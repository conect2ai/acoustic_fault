/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.42669594e-01f, -1.27502412e-01f, -1.39995903e-01f, 2.90699363e-01f, 2.89086342e-01f, 7.33040646e-02f, -5.43558747e-02f, 4.76272823e-03f, 1.14331514e-01f, 1.51579574e-01f,
  2.18962640e-01f, 3.69182914e-01f, 1.31365597e-01f, 1.56938672e-01f, 3.76499305e-03f, -1.20423749e-01f, -1.92198068e-01f, 7.78859630e-02f, 2.54304469e-01f, 3.15278649e-01f,
  1.87778503e-01f, 2.11746544e-01f, 2.65138030e-01f, 2.05030560e-01f, 1.60902381e-01f, 2.00051159e-01f, -7.36593753e-02f, 7.65905902e-02f, 4.26702164e-02f, -2.32589841e-02f,
  1.95427403e-01f, -2.41230265e-03f, 1.72292858e-01f, 2.03095168e-01f, 1.30097777e-01f, 1.41098216e-01f, 1.88795269e-01f, 4.66510095e-02f, 1.01577260e-01f, 8.93413424e-02f,
  1.95586920e-01f, 1.76046327e-01f, 1.65114343e-01f, 1.60636589e-01f, 1.51839390e-01f, 1.04177356e-01f, -3.68876047e-02f, -6.88338326e-03f, 2.47160923e-02f, 7.67793357e-02f,
  1.51475608e-01f, 2.13260040e-01f, 1.13560989e-01f, 1.79918129e-02f, 9.18271765e-02f, 2.42689580e-01f, 1.51588693e-01f, 5.53347319e-02f, 7.01182112e-02f, 2.16478333e-01f,
  -2.61736251e-02f, -1.38113126e-01f, -6.54560253e-02f, -1.36277780e-01f, -8.49092007e-02f, -1.42228544e-01f, -1.58687428e-01f, -8.54524896e-02f, -9.99859720e-02f, -4.74731810e-02f,
  -1.80128545e-01f, -5.90966903e-02f, -1.66438177e-01f, -5.26105091e-02f, -5.41987121e-02f, -1.07988685e-01f, -5.98368533e-02f, -1.35379553e-01f, -1.54025748e-01f, -1.65060967e-01f,
  -9.85529646e-02f, -1.55598804e-01f, -7.87972361e-02f, -1.06025279e-01f, -1.55325696e-01f, -1.68034583e-01f, -6.91641122e-02f, -1.07959077e-01f, -1.03356004e-01f, -1.36604607e-01f,
  2.76553392e-01f, 5.32026999e-02f, 1.59863785e-01f, 1.19491436e-01f, 1.02160133e-01f, 8.77350867e-02f, 1.49455309e-01f, 8.53815228e-02f, 1.13403179e-01f, 1.42136350e-01f,
  1.60327375e-01f, 9.23615098e-02f, 1.44716486e-01f, 5.57026565e-02f, 1.92557052e-01f, 1.81269124e-01f, 9.09057036e-02f, 1.31873786e-01f, 9.20951441e-02f, 1.44629210e-01f,
  6.61402047e-02f, 1.68510318e-01f, 1.97708890e-01f, 1.47102639e-01f, 1.63377091e-01f, 1.69660687e-01f, 1.77452743e-01f, 1.23156704e-01f, 2.06337661e-01f, 1.06753357e-01f,
  6.08826518e-01f, -1.14369579e-01f, 9.87066403e-02f, 1.47339493e-01f, -1.82864055e-01f, -9.12713334e-02f, -1.38691319e-02f, -2.76976302e-02f, -6.20104298e-02f, 1.14578707e-02f,
  -1.56271681e-01f, -1.34717122e-01f, -7.56835788e-02f, -2.14040071e-01f, -4.59599793e-02f, -1.10688165e-01f, -6.68567643e-02f, 7.67677054e-02f, 1.25081509e-01f, -1.61105424e-01f,
  -2.98885912e-01f, 4.52743983e-03f, 1.84461296e-01f, 8.47776420e-03f, -1.27220720e-01f, -1.48998290e-01f, -1.78592920e-01f, -2.08472580e-01f, -2.30236858e-01f, -3.28280151e-01f,
  1.59963733e-03f, 1.87566966e-01f, -7.28320004e-03f, -4.67073470e-02f, -1.15369305e-01f, 1.00588642e-01f, -1.23910615e-02f, 7.48045594e-02f, 1.22139556e-02f, 1.60129776e-03f,
  -1.40863746e-01f, 6.73580468e-02f, -4.88352887e-02f, -5.43125197e-02f, -3.27708758e-02f, 3.22344825e-02f, 4.29193815e-03f, 6.22754097e-02f, 3.48332152e-02f, -1.22889958e-01f,
  -2.33529016e-01f, -1.29785269e-01f, -5.10485331e-03f, -6.46597669e-02f, -6.61867112e-02f, -1.01640135e-01f, -1.99851245e-02f, -2.11825725e-02f, 5.14143892e-02f, 5.70993163e-02f,
  -3.50547768e-02f, -6.95662946e-02f, -6.86040744e-02f, -1.48318391e-02f, -9.63240638e-02f, -2.45865956e-02f, -8.76555741e-02f, -9.84873846e-02f, -5.08951992e-02f, -4.33948599e-02f,
  -6.89185550e-03f, -2.51319557e-02f, -3.57973687e-02f, 7.22078755e-02f, -3.10227349e-02f, -2.55333558e-02f, -7.03144148e-02f, -5.33201126e-03f, -1.21054806e-01f, -1.56178614e-02f,
  2.14141179e-02f, -6.73775971e-02f, 3.94866951e-02f, -6.56108558e-03f, -4.59820358e-03f, 2.73837876e-02f, -4.98909727e-02f, -1.21715859e-01f, -6.17933646e-02f, -7.22002909e-02f,
  2.04782858e-01f, 7.05398545e-02f, 1.02853075e-01f, 8.49376724e-04f, 2.78044418e-02f, -3.05723343e-02f, 5.10220462e-03f, 3.92129533e-02f, -4.74302992e-02f, 1.06591266e-02f,
  -7.25989928e-03f, -3.90218869e-02f, -1.36632938e-02f, 7.38572283e-03f, 3.07388995e-02f, 1.06087634e-02f, -5.90047874e-02f, 5.18786907e-02f, 3.79463658e-02f, 6.91486821e-02f,
  -1.49921402e-02f, 4.61229160e-02f, 6.63364753e-02f, 2.22243797e-02f, -7.19838589e-02f, 7.81187043e-02f, -2.17440650e-02f, 2.31398270e-03f, 5.11224978e-02f, 7.80303404e-02f,
  -1.81474671e-01f, 4.25909795e-02f, -2.12619230e-02f, -1.53593183e-01f, 1.44927189e-01f, 2.61884004e-01f, 2.68827021e-01f, 5.16144820e-02f, -6.46800920e-02f, -5.57027869e-02f,
  1.77744463e-01f, 8.38092789e-02f, -2.34399457e-02f, -6.64753616e-02f, -1.15381181e-01f, -1.37224540e-01f, -2.19704673e-01f, -1.54577330e-01f, -1.06078219e-02f, 2.73247838e-01f,
  7.36998841e-02f, 1.07661359e-01f, -3.27032246e-02f, 6.11732490e-02f, -1.02727652e-01f, 2.68319473e-02f, -1.07223280e-02f, 3.60756293e-02f, 9.12390947e-02f, -1.06662616e-01f,
  -2.49453083e-01f, 1.18347526e-01f, 3.45073380e-02f, 2.81158127e-02f, 9.24455076e-02f, -7.93067645e-03f, -2.71875151e-02f, 2.74669472e-02f, 1.21120960e-01f, -5.46127222e-02f,
  8.59600231e-02f, 6.09156974e-02f, 8.59745070e-02f, 3.59795168e-02f, 2.99739279e-02f, -9.37556755e-03f, 5.55809326e-02f, -4.13856804e-02f, 1.05029650e-01f, 1.44004896e-01f,
  5.93577921e-02f, 1.25002384e-01f, 9.88236368e-02f, -1.38087440e-02f, -1.06740408e-02f, 9.24883559e-02f, 8.50016624e-02f, 9.94149372e-02f, 4.78257164e-02f, -4.43219505e-02f,
  -4.30595726e-02f, -3.63671966e-02f, 3.14479694e-02f, -3.63913849e-02f, 6.07576743e-02f, 1.88372731e-02f, 7.91959465e-03f, -1.98402349e-02f, 2.16580294e-02f, 2.11562682e-03f,
  5.65353930e-02f, -2.06225701e-02f, 6.84791356e-02f, -9.04494375e-02f, 1.38599314e-02f, 3.03343241e-03f, 7.10033327e-02f, -3.33032236e-02f, -4.52864505e-02f, 7.28034526e-02f,
  -9.39604342e-02f, 5.46924677e-03f, -6.40042871e-02f, 1.51937529e-02f, -8.64492282e-02f, -2.16812454e-02f, -1.04747713e-01f, -3.30590345e-02f, -9.69475955e-02f, -2.92991549e-02f,
  -1.59021184e-01f, 1.80697575e-01f, -6.27938062e-02f, 8.22268054e-02f, -1.51989488e-02f, 2.22107153e-02f, -1.84633359e-02f, 5.77799566e-02f, 4.77404892e-02f, 3.76756373e-03f,
  4.44970885e-03f, 2.76186317e-02f, 1.05133884e-01f, 1.33053124e-01f, 6.63274303e-02f, 1.07548432e-02f, 2.81110927e-02f, 7.31068850e-02f, 3.23106535e-02f, 3.84863764e-02f,
  4.05947603e-02f, -4.56520170e-02f, -7.96580762e-02f, 5.57446927e-02f, 9.05537456e-02f, -4.41042706e-02f, -4.97065159e-03f, -4.60548252e-02f, -1.17157735e-01f, -1.14698634e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.97970009e-01f, 4.44433019e-02f, -2.98332721e-02f, -2.00897291e-01f, 1.81043670e-01f, -1.29750013e-01f, -3.65818173e-01f, -2.27764308e-01f, 2.91852113e-02f, 8.35689083e-02f,
  1.95988640e-01f, -7.58522749e-02f, -9.61138681e-02f, -1.41009137e-01f, -7.86896467e-01f, -3.57814461e-01f, -3.53361428e-01f, -6.44370258e-01f, -7.10300922e-01f, -3.74789774e-01f,
  -1.91117495e-01f, -2.93181151e-01f, -3.29929382e-01f, -1.23169899e-01f, 2.76630074e-01f, 2.31478125e-01f, 4.30853516e-01f, -4.25181538e-03f, 1.36254683e-01f, 2.68178284e-01f,
  -7.03382958e-03f, 1.99730441e-01f, 6.94798157e-02f, -1.69791177e-01f, 1.78554803e-01f, 4.84711927e-04f, -2.97677100e-01f, 2.97637638e-02f, 1.68499842e-01f, 6.38123006e-02f,
  -2.45548308e-01f, 2.01739781e-02f, -9.77977365e-02f, -1.79960560e-02f, -2.74185598e-01f, -2.22792968e-01f, -9.87514928e-02f, -2.32544750e-01f, -3.77892017e-01f, -8.02432373e-02f,
  -2.25956306e-01f, -1.22299135e-01f, -7.24523328e-03f, 1.23333089e-01f, -1.96805701e-01f, -2.20592603e-01f, 1.98900789e-01f, 1.82313174e-01f, 2.10414127e-01f, 8.88595134e-02f,
  7.48341903e-02f, -1.58561632e-01f, 1.17182225e-01f, -1.02233030e-01f, -1.18603177e-01f, 1.41963094e-01f, -4.01741937e-02f, -9.91424844e-02f, 1.08758099e-02f, -7.42660537e-02f,
  -3.12185697e-02f, -3.13007012e-02f, 1.23735152e-01f, 1.58187235e-03f, 1.32042065e-01f, -1.04321539e-01f, -8.92208964e-02f, -4.96431142e-02f, 9.04128104e-02f, 5.42475805e-02f,
  -1.59578741e-01f, 7.20908344e-02f, 8.95971432e-03f, -3.46591063e-02f, 2.14101486e-02f, -8.71882886e-02f, -9.65601727e-02f, -2.29853410e-02f, -1.15066133e-01f, -1.78282514e-01f,
  -4.36237734e-03f, 1.29709750e-01f, 8.64306241e-02f, -1.69406131e-01f, -3.45847383e-02f, 1.89990416e-01f, -4.35656048e-02f, -3.65034901e-02f, 5.54786697e-02f, -1.71978533e-01f,
  -2.64695048e-01f, -1.77017123e-01f, -4.99863513e-02f, 1.23500116e-02f, -2.13372618e-01f, -5.35755530e-02f, -1.19201310e-01f, 1.18667148e-01f, -2.01102361e-01f, -6.50850385e-02f,
  -2.93147922e-01f, -4.63014573e-01f, -4.30609673e-01f, -2.59780753e-02f, -1.41265586e-01f, -1.41843349e-01f, -1.41295120e-01f, 7.25756958e-02f, -1.36155054e-01f, -1.35798469e-01f,
  -9.59462225e-01f, -1.47044495e-01f, 6.16184697e-02f, -3.25231910e-01f, -2.98620343e-01f, -2.87434697e-01f, -1.61517784e-01f, -1.65040210e-01f, -2.71518707e-01f, -9.74992663e-02f,
  8.65349844e-02f, 2.25569084e-01f, 2.47396544e-01f, 2.72189707e-01f, 2.22744018e-01f, 9.75666493e-02f, -1.12061435e-02f, 9.50313697e-04f, 5.46171097e-03f, -9.03105363e-03f,
  5.17184697e-02f, 2.16121078e-02f, -1.05823368e-01f, 6.77896738e-02f, 1.43393399e-02f, 1.87914327e-01f, 2.05893949e-01f, -6.00168062e-03f, 1.32964402e-01f, 1.69063643e-01f,
  6.15635574e-01f, -5.74697495e-01f, -5.35261966e-02f, -2.19825581e-01f, -6.32288456e-02f, -2.10570812e-01f, -1.25688436e-02f, -1.38312476e-02f, -1.16336629e-01f, 1.61467642e-02f,
  4.70576957e-02f, 8.06917960e-04f, 8.55871662e-03f, 3.46620865e-02f, -3.33349057e-03f, -8.51395577e-02f, -4.17596176e-02f, -4.01788689e-02f, 9.59165487e-03f, 1.34471416e-01f,
  3.35244052e-02f, -8.99765790e-02f, 1.78461745e-01f, 1.04811154e-01f, -4.88158017e-02f, -8.44463110e-02f, 5.20029403e-02f, 3.86801399e-02f, 2.82637328e-02f, 6.94345534e-02f,
  2.13261947e-01f, 3.03963184e-01f, -1.02265649e-01f, 7.27486536e-02f, 9.17069837e-02f, 1.02615975e-01f, -1.18079288e-02f, 3.06247640e-02f, 4.03003134e-02f, 6.51100948e-02f,
  6.33343235e-02f, 8.72325674e-02f, 8.50421339e-02f, -1.24409623e-01f, -4.30716053e-02f, 4.92653511e-02f, -1.22564018e-01f, 4.86878417e-02f, 2.17440929e-02f, -3.61828879e-02f,
  -1.59506798e-01f, -1.42055992e-02f, -1.31132498e-01f, 4.35914882e-02f, -7.35624954e-02f, -6.80822730e-02f, -3.46664302e-02f, 4.72287880e-03f, -1.09580912e-01f, -3.61968055e-02f,
  6.15517795e-01f, -2.80158967e-01f, -1.44119337e-02f, 3.44533883e-02f, -1.50325149e-01f, -1.19329900e-01f, -8.50062370e-02f, -1.24525711e-01f, -5.04627638e-02f, 1.84643771e-02f,
  -5.37726767e-02f, -7.52235344e-03f, -1.48469908e-02f, 9.21210572e-02f, -6.08942881e-02f, -7.79870227e-02f, -8.34608823e-02f, 1.35208517e-01f, -4.06089006e-03f, 8.06021467e-02f,
  -7.35047907e-02f, 1.04039147e-01f, 1.18665792e-01f, 1.60400823e-01f, 3.32019143e-02f, 3.13771665e-02f, 2.08817512e-01f, 4.11379971e-02f, 9.15054530e-02f, 1.28720492e-01f,
  5.03874272e-02f, -6.37817085e-01f, -3.67654450e-02f, 1.85373381e-01f, -1.25245541e-01f, -4.97527510e-01f, -8.47009718e-01f, -4.15164649e-01f, 3.14821973e-02f, -1.81374162e-01f,
  -7.09072798e-02f, 2.05400527e-01f, 1.80711746e-01f, 1.39420554e-01f, -4.20191251e-02f, -2.67846048e-01f, 8.14080015e-02f, 3.90737921e-01f, 2.69097120e-01f, 1.61547258e-01f,
  3.09126407e-01f, 5.29114485e-01f, 5.05646408e-01f, 3.50622296e-01f, -1.95219293e-02f, 8.13336149e-02f, 9.14130285e-02f, 3.11688572e-01f, 4.31358330e-02f, 2.00577423e-01f,
  1.36648491e-01f, -1.73370913e-01f, 4.99531180e-02f, 2.01151103e-01f, 1.32129535e-01f, 2.10891321e-01f, 9.95992124e-03f, 3.73152703e-01f, 4.54916358e-02f, 9.70246270e-02f,
  1.15991786e-01f, 5.30362539e-02f, 1.47503927e-01f, 2.03812674e-01f, 1.08879663e-01f, -1.09861188e-01f, 2.16155142e-01f, 6.33111373e-02f, -1.18979700e-01f, -4.33710180e-02f,
  -9.27176606e-03f, 3.77843110e-03f, -3.73072386e-01f, -3.71403605e-01f, -2.90072620e-01f, 8.57951790e-02f, -2.14052230e-01f, -1.06715888e-01f, -6.98773339e-02f, -1.24017559e-01f,
  1.66967198e-01f, 2.52215415e-02f, 1.40633713e-03f, -1.97302639e-01f, -1.02993488e-01f, -9.27311182e-02f, -7.99615309e-02f, -1.77927241e-01f, -3.74217331e-03f, -8.79736543e-02f,
  -1.13059327e-01f, -7.03658462e-02f, -1.27737969e-01f, 8.01909715e-03f, 1.17630079e-01f, 6.64182678e-02f, -1.69467464e-01f, -5.92961721e-03f, 6.77247122e-02f, 7.80492350e-02f,
  -3.77282165e-02f, -8.16148072e-02f, 9.70973000e-02f, -5.64713441e-02f, -1.37735242e-02f, -8.35652370e-03f, -4.28659900e-04f, 1.14226043e-01f, 4.77952845e-02f, 6.90439343e-02f,
  1.52353704e-01f, 3.21547568e-01f, -1.80456609e-01f, -3.69945392e-02f, -2.06703931e-01f, -4.68365708e-03f, -1.70712426e-01f, -1.63268134e-01f, -1.65447727e-01f, -6.20749146e-02f,
  -2.04481587e-01f, -2.61216164e-01f, 1.81912884e-01f, 1.99813675e-02f, 1.25499502e-01f, -3.94033305e-02f, -1.66520357e-01f, -4.07564491e-01f, -1.77088171e-01f, -1.36920094e-01f,
  -1.80274934e-01f, -4.63476360e-01f, -5.30912578e-01f, -5.20918727e-01f, -1.71049803e-01f, -2.11480603e-01f, -9.40324366e-02f, -2.76861161e-01f, -4.64354098e-01f, -6.56044722e-01f,
  -2.90820390e-01f, 3.69184136e-01f, 4.26507831e-01f, -3.96089584e-01f, 1.42638281e-01f, 3.14642787e-01f, 7.22490668e-01f, 1.61984846e-01f, -3.77528816e-01f, 1.66745663e-01f,
  1.86952099e-01f, -4.94872361e-01f, -3.83593380e-01f, -1.29213095e-01f, 8.09942409e-02f, 3.19761395e-01f, 9.37774405e-02f, -1.24149844e-01f, -2.09004492e-01f, -7.27667585e-02f,
  -7.07598478e-02f, -2.51210153e-01f, -1.94124758e-01f, -2.63380110e-01f, -2.81423241e-01f, -4.94569600e-01f, 1.73794255e-01f, 6.93271831e-02f, 2.87507981e-01f, -3.05540413e-01f,
  1.65375650e-01f, 2.46379986e-01f, -2.82945126e-01f, -1.74172580e-01f, 8.64995085e-03f, -1.02842130e-01f, -4.70792614e-02f, -6.78200200e-02f, 3.95038314e-02f, 7.40688518e-02f,
  -3.75656262e-02f, 6.55253083e-02f, -3.31928097e-02f, 5.38123585e-03f, -8.52039009e-02f, 5.44311330e-02f, 1.09985583e-01f, 4.85301912e-02f, -2.80848090e-02f, 1.81347623e-01f,
  4.96170036e-02f, 1.73071682e-01f, 2.91987240e-01f, 1.96916580e-01f, 1.89761534e-01f, -1.64513022e-01f, 1.81317180e-01f, -5.73740192e-02f, 5.52284122e-02f, -1.56137839e-01f,
  5.72194904e-02f, -3.69990394e-02f, -9.68470648e-02f, -8.62484798e-02f, -1.28207095e-02f, 4.67613004e-02f, 6.79551288e-02f, 5.95545210e-02f, -5.44384755e-02f, -4.56551723e-02f,
  4.59288098e-02f, -2.66846153e-03f, 4.43232432e-02f, 1.31742060e-01f, -1.51530623e-01f, 4.03605355e-03f, 5.09233810e-02f, 7.49347135e-02f, 1.43884897e-01f, 8.56971890e-02f,
  7.86291584e-02f, 1.37933299e-01f, 6.37124628e-02f, 5.20495139e-02f, 1.42180488e-01f, 9.64941457e-02f, -6.60486147e-02f, -5.42941131e-02f, 8.56544524e-02f, 2.18338981e-01f,
  -3.18522543e-01f, 5.14799178e-01f, -2.71420002e-01f, -1.59480557e-01f, 3.14465836e-02f, 5.92703372e-02f, -2.36980081e-01f, -3.01847439e-02f, 3.13964160e-03f, 3.55569646e-02f,
  1.00313455e-01f, -6.07933179e-02f, 1.31798044e-01f, -1.99930742e-02f, -6.74261972e-02f, -4.84610945e-02f, 4.22282554e-02f, -1.13246135e-01f, 4.85655069e-02f, -1.06195337e-03f,
  3.25722881e-02f, 6.08237311e-02f, -4.43722978e-02f, -1.04570188e-01f, -8.02601874e-03f, -2.85164773e-01f, -4.42780703e-02f, -2.58420799e-02f, 5.88716529e-02f, -1.31477833e-01f,
  3.12698245e-01f, 1.50053035e-02f, 2.18225926e-01f, 3.09829503e-01f, 8.54621828e-02f, -5.71475804e-01f, -7.51427352e-01f, -4.42141950e-01f, 1.32084772e-01f, 1.96016580e-01f,
  1.66824073e-01f, 6.42312765e-02f, 1.04505308e-01f, -2.03168675e-01f, -6.16446376e-01f, -2.42587477e-01f, -1.26712114e-01f, -2.83808887e-01f, -5.86828172e-01f, -4.74741638e-01f,
  -1.17569998e-01f, 5.78868128e-02f, 3.12785283e-02f, -1.22179724e-01f, 5.19640207e-01f, 2.39588693e-01f, 2.90344477e-01f, 2.21216038e-01f, 5.37841991e-02f, 5.85090756e-01f,
  4.92112249e-01f, 3.88781875e-01f, -2.46340036e-01f, 2.25471780e-02f, 1.95344716e-01f, 5.75287119e-02f, -1.28994808e-01f, 8.72483104e-02f, 5.67023419e-02f, 2.03278009e-02f,
  8.25805143e-02f, 4.41642627e-02f, -7.36536086e-02f, -5.22351004e-02f, -5.96549511e-02f, -1.65817782e-01f, -1.11243658e-01f, -2.11600557e-01f, -2.21737370e-01f, 4.21999581e-02f,
  -8.02242011e-02f, 6.16746582e-02f, 4.67789136e-02f, -1.93439052e-01f, -8.45451429e-02f, 3.49119864e-02f, 5.80049418e-02f, 4.30028997e-02f, -1.24766633e-01f, 1.87344566e-01f,
  -6.23405818e-03f, 1.60296671e-02f, 4.06612903e-02f, 6.42739162e-02f, 4.63765785e-02f, -1.37142104e-03f, 1.65530533e-01f, 3.66777554e-02f, -7.78891891e-02f, -2.42480393e-02f,
  -8.26545954e-02f, 4.33620512e-02f, 5.70214950e-02f, -1.24259656e-02f, 1.00006670e-01f, 4.93194498e-02f, 8.20078850e-02f, -5.46494648e-02f, 5.02736159e-02f, 3.06192730e-02f,
  4.06219438e-02f, 1.17433250e-01f, 1.64964944e-01f, -6.61670789e-02f, 9.26112756e-02f, 5.15438691e-02f, 5.51270433e-02f, -2.07243674e-02f, 1.28029838e-01f, 2.14548558e-01f,
  1.73314154e-01f, -4.86606926e-01f, 2.63167053e-01f, -1.62360489e-01f, -1.69907860e-03f, 9.53600034e-02f, 2.79164582e-01f, -5.96904829e-02f, 2.17899606e-01f, -2.96135768e-02f,
  -1.73308447e-01f, -1.07135614e-02f, 9.97151434e-03f, -1.53333485e-01f, -2.40301535e-01f, 1.33849951e-02f, -1.02902837e-01f, -8.32958668e-02f, -3.48231673e-01f, 5.70309721e-02f,
  -9.50874090e-02f, -4.60842013e-01f, -3.13973337e-01f, -1.45766541e-01f, -2.93110311e-02f, -1.68805957e-01f, -7.60447010e-02f, -1.48300022e-01f, -3.15169096e-01f, -2.66414762e-01f,
  -4.24827784e-01f, 3.48760247e-01f, 9.33711901e-02f, -1.76481027e-02f, 4.37613130e-01f, 2.68574897e-02f, -4.13056649e-02f, -3.38256299e-01f, 8.21685046e-02f, 2.77914882e-01f,
  5.78737020e-01f, 2.21764565e-01f, -8.83830264e-02f, -2.58807242e-01f, -7.21880913e-01f, -3.26217502e-01f, -2.21807972e-01f, -7.25016713e-01f, -6.99128926e-01f, -2.39443392e-01f,
  9.02054384e-02f, -1.76903054e-01f, -4.11414802e-01f, -3.30107957e-01f, 8.61041471e-02f, -1.80756882e-01f, 1.56482399e-01f, -3.58060263e-02f, 1.82561427e-01f, 7.25511415e-03f,
  -1.33536756e-01f, -1.96707204e-01f, -6.96214512e-02f, 9.07389298e-02f, 3.83216934e-03f, -1.93327561e-01f, -1.63315050e-02f, -8.80285129e-02f, 4.73881997e-02f, -5.20396158e-02f,
  1.14456750e-01f, 4.93254811e-02f, 1.09215733e-02f, -8.37572664e-02f, -2.62186706e-01f, -2.53206819e-01f, -1.60543188e-01f, -3.86996120e-01f, -3.61312628e-01f, -2.21664414e-01f,
  3.47028166e-01f, 1.37487218e-01f, -3.19314450e-01f, -1.65248320e-01f, -4.95424926e-01f, -2.83238351e-01f, -1.97953090e-01f, -3.49872559e-01f, -4.07571077e-01f, -6.27524614e-01f,
  8.73809028e-03f, 6.76092729e-02f, 1.71525285e-01f, 3.63072269e-02f, -1.10232152e-01f, 1.86896458e-01f, -3.29302400e-02f, 9.68954787e-02f, -6.05811290e-02f, -1.16595916e-01f,
  8.93331096e-02f, 1.55287445e-01f, -5.45528568e-02f, -3.17941383e-02f, -3.13581347e-01f, 8.69079605e-02f, -5.79619361e-03f, -1.33285135e-01f, -2.36500680e-01f, -1.09661341e-01f,
  -1.45343274e-01f, 8.60077292e-02f, 4.36327271e-02f, -7.90396407e-02f, 9.37253162e-02f, 4.57162000e-02f, -1.14141576e-01f, -9.16814152e-03f, -7.44573623e-02f, 1.37547225e-01f,
  -3.44325095e-01f, -7.08991215e-02f, -1.32639438e-01f, 5.55131882e-02f, 1.10354818e-01f, -8.59883577e-02f, 2.57908940e-01f, -1.42544238e-02f, 5.65425083e-02f, -1.49618506e-01f,
  2.37081219e-02f, -1.10479131e-01f, 3.41977775e-02f, -1.30048886e-01f, 2.95823347e-03f, 4.97188233e-02f, -4.89034094e-02f, 1.00940503e-01f, -5.64702321e-03f, 1.01468176e-01f,
  -1.34577855e-01f, -3.17150295e-01f, -2.84339249e-01f, -1.40707875e-02f, -3.87879968e-01f, -3.07882011e-01f, -2.94685811e-01f, -2.92385608e-01f, -3.22757781e-01f, -6.10534072e-01f,
  5.13792276e-01f, -4.38827187e-01f, -4.91293162e-01f, -4.33424972e-02f, -3.60090971e-01f, -4.20472115e-01f, -3.55291545e-01f, -8.06616843e-02f, -1.45920739e-01f, -2.44659528e-01f,
  2.34850459e-02f, 5.41392922e-01f, 3.99341106e-01f, 3.45119148e-01f, 5.58674455e-01f, -3.27030152e-01f, -3.76180202e-01f, 2.04006150e-01f, 4.61135000e-01f, 6.25951588e-02f,
  -9.80799273e-02f, -5.15258051e-02f, 2.38953337e-01f, 3.89822461e-02f, -5.54208279e-01f, -8.30303580e-02f, -5.63960969e-01f, -3.58453214e-01f, -3.77086580e-01f, -5.96518874e-01f,
  2.72987813e-01f, -3.48555505e-01f, -7.00548291e-02f, -5.67708686e-02f, -1.04007944e-02f, 1.65492207e-01f, 9.04394127e-03f, -1.84606478e-01f, -1.22111365e-01f, -1.93718970e-01f,
  -1.78853929e-01f, -6.83884621e-02f, 1.41220642e-02f, -6.94045722e-02f, -6.71348646e-02f, 1.15987279e-01f, -5.80824949e-02f, -2.47654151e-02f, -1.16636306e-01f, 3.55993509e-02f,
  -9.47655961e-02f, -3.18107903e-01f, -8.20661709e-02f, -1.14099398e-01f, -1.71326786e-01f, -9.72552896e-02f, -2.43097857e-01f, -2.92687386e-01f, -1.48081645e-01f, -3.25502336e-01f,
  1.85325835e-02f, -1.24956228e-01f, -5.01030274e-02f, -1.12140447e-01f, 2.67690513e-02f, -7.62645453e-02f, 3.78035270e-02f, 3.42775732e-02f, -8.36538225e-02f, 7.16405660e-02f,
  2.83439793e-02f, -2.20156480e-02f, 2.92093828e-02f, -1.24275852e-02f, -9.72711816e-02f, -1.21185265e-01f, 3.07400748e-02f, 4.21688855e-02f, -2.53026858e-02f, 3.48061211e-02f,
  1.22238491e-02f, 2.12641675e-02f, -6.78499267e-02f, 1.01546735e-01f, -3.90354544e-02f, 9.15099159e-02f, -1.02881536e-01f, 6.73365071e-02f, 8.21410567e-02f, -6.63122013e-02f,
  6.58749938e-01f, 2.54276186e-01f, 1.76853567e-01f, -1.86379720e-02f, -1.86059490e-01f, -1.19805485e-01f, 1.28219360e-02f, -2.98344400e-02f, -1.20256618e-01f, 8.73811468e-02f,
  -1.56877544e-02f, 1.49779275e-01f, 3.35935093e-02f, -8.43082517e-02f, -5.25278710e-02f, -4.42408137e-02f, 2.83913240e-02f, 1.12393096e-01f, -9.71037373e-02f, 6.27046600e-02f,
  -3.06848157e-02f, 1.16718896e-02f, 3.43429476e-01f, 3.72945033e-02f, -1.35481507e-01f, 2.24160179e-01f, 1.12748057e-01f, -3.09112221e-02f, 2.17153072e-01f, 1.10460818e-01f,
  -7.66849637e-01f, -4.64495152e-01f, 3.32961023e-01f, -2.76235133e-01f, 1.72538310e-01f, 4.63668227e-01f, 5.14980495e-01f, 1.12744674e-01f, -2.77895201e-02f, 7.13341087e-02f,
  -2.36493662e-01f, -1.54104084e-01f, -1.20128982e-01f, -4.70621549e-02f, 2.94476431e-02f, 4.16155756e-01f, 4.02770311e-01f, 2.20718216e-02f, 1.25230566e-01f, 6.16539679e-02f,
  -5.66064678e-02f, -2.43976295e-01f, -4.54888612e-01f, -2.33967513e-01f, -2.17930600e-01f, -2.82530803e-02f, -5.22293756e-03f, -1.96345508e-01f, -1.10632531e-01f, -4.65765297e-02f,
  3.10146153e-01f, -4.90126550e-01f, 1.77703589e-01f, -2.17949018e-01f, -1.64726540e-01f, -9.21494141e-02f, -3.89932841e-02f, -1.80679798e-01f, -1.72682762e-01f, -4.14357968e-02f,
  -1.81430429e-01f, -2.04212502e-01f, -1.77241787e-01f, -5.86393289e-02f, -9.89858136e-02f, -5.34897670e-02f, -1.19395122e-01f, -2.05769703e-01f, -1.49232402e-01f, -1.60846233e-01f,
  -5.98711222e-02f, -8.34975690e-02f, -8.63298029e-03f, -2.16952395e-02f, -1.17849261e-01f, -3.39652672e-02f, -1.33723915e-01f, -1.57576263e-01f, -2.10020602e-01f, -1.76865026e-01f,
  3.43028754e-02f, 7.32213184e-02f, 4.12221923e-02f, -1.04836030e-02f, -4.00242815e-03f, 8.00014958e-02f, 1.21398553e-01f, 1.89654045e-02f, 9.33684185e-02f, 2.85469536e-02f,
  -3.66579443e-02f, -1.03047444e-02f, 8.95770043e-02f, -8.73160884e-02f, -7.81202223e-03f, 6.36113063e-02f, 1.43037751e-01f, -2.85098869e-02f, -5.22751845e-02f, 3.29472162e-02f,
  -1.53401624e-02f, 5.04026935e-02f, -3.34676504e-02f, 6.47644922e-02f, -1.86639745e-02f, -4.31957431e-02f, 5.80177680e-02f, 4.72139977e-02f, -4.84372005e-02f, 9.89001989e-02f,
  7.01787993e-02f, -4.43555117e-02f, 1.58589303e-01f, -1.35726929e-01f, -1.75071880e-02f, -1.85485736e-01f, -5.40726222e-02f, -8.59028399e-02f, -1.15655556e-01f, -5.36854267e-02f,
  -4.00316156e-02f, -3.10756490e-02f, -5.31705283e-02f, 1.09720737e-01f, 1.44089803e-01f, -2.18646768e-02f, -4.07867394e-02f, -2.88859624e-02f, -9.80387405e-02f, -3.78802307e-02f,
  -8.17937125e-03f, 7.17085674e-02f, 2.40241289e-01f, 1.66721001e-01f, 6.57930225e-02f, 2.24973395e-01f, 1.79836810e-01f, 1.95331454e-01f, 1.45372584e-01f, 3.08506966e-01f,
  -6.85935244e-02f, -3.03972691e-01f, 3.47767994e-02f, 2.84081697e-01f, 3.72433245e-01f, 2.61811256e-01f, 2.34577477e-01f, 2.05562741e-01f, 2.65686899e-01f, 2.56916046e-01f,
  1.90507323e-01f, 2.56398082e-01f, 2.93443769e-01f, 2.42518127e-01f, 1.02225728e-01f, 1.94648013e-01f, 1.74000114e-01f, 1.01042986e-01f, 9.91369933e-02f, 2.73789495e-01f,
  3.34904462e-01f, 1.35185927e-01f, -1.28425404e-01f, 6.56380132e-02f, 1.68358743e-01f, 1.61710531e-01f, 2.11753592e-01f, 3.49933505e-02f, 1.38036475e-01f, 1.76816061e-01f,
  1.12004049e-01f, -8.86540338e-02f, 1.38451859e-01f, -5.37222400e-02f, -1.05476998e-01f, -1.30563512e-01f, -6.00436814e-02f, -1.75375506e-01f, -1.29192486e-01f, -6.08349638e-03f,
  -1.85221359e-01f, -3.58915217e-02f, -1.06723197e-01f, -1.62186086e-01f, -6.23631179e-02f, -4.83399667e-02f, -8.41049403e-02f, -1.53317293e-02f, 1.01413786e-01f, 5.85316457e-02f,
  6.04763813e-02f, 8.58251154e-02f, 5.88112138e-02f, 4.39313017e-02f, 1.51616380e-01f, 8.67448151e-02f, 2.87257601e-02f, -9.29337516e-02f, 1.27611160e-01f, 2.50571948e-02f,
  2.85015225e-01f, 1.75312862e-01f, 2.12362245e-01f, 6.27075508e-02f, 5.29950373e-02f, -7.38699734e-02f, -7.00895935e-02f, 4.14276868e-02f, 1.24228388e-01f, -4.76249773e-03f,
  -3.82012757e-03f, 2.13912219e-01f, 7.82122910e-02f, 3.16747427e-02f, 1.55805722e-01f, 3.84387635e-02f, -1.66525424e-01f, 4.84047420e-02f, 8.60925880e-04f, -1.95583664e-02f,
  1.11117311e-01f, 6.23542257e-02f, -2.17740700e-01f, -9.98795778e-03f, 3.87005471e-02f, 1.35421589e-01f, 7.31043667e-02f, 8.02773312e-02f, 3.01519744e-02f, -6.74715117e-02f,
  2.99343437e-01f, 2.57471591e-01f, 1.80439904e-01f, -4.73803431e-02f, -2.16739014e-01f, -2.89068043e-01f, -2.66633084e-04f, -1.30042076e-01f, -1.89590558e-01f, -3.29175852e-02f,
  -4.94438410e-02f, -2.39485398e-01f, -2.09846720e-01f, -9.76914540e-02f, -3.79512496e-02f, -6.87183440e-02f, -9.37878340e-02f, -3.94827127e-03f, 9.62931737e-02f, -1.31386772e-01f,
  -2.26033274e-02f, 1.61042944e-01f, 9.60242599e-02f, 5.84261231e-02f, 5.16686775e-02f, 1.41876280e-01f, -1.06600203e-01f, -4.59435470e-02f, 5.41262105e-02f, -8.80936831e-02f,
  5.17847538e-01f, 1.47793917e-02f, 6.09921701e-02f, 2.11503640e-01f, -1.77799955e-01f, -1.32035896e-01f, 1.27899602e-01f, 5.94319738e-02f, 1.23995937e-01f, 1.71758160e-02f,
  -2.08100364e-01f, -3.74293059e-01f, -2.67689347e-01f, -3.38535458e-01f, -7.86369294e-02f, 2.47280419e-01f, 1.18315741e-01f, 1.20243073e-01f, -5.43493815e-02f, -1.06278896e-01f,
  -1.89455792e-01f, -7.19408877e-03f, 9.70325395e-02f, -2.78720520e-02f, -8.24429095e-02f, -1.27054781e-01f, 7.17685148e-02f, -1.73947010e-02f, -7.45123550e-02f, -7.87472576e-02f,
  -2.39140734e-01f, -1.80993378e-02f, -2.64569014e-01f, -1.27879128e-01f, -2.24194542e-01f, 1.48080790e-03f, -5.50559815e-03f, 4.59950566e-02f, 1.00709526e-02f, 2.09193528e-01f,
  -9.26164091e-02f, -4.22378778e-02f, 4.87266555e-02f, -8.09682980e-02f, -1.40195610e-02f, 7.74725452e-02f, 1.26045793e-01f, 1.78209305e-01f, -4.10395898e-02f, 3.75927575e-02f,
  -2.47341953e-03f, 5.44239860e-03f, -9.09320731e-03f, 5.43792360e-02f, -1.13652281e-01f, -1.46110266e-01f, -6.95062280e-02f, -1.82314903e-01f, 4.28344831e-02f, 1.78804860e-01f,
  -8.02324042e-02f, 6.09241091e-02f, 1.04875409e-03f, 8.35608225e-03f, 1.44491762e-01f, 1.61525726e-01f, 3.32313627e-01f, 9.47102904e-02f, 1.84660167e-01f, 1.83149830e-01f,
  1.98777691e-01f, 2.18340695e-01f, 2.43285701e-01f, 1.80180714e-01f, 6.81839064e-02f, 7.80051425e-02f, 6.24724589e-02f, 1.95206068e-02f, 7.31850639e-02f, 2.02635035e-01f,
  7.63003603e-02f, 1.16187751e-01f, 1.11489341e-01f, 1.59130454e-01f, 8.85839239e-02f, -1.15153631e-02f, -1.81436990e-04f, 2.89291199e-02f, 1.08450025e-01f, 1.14801824e-01f,
  -2.88459137e-02f, -3.55784774e-01f, -1.50288129e-02f, 7.17282370e-02f, -1.12830698e-02f, -2.59260535e-02f, -6.49183020e-02f, 8.06217417e-02f, -2.63666604e-02f, 1.10255033e-01f,
  1.00072257e-01f, -2.74575688e-03f, 1.11884058e-01f, -6.20934693e-03f, 1.67498007e-01f, 1.19114257e-01f, -3.86455879e-02f, 6.84735104e-02f, -4.72110882e-02f, 3.60016748e-02f,
  1.72400083e-02f, 1.86615691e-01f, 8.49855319e-02f, 1.14672162e-01f, 2.40558246e-03f, 5.08342981e-02f, 4.67969477e-02f, 3.67154144e-02f, -3.79881188e-02f, 2.50613123e-01f,
  4.80157852e-01f, 3.36778581e-01f, -1.20736390e-01f, 1.92769200e-01f, -4.77117121e-01f, -5.83753347e-01f, -3.77636641e-01f, -2.88553648e-02f, 1.18164532e-01f, 5.63875474e-02f,
  -3.22082371e-01f, -3.75934452e-01f, -1.63316876e-01f, -1.54250443e-01f, -7.11937319e-04f, 6.31343499e-02f, 2.13293701e-01f, 4.73835021e-02f, -3.49258602e-01f, -4.35592353e-01f,
  5.51155536e-03f, 5.55775762e-01f, 7.53295600e-01f, 2.84606516e-01f, 3.51824984e-02f, -6.61421120e-02f, 4.40340817e-01f, 1.23674348e-01f, -2.34346852e-01f, -1.86791465e-01f,
  -3.16485375e-01f, 7.82749057e-02f, -4.00057971e-01f, -8.53099674e-02f, -1.69553533e-02f, -3.74037512e-02f, -2.99180359e-01f, -2.91149486e-02f, -2.80153841e-01f, -1.30887315e-01f,
  -5.18004715e-01f, -2.96231478e-01f, -5.77780187e-01f, -2.03508273e-01f, -1.16934441e-01f, -1.54985398e-01f, 3.17827463e-01f, 1.71745747e-01f, 2.31281027e-01f, -3.73485923e-01f,
  -4.80295509e-01f, -4.55663562e-01f, -3.18775624e-01f, -8.43643397e-02f, -3.61646235e-01f, -3.14346641e-01f, -1.04938351e-01f, -2.91884899e-01f, -1.06149375e-01f, 3.03560406e-01f,
  1.30668551e-01f, -1.29426733e-01f, -9.26167369e-02f, 1.84868589e-01f, 3.45793627e-02f, -2.00114191e-01f, -2.22290009e-02f, 1.79976467e-02f, -1.77439958e-01f, -5.35072163e-02f,
  -1.86424956e-01f, 1.15359671e-01f, -5.53484634e-02f, -6.77034631e-03f, -6.63511083e-02f, 1.14296138e-01f, -1.46255806e-01f, 3.73324484e-01f, 4.19937372e-02f, 8.08127299e-02f,
  2.62347981e-02f, -4.46113721e-02f, -5.09901382e-02f, -7.05159083e-02f, 9.76956114e-02f, 3.29198986e-02f, 2.21894290e-02f, 8.82321447e-02f, 7.36727864e-02f, 1.17427222e-01f,
  5.24640799e-01f, 1.90543041e-01f, -2.42634147e-01f, -9.41800252e-02f, -1.00421011e-01f, 3.59679237e-02f, 1.50444612e-01f, 1.33135095e-01f, -4.19057198e-02f, -1.73735544e-01f,
  -3.01730067e-01f, -1.64900079e-01f, 2.51748841e-02f, -1.08619399e-01f, -2.30020598e-01f, 1.14135277e-02f, 2.73058474e-01f, -2.19252765e-01f, -2.43851691e-02f, -1.02184005e-01f,
  2.40034521e-01f, 9.88157392e-02f, -1.70823082e-01f, -4.36303876e-02f, -1.53810129e-01f, -3.00706420e-02f, 5.35040582e-03f, -2.90259898e-01f, -5.93047813e-02f, 5.21367788e-01f,
  -2.08069772e-01f, -5.72466075e-01f, -2.31064618e-01f, -4.20370281e-01f, 4.41273563e-02f, 3.15608941e-02f, -3.28609437e-01f, -1.86857954e-01f, 9.87466425e-04f, -3.23987961e-01f,
  1.06266983e-01f, 5.07811368e-01f, -2.11043637e-02f, 2.63566464e-01f, 1.08714014e-01f, -4.87046957e-01f, -3.40692908e-01f, 2.40995184e-01f, 5.75802803e-01f, 4.53294665e-01f,
  1.70161277e-01f, 9.48593300e-03f, 3.21641952e-01f, 1.16816156e-01f, -4.11885947e-01f, 8.06032941e-02f, -3.59728783e-01f, -9.85003710e-02f, -1.88271821e-01f, -4.24410045e-01f,
  -9.09335241e-02f, -2.64254630e-01f, 2.19661877e-01f, 1.65224642e-01f, -3.07790153e-02f, -1.60509169e-01f, -3.09756756e-01f, 4.67193732e-03f, 1.23331785e-01f, -4.17039134e-02f,
  -1.00363670e-02f, -4.74193022e-02f, -5.38484417e-02f, 1.13882273e-02f, 1.54166907e-01f, 1.11027583e-01f, -1.58929992e-02f, 2.21023224e-02f, -8.34352151e-02f, -7.09853247e-02f,
  -1.14117444e-01f, -4.01750915e-02f, -9.39661041e-02f, -2.24592999e-01f, -2.83296257e-01f, 1.52530625e-01f, -5.13696298e-02f, -1.54710278e-01f, -8.87248442e-02f, -5.56324899e-01f,
  7.23137558e-02f, 5.05037419e-02f, 9.30349231e-02f, -3.37442458e-02f, 1.07681185e-01f, 5.00151291e-02f, -8.97763819e-02f, 1.26462281e-01f, 2.03276545e-01f, -1.22671328e-01f,
  1.72199458e-01f, 2.64402814e-02f, 7.21433982e-02f, -1.80976436e-01f, 6.80360645e-02f, -9.78706479e-02f, -6.95687756e-02f, -6.46832436e-02f, 1.09413952e-01f, 1.58230662e-02f,
  1.83529988e-01f, 7.45867863e-02f, 2.00851951e-02f, 6.50643259e-02f, 7.15935081e-02f, 3.62491906e-02f, -1.32043615e-01f, 1.25816777e-01f, -6.13139421e-02f, -1.10215351e-01f,
  -2.07214624e-01f, 2.97239989e-01f, -1.99076161e-01f, 1.24798097e-01f, -7.78568313e-02f, 5.27158752e-02f, -8.78832340e-02f, 1.81075275e-01f, 1.34184584e-01f, -1.19991295e-01f,
  -1.91053040e-02f, -1.52883157e-01f, -3.33310753e-01f, -8.02216604e-02f, 1.49568990e-01f, -2.05614388e-01f, -2.08673999e-01f, 9.83399600e-02f, 9.36600044e-02f, -1.62093759e-01f,
  -3.05892199e-01f, -4.12452454e-03f, -5.04727624e-02f, -3.01564425e-01f, -2.37752378e-01f, 1.95887852e-02f, -1.24666199e-01f, -2.32399955e-01f, -9.90313813e-02f, -6.82890892e-01f,
  5.61978042e-01f, 2.40275696e-01f, -5.53437531e-01f, 2.63947278e-01f, 1.63406879e-01f, 1.87785327e-02f, 4.04885709e-01f, 4.51718003e-01f, 3.79907161e-01f, 3.30856293e-01f,
  4.89681661e-02f, -2.69125998e-01f, -2.32008412e-01f, -3.23705763e-01f, -1.22502640e-01f, 1.44736633e-01f, 5.74918427e-02f, -3.64727974e-01f, -3.02716792e-01f, 5.69215082e-02f,
  2.92531163e-01f, 2.73348600e-01f, 2.73020297e-01f, 1.57849669e-01f, 5.89515455e-02f, 5.87579198e-02f, -2.49714274e-02f, -1.30188555e-01f, -9.34880376e-02f, -3.02886188e-01f,
  -6.66318655e-01f, -3.12655270e-01f, -4.22061346e-02f, 1.11641757e-01f, -2.26119626e-02f, 1.23996086e-01f, -4.33866959e-03f, -6.03690147e-02f, 2.42923066e-01f, 1.91931278e-01f,
  -8.24083481e-03f, -9.15644839e-02f, -1.29847795e-01f, 4.68670093e-02f, 7.71138864e-03f, -3.75273935e-02f, 5.53989457e-03f, -8.32323730e-02f, -8.39291736e-02f, -3.00482921e-02f,
  -2.03998953e-01f, -1.97846264e-01f, -4.97921929e-02f, -1.01419026e-02f, -7.62772933e-02f, -6.86317980e-02f, -1.04359992e-01f, -1.68711349e-01f, -1.04596823e-01f, 1.54212937e-01f,
  -3.80549788e-01f, 2.10313275e-02f, -1.24504752e-01f, 1.93286929e-02f, 1.31622702e-01f, 1.68343917e-01f, 9.51018780e-02f, 1.36450175e-02f, -4.27477546e-02f, 9.65350270e-02f,
  6.27563521e-02f, -1.79887846e-01f, -2.04306319e-01f, 7.12856799e-02f, -2.18300641e-01f, -8.76751691e-02f, -3.66939092e-03f, -3.59090157e-02f, -1.40675962e-01f, 3.44218500e-02f,
  -1.19014844e-01f, -3.16061117e-02f, -4.02309448e-02f, -1.82711393e-01f, -1.25565886e-01f, -1.52593166e-01f, -1.57060176e-01f, -1.78959414e-01f, 1.25118652e-02f, 3.81517224e-02f,
  -7.02547026e-04f, -5.04175782e-01f, 3.98974568e-02f, -6.89920858e-02f, -9.12522972e-02f, 3.55390273e-02f, -3.08899969e-01f, -7.15470873e-03f, 8.54224432e-04f, -6.58791587e-02f,
  -1.02849498e-01f, -3.40880603e-02f, -1.09369792e-01f, -2.84667183e-02f, 2.09019318e-01f, -1.14799567e-01f, 9.70533565e-02f, 1.52577246e-02f, -1.24220468e-01f, -5.68801314e-02f,
  8.30895826e-02f, 1.80130661e-01f, 1.80473074e-01f, 6.52802214e-02f, -1.50937764e-02f, 2.46960297e-03f, 1.29766747e-01f, 5.03014363e-02f, 5.02859764e-02f, 5.21693826e-01f,
  7.39996612e-01f, 3.55198056e-01f, 2.48351306e-01f, -5.98945431e-02f, -3.59539449e-01f, -2.32278258e-01f, -9.37455893e-02f, -1.34214386e-01f, -1.80951267e-01f, -3.24948877e-02f,
  -2.68192459e-02f, -2.72603691e-01f, -1.16478130e-01f, -9.44906697e-02f, -5.55716194e-02f, 8.83884206e-02f, -8.96994472e-02f, 1.01968765e-01f, -2.79059023e-01f, -1.90643817e-01f,
  -2.38444656e-01f, -1.11849029e-02f, 2.65842110e-01f, 1.10337004e-01f, 5.03938943e-02f, -1.77262574e-01f, 2.16102287e-01f, 1.75012439e-01f, 1.29270107e-01f, 2.06765756e-01f,
  2.64493197e-01f, 3.77186507e-01f, -3.90893608e-01f, -7.18147084e-02f, 1.23143815e-01f, 1.13770269e-01f, -3.33619043e-02f, -2.03122701e-02f, -9.18632075e-02f, -1.25985354e-01f,
  -2.87071392e-02f, 1.77311767e-02f, -1.71211228e-01f, -1.23470411e-01f, -1.16175309e-01f, -9.91892740e-02f, 7.76619697e-03f, 1.34423465e-01f, -1.30440801e-01f, 7.57770762e-02f,
  -2.10701302e-01f, -1.55547457e-02f, 8.30828696e-02f, -1.51307717e-01f, 1.33908745e-02f, -2.93032229e-01f, -1.63675956e-02f, 1.76681384e-01f, 7.23304003e-02f, 2.60026008e-01f,
  -2.10748523e-01f, 7.10882023e-02f, -1.23456061e-01f, -1.89354807e-01f, -1.94576308e-01f, -1.94084540e-01f, -2.32316852e-01f, 2.05090921e-03f, -6.03482388e-02f, -5.75066078e-03f,
  -1.15256153e-01f, -1.45589381e-01f, -6.38127476e-02f, -1.90168574e-01f, -1.44565687e-01f, -8.69589373e-02f, -1.16673596e-01f, -6.80201650e-02f, 7.51271797e-03f, -8.25634897e-02f,
  -2.53541321e-02f, -1.05038479e-01f, 5.51467463e-02f, -6.02638759e-02f, -1.42271429e-01f, -1.70765176e-01f, -2.42332324e-01f, -6.34897053e-02f, 5.55156134e-02f, 1.18920155e-01f,
  -3.07275265e-01f, -2.19127625e-01f, -8.63999724e-02f, 2.69830555e-01f, 2.77001143e-01f, 2.29525596e-01f, 5.39232492e-02f, 3.22186970e-03f, 1.00702144e-01f, 4.34891321e-02f,
  1.53331876e-01f, 6.19178191e-02f, 1.15005299e-01f, 3.46488170e-02f, -1.16581991e-01f, -8.59080553e-02f, 1.34641090e-02f, -2.88394056e-02f, -3.40977162e-02f, 9.31989029e-02f,
  -7.50459209e-02f, -2.09908769e-01f, -1.96200982e-01f, -2.16170415e-01f, -1.50393452e-02f, -2.84360319e-01f, -1.23497300e-01f, -1.38336703e-01f, -2.41556302e-01f, -2.38305137e-01f,
  9.69406545e-01f, -5.66261709e-01f, -3.62019211e-01f, -6.35320321e-02f, -7.84460306e-02f, 1.26790792e-01f, -1.41299620e-01f, -2.83065625e-03f, 2.70021498e-01f, -1.78916603e-01f,
  -1.45209074e-01f, 2.76567549e-01f, 4.49821092e-02f, 1.35265335e-01f, 6.18321486e-02f, -3.85496885e-01f, -2.66628653e-01f, 1.19089849e-01f, 3.46086055e-01f, 2.26499066e-01f,
  6.56916946e-02f, 3.78060900e-02f, 1.85372755e-01f, 7.08121061e-02f, -4.00200725e-01f, -1.13776900e-01f, -3.42638671e-01f, -2.75154859e-01f, -4.05351937e-01f, -6.19148612e-01f,
  -4.17240173e-01f, 1.00226589e-02f, 1.36839300e-01f, 2.82101780e-02f, -6.69304058e-02f, 2.23140642e-01f, 3.87311168e-02f, -8.11542124e-02f, 3.49043868e-02f, -8.92174989e-02f,
  -3.53073888e-02f, 4.84967642e-02f, -8.80943537e-02f, -5.69249876e-02f, -3.59542519e-02f, -2.02796399e-03f, 8.11679363e-02f, 6.47742674e-02f, 1.44076636e-02f, 5.39077166e-03f,
  -1.69951811e-01f, 1.69922691e-02f, 1.45135865e-01f, 9.10813659e-02f, 1.52485386e-01f, 1.45977378e-01f, -2.55074054e-02f, 8.71774554e-02f, 2.21666187e-01f, 1.36816483e-02f,
  -1.26043409e-01f, 2.33708844e-02f, 9.97649953e-02f, 8.48137736e-02f, 2.25144207e-01f, 7.24614412e-02f, -8.57273117e-03f, 5.28618647e-03f, 1.01019435e-01f, 5.82435541e-02f,
  -8.05296153e-02f, 3.85773219e-02f, 6.12296015e-02f, -9.28263441e-02f, -1.53767809e-01f, -2.55329236e-02f, 1.13984622e-01f, -7.35383108e-02f, -7.50214681e-02f, 1.92326563e-03f,
  1.26460269e-01f, -5.64454049e-02f, -2.37555608e-01f, -5.17102070e-02f, -8.31716582e-02f, 4.83906604e-02f, -7.06093237e-02f, -7.31823146e-02f, -6.56547993e-02f, -6.12109080e-02f,
  -3.18167359e-01f, 3.08944225e-01f, -1.72370374e-02f, 3.91384996e-02f, -1.04665473e-01f, -8.74387696e-02f, -7.28728324e-02f, -8.49325657e-02f, -2.41649374e-01f, -9.50985402e-02f,
  -7.15958849e-02f, 2.19770502e-02f, -2.09866717e-01f, 1.13239557e-01f, 2.63709445e-02f, 1.25240713e-01f, 1.00215539e-01f, 8.18813816e-02f, -9.18658972e-02f, -2.04170510e-01f,
  -2.05542743e-01f, 1.77705541e-01f, 2.10551813e-01f, 1.25253260e-01f, 1.84312031e-01f, 1.82892442e-01f, 2.15353053e-02f, 7.78134586e-03f, 1.93302572e-01f, 1.37098387e-01f,
  4.61994976e-01f, 3.66629899e-01f, 2.38807052e-01f, 1.55862182e-01f, 4.07270789e-01f, 5.30473590e-01f, 5.70256710e-01f, 2.34795347e-01f, 6.34114966e-02f, 2.35230610e-01f,
  3.19912881e-01f, -5.70671670e-02f, 9.91616100e-02f, -1.08036563e-01f, 1.17171638e-01f, 1.05648436e-01f, 4.74132895e-02f, -7.29230717e-02f, -4.16803658e-02f, 2.15663403e-01f,
  -1.19455112e-02f, -9.40119568e-03f, -3.37601677e-02f, -1.80860013e-02f, -4.58940119e-02f, -2.05912873e-01f, 3.29970121e-02f, 1.27751872e-01f, 2.42521167e-01f, -3.04870278e-01f,
  -8.76406580e-02f, 4.00534838e-01f, -2.23707497e-01f, -1.16928406e-01f, -6.08277507e-02f, -1.39548346e-01f, -2.10584961e-02f, -1.05907261e-01f, 2.14352086e-02f, -1.32059738e-01f,
  -6.12444691e-02f, -8.74594525e-02f, 4.90797758e-02f, -4.60461490e-02f, -1.00812819e-02f, 4.13793996e-02f, -1.65686578e-01f, -2.28452861e-01f, -4.35595475e-02f, -2.89941188e-02f,
  -1.54438391e-02f, 1.02379039e-01f, 9.80656967e-02f, -1.72413420e-02f, -2.22315136e-02f, -1.28796503e-01f, 9.50443074e-02f, -2.63582915e-02f, 2.35639326e-02f, -2.47852385e-01f,
  -8.27987194e-02f, 1.61739830e-02f, 8.47145095e-02f, 1.50490403e-01f, 1.31695420e-01f, -7.68072307e-02f, -1.33372724e-01f, -4.74013947e-02f, 1.38122514e-01f, -3.67988236e-02f,
  -2.28608474e-01f, -1.17462622e-02f, 6.50587454e-02f, 4.37648147e-02f, 1.14316560e-01f, 6.18706010e-02f, -8.34776610e-02f, -1.60019901e-02f, 1.37476474e-01f, 1.55884236e-01f,
  1.10623036e-02f, -1.34777576e-01f, -1.12264924e-01f, -2.75186468e-02f, 4.18535061e-02f, -7.51660345e-03f, -5.23151569e-02f, -2.58741975e-02f, 5.17609455e-02f, 7.06733167e-02f,
  -3.22623849e-01f, 4.60703880e-01f, -1.54279828e-01f, -2.27035776e-01f, 1.42730409e-02f, -1.02693722e-01f, 1.59175292e-01f, -7.42794126e-02f, 2.71374695e-02f, -6.18396737e-02f,
  3.53502519e-02f, -2.15684086e-01f, 8.35196674e-02f, 2.83829942e-02f, -1.94967806e-01f, -6.77713901e-02f, -1.37411073e-01f, -2.00307056e-01f, -1.43938556e-01f, -1.95297509e-01f,
  -2.49378651e-01f, -6.64888695e-02f, -1.28207192e-01f, -8.36401880e-02f, -4.38154526e-02f, -1.36913866e-01f, -5.77843860e-02f, -4.08998355e-02f, 1.79914394e-04f, -1.99418023e-01f,
  5.46833217e-01f, -4.51470733e-01f, 4.66459244e-01f, 9.70681831e-02f, 1.41725883e-01f, 3.55601400e-01f, 2.36944407e-01f, 1.75767109e-01f, 1.19507194e-01f, -1.03434280e-01f,
  -7.20005751e-01f, -6.35313928e-01f, -5.47702551e-01f, -4.78867024e-01f, -1.81721270e-01f, 2.12300539e-01f, 4.24238831e-01f, 3.71649086e-01f, 3.41900647e-01f, 1.04089245e-01f,
  -1.79835200e-01f, 1.91541240e-01f, 3.19352776e-01f, 1.15161143e-01f, -9.85481031e-03f, 2.02518776e-02f, 1.21020220e-01f, 2.95263957e-02f, -1.14388086e-01f, 1.02423415e-01f,
  -5.07881753e-02f, 9.74198729e-02f, 9.82715003e-03f, -3.29328060e-01f, -1.82514414e-01f, 3.08075659e-02f, 2.79089846e-02f, 3.68930809e-02f, -7.64620006e-02f, -5.17084897e-02f,
  -1.68164238e-01f, -5.90225011e-02f, -2.53594339e-01f, -9.61538702e-02f, 1.25076577e-01f, 8.36090297e-02f, -5.30498065e-02f, 2.36563999e-02f, -1.12315446e-01f, -1.53817579e-01f,
  -2.41027430e-01f, -3.67949787e-03f, 9.63996351e-02f, 5.51050045e-02f, -9.52688605e-02f, -4.11732607e-02f, -8.98460150e-02f, -9.83954291e-04f, 1.15986034e-01f, 1.22007623e-01f,
  3.61248367e-02f, 3.51363719e-02f, 2.62791831e-02f, 5.84412292e-02f, 2.38209665e-02f, -4.90020448e-03f, 1.29069472e-02f, -1.80090573e-02f, 5.52048609e-02f, -1.46011896e-02f,
  -7.51524940e-02f, -5.63768260e-02f, 2.97902059e-02f, -1.09597214e-01f, -5.02441339e-02f, 7.73387477e-02f, -9.38735623e-03f, -1.36722311e-01f, -1.77851524e-02f, 4.00848202e-02f,
  -4.95549366e-02f, 9.30555761e-02f, 1.81532614e-02f, -4.74638343e-02f, 9.44669992e-02f, 8.02043006e-02f, 5.26950918e-02f, -8.64840001e-02f, -5.54913608e-03f, 3.41182761e-02f,
  -1.06434777e-01f, -2.11486459e-01f, 1.00544512e-01f, -1.36269614e-01f, -2.95942347e-03f, -2.23020405e-01f, -1.76777199e-01f, -8.35926682e-02f, -8.77791867e-02f, 4.09935182e-03f,
  -1.24228209e-01f, -1.46223679e-01f, -1.91988200e-01f, -1.20007610e-02f, 7.85151795e-02f, 1.73252448e-02f, -2.54857570e-01f, -4.73210700e-02f, -3.95289212e-02f, -4.26854566e-02f,
  -9.18025598e-02f, 1.74702421e-01f, 2.95038875e-02f, -6.95662051e-02f, -5.20287491e-02f, -2.95467600e-02f, 1.00990251e-01f, 1.18185759e-01f, 5.41892946e-02f, 1.66252017e-01f,
  5.67695975e-01f, 3.84826273e-01f, 2.51548886e-01f, 4.42367226e-01f, 4.07184124e-01f, 2.92581171e-01f, 2.32656121e-01f, 1.48402244e-01f, 1.16982073e-01f, 3.45488608e-01f,
  2.23440543e-01f, 2.05119506e-01f, 1.75033033e-01f, 4.26396877e-02f, 1.29284129e-01f, 1.15270972e-01f, 9.22605842e-02f, 1.97821036e-01f, 1.67570561e-01f, 1.49178922e-01f,
  1.87066287e-01f, 6.82768226e-02f, 6.49275035e-02f, 9.59167182e-02f, 2.57135928e-01f, 1.64902046e-01f, 9.55915004e-02f, 1.26931608e-01f, 1.36372879e-01f, 3.33403438e-01f,
  2.65403062e-01f, 1.05251998e-01f, -1.91899221e-02f, -9.12921727e-02f, -5.23216724e-02f, -6.95099682e-02f, -4.39259671e-02f, -1.08946912e-01f, -2.28406742e-01f, -3.22352499e-01f,
  -1.36097819e-01f, -9.35611650e-02f, 2.01550443e-02f, -1.80258870e-01f, -2.25888193e-01f, -1.98270768e-01f, -1.15132257e-01f, 4.43426967e-02f, -4.41708863e-02f, -1.79034844e-02f,
  6.80822134e-02f, 8.17594975e-02f, 1.87070630e-02f, -1.37191728e-01f, -1.73878580e-01f, -9.47108939e-02f, -3.78661081e-02f, 1.42768968e-03f, -7.75562525e-02f, -6.13116100e-02f,
  2.29648247e-01f, 2.19685867e-01f, 1.25146195e-01f, 9.47454497e-02f, -2.07676917e-01f, -1.62923470e-01f, -1.68135948e-02f, -7.55979344e-02f, -1.46038666e-01f, -1.17891937e-01f,
  -1.35796919e-01f, -8.53910969e-05f, 6.92215934e-02f, -2.05091070e-02f, 9.84551152e-04f, 1.03795223e-01f, 6.26549572e-02f, 9.97427013e-03f, -9.37111080e-02f, -1.52508229e-01f,
  -3.28184329e-02f, -1.59046844e-01f, -2.86465809e-02f, -9.37501788e-02f, 4.15154211e-02f, -3.28839011e-02f, -4.84404229e-02f, -7.19474480e-02f, -3.39019932e-02f, -9.32801217e-02f,
  -3.66690829e-02f, 7.04355016e-02f, 1.76415175e-01f, 1.88566282e-01f, 1.69581976e-02f, -5.91373667e-02f, 1.31867871e-01f, 2.20166910e-02f, -1.47076458e-01f, -1.44299120e-01f,
  -1.19229577e-01f, 1.53690726e-02f, -7.45214382e-03f, -3.61368507e-02f, -1.26861021e-01f, -2.44969159e-01f, 6.39550388e-02f, 2.98220545e-01f, -5.38753644e-02f, 2.37824488e-02f,
  -4.83550802e-02f, 1.09350264e-01f, 5.43627180e-02f, -8.85070115e-02f, 1.55491047e-02f, 5.26808994e-03f, -1.43188596e-01f, -3.16699408e-02f, -1.39961198e-01f, -1.31904900e-01f,
  -8.39499116e-01f, 1.77260842e-02f, -6.32108212e-01f, -6.83529437e-01f, -4.35061723e-01f, -1.58244409e-02f, 1.87279895e-01f, 3.61601591e-01f, -5.12051955e-02f, -1.10050231e-01f,
  -1.19946264e-01f, -5.04885495e-01f, -5.68689287e-01f, -1.80038512e-01f, 1.32111860e-02f, -3.26007396e-01f, -5.57305038e-01f, -4.94431943e-01f, 1.05083492e-02f, 4.35878575e-01f,
  3.13169420e-01f, -2.33672947e-01f, -2.15396360e-01f, 7.90183023e-02f, -6.47273753e-03f, -4.64860983e-02f, -3.00082713e-01f, -3.10227215e-01f, -1.75509751e-02f, -4.51292485e-01f,
  -4.95591789e-01f, -3.32852066e-01f, -4.84788790e-02f, -1.16546825e-01f, -1.81138501e-01f, -2.43137870e-02f, -2.30682921e-02f, -1.21520512e-01f, 1.19015694e-01f, -3.64328262e-05f,
  -2.93643981e-01f, 8.61848053e-03f, -1.23541310e-01f, -2.58048694e-03f, 2.61384286e-02f, 7.64223412e-02f, -5.05281799e-02f, -8.61658901e-02f, -6.93377703e-02f, 2.11211994e-01f,
  8.05212036e-02f, -1.59516111e-01f, -1.90118670e-01f, 2.70640105e-01f, 2.58700877e-01f, -1.54988036e-01f, 1.88983247e-01f, 3.02095503e-01f, 8.12148750e-02f, 5.55480225e-03f,
  2.06792936e-01f, -1.33695081e-01f, 6.25696257e-02f, 1.07699055e-02f, 2.13510171e-02f, 1.17261298e-02f, -3.58223654e-02f, -2.29040044e-03f, 3.06318458e-02f, -2.21004486e-02f,
  -1.77478805e-01f, 1.23606483e-02f, -6.55710846e-02f, -6.24231957e-02f, -1.42499670e-01f, 1.12990372e-01f, 4.56144363e-02f, 5.94063811e-02f, -3.62035893e-02f, -9.27508399e-02f,
  -1.11312307e-01f, -3.06668319e-02f, -7.95272067e-02f, 1.01102658e-01f, 5.42758889e-02f, -6.67798072e-02f, 5.70695437e-02f, 3.21050912e-01f, 8.53322595e-02f, 3.31922732e-02f,
  -4.95122597e-02f, -2.95176417e-01f, -2.57994443e-01f, 4.30396339e-03f, -8.74897167e-02f, 2.57456559e-03f, -1.29160449e-01f, 9.31680724e-02f, -9.34494734e-02f, 7.42147118e-02f,
  1.17693827e-01f, 7.67159387e-02f, -1.69525102e-01f, 7.51219317e-03f, -1.11433556e-02f, -5.75545244e-02f, 5.59280580e-03f, -2.94236690e-01f, 2.98166857e-03f, 1.95153013e-01f,
  1.98120654e-01f, 3.24641936e-03f, -1.72689781e-01f, -2.33382061e-01f, 9.25807133e-02f, -1.78877071e-01f, -2.57916525e-02f, 2.01092571e-01f, 4.84466739e-02f, 1.37857303e-01f,
  -3.65208387e-01f, 2.65573531e-01f, 4.24175352e-01f, -4.28844802e-02f, -1.40439138e-01f, -1.81621537e-01f, -1.10413827e-01f, -1.11306839e-01f, -1.23999463e-02f, -8.12049117e-03f,
  -2.31220275e-01f, -1.32482454e-01f, 1.54368177e-01f, 1.11721069e-01f, 2.47040153e-01f, 2.05044493e-01f, 4.34477329e-01f, 3.91894341e-01f, 5.17295115e-02f, -2.40612447e-01f,
  3.86966579e-02f, -7.14176428e-03f, -2.17467427e-01f, 6.49103001e-02f, 7.21621513e-02f, -4.74742539e-02f, 9.65314806e-02f, 8.15606304e-03f, 1.85429770e-02f, 4.05468106e-01f,
  -2.00417787e-01f, -1.10331595e-01f, -5.43120597e-03f, -2.47636020e-01f, -1.97148360e-02f, 1.27539456e-01f, 3.47063392e-02f, 5.70951477e-02f, 1.06801003e-01f, 1.08393103e-01f,
  -1.70445889e-01f, -1.44123450e-01f, 1.02749869e-01f, -5.33059463e-02f, -2.65985399e-01f, -2.17146128e-01f, 8.44867602e-02f, 2.24458069e-01f, 2.28802890e-01f, 2.73408759e-02f,
  1.42477185e-01f, -2.91918010e-01f, -3.87513727e-01f, 3.89306657e-02f, 1.23290330e-01f, -1.12220384e-01f, -1.46115154e-01f, -7.79257193e-02f, -1.44056275e-01f, -1.22005448e-01f,
  -2.27132961e-01f, -1.92256153e-01f, -3.14425007e-02f, 6.97352886e-02f, 3.55933495e-02f, 1.23247029e-02f, 1.17571875e-01f, 5.42871058e-02f, 2.09584922e-01f, -3.60038206e-02f,
  2.25348070e-01f, 1.13774473e-02f, -7.60237861e-04f, -1.85941458e-02f, -1.16672171e-02f, -1.26873981e-02f, 9.40228179e-02f, 7.27184713e-02f, -1.51211500e-01f, 1.74983852e-02f,
  -4.62468266e-02f, 5.89728989e-02f, -7.52198175e-02f, 2.14012668e-01f, 1.43719554e-01f, 1.52762666e-01f, 5.34552895e-02f, -2.22635210e-01f, -1.09082460e-01f, -2.62944162e-01f,
  -4.87084240e-01f, 1.17315255e-01f, -1.44845590e-01f, 1.14336021e-01f, -1.39612168e-01f, -7.54860118e-02f, -3.42284255e-02f, -3.56318080e-03f, -5.99702261e-02f, -1.19044274e-01f,
  -3.51889968e-01f, -7.78493099e-03f, 1.03397295e-02f, -1.29902335e-02f, -1.78944588e-01f, -2.86265582e-01f, -2.14470387e-01f, 1.25090003e-01f, -2.01370671e-01f, -8.26295689e-02f,
  9.50586051e-02f, -4.33434635e-01f, -4.32180405e-01f, -1.11043014e-01f, -3.51250589e-01f, -5.19044816e-01f, -2.49837846e-01f, -3.04390550e-01f, -4.62141573e-01f, -5.54622650e-01f,
  -6.07354462e-01f, -1.69328913e-01f, -1.52808756e-01f, 5.26241139e-02f, 3.32961887e-01f, -1.26051120e-02f, -1.38678282e-01f, -4.48494665e-02f, 6.20619841e-02f, -3.55799198e-02f,
  -1.96560293e-01f, 6.03619553e-02f, 1.73292965e-01f, 1.72573984e-01f, 9.18273181e-02f, 1.57798856e-01f, 4.03135419e-01f, 1.96597531e-01f, -5.35624921e-02f, 5.42499823e-03f,
  3.35927844e-01f, 5.92510626e-02f, -2.45330438e-01f, 7.16902176e-03f, 1.74503326e-01f, 2.55326539e-01f, 6.44864291e-02f, 2.18742639e-02f, 1.13836005e-01f, 2.94271588e-01f,
  -4.07940924e-01f, -5.84077060e-01f, -2.80542895e-02f, -1.08896092e-01f, -1.80709660e-01f, -3.59502524e-01f, -2.64522851e-01f, -2.77313411e-01f, -2.77704120e-01f, -1.66883543e-01f,
  -8.25770795e-02f, -1.78628922e-01f, 2.19047368e-01f, -4.93540689e-02f, -1.44233108e-01f, -6.09884076e-02f, 8.00878927e-02f, -2.04692066e-01f, -3.74813586e-01f, -2.28528053e-01f,
  4.48761851e-01f, 7.92382881e-02f, -3.97615343e-01f, -1.31112888e-01f, -1.42137840e-01f, -4.17137146e-02f, -3.31375122e-01f, -3.07825357e-01f, -4.93963659e-01f, -4.32704210e-01f,
  -1.04580931e-01f, -2.11859215e-02f, -1.50585743e-02f, -8.62551294e-03f, 2.19066232e-01f, 1.50735840e-01f, 2.52183884e-01f, 2.26085857e-01f, -1.02732321e-02f, -1.48070365e-01f,
  5.90841249e-02f, -1.74693182e-01f, -1.97424665e-01f, -2.65578143e-02f, 2.80321036e-02f, 4.43200208e-02f, 5.45050949e-02f, -5.16864881e-02f, -7.55224004e-02f, -1.02371790e-01f,
  -1.21912144e-01f, 6.17693365e-02f, 1.51757114e-02f, -3.62967066e-02f, 4.07591425e-02f, 6.04022965e-02f, -6.53440878e-02f, -1.53230891e-01f, 5.01529090e-02f, -1.53135240e-01f,
  -8.08158368e-02f, 2.75641195e-02f, -1.46565229e-01f, 6.71397522e-02f, -1.68458410e-02f, -1.57239251e-02f, -9.11206007e-02f, -4.71642353e-02f, -1.02433689e-01f, -2.12116674e-01f,
  -3.22740436e-01f, -2.61108965e-01f, -1.31099433e-01f, -1.08735897e-01f, -5.13164885e-02f, -6.43977150e-02f, -5.51190600e-03f, 8.47747922e-02f, -2.48346612e-01f, -5.48380427e-02f,
  2.23771825e-01f, -1.93447933e-01f, -3.12088311e-01f, -1.16530180e-01f, -1.11223467e-01f, -2.31927454e-01f, -1.32572159e-01f, -2.68025190e-01f, -5.21551251e-01f, -5.58709502e-01f,
  6.43725634e-01f, 5.00492156e-01f, 2.08447888e-01f, 1.83974609e-01f, 2.38563150e-01f, 1.90651447e-01f, 3.37582767e-01f, -9.19679403e-02f, -1.26433477e-01f, 2.11746782e-01f,
  1.82299286e-01f, -1.02794290e-01f, -2.37289637e-01f, -3.04180086e-01f, -2.53884941e-01f, -2.97808647e-02f, -8.77224654e-02f, -7.11082444e-02f, 5.37438430e-02f, 2.59401649e-01f,
  3.06205004e-01f, 2.93073595e-01f, 3.26131910e-01f, 7.76493773e-02f, 2.80061483e-01f, 1.65704768e-02f, 1.61738515e-01f, 3.83077532e-01f, 1.65353417e-01f, 2.49102667e-01f,
  1.85365692e-01f, 4.57694948e-01f, -4.17633593e-01f, 1.13732563e-02f, -3.74388769e-02f, -2.02241778e-01f, -1.13460697e-01f, -2.22204581e-01f, -1.44594181e-02f, 2.08181869e-02f,
  2.01223791e-01f, 7.68439770e-02f, 1.21029519e-01f, 4.76672500e-02f, 1.71903387e-01f, -2.71484219e-02f, -6.68936968e-02f, -7.52990618e-02f, -2.39142522e-01f, -1.27193972e-01f,
  8.37852731e-02f, 2.02863932e-01f, 7.41641298e-02f, -3.05953711e-01f, -2.61017144e-01f, -3.08733910e-01f, -3.01403012e-02f, -3.59281860e-02f, -3.40085655e-01f, -5.24342768e-02f,
  -2.30267555e-01f, 3.50532383e-02f, -7.23468214e-02f, 3.21796387e-02f, 4.61926535e-02f, -1.37250155e-01f, 1.00696245e-02f, 2.10633483e-02f, -5.79506941e-02f, 2.19420210e-01f,
  -1.37641102e-01f, -1.71097051e-02f, 8.06964934e-03f, -7.63100386e-02f, -8.88151675e-02f, 1.36969825e-02f, 7.05825388e-02f, -8.92232135e-02f, 3.18786316e-02f, -1.94975585e-02f,
  1.12071745e-02f, -1.14493415e-01f, -1.60738409e-01f, -6.78254813e-02f, -8.54850858e-02f, 1.70878880e-02f, 1.63181499e-02f, 4.60336506e-02f, -9.44617298e-03f, 9.29056183e-02f,
  -2.04454675e-01f, -3.20249617e-01f, -3.20413977e-01f, -1.27110615e-01f, 1.33209869e-01f, -2.69844562e-01f, -1.12495109e-01f, -1.87782913e-01f, -2.87797349e-03f, -1.43848732e-01f,
  -5.08898962e-03f, -8.64519253e-02f, 5.58961369e-02f, -1.69509575e-02f, -1.14963204e-02f, -1.79386869e-01f, -3.19023523e-03f, -8.79907142e-03f, -1.48613751e-01f, -4.63221036e-03f,
  -1.76931351e-01f, -2.45830894e-01f, -2.75848031e-01f, -4.71277058e-01f, -4.32301134e-01f, -3.13133180e-01f, -3.04740906e-01f, -1.77799329e-01f, -4.24115330e-01f, -2.88952589e-01f,
  9.93762445e-03f, -6.51719570e-01f, -2.41609231e-01f, -3.38016361e-01f, -2.26966247e-01f, -3.14358264e-01f, -5.89028716e-01f, -3.34971309e-01f, -1.02965198e-01f, -4.22724217e-01f,
  -4.81393449e-02f, 3.99040550e-01f, 7.24672601e-02f, 5.61592802e-02f, -1.33829296e-01f, -6.55972838e-01f, -4.78550196e-01f, -1.71084672e-01f, 1.61814447e-02f, -7.66947046e-02f,
  -2.17765853e-01f, -4.23999757e-01f, -1.73178852e-01f, -1.10424176e-01f, -4.35662836e-01f, -1.03592895e-01f, -4.93405014e-01f, -4.29962635e-01f, -4.39152241e-01f, -5.22624493e-01f,
  -1.84076026e-01f, 2.67562866e-01f, 6.19836971e-02f, 9.09831300e-02f, -2.31438339e-01f, 1.00024164e-01f, 3.72532643e-02f, -5.68093769e-02f, 3.78099307e-02f, -1.34841315e-02f,
  1.66565999e-01f, 1.44498706e-01f, -2.45227385e-02f, 1.13851696e-01f, -7.27931932e-02f, 2.40237594e-01f, 2.44290065e-02f, 1.00695759e-01f, -2.13741814e-03f, 6.99290633e-03f,
  1.07305810e-01f, -9.33068246e-03f, 7.48798773e-02f, 9.83228087e-02f, 8.45104530e-02f, 1.79581299e-01f, -6.13860860e-02f, 1.35724261e-01f, 1.49804220e-01f, -3.93621981e-01f,
  -1.53238505e-01f, 9.26715434e-02f, 2.62052622e-02f, 8.44426453e-02f, 2.38429084e-02f, -1.09831132e-02f, 9.38833207e-02f, -2.66261734e-02f, -7.64625240e-03f, 6.17682375e-02f,
  -3.66158709e-02f, 4.46244292e-02f, -5.94671816e-02f, 2.28597075e-02f, 3.34882550e-02f, 1.70678452e-01f, 4.32778634e-02f, -1.23809822e-01f, 8.26260448e-02f, -4.04746979e-02f,
  3.02251964e-03f, 9.98455435e-02f, 3.49224471e-02f, 1.32323764e-02f, -1.01478770e-02f, -1.05394483e-01f, 1.39063925e-01f, 1.76818386e-01f, 8.13816562e-02f, 7.65811130e-02f,
  -3.53193671e-01f, 9.86060202e-02f, -1.44378081e-01f, 1.95034504e-01f, 2.75443774e-02f, -3.15729342e-02f, -3.09700333e-02f, 1.27870873e-01f, 1.22350246e-01f, -2.92785782e-02f,
  1.00049548e-01f, 5.45123778e-02f, -1.77605957e-01f, 4.14904729e-02f, 6.14492819e-02f, 6.09259941e-02f, -4.01508138e-02f, -4.55160737e-02f, 5.68321310e-02f, 1.08702585e-01f,
  -1.72633961e-01f, -8.91181976e-02f, -5.54731563e-02f, -6.63588420e-02f, 6.25568628e-02f, 1.87852129e-01f, 1.65606569e-03f, -7.29120746e-02f, 3.66428345e-02f, -5.81085443e-01f,
  -1.71732023e-01f, 5.43741167e-01f, -3.48648936e-01f, -2.43347913e-01f, -9.27302837e-02f, -3.33268531e-02f, 4.39007670e-01f, 1.32414967e-01f, 1.67360902e-01f, 4.45825994e-01f,
  3.81442904e-01f, -2.92160630e-01f, -2.97563702e-01f, -4.53567743e-01f, -5.29731691e-01f, 9.38245729e-02f, -2.87323684e-01f, -6.75664127e-01f, -7.92615771e-01f, -3.79553467e-01f,
  -1.80000752e-01f, -3.91214013e-01f, -4.29537147e-01f, -4.02656257e-01f, -5.31493425e-02f, -5.76862454e-01f, -1.81150317e-01f, -4.48086053e-01f, -2.84061909e-01f, -1.40826404e-01f,
  -8.95387158e-02f, -1.18957303e-01f, -1.21060304e-01f, -3.56580061e-03f, -2.04379354e-02f, -1.28977979e-02f, 1.61405414e-01f, -5.69085367e-02f, 1.24511532e-01f, 8.20247829e-02f,
  -1.01108998e-01f, 2.04805210e-01f, -2.22909879e-02f, -3.65083739e-02f, -4.61057387e-02f, -1.25498086e-01f, -7.22099394e-02f, -2.86233127e-01f, -1.12425722e-01f, 2.35863239e-01f,
  3.29679877e-01f, 1.13883577e-02f, -1.76934391e-01f, -3.23087000e-03f, 1.31306576e-03f, -1.64280444e-01f, 8.99724439e-02f, -1.50772452e-01f, -2.97823608e-01f, 2.53166974e-01f,
  2.54104495e-01f, 1.82424843e-01f, -1.96060073e-02f, -6.56458223e-03f, 1.82541862e-01f, 3.38198692e-02f, -2.50271615e-02f, 1.74601391e-01f, 2.65421928e-03f, 3.24140824e-02f,
  8.94916281e-02f, 1.53460905e-01f, -7.27000609e-02f, -8.62145796e-02f, -8.99145082e-02f, -1.88385323e-02f, -1.66971944e-02f, 3.64674516e-02f, -9.64566767e-02f, 2.60484368e-02f,
  -1.40425533e-01f, -3.04568447e-02f, 4.57991734e-02f, -6.24855570e-02f, -3.95695902e-02f, -5.69649115e-02f, -1.51378522e-02f, -5.22306003e-02f, -3.65827419e-02f, -4.81080823e-03f,
  -8.08162913e-02f, -3.89507294e-01f, 2.95173377e-01f, 1.28237829e-01f, 3.27288844e-02f, 2.49019433e-02f, 2.66555041e-01f, -4.30783555e-02f, 6.77554011e-02f, 9.38324556e-02f,
  1.12856075e-01f, 8.29378664e-02f, 1.47374213e-01f, 1.49677888e-01f, 9.81328860e-02f, 3.50121260e-02f, 2.11726233e-01f, -1.19486533e-01f, -5.00646755e-02f, 3.07844877e-01f,
  2.83437610e-01f, 8.55925903e-02f, -5.28124683e-02f, 4.03863005e-02f, -5.23431525e-02f, -2.52044946e-01f, -1.69775665e-01f, -1.73086226e-01f, -2.85375267e-01f, 2.68345803e-01f,
  1.18464005e+00f, -3.65584701e-01f, -7.37379193e-01f, 3.94003063e-01f, -3.94475222e-01f, -5.26138842e-01f, -5.78308523e-01f, -2.94884183e-02f, 3.38089764e-01f, -4.36930716e-01f,
  -1.96060374e-01f, 3.78424317e-01f, 8.09560046e-02f, -2.21181452e-01f, -2.84765750e-01f, -6.08204007e-01f, -5.03499269e-01f, -3.48040938e-01f, -2.60019869e-01f, -3.72758240e-01f,
  -1.97295740e-01f, 9.25917830e-03f, 2.44429931e-01f, -6.70469254e-02f, -3.44533436e-02f, 1.19253501e-01f, -3.48428905e-01f, -1.66071489e-01f, -3.01010877e-01f, -1.98393449e-01f,
  -6.25649691e-01f, -1.50929555e-01f, -2.00388506e-01f, 1.98071256e-01f, -1.01400107e-01f, 7.76902437e-02f, -6.51350617e-02f, -1.62318647e-02f, 5.01286052e-02f, 2.82799955e-02f,
  1.75722502e-02f, -1.18699960e-01f, 2.03566194e-01f, -1.48939788e-01f, -1.32590160e-01f, -4.53122407e-02f, -1.42715335e-01f, -3.99422646e-02f, -7.99484104e-02f, -1.92899823e-01f,
  -1.11957185e-01f, -4.08377759e-02f, 3.64618674e-02f, -1.58611566e-01f, -1.00233309e-01f, 3.63464169e-02f, -2.42675573e-01f, 8.62499885e-03f, -1.75164714e-01f, -1.59950554e-02f,
  1.18259728e-01f, 1.49967775e-01f, -1.39234260e-01f, 2.43487470e-02f, 1.28554702e-01f, 9.15213078e-02f, 1.98048860e-01f, -1.10304346e-02f, 4.10004109e-02f, 7.85155967e-02f,
  2.68150270e-02f, -1.63179204e-01f, -6.00494854e-02f, -2.92392224e-02f, -6.45113513e-02f, 4.98412028e-02f, -2.17967667e-02f, 1.25366598e-02f, -6.94215074e-02f, 5.93884103e-02f,
  2.67901924e-02f, 4.52593900e-02f, 1.01263463e-01f, 2.50631366e-02f, -1.84006736e-01f, -1.23520168e-02f, -1.11164674e-01f, 1.36530921e-02f, 4.12438298e-03f, -1.71887781e-02f,
  3.32241625e-01f, -1.52934790e-01f, 1.59852117e-01f, -1.59638394e-02f, -6.43284693e-02f, -3.56897153e-02f, -1.34106383e-01f, -7.58758932e-02f, 1.91449478e-01f, 6.81211054e-03f,
  -2.88825959e-01f, 7.01542199e-02f, 4.96669225e-02f, -7.41120726e-02f, -1.51510358e-01f, -9.43978131e-02f, -1.66642964e-01f, -8.28059018e-02f, -4.01186608e-02f, 1.06066197e-01f,
  -4.03067134e-02f, 3.02257091e-02f, 2.39821523e-01f, 5.57519384e-02f, 4.65667956e-02f, 3.09922129e-01f, -2.01045722e-01f, 4.57900017e-02f, -6.07306585e-02f, 1.69490516e-01f,
  8.08059812e-01f, 1.61172226e-01f, 2.26215765e-01f, 1.88568100e-01f, -5.70193268e-02f, -7.51812756e-02f, -1.72023818e-01f, -5.10945544e-02f, -6.24492718e-03f, 2.22946316e-01f,
  2.38425791e-01f, 1.40024304e-01f, 1.38693258e-01f, 1.53662032e-02f, 2.87414584e-02f, -2.05341410e-02f, 5.08184033e-03f, 2.61271298e-01f, 1.09915525e-01f, 2.65841484e-01f,
  1.63196191e-01f, 6.12185374e-02f, 2.20283389e-01f, 8.59872028e-02f, 2.03886181e-01f, 4.13194709e-02f, -6.21594712e-02f, 1.38121769e-01f, 4.89115305e-02f, 2.84275740e-01f,
  2.11216494e-01f, 2.73230076e-01f, -1.79572683e-02f, -2.34983116e-02f, -1.34700229e-02f, 2.78540570e-02f, 2.45276503e-02f, 2.46883593e-02f, -1.14366353e-01f, -3.05153560e-02f,
  -1.70537159e-02f, 1.47562595e-02f, 2.58806963e-02f, -9.83752608e-02f, 4.05835919e-02f, 2.94624809e-02f, 5.42286783e-02f, 1.18957348e-01f, -1.45121971e-02f, 6.40569627e-02f,
  -4.90889512e-03f, 9.13236588e-02f, 1.42701445e-02f, -1.59127712e-01f, 2.42919046e-02f, 5.18324301e-02f, 4.26694043e-02f, -4.10932153e-02f, -5.58082685e-02f, 1.12979129e-01f,
  2.78562754e-01f, 2.99996823e-01f, 2.81975508e-01f, 2.90438712e-01f, 3.86203557e-01f, 1.39242843e-01f, -5.28851897e-02f, 2.44172551e-02f, 1.20998159e-01f, 1.44080162e-01f,
  2.56720837e-02f, 1.92091599e-01f, 5.73597103e-03f, -5.20689562e-02f, 2.67498009e-03f, 4.23314013e-02f, -7.11457133e-02f, -5.06294295e-02f, 3.88802290e-02f, -9.78836268e-02f,
  8.88432637e-02f, 4.22600210e-02f, -4.86898832e-02f, -1.36701893e-02f, -4.96725738e-02f, 3.86349894e-02f, 1.92592889e-01f, 1.40069783e-01f, 5.95415123e-02f, 1.38686538e-01f,
  -6.74123228e-01f, -2.05024704e-01f, 8.84429291e-02f, 1.21672124e-01f, -1.21486373e-01f, 2.81066373e-02f, 3.25781964e-02f, 7.73013150e-03f, -1.56189114e-01f, -9.81932357e-02f,
  -1.70548484e-02f, -6.04867004e-02f, -1.36785567e-01f, -1.01701029e-01f, 7.60850869e-03f, -1.00601822e-01f, -1.03857420e-01f, -8.04151073e-02f, -1.42144769e-01f, -9.00299922e-02f,
  -9.74299237e-02f, -1.24585837e-01f, -2.23695531e-01f, -2.78352350e-01f, -7.11067393e-02f, -9.55549479e-02f, -6.89647421e-02f, -3.62042151e-02f, -7.98303932e-02f, -8.85128006e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -1.18191354e-03f, 3.82372260e-01f, 4.60908771e-01f, 7.64011800e-01f, 2.89397150e-01f, 3.38401109e-01f, 8.00369322e-01f, 7.72747695e-01f, 4.20190722e-01f, 6.99132800e-01f,
  7.82903135e-01f, 4.30804163e-01f, 6.94624901e-01f, 5.26331186e-01f, 5.32407701e-01f, 6.42088771e-01f, 6.19413435e-01f, 3.48968506e-01f, 4.13954705e-01f, 4.95995104e-01f,
  1.65327236e-01f, 3.80611837e-01f, 1.66290715e-01f, 6.22049153e-01f, 5.15784264e-01f, 4.26373661e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -7.47832507e-02f, 5.34872711e-02f, -5.24530634e-02f, -7.87844881e-02f, -2.25192513e-02f, 3.62203680e-02f, 2.82684147e-01f, -2.59769130e-02f, 1.82729557e-01f, 1.51940063e-01f,
  -1.45917818e-01f, 1.55116273e-02f, -2.02837572e-01f, 2.88399071e-01f, -1.36778384e-01f, -1.70069188e-01f, -1.14277467e-01f, 2.02661544e-01f, 3.13304484e-01f, 9.18512046e-02f,
  2.34915093e-01f, -1.45699963e-01f, 4.17301655e-01f, -1.73950359e-01f, 2.38336489e-01f, -2.04179332e-01f, 1.59458667e-01f, -4.17003751e-01f, -1.31194387e-02f, 1.12411737e-01f,
  -4.81765449e-01f, -2.74601746e-02f, 1.04225062e-01f, 4.52721901e-02f, -3.77314091e-02f, -1.34731874e-01f, 1.23677164e-01f, 8.09133891e-03f, 1.21525347e-01f, -9.05929580e-02f,
  1.39608279e-01f, -2.72667557e-02f, 4.35837775e-01f, -4.15700153e-02f, -1.90981895e-01f, -6.34098500e-02f, 6.34923205e-02f, 1.38176635e-01f, 1.54977262e-01f, -1.65773988e-01f,
  7.17629492e-02f, 1.13218173e-01f, -4.06176865e-01f, 3.27627324e-02f, -3.22023600e-01f, 4.83553037e-02f, -2.78702021e-01f, 1.66520670e-01f, -2.17142060e-01f, -1.15771540e-01f,
  -4.51512225e-02f, 7.09470138e-02f, -9.41842645e-02f, 2.43479162e-01f, -1.58319306e-02f, 8.24180245e-02f, 1.58814743e-01f, -1.19254310e-02f, 8.34390819e-02f, 6.72828034e-02f,
  -1.38684288e-01f, 1.79529399e-01f, -5.59692122e-02f, -6.87687039e-01f, -1.19944490e-01f, -1.25628635e-01f, 8.19337741e-02f, 3.21733028e-01f, 1.95823595e-01f, -1.29060850e-01f,
  -2.10576528e-03f, -2.13848099e-01f, 1.64150909e-01f, -1.97283089e-01f, 3.12514037e-01f, -1.22509681e-01f, 1.48124918e-01f, -5.80888838e-02f, 1.73441887e-01f, 3.02043200e-01f,
  2.08989784e-01f, -1.56589478e-01f, -2.11261779e-01f, -1.08275816e-01f, -1.72386810e-01f, -3.24053884e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.33011514e-02f, 1.12927757e-01f, 2.75308162e-01f, -5.07048547e-01f, 1.12017177e-01f, 1.32019401e-01f, -4.50067874e-03f, -3.30058575e-01f, -1.23254329e-01f, 6.44167185e-01f,
  -4.08360720e-01f, 2.20536441e-01f, 4.33358014e-01f, -4.47508395e-01f, 7.65056461e-02f, 1.57024175e-01f, 2.10549772e-01f, 7.94017136e-01f, 1.78231508e-01f, 1.09155802e-02f,
  4.48722005e-01f, 7.54353881e-01f, -6.83052778e-01f, -8.59301016e-02f, 4.59386408e-01f, -2.64252871e-01f, -2.27570273e-02f, 2.33716592e-01f, 9.10000205e-02f, 1.01206288e-01f,
  -1.64075587e-02f, -8.48114304e-03f, 2.43547395e-01f, 2.99232095e-01f, 2.14957610e-01f, -2.84615934e-01f, 7.09584057e-02f, 2.85722941e-01f, 3.56652290e-01f, -1.22595973e-01f,
  1.60629898e-01f, 6.54692352e-01f, -5.40221035e-01f, 5.12872040e-01f, -4.62065041e-02f, 1.79278608e-02f, -1.56316161e-01f, 6.30886406e-02f, 5.14625251e-01f, 4.19412464e-01f,
  4.00749967e-02f, -3.14094722e-01f, 7.82219246e-02f, 6.06258750e-01f, -7.57475719e-02f, -2.14224264e-01f, 7.09265113e-01f, 4.34383392e-01f, 2.41184160e-01f, 3.74512151e-02f,
  2.50540167e-01f, 5.47497094e-01f, -4.91290450e-01f, -9.72674116e-02f, 1.89878896e-01f, -4.16564606e-02f, 3.19797367e-01f, 8.11068434e-03f, 7.50275422e-03f, -1.75316483e-01f,
  -2.66538888e-01f, 4.72023875e-01f, -4.75168437e-01f, -3.74896407e-01f, 1.70612544e-01f, -2.82833993e-01f, 7.34072924e-01f, 3.42862040e-01f, 2.58193105e-01f, 4.19375068e-03f,
  -7.25797415e-01f, 4.48049903e-01f, -2.96603173e-01f, 1.98846012e-01f, -6.33885041e-02f, 4.84682858e-01f, -4.54505026e-01f, -6.75521512e-03f, -2.21724153e-01f, 1.87783539e-02f,
  5.77271581e-01f, -3.71477604e-02f, 5.40042579e-01f, -2.95628607e-01f, 1.87755570e-01f, 4.11255844e-02f, 1.41613290e-01f, -4.28076498e-02f, 1.53540120e-01f, 4.84561957e-02f,
  -6.40227571e-02f, 1.84241936e-01f, 5.34003675e-01f, -2.13121206e-01f, -9.46017206e-02f, 4.66733038e-01f, 2.09823593e-01f, 4.41906869e-01f, 3.86690825e-01f, -6.55230284e-01f,
  1.11691371e-01f, 1.74103715e-02f, -3.67923170e-01f, 3.44040990e-01f, -1.03048228e-01f, 3.14491659e-01f, 3.19617331e-01f, 4.42163736e-01f, -4.47245330e-01f, 1.29862264e-01f,
  1.42539561e-01f, -4.16626155e-01f, -1.06945567e-01f, 1.46820799e-01f, 4.54860896e-01f, -7.52194375e-02f, 4.88571435e-01f, 3.32378924e-01f, 1.76757365e-01f, -6.49471134e-02f,
  -2.06955418e-01f, -1.81610867e-01f, -3.61437291e-01f, 3.59463423e-01f, 2.34302327e-01f, 1.40363157e-01f, -1.60142988e-01f, 5.45801103e-01f, -4.75413501e-01f, 4.00303811e-01f,
  -3.26225698e-01f, 6.89869046e-01f, 2.86384106e-01f, -3.02960962e-01f, -2.59893179e-01f, 4.52427864e-01f, -2.28580549e-01f, -4.91030514e-02f, -2.54857183e-01f, 5.61734736e-01f,
  -1.58177689e-01f, -3.22127156e-02f, 3.80438298e-01f, 3.53353262e-01f, 5.34478128e-01f, 3.29860061e-01f, 1.25094010e-02f, 1.54293135e-01f, -5.36624730e-01f, -8.03341866e-02f,
  3.10826898e-01f, 3.64717394e-01f, 3.36370200e-01f, -2.62118299e-02f, 3.03262860e-01f, -1.54575348e-01f, -8.75774026e-02f, -2.58729123e-02f, 4.77455765e-01f, -1.49912059e-01f,
  4.26771045e-01f, -1.32919140e-02f, -2.63190985e-01f, 1.12548970e-01f, -1.32367119e-01f, 4.57486778e-01f, 8.83349359e-01f, -8.14976752e-01f, 7.92040646e-01f, 1.49087355e-01f,
  -3.16427499e-01f, 3.32903236e-01f, 6.26290023e-01f, -2.38401100e-01f, -4.12341282e-02f, -3.01550061e-01f, -2.54288018e-01f, 4.70879138e-01f, -4.74061012e-01f, 4.70328301e-01f,
  3.43225211e-01f, 8.31931904e-02f, 1.60397083e-01f, 1.03867456e-01f, 1.28414899e-01f, -3.13600689e-01f, 2.50747740e-01f, -1.44902229e-01f, 8.69004577e-02f, -8.42989832e-02f,
  7.54270494e-01f, -1.30908668e-01f, 2.50259519e-01f, -7.50698522e-02f, -6.11097328e-02f, -5.20552456e-01f, 2.58011311e-01f, 1.16664931e-01f, 6.22382283e-01f, 6.90321326e-01f,
  -9.60358530e-02f, -2.36648127e-01f, 4.67576891e-01f, -1.10112622e-01f, -1.43062741e-01f, 2.99870193e-01f, -1.81613877e-01f, 5.37896454e-01f, 1.50147483e-01f, -2.49317124e-01f,
  3.58926833e-01f, -1.18517049e-01f, 3.06228697e-01f, 1.43299118e-01f, 1.32581949e-01f, 2.37343237e-01f, 2.99277872e-01f, 1.10549904e-01f, -1.08212873e-01f, -1.09000593e-01f,
  -1.46413177e-01f, 3.12627435e-01f, 3.23702663e-01f, -8.11251104e-01f, -2.56334573e-01f, -2.63296753e-01f, 8.16198349e-01f, 3.63984495e-01f, -5.53721823e-02f, -2.86380406e-02f,
  1.06311664e-01f, 1.78504765e-01f, 3.20203155e-01f, 6.62989020e-02f, 3.34400237e-01f, 3.24611850e-02f, 5.32310605e-02f, 2.81258691e-02f, 1.74002454e-01f, -3.81828174e-02f,
  -1.51845381e-01f, -4.51819524e-02f, 1.53072149e-01f, -7.23809972e-02f, 5.67142487e-01f, 2.34029397e-01f, 3.67827654e-01f, 2.48858318e-01f, 2.70325601e-01f, -2.33921155e-01f,
  5.06882071e-02f, 1.10507317e-01f, 2.13154420e-01f, 3.74573357e-02f, 2.38203645e-01f, 6.09565616e-01f, 8.04097533e-01f, 3.12177747e-01f, -5.08395493e-01f, -5.08956075e-01f,
  -6.00096941e-01f, 1.85933739e-01f, 1.28074199e-01f, -4.68784928e-01f, 5.49977906e-02f, 4.92844224e-01f, -7.90955365e-01f, 1.06559053e-01f, 7.03817979e-02f, 9.98037159e-02f,
  -4.58174855e-01f, 2.96720147e-01f, -5.62591944e-03f, 4.55896378e-01f, 1.05213337e-01f, 2.85033017e-01f, 7.73845911e-02f, 3.01039785e-01f, -2.92209852e-02f, 7.64350519e-02f,
  -1.42844036e-01f, 8.95173177e-02f, -4.16429304e-02f, 4.33509983e-02f, -1.97322205e-01f, -1.26844138e-01f, 2.65652929e-02f, -8.76338482e-02f, -6.55585289e-01f, 8.53533894e-02f,
  4.66630369e-01f, -3.29027355e-01f, -6.90448433e-02f, -1.64467379e-01f, 2.28942737e-01f, -3.58204655e-02f, 5.10531843e-01f, -4.03956026e-01f, 4.59537446e-01f, 4.97584462e-01f,
  -4.05735523e-02f, 5.02197519e-02f, 3.86365563e-01f, -4.28888798e-01f, -2.60012329e-01f, 2.58499116e-01f, 1.06095746e-01f, 1.24122731e-01f, 4.24087495e-01f, 3.54215562e-01f,
  2.56448358e-01f, 3.88956487e-01f, 1.87845543e-01f, -4.71774153e-02f, -4.14511282e-03f, -4.61278781e-02f, 3.26569587e-01f, 4.44933236e-01f, -2.67270565e-01f, 5.64907730e-01f,
  2.73260504e-01f, 2.41957814e-01f, 7.57842064e-02f, 6.66569173e-01f, 1.13456279e-01f, 8.61450434e-02f, 2.65242726e-01f, -5.00417650e-01f, 3.24584246e-01f, 2.55744964e-01f,
  -4.58573580e-01f, 5.81106097e-02f, 3.59679997e-01f, 2.88533092e-01f, 7.17746541e-02f, 3.80444340e-02f, -2.22477838e-01f, 1.71120808e-01f, 1.12222865e-01f, 3.95787656e-01f,
  -1.48227021e-01f, -2.94183731e-01f, 2.44556367e-01f, 4.10825480e-03f, -9.77495611e-02f, 3.16023201e-01f, 2.21953392e-01f, -1.35304421e-01f, -5.01416530e-03f, -1.86291024e-01f,
  7.42995083e-01f, -4.80159074e-01f, 6.06298745e-01f, 5.62456138e-02f, -3.10755998e-01f, -6.65083349e-01f, -1.60763487e-01f, -1.24849804e-01f, -1.07169896e-02f, 2.40666702e-01f,
  -1.58460781e-01f, 4.45259422e-01f, 3.16609114e-01f, -5.49145222e-01f, -1.59659266e-01f, 1.51596501e-01f, 3.30679417e-01f, -1.35883272e-01f, 3.40312362e-01f, 3.60275030e-01f,
  2.83197928e-02f, 1.78002119e-01f, 6.47817701e-02f, 3.31345499e-01f, 3.26875508e-01f, 2.26019830e-01f, 2.41965666e-01f, -6.23556711e-02f, 5.33510372e-02f, -1.63302183e-01f,
  -6.17591500e-01f, -1.52226295e-02f, 2.12424621e-01f, -2.23919898e-01f, 1.92539766e-01f, -2.55658776e-01f, 3.39034826e-01f, -6.41094819e-02f, 8.63873363e-02f, 3.65716547e-01f,
  -6.17470928e-02f, 4.11810845e-01f, -1.23181708e-01f, 6.07361972e-01f, 2.68334776e-01f, 9.49488115e-03f, 2.80154854e-01f, 1.69870168e-01f, -4.47152466e-01f, 6.09968781e-01f,
  2.06196770e-01f, 1.25950292e-01f, 2.46757299e-01f, -5.49689054e-01f, 2.55925953e-01f, 4.89151388e-01f, 8.85754600e-02f, -1.37363672e-01f, 3.46827507e-02f, -2.85888970e-01f,
  -4.41682786e-02f, 1.57437801e-01f, 2.05199748e-01f, 2.48992279e-01f, 1.02063812e-01f, -8.08281302e-01f, -2.02653613e-02f, 6.07224584e-01f, -5.13453558e-02f, 1.45399161e-02f,
  3.23524356e-01f, -2.54209876e-01f, 3.20990622e-01f, 1.42021954e-01f, 1.50995925e-01f, -4.08163041e-01f, -1.45435899e-01f, 2.75194973e-01f, -2.98550129e-01f, 4.09032106e-01f,
  -4.88604754e-01f, 1.58010915e-01f, 6.53040767e-01f, 1.28129900e-01f, -4.25158292e-01f, 3.45703145e-03f, 1.07241139e-01f, -1.93301186e-01f, 1.07343741e-01f, 1.58823878e-01f,
  -6.14029653e-02f, 5.26118398e-01f, -3.71243030e-01f, 1.52232572e-01f, 4.78721768e-01f, -3.09926718e-01f, 4.67892051e-01f, 2.13363990e-02f, 3.13881278e-01f, 5.81111133e-01f,
  -3.60190153e-01f, -3.89477015e-01f, 9.69065949e-02f, -3.55471104e-01f, -1.22284032e-01f, 6.00055635e-01f, -4.73549753e-01f, 1.87495500e-02f, 3.01634848e-01f, -3.78834754e-01f,
  -2.55073547e-01f, -1.28857782e-02f, 6.02721453e-01f, -4.23976362e-01f, 2.42918044e-01f, -4.55499738e-02f, 3.62558663e-01f, 3.52676958e-01f, 7.73969479e-03f, 2.82438934e-01f,
  1.42798414e-02f, 5.72757237e-02f, 3.16221356e-01f, -1.08021289e-01f, -3.08639944e-01f, -5.36486059e-02f, 5.57802141e-01f, 5.77856421e-01f, -2.11505398e-01f, 2.24758148e-01f,
  -5.48004434e-02f, 1.55766144e-01f, 4.68468904e-01f, 4.00651187e-01f, -1.76022053e-02f, 2.48122737e-01f, 4.63718653e-01f, -2.24350274e-01f, 3.68468881e-01f, -1.26375243e-01f,
  -2.32415453e-01f, 1.79423705e-01f, -7.23425865e-01f, -4.85354185e-01f, 4.52869326e-01f, -3.10540553e-02f, -2.42700383e-01f, -6.15502715e-01f, -7.76337236e-02f, 5.88742256e-01f,
  2.63861716e-01f, -6.60128519e-02f, 4.53632921e-02f, 7.97805265e-02f, 1.48101017e-01f, -3.86497937e-02f, 2.09870145e-01f, -3.32321674e-01f, -9.51846242e-01f, -1.16930440e-01f,
  -3.93369049e-02f, -1.86279729e-01f, 5.53720221e-02f, -7.33135819e-01f, 6.94877282e-02f, 6.65483832e-01f, 1.92336515e-02f, 2.57136375e-01f, -1.66520759e-01f, -6.62514329e-01f,
  1.43743679e-01f, 3.00140560e-01f, -3.33611444e-02f, 1.80874333e-01f, 6.64469242e-01f, -1.90240517e-01f, -5.19362807e-01f, 6.08171880e-01f, -1.12431556e-01f, 1.31686226e-01f,
  -4.56260026e-01f, -8.44535589e-01f, -4.76903528e-01f, 4.23862457e-01f, 3.17155778e-01f, 3.38142663e-01f, 2.27239281e-01f, -1.35045201e-01f, 2.49874055e-01f, -2.36752793e-01f,
  -2.92734534e-01f, 3.34482580e-01f, 7.31697261e-01f, -1.84080422e-01f, -2.07516745e-01f, -4.85178888e-01f, 5.69408417e-01f, 9.19612497e-02f, 4.97719161e-02f, 4.83333468e-02f,
  6.43197000e-01f, 5.96510231e-01f, -3.85405472e-03f, 2.62712538e-01f, 4.85674649e-01f, -4.98205870e-01f, 2.94961333e-01f, -6.14607751e-01f, 1.60385728e-01f, 6.87310278e-01f,
  1.22974686e-01f, -5.81048489e-01f, 3.49681675e-02f, -1.77661851e-01f, 2.03169748e-01f, -1.23616591e-01f, 2.13855281e-02f, 2.20001429e-01f, 1.05313040e-01f, 2.36378267e-01f,
  8.72620847e-03f, 8.27633739e-02f, -4.20072228e-01f, -4.02252793e-01f, 1.63633659e-01f, 2.88795292e-01f, 5.67175448e-01f, 1.38697550e-01f, 5.20416021e-01f, -1.44420579e-01f,
  -1.12334579e-01f, 2.33997941e-01f, 4.33000714e-01f, -3.07438761e-01f, 5.61481178e-01f, 4.45981264e-01f, 2.52718702e-02f, 4.13998753e-01f, 2.28662282e-01f, 1.30285382e-01f,
  -4.41183031e-01f, -3.82581085e-01f, -3.24312687e-01f, 5.17238319e-01f, -1.87673584e-01f, 5.31959943e-02f, 6.30815268e-01f, 5.23440242e-01f, 1.61910266e-01f, 2.99590260e-01f,
  -4.18179855e-02f, -6.69296682e-02f, 9.47139263e-02f, 1.67317048e-01f, 2.83604205e-01f, 5.06956875e-02f, 4.12636906e-01f, -1.34210996e-02f, 5.69583714e-01f, 3.49589765e-01f,
  -6.96250379e-01f, -5.66033244e-01f, -1.23551965e-01f, 2.12023765e-01f, 2.26865306e-01f, 2.56255008e-02f, -3.57413024e-01f, 5.03046870e-01f, -5.77211738e-01f, -3.17501932e-01f,
  1.62187546e-01f, 2.20719069e-01f, -4.68280585e-03f, 4.01814699e-01f, 4.30954546e-01f, 5.29430509e-02f, 3.66647303e-01f, 2.29740351e-01f, 1.98158532e-01f, 1.72342792e-01f,
  7.61769637e-02f, 3.09306774e-02f, 1.63946655e-02f, 9.54135656e-02f, 1.64254710e-01f, 1.62657537e-02f, -7.66062856e-01f, -4.34752792e-01f, -3.41830075e-01f, 7.45601773e-01f,
  -2.95484811e-01f, -8.00042093e-01f, 6.21049941e-01f, 1.89528123e-01f, 6.49137944e-02f, 3.29390407e-01f, 1.75356433e-01f, 1.06965825e-01f, 1.12616256e-01f, 4.09786910e-01f,
  4.16051120e-01f, 4.48270559e-01f, 6.84478521e-01f, 3.21354389e-01f, -2.39508703e-01f, 1.23818398e-01f, -5.94746172e-01f, 3.75389636e-01f, 1.12053841e-01f, -6.18962109e-01f,
  2.85407335e-01f, 3.28570247e-01f, 2.25678846e-01f, -8.88876617e-02f, -8.21437612e-02f, 1.04115404e-01f, 2.96967775e-02f, -1.33445263e-01f, 4.39697295e-01f, -1.04080297e-01f,
  1.99052840e-01f, 8.34761113e-02f, 1.76441193e-01f, 2.83370763e-01f, -2.75124311e-01f, 3.40217680e-01f, 2.14723870e-01f, 3.04934829e-01f, 2.26552919e-01f, -4.24428344e-01f,
  4.30137008e-01f, -1.92048058e-01f, 8.83794352e-02f, -2.23209448e-02f, 7.08825111e-01f, -6.05357401e-02f, -9.01715532e-02f, -1.71369538e-01f, 3.17888051e-01f, -9.05442834e-02f,
  1.04542539e-01f, 4.87310857e-01f, -6.88242912e-02f, -1.70822889e-01f, 1.02092407e-03f, 1.47012308e-01f, 2.05325723e-01f, 3.11521798e-01f, 9.07389596e-02f, 4.77000177e-02f,
  3.32974166e-01f, -5.49365729e-02f, -1.86571971e-01f, 5.72539307e-02f, 1.23953685e-01f, 7.78632537e-02f, -1.77410655e-02f, -5.90678155e-01f, 2.62008578e-01f, 2.34022662e-01f,
  6.34739501e-03f, 8.71025398e-03f, 1.74489826e-01f, 7.52370059e-02f, 3.18164647e-01f, 2.91806012e-01f, 2.52012163e-01f, 1.52916968e-01f, 5.19185141e-02f, -3.39056671e-01f,
  -2.28473306e-01f, 4.32046615e-02f, 1.64451882e-01f, 7.38907605e-02f, 5.94854712e-01f, 2.09298562e-02f, 1.64923340e-01f, 1.45711586e-01f, 1.92424312e-01f, 2.20888704e-01f,
  -1.59516573e-01f, -4.85938713e-02f, -2.62726784e-01f, 2.56595224e-01f, -5.66287160e-01f, -3.64894494e-02f, -4.93779540e-01f, 6.46241009e-01f, 1.93699561e-02f, 7.87170351e-01f,
  3.71852010e-01f, 2.53984064e-01f, -7.81428218e-01f, -7.15072632e-01f, 1.32596523e-01f, -3.73729825e-01f, 1.50484189e-01f, 3.25705223e-02f, 5.68119109e-01f, -6.06233142e-02f,
  -7.38789737e-01f, 3.25358331e-01f, 4.17339981e-01f, 1.06679276e-01f, -3.54907542e-01f, -4.46033478e-01f, -3.43383074e-01f, -2.65173048e-01f, 2.21681029e-01f, 2.96540141e-01f,
  2.26247400e-01f, 3.60026240e-01f, -3.91476721e-01f, -1.19160309e-01f, 1.69730112e-01f, 5.59915662e-01f, 2.52301961e-01f, -1.31432399e-01f, 7.53950179e-01f, -3.00445370e-02f,
  3.19999188e-01f, -7.84491599e-02f, -3.21963504e-02f, 1.95358377e-02f, 2.00060323e-01f, -5.51672876e-02f, 7.28987828e-02f, 8.69472399e-02f, 5.94775639e-02f, -7.23532736e-02f,
  -6.68240368e-01f, -2.78437197e-01f, -1.09706767e-01f, -4.53306288e-01f, 3.44559759e-01f, 2.60280762e-02f, 3.93795371e-01f, 3.21863830e-01f, 6.17098987e-01f, -9.95830819e-02f,
  6.20415099e-02f, 7.46169761e-02f, 7.90123418e-02f, 2.76018798e-01f, 4.36346605e-02f, -5.37259057e-02f, -3.34532291e-01f, -4.88767862e-01f, -7.46485293e-02f, -4.54116985e-02f,
  -5.02747655e-01f, -7.38550425e-02f, 7.81390965e-01f, 4.74873697e-03f, -9.23862606e-02f, 3.39584708e-01f, 3.44603658e-01f, 1.00877702e-01f, 6.05600893e-01f, -2.54796386e-01f,
  1.73738852e-01f, 4.78510797e-01f, 2.62318671e-01f, -9.89106670e-03f, 1.34552822e-01f, -5.23128271e-01f, -1.58625036e-01f, 3.24352145e-01f, 3.13530751e-02f, -2.66493075e-02f,
  7.17836499e-01f, 2.36780494e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.82268345e-01f, 1.05829820e-01f, 1.06773600e-01f, -9.47080851e-02f, 4.94315848e-02f, 1.21763438e-01f, 5.45937181e-01f, 3.33572328e-01f, 2.66987145e-01f, -2.05209911e-01f,
  5.79945631e-02f, 5.64310730e-01f, 3.56057972e-01f, 6.22943223e-01f, 3.51654828e-01f, -1.52722299e-01f, -1.20946787e-01f, 5.97355425e-01f, 1.97538599e-01f, 2.21064597e-01f,
  5.79478046e-06f, 1.52954206e-01f, -6.25523878e-03f, 3.12593609e-01f, 4.58232105e-01f, -5.64172380e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.53335318e-01f, -6.68414056e-01f, -1.26815721e-01f, 5.19658983e-01f, -3.33063416e-02f, 1.52580768e-01f, 3.16395372e-01f, 1.98152930e-01f, -1.51870862e-01f, 1.28092781e-01f,
  -1.44605577e-01f, -8.33820522e-01f, 9.52993929e-02f, 1.91776142e-01f, -8.59818697e-01f, 3.88694167e-01f, -4.10890400e-01f, 3.08803886e-01f, -2.93082535e-01f, -7.67526031e-01f,
  2.79102504e-01f, -8.23899284e-02f, -2.81382874e-02f, 1.97372839e-01f, -6.00108743e-01f, 6.26682118e-02f, -4.88903761e-01f, -1.93158045e-01f, 6.02629175e-03f, -5.98828718e-02f,
  1.70210332e-01f, 3.80241983e-02f, -1.55739591e-01f, -3.27649564e-01f, -3.63141559e-02f, -6.51675224e-01f, 3.34489286e-01f, -2.25997955e-01f, 2.68123329e-01f, -2.87283689e-01f,
  2.47874618e-01f, 3.44351113e-01f, -6.01378605e-02f, -8.17786753e-01f, 9.31762382e-02f, 1.32190064e-01f, -3.90571445e-01f, 2.51573622e-01f, -4.78398114e-01f, -3.47930282e-01f,
  1.96457341e-01f, 6.11437298e-02f, -2.34406933e-01f, 4.60717231e-02f, 1.95327386e-01f, 4.62833382e-02f, 3.52917574e-02f, -4.45287406e-01f, 1.98156744e-01f, -1.84023768e-01f,
  1.17048554e-01f, -7.53027946e-02f, 5.28846532e-02f, 2.74450392e-01f, 5.01815319e-01f, 5.94032407e-01f, 5.75383961e-01f, 5.32887518e-01f, 2.04841346e-02f, 5.96095860e-01f,
  2.98309952e-01f, 2.11907253e-01f, -1.48388669e-01f, -3.70234877e-01f, -4.11588699e-01f, -1.61412302e-02f, 3.75244617e-01f, 6.32439554e-02f, -1.41508073e-01f, -2.83715725e-01f,
  -6.66342914e-01f, -1.49696218e-02f, 1.92450687e-01f, -1.74272642e-01f, -5.34890257e-02f, -8.08241606e-01f, -1.40844107e-01f, 8.13518584e-01f, -3.50261092e-01f, -1.20980116e-02f,
  -1.71537355e-01f, -2.15750352e-01f, -4.23152298e-01f, -2.02638581e-01f, 4.70888838e-02f, -2.73109496e-01f, -8.33223283e-01f, -4.63818163e-01f, 2.33643845e-01f, 8.70411620e-02f,
  -2.48527393e-01f, -1.89661160e-01f, 4.03780580e-01f, 4.31509048e-01f, -5.87015808e-01f, -1.04992129e-02f, 9.35442686e-01f, -5.32854199e-01f, -3.20719443e-02f, -6.77999914e-01f,
  -5.25375426e-01f, -1.24270611e-01f, 4.10456747e-01f, -4.65653390e-01f, -4.82753992e-01f, -7.34737277e-01f, 1.62095293e-01f, 3.34021300e-01f, 1.59713235e-02f, -3.82937700e-01f,
  -9.53101397e-01f, -6.99564815e-02f, -2.40800664e-01f, 2.41481185e-01f, -3.95114273e-01f, -4.48630422e-01f, -2.57442385e-01f, -4.87029165e-01f, 2.78954685e-01f, 4.29795593e-01f,
  -3.53981137e-01f, 5.61955988e-01f, -4.22190167e-02f, -2.12911874e-01f, -7.53326565e-02f, 3.51621732e-02f, -5.59604652e-02f, 2.42188394e-01f, -2.51810431e-01f, 7.81299472e-02f,
  1.58192173e-01f, -2.98099399e-01f, 1.65022150e-01f, -3.19269300e-01f, 3.13533098e-01f, -7.17524588e-02f, -3.58866781e-01f, -6.55082166e-02f, 4.04199176e-02f, 2.08782718e-01f,
  -4.79941666e-01f, -4.04662699e-01f, -2.85443693e-01f, 1.33894429e-01f, 7.28666186e-02f, 2.45038301e-01f, 2.82535285e-01f, 8.33325461e-02f, 2.90148467e-01f, -5.50735831e-01f,
  2.04791039e-01f, 3.05240750e-01f, 2.00586885e-01f, -6.45608544e-01f, -1.71331596e-02f, -1.75638646e-01f, 6.33874610e-02f, -1.09653408e-02f, -6.00494981e-01f, -2.13191345e-01f,
  -3.55178535e-01f, 7.49107540e-01f, 3.51773649e-02f, 4.75769639e-02f, -6.65165961e-01f, 3.32031071e-01f, 5.60065992e-02f, -1.75348744e-01f, -2.41595075e-01f, 1.46240383e-01f,
  -3.10903698e-01f, 3.96698028e-01f, -4.06032085e-01f, -1.05748363e-01f, 1.79713994e-01f, -2.00338706e-01f, -2.16613844e-01f, 1.86691463e-01f, 6.18115366e-02f, -4.19533998e-01f,
  2.82109715e-02f, 3.46054196e-01f, -3.69140267e-01f, -2.83822659e-02f, -1.95055664e-01f, -2.27912571e-02f, 1.79915696e-01f, -4.66717273e-01f, -8.15695107e-01f, -5.38331509e-01f,
  -5.60094655e-01f, -4.07813609e-01f, -7.50892818e-01f, 3.24447244e-01f, 1.62604183e-01f, -7.82454237e-02f, 2.42343813e-01f, -4.38969582e-03f, 2.54804790e-01f, 2.29754835e-01f,
  1.39308706e-01f, -1.25982374e-01f, -3.32426697e-01f, -2.47059595e-02f, 5.02472520e-01f, -4.10097688e-01f, 1.75249681e-01f, 2.72799879e-01f, 3.10067326e-01f, -3.80740166e-01f,
  -2.68956631e-01f, -5.75830519e-01f, -7.72764146e-01f, -2.88836032e-01f, -4.80491847e-01f, 1.67517081e-01f, -1.53719410e-01f, -4.62871373e-01f, 3.50160688e-01f, 5.03659010e-01f,
  -1.87909171e-01f, 1.02057964e-01f, 4.30332899e-01f, -3.30793202e-01f, 3.75792205e-01f, -3.87259901e-01f, -7.77394883e-03f, -1.28869742e-01f, 2.58206297e-02f, -2.30799004e-01f,
  9.41635892e-02f, -3.63529474e-01f, 8.87985155e-02f, 4.27787662e-01f, -4.33044344e-01f, -4.65006083e-01f, 8.08981135e-02f, -8.26387525e-01f, -4.52630460e-01f, 1.31425023e-01f,
  -2.58628577e-01f, 2.38250922e-02f, -1.81784526e-01f, 5.12667000e-01f, -4.34145629e-01f, -3.73253018e-01f, 9.79432277e-03f, -7.57290348e-02f, 1.25343457e-01f, 7.16086268e-01f,
  -6.94165647e-01f, 3.05833101e-01f, -5.70209503e-01f, -6.14967048e-01f, -1.76845968e-01f, -5.02782822e-01f, -1.04071431e-01f, 2.68703133e-01f, -2.48285264e-01f, 1.06159084e-01f,
  -5.41397154e-01f, 4.53917347e-02f, -1.11916043e-01f, -3.98527712e-01f, 1.31105781e-01f, -6.73361659e-01f, -1.95720613e-01f, -5.07473230e-01f, 5.46918750e-01f, -8.30797181e-02f,
  1.84194669e-01f, -3.10198128e-01f, 2.46816695e-01f, 5.00431776e-01f, 2.78504472e-02f, 5.14440298e-01f, -2.73451835e-01f, 2.85720348e-01f, 4.05124962e-01f, 1.66082725e-01f,
  2.22574696e-01f, -6.54654443e-01f, 5.26616037e-01f, -6.41735196e-01f, -2.08619207e-01f, -6.79320097e-01f, 1.73580423e-01f, 2.37498105e-01f, 4.61886674e-02f, -1.44536585e-01f,
  1.37816846e-01f, -2.57474154e-01f, 3.18689018e-01f, -7.89818347e-01f, -3.02220702e-01f, 5.48237741e-01f, 1.82220638e-01f, 3.36030312e-02f, 3.42134207e-01f, -9.60509241e-01f,
  -4.53810692e-01f, -8.11308563e-01f, 2.80336261e-01f, 3.69981110e-01f, -7.10719585e-01f, -1.12157539e-01f, -3.19694400e-01f, -9.69326377e-01f, 3.09319109e-01f, -4.95823294e-01f,
  1.17633596e-01f, -2.46871114e-01f, 1.48653137e-02f, -3.87703717e-01f, -1.24557927e-01f, 3.33603799e-01f, -6.04725897e-01f, -6.53331578e-02f, 6.71619773e-01f, -5.94814181e-01f,
  -3.50975633e-01f, -4.49800640e-01f, -7.33829379e-01f, 4.16603237e-01f, -6.00354075e-01f, -3.35144788e-01f, 5.07890999e-01f, -3.70258152e-01f, -5.09587049e-01f, -4.63371247e-01f,
  -1.96915537e-01f, 6.26472056e-01f, 4.16025519e-02f, 3.35586578e-01f, -5.27480125e-01f, -5.62779307e-01f, -7.42981791e-01f, -4.46656376e-01f, -7.81071842e-01f, 7.60661578e-03f,
  4.31025505e-01f, -2.33641505e-01f, -7.93100223e-02f, -2.07559407e-01f, -5.86762011e-01f, 3.03487599e-01f, 3.20752114e-01f, -2.40784794e-01f, 3.98825467e-01f, 1.10430032e-01f,
  -8.50563869e-02f, 2.60943025e-01f, 2.83374954e-02f, 3.76423478e-01f, -7.09952593e-01f, -8.89946103e-01f, 4.08030182e-01f, 7.00599104e-02f, 3.38491470e-01f, -4.59795147e-01f,
  -2.44010583e-01f, -3.87456626e-01f, -4.99690533e-01f, -4.62099969e-01f, -1.14557132e-01f, -5.95554709e-01f, 3.69735450e-01f, -1.31258756e-01f, 1.84047520e-01f, -3.73316526e-01f,
  -3.17989513e-02f, -5.23513794e-01f, -7.27855504e-01f, 1.67359471e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.02352060e-03f, -2.17722952e-01f, 2.92381138e-01f, -8.31738412e-02f, -1.21226728e-01f, -5.47410883e-02f, -4.72667925e-02f, 1.74139246e-01f, -7.25054592e-02f, 3.59826356e-01f,
  5.37653826e-02f, -3.69942009e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    