/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.25756967e-02f, 5.00724912e-02f, 1.00389063e-01f, 9.54726264e-02f, 5.50584681e-02f, -5.88487647e-02f, -1.05216958e-01f, -1.52467534e-01f, 1.06923461e-01f, 5.12474701e-02f,
  9.51524153e-02f, 6.36104047e-02f, 1.37991533e-01f, -2.55823620e-02f, -3.87738273e-02f, -7.57290646e-02f, 3.15793231e-02f, -1.83302283e-01f, -2.00194791e-01f, -9.72564891e-02f,
  -1.20343752e-02f, -8.83061588e-02f, -1.48740500e-01f, -8.89123157e-02f, 8.05082098e-02f, 2.84422953e-02f, 2.04077009e-02f, 1.86961722e-02f, -7.63683487e-03f, 6.90881312e-02f,
  2.59252414e-02f, 2.35320888e-02f, -9.80761722e-02f, 3.83814313e-02f, 5.94307967e-02f, -4.87433448e-02f, 3.26748844e-03f, 2.32155733e-02f, 7.75473565e-02f, 1.92913529e-03f,
  5.60470074e-02f, 2.31765136e-02f, -3.47722583e-02f, -7.81883672e-02f, 1.26173552e-02f, -1.57059938e-01f, -7.21034184e-02f, -4.99647036e-02f, -2.89615039e-02f, -1.06992103e-01f,
  5.43232039e-02f, -8.39920565e-02f, 1.27343535e-02f, -1.04520902e-01f, -2.98984535e-02f, 6.79823458e-02f, 2.00780993e-03f, -5.76965325e-02f, -1.06894463e-01f, -1.18643999e-01f,
  -7.95580596e-02f, 6.28223121e-02f, 1.38289733e-02f, 6.15642443e-02f, 7.60796666e-02f, -2.39072125e-02f, 3.52567285e-02f, 3.94945368e-02f, -2.78169592e-03f, 3.44334333e-03f,
  -7.96073079e-02f, 8.57265368e-02f, 3.55478860e-02f, 9.63338837e-02f, 1.03488741e-02f, 9.67622269e-03f, 5.24398275e-02f, -3.69239002e-02f, 1.97181525e-03f, 3.44549050e-03f,
  -6.66708872e-02f, -4.43637464e-03f, 1.76969711e-02f, -4.91422368e-04f, 1.98531188e-02f, -5.86543307e-02f, -1.15060821e-01f, 5.98235317e-02f, -1.32448534e-02f, 7.99664669e-03f,
  1.80203900e-01f, 2.91591734e-02f, -3.41190509e-02f, -3.30198519e-02f, 1.06626458e-01f, -2.82798782e-02f, 9.25571844e-02f, -3.87154482e-02f, 1.02503553e-01f, -1.01183347e-01f,
  -9.59554687e-02f, -4.17703502e-02f, -3.09028253e-02f, -1.01244062e-01f, 1.43836373e-02f, -9.15849523e-05f, 1.41973598e-02f, -9.01236534e-02f, -1.11182995e-01f, 6.42400011e-02f,
  -2.86267772e-02f, -1.23100236e-01f, -3.75283398e-02f, 2.05084532e-02f, -1.45526482e-02f, 2.28355248e-02f, 6.19830005e-02f, -8.03246424e-02f, -1.02009639e-01f, -5.95771782e-02f,
  5.17578363e-01f, 1.19985184e-02f, -1.03676125e-01f, 2.37875164e-01f, -7.13531002e-02f, -6.80112317e-02f, -9.25935879e-02f, 1.62231941e-02f, 8.68529975e-02f, 5.69270402e-02f,
  -4.58213575e-02f, 9.91896689e-02f, 8.84170383e-02f, 4.95982766e-02f, -2.93541923e-02f, -8.21002498e-02f, -1.40572162e-02f, -1.94813330e-02f, 5.71839958e-02f, 5.34614623e-02f,
  -1.02387100e-01f, 2.68831495e-02f, 1.96548000e-01f, 7.89318755e-02f, 9.25583416e-04f, -6.29620776e-02f, 2.89118662e-02f, -1.26001704e-02f, 7.38448650e-02f, 6.68843612e-02f,
  -1.07725881e-01f, 1.79810703e-01f, -9.74497125e-02f, 7.52106756e-02f, -2.42211968e-02f, 1.22866035e-01f, -5.93242347e-02f, 5.68419583e-02f, 1.20532677e-01f, -5.30263484e-02f,
  1.63244864e-03f, 1.92492716e-02f, 1.38249338e-01f, -2.36599557e-02f, 8.61632153e-02f, 8.48909244e-02f, -2.29837205e-02f, 1.22010201e-01f, 2.93493979e-02f, -6.62320703e-02f,
  -7.33267458e-04f, 1.37731403e-01f, 5.34471832e-02f, -9.74275842e-02f, 4.87813205e-02f, 1.41235264e-02f, -6.54939637e-02f, -3.43145914e-02f, -5.21713644e-02f, 1.95665937e-02f,
  1.13661457e-02f, -4.95794304e-02f, 8.51640385e-03f, -3.97996232e-02f, -2.70811375e-02f, -1.23191848e-02f, 7.36464858e-02f, -1.56965968e-03f, -7.25855231e-02f, 3.99304330e-02f,
  1.55275203e-02f, -8.46963376e-02f, -8.26966316e-02f, 8.97094980e-02f, -6.44064769e-02f, 3.23504806e-02f, -2.28217207e-02f, -9.91872922e-02f, 6.50882125e-02f, 2.34113168e-02f,
  2.38930881e-02f, -3.57694388e-03f, 7.73659488e-03f, -9.70734581e-02f, 2.95918211e-02f, 4.58534285e-02f, 1.33822644e-02f, -5.96682057e-02f, -3.50490003e-03f, 7.96157643e-02f,
  -1.39818355e-01f, 6.59399573e-03f, -2.66454834e-03f, 9.42141265e-02f, 1.00006841e-01f, 3.06302030e-02f, -4.98140305e-02f, 6.79330081e-02f, 7.14387968e-02f, 4.88715284e-02f,
  4.71351147e-02f, 5.60868392e-03f, -2.08506663e-03f, -1.02701381e-01f, -2.51060985e-02f, 5.28979152e-02f, -1.03841551e-01f, 2.88224872e-02f, -1.08764753e-01f, -6.35391027e-02f,
  -1.06532976e-01f, 3.27414647e-02f, 8.30987617e-02f, -3.44092138e-02f, -8.75805840e-02f, -2.25878470e-02f, -5.70802055e-02f, -3.68549861e-02f, -5.41316271e-02f, -8.66842493e-02f,
  1.91543147e-01f, -1.72335789e-01f, -8.51399675e-02f, 9.17365626e-02f, -2.42590290e-02f, -2.31896803e-01f, -3.01725119e-01f, 1.34439776e-02f, -7.85935670e-02f, -1.52791455e-01f,
  8.46363604e-02f, 1.19089469e-01f, 8.55899453e-02f, 1.20076239e-01f, -6.35150000e-02f, -2.08660588e-01f, -3.80909517e-02f, 1.30826430e-02f, 6.68759644e-02f, -1.46308821e-02f,
  -3.42012271e-02f, -4.92877141e-02f, 1.19476914e-01f, 1.43947169e-01f, 4.25615124e-02f, 3.09696589e-02f, -7.94619173e-02f, 3.44274491e-02f, 6.91423425e-03f, -1.77741870e-02f,
  3.03335898e-02f, 8.85724947e-02f, 2.06020158e-02f, 9.02783573e-02f, 4.29758690e-02f, 8.48453045e-02f, 5.59852012e-02f, 6.80951998e-02f, -3.82750714e-03f, -2.90623493e-02f,
  1.40051559e-01f, 8.92398879e-02f, -4.21612989e-03f, 3.48864682e-02f, 5.76586500e-02f, 5.18045612e-02f, 3.17376629e-02f, 1.19632639e-01f, -2.73107104e-02f, 8.82939547e-02f,
  -6.94920197e-02f, 6.69242665e-02f, 1.01619124e-01f, 8.18258990e-03f, 3.10021825e-02f, 7.96524286e-02f, 4.35201079e-02f, 1.43829912e-01f, 5.86631224e-02f, -2.66799144e-02f,
  -3.77175212e-02f, 5.61663285e-02f, 2.10219268e-02f, -5.22313714e-02f, -1.65630709e-02f, -1.03111044e-02f, -1.21195624e-02f, 3.06787584e-02f, 8.88995593e-04f, -3.12579088e-02f,
  3.62275317e-02f, -1.71727818e-02f, 2.56765112e-02f, -4.70636413e-02f, 2.52603181e-02f, 6.49078190e-03f, -1.07646972e-01f, -7.09022628e-03f, 4.41908762e-02f, -4.91599515e-02f,
  -4.95016715e-03f, 5.39769828e-02f, 3.75380851e-02f, -1.00090638e-01f, -3.57160233e-02f, 6.05836920e-02f, 1.88789275e-02f, 3.91324470e-03f, 7.09140673e-02f, 7.40041770e-03f,
  -1.39392748e-01f, -1.30032459e-02f, -1.06129192e-01f, 5.71198715e-03f, 4.72722948e-02f, 1.91040467e-02f, -2.71022320e-02f, 7.80355930e-02f, -1.70017928e-02f, 5.65947667e-02f,
  -1.27882315e-02f, -2.73034517e-02f, -7.79029131e-02f, 6.68138266e-03f, -4.54205610e-02f, -8.21030438e-02f, -1.37252333e-02f, -8.62053186e-02f, -6.75222054e-02f, -6.19646981e-02f,
  -1.05864309e-01f, -1.62114710e-01f, -1.21514954e-01f, -1.05545327e-01f, -7.18442276e-02f, -7.95377940e-02f, -5.75395823e-02f, -7.27750063e-02f, -1.58139393e-01f, -2.68744051e-01f,
  1.53920412e-01f, 2.60820657e-01f, 4.27773654e-01f, 2.94639030e-04f, -1.55654550e-01f, -9.48249325e-02f, 1.02156416e-01f, -3.29017602e-02f, -1.10568836e-01f, 4.86670388e-03f,
  -2.81177182e-03f, -1.17034003e-01f, -1.24519384e-02f, -7.40573555e-02f, 2.06568129e-02f, 1.62936717e-01f, 2.14127414e-02f, 1.29461795e-01f, -4.30658311e-02f, -2.09965721e-01f,
  -2.16456652e-01f, -1.08373433e-01f, -4.11357395e-02f, -7.75916204e-02f, 5.45668714e-02f, -1.24484748e-02f, 2.02997208e-01f, 9.46235508e-02f, 5.08473106e-02f, -4.15881500e-02f,
  2.15001732e-01f, 1.83973953e-01f, -1.36036575e-01f, -1.80453330e-01f, -3.30586312e-03f, 6.45766407e-02f, 4.58353572e-02f, 1.20654158e-01f, 6.27047420e-02f, -7.12425914e-03f,
  -3.14168110e-02f, 5.45770824e-02f, -6.70656711e-02f, -5.73720410e-02f, 7.87387267e-02f, 6.94079101e-02f, 7.52684847e-02f, 1.34991273e-01f, 2.39284746e-02f, 5.99891990e-02f,
  -1.01858094e-01f, -9.48333144e-02f, 7.24797845e-02f, 1.08895957e-01f, 1.20399281e-01f, -7.09821284e-02f, 5.60531728e-02f, 1.34868711e-01f, 5.28476052e-02f, 1.19766265e-01f,
  -2.48943362e-02f, 7.01834494e-03f, 5.16328290e-02f, 5.96059561e-02f, -1.91424154e-02f, 1.77424308e-02f, 1.59120634e-02f, -2.74678990e-02f, -2.08941083e-02f, 2.45332923e-02f,
  6.44750297e-02f, 1.49012813e-02f, -3.06125823e-02f, 1.35398814e-02f, 2.20737085e-02f, 4.10528481e-02f, -4.70571890e-02f, 4.48587164e-02f, -3.37471329e-02f, 1.35740172e-03f,
  -1.20124109e-02f, -3.02202050e-02f, -2.60777455e-02f, -7.63430493e-03f, 9.55189094e-02f, 7.10857287e-02f, 9.51239094e-03f, -5.27977273e-02f, 1.14037678e-01f, -3.92731838e-02f,
  -6.06155768e-03f, -6.04843535e-02f, 6.53782636e-02f, 5.75385541e-02f, -2.20228210e-02f, -1.10892029e-02f, -6.92352578e-02f, 1.99003723e-02f, 3.90390940e-02f, 9.89055112e-02f,
  1.00293271e-02f, 7.87893403e-03f, 1.04547277e-01f, -1.63257960e-02f, -1.01808004e-01f, -7.98262581e-02f, 5.54831512e-02f, -1.36009548e-02f, 4.25068922e-02f, 7.31709525e-02f,
  2.17576921e-02f, -2.79396418e-02f, 3.16924527e-02f, 9.49201733e-03f, 2.45253071e-02f, -4.77449410e-02f, 1.54521599e-01f, -6.24832772e-02f, 3.77950165e-03f, 1.58437062e-02f,
  2.36846820e-01f, -3.74075413e-01f, 2.02957034e-01f, -1.94193691e-01f, -2.54569668e-02f, 1.65062785e-01f, 4.24192549e-04f, 3.19191106e-02f, -1.03293456e-01f, -2.15997964e-01f,
  -1.25993323e-02f, 5.89666106e-02f, -4.28526700e-02f, 4.61253561e-02f, 2.05463067e-01f, -1.78934634e-01f, -2.00123221e-01f, 1.93340108e-01f, 3.33259612e-01f, 2.43535891e-01f,
  -1.40309572e-01f, -5.12413643e-02f, 1.24487177e-01f, 1.06401972e-01f, -3.01806420e-01f, -5.85721619e-02f, -1.21694043e-01f, -6.54356629e-02f, -6.54862300e-02f, -3.41795534e-01f,
  -6.47918507e-02f, -2.10861918e-02f, 6.53044283e-02f, 2.03634072e-02f, -2.31318213e-02f, 1.24093825e-02f, -1.90668479e-02f, -8.84036242e-04f, 2.80421544e-02f, -4.44605947e-02f,
  3.87616381e-02f, 5.52359819e-02f, 2.75190473e-02f, -7.17825675e-03f, 3.60718891e-02f, -4.05347273e-02f, -4.86033037e-02f, 7.43742287e-02f, -1.73243694e-02f, -1.69208050e-02f,
  -1.48527831e-01f, -3.79364900e-02f, 1.37953207e-01f, 2.47996021e-02f, 1.11551926e-01f, 1.53484017e-01f, 6.07642345e-03f, 1.09146275e-02f, 1.84341595e-01f, -1.95081219e-01f,
  -2.06129048e-02f, -2.09911726e-02f, 6.86562732e-02f, 2.15249229e-02f, -1.11531662e-02f, -7.47183785e-02f, -4.77513000e-02f, 5.45994490e-02f, 1.83413904e-02f, -2.04792451e-02f,
  3.50121632e-02f, -7.79635739e-03f, 5.47047406e-02f, -6.49772771e-03f, -5.20359445e-03f, 2.31729336e-02f, -2.44582910e-02f, -3.40375230e-02f, 4.38876152e-02f, 3.33764777e-03f,
  -8.39262363e-03f, 3.43824960e-02f, -2.29012240e-02f, -1.49030716e-03f, 4.66231145e-02f, -2.40313429e-02f, -3.49693857e-02f, -1.31171802e-02f, 7.82606658e-03f, -2.51376536e-02f,
  -1.77385688e-01f, 3.71747106e-01f, -1.66799545e-01f, -1.25265475e-02f, 2.36132462e-02f, -7.11231604e-02f, 2.64030270e-04f, 4.46723914e-03f, -8.61919522e-02f, -6.47151247e-02f,
  8.27032700e-02f, 5.97963892e-02f, -2.43494362e-02f, -5.05815968e-02f, 7.49006644e-02f, 2.86629293e-02f, 8.67007475e-04f, -6.35734573e-02f, 1.46617061e-02f, -6.32032081e-02f,
  -1.12271480e-01f, 2.86530182e-02f, 3.13950479e-02f, -4.94638234e-02f, -5.69784418e-02f, 1.35417297e-01f, 1.99933443e-02f, 7.05121830e-02f, 1.42600313e-01f, -1.99316591e-01f,
  -3.89351666e-01f, 1.13007709e-01f, -1.17571950e-01f, -3.60624231e-02f, 6.65712506e-02f, -1.00424699e-01f, -5.40135577e-02f, -1.32570088e-01f, -5.42457998e-02f, 6.47498071e-02f,
  2.05982789e-01f, 9.62390676e-02f, 1.10765183e-02f, -4.16003503e-02f, -1.30796909e-01f, -4.00690138e-02f, -1.03324130e-02f, -2.40396112e-01f, -3.06137264e-01f, -1.62269622e-01f,
  1.30766612e-02f, -8.21873397e-02f, -1.97179943e-01f, -3.01667824e-02f, 1.75037816e-01f, 3.91585343e-02f, 8.25459138e-02f, 1.09896809e-02f, 4.80459183e-02f, 1.31390050e-01f,
  1.54946996e-02f, -8.09497088e-02f, -7.55668059e-02f, 9.38195512e-02f, 7.99856782e-02f, 7.43011246e-03f, -6.12144694e-02f, -4.15564254e-02f, 5.97764319e-03f, 3.77370045e-02f,
  8.04857090e-02f, 4.29216772e-03f, -5.28594255e-02f, 6.55020773e-02f, -8.70021582e-02f, 4.51727211e-02f, -9.47774127e-02f, -1.04013994e-01f, -1.20545737e-01f, -4.43647467e-02f,
  9.09379795e-02f, -1.17728844e-01f, -1.84153393e-01f, 1.07222833e-02f, -1.13210648e-01f, 8.35945737e-03f, -4.36458290e-02f, 5.53577393e-02f, -9.67071056e-02f, 1.09894924e-01f,
  1.31075848e-02f, -3.28830443e-02f, 2.21522916e-02f, -1.47141865e-03f, 1.65827833e-02f, 1.19221909e-02f, 8.93574953e-02f, 7.89347962e-02f, 4.45168614e-02f, -7.03602135e-02f,
  4.46905121e-02f, -4.57658656e-02f, 1.61517654e-02f, -3.10023185e-02f, 1.25280619e-01f, -6.36841878e-02f, 7.01976642e-02f, -2.80566383e-02f, -6.71222731e-02f, 3.01059410e-02f,
  2.98376232e-02f, -4.55694972e-03f, 4.01428714e-02f, 8.74672905e-02f, 2.43234411e-02f, -3.56354192e-02f, 2.36523170e-02f, 3.52890603e-02f, 3.89501527e-02f, -9.39955488e-02f,
  1.88211560e-01f, -1.10676512e-01f, 1.28336527e-04f, -6.36228621e-02f, -1.35108791e-02f, 2.12084204e-02f, 5.04769906e-02f, -1.20900711e-02f, 1.53807653e-02f, -1.02715660e-02f,
  1.99861173e-02f, 3.57255200e-03f, 4.42966782e-02f, 2.62982789e-02f, 1.61246564e-02f, -4.38806266e-02f, 5.65548986e-02f, 3.19956914e-02f, -5.94111085e-02f, 6.26573786e-02f,
  1.41159594e-02f, -1.11004792e-01f, -4.02469635e-02f, 3.39057073e-02f, -5.68023175e-02f, -8.90564248e-02f, 4.50423993e-02f, -7.20289275e-02f, -8.37959722e-02f, 5.30207120e-02f,
  1.47644132e-01f, -9.01937634e-02f, 6.14810400e-02f, 7.55757317e-02f, 5.71062975e-02f, -3.94550413e-02f, 4.29482013e-03f, 2.54316367e-02f, 6.46185055e-02f, 8.58015493e-02f,
  1.82909876e-01f, 1.32694900e-01f, 7.00976998e-02f, 3.53151821e-02f, -7.02997372e-02f, -1.16813064e-01f, -2.39796087e-01f, -1.56044811e-01f, 2.35669948e-02f, -4.22705747e-02f,
  -9.92874056e-02f, -1.21735163e-01f, -1.66406795e-01f, -1.39816210e-01f, -1.96542311e-02f, -8.06556270e-02f, -9.88577902e-02f, 6.41464218e-02f, -2.32302174e-02f, -1.34312823e-01f,
  1.42498955e-01f, 1.55845970e-01f, 4.86143865e-02f, -3.48988883e-02f, 1.24541610e-01f, 8.18254352e-02f, 1.48496858e-03f, 9.44688842e-02f, 1.73496678e-01f, -3.08974870e-02f,
  3.24619263e-02f, 4.50981185e-02f, 1.17614567e-01f, -8.82680863e-02f, 7.87687115e-03f, 1.76212676e-02f, 2.36796606e-02f, 4.59216982e-02f, -4.52800989e-02f, 7.45793954e-02f,
  -2.60909684e-02f, 7.09337443e-02f, 5.93851022e-02f, -1.60197075e-02f, -4.28022891e-02f, 1.32682145e-01f, 9.10983011e-02f, 1.01631261e-01f, 9.10673961e-02f, -1.56866059e-01f,
  6.04757927e-02f, 4.76891398e-02f, -7.98157156e-02f, 4.81903255e-02f, -7.86622316e-02f, 5.71469069e-02f, -2.80286977e-03f, -2.90318113e-02f, -2.18433682e-02f, -7.33229965e-02f,
  2.80441454e-04f, -1.20414784e-02f, 2.61238366e-02f, -2.87653599e-02f, 4.50826716e-03f, -1.00231934e-02f, -5.25054857e-02f, -2.62489077e-02f, -6.42798841e-02f, 7.41254464e-02f,
  -3.26301740e-03f, 3.36275361e-02f, -5.39222127e-03f, 3.72286178e-02f, -2.20219903e-02f, -2.23675817e-02f, -6.82106838e-02f, 1.56658329e-02f, -1.61570795e-02f, -4.43915557e-03f,
  -5.56818093e-04f, 1.24962136e-01f, 3.99288200e-02f, -5.74295260e-02f, 5.75106218e-02f, 3.92900556e-02f, 1.65510327e-02f, -9.74452943e-02f, 7.29236677e-02f, 4.13465267e-03f,
  3.62789743e-02f, -1.18919825e-02f, 6.98455796e-03f, 1.94967054e-02f, -5.65707274e-02f, -3.12252231e-02f, -7.11338222e-02f, -8.60073566e-02f, 5.06705903e-02f, 2.45501082e-02f,
  -6.40514195e-02f, -5.71245402e-02f, -5.87146450e-03f, -6.56294748e-02f, -2.62243897e-02f, -4.52595465e-02f, -5.44378310e-02f, -2.69240979e-03f, 3.01873535e-02f, -2.04308778e-01f,
  1.39232814e-01f, -2.03846255e-03f, 6.51469305e-02f, -1.58235207e-01f, -1.81307152e-01f, -3.22555676e-02f, 3.06693483e-02f, 3.46188154e-03f, -1.07997701e-01f, -1.94318481e-02f,
  -8.58299211e-02f, 1.17582835e-01f, 1.73715148e-02f, 8.77268836e-02f, 1.05208844e-01f, 9.97817591e-02f, 7.33799934e-02f, 9.59949866e-02f, 7.26560131e-02f, -7.56208459e-03f,
  -8.50043520e-02f, -3.14371940e-03f, 3.42256464e-02f, -4.00514714e-02f, -1.23454615e-01f, 5.42574674e-02f, -5.64818010e-02f, 3.17653902e-02f, 3.63100991e-02f, 9.91565809e-02f,
  1.45039827e-01f, -1.73039854e-01f, 1.51065458e-02f, 2.37121955e-02f, -2.88776192e-03f, 1.02101892e-01f, 9.76125747e-02f, -4.90508415e-02f, -2.55611781e-02f, -1.20472265e-02f,
  1.33340876e-03f, -1.11283928e-01f, 1.42337373e-02f, -6.70362711e-02f, -4.85713668e-02f, 4.39986512e-02f, -5.94725385e-02f, -3.30078937e-02f, 2.04306971e-02f, -4.63526230e-03f,
  3.61460373e-02f, -5.66273592e-02f, -2.12548934e-02f, -6.05592020e-02f, -9.75453779e-02f, 6.61717430e-02f, -6.88486695e-02f, -1.42666483e-02f, 3.27751599e-02f, 3.95795926e-02f,
  7.18378872e-02f, 1.73507221e-02f, 1.55887697e-02f, 4.23391536e-02f, -1.22191394e-02f, -1.59558095e-02f, -2.43072882e-02f, -7.83615410e-02f, 5.30871451e-02f, -6.08808026e-02f,
  2.59397621e-03f, -8.24577641e-03f, -7.47067556e-02f, 2.33705509e-02f, -9.42282658e-03f, -2.45034732e-02f, 1.78327989e-02f, 8.42250735e-02f, -2.01073084e-02f, -6.42061532e-02f,
  -3.84824350e-02f, -1.06434384e-02f, -2.26555970e-02f, -8.23539868e-02f, -1.62445987e-03f, -3.08521315e-02f, 9.01356488e-02f, 1.58506096e-03f, -5.73062571e-03f, 4.77223285e-02f,
  8.10958073e-02f, -2.80001126e-02f, 1.80936128e-01f, -2.97426172e-02f, -4.87316474e-02f, -7.51701221e-02f, 4.04202677e-02f, -4.85293716e-02f, -1.13302641e-01f, -9.23600867e-02f,
  -7.98750147e-02f, 8.04982800e-03f, -9.50736254e-02f, -5.89982010e-02f, 5.74924611e-02f, -6.32006228e-02f, -4.81450297e-02f, 8.43826856e-05f, 7.58306161e-02f, -5.48657663e-02f,
  3.81836481e-02f, -1.23529779e-02f, 7.80254081e-02f, 1.62766486e-01f, -8.26532096e-02f, 4.88144085e-02f, 9.61000919e-02f, 7.97503814e-03f, 1.83264494e-01f, 2.09784448e-01f,
  1.80636838e-01f, 1.82273567e-01f, -1.70719445e-01f, 1.50048852e-01f, 1.80095464e-01f, 1.89274505e-01f, 3.55694205e-01f, 2.74189949e-01f, 1.02595098e-01f, 1.13069363e-01f,
  -7.92241991e-02f, -1.36933520e-01f, -9.08080339e-02f, -1.68543398e-01f, 6.84020715e-03f, -1.82072427e-02f, -3.55869159e-02f, -1.02832101e-01f, -1.95400611e-01f, -6.23833314e-02f,
  1.06437698e-01f, 6.78024068e-02f, 6.52638376e-02f, -4.26416211e-02f, -5.96355796e-02f, -1.82158574e-01f, -1.34398416e-01f, 4.80134264e-02f, -1.32641464e-01f, -2.61327714e-01f,
  -3.25102061e-01f, 1.88782513e-01f, -1.64433509e-01f, -1.08284637e-01f, 1.48452520e-02f, -4.91463356e-02f, -6.61495933e-03f, -6.79934993e-02f, -4.50408161e-02f, -6.14329092e-02f,
  -1.00346074e-01f, 7.10569620e-02f, -2.28400566e-02f, 5.97929023e-02f, 2.85757575e-02f, 5.36785498e-02f, 8.58081877e-02f, -8.57677013e-02f, -1.17850997e-01f, 5.57442047e-02f,
  -7.58698806e-02f, 7.63438046e-02f, -4.21816297e-02f, 2.72326842e-02f, 3.20305303e-02f, -2.83575058e-02f, -1.54745113e-02f, -3.42778154e-02f, -1.16123863e-01f, 6.88398927e-02f,
  -5.12068495e-02f, -4.79216687e-02f, 1.77418385e-02f, 1.13568418e-02f, -1.24573736e-02f, -5.02865836e-02f, -1.59448269e-03f, -4.35630269e-02f, 3.89199294e-02f, -4.44377623e-02f,
  -2.15358790e-02f, -6.17722645e-02f, 3.44665535e-02f, -1.62308849e-03f, -5.57160862e-02f, 3.75899598e-02f, 3.05679701e-02f, 2.35226471e-02f, -3.99296358e-02f, 3.96577232e-02f,
  -4.15449403e-02f, -8.73863846e-02f, 3.33637297e-02f, -2.06380580e-02f, -3.04366499e-02f, -1.02544002e-01f, 4.56967354e-02f, -2.32872665e-02f, 6.07276037e-02f, 2.49223895e-02f,
  1.18068680e-01f, -4.86009344e-02f, 3.15779448e-02f, -2.07126345e-02f, 4.46377918e-02f, -3.80051918e-02f, -8.96980688e-02f, 9.15654656e-03f, -2.11225972e-02f, 2.69642659e-02f,
  -2.18332577e-02f, 5.67145087e-02f, 7.97196627e-02f, -5.67472279e-02f, -1.39139304e-02f, -2.47644708e-02f, 9.83793568e-03f, -8.26583877e-02f, -6.42900765e-02f, 5.02039865e-02f,
  5.30529991e-02f, 7.48902233e-03f, 9.66828242e-02f, 6.72469884e-02f, -1.85541883e-02f, -5.21014407e-02f, -5.66898063e-02f, -1.15334280e-02f, 7.44405538e-02f, 9.36159566e-02f,
  -1.22347577e-02f, -1.62869260e-01f, -2.08615586e-01f, -1.72251463e-01f, -1.72574013e-01f, -9.11143497e-02f, -2.79421449e-01f, -1.32744014e-01f, -4.88156304e-02f, -1.47435576e-01f,
  1.14775702e-01f, 8.87418613e-02f, 2.40521394e-02f, -5.63462712e-02f, -6.93174228e-02f, -1.77903652e-01f, -1.65502116e-01f, -5.31180063e-03f, -8.16311166e-02f, -1.00269072e-01f,
  -9.58383009e-02f, -5.86552247e-02f, -4.24955152e-02f, -7.93429464e-02f, -6.13588877e-02f, 3.94894648e-03f, -1.22399263e-01f, -9.65405405e-02f, -1.04343943e-01f, -5.43438457e-02f,
  6.30714521e-02f, -7.88031518e-02f, 6.18042387e-02f, 7.45000765e-02f, -4.29528244e-02f, 1.74612235e-02f, 4.48907204e-02f, -3.11550628e-02f, 2.23056949e-03f, -7.06018507e-02f,
  1.99031699e-02f, -4.01550196e-02f, -3.01570129e-02f, -3.08969673e-02f, -2.73522874e-03f, -2.24821288e-02f, -9.44403559e-02f, 2.15124413e-02f, -5.78552745e-02f, 1.52369728e-02f,
  -8.85225162e-02f, -1.10913359e-03f, -2.36982927e-02f, 3.34418230e-02f, -3.88988033e-02f, 3.30689512e-02f, 7.20378980e-02f, 3.21620367e-02f, -7.58159906e-02f, -8.76964554e-02f,
  -6.01003366e-03f, 7.41128027e-02f, 3.64675373e-02f, -3.35120820e-02f, 2.82406844e-02f, 4.03396487e-02f, -5.28284349e-02f, 1.97829250e-02f, -4.95029520e-03f, 8.39308724e-02f,
  5.52665330e-02f, -1.04366854e-01f, 5.62650748e-02f, -5.16964030e-03f, -1.38827311e-02f, -2.19714995e-02f, 2.15527024e-02f, -6.48750439e-02f, -3.13902609e-02f, -8.27016532e-02f,
  -7.38446414e-02f, 6.83886465e-03f, 7.78709166e-03f, 1.28451511e-02f, 4.58217859e-02f, -1.18661392e-02f, -3.03693302e-02f, -3.15997265e-02f, 6.25241473e-02f, -5.65646682e-03f,
  2.35679135e-01f, 3.34252492e-02f, 3.34914885e-02f, -2.59589441e-02f, -2.12812740e-02f, 1.10238721e-03f, -9.35733318e-03f, 9.05883312e-02f, 5.13262004e-02f, -8.87961313e-03f,
  -2.43933238e-02f, 6.43617660e-02f, -3.37204114e-02f, 5.77388778e-02f, -7.11835474e-02f, 6.55639470e-02f, -7.65604079e-02f, -2.61099823e-02f, 7.55759627e-02f, -6.50123209e-02f,
  -1.24749830e-02f, 4.79185693e-02f, 3.86916399e-02f, -1.79724693e-02f, 1.02110460e-01f, 2.21533980e-02f, 8.04012790e-02f, 3.79017964e-02f, 2.76257247e-02f, -2.13800464e-02f,
  2.67095894e-01f, 3.48927289e-01f, -6.99772984e-02f, -8.11275169e-02f, -1.45851844e-03f, -4.56274999e-03f, 1.27972871e-01f, -1.07479375e-02f, 4.34354208e-02f, 6.73534796e-02f,
  1.24185570e-01f, 3.30306105e-02f, -1.10822096e-01f, -9.15483478e-03f, -1.26424702e-02f, -4.02607657e-02f, -1.09984107e-01f, -1.82308644e-01f, -2.32348338e-01f, -8.87663141e-02f,
  -1.36621082e-02f, 6.70105442e-02f, -1.14719056e-01f, 4.43463847e-02f, 1.02133885e-01f, -5.56249209e-02f, -9.57068056e-02f, 3.32192220e-02f, 2.28968970e-02f, 1.44676134e-01f,
  -2.84105390e-02f, 2.61801958e-01f, -1.41215235e-01f, 1.97073678e-03f, 2.79875323e-02f, 1.67492777e-02f, 9.16464701e-02f, 2.11026296e-02f, 7.83013925e-03f, -6.38201227e-03f,
  -3.64458114e-02f, 4.53549623e-02f, 6.00450821e-02f, 3.64378728e-02f, 9.10558701e-02f, 1.56406201e-02f, -1.34139042e-02f, -5.03481030e-02f, -6.99324682e-02f, 1.72623828e-01f,
  5.01503795e-02f, 6.72761574e-02f, -3.79671082e-02f, 6.57491460e-02f, 9.46571231e-02f, -2.20140480e-02f, 1.23171553e-01f, 5.95301352e-02f, -7.67165720e-02f, 1.04740217e-01f,
  -5.35137132e-02f, -3.20168585e-02f, -4.61471677e-02f, 3.45249511e-02f, -2.35738084e-02f, -6.67049065e-02f, -4.07539569e-02f, 6.97907712e-03f, -3.41882883e-03f, 1.38796521e-02f,
  -4.56384420e-02f, 1.92859937e-02f, 5.31209596e-02f, -1.11439712e-02f, -5.55263534e-02f, 3.40257362e-02f, -4.36789840e-02f, 1.70083568e-02f, 6.54750317e-02f, 2.36397255e-02f,
  -3.21830846e-02f, 7.78080709e-03f, -7.03447834e-02f, 5.58315217e-02f, 1.19920745e-02f, -1.04677174e-02f, 3.26506533e-02f, 5.86431921e-02f, -1.85934659e-02f, 8.46603513e-02f,
  -2.41090618e-02f, -5.79810031e-02f, -2.56569106e-02f, -1.79279130e-02f, -6.07920028e-02f, 7.02294484e-02f, 1.52450204e-02f, -4.30399068e-02f, 6.42398596e-02f, 1.65838655e-02f,
  4.93410528e-02f, -3.53642926e-02f, 3.65324877e-02f, -5.14482893e-02f, -8.43495727e-02f, -2.24734703e-03f, -1.46233253e-02f, -1.70320272e-02f, 6.93455990e-03f, 3.62678617e-02f,
  -4.47266288e-02f, -8.12460855e-02f, -9.71829221e-02f, -5.81667013e-02f, -4.39115465e-02f, -7.69858733e-02f, -1.16888992e-01f, 3.27560380e-02f, -1.26261026e-01f, -8.71742219e-02f,
  -2.62138784e-01f, 5.13973907e-02f, 5.79549149e-02f, -1.15718301e-02f, 6.28385991e-02f, 3.16846445e-02f, -1.06409840e-01f, -6.34433329e-02f, -3.62371020e-02f, 3.78536363e-03f,
  2.79560219e-02f, 7.13466629e-02f, -5.67019545e-02f, 2.11791638e-02f, -1.42117545e-01f, -1.36630580e-01f, -6.84969267e-03f, -2.10716739e-01f, -1.23118564e-01f, -1.09976001e-01f,
  -1.11022748e-01f, -9.29807425e-02f, -1.95833877e-01f, -1.23879701e-01f, 1.77396983e-02f, 9.37089548e-02f, 5.57849519e-02f, 7.02639520e-02f, -2.12360173e-03f, 3.81173603e-02f,
  2.02425830e-02f, 1.02130972e-01f, -7.30431154e-02f, 4.60491190e-03f, 1.89628024e-02f, -5.62438788e-03f, -7.46413833e-03f, 6.10568598e-02f, -3.04370951e-02f, -2.41981428e-02f,
  -2.05843765e-02f, -1.76212583e-02f, 2.19308473e-02f, 3.83401401e-02f, -5.48347048e-02f, -1.29662633e-01f, -3.84749994e-02f, -5.73456772e-02f, 6.11072145e-02f, 9.91696864e-02f,
  -5.18055120e-03f, -5.59289381e-02f, 4.90411222e-02f, 1.57437455e-02f, 1.24947272e-01f, 5.31865209e-02f, -8.08281079e-03f, 1.30710572e-01f, 2.36021299e-02f, 6.77848235e-02f,
  -9.46086273e-03f, -7.71923084e-03f, 3.99115086e-02f, 8.47520158e-02f, -7.03495890e-02f, 7.46445060e-02f, -1.07838027e-02f, -4.04415503e-02f, -1.36815105e-02f, -2.45678797e-03f,
  5.88426702e-02f, 7.57010514e-03f, -1.58200115e-02f, -4.73125316e-02f, -5.84987216e-02f, 2.02577729e-02f, 3.22799310e-02f, 4.22715582e-02f, -5.32130934e-02f, -8.33943859e-02f,
  -4.94780904e-03f, 3.69465128e-02f, -3.87879275e-02f, 6.04984500e-02f, 9.94615257e-02f, 6.91476092e-02f, -5.85209578e-02f, 1.12941153e-02f, -2.33546942e-02f, -9.61687695e-03f,
  -2.41660159e-02f, -1.13872968e-01f, -7.87566230e-02f, -9.60639268e-02f, 4.39340472e-02f, -3.64290364e-02f, 4.37924303e-02f, 8.42672680e-03f, -4.23041731e-02f, -1.13638461e-01f,
  -2.14632414e-02f, -4.08089459e-02f, -6.13638125e-02f, -6.62051737e-02f, -9.09303054e-02f, -3.69396545e-02f, -5.13759330e-02f, -2.59912275e-02f, 2.12735534e-02f, 3.27757448e-02f,
  -4.89347652e-02f, -1.73881784e-01f, -7.95006827e-02f, -1.46877924e-02f, -6.29432499e-02f, -1.11789010e-01f, 2.81320009e-02f, -2.18080468e-02f, -3.11334729e-02f, -1.66026384e-01f,
  -3.47165555e-01f, -1.70564160e-01f, 2.02588096e-01f, 2.96519045e-02f, 1.68759719e-01f, 8.56371447e-02f, -6.10049302e-03f, -8.40346813e-02f, 5.93713671e-02f, -2.62803473e-02f,
  -1.70308813e-01f, -1.60876051e-01f, -1.15524724e-01f, -1.19648095e-04f, -1.80282131e-01f, 9.64851752e-02f, 1.80755898e-01f, 8.17028061e-02f, -9.15841088e-02f, -7.55167454e-02f,
  3.07502169e-02f, -1.03950754e-01f, -2.63660662e-02f, -5.63095324e-03f, 9.52864736e-02f, 1.25382423e-01f, 3.06779891e-02f, -3.81836891e-02f, -3.95547878e-03f, 1.14416681e-01f,
  9.39403027e-02f, -2.77153045e-01f, 1.24384977e-01f, -4.24030125e-02f, 8.05854723e-02f, -7.13423714e-02f, -1.55829247e-02f, 1.12879455e-01f, -5.67105459e-03f, -1.27069131e-02f,
  1.39081543e-02f, -1.81620885e-02f, 1.16617745e-02f, 5.96260950e-02f, 3.08062378e-02f, -7.09210187e-02f, -3.66130993e-02f, 1.23772901e-02f, -2.92933751e-02f, -9.88867227e-03f,
  -3.51425484e-02f, -7.49925375e-02f, -6.93959147e-02f, 6.54868186e-02f, -1.31014630e-01f, 1.30840847e-02f, -3.45012508e-02f, 1.24155935e-02f, 3.98585061e-03f, 4.23052683e-02f,
  6.48851693e-02f, 9.75482985e-02f, -4.38281372e-02f, -3.50481868e-02f, -1.55242998e-02f, 3.02047469e-03f, 8.93131923e-03f, -4.51473072e-02f, -5.90603724e-02f, -3.13382819e-02f,
  -3.92266400e-02f, -2.65826397e-02f, -3.57783362e-02f, 8.51580426e-02f, 3.32199559e-02f, -4.76181768e-02f, -7.79295564e-02f, -3.19988392e-02f, 3.61652090e-03f, 6.09693751e-02f,
  -3.42232399e-02f, -8.83118156e-03f, 4.26373333e-02f, -1.84793808e-02f, 4.63831127e-02f, 2.09978055e-02f, -4.28737514e-02f, 3.15478854e-02f, -3.13689038e-02f, 4.16941904e-02f,
  8.41646940e-02f, -7.11146519e-02f, 4.06251773e-02f, -1.19729415e-01f, 6.36271313e-02f, 2.90423185e-02f, -3.32890674e-02f, -7.10505396e-02f, 4.46213745e-02f, 3.24098654e-02f,
  -1.10924833e-01f, -4.77768928e-02f, -9.45061166e-03f, -2.45607514e-02f, 7.81914070e-02f, -2.03743875e-02f, -5.78540552e-04f, -6.09606430e-02f, 2.74852500e-03f, 2.26435792e-02f,
  -4.11774255e-02f, 2.95783952e-02f, 8.88942704e-02f, -1.28586981e-02f, 4.97140642e-03f, -3.10716443e-02f, 1.25082701e-01f, 1.04429185e-01f, -2.44489382e-03f, 1.51259243e-01f,
  3.54302153e-02f, -1.21827483e-01f, -2.56069601e-01f, -4.94678132e-02f, -1.80229828e-01f, -2.20029056e-01f, -2.80510843e-01f, -6.20860048e-02f, -7.79358521e-02f, -2.54230332e-02f,
  -4.00080122e-02f, 2.31910303e-01f, 2.03823522e-01f, 2.03132018e-01f, 4.32421081e-02f, -2.10273892e-01f, -9.08963457e-02f, 2.65824832e-02f, 1.13370039e-01f, 1.66682839e-01f,
  9.63966846e-02f, 1.75868690e-01f, 8.39984789e-02f, 1.31123543e-01f, -9.12385061e-03f, 1.14594564e-01f, -1.02515951e-01f, -6.75533190e-02f, -5.88015281e-02f, 1.24054044e-01f,
  7.10670948e-02f, -1.64067835e-01f, 9.55977738e-02f, 8.01374912e-02f, 1.43764224e-02f, 4.15424409e-04f, 4.21515740e-02f, 3.97514179e-02f, -2.79161595e-02f, 4.52568829e-02f,
  4.52575982e-02f, 2.68958416e-02f, -3.85750569e-02f, 5.97665794e-02f, 2.15151962e-02f, -7.52772531e-03f, 4.15614322e-02f, -6.95304340e-03f, -7.64692649e-02f, -3.17877680e-02f,
  7.66587406e-02f, -6.75991476e-02f, -1.62632167e-01f, -3.70076261e-02f, -2.44106911e-02f, 5.77890202e-02f, -9.35033243e-03f, 8.49661604e-02f, -9.34895650e-02f, 7.38193840e-02f,
  9.74674150e-03f, -3.19847241e-02f, 1.66930945e-03f, 5.76299764e-02f, 4.06484492e-02f, -7.91562498e-02f, 3.15620527e-02f, -1.38419233e-02f, 3.38500254e-02f, 3.70988995e-02f,
  4.10040468e-03f, -8.42243712e-03f, -2.47980878e-02f, 4.22271863e-02f, 3.25133726e-02f, -8.03244710e-02f, -3.55984680e-02f, -9.21289809e-03f, -5.65029904e-02f, -4.44879457e-02f,
  8.02339148e-03f, -8.65786001e-02f, 5.71609400e-02f, 2.06741504e-02f, 2.76497677e-02f, 7.61960521e-02f, -5.15034124e-02f, -1.71610974e-02f, -1.98646579e-02f, 6.01656735e-02f,
  2.64306843e-01f, -5.74251078e-02f, -4.75163497e-02f, 8.94416415e-04f, -1.03619657e-01f, 4.15051952e-02f, 5.04646040e-02f, 4.70411256e-02f, 2.29439509e-04f, 3.57213616e-02f,
  4.56458218e-02f, 9.90563817e-03f, 3.01961247e-02f, 6.41367659e-02f, 2.59554051e-02f, 6.82348087e-02f, -2.96840034e-02f, -2.77489815e-02f, -7.90754706e-03f, -5.36192693e-02f,
  -4.26176861e-02f, -1.20319955e-01f, 6.39350899e-03f, -1.88820660e-02f, -5.45622781e-03f, -4.09661718e-02f, -4.48376648e-02f, 4.55104522e-02f, -7.43158683e-02f, -8.72895569e-02f,
  2.06956968e-01f, 4.22298402e-01f, 1.77944973e-01f, 1.87086463e-01f, 6.07039370e-02f, 1.04481436e-01f, 1.28336251e-01f, -4.18492738e-04f, 3.21062692e-02f, 8.45373273e-02f,
  -9.70705412e-03f, -2.47706641e-02f, 3.31852511e-02f, -1.32403806e-01f, 7.85109177e-02f, 2.07392722e-01f, 2.44017810e-01f, -6.88122362e-02f, -1.43308744e-01f, -1.52038828e-01f,
  -3.13676707e-03f, 3.09675001e-02f, -8.31306800e-02f, -3.76739949e-02f, 1.02656223e-01f, 5.87943755e-02f, 1.57645240e-01f, -3.19600664e-03f, 5.37738088e-04f, 1.66010156e-01f,
  -3.54644991e-02f, 1.93767071e-01f, -1.86654121e-01f, -5.76379634e-02f, 4.00852747e-02f, -2.42369995e-02f, 9.74112190e-03f, -9.14110914e-02f, 3.70094962e-02f, -6.20030873e-02f,
  4.62976545e-02f, -4.21197675e-02f, 2.27468759e-02f, -5.72424233e-02f, -1.40560511e-02f, -1.11784346e-01f, 6.36208802e-02f, -1.12020094e-02f, 2.30322704e-02f, 4.49609980e-02f,
  1.00909203e-01f, 1.10471472e-01f, 2.16256231e-02f, -5.23667447e-02f, 7.88657781e-05f, -8.67395923e-02f, -4.73731831e-02f, 3.61790322e-02f, -3.28634866e-02f, 1.71655446e-01f,
  3.93422358e-02f, 2.19888203e-02f, -4.02348721e-03f, 2.31311116e-02f, 3.70288417e-02f, -5.80684729e-02f, 9.06791771e-04f, 1.64969712e-02f, 5.12944572e-02f, -1.08029181e-02f,
  1.25700766e-02f, -7.78820598e-04f, -2.58333609e-03f, 2.42146663e-02f, 3.53867039e-02f, 4.13474347e-03f, 1.59062954e-04f, 1.50833484e-02f, 1.03275739e-02f, -1.17270397e-02f,
  -2.01719701e-02f, 1.61762647e-02f, 4.55196351e-02f, 5.50320186e-02f, 5.03004566e-02f, 5.34324013e-02f, -7.35850781e-02f, -6.31487817e-02f, -3.69106159e-02f, 5.51233590e-02f,
  -2.19346672e-01f, -1.30753785e-01f, 6.56656250e-02f, 2.99852062e-02f, 3.35740013e-04f, 3.05277351e-02f, 3.35113592e-02f, 1.38462028e-02f, -1.03408042e-02f, 4.43995893e-02f,
  2.92866342e-02f, -3.50085683e-02f, 9.31490064e-02f, 3.27628455e-03f, -1.32665038e-01f, -9.23591629e-02f, 7.29761645e-02f, 4.83417287e-02f, -4.12622355e-02f, 3.73233259e-02f,
  1.27351969e-01f, -4.85962890e-02f, -1.18893310e-01f, -9.73070115e-02f, -1.38058821e-02f, -8.18933100e-02f, -4.62016724e-02f, -1.36717260e-01f, -1.11354284e-01f, -2.75445394e-02f,
  2.51889408e-01f, -4.07648757e-02f, 2.74158180e-01f, 9.49210674e-02f, 1.44182453e-02f, -5.89446425e-02f, -6.75636530e-02f, -1.18809626e-01f, -1.29653335e-01f, -6.75384933e-03f,
  3.91188264e-02f, -9.30350572e-02f, 3.83932255e-02f, 4.16301005e-02f, -4.65204827e-02f, -6.49194717e-02f, 1.28270507e-01f, 2.07095608e-01f, 4.27498668e-02f, 1.04418071e-03f,
  4.90272678e-02f, 6.55349270e-02f, 1.81996137e-01f, 4.22269851e-02f, 2.14790720e-02f, -2.62266882e-02f, 3.63046899e-02f, 1.76481292e-01f, 1.45870040e-03f, 8.33841488e-02f,
  -2.88917385e-02f, 2.69744784e-01f, -4.65503298e-02f, 5.93830645e-02f, 7.12432317e-04f, 5.03037833e-02f, -6.01231605e-02f, -3.24346535e-02f, -4.46999148e-02f, 8.47790539e-02f,
  1.07880995e-01f, 4.50878963e-02f, 5.17670717e-03f, 1.94241535e-02f, -2.19701417e-02f, -2.85202134e-02f, 6.63155541e-02f, 9.31892842e-02f, 3.81032787e-02f, 7.29874969e-02f,
  3.83207127e-02f, 5.49317561e-02f, 4.86428924e-02f, 9.29857790e-03f, 7.24307373e-02f, 7.11796209e-02f, -5.97875677e-02f, -4.54061441e-02f, 2.74969973e-02f, -1.58371590e-02f,
  -6.12197891e-02f, -4.55464907e-02f, 2.74283215e-02f, -7.52857774e-02f, -6.16875514e-02f, -9.18176174e-02f, 3.14912461e-02f, -2.81590968e-02f, -4.05834131e-02f, 1.66199859e-02f,
  2.08824258e-02f, 1.13423448e-02f, -4.77784276e-02f, 4.03139330e-02f, -4.66091298e-02f, 1.00829408e-01f, 2.77975909e-02f, -6.46614507e-02f, 4.92836274e-02f, -5.45178801e-02f,
  5.59186423e-03f, 2.71193553e-02f, 4.00915407e-02f, -3.20532434e-02f, -8.83423910e-03f, 1.09273188e-01f, 3.76863442e-02f, 2.78034881e-02f, -6.50206432e-02f, 1.84171833e-02f,
  -1.66642383e-01f, -1.26064187e-02f, -2.22046152e-02f, -7.20214546e-02f, -2.79813427e-02f, -1.12276478e-02f, 1.86240934e-02f, 2.12907195e-02f, -1.45136705e-02f, 4.75975499e-03f,
  -3.83787230e-02f, 7.97559470e-02f, 6.02703057e-02f, -7.31205717e-02f, 4.04761769e-02f, 3.63918114e-03f, 4.90288716e-03f, -2.22144998e-04f, 1.38568133e-03f, -7.57000521e-02f,
  -1.10235512e-01f, -3.46185826e-02f, -6.69582337e-02f, -8.60775337e-02f, -1.35172680e-01f, -6.59286976e-02f, -4.08859737e-02f, -5.68347499e-02f, 2.16330383e-02f, -1.10493705e-01f,
  -1.20869756e-01f, -1.48823053e-01f, -1.75524294e-01f, 1.36794850e-01f, 1.01047002e-01f, -8.92596990e-02f, -8.69213231e-03f, -6.14898689e-02f, 1.27903759e-01f, -7.65705295e-03f,
  5.26306219e-02f, 1.89370215e-01f, 1.21278921e-02f, 1.39402477e-02f, -2.08735913e-02f, -1.57286990e-02f, 7.49704838e-02f, 3.15394700e-02f, -1.07548714e-01f, 5.32638542e-02f,
  8.40316489e-02f, 1.22507766e-01f, -9.32391658e-02f, 2.45196540e-02f, 1.88832387e-01f, 1.46261528e-01f, -2.30994308e-03f, -6.84215948e-02f, -3.53998318e-02f, 1.66713551e-01f,
  -2.01539069e-01f, -2.01771468e-01f, 6.09185696e-02f, 9.14106518e-03f, -6.28445018e-03f, -8.95612165e-02f, -6.18991479e-02f, -7.40850940e-02f, 5.53382188e-02f, -7.96817839e-02f,
  -3.65616307e-02f, 6.12111203e-02f, 1.05310060e-01f, 3.49278674e-02f, 1.38647603e-02f, 3.90214920e-02f, -5.28712533e-02f, -1.23088323e-01f, -1.22613892e-01f, -5.60766235e-02f,
  1.28188491e-01f, -8.95728618e-02f, -3.53765488e-02f, 5.28501011e-02f, -7.04221576e-02f, 2.45300103e-02f, -1.43631548e-01f, 6.92898035e-03f, -1.29314959e-01f, -6.07553348e-02f,
  -2.87467353e-02f, -2.26728339e-02f, -4.84873308e-03f, 3.74309346e-02f, -2.50690691e-02f, 4.36818227e-02f, -4.93290387e-02f, 1.00265138e-01f, -3.58438827e-02f, 6.38872907e-02f,
  2.99064256e-02f, -5.10668792e-02f, -3.28538790e-02f, -4.86003421e-03f, 7.32420161e-02f, -4.56572659e-02f, 2.87903808e-02f, 3.25329937e-02f, -5.98586351e-02f, -2.93786637e-03f,
  -5.01274951e-02f, -4.72680330e-02f, -3.98885347e-02f, 9.22227874e-02f, 4.09015156e-02f, 2.67555583e-02f, 5.87100238e-02f, 5.09881265e-02f, 1.23365102e-02f, 8.97217542e-02f,
  6.52213469e-02f, -2.15591237e-01f, 9.96193066e-02f, 6.97819563e-03f, -1.31363422e-02f, -1.38222268e-02f, -5.87211270e-03f, 1.43152336e-02f, -7.25330114e-02f, 2.82974858e-02f,
  -2.94515900e-02f, -1.51054328e-02f, -1.11984633e-01f, 5.05214892e-02f, 5.55694140e-02f, -1.80295985e-02f, 9.44666192e-02f, -5.87495015e-05f, 2.99680214e-02f, -9.58019048e-02f,
  1.19732484e-01f, -5.83039150e-02f, -5.92893921e-02f, -8.03892910e-02f, -9.18988977e-03f, -1.58968531e-02f, 2.48785112e-02f, 7.06834793e-02f, -7.96928704e-02f, 9.34392363e-02f,
  -2.08970129e-01f, -9.52616110e-02f, 1.35823861e-01f, -6.32582009e-02f, 8.08259323e-02f, 1.74284294e-01f, 4.68971319e-02f, -5.91795631e-02f, 4.78547364e-02f, -9.79616195e-02f,
  -4.26720083e-02f, -1.04337767e-01f, -3.88640426e-02f, 2.35476792e-02f, 9.29296389e-03f, -3.16051170e-02f, 1.17969893e-01f, 5.39436862e-02f, 2.31557176e-01f, 9.79179516e-02f,
  -4.58915867e-02f, 7.92764798e-02f, -3.56013998e-02f, 3.87793668e-02f, 1.63047444e-02f, 3.89746949e-02f, 5.07035963e-02f, 1.37124285e-01f, 8.77317190e-02f, 5.45453094e-02f,
  8.85502696e-02f, -2.05091149e-01f, 1.57927319e-01f, 3.95597331e-02f, 1.04369946e-01f, -9.60912332e-02f, -9.98529345e-02f, -2.81374380e-02f, 3.46217826e-02f, -8.58450085e-02f,
  9.35871378e-02f, 7.40156919e-02f, 8.18112046e-02f, 8.18041489e-02f, -6.72174171e-02f, -4.68605803e-03f, -8.45815018e-02f, 6.69920594e-02f, -3.46999876e-02f, 3.90088670e-02f,
  -5.45303430e-03f, 8.68393704e-02f, -6.06782772e-02f, 8.20742846e-02f, -5.85453324e-02f, 1.09040841e-01f, 1.71995163e-02f, -3.51318382e-02f, -4.62245904e-02f, -9.85107645e-02f,
  4.03055586e-02f, 1.11854654e-02f, 4.17490825e-02f, 9.99683887e-03f, -4.51070927e-02f, -1.96365509e-02f, 6.49350137e-02f, 1.00078909e-02f, 9.51434001e-02f, 2.06742696e-02f,
  -6.89134523e-02f, -2.87695732e-02f, -6.78431010e-03f, 2.23079603e-02f, 1.97511096e-03f, 8.70086998e-03f, 6.03536256e-02f, -8.23801756e-02f, 5.11319228e-02f, -3.04240398e-02f,
  8.42546001e-02f, 8.28602072e-03f, -2.27627046e-02f, 5.95274828e-02f, -4.40341234e-02f, -1.12079140e-02f, -1.26206339e-03f, -6.67776391e-02f, 2.94018630e-02f, -4.47021164e-02f,
  -3.94431688e-02f, -2.90145469e-03f, -1.05269559e-01f, 8.06033146e-03f, 1.13287635e-01f, -7.11505190e-02f, -6.91700950e-02f, 1.69221088e-02f, 2.38207150e-02f, -4.07971963e-02f,
  -8.96525681e-02f, -5.08713685e-02f, 2.83277854e-02f, 6.43197447e-02f, 1.01293631e-01f, 7.16475397e-02f, -9.04165059e-02f, 8.68022367e-02f, -7.41138682e-02f, 3.58673111e-02f,
  -1.72125362e-02f, 3.93655375e-02f, -1.62172858e-02f, -2.65633110e-02f, 6.42853752e-02f, 4.39901091e-02f, 1.46195274e-02f, 3.84543128e-02f, 8.69289339e-02f, -1.33321360e-01f,
  -3.01964022e-02f, 2.29565591e-01f, -4.98318896e-02f, 4.86803204e-02f, -3.03673744e-02f, 1.37947038e-01f, 2.57582605e-01f, 6.22404926e-02f, -8.72109435e-04f, 5.81951030e-02f,
  -1.38541982e-01f, -1.31702274e-01f, -3.24552245e-02f, 6.01452887e-02f, 4.84996140e-02f, 2.45323300e-01f, 1.39939576e-01f, 2.42167898e-02f, 7.66911637e-03f, 1.58406477e-02f,
  1.50237903e-01f, 3.72870564e-02f, -2.78363507e-02f, 1.09215498e-01f, -4.19666804e-03f, -7.70422965e-02f, 1.22835888e-02f, 8.37252736e-02f, -7.70489313e-03f, 2.19272912e-01f,
  1.83072444e-02f, -6.66523427e-02f, 1.83330216e-02f, -9.60070863e-02f, -1.62890434e-01f, 5.02030440e-02f, 4.70589958e-02f, -2.31897049e-02f, -1.41250538e-02f, 2.82714074e-03f,
  -7.93258660e-03f, -3.86654772e-02f, -2.79790927e-02f, -3.94182876e-02f, -5.12180775e-02f, -8.73402357e-02f, 7.17280656e-02f, 7.69218132e-02f, 3.18379439e-02f, 1.20746270e-02f,
  4.98485155e-02f, -4.85955626e-02f, -7.41042569e-02f, -5.12247942e-02f, 2.49510426e-02f, -1.04368590e-01f, 3.42163034e-02f, 6.65327385e-02f, -6.62940294e-02f, 8.71228650e-02f,
  4.47513908e-02f, 6.33693999e-03f, 1.08157396e-02f, 1.39895119e-02f, -5.14324680e-02f, 1.28184250e-02f, 3.01602539e-02f, 5.77818789e-03f, 4.09559347e-02f, -8.48287791e-02f,
  1.05743762e-02f, -6.23970255e-02f, 4.93122265e-02f, 3.99206690e-02f, -3.28267664e-02f, 8.14264119e-02f, 8.38221237e-02f, 6.17426522e-02f, -1.51287876e-02f, -7.21697733e-02f,
  -5.19024134e-02f, -9.91175324e-03f, -1.34176966e-02f, 1.48872603e-02f, 3.97506766e-02f, -7.48710427e-03f, 8.11488647e-03f, -5.65102026e-02f, -1.54272392e-02f, -2.60524917e-02f,
  -1.05753668e-01f, -1.66225448e-01f, -2.20107175e-02f, -5.68556897e-02f, 5.96994236e-02f, -4.96281832e-02f, 2.63443440e-02f, -5.36066182e-02f, -1.04911095e-02f, 5.20088486e-02f,
  -1.02605246e-01f, -1.27627561e-02f, -4.47988883e-02f, 6.98649045e-03f, 6.24652505e-02f, 4.28283066e-02f, 1.97264235e-02f, 6.25659227e-02f, -1.81632652e-03f, 3.95684950e-02f,
  2.90965289e-02f, 7.15982988e-02f, -2.37596687e-03f, 8.99815708e-02f, 4.40170206e-02f, -3.24243195e-02f, -4.47262563e-02f, -7.17736855e-02f, 6.46299571e-02f, 1.88394427e-01f,
  7.48252496e-02f, -1.39114186e-01f, -4.13089871e-01f, -9.47914198e-02f, -1.02384321e-01f, -8.51536766e-02f, -7.51405722e-03f, 6.14313670e-02f, 1.00732774e-01f, -1.07416615e-01f,
  1.83172431e-02f, -5.43795265e-02f, 1.26303500e-02f, -7.37628788e-02f, 2.84554120e-02f, -6.16084151e-02f, -1.57216579e-01f, -1.11060068e-01f, -1.44052627e-02f, 4.45480943e-02f,
  3.28281038e-02f, -4.84009981e-02f, -3.01525407e-02f, 8.58408436e-02f, -1.40503347e-01f, -1.25928417e-01f, -2.07745418e-01f, -1.09703161e-01f, -8.90124813e-02f, -9.64420661e-02f,
  -3.34088326e-01f, 8.71068984e-02f, 4.66976576e-02f, 1.01387002e-01f, -1.63526356e-01f, 8.17439780e-02f, 2.09087320e-02f, 7.08561093e-02f, -1.96390413e-02f, 1.60474516e-02f,
  4.24015243e-03f, 5.16447518e-03f, 4.68335710e-02f, -7.30583742e-02f, 9.26441252e-02f, 2.43805069e-02f, 6.23165146e-02f, 8.51138160e-02f, -4.29789051e-02f, 6.54854253e-02f,
  -3.37589905e-03f, 7.24349692e-02f, -1.46295149e-02f, 3.57513539e-02f, -3.83799779e-03f, -8.02786276e-02f, -1.98715497e-02f, 1.08072311e-01f, 1.29221335e-01f, -1.16750099e-01f,
  2.55831629e-02f, -8.58367160e-02f, 6.79262206e-02f, 5.03512211e-02f, 1.83062050e-02f, 4.15783795e-03f, -1.56816037e-03f, -6.38853386e-02f, -3.21261212e-02f, 1.18581196e-02f,
  -9.10194125e-03f, -8.74680951e-02f, -4.99468520e-02f, 5.07152528e-02f, -2.36637983e-03f, -3.00554391e-02f, 7.02843517e-02f, 4.74044867e-02f, -3.59085426e-02f, -2.34015323e-02f,
  3.33213322e-02f, 2.53318362e-02f, -3.54968905e-02f, 8.72734934e-02f, -1.43733183e-02f, -6.27433583e-02f, 5.23898415e-02f, 3.51276412e-03f, -2.61367690e-02f, -1.77356675e-02f,
  -7.33058900e-02f, 2.33603008e-02f, -1.86063588e-01f, 1.10486284e-01f, -1.28321284e-02f, -4.03089933e-02f, -1.12588987e-01f, -4.68088798e-02f, 9.02882591e-03f, -5.22311777e-02f,
  6.18375354e-02f, -6.63839979e-04f, -6.66839406e-02f, -5.25772534e-02f, -1.27969719e-02f, -1.73379425e-02f, 7.67042488e-02f, -1.94724109e-02f, 8.71234089e-02f, -1.58495307e-02f,
  -4.96834107e-02f, -3.86099927e-02f, 2.26869918e-02f, -5.53147011e-02f, 9.12181512e-02f, 4.85221222e-02f, -3.30922492e-02f, -6.00174516e-02f, -2.73268837e-02f, -5.03953770e-02f,
  -1.19629420e-01f, -1.20947830e-01f, 1.11001926e-02f, -5.78307956e-02f, -7.70251527e-02f, 6.20000204e-03f, 2.53792610e-02f, -1.91655327e-02f, -1.87984016e-02f, 1.67980343e-02f,
  1.50105894e-01f, 1.89311638e-01f, 1.68885395e-01f, 8.00390095e-02f, 7.90869668e-02f, 1.58019923e-02f, 7.07759634e-02f, 3.67098041e-02f, 6.45373166e-02f, -1.53611647e-02f,
  2.67983079e-02f, -9.54628587e-02f, -1.05280764e-01f, -9.72688571e-02f, -1.31000072e-01f, 9.08782408e-02f, -7.80706257e-02f, -4.14717458e-02f, 1.27122551e-02f, 1.55854560e-02f,
  -1.48199946e-01f, -8.69105980e-02f, 1.62617236e-01f, 1.39576271e-01f, -2.40389053e-02f, -9.30117071e-03f, 6.15689121e-02f, 2.41026040e-02f, -1.61516853e-02f, -1.34675046e-02f,
  6.71886876e-02f, 1.45650329e-02f, -2.72078402e-02f, -8.79508182e-02f, -1.05106980e-01f, -1.01054616e-01f, 4.90400866e-02f, 4.46426459e-02f, -8.32325686e-03f, -7.49285659e-03f,
  8.21941793e-02f, 3.21419947e-02f, -4.53471541e-02f, 6.00364059e-02f, -7.56293908e-03f, 1.46909013e-01f, -9.36416015e-02f, -5.59346415e-02f, -4.97650728e-02f, -1.01703420e-01f,
  -7.17858179e-03f, 9.42789018e-03f, 2.77057081e-03f, -4.75019179e-02f, 4.57273498e-02f, 3.65079865e-02f, 7.39181563e-02f, -8.85773078e-02f, -7.80825391e-02f, -1.04269058e-01f,
  4.58512492e-02f, -6.34440454e-03f, 7.34832659e-02f, -5.56345508e-02f, 3.40629881e-03f, 3.81400399e-02f, 1.00585975e-01f, 3.91405374e-02f, -1.19976141e-02f, -5.27621843e-02f,
  1.93661172e-02f, -4.72451039e-02f, -6.69967309e-02f, -2.19452530e-02f, 1.22997239e-01f, -2.61257752e-03f, -8.43327213e-03f, 9.80693288e-03f, 9.34576169e-02f, -8.04338157e-02f,
  -7.84271285e-02f, 3.12827915e-01f, 6.47385372e-03f, 1.54611105e-02f, -9.33769271e-02f, -4.58645256e-04f, -3.49104255e-02f, 3.79506424e-02f, 6.00397848e-02f, -9.42253172e-02f,
  1.84181686e-02f, 2.21898146e-02f, -3.74391787e-02f, -7.59173259e-02f, -7.77439699e-02f, 3.96691300e-02f, -2.39528138e-02f, 3.12131587e-02f, 1.13599479e-01f, -4.18914072e-02f,
  1.08229876e-01f, 5.24875112e-02f, 3.74126136e-02f, 6.48181140e-02f, -3.56578119e-02f, 1.33029029e-01f, -5.62748909e-02f, -8.83188695e-02f, 1.98183637e-02f, -4.24497053e-02f,
  -2.56087244e-01f, -4.16579098e-02f, 6.12295009e-02f, -6.65925257e-03f, 1.18638404e-01f, 2.94746876e-01f, 2.62136519e-01f, 1.31721467e-01f, -4.27305102e-02f, 8.41077715e-02f,
  6.12928942e-02f, 7.76242092e-03f, 4.63180281e-02f, 4.46079262e-02f, -1.59684867e-02f, 1.19828716e-01f, -4.08350155e-02f, -1.57568365e-01f, -1.23162813e-01f, 2.79002506e-02f,
  -6.84010312e-02f, -1.45319507e-01f, -2.58511394e-01f, -1.67082682e-01f, -1.24798305e-01f, 3.68124694e-02f, -6.26898021e-04f, -1.63387954e-01f, 5.45531847e-02f, -2.38716155e-01f,
  1.00613959e-01f, 6.98161498e-03f, 7.39351660e-02f, -9.75473225e-03f, -5.31060062e-02f, -2.84971390e-03f, -2.57408526e-02f, -1.31423309e-01f, 5.55953421e-02f, 4.34474498e-02f,
  -5.95699158e-03f, -9.19572338e-02f, -3.94520871e-02f, -8.44829902e-02f, -6.13985918e-02f, 8.87714401e-02f, -1.46988869e-01f, -8.45986679e-02f, -9.67786908e-02f, 3.17905508e-02f,
  1.21457251e-02f, -4.82188761e-02f, 7.07049435e-03f, -8.14381521e-03f, -1.52026489e-02f, -3.59965973e-02f, -5.48375063e-02f, 7.69582167e-02f, 5.83521836e-02f, -1.47123471e-01f,
  -4.18833010e-02f, 2.52564698e-02f, -1.64730474e-02f, 2.44743819e-03f, -4.73738536e-02f, 6.53886646e-02f, 1.00966198e-02f, 6.26466423e-03f, 4.40123044e-02f, -5.38209863e-02f,
  9.85956285e-03f, 8.44645426e-02f, -4.78356751e-03f, 1.25358533e-02f, -1.91740431e-02f, 6.77260011e-02f, -5.06214499e-02f, 2.20530983e-02f, -4.38945852e-02f, -2.37088334e-02f,
  2.97670271e-02f, 6.02343539e-03f, 1.15316350e-03f, -1.04531482e-01f, -7.49018267e-02f, 3.57455239e-02f, 3.95427644e-02f, 1.45100839e-02f, 4.06758860e-02f, -6.18780404e-02f,
  -7.20421225e-02f, 6.00268766e-02f, -1.66366920e-02f, -7.94918090e-02f, -1.95655338e-02f, -6.85790181e-02f, -4.62657660e-02f, 7.36047560e-03f, -5.51182451e-03f, -5.22352532e-02f,
  4.26913649e-02f, -1.98173132e-02f, 9.44468006e-03f, -2.23355684e-02f, -4.02237959e-02f, -1.98701955e-02f, 7.74210505e-03f, 5.76258488e-02f, 7.99910873e-02f, 2.42072549e-02f,
  9.73129366e-03f, 1.18033811e-01f, 1.53687730e-01f, 1.58984333e-01f, 1.54063534e-02f, 1.58458501e-01f, 9.60143190e-03f, 1.42867744e-01f, 7.34779462e-02f, -4.37572561e-02f,
  2.32141808e-01f, -4.68105115e-02f, 2.05729336e-01f, -1.73710778e-01f, -4.41463925e-02f, 1.70085147e-01f, 2.66249508e-01f, 6.43098876e-02f, -5.20472750e-02f, 3.77854779e-02f,
  -1.28184959e-01f, 1.38228352e-03f, 2.75805872e-02f, 1.00941602e-02f, 1.92045018e-01f, 1.95501391e-02f, 1.02491066e-01f, 2.29249112e-02f, 9.92149189e-02f, 6.59780428e-02f,
  -1.81168333e-01f, -1.79391310e-01f, 8.17567296e-03f, -2.15355866e-02f, -1.96962371e-01f, -1.24868378e-01f, 2.58256719e-02f, -4.38034050e-02f, -8.09924528e-02f, -1.34727433e-01f,
  1.21518470e-01f, 4.70486991e-02f, 2.35426165e-02f, -5.61428033e-02f, -6.57555535e-02f, 2.88511701e-02f, 6.76091909e-02f, -3.31411436e-02f, -3.20623368e-02f, -3.89692672e-02f,
  -3.43895964e-02f, 3.82710248e-02f, -6.96777403e-02f, -6.65894970e-02f, -4.32845838e-02f, -1.15104010e-02f, 3.10828947e-02f, 1.76471192e-03f, 8.82111639e-02f, -6.43874258e-02f,
  -2.26867765e-01f, -1.27612248e-01f, 1.52733669e-01f, 8.82292837e-02f, 4.39570136e-02f, 5.75976707e-02f, 7.07566440e-02f, -6.56612217e-02f, 1.29574031e-01f, 2.32490264e-02f,
  -3.52079906e-02f, 3.97913456e-02f, 2.62374822e-02f, -1.57495830e-02f, 1.94475017e-02f, 1.87093262e-02f, 5.15446626e-03f, -1.61931962e-02f, 5.23170754e-02f, -4.36485074e-02f,
  -2.71176565e-02f, 6.87126666e-02f, -2.12018639e-02f, -3.01041808e-02f, -5.05741127e-02f, -5.57827726e-02f, -2.12084353e-02f, -9.59621277e-03f, 2.86284909e-02f, 6.43408746e-02f,
  -3.81582491e-02f, 3.82678322e-02f, -7.67067820e-02f, -2.07979623e-02f, 3.33189182e-02f, 6.73597902e-02f, -1.26062231e-02f, 9.80806500e-02f, -2.35486384e-02f, 4.71347906e-02f,
  -4.17848229e-02f, 6.39765859e-02f, 8.08604807e-02f, 4.73097675e-02f, -4.45104092e-02f, 8.00816249e-03f, -1.73611846e-02f, -2.75951740e-03f, 3.51123996e-02f, 1.06396668e-01f,
  3.35892737e-02f, 1.43307215e-02f, 2.55437233e-02f, -6.94209412e-02f, 8.45888406e-02f, 2.17650328e-02f, -7.50786141e-02f, -2.08985247e-03f, -1.03419553e-02f, 2.90853390e-03f,
  1.68651156e-03f, 1.11346528e-01f, 1.66397616e-01f, 8.25687125e-02f, 6.90765306e-02f, 1.87390491e-01f, 1.90201774e-01f, 1.83676422e-01f, 2.57873476e-01f, 1.65470079e-01f,
  -2.05631986e-01f, -1.99432418e-01f, -3.03691924e-01f, -3.16118956e-01f, -1.90813422e-01f, -2.44733796e-01f, -2.07142830e-01f, -3.38843428e-02f, -1.36085212e-01f, -2.02726275e-01f,
  -9.24211815e-02f, -1.06196962e-02f, 5.57593405e-02f, -4.32424434e-02f, -9.95521694e-02f, -2.00278431e-01f, -2.80938566e-01f, -1.74682051e-01f, -1.01539813e-01f, -1.09498121e-01f,
  -1.65268973e-01f, -2.19882041e-01f, -1.90972462e-01f, -1.14150964e-01f, -7.23148286e-02f, -9.28763598e-02f, -1.35042399e-01f, -1.76959217e-01f, 1.10144233e-02f, -1.13112159e-01f,
  -1.82974041e-01f, -1.14826836e-01f, 1.27960101e-01f, 1.56357288e-02f, 1.32836215e-03f, -3.29343155e-02f, -1.09290220e-01f, 7.43750334e-02f, -3.66146900e-02f, 3.13626453e-02f,
  8.48630294e-02f, 1.07554585e-01f, 9.66817811e-02f, -1.38121219e-02f, 5.00651784e-02f, -2.31445059e-02f, -3.57867144e-02f, 1.75838973e-02f, -4.18889746e-02f, -4.75639366e-02f,
  7.13710785e-02f, -6.27104491e-02f, 4.15553823e-02f, 1.39958337e-01f, -2.39825472e-02f, 1.35332555e-01f, 1.29691049e-01f, -1.51267489e-02f, 4.41614389e-02f, -3.58405299e-02f,
  7.87968859e-02f, 1.68003812e-02f, 3.46574262e-02f, 2.16162261e-02f, 1.60939824e-02f, 6.57037199e-02f, 7.45016634e-02f, -1.78872850e-02f, 4.02575079e-03f, -3.56843919e-02f,
  6.08491451e-02f, 7.10881315e-03f, -3.97534221e-02f, 2.61432398e-02f, 1.74826160e-02f, -1.13027869e-02f, -1.06093325e-02f, -7.50094419e-03f, 1.39721809e-02f, 1.16279377e-02f,
  1.53430682e-02f, 7.91540816e-02f, 1.61854364e-02f, -1.28085911e-02f, -4.58503626e-02f, -5.39314486e-02f, 6.01480901e-02f, 3.06051411e-02f, 1.04462141e-02f, -5.74184395e-02f,
  1.12363078e-01f, 2.64882147e-02f, -2.88868230e-02f, 6.86395094e-02f, -8.36353190e-03f, 1.08845815e-01f, 5.10060973e-02f, 8.59150141e-02f, 5.81478216e-02f, -4.38251868e-02f,
  8.81731883e-03f, -2.06107982e-02f, 2.48038098e-02f, 3.93635482e-02f, -8.16975012e-02f, 8.02954733e-02f, -1.94554757e-02f, -3.99419330e-02f, 7.06109777e-03f, 2.43805535e-02f,
  6.11362532e-02f, 4.68504019e-02f, 1.03172727e-01f, 1.24128670e-01f, 7.26263449e-02f, 3.27336229e-02f, 7.37447590e-02f, 8.69365484e-02f, 9.62269232e-02f, -1.63741745e-02f,
  3.34997743e-01f, 9.23727453e-02f, -6.97566420e-02f, 3.04918587e-01f, 9.40030664e-02f, 3.57120782e-02f, 4.74199802e-02f, -7.46489852e-04f, 1.03963315e-01f, 1.11816414e-01f,
  -4.08553034e-02f, -6.24973141e-02f, -2.69140434e-02f, -2.32219830e-01f, -2.13467717e-01f, 9.18940231e-02f, 4.17782888e-02f, -1.38728827e-01f, -1.60263166e-01f, 2.30313111e-02f,
  -1.07773598e-02f, 1.03909425e-01f, 7.41064772e-02f, 1.10529840e-03f, 7.13558495e-02f, 7.73534104e-02f, 6.49245381e-02f, 7.74679407e-02f, -6.12512641e-02f, 1.30099565e-01f,
  -2.94111967e-02f, -1.38857942e-02f, -9.56397504e-02f, -3.74274850e-02f, -6.56202137e-02f, -1.12220421e-02f, -1.30840968e-02f, 5.41749857e-02f, -6.18515126e-02f, 9.50508416e-02f,
  -1.79673694e-02f, 5.36191948e-02f, 2.45552771e-02f, 1.32245673e-02f, 1.06043153e-01f, -4.75759506e-02f, -6.11325726e-02f, -8.50420818e-02f, -3.02108731e-02f, -2.57849675e-02f,
  -3.49479243e-02f, -1.34539045e-02f, 9.42704603e-02f, 3.30327488e-02f, -2.58818027e-02f, 4.14413400e-02f, 4.30379510e-02f, 9.60913002e-02f, 8.73877555e-02f, 2.33597413e-01f,
  3.33369449e-02f, -5.90041094e-02f, -4.82693948e-02f, 3.51121649e-02f, 1.74007658e-02f, -3.30426656e-02f, 6.85978830e-02f, -3.66204679e-02f, -5.72959222e-02f, 7.35138506e-02f,
  -2.11031809e-02f, -1.61533374e-02f, 4.04369868e-02f, 1.13649825e-02f, -1.70198530e-02f, 7.05981161e-03f, -6.61638752e-02f, 4.95454296e-02f, -6.68357983e-02f, 2.25897972e-02f,
  -6.02916963e-02f, -6.62826598e-02f, 1.96845978e-02f, -8.65793973e-03f, -8.67031142e-02f, -4.17105481e-02f, 1.96101330e-02f, -1.64135173e-02f, 8.42714459e-02f, 1.02650691e-02f,
  2.61955798e-01f, -2.38467187e-01f, 6.43894151e-02f, 7.94222951e-02f, 2.00746450e-04f, -3.60200182e-02f, 6.27921373e-02f, -4.34304704e-04f, -1.22265950e-01f, 6.09719492e-02f,
  3.60240228e-02f, -3.00810002e-02f, -2.18909476e-02f, -4.92562689e-02f, 3.14323343e-02f, 7.68511370e-02f, 1.47587210e-01f, 2.53523085e-02f, -3.25862244e-02f, 5.44736907e-02f,
  1.09729290e-01f, 4.53025736e-02f, 1.43893033e-01f, 5.85365295e-02f, 9.53441635e-02f, 1.07007787e-01f, 9.39783528e-02f, 3.04754898e-02f, 7.48034120e-02f, 3.16400230e-01f,
  -1.79063119e-02f, 1.46677867e-01f, 3.16179991e-02f, 2.06414595e-01f, 2.67685771e-01f, 1.00538284e-01f, 1.55999482e-01f, -1.22365365e-02f, 8.13852176e-02f, 3.23469155e-02f,
  6.82376176e-02f, 1.36988014e-01f, -2.14370387e-03f, 4.49754708e-02f, -8.52120891e-02f, 8.83400813e-02f, 7.93364495e-02f, -4.06624973e-02f, -7.44259506e-02f, 1.21785961e-01f,
  1.77814692e-01f, 4.73515540e-02f, -1.00563057e-01f, 2.63953712e-02f, 1.27559379e-01f, 6.61363974e-02f, -9.31801088e-03f, 1.21489353e-01f, 2.27879547e-02f, 1.75733536e-01f,
  1.41456559e-01f, 6.28214031e-02f, -7.79658183e-02f, -9.70669389e-02f, -2.97417454e-02f, 5.80414897e-03f, 8.77811164e-02f, -3.41030955e-02f, -8.97630453e-02f, 2.09736936e-02f,
  6.45754561e-02f, -2.89110038e-02f, 1.19450182e-01f, -1.24213602e-02f, 9.97683629e-02f, 2.07004081e-02f, -3.35322577e-03f, -4.56965296e-03f, -8.13885108e-02f, 2.87942868e-02f,
  7.32045621e-02f, 1.43311143e-01f, -6.59065396e-02f, -8.68203044e-02f, 1.17005538e-02f, 5.12766838e-02f, 4.98092026e-02f, -5.65563217e-02f, -9.12747905e-02f, -6.52178982e-03f,
  -2.37091240e-02f, -4.10701558e-02f, -1.14929816e-03f, -1.60365272e-02f, -3.68849887e-03f, -2.49497313e-02f, 2.48082783e-02f, 5.22247702e-02f, -7.68088084e-03f, 2.54857875e-02f,
  2.15255506e-02f, -5.54746315e-02f, -2.63370364e-03f, 5.33742532e-02f, -1.87129173e-02f, 5.70106655e-02f, -4.82892469e-02f, 5.28706945e-02f, -3.04782018e-02f, -2.49433275e-02f,
  -7.24924076e-03f, 2.18844395e-02f, 4.10731584e-02f, -2.63993591e-02f, -1.22723104e-02f, 1.47157256e-03f, 8.57434049e-03f, -4.09212634e-02f, -1.67835392e-02f, 3.69537733e-02f,
  1.99417379e-02f, -8.58133957e-02f, 1.25205934e-01f, 2.54103038e-02f, 7.35548288e-02f, -1.18902840e-01f, 3.85202505e-02f, 3.29006389e-02f, 6.92984462e-03f, -1.44467838e-02f,
  -2.39515241e-04f, 4.56664562e-02f, 6.91230223e-02f, -6.40485957e-02f, 1.79874757e-03f, -6.28819596e-03f, -6.16639443e-02f, 1.91845857e-02f, -1.09944865e-02f, -4.91073653e-02f,
  -1.24708511e-01f, -4.20332141e-02f, -2.27543637e-02f, -2.81042736e-02f, -1.64788663e-02f, 8.20587203e-03f, 1.62590835e-02f, 4.53690672e-03f, -1.33903265e-01f, -6.47468194e-02f,
  7.57150203e-02f, 1.90771595e-01f, 1.81659982e-01f, 4.35701385e-02f, -5.42114256e-03f, 1.08239509e-01f, 2.58335918e-01f, 1.53986722e-01f, -6.94390237e-02f, -2.13623629e-03f,
  1.93171278e-02f, -1.38597831e-01f, 4.67872284e-02f, 7.44506763e-03f, 2.33694702e-01f, 1.77937910e-01f, 3.22228409e-02f, 1.09317116e-01f, 6.03327081e-02f, 3.91706936e-02f,
  3.25709768e-02f, 2.26591770e-02f, 1.07931405e-01f, 2.96105761e-02f, -3.31206098e-02f, -5.59562296e-02f, 4.21179384e-02f, 2.32678745e-02f, -1.16121750e-02f, -1.14155151e-01f,
  -1.92796677e-01f, 3.44319306e-02f, 2.03184970e-02f, -9.40082818e-02f, -6.46989867e-02f, 4.38205898e-02f, -2.44692396e-02f, 3.61778177e-02f, 2.74706148e-02f, 7.93299004e-02f,
  -8.13352596e-03f, -8.04280415e-02f, -1.40573625e-02f, -7.42736980e-02f, -1.53954765e-02f, -2.80092936e-02f, 4.57767807e-02f, 6.75720051e-02f, 8.92872959e-02f, -5.35897352e-02f,
  -9.43415612e-02f, -7.32363239e-02f, 6.72903731e-02f, 1.10130042e-01f, 5.58716990e-02f, 5.21115772e-03f, 3.95239070e-02f, -2.53184251e-02f, 7.02398717e-02f, -1.41793927e-02f,
  -6.37914985e-02f, 2.78381612e-02f, -8.90057459e-02f, 5.81293032e-02f, -3.14509906e-02f, -3.90555896e-02f, 6.40748516e-02f, 2.59259306e-02f, 4.05361913e-02f, -2.63355318e-02f,
  -4.10242863e-02f, 5.32763526e-02f, 4.61461060e-02f, 5.29394671e-02f, 2.45839264e-02f, 7.92925153e-03f, 6.16384596e-02f, 4.41636704e-02f, -1.42272832e-02f, 8.24141875e-02f,
  -6.11940399e-02f, -6.90994263e-02f, 9.45942570e-03f, -6.27574092e-03f, -1.48800192e-02f, -2.91562267e-02f, -8.58484805e-02f, -2.48884168e-02f, 6.01480901e-02f, -4.65149768e-02f,
  -2.00873204e-02f, 1.35308728e-01f, -1.20465964e-01f, 5.29225208e-02f, -5.28227501e-02f, -1.14301937e-02f, -7.37911835e-02f, 1.73992906e-02f, -9.26667154e-02f, -8.00693110e-02f,
  -6.48664162e-02f, 1.11730387e-02f, 9.91362706e-02f, 1.96110010e-02f, 4.36834358e-02f, -2.18597110e-02f, -4.24131267e-02f, 6.01170817e-03f, -3.19573432e-02f, -1.04081400e-01f,
  -2.09645815e-02f, -2.02623606e-02f, 8.23042765e-02f, 3.43021005e-02f, -9.88674760e-02f, -2.03384906e-02f, 7.40645379e-02f, -9.47908238e-02f, -1.00349570e-02f, 1.32020181e-02f,
  -2.69115001e-01f, -5.90451099e-02f, -2.33505458e-01f, 2.70975940e-02f, 1.59517899e-01f, 2.23601431e-01f, 1.95487306e-01f, 8.70152414e-02f, -4.11623754e-02f, -2.94842925e-02f,
  -2.60807481e-02f, 9.01265815e-02f, -5.57189435e-02f, -7.02827647e-02f, -2.91391159e-04f, 2.04451066e-02f, -7.12420493e-02f, -1.61556944e-01f, 1.00828232e-02f, 8.84078667e-02f,
  2.15583786e-01f, -1.02544501e-01f, -1.17358468e-01f, 4.19739150e-02f, -3.69020738e-02f, 9.00948271e-02f, -2.33714599e-02f, -6.55083284e-02f, 9.16498899e-02f, -7.98500329e-02f,
  -3.13275814e-01f, -2.35049009e-01f, 3.58122289e-02f, 1.26798630e-01f, -1.84136387e-02f, 1.50936116e-02f, 1.14511978e-02f, -6.27834052e-02f, 6.24522455e-02f, -6.95184618e-02f,
  -2.03639865e-02f, 1.60315204e-02f, -1.62664689e-02f, 4.28924225e-02f, -3.00028641e-02f, 4.21315012e-03f, -1.14946276e-01f, -1.62998155e-01f, -3.02352272e-02f, -8.82265717e-02f,
  9.31856185e-02f, 2.74618566e-02f, -8.45234990e-02f, -4.17585634e-02f, -1.32912798e-02f, -1.07791659e-03f, -1.11857474e-01f, -8.26690271e-02f, -1.47727847e-01f, -1.37480512e-01f,
  4.81878333e-02f, -4.09683660e-02f, 9.77857560e-02f, -4.01122384e-02f, 7.28484243e-04f, -1.71495229e-02f, -6.90551326e-02f, 2.74868123e-02f, 8.86366740e-02f, 6.61599403e-03f,
  4.53244671e-02f, -6.82203025e-02f, -5.47520816e-03f, -2.84441151e-02f, -8.56546778e-03f, 5.24666682e-02f, -1.89326908e-02f, -3.34129781e-02f, -2.67720204e-02f, -2.79872138e-02f,
  4.61675674e-02f, 3.96211818e-02f, -2.47861389e-02f, -6.19869456e-02f, 6.90985173e-02f, 3.91870104e-02f, -3.96447629e-02f, 1.42018095e-01f, 1.96934752e-02f, -3.29352468e-02f,
  -3.02963518e-02f, 4.84545343e-02f, -1.06432743e-01f, -5.45119457e-02f, 3.05160624e-03f, -9.28314924e-02f, 3.24815959e-02f, -9.05699283e-03f, 3.96517366e-02f, -3.32986414e-02f,
  7.48399720e-02f, -9.79478806e-02f, -5.06587364e-02f, 5.66453896e-02f, 4.91177142e-02f, 6.21819012e-02f, 3.25631388e-02f, 6.37863670e-03f, 6.29180670e-02f, -1.22542670e-02f,
  6.52333647e-02f, 4.67670485e-02f, 6.15418181e-02f, -3.08778905e-03f, -1.10668149e-02f, -5.92285730e-02f, 1.71846524e-02f, 5.82285225e-02f, -1.31661454e-02f, 2.47318856e-02f,
  -4.89687845e-02f, -1.72643289e-02f, -2.68182367e-01f, 3.57083045e-02f, 4.83392887e-02f, 9.55355912e-02f, 3.19118202e-01f, 2.24521711e-01f, 1.10772617e-01f, -6.31982600e-03f,
  9.58208647e-03f, -4.22571413e-02f, -3.73112969e-02f, 4.25162651e-02f, 5.40831611e-02f, 1.04372263e-01f, 7.85277858e-02f, -4.25926261e-02f, 8.15743655e-02f, 1.67921081e-01f,
  1.35245547e-01f, 1.53160160e-02f, -1.00618288e-01f, -4.92301770e-02f, -1.41310185e-01f, -3.87543216e-02f, -1.88888550e-01f, -1.54776856e-01f, -4.05685790e-02f, -2.64718801e-01f,
  -1.87276751e-01f, -1.63784102e-01f, 3.28411609e-02f, 1.01013640e-02f, -1.25904843e-01f, 1.07784020e-02f, 7.83721581e-02f, -1.25946820e-01f, 1.20271519e-02f, 1.31415967e-02f,
  -1.09048650e-01f, -8.34494010e-02f, -7.55490959e-02f, 3.64438482e-02f, 9.09721330e-02f, 1.47519317e-02f, -4.68777157e-02f, -1.31407231e-01f, 5.46669252e-02f, 1.15202116e-02f,
  4.73542586e-02f, -5.46558835e-02f, 1.05627319e-02f, 1.75735485e-02f, -9.97754335e-02f, -4.48766835e-02f, -2.57620122e-05f, -5.17031597e-03f, 7.62756076e-03f, 1.64974313e-02f,
  4.15286906e-02f, -3.32964882e-02f, -6.67216331e-02f, 1.59029886e-02f, 7.13888705e-02f, -5.63467033e-02f, 5.65549731e-02f, 5.85149042e-02f, 2.13069119e-03f, -4.54327650e-02f,
  1.92960687e-02f, -6.33214414e-02f, -2.07699668e-02f, 4.40490209e-02f, -4.03048955e-02f, -2.33482756e-03f, -1.73374414e-02f, -2.74780374e-02f, -3.32350773e-03f, -3.62421460e-02f,
  -6.33843020e-02f, 3.35072279e-02f, -2.35246029e-02f, -3.05837095e-02f, -9.78267170e-04f, 3.48784737e-02f, 2.45253881e-03f, 5.38377184e-03f, 4.15500104e-02f, -6.06450178e-02f,
  1.51712134e-01f, -1.33866239e-02f, 7.39867687e-02f, 5.85864261e-02f, -1.48486652e-04f, -1.07185990e-01f, -2.31746119e-02f, -3.14527564e-02f, -8.20552260e-02f, 8.89172032e-03f,
  7.37478584e-02f, 4.39526401e-02f, -2.62835831e-03f, 4.63196076e-02f, 9.44167003e-02f, 3.80518027e-02f, 1.37562230e-01f, 9.30617824e-02f, -3.38167883e-02f, 9.11807269e-02f,
  -5.31861419e-03f, 2.40726128e-01f, 2.56398231e-01f, 1.50642931e-01f, 3.81992646e-02f, 1.41517371e-01f, 1.55132994e-01f, 1.32839838e-02f, 1.37859896e-01f, 3.02553087e-01f,
  -3.56319547e-01f, 1.94464345e-02f, 1.85252696e-01f, -6.52846023e-02f, 4.62926440e-02f, 9.20867324e-02f, 8.43122452e-02f, 8.04297775e-02f, -1.93145648e-02f, 6.28230721e-02f,
  -7.26789832e-02f, -1.78859290e-02f, 1.19413063e-01f, 1.41325653e-01f, 2.26390392e-01f, 2.35269532e-01f, 1.33809239e-01f, 1.03515312e-01f, 1.75427616e-01f, -4.54757698e-02f,
  9.89694819e-02f, 4.18406762e-02f, 5.76875173e-03f, 2.24159434e-02f, -1.42627265e-02f, 7.67636076e-02f, 7.78657049e-02f, 2.11458076e-02f, 7.66037731e-03f, 1.03753731e-01f,
  -7.84609169e-02f, -9.75494534e-02f, -1.00089284e-02f, -7.49862865e-02f, 3.85093726e-02f, -1.56186428e-02f, -8.84841979e-02f, 1.19736549e-02f, -8.17353427e-02f, -2.19325535e-02f,
  -3.88058387e-02f, -2.97509022e-02f, 5.07768302e-04f, 6.98675662e-02f, 4.43766713e-02f, -5.88381961e-02f, 7.85842910e-02f, 7.20427036e-02f, 1.19053885e-01f, 3.83701688e-03f,
  -4.60267998e-02f, -3.69835682e-02f, 6.49761930e-02f, 7.60937706e-02f, 8.93194824e-02f, -1.94685552e-02f, 7.53424913e-02f, 6.31733164e-02f, 1.40093446e-01f, -1.54432371e-01f,
  3.67003605e-02f, 2.97565069e-02f, -4.21593804e-03f, -3.92491221e-02f, 1.83842983e-02f, -1.91403423e-02f, -1.53758060e-02f, -1.74039658e-02f, 3.65689248e-02f, 2.92682741e-02f,
  -7.82417785e-03f, -3.19940969e-02f, -2.32288223e-02f, -1.50076449e-02f, -2.22925302e-02f, 1.57303419e-02f, 2.07506381e-02f, -1.62499584e-02f, -1.16471350e-02f, 1.37374857e-02f,
  1.97425038e-02f, -1.75060462e-02f, -1.02792062e-01f, -5.79833500e-02f, -4.48480360e-02f, 3.19835767e-02f, 3.70747596e-02f, -1.35297617e-02f, -6.12998530e-02f, 3.83583233e-02f,
  -1.58331499e-01f, 5.81650920e-02f, 1.22461626e-02f, -5.28913252e-02f, -3.58767211e-02f, -8.99215788e-03f, 1.00081395e-02f, 2.29532388e-03f, -1.00857034e-01f, 1.57011524e-02f,
  -6.58532456e-02f, -1.01814210e-01f, 4.58337273e-03f, -7.87119418e-02f, -6.11082017e-02f, 4.02840823e-02f, -6.11145224e-04f, 2.25947704e-02f, 8.15678462e-02f, -3.53756584e-02f,
  4.53272928e-03f, -5.48568461e-03f, -1.23015396e-01f, -1.37894414e-03f, 6.48464039e-02f, 1.23383477e-02f, -2.17985399e-02f, -1.00920647e-01f, -3.85232419e-02f, -1.47146508e-01f,
  -5.23735464e-01f, 2.50285536e-01f, -1.15231529e-01f, -3.15194070e-01f, -5.92882819e-02f, 1.87031999e-01f, 3.14012378e-01f, 8.20258334e-02f, -7.98929781e-02f, 8.16046074e-02f,
  1.51767395e-02f, -6.74735755e-02f, -4.70459312e-02f, 3.47503349e-02f, 8.88282210e-02f, 1.94968909e-01f, 4.69604023e-02f, -1.06461599e-01f, -9.12533775e-02f, 1.38865098e-01f,
  1.78485036e-01f, -5.55506088e-02f, -1.58666164e-01f, -4.35335301e-02f, -7.08419085e-02f, -3.48663814e-02f, -1.72164459e-02f, -3.42418477e-02f, 4.76609468e-02f, 2.38570175e-03f,
  1.38577431e-01f, -1.49870291e-01f, -6.78850105e-03f, -4.88939993e-02f, -5.24558201e-02f, 3.27588394e-02f, -2.04353780e-02f, -1.12972535e-01f, 3.57442833e-02f, 3.67714241e-02f,
  2.03790516e-03f, 1.49876392e-02f, -1.08744651e-01f, 4.83718924e-02f, 3.10161784e-02f, -8.57460545e-04f, 6.23072423e-02f, -1.14356793e-01f, -7.63804913e-02f, 6.72643930e-02f,
  2.01177686e-01f, 1.03688255e-01f, -7.88760663e-04f, 5.00730723e-02f, -2.87662372e-02f, -8.12884420e-02f, -3.12264822e-02f, 2.97117364e-02f, -6.55159801e-02f, 1.45818833e-02f,
  4.40545827e-02f, -3.27400640e-02f, -6.81676194e-02f, 5.29262945e-02f, -1.15998741e-02f, -7.23520815e-02f, 5.17945923e-02f, 5.56945987e-02f, -6.39576390e-02f, 4.88181300e-02f,
  -3.46742682e-02f, 6.01216517e-02f, -2.44880412e-02f, -7.44931251e-02f, 3.89711931e-02f, -3.95607390e-02f, 1.79067422e-02f, 6.98385537e-02f, 4.31147516e-02f, 2.87047811e-02f,
  -9.34993848e-02f, -1.73615478e-02f, -2.07160749e-02f, 4.92164567e-02f, 5.26366048e-02f, 1.18683577e-02f, -1.09359724e-02f, -3.87209468e-02f, 2.77186220e-04f, -5.45984097e-02f,
  7.35726878e-02f, -1.24046437e-01f, -4.53904383e-02f, 3.55409645e-02f, -1.02121636e-01f, 4.29131612e-02f, -7.47355521e-02f, 6.86517954e-02f, -6.25241548e-02f, 1.01005666e-01f,
  2.57281233e-02f, -3.95175070e-02f, -4.73607033e-02f, 5.03767468e-02f, -3.87342856e-03f, -8.44704919e-03f, -3.66699020e-03f, 7.05052307e-03f, -9.61176865e-03f, 3.19858938e-02f,
  5.15023880e-02f, 6.18572272e-02f, -7.39020780e-02f, 2.40383670e-02f, 2.11663573e-04f, -1.05733939e-01f, 1.32157672e-02f, 1.31819788e-02f, -6.72931075e-02f, 1.50548950e-01f,
  -1.94289058e-01f, 1.52671918e-01f, 1.54190347e-01f, -1.07198007e-01f, -1.70156278e-03f, -8.09258595e-02f, 1.81606542e-02f, -1.02903984e-01f, -9.88150388e-02f, 1.31925419e-01f,
  5.26767895e-02f, -4.17396799e-02f, -1.15742691e-01f, -1.31655768e-01f, -1.38889596e-01f, -4.40173708e-02f, -9.01010633e-02f, -1.47571623e-01f, -2.37630084e-01f, -6.04210645e-02f,
  -1.52565073e-02f, -1.50377363e-01f, -1.82378978e-01f, -1.19873993e-01f, 7.85262585e-02f, -6.31423816e-02f, 1.41647428e-01f, 1.40995041e-01f, 1.83913141e-01f, 6.60615787e-02f,
  1.82335690e-01f, 8.61986820e-03f, -7.09619895e-02f, -3.62520888e-02f, 2.79092751e-02f, -2.56893225e-02f, 5.95291406e-02f, 9.94039476e-02f, 1.01157017e-02f, 5.51286414e-02f,
  8.23054984e-02f, -5.57647385e-02f, 4.92112637e-02f, 8.70913044e-02f, 6.11602217e-02f, -2.46311352e-02f, 5.93027622e-02f, -3.30168977e-02f, -9.67560243e-03f, 1.40552551e-01f,
  7.73649570e-03f, 4.67355214e-02f, 5.13207056e-02f, 9.89774317e-02f, -6.48457631e-02f, -6.55960664e-02f, 4.31010388e-02f, 2.81605646e-02f, -7.07745776e-02f, -1.18720671e-02f,
  -6.43598959e-02f, 3.99011374e-02f, -2.56595332e-02f, -7.65084997e-02f, -1.32335024e-03f, -4.75127734e-02f, -5.63207939e-02f, 6.73659798e-03f, -5.15392125e-02f, -3.64966318e-02f,
  2.64327992e-02f, 5.72866155e-03f, -3.98873864e-03f, 5.40684573e-02f, 2.58516967e-02f, -2.83612181e-02f, 9.20806825e-03f, 4.53876937e-03f, 1.94407552e-02f, -2.81245541e-03f,
  -5.82181066e-02f, 6.81602359e-02f, 1.14104167e-01f, -1.42893074e-02f, -2.57177707e-02f, 6.79702237e-02f, 5.78346215e-02f, 7.97517076e-02f, -2.46029720e-02f, -2.98617780e-02f,
  3.48886400e-02f, -1.09276503e-01f, 4.79042009e-02f, -1.27319768e-01f, 6.28821924e-02f, 1.96646135e-02f, 4.19717394e-02f, 1.86917614e-02f, -1.97665021e-02f, -1.36580560e-02f,
  7.16763437e-02f, -4.81321551e-02f, -1.11614242e-02f, -1.40877245e-02f, -9.67733562e-02f, 4.68689762e-02f, 1.02124900e-01f, -9.59147662e-02f, -3.39020267e-02f, 4.61362228e-02f,
  7.64448792e-02f, -1.30422562e-01f, -1.93471879e-01f, -5.68094291e-02f, 7.36735612e-02f, -5.44173829e-02f, 4.91607897e-02f, -3.99231277e-02f, -8.02581906e-02f, -5.89355156e-02f,
  -1.72716543e-01f, 6.80204830e-04f, 1.89893275e-01f, -2.58603483e-01f, 8.62861425e-02f, 1.91653252e-01f, 3.69815588e-01f, 2.15095624e-01f, -1.17373519e-01f, 7.97196254e-02f,
  -3.13214026e-02f, -1.44167304e-01f, -1.21455165e-02f, 3.39846360e-03f, 4.97852154e-02f, 1.57801166e-01f, -4.70319204e-02f, 3.92514989e-02f, -1.06526017e-02f, 7.73449847e-03f,
  -3.89460474e-02f, -2.05146477e-01f, -1.21780619e-01f, -6.28977641e-02f, -2.05652818e-01f, -1.15448937e-01f, -1.21193647e-04f, -1.16463937e-01f, -7.17433169e-02f, -2.23991230e-01f,
  9.29788053e-02f, -8.73923153e-02f, 4.10733968e-02f, -1.51658878e-01f, 5.28247654e-02f, 6.79341555e-02f, -2.93244198e-02f, -4.02639396e-02f, -9.87613872e-02f, 6.97614551e-02f,
  -8.54137912e-02f, -6.10056892e-02f, -4.52304967e-02f, -2.65646111e-02f, 5.04794195e-02f, 5.74465655e-03f, -4.45906147e-02f, -1.99335329e-02f, 2.26522386e-02f, -2.42567365e-03f,
  -1.36200249e-01f, -5.25913350e-02f, 1.26049861e-01f, 1.39314428e-01f, 8.59063417e-02f, -8.48073140e-02f, 1.36267999e-02f, -4.40548034e-03f, 5.64510748e-02f, 2.28824653e-02f,
  -4.47542220e-02f, -3.74040194e-02f, -3.73907089e-02f, -4.70080972e-02f, 3.49654071e-02f, 2.49848124e-02f, -7.36232102e-02f, 1.21618761e-02f, 3.05599999e-02f, 6.54630065e-02f,
  -8.81074369e-03f, 6.72569051e-02f, -3.01562250e-02f, -6.33728206e-02f, 4.48974734e-03f, -6.91110492e-02f, -6.77363575e-02f, -3.92904803e-02f, 7.46988878e-02f, 2.80156806e-02f,
  -9.01839510e-03f, 5.47681674e-02f, -8.58492106e-02f, 1.81527231e-02f, 3.68037894e-02f, 5.50949685e-02f, -8.63000229e-02f, -3.18679176e-02f, -3.35178114e-02f, 4.79331240e-02f,
  1.43305525e-01f, 1.86916441e-01f, -8.23900253e-02f, 2.34825611e-02f, 3.13554294e-02f, -3.24930437e-02f, -2.21197475e-02f, 1.10606533e-02f, -7.49847889e-02f, 2.43765805e-02f,
  1.35823423e-02f, -4.09303904e-02f, 3.02840918e-02f, 8.31233338e-02f, 3.80568802e-02f, 8.20985588e-04f, 4.72055108e-04f, -1.57439336e-02f, 3.87655273e-02f, -2.68168785e-02f,
  5.48308119e-02f, 9.80733857e-02f, 1.42569020e-01f, 1.48981035e-01f, -4.82370667e-02f, 6.30418137e-02f, 1.20079942e-01f, 9.33339819e-02f, 2.12641343e-01f, 1.89146370e-01f,
  1.84920058e-01f, 4.15270627e-01f, 8.72670636e-02f, -5.25333025e-02f, -1.49510115e-01f, -1.51506081e-01f, 5.62516376e-02f, -1.12142704e-01f, -1.34251252e-01f, 1.49204716e-01f,
  8.81834179e-02f, -1.32292390e-01f, -9.86983702e-02f, -1.31608546e-01f, -1.42690837e-01f, 1.17347091e-01f, 6.17525205e-02f, -3.27327522e-03f, -1.96678147e-01f, -1.42072454e-01f,
  4.51264791e-02f, -6.78394921e-04f, 6.89772442e-02f, 6.91445991e-02f, 1.24369180e-02f, -1.07423320e-01f, 9.05348808e-02f, 1.04456462e-01f, 1.75260440e-01f, 3.08940470e-01f,
  1.85730577e-01f, 1.72848657e-01f, -2.10424483e-01f, 8.06176662e-02f, 7.40648881e-02f, 5.05036414e-02f, 4.44451952e-03f, 8.47507045e-02f, -7.29159638e-03f, 7.76590258e-02f,
  1.16727084e-01f, 7.93567970e-02f, -3.72424349e-02f, 2.11690571e-02f, 4.64651212e-02f, 3.08240466e-02f, 2.44413200e-03f, 4.68681604e-02f, -7.97376111e-02f, 1.26758456e-01f,
  6.72643781e-02f, 2.88912468e-03f, -4.79868688e-02f, -8.25634524e-02f, -5.25586195e-02f, -1.02741688e-01f, 8.38747472e-02f, 5.88453151e-02f, -9.74736884e-02f, 1.73340410e-01f,
  2.66714524e-02f, -1.73620116e-02f, 2.95649320e-02f, -2.05171853e-02f, 1.73096173e-02f, 4.86513004e-02f, -1.84044875e-02f, 2.26326436e-02f, -7.36150816e-02f, 6.07608221e-02f,
  -9.40356329e-02f, 3.24673504e-02f, -1.94324565e-03f, 1.55775035e-02f, -1.86224636e-02f, -1.05653517e-02f, -2.41665374e-02f, 5.28849848e-03f, -5.68454387e-03f, -3.92602161e-02f,
  2.64447760e-02f, -4.30470631e-02f, -2.49388884e-03f, -6.25186190e-02f, 6.50008991e-02f, -1.07110878e-02f, -1.97867975e-02f, 4.81414720e-02f, -3.75431590e-02f, 9.86671671e-02f,
  -2.27381721e-01f, -3.64005528e-02f, -4.34779655e-03f, -2.51500178e-02f, -4.14120257e-02f, -4.12859805e-02f, 5.60301868e-03f, -4.82133031e-03f, 8.76452923e-02f, 8.68439116e-03f,
  -2.23866459e-02f, -3.91302556e-02f, 4.85721305e-02f, 5.52518219e-02f, -1.73441067e-01f, -1.50550129e-02f, 1.17466398e-01f, -9.93291885e-02f, -9.67373475e-02f, 5.75380437e-02f,
  -4.20340989e-03f, -7.72029087e-02f, -2.61722982e-01f, -1.31014436e-01f, -7.28043616e-02f, -2.21265748e-01f, -1.28176600e-01f, -1.73194349e-01f, -1.27529189e-01f, -1.44707829e-01f,
  -1.39544979e-02f, 1.71869650e-01f, -1.56766787e-01f, 2.92162448e-02f, -5.23939356e-02f, -1.51161671e-01f, -8.60911682e-02f, -1.89849436e-02f, 6.07074518e-03f, 1.68885514e-01f,
  1.35996282e-01f, 1.66610643e-01f, 1.73252165e-01f, -7.00162947e-02f, -2.87750028e-02f, 6.00199727e-03f, 3.16670239e-02f, -1.72846988e-01f, -2.55530894e-01f, -1.86573908e-01f,
  1.40278433e-02f, -2.60080229e-02f, 4.48580310e-02f, -4.80613299e-02f, -6.91682938e-03f, 5.39431442e-03f, 1.51548520e-01f, -3.28114443e-02f, 5.43188956e-03f, 4.30941861e-03f,
  1.06188446e-01f, -1.42783627e-01f, -1.54053587e-02f, 3.24764401e-02f, 2.65338272e-02f, 2.79549081e-02f, 1.43869137e-02f, -9.81308743e-02f, 6.24792650e-03f, -1.66531857e-02f,
  5.24620265e-02f, -6.75225481e-02f, 9.21320915e-02f, -5.31751141e-02f, -6.95285499e-02f, -1.12262830e-01f, 3.83528173e-02f, -9.57865566e-02f, -5.90933710e-02f, -7.25497901e-02f,
  1.40985288e-02f, -2.06828713e-02f, -4.11245264e-02f, -3.56694199e-02f, 5.34244813e-03f, -6.11553788e-02f, 7.54894465e-02f, -8.69936720e-02f, -6.33619577e-02f, 3.52692381e-02f,
  -4.20117229e-02f, 4.28616256e-02f, 2.36005634e-02f, -8.05127472e-02f, 8.21311548e-02f, 3.14567122e-03f, -2.60462593e-02f, -5.72020821e-02f, 5.07710204e-02f, -1.15950853e-02f,
  2.02058200e-02f, -2.35755015e-02f, 4.76710498e-02f, 3.96689661e-02f, 1.41556822e-02f, -6.08991347e-02f, -2.80498806e-02f, 5.87674323e-04f, 1.15864173e-01f, 4.89860773e-02f,
  5.47263660e-02f, 1.31718172e-02f, 9.42334607e-02f, 4.85498123e-02f, 5.79688288e-02f, -4.49903570e-02f, -4.96633798e-02f, -5.98863661e-02f, -2.88781188e-02f, -6.77673072e-02f,
  2.57520407e-01f, 3.57239991e-02f, -4.11519893e-02f, -5.99282235e-02f, 1.47728957e-02f, 2.74556689e-02f, 4.73597646e-02f, -1.09127478e-03f, 1.13795176e-01f, -8.11707005e-02f,
  -9.80992988e-03f, 1.31100304e-02f, 8.32438618e-02f, -2.60287113e-02f, -3.24014537e-02f, 2.96936352e-02f, 4.73412871e-02f, -8.41633081e-02f, 7.13631287e-02f, 6.03400394e-02f,
  6.93808123e-02f, -9.70201567e-02f, -7.80081237e-03f, 1.02533307e-02f, 7.77294412e-02f, 2.44431645e-02f, -3.40470038e-02f, 3.03819254e-02f, -2.21867394e-02f, 1.05160303e-01f,
  -3.68841439e-01f, -1.91782460e-01f, -1.33986935e-01f, -1.94540635e-01f, 1.72578450e-02f, -1.62231013e-01f, -1.16728500e-01f, -4.87207919e-02f, 4.76710871e-02f, -9.56900790e-02f,
  1.49185449e-01f, 1.02674931e-01f, 1.21122897e-01f, 1.48419172e-01f, 1.27660651e-02f, -1.49601921e-01f, -1.20545827e-01f, -1.59080893e-01f, -5.57078049e-02f, -4.86858785e-02f,
  1.19361617e-01f, -4.95708585e-02f, -1.68414533e-01f, -8.79636705e-02f, 2.69817039e-02f, 4.99723386e-03f, -6.05140813e-02f, -1.49276853e-01f, -3.56341861e-02f, -1.69773817e-01f,
  3.70103307e-02f, -1.73609927e-01f, 7.60340095e-02f, 1.40421718e-01f, 2.11722553e-02f, -7.02604577e-02f, 5.09836674e-02f, -6.21740371e-02f, -5.84778786e-02f, 4.31118021e-03f,
  6.97581619e-02f, 6.37918338e-02f, -6.71015233e-02f, 6.44003972e-02f, 4.57387306e-02f, -1.37866018e-02f, -3.05463187e-02f, -2.40715463e-02f, 7.78078218e-04f, 5.67362979e-02f,
  1.52461641e-02f, -1.44137040e-01f, -1.06949665e-01f, -7.95393884e-02f, -1.28195897e-01f, 2.69301478e-02f, -6.47324026e-02f, -1.15981124e-01f, -1.37081280e-01f, -9.64580178e-02f,
  3.02382465e-02f, -1.82552431e-02f, 4.42331024e-02f, 3.12532745e-02f, -5.60569130e-02f, -9.48550180e-03f, -3.25740874e-02f, 5.36024831e-02f, -2.82069426e-02f, 6.00195257e-03f,
  -6.48210123e-02f, 3.24264653e-02f, -3.73779051e-02f, -2.75622215e-02f, -5.36178937e-03f, 2.62893271e-02f, -6.44682199e-02f, -2.69899108e-02f, -2.03206297e-02f, 4.73696832e-03f,
  -1.24730216e-02f, -6.75417334e-02f, -6.45531341e-02f, -4.98627685e-02f, 2.78788339e-02f, -5.27874678e-02f, 3.59394625e-02f, 1.83783914e-03f, 4.27625738e-02f, -5.46700656e-02f,
  6.54569343e-02f, 8.61263499e-02f, -1.68664828e-02f, 4.03840356e-02f, -7.44335353e-02f, 9.72615853e-02f, -2.63219047e-02f, 6.04929663e-02f, 4.21888232e-02f, -1.63131801e-04f,
  -3.58336046e-02f, -1.08323954e-02f, 5.09316362e-02f, -4.19017822e-02f, -4.44299392e-02f, 2.19362715e-04f, 3.24479714e-02f, -5.95636293e-02f, 8.24807491e-03f, 9.31790695e-02f,
  6.94244951e-02f, -1.43441275e-01f, -5.95758185e-02f, -8.12098905e-02f, -8.00501481e-02f, 6.89270496e-02f, -5.96369617e-02f, -4.84689288e-02f, -7.67492428e-02f, -1.62801459e-01f,
  1.71226695e-01f, 4.27982491e-03f, 1.15168110e-01f, -5.25733754e-02f, -2.42113411e-01f, -5.49956337e-02f, -5.74171878e-02f, -5.06605729e-02f, 6.28744960e-02f, -1.05528228e-01f,
  -1.89338222e-01f, -6.47853240e-02f, -7.90210292e-02f, -2.49153678e-03f, 2.76984205e-03f, 3.75938080e-02f, -2.38131806e-02f, 1.04304373e-01f, 1.25541210e-01f, -5.88549785e-02f,
  -7.05461134e-04f, 7.32929185e-02f, 8.39207694e-02f, -3.80775263e-03f, 7.68771395e-02f, 2.09251624e-02f, 4.39240374e-02f, -1.16074778e-01f, -4.88001795e-04f, 7.36692399e-02f,
  1.11191437e-01f, 8.64117518e-02f, 9.57814157e-02f, -1.60865746e-02f, -7.37358183e-02f, 2.32906640e-02f, -5.29639758e-02f, 2.16211379e-02f, -1.12872563e-01f, 7.19075799e-02f,
  -1.77844331e-01f, -5.63211218e-02f, -8.21076930e-02f, -4.08498906e-02f, -1.79814100e-02f, 5.34757003e-02f, 9.32454988e-02f, 1.42226323e-01f, 6.50493652e-02f, 5.91253489e-02f,
  -4.49667722e-02f, -1.62520662e-01f, -3.83522995e-02f, 6.95494488e-02f, 9.64319035e-02f, 9.05539989e-02f, -4.18689549e-02f, 2.87079420e-02f, 1.51669472e-01f, 6.52216077e-02f,
  4.92234491e-02f, 2.22915784e-02f, -6.20357431e-02f, 7.53559396e-02f, -9.15922038e-03f, -3.79916579e-02f, 7.18329474e-02f, -1.20475292e-01f, 4.11539450e-02f, -1.84555594e-02f,
  -1.37625393e-02f, 5.19364737e-02f, 2.46642791e-02f, 4.26757634e-02f, -8.25696662e-02f, 6.75632432e-02f, 1.67690236e-02f, 6.71789721e-02f, 6.53921217e-02f, -1.43823056e-02f,
  4.87879384e-03f, 6.89376742e-02f, -8.32491554e-03f, -6.06680987e-03f, 1.86922643e-02f, 4.26078513e-02f, 1.40653765e-02f, 6.75876141e-02f, 8.57979432e-02f, -5.95838577e-02f,
  -5.43525303e-03f, -1.92343190e-01f, 1.73567563e-01f, 5.77144884e-03f, 4.18937281e-02f, 1.94094647e-02f, 3.24555486e-02f, 1.87734384e-02f, -4.15009968e-02f, 1.12722628e-01f,
  1.08377989e-02f, 1.82787348e-02f, -1.05189718e-01f, 2.21066196e-02f, -1.04767373e-02f, -9.46066994e-03f, -5.52551001e-02f, 3.41722593e-02f, 5.69259189e-02f, 8.60164836e-02f,
  4.27169492e-03f, 1.30068615e-01f, 6.48045391e-02f, -9.51459445e-03f, -1.57377347e-02f, 9.17874500e-02f, 7.90951028e-02f, 1.43977866e-01f, 1.48867816e-01f, 8.95654559e-02f,
  -3.11796248e-01f, 1.57793358e-01f, 1.94428340e-01f, -7.22190216e-02f, 1.32327795e-01f, 1.63610339e-01f, 2.12578133e-01f, -4.31448314e-03f, -7.00515658e-02f, 8.79598223e-03f,
  6.53650984e-02f, -2.10573912e-01f, -9.00217295e-02f, -1.57955706e-01f, -3.97233367e-02f, 1.44531623e-01f, 1.41385317e-01f, -1.93806112e-01f, -2.19203651e-01f, -1.01141602e-01f,
  -6.81600645e-02f, -1.47322088e-01f, -1.72514170e-01f, -1.06540017e-01f, 1.76600993e-01f, -4.25960682e-02f, 1.40258580e-01f, -1.96030014e-03f, 6.01766258e-02f, 1.61386684e-01f,
  -2.92814020e-02f, 1.80579156e-01f, -1.37098417e-01f, -3.19985785e-02f, 4.26205322e-02f, 5.11407144e-02f, -3.34942155e-02f, 3.72760068e-03f, -5.10585681e-02f, 7.77137056e-02f,
  -7.33612776e-02f, -1.74115021e-02f, -2.07908843e-02f, 5.11392727e-02f, -7.50684962e-02f, -4.03533056e-02f, 4.43219170e-02f, -4.82833870e-02f, 2.36472320e-02f, -2.76071094e-02f,
  1.86206717e-02f, -9.58445072e-02f, -1.13128856e-01f, -6.47169724e-02f, 7.12926909e-02f, -6.59167916e-02f, -1.34212412e-02f, 7.87616149e-02f, 9.26797614e-02f, 7.77391568e-02f,
  -1.31508419e-02f, 7.13824257e-02f, -3.23072150e-02f, -6.71668816e-03f, 3.30980383e-02f, 3.32833789e-02f, 4.03942466e-02f, -8.93158615e-02f, -3.01542263e-02f, 6.62223483e-03f,
  2.42654234e-02f, -9.31274332e-03f, 4.78745960e-02f, 4.13216539e-02f, -7.62809888e-02f, 1.83282271e-02f, 3.49730290e-02f, -6.18659251e-04f, -5.95202185e-02f, -1.53484405e-03f,
  -1.00113735e-01f, 3.15120071e-02f, -6.48140758e-02f, 8.23631301e-04f, 3.13679203e-02f, -5.74526377e-03f, 8.95038340e-03f, -4.14946042e-02f, -7.85309672e-02f, 2.58586258e-02f,
  -2.20506847e-01f, -5.62054738e-02f, -1.86355449e-02f, -2.98443753e-02f, -5.22602387e-02f, 1.20548194e-03f, 7.01737031e-02f, 9.87358205e-03f, 3.26504298e-02f, 5.04579395e-02f,
  -1.31237945e-02f, -4.10554595e-02f, -5.56117482e-03f, -2.93128937e-02f, -3.70268859e-02f, 2.04197410e-02f, -9.57232341e-02f, -1.27396524e-01f, -9.08451527e-02f, 4.38801944e-02f,
  9.24330205e-03f, -2.32995644e-01f, -2.31508091e-01f, -1.09085426e-01f, -8.44953880e-02f, -2.32478335e-01f, -5.59406728e-02f, -2.10344773e-02f, -4.79961671e-02f, -7.80456960e-02f,
  -1.81208663e-02f, -7.47136176e-02f, -2.07061380e-01f, 3.36540043e-02f, 6.74282238e-02f, -9.17735398e-02f, -7.79043185e-03f, 8.03083777e-02f, -1.71894953e-02f, 1.88685916e-02f,
  6.42060786e-02f, 8.22966173e-02f, -2.82403380e-02f, 1.18094208e-02f, -9.14398879e-02f, -3.96147743e-02f, -1.49520069e-01f, -2.63125822e-02f, -4.28803042e-02f, 1.85532048e-02f,
  8.74058604e-02f, -4.96380813e-02f, -8.23803619e-02f, 3.26457731e-02f, 8.73859674e-02f, -4.12540361e-02f, -1.39762074e-01f, -3.47117670e-02f, -4.79086023e-03f, 3.15068266e-03f,
  -6.60189390e-02f, 2.65314290e-03f, -3.37163061e-02f, 3.61504368e-02f, -8.60993564e-02f, 4.01835814e-02f, -2.09101308e-02f, -5.95997684e-02f, -6.33512810e-02f, 5.92088550e-02f,
  2.12545674e-02f, 9.59075615e-02f, 1.28573040e-02f, 2.89762635e-02f, -1.02351971e-01f, 1.58441570e-02f, -5.04885241e-03f, 1.88810527e-02f, 3.15342657e-02f, 5.04502580e-02f,
  1.23169065e-01f, -3.23875472e-02f, -1.26275839e-02f, -6.27268152e-03f, -7.18637481e-02f, -4.50884104e-02f, 3.12203784e-02f, -5.98419970e-03f, -3.99396522e-04f, 1.65237878e-02f,
  8.32373202e-02f, 6.90664351e-03f, 3.82720530e-02f, -1.80854127e-02f, 3.70895751e-02f, -4.23789844e-02f, -3.72513221e-03f, 6.08228967e-02f, -4.19965051e-02f, -2.93706581e-02f,
  -1.77049059e-02f, 1.37414858e-02f, 4.12272476e-02f, -3.59126329e-02f, 6.29054978e-02f, -5.29740453e-02f, 1.55679852e-04f, -8.74644741e-02f, 5.52618280e-02f, 1.33995451e-02f,
  7.06736594e-02f, -4.45275987e-03f, 8.37350730e-03f, 2.80503947e-02f, 3.97317857e-02f, -5.76403104e-02f, -5.27621470e-02f, 6.87878206e-02f, 3.96376215e-02f, 1.73253305e-02f,
  -1.00851119e-01f, 2.33620759e-02f, 8.66280347e-02f, 9.85450000e-02f, -4.03166339e-02f, -5.93433529e-02f, -3.91968600e-02f, -3.68016027e-02f, -6.80398643e-02f, 5.00905812e-02f,
  9.12230927e-03f, -8.50245878e-02f, 1.28693134e-02f, 6.58176616e-02f, -4.36283648e-02f, 6.70043752e-02f, 3.58751714e-02f, -1.97463632e-02f, 2.99485512e-02f, 7.92180449e-02f,
  -7.04164058e-02f, -6.47192150e-02f, -9.58574750e-03f, -2.38781702e-02f, 6.66390173e-04f, 4.42203768e-02f, 1.96730811e-02f, -4.35119346e-02f, -1.64181851e-02f, -1.54673845e-01f,
  3.70685130e-01f, -5.15291933e-04f, -1.09405547e-01f, 1.50350749e-01f, -1.00243241e-01f, -1.35230079e-01f, -1.62612095e-01f, -5.42146750e-02f, 1.62882134e-01f, -9.75885689e-02f,
  1.37743531e-02f, 6.50533140e-02f, 5.31946421e-02f, -1.09340452e-01f, -8.27856436e-02f, -2.31471479e-01f, -2.26620153e-01f, -7.95202404e-02f, -1.36680916e-01f, 3.55130434e-03f,
  4.98244576e-02f, 5.09037226e-02f, 1.89024225e-01f, -5.29555455e-02f, -4.61887643e-02f, -8.65066275e-02f, -5.60340397e-02f, -9.12268367e-03f, -1.12222612e-01f, -1.58251390e-01f,
  -2.39664733e-01f, 1.14447616e-01f, -7.61631280e-02f, -2.54393723e-02f, 2.02907268e-02f, 8.32088590e-02f, 6.65976182e-02f, -1.92779284e-02f, 2.97381543e-02f, 4.91589643e-02f,
  1.34369591e-02f, -1.32622654e-02f, 5.02679162e-02f, -5.82021847e-02f, 1.41787957e-02f, -2.16965992e-02f, 8.77389833e-02f, -6.30759820e-02f, 2.23120060e-02f, 1.68748293e-02f,
  6.81873187e-02f, -5.00781499e-02f, 9.15812850e-02f, 1.31593235e-02f, -1.33897513e-02f, 3.10443956e-02f, 3.49101648e-02f, 2.13825591e-02f, 7.47146383e-02f, -5.26601821e-02f,
  -9.63824689e-02f, -2.31630635e-02f, -5.64075112e-02f, -3.38224992e-02f, 4.49577533e-02f, -6.69490471e-02f, 1.78656895e-02f, -6.49373606e-02f, -6.45183325e-02f, -5.33940271e-02f,
  4.17290591e-02f, 3.13431583e-02f, -5.64610623e-02f, 3.20586525e-02f, -5.35004586e-03f, -5.07389754e-02f, -9.44906622e-02f, 5.13178892e-02f, 4.72987480e-02f, 7.19855726e-02f,
  -1.55595290e-02f, -2.20689544e-04f, 1.19889259e-01f, 3.82279679e-02f, -3.78194042e-02f, -7.22652078e-02f, 7.43497610e-02f, 4.58167531e-02f, -8.69022682e-04f, 1.46169653e-02f,
  4.41699401e-02f, 6.07797923e-03f, -1.13017634e-01f, 1.69658531e-02f, 2.30935197e-02f, -2.05483641e-02f, -4.94410619e-02f, -2.88578011e-02f, 5.78772947e-02f, 3.53689096e-03f,
  8.27274770e-02f, -3.75742726e-02f, 3.18695083e-02f, 6.47994131e-02f, 4.34963964e-02f, 3.35664973e-02f, 3.26919109e-02f, -3.06356288e-02f, 5.49309179e-02f, 5.54768778e-02f,
  1.35186948e-02f, -1.02704979e-01f, 1.26588568e-02f, -7.68630356e-02f, -5.79626784e-02f, -9.07737613e-02f, -8.45312029e-02f, -5.42868711e-02f, -1.39740750e-01f, -1.23304158e-01f,
  7.25099221e-02f, 1.17880926e-02f, -2.67761666e-02f, -5.27301580e-02f, -1.92072719e-01f, -2.31439427e-01f, -1.94069147e-01f, 3.71102057e-02f, 3.91738452e-02f, 2.55190954e-02f,
  5.08378260e-03f, 1.53770864e-01f, 1.50230318e-01f, 1.66648254e-01f, 1.24645181e-01f, -1.06249481e-01f, -1.40414789e-01f, 4.81590666e-02f, 9.01243314e-02f, 4.39284965e-02f,
  -5.96050397e-02f, -2.20392961e-02f, 1.60956532e-01f, -4.26284149e-02f, -9.26506668e-02f, -1.96317956e-02f, -3.93638611e-02f, -1.24426983e-01f, -6.24893829e-02f, -1.00318849e-01f,
  1.67035498e-03f, 2.62402873e-02f, 5.91873974e-02f, 1.02104940e-01f, -8.39758292e-02f, 9.53814983e-02f, -9.17661935e-03f, -7.81254098e-03f, 4.98201065e-02f, 3.86443585e-02f,
  2.63570007e-02f, -5.37157990e-03f, -7.81834498e-02f, -3.67443403e-03f, 3.11346408e-02f, 3.02511360e-02f, 1.10903136e-01f, -2.59854198e-02f, 5.63997291e-02f, 5.46513051e-02f,
  -7.21233934e-02f, -1.24541253e-01f, -1.89100597e-02f, 1.13940667e-02f, -1.27736209e-02f, -3.45934555e-02f, -1.20624252e-01f, 6.65797619e-03f, -7.72300959e-02f, -2.80626733e-02f,
  1.60117298e-02f, 1.77919194e-02f, -8.34169686e-02f, -1.04195308e-02f, -3.03877853e-02f, -2.06092000e-02f, -7.09482357e-02f, -2.06366051e-02f, 4.54256721e-02f, 5.18586189e-02f,
  -1.45887462e-02f, 4.62307297e-02f, 6.52989075e-02f, 6.99921474e-02f, 2.23933104e-02f, -5.90475872e-02f, -1.41065922e-02f, 9.67279598e-02f, -9.57473181e-03f, -2.99599264e-02f,
  6.10269755e-02f, -4.76317666e-02f, -1.23641435e-02f, 2.44663227e-02f, -3.38872597e-02f, 5.71142361e-02f, -4.35497575e-02f, -1.30187366e-02f, 7.52197355e-02f, -5.07439040e-02f,
  2.06324026e-01f, 2.60084998e-02f, -1.05028809e-03f, 9.34361219e-02f, -1.08591229e-01f, 6.97139353e-02f, 5.60909808e-02f, -3.30073424e-02f, -2.15224735e-02f, 6.50977418e-02f,
  -6.16699941e-02f, 8.77080411e-02f, 6.08120998e-03f, -2.00325567e-02f, 6.89704195e-02f, 8.56991783e-02f, 1.08013205e-01f, 4.38931100e-02f, 8.74219164e-02f, 4.09392305e-02f,
  4.44688350e-02f, 3.93966027e-02f, 1.43289849e-01f, 3.47106792e-02f, -6.08364977e-02f, 2.13651005e-02f, 1.46278506e-02f, 7.95359462e-02f, 1.41284525e-01f, 9.06339139e-02f,
  1.68453515e-01f, 2.59999156e-01f, -1.42717779e-01f, 1.49349263e-02f, 7.03886151e-02f, 1.63885951e-02f, 5.33065572e-03f, -3.29381749e-02f, -3.89370732e-02f, 1.39294088e-01f,
  1.90225393e-01f, -6.10966049e-02f, -1.62738059e-02f, -1.41333655e-01f, -9.92038324e-02f, -1.69683114e-01f, -5.90828545e-02f, -2.52006233e-01f, -2.51475811e-01f, -1.56337112e-01f,
  -1.37858853e-01f, -3.80348302e-02f, -1.59033775e-01f, -8.69154558e-02f, -3.48383039e-02f, -1.14332244e-01f, 2.16891244e-02f, -4.38628681e-02f, -6.52660877e-02f, 1.96793815e-03f,
  -9.03013647e-02f, 2.17340603e-01f, -8.13116580e-02f, -2.00841520e-02f, 1.15202248e-01f, -8.49856809e-02f, -8.10535550e-02f, 1.60686728e-02f, 1.06732383e-01f, -7.27970749e-02f,
  4.52110134e-02f, 1.67866307e-03f, 9.65359136e-02f, -3.55031267e-02f, 6.53060451e-02f, -6.52475655e-02f, 6.75587505e-02f, -1.29447103e-01f, -5.82939498e-02f, -2.04715226e-03f,
  3.48328128e-02f, 1.16656028e-01f, 1.28384307e-01f, -6.35252371e-02f, -7.32676266e-03f, -7.81872794e-02f, -3.02936900e-02f, 2.64955480e-02f, -2.23546457e-02f, -8.05188790e-02f,
  2.21447479e-02f, 8.23049166e-04f, -1.61132608e-02f, 7.32943416e-02f, -4.76550981e-02f, 7.00942501e-02f, -7.84511305e-03f, 3.49982567e-02f, 4.70338576e-02f, 4.88181449e-02f,
  -9.98639408e-03f, 4.86675948e-02f, -5.18878438e-02f, 7.85558484e-03f, -7.26963729e-02f, 4.67579328e-02f, -1.90831274e-02f, 4.21674922e-02f, 5.44135980e-02f, 5.41409291e-02f,
  -4.87196371e-02f, 3.99046652e-02f, 1.65196080e-02f, -9.21444148e-02f, -6.61929920e-02f, 1.15860878e-02f, 3.37465927e-02f, 6.85258880e-02f, 9.55969840e-02f, -2.91242879e-02f,
  6.14052229e-02f, -2.05152389e-02f, -1.55670969e-02f, 2.87115723e-02f, 3.62711996e-02f, 1.92524176e-02f, 1.30483657e-01f, 6.43916661e-04f, 2.09477656e-02f, 6.30118847e-02f,
  -1.85606629e-03f, 1.06296251e-02f, 3.15813459e-02f, 5.67103699e-02f, 8.93527456e-03f, 2.05723383e-02f, 1.25183016e-01f, -1.74713619e-02f, -6.92700073e-02f, 5.94943389e-02f,
  1.09515175e-01f, -3.34062055e-02f, -2.45199073e-02f, 8.69241208e-02f, -5.77538013e-02f, -2.65984014e-02f, -9.65038761e-02f, -5.04993461e-02f, -7.25338235e-02f, 8.78380537e-02f,
  3.12987208e-01f, -6.03915714e-02f, -2.57548392e-01f, 1.24740377e-01f, -1.86745286e-01f, -3.62966746e-01f, -3.61608237e-01f, -1.00578509e-01f, 1.33081436e-01f, -4.15734351e-02f,
  -8.48631933e-02f, 4.62180190e-03f, 1.93105079e-02f, 1.28060490e-01f, -1.59354508e-02f, -1.68406785e-01f, -1.55116007e-01f, -4.54026274e-02f, 9.11914110e-02f, -3.22294869e-02f,
  6.11001477e-02f, 3.58093902e-02f, 2.09204584e-01f, 1.75047755e-01f, 1.83670418e-04f, 5.59131280e-02f, 6.01985380e-02f, -9.21315402e-02f, -1.13969229e-01f, 1.75289400e-02f,
  -1.08370721e-01f, -5.70092537e-02f, 8.70136172e-02f, 6.19845800e-02f, -3.77726853e-02f, 3.87896299e-02f, 1.17971189e-02f, -1.85156930e-02f, 6.97037578e-02f, 5.96800745e-02f,
  -5.91251366e-02f, 5.52705303e-02f, -5.64772934e-02f, 5.83485588e-02f, 7.64197763e-03f, 2.20176429e-02f, 1.11585319e-01f, 1.58893511e-01f, 5.19989058e-02f, -1.00172855e-01f,
  -1.19395331e-01f, -1.67110741e-01f, -2.06409961e-01f, 1.32187614e-02f, -3.28322090e-02f, -1.32668447e-02f, -9.04948637e-02f, -1.43653098e-02f, -7.09581599e-02f, 1.25252247e-01f,
  3.13041136e-02f, -1.84981897e-02f, -5.20065613e-03f, 1.27805872e-02f, 2.12926269e-02f, 5.33087887e-02f, -6.93931952e-02f, -6.05717041e-02f, 7.66737610e-02f, -4.33548838e-02f,
  7.03272820e-02f, 7.59448018e-03f, -3.13925557e-02f, -4.22628745e-02f, 6.75355196e-02f, -1.14194185e-01f, -2.04710215e-02f, 3.61545421e-02f, 4.13110070e-02f, -1.24663357e-02f,
  7.78659880e-02f, 2.82949675e-03f, 5.34154065e-02f, -4.02195193e-02f, 9.56250168e-03f, -3.08891796e-02f, 4.08751667e-02f, -6.03079014e-02f, -4.37460952e-02f, -3.80753316e-02f,
  2.58682549e-01f, -9.63513330e-02f, 4.51227315e-02f, 3.99179384e-02f, -3.19087654e-02f, 6.31987527e-02f, -6.42030910e-02f, 7.69440308e-02f, 1.35247614e-02f, 3.65387276e-02f,
  -3.48877758e-02f, -3.86042404e-03f, -1.54858856e-02f, -1.12747774e-03f, 8.12004227e-03f, -1.46132000e-02f, -2.92700175e-02f, -2.17447039e-02f, -2.19957139e-02f, 5.32905832e-02f,
  4.59400974e-02f, 2.88676620e-02f, -5.10544404e-02f, 4.70723659e-02f, -9.20288824e-03f, 4.97077480e-02f, -4.85803336e-02f, 6.16400614e-02f, -1.31558590e-02f, 1.74004361e-01f,
  3.74577314e-01f, 9.30554643e-02f, -2.50542909e-02f, 1.27726182e-01f, 5.18117275e-04f, -2.09118903e-01f, -9.57146436e-02f, -9.78701860e-02f, 1.31011054e-01f, 2.22386979e-02f,
  2.89758071e-02f, 1.15970463e-01f, 4.18315008e-02f, -2.68872604e-02f, 3.67829055e-02f, -1.01185767e-02f, 1.34889884e-02f, 9.26027298e-02f, -1.04041032e-01f, -3.78930494e-02f,
  -1.30916294e-02f, 8.11242908e-02f, 1.92511335e-01f, -4.48583588e-02f, -2.52365397e-04f, 8.29981863e-02f, 3.03211808e-02f, 5.78093417e-02f, -2.31630206e-02f, 6.14498854e-02f,
  -3.02935746e-02f, -1.95972603e-02f, -2.36202944e-02f, 1.04690515e-01f, 2.15076003e-02f, 6.72306418e-02f, 1.20737413e-02f, 3.16695422e-02f, -4.30008881e-02f, -5.05839810e-02f,
  4.92222123e-02f, 1.97315495e-03f, 2.35116463e-02f, 1.43107641e-02f, -4.62107807e-02f, -2.50026174e-02f, 2.67866813e-02f, 5.02272174e-02f, -3.31136063e-02f, -8.62566754e-02f,
  -2.26476602e-02f, -9.81689009e-05f, -3.33961211e-02f, -8.84181932e-02f, -3.65516320e-02f, -7.82411844e-02f, -1.26231670e-01f, -3.37340944e-02f, -3.70996259e-02f, 8.56465697e-02f,
  -3.21180485e-02f, -4.86624502e-02f, 2.16537770e-02f, -3.58080342e-02f, -6.16565673e-03f, -3.70514132e-02f, 6.16143979e-02f, 1.99377537e-02f, 4.70997654e-02f, 3.23053147e-03f,
  5.98555356e-02f, 3.32347415e-02f, -9.02894046e-03f, 6.98722675e-02f, -5.24491407e-02f, 5.19518666e-02f, -1.22064650e-02f, -5.55576421e-02f, 2.68087331e-02f, 5.10627367e-02f,
  -3.28371823e-02f, 1.58166401e-02f, -4.22849394e-02f, 1.64413527e-02f, -6.50712010e-03f, -1.56795047e-02f, 1.94564462e-04f, -5.95427677e-02f, -2.72658337e-02f, -3.51493037e-03f,
  1.85965955e-01f, -1.86571077e-01f, 9.25035253e-02f, 2.59822067e-02f, 1.36408480e-02f, -2.82330289e-02f, 2.98306700e-02f, -3.06271855e-02f, -1.83258019e-02f, -4.48439531e-02f,
  -4.09505293e-02f, 2.57731043e-02f, 2.33871117e-02f, 3.85911837e-02f, 3.50047164e-02f, -5.80052994e-02f, 3.53910327e-02f, 1.06742643e-01f, -8.55526924e-02f, 1.34378746e-02f,
  -5.92328906e-02f, 6.52929023e-02f, 7.00854976e-03f, -4.18149270e-02f, 4.71514091e-02f, -6.66327635e-03f, -6.52970299e-02f, -1.40808262e-02f, 8.75008013e-03f, 1.58936754e-01f,
  -2.06848219e-01f, -1.03723615e-01f, -2.54018575e-01f, -2.05401227e-01f, 1.66915858e-03f, 1.35750845e-01f, 1.33006260e-01f, 8.15767795e-02f, -1.62908603e-02f, -4.87086875e-03f,
  4.00170721e-02f, -4.10326617e-03f, -1.56982988e-01f, -6.53808862e-02f, 5.02096210e-03f, -1.24314487e-01f, -1.37647629e-01f, -1.31284997e-01f, 1.49320886e-01f, 1.45095378e-01f,
  5.73003218e-02f, -3.82508859e-02f, -9.63357463e-02f, -6.81008846e-02f, -1.50233358e-01f, 3.50763625e-03f, -1.25702858e-01f, -1.06629297e-01f, -1.01602390e-01f, -2.84363776e-01f,
  -1.68559656e-01f, -1.56982075e-02f, 1.07183345e-01f, 3.98740545e-03f, -6.51967824e-02f, 2.60786805e-02f, 1.99630186e-02f, -9.79379341e-02f, 6.04613200e-02f, -3.13667506e-02f,
  3.58274505e-02f, -4.18338031e-02f, -5.11944257e-02f, 8.38005766e-02f, 1.01268180e-01f, 6.25780970e-02f, -4.27543446e-02f, 1.27548687e-02f, 5.29366620e-02f, -2.27640606e-02f,
  3.27447541e-02f, -1.00780725e-01f, -3.31321061e-02f, 8.75170752e-02f, 9.20231417e-02f, 5.72789684e-02f, 2.52089463e-02f, 8.22505280e-02f, 6.07208814e-03f, 4.86630835e-02f,
  3.11281923e-02f, -1.99635383e-02f, 9.56504568e-02f, 1.89313889e-02f, 6.50970489e-02f, -9.16002970e-03f, -8.28370228e-02f, 7.80415256e-03f, 1.06969960e-01f, -8.62478167e-02f,
  2.95074582e-02f, -7.02492986e-03f, 1.16337491e-02f, -6.71298206e-02f, -5.64797688e-03f, -5.49641214e-02f, 6.50981814e-02f, 4.41690981e-02f, 2.19379887e-02f, 6.05678149e-02f,
  -6.24595284e-02f, -4.09963727e-02f, -7.26397336e-02f, 1.02379627e-03f, -1.01340786e-02f, -1.80328786e-02f, 2.07592342e-02f, 7.19709322e-03f, -4.59031723e-02f, 1.00828568e-02f,
  -7.04240948e-02f, 1.68293461e-01f, -2.04824731e-02f, -3.00363582e-02f, -6.89230561e-02f, 1.79133250e-03f, -1.55787049e-02f, 1.19423280e-02f, -1.33579187e-02f, -2.87481416e-02f,
  9.67225581e-02f, -3.46989781e-02f, -8.42231214e-02f, -3.22350040e-02f, 8.28795061e-02f, 1.21912427e-01f, 5.67280725e-02f, -1.07094921e-01f, -3.10582537e-02f, 6.09239973e-02f,
  -7.21883476e-02f, 3.50966863e-02f, -5.12159690e-02f, -5.82579896e-02f, -4.32019532e-02f, -2.01137364e-02f, -1.22651905e-02f, 3.80908251e-02f, 7.87058845e-02f, 8.24164450e-02f,
  -2.77771145e-01f, 2.36934461e-02f, 4.50682849e-01f, -1.69452637e-01f, 2.92671006e-02f, 1.19414330e-01f, 1.48120215e-02f, -4.88471799e-02f, -1.78668514e-01f, 1.74585748e-02f,
  5.09936698e-02f, -1.09158657e-01f, -1.09521329e-01f, 1.05265258e-02f, -2.54318211e-02f, 1.37734085e-01f, 1.05766512e-01f, 6.71578646e-02f, -8.29614699e-02f, -3.12886760e-02f,
  -8.88531283e-02f, -7.82563910e-02f, -1.47455379e-01f, -4.74182032e-02f, -3.87532637e-02f, -4.10853699e-02f, 4.69535291e-02f, 3.65553908e-02f, 5.77347800e-02f, 1.16084307e-01f,
  3.53123128e-01f, 1.31053910e-01f, -2.06761453e-02f, -1.06900088e-01f, 1.26877576e-01f, -9.02789384e-02f, 3.30898836e-02f, -6.13202192e-02f, 5.38856536e-02f, 7.83287436e-02f,
  2.47541796e-02f, -7.56605342e-02f, -9.23653990e-02f, 6.53394237e-02f, 3.98827903e-02f, -2.91889952e-03f, -4.25354764e-02f, -8.56297538e-02f, -4.36158031e-02f, 8.20031390e-02f,
  -3.93070467e-02f, 1.09686889e-01f, 7.34064132e-02f, 1.19507246e-01f, 8.58461484e-02f, -4.65514883e-02f, 1.53063849e-01f, 1.11108504e-01f, 4.95272577e-02f, -8.78616124e-02f,
  -4.51664552e-02f, -5.18650573e-04f, 3.54112573e-02f, -7.07826838e-02f, -6.64129406e-02f, 8.06464851e-02f, 4.12093513e-02f, 3.49756256e-02f, -7.30667040e-02f, 3.03993025e-03f,
  -4.42250781e-02f, 3.48924957e-02f, -1.45707773e-02f, -1.27137313e-02f, 1.69016141e-02f, -1.36158720e-03f, 2.44816933e-02f, -1.74001679e-02f, -5.76995965e-03f, 3.73629183e-02f,
  6.74042167e-05f, -1.71648916e-02f, -3.96461710e-02f, -3.08731664e-02f, 4.84195165e-02f, 4.47613150e-02f, 4.18849699e-02f, 2.20845230e-02f, 1.87815318e-03f, 5.79702493e-04f,
  -9.52540338e-02f, 2.30199471e-02f, -6.67047426e-02f, -7.22514912e-02f, 4.29529920e-02f, -3.00422590e-02f, 4.17423286e-02f, -1.22827152e-02f, 5.60333114e-03f, -3.90370078e-02f,
  6.64140657e-02f, -4.41261008e-02f, 7.31253251e-02f, -4.97115739e-02f, -5.01752049e-02f, 4.46682498e-02f, -6.45963550e-02f, 3.97473685e-02f, -2.73665530e-03f, -2.53584646e-02f,
  9.44578461e-03f, -4.53179032e-02f, -8.80843997e-02f, -1.04130693e-02f, -3.56820151e-02f, -4.30813208e-02f, 5.23938872e-02f, -1.68838147e-02f, 7.39072100e-04f, -1.27769515e-01f,
  -1.73584804e-01f, -7.90457502e-02f, -2.40971282e-01f, -4.37978618e-02f, 6.44263476e-02f, -7.92003796e-02f, -1.16891921e-01f, -1.28415421e-01f, -4.46223021e-02f, -9.39992350e-03f,
  2.64444798e-01f, 2.35678315e-01f, 7.08126649e-03f, -5.46480566e-02f, -1.91495061e-01f, -1.98359191e-01f, -3.47811222e-01f, -1.89989462e-01f, -1.59053862e-01f, -2.03168746e-02f,
  1.13377400e-01f, -3.46351936e-02f, -1.67384207e-01f, -4.73230444e-02f, 8.74882862e-02f, -1.39460722e-02f, 4.20174785e-02f, 1.54190352e-02f, -1.52206430e-02f, -8.12298134e-02f,
  1.25876844e-01f, 4.86322194e-02f, -5.66968843e-02f, 7.09283799e-02f, -1.00291157e-02f, -6.64743483e-02f, 7.77820684e-03f, -6.34099096e-02f, 7.68827945e-02f, -2.87532061e-02f,
  7.56159499e-02f, 3.78965326e-02f, -4.46453020e-02f, 9.04530883e-02f, 1.84524041e-02f, 6.10579029e-02f, -1.24999404e-01f, -1.03608958e-01f, 3.31024975e-02f, -1.50945913e-02f,
  1.70726687e-01f, 1.14208028e-01f, -2.13065408e-02f, -3.61716822e-02f, 1.02103949e-02f, 1.00467063e-01f, -2.68728510e-02f, 6.43308088e-02f, -3.33090220e-03f, -7.23023564e-02f,
  -4.65537198e-02f, 2.18139328e-02f, 1.01333391e-03f, 2.70844735e-02f, 1.02619253e-01f, 8.00643349e-04f, -2.80622374e-02f, -1.38519900e-02f, -1.30349193e-02f, -1.83775071e-02f,
  8.38385057e-03f, 3.48295271e-02f, -6.41205683e-02f, -5.67466170e-02f, -2.95169652e-02f, 1.81695484e-02f, 4.91845980e-02f, 7.00952904e-03f, -3.60647822e-03f, 4.42742631e-02f,
  1.38613172e-02f, 7.74877742e-02f, -6.18012771e-02f, 7.61119276e-02f, -1.77840106e-02f, -5.75252362e-02f, -3.64251137e-02f, 4.17917110e-02f, 7.02173859e-02f, -5.19136675e-02f,
  1.98300794e-01f, -4.41675782e-02f, 3.21154483e-02f, -3.90024064e-03f, -4.05681878e-02f, 4.37959433e-02f, 8.78305957e-02f, -8.87788832e-03f, 3.35678533e-02f, -6.17950282e-04f,
  9.50970575e-02f, 2.04544347e-02f, 7.46215731e-02f, -5.31064533e-02f, 1.08743571e-02f, -6.61281422e-02f, -2.30290182e-02f, 3.92907523e-02f, -7.45768175e-02f, 4.35851961e-02f,
  -4.09142002e-02f, -6.30383790e-02f, 1.40205212e-02f, 5.48974751e-03f, 5.30048572e-02f, -4.65691760e-02f, 1.14720076e-01f, -5.51200137e-02f, -6.19114116e-02f, -7.08373338e-02f,
  -8.47359970e-02f, -1.91874072e-01f, -4.21754234e-02f, -1.23837180e-01f, -1.85206309e-01f, -3.04677695e-01f, -3.54425043e-01f, -2.95182467e-02f, 4.21478599e-02f, -1.39833745e-02f,
  -9.96923167e-03f, 4.55761552e-02f, 1.25279725e-01f, 2.14617625e-01f, 8.77754986e-02f, -1.84478275e-02f, -8.64262953e-02f, 1.49618417e-01f, 1.88032970e-01f, 2.50253361e-03f,
  5.36277471e-03f, -9.21897739e-02f, 7.38067850e-02f, 1.00683048e-01f, 6.85301647e-02f, 3.15545686e-02f, -1.22628715e-02f, 1.76859908e-02f, -4.93139736e-02f, 1.21209383e-01f,
  1.13245837e-01f, -1.66088343e-02f, 9.08297580e-03f, -2.17487291e-02f, -6.10412061e-02f, 7.84398541e-02f, -3.55430343e-03f, 1.00234821e-02f, 3.49216349e-02f, -2.77832933e-02f,
  -7.89362714e-02f, 2.19481793e-04f, 2.66942810e-02f, -1.96044631e-02f, 1.17754824e-02f, -7.00207800e-02f, 7.06024468e-02f, 1.44474790e-01f, 4.28757183e-02f, 6.55335709e-02f,
  3.03310435e-02f, -8.63555670e-02f, -1.29971012e-01f, 8.11836794e-02f, 1.27533348e-02f, 4.28300031e-04f, -4.04847376e-02f, 1.17603615e-01f, -5.47597818e-02f, 9.90457460e-03f,
  -6.68906197e-02f, -1.28700119e-02f, -3.41300331e-02f, 1.86825749e-02f, -5.13349548e-02f, 5.65388948e-02f, -6.78762840e-03f, -6.05106056e-02f, 6.70398325e-02f, -1.32243810e-02f,
  4.42614630e-02f, -4.33171690e-02f, -2.47771349e-02f, -3.84758674e-02f, -1.22158518e-02f, -6.06331266e-02f, 1.38102556e-02f, 2.96119638e-02f, 4.34168503e-02f, 3.32547612e-02f,
  8.49237666e-03f, -2.54512262e-02f, -5.95446303e-02f, 4.03798819e-02f, 5.42581007e-02f, -5.55853732e-02f, 1.86276548e-02f, 3.08434926e-02f, 3.35907675e-02f, -7.33205378e-02f,
  7.00344294e-02f, -6.66668862e-02f, 8.89982730e-02f, 1.41325682e-01f, -2.58246232e-02f, 5.11521287e-02f, -4.86575104e-02f, 1.86700094e-02f, -3.04119345e-02f, 4.53795567e-02f,
  6.21359646e-02f, 1.82372145e-02f, 5.58308139e-02f, -1.62429176e-02f, -7.98721537e-02f, -1.25522548e-02f, -1.00273173e-02f, 2.82017253e-02f, -6.62663439e-03f, -2.13404463e-04f,
  -2.38829162e-02f, -1.76343426e-01f, -4.81631979e-02f, 5.12068486e-03f, 2.84706149e-02f, 4.40870263e-02f, -8.11051577e-02f, 3.39780864e-03f, -1.01804055e-01f, -1.30028322e-01f,
  3.18169504e-01f, 2.07285345e-01f, 4.50747870e-02f, 1.47084028e-01f, -9.70588848e-02f, -2.02451870e-01f, -1.89847350e-01f, -1.11532882e-01f, 4.80093574e-03f, 7.59175494e-02f,
  2.27119122e-02f, 1.50527656e-02f, 1.32769972e-01f, 3.14487219e-02f, 3.70848784e-03f, 1.42324129e-02f, -7.26735890e-02f, 1.26868645e-02f, -1.82424590e-01f, -6.25179112e-02f,
  2.91606709e-02f, 1.18749283e-01f, 3.41120027e-02f, 5.81778511e-02f, 1.15264589e-02f, 1.44192930e-02f, -1.38977375e-02f, 7.10888579e-02f, 1.15356753e-02f, 2.02251911e-01f,
  3.44991773e-01f, 1.58495344e-02f, -7.73336068e-02f, 3.00566349e-02f, 1.73045341e-02f, 4.13985550e-02f, 7.74891898e-02f, -5.27894372e-05f, 9.34194848e-02f, 6.94052577e-02f,
  -1.41393542e-02f, -6.94141686e-02f, 4.60081622e-02f, -2.48848479e-02f, -7.51734748e-02f, -1.82187930e-02f, -7.23518282e-02f, 3.27678137e-02f, -7.75466189e-02f, -2.82235071e-02f,
  3.54976114e-03f, 2.03957092e-02f, -4.10965793e-02f, 2.36031488e-02f, -4.58441302e-02f, 2.03870609e-03f, -7.14217126e-02f, -1.15316130e-01f, -8.61262083e-02f, 1.49910852e-01f,
  -4.38648462e-02f, 6.01001121e-02f, 7.06016039e-03f, 1.43198455e-02f, 4.58127894e-02f, 2.87294313e-02f, 1.65184704e-03f, -1.09338565e-02f, -6.72159716e-02f, 1.42877940e-02f,
  -6.87035322e-02f, -3.88282724e-02f, 1.02558453e-02f, -1.88171528e-02f, 5.60754985e-02f, 5.34073748e-02f, 1.08466940e-02f, -4.95992182e-03f, 6.30737469e-02f, -5.08394726e-02f,
  4.62090671e-02f, -5.77446595e-02f, 1.52047863e-02f, -3.47690023e-02f, -1.14113793e-01f, 4.31825966e-02f, 7.14523196e-02f, -9.00339261e-02f, 4.82875146e-02f, 3.03963069e-02f,
  3.65082085e-01f, -2.30075151e-01f, 7.46142268e-02f, 1.73279103e-02f, 7.95234889e-02f, -5.51523380e-02f, 7.07094092e-03f, 3.13432440e-02f, 2.02009417e-02f, -3.31521258e-02f,
  -9.93458927e-02f, 9.30813104e-02f, 9.22060534e-02f, -6.54825196e-02f, -1.73559657e-03f, 6.77235201e-02f, -2.86784116e-02f, 4.78689224e-02f, 5.82808955e-03f, 5.54599985e-02f,
  5.70195680e-03f, 6.07812293e-02f, 5.81611320e-02f, 1.43850055e-02f, -9.34056863e-02f, -5.12925908e-03f, 4.55395356e-02f, 3.76990959e-02f, 8.47894140e-03f, 2.50258625e-01f,
  2.00540349e-02f, 3.50218453e-02f, -1.84223831e-01f, -1.72746748e-01f, -1.52083829e-01f, -1.29365489e-01f, -1.41236067e-01f, -7.53568411e-02f, -6.89918324e-02f, -1.57801464e-01f,
  -1.45399377e-01f, -1.47104248e-01f, -1.49337590e-01f, -7.53004402e-02f, -9.89964828e-02f, -1.83617800e-01f, -1.96506843e-01f, -2.09595069e-01f, -1.24431685e-01f, -1.96662501e-01f,
  -4.62534055e-02f, -1.96891695e-01f, -8.05554241e-02f, -8.75947028e-02f, 5.19040376e-02f, -9.90456156e-03f, -9.43591818e-02f, -1.57617897e-01f, -7.48602077e-02f, -1.30283505e-01f,
  -2.47197047e-01f, 7.40492344e-02f, 1.34220356e-02f, 6.96178004e-02f, -9.92959738e-02f, 9.47293043e-02f, -5.15458211e-02f, -4.17324975e-02f, 3.04401536e-02f, -5.17820381e-02f,
  -7.03963116e-02f, 4.58828621e-02f, -3.08649428e-02f, -4.47407588e-02f, -1.33338543e-02f, -6.11988567e-02f, -8.30079690e-02f, -5.94467744e-02f, 4.58912924e-02f, 6.95374161e-02f,
  1.80705227e-02f, 2.32866337e-03f, -1.78966578e-02f, -2.65295524e-02f, 8.27995613e-02f, 9.05667916e-02f, -8.85380711e-03f, 7.16042370e-02f, 6.10502213e-02f, 1.67255756e-02f,
  -8.13729167e-02f, 4.38682102e-02f, -4.30298820e-02f, 6.72755465e-02f, -5.29392622e-02f, 5.23508936e-02f, 1.43832872e-02f, -3.28033268e-02f, 5.67339994e-02f, -1.99752171e-02f,
  -1.61527544e-02f, -5.97954206e-02f, 1.11375200e-02f, -4.32285294e-02f, -8.89325812e-02f, -1.47729479e-02f, -4.03129049e-02f, 2.87421849e-02f, -5.55350387e-04f, 4.44970950e-02f,
  4.09506075e-02f, -1.31158503e-02f, -6.00742400e-02f, 6.84895515e-02f, -5.75937070e-02f, -7.15745389e-02f, 3.56174889e-03f, 4.61293794e-02f, 6.73338249e-02f, 6.06403053e-02f,
  -1.97711140e-02f, -6.55294731e-02f, 3.20608988e-02f, 4.02853899e-02f, 6.06917171e-03f, 1.44654028e-02f, 9.73527692e-03f, 6.42491728e-02f, -2.59192102e-02f, -6.42984314e-03f,
  7.26952255e-02f, 9.98098403e-03f, 3.78146805e-02f, 3.19382697e-02f, -3.06544565e-02f, -4.27339301e-02f, -7.27039799e-02f, -8.01290050e-02f, -9.32437368e-03f, 4.46876623e-02f,
  -3.59003767e-02f, -8.75416175e-02f, 2.69032363e-02f, 2.74003427e-02f, 1.63148604e-02f, 8.73608887e-03f, -3.67417298e-02f, 5.05670980e-02f, 2.28360854e-02f, -1.02954239e-01f,
  -5.15367389e-01f, 4.41509038e-02f, 2.43789881e-01f, -9.70033258e-02f, 9.95096937e-02f, 1.20594047e-01f, 2.06162065e-01f, 3.70031819e-02f, -1.19255915e-01f, 7.20594600e-02f,
  -4.79002893e-02f, -2.47445703e-01f, -1.37169257e-01f, -7.58940428e-02f, -1.82790190e-01f, 1.26041859e-01f, 1.13877423e-01f, -1.05161324e-01f, -9.38974321e-02f, -7.33045340e-02f,
  2.50908732e-02f, -1.49998233e-01f, -1.34727061e-01f, -8.45294669e-02f, 1.40225679e-01f, -5.25241438e-03f, 1.58612013e-01f, 7.01904446e-02f, 1.28978640e-01f, 2.15155892e-02f,
  5.07251546e-03f, 4.38993201e-02f, -1.04804121e-01f, -1.27108634e-01f, 1.54595062e-01f, -4.83900756e-02f, -8.13626945e-02f, -6.55409023e-02f, 3.51821706e-02f, -7.06361085e-02f,
  6.17755689e-02f, -7.04520196e-02f, -4.59220335e-02f, 1.06146209e-01f, 3.08497064e-02f, 2.85010505e-02f, 1.06953615e-02f, 2.20086630e-02f, 2.32137693e-03f, 4.42125322e-03f,
  1.59100518e-01f, -8.89358670e-03f, 7.42067397e-02f, 3.18857357e-02f, 1.43636659e-01f, 1.00307781e-02f, 5.31196520e-02f, -5.55330282e-03f, 1.06876552e-01f, -8.42210650e-02f,
  -2.62496565e-02f, -2.18754611e-03f, 3.12857330e-02f, -2.84105502e-02f, -2.69184709e-02f, -5.55226300e-03f, 5.34771048e-02f, 2.21934952e-02f, -2.84185037e-02f, 8.51214975e-02f,
  3.21931317e-02f, -3.99792530e-02f, -3.01718377e-02f, -4.85477969e-02f, -2.52423771e-02f, 1.55088119e-02f, -3.47223245e-02f, 1.49042411e-02f, -1.04054399e-02f, -3.15950476e-02f,
  -5.02043255e-02f, 5.22347121e-03f, 9.30553675e-02f, -2.21563801e-02f, 3.30346674e-02f, 3.62546626e-03f, 1.59433745e-02f, -7.06643313e-02f, 6.72413483e-02f, 1.86873451e-02f,
  -2.03749806e-01f, -1.83904842e-02f, -1.21392578e-01f, -6.30821511e-02f, 1.86639950e-02f, 1.44613413e-02f, 6.58343807e-02f, -3.56933242e-03f, -5.22898883e-02f, 7.66907725e-03f,
  5.70340864e-02f, -1.42651778e-02f, 7.84243122e-02f, 8.28023348e-03f, -1.64041426e-02f, -2.32321266e-02f, 8.09539631e-02f, -1.73733551e-02f, -1.00583211e-02f, 1.40595681e-03f,
  1.14684656e-01f, -8.35309178e-03f, -2.48537287e-01f, -1.10249586e-01f, -5.25865480e-02f, -2.33733922e-01f, -5.72625995e-02f, 5.59108332e-02f, -8.23182538e-02f, -1.90967292e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.57901481e-01f, 2.45456416e-02f, -3.93554056e-03f, -2.02025287e-03f, 1.42008945e-01f, 1.21102117e-01f, 1.17063873e-01f, 1.56790271e-01f, 3.51692624e-02f, -7.83575773e-02f,
  2.47342531e-02f, -1.13690361e-01f, -2.27683748e-04f, -4.26333956e-02f, 7.18011856e-02f, 8.59116614e-02f, -3.71255688e-02f, -4.32760008e-02f, 2.59300210e-02f, 4.51694839e-02f,
  1.86734274e-02f, -4.17245962e-02f, -4.55011688e-02f, 2.89765280e-02f, -6.66380897e-02f, -8.38237256e-02f, -8.88554081e-02f, -9.31655839e-02f, 4.41201255e-02f, 3.49970087e-02f,
  -1.62553504e-01f, -4.35857475e-02f, 9.81720909e-02f, -7.41722286e-02f, -4.12542336e-02f, -2.20434703e-02f, -9.36138406e-02f, -3.44598927e-02f, -8.89297482e-03f, -8.46477076e-02f,
  -4.15901355e-02f, 5.03106713e-02f, -5.06563969e-02f, -8.44417363e-02f, -2.68652886e-02f, -4.05558981e-02f, -8.70238915e-02f, -8.32920000e-02f, -1.83787458e-02f, -8.19830373e-02f,
  8.49946737e-02f, -9.57004055e-02f, -1.22848473e-01f, 9.98130292e-02f, -2.31046863e-02f, -7.39777833e-02f, -1.93437338e-02f, -6.64527863e-02f, -1.69361755e-02f, -3.98155786e-02f,
  7.18542188e-03f, -4.49563051e-03f, 3.86965112e-03f, -4.19966020e-02f, -1.07277976e-02f, -7.49382824e-02f, -2.23845486e-02f, 5.99447824e-02f, 9.79924668e-03f, -4.36985306e-02f,
  5.91927283e-02f, 5.23899645e-02f, -4.56707664e-02f, 7.18329623e-02f, -9.92716104e-02f, -7.34376758e-02f, 7.01818764e-02f, -3.90129723e-02f, 7.59401992e-02f, 1.93401682e-03f,
  -5.73048294e-02f, 9.50837508e-03f, -7.81499892e-02f, 6.24499880e-02f, 9.28753689e-02f, 2.47355457e-02f, 9.00041610e-02f, 7.51361325e-02f, -6.54445440e-02f, -3.87107879e-02f,
  -1.60554412e-03f, -2.21983325e-02f, -8.88566151e-02f, 2.11586785e-02f, 1.32685271e-03f, 4.34700288e-02f, 1.67145450e-02f, -9.49006900e-03f, 2.59054881e-02f, 7.66723156e-02f,
  -2.79094968e-02f, 5.10898866e-02f, -7.29068369e-02f, 1.32728266e-02f, -5.58533855e-02f, 8.02990496e-02f, 9.82878953e-02f, 3.88039127e-02f, 6.53481781e-02f, -4.10397165e-02f,
  4.76829633e-02f, -6.76478222e-02f, -4.28511985e-02f, 5.51936701e-02f, 1.57760270e-02f, -6.03510663e-02f, -2.40837615e-02f, -7.92191401e-02f, -8.06992203e-02f, -6.02685788e-04f,
  -2.02313042e-03f, 6.42812252e-02f, 2.57881097e-02f, -1.17684208e-01f, -1.69971026e-02f, 7.01761022e-02f, 1.76549837e-01f, 4.34742821e-03f, -2.69793672e-03f, -5.97887039e-02f,
  -5.48878349e-02f, -9.93690193e-02f, -1.55303612e-01f, -6.76399991e-02f, -5.80007285e-02f, 1.08967777e-02f, 4.40416783e-02f, 4.24849465e-02f, -8.77602119e-03f, 7.46034086e-02f,
  -8.32655877e-02f, 3.02462764e-02f, -9.77140218e-02f, -8.52255449e-02f, -4.21489552e-02f, -4.83429432e-02f, -8.18788558e-02f, -1.29435256e-01f, 3.29270810e-02f, -8.88709277e-02f,
  2.10907906e-02f, -6.94295913e-02f, -5.09332940e-02f, -4.70623970e-02f, 7.53489230e-03f, -2.11537555e-02f, 6.22944161e-02f, -5.16475663e-02f, -5.38957790e-02f, 3.73711251e-02f,
  -1.67057216e-02f, 1.12202689e-02f, 5.77687705e-03f, -3.06732394e-02f, -7.95964971e-02f, -6.92465901e-02f, -4.85273311e-03f, -3.38549949e-02f, 2.08162572e-02f, -4.46439050e-02f,
  5.82826212e-02f, 6.75142407e-02f, 3.16394977e-02f, 7.13535175e-02f, 2.20242105e-02f, 3.18518132e-02f, -8.41253474e-02f, 4.08121338e-03f, 8.91657770e-02f, -1.17969522e-02f,
  7.42044598e-02f, 2.87081916e-02f, 6.14952482e-02f, 7.32166916e-02f, 3.87967564e-02f, 7.38471076e-02f, 1.42528238e-02f, 5.37714735e-02f, -7.12976158e-02f, -6.26709461e-02f,
  6.76653115e-03f, 1.26154060e-02f, -2.82882266e-02f, -5.90414889e-02f, -1.51211629e-02f, -6.23591691e-02f, -2.28987597e-02f, -2.31016278e-02f, -8.82028230e-03f, 2.65893955e-02f,
  8.74264091e-02f, 8.37037116e-02f, -4.62156460e-02f, -7.23147616e-02f, -4.33518551e-02f, -4.39879075e-02f, -4.91290465e-02f, 2.05095038e-02f, -5.30912206e-02f, -3.90412360e-02f,
  2.25553960e-02f, 7.74053484e-02f, 2.79828720e-02f, 4.47761305e-02f, -6.99441582e-02f, -6.59391209e-02f, -6.56039966e-03f, 4.55896631e-02f, 1.20071098e-02f, -4.90191504e-02f,
  -2.27037314e-02f, -9.01848078e-03f, -3.59232575e-02f, 2.39534806e-02f, -2.16109976e-02f, 7.54151568e-02f, 1.05185958e-03f, -2.41092697e-04f, -7.11431876e-02f, -1.55759268e-02f,
  -7.38292979e-03f, 1.25254035e-01f, -6.13101339e-03f, 1.28482804e-02f, -6.39135540e-02f, -7.74395466e-02f, -1.67709615e-04f, 5.04349135e-02f, 5.44980578e-02f, 1.69882074e-01f,
  -3.78459208e-02f, -6.60774484e-02f, 9.75305960e-02f, 1.65603772e-01f, 1.66260228e-01f, 6.41306415e-02f, 1.56565458e-01f, 1.90260634e-02f, 9.50442106e-02f, 1.48523286e-01f,
  1.38704494e-01f, 1.84066489e-01f, 3.49225663e-02f, 1.00355051e-01f, 4.83821146e-02f, 1.06019683e-01f, 1.37195541e-02f, -1.35331731e-02f, 1.38019770e-01f, 8.35751891e-02f,
  6.40884191e-02f, 7.67666921e-02f, 1.98696437e-03f, 9.48753878e-02f, -5.32275951e-03f, 1.03000268e-01f, 4.63615581e-02f, -4.94313240e-02f, 1.56704038e-02f, -6.59188405e-02f,
  -1.73087139e-02f, -1.99756324e-02f, 1.01978086e-01f, -7.96887502e-02f, 5.09429574e-02f, -1.00724891e-01f, -9.88632441e-02f, -1.30013391e-01f, -1.32557750e-02f, 1.74445268e-02f,
  -7.58862644e-02f, -9.72568318e-02f, 4.27993871e-02f, -9.66134481e-03f, -4.50788662e-02f, 2.64929589e-02f, -6.43394887e-02f, -1.22779021e-02f, 3.66207808e-02f, -2.26933099e-02f,
  2.01312806e-02f, -6.04926571e-02f, 5.02880998e-02f, -1.48044005e-02f, 7.92642161e-02f, 6.90233260e-02f, 1.18851122e-02f, 3.54325436e-02f, 3.06941234e-02f, -4.15878110e-02f,
  2.43950281e-02f, 7.84317404e-02f, 1.55898016e-02f, 4.51465473e-02f, -3.60835181e-03f, 6.92956150e-02f, 7.36024901e-02f, 3.12955566e-02f, 8.51382017e-02f, -1.17494473e-02f,
  -1.95962936e-02f, -4.57508378e-02f, 2.86343843e-02f, -3.64976451e-02f, -3.32047716e-02f, 5.79341501e-02f, -7.28899688e-02f, -4.20992896e-02f, -4.36271504e-02f, -1.58710331e-02f,
  -5.70785291e-02f, 8.73346720e-03f, -8.23687688e-02f, 4.04871702e-02f, 8.90903473e-02f, -5.71125485e-02f, 9.28915814e-02f, -2.50043776e-02f, -6.76682591e-02f, 6.08213665e-03f,
  -1.97167005e-02f, 4.52554189e-02f, 9.15162638e-02f, 5.83329797e-03f, 7.47217238e-02f, -2.53641438e-02f, -2.86767725e-02f, -7.40645900e-02f, -8.22024234e-03f, -2.96858251e-02f,
  4.02316526e-02f, -6.91548139e-02f, 6.73234388e-02f, -9.20198336e-02f, -5.69816791e-02f, -3.06008570e-02f, -8.54448825e-02f, -3.16021293e-02f, 5.26907295e-02f, -6.02355935e-02f,
  -9.88476053e-02f, 3.01517993e-02f, 8.22624788e-02f, -4.50740680e-02f, 4.23348695e-03f, -4.39588390e-02f, 1.40340172e-03f, -4.77203075e-03f, 6.63763210e-02f, 3.06313615e-02f,
  -9.19112489e-02f, 5.52564189e-02f, -3.09497081e-02f, 3.65280285e-02f, -3.97090428e-02f, 3.85822728e-02f, 4.60081473e-02f, -3.58862579e-02f, -9.39231217e-02f, 6.78355396e-02f,
  7.42305592e-02f, 6.13249876e-02f, -1.99701134e-02f, -1.59901947e-01f, -1.26196608e-01f, -1.41192138e-01f, -1.62781820e-01f, -1.22894660e-01f, -1.57816052e-01f, -7.75394142e-02f,
  5.06119616e-02f, -7.24243373e-02f, -8.00466537e-02f, -1.15168609e-01f, -7.76747987e-02f, 4.01850119e-02f, -2.42572906e-03f, 5.64976642e-03f, -1.75660104e-02f, 7.70087391e-02f,
  3.67013402e-02f, -3.95414419e-02f, -2.02864427e-02f, 5.67022199e-03f, 1.01021148e-01f, 3.29576135e-02f, 7.22815190e-03f, 1.06907194e-03f, -4.95353341e-02f, 1.10213319e-02f,
  2.49732174e-02f, -6.26387894e-02f, -1.69959702e-02f, 3.26524377e-02f, -1.03561103e-01f, 3.09771635e-02f, -1.13171421e-01f, -1.38267189e-01f, -7.55890086e-03f, -6.06105104e-02f,
  5.17289042e-02f, 1.73170045e-02f, -5.82279228e-02f, -6.68984428e-02f, -5.93850724e-02f, -2.86869295e-02f, -8.56663212e-02f, -3.02030649e-02f, -7.57239535e-02f, -3.47447693e-02f,
  2.01634094e-02f, -3.23268659e-02f, -5.65943960e-03f, 5.31728864e-02f, -5.91866150e-02f, 4.30707335e-02f, -1.02504268e-02f, -1.16877712e-01f, 2.04725768e-02f, 1.58827491e-02f,
  -1.32398345e-02f, 6.96114078e-02f, 1.77860260e-02f, -6.88524768e-02f, -7.94362202e-02f, 5.67330755e-02f, -5.89802749e-02f, -1.15108024e-02f, 4.51050438e-02f, -9.07490030e-03f,
  -9.68597755e-02f, -4.18117903e-02f, 5.52186146e-02f, -3.77934836e-02f, -4.50548492e-02f, 4.45110537e-02f, 5.60360216e-02f, -4.98228148e-03f, -8.91759619e-03f, 1.88536551e-02f,
  -7.45509267e-02f, 1.39682665e-02f, 2.92112725e-03f, -1.12737179e-01f, 6.11993819e-02f, 3.00879832e-02f, 9.31983441e-02f, 4.37761843e-03f, -6.22168966e-02f, -3.39719765e-02f,
  -8.45602155e-02f, -1.61246415e-02f, -8.40146244e-02f, -9.84657407e-02f, -4.07550819e-02f, -5.43870926e-02f, 8.05938393e-02f, -3.85897793e-02f, -3.09220217e-02f, 9.63838100e-02f,
  -5.68284467e-02f, -6.14472963e-02f, -1.03183888e-01f, -1.14809684e-02f, 4.69704792e-02f, -1.12927407e-01f, -1.38290048e-01f, -8.75127688e-02f, -9.56371054e-02f, -1.44383833e-01f,
  -2.05711722e-01f, 1.01966923e-02f, -7.83288553e-02f, -2.64726639e-01f, -2.59588566e-02f, 7.92145322e-04f, 1.82223953e-02f, -3.09942588e-02f, -1.31433666e-01f, -1.06988631e-01f,
  -1.69799607e-02f, -1.68112270e-03f, 2.10393257e-02f, -1.08614406e-02f, 8.11496228e-02f, 4.53933142e-02f, -1.43129662e-01f, -9.83121842e-02f, 9.54109505e-02f, 4.06104848e-02f,
  -2.39221123e-03f, -1.30432174e-01f, -6.89863190e-02f, -2.38282457e-02f, -1.24867052e-01f, 3.01118456e-02f, -3.87209952e-02f, 1.09704481e-02f, 6.11167923e-02f, -1.15166739e-01f,
  2.94141740e-01f, -2.28871349e-02f, 6.82938704e-03f, -8.24967474e-02f, 4.26000021e-02f, -1.09803289e-01f, -6.78096116e-02f, -2.00083330e-02f, -3.09831724e-02f, -2.81516984e-02f,
  -5.86983822e-02f, -8.30701292e-02f, 7.91794807e-02f, 6.65800795e-02f, -3.70223634e-02f, -7.26671070e-02f, -1.29382964e-02f, -3.17930132e-02f, -6.92585930e-02f, 3.71771827e-02f,
  -1.22513939e-02f, 6.88969332e-04f, 8.94246772e-02f, 4.93956059e-02f, -1.01240456e-01f, -1.27223860e-02f, 1.05516963e-01f, -1.03287548e-01f, -4.36825082e-02f, -2.23865565e-02f,
  4.68640476e-02f, 1.74365398e-02f, 7.59690106e-02f, -9.32715684e-02f, -5.70194758e-02f, 1.31564704e-03f, 3.77010703e-02f, -5.80946030e-03f, 6.76300153e-02f, 5.05824797e-02f,
  1.18282782e-02f, -1.57647673e-02f, 4.08414528e-02f, -7.59834470e-03f, 4.33491431e-02f, 6.52338937e-02f, -9.06459391e-02f, 7.73414969e-02f, -7.28452653e-02f, -1.05391078e-01f,
  6.67464745e-04f, -4.50621219e-03f, -1.19358085e-01f, 5.43337800e-02f, -3.72705166e-03f, 2.15263963e-02f, 2.94928364e-02f, -5.93501031e-02f, -3.64717953e-02f, -7.26133212e-02f,
  1.99231416e-01f, -4.80127707e-02f, 1.00163884e-01f, -2.40469892e-02f, -6.41670451e-02f, -1.04447752e-01f, 4.34083976e-02f, -1.26371726e-01f, 1.90351326e-02f, 6.68850020e-02f,
  3.21117118e-02f, 9.00983587e-02f, 7.57270381e-02f, -1.37155643e-02f, -5.34533113e-02f, 2.55943555e-02f, 3.93443517e-02f, -2.61965711e-02f, 2.54441127e-02f, -8.98000374e-02f,
  -9.89850536e-02f, -6.47896081e-02f, 1.58466548e-01f, -8.51006247e-03f, 3.69513929e-02f, 8.11390579e-02f, 2.05468968e-01f, 1.42280489e-01f, 4.47426587e-02f, 4.45316844e-02f,
  1.25118077e-01f, -2.00339165e-02f, -1.72188446e-01f, 2.41111014e-02f, 9.19239894e-02f, 9.30742398e-02f, 4.29856814e-02f, 2.81667290e-03f, 1.21477637e-02f, -1.55337527e-02f,
  1.82213355e-03f, -7.87753835e-02f, -1.68001965e-01f, -8.63615423e-02f, -1.10086761e-01f, 1.66927259e-02f, -1.70318503e-02f, -2.22719759e-02f, -1.15395784e-02f, 1.77952752e-03f,
  8.33407119e-02f, 9.42778140e-02f, 2.01968420e-02f, -3.29353772e-02f, -3.37889642e-02f, -6.37452826e-02f, -1.13962092e-01f, -7.25039765e-02f, -1.42832980e-01f, -1.81426793e-01f,
  -7.62121845e-03f, -8.39533880e-02f, 8.28111172e-02f, -9.59122628e-02f, -3.71107198e-02f, 2.52755303e-02f, -4.73201387e-02f, 1.85466453e-03f, -6.98017364e-04f, 5.87729253e-02f,
  2.10305322e-02f, -3.61663625e-02f, -7.27255195e-02f, 2.34934650e-02f, 9.15973261e-02f, -4.96509001e-02f, 6.87371567e-02f, -1.06764749e-01f, 3.93361561e-02f, -8.15265998e-02f,
  -1.08871356e-01f, 4.15565148e-02f, -4.49509509e-02f, -6.00181147e-02f, 8.55110399e-03f, -1.43985257e-01f, 6.26756921e-02f, 4.00805250e-02f, 2.07580496e-02f, 9.27889198e-02f,
  5.32675870e-02f, 6.33428199e-03f, 6.65876374e-04f, -3.83617692e-02f, 8.78461003e-02f, 3.85835879e-02f, 9.36453938e-02f, 3.15155424e-02f, 8.43334645e-02f, 5.70757911e-02f,
  -2.36091875e-02f, -3.86177376e-02f, 1.00229837e-01f, -9.57755651e-03f, 3.34807001e-02f, -2.27444787e-02f, -3.73069197e-02f, 1.54741351e-02f, -1.10750258e-01f, -4.27496880e-02f,
  -4.33685957e-03f, 8.20764676e-02f, -4.29492965e-02f, -5.62982708e-02f, -5.68215698e-02f, 1.43143153e-02f, -7.97304064e-02f, -3.77771147e-02f, -5.78474551e-02f, -1.31380921e-02f,
  5.76627851e-02f, -1.85999870e-01f, 4.50699702e-02f, 5.58534302e-02f, -2.76885256e-02f, -2.15146914e-02f, -9.56336111e-02f, 8.78143534e-02f, -3.09183449e-02f, -4.42851931e-02f,
  -1.10318393e-01f, 3.65358144e-02f, -5.63549511e-02f, 4.26462889e-02f, 5.61961271e-02f, 6.24237694e-02f, 8.90208259e-02f, -3.27711254e-02f, -5.77206947e-02f, -4.01076004e-02f,
  5.33837043e-02f, 1.67142838e-01f, 4.48453240e-02f, 1.38291270e-01f, 5.46435639e-02f, 5.79173900e-02f, 1.15163848e-01f, 9.94335040e-02f, -3.75594798e-04f, 3.06270331e-01f,
  -3.80063541e-02f, 1.66298926e-01f, 5.55294454e-02f, 2.34537981e-02f, 9.13598016e-02f, 8.97396356e-03f, 2.95620528e-03f, 7.70372450e-02f, -9.25093591e-02f, -6.47311285e-03f,
  -3.24868248e-03f, 6.39320305e-03f, -7.93936178e-02f, -8.22787881e-02f, 5.87398335e-02f, -1.93336625e-02f, -7.61144012e-02f, -8.07782933e-02f, -1.23264439e-01f, 1.68662053e-02f,
  -6.19986840e-02f, 1.33472085e-02f, 6.74764216e-02f, 3.32740583e-02f, 6.99765533e-02f, -8.13401267e-02f, -7.03579187e-03f, -6.39014617e-02f, -6.06525838e-02f, 1.17226643e-02f,
  -4.92668850e-03f, 1.21719930e-02f, -1.06400460e-01f, -9.97922122e-02f, -3.44331786e-02f, -7.77714550e-02f, 8.37744400e-02f, 2.26832721e-02f, -8.52650255e-02f, -8.47966522e-02f,
  1.01493724e-01f, -4.73623769e-03f, 1.70741342e-02f, -3.96715328e-02f, -2.55406220e-02f, -1.98646132e-02f, -4.92617525e-02f, -6.44412860e-02f, 3.64921503e-02f, 1.06458794e-02f,
  -5.99365458e-02f, 3.22975889e-02f, 1.06304303e-01f, -2.98701134e-02f, 5.26634194e-02f, -8.64635333e-02f, 8.01010653e-02f, 1.82624217e-02f, -7.83024207e-02f, 7.96295255e-02f,
  1.71499513e-02f, 5.36270887e-02f, -1.16907852e-02f, -1.08189724e-01f, -8.59156325e-02f, -9.01044235e-02f, 4.81552863e-03f, -3.72805595e-02f, 2.78089345e-02f, -8.73782188e-02f,
  -4.51137200e-02f, 2.68200040e-02f, -9.39513892e-02f, 5.57625853e-02f, -6.01471253e-02f, -1.12031968e-02f, -1.08122922e-01f, 4.27934937e-02f, -4.74663861e-02f, 4.75453883e-02f,
  -4.78000678e-02f, -2.18412373e-02f, -6.08667843e-02f, -9.04470757e-02f, 4.22827154e-02f, 1.48681775e-02f, 1.37403617e-02f, -3.62797305e-02f, -4.97012734e-02f, -7.79689252e-02f,
  -7.64218792e-02f, 3.33897807e-02f, 8.63532722e-03f, -8.75066146e-02f, 5.04252091e-02f, -1.43511863e-02f, 2.32315548e-02f, -7.07558021e-02f, -3.64565942e-03f, -2.65206080e-02f,
  3.03423759e-02f, 4.99455445e-02f, 3.54021899e-02f, -5.60711212e-02f, 4.63364050e-02f, 2.74057984e-02f, -1.31821097e-03f, -1.47920297e-02f, 6.23142496e-02f, 1.16253216e-02f,
  1.43241957e-02f, -6.12705536e-02f, 4.03340794e-02f, 5.42141795e-02f, -4.98388410e-02f, 3.48777473e-02f, -6.71196580e-02f, 5.15663857e-03f, -4.70569655e-02f, 1.85356615e-03f,
  -4.60142307e-02f, -3.30281556e-02f, 2.08667323e-01f, -1.05988093e-01f, -1.14744686e-01f, -9.75876674e-03f, -1.21076303e-02f, -2.41742712e-02f, -1.40888810e-01f, -1.37105118e-02f,
  -6.03401624e-02f, -1.33621708e-01f, -6.62150085e-02f, 7.51266405e-02f, 9.27037597e-02f, -3.74341011e-02f, 9.99398679e-02f, 1.58430949e-01f, 7.89116789e-03f, 1.40315751e-02f,
  -1.15548573e-01f, -3.12540121e-02f, 1.11601338e-01f, 1.36887683e-02f, -1.59785859e-02f, -1.23712653e-02f, 7.34530315e-02f, 8.72069895e-02f, 6.33244514e-02f, -8.83060023e-02f,
  1.16707361e-03f, -2.15225387e-02f, 2.45453939e-02f, -4.62053120e-02f, -2.95144618e-02f, -7.66980229e-04f, -7.66079947e-02f, 1.06243685e-01f, -8.82882327e-02f, 5.33631966e-02f,
  4.95414622e-02f, -6.81912526e-02f, 3.10819061e-03f, 5.61025552e-03f, 1.90436151e-02f, -5.54081462e-02f, 1.25260189e-01f, 1.56717822e-01f, 6.47524521e-02f, -5.71992733e-02f,
  -4.86393869e-02f, 3.83259892e-03f, -2.50687301e-02f, 6.94248546e-03f, 1.08928330e-01f, 2.10712459e-02f, -3.09650078e-02f, 6.61377003e-03f, 2.25833636e-02f, -1.49644054e-02f,
  1.90299228e-02f, 4.82804030e-02f, -4.13211584e-02f, 2.02389359e-02f, 5.10636484e-03f, 8.78779497e-03f, 3.27773206e-02f, -8.03913176e-02f, -2.34431382e-02f, -4.88267560e-03f,
  -4.43461314e-02f, 2.62095667e-02f, 1.98801216e-02f, -7.92525113e-02f, -3.79643887e-02f, 1.01366388e-02f, -8.32665488e-02f, 4.68558446e-03f, 6.72327876e-02f, 6.66528009e-03f,
  1.67223178e-02f, 5.49048148e-02f, 6.68456852e-02f, 1.50539009e-02f, 7.90579095e-02f, -2.30860692e-02f, 3.80196907e-02f, -3.01302038e-02f, 3.96349877e-02f, -2.05427036e-02f,
  -1.64730504e-01f, 1.87512711e-01f, -1.41812548e-01f, -8.28901902e-02f, -2.54164785e-02f, 5.20710498e-02f, -8.88026357e-02f, -3.94987538e-02f, -4.23872918e-02f, -4.82212268e-02f,
  -7.50616193e-02f, -7.14935809e-02f, -9.81483310e-02f, -8.14768076e-02f, -3.04736401e-04f, -9.68227759e-02f, -2.84734406e-02f, -9.78174731e-02f, 5.61682433e-02f, 4.26654071e-02f,
  -2.49498766e-02f, -7.40307495e-02f, -2.43302546e-02f, -4.86526750e-02f, -1.26887709e-01f, -4.51716967e-02f, -9.26159099e-02f, -6.16061222e-03f, -4.20296937e-02f, -5.86625338e-02f,
  1.48147702e-01f, -8.79704729e-02f, 2.73475014e-02f, -2.89639714e-03f, 5.78625016e-02f, 6.69628084e-02f, 6.06571659e-02f, -8.72807950e-02f, -9.89932008e-03f, -8.89434144e-02f,
  -1.63726434e-01f, -3.15000452e-02f, -5.27027994e-02f, -1.15841083e-01f, 3.22852805e-02f, 1.16281644e-01f, 1.08296629e-02f, 7.22782835e-02f, 7.61563107e-02f, 8.04731548e-02f,
  -4.09988724e-02f, 7.51082152e-02f, -1.82545371e-02f, 7.01183826e-02f, -5.22908941e-02f, 5.76808676e-02f, 3.38458680e-02f, -2.61823144e-02f, -4.15544212e-02f, 1.35141332e-02f,
  -1.48317171e-02f, -9.03271139e-02f, -6.20906316e-02f, 6.33749962e-02f, 6.63134456e-02f, -3.83935645e-02f, -1.46272518e-02f, 9.63488519e-02f, 5.91915064e-02f, 7.66448900e-02f,
  7.32133240e-02f, -2.62844320e-02f, -1.39295496e-02f, 2.96914671e-02f, 5.63185588e-02f, 3.72859798e-02f, 5.31284101e-02f, 1.05431043e-01f, -2.54945029e-02f, -1.61669329e-02f,
  2.21341848e-02f, -2.78118253e-02f, 1.83419380e-02f, -1.08057573e-01f, -4.18922631e-03f, 2.95401253e-02f, 4.84741777e-02f, -9.89716500e-03f, -6.10858686e-02f, 7.63208270e-02f,
  -4.25655171e-02f, 1.00661762e-01f, 6.63461983e-02f, 3.09992488e-02f, -7.57365599e-02f, -2.37887958e-04f, 4.93715107e-02f, -1.56475268e-02f, 3.93375866e-02f, 5.45143485e-02f,
  5.72507828e-03f, 8.46230164e-02f, -8.63299891e-02f, 5.67678772e-02f, 4.18869369e-02f, -3.83191667e-02f, -6.25325441e-02f, -1.36130564e-02f, -1.05018362e-01f, 1.55377863e-02f,
  7.07108229e-02f, -1.00926355e-01f, -6.96885362e-02f, -7.10542351e-02f, 4.94186468e-02f, 5.15994942e-03f, 4.04523797e-02f, -7.34192580e-02f, -5.65912463e-02f, -1.02279700e-01f,
  2.05161739e-02f, -1.42332226e-01f, -8.34210031e-03f, -8.13180357e-02f, -6.46633282e-02f, 7.63886943e-02f, -2.37334780e-02f, 5.22126295e-02f, 7.55650997e-02f, -5.34537025e-02f,
  5.06537482e-02f, 4.20525037e-02f, 4.83145355e-04f, 7.89865926e-02f, -1.12808915e-02f, 3.13675888e-02f, 7.54593909e-02f, 5.82447052e-02f, -4.01796252e-02f, 4.41028289e-02f,
  3.70645039e-02f, 5.77826425e-02f, 5.16424403e-02f, 8.67364481e-02f, 8.55405908e-03f, -6.62952587e-02f, -5.63442558e-02f, -4.77172881e-02f, -5.38021475e-02f, 1.29537387e-02f,
  1.51226580e-01f, 1.44336866e-02f, 2.03139156e-01f, 1.05165653e-02f, 1.97380275e-01f, 2.25254565e-01f, 1.55818984e-01f, -4.36283741e-03f, 7.31739029e-02f, 2.76623517e-02f,
  5.95493987e-02f, -1.28050491e-01f, -1.09482639e-01f, -5.36668710e-02f, -2.20618509e-02f, -6.16829656e-02f, 4.84513752e-02f, 9.03829411e-02f, 1.59978926e-01f, -3.77309024e-02f,
  -5.71247526e-02f, -5.90457628e-03f, -1.32008027e-02f, 3.74954455e-02f, -5.40525801e-02f, -4.10248153e-02f, 4.07976881e-02f, 1.81459673e-02f, 1.82057638e-02f, 3.64252888e-02f,
  -1.56047978e-02f, 8.63271952e-02f, -5.05103506e-02f, 2.31372938e-03f, -1.91046745e-02f, -3.70627083e-02f, 9.21341181e-02f, -6.43691700e-03f, 9.58855171e-03f, -6.50917441e-02f,
  -1.03739522e-01f, -3.55331376e-02f, -8.49839896e-02f, 2.88243573e-02f, -3.26404050e-02f, 5.70484512e-02f, -8.12212229e-02f, 3.09856627e-02f, -4.73878346e-02f, -1.07158661e-01f,
  -5.06604314e-02f, 6.70445114e-02f, 4.83394079e-02f, 4.14119847e-02f, -2.78832931e-02f, 6.02811202e-02f, 4.02345732e-02f, -8.12218264e-02f, 4.06146310e-02f, 1.28674991e-02f,
  -4.62538637e-02f, 4.57948968e-02f, 4.84832712e-02f, 4.29111682e-02f, 2.55397744e-02f, -3.60571928e-02f, -3.46144587e-02f, -4.65112701e-02f, 1.91378314e-02f, 5.03234714e-02f,
  1.10334868e-03f, 7.81574920e-02f, -2.80402545e-02f, 5.63698858e-02f, -5.82155176e-02f, 1.45553704e-02f, 1.07676849e-01f, -2.71509048e-02f, 6.29502013e-02f, -3.43516730e-02f,
  -2.13297065e-02f, 1.13423921e-01f, 6.13309629e-02f, 8.02427009e-02f, -5.92012368e-02f, 4.82848212e-02f, -3.61295068e-04f, -6.07944243e-02f, 2.27476005e-02f, 2.38709953e-02f,
  -1.46643475e-01f, 2.39389259e-02f, 2.99534462e-02f, -1.00458406e-01f, -3.83848026e-02f, -4.68240529e-02f, 5.00693731e-03f, 3.67606133e-02f, -7.81690795e-03f, -6.56230189e-03f,
  -1.88802592e-02f, 4.39885929e-02f, -2.76410859e-02f, -1.08258482e-02f, 9.43366662e-02f, -1.27358288e-02f, -4.08753343e-02f, -1.97627079e-02f, -1.89500730e-02f, -4.03769203e-02f,
  -1.76845521e-01f, 7.12309927e-02f, 1.19278654e-01f, 8.95943865e-02f, -3.80756818e-02f, 1.39339671e-01f, 8.83044600e-02f, 1.57320257e-02f, 1.29181683e-01f, -3.79881337e-02f,
  -2.99869895e-01f, -1.75229952e-01f, -2.50946246e-02f, -7.30737448e-02f, -3.12373545e-02f, 3.78009006e-02f, -2.56354101e-02f, -3.67020890e-02f, -5.73746111e-05f, -1.65031865e-01f,
  -1.76770557e-02f, -4.92546447e-02f, -4.80453297e-03f, -8.73286836e-03f, 2.59139296e-02f, -1.03797317e-01f, 1.39314458e-02f, -1.44806160e-02f, 9.33494493e-02f, -9.49805826e-02f,
  -1.17337666e-01f, -8.69246796e-02f, -1.77749954e-02f, 7.62786791e-02f, 1.54548846e-02f, 2.58070491e-02f, 5.72713763e-02f, -7.83531666e-02f, -1.14212573e-01f, -7.61319101e-02f,
  -1.10205531e-01f, -6.49651960e-02f, 4.86150272e-02f, 1.24863153e-02f, -6.46935776e-03f, -2.86598671e-02f, -1.13932773e-01f, 9.70274657e-02f, 3.88730131e-02f, -8.22771192e-02f,
  -6.80072140e-03f, 5.28054088e-02f, 5.20503558e-02f, -5.13990968e-02f, -8.69161338e-02f, 3.76242138e-02f, -4.99338880e-02f, 1.89130008e-02f, -3.93800996e-02f, -4.79295552e-02f,
  -1.66210128e-04f, -1.34022743e-01f, -1.31856918e-01f, -6.44015819e-02f, 3.94770056e-02f, 2.91196089e-02f, -1.27380982e-01f, -4.09517214e-02f, -1.34024629e-02f, -1.46308348e-01f,
  4.65981178e-02f, -8.71320888e-02f, 4.43473980e-02f, -5.27208596e-02f, -1.84374414e-02f, 2.14126147e-02f, 5.04238047e-02f, 3.29426341e-02f, -4.66771750e-03f, -5.58144674e-02f,
  1.87577643e-02f, 6.08498082e-02f, 7.71823823e-02f, -2.03514658e-02f, -1.98350977e-02f, 5.56814075e-02f, -1.52387898e-02f, -1.48805045e-02f, -1.83611754e-02f, -3.04700211e-02f,
  -6.85220063e-02f, 2.10480019e-02f, 7.27119297e-02f, 1.41220186e-02f, 3.32824104e-02f, 7.12115094e-02f, -5.78104705e-02f, -4.63945232e-02f, 3.21483351e-02f, 5.51009662e-02f,
  -7.84941912e-02f, 1.12096213e-01f, -1.74943414e-02f, 3.97186801e-02f, -5.86691946e-02f, 2.61916518e-02f, 2.01971233e-02f, 3.35797854e-03f, -5.33059202e-02f, -6.07648585e-03f,
  1.90139059e-02f, -3.57527845e-02f, -5.22863679e-02f, -7.58300424e-02f, -9.20882002e-02f, -4.33840938e-02f, -6.77012131e-02f, 2.02923231e-02f, -8.37619379e-02f, 7.07043521e-03f,
  -6.97561353e-03f, -1.42947003e-01f, -2.19991103e-01f, -1.38278216e-01f, -7.04145133e-02f, -1.86494023e-01f, -1.10989407e-01f, -1.13612480e-01f, -9.17224213e-02f, -2.38931775e-01f,
  2.10089236e-01f, -1.63896218e-01f, -2.23364532e-01f, 1.69359773e-01f, -1.94788091e-02f, -7.33329207e-02f, -2.22495481e-01f, -1.19710624e-01f, -1.36253731e-02f, 5.20265661e-02f,
  8.43959153e-02f, 1.65836662e-01f, 3.79171595e-02f, 7.49236792e-02f, -1.50079951e-01f, -1.53302819e-01f, -9.39555466e-02f, 1.56664825e-03f, 1.01413906e-01f, 1.77527115e-01f,
  1.79482907e-01f, 1.63848743e-01f, 9.72484332e-03f, 8.70135203e-02f, 1.32642642e-01f, 1.45196944e-01f, -7.35507235e-02f, 8.62373784e-02f, 1.26489803e-01f, 1.99447557e-01f,
  1.61817864e-01f, -1.25640228e-01f, -4.41358872e-02f, 1.35182336e-01f, 7.79735073e-02f, 5.37933782e-02f, -8.04415941e-02f, -6.02156036e-02f, -1.63337849e-02f, 2.19534263e-02f,
  6.88755512e-02f, -6.63850978e-02f, 3.18378322e-02f, 6.42893538e-02f, -7.63331801e-02f, -1.72391837e-03f, -1.29411340e-01f, -6.54617846e-02f, -1.61185458e-01f, -1.59409419e-02f,
  1.08668551e-01f, 1.21571749e-01f, -8.20912272e-02f, -1.88256994e-01f, -1.56515583e-01f, 7.79261589e-02f, -1.32113189e-01f, -7.23339245e-02f, -1.92998592e-02f, -6.03054389e-02f,
  4.74204123e-02f, 8.17413069e-03f, -5.10853566e-02f, -9.46130976e-02f, 7.54800215e-02f, 5.27065769e-02f, 4.83872853e-02f, 5.80722140e-03f, 6.69653043e-02f, -1.11760579e-01f,
  -7.78365210e-02f, 3.95988002e-02f, -6.80807754e-02f, -5.69812879e-02f, 7.21539557e-02f, -2.78029516e-02f, -2.90754810e-02f, -2.45974846e-02f, 7.43163154e-02f, 1.46746505e-02f,
  3.85388136e-02f, -4.66832854e-02f, -6.61956370e-02f, -1.06638424e-01f, 3.69701423e-02f, 4.47295234e-02f, 7.57356659e-02f, 8.19675773e-02f, -4.19130437e-02f, 6.27204999e-02f,
  -9.54745635e-02f, -6.67157620e-02f, -7.81122409e-03f, 2.55177561e-02f, 6.63208142e-02f, -5.80609664e-02f, 5.94459623e-02f, -1.14575485e-02f, -6.99068829e-02f, -5.96510284e-02f,
  -2.86552142e-02f, -1.48329418e-02f, 2.31231600e-02f, -5.98423705e-02f, -5.54787070e-02f, -3.34235653e-02f, 3.16444784e-02f, -4.82542347e-03f, -7.83486199e-03f, 5.56069128e-02f,
  -2.28433013e-02f, -9.45399422e-03f, -9.36457701e-03f, -1.53178290e-01f, -5.11988103e-02f, 4.67894822e-02f, 1.05260406e-02f, -6.72140494e-02f, -1.82258457e-01f, -1.43856212e-01f,
  1.28201500e-01f, -8.20708722e-02f, 9.69613902e-03f, 5.03736585e-02f, 4.56595980e-02f, 1.05238013e-01f, -1.65083781e-02f, 1.58667360e-02f, 2.86523756e-02f, -7.46220425e-02f,
  -4.37434055e-02f, -3.35586965e-02f, 1.46295819e-02f, 1.75074127e-03f, 3.39625962e-02f, 3.52280252e-02f, 4.56206910e-02f, -1.57833621e-02f, 6.41290545e-02f, -4.67177713e-03f,
  1.20431958e-02f, -7.64852762e-02f, 7.97990710e-02f, -4.89150770e-02f, -3.02157346e-02f, -1.60858815e-03f, -8.21682960e-02f, -1.32674433e-03f, 3.41341458e-02f, -2.17296947e-02f,
  -5.59029803e-02f, -1.50800655e-02f, 3.11919469e-02f, 2.14079320e-02f, -2.95628551e-02f, 2.48632655e-02f, 2.29382664e-02f, 2.33025756e-02f, -3.08655892e-02f, -2.65268311e-02f,
  -3.92479189e-02f, 2.74310261e-02f, 5.03229350e-02f, 7.59073794e-02f, 5.78430556e-02f, -4.95384559e-02f, -1.98141355e-02f, 2.21262351e-02f, -5.53631335e-02f, -8.14326704e-02f,
  4.45919111e-02f, 7.74936900e-02f, 1.09219007e-01f, -2.15013307e-02f, 8.98357853e-02f, -3.35668400e-02f, -6.53638318e-02f, 7.55543113e-02f, -4.39928612e-04f, 7.55039752e-02f,
  -5.77575713e-02f, 8.26789662e-02f, -2.80055646e-02f, 4.96478155e-02f, -6.78346530e-02f, -5.41494004e-02f, 1.06832990e-03f, -3.79918329e-02f, -9.52528417e-03f, -8.93833116e-03f,
  -6.03359453e-02f, -7.01770559e-02f, -1.90600138e-02f, 1.18245929e-02f, -5.02558611e-02f, 7.13522285e-02f, 6.96326941e-02f, 1.79522112e-02f, 9.72073711e-03f, -5.51832877e-02f,
  -2.97159869e-02f, -4.89329174e-03f, -7.73130953e-02f, 5.47405556e-02f, 1.98228844e-02f, 7.03651160e-02f, 7.50953257e-02f, -3.14180963e-02f, 5.15844226e-02f, -3.33741233e-02f,
  1.24964034e-02f, 1.36533946e-01f, 6.19003326e-02f, -8.04941952e-02f, 8.03767063e-04f, -7.76324719e-02f, 5.06990515e-02f, -3.39055285e-02f, 6.06650859e-02f, 5.00517152e-02f,
  5.14636114e-02f, -2.60717086e-02f, -2.59669982e-02f, 1.60746428e-03f, 1.21025965e-02f, -4.16597016e-02f, 7.26080686e-02f, -4.49099503e-02f, -9.35307145e-02f, -4.34281901e-02f,
  -3.86472754e-02f, -4.44030873e-02f, -4.58994647e-03f, 2.50190310e-02f, -4.45455723e-02f, 8.80777743e-03f, -7.05666393e-02f, 2.48768460e-02f, 8.84944871e-02f, -2.10579876e-02f,
  1.20997585e-01f, -4.95308563e-02f, -9.92462877e-03f, 4.86682318e-02f, 2.21961185e-01f, 1.44946501e-01f, 1.02720916e-01f, 7.61562884e-02f, 7.60755613e-02f, 1.74648523e-01f,
  8.38553682e-02f, 1.72106683e-01f, 8.49038586e-02f, 7.37861618e-02f, 1.16501547e-01f, 8.92899111e-02f, 1.05270170e-01f, -4.21581753e-02f, 7.40418732e-02f, 1.23581611e-01f,
  -4.78368253e-02f, 2.29426064e-02f, -1.06299035e-01f, -4.53911796e-02f, 6.54806569e-02f, 1.06679611e-01f, 8.39723423e-02f, 4.24476229e-02f, 5.91398813e-02f, 3.44414376e-02f,
  -9.46455970e-02f, 3.23447678e-03f, 9.40979570e-02f, -1.32299233e-02f, 4.34627727e-04f, -1.04128286e-01f, 5.24973832e-02f, -1.44223586e-01f, 2.67133024e-02f, 4.61145602e-02f,
  -4.77334261e-02f, 6.61972091e-02f, -7.43134394e-02f, 2.06408445e-02f, -3.53613570e-02f, 2.86098383e-02f, -6.31530881e-02f, 4.16142382e-02f, 1.13139665e-02f, 4.76618148e-02f,
  -5.50633483e-02f, 9.99014750e-02f, 9.63104442e-02f, 1.85083342e-03f, 8.39659274e-02f, 6.92183822e-02f, -2.03075148e-02f, 6.82045072e-02f, -5.42562604e-02f, -4.60626557e-02f,
  9.41456184e-02f, 9.30868015e-02f, 8.10966119e-02f, 3.20766084e-02f, 5.68490699e-02f, 3.94464210e-02f, -2.46643201e-02f, 6.32547289e-02f, -3.13071497e-02f, -1.27450069e-02f,
  -3.39834504e-02f, 4.63334620e-02f, -6.57121837e-02f, 1.98239647e-02f, 9.91623029e-02f, -3.03452313e-02f, 6.58076722e-04f, 6.82965145e-02f, -7.44264573e-02f, 7.68853724e-02f,
  2.35087741e-02f, -3.01067661e-02f, 4.16585766e-02f, -6.64227307e-02f, -6.30194470e-02f, -6.99728495e-03f, 2.36627217e-02f, 2.38042548e-02f, -6.23366795e-02f, 2.61222059e-03f,
  2.33763829e-02f, 4.14408930e-03f, -9.16520208e-02f, -6.56623021e-02f, -1.09891118e-02f, 1.21124489e-02f, 3.78424418e-03f, 3.28652794e-03f, -2.96871662e-02f, 5.65685257e-02f,
  -6.08422644e-02f, -6.14120765e-03f, -5.43195382e-02f, 2.45842971e-02f, 6.42872900e-02f, -3.61394137e-02f, 6.20040521e-02f, 1.73413903e-02f, 4.56235837e-03f, -5.87316155e-02f,
  1.62257217e-02f, -3.77460904e-02f, -1.16801271e-02f, 5.40281832e-02f, -1.53533788e-02f, 5.72517924e-02f, 3.63214277e-02f, 9.79705132e-04f, -5.74510871e-03f, -7.53960386e-02f,
  -2.62185276e-01f, -3.89040411e-02f, 5.88297285e-02f, -5.97408824e-02f, 2.71042977e-02f, 1.00021586e-01f, 1.12389900e-01f, -4.31478173e-02f, 4.02106605e-02f, 7.47182146e-02f,
  -5.09830825e-02f, -3.10229529e-02f, 8.33290350e-03f, 1.60729110e-01f, 4.48444337e-02f, 4.78963666e-02f, 8.03418607e-02f, -3.77923017e-03f, -2.50014663e-02f, 2.88388226e-02f,
  7.85145834e-02f, 2.39087865e-02f, -9.93775725e-02f, 5.01077920e-02f, -2.34241262e-02f, 2.43775733e-02f, 6.74388483e-02f, 2.42053866e-02f, 3.52649693e-03f, -7.53579289e-02f,
  1.44226566e-01f, -1.93885103e-01f, -3.37971672e-02f, 8.35067686e-03f, 5.14209978e-02f, -9.04750600e-02f, 6.84602037e-02f, -1.34951044e-02f, -8.35482329e-02f, 4.40326147e-02f,
  -3.61374095e-02f, 3.27524729e-02f, -6.12455197e-02f, -8.13270137e-02f, -8.23131949e-02f, -5.64567372e-02f, -7.59260058e-02f, -4.11635712e-02f, 5.54565564e-02f, -5.57061955e-02f,
  -2.57531181e-02f, -2.85443608e-02f, -8.41502473e-02f, 4.18418683e-02f, -2.18616221e-02f, 8.23692456e-02f, -1.74536519e-02f, -2.68270653e-02f, -7.05747977e-02f, -3.71528417e-02f,
  2.42926851e-02f, -4.48977649e-02f, -1.80577841e-02f, 3.17091830e-02f, -4.78317179e-02f, -7.67479166e-02f, 8.00806880e-02f, 9.07039642e-03f, 8.18368196e-02f, -6.57359138e-02f,
  1.00898914e-01f, 5.28608449e-04f, 6.18440136e-02f, -6.98416159e-02f, 7.33596226e-03f, 4.80165705e-02f, 1.20599866e-02f, -3.89663838e-02f, 1.19241280e-02f, 9.92218778e-03f,
  -8.92192349e-02f, -1.07837096e-01f, 2.35458687e-02f, 2.33727172e-02f, -3.57743353e-03f, -4.05222103e-02f, -8.71800855e-02f, 8.82719457e-03f, -3.08624171e-02f, 1.78363621e-02f,
  -5.90605312e-04f, 9.99853835e-02f, -5.00677302e-02f, 8.54762569e-02f, -8.67584662e-04f, -2.83367038e-02f, -3.56106466e-04f, -4.62774970e-02f, -8.34503248e-02f, 8.11495110e-02f,
  -2.84376182e-02f, 5.77622652e-02f, -3.63925355e-03f, 1.36122992e-02f, -6.52545691e-03f, 1.06052402e-02f, -1.03912726e-01f, 5.83601221e-02f, 9.69521850e-02f, 3.35869417e-02f,
  -5.02175838e-02f, -4.09807563e-02f, 4.80289385e-02f, 1.23635657e-01f, 7.82434568e-02f, 4.58670184e-02f, 8.51124376e-02f, -6.16546310e-02f, 1.69878155e-02f, 4.47532721e-02f,
  -1.03826933e-01f, -6.00960441e-02f, -1.12654027e-02f, 3.44865322e-02f, -8.97263438e-02f, -9.54352412e-03f, -3.90085392e-02f, 1.01270661e-01f, 1.19785905e-01f, -4.33440432e-02f,
  -4.08390127e-02f, -8.31444263e-02f, 2.21677907e-02f, -1.22191003e-02f, 3.90381217e-02f, -7.17891902e-02f, -1.24272816e-01f, -2.14806031e-02f, -9.82410535e-02f, -1.39566930e-02f,
  2.11826083e-03f, 3.28376554e-02f, -1.36205137e-01f, 5.33464104e-02f, 7.78638273e-02f, 4.64845113e-02f, -1.22304007e-01f, -1.06982507e-01f, -7.74882808e-02f, -4.26547118e-02f,
  -7.85499513e-02f, 8.50480720e-02f, -8.67747292e-02f, -3.90685461e-02f, -8.12227726e-02f, -8.91411677e-02f, -5.93523346e-02f, -1.29496527e-03f, 3.77580374e-02f, -5.34701534e-02f,
  3.77136804e-02f, 7.09195435e-02f, 2.83305859e-03f, -7.57761374e-02f, -8.01556632e-02f, 7.26677254e-02f, -7.31717497e-02f, 3.75858881e-02f, 4.84176390e-02f, -2.77437419e-02f,
  -2.80617829e-02f, -1.23765118e-01f, -1.03349343e-01f, -9.24299806e-02f, 6.07474297e-02f, -1.03201434e-01f, -9.38229859e-02f, 8.66937339e-02f, -2.87828296e-02f, 1.04118092e-02f,
  2.57239249e-02f, -9.93705075e-03f, 3.21080498e-02f, -5.96623756e-02f, -1.01320827e-02f, -4.76777330e-02f, -3.54262181e-02f, -6.69129146e-03f, -3.05882692e-02f, -2.09103376e-02f,
  -1.28060216e-02f, -6.68248087e-02f, 3.31324525e-02f, 6.06739148e-02f, 2.64362060e-02f, 5.62389307e-02f, 1.28113339e-02f, -9.27533656e-02f, -5.24122342e-02f, 2.09742673e-02f,
  4.97058453e-03f, 5.77701330e-02f, 1.30291991e-02f, -1.53823467e-02f, 4.25288407e-03f, 2.62993965e-02f, 7.27342144e-02f, -2.52755564e-02f, 6.40257224e-02f, 3.60588282e-02f,
  -6.73934370e-02f, -1.19324513e-01f, -2.50749122e-02f, -4.70934920e-02f, 5.57281226e-02f, 4.47776960e-03f, -1.02960408e-01f, 6.92804903e-02f, -6.03122897e-02f, -6.73440322e-02f,
  2.37228000e-03f, 2.18242244e-03f, -4.54240143e-02f, 6.56024143e-02f, 2.79973876e-02f, 1.61617566e-02f, -3.13257687e-02f, -4.37085144e-02f, -6.40795082e-02f, -2.21608486e-02f,
  -9.15557668e-02f, -1.28727093e-01f, -1.02590352e-01f, 2.51535457e-02f, -1.70283508e-03f, -6.48331922e-03f, 1.42687131e-02f, -6.68035820e-02f, -1.11966282e-01f, -4.35787775e-02f,
  -2.40106955e-02f, 4.00242768e-02f, -4.55454402e-02f, -1.84049290e-02f, -2.68845316e-02f, -4.34670001e-02f, 5.60964756e-02f, -8.11563432e-03f, -6.47510514e-02f, 2.81832423e-02f,
  1.19003810e-01f, 8.22622553e-02f, -5.26176021e-02f, 7.74066001e-02f, -4.96149138e-02f, 6.70061633e-02f, 1.84147842e-02f, -9.91085693e-02f, -8.42541978e-02f, 3.08047086e-02f,
  -7.85180777e-02f, -4.72272560e-02f, 6.05509132e-02f, -7.53509477e-02f, 9.63959098e-02f, 3.90692651e-02f, -2.67049149e-02f, 5.30752875e-02f, -2.76179030e-03f, 8.77290070e-02f,
  -4.53826450e-02f, 4.15816233e-02f, -1.11335772e-03f, 1.82267074e-02f, 4.81028855e-02f, -1.05085941e-02f, -3.78876030e-02f, 2.47480385e-02f, 1.05022900e-01f, -6.47203475e-02f,
  -1.36622656e-02f, 4.94151898e-02f, 2.56624576e-02f, 3.53395790e-02f, 8.17563534e-02f, 6.22560568e-02f, 8.48664939e-02f, 1.04215972e-01f, -4.16972749e-02f, -2.47791391e-02f,
  1.11045979e-01f, 3.56959067e-02f, 4.83249500e-02f, 2.54728403e-02f, -7.29072317e-02f, 2.29514893e-02f, -3.04821320e-02f, 4.17776294e-02f, 2.07989551e-02f, -5.77750616e-02f,
  8.05575028e-02f, 1.00901961e-01f, -6.92431778e-02f, -3.91456075e-02f, -2.99714338e-02f, -8.23413953e-02f, 2.78504007e-02f, 7.28269294e-02f, -5.49642630e-02f, -2.80194208e-02f,
  4.96543711e-03f, -3.31034549e-02f, -6.57795668e-02f, -3.84325758e-02f, 2.85187736e-02f, 7.91719481e-02f, -4.14500199e-02f, 6.45148978e-02f, 1.28317485e-02f, 4.00268622e-02f,
  -9.91703570e-02f, 6.49261400e-02f, 1.50227277e-02f, -6.28242642e-03f, -5.35528027e-02f, -3.16926427e-02f, -9.70887765e-02f, -6.77829459e-02f, -4.73390482e-02f, 1.79446768e-02f,
  1.18977509e-01f, 2.37831082e-02f, -5.39605208e-02f, 2.58221868e-02f, 6.33719116e-02f, -4.86416519e-02f, -2.63464618e-02f, -7.98486695e-02f, -3.41976471e-02f, -7.96865299e-02f,
  7.87542537e-02f, 3.50725986e-02f, 9.32596922e-02f, 4.08119634e-02f, -4.47814204e-02f, 2.90327854e-02f, 4.64890450e-02f, 9.96074677e-02f, 6.07989170e-02f, 5.13654649e-02f,
  -1.28159346e-02f, 5.98911531e-02f, 1.02009997e-01f, -5.17536420e-03f, 5.30325109e-03f, -1.31635470e-02f, 8.09713677e-02f, -8.95277504e-03f, 6.69303834e-02f, 1.17209651e-01f,
  -1.98278669e-02f, -5.19335605e-02f, 5.79805113e-03f, -1.04028303e-02f, -8.14630762e-02f, -3.18109281e-02f, -1.78073674e-01f, -6.15088493e-02f, 6.01718621e-03f, -1.30162939e-01f,
  -3.05282138e-02f, -5.12616448e-02f, 2.24244539e-02f, -2.66664103e-02f, -6.23409823e-03f, -1.27229542e-01f, -1.10247366e-01f, 2.79556252e-02f, 3.53972949e-02f, -1.46716461e-01f,
  -1.41730577e-01f, -7.66261593e-02f, 4.02624086e-02f, 4.57814662e-03f, -1.19897924e-01f, -6.24524020e-02f, -7.79075697e-02f, -1.23837851e-01f, -7.60737285e-02f, -1.24009624e-01f,
  -1.12984113e-01f, 6.50279410e-03f, -6.79883063e-02f, -1.86561365e-02f, -1.01718329e-01f, -7.61025632e-03f, 4.47961353e-02f, 8.59579369e-02f, -6.12649694e-02f, 4.63186502e-02f,
  -7.50394631e-03f, -2.92887837e-02f, -5.61079606e-02f, -3.89383659e-02f, 1.03801852e-02f, 2.61234436e-02f, 2.29586568e-02f, 4.60074283e-03f, 8.52810219e-02f, 1.79210640e-02f,
  -5.26880510e-02f, -9.00190473e-02f, -1.44619374e-02f, -3.84779088e-02f, -2.95221712e-02f, -1.01030111e-01f, -1.66768310e-04f, -5.79630136e-02f, -2.36865040e-02f, -1.00131392e-01f,
  -9.93644521e-02f, 4.12809663e-02f, 1.58430287e-03f, -2.26615034e-02f, -1.77160222e-02f, 9.00846254e-03f, 9.01792347e-02f, 4.01132926e-02f, 2.95003746e-02f, -5.02997562e-02f,
  -5.30144982e-02f, 3.93536948e-02f, -3.37405205e-02f, -5.46100922e-02f, 2.22319458e-02f, 3.23015898e-02f, 2.56018434e-02f, -3.13451253e-02f, -4.44455780e-02f, 7.86981285e-02f,
  7.21869692e-02f, 1.72400493e-02f, -3.37831266e-02f, -6.40542284e-02f, -3.40782963e-02f, -6.64029494e-02f, 6.29467815e-02f, 2.22274959e-02f, -1.99593287e-02f, 7.74705410e-02f,
  7.10962340e-02f, 7.94100165e-02f, -5.89457117e-02f, 7.11517856e-02f, 5.04337884e-02f, -9.11864862e-02f, 3.74955982e-02f, 2.37358129e-03f, -1.70019027e-02f, -9.99169499e-02f,
  -6.12109490e-02f, 5.76548800e-02f, 6.10561706e-02f, 3.67151350e-02f, -5.96415102e-02f, -9.80047975e-03f, -4.25434671e-02f, -1.67898387e-02f, 3.76720689e-02f, -6.78102002e-02f,
  3.49156745e-02f, -1.10827729e-01f, 4.17700224e-02f, -5.88405728e-02f, 5.57300709e-02f, 6.48818091e-02f, -9.04069394e-02f, -1.13869339e-01f, 1.88998750e-03f, -1.02170661e-01f,
  -7.58629665e-02f, 2.66080387e-02f, -1.13220513e-02f, -1.16459332e-01f, -2.01192610e-02f, 5.06242402e-02f, 3.45714577e-02f, -1.02116324e-01f, 7.39526516e-03f, 8.33724514e-02f,
  1.06806859e-01f, -1.29157854e-02f, 2.45063324e-02f, 1.93832070e-02f, -5.15781567e-02f, -1.93882547e-02f, -2.26748679e-02f, 4.79593351e-02f, -1.19821094e-02f, -1.15760034e-02f,
  -3.63124833e-02f, -1.14165649e-01f, -8.94850567e-02f, 3.63140218e-02f, 4.39542681e-02f, -6.30883649e-02f, -4.83064540e-02f, -9.15255100e-02f, 9.41724107e-02f, 1.05827395e-02f,
  2.13907108e-01f, -7.09916875e-02f, -3.73560376e-03f, 1.83015447e-02f, 7.39957541e-02f, 5.21943793e-02f, 9.50754881e-02f, -3.19847502e-02f, 2.95194648e-02f, 5.67196906e-02f,
  -5.11996187e-02f, -4.53757644e-02f, 4.84451046e-03f, 1.64459646e-02f, 7.48876631e-02f, 5.53438403e-02f, -2.76930090e-02f, -3.55248488e-02f, 2.81360350e-03f, -7.30616227e-02f,
  -7.77821466e-02f, -2.33283099e-02f, 3.13205160e-02f, -7.17083141e-02f, -9.88229960e-02f, -1.40976086e-02f, -7.97366500e-02f, -5.27530955e-03f, 4.46277820e-02f, -2.99127083e-02f,
  -6.44908547e-02f, 6.95199966e-02f, -1.27994297e-02f, 8.68864171e-03f, 4.21378985e-02f, -8.23091064e-03f, -4.14274372e-02f, 2.00517736e-02f, 3.27595882e-02f, -1.66208744e-02f,
  -1.23309400e-02f, 5.52460365e-03f, 4.82925251e-02f, 3.27724554e-02f, -4.80002575e-02f, -9.35176685e-02f, 9.41705052e-03f, -3.98534797e-02f, 2.17206813e-02f, -8.75635296e-02f,
  5.41440817e-03f, 6.30991459e-02f, -3.48615907e-02f, 9.41884443e-02f, 5.25887534e-02f, -5.33833615e-02f, 6.42597750e-02f, 3.57600041e-02f, -7.54911751e-02f, 5.95394932e-02f,
  1.48910552e-01f, -1.36563078e-01f, 3.33633833e-02f, 2.48039737e-02f, -2.00010687e-02f, 5.81023842e-02f, -3.22605669e-02f, -4.43756245e-02f, -4.62597124e-02f, -4.22193259e-02f,
  2.25099176e-02f, -5.28040677e-02f, 8.22152346e-02f, -6.45162463e-02f, 6.58351257e-02f, 3.22993770e-02f, -1.46855190e-02f, -6.38958663e-02f, -8.01590085e-02f, 1.16705010e-02f,
  7.14428425e-02f, 4.94970195e-02f, 3.14506069e-02f, 3.72962654e-03f, -9.25080255e-02f, 4.53930311e-02f, 9.04856846e-02f, 4.53345254e-02f, -7.46920854e-02f, 1.28297552e-01f,
  5.72963730e-02f, 8.54238942e-02f, -3.60207334e-02f, 3.92283797e-02f, -1.12507101e-02f, -1.00290246e-01f, -1.78551272e-01f, -1.31842688e-01f, 1.13397501e-01f, -8.59545916e-02f,
  -6.66294247e-02f, -8.18613246e-02f, -3.84257697e-02f, -1.40833303e-01f, -2.02281550e-01f, -8.96754563e-02f, -1.33791536e-01f, -1.47099212e-01f, -1.74718603e-01f, -4.88328971e-02f,
  -9.00122523e-03f, 3.05738840e-02f, 6.27855137e-02f, 2.54443800e-03f, 1.85724452e-01f, 9.25348625e-02f, 7.74005204e-02f, 6.87079430e-02f, 7.31904283e-02f, 1.80083364e-01f,
  5.29246330e-02f, 9.03063044e-02f, -8.49283263e-02f, 7.64333317e-03f, 5.40199615e-02f, 6.28116429e-02f, -9.01301503e-02f, 3.32927704e-02f, 6.57092109e-02f, -7.28653446e-02f,
  -8.21447298e-02f, -1.35962712e-03f, 4.74122688e-02f, -2.33813804e-02f, -5.52897714e-03f, -9.59120691e-02f, 3.62045169e-02f, 2.67041158e-02f, 3.95027688e-03f, -8.37909430e-02f,
  -5.87862357e-02f, -6.71951473e-02f, 4.12899218e-02f, 1.41368154e-02f, -5.22300079e-02f, 5.52431215e-03f, -1.56667624e-02f, 8.91937166e-02f, 2.28145234e-02f, 1.23045370e-01f,
  6.37957454e-02f, -8.74673501e-02f, 4.74964082e-03f, 5.52551262e-02f, 2.53025629e-03f, -2.28702892e-02f, 1.66686811e-02f, -3.64432298e-02f, 3.01938858e-02f, -6.86824471e-02f,
  -6.49039298e-02f, -6.00778200e-02f, 3.34046520e-02f, 4.63228449e-02f, 6.86641559e-02f, 8.45222920e-02f, -5.90986647e-02f, -3.74408998e-02f, -8.52373019e-02f, 3.55851389e-02f,
  9.48959775e-03f, -3.71913277e-02f, 9.25726518e-02f, 1.75784416e-02f, 1.80850774e-02f, -3.93677503e-02f, -5.63747399e-02f, -5.59756048e-02f, 3.99949178e-02f, -2.89896317e-02f,
  1.62525818e-01f, -1.52276114e-01f, 4.93938290e-02f, 7.81426877e-02f, -9.22568738e-02f, -6.64250404e-02f, 5.44598922e-02f, 1.84803158e-02f, -7.24322200e-02f, 3.12317889e-02f,
  -5.40709309e-02f, -7.92619437e-02f, -4.65614833e-02f, -2.83729583e-02f, -9.47482809e-02f, -3.46513391e-02f, -8.42388794e-02f, 4.22604237e-04f, -3.59619260e-02f, 4.10835333e-02f,
  -1.20638072e-01f, -1.03628591e-01f, -1.00829624e-01f, -4.64158878e-02f, 9.34754983e-02f, -7.11551309e-02f, -8.74623135e-02f, -4.60144095e-02f, 2.77002063e-03f, -7.14102313e-02f,
  4.56627086e-02f, -7.41513893e-02f, -1.29735753e-01f, 1.85960099e-01f, 5.87065741e-02f, 4.88884524e-02f, -4.83250953e-02f, -1.19104512e-01f, 3.03181056e-02f, 6.95384815e-02f,
  3.19374236e-03f, -9.12521593e-03f, -1.27306804e-01f, -4.34199758e-02f, -2.09645167e-01f, -5.21349758e-02f, 7.42574222e-03f, -5.13504632e-02f, -1.11968838e-01f, 3.95142287e-02f,
  1.71815917e-01f, 4.60851900e-02f, 8.23915899e-02f, 7.41584077e-02f, 1.12080105e-01f, 1.58398330e-01f, 9.63156968e-02f, 9.00257379e-02f, 1.18918017e-01f, 9.90050286e-02f,
  1.55447358e-02f, -7.46388137e-02f, -9.92219225e-02f, 6.59241388e-03f, 3.67233455e-02f, -1.08123265e-01f, 2.37959307e-02f, -1.29419444e-02f, 3.08982860e-02f, -3.81041579e-02f,
  -1.47936530e-02f, 4.40973751e-02f, -2.39202660e-02f, -1.09613694e-01f, -1.07634431e-02f, -6.64825588e-02f, -1.05143748e-01f, -8.91894400e-02f, -1.73638582e-01f, -1.33525087e-02f,
  8.43417943e-02f, 8.78474414e-02f, -8.88217092e-02f, 9.42506362e-03f, -1.33628562e-01f, 3.29274200e-02f, -6.84156492e-02f, -8.61833319e-02f, -4.97446693e-02f, -2.38051899e-02f,
  2.76317000e-02f, 1.23983866e-03f, 4.21302952e-02f, 2.59975996e-02f, -7.39935488e-02f, 9.90207791e-02f, 5.25668599e-02f, -7.35161230e-02f, 4.90424335e-02f, 6.21368960e-02f,
  -5.61029464e-02f, -3.87094095e-02f, 2.46371124e-02f, -7.50839859e-02f, 4.76532988e-02f, -7.40281399e-03f, 7.20907599e-02f, -7.12324753e-02f, 5.94436526e-02f, -7.33469352e-02f,
  5.83814718e-02f, -9.91494134e-02f, -6.37186319e-02f, -4.31795269e-02f, -4.98119108e-02f, -6.93321899e-02f, -2.05370076e-02f, -6.26399070e-02f, 5.14071994e-02f, -6.71847025e-03f,
  5.39470352e-02f, -1.36306942e-01f, 8.69758502e-02f, -8.28872249e-02f, 6.09037876e-02f, 5.86584136e-02f, -5.44709004e-02f, -7.86908865e-02f, -8.45645368e-02f, 4.45462614e-02f,
  -3.58974598e-02f, -2.49693021e-02f, -5.40823564e-02f, -1.06585160e-01f, 3.46065387e-02f, 7.36041144e-02f, 9.42009389e-02f, -3.78902331e-02f, -5.60263619e-02f, -6.95296749e-02f,
  3.27588022e-02f, 1.04527555e-01f, 8.40171352e-02f, 6.45308429e-03f, -4.57297564e-02f, 6.55079782e-02f, -5.20684049e-02f, -2.87243482e-02f, -6.51668943e-03f, 1.12929344e-01f,
  3.36479917e-02f, -1.40520394e-01f, 2.53267474e-02f, -3.34047005e-02f, -7.49518052e-02f, -7.03403801e-02f, -3.71526480e-02f, -3.95223089e-02f, 3.76260877e-02f, -1.04981074e-02f,
  6.44206405e-02f, 9.12269056e-02f, 9.24641937e-02f, 4.97838445e-02f, 2.32741423e-02f, -1.19863391e-01f, -1.10538844e-02f, 3.73386126e-03f, 3.80079150e-02f, -8.40604212e-03f,
  1.37916040e-02f, -6.55518174e-02f, -7.22840130e-02f, 6.62172958e-02f, -6.09926544e-02f, -5.17203733e-02f, -1.18834935e-01f, 2.95693111e-02f, -9.82068758e-03f, -6.65476024e-02f,
  -1.22647472e-01f, 7.43864477e-02f, 3.22911255e-02f, 9.00840089e-02f, 2.64844261e-02f, -1.61200445e-02f, -1.14522576e-02f, 3.23975980e-02f, -1.51828201e-02f, 1.11235939e-02f,
  -7.44150206e-02f, 6.19907938e-02f, -6.45064190e-02f, -1.50431925e-02f, 6.72289580e-02f, 3.85294482e-02f, 4.92764860e-02f, -7.22825155e-02f, 4.16400731e-02f, 4.41697724e-02f,
  -9.75685269e-02f, 8.67258459e-02f, 8.81206542e-02f, 7.66699016e-02f, 9.83066559e-02f, 1.21197693e-01f, -9.71240457e-03f, -6.08607642e-02f, 6.99934214e-02f, -3.28273959e-02f,
  6.75794631e-02f, 1.54370144e-02f, 8.29652548e-02f, -5.02131283e-02f, -3.58540267e-02f, 2.61246897e-02f, -5.96296489e-02f, 2.53397487e-02f, 7.46868253e-02f, -9.98747051e-02f,
  1.72281824e-02f, 5.54373786e-02f, 7.41295069e-02f, -9.48408023e-02f, 7.10363779e-03f, -5.05278148e-02f, -8.64520296e-02f, 3.35176103e-02f, 4.96879369e-02f, -2.87698042e-02f,
  4.70393850e-03f, 1.03294663e-02f, -9.36952755e-02f, -1.02427557e-01f, -1.01661228e-01f, 5.22902794e-02f, -4.38880436e-02f, -1.94686167e-02f, -5.33147417e-02f, 4.15337756e-02f,
  -5.00943586e-02f, 5.13851456e-02f, 8.74316543e-02f, 4.48029861e-02f, 3.72326048e-03f, -8.96129832e-02f, 2.83152796e-02f, 1.71697158e-02f, 5.36861690e-03f, -7.33363703e-02f,
  -9.34015214e-03f, 2.34997012e-02f, 6.09795488e-02f, -9.32594463e-02f, -7.15690404e-02f, 8.38312209e-02f, -7.31315836e-02f, 6.26976639e-02f, 5.13368621e-02f, 6.54161498e-02f,
  -6.01118617e-02f, 7.38623366e-02f, 6.69596642e-02f, 2.72910018e-02f, 3.81433964e-02f, 8.39904919e-02f, 8.07722807e-02f, -2.93086227e-02f, 5.31216301e-02f, -4.74357344e-02f,
  -1.24507062e-01f, 6.48806393e-02f, -9.60284844e-02f, -1.37670293e-01f, -6.99658394e-02f, 2.09007002e-02f, 6.06899075e-02f, -2.39703599e-02f, -1.01300567e-01f, 5.10534309e-02f,
  -2.48030499e-02f, -1.40952662e-01f, -7.35542253e-02f, -5.46971187e-02f, -4.56950851e-02f, 3.82698961e-02f, 6.94719404e-02f, -8.43331143e-02f, -8.26326534e-02f, -6.08043782e-02f,
  -5.89738637e-02f, -1.43175319e-01f, -1.78918820e-02f, -7.68478066e-02f, -1.10658236e-01f, -2.11706311e-02f, -1.18632779e-01f, -1.34401828e-01f, 1.30622173e-02f, 4.16627526e-02f,
  -6.44384921e-02f, -7.83464909e-02f, -3.48943397e-02f, -8.53399262e-02f, 3.07387058e-02f, 3.42805348e-02f, 2.08401959e-02f, -6.20698594e-02f, 5.31471781e-02f, -6.69818446e-02f,
  -8.47957805e-02f, -4.88609709e-02f, 4.57379594e-03f, 2.66576745e-02f, -5.29093109e-02f, -6.43502222e-03f, 7.91148841e-02f, -6.50704727e-02f, 1.35222645e-02f, -2.12667584e-02f,
  1.68154910e-02f, -1.38485748e-02f, -6.76373020e-02f, 8.91991034e-02f, -6.33373335e-02f, -7.36690611e-02f, -4.34089787e-02f, -5.59669137e-02f, 4.65004928e-02f, 6.30305037e-02f,
  -1.42246559e-02f, 7.82109052e-03f, -6.36777654e-02f, -9.42707583e-02f, 8.32906365e-03f, -5.02746142e-02f, 9.88531858e-03f, 7.77587891e-02f, -1.17076118e-03f, -6.44851476e-02f,
  4.52649407e-02f, 3.17993388e-02f, 3.35039757e-02f, 3.63045326e-03f, 7.96298832e-02f, 4.45918106e-02f, -5.96768335e-02f, -2.48326398e-02f, 2.68911496e-02f, 8.01382512e-02f,
  -6.62651611e-03f, -1.00517809e-01f, 2.38777846e-02f, -1.32952267e-02f, -2.69804779e-03f, -9.46624763e-03f, 5.45016006e-02f, -5.67246787e-02f, -3.13054733e-02f, 4.71182503e-02f,
  -1.12023920e-01f, -4.80668154e-03f, 1.05759921e-02f, -7.20886420e-03f, 8.09248462e-02f, 7.06969500e-02f, -5.87022007e-02f, -3.72913852e-03f, 2.03402266e-02f, -5.94771318e-02f,
  6.22303113e-02f, 5.69767170e-02f, 2.52092406e-02f, 3.37848216e-02f, -3.27016301e-02f, 3.43885496e-02f, 5.47587648e-02f, -5.03966063e-02f, -3.21313068e-02f, -4.16234471e-02f,
  -4.67700288e-02f, 1.73227228e-02f, -1.17995337e-01f, 1.10386582e-02f, -7.74135813e-02f, -9.34360996e-02f, -3.59480791e-02f, -2.96922680e-02f, 1.67976543e-02f, 6.33771420e-02f,
  -1.50100857e-01f, 1.71716273e-01f, 2.76743453e-02f, 9.37874019e-02f, 2.34830237e-04f, 1.32334903e-01f, 8.80374685e-02f, 9.75959823e-02f, -1.14594009e-02f, 8.87914971e-02f,
  -6.18789718e-02f, 6.41160607e-02f, 1.22506872e-01f, 1.12394966e-01f, 1.65019646e-01f, 1.59182735e-02f, 1.59273073e-01f, -7.42814913e-02f, 4.24310230e-02f, -3.97705659e-02f,
  2.19063535e-02f, 7.10871443e-02f, 1.34525839e-02f, 6.28087521e-02f, 7.59936571e-02f, -5.09897619e-03f, 5.05212992e-02f, -1.74875576e-02f, 3.03940549e-02f, 7.45322779e-02f,
  -1.57707408e-01f, -5.93144111e-02f, -1.04436576e-01f, 8.47500283e-03f, -5.78389177e-03f, 2.49396563e-02f, 5.91551252e-02f, -2.15555858e-02f, -7.29859099e-02f, 8.47760811e-02f,
  4.11910862e-02f, -5.99212982e-02f, 8.19836482e-02f, 2.54525873e-03f, 1.95799228e-02f, -6.97941706e-02f, -5.78448689e-03f, -3.24961245e-02f, 6.04166612e-02f, -6.89222366e-02f,
  -8.09579436e-03f, -1.03011176e-01f, 2.16877880e-03f, 8.93077478e-02f, 2.65055671e-02f, 6.53969646e-02f, 8.29123408e-02f, -5.99404164e-02f, 1.64645328e-03f, 2.53206398e-02f,
  -3.75947319e-02f, -7.50761926e-02f, 6.85448647e-02f, -8.28693435e-02f, 7.82643035e-02f, -3.09601724e-02f, 1.34246824e-02f, 7.28035718e-02f, -9.25071596e-04f, -1.56215159e-02f,
  -5.30938897e-03f, -6.21069446e-02f, -7.64016584e-02f, 1.53626304e-03f, 7.72161223e-03f, 5.13696671e-02f, 4.20836881e-02f, -2.94022216e-03f, 3.93279344e-02f, 2.77265161e-02f,
  1.57984588e-02f, 9.16453451e-03f, -1.12024195e-01f, 9.04403031e-02f, -7.68882856e-02f, -7.61172846e-02f, -2.69428059e-03f, -2.79333275e-02f, -6.93627372e-02f, -9.79576334e-02f,
  -4.93534729e-02f, -3.20316129e-03f, 2.51166280e-02f, -2.03427523e-02f, -8.85481294e-03f, 7.07966760e-02f, -2.39026714e-02f, 4.88045327e-02f, -4.07063141e-02f, 8.29933658e-02f,
  -5.85116073e-02f, -7.12566897e-02f, -7.62462988e-02f, 1.89161755e-03f, -4.58294712e-02f, 1.42118176e-02f, 2.62948815e-02f, -5.74746877e-02f, -2.17907056e-02f, 6.92307353e-02f,
  -7.30135590e-02f, -1.09197102e-01f, -4.68669049e-02f, 6.01457711e-03f, 2.77820751e-02f, -1.13738395e-01f, -4.23370562e-02f, -8.36333930e-02f, 2.16108339e-04f, -1.19685650e-01f,
  1.74307376e-01f, -2.80013159e-02f, 1.21362247e-02f, 1.15615390e-02f, -8.89105648e-02f, 5.66345057e-04f, 6.68160021e-02f, 4.95058559e-02f, -5.00846356e-02f, -1.90338567e-02f,
  -9.00068581e-02f, -4.49053161e-02f, 8.90085772e-02f, -1.54664395e-02f, 8.83235037e-02f, -6.24434538e-02f, -2.75590923e-02f, -5.31708524e-02f, 3.14141996e-02f, -7.99020678e-02f,
  -4.26283851e-02f, -8.71595517e-02f, 8.30170363e-02f, -2.58514564e-02f, -7.11566508e-02f, 4.87552136e-02f, 4.69584689e-02f, -1.80538353e-02f, -4.33646888e-02f, -7.29249567e-02f,
  -6.75138533e-02f, 7.94686601e-02f, -6.76185489e-02f, 5.44142053e-02f, -5.74056692e-02f, -3.80708128e-02f, 8.73880237e-02f, -8.95495191e-02f, 1.84984673e-02f, 8.38777889e-03f,
  -5.21289036e-02f, -5.47736548e-02f, 4.31122184e-02f, -3.73374298e-02f, 3.20739560e-02f, 2.28663888e-02f, -6.90008998e-02f, -2.68751550e-02f, 3.30541134e-02f, -8.09161738e-03f,
  4.16600294e-02f, 1.11581143e-02f, 1.18004672e-01f, -4.17545475e-02f, -5.92322908e-02f, 1.09670259e-01f, 8.22168589e-02f, -7.18624815e-02f, 1.97201632e-02f, 2.86089499e-02f,
  1.13008119e-01f, -4.98969071e-02f, -2.02599838e-02f, 8.06118548e-02f, -9.74116754e-03f, -3.89232226e-02f, 2.16409843e-03f, -5.93615882e-02f, 9.25874561e-02f, 1.98947894e-03f,
  -4.54219468e-02f, 5.17667159e-02f, -3.04493122e-02f, 3.85599881e-02f, 3.06323655e-02f, -3.49850170e-02f, 3.64122130e-02f, -3.87393050e-02f, -6.24125972e-02f, 6.71103224e-02f,
  5.82313128e-02f, -3.92371602e-02f, 1.73145290e-02f, 9.44986567e-02f, 7.61922747e-02f, -5.14719188e-02f, 3.15578990e-02f, 5.16053811e-02f, 4.22368534e-02f, 5.12891822e-02f,
  -1.03464760e-01f, 6.57550544e-02f, -3.33201811e-02f, 1.55393705e-02f, -5.95932193e-02f, -8.28626454e-02f, -7.47754872e-02f, -4.42483053e-02f, -2.69757793e-03f, -3.23622711e-02f,
  -5.90118021e-02f, -1.27500389e-02f, 4.46216464e-02f, 4.60632071e-02f, 1.50456531e-02f, -6.35110512e-02f, -1.55439619e-02f, 1.01629749e-01f, -6.56676888e-02f, -4.33004601e-03f,
  6.47586808e-02f, 1.38148859e-01f, 8.60174000e-02f, -1.69988275e-02f, 7.43629709e-02f, 9.98263806e-02f, -3.28837894e-02f, 7.94543326e-02f, 9.73234177e-02f, -1.28018325e-02f,
  -6.39439300e-02f, -1.39452890e-01f, 3.66360992e-02f, 1.11962751e-01f, -1.96056906e-02f, -1.02499584e-02f, -1.05329707e-01f, 5.05559593e-02f, 1.29297510e-01f, -5.37666667e-04f,
  -6.33810833e-02f, -3.04621644e-02f, -1.10448906e-02f, -4.59091961e-02f, 8.74020085e-02f, 8.17793012e-02f, 1.14358291e-01f, 1.06635600e-01f, 3.67000587e-02f, 3.57613340e-02f,
  -4.99881841e-02f, 8.57203081e-02f, -7.64749125e-02f, 6.20114580e-02f, -6.50114939e-02f, -1.04971719e-03f, 9.95990410e-02f, -3.31864413e-03f, 3.88736464e-02f, 1.00064427e-01f,
  -1.27849355e-01f, 3.07793217e-03f, 9.37073901e-02f, 5.83476275e-02f, -4.34067994e-02f, -4.61805873e-02f, 8.98118541e-02f, -4.76280227e-02f, -7.45041072e-02f, 3.28589380e-02f,
  4.50715572e-02f, -3.30753811e-02f, 6.13717958e-02f, -2.94295605e-02f, -6.46884441e-02f, 1.44259883e-02f, 1.16225453e-02f, 6.87300116e-02f, 2.73337442e-04f, -4.00727987e-02f,
  -3.72632630e-02f, -6.56635612e-02f, -1.53907873e-02f, 8.24815109e-02f, 4.81507555e-02f, 1.84227079e-02f, -5.85543923e-02f, -1.19182626e-02f, -4.80294973e-02f, -4.79840115e-02f,
  4.51338571e-03f, 2.94528715e-02f, -1.94363091e-02f, 2.48965435e-02f, 1.53904883e-02f, -2.91943420e-02f, 8.31886902e-02f, -3.98700573e-02f, -4.16807644e-02f, -7.72466063e-02f,
  -8.38379860e-02f, -2.47084070e-02f, -5.77932522e-02f, -3.46721560e-02f, -6.51726918e-03f, -1.72499511e-02f, -1.59244314e-02f, 1.69587638e-02f, 7.69492844e-03f, -2.20489632e-02f,
  -2.58535370e-02f, 7.64423236e-03f, 3.35860960e-02f, 3.76548059e-02f, 3.81533392e-02f, -7.81660527e-03f, -9.50704142e-03f, 3.67778982e-03f, -3.48137431e-02f, 2.64728088e-02f,
  2.98363771e-02f, 3.23923392e-04f, 8.44448060e-03f, -5.66674862e-03f, 2.61189491e-02f, 7.48662557e-03f, -6.74631223e-02f, -1.03470739e-02f, 7.30144151e-04f, 6.13634475e-02f,
  1.48520172e-02f, 2.16840077e-02f, 2.32787412e-02f, -8.98903608e-02f, 2.26427149e-03f, 3.87565754e-02f, -1.17427493e-02f, 1.02271631e-01f, 1.80170499e-02f, -4.78551984e-02f,
  -3.92595492e-02f, 3.03240791e-02f, 1.12193801e-01f, 7.26853386e-02f, 4.67221588e-02f, 9.70177874e-02f, -3.04035787e-02f, 1.03854667e-02f, 6.55437112e-02f, -7.34171690e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.41469839e-02f, 1.28153995e-01f, 1.37222093e-02f, 1.60209417e-01f, 1.15395829e-01f, 8.83997828e-02f, -1.20762829e-02f, 5.91766946e-02f, 8.53462890e-02f, 1.25426024e-01f,
  7.11850077e-02f, 2.23346978e-01f, 6.16200976e-02f, 5.40405065e-02f, 1.04649611e-01f, 5.65934815e-02f, -4.48961183e-02f, 1.15422502e-01f, 6.77077398e-02f, 1.01235457e-01f,
  8.85317251e-02f, -2.82195657e-02f, 4.18041088e-03f, 9.35046896e-02f, -2.29087900e-02f, 4.42564599e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.59921616e-01f, 1.91128716e-01f, -9.35751647e-02f, -4.12837774e-01f, -1.72633514e-01f, 1.25515968e-01f, -8.89214128e-02f, 2.43573617e-02f, 1.96434893e-02f, -1.61765039e-01f,
  2.16696598e-02f, -2.62884162e-02f, 9.96678174e-02f, -2.38462351e-02f, -3.46535891e-01f, -5.95014580e-02f, 5.08014262e-02f, 7.86644872e-03f, -1.40222624e-01f, -5.05694807e-01f,
  2.45085154e-02f, -1.86837167e-02f, -2.41935141e-02f, -2.76791573e-01f, -1.83418989e-01f, -1.05373196e-01f, -1.57438338e-01f, -1.00027002e-01f, 1.65487379e-01f, -1.62098721e-01f,
  3.68931368e-02f, 1.99956387e-01f, -3.13739665e-02f, 5.19470423e-02f, 1.64883398e-02f, -2.45984763e-01f, 1.16892634e-02f, 2.82589555e-01f, -1.23491965e-01f, -2.17122436e-01f,
  7.79510960e-02f, 6.08509183e-02f, -1.01368718e-01f, 2.17560250e-02f, -4.27190185e-01f, -8.30999836e-02f, -1.56079307e-01f, 5.87054342e-02f, -1.51064709e-01f, -2.72893578e-01f,
  2.00837761e-01f, -1.03236400e-01f, -7.00124800e-02f, 3.29227626e-01f, -3.81646246e-01f, 3.87023300e-01f, 3.90030816e-02f, 6.11006357e-02f, -2.75247484e-01f, 1.69255525e-01f,
  5.32022975e-02f, 4.42403480e-02f, 1.10766813e-01f, -2.48303309e-01f, 3.95738184e-01f, -3.23364407e-01f, -1.31372765e-01f, 1.01023108e-01f, -3.04166712e-02f, -1.80886090e-01f,
  1.34661078e-01f, -8.19498450e-02f, -1.67327337e-02f, -1.79012910e-01f, 1.19126536e-01f, -1.82219580e-01f, -4.29853126e-02f, -1.29202425e-01f, 2.69017160e-01f, 8.02967101e-02f,
  -1.60904467e-01f, 1.80883594e-02f, -9.40542370e-02f, -1.12124696e-01f, -3.46715212e-01f, -1.58366054e-01f, 1.18567668e-01f, -2.52844058e-02f, 8.32268968e-03f, 2.13992462e-01f,
  3.19976807e-01f, 1.55295253e-01f, 5.37153818e-02f, 1.96222499e-01f, -1.40648857e-01f, 3.68704736e-01f, -3.74016136e-01f, 2.75683612e-01f, 2.02533796e-01f, -2.87198454e-01f,
  3.75262869e-04f, -1.32736281e-01f, 9.69606265e-02f, 3.42604779e-02f, -1.24530822e-01f, 5.96945249e-02f, -8.25550407e-03f, 1.61094889e-01f, -1.27803758e-01f, -5.73170446e-02f,
  -4.12148312e-02f, -4.04095501e-02f, 2.55186260e-01f, 1.89722449e-01f, 1.13588450e-02f, 5.98390624e-02f, -1.61126014e-02f, 2.57985175e-01f, 4.33670208e-02f, 2.22984940e-01f,
  -5.67989685e-02f, 8.21378380e-02f, 5.22327349e-02f, 1.72576785e-01f, -2.15971423e-03f, -4.13311925e-03f, -7.27088749e-02f, -5.40864579e-02f, -2.06942018e-02f, 1.11001261e-01f,
  6.11414053e-02f, 7.71584064e-02f, -1.81479052e-01f, 7.33403638e-02f, 1.51229635e-01f, 9.27624330e-02f, 1.94187194e-01f, -2.14306295e-01f, 1.37536898e-01f, 1.71066877e-02f,
  -4.87685576e-02f, 8.67126435e-02f, -1.89340174e-01f, 1.23739943e-01f, 2.14175787e-02f, -1.18818106e-02f, -8.87098610e-02f, -1.63948864e-01f, -1.07421905e-01f, 1.79174632e-01f,
  -4.37125415e-02f, -4.36467499e-01f, 3.33221138e-01f, -1.02166049e-01f, -2.67397612e-02f, -6.93441415e-03f, 1.35731071e-01f, -3.43408138e-02f, -3.04957181e-02f, -1.13913700e-01f,
  2.09947303e-01f, -4.92246486e-02f, 1.22630060e-01f, 1.93519339e-01f, 1.07731439e-01f, -2.40756616e-01f, 2.72011999e-02f, 4.81423102e-02f, -3.36949639e-02f, 9.39448178e-02f,
  1.40395220e-02f, -4.60163839e-02f, 6.45974129e-02f, 5.95326759e-02f, 7.03871474e-02f, 6.44545555e-02f, -1.74450048e-03f, -2.44596794e-01f, -4.08620209e-01f, 6.01392500e-02f,
  3.72691870e-01f, 1.31704077e-01f, -1.84874639e-01f, 5.12332022e-01f, -3.36759716e-01f, 3.10107291e-01f, 3.28774065e-01f, -9.52460542e-02f, 1.79445460e-01f, -1.38753578e-01f,
  -2.29190573e-01f, -3.32463294e-01f, 1.11135930e-01f, -2.88960766e-02f, 6.35564700e-02f, -6.54575899e-02f, -1.39400363e-01f, -2.44036362e-01f, 1.63263217e-01f, 4.39063430e-01f,
  2.47655630e-01f, 4.40751582e-01f, -1.03569422e-02f, -6.95777759e-02f, -1.01623610e-01f, -1.80791062e-03f, -7.21356347e-02f, 2.81304121e-01f, -9.96237099e-02f, -5.19712210e-01f,
  -4.16262895e-01f, 9.56590995e-02f, -4.39591229e-01f, 1.04270540e-02f, 8.97539556e-02f, 1.13305785e-01f, -3.74974579e-01f, -1.14089353e-02f, 1.42448485e-01f, 3.87404263e-01f,
  -1.39136212e-02f, 1.41487077e-01f, 1.77330971e-01f, -4.44514751e-02f, -3.00774425e-01f, 1.07472613e-02f, 1.23506583e-01f, 5.55117242e-02f, 1.35388106e-01f, -5.61014771e-01f,
  -9.29325223e-02f, -4.73703295e-02f, 3.61876637e-01f, -2.38333315e-01f, 5.95387332e-02f, -9.52734873e-02f, -6.85057640e-02f, -1.44087702e-01f, -1.80828482e-01f, 1.26674324e-01f,
  -2.40834922e-01f, 1.05917603e-01f, 1.21348217e-01f, 3.24078441e-01f, -1.68286040e-02f, -9.64406580e-02f, -7.04086572e-02f, 2.11411580e-01f, -9.29286703e-02f, -1.81044281e-01f,
  -1.60781875e-01f, 2.22298905e-01f, -5.15081286e-02f, 7.85173774e-02f, 2.36654788e-01f, 8.80341753e-02f, -2.92573981e-02f, 1.20012090e-01f, -5.93182594e-02f, 4.50887345e-02f,
  -1.10460252e-01f, 1.42145991e-01f, 1.19860515e-01f, -5.25978468e-02f, -1.60223737e-01f, 2.24146634e-01f, -6.68743476e-02f, 1.38045609e-01f, -1.17846318e-02f, -5.71706854e-02f,
  3.07376564e-01f, 1.02182910e-01f, 1.46935275e-02f, -2.04454083e-02f, 1.45384371e-02f, 9.81538668e-02f, -9.88264903e-02f, -7.75860026e-02f, 1.08650565e-01f, 4.83712971e-01f,
  -1.10167444e-01f, 1.10319428e-01f, 3.05504035e-02f, 8.20100307e-02f, -1.08957946e-01f, 9.34355929e-02f, -5.44993728e-02f, 6.19726367e-02f, 1.74817920e-01f, 2.12080345e-01f,
  6.62433282e-02f, 1.18305631e-01f, 3.08577362e-02f, 2.66503226e-02f, -8.47251341e-02f, 1.44176528e-01f, 1.98943727e-02f, 7.81949311e-02f, 1.17050633e-01f, -1.20168133e-02f,
  6.91925585e-02f, 9.05026589e-03f, 2.72613131e-02f, -5.49885258e-02f, 7.88158253e-02f, 3.11634272e-01f, 1.03257500e-01f, -2.57846955e-02f, -1.24264389e-01f, 2.08665505e-01f,
  4.19897921e-02f, 5.12800276e-01f, -1.45456478e-01f, -1.53180510e-01f, -2.72985455e-02f, -3.71214539e-01f, 1.01697393e-01f, -3.58625472e-01f, 2.10163146e-02f, 1.08317591e-01f,
  1.49751365e-01f, -1.19085670e-01f, 2.62821645e-01f, -6.01567514e-02f, 1.97130263e-01f, -1.88641667e-01f, -7.05254525e-02f, 2.03655466e-01f, -3.06392640e-01f, -2.16842487e-01f,
  -1.11425422e-01f, -4.41049069e-01f, -3.72772336e-01f, 1.09596007e-01f, -1.30808264e-01f, -4.20628488e-01f, 2.75973290e-01f, -2.90453494e-01f, -1.62534907e-01f, -2.14779332e-01f,
  -5.79504892e-02f, -7.79999793e-02f, 1.70753092e-01f, 3.86220473e-03f, -1.22725971e-01f, -1.65747106e-01f, 5.75986318e-02f, 1.41027898e-01f, -3.18753868e-01f, 2.51092255e-01f,
  -1.92313511e-02f, -2.81189382e-02f, 4.16515358e-02f, -2.30467632e-01f, 2.72965759e-01f, -2.73837984e-01f, -7.31291398e-02f, 4.78699356e-02f, -1.19231313e-01f, -1.36294052e-01f,
  -2.44553927e-02f, -9.96094123e-02f, -2.28032187e-01f, -1.79661542e-01f, -5.37567213e-02f, 3.99233073e-01f, 5.66046732e-03f, -1.16605528e-01f, 2.62145609e-01f, -8.38119388e-02f,
  7.23067448e-02f, -1.31259143e-01f, 2.61199288e-02f, -6.65794536e-02f, -8.20863806e-03f, 1.38807461e-01f, -1.33579373e-01f, -9.72390622e-02f, -2.54640490e-01f, 9.13620964e-02f,
  -4.97306362e-02f, -3.46783772e-02f, -1.55564636e-01f, 1.66765004e-01f, 4.55723964e-02f, -2.26743937e-01f, 5.99827692e-02f, 3.22127715e-02f, 7.15956092e-02f, -1.06954932e-01f,
  1.08274743e-01f, 9.28740650e-02f, 1.22677833e-01f, 2.42071927e-01f, 5.50526083e-02f, -8.69611800e-02f, 2.04147957e-02f, 3.66670452e-02f, 1.77020326e-01f, -2.47786567e-03f,
  9.23527777e-02f, 7.43468851e-02f, 6.91014156e-02f, 1.08379595e-01f, 2.06556302e-02f, -1.50977731e-01f, 1.05092257e-01f, 8.94984901e-02f, -4.96082127e-01f, 1.75767466e-02f,
  1.11895852e-01f, -6.73730671e-02f, 1.17342807e-01f, 2.42360115e-01f, -2.59154975e-01f, -1.30216703e-01f, -1.35132030e-01f, -1.10356882e-02f, 1.18033491e-01f, -2.02655554e-01f,
  -1.41118243e-01f, -4.35892254e-01f, 6.97837323e-02f, 2.18733624e-01f, 6.96935654e-02f, 3.57031748e-02f, 1.32624954e-01f, -3.03769886e-01f, -2.52041101e-01f, -1.08594447e-02f,
  1.21505760e-01f, 9.84593332e-02f, -2.34746411e-01f, 2.82469634e-02f, -1.71347350e-01f, -7.12964684e-02f, -3.09890568e-01f, -1.76424488e-01f, -3.63945626e-02f, 1.42067373e-01f,
  1.26870528e-01f, -3.46404538e-02f, 6.75787479e-02f, -2.94987224e-02f, 1.55310228e-01f, 1.45006895e-01f, 1.82803407e-01f, 8.14269260e-02f, -3.54192287e-01f, -8.67727399e-02f,
  -2.09600046e-01f, -2.22720534e-01f, 1.84011906e-02f, 7.97386691e-02f, 2.14467883e-01f, 2.83177674e-01f, 3.60819340e-01f, 1.40067786e-01f, 1.57972500e-01f, -2.48204604e-01f,
  -2.17411816e-01f, -1.48351997e-01f, 2.76057512e-01f, 3.12625356e-02f, 1.90265909e-01f, 5.46787918e-01f, 2.11537778e-01f, 3.84670645e-01f, 2.53068596e-01f, -7.43122697e-02f,
  1.54497325e-01f, -3.58302593e-02f, 3.30874711e-01f, 1.23939440e-01f, -1.94065124e-01f, -1.52761564e-01f, 2.66284607e-02f, -5.65906584e-01f, -3.83548766e-01f, 1.56664431e-01f,
  3.34277093e-01f, 2.12427080e-02f, -1.71364725e-01f, -3.91525954e-01f, 2.63936967e-01f, 3.55077475e-01f, 1.52766898e-01f, 2.17842117e-01f, -1.03537336e-01f, 1.85709313e-01f,
  5.99540323e-02f, -1.01347670e-01f, 4.84111831e-02f, 1.33090749e-01f, -8.64563286e-02f, -7.95000866e-02f, 2.36835852e-01f, -2.06462950e-01f, -7.76757523e-02f, -7.05269799e-02f,
  4.14744951e-02f, 4.07873876e-02f, -2.06915215e-02f, 5.51719554e-02f, 4.43993844e-02f, -2.55130321e-01f, -9.54380929e-02f, -7.34398607e-03f, 3.71685058e-01f, 5.14221452e-02f,
  7.29517117e-02f, -2.60864254e-02f, -3.42876077e-01f, 1.07482307e-01f, 1.35460496e-01f, 1.32019266e-01f, 1.50445223e-01f, -2.88912714e-01f, -4.15840894e-02f, -8.12966973e-02f,
  -1.49728358e-01f, -1.26630008e-01f, -3.71411778e-02f, -3.88376057e-01f, 4.61258814e-02f, 1.21788539e-01f, 1.54916078e-01f, 1.70638070e-01f, -3.06409150e-02f, 3.37409377e-02f,
  -6.99517205e-02f, 2.59234339e-01f, -8.98039900e-03f, 1.45469740e-01f, -1.58287790e-02f, -7.96114467e-03f, 6.03785105e-02f, 1.15939334e-01f, -1.64353192e-01f, 5.22135682e-02f,
  -1.91078678e-01f, -5.41632622e-02f, 1.15806974e-01f, -2.71922380e-01f, 1.32845998e-01f, 9.56161320e-02f, -8.06735978e-02f, -6.10972121e-02f, 1.70809757e-02f, -1.87860385e-01f,
  -4.71366243e-03f, -2.94114500e-02f, 3.33766490e-02f, -1.99537218e-01f, 3.73339467e-02f, 1.35493070e-01f, 3.85203272e-01f, 1.41690105e-01f, -5.35637587e-02f, -1.98922604e-02f,
  2.27630556e-01f, -2.00046822e-01f, 1.26560092e-01f, 2.26612046e-01f, 4.95113852e-03f, 2.24366412e-01f, 1.74378052e-01f, -4.13039476e-01f, 2.16516629e-01f, 2.55347669e-01f,
  -1.92480475e-01f, -8.61631781e-02f, 1.55548468e-01f, 1.96758226e-01f, 3.12256098e-01f, 2.43031442e-01f, -9.84215960e-02f, -5.23787774e-02f, -1.38730735e-01f, -2.35205106e-02f,
  -1.50632679e-01f, -2.50289619e-01f, 1.17617503e-01f, -2.06473544e-01f, 8.42162818e-02f, -2.22750783e-01f, 3.47241700e-01f, -9.44629163e-02f, -1.60893679e-01f, -2.42208198e-01f,
  -2.27889076e-01f, -3.93867105e-01f, -2.05174208e-01f, -1.82625607e-01f, 2.51199007e-01f, -1.11459099e-01f, 2.21426427e-01f, 2.43418127e-01f, 1.50339708e-01f, 4.75414749e-03f,
  3.95151377e-01f, -2.67800651e-02f, 1.78185567e-01f, -1.18689887e-01f, 2.15975255e-01f, 8.79553854e-02f, -3.19154598e-02f, 8.92251804e-02f, 2.53036708e-01f, 3.15099686e-01f,
  7.17855990e-02f, 1.45409584e-01f, 1.69116706e-01f, 3.51746798e-01f, -1.73583597e-01f, -1.36788428e-01f, -5.16671054e-02f, 1.70009226e-01f, -1.30539566e-01f, -1.69313610e-01f,
  8.40622187e-02f, -1.04174852e-01f, -7.09446073e-02f, 8.95091370e-02f, 1.81640446e-01f, -2.27899373e-01f, 1.86304294e-03f, 8.78832117e-02f, -1.56300887e-01f, 1.80146188e-01f,
  1.03121214e-01f, 2.07960755e-01f, -7.67708465e-04f, 4.42103416e-01f, 2.17232648e-02f, 3.75346392e-02f, 5.16122282e-02f, -4.34891805e-02f, -7.33660683e-02f, 5.69496267e-02f,
  1.53278396e-01f, 7.10244477e-02f, -8.29400728e-04f, -1.74561422e-02f, 1.77498668e-01f, 3.72631364e-02f, -1.00187950e-01f, -2.67736483e-02f, -3.65491980e-03f, 6.33268505e-02f,
  7.87648261e-02f, 1.21682726e-01f, 7.92344064e-02f, -5.43996096e-02f, 3.73522878e-01f, -2.08451115e-02f, 6.93673790e-02f, -7.20798150e-02f, 1.86211273e-01f, 1.25198007e-01f,
  8.09082389e-03f, 5.24746962e-02f, 3.03192556e-01f, 2.58082990e-02f, -3.51031870e-02f, -4.00340147e-02f, -3.06939520e-02f, 1.22967556e-01f, 6.32196441e-02f, -2.38508269e-01f,
  2.17463106e-01f, 1.09529778e-01f, 2.85360873e-01f, 3.14656675e-01f, -1.11593746e-01f, 1.71833888e-01f, 6.12387545e-02f, 2.41700470e-01f, 1.15335576e-01f, 4.55444753e-02f,
  -2.12462582e-02f, -1.22271374e-01f, -1.51303485e-01f, 6.95720986e-02f, 6.95092827e-02f, -1.10133342e-01f, 1.50582701e-01f, 5.33907041e-02f, 4.16304916e-02f, 5.47472108e-03f,
  -2.05063783e-02f, 6.75484017e-02f, -5.03554568e-02f, -3.21396530e-01f, -8.01901594e-02f, -4.38417107e-01f, 2.20532551e-01f, -3.07769448e-01f, 1.17008567e-01f, 5.15589178e-01f,
  3.88471037e-02f, 1.82097122e-01f, -1.08407788e-01f, -2.57172659e-02f, -1.16744479e-02f, 1.08418345e-01f, -2.28618249e-01f, 1.95296273e-01f, -3.88110995e-01f, 1.86150059e-01f,
  2.32910484e-01f, -6.68102279e-02f, -1.16126910e-01f, -7.55939493e-03f, 2.04323724e-01f, 5.22114277e-01f, -1.94520220e-01f, 9.40200090e-02f, 1.63954973e-01f, 5.05573332e-01f,
  -2.10241631e-01f, 9.17899758e-02f, -1.11402266e-01f, 1.38579264e-01f, -1.57626923e-02f, 2.87825555e-01f, -2.51300894e-02f, 4.02374566e-02f, -2.33992338e-01f, -4.32441384e-02f,
  2.08372936e-01f, 2.38743857e-01f, 3.58263284e-01f, 4.29771036e-01f, 3.65425646e-01f, 6.28406182e-02f, -5.45143783e-01f, -9.17037129e-02f, -2.59403169e-01f, 3.17814589e-01f,
  1.93112627e-01f, -4.21996593e-01f, -1.17131695e-02f, 1.18009567e-01f, -4.01128363e-03f, 2.40157992e-02f, -1.31312087e-01f, 3.69227707e-01f, 5.28331548e-02f, -6.61577731e-02f,
  5.25133982e-02f, -1.76204830e-01f, -2.00529680e-01f, -1.65804736e-02f, -1.02746464e-01f, -2.66280235e-03f, -1.82886571e-01f, -1.68667231e-02f, 1.23652905e-01f, 1.89494435e-02f,
  5.04657663e-02f, 3.04874778e-02f, 1.88460782e-01f, -8.53894278e-02f, 1.72667295e-01f, 5.36600454e-03f, 1.94007140e-02f, -1.06619694e-03f, 7.88187608e-02f, -1.18167140e-01f,
  -1.00251138e-01f, -5.86977378e-02f, 8.08453783e-02f, -2.69337799e-02f, -6.35688156e-02f, -6.74384013e-02f, 1.48717076e-01f, -1.82026327e-02f, -4.40271497e-02f, 1.30331174e-01f,
  -4.10631374e-02f, 1.12623960e-01f, -1.26787528e-01f, -1.56117171e-01f, 2.09030718e-01f, -4.50120457e-02f, -8.72616023e-02f, -4.19828668e-03f, -1.65727679e-02f, -3.32989872e-01f,
  1.60874993e-01f, -2.30361149e-01f, 1.43947676e-01f, 2.18709186e-01f, 1.13743588e-01f, -1.28407493e-01f, -1.25632703e-01f, 9.34224725e-02f, 5.52644767e-02f, 3.52581069e-02f,
  -1.67116091e-01f, -3.81436914e-01f, 4.39379513e-02f, -1.57124028e-01f, 1.01372749e-01f, 1.06502555e-01f, -5.19293882e-02f, 1.69690579e-01f, -5.65079004e-02f, -4.79431543e-03f,
  6.45388365e-02f, -1.32916406e-01f, -1.87266931e-01f, 5.23981899e-02f, -1.37333423e-01f, -5.97145818e-02f, -8.19171686e-03f, 1.89351678e-01f, 3.81115871e-03f, -1.92594752e-01f,
  3.38572145e-01f, 1.51884630e-01f, 4.95087504e-01f, -2.98764735e-01f, -2.83378482e-01f, -1.83295712e-01f, 1.48905933e-01f, -1.97342813e-01f, -2.93958575e-01f, 2.73739666e-01f,
  -1.44843191e-01f, -2.28435427e-01f, 7.21585006e-02f, 3.76777798e-01f, 2.96158284e-01f, -9.07980427e-02f, -1.10587746e-01f, 3.40074360e-01f, -7.88023621e-02f, -3.12434494e-01f,
  -3.87843490e-01f, -8.00453275e-02f, -4.95834172e-01f, 4.24776301e-02f, 1.83040783e-01f, 2.03375414e-01f, -4.84324157e-01f, -2.27203667e-01f, 1.60037756e-01f, -1.31996244e-01f,
  -8.79165083e-02f, -3.78092915e-01f, 3.82254988e-01f, -2.34687105e-01f, -4.06443805e-01f, 4.43280518e-01f, 9.05599371e-02f, -7.80233964e-02f, -2.75380481e-02f, 4.52972762e-02f,
  -2.18988344e-01f, 2.08693847e-01f, 2.72407740e-01f, -2.99712330e-01f, -3.86462696e-02f, -3.85721743e-01f, 3.10239166e-01f, 2.72562087e-01f, -1.72559395e-01f, -1.68301672e-01f,
  -1.05106816e-01f, -1.00624496e-02f, -1.42845288e-01f, -2.65198797e-01f, -1.49755687e-01f, -1.04895934e-01f, -3.80776897e-02f, 1.57337368e-01f, 1.32420659e-01f, -6.66194707e-02f,
  -1.64570570e-01f, 3.51434486e-04f, -2.84791905e-02f, -2.14595616e-01f, -1.73060581e-01f, 3.21885161e-02f, 3.17182876e-02f, -3.14614773e-02f, 1.11959791e-02f, 1.50085106e-01f,
  -1.46908388e-01f, -4.97117825e-02f, 7.16065895e-03f, 4.38549668e-02f, 1.32316696e-02f, 2.45806202e-02f, 5.97384945e-02f, 1.27663583e-01f, -3.51978466e-02f, 2.66264658e-02f,
  -3.33542913e-01f, 7.75012895e-02f, -4.55980562e-02f, -9.97600108e-02f, -7.75256827e-02f, -2.79774040e-01f, -1.19647212e-01f, 9.84617025e-02f, 9.49347913e-02f, 3.76597159e-02f,
  -1.96243539e-01f, 1.48522586e-01f, -3.29021066e-01f, -3.26379873e-02f, -2.04938337e-01f, 9.00451839e-02f, -7.73717314e-02f, 8.78293738e-02f, -9.97746438e-02f, -1.39387250e-01f,
  -2.73471065e-02f, -2.30882347e-01f, 3.33627965e-03f, -1.93519399e-01f, 1.23992078e-01f, -4.42339331e-01f, -1.41284108e-01f, -3.22379894e-03f, 1.69439651e-02f, 4.01994623e-02f,
  5.68488054e-02f, 8.99966955e-02f, -8.10116306e-02f, -5.33446334e-02f, 6.66105747e-02f, -1.13779187e-01f, -2.18871281e-01f, -5.22583313e-02f, -9.27744806e-02f, 7.96296746e-02f,
  1.77533384e-02f, -1.15185849e-01f, -3.91534492e-02f, 9.64987203e-02f, -1.65050268e-01f, 1.82472710e-02f, 1.00013241e-02f, 5.15631214e-02f, -1.48245931e-01f, -2.09423408e-01f,
  -2.70278931e-01f, -3.59686464e-01f, 1.56682968e-01f, -2.59167880e-01f, -1.34059206e-01f, 6.13471828e-02f, -2.63022155e-01f, -4.65585031e-02f, -2.23865956e-02f, 1.16940543e-01f,
  -1.02653384e-01f, 1.87822029e-01f, -5.41024655e-02f, 3.78621340e-01f, 1.98421925e-01f, 2.86888629e-01f, -9.03618410e-02f, 1.40221551e-01f, 1.75371170e-01f, -2.03733295e-01f,
  -1.73713148e-01f, -1.26700103e-01f, 2.55771488e-01f, 2.27224395e-01f, 3.75576615e-01f, 1.30220219e-01f, 3.00661922e-01f, 2.71268308e-01f, -1.82949767e-01f, -1.97223440e-01f,
  -7.37953186e-02f, 1.15535147e-02f, -3.24889598e-03f, -3.06497455e-01f, 1.90827668e-01f, -1.60849653e-02f, -2.93772131e-01f, -2.31698260e-01f, -1.01608090e-01f, -3.20064873e-01f,
  -2.42904271e-03f, -1.60833031e-01f, -1.07606553e-01f, -1.68366432e-01f, 2.96060741e-02f, -2.01235980e-01f, -2.29544863e-01f, 2.59349376e-01f, 2.79818863e-01f, -1.02978811e-01f,
  1.77071765e-01f, -3.15367058e-02f, -8.73355120e-02f, -1.17498405e-01f, -1.17654905e-01f, -6.64672554e-02f, -4.21731360e-02f, -1.30390495e-01f, 1.19292066e-01f, -2.73159221e-02f,
  -2.00730432e-02f, 1.26970112e-01f, 2.26336136e-01f, 1.18272662e-01f, -2.38948036e-03f, -9.73328426e-02f, -1.36659786e-01f, -8.12044293e-02f, 7.42607862e-02f, 6.19351119e-02f,
  -6.63322732e-02f, 3.11384499e-01f, -1.32465258e-01f, 1.74486294e-01f, 1.21475093e-01f, 4.83107343e-02f, -6.41744733e-02f, 1.39110655e-01f, -2.31837425e-02f, -8.83057415e-02f,
  -9.16039944e-02f, 5.40904365e-02f, 1.17422737e-01f, 1.55986458e-01f, -3.74424458e-02f, -1.03537571e-02f, -1.65318921e-01f, -1.14902377e-01f, 8.53712261e-02f, 2.57656723e-02f,
  4.54544164e-02f, 2.07198225e-02f, -3.32498103e-02f, 6.85882717e-02f, -5.29831760e-02f, -7.79372547e-03f, -1.79944158e-01f, 1.89850748e-01f, -1.79062992e-01f, 9.41177979e-02f,
  3.79474573e-02f, 2.08994951e-02f, -9.37966481e-02f, 1.26665428e-01f, 1.25751570e-01f, -2.54418198e-02f, -9.87392068e-02f, -1.89466909e-01f, -7.43437856e-02f, -1.93021372e-01f,
  2.85541397e-02f, 1.24858625e-01f, -6.16505183e-02f, -3.59770805e-02f, 1.48486733e-01f, 7.91387632e-02f, 1.52666554e-01f, -2.38750391e-02f, 9.23016295e-02f, 5.69331683e-02f,
  -3.75858694e-02f, -1.19611032e-01f, 1.25807777e-01f, 8.96679685e-02f, 1.26973763e-01f, -2.79985696e-01f, -7.76771223e-03f, -3.23365331e-01f, -4.03582603e-02f, 2.17509910e-01f,
  -3.73538166e-01f, -1.62754953e-01f, 1.11380599e-01f, 2.14624435e-01f, -2.68192619e-01f, -2.97390163e-01f, -2.22139880e-01f, 4.27422553e-01f, -3.61233801e-01f, -1.34015560e-01f,
  4.85049114e-02f, 2.52020359e-02f, 3.27222794e-01f, 1.50534838e-01f, -2.10181415e-01f, -1.57340720e-01f, 1.98039368e-01f, 2.70130306e-01f, -1.85294792e-01f, 3.85254651e-01f,
  8.60741511e-02f, 5.80598563e-02f, 9.01273042e-02f, 2.73207724e-01f, -4.42874013e-03f, -1.86305955e-01f, -2.61087030e-01f, 2.75399834e-01f, -3.03410977e-01f, -3.56169194e-01f,
  -4.09414947e-01f, 2.16330111e-01f, -1.42102301e-01f, -1.58760399e-01f, -2.34548837e-01f, -2.15588138e-01f, -2.75232106e-01f, -1.65252045e-01f, 2.15838617e-03f, 2.55086180e-02f,
  6.53279871e-02f, -4.08710152e-01f, -3.08162928e-01f, -4.42695897e-03f, -3.47784579e-01f, -1.20611995e-01f, 7.76485130e-02f, 1.66886553e-01f, 5.54278269e-02f, -5.90274110e-02f,
  -7.19557330e-02f, 2.97483236e-01f, -7.28811249e-02f, -7.22117051e-02f, 1.09234333e-01f, 4.03690130e-01f, -1.47714272e-01f, -4.56780493e-02f, 1.32843584e-01f, -2.04418506e-02f,
  -6.26914855e-03f, -1.14497520e-01f, -1.80275425e-01f, -1.29065618e-01f, -3.64304110e-02f, -1.35205030e-01f, 2.22806200e-01f, 2.73118494e-03f, -3.14323083e-02f, -2.31241629e-01f,
  9.28894132e-02f, 1.58505052e-01f, 3.27997543e-02f, -3.52896154e-02f, 3.71653051e-03f, 1.24022299e-02f, 3.66937257e-02f, 8.04779381e-02f, 9.39351022e-02f, 1.99230597e-03f,
  -2.34822184e-02f, 2.02220693e-01f, -2.41052490e-02f, 1.14162177e-01f, 1.92346405e-02f, -8.11955333e-02f, 1.72696397e-01f, 9.07361209e-02f, 1.10548490e-03f, -2.40702480e-02f,
  5.62628508e-02f, -8.77264515e-02f, 8.65501389e-02f, -9.79910642e-02f, -3.33936423e-01f, 1.86044693e-01f, 9.13829878e-02f, -1.03809528e-01f, 8.60156938e-02f, 1.37828097e-01f,
  -1.92086518e-01f, 7.17797205e-02f, 6.18647002e-02f, 7.72972330e-02f, -4.99329299e-01f, -1.56439930e-01f, 4.60235439e-02f, 2.05795571e-01f, -2.03981381e-02f, 9.45227891e-02f,
  -3.44341286e-02f, -1.17505454e-01f, -7.54323974e-02f, -7.28590637e-02f, 5.85523658e-02f, -1.00289844e-01f, -6.83608651e-02f, -5.74595705e-02f, 1.19247623e-01f, 9.97654721e-03f,
  -7.34583735e-02f, 2.78065037e-02f, 5.44900820e-02f, 2.87837297e-01f, 1.74261063e-01f, 2.79908299e-01f, -3.12370509e-01f, -4.05048966e-01f, 3.24163407e-01f, 9.94253531e-02f,
  -7.87631422e-02f, -3.39239359e-01f, -5.46701327e-02f, 1.79631695e-01f, 5.60069345e-02f, -6.15751073e-02f, 2.69681394e-01f, 2.41229862e-01f, 2.98982024e-01f, 3.27200234e-01f,
  9.36023593e-02f, -3.72492746e-02f, -1.91121489e-01f, 2.27542277e-02f, -2.42558926e-01f, -4.16463792e-01f, -2.38917261e-01f, 5.82544832e-03f, 3.12683374e-01f, -4.01974052e-01f,
  3.35873775e-02f, -3.37579221e-01f, -2.05166444e-01f, -8.48561078e-02f, 1.61097333e-01f, -4.37586755e-01f, 4.10350412e-01f, 1.46236181e-01f, 1.87224090e-01f, -3.12126756e-01f,
  -9.40598473e-02f, 8.44558999e-02f, -2.74929311e-03f, -1.62210345e-01f, 1.46485001e-01f, -4.22255248e-02f, 2.15119570e-01f, -2.40612239e-01f, -3.43691185e-02f, 4.38305020e-01f,
  5.26904687e-02f, 2.16566756e-01f, 4.83277589e-02f, -7.50993341e-02f, -1.98113233e-01f, -1.17092155e-01f, 6.27696663e-02f, 2.45252922e-01f, -1.43955261e-01f, -1.38796881e-01f,
  1.74812376e-02f, -1.77546442e-01f, -4.22590077e-02f, -5.82349338e-02f, -1.61148787e-01f, 7.30346799e-01f, -2.78943721e-02f, 2.69478243e-02f, -9.89584401e-02f, -1.16563000e-01f,
  -3.19627896e-02f, -2.00065300e-01f, 2.81886477e-02f, 1.70876905e-01f, 3.65878522e-01f, -3.83338034e-02f, 1.18937753e-02f, -1.05496868e-01f, -6.98765963e-02f, -3.41644362e-02f,
  -1.77148581e-02f, -3.17707151e-01f, -1.12969071e-01f, 1.12867445e-01f, 1.25315458e-01f, -6.12043180e-02f, 6.47467077e-02f, -1.11467145e-01f, -9.17204190e-03f, -5.13772340e-03f,
  -3.11857872e-02f, 1.41212523e-01f, -9.72795188e-02f, 4.21604738e-02f, -1.57107353e-01f, -1.08093478e-01f, 6.26395419e-02f, 8.34649280e-02f, 6.94346428e-02f, 1.05348326e-01f,
  -1.98231731e-02f, -8.15790190e-05f, 6.01793490e-02f, 9.07044187e-02f, 1.83685213e-01f, 1.01831466e-01f, -5.66936545e-02f, -9.79054645e-02f, -4.65922803e-03f, -2.94495318e-02f,
  -1.36998191e-01f, 6.54469877e-02f, -2.61689425e-01f, -7.98273012e-02f, -3.36975493e-02f, 9.74255577e-02f, 1.02327861e-01f, 4.45274673e-02f, 1.63111314e-02f, 2.38049980e-02f,
  3.78170460e-02f, 1.94489658e-02f, 1.45188466e-01f, -1.22812185e-02f, 1.35307503e-03f, -3.83508801e-02f, -1.58984177e-02f, -8.02931413e-02f, -5.69550768e-02f, 2.53457874e-01f,
  1.15616858e-01f, -1.71882939e-02f, -3.44712049e-01f, -1.94095314e-01f, 1.78016603e-01f, -1.42636716e-01f, 1.98096365e-01f, -5.45045733e-02f, 2.69440591e-01f, -2.52792925e-01f,
  1.86086431e-01f, -1.78649604e-01f, -7.59614119e-03f, 2.30373532e-01f, 2.61401296e-01f, -3.14377159e-01f, -2.27576032e-01f, -1.80179588e-02f, 1.25184044e-01f, 6.90146629e-03f,
  -4.07660007e-01f, -1.16291538e-01f, 2.40070671e-01f, 2.92131603e-01f, 2.35610306e-01f, 1.06746927e-01f, -1.26436702e-03f, -1.27587570e-02f, -1.00571223e-01f, 1.06397800e-01f,
  -1.50232557e-02f, 5.14004827e-01f, 1.22049265e-01f, 3.31705779e-01f, -2.13691503e-01f, 1.69077784e-01f, 2.12535262e-01f, 1.68982282e-01f, -1.64810196e-01f, -1.47474423e-01f,
  -4.21580136e-01f, 1.93408594e-01f, -1.69851929e-01f, -5.39090075e-02f, 1.74237099e-02f, -5.84965106e-03f, 2.67365158e-01f, 2.45748207e-01f, 1.26358733e-01f, 3.72153372e-01f,
  -1.21072195e-01f, -9.35176164e-02f, -1.45632038e-02f, 8.25296193e-02f, -3.00736763e-02f, -1.12902559e-01f, 5.50786853e-01f, 9.78909656e-02f, -5.23027070e-02f, -1.41059831e-01f,
  -1.44870549e-01f, -7.15952665e-02f, -1.81777358e-01f, -1.78922266e-01f, -2.59685088e-02f, -1.87303007e-01f, 2.35093430e-01f, -8.54188129e-02f, 1.41553590e-02f, -1.11070544e-01f,
  3.15176636e-01f, -5.36589092e-03f, -6.77154288e-02f, -6.66703805e-02f, -6.72198087e-02f, -9.71860141e-02f, -1.54117048e-01f, -8.16624686e-02f, -6.16899207e-02f, -7.68284053e-02f,
  1.52591959e-01f, 7.94306770e-03f, 6.79937229e-02f, -1.01054624e-01f, -2.10696124e-02f, 3.01124882e-02f, 3.21200653e-03f, -2.20359713e-02f, -8.72573033e-02f, 1.07093960e-01f,
  -4.46175970e-02f, -2.00192422e-01f, -2.59854406e-01f, -5.19998334e-02f, 3.72186229e-02f, -2.70983502e-02f, 6.93523586e-02f, 1.26181871e-01f, 6.46435246e-02f, 1.13876022e-01f,
  1.96270034e-01f, -5.09937406e-02f, 1.60231978e-01f, -2.39817817e-02f, -1.62957340e-01f, 1.09749816e-01f, 1.32890761e-01f, 7.39229321e-02f, 2.95273717e-02f, 1.33502826e-01f,
  2.18204290e-01f, -2.28105895e-02f, 1.08782731e-01f, -1.26963034e-01f, 8.81570876e-02f, 8.52796510e-02f, 3.50140734e-03f, 1.59706287e-02f, -4.64726463e-02f, 5.96362799e-02f,
  -2.15438887e-01f, 8.78184941e-03f, 1.12056293e-01f, 1.93162095e-02f, 6.81694746e-02f, -1.27958864e-01f, 3.10613494e-02f, 1.09450728e-01f, 8.33199546e-02f, -1.64714251e-02f,
  1.66630909e-01f, -5.98612875e-02f, 4.31258768e-01f, 2.15493172e-01f, -2.20853373e-01f, 2.86817551e-01f, -3.23783815e-01f, 4.58519638e-01f, -2.15364143e-01f, 4.18262988e-01f,
  -7.62863159e-02f, -3.98020089e-01f, -4.31435257e-01f, 2.86232114e-01f, 2.83138037e-01f, -3.78349453e-01f, -2.64540352e-02f, 5.37965558e-02f, -1.31329730e-01f, -1.80589825e-01f,
  9.76253226e-02f, 2.31603354e-01f, -1.98126927e-01f, 1.33246779e-02f, 2.05844805e-01f, 2.92344600e-01f, -1.10855736e-01f, -9.64217559e-02f, 3.71806100e-02f, -3.94110717e-02f,
  8.12992454e-02f, 1.59482107e-01f, 3.51984352e-01f, -9.01677161e-02f, -3.41446906e-01f, -2.84811705e-01f, 1.95985094e-01f, -1.47421032e-01f, 1.12700090e-01f, -2.09800526e-01f,
  3.82096946e-01f, -5.05079985e-01f, -5.83755877e-03f, -1.07048318e-01f, 2.78051734e-01f, -8.85679349e-02f, -4.32098448e-01f, -1.16084211e-01f, -3.45691890e-02f, 3.11549515e-01f,
  -3.36113735e-03f, 5.82895838e-02f, 2.54444554e-02f, 4.96127233e-02f, 3.09862383e-03f, -1.14589714e-01f, 1.59811541e-01f, 1.16784118e-01f, -8.10342431e-02f, 2.90749937e-01f,
  -1.93603173e-01f, -2.63757765e-01f, 9.39581990e-02f, 5.42043932e-02f, -4.79208790e-02f, -3.11403181e-02f, -1.38472682e-02f, -6.85576349e-02f, -8.84260237e-02f, -1.29505932e-01f,
  -1.20723076e-01f, -6.63610324e-02f, -1.07144527e-01f, 5.09567373e-02f, 6.25893101e-02f, -2.14929089e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.36970831e-02f, 1.61871326e-03f, 9.84694436e-03f, -3.49836424e-02f, -2.40888465e-02f, 7.04068244e-02f, 3.62422131e-02f, 1.33555336e-02f, -9.99422744e-02f, -2.85510309e-02f,
  5.98008335e-02f, 8.86385068e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    