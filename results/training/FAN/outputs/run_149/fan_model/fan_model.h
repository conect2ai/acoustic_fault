/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.70305324e-01f, 4.38337177e-02f, 1.55705303e-01f, 1.76123664e-01f, -8.75159055e-02f, 2.58342087e-01f, 2.00128734e-01f, -1.29064336e-01f, -5.99853285e-02f, -1.57315359e-02f,
  -6.87500238e-02f, 3.08511227e-01f, -8.15406889e-02f, 1.90723196e-01f, 3.50364298e-01f, 4.83052880e-02f, 3.92526180e-01f, 2.03294724e-01f, -2.68594958e-02f, 1.37174487e-01f,
  1.13186195e-01f, 5.18354513e-02f, 8.48692879e-02f, -2.23821327e-01f, 1.03645958e-01f, -1.17798030e-01f, -8.96565691e-02f, -2.28605330e-01f, 6.49952963e-02f, 2.38553509e-02f,
  -3.13050039e-02f, -4.61356789e-02f, 6.21854281e-03f, -1.05451247e-04f, 6.43336102e-02f, 5.99310212e-02f, 9.44695473e-02f, -7.74988160e-03f, -7.23851696e-02f, -3.09271924e-02f,
  1.04896128e-01f, 3.20580825e-02f, -2.40650959e-02f, -6.47176057e-02f, 2.83844676e-02f, -2.70221923e-02f, 4.58631702e-02f, 7.04877451e-03f, -4.78878468e-02f, 1.42410472e-01f,
  2.63141375e-02f, 5.75438663e-02f, 1.26020223e-01f, 2.16835402e-02f, 1.40426029e-02f, 4.28239768e-03f, 7.31018558e-02f, 8.45955014e-02f, 4.24927473e-02f, 4.75546904e-02f,
  5.32533452e-02f, 1.67439375e-02f, 5.54827694e-03f, -9.99883488e-02f, -2.57491488e-02f, -4.29852121e-02f, -2.25065332e-02f, 4.06417362e-02f, 3.53299576e-04f, 4.13147397e-02f,
  -3.30711417e-02f, -5.50437393e-03f, -6.36566952e-02f, 3.68278399e-02f, 7.50154108e-02f, -2.17704047e-02f, 6.54244274e-02f, 5.33416588e-03f, 3.41421440e-02f, -6.23336760e-03f,
  -9.87235606e-02f, 2.42309198e-02f, -8.10893774e-02f, -3.50941010e-02f, -3.76805551e-02f, -4.74768318e-02f, -5.81192691e-03f, -1.93430611e-03f, -1.31133065e-01f, 3.32374945e-02f,
  8.20159242e-02f, 1.20967023e-01f, -5.59881255e-02f, -8.74435306e-02f, -3.00508030e-02f, 7.18094707e-02f, 9.04366821e-02f, 5.21358922e-02f, 1.36638237e-02f, 5.36771826e-02f,
  1.39408186e-01f, -5.38197607e-02f, -2.08628215e-02f, -3.09854988e-02f, -1.54626854e-02f, 1.16294855e-02f, 1.01563580e-01f, -1.41480342e-01f, 9.12843645e-02f, -2.38653645e-02f,
  1.89357921e-02f, 9.95984999e-04f, 2.34581847e-02f, -6.20236807e-03f, 4.25079279e-02f, -5.02458541e-03f, 8.68428648e-02f, -4.49727289e-02f, 4.14193124e-02f, -2.77687120e-03f,
  -2.90181190e-01f, 1.15418732e-01f, -2.30758384e-01f, -2.79145092e-01f, 4.62628296e-03f, 5.34606986e-02f, -3.81743163e-02f, 4.56194542e-02f, -3.75363618e-01f, 2.88636982e-01f,
  1.23219803e-01f, -3.17798167e-01f, 1.80008218e-01f, 1.18034773e-01f, -2.55599499e-01f, 6.38510361e-02f, 6.56031072e-02f, -9.34449285e-02f, -1.36011109e-01f, 1.38677163e-02f,
  -1.61594272e-01f, 2.91517496e-01f, 1.30062774e-01f, 2.43079901e-01f, 1.58347711e-01f, -7.87503272e-02f, 2.22994521e-01f, 2.36682105e-03f, 1.49175823e-01f, 3.80148515e-02f,
  1.13219567e-01f, -2.27469616e-02f, 4.62944172e-02f, 9.06984583e-02f, 8.01106989e-02f, 7.87258223e-02f, 5.52012473e-02f, 4.76231799e-02f, -7.56908655e-02f, -1.01770088e-01f,
  2.28433292e-02f, -1.80983748e-02f, -8.40379018e-03f, -5.88569045e-02f, -5.06549440e-02f, -1.00767137e-02f, 2.20082812e-02f, -9.36611444e-02f, -4.07028757e-02f, -2.74206009e-02f,
  -4.74644713e-02f, -1.02763645e-01f, -5.90872094e-02f, -2.85183061e-02f, -9.23338309e-02f, -3.27833667e-02f, 2.47178804e-02f, -2.61425264e-02f, -8.93142745e-02f, -3.16321366e-02f,
  -4.30863090e-02f, -2.47270204e-02f, 4.50962186e-02f, 6.00216649e-02f, 3.10165454e-02f, 6.79501891e-02f, 1.02875292e-01f, 1.64372757e-01f, -5.99408448e-02f, -4.80119400e-02f,
  -1.00530684e-02f, -2.82352604e-03f, 4.33086641e-02f, -5.35812415e-02f, 9.67147276e-02f, -1.06556704e-02f, -7.44703189e-02f, 4.80469614e-02f, -2.93793194e-02f, 6.61295056e-02f,
  4.13868465e-02f, -3.61254811e-02f, 4.15118560e-02f, 4.08551395e-02f, -3.57110351e-02f, -1.35483891e-01f, 4.67848331e-02f, 1.88985020e-02f, -4.12055366e-02f, 6.74229115e-03f,
  1.51162133e-01f, 1.52627125e-01f, 1.20824426e-01f, 9.35458764e-02f, 4.98535149e-02f, -5.88488532e-03f, 4.66521122e-02f, 5.33249527e-02f, 2.87477691e-02f, -1.13221064e-01f,
  1.11888128e-03f, 1.20167166e-01f, -7.09902793e-02f, -7.61660933e-02f, -3.01284175e-02f, 3.00835054e-02f, -1.61814839e-02f, -7.42171332e-02f, 1.59393977e-02f, 5.14648259e-02f,
  -9.04093403e-03f, -6.90739155e-02f, -9.35042351e-02f, 3.56383547e-02f, 3.34548615e-02f, 2.82132663e-02f, -4.23146896e-02f, -7.37676919e-02f, 3.51175591e-02f, 4.97624464e-03f,
  3.70254248e-01f, -2.84425050e-01f, 2.48182327e-01f, 4.83041406e-02f, -1.33086238e-02f, -1.51738331e-01f, -9.66493860e-02f, -3.10571922e-04f, 5.56703769e-02f, -1.12913080e-01f,
  -1.73418626e-01f, -2.59468798e-02f, -1.71585396e-01f, -2.73743182e-01f, 1.10089347e-01f, -2.03330487e-01f, -1.86891600e-01f, -2.63113920e-02f, 2.80602220e-02f, -1.59513634e-02f,
  8.88025761e-02f, -1.89898297e-01f, -6.43961504e-02f, -6.89212652e-03f, 1.19518850e-03f, 1.29722953e-01f, 1.25340238e-01f, 6.01976886e-02f, -8.32575858e-02f, -7.57820830e-02f,
  2.42005456e-02f, 2.36355081e-01f, 4.69178781e-02f, 8.08365792e-02f, 6.19675331e-02f, 1.57239333e-01f, 1.07647635e-01f, 1.14272319e-01f, -3.00251096e-02f, -1.57714151e-02f,
  8.36429279e-03f, -2.20186543e-02f, -1.35993913e-01f, -2.36832183e-02f, -8.87280237e-03f, -2.11275853e-02f, -1.96939781e-02f, -3.37557495e-02f, -9.39605981e-02f, 4.16726060e-02f,
  -6.61627576e-02f, -8.05671886e-02f, 3.31126642e-03f, -7.88898990e-02f, 1.52498260e-02f, -3.30534019e-02f, 1.33786350e-01f, 2.10790075e-02f, -1.34409145e-01f, 1.27525581e-02f,
  -4.34215553e-03f, 5.88723831e-02f, 6.31818920e-02f, 1.58016607e-02f, 8.10754448e-02f, 1.27543256e-01f, -4.57689278e-02f, 3.38319018e-02f, 8.54776055e-02f, 4.64821272e-02f,
  -6.09950908e-02f, 2.20684521e-03f, 5.87464422e-02f, -3.63685861e-02f, 6.88249245e-03f, 6.44701645e-02f, 3.25866528e-02f, 4.37225774e-02f, -6.56392053e-02f, 6.06012866e-02f,
  6.23420216e-02f, 5.31720323e-03f, -5.66052683e-02f, -8.89059752e-02f, -1.90571696e-02f, -1.77346300e-02f, -3.50125767e-02f, -1.60044525e-02f, 7.01259822e-02f, -3.34163345e-02f,
  -3.61724524e-03f, 1.98648214e-01f, -1.53790675e-02f, -1.23817455e-02f, 5.36586270e-02f, 1.56839229e-02f, 5.42449690e-02f, 5.68362176e-02f, -4.57759574e-02f, 7.34445974e-02f,
  6.28857017e-02f, -6.54714927e-02f, -1.98505223e-02f, -1.18941836e-01f, -3.62466238e-02f, -3.58008780e-02f, 5.79146147e-02f, 3.89759173e-03f, -4.55582701e-02f, 1.82501823e-02f,
  1.10961199e-01f, -4.62193321e-03f, 1.13013707e-01f, 4.98512536e-02f, 9.80024263e-02f, -8.48931260e-03f, 1.17916919e-01f, -3.33125591e-02f, 7.40578324e-02f, -1.33236498e-01f,
  2.63557553e-01f, 6.75217956e-02f, 5.20075613e-04f, -7.88143743e-03f, 1.12347789e-01f, -3.42541486e-02f, -8.19373280e-02f, 5.20792939e-02f, -2.39647463e-01f, -1.25017725e-02f,
  -6.97231293e-02f, 1.67865962e-01f, -1.17966004e-01f, -1.81131400e-02f, -9.98386964e-02f, -1.56225830e-01f, 4.43700738e-02f, 1.33458480e-01f, -5.63687906e-02f, 5.19477651e-02f,
  -4.47607832e-03f, 8.10053498e-02f, -5.61014488e-02f, 8.70257095e-02f, 2.27479741e-01f, 1.49604410e-01f, 1.27536535e-01f, -2.72246972e-02f, 1.25324011e-01f, 1.40229915e-03f,
  -5.07495068e-02f, -4.43184376e-02f, 1.27226254e-02f, -5.88255608e-03f, -2.93001384e-02f, 6.04928024e-02f, 1.07653700e-01f, 4.75548580e-02f, -5.28021716e-02f, -3.61145586e-02f,
  1.65123224e-01f, 3.56411897e-02f, -8.38871524e-02f, -3.26734129e-03f, 1.06115386e-01f, -2.22129859e-02f, 5.38201444e-03f, 2.57761888e-02f, 1.30670359e-02f, -3.85175981e-02f,
  -2.71386746e-02f, 7.34533817e-02f, 7.64546692e-02f, 2.71813888e-02f, -2.85010375e-02f, -2.48469114e-02f, -6.15946725e-02f, 7.86050260e-02f, 8.13911706e-02f, -4.04013954e-02f,
  1.11005649e-01f, -3.28886025e-02f, 1.72596779e-02f, -3.33724767e-02f, -6.85462505e-02f, -1.31459991e-02f, 1.00214630e-02f, 8.12146068e-02f, -6.71395939e-03f, -5.56151904e-02f,
  -2.21366435e-03f, -2.99938265e-02f, -4.77481447e-02f, 9.96243325e-04f, 4.58471328e-02f, -6.62718862e-02f, 1.07878856e-01f, 1.05928540e-01f, -1.23255678e-01f, 2.92563532e-02f,
  2.34466456e-02f, -4.75846976e-02f, -1.69192269e-01f, 4.81041409e-02f, -1.21586714e-02f, -6.21482134e-02f, -5.82306692e-03f, -3.59645300e-02f, -6.40550554e-02f, 6.71074837e-02f,
  3.66075970e-02f, -3.23443003e-02f, -9.97885019e-02f, -6.81673214e-02f, -1.18370123e-01f, 5.50577603e-02f, -3.32248695e-02f, 1.02370612e-01f, -2.29800828e-02f, -3.37054655e-02f,
  1.55393943e-01f, 2.00678315e-02f, -7.72537710e-03f, -1.53622329e-01f, 1.21357739e-01f, -1.36213139e-01f, 1.62578616e-02f, -4.90152091e-02f, 9.06034559e-02f, 4.40114457e-03f,
  8.48125219e-02f, -1.86890420e-02f, 8.75375047e-02f, -5.37374616e-02f, 1.39317617e-01f, 1.02219032e-03f, 9.66432784e-03f, -6.44149333e-02f, 1.23850174e-01f, -8.09772909e-02f,
  -9.39826816e-02f, 1.08716294e-01f, 2.06154585e-02f, -5.58745535e-03f, -2.79274195e-01f, -8.22054371e-02f, 6.24709874e-02f, -2.17671990e-01f, -2.43934274e-01f, 6.32954538e-02f,
  -1.00429200e-01f, 1.51420176e-01f, 4.56537120e-02f, 8.64645094e-02f, -9.50161517e-02f, -1.44360319e-01f, 1.10967897e-01f, 8.82679000e-02f, -8.53518620e-02f, 1.22774309e-02f,
  -3.49823199e-02f, -1.31732121e-01f, 9.44028199e-02f, -2.13575602e-01f, 7.78445154e-02f, -5.31852618e-02f, 2.93773357e-02f, 1.97079051e-02f, 3.58800478e-02f, -7.72197079e-03f,
  1.15973674e-01f, -7.60503635e-02f, 1.20640941e-01f, 1.04021497e-01f, 7.39979818e-02f, 2.13322341e-02f, 1.67664647e-01f, -2.62534339e-02f, -3.04302163e-02f, 6.20333478e-02f,
  5.66678569e-02f, -4.77635153e-02f, 5.31785861e-02f, -8.32000822e-02f, -9.38325655e-03f, 7.00552890e-04f, -8.72638375e-02f, 7.42592192e-06f, -5.62529825e-02f, -6.90013468e-02f,
  -4.16932479e-02f, 1.30294830e-01f, -4.43188772e-02f, 5.69471568e-02f, -7.34552220e-02f, -1.11804798e-01f, 5.59184030e-02f, 5.09862974e-02f, -8.69940314e-03f, -1.93928778e-02f,
  -1.12232782e-01f, 8.69230330e-02f, 9.50860605e-03f, 3.64910364e-02f, -9.59730707e-03f, 2.64169630e-02f, 6.59805164e-02f, 5.91543838e-02f, 2.36524735e-02f, 9.60438251e-02f,
  9.26296040e-02f, 6.20624535e-02f, -7.73224011e-02f, -5.20091206e-02f, 3.87713220e-03f, 7.74997752e-03f, 8.95909220e-03f, 6.83258986e-03f, 6.39152303e-02f, -3.08775436e-02f,
  -5.81242405e-02f, -3.50427665e-02f, 9.35975239e-02f, 1.41964972e-01f, 1.86497520e-03f, -9.69021246e-02f, 3.42734158e-02f, -8.08117038e-05f, -5.76881655e-02f, 3.18815745e-02f,
  7.89452046e-02f, 2.63202209e-02f, 2.23306231e-02f, 5.16957268e-02f, 7.25133866e-02f, -7.77553469e-02f, 3.85668613e-02f, -9.94171202e-02f, -2.95835380e-02f, -1.17467366e-01f,
  -3.86053137e-03f, 1.30393937e-01f, 4.86596115e-02f, 3.07599008e-02f, 1.15220182e-01f, -4.58695255e-02f, -4.61377390e-02f, 7.66397566e-02f, -2.16786005e-02f, 5.56422956e-03f,
  -6.44491166e-02f, -1.89109035e-02f, 6.12269230e-02f, 1.27498200e-02f, 2.41035689e-02f, 4.43390906e-02f, -3.72209474e-02f, -2.61724889e-02f, -7.77154490e-02f, 6.26729205e-02f,
  -1.48821846e-01f, 1.65523946e-01f, 2.31816620e-01f, -8.81884843e-02f, -2.65211105e-01f, -1.10842131e-01f, 1.76294804e-01f, -8.35835189e-02f, -4.48053181e-02f, 1.10588312e-01f,
  -7.08373711e-02f, 2.39559114e-01f, 2.10435435e-01f, -6.55033737e-02f, 5.31568639e-02f, 2.02910349e-01f, -1.15697242e-01f, 6.67385608e-02f, 3.32774185e-02f, 9.90865752e-02f,
  -5.70888929e-02f, -3.27690631e-01f, 6.29088655e-02f, -7.62085319e-02f, -1.60378873e-01f, 4.09733364e-03f, -5.08874953e-02f, 1.66569576e-01f, -1.43802509e-01f, -6.20894022e-02f,
  -1.75032482e-01f, -6.55923858e-02f, -1.52857387e-02f, -4.31115888e-02f, -1.44576475e-01f, -4.62031439e-02f, -7.52565935e-02f, -1.65388733e-02f, 7.79210627e-02f, -5.17814308e-02f,
  -3.40164453e-02f, -2.12146208e-01f, -4.33264598e-02f, 4.83712032e-02f, -7.36649632e-02f, -6.70824572e-02f, -2.33852658e-02f, -6.10368811e-02f, -6.32752925e-02f, 1.46353068e-02f,
  4.47655395e-02f, -1.30646482e-01f, -3.74371745e-02f, -1.16219029e-01f, -1.15485825e-01f, -1.77403111e-02f, -2.33685672e-02f, -3.51713598e-02f, -1.25699580e-01f, -2.20447674e-01f,
  -6.03778102e-03f, 7.69801205e-04f, 8.04168954e-02f, -2.43682624e-03f, -4.22431566e-02f, -5.07272109e-02f, 1.28483236e-01f, -1.16244680e-03f, 1.53506426e-02f, -1.08742155e-01f,
  -8.06615278e-02f, -3.76878753e-02f, -2.76270835e-03f, -8.52861032e-02f, -8.28311145e-02f, -6.06496781e-02f, 9.25549343e-02f, -5.40088229e-02f, -4.49138358e-02f, -2.63252705e-02f,
  1.20447621e-01f, -1.00732446e-01f, 7.20499009e-02f, -8.88416469e-02f, 7.23396987e-02f, -3.21345329e-02f, -8.85841995e-02f, 3.96249406e-02f, 1.70375973e-01f, -8.54729660e-05f,
  -2.01315023e-02f, 1.25741407e-01f, 1.35255782e-02f, -1.28817081e-01f, 3.16401385e-02f, 8.80747382e-03f, 3.34048755e-02f, -2.10522879e-02f, 1.05912112e-01f, -4.54351865e-02f,
  -1.09120369e-01f, -7.34459385e-02f, -4.58011627e-02f, -4.16898914e-02f, 2.81807445e-02f, 4.90098409e-02f, 1.29705161e-01f, 3.05505861e-02f, -1.08035997e-01f, 5.00111189e-03f,
  4.82172854e-02f, 5.88786565e-02f, -8.82269163e-03f, -2.63843715e-01f, -1.32092744e-01f, 9.99198016e-03f, 8.78285691e-02f, -6.02215901e-02f, -1.11620553e-01f, -9.46196690e-02f,
  -2.42573455e-01f, 5.03769740e-02f, -1.56606734e-01f, -1.53025031e-01f, 8.06567967e-02f, -8.81452933e-02f, -1.69925377e-01f, -2.91010644e-02f, 9.17394236e-02f, -1.39062598e-01f,
  -5.25272489e-02f, -2.71437794e-01f, 6.58444241e-02f, -9.09099504e-02f, -1.84888572e-01f, 1.78237453e-01f, -1.43655881e-01f, -1.93599164e-01f, -3.75972502e-02f, -8.74752551e-02f,
  6.98368847e-02f, -2.49906499e-02f, 3.76999713e-02f, 1.96000617e-02f, -3.32053959e-01f, -9.50125381e-02f, -1.47201061e-01f, -6.17265189e-03f, -2.92315274e-01f, -1.38330340e-01f,
  -9.69304368e-02f, 1.23654492e-02f, 3.39318104e-02f, -3.40529941e-02f, -1.30864382e-01f, -1.45182693e-02f, -2.97842752e-02f, 5.56317344e-02f, -4.35801670e-02f, 2.74088364e-02f,
  -1.06292088e-02f, 4.94613983e-02f, 6.19999319e-03f, 7.85112381e-02f, -4.75253910e-02f, 1.74044091e-02f, -1.20047107e-02f, -8.44948217e-02f, -8.06671754e-03f, 7.11092353e-03f,
  -3.68370041e-02f, -1.58479791e-02f, -1.03388697e-01f, -5.47752343e-02f, -4.31823507e-02f, -6.65952787e-02f, 9.84768122e-02f, -9.44831991e-04f, -1.29872501e-01f, -7.73316324e-02f,
  -1.09741818e-02f, 1.78482145e-01f, 5.30162938e-02f, -3.75006944e-02f, -1.19334571e-02f, -2.19043382e-02f, -1.91058908e-02f, 4.63658273e-02f, -2.68489104e-02f, 2.85188798e-02f,
  -1.90065503e-02f, -1.89313535e-02f, -7.00043701e-03f, -7.15293065e-02f, -3.12382448e-02f, 4.73036990e-03f, -1.63137410e-02f, -1.17447719e-01f, 7.03066308e-03f, -2.14474630e-02f,
  -2.37901025e-02f, -1.38321845e-02f, 2.33442010e-03f, 1.21223167e-01f, -2.56591775e-02f, -8.44416469e-02f, 1.40528968e-02f, -3.08364481e-02f, -3.46971937e-02f, -4.98891287e-02f,
  -1.46826267e-01f, -1.68914095e-01f, 9.20477509e-02f, -7.27383420e-02f, -2.38085538e-02f, -8.86527263e-03f, 8.01196098e-02f, 1.14934318e-01f, -1.77125409e-01f, -1.07111968e-02f,
  4.26198393e-02f, 3.28054950e-02f, -5.62212318e-02f, 8.40154365e-02f, -4.04815041e-02f, 3.02280840e-02f, -6.95021898e-02f, -7.08732530e-02f, -2.01247837e-02f, -2.78865099e-02f,
  -4.66627218e-02f, -1.62379332e-02f, 1.55553613e-02f, 5.83450720e-02f, 2.40577031e-02f, -6.45768642e-02f, -5.84923849e-02f, 6.76103160e-02f, -5.13438098e-02f, -9.23491642e-03f,
  -2.89029539e-01f, 3.78220499e-01f, 2.06087023e-01f, -1.40030935e-01f, -1.73851475e-01f, -3.49999785e-01f, -3.29266518e-01f, -1.79099873e-01f, -1.23505756e-01f, 5.70269860e-03f,
  -1.10768430e-01f, 7.00969324e-02f, 6.32229298e-02f, -3.14095140e-01f, -4.75598156e-01f, -2.48165410e-02f, -2.64850646e-01f, -1.16834603e-01f, -1.09447159e-01f, -6.52041705e-03f,
  -2.17767373e-01f, -2.57690489e-01f, -2.78666639e-03f, -5.51909357e-02f, -1.75107077e-01f, 1.16879530e-01f, -7.24411383e-02f, 1.20709263e-01f, -2.15847567e-01f, -9.67681333e-02f,
  1.70793980e-02f, 1.30087927e-01f, 8.74441564e-02f, 8.74077380e-02f, 2.81382930e-02f, 6.20369054e-02f, 2.88132206e-02f, 3.37160006e-02f, 3.85474041e-03f, -1.57603677e-02f,
  -4.47478052e-03f, -9.58118588e-02f, -2.87215672e-02f, -5.12786694e-02f, -3.89439724e-02f, -2.58462597e-03f, -7.28783309e-02f, -2.33673584e-02f, -4.38356027e-02f, -8.05065706e-02f,
  -5.62544912e-03f, -2.10710000e-02f, -1.06545798e-01f, 5.14038615e-02f, -2.39992421e-02f, -7.13693947e-02f, 5.49560785e-02f, 2.28101052e-02f, -1.03637598e-01f, -1.17453359e-01f,
  -9.89613310e-02f, 1.10518578e-02f, -5.75501733e-02f, 3.18039060e-02f, -1.41934603e-02f, 1.30829904e-02f, -4.76253778e-02f, 2.01692227e-02f, 9.05576795e-02f, 6.64045662e-02f,
  -5.59801981e-02f, 3.76728363e-02f, -1.88285168e-02f, -1.76018834e-01f, -1.63184598e-01f, 1.14117796e-02f, 3.08673773e-02f, 9.94556583e-03f, 1.89560968e-02f, -4.49966546e-03f,
  -1.54685369e-02f, -5.83056873e-03f, 5.61590306e-02f, 6.83870837e-02f, 2.36857422e-02f, -3.17836180e-02f, 3.31493258e-03f, -3.95690650e-02f, 5.60906529e-03f, -2.68229470e-02f,
  5.05178273e-02f, 8.90353248e-02f, 5.43622077e-02f, 4.92111556e-02f, 1.31986588e-01f, -3.21916565e-02f, 3.55953798e-02f, -4.68668388e-03f, -3.50463688e-02f, -7.83457235e-02f,
  -8.95973220e-02f, 6.10980857e-03f, 1.94811355e-02f, 3.96451093e-02f, 6.45115003e-02f, -8.04113876e-03f, -6.49025738e-02f, 2.36227345e-02f, -8.08110684e-02f, 5.69196530e-02f,
  -4.55885790e-02f, -4.85212095e-02f, 8.15698206e-02f, -1.42975943e-02f, -2.50990968e-02f, 2.63698287e-02f, 2.37069884e-03f, 3.56965177e-02f, -1.15589052e-02f, 3.37402336e-02f,
  3.25083375e-01f, -1.30072117e-01f, 2.26941347e-01f, -1.98132426e-01f, 6.97001889e-02f, -8.84087831e-02f, -1.29851416e-01f, -1.63739085e-01f, -6.21366762e-02f, -3.63593966e-01f,
  -2.58740753e-01f, -2.46719122e-02f, -2.23632216e-01f, -4.06601518e-01f, -5.99777065e-02f, -2.88428634e-01f, -3.06329399e-01f, -1.17878199e-01f, 6.93032816e-02f, -1.01872711e-02f,
  -6.16934747e-02f, -3.08006287e-01f, -1.32166788e-01f, -1.22541316e-01f, -1.24957167e-01f, 4.00591567e-02f, -1.14648603e-01f, 1.10658571e-01f, -2.37966970e-01f, -3.27605791e-02f,
  2.36939359e-02f, 2.65953727e-02f, 4.86392900e-02f, 7.37609863e-02f, 8.40314757e-03f, 7.69622996e-02f, 5.27537949e-02f, 4.45450917e-02f, 6.16069324e-02f, 3.35267596e-02f,
  2.34104358e-02f, -1.18748344e-01f, -1.61775742e-02f, -1.32633431e-03f, 1.32567242e-01f, 5.84258847e-02f, 5.39747439e-03f, -6.54417183e-03f, -1.06945872e-01f, -1.07897762e-02f,
  -3.53323109e-02f, 2.07295232e-02f, 9.18406472e-02f, -1.20971583e-01f, -4.75481562e-02f, -4.89918627e-02f, 7.22625405e-02f, 8.66387933e-02f, -8.23974088e-02f, -9.47798863e-02f,
  -7.13729337e-02f, 1.26658808e-02f, -5.47636636e-02f, 8.75183120e-02f, 3.30927707e-02f, 5.79627557e-03f, -5.59482761e-02f, 2.50127893e-02f, 8.75098556e-02f, 1.33244006e-03f,
  -1.03313979e-02f, 6.02752790e-02f, 6.02917410e-02f, -8.75882283e-02f, -1.13720395e-01f, 7.95860589e-02f, 1.61312029e-01f, -1.07718460e-01f, -3.85239832e-02f, 3.26687619e-02f,
  3.74063477e-02f, 5.78204803e-02f, 2.45658532e-02f, -3.18400469e-03f, 6.12905696e-02f, -3.25325392e-02f, -1.01863377e-01f, 3.86445932e-02f, 1.44827683e-02f, -5.04080243e-02f,
  -2.42860973e-01f, -2.21347272e-01f, -7.12982938e-02f, -3.81411314e-02f, 4.12099287e-02f, 6.26833066e-02f, -1.96046545e-03f, -1.39492350e-02f, -1.24207467e-01f, -9.97781660e-03f,
  1.07400203e-02f, 1.45603437e-02f, -1.61307305e-02f, -3.53333578e-02f, -3.73627320e-02f, -4.39846702e-02f, -6.19174801e-02f, -1.06379092e-02f, -9.74227786e-02f, 1.95272956e-02f,
  -7.63793439e-02f, -2.13537421e-02f, 5.76556809e-02f, -4.08832245e-02f, -6.62259087e-02f, -2.80619878e-02f, 7.89290518e-02f, -2.13810382e-03f, -3.69769037e-02f, -9.78109986e-02f,
  -2.89957613e-01f, -1.40329883e-01f, 1.13617286e-01f, 1.54982805e-01f, 7.01566041e-02f, 2.95789033e-01f, 2.60330141e-01f, -2.78220251e-02f, 1.71649814e-01f, 6.49446920e-02f,
  1.56351954e-01f, 8.49972852e-03f, 8.23420584e-02f, 2.18377784e-01f, 3.08341444e-01f, 1.95462674e-01f, 2.20146686e-01f, 2.18496978e-01f, -3.44039239e-02f, -4.98402864e-02f,
  3.78861576e-02f, 1.40252754e-01f, 1.11105360e-01f, -4.27640080e-02f, -5.97826988e-02f, -2.49175504e-01f, -2.29027972e-01f, -9.54355448e-02f, 9.03353095e-03f, 1.16232559e-01f,
  -4.55798954e-02f, 2.22174264e-03f, 2.77768262e-02f, 4.32339944e-02f, -4.38478813e-02f, 3.80909070e-02f, -1.52729983e-02f, 9.55557600e-02f, 1.03729079e-02f, -3.90137583e-02f,
  3.86273004e-02f, -2.17842571e-02f, -7.83542618e-02f, -2.08597630e-03f, -1.92622431e-02f, -2.77994052e-02f, 3.74489240e-02f, -7.88424537e-03f, -1.90006346e-02f, 2.77554058e-02f,
  5.57468459e-02f, -6.83949739e-02f, -2.74410658e-02f, -9.05360654e-03f, -2.09616330e-02f, 2.27753520e-02f, -3.34237777e-02f, -4.95325103e-02f, -6.54854625e-02f, 7.47828139e-03f,
  4.45401156e-03f, -4.23680618e-02f, -1.35974642e-02f, -3.69637720e-02f, 1.19513099e-03f, -5.41065335e-02f, 3.27769853e-02f, 5.30821122e-02f, -8.22072849e-02f, -2.00291928e-02f,
  -3.58813778e-02f, 1.11353826e-02f, -7.33878762e-02f, 4.96564060e-02f, 4.07369733e-02f, -4.74203229e-02f, -4.34344448e-02f, -9.40575525e-02f, -2.65499614e-02f, 5.05488948e-04f,
  6.84562996e-02f, -2.37291958e-02f, -4.53933142e-02f, -6.42921478e-02f, 5.16124186e-04f, 2.84218509e-02f, -1.08199110e-02f, -3.52578014e-02f, 7.01586436e-03f, -2.81190476e-03f,
  -1.17180452e-01f, -1.57064348e-01f, 4.72448394e-02f, -9.19361692e-03f, 6.34738617e-03f, 2.79202871e-02f, 7.65575767e-02f, 1.12465173e-02f, 1.03422301e-02f, -6.46798499e-03f,
  1.79883409e-02f, -8.13217089e-02f, -1.72612473e-01f, -8.82620066e-02f, 6.56859949e-02f, -5.55467904e-02f, -1.05088763e-02f, -7.16939270e-02f, -2.47555086e-03f, -7.32076541e-02f,
  -4.08642087e-03f, -1.09524041e-01f, 6.40404597e-02f, -3.61465253e-02f, -2.02467963e-02f, -3.04711573e-02f, -5.15011847e-02f, 2.24638451e-02f, -6.32681176e-02f, 8.25319532e-03f,
  5.99179417e-02f, 2.81179011e-01f, -5.36957867e-02f, -2.38836948e-02f, 1.15303621e-01f, 3.67409699e-02f, -6.62286505e-02f, 1.73768640e-01f, -1.15513813e-03f, 7.06373975e-02f,
  -2.93712914e-02f, 9.27876495e-03f, -2.01076120e-01f, 1.81953073e-01f, -1.76558837e-01f, -2.42310449e-01f, 2.10630625e-01f, -1.23912152e-02f, -3.86851467e-02f, 2.63159305e-01f,
  1.30104557e-01f, -6.60044774e-02f, 6.97886199e-02f, 2.23615661e-01f, 1.87059730e-01f, 1.30224809e-01f, -3.65561955e-02f, -1.17122456e-01f, 9.31688696e-02f, -5.63958921e-02f,
  1.78338081e-01f, 1.25738978e-01f, 1.10258192e-01f, 2.12360192e-02f, 1.71611831e-01f, 3.44931781e-02f, 1.01725273e-01f, -9.55616906e-02f, -6.20886646e-02f, -5.81053197e-02f,
  -5.16671464e-02f, -1.29757732e-01f, 5.91502786e-02f, -8.51290599e-02f, -6.13187999e-03f, -5.81965894e-02f, -2.64555439e-02f, 1.95546634e-02f, 7.08402395e-02f, 8.49112272e-02f,
  2.03600824e-02f, -6.56441748e-02f, 4.29636203e-02f, -3.55935954e-02f, -8.84361099e-03f, 4.83447826e-03f, 9.86749753e-02f, -5.55864200e-02f, -1.12851433e-01f, 4.84172478e-02f,
  -1.05694503e-01f, -1.64186824e-02f, 8.92941058e-02f, -7.15371221e-02f, -1.07687175e-01f, 1.18150823e-02f, 1.47303089e-01f, 7.94497952e-02f, 2.43723765e-03f, 3.87865491e-02f,
  -9.32634994e-02f, 6.29417598e-02f, -1.66788057e-03f, 1.70750227e-02f, 8.78144056e-02f, 1.16943665e-01f, -1.18898876e-01f, -6.75150454e-02f, 1.82725281e-01f, 6.85698017e-02f,
  -5.52932406e-03f, 2.05175430e-02f, 1.38985803e-02f, 2.29592174e-02f, 1.08334292e-02f, -1.19459167e-01f, -3.11306547e-02f, 2.68833190e-02f, 4.96639684e-02f, -1.08615458e-01f,
  1.32252336e-01f, 6.71270639e-02f, 1.24949180e-01f, 4.69156764e-02f, 3.92210223e-02f, -4.83711287e-02f, 6.50157705e-02f, 3.12065687e-02f, 3.43323238e-02f, -7.32797980e-02f,
  -1.98035277e-02f, 1.09441765e-01f, -9.19740051e-02f, -2.28625387e-02f, -1.36307269e-01f, 1.32736996e-01f, -1.62318069e-02f, -1.61962271e-01f, -3.29794548e-02f, -1.17212059e-02f,
  -1.16661198e-01f, -3.46911550e-02f, -9.63214040e-02f, 6.99315667e-02f, 7.31474720e-03f, 4.68099229e-02f, 4.10501361e-02f, 7.78045412e-03f, -1.69778034e-01f, 4.20249626e-03f,
  -1.96489796e-01f, -3.46717179e-01f, 1.47873983e-01f, -7.05275461e-02f, 4.64966595e-02f, 7.28220344e-02f, 6.53231665e-02f, -1.37307823e-01f, -4.34132032e-02f, -2.06834137e-01f,
  -2.74247816e-03f, -1.47357479e-01f, -1.45849865e-02f, -1.41742632e-01f, 9.95508209e-02f, 4.81433943e-02f, -2.12801263e-01f, -4.05468382e-02f, 9.82896462e-02f, -1.25293136e-01f,
  2.09221784e-02f, -1.38019294e-01f, 4.13033441e-02f, -4.99798805e-02f, -9.06861499e-02f, -3.20902020e-02f, -1.31911486e-01f, 1.78107575e-01f, -6.56041056e-02f, 1.59796737e-02f,
  -1.18637264e-01f, -6.49011210e-02f, -3.39742824e-02f, 5.52561991e-02f, -9.09676310e-03f, 5.39631508e-02f, 1.56618562e-02f, 1.07824966e-01f, 8.04145932e-02f, 3.06977052e-02f,
  6.19204938e-02f, -1.25978142e-02f, -4.43182401e-02f, -1.30820498e-02f, 3.84067148e-02f, 8.34683999e-02f, 5.73263131e-03f, -1.33181764e-02f, -5.39599881e-02f, 1.46827064e-02f,
  5.17726950e-02f, 9.45663080e-02f, 2.42233872e-02f, 4.26831730e-02f, 4.64335345e-02f, 3.48149948e-02f, 4.48282883e-02f, 2.34056097e-02f, 1.54785784e-02f, -7.54830521e-03f,
  6.05194420e-02f, -2.93112826e-02f, -1.95498243e-02f, 4.64434996e-02f, -1.67895146e-02f, 3.86165865e-02f, -2.84038913e-02f, 2.36875401e-03f, -5.51811941e-02f, -4.73014563e-02f,
  -1.84620061e-04f, -6.30930439e-02f, -5.35004884e-02f, -3.17153744e-02f, -2.89521702e-02f, -4.65981327e-02f, -3.69155291e-03f, 6.43933052e-03f, 1.06553044e-02f, 6.64620921e-02f,
  -9.72150639e-03f, 9.28018335e-03f, -8.85051116e-02f, -5.74546829e-02f, 8.36278424e-02f, 1.61911733e-02f, -8.67192075e-02f, 1.90894417e-02f, -1.68894827e-02f, 3.65086645e-02f,
  -2.66937762e-01f, -2.65092671e-01f, -1.30141862e-02f, -8.65627080e-03f, -1.14343278e-02f, 8.57606903e-02f, 7.59762526e-03f, -9.91341565e-03f, -1.84914991e-02f, -1.80931222e-02f,
  -4.22973419e-03f, -6.68288171e-02f, 8.23821872e-03f, -6.18199073e-02f, 7.81389773e-02f, -8.38025734e-02f, -4.88462336e-02f, -4.03155871e-02f, -1.04626179e-01f, -1.25315890e-01f,
  -7.20337732e-03f, 4.16956246e-02f, 1.32081181e-01f, 4.13329229e-02f, 5.63224964e-02f, -4.97670323e-02f, -7.82505237e-03f, 9.88190323e-02f, 7.15348795e-02f, -2.39033960e-02f,
  -3.34185570e-01f, -8.75802636e-02f, -1.23583756e-01f, -2.90136784e-01f, 8.96783173e-02f, 6.11375161e-02f, 8.55462253e-02f, -9.79845077e-02f, -2.46062934e-01f, -9.51547176e-02f,
  1.85338929e-01f, -9.01436806e-02f, 1.65158898e-01f, -2.94128861e-02f, -8.40168744e-02f, -2.60096733e-02f, -2.64656514e-01f, -1.10161088e-01f, -6.57509863e-02f, -1.29160166e-01f,
  -9.93752629e-02f, 9.15406197e-02f, -7.20063150e-02f, -1.87868774e-02f, -2.64840797e-02f, -1.85769409e-01f, 1.66851982e-01f, 2.11484373e-01f, 9.11337137e-02f, 2.71821674e-02f,
  4.23510298e-02f, -1.22199215e-01f, 3.81634906e-02f, -5.81198260e-02f, -1.05910271e-01f, -2.39279643e-02f, 7.37035507e-03f, 6.43647388e-02f, 5.06770685e-02f, 3.46358344e-02f,
  -7.97782764e-02f, 1.75854992e-02f, 6.36629108e-03f, -2.13361438e-02f, -1.08330861e-01f, 5.11305295e-02f, -7.97322094e-02f, 3.28474455e-02f, 3.08439806e-02f, -1.02037214e-01f,
  -2.06543375e-02f, -3.31708193e-02f, -7.04726353e-02f, -1.01615138e-01f, -3.52077372e-02f, -1.79724880e-02f, -7.82310590e-02f, 2.78899707e-02f, 7.82894716e-02f, -5.77835925e-02f,
  -1.07736483e-01f, 8.61489922e-02f, 3.63826454e-02f, 3.69357392e-02f, 2.25076135e-02f, 4.97329980e-02f, 1.28145413e-02f, -5.97024448e-02f, -5.68382144e-02f, 1.69166178e-02f,
  6.43087178e-02f, -4.41488959e-02f, 1.17421046e-01f, 5.87718980e-03f, -7.67854378e-02f, -8.42438713e-02f, 2.69033499e-02f, -3.12846228e-02f, -7.80272409e-02f, 2.48476397e-02f,
  1.52249373e-02f, 3.98397110e-02f, 1.44223526e-01f, 5.94950616e-02f, 1.02638617e-01f, -6.19848259e-02f, -1.09855402e-02f, -2.59921961e-02f, 8.58580396e-02f, 8.18561614e-02f,
  7.24741630e-03f, -2.01931581e-01f, 1.37420353e-02f, 2.89272033e-02f, -3.48592512e-02f, -1.40362931e-03f, -1.41026869e-01f, -9.69414562e-02f, -2.20394041e-02f, 3.06754988e-02f,
  -9.25106704e-02f, 3.49875912e-02f, 3.44199687e-02f, -2.27057375e-02f, -6.82748156e-03f, 3.51433977e-02f, -2.69492809e-02f, 1.08976148e-01f, -2.72393003e-02f, 6.24134624e-03f,
  6.07866459e-02f, 3.95453423e-02f, -7.88725689e-02f, -8.23375303e-03f, -7.06365258e-02f, -3.25468672e-03f, -7.50029162e-02f, -5.70497513e-02f, -3.81056145e-02f, 4.06238735e-02f,
  2.61142999e-01f, -6.74886778e-02f, -2.11555630e-01f, 1.93006635e-01f, 2.50072479e-01f, -1.19222566e-01f, -3.45117867e-01f, 1.35020837e-01f, 7.00525045e-02f, -2.64331877e-01f,
  1.23013914e-01f, -1.49300635e-01f, -1.89102739e-01f, 2.07081974e-01f, 1.21604159e-01f, -4.81735542e-02f, 6.60667866e-02f, -1.21055603e-01f, -2.14955844e-02f, 1.86903536e-01f,
  1.03331506e-01f, 2.68305272e-01f, 1.50852382e-01f, 5.17794304e-02f, 4.80943844e-02f, -3.98140810e-02f, 4.49098945e-02f, -1.50443479e-01f, 3.31824794e-02f, 2.58842465e-02f,
  9.93992239e-02f, 1.44549280e-01f, -7.92959630e-02f, -4.54454646e-02f, 5.70142940e-02f, -1.20669447e-01f, -9.32824463e-02f, -1.24393672e-01f, 6.31762594e-02f, 7.37662474e-03f,
  -1.50246486e-01f, 4.66415435e-02f, -6.78537134e-03f, -9.31492671e-02f, -1.09170787e-02f, -9.94856134e-02f, -5.35434149e-02f, -5.04903384e-02f, 2.26426441e-02f, -4.92691696e-02f,
  -1.17446445e-01f, -9.58999693e-02f, -5.91627657e-02f, -1.50385464e-03f, -1.45917907e-02f, -4.33791354e-02f, -4.38190661e-02f, -1.05581336e-01f, 9.60110873e-03f, -2.34472919e-02f,
  -1.39724659e-02f, 5.10924533e-02f, -3.79864052e-02f, 8.41654316e-02f, -5.01361154e-02f, -4.12250347e-02f, -2.53199413e-03f, -2.54986323e-02f, -1.00125946e-01f, 6.96368143e-02f,
  1.05282597e-01f, 1.51105253e-02f, 1.05848834e-01f, -9.62925032e-02f, -9.26045701e-02f, 7.07231602e-03f, -2.78470553e-02f, 5.00828885e-02f, 4.74470370e-02f, -6.24570698e-02f,
  -7.37439767e-02f, 2.76882835e-02f, 9.11708325e-02f, 7.50226676e-02f, -1.12304604e-02f, -7.85982311e-02f, 2.23759525e-02f, 5.45596480e-02f, 4.26991470e-02f, 1.50341690e-02f,
  1.59451455e-01f, 2.04215601e-01f, 4.51792218e-02f, 1.17400043e-01f, 1.96733475e-02f, -6.62263334e-02f, -5.96525520e-03f, 4.72997762e-02f, -7.89599046e-02f, 4.86165136e-02f,
  -7.20404238e-02f, 3.44752409e-02f, 1.02264062e-01f, 3.66593264e-02f, 1.13535617e-02f, 5.75318933e-02f, -1.14390580e-02f, 4.18528840e-02f, 2.33304147e-02f, 9.06175822e-02f,
  -3.40999477e-02f, 4.92855944e-02f, -1.24214180e-01f, 9.62050334e-02f, 3.42240706e-02f, 7.42795840e-02f, 7.00377822e-02f, -3.72066088e-02f, -1.06945500e-01f, -4.57881689e-02f,
  1.95194960e-01f, 5.37488461e-02f, -1.24336071e-01f, 1.05873369e-01f, 2.95144379e-01f, -8.96748602e-02f, -1.26724258e-01f, 8.61580521e-02f, -1.52014077e-01f, 3.96661051e-02f,
  6.84634894e-02f, 1.23727947e-01f, -1.26054466e-01f, 6.19078875e-02f, -2.29111210e-01f, -2.73811340e-01f, -1.85476676e-01f, 5.15417457e-02f, -3.15568857e-02f, 1.50334403e-01f,
  -2.52309628e-02f, 1.87622309e-01f, -6.49507418e-02f, 2.35983670e-01f, 2.62537807e-01f, 8.06956142e-02f, 1.87890649e-01f, 1.88616775e-02f, 2.40315184e-01f, -1.03842001e-02f,
  8.84642638e-03f, 6.28396496e-02f, -3.44506092e-02f, 1.43152038e-02f, 1.08912930e-01f, -1.16667738e-02f, 2.32768953e-02f, -3.23928371e-02f, 6.80922298e-03f, 1.70841776e-02f,
  5.67613505e-02f, 1.10418692e-01f, 6.92764670e-02f, -8.90695825e-02f, 1.15624815e-02f, 2.19433662e-02f, 5.00621237e-02f, -2.06131898e-02f, 8.96407664e-02f, -4.53639887e-02f,
  1.12218363e-02f, 7.09471256e-02f, -8.28787461e-02f, 8.11529830e-02f, 1.76280327e-02f, -8.06396678e-02f, -1.05513230e-01f, 3.86718921e-02f, 2.65781451e-02f, 2.03352813e-02f,
  -5.59957176e-02f, -5.90105802e-02f, 2.62395758e-02f, -9.86752007e-03f, -2.49924995e-02f, 1.05399176e-01f, -5.56063168e-02f, 4.83958758e-02f, -4.54217494e-02f, 9.39802304e-02f,
  1.20281018e-01f, 1.32746827e-02f, 3.24735157e-02f, -9.24753770e-02f, -5.61822578e-02f, -5.28463535e-02f, -4.94777262e-02f, 7.38957971e-02f, 2.42495928e-02f, 1.17775677e-02f,
  -3.90109536e-03f, -9.72614735e-02f, 1.64357554e-02f, -9.64915007e-03f, -4.46597114e-02f, 8.01458880e-02f, -3.30902301e-02f, -6.87185749e-02f, -1.79996826e-02f, 2.16689259e-02f,
  1.04386628e-01f, 5.73453940e-02f, 1.52411405e-02f, 2.76843179e-02f, -1.23931449e-02f, -1.56503692e-02f, -1.42773300e-01f, 1.17422920e-02f, 1.70353074e-02f, -3.75038013e-02f,
  2.51833610e-02f, -2.62317974e-02f, 1.09506950e-01f, -6.49951696e-02f, -1.35616967e-02f, -9.92700011e-02f, 2.34112926e-02f, 4.43716384e-02f, 7.84303818e-04f, 2.43932847e-02f,
  1.32765651e-01f, 1.19329043e-01f, 5.71324266e-02f, 1.27007470e-01f, 2.25691982e-02f, 4.74487878e-02f, 4.35643643e-02f, -5.30244969e-02f, 4.50240560e-02f, -7.45430961e-03f,
  -1.08291134e-01f, 9.00987089e-02f, 1.43212103e-03f, -1.26089364e-01f, -6.56117946e-02f, -1.78734630e-01f, -1.64649859e-01f, -5.83828129e-02f, 9.62997377e-02f, 9.14321840e-02f,
  -9.82569903e-02f, -7.33109843e-03f, 8.14087838e-02f, 6.11921679e-03f, -2.28908777e-01f, 1.28460586e-01f, -2.38508731e-02f, -4.11692001e-02f, 1.68632969e-01f, -1.96462143e-02f,
  -4.33657058e-02f, -3.60924564e-02f, -1.21578626e-01f, 6.55926019e-02f, -9.85742956e-02f, 3.72879170e-02f, -1.67660177e-01f, -4.75902744e-02f, -1.03955857e-01f, -1.43681601e-01f,
  -2.17085276e-02f, -1.64639745e-02f, 1.19122401e-01f, 5.17784320e-02f, -3.94846201e-02f, 7.77304992e-02f, -8.58439356e-02f, 7.31858090e-02f, 2.74183098e-02f, -9.69900284e-04f,
  4.64002229e-02f, 4.53157816e-03f, 2.87785400e-02f, 1.22429460e-01f, 1.52925737e-02f, -1.55159030e-02f, 1.55476583e-02f, -3.59361846e-04f, 2.62573687e-03f, -3.68413068e-02f,
  2.56240591e-02f, -2.93061826e-02f, -2.16834117e-02f, -6.96299747e-02f, -1.18736498e-01f, -1.54768806e-02f, 5.95839880e-02f, -2.23248862e-02f, -2.20560551e-01f, -5.39686568e-02f,
  1.92460734e-02f, 7.35527202e-02f, 4.42862548e-02f, -1.04011018e-02f, -6.19131722e-04f, -4.75200415e-02f, 3.56809981e-02f, 7.32096508e-02f, 4.25061733e-02f, -7.62423053e-02f,
  -3.17666493e-02f, 8.36556870e-03f, -3.05805635e-02f, 1.24757543e-01f, 8.88919234e-02f, 6.37896508e-02f, -3.94320525e-02f, -3.86185534e-02f, 1.61881279e-02f, -1.25521105e-02f,
  3.03196851e-02f, 7.79872434e-03f, -8.46540108e-02f, -1.54560888e-02f, -6.74991384e-02f, -1.10254427e-02f, 1.04274146e-01f, -7.16933161e-02f, -1.05395630e-01f, -1.37873694e-01f,
  -2.11842224e-01f, -2.59354830e-01f, -2.34726034e-02f, -9.10168216e-02f, -4.11163121e-02f, 7.47305304e-02f, 1.38846323e-01f, 4.64613773e-02f, -1.11083992e-01f, 3.05369552e-02f,
  1.07966714e-01f, -6.00423962e-02f, -1.07225761e-01f, 5.26318909e-04f, -3.27707715e-02f, -8.68641958e-02f, 1.55508127e-02f, -1.00558862e-01f, -1.17991425e-01f, -5.98365292e-02f,
  -4.31278311e-02f, -2.61540357e-02f, 5.52533604e-02f, -6.86130300e-02f, 2.82227341e-02f, -1.09071732e-01f, -1.86371207e-02f, 2.59394478e-02f, -2.72975024e-03f, 3.80127952e-02f,
  3.41809243e-01f, 1.44460291e-01f, 1.23643905e-01f, 6.20041229e-03f, -5.36960997e-02f, 1.13877788e-01f, 2.35814109e-01f, -1.02373011e-01f, 6.81332685e-03f, 1.13044620e-01f,
  -1.49980441e-01f, 3.96163523e-01f, -1.34676462e-02f, 9.28908810e-02f, 1.73920408e-01f, -3.29483822e-02f, 1.69950143e-01f, 1.88070759e-01f, 1.70683935e-01f, 1.61359891e-01f,
  -1.12288874e-02f, -3.49363908e-02f, -1.49206221e-01f, -6.08686619e-02f, 6.17609918e-03f, 2.12507062e-02f, -2.17382818e-01f, -8.78831446e-02f, -7.60384127e-02f, -2.38717976e-03f,
  -1.19735245e-02f, 7.78730437e-02f, 1.55362180e-02f, -1.84493717e-02f, -2.69551706e-02f, 9.58621129e-02f, 4.50011529e-02f, 1.05800919e-01f, -2.14238483e-02f, -2.59033870e-02f,
  1.53295159e-01f, 1.77049637e-02f, 2.45784107e-03f, -1.28237326e-02f, 1.87369324e-02f, -5.81820421e-02f, 3.32523659e-02f, -1.24296211e-01f, 2.80927885e-02f, -1.28784822e-02f,
  -1.36388140e-02f, 2.52180602e-02f, 2.63384786e-02f, -9.94381029e-03f, -7.59659661e-03f, 6.46838620e-02f, 4.79669422e-02f, 6.48694411e-02f, -1.14289504e-02f, 3.02212462e-02f,
  6.13095574e-02f, -5.80611937e-02f, -4.94637750e-02f, -4.91737537e-02f, 5.75421825e-02f, 1.15263613e-03f, 2.55758315e-02f, 1.11462675e-01f, 2.31671669e-02f, 6.71660304e-02f,
  -1.88437719e-02f, 9.14831534e-02f, -4.90536727e-02f, 8.95702541e-02f, 8.68794546e-02f, -1.79044772e-02f, 6.25582114e-02f, 4.19079401e-02f, -1.10832460e-01f, -9.36084054e-03f,
  3.39553021e-02f, -6.18489720e-02f, -4.38182242e-02f, -1.09798744e-01f, -6.82141166e-03f, 5.63200042e-02f, -1.99171659e-02f, -1.12235755e-01f, -5.22476025e-02f, -1.90371256e-02f,
  5.59799410e-02f, 1.45567298e-01f, -6.05124868e-02f, -4.76704873e-02f, 2.91959308e-02f, 1.06397100e-01f, 7.65748397e-02f, 2.26443391e-02f, 1.66761950e-02f, 3.65242101e-02f,
  7.98444226e-02f, -7.16833770e-02f, -1.16132334e-01f, -6.49360269e-02f, -1.38919875e-01f, -4.34519164e-02f, 8.50097686e-02f, -9.87374857e-02f, 2.94868951e-03f, -2.59645144e-03f,
  -2.49815341e-02f, 3.75537500e-02f, 4.77546453e-02f, -1.05973937e-01f, -1.04306787e-02f, 2.50257738e-02f, 3.55271921e-02f, -1.02022983e-01f, -2.35330313e-02f, -7.65217515e-03f,
  -8.26750770e-02f, 1.44785106e-01f, 2.22880214e-01f, 1.45710543e-01f, -6.82144673e-05f, 3.41730118e-02f, -3.48422751e-02f, 1.77282989e-01f, 2.71727949e-01f, -9.87013802e-02f,
  2.70231813e-02f, -2.10251063e-01f, -1.03294067e-02f, 1.38810784e-01f, 1.74120138e-03f, 1.84026927e-01f, 1.51293665e-01f, 3.69598381e-02f, 2.16434062e-01f, -4.03015204e-02f,
  1.03754736e-01f, -9.38164964e-02f, 1.11236900e-01f, 5.56193152e-03f, -5.37941121e-02f, 7.73934796e-02f, -2.63893664e-01f, 4.59776772e-03f, -1.55418172e-01f, -2.84873210e-02f,
  -4.11796682e-02f, 1.52075633e-01f, 1.94648262e-02f, 5.75740896e-02f, -3.57216522e-02f, -3.72562069e-03f, -4.23483439e-02f, 2.30835583e-02f, 1.06017798e-01f, 6.05902262e-03f,
  -9.95566975e-03f, -4.90416884e-02f, -4.25562710e-02f, -1.56414136e-02f, 8.05509686e-02f, 6.16536550e-02f, 8.15423653e-02f, 1.05249099e-01f, 3.21717709e-02f, 5.61246537e-02f,
  7.53126442e-02f, 6.95722923e-02f, 6.39467090e-02f, 7.99226388e-02f, -3.73999076e-03f, 6.87154159e-02f, 2.43047569e-02f, -1.57317936e-01f, -1.29213214e-01f, 3.03999940e-03f,
  6.10799305e-02f, -1.72027647e-02f, -1.26650799e-02f, 2.56430916e-03f, -3.64107527e-02f, 1.06589496e-02f, 1.67774130e-03f, 2.71435268e-03f, 1.63953926e-03f, -1.01909988e-01f,
  -1.21429905e-01f, -2.95208190e-02f, -5.73170446e-02f, 4.33347560e-02f, -1.13728903e-02f, -5.13294190e-02f, -4.55054753e-02f, -7.27452636e-02f, -8.81321430e-02f, -3.92279439e-02f,
  1.03184842e-01f, 4.08416288e-03f, -5.10350913e-02f, -6.37622848e-02f, 6.44195871e-03f, 6.30825711e-03f, 7.99135789e-02f, 9.47193354e-02f, -1.79217185e-03f, -1.49550661e-01f,
  -2.11859807e-01f, -1.58302918e-01f, 2.34007533e-03f, -3.89621481e-02f, 3.08270641e-02f, -9.31909401e-03f, 6.56457320e-02f, 6.76240027e-03f, 4.87944447e-02f, 1.87077292e-03f,
  5.16475514e-02f, -8.83571990e-03f, -1.35582089e-01f, 1.43163861e-03f, 6.35768101e-03f, -4.58649509e-02f, 9.55230836e-03f, -4.80452180e-02f, -2.05282226e-01f, -6.39194548e-02f,
  6.25707209e-02f, -6.93405792e-02f, 9.99275669e-02f, -4.53055613e-02f, -4.81434986e-02f, -7.86325708e-02f, -2.98033208e-02f, 3.09094228e-02f, -4.65051904e-02f, -1.06582046e-01f,
  1.30275695e-03f, 1.12115391e-01f, 2.63051122e-01f, 3.71852778e-02f, -1.85912296e-01f, -3.56744260e-01f, -1.32291377e-01f, -1.97639212e-01f, -1.76771745e-01f, -8.06230232e-02f,
  -8.90833810e-02f, 8.15870091e-02f, 7.30230585e-02f, -1.36109725e-01f, -2.93586880e-01f, 3.81192528e-02f, -3.27405304e-01f, -1.54228136e-01f, 1.46685448e-02f, -5.53295910e-02f,
  -4.51863669e-02f, -2.52973676e-01f, 1.07587740e-01f, -1.22600324e-01f, -5.44096455e-02f, 1.42767755e-02f, 6.74865544e-02f, 1.50895298e-01f, -1.35879144e-01f, -3.15986164e-02f,
  4.82310764e-02f, 2.71012671e-02f, 7.33304992e-02f, 5.80068454e-02f, 7.07556540e-03f, 6.81365654e-02f, 1.75747246e-01f, 1.09051965e-01f, -1.98363811e-02f, -7.28506967e-03f,
  3.05236429e-02f, 8.10389034e-03f, -1.79155376e-02f, -1.34189039e-01f, 5.26021759e-04f, -2.37601083e-02f, -4.52732947e-03f, -5.65838590e-02f, -6.28056824e-02f, 1.17208883e-01f,
  3.81943546e-02f, 6.05629897e-03f, -2.87173390e-02f, 5.30919759e-04f, -4.06433195e-02f, -4.51559611e-02f, 7.98716918e-02f, 7.88957328e-02f, -5.44066727e-02f, -2.63177007e-02f,
  9.56128258e-03f, 3.78380157e-02f, 5.16096279e-02f, -2.18744185e-02f, -3.22043560e-02f, 1.00597881e-01f, -3.88101414e-02f, 6.30597919e-02f, 4.84667495e-02f, -3.18703614e-03f,
  -4.99128774e-02f, 2.37504132e-02f, -8.70848820e-02f, -1.03552163e-01f, -1.08997494e-01f, 5.26063889e-03f, 5.62774390e-02f, 3.07304394e-02f, -2.98604649e-03f, 3.33046317e-02f,
  5.17782010e-02f, -6.78167911e-03f, 2.04850826e-02f, 3.48847844e-02f, 3.73418257e-02f, -8.84726569e-02f, 3.16883698e-02f, 2.05929000e-02f, -4.44043018e-02f, -4.68586106e-03f,
  -1.65119946e-01f, -1.72497019e-01f, -2.61120801e-03f, -2.23077484e-03f, 1.49267346e-01f, 2.01710891e-02f, 1.12300508e-01f, -7.68185221e-03f, -4.70325276e-02f, -1.06516436e-01f,
  -3.91934179e-02f, 1.98609103e-02f, -5.59220649e-02f, -1.65628102e-02f, -1.12925246e-01f, 2.67396457e-02f, -1.64315775e-02f, -1.51504157e-02f, -9.32850689e-02f, -1.85282584e-02f,
  -6.98040426e-03f, -4.86451872e-02f, 5.73486425e-02f, -2.65770666e-02f, -4.58771400e-02f, -3.15879844e-02f, -9.06797051e-02f, 7.36935213e-02f, 4.91890348e-02f, 5.37567660e-02f,
  1.31009609e-01f, 3.63474898e-02f, 6.87059686e-02f, 1.48632586e-01f, -2.93100718e-02f, -1.72236972e-02f, 2.31287062e-01f, 1.41677111e-02f, 1.99737504e-01f, -8.07754174e-02f,
  -4.64140587e-02f, 1.22024968e-01f, 1.93106696e-01f, -1.83784708e-01f, -9.31359362e-03f, 1.78691372e-01f, -1.97365582e-02f, 7.87826255e-02f, 1.21578143e-03f, -1.45805138e-03f,
  -1.07999081e-02f, -1.73836961e-01f, 3.82902101e-02f, -1.08111851e-01f, -1.31542787e-01f, -1.07202478e-01f, -1.47403866e-01f, -1.11010768e-01f, -2.49722347e-01f, -1.61659531e-02f,
  -1.98567212e-01f, 3.52796949e-02f, -8.25753063e-03f, -1.10785566e-01f, -3.74640748e-02f, -2.17362843e-03f, -1.20555749e-02f, -1.55686364e-02f, -2.91218348e-02f, 3.54968123e-02f,
  1.25363976e-01f, -1.01587430e-01f, -6.92360103e-02f, 4.17054445e-02f, 4.67848629e-02f, -8.17585364e-02f, 2.52953954e-02f, 5.64199015e-02f, 7.26977363e-02f, 1.02888756e-01f,
  6.28060624e-02f, -7.01545477e-02f, 2.14009266e-02f, 6.16431348e-02f, 6.60475343e-02f, 4.09248918e-02f, -2.43730191e-02f, 5.97623736e-02f, -1.21986559e-02f, -3.99559177e-02f,
  4.37736511e-02f, -4.67975959e-02f, -3.08401790e-02f, -1.00347452e-01f, -1.85918752e-02f, -1.71280757e-01f, -7.04137161e-02f, -2.69500595e-02f, 5.96143790e-02f, -7.66954273e-02f,
  -1.14885598e-01f, -1.58898961e-02f, -4.28453162e-02f, -5.78303775e-03f, 3.61532010e-02f, 6.20745346e-02f, 4.38901456e-03f, -1.36714071e-01f, -1.16963930e-01f, -5.77138886e-02f,
  -5.58770262e-02f, -8.46920609e-02f, -1.06096283e-01f, 6.94696680e-02f, -3.30860056e-02f, 5.44568338e-02f, -1.59910712e-02f, -2.23693624e-02f, -4.01217155e-02f, 6.13032728e-02f,
  -1.96204022e-01f, -6.87221065e-02f, -9.80724674e-03f, -8.68139490e-02f, -5.60399704e-02f, -1.07569089e-02f, -2.93299109e-02f, -2.89558619e-02f, -4.09845932e-04f, 8.26801434e-02f,
  2.03837693e-01f, -4.41721119e-02f, -1.14274897e-01f, -9.48105603e-02f, 1.43853361e-02f, -8.15792941e-03f, 4.63760234e-02f, -7.18753934e-02f, 5.65461330e-02f, -2.90192291e-02f,
  -3.60431038e-02f, -9.59769338e-02f, 5.59976920e-02f, 2.24891696e-02f, 3.05248126e-02f, 6.42980859e-02f, -7.75678158e-02f, 1.01844132e-01f, -5.05336979e-03f, -7.18199909e-02f,
  -2.17893928e-01f, 1.51123464e-01f, 1.90334737e-01f, 7.55976066e-02f, -2.13189021e-01f, 4.08207178e-02f, 1.52575955e-01f, 2.06355937e-02f, -1.47508085e-01f, 7.21066222e-02f,
  9.37523767e-02f, 1.85825061e-02f, 4.84400243e-02f, 1.28292888e-01f, 6.42967522e-02f, -1.42336842e-02f, 8.57845545e-02f, 7.46488795e-02f, -2.15568751e-01f, 6.60263151e-02f,
  3.26196514e-02f, 4.89646494e-02f, 2.48730943e-01f, -2.22489592e-02f, 8.17767307e-02f, -3.76253203e-02f, 1.79649815e-01f, 4.38944660e-02f, 4.78627719e-02f, 5.69382161e-02f,
  -9.65428427e-02f, -1.00823261e-01f, 4.47615087e-02f, 4.63184007e-02f, 1.05669044e-01f, 3.06367595e-02f, 1.47351250e-01f, -3.16023105e-03f, -7.77784809e-02f, 1.15587063e-01f,
  -6.02564216e-02f, -8.16595629e-02f, -5.03182486e-02f, -5.01478575e-02f, -1.45508841e-01f, -2.91768983e-02f, -1.11456506e-01f, 8.00444856e-02f, 9.38723609e-02f, -5.35538197e-02f,
  -8.11228703e-04f, 1.23410940e-01f, 1.65716447e-02f, 8.05930942e-02f, -4.51832786e-02f, -4.62877005e-02f, 3.77800805e-03f, -4.24814178e-03f, 3.81060094e-02f, 1.36841834e-01f,
  -1.32821634e-01f, 5.58470190e-02f, -1.20441407e-01f, -5.12088090e-02f, -6.72040880e-02f, -1.12858033e-02f, -9.31570530e-02f, -1.22950852e-01f, 7.10885925e-03f, 4.31900173e-02f,
  1.40687954e-02f, -1.13623895e-01f, -4.04183269e-02f, 1.83599256e-02f, -1.05572477e-01f, 8.18008855e-02f, -1.24271670e-02f, 1.09190650e-01f, 6.03582850e-03f, -3.87049951e-02f,
  -2.50763502e-02f, 6.00012541e-02f, 3.10726259e-02f, 5.56912944e-02f, -1.10072279e-02f, 3.00265457e-02f, 1.34102330e-01f, 8.13933387e-02f, 5.53597808e-02f, 7.71119148e-02f,
  1.03609376e-01f, 2.45394111e-01f, 6.60001487e-02f, 2.05697529e-02f, 4.59412672e-02f, 1.43006276e-02f, 9.11233425e-02f, -4.96032201e-02f, -6.13802150e-02f, 1.62352607e-01f,
  2.01097429e-02f, 6.60590455e-02f, 5.44475801e-02f, 9.41189378e-02f, 2.91308295e-03f, 4.95628603e-02f, -4.59405407e-02f, 8.69239792e-02f, 2.34508440e-01f, 5.31291477e-02f,
  8.26577395e-02f, -6.74130488e-03f, 4.41706507e-03f, -1.53700002e-02f, 3.70023064e-02f, 1.12163574e-01f, -5.18684834e-02f, -2.12193485e-02f, -5.18407971e-02f, 1.26138777e-01f,
  2.07866933e-02f, 2.83940256e-01f, 1.27083790e-02f, -2.67846048e-01f, -7.26124132e-03f, -1.93211868e-01f, -2.01026514e-01f, 1.82905316e-01f, -1.09685235e-01f, -3.72769535e-02f,
  -3.25543553e-01f, -8.00241306e-02f, 3.17661017e-02f, -3.43002558e-01f, -2.73973256e-01f, -1.10735282e-01f, -3.48176569e-01f, -3.06278706e-01f, 5.74488379e-02f, 3.43113526e-04f,
  -3.84324044e-02f, -1.25487044e-01f, 5.04947603e-02f, 3.14658701e-01f, -4.97219944e-03f, 2.50366300e-01f, 1.09287292e-01f, 2.32396528e-01f, -1.03606984e-01f, -4.53835726e-02f,
  9.32206884e-02f, 9.57939960e-03f, 6.12894520e-02f, 1.24399096e-01f, -3.78492884e-02f, 4.97350171e-02f, 5.88116832e-02f, 2.47158892e-02f, 8.09104741e-03f, 7.25931302e-02f,
  -7.52545074e-02f, 4.88795377e-02f, 1.12707550e-02f, -5.67130707e-02f, -2.83909999e-02f, 3.31885405e-02f, -7.84991905e-02f, 2.36626230e-02f, 6.95113242e-02f, -6.94484711e-02f,
  -1.10473372e-01f, -8.03583935e-02f, -1.19099356e-01f, -5.16785719e-02f, -5.83453625e-02f, -1.27406985e-01f, 6.64991438e-02f, -2.67446991e-02f, -2.05286406e-02f, -1.91104319e-02f,
  -3.12040076e-02f, 1.05857119e-01f, 1.74869746e-02f, 7.40186423e-02f, 5.76921739e-02f, 2.71806922e-02f, -7.52540752e-02f, -3.50505486e-02f, 2.89419461e-02f, 6.68531656e-02f,
  -8.48015398e-02f, -5.86070307e-03f, -1.50178093e-02f, -1.97768249e-02f, -6.06213883e-02f, 8.48771483e-02f, 6.09138682e-02f, 3.16013768e-02f, -6.77813068e-02f, 6.84293499e-03f,
  7.61913061e-02f, 4.19783741e-02f, 9.72625017e-02f, 3.38828750e-02f, 1.86360907e-02f, -7.69971088e-02f, 2.75967419e-02f, 7.38053620e-02f, 8.78240466e-02f, -3.81549187e-02f,
  1.39604285e-01f, 1.79447591e-01f, 6.08448125e-02f, 5.68708144e-02f, 4.34074458e-03f, -4.17700931e-02f, 1.36932265e-02f, -2.85530426e-02f, 7.07032606e-02f, 8.20519328e-02f,
  -3.85387763e-02f, 3.15801911e-02f, 3.03288344e-02f, 6.45270990e-03f, -9.26017985e-02f, 5.25777899e-02f, -6.68939352e-02f, 4.22813408e-02f, 3.25700326e-04f, 1.10312998e-01f,
  1.83251838e-03f, -4.11002971e-02f, -6.39339462e-02f, 9.17477161e-02f, -6.43063635e-02f, -8.96098614e-02f, 6.44458085e-02f, -4.01122980e-02f, -6.92390203e-02f, -2.01533139e-02f,
  2.48859793e-01f, 5.58427162e-03f, 3.02336961e-01f, 2.40836918e-01f, 1.15992919e-01f, -1.31863371e-01f, -1.19894676e-01f, 4.54159081e-02f, 1.66822761e-01f, -2.26253003e-01f,
  -1.72502324e-01f, 1.38531119e-01f, -2.89316356e-01f, 1.16868004e-01f, 2.62407660e-01f, -1.02280229e-01f, 1.13470154e-02f, -7.12976009e-02f, 7.89460465e-02f, -9.09688622e-02f,
  1.34419367e-01f, -1.50388837e-01f, 1.04521431e-01f, 1.66791771e-02f, 1.68356061e-01f, 2.70695329e-01f, 7.64416680e-02f, 1.41662359e-01f, 1.01816535e-01f, 9.66394544e-02f,
  -7.47395456e-02f, -9.74962302e-03f, 9.09439996e-02f, 2.12673005e-02f, -1.11294314e-02f, -4.44950089e-02f, -6.92942739e-02f, -3.79062071e-02f, 5.91839030e-02f, -2.19646469e-02f,
  -7.43575543e-02f, -2.36864444e-02f, 8.21904466e-02f, -1.70298293e-02f, -2.41147284e-03f, 5.13793118e-02f, 5.26167527e-02f, -4.06551659e-02f, -2.04423312e-02f, 5.63250631e-02f,
  8.70440975e-02f, 2.16120966e-02f, 7.96894282e-02f, -5.61033599e-02f, 2.80164294e-02f, 7.87896141e-02f, 3.86144295e-02f, 9.62647516e-03f, 2.00305581e-02f, 2.27672029e-02f,
  -3.60994227e-02f, 7.71544501e-02f, 1.58057958e-01f, 4.13878523e-02f, 2.97058094e-02f, 4.36135009e-02f, -2.26406078e-03f, -1.08065747e-03f, 8.45910907e-02f, -6.20349608e-02f,
  -6.01900965e-02f, 2.00654641e-02f, -6.90392330e-02f, -2.64901813e-04f, -1.09141648e-01f, 2.01338306e-02f, -6.54716715e-02f, -7.56042302e-02f, -4.83223572e-02f, 1.00637205e-01f,
  3.58660892e-02f, 2.50033364e-02f, 1.10306945e-02f, -5.46631441e-02f, 2.43302621e-02f, 2.76271701e-02f, -4.93230447e-02f, -2.55738050e-02f, 9.04417410e-02f, -1.71177953e-01f,
  -1.37455121e-01f, -6.20463230e-02f, -2.14505661e-02f, -1.20646879e-01f, -4.35907990e-02f, -6.77605346e-02f, 4.04982045e-02f, 5.35183474e-02f, -7.20056519e-02f, -1.13126837e-01f,
  -5.96515536e-02f, 1.09204277e-02f, -9.02478844e-02f, -2.08976846e-02f, -6.13587908e-02f, 4.18145582e-02f, -1.05747497e-02f, -1.04983553e-01f, -1.06349260e-01f, -2.97257174e-02f,
  -2.52402108e-02f, -2.59232093e-02f, 5.68243451e-02f, -1.09483153e-02f, -4.99649793e-02f, -5.97024709e-02f, 7.52974004e-02f, 4.01011780e-02f, 1.37953619e-02f, -1.09781876e-01f,
  3.26089621e-01f, -4.18021008e-02f, -1.63220502e-02f, 1.96422517e-01f, 1.53655723e-01f, -8.93000141e-02f, -6.72086254e-02f, 1.41353995e-01f, 2.53940821e-01f, -1.00843906e-01f,
  -2.26821303e-02f, 2.27671430e-01f, -1.78622782e-01f, 1.82334214e-01f, -7.37195835e-02f, -1.04552910e-01f, 1.05780467e-01f, 9.73918736e-02f, 1.76043004e-01f, 1.11060455e-01f,
  7.17353672e-02f, 1.22967087e-01f, -1.04432650e-01f, 1.49146661e-01f, 9.39349830e-02f, 1.26622319e-01f, -1.94568083e-01f, -2.59991698e-02f, 6.87507987e-02f, 4.13978584e-02f,
  -6.34641349e-02f, 1.77087292e-01f, 1.42709550e-03f, 6.47597527e-03f, 1.13574713e-02f, -9.40498784e-02f, -1.26545817e-01f, -3.43837552e-02f, 1.18525520e-01f, 7.52136707e-02f,
  5.88850304e-02f, 6.62506139e-03f, 1.48350373e-01f, 1.01758495e-01f, 9.65442217e-04f, 2.56131217e-02f, 4.26647030e-02f, 9.76338051e-03f, 1.04580894e-01f, -1.20679243e-03f,
  3.56925614e-02f, -3.58698331e-02f, -1.69962533e-02f, 5.89740314e-02f, -8.73904601e-02f, 9.12470743e-02f, -1.18906356e-01f, -7.87404105e-02f, -3.43553089e-02f, 6.96209967e-02f,
  8.27375054e-02f, -2.39070281e-02f, 2.92368662e-02f, -1.24969743e-02f, 2.37410013e-02f, -9.31606535e-03f, -3.71559821e-02f, -3.85096632e-02f, -2.23828629e-02f, -6.78340793e-02f,
  1.42074469e-03f, -3.40191312e-02f, 5.30072339e-02f, 2.57448424e-02f, 5.51170968e-02f, -7.96811562e-03f, -4.31168489e-02f, 5.90012558e-02f, -4.70389985e-02f, -8.17462336e-03f,
  6.83767349e-02f, -7.93498605e-02f, -4.98235822e-02f, -1.26036808e-01f, -3.06781251e-02f, 2.85331942e-02f, -4.09706458e-02f, 4.74600829e-02f, -2.90496293e-02f, -3.98212373e-02f,
  -1.44409865e-01f, 4.90386933e-02f, -2.31398884e-02f, 8.99733568e-04f, -1.11171538e-02f, 1.55685311e-02f, -9.27216653e-03f, 1.06566995e-02f, 7.74261281e-02f, 1.02978192e-01f,
  7.91451111e-02f, -4.71784398e-02f, -3.30595821e-02f, -5.68492897e-02f, -1.06488846e-01f, -7.90208653e-02f, 3.74117829e-02f, -4.57151122e-02f, 1.43821826e-02f, 5.36799170e-02f,
  5.49877994e-02f, 1.09056741e-01f, 4.22614738e-02f, -4.10674997e-02f, -6.89366162e-02f, 2.48580892e-02f, 1.12841465e-01f, -3.72594334e-02f, -1.23136779e-02f, -1.26057073e-01f,
  -1.84469223e-01f, 2.27351010e-01f, 1.80865988e-01f, -9.09794420e-02f, -2.23924771e-01f, -1.00796418e-02f, -8.51120858e-05f, -1.19548678e-01f, 1.93688706e-01f, 8.52663070e-02f,
  -7.30499104e-02f, 6.57330155e-02f, 1.37794405e-01f, -1.16296038e-01f, -2.88293600e-01f, 2.26863965e-01f, -1.31344860e-02f, 7.23435059e-02f, 1.73936009e-01f, -8.27084407e-02f,
  -2.27297395e-02f, -3.34265649e-01f, -1.97616536e-02f, -2.09662661e-01f, -2.53892928e-01f, -2.48774365e-02f, -2.97219157e-01f, 5.98945394e-02f, -1.73515201e-01f, -6.09593950e-02f,
  7.55729154e-02f, 3.27740610e-02f, -2.09639315e-02f, 4.91597988e-02f, -6.03757799e-02f, -5.91592602e-02f, -2.66228281e-02f, -1.29438892e-01f, 1.11596882e-01f, 7.29094818e-02f,
  -1.00136481e-01f, -5.89912422e-02f, -2.04255003e-02f, -7.72117451e-02f, 1.43405860e-02f, -4.54044603e-02f, -1.63744707e-02f, 4.35199738e-02f, 2.01767180e-02f, -1.20464945e-02f,
  6.48101000e-03f, 4.05765362e-02f, -4.14281264e-02f, -2.54592542e-02f, 1.97719205e-02f, 8.33105296e-02f, 7.01778084e-02f, -1.94019079e-02f, -7.45437816e-02f, 2.09115893e-02f,
  -9.47801620e-02f, 1.59120679e-01f, -1.49978148e-02f, 5.53799272e-02f, -2.47843261e-03f, -6.27377853e-02f, 5.53392507e-02f, -1.45186737e-01f, 6.18509054e-02f, 7.00167287e-03f,
  7.15002324e-03f, 6.55593947e-02f, 3.00002061e-02f, -4.40164469e-02f, -2.95023751e-02f, -5.42119611e-03f, -2.83548385e-02f, -2.64119133e-02f, -3.75069976e-02f, -3.24062593e-02f,
  -6.02864660e-02f, 5.10950424e-02f, 1.28349617e-01f, 3.89241353e-02f, 7.63814673e-02f, -6.27554860e-03f, -1.83668677e-02f, -5.07896533e-04f, 6.21293597e-02f, -8.81465152e-02f,
  7.13406950e-02f, -4.35464457e-03f, 1.48512758e-02f, 6.20034710e-02f, 5.79008162e-02f, -9.14571062e-02f, 4.00560023e-03f, -9.76009443e-02f, -8.85991938e-03f, -9.18935984e-02f,
  -9.24948677e-02f, -4.07614885e-03f, 8.98087695e-02f, -6.01475388e-02f, -1.00902580e-02f, 3.64622101e-02f, 4.84845527e-02f, 5.51964268e-02f, -1.10863313e-01f, 3.34860198e-02f,
  -1.12916030e-01f, -3.15648280e-02f, -1.02862939e-01f, -8.89563188e-02f, -8.16809833e-02f, 1.81945898e-02f, -9.89939570e-02f, 5.01088984e-02f, -1.54418707e-01f, 6.15667924e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.97956991e-02f, 3.49071503e-01f, -7.63584897e-02f, 1.27154917e-01f, 1.33625656e-01f, 4.73958105e-01f, 3.11804444e-01f, 2.09958240e-01f, 2.64702678e-01f, 1.09471783e-01f,
  -9.90900993e-02f, 1.13523774e-01f, -1.50867961e-02f, 9.91934389e-02f, 3.52982059e-02f, 1.18931182e-01f, 2.49274120e-01f, 1.62220269e-01f, 1.89843744e-01f, -6.61384016e-02f,
  2.98183449e-02f, 9.80578214e-02f, -2.76545793e-01f, -4.86040749e-02f, -1.03442311e-01f, -9.70033556e-02f, -3.43385518e-01f, -2.16352299e-01f, -9.72455367e-02f, 1.02987066e-01f,
  3.92920524e-02f, 1.16825148e-01f, -3.39911468e-02f, -3.06996554e-02f, -4.79765870e-02f, 7.06372708e-02f, -1.50812594e-02f, 6.19453564e-03f, -1.30768865e-01f, 4.52675344e-03f,
  4.03383486e-02f, -1.66906938e-02f, 1.81835219e-02f, -6.10137824e-03f, 2.46712100e-02f, -4.86329868e-02f, 2.00186186e-02f, -6.06267005e-02f, 5.14495037e-02f, 5.01232408e-02f,
  -6.96218237e-02f, -8.09654370e-02f, -2.66218539e-02f, 2.59946045e-02f, 8.59916862e-03f, 3.29855382e-02f, 1.01453997e-01f, 1.10360691e-02f, -8.30009952e-02f, 1.57390416e-01f,
  -3.79761942e-02f, 9.08179954e-02f, 4.76364195e-02f, -8.73773694e-02f, 9.97062698e-02f, 2.66177077e-02f, -7.76813328e-02f, 3.67722698e-02f, 4.69195470e-02f, -7.07383975e-02f,
  -3.81389968e-02f, 2.81078760e-02f, 4.55659069e-02f, -3.10968570e-02f, 1.25657707e-01f, 1.33396881e-02f, -4.27460410e-02f, -2.66882032e-02f, -4.13844222e-03f, -7.12724924e-02f,
  -4.68240604e-02f, -2.56028585e-02f, -7.87478611e-02f, -4.72669154e-02f, -5.89960515e-02f, -2.13883799e-02f, 7.79621527e-02f, -8.31355974e-02f, -1.15315795e-01f, 2.77252086e-02f,
  1.48566052e-01f, 4.03102815e-01f, 2.21943296e-02f, -8.55410099e-03f, -3.68866920e-02f, 6.95326924e-02f, 1.74119812e-03f, 9.16194990e-02f, 6.48497641e-02f, 1.32065728e-01f,
  8.00041258e-02f, -1.37285972e-02f, -5.44092804e-02f, -1.26671001e-01f, -6.31127879e-02f, 1.02102950e-01f, 1.85970683e-02f, -3.20450701e-02f, 8.30538943e-03f, -1.40387509e-02f,
  -6.78772181e-02f, -2.50418596e-02f, -2.64538527e-02f, 7.80760311e-03f, 8.28274563e-02f, -2.68166978e-02f, 6.04847632e-02f, -6.13902248e-02f, -3.85137573e-02f, 2.93464940e-02f,
  -3.20629217e-02f, 2.51804203e-01f, -3.20636213e-01f, -1.57804862e-01f, 2.50898421e-01f, -3.39966118e-01f, -2.01433972e-01f, 8.77047405e-02f, 3.40022743e-02f, 1.50885269e-01f,
  4.22769114e-02f, -3.87817691e-03f, 1.16552368e-01f, -2.11807385e-01f, -4.35422361e-01f, -3.27866167e-01f, -2.65065551e-01f, -1.55569971e-01f, -2.29690261e-02f, 2.38331020e-01f,
  -9.07300189e-02f, 1.97035298e-01f, -3.71395499e-01f, 4.71701413e-01f, -3.32460366e-02f, 1.45963777e-03f, 1.85798869e-01f, 1.51613235e-01f, -1.74489677e-01f, -2.93335393e-02f,
  -1.86773404e-01f, 8.68448988e-02f, -1.26201257e-01f, -8.65479186e-02f, -6.24483973e-02f, 2.17698850e-02f, -5.90630434e-02f, -5.99392317e-02f, -2.03825027e-01f, -8.55306163e-02f,
  5.28173111e-02f, -6.88966364e-03f, 9.92201567e-02f, 4.98462096e-02f, 6.95816949e-02f, 1.05455823e-01f, -2.04038560e-01f, -2.10138232e-01f, -4.51123267e-02f, -9.11292434e-02f,
  -1.56320691e-01f, -1.76113211e-02f, -3.72429416e-02f, -8.65013078e-02f, -4.89635505e-02f, -5.51660843e-02f, 1.15885641e-02f, -4.43151481e-02f, -9.50106829e-02f, -5.91739304e-02f,
  5.28595671e-02f, 1.42524526e-01f, -5.33367991e-02f, -2.98709236e-02f, 5.30721582e-02f, 1.61354952e-02f, -1.04693724e-02f, 3.05119641e-02f, -1.09475583e-03f, 5.82078658e-02f,
  1.07570566e-01f, 7.80565813e-02f, 6.95012435e-02f, -7.76660144e-02f, -2.76963115e-02f, 6.00242279e-02f, 5.67736402e-02f, 8.83741491e-03f, -7.97616504e-03f, -1.02454238e-01f,
  3.03316955e-02f, 8.75200145e-03f, 7.93230161e-02f, 1.18180655e-01f, -2.53424086e-02f, 2.10346561e-02f, 1.44759998e-01f, -1.25771523e-01f, -7.61938095e-02f, 4.24613692e-02f,
  1.18468395e-02f, 1.73450008e-01f, 7.69025972e-03f, -3.52327968e-03f, 5.65675013e-02f, 1.99961476e-02f, -1.95370428e-02f, -1.25562221e-01f, -1.22434504e-01f, 1.57524541e-01f,
  5.45471013e-02f, 2.17538308e-02f, 3.97824943e-02f, 1.25630824e-02f, -3.64031233e-02f, 3.73919122e-02f, 8.80720839e-03f, -4.89320718e-02f, -2.22035367e-02f, 1.26990259e-01f,
  6.77669868e-02f, 1.33126527e-01f, 1.76565666e-02f, 2.58220267e-02f, 2.16954984e-02f, -1.14878826e-02f, 1.44068420e-01f, -3.74411568e-02f, -3.49903591e-02f, -6.50229901e-02f,
  -1.42439812e-01f, 9.80838537e-02f, -2.58259624e-01f, -1.10244825e-02f, 8.46531168e-02f, -4.53204811e-02f, 9.81676131e-02f, 7.76026994e-02f, -6.89784586e-02f, 3.56961757e-01f,
  2.86560714e-01f, -5.55549040e-02f, 2.33566478e-01f, 2.17982039e-01f, -2.43150368e-01f, 4.42552418e-02f, 1.54909775e-01f, 7.45592788e-02f, -1.40215710e-01f, 2.90524140e-02f,
  -1.10775769e-01f, 2.09123209e-01f, 1.04707601e-02f, 3.27698886e-02f, 7.38533437e-02f, -1.40178666e-01f, 2.31416047e-01f, -6.28570914e-02f, 1.02267869e-01f, 7.71800205e-02f,
  -3.98379657e-03f, -1.60573535e-02f, -2.03873385e-02f, -9.43135172e-02f, -4.10272367e-02f, 9.94008556e-02f, -6.87040156e-03f, -9.11622122e-02f, -5.11085726e-02f, -6.58437386e-02f,
  2.89401226e-02f, -1.81306042e-02f, -1.15528129e-01f, 5.31012602e-02f, -4.89532948e-02f, -3.77551615e-02f, -8.04814249e-02f, -5.07969037e-02f, -3.93095165e-02f, 3.17017138e-02f,
  -4.35061231e-02f, -1.12003960e-01f, 8.95425156e-02f, -1.43158603e-02f, -2.07065474e-02f, 5.58226556e-02f, -4.80872728e-02f, 3.68071049e-02f, -3.74301225e-02f, 1.64312485e-03f,
  -1.42610753e-02f, 8.25409144e-02f, -2.33738665e-02f, -3.18047814e-02f, -2.21964214e-02f, -3.11577544e-02f, 2.78020184e-02f, 2.92934570e-02f, 2.28019655e-02f, 2.22341456e-02f,
  -3.15189324e-02f, -8.69404450e-02f, 1.08670555e-01f, 8.96426439e-02f, 4.22239974e-02f, -5.27585577e-03f, -1.13729611e-01f, 1.82313416e-02f, 2.91857123e-02f, -8.83281901e-02f,
  5.20429462e-02f, -7.66564086e-02f, -6.30809367e-02f, 5.28541841e-02f, -3.58505262e-04f, 3.68679501e-02f, 1.36255667e-01f, 1.76821195e-04f, 1.89203843e-02f, 8.19999799e-02f,
  9.37363431e-02f, 8.75894353e-02f, -2.61922646e-02f, -9.37850587e-03f, -7.85215124e-02f, 8.61418375e-04f, 6.20530471e-02f, -1.11161500e-01f, 4.89619151e-02f, 4.41543721e-02f,
  2.08072690e-03f, -5.91397882e-02f, 1.21156327e-01f, -6.21848591e-02f, -1.28657714e-01f, 7.23506883e-02f, 1.75449058e-01f, -5.35874106e-02f, 3.08962688e-02f, -2.60166191e-02f,
  9.41649526e-02f, -5.56279793e-02f, -1.29534043e-02f, 3.72183137e-02f, -1.24522801e-02f, 1.54533833e-01f, -3.47375497e-02f, 5.44164935e-03f, 1.59052368e-02f, 5.97912557e-02f,
  -5.76015294e-01f, 4.48910117e-01f, 3.39318633e-01f, -1.72232822e-01f, 3.41339298e-02f, 6.79291636e-02f, 8.36377367e-02f, 8.23605731e-02f, -8.32758918e-02f, 1.37040406e-01f,
  6.80250674e-02f, 1.74533632e-02f, 2.09111512e-01f, 4.56672832e-02f, -9.00648758e-02f, 6.12607785e-03f, -9.83688980e-02f, -7.12469667e-02f, -2.17853580e-02f, -1.34065092e-01f,
  -1.24188125e-01f, -5.06211966e-02f, 7.59370998e-02f, 1.68319404e-01f, 1.32967755e-01f, -4.90978993e-02f, -6.80077896e-02f, 1.70195296e-01f, 3.15248594e-02f, 1.45477831e-01f,
  -1.86451241e-01f, -2.86998630e-01f, -2.36157238e-01f, -8.34497884e-02f, -8.84857774e-02f, -6.84363544e-02f, -4.04731408e-02f, 3.86989526e-02f, -1.65771246e-01f, -5.87831177e-02f,
  2.80262716e-02f, 1.35190964e-01f, -6.85911700e-02f, -3.23908031e-02f, -1.37783941e-02f, 6.73142746e-02f, 1.57142639e-01f, 4.44612553e-04f, 6.37885034e-02f, 1.85681060e-01f,
  1.30800486e-01f, 3.72516662e-02f, 4.93148528e-02f, -3.46877836e-02f, 9.55019370e-02f, 9.56869312e-03f, 1.38164544e-02f, 8.70563686e-02f, 5.59926108e-02f, -2.58981660e-02f,
  9.84484237e-03f, -9.29165855e-02f, 7.98561573e-02f, -2.92309020e-02f, 1.07673667e-01f, 1.15023784e-01f, -3.36952917e-02f, 9.83748771e-03f, 2.31230147e-02f, -1.41858310e-03f,
  1.68987457e-02f, -6.10890351e-02f, -9.58787501e-02f, -5.90421669e-02f, -7.75801670e-03f, -1.98133364e-02f, -1.16759345e-01f, 1.34151783e-02f, -1.23308378e-03f, 4.49807830e-02f,
  -2.02532765e-02f, 5.09966724e-02f, 4.03089188e-02f, 3.50584798e-02f, 3.48684471e-03f, 1.25453705e-02f, 8.25742558e-02f, 1.44907236e-02f, -1.00509979e-01f, -1.48059716e-02f,
  -4.85469073e-01f, -4.38171864e-01f, -1.54575676e-01f, -3.69124003e-02f, -9.76568311e-02f, -7.38391876e-02f, -1.06146388e-01f, -2.32230127e-02f, -8.49028826e-02f, -1.72112554e-01f,
  -2.57094912e-02f, 1.83848552e-02f, -4.58625406e-02f, -1.23909332e-01f, -2.80447416e-02f, -5.80328703e-02f, -9.05072168e-02f, -1.71666145e-01f, -1.13694333e-01f, 1.46217206e-02f,
  3.88790071e-02f, -5.54287955e-02f, 7.72623941e-02f, 1.27871206e-03f, -5.08555248e-02f, 3.14867198e-02f, -1.82840914e-01f, 1.29863888e-01f, 2.77265208e-04f, 4.94488254e-02f,
  -2.95876741e-01f, 2.60373205e-01f, -4.22762707e-03f, -1.94009900e-01f, -3.47201414e-02f, -1.67360663e-01f, -2.44656112e-02f, 8.09489861e-02f, -2.61625685e-02f, 1.90686822e-01f,
  2.78357640e-02f, 4.26761061e-02f, 8.80340412e-02f, -1.49060830e-01f, -5.58040917e-01f, -1.95706561e-01f, -2.09313199e-01f, -5.93777299e-02f, -1.81581914e-01f, 1.52287632e-02f,
  -1.65042847e-01f, -2.46654987e-01f, -2.28808634e-02f, -7.78332204e-02f, 1.20106367e-02f, 1.18536547e-01f, -6.96313083e-02f, 1.26566246e-01f, -2.74669807e-02f, -2.19637174e-02f,
  1.72909886e-01f, 1.60516635e-01f, 1.17941968e-01f, 3.18449102e-02f, -4.44080569e-02f, -8.78106430e-03f, 4.87035466e-03f, -6.86697736e-02f, 1.63822938e-02f, 7.61571229e-02f,
  -5.32453470e-02f, 3.24650593e-02f, 4.17358615e-02f, -8.55603963e-02f, -5.29471152e-02f, 4.50411029e-02f, 2.26427261e-02f, 8.34793076e-02f, 9.95467082e-02f, -4.41400856e-02f,
  1.47974892e-02f, 2.37851497e-02f, -5.19831814e-02f, 4.89084562e-03f, -1.82259250e-02f, 5.46600595e-02f, -5.81662208e-02f, 4.28154180e-03f, 8.25800300e-02f, -5.42474911e-02f,
  -8.32062662e-02f, -5.67020364e-02f, 1.74232144e-02f, 2.68392675e-02f, -1.06159478e-01f, 2.02724393e-02f, -7.71245137e-02f, -2.23744828e-02f, -8.17655772e-02f, 1.87322404e-02f,
  3.05766352e-02f, 3.40116508e-02f, 6.77422248e-03f, -1.24186039e-01f, -1.18171714e-01f, -3.53440829e-02f, -2.87395939e-02f, 7.12852255e-02f, -2.44201683e-02f, 1.19803343e-02f,
  7.66668096e-02f, 4.53707622e-03f, 9.34885517e-02f, 7.16229975e-02f, 2.98111197e-02f, -7.06341788e-02f, -1.94351524e-02f, 1.68450177e-02f, 1.23854585e-01f, -9.24066529e-02f,
  3.69197018e-02f, -5.69864474e-02f, 1.30577371e-01f, 8.79194438e-02f, 5.92263527e-02f, -8.20438862e-02f, -1.01026662e-01f, -1.26089938e-02f, -7.75683252e-03f, -1.15042858e-01f,
  -1.09239891e-01f, 6.62133321e-02f, 6.20098524e-02f, -3.16094235e-02f, -2.60763858e-02f, -1.36802467e-02f, 1.02993483e-02f, 1.39586985e-01f, 5.21413758e-02f, 4.91557047e-02f,
  5.73903807e-02f, 3.23997848e-02f, -7.00926334e-02f, 4.89850454e-02f, 3.72753032e-02f, 5.26662245e-02f, 2.02772263e-02f, 1.95112154e-02f, -4.75534052e-02f, 4.23254184e-02f,
  1.20251030e-01f, -2.04581600e-02f, -2.53998637e-01f, -9.84959975e-02f, 3.95874158e-02f, 3.17561328e-02f, -1.19470537e-01f, -3.14987116e-02f, -2.37605885e-01f, 1.29488841e-01f,
  1.25089779e-01f, -1.03656456e-01f, -2.77230758e-02f, 2.86960930e-01f, 2.26358801e-01f, 7.38795325e-02f, 2.37711355e-01f, 1.41427130e-01f, 1.61172330e-01f, 2.06960991e-01f,
  1.38259590e-01f, 3.54160547e-01f, 1.12615198e-01f, 3.07247341e-01f, 1.78598672e-01f, -4.83077466e-02f, 2.25874662e-01f, -4.87624109e-02f, 1.68674976e-01f, 4.89986688e-02f,
  3.74603383e-02f, 9.24426168e-02f, -3.56227681e-02f, -6.90733120e-02f, 1.55003399e-01f, 6.26656339e-02f, 6.34508859e-03f, 3.42055410e-02f, -1.08388990e-01f, -1.57556068e-02f,
  1.85079724e-02f, -3.24959308e-02f, 4.56382707e-02f, 2.77173799e-02f, -2.78314911e-02f, -5.41585386e-02f, -1.11690927e-02f, -8.91427696e-02f, -9.66241583e-02f, 4.50760238e-02f,
  -8.03030282e-02f, -3.03393435e-02f, -5.82800880e-02f, -1.89389717e-02f, -9.39220414e-02f, -8.64048228e-02f, -3.99115719e-02f, -5.45382313e-02f, -2.39426531e-02f, 9.00852866e-03f,
  7.55297858e-03f, 1.08452458e-02f, -5.03054063e-04f, -1.71973482e-02f, 6.89787790e-02f, -2.12963112e-02f, -4.23198827e-02f, 7.87404701e-02f, -5.66634275e-02f, 3.30200419e-02f,
  2.03928235e-03f, -4.70369607e-02f, 3.02635804e-02f, 8.99134427e-02f, 1.16336472e-01f, 4.76186760e-02f, 2.77014188e-02f, 5.75131038e-03f, 4.06353315e-03f, 3.41056511e-02f,
  1.47607503e-02f, 3.53012532e-02f, -2.63820235e-02f, -5.20969443e-02f, -1.11359302e-02f, -5.30098863e-02f, 4.41570990e-02f, 2.03098077e-02f, -9.56007689e-02f, -7.45900422e-02f,
  1.39391288e-01f, 2.19063580e-01f, -1.15616259e-03f, -4.33301665e-02f, 2.74761785e-02f, 7.70173371e-02f, 4.38823253e-02f, -3.63239348e-02f, 1.11656096e-02f, 1.60240084e-01f,
  8.59370008e-02f, -1.25061825e-01f, -1.04811424e-02f, -1.34530291e-02f, -7.22450092e-02f, 5.76460874e-03f, 3.26217450e-02f, -1.85649157e-01f, -7.71034658e-02f, 6.35096878e-02f,
  2.15865411e-02f, 2.70670338e-04f, -5.89724295e-02f, -8.39637443e-02f, -5.23374453e-02f, 1.00750504e-02f, 6.02239966e-02f, -2.87677199e-02f, 7.55031928e-02f, -6.04572110e-02f,
  -3.08074176e-01f, 2.93442726e-01f, 4.23747778e-01f, 8.47533345e-02f, -8.36584345e-02f, 3.16422850e-01f, 2.79144734e-01f, 3.65609452e-02f, 2.68253386e-01f, -3.75504270e-02f,
  -2.69095123e-01f, 1.07469261e-01f, 8.18190873e-02f, -3.94825870e-03f, 2.87835538e-01f, 2.66690791e-01f, 2.24650115e-01f, 2.31782228e-01f, 1.61576480e-01f, 2.12042201e-02f,
  -7.18784854e-02f, -1.78342134e-01f, -6.49189204e-02f, -1.49919406e-01f, -1.59416080e-01f, -5.74939214e-02f, -3.40752035e-01f, 1.10918738e-01f, -1.35542512e-01f, -9.45046544e-02f,
  -1.08571775e-01f, -1.54569641e-01f, -2.49581128e-01f, -4.62886924e-03f, -7.12637082e-02f, -2.03898884e-02f, 1.98564604e-02f, -3.00981514e-02f, 5.92683395e-03f, -4.59974632e-02f,
  -1.91849079e-02f, -7.52590969e-02f, -8.79240111e-02f, -3.51708904e-02f, 1.39276281e-01f, -5.02931811e-02f, 7.11584687e-02f, -4.19029444e-02f, -6.35337606e-02f, -5.16434722e-02f,
  -5.19070774e-03f, 2.30935812e-02f, 7.45890141e-02f, 6.17680773e-02f, 4.14141230e-02f, -5.92335053e-02f, 2.57927179e-02f, -9.12880432e-03f, 1.93073611e-05f, 4.43710312e-02f,
  4.29072194e-02f, -5.43585233e-03f, -1.04269892e-01f, -1.61884085e-03f, 2.88657122e-03f, -9.54929739e-04f, -2.43781395e-02f, -9.64394361e-02f, -1.90654304e-02f, -1.23946831e-01f,
  4.53842431e-03f, -1.39288818e-02f, -5.11144027e-02f, 1.25060529e-01f, -4.15257290e-02f, -1.48122072e-01f, 6.22253213e-03f, 5.53809218e-02f, 3.54301259e-02f, -5.27103879e-02f,
  3.94465588e-02f, 8.43550861e-02f, -1.41511887e-01f, -8.98591131e-02f, 6.27438575e-02f, -5.41595891e-02f, -9.43338424e-02f, 2.23269854e-02f, -1.34612292e-01f, -3.78924003e-03f,
  1.81194544e-01f, 1.49266660e-01f, -1.21743701e-01f, -1.38102785e-01f, 7.22901076e-02f, 6.73397258e-02f, 7.26479441e-02f, -1.39505491e-01f, 1.17489904e-01f, -5.34525588e-02f,
  -4.42763194e-02f, -1.11371353e-01f, 1.19285015e-02f, -7.66613185e-02f, 1.52258009e-01f, -1.23177812e-01f, -9.63841286e-03f, -7.94702694e-02f, -7.80635476e-02f, -1.12922095e-01f,
  -1.14653692e-01f, 2.64903568e-02f, 7.99246579e-02f, -1.38550654e-01f, -2.27439795e-02f, -7.39699006e-02f, -2.29929257e-02f, -1.12830168e-02f, 7.66693726e-02f, 1.40580917e-02f,
  -5.00556946e-01f, 2.33365193e-01f, -1.10440068e-01f, 4.39973585e-02f, -2.39590660e-01f, -2.17911139e-01f, -2.24289522e-02f, -1.05504937e-01f, -2.28779055e-02f, 2.82893896e-01f,
  1.67709887e-01f, -1.51536897e-01f, 1.88488603e-01f, 1.53326258e-01f, -2.79814720e-01f, 2.78004616e-01f, 1.34471972e-02f, 5.91786951e-02f, 6.49792701e-02f, -1.72319189e-01f,
  -9.01345015e-02f, -8.29468668e-02f, 4.62138690e-02f, -9.42864865e-02f, -2.22004741e-01f, -1.10550307e-01f, 1.41707566e-02f, -1.92338303e-01f, 3.76472399e-02f, -9.16569903e-02f,
  -1.41404405e-01f, -1.17172651e-01f, -9.88598317e-02f, -1.52444035e-01f, -6.87267855e-02f, -2.44293474e-02f, -1.19246356e-01f, 2.08553988e-02f, -7.30734393e-02f, -4.88142483e-02f,
  4.71893046e-03f, 2.51575932e-02f, 5.47399521e-02f, 5.24754822e-02f, -3.04939877e-02f, -1.27434984e-01f, 2.10859738e-02f, -6.74205367e-04f, -1.36769488e-01f, 3.98172960e-02f,
  5.38407266e-02f, 6.14631474e-02f, -2.98494808e-02f, 1.62435938e-02f, -5.18124923e-02f, -6.27233693e-03f, 7.40395412e-02f, 4.44306508e-02f, 3.39433625e-02f, -3.94856110e-02f,
  9.36952904e-02f, 3.44575495e-02f, -5.55364713e-02f, -7.65313581e-03f, 8.68552625e-02f, 6.28496408e-02f, 5.74830435e-02f, 2.47132294e-02f, 2.59342026e-02f, -7.95140043e-02f,
  -5.35983033e-02f, -8.97827372e-02f, -7.23877028e-02f, 4.68472578e-03f, 8.30259472e-02f, -8.04120824e-02f, 1.57497227e-02f, -1.57887042e-02f, 1.68748982e-02f, -7.42653757e-03f,
  1.15136383e-02f, -1.00019970e-03f, -3.24361809e-02f, -8.52809995e-02f, -1.41026452e-02f, -3.22749317e-02f, 1.43008932e-01f, 3.55500053e-03f, -9.51897502e-02f, -7.84493983e-02f,
  -3.68299961e-01f, -2.77341008e-01f, -1.74578413e-01f, -1.21854991e-01f, -6.87487721e-02f, -4.44204696e-02f, 5.66821592e-03f, -1.09384665e-02f, -8.88644457e-02f, -1.48108482e-01f,
  -1.40255354e-02f, 1.02733611e-03f, 1.23580974e-02f, -3.49288248e-02f, 3.51690198e-03f, -6.88747019e-02f, -4.43274230e-02f, -4.51858081e-02f, -1.33622408e-01f, -9.92495194e-02f,
  -3.42200510e-02f, -4.37470861e-02f, -9.21582133e-02f, -2.42982917e-02f, 7.59259462e-02f, -7.86120966e-02f, -4.82604504e-02f, 6.36745095e-02f, 2.59694876e-03f, -4.42343717e-03f,
  3.60006183e-01f, -2.50326283e-02f, 2.09259182e-01f, 3.67497057e-01f, 8.53111781e-03f, -1.00814693e-01f, -7.15382919e-02f, 3.72933932e-02f, 3.64173502e-01f, -6.71728477e-02f,
  -1.75002307e-01f, 3.10112536e-01f, -3.80852342e-01f, 1.37560457e-01f, -2.30900824e-01f, -2.30319142e-01f, 2.48910803e-02f, 1.24625891e-01f, 9.91387889e-02f, -3.52572650e-02f,
  1.52864173e-01f, -2.94857085e-01f, -3.38434279e-02f, -3.14304471e-01f, 7.28363693e-02f, 1.18607946e-01f, -2.59635478e-01f, -1.08879611e-01f, 3.98895331e-02f, -2.38455273e-02f,
  -1.19947670e-02f, 5.32545671e-02f, 4.24048491e-02f, 1.89795941e-02f, -2.09676716e-02f, 8.27721283e-02f, 4.98495623e-02f, 2.05463972e-02f, -5.08530065e-02f, 5.32524288e-02f,
  2.87962649e-02f, -6.42858818e-03f, 3.53350416e-02f, 6.16352521e-02f, 8.44555721e-03f, 2.68254317e-02f, 1.37181625e-01f, 4.97775152e-02f, 1.74288601e-02f, 1.77902982e-01f,
  5.79866245e-02f, 1.15332894e-01f, 8.94825757e-02f, 2.22400241e-02f, 8.89722183e-02f, 9.26482864e-03f, 1.23840310e-01f, 7.30412230e-02f, 3.95417660e-02f, 7.40632340e-02f,
  1.43933985e-02f, -3.67714427e-02f, -1.05907299e-01f, -1.04747824e-02f, -8.83978382e-02f, 2.49254294e-02f, -7.25439936e-02f, -3.35586071e-02f, 1.06084589e-02f, 1.41852517e-02f,
  -9.61636454e-02f, -1.94532387e-02f, 5.35821356e-02f, 3.19333151e-02f, -2.43595410e-02f, 1.34661525e-01f, -3.62789966e-02f, 9.44257826e-02f, 4.22256738e-02f, -9.32020620e-02f,
  -1.08901665e-01f, -2.47038491e-02f, -3.44459638e-02f, 2.69168410e-02f, -2.86580250e-02f, -3.59830484e-02f, 4.10608687e-02f, 1.03168815e-01f, 7.62445107e-02f, -1.55093312e-01f,
  -3.04247409e-01f, -2.76838303e-01f, -7.96494782e-02f, 2.68394835e-02f, -9.72867534e-02f, 5.52741364e-02f, 1.38749257e-01f, 1.77160263e-01f, -1.91790760e-01f, -2.36736611e-02f,
  7.43497387e-02f, -1.77724082e-02f, -6.06721789e-02f, 1.50355533e-01f, -1.54289305e-01f, -3.81815247e-02f, 3.63819413e-02f, -8.71086121e-02f, -1.00021459e-01f, -4.65426445e-02f,
  1.73770133e-02f, -4.49532270e-02f, -1.38821232e-03f, 8.11694711e-02f, 1.27465695e-01f, -1.06783614e-01f, 1.51272044e-01f, 9.83823761e-02f, 7.42554739e-02f, 6.90361336e-02f,
  -9.45382714e-02f, 2.88957059e-01f, 5.55016473e-02f, -1.36492729e-01f, -2.45285243e-01f, -7.48351738e-02f, -6.67872950e-02f, 7.22418353e-02f, 2.67077416e-01f, 1.06230408e-01f,
  -1.67793155e-01f, 3.24799538e-01f, 6.99932054e-02f, -1.61441460e-01f, -1.91928282e-01f, 1.12631954e-02f, -1.87690780e-01f, -3.44353318e-02f, -5.71650192e-02f, -8.72127712e-02f,
  -1.06042817e-01f, -2.99707144e-01f, -1.25536934e-01f, -1.79688901e-01f, -1.12121806e-01f, 9.22764316e-02f, -2.04820648e-01f, 6.90993693e-05f, -8.97043794e-02f, -1.63768958e-02f,
  1.42233707e-02f, 8.86696950e-02f, 1.49313703e-01f, 1.81422800e-01f, 1.51966661e-02f, -1.08301669e-01f, 1.22461552e-02f, 3.84817943e-02f, 1.46934344e-02f, 1.20086342e-01f,
  5.25609367e-02f, 1.13431588e-01f, 5.95275201e-02f, -1.40894309e-01f, 1.12523949e-02f, -3.55541185e-02f, 6.42725173e-03f, 2.91333925e-02f, 1.56852767e-01f, -1.28777221e-01f,
  2.57739611e-02f, 8.14853609e-02f, -6.83972836e-02f, 8.44615176e-02f, 7.21170530e-02f, 1.68184862e-02f, 2.79433988e-02f, 7.44540291e-03f, 8.16625208e-02f, 2.55735498e-02f,
  1.05497222e-02f, -9.59649533e-02f, -3.66273113e-02f, -4.55902144e-02f, -3.11170910e-02f, 5.10652959e-02f, -3.34024094e-02f, -1.28822654e-01f, 9.84200463e-03f, 9.94280279e-02f,
  3.60297300e-02f, 8.32015425e-02f, -4.65421788e-02f, -1.43717542e-01f, -6.86248615e-02f, 6.64321259e-02f, -9.28853005e-02f, 8.71341228e-02f, 3.20512727e-02f, 2.25839708e-02f,
  -5.21122366e-02f, -1.45226747e-01f, 5.35541922e-02f, -7.43017439e-03f, -2.45084171e-03f, 2.19693221e-03f, -1.05477981e-01f, 9.66411922e-03f, 1.02362044e-01f, -1.18769810e-01f,
  4.62931618e-02f, 1.68018956e-02f, 1.63044378e-01f, 2.29343906e-01f, 1.46076381e-01f, -1.04879230e-01f, -7.37558156e-02f, 9.64255333e-02f, 5.60381413e-02f, -2.31365263e-02f,
  -7.06534535e-02f, 1.32282257e-01f, 2.12302655e-02f, -8.06351900e-02f, 3.25502753e-02f, 6.19846173e-02f, -8.69204476e-03f, 1.27639756e-01f, 2.72376612e-02f, -2.48572659e-02f,
  -4.71981615e-02f, -1.68037191e-02f, -4.28828634e-02f, 7.29445964e-02f, 3.23372148e-02f, 2.93017011e-02f, 1.17017701e-03f, 9.27636027e-02f, -1.02926493e-01f, 3.64591777e-02f,
  1.94273040e-01f, -1.85360119e-01f, -1.71439782e-01f, -6.42372519e-02f, 1.25329211e-01f, 1.23047203e-01f, 1.45030320e-01f, -1.36310458e-01f, -2.86805332e-01f, 8.23734850e-02f,
  3.69317718e-02f, -5.50565422e-02f, 1.09288678e-01f, -2.40125835e-01f, -5.86486124e-02f, -1.78989455e-01f, 1.00139929e-02f, 3.46045010e-02f, -6.72028214e-02f, 2.77192026e-01f,
  4.50930521e-02f, 8.53627399e-02f, -1.71621814e-01f, 9.52292904e-02f, 4.08430658e-02f, 1.64180443e-01f, 2.54148394e-01f, 9.69138741e-02f, 7.57922381e-02f, -1.63024068e-01f,
  -1.44885689e-01f, -1.76353723e-01f, -1.10767484e-01f, -2.32134052e-02f, 1.05966114e-01f, 1.42546937e-01f, 6.09795842e-03f, -4.24696207e-02f, 1.20508811e-03f, -2.70978324e-02f,
  2.06319019e-01f, -2.61862148e-02f, -5.83975278e-02f, -1.90792419e-02f, 8.47025737e-02f, 2.13443134e-02f, -2.76593734e-02f, -1.01504661e-01f, -9.50658396e-02f, 7.94797689e-02f,
  2.65753698e-02f, -6.48280373e-03f, 3.68318483e-02f, -3.90153378e-02f, 9.11701620e-02f, 9.21624917e-07f, 6.85965568e-02f, 1.86815843e-01f, -6.68861344e-02f, 4.30864654e-02f,
  8.29752237e-02f, 9.93410423e-02f, 8.17888528e-02f, -1.57101616e-01f, -5.18684927e-03f, -7.64225647e-02f, -6.51109591e-02f, -2.96309385e-02f, -2.08884198e-02f, 2.75462549e-02f,
  8.44121873e-02f, 6.67124614e-02f, -1.34589970e-01f, 5.74578978e-02f, 1.67992547e-01f, -1.09278306e-01f, 4.89196815e-02f, 8.61644447e-02f, 1.81453586e-01f, -6.90680444e-02f,
  -1.31667957e-01f, 1.09135266e-02f, 5.19465934e-03f, -3.54016535e-02f, -8.25872496e-02f, 1.44190386e-01f, 5.04128113e-02f, -2.28452999e-02f, -1.16987631e-01f, 4.11881395e-02f,
  8.99614841e-02f, 2.31086254e-01f, -2.16710512e-02f, 1.26369717e-02f, -4.95088063e-02f, 1.47062048e-01f, -1.42123371e-01f, -5.34427948e-02f, 5.55103756e-02f, 7.91527629e-02f,
  2.35167921e-01f, 5.66141605e-02f, 4.78450442e-03f, -6.24062382e-02f, -5.00954613e-02f, 1.55674994e-01f, 1.79451138e-01f, 2.85300449e-03f, 1.05504524e-02f, 3.48290466e-02f,
  1.50585726e-01f, 1.08706154e-01f, 5.15026152e-02f, -4.99911942e-02f, 1.25826627e-01f, 7.37314448e-02f, 8.90682340e-02f, 3.53558064e-02f, 1.73917394e-02f, -5.70583977e-02f,
  1.19887814e-02f, 1.29865631e-02f, -2.47577325e-01f, -7.86655694e-02f, -1.10401779e-01f, -1.47497296e-01f, -1.11720465e-01f, 1.08091854e-01f, 1.45908281e-01f, 2.79713601e-01f,
  -1.63086534e-01f, 3.65452468e-01f, 2.87455559e-01f, -2.61134267e-01f, -2.59594977e-01f, 5.01203127e-02f, -1.94535688e-01f, -3.34180659e-03f, -1.88492313e-02f, 7.41423806e-03f,
  -7.76547343e-02f, -2.95631010e-02f, -3.07731271e-01f, 1.90160409e-01f, -2.31317401e-01f, 4.01453814e-03f, -2.79770672e-01f, -1.41115665e-01f, -3.30071241e-01f, -1.79266453e-01f,
  -1.79449648e-01f, 1.47850946e-01f, 4.66313697e-02f, 2.41885185e-02f, -2.72992942e-02f, 5.61516918e-02f, -1.46164864e-01f, 9.47198570e-02f, 2.14597138e-04f, -1.84613857e-02f,
  1.51409194e-01f, 1.55075461e-01f, 4.54755202e-02f, -8.66281316e-02f, -7.84963667e-02f, -1.06095277e-01f, -7.69513622e-02f, -1.50416374e-01f, 1.27580419e-01f, -1.07174046e-01f,
  -1.51764816e-02f, -8.70900378e-02f, -3.30511928e-02f, -1.77035388e-02f, 2.07339711e-02f, 2.30002701e-02f, -4.99106944e-02f, -1.84487447e-01f, -3.70373763e-02f, -4.56413999e-02f,
  6.96417615e-02f, -6.21744171e-02f, 2.14235224e-02f, -6.68585300e-02f, 4.06518131e-02f, 4.52683493e-02f, 4.43741865e-02f, -5.35549736e-03f, 2.49722693e-02f, -4.97047193e-02f,
  -7.66795687e-03f, -8.46922677e-03f, -1.47148415e-01f, -4.26892117e-02f, 3.55321988e-02f, 7.58673996e-02f, -1.74040273e-02f, 2.71123517e-02f, -2.64854636e-02f, 1.29778944e-02f,
  -4.46533747e-02f, -1.81082878e-02f, 4.84065711e-02f, -1.05777703e-01f, -1.38092801e-01f, -2.06639394e-02f, -5.90640903e-02f, -8.76242146e-02f, 4.05001966e-03f, 5.05427904e-02f,
  -3.96055169e-02f, 1.03114322e-01f, 1.61898270e-01f, 1.41722068e-01f, 9.97907296e-02f, 1.41494852e-02f, 1.99404489e-02f, 9.47360694e-02f, -1.16536200e-01f, 9.81174707e-02f,
  -5.03425859e-03f, 9.94854793e-02f, -1.50146738e-01f, -1.43423706e-01f, 1.22215763e-01f, -9.63854566e-02f, 7.89519586e-03f, -1.64468382e-02f, -1.21915899e-02f, -2.82290727e-02f,
  1.21755250e-01f, 7.31182918e-02f, 1.82918370e-01f, 7.36856908e-02f, 1.97806925e-01f, 5.08594140e-03f, 9.21723172e-02f, -2.27387138e-02f, 2.11163107e-02f, -4.70337145e-05f,
  4.04958129e-01f, -2.45237470e-01f, -1.51075780e-01f, 2.79846549e-01f, 1.67039439e-01f, 2.64750928e-01f, 2.38804191e-01f, -1.05698109e-01f, -1.10790143e-02f, -1.15780784e-02f,
  1.70238912e-01f, -5.69928065e-02f, -2.80597597e-01f, 3.61825317e-01f, 1.60272673e-01f, -1.05390742e-01f, 2.58106709e-01f, 1.88397020e-01f, -3.36308181e-02f, -1.16724065e-02f,
  9.48913693e-02f, 2.95493335e-01f, -8.53658989e-02f, 1.53298033e-02f, 2.50910223e-01f, -5.31899743e-02f, -1.07786700e-01f, -1.55373156e-01f, 1.76130816e-01f, 8.90328959e-02f,
  7.98662677e-02f, 9.12419148e-03f, -1.60343410e-03f, -5.22087179e-02f, 2.03674342e-02f, 1.20330192e-01f, 1.61477756e-02f, -1.54406019e-02f, 3.62481959e-02f, -7.01935813e-02f,
  7.63338571e-03f, 8.64088014e-02f, -2.72013471e-02f, -9.26046725e-03f, 1.90525189e-01f, 8.45776275e-02f, 4.77010906e-02f, -2.06591301e-02f, -5.33526540e-02f, -1.08535159e-02f,
  7.99347237e-02f, 3.45030241e-02f, 8.69272351e-02f, -5.20837726e-03f, -3.60652581e-02f, -1.72709990e-02f, -1.21416673e-01f, -1.28081173e-01f, -2.46717241e-02f, -4.46513575e-03f,
  -2.06313096e-02f, -2.60406099e-02f, 1.23974206e-02f, 5.58575504e-02f, 7.10491464e-02f, 3.64285856e-02f, 7.53563419e-02f, 6.67192915e-04f, -2.84145791e-02f, -4.53881137e-02f,
  1.02802172e-01f, 6.35225475e-02f, 9.42133553e-03f, 7.83492997e-02f, 3.01453825e-02f, -2.52336860e-02f, -1.66949015e-02f, -4.55899909e-03f, 1.13326358e-03f, -1.81810521e-02f,
  8.13760236e-02f, 3.16904299e-02f, -5.24529777e-02f, -2.37345584e-02f, 5.56453504e-02f, -6.47537857e-02f, 5.40129840e-02f, -1.72658451e-02f, -9.59339589e-02f, 1.96466427e-02f,
  -1.12285830e-01f, -3.47800344e-01f, -8.50562900e-02f, -2.61307340e-02f, 1.16762118e-02f, 9.31869447e-02f, -1.09878052e-02f, -8.86513144e-02f, -2.95871031e-02f, 4.68202010e-02f,
  7.04546645e-03f, 2.90759606e-03f, -6.40461221e-02f, 2.29600556e-02f, 5.45950010e-02f, -5.03712445e-02f, 1.86797418e-02f, -1.20546324e-02f, -4.30831797e-02f, -3.99174541e-02f,
  3.94814499e-02f, -1.08935721e-02f, 1.03357032e-01f, -2.33475007e-02f, -1.89365391e-02f, -3.03722117e-02f, -9.82284620e-02f, 1.92204379e-02f, -2.21301764e-02f, -8.91379490e-02f,
  -9.36258063e-02f, 1.60661995e-01f, -1.78467810e-01f, -7.86750764e-03f, -2.30957597e-01f, -2.82188773e-01f, -1.65713400e-01f, 3.22866850e-02f, 2.41957411e-01f, 3.65739316e-02f,
  -1.68194443e-01f, 1.51985630e-01f, 2.29816169e-01f, -2.44082466e-01f, 1.65867936e-02f, 1.47525102e-01f, -8.73580426e-02f, -9.95768309e-02f, 1.13319397e-01f, -1.29201382e-01f,
  2.12312620e-02f, -1.04629733e-01f, -1.59647793e-01f, -9.35751349e-02f, -2.44470552e-01f, 6.47260761e-03f, -4.43932936e-02f, -1.12735637e-01f, -2.35203058e-01f, 4.63445820e-02f,
  -1.43657267e-01f, 1.61056623e-01f, 1.91058796e-02f, 4.71827835e-02f, -3.93085293e-02f, -3.89711224e-02f, -1.23088300e-01f, 4.62414175e-02f, 4.31875251e-02f, 5.20737208e-02f,
  8.35656375e-02f, 9.41184834e-02f, 5.76774180e-02f, -1.22553788e-01f, 4.57061678e-02f, -4.53135930e-02f, 3.31238918e-02f, -3.81669849e-02f, 8.90045092e-02f, -2.01139346e-01f,
  -9.94621217e-02f, 2.11494789e-02f, -3.68742570e-02f, 2.29598016e-01f, 1.76275030e-01f, 1.02581978e-01f, 1.06637562e-02f, 2.77609583e-02f, 6.53254315e-02f, 1.53053254e-01f,
  -1.29941171e-02f, 1.37671735e-02f, -3.96809168e-02f, -9.88030210e-02f, 3.82653475e-02f, 1.00427717e-01f, -4.23661768e-02f, -6.59335330e-02f, 1.23724185e-01f, -3.07657812e-02f,
  -6.53480180e-03f, 3.41052674e-02f, -8.95268396e-02f, -1.01129852e-01f, 7.03488514e-02f, 9.20148790e-02f, -4.42816317e-02f, -2.17722673e-02f, 2.48504374e-02f, -6.90517649e-02f,
  -2.81387400e-02f, 2.83908378e-02f, 7.17459363e-04f, -5.67200519e-02f, -1.46172956e-01f, 5.98341562e-02f, -1.09687269e-01f, -9.86998603e-02f, -5.96192107e-02f, 1.84594989e-02f,
  -2.68873554e-02f, 3.02829027e-01f, 8.79326463e-02f, 1.52588964e-01f, 6.21040799e-02f, 3.07089221e-02f, -7.62818009e-02f, 8.71710405e-02f, 1.36685684e-01f, 1.31115299e-02f,
  -6.99871872e-03f, 5.72656803e-02f, -4.56036814e-02f, -1.34906650e-01f, 1.61760807e-01f, -3.94567568e-03f, -4.52387985e-03f, 1.90545216e-01f, 1.15713850e-01f, -2.24460475e-02f,
  -1.25076279e-01f, -4.75147665e-02f, 2.09312946e-01f, 1.61452457e-01f, 1.21753730e-01f, 9.97905880e-02f, -7.48877078e-02f, 7.34311491e-02f, 6.61517754e-02f, 1.29712507e-01f,
  4.80863124e-01f, -3.85623276e-01f, -1.07896216e-01f, 1.29209757e-01f, 3.37979198e-01f, 3.10033530e-01f, 2.30607659e-01f, -9.30981115e-02f, -1.31397173e-01f, -2.82380342e-01f,
  8.86141285e-02f, -4.91668656e-02f, -1.88548818e-01f, 1.71814486e-01f, 4.94022071e-01f, -8.76778439e-02f, 1.63312912e-01f, 5.24721630e-02f, 9.10780951e-02f, 2.83982437e-02f,
  1.49231404e-01f, 2.19877675e-01f, 7.24136680e-02f, -2.27134232e-03f, 2.19549358e-01f, -7.50779361e-02f, -6.19958714e-02f, -3.37947272e-02f, 5.79856187e-02f, 1.62258595e-01f,
  1.35908440e-01f, -1.05973527e-01f, 5.64434789e-02f, -6.89739082e-03f, -3.61187831e-02f, 2.78770793e-02f, -4.50801774e-04f, 1.09177172e-01f, 6.22503757e-02f, -6.79040328e-02f,
  1.52641675e-02f, -3.43232378e-02f, -2.40253303e-02f, 6.20713122e-02f, 2.01405454e-02f, -1.46496939e-02f, 9.04683664e-04f, 6.81544021e-02f, -1.56029552e-01f, 2.80887727e-02f,
  6.91181887e-03f, -4.78336267e-04f, 1.19286284e-01f, -3.50430422e-02f, -5.08033000e-02f, -5.05931377e-02f, -6.37208521e-02f, -7.23294765e-02f, -3.43245789e-02f, -4.68981713e-02f,
  -4.94469479e-02f, 3.29511776e-03f, 3.93709242e-02f, 2.56396644e-02f, 4.57988195e-02f, 3.52333784e-02f, 8.13542977e-02f, 3.39781642e-02f, -2.00957712e-02f, -3.08477934e-02f,
  4.47133183e-02f, -3.50081474e-02f, -2.99940109e-02f, 1.14873298e-01f, -4.90894774e-03f, 5.80932535e-02f, 6.83068782e-02f, -9.11645312e-03f, -7.25473166e-02f, 6.37495890e-02f,
  7.50329420e-02f, -3.67053295e-03f, -7.68590122e-02f, -2.16376074e-02f, -1.16956858e-02f, 2.13244166e-02f, 1.52611556e-02f, -5.06654046e-02f, -1.44308107e-02f, 2.11147182e-02f,
  -1.21704713e-01f, -3.82416248e-01f, -3.66953388e-02f, -4.81228605e-02f, -7.53826275e-02f, 2.14171093e-02f, 9.95470397e-03f, -4.93727103e-02f, -2.56540347e-02f, 3.34591195e-02f,
  1.43839384e-03f, -5.59337549e-02f, -4.15422469e-02f, 6.08143732e-02f, -2.59893644e-03f, -1.99920982e-02f, 4.47124336e-03f, -5.59879653e-02f, -3.38601805e-02f, -1.29660279e-01f,
  2.86387205e-02f, -1.45622790e-02f, 4.49079238e-02f, -8.43918845e-02f, -8.59198794e-02f, -6.92845061e-02f, -2.70550512e-02f, -4.67791632e-02f, -1.28542783e-03f, -1.25575140e-01f,
  -1.01549178e-01f, -2.89115071e-01f, 2.03447923e-01f, 2.55760878e-01f, -1.82640642e-01f, -2.56836981e-01f, 1.98449404e-03f, -3.46211493e-01f, -2.81160116e-01f, -3.17033470e-01f,
  -1.28736779e-01f, 3.09597671e-01f, -1.85821325e-01f, 2.55887002e-01f, 5.54998815e-01f, 4.16122191e-02f, 2.56476868e-02f, 1.73088890e-02f, -2.16341298e-02f, -1.21591628e-01f,
  -2.25091521e-02f, 4.43566814e-02f, 3.00720960e-01f, -1.22378848e-01f, 5.78138679e-02f, 1.80306882e-01f, 4.91069496e-01f, 1.84037745e-01f, 2.19219744e-01f, 2.96652138e-01f,
  -2.41994202e-01f, -2.48124655e-02f, -1.16440110e-01f, -1.07078537e-01f, -8.03868696e-02f, -1.13101518e-02f, 1.17339306e-01f, 1.83909267e-01f, 1.61185876e-01f, 2.14765836e-02f,
  8.27115774e-02f, 2.66435035e-02f, 7.42586283e-03f, 1.29155159e-01f, -5.69969602e-02f, 1.52978208e-02f, 6.17283694e-02f, -1.89248338e-01f, -7.37233460e-02f, -3.98375168e-02f,
  -4.78041656e-02f, -1.53533772e-01f, 4.38080505e-02f, 7.19325840e-02f, 1.06667466e-01f, -1.97768107e-01f, 1.16792336e-01f, 1.23136833e-01f, -2.87265889e-02f, -4.96105067e-02f,
  -1.64314155e-02f, 4.25435863e-02f, -8.51669833e-02f, 1.41966967e-02f, -1.19609646e-02f, 2.77436804e-04f, -9.18099210e-02f, 8.28894153e-02f, 1.04498319e-01f, -9.44167823e-02f,
  1.44545566e-02f, 6.00663573e-02f, -5.09764813e-02f, -3.24324556e-02f, -3.20902257e-03f, -9.32869464e-02f, 6.60595074e-02f, -2.17134804e-02f, -9.86069962e-02f, -3.46028320e-02f,
  1.11811370e-01f, -3.93796489e-02f, -8.15899484e-03f, 1.72917023e-02f, -8.30671638e-02f, 1.52064972e-02f, 7.07862154e-02f, -1.02190105e-02f, -8.96825548e-03f, 7.35702738e-02f,
  -1.79538533e-01f, 1.40145198e-01f, -4.50709164e-02f, -1.85498446e-01f, 3.02522685e-02f, 8.51453170e-02f, 1.07372589e-01f, -9.88833159e-02f, 9.24472883e-02f, -7.86682777e-03f,
  2.28790290e-04f, 3.08256075e-02f, -4.59846333e-02f, -2.76109576e-02f, 1.32277489e-01f, -1.99758839e-02f, 1.43493861e-01f, -3.72263081e-02f, -5.09420820e-02f, -6.23419806e-02f,
  3.59548926e-02f, -1.66073814e-02f, 9.66262594e-02f, -1.27408266e-01f, -9.43490770e-03f, -4.40581739e-02f, 4.05438878e-02f, -3.51164639e-02f, 7.11895600e-02f, 3.13952975e-02f,
  -4.48492974e-01f, 4.19176936e-01f, 4.20900881e-02f, -8.29736888e-02f, -1.41975842e-02f, -1.59408003e-01f, 2.61475686e-02f, 7.71958828e-02f, -5.62992804e-02f, 4.09502923e-01f,
  3.66437435e-02f, 7.27592735e-03f, 9.04447120e-03f, 1.26247510e-01f, -5.08839607e-01f, -1.38304114e-01f, -5.34505360e-02f, 4.18850146e-02f, -1.32197022e-01f, -8.13210979e-02f,
  -2.20060945e-01f, -1.20829225e-01f, 2.18812302e-02f, 1.77449640e-02f, 1.75007179e-01f, 6.72962070e-02f, 1.15376234e-01f, -4.34509590e-02f, 1.35874793e-01f, -5.10816500e-02f,
  -9.22772959e-02f, 1.94567982e-02f, 1.16959020e-01f, -4.60582823e-02f, -6.49932176e-02f, 5.61627336e-02f, -3.24708670e-02f, 2.09704991e-02f, -2.89310981e-02f, -5.62208146e-02f,
  1.02490157e-01f, 2.75484547e-02f, -6.40196279e-02f, 6.05611922e-03f, 4.41887230e-02f, -1.07438736e-01f, 1.52762070e-01f, 8.98936018e-02f, 2.24092249e-02f, 4.51046079e-02f,
  8.98793265e-02f, 8.74416605e-02f, 7.43951872e-02f, 6.20809048e-02f, 6.35847002e-02f, 8.57582781e-03f, 4.68746535e-02f, 1.18242912e-01f, 1.38566613e-01f, 1.47237284e-02f,
  7.35566095e-02f, -7.91976750e-02f, 1.12811364e-01f, -8.44328851e-02f, 3.23905572e-02f, 4.02035471e-03f, 4.73005846e-02f, 9.90471244e-03f, 4.81343269e-02f, -6.56966418e-02f,
  -1.23393074e-01f, -6.57201856e-02f, -8.17447603e-02f, -4.84662056e-02f, -2.67368741e-02f, -8.31962749e-02f, -4.78818342e-02f, 9.28405896e-02f, -1.43005729e-01f, 2.40602642e-02f,
  5.87291270e-02f, 1.25381965e-02f, -1.62138268e-02f, -1.33511322e-02f, 2.33342387e-02f, -3.69467996e-02f, 1.21460937e-01f, 4.39462699e-02f, -6.35267496e-02f, -1.45849347e-01f,
  -1.93971977e-01f, -1.83396608e-01f, 1.61858425e-02f, -1.11816719e-03f, 1.33064231e-02f, -1.32420810e-03f, 1.85379833e-02f, 6.83269575e-02f, 1.49037428e-02f, -9.95478183e-02f,
  4.83795293e-02f, 1.31352574e-01f, -2.49382854e-02f, -1.07380517e-01f, -9.14192796e-02f, -1.09013490e-01f, 3.74616943e-02f, -1.30072832e-01f, 1.80266965e-02f, -5.43848984e-02f,
  1.40883476e-01f, 4.04881425e-02f, 3.96136194e-02f, 7.95800388e-02f, 1.73855245e-01f, 1.11372501e-03f, -2.53921412e-02f, 1.53668374e-01f, 1.57631293e-01f, 3.41849513e-02f,
  -1.38307614e-02f, -1.33817613e-01f, -2.46416554e-01f, -1.56384557e-02f, 1.23820128e-02f, -2.68703312e-01f, -2.25482769e-02f, -1.12315036e-01f, 1.07295372e-01f, 1.11434333e-01f,
  1.97408140e-01f, 7.11579099e-02f, 2.81107426e-01f, 2.02796166e-03f, 1.23098262e-01f, 2.94004321e-01f, -1.65267855e-01f, 3.52305062e-02f, -3.63763422e-02f, -1.74699485e-01f,
  -4.09387872e-02f, 4.12988923e-02f, -2.76427455e-02f, -1.62195235e-01f, -1.32161751e-01f, -1.08108521e-01f, 1.93494901e-01f, 4.05375063e-02f, -1.53217494e-01f, 7.81501904e-02f,
  -1.62801191e-01f, -1.00551970e-01f, -1.29620478e-01f, -5.78111932e-02f, -1.02736883e-01f, -2.62629595e-02f, -3.68294306e-02f, 3.58482227e-02f, 3.46745886e-02f, -9.72076133e-02f,
  9.14799795e-02f, 4.53831404e-02f, -7.07443133e-02f, 1.06435448e-01f, -1.30106565e-02f, -8.22905153e-02f, -4.93689999e-03f, 2.41967309e-02f, -2.59231851e-02f, 9.36929360e-02f,
  -5.43485619e-02f, -7.56854862e-02f, 1.12792645e-02f, -2.36451328e-02f, 3.89759205e-02f, 5.32133654e-02f, -1.10353425e-01f, 1.08899556e-01f, 1.27254613e-03f, -5.01912758e-02f,
  8.11102465e-02f, 3.51993144e-02f, 2.61499099e-02f, -7.11822091e-03f, -1.00349538e-01f, -7.89370313e-02f, -3.30134220e-02f, -2.72850022e-02f, 8.90843421e-02f, 1.57041010e-03f,
  -1.34460881e-01f, -1.13677837e-01f, -6.41115308e-02f, 1.23754740e-02f, -1.01866415e-02f, 1.28912553e-02f, -5.58407828e-02f, -8.99475254e-03f, 2.62642931e-02f, -2.98997480e-02f,
  4.42425162e-02f, -5.82719930e-02f, -8.59642327e-02f, 3.86499688e-02f, -5.38924485e-02f, 1.80823773e-01f, -1.14755794e-01f, -7.05960393e-02f, -1.95746515e-02f, -1.88835375e-02f,
  -1.39497012e-01f, -2.30097249e-01f, -2.17116307e-02f, -7.90165514e-02f, 4.73423451e-02f, 1.37072231e-03f, -2.50313655e-02f, -2.43216921e-02f, 1.23490142e-02f, -7.49089941e-02f,
  -2.19877139e-02f, -5.23166917e-02f, -2.99939550e-02f, 8.33675638e-02f, 8.45829993e-02f, -7.16607571e-02f, 6.63346872e-02f, 4.07047905e-02f, 3.67256850e-02f, -4.30597514e-02f,
  3.91710848e-02f, -9.60464776e-03f, 5.00469469e-02f, 1.64450519e-02f, 5.45777492e-02f, 6.17971756e-02f, -2.73022857e-02f, 3.16902660e-02f, 4.34583649e-02f, 5.65299280e-02f,
  1.43679986e-02f, 4.55566496e-01f, 1.74452335e-01f, 1.82127550e-01f, -3.85416336e-02f, -2.70272374e-01f, -1.14050388e-01f, 5.81608750e-02f, 1.06371224e-01f, 1.06013767e-01f,
  -3.58201638e-02f, 2.99733311e-01f, -8.96018222e-02f, 1.54758051e-01f, -5.48550606e-01f, -2.68849194e-01f, -1.89815536e-01f, 7.31688440e-02f, 3.08690928e-02f, 1.87369827e-02f,
  -1.88372463e-01f, -7.54440650e-02f, -1.23435833e-01f, 4.48024645e-02f, 1.37833461e-01f, 1.75366715e-01f, -2.17796817e-01f, 1.44355327e-01f, 4.26230356e-02f, -1.19476533e-02f,
  -1.91620160e-02f, 2.58856535e-01f, 1.57331824e-02f, 1.48675712e-02f, -6.14369474e-02f, -5.56802265e-02f, 7.01138342e-04f, 5.38194478e-02f, -2.65224427e-02f, 1.33796064e-02f,
  7.04709664e-02f, -8.20376873e-02f, 5.87761179e-02f, 6.75928816e-02f, 9.64759961e-02f, 1.38699706e-03f, 6.36867583e-02f, 1.04974012e-03f, 9.97892171e-02f, 3.49171422e-02f,
  1.41432256e-01f, 4.81469706e-02f, 1.63915218e-03f, -1.93126053e-02f, -4.67654578e-02f, -5.69885690e-03f, -2.04976778e-02f, 6.59232885e-02f, -1.40645099e-03f, -4.42019626e-02f,
  3.40833049e-03f, 2.12226547e-02f, 3.66591103e-02f, -8.23079899e-04f, 4.67804857e-02f, -2.07318794e-02f, -4.74436022e-02f, 1.27753885e-02f, 3.19836736e-02f, -9.46104247e-03f,
  -6.73975199e-02f, 6.29772097e-02f, -2.65636574e-03f, 1.42716728e-02f, -9.01470259e-02f, 4.06488925e-02f, -8.88882726e-02f, 5.87550439e-02f, -1.14287987e-01f, 3.28127705e-02f,
  8.50484148e-02f, 1.46235107e-02f, 3.48490290e-02f, -1.64407700e-01f, 1.17122317e-02f, 3.14640650e-03f, 5.10592461e-02f, -3.32654198e-03f, 1.74257010e-02f, -9.76890847e-02f,
  -2.52692789e-01f, -5.01323566e-02f, -8.49473029e-02f, -8.19550976e-02f, 6.78900257e-02f, -4.86061387e-02f, 5.30277230e-02f, -1.85257487e-03f, -4.65641618e-02f, 7.00445287e-03f,
  -4.25489666e-03f, -5.85938096e-02f, -1.17817454e-01f, 1.81875527e-02f, -1.06641762e-01f, -7.10605979e-02f, 5.64990863e-02f, -1.50741346e-03f, -5.13686985e-02f, -9.33321659e-03f,
  1.14547595e-01f, 1.73759982e-02f, 9.65572055e-03f, 4.03493643e-03f, 8.41565058e-03f, -1.91126261e-02f, 1.40176281e-01f, 8.04615021e-02f, -1.25521445e-03f, -4.98415250e-03f,
  -6.12498283e-01f, -2.79257029e-01f, -6.88026771e-02f, 2.59578049e-01f, -1.91779941e-01f, -2.42376834e-01f, -8.08978900e-02f, -8.40843841e-02f, -1.34668887e-01f, 1.03500083e-01f,
  1.20453976e-01f, -1.20610863e-01f, -1.04217365e-01f, 2.42799327e-01f, 9.18172002e-02f, 6.30893037e-02f, 3.62550646e-01f, 1.27282679e-01f, 7.58529976e-02f, -7.75031373e-02f,
  1.06522121e-01f, 1.53540432e-01f, 3.14789146e-01f, 6.28614724e-02f, -1.67066306e-01f, 7.87152946e-02f, 2.34619081e-01f, -1.04974970e-01f, 3.10849458e-01f, 6.20063096e-02f,
  -1.80907443e-01f, -7.67669380e-02f, 3.54298167e-02f, -9.37862471e-02f, 8.31726268e-02f, 4.88965325e-02f, -4.91132103e-02f, 4.92954962e-02f, -2.16719750e-02f, 7.05832168e-02f,
  -1.33758500e-01f, 6.56835735e-02f, 5.00875749e-02f, 1.15485638e-01f, -5.89325540e-02f, -7.38803968e-02f, -3.65358144e-02f, -7.48846680e-02f, -8.66209194e-02f, -2.42062192e-02f,
  -9.52449739e-02f, -7.90032558e-04f, 4.54467162e-02f, -3.06418650e-02f, -3.85002457e-02f, 2.69861035e-02f, 1.13475561e-01f, 1.10859992e-02f, 3.83939371e-02f, 3.59987468e-02f,
  -1.51235946e-02f, 1.19091138e-01f, -1.17027566e-01f, -7.08426675e-03f, 9.58484504e-03f, 1.03150226e-01f, 6.31260797e-02f, 1.13405138e-01f, 8.28720406e-02f, -8.62303823e-02f,
  2.48810705e-02f, -2.88836230e-02f, 3.87027636e-02f, 5.94655750e-03f, 1.40415460e-01f, 4.06103171e-02f, 5.08021489e-02f, -9.71890688e-02f, -6.18395656e-02f, 5.35318181e-02f,
  -1.51587240e-02f, 1.72406342e-02f, -8.74950364e-02f, 9.14648827e-03f, -6.61478713e-02f, -1.37595949e-03f, 1.36464909e-01f, -2.65737455e-02f, -5.48006073e-02f, 6.95137754e-02f,
  -3.37764859e-01f, -8.17457028e-03f, -1.03019759e-01f, -1.66113704e-01f, 2.37797387e-02f, 2.26042289e-02f, -4.74977084e-02f, -1.96705442e-02f, -1.30369723e-01f, -7.16250166e-02f,
  6.47254363e-02f, 7.03772455e-02f, -1.82318334e-02f, -1.82519443e-02f, 9.75377932e-02f, -9.85073075e-02f, -5.61171360e-02f, -6.56363787e-03f, 2.47943494e-02f, -2.99412361e-03f,
  -9.27065313e-03f, -9.41671729e-02f, 1.12693742e-01f, -3.75806987e-02f, 1.45647496e-01f, -2.07092818e-02f, -9.85106528e-02f, 1.01069696e-01f, 7.85073936e-02f, 2.70732865e-02f,
  -3.01194992e-02f, 3.71024609e-02f, -2.17744663e-01f, -8.75735730e-02f, -5.00861146e-02f, -3.47511292e-01f, -2.33964562e-01f, 1.38611877e-02f, 8.69186670e-02f, 1.25454739e-01f,
  9.35545638e-02f, 3.32490318e-02f, 2.69487172e-01f, -6.14295602e-02f, -4.81393486e-02f, 1.68094307e-01f, -2.63270468e-01f, -1.45606771e-01f, 7.67923519e-02f, -1.07123286e-01f,
  2.86803823e-02f, 1.18644796e-01f, -8.74373764e-02f, 8.02843273e-02f, -1.19803332e-01f, 3.72310132e-02f, 4.59984913e-02f, 4.32287529e-02f, -1.50413007e-01f, 1.36407204e-02f,
  -1.19075932e-01f, 2.53328472e-01f, -8.87959301e-02f, 3.74205830e-03f, -8.32777023e-02f, -1.53175578e-03f, -1.49772108e-01f, -1.96918026e-02f, 2.90024616e-02f, -4.42680605e-02f,
  1.97070986e-02f, 6.34605736e-02f, -1.98462140e-03f, 8.23927000e-02f, -2.33940929e-02f, 9.17656999e-03f, 2.38303374e-02f, -1.25706196e-01f, 6.84257364e-03f, 1.45046469e-02f,
  2.12542824e-02f, -1.54597107e-02f, -5.25269695e-02f, 7.13210478e-02f, 7.45278075e-02f, 1.48062957e-02f, -1.07406229e-01f, -1.04050025e-01f, -4.38911095e-02f, 1.26021178e-02f,
  1.16062626e-01f, -1.02977827e-01f, -1.18533121e-02f, -3.77975814e-02f, 6.02791272e-02f, 3.70980753e-03f, 1.05273500e-02f, 1.62892640e-02f, 7.79126480e-04f, -1.05968609e-01f,
  -1.64918825e-01f, -4.48897891e-02f, 4.94449697e-02f, 2.34999433e-02f, 4.81596030e-02f, -6.86067268e-02f, -7.80469924e-02f, -1.78406220e-02f, -9.26564336e-02f, -4.53574285e-02f,
  3.73882800e-02f, -1.45835690e-02f, -4.92836088e-02f, -7.14843199e-02f, -1.02394268e-01f, 8.26315780e-04f, -3.83735038e-02f, -5.67987598e-02f, -7.72684887e-02f, -1.67412106e-02f,
  -4.79321741e-02f, 1.49609029e-01f, 1.93316657e-02f, 7.86952209e-03f, -5.47629111e-02f, -3.84229906e-02f, -2.14082841e-02f, -4.61234115e-02f, 7.20655844e-02f, 2.67370231e-02f,
  -5.31752184e-02f, -1.06905825e-01f, -9.75262746e-02f, -7.34989271e-02f, 4.50257361e-02f, -1.22749820e-01f, 2.53758896e-02f, -4.76053357e-02f, -2.10668445e-02f, -2.43967120e-02f,
  9.03281048e-02f, 1.52807562e-02f, 2.79942676e-02f, -4.47568372e-02f, 2.97890641e-02f, 4.48281877e-02f, -2.44200882e-02f, -1.74541902e-02f, 1.14794634e-01f, 2.55152304e-02f,
  -3.33794028e-01f, 1.95611432e-01f, -2.83228129e-01f, 4.51628044e-02f, 2.03332260e-01f, 3.09466511e-01f, -2.41214670e-02f, 2.01388579e-02f, -2.38393381e-01f, 1.42610356e-01f,
  1.57126024e-01f, -2.40544770e-02f, -1.48266733e-01f, 5.32608151e-01f, 3.29379231e-01f, 1.64293349e-01f, 3.44324678e-01f, 2.54771858e-01f, 2.04266846e-01f, 9.01501551e-02f,
  1.07972920e-01f, 5.44077635e-01f, 1.52133152e-01f, 4.30676877e-01f, 2.68380970e-01f, -6.97779357e-02f, 1.17261581e-01f, -1.29048228e-01f, 3.08741093e-01f, 1.95003942e-01f,
  6.41078725e-02f, -1.65222883e-01f, 1.45564857e-03f, -1.46313041e-01f, -1.91075783e-02f, -4.61727828e-02f, -7.49961734e-02f, 1.02644615e-01f, -1.75562739e-01f, -4.32287157e-02f,
  -7.47524500e-02f, 1.86456367e-02f, -1.74902529e-02f, 5.08945882e-02f, -1.64834186e-02f, 7.89712649e-03f, 5.90146929e-02f, 3.09544560e-02f, 1.38856824e-02f, 9.84057784e-03f,
  9.98553168e-03f, 1.03556462e-01f, 1.77694187e-02f, 5.28104603e-02f, 4.39004265e-02f, 5.90509502e-03f, 4.71289530e-02f, -3.69356573e-02f, 1.06721841e-01f, 7.21267685e-02f,
  3.98881435e-02f, -6.10701367e-02f, 7.04440102e-02f, 1.23719331e-02f, 1.29815668e-01f, 9.49420407e-02f, 8.48235935e-02f, 1.08057782e-01f, 5.82989454e-02f, 5.15032262e-02f,
  8.11414607e-03f, -4.34289016e-02f, -7.60770440e-02f, -3.38519886e-02f, 4.82300855e-02f, 7.19020441e-02f, 2.12284941e-02f, 8.36095121e-03f, -2.85937581e-02f, 1.40233785e-01f,
  -8.98821745e-03f, 2.28377953e-02f, -1.19697582e-02f, -4.96556722e-02f, 2.11082473e-02f, -2.90030260e-02f, -3.05146277e-02f, -5.57547472e-02f, 1.58019513e-02f, -8.22743550e-02f,
  1.43757150e-01f, -2.70453915e-02f, -2.97071249e-03f, 2.68523162e-03f, 8.88480432e-03f, 9.48080197e-02f, 6.65380955e-02f, 1.34140432e-01f, -3.95162962e-02f, -1.87660400e-02f,
  -1.28668034e-02f, -1.04462519e-01f, -4.44910526e-02f, 1.60551760e-02f, 3.01924273e-02f, 2.32330952e-02f, -6.63997307e-02f, -5.09154126e-02f, -4.01822925e-02f, 1.92112066e-02f,
  8.39496553e-02f, 1.83691960e-02f, -1.90286171e-02f, 7.90713206e-02f, 1.18538059e-01f, -3.60843800e-02f, 1.02897152e-01f, -1.02534620e-02f, 9.91975963e-02f, -6.38865074e-03f,
  4.24442530e-01f, 1.80960909e-01f, 4.08275306e-01f, 5.35590827e-01f, -5.58464527e-02f, -3.22435707e-01f, -1.22724557e-02f, 1.07177526e-01f, 5.30125201e-01f, -1.62155211e-01f,
  -1.15834177e-01f, 2.22284466e-01f, -1.85918212e-01f, 1.77627936e-01f, -2.44267806e-01f, -2.47103482e-01f, 1.31946430e-01f, 6.41062111e-02f, 8.15542936e-02f, 1.56911984e-01f,
  1.69118166e-01f, -2.73417443e-01f, 6.56701177e-02f, -2.51023948e-01f, 2.06960782e-01f, 2.14375138e-01f, -8.33209828e-02f, -2.23206673e-02f, 9.94132906e-02f, -1.41405612e-01f,
  -8.35830793e-02f, 9.67690721e-02f, 8.62943828e-02f, -5.88777773e-02f, 5.78542762e-02f, -1.35335207e-01f, -8.05811733e-02f, -2.33922139e-01f, 7.73876682e-02f, 9.50981230e-02f,
  1.04395533e-02f, -5.89633025e-02f, 4.18146960e-02f, -2.91439071e-02f, 1.27929121e-01f, 1.04149401e-01f, 2.27128938e-01f, 1.22193687e-01f, 5.41360937e-02f, 3.88169587e-02f,
  1.45917505e-01f, 8.32460970e-02f, 1.82024628e-01f, -8.01370759e-03f, 1.32956356e-01f, 1.02469049e-01f, -3.72759029e-02f, 8.21618065e-02f, 7.68905953e-02f, 9.04352218e-02f,
  -1.70913532e-01f, -3.07012573e-02f, -3.96747189e-03f, 6.47255257e-02f, 6.46284316e-03f, -1.72535772e-04f, 3.82239850e-05f, -1.19381353e-01f, 1.49128124e-01f, 1.23821571e-03f,
  8.09652433e-02f, 1.26781046e-01f, 3.99001986e-02f, 2.56579760e-02f, -1.09018134e-02f, 8.88067763e-04f, -8.24821889e-02f, -4.99323010e-02f, 4.56711203e-02f, -1.00067174e-02f,
  -1.25427812e-01f, -5.45522943e-02f, 9.92196500e-02f, -1.06704257e-01f, -8.07259977e-02f, 1.15185969e-01f, 5.95650487e-02f, 3.18367146e-02f, -4.08060960e-02f, 1.37563311e-02f,
  -7.47099593e-02f, -9.69667546e-03f, -6.80003986e-02f, -8.95009935e-02f, 1.85815319e-02f, 1.05120521e-02f, -5.40308319e-02f, -1.06864469e-03f, 4.59876806e-02f, -1.13693953e-01f,
  -2.37221010e-02f, 1.17727004e-01f, -2.97268610e-02f, -7.70729035e-02f, 2.19121464e-02f, 6.78293854e-02f, 9.17779729e-02f, 3.56893577e-02f, -3.75618376e-02f, 2.36825570e-02f,
  3.39094986e-04f, -5.07571287e-02f, 1.17187478e-01f, 9.21409354e-02f, -1.10196117e-02f, 5.72928740e-03f, -1.24950744e-02f, 8.76777992e-02f, 3.54988836e-02f, 5.38229346e-02f,
  -3.41945380e-01f, 1.43815249e-01f, 2.58239806e-01f, -2.27939442e-01f, 3.62341404e-01f, 3.36378098e-01f, -7.21966028e-02f, 1.78821653e-01f, -1.13247307e-02f, -2.95286417e-01f,
  -1.47867486e-01f, -2.33270228e-01f, 1.58460751e-01f, -1.49007559e-01f, -2.21912414e-02f, 1.45338640e-01f, -1.16923615e-01f, -1.87897936e-01f, 2.41215050e-01f, -4.94147688e-02f,
  7.43985735e-03f, -3.15531269e-02f, 1.35368153e-01f, 1.93036407e-01f, 1.02958351e-01f, -5.09361513e-02f, -2.72856236e-01f, 1.67893186e-01f, -1.92169532e-01f, -2.33500171e-02f,
  2.67418344e-02f, -1.36244729e-01f, 8.27059299e-02f, 5.10473177e-02f, 2.85616890e-03f, -9.46877226e-02f, -4.51458581e-02f, 5.05851544e-02f, -5.12608886e-03f, 8.66353661e-02f,
  -6.73659071e-02f, 1.61927179e-01f, -1.05653532e-01f, 4.72020395e-02f, 7.75624588e-02f, 1.39813244e-01f, 1.26914412e-01f, 7.74507150e-02f, 1.29130065e-01f, 1.06525578e-01f,
  9.26462784e-02f, 1.06339253e-01f, 2.71155257e-02f, -1.86005700e-02f, 1.16234966e-01f, 3.39050479e-02f, 5.01251742e-02f, -6.58889860e-02f, 4.67723757e-02f, -2.97448598e-02f,
  1.04402388e-02f, 1.87858045e-02f, 4.62592691e-02f, 1.86050087e-02f, 5.35479793e-03f, 3.71796936e-02f, -3.53450663e-02f, -3.92110758e-02f, -1.86339617e-02f, 6.98491260e-02f,
  4.47977427e-03f, 2.93193031e-02f, -2.64389557e-03f, 2.71687750e-03f, -6.45310357e-02f, -3.33139747e-02f, 3.41663137e-02f, 7.21432269e-02f, -2.75075007e-02f, -9.40526724e-02f,
  -1.28647834e-02f, -8.11603665e-02f, 1.53677464e-02f, 1.66382372e-01f, 4.30068076e-02f, 9.62272510e-02f, -1.16678579e-02f, 1.19228363e-01f, 1.00124981e-02f, 4.59435321e-02f,
  -1.27903819e-01f, -3.27711642e-01f, -1.94277614e-02f, 5.80070866e-03f, -3.74351032e-02f, 3.49587835e-02f, 5.53852059e-02f, 6.09797649e-02f, -6.20479211e-02f, 1.49474204e-01f,
  -9.26667883e-04f, -1.02869652e-01f, 1.40637038e-02f, 5.34397960e-02f, -3.00598871e-02f, 1.05971135e-01f, -7.09387809e-02f, -6.72622472e-02f, -4.38322499e-02f, -9.57902670e-02f,
  5.60415052e-02f, -6.63022371e-03f, -3.07216048e-02f, 6.31164834e-02f, -2.82011218e-02f, -6.96371198e-02f, -3.10218874e-02f, -4.22642427e-03f, 1.24537833e-02f, 2.47716741e-03f,
  2.74394751e-01f, -4.95479435e-01f, 2.51043320e-01f, 4.22925323e-01f, 2.27864698e-01f, -8.62408504e-02f, 2.76351213e-01f, -2.26301719e-02f, 5.27848005e-02f, -3.77477199e-01f,
  1.72361359e-01f, 1.93791352e-02f, -3.47639434e-02f, -5.51124476e-03f, 3.57811958e-01f, -5.75256161e-02f, 6.46062717e-02f, -1.95044074e-02f, 9.57107358e-03f, -1.77852623e-02f,
  2.56561816e-01f, 2.07813848e-02f, 2.72418410e-01f, -2.42364481e-01f, 1.42670432e-02f, -5.05219512e-02f, 1.23607844e-01f, 1.33290933e-02f, -5.20733669e-02f, 3.78917307e-02f,
  -1.84437305e-01f, -1.44900382e-02f, -4.57934663e-02f, -1.42340913e-01f, -7.75083303e-02f, 5.71446717e-02f, 5.27041778e-02f, 1.07167065e-01f, 4.14815508e-02f, -3.68426107e-02f,
  -8.80386755e-02f, 1.62706412e-02f, -3.28992344e-02f, -2.38042455e-02f, -5.51099181e-02f, -3.29091810e-02f, -9.56997462e-03f, -3.02977581e-02f, 3.70475799e-02f, 1.27385974e-01f,
  5.17045856e-02f, -2.46413648e-02f, 8.90852511e-02f, -5.51577359e-02f, 1.56409428e-01f, 8.27885345e-02f, 1.38994426e-01f, 5.02470024e-02f, -5.60081042e-02f, 4.03016768e-02f,
  8.75998735e-02f, -1.95506029e-03f, 4.56228517e-02f, 3.58025096e-02f, 1.15841990e-02f, 1.34423539e-01f, -5.21762259e-02f, -1.94393508e-02f, 1.72554553e-02f, -2.39426289e-02f,
  3.11846808e-02f, -2.80793365e-02f, -5.89112565e-02f, -6.05726317e-02f, 2.58993357e-03f, 1.21404313e-01f, 6.10776357e-02f, -4.27061394e-02f, -5.09810522e-02f, 2.42848247e-02f,
  -6.07904159e-02f, 4.37842906e-02f, -1.43366277e-01f, 1.16218226e-02f, -6.54619485e-02f, 7.41181821e-02f, -5.05318157e-02f, -3.53870839e-02f, 6.36634901e-02f, 7.21012009e-03f,
  -3.42449158e-01f, -3.39675158e-01f, -1.11414224e-01f, -6.33647889e-02f, -1.07497983e-01f, -5.77947684e-02f, 1.92419700e-02f, -1.86110344e-02f, -1.54857323e-01f, -1.48239322e-02f,
  -4.86769490e-02f, 1.84185896e-02f, -7.28566125e-02f, 2.13083681e-02f, -4.37023714e-02f, 2.48449035e-02f, 8.65032375e-02f, -1.04331143e-01f, 1.17563661e-02f, -4.68890294e-02f,
  -6.06999286e-02f, -3.27289179e-02f, 1.76083762e-02f, 4.73770872e-03f, 3.84849682e-02f, 8.31780396e-03f, -1.72061920e-02f, 5.55510186e-02f, 2.20785774e-02f, -2.60837208e-02f,
  -8.21047947e-02f, 2.44474471e-01f, 1.32841974e-01f, 1.16964234e-02f, -1.47477850e-01f, 4.20242362e-02f, 1.35261834e-01f, 8.75036605e-03f, 1.43669724e-01f, 2.54121363e-01f,
  -1.16842918e-01f, 2.46127293e-01f, -1.45619754e-02f, -1.16137946e-02f, -4.93610799e-01f, -1.20231077e-01f, -5.56699336e-02f, 3.91097851e-02f, -1.35448247e-01f, 1.37315974e-01f,
  -1.16545878e-01f, -2.19205573e-01f, -6.60111532e-02f, -9.28939804e-02f, 6.69952482e-02f, 1.16303511e-01f, -1.99997112e-01f, -9.80913639e-02f, 8.50729737e-03f, -1.92234695e-01f,
  5.46054728e-02f, -3.01536601e-02f, 9.32405517e-02f, 1.01383574e-01f, 7.61383101e-02f, 2.60570403e-02f, 6.09279983e-02f, -1.28386095e-01f, -6.13393299e-02f, 1.49650395e-01f,
  4.37440760e-02f, 6.35090247e-02f, 5.09951748e-02f, -8.85961205e-02f, -2.29841061e-02f, 5.22253364e-02f, 1.17131062e-01f, 3.91697995e-02f, 1.20819345e-01f, -5.03577739e-02f,
  1.30325168e-01f, 2.95992177e-02f, 4.21757996e-02f, 2.91055720e-02f, -1.08253919e-02f, 8.40852968e-03f, 9.51702520e-02f, -1.95593107e-02f, 1.64234400e-01f, -2.49398965e-02f,
  -7.37788528e-02f, 8.19685906e-02f, 4.93481979e-02f, 5.52696101e-02f, -8.17400590e-02f, -1.80818569e-02f, -1.79087128e-02f, -9.25100967e-02f, -2.04018205e-02f, -7.38217030e-03f,
  -5.16827684e-03f, 2.82827243e-02f, 4.43981513e-02f, 5.54498658e-03f, -6.90321764e-03f, 8.02105367e-02f, -5.95405363e-02f, 4.53019626e-02f, 6.14795871e-02f, 1.91149593e-03f,
  -4.29020301e-02f, -2.27391254e-02f, 1.19583219e-01f, 5.56169786e-02f, -1.22486670e-02f, -2.86438689e-02f, 2.85121687e-02f, 6.30759597e-02f, 1.02048833e-02f, -2.79457141e-02f,
  9.55172069e-03f, -8.06931779e-02f, 2.43961029e-02f, 5.54943793e-02f, 1.26837036e-02f, -1.76352169e-02f, -1.02403991e-01f, 6.80011660e-02f, -4.12066206e-02f, 5.31699322e-02f,
  6.37783334e-02f, 1.12420753e-01f, 1.07415684e-01f, -1.07640520e-01f, -6.10434115e-02f, 2.78974827e-02f, 9.01063085e-02f, 4.05101143e-02f, 4.34005447e-02f, 4.56549833e-03f,
  8.75422657e-02f, 3.80830839e-02f, 4.58341651e-02f, 1.07138820e-01f, 6.63021579e-02f, 2.89296694e-02f, -6.35513812e-02f, -4.26683575e-03f, -7.44336322e-02f, 5.64233921e-02f,
  -4.67677414e-01f, 3.79556298e-01f, 4.27481346e-02f, -3.98338199e-01f, 1.93580911e-01f, 1.20450892e-02f, -2.80270725e-01f, 9.65828821e-02f, 3.50587349e-03f, -2.70699076e-02f,
  -6.17998391e-02f, 7.81122886e-04f, 2.87899017e-01f, -1.06153473e-01f, -1.01201780e-01f, 2.06392378e-01f, -2.61269420e-01f, -1.76272482e-01f, 1.08607970e-01f, -6.42695799e-02f,
  -9.16080028e-02f, -9.77581516e-02f, -1.12402022e-01f, 1.81909785e-01f, -2.17065811e-01f, -1.74025789e-01f, -1.87405080e-01f, 1.65308982e-01f, -2.27911666e-01f, 1.00741826e-01f,
  -1.69878632e-01f, -1.15871832e-01f, -2.90757030e-01f, -9.99508500e-02f, -1.21226825e-01f, -3.15246694e-02f, -1.23760164e-01f, 4.46791854e-03f, -7.46848946e-03f, -4.59233634e-02f,
  2.72384174e-02f, 1.31895870e-01f, 5.71007142e-03f, 4.96749915e-02f, -4.07152139e-02f, 5.37837390e-03f, 2.51491480e-02f, -7.22308531e-02f, 7.05807284e-03f, 6.00274354e-02f,
  1.78387482e-02f, 6.42999336e-02f, -8.44793618e-02f, -5.98205142e-02f, 1.22090150e-02f, -1.08790353e-01f, -4.11203280e-02f, 4.26274985e-02f, -1.54989719e-01f, -8.75371248e-02f,
  1.90393941e-03f, -8.94043874e-03f, -3.28079164e-02f, -7.80569166e-02f, 6.06656261e-02f, 9.00801867e-02f, -3.64237241e-02f, 2.23152060e-02f, -8.24813992e-02f, -2.03136262e-02f,
  5.08460887e-02f, 5.91303641e-03f, -5.73785789e-03f, -2.76662409e-02f, -8.68653879e-02f, -1.03858270e-01f, -7.49521032e-02f, 3.06308810e-02f, 2.90561803e-02f, -1.15705384e-02f,
  -7.41049871e-02f, 2.15113703e-02f, 8.34020786e-03f, -3.90864573e-02f, 3.81390704e-03f, 5.89743406e-02f, 1.87768228e-02f, 2.89414451e-02f, -3.76856923e-02f, 1.22466072e-01f,
  -2.83014655e-01f, -2.75909334e-01f, -1.49465770e-01f, -1.60344288e-01f, -4.83257361e-02f, 1.61954314e-02f, 2.38597830e-04f, -9.57057998e-02f, -1.13174848e-01f, -2.67179310e-02f,
  -9.35393909e-05f, -1.12122878e-01f, -1.67150386e-02f, -8.35351720e-02f, 3.86221497e-03f, -5.56984171e-02f, -6.17489293e-02f, -1.25860170e-01f, -1.77100062e-01f, 1.20898215e-02f,
  -4.34450917e-02f, -4.86776000e-03f, 9.07104611e-02f, 4.17948747e-03f, -6.60816068e-03f, -1.24886952e-01f, 7.57028302e-03f, 3.20297368e-02f, 4.66577671e-02f, 9.23215374e-02f,
  -2.52676964e-01f, 1.68180913e-02f, -6.80744573e-02f, 3.19003277e-02f, 8.88990536e-02f, -1.26481980e-01f, 8.42703581e-02f, -2.13894874e-01f, 1.13361657e-01f, -1.88192546e-01f,
  -7.94065297e-02f, -1.09669060e-01f, -1.55962408e-01f, -8.95196274e-02f, -3.18540186e-01f, -1.16346881e-01f, -1.82674658e-02f, 1.93463184e-03f, 1.06704973e-01f, -2.13949233e-01f,
  -7.00106919e-02f, -9.03471261e-02f, -2.38085091e-01f, -1.40761351e-02f, 2.40141097e-02f, 3.01195860e-01f, 1.03192069e-01f, 2.08531573e-01f, 1.69826418e-01f, 2.15592533e-01f,
  2.34173238e-02f, 7.03357439e-03f, -2.41899434e-02f, 1.40371233e-01f, -9.14601162e-02f, -8.27582479e-02f, 1.32897899e-01f, 2.21156720e-02f, 1.41554475e-01f, -7.44047062e-03f,
  5.42208366e-03f, 1.50921375e-01f, 7.18229786e-02f, -1.04088299e-01f, 9.56589878e-02f, 5.69298156e-02f, 6.19800910e-02f, -8.54208097e-02f, 8.99294242e-02f, -1.14771076e-01f,
  -7.15598762e-02f, 8.20710324e-03f, -3.05879414e-02f, 2.23996788e-01f, 1.69550672e-01f, 2.11081088e-01f, 9.14655849e-02f, 4.58646566e-02f, 1.60664812e-01f, 1.53704882e-01f,
  -1.02162860e-01f, 3.65750380e-02f, -1.02692880e-01f, -1.09069832e-01f, -1.00497082e-02f, 9.18811411e-02f, 1.32012535e-02f, -1.14059776e-01f, 7.15774670e-02f, 7.94845670e-02f,
  1.34410039e-01f, 1.02401704e-01f, 6.18745126e-02f, -3.46631221e-02f, -2.49801837e-02f, -1.59591854e-01f, -9.61489305e-02f, 9.95937213e-02f, -1.79698002e-02f, -1.90968573e-01f,
  -1.37876555e-01f, 6.99726641e-02f, 1.13314375e-01f, 2.10959446e-02f, -5.31930178e-02f, -3.59620936e-02f, 4.07317020e-02f, -9.55304205e-02f, -1.50922745e-01f, -4.00725156e-02f,
  9.99788791e-02f, 2.35430703e-01f, 7.09609911e-02f, 1.14326142e-01f, 2.24747937e-02f, -1.48666441e-01f, 5.66618368e-02f, 5.35758920e-02f, 1.21260934e-01f, -9.96212438e-02f,
  -5.10055609e-02f, 1.51179314e-01f, 3.67589816e-02f, -4.37641479e-02f, -1.16362078e-02f, -2.61514857e-02f, 8.25697109e-02f, 1.17323272e-01f, 1.88283131e-01f, 7.50139505e-02f,
  -9.39415023e-02f, -7.09681660e-02f, -9.31226686e-02f, 9.19578448e-02f, 3.03788520e-02f, 2.16817390e-02f, -1.11620553e-01f, -5.65469563e-02f, 8.79145637e-02f, 1.59942046e-01f,
  1.32638007e-01f, 1.71715897e-02f, -2.65411109e-01f, -7.20195621e-02f, 8.61084759e-02f, 9.19302031e-02f, 5.18743582e-02f, 6.84011951e-02f, -3.99229908e-03f, 3.66031289e-01f,
  2.74822235e-01f, -2.31858641e-02f, 1.09884664e-01f, 2.74662256e-01f, 1.16936632e-01f, 9.78054255e-02f, 2.19683766e-01f, 1.16759710e-01f, 9.44600906e-03f, 9.93414000e-02f,
  1.05639093e-01f, 3.05978179e-01f, -3.68151255e-02f, 1.13053352e-01f, 1.78588882e-01f, -1.53606519e-01f, 2.14150101e-01f, -1.73165277e-01f, 1.10304281e-01f, 4.24643271e-02f,
  -3.34785180e-03f, 3.31708454e-02f, -9.89343226e-03f, -9.19156596e-02f, -4.31418419e-02f, -2.11377311e-02f, -6.60755811e-03f, -2.60362644e-02f, -9.11303982e-02f, -3.11615448e-02f,
  3.96092758e-02f, -4.07629274e-02f, -3.66105624e-02f, -1.14664016e-02f, -4.36617155e-03f, 1.13455793e-02f, -1.46083999e-03f, 4.90811514e-03f, -5.61691895e-02f, 5.47761992e-02f,
  -9.17063188e-03f, -7.86456466e-03f, 1.00067191e-01f, 2.98724906e-03f, -2.74620801e-02f, 1.75738502e-02f, -7.29408786e-02f, 5.82900271e-03f, 3.49146165e-02f, 2.93727145e-02f,
  1.04524679e-01f, 1.43790888e-02f, 8.78553241e-02f, 1.08485930e-02f, -3.63594703e-02f, -1.27465241e-02f, 6.41036332e-02f, 2.67500663e-03f, -5.48182577e-02f, -1.07405186e-02f,
  -1.61706023e-02f, -6.62210733e-02f, 2.87317745e-02f, 8.99086818e-02f, 1.32894114e-01f, -7.88580850e-02f, -5.88696897e-02f, 2.10997146e-02f, 3.90319526e-02f, -9.05693509e-03f,
  -3.66420336e-02f, 2.58138347e-02f, -4.06451039e-02f, -2.49923803e-02f, -6.52705505e-02f, 8.09952170e-02f, 1.25342801e-01f, 9.44512486e-02f, -1.41227404e-02f, -1.92912947e-02f,
  7.68711641e-02f, 1.59924626e-01f, -8.82594287e-03f, -1.12154730e-01f, -1.09404601e-01f, 1.15449205e-01f, -4.54555359e-03f, -4.28895392e-02f, 3.55568565e-02f, 5.96100464e-02f,
  4.78855632e-02f, -4.18711863e-02f, 6.22335076e-02f, -2.68384330e-02f, -1.38255939e-01f, 1.19377568e-01f, 9.39809009e-02f, -1.40200481e-01f, -9.05990694e-03f, 3.37627120e-02f,
  3.15200873e-02f, 4.34290525e-03f, -3.39941978e-02f, -5.23323640e-02f, 1.62599981e-02f, 5.78356087e-02f, 4.40361649e-02f, -3.38970870e-02f, 8.75449702e-02f, 2.29439307e-02f,
  2.39022166e-01f, 4.66645002e-01f, 3.09268177e-01f, 2.72886813e-01f, -2.84504324e-01f, -1.64837196e-01f, -8.46438576e-03f, 7.52499746e-03f, 2.80018523e-02f, 1.82757914e-01f,
  -1.87082738e-01f, 3.10337305e-01f, -1.63789261e-02f, 2.21435204e-01f, -1.70492560e-01f, -6.27162233e-02f, 2.64399052e-01f, 1.03452906e-01f, -1.13225682e-02f, 2.57144153e-01f,
  5.37024066e-02f, -3.20833698e-02f, 1.19111583e-01f, -1.73704654e-01f, 2.51883775e-01f, 1.27535477e-01f, -1.28929511e-01f, -1.76972255e-01f, 1.33962676e-01f, -9.49957967e-02f,
  -7.23981783e-02f, 1.00335747e-01f, 1.28659412e-01f, -1.61438528e-02f, 9.67655182e-02f, 5.85832968e-02f, 3.93646620e-02f, -2.97441501e-02f, -5.90650029e-02f, 5.32828383e-02f,
  1.76459461e-01f, 1.88526604e-02f, 4.80361842e-02f, -4.58347760e-02f, 9.25762579e-02f, 1.03139319e-02f, 6.69036657e-02f, 8.14473908e-03f, 3.73524167e-02f, 1.80674165e-01f,
  1.41264573e-01f, 9.68576223e-02f, 1.38683155e-01f, 1.03435315e-01f, 3.26514617e-02f, -1.55750904e-02f, 6.70698807e-02f, 1.34735376e-01f, 1.10283747e-01f, 5.11064008e-02f,
  1.14225544e-01f, -5.38602173e-02f, -1.69062000e-02f, -9.20437425e-02f, -5.84052689e-02f, -3.27554494e-02f, -7.01983795e-02f, -9.80589986e-02f, -6.21363893e-02f, 1.94589756e-02f,
  -8.37336481e-02f, 6.24672920e-02f, -1.53103784e-01f, -2.08917782e-02f, 5.70708402e-02f, -8.53504520e-04f, -9.40574259e-02f, 1.80462841e-02f, 6.90820888e-02f, 7.94768892e-03f,
  -1.03389658e-01f, -7.30262324e-02f, -2.84767672e-02f, -5.39030097e-02f, -7.68429637e-02f, 1.09612998e-02f, -8.77033826e-03f, 8.07850659e-02f, -1.20110676e-01f, 4.31336649e-02f,
  9.05788541e-02f, 1.94992229e-01f, 2.88820360e-02f, -1.47497654e-02f, 5.07432595e-02f, 8.57391655e-02f, 3.03921867e-02f, 1.04038090e-01f, 8.90441015e-02f, 4.60023945e-03f,
  1.48154750e-01f, 1.97618846e-02f, 1.02386973e-03f, -7.31334239e-02f, 3.91404610e-03f, 3.81513909e-02f, 4.88439016e-02f, -1.11757100e-01f, 6.96736434e-03f, 4.43919487e-02f,
  2.83295568e-02f, -4.84283678e-02f, 1.66980699e-01f, 1.17637860e-02f, 9.00786296e-02f, 8.28235298e-02f, -2.75367275e-02f, 3.80032137e-02f, 7.32429177e-02f, 3.95473950e-02f,
  3.04339558e-01f, 2.13814095e-01f, 7.42736533e-02f, 1.43776149e-01f, -1.55169427e-01f, -1.45211697e-01f, -1.64124236e-01f, 4.89850231e-02f, -1.30218372e-01f, 4.99150380e-02f,
  1.01010790e-02f, 1.69140875e-01f, -7.56088272e-02f, 2.51115739e-01f, 1.59987167e-01f, -4.13500406e-02f, 2.30945989e-01f, 1.22094192e-01f, 4.10683826e-02f, 2.04758584e-01f,
  6.68429509e-02f, 1.26131013e-01f, 1.12913221e-01f, 1.58545986e-01f, 2.49444932e-01f, 1.44853398e-01f, 9.15343538e-02f, -8.58725086e-02f, 1.99229345e-01f, 6.05555847e-02f,
  -3.70094255e-02f, 7.56695867e-02f, 2.25854907e-02f, -3.78989466e-02f, -2.56466735e-02f, 2.43067350e-02f, -2.87454762e-02f, 1.14990517e-01f, -7.39423186e-02f, 2.23305135e-04f,
  9.03104693e-02f, -3.35900746e-02f, 5.69379702e-02f, -1.07679097e-02f, 7.39321932e-02f, 1.25871534e-02f, 4.42811437e-02f, -5.51420487e-02f, -4.06674221e-02f, 1.40790284e-01f,
  5.24984002e-02f, 7.85774812e-02f, 9.38853770e-02f, 4.40260582e-02f, -2.91563030e-02f, -9.22443494e-02f, 1.55771496e-02f, 2.59084515e-02f, 6.15862906e-02f, 1.55487461e-02f,
  1.12850092e-01f, -5.33641800e-02f, -4.16855775e-02f, -1.02226138e-02f, -4.09213975e-02f, -2.92088445e-02f, -1.03569841e-02f, 4.15345691e-02f, -4.85973842e-02f, 7.19669554e-03f,
  -5.09899668e-02f, 4.63155545e-02f, -8.36460590e-02f, -8.05087667e-03f, 4.56885174e-02f, -1.24674216e-02f, -8.88563786e-03f, 4.44426872e-02f, 2.97049843e-02f, -1.91664565e-02f,
  -4.08468321e-02f, -1.25192618e-02f, -6.60945028e-02f, 8.99782777e-03f, -4.79338802e-02f, 2.08552442e-02f, 4.01102193e-02f, 5.25224209e-02f, -8.16078261e-02f, -2.37521250e-02f,
  5.90915494e-02f, 1.25261307e-01f, -8.78143907e-02f, -9.58909839e-02f, -4.77486588e-02f, 7.04002604e-02f, -1.95466280e-02f, 1.18223786e-01f, 3.96924578e-02f, 3.82838957e-02f,
  8.31224173e-02f, -7.78009519e-02f, -6.57967478e-02f, -1.81487408e-02f, 3.93058471e-02f, -2.77650561e-02f, 5.26110977e-02f, -1.57474458e-01f, -1.41072483e-03f, 1.15461618e-01f,
  9.49953347e-02f, -5.79638965e-03f, 1.15841068e-01f, -9.76809412e-02f, 1.96715295e-02f, 7.83084426e-03f, 2.63119303e-02f, 4.59868610e-02f, 1.16622128e-01f, -3.08307502e-02f,
  -1.32572696e-01f, -2.23066285e-01f, -2.36524016e-01f, 2.78731048e-01f, 1.97176844e-01f, 5.77498339e-02f, 6.65059686e-02f, 1.03364453e-01f, -5.31872064e-02f, 1.54590428e-01f,
  2.53078669e-01f, -4.17060673e-01f, -1.20886207e-01f, 2.41310745e-01f, -8.61258805e-02f, -2.32136965e-01f, 2.64780968e-01f, 9.02789384e-02f, -1.54890597e-01f, -1.06546551e-01f,
  1.55289471e-02f, 2.93188930e-01f, -3.68981846e-02f, -8.27547279e-04f, 1.37395963e-01f, -9.85101089e-02f, 2.51903027e-01f, -9.62867811e-02f, 2.27205724e-01f, 1.59374829e-02f,
  9.13270488e-02f, -4.93612364e-02f, -5.40195182e-02f, -9.34263989e-02f, -5.37958927e-03f, 8.00967291e-02f, 7.37572908e-02f, -8.89530629e-02f, -8.34720489e-03f, -8.40537548e-02f,
  -1.29521238e-02f, 5.93349189e-02f, -7.22302049e-02f, -8.32309052e-02f, 7.94759169e-02f, 5.13057858e-02f, -8.17247108e-02f, 2.28729262e-03f, -1.06573841e-02f, -1.89000607e-01f,
  -3.72323431e-02f, 8.85384157e-02f, 1.37994066e-01f, 2.33839769e-02f, -3.29051204e-02f, -5.28092086e-02f, -9.82184485e-02f, -1.09406643e-01f, 1.36813626e-01f, -7.23134279e-02f,
  -7.73876673e-03f, 2.83153243e-02f, 2.52164602e-02f, 4.76314761e-02f, -7.66621605e-02f, 1.57620218e-02f, 4.04188819e-02f, -1.21797938e-02f, -1.73758879e-01f, -8.29139650e-02f,
  8.55650902e-02f, -6.28189817e-02f, -5.93157262e-02f, 8.08204934e-02f, 4.45625409e-02f, 4.33073081e-02f, -7.46729178e-03f, 1.77506618e-02f, 2.81110071e-02f, 1.08459331e-02f,
  7.18678012e-02f, 3.50501947e-02f, -8.64457265e-02f, 9.07030404e-02f, 8.90152901e-02f, -8.68442208e-02f, 1.20099336e-01f, -2.76499018e-02f, -2.65356358e-02f, 1.30887419e-01f,
  5.48404828e-02f, -1.99458688e-01f, -7.90175796e-02f, 2.92238779e-02f, -1.22946553e-01f, 1.60847027e-02f, -9.07036588e-02f, -1.29755780e-01f, -5.47548309e-02f, -7.62501508e-02f,
  -9.18251928e-03f, 1.16456941e-01f, 1.48103431e-01f, -7.73962913e-03f, 1.68150708e-01f, -2.11117230e-02f, 1.22639783e-01f, 1.51066184e-02f, 2.06480160e-01f, -4.58072349e-02f,
  1.22531101e-01f, -8.17378014e-02f, 8.59346166e-02f, 4.97112721e-02f, 9.66410190e-02f, -1.09519754e-02f, -6.52496889e-02f, -4.56755161e-02f, 5.83033487e-02f, 3.13269645e-02f,
  3.61246526e-01f, -3.30622017e-01f, -3.27049196e-01f, -2.48369370e-02f, 1.67276680e-01f, 1.73563763e-01f, -3.97493280e-02f, 1.74154118e-01f, -1.13046110e-01f, 1.03895143e-02f,
  1.45252079e-01f, -1.41546205e-01f, -3.10208082e-01f, 1.53653920e-01f, 2.11878657e-01f, -2.08221808e-01f, 2.36293763e-01f, 1.83361277e-01f, 3.43916789e-02f, 1.56042337e-01f,
  1.43326685e-01f, 3.90050203e-01f, -7.25154877e-02f, 2.94835865e-01f, 2.33271897e-01f, 1.48606613e-01f, 2.38006070e-01f, -4.35888916e-02f, 2.66452760e-01f, 1.35527194e-01f,
  -1.77883618e-02f, -1.19052134e-01f, -1.20800186e-03f, 2.79560480e-02f, -2.69738529e-02f, 3.88535904e-03f, 3.86709757e-02f, 7.49173164e-02f, 6.28606379e-02f, -1.46224936e-02f,
  1.58652570e-02f, 9.70793739e-02f, 8.89507011e-02f, 5.29146865e-02f, 9.56102535e-02f, 2.54699551e-02f, 3.56116444e-02f, -5.53870611e-02f, 5.71909323e-02f, -9.37553570e-02f,
  -1.08464681e-01f, 2.40057092e-02f, 4.58702669e-02f, -2.85507031e-02f, -1.18213847e-01f, 3.74195836e-02f, -4.32002731e-02f, -1.31901547e-01f, 9.59432311e-03f, -4.54649562e-03f,
  1.44144952e-01f, -8.21950957e-02f, 1.83080845e-02f, -6.25160411e-02f, -6.44688457e-02f, -4.96098176e-02f, 1.57539267e-02f, -2.39053331e-02f, -5.37879318e-02f, -6.43676147e-02f,
  3.46271396e-02f, 1.52611779e-02f, 6.03658743e-02f, 6.98176250e-02f, 4.70543839e-02f, 2.12390199e-02f, 4.70456183e-02f, 7.82972127e-02f, -7.51495510e-02f, -5.84028102e-02f,
  9.63643193e-02f, 4.41715419e-02f, 1.14779677e-02f, 7.05411211e-02f, 1.06787249e-01f, -5.50873317e-02f, 1.86863891e-03f, 7.73390234e-02f, -2.81327851e-02f, 1.87399259e-04f,
  -8.57831836e-02f, -9.35255215e-02f, -3.61712947e-02f, 4.51916531e-02f, -1.17093481e-01f, 9.75699946e-02f, 1.15093812e-02f, 4.62286435e-02f, 6.09788261e-02f, 4.49045561e-02f,
  9.68376845e-02f, 2.89106555e-02f, -4.23313212e-03f, -1.58414226e-02f, 3.60632390e-02f, -2.59141810e-02f, 1.15412183e-01f, -5.47319418e-03f, 1.45095974e-01f, -9.27677844e-03f,
  2.54615899e-02f, 5.97999878e-02f, 1.75711997e-02f, -1.06064022e-01f, -5.71204759e-02f, -4.46999632e-02f, 5.27967624e-02f, -3.18566151e-02f, 8.24470520e-02f, -1.20401353e-01f,
  -3.14542413e-01f, 2.10675091e-01f, 1.01061054e-01f, 1.66448176e-01f, -2.25817919e-01f, -3.10482770e-01f, -1.03641331e-01f, 9.31824520e-02f, -9.98708382e-02f, 1.22078225e-01f,
  1.78463116e-01f, -7.14252815e-02f, 2.89001524e-01f, 6.15832098e-02f, -1.48010656e-01f, 9.60834920e-02f, 1.80006728e-01f, -2.07872670e-02f, -9.82979126e-03f, 2.00591549e-01f,
  9.72800106e-02f, 5.51648885e-02f, 3.36291850e-01f, 4.51506376e-02f, 1.56424809e-02f, 8.68687108e-02f, 2.72354275e-01f, -2.60781497e-03f, 6.45007864e-02f, -9.00198892e-02f,
  -2.09059622e-02f, 7.93046951e-02f, 4.20995355e-02f, -8.15435201e-02f, 1.07479550e-01f, -4.57622856e-02f, 2.33469624e-02f, -7.60834664e-02f, -9.97705609e-02f, 6.89373463e-02f,
  -5.04200682e-02f, -1.50520522e-02f, 1.10823773e-01f, -6.81088045e-02f, -9.50705186e-02f, -2.10303459e-02f, -4.24618572e-02f, -9.59070921e-02f, 1.61666907e-02f, 9.96678695e-02f,
  -2.79684179e-02f, 2.98066083e-02f, 4.32804897e-02f, 1.01098560e-01f, 7.47046899e-03f, -1.18930712e-02f, -2.52743904e-02f, 8.40472281e-02f, 8.37069005e-02f, 5.80444634e-02f,
  5.11282459e-02f, -1.20357247e-02f, -9.14341211e-02f, -3.20041850e-02f, -1.58891007e-01f, -2.00047460e-03f, -9.31265652e-02f, -1.14417620e-01f, -8.25390741e-02f, 3.10126487e-02f,
  1.17484443e-02f, 6.69493601e-02f, 1.05957789e-02f, -1.35924056e-01f, -1.82378024e-03f, -3.38246934e-02f, -5.88338785e-02f, 2.81274924e-03f, 7.47059211e-02f, -7.81430583e-03f,
  -1.19002638e-02f, -1.00772485e-01f, 9.96253453e-03f, 1.18435517e-01f, -1.85461203e-03f, -3.83270835e-03f, 3.45597640e-02f, 4.22333293e-02f, 2.56441757e-02f, 1.30195454e-01f,
  1.97491035e-01f, 2.58918196e-01f, 5.49628474e-02f, -7.84224868e-02f, 3.95431481e-02f, -5.85871264e-02f, -2.22013500e-02f, 1.33959083e-02f, 5.60804307e-02f, -2.61617526e-02f,
  1.56245632e-02f, -1.65848285e-02f, 8.40101913e-02f, -5.17540649e-02f, 2.07967237e-02f, 1.15582645e-01f, -2.70373020e-02f, 2.41665300e-02f, 1.34034678e-01f, 1.45900056e-01f,
  -9.72609501e-03f, -4.81271930e-02f, 1.97407007e-02f, 1.88224241e-02f, -3.64404870e-03f, 1.04810491e-01f, -1.33437663e-01f, 5.66366240e-02f, 1.75935216e-02f, 1.22666411e-01f,
  4.12576228e-01f, -3.93030643e-01f, 6.42523840e-02f, 1.99074954e-01f, 2.00273156e-01f, 2.48587996e-01f, 4.26563650e-01f, 6.31372705e-02f, 3.50179732e-01f, -1.98943704e-01f,
  6.55495888e-03f, 7.81454742e-02f, 1.18927002e-01f, -3.04000266e-02f, 4.47561324e-01f, 9.56618562e-02f, 1.68551162e-01f, 1.77099749e-01f, 1.65690571e-01f, 1.37954608e-01f,
  1.80869073e-01f, 8.23481604e-02f, -9.14965663e-03f, -2.13285238e-01f, 4.41963263e-02f, -1.87908366e-01f, -1.73335031e-01f, 1.00953691e-01f, -1.71449512e-01f, 6.49509653e-02f,
  1.99750834e-03f, -7.22653046e-02f, -8.12907424e-03f, -8.28550905e-02f, -1.64814889e-02f, -6.52227923e-02f, 5.88813722e-02f, 4.21184525e-02f, 1.41221151e-01f, -7.65766129e-02f,
  3.39066088e-02f, -2.28835028e-02f, 1.11197587e-02f, 5.55359572e-02f, 1.07278898e-01f, -7.16477260e-02f, -8.67021084e-03f, -4.97477576e-02f, 1.01154903e-02f, 1.98875759e-02f,
  1.04028545e-02f, -5.53792417e-02f, -1.43930633e-02f, -4.13496532e-02f, 2.02718545e-02f, -4.90116812e-02f, -1.09698638e-01f, -6.06488960e-04f, -4.32167649e-02f, -2.06083134e-02f,
  8.88173655e-02f, 4.29066643e-02f, -7.54033849e-02f, -7.11007565e-02f, 1.98502727e-02f, -5.37642352e-02f, 2.15275530e-02f, -4.86517698e-02f, -7.67550170e-02f, -2.48131296e-03f,
  4.29725349e-02f, 1.09043773e-02f, 7.40817469e-03f, 8.38925987e-02f, 8.86365250e-02f, -7.71768317e-02f, 1.61745548e-02f, 3.27270254e-02f, -7.25521939e-03f, -2.82663088e-02f,
  8.45533758e-02f, -1.77736022e-02f, -6.63311481e-02f, -7.66131207e-02f, 2.68057343e-02f, -5.80647867e-03f, -3.37460674e-02f, 8.32779706e-02f, -4.31989469e-02f, 1.07451983e-01f,
  3.45773697e-02f, -7.44852945e-02f, 9.41402931e-03f, -7.87077546e-02f, -7.26873577e-02f, -4.85695042e-02f, 8.40543061e-02f, -5.58098331e-02f, 1.29768580e-01f, 2.04096492e-02f,
  -2.12408472e-02f, -3.97398174e-02f, -2.90327258e-02f, -3.76731604e-02f, -2.41825245e-02f, -1.08801618e-01f, 1.11997843e-01f, 2.14170236e-02f, 4.72249165e-02f, -4.42070328e-02f,
  -3.78607586e-03f, 6.41737506e-02f, 1.13400063e-02f, -5.10424860e-02f, -1.43654332e-01f, 1.22411018e-02f, 1.68915428e-02f, -2.83553787e-02f, -1.74532499e-04f, -1.45208267e-02f,
  2.74145186e-01f, -1.50687560e-01f, 1.75760418e-01f, 1.62542120e-01f, 1.74121022e-01f, 2.57186443e-01f, 2.94530571e-01f, -2.31470671e-02f, 2.39804432e-01f, -1.91750035e-01f,
  -1.20568067e-01f, 1.72917858e-01f, 1.08349606e-01f, -2.01469049e-01f, 2.16494560e-01f, -2.03686077e-02f, 7.69483745e-02f, 1.25780836e-01f, 9.35370848e-02f, 1.21525571e-01f,
  3.07088848e-02f, -2.07009301e-01f, -9.47810933e-02f, -2.03598827e-01f, 6.14203932e-03f, -6.85628057e-02f, -3.42038751e-01f, 1.27615467e-01f, -2.79291004e-01f, 8.94894172e-03f,
  2.54478790e-02f, -4.20894735e-02f, -3.40007581e-02f, -6.11407124e-02f, 9.38022658e-02f, 5.71527667e-02f, -1.44079830e-02f, 6.07263483e-03f, 1.19358435e-01f, -7.88208097e-02f,
  3.57286558e-02f, -7.60050267e-02f, -6.27725758e-03f, -3.02438177e-02f, 1.28720552e-01f, -5.90391643e-02f, 3.48152667e-02f, 3.86955738e-02f, 2.97995168e-03f, 8.95990133e-02f,
  7.47844204e-02f, -3.84996235e-02f, 2.31782030e-02f, -5.10104299e-02f, 2.72161029e-02f, -3.66203524e-02f, -4.21915054e-02f, 4.91941161e-02f, -2.58512758e-02f, -5.74634559e-02f,
  1.14234146e-02f, -2.25175004e-02f, -1.37295902e-01f, 2.43130457e-02f, 3.33851166e-02f, 9.89741087e-03f, -5.14948107e-02f, -7.56252930e-02f, 3.66773754e-02f, 2.85343640e-02f,
  4.39694850e-03f, -4.95662913e-03f, 3.83002087e-02f, 8.00364930e-03f, -5.66934515e-03f, -1.28957219e-02f, 3.82052287e-02f, -3.35397236e-02f, 2.25127768e-03f, 1.44328000e-02f,
  1.93131752e-02f, -1.59061588e-02f, 5.16228750e-03f, -8.69894028e-02f, 1.23181622e-02f, 5.77392429e-03f, -1.73606560e-01f, -5.33878012e-03f, -5.09760492e-02f, 4.50670421e-02f,
  -1.02622015e-02f, -1.21807478e-01f, -4.61349227e-02f, -7.11942762e-02f, -4.49727327e-02f, 2.45004166e-02f, -1.92847792e-02f, -1.07010812e-01f, 4.00392823e-02f, -6.30110428e-02f,
  2.25890777e-03f, -6.64972095e-03f, -1.31156193e-02f, -1.24791428e-01f, 7.47948661e-02f, -1.16532646e-01f, 3.49182375e-02f, 9.41777509e-03f, -7.79454485e-02f, 1.41947123e-03f,
  4.98372391e-02f, 9.60012060e-03f, 1.04933120e-02f, -6.71359971e-02f, -2.14021131e-02f, -6.71037892e-03f, 5.76842837e-02f, -1.95118021e-02f, 7.07928538e-02f, -2.80913562e-02f,
  -2.35929966e-01f, -2.02474952e-01f, 1.56446010e-01f, 3.21738720e-01f, -1.09251581e-01f, -2.42994741e-01f, -2.68756509e-01f, -1.78561553e-01f, -3.99444140e-02f, -3.57766718e-01f,
  -1.99048236e-01f, 6.40631393e-02f, -2.56206244e-01f, 1.92590654e-01f, 3.14880997e-01f, -1.47650287e-01f, 2.15677440e-01f, -6.49845004e-02f, -3.36330384e-02f, -6.28099293e-02f,
  1.86528280e-01f, 1.85863182e-01f, 2.41034776e-01f, 1.99265108e-01f, 1.23574905e-01f, 2.70264894e-01f, 2.51340508e-01f, 8.66810754e-02f, 3.23978096e-01f, 1.53508171e-01f,
  -6.96339384e-02f, -7.29049817e-02f, 5.03138527e-02f, 1.27402931e-01f, -9.91605446e-02f, -1.25995487e-01f, 1.02681264e-01f, -1.55622251e-02f, 5.62389120e-02f, 6.52342103e-04f,
  -1.70944277e-02f, 2.36820742e-01f, 1.03515960e-01f, -6.80813640e-02f, 1.00751810e-01f, 1.34896576e-01f, 1.25525091e-02f, -1.25521272e-01f, 9.08911154e-02f, -1.42860726e-01f,
  -3.78487557e-02f, -2.09521092e-02f, -5.25712371e-02f, 1.63215429e-01f, 2.21869364e-01f, 4.05937769e-02f, -6.68836059e-03f, -1.75571477e-03f, 1.57700494e-01f, 1.02211311e-01f,
  -1.68943107e-02f, -7.43940920e-02f, -1.00408174e-01f, -1.03514105e-01f, -1.58198476e-01f, -7.78132677e-03f, -4.25631627e-02f, -6.35328814e-02f, 3.41049694e-02f, -7.02928230e-02f,
  7.44512975e-02f, 1.56181562e-03f, -6.59132842e-03f, -8.30417201e-02f, 1.74278561e-02f, -1.16147608e-01f, 2.50539347e-03f, 9.60310996e-02f, 8.19393620e-02f, -7.84223974e-02f,
  -7.03571141e-02f, 3.93284811e-03f, 4.17154431e-02f, 1.44920304e-01f, -1.39026865e-01f, -3.16237919e-02f, 5.76981576e-03f, 2.87205800e-02f, -1.01856954e-01f, 9.24667437e-03f,
  1.07656911e-01f, 1.20551154e-01f, 5.57773374e-02f, 1.11702159e-01f, -2.20220792e-03f, -1.05946161e-01f, 3.88318636e-02f, 1.15655124e-01f, 1.03796855e-01f, -9.82200801e-02f,
  -4.45178226e-02f, 8.53713602e-02f, -2.32418980e-02f, 3.94257624e-03f, 2.18506783e-01f, 2.62519326e-02f, 2.36265417e-02f, 1.20075695e-01f, 1.80407926e-01f, 4.46479395e-03f,
  -2.75211465e-02f, -1.47534311e-01f, 5.36272824e-02f, 8.82526785e-02f, 8.83090124e-02f, 9.16450173e-02f, -1.18136592e-01f, 1.16341161e-02f, 7.76588991e-02f, 1.26737386e-01f,
  -4.25741166e-01f, 1.39279589e-01f, -4.63560261e-02f, -3.39843571e-01f, 2.33628601e-01f, 7.45352060e-02f, -3.24766561e-02f, 3.26608539e-01f, -7.18368217e-02f, 1.27074882e-01f,
  3.32216322e-02f, -3.24259013e-01f, 1.09994054e-01f, -3.86461437e-01f, -2.84254164e-01f, -2.53619611e-01f, -3.30573559e-01f, -2.38202780e-01f, -1.37529403e-01f, -5.32257669e-02f,
  -1.59792095e-01f, -2.09945396e-01f, -7.29210004e-02f, 3.18859369e-01f, -4.23489790e-03f, 1.20100223e-01f, 1.24307930e-01f, 3.61850142e-01f, -8.63898620e-02f, 6.37627169e-02f,
  3.10402866e-02f, 4.09895219e-02f, 1.62685439e-01f, 2.86282972e-02f, 9.73722264e-02f, -6.62811892e-03f, -7.27041811e-02f, -3.20102163e-02f, 1.61474906e-02f, 1.63562559e-02f,
  -8.15695226e-02f, -1.70043111e-01f, -6.46457151e-02f, 6.07255325e-02f, 6.90862983e-02f, 1.03997439e-02f, -3.31783816e-02f, 8.48679766e-02f, 4.20937277e-02f, -1.71600297e-01f,
  -2.61958428e-02f, -1.00329019e-01f, -3.54928710e-02f, -1.35595769e-01f, -6.52486086e-02f, 2.28118747e-02f, -1.13840438e-01f, -1.78592727e-02f, -4.26174551e-02f, -7.30237067e-02f,
  -4.08267640e-02f, -4.09425907e-02f, 6.57222653e-03f, 7.35186562e-02f, 4.40720953e-02f, 2.20007543e-02f, 1.48523794e-02f, -5.80115467e-02f, 6.00021370e-02f, 9.17277485e-03f,
  -1.59883276e-02f, -5.37667498e-02f, 4.42388467e-02f, -5.04597686e-02f, -1.37202710e-01f, -5.84865510e-02f, 3.92307229e-02f, -1.38923764e-01f, -6.63295463e-02f, 5.18113822e-02f,
  -9.87378787e-03f, -4.70707938e-02f, 6.40987530e-02f, 4.78036329e-02f, 4.74335477e-02f, 5.75036416e-03f, -5.66910803e-02f, 4.73990627e-02f, 9.28101987e-02f, -1.25094224e-02f,
  5.08500859e-02f, 5.63502088e-02f, 1.43359616e-01f, 3.56310420e-02f, 2.20661778e-02f, 1.41330855e-03f, -6.49395287e-02f, -4.45284843e-02f, 4.64637801e-02f, -4.26634029e-02f,
  -4.77158315e-02f, 1.22452565e-02f, 1.05167501e-01f, 3.01272143e-02f, 3.24708857e-02f, 1.38335809e-01f, -1.11839771e-01f, 1.25947952e-01f, 1.31086588e-01f, 3.69363874e-02f,
  1.04796968e-03f, -2.47851349e-02f, -6.03340752e-02f, -6.12280844e-03f, -8.16581845e-02f, 4.20869552e-02f, -2.36827806e-02f, -3.35372835e-02f, -6.01872317e-02f, -6.16614483e-02f,
  3.58967036e-01f, -3.17409076e-02f, 7.90845379e-02f, 4.21082288e-01f, 3.73746455e-01f, -2.32160045e-03f, 1.45752832e-01f, 2.28743926e-01f, 4.53175396e-01f, -1.40835479e-01f,
  1.23750344e-01f, -1.95627853e-01f, -1.85082719e-01f, 3.08315486e-01f, 3.04312289e-01f, -1.39668331e-01f, 3.65726590e-01f, 5.66751808e-02f, 2.16186658e-01f, 1.50869101e-01f,
  2.61211276e-01f, 2.81796247e-01f, 3.01744640e-02f, 7.59111047e-02f, 1.51466489e-01f, 2.69606449e-02f, -6.67154565e-02f, -1.58803046e-01f, -5.90286069e-02f, -5.65453200e-03f,
  -3.88895124e-02f, 1.12817802e-01f, -2.39460003e-02f, -1.21747330e-01f, 1.54342204e-01f, 2.26044524e-02f, -9.22905430e-02f, -1.32178843e-01f, 1.26287974e-02f, -1.13813542e-01f,
  1.14243459e-02f, -1.13469213e-01f, -1.12269230e-01f, -5.17528802e-02f, 1.86676279e-01f, 2.73655280e-02f, -1.88985914e-02f, 4.90576662e-02f, -4.12569679e-02f, 5.37043670e-03f,
  6.76931292e-02f, -1.53887803e-02f, 1.92413822e-01f, -9.45205614e-03f, 4.41545062e-02f, 9.26760584e-02f, -2.91419886e-02f, -3.79303284e-02f, -8.50680321e-02f, 7.22472966e-02f,
  -1.10456962e-02f, -4.22885455e-02f, -4.31659892e-02f, -1.00182280e-01f, 6.12445809e-02f, 6.77299127e-02f, -1.14602987e-02f, 8.05682410e-03f, 1.11206472e-01f, 2.39857957e-02f,
  7.55603286e-03f, 2.53573898e-02f, 5.23440912e-02f, -5.69335520e-02f, 1.30373687e-01f, -1.33973046e-03f, -8.10177624e-02f, -1.44858003e-01f, 9.15218070e-02f, -3.42748687e-02f,
  -3.88015211e-02f, 6.32660612e-02f, -1.37999386e-01f, -1.19844481e-01f, 3.38621857e-03f, 6.02475069e-02f, 7.17653520e-03f, 1.94425769e-02f, -4.79566567e-02f, 4.32916172e-02f,
  4.33901651e-03f, 9.94974524e-02f, -1.83129162e-02f, -9.49129760e-02f, -6.42952463e-03f, 1.29354477e-01f, 6.82445988e-02f, 4.06376719e-02f, 4.66985628e-02f, -3.12200841e-02f,
  1.56209856e-01f, -5.18336073e-02f, -3.75509486e-02f, -8.29559639e-02f, 7.62911187e-03f, 8.68686885e-02f, 1.65326465e-02f, -1.51247368e-03f, -2.03317124e-03f, -8.74253958e-02f,
  -4.49176393e-02f, 9.88361984e-03f, 1.61296457e-01f, 9.75589380e-02f, 6.38274997e-02f, -2.88188774e-02f, -3.70590501e-02f, 8.05967767e-03f, 6.42007217e-02f, -1.80410445e-02f,
  -4.06667203e-01f, 4.80737358e-01f, -1.43916488e-01f, 3.99713553e-02f, -1.14054643e-01f, 4.61398482e-01f, 3.19679707e-01f, 2.63854247e-02f, 9.63599682e-02f, 2.73657680e-01f,
  1.55316487e-01f, -6.10189140e-02f, 1.54827699e-01f, 3.31589550e-01f, 1.10856414e-01f, 4.30542946e-01f, 2.64476001e-01f, 1.18956178e-01f, 2.47113965e-02f, -6.52999803e-02f,
  -6.50196075e-02f, 1.85210928e-01f, -1.64287109e-02f, -5.15228473e-02f, -1.83421627e-01f, -2.45842949e-01f, -2.00960770e-01f, -2.55873889e-01f, 2.13756710e-02f, -5.53307263e-03f,
  -7.99595565e-03f, -1.78156123e-01f, -8.43778700e-02f, 2.48265695e-02f, -6.64629682e-04f, -1.13724880e-01f, -7.85861537e-03f, -3.16105857e-02f, -7.55897537e-02f, 3.10124154e-03f,
  4.75704065e-03f, 4.09108028e-03f, 2.09235996e-02f, -1.01327196e-01f, -1.22123882e-01f, 2.21949983e-02f, 4.16702591e-02f, 1.84413791e-02f, 7.30667189e-02f, -4.41448838e-02f,
  4.19947170e-02f, 8.61629564e-03f, -4.35924456e-02f, 4.87855598e-02f, -4.41585779e-02f, 1.25384659e-01f, 6.85465336e-02f, -7.92016909e-02f, 9.28597152e-02f, 8.47568214e-02f,
  -4.29211743e-02f, 1.62875317e-02f, 4.30303663e-02f, -4.61858436e-02f, -3.23934853e-02f, -3.77576007e-03f, 7.50029534e-02f, 1.43428321e-03f, -6.02435172e-02f, 4.38952520e-02f,
  3.78372297e-02f, 3.24247330e-02f, 7.97121320e-03f, 1.59662347e-02f, 6.50024191e-02f, -1.43292360e-02f, -5.71644455e-02f, -3.74952517e-02f, 3.64907458e-02f, 6.54802248e-02f,
  -7.54517466e-02f, 2.01906282e-02f, -7.60657992e-03f, 3.32796872e-02f, 4.30295914e-02f, -1.23260319e-01f, -1.75636671e-02f, 2.03144718e-02f, 7.09775975e-03f, 1.08175334e-02f,
  1.79163873e-01f, 1.45151436e-01f, 9.15497690e-02f, 1.99724007e-02f, 3.10294749e-03f, -4.18298803e-02f, 4.83683944e-02f, 5.24304099e-02f, 6.75310493e-02f, 5.45519497e-03f,
  -4.71378900e-02f, -1.31340558e-02f, 3.21962545e-03f, -1.01817191e-01f, -3.12052183e-02f, 2.25004897e-01f, -3.47226039e-02f, -3.45019475e-02f, 7.23193064e-02f, -3.58766951e-02f,
  -2.82342415e-02f, -6.36434853e-02f, -8.23121741e-02f, 1.14070335e-02f, -5.09853661e-03f, 1.14234211e-02f, -3.87657285e-02f, -8.41971710e-02f, -2.04063533e-03f, 9.60067213e-02f,
  2.94016272e-01f, 3.64733517e-01f, 9.90406647e-02f, 1.80377141e-01f, 1.20975606e-01f, -1.62050933e-01f, 1.02999493e-01f, -8.82589084e-04f, 6.26545995e-02f, 6.47573825e-03f,
  -2.71121770e-01f, 2.08493665e-01f, -2.98659891e-01f, -5.68478815e-02f, -5.32864213e-01f, -3.75455797e-01f, -1.46686569e-01f, 8.04767385e-02f, 9.31997260e-04f, 6.56745359e-02f,
  -1.04458943e-01f, -1.40155047e-01f, -7.91687071e-02f, 1.27610683e-01f, 2.23562628e-01f, 1.09741025e-01f, -1.40400887e-01f, 7.17235506e-02f, -1.63443927e-02f, 2.25412138e-02f,
  5.53278960e-02f, 1.66746959e-01f, 1.62972599e-01f, 9.94114950e-02f, -4.48232219e-02f, 8.30056816e-02f, 1.24037772e-01f, 5.98789053e-03f, -7.03631714e-02f, 2.29844544e-02f,
  9.48844291e-03f, -1.75383985e-02f, 1.37035036e-02f, -6.01908639e-02f, 2.35263005e-01f, 1.54225156e-01f, -3.57953794e-02f, -1.76250953e-02f, 2.78958157e-02f, 2.08026986e-03f,
  4.00938801e-02f, -1.04942936e-02f, -6.31344393e-02f, -5.37658148e-02f, -1.13277480e-01f, -1.25234470e-01f, -2.43405886e-02f, 7.41108060e-02f, -8.86469632e-02f, 7.23011270e-02f,
  -4.63723876e-02f, 1.25352237e-02f, 4.21259366e-02f, 1.18528180e-01f, -9.51628573e-03f, 5.44375852e-02f, 2.57606339e-02f, 6.57764450e-02f, 7.79963806e-02f, 4.92673144e-02f,
  2.64299661e-02f, 1.52981684e-01f, 2.89022177e-02f, -2.10638400e-02f, -1.10624880e-01f, 1.13016218e-01f, 2.54892856e-02f, -9.67856869e-02f, -4.96701188e-02f, 1.13237537e-01f,
  1.04812987e-01f, 6.60799071e-02f, 8.90176222e-02f, -3.12162973e-02f, 7.35514462e-02f, -1.67379647e-01f, -3.23300958e-02f, 4.02858295e-02f, -3.13090789e-03f, -2.26270650e-02f,
  -2.46224284e-01f, -2.76380956e-01f, -2.59971712e-02f, 1.02936529e-01f, 5.40199839e-02f, 7.85374269e-02f, 7.24129453e-02f, -1.96480169e-03f, -5.29696047e-02f, -2.56721079e-02f,
  2.80694733e-03f, 1.00229263e-01f, -1.54368505e-01f, -3.19312327e-02f, -8.86052288e-03f, -7.35675320e-02f, -8.48509669e-02f, -8.37559439e-03f, -7.89338872e-02f, 2.28911173e-02f,
  1.03842743e-01f, -5.25879711e-02f, -2.09548436e-02f, 1.26677141e-01f, 6.85023293e-02f, -9.75355357e-02f, -4.49251197e-02f, 7.47834221e-02f, -1.72679573e-01f, -6.51661754e-02f,
  2.54455417e-01f, -2.51027822e-01f, -2.80433804e-01f, -1.92992926e-01f, 1.90748826e-01f, 2.22597241e-01f, -1.55860230e-01f, -1.14319988e-01f, -3.54742914e-01f, 1.28897578e-01f,
  1.98360682e-02f, -6.92813471e-02f, -2.94543862e-01f, 4.64085750e-02f, 8.38445798e-02f, -2.68955827e-01f, 2.17607230e-01f, 1.30540311e-01f, -9.23336893e-02f, 2.38963719e-02f,
  -2.34500263e-02f, 1.92817062e-01f, -2.44107485e-01f, 2.76925862e-01f, 2.35603273e-01f, 3.58574539e-02f, 2.11194307e-01f, -6.37621507e-02f, 2.28388503e-01f, 9.25202742e-02f,
  1.78359486e-02f, -7.55409896e-02f, -7.54560381e-02f, 2.58390661e-02f, 6.27405196e-02f, 1.65966660e-01f, 1.38771668e-01f, 6.28252178e-02f, -1.47611678e-01f, -1.06648766e-01f,
  1.18891291e-01f, -2.62384098e-02f, 2.65254057e-03f, -1.09560741e-02f, 5.76487519e-02f, -3.31464894e-02f, -9.82664824e-02f, 9.60431155e-03f, -2.17008129e-01f, -8.13803747e-02f,
  -1.62938565e-01f, -7.93721341e-03f, 3.56266908e-02f, 2.25577690e-02f, -1.13554224e-01f, -1.25410452e-01f, 1.47405621e-02f, -6.05517030e-02f, 1.06923282e-01f, 4.96135931e-03f,
  3.71051468e-02f, 8.93458650e-02f, 1.79812144e-02f, -6.28477661e-03f, -1.69320907e-02f, -1.79142952e-02f, 5.05365655e-02f, 1.51071837e-02f, -5.52543066e-02f, -5.19474372e-02f,
  -4.12158854e-02f, -7.93552175e-02f, 6.57306446e-05f, 9.06423032e-02f, 8.26245919e-02f, 3.91085222e-02f, 5.43857440e-02f, 7.88656436e-03f, -1.28228307e-01f, -6.37346581e-02f,
  4.66440506e-02f, 4.37915772e-02f, -1.05183415e-01f, 2.29672883e-02f, -2.41804626e-02f, -1.97883379e-02f, 7.75096491e-02f, -3.35590728e-02f, -1.16077632e-01f, 2.29881145e-02f,
  1.10290706e-01f, 1.31846085e-01f, -6.19316213e-02f, -2.83301678e-02f, -1.08319513e-01f, 1.70001462e-01f, 9.15147439e-02f, -3.84241808e-03f, 3.04095801e-02f, 4.97364998e-02f,
  1.39643699e-01f, -5.26130535e-02f, 1.78990379e-01f, -6.69544637e-02f, -3.36091891e-02f, -1.06416963e-01f, 6.61857277e-02f, -2.14915089e-02f, 1.47307813e-02f, -7.25974068e-02f,
  6.93374872e-02f, -4.94098067e-02f, 5.64564280e-02f, -4.35375832e-02f, 5.47100045e-02f, -5.79759898e-03f, 6.89851716e-02f, -6.24165498e-02f, 1.41805097e-01f, -1.04371145e-01f,
  8.48439112e-02f, -2.10696533e-02f, -9.20338705e-02f, 1.22684792e-01f, -1.52963385e-01f, -9.49413255e-02f, -2.42481619e-01f, -5.02894707e-02f, -2.37664104e-01f, -1.79939251e-02f,
  -3.44870724e-02f, -1.97529122e-02f, -2.87790924e-01f, 3.62123936e-01f, 3.19228560e-01f, 8.42166767e-02f, 3.66832227e-01f, 1.71803772e-01f, 1.41615555e-01f, 2.30677858e-01f,
  2.43627355e-01f, 3.89876515e-01f, 2.20879704e-01f, 4.39059079e-01f, 1.40873805e-01f, 1.55524045e-01f, 8.50735679e-02f, -5.80448508e-02f, 2.73486406e-01f, 5.30955419e-02f,
  1.28965333e-01f, 8.01782496e-03f, 8.85400474e-02f, 2.12722141e-02f, 1.00499757e-01f, -4.45646942e-02f, 2.80663967e-02f, -7.02742394e-03f, -4.18674611e-02f, -8.98607969e-02f,
  6.97723180e-02f, 3.76581624e-02f, 1.53237015e-01f, 2.17478573e-02f, 2.69339737e-02f, 3.81144024e-02f, 4.36504418e-03f, -9.89692360e-02f, -1.00102387e-01f, 4.12941389e-02f,
  -5.20354696e-02f, -4.34452697e-04f, -9.15493593e-02f, -2.66623916e-03f, -9.30612087e-02f, -6.43408149e-02f, 9.18914750e-03f, -1.08238295e-01f, -3.17198038e-02f, 8.42735544e-03f,
  9.29043815e-02f, -3.24045531e-02f, -6.67061657e-02f, 2.52952334e-03f, -1.55673902e-02f, -6.04791753e-02f, -6.87446594e-02f, 3.61191258e-02f, -1.36196285e-01f, 2.80564488e-03f,
  2.35098582e-02f, -7.03569269e-03f, -2.00304892e-02f, 1.05525907e-02f, 1.33569762e-01f, 1.13677561e-01f, 1.41495606e-02f, 3.02560767e-03f, -7.88404315e-04f, 2.09786370e-02f,
  4.72632572e-02f, 7.81968702e-03f, -2.29478031e-02f, 4.23964579e-03f, 4.65261824e-02f, -9.70935225e-02f, 1.55751714e-02f, 3.04884631e-02f, -6.82289228e-02f, -7.83020929e-02f,
  1.20849028e-01f, 9.93493050e-02f, -1.92704909e-02f, 3.85392234e-02f, 9.36937984e-03f, 5.77030368e-02f, 1.08442709e-01f, 5.66997193e-02f, 3.31376977e-02f, 3.79736125e-02f,
  1.32925943e-01f, -7.11666569e-02f, -3.14348787e-02f, -6.10864051e-02f, 3.75813693e-02f, -4.85061854e-02f, 1.63053479e-02f, -1.24497972e-01f, -5.46390302e-02f, 1.26856223e-01f,
  1.46490866e-02f, -3.99867594e-02f, 2.97190696e-02f, -6.19195811e-02f, 3.71405557e-02f, -4.27959748e-02f, -2.77318410e-03f, -2.62580253e-02f, 3.26229185e-02f, -7.51846507e-02f,
  8.09787363e-02f, -1.20666148e-02f, -2.30855465e-01f, -3.14461924e-02f, -2.56729364e-01f, 7.07687214e-02f, 5.69356903e-02f, -8.55232105e-02f, 1.25147730e-01f, 2.40341812e-01f,
  -4.48807925e-02f, 6.79963408e-03f, 2.20422328e-01f, -1.53167332e-02f, 1.52325243e-01f, 3.80939633e-01f, 2.21084461e-01f, 1.38150200e-01f, -1.46079231e-02f, -4.16080207e-02f,
  1.88196190e-02f, 1.38885289e-01f, -1.02678128e-01f, -1.33423507e-01f, -1.64465338e-01f, -2.27147207e-01f, -6.97861090e-02f, -3.47136557e-01f, -1.36442393e-01f, -1.17025174e-01f,
  -5.21877185e-02f, -7.28973299e-02f, -8.90426263e-02f, 3.87521368e-03f, -9.99038666e-03f, 2.30880100e-02f, -1.50002828e-02f, -7.91964084e-02f, -1.03849307e-01f, -3.41057032e-02f,
  9.65815932e-02f, 6.79176748e-02f, -4.34902832e-02f, -6.86850697e-02f, -7.14918599e-02f, -8.08868557e-03f, 2.38230042e-02f, -1.15788989e-02f, 1.76986679e-02f, 2.03709267e-02f,
  -1.23261474e-02f, -4.79240678e-02f, -3.75991464e-02f, 1.92801580e-02f, -7.11362213e-02f, 2.90849805e-02f, 2.10709479e-02f, -3.27060819e-02f, 8.31673443e-02f, 6.82606250e-02f,
  -1.95634887e-02f, 8.39753225e-02f, 5.54726347e-02f, -8.37776624e-03f, 2.51718368e-02f, -4.66629118e-02f, 1.13120684e-02f, -2.32491735e-03f, -2.08742190e-02f, 2.72813961e-02f,
  4.64747613e-03f, -3.51640880e-02f, 1.62582938e-02f, 1.02801181e-01f, 1.25617668e-01f, 3.72761837e-03f, -9.37701985e-02f, -1.14241317e-02f, 9.25433170e-03f, 5.72665185e-02f,
  -2.55906750e-02f, 2.25281119e-02f, -1.16202854e-01f, 2.89387405e-02f, -2.36194115e-03f, 5.19434980e-04f, 4.07224856e-02f, -3.03557739e-02f, -4.06682007e-02f, 7.82856792e-02f,
  -1.03366487e-02f, 8.92980769e-02f, 4.75853076e-03f, -2.39646398e-02f, -3.18841860e-02f, 2.17912300e-03f, -1.15187531e-02f, -9.80603099e-02f, 2.29037693e-03f, 7.00350627e-02f,
  7.28050917e-02f, -1.06266700e-02f, 8.40084925e-02f, -1.67797983e-01f, 2.39544883e-02f, -4.31763660e-03f, 1.70395523e-01f, -1.34466579e-02f, 4.89151180e-02f, 2.26356019e-03f,
  1.17400731e-03f, 7.83148259e-02f, 1.09943971e-01f, 5.47709092e-02f, 2.31319629e-02f, 3.03500853e-02f, -3.44757922e-02f, -6.32850453e-02f, 8.72126669e-02f, 1.01244159e-01f,
  2.45478109e-01f, 5.72517887e-02f, 3.41914862e-01f, 3.94099563e-01f, -2.24729348e-02f, -3.52371216e-01f, -2.89137036e-01f, 2.51123250e-01f, 2.53600568e-01f, -2.72924483e-01f,
  -2.59078979e-01f, 2.76324730e-02f, -2.75483608e-01f, 4.67962176e-02f, 1.56560671e-02f, -1.54240429e-01f, 2.09840685e-01f, -7.80790672e-02f, 3.29011410e-01f, 1.85939431e-01f,
  3.38718772e-01f, 3.01996283e-02f, 3.62043232e-01f, 8.10733438e-02f, 2.26997584e-01f, 2.37042844e-01f, 1.09290376e-01f, 1.11191534e-02f, -4.03681807e-02f, -2.46208668e-01f,
  -1.22541890e-01f, 2.14469105e-01f, 1.00015856e-01f, -9.34918895e-02f, 9.62621570e-02f, -1.41755631e-02f, 6.45049140e-02f, -5.75088747e-02f, 3.46638449e-02f, 2.23710835e-02f,
  3.05668898e-02f, 2.05027699e-01f, 1.34864338e-02f, 6.60049170e-02f, -6.56058565e-02f, 1.71023354e-01f, 1.77314878e-01f, 9.82647166e-02f, 1.55822542e-02f, 1.41855225e-01f,
  7.77766258e-02f, -4.31663217e-03f, -4.32562828e-02f, -9.68076661e-02f, 6.81439713e-02f, -3.53737175e-02f, 3.58120352e-02f, 1.67243462e-02f, -4.70271818e-02f, -2.35069152e-02f,
  -2.79263277e-02f, 1.24640211e-01f, -1.05283804e-01f, 7.24386945e-02f, -7.77537748e-02f, 7.61809945e-02f, -7.68078789e-02f, 1.22339977e-02f, -1.80745590e-02f, -5.70997000e-02f,
  -2.08007987e-03f, 3.46211232e-02f, 6.20077513e-02f, -2.16966085e-02f, 5.24463840e-02f, 7.01869056e-02f, -3.58788520e-02f, -1.05296321e-01f, 1.73786785e-02f, -7.33620003e-02f,
  8.79471377e-02f, -4.71449420e-02f, 2.78047398e-02f, 1.17227379e-02f, -1.34908304e-01f, 5.72148189e-02f, 2.02125385e-01f, -4.67678532e-02f, -2.87887249e-02f, 6.99549168e-02f,
  -2.82066077e-01f, 1.23721704e-01f, -9.19922441e-02f, -2.21199408e-01f, -9.89731699e-02f, 8.73411074e-02f, 2.14265231e-02f, 1.68595966e-02f, -6.82086945e-02f, 6.94132820e-02f,
  5.07312231e-02f, 2.81515662e-02f, -2.28805408e-01f, -3.43271904e-02f, -1.40223980e-01f, 6.88307080e-03f, 9.06326901e-03f, -5.74032813e-02f, -7.42655769e-02f, 9.37590227e-02f,
  7.33976141e-02f, -1.22905388e-01f, 3.56557295e-02f, 1.57616228e-01f, 1.81462541e-02f, -4.67697978e-02f, -8.22381452e-02f, 3.50727933e-03f, -6.02832660e-02f, -1.62682943e-02f,
  3.96761984e-01f, -3.68268400e-01f, 1.20003261e-01f, 1.46867856e-01f, 2.69205362e-01f, 8.63999277e-02f, 3.31621736e-01f, -1.44609902e-02f, 2.57437497e-01f, -2.59004146e-01f,
  2.29380354e-02f, -1.68325230e-01f, 9.69360396e-02f, -2.18006983e-01f, 3.67082924e-01f, -6.40062802e-03f, -5.15575856e-02f, -1.49833992e-01f, 1.16302051e-01f, -7.96021894e-02f,
  2.57346686e-02f, -1.89473480e-01f, 6.05936870e-02f, -2.59737432e-01f, -9.80741233e-02f, -7.96251744e-02f, -1.00013003e-01f, 5.24964705e-02f, -2.71592200e-01f, 1.58421751e-02f,
  2.68378798e-02f, 2.07439307e-02f, 2.29475573e-02f, -4.85820621e-02f, 5.45899756e-02f, 4.32889089e-02f, -1.01455189e-01f, 3.11673097e-02f, 1.42081112e-01f, -3.54150347e-02f,
  -6.69679195e-02f, -1.34724483e-01f, -9.54466686e-02f, 5.57744540e-02f, 4.81058210e-02f, -5.70663698e-02f, 1.77140981e-02f, 1.19719394e-01f, -1.24974623e-02f, 5.49496934e-02f,
  1.05370477e-01f, -1.08963154e-01f, 7.29689747e-02f, -8.78318921e-02f, 8.08730423e-02f, 2.52443720e-02f, -5.91494218e-02f, -2.23384816e-02f, -1.13870233e-01f, -1.47825539e-01f,
  -3.11232433e-02f, -1.15902208e-01f, 1.16018774e-02f, -3.86334546e-02f, 7.78401420e-02f, 7.50204846e-02f, 3.05024267e-04f, -9.38186597e-04f, 3.57877053e-02f, -2.74106283e-02f,
  -2.99404338e-02f, -5.12075089e-02f, 5.16019128e-02f, 4.49985042e-02f, -5.52855358e-02f, 2.03925669e-02f, -2.93229073e-02f, -1.52100831e-01f, 3.01675536e-02f, 7.97721446e-02f,
  -2.94551812e-03f, -6.24784008e-02f, -4.31363820e-04f, -7.51339197e-02f, -2.94563938e-02f, 9.20492783e-02f, -1.35620415e-01f, -9.84486043e-02f, 9.04937088e-02f, -4.10608239e-02f,
  -6.80357441e-02f, -3.20413411e-01f, -3.05526075e-03f, -8.58612433e-02f, -5.01736589e-02f, -2.30458882e-02f, -4.48744930e-03f, -1.57755092e-02f, -6.31892532e-02f, -1.06099628e-01f,
  -1.07378013e-01f, -3.86987031e-02f, -2.99444906e-02f, 2.84425244e-02f, -6.68461397e-02f, -4.48596515e-02f, -4.96571362e-02f, -6.53796196e-02f, -7.58784190e-02f, -1.01678491e-01f,
  -1.66343004e-02f, -1.70009006e-02f, 3.53474286e-03f, -3.72082694e-03f, -7.09909052e-02f, 2.03683879e-02f, 5.42933866e-02f, 1.49983345e-02f, 4.98864017e-02f, -1.36111602e-01f,
  -2.49787331e-01f, -3.36022139e-01f, -1.55493855e-01f, 7.99667239e-02f, 9.57845002e-02f, -8.86975899e-02f, -1.91609636e-01f, -1.77671030e-01f, -1.18024811e-01f, -1.15998678e-01f,
  -7.44035617e-02f, 1.04006387e-01f, -3.64898860e-01f, 1.68041110e-01f, 3.80495042e-02f, -1.35968953e-01f, 5.48449047e-02f, 2.06825376e-01f, 6.86034560e-02f, -1.45578459e-01f,
  2.92717200e-02f, 1.26489565e-01f, -4.06973921e-02f, 1.49895877e-01f, -8.24701712e-02f, 5.43677881e-02f, 1.41013503e-01f, 1.24796713e-02f, 2.86013961e-01f, 1.87951311e-01f,
  -1.41458735e-01f, -1.56334072e-01f, -8.37803334e-02f, -4.47630882e-02f, -9.92599353e-02f, 7.62152597e-02f, -3.83047983e-02f, 4.43276428e-02f, 3.80872563e-02f, 9.23680887e-03f,
  -9.81650129e-03f, 1.85398776e-02f, 5.01631610e-02f, 1.12742387e-01f, 1.68875381e-02f, 1.71118528e-02f, 6.27003536e-02f, -8.94694105e-02f, -6.34725541e-02f, -7.11424649e-03f,
  -9.33564752e-02f, -7.16146231e-02f, -2.63653528e-02f, -2.49768198e-02f, -3.74080166e-02f, 5.08154370e-02f, 4.00382839e-02f, 4.01767753e-02f, -1.50295841e-02f, 2.05629319e-02f,
  4.27107662e-02f, -1.16859945e-02f, -4.64966036e-02f, -3.81469019e-02f, -1.44882780e-02f, 1.29879564e-02f, -7.18624890e-02f, 5.56615666e-02f, 7.12360665e-02f, -1.12935990e-01f,
  -2.39070244e-02f, 1.35619584e-02f, 4.01202589e-02f, 3.65893007e-03f, 5.01082800e-02f, 2.75305007e-02f, -8.35782290e-02f, 2.60439776e-02f, -5.55160940e-02f, 5.62365353e-02f,
  -9.01355594e-02f, -8.87816995e-02f, -2.20486328e-01f, -2.11670920e-02f, -6.03934228e-02f, -5.80809787e-02f, -5.43106012e-02f, -5.63539043e-02f, -1.36510953e-02f, -1.42192689e-03f,
  -4.00418699e-01f, -3.19137454e-01f, -1.00109801e-01f, -3.90968062e-02f, 3.56282182e-02f, 7.86050484e-02f, 3.98727991e-02f, 4.42867354e-02f, -1.22809410e-01f, -9.78711173e-02f,
  3.94539088e-02f, -4.02111933e-02f, 4.00626287e-02f, 7.01414943e-02f, 2.12094020e-02f, -1.13010347e-01f, -4.69031222e-02f, -8.92572328e-02f, -8.17741826e-02f, -1.56412162e-02f,
  -4.72820476e-02f, -7.45823979e-02f, 1.29990667e-01f, -6.47627236e-03f, 6.97542131e-02f, 3.69369835e-02f, 2.63112430e-02f, 1.04677394e-01f, 9.13834348e-02f, 3.29460837e-02f,
  1.34007826e-01f, 2.15175807e-01f, -1.43395215e-01f, -1.84129328e-01f, -6.41377969e-03f, -3.89152974e-01f, -2.63858736e-01f, -1.01562373e-01f, 1.93918068e-02f, 3.84580418e-02f,
  -2.14487135e-01f, 1.05844565e-01f, -1.08694686e-02f, -2.34502107e-01f, -2.80157119e-01f, -2.09291667e-01f, -3.29753786e-01f, -1.12482175e-01f, 4.93299514e-02f, -8.72571841e-02f,
  -1.44897878e-01f, -1.51444346e-01f, -2.59069890e-01f, 6.37158900e-02f, -6.84625879e-02f, -2.64555812e-02f, -2.71921270e-02f, 1.54786944e-01f, -1.50146410e-01f, -2.16583279e-03f,
  -4.54753032e-03f, 1.29491031e-01f, -6.55572349e-03f, 4.68127765e-02f, -5.54857105e-02f, 3.46987918e-02f, 6.06122427e-02f, 8.03215504e-02f, 2.28890963e-03f, 1.15406595e-01f,
  -9.40535888e-02f, 6.96143210e-02f, -1.16881486e-02f, 7.42182434e-02f, 6.44257143e-02f, 1.29194453e-01f, -1.29125297e-01f, -2.56028082e-02f, -3.48518901e-02f, -4.04675603e-02f,
  -9.04599279e-02f, 6.41892850e-02f, -8.74841437e-02f, -4.81144898e-02f, -7.85597712e-02f, -5.06964363e-02f, -2.46444028e-02f, 6.69721141e-02f, -2.05320809e-02f, 3.71207744e-02f,
  -6.14372194e-02f, 7.99885988e-02f, 3.20711620e-02f, 1.24313727e-01f, 3.64407450e-02f, 9.74176824e-02f, -2.89572775e-02f, 6.84656156e-03f, 1.23351775e-01f, 1.34948164e-01f,
  3.97503674e-02f, 4.85392362e-02f, 1.98566858e-02f, -6.06527850e-02f, -1.23696707e-01f, 5.57329990e-02f, 1.92682799e-02f, 3.91597254e-03f, -4.18022536e-02f, 2.36424450e-02f,
  5.17647304e-02f, 7.68664926e-02f, 7.58338198e-02f, -5.66703267e-02f, 5.85893765e-02f, -1.84210557e-02f, -4.84014116e-02f, -2.02394575e-02f, -1.03976475e-02f, -7.07405880e-02f,
  -1.56665862e-01f, -5.57081476e-02f, -2.19900571e-02f, 1.25084803e-01f, 1.14492528e-01f, 3.77169847e-02f, 5.07868528e-02f, -1.47541640e-02f, -2.18340270e-02f, 4.02594097e-02f,
  -1.12914629e-01f, 4.11992520e-02f, 3.83164585e-02f, 1.22942679e-01f, -2.43413337e-02f, -1.09084070e-01f, -1.27673671e-01f, 5.45963459e-02f, -1.17539465e-01f, -2.79083326e-02f,
  -1.38687184e-02f, 1.06608167e-01f, 6.31368393e-03f, 1.08524553e-01f, -3.03109176e-02f, -7.47870803e-02f, 5.05292974e-02f, 9.32316482e-02f, -5.74886575e-02f, 7.30979741e-02f,
  2.54847944e-01f, 7.78186508e-03f, -2.24650949e-01f, -1.92067459e-01f, -2.71496713e-01f, 1.31022725e-02f, -2.35730857e-02f, -2.07467705e-01f, -2.12294221e-01f, 9.92165357e-02f,
  -2.40523115e-01f, 7.18802735e-02f, 2.19643593e-01f, -8.27004015e-02f, 2.02772200e-01f, 3.52747619e-01f, -1.10116890e-02f, 4.61810343e-02f, -4.95379977e-02f, -1.40403435e-02f,
  1.00385295e-02f, 1.04617119e-01f, 5.55690117e-02f, -9.35205370e-02f, -2.33261108e-01f, -1.43053263e-01f, -1.27220213e-01f, -2.44929045e-01f, -1.89568281e-01f, -2.38682181e-01f,
  1.93318445e-02f, -6.63816929e-02f, -2.57665180e-02f, 2.31978986e-02f, 6.12198114e-02f, 9.32445824e-02f, -1.93127187e-03f, 1.67115945e-02f, -4.48962860e-02f, -1.59726739e-02f,
  8.38463828e-02f, 1.14846826e-01f, -1.38529256e-01f, -5.97310998e-03f, -1.04303002e-01f, -8.73385817e-02f, -3.62567306e-02f, -4.02456373e-02f, -9.00445599e-03f, 9.07813534e-02f,
  -1.24370987e-02f, -6.28266018e-03f, -1.51709333e-01f, 3.05813011e-02f, -1.57644391e-01f, -9.53526199e-02f, 1.50368884e-01f, -2.48025488e-02f, 3.56369140e-03f, -8.27135239e-03f,
  5.34326583e-03f, 8.03038552e-02f, 1.38021752e-01f, 1.06401676e-02f, 1.01654328e-01f, 2.38912273e-02f, -2.74440031e-02f, 8.95692632e-02f, -7.65479580e-02f, -2.32122522e-02f,
  -8.34957585e-02f, -6.28082454e-02f, -3.53189930e-02f, 6.20372333e-02f, 6.84213415e-02f, 4.19864431e-02f, -3.82899567e-02f, -1.19209085e-02f, -1.35475099e-01f, -7.85484239e-02f,
  -1.93826817e-02f, -5.81907399e-04f, -5.41923754e-02f, -7.36904144e-02f, -6.19246438e-03f, -1.26178944e-02f, -5.67021482e-02f, -2.80164070e-02f, -9.68961045e-02f, -2.17731707e-02f,
  -5.37633635e-02f, -6.18882142e-02f, -5.24392389e-02f, 1.28614176e-02f, 3.93298790e-02f, 8.23814347e-02f, -4.39295731e-03f, -2.45755073e-02f, -6.64995685e-02f, 1.07973047e-01f,
  7.06611993e-03f, -1.90735199e-02f, -1.12768270e-01f, -1.32592604e-01f, -1.07910462e-01f, -6.99752271e-02f, 1.50637895e-01f, -1.10050380e-01f, -7.00602904e-02f, -7.31995925e-02f,
  5.43199703e-02f, -1.37058469e-02f, 3.12908702e-02f, 8.69968627e-03f, 1.77640154e-03f, -8.44583362e-02f, 7.51425102e-02f, -4.38284129e-02f, -3.24994512e-02f, -5.38871177e-02f,
  9.65647921e-02f, -1.41836137e-01f, 9.82529521e-02f, 1.68079272e-01f, -1.21435501e-01f, -8.19371790e-02f, -7.07919374e-02f, -6.33392483e-02f, 2.46465087e-01f, -9.02540237e-02f,
  -1.70221001e-01f, 2.30371580e-01f, -3.06162667e-02f, -2.27854103e-01f, 7.76963215e-03f, -1.32027715e-02f, -2.65649017e-02f, 8.04966390e-02f, -3.49348746e-02f, -7.74524063e-02f,
  -6.77342266e-02f, -3.63068610e-01f, -1.40210941e-01f, -3.54845822e-01f, -1.37379870e-01f, -2.59891097e-02f, -1.52220935e-01f, -6.15573712e-02f, -4.55929413e-02f, -1.22668229e-01f,
  5.42227104e-02f, -1.01300284e-01f, -8.62890296e-03f, 3.73564498e-03f, -5.26002571e-02f, -7.00332969e-02f, 3.04921414e-03f, -1.29093528e-01f, 7.61151314e-02f, 1.22383554e-02f,
  1.28759677e-02f, 9.18356478e-02f, -9.41214897e-03f, -1.20435640e-01f, 1.87310502e-02f, 2.15734099e-03f, 7.57113248e-02f, 1.11977987e-01f, -1.94593845e-03f, -2.83566713e-02f,
  9.72535908e-02f, 7.45750964e-02f, 1.08227640e-01f, 2.12841466e-01f, 7.91102201e-02f, 3.14211398e-02f, 3.43374424e-02f, 8.20546895e-02f, 2.31930345e-01f, 7.68921897e-02f,
  -1.16891250e-01f, -1.22398566e-02f, -7.27496073e-02f, -6.03231229e-03f, -6.69562593e-02f, -1.67417452e-02f, -9.31344330e-02f, -1.51130423e-01f, 1.29319906e-01f, 2.95162890e-02f,
  2.47276686e-02f, -1.02504171e-01f, -8.60121697e-02f, -3.13771442e-02f, -1.44190431e-01f, 4.51094620e-02f, 1.61325634e-02f, 5.98052777e-02f, 1.20669201e-01f, -8.10908712e-03f,
  -1.46132201e-01f, 1.02649018e-01f, 9.83013809e-02f, 2.94884238e-02f, 4.29665558e-02f, 4.70460244e-02f, 4.59109026e-04f, 2.49984618e-02f, 1.95552856e-02f, 1.89190414e-02f,
  5.84551767e-02f, -1.54513732e-01f, -3.12175062e-02f, 1.03088297e-01f, 4.46973592e-02f, 3.05937808e-02f, -7.88044631e-02f, 1.35057885e-02f, 3.16620655e-02f, -1.24809615e-01f,
  -7.32292905e-02f, 9.53183994e-02f, 1.70443445e-01f, 1.82183553e-02f, 5.59388064e-02f, -2.69245468e-02f, 4.58436571e-02f, 1.57918915e-01f, -8.62101931e-03f, -8.27038437e-02f,
  8.08669440e-03f, 4.06079814e-02f, 5.90981506e-02f, 1.67422026e-01f, 1.34954423e-01f, 2.57342476e-02f, 7.22795632e-03f, 4.20254096e-02f, 6.84046298e-02f, 1.66188687e-01f,
  1.99323773e-01f, -4.14566427e-01f, -9.52837393e-02f, 2.35716067e-02f, 7.20975399e-02f, -1.68838114e-01f, -8.16521496e-02f, -1.43436670e-01f, 1.86640531e-01f, -2.60672897e-01f,
  -4.27214094e-02f, 8.22648033e-02f, 5.35255931e-02f, -1.71719253e-01f, 3.94564599e-01f, 1.20434217e-01f, -3.01224384e-02f, -1.28825614e-03f, 1.01730756e-01f, -1.97788507e-01f,
  5.43450154e-02f, -1.42372042e-01f, -2.78641172e-02f, -3.37058574e-01f, -1.82703301e-01f, -1.54745400e-01f, -3.22803780e-02f, -5.06791808e-02f, -1.62135124e-01f, 9.27699506e-02f,
  4.49848771e-02f, 7.17033260e-03f, -3.33699994e-02f, 8.21544975e-03f, -1.16646692e-01f, -1.01805031e-02f, -2.45950986e-02f, -5.99927083e-03f, 2.11111888e-01f, 2.70800851e-02f,
  -2.91085206e-02f, 1.13103338e-01f, -1.19029798e-01f, 8.55956823e-02f, 4.33038361e-02f, -2.15276587e-03f, 2.13456955e-02f, 9.44894403e-02f, 6.99743582e-03f, -2.67417729e-02f,
  5.23467883e-02f, 7.19802305e-02f, 6.81199655e-02f, 7.78182819e-02f, 7.10502043e-02f, 3.47662307e-02f, -8.42033029e-02f, -1.22063542e-02f, 5.05469106e-02f, 3.47961150e-02f,
  -5.63078672e-02f, 1.82525609e-02f, -1.97095722e-02f, 1.90915652e-02f, 3.57023850e-02f, 3.37238573e-02f, 2.41215993e-03f, -4.04703990e-02f, 6.18729480e-02f, -1.82340704e-02f,
  5.32242320e-02f, -7.94894546e-02f, -6.72128275e-02f, 6.25931621e-02f, -3.29051167e-02f, -4.13482375e-02f, -5.35764545e-02f, -5.80192506e-02f, 2.27797274e-02f, -3.17515768e-02f,
  6.12217793e-03f, 7.31049776e-02f, -6.76023737e-02f, -3.44711170e-02f, -3.35022621e-02f, 1.24994069e-01f, -1.44294591e-03f, -9.53735188e-02f, -1.17527787e-03f, 9.95543669e-04f,
  1.80719316e-03f, -2.31089279e-01f, -9.24971178e-02f, -1.35152405e-02f, -9.02953893e-02f, -1.25314808e-02f, -8.14056695e-02f, -8.38751197e-02f, 7.18322843e-02f, -6.16042987e-02f,
  -5.92848696e-02f, -1.58220120e-02f, 6.90504089e-02f, 7.85680264e-02f, 6.40017688e-02f, -1.84269264e-01f, -5.83368074e-03f, 7.17173517e-02f, 5.51819578e-02f, -1.15086474e-01f,
  -1.57492161e-02f, 1.99504402e-02f, 1.09926738e-01f, 4.72951904e-02f, -1.65844280e-02f, 1.05527854e-02f, 3.15770879e-03f, 2.36725900e-02f, 4.67651412e-02f, 5.04234433e-02f,
  1.25363305e-01f, -2.27648467e-01f, -1.28958374e-01f, -1.22325674e-01f, -8.64835083e-02f, -4.33266796e-02f, 2.10160799e-02f, -2.70663023e-01f, -1.21641137e-01f, -1.95543140e-01f,
  -2.65251130e-01f, 1.19607970e-01f, 2.73231179e-01f, -3.62634748e-01f, 2.76796073e-01f, 2.15626851e-01f, -1.07455276e-01f, -1.27174202e-02f, -1.51042089e-01f, -1.44505307e-01f,
  -1.64331228e-01f, -1.18228905e-01f, -6.55310601e-02f, -2.36066565e-01f, -2.65919894e-01f, -1.66582987e-01f, 3.52330171e-02f, -1.04026921e-01f, -2.88674712e-01f, -7.57195801e-02f,
  -1.86957628e-01f, -6.80178106e-02f, 1.19097987e-02f, 2.13410053e-02f, -7.30483681e-02f, 4.46125045e-02f, 6.09813146e-02f, 1.05748609e-01f, 4.71545476e-03f, 5.42948581e-02f,
  1.17547303e-01f, 9.42568779e-02f, -1.11935027e-01f, 1.58841107e-02f, -1.76763296e-01f, -1.18010744e-01f, -1.57506056e-02f, -4.00894582e-02f, 1.32331215e-02f, 8.41838308e-03f,
  -2.11700685e-02f, -3.27392668e-02f, -1.68033883e-01f, 8.99636522e-02f, 9.23099294e-02f, -4.12205309e-02f, 1.45607248e-01f, 1.97909519e-01f, 1.20821118e-01f, 5.61248772e-02f,
  -7.48800784e-02f, 1.99056551e-01f, 1.76623650e-02f, -8.51349831e-02f, -3.40879038e-02f, -1.24710575e-02f, -1.12910252e-02f, -5.50503023e-02f, -5.27275875e-02f, -5.27623855e-02f,
  1.41682262e-02f, 4.83941287e-02f, -8.82850960e-02f, -3.15388804e-03f, -6.96727261e-02f, 3.68700251e-02f, 4.23297621e-02f, -1.10626537e-02f, -1.72531679e-01f, -9.56134871e-02f,
  -1.10414416e-01f, 1.60081517e-02f, -1.60952248e-02f, -4.66495454e-02f, -3.31155881e-02f, 2.88897689e-04f, -9.05006826e-02f, -8.50750282e-02f, -9.97229889e-02f, 1.36346251e-01f,
  1.16179921e-02f, 8.10147915e-03f, -5.51909097e-02f, 3.46306488e-02f, 7.72346109e-02f, 5.64885363e-02f, -8.83258730e-02f, -3.47062498e-02f, -2.06580888e-02f, -1.65028940e-03f,
  -9.29872617e-02f, 8.36373642e-02f, -2.63697691e-02f, -9.13194474e-03f, 2.84149474e-03f, -3.16762291e-02f, 5.45291416e-02f, -4.92290361e-03f, 9.29642096e-02f, -3.87176350e-02f,
  3.09142191e-02f, 4.47545713e-03f, 1.13829046e-01f, 1.58331454e-01f, 3.73028554e-02f, -3.29865725e-03f, 4.95168827e-02f, -6.18488775e-05f, 1.31325915e-01f, 3.68632339e-02f,
  -5.44137061e-01f, -1.59946576e-01f, 2.88718730e-01f, -3.95103306e-01f, 1.38277724e-01f, 5.15269160e-01f, 1.93832368e-01f, -7.42253885e-02f, -3.43329221e-01f, -1.67540193e-01f,
  5.27459010e-02f, -2.72604842e-02f, 1.65837362e-01f, 2.15338189e-02f, 4.56667095e-01f, 1.69724286e-01f, -7.53706470e-02f, 1.54850138e-02f, 7.62334093e-02f, -2.04475030e-01f,
  -7.25582382e-03f, 1.16109863e-01f, 2.86276489e-01f, -6.18752912e-02f, 4.43234965e-02f, -1.61490023e-01f, -4.59910333e-02f, 2.60205269e-01f, 8.42659175e-02f, 2.53592879e-01f,
  2.08173413e-04f, -3.94171625e-01f, 2.22614277e-02f, 5.50595298e-02f, 4.83330227e-02f, 7.13322137e-04f, 1.51819875e-03f, 1.65024787e-01f, -4.65829298e-02f, 5.92987165e-02f,
  -2.73324409e-03f, 1.93795949e-01f, -1.62862405e-01f, 1.79273799e-01f, -4.43026125e-02f, 1.13083916e-02f, 1.56409860e-01f, 8.59933347e-02f, 1.36269912e-01f, 2.28171851e-02f,
  1.76490352e-01f, 8.58335644e-02f, 2.66143065e-02f, 2.05933768e-02f, 9.59408879e-02f, 1.64654106e-02f, -3.70384492e-02f, 1.00515969e-03f, 2.73653194e-02f, -2.76121236e-02f,
  -5.17614037e-02f, 2.74295248e-02f, 1.04505181e-01f, 4.98573706e-02f, -3.79719771e-02f, -3.10965274e-02f, 6.06943443e-02f, 3.95092461e-03f, 7.32863545e-02f, 2.59007178e-02f,
  -9.37987044e-02f, 3.27766351e-02f, -9.98001248e-02f, 7.11423233e-02f, 9.63411108e-02f, -8.92563909e-02f, 4.77836467e-02f, 2.33346713e-03f, 3.82571854e-02f, 7.50468159e-03f,
  -4.00806740e-02f, -7.27711320e-02f, 4.28252965e-02f, -4.11063284e-02f, -3.91118564e-02f, 1.53040111e-01f, 3.09514720e-02f, 9.01679993e-02f, -1.58404633e-01f, 1.01719201e-01f,
  5.62580749e-02f, -3.15115303e-01f, 3.13133337e-02f, 4.12490629e-02f, 6.23021275e-02f, 7.24450797e-02f, 1.66757987e-03f, -3.58574837e-02f, -2.25793105e-02f, 3.01136263e-02f,
  2.77389009e-02f, 1.28924660e-02f, -4.40312224e-03f, 1.14368089e-01f, 1.76114552e-02f, 6.69475123e-02f, -3.73109356e-02f, 5.56377582e-02f, 8.12034607e-02f, -1.40339926e-01f,
  -1.58102959e-02f, -5.66136017e-02f, 6.07897751e-02f, -2.43085437e-02f, -7.07568228e-02f, 2.13169232e-02f, -1.17782138e-01f, -5.10534905e-02f, 7.41160661e-02f, 1.64364427e-02f,
  -2.85676420e-01f, -1.89983577e-01f, 2.57299006e-01f, -3.40171099e-01f, 1.40036032e-01f, 2.80184865e-01f, -9.18496847e-02f, -1.64132103e-01f, -3.40763986e-01f, -3.73843610e-01f,
  -2.44729027e-01f, 6.82179406e-02f, -2.33296994e-02f, 7.54199456e-04f, 4.70169306e-01f, 7.42316023e-02f, -1.05136238e-01f, -1.57692581e-02f, 6.14363775e-02f, -5.67116998e-02f,
  1.86059792e-02f, -5.24320640e-02f, 2.29341716e-01f, 1.25085443e-01f, 7.20725060e-02f, -1.22905709e-01f, -7.39202797e-02f, 2.70172149e-01f, -2.41781306e-02f, 1.86788872e-01f,
  -9.84022692e-02f, -2.09395647e-01f, 2.32304856e-02f, 3.45527530e-02f, -4.61554417e-04f, 4.90936264e-02f, 7.70716891e-02f, 1.03055567e-01f, -3.02548427e-02f, 1.48641663e-02f,
  6.43916614e-03f, 1.05135269e-01f, -3.24805565e-02f, 4.46140207e-03f, -1.19501360e-01f, -1.97819714e-02f, 5.49935289e-02f, -1.00707054e-01f, -4.26181704e-02f, 9.14086178e-02f,
  -1.37680415e-02f, -1.48107456e-02f, -6.34833276e-02f, 5.53071760e-02f, -2.49986071e-02f, -1.34682998e-01f, 1.49595654e-02f, 1.48936540e-01f, -4.40306440e-02f, -2.27894410e-02f,
  1.26811057e-01f, 1.07058309e-01f, -1.73822939e-02f, -7.45915771e-02f, -4.93936464e-02f, -1.12179548e-01f, -1.01672597e-01f, 1.67936191e-03f, -5.44978455e-02f, -9.61332768e-02f,
  7.99373630e-03f, 3.04384474e-02f, -4.08317447e-02f, -1.16399236e-01f, -1.15564287e-01f, -1.91888452e-01f, 9.95690376e-03f, 1.67319626e-02f, 1.56187536e-02f, 5.45312464e-02f,
  -6.23220205e-02f, 2.03907210e-02f, -1.52128860e-02f, 8.94843265e-02f, 3.86189744e-02f, 2.15508845e-02f, -1.19730318e-02f, 2.20921892e-03f, -6.26139939e-02f, 1.45590544e-01f,
  -2.59788543e-01f, -3.19549322e-01f, -4.72586006e-02f, -5.84489293e-02f, 6.07059523e-02f, 5.51321507e-02f, 7.02113956e-02f, -1.69742972e-01f, -1.31566927e-01f, 8.64405930e-03f,
  -1.83058195e-02f, 6.49997778e-03f, -9.97020379e-02f, -3.05661801e-02f, 3.97936292e-02f, -1.02569625e-01f, -3.19241397e-02f, -2.17139125e-01f, -1.15489297e-01f, -2.83967052e-02f,
  -8.31231549e-02f, -9.17139128e-02f, 1.83164403e-01f, 4.90041450e-02f, -5.02366535e-02f, -1.07429124e-01f, -1.15464598e-01f, 4.91334572e-02f, 1.21622786e-01f, -2.19698269e-02f,
  4.79394674e-01f, -3.35417747e-01f, -6.29440397e-02f, 1.76402643e-01f, 2.90580690e-01f, 2.56820023e-01f, 3.18835497e-01f, 2.18141302e-02f, 1.48600847e-01f, -1.97105244e-01f,
  -6.85254624e-03f, -5.92856407e-02f, -1.34717256e-01f, 8.62344876e-02f, 4.76080596e-01f, -4.04494517e-02f, 2.35690773e-01f, 1.23004213e-01f, 8.50362554e-02f, 6.27749413e-02f,
  1.68916926e-01f, 2.56823182e-01f, -4.19608597e-03f, -2.30889600e-02f, 1.72562510e-01f, -9.51859951e-02f, -7.31612369e-02f, -5.77906929e-02f, -3.56779881e-02f, 7.26751238e-02f,
  1.43161993e-02f, -9.89145041e-02f, 4.21698727e-02f, -1.18841797e-01f, 4.28949445e-02f, 1.37498705e-02f, -2.27890499e-02f, 7.51741901e-02f, 1.25400797e-01f, -4.82439324e-02f,
  1.01459697e-01f, -6.63322397e-03f, -4.55945320e-02f, 8.68210793e-02f, 1.20447703e-01f, 3.26183587e-02f, 3.02725416e-02f, -1.34086888e-02f, -1.61664616e-02f, 4.92531632e-04f,
  3.30973975e-02f, -9.47490782e-02f, 2.25069337e-02f, -3.52043882e-02f, -1.73852202e-02f, 5.20074442e-02f, -3.37811038e-02f, -1.07386038e-02f, -4.80334498e-02f, 6.24645203e-02f,
  1.38557958e-03f, -2.59693973e-02f, 4.83284518e-02f, -2.67832298e-02f, 7.76810497e-02f, -9.33785830e-03f, 7.14447871e-02f, -2.48722341e-02f, -1.46754226e-02f, -2.77433600e-02f,
  2.32808162e-02f, 3.08986977e-02f, -2.16932269e-03f, 7.94895589e-02f, 5.81499264e-02f, -7.29332045e-02f, 2.14657169e-02f, -4.83448394e-02f, 2.33561825e-02f, -2.79892292e-02f,
  3.89675051e-02f, 5.90274259e-02f, -7.52284303e-02f, -1.04701251e-01f, 4.83465753e-02f, 9.77442786e-03f, -1.06315780e-02f, -2.05311850e-02f, -1.00059040e-01f, 2.33317576e-02f,
  -4.43020239e-02f, -2.53653258e-01f, -9.43508595e-02f, -8.81858319e-02f, -6.14421517e-02f, 8.52281228e-02f, 3.43059003e-02f, -1.66972466e-02f, 5.15610864e-03f, 3.42259519e-02f,
  4.74288054e-02f, -5.12820780e-02f, -9.48679298e-02f, -9.82552953e-03f, -4.44656610e-02f, -3.50640155e-02f, 5.63310944e-02f, -1.88782644e-02f, -6.47312542e-03f, -6.23619296e-02f,
  3.14594544e-02f, -4.63107079e-02f, 2.53210217e-02f, 9.32128660e-06f, -2.40029488e-02f, -2.10293587e-02f, -2.09158491e-02f, -1.38120586e-02f, 3.69718745e-02f, -3.58877666e-02f,
  4.21739250e-01f, -2.75430322e-01f, 2.59984374e-01f, 4.25563246e-01f, 2.35190049e-01f, 4.70889919e-02f, 3.73907566e-01f, -7.96810091e-02f, 2.15586826e-01f, -2.99563110e-01f,
  5.52360155e-02f, 7.69419372e-02f, 1.66481659e-01f, -1.01527333e-01f, 1.21554784e-01f, -1.26178473e-01f, 4.76501994e-02f, 1.13297246e-01f, 4.31783572e-02f, 4.04913090e-02f,
  7.46553615e-02f, -2.18519539e-01f, 5.24446741e-02f, -2.95946211e-01f, 9.49956477e-02f, -1.18514188e-01f, -1.62464947e-01f, 7.38569200e-02f, -1.34165347e-01f, -3.65476273e-02f,
  5.93967102e-02f, -2.74725049e-03f, -5.24915718e-02f, -8.52408037e-02f, 6.34559020e-02f, 2.80141607e-02f, 3.57372202e-02f, -6.55173957e-02f, 1.43023401e-01f, 5.73741160e-02f,
  5.40552884e-02f, -2.96499413e-02f, -1.45791516e-01f, -1.67852622e-02f, 1.08144522e-01f, 1.38895996e-02f, 4.07308042e-02f, 1.03164926e-01f, 1.53570464e-02f, 6.76456317e-02f,
  8.24508518e-02f, 6.10552728e-03f, 8.76421109e-02f, -8.57947022e-03f, 7.92460367e-02f, -1.05846897e-02f, -8.77362639e-02f, 8.05446580e-02f, -2.40635909e-02f, -1.00688348e-02f,
  -9.30559263e-02f, -1.01607926e-01f, 5.29845990e-02f, 1.40243890e-02f, 4.62310277e-02f, 2.73785405e-02f, 5.13581857e-02f, -5.97592443e-02f, 9.59372371e-02f, -4.39106894e-04f,
  7.57515207e-02f, 5.41009055e-03f, -5.93750440e-02f, 1.49540156e-02f, -6.85085505e-02f, -6.14640526e-02f, -4.12167720e-02f, -4.98331152e-02f, 7.30822608e-02f, 4.05339487e-02f,
  -1.11216739e-01f, -1.61172599e-02f, -9.64271650e-03f, 7.42147565e-02f, -1.36595350e-02f, 3.14244740e-02f, -8.73586237e-02f, -2.22902168e-02f, 1.47792120e-02f, 1.10387102e-01f,
  -1.31704137e-01f, -3.00202221e-01f, -1.29744992e-01f, -3.19097899e-02f, -2.56817639e-02f, 3.84897715e-03f, -2.88694482e-02f, -7.51876235e-02f, -3.73731330e-02f, -7.90412053e-02f,
  -1.15809757e-02f, 7.35971332e-02f, 3.21848653e-02f, -3.63006927e-02f, -3.98226045e-02f, -4.47644889e-02f, 5.24105616e-02f, -4.22969647e-02f, -3.18373218e-02f, -9.29664373e-02f,
  -6.17594365e-03f, 6.93128929e-02f, 6.68193474e-02f, 4.57301848e-02f, -2.66100522e-02f, 2.20060591e-02f, -6.74688444e-02f, 2.47327834e-02f, 6.64904565e-02f, -2.55905483e-02f,
  -2.49517104e-03f, 3.08242321e-01f, 1.66651025e-01f, -1.53306186e-01f, -7.81243443e-02f, -7.17950761e-02f, -2.80194491e-01f, 1.67877171e-02f, -1.85443889e-02f, 5.06221317e-02f,
  -2.26171896e-01f, 1.99964479e-01f, -8.44409391e-02f, -1.27557799e-01f, -2.42472902e-01f, -1.26128003e-01f, -2.61502475e-01f, -1.98936358e-01f, -3.69008514e-03f, -2.31884167e-01f,
  -5.75446114e-02f, -3.23986858e-01f, -7.08216503e-02f, -1.00120001e-01f, -1.37813529e-02f, -5.15728537e-03f, -1.24145649e-01f, -6.42725034e-04f, -7.93999583e-02f, 1.12117231e-02f,
  -8.35620239e-02f, -4.55313921e-02f, -1.66656990e-02f, 4.11136933e-02f, -3.41370590e-02f, 1.18614426e-02f, 7.69318864e-02f, -3.28380987e-02f, 3.53999436e-02f, 4.69578058e-02f,
  9.56913680e-02f, 1.06342107e-01f, -2.13776790e-02f, -7.36016734e-03f, 6.21875748e-03f, 9.06873122e-02f, 8.89564976e-02f, -4.37267171e-03f, -3.85517515e-02f, 1.29135519e-01f,
  1.55507419e-02f, 1.46261767e-01f, 1.22855589e-01f, 6.61385730e-02f, 5.88005111e-02f, -8.06273147e-03f, 1.29847229e-02f, 1.33913219e-01f, 7.96463341e-02f, -1.98747357e-03f,
  4.81633730e-02f, -2.37767566e-02f, -3.18551762e-03f, -2.72378214e-02f, -1.17825031e-01f, -4.01467420e-02f, -9.79853496e-02f, -2.35683806e-02f, -3.86625268e-02f, 5.77922054e-02f,
  7.41836578e-02f, 4.12742421e-02f, -7.37547278e-02f, -8.67433995e-02f, -6.97029531e-02f, -4.92166281e-02f, -5.22691049e-02f, 9.94808599e-02f, -1.95767637e-02f, -2.41869930e-02f,
  -1.53158633e-02f, -2.82634664e-02f, -7.60583486e-03f, 2.45507862e-02f, 3.19439247e-02f, -1.01172039e-02f, 1.29188776e-01f, 5.17002530e-02f, -8.59482586e-02f, -4.34184633e-02f,
  -1.47812933e-01f, -2.04632074e-01f, -9.94188711e-02f, -2.70741936e-02f, -5.85981756e-02f, 3.52342390e-02f, -1.59692653e-02f, 4.15305272e-02f, 3.54106501e-02f, 3.98936570e-02f,
  1.44077763e-01f, -1.37410918e-02f, -5.26488274e-02f, -4.86241318e-02f, -1.21294826e-01f, -2.39012539e-02f, -1.73256127e-03f, -9.27161872e-02f, -9.50535685e-02f, 2.81357821e-02f,
  3.73008139e-02f, -3.87662537e-02f, 1.37026176e-01f, 9.19015706e-02f, 2.65445374e-02f, -9.81550547e-04f, 6.97179371e-03f, 8.63739625e-02f, -1.55836800e-02f, 7.22337663e-02f,
  -3.42124134e-01f, 2.22081289e-01f, -3.56505699e-02f, 1.30893156e-01f, -2.71957040e-01f, 1.21273667e-01f, 2.66601920e-01f, -1.28698900e-01f, 1.76521569e-01f, 2.59169608e-01f,
  -3.08557451e-02f, -1.24381622e-02f, 1.48247480e-01f, 1.17985010e-01f, -1.57822460e-01f, 2.56096393e-01f, 2.06600368e-01f, 1.93133190e-01f, -6.74867257e-02f, -2.82872561e-02f,
  -5.52811734e-02f, 7.93226585e-02f, -3.20589170e-02f, -1.54427439e-01f, -1.89103693e-01f, -2.01394409e-01f, -4.45655286e-02f, -1.88659832e-01f, -5.98269589e-02f, -1.03032984e-01f,
  -6.67718649e-02f, -7.99374133e-02f, -1.34337142e-01f, -4.14487384e-02f, 2.76627336e-02f, 5.59850074e-02f, 1.11078195e-01f, -7.70422146e-02f, -7.28716403e-02f, -1.92770883e-02f,
  3.91709134e-02f, 1.44299399e-02f, 1.95015483e-02f, -7.17661604e-02f, -7.83897787e-02f, -4.86055501e-02f, -8.87495428e-02f, -1.15515918e-01f, -1.78690907e-02f, -1.32085294e-01f,
  -7.50527903e-02f, -1.00165926e-01f, -1.08051255e-01f, 5.40281273e-02f, -1.10934347e-01f, -3.02389003e-02f, 9.63172764e-02f, -3.82862911e-02f, 5.07648587e-02f, 2.60928292e-02f,
  -2.48300750e-02f, 1.85726389e-01f, -4.92107868e-03f, 6.26583770e-02f, -7.66469389e-02f, -1.20168753e-01f, 2.01536156e-02f, -3.08620986e-02f, -6.77787811e-02f, 1.50000118e-02f,
  -1.40091742e-03f, 1.30341845e-02f, -5.07982075e-02f, -4.70270552e-02f, 3.61373052e-02f, 1.08495712e-01f, -5.46596795e-02f, -5.68063557e-03f, -6.54329313e-03f, -1.18941972e-02f,
  -4.96195555e-02f, -1.74263343e-02f, -4.93952036e-02f, 8.88563097e-02f, 9.53507125e-02f, -1.18610784e-01f, 1.18551128e-01f, -6.56730682e-02f, 4.59629297e-03f, 3.91549990e-02f,
  1.52328923e-01f, 1.61067873e-01f, -5.47481738e-02f, -8.00515786e-02f, 1.09091617e-01f, -5.55971153e-02f, 3.23217250e-02f, -6.57955036e-02f, 1.03071192e-02f, 3.97584736e-02f,
  -6.13708934e-03f, 4.01612259e-02f, 2.23033689e-02f, 2.74808053e-02f, -5.08508570e-02f, 1.02274474e-02f, 9.31047425e-02f, 5.06304912e-02f, 9.18252021e-02f, -2.61379983e-02f,
  -6.12660348e-02f, -2.41489448e-02f, -4.24565636e-02f, 6.93618879e-02f, -2.84942016e-02f, -8.11358541e-03f, -6.97100163e-02f, -5.58619462e-02f, -6.79266602e-02f, 1.04857251e-01f,
  -1.89155132e-01f, 1.39466345e-01f, -3.13267112e-01f, 1.26072034e-01f, -2.15258542e-02f, -7.34432489e-02f, 8.69845748e-02f, -7.87467286e-02f, 1.68119557e-02f, 3.54446411e-01f,
  4.53234345e-01f, -1.28453255e-01f, 2.56650537e-01f, 5.33415139e-01f, -2.39827797e-01f, 1.48387462e-01f, 1.28293931e-01f, 1.53871492e-01f, -1.44886225e-01f, 8.32492299e-03f,
  -9.70324501e-02f, 3.70276958e-01f, 1.03023261e-01f, -1.32888302e-01f, 2.09208094e-02f, -3.22724432e-01f, 2.08869042e-05f, -1.12021625e-01f, 1.35276124e-01f, -3.90382786e-03f,
  1.70994535e-01f, 2.35761777e-01f, -2.02201027e-02f, -6.91634789e-02f, -5.04597425e-02f, -7.31156841e-02f, -6.15997054e-02f, -1.60719648e-01f, -3.97262983e-02f, -3.15303076e-03f,
  -6.52477220e-02f, -4.08768617e-02f, -8.66261721e-02f, 9.27565768e-02f, -5.77643141e-02f, -5.70030622e-02f, 3.13828140e-02f, 2.67928131e-02f, -2.35017091e-02f, 1.02312295e-02f,
  8.62786397e-02f, -7.52128810e-02f, 4.44852887e-03f, -2.46825609e-02f, -4.54961620e-02f, -5.42581677e-02f, -1.57056049e-01f, -6.75120875e-02f, -8.27462412e-03f, -2.15483587e-02f,
  -9.41198245e-02f, 3.28321829e-02f, 6.88414350e-02f, 1.31520540e-01f, -3.90989296e-02f, 1.80998072e-02f, 9.93083194e-02f, 3.99248488e-03f, -7.24483803e-02f, 1.62883848e-02f,
  2.89680697e-02f, -3.91074717e-02f, 8.87956172e-02f, 4.58346903e-02f, -4.25067125e-03f, -5.85383922e-02f, -9.63016674e-02f, 4.48021367e-02f, 9.90774184e-02f, -3.55720371e-02f,
  -1.41129140e-02f, -9.00677126e-03f, 1.18672494e-02f, 3.21553834e-02f, 5.60806617e-02f, 7.77567849e-02f, 1.43176481e-01f, 3.00727058e-02f, -2.32879072e-02f, 8.81159306e-03f,
  4.67452966e-02f, -1.75600424e-02f, -1.32187763e-02f, 6.45109499e-03f, -1.18160442e-01f, -2.97725257e-02f, -8.12853277e-02f, -1.89728484e-01f, -3.79843661e-03f, -2.69813035e-02f,
  -8.02488402e-02f, -6.58279061e-02f, 1.59435924e-02f, 1.11421488e-01f, -1.25359818e-01f, 9.31107998e-02f, 9.38684866e-03f, -4.93890606e-02f, -7.63959363e-02f, -1.34731516e-01f,
  -6.59909993e-02f, -4.44808416e-02f, -1.36683658e-01f, -1.29780853e-02f, -6.54078349e-02f, 1.34445122e-02f, -9.85315517e-02f, 7.23301396e-02f, -1.00435773e-02f, 6.33799508e-02f,
  -2.63592094e-01f, 3.83572996e-01f, 1.45419195e-01f, 1.92138609e-02f, 2.55430311e-01f, 4.34615165e-01f, 1.40307724e-01f, 3.06338221e-01f, 3.94432962e-01f, -1.30622715e-01f,
  -1.35988861e-01f, 3.35409380e-02f, -5.10697998e-02f, -8.85673761e-02f, 1.38433591e-01f, 1.47800446e-01f, 1.35141343e-01f, 1.50781229e-01f, 2.45260671e-01f, -1.66210495e-02f,
  1.01699769e-01f, 7.82076095e-04f, -1.79341972e-01f, 2.23783311e-02f, -6.34990335e-02f, 4.75987233e-03f, -1.22079425e-01f, 2.30264112e-01f, -2.11864188e-02f, 1.91436872e-01f,
  -6.31107986e-02f, -1.01184979e-01f, -2.56353438e-01f, -1.29613444e-01f, -1.51091620e-01f, -6.23667091e-02f, 9.49538127e-02f, -1.09721139e-01f, -3.57117094e-02f, -4.48871739e-02f,
  -1.06400661e-01f, -3.26049142e-02f, -3.77215631e-02f, 2.21900381e-02f, 8.80172327e-02f, 3.19894962e-02f, -6.85591921e-02f, -6.96665049e-02f, 1.53851211e-02f, 3.03436127e-02f,
  -7.39145279e-02f, -3.25991772e-02f, -1.52517378e-01f, 1.32469967e-01f, -1.28044244e-02f, 2.54633874e-02f, 4.91442857e-03f, 8.19395781e-02f, 9.08196792e-02f, 9.11675543e-02f,
  1.33814082e-01f, 1.50428548e-01f, -1.25496209e-01f, -3.41497622e-02f, -4.84706536e-02f, -3.75298299e-02f, -3.58256735e-02f, -1.04906350e-01f, -1.15492634e-01f, -4.88313995e-02f,
  -4.89128418e-02f, 4.45050932e-03f, 4.30827476e-02f, 5.80325723e-02f, 8.55236780e-03f, -6.65409165e-03f, -1.11862719e-02f, 3.98192666e-02f, -1.20334479e-03f, -7.63817728e-02f,
  7.83098415e-02f, -2.03583222e-02f, -1.61986664e-01f, 3.00624724e-02f, -3.25169936e-02f, -9.29359645e-02f, 6.82633892e-02f, -1.80311099e-01f, -4.18960005e-02f, 3.49652022e-02f,
  2.47123823e-01f, 4.20709759e-01f, -7.37875178e-02f, -1.25738144e-01f, -1.35120638e-02f, -8.92132446e-02f, 4.38220240e-02f, -8.55164528e-02f, 8.64445642e-02f, 1.06880322e-01f,
  -6.27137274e-02f, -1.69759274e-01f, -8.12755059e-03f, -2.76072789e-02f, 7.40008280e-02f, -7.53275165e-03f, -6.43239990e-02f, 4.49062623e-02f, 4.23442461e-02f, 9.59200710e-02f,
  -6.96560368e-02f, -3.74230277e-03f, -1.15396872e-01f, -2.36083823e-03f, -1.18034273e-01f, -3.52139026e-02f, 1.37433603e-01f, -3.48604731e-02f, -1.01959050e-01f, 9.26926136e-02f,
  -5.26244402e-01f, 2.92911619e-01f, -1.06461786e-01f, 5.34812436e-02f, -1.65398061e-01f, -2.01042101e-01f, 1.58931807e-01f, -8.73835161e-02f, 1.07724749e-01f, 4.07375962e-01f,
  2.17462063e-01f, -7.48366565e-02f, 2.16416568e-01f, 2.52122402e-01f, -4.39791322e-01f, 1.58467099e-01f, 1.26556307e-02f, 8.79810080e-02f, 5.03131561e-02f, -9.36445147e-02f,
  -1.14797123e-01f, 9.85861197e-02f, -4.34219092e-02f, 2.18731780e-02f, -1.77597135e-01f, -2.30291318e-02f, -4.18437533e-02f, -4.26481478e-02f, -2.71462481e-02f, -7.57873952e-02f,
  -1.29843712e-01f, -4.50373404e-02f, -5.08089662e-02f, -1.52287349e-01f, -8.33297223e-02f, -2.16731895e-02f, -1.35030136e-01f, 5.65242544e-02f, 2.33995914e-02f, -9.76558495e-03f,
  3.84460390e-02f, 4.68870765e-03f, 4.96330895e-02f, 8.19617733e-02f, -2.83545461e-02f, -4.97457944e-02f, 8.70871693e-02f, -4.74241525e-02f, 1.34465436e-03f, -2.39891908e-03f,
  1.10156894e-01f, -3.80261652e-02f, 2.25282591e-02f, -7.06052454e-03f, -9.91026610e-02f, 7.25900009e-02f, 3.46106775e-02f, -2.37814877e-02f, -4.92911823e-02f, -6.61140755e-02f,
  1.01767473e-01f, 7.14319479e-03f, 1.01548657e-01f, 6.10031039e-02f, 9.86053720e-02f, -8.58728588e-02f, 5.64447306e-02f, -1.94184901e-03f, 3.87070403e-02f, -1.09593101e-01f,
  -7.88442865e-02f, -9.49858725e-02f, -1.01525076e-01f, 1.50864879e-02f, 4.43247519e-02f, -2.82194233e-03f, 1.25628011e-03f, 5.41195124e-02f, -1.57652840e-01f, -3.09830229e-03f,
  1.00313313e-01f, 3.47329490e-02f, -8.77887383e-02f, -1.73472732e-01f, 3.92801054e-02f, 4.73516807e-02f, 7.48365745e-02f, -4.40679118e-02f, -6.05881773e-03f, -9.57308635e-02f,
  -3.06307673e-01f, -2.63204336e-01f, 1.57682803e-02f, -7.91221857e-02f, 5.87635525e-02f, -5.22685051e-02f, 3.32957692e-02f, -7.03655034e-02f, 2.53713019e-02f, -1.19334556e-01f,
  4.36241627e-02f, -1.55294789e-02f, -4.35108319e-02f, -3.78319994e-02f, -1.04847560e-02f, -8.47223848e-02f, 5.93585335e-02f, -6.61551505e-02f, -6.66187378e-03f, -8.16657692e-02f,
  -2.13619899e-02f, 8.71586241e-03f, 1.89200174e-02f, -9.01599824e-02f, 3.73849347e-02f, 3.64038199e-02f, -4.78024632e-02f, 3.90355848e-02f, 6.74739387e-03f, -9.33219045e-02f,
  3.13452393e-01f, -2.16180012e-01f, -1.41016960e-01f, 4.32142705e-01f, 1.43352104e-02f, 3.27930123e-01f, 4.58591312e-01f, 9.70828012e-02f, 4.15288121e-01f, 1.12441212e-01f,
  1.56105861e-01f, -1.44927055e-01f, 2.67227124e-02f, 3.41685981e-01f, 2.15861604e-01f, 2.15585828e-01f, 3.87524396e-01f, 2.52528608e-01f, 9.30627733e-02f, 4.34001386e-02f,
  1.26889467e-01f, 2.64002919e-01f, -1.16324224e-01f, -1.80806413e-01f, -7.43003637e-02f, -2.39811048e-01f, -2.29102179e-01f, -2.26622939e-01f, -1.29196681e-02f, -3.44756171e-02f,
  4.40702960e-02f, 9.14746523e-02f, -5.67054041e-02f, -4.74350117e-02f, -2.28316057e-02f, 6.84598461e-02f, 3.23234238e-02f, -1.60731465e-01f, 9.60106310e-03f, 1.47444531e-02f,
  2.52402648e-02f, 6.75342306e-02f, 1.74686331e-02f, -7.65307397e-02f, 1.70670748e-02f, 1.31820468e-03f, 4.30128835e-02f, -5.61218662e-03f, -3.10556218e-02f, -6.80899322e-02f,
  1.06390715e-01f, -2.49074847e-02f, 1.19908355e-01f, 1.08999554e-02f, -2.54935604e-02f, 1.18065648e-01f, -6.16832897e-02f, -1.49644941e-01f, 8.22325982e-03f, 3.01745944e-02f,
  -8.53595808e-02f, 5.47601990e-02f, 1.30727783e-01f, 1.07502081e-02f, -2.30067726e-02f, -3.85952108e-02f, 9.94002894e-02f, -1.28116282e-02f, 1.85517762e-02f, -7.53440782e-02f,
  5.63333668e-02f, -5.34521975e-02f, 2.37169191e-02f, 1.59810483e-02f, 1.26711279e-01f, 2.43965932e-03f, -7.52327144e-02f, 2.35086158e-02f, 1.22496083e-01f, -2.58487947e-02f,
  -6.74691200e-02f, 5.76678151e-03f, -5.26957996e-02f, -9.34379622e-02f, -1.06062274e-02f, -3.14940177e-02f, 9.36678946e-02f, -1.98213011e-02f, -3.67126800e-02f, 6.14914373e-02f,
  9.86199602e-02f, -1.99369751e-02f, -9.94946901e-03f, -1.24797244e-02f, -1.02809191e-01f, 2.77526751e-02f, 9.61200371e-02f, -3.65332365e-02f, -2.05686949e-02f, 1.01546600e-01f,
  -1.19290361e-02f, 9.05739143e-02f, 6.84257299e-02f, -9.82034877e-02f, -2.77159363e-02f, 6.69324622e-02f, 1.61755502e-01f, -8.97004083e-02f, -6.13975823e-02f, -1.65002808e-01f,
  -3.91370580e-02f, 5.42695336e-02f, 3.20740342e-02f, 5.68783246e-02f, -7.69733265e-03f, -3.99795733e-02f, -3.25802900e-02f, -3.48179191e-02f, 3.25498953e-02f, 3.92596498e-02f,
  -2.80892961e-02f, -2.73868829e-01f, -3.24637920e-01f, -1.49992302e-01f, 2.06502646e-01f, 3.74678969e-01f, 3.32044214e-01f, -1.13534845e-01f, -3.14642906e-01f, 1.63891599e-01f,
  3.23318154e-01f, 4.84680086e-02f, 5.82785606e-02f, 2.29492128e-01f, 3.65646034e-01f, 1.64997354e-01f, 1.55412704e-01f, 1.87642679e-01f, -4.52619679e-02f, -7.46945962e-02f,
  -1.14388168e-02f, 2.67205209e-01f, 5.45002259e-02f, 7.68257603e-02f, 1.89332321e-01f, -1.08375333e-01f, 1.98166296e-01f, 6.58417717e-02f, 2.90898919e-01f, 2.15130627e-01f,
  3.94554064e-02f, -1.06731176e-01f, -1.09526865e-01f, -1.24200724e-01f, 1.12873420e-01f, 1.11023575e-01f, 3.35833244e-02f, 2.49294668e-01f, 5.29778004e-02f, 1.25805447e-02f,
  1.41971767e-01f, -1.63959581e-02f, -8.63116086e-02f, 1.03016272e-01f, -5.91413528e-02f, -3.88420895e-02f, -3.45774554e-02f, -3.57007682e-02f, -8.00689086e-02f, 1.99353453e-02f,
  -3.75698768e-02f, -4.04114388e-02f, -3.11355125e-02f, -6.40673935e-02f, -2.49107443e-02f, -4.07111160e-02f, -3.33291516e-02f, 4.81379442e-02f, 2.84048496e-03f, -1.32423416e-02f,
  5.20965904e-02f, 7.12913740e-03f, -2.84581482e-02f, -7.73920417e-02f, 6.72693923e-02f, 3.16177607e-02f, 5.65831959e-02f, 1.09638080e-01f, -8.38518608e-03f, -4.87589203e-02f,
  -4.18274431e-03f, 3.76035571e-02f, -4.52937223e-02f, 4.62631360e-02f, 7.51009583e-02f, -5.05733639e-02f, 6.76778480e-02f, 2.66688354e-02f, -1.01992242e-01f, 8.44643340e-02f,
  6.34484515e-02f, 2.03888901e-02f, 3.37592661e-02f, -3.92566547e-02f, -6.77835643e-02f, 5.65522090e-02f, 2.45101955e-02f, -1.43698063e-02f, -3.00095025e-02f, 6.07818924e-02f,
  -2.93240100e-02f, -1.39048755e-01f, -1.06817104e-01f, -3.84751186e-02f, 5.31339832e-03f, 1.40353695e-01f, -1.50787067e-02f, 3.72636016e-03f, 6.74012080e-02f, 4.27893847e-02f,
  1.03943609e-01f, -1.97171010e-02f, -9.44041461e-02f, -3.66636775e-02f, -8.44930410e-02f, -3.25728115e-03f, 6.15753047e-02f, -4.96234260e-02f, -5.51856570e-02f, -7.67922103e-02f,
  2.27411110e-02f, 3.97798456e-02f, -1.25724645e-02f, -2.24668114e-03f, -4.79872935e-02f, 2.24831533e-02f, -3.22486530e-03f, -2.95477398e-02f, 9.16270688e-02f, -7.74418712e-02f,
  2.96175212e-01f, -2.82404497e-02f, -1.21896423e-01f, 8.98889452e-03f, -1.12546273e-02f, 1.12119913e-01f, -1.39109924e-01f, -9.17006433e-02f, -1.90336421e-01f, 5.25065400e-02f,
  -9.00236890e-02f, 1.55651465e-01f, -3.31234932e-01f, 2.43170872e-01f, 2.35430762e-01f, -2.14764595e-01f, 3.13353091e-01f, 1.77497968e-01f, -4.22021113e-02f, 1.14053540e-01f,
  2.69764587e-02f, 2.79284120e-01f, -1.28477469e-01f, 2.62408286e-01f, 2.16941908e-01f, 4.89050485e-02f, 7.49201626e-02f, -1.60657227e-01f, 2.39228308e-01f, 7.76759982e-02f,
  8.80565494e-04f, -8.57354794e-03f, 9.10223275e-03f, 3.41629051e-02f, -4.93703373e-02f, 6.04461916e-02f, 5.70034608e-03f, 3.32857855e-02f, -8.96625593e-02f, -8.05665329e-02f,
  9.01460797e-02f, 5.79454117e-02f, 7.61505514e-02f, 2.43150592e-02f, 1.09906919e-01f, 9.22022387e-02f, -8.73446744e-03f, -6.32198080e-02f, -8.93326476e-02f, -1.88605487e-02f,
  -6.03769012e-02f, -1.50829144e-02f, 1.83037184e-02f, -3.41373459e-02f, -5.88065200e-02f, 1.19825574e-02f, 9.31837186e-02f, -5.37792183e-02f, 9.49130729e-02f, 5.41065261e-02f,
  -1.10564260e-02f, 4.71218377e-02f, 3.22373286e-02f, 2.07785387e-02f, 3.49543244e-02f, -6.20733611e-02f, 1.36427004e-02f, 5.28252274e-02f, -2.96107437e-02f, 1.95958707e-02f,
  1.70939807e-02f, -3.03058680e-02f, -4.51568104e-02f, 6.69197887e-02f, 6.35252073e-02f, 5.53220175e-02f, -2.26582326e-02f, 2.64174249e-02f, -5.93518987e-02f, -5.02383672e-02f,
  -6.45086989e-02f, 6.62309006e-02f, -9.39721018e-02f, -6.03742264e-02f, 5.12653179e-02f, -4.29134369e-02f, 9.58347842e-02f, -1.85460374e-02f, -1.61906794e-01f, -6.76275864e-02f,
  5.23331277e-02f, 9.46476236e-02f, -8.58876184e-02f, 3.04799285e-02f, -3.29839289e-02f, 1.22767933e-01f, 7.83927739e-02f, 7.44431019e-02f, 3.24971080e-02f, 4.87868711e-02f,
  1.18915170e-01f, -6.42240196e-02f, -2.64416486e-02f, -5.40773571e-03f, 4.01334502e-02f, -5.90040497e-02f, 6.51474223e-02f, -1.35861978e-01f, 2.07496583e-02f, -1.62759572e-02f,
  4.15567979e-02f, -8.16430375e-02f, 1.20150909e-01f, -3.67869325e-02f, 8.38974714e-02f, -2.07557622e-02f, 5.51590063e-02f, 5.69015695e-03f, 6.47306517e-02f, -3.55080590e-02f,
  3.10791105e-01f, -1.07327409e-01f, -2.66733229e-01f, -1.18618824e-01f, -3.72007936e-02f, -1.89350724e-01f, -1.62910491e-01f, -7.14991540e-02f, 4.60078679e-02f, 2.12439343e-01f,
  6.65974244e-02f, 1.05633520e-01f, 1.22199744e-01f, 3.61164957e-02f, -2.68758945e-02f, 1.11962028e-01f, -2.69974321e-01f, -7.32780769e-02f, 1.03643984e-01f, -9.90683734e-02f,
  2.18533501e-02f, 8.30332339e-02f, -1.32463902e-01f, -2.07776800e-02f, 6.96505755e-02f, 7.85405468e-03f, -3.24949026e-02f, 4.44818363e-02f, -2.02669902e-03f, 4.48583253e-02f,
  5.15034236e-03f, 9.28825662e-02f, -8.85483697e-02f, 3.88204604e-02f, -1.20514169e-01f, -1.44390846e-02f, -1.04052499e-02f, -6.71710223e-02f, 5.49202599e-02f, -2.27583796e-02f,
  4.19744477e-02f, 1.06077954e-01f, -1.25452727e-01f, 1.26444399e-01f, 1.10744145e-02f, 4.51991381e-03f, 6.37665316e-02f, 5.36714680e-02f, -1.41571397e-02f, 6.99101239e-02f,
  2.59675831e-02f, -1.10769188e-02f, 4.48485501e-02f, -4.91697453e-02f, -6.96355477e-02f, 7.37924203e-02f, -1.03115344e-04f, -5.08839488e-02f, -7.14140758e-03f, -8.79157893e-03f,
  2.74694469e-02f, 1.00769497e-01f, 4.57931310e-02f, -6.41708542e-03f, -1.59116071e-02f, -3.82775553e-02f, 1.25510255e-02f, -1.10335819e-01f, 3.77821326e-02f, 1.46482401e-02f,
  -5.05910218e-02f, -6.88722953e-02f, 6.17191643e-02f, 7.17578977e-02f, 6.59061670e-02f, 4.75082844e-02f, -3.05080451e-02f, 7.00905547e-02f, -1.17348477e-01f, -6.83654845e-02f,
  1.00115739e-01f, 4.54578921e-02f, -2.95890328e-02f, -1.22750081e-01f, -6.57920353e-03f, 1.26660451e-01f, 7.54452571e-02f, 9.19679925e-02f, -3.36984880e-02f, -1.00009441e-01f,
  -1.38836294e-01f, -8.41554031e-02f, -3.21343392e-02f, -5.03071137e-02f, -5.41345216e-02f, 2.06062980e-02f, 4.29436378e-02f, -1.25526652e-01f, 2.62122210e-02f, 9.88721102e-03f,
  -5.22542037e-02f, -1.91623736e-02f, -1.04692534e-01f, 8.81115496e-02f, -6.75224289e-02f, -9.80241224e-02f, 1.66540116e-01f, 1.12947086e-02f, -5.02904989e-02f, -1.32394791e-01f,
  1.63634457e-02f, 3.23899537e-02f, 6.97747618e-02f, -1.04174845e-01f, -7.47238696e-02f, 8.50017220e-02f, 4.61722873e-02f, 6.96328431e-02f, 4.07353900e-02f, -1.04327410e-01f,
  -4.47691791e-03f, 1.23857170e-01f, 3.00416052e-01f, 1.92756280e-01f, -9.62614268e-02f, -7.75166694e-03f, 2.83023894e-01f, -1.45307317e-01f, -2.20303819e-01f, 3.93229648e-02f,
  1.38812646e-01f, 3.48951519e-01f, 2.07370952e-01f, 1.80334970e-02f, 1.87410600e-02f, -8.09167251e-02f, -5.51108271e-02f, 7.68017992e-02f, -9.28696841e-02f, -4.42362623e-03f,
  -5.08881547e-02f, -8.31942707e-02f, 1.58897996e-01f, -3.84853244e-01f, 1.61716461e-01f, -9.51203052e-03f, 6.35268614e-02f, 1.78382367e-01f, -8.89492221e-03f, 2.66434878e-01f,
  -6.86960891e-02f, -4.27817404e-02f, -4.23534885e-02f, -7.69849271e-02f, -4.13004868e-02f, -1.02829458e-02f, 8.20744485e-02f, 1.23729758e-01f, 1.15282349e-01f, 3.10422480e-02f,
  3.56973931e-02f, 2.40260828e-02f, -3.55041064e-02f, 1.01855844e-01f, -2.23036688e-02f, -4.85022329e-02f, 1.36935003e-02f, 6.64984360e-02f, 3.75232622e-02f, 1.14967152e-01f,
  6.07193671e-02f, 4.04177755e-02f, 8.32338482e-02f, 9.23492536e-02f, -4.51594032e-02f, 6.84090890e-03f, -6.80949818e-03f, 1.47133082e-01f, 3.80479754e-03f, -8.22407827e-02f,
  -1.34569360e-02f, 8.17084406e-03f, -1.30821131e-02f, 2.62327841e-03f, -3.66728604e-02f, -1.08194456e-01f, -1.08027324e-01f, 9.37520433e-03f, 8.75349045e-02f, 3.97871993e-02f,
  -7.33177885e-02f, -1.49963796e-01f, -2.55314093e-02f, 9.95772146e-03f, -1.25351384e-01f, 1.12144649e-02f, 1.13607878e-02f, 5.25981337e-02f, 7.69036636e-02f, -9.60814282e-02f,
  6.25156611e-02f, -5.53272571e-03f, 3.10293008e-02f, -1.40616447e-02f, 2.86358967e-02f, 5.38898408e-02f, 8.68662596e-02f, 1.30106537e-02f, 1.01584513e-02f, 1.37507245e-02f,
  -1.49882417e-02f, -6.69517294e-02f, -5.53148761e-02f, -7.93242678e-02f, 7.80244265e-03f, -5.92294596e-02f, -2.45239772e-02f, -1.78425357e-01f, 4.95868176e-02f, -1.07588239e-01f,
  -6.25220239e-02f, 5.81307039e-02f, -6.67870138e-03f, 6.48804009e-02f, -2.87627093e-02f, 7.98229128e-03f, 1.02846496e-01f, 1.29650101e-01f, 8.46617222e-02f, 1.35618094e-02f,
  7.08029941e-02f, 8.08960944e-02f, 8.99302494e-03f, -2.29355544e-02f, -4.89289351e-02f, 1.49809703e-01f, 2.40831412e-02f, 2.69370526e-02f, -3.31032425e-02f, 4.09764610e-02f,
  1.25711057e-02f, 3.53091434e-02f, 1.62076447e-02f, 2.15327561e-01f, 1.99326664e-01f, -3.07296008e-01f, -1.24635100e-01f, 8.86102542e-02f, 1.35318354e-01f, -1.74342722e-01f,
  -9.36766267e-02f, -1.32806420e-01f, -1.02447063e-01f, -5.08974865e-02f, -1.28348857e-01f, -3.23491931e-01f, 2.98270993e-02f, -7.34449252e-02f, -2.83447281e-02f, -5.30891344e-02f,
  -8.23324174e-03f, 1.43109605e-01f, -2.31837370e-02f, 2.02456579e-01f, 1.13009050e-01f, 1.21401191e-01f, 8.56321901e-02f, 1.22981556e-01f, -3.47878449e-02f, 7.86582753e-02f,
  -8.61886702e-03f, 1.50197327e-01f, 1.23977466e-02f, 2.83791106e-02f, -6.67595025e-03f, -1.76807120e-02f, -3.05773746e-02f, 1.25530735e-02f, -2.66621485e-02f, -1.00760274e-01f,
  -7.91715644e-03f, 3.06161176e-02f, 6.07336499e-03f, -7.37775723e-03f, 1.83059096e-01f, 4.36677709e-02f, -9.25440267e-02f, -9.47711021e-02f, -2.55122092e-02f, -1.38953552e-01f,
  -7.96639249e-02f, 2.58296519e-03f, 5.89247048e-02f, 4.00037877e-02f, 4.34970036e-02f, 4.62781377e-02f, -3.44745740e-02f, 1.40708927e-02f, -3.60571034e-02f, 4.99759763e-02f,
  3.95947136e-02f, 5.52519411e-03f, -6.73437864e-02f, 6.27330765e-02f, 1.12193748e-02f, 4.71730940e-02f, -1.50230434e-02f, -2.93067098e-02f, 6.03040829e-02f, 2.43974179e-02f,
  6.04682416e-02f, 5.24858497e-02f, -1.56792942e-02f, -1.72379930e-02f, -2.53300760e-02f, 1.74350757e-02f, 1.94318686e-02f, -6.34398237e-02f, 6.90151900e-02f, 2.83018835e-02f,
  -2.84264497e-02f, 4.38657738e-02f, -3.64215076e-02f, -4.43419889e-02f, -2.31113341e-02f, 5.56598231e-02f, -6.63189217e-02f, -1.00645609e-01f, -1.27768278e-01f, 5.30576222e-02f,
  -2.43216921e-02f, 8.82114246e-02f, -4.33128849e-02f, 8.29716921e-02f, -3.35003529e-03f, -5.15272170e-02f, -5.57776839e-02f, 3.70800309e-02f, 7.39863608e-03f, -1.36602923e-01f,
  4.36060205e-02f, -4.06775856e-03f, -2.92902123e-02f, 3.09033729e-02f, 1.80714563e-01f, -1.46204252e-02f, -6.52443171e-02f, 4.83399816e-02f, 7.61353821e-02f, -2.11920775e-02f,
  -6.80822693e-03f, -1.24436520e-01f, 1.35651171e-01f, 7.82557726e-02f, 3.51932794e-02f, 1.76330898e-02f, -3.26601155e-02f, 4.44502831e-02f, 9.47922915e-02f, 1.19005293e-02f,
  -8.36072713e-02f, -2.52507087e-02f, 1.30633041e-01f, -2.60463078e-02f, 2.28412617e-02f, -8.37889388e-02f, -9.84456092e-02f, 2.36165091e-01f, -5.52321263e-02f, -1.77641492e-02f,
  -9.41135809e-02f, -4.03870866e-02f, -3.85312214e-02f, -2.40061596e-01f, -2.60736227e-01f, -3.49094719e-01f, 4.06759828e-02f, -1.01419352e-01f, -1.50787175e-01f, 2.01896504e-01f,
  9.59233567e-02f, -7.82203004e-02f, 2.24373102e-01f, 1.92226678e-01f, 1.28492266e-01f, 2.78487802e-01f, 1.54525742e-01f, 7.65294358e-02f, 2.33638793e-01f, 5.17558455e-02f,
  -7.96133950e-02f, -4.51118499e-02f, 1.26692504e-01f, -6.53518885e-02f, 1.93926483e-01f, 6.18731081e-02f, 4.48102579e-02f, -4.51723821e-02f, -2.20859759e-02f, 5.91384582e-02f,
  9.94185209e-02f, 3.61784152e-03f, -5.56711573e-03f, -1.61738507e-02f, 9.62346643e-02f, -1.10904248e-02f, 2.46413480e-02f, 8.06329027e-03f, -5.44785112e-02f, 4.15713824e-02f,
  -1.26846908e-02f, 8.55794735e-03f, 9.42937061e-02f, 1.26185250e-02f, 1.18218191e-01f, 3.06788199e-02f, 3.71584520e-02f, 2.08106965e-01f, -4.52421308e-02f, 1.15935422e-01f,
  1.36556685e-01f, -3.17207277e-02f, -8.88254046e-02f, -1.66672021e-01f, -1.65579408e-01f, -1.38100684e-01f, -2.45141879e-01f, -1.15572073e-01f, 1.05509814e-02f, -2.59171072e-02f,
  -7.24377995e-03f, 1.16083007e-02f, -1.40678853e-01f, -1.02077857e-01f, 8.90597049e-03f, -1.01425797e-01f, 4.74848337e-02f, 4.55050059e-02f, 1.16652682e-01f, -6.16275258e-02f,
  -1.92125306e-01f, -7.19685107e-02f, 6.12444729e-02f, 3.23873311e-02f, -1.92440063e-01f, 4.91785780e-02f, 2.33435389e-02f, 9.31019261e-02f, 1.06129628e-02f, 5.97481988e-02f,
  2.95064524e-02f, 1.21896282e-01f, 8.63923430e-02f, -6.73987865e-02f, -7.53754303e-02f, -4.06615399e-02f, -9.99968648e-02f, 2.90684253e-02f, 2.24529821e-02f, 3.14890989e-03f,
  2.60295868e-01f, 9.92292613e-02f, -9.14421976e-02f, -9.68998484e-03f, 5.65021150e-02f, 1.03598736e-01f, -5.90732961e-04f, 2.07589101e-02f, 1.52684867e-01f, 1.67686343e-01f,
  5.57419620e-02f, 3.30370441e-02f, 3.46311554e-02f, 1.11149147e-01f, 7.39785656e-02f, 1.02466784e-01f, -3.10681702e-04f, 1.96758911e-01f, -1.11483848e-02f, 7.28843585e-02f,
  -2.40269378e-01f, -1.54829724e-02f, 9.89993103e-03f, -3.64125282e-01f, -1.50546402e-01f, 4.42635030e-01f, -1.68999750e-02f, 5.68698980e-02f, -2.84685820e-01f, 4.47263978e-02f,
  -1.32478714e-01f, -2.24177852e-01f, 1.02426127e-01f, -2.82028913e-01f, 4.49382663e-02f, 1.14213064e-01f, -9.66405943e-02f, -1.66558847e-01f, -1.53136328e-01f, 6.58456683e-02f,
  -1.41859293e-01f, -1.20126262e-01f, 6.37825206e-03f, 4.38034572e-02f, -2.43699044e-01f, -6.72559589e-02f, -9.16613936e-02f, -1.41763344e-01f, -1.93989217e-01f, -1.88459381e-01f,
  6.65364861e-02f, -1.57854408e-01f, 1.25668123e-01f, 1.26970381e-01f, 1.01379193e-01f, 7.28383381e-03f, -5.85285313e-02f, -3.48682366e-02f, -1.59766287e-01f, -1.40732452e-02f,
  -3.50964852e-02f, 8.18236396e-02f, 2.06915047e-02f, -7.48668388e-02f, -1.66482612e-01f, -1.27072498e-01f, 6.60057366e-02f, 8.02351758e-02f, 1.36481106e-01f, 6.80966079e-02f,
  5.81354275e-02f, 3.19296010e-02f, -4.79800738e-02f, -1.27256587e-01f, -8.17316920e-02f, 3.01717091e-02f, 1.43633753e-01f, -7.79139111e-03f, -4.25202549e-02f, -1.61613021e-02f,
  -7.31148049e-02f, 7.73583353e-02f, 1.24517567e-01f, 5.83788799e-03f, 8.66254419e-03f, 4.92095463e-02f, 2.82123014e-02f, -2.90699303e-02f, -2.37343665e-02f, 8.07527006e-02f,
  -9.24518928e-02f, -7.96162412e-02f, 1.30154327e-01f, 9.55192745e-02f, 7.68517330e-02f, 6.79872259e-02f, 6.58095721e-03f, -9.47431922e-02f, -8.65369216e-02f, 1.66259259e-01f,
  -5.91829419e-03f, -3.19894105e-02f, 8.27205542e-04f, 4.91966382e-02f, 1.37777239e-01f, -4.82804095e-03f, -5.68423383e-02f, 1.36136832e-02f, 7.71063641e-02f, -1.28158089e-02f,
  5.29818274e-02f, 1.37627155e-01f, 8.48314539e-02f, 4.10840400e-02f, 6.80308416e-02f, -2.42883246e-02f, -4.45655212e-02f, 3.07649914e-02f, -1.32882506e-01f, 8.04016516e-02f,
  -8.59077722e-02f, -1.09639084e-02f, 1.53430298e-01f, -4.92115803e-02f, -8.17719921e-02f, 1.39257327e-01f, 2.77509764e-02f, -2.11736113e-02f, 7.94252157e-02f, 8.16556513e-02f,
  9.16743372e-03f, -2.68540834e-03f, -8.29211771e-02f, 1.95001308e-02f, -1.11169659e-01f, 1.29619921e-02f, 1.18834414e-01f, -5.78914993e-02f, -1.13987215e-01f, -1.53901882e-03f,
  2.37305179e-01f, -2.12845057e-01f, 1.40377000e-01f, 1.79287866e-01f, 1.29031777e-01f, -1.37324095e-01f, 1.37696043e-01f, -2.81634461e-02f, -8.15957636e-02f, -3.94268811e-01f,
  9.42631811e-02f, -1.20393753e-01f, 1.95352465e-01f, -3.58648226e-02f, 2.70428479e-01f, 1.58111781e-01f, 9.67713422e-04f, -1.46102488e-01f, -3.90008208e-03f, 1.84694737e-01f,
  1.25319064e-01f, 6.56781811e-03f, 3.45168918e-01f, -7.57196546e-02f, 1.07620142e-01f, -6.84955269e-02f, 3.04285064e-02f, 1.74981132e-01f, -2.58640945e-01f, -5.29694445e-02f,
  1.10043675e-01f, 1.92996383e-01f, 1.74215108e-01f, -2.30731051e-02f, 5.02817519e-02f, -4.93588746e-02f, -6.42553493e-02f, 5.11021651e-02f, 3.89053449e-02f, 1.51856523e-02f,
  -5.75514808e-02f, -1.58569768e-01f, -2.27132421e-02f, 3.06407753e-02f, 1.67959575e-02f, -2.78634187e-02f, -2.80666817e-02f, -2.85054222e-02f, 2.00740565e-02f, 2.97736600e-02f,
  5.50645478e-02f, -2.75203027e-02f, 7.61693940e-02f, -6.95628822e-02f, 5.39849885e-03f, -4.78566475e-02f, -6.94626868e-02f, 9.52740107e-03f, -3.04799788e-02f, -5.60508147e-02f,
  1.00957528e-02f, -7.87709877e-02f, 5.39091788e-02f, 1.70404278e-02f, 1.23760179e-02f, -8.90996829e-02f, 1.56216519e-02f, -2.22355779e-02f, 2.60362606e-02f, 3.97297964e-02f,
  -1.41113102e-02f, 6.50580078e-02f, 1.58786148e-01f, -7.56389275e-02f, -8.04887712e-02f, -3.03839380e-03f, 1.04648069e-01f, -4.15125191e-02f, 6.80362210e-02f, 2.58964971e-02f,
  -1.57108624e-02f, -3.14721055e-02f, 5.31475432e-02f, 1.47190586e-01f, 3.78330201e-02f, -4.27668393e-02f, -9.43679810e-02f, 3.06843780e-02f, 1.67647570e-01f, 1.00790426e-01f,
  1.00331508e-01f, -1.09551977e-02f, 1.05506718e-01f, -7.30170356e-03f, 3.46242078e-02f, 1.43764345e-02f, -3.91762611e-03f, -6.49417266e-02f, -3.62081565e-02f, 3.23080681e-02f,
  -1.45719156e-01f, 3.00526470e-02f, -3.55779962e-03f, 1.63860004e-02f, -6.52066767e-02f, 2.21126098e-02f, -8.19732845e-02f, -8.70217662e-03f, 6.71431050e-02f, -3.67455259e-02f,
  -2.12432779e-02f, 1.95788816e-02f, -5.48927709e-02f, -8.10129791e-02f, -1.56724349e-01f, 8.83840676e-03f, -7.62544498e-02f, -6.32273480e-02f, 9.41720325e-03f, -8.00970122e-02f,
  1.37332842e-01f, 1.92686409e-01f, 3.77472311e-01f, -2.82226294e-01f, -1.70762613e-01f, 4.20994721e-02f, -2.53739297e-01f, 5.92179410e-02f, -6.69035837e-02f, 4.38521570e-03f,
  -1.87043473e-01f, 1.45612285e-01f, -6.13061301e-02f, -1.27425119e-01f, 1.19189583e-01f, 2.40395237e-02f, -2.61487156e-01f, -2.66164303e-01f, -1.47576451e-01f, -2.64583737e-01f,
  -2.14177877e-01f, -5.80124199e-01f, 7.60352463e-02f, -3.93237770e-01f, -2.23959059e-01f, 4.17483635e-02f, -1.35651127e-01f, -9.80136767e-02f, 1.60257961e-03f, -2.42428537e-02f,
  6.68499246e-02f, -1.80003922e-02f, 2.08574682e-01f, 1.18256532e-01f, 1.86645258e-02f, 2.71857828e-02f, -2.62415688e-02f, -5.14595024e-03f, -1.64514147e-02f, 8.38219300e-02f,
  -5.75223118e-02f, -8.97705257e-02f, 5.27797155e-02f, 6.98159635e-02f, -8.11110660e-02f, -9.58831143e-03f, -1.12973610e-02f, 1.51441664e-01f, 4.27402183e-02f, 1.25816852e-01f,
  3.93230915e-02f, 1.92806259e-01f, 5.76502457e-02f, -2.42637619e-02f, -5.25824092e-02f, 1.06607666e-02f, 1.32071987e-01f, 3.92638780e-02f, -5.95316812e-02f, 6.11046888e-02f,
  1.25299515e-02f, -9.71769691e-02f, -7.26125762e-02f, -2.91791055e-02f, -3.57300229e-02f, 3.36993113e-03f, -6.31912798e-03f, 4.76811118e-02f, -5.06630428e-02f, -5.98920435e-02f,
  -1.59475222e-01f, -7.10773328e-03f, -9.35418233e-02f, -2.16435865e-02f, 1.60302538e-02f, 1.51385918e-01f, 7.45261684e-02f, 8.56768806e-03f, -1.00039937e-01f, 1.08519070e-01f,
  -2.42062919e-02f, -8.90367404e-02f, -5.45865148e-02f, -1.37770131e-01f, -5.45889959e-02f, 5.92519119e-02f, -1.15577400e-01f, 1.15997933e-01f, 1.34955004e-01f, -1.69056028e-01f,
  7.53453821e-02f, -1.37368172e-01f, 5.73606007e-02f, 4.51614596e-02f, 4.87841778e-02f, 7.73715749e-02f, 3.20189446e-02f, 5.22459038e-02f, 1.04378285e-02f, -7.93083385e-02f,
  -3.31014320e-02f, 3.03406958e-02f, 3.40742134e-02f, 6.81115985e-02f, -1.42899275e-01f, 1.36876712e-02f, -2.05056950e-01f, -9.12506320e-03f, -1.08465622e-03f, 4.10915911e-02f,
  -7.58238658e-02f, -6.30952418e-02f, -1.59967840e-02f, -1.50985822e-01f, -1.53395861e-01f, -2.12362129e-02f, 1.09631218e-01f, 3.18600833e-02f, -1.41778231e-01f, -2.68013030e-02f,
  -4.17525351e-01f, -1.01960823e-01f, 1.09520204e-01f, 1.87210403e-02f, -3.17654163e-01f, 7.10996240e-02f, 4.67141598e-01f, -2.40806460e-01f, -1.95512250e-01f, 1.84799850e-01f,
  1.12102795e-02f, -1.15334071e-01f, 2.80600905e-01f, 1.35542572e-01f, 1.94774747e-01f, 3.79326135e-01f, 1.67494982e-01f, 1.56442717e-01f, -9.47180241e-02f, -1.08923115e-01f,
  -7.83537701e-02f, -1.01647414e-01f, 4.06002283e-01f, -3.06992054e-01f, -1.65522277e-01f, -2.48797417e-01f, 7.26232082e-02f, -3.04932203e-02f, -5.88471703e-02f, -2.15767790e-02f,
  -1.42567992e-01f, -2.45855615e-01f, 8.85146018e-03f, -1.91174708e-02f, -2.02662740e-02f, 7.79200569e-02f, 6.17090054e-02f, 1.76675707e-01f, -4.04350795e-02f, -6.32109046e-02f,
  9.30094421e-02f, -3.24308313e-02f, -1.41163096e-01f, 1.63627733e-02f, -4.65270616e-02f, -1.77058607e-01f, -3.90337221e-02f, -7.95773044e-02f, -1.38989061e-01f, 1.54790450e-02f,
  1.14725642e-01f, -3.23296934e-02f, -4.18017656e-02f, 5.21352552e-02f, -2.36140229e-02f, -1.16815373e-01f, 1.16261460e-01f, 1.41637623e-01f, -4.27674223e-03f, -1.44210160e-01f,
  1.29262730e-01f, 2.02190586e-06f, 2.43335310e-02f, 4.03783144e-03f, 6.47421479e-02f, 1.23980492e-02f, 1.32051572e-01f, 1.02238208e-01f, 2.38452777e-02f, -1.05489172e-01f,
  -1.58536762e-01f, 2.60228827e-03f, -1.82565361e-01f, 6.02042489e-02f, 2.35383939e-02f, -3.67405042e-02f, 8.94360021e-02f, -1.06079750e-01f, -6.09214306e-02f, 4.63309288e-02f,
  6.88400492e-02f, 5.09928912e-03f, -1.02783591e-01f, 1.69135258e-02f, 1.62732627e-04f, 2.43855417e-02f, 3.21491659e-02f, 2.17060745e-02f, -1.37493223e-01f, 1.15539590e-02f,
  -2.55034298e-01f, -2.28482589e-01f, -1.67502239e-02f, -6.75498620e-02f, 7.29435906e-02f, -1.02664210e-01f, 2.10452150e-03f, -5.68700023e-03f, 2.92066801e-02f, -7.88973570e-02f,
  -4.22994010e-02f, 9.12425369e-02f, -8.16949680e-02f, -1.28471389e-01f, 2.13075895e-02f, -1.19642861e-01f, 7.58875757e-02f, -1.25059277e-01f, -6.40736474e-03f, -1.31428555e-01f,
  4.37022978e-03f, -4.66052443e-02f, 4.61638495e-02f, -9.08644870e-02f, 1.39377028e-01f, -3.73175927e-02f, -9.91280749e-02f, -1.34952813e-02f, 6.97918832e-02f, -2.93189120e-02f,
  -9.90296528e-02f, -3.00936222e-01f, -2.17520311e-01f, -1.66540414e-01f, 1.25228852e-01f, -1.79413632e-02f, -1.87583104e-01f, -1.42893521e-02f, -1.70453951e-01f, 4.15941104e-02f,
  5.62049150e-02f, -2.11377591e-01f, -1.20223030e-01f, -3.46911937e-01f, -9.29048136e-02f, -2.61307716e-01f, -6.43273890e-02f, -6.78471848e-02f, -1.03208639e-01f, -1.94802433e-02f,
  4.11805101e-02f, -1.85504761e-02f, -1.22067511e-01f, 1.29033431e-01f, -3.89054865e-02f, 1.61040246e-01f, 3.54679495e-01f, 1.08566759e-02f, 1.05212472e-01f, 6.91063236e-03f,
  -1.73828110e-01f, -1.64968193e-01f, -1.63899019e-01f, -9.07958746e-02f, 4.34226729e-02f, 1.54062703e-01f, 8.43372419e-02f, -6.55676648e-02f, -1.75505206e-02f, -5.47485799e-02f,
  5.12884296e-02f, 2.09793225e-02f, -1.82831153e-01f, 2.71940138e-02f, 5.29218018e-02f, -3.09574269e-02f, -1.58351380e-02f, 4.43915613e-02f, -5.03327735e-02f, -7.47231767e-02f,
  -6.83733299e-02f, 4.71525379e-02f, 4.43796590e-02f, 3.76693308e-02f, 2.59685311e-02f, 6.04160801e-02f, -8.51676054e-03f, 1.43219277e-01f, -1.40991509e-02f, 1.81297679e-02f,
  6.51485473e-02f, 3.43769826e-02f, 1.28337573e-02f, -1.44313276e-01f, -4.39395905e-02f, -2.39960644e-02f, -1.17588267e-01f, -4.31869291e-02f, 4.59254980e-02f, -1.15646888e-03f,
  7.60633796e-02f, -6.20984063e-02f, -1.55441657e-01f, 9.16993320e-02f, 8.70836601e-02f, -4.90917787e-02f, -3.64089385e-02f, 7.41313472e-02f, 3.29552963e-02f, -1.07945979e-01f,
  -1.43157423e-01f, 1.13485977e-02f, 1.21086529e-02f, -1.81432310e-02f, -1.29995152e-01f, 1.32152334e-01f, 8.98218304e-02f, 2.74358019e-02f, 1.78839546e-02f, 2.66754739e-02f,
  1.14765123e-01f, 1.24730222e-01f, -8.95801112e-02f, -4.35668714e-02f, -1.34902090e-01f, 1.00362837e-01f, -1.44929752e-01f, -3.06828711e-02f, 5.80844432e-02f, 4.23101429e-03f,
  1.80538848e-01f, 3.15739587e-02f, 1.26500547e-01f, 3.46652679e-02f, 6.11683913e-02f, 1.01668708e-01f, 8.78915191e-02f, 6.19636998e-02f, 5.70643954e-02f, 6.64262921e-02f,
  1.96247235e-01f, 1.09861039e-01f, 3.25472243e-02f, 3.38034481e-02f, 1.19576238e-01f, 1.56866163e-01f, 2.60158926e-02f, 7.14454055e-02f, 7.25400969e-02f, 9.06640571e-03f,
  -1.13521203e-01f, 1.94961563e-01f, 4.57168221e-01f, 1.15480453e-01f, 2.78787315e-01f, 4.37047958e-01f, 2.12390274e-01f, 3.49127620e-01f, 4.41799343e-01f, -1.41035825e-01f,
  -1.68528602e-01f, -5.16465828e-02f, -1.05997606e-03f, -2.20748391e-02f, 1.17909595e-01f, 1.91808522e-01f, 8.03710967e-02f, -5.54416068e-02f, 7.99665973e-02f, -1.12587519e-01f,
  7.00237304e-02f, -1.59038708e-01f, -5.91752827e-02f, -2.15833798e-01f, -3.32770608e-02f, -2.62661558e-02f, -3.91968936e-01f, -1.23780221e-02f, -1.40747651e-01f, 7.14110583e-02f,
  -1.00107966e-02f, -8.11826438e-02f, -1.24799535e-01f, -7.65070394e-02f, -8.80858768e-03f, -1.54967653e-02f, 7.69854663e-03f, -5.68735301e-02f, 6.13790751e-02f, 5.26044285e-03f,
  -2.22349986e-02f, 2.09245961e-02f, -6.67197034e-02f, -5.49010970e-02f, 1.72666207e-01f, -2.83944304e-03f, 7.44787306e-02f, 3.41709629e-02f, 8.91319737e-02f, 8.56733844e-02f,
  2.70435810e-02f, 1.01450913e-01f, 5.42031713e-02f, 9.95971262e-02f, 5.44612817e-02f, -1.25274472e-02f, 3.53826792e-03f, 1.30885541e-02f, 7.31812045e-02f, 5.76550029e-02f,
  -2.62576528e-02f, 1.15319490e-01f, -1.44617751e-01f, 5.67898853e-03f, -5.15496992e-02f, 8.76305699e-02f, -4.26903851e-02f, 1.92666857e-03f, -2.06148159e-03f, -9.53281373e-02f,
  1.40967956e-02f, 2.88413391e-02f, 1.39745072e-01f, -1.26452846e-02f, -5.82020842e-02f, -7.81127810e-02f, -3.47258747e-02f, 4.00498770e-02f, -4.15037870e-02f, -1.48839548e-01f,
  -1.13195784e-01f, -1.11414999e-01f, -1.86376914e-01f, 6.62722290e-02f, -3.86806689e-02f, 1.48601346e-02f, -3.58033143e-02f, 3.60046141e-02f, -8.16568881e-02f, -5.45051321e-02f,
  7.84149766e-02f, 7.45358877e-03f, -1.37671739e-01f, -1.66096434e-01f, -9.36821699e-02f, -2.63382047e-02f, 4.82865684e-02f, -2.35748617e-03f, 4.62017953e-02f, 7.53469244e-02f,
  4.74619903e-02f, -1.38094470e-01f, -3.29457708e-02f, -8.57289881e-02f, 1.06473910e-02f, -2.41834368e-03f, -1.66490674e-02f, -6.20987229e-02f, 5.86452074e-02f, -4.58860509e-02f,
  -6.00966364e-02f, -5.45142666e-02f, -2.77746767e-02f, -3.12456917e-02f, -3.27476636e-02f, -2.20670234e-02f, 4.12974041e-03f, -5.15676700e-02f, 2.48918328e-02f, 6.46390393e-02f,
  -3.86171192e-01f, 2.71285117e-01f, 4.42392156e-02f, -3.06474179e-01f, 6.61782697e-02f, -3.36269625e-02f, -2.45409682e-01f, 9.65070054e-02f, -1.48688227e-01f, 5.93993887e-02f,
  -1.08642265e-01f, -6.69640005e-02f, 1.21227764e-01f, -1.19190969e-01f, -2.03029975e-01f, 1.34763241e-01f, -1.94351748e-01f, -2.04899579e-01f, 1.69273913e-01f, -1.54445410e-01f,
  -6.15838468e-02f, -8.80329981e-02f, 6.55745715e-02f, 1.84475228e-01f, -1.05262555e-01f, -3.91470753e-02f, 3.41481122e-04f, 8.02724436e-02f, -7.98559040e-02f, 1.77408755e-02f,
  -7.10569471e-02f, -1.34801552e-01f, -4.61314209e-02f, -5.17567098e-02f, -4.99454178e-02f, -2.25069150e-02f, -3.32590342e-02f, 2.43014097e-02f, 6.55291602e-03f, -1.17234269e-03f,
  6.61601275e-02f, 1.46559924e-01f, -6.65526986e-02f, 8.91830027e-02f, -6.44540787e-03f, 5.13027906e-02f, 1.59201920e-01f, -2.16392279e-02f, -3.56276333e-02f, 6.61149323e-02f,
  8.56733546e-02f, 6.66764900e-02f, -7.41905242e-04f, 4.35109204e-03f, 8.09514336e-03f, -9.44553595e-03f, 1.65727902e-02f, 1.05356788e-02f, -2.49431115e-02f, -1.54657569e-02f,
  1.26611721e-02f, 2.49334984e-03f, 5.77307642e-02f, -3.84188890e-02f, -6.47207722e-02f, -3.51539887e-02f, -3.19791883e-02f, 5.33007085e-03f, 2.23600771e-02f, 3.56288371e-03f,
  -5.18635474e-02f, -5.51404953e-02f, -6.56037927e-02f, -4.56289202e-03f, 3.99106108e-02f, -1.08362973e-01f, 7.96634471e-04f, -3.21263704e-03f, -6.87843487e-02f, -3.93576846e-02f,
  8.06457549e-03f, 1.51116708e-02f, -7.71617517e-02f, 6.82055391e-03f, -2.81847604e-02f, 4.13307548e-02f, 1.59597233e-01f, 2.89010163e-03f, -9.56087261e-02f, 4.11817282e-02f,
  -7.86226168e-02f, -1.14328712e-01f, -2.51797810e-02f, -9.66709927e-02f, -4.69677337e-02f, 7.71978274e-02f, 2.98986584e-02f, -2.55642668e-03f, 1.31588653e-02f, -2.88699032e-03f,
  5.08356579e-02f, -4.16399278e-02f, -2.66782548e-02f, -6.98216707e-02f, 2.25075986e-03f, -1.62838642e-02f, 3.71743850e-02f, -9.40144956e-02f, -6.93866983e-02f, -5.19147553e-02f,
  6.96762279e-02f, -3.96448597e-02f, 9.29938555e-02f, 7.73376897e-02f, -4.63828072e-02f, -2.72838976e-02f, -2.61191595e-02f, 6.44688681e-02f, 4.71191593e-02f, -3.95416468e-03f,
  7.66732842e-02f, 3.87203917e-02f, -3.72407079e-01f, -3.52329835e-02f, -1.91379637e-01f, 1.67547673e-01f, 4.23757792e-01f, 7.36502409e-02f, 3.06418631e-02f, 4.63799477e-01f,
  1.53651312e-01f, 1.43706024e-01f, 2.43395776e-01f, 3.57190341e-01f, -1.10949099e-01f, 2.21280172e-01f, 1.36722267e-01f, 2.11904153e-01f, 1.31754294e-01f, 1.63347781e-01f,
  -1.03406668e-01f, 3.00322384e-01f, -1.11559212e-01f, -3.19998078e-02f, 2.54947562e-02f, -1.81815863e-01f, -9.79746804e-02f, -8.90902206e-02f, 5.74471653e-02f, 1.29488660e-02f,
  8.11466426e-02f, 1.18260168e-01f, 1.63375139e-02f, 1.42077524e-02f, -8.19854960e-02f, 5.47581539e-02f, 3.80732156e-02f, -9.62586403e-02f, 3.62263955e-02f, 9.75321755e-02f,
  1.15388416e-01f, 5.05736805e-02f, 1.34710048e-03f, -9.87187377e-04f, -2.72054430e-02f, -5.57084568e-03f, 2.09781658e-02f, -8.72353911e-02f, 5.20188101e-02f, 4.56270762e-02f,
  -6.16331934e-04f, -2.85659488e-02f, 1.37081286e-02f, 4.64426680e-03f, -2.30359118e-02f, 1.40437856e-01f, 3.88349444e-02f, -1.01394646e-01f, -4.48922180e-02f, 8.14177841e-03f,
  -6.72796518e-02f, 6.73656836e-02f, 7.62045681e-02f, 7.91879836e-03f, -4.53210920e-02f, -2.24869363e-02f, 9.34578255e-02f, -1.39441453e-02f, -3.35332565e-02f, 1.99181158e-02f,
  -2.56716553e-02f, -9.91643593e-02f, 6.68942705e-02f, 1.17268853e-01f, 1.93738624e-01f, 1.02159947e-01f, -6.54217750e-02f, 3.87910455e-02f, -7.38935247e-02f, -1.23162396e-01f,
  2.43065804e-02f, -1.47449449e-02f, 8.76795202e-02f, 1.00880237e-02f, 9.23806205e-02f, -6.49935082e-02f, 9.41179618e-02f, 7.39122555e-02f, -6.05860129e-02f, -2.72047892e-02f,
  -5.51118106e-02f, 5.89505257e-03f, 5.49770929e-02f, 4.21769358e-02f, -4.14067917e-02f, 9.61225927e-02f, 3.89971100e-02f, -1.16447113e-01f, 5.77137321e-02f, 1.30147994e-01f,
  4.08595726e-02f, 8.11654180e-02f, -9.60789174e-02f, -1.16973147e-01f, -1.03354119e-01f, -5.64625077e-02f, 1.43735692e-01f, -1.48759872e-01f, -8.67549032e-02f, -7.99518377e-02f,
  -4.61972505e-02f, 8.93395245e-02f, 4.51347344e-02f, 2.53593940e-02f, -2.44085379e-02f, 2.83703096e-02f, -5.61781377e-02f, 2.99437233e-04f, -4.30382341e-02f, -5.48745021e-02f,
  -1.45864323e-01f, -2.08615482e-01f, -1.00543767e-01f, -9.94489640e-02f, 1.18055940e-01f, 1.58175707e-01f, -1.79493383e-01f, -5.17727360e-02f, -1.83186680e-01f, 4.94358763e-02f,
  -6.05996959e-02f, -9.05457661e-02f, -3.18232715e-01f, -1.82094261e-01f, -2.02412844e-01f, -2.88342565e-01f, -4.00044732e-02f, -3.06664151e-04f, -1.59986675e-01f, -1.40931949e-01f,
  2.69555189e-02f, -1.44424841e-01f, -1.38386518e-01f, 1.79930240e-01f, 5.83766364e-02f, 2.22045094e-01f, 2.59647489e-01f, 8.11401308e-02f, 1.85629666e-01f, 5.31735681e-02f,
  -4.11817543e-02f, -2.40082607e-01f, -5.28096296e-02f, 4.44401652e-02f, -7.15617314e-02f, -3.33131477e-02f, 1.00872874e-01f, -1.58968810e-02f, -3.48824598e-02f, -1.16693377e-01f,
  4.68859971e-02f, -5.73341213e-02f, -1.11158108e-02f, -8.05142522e-02f, 2.95078773e-02f, -4.61943932e-02f, -4.23713550e-02f, 1.03954166e-01f, -6.09920099e-02f, -9.84799042e-02f,
  -8.52527693e-02f, 8.34141225e-02f, 9.96300280e-02f, 8.95693973e-02f, 7.96688050e-02f, 4.01275195e-02f, -2.62747090e-02f, -3.66251543e-03f, 9.54756513e-02f, -4.69142906e-02f,
  -5.37599623e-02f, 1.02126487e-01f, -1.88226197e-02f, -1.70467757e-02f, -8.77232477e-02f, 4.90717143e-02f, 4.46255542e-02f, 2.69273832e-03f, 1.62561797e-02f, -4.55464283e-03f,
  1.70215555e-02f, -9.58893001e-02f, -6.30708486e-02f, 1.14974946e-01f, -6.24889918e-02f, 4.64420840e-02f, 4.92847897e-02f, 1.18708685e-02f, -1.77933760e-02f, 4.65346240e-02f,
  -7.63666583e-03f, 1.03431098e-01f, 4.49771211e-02f, -7.66203040e-03f, -3.14472020e-02f, 1.36433181e-03f, 5.62994741e-02f, 7.55626559e-02f, 6.52841255e-02f, -7.20216408e-02f,
  9.58464071e-02f, -4.38855886e-02f, -8.53055194e-02f, -6.58099428e-02f, -8.62305760e-02f, -1.88559312e-02f, 4.58430313e-02f, -1.39455264e-03f, 1.63220242e-02f, -1.03653707e-01f,
  3.58329117e-02f, 4.05615270e-02f, 1.92686334e-01f, 6.71588769e-03f, 5.82233779e-02f, -7.86938518e-02f, 6.95620403e-02f, 1.40186131e-01f, 1.22919962e-01f, 4.05129902e-02f,
  1.50639072e-01f, 8.40332508e-02f, 3.73219769e-03f, 3.62897478e-02f, 7.02197403e-02f, 4.25203666e-02f, 7.98822790e-02f, -6.98574185e-02f, 3.24518830e-02f, -1.04679344e-02f,
  -1.03832521e-01f, -4.73647099e-03f, 1.95896160e-02f, -1.05329148e-01f, 4.89279330e-02f, -2.97458410e-01f, -2.50201464e-01f, -2.08904054e-02f, -5.89679480e-02f, -1.81396976e-01f,
  -2.72697136e-02f, 1.66290775e-01f, 1.92202672e-01f, -1.81758851e-01f, 1.47503823e-01f, 2.65235096e-01f, -2.86387801e-01f, -1.41706616e-01f, -3.22677158e-02f, -9.77242514e-02f,
  -6.27474487e-02f, -1.74788937e-01f, 2.43104130e-01f, -7.60339573e-02f, -1.15540415e-01f, -6.35973960e-02f, 1.95091769e-01f, 9.87699628e-02f, -1.44293770e-01f, 1.24099761e-01f,
  -5.42381890e-02f, 1.21485256e-01f, -2.21468937e-02f, -1.14472859e-01f, -1.22165620e-01f, -3.70027423e-02f, -8.76223296e-02f, 1.84327420e-02f, -9.89147797e-02f, -5.47056273e-02f,
  -9.27077830e-02f, -5.38339764e-02f, -1.12159066e-01f, 5.16769961e-02f, -7.88167641e-02f, -9.04933065e-02f, 3.27670239e-02f, 6.33330122e-02f, 7.56658018e-02f, -1.45171927e-02f,
  3.51625457e-02f, -1.81259029e-02f, 7.10022226e-02f, 9.41989571e-02f, 1.18535496e-01f, -4.74715754e-02f, -3.59373428e-02f, 7.11250156e-02f, -2.46275067e-02f, -1.08120879e-02f,
  -4.01724875e-02f, -1.40073728e-02f, 1.05121778e-02f, -2.14209408e-03f, -8.12413618e-02f, 7.01482501e-03f, -2.46359967e-02f, -3.67976315e-02f, 5.81795089e-02f, -2.90368479e-02f,
  -1.66945960e-02f, 2.10163612e-02f, 4.47918512e-02f, -1.15049824e-01f, -1.32546604e-01f, 2.45143585e-02f, -7.81816896e-03f, 2.53207423e-03f, -6.15856797e-02f, -8.08603317e-03f,
  1.41947782e-02f, -3.02223917e-02f, 4.73494269e-02f, 4.86616082e-02f, -1.72258720e-01f, 2.61716433e-02f, -4.51017357e-02f, 6.17405325e-02f, 1.17324829e-01f, -1.12065431e-02f,
  -1.56272110e-02f, 5.49334399e-02f, -2.35201791e-02f, 6.19915798e-02f, -4.77093495e-02f, -1.23329647e-02f, -6.92662373e-02f, 3.06312181e-02f, -1.07729331e-01f, -1.69806443e-02f,
  -1.83480009e-01f, -4.40049432e-02f, -5.10142483e-02f, -1.56448074e-02f, 3.58149521e-02f, -3.73272669e-05f, 2.83655319e-02f, 4.42766696e-02f, 7.10298046e-02f, -2.98257526e-02f,
  6.65690228e-02f, -3.09429951e-02f, 9.16312933e-02f, -5.21423481e-02f, 9.43491757e-02f, 4.99966592e-02f, 4.16793004e-02f, 1.53662236e-02f, 4.53190245e-02f, 1.55753531e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  2.05394372e-01f, 2.73115009e-01f, 1.76809043e-01f, 2.59239644e-01f, 2.56399155e-01f, 1.95709527e-01f, 3.40861827e-01f, 1.70845166e-01f, 2.98585802e-01f, 1.98288754e-01f,
  2.73212075e-01f, 1.49736926e-01f, 2.85745203e-01f, 1.34756640e-01f, 3.20858002e-01f, 2.78475970e-01f, 3.28847945e-01f, 1.35172486e-01f, 2.21282765e-01f, 1.89767540e-01f,
  1.95566490e-01f, 2.40533799e-01f, 3.18816245e-01f, 2.64422476e-01f, 1.91335052e-01f, 2.50787050e-01f, 2.46395409e-01f, 1.54465288e-01f, 1.09817825e-01f, 3.32802832e-01f,
  1.96475148e-01f, 2.46429741e-01f, 2.39096925e-01f, 1.56204671e-01f, 2.70265758e-01f, 3.19873661e-01f, 5.99058010e-02f, 3.74791831e-01f, 2.75025606e-01f, 2.91300327e-01f,
  2.45257631e-01f, 3.14866334e-01f, 2.55260170e-01f, 1.80833772e-01f, 3.41521591e-01f, 2.76565582e-01f, 1.67054191e-01f, 1.99757367e-01f, 1.88253775e-01f, 3.14689934e-01f,
  1.78634450e-01f, 2.00471282e-01f, 3.22516441e-01f, 3.96543473e-01f, 2.85494149e-01f, 2.03082308e-01f, 2.77823448e-01f, 1.78899556e-01f, 1.34031430e-01f, 2.07636565e-01f,
  1.53254077e-01f, 2.61766881e-01f, 2.88009107e-01f, 2.63321906e-01f, 1.39421165e-01f, 1.88875809e-01f, 2.28439167e-01f, 2.24171534e-01f, 2.79826283e-01f, 1.95475653e-01f,
  1.76098540e-01f, 2.34793738e-01f, 2.28863746e-01f, 2.70193130e-01f, 3.40782493e-01f, 1.71689987e-01f, 2.41440400e-01f, 1.82509556e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.28704190e-01f, -2.78265834e-01f, -3.06101263e-01f, -1.65992439e-01f, -1.26688546e-02f, -9.73464772e-02f, -3.21132727e-02f, 4.11432236e-02f, -3.12542051e-01f, -1.90626204e-01f,
  -1.08964205e-01f, 1.49213314e-01f, 7.25473538e-02f, -7.10822642e-02f, -2.90806234e-01f, -8.58693048e-02f, 2.19841469e-02f, 5.37453778e-02f, 4.39889394e-02f, -1.72303885e-01f,
  -1.18400559e-01f, -2.62380570e-01f, -2.04528630e-01f, -1.95570484e-01f, 4.00645994e-02f, -8.56415704e-02f, 2.80409664e-01f, -3.96329761e-02f, -1.94765732e-01f, 2.60125458e-01f,
  6.96478486e-02f, 3.06229800e-01f, 1.16202168e-01f, -7.53867775e-02f, 3.10839593e-01f, 2.52911113e-02f, -4.64590117e-02f, 1.55185252e-01f, -3.32507521e-01f, -2.31995836e-01f,
  2.03976616e-01f, -1.84337810e-01f, 1.83912486e-01f, 4.45128717e-02f, -2.53997538e-02f, 1.99247301e-01f, -3.21827680e-01f, -1.54023498e-01f, -2.41601378e-01f, 2.92692542e-01f,
  -1.93115994e-02f, -3.26351255e-01f, 3.01661640e-01f, 8.63330960e-02f, 1.94174185e-01f, 1.00421034e-01f, -8.77368823e-02f, 5.71880937e-01f, -9.81590524e-02f, -1.39883146e-01f,
  -2.27548495e-01f, -4.55907077e-01f, 6.23695254e-02f, -2.93090612e-01f, -2.08619088e-01f, 4.81664091e-02f, 3.31783265e-01f, 1.54189259e-01f, -2.98956037e-02f, 5.56433320e-01f,
  -6.78535104e-02f, 2.41614223e-01f, -2.79222637e-01f, -3.59242529e-01f, -5.25351055e-03f, 9.23038498e-02f, -2.13666216e-01f, -1.47388384e-01f, 6.84476793e-02f, -2.44813561e-02f,
  -1.46241739e-01f, 3.06051075e-01f, -4.80002403e-01f, 2.89782673e-01f, -4.17219579e-01f, -3.13276976e-01f, -2.43003175e-01f, -1.53347149e-01f, -2.57464916e-01f, 3.59962225e-01f,
  -2.11474486e-02f, -1.89382181e-01f, 9.18503627e-02f, 1.98536605e-01f, -2.00011924e-01f, -2.70719498e-01f, 5.36833145e-02f, -2.15926394e-01f, 1.31480381e-01f, -1.63630977e-01f,
  -1.36701167e-01f, -2.05279619e-01f, 2.59227622e-02f, -2.96776623e-01f, -4.41176832e-01f, -1.80589274e-01f, -2.24716172e-01f, 4.27559674e-01f, 5.19069254e-01f, -4.55769330e-01f,
  5.03378391e-01f, 1.63083389e-01f, 1.16054572e-01f, -2.59268731e-01f, -1.07869722e-01f, 7.12461695e-02f, -2.35055283e-01f, -2.47360528e-01f, 1.12305164e-01f, 5.23243658e-02f,
  -2.61892527e-01f, 6.31059706e-01f, -2.16688454e-01f, -2.89904088e-01f, -8.22772756e-02f, 3.10082287e-01f, -1.51007220e-01f, -1.32304937e-01f, -4.31089364e-02f, 1.58125788e-01f,
  -2.29412168e-01f, 1.23410122e-02f, 1.78873651e-02f, 1.43164452e-02f, -8.73160660e-02f, -3.34207803e-01f, -3.26127857e-01f, -1.13191895e-01f, 1.17886573e-01f, -2.19495386e-01f,
  1.86809108e-01f, -1.12553738e-01f, 2.17107624e-01f, -5.26877120e-02f, 1.39089584e-01f, -6.10625297e-02f, -3.48715961e-01f, 1.66992515e-01f, -4.83134463e-02f, -7.99416155e-02f,
  2.16259554e-01f, 1.09375902e-01f, 1.96597531e-01f, 3.09123963e-01f, 2.94795275e-01f, -4.85658616e-01f, 1.96451306e-01f, -5.47548793e-02f, -4.13789064e-01f, -2.58884162e-01f,
  -2.90154576e-01f, -2.42000982e-01f, -5.78057878e-02f, 2.43404254e-01f, -3.92136604e-01f, 3.25453728e-02f, 4.59755301e-01f, 3.50577742e-01f, -4.11785662e-01f, 3.54980260e-01f,
  -3.22442949e-01f, -8.49966425e-03f, -1.62797228e-01f, -7.76654333e-02f, 4.45076115e-02f, -3.44286084e-01f, 1.26642153e-01f, -4.87155169e-01f, 2.35849321e-01f, 1.53179094e-01f,
  1.78577110e-01f, -3.68979275e-01f, -4.15838599e-01f, 3.15781474e-01f, -3.19620252e-01f, -4.15249795e-01f, -4.14747387e-01f, -4.49588418e-01f, 8.99598375e-02f, -2.79341400e-01f,
  3.45249891e-01f, -2.87127465e-01f, 2.46017516e-01f, -6.79263055e-01f, -2.22154275e-01f, 7.39848614e-02f, -1.87281340e-01f, -4.75623846e-01f, 6.03952594e-02f, 4.58367705e-01f,
  -3.28135580e-01f, -2.03485638e-01f, -3.87547135e-01f, -2.46774167e-01f, -3.62492502e-01f, -3.58743161e-01f, 3.34979981e-01f, -1.83526799e-02f, 1.65902689e-01f, 7.05436096e-02f,
  3.25330019e-01f, -1.57132268e-01f, 6.87275380e-02f, -1.11957967e-01f, -4.72158939e-01f, -2.77547181e-01f, 1.76166877e-01f, 2.20723644e-01f, 1.05536647e-01f, 3.15975487e-01f,
  1.93534181e-01f, 1.41642079e-01f, -5.49973190e-01f, -6.15339167e-02f, -5.34395635e-01f, 1.37248173e-01f, 2.11541653e-01f, -3.35926235e-01f, -6.79545328e-02f, -3.97542790e-02f,
  9.07222182e-02f, -3.94500643e-01f, 2.38911062e-01f, -1.31565079e-01f, -2.15754464e-01f, 4.89191432e-03f, 3.03402036e-01f, 1.40711188e-01f, -3.26730400e-01f, 2.02540100e-01f,
  3.33027154e-01f, 3.16444367e-01f, 3.10552686e-01f, -2.92014889e-02f, -1.17265858e-01f, -2.10541055e-01f, 5.95977856e-03f, -8.29458982e-03f, -5.89641109e-02f, -4.01216596e-01f,
  -1.97257549e-02f, -9.82477963e-02f, -2.64810085e-01f, 2.99838454e-01f, -5.72261401e-02f, -3.82926874e-02f, -1.25032375e-02f, -9.42240655e-02f, 6.21930063e-02f, -5.12315426e-03f,
  -5.50038107e-02f, -2.32504874e-01f, 2.62491256e-02f, -1.87378958e-01f, 8.89741555e-02f, 4.66334186e-02f, -1.14754744e-01f, 5.52289411e-02f, 2.41728295e-02f, -1.33018613e-01f,
  -1.42027393e-01f, -5.68675995e-02f, -1.56463161e-01f, -1.09429456e-01f, -1.15155682e-01f, -2.46048421e-01f, 8.79905671e-02f, -2.45007396e-01f, -1.66520044e-01f, -1.18160658e-01f,
  -2.06704021e-01f, -1.28750414e-01f, -4.96490970e-02f, 1.58880614e-02f, 6.73995987e-02f, -3.89970429e-02f, -2.17551246e-01f, -7.44834170e-02f, -7.01958239e-02f, 6.62769482e-04f,
  7.75662810e-02f, 1.06280548e-02f, 2.14637220e-01f, 8.70334134e-02f, 7.54972994e-02f, 6.18684702e-02f, -7.85125494e-02f, -1.81642577e-01f, -7.22852945e-02f, -2.36459941e-01f,
  -1.61420062e-01f, -4.67956327e-02f, -1.83956459e-01f, 3.06374162e-01f, 1.38921738e-01f, -9.08702463e-02f, -3.26672912e-01f, -1.74456522e-01f, -2.42392913e-01f, -1.59247160e-01f,
  -1.39447302e-01f, -3.85496952e-03f, -2.35077977e-01f, -1.86971977e-01f, 1.39295598e-02f, -6.41838238e-02f, -1.98505953e-01f, -1.16388939e-01f, 3.65809321e-01f, -8.34545866e-02f,
  3.01389039e-01f, 2.46606886e-01f, -1.62769258e-01f, -1.52001485e-01f, -6.23691343e-02f, 4.00589854e-01f, -3.35169226e-01f, 1.74493894e-01f, -1.38658419e-01f, -2.81549752e-01f,
  1.47347555e-01f, -1.75591871e-01f, -7.43805766e-02f, 2.32491583e-01f, -2.99751848e-01f, -3.84277105e-01f, -4.47613262e-02f, 3.31094861e-01f, 4.51335639e-01f, -3.72763246e-01f,
  -9.78937224e-02f, -2.49807805e-01f, 4.88513350e-01f, -9.56966728e-02f, 4.54902388e-02f, -2.04665944e-01f, 1.01424903e-01f, 2.49355674e-01f, 2.90656954e-01f, -1.07131787e-01f,
  -1.61981627e-01f, -3.21853936e-01f, 5.99204600e-01f, -1.76158309e-01f, -1.91371754e-01f, 7.49844238e-02f, 1.72430322e-01f, -1.45885423e-01f, 6.01723939e-02f, 2.42480651e-01f,
  1.76150456e-01f, -2.33309522e-01f, -1.48609772e-01f, -1.83764100e-01f, -1.91154182e-01f, -2.24002242e-01f, -9.38101187e-02f, -2.13105306e-02f, 5.96821457e-02f, 3.22873920e-01f,
  -2.20295742e-01f, -2.63154685e-01f, 1.72219157e-01f, 2.10121088e-03f, -2.29561180e-01f, -2.15237737e-01f, -1.56970382e-01f, -1.49012938e-01f, 9.09924433e-02f, -3.58344078e-01f,
  -2.11581305e-01f, -2.19808370e-01f, 2.68507481e-01f, -3.52513522e-01f, -5.50074458e-01f, 9.32148192e-03f, -3.26998681e-02f, 8.29436108e-02f, -1.89848736e-01f, -4.11240011e-02f,
  -1.84931323e-01f, -2.95131445e-01f, 2.68597831e-03f, 2.07201883e-01f, -3.62065062e-02f, 5.96482120e-02f, -2.71400273e-01f, -2.00407386e-01f, 1.74683705e-01f, -3.55953246e-01f,
  -3.04202884e-02f, 1.56173572e-01f, -6.10946603e-02f, -1.05884865e-01f, -3.39248367e-02f, -1.45707861e-01f, -8.45533535e-02f, 8.12269077e-02f, -1.76449567e-02f, -1.06034815e-01f,
  1.74288347e-01f, -1.81041926e-01f, -4.31652218e-02f, -2.09383383e-01f, 1.54016823e-01f, 2.71826297e-01f, 8.85704681e-02f, 5.26630282e-02f, -1.63084850e-01f, -1.19727202e-01f,
  2.88936868e-02f, 1.31454960e-01f, -8.22892189e-02f, 1.51226848e-01f, 2.12224647e-01f, 3.68929841e-02f, 6.59151152e-02f, 1.43061250e-01f, 6.29137009e-02f, -2.16596067e-01f,
  1.00578181e-01f, -2.18322262e-01f, 2.31179491e-01f, 4.42527644e-02f, -1.25021758e-02f, 5.09743571e-01f, 2.17147544e-01f, 3.54750663e-01f, 2.84469903e-01f, -2.73661703e-01f,
  -3.70029241e-01f, 2.65897840e-01f, -1.40537322e-01f, 1.69727460e-01f, -3.98781449e-01f, 3.71573508e-01f, -6.90399334e-02f, 1.71832934e-01f, -1.65187821e-01f, -1.66709319e-01f,
  3.47408980e-01f, 1.89293057e-01f, 5.50938368e-01f, -1.56652480e-01f, 4.20833498e-01f, -1.54961884e-01f, -1.67613775e-01f, 1.86042875e-01f, -7.63332397e-02f, 7.00920671e-02f,
  4.31896508e-01f, 1.34050012e-01f, -4.95962501e-02f, -2.47675970e-01f, -1.76149487e-01f, -1.55268267e-01f, -2.40585580e-01f, -3.58979031e-02f, -1.05497606e-01f, -2.84726292e-01f,
  -1.15846485e-01f, 3.30578029e-01f, -9.02427286e-02f, -3.92673403e-01f, 2.44597539e-01f, -5.71591437e-01f, -3.33306402e-01f, -3.72606725e-01f, -3.80966902e-01f, -3.17847043e-01f,
  1.10737108e-01f, 2.89235890e-01f, -3.82295609e-01f, -4.49215919e-01f, -3.38308394e-01f, -3.82157713e-01f, -1.99363261e-01f, -8.24593902e-02f, -8.80254805e-02f, -2.36505806e-01f,
  1.17880657e-01f, -1.16623662e-01f, 2.44098842e-01f, -8.61293636e-03f, 5.28759718e-01f, -2.45118365e-01f, -2.02697694e-01f, -3.56666207e-01f, 2.61175185e-01f, 7.00154295e-03f,
  1.38068929e-01f, -1.98326409e-01f, -3.35004270e-01f, 4.42496501e-02f, -5.41573465e-01f, -3.04822594e-01f, -2.22761437e-01f, -4.83478040e-01f, 3.61965150e-01f, 2.26535603e-01f,
  -2.41535127e-01f, 2.22091943e-01f, 2.43102819e-01f, 8.21591690e-02f, 5.39538711e-02f, 1.17901368e-02f, 1.66054934e-01f, 1.06207833e-01f, -4.84207049e-02f, 2.50236690e-01f,
  1.39708519e-01f, 1.37849092e-01f, 1.73898637e-01f, 1.37763182e-02f, 5.56526743e-02f, -3.51855382e-02f, 1.24357820e-01f, 1.64117813e-01f, 7.41038397e-02f, -6.52215853e-02f,
  1.71701521e-01f, 1.59706518e-01f, -6.51842542e-03f, 3.31844121e-01f, 2.22532928e-01f, 1.43963382e-01f, 1.21632122e-01f, -3.14633965e-01f, 2.42111415e-01f, -2.36198694e-01f,
  -1.19993888e-01f, -2.09798113e-01f, 8.40744302e-02f, 2.83165962e-01f, 2.93469220e-01f, 8.50913897e-02f, 3.77844006e-01f, 1.04915276e-01f, 3.07297200e-01f, 7.49553964e-02f,
  -1.30088940e-01f, -2.94112474e-01f, 1.52232736e-01f, -1.33059293e-01f, 2.82936692e-01f, 1.76996074e-03f, -1.10744104e-01f, -8.64463747e-02f, 1.75243840e-01f, 7.82001093e-02f,
  -3.19976568e-01f, 2.52151638e-01f, 8.85269605e-03f, -6.18635416e-01f, -2.49237686e-01f, 6.15327179e-01f, 2.07208358e-02f, 1.31110087e-01f, 2.86256135e-01f, 1.12174243e-01f,
  -1.65400133e-01f, 9.96234342e-02f, -2.94294983e-01f, -2.58896142e-01f, -4.04710174e-01f, -2.97726959e-01f, -1.20041585e-02f, -1.71912283e-01f, 8.86489579e-04f, -3.42092782e-01f,
  -2.32584611e-01f, -8.42256844e-03f, -1.03679679e-01f, 2.47993171e-01f, -3.29524845e-01f, 5.73195219e-01f, -3.38365853e-01f, -9.14751142e-02f, 4.44944769e-01f, -2.89219856e-01f,
  -1.57414079e-01f, -2.06581026e-01f, -5.87259978e-02f, -3.60264033e-01f, -4.79279086e-02f, -8.35436285e-02f, -3.93553853e-01f, -8.78571793e-02f, -1.85799580e-02f, 2.59572387e-01f,
  -2.65941203e-01f, 1.88027948e-01f, -4.05187458e-01f, -4.76636514e-02f, 1.74189627e-01f, -2.80944020e-01f, 2.27485463e-01f, -1.13261687e-02f, -4.86248247e-02f, -2.74228781e-01f,
  -3.58351171e-02f, -2.32767805e-01f, -1.85244620e-01f, -2.15512767e-01f, 6.16774559e-01f, 5.73245883e-01f, -1.89579770e-01f, -2.74519801e-01f, 2.18215346e-01f, -3.22276384e-01f,
  -2.38089740e-01f, 1.25249833e-01f, -2.70303935e-02f, -6.00006819e-01f, 2.39709746e-02f, -1.63462102e-01f, -2.05169469e-01f, -3.09459031e-01f, -3.25274229e-01f, 2.62553315e-03f,
  4.15459126e-01f, 1.33255169e-01f, 4.99537081e-01f, 7.39201754e-02f, -1.64678052e-01f, 3.95983249e-01f, 3.54408532e-01f, -4.09525573e-01f, -7.21348748e-02f, 1.02069657e-02f,
  5.57913706e-02f, 2.46704400e-01f, 2.15682462e-01f, 1.60797462e-01f, 1.12415709e-01f, 7.23738149e-02f, -1.26063237e-02f, 2.37813786e-01f, 2.66554326e-01f, 3.39003094e-02f,
  4.59614173e-02f, 1.97983727e-01f, -1.34228468e-02f, 3.09870392e-01f, 5.24573913e-03f, 3.51571776e-02f, 1.50046378e-01f, -1.41836423e-02f, 1.23404801e-01f, 2.02053878e-02f,
  1.78519860e-01f, 3.16997349e-01f, -3.97750027e-02f, 1.32807478e-01f, -5.87539971e-02f, 2.50146538e-01f, -4.05827343e-01f, -2.24476323e-01f, -3.13808113e-01f, -5.46952933e-02f,
  4.43915397e-01f, -1.50070921e-01f, -1.94799483e-01f, -5.07247865e-01f, 2.06614777e-01f, -8.99418890e-02f, -2.91704953e-01f, -3.57592821e-01f, -3.91931459e-02f, -2.58265227e-01f,
  -7.19129965e-02f, 3.75378042e-01f, 1.51132628e-01f, -4.11510199e-01f, 1.27682790e-01f, 2.35084936e-01f, -2.77052730e-01f, -5.88513259e-03f, 1.31647706e-01f, 2.96164125e-01f,
  4.29514110e-01f, 1.53667713e-03f, -2.41687134e-01f, -4.79889452e-01f, -2.14110196e-01f, -2.02480435e-01f, 5.80962837e-01f, -1.05625622e-01f, -1.59025207e-01f, 2.41523102e-01f,
  1.11503206e-01f, 4.65812802e-01f, -2.04918981e-01f, 3.57587427e-01f, -4.31760907e-01f, 1.71976462e-01f, -5.22736549e-01f, -4.99522910e-02f, -1.71699017e-01f, -3.87685895e-01f,
  -1.36015676e-02f, -3.57579142e-01f, 3.97340953e-02f, -1.92846939e-01f, -3.97359818e-01f, 1.68896541e-01f, -1.33118168e-01f, 5.07242680e-01f, -2.17961043e-01f, 1.68267086e-01f,
  -1.06037460e-01f, -5.28399646e-01f, -3.17840010e-01f, -7.75303468e-02f, 2.25396007e-01f, 1.82908237e-01f, 2.69483328e-01f, -4.40884441e-01f, 1.12871751e-01f, 2.53288925e-01f,
  -3.36292028e-01f, -2.49574259e-01f, -2.54861284e-02f, 3.16806525e-01f, -2.55232841e-01f, -2.51789480e-01f, -2.37072960e-01f, -3.94341677e-01f, 2.96442062e-01f, 1.24386288e-01f,
  -1.89562708e-01f, 2.13112369e-01f, -2.88167119e-01f, -1.87897608e-01f, -5.16325310e-02f, -1.86525494e-01f, -4.62348729e-01f, 2.77547449e-01f, -3.45896155e-01f, 6.56892836e-01f,
  9.03229266e-02f, 2.40938395e-01f, -3.33771914e-01f, 5.47575802e-02f, -1.79326057e-01f, -7.84195289e-02f, -8.71089771e-02f, -3.50333691e-01f, 2.60068089e-01f, -2.67761767e-01f,
  -2.78555006e-01f, 6.52465001e-02f, -2.21068278e-01f, 3.56926709e-01f, -2.10144117e-01f, 1.33981243e-01f, -1.25302523e-01f, -3.08731169e-01f, 6.50873706e-02f, -1.56831473e-01f,
  -7.86462352e-02f, 4.40425724e-02f, -1.03399508e-01f, -3.88501771e-02f, 1.32166937e-01f, -7.45575801e-02f, 1.21454513e-02f, 1.15253605e-01f, 9.88703966e-02f, 8.02847445e-02f,
  -4.35388945e-02f, 7.46948123e-02f, 1.25666797e-01f, 1.64585680e-01f, -4.03480977e-02f, -5.62789477e-02f, 9.07723308e-02f, 2.50013173e-02f, 7.27546886e-02f, -1.49387643e-01f,
  -1.59612253e-01f, 2.95416880e-02f, -3.67368907e-02f, -1.74940258e-01f, -6.05783351e-02f, 3.07236552e-01f, -9.11602080e-02f, -2.72854030e-01f, -4.09182250e-01f, 1.25873715e-01f,
  -2.65231311e-01f, 3.31083745e-01f, 7.57456347e-02f, 3.14598233e-01f, 1.43116057e-01f, -1.77529514e-01f, 3.80214512e-01f, 3.38526964e-02f, 3.54107358e-02f, -3.22094291e-01f,
  3.13013852e-01f, -1.34337157e-01f, 2.42186278e-01f, -3.16679150e-01f, 1.96764290e-01f, 2.06017166e-01f, 2.35978782e-01f, -1.76984951e-01f, -8.53603333e-02f, -9.90956351e-02f,
  -1.86005518e-01f, -2.28085458e-01f, -2.08909884e-01f, -2.85486102e-01f, -2.84673691e-01f, -9.35180038e-02f, 4.84791756e-01f, -1.72693014e-01f, -9.29128602e-02f, -1.53663263e-01f,
  3.07256013e-01f, -5.76567948e-02f, 2.38669023e-01f, -4.65376675e-01f, -2.83298165e-01f, -1.87212333e-01f, -2.12298498e-01f, -3.36819977e-01f, -5.98556735e-02f, -5.00512064e-01f,
  3.97800893e-01f, 1.28060371e-01f, 4.16743577e-01f, -7.28097260e-02f, -3.21315169e-01f, -1.93832666e-01f, -5.94638065e-02f, -2.46836632e-01f, -2.98267156e-01f, 2.03487024e-01f,
  1.22329786e-01f, -1.76461831e-01f, 3.66347343e-01f, 2.92073369e-01f, -1.79104254e-01f, 2.28280574e-01f, 5.65593064e-01f, -2.57985264e-01f, 8.08763057e-02f, -4.00228649e-01f,
  -2.84856647e-01f, -3.58969457e-02f, 4.85962719e-01f, 4.31719095e-01f, -9.73074436e-02f, -7.80753791e-02f, -3.43109518e-01f, 2.19320521e-01f, 2.22256646e-01f, -3.04808825e-01f,
  -6.61610305e-01f, -3.22055787e-01f, 3.65326971e-01f, 4.48978335e-01f, -1.91216767e-01f, -2.50797093e-01f, 6.38313293e-02f, -2.30960727e-01f, -2.39680141e-01f, 4.08211172e-01f,
  -3.87992680e-01f, -3.25240344e-01f, -3.12008671e-02f, -4.35922235e-01f, 2.36858472e-01f, 1.99607462e-01f, -3.06988031e-01f, 2.52358675e-01f, -2.89730817e-01f, -4.81225282e-01f,
  -3.95918451e-02f, 2.42883310e-01f, -1.93277225e-01f, -1.07718430e-01f, -2.10856095e-01f, -2.93416113e-01f, -7.01890066e-02f, -2.05090865e-01f, -9.57591161e-02f, -1.19459927e-01f,
  -9.67362523e-02f, -3.26287784e-02f, -3.12918723e-02f, -6.75951466e-02f, -4.09324877e-02f, -1.05895139e-01f, -3.41800988e-01f, -2.26595029e-01f, -9.98972803e-02f, 2.92591620e-02f,
  -5.72239794e-02f, 3.80308181e-02f, -6.23277798e-02f, -4.06654105e-02f, -1.45121261e-01f, 2.95893848e-03f, -1.42085537e-01f, 1.63536891e-02f, -8.85304809e-02f, -1.75404772e-01f,
  -6.58724010e-02f, -1.36011496e-01f, -2.27100968e-01f, 2.98071057e-01f, -7.33740702e-02f, -5.88358752e-02f, 1.26817763e-01f, 7.34042078e-02f, 2.21997470e-01f, 1.61252007e-01f,
  -1.16414465e-01f, -1.67632788e-01f, 1.74552888e-01f, -1.88770786e-01f, -2.52601039e-02f, 3.30355056e-02f, 2.29302660e-01f, -1.87803239e-01f, -1.31768867e-01f, 1.12415306e-01f,
  1.23761997e-01f, -2.09420294e-01f, -1.72294021e-01f, 1.26543671e-01f, 3.28369701e-04f, 1.28930941e-01f, -3.04253995e-01f, -4.04994301e-02f, -1.53684318e-01f, -2.22770393e-01f,
  -2.07401738e-02f, -4.77549955e-02f, -5.32019995e-02f, 2.67411649e-01f, 2.36600950e-01f, 1.77308932e-01f, -1.81019738e-01f, 2.36553624e-01f, -2.43343741e-01f, 4.02645528e-01f,
  -2.63275325e-01f, 2.05368474e-01f, -3.38775247e-01f, 4.07943249e-01f, -1.54738694e-01f, 5.43365106e-02f, 2.89914519e-01f, 1.46170706e-02f, -2.82573979e-02f, -3.43201607e-02f,
  -2.58458517e-02f, -2.91656882e-01f, 3.13185066e-01f, -6.09287545e-02f, -3.46775651e-02f, -1.25937387e-01f, -4.29939218e-02f, -6.78825229e-02f, -1.88306391e-01f, -3.55488881e-02f,
  -1.67116001e-01f, -4.90957126e-02f, 7.54130483e-02f, -1.22697160e-01f, -5.31517044e-02f, -1.80988342e-01f, -1.88395858e-01f, -9.36684012e-02f, -1.58478871e-01f, 1.76398739e-01f,
  1.60695136e-01f, 1.24655724e-01f, 3.26307118e-01f, 1.75836861e-01f, 2.01719508e-01f, 2.47540087e-01f, 4.22390133e-01f, 3.82901669e-01f, -1.97773844e-01f, 1.37485117e-01f,
  -2.69751608e-01f, -8.54317844e-02f, 2.83891857e-01f, 3.34262452e-03f, -1.03687026e-01f, -8.24880973e-02f, -1.43196836e-01f, -7.02523217e-02f, -2.63795555e-01f, -1.25317410e-01f,
  1.90472037e-01f, -7.51634911e-02f, 3.60269807e-02f, -1.15160480e-01f, 1.61167383e-02f, -1.99065343e-01f, 2.42682427e-01f, -7.80206919e-03f, 1.70187414e-01f, -3.91480662e-02f,
  2.64362812e-01f, -1.95453376e-01f, -3.48462461e-04f, 3.79715592e-01f, -8.63898247e-02f, -7.43376985e-02f, -3.31216566e-02f, -1.27153397e-01f, 5.42919859e-02f, 2.45421054e-03f,
  -4.69282232e-02f, 8.00598338e-02f, -1.25341773e-01f, -1.14301108e-01f, -2.73616593e-02f, -2.79601812e-01f, -1.84501216e-01f, -1.51261181e-01f, -4.23792899e-02f, -6.08631447e-02f,
  -1.48142472e-01f, 6.90891147e-02f, 1.29059679e-03f, 5.04613481e-03f, -1.89517394e-01f, -6.88276663e-02f, 9.64813586e-03f, -4.95725125e-03f, -1.23569854e-01f, 1.65078655e-01f,
  -4.39628102e-02f, 1.81824386e-01f, 1.20201893e-02f, -3.06893028e-02f, 1.49099886e-01f, -2.11975232e-01f, 1.54304579e-01f, -2.79695362e-01f, -1.70601219e-01f, 9.80328918e-02f,
  -2.03106046e-01f, -2.35030189e-01f, 1.72210857e-01f, -1.83007345e-02f, -1.60343006e-01f, -1.54188633e-01f, 1.19573526e-01f, 6.15453497e-02f, -1.54924160e-02f, 2.53112704e-01f,
  1.79117158e-01f, 1.64218992e-01f, 7.62992650e-02f, -2.23624200e-01f, -2.28652462e-01f, 1.31263658e-01f, 1.06855698e-01f, -1.66347742e-01f, -2.58806199e-01f, 1.85448065e-01f,
  -1.50455922e-01f, 2.69938614e-02f, -2.66328841e-01f, -1.27979070e-01f, 5.29521033e-02f, -9.52189937e-02f, -3.41577888e-01f, 1.66114226e-01f, -3.16407740e-01f, 4.04524386e-01f,
  -1.34060949e-01f, -1.31499961e-01f, 7.47337192e-02f, 3.30966979e-01f, 1.75616249e-01f, 1.69672564e-01f, 4.18619573e-01f, -9.98978093e-02f, 1.41682371e-01f, -2.28428528e-01f,
  -1.28226653e-01f, -1.59216002e-01f, 1.42309651e-01f, 3.81984770e-01f, 3.77606481e-01f, 4.96132486e-02f, 4.30580229e-02f, 5.18952906e-01f, -6.03351332e-02f, -1.74358383e-01f,
  4.05025214e-01f, -1.66758999e-01f, 2.61118740e-01f, -2.14770228e-01f, -2.02542409e-01f, -9.14876983e-02f, 3.02166194e-01f, -1.53025789e-02f, 6.21735275e-01f, -2.23719642e-01f,
  -3.57397884e-01f, -2.08633617e-01f, -2.53050864e-01f, -2.42390841e-01f, -2.48854920e-01f, -1.68092966e-01f, -1.39576510e-01f, -3.22832584e-01f, -2.08807349e-01f, -1.04997464e-01f,
  -1.70206904e-01f, -7.15749711e-02f, -1.73874199e-01f, -8.09843615e-02f, -1.09653778e-01f, -2.91890681e-01f, -2.31285408e-01f, 1.27129421e-01f, -2.03908414e-01f, 1.27921537e-01f,
  2.27339596e-01f, 3.15853477e-01f, -3.18715036e-01f, 1.60752639e-01f, -2.33772211e-02f, -6.76813796e-02f, 6.80301860e-02f, -2.26889938e-01f, -1.59468483e-02f, -3.28210622e-01f,
  -2.77301222e-01f, 1.59508258e-01f, 2.36190744e-02f, 7.75661319e-02f, 1.28443286e-01f, -1.14737870e-03f, 3.05375811e-02f, 1.23607367e-01f, 4.28562611e-02f, 7.30003342e-02f,
  -1.34289386e-02f, -2.74153836e-02f, -1.07399978e-01f, -1.62072256e-01f, -4.37643677e-02f, -5.24619073e-02f, -7.72274882e-02f, 6.64125904e-02f, 1.08058386e-01f, 1.69433400e-01f,
  2.96445135e-02f, -3.23107652e-02f, -2.77776644e-02f, 7.06063733e-02f, 7.37975687e-02f, 1.15472272e-01f, 2.33722981e-02f, 3.43251914e-01f, -1.52958587e-01f, 3.20687741e-01f,
  1.37544740e-02f, 1.77886546e-01f, 2.81435728e-01f, -3.44973877e-02f, -2.67925113e-02f, 3.08516443e-01f, 1.03662923e-01f, -3.88888836e-01f, 2.02778608e-01f, 2.48196408e-01f,
  -2.82984138e-01f, -7.98948780e-02f, -2.09838152e-01f, 2.04676554e-01f, -3.42895865e-01f, 2.20745146e-01f, 1.71341240e-01f, 1.97753161e-01f, -3.61753225e-01f, -1.10685490e-01f,
  -3.67137969e-01f, -1.26144484e-01f, -4.73881394e-01f, -1.75710827e-01f, 9.28282961e-02f, 8.92413184e-02f, -1.19639419e-01f, -2.40320146e-01f, 4.48015966e-02f, -4.07332987e-01f,
  -2.54252195e-01f, -2.28869364e-01f, 1.66377544e-01f, -3.15454841e-01f, -9.60975662e-02f, -2.55997598e-01f, 3.35279226e-01f, 5.27602851e-01f, -2.05062136e-01f, 2.42145896e-01f,
  -2.17522532e-01f, -1.71158284e-01f, -2.51646817e-01f, -4.77630109e-01f, -5.21527708e-01f, -3.27797495e-02f, 4.18135226e-01f, -2.77366519e-01f, -3.30855429e-01f, -1.11296475e-01f,
  -2.09008172e-01f, -2.09388822e-01f, -9.16604474e-02f, -1.77867681e-01f, -2.50179410e-01f, -5.45555986e-02f, 3.73692960e-01f, 3.59534830e-01f, -1.21514253e-01f, -4.22279149e-01f,
  -4.60457742e-01f, -4.60200548e-01f, -3.50174040e-01f, -7.19744638e-02f, -5.44134140e-01f, -9.27474052e-02f, -3.72037619e-01f, 3.23594302e-01f, -7.99729526e-02f, -1.97054520e-01f,
  4.24654931e-02f, 1.16461672e-01f, 2.50369161e-01f, 5.11949718e-01f, 4.71379697e-01f, 4.76036698e-01f, 2.70780206e-01f, 3.53045553e-01f, -1.72935471e-01f, -1.09550908e-01f,
  -1.84515715e-01f, -3.51370096e-01f, -2.16761187e-01f, -1.73923671e-01f, 3.93958062e-01f, -3.68466526e-01f, -1.52550802e-01f, 5.03431261e-01f, -2.53778011e-01f, -2.51103252e-01f,
  6.35357425e-02f, 3.75584543e-01f, -1.81835368e-02f, 5.17667234e-01f, -1.45486280e-01f, -1.02481648e-01f, -2.62002945e-01f, -2.41821215e-01f, -1.93493426e-01f, 1.57892257e-01f,
  1.06545858e-01f, -1.38385400e-01f, 1.48319438e-01f, 8.57020169e-02f, 2.09677592e-01f, 6.01396151e-02f, 2.48083234e-01f, 1.86170384e-01f, 9.03735980e-02f, -2.16201618e-01f,
  5.12891859e-02f, 1.79503173e-01f, 1.02910809e-01f, 3.02323371e-01f, -1.13559444e-03f, 1.73748583e-01f, 8.22891295e-02f, -1.71787977e-01f, 9.70629752e-02f, 1.89460199e-02f,
  1.02027871e-01f, -1.97327952e-03f, -1.40862167e-02f, 1.52973339e-01f, 1.88235819e-01f, -3.43522549e-01f, 2.39348605e-01f, 3.87122631e-01f, 2.71966726e-01f, 2.46145390e-02f,
  -1.36603937e-01f, -1.54545784e-01f, 1.27938136e-01f, 1.29695475e-01f, -2.94190496e-01f, 9.98251215e-02f, -9.96962655e-03f, 2.44971067e-01f, -1.36026859e-01f, 3.14419061e-01f,
  -1.98923618e-01f, -2.73549557e-01f, -3.92276168e-01f, -4.78886627e-02f, -3.10617119e-01f, 1.27032995e-01f, 3.09576571e-01f, -4.00428623e-01f, -3.59858990e-01f, -3.13172162e-01f,
  -1.98491395e-01f, 3.24792087e-01f, 2.80224264e-01f, -4.53127742e-01f, 1.71564862e-01f, 1.14064813e-02f, -1.30200848e-01f, -2.87025303e-01f, -3.23877782e-01f, -2.30298385e-01f,
  6.73261106e-01f, -1.04677804e-01f, -1.93418369e-01f, -2.25873351e-01f, -3.72437090e-01f, -3.25708449e-01f, 1.97381109e-01f, -1.88752517e-01f, -2.55345613e-01f, 4.02424373e-02f,
  -1.38000458e-01f, -2.98440427e-01f, -2.63456911e-01f, -1.94865212e-01f, -2.60952055e-01f, 1.27657995e-01f, -2.85870254e-01f, 2.44296506e-01f, 1.27500057e-01f, -2.00270578e-01f,
  -3.10313106e-01f, 3.22219521e-01f, 1.60023898e-01f, 1.03050970e-01f, -1.95393547e-01f, -7.88464993e-02f, -2.78497517e-01f, 4.64898795e-01f, -2.55955040e-01f, -2.42741570e-01f,
  -1.96640238e-01f, 4.19449091e-01f, -4.11638796e-01f, -2.68292450e-03f, -2.38498449e-01f, -2.47994140e-01f, 1.35978684e-02f, -6.75210357e-02f, -3.44769061e-01f, 2.49760654e-02f,
  -2.43669108e-01f, 1.44334426e-02f, -2.14609522e-02f, -2.40880638e-01f, -1.62740558e-01f, -1.91816166e-01f, -2.92017520e-03f, -3.85474949e-03f, -3.30337197e-01f, 3.91761726e-03f,
  -3.17390025e-01f, -1.67792499e-01f, 1.85714781e-01f, -2.04798523e-02f, -1.20913319e-01f, -3.93294916e-02f, 5.06129488e-02f, 4.92084354e-01f, 2.17689857e-01f, -4.83981520e-01f,
  -2.90290833e-01f, -1.62369981e-01f, 6.23793781e-01f, -6.77599087e-02f, 1.34514004e-01f, -2.53627986e-01f, 5.51163912e-01f, -1.62510350e-01f, 8.27617571e-02f, 6.38269959e-03f,
  1.11853629e-01f, -9.82317626e-02f, -1.11068793e-01f, 5.61299101e-02f, -9.79520753e-02f, 1.22538423e-02f, 8.14114884e-02f, 1.91787913e-01f, -7.81029314e-02f, 1.51525080e-01f,
  -5.29803224e-02f, -1.01830304e-01f, -1.41944932e-02f, 3.44594605e-02f, -1.03869312e-01f, 7.34159723e-02f, 1.16620641e-02f, 1.11991458e-01f, -2.83224769e-02f, 1.98456809e-01f,
  1.74120851e-02f, -7.84710795e-02f, -3.04638278e-02f, 2.61521697e-01f, -2.77379870e-01f, 1.20576598e-01f, 3.88519108e-01f, 2.95982152e-01f, 2.24680558e-01f, -3.08520705e-01f,
  2.73688048e-01f, 1.43435135e-01f, -1.80915594e-01f, 2.49022484e-01f, -1.76826298e-01f, -2.74666905e-01f, -3.11643600e-01f, 2.43694142e-01f, 3.07939768e-01f, 3.04004759e-01f,
  1.39724463e-01f, 1.96975559e-01f, 1.20080061e-01f, 2.77326219e-02f, 1.35962501e-01f, 2.86213189e-01f, 1.25591785e-01f, 1.82890534e-01f, -7.74797201e-02f, -3.14583361e-01f,
  -2.48566270e-01f, 3.74999107e-03f, 2.16508120e-01f, -3.25662374e-01f, 1.01105802e-01f, -1.59844458e-02f, 6.31468713e-01f, 3.26908767e-01f, -1.25184059e-01f, 8.79280493e-02f,
  6.75209239e-02f, -5.66657782e-02f, -1.40796378e-01f, -3.00436348e-01f, 2.61740357e-01f, -1.96064517e-01f, 5.09337008e-01f, -2.51933366e-01f, -1.99555501e-01f, -2.06046179e-01f,
  5.23130059e-01f, -1.54573888e-01f, -1.85496673e-01f, 4.11905050e-01f, -3.56032550e-01f, 3.19212489e-03f, -1.73270702e-01f, 5.37909627e-01f, 2.44579673e-01f, -2.62084395e-01f,
  -4.66350615e-02f, -1.32011637e-01f, -2.91894853e-01f, 9.93794277e-02f, -1.56465560e-01f, -3.34552675e-01f, -3.71757597e-01f, -3.83518606e-01f, 4.60433424e-01f, -8.86587650e-02f,
  -1.99403584e-01f, -2.38368124e-01f, 1.36811912e-01f, -2.66817063e-01f, -3.54121290e-02f, 1.19783215e-01f, -1.47478521e-01f, 2.79327750e-01f, -1.32924035e-01f, -1.64368227e-01f,
  -2.42025912e-01f, -1.04819015e-01f, -2.57691503e-01f, 1.50978029e-01f, 3.53228867e-01f, -2.33473659e-01f, -1.53085053e-01f, -1.79093868e-01f, -8.60768557e-02f, -4.06182945e-01f,
  -1.65098190e-01f, 1.72078937e-01f, 7.61790201e-02f, 2.40622029e-01f, -1.29469693e-01f, 1.61133677e-01f, -3.82478058e-01f, -3.64794254e-01f, 3.08495224e-01f, -4.99987938e-02f,
  -3.92129183e-01f, 1.22905008e-01f, -1.02535971e-01f, -1.02972900e-02f, -8.52910895e-03f, -2.56616294e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.97065708e-02f, 6.79568760e-03f, -7.95869753e-02f, -9.71946716e-02f, 8.21349844e-02f, 5.28570451e-02f, 3.55122797e-02f, -5.05248904e-02f, -7.25319386e-02f, -5.60011864e-02f,
  1.09051289e-02f, -1.34444255e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    