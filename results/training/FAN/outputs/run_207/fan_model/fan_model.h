/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.38759151e-01f, -3.61387283e-01f, -5.76715432e-02f, 5.03091700e-02f, 2.25252613e-01f, 3.16769332e-01f, 1.41391665e-01f, -3.14795040e-02f, 1.12045564e-01f, -2.96929002e-01f,
  3.81012484e-02f, -7.98633043e-03f, -1.20222762e-01f, 6.36447668e-02f, 3.72317940e-01f, 2.49842294e-02f, 1.04756258e-01f, -7.69231394e-02f, 4.91883457e-02f, -3.26213613e-02f,
  5.68914227e-02f, 1.78610757e-01f, 4.54486497e-02f, -3.28470245e-02f, -2.88062985e-03f, -9.50018764e-02f, -2.62995601e-01f, -7.82041159e-03f, -9.33042094e-02f, 1.13829263e-01f,
  1.52683049e-01f, -6.53866585e-03f, 3.30204181e-02f, -2.47698519e-02f, -6.35815263e-02f, -9.66156647e-02f, -2.80710161e-02f, 4.40624095e-02f, 1.55165270e-02f, -1.16603812e-02f,
  -5.34029305e-02f, 5.51986471e-02f, 4.38955054e-02f, 8.28354619e-03f, 3.83699313e-02f, 1.46899866e-02f, 1.89216696e-02f, 3.90803516e-02f, -1.99980494e-02f, 1.66143905e-02f,
  3.59374285e-02f, -2.96741743e-02f, -4.39341478e-02f, -2.57686786e-02f, 1.07195880e-02f, 5.28670587e-02f, -2.30149552e-02f, -7.40687037e-03f, -1.57580581e-02f, 1.79755408e-02f,
  -6.68212250e-02f, -2.53597181e-03f, -2.09243651e-02f, -1.68874841e-02f, 8.31017271e-03f, 1.51366219e-02f, 2.76384130e-02f, -5.94678707e-02f, 1.29481182e-02f, -4.70932089e-02f,
  -8.77956208e-03f, 9.03111324e-03f, -1.69330277e-02f, -1.41367801e-02f, -1.81508565e-03f, -3.16656567e-02f, -1.48855066e-02f, -2.70836800e-02f, -2.53700148e-02f, 2.84768399e-02f,
  -2.29241289e-02f, 5.61069511e-03f, 1.16173411e-03f, -6.06694184e-02f, 2.00289376e-02f, 3.00462302e-02f, -2.05809320e-03f, -3.12793329e-02f, -1.94213670e-02f, 5.79625182e-03f,
  -4.03245948e-02f, -3.48368436e-01f, 1.07759861e-02f, 2.57086474e-02f, -4.42230031e-02f, -2.45659444e-02f, -2.32016407e-02f, 4.86228429e-03f, -1.92617588e-02f, 1.95836322e-03f,
  -3.63313965e-02f, -2.29939539e-02f, -7.93647114e-03f, 5.34660295e-02f, -8.19161627e-03f, -1.92726206e-04f, -5.54030687e-02f, -4.39044535e-02f, -4.94449511e-02f, -5.11127226e-02f,
  -1.12016387e-01f, 6.41788729e-03f, 3.72943692e-02f, 5.51400334e-02f, -4.36835662e-02f, -9.28134695e-02f, -2.99276058e-02f, -1.04573518e-02f, -2.71866992e-02f, -3.64434533e-02f,
  -4.61878888e-02f, 1.19581535e-01f, 2.91977614e-01f, -5.86629324e-02f, -8.28441083e-02f, 5.22620201e-01f, 4.22725618e-01f, -3.18799093e-02f, 1.47039548e-01f, 3.89738493e-02f,
  5.37897809e-04f, -2.19156202e-02f, 9.47740600e-02f, -1.08775929e-01f, -3.36300135e-02f, 1.17139906e-01f, -5.49887307e-02f, 7.20868818e-04f, 1.61022693e-02f, -6.32091016e-02f,
  1.41756097e-02f, -1.64715081e-01f, -3.92005928e-02f, 1.50414510e-02f, -1.12944327e-01f, 5.68645634e-03f, -3.11137497e-01f, 2.77304072e-02f, -1.02196798e-01f, -9.34540257e-02f,
  2.33403876e-01f, -7.89848790e-02f, -2.65177165e-04f, -2.82371864e-02f, 3.43633778e-02f, 5.20731173e-02f, -1.34783350e-02f, 3.30321826e-02f, -3.54819521e-02f, -2.34579947e-02f,
  4.62983027e-02f, -5.86147830e-02f, 2.54072100e-02f, -2.17249449e-02f, 1.96882039e-02f, -1.10048940e-02f, 1.17338421e-02f, 2.03202367e-02f, 1.22190965e-02f, -9.54151992e-03f,
  1.08406559e-01f, -2.59061754e-02f, -3.01533230e-02f, -7.40179885e-03f, 5.35254739e-02f, 5.16103581e-02f, 4.67910506e-02f, -2.88405325e-02f, -1.69408340e-02f, -2.41810028e-02f,
  -2.43944973e-02f, 2.19583865e-02f, 3.76992449e-02f, 9.09190532e-03f, 3.95621732e-02f, 1.67929474e-02f, 2.57431883e-02f, -1.64668597e-02f, -6.81746099e-03f, -7.01991701e-03f,
  -3.12989601e-03f, -1.31665450e-02f, -7.66677707e-02f, 1.38015728e-02f, 2.05816142e-02f, -3.97220301e-03f, 1.86526682e-02f, -2.26653609e-02f, 9.52054411e-02f, 1.52734155e-02f,
  -4.88612205e-02f, -1.26197387e-03f, 3.53078842e-02f, -2.64809411e-02f, 2.35847826e-03f, -2.99615376e-02f, -7.65788555e-03f, 2.03832276e-02f, -1.89071409e-02f, -5.04523166e-04f,
  -2.60581337e-02f, -2.29864895e-01f, 9.94690433e-02f, -4.62198444e-03f, 1.61580741e-02f, -8.25922377e-03f, 1.65051837e-02f, 2.59881187e-02f, 1.25055041e-04f, -4.94240457e-03f,
  -6.82579577e-02f, 4.48367745e-02f, -3.06764692e-02f, 7.24344980e-03f, -1.23460311e-02f, 3.27327959e-02f, -1.37910610e-02f, -2.50542499e-02f, -2.59652026e-02f, -7.16192722e-02f,
  -8.58272240e-02f, -3.91992889e-02f, 4.58582938e-02f, 7.15337992e-02f, -3.79921752e-03f, -2.29190551e-02f, -7.18251802e-03f, 4.55947891e-02f, -2.05746945e-02f, -3.32799852e-02f,
  7.11454570e-01f, 2.00351045e-01f, 1.64580762e-01f, 4.44903582e-01f, 6.50463253e-02f, -1.05556503e-01f, 1.13293938e-01f, 8.47586244e-02f, 1.21627472e-01f, -6.07148781e-02f,
  5.80094010e-02f, 1.19168572e-01f, -4.73363027e-02f, -4.35344614e-02f, 4.52631414e-02f, -1.28613845e-01f, 7.23759457e-02f, 8.59606192e-02f, -6.61494583e-02f, 2.57403553e-01f,
  8.19787607e-02f, -3.72656807e-02f, -2.41797809e-02f, 1.71423948e-03f, 9.75933969e-02f, 1.97953075e-01f, 9.35119241e-02f, -1.36193847e-02f, 9.11885798e-02f, -1.12087339e-01f,
  -2.45691859e-03f, -1.04373962e-01f, 2.36169863e-02f, -1.01933919e-01f, 1.08140588e-01f, 3.05461581e-03f, 1.73043367e-02f, -6.78984672e-02f, -8.67995527e-03f, -3.98267806e-03f,
  -8.60877894e-03f, 1.29438229e-02f, -4.51371931e-02f, -6.24147356e-02f, -4.55021532e-03f, 1.74193010e-02f, -2.64989939e-02f, 4.04398181e-02f, -1.19758153e-03f, -6.22245260e-02f,
  3.18777114e-02f, -4.14716192e-02f, 7.09268078e-02f, 1.31626697e-02f, 3.39983143e-02f, -8.89558997e-03f, 1.00723831e-02f, 1.37624061e-02f, 1.54353213e-02f, 2.43880283e-02f,
  -7.00200200e-02f, 9.11002792e-03f, -3.24973613e-02f, -6.69224793e-03f, 2.57332176e-02f, 4.14085463e-02f, 6.69614822e-02f, -3.69516127e-02f, 5.61305508e-02f, -2.26610317e-03f,
  7.51399547e-02f, 5.24724834e-02f, -4.59002741e-02f, -8.81706190e-04f, 5.72749823e-02f, 3.20192501e-02f, -2.65793130e-02f, 2.30242571e-04f, 5.57803735e-02f, 1.76360812e-02f,
  -2.07530018e-02f, 2.50264220e-02f, 6.58170134e-02f, 6.31156890e-03f, -1.99290477e-02f, 7.36660650e-03f, 1.88625604e-03f, 2.71039475e-02f, 8.20316095e-03f, 9.96680651e-03f,
  2.92623758e-01f, 2.68055975e-01f, -2.84060873e-02f, 7.85191357e-03f, -2.37652846e-02f, -3.13243158e-02f, -6.10918105e-02f, 1.66665986e-02f, 2.91447733e-02f, 2.32182778e-02f,
  -4.68555809e-04f, 2.06234325e-02f, 4.20223176e-02f, 4.43392619e-02f, -2.22776849e-02f, -5.31307142e-03f, 9.93189029e-03f, 2.02120673e-02f, 1.40819522e-02f, 3.91291156e-02f,
  4.10133041e-02f, 9.77834687e-03f, -5.02456054e-02f, -1.41739296e-02f, -3.90787087e-02f, 7.83873275e-02f, 1.04765380e-02f, 1.49075426e-02f, -3.40137519e-02f, 4.30564769e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.69420743e-02f, -2.80330807e-01f, -5.97430170e-02f, -1.11399963e-01f, -1.05077989e-01f, -1.21617094e-01f, 8.63016248e-02f, -5.26288092e-01f, -2.88110375e-01f, -3.30748647e-01f,
  -7.38878325e-02f, 3.18336278e-01f, 4.26123828e-01f, -4.85517383e-01f, 6.21784389e-01f, 2.05591440e-01f, -4.04827535e-01f, -4.11650389e-02f, -7.28467852e-02f, -3.81177127e-01f,
  -8.60745609e-02f, -5.02790093e-01f, 1.88660726e-01f, -4.69644457e-01f, -2.85057038e-01f, -2.89885223e-01f, 1.82757512e-01f, 2.18200311e-01f, -3.13367039e-01f, 1.64286897e-01f,
  -1.07544497e-01f, -1.68007463e-01f, -1.60628125e-01f, -4.88517396e-02f, -1.06288984e-01f, 5.86603805e-02f, 1.03857130e-01f, 2.55590588e-01f, 6.33621356e-03f, -7.78062642e-03f,
  6.20762594e-02f, 2.46255193e-02f, -2.15693071e-01f, 4.37608324e-02f, -8.79902318e-02f, -1.61646724e-01f, 2.35282723e-02f, -5.22663668e-02f, -3.87139358e-02f, 7.50348866e-02f,
  -1.23060262e-02f, -1.62002221e-02f, -9.12003219e-02f, -3.61300958e-03f, 3.06632668e-02f, -1.22579932e-01f, 2.83725336e-02f, 1.14802435e-01f, -4.71730493e-02f, -1.19797572e-01f,
  -1.04123950e-01f, 5.83296008e-02f, 4.26603332e-02f, -5.09991050e-02f, -3.63430344e-02f, -5.07472530e-02f, 2.91688498e-02f, 2.47257464e-02f, 4.28758673e-02f, -6.22657128e-02f,
  -1.02575198e-02f, -1.33944573e-02f, -1.10371217e-01f, 3.61248143e-02f, -5.13128564e-02f, -2.51532253e-02f, 9.79847312e-02f, 1.00464374e-03f, -2.64197737e-02f, -4.06283550e-02f,
  1.31599056e-02f, 4.58698161e-02f, 3.42414938e-02f, 2.25169174e-02f, 3.10736080e-03f, 7.82438442e-02f, -4.74126376e-02f, -1.87768806e-02f, 1.87098607e-02f, 4.15639281e-02f,
  2.45300084e-02f, -2.53999084e-01f, -8.95341039e-02f, -2.47045141e-02f, 4.77016671e-03f, -1.09702133e-01f, -3.23653184e-02f, -1.51847199e-01f, 3.65404114e-02f, -1.68045387e-02f,
  -4.51740623e-02f, 4.00301218e-02f, 5.92121482e-02f, -1.07833650e-02f, 5.03352620e-02f, -6.49832711e-02f, 3.52694318e-02f, 7.91211724e-02f, -1.17689064e-02f, -5.35274446e-02f,
  1.35179106e-02f, -1.22033739e-02f, 1.12221576e-01f, -1.27039999e-01f, -9.83251557e-02f, 1.32530794e-01f, -1.47732452e-01f, 6.00194484e-02f, 1.19357906e-01f, 4.01461534e-02f,
  -3.35815132e-01f, 2.89768994e-01f, -2.18215108e-01f, 1.60324231e-01f, -1.77573055e-01f, 5.30246384e-02f, 9.43967849e-02f, -7.30771422e-02f, -1.76113158e-01f, 3.39524686e-01f,
  1.83330134e-01f, -2.67071389e-02f, 1.04551330e-01f, 4.60602671e-01f, 3.04771718e-02f, 1.97965145e-01f, 3.60992283e-01f, 2.82570988e-01f, 7.93067738e-02f, -2.30288897e-02f,
  1.17126303e-02f, 3.51149648e-01f, 2.47276351e-01f, 1.64545164e-01f, 8.56023431e-02f, -6.86263219e-02f, 2.75950074e-01f, -9.51483250e-02f, 2.11571068e-01f, 8.31054598e-02f,
  1.70009717e-01f, 1.34600177e-01f, -5.67300022e-02f, -7.82087371e-02f, -3.25793074e-03f, 3.06757092e-02f, 1.47674391e-02f, -1.04011809e-02f, -4.25276458e-02f, -7.89523274e-02f,
  -5.27467430e-02f, 1.53721427e-03f, 2.78810151e-02f, 8.35123472e-03f, -3.26251946e-02f, -3.66900787e-02f, 3.04933283e-02f, -1.81248330e-03f, -3.78700159e-02f, -4.79181893e-02f,
  -5.62186874e-02f, -3.39179747e-02f, -8.26608688e-02f, 9.51052010e-02f, -3.17158177e-02f, 8.45985040e-02f, 3.99981290e-02f, 1.82320718e-02f, 8.74184370e-02f, 2.31030560e-03f,
  2.25279126e-02f, 1.62718073e-02f, 7.49456063e-02f, 3.71472985e-02f, 7.57310465e-02f, 1.31585123e-02f, 4.41044159e-02f, 2.99668703e-02f, -6.92997128e-02f, 5.11493646e-02f,
  -2.65109986e-02f, -2.96856761e-02f, 1.01161823e-02f, 1.68623552e-02f, -3.35772149e-02f, 3.84756625e-02f, -5.60170993e-05f, -6.49228552e-03f, 3.49100903e-02f, -2.42764000e-02f,
  4.23135534e-02f, -9.87323597e-02f, 1.18738897e-01f, -3.73377651e-02f, -1.96764320e-02f, -5.25479056e-02f, 7.20032007e-02f, 6.39403090e-02f, 7.94366598e-02f, -4.72831614e-02f,
  1.53575599e-01f, 1.46180481e-01f, 3.92976254e-02f, 3.96334520e-03f, 3.90924513e-02f, 2.22364496e-02f, 1.28821833e-02f, -9.75314993e-03f, 4.58231680e-02f, -3.26716946e-03f,
  5.18146995e-03f, 5.79067855e-04f, 4.08791984e-03f, -5.15749454e-02f, 6.83729118e-03f, 1.50530204e-01f, 8.30628946e-02f, -1.74500179e-02f, 1.68485325e-02f, 1.11832269e-01f,
  -8.74075759e-03f, 1.91188101e-02f, -2.19075624e-02f, 2.41414011e-02f, -2.00212765e-02f, -4.22342867e-02f, 2.42590737e-02f, -1.99142080e-02f, -2.42911614e-02f, -1.77128781e-02f,
  -2.93957710e-01f, 9.16018724e-01f, 5.09418905e-01f, -5.28292917e-02f, -3.26274902e-01f, 3.27997684e-01f, 1.42713904e-01f, 5.50636835e-02f, 2.62564510e-01f, 2.15824947e-01f,
  -3.61392289e-01f, 6.00504398e-01f, -1.45334769e-02f, 1.75652623e-01f, -2.86060303e-01f, 1.80901527e-01f, 8.05928707e-02f, 1.96286395e-01f, 1.38512939e-01f, -9.34506208e-02f,
  -1.72613323e-01f, -3.31834704e-01f, -1.32704630e-01f, -9.73149985e-02f, -2.44086608e-01f, 2.74002943e-02f, -4.24569964e-01f, 4.94277403e-02f, -7.72390962e-02f, 1.69031210e-02f,
  -1.37063771e-01f, -1.12663522e-01f, -2.52523534e-02f, 1.25120416e-01f, -7.11081773e-02f, -1.34125561e-03f, 8.11871607e-03f, -6.62913173e-02f, -5.65594099e-02f, 3.49108502e-02f,
  8.32928643e-02f, -7.19078304e-03f, 8.59119743e-03f, 4.37259153e-02f, 8.81347731e-02f, 6.09623156e-02f, -2.10268330e-02f, -1.06871473e-02f, 9.17807072e-02f, 7.50641599e-02f,
  4.41562124e-02f, -2.19946541e-03f, -1.69311874e-02f, 6.30093515e-02f, 1.40992980e-02f, 6.37850836e-02f, 3.52384038e-02f, 4.84414864e-03f, 2.63451710e-02f, 7.52764642e-02f,
  -4.26838361e-02f, 2.63328999e-02f, -2.84247678e-02f, -6.64660409e-02f, 8.27680435e-03f, -1.01872168e-01f, 5.06478101e-02f, -1.58870324e-01f, 9.32587609e-02f, -8.23062807e-02f,
  -8.16097632e-02f, -4.64297384e-02f, -3.03575397e-03f, 2.32535638e-02f, -6.01194538e-02f, 4.00571302e-02f, -8.99287686e-02f, -3.10321357e-02f, 2.49595102e-02f, -3.39243561e-02f,
  -5.63775562e-03f, 1.42658539e-02f, 3.01130507e-02f, -4.48625647e-02f, 2.81161889e-02f, -2.66058259e-02f, 2.20679212e-03f, 3.33788767e-02f, -1.33416867e-02f, -3.57901230e-02f,
  9.64117497e-02f, 9.57875177e-02f, 1.90229025e-02f, 1.07747335e-02f, 2.54570302e-02f, -5.40335886e-02f, 8.76488723e-03f, 6.06314419e-03f, 1.14123888e-01f, -6.17514402e-02f,
  -3.72521393e-02f, -2.63598450e-02f, 1.53562566e-02f, -4.35450226e-02f, 2.49027293e-02f, -1.14472292e-03f, 8.27021711e-03f, 6.19337261e-02f, -3.02726906e-02f, -2.50431597e-02f,
  -5.73643073e-02f, 2.52015553e-02f, -8.30135681e-03f, -5.62293120e-02f, -5.86097091e-02f, -9.33340713e-02f, 3.12256124e-02f, 1.27509743e-01f, -3.34225819e-02f, 3.85048501e-02f,
  -7.62083054e-01f, 2.84510821e-01f, -1.02719687e-01f, -2.43354905e-02f, -2.39534020e-01f, -2.81200036e-02f, 9.14295688e-02f, 7.93813542e-03f, -2.41969377e-02f, 3.44824165e-01f,
  1.54894441e-01f, -1.07025221e-01f, 3.28790218e-01f, 2.85691381e-01f, -2.64860243e-01f, 3.69575679e-01f, 1.05997048e-01f, 2.06386391e-02f, -4.63243313e-02f, -8.82948413e-02f,
  -1.55552164e-01f, 1.49780720e-01f, 1.36986002e-01f, 8.99517313e-02f, -5.03796600e-02f, -1.24772698e-01f, -3.76956761e-02f, 6.92766979e-02f, -3.83718149e-03f, -7.02018142e-02f,
  -1.34089053e-01f, -2.35467821e-01f, -1.13391653e-01f, -2.61813626e-02f, -1.89460620e-01f, -1.13366015e-01f, -5.09901494e-02f, -3.85432085e-03f, -7.56716207e-02f, -5.50852157e-02f,
  -6.59487173e-02f, -5.81535744e-03f, 2.51329225e-02f, -3.60087790e-02f, -8.85679275e-02f, -2.13069911e-03f, 2.54804865e-02f, 1.61676854e-02f, 1.02494545e-01f, 7.52288662e-03f,
  4.01671156e-02f, -1.29293427e-02f, -2.18818728e-02f, 3.25080343e-02f, -2.36962158e-02f, -2.30547674e-02f, 5.21668866e-02f, -4.40462716e-02f, -1.61695793e-01f, -6.45013228e-02f,
  -3.98170650e-02f, -3.33801992e-02f, 4.51925099e-02f, -6.41061366e-02f, -9.97929927e-03f, 3.36000882e-02f, 8.32182448e-03f, -2.75927745e-02f, -9.37403087e-03f, 2.60052197e-02f,
  -1.38205066e-02f, 7.08067603e-03f, -2.30620820e-02f, 9.08828247e-03f, -5.47355823e-02f, 5.89540415e-02f, -1.44715635e-02f, -4.86848056e-02f, 5.74154370e-02f, -4.67363857e-02f,
  -3.62905441e-03f, 3.21445838e-02f, -2.02447246e-03f, 3.81932072e-02f, -1.47416079e-02f, 4.15361114e-02f, -1.42869018e-02f, 3.44616398e-02f, -4.96879555e-02f, -3.44244465e-02f,
  -3.90452296e-01f, -2.63042629e-01f, -2.64475774e-02f, -7.65312091e-02f, -2.11987980e-02f, -6.42879158e-02f, 1.60568506e-02f, -5.24421073e-02f, -2.41809394e-02f, -4.17782217e-02f,
  -7.99809620e-02f, -7.83099141e-03f, -4.88502830e-02f, -1.93576366e-02f, -3.78202870e-02f, -1.95906404e-02f, -1.84171349e-02f, -4.34626974e-02f, -9.11237895e-02f, -4.20865268e-02f,
  -2.05344427e-02f, 5.79358218e-03f, 8.25743824e-02f, 1.42312218e-02f, -3.44298892e-02f, 3.14000621e-02f, -6.79509714e-02f, 1.33802667e-02f, -8.75499919e-02f, 1.48922903e-02f,
  5.51059306e-01f, 5.01562469e-02f, -2.86855012e-01f, 3.75793129e-02f, -7.15672225e-02f, 3.60377014e-01f, 2.44274035e-01f, 7.81603381e-02f, 1.67422578e-01f, 2.45306730e-01f,
  -4.04836647e-02f, 1.12347230e-02f, 5.28393984e-02f, -7.75054190e-03f, -6.36400878e-02f, 3.29036750e-02f, 2.08340093e-01f, 1.47818834e-01f, 4.45614271e-02f, 8.94304141e-02f,
  -3.10868770e-02f, 1.99769393e-01f, -2.11247161e-01f, -2.61229742e-02f, -5.26392944e-02f, -1.56912997e-01f, -2.05140844e-01f, -7.47875795e-02f, -1.17346473e-01f, -8.81247222e-02f,
  2.79037207e-02f, -1.22901499e-01f, -1.22556768e-01f, -5.79549298e-02f, -1.04004089e-02f, 6.75557065e-04f, 1.10456254e-02f, -3.39489281e-02f, -1.08805023e-01f, -1.92848016e-02f,
  -1.32474061e-02f, -3.73912938e-02f, 5.72738163e-02f, -3.06268409e-02f, -1.26429638e-02f, -5.99279106e-02f, -8.72995928e-02f, -7.13637620e-02f, -8.97645205e-03f, -3.16951498e-02f,
  -9.94012356e-02f, -1.15480028e-01f, -7.02081174e-02f, -1.84777267e-02f, -6.15673065e-02f, 3.08828019e-02f, 7.40029057e-03f, -2.79541444e-02f, -2.34437566e-02f, 3.05379871e-02f,
  -1.25567049e-01f, 9.75438729e-02f, 1.76605657e-02f, 7.55050965e-03f, 2.75402162e-02f, -3.56837846e-02f, 4.58457395e-02f, 1.39836557e-02f, 1.05537763e-02f, 2.69152429e-02f,
  4.65768762e-02f, 5.87136745e-02f, -4.75363918e-02f, 5.86914346e-02f, 2.82483213e-02f, 4.71744686e-02f, 6.30587563e-02f, -8.03703442e-03f, 1.88313648e-02f, -1.46558313e-02f,
  -2.69684773e-02f, -3.50548886e-02f, 1.20074032e-02f, -7.49470061e-03f, -2.82201380e-03f, -1.38573125e-02f, -3.16643082e-02f, -5.80176264e-02f, -1.45629114e-02f, 3.24017107e-02f,
  3.65167260e-02f, 2.69513845e-01f, 7.22461939e-02f, -2.64202673e-02f, 4.29996066e-02f, -9.26737953e-03f, 3.49786207e-02f, -8.54735728e-03f, 3.05465609e-02f, 4.85053957e-02f,
  -2.99338885e-02f, 1.08738311e-01f, 5.31126894e-02f, -5.86313307e-02f, -1.69320274e-02f, -1.61364377e-02f, 3.58702391e-02f, 2.49298234e-02f, -1.69564877e-03f, -4.80890162e-02f,
  -9.05087292e-02f, 9.52051058e-02f, 4.04479094e-02f, 4.87437434e-02f, -1.68505665e-02f, -7.02717081e-02f, 7.93375224e-02f, -4.37755547e-02f, -5.56086600e-02f, -6.28977455e-03f,
  5.02814651e-01f, 2.03210220e-01f, -3.27681065e-01f, -2.04485551e-01f, 8.27883333e-02f, 4.48563665e-01f, 4.43478674e-01f, -1.30634323e-01f, -1.88254878e-01f, 2.61560261e-01f,
  2.95659184e-01f, -8.91910046e-02f, 1.35797009e-01f, 1.85420290e-01f, 7.87691250e-02f, 1.57157779e-01f, 1.76723257e-01f, 1.12816535e-01f, -2.03834981e-01f, -7.65717495e-03f,
  -1.61762640e-01f, 3.02184850e-01f, -1.85880914e-01f, -1.28324628e-01f, 8.69870931e-02f, -2.96808660e-01f, -2.69833393e-02f, -5.17147817e-02f, -6.19872175e-02f, 1.12414129e-01f,
  -2.23727059e-02f, -1.03736706e-01f, -6.38859570e-02f, 2.68754326e-02f, 1.10988514e-02f, 2.00134143e-02f, 7.02280477e-02f, 4.38291095e-02f, -9.30375829e-02f, 6.44805655e-03f,
  4.10123840e-02f, -2.47941446e-02f, -7.79024214e-02f, 1.50679421e-04f, 2.60675643e-02f, -1.21612795e-01f, -8.40353668e-02f, -6.59144577e-03f, -7.43265823e-02f, 6.54437840e-02f,
  -8.86646137e-02f, 3.22250165e-02f, -7.23180994e-02f, -5.87805212e-02f, -1.80560902e-01f, -5.92150353e-02f, 8.12950835e-04f, -3.29985283e-02f, -9.20963008e-03f, 5.53675331e-02f,
  1.12075277e-01f, 6.21183924e-02f, 5.34572825e-03f, -2.24395171e-02f, 8.35086312e-03f, 1.10528655e-02f, -4.43891399e-02f, -5.29576391e-02f, -2.55593993e-02f, 5.94360679e-02f,
  -7.81620443e-02f, -6.10763393e-02f, 9.06666592e-02f, 2.55619474e-02f, 7.47837592e-03f, -7.08418200e-03f, 2.33568717e-02f, -2.30534580e-02f, -4.15030420e-02f, -4.78757508e-02f,
  -2.81627979e-02f, 7.52020702e-02f, -6.72152489e-02f, -2.16839574e-02f, 5.57856523e-02f, -1.48226498e-02f, 8.91978145e-02f, 3.89756933e-02f, -9.51797068e-02f, 2.30353363e-02f,
  4.00969088e-02f, 7.60113075e-02f, -1.05067320e-01f, 8.25259984e-02f, -2.45066639e-02f, 3.69672142e-02f, -9.75310896e-03f, 2.16977904e-03f, 2.90219206e-02f, 3.89858969e-02f,
  1.60161201e-02f, -1.48751456e-02f, 2.75231432e-02f, -3.04933898e-02f, -7.18410388e-02f, 9.30691585e-02f, 4.68777493e-02f, -6.06492981e-02f, 3.48623432e-02f, 1.89643130e-02f,
  5.75426556e-02f, 3.70925702e-02f, 3.40157934e-02f, -6.31057173e-02f, 6.09656200e-02f, 7.77204409e-02f, 3.56642976e-02f, 5.63209429e-02f, 3.12760584e-02f, -5.78963980e-02f,
  -3.96754593e-01f, 1.64099023e-01f, -2.90161192e-01f, -2.86506325e-01f, 4.56491411e-02f, -2.36779675e-01f, -2.08252162e-01f, 1.39879093e-01f, -9.81588811e-02f, 1.17183194e-01f,
  2.99427789e-02f, -1.30561471e-01f, 9.56095234e-02f, -3.55864555e-01f, -3.28798950e-01f, -1.61324628e-02f, -3.92235577e-01f, -1.34909630e-01f, 3.42656374e-02f, -7.34802186e-02f,
  -1.43366247e-01f, -1.58917040e-01f, -2.39554703e-01f, 1.44971117e-01f, -1.52812138e-01f, 3.10424697e-02f, 6.99749514e-02f, 1.52396679e-01f, -1.43867448e-01f, -5.64466193e-02f,
  6.79200282e-04f, 7.13697150e-02f, -1.52913798e-02f, -2.48118490e-02f, -5.95075935e-02f, -1.81223806e-02f, 2.25362554e-02f, -1.15933605e-02f, -2.41649039e-02f, -4.59756888e-02f,
  -2.53850548e-03f, 3.47521305e-02f, -8.13423097e-02f, -1.57102570e-02f, -6.92629069e-02f, -4.32667248e-02f, -6.22816086e-02f, 3.91453840e-02f, -4.46276553e-02f, -2.20193733e-02f,
  -6.36282787e-02f, -5.65667972e-02f, -4.05324697e-02f, 1.11060590e-03f, -1.44539088e-01f, -1.00296549e-02f, -1.06128648e-01f, -5.49113788e-02f, 3.46745327e-02f, 6.82753474e-02f,
  -1.07546084e-01f, -4.25105132e-02f, -5.73047698e-02f, 2.08495688e-02f, -1.73112415e-02f, 4.63324860e-02f, -5.52729405e-02f, 4.60560322e-02f, -1.25877671e-02f, 5.17108366e-02f,
  2.09854841e-02f, -9.17681828e-02f, -2.92273015e-02f, -2.71101762e-02f, -3.63144800e-02f, -3.78489569e-02f, -6.44644722e-02f, 2.68732551e-02f, -7.42128640e-02f, 1.12677831e-02f,
  9.56996828e-02f, -3.62420920e-03f, 5.17242849e-02f, 3.34593072e-03f, -9.18790326e-03f, -1.59506798e-02f, 1.50773050e-02f, 4.29963693e-02f, -2.76554525e-02f, -3.11257429e-02f,
  8.63137469e-02f, 1.73447222e-01f, -3.06149181e-02f, 1.12299308e-01f, 6.59783483e-02f, -2.49429774e-02f, -8.20064619e-02f, -1.24333613e-02f, -1.24906171e-02f, -3.53553817e-02f,
  -4.86921668e-02f, -4.25945260e-02f, -1.68125369e-02f, -2.92963535e-02f, 4.86384742e-02f, 3.66582088e-02f, -2.75742579e-02f, 5.44703659e-03f, -2.87783556e-02f, -1.86051428e-02f,
  4.73819040e-02f, 1.25589697e-02f, -6.11799732e-02f, -3.33651714e-02f, -2.38855416e-03f, -1.92486141e-02f, 6.15508631e-02f, 1.99929439e-03f, -3.42886597e-02f, -1.80971343e-02f,
  -1.59425795e-01f, -2.89755106e-01f, -2.48355761e-01f, 5.45626804e-02f, 9.54046547e-02f, 1.02337688e-01f, -1.55043781e-01f, -9.18844268e-02f, -2.91054636e-01f, 1.15334708e-02f,
  3.57167758e-02f, -3.65240686e-02f, -4.39163834e-01f, 6.96273670e-02f, -1.34027138e-01f, -3.23405892e-01f, 1.11996099e-01f, 4.10054140e-02f, -1.78413466e-01f, -9.89086106e-02f,
  -5.62920272e-02f, 2.18162045e-01f, -5.58575019e-02f, 2.88670242e-01f, 1.74287811e-01f, 9.39401984e-02f, 2.09935308e-01f, -3.14981341e-02f, 4.46680427e-01f, 2.22663254e-01f,
  2.37581506e-02f, -7.85165876e-02f, 4.02044058e-02f, -1.76754110e-02f, -1.71625707e-02f, 1.45772383e-01f, 1.20980479e-01f, 6.37124404e-02f, 6.37876168e-02f, -8.07278901e-02f,
  3.63428667e-02f, 3.53567814e-03f, 4.78238575e-02f, -2.11320221e-02f, 2.35180538e-02f, 1.16804778e-03f, -5.56181278e-03f, 1.07308142e-02f, 5.18257357e-02f, -9.82469022e-02f,
  -1.14120573e-01f, -1.64289679e-02f, 1.75170377e-02f, 1.26287609e-01f, -6.78643361e-02f, -2.27949303e-02f, 1.99372340e-02f, -2.49013631e-03f, 2.86685377e-02f, 1.35540888e-02f,
  -7.94004835e-03f, 1.17859589e-02f, 3.90012423e-03f, 1.36348400e-02f, -3.57813314e-02f, 2.10484583e-02f, 5.22950590e-02f, 1.17352791e-02f, -2.32078955e-02f, -2.26489492e-02f,
  9.38134566e-02f, 1.93410087e-02f, -3.78745608e-03f, -3.02457996e-02f, -1.38652055e-02f, 2.42417976e-02f, 2.85515953e-02f, -1.22213615e-02f, -7.20773917e-03f, -3.69598791e-02f,
  6.68286160e-03f, 9.15354677e-03f, -4.56660390e-02f, 4.97188903e-02f, -6.38133138e-02f, -1.98589657e-02f, -1.45370467e-02f, -4.13151234e-02f, 3.78136560e-02f, 2.30301358e-02f,
  3.59539501e-02f, -1.88295439e-01f, -7.34508485e-02f, 3.25210169e-02f, 2.98279263e-02f, 3.22712809e-02f, -1.00081429e-01f, 2.51343045e-02f, -7.75108114e-02f, -8.48193094e-02f,
  6.93954974e-02f, 9.61068198e-02f, 3.01517285e-02f, 2.71537453e-02f, 1.14226356e-01f, -6.33514766e-03f, -1.44432969e-02f, 5.00206500e-02f, -3.31592583e-03f, 6.78597242e-02f,
  -1.30573260e-02f, 7.20401062e-03f, 2.20103785e-02f, -8.57747123e-02f, 5.03154583e-02f, -3.18620633e-03f, 4.40600477e-02f, 1.76715348e-02f, 6.78365529e-02f, 3.89905041e-03f,
  -1.86039820e-01f, 2.73308337e-01f, -1.30298123e-01f, -1.56121686e-01f, 9.28556696e-02f, -1.82518423e-01f, -5.46301827e-02f, -6.41898438e-02f, -5.45969345e-02f, 3.15732390e-01f,
  -2.40734182e-02f, 2.44622871e-01f, 6.72302544e-02f, -2.26847604e-01f, -8.18177462e-01f, -2.66416609e-01f, -3.23979378e-01f, -9.80780423e-02f, -1.90474242e-01f, -4.60999981e-02f,
  -3.11134011e-01f, -6.43991455e-02f, -3.84705722e-01f, 8.32073912e-02f, 1.93320718e-02f, 1.31114691e-01f, 1.62712894e-02f, 1.61486372e-01f, 3.83330807e-02f, 5.39952144e-03f,
  -1.77677274e-02f, 1.67114928e-01f, 4.09830809e-02f, 3.88520397e-02f, -9.15308371e-02f, -3.42268571e-02f, 3.76177095e-02f, -1.45666292e-02f, -3.52155864e-02f, -7.46073276e-02f,
  1.11936845e-01f, -3.55773270e-02f, -1.65774170e-02f, 8.60008132e-03f, 5.34361005e-02f, 8.12781975e-02f, 1.04754511e-02f, -5.38836308e-02f, 6.60043582e-02f, -6.71826024e-03f,
  -9.69438534e-03f, -1.57183260e-02f, -1.71698891e-02f, -4.07115333e-02f, -6.54347166e-02f, -2.23731250e-02f, 9.11958236e-03f, 9.73686352e-02f, -2.03310256e-03f, -9.04563591e-02f,
  -7.50195533e-02f, 2.19728425e-02f, -1.10061644e-02f, 5.82472747e-03f, -1.03216842e-02f, 4.81289327e-02f, 4.62319702e-03f, 4.00132798e-02f, 4.05026823e-02f, -4.26017027e-03f,
  -3.51642743e-02f, 1.59879141e-02f, 2.96672503e-03f, -3.15876342e-02f, 9.17227753e-03f, 4.94657531e-02f, 3.95678692e-02f, -1.47529598e-02f, -7.04515800e-02f, -1.64654832e-02f,
  8.89135059e-03f, -2.52096187e-02f, 2.29435489e-02f, -1.01899300e-02f, -6.71599582e-02f, 5.40003926e-02f, 8.76322668e-03f, 1.90725774e-02f, -3.39767449e-02f, -3.24382260e-02f,
  -1.39336169e-01f, -9.97194871e-02f, 5.00982516e-02f, 9.10472199e-02f, -1.78045630e-02f, 1.02227861e-02f, -8.52239877e-02f, -3.80763859e-02f, -4.07297425e-02f, -1.57175958e-02f,
  -3.81502346e-03f, 6.22506347e-03f, -2.31605191e-02f, 8.05928186e-03f, -3.71854492e-02f, -7.69289285e-02f, 1.48667237e-02f, 2.45258491e-02f, -3.88075113e-02f, -1.26780430e-02f,
  9.12062675e-02f, 7.48273730e-02f, 4.47812537e-03f, 2.28549764e-02f, -1.35771250e-02f, 8.44353437e-02f, 3.20772082e-02f, 1.14680538e-02f, -6.84592873e-03f, -7.68640544e-03f,
  -1.61234573e-01f, 1.01708360e-01f, -1.03681341e-01f, 1.75973535e-01f, 2.17339665e-01f, 3.41662139e-01f, 3.82401109e-01f, 1.40312001e-01f, 3.66980731e-01f, 3.35564584e-01f,
  2.35136598e-01f, -9.34610665e-02f, 4.75490503e-02f, 3.50934714e-01f, 3.11870575e-02f, 1.77340314e-01f, 3.55332285e-01f, 2.23876432e-01f, -2.94261128e-02f, -3.66181806e-02f,
  -1.14144444e-01f, 1.69797391e-01f, -1.09306403e-01f, -9.43785384e-02f, 3.34393000e-03f, -2.51135916e-01f, -4.48536538e-02f, -2.55721390e-01f, 5.46676330e-02f, 1.40606984e-02f,
  1.89830475e-02f, -6.15533181e-02f, -4.98904809e-02f, 2.26218235e-02f, -5.36005311e-02f, -1.24031156e-01f, -5.01636378e-02f, -1.23621590e-01f, -6.66586980e-02f, -5.95503561e-02f,
  -1.07698273e-02f, -1.39645472e-01f, 2.11119968e-02f, 1.65694542e-02f, 2.35511102e-02f, -2.42079864e-03f, -1.50996642e-02f, 5.59473522e-02f, 1.06508844e-03f, -9.81903598e-02f,
  2.92813014e-02f, 6.83081970e-02f, 5.27548827e-02f, 6.71426952e-02f, 2.50445772e-02f, 5.86758219e-02f, 8.98238122e-02f, -3.57367173e-02f, -1.92400869e-02f, 4.51131426e-02f,
  -5.30042723e-02f, -5.81717901e-02f, -4.65995446e-02f, 2.37484891e-02f, -8.50635096e-02f, 4.56212880e-03f, 6.76738098e-02f, 1.14764515e-02f, 1.69836693e-02f, 3.35360542e-02f,
  3.79836708e-02f, -8.93495977e-03f, 2.06249487e-02f, -3.25435959e-02f, 3.05170715e-02f, 6.45087957e-02f, -4.82782610e-02f, 2.49341000e-02f, 1.28518585e-02f, 1.53200999e-01f,
  4.92155068e-02f, -4.17504199e-02f, 3.79209146e-02f, 1.53794428e-02f, 5.66758737e-02f, -2.29363353e-03f, 7.95893595e-02f, -2.62118442e-06f, 5.88689372e-02f, 7.90109299e-03f,
  1.00119203e-01f, -3.53668369e-02f, 1.42070949e-02f, -2.26639938e-02f, -1.24818394e-02f, 1.79096330e-02f, 9.85655654e-03f, 2.14328840e-02f, 3.66410017e-02f, 2.19457094e-02f,
  5.97770102e-02f, 6.74452037e-02f, -5.54060452e-02f, 1.71165038e-02f, 1.12489006e-02f, 7.88177177e-02f, -2.00444348e-02f, 5.12183458e-02f, 8.79091397e-02f, -9.16306078e-02f,
  -3.16027291e-02f, -9.71373022e-02f, -3.15798521e-02f, -2.63329875e-02f, 1.22434177e-01f, -3.32991853e-02f, -7.61175826e-02f, -7.74463639e-02f, 6.13317778e-03f, 4.40335870e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.29949042e-01f, 3.61238360e-01f, 8.31781864e-01f, 2.22225115e-01f, 3.36515963e-01f, 4.41646606e-01f, 4.17389721e-01f, 1.91214398e-01f, 2.25305021e-01f, 1.88515276e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.42235065e-01f, 3.13823223e-01f, 8.37626904e-02f, -6.12421870e-01f, -3.58859420e-01f, 6.16468370e-01f, -5.51425397e-01f, 9.70178246e-02f, 1.99571460e-01f, -3.38885427e-01f,
  5.26502550e-01f, 2.35919505e-01f, 5.73800318e-02f, 6.39611483e-02f, 1.28768593e-01f, 5.35130464e-02f, 7.73624480e-02f, -5.82203627e-01f, -4.55289185e-01f, -2.51627177e-01f,
  -1.20972320e-01f, -6.46721959e-01f, 7.03850687e-02f, 1.31758332e-01f, -1.29014090e-01f, 4.17365372e-01f, -2.97482431e-01f, -3.34387660e-01f, 2.97322512e-01f, -4.17949557e-01f,
  8.60672817e-02f, -1.99730456e-01f, -2.58204281e-01f, -5.98721862e-01f, 1.13050610e-01f, -1.53730661e-01f, -2.58116275e-01f, -4.22399461e-01f, 2.99242765e-01f, 5.49435355e-02f,
  -4.11683172e-01f, 2.05322057e-01f, -4.13567960e-01f, -2.07359642e-01f, 5.57916224e-01f, 1.10881217e-01f, -7.52266555e-04f, -5.52739799e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.89579463e-01f, 2.65280694e-01f, 1.18969351e-01f, 3.08971554e-01f, 5.14206290e-01f, -8.20849538e-02f, 6.79332972e-01f, -1.95989460e-01f, 1.20664430e+00f, -3.58540356e-01f,
  1.11970849e-01f, -1.77159235e-01f, 2.30755895e-01f, -2.38519236e-01f, -8.33475739e-02f, -5.08556485e-01f, 2.50306964e-01f, 1.14905410e-01f, 5.23782253e-01f, 2.15219893e-02f,
  -3.26583445e-01f, 6.52835518e-02f, 6.44513905e-01f, 3.99933234e-02f, -2.99214460e-02f, -5.07152081e-01f, 3.85972232e-01f, 5.97785771e-01f, 2.31926084e-01f, 4.05484624e-02f,
  -2.23889817e-02f, 9.84103084e-02f, 3.06764871e-01f, 4.68005121e-01f, 3.03698480e-01f, 7.33651698e-01f, 8.84722292e-01f, -1.79920852e-01f, -1.20565601e-01f, 2.35659048e-01f,
  1.68909058e-01f, 5.42758644e-01f, 5.02856672e-01f, 5.95329523e-01f, -2.47437119e-01f, -2.54955500e-01f, -5.44549942e-01f, 7.30044663e-01f, -2.54882991e-01f, -3.24362796e-03f,
  4.08489972e-01f, 5.84572911e-01f, -3.70424926e-01f, -1.22869067e-01f, 2.62137890e-01f, 2.20707715e-01f, -1.34098664e-01f, -2.38968134e-01f, -1.03583597e-01f, -5.62163964e-02f,
  -1.61614850e-01f, 8.85650516e-01f, 3.95633169e-02f, 1.77835360e-01f, 6.59795523e-01f, -3.07046194e-02f, -4.08011675e-02f, 2.49269053e-01f, 4.58288103e-01f, -7.98154593e-01f,
  -1.67752653e-01f, 3.98302317e-01f, 9.86025691e-01f, 5.93770146e-01f, -2.50594258e-01f, -2.26495460e-01f, 2.38869473e-01f, -2.30578914e-01f, 9.43193287e-02f, -2.97220871e-02f,
  -1.28145069e-01f, 2.80055940e-01f, 4.98253852e-01f, 4.15262073e-01f, -1.38169229e-01f, -3.06451172e-01f, 9.82071757e-01f, 2.19254255e-01f, -4.34249759e-01f, -1.25181470e-02f,
  -1.02333508e-01f, 5.96267760e-01f, -2.23871484e-01f, 2.55612403e-01f, -3.83928493e-02f, 3.08256317e-02f, 5.76213062e-01f, -4.76702720e-01f, -2.96178877e-01f, -4.48314756e-01f,
  -1.29497238e-02f, -7.09766597e-02f, 6.96202815e-01f, 9.91095066e-01f, 1.02383792e-01f, 4.57343310e-01f, 3.51354301e-01f, 7.36605823e-01f, -4.89589684e-02f, -1.39069408e-01f,
  -2.64856845e-01f, 6.79424524e-01f, 9.03559998e-02f, 7.42613256e-01f, 1.97731704e-01f, -4.61936563e-01f, 2.67640650e-01f, -5.07939637e-01f, 3.43837216e-02f, 1.42267682e-02f,
  6.91661358e-01f, 4.98018742e-01f, 1.56003550e-01f, -2.22907662e-01f, 7.73422360e-01f, 2.58423597e-01f, 1.15675581e+00f, -2.48838112e-01f, -2.40782455e-01f, 8.38429108e-02f,
  -2.76987672e-01f, -1.07354864e-01f, 4.38446105e-02f, 2.65629619e-01f, -1.60083145e-01f, 3.51295441e-01f, -1.39229551e-01f, -2.23242968e-01f, -2.03201532e-01f, -2.02357218e-01f,
  -1.22742243e-01f, -6.18018582e-02f, 4.92505506e-02f, 2.09273949e-01f, -2.02094257e-01f, 5.11178255e-01f, 3.43101531e-01f, 7.79292047e-01f, 7.66781688e-01f, 3.52174670e-01f,
  5.35655975e-01f, -4.39562470e-01f, 2.94969380e-01f, -2.57530004e-01f, 3.76884907e-01f, 2.18322158e-01f, -3.74662429e-01f, -2.70947158e-01f, -4.29531217e-01f, 3.15820634e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  5.65581501e-01f, 3.16661894e-01f, 5.49443603e-01f, 4.76440638e-01f, 7.19170347e-02f, 4.29589525e-02f, 9.08719972e-02f, 2.11602040e-02f, -1.08208306e-01f, 2.43256196e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  9.55419913e-02f, 9.63749960e-02f, -2.44151101e-01f, -3.82072777e-01f, 2.92996794e-01f, 1.48191780e-01f, -7.13753760e-01f, -6.60841942e-01f, 7.21128523e-01f, -4.01735276e-01f,
  5.97019732e-01f, -1.78974375e-01f, 7.98883557e-01f, 1.12275079e-01f, 1.72577016e-02f, -3.81200045e-01f, -1.97039232e-01f, -8.23841095e-01f, -5.15729129e-01f, 5.65704167e-01f,
  -1.96449272e-02f, -3.06602627e-01f, -7.52902508e-01f, 3.96347731e-01f, 5.34831941e-01f, -1.15480281e-01f, -2.75906652e-01f, 3.19538116e-01f, 8.52165163e-01f, -7.16181278e-01f,
  6.12497851e-02f, -4.65895236e-02f, 4.42217201e-01f, -4.56562608e-01f, 7.53935993e-01f, 2.82826006e-01f, -9.58748043e-01f, 2.24475473e-01f, -6.32541895e-01f, 6.13188418e-03f,
  -1.23688377e-01f, 1.18928504e+00f, -4.30231392e-01f, 4.35409755e-01f, -3.36897135e-01f, -4.10268635e-01f, -3.11636537e-01f, -3.14813972e-01f, 2.37524793e-01f, -5.91181695e-01f,
  1.58025033e-03f, 3.69196013e-02f, 1.14858150e+00f, 1.60272494e-01f, -1.02249414e-01f, -5.85378528e-01f, -2.35358998e-01f, -1.60430565e-01f, 4.19265062e-01f, -2.82444656e-01f,
  -4.79886681e-01f, 1.09442914e+00f, 7.43554458e-02f, -4.94843394e-01f, -3.65469873e-01f, 3.70783001e-01f, 7.20898211e-01f, -1.35591376e+00f, 7.94434667e-01f, 1.06179915e-01f,
  5.85127294e-01f, -3.84726971e-01f, 4.75456089e-01f, -2.72619724e-02f, 9.58909810e-01f, -5.68732396e-02f, -1.35906309e-01f, 7.24015310e-02f, 1.46654114e-01f, -3.19328070e-01f,
  -1.14276014e-01f, -4.35490459e-01f, -1.05273807e+00f, 4.55586612e-02f, -2.86321074e-01f, -1.99534506e-01f, 4.16746587e-01f, 9.38920602e-02f, 7.09806144e-01f, -2.97800303e-01f,
  3.88918608e-01f, -6.58057451e-01f, 1.60479516e-01f, -1.16141468e-01f, 1.81892082e-01f, 4.25900578e-01f, 1.04107666e+00f, -5.58306873e-01f, 3.86994451e-01f, 1.27963975e-01f,
  -8.03508639e-01f, -1.02846563e+00f, 3.99435684e-02f, -1.65697038e-01f, 8.75978529e-01f, 1.68509841e-01f, -7.34036684e-01f, -2.47590497e-01f, -7.37584233e-01f, -2.94984877e-01f,
  1.29105404e-01f, 1.02577925e+00f, -6.49132490e-01f, -2.00205714e-01f, -5.39123833e-01f, -5.98399103e-01f, 8.30977976e-01f, 1.54541016e-01f, 6.27174497e-01f, 4.72094715e-01f,
  -9.50645208e-01f, -1.63080506e-02f, -1.08414456e-01f, 3.49854439e-01f, 5.94314694e-01f, 3.06616873e-02f, 1.38466135e-02f, -1.40487507e-01f, 5.98053634e-01f, 1.21194863e+00f,
  7.09569871e-01f, 1.26764250e+00f, 6.70057833e-01f, 9.40332830e-01f, -2.67820269e-01f, -9.20649767e-02f, -6.96654737e-01f, 1.78578347e-01f, -2.77351081e-01f, -3.46907973e-01f,
  7.41957963e-01f, -7.39066482e-01f, 3.05527866e-01f, -2.49426633e-01f, -4.67179716e-01f, 1.76431209e-01f, 1.71019673e-01f, -1.14011204e+00f, -2.34327212e-01f, 1.42451376e-01f,
  1.80316925e-01f, 9.02756602e-02f, 1.78995300e-02f, 2.25282848e-01f, -3.32508832e-01f, 8.35672915e-01f, 1.89231965e-03f, -4.43341792e-01f, -1.82261676e-01f, 9.12790358e-01f,
  -2.95092285e-01f, 5.69990933e-01f, 4.87373799e-01f, 8.53518307e-01f, -6.33143127e-01f, 6.35313570e-01f, -3.06258112e-01f, 2.59995341e-01f, -4.54417169e-01f, 2.20056236e-01f,
  -5.46949506e-01f, -6.67545050e-02f, -4.65389460e-01f, 9.85044062e-01f, -1.35045677e-01f, -3.61256331e-01f, -3.91741335e-01f, 1.96857661e-01f, -8.20394039e-01f, 3.85338455e-01f,
  -7.63372898e-01f, -1.09674406e+00f, 9.00792420e-01f, -3.98962528e-01f, -4.36604261e-01f, -6.33403137e-02f, 3.78306687e-01f, -4.94687468e-01f, -6.26182556e-01f, 5.02243876e-01f,
  -8.96116197e-02f, -2.73222566e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.11205781e-01f, -5.13127148e-01f, 1.75231323e-01f, -2.92913496e-01f, 2.22184569e-01f, -1.34386972e-01f, 2.10182190e-01f, -1.40496552e-01f, 9.06349123e-01f, -3.13665628e-01f,
  2.23835111e-01f, 2.07137287e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    