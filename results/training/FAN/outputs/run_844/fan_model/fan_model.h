/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.73132592e-02f, -5.11717260e-01f, -6.66959211e-02f, -3.28178518e-02f, -2.00166944e-02f, 9.91333202e-02f, -2.87720829e-01f, 1.43868169e-02f, 8.77858698e-02f, -2.50666797e-01f,
  -1.58212051e-01f, 1.93738863e-01f, 2.85685241e-01f, 3.00799131e-01f, 2.06408411e-01f, -1.17333904e-01f, -9.73941609e-02f, 2.14039847e-01f, 4.50999260e-01f, 1.01723813e-01f,
  1.28412731e-02f, -4.07443792e-02f, -2.14391034e-02f, 1.28228456e-01f, -2.01323971e-01f, 1.93904355e-01f, -1.00381948e-01f, -1.55894026e-01f, -1.24856517e-01f, -5.19394696e-01f,
  -2.49080464e-01f, -3.00264299e-01f, 2.31643736e-01f, 3.34937163e-02f, -8.20169449e-02f, 4.92377691e-02f, 1.71574187e-02f, 4.35581058e-02f, 4.99086939e-02f, -2.95608230e-02f,
  -5.28050736e-02f, 4.60497988e-03f, -3.21961641e-02f, 1.27632264e-03f, -1.11206964e-01f, -2.41440963e-02f, -1.16622478e-01f, 2.99326647e-02f, -1.69032887e-02f, -1.36446238e-01f,
  -1.27558529e-01f, -1.92414135e-01f, -1.33285180e-01f, 6.47914484e-02f, 6.05575554e-02f, 1.61025152e-01f, -1.08768903e-01f, -1.35587171e-01f, -9.42103192e-03f, -8.39054808e-02f,
  -2.46631037e-02f, 2.58403439e-02f, -4.74169441e-02f, -2.42062397e-02f, 3.39870043e-02f, 8.15882627e-03f, -6.66789617e-03f, 3.87949962e-03f, 4.36081477e-02f, -2.25687120e-02f,
  -2.11526863e-02f, 2.86785699e-03f, 2.50343718e-02f, -2.17778664e-02f, 6.92053884e-02f, 6.18844293e-03f, -9.35782678e-03f, -7.34205544e-03f, 2.30073538e-02f, -1.88413281e-02f,
  1.40510695e-02f, -6.91547766e-02f, -8.20135996e-02f, 5.37555143e-02f, -5.19972593e-02f, 5.32173030e-02f, 1.72938425e-02f, 1.17847407e-02f, 4.45574522e-02f, -2.48106960e-02f,
  -1.30568387e-03f, 1.83390617e-01f, -5.25018480e-03f, -2.94098780e-02f, 3.45521010e-02f, 4.49326970e-02f, -4.01944555e-02f, 1.82733766e-03f, -3.14494073e-02f, -3.53769697e-02f,
  -3.58530246e-02f, 2.32824590e-02f, -3.22558805e-02f, -1.18172161e-01f, 7.51848966e-02f, 8.05656239e-02f, -1.84491575e-02f, 9.04282928e-02f, 2.88109351e-02f, -1.12360619e-01f,
  -3.15794833e-02f, 1.15208216e-01f, 1.90381959e-01f, 6.47527203e-02f, 1.66278856e-03f, 1.68682456e-01f, 6.27862141e-02f, 1.79255530e-02f, 2.83496499e-01f, 1.53453276e-01f,
  -7.44691491e-01f, 2.33564019e-01f, 5.09896800e-02f, -2.56493837e-01f, -8.03974047e-02f, 1.16215602e-01f, 9.43801776e-02f, 7.35858679e-02f, 2.25856435e-02f, -3.11082322e-02f,
  -8.29969794e-02f, -9.30236876e-02f, -1.85148627e-01f, 3.27921547e-02f, -2.92347614e-02f, -4.33276128e-03f, -9.95171443e-02f, -1.63301557e-01f, -8.81731436e-02f, 6.88897073e-03f,
  1.38791576e-01f, 4.44034551e-04f, -1.43778577e-01f, 3.61071825e-02f, -9.93953943e-02f, 1.20215677e-01f, -4.77376534e-03f, -8.40727165e-02f, 7.00250864e-02f, -2.97766954e-01f,
  -2.93785691e-01f, -1.81610622e-02f, -2.72413380e-02f, 3.49031352e-02f, -3.76293110e-03f, 1.70077402e-02f, -3.31022590e-02f, -2.12961715e-02f, 1.25424536e-02f, -1.43085159e-02f,
  -4.54815850e-02f, 4.47320789e-02f, -1.98391918e-02f, 7.79724196e-02f, -5.62882647e-02f, -5.15479175e-03f, 3.96865159e-02f, 9.27823782e-03f, -2.79770065e-02f, 3.23466435e-02f,
  2.56223418e-02f, -4.50227633e-02f, -3.12045496e-02f, 7.70571455e-02f, 2.15806309e-02f, -9.55098495e-02f, 7.97839314e-02f, 1.21380659e-02f, 1.20356262e-01f, 6.89194947e-02f,
  -1.18712848e-02f, -2.38058865e-02f, -1.81064084e-02f, 1.37463612e-02f, -7.94771165e-02f, 2.19963677e-02f, -5.86579815e-02f, -4.46002111e-02f, 4.99490127e-02f, 3.68359662e-03f,
  1.36557203e-02f, -4.27077413e-02f, 5.31910360e-02f, 1.88574125e-03f, -5.82154356e-02f, -1.92689095e-02f, -3.78406346e-02f, -6.78644925e-02f, 4.87610251e-02f, -4.45852615e-02f,
  -2.09739152e-02f, 2.13340987e-02f, -8.25395882e-02f, 9.75823626e-02f, 3.93948816e-02f, -2.83340849e-02f, -4.59551103e-02f, 7.31861740e-02f, -2.16924101e-02f, 1.00821943e-03f,
  1.96240330e-03f, 1.35293240e-02f, -9.60362777e-02f, 3.16871883e-04f, 3.11304256e-02f, 9.73954704e-03f, -3.57254297e-02f, 1.27882883e-02f, -4.97022942e-02f, 6.01615272e-02f,
  1.70999374e-02f, 2.74703018e-02f, -2.76747681e-02f, 6.06017262e-02f, 6.63438514e-02f, 2.03707758e-02f, 1.22573273e-02f, -8.94696116e-02f, 6.66347966e-02f, 3.92843261e-02f,
  -2.06360444e-02f, 1.73148680e-02f, -7.08369836e-02f, 3.02892029e-02f, 8.48056283e-03f, -9.92428139e-02f, -1.39199598e-02f, 7.37944990e-02f, -1.08164893e-02f, 1.60237715e-01f,
  3.69150676e-02f, 8.54500309e-02f, 2.36408174e-01f, 1.25705704e-01f, 1.24602526e-01f, 2.29479223e-01f, 3.64464283e-01f, 9.72340852e-02f, -3.09000611e-02f, 8.92562717e-02f,
  -7.16741830e-02f, -1.73056930e-01f, -2.41873711e-01f, -1.00694738e-01f, -1.12344809e-02f, 1.57912135e-01f, 2.30066627e-01f, 8.04943964e-03f, -5.15533835e-02f, 2.09830716e-01f,
  -2.67846580e-03f, 2.53170393e-02f, -2.43737325e-02f, 3.56264934e-02f, 9.66892168e-02f, -1.17859676e-01f, 5.75531609e-02f, -5.61059453e-02f, 3.22734378e-02f, 2.49164745e-01f,
  1.12528227e-01f, 3.52924652e-02f, -7.51802549e-02f, -1.13490343e-01f, -6.22251071e-02f, -5.12531511e-02f, -3.28370812e-03f, -9.71043389e-03f, -1.36251226e-01f, 1.98738724e-02f,
  -8.94188955e-02f, -1.23750428e-02f, -1.09087773e-01f, -8.92751813e-02f, 2.75037996e-02f, 1.26095131e-01f, -7.87231401e-02f, -5.66636678e-03f, -4.35418673e-02f, 6.46932125e-02f,
  7.55813494e-02f, 2.18065921e-02f, 3.36098000e-02f, 1.35182459e-02f, 8.49848762e-02f, -8.21782649e-02f, 7.12917224e-02f, 7.43013844e-02f, 5.12271710e-02f, 1.54005855e-01f,
  9.78000183e-03f, -1.32704861e-02f, -6.29746243e-02f, 2.18313374e-02f, -1.30523629e-02f, -2.56034080e-02f, 1.46797309e-02f, -1.65688079e-02f, 1.10506201e-02f, 3.93181704e-02f,
  -1.15520217e-01f, 8.67388770e-02f, -4.69143055e-02f, 7.25913271e-02f, 2.67161746e-02f, 3.28949727e-02f, 2.04756074e-02f, 3.73562947e-02f, 4.28520143e-02f, -1.78665370e-02f,
  -1.09880920e-02f, -6.38659149e-02f, 4.37661558e-02f, 5.53648360e-02f, -8.82164482e-03f, 6.88914508e-02f, -1.69086382e-02f, -7.15133920e-02f, -1.51293948e-02f, -1.17152713e-01f,
  -2.00710624e-01f, -1.34272426e-01f, 3.26068178e-02f, 2.25764103e-02f, 1.02460959e-04f, 4.09665518e-02f, -8.80790781e-03f, 3.09006171e-03f, 5.37767494e-03f, 5.12221679e-02f,
  6.98583797e-02f, -1.72445253e-02f, -2.72652134e-02f, -3.11399996e-02f, 9.16576833e-02f, 7.62768313e-02f, 6.50686398e-02f, -7.45469006e-03f, 2.87674107e-02f, 1.48497432e-01f,
  6.29393756e-02f, 5.27617428e-03f, -7.23941624e-02f, 5.67208678e-02f, -4.12182063e-02f, -7.17509910e-02f, 1.35514466e-02f, 9.13276449e-02f, -6.34379983e-02f, -5.24352156e-02f,
  1.09190546e-01f, -2.44876415e-01f, -3.44677657e-01f, 1.64164742e-03f, -2.65155345e-01f, -3.29296947e-01f, -3.66739124e-01f, -9.28758383e-02f, 8.35536644e-02f, -1.99090615e-01f,
  -2.41263986e-01f, -3.38305272e-02f, -3.99515256e-02f, 8.80842190e-03f, -1.24700911e-01f, -2.00156197e-01f, -4.28395383e-02f, -1.77145693e-02f, 5.24676219e-02f, -7.19609931e-02f,
  4.56109680e-02f, 9.20665339e-02f, 1.05214193e-01f, 1.79719582e-01f, -3.66653502e-02f, -1.77997556e-02f, -1.00377843e-01f, -1.58235505e-01f, -1.85541436e-01f, 6.83767572e-02f,
  -5.25372684e-01f, -6.30373284e-02f, 8.56342241e-02f, 3.20416689e-02f, -1.29751489e-01f, 5.69741726e-02f, -7.27798045e-02f, 6.05174303e-02f, 3.06233708e-02f, 4.67927661e-03f,
  -2.84312349e-02f, 1.03801452e-01f, 7.55664334e-02f, 4.32657152e-02f, -3.78191285e-02f, 5.19151092e-02f, 1.49169296e-01f, 6.87165111e-02f, -2.71700695e-02f, 1.38521800e-02f,
  -5.92179149e-02f, 7.96172544e-02f, -3.83247668e-03f, -2.58780066e-02f, 2.10963693e-02f, 3.66651863e-02f, -1.16648652e-01f, 3.09240445e-02f, -3.49874832e-02f, -7.90458769e-02f,
  -2.80031245e-02f, -6.74193203e-02f, -1.74897350e-02f, 1.59631707e-02f, 1.28595177e-02f, -3.94614637e-02f, 3.43808196e-02f, -3.57391872e-02f, 5.86768463e-02f, 5.32734543e-02f,
  2.03528050e-02f, -5.80559745e-02f, 2.78573893e-02f, -1.25352591e-02f, 2.45269611e-02f, -3.80884297e-02f, 4.69599254e-02f, -3.03152539e-02f, 4.11737785e-02f, 7.76741952e-02f,
  7.88430944e-02f, 5.04820123e-02f, -7.11350096e-03f, 4.78796586e-02f, -7.45806471e-02f, -1.91604253e-02f, 2.66770441e-02f, -2.75571980e-02f, -6.42190501e-02f, 7.88486227e-02f,
  -3.61469127e-02f, 1.11582391e-02f, -7.84594342e-02f, 5.61803691e-02f, 4.10415195e-02f, 5.35407476e-02f, -2.08597276e-02f, 9.64596048e-02f, 8.00638869e-02f, -6.17942810e-02f,
  3.93581204e-02f, -1.31855824e-03f, -3.00367512e-02f, 3.18186320e-02f, -4.08221260e-02f, 9.07077342e-02f, -3.81462164e-02f, -2.22725552e-02f, 1.22325018e-01f, 1.10555487e-02f,
  4.04235609e-02f, 3.38790976e-02f, -1.00177579e-01f, 5.85963279e-02f, 9.65569727e-03f, -2.49367431e-02f, -2.83275396e-02f, -2.82816626e-02f, -1.12476777e-02f, -8.92386809e-02f,
  -6.37709498e-01f, 1.48917541e-01f, -2.78888851e-01f, 9.09472033e-02f, 2.29704484e-01f, -2.41405498e-02f, -6.26557767e-02f, 3.38124707e-02f, 1.77449107e-01f, 2.44593490e-02f,
  2.69495666e-01f, 2.23353744e-01f, 5.61066382e-02f, 4.76438589e-02f, -2.51088977e-01f, -7.55466148e-02f, -1.58197105e-01f, -3.59754562e-01f, -9.23695341e-02f, 1.65200844e-01f,
  1.96035281e-01f, -3.48194242e-02f, -2.22797886e-01f, 7.41058066e-02f, 6.70265183e-02f, 2.64198452e-01f, 2.18175966e-02f, -2.96967179e-02f, 8.41943771e-02f, -9.32459068e-03f,
  -1.05469488e-01f, -1.25214055e-01f, 5.25949895e-02f, 4.91228551e-02f, 9.01951641e-02f, -7.05633983e-02f, 1.27944918e-02f, -8.61726925e-02f, 3.67821269e-02f, 2.32150238e-02f,
  1.10999644e-02f, 3.01794112e-02f, -3.86483334e-02f, 1.60111077e-02f, -1.13616168e-01f, 4.02814373e-02f, -7.01415539e-03f, -1.78258583e-01f, -1.65162653e-01f, 2.66048256e-02f,
  1.80778027e-01f, 3.70652303e-02f, -2.41227612e-01f, 1.23159878e-03f, -3.08070201e-02f, -1.18485652e-02f, 9.11802426e-02f, -8.38545933e-02f, -1.79119781e-02f, 2.35689175e-03f,
  8.09099972e-02f, -8.34031031e-03f, -3.26922350e-02f, 1.10028416e-03f, 3.13177444e-02f, -3.00731398e-02f, -2.35180501e-02f, -7.37433461e-03f, -2.65445001e-02f, -3.31438370e-02f,
  2.94917580e-02f, 9.60030407e-03f, -2.78902017e-02f, -2.54789442e-02f, 8.98833200e-02f, -6.68293657e-03f, -2.79453211e-02f, 2.20914036e-02f, 1.26840211e-02f, -7.55616948e-02f,
  3.16347443e-02f, -5.65793067e-02f, 8.38446468e-02f, 2.02538688e-02f, -3.34091298e-02f, 1.27243418e-02f, -4.45636474e-02f, 2.93876156e-02f, 5.31417988e-02f, -1.95729248e-02f,
  6.50246516e-02f, -8.50069597e-02f, -7.71156559e-03f, -3.24103562e-03f, -4.15575467e-02f, 8.12456533e-02f, -1.68415289e-02f, 3.20556425e-02f, 6.06667474e-02f, -3.72701362e-02f,
  3.15386727e-02f, -5.64606152e-02f, 5.04377037e-02f, -1.26757743e-02f, 2.34630406e-02f, -4.03584167e-03f, 1.15165584e-01f, -2.44831778e-02f, 2.20616870e-02f, 4.81200069e-02f,
  5.13562635e-02f, -3.36396322e-02f, -4.03618366e-02f, -6.29050061e-02f, 3.78714800e-02f, -1.55015737e-02f, -8.93961340e-02f, -3.77957486e-02f, -1.38876751e-01f, 6.10917956e-02f,
  -4.32381362e-01f, 1.55546620e-01f, 7.09352046e-02f, -2.84250323e-02f, -2.37202659e-01f, -3.02939594e-01f, -3.83772343e-01f, -2.05644593e-01f, -2.47992128e-02f, 1.05251744e-01f,
  -1.10861823e-01f, 7.84148872e-02f, 1.54012203e-01f, 1.43559054e-01f, 7.06009625e-04f, 4.77004386e-02f, 3.44947547e-01f, 9.82563868e-02f, -2.82994211e-01f, -2.55319148e-01f,
  5.78484461e-02f, 4.08789665e-02f, 1.48616789e-03f, -1.24113142e-01f, 1.66749984e-01f, -5.16302735e-02f, 8.37087408e-02f, 5.11211231e-02f, 2.90017053e-02f, 5.80512524e-01f,
  -9.48426500e-02f, -1.24823004e-01f, 5.53905591e-02f, 8.01073164e-02f, 4.25715111e-02f, 5.97332828e-02f, 1.21858604e-02f, 1.33993566e-01f, 4.16242145e-02f, 1.02582730e-01f,
  -6.58334196e-02f, 7.44070560e-02f, 7.51993582e-02f, 1.94706880e-02f, -7.47608170e-02f, 1.50843840e-02f, 1.26627877e-01f, 5.06617650e-02f, 6.54159347e-03f, -4.45820838e-02f,
  1.57251041e-02f, -7.34432042e-02f, -2.05686361e-01f, 6.94843158e-02f, 3.04216556e-02f, -1.48846498e-02f, -1.11614473e-01f, -7.08203530e-03f, 8.19169059e-02f, 2.58475780e-01f,
  -1.18173128e-02f, 5.66837192e-02f, -6.13121258e-04f, -7.03160539e-02f, -1.23156579e-02f, -1.88490644e-03f, 6.69154990e-03f, -1.17016668e-02f, 6.17580581e-03f, 2.66108215e-02f,
  3.98064554e-02f, -6.53039515e-02f, -5.05545875e-03f, 2.32787356e-02f, 4.25839201e-02f, -3.90446302e-03f, -3.88714522e-02f, -2.35058349e-02f, 1.77471153e-02f, -2.41693649e-02f,
  -1.44920899e-02f, 8.74243584e-03f, 5.75860264e-03f, 2.80578472e-02f, -1.37291588e-02f, -3.50970998e-02f, 4.26913798e-02f, -1.31101636e-02f, 3.82029787e-02f, -1.09367492e-02f,
  -1.14866830e-01f, 3.85489091e-02f, -1.44760460e-02f, 2.68262215e-02f, -4.33580242e-02f, 2.39408854e-02f, -4.14689668e-02f, 5.46493335e-03f, 2.52648108e-02f, -6.98030740e-02f,
  -8.90335143e-02f, -1.18573764e-02f, -1.97261833e-02f, 1.53962392e-02f, 4.09848653e-02f, -2.24792492e-02f, 2.29282733e-02f, -5.24262153e-02f, 1.79195255e-02f, -8.64573121e-02f,
  8.74483138e-02f, -9.39742774e-02f, -1.30348176e-01f, -1.43143907e-02f, -1.23721503e-01f, -1.14073597e-01f, -1.53576732e-01f, -1.66019827e-01f, -2.17242092e-01f, -1.02313831e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.96238667e-01f, 8.12896267e-02f, 3.93775441e-02f, 7.53273368e-02f, -1.34517979e-02f, -1.06184378e-01f, -2.27804527e-01f, -1.14167146e-01f, 2.10495163e-02f, 5.74269854e-02f,
  6.00998886e-02f, -8.94238707e-04f, -8.55572969e-02f, -9.35436115e-02f, -2.73280218e-02f, 2.77477154e-03f, -1.44101456e-01f, -8.58893320e-02f, -7.17463940e-02f, -6.43982217e-02f,
  -2.01943144e-02f, 9.72567797e-02f, 2.48018913e-02f, 1.08584138e-02f, 1.64757699e-01f, -5.32735884e-02f, 4.20259796e-02f, 1.07783459e-01f, -1.96735514e-03f, 2.52233982e-01f,
  2.19621196e-01f, 1.87073722e-01f, -8.43734443e-02f, 2.92565767e-02f, 8.34351778e-02f, -5.39256930e-02f, 6.15148060e-03f, 7.49625033e-03f, -5.86671457e-02f, -1.47371385e-02f,
  9.25586000e-02f, -6.22852519e-02f, -8.56870562e-02f, 5.72506972e-02f, -2.00547595e-02f, 1.23537323e-02f, -7.21603334e-02f, -5.18717170e-02f, -5.20937257e-02f, 7.00812712e-02f,
  -6.65050820e-02f, 6.91241622e-02f, 1.12978183e-01f, -1.26749456e-01f, -3.03494688e-02f, 4.88252714e-02f, 6.43230379e-02f, 4.80250902e-02f, -1.33997127e-02f, 1.07177451e-01f,
  1.44154374e-02f, -3.45630571e-02f, 2.96982899e-02f, 2.02548727e-02f, -2.91797835e-02f, 2.46978402e-02f, -5.08252420e-02f, 3.84032764e-02f, -2.56607123e-02f, -3.05206981e-02f,
  -6.51850849e-02f, -6.24231212e-02f, 4.65425923e-02f, -3.07545718e-02f, -1.90152973e-02f, 8.07999750e-04f, -2.26360317e-02f, -9.20098275e-03f, -6.18741056e-03f, 4.89289388e-02f,
  5.98311424e-02f, -1.74960159e-02f, 4.68001813e-02f, 3.15318145e-02f, 6.77812621e-02f, 1.40388142e-02f, -4.92296629e-02f, 2.24568602e-02f, -3.13505009e-02f, -2.18127761e-02f,
  -9.28402543e-02f, -2.62418687e-01f, -5.57771465e-03f, -1.54657140e-02f, -3.26319039e-03f, 3.32024693e-02f, 3.92218977e-02f, -5.47598749e-02f, 1.10239973e-02f, -2.74143424e-02f,
  -2.46898830e-02f, 6.98833540e-03f, -1.89230626e-03f, -3.69187593e-02f, -5.53328954e-02f, 7.73398811e-03f, -6.97189569e-02f, -8.32977891e-02f, -1.20639838e-01f, -8.04887190e-02f,
  -1.26125649e-01f, -1.65407673e-01f, -1.18394069e-01f, -6.96607754e-02f, -5.68816671e-04f, -6.70155231e-03f, -1.03394128e-01f, 3.08054276e-02f, -5.31100072e-02f, -1.30508736e-01f,
  -6.14702590e-02f, -8.50778818e-02f, 1.17836241e-02f, 3.95355038e-02f, 1.72706172e-01f, 4.28592078e-02f, 1.86916530e-01f, 1.14448778e-01f, 1.31593466e-01f, -2.04726513e-02f,
  -5.36138602e-02f, -1.33748800e-01f, -2.21454613e-02f, -1.33271283e-03f, -6.71711713e-02f, 1.76081702e-01f, 7.60835111e-02f, 1.47024855e-01f, 7.71892443e-02f, 2.92518605e-02f,
  9.87144634e-02f, -3.95308137e-02f, -3.48777883e-02f, 5.69650717e-02f, -2.87215281e-02f, -6.08896650e-02f, 4.83891591e-02f, -1.48864929e-02f, 2.31732391e-02f, 2.85019614e-02f,
  -9.95225608e-02f, -2.35120188e-02f, 1.31813779e-01f, -6.49565905e-02f, -1.12825697e-02f, -5.76110780e-02f, 4.11744192e-02f, 1.00023011e-02f, -6.21399544e-02f, 1.68077066e-03f,
  -1.77264016e-03f, -2.79155895e-02f, -6.35516420e-02f, 1.59511110e-03f, -2.42721047e-02f, 4.71564084e-02f, -9.34228534e-04f, -8.79587755e-02f, -9.79947522e-02f, -1.55591946e-02f,
  -1.00724436e-01f, -1.06436662e-01f, -6.46657050e-02f, 1.19169326e-02f, -9.38748270e-02f, 2.63174679e-02f, 7.25343218e-03f, 1.84426606e-02f, 2.41090283e-02f, 3.75009142e-02f,
  2.61981087e-03f, 6.66206330e-02f, -7.56098656e-03f, -3.27173509e-02f, -4.69493717e-02f, -4.10727784e-02f, 1.05429925e-01f, -2.34815478e-02f, -3.92928831e-02f, -2.03465670e-02f,
  -3.49455439e-02f, 2.42891745e-03f, -1.46391159e-02f, -5.37157953e-02f, 6.31039962e-02f, 3.56207602e-02f, -3.93171944e-02f, -4.60868031e-02f, 1.61216762e-02f, -5.13785258e-02f,
  7.72934034e-02f, -5.51548414e-02f, -8.98320898e-02f, 7.90413395e-02f, 5.64782694e-02f, 8.85495543e-02f, 4.24936116e-02f, 2.92140455e-03f, -4.87591326e-02f, -8.33351761e-02f,
  -3.66189294e-02f, -7.97027051e-02f, 4.80352752e-02f, -5.32378629e-02f, 5.08778989e-02f, -3.86400409e-02f, -9.07607675e-02f, 6.13972219e-03f, -2.55831964e-02f, -5.88552877e-02f,
  -1.16122030e-01f, 6.61987113e-03f, -1.57924537e-02f, 2.75693424e-02f, -2.29464546e-02f, 7.07343966e-02f, -2.51807123e-02f, 3.19056921e-02f, 4.46567237e-02f, -8.54219571e-02f,
  -9.02353879e-03f, 8.82320926e-02f, 1.00951724e-01f, -2.24512182e-02f, 6.66127428e-02f, -1.26926191e-02f, 4.46524061e-02f, -1.67337086e-04f, -7.01405182e-02f, -1.39147472e-02f,
  -1.32338315e-01f, 1.80214271e-02f, 1.63109228e-02f, -7.29770288e-02f, -1.31053207e-02f, 1.01409033e-01f, 5.69934808e-02f, -5.48685044e-02f, 4.92764227e-02f, 2.78412458e-03f,
  -1.36099443e-01f, -1.09622397e-01f, -9.18595716e-02f, -5.05501628e-02f, -7.64181092e-02f, 4.63793091e-02f, 8.15004930e-02f, -1.03151038e-01f, -7.78432786e-02f, 1.07589841e-01f,
  -3.44938338e-02f, -1.12758100e-01f, -8.71360227e-02f, -7.93594718e-02f, -1.10867031e-01f, -4.97598425e-02f, 1.78754218e-02f, -5.21265902e-02f, -1.37968004e-01f, -1.23541690e-01f,
  1.88064829e-01f, -2.15278104e-01f, 9.42585710e-03f, -1.07199207e-01f, -2.38915030e-02f, -1.57491155e-02f, 4.90231533e-03f, 4.99175973e-02f, 1.04146905e-01f, -1.71607099e-02f,
  -5.34636453e-02f, 1.23468218e-02f, -1.05864750e-02f, -6.50090650e-02f, 1.32707767e-02f, 1.37759838e-02f, 1.73854548e-02f, -5.63367382e-02f, -1.03134677e-01f, -9.42005143e-02f,
  -8.02795812e-02f, 2.37574503e-02f, 1.04227938e-01f, 1.56765382e-04f, 2.12756302e-02f, -8.44414607e-02f, 7.48042241e-02f, -3.68089005e-02f, -2.34387200e-02f, 1.73109606e-01f,
  8.77890289e-02f, 8.10187869e-03f, -1.00019231e-01f, 3.97625752e-02f, -6.22288138e-02f, 1.01006562e-02f, -1.34886606e-02f, 2.81560458e-02f, -7.20760822e-02f, 1.10225640e-01f,
  -5.91152348e-02f, -4.47390787e-02f, 1.25731258e-02f, -4.43550535e-02f, -5.46090072e-04f, -4.85295692e-04f, -3.02325506e-02f, -1.99377835e-02f, -2.07045618e-02f, -1.21169239e-01f,
  -5.08596860e-02f, -8.53750557e-02f, -9.57652107e-02f, 8.70973710e-03f, -1.32465854e-01f, -2.24603452e-02f, -2.61468887e-02f, 6.13914337e-03f, 4.73501086e-02f, -4.64075711e-03f,
  1.65303499e-02f, -2.36945048e-01f, 2.14657392e-02f, -4.37772200e-02f, -1.04535326e-01f, -6.22283742e-02f, -2.57971715e-02f, -9.12140086e-02f, -1.00835629e-01f, 4.12704125e-02f,
  -6.69088811e-02f, -2.42782999e-02f, -8.48354846e-02f, -1.03018330e-02f, 1.30172923e-01f, 3.90556902e-02f, -5.22607118e-02f, 4.42035757e-02f, -8.88242796e-02f, -9.24209952e-02f,
  2.60622962e-03f, 1.89292058e-01f, 2.27257475e-01f, 8.85429159e-02f, 3.59135419e-02f, 1.19365841e-01f, 2.14195818e-01f, 7.66803026e-02f, 8.69469568e-02f, 3.95674199e-01f,
  -1.85910583e-01f, -1.79507554e-01f, -4.38966341e-02f, 1.00227162e-01f, 2.75670886e-01f, 1.46854088e-01f, 1.76884592e-01f, 1.85391545e-01f, 1.86318234e-01f, 8.40031803e-02f,
  -1.47034436e-01f, -3.26594636e-02f, 1.08089395e-01f, -7.67495576e-03f, 1.28619686e-01f, 1.58732817e-01f, 2.46240854e-01f, 2.69637275e-02f, -1.24912346e-02f, 1.16537102e-01f,
  1.08818427e-01f, -6.05144016e-02f, -1.30403653e-01f, -2.45980695e-02f, 1.35716677e-01f, 1.35113284e-01f, 1.79148675e-03f, -8.37755725e-02f, 5.09077311e-03f, 1.37877285e-01f,
  -2.02875629e-01f, -2.01387748e-01f, 8.92161056e-02f, -4.22221459e-02f, -1.23215586e-01f, -1.24414451e-01f, 6.28789945e-04f, -1.27437502e-01f, -5.58274053e-02f, -7.94921070e-02f,
  -9.98893902e-02f, -6.87102005e-02f, -2.03306712e-02f, -1.02729931e-01f, -3.39279696e-02f, 1.14047537e-02f, -2.46330001e-03f, -3.52601856e-02f, 7.42505044e-02f, -3.01549793e-03f,
  6.74373880e-02f, 9.64742079e-02f, -1.04318731e-01f, 8.99292808e-03f, 1.20630395e-02f, 9.67093930e-02f, 3.71942222e-02f, 1.27601251e-02f, -5.83938062e-02f, -5.76478392e-02f,
  -5.41556627e-02f, -7.85016343e-02f, -1.69888251e-02f, -4.44129705e-02f, 3.04452088e-02f, 5.26708141e-02f, -5.77283800e-02f, 4.24838588e-02f, 7.46511221e-02f, 5.15467450e-02f,
  6.37664422e-02f, -2.54686400e-02f, 1.21630140e-01f, 7.50013888e-02f, -4.90665734e-02f, -3.35783325e-02f, -7.84787256e-03f, -7.63299549e-03f, -2.96437610e-02f, -3.21768261e-02f,
  3.46696414e-02f, 6.36774674e-02f, -4.85441387e-02f, -5.65142778e-04f, 4.11641300e-02f, 5.43563068e-02f, 2.88692974e-02f, -7.84684196e-02f, 4.83506499e-03f, 1.79304425e-02f,
  -3.88514553e-03f, -7.65849799e-02f, 1.03812851e-01f, 8.13606530e-02f, -6.05538487e-02f, -5.97250089e-02f, 2.25888044e-02f, -9.30781513e-02f, -8.18238556e-02f, -2.59978604e-02f,
  -1.24143399e-01f, -7.95878023e-02f, -9.19113159e-02f, 3.08418218e-02f, 3.86250578e-02f, -7.46313334e-02f, -8.92844051e-03f, 5.90752438e-02f, 1.31480008e-01f, 4.43824381e-02f,
  2.05265777e-03f, 1.66056350e-01f, 1.16467504e-02f, 1.85617864e-01f, 4.12644595e-02f, 1.10061325e-01f, 7.41470838e-03f, 7.80602470e-02f, 5.57727367e-02f, 8.36085877e-04f,
  2.45704837e-02f, 6.42427057e-02f, -8.44305456e-02f, 1.84627753e-02f, 4.10274640e-02f, -6.48777783e-02f, -3.00301425e-03f, 7.68526271e-02f, -2.10824236e-02f, 9.12433192e-02f,
  -4.45696451e-02f, 1.44073397e-01f, -4.28745383e-03f, 1.77051753e-01f, 1.89984664e-01f, 7.75304139e-02f, 1.60615057e-01f, 2.96581127e-02f, -6.85055330e-02f, 1.59324035e-02f,
  -3.84362377e-02f, 7.84690678e-02f, 5.87237962e-02f, 2.42099669e-02f, 2.00284794e-02f, -4.21767915e-03f, 6.04822598e-02f, 4.48958315e-02f, -2.70428192e-02f, 2.33149096e-01f,
  1.13535291e-02f, 7.32471719e-02f, -3.52827311e-02f, -3.50521654e-02f, 8.75851437e-02f, 1.37658238e-01f, 1.39348269e-01f, -6.18395396e-02f, -2.64429096e-02f, -3.64931785e-02f,
  2.27753688e-02f, 1.09415598e-01f, 5.56062385e-02f, -3.41416635e-02f, -2.24940572e-02f, 1.38376476e-02f, -4.21025464e-03f, -6.51837466e-03f, 1.06978901e-01f, 4.01051417e-02f,
  1.73475575e-02f, -1.08388081e-01f, -4.68828063e-03f, -3.55270766e-02f, 9.20140836e-03f, 5.44538163e-02f, 5.92971295e-02f, -4.56686877e-02f, 8.00079107e-02f, 1.14348494e-02f,
  -6.90542981e-02f, -2.02205032e-02f, -7.35519528e-02f, -9.40546952e-03f, -3.01762428e-02f, 4.90409508e-02f, -2.50571454e-03f, 4.46819626e-02f, -7.30734393e-02f, -1.40101705e-02f,
  -4.33811620e-02f, -8.02908465e-03f, -7.44215623e-02f, -1.07816765e-02f, -2.87671294e-02f, 2.94585042e-02f, 3.51909213e-02f, -2.11390704e-02f, -3.98704745e-02f, -4.65193354e-02f,
  -4.60992455e-02f, 8.73744413e-02f, 5.91639578e-02f, 8.90785530e-02f, -5.94602004e-02f, -5.25992289e-02f, 5.17174648e-03f, 3.57591808e-02f, -9.31880902e-03f, -4.83938754e-02f,
  1.04440063e-01f, -7.88774490e-02f, 4.28641438e-02f, 1.72695890e-01f, 3.05894967e-02f, 7.10989162e-02f, 1.99616775e-02f, -3.46008397e-04f, 1.08657807e-01f, 1.19292684e-01f,
  1.13593549e-01f, 7.24393651e-02f, 3.91944945e-02f, -4.95602600e-02f, -7.27728382e-02f, 2.81543210e-02f, 7.05262125e-02f, 1.10796116e-01f, -1.89013616e-03f, -1.60752349e-02f,
  -2.66427435e-02f, -1.01567000e-01f, 7.61717279e-03f, -1.07929811e-01f, -3.70727964e-02f, 3.41136381e-02f, -5.47504835e-02f, 6.20786510e-02f, 1.70961339e-02f, -1.58050328e-01f,
  -1.50112882e-01f, -2.99329124e-02f, 1.79340336e-02f, -2.17268735e-01f, -1.18888080e-01f, 6.37546107e-02f, 5.87029643e-02f, -1.09859779e-01f, -2.35206932e-02f, -6.65045977e-02f,
  7.75229633e-02f, 2.09860578e-02f, 1.10285282e-01f, 4.59152311e-02f, -2.11067088e-02f, 9.94257703e-02f, -6.84525520e-02f, 8.98384452e-02f, 5.47164166e-03f, -2.97939219e-02f,
  -2.45974236e-03f, -3.08636241e-02f, 2.36267671e-02f, 6.08745329e-02f, -6.62056506e-02f, 1.25669882e-01f, -4.28736061e-02f, 3.74508165e-02f, -4.65098815e-03f, -1.10467106e-01f,
  2.65125781e-01f, -2.46864408e-01f, -6.11275434e-02f, -5.98475747e-02f, -4.64040600e-02f, -8.45653713e-02f, 6.25540391e-02f, -4.70629670e-02f, -4.16642688e-02f, 8.64019543e-02f,
  -4.13310627e-04f, -9.29616839e-02f, -3.13300341e-02f, 5.70371561e-02f, -4.51956168e-02f, 9.31231454e-02f, -3.75017780e-03f, 6.17436646e-03f, -4.25467268e-02f, -5.30798845e-02f,
  2.31755767e-02f, -1.70474239e-02f, -1.25738561e-01f, 2.58579571e-02f, 3.20069678e-02f, -1.11908033e-01f, -4.32881061e-03f, -9.46885999e-03f, -6.82309270e-02f, 1.03395887e-01f,
  -1.92884542e-02f, 1.05298888e-02f, 7.90138096e-02f, -7.95368254e-02f, 4.39630374e-02f, 5.28212264e-02f, 9.05931182e-03f, 8.02068710e-02f, 4.44445759e-02f, 5.61514348e-02f,
  6.18153438e-03f, -2.20235549e-02f, -6.13540933e-02f, 6.17293529e-02f, 4.56899479e-02f, -9.00516137e-02f, 1.17403930e-02f, 4.62631136e-02f, 3.24208215e-02f, 1.63515937e-02f,
  1.60218012e-02f, -8.20050389e-02f, 1.96012091e-02f, 1.18210927e-01f, -2.72440668e-02f, -6.22354746e-02f, -8.21844786e-02f, -1.05711874e-02f, -7.11820051e-02f, -1.15039214e-01f,
  2.12494314e-01f, -1.78601965e-01f, 1.35520240e-02f, -4.92306948e-02f, -4.47605401e-02f, -9.22924504e-02f, -4.22575250e-02f, 8.59679729e-02f, -9.17776823e-02f, -2.54820194e-03f,
  -6.05562590e-02f, -1.71995386e-02f, 9.18623358e-02f, 5.11088409e-02f, -1.30772463e-03f, -3.79894525e-02f, -1.54714286e-02f, -7.63372928e-02f, -6.12777546e-02f, 6.45505115e-02f,
  6.29329996e-04f, -4.89824787e-02f, -5.76499701e-02f, 5.65349162e-02f, 3.79007012e-02f, 2.59676259e-02f, 2.14627013e-01f, 3.40135739e-04f, 1.48386300e-01f, 1.94231004e-01f,
  -3.35566476e-02f, 1.83405191e-01f, 2.88376156e-02f, -5.33585809e-02f, -3.42198834e-02f, 9.75267664e-02f, 1.94783777e-01f, 8.51331428e-02f, -2.11857464e-02f, 1.14675343e-01f,
  -4.14668918e-02f, -7.23903105e-02f, 2.88809109e-02f, 5.79722710e-02f, 1.33001029e-01f, 8.49528909e-02f, 1.21517800e-01f, 1.07025668e-01f, 3.10291536e-02f, 7.26817176e-02f,
  1.20098172e-02f, -1.62395346e-03f, -5.31204380e-02f, 8.36089551e-02f, -1.44570582e-02f, -8.16105083e-02f, 6.63989708e-02f, 7.45465606e-02f, -3.59746329e-02f, 7.58673474e-02f,
  8.87048990e-02f, 1.27405733e-01f, -6.76217973e-02f, -4.35835645e-02f, 1.36306500e-02f, -2.51171570e-02f, -7.09863976e-02f, 4.30394858e-02f, -5.29527152e-03f, 8.79110419e-04f,
  -6.82982728e-02f, 6.05042055e-02f, 3.04933023e-02f, 3.72145548e-02f, 7.03517115e-03f, -1.63671523e-02f, 3.35803889e-02f, 8.91177654e-02f, -3.75989713e-02f, 7.35824779e-02f,
  1.06806420e-01f, 4.75998921e-03f, -9.28407628e-03f, 5.00535034e-02f, 1.86086558e-02f, -3.82929631e-02f, 8.47529918e-02f, -5.53237237e-02f, -6.79385737e-02f, 3.86506654e-02f,
  4.59048040e-02f, -2.20959242e-02f, -1.81632005e-02f, -1.43101113e-02f, -4.84611047e-03f, -4.39779796e-02f, -5.10811992e-03f, 1.16097778e-02f, 4.89329658e-02f, 3.40797938e-03f,
  6.63872808e-03f, -2.77479459e-02f, 2.85605360e-02f, -4.27972302e-02f, -9.66932848e-02f, -6.40456080e-02f, 4.66206949e-03f, -5.57572134e-02f, -4.53978889e-02f, 2.12694108e-02f,
  -1.03884535e-02f, 3.72422226e-02f, 2.38097692e-03f, 1.07435383e-01f, 2.54909392e-03f, -3.22521664e-02f, 2.68156230e-02f, -6.87446743e-02f, 3.99690941e-02f, -2.06425041e-02f,
  -1.15290478e-01f, 8.23117699e-03f, 6.12996891e-02f, 1.60938781e-02f, 8.01004991e-02f, 2.28259657e-02f, -7.07799662e-03f, -6.39597923e-02f, 7.35470876e-02f, -7.76149705e-03f,
  1.49521455e-02f, 2.72821356e-02f, -4.47914116e-02f, 5.90959005e-02f, -8.86400044e-02f, -8.32131356e-02f, -2.20819041e-02f, 1.01350717e-01f, 4.33422029e-02f, 6.05265796e-02f,
  -5.26773967e-02f, 1.41851585e-02f, -1.96520016e-02f, 4.09529619e-02f, 6.16698153e-02f, -1.11065425e-01f, -3.99751179e-02f, -6.44441396e-02f, -3.93262021e-02f, -2.30692793e-02f,
  2.36078024e-01f, 1.30770449e-02f, -1.80828348e-01f, 7.90869072e-02f, -2.21812040e-01f, -1.27307028e-01f, -5.45590930e-02f, 1.44128025e-01f, 9.44185555e-02f, -8.77543241e-02f,
  -9.80170295e-02f, 1.94294780e-01f, 1.13597155e-01f, 1.66170791e-01f, 9.92241651e-02f, -1.19495891e-01f, -1.96690008e-01f, -4.46956493e-02f, 6.02037534e-02f, -1.40676489e-02f,
  -2.58943159e-03f, 4.97118570e-03f, 1.99022144e-03f, -6.65248409e-02f, -1.01353757e-01f, -7.71524906e-02f, -1.18772462e-01f, -1.66314378e-01f, -4.89816144e-02f, -1.95658728e-01f,
  1.57906581e-02f, -7.22808540e-02f, -5.52828424e-02f, 7.14925453e-02f, -8.88062716e-02f, 8.04514438e-03f, -1.44818798e-02f, -1.24335915e-01f, -8.30804408e-02f, -7.69556388e-02f,
  -1.00180335e-01f, 7.84176588e-02f, 2.66670864e-02f, -2.69880034e-02f, -2.97458693e-02f, -1.19376900e-02f, -8.45425352e-02f, -7.06220344e-02f, -1.26963379e-02f, -7.60863721e-02f,
  1.61075369e-02f, -2.43725643e-01f, -4.16445173e-02f, -2.76122913e-02f, -1.19438380e-01f, -3.64946537e-02f, -1.24520123e-01f, -1.16050631e-01f, -1.99280590e-01f, -3.33476365e-02f,
  -1.91202220e-02f, 1.59747042e-02f, -5.38440682e-02f, -1.39378291e-02f, 5.49594350e-02f, 1.25557659e-02f, 1.04253460e-02f, -5.42985983e-02f, -5.14834076e-02f, 6.84007779e-02f,
  -2.31010560e-02f, -4.48305719e-02f, -3.14853620e-04f, -1.78597849e-02f, -6.86983392e-02f, -6.11763410e-02f, -1.45329032e-02f, 5.57150431e-02f, 6.85610063e-03f, 4.71961759e-02f,
  2.60297749e-02f, 5.44440746e-02f, 3.39167262e-03f, 3.76384631e-02f, -9.08974037e-02f, 4.20001661e-03f, 6.64364696e-02f, 1.42389275e-02f, 6.75808564e-02f, -9.94707942e-02f,
  1.20962225e-01f, -5.09351753e-02f, 1.12651892e-01f, 1.17295854e-01f, -1.90351512e-02f, 1.74164085e-03f, 3.59164551e-02f, -4.42426726e-02f, 2.92048585e-02f, -1.74015127e-02f,
  5.05291112e-02f, -2.80986894e-02f, -3.35093791e-05f, 4.27847318e-02f, 2.79469229e-02f, -7.36396015e-02f, 7.87763149e-02f, 5.50654493e-02f, 8.79348349e-03f, -1.37622626e-02f,
  8.34243558e-03f, 1.54495677e-02f, 1.27139032e-01f, 1.32357895e-01f, -1.01231650e-01f, 1.67806625e-01f, 7.51090869e-02f, 1.36370346e-01f, 5.45122288e-02f, 2.15272099e-01f,
  -3.43102604e-01f, 1.61617965e-01f, 5.85745052e-02f, -6.69557005e-02f, -1.58738494e-02f, 1.55031472e-01f, 1.18767865e-01f, 1.28539294e-01f, 6.94531202e-03f, 5.73556721e-02f,
  -1.10516036e-02f, 1.19215483e-03f, -4.17593904e-02f, -1.65946204e-02f, 2.34282464e-02f, 1.93887711e-01f, 2.23677859e-01f, -1.12200230e-01f, -1.37244895e-01f, 3.63888741e-02f,
  -5.60408039e-03f, -7.05568865e-02f, -2.13607773e-01f, -1.59012973e-01f, 5.48682772e-02f, -5.95138632e-02f, 6.36669528e-03f, -6.58927336e-02f, 1.73334572e-02f, 3.02491337e-01f,
  1.67622805e-01f, -1.84287027e-01f, -4.37671784e-03f, -1.33464918e-01f, -7.53658414e-02f, 1.87884402e-02f, -4.76032495e-02f, 1.07331667e-02f, -1.02497846e-01f, -7.34897554e-02f,
  -5.85965579e-03f, 6.30141720e-02f, 2.06021070e-02f, 5.18079624e-02f, -6.44097403e-02f, -9.76498798e-02f, -3.37123200e-02f, -5.27687669e-02f, -1.63635567e-01f, 2.03160774e-02f,
  3.91112417e-02f, -3.31310406e-02f, 3.71743995e-03f, -7.45912120e-02f, 1.90494377e-02f, -6.08172156e-02f, 2.63773873e-02f, -6.51988313e-02f, -1.07067883e-01f, 5.23503637e-03f,
  -3.12001836e-02f, -1.03268638e-01f, 2.49295272e-02f, 1.30924303e-02f, 3.44024561e-02f, -7.90683739e-03f, -3.21446173e-02f, 2.39837896e-02f, -4.22637649e-02f, 5.91628440e-03f,
  -2.68767849e-02f, 5.29150199e-03f, -4.50600907e-02f, -7.31861368e-02f, 1.48675861e-02f, -1.19990821e-03f, -3.68136503e-02f, -4.12911214e-02f, -3.49992304e-03f, -5.87997921e-02f,
  -6.38829097e-02f, 1.40586924e-02f, -5.40447719e-02f, 8.53927881e-02f, 5.46769351e-02f, -2.45806528e-03f, -1.63009346e-01f, -1.24297403e-01f, -8.40099230e-02f, 2.48135962e-02f,
  -3.64229120e-02f, -3.33952792e-02f, -9.00966749e-02f, -4.17710952e-02f, -5.39051704e-02f, -5.20708151e-02f, 3.55719328e-02f, -4.13000844e-02f, -2.20709592e-02f, 5.47476262e-02f,
  1.67060867e-02f, -2.66894065e-02f, 7.09778145e-02f, 4.41285372e-02f, -1.00191869e-01f, -5.82324192e-02f, -2.24457849e-02f, 3.22511680e-02f, 3.68540622e-02f, -1.20959871e-01f,
  4.93884236e-02f, 1.78418383e-02f, -7.96471611e-02f, -2.08490063e-04f, -1.02972053e-01f, -4.38614562e-02f, -7.47153610e-02f, -8.69941786e-02f, 2.54642963e-02f, -5.03933914e-02f,
  -4.01751190e-01f, -8.36260151e-03f, -1.40824348e-01f, -3.14852327e-01f, -6.46082759e-02f, -1.16283767e-01f, -5.77489398e-02f, -4.28001620e-02f, -1.54692471e-01f, -1.89227998e-01f,
  7.56340101e-04f, 7.69170448e-02f, -6.32598847e-02f, -3.06618717e-02f, 9.46445577e-03f, -2.06156522e-01f, -2.61047393e-01f, -1.79785281e-01f, 6.12205938e-02f, 1.61109623e-02f,
  -6.33065104e-02f, -5.43730631e-02f, -1.45393685e-01f, -6.36263341e-02f, -3.62310074e-02f, -1.77627131e-02f, -6.46203682e-02f, -1.35583177e-01f, 3.83607969e-02f, 2.68100714e-03f,
  2.30648786e-01f, 6.82278350e-02f, 7.91136771e-02f, -8.08469728e-02f, 1.38972849e-02f, -1.44064368e-03f, -5.16446345e-02f, 5.03244102e-02f, -7.82397315e-02f, -5.08859009e-03f,
  1.71278920e-02f, 2.54852418e-02f, -7.73017481e-02f, 3.67746991e-03f, 9.62068327e-03f, -6.35026544e-02f, -6.09839596e-02f, -3.28826718e-02f, 9.06402767e-02f, 1.09885454e-01f,
  4.16918434e-02f, 1.39680490e-01f, 1.16877541e-01f, 1.10908963e-01f, 1.62703395e-01f, -4.82863151e-02f, 1.88815728e-01f, 1.09624870e-01f, 1.31338432e-01f, 9.07383934e-02f,
  -3.90588269e-02f, 2.01779008e-02f, 4.97544333e-02f, 3.50929350e-02f, 3.29621974e-03f, 5.29983565e-02f, 2.24649440e-02f, 6.63551316e-02f, -1.60487592e-02f, -3.99410315e-02f,
  -3.30561376e-03f, -1.47362787e-03f, -1.36206709e-02f, -1.28323641e-02f, -2.90430039e-02f, -2.30787527e-02f, 1.61752338e-03f, -9.44161229e-03f, -3.17087993e-02f, 3.53477709e-02f,
  7.51280561e-02f, 5.20191668e-03f, 3.05613270e-03f, 3.26175056e-02f, -3.07176765e-02f, -3.04324627e-02f, 2.35255994e-02f, 1.08534098e-02f, -2.60161273e-02f, -1.24519831e-02f,
  -7.10713584e-03f, -5.85774705e-02f, 1.45754470e-02f, 1.41634524e-01f, -3.88991684e-02f, 2.88418569e-02f, 9.17528663e-03f, -2.39559002e-02f, -8.46044943e-02f, 5.01203462e-02f,
  -5.18593844e-03f, 6.63657933e-02f, -9.25848335e-02f, 8.48703533e-02f, -7.05147684e-02f, 7.45578185e-02f, -3.88927222e-03f, -1.87891927e-02f, -2.08488591e-02f, 2.36517042e-02f,
  -1.11526318e-01f, 4.31692526e-02f, 7.88429081e-02f, -3.63677251e-03f, 3.20057943e-02f, -9.89322662e-02f, 3.54016125e-02f, 1.46158278e-01f, -1.37301823e-02f, -3.73773202e-02f,
  -1.72066525e-01f, 5.12244627e-02f, 1.44295543e-01f, -1.29480243e-01f, 3.34947295e-02f, -3.50095308e-03f, 1.28947154e-01f, 5.16684577e-02f, -1.68433532e-01f, -3.46179307e-02f,
  6.09653629e-02f, 1.00643404e-01f, 1.29050180e-01f, 1.60687417e-01f, 5.91314994e-02f, 8.39736760e-02f, 5.21922894e-02f, 1.13413058e-01f, 1.16484806e-01f, 1.69201747e-01f,
  -6.86105117e-02f, -6.15725480e-02f, -8.51718187e-02f, -2.14950996e-03f, -1.00118466e-01f, -3.59172784e-02f, -2.86603719e-02f, -7.48603791e-02f, 3.80517840e-02f, -1.17286481e-01f,
  3.17094356e-01f, -1.26513233e-03f, 1.07715152e-01f, -3.37739103e-02f, 6.25162348e-02f, 8.62525478e-02f, 1.19667597e-01f, -2.98968609e-03f, 4.38387506e-02f, 7.75473565e-02f,
  4.07172553e-02f, -1.91048216e-02f, 1.16566047e-01f, -5.32551110e-02f, 2.60396078e-02f, 8.49102810e-02f, -8.75133730e-04f, 7.11210594e-02f, -1.07708424e-02f, 9.54040885e-02f,
  1.08082816e-01f, 1.69135607e-03f, 7.59460628e-02f, 2.21442748e-02f, 3.40718888e-02f, 1.41238691e-02f, 5.85410595e-02f, 7.29669183e-02f, 5.10886125e-02f, -2.81091668e-02f,
  1.92460348e-03f, -8.02325606e-02f, -7.64073152e-03f, -6.43620044e-02f, 1.94813125e-02f, 7.32840151e-02f, 1.40797701e-02f, 5.71385175e-02f, -2.82979459e-02f, 3.72381397e-02f,
  -3.69476750e-02f, 2.17341483e-02f, -7.17879012e-02f, 7.06989691e-02f, -4.16329242e-02f, 1.51598547e-02f, -5.15354238e-03f, 1.76302320e-03f, -5.22438064e-02f, -4.33239006e-02f,
  6.43805712e-02f, -1.44277466e-02f, -2.01376639e-02f, -3.20937857e-02f, -6.98370114e-02f, 3.39531191e-02f, -4.30525094e-02f, -4.38253842e-02f, -1.91559419e-02f, 3.03806327e-02f,
  8.93654451e-02f, -1.86694544e-02f, 2.43231915e-02f, -5.79655617e-02f, -1.38323620e-01f, -1.15045086e-01f, -3.15069184e-02f, -2.21524257e-02f, -2.29377393e-02f, 1.10680595e-01f,
  2.32889168e-02f, 1.43878963e-02f, -4.60987817e-03f, -4.25630808e-02f, 5.40153384e-02f, 1.54245179e-02f, -1.16322823e-01f, -3.42537090e-03f, -3.98844853e-02f, 2.63250712e-02f,
  -8.81700888e-02f, -1.39077771e-02f, 2.34276265e-01f, 1.17215224e-01f, 8.02419856e-02f, 9.87876207e-02f, 1.94727972e-01f, 4.52245437e-02f, 8.95018056e-02f, 2.59632450e-02f,
  1.47172853e-01f, 2.41394527e-02f, 4.43808065e-04f, 1.51802480e-01f, 7.55551923e-03f, 1.08261362e-01f, 1.40564859e-01f, 7.84445331e-02f, 1.69659495e-01f, 1.02742404e-01f,
  -2.51510385e-02f, 4.60311845e-02f, 1.58224151e-01f, 7.69983679e-02f, 7.97299519e-02f, 9.82167721e-02f, 4.84297201e-02f, 6.10951893e-02f, 1.64319109e-02f, 1.34500891e-01f,
  1.12729155e-01f, 2.61609089e-02f, 7.56916255e-02f, 3.44740081e-04f, -4.37746830e-02f, 7.52836559e-03f, 4.13256232e-03f, -7.52923042e-02f, -8.85072798e-02f, -8.66606715e-04f,
  -1.78316012e-01f, 2.13165525e-02f, 8.41620192e-02f, 2.02134531e-02f, -3.99863087e-02f, 4.75403387e-03f, -1.36659238e-02f, -8.22273865e-02f, -1.55976200e-02f, 4.81913835e-02f,
  -5.94036374e-03f, -7.35721737e-02f, 2.16134768e-02f, 3.13300788e-02f, -9.64298174e-02f, 3.37268449e-02f, -1.08122984e-02f, 1.05213717e-01f, 9.91593897e-02f, -4.35122401e-02f,
  8.22205171e-02f, 5.71914949e-02f, -1.19547332e-02f, 9.54733267e-02f, 7.80305266e-02f, 3.56206968e-02f, 2.34777969e-03f, 1.75492074e-02f, 4.27029729e-02f, 7.31637031e-02f,
  3.29982340e-02f, 5.92151433e-02f, 1.00307316e-01f, 6.56601265e-02f, 6.53463826e-02f, 7.58427456e-02f, -6.27151430e-02f, 6.07707687e-02f, 4.84163873e-02f, -8.14455599e-02f,
  -2.71230787e-02f, 2.51994077e-02f, -1.55100683e-02f, 4.29237671e-02f, 4.17903550e-02f, -7.18285292e-02f, -5.33954985e-02f, -4.47905883e-02f, 4.80793901e-02f, 2.67546857e-03f,
  -2.35998421e-03f, -2.38623470e-02f, -2.03341730e-02f, -2.67372634e-02f, 1.78129710e-02f, 1.98865328e-02f, -1.17064100e-02f, -2.44433619e-02f, -1.14254013e-01f, -7.88786262e-02f,
  -8.29034075e-02f, -8.94130731e-04f, 1.66111924e-02f, 5.84663376e-02f, -8.06252509e-02f, -6.26575798e-02f, -2.98637729e-02f, -6.25059009e-02f, -5.14182933e-02f, -1.04568638e-01f,
  -1.10944420e-01f, -5.62108681e-02f, -4.25980799e-02f, 2.49063466e-02f, -2.76050251e-03f, -4.97607216e-02f, -8.63447934e-02f, 9.15798396e-02f, -6.41289800e-02f, -1.16946049e-01f,
  3.02521158e-02f, 6.42496869e-02f, -2.88367216e-02f, 1.25679210e-01f, -7.79012889e-02f, 8.95735845e-02f, -7.56607801e-02f, 1.85892719e-03f, 2.16601975e-02f, 3.53050269e-02f,
  1.14979163e-01f, -1.16361022e-01f, -1.83150060e-02f, 3.61584760e-02f, 6.21202122e-03f, 1.04519777e-01f, -4.94427569e-02f, 1.10393859e-01f, 1.01449862e-01f, -1.03205755e-01f,
  -1.57045558e-01f, -9.45496038e-02f, -8.11750889e-02f, 4.88335714e-02f, 1.04671173e-01f, 4.52725515e-02f, 5.60351722e-02f, 1.57690942e-01f, 2.05360483e-02f, 8.83733854e-03f,
  1.22351041e-02f, 7.98345506e-02f, 1.01536795e-01f, 7.76515380e-02f, 5.33324555e-02f, 7.30398521e-02f, -3.68737318e-02f, 1.06269471e-01f, 2.89850570e-02f, 1.20880380e-01f,
  -1.25332505e-01f, -7.08963573e-02f, -4.88332137e-02f, -1.01814032e-01f, -2.44108099e-03f, -2.48420518e-02f, 8.10484774e-03f, 2.84417495e-02f, -1.13940895e-01f, 1.73391998e-02f,
  -7.42950104e-03f, -4.29371558e-02f, -5.62066734e-02f, 1.79793895e-03f, -8.63275304e-02f, -3.95434089e-02f, 2.28771120e-02f, 2.48463992e-02f, 3.47868260e-03f, -2.14926079e-02f,
  -3.30644399e-02f, 1.98104288e-02f, 2.99607255e-02f, 6.85705394e-02f, 9.04590052e-05f, 4.87828366e-02f, 6.02593757e-02f, -7.05129579e-02f, -8.66331533e-03f, 1.47052845e-02f,
  3.72125842e-02f, -6.00397936e-04f, 5.68709113e-02f, 5.14866710e-02f, 5.89631982e-02f, 3.94436084e-02f, -1.93762537e-02f, -1.10166147e-02f, 1.13159627e-01f, -7.33135492e-02f,
  -8.33071396e-02f, 3.31326984e-02f, -9.41436440e-02f, -4.70401533e-02f, -1.10657997e-01f, -2.77295965e-03f, -6.88205585e-02f, 6.74408209e-03f, -1.88762955e-02f, -3.57566886e-02f,
  1.57409180e-02f, -2.63640303e-02f, 3.21789868e-02f, -2.27488447e-02f, 1.99580137e-02f, 2.75272829e-03f, 9.80790798e-03f, 6.25244994e-03f, 2.51133256e-02f, -1.38121620e-02f,
  -5.39868139e-02f, 5.78145981e-02f, 3.47401276e-02f, 7.93190673e-02f, -3.71921598e-03f, -3.37979496e-02f, -4.90208492e-02f, 3.01211141e-02f, -8.09232444e-02f, -2.53945421e-02f,
  1.74083486e-02f, 4.87159118e-02f, 2.44163387e-02f, 7.81746060e-02f, -1.25028556e-02f, 1.96988974e-02f, -3.80911380e-02f, 5.78305498e-03f, -6.60459686e-04f, -4.60168794e-02f,
  2.76782624e-02f, -4.63054404e-02f, 6.76275045e-02f, 3.01833581e-02f, 1.14728481e-01f, 1.31337553e-01f, 6.73530251e-02f, -3.80496122e-02f, -4.81331870e-02f, 6.91711605e-02f,
  -3.06472361e-01f, -1.34416401e-01f, 4.12446335e-02f, 4.81493436e-02f, -3.10074128e-02f, -5.50836660e-02f, -2.79310673e-01f, -6.67145699e-02f, 5.28764315e-02f, -2.94793602e-02f,
  -4.18628827e-02f, 3.60876182e-03f, 8.67172889e-03f, 3.54909562e-02f, -2.09214687e-01f, 1.24743935e-02f, 8.05074424e-02f, -1.03520349e-01f, -1.34766698e-02f, -1.21897191e-01f,
  -6.21838607e-02f, -6.71206694e-03f, 7.75178662e-03f, -9.27116256e-03f, 9.18102190e-02f, 9.68934596e-02f, 5.04119992e-02f, -2.54883934e-02f, 9.26584825e-02f, 1.22124493e-01f,
  3.60068753e-02f, 5.36324717e-02f, -3.18687968e-02f, 4.35790680e-02f, 1.04875654e-01f, -3.98608223e-02f, -3.08579504e-02f, 4.29867990e-02f, -5.27197570e-02f, -7.26397112e-02f,
  1.96646526e-02f, -1.52660673e-02f, -5.63463457e-02f, -1.94019079e-02f, 2.41471883e-02f, 1.02158645e-02f, -1.12478212e-01f, 2.76807006e-02f, 2.48322058e-02f, -7.10017309e-02f,
  2.04711389e-02f, -4.96943332e-02f, -1.30733788e-01f, -8.22910964e-02f, -3.97322141e-02f, 5.79444580e-02f, -2.01274343e-02f, 7.45040923e-02f, -7.41704479e-02f, -9.21239480e-02f,
  3.75834592e-02f, -3.19544710e-02f, 4.77022715e-02f, -1.99415907e-02f, -8.18039849e-02f, 3.80740836e-02f, 9.00817588e-02f, -5.13533242e-02f, -8.06032738e-04f, 6.46932274e-02f,
  -2.16138065e-02f, -4.02827151e-02f, -4.62046526e-02f, 1.12803921e-01f, -8.51510372e-03f, 6.69596344e-02f, -2.94144303e-02f, -5.07508442e-02f, 1.86688155e-02f, 4.26443070e-02f,
  -5.39958365e-02f, 6.47813305e-02f, 3.42327468e-02f, -5.88043146e-02f, 7.85365626e-02f, 1.06294245e-01f, 1.77336950e-02f, -6.13874421e-02f, -5.06719388e-02f, -1.00648310e-02f,
  1.06035480e-02f, 4.88603301e-02f, -8.46274942e-02f, -7.31561333e-02f, -1.78010222e-02f, 2.23317668e-02f, 6.43569008e-02f, 3.71454209e-02f, -1.51734613e-02f, -7.03043863e-02f,
  -6.43348768e-02f, -1.87492408e-02f, -9.80703346e-03f, 1.24743395e-02f, -1.29018009e-01f, -6.58291727e-02f, -5.04051670e-02f, 5.81478409e-04f, -1.02007091e-01f, -4.97411638e-02f,
  -7.60833025e-02f, -1.68446094e-01f, -1.30296990e-01f, -1.85824875e-02f, -1.03069365e-01f, -1.20281376e-01f, -1.66275397e-01f, -5.03273960e-03f, -5.92899285e-02f, -1.97811767e-01f,
  -1.60675168e-01f, -4.25635837e-02f, -1.44052491e-01f, -8.92534703e-02f, 5.41238971e-02f, 8.38402137e-02f, -2.69401446e-02f, -4.31123078e-02f, -1.25827447e-01f, -1.08554825e-01f,
  -6.09025545e-02f, -2.08425149e-02f, -1.18504073e-02f, -2.95402557e-02f, -5.55646233e-02f, -1.11438058e-01f, -1.05364703e-01f, -1.56273156e-01f, 2.31385324e-02f, -1.36025734e-02f,
  -7.58731961e-02f, -1.02811754e-01f, -2.41674855e-01f, -1.37719542e-01f, -1.72350153e-01f, -1.62834927e-01f, -1.16722919e-01f, -2.13327885e-01f, 1.56747513e-02f, -7.58424029e-02f,
  -1.71978548e-02f, 2.01178610e-01f, 8.53926614e-02f, -7.05211088e-02f, -1.18877217e-01f, -2.94145141e-02f, -3.72846462e-02f, 5.06206357e-04f, 4.91414629e-02f, -6.02787957e-02f,
  1.76884383e-02f, 5.03887832e-02f, -1.13682844e-01f, -2.88660880e-02f, 5.14479950e-02f, -6.40387014e-02f, -5.40562607e-02f, 4.13237587e-02f, 6.38551414e-02f, -3.68259847e-02f,
  -5.42242564e-02f, -9.27053168e-02f, 3.54408026e-02f, -3.10182255e-02f, 2.83008795e-02f, 7.14562163e-02f, -4.49389592e-02f, -7.69698620e-02f, -2.21704710e-02f, -6.81173056e-02f,
  -2.82275416e-02f, 6.38406500e-02f, 6.02743141e-02f, 7.10783002e-04f, -7.49437213e-02f, -8.35378245e-02f, -8.06746352e-03f, 6.19282909e-02f, 3.67859146e-03f, -5.58906831e-02f,
  6.89409152e-02f, -4.85390909e-02f, -2.30023339e-02f, -3.34708914e-02f, 1.32736089e-02f, -8.77129436e-02f, -3.87785211e-02f, -7.46201649e-02f, -6.69798031e-02f, -1.46458084e-02f,
  -5.48005141e-02f, -7.59666553e-03f, -8.43152404e-02f, -6.60413057e-02f, -1.15822464e-01f, 2.23113913e-02f, 6.16131499e-02f, 2.21063774e-02f, 7.68896043e-02f, 5.50654829e-02f,
  -1.53491184e-01f, 1.58193588e-01f, 1.22394180e-02f, -8.08394328e-03f, -9.20747221e-02f, -1.11461595e-01f, -1.32342307e-02f, 3.37732174e-02f, 7.08838627e-02f, -6.41339645e-02f,
  1.08430870e-02f, -1.09666787e-01f, -5.22641651e-02f, 7.70656345e-03f, 5.36815897e-02f, -2.39712466e-02f, -1.21112444e-01f, -4.36849222e-02f, 6.70221895e-02f, -3.49303745e-02f,
  -3.74671705e-02f, -4.67526866e-03f, -6.88992068e-02f, -1.00820549e-01f, 3.33947875e-02f, 4.59656045e-02f, 2.56597959e-02f, -4.72243801e-02f, 4.56683710e-02f, -1.87601611e-01f,
  -5.92972636e-02f, 1.06342450e-01f, -8.66849944e-02f, -4.99883778e-02f, 6.96790591e-02f, -8.40461105e-02f, 6.64396584e-02f, -1.05227523e-01f, -4.70355265e-02f, -1.01665109e-01f,
  5.33042289e-02f, 6.46051466e-02f, -1.14307016e-01f, -1.03040576e-01f, -1.24829993e-01f, -4.81203794e-02f, -2.07987294e-01f, -1.74012154e-01f, -1.23086959e-01f, 6.03507422e-02f,
  -5.50771430e-02f, -4.35622260e-02f, -9.52500105e-02f, -1.15584172e-01f, 1.17642038e-01f, 2.29996257e-02f, -1.21099204e-02f, 6.91338107e-02f, 1.34914061e-02f, 8.55466798e-02f,
  1.43469766e-01f, 1.79680679e-02f, -8.15292075e-02f, -1.74194742e-02f, 3.92107479e-02f, -6.26354590e-02f, 2.61671357e-02f, 1.97932757e-02f, -1.65229775e-02f, 3.92590882e-03f,
  -1.94064267e-02f, 4.65768576e-02f, 5.02105132e-02f, 5.33997305e-02f, -8.18035007e-02f, -6.56228140e-03f, -9.64574069e-02f, -3.35578285e-02f, -8.16337764e-02f, -4.69907932e-02f,
  6.77634999e-02f, 4.26390953e-02f, 4.41215327e-03f, -6.60839081e-02f, -7.97365457e-02f, 4.31999890e-03f, 9.86485463e-03f, 9.87340212e-02f, 2.34641451e-02f, -2.80190054e-02f,
  -3.31449471e-02f, 1.30655821e-02f, -4.46621813e-02f, 2.37658136e-02f, -4.19583395e-02f, 4.54291068e-02f, 2.64661685e-02f, 2.67533399e-03f, 6.12648092e-02f, 2.16581710e-02f,
  -3.08843181e-02f, -2.96563543e-02f, 7.91179165e-02f, -5.27997911e-02f, -3.80092561e-02f, -4.55889702e-02f, 8.83065611e-02f, 3.03378794e-02f, -2.45157466e-03f, 2.04596464e-02f,
  -3.55055109e-02f, -8.73943698e-03f, 2.99408697e-02f, -3.26532200e-02f, -3.38386782e-02f, 1.60887893e-02f, 8.01032260e-02f, -4.59324159e-02f, -7.32790604e-02f, 4.45248075e-02f,
  -5.59075288e-02f, 1.35008087e-02f, -1.05352305e-01f, -1.49546154e-02f, -7.14732409e-02f, -9.31281745e-02f, 2.67236549e-02f, 7.10858731e-03f, -8.06606933e-02f, -7.00203255e-02f,
  2.43743528e-02f, -8.60260800e-02f, -5.93182184e-02f, 7.09135011e-02f, 6.93903724e-03f, 2.21265722e-02f, 4.00561057e-02f, -8.01072642e-03f, 1.21774096e-02f, -9.65485256e-03f,
  -1.13141946e-01f, -1.05034567e-01f, -2.47391574e-02f, 2.99864332e-03f, -6.10552952e-02f, -2.14843801e-03f, -1.51919946e-02f, -7.98858777e-02f, -1.66834164e-02f, -5.90532236e-02f,
  1.26487434e-01f, 7.37079456e-02f, -1.88785806e-01f, 1.87209398e-01f, -1.51195541e-01f, -8.54189694e-02f, -1.65706035e-02f, -5.92081323e-02f, -1.80645175e-02f, -2.19212174e-02f,
  -5.29150404e-02f, -8.53194445e-02f, -3.91491838e-02f, -1.52375340e-01f, -8.35948884e-02f, -4.76110019e-02f, -4.72772345e-02f, -1.36025578e-01f, -2.64319658e-01f, -2.34038070e-01f,
  -2.65951920e-02f, 3.88323776e-02f, 6.62229434e-02f, 3.85478092e-03f, -2.55237892e-02f, -1.19764067e-01f, 7.16716126e-02f, -9.97693986e-02f, -6.73864111e-02f, -1.41039252e-01f,
  -5.86296245e-02f, -8.62089768e-02f, -1.43735200e-01f, -4.33165766e-02f, -4.76772152e-02f, 5.44794612e-02f, -1.19981617e-01f, -1.38140023e-01f, -9.87773761e-02f, -6.08748756e-02f,
  -4.89116460e-02f, -1.09075509e-01f, -8.43169689e-02f, -3.35930735e-02f, 4.90665361e-02f, -1.39745310e-01f, 4.60260771e-02f, -7.50671700e-02f, -8.52386057e-02f, 3.00893583e-03f,
  -3.94075178e-02f, -7.05780834e-02f, -1.64058998e-01f, -1.47318318e-01f, -1.24297552e-01f, -9.77701694e-02f, 3.37762898e-03f, -6.58178702e-02f, -1.57998338e-01f, 9.82332751e-02f,
  1.79461949e-02f, -1.22018252e-02f, -6.99614584e-02f, 9.01931822e-02f, 9.10199657e-02f, -3.62519063e-02f, 1.43516605e-04f, 8.19559544e-02f, 7.10643232e-02f, -6.90201810e-03f,
  -9.94166639e-03f, -4.65300046e-02f, -7.86142871e-02f, 2.46346146e-02f, -1.02812713e-02f, -5.48958145e-02f, 3.65529694e-02f, -3.04097235e-02f, -5.64566776e-02f, 1.63220260e-02f,
  3.52466218e-02f, -9.73835308e-03f, 4.89449389e-02f, -5.23739029e-03f, -7.34870359e-02f, 2.30875853e-02f, -2.49613058e-02f, -8.38931128e-02f, -2.05352642e-02f, 1.12359757e-02f,
  1.26881510e-01f, -2.92076498e-01f, -1.55144734e-02f, -2.00522002e-02f, 1.57315284e-02f, 3.13084684e-02f, 1.09953046e-01f, 2.76918933e-02f, -1.24674384e-02f, 1.08381413e-01f,
  -1.12778813e-01f, 5.58096915e-02f, 9.45381597e-02f, 3.24336253e-02f, -1.08509921e-01f, -8.14117119e-02f, 7.82492906e-02f, 6.38977066e-02f, -1.12868577e-01f, 9.97634679e-02f,
  8.58468488e-02f, -1.65188052e-02f, -1.52234919e-02f, 5.90237677e-02f, 1.99331399e-02f, -2.60797776e-02f, 3.60621735e-02f, 6.13691621e-02f, -1.32685483e-01f, 2.56679565e-01f,
  8.98869410e-02f, -2.59203520e-02f, 6.73654899e-02f, 2.24225912e-02f, 8.05926248e-02f, 1.12791717e-01f, 1.58150494e-01f, 1.27251536e-01f, -5.17133065e-02f, 5.62349334e-03f,
  -9.71803218e-02f, 3.05005517e-02f, -6.13142289e-02f, -1.31281137e-01f, -1.74172726e-02f, -5.78437187e-02f, -1.90158039e-02f, 7.34334588e-02f, 7.74829090e-02f, 8.47062245e-02f,
  1.02025745e-02f, 1.00173332e-01f, 1.64714754e-01f, -3.88308205e-02f, -3.03242281e-02f, 3.44819911e-02f, 6.96211904e-02f, 2.91427672e-02f, -5.22758393e-03f, 3.39029990e-02f,
  -1.05492041e-01f, 5.05746491e-02f, 1.00658000e-01f, 3.37400362e-02f, -8.64690468e-02f, -1.41876573e-02f, -3.31709199e-02f, 9.00608953e-03f, 3.29871438e-02f, 2.39638779e-02f,
  -1.25817657e-01f, -9.47187319e-02f, 3.11164539e-02f, -1.78223513e-02f, 8.72432515e-02f, -4.96322773e-02f, 5.32951131e-02f, 1.34148290e-02f, -8.28787833e-02f, 3.36936563e-02f,
  -1.11590363e-01f, -6.39289990e-02f, 1.24653187e-02f, 8.84752199e-02f, -6.92448243e-02f, -3.36390994e-02f, -6.28437996e-02f, 6.00528307e-02f, 5.30245863e-02f, -6.07850552e-02f,
  -6.05744645e-02f, 4.02340107e-02f, 1.48625914e-02f, -3.81201804e-02f, 4.01791334e-02f, -3.22025344e-02f, -3.86266736e-03f, 9.46203843e-02f, 3.99828330e-02f, 4.71437462e-02f,
  5.39660342e-02f, 1.23372832e-02f, 6.23494238e-02f, 4.03960831e-02f, -1.33281918e-02f, 4.85611446e-02f, -7.75798485e-02f, -5.98275959e-02f, -4.66846768e-03f, 8.63417983e-02f,
  1.05716988e-01f, 1.11317068e-01f, 8.94924998e-02f, 7.95838758e-02f, -7.70206004e-02f, -5.38497232e-02f, 5.66898659e-02f, -1.25815682e-02f, 5.89671824e-03f, 1.81960203e-02f,
  3.01415082e-02f, 1.96309332e-02f, -8.53389129e-02f, -1.50062656e-02f, 9.04138237e-02f, -5.47671542e-02f, -8.60855952e-02f, 6.16355240e-03f, -1.24880813e-01f, 2.60584336e-02f,
  5.87351322e-02f, 6.99506626e-02f, 2.44533829e-02f, 2.45260447e-02f, 9.54360217e-02f, -8.92819390e-02f, 6.79396838e-02f, 6.84027746e-02f, -1.98982190e-02f, -7.60191977e-02f,
  2.74880957e-02f, 6.80748932e-03f, 1.36041477e-01f, -4.20205854e-02f, -6.57548979e-02f, 3.22645865e-02f, 8.24699178e-02f, 1.79727320e-02f, 5.94297349e-02f, 2.00867996e-01f,
  -6.96420729e-01f, 1.40202671e-01f, -1.97840124e-01f, -3.15913916e-01f, 1.80946901e-01f, 2.42448702e-01f, 3.67917269e-01f, 1.15304925e-01f, -9.83471051e-02f, 1.44607261e-01f,
  -8.19362048e-03f, -9.10196081e-02f, -3.54453437e-02f, 1.31791174e-01f, -5.21465056e-02f, 2.67933249e-01f, 2.58298814e-01f, 1.24244122e-02f, -1.34065047e-01f, -4.03420813e-03f,
  2.11342409e-01f, -2.66863465e-01f, -3.20974171e-01f, -8.15144703e-02f, 8.50350857e-02f, -2.32843943e-02f, -9.35839303e-03f, -4.24373038e-02f, 1.66042536e-01f, 1.68357149e-01f,
  -1.12483375e-01f, -1.23724133e-01f, -2.72372719e-02f, -4.46036607e-02f, -4.20279130e-02f, -9.10040066e-02f, 3.00592221e-02f, -1.28590539e-01f, -5.87662980e-02f, 5.88867534e-03f,
  -2.26563886e-02f, -4.27698456e-02f, -6.45231083e-02f, -3.50153781e-02f, -5.65649644e-02f, -6.41834165e-04f, -1.23757741e-03f, -8.56696665e-02f, -1.16551064e-01f, 4.53880019e-02f,
  1.69473469e-01f, 2.79189777e-02f, -9.13179889e-02f, 5.52572049e-02f, -5.93111105e-02f, 1.50971888e-02f, -9.53559726e-02f, 8.00876413e-03f, -5.53202033e-02f, -1.08116359e-01f,
  8.49316865e-02f, 6.96015954e-02f, 4.57319207e-02f, 5.76367639e-02f, 5.04384302e-02f, 1.99540667e-02f, 2.54293438e-02f, 4.75872308e-02f, 3.42236012e-02f, -6.19727746e-02f,
  3.15853842e-02f, 4.64280881e-03f, 2.60761026e-02f, -5.96565381e-02f, 1.68130621e-02f, 1.80804413e-02f, 2.62612198e-02f, 5.98431602e-02f, -2.36537810e-02f, 1.93631346e-03f,
  8.80683437e-02f, -3.62087861e-02f, -1.68555696e-03f, -4.93708998e-03f, -4.03040182e-03f, 5.17632142e-02f, 5.85046038e-02f, 2.42284294e-02f, 3.29723861e-03f, -2.39591748e-02f,
  -2.15769187e-01f, 6.28036037e-02f, 3.70169245e-02f, -7.63793588e-02f, 7.75862262e-02f, -4.06468213e-02f, -3.48063372e-02f, -4.59969463e-03f, -5.81313744e-02f, -2.65512504e-02f,
  -1.05514266e-02f, 2.95143910e-02f, 2.91624595e-03f, 1.19834021e-01f, -4.61626127e-02f, 3.00533287e-02f, -1.94281675e-02f, 4.02804511e-03f, 4.96206060e-02f, -2.59339344e-02f,
  7.00430945e-02f, -3.10643204e-02f, -1.13217600e-01f, -3.77584957e-02f, 4.80189882e-02f, 4.70998399e-02f, 7.55850645e-03f, -6.15581423e-02f, -8.83794501e-02f, -1.11796036e-01f,
  2.13619128e-01f, 1.98360154e-04f, 3.21750462e-01f, 1.25024483e-01f, 3.39913778e-02f, 2.31962457e-01f, 1.43312961e-01f, 1.69585377e-01f, 1.99040622e-02f, -5.37343472e-02f,
  8.61957669e-03f, -1.90544009e-01f, -9.44641680e-02f, -7.81649724e-02f, 1.16759606e-01f, 1.05504850e-02f, 9.03346837e-02f, 1.61566257e-01f, 1.81585014e-01f, 9.52321887e-02f,
  -1.71082035e-01f, 6.45993128e-02f, 2.05692381e-01f, 7.46509060e-02f, -4.07217294e-02f, -1.34652615e-01f, 1.35080874e-01f, 2.55440194e-02f, -7.86534250e-02f, -7.01568276e-02f,
  -2.07248390e-01f, 2.20283151e-01f, -4.70196689e-03f, -2.81712264e-02f, 8.34446251e-02f, 8.46474431e-03f, -1.17026949e-02f, 9.27079320e-02f, -9.40366648e-03f, 5.93931936e-02f,
  1.28222851e-03f, 3.10739353e-02f, 3.28504331e-02f, 2.28460152e-02f, -4.89771962e-02f, 7.54659027e-02f, -2.57230960e-02f, 5.92902303e-02f, -1.62253007e-02f, -4.86754961e-02f,
  -7.97738209e-02f, 8.25659037e-02f, 1.44846574e-03f, 6.60729110e-02f, -1.38827916e-02f, -8.49538743e-02f, 3.46425921e-02f, -2.24244520e-02f, 4.71491404e-02f, 6.23613521e-02f,
  1.24635873e-03f, -5.37103489e-02f, 2.63851210e-02f, 8.38964246e-03f, -3.43767405e-02f, 1.14423586e-02f, 6.01670984e-03f, -1.37376329e-02f, -2.49766707e-02f, 9.60192084e-02f,
  -7.84418285e-02f, -5.89187890e-02f, 1.93303786e-02f, -6.34724926e-03f, -6.72908209e-04f, 3.89272757e-02f, 3.77708264e-02f, -8.95508192e-03f, -1.07123651e-01f, -2.42076796e-02f,
  1.73597038e-02f, -3.57380919e-02f, 7.22506866e-02f, -3.12331151e-02f, 4.57265154e-02f, -5.90270869e-02f, 7.74984434e-02f, -6.74741119e-02f, 6.04792722e-02f, 6.98184296e-02f,
  -2.26187170e-01f, 6.66032061e-02f, -2.06885546e-01f, -1.08139984e-01f, 1.78793480e-03f, 5.72466888e-02f, -2.20808163e-02f, -2.06827205e-02f, 4.08157073e-02f, -1.37877343e-02f,
  6.47190884e-02f, 1.09095640e-01f, 7.06612971e-03f, 7.55523667e-02f, 6.07860088e-02f, 3.64876464e-02f, -3.99025492e-02f, -5.04715629e-02f, -5.79144508e-02f, -6.11675829e-02f,
  6.32322803e-02f, 4.23882753e-02f, -6.47953385e-03f, -9.78403315e-02f, 2.77259462e-02f, -1.27487808e-01f, -1.09273806e-01f, -8.07534456e-02f, 2.29694485e-03f, 7.48768896e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.53394759e-01f, 6.53099939e-02f, 1.35934383e-01f, 4.89664599e-02f, 1.06317125e-01f, 5.14721237e-02f, 9.51440930e-02f, 1.68470562e-01f, 2.88685299e-02f, 2.13787332e-01f,
  8.59607384e-02f, 8.53702649e-02f, 5.66192679e-02f, 1.11282930e-01f, -5.15432432e-02f, 1.06257938e-01f, 7.81198144e-02f, 6.19707406e-02f, 2.21375704e-01f, 2.62199610e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.01062804e-01f, 2.27266252e-01f, -3.36985067e-02f, -1.64826185e-01f, 6.68443292e-02f, 2.20134147e-02f, 4.84394252e-01f, 2.72472769e-01f, -3.27324606e-02f, -2.22955182e-01f,
  1.39249966e-01f, -5.62074065e-01f, -2.02469504e-03f, -3.23563367e-02f, 3.52154344e-01f, 2.45740592e-01f, -2.41497919e-01f, 2.08430156e-01f, 2.47877240e-02f, 6.44865930e-02f,
  -3.75675887e-01f, 9.68029201e-02f, 1.72609255e-01f, -5.63380234e-02f, 1.37090394e-02f, -1.11035258e-01f, -1.77608475e-01f, -1.31618336e-01f, 3.49089876e-02f, 2.04848778e-02f,
  -3.20781797e-01f, 1.25858977e-01f, -1.16265103e-01f, -2.04403862e-01f, 2.74770498e-01f, -3.32126729e-02f, 6.04190007e-02f, 1.11547463e-01f, -1.24835894e-01f, 1.87289625e-01f,
  -2.78736860e-01f, 2.53649801e-01f, 2.43877605e-01f, 1.81788787e-01f, 5.10778315e-02f, -8.29842389e-02f, 1.93122085e-02f, -3.01421404e-01f, 9.49517339e-02f, -1.84198454e-01f,
  -4.38956805e-02f, -2.99584925e-01f, -1.42550692e-01f, 3.91725451e-02f, -7.37236068e-02f, -2.26550251e-01f, -1.07813887e-01f, 2.66599417e-01f, -8.28040317e-02f, -2.12976895e-02f,
  -1.41251296e-01f, 5.64324036e-02f, -1.07550442e-01f, -1.05535395e-01f, 7.82260895e-02f, 1.38994142e-01f, 2.51326323e-01f, -2.03185882e-02f, 2.28207067e-01f, -4.04638564e-03f,
  6.11099452e-02f, -2.15551570e-01f, 2.49155499e-02f, -1.21598113e-02f, -2.63824165e-01f, -1.23144001e-01f, -1.42702326e-01f, -1.52893230e-01f, -1.13263130e-01f, 1.71229601e-01f,
  -2.09509626e-01f, 6.03723638e-02f, -8.45241323e-02f, 1.07619740e-01f, -2.35098675e-02f, -3.64260942e-01f, -7.99891353e-02f, 3.31829228e-02f, -1.19380623e-01f, -1.70458242e-01f,
  -1.80350661e-01f, -2.25334704e-01f, -8.38344619e-02f, 8.12796950e-02f, 1.31643489e-01f, 2.22366840e-01f, 1.33220404e-02f, 3.39895368e-01f, 1.04542889e-01f, 1.55415982e-01f,
  3.74951139e-02f, -6.75250217e-02f, -4.24981147e-01f, -3.47648263e-01f, 1.47416024e-02f, 2.09037945e-01f, -1.10483691e-01f, 4.49533284e-01f, 4.24627662e-01f, -1.14220902e-01f,
  1.08533620e-03f, -1.67378411e-01f, -8.03413019e-02f, -3.89838219e-02f, -3.03602200e-02f, -1.20140761e-01f, -2.42797524e-01f, -2.95706391e-01f, -3.63773197e-01f, 4.04091440e-02f,
  1.21672779e-01f, 1.39466703e-01f, -2.66759247e-01f, 4.23994623e-02f, 4.81135219e-01f, 1.82910442e-01f, -3.63690823e-01f, 3.56476933e-01f, 1.20003469e-01f, -6.74576163e-02f,
  8.75420198e-02f, -2.25144345e-02f, 1.34239584e-01f, -2.85767335e-02f, 3.65258217e-01f, 3.64296705e-01f, -2.49480337e-01f, 3.41456950e-01f, 6.92646205e-02f, -6.36005253e-02f,
  -2.75632977e-01f, 1.42854527e-01f, -7.44908303e-02f, 3.18114311e-01f, 9.14056450e-02f, -1.49116054e-01f, 6.71202019e-02f, 2.46857759e-02f, 7.72403739e-03f, 6.80804700e-02f,
  -2.25268975e-02f, -2.72981711e-02f, -1.46242222e-02f, 2.21841887e-01f, 2.68998235e-01f, -1.47505358e-01f, -1.37689292e-01f, -1.17394095e-02f, 2.41876423e-01f, -3.83829651e-03f,
  -2.08321795e-01f, -3.41853313e-02f, -2.96982199e-01f, -3.67261082e-01f, -2.62474537e-01f, 1.75027147e-01f, 4.37109977e-01f, 1.82909578e-01f, -3.03289711e-01f, 3.83179560e-02f,
  -3.04452181e-02f, -6.02082193e-01f, -6.02971129e-02f, -5.33580892e-02f, -3.30901146e-01f, 1.04442509e-02f, -1.70889005e-01f, -1.17949292e-01f, -2.89700590e-02f, 3.05441618e-01f,
  -3.12488019e-01f, -2.13750392e-01f, -1.62195474e-01f, 2.26545721e-01f, -7.47427642e-02f, -9.85389277e-02f, 2.91241705e-02f, 1.74362236e-03f, 9.51658189e-02f, 7.13631287e-02f,
  -5.16844332e-01f, 2.82740235e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -7.22797662e-02f, 8.52511898e-02f, -2.19711944e-01f, 1.79568768e-01f, 1.56952649e-01f, 6.72755316e-02f, 8.03451389e-02f, 2.06560418e-02f, 1.90101743e-01f, 3.88529263e-02f,
  -2.72626549e-01f, 1.61272317e-01f, 2.85331070e-01f, 2.86547095e-02f, -1.79544598e-01f, 2.01780125e-01f, 2.33937368e-01f, -2.38551982e-02f, 1.89998418e-01f, 1.23119771e-01f,
  1.95911095e-01f, 3.35656524e-01f, -1.17766805e-01f, 1.79086789e-01f, 2.12488696e-01f, 6.10320605e-02f, 1.11526877e-01f, 1.45810649e-01f, -1.60763413e-01f, 7.68756568e-02f,
  3.31662089e-01f, 3.07138432e-02f, 3.45802516e-01f, -7.51770362e-02f, 4.00714278e-01f, 1.24628328e-01f, 2.89711386e-01f, 4.71566409e-01f, 6.06372841e-02f, 3.42581302e-01f,
  -2.60357559e-01f, -8.25993493e-02f, 6.22476816e-01f, -1.38794884e-01f, 1.52698070e-01f, -1.83825567e-01f, 6.24302328e-02f, 5.54888286e-02f, -1.03366643e-01f, 2.20524654e-01f,
  -5.09607233e-03f, 2.20302969e-01f, 1.26840591e-01f, 3.69433224e-01f, -2.42813621e-02f, 8.51782113e-02f, 3.91938910e-02f, 2.71290481e-01f, 2.32841417e-01f, 1.51637658e-01f,
  2.11974695e-01f, 1.95670296e-02f, 4.09688689e-02f, -1.39888614e-01f, -1.98025107e-02f, -5.49483150e-02f, -5.25569692e-02f, -1.31563857e-01f, -9.14475992e-02f, 1.59249365e-01f,
  1.00827627e-01f, -2.14870855e-01f, -1.13139510e-01f, 1.91455990e-01f, -1.24115542e-01f, -1.74589425e-01f, -3.42989564e-02f, 6.50513917e-02f, 3.62469954e-03f, 2.02557191e-01f,
  -2.25971173e-02f, -7.67592564e-02f, -6.42568767e-02f, 2.28478760e-01f, 1.08760670e-01f, 7.17190206e-02f, -1.23439819e-01f, 1.61222234e-01f, -9.80344564e-02f, -1.34678990e-01f,
  7.38364309e-02f, -1.25976861e-01f, 1.32919505e-01f, 2.18040898e-01f, -6.79257512e-02f, -4.30171937e-02f, 3.28472435e-01f, -9.21834558e-02f, 2.18697250e-01f, -5.23416810e-02f,
  6.81980029e-02f, 2.22394794e-01f, 3.87503318e-02f, 2.18276426e-01f, 2.06131339e-02f, 1.74607038e-01f, 3.92925709e-01f, -4.76220436e-02f, -7.97695946e-03f, -5.99134974e-02f,
  -4.17514406e-02f, -9.88905802e-02f, -2.57711206e-03f, -1.65030450e-01f, -4.84753847e-02f, 9.97280329e-03f, -7.52645284e-02f, 6.17316440e-02f, -2.29769200e-01f, 9.61636752e-02f,
  1.84511021e-01f, -2.59878654e-02f, 2.64572680e-01f, 2.79954582e-01f, 2.33643144e-01f, -1.80632714e-03f, 3.38375479e-01f, -9.08201188e-02f, -6.67767227e-02f, -1.53366327e-01f,
  7.37449750e-02f, -5.51269688e-02f, -1.04410313e-01f, -6.46507367e-02f, -4.38689515e-02f, 6.56829029e-02f, -1.99662354e-02f, -2.36035399e-02f, -9.70461592e-02f, 1.65063918e-01f,
  -8.87145326e-02f, 1.94120198e-01f, 4.26211469e-02f, -9.28932875e-02f, 1.87231377e-02f, -3.94432209e-02f, 2.22909927e-01f, 2.38174647e-02f, 2.81748269e-03f, -2.94399802e-02f,
  2.39512444e-01f, -1.00383267e-01f, -4.35160510e-02f, 2.35487334e-02f, -1.15320168e-01f, -4.68246043e-02f, -1.09594561e-01f, -1.71936676e-01f, 1.04458399e-01f, 4.79119979e-02f,
  -2.11365551e-01f, 9.01929513e-02f, -1.09058380e-01f, 1.39277384e-01f, -9.91087481e-02f, -8.25612061e-03f, 1.11919135e-01f, -3.43992598e-02f, -2.50271827e-01f, 2.07925275e-01f,
  -3.36653851e-02f, -1.03639737e-01f, -1.58201769e-01f, 1.14400730e-01f, 1.11121729e-01f, 1.86129585e-02f, 1.93628475e-01f, -1.09401613e-01f, 2.45237686e-02f, 2.09165901e-01f,
  1.60684988e-01f, -1.94198266e-02f, -8.90127644e-02f, -1.75514400e-01f, 1.30447492e-01f, 3.10293604e-02f, 1.59589425e-01f, 2.40891874e-02f, 1.01900153e-01f, 2.38689296e-02f,
  -7.01907575e-02f, 1.57702282e-01f, -1.27337992e-01f, -2.19335303e-01f, 2.38262340e-01f, 1.59935132e-01f, 1.74336925e-01f, 1.25889912e-01f, 2.93411091e-02f, 2.54914641e-01f,
  4.20528762e-02f, -2.74802804e-01f, 1.97064325e-01f, -2.01056480e-01f, 9.74616408e-02f, -1.03668422e-01f, 2.14231685e-01f, -1.11539692e-01f, -2.28611469e-01f, 2.63866484e-01f,
  9.39745829e-02f, -1.67347744e-01f, 1.57508388e-01f, 1.40672848e-01f, 2.44354852e-03f, -4.80419733e-02f, -1.00848787e-01f, 1.26478717e-01f, 8.47666338e-02f, 8.79252851e-02f,
  -1.74990237e-01f, -5.24153979e-03f, 2.50619799e-01f, 7.08504170e-02f, -4.22139093e-02f, 2.77856797e-01f, 1.25308931e-01f, 9.33519527e-02f, 2.20830083e-01f, 2.24520192e-01f,
  -1.35926604e-01f, -1.80116445e-01f, -3.32481265e-02f, 4.32819396e-01f, -4.49618459e-01f, 3.35078567e-01f, 5.53817954e-03f, 1.06857218e-01f, 6.66488186e-02f, -1.41572252e-01f,
  1.98421746e-01f, 3.41032259e-02f, 1.54825240e-01f, -7.95108005e-02f, -7.49346241e-02f, -1.44572854e-01f, 4.56680283e-02f, -3.21853124e-02f, 2.38738254e-01f, 2.06220776e-01f,
  3.48992832e-03f, -1.24181263e-01f, 8.49836394e-02f, 1.52634934e-01f, -4.65893410e-02f, 2.59489864e-01f, 3.68650295e-02f, 9.93231237e-02f, -5.57959899e-02f, -2.81210784e-02f,
  -1.08005859e-01f, -7.78442100e-02f, -1.41325295e-01f, -1.76041812e-01f, 8.82169008e-02f, 7.14534968e-02f, 1.79009691e-01f, 7.53254667e-02f, 1.85734443e-02f, 3.24266367e-02f,
  1.17695980e-01f, -1.48122057e-01f, 1.77280903e-01f, 1.32022770e-02f, 1.94714531e-01f, -3.45662795e-02f, -1.72320768e-01f, 3.03850695e-02f, 2.88830251e-01f, 1.26958996e-01f,
  -2.22947057e-02f, 7.99494237e-02f, -6.38803467e-03f, -2.54583564e-02f, -1.16849869e-01f, 3.14741745e-03f, -7.37204999e-02f, 2.65108049e-02f, 3.70895594e-01f, 6.07338436e-02f,
  2.58506864e-01f, 2.08429053e-01f, 5.07109128e-02f, 9.18035805e-02f, 1.82570126e-02f, 3.06241959e-01f, 7.26751164e-02f, 8.57767612e-02f, 6.05313241e-01f, 6.35147169e-02f,
  7.76467286e-03f, 1.89249143e-02f, -5.24325203e-03f, 9.90696847e-02f, 7.22881034e-03f, 1.14460448e-02f, -1.52126625e-01f, 4.98418212e-02f, -8.15669969e-02f, 2.26031870e-01f,
  -8.89106318e-02f, -2.63851956e-02f, -5.32131307e-02f, 1.99260160e-01f, -5.32261766e-02f, 7.54551813e-02f, 2.41115794e-01f, 9.26477164e-02f, 2.86553562e-01f, 7.82281235e-02f,
  2.96946913e-01f, 6.78287327e-01f, 1.40414357e-01f, 3.97567153e-02f, 2.68120229e-01f, 2.56074518e-01f, 5.81809819e-01f, 1.13688976e-01f, -2.20925003e-01f, -4.13618118e-01f,
  -2.48499334e-01f, -5.13699651e-01f, -3.63935083e-01f, 2.53031284e-01f, 5.09205401e-01f, 2.16186326e-02f, -1.81116417e-01f, 4.87321734e-01f, -3.94262746e-02f, 4.70205873e-01f,
  -1.42577931e-01f, -2.72500366e-02f, 1.86082631e-01f, 9.03644934e-02f, 7.73231164e-02f, -2.44830698e-01f, -2.33366191e-01f, -1.03132688e-01f, 2.62132049e-01f, 2.86161393e-01f,
  -1.70723513e-01f, 4.59989101e-01f, 1.65031459e-02f, -1.39330193e-01f, 1.25500157e-01f, 3.48472685e-01f, 1.13415495e-01f, 1.14839999e-02f, -5.91905378e-02f, -7.71815330e-02f,
  1.06435291e-01f, -1.51165634e-01f, 2.31787682e-01f, 1.70227900e-01f, -1.41685441e-01f, 6.99816793e-02f, 9.34463814e-02f, 5.30894339e-01f, 7.24766999e-02f, -2.06888244e-02f,
  8.99887532e-02f, -2.10479975e-01f, 4.12703633e-01f, 1.66099653e-01f, 2.08558911e-03f, 1.64780214e-01f, 7.14932829e-02f, -1.64281040e-01f, 2.93937810e-02f, 6.07042648e-02f,
  -2.80385971e-01f, -1.15200251e-01f, 6.86421216e-01f, -2.72352457e-01f, -2.50369310e-01f, -1.24334656e-01f, -7.61492848e-02f, -1.61308542e-01f, 6.03140444e-02f, -3.05320956e-02f,
  9.12451968e-02f, 1.16309547e-03f, -1.12705208e-01f, 1.30369499e-01f, -3.57742965e-01f, -7.41463080e-02f, 6.41352460e-02f, 1.77002057e-01f, 1.15112200e-01f, 7.37090036e-02f,
  1.53564319e-01f, -6.58733994e-02f, 7.22893998e-02f, 1.87826574e-01f, -1.79120690e-01f, 2.35051557e-01f, -1.59666792e-01f, 2.78263330e-01f, 2.24200040e-01f, 1.07953243e-01f,
  2.79885173e-01f, 3.37603688e-02f, -1.63866915e-02f, -2.36252137e-03f, -1.92470834e-01f, 1.52299210e-01f, -3.23958322e-02f, -6.42036647e-02f, -1.48081467e-01f, -8.27665552e-02f,
  1.26486614e-01f, 1.45071462e-01f, -3.17435950e-01f, -2.18726099e-01f, 1.11093096e-01f, 1.50552481e-01f, -9.84646082e-02f, -5.62750101e-02f, 2.00324491e-01f, -9.27812606e-02f,
  1.13579400e-01f, -2.87189167e-02f, 6.06496111e-02f, 9.51324329e-02f, 1.72137469e-02f, 3.78102362e-02f, 1.48568898e-01f, 1.66410074e-01f, -1.82985082e-01f, -8.54995623e-02f,
  2.06047818e-02f, 1.77519873e-01f, -5.03335670e-02f, 2.00099140e-01f, -1.72906406e-02f, -2.30116285e-02f, -1.55191287e-01f, 1.80588990e-01f, 2.27589116e-01f, 3.40077251e-01f,
  1.02322951e-01f, 1.70799658e-01f, 2.45228913e-02f, 2.70380825e-01f, -4.58396226e-01f, -3.31273168e-01f, 3.45063984e-01f, -1.99295595e-01f, -3.52238715e-01f, 1.83369294e-01f,
  2.26842687e-01f, 8.43305439e-02f, 1.95774853e-01f, 8.48564208e-02f, 7.61344060e-02f, 9.41395387e-02f, 2.31737331e-01f, -1.68676704e-01f, 2.17497006e-01f, 5.96128181e-02f,
  -1.01622477e-01f, -1.51893392e-01f, -1.00972943e-01f, 1.60397276e-01f, 6.42855614e-02f, 3.86662520e-02f, 2.87757665e-01f, 3.58386673e-02f, 7.04104081e-02f, 1.72929838e-01f,
  7.24559247e-01f, 3.63300890e-01f, 2.33565107e-01f, 4.21586066e-01f, 2.90153593e-01f, -2.73352802e-01f, 5.77816218e-02f, 1.10774010e-01f, 1.64328232e-01f, 4.40115571e-01f,
  -2.47459278e-01f, 5.52929223e-01f, -9.02420580e-02f, 2.70162791e-01f, 3.98408294e-01f, 3.43788922e-01f, -1.56470865e-01f, -5.92222139e-02f, -2.47165620e-01f, -1.38898551e-01f,
  1.78064227e-01f, -2.57622719e-01f, -4.04783905e-01f, 6.24012612e-02f, 2.95759171e-01f, 2.34593496e-01f, -1.47669971e-01f, -1.92902729e-01f, 2.41371468e-01f, 1.40236348e-01f,
  1.01975024e-01f, -3.43504958e-02f, 3.09036851e-01f, 1.00427777e-01f, 8.69662836e-02f, 2.71779329e-01f, -1.22427486e-03f, 2.58162856e-01f, -3.30598503e-02f, 3.45054299e-01f,
  -1.13799281e-01f, 2.86908261e-02f, 2.70850539e-01f, 8.68074223e-02f, -1.08183794e-01f, -4.66269813e-02f, 2.10253522e-01f, -1.22020498e-01f, 1.82063997e-01f, -2.62055118e-02f,
  -6.16921531e-03f, -7.34842196e-02f, 9.06277671e-02f, 7.15098605e-02f, 1.79987371e-01f, 6.25454113e-02f, 4.01030965e-02f, 2.67972648e-01f, 1.06061190e-01f, 1.38217956e-01f,
  3.31734447e-03f, 1.56185299e-01f, -7.95895513e-03f, -5.02329208e-02f, 3.46017420e-01f, 1.74057439e-01f, 2.59404302e-01f, -7.82505944e-02f, 2.79992044e-01f, 3.47705394e-01f,
  3.18829775e-01f, 3.75492632e-01f, -2.73273081e-01f, 9.73309651e-02f, 4.44105089e-01f, -9.89012942e-02f, -1.10949911e-01f, 1.29683211e-01f, 2.77240723e-01f, 8.90516713e-02f,
  -8.18552002e-02f, 2.70079467e-02f, -4.60923053e-02f, 3.86294216e-01f, 7.06113577e-02f, 2.08741516e-01f, 2.37046406e-01f, 2.45953321e-01f, -4.97242250e-02f, 6.22510575e-02f,
  1.53359726e-01f, -8.26589204e-03f, 1.36323959e-01f, 6.40466884e-02f, 1.55669600e-01f, 1.91196814e-01f, -1.57354712e-01f, 2.24356316e-02f, 6.40398860e-02f, 4.30012792e-02f,
  -1.18597254e-01f, 2.25183889e-02f, 9.91539210e-02f, 1.26358479e-01f, 1.73238963e-01f, -7.43760690e-02f, -9.06008258e-02f, -8.46805051e-02f, -1.44637182e-01f, -8.66294876e-02f,
  3.77293467e-03f, 1.39537230e-01f, -1.34785056e-01f, -1.68100268e-01f, -1.36544511e-01f, -1.31189853e-01f, -6.12842590e-02f, -4.71719354e-02f, 4.54901718e-02f, -7.09363222e-02f,
  -1.38384685e-01f, -1.04994103e-01f, 5.49174882e-02f, -8.20835531e-02f, 1.29750848e-01f, -4.27843519e-02f, 1.55335307e-01f, -4.26582173e-02f, -1.72780126e-01f, 1.50451049e-01f,
  1.49183050e-01f, 3.04420650e-01f, 3.02772671e-02f, -1.16929255e-01f, -3.01529974e-01f, -1.47831887e-01f, 4.35829401e-01f, -2.02009469e-01f, -4.86635625e-01f, -5.83529733e-02f,
  -4.27080542e-02f, 1.82001367e-01f, 1.62698980e-02f, 1.57937989e-01f, -7.44626969e-02f, -1.33724168e-01f, 1.15347743e-01f, -1.23245992e-01f, 1.23728149e-01f, -1.55212268e-01f,
  1.79955035e-01f, -3.77075076e-02f, 6.52795061e-02f, 1.08727075e-01f, 1.17675856e-01f, -1.63824648e-01f, -1.64991036e-01f, 2.32666880e-01f, 2.91140437e-01f, 2.38995910e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.27259219e-01f, 2.10476846e-01f, -1.43622374e-02f, 2.22387046e-01f, -4.06853147e-02f, -2.12384705e-02f, 1.99975580e-01f, 4.26402092e-01f, -2.11325765e-01f, 2.25432381e-01f,
  3.26779813e-01f, 1.15726441e-01f, 1.76718220e-01f, 2.37841547e-01f, 1.35293007e-01f, 2.25311011e-01f, -3.06623857e-02f, 4.57896233e-01f, -3.18648554e-02f, -2.63507012e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.87275182e-02f, -6.76403418e-02f, -1.03064358e-01f, -6.23550303e-02f, 8.12336653e-02f, 4.45392609e-01f, 4.12277505e-02f, -1.82995349e-01f, 1.17072910e-02f, 4.57022130e-01f,
  -1.14300646e-01f, 2.35443600e-02f, -3.90145108e-02f, -2.87965238e-01f, 5.12626804e-02f, -1.86990872e-01f, -5.26164845e-02f, -3.13487165e-02f, -1.58038944e-01f, 5.43181412e-02f,
  -1.22089371e-01f, 1.30494282e-01f, 5.48461139e-01f, -3.24658781e-01f, -7.82842711e-02f, -1.14669010e-01f, 2.61188269e-01f, 2.08905980e-01f, 2.44710781e-02f, -9.11457166e-02f,
  -1.23263337e-01f, 9.59023163e-02f, 1.59677207e-01f, -5.31188883e-02f, -2.49097347e-02f, 1.99330062e-01f, 1.38618007e-01f, 1.90916985e-01f, 4.14455295e-01f, 1.91131216e-02f,
  2.14960098e-01f, 1.32443279e-01f, -5.71447276e-02f, 2.51260191e-01f, -2.23327488e-01f, 1.61267236e-01f, -1.60086274e-01f, 4.59809834e-03f, 2.69937124e-02f, -1.85575724e-01f,
  -7.37010241e-02f, -1.45672485e-01f, -2.56005041e-02f, 7.62099326e-02f, 4.54576761e-01f, -2.02034160e-01f, 2.77465712e-02f, -1.29652470e-01f, -9.98531431e-02f, -1.72578335e-01f,
  -6.50995672e-02f, 2.05673039e-01f, 1.04716189e-01f, -1.93390086e-01f, -1.17327735e-01f, 5.74898012e-02f, 2.19656900e-01f, -2.88396981e-02f, 1.43592983e-01f, 7.35532716e-02f,
  4.05661672e-01f, -1.69348016e-01f, 1.01476267e-01f, -1.35590853e-02f, 3.45303752e-02f, 2.24333897e-01f, -2.21718699e-01f, 6.64605424e-02f, 5.70566617e-02f, 1.02804275e-02f,
  -1.80684641e-01f, 1.53078670e-02f, 1.44480392e-01f, -1.38846606e-01f, -9.70317945e-02f, -7.18629956e-02f, 4.36581820e-01f, -8.65881518e-02f, -1.41967669e-01f, -9.44734663e-02f,
  -2.01573029e-01f, -2.38706112e-01f, -1.65479109e-01f, 2.32805863e-01f, -7.01861158e-02f, 3.69938016e-02f, -7.00197667e-02f, -1.12580337e-01f, 9.37413424e-02f, 2.54160553e-01f,
  -1.77638531e-01f, -2.23187849e-01f, 1.66329652e-01f, 2.96093196e-01f, 5.75424246e-02f, -1.59265041e-01f, 3.97347480e-01f, -3.22043262e-02f, -1.02379218e-01f, 3.07743192e-01f,
  -2.28520259e-02f, -9.26930308e-02f, 3.97455990e-02f, -7.40749389e-02f, 1.07598148e-01f, -1.56315714e-01f, 1.32886231e-01f, 3.54142606e-01f, 2.95057327e-01f, 2.41465494e-01f,
  -3.09823334e-01f, -1.58720821e-01f, -2.99634516e-01f, 1.98768035e-01f, 1.68734133e-01f, 2.99437046e-01f, -1.38983235e-01f, -1.87362567e-01f, -2.06161827e-01f, 1.75237715e-01f,
  7.75491027e-03f, -6.43353835e-02f, -6.98052719e-02f, -2.65592158e-01f, -3.90960246e-01f, -1.27182260e-01f, -7.51032233e-02f, 1.92261208e-02f, 3.02208513e-02f, -3.76444668e-01f,
  7.20515028e-02f, -4.36779261e-01f, -7.44673610e-02f, 1.45684302e-01f, 2.20093220e-01f, 5.74221872e-02f, -2.17431113e-01f, 1.96072280e-01f, 4.91984829e-04f, -2.33370513e-01f,
  -1.11479908e-01f, 3.34494829e-01f, 1.14614129e-01f, -2.96959039e-02f, 9.16025415e-02f, 4.86452967e-01f, 5.18058278e-02f, -3.15084457e-01f, 1.76309213e-01f, 2.31739134e-01f,
  2.46273410e-02f, -1.67746648e-01f, -7.37738311e-02f, -6.25965670e-02f, -2.87905693e-01f, -5.74044846e-02f, 1.31842028e-02f, 3.13801318e-01f, -5.11621945e-02f, -5.94505593e-02f,
  3.49869192e-01f, 1.66652441e-01f, -2.91722026e-02f, 2.33875245e-01f, -1.24898925e-01f, 2.47252390e-01f, 1.35227203e-01f, 1.53799891e-01f, 1.72262102e-01f, -2.24563435e-01f,
  -5.23286015e-02f, 2.92053878e-01f, -4.52677459e-01f, 2.74756581e-01f, -1.90703757e-02f, 4.80824821e-02f, -2.97576308e-01f, 1.40818059e-01f, 1.93824783e-01f, 1.14860885e-01f,
  8.88657272e-02f, -3.67423296e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.75362006e-01f, 4.97741178e-02f, 1.04632623e-01f, -9.17047784e-02f, -4.55022353e-04f, 5.83659299e-02f, 2.65447408e-01f, -4.79079299e-02f, -1.31736219e-01f, -1.84637994e-01f,
  -1.30756214e-01f, -2.21269690e-02f, 4.18872871e-02f, -8.90636072e-02f, -1.56414300e-01f, -1.11367799e-01f, -1.67245433e-01f, -1.26400188e-01f, 7.05607906e-02f, -9.22098756e-02f,
  -1.36241555e-01f, 1.23414159e-01f, 5.18067181e-01f, -1.81806311e-02f, -3.96502251e-03f, 5.79435416e-02f, 1.69258311e-01f, -1.73544828e-02f, -8.80583376e-02f, 6.87900037e-02f,
  -1.19137160e-01f, 9.74103957e-02f, -9.49630216e-02f, -1.20237984e-01f, 1.41029619e-02f, 4.56045829e-02f, -1.48277700e-01f, -3.55670989e-01f, -2.19073996e-01f, -2.29911149e-01f,
  1.12542301e-01f, -3.49660784e-01f, 5.22897951e-02f, -8.15782994e-02f, 1.82791665e-01f, -9.45780352e-02f, 7.61753172e-02f, -3.77517263e-03f, 1.34942368e-01f, -1.49047896e-01f,
  -9.24215242e-02f, 7.25353286e-02f, -7.83370659e-02f, 1.81398690e-01f, -2.61190087e-01f, 4.21445757e-01f, 2.39136908e-02f, 1.05478123e-01f, 1.62364736e-01f, 2.23943338e-01f,
  -1.12880751e-01f, -6.38154745e-02f, 1.06556915e-01f, 2.46171102e-01f, -2.10346580e-02f, 3.91445169e-03f, 9.18813422e-02f, 3.77934784e-01f, -7.61190429e-02f, -2.14478940e-01f,
  -3.07158738e-01f, -6.59671575e-02f, 7.45355710e-03f, 3.39023262e-01f, 3.41222256e-01f, -8.78494531e-02f, 3.38653654e-01f, -2.56886631e-01f, 5.79850413e-02f, -7.69018456e-02f,
  -4.29287739e-02f, 1.37945622e-01f, -2.11300962e-02f, 4.59963053e-01f, -6.84541240e-02f, 5.25722653e-02f, 8.95273164e-02f, 3.68724614e-01f, 1.20092342e-02f, -7.30726197e-02f,
  7.70730749e-02f, 7.51278281e-01f, 6.73659518e-02f, 6.27521053e-02f, 1.02558874e-01f, 2.62860000e-01f, -1.23551264e-01f, -5.74208163e-02f, -5.94300404e-02f, 1.29034057e-01f,
  1.87744975e-01f, -1.49814159e-01f, -4.56986576e-03f, -1.50226772e-01f, -1.91745564e-01f, -2.11954582e-02f, 6.91311210e-02f, -1.26806319e-01f, -1.31457925e-01f, 9.92716327e-02f,
  1.05029959e-02f, -9.35630351e-02f, -8.40136260e-02f, 8.28596205e-02f, 4.30750176e-02f, -1.72334686e-01f, -1.06053591e-01f, -5.67646213e-02f, 2.22687885e-01f, -1.77191585e-01f,
  -1.30806625e-01f, -8.87349844e-02f, 2.54651997e-02f, -1.53475270e-01f, 2.30047405e-01f, 2.24373564e-01f, -4.07353304e-02f, -2.24090755e-01f, 6.12848885e-02f, 1.16256796e-01f,
  -7.76738748e-02f, 5.33790141e-02f, 3.47977504e-02f, 1.74962044e-01f, 1.23845138e-01f, 1.41758963e-01f, -1.48573294e-01f, -1.86223343e-01f, 5.85470311e-02f, -2.20011413e-01f,
  8.73673782e-02f, 4.62356091e-01f, -5.19546643e-02f, 1.86229318e-01f, -1.58819091e-02f, -1.83241278e-01f, 2.15090916e-01f, -2.46747166e-01f, -1.08071290e-01f, 2.70429075e-01f,
  2.72356952e-03f, -9.47175026e-02f, -2.24858612e-01f, -4.18240018e-02f, -5.79286274e-03f, 2.96266466e-01f, 2.99722821e-01f, 2.77809709e-01f, 6.78910539e-02f, -2.01464608e-01f,
  1.36624515e-01f, -1.30842566e-01f, 1.60000324e-01f, 2.50621349e-01f, -3.97630744e-02f, 1.50053605e-01f, 3.22955668e-01f, -4.23424661e-01f, 1.39162496e-01f, -3.36341709e-01f,
  6.55223951e-02f, 3.19249064e-01f, 2.55904585e-01f, -6.82839379e-02f, 2.28853628e-01f, -1.79226577e-01f, 3.35001536e-02f, 2.70027757e-01f, -8.89991671e-02f, -7.77138323e-02f,
  -7.35011846e-02f, -1.81289345e-01f, 3.41089189e-01f, 2.36167505e-01f, 3.77756834e-01f, -5.00970073e-02f, -1.04605161e-01f, -1.16449788e-01f, -3.14653039e-01f, 2.98928440e-01f,
  -5.58386892e-02f, 3.22110534e-01f, -2.47564558e-02f, -5.63618876e-02f, -9.73924175e-02f, 9.10419673e-02f, -8.63130391e-02f, 9.73266140e-02f, 5.30838557e-02f, -1.11846820e-01f,
  1.24685168e-01f, 1.61412343e-01f, -1.60821021e-01f, 5.48931956e-02f, 2.98874266e-02f, -7.89125040e-02f, 5.42060211e-02f, 8.59035924e-02f, 1.78573683e-01f, 5.15734330e-02f,
  7.39944428e-02f, 7.17940480e-02f, 1.89670861e-01f, 6.70116320e-02f, 1.41587511e-01f, -1.73360184e-01f, 6.11268133e-02f, -1.63611129e-01f, 1.84614033e-01f, 1.92490622e-01f,
  1.53607026e-01f, -4.24329229e-02f, 1.27622873e-01f, -7.90755153e-02f, -1.85775578e-01f, -1.25300378e-01f, 1.46183878e-01f, -1.08532369e-01f, -8.71551186e-02f, -3.18880588e-01f,
  -1.57082751e-01f, -1.01553211e-02f, 8.10600147e-02f, -1.19234361e-02f, 6.03871644e-02f, -3.54507685e-01f, -6.84622005e-02f, 3.10569942e-01f, -1.35093585e-01f, -2.95331161e-02f,
  -2.86301579e-02f, -1.64910257e-01f, 3.09704006e-01f, -6.63342997e-02f, 2.26374008e-02f, 1.61512479e-01f, 2.26846054e-01f, 1.82430640e-01f, -1.36801168e-01f, -1.06021799e-01f,
  2.04798102e-01f, 3.30924034e-01f, 2.39301875e-01f, 5.43550290e-02f, -1.64605737e-01f, 3.99665423e-02f, 4.78552997e-01f, 3.76622736e-01f, 2.35444620e-01f, 6.11093462e-01f,
  3.88751656e-01f, 6.27368689e-01f, 8.02863389e-02f, -5.57625620e-03f, 4.05085504e-01f, 8.61761034e-01f, 4.93972264e-02f, 2.21974235e-02f, -1.61303431e-01f, 1.20035904e-02f,
  2.41286799e-01f, -1.31815121e-01f, -1.70085624e-01f, 1.83055699e-01f, -2.33721837e-01f, 5.07958412e-01f, -1.40110180e-01f, 7.49260858e-02f, 6.28425658e-01f, -4.85967934e-01f,
  1.02182381e-01f, 1.39674053e-01f, 3.30202617e-02f, 7.51939476e-01f, -4.05143313e-02f, 1.86118230e-01f, 8.77615064e-02f, -1.47933168e-02f, 3.21048766e-01f, 1.76429823e-01f,
  -2.13270962e-01f, 1.06887043e-01f, -2.14964524e-01f, 4.20847446e-01f, 2.10177451e-01f, 2.36555636e-01f, -3.20839971e-01f, -2.83022195e-01f, 2.87410170e-01f, 5.75314105e-01f,
  -1.05772605e-02f, 6.65368855e-01f, -6.02051802e-02f, 4.31409568e-01f, 1.61847085e-01f, 3.51865180e-02f, 1.11492448e-01f, -9.28084087e-03f, 2.43379518e-01f, 2.61490375e-01f,
  9.04960334e-02f, -1.74253255e-01f, 5.35431542e-02f, 4.30649109e-02f, -1.44134164e-01f, -3.62786323e-01f, 3.41076374e-01f, 6.27381623e-01f, -9.66589227e-02f, -3.62726092e-01f,
  -1.88885719e-01f, 1.16477117e-01f, 1.40055940e-02f, 4.51804139e-02f, 4.08786125e-02f, -3.79782230e-01f, -7.25913420e-02f, 1.73439875e-01f, -3.13474625e-01f, 7.84582198e-02f,
  -1.54916570e-01f, -4.33641285e-01f, -5.23447879e-02f, 4.16815162e-01f, -2.44768366e-01f, 3.56960475e-01f, -2.03423966e-02f, 1.88270267e-02f, 2.38893911e-01f, -1.02358446e-01f,
  1.65679604e-01f, 5.84371448e-01f, 3.20706330e-02f, 2.88186580e-01f, -1.53585732e-01f, 7.52628148e-02f, 1.91457480e-01f, 2.56738514e-01f, 2.01738715e-01f, 3.14386964e-01f,
  -4.58104946e-02f, -4.99992855e-02f, 1.72308326e-01f, 1.96953461e-01f, 2.93427110e-01f, 4.19865213e-02f, -9.96352285e-02f, 1.69138983e-01f, 3.72022778e-01f, -1.03239998e-01f,
  2.21433118e-02f, -5.55527091e-01f, 3.94948691e-01f, 4.34123546e-01f, 7.17667863e-02f, 3.66345584e-01f, 1.94759414e-01f, 2.08443150e-01f, -4.00879271e-02f, -4.48433161e-02f,
  4.08637039e-02f, -1.76583856e-01f, -1.23590492e-01f, 1.52151197e-01f, 5.73461294e-01f, 1.27443314e-01f, 1.59458935e-01f, -1.66512236e-01f, -2.55383790e-01f, -1.74341291e-01f,
  8.50079805e-02f, 5.60496092e-01f, -4.64474857e-02f, -2.73446292e-01f, 1.66882887e-01f, 1.65701449e-01f, -6.64973855e-02f, -4.27705608e-02f, -4.75006513e-02f, -9.36505049e-02f,
  2.03796297e-01f, 1.90346286e-01f, -2.19580203e-01f, -3.42004895e-01f, 3.27256054e-01f, 1.63689822e-01f, 2.95746714e-01f, 2.02298045e-01f, -5.30391447e-02f, 2.27115396e-03f,
  -4.08404693e-02f, 1.74735904e-01f, 1.04037747e-01f, 2.37750001e-02f, -2.71561481e-02f, 1.20187834e-01f, 4.56069484e-02f, -7.07272887e-02f, 3.70185971e-01f, 1.29011229e-01f,
  -1.37019232e-01f, -3.99840802e-01f, 2.54466338e-03f, 1.53747156e-01f, -1.27109095e-01f, -1.63008898e-01f, 2.88442317e-02f, -1.17069989e-01f, -1.13727286e-01f, 1.60331219e-01f,
  -5.31383650e-03f, 2.88064837e-01f, -1.25927150e-01f, -1.86823845e-01f, 8.31398144e-02f, 1.72246341e-02f, -2.57220119e-01f, -8.14451575e-02f, -1.51257366e-01f, -1.63051024e-01f,
  -1.77089810e-01f, -2.02153958e-02f, 2.09315896e-01f, -9.17924866e-02f, -2.44811289e-02f, 1.23109132e-01f, 1.65709019e-01f, 1.88517664e-02f, 2.82711536e-01f, -1.19924307e-01f,
  5.94934635e-03f, 3.41455154e-02f, 2.28578478e-01f, 1.85392246e-01f, -1.29237026e-01f, 8.23543593e-02f, -1.35996163e-01f, 1.53578982e-01f, -1.00337669e-01f, 1.33699834e-01f,
  2.16973186e-01f, 5.06612733e-02f, 8.93009752e-02f, -5.42058051e-02f, -2.11055502e-02f, -2.50168949e-01f, 1.61522895e-01f, 1.78307891e-01f, -2.60726303e-01f, -2.79691309e-01f,
  1.22757487e-01f, -3.47201503e-03f, 1.25797436e-01f, -5.02518564e-02f, -9.75850597e-02f, 6.88286498e-02f, -1.51701361e-01f, 2.61751525e-02f, -7.83397630e-02f, 2.19102334e-02f,
  -1.71557873e-01f, 2.65433818e-01f, -7.69153312e-02f, 1.81952253e-01f, 2.90128201e-01f, 1.03614181e-01f, -2.03194380e-01f, 1.68448911e-04f, 4.28583240e-03f, 2.62076795e-01f,
  -2.39423871e-01f, -1.54091306e-02f, 8.53701308e-02f, -1.95426375e-01f, 4.75108065e-02f, -1.73794746e-01f, -7.55426884e-02f, 1.42230928e-01f, -1.64220944e-01f, -3.22693616e-01f,
  9.33399200e-02f, 6.00892231e-02f, 1.06939517e-01f, 3.22258957e-02f, 5.96532784e-03f, 5.73536828e-02f, -8.86531472e-02f, 2.40955856e-02f, 2.36684725e-01f, -1.05975620e-01f,
  -1.77080661e-01f, -4.04022150e-02f, -3.03266216e-02f, 3.27252209e-01f, -2.14267120e-01f, -3.13065387e-02f, -1.17437430e-01f, -8.50205775e-03f, 1.08264066e-01f, 2.33330548e-01f,
  -5.23465872e-02f, -1.21198416e-01f, -1.41180441e-01f, -1.51322097e-01f, -1.17794804e-01f, 1.75256699e-01f, -4.42534983e-02f, 3.20058763e-02f, -5.94075210e-02f, 1.37288552e-02f,
  4.32309607e-04f, 9.96818990e-02f, 7.89163113e-02f, -3.31513919e-02f, -5.29444925e-02f, -5.94426654e-02f, -6.37445375e-02f, -9.85316262e-02f, 1.24631282e-02f, 8.77258256e-02f,
  -1.35703966e-01f, -6.02650084e-02f, 1.36887565e-01f, 6.60316721e-02f, 1.72026351e-01f, 1.76086739e-01f, 1.79412346e-02f, 1.12429745e-01f, -1.68777466e-01f, -1.41037866e-01f,
  8.25509802e-02f, -1.09628625e-01f, -5.36778569e-02f, -9.88184586e-02f, -1.52816123e-03f, -3.59565113e-03f, 2.60401577e-01f, -4.20502722e-02f, 2.49717966e-01f, -4.25803289e-02f,
  -3.64059240e-01f, -3.31089139e-01f, 1.53567106e-01f, -8.92011821e-02f, -1.34216473e-01f, -1.18589409e-01f, 4.48019534e-01f, -1.28740206e-01f, -1.86563119e-01f, 2.10808534e-02f,
  1.32350147e-01f, -1.24580435e-01f, -4.30658571e-02f, 2.21425272e-03f, -1.27807990e-01f, -4.08490710e-02f, -2.88825482e-01f, 2.80261666e-01f, -1.19547412e-01f, 2.43689507e-01f,
  3.65808100e-01f, -6.61470070e-02f, -1.69717252e-01f, -3.05640697e-01f, 1.36396796e-01f, 6.70329332e-02f, -4.38659303e-02f, 1.21903466e-02f, 3.67240191e-01f, -1.34515604e-02f,
  3.16721708e-01f, 3.99636775e-01f, 2.38598987e-01f, -4.19793338e-01f, 1.42802626e-01f, -2.15478539e-01f, -4.06845480e-01f, -4.21597548e-02f, 3.32247093e-02f, -4.15274203e-02f,
  6.33489117e-02f, -4.18493360e-01f, -1.84860542e-01f, 4.79423180e-02f, 4.00088221e-01f, 4.05989438e-02f, -2.54730582e-01f, -2.62947887e-01f, 7.47659564e-01f, 9.83648226e-02f,
  1.55216306e-01f, 1.39534071e-01f, 2.29608625e-01f, -5.43902636e-01f, -2.22842372e-03f, -4.91228998e-02f, 9.29520372e-03f, 2.55570412e-01f, 3.50704253e-01f, 6.29958093e-01f,
  4.94226307e-01f, -1.13231078e-01f, 2.32694983e-01f, -6.27809986e-02f, -6.01520240e-01f, 1.57203451e-01f, 5.82185648e-02f, 6.87956274e-01f, -4.12218869e-01f, -5.72707295e-01f,
  2.59750754e-01f, -1.70890778e-01f, 1.68066621e-02f, -5.44464216e-02f, -1.18893079e-01f, 1.47929773e-01f, -5.37037365e-02f, 5.43436825e-01f, 5.06530814e-02f, -5.49275838e-02f,
  -4.74471182e-01f, -1.39449403e-01f, -1.07034713e-01f, 3.67021739e-01f, 5.51149905e-01f, 1.41504519e-02f, -4.90103886e-02f, -2.11031854e-01f, -3.87751162e-02f, 2.53149539e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  3.90442014e-02f, 8.51291344e-02f, 2.54033715e-01f, -8.71803910e-02f, 1.86416924e-01f, 2.24079862e-01f, -1.29844055e-01f, 7.05387369e-02f, 4.00567412e-01f, 6.41180128e-02f,
  9.81042609e-02f, 5.57316542e-02f, 5.02077155e-02f, -1.88536078e-01f, -6.24870770e-02f, -5.97987175e-02f, -1.21422373e-01f, 2.18231753e-01f, 2.27304012e-01f, 4.72500086e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.13812143e-02f, -2.26514354e-01f, 2.10655943e-01f, -2.58772820e-01f, -7.40357459e-01f, -2.75297016e-01f, -2.63876587e-01f, 2.30504856e-01f, 2.68257469e-01f, 1.85351118e-01f,
  1.11318216e-01f, 5.01566291e-01f, -2.79436959e-03f, 5.81120849e-02f, -6.68118715e-01f, -5.89038208e-02f, 8.11546519e-02f, 1.10812165e-01f, 1.53377771e-01f, -3.95731330e-01f,
  -6.84489667e-01f, 1.02099359e+00f, -1.44350618e-01f, 6.42666936e-01f, 3.55543941e-01f, 1.33466586e-01f, 4.43799160e-02f, -1.22260042e-01f, -1.82518288e-02f, 2.44604368e-02f,
  -3.78304571e-01f, -2.23055378e-01f, 4.14404899e-01f, -7.02213272e-02f, -6.67143762e-02f, 1.26051560e-01f, 4.00527269e-02f, 3.36991072e-01f, 2.20448405e-01f, 1.54870987e-01f,
  2.18539238e-01f, 2.10020036e-01f, -4.59810793e-01f, -4.48207885e-01f, -2.36302335e-02f, 1.15567461e-01f, -1.26972884e-01f, -5.54554118e-03f, -3.59324157e-01f, 7.78634489e-01f,
  -2.02200532e-01f, -4.33748692e-01f, 1.84971020e-01f, 2.70435870e-01f, -6.82168722e-01f, 5.56752026e-01f, 4.10208970e-01f, -3.86087894e-01f, -2.89848685e-01f, -1.76977813e-01f,
  -8.25461969e-02f, -3.09081748e-02f, 3.93209368e-01f, -4.45721090e-01f, 1.67833880e-01f, 4.11357224e-01f, 4.92685199e-01f, 7.99041241e-02f, 6.13977015e-01f, 6.74025178e-01f,
  2.75953859e-01f, 1.44852549e-01f, -2.87735134e-01f, 5.67535281e-01f, 2.35465825e-01f, 1.65470019e-01f, -1.96492627e-01f, -3.03141683e-01f, 5.50960779e-01f, -3.02782971e-02f,
  1.00736106e-02f, -3.84968698e-01f, 1.27850354e-01f, 1.20286848e-02f, 8.54814768e-01f, -2.28034765e-01f, -1.49967089e-01f, -5.71842119e-02f, -1.34853706e-01f, 2.06467174e-02f,
  -2.79230565e-01f, -2.03562230e-01f, 7.87379444e-02f, -5.73036373e-01f, -5.43890774e-01f, 2.68444419e-01f, -4.91312385e-01f, 1.26081392e-01f, 2.11346880e-01f, -1.88413039e-01f,
  3.88467729e-01f, -1.16627030e-01f, -2.99298942e-01f, -2.48770878e-01f, 8.84288456e-03f, 6.22599497e-02f, -2.84280509e-01f, 1.33320302e-01f, -2.24203095e-01f, 1.74621046e-01f,
  -6.14382178e-02f, -1.77170321e-01f, 3.64139557e-01f, -3.55638832e-01f, -5.38845034e-03f, 3.85736763e-01f, -9.96641695e-01f, 2.59296089e-01f, 4.17818457e-01f, 4.33826685e-01f,
  1.82055488e-01f, -2.16755450e-01f, -1.77956298e-01f, 4.18183148e-01f, -2.18758136e-02f, -2.36914992e-01f, -8.07533711e-02f, -4.44679916e-01f, 2.77664602e-01f, 3.82072270e-01f,
  2.08308473e-01f, -2.16077231e-02f, 2.93110535e-02f, -2.91483074e-01f, -4.28623557e-01f, 5.06292135e-02f, -4.79984373e-01f, 3.30855966e-01f, -5.68532884e-01f, 7.68310249e-01f,
  -1.10111937e-01f, -2.87520468e-01f, 8.39878246e-02f, 4.22912240e-02f, 4.87563223e-01f, -2.15130717e-01f, 1.28542319e-01f, 3.10193151e-02f, 1.49433896e-01f, 5.64136922e-01f,
  3.24709684e-01f, -2.40341708e-01f, 1.34715527e-01f, -1.51743814e-01f, -2.66538501e-01f, -1.89556867e-01f, -8.98988396e-02f, 7.39530008e-03f, -3.13650429e-01f, 3.79830822e-02f,
  -2.67100602e-01f, -5.97323537e-01f, -7.29540884e-02f, -3.35970491e-01f, 5.53195961e-02f, 4.59923446e-01f, 3.74042720e-01f, 3.00554276e-01f, 2.72993565e-01f, 6.44295812e-02f,
  -4.19027537e-01f, -1.88186299e-02f, 4.25813813e-03f, -1.26601949e-01f, -1.66925192e-02f, 2.07815655e-02f, 8.01052973e-02f, -1.47810921e-01f, 1.14264458e-01f, 4.44310009e-02f,
  7.27489769e-01f, 2.74525374e-01f, 1.10626176e-01f, 4.04537439e-01f, -4.18685347e-01f, 1.93105787e-01f, -7.93984234e-02f, -2.51878262e-01f, 3.75520554e-03f, 4.81073707e-02f,
  -2.78493732e-01f, -5.58386743e-01f, -5.35991974e-03f, -1.59545019e-01f, -2.18640059e-01f, -4.45836693e-01f, -6.60346806e-01f, -5.61269164e-01f, 2.91797429e-01f, -5.51259339e-01f,
  -1.54343441e-01f, -5.96435666e-01f, 2.73960292e-01f, -2.90558219e-01f, -1.51382685e-02f, 2.37188652e-01f, 1.87806904e-01f, 8.41138288e-02f, -3.99289936e-01f, -3.30847740e-01f,
  1.07992999e-01f, -1.73606992e-01f, -1.34635255e-01f, -1.06467597e-01f, -3.35502505e-01f, -5.05823314e-01f, 1.05155557e-01f, -1.91907939e-02f, 3.15367162e-01f, 1.30345941e-01f,
  -1.49227992e-01f, 4.50248569e-01f, -4.88245972e-02f, 1.04453444e+00f, -2.24236902e-02f, -1.06880181e-01f, -1.88642696e-01f, -5.30055203e-02f, -3.30975145e-01f, -4.02934365e-02f,
  -3.30093533e-01f, -3.93066525e-01f, -2.90082127e-01f, 5.56904674e-01f, 3.02955210e-01f, 9.41148400e-02f, -1.15702185e-03f, 6.64435267e-01f, 6.19499385e-01f, -1.11055553e-01f,
  -1.08876988e-01f, 1.96339235e-01f, -1.52489215e-01f, 1.03856333e-01f, -6.38605118e-01f, -1.59766480e-01f, 1.82542652e-01f, -1.35404006e-01f, -9.84226838e-02f, -1.54295221e-01f,
  2.51845479e-01f, 2.50918478e-01f, 1.25619635e-01f, 4.48534966e-01f, -3.42243195e-01f, -1.38111442e-01f, -2.40789220e-01f, -1.39615266e-03f, -6.22849800e-02f, 2.69754499e-01f,
  4.65943158e-01f, -3.78113538e-01f, -8.93083662e-02f, 4.72563922e-01f, 2.32316703e-01f, 2.46477753e-01f, 1.91879764e-01f, -3.72849345e-01f, 3.35209042e-01f, -6.17017448e-02f,
  2.52861887e-01f, -1.87759221e-01f, -1.08033665e-01f, 4.75058973e-01f, 6.94812536e-02f, 1.45287365e-01f, 5.28369904e-01f, -8.23627114e-01f, -1.47923991e-01f, -5.85003383e-02f,
  -5.41008830e-01f, 1.35890782e-01f, -1.57678314e-02f, 2.41425969e-02f, 3.26442756e-02f, -3.85763377e-01f, 3.22783381e-01f, -4.87948209e-01f, 3.84598166e-01f, 7.28096291e-02f,
  2.24488929e-01f, 8.59304070e-01f, 2.18155593e-01f, 5.08634448e-01f, -1.68802902e-01f, -4.61743087e-01f, -4.95829076e-01f, -2.59537473e-02f, 5.53248465e-01f, -5.41274510e-02f,
  -1.76550791e-01f, -7.31706098e-02f, 3.00620180e-02f, 1.59628004e-01f, -1.14834547e-01f, -2.98768044e-01f, -1.69057727e-01f, 1.45525545e-01f, -5.10514043e-02f, -3.18974435e-01f,
  5.73590219e-01f, -4.56331998e-01f, -1.59561068e-01f, -3.41819793e-01f, 2.77601629e-01f, -8.83287713e-02f, 1.16512135e-01f, 1.92076847e-01f, -4.52110261e-01f, 8.59198034e-01f,
  -1.28720505e-02f, -5.32329500e-01f, -4.17966247e-01f, -2.51917601e-01f, -5.38537025e-01f, 3.10318619e-01f, 1.30808204e-01f, 4.71268296e-02f, 3.33463073e-01f, -4.35242295e-01f,
  6.26429990e-02f, -1.41188934e-01f, 4.52594131e-01f, -7.03204051e-03f, -5.22368431e-01f, 3.67078811e-01f, 2.73170203e-01f, -2.15426330e-02f, -1.71782561e-02f, 3.59203845e-01f,
  -6.23671949e-01f, 1.33989140e-01f, 2.52037555e-01f, 3.75100940e-01f, 8.81332383e-02f, -1.57483831e-01f, -2.12784976e-01f, 1.31244138e-01f, -1.17003769e-02f, -3.10032051e-02f,
  6.45268917e-01f, -2.61134386e-01f, -2.58640438e-01f, 4.34570670e-01f, 1.27112895e-01f, -2.27279570e-02f, 5.52767813e-01f, -4.72352177e-01f, 3.42991680e-01f, 5.50602227e-02f,
  1.21656880e-01f, -5.72380960e-01f, 1.93357915e-01f, -1.74189925e-01f, 1.46948501e-01f, -1.84922755e-01f, -2.58489102e-01f, 4.28691320e-02f, -3.65012497e-01f, 1.18300639e-01f,
  1.37016401e-02f, -2.92423695e-01f, 3.65232795e-01f, -3.25435787e-01f, -3.47226113e-01f, -6.32704139e-01f, 2.45586596e-02f, 2.27745011e-01f, 2.06901520e-01f, 1.43514171e-01f,
  7.57565862e-03f, 2.32148126e-01f, 8.08164716e-01f, 5.90770304e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.25222579e-01f, -5.99485822e-02f, 3.74862403e-02f, -1.19658314e-01f, 7.50038102e-02f, 1.40975071e-02f, -1.51792705e-01f, -1.67372148e-03f, 6.95856735e-02f, 2.42066950e-01f,
  -2.39299268e-01f, 9.97197926e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    