/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.45893157e-01f, 2.36947522e-01f, -1.34239942e-01f, 3.46434593e-01f, 1.48078412e-01f, 1.26701947e-02f, -2.49146178e-01f, 3.17847997e-01f, 2.87886381e-01f, 2.34653167e-02f,
  1.78712197e-02f, -1.09458324e-02f, -2.65287161e-01f, 2.24855721e-01f, -1.91084206e-01f, -3.19747813e-02f, 2.22444758e-01f, 5.05023226e-02f, 1.00977294e-01f, 2.08551332e-01f,
  2.72782817e-02f, 2.47812673e-01f, -1.16978809e-01f, 2.65884221e-01f, 4.32504714e-02f, 1.15910269e-01f, 5.59734646e-03f, -2.10517704e-01f, 1.44726321e-01f, -6.95545077e-02f,
  -1.09521031e-01f, 1.02466591e-01f, 3.01864557e-02f, -7.65986815e-02f, 3.22316103e-02f, -6.51705489e-02f, -1.54102966e-01f, -2.12050229e-01f, -5.49480207e-02f, 3.08199823e-02f,
  -1.39654338e-01f, 3.18882465e-02f, 6.91847578e-02f, 3.80009748e-02f, 1.00971572e-01f, -3.21229324e-02f, -4.00865451e-02f, -3.58973183e-02f, 1.02321114e-02f, -7.71392733e-02f,
  -4.51793969e-02f, -4.38875519e-02f, 6.53185649e-04f, 6.00862913e-02f, -6.25082478e-03f, 2.82195443e-03f, -8.71277675e-02f, -6.60867617e-02f, 2.16419790e-02f, 1.36141911e-01f,
  3.76883708e-02f, -2.82443147e-02f, -3.71242650e-02f, -5.45115024e-02f, 3.56921554e-02f, -1.33300619e-02f, 3.54942419e-02f, -8.51241946e-02f, 2.09636316e-02f, -1.63779650e-02f,
  8.42036083e-02f, 3.52550484e-02f, 6.15172237e-02f, 2.12427285e-02f, 1.23559972e-02f, 4.86608818e-02f, -1.04035176e-01f, 3.31529751e-02f, 6.57406151e-02f, 6.44912347e-02f,
  -1.11407824e-01f, 2.97759678e-02f, -4.09382470e-02f, -9.25729349e-02f, -8.47996678e-03f, -4.02361676e-02f, 6.57385662e-02f, 1.00939991e-02f, -2.79160012e-02f, -8.39929953e-02f,
  7.03920871e-02f, 1.91778824e-01f, 5.39532527e-02f, 7.99345151e-02f, -3.79676111e-02f, 5.59100993e-02f, -9.95400548e-02f, 1.39623269e-01f, -3.71743850e-02f, 3.79229225e-02f,
  8.31870884e-02f, -6.00573199e-04f, 4.73676287e-02f, 2.61405911e-02f, -3.61108743e-02f, 5.82854562e-02f, -5.37277088e-02f, -1.36032077e-02f, 3.44280973e-02f, 8.62928107e-02f,
  3.09973862e-02f, -3.24299144e-05f, -9.28019814e-04f, 4.09676693e-02f, 5.05937710e-02f, -1.80689078e-02f, 1.07328266e-01f, -5.87758310e-02f, -2.49284580e-02f, 2.75307111e-02f,
  -6.42365158e-01f, -4.82977293e-02f, -2.87699610e-01f, -1.31741539e-01f, 3.33795026e-02f, 1.84036016e-01f, 1.80196449e-01f, 1.14446329e-02f, -7.77404606e-02f, 2.22941875e-01f,
  2.99530298e-01f, -2.89811902e-02f, 1.49269134e-01f, 1.59372702e-01f, -2.20032543e-01f, 1.01897456e-01f, -9.89229009e-02f, -2.86204796e-02f, -8.57609604e-03f, -1.10212699e-01f,
  -1.50583759e-01f, 3.21724474e-01f, -9.50836837e-02f, 1.39745981e-01f, -2.60555688e-02f, -1.76652148e-01f, 1.30650148e-01f, 3.63903306e-02f, 2.03066901e-03f, 3.74865159e-02f,
  1.60382718e-01f, 2.98204701e-02f, -2.80929524e-02f, -1.25742741e-02f, -2.63867658e-02f, -3.51944268e-02f, -1.33383581e-02f, 1.59249753e-02f, 3.08348518e-02f, 3.27574508e-03f,
  2.43528970e-02f, -1.48773463e-02f, 4.73666862e-02f, -1.76144224e-02f, -8.44496209e-03f, -3.67746279e-02f, -3.82836424e-02f, -7.30321109e-02f, 4.10108455e-02f, -7.89958984e-02f,
  -1.00043893e-01f, -7.44536370e-02f, -4.76782545e-02f, -1.18937166e-02f, -5.48572317e-02f, -1.44222993e-02f, 3.79153602e-02f, -4.21167091e-02f, -1.56201860e-02f, -6.41270503e-02f,
  4.88293283e-02f, -1.20361028e-02f, -2.84672976e-02f, 1.50205698e-02f, 3.87225002e-02f, 1.51846549e-02f, 6.34203404e-02f, 5.87729476e-02f, -5.14770821e-02f, 3.54316086e-02f,
  -2.48947442e-02f, -5.57883307e-02f, 1.05095804e-01f, -5.10559157e-02f, -2.76742745e-02f, 1.05649345e-02f, -3.59630212e-02f, 7.80571904e-03f, -9.62806121e-02f, 1.95709392e-02f,
  4.45669442e-02f, -5.14315218e-02f, 2.94545852e-02f, 3.36893201e-02f, 9.64504704e-02f, -5.23319095e-02f, 4.86177765e-02f, -1.01649918e-01f, 2.72324849e-02f, -1.16137937e-02f,
  2.92004440e-02f, 9.88941044e-02f, 2.51830779e-02f, 3.33404653e-02f, 1.32077970e-02f, -2.12099701e-02f, 1.18503151e-02f, -5.04801869e-02f, -4.58387583e-02f, 1.15291560e-02f,
  -3.64616811e-02f, 3.78731079e-02f, 6.67550322e-03f, -4.88590542e-03f, 2.01811711e-03f, -2.77774893e-02f, 8.22391734e-02f, 1.82751324e-02f, 2.20402498e-02f, -1.58811379e-02f,
  5.89876212e-02f, 5.74763305e-02f, 1.14457691e-02f, 1.69757567e-02f, 5.98131791e-02f, -5.09106671e-04f, -5.63104125e-03f, -1.23146117e-01f, -2.21122671e-02f, 2.62297839e-02f,
  -2.17328817e-01f, -5.96347302e-02f, -3.12251393e-02f, -1.63863733e-01f, 4.44535874e-02f, -1.32333234e-01f, -8.95219445e-02f, -1.95524424e-01f, -2.95241475e-02f, 1.38610825e-01f,
  9.04896855e-02f, -1.32762745e-01f, 1.46057189e-01f, -5.66075481e-02f, 2.36911140e-03f, 3.41788650e-01f, -2.20253728e-02f, -7.99804647e-03f, 4.76135723e-02f, -1.66913375e-01f,
  -1.17057890e-01f, 9.74023789e-02f, 9.09342542e-02f, -4.88561988e-02f, -9.18581933e-02f, -1.30422384e-01f, 3.38065587e-02f, 9.57929567e-02f, -1.55806825e-01f, -2.66896538e-03f,
  -1.04553893e-01f, -8.88453573e-02f, -1.45353628e-02f, 8.70101228e-02f, -5.07534966e-02f, 1.25846341e-01f, -3.26626934e-02f, 1.20765053e-01f, 4.52642515e-02f, 4.12560180e-02f,
  1.01525836e-01f, -6.34498447e-02f, -3.08619514e-02f, 5.11311255e-02f, 5.78391030e-02f, 1.75576713e-02f, -1.03354063e-02f, -2.91806906e-02f, -7.94282649e-03f, -6.39436580e-03f,
  -6.10061288e-02f, -7.73984939e-02f, 6.40892312e-02f, 4.89808619e-02f, 1.23975100e-02f, 8.71618977e-04f, 2.15911117e-04f, 5.54515086e-02f, -1.10790124e-02f, -1.15518786e-01f,
  1.00905284e-01f, -5.06120697e-02f, 7.46315047e-02f, -7.09241927e-02f, -4.06615846e-02f, 3.26963775e-02f, 3.39798294e-02f, -1.84356887e-02f, 1.73146110e-02f, -8.02132040e-02f,
  -6.76714778e-02f, 1.47901755e-03f, 2.45855283e-02f, 2.54950281e-02f, -1.60703324e-02f, -4.98183221e-02f, 4.88309897e-02f, -6.03520460e-02f, -2.29570474e-02f, 7.65429984e-04f,
  2.47752778e-02f, 6.85226498e-03f, 3.28652076e-02f, 3.44885513e-02f, 2.46404894e-02f, -7.01909233e-03f, 1.83240417e-03f, 4.64618504e-02f, 1.81902871e-02f, -3.90018374e-02f,
  -1.12939633e-01f, -9.80912820e-02f, -1.50909100e-03f, -2.28411686e-02f, -1.57652814e-02f, 6.82019219e-02f, 6.26840144e-02f, 2.32702382e-02f, 1.06221726e-02f, 1.09532215e-02f,
  -3.02669797e-02f, 2.83037666e-02f, -1.21693075e-01f, -2.60937400e-02f, 1.23849018e-02f, 1.63752306e-02f, -8.52657855e-02f, 2.47168541e-02f, -1.37729719e-01f, -5.73540777e-02f,
  -2.50556488e-02f, 3.26606520e-02f, 4.46295254e-02f, -2.78376713e-02f, 1.29003316e-01f, -7.40167052e-02f, -4.88000587e-02f, 2.50679180e-02f, 2.49933638e-02f, 3.32544744e-02f,
  -2.16454029e-01f, -1.27900526e-01f, -3.44018862e-02f, -1.78404406e-01f, 2.78067499e-01f, -2.69579947e-01f, -3.16116631e-01f, 3.22613232e-02f, 1.30461574e-01f, -7.42656514e-02f,
  -3.05112507e-02f, -7.39130974e-02f, -5.82732707e-02f, -8.33421275e-02f, -3.58403802e-01f, -2.05477133e-01f, -2.62084842e-01f, -1.12191312e-01f, 1.69453308e-01f, 8.35750811e-03f,
  -1.02948718e-01f, -7.42179677e-02f, -1.78805470e-01f, 2.58649290e-01f, 8.66597742e-02f, 9.10230950e-02f, -1.27035603e-01f, 1.03842206e-01f, -2.60449704e-02f, -2.57480219e-02f,
  -4.97046337e-02f, -8.74881074e-02f, 2.23382283e-02f, 1.00993440e-01f, -3.26314522e-03f, 3.31734791e-02f, -2.50588153e-02f, 1.11276153e-02f, 3.85871604e-02f, 1.42203048e-01f,
  -3.26430015e-02f, 1.14080325e-01f, -1.99475028e-02f, 1.07875094e-01f, -6.27057850e-02f, 6.56865761e-02f, 1.06722191e-01f, 6.20834045e-02f, 3.29857208e-02f, 8.32375512e-03f,
  1.97635628e-02f, -7.45959114e-03f, -8.01631808e-02f, 2.18683723e-02f, -3.47124450e-02f, 1.44954612e-02f, 6.47258088e-02f, 9.11968574e-03f, -5.25437184e-02f, 5.00056818e-02f,
  6.83531910e-02f, 2.76669301e-02f, -2.57938430e-02f, 1.92528311e-02f, 2.46279649e-02f, 3.78172137e-02f, -2.98205763e-02f, -4.75065634e-02f, 1.74593627e-02f, 1.04148798e-02f,
  -1.84338149e-02f, -7.62621462e-02f, 4.61629331e-02f, 2.38660593e-02f, -5.60083874e-02f, -1.69426780e-02f, -1.30292326e-02f, 2.73225140e-02f, -2.44621448e-02f, 5.76000735e-02f,
  -2.71073915e-02f, -2.08883584e-02f, -8.37339163e-02f, -5.28965034e-02f, 1.23980148e-02f, 1.55133037e-02f, 2.66836938e-02f, 7.62643963e-02f, -4.29442190e-02f, -8.03096294e-02f,
  -3.07354540e-01f, -2.85318494e-01f, -5.70399910e-02f, -3.48181017e-02f, 5.12657454e-03f, -1.39377015e-02f, 3.87643613e-02f, 7.73259252e-02f, -7.27220103e-02f, -6.67969184e-03f,
  6.20579943e-02f, -4.22533788e-03f, 7.55054178e-03f, -3.45280804e-02f, -7.81718343e-02f, 2.34516850e-03f, -1.15880482e-01f, -1.24311328e-01f, -1.33285731e-01f, -4.47356813e-02f,
  -8.91975164e-02f, -2.68893386e-03f, 8.06318074e-02f, -2.74649058e-02f, -3.20884399e-02f, 4.03060066e-03f, 2.27935649e-02f, 7.99113289e-02f, 5.81315570e-02f, -1.51093453e-02f,
  -2.93361455e-01f, 1.93605214e-01f, 1.02477804e-01f, -1.12174019e-01f, 6.92938864e-02f, -4.82721120e-01f, -3.92379850e-01f, 1.24398001e-01f, -6.48439676e-02f, 3.28027494e-02f,
  -1.96406767e-01f, 2.29805261e-01f, -1.16404463e-02f, -3.28131080e-01f, -4.62308884e-01f, -1.25184163e-01f, -3.86857182e-01f, -7.93017596e-02f, 2.00461224e-02f, -1.06523028e-02f,
  2.01060846e-02f, -1.07223943e-01f, 8.65053199e-03f, 2.10963354e-01f, 5.12954220e-02f, 2.82197624e-01f, 1.31889269e-01f, 1.81786403e-01f, 8.02429393e-03f, -3.58012207e-02f,
  -1.15483329e-01f, -1.31596979e-02f, 1.22994155e-01f, -8.20289738e-03f, -6.98991492e-02f, 4.28776592e-02f, -1.79301389e-02f, 3.26131955e-02f, 2.01981738e-02f, 1.83115937e-02f,
  5.48999347e-02f, -8.45448002e-02f, -5.84381223e-02f, 3.93257812e-02f, -2.77815908e-02f, 2.63839755e-02f, 1.29568251e-02f, -2.76877079e-02f, 2.43886951e-02f, -3.56598981e-02f,
  2.54540090e-02f, -6.85930848e-02f, -4.55193035e-02f, -5.06292507e-02f, 2.74096411e-02f, -7.68953264e-02f, -1.21839000e-02f, 3.79561558e-02f, -1.39928777e-02f, -1.49952630e-02f,
  -6.58291206e-02f, -4.07583266e-02f, 5.64469621e-02f, 4.56104614e-02f, 1.28335943e-02f, 5.11792786e-02f, -7.99351651e-03f, -2.83280984e-02f, 7.75163993e-02f, -3.30270007e-02f,
  -2.22997349e-02f, 1.83772221e-02f, -4.00800742e-02f, 4.17267792e-02f, -4.21204045e-02f, 7.56331980e-02f, 1.33330720e-02f, 2.75346208e-02f, -6.71497583e-02f, 1.06663862e-02f,
  2.53225695e-02f, -4.00699228e-02f, 1.16061829e-01f, 1.22214239e-02f, -4.00260985e-02f, -4.50951885e-03f, 1.56112909e-02f, 3.33148241e-02f, 9.80667770e-02f, -2.19121464e-02f,
  -9.31308940e-02f, 1.25138924e-01f, 3.96689959e-02f, 1.11509778e-03f, -8.85653961e-03f, 5.06210178e-02f, -8.78346264e-02f, -2.45135538e-02f, 1.60726905e-02f, -2.26797257e-02f,
  -5.59982508e-02f, 1.42362257e-02f, 7.67043829e-02f, 1.33501012e-02f, 3.51789482e-02f, -3.12387161e-02f, -6.21162690e-02f, 5.17426543e-02f, 6.29252419e-02f, 3.29684727e-02f,
  -6.85163657e-04f, -4.33530957e-02f, 2.80628391e-02f, -1.58373627e-03f, -2.51851268e-02f, 3.40000689e-02f, -3.81563604e-03f, 3.58774490e-03f, -3.84659432e-02f, -2.77460553e-02f,
  5.99175334e-01f, -3.12979162e-01f, -2.39630416e-01f, 1.65555611e-01f, 2.10751668e-01f, -2.40413368e-01f, -6.87182695e-02f, 2.71830410e-02f, 9.50900242e-02f, -1.07754260e-01f,
  1.40952215e-01f, -3.33255380e-02f, -7.21646622e-02f, -9.42723379e-02f, 2.38653570e-01f, -1.04525819e-01f, 4.07665484e-02f, -2.96600722e-02f, 2.62611709e-03f, 6.40022987e-03f,
  7.65132979e-02f, 5.38656004e-02f, -5.05991280e-02f, -1.07201211e-01f, 3.67118069e-03f, -1.18445821e-01f, 1.71843037e-01f, -7.91594163e-02f, 1.77113730e-02f, -2.29392219e-02f,
  -1.20000757e-01f, -1.40666619e-01f, -2.52630059e-02f, -8.02832022e-02f, 3.31910141e-02f, 4.54736990e-04f, -2.77090892e-02f, -1.73699334e-02f, 4.51091230e-02f, 1.79230119e-03f,
  -4.92755137e-03f, -6.08747406e-03f, -1.41431615e-02f, -4.06505093e-02f, 6.29700050e-02f, -3.29985060e-02f, 4.17017452e-02f, 3.79229076e-02f, -9.36889201e-02f, 6.20570220e-02f,
  -6.56556413e-02f, -6.04085103e-02f, 5.19817844e-02f, -2.01698113e-02f, 5.37175462e-02f, -6.83283135e-02f, -5.89070171e-02f, -2.30684951e-02f, 4.50877892e-03f, 1.49310399e-02f,
  3.78262512e-02f, -1.35457683e-02f, 2.89496803e-03f, 6.64151087e-03f, -1.89789382e-04f, -1.28689287e-02f, 1.54994316e-02f, 3.85929132e-03f, 4.44824137e-02f, -1.26762865e-02f,
  5.56076616e-02f, 5.90514429e-02f, -1.67634729e-02f, 2.34460160e-02f, 5.17434813e-02f, -1.06935631e-02f, 7.07395449e-02f, -8.54300186e-02f, 5.01778759e-02f, -2.05553020e-03f,
  -8.67982432e-02f, 2.63920240e-02f, -5.31773306e-02f, 1.02235898e-02f, -6.57081082e-02f, 9.27524269e-02f, -2.41993857e-03f, -5.80639765e-02f, 1.78297535e-02f, 4.92982119e-02f,
  4.05226974e-03f, -1.08483449e-01f, -3.33913900e-02f, -1.34837441e-02f, -5.13739958e-02f, 7.66157806e-02f, -3.77871804e-02f, 2.67262030e-02f, -1.03007048e-01f, 4.48224507e-02f,
  4.51086834e-03f, 4.42938432e-02f, 2.43435390e-02f, 8.00894946e-02f, 1.34755646e-05f, -2.61818133e-02f, -5.09877913e-02f, -6.90700370e-04f, 6.41682073e-02f, -9.90946137e-05f,
  3.83261889e-02f, 4.31998521e-02f, -1.30570382e-02f, 5.50200604e-02f, 7.16755316e-02f, 1.98466070e-02f, 2.00721473e-02f, -5.42743579e-02f, -8.65790993e-03f, -9.11277253e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.70005679e-01f, -2.47954085e-01f, 2.50607550e-01f, 5.05543530e-01f, 3.74023020e-01f, -1.35326579e-01f, 3.91722232e-01f, 1.77975774e-01f, 4.03184563e-01f, -4.49776202e-01f,
  -4.15561497e-02f, -1.07782580e-01f, -9.97118056e-02f, 1.65245086e-01f, 2.22685635e-01f, -4.92166821e-03f, 1.94249868e-01f, -6.55980259e-02f, 2.10261598e-01f, 1.72454447e-01f,
  3.43797565e-01f, 1.01648510e-01f, 2.69276112e-01f, -1.71549216e-01f, 3.20226938e-01f, 4.97504361e-02f, -1.73013151e-01f, 8.74753371e-02f, -2.38095716e-01f, -1.09700665e-01f,
  -1.88418061e-01f, 2.32002959e-01f, 1.25009134e-01f, -6.03434071e-02f, -2.54397877e-02f, -1.53790377e-02f, -1.02214620e-01f, -1.41944289e-01f, 1.77165106e-01f, -1.12827523e-02f,
  -1.56684488e-01f, 7.83266649e-02f, 1.24415187e-02f, -8.57061986e-03f, 3.53950188e-02f, 3.25546227e-02f, 1.19630106e-01f, 3.98363136e-02f, 3.49963307e-02f, 1.06960610e-01f,
  1.76841557e-01f, -4.36810069e-02f, 1.42901495e-01f, -2.73961931e-01f, 1.09423600e-01f, 1.42365473e-03f, -1.46727487e-01f, -3.04728211e-03f, -9.01876986e-02f, 1.53528471e-02f,
  2.17093211e-02f, 5.28758243e-02f, 2.60317838e-03f, 5.35733476e-02f, 5.66352420e-02f, 1.32056132e-01f, -1.87473670e-02f, -8.39613527e-02f, 6.80900812e-02f, -6.50511310e-02f,
  1.96419787e-02f, 6.25139615e-03f, 2.59165708e-02f, -9.85633358e-02f, -1.56761948e-02f, 6.55652210e-02f, -1.33406684e-01f, -8.58605579e-02f, -5.47919832e-02f, 9.23033282e-02f,
  -1.23636909e-02f, -9.25317407e-02f, 9.21452567e-02f, 8.18329025e-03f, -2.22078171e-02f, -2.21935045e-02f, 1.07714105e-02f, 1.30626597e-02f, 1.41680449e-01f, 4.21406142e-03f,
  -4.48671162e-01f, -2.68648416e-01f, -1.80117078e-02f, -5.19325174e-02f, -2.33696222e-01f, -8.85517001e-02f, 2.57947221e-02f, -5.19777611e-02f, -1.02553278e-01f, 1.06408775e-01f,
  4.12516110e-02f, -1.02849700e-01f, -2.03201517e-01f, -5.05102389e-02f, -5.18703554e-03f, 9.81385410e-02f, 2.42118798e-02f, -8.71912017e-02f, -7.71105960e-02f, -4.73769195e-02f,
  5.32191135e-02f, 8.67191516e-03f, 5.13621792e-02f, 1.08921558e-01f, -2.77148169e-02f, -9.70920920e-02f, -2.60189995e-02f, -5.05822226e-02f, -1.01596035e-01f, -5.86293899e-02f,
  -4.27898057e-02f, 1.09717101e-01f, 8.04053023e-02f, 6.13600910e-02f, 5.36430180e-01f, 4.64621305e-01f, 3.35171342e-01f, 2.31884316e-01f, 6.13074601e-01f, -1.09437563e-01f,
  -1.37422964e-01f, -1.00907505e-01f, -2.92760909e-01f, -4.86439466e-02f, 4.76004109e-02f, -1.74349248e-02f, 3.29077691e-01f, 7.52447024e-02f, 2.15453550e-01f, 1.26482427e-01f,
  2.12545782e-01f, 1.65874674e-03f, -3.63307327e-01f, -1.96356297e-01f, -1.61153749e-01f, -8.91578197e-02f, -3.12885731e-01f, 1.64302089e-03f, -2.93650985e-01f, 1.23881482e-01f,
  5.04258648e-02f, -5.74036948e-02f, -2.66846091e-01f, -1.18031345e-01f, 5.44281825e-02f, -4.00705598e-02f, -6.27224296e-02f, 2.23327596e-02f, 6.08737953e-03f, 2.90972013e-02f,
  -7.47039095e-02f, -1.12436377e-01f, 2.17282232e-02f, 9.25993547e-02f, 5.86847030e-02f, -6.94222525e-02f, -7.31521323e-02f, -6.67880699e-02f, -8.09223801e-02f, -5.91110550e-02f,
  -1.25213817e-01f, -5.15084118e-02f, 6.19760528e-02f, 1.13868155e-01f, -7.88048133e-02f, 4.33003344e-02f, 1.24051549e-01f, -2.39913911e-02f, -2.35511223e-04f, 2.44800560e-02f,
  -4.90262285e-02f, 1.17602475e-01f, -2.39782166e-02f, -1.15081772e-01f, -3.19391377e-02f, -5.68762384e-02f, -4.68828082e-02f, -4.35935659e-03f, 8.97490680e-02f, -2.96450164e-02f,
  1.50464308e-02f, -2.31673680e-02f, 1.41016617e-01f, 3.38531807e-02f, 1.19236335e-01f, 4.12857719e-02f, 2.97648534e-02f, -3.58823538e-02f, 3.61752734e-02f, -6.15040772e-02f,
  7.48660713e-02f, 5.65921655e-03f, -5.08362018e-02f, 2.48905737e-02f, -9.30268690e-02f, -7.65229166e-02f, 1.89983323e-02f, 2.52266545e-02f, -5.86671522e-03f, 9.15521104e-03f,
  2.62667090e-01f, 5.09896100e-01f, 4.29189019e-03f, -5.86679764e-02f, 8.86449241e-04f, 7.06584984e-03f, 6.78377301e-02f, 1.41106602e-02f, 9.44544449e-02f, 4.28168066e-02f,
  1.01158120e-01f, 6.29988685e-02f, 6.62479922e-02f, -7.30713978e-02f, -3.25098671e-02f, 1.18944228e-01f, -8.82909894e-02f, 9.77205187e-02f, 5.49953990e-02f, -9.92224142e-02f,
  -6.43002838e-02f, 8.92020315e-02f, 4.88611609e-02f, 7.25596994e-02f, -2.08649989e-02f, -1.47941783e-01f, 2.33286157e-01f, -7.12147951e-02f, -3.46747525e-02f, 1.36667669e-01f,
  -1.64948165e-01f, -4.86562908e-01f, 3.22694808e-01f, -1.63951010e-01f, 1.33691013e-01f, 3.14097822e-01f, 3.74332845e-01f, -4.67790037e-01f, -6.00004613e-01f, -3.47983629e-01f,
  6.40778104e-03f, 2.27052033e-01f, -2.15069596e-02f, -5.82212098e-02f, 7.46360242e-01f, -2.73058452e-02f, -6.93937317e-02f, 1.81436658e-01f, -8.31940696e-02f, -1.44535705e-01f,
  -9.49747935e-02f, 6.66144341e-02f, 2.58352697e-01f, -1.52049646e-01f, -2.28642728e-02f, -1.19983725e-01f, 7.37408772e-02f, 2.68441379e-01f, 1.25005186e-01f, 4.09380913e-01f,
  -8.08186233e-02f, -4.23013389e-01f, -4.73641716e-02f, -1.06509134e-01f, -1.74845204e-01f, -2.08941437e-02f, 1.67502508e-01f, 2.79675484e-01f, -2.92069335e-02f, 1.70512665e-02f,
  4.32264134e-02f, -4.53208126e-02f, -2.81453654e-02f, 9.71678048e-02f, -1.11647427e-01f, -1.65490448e-01f, -1.03552222e-01f, -1.24164172e-01f, -5.41627705e-02f, 7.70636275e-02f,
  -2.56867241e-02f, 5.61022758e-02f, -2.04717722e-02f, 1.86622683e-02f, 6.00426123e-02f, -9.96923745e-02f, 6.58027828e-02f, 1.57235339e-01f, -8.91132951e-02f, -7.83945248e-02f,
  1.62028940e-03f, 1.07157782e-01f, -1.86447445e-02f, -1.59286186e-02f, -1.52872037e-02f, 8.14458355e-02f, 2.47958805e-02f, 2.67845374e-02f, 4.10909541e-02f, 1.69429760e-02f,
  -6.84360042e-03f, 9.50830150e-03f, -1.14482857e-01f, -1.21687382e-01f, 1.88655499e-02f, -5.14061972e-02f, 1.54094860e-01f, -3.06983497e-02f, -1.02569656e-02f, 7.13866577e-02f,
  -6.64358586e-02f, 6.10638363e-03f, 1.01462230e-01f, 3.35375778e-02f, -8.65294635e-02f, 1.00090623e-01f, -7.26286247e-02f, -2.84899361e-02f, -4.03037034e-02f, 2.02540293e-01f,
  -3.58541399e-01f, -4.90661204e-01f, 9.08452831e-03f, -3.58718969e-02f, 5.29671162e-02f, -1.11267418e-01f, -7.53434002e-02f, -1.00935176e-01f, -8.32940489e-02f, -1.23623591e-02f,
  -6.86461804e-03f, 1.92334075e-02f, -7.97010809e-02f, -3.24269454e-03f, 7.60610923e-02f, -1.01587050e-01f, 3.01255006e-02f, -3.76933143e-02f, 7.87302561e-04f, -2.95608565e-02f,
  -2.25499645e-02f, -3.85699347e-02f, 7.92856663e-02f, -2.36084405e-02f, -3.59986462e-02f, 1.54125672e-02f, -7.31766447e-02f, 2.37172041e-02f, 8.14009756e-02f, 3.84993814e-02f,
  1.80499539e-01f, -6.51420414e-01f, -5.44986665e-01f, 3.15370634e-02f, 5.28795660e-01f, 1.83819592e-01f, -1.07660808e-01f, 1.60978973e-01f, -2.38495961e-01f, -4.62696463e-01f,
  2.52454225e-02f, -2.29987577e-01f, -5.02331555e-01f, 1.10023059e-01f, 3.08082849e-01f, -4.39739317e-01f, 2.86612362e-01f, 5.07387444e-02f, -6.73165396e-02f, 2.52640084e-03f,
  2.22014830e-01f, 5.32114148e-01f, 8.75287578e-02f, 3.09751272e-01f, 7.18518123e-02f, 7.19843805e-02f, 1.02806561e-01f, -2.63172150e-01f, 2.02672109e-01f, 1.27656594e-01f,
  6.43230304e-02f, -9.55319032e-02f, 8.36369023e-02f, 5.48350811e-02f, -1.04399428e-01f, 6.97285086e-02f, 1.44360196e-02f, -7.58069428e-03f, 5.31738102e-02f, -2.86661331e-02f,
  -1.25653714e-01f, 9.57899615e-02f, 9.32287872e-02f, 7.88772330e-02f, 1.03907563e-01f, 1.63080901e-01f, 5.38872704e-02f, -9.29749161e-02f, 5.75938337e-02f, -1.27378821e-01f,
  -1.33328721e-01f, 4.47004847e-02f, -1.04085788e-01f, 7.45677799e-02f, -8.26324746e-02f, 1.01281121e-01f, -9.80032422e-03f, -1.39006436e-01f, 4.23420686e-03f, 4.02590632e-02f,
  1.01970591e-01f, -2.09471449e-01f, -8.46236013e-03f, 3.65691073e-02f, -8.98384899e-02f, -1.87417641e-02f, 5.53957671e-02f, 4.71275933e-02f, -1.13058887e-01f, -3.94940525e-02f,
  -2.34181769e-02f, 6.20875731e-02f, -1.18534304e-02f, 7.55169317e-02f, 1.54225871e-01f, 8.64920169e-02f, 3.15909013e-02f, 1.02647804e-01f, -5.75054437e-02f, 5.89003116e-02f,
  4.76709530e-02f, 1.20068580e-01f, -5.52488640e-02f, 3.80592570e-02f, 1.06768213e-01f, -7.16327131e-02f, -7.53510222e-02f, -7.91497752e-02f, -5.41517437e-02f, 3.59931812e-02f,
  -6.98082373e-02f, -5.16648114e-01f, -6.12765811e-02f, 9.69670936e-02f, 8.54210369e-03f, -9.51759424e-03f, -9.76600870e-02f, 5.63946776e-02f, -4.20479253e-02f, -1.61178976e-01f,
  -1.39315836e-02f, 4.04302627e-02f, -4.98887487e-02f, 1.15055613e-01f, 4.97012362e-02f, -4.43996824e-02f, 2.45589968e-02f, -2.12332513e-02f, 1.47873551e-01f, 5.71431182e-02f,
  -7.67190605e-02f, -4.65723909e-02f, -5.36645390e-02f, 1.02987304e-01f, 9.66176540e-02f, -4.87318970e-02f, 1.32899895e-01f, -4.07423191e-02f, 4.78866510e-02f, -4.33041640e-02f,
  -6.02905452e-01f, 1.51936635e-01f, -6.06740639e-02f, -5.57754159e-01f, 2.75055677e-01f, -2.71242540e-02f, -2.68247128e-01f, 2.78924316e-01f, -2.83407569e-01f, 1.61885396e-01f,
  2.86390241e-02f, -3.38518441e-01f, 3.14051241e-01f, -4.48014021e-01f, -4.66901600e-01f, -1.19806118e-01f, -4.81366873e-01f, -3.41697216e-01f, -5.43002114e-02f, -2.02584341e-01f,
  -2.55171597e-01f, -2.23251373e-01f, -2.47414038e-01f, 3.53344113e-01f, -1.59938827e-01f, 3.57799195e-02f, 1.98232234e-02f, 3.85679811e-01f, -7.83869699e-02f, 8.58146474e-02f,
  -2.63899285e-02f, 9.83193442e-02f, 6.12492003e-02f, 1.07643299e-01f, 1.58144385e-02f, 3.95136094e-03f, -6.08125888e-02f, 6.40993863e-02f, -3.92659754e-02f, 1.33022461e-02f,
  -3.26817371e-02f, -8.03769231e-02f, -8.67124349e-02f, 4.29713652e-02f, -5.73399961e-02f, 2.71785557e-02f, -2.69991066e-02f, -2.46128459e-02f, 2.77677048e-02f, -5.18703870e-02f,
  3.12279295e-02f, -9.89443362e-02f, -1.08627558e-01f, -1.14072114e-01f, -1.12586163e-01f, 8.16257820e-02f, -1.46433607e-01f, 2.01847665e-02f, -1.38550207e-01f, -6.53742105e-02f,
  -4.98427227e-02f, 2.46103629e-02f, 1.95739195e-02f, 3.35299335e-02f, -7.96163455e-03f, 1.19418465e-02f, -3.77148278e-02f, -5.01464196e-02f, -3.16318832e-02f, 8.38941038e-02f,
  -1.05270669e-01f, 1.31801479e-02f, 2.89472118e-02f, -1.29187539e-01f, -1.37822837e-01f, -3.59034836e-02f, -7.03802407e-02f, 7.24362358e-02f, -2.24621907e-01f, -6.65810239e-03f,
  6.42851368e-02f, 2.04160083e-02f, 1.03705958e-03f, -1.77675057e-02f, 9.09269303e-02f, -9.52880643e-03f, 1.68269090e-02f, 6.06326340e-03f, 5.30913472e-02f, -7.78825581e-02f,
  4.93469201e-02f, 1.29781328e-02f, 1.34812176e-01f, 8.01731572e-02f, 4.43330780e-02f, -4.44777869e-03f, -4.84888516e-02f, -1.43035769e-01f, 4.87757176e-02f, 5.85953817e-02f,
  2.23072544e-02f, -3.49039324e-02f, -1.10622784e-02f, -6.34779409e-03f, -1.43276285e-02f, -3.95091772e-02f, -5.37688918e-02f, -8.37758090e-03f, -1.34001136e-01f, -3.20264623e-02f,
  -6.49656132e-02f, 3.36545482e-02f, -1.02123633e-01f, -4.92794402e-02f, 8.65649581e-02f, -5.36677837e-02f, -1.96777489e-02f, -2.51453128e-02f, -4.35593836e-02f, -4.97690439e-02f,
  -1.48751708e-02f, -3.51095587e-01f, -4.91778195e-01f, -2.41751745e-01f, 2.67844200e-01f, -6.37014117e-03f, -4.87749279e-01f, -1.10995263e-01f, -5.22916257e-01f, 6.23215660e-02f,
  1.36166468e-01f, -2.82314777e-01f, -5.37333727e-01f, 1.27484664e-01f, -8.56635273e-02f, -4.09348905e-01f, 2.83356786e-01f, 1.52121067e-01f, -2.25099504e-01f, -8.14823732e-02f,
  -2.02212557e-01f, 4.99866098e-01f, -3.03213060e-01f, 4.86593068e-01f, 9.83082429e-02f, 8.92533362e-02f, 4.30477947e-01f, -4.63212021e-02f, 4.50435936e-01f, 3.28896582e-01f,
  5.65096103e-02f, -2.43614748e-01f, -5.20737879e-02f, -4.35023047e-02f, -9.44304243e-02f, 1.14338316e-01f, 1.60792142e-01f, 6.04245402e-02f, -2.94604991e-02f, -1.23834856e-01f,
  9.24733281e-02f, 3.64742801e-02f, 4.62738872e-02f, 4.72245961e-02f, -3.39780040e-02f, 7.18583241e-02f, -2.44587854e-01f, 4.63044345e-02f, -1.79170325e-01f, -2.02671528e-01f,
  -2.44668648e-01f, -8.83379802e-02f, 1.15517154e-01f, 9.09264479e-03f, -1.22597374e-01f, -1.44370459e-02f, 2.57466105e-03f, -1.83794480e-02f, 1.07818998e-01f, 2.40082070e-02f,
  3.18888016e-03f, 1.41029835e-01f, -1.15063339e-01f, 5.55220284e-02f, -7.61366114e-02f, 7.79067427e-02f, 2.31945030e-02f, 4.91100252e-02f, -1.35046439e-02f, -1.04172625e-01f,
  -2.47575585e-02f, -1.14270076e-01f, 3.53952236e-02f, 1.50754834e-02f, -3.44482879e-03f, 8.81944895e-02f, 4.98273633e-02f, 4.42922823e-02f, -7.01052547e-02f, 1.85125414e-02f,
  1.10115195e-02f, 4.65816967e-02f, 1.54983196e-02f, 4.22699377e-02f, 4.01136093e-03f, -3.33703868e-02f, 1.54720426e-01f, -6.51844144e-02f, 2.05830298e-02f, -1.92374140e-02f,
  -8.31534564e-02f, 6.77560493e-02f, -1.47582740e-01f, -1.53525721e-03f, 3.16340625e-02f, 1.08217895e-01f, 6.42230287e-02f, -6.28319606e-02f, -2.51962524e-02f, -1.57905743e-02f,
  4.08891924e-02f, 7.56121203e-02f, 1.32051378e-01f, 8.75479355e-03f, 1.00717880e-01f, 4.54650708e-02f, 8.50541592e-02f, 8.60621706e-02f, 5.47393933e-02f, 6.23690784e-02f,
  1.59814849e-01f, 1.42815174e-03f, 5.70640750e-02f, -1.90694574e-02f, 1.39245495e-01f, 2.54853014e-02f, 1.67982787e-01f, -5.63158207e-02f, -5.00251539e-02f, -2.14180201e-02f,
  3.68554085e-01f, 2.58237332e-01f, -4.84779894e-01f, -1.51203632e-01f, -1.01630017e-01f, 1.51525348e-01f, -1.52003064e-04f, -6.78602904e-02f, -2.51058310e-01f, 3.98459107e-01f,
  3.11891228e-01f, 6.19158037e-02f, 9.56601501e-02f, 4.35630202e-01f, 1.00099303e-01f, -4.90138307e-02f, 2.89252102e-01f, 1.64485589e-01f, -1.60970986e-01f, 3.49753499e-01f,
  -4.43924144e-02f, 4.62231636e-01f, -9.88579094e-02f, 5.27486242e-02f, 4.33859169e-01f, -1.93099484e-01f, 3.07127506e-01f, -3.34607452e-01f, 4.56711426e-02f, 3.70264053e-02f,
  6.10606223e-02f, 9.76974294e-02f, 1.41557893e-02f, 4.25740937e-03f, 8.60945135e-02f, 1.16873808e-01f, -3.63647267e-02f, -4.69428785e-02f, -1.17656872e-01f, 6.92361370e-02f,
  3.04779038e-02f, 2.83116158e-02f, -5.98869435e-02f, -4.10276614e-02f, 3.74971777e-02f, -1.03616938e-01f, -1.18368596e-01f, -1.08062662e-01f, -1.38920918e-01f, 1.08505867e-01f,
  -8.15633014e-02f, 1.16189513e-02f, -1.22141112e-02f, -1.23684064e-01f, -1.28295943e-01f, -3.57579552e-02f, -8.91302079e-02f, 2.51495931e-03f, 1.80551261e-02f, 5.50281890e-02f,
  1.54466987e-01f, 5.81577495e-02f, 1.21792950e-01f, -1.13233954e-01f, 9.90938470e-02f, -1.34711089e-02f, -3.14599164e-02f, -4.54299711e-02f, -1.16243273e-01f, 1.44988626e-01f,
  -1.58893585e-01f, -1.09002106e-01f, 4.63388041e-02f, -7.84420371e-02f, 1.41932905e-01f, 3.19201648e-02f, -8.59165471e-03f, -5.22936285e-02f, -1.33417994e-01f, -5.18599153e-02f,
  -3.67758572e-02f, 7.81606883e-02f, 3.51159498e-02f, -1.57510936e-02f, -1.12011014e-02f, 2.98560760e-03f, 9.86485928e-02f, 1.11873418e-01f, -1.98015854e-01f, 2.99894041e-03f,
  8.62348005e-02f, 1.68469459e-01f, -7.32158944e-02f, -8.59675035e-02f, -3.62612158e-02f, 1.58689052e-01f, -2.83278879e-02f, 7.51737133e-02f, 3.00657330e-03f, 5.17779514e-02f,
  1.81616873e-01f, -1.23905480e-01f, 2.32456736e-02f, -1.83083136e-02f, -1.42856270e-01f, 1.52426019e-01f, 7.14446530e-02f, -1.34507820e-01f, -3.90570201e-02f, 8.56138170e-02f,
  -2.85417195e-02f, 3.46192457e-02f, 7.00119836e-03f, -4.47628908e-02f, -8.09106603e-02f, 8.03136006e-02f, 8.98561403e-02f, -2.93010604e-02f, 2.42233593e-02f, -6.05522357e-02f,
  -3.03757727e-01f, 3.65017176e-01f, -1.18908808e-01f, 3.05927068e-01f, -1.53589532e-01f, -6.36726618e-02f, 2.80869636e-03f, 2.47694492e-01f, -1.58074141e-01f, 2.80610710e-01f,
  3.24641883e-01f, -3.61129977e-02f, 1.41430095e-01f, 5.60086787e-01f, 2.44307563e-01f, 3.35671872e-01f, 4.50512081e-01f, 2.66950637e-01f, 2.15330683e-02f, 1.71710834e-01f,
  1.94642559e-01f, 4.16768283e-01f, 4.08829004e-01f, 1.78779542e-01f, 3.35920125e-01f, 2.55718380e-02f, 2.12495014e-01f, -5.77972680e-02f, 3.71531546e-01f, 5.89779504e-02f,
  1.39398262e-01f, 1.59254879e-01f, -8.23688880e-02f, -1.61083162e-01f, 5.89787103e-02f, -2.08586939e-02f, -8.31078887e-02f, -1.28761202e-01f, -1.16581149e-01f, 1.16237313e-01f,
  -1.20673545e-01f, 2.41787657e-02f, 9.34807360e-02f, -2.95520909e-02f, -1.42043978e-01f, -6.28906786e-02f, -1.09266117e-02f, -4.95909946e-03f, -1.87065043e-02f, -1.47108845e-02f,
  -7.52983615e-02f, -2.13406906e-02f, 1.05518200e-01f, 1.53000593e-01f, -6.85194368e-03f, -4.63367961e-02f, 2.53877416e-02f, -9.71393194e-03f, 5.34402095e-02f, 7.10118935e-02f,
  -1.22665636e-01f, -6.16851868e-03f, -6.91974536e-02f, 1.37178414e-02f, -6.11707680e-02f, 6.19863253e-03f, 1.87167786e-02f, 5.09429760e-02f, -5.54857254e-02f, 2.58071646e-02f,
  7.15141892e-02f, 3.66906412e-02f, -2.39249994e-03f, 6.44711107e-02f, 7.75782838e-02f, -5.46174273e-02f, -1.04687348e-01f, 1.07470311e-01f, -4.64335456e-03f, 1.26149297e-01f,
  2.00629402e-02f, 1.34315714e-02f, 8.01284090e-02f, -2.60359067e-02f, -1.05603725e-01f, -6.68970449e-03f, 1.25323296e-01f, 8.11986849e-02f, 7.63918236e-02f, -8.31765011e-02f,
  2.16202721e-01f, 4.44315434e-01f, -4.12548855e-02f, -5.15539758e-02f, -4.86342944e-02f, -5.89542165e-02f, 6.82704747e-02f, 7.70872086e-02f, 3.43329012e-02f, 1.13982476e-01f,
  -8.87607876e-03f, 3.80939059e-02f, 9.18200612e-03f, -4.72194850e-02f, -1.87827982e-02f, 9.64084268e-02f, 9.65632647e-02f, 4.09536920e-02f, 1.33136585e-01f, 3.78614776e-02f,
  3.31202857e-02f, 3.01509630e-04f, 3.62277813e-02f, 5.52079752e-02f, -1.82604243e-03f, 1.52287990e-01f, -8.61508250e-02f, -1.17071912e-01f, 1.23717159e-01f, 1.20975330e-01f,
  -3.83677967e-02f, 1.65258884e-01f, 2.53691897e-02f, -3.74374270e-01f, 1.51414037e-01f, 1.48888305e-01f, -6.80128336e-02f, 1.19163632e-01f, -2.28300378e-01f, 2.68680960e-01f,
  -1.39529556e-01f, 5.85010536e-02f, -2.21227244e-01f, -4.46547955e-01f, -4.92403120e-01f, -4.18858737e-01f, -2.69571334e-01f, -5.22879921e-02f, -1.91083029e-01f, 1.15103245e-01f,
  -1.09383255e-01f, -3.71727049e-01f, -8.92000049e-02f, 4.64552604e-02f, 2.42616042e-01f, 2.84973770e-01f, 6.68369755e-02f, 9.11127776e-02f, 1.86110303e-01f, -1.81188643e-01f,
  -1.35814935e-01f, -1.32233053e-01f, 1.76201612e-01f, 3.07222437e-02f, 1.33707359e-01f, 2.86143124e-01f, 1.62108690e-01f, -1.25993878e-01f, -4.07445021e-02f, 3.19647305e-02f,
  2.53875647e-03f, 1.12187937e-02f, -8.34714398e-02f, -6.32898659e-02f, 6.63993508e-02f, -8.06058850e-03f, -5.59713952e-02f, 1.70208469e-01f, 2.35955939e-02f, -3.38182598e-02f,
  -7.24031404e-02f, 9.49574038e-02f, 1.51809648e-01f, -2.31833421e-02f, -7.83175379e-02f, 1.89381819e-02f, 1.49071291e-01f, 9.82884541e-02f, 1.46800950e-01f, -2.63622273e-02f,
  1.34661542e-02f, 8.63483027e-02f, -1.04744121e-01f, -2.00900882e-02f, -1.19982302e-01f, 1.20333489e-03f, -1.01612635e-01f, 2.97639199e-04f, -1.61001720e-02f, 1.10140130e-01f,
  1.83391862e-03f, 8.65956489e-03f, -1.39952734e-01f, 2.08100095e-01f, -6.49742968e-03f, -4.88576889e-02f, 1.06465317e-01f, -3.91233303e-02f, 2.18923092e-02f, 7.01075885e-03f,
  -8.78064856e-02f, -6.69955416e-03f, 3.41711566e-02f, 9.98325273e-02f, -1.81683034e-01f, -7.49433041e-02f, 9.06437784e-02f, -1.85475114e-03f, -9.70220417e-02f, 5.45534454e-02f,
  5.33798449e-02f, -4.60353009e-02f, -2.02175844e-02f, -1.04698099e-01f, -3.35707143e-02f, 1.27359875e-03f, -3.75686139e-02f, -4.81916629e-02f, -5.32468781e-02f, -2.87894043e-03f,
  1.95213258e-01f, 1.29676953e-01f, 1.82307944e-01f, -8.46793205e-02f, -5.03349565e-02f, 3.29739228e-02f, -9.41306818e-03f, 6.44244999e-02f, 2.27741554e-01f, 2.62528397e-02f,
  1.65980130e-01f, 1.29093289e-01f, -3.13524567e-02f, 3.77471792e-03f, 5.85640222e-02f, 6.90580308e-02f, 1.11716084e-01f, 2.87440568e-02f, -9.32749286e-02f, 3.82680260e-02f,
  8.45928714e-02f, 3.55230182e-01f, 3.25531423e-01f, 5.63380599e-01f, 2.86743627e-03f, -6.18139565e-01f, -3.60702783e-01f, 5.82345277e-02f, 2.89741773e-02f, -1.73732474e-01f,
  -8.33843946e-02f, 3.43531013e-01f, -3.34905058e-01f, 3.66810709e-01f, -2.25823760e-01f, -3.58979464e-01f, -6.30416274e-02f, -1.34395227e-01f, 3.93203944e-02f, 5.95938265e-02f,
  -2.45437995e-02f, 1.61146924e-01f, 1.42909110e-01f, 2.32637599e-01f, 1.56274110e-01f, 3.95437598e-01f, 1.32105440e-01f, 4.60277237e-02f, 3.08463603e-01f, 4.40760143e-02f,
  -2.06372306e-01f, 2.21187457e-01f, 1.42129108e-01f, -3.04761473e-02f, -8.13604519e-02f, -8.42499882e-02f, -1.54414084e-02f, 6.62361234e-02f, 6.31332174e-02f, 1.72160994e-02f,
  -1.43440500e-01f, -2.76632756e-02f, 1.68039814e-01f, 7.58107156e-02f, 2.38077585e-02f, 2.70303160e-01f, 8.75381902e-02f, 2.12898497e-02f, 1.43705070e-01f, 4.62718718e-02f,
  9.14176404e-02f, -1.35892415e-02f, 6.46587610e-02f, 2.04161461e-02f, 2.12288499e-02f, -4.77350084e-03f, 7.63486922e-02f, 6.76460331e-03f, 7.36377910e-02f, 9.98717770e-02f,
  2.62839533e-02f, -1.99868623e-02f, 5.75038008e-02f, 1.15831070e-01f, 3.08029726e-02f, 1.55068061e-03f, 1.74759421e-02f, -4.68432382e-02f, 1.40800970e-02f, -1.07507862e-01f,
  -4.58049071e-05f, 5.73543347e-02f, 2.48369258e-02f, -6.03167713e-02f, 5.58755100e-02f, 1.14880554e-01f, -4.24750010e-03f, -9.03250501e-02f, -1.77276522e-01f, -3.18732932e-02f,
  9.13781375e-02f, -8.36039856e-02f, 9.09798443e-02f, -7.95251131e-02f, 4.15445166e-03f, -2.56204419e-02f, 3.23698409e-02f, 1.00065060e-01f, 5.72276935e-02f, 2.79634986e-02f,
  -4.52735245e-01f, 1.12961203e-01f, 2.36203093e-02f, -7.71107748e-02f, 5.54457866e-03f, -3.51730138e-02f, 9.51720700e-02f, -2.44420636e-02f, -3.44657712e-03f, -1.32330626e-01f,
  -7.56560192e-02f, -5.13235033e-02f, -2.27666572e-01f, -7.79566467e-02f, -1.33978605e-01f, -3.50523852e-02f, -1.10566095e-01f, 6.85073854e-03f, 1.14305891e-01f, 2.73347162e-02f,
  1.17845066e-01f, -1.52500644e-01f, 2.55586840e-02f, 3.84868756e-02f, -9.77773815e-02f, 4.83476371e-02f, 4.96706627e-02f, 1.01625860e-01f, 4.13404740e-02f, -6.23752885e-02f,
  -3.00275415e-01f, 2.75797993e-01f, -3.23851709e-03f, 1.01281263e-01f, 1.52578941e-02f, -5.22890449e-01f, -3.75368476e-01f, 2.50733256e-01f, -1.43958509e-01f, 1.04403570e-01f,
  7.90178329e-02f, -3.29764515e-01f, 2.84849316e-01f, -2.51598299e-01f, -2.70727664e-01f, -1.98580220e-01f, -2.59025246e-01f, -3.60611618e-01f, -6.79515675e-02f, 2.85055250e-01f,
  -8.16680491e-02f, 1.33337319e-01f, 4.49688323e-02f, 3.32846552e-01f, -5.53429238e-02f, 3.56559068e-01f, 5.75581431e-01f, 2.06228405e-01f, 2.77554274e-01f, 1.65787444e-03f,
  -1.68467432e-01f, 1.16296157e-01f, -1.21601000e-02f, -1.07129380e-01f, 1.06187403e-01f, 2.16863607e-03f, -5.04702926e-02f, -6.68651611e-02f, -9.06798989e-02f, -7.73926452e-02f,
  6.43558875e-02f, -5.76307438e-03f, -4.56751511e-02f, 3.41468342e-02f, -6.97569028e-02f, -2.29316261e-02f, -5.02015390e-02f, -1.06257491e-01f, -1.32258385e-01f, -3.95162851e-02f,
  2.87104566e-02f, 3.07536731e-03f, -7.68970884e-03f, 9.28465649e-02f, 1.01962350e-01f, 2.22492088e-02f, 1.01531900e-01f, 2.86629237e-03f, -8.65133405e-02f, -3.80399427e-03f,
  8.42047781e-02f, -6.39007241e-02f, -6.49498496e-03f, -1.61849201e-01f, -2.65382100e-02f, -5.49328253e-02f, -1.16908796e-01f, 3.19686756e-02f, 5.60996681e-02f, 4.52412888e-02f,
  7.98111260e-02f, 9.31082740e-02f, -8.85981768e-02f, 2.32063476e-02f, 8.72895643e-02f, -4.66761291e-02f, 5.14972210e-02f, 9.87117365e-02f, 1.84334535e-02f, 3.66662964e-02f,
  9.60541144e-03f, -3.04916184e-02f, -4.53224145e-02f, 1.45506598e-02f, -1.62424892e-01f, 1.05957478e-01f, 6.29867315e-02f, -8.45451429e-02f, -4.29647369e-03f, 6.54830113e-02f,
  4.00551856e-02f, 4.92704660e-01f, 3.92647162e-02f, 9.62480344e-03f, -3.48672434e-03f, -8.74053240e-02f, -1.12935632e-01f, 7.59797618e-02f, 6.15181290e-02f, 1.27797723e-02f,
  1.54250428e-01f, -7.34346686e-03f, -6.44219220e-02f, -1.44257769e-01f, 1.90194361e-02f, 1.50655732e-01f, 1.42978460e-01f, 3.39928158e-02f, 8.56114551e-02f, 8.55966136e-02f,
  1.55298784e-01f, 3.60570922e-02f, -4.70731892e-02f, -3.24387588e-02f, 9.03705359e-02f, 5.99477589e-02f, 5.63182384e-02f, 8.56530294e-02f, 1.83099389e-01f, 4.55849245e-02f,
  2.59872556e-01f, 2.85472333e-01f, 1.01566643e-01f, 1.17538191e-01f, -3.27613682e-01f, -2.09523559e-01f, -5.31724840e-02f, -2.01783553e-01f, 3.97716969e-01f, 4.81322967e-02f,
  -3.27796668e-01f, 4.48262900e-01f, -7.81880245e-02f, -1.37543082e-01f, 9.20494869e-02f, 2.76840866e-01f, 1.80700392e-01f, 1.76145077e-01f, 1.52841568e-01f, -5.38942143e-02f,
  1.23582138e-02f, -2.68018246e-01f, -1.09586969e-01f, -3.24910551e-01f, -3.37468028e-01f, 6.88891783e-02f, -2.23305210e-01f, -1.14435814e-01f, -2.17641681e-01f, -4.32601012e-03f,
  -1.32397011e-01f, 8.64539370e-02f, 2.68849488e-02f, 5.83040714e-02f, -2.52967048e-02f, -6.26553372e-02f, 3.30076553e-02f, 2.63794418e-02f, 2.76782792e-02f, -3.75569798e-04f,
  2.08807006e-01f, 5.99992462e-02f, 8.88291746e-02f, -2.00525369e-03f, 8.89436714e-03f, 1.51740024e-02f, 6.28573149e-02f, -5.50586171e-02f, -3.03665102e-02f, -1.74752902e-02f,
  -1.71533704e-01f, -7.74667226e-03f, -6.63101748e-02f, 8.18988532e-02f, 1.39362276e-01f, 7.69143105e-02f, 1.34294257e-01f, 4.30190787e-02f, -3.94303575e-02f, 1.81779206e-01f,
  9.45049375e-02f, 4.17947061e-02f, -1.02121092e-01f, -1.77456900e-01f, -1.22834876e-01f, -5.11226840e-02f, -1.66983660e-02f, -7.03699738e-02f, 3.08684651e-02f, 8.82152095e-03f,
  -2.05312222e-02f, -1.28966069e-03f, 3.21183540e-02f, -3.36189866e-02f, -2.57741231e-02f, 2.65974514e-02f, 2.06203517e-02f, -6.01560660e-02f, 8.06211606e-02f, -8.13520327e-03f,
  -5.80419600e-02f, 9.84734893e-02f, -6.50203079e-02f, -3.97172496e-02f, -5.34395427e-02f, -4.32151780e-02f, 2.95152646e-02f, -3.58194709e-02f, 3.04975063e-02f, -1.39001459e-01f,
  8.81679058e-02f, 2.06913128e-01f, 1.18980385e-01f, 8.74181017e-02f, 5.14542721e-02f, 1.97393522e-02f, 8.71253163e-02f, 1.08604051e-01f, 1.18650779e-01f, 1.70943129e-03f,
  4.25892696e-02f, 8.98160562e-02f, 6.83021396e-02f, -2.88163424e-02f, -3.95426247e-03f, -9.64698270e-02f, 1.06151685e-01f, 1.10168075e-02f, 9.24708694e-02f, -7.78940693e-03f,
  -4.11369652e-02f, -3.65326391e-03f, 1.15235940e-01f, -5.05007665e-05f, 6.59869462e-02f, 5.42089269e-02f, -8.15325379e-02f, 1.09385557e-01f, 2.75088791e-02f, -3.84382234e-04f,
  -5.26722312e-01f, 3.75751287e-01f, -4.68841195e-02f, -3.93082470e-01f, -1.52480761e-02f, -2.58972406e-01f, -2.03074232e-01f, 1.62141174e-02f, -1.22859977e-01f, -8.83164480e-02f,
  -2.37706423e-01f, 3.11700162e-02f, 1.90070376e-01f, -3.22604575e-03f, -1.11417070e-01f, 1.30446821e-01f, -2.47016817e-01f, -5.93029484e-02f, 1.49812013e-01f, -2.44124353e-01f,
  3.21010351e-02f, -7.74182901e-02f, -6.32915273e-02f, 8.71254653e-02f, -1.05853476e-01f, -2.66348850e-02f, -8.31984356e-02f, 7.69339129e-02f, -4.83534820e-02f, 1.87846094e-01f,
  -4.05791998e-01f, -3.97773892e-01f, -3.57898831e-01f, -2.41721168e-01f, -1.65757149e-01f, -7.23429024e-02f, -1.55686557e-01f, 3.93379256e-02f, -1.26476422e-01f, -6.20285980e-02f,
  -4.32500895e-03f, 5.79315871e-02f, -6.11812808e-02f, 8.74330103e-02f, 1.82292759e-02f, -2.75402027e-03f, 1.04949325e-01f, -4.45107669e-02f, -6.33171201e-02f, 2.01489374e-01f,
  9.64920446e-02f, 8.68346244e-02f, -8.16163123e-02f, -5.94796194e-03f, 8.23976025e-02f, -8.16806555e-02f, 8.72433931e-03f, -2.09448487e-02f, -3.42593342e-02f, -5.94125465e-02f,
  -1.47844600e-02f, -1.60922445e-02f, -8.46018493e-02f, -1.60796754e-02f, 4.86033298e-02f, 4.70753387e-02f, 7.39310915e-03f, 7.15727881e-02f, -1.03907198e-01f, -3.77178863e-02f,
  -8.93553346e-02f, 2.12916471e-02f, -1.17250107e-01f, -1.11063689e-01f, -1.33071439e-02f, -3.08060478e-02f, -3.68134677e-02f, 3.56597267e-02f, 6.82795495e-02f, -1.45598436e-02f,
  -3.68702076e-02f, 3.63406427e-02f, -8.49154778e-03f, -7.24899992e-02f, -6.92813918e-02f, 5.91223389e-02f, -2.72458419e-02f, -9.94018000e-03f, -1.13065131e-02f, -7.47670466e-03f,
  -5.79416335e-01f, -4.46172774e-01f, -6.34324178e-02f, -1.69407964e-01f, 2.44239364e-02f, -3.10567487e-02f, -1.49131939e-02f, -1.69742815e-02f, -6.32082075e-02f, -4.01246510e-02f,
  -7.24805146e-02f, -4.51056706e-03f, -9.93620045e-03f, -4.28588092e-02f, 9.07270759e-02f, 1.83765739e-02f, -3.13159600e-02f, -6.32385984e-02f, -1.53919026e-01f, 2.86515523e-03f,
  1.10493843e-02f, -2.04386450e-02f, 1.89709011e-02f, -8.78164545e-02f, -4.63301614e-02f, -1.04504779e-01f, 3.06841526e-02f, 8.54503736e-02f, -3.91865298e-02f, 8.91711563e-02f,
  -8.19144249e-01f, 5.63201249e-01f, -2.57261693e-01f, -2.76853498e-02f, 6.03194460e-02f, 3.76386285e-01f, 1.01005509e-01f, 1.47650287e-01f, -1.11116022e-01f, 2.58236855e-01f,
  9.17762369e-02f, -2.29433015e-01f, 1.44365737e-02f, 4.05356467e-01f, -1.83819205e-01f, 3.66672277e-01f, 2.90283114e-01f, 8.93981755e-02f, 4.78412993e-02f, -7.11959749e-02f,
  -8.70087668e-02f, 3.86358887e-01f, 1.03317298e-01f, 2.28118613e-01f, -1.26104310e-01f, -2.30118200e-01f, -1.35371953e-01f, -1.62970275e-02f, 1.47802770e-01f, 1.37640208e-01f,
  -3.02480072e-01f, -5.34742713e-01f, -1.85613737e-01f, -1.81814864e-01f, -7.94843882e-02f, -1.31290838e-01f, -8.55926648e-02f, -5.62641360e-02f, -4.16047946e-02f, 7.51026049e-02f,
  -1.00023478e-01f, 6.14066888e-03f, 2.49454426e-03f, -9.22941417e-03f, 5.76086715e-03f, 4.29680236e-02f, 1.68223649e-01f, 3.17797437e-02f, 2.38197055e-02f, 1.10771179e-01f,
  1.24535032e-01f, 9.84558910e-02f, 5.26658557e-02f, 7.58569539e-02f, 7.08407238e-02f, 3.61914113e-02f, -7.41945431e-02f, -2.82904208e-02f, 1.13273524e-01f, 1.80056517e-03f,
  3.80627103e-02f, -8.02789330e-02f, 1.27310324e-02f, -8.45693401e-04f, 1.00476453e-02f, 1.00364417e-01f, -5.52165955e-02f, -2.80742738e-02f, 4.41447124e-02f, 5.93470074e-02f,
  8.08935612e-02f, -2.98145358e-02f, -5.08446023e-02f, 3.65218446e-02f, 3.34799290e-02f, -6.47974163e-02f, -1.35855734e-01f, -4.28480729e-02f, 8.29014108e-02f, 2.39477470e-03f,
  -1.18430465e-01f, -9.96227041e-02f, 8.87970626e-02f, 3.51010710e-02f, -2.35619443e-03f, -4.39474508e-02f, -2.16158610e-02f, 6.21183366e-02f, 4.17142473e-02f, -2.71878242e-02f,
  -2.77304083e-01f, -4.03016090e-01f, 3.03995963e-02f, 7.73137063e-02f, -6.23966306e-02f, 9.38340202e-02f, -9.59460884e-02f, 1.79293118e-02f, -1.07018091e-02f, -2.19529439e-02f,
  -4.96873297e-02f, -1.19019896e-01f, -5.71356341e-02f, -1.60046294e-02f, -7.81804472e-02f, 1.42906085e-01f, -8.97707418e-02f, -8.03118497e-02f, 5.59587926e-02f, 3.51082198e-02f,
  -5.91797791e-02f, -5.48329689e-02f, -3.33382413e-02f, 6.51366413e-02f, -1.25562828e-02f, -3.31020206e-02f, -7.39614964e-02f, 2.82779485e-02f, 2.00175233e-02f, 4.79736514e-02f,
  -9.58995707e-03f, 5.01813702e-02f, -3.29012305e-01f, -2.31579527e-01f, 3.75827998e-02f, -5.45370758e-01f, -3.28449786e-01f, -2.44610399e-01f, -5.54471314e-02f, 3.10388893e-01f,
  -2.03478217e-01f, 2.34315693e-01f, 9.73614398e-03f, -4.94539201e-01f, -7.49126136e-01f, -2.40416050e-01f, -5.16352236e-01f, -8.12462568e-02f, -6.56956211e-02f, -2.86095273e-02f,
  -4.75087874e-02f, -2.69843221e-01f, -4.05471981e-01f, -4.95749265e-02f, -4.58357595e-02f, 2.14064494e-01f, 1.21260591e-01f, -2.35023648e-02f, -1.28955513e-01f, -8.37213695e-02f,
  -1.77968383e-01f, 1.63634345e-01f, 8.80025849e-02f, -9.98737291e-02f, -1.47695661e-01f, 7.15392176e-03f, 3.15005258e-02f, -2.80271731e-02f, -3.35961841e-02f, -1.48434807e-02f,
  1.23946987e-01f, -3.57343778e-02f, -3.17883156e-02f, -1.66264120e-02f, 1.48155361e-01f, 2.84783114e-02f, -6.09839261e-02f, -2.07712222e-02f, 7.66803026e-02f, -2.12418586e-02f,
  -7.37628117e-02f, 6.02926128e-02f, 5.35854027e-02f, 4.40620072e-02f, -5.34887761e-02f, 9.22747143e-03f, -7.48920813e-02f, -2.12128056e-04f, 1.57025278e-01f, -2.19627135e-02f,
  4.78375852e-02f, -1.45074064e-02f, -4.80769910e-02f, -5.82473259e-03f, 2.69560795e-02f, 6.58306032e-02f, 5.45952693e-02f, 1.15183145e-01f, 6.79719448e-02f, -3.39520574e-02f,
  -1.04685940e-01f, 7.97822624e-02f, -4.50778939e-02f, -1.14254523e-02f, -3.81425582e-02f, -2.52035586e-03f, -6.69204025e-03f, -4.26280238e-02f, -5.39511442e-02f, -9.79121476e-02f,
  1.11270748e-01f, -6.90146163e-02f, 5.74702695e-02f, 1.60275444e-01f, -8.83463472e-02f, -1.64978355e-02f, 1.10850446e-02f, 8.45636874e-02f, -1.42661538e-02f, 1.70276482e-02f,
  -5.48572317e-02f, 1.01612620e-01f, -1.42221600e-01f, 4.83819805e-02f, 1.10558085e-02f, 4.19832617e-02f, -1.98462963e-01f, -5.77235483e-02f, -2.32035834e-02f, -8.14014152e-02f,
  2.46973541e-02f, 9.88551751e-02f, 9.03339777e-03f, 7.87971020e-02f, -3.02251168e-02f, -1.95688158e-01f, 3.22304852e-02f, 1.36880502e-01f, -5.99946715e-02f, 6.53571859e-02f,
  1.69739708e-01f, 9.14993733e-02f, 3.38964574e-02f, 9.46471617e-02f, -1.24274893e-02f, 8.04883167e-02f, 1.68991019e-03f, -7.13021979e-02f, 5.27161546e-02f, 1.69714503e-02f,
  -6.36582613e-01f, 1.70110408e-02f, -4.16109711e-01f, 1.39707014e-01f, -3.11956495e-01f, -4.24327165e-01f, -1.73840355e-02f, -2.61328727e-01f, 7.15986639e-02f, 3.24131012e-01f,
  3.61529022e-01f, -1.13996588e-01f, 2.04130411e-01f, 2.01073706e-01f, -3.82143348e-01f, 4.00325239e-01f, -7.84033015e-02f, 1.97953165e-01f, -1.61607459e-01f, -2.69472867e-01f,
  -1.98287413e-01f, 1.47694036e-01f, 1.37024857e-02f, -1.69545591e-01f, -3.28992665e-01f, -1.57503009e-01f, 1.48032725e-01f, -3.37051064e-01f, 1.65232196e-02f, -1.10347256e-01f,
  -3.69501919e-01f, -1.53847843e-01f, 3.17753339e-03f, -8.61875564e-02f, -1.24598399e-01f, -2.26552542e-02f, -5.53259961e-02f, -3.38094160e-02f, 3.40006426e-02f, -9.93844569e-02f,
  -5.19534610e-02f, -6.61967173e-02f, 4.19525355e-02f, 4.77574654e-02f, -1.54703110e-01f, -4.48317491e-02f, -8.58225599e-02f, -1.29568344e-02f, -6.87628984e-02f, -9.09785256e-02f,
  -1.52733959e-02f, -6.20710105e-02f, 5.90140149e-02f, 1.46636680e-01f, -1.02687240e-01f, 6.11670762e-02f, 9.11068469e-02f, -5.59168458e-02f, -1.74309582e-01f, -7.08690286e-02f,
  -4.69337292e-02f, 1.70512170e-01f, 5.99173978e-02f, 2.45897155e-02f, -7.00265989e-02f, 1.93085670e-02f, -8.35601054e-03f, 9.68299583e-02f, -2.82305721e-02f, 1.07917590e-02f,
  -3.49500291e-02f, -5.81306964e-02f, -3.74157727e-02f, 1.52271306e-02f, 3.17267925e-02f, 1.23789430e-01f, -5.25971036e-03f, -6.55470565e-02f, 3.37842070e-02f, 2.42598560e-02f,
  7.91155770e-02f, -3.70206200e-02f, 5.47396541e-02f, 5.61045930e-02f, -1.31561369e-01f, 4.14142124e-02f, 2.41312124e-02f, -5.27533330e-02f, 1.04833007e-01f, -1.15927242e-01f,
  -4.79271531e-01f, -4.76378024e-01f, 1.08492807e-01f, -8.27038363e-02f, -2.95849964e-02f, -3.84065472e-02f, 9.00798365e-02f, -1.66578978e-01f, -8.76242220e-02f, -1.40097693e-01f,
  6.34776726e-02f, 1.32687809e-02f, -8.59023929e-02f, 5.38181253e-02f, -1.21864490e-02f, 7.32633024e-02f, 5.58675900e-02f, -9.09839291e-03f, -5.30550666e-02f, -9.60516855e-02f,
  -3.70550677e-02f, 1.39881158e-02f, -3.98642384e-02f, -2.37874202e-02f, 5.75287268e-02f, 5.00518829e-02f, -7.31881931e-02f, 2.81556267e-02f, -1.65842503e-01f, -2.62231678e-02f,
  1.05486423e-01f, -2.74149090e-01f, -6.27400279e-02f, -3.25848132e-01f, 4.48610000e-02f, -3.19608480e-01f, -2.10814565e-01f, -2.60078967e-01f, -3.16687405e-01f, -4.11569089e-01f,
  -3.02828580e-01f, 8.39612782e-02f, 3.02365601e-01f, -4.15343434e-01f, 3.82777393e-01f, 3.69955897e-01f, -3.25186521e-01f, -7.30523691e-02f, 6.95395544e-02f, -1.87079936e-01f,
  -7.82463793e-03f, -2.52983034e-01f, 2.13255569e-01f, -1.72741145e-01f, -2.04843462e-01f, -1.58408597e-01f, 2.07772497e-02f, 1.69245183e-01f, -4.11964566e-01f, 2.18533333e-02f,
  -1.12120762e-01f, 1.37140319e-01f, 1.47431225e-01f, 1.52378842e-01f, 1.85088739e-02f, 4.18091379e-02f, 1.00863911e-01f, 1.61349863e-01f, -3.81853175e-03f, -1.50827575e-04f,
  4.81527485e-02f, 2.70577706e-02f, -1.71436355e-01f, 6.09609447e-02f, -1.36358008e-01f, -8.90349224e-02f, -1.67619046e-02f, -3.63403670e-02f, 3.29405069e-03f, 2.35182226e-01f,
  5.24590500e-02f, 5.61764278e-02f, -6.30034730e-02f, -4.52584140e-02f, -4.38441671e-02f, -1.67812020e-01f, 7.04529211e-02f, 8.95621106e-02f, -3.34647996e-03f, -1.14026926e-01f,
  6.71428367e-02f, 8.57741684e-02f, 1.11446232e-01f, 2.04246510e-02f, -3.61486524e-02f, -4.88606207e-02f, 1.03470989e-01f, 6.41639978e-02f, -4.17663008e-02f, -3.55319842e-03f,
  -1.19720444e-01f, 1.48906689e-02f, 1.03920594e-01f, -3.57254408e-02f, -1.41222715e-01f, 1.22481205e-01f, 7.05694705e-02f, 9.94292349e-02f, -2.09312916e-01f, -9.70915407e-02f,
  2.94845626e-02f, -4.32585217e-02f, 8.17369297e-02f, -7.96660706e-02f, -2.43238211e-02f, -3.49889733e-02f, 7.18850195e-02f, 1.11227758e-01f, -6.23107739e-02f, 4.28175926e-02f,
  -8.66502523e-02f, -1.22173928e-01f, 2.63280831e-02f, 2.64984015e-02f, 1.16915461e-02f, 2.77020205e-02f, 1.21859387e-01f, -1.87577263e-01f, -2.86402069e-02f, 3.72737646e-02f,
  -2.15777546e-01f, -8.45227158e-04f, -8.93254653e-02f, -5.26396930e-02f, -7.04868659e-02f, -9.37172398e-02f, 2.08942220e-02f, 1.11397907e-01f, 1.95282698e-02f, -7.67971128e-02f,
  3.41063552e-02f, 1.26050249e-01f, 1.00611977e-03f, -2.04588342e-02f, -3.46545950e-02f, -6.55696588e-03f, 9.70068574e-02f, -9.15740803e-02f, 1.85977668e-02f, -2.15157960e-02f,
  2.07695216e-01f, -2.90918767e-01f, 1.71412364e-01f, 2.41502356e-02f, 9.77802873e-02f, -1.59718003e-02f, -7.35600144e-02f, 1.13052865e-02f, 2.78391540e-01f, -3.57697904e-01f,
  -1.47171453e-01f, -4.53351326e-02f, 4.44443617e-03f, -3.85052174e-01f, 6.11486197e-01f, 9.34926495e-02f, -2.26502746e-01f, -2.92898864e-01f, -3.20425406e-02f, -3.04894418e-01f,
  6.94996417e-02f, -5.83165824e-01f, -2.90296506e-02f, -3.80473763e-01f, -1.44909322e-01f, -1.31575957e-01f, -1.01382084e-01f, -7.90425241e-02f, -2.85074890e-01f, -1.03203356e-01f,
  4.13478054e-02f, -2.23157089e-02f, -1.72287494e-01f, -9.02204309e-03f, 3.95950153e-02f, -3.96261998e-02f, -1.05614446e-01f, -3.72717343e-02f, 1.83813930e-01f, 2.40270644e-02f,
  3.33395973e-02f, -2.84118131e-02f, -5.45245148e-02f, 1.39832655e-02f, 7.72441179e-02f, 6.70023039e-02f, -1.95032526e-02f, 2.79430281e-02f, -1.29159093e-02f, 3.92334349e-03f,
  1.03585854e-01f, 2.45406628e-02f, 5.62363453e-02f, -5.70781045e-02f, -2.25812607e-02f, 5.17437719e-02f, 8.15825239e-02f, -8.16414207e-02f, 1.25365239e-02f, 1.12640798e-01f,
  -2.49799266e-01f, -1.16001397e-01f, -4.64756265e-02f, 7.07265586e-02f, 3.40778120e-02f, 1.47435382e-01f, 2.96309330e-02f, -3.54057737e-02f, 8.07433426e-02f, 1.13221100e-02f,
  -1.04961693e-02f, -6.95015714e-02f, -2.42828261e-02f, 8.33992735e-02f, 2.13077455e-03f, 4.62100692e-02f, -2.75950488e-02f, 1.93959437e-02f, 1.21516950e-01f, 1.16071858e-01f,
  5.48487939e-02f, -8.07537064e-02f, -8.53739083e-02f, 7.51590058e-02f, -2.69282572e-02f, 1.00681998e-01f, -8.71384218e-02f, 7.19503686e-02f, 8.17670971e-02f, -1.16357602e-01f,
  4.40351851e-02f, -5.08607924e-01f, -5.69072627e-02f, -1.73317239e-01f, -4.80960123e-02f, -1.81671269e-02f, -1.07335918e-01f, 8.04344378e-03f, -1.99467167e-01f, -6.96900412e-02f,
  -1.19423412e-01f, -3.84370275e-02f, 1.16597656e-02f, 5.82029577e-03f, -8.99228081e-02f, 9.63154361e-02f, -2.72998214e-01f, -8.82159248e-02f, -1.15519166e-01f, -1.39726773e-01f,
  -4.70815152e-02f, -6.31721765e-02f, 1.32487749e-03f, -3.88559420e-03f, -1.24925941e-01f, 1.36116147e-01f, 3.25829387e-02f, 3.88309695e-02f, 3.77184637e-02f, -3.17046680e-02f,
  -1.98106527e-01f, 8.80759433e-02f, -2.04997778e-01f, -2.34823883e-01f, -3.90347183e-01f, 1.00217592e-02f, -1.22140916e-02f, 1.64801121e-01f, 3.96399379e-01f, 3.84758234e-01f,
  -2.93531150e-01f, 2.20900491e-01f, 3.26136500e-01f, -1.15927421e-01f, -3.66476085e-03f, 2.62340248e-01f, -3.08356732e-01f, -1.05418675e-01f, 1.28232226e-01f, -6.25670105e-02f,
  -2.08172783e-01f, -2.19955787e-01f, -2.12329939e-01f, 1.99125726e-02f, -5.13818562e-01f, -1.21837057e-01f, -1.66329145e-01f, -1.14506878e-01f, -3.49820077e-01f, -2.14886874e-01f,
  -1.79426923e-01f, 1.08162565e-02f, -2.59530395e-01f, -2.34430972e-02f, -3.11502844e-01f, -7.25541860e-02f, -1.05491064e-01f, -6.10146448e-02f, 1.67722367e-02f, 1.02966458e-01f,
  -1.38181478e-01f, 6.66658878e-02f, 6.49598660e-03f, 1.10579573e-01f, -3.69195687e-03f, 3.81676294e-02f, -7.38870129e-02f, -1.49222553e-01f, 2.22018659e-02f, -1.67876706e-01f,
  -2.62088925e-02f, -4.43033464e-02f, -8.70929435e-02f, 8.52363855e-02f, -2.10478202e-01f, -8.12847838e-02f, 6.55481666e-02f, -1.86481848e-01f, -1.49761096e-01f, -7.60824233e-02f,
  -1.38308736e-03f, 4.04324345e-02f, -1.03830300e-01f, 2.27422640e-02f, 9.30055510e-04f, -1.70625791e-01f, -1.45388618e-02f, -9.33835432e-02f, 3.67201194e-02f, -9.40257013e-02f,
  -4.35270295e-02f, -1.13977544e-01f, -1.16523027e-01f, -1.58898365e-02f, -2.46055680e-03f, -9.07926541e-03f, -2.51136124e-02f, -7.84760416e-02f, -9.54635814e-02f, -3.36696510e-03f,
  1.00561909e-01f, 1.37251809e-01f, -1.08738184e-01f, -1.31158680e-01f, -1.28181176e-02f, -1.49626192e-02f, 7.69394860e-02f, -4.04856764e-02f, -4.51759212e-02f, -4.06804346e-02f,
  -1.10161314e-02f, 9.11068823e-03f, -6.48885369e-02f, 5.20452075e-02f, 1.06489591e-01f, -1.61884539e-02f, -2.56115589e-02f, -1.72216654e-01f, 3.98899429e-02f, 4.40666378e-02f,
  1.08870327e-01f, -7.54448306e-03f, -5.96156754e-02f, -9.30385944e-03f, 2.78954446e-01f, -7.89229572e-02f, -2.29630060e-02f, 1.02155596e-01f, -2.66816448e-02f, -3.47657911e-02f,
  -7.60639831e-02f, 1.25138402e-01f, 2.42885545e-01f, 4.09633480e-02f, -7.69504756e-02f, -5.43262362e-02f, -1.59329418e-02f, -2.67173797e-02f, -1.41500995e-01f, 2.08108258e-02f,
  3.40758294e-01f, 4.20488983e-01f, 1.07471213e-01f, 4.68342811e-01f, -3.78026545e-01f, 1.70308828e-01f, 2.16302305e-01f, -4.88167256e-02f, 3.02959502e-01f, 2.59632796e-01f,
  -2.51010925e-01f, 4.83358294e-01f, -1.14450738e-01f, 3.16451311e-01f, -4.65945810e-01f, -1.08370319e-01f, 2.21601829e-01f, 4.18905079e-01f, 5.56191206e-02f, 1.50092900e-01f,
  -1.34554952e-01f, -2.40747258e-01f, -2.28163764e-01f, -2.37139151e-01f, 1.48821980e-01f, 1.42117217e-01f, -4.43451166e-01f, -1.39558777e-01f, 8.33896995e-02f, -1.40472844e-01f,
  1.15886152e-01f, 1.20625414e-01f, 2.94481758e-02f, 1.17207333e-01f, -6.94745779e-02f, -9.48703382e-03f, 3.51736844e-02f, -1.15261681e-01f, -1.49893358e-01f, 9.29018781e-02f,
  1.60417795e-01f, -7.18292668e-02f, 7.04006851e-02f, -6.03894927e-02f, 8.08886737e-02f, 3.33218882e-03f, 3.09420004e-03f, 1.33246882e-02f, 1.31008774e-01f, 1.94804706e-02f,
  1.61057040e-01f, 1.43813521e-01f, -2.60145236e-02f, 4.53779623e-02f, -1.30005836e-01f, 1.25435479e-02f, 7.50487074e-02f, -8.04795921e-02f, 6.98294789e-02f, 1.51606081e-02f,
  -8.54543895e-02f, -9.76045206e-02f, 3.79270613e-02f, 7.46659413e-02f, -3.85370068e-02f, 2.21236353e-03f, 4.97113280e-02f, -1.41070813e-01f, 9.68444869e-02f, -7.65681779e-03f,
  2.49274578e-02f, 1.08126342e-01f, -1.59817294e-03f, 2.80600153e-02f, 7.00473934e-02f, 1.03884801e-01f, -3.33803818e-02f, 1.61255419e-01f, 6.05869442e-02f, -6.91611022e-02f,
  -3.47968787e-02f, -6.40272498e-02f, -2.24313643e-02f, 5.04034534e-02f, -1.36883194e-02f, -1.66920256e-02f, 7.68938586e-02f, 5.71510755e-02f, -5.16660810e-02f, -9.97336879e-02f,
  1.21558597e-02f, -1.09951936e-01f, -1.31629291e-03f, -1.30982464e-02f, 2.59357132e-02f, -1.38707206e-01f, -6.73743188e-02f, 4.87022325e-02f, -1.06798828e-01f, -2.56769415e-02f,
  -4.91037443e-02f, -2.79820934e-02f, -1.49454653e-01f, -5.78940026e-02f, 9.86425206e-03f, -2.55788043e-02f, 8.13545659e-02f, 4.20923438e-03f, -1.85730308e-01f, 2.49933656e-02f,
  4.33104448e-02f, 7.12402314e-02f, -1.24318182e-01f, -2.83990894e-02f, 4.68384773e-02f, -1.12756878e-01f, 6.94857389e-02f, 6.61772713e-02f, -1.64929166e-01f, 6.43103663e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.03357828e-01f, 2.95149297e-01f, 1.98385745e-01f, 3.72896433e-01f, 4.90633577e-01f, 3.84409308e-01f, 2.33469248e-01f, 4.60955262e-01f, 4.41753715e-01f, 5.38565218e-01f,
  3.04362357e-01f, 2.94608951e-01f, 2.02386677e-01f, 4.73193407e-01f, 3.91505420e-01f, -1.97371263e-02f, 1.88815609e-01f, 5.39117396e-01f, 3.79330695e-01f, 3.64630252e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.04581020e-02f, 1.21792942e-01f, 1.58704564e-01f, 6.92031905e-02f, 2.41230950e-02f, -4.51582819e-02f, 8.59109834e-02f, 9.59974006e-02f, -8.27640444e-02f, -1.91507548e-01f,
  -2.54203260e-01f, -1.14186034e-01f, -9.02794823e-02f, 1.26264945e-01f, -1.66423947e-01f, 1.25066981e-01f, -1.67757139e-01f, 2.71178722e-01f, 3.09808105e-01f, 2.05272362e-01f,
  -6.24947138e-02f, -1.23519301e-01f, 9.99947563e-02f, -1.27685517e-01f, -3.03463489e-01f, 3.17687690e-01f, -3.38239968e-01f, 7.19600245e-02f, -4.54900116e-02f, -5.25667481e-02f,
  2.26438090e-01f, -1.75776795e-01f, 1.39758423e-01f, -2.11374089e-01f, 2.20405295e-01f, -1.96823433e-01f, -1.67889059e-01f, -1.02399230e-01f, 1.70591637e-01f, -2.48565488e-02f,
  -3.02252412e-01f, -2.33178318e-01f, -2.63158649e-01f, 4.65999633e-01f, 2.03679338e-01f, 2.06987560e-02f, -3.00185323e-01f, 1.85698643e-01f, -1.00892484e-01f, 2.57278264e-01f,
  2.26298735e-01f, 7.46225566e-02f, -6.29969984e-02f, -4.13032323e-02f, 1.70258582e-01f, -1.53777137e-01f, -3.27612966e-01f, 1.01130426e-01f, -3.97772193e-02f, 7.92760924e-02f,
  -1.75844640e-01f, -7.51953721e-02f, -2.64110208e-01f, 2.23026536e-02f, 1.54798582e-01f, -4.03771460e-01f, 5.67785688e-02f, -2.53799539e-02f, -4.26044405e-01f, 1.01064239e-02f,
  2.53533632e-01f, 1.33442134e-01f, -1.21715084e-01f, -1.19945116e-01f, 2.94388056e-01f, -2.57125515e-02f, -1.87385887e-01f, -1.69495717e-01f, -1.11518800e-01f, 8.49553123e-02f,
  2.36928612e-01f, 8.89064893e-02f, 1.03308260e-02f, 1.95954904e-01f, 1.36456806e-02f, 2.99566954e-01f, 1.86319232e-01f, -5.65809794e-02f, -1.55776232e-01f, 9.95534211e-02f,
  1.56295970e-01f, 1.73831999e-01f, -2.09770381e-01f, -2.73481846e-01f, -1.52377978e-01f, 2.82599390e-01f, -2.09111720e-01f, 2.58034607e-03f, 2.62335241e-01f, -1.29573792e-01f,
  5.30905314e-02f, 2.59334385e-01f, -8.06328356e-02f, 3.14360559e-01f, -2.09268644e-01f, -2.45468587e-01f, -2.54260421e-01f, -9.99462605e-02f, -2.20270872e-01f, 8.37928057e-02f,
  4.24074560e-01f, 1.31866366e-01f, -1.72006451e-02f, 4.60125953e-01f, 4.01240513e-02f, 6.89558461e-02f, 3.28582637e-02f, -3.56386751e-01f, 1.89430654e-01f, -2.04076201e-01f,
  -2.43251204e-01f, -7.16553256e-02f, -1.05118200e-01f, -1.60191834e-01f, -1.40601948e-01f, -1.17313623e-01f, 1.81089006e-02f, -1.82815447e-01f, 2.33846769e-01f, 2.88280338e-01f,
  -5.18533364e-02f, 6.07502423e-02f, 1.27807885e-01f, 4.17041294e-02f, -3.27907860e-01f, 1.32621974e-01f, 3.02706093e-01f, 1.73086315e-01f, -3.70335162e-01f, -4.72827107e-01f,
  2.45212749e-01f, 2.71774232e-01f, -6.24686182e-02f, -3.61333136e-03f, -1.60929486e-01f, -3.02188486e-01f, -9.09545720e-02f, -9.62873250e-02f, 8.44720192e-03f, -2.33694881e-01f,
  -3.58238630e-02f, 6.66997209e-02f, -1.72915831e-02f, 3.81476022e-02f, -3.73169988e-01f, 1.94025502e-01f, -1.17672449e-02f, 5.54261282e-02f, 1.81977227e-02f, -1.04515143e-01f,
  -2.39820108e-01f, -2.36493107e-02f, -2.76288450e-01f, -3.93023267e-02f, 1.75247297e-01f, -2.51061082e-01f, -3.29503626e-01f, 2.06444919e-01f, 4.97026704e-02f, -1.42684519e-01f,
  1.10642530e-01f, -4.72494960e-01f, -6.43384829e-02f, -2.44361311e-01f, 1.33922905e-01f, -2.48382851e-01f, 1.30607888e-01f, -3.50013107e-01f, -1.51212767e-01f, 3.24800551e-01f,
  -2.91222394e-01f, 6.71236888e-02f, 7.04283789e-02f, -5.31643443e-02f, 3.51174682e-01f, 9.46360826e-02f, -1.32201880e-01f, 2.67776906e-01f, 2.94510394e-01f, 8.24074596e-02f,
  2.12614402e-01f, -2.33292073e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.86792564e-01f, -1.22648314e-01f, 8.30348358e-02f, 3.66084725e-01f, -6.22173473e-02f, -7.50466436e-02f, 4.17643368e-01f, -2.75311351e-01f, -4.05162275e-01f, 2.70139277e-01f,
  5.10657966e-01f, 3.77039403e-01f, 3.52290094e-01f, -3.86526376e-01f, 7.87398741e-02f, 6.12616122e-01f, -9.28202793e-02f, 6.23490512e-01f, -2.28626668e-01f, -1.11247405e-01f,
  6.21083617e-01f, 5.01633704e-01f, 5.50977234e-03f, 2.93335319e-01f, -3.15020591e-01f, -1.39249280e-01f, 1.99609563e-01f, 1.95934009e-02f, -5.55917501e-01f, 2.42770538e-02f,
  -3.21460247e-01f, 3.16810340e-01f, -1.63541496e-01f, 1.84671789e-01f, 4.62012172e-01f, 3.97371709e-01f, 3.52876812e-01f, 2.07528368e-01f, -6.90193772e-01f, 3.51913780e-01f,
  -5.21450974e-02f, -4.76068668e-02f, -2.43814901e-01f, -2.42605314e-01f, -8.61335546e-02f, -1.93931803e-01f, 8.05982828e-01f, 4.69082862e-01f, 9.78502072e-03f, 6.63362145e-01f,
  2.61218905e-01f, 6.15607202e-01f, 3.21852326e-01f, -3.97422284e-01f, -4.46077473e-02f, -3.15735787e-01f, -2.80098035e-03f, 6.26882255e-01f, -1.27200469e-01f, 6.84468523e-02f,
  3.19451272e-01f, 7.81322122e-02f, -3.01052213e-01f, -4.19144124e-01f, 3.77625942e-01f, 5.74142933e-01f, 1.19831271e-01f, 1.64222941e-01f, 5.36379099e-01f, 5.20972610e-02f,
  -2.01118276e-01f, -4.34788346e-01f, 1.40172662e-02f, 5.44249892e-01f, 3.46523486e-02f, -2.66802609e-01f, 3.85524333e-01f, 3.99571180e-01f, 2.56883383e-01f, 4.95948821e-01f,
  2.08630577e-01f, -1.22102655e-01f, -3.09862942e-01f, -1.82758868e-01f, 4.54953015e-02f, 2.79907763e-01f, -3.82601440e-01f, 6.21768415e-01f, 4.07526135e-01f, 1.28512695e-01f,
  -4.63364631e-01f, -4.14653033e-01f, 3.09870511e-01f, 7.13126898e-01f, 3.86825770e-01f, 5.75444615e-03f, 3.89871538e-01f, 6.18816257e-01f, 3.68829429e-01f, 4.66863066e-01f,
  6.74533725e-01f, 4.21415836e-01f, 1.43723235e-01f, 1.88427225e-01f, -3.17451358e-01f, 5.08127436e-02f, -1.84712529e-01f, -6.24708056e-01f, -2.95458376e-01f, 4.75473195e-01f,
  -1.01703927e-01f, 4.66846824e-01f, 2.26049513e-01f, 4.04247761e-01f, 8.12380388e-02f, -1.22930212e-02f, 6.21461451e-01f, -3.03649783e-01f, -4.19169039e-01f, 1.13287158e-01f,
  -6.49362803e-02f, 6.45080745e-01f, -3.27716023e-02f, -3.03802222e-01f, -2.19524443e-01f, -1.97592884e-01f, 1.82604522e-01f, 5.35409391e-01f, 3.79943818e-01f, 4.23630960e-02f,
  1.63621470e-01f, 4.77454901e-01f, 1.09910175e-01f, 1.07367493e-01f, -9.31418017e-02f, -6.91114247e-01f, -1.65486813e-01f, 4.98930663e-01f, 3.12608719e-01f, 6.01396084e-01f,
  4.88361806e-01f, 6.77433386e-02f, -4.22527969e-01f, 8.94854516e-02f, 1.61195889e-01f, -3.51780355e-02f, 2.18290731e-01f, -3.93908024e-01f, 5.64759254e-01f, -2.09246933e-01f,
  -1.47609934e-01f, 1.84401736e-01f, -7.27724433e-02f, -3.81945580e-01f, 3.27032924e-01f, -2.06856489e-01f, 1.29663229e-01f, 7.39538491e-01f, -3.38513583e-01f, 9.69638750e-02f,
  -4.51440990e-01f, 4.34605569e-01f, 4.84553337e-01f, -1.62800625e-01f, -4.07236665e-02f, 3.29598039e-01f, 2.66979113e-02f, -3.16793621e-01f, -3.10933203e-01f, -7.81945229e-01f,
  -4.37646240e-01f, 6.07636213e-01f, 3.06194782e-01f, 3.88866365e-01f, 6.97075486e-01f, 4.83159095e-01f, -5.70446014e-01f, 2.51048893e-01f, 4.11813170e-01f, 3.80550653e-01f,
  -3.32782239e-01f, 5.11187494e-01f, 2.82234311e-01f, 3.29956681e-01f, -2.34607145e-01f, -2.05550089e-01f, -2.56372988e-01f, -1.43820360e-01f, 3.95122826e-01f, 2.91021496e-01f,
  -1.10907406e-01f, -2.65195280e-01f, -1.35314852e-01f, 3.10907066e-01f, 3.57912987e-01f, 3.10332388e-01f, 5.39366245e-01f, 3.36328715e-01f, -1.11794127e-02f, 1.15616530e-01f,
  1.43775288e-02f, -1.25940546e-01f, 4.13844250e-02f, -2.11822614e-01f, 1.49147362e-01f, 2.83816874e-01f, -1.91484824e-01f, -2.50850171e-02f, 1.72557101e-01f, -9.86910984e-02f,
  5.45875728e-01f, 4.24822211e-01f, 2.30583683e-01f, -1.98055580e-01f, 4.77470160e-01f, -3.51563692e-01f, 1.99054465e-01f, 3.69975358e-01f, -2.86778331e-01f, -3.65163416e-01f,
  3.56536835e-01f, 1.92602202e-01f, -4.06587511e-01f, -3.30659986e-01f, 2.75333017e-01f, -1.49786890e-01f, 2.12715968e-01f, -6.59563765e-02f, -4.19783860e-01f, 5.24503171e-01f,
  3.11989844e-01f, 5.32810688e-01f, -3.25648159e-01f, -5.99960983e-01f, -8.60775411e-02f, -1.84115544e-01f, -1.75728232e-01f, 2.69884109e-01f, -4.66554612e-01f, -3.85598332e-01f,
  7.92647973e-02f, 2.74929225e-01f, 5.02322972e-01f, 2.83809483e-01f, 5.89729249e-01f, 2.02168927e-01f, 4.74758536e-01f, 1.12733431e-01f, -2.54596859e-01f, 3.30547065e-01f,
  5.71157217e-01f, 3.37507010e-01f, -2.08798647e-01f, -4.43943948e-01f, 9.50827375e-02f, 5.95898330e-01f, -1.25009362e-02f, -4.18667465e-01f, 1.07786834e-01f, -2.04583198e-01f,
  -4.15272683e-01f, -1.51793525e-01f, 2.64056735e-02f, -5.21520004e-02f, -1.21438247e-03f, -2.21968412e-01f, 2.39887804e-01f, -2.76448071e-01f, -2.10723788e-01f, -3.19432616e-01f,
  -3.09900641e-01f, -1.20036267e-01f, 4.14492279e-01f, -2.61871554e-02f, 3.44170541e-01f, 1.78812012e-01f, 1.53684035e-01f, 5.23017466e-01f, 1.50375953e-03f, 2.87184805e-01f,
  3.65180582e-01f, 4.49578941e-01f, 4.65218812e-01f, 3.94002229e-01f, 4.75838572e-01f, -1.29172295e-01f, 4.76860851e-02f, 5.94948590e-01f, 2.08900079e-01f, 3.85828048e-01f,
  1.40749693e-01f, 5.79225242e-01f, 3.21401536e-01f, 5.05568445e-01f, -2.30345994e-01f, -7.39788949e-01f, -4.20443416e-02f, 3.23379874e-01f, 5.50308786e-02f, 6.02522075e-01f,
  7.81138361e-01f, 1.25799730e-01f, 5.09854257e-01f, 1.78098962e-01f, -3.19854021e-01f, 2.12819837e-02f, -2.31908157e-01f, 4.57088426e-02f, 1.89191431e-01f, 5.07667542e-01f,
  4.74778175e-01f, 6.16179824e-01f, -1.78906575e-01f, -5.78967512e-01f, 9.78576541e-02f, -3.35082002e-02f, 7.79894367e-02f, 8.63874197e-01f, 1.71188399e-01f, 3.33632618e-01f,
  4.72741455e-01f, 2.28284881e-01f, -6.00791350e-02f, -1.46424919e-01f, 9.44647416e-02f, 2.52925843e-01f, 2.46419296e-01f, 2.18166500e-01f, 2.08077103e-01f, -1.91209286e-01f,
  1.84375167e-01f, -6.69980764e-01f, -2.53957927e-01f, 9.38732848e-02f, -2.91261643e-01f, -5.14410019e-01f, 5.70163846e-01f, -1.56928033e-01f, -7.13639408e-02f, 6.70005620e-01f,
  -6.51867017e-02f, 5.91371477e-01f, 5.43803513e-01f, 4.77684408e-01f, 5.96325457e-01f, 3.93939853e-01f, 4.44753945e-01f, 6.44039214e-01f, 1.45669430e-01f, -8.09715167e-02f,
  7.83067226e-01f, 1.58307105e-01f, 7.15658888e-02f, 1.78677738e-01f, 6.90570660e-03f, 5.38836308e-02f, -3.65915120e-01f, 2.58479506e-01f, 7.99549073e-02f, 2.92965382e-01f,
  1.09546453e-01f, 1.94306150e-01f, 9.98537838e-02f, 5.09246469e-01f, -4.66007471e-01f, 4.83511031e-01f, -3.24028760e-01f, 3.62524480e-01f, 2.92637795e-01f, 6.24535561e-01f,
  1.26761362e-01f, -1.44116729e-01f, 1.38745800e-01f, -2.68662274e-01f, 5.12409210e-01f, 1.54264197e-01f, 2.71203905e-01f, -3.28041911e-01f, 6.39967024e-01f, 5.85238971e-02f,
  4.11081553e-01f, 2.66224056e-01f, 3.87919843e-01f, -4.69139874e-01f, 2.36670047e-01f, 1.52798727e-01f, 4.07367945e-01f, 4.41960571e-03f, 2.12720081e-01f, 2.15974852e-01f,
  -3.15212280e-01f, 2.68743843e-01f, 1.87548980e-01f, -5.36731303e-01f, -8.65156531e-01f, -3.50558609e-01f, -3.36520731e-01f, 4.59834278e-01f, 2.06161872e-01f, -9.01055411e-02f,
  -1.85487106e-01f, 1.53325513e-01f, 5.13418972e-01f, 4.54788089e-01f, -3.74980837e-01f, -7.18205154e-01f, -6.17199779e-01f, 3.16654295e-01f, 2.24462569e-01f, 3.04693848e-01f,
  1.31940171e-01f, 7.44685471e-01f, 7.20085979e-01f, 1.94490030e-01f, 5.42347610e-01f, 4.29311484e-01f, -2.71929428e-02f, 3.94681454e-01f, 2.47553736e-01f, 1.02879144e-01f,
  2.81829555e-02f, 9.64483321e-02f, 1.86958425e-02f, 2.29606051e-02f, -6.06248900e-02f, -5.23602553e-02f, 4.42326099e-01f, 2.87686259e-01f, 4.36193883e-01f, -1.03526495e-01f,
  5.66455066e-01f, 5.98069012e-01f, 6.89858854e-01f, 2.63367712e-01f, 1.27872616e-01f, 1.86281338e-01f, 6.15511611e-02f, 2.60052294e-01f, 7.11988926e-01f, -2.42652819e-01f,
  3.37122500e-01f, -1.40511822e-02f, -1.35563850e-01f, -3.86170477e-01f, 2.97637135e-01f, 3.55680436e-01f, -3.45140765e-03f, -5.93392134e-01f, 3.98317724e-01f, 9.64730307e-02f,
  4.69251484e-01f, -1.02858387e-01f, -2.67947704e-01f, 8.36125091e-02f, 4.26889628e-01f, 3.47958893e-01f, -3.42167050e-01f, 3.93930078e-01f, 3.19127768e-01f, 1.50319070e-01f,
  1.21980309e-01f, 7.55640119e-02f, -2.62683593e-02f, 6.14038229e-01f, 5.83559513e-01f, 7.74576843e-01f, 2.95503020e-01f, -3.73398699e-02f, 6.51533365e-01f, 2.01228455e-01f,
  5.19550383e-01f, -4.47207779e-01f, 1.43124029e-01f, 4.51843768e-01f, 1.80537179e-01f, -3.83217365e-01f, -2.23929867e-01f, -1.93401381e-01f, -8.80145878e-02f, -1.37095511e-01f,
  4.04752009e-02f, 2.34998912e-01f, 4.72297631e-02f, 3.38827431e-01f, -2.63452567e-02f, 2.74699062e-01f, 2.92737126e-01f, -4.16909814e-01f, -1.69672400e-01f, -1.66371495e-01f,
  3.37663084e-01f, -8.66819695e-02f, -6.48669228e-02f, 4.37646955e-02f, 1.84861436e-01f, -2.75059998e-01f, -1.77006260e-01f, 3.31380218e-01f, -3.56475357e-03f, 3.74210030e-02f,
  4.09464538e-01f, 6.27417326e-01f, 4.02553707e-01f, 6.78951681e-01f, -1.13707460e-01f, -4.03493702e-01f, 5.05908728e-01f, -4.27664220e-02f, -5.61061427e-02f, -1.91632733e-01f,
  3.71299058e-01f, 4.44571227e-01f, 1.84078798e-01f, 1.87281936e-01f, -1.07848004e-01f, 1.56345814e-01f, 3.46694142e-01f, -1.59341544e-01f, -5.33027291e-01f, 3.66785049e-01f,
  4.06626731e-01f, 6.01839602e-01f, 3.42021912e-01f, -3.98923784e-01f, -1.56891212e-01f, -3.75347555e-01f, 5.63261628e-01f, 3.99218470e-01f, 6.33723736e-01f, 3.89794469e-01f,
  -2.79608190e-01f, 1.90094396e-01f, 1.72601148e-01f, 2.02671587e-01f, 2.49270022e-01f, -1.10777430e-01f, 7.07852721e-01f, 4.01128739e-01f, 3.48369747e-01f, 4.06935573e-01f,
  2.24697471e-01f, 2.54903227e-01f, 1.03665099e-01f, -2.50646502e-01f, 6.07339799e-01f, 5.26378095e-01f, 2.50920326e-01f, 4.05664146e-01f, 4.92807180e-01f, 3.14690173e-01f,
  4.22198504e-01f, -3.31698626e-01f, -2.37197071e-01f, 3.94122422e-01f, 2.71850258e-01f, -4.49701428e-01f, 4.34802324e-01f, 6.00147367e-01f, -4.18771118e-01f, -4.49316502e-02f,
  4.80843425e-01f, -2.50665516e-01f, -1.65459007e-01f, -2.41132632e-01f, 4.73400325e-01f, 2.64188677e-01f, 1.62582323e-01f, 3.65366876e-01f, 1.23010561e-01f, 2.09756345e-01f,
  -7.25172833e-02f, -4.17738646e-01f, -2.56296694e-01f, 1.34049319e-02f, 1.81191489e-01f, 6.52327716e-01f, 3.06627721e-01f, 3.04012299e-01f, 4.57912266e-01f, 1.52831987e-01f,
  -1.12192258e-02f, 4.25467521e-01f, 5.05889177e-01f, -4.40092027e-01f, -6.04498923e-01f, -4.56786692e-01f, -6.22860491e-01f, 4.26931173e-01f, 6.49716854e-01f, 7.32738674e-01f,
  -7.01325163e-02f, 4.02204186e-01f, -5.64629912e-01f, 1.36844024e-01f, 1.69618294e-01f, 1.68042496e-01f, -6.40758127e-02f, 4.92676884e-01f, -1.64435938e-01f, 5.62188566e-01f,
  -4.33061182e-01f, -1.43283680e-01f, -1.45537317e-01f, -4.40407157e-01f, 1.73860916e-03f, 7.16031641e-02f, 2.31918126e-01f, 4.15909946e-01f, 2.09275305e-01f, -4.86042164e-02f,
  -1.61115035e-01f, -2.26148695e-01f, 5.18446192e-02f, 2.63352003e-02f, -1.43330634e-01f, 1.85369730e-01f, 2.47503087e-01f, 1.15911938e-01f, -2.19303563e-01f, -3.88986677e-01f,
  -3.44101548e-01f, -9.94580090e-02f, -9.14944336e-02f, -1.83523595e-01f, 2.18645379e-01f, -2.29900479e-01f, 2.36016393e-01f, 3.36015373e-01f, -9.77910236e-02f, 3.72594178e-01f,
  -4.09348339e-01f, 9.36554670e-02f, 6.86525285e-01f, 6.60734236e-01f, 3.24433595e-01f, 6.47512674e-01f, 5.24454415e-01f, 2.16406882e-01f, 4.01748627e-01f, 6.18487537e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -6.36983886e-02f, 2.26300582e-01f, 2.75614858e-01f, 2.03460500e-01f, 1.14538543e-01f, 2.20911369e-01f, 1.78876996e-01f, -1.55123584e-02f, -6.19286019e-03f, 2.88785964e-01f,
  1.59742787e-01f, -8.92345756e-02f, 2.25468919e-01f, 3.79979223e-01f, 5.18148392e-02f, 1.80702552e-01f, 1.25602767e-01f, 3.02266419e-01f, 3.33396435e-01f, 1.59520432e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.61250049e-01f, 2.80290484e-01f, -4.41766568e-02f, 1.02682933e-01f, 3.20409462e-02f, -1.28862515e-01f, 1.84068158e-01f, 3.24482977e-01f, 4.96814996e-01f, 8.33750144e-02f,
  2.69171029e-01f, 4.51216191e-01f, -3.45287174e-01f, 2.99671263e-01f, -7.52859533e-01f, -5.45766242e-02f, -3.04615974e-01f, -5.31987369e-01f, 8.49977732e-02f, 2.86835730e-01f,
  3.39468598e-01f, -5.58419406e-01f, 2.30204269e-01f, -6.24399364e-01f, 4.60831583e-01f, -9.33003485e-01f, -4.97633517e-01f, -4.90389943e-01f, 1.98662445e-01f, -5.77484787e-01f,
  -6.39036775e-01f, 5.23214340e-01f, -3.82246792e-01f, -5.12628734e-01f, 1.64595172e-01f, -1.66934520e-01f, 1.94359705e-01f, 2.02570811e-01f, 1.20571323e-01f, 3.98282409e-01f,
  1.68777794e-01f, 4.23622757e-01f, -3.78303796e-01f, -5.55372119e-01f, -4.12055969e-01f, 3.51593792e-01f, -7.17526078e-01f, 1.41443387e-01f, -2.11043898e-02f, 3.27066332e-01f,
  4.52539474e-01f, 3.28839809e-01f, 1.85747415e-01f, -7.58856237e-01f, -4.96121883e-01f, 2.91276276e-02f, 2.00232998e-01f, -1.41898453e-01f, 2.24437699e-01f, -4.41323936e-01f,
  -6.46979332e-01f, -3.65654618e-01f, 1.81342289e-01f, 4.27182652e-02f, -2.88298637e-01f, -2.74853289e-01f, 1.93408296e-01f, -1.84144601e-01f, -1.23975880e-01f, -4.10023421e-01f,
  2.87340581e-01f, 2.35028207e-01f, 3.03166568e-01f, 2.02251852e-01f, -3.04944187e-01f, -1.76591158e-01f, 5.86217225e-01f, 2.88302928e-01f, 2.88126171e-02f, 1.11125279e-02f,
  -6.01470411e-01f, 1.28057599e-01f, -5.83926976e-01f, -5.32800376e-01f, -8.16351533e-01f, -1.96398441e-02f, -6.24020815e-01f, -5.48144989e-02f, -4.70100611e-01f, 9.92885381e-02f,
  3.41721803e-01f, 6.13469556e-02f, 2.75171310e-01f, -3.23673517e-01f, 8.99980292e-02f, -2.99455374e-01f, -7.43600056e-02f, -2.02930108e-01f, -3.75933915e-01f, 1.24557979e-01f,
  1.60217918e-02f, 1.42754212e-01f, -3.88363004e-01f, -3.97235721e-01f, 2.62893647e-01f, -3.25604707e-01f, -2.52804190e-01f, 5.69786549e-01f, -4.60686177e-01f, -7.78320432e-01f,
  -3.42464000e-01f, -4.25809562e-01f, -5.60326576e-01f, -4.27652985e-01f, -2.81719655e-01f, 2.79078096e-01f, 5.10126710e-01f, -8.34430575e-01f, 4.05553520e-01f, 1.42471686e-01f,
  -5.39910972e-01f, 9.44093242e-02f, 3.09662938e-01f, -1.04910813e-01f, 3.01038861e-01f, 6.92581013e-02f, -4.92146820e-01f, 2.95945466e-01f, 4.62114394e-01f, -2.25021988e-01f,
  1.45648003e-01f, 2.51735866e-01f, 6.23790324e-02f, -3.91493738e-02f, 1.33957386e-01f, -3.11607838e-01f, -4.46122438e-01f, -2.64338166e-01f, 3.90895218e-01f, 5.01232803e-01f,
  -3.89363050e-01f, 3.22917730e-01f, 5.15164971e-01f, 3.76594722e-01f, 1.95753817e-02f, -6.71598077e-01f, 5.42182028e-01f, -6.88080430e-01f, -2.03140303e-01f, -3.64008904e-01f,
  2.24178797e-03f, -3.42668682e-01f, -1.42521754e-01f, 1.09172262e-01f, -5.52878082e-02f, -3.80723566e-01f, 3.99103612e-01f, 3.19475621e-01f, -5.97524405e-01f, 1.91982657e-01f,
  1.45781692e-02f, 3.37529898e-01f, 2.57352978e-01f, 2.66443372e-01f, -2.75712780e-04f, 1.93615869e-01f, 3.33551586e-01f, -1.53504238e-01f, -2.63281524e-01f, -2.74649747e-02f,
  4.90473151e-01f, -1.23696201e-01f, -5.68741798e-01f, -5.37007093e-01f, 1.45637348e-01f, 3.73560816e-01f, -4.57808077e-01f, -4.18293960e-02f, -2.00711191e-01f, 2.02803329e-01f,
  -3.51698935e-01f, -4.67403308e-02f, 1.88319176e-01f, -1.12601861e-01f, 2.69209921e-01f, -7.88378596e-01f, -7.71909952e-01f, 2.70383745e-01f, -7.48861909e-01f, 4.04838741e-01f,
  4.06392336e-01f, 1.49982953e-02f, 9.85257030e-02f, -5.63330129e-02f, 1.31902531e-01f, 1.13896742e-01f, 1.57017317e-02f, -3.34644347e-01f, -1.79847572e-02f, 4.29794192e-01f,
  -6.00782216e-01f, -6.55025780e-01f, 3.87172431e-01f, -4.61981535e-01f, 2.47578204e-01f, -6.30071104e-01f, 2.61394590e-01f, -3.20818514e-01f, 6.42538548e-01f, -7.90518373e-02f,
  -1.20075472e-01f, -6.00175858e-01f, -6.65861070e-01f, 4.34686422e-01f, -8.36210251e-01f, -1.05144374e-01f, -5.47354877e-01f, -2.73574796e-02f, 5.44069484e-02f, -2.58671701e-01f,
  -5.81459999e-01f, 4.09451753e-01f, 3.94452274e-01f, -4.71376538e-01f, -1.59137264e-01f, -8.97616148e-02f, -1.91132933e-01f, -3.80498707e-01f, -2.29455456e-01f, 4.72997241e-02f,
  -2.59624511e-01f, -2.34673843e-01f, -3.17664087e-01f, -1.64655685e-01f, -4.17130113e-01f, 1.89745441e-01f, -1.42126724e-01f, -5.70569634e-01f, 1.25294849e-01f, -7.23983884e-01f,
  4.22816128e-01f, -1.86704695e-01f, -2.57755876e-01f, -4.24225032e-01f, 1.69317722e-01f, 3.70634235e-02f, 1.23399608e-01f, 4.47635561e-01f, 1.52398497e-01f, -1.31585255e-01f,
  -6.18610382e-01f, 1.66374505e-01f, 2.07172781e-01f, -6.29703760e-01f, -4.08960104e-01f, 3.34624708e-01f, -1.01608336e-01f, -3.25266212e-01f, -2.14258105e-01f, 3.54666226e-02f,
  -2.77928472e-01f, 2.82760918e-01f, 2.59590149e-01f, 3.56242269e-01f, 1.44488081e-01f, -2.22452387e-01f, -3.87625009e-01f, -1.23503227e-02f, -9.18710083e-02f, -1.84694961e-01f,
  -5.37821293e-01f, -8.24622393e-01f, -1.28701791e-01f, 3.63433093e-01f, 3.82693022e-01f, 2.43105128e-01f, -5.79417832e-02f, 2.18265384e-01f, 3.37502033e-01f, -1.74280405e-01f,
  -7.26662159e-01f, 3.53044331e-01f, -9.74974409e-02f, 3.03411692e-01f, -3.61602068e-01f, -5.44762313e-02f, 3.39418463e-02f, -4.31139350e-01f, 3.87361854e-01f, 2.43103057e-01f,
  -3.40657830e-01f, 2.19049484e-01f, 2.04541102e-01f, 3.32827687e-01f, -1.66898981e-01f, -6.31881833e-01f, -4.77597326e-01f, 4.79789913e-01f, 3.53185594e-01f, 2.23780409e-01f,
  -6.06507421e-01f, 5.69579005e-01f, 8.73440355e-02f, -6.14929140e-01f, -1.28478900e-01f, 4.71813411e-01f, 1.60649419e-02f, -3.17446411e-01f, -6.39839590e-01f, 4.19258714e-01f,
  -6.22435749e-01f, -1.96388319e-01f, -1.57999676e-02f, 3.04076523e-01f, -1.09658480e+00f, -1.04616463e-01f, 1.53303534e-01f, -6.16336346e-01f, -9.52318385e-02f, -2.24254981e-01f,
  2.09468424e-01f, 2.03887358e-01f, -8.24681222e-02f, 2.74007339e-02f, -1.20089941e-01f, -2.47768328e-01f, -1.25847489e-01f, -7.36943930e-02f, 3.11730146e-01f, 5.69597721e-01f,
  -3.33301842e-01f, -5.10664165e-01f, 1.14007361e-01f, 5.06706126e-02f, -4.87617373e-01f, 2.09083602e-01f, 3.28317106e-01f, -8.55688572e-01f, 1.12876743e-01f, 3.00074488e-01f,
  -4.32635903e-01f, -2.33779073e-01f, -1.31916597e-01f, 3.89389217e-01f, -6.48381352e-01f, 1.49169266e-01f, 4.69869822e-01f, 2.03243300e-01f, 1.89340502e-01f, 1.43796518e-01f,
  -5.95526397e-01f, -6.91463411e-01f, -3.43675703e-01f, 1.80043906e-01f, 1.70399970e-03f, -3.44640166e-01f, -9.99317616e-02f, -1.46429256e-01f, -4.64190036e-01f, -3.88668895e-01f,
  3.86232704e-01f, -3.32090020e-01f, -4.87172455e-01f, -2.16822281e-01f, 5.56907058e-01f, -3.90095770e-01f, -7.84148555e-03f, 9.41282138e-02f, 3.79865974e-01f, -5.82776964e-01f,
  -6.93076432e-01f, 2.18555555e-01f, 4.98015821e-01f, 2.48297140e-01f, -2.34566644e-01f, -5.40766776e-01f, -6.96015716e-01f, -6.87695503e-01f, -1.79179966e-01f, 4.57696408e-01f,
  -3.13649058e-01f, 3.03833514e-01f, 5.20509072e-02f, 1.40428796e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.60672426e-01f, 3.34194787e-02f, -1.45090282e-01f, -3.66012417e-02f, 1.22132897e-01f, 1.10661099e-02f, 3.21635567e-02f, -1.75583556e-01f, -1.16312683e-01f, 2.61275053e-01f,
  -2.23186105e-01f, -2.14321285e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    