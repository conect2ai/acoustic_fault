/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.61811039e-01f, -1.01154774e-01f, -2.59162754e-01f, -2.60259151e-01f, 3.25235993e-01f, 2.35700831e-01f, 9.18795392e-02f, 9.61773694e-02f, -1.26450956e-01f, 7.67241716e-02f,
  5.58110066e-02f, -2.09290415e-01f, 2.03270055e-02f, -5.70986010e-02f, -1.25135079e-01f, -1.44973636e-01f, -1.48405820e-01f, -1.38821816e-02f, -8.29897672e-02f, 2.02679504e-02f,
  -4.03607488e-02f, 1.51263133e-01f, -9.65843648e-02f, 1.44307822e-01f, 1.46680355e-01f, -1.41414851e-01f, 6.63272813e-02f, 5.06455228e-02f, 5.17849550e-02f, 1.23821139e-01f,
  7.96061307e-02f, -1.25308931e-01f, -3.04417629e-02f, -4.37185988e-02f, 2.01679096e-02f, 9.59016308e-02f, -5.00136204e-02f, -7.03393528e-03f, -1.25318408e-01f, 4.17793468e-02f,
  5.55539951e-02f, -9.21607111e-03f, 3.50604840e-02f, -3.03965639e-02f, 8.70348290e-02f, -1.11973599e-01f, -7.75466710e-02f, -5.68911955e-02f, 5.11922454e-03f, 4.60856110e-02f,
  -1.62754897e-02f, 1.25303920e-02f, -3.06749027e-02f, -3.43202241e-02f, -6.99819922e-02f, -1.70799885e-02f, -7.11097419e-02f, -2.49067266e-02f, -3.96067351e-02f, -7.10892677e-02f,
  -3.06276232e-02f, -1.23794023e-02f, -6.99604228e-02f, 5.18832579e-02f, 2.77766176e-02f, 2.39256769e-02f, -5.69692664e-02f, 1.39812063e-02f, -5.91188222e-02f, 9.82756466e-02f,
  9.68934149e-02f, 5.14604971e-02f, -4.88259271e-02f, 2.31950711e-02f, 6.54964894e-02f, -8.15851018e-02f, 3.70390527e-02f, 2.26658341e-02f, -6.31865636e-02f, 6.90239063e-03f,
  -3.53945494e-02f, 3.59189995e-02f, -7.30863912e-03f, 3.77933569e-02f, 4.75948043e-02f, -1.05867520e-01f, -6.12845570e-02f, -1.46664027e-02f, 3.02725919e-02f, 8.54360238e-02f,
  1.45133778e-01f, -2.10566059e-01f, -7.98488501e-03f, 4.71810773e-02f, -4.13526297e-02f, 2.14169584e-02f, -1.69096276e-01f, 1.01414584e-01f, -2.63471622e-02f, 5.61467931e-02f,
  -1.78431273e-02f, 7.38583505e-02f, 4.75492179e-02f, -4.13928218e-02f, 3.61723565e-02f, 5.79476990e-02f, -1.56768143e-01f, -5.55683635e-02f, -8.32678098e-03f, 2.03907676e-02f,
  -5.02072237e-02f, -1.24584734e-01f, 3.33940126e-02f, -2.55393181e-02f, 1.06252544e-01f, -3.20800766e-02f, -2.37174947e-02f, -9.26876962e-02f, 4.25247140e-02f, 4.63166088e-02f,
  4.42878716e-02f, 1.04669407e-01f, 2.02576354e-01f, 1.52474299e-01f, -2.61580069e-02f, -2.43304804e-01f, -1.29779488e-01f, 1.81132760e-02f, 2.48424187e-01f, -2.47996464e-01f,
  -2.38638952e-01f, 2.55378842e-01f, -4.57007922e-02f, -1.18233219e-01f, 1.47573575e-01f, 1.16604306e-02f, -6.00439832e-02f, -8.75689462e-02f, 8.19363520e-02f, -1.15491055e-01f,
  8.75798464e-02f, -3.28531355e-01f, 3.91690210e-02f, -3.27445716e-02f, -6.80686161e-02f, 2.91822791e-01f, -6.71172515e-02f, 1.35326579e-01f, -6.15489297e-02f, 1.05869183e-02f,
  7.99984019e-03f, -5.42680435e-02f, 1.01027124e-01f, 1.17068581e-01f, -5.17726950e-02f, -1.45362198e-01f, -2.08062399e-02f, 7.93398991e-02f, 1.16217069e-01f, -6.05125055e-02f,
  9.94068477e-03f, 9.05741081e-02f, 6.95849508e-02f, 9.22175944e-02f, 2.33504083e-03f, 1.60771221e-01f, 2.34194677e-02f, -1.07897170e-01f, 4.72447164e-02f, -4.72121090e-02f,
  -1.09340362e-02f, 8.68627429e-02f, 3.44691426e-02f, 5.49119413e-02f, 7.28788301e-02f, 9.39664915e-02f, 5.09486012e-02f, 2.83867717e-02f, 3.40245739e-02f, 5.11030443e-02f,
  -1.66671619e-01f, -3.07891779e-02f, 2.37230621e-02f, -2.02752892e-02f, -1.83033887e-02f, 4.37207669e-02f, 3.20746116e-02f, -9.53820646e-02f, 1.04689047e-01f, -4.01702672e-02f,
  7.46940300e-02f, 6.26734272e-02f, 4.45884466e-02f, -2.30597276e-02f, -8.81864950e-02f, 4.00354005e-02f, 3.89945433e-02f, -2.95364484e-02f, 6.62150607e-02f, -7.92970601e-03f,
  7.15240985e-02f, 5.82778528e-02f, 8.51639826e-03f, -4.76289028e-03f, 3.08758449e-02f, 7.89923221e-02f, -1.01344502e-02f, 2.73406655e-02f, 9.43109021e-03f, -7.69396201e-02f,
  -1.50258526e-01f, -4.91343625e-02f, 4.19622213e-02f, 5.88951819e-02f, 2.60192212e-02f, -4.54949588e-02f, 4.25581709e-02f, 9.90515854e-03f, 1.01353645e-01f, -2.68755499e-02f,
  -5.07800728e-02f, -1.95829216e-02f, -2.85675470e-02f, 1.28278444e-02f, 7.70324469e-02f, -6.64384440e-02f, -1.86977293e-02f, 4.50665466e-02f, 4.15288880e-02f, -3.31926183e-03f,
  -8.61287639e-02f, 8.99418443e-03f, -1.85013493e-03f, 4.71295454e-02f, -1.16813824e-01f, -2.32928395e-02f, -6.06197044e-02f, 6.34070411e-02f, -1.00363776e-01f, 4.88977470e-02f,
  -3.05933803e-01f, 2.55445063e-01f, -1.17859326e-01f, -9.95923672e-03f, 2.77733713e-01f, -4.71823961e-02f, -2.45274529e-01f, 1.85697645e-01f, -1.97561048e-02f, 7.26709003e-03f,
  -4.46258262e-02f, -1.16377771e-01f, -2.03727171e-01f, 2.59183973e-01f, -1.74350396e-01f, -3.09800923e-01f, -2.99134175e-03f, -9.13589373e-02f, -4.53091040e-03f, 1.23108037e-01f,
  -1.26123771e-01f, 2.20588580e-01f, -1.73563734e-01f, 1.79552600e-01f, 1.10600613e-01f, -8.10277760e-02f, 6.68490753e-02f, 4.11283113e-02f, 5.70783094e-02f, 5.51710911e-02f,
  -6.72379285e-02f, 8.89350008e-03f, -2.04350408e-02f, -9.06914249e-02f, -7.77665898e-02f, 2.96055991e-02f, -1.52581021e-01f, -5.94151989e-02f, -8.45903754e-02f, -6.94107637e-03f,
  -1.03502661e-01f, -3.18571851e-02f, 7.57515244e-03f, 1.47497104e-02f, -4.68515456e-02f, -1.36201512e-02f, -2.98926514e-02f, -3.82952988e-02f, -6.52516708e-02f, 6.41154051e-02f,
  -1.19430404e-02f, 1.63238589e-02f, 4.14315891e-03f, 2.26592887e-02f, -2.21569203e-02f, 1.44039439e-02f, -4.76725362e-02f, -7.61792362e-02f, -5.91134578e-02f, 7.50666261e-02f,
  -2.31948551e-02f, -2.39930637e-02f, -6.59624115e-03f, 9.54290703e-02f, 4.69872728e-02f, 4.72577550e-02f, -5.44959120e-03f, 6.05296390e-03f, 2.24127080e-02f, 7.08620623e-02f,
  -3.54636423e-02f, 2.25193538e-02f, 2.61600558e-02f, -6.07511885e-02f, 5.04371431e-03f, -8.34134873e-03f, -8.92536268e-02f, -6.28509894e-02f, -2.20818184e-02f, -5.08982781e-03f,
  7.09525794e-02f, -1.75875444e-02f, 4.93108481e-02f, 3.34509090e-02f, -5.64476699e-02f, -9.03902799e-02f, 1.28862903e-01f, -3.55820172e-02f, 2.47813575e-02f, 8.44406802e-03f,
  1.06255412e-02f, 1.71668231e-01f, 1.45310080e-02f, 6.46982193e-02f, 5.34588657e-02f, 5.94381690e-02f, -7.40702301e-02f, -2.27534063e-02f, -4.38979603e-02f, 1.99712124e-02f,
  -7.98585415e-02f, -6.28027841e-02f, -8.00028592e-02f, -2.01419368e-03f, 2.71018259e-02f, 6.92501897e-03f, -1.23751901e-01f, -7.99976215e-02f, -5.32558337e-02f, 9.87705067e-02f,
  -3.40755656e-02f, -7.35160485e-02f, 3.07625905e-03f, -2.94251461e-02f, 8.17928612e-02f, -3.08498107e-02f, 1.37669668e-01f, -5.02007157e-02f, 5.41425385e-02f, -9.60023701e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.49939635e-01f, 2.32968226e-01f, 9.21184719e-02f, -2.29949459e-01f, 3.42382230e-02f, -2.25059703e-01f, -2.89292574e-01f, 1.03158891e-01f, 4.57186773e-02f, 5.91548830e-02f,
  -1.73965067e-01f, -1.01221129e-01f, 1.18049406e-01f, -2.02420071e-01f, -2.73722082e-01f, 1.73608903e-02f, -3.40052724e-01f, -2.35231236e-01f, -9.44212731e-03f, -2.56264210e-01f,
  -1.46172792e-01f, -2.18730345e-01f, -1.44977227e-01f, 9.46888104e-02f, -5.91766424e-02f, 3.57746258e-02f, -1.39269173e-01f, 1.13466963e-01f, -3.30500789e-02f, 5.54723740e-02f,
  -1.40524164e-01f, 9.63362902e-02f, 6.67434484e-02f, 9.00634229e-02f, -1.80225521e-01f, -9.05467663e-03f, -4.53438014e-02f, -3.07765882e-02f, -1.20707162e-01f, 2.36794688e-02f,
  -6.15586452e-02f, -2.12270580e-02f, -4.29494586e-03f, 1.77782848e-01f, -5.01343794e-03f, 6.66379333e-02f, 6.53263703e-02f, -9.41829477e-03f, -1.86398849e-02f, 1.52362892e-02f,
  -2.04474144e-02f, -5.80222253e-03f, 5.89039102e-02f, 7.69281238e-02f, -4.18350473e-02f, -5.35297133e-02f, -4.20615040e-02f, -2.04766914e-02f, -5.44436947e-02f, -2.85138115e-02f,
  -4.78758849e-02f, -5.55870384e-02f, 1.67715698e-02f, 5.37865050e-02f, -6.41179234e-02f, 6.99738860e-02f, 5.88457920e-02f, 5.56249544e-03f, 1.99439339e-02f, -1.81774131e-03f,
  -2.01848000e-02f, 4.23133606e-03f, 6.91816807e-02f, -6.01405203e-02f, -4.06163558e-02f, 7.30050146e-04f, -5.43779694e-02f, 1.76995788e-02f, -3.85910720e-02f, -1.14482120e-01f,
  -1.61433704e-02f, -3.57346311e-02f, 1.10186405e-01f, 2.23952942e-02f, 1.01537958e-01f, 2.35480145e-02f, 1.74820334e-01f, 1.00241207e-01f, -6.15294501e-02f, -1.25118986e-01f,
  -5.57931922e-02f, -2.04778998e-03f, -3.10469400e-02f, 1.23993285e-01f, 3.09203956e-02f, -5.28935827e-02f, -7.45444447e-02f, 6.36052415e-02f, -6.39184415e-02f, 6.74859062e-02f,
  -1.43677026e-01f, -4.61750813e-02f, -9.60280970e-02f, 1.19387537e-01f, 8.23873654e-02f, -1.47902220e-01f, -3.49930897e-02f, 3.47192213e-02f, -1.58323839e-01f, 7.74676632e-03f,
  -5.70853502e-02f, -1.02773961e-02f, 3.03272419e-02f, 8.51081610e-02f, -1.01095654e-01f, -8.63648206e-02f, -1.47951528e-01f, -9.45389345e-02f, -3.21436003e-02f, 7.17785805e-02f,
  5.63432984e-02f, 2.03152001e-01f, 2.42771477e-01f, 2.79932559e-01f, -4.28826846e-02f, -3.96682173e-01f, -3.27204913e-01f, 6.16878225e-03f, -6.95907325e-03f, -5.00472449e-02f,
  -1.85847536e-01f, 4.03893948e-01f, -2.27575332e-01f, -2.31384533e-04f, -2.77132452e-01f, -2.76407033e-01f, 2.48623956e-02f, 1.07619733e-01f, 5.55373654e-02f, 8.13826546e-02f,
  1.08241305e-01f, -1.36244923e-01f, 1.56164542e-01f, 4.57715765e-02f, 1.97190680e-02f, 2.13674754e-01f, 1.45053357e-01f, -1.37899965e-01f, 2.72936642e-01f, -4.04998213e-02f,
  -4.29295339e-02f, 1.21974804e-01f, 7.16469213e-02f, 3.87114100e-02f, 5.97095117e-02f, -1.12811305e-01f, 1.28145404e-02f, -2.29903962e-02f, -1.39078245e-01f, 6.66449890e-02f,
  5.31982519e-02f, -6.56506643e-02f, 8.77927020e-02f, -5.48476689e-02f, -1.51462751e-02f, 2.60326592e-03f, 1.48025334e-01f, 8.18081498e-02f, 1.06017604e-01f, 9.62734446e-02f,
  1.45134479e-01f, 4.86094095e-02f, -1.60437562e-02f, -2.56106071e-02f, 1.31755173e-01f, -3.10576018e-02f, 6.37269318e-02f, 5.14548793e-02f, 5.06350286e-02f, 1.26808137e-01f,
  5.39224818e-02f, 1.92472916e-02f, -7.43393376e-02f, -1.72356099e-01f, -1.07288353e-01f, -2.10265182e-02f, -4.92663160e-02f, 4.27587098e-03f, -9.65661481e-02f, -6.74635544e-02f,
  -8.14605653e-02f, 1.18788503e-01f, -5.82058169e-02f, -1.00565277e-01f, 7.69354105e-02f, -6.19062483e-02f, 1.86157841e-02f, -6.56685829e-02f, 9.48121175e-02f, 1.37053952e-01f,
  5.36561273e-02f, -1.65907562e-01f, 4.31386307e-02f, -1.61738414e-03f, -2.40454987e-01f, -4.43179198e-02f, 5.08869113e-03f, 7.65511766e-02f, -2.16849670e-02f, 7.46033266e-02f,
  -2.72629727e-02f, 4.56308722e-02f, 1.46208689e-01f, -2.27575060e-02f, -2.09519863e-02f, -2.92603811e-03f, -1.05695613e-01f, 5.34269586e-02f, 3.34943123e-02f, -2.35296873e-04f,
  9.95465834e-03f, 7.45343789e-02f, -5.26461340e-02f, -3.35012078e-02f, 5.82054444e-03f, -7.65939131e-02f, 6.43220767e-02f, -2.35700961e-02f, 1.13382429e-01f, 4.54601459e-02f,
  2.17575524e-02f, 5.54239051e-03f, -8.48272964e-02f, 1.22096306e-02f, 1.42650586e-02f, 9.63891298e-02f, -1.79473504e-01f, -1.52900200e-02f, 1.87529847e-02f, 3.78157152e-03f,
  -7.49854684e-01f, 1.88308597e-01f, 4.59158910e-04f, -1.79109171e-01f, 1.40501305e-01f, -1.30739408e-02f, -9.32421982e-02f, 8.17176253e-02f, -2.28773728e-01f, 5.56791835e-02f,
  -8.80471468e-02f, -2.62161493e-01f, 1.49285048e-01f, -6.44058809e-02f, -2.10558683e-01f, 5.02612963e-02f, -1.09894224e-01f, -1.25291482e-01f, 1.58329215e-02f, 5.43468446e-02f,
  -6.20006956e-02f, 1.82802469e-01f, 4.68690954e-02f, 3.41935396e-01f, 3.37018669e-02f, -1.69866867e-02f, 3.73428594e-03f, 8.63292590e-02f, -2.87975557e-03f, 7.00971903e-03f,
  -4.90114987e-02f, -5.32126650e-02f, 4.47870642e-02f, 1.04779080e-01f, 6.67595770e-03f, -1.45501681e-02f, -2.23398264e-02f, -1.10663688e-02f, 5.19436076e-02f, -9.90396217e-02f,
  -2.13167574e-02f, -2.50821784e-02f, -1.35508642e-01f, 4.26858142e-02f, 3.83985043e-02f, 3.03036254e-02f, 6.25240579e-02f, -4.54049148e-02f, 9.27594677e-02f, 1.79078318e-02f,
  2.48629507e-02f, 9.10952240e-02f, -8.05940107e-03f, -1.49178337e-02f, -3.09959203e-02f, 6.28871918e-02f, 3.25163119e-02f, -1.00737497e-01f, -1.82832200e-02f, -1.32671714e-01f,
  -4.33315076e-02f, -9.18278545e-02f, 1.25673518e-01f, -8.13953727e-02f, -1.17870227e-01f, 4.00531329e-02f, 2.17503496e-03f, -4.07508062e-03f, -3.75440419e-02f, 1.31802335e-01f,
  -6.48212852e-03f, -8.35561380e-02f, 1.77207328e-02f, 1.35452047e-01f, 1.42605193e-02f, -1.47232607e-01f, -3.24598746e-03f, 1.76177919e-03f, -3.85389142e-02f, -3.94736882e-03f,
  3.28736976e-02f, 2.34814100e-02f, 3.44722047e-02f, 9.37523693e-02f, 2.68654451e-02f, 9.18393433e-02f, -2.32510611e-05f, 1.20434299e-01f, -9.23050160e-04f, -6.48054704e-02f,
  1.27712842e-02f, -9.83118564e-02f, 6.16415069e-02f, -5.06607555e-02f, -6.31181821e-02f, -1.17192846e-02f, -8.70557129e-02f, -1.49157932e-02f, -8.76091141e-03f, -8.40858892e-02f,
  -3.79970744e-02f, 3.40674259e-02f, -8.93056020e-02f, 2.56469250e-02f, -1.85252670e-02f, 3.79036143e-02f, -3.03171901e-03f, -5.18591851e-02f, -6.60853460e-02f, -7.38782808e-03f,
  1.10189162e-01f, 3.98733746e-03f, -1.80300069e-03f, 4.48378827e-03f, 3.67642678e-02f, -5.13813235e-02f, 2.67953333e-02f, -1.73810404e-02f, 3.29979584e-02f, 3.25879194e-02f,
  -3.42439681e-01f, 1.18886895e-01f, 1.17277689e-02f, -2.43439093e-01f, 2.01639429e-01f, -7.18098059e-02f, -2.54392475e-01f, 1.21278144e-01f, -1.40722543e-02f, 3.02501708e-01f,
  1.48145765e-01f, -1.66209728e-01f, 1.20452762e-01f, -3.96096677e-01f, -5.41680098e-01f, -2.87903666e-01f, -4.77521032e-01f, -5.36261760e-02f, -1.36034429e-01f, 9.13947821e-03f,
  -1.80130765e-01f, -2.84047812e-01f, -2.64049500e-01f, 1.32305533e-01f, 3.01107429e-02f, 2.37924337e-01f, 1.77232504e-01f, 1.28389791e-01f, 5.70903346e-02f, -4.68047000e-02f,
  1.78592326e-03f, 8.01079720e-02f, 1.24457605e-01f, 1.06911464e-02f, 1.82491541e-02f, 6.85024858e-02f, 8.63272771e-02f, 2.78165620e-02f, -3.93642858e-02f, -1.15890838e-01f,
  1.02719022e-02f, -1.21550813e-01f, -9.36422795e-02f, 4.17239815e-02f, 2.43292805e-02f, 6.48068450e-03f, -1.06992841e-01f, -2.26589898e-03f, -3.93157527e-02f, -1.29534543e-01f,
  -1.38224274e-01f, -3.21647748e-02f, -1.18596740e-01f, -8.93084779e-02f, -2.59029996e-02f, 2.19681375e-02f, 4.45292192e-03f, 4.14834544e-02f, -4.50271480e-02f, -2.23969985e-02f,
  -3.24901380e-02f, 5.91555871e-02f, -6.68526739e-02f, 2.22215056e-02f, -1.81167778e-02f, 4.90982309e-02f, -4.23502326e-02f, 1.58551540e-02f, -8.02840889e-02f, 2.67408658e-02f,
  3.59067954e-02f, -5.73008358e-02f, -2.59180181e-02f, 1.94825549e-02f, -1.36078537e-01f, -3.05464212e-02f, 1.99556667e-02f, 3.13132964e-02f, -6.31542280e-02f, -6.05149604e-02f,
  1.12197332e-01f, -4.27883007e-02f, 5.01922034e-02f, 4.04736921e-02f, -1.16111012e-02f, -1.71352699e-02f, -1.41495988e-02f, 1.41937599e-01f, 3.48859206e-02f, 4.38251160e-03f,
  5.48081324e-02f, 9.26726311e-02f, 4.93146386e-03f, 2.62065958e-02f, -7.26622716e-03f, -4.21188176e-02f, -1.24021992e-01f, -6.55497611e-02f, 9.61253233e-03f, -7.77898282e-02f,
  -1.05194673e-02f, 8.65963288e-03f, 9.62010175e-02f, -4.94324155e-02f, 5.71178794e-02f, 1.25568703e-01f, 1.01057597e-01f, -1.15676681e-02f, 2.01102179e-02f, 2.93945447e-02f,
  2.81092264e-02f, -4.54553738e-02f, -1.27141431e-01f, -3.17502916e-02f, -3.55396122e-02f, -1.97476503e-02f, 6.61450103e-02f, 1.30515054e-01f, -6.76444247e-02f, 2.23431215e-02f,
  2.16418058e-01f, -4.11789212e-03f, -6.32886169e-03f, 3.69519591e-01f, 4.12578374e-01f, 4.23455834e-01f, 1.12417750e-01f, 3.00966829e-01f, 5.95290840e-01f, -5.95413819e-02f,
  -8.85401107e-03f, -1.00743257e-01f, -2.23281413e-01f, 1.42062321e-01f, -2.34296527e-02f, -7.74741471e-02f, 1.92236483e-01f, -1.05726803e-02f, 1.82183102e-01f, 3.44417468e-02f,
  1.81810468e-01f, 9.91257504e-02f, -2.94740319e-01f, -1.58191681e-01f, -6.77250400e-02f, -1.59529805e-01f, -2.46281400e-01f, -2.62618482e-01f, -1.05279133e-01f, 2.47407202e-02f,
  5.54672554e-02f, -7.89136346e-03f, -1.54680833e-01f, -1.63212735e-02f, -8.12374204e-02f, -1.66038752e-01f, -1.84601113e-01f, -1.21924095e-01f, 1.76550299e-02f, 1.80713460e-02f,
  -2.45498046e-02f, -1.75432548e-01f, 1.00839444e-01f, 3.94084677e-02f, -4.72305194e-02f, -4.12946418e-02f, 1.04318066e-02f, 5.21787889e-02f, -1.55252460e-02f, 4.01705876e-02f,
  -2.35232636e-02f, 1.75373688e-01f, 2.54494790e-02f, 8.71736631e-02f, 1.58361606e-02f, -1.95399206e-02f, -6.39626803e-03f, -7.76517764e-02f, -4.28552963e-02f, 1.29729465e-01f,
  2.23949552e-02f, 7.59878159e-02f, -1.51855528e-01f, -8.05581436e-02f, 8.64153448e-03f, -2.52158865e-02f, -4.68932875e-02f, -1.76537014e-03f, 7.57795013e-03f, 4.52021062e-02f,
  -5.11160456e-02f, 8.77033547e-02f, 2.82950187e-03f, 6.18707687e-02f, 5.32148480e-02f, 5.51152341e-02f, 4.07142863e-02f, 7.27017736e-03f, 4.17641066e-02f, 7.64880255e-02f,
  7.77392536e-02f, 2.56745610e-02f, -7.15238601e-02f, -4.30023633e-02f, 1.92836747e-02f, 3.19612920e-02f, 3.25116105e-02f, 1.01467706e-01f, 9.75447223e-02f, -5.27301840e-02f,
  1.94183856e-01f, 1.23388678e-01f, -7.59309381e-02f, 1.97298620e-02f, -1.32112997e-02f, -2.06073932e-02f, -3.40709016e-02f, 6.61091283e-02f, 2.74702422e-02f, 7.12341350e-03f,
  4.44614924e-02f, 1.60685610e-02f, 4.04624343e-02f, -1.66540723e-02f, -6.58766776e-02f, 3.64624709e-02f, 1.58443786e-02f, 6.06467240e-02f, 4.00170237e-02f, 2.16670975e-01f,
  1.05160596e-02f, 3.68846990e-02f, -8.55615139e-02f, 4.18952629e-02f, 8.65595564e-02f, -1.88118964e-01f, 6.52111396e-02f, -7.50745758e-02f, -4.16226350e-02f, 8.50320607e-03f,
  -4.91248101e-01f, 2.07663625e-01f, -7.15678409e-02f, -1.26660630e-01f, -8.30835700e-02f, -9.67964008e-02f, -1.20830052e-01f, -1.72375571e-02f, 2.53089756e-01f, 2.93676823e-01f,
  3.29857543e-02f, 1.39090225e-01f, 3.67082417e-01f, -5.86633272e-02f, -1.60011023e-01f, 2.18762815e-01f, -2.56070852e-01f, 9.44046711e-04f, 1.13878191e-01f, -1.76280186e-01f,
  -1.00815423e-01f, -1.09931178e-01f, -1.73059657e-01f, 2.29538962e-01f, -2.65032858e-01f, -1.27220809e-01f, -2.54215360e-01f, 8.02547019e-03f, -3.08222979e-01f, -9.05882120e-02f,
  -3.31549376e-01f, 2.29005404e-02f, -1.91599175e-01f, -8.34967494e-02f, -1.17737770e-01f, -8.46632421e-02f, -1.52970925e-01f, -1.25185763e-02f, 6.97842389e-02f, 7.89699405e-02f,
  -7.31047392e-02f, 9.95530933e-02f, -1.61006600e-02f, 9.95560214e-02f, -2.46248804e-02f, 8.63481592e-03f, -4.01873663e-02f, -4.62621339e-02f, 3.01113464e-02f, 2.23428495e-02f,
  5.81780337e-02f, -1.33132022e-02f, -1.23568900e-01f, -1.90788031e-01f, -3.05086315e-01f, 9.95337665e-02f, -5.75036108e-02f, -1.72109887e-01f, -1.82074383e-01f, 3.39031033e-02f,
  1.42478019e-01f, -1.84579864e-02f, -2.82099489e-02f, 8.90219584e-02f, 5.36130592e-02f, -2.76409481e-02f, -1.96579397e-02f, 9.30873677e-03f, 9.52568278e-03f, -9.89447683e-02f,
  -2.83668377e-02f, -9.01233256e-02f, 1.79071017e-02f, -1.15726292e-01f, 1.69519156e-01f, -1.48879169e-02f, -6.50774688e-02f, -1.67084992e-01f, -6.42945245e-02f, -3.64199020e-02f,
  1.13116831e-01f, -6.19144626e-02f, 6.20733798e-02f, -1.28772452e-01f, 1.23698460e-02f, 3.26272286e-02f, 2.60563614e-03f, -3.17958370e-02f, 3.43118310e-02f, -3.36266980e-02f,
  -4.93202537e-01f, -2.31545433e-01f, -3.15182796e-03f, -2.75535267e-02f, 1.05632702e-03f, -9.83711556e-02f, -3.85959409e-02f, -1.79897234e-01f, 5.08935414e-02f, 6.27026483e-02f,
  -5.21040112e-02f, -5.90377040e-02f, -1.42581314e-01f, -5.50969271e-04f, 3.00299451e-02f, -8.66264775e-02f, -4.61839251e-02f, -6.83458522e-02f, -1.13604896e-01f, -5.50441034e-02f,
  -6.10896759e-03f, -2.62035020e-02f, -4.96252347e-03f, -1.05990730e-01f, -9.66900513e-02f, -1.07919522e-01f, -5.94449192e-02f, -5.51352762e-02f, -1.62821233e-01f, 6.95401877e-02f,
  -2.16183513e-01f, -2.00896055e-01f, -6.44381791e-02f, -2.33925521e-01f, 4.55847196e-02f, -2.75964499e-01f, -1.95366498e-02f, -2.96254098e-01f, -2.40575239e-01f, -1.98109865e-01f,
  -2.03034893e-01f, 1.37458131e-01f, 2.35263050e-01f, -1.18122444e-01f, 9.00555775e-02f, 2.56182462e-01f, -2.16786325e-01f, -1.69535875e-01f, -1.16132442e-02f, -1.08496502e-01f,
  4.24974002e-02f, -7.71769509e-02f, 1.18198529e-01f, -6.16407841e-02f, -2.00028419e-01f, -1.39558345e-01f, 6.67858198e-02f, -6.24419153e-02f, -1.48951337e-01f, -4.87259403e-03f,
  -2.53953695e-01f, -1.03195317e-01f, -5.77308834e-02f, 1.14564290e-02f, -1.88783839e-01f, 2.01071259e-02f, 8.76984075e-02f, 1.94843963e-01f, 1.01279924e-02f, 2.46655755e-02f,
  4.43284251e-02f, -2.87155919e-02f, -8.13943818e-02f, -6.91794157e-02f, -3.29714194e-02f, -5.74304871e-02f, -1.47800326e-01f, -2.70000286e-02f, -4.26580757e-03f, -3.51526663e-02f,
  -8.02392364e-02f, -3.05440072e-02f, -1.69408381e-01f, 3.03368457e-02f, 8.69577304e-02f, -7.42709711e-02f, 6.08319044e-02f, 1.79898605e-01f, 2.58783717e-02f, -4.46709134e-02f,
  -1.42002692e-02f, 7.28830323e-03f, -3.40197701e-03f, -6.80071041e-02f, -1.05279321e-02f, -3.33072916e-02f, 4.65188436e-02f, -1.43504748e-02f, -6.06679730e-02f, -3.88547331e-02f,
  -4.51639071e-02f, 5.88232279e-02f, 1.24318801e-01f, -9.11209956e-02f, -5.72827496e-02f, -2.67074890e-02f, 8.19687471e-02f, -6.25658631e-02f, 1.55575297e-04f, 1.93771645e-02f,
  -1.12295158e-01f, -6.29088655e-02f, -4.31773141e-02f, 3.15620266e-02f, 1.51699889e-04f, 3.68957184e-02f, 1.70408711e-02f, -4.56576571e-02f, -7.39637986e-02f, 1.17357798e-01f,
  -3.50734979e-01f, -2.53310919e-01f, -4.08868380e-02f, -4.03311811e-02f, 1.82408486e-02f, 5.86145036e-02f, 2.99821366e-02f, -3.02467346e-02f, -1.10340722e-01f, 2.68879309e-02f,
  -8.42342675e-02f, 9.60229617e-03f, -6.84129745e-02f, 6.67772591e-02f, 2.74202209e-02f, -1.10343337e-01f, -5.21309972e-02f, 4.35192399e-02f, -3.47039215e-02f, -1.13459013e-01f,
  -4.22017016e-02f, 3.89135140e-03f, 2.22835895e-02f, -5.65153314e-03f, 1.28783852e-01f, -7.11122155e-02f, -8.61459002e-02f, -4.24937829e-02f, -2.84465589e-02f, -9.28200558e-02f,
  3.37722033e-01f, -3.08795333e-01f, 3.35478902e-01f, 2.94064730e-01f, 2.12137207e-01f, 7.36077204e-02f, 2.55967826e-01f, 1.24130193e-02f, 1.32614568e-01f, -2.89342105e-01f,
  -1.04039587e-01f, 1.89912081e-01f, -2.04596385e-01f, -1.80376489e-02f, 2.54625380e-02f, -3.05674195e-01f, 2.13174112e-02f, 6.71456233e-02f, -5.21646813e-02f, 6.91392720e-02f,
  7.34359324e-02f, 1.69947613e-02f, 1.70645975e-02f, -1.94590241e-01f, 3.03735614e-01f, 1.40413105e-01f, -1.18216872e-01f, 3.26118320e-02f, 9.81468894e-03f, -1.06938009e-03f,
  5.23153655e-02f, 4.76471987e-03f, -7.76071995e-02f, -2.97260046e-01f, 7.26908892e-02f, 1.14481322e-01f, -7.73306563e-03f, -1.04730148e-02f, 1.13490351e-01f, -9.23341978e-03f,
  -1.47567661e-02f, -1.78135987e-02f, 7.37336501e-02f, 2.65413318e-02f, -4.52111922e-02f, 1.93045661e-02f, 1.14465736e-01f, 1.99526381e-02f, -3.25400494e-02f, 7.43325651e-02f,
  1.98126376e-01f, 2.84192972e-02f, 5.21364994e-02f, -2.09635366e-02f, 1.71133932e-02f, -5.04300073e-02f, 1.12478048e-01f, 4.24996018e-02f, 1.16256159e-02f, 1.07461832e-01f,
  -1.36395410e-01f, -5.85730076e-02f, 8.67464021e-02f, 1.05435625e-01f, -1.95089765e-02f, 8.13025683e-02f, 7.94934779e-02f, 7.65043497e-03f, 9.69062839e-03f, -7.49402493e-02f,
  -6.29846305e-02f, -1.10403888e-01f, 1.02932952e-01f, -5.01386216e-03f, -1.11908987e-01f, -1.21057900e-02f, 9.08519328e-02f, 5.26962318e-02f, -3.35618854e-03f, -8.20834264e-02f,
  1.02370307e-01f, -1.87386330e-02f, -7.23589361e-02f, 2.33566705e-02f, -5.88107593e-02f, -4.65689190e-02f, -6.79746317e-03f, 5.39952591e-02f, 5.82377464e-02f, -9.47372019e-02f,
  -2.97366679e-01f, -3.64594012e-01f, -1.72724932e-01f, -6.41723499e-02f, -4.36787941e-02f, -9.57037415e-03f, -3.87933627e-02f, 4.83806543e-02f, -8.10983405e-02f, -1.74058266e-02f,
  -3.61199342e-02f, 7.90085420e-02f, -3.63210887e-02f, 8.65279287e-02f, -1.65101305e-01f, -6.68811575e-02f, -1.34609053e-02f, -1.07751429e-01f, -1.20623354e-02f, -1.38275251e-01f,
  -2.02786494e-02f, -6.86144456e-02f, 6.86199665e-02f, 1.54670551e-02f, 1.60354897e-02f, 7.44003057e-02f, 3.20960879e-02f, -7.96253905e-02f, 4.45126109e-02f, 7.14915479e-03f,
  2.20893979e-01f, 3.85449499e-01f, 3.30803841e-01f, 2.33232751e-01f, -1.28406838e-01f, -9.22982991e-02f, -3.59054655e-03f, 2.82081738e-02f, 6.23350255e-02f, 2.03813761e-01f,
  -1.16398066e-01f, 5.18856049e-01f, -1.38462931e-01f, -2.59777270e-02f, -4.08747166e-01f, -3.87167186e-01f, -1.26949817e-01f, 5.72350919e-02f, -3.81069332e-02f, -2.42134519e-02f,
  -4.20471802e-02f, -3.51319462e-01f, -1.56019986e-01f, -1.72160655e-01f, 1.77363291e-01f, 1.82621643e-01f, -3.56507570e-01f, -1.89155206e-01f, 2.04709917e-01f, -1.72696546e-01f,
  -3.84778492e-02f, -7.36963823e-02f, 4.30462435e-02f, -1.26015618e-02f, -5.37083708e-02f, 8.68888423e-02f, 5.79228960e-02f, 3.24708922e-03f, -2.80945860e-02f, 5.34152165e-02f,
  -3.81040424e-02f, -6.71238676e-02f, 5.89448959e-02f, -1.35419235e-01f, -1.85334347e-02f, 5.83452769e-02f, -4.61089201e-02f, 3.64080183e-02f, 7.89304972e-02f, 1.35758162e-01f,
  -1.54416021e-02f, 2.38275737e-01f, 4.31135669e-02f, 5.76887429e-02f, -3.08560636e-02f, 1.00379111e-02f, 6.99455589e-02f, 1.09189451e-01f, 5.20172641e-02f, 1.07070178e-01f,
  3.03909481e-02f, -1.73074841e-01f, -6.62170574e-02f, -5.56024909e-02f, -4.87349257e-02f, -6.82554841e-02f, -3.30222510e-02f, -3.21030207e-02f, -5.37622795e-02f, 1.78105887e-02f,
  -2.84372419e-02f, 1.06964163e-01f, -6.25799671e-02f, 6.39579892e-02f, 5.73124215e-02f, -2.73155533e-02f, -2.40110364e-02f, -2.85179019e-02f, -4.10510786e-02f, 5.31145036e-02f,
  1.54012989e-03f, -2.53836717e-02f, -3.99021357e-02f, -5.73036969e-02f, -1.47679755e-02f, 1.11950571e-02f, 3.77218872e-02f, 1.24348298e-01f, -1.40089979e-02f, -2.64524878e-03f,
  -2.75922686e-01f, -1.28644362e-01f, -4.57504652e-02f, -2.62065511e-02f, -7.10830539e-02f, 2.10123584e-02f, -4.31019813e-03f, 3.20099071e-02f, -3.00701652e-02f, -8.59752372e-02f,
  -4.53269947e-03f, -6.38353527e-02f, 6.41299188e-02f, -3.05797141e-02f, -1.88127980e-01f, 1.23991864e-02f, -3.70774865e-02f, -4.42904513e-03f, 5.35701110e-04f, 9.83272959e-03f,
  4.00987305e-02f, -2.88442671e-02f, -3.60817611e-02f, 3.07583511e-02f, 2.06001829e-02f, 3.52973007e-02f, -2.58490350e-02f, 3.14372703e-02f, -1.08164489e-01f, 2.49530990e-02f,
  5.92281185e-02f, -2.49928951e-01f, -2.52826810e-01f, -1.99291617e-01f, 7.19961822e-02f, -2.95317024e-01f, -2.75635332e-01f, -2.30973378e-01f, -1.22719891e-01f, 2.68345233e-02f,
  -2.19226986e-01f, -1.08572192e-01f, -2.32710578e-02f, -4.84888315e-01f, -2.56509334e-01f, -1.61803171e-01f, -3.27786177e-01f, -1.67286813e-01f, 6.57074228e-02f, -4.34983075e-02f,
  -7.44543746e-02f, -2.33981356e-01f, -3.08349222e-01f, 2.50051878e-02f, -1.25815645e-01f, 1.23864152e-01f, 2.79246539e-01f, 8.33423361e-02f, -8.32603648e-02f, -7.16553926e-02f,
  -5.96557260e-02f, -1.11008793e-01f, -2.01930609e-02f, -8.34062994e-02f, 3.63323279e-02f, 9.37697738e-02f, 3.16057838e-02f, -8.67543742e-03f, 2.14023441e-02f, 7.28061423e-02f,
  1.79625064e-01f, -5.64040337e-03f, -5.78635335e-02f, 4.23514992e-02f, 1.07432172e-01f, -8.00301284e-02f, -1.20349554e-02f, 4.81726415e-02f, -6.94768950e-02f, -1.75159555e-02f,
  -8.71763304e-02f, -4.33778623e-03f, -1.78873762e-02f, 4.34550568e-02f, 8.95415060e-03f, -4.50843722e-02f, -1.71037614e-02f, 7.56635591e-02f, 4.76181321e-02f, 5.38358390e-02f,
  1.01073399e-01f, 1.46936208e-01f, -5.33865616e-02f, -3.82465944e-02f, -2.79062539e-02f, 4.61510010e-03f, -4.31068335e-03f, 1.14663772e-01f, -7.67981214e-03f, 8.73086378e-02f,
  -9.12052169e-02f, -7.95413330e-02f, -5.33691980e-02f, 6.87269494e-02f, 5.50330244e-02f, -6.76562823e-03f, 9.79484059e-03f, -4.87219123e-03f, -1.01527177e-01f, -7.87473693e-02f,
  9.27095786e-02f, -2.28514578e-02f, 2.02121083e-02f, 1.18084818e-01f, -1.19582012e-01f, 1.61202513e-02f, 1.54706987e-03f, 1.98368467e-02f, -6.23827055e-02f, 8.38762894e-02f,
  -4.40721735e-02f, 4.55766544e-02f, -1.16315916e-01f, -6.66202456e-02f, -6.14839084e-02f, -1.69643518e-02f, -6.04616143e-02f, -1.59561336e-01f, 2.97499844e-03f, 1.04718134e-01f,
  3.20460498e-02f, 4.44537774e-02f, 1.00682110e-01f, -1.34379491e-01f, -1.22609148e-02f, -3.64333913e-02f, 1.19036712e-01f, 1.41760120e-02f, 3.24216560e-02f, 1.39384791e-02f,
  3.39970104e-02f, -3.16860504e-03f, 1.10263310e-01f, -7.04502836e-02f, 3.54821272e-02f, 6.07644171e-02f, 8.65110531e-02f, 1.16946734e-01f, 1.13368601e-01f, 2.72824802e-02f,
  3.90682250e-01f, -1.72722250e-01f, -7.67655075e-02f, 1.66707531e-01f, 1.61945567e-01f, -1.77998692e-01f, -1.38060704e-01f, 1.12294577e-01f, 5.30085266e-01f, -2.18768224e-01f,
  6.21845275e-02f, -2.29986250e-01f, -2.87972808e-01f, 7.17651621e-02f, 1.57503933e-01f, -9.98880938e-02f, 1.12632690e-02f, -1.71798170e-01f, 8.77506137e-02f, -1.52817518e-02f,
  3.70242655e-01f, -2.74767894e-02f, -1.18778199e-01f, -1.54557556e-01f, -2.28501260e-01f, 1.42823374e-02f, -1.43400565e-01f, -1.69088751e-01f, 2.31686747e-03f, -2.39543289e-01f,
  -2.50384044e-02f, 8.87848437e-02f, 7.36931637e-02f, 8.52489620e-02f, -1.91316847e-02f, -6.68815151e-02f, -9.94041786e-02f, -1.67315125e-01f, 6.92422837e-02f, 3.99368480e-02f,
  -9.48009118e-02f, 2.85972171e-02f, -7.25982105e-03f, -5.34316823e-02f, 1.39598131e-01f, 7.46284947e-02f, 2.09920689e-01f, 7.37354606e-02f, -1.00623868e-01f, -2.73294188e-02f,
  2.88219191e-02f, -1.11669064e-01f, 1.66236863e-01f, -7.15952665e-02f, 7.64155313e-02f, 1.24919638e-01f, -3.86790112e-02f, -7.23587722e-02f, -2.19295640e-03f, -7.10661011e-03f,
  -7.41387345e-03f, 1.20818252e-02f, -4.50931080e-02f, 1.60089526e-02f, 1.33279264e-02f, 7.02538854e-03f, -4.59243022e-02f, -2.27028634e-02f, 4.22281809e-02f, 2.56875604e-02f,
  -2.60814279e-02f, -2.10081134e-02f, 4.61832248e-02f, -2.03032400e-02f, -8.99610022e-05f, 1.02673106e-01f, 2.71789357e-02f, -7.35583156e-02f, 1.36308940e-02f, -2.25722808e-02f,
  7.84128788e-04f, 4.46310416e-02f, -9.13252532e-02f, -7.29030669e-02f, 8.72364640e-03f, -1.72847807e-02f, 6.68783113e-02f, -8.84314254e-02f, 8.03920925e-02f, -6.10351264e-02f,
  3.94746810e-02f, -1.63201720e-01f, 2.11472046e-02f, -3.21818814e-02f, -7.63417780e-02f, 2.99859475e-02f, -4.07405756e-02f, 8.84048566e-02f, -1.31040007e-01f, -1.33904908e-02f,
  -3.96047048e-02f, -4.31797691e-02f, -4.60607558e-02f, 9.48681831e-02f, 1.93918776e-02f, -2.97106826e-03f, -4.84807454e-02f, -3.58503088e-02f, -1.04485527e-01f, 1.20569840e-01f,
  -2.83841006e-02f, -8.13909173e-02f, -2.32663862e-02f, -5.20982817e-02f, -1.38313777e-03f, -9.25076306e-02f, 4.21941131e-02f, 1.92156639e-02f, 7.03484798e-03f, 1.85981381e-03f,
  -2.85649061e-01f, -1.32049888e-01f, -1.26000613e-01f, 2.90278960e-02f, -9.60692689e-02f, -3.09789866e-01f, -3.97513419e-01f, 1.10826036e-02f, -2.56946295e-01f, -1.89953446e-01f,
  3.56346481e-02f, -1.85239688e-02f, -2.87680835e-01f, 1.73031807e-01f, 2.00093031e-01f, -2.62223512e-01f, 2.62107372e-01f, 4.47504967e-02f, -8.92251357e-02f, 1.10218935e-01f,
  2.30274007e-01f, 1.98004663e-01f, 2.37828821e-01f, 4.24301863e-01f, -1.00954182e-01f, 1.96739703e-01f, 3.65294456e-01f, 9.24452469e-02f, 4.24920350e-01f, 1.62514031e-01f,
  -9.59707350e-02f, -8.85420740e-02f, -8.29643384e-02f, 2.88389344e-02f, -1.54371224e-02f, 4.82152440e-02f, 1.64256562e-02f, 9.29948222e-03f, 4.85109389e-02f, 3.46119404e-02f,
  -6.62298873e-02f, 2.01897785e-01f, 2.13398356e-02f, 6.71111196e-02f, -1.13339946e-02f, 7.58717880e-02f, 1.40484869e-02f, -1.21123984e-01f, 5.26867583e-02f, 1.37741780e-02f,
  9.69459768e-03f, 1.38913700e-03f, -2.34837625e-02f, 9.08123516e-03f, -1.22095942e-01f, -3.42599414e-02f, -7.98838362e-02f, -1.77714657e-02f, 4.79374379e-02f, 4.47899476e-02f,
  1.71320215e-02f, -1.32425860e-01f, -1.03170976e-01f, -4.92177643e-02f, 6.64950022e-03f, -6.53964952e-02f, 1.18951812e-01f, 3.95345129e-03f, -6.01054728e-02f, 1.23364094e-04f,
  -2.91555244e-02f, -4.80333678e-02f, -4.55496050e-02f, 8.09915438e-02f, 4.06811982e-02f, -5.48672192e-02f, 1.81825440e-02f, -1.73734054e-02f, -4.77024503e-02f, -6.71484391e-04f,
  -6.10905997e-02f, 6.17819838e-02f, 6.24441821e-03f, 5.93146347e-02f, -5.97161986e-02f, -1.42508864e-01f, 1.30625591e-01f, -1.09906323e-01f, 5.54858223e-02f, 1.17369846e-01f,
  8.69766101e-02f, 1.35884240e-01f, -8.12815130e-02f, -1.80223933e-03f, 5.14896996e-02f, -9.24002230e-02f, -9.75513607e-02f, 9.04201642e-02f, 9.40759853e-02f, -1.49958013e-02f,
  9.43137780e-02f, 4.31042165e-02f, 2.28300854e-03f, 8.68567973e-02f, 9.31295455e-02f, -7.58387819e-02f, 1.95067078e-02f, -7.51477182e-02f, 7.99300373e-02f, 5.57490662e-02f,
  -9.49879140e-02f, -1.77470997e-01f, -2.63565052e-02f, -2.73568723e-02f, 6.21674247e-02f, -2.41466276e-02f, 2.19683964e-02f, -6.42988756e-02f, 4.63450849e-02f, -3.96083444e-02f,
  8.98577720e-02f, 8.49073380e-02f, -1.30329296e-01f, 2.81257778e-01f, -2.49655366e-01f, -1.39857590e-01f, -3.10934260e-02f, -5.38852951e-03f, -7.47692287e-02f, 1.62564620e-01f,
  2.05892324e-01f, 2.81404275e-02f, 2.33885363e-01f, 2.71411031e-01f, 4.18986045e-02f, 2.75384188e-01f, 1.63705960e-01f, -1.20866019e-02f, -2.24481635e-02f, 2.15223908e-01f,
  1.04119152e-01f, 3.42952639e-01f, 2.20174015e-01f, 1.31752208e-01f, 9.02429149e-02f, -8.11559986e-03f, 2.33816952e-01f, 4.74317297e-02f, 7.26122856e-02f, -1.20363392e-01f,
  1.24529451e-02f, 1.55709371e-01f, -8.24648887e-02f, -9.63986963e-02f, 1.17388193e-03f, 8.13025907e-02f, -6.50871545e-02f, -1.86712623e-01f, -1.28877714e-01f, 9.73802209e-02f,
  2.28620637e-02f, -5.31268492e-02f, 7.99553320e-02f, -1.32244062e-02f, -2.77746953e-02f, -1.22325122e-01f, -4.93804775e-02f, -1.03513308e-01f, -7.24895969e-02f, 1.42726794e-01f,
  1.32239327e-01f, 9.89181250e-02f, 6.33109286e-02f, -5.66076189e-02f, -1.36879189e-02f, 4.99963015e-02f, -5.31890430e-02f, -3.25230211e-02f, 1.03931338e-01f, 8.61231536e-02f,
  3.93524095e-02f, 8.80980343e-02f, 1.17934421e-01f, -9.13814232e-02f, -9.64724198e-02f, -1.05216578e-02f, -2.85941884e-02f, -7.65284449e-02f, -1.52205646e-01f, 1.37705952e-01f,
  1.75765604e-02f, -2.42418684e-02f, 7.29905814e-02f, -7.13921664e-03f, 1.65571153e-01f, 1.25430882e-01f, -4.44776304e-02f, -1.05883822e-01f, -4.74926494e-02f, 8.03540926e-03f,
  -1.62899420e-02f, -2.42763199e-02f, 7.07627181e-03f, 1.92001015e-02f, 6.53146729e-02f, -8.78626853e-02f, 1.31789461e-01f, 1.08522721e-01f, -7.19048604e-02f, -5.02519123e-02f,
  2.68788692e-02f, 3.60430866e-01f, -2.71288436e-02f, -4.89917397e-02f, 2.33039563e-03f, 4.07946616e-04f, -8.35444853e-02f, 5.00875190e-02f, 6.96195588e-02f, 1.24618992e-01f,
  -1.91746764e-02f, -2.87719797e-02f, 7.35535920e-02f, -5.67937903e-02f, -7.08504114e-03f, 2.21152827e-01f, 6.46267608e-02f, -1.18104070e-02f, -2.05317028e-02f, -2.80484487e-03f,
  7.14486986e-02f, 9.48389545e-02f, 4.04709913e-02f, -2.40393892e-01f, -4.68968451e-02f, 1.20800294e-01f, -3.71797383e-02f, -3.82690877e-03f, 7.47512430e-02f, 1.26640767e-01f,
  3.22301298e-01f, -2.54074365e-01f, 2.70851612e-01f, 1.49269104e-01f, 3.73288095e-01f, 2.17702240e-01f, 4.63630825e-01f, 1.76984191e-01f, 1.66365787e-01f, -3.46579581e-01f,
  -1.35788262e-01f, -2.47592419e-01f, 1.32483710e-02f, -3.55570108e-01f, 1.87401578e-01f, -3.32940295e-02f, -3.87443043e-02f, -2.68138111e-01f, 8.76273438e-02f, 6.88237324e-02f,
  1.61290750e-01f, 1.28935203e-01f, 2.22346604e-01f, -8.94864351e-02f, 6.63545728e-02f, -1.42124876e-01f, -3.19940373e-02f, 1.07225120e-01f, -1.44491151e-01f, 1.69456247e-02f,
  -5.16762212e-02f, 9.90386214e-03f, -1.31382778e-01f, -1.57803446e-01f, -3.47383991e-02f, -1.74799655e-02f, 3.27016115e-02f, -2.69976035e-02f, 5.82782961e-02f, 8.26843902e-02f,
  -7.82758221e-02f, -1.58495799e-01f, 9.24589485e-02f, 9.80205461e-02f, 1.76940728e-02f, 3.52895670e-02f, -5.71669117e-02f, -9.77333784e-02f, 3.11443582e-02f, 6.53076405e-03f,
  1.16259702e-01f, -9.41264257e-02f, -3.61693017e-02f, -1.51273191e-01f, 1.05384432e-01f, -4.38231789e-02f, 7.82142654e-02f, -1.25325575e-01f, -1.42475024e-01f, 4.26656753e-02f,
  1.20561592e-01f, 6.68377802e-02f, 3.78021561e-02f, -5.48065491e-02f, -1.21234171e-01f, 6.51673302e-02f, 2.40937769e-02f, 7.71981701e-02f, -5.27702235e-02f, 6.07028650e-03f,
  -6.36894703e-02f, -2.45032795e-02f, -4.50442471e-02f, 5.41267544e-02f, 1.25858327e-02f, -1.11476980e-01f, -1.02031171e-01f, -9.71479416e-02f, -8.54934826e-02f, 4.91611101e-03f,
  9.19401422e-02f, -2.74822880e-02f, 4.03175130e-03f, -5.18761128e-02f, -9.54300631e-03f, -5.06718345e-02f, -7.52373785e-03f, -1.00702643e-01f, 3.67879979e-02f, 3.31828967e-02f,
  -3.92356426e-01f, -3.51843417e-01f, 2.06818082e-03f, -5.67532219e-02f, -1.61104932e-01f, -8.63511786e-02f, 1.29246796e-02f, -9.38218161e-02f, 3.50997527e-03f, -1.18618812e-02f,
  5.90638883e-05f, -3.59735899e-02f, 5.09484224e-02f, -6.26614690e-03f, -3.62674519e-02f, 1.19533077e-01f, -3.10006328e-02f, -1.06684074e-01f, -2.36129351e-02f, -1.28693074e-01f,
  -3.66936922e-02f, -4.65529375e-02f, -4.88726236e-02f, -1.67875476e-02f, -3.42806876e-02f, 1.92310605e-02f, 3.23164463e-02f, -8.99439901e-02f, 3.21972445e-02f, 7.93334004e-03f,
  -5.21120071e-01f, 1.97704479e-01f, -6.21365607e-02f, -4.91891168e-02f, -2.83348113e-01f, -1.60296589e-01f, -1.49536422e-02f, -1.03904501e-01f, -4.79144305e-02f, 2.90212482e-01f,
  6.37783706e-02f, -2.30239779e-01f, 2.17818841e-01f, 9.96456444e-02f, -2.44361311e-01f, 1.55644849e-01f, 6.23584948e-02f, 5.75144887e-02f, 8.63572136e-02f, -1.13478862e-01f,
  -5.26702292e-02f, 6.69322163e-02f, 8.90088230e-02f, 1.24733923e-02f, -1.49419099e-01f, -2.19170935e-02f, 7.22865462e-02f, -1.93401322e-01f, -1.11205123e-01f, -1.79483637e-01f,
  -2.78787404e-01f, -2.08839178e-01f, -7.83354267e-02f, -1.34974852e-01f, -1.24047972e-01f, 2.49098558e-02f, 1.13919144e-02f, -5.81638403e-02f, -1.96907613e-02f, -7.62091205e-02f,
  -1.40626311e-01f, -1.51927605e-01f, -9.01815891e-02f, 3.27310972e-02f, -7.39186928e-02f, -1.91999990e-02f, 5.02210818e-02f, -5.59232272e-02f, 2.96426080e-02f, -7.22507685e-02f,
  -4.64008003e-02f, -4.10439149e-02f, 4.76830266e-02f, 1.48057118e-01f, -8.11348557e-02f, 1.50105543e-02f, 4.24504243e-02f, -9.73210670e-03f, -1.86154485e-01f, -2.75936555e-02f,
  -1.22005427e-02f, 7.71654174e-02f, -1.25552649e-02f, -6.02621771e-02f, -5.36792427e-02f, -4.54299524e-03f, 1.00617357e-01f, 1.14914803e-02f, -4.52152267e-02f, -3.15533653e-02f,
  -2.79474873e-02f, -1.07223988e-01f, -1.11277020e-02f, 4.07948457e-02f, 4.12383899e-02f, -1.08408488e-01f, -5.67056425e-02f, -7.96702355e-02f, 6.26431555e-02f, 8.59473795e-02f,
  -2.76690312e-02f, -1.07623219e-01f, 1.54843135e-02f, 6.60202280e-02f, -8.95447806e-02f, 3.09466547e-03f, 3.22607420e-02f, -7.57105127e-02f, 3.64852659e-02f, -7.82719627e-02f,
  -3.10808510e-01f, -2.82376796e-01f, -2.98477430e-02f, -8.84836242e-02f, 1.08935293e-02f, -1.02884099e-01f, 4.28217761e-02f, -6.95451126e-02f, -4.06232923e-02f, -1.27643868e-01f,
  -1.99133471e-01f, -5.55536188e-02f, -5.33582531e-02f, 4.17070240e-02f, -5.95334992e-02f, 2.78119743e-02f, 2.85780872e-03f, -1.23041257e-01f, -9.75207984e-02f, -3.30165289e-02f,
  -2.19526924e-02f, 8.00309703e-02f, 7.63553940e-03f, 6.27739429e-02f, 9.11473110e-02f, -5.58963679e-02f, -1.64040014e-01f, -3.33580412e-02f, -8.31920207e-02f, 6.04349971e-02f,
  -3.61638695e-01f, -2.08871476e-02f, -4.04402107e-01f, 3.31109129e-02f, 1.41675562e-01f, 3.59400213e-01f, 8.80804434e-02f, -4.91475053e-02f, -3.45672965e-01f, 2.55844891e-01f,
  2.69372255e-01f, -2.87900686e-01f, -9.12856832e-02f, 2.39415899e-01f, 1.73870120e-02f, 4.10078913e-02f, 3.13197851e-01f, 2.38359183e-01f, -5.84764294e-02f, 8.17497596e-02f,
  -8.28363746e-02f, 3.44659954e-01f, 4.23832759e-02f, 9.75095555e-02f, 8.39333013e-02f, -8.15198794e-02f, 1.83786094e-01f, -8.27592164e-02f, 2.53071338e-01f, -3.81097966e-03f,
  7.65866712e-02f, -1.65460199e-01f, -1.63117629e-02f, -1.44690916e-01f, 1.17961712e-01f, 4.60368656e-02f, 5.43890893e-02f, -3.88500057e-02f, -1.25834830e-02f, -5.82200773e-02f,
  2.77332738e-02f, -3.02010737e-02f, -2.84338766e-03f, 7.87020326e-02f, -6.41003400e-02f, -1.53553970e-02f, -2.11326219e-02f, -6.57247156e-02f, -1.78444590e-02f, -2.80719250e-02f,
  -4.62150387e-02f, 4.24058735e-02f, -9.05625336e-03f, 2.68843658e-02f, -6.19848967e-02f, -4.62517589e-02f, 6.67209402e-02f, -1.12771913e-01f, 5.86899966e-02f, 7.02945981e-03f,
  -8.72311369e-03f, 5.15681459e-03f, -7.35474825e-02f, 4.61696647e-02f, 4.88554537e-02f, 1.52893499e-01f, 1.40940294e-01f, 6.98135421e-02f, -7.57481456e-02f, 6.24238886e-02f,
  -7.67423287e-02f, -2.99727023e-02f, -7.17781857e-03f, 6.66206181e-02f, 1.15652559e-02f, -1.37875257e-02f, -7.06135929e-02f, -3.31820436e-02f, -3.80226225e-02f, -2.42649508e-03f,
  7.53669515e-02f, -2.75931098e-02f, 3.77519690e-02f, 6.83124214e-02f, -4.96045500e-02f, -3.66046354e-02f, 1.74029842e-02f, 8.01467279e-04f, 1.41326442e-01f, 3.61453258e-02f,
  2.34781280e-01f, 7.01020211e-02f, -7.03856945e-02f, 4.28001471e-02f, 2.19412372e-02f, 3.99521999e-02f, -1.02828480e-02f, -9.23112258e-02f, 4.82261665e-02f, -1.80734601e-02f,
  -5.87300817e-03f, -6.33391226e-03f, 3.58835459e-02f, -1.19539529e-01f, 1.13014253e-02f, 1.51833907e-01f, 7.21133575e-02f, -2.15863865e-02f, 3.60325798e-02f, 1.33838028e-01f,
  8.12187418e-02f, -1.12869209e-02f, -3.47852036e-02f, -2.10839678e-02f, 4.79775593e-02f, 7.17959404e-02f, 1.96465269e-01f, -1.11997072e-02f, 3.28535885e-02f, -2.82765012e-02f,
  2.85161018e-01f, 5.63639142e-02f, -1.37163177e-01f, -8.71824622e-02f, 1.21026132e-02f, 1.19876042e-01f, 1.18031595e-02f, -2.05425359e-02f, 3.10093071e-02f, 1.05255596e-01f,
  1.61582921e-02f, 1.34467483e-01f, -1.35953009e-01f, 2.08957151e-01f, 1.97051555e-01f, -4.64472994e-02f, 2.17676595e-01f, 1.24689974e-01f, -3.76663171e-02f, 2.86842495e-01f,
  -1.43832946e-02f, 1.72791362e-01f, -2.52629548e-01f, -3.54144275e-02f, -8.32546279e-02f, -1.31207615e-01f, -1.31960541e-01f, -1.69845626e-01f, -5.76374307e-02f, 2.40133312e-02f,
  3.92978080e-02f, -4.23708260e-02f, -8.54693260e-03f, 1.61975268e-02f, 5.53755648e-03f, 4.38448898e-02f, -1.06904641e-01f, -1.39020830e-01f, 1.47451982e-02f, -1.03815891e-01f,
  -4.18527517e-03f, 6.06387481e-02f, 9.84784067e-02f, 2.98850890e-02f, 5.36452085e-02f, -9.17576775e-02f, 8.72246921e-02f, -1.78820983e-01f, -3.98440845e-02f, 1.21324919e-02f,
  -2.35675778e-02f, -9.64742899e-02f, 1.29312053e-02f, -5.78130037e-02f, -8.43134001e-02f, 1.38800228e-02f, 9.27317813e-02f, -5.53663038e-02f, -6.52712509e-02f, 8.05753544e-02f,
  6.29172176e-02f, -4.63762283e-02f, 8.11045691e-02f, -4.51362282e-02f, 3.78891341e-02f, 1.25600705e-02f, 6.47547469e-02f, 2.14299578e-02f, 5.17982095e-02f, 6.53020218e-02f,
  -2.92019024e-02f, -9.48768035e-02f, -9.31495354e-02f, 3.62020023e-02f, 2.59182323e-02f, -4.36506458e-02f, -4.48890403e-03f, 1.72135253e-02f, 3.02918367e-02f, -1.41548157e-01f,
  -7.46979713e-02f, 1.28691122e-01f, 9.82445478e-02f, -2.05510911e-02f, 1.00569436e-02f, -6.34892210e-02f, -3.18414718e-02f, -9.05411169e-02f, 3.42739262e-02f, 1.21146046e-01f,
  2.55838875e-02f, 2.26872042e-01f, 9.09264460e-02f, 2.97647268e-02f, 2.20398009e-02f, 5.25638722e-02f, 3.50033417e-02f, 8.49761367e-02f, 8.25364739e-02f, 7.10257813e-02f,
  8.66930634e-02f, 6.77767619e-02f, -2.68606655e-02f, 2.19589006e-02f, -1.15036676e-02f, 5.91224991e-02f, 1.73897706e-02f, -3.94624360e-02f, 1.79245770e-01f, 3.84987071e-02f,
  -3.94866243e-02f, 7.89914951e-02f, 6.11909591e-02f, -3.19858715e-02f, -4.31333575e-03f, 1.35653634e-02f, 2.00868413e-01f, 2.36471038e-04f, 2.92042084e-02f, 3.66913937e-02f,
  -5.41617215e-01f, 1.95572540e-01f, 2.47141719e-01f, -7.94954132e-03f, -3.08341175e-01f, 4.54466075e-01f, 5.76246500e-01f, -8.79366025e-02f, 8.65388885e-02f, 2.93823987e-01f,
  1.73295334e-01f, 1.88757434e-01f, 2.10251153e-01f, 2.09101558e-01f, 2.08361164e-01f, 2.36134470e-01f, 1.15412302e-01f, 1.82035446e-01f, -1.17348380e-01f, -1.80835664e-01f,
  -1.96967319e-01f, -3.69767584e-02f, 1.19699866e-01f, -2.26463154e-01f, -1.00923046e-01f, -1.51004225e-01f, -1.36330575e-02f, 1.74848199e-01f, -4.81223874e-02f, 1.25866055e-01f,
  -2.34021351e-01f, -1.58402145e-01f, -2.34525427e-01f, 3.21073458e-02f, 9.62341949e-03f, -6.13644607e-02f, 1.63937449e-01f, 1.78329006e-01f, -2.51873098e-02f, -1.79005563e-02f,
  5.45760021e-02f, -2.85425950e-02f, -5.65479286e-02f, 1.82113610e-02f, 2.62807477e-02f, 1.64010953e-02f, -2.73693725e-02f, -8.94725099e-02f, 5.49933016e-02f, -5.23903556e-02f,
  9.39655975e-02f, 1.74814798e-02f, -2.38106847e-02f, 7.43638799e-02f, 2.65239943e-02f, 9.03002918e-02f, 7.12154582e-02f, 4.62816991e-02f, -3.32266539e-02f, -1.10496305e-01f,
  -3.13093551e-02f, -4.32651024e-03f, 3.37061659e-02f, -6.21786565e-02f, 1.83754750e-02f, -1.06843323e-01f, 5.03666475e-02f, -2.65496243e-02f, 7.90688768e-02f, -1.09287903e-01f,
  -3.29008661e-02f, -6.25324920e-02f, -7.66319111e-02f, -2.35563051e-02f, 1.77363250e-02f, 1.01382183e-02f, 1.18899150e-02f, -8.93425792e-02f, 7.67404139e-02f, -1.63832065e-02f,
  -2.56207976e-02f, 1.28775127e-02f, -5.07990131e-03f, 7.17187524e-02f, -5.00984639e-02f, 5.52755482e-02f, 5.51769398e-02f, -1.19813740e-01f, -3.92954610e-03f, 3.88044827e-02f,
  -8.97701457e-02f, -5.33519918e-03f, -3.01905777e-02f, -1.02383811e-02f, 4.87267636e-02f, -4.67216820e-02f, 5.10084406e-02f, -6.28307611e-02f, 7.05517679e-02f, 2.33488362e-02f,
  2.85672490e-02f, -6.40966073e-02f, -5.21343127e-02f, -2.33804323e-02f, 1.75451413e-02f, 2.25819759e-02f, 1.24954753e-01f, -9.15265270e-03f, 8.73059966e-03f, -4.68200725e-03f,
  -1.57095417e-02f, 3.71766533e-03f, 5.92202321e-02f, -4.38932218e-02f, 4.67898138e-02f, 7.49421343e-02f, -1.48272812e-01f, -6.34180428e-03f, -1.12154171e-01f, 5.80447055e-02f,
  -9.28505138e-02f, -2.74295747e-01f, -2.43535824e-02f, 8.10000598e-02f, 2.34288827e-01f, 8.06830302e-02f, -1.81765750e-01f, 1.60784319e-01f, -2.25385621e-01f, -1.16760649e-01f,
  -1.15989655e-01f, -2.28723302e-01f, -3.75013590e-01f, -2.36102432e-01f, -1.76589817e-01f, -3.97408038e-01f, -3.92673053e-02f, -4.96216528e-02f, -1.74209192e-01f, 6.42290264e-02f,
  1.07624538e-01f, 2.21385732e-01f, 1.89056039e-01f, 3.08632612e-01f, 1.50387540e-01f, 3.98857445e-01f, 2.84628808e-01f, 1.27265692e-01f, 3.00902843e-01f, -1.64913703e-02f,
  -3.24414149e-02f, -1.19095802e-01f, 1.15694171e-02f, 3.66597250e-02f, 1.22023970e-01f, 1.51192486e-01f, 9.51429904e-02f, -4.01024073e-02f, 5.40767275e-02f, -7.06913322e-02f,
  -2.66435742e-02f, -2.70986906e-03f, -2.36483384e-02f, 1.34370141e-02f, 5.63988201e-02f, -2.51590554e-02f, 9.16433055e-03f, 1.15698412e-01f, -4.71705198e-02f, -1.42895088e-01f,
  1.38579309e-02f, 5.11083081e-02f, 9.93045345e-02f, 8.32503140e-02f, -8.32968280e-02f, -5.09637967e-02f, 4.77642342e-02f, 3.75120118e-02f, 8.75026546e-03f, -2.00686939e-02f,
  2.93872814e-04f, 7.23402128e-02f, -1.13302097e-01f, -1.44181430e-01f, -9.79953334e-02f, -4.35148068e-02f, -1.30628720e-01f, -2.63088550e-02f, -9.12481099e-02f, 1.94613468e-02f,
  7.19528124e-02f, 2.35153381e-02f, -1.08079046e-01f, 2.68751327e-02f, 5.71873412e-02f, 6.68961927e-03f, 1.36835858e-01f, -5.78688607e-02f, -6.45016320e-03f, -1.28303180e-02f,
  -1.21883377e-01f, -3.09515838e-03f, 1.08354539e-01f, 5.69371656e-02f, -7.66934827e-02f, 5.29688112e-02f, -6.47096112e-02f, -1.00902831e-02f, 1.74876824e-02f, 3.50766070e-02f,
  7.66366795e-02f, -9.15987194e-02f, -7.84660876e-02f, -1.44197404e-01f, -2.80661695e-02f, -4.65442017e-02f, -1.34809256e-01f, 2.35079546e-02f, 5.97890802e-02f, -2.02967152e-02f,
  1.86019465e-01f, 1.14518970e-01f, 1.15010021e-02f, 1.97434705e-02f, 3.85259204e-02f, -2.23222207e-02f, -6.76240996e-02f, 1.76946536e-01f, 9.17391479e-02f, 3.36014554e-02f,
  1.34058565e-01f, 4.44165841e-02f, 3.21702822e-03f, 6.68368712e-02f, -2.84323357e-02f, 7.89505169e-02f, 6.27047271e-02f, 1.10716283e-01f, -4.17487174e-02f, -1.08905382e-01f,
  -2.13147521e-01f, 1.71267733e-01f, 2.18158085e-02f, 9.16383713e-02f, -2.42321584e-02f, -2.59768248e-01f, -1.93729669e-01f, 7.94735029e-02f, -2.25799382e-02f, 1.11993439e-01f,
  -4.76220995e-02f, -2.08749715e-02f, 2.03755543e-01f, 4.13316600e-02f, -1.83223024e-01f, -2.01579049e-01f, -1.07146516e-01f, -1.18413299e-01f, 2.37588175e-02f, 2.64069960e-02f,
  1.05550094e-02f, -6.68064132e-02f, 6.40571192e-02f, 1.42285973e-01f, 2.61393711e-02f, 1.96581900e-01f, 2.76878595e-01f, 1.38403088e-01f, 7.70028979e-02f, -9.86505672e-02f,
  -1.34027943e-01f, 3.17358063e-03f, -3.37502756e-03f, -8.43636096e-02f, -1.25435084e-01f, -6.17314503e-02f, -6.22865325e-03f, -1.08886063e-02f, 3.80433956e-03f, -1.52325584e-02f,
  -3.06326728e-02f, 1.46076456e-02f, 4.80139144e-02f, -3.74011658e-02f, -1.08394980e-01f, 2.01725289e-02f, 6.83252886e-02f, 1.17607620e-02f, -6.22832179e-02f, -5.32239377e-02f,
  -2.86719110e-02f, -4.74471077e-02f, 8.95124972e-02f, -9.90150496e-02f, -4.71354909e-02f, 4.66291942e-02f, -6.56343997e-02f, 1.17252860e-02f, 1.16859786e-01f, -6.46025613e-02f,
  2.02142410e-02f, -4.75131907e-02f, -1.20015778e-02f, 6.71110451e-02f, 5.75869009e-02f, -1.39536098e-01f, -8.20405409e-03f, -8.91015008e-02f, -3.47855389e-02f, -1.02056734e-01f,
  -7.36721605e-02f, -4.24906872e-02f, 9.47940908e-03f, -1.62400901e-02f, -5.92741705e-02f, 4.51856628e-02f, -1.63615774e-02f, 1.02020234e-01f, -7.83164874e-02f, -1.05370693e-01f,
  9.13863331e-02f, 5.53876422e-02f, -4.20601331e-02f, -6.00119233e-02f, -1.37217501e-02f, 8.01035762e-02f, 8.21198523e-02f, -1.12249605e-01f, 1.03927277e-01f, 5.11642396e-02f,
  -1.87269747e-02f, 2.65448749e-01f, -3.84691395e-02f, -1.72324166e-01f, -4.40347614e-03f, -8.35650191e-02f, 3.35137211e-02f, 4.37926203e-02f, 1.17481567e-01f, 1.55640617e-02f,
  8.43856856e-02f, -1.61127634e-02f, 2.39338577e-02f, -6.84996098e-02f, -1.42472647e-02f, -3.08613782e-03f, 1.41067356e-01f, 5.89677207e-02f, 1.71727806e-01f, 1.08449660e-01f,
  2.11682290e-01f, 1.06224932e-01f, 7.63267949e-02f, 5.50250290e-03f, -3.70993651e-02f, 1.03693288e-02f, 7.71057904e-02f, -8.66522267e-03f, 1.69390929e-03f, -7.56440684e-02f,
  2.97701269e-01f, -2.91845739e-01f, -4.03352499e-01f, 6.65997639e-02f, 9.98868346e-02f, 1.24400117e-01f, -5.53413406e-02f, 1.74033474e-02f, -2.21364290e-01f, -5.99576235e-02f,
  2.35559925e-01f, -4.25367914e-02f, -2.12654844e-01f, 2.76807010e-01f, 2.61232138e-01f, -2.86504954e-01f, 3.44849706e-01f, 2.14581817e-01f, -1.01965524e-01f, 6.53399825e-02f,
  1.51137471e-01f, 4.09906030e-01f, 1.80298835e-02f, 3.26155365e-01f, 1.70991257e-01f, -7.27138817e-02f, 2.04344347e-01f, -1.14173204e-01f, 2.36488283e-01f, 2.03077272e-01f,
  3.56277749e-02f, -2.07175631e-02f, -3.13837044e-02f, 1.13775814e-02f, -3.57117392e-02f, 3.60153988e-02f, -7.87679404e-02f, 5.88118099e-03f, -7.71555528e-02f, -4.13892008e-02f,
  -1.40070155e-01f, 2.99286470e-02f, 8.21941644e-02f, 6.21297546e-02f, 5.15656210e-02f, -9.39745754e-02f, -1.80015236e-01f, -1.23185948e-01f, -5.37749492e-02f, -6.83137402e-02f,
  -2.05000788e-01f, 3.87961627e-03f, 8.34222697e-03f, -3.54209282e-02f, -7.24203512e-02f, -2.24983189e-02f, -4.42048013e-02f, -6.28438592e-02f, -2.01180261e-02f, 1.07971646e-01f,
  1.51725709e-01f, 3.21967565e-02f, 4.22328338e-02f, 7.19312504e-02f, -6.74140304e-02f, -5.53325564e-02f, 5.71420379e-02f, 4.48618736e-03f, -8.11111927e-02f, 2.14415342e-02f,
  -2.68074367e-02f, -7.25854784e-02f, 4.92269397e-02f, 2.71003582e-02f, 9.51340608e-03f, 4.34661806e-02f, -2.52266545e-02f, -1.09999627e-01f, -1.28283441e-01f, -4.03897353e-02f,
  5.14429137e-02f, 9.06446427e-02f, -4.93437313e-02f, 2.74237599e-02f, 7.33664110e-02f, -7.85115361e-02f, 1.49114937e-01f, 8.60126913e-02f, -8.83352533e-02f, 6.22156337e-02f,
  -6.18579797e-02f, -6.04847930e-02f, -7.06114396e-02f, 2.21847408e-02f, -3.33918110e-02f, 4.66679782e-02f, 3.09752673e-02f, 5.03845699e-02f, 7.18884990e-02f, -5.21515682e-02f,
  -5.09393103e-02f, -1.78682152e-02f, -2.79132426e-02f, -4.94308546e-02f, 6.12191409e-02f, 7.06631839e-02f, -1.58217084e-02f, -4.35146578e-02f, -2.34193355e-02f, -7.90491700e-02f,
  -1.92067982e-03f, -1.34227961e-01f, 9.74733084e-02f, -1.53813839e-01f, -5.74000292e-02f, -1.74816307e-02f, 3.93989347e-02f, 1.05335591e-02f, 7.48294964e-03f, -2.98449323e-02f,
  1.58279672e-01f, -2.31468618e-01f, 2.73451000e-01f, -7.00997338e-02f, 3.86384390e-02f, 1.98110938e-02f, -3.50945219e-02f, -1.78688332e-01f, -3.55539192e-03f, -2.89171278e-01f,
  -4.81701009e-02f, 6.43810034e-02f, 1.96816340e-01f, -1.78211436e-01f, 3.50848556e-01f, 5.57651371e-02f, -5.88997900e-02f, 3.01160365e-02f, -6.62202667e-03f, -1.32636443e-01f,
  -3.57371382e-02f, -2.88464844e-01f, -8.52352846e-03f, -2.45565534e-01f, -1.34545118e-01f, -7.60368332e-02f, -2.08549742e-02f, 1.60392020e-02f, -3.06219369e-01f, 6.70193732e-02f,
  -5.14578708e-02f, -9.54283699e-02f, -1.32942677e-01f, -1.96521580e-01f, -1.11356294e-02f, 8.49036500e-02f, -7.45542198e-02f, 1.32144436e-01f, 4.59926128e-02f, -9.79914442e-02f,
  -3.44188213e-02f, -2.96154004e-02f, -2.06494257e-01f, 3.35829034e-02f, -1.31943509e-01f, -1.00242957e-01f, -8.82092044e-02f, -1.68653965e-01f, 3.60909738e-02f, 1.52551055e-01f,
  1.56302854e-01f, 6.31190538e-02f, -5.97123206e-02f, 1.32347001e-02f, 1.09505625e-02f, -6.23995289e-02f, 1.89644266e-02f, 1.35714576e-01f, -7.22499937e-02f, 7.10862875e-02f,
  9.77561101e-02f, -2.98188929e-03f, -2.45702639e-02f, -6.61949888e-02f, -1.80523098e-02f, 1.19205844e-02f, -2.47603450e-02f, -2.83194836e-02f, -3.07339001e-02f, 2.04146793e-03f,
  1.09184049e-01f, -1.27881914e-02f, 3.68013345e-02f, 7.18522668e-02f, 4.38491032e-02f, -1.01495609e-01f, -7.79114524e-03f, 8.23069736e-02f, 8.23410600e-02f, -5.28334305e-02f,
  -4.36343364e-02f, -1.05295647e-02f, 9.18757915e-02f, 8.27813298e-02f, 5.89760654e-02f, 5.20884842e-02f, -2.64882036e-02f, 1.91295221e-01f, -4.16292017e-03f, 1.34563837e-02f,
  -1.85198843e-01f, -2.75082707e-01f, -5.05287498e-02f, -7.24260956e-02f, -1.01829693e-01f, -5.12182750e-02f, -8.48462656e-02f, -2.94524226e-02f, -5.69985248e-02f, -1.53023973e-01f,
  -1.06715098e-01f, -6.26615956e-02f, 3.17076780e-02f, 9.23345536e-02f, -1.56171158e-01f, -5.96534722e-02f, -1.27388999e-01f, -1.01524055e-01f, -1.15788737e-02f, 1.54064707e-02f,
  6.89752325e-02f, -8.99328664e-02f, 2.98911426e-02f, -3.57831642e-02f, -6.19893000e-02f, 9.47638601e-02f, 1.18859358e-01f, 6.00658208e-02f, -5.36282547e-03f, 1.15801590e-02f,
  -4.49337482e-01f, 1.31849289e-01f, 3.19936126e-01f, -3.19479108e-01f, 2.83515781e-01f, 3.15997690e-01f, 3.29903141e-02f, 8.94635320e-02f, -1.45722285e-01f, -2.28163674e-01f,
  -1.54390410e-01f, 4.17591594e-02f, 4.60641785e-03f, -1.22355811e-01f, 1.50701240e-01f, -1.03256926e-02f, 2.24568578e-03f, -9.55466256e-02f, 3.82705070e-02f, 1.96692161e-02f,
  4.73862439e-02f, -1.56200137e-02f, 1.97865024e-01f, 1.67018294e-01f, 1.33340552e-01f, -6.37614429e-02f, -1.23492226e-01f, 2.04058707e-01f, 9.86271277e-02f, 2.29835913e-01f,
  -1.75670102e-01f, -3.72039676e-01f, -8.21729526e-02f, -6.66355640e-02f, 2.42058802e-02f, -7.23065156e-03f, -8.23612064e-02f, -5.04365340e-02f, -1.30127102e-01f, -9.51853674e-03f,
  1.78936962e-02f, 6.76840991e-02f, -8.44703913e-02f, 1.08203879e-02f, -6.59849942e-02f, 7.07545727e-02f, 6.63856566e-02f, 1.70084257e-02f, 1.79069210e-02f, 1.75489232e-01f,
  1.32792532e-01f, -2.63455696e-02f, -6.38835132e-02f, 1.42856184e-02f, 7.81683624e-02f, -4.37069908e-02f, 2.80370209e-02f, 5.71004935e-02f, 1.17240913e-01f, -1.27836421e-01f,
  1.22565337e-01f, 3.95080494e-03f, 1.20672472e-01f, 1.07354736e-02f, -7.03608757e-03f, 4.96666282e-02f, -1.60410367e-02f, -1.08224429e-01f, 5.93817281e-03f, -2.40390142e-03f,
  -1.27922967e-01f, -7.97211006e-03f, -1.01111852e-01f, 1.00794278e-01f, 1.70720028e-04f, -4.09604684e-02f, 5.52479625e-02f, -8.42794329e-02f, -8.62808153e-02f, 2.40450315e-02f,
  -2.29100864e-02f, -8.22794959e-02f, 9.86825377e-02f, -6.81813061e-03f, -1.67950075e-02f, -8.39169994e-02f, -4.82690986e-03f, -4.67887111e-02f, -3.06881815e-02f, -1.13862474e-02f,
  -3.06656837e-01f, -3.95915985e-01f, -1.75906196e-01f, -6.38578087e-02f, -4.08739457e-03f, 1.09271638e-01f, 5.64175658e-02f, -2.23604422e-02f, -4.88983616e-02f, -1.42105043e-01f,
  1.09965056e-01f, -5.25143966e-02f, -2.38853041e-02f, 1.04445312e-02f, -1.19888713e-03f, 3.40421349e-02f, -1.58520088e-01f, -1.16377182e-01f, -1.33665636e-01f, 5.92786670e-02f,
  -7.17577115e-02f, -1.15758352e-01f, 6.95373788e-02f, -5.28105423e-02f, 1.60941053e-02f, -4.25206237e-02f, -6.40979176e-03f, 8.78694816e-04f, 1.54638693e-01f, 1.01686940e-01f,
  -2.25472391e-01f, 1.69743299e-01f, -8.46393034e-02f, 1.07313715e-01f, 8.52019414e-02f, -2.50751764e-01f, -2.29913935e-01f, 1.48250893e-01f, -1.52468368e-01f, 1.05034091e-01f,
  6.98459372e-02f, -9.81250405e-02f, 2.03557357e-01f, -6.61782175e-02f, -2.56775469e-01f, -1.87094823e-01f, -1.17147550e-01f, -1.36394873e-01f, -9.36435014e-02f, 1.57094300e-01f,
  -1.50401676e-02f, 1.79186419e-01f, -5.94084226e-02f, 8.34959820e-02f, 4.47220281e-02f, 1.92846626e-01f, 3.04533720e-01f, 2.55098760e-01f, 1.30074233e-01f, -3.14824991e-02f,
  -8.41731951e-02f, 1.46965787e-01f, -3.08033396e-02f, -8.35841522e-02f, -2.15029134e-03f, 9.39243138e-02f, -5.93796186e-02f, 6.41070381e-02f, -5.00433519e-02f, -4.84942086e-02f,
  7.71142915e-02f, -2.83266790e-02f, -4.70836051e-02f, -7.87665024e-02f, 3.30403410e-02f, 1.09647587e-01f, 8.60132501e-02f, -7.48668686e-02f, -1.14238180e-01f, -6.26728684e-02f,
  8.26832186e-03f, -5.36702537e-05f, 3.55051793e-02f, -8.44427049e-02f, 9.44651384e-03f, 5.20554222e-02f, -2.66652238e-02f, 7.57762417e-02f, -5.00121973e-02f, -7.29461620e-03f,
  3.32536288e-02f, -3.97403277e-02f, -8.30982104e-02f, -1.31578967e-01f, 7.46809170e-02f, 3.94124277e-02f, -4.00532223e-02f, 2.42856815e-02f, -6.73644543e-02f, 9.52966511e-02f,
  4.53566797e-02f, -1.18387314e-02f, -1.02025367e-01f, -1.68701552e-03f, 3.49852294e-02f, -4.52977456e-02f, -2.83029266e-02f, 2.74111591e-02f, 3.23452614e-02f, -4.01376188e-02f,
  4.34870645e-02f, 2.11152695e-02f, 6.53899182e-03f, -1.60404723e-02f, -4.23741937e-02f, 9.14709419e-02f, 9.37405676e-02f, -2.06212997e-02f, 8.86868387e-02f, 9.48990788e-03f,
  1.11994281e-01f, 2.27650657e-01f, 1.89804658e-02f, -3.04074306e-02f, -4.24097925e-02f, -4.70309891e-02f, -1.80979624e-01f, 5.39943911e-02f, 1.67337619e-02f, 3.08532380e-02f,
  1.31897151e-01f, 2.55924836e-02f, -7.08923116e-02f, 6.04986809e-02f, 3.11127491e-02f, 1.67653292e-01f, 6.39341474e-02f, 1.85486618e-02f, 3.32570560e-02f, 6.07075617e-02f,
  5.85065149e-02f, 5.15154488e-02f, -8.27497914e-02f, -7.26000145e-02f, -4.02796920e-03f, 4.81105484e-02f, 1.18187489e-02f, 8.07091892e-02f, 7.15206414e-02f, -1.53461881e-02f,
  -2.73654401e-01f, 2.84493834e-01f, 3.71055156e-01f, -1.21667147e-01f, -5.51826805e-02f, 1.55851543e-01f, -2.88232621e-02f, 3.12386930e-01f, 6.48852214e-02f, -1.55331820e-01f,
  -1.43703893e-01f, -6.82695135e-02f, 9.19166952e-02f, -1.04836993e-01f, 1.68913618e-01f, 2.71870375e-01f, 6.45999908e-02f, -3.81549373e-02f, 2.36192688e-01f, 5.18794507e-02f,
  7.95071870e-02f, -2.59912014e-01f, 4.26099375e-02f, 1.14032179e-01f, -1.94995582e-01f, 9.28755105e-02f, -1.83176041e-01f, -1.03802998e-02f, -1.24421045e-01f, 4.17775102e-02f,
  4.18329984e-02f, 1.37973800e-01f, 3.82001139e-02f, 7.73770213e-02f, 2.33425777e-02f, -5.68044819e-02f, 7.21576856e-04f, 1.21101774e-02f, -1.14907266e-03f, -1.79624930e-02f,
  -1.19854890e-01f, -3.50798434e-03f, -1.20167740e-01f, -1.34424925e-01f, 3.44671719e-02f, -4.79509756e-02f, -2.27221679e-02f, 3.59227806e-02f, 8.03870261e-02f, -1.26832100e-02f,
  2.28383020e-02f, 4.57118936e-02f, -6.78772628e-02f, 9.28750858e-02f, 6.12264313e-02f, 6.88518658e-02f, 1.35404706e-01f, -2.35259868e-02f, 4.11977246e-02f, 3.99809852e-02f,
  5.68813682e-02f, 1.19405560e-01f, -8.19294378e-02f, -6.20106794e-02f, -9.18613002e-02f, 9.98530304e-04f, -7.07846656e-02f, -9.86770540e-02f, 6.25188276e-02f, -1.34167999e-01f,
  -1.07866824e-02f, 2.68452298e-02f, 1.92819424e-02f, -3.18159573e-02f, -7.84099549e-02f, -4.91703860e-03f, -7.62025639e-02f, 7.59426355e-02f, -1.82000324e-02f, -1.08592518e-01f,
  -6.68581501e-02f, -3.46872285e-02f, -3.01765855e-02f, -2.37803608e-02f, 1.94774717e-02f, -4.34704013e-02f, -1.12748235e-01f, -4.29217219e-02f, 1.91534553e-02f, -2.53313016e-02f,
  2.24021345e-01f, 4.22569424e-01f, 1.17266245e-01f, 5.47877587e-02f, 1.85519084e-02f, -6.49999529e-02f, 1.05439723e-01f, -3.83648127e-02f, 5.93756773e-02f, 1.25766948e-01f,
  -1.10507965e-01f, -6.57152832e-02f, -1.29035100e-01f, -1.23547964e-01f, -5.55133820e-02f, 7.06981421e-02f, 7.10648745e-02f, 3.65712531e-02f, 1.81870274e-02f, 8.29735622e-02f,
  -7.84036741e-02f, 2.02147532e-02f, -7.75733143e-02f, -6.69339299e-02f, -1.17472075e-02f, -1.36165880e-02f, -1.38473895e-03f, 7.32645988e-02f, -6.14219764e-03f, 7.36573040e-02f,
  8.65147449e-03f, -3.27159703e-01f, -5.99035919e-02f, -5.96273392e-02f, -1.42997708e-02f, -2.93031931e-01f, -2.16986850e-01f, -1.80435866e-01f, -6.94341213e-02f, -6.02642149e-02f,
  -3.38310711e-02f, 1.50348932e-01f, 1.58467472e-01f, -3.26218307e-01f, 1.63483545e-01f, 8.78288969e-02f, -3.16631615e-01f, -6.44833967e-03f, 1.68398023e-02f, -1.60451636e-01f,
  -1.67399973e-01f, -1.93684682e-01f, 7.15606380e-03f, -2.27830663e-01f, -1.10113844e-01f, -4.42872979e-02f, 1.87170610e-01f, 9.04813409e-02f, -2.08061650e-01f, 2.15614915e-01f,
  -5.50028384e-02f, 7.53560662e-02f, -2.23313980e-02f, -4.84385043e-02f, -1.15627289e-01f, 4.42504650e-03f, -9.59351957e-02f, 2.41001233e-01f, 1.31402165e-01f, 6.20616749e-02f,
  9.48407799e-02f, 1.48026915e-02f, -5.65079302e-02f, 1.17739670e-01f, -1.13623574e-01f, 8.24159980e-02f, 1.19518071e-01f, 3.91293466e-02f, 3.61483172e-02f, 8.70691538e-02f,
  -4.01968025e-02f, -8.37593339e-03f, -2.26257485e-03f, 2.88194465e-03f, -3.36380675e-02f, -3.05634327e-02f, 3.05377431e-02f, 1.89430602e-02f, -7.95101821e-02f, 6.74542561e-02f,
  -1.45524785e-01f, 4.01997082e-02f, -6.93160221e-02f, -1.44189028e-02f, 8.13093856e-02f, 4.85066809e-02f, -6.93142489e-02f, 2.69023869e-02f, -3.08579449e-02f, -1.83946304e-02f,
  -4.25584354e-02f, 3.56370807e-02f, -1.39528140e-01f, -9.13778245e-02f, -9.77512971e-02f, 9.98389050e-02f, -3.96481864e-02f, 4.49388511e-02f, -6.49597496e-02f, -1.22343779e-01f,
  1.65917635e-01f, 6.03830889e-02f, 9.36289877e-02f, -1.02502443e-02f, -5.58325499e-02f, 2.35780515e-02f, 3.83363198e-03f, -9.01696365e-03f, 1.46918654e-01f, -2.09979769e-02f,
  -5.01124263e-02f, 1.60985589e-02f, 3.38222506e-03f, 9.72933974e-03f, 6.16426207e-02f, 1.11780167e-01f, -1.13051459e-01f, -9.09457430e-02f, 6.35077581e-02f, -1.00215316e-01f,
  -9.49156582e-02f, 9.06357449e-03f, -1.29032731e-01f, -8.94150212e-02f, -7.21018296e-03f, -9.96318907e-02f, 1.66227937e-01f, 9.32551101e-02f, -4.59256321e-02f, 8.24588537e-02f,
  1.97073147e-02f, 2.23068863e-01f, 7.56894201e-02f, -3.27196270e-02f, 4.14962322e-02f, -3.54517847e-02f, -6.59622997e-02f, -5.69299012e-02f, 1.88455824e-02f, 2.48896945e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.91765711e-01f, 2.54056722e-01f, 2.28140220e-01f, 9.75209400e-02f, 1.89988002e-01f, 2.80459464e-01f, 1.19294092e-01f, 4.06119257e-01f, 1.34423837e-01f, 1.02729619e-01f,
  1.30854577e-01f, 3.15893665e-02f, 2.99416874e-02f, 3.18853855e-01f, 2.08633572e-01f, 3.48908395e-01f, 1.23508289e-01f, 3.27281296e-01f, 2.34745726e-01f, 2.83200473e-01f,
  1.16761558e-01f, 1.82680979e-01f, 2.55286962e-01f, 9.18617547e-02f, 3.06808621e-01f, 1.79351792e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.26405203e-01f, -3.50366123e-02f, 5.16250469e-02f, 1.07581966e-01f, -1.64127171e-01f, -1.55045956e-01f, -1.69095993e-01f, -2.75495410e-01f, -9.11222324e-02f, -2.66593963e-01f,
  9.26139653e-02f, -6.55359253e-02f, -9.83309280e-03f, 1.63525313e-01f, -2.64316916e-01f, -1.07886270e-01f, 1.46160737e-01f, -3.36291194e-02f, -8.60981792e-02f, 3.26347470e-01f,
  2.18298584e-02f, 1.35254815e-01f, 8.51617306e-02f, 2.56104648e-01f, 6.46106824e-02f, -1.82015762e-01f, 2.89588809e-01f, 8.75045061e-02f, -1.00524120e-01f, -5.78833409e-02f,
  -1.68319851e-01f, -2.47122757e-02f, -2.25263629e-02f, 3.16453390e-02f, -5.45120202e-02f, 1.57736182e-01f, -1.74641386e-01f, -1.84034213e-01f, 5.20595834e-02f, -2.26380050e-01f,
  2.68854260e-01f, 1.84701666e-01f, -2.46990919e-01f, -4.87379410e-04f, 2.89667517e-01f, -1.89237177e-01f, -3.75572085e-01f, 1.90116256e-01f, -2.07103357e-01f, -1.90346479e-01f,
  1.13015957e-01f, 8.88662189e-02f, 1.68578953e-01f, 1.99489012e-01f, -1.79263070e-01f, 2.29345471e-01f, -7.82159418e-02f, -2.35662255e-02f, -1.01557113e-01f, 1.05403349e-01f,
  1.09742083e-01f, 8.33360851e-02f, 4.83708419e-02f, 2.98627824e-01f, 1.00127831e-01f, -3.46639683e-03f, 9.91833657e-02f, -2.68792599e-01f, -1.83049276e-01f, 6.70315558e-03f,
  -1.96300030e-01f, -1.58600155e-02f, -1.09460436e-01f, -2.87339807e-01f, 2.04830989e-01f, 6.33714199e-02f, -3.68163735e-02f, -4.12543975e-02f, -3.77275974e-01f, -1.78188160e-02f,
  1.19502448e-01f, 4.89454530e-02f, 4.30236250e-01f, 2.79055893e-01f, 1.94821253e-01f, -2.53802463e-02f, 1.82136834e-01f, 1.33499339e-01f, -1.62560433e-01f, -1.00366816e-01f,
  8.27327073e-02f, 9.67030153e-02f, -3.12998116e-01f, 1.25170853e-02f, 8.14836547e-02f, 7.33455718e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.87852889e-01f, 1.35522336e-01f, 2.27529019e-01f, 1.37020469e-01f, -3.53636235e-01f, 8.59866589e-02f, -1.20810941e-01f, -1.40185818e-01f, 5.30992858e-02f, -6.52743410e-03f,
  3.14794511e-01f, -9.64482427e-02f, -1.20793976e-01f, -1.36127576e-01f, -1.10663384e-01f, 3.02035660e-01f, -5.20389043e-02f, 1.23277038e-01f, 2.27151930e-01f, -3.57766300e-01f,
  1.15426198e-01f, 3.94072294e-01f, 2.50916660e-01f, 2.85918504e-01f, 1.75145239e-01f, 1.17877960e-01f, 3.64014983e-01f, -2.00312942e-01f, -2.49840736e-01f, 3.50028947e-02f,
  -6.68342039e-02f, -1.56908985e-02f, 4.54639122e-02f, 1.14499606e-01f, 2.37299651e-01f, -3.87592643e-01f, 7.20400661e-02f, 1.89784870e-01f, 5.43780923e-02f, 2.09738031e-01f,
  -4.49814498e-02f, -3.71201664e-01f, 4.14843261e-01f, 2.31994957e-01f, -1.59631342e-01f, 4.51451279e-02f, 9.36450511e-02f, -3.83328736e-01f, 4.26519364e-02f, 3.94728094e-01f,
  1.74368814e-01f, -1.17574878e-01f, 7.68855885e-02f, 1.33868158e-01f, 2.54765004e-01f, 1.77430242e-01f, 1.04480408e-01f, 8.67338032e-02f, 1.67699605e-01f, 2.55336761e-02f,
  -1.12872332e-01f, 1.00494310e-01f, 1.63274497e-01f, -2.16086134e-01f, 1.47641838e-01f, -4.02166173e-02f, 7.41850510e-02f, 1.76645204e-01f, -4.02008176e-01f, 2.49613538e-01f,
  8.82510841e-02f, -1.57619357e-01f, 1.41688854e-01f, 2.63314933e-01f, 1.93851277e-01f, 2.34575704e-01f, 2.21553743e-02f, -2.25658163e-01f, -2.11797804e-01f, 2.99898297e-01f,
  5.67464866e-02f, -3.34877014e-01f, 3.85194004e-01f, -1.36904061e-01f, 2.32977673e-01f, 1.97721615e-01f, 1.48692921e-01f, 2.18742177e-01f, -1.78063631e-01f, 1.89142838e-01f,
  1.45505637e-01f, -1.60676017e-01f, -7.49464706e-02f, 2.32118130e-01f, 1.87522322e-01f, 2.30659261e-01f, 3.09255552e-02f, 1.16431564e-01f, 6.72488064e-02f, 2.38858070e-02f,
  2.73437351e-01f, -2.66997635e-01f, 1.11075059e-01f, 3.47912520e-01f, -2.94584841e-01f, 7.18715228e-03f, 1.91160619e-01f, -6.78888485e-02f, -5.67611046e-02f, 5.08062005e-01f,
  4.86174822e-01f, 7.76500106e-02f, 4.41855490e-01f, -5.04723974e-02f, -1.83772579e-01f, 4.22612220e-01f, -8.23976398e-02f, -2.57835258e-03f, -3.13656554e-02f, -1.68510556e-01f,
  1.71543926e-01f, -3.71219814e-02f, 8.34414139e-02f, 1.44101515e-01f, -1.12068959e-01f, -1.66094348e-01f, -2.44487554e-01f, 4.56288829e-02f, -8.07586610e-02f, 1.93313062e-02f,
  1.95221499e-01f, -2.04649851e-01f, 2.79811382e-01f, 1.96232080e-01f, 3.27811390e-01f, 5.10197639e-01f, -1.46565950e-02f, 3.26775640e-01f, -1.86320528e-01f, 1.82727203e-01f,
  -8.98041483e-03f, 2.52613425e-01f, 5.56953251e-01f, 3.19309980e-02f, 4.59294133e-02f, 4.75239873e-01f, -1.86049610e-01f, -2.76558012e-01f, 5.96831217e-02f, 1.02113798e-01f,
  -1.59648284e-01f, -2.52079993e-01f, 2.24379048e-01f, 2.69368052e-01f, 1.45724267e-01f, 1.64807420e-02f, 5.58465049e-02f, 1.62458077e-01f, -4.04826365e-02f, -1.15353791e-02f,
  1.10531271e-01f, 1.14763953e-01f, 1.01774827e-01f, -3.35090458e-02f, 8.65754932e-02f, 2.88697690e-01f, 2.20977664e-01f, 1.68030813e-01f, 1.26949102e-01f, 4.16044099e-03f,
  3.15430433e-01f, 1.80398509e-01f, -1.74793229e-01f, 1.40943691e-01f, 3.69547382e-02f, -1.42685592e-01f, 1.17045261e-01f, 2.99190104e-01f, 1.11187913e-03f, 2.92548649e-02f,
  -1.35813564e-01f, -7.79544264e-02f, 1.62404999e-01f, -1.51968792e-01f, 2.15748504e-01f, 2.54960388e-01f, 1.64267838e-01f, 3.45468707e-02f, 2.27627009e-01f, 1.71119571e-01f,
  2.02501535e-01f, -1.47762433e-01f, -9.21642780e-02f, -1.77697256e-01f, -3.97192352e-02f, -1.31791100e-01f, -1.43587381e-01f, -1.32017985e-01f, 8.47059786e-02f, 4.16593179e-02f,
  -1.27724141e-01f, -4.89168018e-02f, -1.25649050e-01f, 9.81672108e-02f, 1.96228176e-01f, -8.45629349e-02f, -2.45902792e-01f, 3.04876179e-01f, 1.62492067e-01f, -1.18440352e-01f,
  2.30149329e-01f, 4.43675332e-02f, 3.50721329e-01f, 1.19104251e-01f, -2.02336952e-01f, 1.54625494e-02f, -9.42131430e-02f, -2.88074836e-03f, -2.49095205e-02f, 3.21875699e-02f,
  -2.29888290e-01f, -8.97568986e-02f, -1.75045267e-01f, 2.61617094e-01f, 3.00079316e-01f, 2.68613458e-01f, 2.93630604e-02f, 2.20239926e-02f, 2.20735520e-01f, -3.30254585e-01f,
  6.10684901e-02f, 1.57301202e-01f, -2.58720398e-01f, -1.12968393e-01f, -7.96864703e-02f, -1.20331228e-01f, 2.67248362e-01f, 4.68709588e-01f, 3.63127649e-01f, 1.94048643e-01f,
  3.28621924e-01f, 2.28506345e-02f, -2.80877411e-01f, 4.68839228e-01f, -1.07326932e-01f, 6.23186044e-02f, 8.48280918e-03f, -6.14454076e-02f, 1.87988788e-01f, -1.20663323e-01f,
  1.31386250e-01f, 3.75396967e-01f, 6.92123249e-02f, -2.27173552e-01f, -6.15547001e-02f, 3.57665241e-01f, -1.40868321e-01f, -3.93014662e-02f, -7.89593458e-02f, -1.61120787e-01f,
  -3.42354625e-02f, 1.62757546e-01f, 2.07906529e-01f, 2.63531119e-01f, 1.47931233e-01f, 1.21073209e-01f, -5.41044921e-02f, 2.26091698e-01f, 1.91846579e-01f, -1.74361080e-01f,
  -9.16610956e-02f, 2.02948585e-01f, 7.03583881e-02f, 8.53614137e-02f, 2.74295777e-01f, -8.14975500e-02f, 1.59413368e-01f, 2.89789885e-02f, -1.34382891e-02f, -2.35377282e-01f,
  6.14049286e-02f, 3.18686396e-01f, -7.36193135e-02f, -4.95889671e-02f, -1.98227644e-01f, 2.49187380e-01f, -1.87577922e-02f, 2.98115551e-01f, 7.48215616e-02f, 2.93938726e-01f,
  2.64239669e-01f, 1.10775214e-02f, 2.36110553e-01f, 3.04859430e-01f, 2.93161869e-01f, 1.66269198e-01f, 3.36010993e-01f, 1.88539937e-01f, 4.26178753e-01f, 6.24023899e-02f,
  -2.27277756e-01f, 1.01155296e-01f, -5.46351075e-02f, -2.99760699e-01f, 2.21436635e-01f, 4.98588055e-01f, -2.69479632e-01f, 2.33840704e-01f, 2.00659949e-02f, -8.16674456e-02f,
  9.26108435e-02f, -1.23639688e-01f, 5.05780458e-01f, 2.46718213e-01f, 7.60225207e-02f, -2.04081703e-02f, 1.81918800e-01f, -2.59692594e-02f, 4.80374336e-01f, -2.23827049e-01f,
  3.02139729e-01f, 3.46537679e-02f, 4.35488224e-02f, 2.16525868e-01f, -2.47185081e-01f, 1.99438900e-01f, -9.20831859e-02f, -1.69894323e-01f, -5.66418804e-02f, -1.21586844e-01f,
  3.55048686e-01f, 6.57626018e-02f, -2.87884921e-01f, 1.44596770e-01f, -1.96076930e-01f, 2.27115471e-02f, 2.07261905e-01f, 6.67401776e-02f, 9.39090252e-02f, 1.87821791e-01f,
  -1.22960493e-01f, 1.19006500e-01f, 1.89142972e-01f, -3.09647154e-02f, 2.26299271e-01f, -1.40366256e-01f, 4.23829466e-01f, 1.03865296e-01f, -2.72974730e-01f, -7.87416548e-02f,
  -4.37218808e-02f, -7.62459561e-02f, 5.24785556e-02f, 2.06160918e-01f, -6.11923896e-02f, 1.65973231e-01f, 2.75769047e-02f, 2.07905248e-02f, 2.74003297e-01f, -1.33447513e-01f,
  2.81557798e-01f, 3.74689341e-01f, -3.90997589e-01f, 5.04553735e-01f, 4.23918217e-01f, 8.75478834e-02f, -1.27067164e-01f, -2.27584466e-02f, -1.26265392e-01f, 3.56548540e-02f,
  1.19864820e-02f, 1.93658859e-01f, 2.37572908e-01f, 1.41471758e-01f, -1.18031032e-01f, 3.66862029e-01f, -2.74640828e-01f, 3.38575547e-03f, -1.74390197e-01f, 4.86095510e-02f,
  4.50209647e-01f, 4.75401357e-02f, 3.24209243e-01f, 2.14159802e-01f, 1.44349888e-01f, 2.32595071e-01f, 1.40533894e-01f, -3.56452614e-01f, 1.56024203e-01f, 3.01722527e-01f,
  2.85713881e-01f, 2.50005722e-01f, 2.32702613e-01f, 2.06422836e-01f, -3.03292107e-02f, 5.34855783e-01f, 2.57076956e-02f, 5.32867154e-03f, 3.70556235e-01f, -3.47060770e-01f,
  -1.23256236e-01f, 3.05083185e-01f, 1.31340563e-01f, -2.34014913e-01f, 3.09671879e-01f, 7.73163140e-02f, -8.17849711e-02f, 1.54035062e-01f, -1.17217461e-02f, 1.63272455e-01f,
  1.85372472e-01f, -1.62410051e-01f, 2.00440124e-01f, -7.69835804e-03f, 8.74340236e-02f, -1.13799013e-01f, -1.38537645e-01f, -8.20924044e-02f, -6.71541467e-02f, -3.41332018e-01f,
  9.13188607e-02f, 8.25230926e-02f, 2.87205249e-01f, 1.98974401e-01f, -6.39360175e-02f, -4.99581546e-02f, -1.29743353e-01f, 3.26040804e-01f, 2.37802789e-01f, -2.32958138e-01f,
  -3.11872721e-01f, 3.55547249e-01f, 2.30141252e-01f, 2.08945066e-01f, 2.98797041e-01f, -4.33416776e-02f, 9.90477279e-02f, -1.88523859e-01f, -7.35375881e-02f, -2.01406077e-01f,
  2.61547975e-02f, 2.87250191e-01f, -4.94566001e-02f, 8.54424685e-02f, -2.58603334e-01f, 2.94548869e-01f, 1.04534701e-01f, 2.67092049e-01f, 1.40030801e-01f, 8.58261436e-02f,
  2.57329166e-01f, 4.12196107e-02f, 1.66619316e-01f, -2.42141604e-01f, 1.16342202e-01f, 2.19778791e-01f, 9.90445167e-02f, 2.87948400e-01f, 3.70728574e-03f, -4.91926074e-03f,
  -1.08812712e-02f, 1.98722199e-01f, 3.82450163e-01f, 2.81597763e-01f, 2.16082811e-01f, -8.97922218e-02f, -2.97678649e-01f, 1.00973405e-01f, 1.03305735e-01f, 8.32863748e-02f,
  2.49943342e-02f, -1.02354571e-01f, 1.90235332e-01f, 7.26351365e-02f, -2.30620936e-01f, 1.14106737e-01f, 8.19636136e-02f, -8.57701972e-02f, 1.94015682e-01f, 1.96724221e-01f,
  1.88613772e-01f, 2.46148467e-01f, 1.11111201e-01f, -7.61744305e-02f, -3.70521881e-02f, -2.85064608e-01f, -9.44709852e-02f, -7.26886541e-02f, 7.44177699e-02f, -1.06268287e-01f,
  9.95156094e-02f, 4.41103816e-01f, 4.02403176e-01f, 5.44868931e-02f, -2.71147937e-01f, 1.10643566e-01f, -1.08360291e-01f, -8.29135031e-02f, 7.64603019e-02f, 1.60729229e-01f,
  2.90698349e-01f, 2.61304565e-02f, 5.77688310e-03f, 4.49044317e-01f, -2.54120886e-01f, 2.47505624e-02f, -2.36228466e-01f, 2.90091574e-01f, 7.88581520e-02f, -1.93148628e-01f,
  2.61651605e-01f, 3.64685595e-01f, 7.95425661e-03f, 2.09114537e-01f, 1.53923094e-01f, -4.21080798e-01f, 1.96460813e-01f, 1.27621725e-01f, -1.05200067e-01f, 2.04758778e-01f,
  -1.81309253e-01f, -4.14292216e-01f, 3.26159090e-01f, 2.43898511e-01f, -2.22482264e-01f, 1.15729466e-01f, -1.57393999e-02f, -3.98049563e-01f, -3.62128997e-03f, 2.72085309e-01f,
  3.62683207e-01f, -6.26880676e-02f, -1.65314451e-01f, 1.68641433e-02f, 3.04312646e-01f, 7.36784339e-02f, 1.98406518e-01f, 5.35399318e-02f, -2.99006738e-02f, -4.21440229e-03f,
  -2.18661308e-01f, 6.58498779e-02f, 2.08497956e-01f, -1.50965586e-01f, 2.09307168e-02f, -9.44942981e-02f, 2.42783517e-01f, 2.17064217e-01f, -2.89062828e-01f, 1.98321253e-01f,
  9.79683027e-02f, -1.55254245e-01f, 7.61558488e-02f, 3.05144936e-01f, 1.48758283e-02f, -2.19070449e-01f, 5.41637391e-02f, -3.52138057e-02f, 4.80313450e-02f, 2.32035682e-01f,
  -1.09655552e-01f, 1.31466523e-01f, 5.18259034e-02f, -2.98335552e-01f, 1.16058610e-01f, 3.24664414e-01f, 4.99199033e-02f, 1.96360797e-01f, 3.14916670e-01f, 9.52599570e-02f,
  3.47156376e-01f, -2.09528774e-01f, -8.25588703e-02f, 2.40942195e-01f, -2.89512008e-01f, 7.20325485e-02f, 3.17770511e-01f, 2.48132169e-01f, 2.70011395e-01f, -1.85463391e-02f,
  9.60806012e-02f, -3.57385010e-01f, -9.72947329e-02f, -1.01312272e-01f, 1.29954934e-01f, -2.82986164e-01f, 2.34880462e-01f, 3.05602532e-02f, -3.61148193e-02f, 2.63419807e-01f,
  2.38805309e-01f, -4.08849180e-01f, 1.63769171e-01f, 2.97599379e-02f, -1.19597606e-01f, 2.65677810e-01f, 2.25146040e-01f, 2.23250180e-01f, 1.28363550e-01f, 2.68267363e-01f,
  9.46704149e-02f, -1.40961796e-01f, 8.67163539e-02f, 2.96654433e-01f, 3.11434835e-01f, -2.99078137e-01f, 3.81335109e-01f, -1.51049867e-01f, 1.37136981e-01f, 1.96044087e-01f,
  2.14328691e-01f, 1.67869508e-01f, -2.09717453e-01f, 1.80600867e-01f, -1.70771219e-02f, 4.21270877e-02f, -7.87923560e-02f, 1.84143811e-01f, 2.10324615e-01f, -5.72283506e-01f,
  -2.48991311e-01f, 2.74424225e-01f, -4.49542217e-02f, 2.15992838e-01f, 3.09645951e-01f, 4.50625598e-01f, -2.84967702e-02f, 2.92731877e-02f, -2.12333620e-01f, 2.69973755e-01f,
  6.67040199e-02f, -2.78925031e-01f, 5.63431740e-01f, 2.45651692e-01f, 4.57002968e-01f, -2.96212733e-02f, -5.70184104e-02f, 1.95128933e-01f, -2.81481266e-01f, -3.88592370e-02f,
  1.75317422e-01f, 3.35058004e-01f, -8.81661288e-03f, -5.63737797e-03f, 1.19983986e-01f, -3.69470447e-01f, 2.12330446e-02f, 1.80509135e-01f, -9.05897319e-02f, -1.00767789e-02f,
  -1.13843970e-01f, 5.31186424e-02f, 3.74780953e-01f, 3.71449232e-01f, 2.49105275e-01f, 9.80376303e-02f, 1.89311840e-02f, -1.84760187e-02f, -1.86708331e-01f, 1.23507611e-01f,
  -1.37782916e-01f, 2.28059478e-02f, 1.10628694e-01f, 6.71603829e-02f, -9.02209580e-02f, -1.17692672e-01f, 1.07036993e-01f, 3.82476628e-01f, 1.70736447e-01f, -1.26046345e-01f,
  -7.98072591e-02f, 2.69266665e-01f, 3.20133343e-02f, -2.08317931e-03f, 1.68555334e-01f, 1.86589345e-01f, -2.51319796e-01f, 1.30108288e-02f, 2.71543711e-01f, -1.23219028e-01f,
  4.11749005e-01f, 4.74413753e-01f, -2.99918622e-01f, -3.43338363e-02f, 2.22494617e-01f, 6.48854151e-02f, 9.02912840e-02f, 2.18596786e-01f, -2.43328840e-01f, -1.38285547e-01f,
  1.67966983e-03f, 1.52680039e-01f, 4.54473168e-01f, 4.82569814e-01f, -2.62771577e-01f, 1.43764317e-01f, -7.19749704e-02f, 1.97807834e-01f, -1.02675356e-01f, 5.88260666e-02f,
  4.75948215e-01f, 2.06222147e-01f, -4.72456105e-02f, 8.73660371e-02f, -7.64756054e-02f, 1.40923634e-01f, 8.95149708e-02f, -2.07817495e-01f, 1.04956299e-01f, 1.21907346e-01f,
  3.56553227e-01f, 3.40416282e-01f, 3.29586506e-01f, 4.10598576e-01f, -1.28865868e-01f, 3.96995693e-01f, 1.87709853e-01f, 4.09763120e-02f, 2.49158934e-01f, 8.78195018e-02f,
  -1.70749351e-01f, 2.34667599e-01f, -2.75173672e-02f, -1.21838279e-01f, 3.72408450e-01f, 1.58188775e-01f, -1.31668940e-01f, 1.36250541e-01f, 3.54566313e-02f, 1.76498845e-01f,
  -1.30551113e-02f, -7.33427936e-04f, 3.27935666e-01f, 2.11440593e-01f, 2.01909259e-01f, 2.90271919e-02f, 2.97584921e-01f, -7.77189014e-03f, 8.06118995e-02f, 3.94565165e-01f,
  -3.96304071e-01f, 1.78328380e-01f, 6.04847707e-02f, -2.28567228e-01f, 1.79406852e-01f, 1.24001674e-01f, 7.14679062e-02f, -3.54379565e-01f, 1.44300563e-02f, -1.30551279e-01f,
  -2.07089722e-01f, 2.97876298e-01f, 1.75120700e-02f, 3.51836264e-01f, -8.32821503e-02f, -2.59674311e-01f, -5.08780293e-02f, 4.78981942e-01f, 3.25295851e-02f, 5.61888795e-03f,
  3.12172771e-01f, 1.44232037e-02f, 5.57801425e-01f, -1.01685851e-04f, 4.09114324e-02f, -6.16266578e-02f, -3.57994288e-01f, -7.41039440e-02f, 2.72268593e-01f, 3.98363739e-01f,
  2.76242465e-01f, 2.31177449e-01f, 1.61375850e-01f, -1.71084419e-01f, -1.93349093e-01f, -1.55600935e-01f, -5.59259243e-02f, -1.46125153e-01f, 3.61000657e-01f, 1.10987388e-01f,
  3.60148735e-02f, 4.03444469e-01f, -4.06042337e-02f, -1.73367918e-01f, 1.49301499e-01f, 1.13395974e-01f, -1.18761867e-01f, 4.18557614e-01f, -2.13238940e-01f, -5.46618849e-02f,
  1.46135077e-01f, 2.37299576e-01f, 1.67580485e-01f, -1.87144578e-01f, 7.00204596e-02f, 4.16910976e-01f, 2.75743335e-01f, -2.73878872e-01f, 2.47314841e-01f, 2.27251370e-03f,
  3.69449615e-01f, 6.61772788e-02f, 1.23127386e-01f, -1.73369080e-01f, -1.09015308e-01f, -3.23153585e-01f, -3.44466716e-01f, -1.54262632e-01f, -7.26536512e-02f, -3.37297320e-01f,
  2.23962530e-01f, 2.71092474e-01f, 2.88354289e-02f, 3.20100449e-02f, -1.48694683e-02f, -2.91783035e-01f, -4.43181574e-01f, -2.02353358e-01f, 3.29208016e-01f, -1.10387035e-01f,
  3.49000007e-01f, 4.54576373e-01f, 2.40664840e-01f, 6.44271433e-01f, -3.02755386e-01f, -2.51218021e-01f, -2.71855369e-02f, -1.11832529e-01f, -1.86122105e-01f, -1.53388992e-01f,
  2.22155601e-01f, 4.85271076e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.46794373e-01f, 7.19893947e-02f, 1.22363992e-01f, 1.56446368e-01f, 8.72680768e-02f, 6.58406466e-02f, -9.45238769e-02f, 3.04717064e-01f, -8.80216435e-02f, 6.51454180e-02f,
  1.43262178e-01f, 9.39186737e-02f, 1.97490647e-01f, -1.07641362e-01f, 2.32118502e-01f, 3.01891506e-01f, 2.31481984e-01f, 1.99018076e-01f, 3.18012863e-01f, 7.92539567e-02f,
  3.20420563e-01f, 2.08916634e-01f, 2.16258764e-01f, 6.15167320e-02f, 1.80125460e-01f, 2.63659656e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -8.30261260e-02f, -2.11086169e-01f, -3.37885879e-03f, -1.86030179e-01f, 1.79820880e-01f, -3.34913917e-02f, -1.16327986e-01f, -6.90814778e-02f, -1.30327782e-02f, -2.59138525e-01f,
  4.39353436e-02f, -3.32780629e-02f, 1.27751362e-02f, -1.18781164e-01f, 1.61414951e-01f, 1.02263242e-01f, -1.95322007e-01f, 1.84382141e-01f, -1.66173592e-01f, 1.68302312e-01f,
  -1.61198378e-01f, -1.45219401e-01f, 2.78076082e-02f, 5.20699397e-02f, -2.57756412e-01f, 1.02936916e-01f, -2.13572234e-01f, 1.84319110e-03f, 1.33065954e-01f, -3.69810872e-02f,
  -2.03032762e-01f, -1.13124281e-01f, 7.15374425e-02f, -1.71588007e-02f, 1.35925680e-01f, -1.90951884e-01f, 2.07026750e-01f, 3.12252989e-04f, -4.67428705e-03f, -3.56468335e-02f,
  5.21218143e-02f, -7.62088522e-02f, 2.41172407e-02f, 1.92257185e-02f, -4.04281635e-03f, 1.26669809e-01f, 1.12473309e-01f, -1.81812420e-01f, -5.86286746e-02f, 1.38341516e-01f,
  1.22138940e-01f, -3.99098359e-02f, 1.24273777e-01f, 1.55460835e-01f, -7.92797580e-02f, 1.35416105e-01f, -8.58718976e-02f, -4.06995043e-02f, -3.99848670e-02f, 1.88455999e-01f,
  2.06142545e-01f, -1.44728214e-01f, -3.16791497e-02f, 1.19733447e-02f, -1.07410118e-01f, -1.91294923e-01f, 9.77088511e-02f, -1.62085608e-01f, -7.87944794e-02f, -6.31904081e-02f,
  -1.56837374e-01f, 3.17349806e-02f, -2.45018341e-02f, 1.64971441e-01f, 7.89538547e-02f, -9.15854648e-02f, 1.03990577e-01f, 1.19819239e-01f, -9.68585238e-02f, -9.20867771e-02f,
  2.40174588e-02f, -1.07992543e-02f, -1.11052401e-01f, -8.07026401e-02f, 1.80871040e-01f, 3.82512584e-02f, -5.86730503e-02f, -1.08926460e-01f, 1.53633893e-01f, -1.40176117e-01f,
  -4.19342052e-03f, 1.11095414e-01f, 2.14852369e-03f, -8.06904510e-02f, -4.44164723e-02f, 1.68754607e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -7.07862601e-02f, -8.34903307e-03f, 7.66488239e-02f, -6.23618923e-02f, 3.43039274e-01f, 1.39340580e-01f, -7.88022354e-02f, -1.57623515e-01f, 1.20066576e-01f, 1.13358662e-01f,
  -5.81210386e-03f, -2.46516570e-01f, 1.89577639e-01f, 2.03089833e-01f, 3.22706811e-02f, -3.46953720e-01f, -1.80128247e-01f, 5.05011499e-01f, 2.54993498e-01f, 8.92212912e-02f,
  6.30146265e-02f, 3.71386796e-01f, -1.05335243e-01f, -1.68453500e-01f, 8.30183774e-02f, -5.78286588e-01f, 2.90684760e-01f, 3.51669341e-01f, 2.86625355e-01f, -1.54248461e-01f,
  -2.10443549e-02f, 3.87803584e-01f, -2.53255337e-01f, 1.11298501e-01f, -1.00754373e-01f, 1.55743480e-01f, 7.89763033e-02f, 2.81094164e-02f, 2.94995129e-01f, 1.59498483e-01f,
  3.86325747e-01f, -2.61871129e-01f, 7.92869106e-02f, 2.83371568e-01f, 1.22670531e-02f, -2.68184274e-01f, 1.44186974e-01f, 1.46356300e-01f, 3.13487470e-01f, -2.86882930e-02f,
  2.36040846e-01f, 1.78050265e-01f, -1.37403160e-01f, -2.74088293e-01f, 3.95670421e-02f, 4.27581877e-01f, -3.23532403e-01f, 3.25148672e-01f, -1.45539969e-01f, 2.57726640e-01f,
  1.05601482e-01f, 4.05573279e-01f, -3.27511638e-01f, -6.89984635e-02f, 3.14561099e-01f, 1.46805704e-01f, 1.57396317e-01f, -1.68380216e-01f, -8.02593678e-02f, 3.84275317e-01f,
  -9.57979113e-02f, 1.55223414e-01f, 1.72894463e-01f, -1.29584655e-01f, -1.42692789e-01f, 2.01027676e-01f, 6.92741647e-02f, -1.48930000e-02f, 2.54758775e-01f, 4.18251693e-01f,
  4.59597819e-02f, 1.13998428e-01f, 1.45526662e-01f, 4.05286074e-01f, 9.78827700e-02f, 3.32513094e-01f, 3.74868512e-01f, -2.35360846e-01f, -1.02259219e-01f, -9.55865458e-02f,
  -3.00197173e-02f, -1.76715806e-01f, 1.86977327e-01f, -4.82191265e-01f, -9.43796895e-03f, -1.48628861e-01f, 2.22698092e-01f, 6.67107254e-02f, 1.28438815e-01f, -3.04155827e-01f,
  3.62304658e-01f, -2.74519563e-01f, 2.27527041e-02f, -2.40221605e-01f, 1.34593576e-01f, -2.02069402e-01f, 9.04147420e-03f, -1.11233750e-02f, -1.68286458e-01f, 8.39201957e-02f,
  -1.03734493e-01f, 1.75019786e-01f, -4.03175294e-01f, 5.02949417e-01f, -4.95553501e-02f, -2.99252748e-01f, 2.28610709e-01f, 2.26275653e-01f, -2.70419985e-01f, 2.35694394e-01f,
  7.49268085e-02f, 1.12983678e-02f, 2.28605703e-01f, 4.90885556e-01f, 2.85725981e-01f, 1.22476839e-01f, -4.05060239e-02f, -1.67476118e-01f, 1.19174317e-01f, 2.47908950e-01f,
  2.14928165e-01f, -3.84611078e-02f, -2.49627437e-02f, 6.20684773e-02f, -1.92875072e-01f, -7.52434060e-02f, -1.89981073e-01f, 4.04082716e-01f, -6.33015558e-02f, -8.63280240e-03f,
  -8.46171901e-02f, 5.11221051e-01f, -1.38616413e-01f, 1.20864086e-01f, 2.14610547e-02f, 1.54816613e-01f, -1.73008218e-01f, -6.71154559e-02f, 2.80650914e-01f, 2.79061496e-01f,
  8.20299760e-02f, -2.01623559e-01f, 2.76280314e-01f, -1.30034477e-01f, 4.68468130e-01f, -1.19699337e-01f, 4.32538316e-02f, -3.67420554e-01f, 3.20599288e-01f, 2.84369458e-02f,
  5.42847998e-02f, 1.52638350e-02f, 1.88525587e-01f, -1.68235809e-01f, 1.17999641e-02f, 1.33461550e-01f, -6.16491847e-02f, 6.16993345e-02f, -4.62867953e-02f, 1.47643209e-01f,
  8.35585371e-02f, 4.51681055e-02f, 1.30354956e-01f, 2.73656875e-01f, 1.66387022e-01f, -1.88129723e-01f, -2.34302685e-01f, 4.12816077e-01f, 2.31698155e-01f, 1.10782959e-01f,
  2.20286772e-01f, 3.82243127e-01f, 1.54370621e-01f, -2.91964024e-01f, 3.21339577e-01f, -3.78285408e-01f, 3.62589985e-01f, -1.11944623e-01f, 1.71756789e-01f, -4.65706378e-01f,
  1.14575714e-01f, 2.37560689e-01f, 2.04909712e-01f, 2.93335289e-01f, 3.66890043e-01f, 3.62342410e-02f, -6.52147532e-02f, 1.02776490e-01f, -1.17589183e-01f, 1.70806587e-01f,
  -3.85364622e-01f, -1.45926073e-01f, -3.06733958e-02f, 1.95786700e-01f, -2.54747599e-01f, 2.84251779e-01f, -1.68368101e-01f, 3.85122657e-01f, 2.23924369e-01f, 1.70239806e-01f,
  5.94293959e-02f, -5.73073253e-02f, -2.28091180e-01f, 1.82191566e-01f, 2.16073111e-01f, -2.24526569e-01f, 2.97027022e-01f, 2.74054706e-01f, 1.83802918e-01f, -1.54973701e-01f,
  -9.03667230e-03f, 2.17544869e-01f, 4.59484786e-01f, -8.84501711e-02f, 7.11047873e-02f, -2.02755570e-01f, 3.72547982e-03f, -2.83404738e-01f, -2.63163865e-01f, -2.98519701e-01f,
  -1.99609801e-01f, 1.34040177e-01f, -9.52769890e-02f, 1.01200074e-01f, 4.52318817e-01f, 4.54063803e-01f, -2.36592010e-01f, -6.03896491e-02f, 1.40692398e-01f, 5.70219517e-01f,
  -1.80000186e-01f, 4.49444316e-02f, 4.47301626e-01f, 2.34403182e-02f, 1.82199180e-01f, -5.72968163e-02f, 1.46105394e-01f, 6.66479096e-02f, -5.70000149e-02f, 5.19877449e-02f,
  1.24616601e-01f, 9.45446938e-02f, 4.16257948e-01f, -2.66470388e-02f, -7.72852004e-02f, -5.13995349e-01f, -4.55739237e-02f, -1.00726955e-01f, 4.42491733e-02f, -1.93565518e-01f,
  1.42318085e-01f, -3.45400572e-01f, 4.51978743e-02f, -2.02067509e-01f, 4.51503582e-02f, 8.25128332e-02f, 3.22775155e-01f, 1.22869853e-03f, -1.41304091e-01f, 6.86616227e-02f,
  -3.94456238e-02f, 9.08586383e-02f, -1.98879793e-01f, 3.71833175e-01f, 2.16589376e-01f, -3.38375211e-01f, 3.44462246e-01f, -1.68769464e-01f, -2.61972785e-01f, 7.25527704e-02f,
  7.27896020e-02f, -3.72734591e-02f, 1.51716441e-01f, 4.31242466e-01f, 1.76449135e-01f, 1.19994450e-02f, -1.25324011e-01f, -1.21612281e-01f, 2.88503975e-01f, 8.25696858e-04f,
  3.03001106e-01f, -1.94453493e-01f, -1.60930216e-01f, -5.66202104e-02f, -1.32346094e-01f, -4.23287153e-02f, -2.47981519e-01f, 1.90958217e-01f, -9.80869401e-03f, 1.45685405e-01f,
  -2.24457189e-01f, 2.25587696e-01f, -2.83715993e-01f, 2.96481758e-01f, 2.25358084e-03f, 6.61653951e-02f, -1.93651244e-02f, -3.14965785e-01f, 2.45332867e-01f, -6.92515494e-03f,
  7.14558586e-02f, -2.10860014e-01f, 3.83188725e-01f, 1.78147424e-02f, 1.18761919e-01f, -7.88278356e-02f, 1.64899826e-01f, -2.51869887e-01f, 3.53104144e-01f, 6.20345287e-02f,
  1.78661719e-01f, -3.97468694e-02f, 2.06684306e-01f, -2.03564122e-01f, 2.79989213e-01f, 2.71459937e-01f, 2.57778674e-01f, 2.69602567e-01f, 2.59832650e-01f, -4.15647417e-01f,
  -7.77408630e-02f, 2.79613435e-01f, -1.05251759e-01f, -4.95170444e-01f, 8.30837712e-02f, 1.35802671e-01f, -1.18642353e-01f, 4.28529561e-01f, 4.00346935e-01f, 8.78904073e-04f,
  -1.23112306e-01f, 3.71480465e-01f, 2.99884349e-01f, -4.26696055e-02f, 2.81196386e-01f, -3.84342641e-01f, -1.55137539e-01f, 2.05758259e-01f, 3.88924807e-01f, -2.92361051e-01f,
  1.58189293e-02f, 4.90845501e-01f, 2.61321031e-02f, 9.85626876e-02f, -6.40032515e-02f, -6.17804788e-02f, -2.61249334e-01f, -7.42344558e-02f, 2.30957627e-01f, 7.75637552e-02f,
  -8.80645216e-02f, 3.62314254e-01f, 2.99039900e-01f, 8.39924887e-02f, 8.78359899e-02f, 4.07783508e-01f, 1.46629676e-01f, 8.52396339e-02f, 1.53711975e-01f, -3.44513685e-01f,
  -1.95041493e-01f, 2.26702482e-01f, 2.58256197e-01f, -1.87740237e-01f, 2.39051431e-01f, 1.38138413e-01f, 1.50699377e-01f, 5.43958366e-01f, 7.01658651e-02f, -1.93008587e-01f,
  1.22104928e-01f, 1.17484704e-01f, 1.28413692e-01f, -1.83178693e-01f, -1.02432653e-01f, -1.88227877e-01f, 2.40177978e-02f, -1.84740081e-01f, 1.03202596e-01f, -1.15206875e-01f,
  -1.21039346e-01f, -2.81677037e-01f, -8.63021538e-02f, 3.83260965e-01f, 1.38287842e-01f, 2.92645190e-02f, 1.19551897e-01f, 3.60754907e-01f, 1.27404243e-01f, 2.86606066e-02f,
  -3.06838602e-02f, 2.39196062e-01f, 4.95562106e-02f, 5.89781366e-02f, 2.92320102e-01f, 1.25994071e-01f, -2.93107152e-01f, -8.71022791e-02f, 2.17389807e-01f, -1.27897048e-02f,
  1.51322246e-01f, 3.87102067e-01f, 1.30641565e-01f, -5.33408187e-02f, 1.14426069e-01f, -3.48390698e-01f, 1.14493698e-01f, 2.36685142e-01f, 1.42113850e-01f, 3.48071247e-01f,
  1.84809849e-01f, 2.43795320e-01f, 2.30851904e-01f, 5.15456498e-02f, 2.98310995e-01f, 5.04197478e-02f, -4.88231808e-01f, 4.48324680e-02f, 7.62632340e-02f, 1.73246697e-01f,
  -9.50689688e-02f, -4.79048938e-02f, 2.51392573e-01f, -1.62979327e-02f, -7.61126280e-02f, -8.22782889e-02f, 1.25007764e-01f, 3.86641562e-01f, 1.13591716e-01f, 8.91531631e-02f,
  4.35086638e-01f, -1.47469547e-02f, 3.09722334e-01f, -1.56915814e-01f, -9.59821939e-02f, 2.05670930e-02f, 3.76733154e-01f, 4.66687679e-01f, -8.93838704e-02f, -1.42434061e-01f,
  -6.72137691e-03f, -3.15958261e-02f, -4.30782735e-01f, -3.82270873e-01f, -2.32366055e-01f, 1.94785103e-01f, -4.98709768e-01f, 3.41262698e-01f, 4.59157974e-01f, 1.27591684e-01f,
  -2.88184345e-01f, 1.69703454e-01f, -1.93492204e-01f, 4.78105009e-01f, 9.06928256e-02f, 1.55146986e-01f, 4.25688058e-01f, -4.33353782e-01f, 1.78129628e-01f, -2.27432400e-01f,
  -6.80472329e-02f, 5.87367825e-02f, 3.05679947e-01f, 1.49162680e-01f, 5.35580590e-02f, -1.77480076e-02f, 2.98734516e-01f, 1.72812194e-01f, 2.06323862e-01f, -4.43309009e-01f,
  1.87874511e-01f, -1.04823276e-01f, 3.26800868e-02f, 2.70941854e-01f, -3.50422114e-01f, 1.62143946e-01f, 1.54089540e-01f, 2.82514364e-01f, 5.72341718e-02f, 1.63413927e-01f,
  -2.03688264e-01f, 1.71326354e-01f, -2.96724793e-02f, -2.23349687e-02f, -1.03204161e-01f, 4.49506909e-01f, 2.86018431e-01f, -2.24074274e-01f, -7.21106231e-02f, -1.55024856e-01f,
  5.25087444e-03f, 9.69333388e-03f, 2.84021378e-01f, 9.45668817e-02f, 2.78660864e-01f, 2.76965380e-01f, -2.50798762e-01f, -1.86586440e-01f, -7.91472718e-02f, 4.36885767e-02f,
  8.95486996e-02f, 2.78101474e-01f, -5.09344228e-02f, -7.38770515e-02f, -1.54124245e-01f, 1.25562381e-02f, 1.42475262e-01f, 1.83592923e-02f, 3.05389255e-01f, 1.04347721e-01f,
  4.74054217e-02f, -1.63147859e-02f, 2.41836518e-01f, -2.24943776e-02f, 2.33067840e-01f, 6.61364868e-02f, 2.41856113e-01f, -1.61972661e-02f, -1.20722940e-02f, -9.04340148e-02f,
  8.38342905e-02f, 2.16627881e-01f, 1.20381815e-02f, 6.77734762e-02f, 1.20645352e-01f, 3.66217285e-01f, 2.45990325e-02f, 3.67713571e-01f, 2.78667491e-02f, 3.55063736e-01f,
  2.32015043e-01f, 3.86420399e-01f, -3.19469780e-01f, 2.47581929e-01f, 2.84717739e-01f, 6.97029680e-02f, -2.45676190e-03f, 2.72700161e-01f, -1.05194867e-01f, 3.05002570e-01f,
  3.12453032e-01f, 3.79694194e-01f, 6.20016754e-02f, -1.68361500e-01f, -2.19966739e-01f, -3.59017178e-02f, 5.20803072e-02f, -9.03770477e-02f, -1.65965557e-01f, 4.03257385e-02f,
  3.65274101e-01f, -6.66885972e-02f, 2.34497607e-01f, -4.90128845e-02f, -1.10203952e-01f, 3.01312774e-01f, 3.17612827e-01f, 9.36601236e-02f, 3.35688084e-01f, -8.15894604e-02f,
  1.01676285e-02f, -1.84093818e-01f, -6.28811866e-02f, 8.86846483e-02f, 2.08057433e-01f, 4.57603633e-01f, -9.52267051e-02f, -1.52832223e-02f, -8.57199878e-02f, -1.75898433e-01f,
  -3.93613249e-01f, -4.11621556e-02f, -9.57083795e-03f, 3.55709791e-01f, -1.63289964e-01f, 3.01157087e-01f, 4.86490041e-01f, 2.04856634e-01f, 8.36914331e-02f, 1.19907007e-01f,
  3.22172612e-01f, 7.44931325e-02f, -9.16454718e-02f, -1.85476944e-01f, 1.69218540e-01f, 3.45350862e-01f, 2.58870006e-01f, -8.28838125e-02f, 4.14819509e-01f, -5.35373017e-02f,
  -1.79054439e-01f, 1.92959011e-01f, 1.44897416e-01f, -2.36756250e-01f, 3.00425470e-01f, -1.69667810e-01f, -1.97477102e-01f, -9.82588902e-02f, -9.10556130e-03f, 3.16046327e-01f,
  1.57999068e-01f, 4.30941612e-01f, -1.29480585e-01f, 2.01570600e-01f, 2.51997918e-01f, 7.14526996e-02f, -8.59670788e-02f, 3.62177312e-01f, -2.91096151e-01f, 2.05197975e-01f,
  -1.03947163e-01f, 4.87884998e-01f, -1.66085511e-01f, -3.76686864e-02f, 3.50997925e-01f, -1.87559426e-01f, -2.58443654e-01f, -2.10020706e-01f, 3.62188295e-02f, 4.02223580e-02f,
  1.80611357e-01f, 6.82289451e-02f, 2.00617537e-01f, 1.96487233e-01f, 4.49349076e-01f, -4.66175020e-01f, -3.95244956e-01f, 2.49703437e-01f, 4.75599438e-01f, 1.44553974e-01f,
  3.14082623e-01f, 2.73263067e-01f, 1.93604276e-01f, -7.79406875e-02f, -4.79707606e-02f, 3.20233926e-02f, 3.33302230e-01f, 2.33868450e-01f, 1.95370197e-01f, -2.48785838e-01f,
  -2.45629176e-01f, 2.90671140e-01f, -2.06042722e-01f, -1.35030732e-01f, -1.69801265e-01f, 4.85909611e-01f, 2.68268853e-01f, -1.12597279e-01f, -1.16415747e-01f, -2.02202722e-01f,
  1.67311445e-01f, -1.42920718e-01f, 1.63967907e-01f, 2.92727835e-02f, 2.36473829e-01f, 3.50782484e-01f, -1.69964328e-01f, -1.18870428e-02f, -2.86306590e-02f, 2.97147989e-01f,
  1.87928319e-01f, 1.60051957e-02f, -2.79608935e-01f, -2.28370860e-01f, -1.21024229e-01f, -5.28020933e-02f, -1.50544748e-01f, 7.52288029e-02f, -1.43900648e-01f, -1.68743879e-01f,
  1.34266540e-01f, 2.24936068e-01f, 3.59403044e-01f, 1.61934663e-02f, 1.63344428e-01f, 1.01663068e-01f, 2.59364069e-01f, 1.25731938e-02f, -7.98630435e-03f, 2.04091847e-01f,
  4.26218435e-02f, 4.36795235e-01f, 3.32124569e-02f, 7.27772564e-02f, -5.68450205e-02f, 7.28652924e-02f, -4.56940264e-01f, -1.37169495e-01f, 1.39910504e-01f, 9.58490223e-02f,
  2.24433661e-01f, -1.64854318e-01f, -3.06756973e-01f, -3.89820695e-01f, 1.13534965e-01f, 1.47676915e-01f, -2.59954482e-02f, -2.16451734e-01f, -1.18995823e-01f, -2.19653383e-01f,
  2.61517376e-01f, 4.31363672e-01f, -4.53685559e-02f, -1.45107761e-01f, 4.15166557e-01f, 2.07590982e-01f, -2.17528120e-01f, -1.58568352e-01f, -6.90252893e-03f, 1.13555528e-01f,
  -1.77666679e-01f, 3.94405872e-02f, 5.40092051e-01f, -7.10409507e-02f, -8.61181170e-02f, -1.71461523e-01f, 3.65462154e-01f, 1.94086015e-01f, 6.84987158e-02f, 1.80947967e-02f,
  4.44372650e-03f, 2.12402120e-01f, 2.27821350e-01f, 1.70965254e-01f, -2.28155017e-01f, 4.32610124e-01f, -1.81539804e-02f, 1.45081624e-01f, 7.89151341e-02f, 2.13464543e-01f,
  2.93347538e-01f, -1.11896418e-01f, 2.02384442e-01f, -5.58930859e-02f, 1.89690497e-02f, -1.63673863e-01f, -1.00303225e-01f, -1.17761433e-01f, -6.56162738e-04f, -1.30716376e-02f,
  3.69835272e-03f, -1.61983609e-01f, 1.21815473e-01f, 4.32382599e-02f, -8.61560404e-02f, -1.24866217e-01f, 2.18938570e-02f, 1.60321325e-01f, -1.81208685e-01f, 2.56954789e-01f,
  1.47427902e-01f, 2.08031863e-01f, 1.39106840e-01f, 3.15072179e-01f, 1.12317242e-01f, 4.48103070e-01f, 5.95107079e-02f, 2.46363565e-01f, -4.56638038e-02f, -9.64309182e-03f,
  1.08660303e-01f, -4.57783826e-02f, 2.00110942e-01f, 6.23082332e-02f, 2.78313458e-01f, -4.09370884e-02f, 4.72100556e-01f, -1.91415831e-01f, -1.10193282e-01f, 8.23927894e-02f,
  2.66786516e-01f, -1.75701365e-01f, 3.16520602e-01f, -2.87455115e-02f, 1.99356884e-01f, 3.82983893e-01f, 3.26471329e-02f, 3.02485794e-01f, 1.62561789e-01f, 1.47955701e-01f,
  -2.42118254e-01f, 4.35465246e-01f, -1.65633351e-01f, 1.50783926e-01f, -5.47315516e-02f, 3.99284571e-01f, 2.19938546e-01f, 4.18407768e-01f, -3.45589966e-01f, -1.72303077e-02f,
  -1.05533004e-01f, 9.87036340e-03f, -6.29471466e-02f, -8.90776739e-02f, -8.59538764e-02f, -2.62929887e-01f, -4.19440009e-02f, -2.19695851e-01f, -3.01664442e-01f, 3.06813657e-01f,
  2.89957583e-01f, -6.24522083e-02f, 1.79453418e-01f, 5.00928879e-01f, -3.38771753e-02f, -7.47073144e-02f, -9.60331708e-02f, -1.90898642e-01f, -8.58089849e-02f, 8.40279087e-02f,
  9.67340469e-02f, -1.74480584e-02f, -3.11690569e-01f, 1.89024597e-01f, 1.03189960e-01f, 3.31202030e-01f, 2.95933962e-01f, -1.21561782e-02f, -1.90979186e-02f, 2.56345302e-01f,
  1.05394393e-01f, -2.76121944e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  9.28394347e-02f, 1.04752779e-01f, 1.45644117e-02f, 1.08979046e-01f, 2.36374438e-01f, 2.16073677e-01f, 5.33958264e-02f, 6.41867369e-02f, -1.65720508e-02f, 1.48431718e-01f,
  1.60760671e-01f, 7.90567398e-02f, 8.66904482e-02f, 2.29613766e-01f, -1.03487603e-01f, 1.05061509e-01f, -1.97826829e-02f, 1.67745441e-01f, 6.04803849e-04f, 1.10498250e-01f,
  5.16457148e-02f, -9.47578475e-02f, 4.05674055e-02f, 4.87892553e-02f, 1.49277553e-01f, -4.20068800e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -9.06354412e-02f, -3.86791117e-02f, 3.07017080e-02f, -2.57611200e-02f, 1.56599447e-01f, 7.38779828e-02f, 3.66079062e-01f, -2.80524418e-02f, -2.76990265e-01f, -9.14329141e-02f,
  -5.19475996e-01f, -6.56059943e-03f, -6.01508677e-01f, -4.92049426e-01f, -3.66615993e-03f, -2.62353390e-01f, 3.28571439e-01f, -5.30824065e-01f, -1.45528942e-01f, 7.58674815e-02f,
  -4.85846400e-01f, 1.98668867e-01f, 3.27576399e-01f, 3.95355135e-01f, -2.90459394e-01f, -5.49986243e-01f, -2.14744508e-01f, -2.75949895e-01f, 1.82523534e-01f, 2.56441772e-01f,
  1.28863439e-01f, -1.12610333e-01f, -1.30093107e-02f, 1.76699936e-01f, -5.19955419e-02f, -2.72121191e-01f, -1.06197283e-01f, -3.16069186e-01f, -5.60774028e-01f, 3.40139985e-01f,
  -3.27926755e-01f, -3.35085899e-01f, -3.30187619e-01f, -6.43011093e-01f, 4.77510784e-03f, -6.17661119e-01f, -3.38609844e-01f, -4.56372380e-01f, -4.49984111e-02f, 5.57881072e-02f,
  -2.95139968e-01f, 2.42242113e-01f, -5.89357555e-01f, 1.44547224e-01f, 8.86253044e-02f, 2.00640276e-01f, -2.98433334e-01f, 4.03074235e-01f, 3.57014000e-01f, -6.72700405e-02f,
  5.09452783e-02f, 2.47652918e-01f, 3.20751786e-01f, -1.83707312e-01f, 2.02238224e-02f, -1.89263776e-01f, -5.60292490e-02f, -6.72752932e-02f, -2.61312127e-01f, -2.00230002e-01f,
  -1.57416031e-01f, 4.40466851e-02f, -5.20733833e-01f, -2.75483191e-01f, -3.51726562e-01f, -5.13744950e-01f, 3.61243635e-01f, 5.75735867e-02f, -6.54223859e-02f, -1.38423666e-01f,
  -4.56592232e-01f, 8.28758776e-02f, -2.00987861e-01f, -2.25341633e-01f, 5.41758776e-01f, 9.16656181e-02f, 1.98894460e-02f, 1.18419990e-01f, 1.14932783e-01f, 1.63194209e-01f,
  4.10924591e-02f, -2.96763957e-01f, 1.23273291e-01f, 1.06905341e-01f, -2.70989656e-01f, 4.06379998e-01f, -5.30110206e-03f, -7.08213896e-02f, 4.84286919e-02f, 1.49142161e-01f,
  -2.98571438e-02f, -1.96581110e-01f, 2.68342406e-01f, 1.88001633e-01f, 1.01768360e-01f, 6.38351068e-02f, -5.58770657e-01f, 5.43650836e-02f, -4.54249918e-01f, 2.36590371e-01f,
  1.76045746e-01f, -3.63164216e-01f, 3.11799020e-01f, -4.15647149e-01f, 9.01281461e-02f, -6.28492415e-01f, 1.83486100e-02f, -5.04798114e-01f, -4.61138152e-02f, -5.36381066e-01f,
  1.16069494e-02f, -5.95102049e-02f, -4.07047421e-01f, 3.44349146e-01f, 5.03936931e-02f, -1.15061060e-01f, 1.25527516e-01f, -4.33367133e-01f, 1.85465470e-01f, 5.24056293e-02f,
  1.00712486e-01f, -8.10260326e-03f, 2.32861396e-02f, 1.29587844e-01f, 1.01726532e-01f, -3.06359559e-01f, 1.87395230e-01f, 3.83475989e-01f, 3.91151085e-02f, 1.18696883e-01f,
  3.72622967e-01f, 2.15077236e-01f, 2.50646502e-01f, 2.57495373e-01f, 2.30123013e-01f, -3.43272388e-01f, 1.75321758e-01f, -1.50551334e-01f, 1.01030953e-01f, -1.51703581e-01f,
  -1.83873132e-01f, -1.86553821e-01f, -4.48910058e-01f, -5.62591195e-01f, 3.08217645e-01f, -4.74559128e-01f, 1.05070369e-02f, -3.08620073e-02f, -6.51188102e-03f, -3.01153541e-01f,
  -1.00895025e-01f, 2.95258492e-01f, 6.16845936e-02f, -2.71333069e-01f, 1.32300425e-02f, -1.77757651e-01f, -1.17257252e-01f, -4.20824021e-01f, 4.28391933e-01f, -3.12185019e-01f,
  8.82574469e-02f, 2.32290119e-01f, 2.20847860e-01f, -1.88508034e-01f, -4.00892735e-01f, 1.93657890e-01f, 3.39530200e-01f, -1.80382013e-01f, -5.23529172e-01f, 2.79054433e-01f,
  -3.66645277e-01f, 1.61474556e-01f, -3.21118802e-01f, 3.50593507e-01f, 8.03731903e-02f, 8.48282874e-02f, 2.12809905e-01f, -1.29343361e-01f, 1.58323050e-01f, -1.32533312e-01f,
  -4.96131659e-01f, -4.20911431e-01f, 3.24156098e-02f, 1.11427367e-01f, -9.87133086e-02f, -7.31759742e-02f, -2.25758955e-01f, 1.88638806e-01f, -4.66553271e-01f, -5.24356484e-01f,
  7.94537738e-02f, -5.60352087e-01f, 2.66301304e-01f, -5.11620566e-02f, 1.99492991e-01f, -3.18759233e-02f, -2.21504673e-01f, 2.12372303e-01f, -6.77999973e-01f, 3.07719737e-01f,
  1.53663158e-01f, 7.38174990e-02f, 2.16414690e-01f, 3.02967906e-01f, -7.29671359e-01f, -6.89946860e-02f, -7.34113455e-02f, 3.31738710e-01f, 5.21141365e-02f, -1.14640504e-01f,
  -8.24296296e-01f, -4.35216218e-01f, -3.80016237e-01f, -4.41393722e-03f, 1.03778407e-01f, -1.62736133e-01f, -2.22427219e-01f, 2.51297027e-01f, 3.09925396e-02f, -6.27349317e-03f,
  3.14278156e-01f, -2.95647949e-01f, 2.88527548e-01f, -1.19931415e-01f, 1.12768263e-01f, 3.36030900e-01f, -1.48340732e-01f, -1.05493277e-01f, -6.94886371e-02f, -2.50820816e-01f,
  -2.49207854e-01f, 2.04371884e-01f, 3.27199608e-01f, -8.61661360e-02f, -5.19213676e-01f, -2.53235668e-01f, 7.68115297e-02f, -1.95421964e-01f, 2.53695190e-01f, -1.71985775e-01f,
  -1.00348614e-01f, 4.28641886e-01f, -5.50356328e-01f, -1.32856622e-01f, 2.21963063e-01f, 3.53615046e-01f, -1.16293222e-01f, -5.05850129e-02f, -1.04076527e-01f, 1.70477226e-01f,
  -1.13218784e-01f, -8.75651464e-03f, -2.64804959e-01f, 2.70990729e-01f, 3.37536573e-01f, -5.15311658e-01f, -2.14609072e-01f, -3.73094156e-02f, 1.60242677e-01f, 2.17172220e-01f,
  -4.62826610e-01f, -3.27177703e-01f, 1.44610047e-01f, 2.46825337e-01f, -4.15158749e-01f, -4.30123866e-01f, -1.89156398e-01f, 2.20965706e-02f, 1.65850684e-01f, -5.27218245e-02f,
  4.11112607e-01f, -4.23674643e-01f, 6.28775125e-03f, -2.03696322e-02f, 3.66355449e-01f, -3.55046332e-01f, -1.06577478e-01f, -2.64940441e-01f, -1.57453924e-01f, 1.61808189e-02f,
  -4.66538742e-02f, -1.69089675e-01f, 3.04566771e-01f, 3.18198770e-01f, 4.02306557e-01f, -8.48581195e-02f, -3.28029871e-01f, 9.29085463e-02f, 3.82711530e-01f, 2.69622266e-01f,
  1.80460885e-01f, -5.46335280e-01f, -3.95331867e-02f, 8.63201395e-02f, -3.71338546e-01f, -4.23307270e-02f, 1.68287471e-01f, 1.82136387e-01f, -2.80646503e-01f, -3.19995552e-01f,
  -1.99405208e-01f, -8.89019966e-02f, -4.06551868e-01f, 3.67171377e-01f, -5.49685121e-01f, -2.49355391e-01f, -3.38506073e-01f, 2.71454036e-01f, -4.66111749e-01f, 1.31116092e-01f,
  1.25832811e-01f, -2.53244583e-02f, -8.75446647e-02f, 2.97413170e-01f, 3.25090200e-01f, -1.82424322e-01f, -4.53916311e-01f, 1.87453777e-01f, -3.21340591e-01f, 3.69319677e-01f,
  -1.83181778e-01f, -4.61873978e-01f, -3.96720111e-01f, 8.77655074e-02f, 2.53457904e-01f, -1.22652143e-01f, -1.77058011e-01f, 2.84766346e-01f, 1.70745626e-02f, -4.29806858e-01f,
  -6.87201843e-02f, -1.31685495e-01f, 2.74802744e-01f, -3.89763713e-01f, 6.86491430e-02f, -5.64322233e-01f, 1.81148708e-01f, -3.60489711e-02f, 1.69842258e-01f, 1.99684128e-01f,
  1.74171627e-01f, 2.76038766e-01f, -6.35076612e-02f, 7.56589919e-02f, -1.78974107e-01f, -2.59566635e-01f, 1.18596151e-01f, 2.46253222e-01f, -4.62271944e-02f, -3.72866184e-01f,
  -3.66855264e-01f, -2.14868411e-01f, 1.00311108e-01f, 1.52076840e-01f, -2.39070520e-01f, 2.26026967e-01f, 3.21346372e-01f, 1.63528278e-01f, -3.89402807e-01f, 2.35045895e-01f,
  1.74935699e-01f, -4.14259285e-01f, 4.12406504e-01f, -2.33672351e-01f, -1.32349268e-01f, -3.01232785e-01f, 2.78172851e-01f, -1.11401796e-01f, -3.90239775e-01f, 8.38146806e-02f,
  2.25490808e-01f, -3.16288620e-01f, -3.29204381e-01f, 2.91479468e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.70397311e-02f, 6.98923916e-02f, -1.31902352e-01f, -1.31268978e-01f, 6.31492510e-02f, -6.51616752e-02f, 6.13901205e-02f, -5.64920120e-02f, -2.30022278e-02f, 1.16676807e-01f,
  6.07136749e-02f, 2.77513918e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    