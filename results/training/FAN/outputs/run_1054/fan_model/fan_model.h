/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.73129171e-01f, 2.11507842e-01f, 3.98307256e-02f, -2.02054247e-01f, 1.68050140e-01f, -2.65695062e-02f, -9.52696893e-03f, 1.62638456e-01f, 1.71794742e-01f, 1.10284247e-01f,
  2.57213742e-01f, 4.47052360e-01f, 2.06537306e-01f, 6.51657283e-02f, -9.29691195e-02f, -1.20227419e-01f, -2.16562375e-01f, -2.20659122e-01f, -1.06489100e-01f, 4.30704877e-02f,
  1.06796287e-01f, -1.11943774e-01f, -2.57697046e-01f, -1.21576644e-01f, -9.20834169e-02f, -1.08865894e-01f, -2.88681895e-01f, -1.42048642e-01f, 1.60606369e-01f, -1.36951163e-01f,
  3.34084332e-02f, 2.35690773e-01f, 1.33336261e-01f, 4.22184654e-02f, 1.16586760e-01f, 6.89314157e-02f, 1.60122380e-01f, 7.99732804e-02f, 1.46692157e-01f, 4.36572619e-02f,
  1.31288037e-01f, 1.79510698e-01f, 1.85773656e-01f, 1.41844526e-01f, -7.83126429e-03f, -1.57116670e-02f, 2.93738600e-02f, 2.72629242e-02f, 2.88088340e-02f, 1.10276662e-01f,
  1.78622544e-01f, -7.12371245e-02f, -5.18744439e-02f, 4.18832414e-02f, 8.53531156e-03f, -5.78988567e-02f, -3.63488682e-02f, -6.47234097e-02f, 1.10998079e-02f, -2.64621496e-01f,
  -6.63479269e-02f, 4.11553718e-02f, 1.22412264e-01f, -7.10836649e-02f, -2.11828470e-01f, 9.45955291e-02f, -1.28357828e-01f, -9.75619256e-02f, 1.99607778e-02f, -1.50138035e-01f,
  9.03922021e-02f, -2.17319820e-02f, -2.39156801e-02f, -5.07910997e-02f, 1.21923564e-02f, -7.95600563e-03f, -4.45915833e-02f, -9.43794921e-02f, 4.68116738e-02f, -1.19516879e-01f,
  -1.17543768e-02f, -9.21935029e-03f, 2.55106967e-02f, -1.30765745e-02f, -6.91183656e-03f, -4.92639579e-02f, 2.57146135e-02f, 7.29468912e-02f, 9.57308710e-02f, 4.74772155e-02f,
  -2.45956272e-01f, 1.87550947e-01f, -1.03322245e-01f, 8.83553848e-02f, 9.51825082e-02f, 2.80144322e-03f, 1.01268761e-01f, 1.36036471e-01f, 1.46228760e-01f, 1.18568189e-01f,
  1.78261846e-01f, 9.05764997e-02f, 9.71430391e-02f, 1.00040279e-01f, 5.94916753e-02f, 5.91066107e-02f, 1.06503814e-01f, 3.30425240e-02f, 1.34673089e-01f, 9.68238711e-02f,
  3.77727598e-02f, -1.13730289e-01f, -1.13034770e-01f, -3.75187211e-02f, 3.59456465e-02f, -1.73891366e-01f, -9.51813906e-03f, 3.77565697e-02f, -2.07015742e-02f, -3.22182685e-01f,
  2.04270259e-01f, -4.89246398e-02f, -2.46329024e-01f, 1.71819001e-01f, 5.75157441e-02f, -1.80327222e-01f, -4.88380402e-01f, -2.25565061e-01f, 8.51514861e-02f, 4.31583598e-02f,
  1.56102777e-01f, 3.71956944e-01f, 1.85368523e-01f, 5.41932471e-02f, -2.49334052e-01f, -2.05818087e-01f, -3.06298494e-01f, -1.05844982e-01f, -1.24468908e-01f, -9.98726189e-02f,
  5.08517064e-02f, 1.68053776e-01f, 7.75971357e-03f, -6.13559410e-02f, 4.94527556e-02f, 2.24056169e-01f, 9.05730799e-02f, -3.27162072e-02f, -1.27295673e-01f, 7.40363449e-02f,
  5.18299043e-02f, -1.37912393e-01f, -6.00771569e-02f, 8.49755257e-02f, 3.35058570e-02f, -1.05985329e-01f, -1.53201595e-01f, 1.52519196e-02f, -3.55711803e-02f, -6.47562221e-02f,
  5.38428538e-02f, 1.31376805e-02f, -7.30864555e-02f, 3.37794870e-02f, -6.27097636e-02f, -2.54041087e-02f, -1.10773295e-01f, -2.97399834e-02f, -7.47674480e-02f, -6.79998950e-04f,
  7.48683810e-02f, -5.53233083e-03f, -4.49064858e-02f, -1.39432341e-01f, -1.64004833e-01f, 9.93603244e-02f, -1.67548377e-02f, -1.05200812e-01f, -2.21311808e-01f, 5.67739969e-03f,
  2.99992505e-02f, -1.91944167e-02f, -2.54009180e-02f, 7.21651539e-02f, -1.15580559e-02f, 4.95897382e-02f, 2.01431327e-02f, 1.08893104e-01f, -3.37102488e-02f, 7.82378912e-02f,
  3.51134501e-02f, -1.31400693e-02f, -1.25464708e-01f, 9.73456129e-02f, 7.72175640e-02f, -4.33868505e-02f, 3.03748120e-02f, 1.03715427e-01f, -2.97567137e-02f, -3.73115353e-02f,
  4.54555564e-02f, -1.08030280e-02f, 6.09715953e-02f, -3.06006018e-02f, 2.28323862e-02f, -4.73452695e-02f, -4.04087361e-03f, 8.59432742e-02f, 8.99695680e-02f, 3.21461894e-02f,
  3.72138470e-01f, 1.99033953e-02f, 1.57343730e-01f, -1.18733376e-01f, 4.96810414e-02f, 5.15503623e-02f, 1.31789014e-01f, -4.26966734e-02f, 1.42316237e-01f, 6.00698357e-03f,
  -1.13797724e-01f, -1.72235798e-02f, 1.83577556e-02f, 2.85209622e-03f, 1.50116868e-02f, 1.43578574e-02f, 8.64790678e-02f, 8.05828422e-02f, -4.21820097e-02f, 1.99805815e-02f,
  5.99454110e-03f, -3.76425572e-02f, 1.69075459e-01f, 1.10266069e-02f, 3.82991359e-02f, 9.08638760e-02f, 2.98055857e-02f, 9.35834274e-02f, -5.33319376e-02f, 1.15542695e-01f,
  2.90731788e-01f, -2.34041154e-01f, 9.64466482e-02f, 5.21243870e-01f, 2.91598141e-01f, -1.19122498e-01f, -2.29639545e-01f, -1.20628625e-01f, 4.74338084e-02f, -9.88789052e-02f,
  6.91029802e-02f, 9.79139656e-02f, 1.76669508e-01f, -2.42773034e-02f, -4.15040031e-02f, -5.95727898e-02f, 1.93559393e-01f, 1.75858006e-01f, 2.34038293e-01f, 1.47138434e-02f,
  -7.86875607e-04f, 2.99770802e-01f, 3.39826614e-01f, 5.90740778e-02f, -1.97873451e-02f, -4.82739136e-03f, 1.53921977e-01f, 1.23220667e-01f, -2.32985795e-01f, 4.43907194e-02f,
  2.27177143e-02f, -1.28737062e-01f, 3.51953134e-02f, 1.97283864e-01f, 4.67137247e-02f, -7.69655108e-02f, 6.35937899e-02f, 8.24092925e-02f, -2.44650468e-02f, 1.50732265e-03f,
  1.86873779e-01f, 3.90449679e-03f, 1.64107546e-01f, 4.98246513e-02f, 9.48996693e-02f, 4.56162244e-02f, 2.76528243e-02f, -8.88692960e-02f, -8.27856828e-03f, -1.31307086e-02f,
  8.08100626e-02f, 3.30042429e-02f, 9.54360235e-03f, -2.19068844e-02f, -2.44463813e-02f, 9.19665992e-02f, -9.67432484e-02f, -1.75661713e-01f, -8.54485929e-02f, -1.54716134e-01f,
  -5.58784306e-02f, -1.10320181e-01f, -6.50734007e-02f, 5.71571589e-02f, 1.34651689e-02f, -6.35080487e-02f, 2.89692543e-02f, -1.38392160e-02f, 3.05390581e-02f, 4.22251085e-03f,
  -3.56917195e-02f, -1.09203406e-01f, -2.43782457e-02f, -2.77171787e-02f, -5.72617128e-02f, 8.08440440e-04f, -4.33746278e-02f, -3.97922210e-02f, -4.75673899e-02f, -7.81507194e-02f,
  -3.77738997e-02f, 3.62038873e-02f, -1.28720095e-02f, 3.27538922e-02f, 7.07390439e-03f, -7.92206898e-02f, 2.49515451e-03f, -2.12110430e-02f, 1.04894359e-02f, -1.59673654e-02f,
  7.23370761e-02f, 1.35968938e-01f, 9.47278589e-02f, -8.32983479e-02f, 4.19170447e-02f, -8.24108869e-02f, 5.12358099e-02f, -9.64010041e-03f, 6.45857528e-02f, -3.38820629e-02f,
  7.59807453e-02f, -6.11109659e-02f, 1.55765042e-01f, -1.78956892e-02f, 1.32866517e-01f, 7.18923509e-02f, 3.23163858e-03f, 1.01225726e-01f, -2.30276659e-02f, 1.12873428e-01f,
  1.32751375e-01f, 4.30278480e-02f, 1.36063201e-02f, 9.42776501e-02f, 1.01748385e-01f, 1.99038476e-01f, 2.60650143e-02f, -1.59145202e-02f, 2.71764002e-03f, -3.98362018e-02f,
  7.05710575e-02f, -4.83215243e-01f, -2.09858820e-01f, 5.34912944e-02f, 1.28173336e-01f, 1.34316713e-01f, -1.67313874e-01f, 3.76055203e-02f, 1.98182747e-01f, 1.96257960e-02f,
  1.80288211e-01f, 2.37130076e-01f, 9.59018543e-02f, 4.53328900e-02f, 7.80330822e-02f, -1.43815866e-02f, -1.30314559e-01f, -7.16544166e-02f, 3.53246391e-01f, 3.06135088e-01f,
  1.67055383e-01f, -4.66465279e-02f, -5.73625937e-02f, 1.17045358e-01f, -8.98069739e-02f, 2.98717111e-01f, -2.17394739e-01f, -1.18239231e-01f, 4.57124673e-02f, -3.42783689e-01f,
  1.23808704e-01f, -1.28914520e-01f, 1.54664412e-01f, 4.10088524e-03f, -4.86519262e-02f, 1.81737002e-02f, 8.98042619e-02f, -8.07646811e-02f, -5.36476634e-02f, 4.20220308e-02f,
  -9.55166817e-02f, 1.52818207e-02f, -2.14411295e-04f, -4.56946110e-03f, -1.42117232e-01f, 3.41665559e-02f, -9.05637220e-02f, -9.61769745e-02f, -1.41707912e-01f, 1.51561964e-02f,
  -9.82701778e-03f, -3.65444496e-02f, -1.43046021e-01f, -1.66840386e-02f, 7.34203123e-03f, 1.20037504e-01f, -1.09049544e-01f, -2.24138442e-02f, -8.08563605e-02f, -1.04951590e-01f,
  1.53827161e-01f, 5.62692713e-03f, -3.51961236e-03f, -6.15732148e-02f, -8.17418918e-02f, -7.43387491e-02f, 1.55643430e-02f, -3.53934206e-02f, 2.09299605e-02f, 1.11747924e-02f,
  2.90119974e-03f, 5.21597527e-02f, -5.01020290e-02f, -2.17795838e-02f, 1.07320078e-01f, -2.96560470e-02f, 3.12845036e-02f, 2.25989003e-04f, -4.12378535e-02f, 6.63839951e-02f,
  2.90782414e-02f, 9.19830578e-04f, -1.62157472e-02f, -3.15411836e-02f, -4.00941856e-02f, 3.20922658e-02f, 1.67932082e-02f, 1.01252720e-01f, 6.39465004e-02f, 3.93211283e-02f,
  9.34910029e-03f, 1.10502886e-02f, -1.08321402e-02f, 7.72947147e-02f, -3.20856571e-02f, 2.55611576e-02f, 3.72147486e-02f, -3.48174572e-02f, -1.16878241e-01f, -3.27808782e-02f,
  9.97849405e-02f, -6.20381013e-02f, -7.72826150e-02f, -5.04100695e-03f, 1.18269980e-01f, 1.15214571e-01f, 2.40011923e-02f, 4.64589484e-02f, 1.07597634e-02f, -3.67206372e-02f,
  -1.46881893e-01f, 9.72442478e-02f, 2.27373168e-01f, 1.47145577e-02f, 1.25791445e-01f, 1.01253808e-01f, 1.48007751e-01f, 1.05925694e-01f, 1.78536728e-01f, 2.05318071e-02f,
  -1.53002396e-01f, 5.62410712e-01f, 5.59324920e-01f, 1.71826035e-01f, 1.66090146e-01f, 9.03086662e-02f, 4.96069670e-01f, 1.02037996e-01f, -2.98900247e-01f, 2.29691014e-01f,
  1.45798475e-01f, -2.08028540e-01f, -2.46468425e-01f, -9.51137170e-02f, -1.19826104e-02f, 1.95015088e-01f, 9.92103219e-02f, 5.71234487e-02f, -7.69539475e-02f, 1.38695806e-01f,
  1.96158979e-02f, -1.76780876e-02f, -7.47677386e-02f, 4.68819542e-03f, 1.55434966e-01f, -2.41360173e-01f, 1.03880256e-01f, 2.70888805e-02f, -5.57043664e-02f, 2.18092591e-01f,
  2.85825990e-02f, 2.51053452e-01f, 2.78461329e-03f, -2.20021140e-02f, 6.14648312e-02f, -6.68091848e-02f, 3.13065536e-02f, 6.47167712e-02f, -4.90952693e-02f, -1.79365035e-02f,
  -2.85914857e-02f, -1.61120633e-03f, 1.03842588e-02f, 3.68081331e-02f, 9.40854251e-02f, 3.62640284e-02f, 2.80488022e-02f, 9.38903391e-02f, -3.81665751e-02f, 7.19809160e-02f,
  4.86404710e-02f, 7.72311464e-02f, 7.46001080e-02f, -1.95972007e-02f, 7.43191764e-02f, -6.28389325e-03f, 2.05092043e-01f, 3.52351740e-02f, 2.45477241e-02f, 4.00552414e-02f,
  1.50273805e-02f, -8.44308734e-02f, -1.18247688e-01f, 3.71962376e-02f, 1.77325192e-03f, -2.75063384e-02f, -2.38710195e-02f, -1.58806946e-02f, -6.79525211e-02f, -4.67777625e-02f,
  -8.29707533e-02f, 7.17936158e-02f, 3.42191793e-02f, 3.95238921e-02f, 2.47688703e-02f, 9.65118129e-03f, -1.49154337e-02f, 3.37448828e-02f, -6.28123507e-02f, -6.74302354e-02f,
  -6.31897151e-02f, -6.67269304e-02f, -2.31499095e-02f, 2.10748389e-02f, 6.20452277e-02f, 5.47061861e-03f, -6.74223304e-02f, -8.69520474e-03f, -4.40660911e-03f, 8.01565871e-03f,
  -1.63188875e-01f, 4.36041057e-02f, 3.62098478e-02f, 3.35314944e-02f, 3.47453952e-02f, -1.21073611e-01f, -7.31127337e-02f, -7.83082098e-02f, 2.68870723e-02f, 9.66310443e-04f,
  7.08475411e-02f, -1.26796991e-01f, 7.27229007e-03f, -8.07963982e-02f, 4.83834483e-02f, -6.19390942e-02f, -6.44356236e-02f, 6.63253814e-02f, -8.15839879e-03f, 1.46688707e-02f,
  -4.31056991e-02f, -9.65283886e-02f, -7.39263296e-02f, -7.80379847e-02f, -4.92076911e-02f, -1.77700162e-01f, -8.30828398e-02f, 7.13689579e-03f, -5.30130006e-02f, -9.80215743e-02f,
  6.35939002e-01f, -1.15511951e-03f, -3.42295319e-02f, 2.23838851e-01f, -9.38573480e-02f, -2.35245749e-01f, -4.09780055e-01f, -1.94551274e-02f, 9.96528640e-02f, -1.36749670e-01f,
  -3.07420753e-02f, 1.60732865e-02f, 4.27358076e-02f, -6.93111569e-02f, -8.73541310e-02f, -2.19103053e-01f, 7.27758110e-02f, 1.56198680e-01f, -1.82869941e-01f, -3.24288815e-01f,
  -1.39606938e-01f, 1.74381301e-01f, 2.63492823e-01f, -2.97582541e-02f, -3.84996086e-02f, -1.75414398e-01f, -6.90314323e-02f, 1.01955205e-01f, -8.67139027e-02f, 2.57833004e-01f,
  2.24355012e-02f, 1.61794692e-01f, -1.27365962e-01f, 3.93662378e-02f, 1.88768450e-02f, 1.09353792e-02f, -2.43870337e-02f, 1.85995042e-01f, 5.48719950e-02f, 1.35281786e-01f,
  6.80497438e-02f, 2.70326305e-02f, 8.18715543e-02f, 2.22225469e-02f, 6.87622651e-02f, -4.40339074e-02f, 7.48903900e-02f, 7.51438439e-02f, 9.83823612e-02f, -8.58454779e-02f,
  5.19639105e-02f, 6.40806705e-02f, 7.54228756e-02f, -7.71483779e-02f, 1.02104686e-01f, 3.16547491e-02f, -1.84182208e-02f, 1.13488153e-01f, -6.28246292e-02f, 6.19942956e-02f,
  4.30947775e-03f, 5.10932952e-02f, -1.15447417e-02f, -3.66805606e-02f, 1.39722330e-02f, 4.56337705e-02f, 3.97841856e-02f, -4.66893315e-02f, 2.53300462e-02f, 2.94590853e-02f,
  2.13668812e-02f, 4.46951482e-03f, 4.09846753e-02f, -4.46368121e-02f, 8.84414390e-02f, 7.30018318e-02f, 4.16787937e-02f, -6.98549673e-02f, 9.79930162e-02f, 7.59396479e-02f,
  -4.10268344e-02f, 9.12307873e-02f, -2.85075102e-02f, -3.69086862e-02f, 1.38466628e-02f, 2.54607070e-02f, 3.87730077e-02f, 6.87854663e-02f, 3.27433459e-03f, 9.51304808e-02f,
  -1.16265535e-01f, -1.64238103e-02f, -5.83576486e-02f, 5.50142825e-02f, 1.26771498e-02f, 1.71494279e-02f, -1.14980452e-02f, -5.98963536e-02f, 1.11841684e-04f, -6.81168064e-02f,
  -5.27112931e-02f, -7.47045176e-03f, 5.46033718e-02f, -4.48126234e-02f, -8.77900943e-02f, -9.49216187e-02f, -4.22598608e-02f, -5.10444343e-02f, 3.70895155e-02f, 3.95426005e-02f,
  -7.41787478e-02f, -2.21895799e-01f, -1.35983199e-01f, -2.02557161e-01f, -5.94795831e-02f, -1.06177889e-01f, -2.31171310e-01f, -2.12722197e-01f, -1.18960269e-01f, -2.78749049e-01f,
  7.30217248e-02f, 6.12398148e-01f, 4.90465239e-02f, -3.67050096e-02f, -1.48891091e-01f, -2.13700101e-01f, 1.96253508e-01f, 1.27355024e-01f, -1.16134524e-01f, 2.83979774e-01f,
  5.84245548e-02f, -2.46002272e-01f, -2.79429294e-02f, -1.92247927e-01f, -6.47600070e-02f, 2.11789683e-01f, 3.61719467e-02f, -2.09763408e-01f, -3.94974381e-01f, -1.50680140e-01f,
  6.51628450e-02f, 2.47441202e-01f, -4.24022600e-02f, -7.79903308e-03f, 1.87431902e-01f, -1.93353146e-01f, 7.45124444e-02f, 1.74023882e-01f, -6.86953738e-02f, 2.90120870e-01f,
  1.07143454e-01f, 2.60948241e-01f, -2.97697723e-01f, -1.13164626e-01f, -3.34009118e-02f, -1.67649274e-03f, -8.51085503e-03f, 4.28863689e-02f, -7.35048279e-02f, 1.23969600e-01f,
  -6.28240232e-04f, -5.74905910e-02f, -1.73264537e-02f, 8.20877329e-02f, 1.48700163e-01f, -2.86744814e-02f, 8.95393863e-02f, 1.11343050e-02f, -1.39062166e-01f, -9.97024588e-03f,
  6.64026141e-02f, 8.98368564e-03f, 1.08741164e-01f, 1.52692236e-02f, 1.85854249e-02f, -1.43459976e-01f, -3.03999446e-02f, -1.00930087e-01f, -6.01712465e-02f, 1.95813581e-01f,
  1.06944358e-02f, 2.22702678e-02f, 2.67925728e-02f, 7.46764094e-02f, -4.14268026e-04f, -1.98572632e-02f, 7.86459912e-03f, -2.47497857e-02f, 3.77541296e-02f, 9.75579396e-02f,
  3.52787040e-02f, -6.08511828e-02f, -2.38005258e-02f, -2.90869139e-02f, -7.92648178e-03f, 2.03935616e-02f, -1.57156829e-02f, 4.45171036e-02f, -9.18658748e-02f, -2.07877699e-02f,
  -4.38194908e-02f, 6.63237041e-03f, 8.78478959e-02f, 4.22931574e-02f, -6.73839971e-02f, -3.87706161e-02f, 1.63016114e-02f, 3.37722301e-02f, 8.77908170e-02f, 3.91825661e-02f,
  5.41339442e-02f, -2.32723743e-01f, -8.34335480e-03f, 2.75228769e-02f, 6.50403425e-02f, 6.37523979e-02f, 3.11363619e-02f, -3.88736986e-02f, 5.07976525e-02f, -4.53411648e-03f,
  1.60662667e-03f, 3.65320258e-02f, 1.26054481e-01f, 2.09800061e-02f, 6.41132146e-02f, -9.62330550e-02f, 3.45262252e-02f, -6.34022728e-02f, -8.69636014e-02f, 1.26821071e-01f,
  6.81042895e-02f, 1.50514841e-02f, -4.20262702e-02f, -4.04717459e-04f, 2.19651908e-02f, -4.18716334e-02f, 3.60894799e-02f, 3.57751474e-02f, -1.34859949e-01f, 7.08829379e-03f,
  5.19366562e-01f, -1.29500315e-01f, 4.15567756e-02f, 4.96125221e-02f, -6.53316900e-02f, 1.47233889e-01f, -1.58309937e-01f, 5.70673421e-02f, 1.14940383e-01f, 1.59207336e-03f,
  6.61941990e-02f, 2.35238135e-01f, 2.57621467e-01f, 7.04030842e-02f, 9.67217311e-02f, -1.02156788e-01f, -2.06172347e-01f, -4.05166186e-02f, 1.01215437e-01f, 1.32903457e-01f,
  -1.20836027e-01f, -1.07151046e-01f, -3.00656247e-04f, 1.48449471e-04f, -1.92575037e-01f, 1.31997526e-01f, -9.67461616e-02f, -9.35834870e-02f, -3.22498791e-02f, -1.56322509e-01f,
  2.64860868e-01f, 8.79054051e-03f, 2.41264272e-02f, 1.42101750e-01f, 1.68033224e-02f, 1.26923352e-01f, 1.43469080e-01f, -4.35991287e-02f, 1.03770316e-01f, 9.16544348e-02f,
  7.13049769e-02f, -5.49137741e-02f, 5.15317805e-02f, 1.61266718e-02f, 6.60391077e-02f, -1.15502207e-02f, -2.81847753e-02f, -2.23676022e-02f, 1.84773803e-02f, 1.09138213e-01f,
  -7.37011060e-02f, 3.34088281e-02f, 2.89542228e-02f, -7.67372549e-02f, 5.67680597e-02f, 8.01235065e-02f, -1.73244569e-02f, -4.52974774e-02f, 3.45461406e-02f, 3.68351340e-02f,
  4.61243242e-02f, -2.46766079e-02f, 2.64903046e-02f, -7.76168779e-02f, 9.99117154e-04f, -4.43374403e-02f, -5.19775599e-02f, -1.13481306e-01f, -1.07505582e-01f, -8.96804333e-02f,
  4.25286498e-03f, -2.63617951e-02f, 2.13322267e-02f, -1.64494663e-02f, 2.26044133e-02f, -1.13477390e-02f, -1.96312312e-02f, -5.22211194e-02f, 2.73951970e-04f, 1.07811382e-02f,
  -2.17902139e-02f, -8.70067552e-02f, -5.75802773e-02f, 6.51509985e-02f, -1.55636109e-04f, 4.58704755e-02f, 9.93937552e-02f, -6.40042573e-02f, 3.61709972e-03f, 6.32023439e-04f,
  9.02674049e-02f, 7.63835162e-02f, 1.52824953e-01f, 1.95462890e-02f, 4.81188297e-02f, 9.95067880e-02f, 6.61883578e-02f, -1.50009496e-02f, 9.99483615e-02f, 2.41647232e-02f,
  4.58839983e-02f, 2.01613411e-01f, 5.51096648e-02f, 7.62690455e-02f, 1.15843214e-01f, 1.07294858e-01f, 1.45002119e-02f, 9.48567763e-02f, 1.15786247e-01f, 1.37988031e-01f,
  -2.88920663e-02f, 2.43038554e-02f, 1.85087040e-01f, 9.81430486e-02f, 1.23650037e-01f, 1.56633824e-01f, 9.91443098e-02f, 1.20939448e-01f, 2.37952217e-01f, 1.79546818e-01f,
  7.29933143e-01f, -3.19574565e-01f, 2.88736731e-01f, 5.93489930e-02f, -2.04046860e-01f, 1.20729454e-01f, -9.18158367e-02f, -1.07981181e-02f, -1.06393490e-02f, -2.53832310e-01f,
  1.61378048e-02f, 9.13238600e-02f, -3.99029255e-02f, 5.00101410e-03f, 2.13329732e-01f, -2.93602556e-01f, -1.67795002e-01f, 3.31151366e-01f, 5.06825387e-01f, 7.34637454e-02f,
  -2.81166941e-01f, -5.25148250e-02f, 2.45306566e-01f, 1.48773551e-01f, -2.17721447e-01f, 2.08661593e-02f, -1.26774654e-01f, 8.35928023e-02f, -1.01438254e-01f, -4.90937829e-01f,
  1.95768699e-01f, 2.01166868e-01f, 3.48887257e-02f, 4.17319611e-02f, -2.13048905e-02f, 2.37024892e-02f, 6.18650857e-03f, -7.17410352e-03f, -8.31696242e-02f, -3.75327729e-02f,
  -2.45644338e-02f, 2.81957686e-02f, 7.53924474e-02f, -7.52206445e-02f, 2.55987030e-02f, 2.65866183e-02f, -1.98740009e-02f, 1.69958383e-01f, 7.54038766e-02f, -1.15666069e-01f,
  -1.06448159e-01f, 2.77959965e-02f, 1.04428366e-01f, 3.77649143e-02f, 1.46860942e-01f, -1.30233215e-02f, 1.99858434e-02f, 7.78004006e-02f, 9.46057439e-02f, -1.67681128e-01f,
  3.00668161e-02f, -4.87760752e-02f, -8.13309569e-04f, -2.97498181e-02f, -5.02597876e-02f, 5.78361796e-03f, 1.96753163e-02f, -3.99127044e-02f, 1.62372310e-02f, -2.51289923e-02f,
  -6.04955014e-03f, -5.53866886e-02f, -3.07249594e-02f, 3.12382989e-02f, -4.25660536e-02f, -3.52615081e-02f, 6.34849370e-02f, -5.06847054e-02f, -6.29407726e-03f, -5.72719462e-02f,
  6.02687150e-02f, -1.73769915e-03f, -2.63061393e-02f, -8.30523111e-03f, -1.48297613e-02f, 3.27165425e-02f, -6.70654699e-03f, 3.18397246e-02f, 1.47815794e-02f, -5.39222620e-02f,
  -2.05730032e-02f, 1.39596954e-01f, -1.23673849e-01f, 6.19294308e-02f, 1.91596784e-02f, -1.05112419e-03f, 1.82831381e-02f, -9.73116606e-02f, -6.66476339e-02f, -3.15330736e-02f,
  5.50885573e-02f, 4.07748632e-02f, -2.66538002e-02f, -1.37066692e-02f, 7.81876892e-02f, 5.83621161e-03f, -7.66253471e-02f, 1.05700726e-02f, -2.51465794e-02f, -1.07807241e-01f,
  -6.73601851e-02f, -8.43434110e-02f, 3.24658342e-02f, 1.61943305e-02f, -2.44260542e-02f, 8.41471478e-02f, -1.89970899e-02f, 8.44180584e-03f, 1.60724297e-01f, -1.38302609e-01f,
  -1.99332580e-01f, -7.37478435e-02f, -5.05123511e-02f, -6.43623993e-02f, -1.07408144e-01f, -2.28034496e-01f, -2.53147513e-01f, -3.46300155e-02f, 1.56502631e-02f, -5.59236072e-02f,
  -3.12941745e-02f, 1.54038906e-01f, 7.40399659e-02f, 5.56219034e-02f, -6.89934120e-02f, -1.05219491e-01f, 2.06934452e-01f, 1.26582757e-01f, -2.38359824e-01f, -1.91757813e-01f,
  -4.44838079e-03f, 5.72663881e-02f, 1.38228655e-01f, 1.32578522e-01f, 2.46219441e-01f, 6.57661110e-02f, 1.23546846e-01f, 2.08245531e-01f, 1.42400920e-01f, 4.85507131e-01f,
  1.72999855e-02f, 8.73994082e-02f, -1.01272784e-01f, -7.57733583e-02f, 2.03409791e-02f, 2.78962534e-02f, -5.73845804e-02f, 5.01865149e-02f, -6.32315278e-02f, 1.43770734e-02f,
  1.34054050e-01f, 3.38727608e-02f, 6.34536073e-02f, 2.05902848e-02f, -3.40328254e-02f, -2.14336440e-02f, 6.08964451e-02f, 4.39807912e-03f, 6.57672212e-02f, -8.36480930e-02f,
  4.12277021e-02f, -9.33664106e-03f, 1.06971644e-01f, 1.90525632e-02f, 1.86071545e-02f, 5.22753783e-02f, -8.23251680e-02f, 7.98831210e-02f, 2.51889173e-02f, 4.36800942e-02f,
  -1.31544992e-01f, 1.72854457e-02f, 5.24055446e-03f, -7.83740357e-02f, -1.11782297e-01f, 2.81744320e-02f, 8.57194513e-02f, 7.31714219e-02f, -4.48971316e-02f, -4.65846360e-02f,
  1.89032368e-02f, -8.31074268e-02f, -7.57506937e-02f, -6.09452091e-02f, -7.59728923e-02f, -2.28605680e-02f, 4.07915674e-02f, 1.93871763e-02f, -3.89931612e-02f, 5.74437976e-02f,
  5.46222851e-02f, 3.23768472e-03f, -1.24252504e-02f, 1.16537392e-01f, -2.38091052e-02f, 1.38001636e-01f, 1.30734290e-04f, -7.62567073e-02f, -2.42369622e-02f, -8.00745338e-02f,
  -2.13567108e-01f, -7.61459544e-02f, 6.16566688e-02f, 2.64719361e-03f, 1.02571182e-01f, -1.34006403e-02f, 4.52245176e-02f, 7.90581554e-02f, 6.91984519e-02f, 1.63513534e-02f,
  -1.23757180e-02f, -1.58219654e-02f, -1.03768772e-02f, 4.73669842e-02f, -5.47734573e-02f, 3.17446366e-02f, -2.12814175e-02f, -2.42311247e-02f, -5.51234446e-02f, 3.83203961e-02f,
  -6.68656603e-02f, -1.20302945e-01f, -1.50839984e-01f, 2.41631176e-02f, -2.33273841e-02f, -1.65594548e-01f, -1.95856139e-01f, -1.93573043e-01f, -1.26380667e-01f, -3.09783250e-01f,
  2.90918112e-01f, 1.51999995e-01f, -1.99557781e-01f, 9.61020440e-02f, 6.08386844e-02f, 1.09541893e-01f, 3.53528082e-01f, 2.62289524e-01f, 1.62909269e-01f, 1.77331671e-01f,
  5.17422333e-03f, -1.30972192e-01f, 8.89680684e-02f, 1.36881433e-02f, 1.64034247e-01f, 1.87587574e-01f, 5.71933910e-02f, -1.60924599e-01f, 3.26757953e-02f, 2.89417394e-02f,
  1.09696267e-02f, -9.75667536e-02f, -7.25555420e-02f, -7.61948079e-02f, -1.46537021e-01f, -4.80299704e-02f, -1.68207347e-01f, -1.48613259e-01f, -9.70260054e-02f, -3.08236688e-01f,
  -3.21714014e-01f, 1.79263428e-01f, 8.44982713e-02f, 1.29907936e-01f, 5.85462106e-03f, 2.74318326e-02f, 8.49870965e-03f, -9.33933184e-02f, 3.47770564e-02f, 3.11421752e-02f,
  6.70227557e-02f, -4.15331349e-02f, 2.40961052e-02f, -1.08073922e-02f, 6.23034202e-02f, -1.16479187e-03f, 3.59239057e-02f, -3.19932140e-02f, 1.61727220e-02f, 6.95857927e-02f,
  4.06471416e-02f, -1.41806424e-01f, 2.25783307e-02f, 1.35726272e-03f, 1.72839046e-01f, 8.77572894e-02f, 9.57701355e-02f, 1.21656610e-02f, 1.36744946e-01f, 7.63487816e-02f,
  1.19318450e-02f, -4.99502048e-02f, -5.09494022e-02f, 4.95529398e-02f, 4.95735295e-02f, -1.30708879e-02f, -9.63984653e-02f, -7.33325258e-02f, -2.81337313e-02f, -1.93129126e-02f,
  -2.23202780e-02f, -1.74235683e-02f, -1.87326729e-01f, -3.72536853e-02f, -5.43852150e-02f, -8.69665220e-02f, 4.23631333e-02f, -3.38118747e-02f, -9.57743600e-02f, -1.23854037e-02f,
  -9.84582677e-02f, -7.34931156e-02f, -8.71729851e-02f, -8.48452523e-02f, -6.67218417e-02f, -1.78382900e-02f, -2.81931274e-02f, -2.21254248e-02f, -5.10607027e-02f, -1.04211450e-01f,
  2.53680944e-01f, 1.38517886e-01f, 1.01561449e-01f, 1.89369962e-01f, 1.83371723e-01f, 1.11119732e-01f, 5.41385636e-02f, 1.46547228e-01f, 8.30106288e-02f, 1.42136574e-01f,
  9.36455280e-02f, 1.32661313e-01f, 3.45674902e-02f, 7.26792961e-02f, 1.08953029e-01f, 1.35204405e-01f, 1.73966929e-01f, 1.52993679e-01f, 1.60279468e-01f, 2.59255301e-02f,
  2.04387754e-01f, 1.36640996e-01f, 2.15135664e-01f, 1.32077321e-01f, 9.47519317e-02f, 2.32294887e-01f, 1.54338941e-01f, 2.00114921e-01f, 1.95595086e-01f, 3.81385833e-01f,
  -5.52938432e-02f, -1.53792322e-01f, 7.45246038e-02f, 2.88239438e-02f, 1.13349920e-02f, 1.54829651e-01f, 9.06766951e-02f, -1.00926489e-01f, -2.76117083e-02f, 1.04935639e-01f,
  -9.15394723e-02f, -2.13532612e-01f, -1.88569069e-01f, -1.99490815e-01f, -1.82502598e-01f, -8.30567554e-02f, -2.67670304e-01f, -1.79693893e-01f, -6.06345348e-02f, 1.13331296e-01f,
  3.70639190e-03f, -8.88330862e-02f, -2.82718211e-01f, -2.18353063e-01f, -3.65726240e-02f, 1.16793171e-01f, -5.76846078e-02f, -8.27267021e-02f, 8.93875062e-02f, -2.92154223e-01f,
  1.37590235e-02f, -1.98725730e-01f, -4.77219298e-02f, -2.25988314e-01f, -1.38441518e-01f, -1.94111541e-02f, 6.42795563e-02f, -7.54165575e-02f, -3.93139161e-02f, 8.58918997e-04f,
  -1.83515176e-01f, -1.17386039e-02f, -2.38879547e-01f, -8.01758543e-02f, -7.93190151e-02f, -6.05415553e-02f, -2.23207533e-01f, -2.30084792e-01f, -6.28535375e-02f, 4.00047265e-02f,
  -1.31049708e-01f, -1.96906701e-01f, -1.64563879e-01f, -1.10032164e-01f, -1.22204889e-02f, -8.87349546e-02f, -5.92648163e-02f, -6.12712726e-02f, -5.33989025e-03f, 3.06647252e-02f,
  3.89114283e-02f, 1.14584796e-01f, 1.75028518e-01f, 3.49184684e-03f, 1.25963986e-01f, 1.15135424e-01f, 1.36074007e-01f, 7.48236477e-02f, 7.86244124e-02f, 1.96066931e-01f,
  8.58872160e-02f, 1.28343299e-01f, -1.19277672e-03f, 1.19088858e-01f, -4.14216146e-02f, 7.88174570e-02f, 1.05167173e-01f, 1.08358860e-01f, 8.27914849e-03f, 4.14647050e-02f,
  2.46663503e-02f, 1.48633614e-01f, 9.65019315e-02f, -2.26989668e-02f, 1.82791185e-02f, 1.16472438e-01f, 2.08189730e-02f, 8.02786723e-02f, -5.57807125e-02f, -2.91018430e-02f,
  1.35058999e-01f, -2.51414597e-01f, 4.78575453e-02f, -8.87269899e-02f, -9.15699154e-02f, -9.03721303e-02f, -4.01239321e-02f, -3.56484540e-02f, -7.06225112e-02f, -1.33899808e-01f,
  -1.69668794e-01f, -8.02829489e-02f, -6.64502531e-02f, -6.07725754e-02f, -9.60837156e-02f, -8.69957358e-02f, -1.22664377e-01f, -5.78590147e-02f, -1.36676520e-01f, -8.97815377e-02f,
  -4.41688038e-02f, 2.42737662e-02f, 5.39001711e-02f, 7.11529795e-03f, -1.47929221e-01f, 4.24839742e-02f, 9.38855484e-03f, 3.69448215e-02f, 8.65017399e-02f, 2.17061475e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.11368430e-01f, -1.88800186e-01f, 4.65321422e-01f, 2.80064076e-01f, 5.17283916e-01f, 5.73513508e-01f, 5.21436334e-01f, 2.76335746e-01f, 7.50906691e-02f, 9.61165503e-02f,
  1.72547325e-02f, -1.15749985e-01f, -2.14109212e-01f, -2.71156937e-01f, -2.19065085e-01f, -2.43615247e-02f, -3.30254734e-02f, -7.90463686e-02f, 9.39176977e-02f, 2.98190862e-01f,
  -9.01156440e-02f, -3.87650984e-03f, -1.61469251e-01f, -9.36580077e-02f, -1.64082646e-01f, -9.17412639e-02f, 5.75648248e-02f, 2.82544009e-02f, -4.97942045e-03f, -4.61820424e-01f,
  4.96821515e-02f, 1.05768494e-01f, 8.55124965e-02f, -1.03448667e-01f, -6.52571544e-02f, -1.06754042e-01f, -4.96698804e-02f, 1.72002092e-02f, 1.78023800e-01f, 8.22576508e-02f,
  -4.89560626e-02f, -1.53786376e-01f, -1.39752045e-01f, -1.24490261e-01f, 8.24098289e-02f, 6.71935501e-04f, -1.80802569e-01f, -2.51370985e-02f, 1.09184146e-01f, 1.28129348e-01f,
  -5.80783933e-02f, 2.88886547e-01f, 3.70612830e-01f, 2.24561721e-01f, 1.44838810e-01f, 1.09539879e-02f, 3.36732678e-02f, -5.06703220e-02f, 1.43938854e-01f, -1.11484177e-01f,
  7.03622326e-02f, 1.97929218e-02f, -1.18318669e-01f, -5.09070717e-02f, -1.16917416e-01f, 7.34818503e-02f, -1.15107343e-01f, 4.40231003e-02f, -1.06464475e-02f, -9.49230567e-02f,
  -2.88556572e-02f, 7.65381288e-03f, 1.04373343e-01f, 2.27853227e-02f, -1.19479321e-01f, 8.32491815e-02f, 1.38051538e-02f, -4.36106324e-02f, -1.18143940e-02f, -7.17996284e-02f,
  -4.17451449e-02f, 2.69866418e-02f, -2.14100499e-02f, -1.63706422e-01f, 2.25086585e-02f, -3.81826982e-02f, 1.14039262e-03f, 1.04078557e-02f, 7.66590890e-03f, 1.72014460e-01f,
  -3.19455922e-01f, 1.60034135e-01f, -1.64205521e-01f, -2.87243761e-02f, -1.35945335e-01f, -1.99442253e-01f, 2.82497592e-02f, 3.78417457e-03f, 5.34048751e-02f, 3.07525489e-02f,
  1.12370111e-01f, -1.89402513e-02f, -1.42106162e-02f, 2.26744525e-02f, 1.08838029e-01f, 7.99468309e-02f, -9.32622477e-02f, 9.31295902e-02f, 7.91701525e-02f, 3.08652297e-02f,
  7.03926980e-02f, 1.53905720e-01f, 3.10312271e-01f, 1.08048841e-01f, 2.57771648e-02f, 6.14823326e-02f, 1.34786274e-02f, 9.02358294e-02f, 5.39168604e-02f, 1.35535911e-01f,
  -3.27655882e-01f, -9.88305956e-02f, -3.48947495e-02f, -2.50736386e-01f, 3.05612355e-01f, 1.91162713e-02f, -1.34238616e-01f, -2.18630269e-01f, -9.50287730e-02f, 5.43213226e-02f,
  2.87039399e-01f, 1.71861053e-01f, 2.56886464e-02f, -1.50679529e-01f, -5.58592737e-01f, -5.49896806e-02f, -1.41262665e-01f, -3.25013280e-01f, -3.59462410e-01f, -1.32144466e-01f,
  1.85123459e-01f, -2.79497594e-01f, -5.51062346e-01f, -9.28172767e-02f, 2.65246689e-01f, 3.10254861e-02f, 8.43811259e-02f, 4.01104093e-02f, 1.37856707e-01f, 1.09212540e-01f,
  2.21880019e-01f, 1.34552434e-01f, 4.67846403e-03f, -3.03612649e-02f, 2.26741493e-01f, -5.98597936e-02f, -7.32165724e-02f, 8.01767558e-02f, 1.16799086e-01f, 1.31303713e-01f,
  5.32730818e-02f, 4.62838188e-02f, 5.73085248e-03f, -8.58694240e-02f, -2.73261160e-01f, -9.97491106e-02f, -1.85146719e-01f, -1.75482526e-01f, -2.19639033e-01f, -1.81323841e-01f,
  -9.69063863e-03f, 1.88484415e-01f, -1.63500100e-01f, -9.17202979e-02f, 1.01428218e-02f, -1.46584332e-01f, 2.45963018e-02f, 1.55204535e-01f, -1.29192099e-02f, -1.13510951e-01f,
  -5.05186804e-02f, -3.47235687e-02f, -2.23422293e-02f, 1.00516500e-02f, -7.27897659e-02f, 1.53977871e-01f, -7.20617473e-02f, -1.24063469e-01f, -7.35773593e-02f, 5.34706004e-02f,
  -7.55500495e-02f, 1.21791614e-02f, 2.93264892e-02f, -3.93823385e-02f, 8.76263008e-02f, 1.61915161e-02f, 1.01722643e-01f, -1.37726665e-01f, 3.38935889e-02f, -1.10350261e-02f,
  -1.17780685e-01f, 7.38212690e-02f, -7.80197009e-02f, 9.24422070e-02f, -2.65461951e-02f, -4.58129421e-02f, 4.88558337e-02f, -4.35512252e-02f, -5.85528053e-02f, 4.68271077e-02f,
  -1.95443451e-01f, 1.24066927e-01f, 5.20786382e-02f, -5.44644780e-02f, 4.88523766e-02f, 6.45514131e-02f, -9.05848481e-03f, -7.61514157e-02f, -1.74356867e-02f, -4.13759165e-02f,
  -1.31452590e-01f, -3.56232859e-02f, 9.07782242e-02f, 4.60407175e-02f, -1.38599068e-01f, -5.02346233e-02f, -1.00769619e-04f, 6.58057211e-03f, -1.49262801e-01f, 3.32501507e-03f,
  -2.25947693e-01f, -3.77270669e-01f, -4.07601833e-01f, -2.10091531e-01f, 4.00755443e-02f, -1.33377209e-01f, -4.34089862e-02f, 5.03855459e-02f, -8.54981169e-02f, -4.35668111e-01f,
  -7.75398135e-01f, 1.54961094e-01f, 1.45220414e-01f, -2.29718283e-01f, -1.87070847e-01f, -2.72549301e-01f, 3.23889703e-02f, -2.07086533e-01f, -3.27595949e-01f, -3.81257981e-02f,
  5.18071167e-02f, 4.39211167e-03f, 1.31235391e-01f, 6.06816560e-02f, 8.22069123e-02f, 2.08603591e-01f, -3.19310627e-03f, 9.19208769e-03f, -1.21227212e-01f, -1.68261647e-01f,
  -2.12253388e-02f, 6.37632012e-02f, -9.03459936e-02f, -1.47616982e-01f, -2.60345284e-02f, -6.85765669e-02f, 2.40806848e-01f, -6.44407198e-02f, -1.98806331e-01f, 9.70776677e-02f,
  5.80785215e-01f, 9.36782882e-02f, 9.90108401e-02f, -8.45027789e-02f, 1.69319496e-01f, 3.46514545e-02f, -1.08522531e-02f, 6.98441938e-02f, -9.58290249e-02f, -4.77567464e-02f,
  1.26411365e-02f, -6.48919567e-02f, 3.19277532e-02f, 6.81108311e-02f, 5.28267445e-03f, -9.61470418e-03f, -9.91306677e-02f, 9.28466674e-03f, -2.08951719e-02f, 2.23874569e-01f,
  1.09470129e-01f, -6.59899786e-02f, 3.67088467e-02f, -1.09685048e-01f, -1.14950895e-01f, -7.11716563e-02f, 1.03560701e-01f, -1.11623287e-01f, -2.23959774e-01f, 1.34930974e-02f,
  -1.56183288e-01f, -2.46991944e-02f, -1.06846513e-02f, -2.68183113e-03f, -3.34146842e-02f, -2.37479042e-02f, -2.19710940e-03f, 5.89705780e-02f, -2.97228545e-02f, -1.85692012e-01f,
  -1.42322406e-01f, 1.11129589e-01f, 7.39737898e-02f, -7.79583752e-02f, 4.75405753e-02f, -1.21419542e-01f, -9.42683816e-02f, 8.24441761e-02f, -2.33178539e-03f, -6.46310747e-02f,
  -2.26577576e-02f, -8.69495645e-02f, 7.40527734e-02f, 6.41159937e-02f, 6.06337143e-03f, -1.03959657e-01f, -7.00420588e-02f, -3.13123427e-02f, -1.63880140e-01f, -8.79890323e-02f,
  3.82063895e-01f, -1.34285465e-02f, 2.63279378e-01f, 1.03920937e-01f, -5.31738736e-02f, 8.11938569e-03f, 3.85456607e-02f, 7.56009445e-02f, 1.17151201e-01f, 7.23357350e-02f,
  9.44780558e-02f, -9.48153511e-02f, 4.54359166e-02f, 2.02894099e-02f, -1.41687036e-01f, 2.28715502e-02f, 2.00756695e-02f, 6.28045350e-02f, 7.06235990e-02f, 7.73283746e-03f,
  -6.95801750e-02f, 7.07625300e-02f, 9.74868014e-02f, 1.45845622e-01f, 7.15587735e-02f, -1.35623142e-01f, 1.85065687e-01f, 1.12028293e-01f, 8.58296156e-02f, 9.09604132e-02f,
  -5.52866161e-01f, -2.29712591e-01f, 5.96324801e-02f, -4.84041512e-01f, -1.12659484e-01f, 1.59058586e-01f, -9.08100381e-02f, -4.83251587e-02f, -1.43309548e-01f, -3.12188804e-01f,
  -8.94112587e-02f, -2.03454364e-02f, -2.62384713e-01f, 1.19536489e-01f, 1.97719604e-01f, -6.38416409e-02f, -9.76323560e-02f, -3.68892658e-03f, 3.05676758e-01f, 4.92252231e-01f,
  4.49922271e-02f, -4.89603356e-02f, 2.39155218e-02f, 2.56216794e-01f, -7.11323693e-02f, -9.52095613e-02f, -1.76815569e-01f, -8.42152163e-02f, 2.20365360e-01f, -5.43411672e-01f,
  -2.08500117e-01f, -4.20845263e-02f, 2.46121421e-01f, -1.45020023e-01f, 1.83252897e-02f, 1.47412466e-02f, 5.27391583e-02f, -1.69007853e-01f, 5.86793721e-02f, -2.31330264e-02f,
  4.90895286e-02f, 1.28863096e-01f, -5.34594432e-02f, 1.25765726e-02f, -1.15783680e-02f, 4.21963446e-03f, 1.41190544e-01f, -1.46693671e-02f, 7.73988524e-03f, 7.77474344e-02f,
  -1.52077705e-01f, -1.45270735e-01f, -7.83556476e-02f, 1.94742501e-01f, 1.65546685e-01f, -1.24380313e-01f, 1.42216146e-01f, 1.74861953e-01f, 1.50493473e-01f, -4.49187249e-01f,
  3.88767533e-02f, 4.77424171e-03f, 6.92713857e-02f, 5.43280281e-02f, -1.52671197e-02f, -4.31482866e-02f, -5.94596528e-02f, 7.78291374e-02f, 9.35217887e-02f, -1.38194695e-01f,
  6.79738075e-02f, 1.07410923e-01f, 4.96207140e-02f, -2.49864627e-02f, 4.22187373e-02f, -5.35482988e-02f, -2.29371414e-02f, -7.58729577e-02f, -5.92048606e-03f, -6.32437989e-02f,
  7.12830946e-02f, -6.34785369e-02f, -3.88301280e-03f, 6.66593164e-02f, 4.73540649e-02f, -1.93859562e-02f, 1.51314763e-02f, 7.34433383e-02f, -1.20166942e-01f, -8.83889124e-02f,
  -1.61395445e-01f, 4.86980408e-01f, -3.51398468e-01f, -2.90928800e-02f, -3.32487933e-02f, 1.55458541e-03f, -9.59033072e-02f, 5.73271997e-02f, 2.30679438e-02f, -4.05703858e-03f,
  1.67851135e-01f, -1.21515192e-01f, -5.41292280e-02f, 1.37597233e-01f, 3.99203263e-02f, 2.62261294e-02f, 3.34330127e-02f, -1.01421677e-01f, 1.14180848e-01f, -1.32925045e-02f,
  8.53527337e-03f, -1.18101977e-01f, -1.25710502e-01f, -1.23654395e-01f, -1.64909691e-01f, -1.40728131e-01f, -1.56200200e-01f, -1.81113124e-01f, -2.01389700e-01f, -3.95555347e-01f,
  -9.66405094e-01f, -1.75221279e-01f, -3.52365314e-04f, -4.12152946e-01f, -4.85196058e-03f, 8.37956071e-02f, 4.94792350e-02f, -3.79697420e-02f, -1.68088317e-01f, 5.29999100e-02f,
  -4.45353054e-02f, -6.08631447e-02f, -2.35087246e-01f, -1.06330216e-01f, -3.79669696e-01f, -6.14051372e-02f, -1.96459293e-01f, -4.77327049e-01f, -2.85133392e-01f, 2.07250759e-01f,
  -5.63728027e-02f, -5.71581125e-01f, -7.56399214e-01f, -2.77617604e-01f, 5.97756468e-02f, -2.12652370e-01f, -5.58896102e-02f, -7.07430616e-02f, 2.63282396e-02f, -3.12918901e-01f,
  2.91479975e-01f, -1.02653086e-01f, 9.53247305e-03f, -1.67043209e-01f, -2.45630108e-02f, -6.89799637e-02f, 1.19181769e-02f, -1.01453736e-01f, 1.07731938e-01f, 1.11455992e-01f,
  -3.73275392e-02f, 7.27116223e-03f, -1.23738140e-01f, -2.50006542e-02f, -2.43971571e-02f, 7.88656920e-02f, 5.19480333e-02f, -6.13977984e-02f, -5.13743088e-02f, 2.27447793e-01f,
  2.53561825e-01f, 1.14507012e-01f, 6.09716550e-02f, 2.38999158e-01f, 2.71787912e-01f, -4.46959771e-02f, 2.00722054e-01f, 1.93601936e-01f, 1.80002283e-02f, 1.42959490e-01f,
  -2.67842691e-02f, 1.27672762e-01f, 4.32102643e-02f, -4.40971786e-03f, -1.70904607e-01f, 3.90625820e-02f, 3.26370895e-02f, 4.81458269e-02f, -9.78826880e-02f, 5.84821217e-02f,
  1.41036734e-01f, -4.92351204e-02f, -3.44323069e-02f, -9.38612670e-02f, -1.10601090e-01f, -1.03137158e-01f, -1.70766845e-01f, 4.19506850e-03f, 6.40066266e-02f, -6.91562369e-02f,
  1.65970996e-02f, 1.24595389e-02f, -7.05660060e-02f, -7.44290054e-02f, -4.40429896e-02f, -2.08530985e-02f, -3.70965749e-02f, 3.86931859e-02f, -3.23865935e-03f, -1.59795433e-02f,
  -9.67356265e-02f, -3.61947387e-01f, -8.65242556e-02f, -1.02178724e-02f, -3.31893563e-02f, 5.74428141e-02f, 4.29890677e-02f, 5.16575836e-02f, 2.54134387e-02f, 6.50991276e-02f,
  8.12781453e-02f, 2.93290615e-02f, -6.26367033e-02f, 1.19421884e-01f, 1.12448148e-01f, -1.16076153e-02f, 2.90757641e-02f, -1.38049573e-01f, 2.06578989e-02f, 2.15834558e-01f,
  6.06698059e-02f, -1.48074785e-02f, -5.87221794e-03f, 5.79120331e-02f, -1.77462734e-02f, -3.39779854e-02f, 1.12991259e-01f, 5.29702008e-02f, 2.54448205e-02f, 1.52375937e-01f,
  -1.02999628e-01f, 7.87851289e-02f, -4.74203825e-01f, -5.22095442e-01f, -1.36726677e-01f, 1.04440451e-01f, 5.73596498e-03f, 7.58803785e-02f, 1.15811564e-01f, 2.51250947e-03f,
  -1.43816955e-02f, -1.91382751e-01f, -3.32355857e-01f, -2.91628204e-02f, 1.73029944e-01f, 4.88033518e-02f, -2.34995931e-01f, -1.79920584e-01f, 8.54937732e-02f, 2.66452134e-01f,
  9.10180733e-02f, -2.75393426e-01f, -2.32497066e-01f, 3.21860202e-02f, -1.83040828e-01f, -1.42402232e-01f, -3.04594696e-01f, -1.63254216e-01f, 1.93932891e-01f, -2.76113331e-01f,
  -2.20985487e-01f, -1.21018223e-01f, -5.88231906e-03f, 2.20232308e-02f, -1.51549608e-01f, 8.57857838e-02f, -2.06421185e-02f, -2.39708602e-01f, -2.76561156e-02f, 7.00475788e-03f,
  -1.49890944e-01f, 3.35584991e-02f, -2.06067562e-01f, 1.72774047e-02f, -1.56634644e-01f, 2.31190622e-02f, -4.89122756e-02f, -1.33085996e-02f, 3.33918966e-02f, -4.63766865e-02f,
  7.75955766e-02f, 6.40245155e-02f, -9.81547236e-02f, -2.98770946e-02f, 1.53198643e-02f, -7.00623915e-02f, -5.09964898e-02f, -2.96595693e-02f, -7.80352727e-02f, 3.43413390e-02f,
  9.49397907e-02f, -2.15469286e-01f, -4.53212783e-02f, 3.86062004e-02f, -1.53015135e-02f, -2.88487207e-02f, -1.57998607e-01f, 1.05123445e-01f, -2.45182812e-02f, -1.40200555e-01f,
  -1.64442193e-02f, -1.93574220e-01f, -2.59124748e-02f, 7.32416064e-02f, -1.34215608e-01f, -9.82435867e-02f, 1.63829044e-01f, 1.20998975e-02f, -2.86390092e-02f, -4.73668911e-02f,
  6.34618551e-02f, 8.99105370e-02f, 3.81266139e-02f, 2.69749817e-02f, 4.00132164e-02f, 3.55174243e-02f, -4.50301990e-02f, 1.34605393e-01f, 2.02819467e-01f, 3.25357139e-01f,
  -6.72605112e-02f, 1.02976575e-01f, -2.40367488e-03f, 1.09951913e-01f, -1.12110436e-01f, 8.17874819e-02f, -1.67528257e-01f, 7.78912604e-02f, -1.73714966e-01f, 3.06880325e-02f,
  3.11025344e-02f, 8.16084631e-03f, -1.26322851e-01f, 4.93859202e-02f, -1.91939659e-02f, 3.53912450e-02f, 1.02273095e-03f, -2.29219962e-02f, -7.96174705e-02f, 1.05826750e-01f,
  1.14991337e-01f, 2.25442261e-01f, 1.41679794e-01f, -4.07188311e-02f, -4.09632735e-02f, 1.00668937e-01f, 1.26055507e-02f, 1.24116331e-01f, 1.85174376e-01f, 2.06810519e-01f,
  -4.71575171e-01f, -6.28730953e-02f, -3.07365030e-01f, 9.64973047e-02f, 1.24920674e-01f, 1.92665547e-01f, 3.47070575e-01f, 1.68185323e-01f, 1.02558509e-01f, 8.61965120e-02f,
  -9.74180643e-03f, 1.85548425e-01f, 2.11227268e-01f, 3.13365340e-01f, 2.42160782e-01f, 3.82197201e-01f, 3.76352400e-01f, 1.34280995e-01f, -1.03454269e-01f, -8.45772624e-02f,
  1.61362991e-01f, -5.47670946e-02f, -2.70769745e-01f, 6.47617504e-02f, 1.25932455e-01f, 6.83582053e-02f, 4.98945750e-02f, -1.05131201e-01f, -2.17185486e-02f, 2.09001929e-01f,
  -1.40070170e-01f, -1.31309599e-01f, 1.87784731e-01f, -1.16440475e-01f, -1.96566984e-01f, -9.72515345e-02f, -1.43775657e-01f, -1.77106693e-01f, -2.01299801e-01f, -9.21011120e-02f,
  -7.95407221e-02f, -2.16190424e-02f, 6.46302998e-02f, -1.06331721e-01f, -1.96564749e-01f, -1.47219971e-01f, -2.87560723e-03f, 1.58433229e-01f, 1.96000516e-01f, 3.51350792e-02f,
  2.28658944e-01f, -1.81325078e-01f, -2.37478018e-01f, 5.52224889e-02f, 1.71619803e-01f, 2.55694594e-02f, -1.08870752e-01f, -2.69716848e-02f, -3.92187424e-02f, 6.08583763e-02f,
  2.39144400e-01f, -1.07558966e-01f, -7.74258971e-02f, 1.69897318e-01f, 1.11479297e-01f, 1.23002388e-01f, 1.20560311e-01f, -2.48200446e-02f, 1.33932039e-01f, -1.33336186e-01f,
  -1.76905580e-02f, 9.15120356e-03f, -3.71347903e-03f, 3.65547836e-02f, 5.73117062e-02f, 3.71098891e-02f, -9.14370269e-02f, -6.12206906e-02f, -9.99939218e-02f, 2.58241910e-02f,
  2.00853553e-02f, 6.10685050e-02f, -1.09597959e-01f, 1.18802853e-01f, -1.76214073e-02f, -9.27173421e-02f, -8.55225772e-02f, -1.42068848e-01f, -1.02934636e-01f, 4.27170247e-02f,
  -4.61773798e-02f, 1.37021735e-01f, 3.89072031e-01f, 2.51366794e-01f, -3.57705802e-02f, -4.21563163e-02f, 1.21268667e-01f, -6.34117648e-02f, -1.25715155e-02f, -1.71094611e-02f,
  -6.09595887e-02f, -1.16999021e-04f, 1.25942854e-02f, -3.65240574e-02f, -9.12044346e-02f, -8.21563154e-02f, 1.00993149e-01f, 1.43741921e-01f, 1.19918324e-01f, -5.88979125e-02f,
  3.34608741e-02f, -6.25361502e-02f, -1.31748170e-01f, 1.62721246e-01f, 1.20001726e-01f, 5.49474172e-03f, -6.69733435e-02f, -7.60059506e-02f, -5.08683212e-02f, -1.28062051e-02f,
  6.52786940e-02f, -3.94398123e-01f, -6.98104382e-01f, -2.05808189e-02f, -1.69566855e-01f, 1.03886172e-01f, -1.07429460e-01f, 2.04726219e-01f, 1.87719718e-01f, -4.15888786e-01f,
  -2.35449150e-01f, -5.52080609e-02f, -1.89234778e-01f, -2.26862162e-01f, -8.87113139e-02f, -2.68898606e-01f, -3.12821776e-01f, -2.48940617e-01f, 1.73106447e-01f, 3.27748656e-01f,
  1.81956589e-01f, -1.40171871e-02f, 2.34493893e-02f, 4.80807163e-02f, 3.79002071e-03f, -1.55857474e-01f, -6.39158428e-01f, -2.97492355e-01f, -1.86713219e-01f, -5.49338639e-01f,
  -2.32531950e-01f, -2.09183544e-01f, 1.30485278e-02f, -2.41168980e-02f, -1.80785269e-01f, 4.45948951e-02f, -4.68778498e-02f, -1.10092126e-01f, 1.18699335e-01f, 1.27625108e-01f,
  -7.72404298e-02f, 3.44413482e-02f, 1.41486332e-01f, 4.21997532e-02f, 1.56612862e-02f, 6.70359954e-02f, -1.05841113e-02f, -4.32062224e-02f, 7.26826140e-04f, 1.10855602e-01f,
  -2.44802143e-02f, -3.60606946e-02f, -3.70410010e-02f, 3.45689841e-02f, -1.31329587e-02f, -2.07193464e-01f, -1.95612550e-01f, -3.70520018e-02f, -1.92796111e-01f, -1.70561582e-01f,
  -1.11444533e-01f, 1.17213978e-02f, -7.34586790e-02f, 7.03935400e-02f, 9.61772576e-02f, 6.68216273e-02f, 7.30954483e-02f, -4.59061675e-02f, 7.20550418e-02f, -4.02468257e-03f,
  -2.47679129e-02f, -9.31259841e-02f, 3.39143947e-02f, -6.94450811e-02f, -8.49750265e-02f, 2.49121096e-02f, -1.51240960e-01f, 3.27763259e-02f, -7.17248209e-03f, -9.87606123e-03f,
  -3.05003785e-02f, -9.72848088e-02f, -1.01994388e-01f, -2.89577544e-02f, -1.78042710e-01f, -1.62009835e-01f, -1.55796885e-01f, 1.75705254e-02f, -3.57310101e-02f, -1.34060159e-01f,
  1.63801193e-01f, -2.39415005e-01f, 9.53747183e-02f, 4.06541452e-02f, -7.54832104e-02f, -7.70526305e-02f, -1.30418226e-01f, 8.18182901e-02f, 7.69637302e-02f, 1.26788110e-01f,
  2.75221840e-03f, -2.57641766e-02f, -8.92901123e-02f, -1.39440149e-02f, 4.56323251e-02f, 5.73823899e-02f, 1.01187406e-02f, 4.12341990e-02f, 6.53089806e-02f, 9.54199210e-02f,
  -2.76937406e-03f, 1.14389688e-01f, 2.07807511e-01f, 1.38216140e-02f, 2.02807397e-01f, 9.86245796e-02f, -4.70787138e-02f, 6.67757764e-02f, 1.14949092e-01f, 1.64742813e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.64244220e-03f, 4.75843400e-02f, -1.72584638e-01f, 2.47162748e-02f, -3.60373817e-02f, 7.90620223e-02f, -1.78301409e-01f, 1.64117292e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.15605384e-01f, -5.06808721e-02f, 6.16535060e-02f, 5.68715669e-02f, 1.52297258e-01f, 1.21623844e-01f, -6.60986528e-02f, -1.06676109e-01f, -1.78762600e-01f, 2.21963644e-01f,
  2.73784190e-01f, 2.96575632e-02f, 8.93214419e-02f, -3.36460620e-01f, 1.73093770e-02f, -5.97142279e-02f, 7.40033314e-02f, -1.74650654e-01f, -3.51547956e-01f, -8.34446847e-02f,
  3.54094833e-01f, -1.64149031e-01f, -3.58899981e-02f, 6.01406582e-02f, 4.25145030e-02f, 9.00258571e-02f, -3.46497357e-01f, 6.76027656e-01f, -5.20987809e-02f, 1.19787127e-01f,
  4.64737341e-02f, 9.16499645e-02f, 2.25597054e-01f, -8.01941305e-02f, 1.95317805e-01f, 1.68286776e-03f, -1.94879323e-01f, 2.23518386e-01f, -2.83309855e-02f, -5.58349974e-02f,
  3.77495028e-02f, 9.50778052e-02f, -6.15820475e-03f, 3.41040976e-02f, 1.18272856e-01f, 2.89101034e-01f, -3.06327995e-02f, -2.91446000e-02f, -1.27429679e-01f, 2.62333483e-01f,
  1.55332819e-01f, 1.31472155e-01f, 3.64058197e-01f, -9.37534869e-02f, 1.54393435e-01f, 1.76017359e-02f, -3.62269700e-01f, -8.80269632e-02f, 1.99206844e-01f, -2.30955675e-01f,
  -6.52678311e-02f, 5.15396036e-02f, -1.08502522e-01f, 1.39798015e-01f, 7.27965534e-02f, 7.94447213e-02f, 2.08135530e-01f, 1.33992985e-01f, -1.22619256e-01f, 5.76605573e-02f,
  7.65421689e-02f, -4.05143984e-02f, -1.91042980e-03f, 2.22374171e-01f, 1.69476405e-01f, 2.18886808e-02f, 8.35011527e-03f, 5.86439483e-02f, 5.46264946e-02f, -1.72151923e-01f,
  -3.07045933e-02f, 1.11631170e-01f, 7.72779882e-02f, 1.40005983e-02f, 2.29219928e-01f, -1.65499300e-01f, 9.64149833e-02f, -3.31403944e-03f, 1.53660476e-01f, -2.33680844e-01f,
  2.11295515e-01f, -3.89163852e-01f, -2.11211994e-01f, -4.70181219e-02f, 3.93046923e-02f, 1.29621504e-02f, -2.68877894e-01f, 1.07973799e-01f, -5.93698323e-02f, 1.05872221e-01f,
  3.63661915e-01f, -3.58442217e-01f, 2.30000526e-01f, 2.21042916e-01f, 3.64442229e-01f, -2.74513930e-01f, -1.92812815e-01f, -8.55603591e-02f, -1.96740299e-01f, 6.61226735e-03f,
  -2.73345225e-02f, 9.80718434e-02f, -1.38679724e-02f, -7.89493695e-02f, 1.73381403e-01f, 1.16232105e-01f, -1.66337043e-01f, 1.56655639e-01f, -6.88630715e-02f, 6.69810409e-03f,
  -1.90420732e-01f, 1.22567661e-01f, 1.34372860e-01f, -2.35439897e-01f, 1.49692774e-01f, -2.92295609e-02f, -1.48497134e-01f, -4.28804569e-02f, 1.40000656e-01f, 6.81103989e-02f,
  -3.15390155e-02f, -1.20291285e-01f, -1.58828363e-01f, -7.75551647e-02f, -3.53235573e-01f, -1.93272799e-01f, -8.81408751e-02f, 1.17445141e-01f, -1.17436118e-01f, -5.39599434e-02f,
  1.73051313e-01f, -1.55009314e-01f, 2.75511920e-01f, -2.43431479e-01f, 1.86759010e-01f, 1.26809508e-01f, -1.89761609e-01f, -1.01366900e-01f, 3.71211201e-01f, 2.28445798e-01f,
  -1.32742360e-01f, -9.34879258e-02f, -6.19243179e-03f, -2.58246809e-01f, 1.16993338e-01f, 2.35061392e-01f, -1.91303194e-01f, -1.87247947e-01f, 8.10272247e-02f, -4.21976984e-01f,
  2.42317930e-01f, -8.19602534e-02f, -5.47405854e-02f, -1.18074238e-01f, -2.03331053e-01f, -6.61098212e-02f, -1.41435102e-01f, 9.45509151e-02f, 6.21951595e-02f, -3.45821232e-02f,
  -2.55614698e-01f, -3.75425257e-02f, -5.12728207e-02f, 1.99385107e-01f, -4.81118588e-03f, -1.46117702e-01f, 1.19144479e-02f, 5.46790063e-01f, 1.69295177e-01f, -1.25291348e-01f,
  -2.31596217e-01f, 2.63230205e-01f, 1.36098623e-01f, -8.81684572e-02f, -2.12252989e-01f, -2.24509284e-01f, 5.45216575e-02f, -1.07351243e-01f, -1.24131560e-01f, -5.22013530e-02f,
  -1.16412885e-01f, -1.87214598e-01f, 6.22554757e-02f, -9.22519863e-02f, 6.98846132e-02f, 3.00585832e-02f, -1.68897346e-01f, -2.33019382e-01f, 7.82711208e-02f, -5.43580949e-02f,
  -1.25725679e-02f, -1.01601854e-01f, -8.46259296e-02f, -1.30962849e-01f, 3.49896029e-02f, 2.05978930e-01f, -5.45506179e-02f, 1.17917158e-01f, 1.06603816e-01f, 2.92003721e-01f,
  -6.04887083e-02f, 1.08605959e-01f, 4.24971208e-02f, 2.68753439e-01f, -7.59145319e-02f, -5.47226667e-02f, -3.42105478e-01f, 8.39902908e-02f, 3.35703611e-01f, -3.41619045e-01f,
  9.07300860e-02f, -2.66180962e-01f, 3.84626627e-01f, -2.24386871e-01f, 2.39145029e-02f, 2.74768136e-02f, 1.25118047e-01f, -6.84937984e-02f, -1.33275643e-01f, 7.24810213e-02f,
  -9.51482654e-02f, 1.18582480e-01f, 7.79533088e-02f, 6.71415925e-02f, 7.38797486e-02f, 1.14600532e-01f, 1.44199198e-02f, -1.11312471e-01f, 1.41454026e-01f, 1.22926915e-02f,
  -9.13055390e-02f, 3.27337720e-02f, -2.05352921e-02f, -9.89917815e-02f, 3.62720042e-01f, -1.65950470e-02f, -1.88149318e-01f, -6.51706308e-02f, 4.42469746e-01f, 1.78885332e-03f,
  -2.12990806e-01f, 4.63526011e-01f, 3.71293277e-02f, -1.23946145e-01f, -3.27269495e-01f, -5.88295124e-02f, -1.01763837e-01f, -1.62761882e-01f, 9.35138017e-02f, 1.77914258e-02f,
  -1.23808772e-04f, -1.04455411e-01f, -3.73827815e-02f, 5.32018729e-02f, -6.86640069e-02f, -1.47661150e-01f, -1.83641553e-01f, -4.32778895e-02f, -3.80014665e-02f, -2.09646195e-01f,
  3.39649315e-03f, -3.46917957e-01f, 5.13925701e-02f, 3.83877270e-02f, 2.57126778e-01f, -1.24362439e-01f, -2.15686053e-01f, 2.61727452e-01f, -3.69415656e-02f, -2.33962536e-02f,
  2.26838499e-01f, 1.21767633e-01f, 1.06446549e-01f, -6.57718927e-02f, -8.03833827e-02f, -3.16731423e-01f, 1.57921746e-01f, -3.46343696e-01f, 1.99668072e-02f, 5.66963591e-02f,
  -8.46509486e-02f, -1.44565493e-01f, 3.97758991e-01f, -7.46564865e-02f, 7.43928999e-02f, -9.80818197e-02f, 8.04288015e-02f, 3.71041335e-02f, 5.68591729e-02f, -5.11468053e-02f,
  -1.57146126e-01f, -8.63731652e-02f, -1.68461263e-01f, 2.71953225e-01f, -9.51987058e-02f, -2.48076558e-01f, -3.20942819e-01f, 1.56794593e-01f, 3.11217666e-01f, -2.83953607e-01f,
  -1.07572293e-02f, 8.15056339e-02f, 5.31431921e-02f, -1.84038922e-01f, 2.94307739e-01f, 1.52400076e-01f, 5.12774214e-02f, 1.47115543e-01f, 1.61894485e-02f, -1.56012207e-01f,
  -1.80548698e-01f, -2.26063177e-01f, -1.30403608e-01f, -1.29270211e-01f, 9.57974195e-02f, -3.00741971e-01f, 8.04133564e-02f, -2.20144242e-01f, -5.28480783e-02f, 3.92278060e-02f,
  3.83248478e-02f, -2.00905681e-01f, 3.48195195e-01f, 2.62415856e-01f, -7.24940524e-02f, -4.27954160e-02f, -1.81768779e-02f, 6.24038428e-02f, -7.54800858e-03f, -2.64972430e-02f,
  -3.10225517e-01f, 2.29041547e-01f, -1.71544254e-01f, 1.10246532e-01f, -2.01761067e-01f, 2.88461685e-01f, 2.78899699e-01f, -3.77146035e-01f, 1.93181649e-01f, -2.59478688e-01f,
  9.51607991e-03f, -2.27851823e-01f, 3.66506376e-03f, 3.28108557e-02f, -1.38399571e-01f, 1.89755544e-01f, 3.05844277e-01f, -1.37854367e-01f, 2.34053940e-01f, 1.62871834e-02f,
  2.74758488e-01f, 6.00442775e-02f, -6.48986222e-03f, 5.91606162e-02f, -2.32410431e-01f, -4.73303199e-02f, 4.40032743e-02f, -3.27041894e-01f, -6.11495934e-02f, -3.33291799e-01f,
  2.18654707e-01f, -9.57721993e-02f, -5.47025442e-01f, -1.05154477e-01f, 1.28253430e-01f, -1.19714951e-02f, -1.89181209e-01f, 9.58271921e-02f, 2.06042707e-01f, 7.96032622e-02f,
  3.01971495e-01f, 1.10182725e-01f, -1.80942584e-02f, -2.05327034e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -9.37621668e-02f, -1.14666402e-01f, -1.83890775e-01f, -1.14548393e-03f, 8.85380283e-02f, 2.72825301e-01f, -4.98330183e-02f, 4.08228070e-01f, 1.66006133e-01f, 9.87950899e-03f,
  -1.40956296e-02f, -5.93760982e-02f, 2.16959700e-01f, 1.52820840e-01f, 5.22297435e-03f, -2.96818521e-02f, -1.85217112e-01f, 4.39024568e-01f, -2.79173255e-01f, -2.57850468e-01f,
  -9.65832546e-02f, 5.10489106e-01f, -2.83233941e-01f, -1.03700615e-01f, -6.64201021e-01f, 2.81808108e-01f, -3.02279949e-01f, 4.16481912e-01f, -5.44788726e-02f, -1.80152357e-01f,
  -2.34423950e-01f, -6.35216106e-03f, -1.39636993e-01f, 1.83223456e-01f, 7.54885096e-03f, 1.41724199e-01f, 4.92667079e-01f, 1.92158371e-01f, 3.16823833e-02f, 2.12194413e-01f,
  3.59591618e-02f, 1.04787268e-01f, -3.12804133e-02f, 9.74878669e-03f, -3.44825070e-03f, -1.23481285e-02f, -2.31628507e-01f, -1.11961581e-01f, -3.95041138e-01f, -4.36011791e-01f,
  -5.56389010e-03f, 1.05668195e-01f, -2.69871116e-01f, -2.88570404e-01f, 3.75609219e-01f, 1.68534622e-01f, -1.96398631e-01f, 3.65832657e-01f, -1.72729835e-01f, 1.07657641e-01f,
  4.28897142e-01f, 4.09172654e-01f, 5.44220582e-02f, -4.84297425e-02f, 6.78986982e-02f, 2.29531214e-01f, 9.33130085e-02f, -5.13563156e-02f, 9.51565430e-02f, -1.84930384e-01f,
  -6.26409724e-02f, -9.20689553e-02f, 5.69915622e-02f, -3.60621549e-02f, 8.79496783e-02f, -6.44866377e-02f, -1.43111926e-02f, 2.56332397e-01f, -2.95628339e-01f, 1.18598200e-01f,
  -6.23068698e-02f, -1.28165185e-01f, -4.20780033e-01f, 1.14326514e-01f, 2.66197741e-01f, -7.73125514e-02f, 6.17873557e-02f, 2.80424744e-01f, 1.74359307e-01f, -2.54483074e-01f,
  3.26143384e-01f, -1.97309018e-05f, -4.70999517e-02f, 1.57248043e-02f, 2.22132772e-01f, -2.03965768e-01f, 8.70768726e-02f, -7.10987598e-02f, 1.25220314e-01f, 2.62030363e-01f,
  7.22621530e-02f, 6.34502154e-03f, 1.57687232e-01f, -8.35140124e-02f, 7.18953982e-02f, -1.78822860e-01f, 1.16408408e-01f, 7.66597316e-02f, -2.54308879e-01f, -4.43971336e-01f,
  1.02180235e-01f, -1.18578225e-01f, 2.86660403e-01f, 2.52922535e-01f, 1.54526485e-02f, -1.29739016e-01f, 2.13372000e-02f, 4.17247653e-01f, -8.71432573e-02f, -1.30268946e-01f,
  -3.93162370e-01f, -2.47720376e-01f, 2.10191533e-01f, 4.33546722e-01f, -3.61289829e-01f, -4.49472725e-01f, 2.78484046e-01f, -2.61064738e-01f, -1.21876173e-01f, 6.10299893e-02f,
  3.82426500e-01f, 1.66021753e-02f, -9.10338461e-02f, 7.43370363e-03f, -3.51812243e-02f, -6.64533153e-02f, -2.10832283e-01f, 5.40791340e-02f, 1.95122927e-01f, 1.13139652e-01f,
  -1.80946961e-02f, -3.93723547e-01f, -3.98138165e-02f, -4.56740826e-01f, 3.38885695e-01f, -1.86340407e-01f, 3.49361002e-01f, -8.86431262e-02f, -1.23979412e-01f, 1.88873425e-01f,
  4.13028635e-02f, -5.09954393e-02f, -1.20598882e-01f, -2.39307463e-01f, 3.31692934e-01f, -1.23026617e-01f, -1.67050004e-01f, -2.98602045e-01f, 2.73965627e-01f, -9.39476863e-02f,
  2.13234589e-01f, 4.45579812e-02f, -1.87717125e-01f, 3.37468386e-01f, 2.53937781e-01f, 1.86606675e-01f, 1.46956846e-01f, -1.45742953e-01f, -9.61842760e-02f, 1.42436191e-01f,
  2.04887807e-01f, 5.23005165e-02f, 1.16711922e-01f, -1.40707493e-01f, 2.37204045e-01f, 1.21952318e-01f, 3.81540954e-01f, -2.68914610e-01f, 9.47088450e-02f, -3.45983297e-01f,
  -6.12057090e-01f, 1.98541701e-01f, -2.47954316e-02f, -7.07693473e-02f, 1.25529513e-01f, 2.79377878e-01f, -1.85255222e-02f, 2.41689142e-02f, 8.96507800e-02f, 1.41408071e-01f,
  5.88944852e-01f, -4.84694898e-01f, -6.71900734e-02f, 1.62925705e-01f, 1.32765755e-01f, 3.79443541e-02f, -1.99494019e-01f, 2.37333909e-01f, 1.26965836e-01f, -1.98494121e-02f,
  -3.11870962e-01f, 2.54787281e-02f, 5.32156639e-02f, 2.66865253e-01f, 7.64646456e-02f, 8.96718632e-03f, 5.36236875e-02f, 4.55559045e-01f, -8.96218698e-03f, 1.13912225e-01f,
  -4.35605705e-01f, 7.00699165e-02f, 3.63160014e-01f, -1.68320194e-01f, 6.78754523e-02f, 3.28034163e-02f, 9.43028852e-02f, -1.02983497e-01f, -3.94691914e-01f, 3.65001231e-01f,
  2.56818920e-01f, 3.23939055e-01f, 4.66094106e-01f, 3.61829996e-01f, -9.28103253e-02f, -3.98782156e-02f, -8.93033296e-02f, 5.24804629e-02f, -5.58083095e-02f, 2.70968437e-01f,
  1.43436283e-01f, 4.71357256e-02f, 1.93441167e-01f, 1.06806755e-01f, 1.25947848e-01f, 2.61307716e-01f, 1.98483348e-01f, 5.54560423e-02f, 6.19491935e-02f, -1.55338943e-01f,
  1.10724173e-01f, -1.72291309e-01f, 1.78004444e-01f, -1.33130103e-01f, -3.42483759e-01f, 3.23454943e-03f, 1.28401279e-01f, -2.12106004e-01f, 2.04644665e-01f, 6.38881683e-01f,
  8.40472803e-02f, 9.77732316e-02f, 5.38198590e-01f, 1.40807509e-01f, -4.13487822e-01f, 1.52825177e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.46984497e-01f, -1.77924365e-01f, 1.70915589e-01f, 2.69157201e-01f, 1.71808019e-01f, -1.53581545e-01f, -1.90801099e-02f, 6.65562302e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.82068610e-01f, 2.09993541e-01f, 1.67018220e-01f, -1.93381503e-01f, -9.53160524e-02f, 2.50557691e-01f, 1.57011509e-01f, 2.78779805e-01f, -3.40779483e-01f, 1.67027548e-01f,
  2.42920280e-01f, -1.22401342e-01f, -3.10703099e-01f, 5.74798703e-01f, 4.10481602e-01f, -2.01814801e-01f, -3.10000102e-03f, -2.22310960e-01f, 4.88911308e-02f, -2.46707782e-01f,
  -2.06758678e-02f, 2.19710156e-01f, -1.85221553e-01f, -1.61189467e-01f, -3.78055722e-01f, 1.54030994e-02f, -1.14932209e-02f, 1.67235509e-02f, 2.03008533e-01f, 1.59326792e-01f,
  -9.85526741e-02f, -2.60012031e-01f, 1.61461577e-01f, 2.86212415e-01f, 1.69205457e-01f, 1.12418815e-01f, -1.77706316e-01f, 8.23696628e-02f, -8.05099830e-02f, -7.63570592e-02f,
  1.33068785e-01f, -7.50685707e-02f, -1.16315514e-01f, -2.51678936e-02f, -3.23332101e-01f, -1.32910460e-01f, -1.27213910e-01f, 2.99414933e-01f, -1.72978476e-01f, -5.51393889e-02f,
  2.10102916e-01f, -2.09285274e-01f, 1.54636681e-01f, -3.38519067e-01f, 2.56600708e-01f, 4.00401473e-01f, -2.01624677e-01f, -2.88740778e-03f, 5.58590516e-02f, 3.79725754e-01f,
  2.50323057e-01f, 6.36645034e-02f, -3.93950850e-01f, 3.39953035e-01f, -1.67734817e-01f, 5.27529418e-01f, 1.51344344e-01f, 2.08295703e-01f, -1.01984449e-01f, 9.90917534e-02f,
  -2.17131409e-03f, 4.30552483e-01f, 1.86883077e-01f, 1.45423129e-01f, -3.66166443e-01f, -6.02408946e-02f, -2.61588185e-03f, 3.05213660e-01f, -2.37928182e-01f, 3.55205357e-01f,
  4.07344878e-01f, -1.59854107e-02f, 2.82246411e-01f, -1.88204542e-01f, -1.79185290e-02f, -2.98507869e-01f, 2.32763350e-01f, 5.76314867e-01f, 2.40940809e-01f, 5.50093614e-02f,
  1.22238593e-02f, 3.19675803e-01f, 4.47033904e-02f, -3.86520803e-01f, -1.13124534e-01f, -2.00755253e-01f, 1.38476461e-01f, 7.14811608e-02f, 1.59883313e-02f, -2.12199077e-01f,
  8.07961896e-02f, 4.60530609e-01f, 2.33837590e-01f, -1.53741166e-01f, -4.03026715e-02f, 1.10854819e-01f, 7.71997422e-02f, 2.09265113e-01f, 2.22905383e-01f, 1.88005775e-01f,
  3.50527555e-01f, -2.40090072e-01f, 2.51511663e-01f, -3.62345606e-01f, -5.62252887e-02f, 4.40351851e-02f, 6.14220023e-01f, -3.17848086e-01f, -1.65192962e-01f, 9.79329571e-02f,
  2.83513349e-02f, -1.36847362e-01f, -3.06218654e-01f, 1.05097197e-01f, 1.23904981e-01f, -1.75125584e-01f, 6.77478611e-02f, 4.48021889e-02f, -9.98139083e-02f, 2.43007001e-02f,
  3.42261016e-01f, -6.18889704e-02f, 1.42307311e-01f, 2.59075612e-01f, -1.60937011e-01f, -2.69633263e-01f, 1.92296922e-01f, 2.44746506e-01f, -2.17051990e-02f, 2.60545492e-01f,
  1.42600656e-01f, 4.90132719e-02f, -4.53787437e-03f, -1.76554576e-01f, 4.97833252e-01f, -6.69299811e-03f, -4.64532897e-03f, 1.78997979e-01f, 4.84664112e-01f, -2.36388847e-01f,
  1.00626245e-01f, -1.07213147e-01f, 4.00623903e-02f, -2.90654272e-01f, 1.13390684e-01f, -1.08596154e-01f, 2.69545972e-01f, -7.23066106e-02f, 1.68147404e-02f, 2.90891230e-02f,
  -8.18873644e-02f, -4.21855420e-01f, -3.67497087e-01f, -8.28420445e-02f, 4.20136042e-02f, -1.32385984e-01f, 1.35498196e-01f, 8.35488364e-02f, -6.54182315e-01f, -2.31129274e-01f,
  1.34456113e-01f, -6.53959140e-02f, 2.70787746e-01f, 8.98048282e-02f, 2.50517696e-01f, -2.69267648e-01f, -9.41587314e-02f, -3.70178789e-01f, -2.66531371e-02f, -1.68914780e-01f,
  1.07240051e-01f, 6.68076575e-02f, -4.01407443e-02f, -3.83700371e-01f, -4.88902748e-01f, -1.60774991e-01f, 2.24502400e-01f, -1.61045432e-01f, 2.80928016e-01f, 1.91123128e-01f,
  8.83020312e-02f, -1.03593946e-01f, 1.15945347e-01f, 2.96710163e-01f, 2.49812216e-01f, -6.90090982e-03f, 3.31085436e-02f, -1.64321646e-01f, 1.81306023e-02f, -3.97995263e-01f,
  2.87487894e-01f, -1.39879808e-02f, -2.54660975e-02f, 1.72207415e-01f, 1.57821864e-01f, -3.30258235e-02f, 3.01586628e-01f, 5.13535216e-02f, 2.10028365e-01f, -3.34047258e-01f,
  -2.86426917e-02f, 4.69361186e-01f, 3.90455946e-02f, 5.81288077e-02f, -1.06775135e-01f, 1.15224235e-01f, 1.07680693e-01f, -2.02678367e-01f, 2.73312688e-01f, -4.71272245e-02f,
  3.13312322e-01f, -4.01199162e-01f, -1.70229927e-01f, -7.28908852e-02f, -2.80828327e-01f, 8.19780156e-02f, -7.09100515e-02f, 2.73901999e-01f, -3.15699130e-02f, 7.37024099e-02f,
  -4.86311987e-02f, 9.39304456e-02f, 3.36601704e-01f, 2.17183441e-01f, -4.93204892e-02f, -1.78259000e-01f, -3.80674489e-02f, -3.34351175e-02f, -1.97212338e-01f, 1.38049543e-01f,
  -2.04759941e-01f, 3.38737398e-01f, -2.18393013e-01f, 1.64917424e-01f, -1.02750607e-01f, 2.12796360e-01f, -9.07003731e-02f, 5.06454222e-02f, 5.15340686e-01f, 2.44627804e-01f,
  -2.76950628e-01f, -1.56620935e-01f, -4.01857495e-01f, 1.17133327e-01f, 1.17452428e-01f, -7.12397546e-02f, -1.10533889e-02f, -1.14332519e-01f, -7.62926787e-02f, 7.68154114e-02f,
  -1.48945935e-02f, 1.91838592e-01f, 1.94933742e-01f, -8.13332871e-02f, -3.18814278e-01f, 2.91130245e-01f, 1.45928795e-02f, 1.10878453e-01f, 8.78468826e-02f, 2.36031741e-01f,
  2.78113425e-01f, -1.14542969e-01f, 1.76213756e-01f, -2.68725455e-01f, -6.89479411e-02f, -4.20750409e-01f, 4.10439491e-01f, 8.60036984e-02f, -1.31889299e-01f, -1.30145267e-01f,
  -2.13737130e-01f, -1.59958616e-01f, -6.15029968e-02f, 2.67393827e-01f, 2.94352561e-01f, -1.64709225e-01f, 1.85870498e-01f, -9.53581035e-02f, -2.04549804e-01f, 2.86628399e-03f,
  -1.95423901e-01f, 2.73417979e-01f, -1.23458058e-01f, -3.25265080e-02f, -2.20711201e-01f, -3.51843804e-01f, 1.89140737e-01f, 2.12318420e-01f, 1.07895166e-01f, 9.16239396e-02f,
  -8.94189924e-02f, -5.57855070e-01f, -3.14380452e-02f, -1.30690882e-04f, -4.80637791e-05f, 2.92271018e-01f, -6.87235594e-01f, 3.73631358e-01f, 9.14544612e-02f, -6.80986270e-02f,
  -2.36496329e-01f, -8.33342001e-02f, -2.29340598e-01f, 1.17382556e-02f, -2.20444456e-01f, -2.10655674e-01f, -8.59887227e-02f, -1.22008435e-01f, -1.61892176e-01f, 2.56284088e-01f,
  4.24969336e-03f, -1.49133772e-01f, -2.48618096e-01f, -1.18124023e-01f, 1.46105979e-03f, -1.36745228e-02f, -2.38139391e-01f, -1.13610737e-01f, 2.59685665e-01f, 2.90882885e-01f,
  2.25507375e-03f, -2.32059941e-01f, 1.48719802e-01f, -2.65911967e-01f, -3.89398754e-01f, 1.27845392e-01f, 1.85799021e-02f, 1.82114646e-01f, 2.13118806e-01f, -1.80910677e-01f,
  -1.41019464e-01f, -3.68581682e-01f, 4.42010701e-01f, 2.05237255e-01f, 2.61335999e-01f, -1.01428248e-01f, 1.02592766e-01f, -1.57664537e-01f, -1.51012182e-01f, 2.99291313e-01f,
  -5.24616800e-03f, 2.40993813e-01f, -8.90855491e-02f, -1.96672440e-01f, -1.28890455e-01f, 1.80957079e-01f, 4.64207865e-02f, 1.99425481e-02f, -1.22476675e-01f, -1.32828727e-01f,
  -3.15181583e-01f, 1.71799079e-01f, -1.08519375e-01f, 2.02915817e-01f, 2.44042277e-01f, 1.06300600e-01f, 2.79144108e-01f, -4.79627959e-02f, 2.27583110e-01f, 1.44790813e-01f,
  -2.95057803e-01f, 1.80117309e-01f, 4.77041721e-01f, 4.92542125e-02f, -2.63849884e-01f, 1.71601832e-01f, -1.37264607e-02f, -2.35501766e-01f, 2.66315907e-01f, 2.67564744e-01f,
  1.14397846e-01f, -2.03071669e-01f, 9.32367295e-02f, -1.67995668e-03f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.58029437e-01f, -3.74561667e-01f, -2.77180150e-02f, -1.28563240e-01f, 3.48841369e-01f, -1.40020445e-01f, 5.84392212e-02f, 1.92651615e-01f, -3.73784333e-01f, 8.97244066e-02f,
  1.59775645e-01f, -3.32323052e-02f, 5.36422193e-01f, 3.54298651e-01f, 6.15814805e-01f, -4.21587646e-01f, -2.70022988e-01f, -1.22048073e-01f, -1.36334905e-02f, 2.28353113e-01f,
  8.62557665e-02f, 4.04021114e-01f, -1.96122259e-01f, -5.56469977e-01f, -5.75039685e-01f, -2.65659243e-01f, 2.40187958e-01f, -7.56733119e-02f, 1.49944022e-01f, 3.17998856e-01f,
  3.87853533e-01f, -2.45923996e-01f, -8.11613724e-02f, -2.45845631e-01f, -2.60887146e-01f, 4.61487561e-01f, 6.80971444e-02f, -1.90449849e-01f, 1.18471554e-03f, 1.19190797e-01f,
  1.96883410e-01f, 7.64568150e-02f, 2.64943708e-02f, 4.65164721e-01f, 6.02569640e-01f, -5.25786638e-01f, 1.84053704e-01f, -1.78480983e-01f, -3.51661265e-01f, -1.50010973e-01f,
  -5.44597328e-01f, 2.87054241e-01f, -1.71178149e-03f, 3.67319226e-01f, -6.01240218e-01f, 1.66832842e-02f, 8.26941878e-02f, 3.85502070e-01f, -2.69236743e-01f, 2.43438497e-01f,
  1.72981873e-01f, 4.13752437e-01f, 5.08139610e-01f, 2.26680085e-01f, -3.42252493e-01f, 4.51447405e-02f, 2.68447578e-01f, 1.44315571e-01f, 2.29138568e-01f, -5.15194088e-02f,
  1.17570490e-01f, 2.86080718e-01f, 8.51287022e-02f, -2.59946547e-02f, 2.30131984e-01f, 2.89788365e-01f, -4.48394001e-01f, -4.44511920e-01f, -2.57871866e-01f, 7.89228305e-02f,
  -5.25828414e-02f, -4.30709831e-02f, 7.94610918e-01f, -5.96343219e-01f, 4.76216376e-01f, -5.54907739e-01f, 3.64785269e-02f, 2.68962055e-01f, -7.90532231e-02f, -2.17299104e-01f,
  -1.92037225e-01f, 5.25634587e-01f, 5.35890341e-01f, 2.28322536e-01f, -9.48831066e-02f, -3.61721247e-01f, -1.37769848e-01f, 1.46181569e-01f, -2.56135911e-01f, 1.86032414e-01f,
  -1.79236159e-01f, 2.01054215e-01f, 2.42191836e-01f, 2.55355746e-01f, 1.05723523e-01f, 4.12752688e-01f, -1.91653073e-01f, -2.07582384e-01f, 1.83785334e-01f, 3.78212333e-01f,
  -6.31640673e-01f, 1.63081810e-01f, 1.25302255e-01f, 6.24241084e-02f, -1.31052747e-01f, -1.37754222e-02f, -6.94380462e-01f, -1.31643832e-01f, 1.78454697e-01f, 2.65545279e-01f,
  5.95789015e-01f, 7.69407526e-02f, -1.33885726e-01f, 2.13449091e-01f, -3.38072419e-01f, -5.10822795e-02f, -9.68676880e-02f, 2.71640062e-01f, 2.27733225e-01f, 5.04113257e-01f,
  1.26643643e-01f, 2.79832691e-01f, 6.09204313e-03f, 3.80255520e-01f, 1.24673024e-01f, 4.37909514e-01f, 2.33788174e-02f, 5.18729150e-01f, 5.97975701e-02f, 1.67269096e-01f,
  -1.06254779e-01f, 4.40042108e-01f, 2.69919008e-01f, 2.15167075e-01f, 3.60056877e-01f, 2.13166669e-01f, -2.75672227e-02f, -9.72941741e-02f, 5.12837410e-01f, -4.26126957e-01f,
  -4.42403346e-01f, 4.16373640e-01f, 5.22179186e-01f, 2.12591477e-02f, -1.95341587e-01f, 4.59941208e-01f, 3.39340150e-01f, -3.18291545e-01f, -5.52360602e-02f, -6.29790127e-02f,
  -2.50348952e-02f, -1.45518839e-01f, 6.56339675e-02f, -1.38524324e-01f, -3.35396570e-03f, 1.33608043e-01f, 1.94068044e-01f, 2.40579203e-01f, -3.77601266e-01f, 4.40079570e-01f,
  2.83734590e-01f, 2.37338230e-01f, 4.18164313e-01f, 1.96554467e-01f, 2.64205515e-01f, -5.89934587e-01f, 5.76827452e-02f, -1.01926580e-01f, 5.52094243e-02f, -4.25955057e-01f,
  3.17117006e-01f, -4.09916997e-01f, -2.96941638e-01f, -2.97841430e-01f, -2.57124126e-01f, -1.00905843e-01f, 1.67737305e-01f, 2.43010953e-01f, 3.19239706e-01f, 3.69852960e-01f,
  -5.22736646e-03f, 1.74424008e-01f, 1.80811793e-01f, 4.00401046e-03f, -4.56070267e-02f, 1.17758997e-01f, -5.49666584e-01f, -9.24274791e-03f, 2.52875835e-01f, 3.15457255e-01f,
  -4.56552148e-01f, 4.41534907e-01f, -5.51850582e-03f, -2.78422106e-02f, 5.10422438e-02f, 2.75609910e-01f, 3.47972244e-01f, 1.12606101e-01f, -5.18119335e-01f, -5.51044226e-01f,
  -3.35587502e-01f, -7.55803660e-02f, -1.86386093e-01f, 4.35200721e-01f, -6.38060495e-02f, 3.09622914e-01f, -1.17319383e-01f, 4.36935484e-01f, -1.03387251e-01f, -6.79562032e-01f,
  -3.70471239e-01f, -9.29508582e-02f, 4.49188381e-01f, 3.87900382e-01f, 8.31170455e-02f, 4.34931993e-01f, 5.30101120e-01f, -1.74063727e-01f, -2.08945855e-01f, 4.22404557e-01f,
  -5.13134003e-02f, 5.65852225e-01f, 1.92631915e-01f, -1.13957837e-01f, 1.82714254e-01f, -4.37063247e-01f, -3.23400319e-01f, 1.51920512e-01f, -3.33389491e-01f, 1.96899265e-01f,
  -2.25607917e-01f, -2.32100278e-01f, 3.33527237e-01f, -3.80892724e-01f, -5.32568574e-01f, -1.96353585e-01f, 3.88492674e-01f, 4.07234550e-01f, -3.55419964e-02f, 2.42689192e-01f,
  4.85943258e-02f, 6.64363578e-02f, -1.50400981e-01f, 1.25695050e-01f, -2.98987150e-01f, 3.05361390e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -6.15424700e-02f, 2.91112959e-01f, 9.54316929e-02f, 5.37172407e-02f, 4.72873330e-01f, 1.74180493e-01f, 1.74618751e-01f, 2.84275800e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.95596352e-01f, -6.12430461e-02f, 1.01644315e-01f, -1.30953491e-01f, 2.42089286e-01f, -1.07391149e-01f, 1.21182747e-01f, 1.06627412e-01f, 6.93991035e-02f, 2.80145500e-02f,
  -8.85724369e-03f, 2.91062389e-02f, 4.36250716e-01f, 5.54155827e-01f, -1.22581251e-01f, -1.29798368e-01f, 1.27992183e-01f, 1.97547406e-01f, -1.08379051e-01f, -1.56710878e-01f,
  6.04841188e-02f, -5.33432722e-01f, -3.71423028e-02f, -7.09652249e-03f, 7.03173503e-02f, -3.07851881e-01f, 2.91744143e-01f, -2.24282041e-01f, -5.01669571e-02f, 3.56225818e-01f,
  -1.79833725e-01f, 6.98459670e-02f, -1.81441665e-01f, 1.94571778e-01f, -3.34202847e-03f, 5.72252035e-01f, 2.56658226e-01f, -7.11841881e-02f, 2.43774354e-01f, -6.31489679e-02f,
  4.19770479e-01f, 5.79177663e-02f, 3.99357677e-01f, 2.17731461e-01f, -8.86184126e-02f, -3.42180133e-01f, -5.99472001e-02f, -2.15573624e-01f, 4.13670428e-02f, -1.65933490e-01f,
  -1.63020849e-01f, 1.70707732e-01f, 1.02926835e-01f, 3.20336640e-01f, 2.91467458e-01f, -2.98166592e-02f, -1.97329789e-01f, 1.62221685e-01f, -4.09080744e-01f, 6.63252026e-02f,
  -1.25276828e-02f, -2.58431703e-01f, 2.25695848e-01f, -2.86168724e-01f, -3.28565627e-01f, -2.86135823e-01f, -1.00811079e-01f, 3.85377437e-01f, 1.26020372e-01f, -4.52931076e-01f,
  -1.50796518e-01f, -2.25324910e-02f, -1.88027173e-02f, 2.19538391e-01f, 7.03691021e-02f, -3.57759118e-01f, -4.80277866e-01f, -3.87670100e-01f, 3.49281281e-01f, -3.78015637e-02f,
  -2.23808363e-03f, -1.08528070e-01f, 1.22404464e-01f, 3.65484148e-01f, -1.11833304e-01f, 1.65382013e-01f, 6.31890148e-02f, -2.57006824e-01f, 5.44611625e-02f, -9.64542702e-02f,
  -1.14552483e-01f, 3.19503099e-01f, -2.64925119e-02f, -2.64678765e-02f, 1.25667065e-01f, -1.86024643e-02f, -9.64890197e-02f, -5.90543672e-02f, 2.19849765e-01f, -6.44791871e-03f,
  -2.38603339e-01f, -1.75630555e-01f, -1.82262644e-01f, -2.03830346e-01f, -8.54248181e-02f, 2.16242954e-01f, -2.39760011e-01f, -1.78017378e-01f, -1.24161251e-01f, -7.97723681e-02f,
  -1.50655076e-01f, -6.31599352e-02f, -2.17493102e-01f, -2.54846454e-01f, -5.43264687e-01f, 2.67332476e-02f, -1.26765072e-01f, 9.29566026e-02f, 1.05247222e-01f, -3.29132915e-01f,
  2.48781443e-02f, -8.44166949e-02f, -2.18920365e-01f, 3.42142880e-01f, -1.51387796e-01f, -8.47047269e-02f, 2.44553640e-01f, 9.64845866e-02f, -1.76227778e-01f, -1.72866464e-01f,
  2.33350784e-01f, 6.12594128e-01f, 2.64122486e-01f, -9.19469297e-02f, 2.01583147e-01f, -1.44208267e-01f, -4.23066095e-02f, 2.29296654e-01f, -1.43145338e-01f, -1.76552817e-01f,
  2.18302503e-01f, -2.02571213e-01f, 8.41651186e-02f, -1.35154843e-01f, -3.39624733e-01f, -2.51956165e-01f, -4.74253088e-01f, 4.30916429e-01f, 3.58342856e-01f, 1.78881675e-01f,
  3.61370474e-01f, -2.92261630e-01f, 1.51999876e-01f, -1.12699397e-01f, -1.93970591e-01f, 1.33814648e-01f, 1.48506269e-01f, 3.32986191e-02f, 2.74538785e-01f, -5.07373028e-02f,
  -6.22971058e-02f, -2.00252254e-02f, 2.27146327e-01f, 2.82249808e-01f, 1.05347067e-01f, 2.78661489e-01f, 2.96362698e-01f, 7.36706555e-02f, 3.25650394e-01f, 1.02424873e-02f,
  1.94432646e-01f, 1.39839770e-02f, 5.64454854e-01f, 1.01997249e-01f, 4.71463799e-01f, 1.15153283e-01f, 1.68062285e-01f, -4.56215143e-02f, -1.57461464e-01f, -3.31931204e-01f,
  1.41089454e-01f, 4.70614650e-05f, 1.51567578e-01f, 7.31849298e-02f, -2.49494508e-01f, -2.72296607e-01f, 2.14378864e-01f, -1.84776515e-01f, 2.36367702e-01f, 4.22149822e-02f,
  2.97181010e-02f, 2.00816944e-01f, -1.72023535e-01f, 5.90111129e-02f, -7.45013207e-02f, -2.34154925e-01f, -3.85811061e-01f, 3.66615772e-01f, -7.00494573e-02f, 9.13053155e-02f,
  3.16867940e-02f, -1.58231497e-01f, 1.90566167e-01f, 3.49706560e-02f, -2.41773069e-01f, 8.03600624e-02f, -3.58523250e-01f, 8.62755477e-02f, -2.00800017e-01f, 2.41987765e-01f,
  -7.00919554e-02f, -8.93354863e-02f, -2.32072592e-01f, 2.70264417e-01f, -5.28805405e-02f, -3.33965749e-01f, -1.52321771e-01f, 1.60770565e-01f, 3.11168164e-01f, 1.57825425e-01f,
  -3.02188814e-01f, 8.14236514e-03f, 2.49706507e-01f, 2.12165236e-01f, 2.24835560e-01f, 1.14383876e-01f, 4.64232266e-02f, 2.00583726e-01f, 1.65613994e-01f, -1.36821568e-01f,
  1.21944593e-02f, 2.12584749e-01f, 2.92596426e-02f, 1.02432750e-01f, 3.88541907e-01f, -3.39140110e-02f, 5.21327794e-01f, 6.26183599e-02f, 4.57072020e-01f, 4.92209107e-01f,
  -7.35170022e-03f, -2.30533898e-01f, 9.00946632e-02f, 2.44814143e-01f, 6.57614946e-01f, -3.08496118e-01f, -3.27788711e-01f, 2.52162188e-01f, 1.42305672e-01f, -1.17001057e-01f,
  -1.12982027e-01f, 1.95783433e-02f, 1.99502930e-01f, -2.83938587e-01f, -1.41210064e-01f, -2.80338824e-01f, -3.06657165e-01f, -3.42978120e-01f, 2.38110963e-02f, 1.39667064e-01f,
  4.29112315e-01f, -3.82209599e-01f, -8.47770050e-02f, -5.80928147e-01f, 9.38215330e-02f, -2.69099772e-01f, -1.87719792e-01f, 1.86885685e-01f, -2.11903974e-01f, -2.81318069e-01f,
  -3.37082446e-01f, 1.36285042e-02f, -1.85879722e-01f, 2.07411963e-02f, -1.75113335e-01f, 4.00900096e-02f, -2.58231997e-01f, -3.88288021e-01f, 1.51915863e-01f, 2.76051853e-02f,
  1.41228491e-03f, 2.91360945e-01f, 1.45416856e-01f, 8.48460943e-02f, -1.50145739e-01f, -3.43514830e-02f, -7.79205635e-02f, -3.24327171e-01f, 1.20548874e-01f, 3.70335519e-01f,
  2.76320249e-01f, -3.39675337e-01f, -3.79401624e-01f, 2.63824791e-01f, -3.10665905e-01f, -1.63320437e-01f, 7.64685756e-05f, -3.27069819e-01f, 1.62323281e-01f, 1.06491439e-01f,
  -3.70902061e-01f, 9.21238810e-02f, -3.50461483e-01f, -3.29835653e-01f, -1.54089361e-01f, -1.56996474e-01f, -1.26047254e-01f, 1.63042899e-02f, -3.48990411e-01f, 4.51051146e-01f,
  4.36098754e-01f, -2.57457882e-01f, -4.04289588e-02f, -4.56459187e-02f, -1.59146935e-01f, 1.15066200e-01f, -1.77765206e-01f, 2.73518026e-01f, -6.97780922e-02f, 4.12776589e-01f,
  -4.81230795e-01f, 2.73750663e-01f, 1.04589872e-01f, 2.41376355e-01f, 1.88948512e-01f, 1.05759479e-01f, 6.46360219e-02f, -1.30949482e-01f, 2.24660471e-01f, -1.32408097e-01f,
  -1.14216909e-01f, -1.71779498e-01f, 3.77121359e-01f, 3.77068341e-01f, 1.49498343e-01f, 2.12928988e-02f, -2.50838578e-01f, -6.39440119e-01f, -5.51201284e-01f, 3.93439710e-01f,
  -2.66546875e-01f, 2.20641683e-04f, 1.43440496e-02f, -2.95427442e-01f, -4.55198526e-01f, 7.66073877e-04f, 7.39974082e-02f, -2.87368834e-01f, 2.97591295e-02f, -3.38558376e-01f,
  2.52458572e-01f, -1.71391770e-01f, -1.25460029e-01f, -7.23102316e-02f, 2.03476131e-01f, -1.81107625e-01f, -2.80461516e-02f, -9.39273760e-02f, -4.05653985e-03f, -2.92049557e-01f,
  -1.38539150e-01f, 3.31975929e-02f, -1.47489443e-01f, -3.24474752e-01f, -1.41763911e-01f, -3.38978112e-01f, -5.30873895e-01f, -1.27501205e-01f, -2.59601206e-01f, 5.19516170e-02f,
  3.49205770e-02f, -1.40607497e-02f, -8.32965672e-02f, -4.39984240e-02f, -5.81611246e-02f, -2.59038031e-01f, 1.14527576e-01f, 2.14540228e-01f, -1.65373653e-01f, 1.93764389e-01f,
  -1.68746263e-01f, 2.41563335e-01f, 2.89261371e-01f, -8.66446942e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -3.04264307e-01f, 8.20942447e-02f, -7.09898770e-02f, 1.99507579e-01f, 2.69603610e-01f, 3.09598297e-02f, -1.76634774e-01f, -2.48643532e-01f, 1.95610747e-01f, 2.62552917e-01f,
  1.29805833e-01f, 3.03785533e-01f, -7.75023460e-01f, -4.17472988e-01f, -3.10991168e-01f, -3.72075021e-01f, -4.39382762e-01f, -8.33030418e-02f, -9.91467983e-02f, 2.10053086e-01f,
  -3.60397428e-01f, 5.20459235e-01f, 8.52643028e-02f, 2.32442200e-01f, 8.18679761e-03f, 7.69712567e-01f, -7.13274062e-01f, 6.27039790e-01f, -2.04696313e-01f, 6.77115694e-02f,
  5.73479831e-01f, 2.00780720e-01f, 1.43870637e-01f, 2.71559119e-01f, -3.11636981e-02f, -1.83965266e-01f, 1.18339814e-01f, 6.31332994e-01f, -1.98240438e-03f, 5.94645500e-01f,
  4.60677505e-01f, 1.00933217e-01f, 6.03582084e-01f, 4.94229496e-01f, 3.45836729e-01f, -2.80246645e-01f, -6.58222497e-01f, 7.73922727e-02f, -2.35210672e-01f, 1.39110178e-01f,
  3.54242712e-01f, 1.51957780e-01f, 4.18517381e-01f, 5.44647574e-01f, -8.51372361e-01f, 4.37344104e-01f, 3.50083113e-01f, 5.31231165e-01f, -3.93498570e-01f, -2.55303085e-02f,
  1.21540539e-01f, 3.86115551e-01f, 3.58621240e-01f, -1.44224912e-01f, 4.17609453e-01f, 1.34735823e-01f, 3.17951068e-02f, 3.38215888e-01f, 1.08143594e-02f, -2.85563797e-01f,
  3.77594709e-01f, -2.95932233e-01f, 2.90535569e-01f, 8.06169331e-01f, 1.84514984e-01f, 1.04947865e-01f, 2.61554807e-01f, 1.38654932e-01f, 4.75246072e-01f, 6.00156307e-01f,
  5.52997947e-01f, -3.41267943e-01f, 4.98158455e-01f, 2.67368585e-01f, 6.36117816e-01f, -8.79037976e-02f, -4.23244148e-01f, 6.30045712e-01f, -3.28915983e-01f, -4.76933718e-02f,
  1.19875789e-01f, 5.34258902e-01f, 1.05690217e+00f, 4.27359939e-01f, 5.12774996e-02f, -7.14267464e-03f, -4.49742079e-02f, -6.72019839e-01f, -2.61617929e-01f, 7.74869561e-01f,
  5.51869869e-01f, -5.66890717e-01f, 6.11610115e-01f, 1.54931933e-01f, 2.39734381e-01f, 1.80100538e-02f, -1.89006746e-01f, 2.94824392e-02f, 9.14011061e-01f, -9.95903462e-02f,
  3.21469933e-01f, 1.83034360e-01f, 3.83057110e-02f, 6.18217848e-02f, -4.78840619e-01f, -6.06838576e-02f, 6.39990985e-01f, -7.88928747e-01f, -1.07359812e-01f, 6.99269772e-02f,
  6.18343234e-01f, -1.39657304e-01f, 7.62910128e-01f, -1.51277287e-02f, 1.64535999e-01f, 4.30922806e-01f, 4.59248930e-01f, 3.39423895e-01f, 2.06012964e-01f, -2.45564967e-01f,
  2.74322540e-01f, 2.09691122e-01f, -2.77014613e-01f, 7.29408741e-01f, 3.29808921e-01f, 5.96221447e-01f, 3.66156340e-01f, -5.46820998e-01f, 7.36967325e-01f, -2.96721667e-01f,
  9.42892015e-01f, 5.71017563e-01f, 4.33131307e-01f, -6.92776024e-01f, -2.88985193e-01f, -4.54684235e-02f, -1.72291756e-01f, -3.88430089e-01f, -4.21840362e-02f, -7.75984824e-01f,
  -3.21208924e-01f, -4.50813532e-01f, -2.00185239e-01f, -3.25509161e-01f, -3.03191900e-01f, -1.03234261e-01f, -4.31123763e-01f, -2.58559018e-01f, 2.72462666e-01f, 4.42303121e-01f,
  3.39057326e-01f, 2.02755392e-01f, 2.00661451e-01f, 5.59997439e-01f, 3.13730419e-01f, 3.57744806e-02f, 6.11618578e-01f, 6.93632185e-01f, -8.48482549e-03f, 5.76275103e-02f,
  1.95944924e-02f, 2.62588039e-02f, -1.73855335e-01f, 5.41330278e-01f, 2.77736485e-01f, -1.68568954e-01f, -4.67217952e-01f, -2.91972697e-01f, 1.06597617e-02f, 5.43611646e-01f,
  -5.84315419e-01f, -5.91398366e-02f, 3.63226712e-01f, -6.98831201e-01f, 1.56799704e-01f, -3.05232584e-01f, -5.12230285e-02f, 1.89287350e-01f, -1.49011305e-02f, -5.45471370e-01f,
  1.90860793e-01f, 6.19122803e-01f, 1.70666978e-01f, 3.05826843e-01f, 5.10485828e-01f, -6.42477810e-01f, -3.54738683e-02f, 3.60907137e-01f, 1.46514714e-01f, 4.53132987e-01f,
  -4.24619704e-01f, -2.91921049e-01f, 3.03893175e-04f, 1.39531717e-01f, 7.32205927e-01f, 4.58911628e-01f, -2.72867620e-01f, -4.38127480e-02f, 1.42524406e-01f, 2.85236835e-01f,
  1.16530180e-01f, -5.03460526e-01f, 2.57905811e-01f, -1.83539033e-01f, -3.67640287e-01f, -1.43320970e-02f, 2.94475853e-01f, 4.34532553e-01f, 6.45269930e-01f, -6.58941448e-01f,
  3.42648476e-01f, 4.07418817e-01f, -4.52080034e-02f, -4.09869939e-01f, -1.27584606e-01f, 1.97576359e-01f, 3.76539946e-01f, 9.92929041e-02f, -3.76721710e-01f, -1.03945956e-01f,
  3.18725593e-02f, -4.73710626e-01f, -5.26010454e-01f, 3.06069925e-02f, 4.73295785e-02f, 1.20531790e-01f, 1.12443306e-01f, 7.35029042e-01f, -6.35499542e-04f, -2.53752526e-02f,
  -5.22571623e-01f, -2.38873199e-01f, -8.37766945e-01f, 5.56487851e-02f, -1.69256806e-01f, -1.94323897e-01f, 8.85846138e-01f, -8.20588052e-01f, -2.26620495e-01f, 2.72338748e-01f,
  7.81301081e-01f, 3.87881070e-01f, 2.28300318e-01f, 2.98697323e-01f, 3.44399065e-01f, 6.78254783e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  3.89109462e-01f, 4.19879168e-01f, 2.89989829e-01f, 2.58632097e-02f, 5.32503054e-03f, 2.61208653e-01f, 8.54253024e-02f, -9.94029548e-03f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.12609260e-01f, 4.97548766e-02f, -1.90531403e-01f, -6.70878649e-01f, -4.20262337e-01f, 3.30969870e-01f, -6.37743771e-01f, 9.47134569e-02f, -4.32928741e-01f, 3.88983727e-01f,
  -4.67327684e-01f, -4.75730211e-01f, 4.36122477e-01f, -7.58752704e-01f, 2.43659467e-01f, 5.74495435e-01f, -4.13837224e-01f, -4.09973204e-01f, -2.90432628e-02f, -5.86303830e-01f,
  -9.35276374e-02f, 3.37093264e-01f, 3.38430375e-01f, -3.13176751e-01f, 2.41287693e-01f, 1.73769891e-01f, -3.68884876e-02f, -7.11352155e-02f, -7.39721537e-01f, -6.55916452e-01f,
  -1.13916302e+00f, -2.51570959e-02f, 5.14182270e-01f, 5.84254980e-01f, 2.99772799e-01f, 2.89104044e-01f, -5.42646289e-01f, -1.97072490e-03f, 6.22474551e-02f, 1.43415332e-01f,
  3.11491013e-01f, -4.83666092e-01f, -1.78521663e-01f, -1.85110793e-01f, 1.82093129e-01f, 3.68751228e-01f, -2.37789955e-02f, 4.46293503e-02f, 4.43275779e-01f, -3.52516800e-01f,
  -3.17702681e-01f, 2.45662719e-01f, 4.55339968e-01f, -4.17802706e-02f, -5.38026094e-01f, 2.78037369e-01f, -1.37156829e-01f, 2.29218647e-01f, -3.20705771e-01f, 6.87993169e-01f,
  -5.35198569e-01f, -4.30414587e-01f, -1.22263078e-02f, -5.71672201e-01f, 4.59596515e-03f, 4.60186869e-01f, 9.04242247e-02f, 2.36768484e-01f, 5.08698940e-01f, 6.27520621e-01f,
  -2.39424542e-01f, -6.01962209e-01f, 4.91979510e-01f, -1.79734975e-01f, -1.14278555e-01f, 2.94723868e-01f, -3.72189820e-01f, 1.81743905e-01f, 5.83794713e-01f, -3.46231252e-01f,
  4.09483761e-01f, -8.99290219e-02f, -4.89362061e-01f, 2.48633236e-01f, 1.06896617e-01f, -7.95815364e-02f, -7.87257910e-01f, -4.70257312e-01f, 7.64441118e-02f, -5.06980941e-02f,
  4.85736638e-01f, -2.79414475e-01f, -2.10048169e-01f, -4.45887536e-01f, -9.07154977e-01f, -5.25051415e-01f, -1.14449449e-02f, -3.41686636e-01f, 1.17957190e-01f, -3.22131902e-01f,
  -3.50972801e-01f, -6.58075869e-01f, 5.78254044e-01f, 6.20094463e-02f, 9.74849835e-02f, -5.78754842e-01f, 3.30915660e-01f, 2.84001142e-01f, 1.77732244e-01f, 4.46541816e-01f,
  3.47339660e-01f, -6.78719208e-02f, 6.45379126e-01f, -9.68530998e-02f, -3.53304505e-01f, 2.54857183e-01f, 4.25759226e-01f, -2.11633056e-01f, 4.10265446e-01f, -1.02043189e-01f,
  2.40397796e-01f, 6.82647526e-02f, -8.61936569e-01f, -1.22715235e+00f, -4.99462515e-01f, -3.72180194e-01f, -5.46604991e-01f, 4.08277214e-01f, -4.37838554e-01f, -2.53605753e-01f,
  -6.42763376e-01f, -3.09000853e-02f, -2.39458621e-01f, 5.11703730e-01f, -2.75545865e-01f, -5.27700067e-01f, 5.20383060e-01f, -3.18348169e-01f, -1.66227669e-01f, -5.21820486e-01f,
  -2.60201246e-01f, 1.59741655e-01f, -3.29707563e-01f, -1.40727833e-01f, -4.79727179e-01f, -1.93928450e-01f, -8.00939500e-02f, -6.97578341e-02f, -2.27267832e-01f, 2.35679612e-01f,
  3.12872291e-01f, 2.26802692e-01f, 1.12717606e-01f, -7.75712371e-01f, -2.07925722e-01f, -2.70636261e-01f, -4.71174210e-01f, 4.53426927e-01f, 4.95892726e-02f, 3.19047689e-01f,
  3.03319748e-03f, -4.21103626e-01f, 5.72162032e-01f, 1.94052771e-01f, -3.18048030e-01f, 9.79358703e-02f, 1.22337997e-01f, 4.42831397e-01f, 4.69239801e-02f, 3.31701666e-01f,
  6.87128827e-02f, 6.44210637e-01f, -7.36333251e-01f, 4.57151294e-01f, -4.09678817e-02f, 4.65651244e-01f, -1.33219227e-01f, 2.07016185e-01f, 6.48197591e-01f, 7.39938378e-01f,
  -8.26799393e-01f, -9.04891342e-02f, 8.49418461e-01f, 4.96598333e-01f, -4.44738828e-02f, 2.54024535e-01f, 1.86769795e-02f, -5.00104800e-02f, -3.46039712e-01f, 1.74007937e-01f,
  -5.35939038e-01f, -1.27582982e-01f, -2.83181757e-01f, -5.29550791e-01f, 1.95961490e-01f, -3.16285729e-01f, 5.64884907e-03f, -4.91913795e-01f, 7.10343495e-02f, -4.57267135e-01f,
  -4.16094989e-01f, -6.68182433e-01f, 2.89489746e-01f, -5.48766494e-01f, 3.82659554e-01f, -4.59291309e-01f, -6.50051713e-01f, 3.15686017e-01f, -4.99703407e-01f, -1.09153077e-01f,
  -4.55315351e-01f, -5.74317686e-02f, -1.75815448e-01f, -2.32748762e-01f, -9.08451825e-02f, -2.28890151e-01f, -4.26095814e-01f, -3.41253281e-01f, 3.57813299e-01f, 2.34801754e-01f,
  -1.51313037e-01f, -5.93423247e-01f, 1.83841796e-04f, -2.95389742e-01f, -3.75793159e-01f, -2.73813196e-02f, -5.74357331e-01f, -2.15448245e-01f, 4.09625694e-02f, 2.22309798e-01f,
  -2.57093668e-01f, 3.61794353e-01f, 2.76162833e-01f, 2.40192354e-01f, -4.86730963e-01f, 5.00411868e-01f, -2.06538260e-01f, 4.79050428e-02f, -4.47028875e-02f, 1.90865368e-01f,
  -3.21820974e-01f, -1.72718540e-02f, 2.49671221e-01f, -5.17931819e-01f, 5.69348514e-01f, 2.81189363e-02f, -3.25586438e-01f, 2.21552357e-01f, -5.57230949e-01f, -2.06647247e-01f,
  -3.24431270e-01f, 2.05819070e-01f, -4.95871753e-01f, -5.37140369e-01f, 3.60783398e-01f, 2.95665771e-01f, -3.51284355e-01f, -2.38795310e-01f, 2.31971517e-01f, 2.17244446e-01f,
  3.61848772e-01f, -4.85828549e-01f, 2.78869327e-02f, -1.82628945e-01f, -1.70812607e-02f, 4.28304136e-01f, 7.18386248e-02f, 1.07675247e-01f, -4.22337204e-01f, 3.93386781e-01f,
  2.50137150e-01f, -7.00925440e-02f, 1.94951683e-01f, -4.04661261e-02f, 5.96506596e-01f, -5.96694231e-01f, 6.23154104e-01f, -2.10666880e-01f, -7.04754889e-01f, 5.62009037e-01f,
  3.34682196e-01f, 5.21241724e-01f, -8.99506688e-01f, -7.01713920e-01f, -2.95737088e-01f, 8.78743380e-02f, -2.90936559e-01f, -8.81847143e-01f, 4.96513732e-02f, 4.91140217e-01f,
  3.72027904e-01f, 1.50656581e-01f, 3.88090402e-01f, -5.02450526e-01f, 2.97166824e-01f, 4.94932741e-01f, -2.34989896e-02f, 5.74626446e-01f, 1.70342490e-01f, -2.21717656e-01f,
  6.04187965e-01f, -1.82514772e-01f, 5.07037818e-01f, -6.15878105e-01f, 4.49456125e-01f, 5.37802100e-01f, -3.65234703e-01f, 5.35635889e-01f, -1.07437640e-01f, -1.22873507e-01f,
  3.32280964e-01f, -4.66997385e-01f, -6.76981747e-01f, -8.13146651e-01f, 1.01645336e-01f, 2.44041637e-01f, -1.23146737e+00f, 3.62995744e-01f, -4.15631443e-01f, 3.50517690e-01f,
  2.79220402e-01f, 3.37077469e-01f, 2.46284291e-01f, -2.61204839e-01f, 1.34163797e-01f, -5.58344066e-01f, -2.92911202e-01f, 1.73066601e-01f, -7.74908543e-01f, -1.62390441e-01f,
  1.67823374e-01f, 9.84339342e-02f, 4.15750325e-01f, 1.14654891e-01f, 9.13336466e-04f, 1.95509031e-01f, 4.26359236e-01f, 2.17721790e-01f, -8.04241821e-02f, -5.57454348e-01f,
  -1.47273690e-01f, 4.75244299e-02f, 3.16900223e-01f, 5.79441264e-02f, -2.95027822e-01f, -3.27685207e-01f, -8.47244859e-01f, -4.88734692e-02f, 7.37086475e-01f, 3.18249851e-01f,
  -5.36118925e-01f, 3.14220553e-03f, 5.71020365e-01f, 2.26795092e-01f, -3.64661664e-01f, -2.50423312e-01f, 2.16575280e-01f, 2.09310800e-01f, 2.37216055e-01f, 2.01584309e-01f,
  -3.22560012e-01f, 5.85888684e-01f, -2.36912802e-01f, 2.37621441e-01f, -3.80983278e-02f, -4.48089361e-01f, -5.93364894e-01f, -3.66861433e-01f, -2.48285055e-01f, 1.37464246e-02f,
  -7.73518458e-02f, 2.44144559e-01f, -6.19720042e-01f, 2.57989764e-01f, -3.97902429e-02f, -1.13422565e-01f, -3.86515111e-01f, 5.08074105e-01f, 1.04595207e-01f, -9.99948144e-01f,
  -7.78181732e-01f, -2.40429491e-01f, 2.95078456e-01f, -6.14735305e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.06448406e-01f, 1.33573068e-02f, 3.92615736e-01f, -1.87266618e-01f, 3.41909863e-02f, -1.44385591e-01f, 1.06501274e-01f, -7.99803436e-02f, 1.68045580e-01f, -2.72706039e-02f,
  -2.42475167e-01f, -2.74360124e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    