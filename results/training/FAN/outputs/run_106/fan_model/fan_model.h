/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.57733154e-01f, 1.32818922e-01f, -1.64542124e-01f, -4.02337432e-01f, -8.38735625e-02f, 2.96256542e-01f, 5.24501689e-02f, -1.19386176e-02f, -9.31817889e-02f, 1.51582271e-01f,
  9.48013589e-02f, -2.22625703e-01f, 3.60735863e-01f, -2.08008274e-01f, -3.96123230e-01f, 3.08662474e-01f, -1.65204853e-01f, -3.31027396e-02f, 1.26864344e-01f, -1.64229423e-01f,
  -1.91362798e-01f, -1.57528326e-01f, -9.93301049e-02f, 8.94321725e-02f, -1.97514862e-01f, 4.81943004e-02f, -2.64457196e-01f, 3.63536514e-02f, -1.97349206e-01f, -4.13828120e-02f,
  2.30947323e-02f, 1.79693341e-01f, -8.48611295e-02f, 6.80040270e-02f, 1.84747260e-02f, -1.16309384e-03f, -5.12551069e-02f, -6.44154893e-03f, 4.08477237e-04f, 5.60711995e-02f,
  -3.28702293e-03f, -3.17479447e-02f, 2.73999497e-02f, 4.06410574e-04f, -1.18765339e-01f, -9.81859267e-02f, -2.58732513e-02f, 3.95422988e-02f, 5.34477644e-02f, 2.01358628e-02f,
  -3.74767222e-02f, -1.39128393e-03f, -9.11399573e-02f, 4.86366227e-02f, -3.12752626e-03f, 4.41016182e-02f, -5.10391779e-02f, -4.16995846e-02f, -4.71337959e-02f, -4.22285013e-02f,
  1.01546943e-02f, 4.13672905e-03f, -4.01404575e-02f, -5.22581749e-02f, -9.78274830e-03f, -2.10355669e-02f, -3.32915224e-02f, -2.74515469e-02f, -3.94290835e-02f, 6.40508067e-03f,
  -3.87184732e-02f, -2.69909594e-02f, -6.88939542e-02f, -5.78647293e-02f, -1.90508161e-02f, -3.58073190e-02f, 1.45179173e-02f, 7.92170390e-02f, -3.35534140e-02f, -5.16195633e-02f,
  -4.44240542e-03f, -4.71267961e-02f, -1.40029546e-02f, -3.21102440e-02f, -3.38249817e-03f, -7.11779222e-02f, -3.33958454e-02f, 2.74841627e-03f, -3.89845250e-03f, -2.07217615e-02f,
  5.64448461e-02f, -5.78029193e-02f, 1.26544446e-01f, -3.22689898e-02f, 2.32910682e-02f, -2.59204619e-02f, -1.01990337e-02f, -8.44535977e-03f, -5.34100877e-03f, -2.96498891e-02f,
  2.11301316e-02f, -2.10775901e-03f, -1.11734867e-02f, -1.78945288e-02f, -3.61398458e-02f, 2.73946803e-02f, 8.70329700e-03f, -6.75101019e-03f, -8.29584748e-02f, -5.53544685e-02f,
  -4.82312553e-02f, 5.70182689e-02f, 3.96877080e-02f, 1.09872222e-02f, 1.71071272e-02f, 4.19376306e-02f, -7.68492371e-02f, 6.10339344e-02f, 3.40376347e-02f, -2.21819561e-02f,
  2.70003378e-01f, -1.68233570e-02f, 3.43910515e-01f, -1.19474821e-01f, -1.70923948e-01f, -2.47459725e-01f, -1.35598406e-01f, -1.60750210e-01f, -2.64591515e-01f, -1.35787889e-01f,
  -2.07688347e-01f, 4.99698818e-02f, 1.00773983e-01f, -2.74752051e-01f, 2.32642055e-01f, 9.87949595e-02f, -2.52155602e-01f, -1.90533221e-01f, -7.64681622e-02f, 1.27339605e-02f,
  6.74777180e-02f, -2.61013389e-01f, 2.56516755e-01f, -1.57397389e-01f, -1.56787299e-02f, 7.41988719e-02f, 2.03081116e-01f, 8.70361552e-02f, -1.70811359e-02f, -1.08489327e-01f,
  -2.80481372e-02f, -8.21076035e-02f, -5.63604198e-02f, 7.40823075e-02f, 4.64908555e-02f, 7.34876320e-02f, 4.20071259e-02f, 6.12836406e-02f, 7.68994391e-02f, -5.08367680e-02f,
  9.10255406e-03f, 5.88335507e-02f, -1.10044226e-01f, -4.74987403e-02f, 2.62187552e-02f, 2.27594897e-02f, 9.10685733e-02f, -4.77707200e-02f, -7.16922246e-03f, 1.03822388e-01f,
  -2.65893191e-02f, 9.21875015e-02f, 2.15306450e-02f, -4.61961962e-02f, 1.32794175e-02f, -8.74980465e-02f, 3.79245877e-02f, 5.53056598e-03f, -3.08218375e-02f, -1.12202592e-01f,
  1.08216668e-03f, 2.06849705e-02f, 3.72248180e-02f, -1.47716738e-02f, -2.52056234e-02f, 8.10371339e-03f, -2.01134700e-02f, 4.60532531e-02f, 3.14299837e-02f, 3.06499545e-02f,
  -5.22296354e-02f, 1.91274229e-02f, -5.33582903e-02f, 1.89644024e-02f, -6.69500232e-02f, 2.84056254e-02f, 4.78866100e-02f, -2.12711766e-02f, -4.19339165e-02f, 5.70993498e-03f,
  -1.15679111e-02f, -8.35307781e-03f, -6.06721677e-02f, 3.53091508e-02f, 4.83249547e-03f, 3.99473198e-02f, -7.16313422e-02f, 2.31946465e-02f, 4.49312327e-04f, -3.25803086e-03f,
  -1.18039362e-01f, -1.22505955e-01f, -3.74798663e-02f, -1.22312069e-01f, -6.42171828e-03f, -1.28908325e-02f, -8.64090398e-02f, -2.90968288e-02f, -7.08314106e-02f, -2.56340634e-02f,
  -4.09537852e-02f, -4.74762991e-02f, 8.71990621e-02f, -2.02884898e-02f, 2.71393470e-02f, -9.23147947e-02f, 2.96410955e-02f, -1.04052313e-01f, -3.37403044e-02f, -5.32179652e-03f,
  3.05026658e-02f, -7.56309852e-02f, 6.09352328e-02f, -8.54645073e-02f, -5.83165959e-02f, 3.82988676e-02f, -1.45028099e-01f, 4.73940335e-02f, 1.27743319e-01f, -1.29621290e-02f,
  -4.76673514e-01f, 4.77490753e-01f, 3.35381068e-02f, -8.85998830e-02f, -1.58597589e-01f, 3.94255430e-01f, 2.31089532e-01f, 1.26101807e-01f, -1.00385971e-01f, 2.91427851e-01f,
  1.67450279e-01f, -8.65026414e-02f, 1.99792787e-01f, 3.80897939e-01f, 1.61184132e-01f, 3.51208299e-01f, 7.39589557e-02f, 7.38485754e-02f, -5.72942868e-02f, -2.23250464e-02f,
  1.25221973e-02f, 2.99996048e-01f, 1.57666564e-01f, 1.88914284e-01f, 2.50247549e-02f, -1.25659093e-01f, 9.06702969e-03f, -7.27910250e-02f, 5.12937084e-03f, 1.10650606e-01f,
  1.31105363e-01f, 6.63663968e-02f, -4.01427783e-02f, 2.22755577e-02f, 8.52212757e-02f, -4.58280221e-02f, -8.02856982e-02f, 4.11596242e-03f, 1.55237624e-02f, -6.41184486e-03f,
  -6.77650273e-02f, 2.39755679e-02f, 6.51210621e-02f, -4.03122120e-02f, -5.12710847e-02f, -5.31900376e-02f, 1.88465007e-02f, -7.22990111e-02f, 3.71676125e-02f, 1.00716371e-02f,
  -2.85354778e-02f, -9.62507166e-03f, -5.89625165e-02f, 3.37943472e-02f, -4.50321175e-02f, -4.29719046e-04f, 3.19865011e-02f, -4.16784957e-02f, -4.06363197e-02f, 5.09962160e-03f,
  -4.99299087e-04f, -2.51377132e-02f, 2.05690879e-02f, 1.88893569e-03f, 5.80050461e-02f, -5.91760427e-02f, 1.60776433e-02f, 2.46837251e-02f, -4.96134162e-02f, 7.20745251e-02f,
  -6.60067722e-02f, -3.51028182e-02f, 1.10904155e-02f, -2.72716898e-02f, -4.68918448e-03f, -1.52087035e-02f, -4.08480875e-02f, 1.23103596e-02f, -1.32762775e-01f, -4.47192341e-02f,
  3.88684981e-02f, -1.81115195e-02f, 5.24580553e-02f, -2.00437475e-02f, 7.56755173e-02f, -2.92904787e-02f, 5.48667982e-02f, -6.74702600e-03f, -3.03997542e-03f, -3.05646919e-02f,
  2.08193392e-01f, 1.39431790e-01f, -1.34582371e-02f, 3.24971229e-02f, -3.58309299e-02f, -6.04888052e-02f, 4.35960144e-02f, 3.61558795e-02f, -7.09034828e-03f, -2.72793928e-03f,
  -8.92105419e-03f, -3.70685607e-02f, -4.15753685e-02f, -4.60693128e-02f, 3.41333039e-02f, 7.69369230e-02f, -3.64032923e-03f, -4.18613404e-02f, -7.53206536e-02f, -3.08658788e-03f,
  -2.08993088e-02f, -4.85944636e-02f, -2.02066042e-02f, -1.58085860e-02f, -2.85284594e-02f, 3.49928327e-02f, -5.10965437e-02f, -3.61173265e-02f, 4.06577475e-02f, 1.62378456e-02f,
  1.47645712e-01f, 1.47742061e-02f, -3.62914085e-01f, 1.37044443e-02f, 1.14455886e-01f, 2.60968685e-01f, 2.87934631e-01f, 5.73631525e-02f, -1.51112586e-01f, 1.69539988e-01f,
  1.32169962e-01f, -1.05725452e-01f, 4.35259342e-02f, 2.49272600e-01f, 3.98610711e-01f, -4.41424027e-02f, 2.26020947e-01f, 5.42753525e-02f, -1.63978681e-01f, 2.68860231e-03f,
  -2.86445953e-02f, 3.36384207e-01f, -8.14913586e-02f, 1.27953887e-02f, 1.49952650e-01f, -2.03065917e-01f, 2.64650196e-01f, -1.51788965e-01f, 1.50080934e-01f, 9.08014029e-02f,
  9.30859968e-02f, -5.22783361e-02f, -1.29805446e-01f, -7.54670128e-02f, 1.01920575e-01f, 3.28424647e-02f, 8.81321449e-03f, 6.46848679e-02f, 1.04019996e-02f, -4.16854396e-02f,
  3.55862491e-02f, 1.28018474e-02f, 8.98513645e-02f, -6.06198460e-02f, 2.47850306e-02f, -5.41777425e-02f, -7.74383098e-02f, -1.36483118e-01f, -5.12449332e-02f, -1.67234000e-02f,
  -1.43964723e-01f, -6.84192777e-02f, -1.52118653e-02f, -2.41110325e-02f, -6.03797361e-02f, -5.01145124e-02f, -6.87956214e-02f, -3.48968655e-02f, 3.53471451e-02f, -5.64804450e-02f,
  -8.75403658e-02f, 6.05749637e-02f, -4.39631753e-02f, -4.82367212e-03f, -9.11931135e-03f, -5.19095920e-02f, 1.65248811e-02f, 3.20747346e-02f, -2.22930126e-02f, 3.68048474e-02f,
  3.19705904e-02f, 5.23951612e-02f, -2.22976506e-02f, -2.38404088e-02f, 5.91654703e-02f, -9.30618215e-03f, 6.18107151e-03f, -1.14354892e-02f, 1.73633937e-02f, 4.49753366e-03f,
  -2.63833907e-02f, 3.80695611e-02f, 6.18478619e-02f, 5.03911404e-03f, -5.57135381e-02f, -5.21512656e-03f, 2.67046876e-03f, -8.97937268e-02f, -3.86439986e-03f, 1.07523464e-01f,
  3.93929541e-01f, 3.12352389e-01f, 1.80318039e-02f, 3.47150676e-02f, -2.13514287e-02f, 7.17704967e-02f, -5.31106927e-02f, -6.56451061e-02f, 3.03849857e-02f, -1.79450884e-02f,
  1.70355048e-02f, -2.79034283e-02f, 3.11335865e-02f, 3.01641077e-02f, 2.63905916e-02f, 3.71118188e-02f, 7.75430426e-02f, 6.90613538e-02f, 1.41311333e-01f, 8.59567374e-02f,
  2.67139208e-02f, -2.67238803e-02f, -3.21692005e-02f, 4.25100233e-03f, 4.82129827e-02f, 2.81717535e-02f, 2.39141528e-02f, -7.69873857e-02f, 5.08768782e-02f, 9.03532654e-02f,
  -1.04714893e-02f, -1.87899321e-01f, 3.70494634e-01f, -3.21424603e-01f, 2.01539565e-02f, 2.85802245e-01f, 1.90292001e-01f, -1.94744885e-01f, -1.46739632e-01f, -2.83530682e-01f,
  -2.51393378e-01f, -6.53640702e-02f, 3.02301813e-02f, -4.93506700e-01f, 3.02978873e-01f, -3.09404824e-02f, -2.78018206e-01f, -9.89068449e-02f, -1.51118683e-03f, -1.59381732e-01f,
  4.70744930e-02f, -4.26222622e-01f, 1.63723752e-02f, -1.57536596e-01f, -1.15376055e-01f, 9.11538824e-02f, -2.00581968e-01f, 2.10955381e-01f, -1.96519405e-01f, -5.65566914e-03f,
  -6.19632900e-02f, -1.95194244e-01f, 7.37352669e-02f, 8.61285031e-02f, 1.34965494e-01f, 6.20996244e-02f, 9.30211693e-02f, 1.39264524e-01f, -3.94793181e-03f, -3.13919261e-02f,
  3.39304283e-02f, -7.85677359e-02f, -4.30228151e-02f, -3.05752959e-02f, -1.65442806e-02f, 3.72031629e-02f, 1.98071823e-03f, 4.45661843e-02f, -3.17071378e-02f, 5.08547463e-02f,
  4.71262932e-02f, 5.34025021e-02f, -4.52131368e-02f, -1.34417964e-02f, 9.49083418e-02f, -9.38144997e-02f, 3.59610952e-02f, 2.63680276e-02f, 4.65169847e-02f, -4.33054827e-02f,
  1.84173472e-02f, 6.94648596e-03f, 9.29848328e-02f, -5.25455698e-02f, -1.17258271e-02f, -4.40094667e-03f, -8.27250332e-02f, 2.94512492e-02f, 4.27695587e-02f, 8.56031571e-03f,
  -6.23491071e-02f, -1.54790115e-02f, -5.93838431e-02f, -9.96573195e-02f, -2.35769562e-02f, -4.29173298e-02f, -1.91712528e-02f, -6.76053464e-02f, 3.70447487e-02f, -5.35663916e-03f,
  -2.00797152e-02f, 2.29913034e-02f, 4.72313212e-03f, 6.44526109e-02f, 2.19772905e-02f, -4.33748998e-02f, -1.05992988e-01f, -2.15546433e-02f, -1.86845008e-02f, 7.23843351e-02f,
  -2.28107022e-03f, -1.26628757e-01f, -4.98627350e-02f, -1.00035757e-01f, -9.24687367e-03f, 4.11481597e-02f, -1.52251022e-02f, 1.41190700e-02f, 2.02375688e-02f, -5.23245148e-03f,
  -3.45013551e-02f, -4.21453752e-02f, 1.07032157e-01f, -2.34113615e-02f, 2.07949337e-02f, -2.01367084e-02f, -2.64032669e-02f, -3.04361954e-02f, -4.77742665e-02f, -4.50638980e-02f,
  2.35188827e-02f, -5.60322553e-02f, 6.75236881e-02f, -2.94795148e-02f, -6.95107877e-02f, 2.53020115e-02f, -4.26353775e-02f, 7.21473396e-02f, 2.26816558e-03f, -2.80362796e-02f,
  -5.22482872e-01f, 4.09915745e-02f, -1.62566558e-01f, -3.17895502e-01f, -6.25074878e-02f, -1.87107399e-01f, 2.16459073e-02f, -2.01894775e-01f, -1.30066678e-01f, 1.09763213e-01f,
  -9.05760750e-03f, 1.30642831e-01f, 3.21775317e-01f, -2.55126834e-01f, -6.80341274e-02f, 2.26750150e-01f, -3.53442818e-01f, -6.50496408e-02f, -6.89994637e-03f, -1.32937849e-01f,
  -1.19723298e-01f, -7.34250098e-02f, -7.72710368e-02f, 3.26099470e-02f, -2.05787361e-01f, -9.25363451e-02f, 1.26072958e-01f, 2.01374620e-01f, -2.09139213e-01f, 5.79222254e-02f,
  -9.13235322e-02f, 1.72913317e-02f, -6.38289303e-02f, 2.28001014e-03f, -1.24627568e-01f, 1.84474327e-02f, -1.37880323e-02f, 1.11249179e-01f, -5.06794937e-02f, -1.83797646e-02f,
  -2.39875703e-03f, -2.27106139e-02f, -2.02759001e-02f, 1.08054027e-01f, -1.17425412e-01f, -6.87220320e-02f, -4.50723432e-02f, -1.19847022e-01f, 1.84899662e-02f, -4.30714041e-02f,
  -1.63341984e-02f, -8.43552798e-02f, -1.17248289e-01f, 4.77953628e-02f, -1.19944019e-02f, -6.81995079e-02f, 5.81982825e-03f, 6.69994950e-02f, -5.10609373e-02f, 8.82236194e-03f,
  1.93059503e-03f, 2.76682805e-02f, 2.02433974e-03f, -4.46950085e-02f, 3.78904655e-03f, -3.65535878e-02f, -6.51587918e-03f, 2.33075451e-02f, 1.11426534e-02f, 2.24688910e-02f,
  -7.66721144e-02f, -4.96527702e-02f, -1.83958020e-02f, -6.56003281e-02f, -3.66363488e-02f, -4.64214161e-02f, 2.44260076e-02f, 8.38607624e-02f, -9.99460295e-02f, -6.54656440e-02f,
  6.29509985e-02f, -8.55731219e-03f, 4.64563817e-02f, 6.69348799e-03f, -1.57261752e-02f, 4.69226614e-02f, -2.16019880e-02f, -4.49720863e-03f, -4.86266129e-02f, 2.37608869e-02f,
  6.99871629e-02f, 2.84507006e-01f, 2.25714967e-02f, 1.33195082e-02f, 1.07007593e-01f, -3.50003280e-02f, 1.70898438e-03f, -7.83884153e-02f, 6.94747642e-02f, -2.74232402e-03f,
  -2.44569108e-02f, 4.38030856e-03f, -1.72548823e-03f, -7.07084611e-02f, 3.70874330e-02f, -1.23398723e-02f, 5.18168136e-02f, 7.59913996e-02f, -4.86879656e-03f, -1.08237257e-02f,
  -6.91000931e-03f, 4.54169288e-02f, 5.09211048e-02f, -3.97562720e-02f, -6.05242699e-02f, 4.23818119e-02f, -3.68671082e-02f, -1.65457968e-02f, 4.48549576e-02f, 3.21522765e-02f,
  4.29852664e-01f, 9.96221527e-02f, -8.63182768e-02f, 7.70319253e-02f, 9.92500633e-02f, 3.00820559e-01f, 1.45318404e-01f, 1.04393058e-01f, -2.19997317e-01f, 2.35410288e-01f,
  -4.91725504e-02f, 1.58806205e-01f, -2.85862893e-01f, 2.25667357e-01f, -2.77572483e-01f, -2.40244135e-01f, 1.61033288e-01f, 1.99462563e-01f, -2.24094912e-01f, 2.52045870e-01f,
  -1.22279704e-01f, 1.88165992e-01f, -1.36636958e-01f, -1.25677651e-03f, 2.35407740e-01f, -1.32987825e-02f, 8.06312487e-02f, -2.13417798e-01f, 2.69456476e-01f, 4.96353507e-02f,
  1.05936095e-01f, -1.21634647e-01f, 4.72038351e-02f, -7.13532791e-02f, 1.58853471e-01f, -8.40616133e-03f, 3.69913206e-02f, -1.47936091e-01f, -4.50638235e-02f, 4.53056805e-02f,
  8.51676092e-02f, -3.96511257e-02f, 2.93652583e-02f, -1.05875604e-01f, -1.37999933e-02f, -5.66395409e-02f, -6.96079712e-03f, 5.19787446e-02f, -2.90697459e-02f, -4.77707088e-02f,
  -3.62639986e-02f, -2.10311860e-02f, 1.79774722e-03f, 4.35225405e-02f, -5.48839718e-02f, -5.10441028e-02f, -1.38903204e-02f, 1.22442037e-01f, 1.05614744e-01f, 2.93791033e-02f,
  -5.56086935e-02f, -1.24014117e-01f, 4.56398819e-03f, -3.45673040e-03f, -7.34053599e-03f, 6.87366650e-02f, -1.00065403e-01f, 4.04242426e-02f, 3.17150317e-02f, 1.15344552e-02f,
  8.94173905e-02f, 3.40708606e-02f, -5.38578816e-03f, -4.35775891e-02f, 2.81261709e-02f, 4.15026993e-02f, 2.68621352e-02f, 1.02807947e-01f, -2.60164915e-03f, 2.74421871e-02f,
  2.82103140e-02f, -2.32333746e-02f, 1.22907823e-02f, 3.18215303e-02f, -3.00950725e-02f, 2.70856190e-02f, -7.09529445e-02f, -1.20033687e-02f, -6.74185250e-03f, 6.26845732e-02f,
  2.62962639e-01f, 7.68453181e-02f, 2.64539779e-03f, -7.68462487e-04f, 9.18192149e-04f, -1.20935189e-02f, -1.57641649e-01f, 1.11937582e-01f, -2.25165356e-02f, -1.91707239e-02f,
  -5.81945591e-02f, 8.16447511e-02f, 1.34155676e-01f, 3.72766145e-02f, 2.32607732e-03f, 1.12991352e-02f, 1.25481589e-02f, 1.74411025e-03f, 1.71391994e-01f, 2.39823060e-03f,
  -3.86204757e-03f, 2.01398544e-02f, -9.01831612e-02f, 5.00215814e-02f, 7.24255666e-02f, 8.64170268e-02f, 5.72714172e-02f, -1.03352636e-01f, 7.43139014e-02f, -5.26400432e-02f,
  -1.24890767e-01f, -1.33380488e-01f, -1.39094204e-01f, -3.73726524e-02f, 4.33000512e-02f, -1.12812921e-01f, -1.66849136e-01f, -8.98401514e-02f, -2.75420219e-01f, -8.52820650e-02f,
  -1.13320291e-01f, 1.45952448e-01f, -2.03592986e-01f, 2.08050888e-02f, 2.12041333e-01f, -6.70616701e-02f, 1.28501877e-01f, 1.97865933e-01f, -4.34481446e-03f, 1.87420785e-01f,
  1.80846453e-01f, 3.37481707e-01f, 1.72963783e-01f, 2.22495690e-01f, 1.48456439e-01f, -2.06766538e-02f, 3.26617688e-01f, 4.89915162e-02f, 2.79942930e-01f, 9.39921513e-02f,
  8.59114435e-03f, -1.69923425e-01f, -9.65839401e-02f, 1.91425923e-02f, 6.42909333e-02f, -1.07823320e-01f, 1.09337591e-01f, -5.09766154e-02f, -5.31872734e-02f, 2.58038174e-02f,
  -7.17490073e-03f, 9.56989005e-02f, 6.11707494e-02f, -7.75055662e-02f, -1.67512223e-01f, -6.53567314e-02f, 1.64026991e-02f, 1.37313567e-02f, 1.42542580e-02f, -1.03911377e-01f,
  -8.99178535e-02f, -7.10308030e-02f, -4.34391424e-02f, -3.00402399e-02f, 3.64041813e-02f, -1.19431883e-01f, -9.25176814e-02f, 2.85800416e-02f, 3.14742140e-02f, -9.95080322e-02f,
  -3.24100885e-03f, -5.53871803e-02f, 1.93745885e-02f, -1.59752332e-02f, 3.04001272e-02f, -3.78415585e-02f, -6.49926662e-02f, 3.15703973e-02f, -8.66598263e-03f, -2.22305115e-02f,
  -1.71953943e-02f, -3.55326980e-02f, 1.22558353e-02f, -1.81462601e-01f, 2.69742962e-02f, -1.05143100e-01f, 6.69752732e-02f, 3.35386656e-02f, 9.71332099e-03f, -1.11004701e-02f,
  -1.08187325e-01f, -4.90511730e-02f, -3.31253419e-03f, 2.26782188e-02f, -1.71270743e-02f, -7.33836219e-02f, -7.24499151e-02f, -5.03592826e-02f, 4.83221672e-02f, 1.17152840e-01f,
  2.07597136e-01f, 2.84837842e-01f, 4.58495654e-02f, 4.53317538e-02f, 8.20146576e-02f, 5.85257709e-02f, 2.32521407e-02f, 2.61754356e-02f, 9.95615497e-02f, 4.36137132e-02f,
  -3.26515213e-02f, -3.82200489e-03f, 6.25635311e-02f, -6.85215741e-02f, 4.95449491e-02f, -9.36022177e-02f, 1.03259347e-01f, 1.66850667e-02f, 3.22126523e-02f, -3.09408698e-02f,
  -8.54103081e-03f, 6.58719316e-02f, 1.78889390e-02f, 1.60018846e-01f, -9.53083709e-02f, 3.99250574e-02f, -1.67633351e-02f, -9.08791050e-02f, 1.13481238e-01f, 3.24580409e-02f,
  3.60913932e-01f, -1.02484643e-01f, 1.85693830e-01f, 2.04629019e-01f, 1.52616546e-01f, 2.49610990e-02f, 1.86369538e-01f, -1.61828592e-01f, 1.17955462e-03f, -2.97093004e-01f,
  -7.14893341e-02f, -3.40628587e-02f, -2.40642309e-01f, 2.42885321e-01f, 5.94046950e-01f, -8.80044326e-02f, 1.08587794e-01f, -5.85749894e-02f, 3.11574545e-02f, -1.30270854e-01f,
  1.19110994e-01f, 5.32079712e-02f, 1.55557051e-01f, -1.04430810e-01f, 1.19142108e-01f, 6.44162223e-02f, 2.73407191e-01f, 7.46810287e-02f, 2.03934386e-01f, 2.43335903e-01f,
  -8.48420486e-02f, -6.06625564e-02f, -1.06138596e-03f, 2.85906140e-02f, 5.43313380e-03f, -7.64671192e-02f, 1.14137633e-02f, 1.26503244e-01f, 1.07550286e-02f, -7.69416168e-02f,
  -7.29151592e-02f, 9.39937308e-02f, -4.18510959e-02f, 5.76296151e-02f, 6.91446289e-02f, 4.38096896e-02f, -7.32293818e-03f, -5.77081554e-02f, -1.55070014e-02f, 1.08046969e-02f,
  -1.40093453e-02f, -2.00625826e-02f, 7.85125867e-02f, 1.56303886e-02f, 1.17010847e-01f, 3.90847623e-02f, 2.53761411e-02f, 3.95254157e-02f, -3.21106389e-02f, 3.13582905e-02f,
  4.97771800e-02f, -3.17011997e-02f, -9.58760921e-03f, -8.38582870e-03f, -1.31766405e-02f, 3.52715552e-02f, 8.12645257e-03f, -2.14409940e-02f, 2.29796357e-02f, 6.22559222e-04f,
  -4.93191294e-02f, -1.84526443e-02f, -2.04347470e-03f, 5.33687789e-03f, 1.64255314e-02f, -1.02929279e-01f, -1.18776411e-02f, -2.51635686e-02f, -4.40219864e-02f, 1.37411756e-02f,
  2.70817541e-02f, 6.38127699e-02f, -5.63460849e-02f, 3.08618043e-02f, -2.17992663e-02f, 2.83509176e-02f, 2.52491459e-02f, 1.44939357e-02f, -5.26939966e-02f, 5.60776480e-02f,
  1.17310606e-01f, 2.54725695e-01f, -2.09633317e-02f, -6.73841685e-02f, -2.55365595e-02f, 1.70989875e-02f, 1.52047360e-02f, -3.49746682e-02f, 2.07766771e-01f, 2.05140691e-02f,
  3.13225755e-04f, -6.36687204e-02f, -2.70592403e-02f, -4.86980844e-03f, -3.86196598e-02f, 3.50970251e-04f, -1.64907835e-02f, -1.41182682e-02f, 5.38000315e-02f, -1.88135244e-02f,
  -3.97913270e-02f, -4.15095873e-02f, -9.78847966e-03f, -2.93166116e-02f, 1.67657081e-02f, 2.06324011e-02f, 1.42548978e-02f, -8.15092102e-02f, 7.00617656e-02f, -1.27218151e-02f,
  6.45354211e-01f, -4.55572098e-01f, -4.02324386e-02f, 9.52011123e-02f, 1.20499514e-01f, 1.70643508e-01f, 2.96072245e-01f, -1.12233154e-01f, 2.73053169e-01f, -3.25033933e-01f,
  -1.56310603e-01f, -5.28624877e-02f, -1.26673296e-01f, -1.97707504e-01f, 4.60380197e-01f, 9.81818587e-02f, 1.46863699e-01f, 1.40129089e-01f, 5.09700030e-02f, -1.13356054e-01f,
  4.00406383e-02f, -3.86166126e-02f, -2.36327741e-02f, -2.02462196e-01f, 2.30425177e-03f, -7.64656141e-02f, -1.18773907e-01f, -2.21059639e-02f, -2.55498916e-01f, 1.93920322e-02f,
  -6.05474636e-02f, -7.02175796e-02f, -9.40242112e-02f, -4.44396026e-02f, 6.70559928e-02f, -1.16454288e-02f, 3.80545360e-04f, 1.00410119e-01f, 6.63661435e-02f, -1.71153769e-02f,
  1.66105814e-02f, 4.80694808e-02f, -4.70813327e-02f, 1.80637557e-02f, 5.38302213e-03f, -8.92845914e-02f, -5.32614253e-02f, 1.62472315e-02f, -5.45333549e-02f, 6.38758717e-03f,
  4.22610827e-02f, -2.19442397e-02f, -8.86163954e-03f, -2.45250445e-02f, -1.61171984e-02f, -1.90287214e-02f, 5.05763702e-02f, 4.48150337e-02f, 5.25805727e-02f, 7.00969622e-02f,
  -7.98800141e-02f, 9.44564492e-02f, 5.89680932e-02f, -1.39450198e-02f, -1.26007118e-03f, -7.53154838e-03f, -6.66725710e-02f, -3.24998908e-02f, 5.69370277e-02f, -6.69720471e-02f,
  -1.54421562e-02f, -4.30268561e-03f, 2.38146936e-03f, -2.34796759e-02f, 2.49365643e-02f, -5.92677062e-03f, 5.50408885e-02f, -3.73199545e-02f, 1.01709187e-01f, 5.22107519e-02f,
  -3.34211811e-02f, 1.60883460e-02f, 1.83730107e-02f, 2.36438448e-03f, 4.22135275e-03f, 2.50187963e-02f, -4.25411575e-02f, -8.25466216e-02f, -3.99553254e-02f, 6.01654034e-03f,
  -6.43889233e-02f, -1.21931240e-01f, -5.84819391e-02f, -1.14542365e-01f, -2.31287498e-02f, -6.22726604e-02f, 5.53376861e-02f, 1.05347752e-03f, 8.31286330e-03f, 5.80495223e-03f,
  9.94778983e-03f, -7.72501379e-02f, 8.81813392e-02f, 3.81562524e-02f, 3.14939930e-03f, 2.40341928e-02f, -1.50815146e-02f, -4.51876074e-02f, 6.68123215e-02f, -9.21129137e-02f,
  -8.82785246e-02f, 4.96894270e-02f, 7.14469552e-02f, 5.06948903e-02f, -1.90116651e-02f, -1.62876043e-02f, 3.57922204e-02f, -1.78553965e-02f, -2.44762097e-02f, -1.29799535e-02f,
  -5.86586773e-01f, 1.77390575e-01f, 2.12793127e-01f, -3.44872385e-01f, 6.81690499e-02f, 3.26143861e-01f, 2.08385870e-01f, -1.92250535e-01f, -1.41240671e-01f, -1.25720166e-04f,
  6.00790381e-02f, 1.89832915e-02f, 2.97072738e-01f, -4.52360958e-02f, 3.46045882e-01f, 2.35510156e-01f, -1.31031901e-01f, -9.94129851e-02f, 7.65199885e-02f, -4.84505482e-02f,
  -6.81353956e-02f, 4.40968424e-02f, 1.50670901e-01f, 1.27307419e-02f, 3.88717577e-02f, -1.11324176e-01f, 3.70544824e-03f, 1.58741578e-01f, -4.99415472e-02f, 1.46395102e-01f,
  -4.45432626e-02f, -3.49792570e-01f, 5.42234555e-02f, 1.58380680e-02f, -2.49294527e-02f, -1.64903309e-02f, -2.48184334e-03f, 1.05719812e-01f, 3.44927199e-02f, -4.94095257e-05f,
  -2.55222619e-02f, -4.07782681e-02f, -8.73094276e-02f, 4.29115482e-02f, -8.96210968e-03f, -7.11484328e-02f, 7.04541281e-02f, 6.20182790e-03f, -4.39067883e-03f, 2.91347932e-02f,
  1.64844766e-02f, 2.14157030e-02f, 9.44939815e-03f, 4.46513854e-02f, 1.70846041e-02f, -9.14546940e-03f, 6.05067611e-03f, 2.78156158e-02f, -3.59335542e-02f, -1.17517151e-01f,
  -1.90482866e-02f, -7.55011337e-03f, 1.95901990e-02f, -4.95988354e-02f, 1.90131813e-02f, -1.19646467e-01f, 3.01378295e-02f, 4.28380184e-02f, 4.65907622e-03f, -3.26114707e-02f,
  -5.99903539e-02f, -3.63669097e-02f, -6.91881776e-02f, -5.75520061e-02f, -7.72241130e-02f, -6.46635816e-02f, 4.44380455e-02f, 5.63743338e-02f, -8.15490186e-02f, 2.62893159e-02f,
  1.40220746e-02f, 3.31172049e-02f, 5.77952452e-02f, -3.62328216e-02f, 7.71367624e-02f, 1.04189217e-01f, 1.67937614e-02f, -2.99998112e-02f, -4.56553046e-03f, 8.59641284e-02f,
  5.05814776e-02f, -1.64040383e-02f, 5.80867827e-02f, -7.04131648e-02f, 8.96247327e-02f, 4.34081629e-02f, -1.25760185e-02f, -5.47496155e-02f, 3.37440223e-02f, -1.85043402e-02f,
  -8.88191909e-02f, -8.09474289e-02f, -3.39300409e-02f, -3.26629393e-02f, 2.11239625e-02f, 2.87064649e-02f, 1.25029180e-02f, 1.68869796e-03f, -7.74478633e-03f, -6.38033375e-02f,
  -8.45129862e-02f, -2.54130876e-03f, 4.64474373e-02f, -1.03618793e-01f, -8.98934081e-02f, 6.03245124e-02f, 2.15155557e-02f, -7.66745433e-02f, 6.33084625e-02f, -1.26564400e-02f,
  -6.14276342e-02f, -2.61008650e-01f, -3.14183801e-01f, -1.52568668e-01f, -1.61158353e-01f, 4.80177999e-01f, 3.79645377e-01f, -2.19514042e-01f, -2.53049493e-01f, 2.19763249e-01f,
  8.52066502e-02f, -5.53740822e-02f, -7.73606524e-02f, 4.41465229e-02f, 1.67031571e-01f, 8.48367736e-02f, 1.62785158e-01f, 8.37478936e-02f, -2.02648133e-01f, -1.25309601e-01f,
  -6.70551434e-02f, 1.34128109e-01f, -1.16957001e-01f, -5.83757684e-02f, -1.12786680e-01f, -1.01269044e-01f, 7.65569955e-02f, -1.57814752e-02f, 1.18238993e-01f, 1.71750918e-01f,
  7.77400285e-03f, -2.70548820e-01f, -1.37259573e-01f, 3.10475901e-02f, -3.26212985e-03f, 1.00956224e-01f, 1.18437625e-01f, 1.06133468e-01f, -4.51600887e-02f, 6.24424638e-03f,
  8.42139423e-02f, 3.26309241e-02f, 5.85569395e-03f, -1.63445137e-02f, 3.05100554e-03f, -6.15585893e-02f, -1.86847717e-01f, -1.17822886e-01f, -1.49958342e-01f, -3.70513387e-02f,
  -1.54255629e-01f, 4.97196161e-04f, 5.01617752e-02f, 1.11933038e-01f, -1.31784026e-02f, -4.75912951e-02f, 1.44540787e-01f, 7.50263482e-02f, 5.38944677e-02f, -6.08084202e-02f,
  1.09360158e-01f, 1.76404733e-02f, -3.48913372e-02f, -8.93424898e-02f, -4.31035161e-02f, -1.37216775e-02f, 1.30861476e-02f, 7.73983970e-02f, -8.62144120e-03f, -5.73276868e-03f,
  2.70801447e-02f, -4.60741818e-02f, -2.17994675e-02f, 3.87973376e-02f, 5.56447916e-03f, -2.51348615e-02f, 5.96974306e-02f, 1.92118827e-02f, 2.39724405e-02f, -1.23349484e-02f,
  -4.12169397e-02f, 9.23296362e-02f, -5.01871072e-02f, 5.72094396e-02f, 4.64451015e-02f, -1.09206541e-02f, -4.70654517e-02f, -4.03969898e-04f, -1.16237924e-01f, 3.89094315e-02f,
  1.49073556e-01f, 1.14966758e-01f, -3.11351405e-03f, 3.91375311e-02f, -1.92432851e-02f, -3.02793290e-02f, -2.19884235e-02f, 3.00765857e-02f, 4.61502299e-02f, 1.67480819e-02f,
  4.13738117e-02f, 2.01124027e-02f, 9.40490812e-02f, 6.73286691e-02f, -1.54849887e-02f, -1.79871563e-02f, 8.56324583e-02f, 9.97739807e-02f, 9.85041484e-02f, -2.92663388e-02f,
  2.51967143e-02f, 2.88034882e-02f, 3.72872055e-02f, 6.16502389e-02f, 1.10451661e-01f, 1.58402342e-02f, 8.90412834e-03f, 1.75741799e-02f, 2.27617864e-02f, 5.97571395e-02f,
  -9.47167650e-02f, -4.38388556e-01f, -1.48103997e-01f, 9.30551067e-03f, 1.44792750e-01f, -2.20406935e-01f, -4.09322642e-02f, -1.35633960e-01f, 2.21299067e-01f, -1.55769899e-01f,
  5.12891673e-02f, -5.97448945e-02f, -5.39302155e-02f, 1.18827656e-01f, -1.22792877e-01f, -7.32395500e-02f, -1.64368153e-01f, -1.43852502e-01f, 1.47653416e-01f, -9.38095152e-02f,
  -2.21207608e-02f, 1.90173566e-01f, -1.99507356e-01f, 1.55204117e-01f, -6.38049245e-02f, 1.28344195e-02f, -5.28202988e-02f, 1.86963789e-02f, -3.91726941e-02f, 2.61978135e-02f,
  -1.09924227e-01f, -3.93274799e-02f, -5.41723557e-02f, -6.02126345e-02f, -1.45495892e-01f, -6.20118342e-02f, -8.68801698e-02f, 9.01338309e-02f, 9.05330479e-02f, 6.55182227e-02f,
  -1.09243551e-02f, 1.87565327e-01f, 7.21552297e-02f, 7.19116181e-02f, -7.01712072e-02f, 9.93125960e-02f, -1.51499650e-02f, -4.44866419e-02f, 3.56361195e-02f, -1.08531080e-01f,
  9.12329331e-02f, -5.05599603e-02f, -1.77868664e-01f, -4.03319113e-02f, -4.60860841e-02f, 1.06266715e-01f, -2.65150238e-03f, -4.38541211e-02f, -1.15279846e-01f, 4.34424207e-02f,
  6.07785210e-02f, -3.99587937e-02f, -9.44310203e-02f, 2.89431009e-02f, 3.82208526e-02f, 2.98455693e-02f, -9.49932486e-02f, -2.65398266e-04f, 7.46316463e-02f, -3.80874947e-02f,
  6.96047693e-02f, -2.27279589e-02f, 3.67637202e-02f, 2.31838468e-02f, 1.00723538e-03f, -3.24085355e-03f, 1.58781502e-02f, 1.70722883e-02f, -1.15061656e-01f, -2.89639961e-02f,
  4.32935767e-02f, -4.50209156e-02f, -7.88307860e-02f, -9.18441936e-02f, -2.72485539e-02f, 1.12699559e-02f, -1.00655571e-01f, -1.19627997e-01f, 8.96158814e-03f, 3.43222581e-02f,
  -3.53780210e-01f, -2.62368649e-01f, -1.11158095e-01f, 2.59697791e-02f, 2.96878703e-02f, -7.92838335e-02f, 8.77572671e-02f, -1.23695880e-02f, -1.35116475e-02f, 4.70311493e-02f,
  -1.89486183e-02f, -7.18390197e-02f, -2.13572700e-02f, 7.42174760e-02f, -2.94720661e-02f, 3.09580867e-03f, -1.55498004e-02f, -2.25806888e-02f, -1.46761253e-01f, -9.92675945e-02f,
  -1.29669577e-01f, 8.22681114e-02f, 3.90423946e-02f, -5.87230250e-02f, -1.20774172e-01f, -2.20115948e-02f, -6.59309551e-02f, 5.87452799e-02f, 3.34121510e-02f, -3.33912298e-02f,
  -3.57932001e-01f, -3.52827966e-01f, -3.64669830e-01f, -1.23614870e-01f, -1.60782188e-01f, -3.25219240e-04f, 2.73311883e-01f, -2.52872735e-01f, -3.10115695e-01f, 1.80451587e-01f,
  1.77663818e-01f, -1.75353825e-01f, 1.83772624e-01f, -1.30124437e-02f, -2.12410361e-01f, 1.67574987e-01f, -2.12820858e-01f, 2.10499298e-02f, -9.67540145e-02f, -2.89404601e-01f,
  -2.33419746e-01f, 1.95341349e-01f, -1.27785251e-01f, -1.98380306e-01f, -3.85182016e-02f, -1.60921484e-01f, 1.74536064e-01f, 1.04672559e-01f, 1.54104363e-02f, 1.81004614e-01f,
  -1.28108621e-01f, -7.06462488e-02f, 6.17014691e-02f, -6.35780394e-03f, -5.94639331e-02f, 1.68288574e-02f, 5.49592823e-02f, 1.79996312e-01f, 6.29563630e-02f, -3.01955659e-02f,
  6.43237829e-02f, -1.30088687e-01f, -5.45693636e-02f, 7.06411973e-02f, -7.44979531e-02f, -1.47737309e-01f, 1.44657381e-02f, 5.47511643e-03f, -8.37215707e-02f, -1.47327147e-02f,
  3.35418899e-03f, -1.51357017e-02f, -1.52140139e-02f, 5.91443330e-02f, -3.63692194e-02f, -6.56170994e-02f, -5.52047305e-02f, 2.55778078e-02f, -9.15435031e-02f, -1.93846837e-01f,
  3.14039737e-02f, -6.90625906e-02f, -1.68632856e-03f, 3.57683711e-02f, 2.91505884e-02f, 3.14851925e-02f, 4.65148091e-02f, 2.37221979e-02f, -3.29148024e-02f, 5.90579119e-03f,
  -3.67950611e-02f, -3.19325104e-02f, 4.21007760e-02f, 5.90254739e-02f, 1.64701249e-02f, 1.67448875e-02f, 3.32693532e-02f, 1.35676861e-01f, -5.60739152e-02f, 7.79483542e-02f,
  1.61525160e-02f, -8.35748985e-02f, 4.79865298e-02f, 2.00699680e-02f, -4.39948700e-02f, 2.49032164e-03f, -2.65024286e-02f, -5.85613362e-02f, -1.31802140e-02f, 1.29084773e-02f,
  -1.74664602e-01f, -2.52520174e-01f, -5.96444719e-02f, -1.46028411e-03f, 1.12119123e-01f, 4.40497696e-02f, -7.29611143e-02f, 1.78888552e-02f, -7.18360767e-02f, -4.08861134e-03f,
  -7.31193647e-02f, 5.25364131e-02f, -1.23002112e-01f, 1.23701453e-01f, -8.27720203e-03f, -8.06563348e-03f, 7.04748407e-02f, -3.11702602e-02f, -4.85806838e-02f, -2.51935236e-03f,
  -1.84563976e-02f, -2.44174469e-02f, -2.66664363e-02f, -8.49338621e-02f, 8.35498273e-02f, -7.22047873e-03f, -4.88371179e-02f, -3.06604058e-02f, 6.48402125e-02f, 3.63839120e-02f,
  -3.88587087e-01f, 3.01895708e-01f, -1.16058856e-01f, -2.45428309e-01f, -4.17931080e-01f, 1.78157702e-01f, 2.18540177e-01f, -5.66911884e-02f, 1.28805533e-01f, 3.65243167e-01f,
  -2.63801366e-01f, 8.81590545e-02f, 1.68256924e-01f, -1.17918983e-01f, -3.99740905e-01f, 1.22104369e-01f, 1.41337244e-02f, 1.24707758e-01f, 1.16988324e-01f, 5.55760507e-03f,
  -1.42895967e-01f, -2.20248446e-01f, -1.56436086e-01f, 2.49902997e-02f, -1.74536332e-01f, 4.66281548e-02f, -4.50283028e-02f, 8.29518586e-03f, -7.85539746e-02f, -3.78199667e-02f,
  -8.57930481e-02f, 1.19339965e-01f, -5.54256923e-02f, 5.35396934e-02f, -7.71774864e-03f, -1.88798867e-02f, 4.74922806e-02f, -4.17044312e-02f, -6.20600618e-02f, 6.62080124e-02f,
  7.37850517e-02f, -6.27237931e-02f, 1.62845515e-02f, -2.90497001e-02f, -3.41604315e-02f, -9.36696026e-03f, -2.12706756e-02f, -2.69952379e-02f, 2.74255052e-02f, -4.49147895e-02f,
  -1.67465974e-02f, -5.88634908e-02f, -7.30677098e-02f, 8.30006078e-02f, -2.58436427e-02f, -2.06835866e-02f, 3.62187289e-02f, 1.78025141e-02f, 1.16551863e-02f, 1.99658070e-02f,
  2.38313917e-02f, 6.91187531e-02f, -3.14100310e-02f, -6.26669377e-02f, -1.88794527e-02f, -3.73960957e-02f, -3.12153075e-04f, -1.99430976e-02f, 3.62511501e-02f, 4.88636596e-03f,
  -1.84738506e-02f, -6.24766424e-02f, -3.17252576e-02f, -3.97693403e-02f, -4.16684058e-03f, 7.22382683e-03f, -4.94665056e-02f, 1.39293931e-02f, 3.38333286e-02f, -8.54057074e-02f,
  3.27910408e-02f, -4.07875068e-02f, 6.93758875e-02f, -2.33208332e-02f, 6.50775805e-02f, -5.04575633e-02f, 1.28285410e-02f, -2.54904497e-02f, 1.62552055e-02f, -5.88746816e-02f,
  1.48743391e-01f, 2.56480873e-01f, 9.80041996e-02f, -2.24589482e-02f, 8.55513141e-02f, -2.63494179e-02f, 2.63077077e-02f, -3.36763971e-02f, 1.06022798e-01f, -2.42048167e-02f,
  1.90237514e-03f, 5.01027256e-02f, 1.17845200e-02f, -7.51300529e-02f, -2.46565510e-02f, 2.68429779e-02f, 4.67744470e-02f, 2.06125490e-02f, -6.42421022e-02f, 3.16895992e-02f,
  -1.92029476e-02f, 3.50044034e-02f, 2.43646782e-02f, -1.91500261e-02f, -2.26048827e-02f, 2.47942209e-02f, 1.89295523e-02f, 5.99942394e-02f, -2.76511796e-02f, 3.21600027e-02f,
  -8.10986817e-01f, 2.12216109e-01f, -2.22679958e-01f, 5.55697605e-02f, -2.36052319e-01f, 1.91002890e-01f, 4.66478616e-03f, 4.70657274e-02f, -1.58419698e-01f, 3.41607243e-01f,
  8.03670511e-02f, -1.50682494e-01f, 1.25779882e-01f, 2.31710985e-01f, -1.03720486e-01f, 1.88687667e-01f, 1.51493981e-01f, 8.41254219e-02f, -2.92474627e-02f, 5.82291223e-02f,
  -5.58284409e-02f, 2.10631430e-01f, 7.21478239e-02f, 1.96845248e-01f, -1.52749091e-01f, -3.70164625e-02f, 1.93879545e-01f, 3.50926258e-02f, 1.22388437e-01f, -2.12896373e-02f,
  -3.10658794e-02f, -1.20002992e-01f, -5.74285276e-02f, -9.01217014e-02f, 1.63350895e-03f, -9.68765095e-03f, -6.03251113e-03f, -1.61619540e-02f, -4.57863696e-02f, -1.00919073e-02f,
  -2.98946369e-02f, -1.82224102e-02f, -6.28827093e-03f, -3.60364914e-02f, -8.51877853e-02f, -9.49488655e-02f, -6.79591745e-02f, -2.26979535e-02f, 5.14317825e-02f, -5.89180663e-02f,
  -2.36713309e-02f, 4.96599730e-03f, -2.84421239e-02f, 7.78456265e-03f, -3.40834670e-02f, -4.99093346e-02f, 2.27663163e-02f, -5.21332584e-02f, 2.48510558e-02f, -9.69541166e-03f,
  -4.49327156e-02f, -5.47999796e-03f, -4.54841778e-02f, -1.75692458e-02f, 5.91691909e-03f, -8.76231771e-03f, 1.14400927e-02f, 2.66785808e-02f, -7.18120635e-02f, 1.61341093e-02f,
  4.74743806e-02f, -2.61338726e-02f, -1.83510240e-02f, -2.02215873e-04f, 2.71937996e-02f, 2.71340273e-02f, -1.97597332e-02f, 1.44756446e-02f, -1.52148008e-02f, 1.83580294e-02f,
  1.73626654e-02f, 1.99713893e-02f, 1.44377425e-02f, 2.52891425e-03f, 4.63980064e-02f, 1.95132801e-03f, 5.45636602e-02f, -2.38858536e-02f, -1.30442055e-02f, -1.55868661e-02f,
  2.29992375e-01f, 3.62601280e-01f, 1.00447744e-01f, 6.75990358e-02f, 2.74984818e-02f, -3.53997760e-02f, -2.99889641e-03f, -4.38582301e-02f, 4.86896373e-02f, 2.73854826e-02f,
  -1.08314436e-02f, 1.64907966e-02f, 6.70471862e-02f, 1.91953350e-02f, 3.85579206e-02f, 9.76935327e-02f, 6.16767928e-02f, -3.90644558e-02f, 2.80188192e-02f, 2.97759380e-02f,
  4.29451279e-02f, 5.98859368e-03f, -3.38296928e-02f, 1.28667615e-02f, 1.43115474e-02f, 2.40883604e-02f, 9.47302859e-03f, -3.72859836e-02f, 1.81974955e-02f, 5.51600121e-02f,
  3.24629098e-01f, -5.43074906e-01f, -1.69167221e-01f, -3.69931519e-01f, 4.16404486e-01f, 6.35156482e-02f, -2.17459410e-01f, -6.45779893e-02f, -1.52836561e-01f, -3.70124817e-01f,
  2.71532610e-02f, -6.52380511e-02f, -1.86905563e-01f, -2.16468722e-01f, 4.40224707e-01f, -1.99547336e-01f, -1.99372560e-01f, -2.24034980e-01f, -2.93867604e-04f, -1.28124177e-01f,
  7.08266124e-02f, -1.39150331e-02f, -4.14377898e-02f, -1.66830039e-04f, 2.16116048e-02f, -9.88615155e-02f, 3.15433787e-03f, 6.15801923e-02f, 2.54001077e-02f, 1.41728133e-01f,
  1.15979686e-02f, -1.14463516e-01f, 4.60757725e-02f, -4.57722368e-03f, -1.32284109e-02f, 4.08331826e-02f, -1.18999798e-02f, 1.03651606e-01f, 9.99544188e-02f, -6.51849508e-02f,
  -3.54625024e-02f, 3.10622267e-02f, -1.88295206e-03f, 3.52091715e-02f, 7.23909773e-03f, 2.81597413e-02f, 4.16327119e-02f, 6.58953488e-02f, -5.99835403e-02f, 9.41631384e-03f,
  -1.25297504e-02f, 1.11013157e-02f, -5.88715123e-03f, -1.05543666e-01f, 2.79018208e-02f, -3.94657068e-02f, -8.08074176e-02f, 4.41829441e-03f, -6.42194301e-02f, -2.17128005e-02f,
  -1.68914292e-02f, -3.70920599e-02f, -1.95500962e-02f, 6.36905283e-02f, -2.42795935e-03f, 4.21329290e-02f, 3.23789082e-02f, 4.63306457e-02f, -2.93854941e-02f, -4.43129195e-03f,
  2.07655923e-03f, 2.90551281e-04f, -1.31189693e-02f, -1.63915311e-03f, -3.43639739e-02f, -4.35517356e-02f, 1.00049581e-02f, -2.93414462e-02f, -3.42054926e-02f, 4.22513634e-02f,
  -2.72850096e-02f, 4.82299272e-03f, -3.63085307e-02f, 1.85654107e-02f, -4.52523939e-02f, -1.26764355e-02f, -1.38119226e-02f, -8.39163084e-03f, -2.00186800e-02f, 5.93401417e-02f,
  -1.51089534e-01f, -3.82138997e-01f, -1.39687695e-02f, -2.68417243e-02f, -3.36658917e-02f, 2.21784450e-02f, 4.71289903e-02f, -1.74734853e-02f, -8.17894861e-02f, 3.26954108e-03f,
  -1.02229826e-02f, -4.42765020e-02f, -2.37866379e-02f, 2.86866445e-02f, 3.43645811e-02f, -2.93225721e-02f, -8.62141401e-02f, -2.92860158e-02f, 1.08083179e-02f, 3.78115363e-02f,
  -1.96507778e-02f, -6.26755804e-02f, -1.51976093e-03f, -1.78941023e-02f, -4.00605910e-02f, -1.68810841e-02f, 3.56880017e-02f, 1.20546436e-02f, 1.78584289e-02f, -3.13374288e-02f,
  1.29442394e-01f, -1.39891014e-01f, 1.73947245e-01f, 8.64030719e-02f, 2.19084933e-01f, 3.01850945e-01f, 2.89736152e-01f, 6.99725971e-02f, 1.68334678e-01f, -2.69751567e-02f,
  1.24696240e-01f, 8.71724710e-02f, -1.64734080e-01f, 1.80498153e-01f, -8.28036666e-03f, 1.76245887e-02f, 1.77904338e-01f, 1.46147802e-01f, -1.38884246e-01f, -4.42471297e-04f,
  4.20452580e-02f, -6.96154609e-02f, 1.29657015e-02f, -2.75061339e-01f, 1.46940336e-01f, -1.40125811e-01f, -2.98858851e-01f, -1.53522044e-01f, 4.48699705e-02f, 1.39105722e-01f,
  -2.27070600e-02f, -3.59397829e-02f, 1.64528115e-04f, -9.63673443e-02f, 6.68089185e-03f, -5.11946790e-02f, -1.11856155e-01f, -3.96335125e-02f, -9.87449586e-02f, 7.57060573e-02f,
  -1.16420805e-03f, -3.46276797e-02f, 5.70370033e-02f, 2.72057625e-03f, 3.73933911e-02f, -1.05922334e-02f, 1.56316295e-01f, 4.27348651e-02f, 5.06375581e-02f, 5.78351915e-02f,
  1.39449969e-01f, 4.78747934e-02f, 2.95584071e-02f, 4.07743640e-02f, 1.91154461e-02f, 8.10877513e-03f, 1.67390015e-02f, 1.20529629e-01f, 2.26879995e-02f, 5.92825077e-02f,
  -6.42715469e-02f, -8.82727802e-02f, 7.90576544e-03f, -7.05471337e-02f, -3.40912454e-02f, -1.43637566e-03f, -1.59617011e-02f, -2.14163214e-02f, 2.39107907e-02f, 1.32714752e-02f,
  5.61078116e-02f, 2.42200494e-02f, -2.62412000e-02f, -4.68739420e-02f, -7.14045158e-03f, 5.92430644e-02f, -5.42373136e-02f, 4.62531708e-02f, 7.73045346e-02f, 3.01320534e-02f,
  -2.43699700e-02f, -5.75888269e-02f, 7.65161067e-02f, -4.27417830e-02f, -4.68268283e-02f, 2.89154332e-02f, -1.05107419e-01f, 8.22302923e-02f, 9.13396254e-02f, 1.08008403e-02f,
  -2.25194722e-01f, -2.93906599e-01f, 3.06374077e-02f, 1.49269756e-02f, -5.31169064e-02f, 3.98595259e-02f, -5.25210947e-02f, 1.02634430e-01f, -1.55143425e-01f, -3.49639133e-02f,
  -7.71364942e-02f, 8.17753002e-02f, -6.67861104e-02f, -3.08350404e-03f, -3.47423777e-02f, 3.63280699e-02f, -4.45286483e-02f, -1.39430519e-02f, -3.50495614e-02f, -7.73127303e-02f,
  -7.48262107e-02f, -2.07519904e-02f, -4.99523655e-02f, 9.30724945e-03f, -3.14280950e-02f, 4.92043793e-02f, 3.15497816e-02f, 1.54287256e-02f, 2.17044856e-02f, -7.19499663e-02f,
  1.90760598e-01f, 9.89260077e-02f, 2.65913099e-01f, -3.08681160e-01f, -3.91210988e-02f, 2.63870269e-01f, -1.39515817e-01f, -6.17645569e-02f, 2.70269215e-01f, -1.76875070e-01f,
  -3.65597934e-01f, 3.60970080e-01f, -1.58315822e-01f, -2.86638796e-01f, 2.46662661e-01f, -5.36026433e-02f, -1.33216679e-01f, -1.23699702e-01f, 1.50276661e-01f, -9.50748101e-02f,
  1.39402342e-03f, -2.87897259e-01f, -1.45390287e-01f, -9.18178558e-02f, -1.09054953e-01f, 4.16766629e-02f, -3.01907539e-01f, -1.66217834e-02f, -1.13464743e-01f, 8.84485841e-02f,
  -2.50912301e-04f, -9.12937447e-02f, -1.55975493e-02f, 8.43665078e-02f, -2.78180521e-02f, -7.79836401e-02f, 4.98607643e-02f, -9.83948261e-03f, 7.08568618e-02f, -5.68921715e-02f,
  9.98431258e-03f, 6.78156093e-02f, 3.58291119e-02f, 2.88110524e-02f, -5.05188033e-02f, 1.05452072e-02f, 1.83594748e-02f, 2.01671887e-02f, 2.96008587e-02f, -2.81174462e-02f,
  1.58307981e-02f, 7.59026408e-03f, 2.61596777e-02f, 1.65422279e-02f, 8.86841863e-02f, 3.79098840e-02f, 5.65041788e-02f, 3.83362323e-02f, 3.81391644e-02f, 6.79882318e-02f,
  -2.71981256e-03f, 3.56216505e-02f, 1.73307536e-03f, 4.38761674e-02f, -1.37208560e-02f, -2.89454646e-02f, 1.29267073e-03f, -4.95980904e-02f, 1.29064145e-02f, -2.15860475e-02f,
  -2.96566803e-02f, 2.75503471e-03f, 6.50323089e-03f, 3.75762023e-02f, -2.75743450e-03f, 2.97787357e-02f, 4.41979989e-02f, 2.96102483e-02f, 9.70842596e-03f, -3.66396867e-02f,
  -5.94757535e-02f, 2.88308486e-02f, 1.35963066e-02f, -7.99108893e-02f, -2.10412554e-02f, 4.73182425e-02f, -8.29569623e-02f, 3.28625403e-02f, -3.35492678e-02f, -4.51270584e-03f,
  5.49459923e-03f, 2.44955625e-02f, 4.77307243e-03f, 7.54767796e-03f, 1.97342169e-02f, 7.05338418e-02f, -2.39500087e-02f, 1.07337914e-01f, 3.28261368e-02f, 4.35890220e-02f,
  4.51361351e-02f, -6.85167983e-02f, 2.90804654e-02f, -1.80403944e-02f, 1.59374848e-02f, -6.51967227e-02f, -4.36601415e-02f, 3.65165472e-02f, -7.33799636e-02f, -1.21552851e-02f,
  -3.03637870e-02f, 7.73131475e-02f, 4.91350610e-03f, 2.37027137e-03f, -7.65305609e-02f, -5.20195439e-02f, 5.08323684e-02f, 4.39305790e-02f, -1.07498176e-01f, 1.17340265e-03f,
  5.49734354e-01f, 7.31208250e-02f, 1.84692174e-01f, 3.40613753e-01f, -1.49030745e-01f, -1.14477858e-01f, 1.14324667e-01f, 9.43167601e-03f, 4.27670568e-01f, -1.54155135e-01f,
  -2.13952765e-01f, 3.97784680e-01f, -7.00182989e-02f, -9.31398049e-02f, -5.20413322e-03f, -1.56896487e-01f, 6.81522340e-02f, 1.11883603e-01f, 1.01026684e-01f, 1.29881665e-01f,
  9.64027122e-02f, -1.75550237e-01f, -8.21379051e-02f, -1.72737986e-01f, 4.98617515e-02f, 2.17735231e-01f, -2.48487532e-01f, -1.91232972e-02f, -1.21059872e-01f, -3.76725048e-02f,
  -1.27657443e-01f, 1.40055239e-01f, -1.95716247e-02f, 3.53889875e-02f, -3.80428694e-02f, -5.73098660e-02f, 9.06789675e-03f, 3.43185849e-04f, -5.06910449e-03f, 1.00180782e-01f,
  2.58239359e-02f, 1.44459037e-02f, 1.56515725e-02f, 4.54345457e-02f, -2.21401490e-02f, 1.92727335e-02f, 1.11906759e-01f, -2.82340068e-02f, 4.82000858e-02f, 5.73158376e-02f,
  -2.47110240e-02f, -2.76837610e-02f, 1.53108574e-02f, 8.15947354e-02f, 6.31688759e-02f, 3.63064930e-02f, -3.52426395e-02f, 1.50263007e-03f, 5.38121313e-02f, 8.28319192e-02f,
  4.51495945e-02f, -3.91719677e-03f, 2.62682904e-02f, -7.48997182e-02f, 3.73369120e-02f, -7.13534728e-02f, 7.25724921e-02f, -5.78895546e-02f, 1.08397014e-01f, -8.70727561e-03f,
  -7.68559203e-02f, -8.91194493e-03f, -4.91948836e-02f, 2.34380271e-02f, 1.28979981e-02f, 4.94910963e-02f, -1.04320853e-03f, -9.98497754e-03f, 2.67938338e-02f, -2.77075469e-02f,
  -8.78485218e-02f, -3.61597538e-02f, -1.80391688e-02f, -7.15532079e-02f, -5.24267741e-02f, 7.35843107e-02f, 3.13401408e-02f, 7.27590732e-03f, -1.06507330e-03f, -3.07226423e-02f,
  -5.64580709e-02f, 2.37042740e-01f, -4.31097858e-02f, 4.99945832e-03f, 7.76696019e-03f, -1.07453018e-01f, 4.63354439e-02f, 6.89509362e-02f, 2.86338665e-02f, -2.34610047e-02f,
  3.42659689e-02f, 2.30906345e-02f, -2.91048214e-02f, -2.22564600e-02f, -6.38029054e-02f, -3.48211341e-02f, -5.80002442e-02f, 4.09672931e-02f, -4.25832123e-02f, 7.57074505e-02f,
  -3.63706797e-02f, 9.46537256e-02f, 7.90582155e-04f, -4.90460321e-02f, -5.44718355e-02f, 2.70841382e-02f, 1.05026864e-01f, -1.26680071e-02f, -2.88308319e-02f, -2.65795235e-02f,
  -2.85909921e-01f, -2.42675588e-01f, 2.46428195e-02f, 7.76483715e-02f, -3.55075777e-01f, -3.36180963e-02f, 1.52292237e-01f, -3.85679096e-01f, 1.13037340e-01f, -3.74199711e-02f,
  -6.81486130e-02f, 3.04788828e-01f, 1.16036534e-01f, -1.14525691e-01f, 4.76558149e-01f, 3.90007555e-01f, 9.00248215e-02f, 1.28883511e-01f, 1.37513310e-01f, -1.86039135e-01f,
  3.72216441e-02f, -3.08493227e-01f, 4.64616343e-02f, -3.04456800e-01f, -3.92401755e-01f, -1.69633910e-01f, -1.45633459e-01f, 9.57147276e-04f, -1.32755339e-01f, 1.27266556e-01f,
  1.04152814e-01f, -8.01509619e-02f, -2.30550654e-02f, 6.57672584e-02f, -9.80910361e-02f, 5.12629980e-03f, 6.10947944e-02f, 1.13074686e-02f, 1.09079123e-01f, 2.37081051e-02f,
  6.60764948e-02f, -2.04381682e-02f, -5.10235019e-02f, 2.05301009e-02f, -1.33530915e-01f, 3.45169045e-02f, -3.05932835e-02f, 4.62251203e-03f, 2.88014859e-02f, -1.14676438e-01f,
  1.85345151e-02f, 2.95388941e-02f, 5.06870188e-02f, 2.90787425e-02f, 1.44127989e-02f, 4.72456813e-02f, 1.41187027e-01f, -1.51391737e-02f, -1.61407366e-02f, -6.08140975e-02f,
  -1.16441630e-01f, -2.68192776e-02f, 7.45160952e-02f, 1.03869408e-01f, -4.05144272e-03f, 1.50086274e-02f, 4.70391177e-02f, 5.38073182e-02f, 5.95022142e-02f, 9.26443748e-03f,
  5.28831733e-03f, -5.49641624e-02f, -9.86417662e-03f, -5.79712726e-02f, 3.75082642e-02f, -1.97923910e-02f, 3.30944546e-02f, -3.24601419e-02f, -1.64756089e-01f, -1.53432693e-02f,
  7.39460289e-02f, -1.69161391e-02f, -2.36721039e-02f, -1.25342663e-02f, 2.55913436e-02f, -3.72064374e-02f, -6.23214729e-02f, -7.53687471e-02f, 2.67300941e-02f, 2.39840988e-02f,
  3.64375226e-02f, -1.25890493e-01f, 4.03480753e-02f, 2.24026982e-02f, 9.51237231e-02f, 6.13942482e-02f, 1.17819846e-01f, -6.13212362e-02f, -3.56291570e-02f, -1.98577195e-02f,
  -8.82038251e-02f, 3.77190299e-02f, -3.48596461e-02f, -2.71710623e-02f, 1.07095189e-01f, -8.12639892e-02f, 1.36760278e-02f, 1.17329374e-01f, 6.98930100e-02f, -1.00041859e-01f,
  -1.45352453e-01f, -4.06426713e-02f, 4.98906635e-02f, -5.40273041e-02f, -8.49550739e-02f, -1.49862580e-02f, -4.00862806e-02f, -1.12746013e-02f, 2.78085880e-02f, 1.25728533e-01f,
  3.01176965e-01f, -7.50847340e-01f, 9.65842307e-02f, -2.29072556e-01f, -1.04212470e-01f, -4.21815425e-01f, -2.89224554e-02f, -2.23122418e-01f, -2.78146684e-01f, -5.47751114e-02f,
  7.86427855e-02f, 1.04926296e-01f, 4.05378379e-02f, -2.18518704e-01f, 1.56067848e-01f, -8.72030184e-02f, -3.54763627e-01f, 4.14288081e-02f, -2.55885452e-01f, 3.26570421e-02f,
  -1.07840650e-01f, -6.76378328e-03f, 1.09321274e-01f, 1.40814967e-02f, -8.04978162e-02f, 7.61690289e-02f, 2.09614411e-01f, 5.55917481e-03f, 9.47138667e-02f, -9.02958959e-02f,
  -6.33611158e-02f, 1.01390027e-01f, 5.23129962e-02f, 2.93011907e-02f, 2.63201781e-02f, 1.16650924e-01f, 1.33534754e-02f, 1.06746435e-01f, 1.49248958e-01f, -5.77582419e-02f,
  -4.13286947e-02f, 5.44578172e-02f, 1.73289934e-03f, -3.39246332e-03f, -1.09610751e-01f, 6.25648871e-02f, -1.20400086e-01f, -1.03946164e-01f, -2.67318506e-02f, 3.46644334e-02f,
  -7.67342225e-02f, -1.33382916e-01f, -6.76130354e-02f, -1.32165682e-02f, 5.32045960e-02f, -5.40341921e-02f, -1.33693228e-02f, 5.88063076e-02f, -1.58769459e-01f, -3.93127762e-02f,
  -1.32924160e-02f, -8.03785771e-02f, 7.24132285e-02f, 4.60841088e-03f, -6.37898296e-02f, -2.93449406e-03f, -5.16953059e-02f, 4.10702340e-02f, -2.79896483e-02f, -3.41698453e-02f,
  8.75660963e-03f, 7.22539751e-03f, -9.41215679e-02f, 1.13339638e-02f, -7.06032151e-03f, 8.62540118e-03f, 2.96176989e-02f, -3.75095867e-02f, 3.69538320e-03f, -3.68548557e-02f,
  -1.76641904e-02f, -5.04113659e-02f, 5.65067157e-02f, 4.22657002e-03f, -8.24088156e-02f, 4.41049002e-02f, -2.06575468e-02f, -3.55647318e-02f, 9.20809619e-03f, -6.77627185e-03f,
  -9.41792056e-02f, -6.85169548e-02f, 6.24846034e-02f, 5.99388173e-03f, -5.50334640e-02f, -6.55877590e-02f, -4.12897430e-02f, -8.99184030e-03f, -4.23954092e-02f, -3.58180515e-02f,
  9.64337885e-02f, 4.16970067e-02f, -2.14586034e-03f, -4.23751175e-02f, 5.99841401e-03f, 1.05321780e-02f, 1.41396755e-02f, 2.13021366e-03f, 7.97843281e-03f, -2.09886264e-02f,
  5.94066456e-02f, 5.79548590e-02f, 3.66293341e-02f, 7.64344446e-03f, 4.16151807e-03f, 1.06135815e-01f, -2.40988079e-02f, -2.72522923e-02f, 4.23316732e-02f, 1.84464757e-03f,
  -1.83242202e-01f, 3.36635590e-01f, 1.89695761e-01f, -4.06425387e-01f, 1.41806170e-01f, 5.82375936e-02f, -1.60239920e-01f, 1.83819816e-01f, -2.70197779e-01f, 2.61410233e-02f,
  -2.58476704e-01f, -4.44712974e-02f, 5.69037795e-02f, -2.84617364e-01f, -4.46487665e-01f, -1.94277108e-01f, -3.32329601e-01f, -1.67232454e-01f, 6.04011258e-03f, -1.74863189e-02f,
  -8.61027390e-02f, -1.82521582e-01f, 7.57366419e-02f, 2.05763906e-01f, 1.66462168e-01f, 3.02123994e-01f, -5.74779138e-02f, 2.52254367e-01f, -2.80622952e-02f, 1.07792327e-02f,
  -6.79463670e-02f, 1.29009169e-02f, 1.07351400e-01f, -2.02986542e-02f, -2.76605133e-02f, 1.64161006e-03f, 6.08721888e-03f, -1.48449857e-02f, -1.55838747e-02f, 5.18287793e-02f,
  -2.37656198e-02f, 5.90010034e-03f, -6.30417168e-02f, -1.12473248e-02f, 3.08761708e-02f, -1.11119989e-02f, 4.69651520e-02f, 5.76895475e-02f, 6.93403631e-02f, 3.29984762e-02f,
  -1.53613342e-02f, -1.74989067e-02f, -5.38137406e-02f, -7.90557042e-02f, 3.67236920e-02f, -7.37363324e-02f, -4.59191613e-02f, 5.91098405e-02f, 2.84411851e-02f, -4.49805036e-02f,
  2.56079566e-02f, -9.38306972e-02f, 5.82714714e-02f, -1.27613656e-02f, -2.19804142e-02f, 6.19630888e-02f, -4.38367911e-02f, 3.14058326e-02f, 1.49553483e-02f, 2.58031674e-02f,
  -3.07600964e-02f, -4.30334732e-03f, -2.23341957e-02f, -5.08550070e-02f, -3.45062204e-02f, 4.52276953e-02f, 8.15951359e-03f, 3.56951058e-02f, -8.35440122e-03f, 5.76855280e-02f,
  -7.14983642e-02f, -7.77770802e-02f, 7.90622160e-02f, 4.39622477e-02f, -5.84001653e-02f, -5.66314720e-02f, 1.06288232e-02f, 6.46195114e-02f, -1.80458967e-02f, -2.01822771e-03f,
  -5.96095584e-02f, 6.89430684e-02f, 6.17680047e-03f, -7.30334781e-03f, -4.39524651e-02f, 4.65460010e-02f, -8.56336877e-02f, 7.56445006e-02f, 1.53091457e-02f, -3.89713272e-02f,
  -5.23867197e-02f, -1.14776031e-03f, 7.53322840e-02f, -1.90977026e-02f, -3.55274566e-02f, 5.36488108e-02f, -1.22917503e-01f, -4.07285988e-02f, -2.39279084e-02f, 2.47938652e-02f,
  -2.59126723e-02f, -5.68541400e-02f, -8.77639651e-02f, 8.70095268e-02f, -2.16643382e-02f, 5.05071692e-03f, 7.26904944e-02f, -3.96673717e-02f, -7.29050627e-03f, -8.17623809e-02f,
  3.39662135e-02f, -9.28077474e-02f, 3.61614257e-01f, -7.12306798e-02f, 1.63655236e-01f, 2.27550715e-01f, 6.52350038e-02f, 1.01072967e-01f, -2.85578758e-01f, -3.07928741e-01f,
  -1.63843930e-01f, 5.21348082e-02f, -1.26581371e-01f, 7.99557716e-02f, 1.37797505e-01f, -1.48166493e-01f, -1.49074420e-01f, -1.45004585e-01f, -9.16116114e-04f, 9.96040851e-02f,
  -1.87379047e-02f, -1.61472127e-01f, 1.43233985e-01f, 4.47342955e-02f, 2.58398801e-01f, 7.13983737e-03f, -2.03242227e-01f, 9.85387713e-02f, 1.08423255e-01f, 5.87090626e-02f,
  1.71936110e-01f, -1.39178783e-01f, -5.90667361e-03f, 1.37063563e-02f, 5.29135466e-02f, 1.58955362e-02f, 2.29857359e-02f, -3.26379798e-02f, 6.76493123e-02f, 5.55947982e-02f,
  2.07687840e-02f, 2.42272578e-02f, 7.85947442e-02f, -2.74305195e-02f, -4.93465411e-03f, 1.73604432e-02f, 8.99993703e-02f, 1.81275830e-02f, 1.40635101e-02f, 1.63100272e-01f,
  2.80563086e-02f, 1.09740965e-01f, 4.90575582e-02f, 6.61198050e-02f, 2.22598538e-02f, 5.19092269e-02f, -3.40098925e-02f, 2.14228965e-02f, 7.10086944e-03f, 5.89689165e-02f,
  2.00356096e-02f, -2.64261365e-02f, 2.70379707e-02f, 4.80323620e-02f, -4.56221662e-02f, 8.92273039e-02f, -3.21713299e-03f, 4.94778249e-03f, -8.73052399e-04f, -4.04494740e-02f,
  8.43200758e-02f, 2.92948838e-02f, -3.45679745e-02f, -5.19176759e-02f, -8.40540528e-02f, -7.87775069e-02f, -6.10284321e-02f, 3.24601904e-02f, -3.30029242e-02f, -2.14532726e-02f,
  -1.28695695e-02f, 1.02615459e-02f, 1.87311508e-02f, -1.60792768e-02f, 3.89440334e-04f, -7.28598461e-02f, 3.48887406e-02f, 3.41287106e-02f, 5.07855192e-02f, 5.60330078e-02f,
  -3.58210683e-01f, -3.23177099e-01f, -4.72906753e-02f, 2.55217124e-02f, -2.45616939e-02f, -2.02758033e-02f, -4.56632227e-02f, -1.67652760e-02f, -9.15998444e-02f, -3.93683761e-02f,
  1.87143181e-02f, -2.29025912e-03f, -4.22669202e-02f, -3.04740202e-02f, -2.54014805e-02f, 8.83772597e-03f, -5.33493869e-02f, -1.73975199e-01f, -1.28666982e-01f, 6.15313128e-02f,
  -7.23924935e-02f, -4.16215919e-02f, 1.45604908e-01f, 1.70849338e-02f, -6.02030642e-02f, -9.71519295e-03f, -5.35283722e-02f, 2.77452334e-03f, 7.73561969e-02f, 3.64434309e-02f,
  -9.86384898e-02f, 1.02574676e-02f, -2.16801018e-02f, -6.49654120e-02f, -1.76693305e-01f, 1.91678360e-01f, 7.47084897e-03f, -5.03323898e-02f, -3.33866805e-01f, 3.25679988e-01f,
  3.88917886e-02f, 8.31311643e-02f, -2.42576435e-01f, 3.34366828e-01f, -3.93979639e-01f, -3.12284976e-01f, 1.82805374e-01f, 1.79031968e-01f, -9.00050253e-02f, -1.12451605e-01f,
  -1.16608612e-01f, -2.38757376e-02f, -1.12486705e-01f, 4.28454839e-02f, -1.11492686e-02f, 2.21408471e-01f, -6.42656162e-02f, -1.13515854e-01f, 3.31033707e-01f, 1.41828373e-01f,
  1.59683287e-01f, -1.22382522e-01f, 1.74023826e-02f, 7.91801885e-02f, -5.32590300e-02f, 5.85043319e-02f, 2.10970849e-01f, 6.16998412e-02f, -3.72564197e-02f, 4.18981314e-02f,
  5.20603545e-02f, -5.79739688e-03f, -1.39996782e-02f, -5.60416095e-02f, 7.60877505e-02f, 8.59700702e-03f, -5.25044426e-02f, 1.03625260e-01f, -1.01299621e-01f, -2.80702356e-02f,
  -1.02766767e-01f, 6.02454506e-02f, 1.04581844e-02f, 1.26469731e-01f, -1.35970458e-01f, 3.27426866e-02f, 1.81983877e-02f, 2.09508203e-02f, 5.34028839e-03f, 1.12850992e-02f,
  -6.26341328e-02f, 1.09237991e-01f, -1.41961128e-02f, 7.19588399e-02f, -1.38682395e-01f, -2.78609134e-02f, 3.20830904e-02f, -7.94583000e-03f, 1.63798630e-02f, -7.06010535e-02f,
  7.69521743e-02f, -5.19453287e-02f, 5.35443202e-02f, -2.47543165e-03f, -8.72426778e-02f, 1.73721779e-02f, 1.76247340e-02f, 2.90903915e-02f, 1.72713269e-02f, -5.64670414e-02f,
  5.83840460e-02f, -2.07828879e-02f, -3.03043257e-02f, 7.42389774e-03f, 9.63901915e-03f, -1.86495874e-02f, 3.54548395e-02f, 4.42761034e-02f, -7.18196575e-03f, -6.36243001e-02f,
  -5.17643094e-02f, -2.06493765e-01f, -1.44964948e-01f, 7.16430647e-03f, 2.14708429e-02f, -1.56260952e-02f, -5.47692785e-03f, -7.13337511e-02f, -2.70307120e-02f, -1.53806761e-01f,
  4.22931761e-02f, -6.87685749e-03f, 1.56255484e-01f, 1.56350564e-02f, -4.43447102e-03f, -2.38149129e-02f, 4.08584140e-02f, 7.36608729e-02f, -2.54845731e-02f, -7.17689935e-03f,
  7.18150213e-02f, 4.02394459e-02f, -1.41748879e-02f, -3.55329216e-02f, 7.93079585e-02f, 1.32904563e-03f, 5.59371896e-03f, 6.13555796e-02f, 7.89136533e-03f, -1.03781084e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.28430247e-01f, -2.85319269e-01f, -4.93164867e-01f, -1.06064968e-01f, -5.20459600e-02f, 1.61643028e-01f, -4.26089585e-01f, -1.03222981e-01f, -4.74561423e-01f, -2.32574031e-01f,
  -7.10299611e-02f, -2.80789547e-02f, -3.84450257e-01f, 4.67202455e-01f, 4.74193633e-01f, 2.17380136e-01f, 3.92438084e-01f, 1.68516219e-01f, 2.77112901e-01f, -1.69606894e-01f,
  2.27164075e-01f, 4.20745105e-01f, 3.72928351e-01f, 4.67254609e-01f, 1.35481566e-01f, 2.00745359e-01f, 1.81249350e-01f, 3.30732726e-02f, 3.63510370e-01f, 2.76304603e-01f,
  -1.45274982e-01f, -3.85626078e-01f, -2.02828541e-01f, -1.38255596e-01f, -1.26413032e-01f, -1.42986506e-01f, -1.07039236e-01f, 3.68859768e-02f, -6.60642236e-02f, 3.38915400e-02f,
  -1.29750431e-01f, 6.58006817e-02f, 1.59253031e-01f, 8.31030309e-02f, -1.73320904e-01f, -5.05901836e-02f, 8.18389580e-02f, -7.17393830e-02f, -3.87536101e-02f, 3.91787738e-02f,
  -5.79175688e-02f, 1.68795913e-01f, -6.70593753e-02f, 1.20729849e-01f, -1.55256297e-02f, -3.91460285e-02f, 6.22771047e-02f, -3.69605459e-02f, 8.04741383e-02f, -4.16426398e-02f,
  4.91621010e-02f, -1.59578826e-02f, 1.49647864e-02f, 3.98012474e-02f, -9.69322696e-02f, 2.89771929e-02f, 1.01247318e-01f, 9.92507488e-02f, 4.33776975e-02f, -2.36890763e-02f,
  -1.17869861e-02f, -2.44447831e-02f, -1.11103170e-01f, -1.23877600e-01f, -3.20974016e-03f, 2.48361938e-03f, 7.14433612e-03f, -2.02535838e-02f, -2.71026827e-02f, 1.49404779e-01f,
  -6.84904680e-02f, 3.29184197e-02f, -2.20765043e-02f, 4.57067974e-02f, -1.95474643e-02f, -4.44016047e-02f, 1.04018524e-02f, -4.93276976e-02f, -4.06899750e-02f, 2.65781768e-02f,
  -4.34184402e-01f, -3.46171856e-01f, -3.68889831e-02f, 2.20211688e-03f, 1.83760542e-02f, 2.11675139e-03f, 6.05555698e-02f, 1.64478496e-01f, -7.26775452e-02f, -6.27728254e-02f,
  -7.16178417e-02f, -3.36766280e-02f, -7.70832971e-02f, 1.74430665e-02f, 2.02772230e-01f, -2.17444450e-01f, -4.01789695e-02f, -1.22185051e-02f, -4.62568924e-03f, 7.93211386e-02f,
  -6.20563217e-02f, -1.16129011e-01f, 1.34549722e-01f, 1.93234682e-01f, -4.44689253e-03f, -5.18648140e-02f, -4.71720882e-02f, 3.60334739e-02f, 1.77268296e-01f, 7.76748508e-02f,
  2.22141057e-01f, -2.16614872e-01f, -2.06138790e-01f, -3.95711303e-01f, -3.34739655e-01f, 1.50575444e-01f, -6.02069050e-02f, -1.69431776e-01f, -3.47233772e-01f, 2.33613364e-02f,
  -3.17273200e-01f, 1.58769503e-01f, 3.69884014e-01f, -4.44853991e-01f, 5.22992909e-01f, 3.51754665e-01f, -1.91215202e-01f, -2.48356890e-02f, -2.05733761e-01f, -7.65070021e-02f,
  -1.50993019e-01f, -2.28510588e-01f, -5.95113225e-02f, -2.38092393e-01f, -4.38863963e-01f, -2.55218476e-01f, -9.48852524e-02f, -2.51351267e-01f, -5.25412083e-01f, -2.27251872e-01f,
  -5.54504767e-02f, -1.59837484e-01f, -4.40984555e-02f, 1.23663127e-01f, -7.14898575e-04f, 4.13879156e-02f, 7.97823817e-02f, 9.25442278e-02f, -5.07434644e-02f, 5.77679835e-02f,
  9.30918194e-03f, 6.79792166e-02f, -1.07155457e-01f, 1.72165275e-01f, -1.16069086e-01f, -1.85798839e-01f, -8.67556110e-02f, -2.39753649e-02f, 4.54279315e-03f, 6.19280748e-02f,
  -7.71926865e-02f, 6.69293255e-02f, -1.12294532e-01f, -3.39491083e-03f, -1.52778938e-01f, -1.23614259e-01f, 2.05345735e-01f, 1.30812198e-01f, -1.38425352e-02f, 4.19210829e-02f,
  -2.19958369e-02f, 1.50265992e-01f, 9.17594731e-02f, -1.07722297e-01f, 4.79304120e-02f, -1.10716023e-01f, 4.71420586e-02f, -5.95806800e-02f, -3.27171944e-02f, -1.56871614e-03f,
  -1.50936291e-01f, -2.67811934e-03f, -4.67094705e-02f, 1.31026283e-01f, 2.16458309e-02f, 1.05364889e-01f, 1.21228002e-01f, 1.11479107e-02f, -8.68188441e-02f, -6.57959701e-03f,
  -8.77524391e-02f, 3.11810076e-02f, -8.55865553e-02f, -6.73484504e-02f, 1.24756575e-01f, 7.14859813e-02f, -1.49238050e-01f, -2.16529630e-02f, 6.98381439e-02f, 2.14094102e-01f,
  -6.19456507e-02f, 1.59377421e-04f, -1.01312220e-01f, 5.11569567e-02f, 8.01143274e-02f, 9.02940780e-02f, -3.79313231e-02f, -1.56915247e-01f, -4.08639275e-02f, 3.88969891e-02f,
  3.30997072e-02f, -1.13106389e-02f, -4.40667756e-02f, 1.60344020e-02f, -1.45956632e-02f, 5.96808130e-03f, -3.45763750e-02f, 2.58785468e-02f, 3.55990231e-02f, 1.83166855e-03f,
  -2.27817032e-03f, 1.09862164e-01f, 1.41353816e-01f, 2.67026052e-02f, 1.25254132e-02f, 1.10672072e-01f, 9.48381945e-02f, 4.02828492e-02f, -7.87969828e-02f, -8.42548832e-02f,
  -7.67463267e-01f, 1.88399330e-01f, 1.76199824e-02f, -6.92633510e-01f, 2.69259840e-01f, 3.68825972e-01f, -1.38477370e-01f, 3.26491714e-01f, -2.95956910e-01f, 2.49420628e-01f,
  8.01744238e-02f, -4.58502263e-01f, 1.93581894e-01f, -3.68952513e-01f, -4.95299548e-01f, -2.84571320e-01f, -4.82133180e-01f, -3.35648149e-01f, -2.08911166e-01f, -2.34058455e-01f,
  -2.61282623e-01f, -1.15310110e-01f, -1.32813692e-01f, 4.28104043e-01f, 5.02256118e-02f, -9.59377550e-03f, 1.65287450e-01f, 3.62843990e-01f, 3.26007195e-02f, 1.20254494e-01f,
  1.06100887e-02f, -2.92869918e-02f, 4.60611768e-02f, 5.73752262e-02f, 5.88084683e-02f, 5.54500818e-02f, -7.99094979e-03f, 4.89098653e-02f, -2.65540369e-02f, -1.24244191e-01f,
  -7.95650259e-02f, -3.18684541e-02f, -1.30356446e-01f, 3.14233638e-02f, 3.69709171e-02f, 6.39523342e-02f, 1.34236179e-02f, 3.78965288e-02f, 1.42727450e-01f, -8.84305984e-02f,
  -1.15746863e-01f, -1.09317638e-01f, -6.02554604e-02f, -1.99157253e-01f, -4.49593216e-02f, 7.38555938e-02f, -7.36392736e-02f, 1.14336520e-01f, -1.92191079e-02f, -5.95835969e-02f,
  -6.23396412e-02f, -2.82361843e-02f, 5.31079993e-02f, 7.17770606e-02f, -1.07925078e-02f, 5.49231470e-02f, -1.04903392e-01f, -5.18251508e-02f, -4.55060303e-02f, 4.62465268e-03f,
  -3.03407256e-02f, -4.33554724e-02f, -1.24245500e-02f, -2.21990831e-02f, -5.59901334e-02f, -6.08869419e-02f, -3.39727476e-02f, -3.73337343e-02f, -1.02789260e-01f, 4.20034043e-02f,
  -4.55608293e-02f, -9.90426466e-02f, 2.18537692e-02f, -5.72760170e-03f, 5.56509336e-03f, -1.30351055e-02f, -4.65268828e-02f, 6.88244179e-02f, -1.39307417e-03f, 4.79463208e-03f,
  1.57058835e-01f, 6.84151351e-02f, 5.49989305e-02f, 7.03467280e-02f, -7.49517325e-03f, 6.31804839e-02f, -8.81256885e-04f, 1.19473003e-02f, -4.80335718e-03f, 5.62982596e-02f,
  4.45633158e-02f, 5.65352477e-03f, -2.23023221e-02f, -7.59305358e-02f, -4.12000678e-02f, 1.57920688e-01f, -1.04380347e-01f, -1.01324506e-02f, 1.14347115e-01f, 9.55545902e-02f,
  1.17854133e-01f, 3.18381898e-02f, -1.13571435e-01f, 7.22736167e-03f, -5.67482710e-02f, 4.44109971e-03f, 4.71114814e-02f, -9.83098173e-04f, -1.94492820e-03f, -5.53857628e-03f,
  -8.67684841e-01f, 4.76135045e-01f, 1.05380937e-01f, 9.08240974e-02f, -2.93855220e-01f, -2.69009054e-01f, 1.49397284e-01f, -1.68359995e-01f, -7.14323446e-02f, 4.52266008e-01f,
  1.45015374e-01f, -1.10696800e-01f, 1.25737011e-01f, 3.13191533e-01f, -6.54934525e-01f, 1.33052856e-01f, 1.02737367e-01f, 3.38819996e-02f, -1.49913296e-01f, -1.71279564e-01f,
  -2.04413101e-01f, -1.53823897e-01f, 1.17862985e-01f, 1.06636785e-01f, 1.13270804e-01f, 6.29509911e-02f, 2.12532744e-01f, -8.43477622e-02f, 2.52646714e-01f, -1.46607623e-01f,
  -2.72867411e-01f, -2.08937302e-01f, 1.10344537e-01f, -5.14401086e-02f, -7.72327259e-02f, 5.60283661e-02f, 5.29525578e-02f, -4.52868044e-02f, -5.61224297e-02f, -1.38719395e-01f,
  -1.73096377e-02f, -1.27764598e-01f, -1.88666135e-02f, -6.20348305e-02f, -1.06885090e-01f, -2.92529259e-02f, 3.92150991e-02f, 1.28201395e-01f, 2.89614182e-02f, -3.03193345e-03f,
  9.29138660e-02f, 3.22845839e-02f, 1.19209394e-01f, 1.07953794e-01f, -3.82729387e-03f, -1.29227079e-02f, 1.00828260e-01f, 1.57233756e-02f, -1.83275193e-02f, -6.62442818e-02f,
  -6.85065836e-02f, -2.08768453e-02f, 1.08585618e-01f, -1.01440921e-01f, 2.91401800e-03f, 1.00565806e-01f, 6.08766451e-02f, -3.92310955e-02f, -1.26987584e-02f, -4.58976179e-02f,
  -1.22110330e-01f, -4.11561057e-02f, -4.47318628e-02f, 7.50285313e-02f, 4.13777977e-02f, -2.04899646e-02f, 7.79609904e-02f, -1.54574633e-01f, 2.98634879e-02f, -9.63854231e-03f,
  -7.11993352e-02f, -1.11248776e-01f, -2.90976707e-02f, 5.49823903e-02f, 3.95808485e-04f, -4.07644510e-02f, -2.69209947e-02f, 5.58339730e-02f, 2.36131568e-02f, -8.45456645e-02f,
  -6.24571800e-01f, -4.64821398e-01f, -1.49555458e-02f, -1.39399529e-01f, 7.73524642e-02f, -4.79662828e-02f, -5.44963442e-02f, -3.34759429e-02f, -1.20424271e-01f, -1.10681884e-01f,
  -6.22369722e-02f, 1.62255943e-01f, -4.77152616e-02f, -6.04633950e-02f, -5.30272238e-02f, -4.06585783e-02f, -3.12619843e-02f, -3.65063846e-02f, -3.59107181e-02f, -9.65672806e-02f,
  9.09992605e-02f, 2.49381457e-02f, 8.34883526e-02f, 3.48507427e-02f, -1.02442652e-02f, -1.51354484e-02f, -1.28962889e-01f, 2.83053666e-02f, -5.45613840e-02f, 1.84789803e-02f,
  2.73730487e-01f, 5.02160728e-01f, 6.38868451e-01f, 6.01933777e-01f, -4.52671826e-01f, -5.12933850e-01f, 5.06726354e-02f, -4.66045104e-02f, -6.55417889e-02f, -7.42527246e-02f,
  -1.63846642e-01f, 5.42329669e-01f, 1.42172068e-01f, 2.29495704e-01f, 9.67759490e-02f, -9.66832265e-02f, 1.07146122e-01f, 1.49412518e-02f, -6.88576745e-03f, 2.35679522e-01f,
  -2.82598268e-02f, -4.10138816e-01f, 4.17056680e-01f, -2.26547271e-01f, 3.44812930e-01f, 4.69831228e-01f, 9.82058495e-02f, 2.17960000e-01f, 3.52935731e-01f, 1.07540235e-01f,
  -1.32837415e-01f, 1.02873318e-01f, 1.21347040e-01f, 3.22025828e-02f, 2.16726400e-02f, -7.26593584e-02f, 9.17444825e-02f, 8.42855051e-02f, 6.07268065e-02f, -2.00529099e-02f,
  4.23997156e-02f, -7.76797310e-02f, 7.09609538e-02f, 4.21967693e-02f, -1.25796258e-01f, 8.10623448e-03f, 3.35540436e-02f, -1.97102455e-03f, 6.40565157e-02f, 9.78246778e-02f,
  1.13226287e-01f, 6.35279343e-02f, 7.41306767e-02f, 1.51946634e-01f, 1.74533233e-01f, -6.71471432e-02f, 5.51285967e-02f, 1.87359437e-01f, 2.58551296e-02f, -5.48928790e-02f,
  -2.73514576e-02f, -8.67340714e-02f, -7.45201409e-02f, -8.16021785e-02f, -2.73840427e-02f, -7.28843212e-02f, 4.55440506e-02f, -5.84158003e-02f, 3.73568758e-02f, -2.47734729e-02f,
  -5.80960028e-02f, 7.80248791e-02f, -9.98973548e-02f, -2.58278828e-02f, -4.31421679e-03f, -1.20284162e-01f, -1.78526342e-02f, 1.20462507e-01f, 1.00165252e-02f, -4.19973955e-02f,
  2.07209326e-02f, -9.09258202e-02f, 9.89295989e-02f, -2.73881089e-02f, -1.84522361e-01f, -1.90432556e-02f, 7.79101104e-02f, 4.39194217e-02f, -2.83576436e-02f, 5.87252975e-02f,
  7.21013471e-02f, 4.88158882e-01f, 1.08092673e-01f, -8.14152285e-02f, 2.85841580e-02f, 1.13394363e-02f, 4.08043750e-02f, 1.45266876e-01f, 2.77698874e-01f, -3.62363942e-02f,
  -7.70974606e-02f, 2.53881351e-03f, 9.82421357e-03f, -3.00599374e-02f, 8.42504427e-02f, 7.40701184e-02f, 7.15317056e-02f, 3.39705795e-02f, 7.70378038e-02f, 6.66926876e-02f,
  4.49210741e-02f, -2.85053216e-02f, 5.11553697e-02f, -6.02984568e-03f, -3.61707695e-02f, 7.10749254e-02f, -5.47647662e-02f, 6.56669810e-02f, 9.61260647e-02f, 8.62517580e-02f,
  -2.08451882e-01f, 3.49118114e-01f, -1.64696649e-01f, -1.66646183e-01f, 1.02108546e-01f, -6.29991651e-01f, -2.11225942e-01f, -1.02806978e-01f, -1.04229309e-01f, 3.77197146e-01f,
  -1.78989634e-01f, 2.71400720e-01f, 3.75197940e-02f, -3.91322196e-01f, -8.01489711e-01f, -5.14248073e-01f, -4.35047209e-01f, -1.51319325e-01f, -5.78735396e-02f, 2.26092730e-02f,
  -1.16342761e-01f, -1.12485521e-01f, -2.51395941e-01f, 3.30071062e-01f, 1.47184610e-01f, 4.60715294e-01f, 2.47691423e-01f, 2.06044063e-01f, 1.24698475e-01f, -2.43514106e-02f,
  -2.48485595e-01f, 7.87442774e-02f, 9.73896459e-02f, -6.58045262e-02f, -6.16902523e-02f, 6.80863112e-02f, 3.53783481e-02f, 7.43900519e-03f, -6.08102307e-02f, -1.02081252e-02f,
  1.19789101e-01f, -5.07614501e-02f, -2.20655780e-02f, 7.32510239e-02f, 8.04257691e-02f, 5.69501966e-02f, -5.78134060e-02f, 1.40118646e-02f, 1.66306142e-02f, -1.13766491e-01f,
  -1.35726398e-02f, -2.35161721e-03f, 3.72273615e-03f, 5.11245281e-02f, -8.51840824e-02f, 5.77869378e-02f, -3.88059579e-02f, 4.24020402e-02f, 1.61879286e-02f, 3.50764836e-04f,
  -4.00712859e-04f, 7.58891627e-02f, -5.25897294e-02f, 6.05421737e-02f, -1.14208452e-01f, -1.09025780e-02f, 9.09855776e-03f, -1.99778657e-02f, 5.68347163e-02f, -1.11650759e-02f,
  5.81358112e-02f, 3.73540595e-02f, 2.00602524e-02f, -2.60685813e-02f, -1.38388211e-02f, 3.86041813e-02f, 3.86563651e-02f, 9.57556590e-02f, -1.10368796e-01f, -4.81594428e-02f,
  8.94747153e-02f, -3.11749429e-02f, 6.44979700e-02f, 3.62672321e-02f, -5.85833341e-02f, 4.35524397e-02f, 5.96030280e-02f, -8.61680508e-02f, 2.47804169e-02f, 2.66281404e-02f,
  -1.03402950e-01f, 2.03404605e-01f, 6.91349283e-02f, 1.13929547e-01f, 7.95188323e-02f, 1.11997789e-02f, -1.50052801e-01f, -4.23321165e-02f, -7.50703365e-02f, -6.16713054e-02f,
  9.84367058e-02f, 5.00835516e-02f, 1.53847598e-02f, -2.45348364e-03f, -4.87211831e-02f, -7.35395551e-02f, 4.52402681e-02f, 1.68483496e-01f, 5.76950163e-02f, 4.90260869e-02f,
  1.62179008e-01f, 1.47576109e-01f, 8.67307931e-02f, 1.13551669e-01f, 6.52847067e-02f, 7.88656920e-02f, 1.19283780e-01f, -3.98917422e-02f, 1.54240225e-02f, 4.16124649e-02f,
  1.80159926e-01f, -5.78676999e-01f, -3.58532965e-01f, -1.56830698e-01f, 2.98826158e-01f, -1.85898274e-01f, 8.69539157e-02f, -3.02050918e-01f, -1.69080477e-02f, -3.16737354e-01f,
  1.02803938e-01f, -1.19517870e-01f, 1.65058538e-01f, -4.77963984e-01f, -8.59561085e-04f, -4.97447932e-03f, -3.69511813e-01f, -1.05093777e-01f, 1.54299997e-02f, 3.28704678e-02f,
  -3.95480618e-02f, -2.83009738e-01f, -1.97216585e-01f, -3.37747216e-01f, -6.97977915e-02f, -4.11088653e-02f, 3.59091192e-01f, 1.91408664e-01f, -3.62407774e-01f, 1.40798205e-04f,
  -1.45315602e-01f, -2.37174124e-01f, -1.23173483e-01f, -1.68671414e-01f, -1.13285268e-02f, 1.37021944e-01f, 1.22646131e-01f, 5.28231412e-02f, 4.51748297e-02f, -2.53044385e-02f,
  1.60250008e-01f, 1.02698632e-01f, -1.93529323e-01f, -9.71097406e-03f, -7.51550822e-03f, -1.88061580e-01f, -2.22241264e-02f, -2.18826663e-02f, -3.23766768e-02f, -6.61012828e-02f,
  -5.98834120e-02f, 5.72881736e-02f, 9.96271670e-02f, -2.30295192e-02f, 6.62641972e-02f, -6.49112985e-02f, -3.66865396e-02f, 2.88638379e-02f, 8.61904919e-02f, 2.47208402e-03f,
  -3.22587155e-02f, 1.32453263e-01f, 2.51820739e-02f, -1.07815892e-01f, -3.36706303e-02f, -3.48377824e-02f, 1.00904312e-02f, 3.15343142e-02f, 1.28132969e-01f, 4.00814973e-02f,
  4.21111435e-02f, -1.38695268e-02f, -8.69344324e-02f, 4.54777405e-02f, -6.91228220e-03f, -2.96271667e-02f, 9.82662588e-02f, 9.48837399e-02f, 7.76086748e-02f, 2.96387803e-02f,
  -6.10401928e-02f, -1.55968796e-02f, -1.52258612e-02f, 7.05354735e-02f, -1.53824136e-01f, 3.11266147e-02f, -2.01090127e-02f, 4.36752588e-02f, 5.27135059e-02f, 1.22520976e-01f,
  6.48007914e-02f, -1.09676704e-01f, -1.37246370e-01f, -1.04576081e-01f, -6.84619397e-02f, -1.73905529e-02f, -7.88905099e-02f, -1.16526656e-01f, -6.19372353e-02f, -4.99878498e-03f,
  -3.69613841e-02f, 1.31591097e-01f, 1.00104399e-01f, -1.79854361e-03f, -6.50559366e-02f, -5.90599589e-02f, 1.06196843e-01f, -1.21011736e-03f, 7.14148208e-02f, -4.51661460e-03f,
  1.16572745e-01f, 1.21693209e-01f, -2.32476220e-02f, 1.69785193e-03f, -6.51078299e-02f, 1.71543464e-01f, 9.79942977e-02f, -4.88877334e-02f, 1.10565998e-01f, 4.22786130e-03f,
  -6.71491861e-01f, 6.18420780e-01f, -1.20988965e-01f, -2.89420605e-01f, -1.16260320e-01f, -3.37162405e-01f, -2.96563625e-01f, 1.00152768e-01f, 4.63537909e-02f, 1.20792419e-01f,
  -5.42008765e-02f, 6.28295215e-03f, 3.08409184e-01f, 1.29746785e-02f, -2.50037670e-01f, 3.39644819e-01f, -3.99098933e-01f, -1.87730730e-01f, 1.76617593e-01f, -2.15989619e-01f,
  -8.44119638e-02f, -1.34034202e-01f, -2.76216567e-02f, 9.23899412e-02f, -2.34547839e-01f, -8.34508166e-02f, -2.21412137e-01f, 3.41927633e-03f, -2.44909972e-01f, -1.77819375e-02f,
  -4.11859602e-01f, -1.66714102e-01f, -2.91087538e-01f, -1.51710883e-01f, -2.39120632e-01f, -1.15799338e-01f, -2.11237356e-01f, -4.48040515e-02f, 2.14465056e-02f, 7.22469464e-02f,
  1.63416993e-02f, 7.43328333e-02f, 8.81441217e-03f, 1.45300105e-01f, -5.35039641e-02f, 2.42770705e-02f, 1.05331346e-01f, -7.42648020e-02f, 2.23621298e-02f, 1.03814013e-01f,
  9.62773040e-02f, 4.42726091e-02f, -1.28722340e-01f, 6.78171888e-02f, -6.30640313e-02f, -8.73440802e-02f, -1.41094252e-01f, -1.19852170e-01f, -1.06149271e-01f, -6.80828243e-02f,
  4.61858064e-02f, -1.00666448e-01f, 3.51830497e-02f, 2.72297096e-02f, 2.80668046e-02f, -3.05253454e-02f, -1.52371135e-02f, -8.51270836e-03f, 1.52193280e-02f, 2.26042252e-02f,
  -4.75068530e-03f, -1.51998520e-01f, -8.35450599e-04f, 1.87932122e-02f, -2.93420497e-02f, -6.53734133e-02f, -5.91668412e-02f, -3.03240232e-02f, 7.01662824e-02f, -2.95291767e-02f,
  -1.54297799e-01f, -3.76005955e-02f, 4.26454656e-02f, -4.53412114e-03f, -1.13111094e-01f, 9.46030989e-02f, 5.96531760e-03f, 9.09614265e-02f, -6.53974190e-02f, -4.74118963e-02f,
  -6.14404500e-01f, -5.22738397e-01f, -9.66238901e-02f, -1.40729502e-01f, -1.20961361e-01f, 9.95531492e-03f, -5.04410267e-02f, -2.49940455e-02f, -1.63879648e-01f, -4.21899324e-03f,
  -1.81492977e-02f, -9.64969769e-03f, -1.84560493e-01f, 8.00972525e-03f, -6.45302087e-02f, -6.93119094e-02f, -1.71425104e-01f, -7.12374151e-02f, -2.70389289e-01f, -3.03533450e-02f,
  -1.47051677e-01f, -1.83083396e-02f, -3.09151076e-02f, 4.45101634e-02f, -9.81528983e-02f, -1.16148859e-01f, -3.14216129e-02f, -7.67584937e-03f, -5.68663739e-02f, 6.80616498e-02f,
  1.90414771e-01f, 7.65814543e-01f, 1.69876292e-01f, -2.46560127e-02f, -3.62332314e-01f, -1.33846283e-01f, -1.76672608e-01f, 4.46249023e-02f, 1.65068433e-01f, 3.29953521e-01f,
  -2.68596411e-01f, 7.39256620e-01f, -3.35028991e-02f, -2.89214551e-02f, -4.49626297e-01f, -2.35327948e-02f, -2.62254745e-01f, 8.65133554e-02f, -7.96874166e-02f, -9.37629640e-02f,
  -1.96039557e-01f, -5.61829388e-01f, -2.42415041e-01f, -2.05043718e-01f, -1.80404186e-01f, 3.43573168e-02f, -5.07210791e-01f, -1.63060799e-01f, 4.13956083e-02f, -3.42952833e-02f,
  1.32359937e-01f, 2.68052425e-02f, 9.43259448e-02f, 7.35479444e-02f, -1.27711162e-01f, 5.13397194e-02f, 6.15744255e-02f, 9.22318101e-02f, -7.05091953e-02f, 7.34260157e-02f,
  1.42499700e-01f, 7.14685842e-02f, 5.97375818e-02f, -2.62414757e-02f, 2.12876089e-02f, 1.01230346e-01f, 3.57125029e-02f, 1.80472452e-02f, 1.43252760e-01f, 3.87446471e-02f,
  1.42190754e-01f, 6.72257170e-02f, -1.58497393e-01f, -1.03652306e-01f, -1.33997321e-01f, -1.09595798e-01f, 8.05490837e-02f, 7.35671818e-02f, 7.97366053e-02f, -1.43581470e-02f,
  -9.85559374e-02f, -9.48544443e-02f, -1.83118805e-02f, 7.61965662e-02f, 3.87603603e-02f, -4.56111878e-02f, 4.41018008e-02f, -5.27899712e-02f, -7.51484884e-03f, -8.85036960e-02f,
  -2.10013241e-02f, 1.32341295e-01f, -6.39740378e-02f, 1.14605771e-02f, 3.65585163e-02f, 8.01119357e-02f, -1.09535120e-01f, 1.15792692e-01f, 3.98835652e-02f, 1.13599105e-02f,
  -3.33593562e-02f, -3.38659063e-02f, 8.61578882e-02f, -1.74108729e-01f, -6.86649978e-02f, 1.05377631e-02f, 2.20706202e-02f, 1.12176575e-01f, 6.16597524e-03f, -1.75090566e-01f,
  -1.61829904e-01f, -4.17492598e-01f, 1.38359992e-02f, 1.96054861e-01f, 4.90408354e-02f, 2.56459713e-02f, -9.84202698e-02f, 5.18267974e-02f, -1.02561623e-01f, -9.96537358e-02f,
  -2.88486946e-02f, 8.43495131e-02f, -7.28703663e-02f, -3.33333425e-02f, 4.14424837e-02f, 5.48271136e-03f, -7.64580891e-02f, -3.65326256e-02f, -8.30073804e-02f, -4.58785594e-02f,
  5.28889187e-02f, -1.21189011e-02f, -8.70647803e-02f, -1.50456995e-01f, 1.21766962e-02f, 7.80150993e-03f, 5.31430840e-02f, 1.06241092e-01f, -1.23985782e-01f, 5.57467341e-02f,
  1.90065891e-01f, -2.97638416e-01f, -5.32988608e-01f, -1.93917811e-01f, 2.85458058e-01f, 1.02337092e-01f, -3.52533787e-01f, 1.54645354e-01f, -5.90694845e-01f, 5.11260629e-02f,
  2.15649381e-01f, -3.57075393e-01f, -3.38071913e-01f, 9.64932665e-02f, 1.99868262e-01f, -5.47271669e-01f, 3.58772278e-01f, 7.45895356e-02f, -1.94145858e-01f, 4.00435954e-01f,
  8.91784430e-02f, 6.12431407e-01f, -1.40334396e-02f, 4.97014791e-01f, 3.00655186e-01f, 2.18872607e-01f, 7.01916695e-01f, -8.44546407e-03f, 5.26713252e-01f, 1.03157878e-01f,
  -7.80302286e-02f, -7.65860453e-02f, -1.33916959e-02f, -1.20974973e-01f, 2.51323104e-01f, 2.90888131e-01f, 8.11102912e-02f, -1.24123469e-02f, -7.37700090e-02f, -6.96120262e-02f,
  -4.77536395e-02f, 3.54380831e-02f, 6.38649315e-02f, -4.16846909e-02f, 8.92536417e-02f, 3.36124711e-02f, -9.43720564e-02f, -5.24607040e-02f, -1.80364057e-01f, -7.29085803e-02f,
  -1.92261711e-01f, 1.88707337e-02f, -6.98952412e-04f, -1.01198591e-01f, -1.20477736e-01f, 2.29291841e-02f, 3.08395103e-02f, 7.66584501e-02f, -1.07209727e-01f, 9.48583186e-02f,
  1.60489157e-01f, -1.43005587e-02f, -2.30252300e-03f, -2.02551529e-01f, -3.79366577e-02f, -5.36638610e-02f, -7.41838068e-02f, 2.23174458e-03f, -6.41728789e-02f, 4.30010259e-02f,
  1.53214000e-02f, 7.88911618e-03f, -6.66324794e-02f, 9.47725475e-02f, 1.94114149e-01f, -3.46198827e-02f, -2.44272593e-02f, 4.93404716e-02f, -5.28596006e-02f, -2.40358729e-02f,
  -1.63833454e-01f, 8.87244046e-02f, -3.20504569e-02f, 3.00940536e-02f, -9.62411836e-02f, -4.58430639e-03f, 1.15844131e-01f, 3.02673671e-02f, -1.13079526e-01f, 1.98025126e-02f,
  1.14487983e-01f, 3.42832923e-01f, -6.42532632e-02f, -1.08956642e-01f, -1.17396913e-01f, 1.37689278e-01f, -1.07143715e-01f, -1.81321800e-02f, 9.28878933e-02f, 4.13176268e-02f,
  2.36311242e-01f, 8.78654271e-02f, 5.67478947e-02f, 4.48289029e-02f, -6.84216693e-02f, 1.85493395e-01f, 1.21016778e-01f, 7.63549879e-02f, 1.39128789e-01f, 2.29522899e-01f,
  1.21769026e-01f, 1.05693616e-01f, -3.63734439e-02f, -4.57076319e-02f, 1.14634141e-01f, 7.78408274e-02f, 1.30507618e-01f, -7.23804487e-03f, 4.07502726e-02f, -4.84463312e-02f,
  1.37666821e-01f, 3.06458063e-02f, -3.05158883e-01f, -3.78831506e-01f, -1.62811399e-01f, -5.87097645e-01f, -4.72070158e-01f, -1.54316097e-01f, 6.28569105e-04f, 8.93447101e-02f,
  -7.75532946e-02f, 8.21555853e-02f, 2.46495381e-01f, -2.74313062e-01f, -2.57951915e-01f, 1.75154567e-01f, -5.78086972e-01f, -3.03127080e-01f, 1.70130327e-01f, -3.39308321e-01f,
  -6.63010031e-02f, -7.98305199e-02f, -1.89871073e-01f, 8.26668888e-02f, -3.16333562e-01f, -7.52117261e-02f, 6.82372879e-03f, 2.43200287e-01f, -2.70603657e-01f, 1.32665843e-01f,
  -5.64284734e-02f, 2.62919217e-01f, -5.45371994e-02f, 5.04318215e-02f, -2.03157023e-01f, -1.27128839e-01f, -1.34290248e-01f, 7.07636029e-02f, 1.76160093e-02f, -5.19310758e-02f,
  -5.42160869e-02f, 4.38864455e-02f, -4.10725586e-02f, 2.65149891e-01f, 4.56255749e-02f, -4.56878245e-02f, 7.62364939e-02f, -2.09515169e-01f, -4.52041328e-02f, 4.94161509e-02f,
  -1.01271145e-01f, -1.33825064e-01f, -9.97560248e-02f, 5.69187454e-04f, -9.53279622e-03f, 5.48386052e-02f, -7.34685957e-02f, -1.65975988e-01f, -6.46359026e-02f, -4.65445109e-02f,
  4.02996764e-02f, -6.23621903e-02f, 6.81720078e-02f, 6.29387572e-02f, 6.97889626e-02f, -6.54240102e-02f, 4.88002896e-02f, -5.89676946e-02f, 1.55106094e-02f, -9.26696584e-02f,
  -6.96671084e-02f, 1.11536607e-01f, 1.07739329e-01f, -1.89314723e-01f, -6.16049394e-02f, 9.07291993e-02f, -3.22287716e-02f, 5.34569100e-02f, -1.64631382e-01f, -7.77908862e-02f,
  2.21953511e-01f, 8.18912778e-03f, 5.45435585e-02f, -2.91707856e-03f, -5.80155738e-02f, 4.07510102e-02f, 3.52964588e-02f, 1.33194793e-02f, -9.76185873e-03f, -2.88637877e-02f,
  -1.32992342e-01f, 4.77836244e-02f, -5.16484317e-04f, 1.04500785e-01f, 1.00567751e-02f, -1.94954518e-02f, -2.19929907e-02f, -8.12442750e-02f, 3.25829796e-02f, 1.58692431e-02f,
  -1.09546691e-01f, -1.47639111e-01f, -2.04344377e-01f, 7.69466162e-02f, -1.12834955e-02f, -2.04064801e-01f, -5.37120253e-02f, -5.89333661e-02f, -1.68400586e-01f, 6.38891309e-02f,
  -5.31517006e-02f, -3.04390714e-02f, 7.81260356e-02f, -7.07097277e-02f, -7.44050518e-02f, -2.71886438e-02f, -1.58319622e-02f, 9.01313201e-02f, 3.40416990e-02f, -1.03479996e-01f,
  4.23906147e-01f, 1.60348892e-01f, -5.58357716e-01f, -1.09538613e-02f, -2.00803488e-01f, 5.60985863e-01f, 5.34287095e-01f, -1.47302032e-01f, -3.18097025e-02f, 4.67205852e-01f,
  5.44581413e-01f, -7.93823823e-02f, 2.84611434e-01f, 7.24421442e-01f, 5.53505458e-02f, 5.03106415e-01f, 4.58822519e-01f, 3.86958927e-01f, -1.69933125e-01f, 2.44947419e-01f,
  -4.00299132e-02f, 5.17721832e-01f, -1.43900424e-01f, -2.62447804e-01f, 2.65715092e-01f, -4.77842301e-01f, -1.75529003e-01f, -4.78901178e-01f, 9.99194756e-03f, -8.47308263e-02f,
  1.52428761e-01f, 1.16368152e-01f, 5.66873932e-03f, -1.45066530e-01f, 6.48975186e-03f, 1.56450242e-01f, -6.12811074e-02f, -1.08136624e-01f, -5.33867553e-02f, 1.77644510e-02f,
  1.27182752e-01f, -3.05242836e-02f, 9.08916369e-02f, -9.95590389e-02f, 5.91115654e-03f, -2.43427269e-02f, 2.77455915e-02f, -2.81740483e-02f, -6.14995137e-02f, 1.49069682e-01f,
  1.74354296e-02f, -7.07741966e-03f, 9.77221280e-02f, 4.39828401e-03f, -1.72180682e-01f, 1.03161626e-01f, -6.87020924e-03f, -1.36005551e-01f, 1.15112839e-02f, -3.94901671e-02f,
  1.06766913e-02f, 3.12131848e-02f, 2.01901674e-01f, 1.20982468e-01f, -3.35319750e-02f, -2.60388646e-02f, 5.25063388e-02f, -6.90232888e-02f, -1.09868124e-01f, 1.06405154e-01f,
  -5.77789508e-02f, -6.81305900e-02f, 1.41210891e-02f, 6.17089979e-02f, 7.94956461e-02f, 5.45859635e-02f, -1.88553277e-02f, -5.38460389e-02f, 9.31069907e-03f, -1.26113579e-01f,
  -2.83918511e-02f, 2.94376127e-02f, 6.22412302e-02f, -5.75982630e-02f, 6.84683844e-02f, -1.11122400e-01f, 8.12821835e-02f, 4.38922457e-02f, 1.13184226e-03f, -9.23758596e-02f,
  5.34266829e-02f, -1.16614766e-01f, -7.22839907e-02f, -8.23652297e-02f, -1.95114359e-01f, 1.17865823e-01f, 3.10785566e-02f, 1.57587100e-02f, -7.16862530e-02f, 1.05549440e-01f,
  -2.18382720e-02f, 1.18488958e-02f, -5.99957779e-02f, -1.90340485e-02f, -1.29355386e-01f, 1.46812841e-01f, 8.60322267e-02f, -8.25289413e-02f, -7.42435679e-02f, -1.95572972e-01f,
  -9.58924964e-02f, 1.99195608e-01f, -3.24566811e-02f, -2.57126018e-02f, -7.79948086e-02f, -2.99969106e-04f, -7.55425915e-02f, -8.12918767e-02f, -1.28507182e-01f, 1.30163822e-02f,
  2.36930445e-01f, -4.01258230e-01f, -1.54970601e-01f, 6.57341719e-01f, 2.66418338e-01f, 7.16338456e-02f, 2.42929205e-01f, 3.75930369e-01f, 8.22946310e-01f, -2.17837527e-01f,
  -2.40009487e-01f, -6.24946475e-01f, -5.75423002e-01f, -4.51548472e-02f, -1.05849326e-01f, -2.89161056e-01f, 3.30715895e-01f, -3.51903252e-02f, 3.29190761e-01f, -9.16376635e-02f,
  1.25047877e-01f, 2.31653154e-02f, -3.61185789e-01f, 4.94406037e-02f, -4.58328128e-02f, 3.17356259e-01f, -1.66065797e-01f, -2.39698719e-02f, -1.64185956e-01f, -3.65156196e-02f,
  7.89466724e-02f, 1.83187708e-01f, -8.11949223e-02f, 5.87692112e-02f, 1.71760380e-01f, -2.33184732e-02f, -4.21018340e-02f, -1.32717833e-01f, 1.42764196e-01f, -3.30749224e-03f,
  -2.38009721e-01f, -1.44437766e-02f, 9.82557982e-02f, -1.30748540e-01f, 2.60613471e-01f, -1.40545203e-03f, 9.00275074e-03f, 3.51847038e-02f, -3.13485563e-02f, -1.87375739e-01f,
  -1.49322346e-01f, -3.04206256e-02f, 1.75030857e-01f, 2.93417685e-02f, 2.22208202e-02f, 1.50157005e-01f, 8.61645713e-02f, -1.68980956e-01f, -1.13671444e-01f, 1.44313321e-01f,
  -6.93751201e-02f, 8.54596272e-02f, -9.03800577e-02f, 4.43070270e-02f, 2.84351176e-03f, 1.28360584e-01f, 3.62865487e-03f, -3.85140106e-02f, 3.49799581e-02f, -1.34099334e-01f,
  1.48179486e-01f, 6.27114950e-03f, 9.24139842e-02f, 5.57679906e-02f, 3.17543447e-02f, 1.06391855e-01f, -2.73347665e-02f, -7.69957155e-02f, 1.45464361e-01f, -6.80065621e-03f,
  2.75295507e-02f, -1.54947611e-02f, -1.03037812e-01f, 2.35113613e-02f, 9.67286676e-02f, -3.48963663e-02f, 3.02669834e-02f, -7.90462922e-03f, 6.05040789e-02f, -1.57319173e-01f,
  -1.39395535e-01f, 1.40317408e-02f, 3.58481370e-02f, 5.27996160e-02f, -5.48039861e-02f, -3.59436534e-02f, 3.76870297e-03f, 6.62600994e-02f, 6.86799064e-02f, 4.27245311e-02f,
  -1.65390279e-02f, -4.30306643e-02f, -2.39882749e-02f, 1.24958586e-02f, -3.52324508e-02f, -1.09762698e-01f, 1.88137107e-02f, 1.27024800e-01f, 7.46722296e-02f, -6.71797767e-02f,
  -1.47610560e-01f, -7.74394814e-03f, 6.45327717e-02f, 1.91107437e-01f, 4.90333922e-02f, -1.15986489e-01f, -1.25376061e-02f, 3.98320407e-02f, -6.73631802e-02f, 3.09401043e-02f,
  -4.56386745e-01f, -4.50633258e-01f, 5.30391812e-01f, -1.21177875e-01f, -2.88961709e-01f, 3.43663633e-01f, 5.87903500e-01f, -2.83160508e-01f, -3.79270434e-01f, -1.76507398e-01f,
  -3.44888046e-02f, -1.10262476e-01f, 4.85183060e-01f, 5.69314733e-02f, 5.02329290e-01f, 3.67333621e-01f, 1.04053862e-01f, 1.71496078e-01f, -1.58090502e-01f, -2.76613474e-01f,
  -1.40100449e-01f, -2.92084634e-01f, 6.31330013e-01f, -5.10394335e-01f, -1.81410298e-01f, -2.62430400e-01f, 1.76532555e-03f, 1.89088628e-01f, -1.21979058e-01f, 6.77288547e-02f,
  -1.35161966e-01f, -2.83864409e-01f, -1.20234691e-01f, 3.29859890e-02f, -5.10876700e-02f, 1.83707848e-02f, 1.22634433e-01f, 1.92327350e-01f, -8.95693805e-03f, 3.68216746e-02f,
  1.10958023e-02f, 1.52926184e-02f, -2.05659449e-01f, 4.01896685e-02f, -1.40631959e-01f, -9.17283520e-02f, 1.95405949e-02f, 6.03102632e-02f, -1.08810654e-02f, 1.06561676e-01f,
  9.88666713e-02f, -3.20742838e-02f, 4.66481559e-02f, -2.50323955e-02f, -1.48137531e-03f, -1.56654622e-02f, 1.57191813e-01f, 9.03640389e-02f, -9.86104533e-02f, -1.00923650e-01f,
  7.46340549e-04f, -8.20767879e-02f, -1.41477529e-02f, 9.31967702e-03f, -2.53292192e-02f, -7.01167956e-02f, -5.42303436e-02f, 5.05045243e-02f, -5.45699261e-02f, 2.92661488e-02f,
  2.54712738e-02f, 5.98954968e-02f, -5.43606933e-04f, 7.29237199e-02f, -9.99570563e-02f, -2.46715490e-02f, 7.07491040e-02f, -5.35747781e-02f, 1.47382487e-02f, -1.33898659e-02f,
  2.39161775e-02f, 8.95684510e-02f, 5.36486767e-02f, 2.55092978e-02f, -7.00969365e-04f, 2.63013933e-02f, -6.20893613e-02f, 9.91039053e-02f, 7.65526528e-03f, 6.49389904e-03f,
  -3.75224650e-01f, -6.02898598e-01f, -1.85084447e-01f, -7.42034540e-02f, -7.61108026e-02f, -1.37823656e-01f, -2.05469467e-02f, -1.27023101e-01f, -7.53311440e-02f, -2.90164705e-02f,
  -1.75531730e-01f, 3.39606777e-02f, -1.30786836e-01f, -3.55612077e-02f, -1.87765956e-02f, -1.80075108e-03f, -3.86310816e-02f, -5.53539954e-02f, -1.61591247e-01f, -1.14888430e-01f,
  2.43350100e-02f, -6.34441972e-02f, -4.47032638e-02f, -1.57422617e-01f, -6.09632507e-02f, -2.79497840e-02f, -1.83632866e-01f, -3.14489268e-02f, -3.44917141e-02f, 2.94468049e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.37961435e-01f, 3.35692614e-01f, 5.49889386e-01f, 3.03803861e-01f, 5.20342648e-01f, 4.20738488e-01f, 6.57546520e-01f, 3.13817412e-01f, 4.04704720e-01f, 6.07119083e-01f,
  1.18467271e-01f, 3.60577017e-01f, 3.03938657e-01f, 5.09973526e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.02158770e-01f, 3.75743210e-02f, -2.67348409e-01f, 1.08684897e-01f, -2.19325662e-01f, 3.14831696e-02f, 8.89024660e-02f, 9.35680270e-02f, 6.40029758e-02f, -1.39253914e-01f,
  -9.48559269e-02f, -1.94891170e-01f, -1.81870595e-01f, -6.32235706e-01f, -1.47928566e-01f, -6.39807343e-01f, -5.85328519e-01f, 4.70087454e-02f, -4.53718245e-01f, -3.99189532e-01f,
  -1.16990864e-01f, -7.51559064e-02f, -1.29271582e-01f, -1.29644081e-01f, -1.15122512e-01f, 3.63550127e-01f, -3.97224784e-01f, -7.61303529e-02f, 3.60137105e-01f, -5.02980649e-01f,
  8.72624591e-02f, -1.22416116e-01f, -2.38151446e-01f, -5.85882902e-01f, -5.49081147e-01f, 2.20485166e-01f, 2.70373940e-01f, 9.59231034e-02f, 5.16148210e-01f, 4.45386916e-01f,
  2.05831245e-01f, -3.35586816e-01f, 6.81900457e-02f, -6.67939365e-01f, -3.59083146e-01f, 2.85477549e-01f, 7.28562623e-02f, -3.31359476e-01f, -3.70575815e-01f, 4.70291197e-01f,
  1.83500424e-01f, -1.45195886e-01f, -1.99845761e-01f, 8.31316471e-01f, -3.95721674e-01f, -3.69212061e-01f, -5.08151114e-01f, 5.43688834e-02f, -1.19550243e-01f, -4.00826484e-01f,
  -3.91285062e-01f, 4.84732032e-01f, -2.11425781e-01f, 4.22692806e-01f, 5.92738211e-01f, -5.78712404e-01f, -3.97213966e-01f, -7.93609798e-01f, -4.04104143e-01f, 4.02280316e-02f,
  -6.38604403e-01f, 1.84272990e-01f, 3.35538268e-01f, 2.50383466e-01f, 1.46622926e-01f, -1.30643100e-01f, 9.12220851e-02f, 3.93135369e-01f, 5.07085681e-01f, 1.93789527e-02f,
  5.28124869e-01f, -2.77171075e-01f, 2.81871725e-02f, 3.54786068e-01f, 1.34098038e-01f, -1.53973103e-01f, 6.40698001e-02f, -1.26231052e-02f, 7.36957937e-02f, -4.56187934e-01f,
  -7.09358603e-02f, 4.70265895e-01f, 4.38118763e-02f, -3.12387973e-01f, -3.04875404e-01f, 5.64134538e-01f, 6.65810823e-01f, 5.81776261e-01f, 7.96923265e-02f, 3.13679069e-01f,
  4.60648209e-01f, -3.21683496e-01f, 1.73247159e-01f, -4.08289284e-01f, 3.42338949e-01f, -3.03429008e-01f, 1.45409957e-01f, -3.18856746e-01f, -3.69278818e-01f, -7.57461786e-01f,
  -4.80980843e-01f, -2.29352534e-01f, -3.06920171e-01f, 2.78961182e-01f, 2.77300049e-02f, 9.28799212e-02f, -2.58212924e-01f, -5.97434223e-01f, -6.26969337e-01f, -6.11737132e-01f,
  -1.33176476e-01f, -5.54529846e-01f, -3.91714692e-01f, 4.71278727e-01f, 2.13209376e-01f, 7.69198835e-01f, -4.58522528e-01f, -7.79935658e-01f, -4.95906919e-01f, 1.90455750e-01f,
  2.71206707e-01f, -3.17437667e-03f, 1.55227095e-01f, -3.71510357e-01f, -1.11508928e-01f, -5.03258109e-01f, -3.60570729e-01f, 1.18393406e-01f, -1.39487162e-01f, -1.64252907e-01f,
  -6.46380037e-02f, 1.11644506e-01f, -5.83027661e-01f, 2.41039008e-01f, -3.74618530e-01f, 3.09699237e-01f, 1.58856213e-01f, -1.76667422e-02f, -8.33818838e-02f, 1.03384934e-01f,
  -3.87432724e-01f, -1.73781931e-01f, -3.04679543e-01f, -2.32797623e-01f, -2.49470755e-01f, -2.76821882e-01f, 2.69058496e-01f, -4.43060964e-01f, -2.98382163e-01f, 2.03668058e-01f,
  3.34995955e-01f, 6.72599375e-02f, 5.81710674e-02f, -1.96383461e-01f, 4.87764239e-01f, 4.62980986e-01f, 1.22857787e-01f, -2.67555326e-01f, -1.46055207e-01f, 5.28781354e-01f,
  2.61470497e-01f, -9.52480137e-02f, -2.32079953e-01f, 3.76244068e-01f, 5.53839564e-01f, -1.13261253e-01f, 4.06733364e-01f, 5.25940657e-01f, 8.12898934e-01f, -2.89477021e-01f,
  2.45567933e-02f, -1.80287525e-01f, -4.90483075e-01f, -1.84802771e-01f, -4.02934343e-01f, -3.32840800e-01f, -1.84180185e-01f, 5.33630073e-01f, -3.13651413e-01f, -5.54915726e-01f,
  3.02367210e-01f, -2.03284621e-01f, -3.74646038e-01f, 1.18871614e-01f, 3.17891330e-01f, -1.07688397e-01f, 2.76982356e-02f, -5.99815428e-01f, 5.69265857e-02f, -1.73917301e-02f,
  -3.78682047e-01f, -5.31297863e-01f, -7.39837391e-03f, -2.05736190e-01f, -4.01764780e-01f, -2.16377392e-01f, -3.11776817e-01f, -4.88068536e-03f, -3.34876329e-02f, 1.45064741e-01f,
  2.22617239e-02f, -1.02911472e-01f, 5.81659041e-02f, 1.37567803e-01f, -2.23432466e-01f, 7.74802268e-02f, -2.17520278e-02f, 1.91853195e-01f, -2.08143085e-01f, -3.80868353e-02f,
  -2.85899639e-01f, -4.12799984e-01f, 3.91171098e-01f, -6.18955433e-01f, -4.95853692e-01f, 7.24502979e-03f, -3.29095483e-01f, 1.82498872e-01f, -5.10143697e-01f, 5.84679723e-01f,
  3.40947896e-01f, -1.69479385e-01f, 2.25056574e-01f, 4.21965383e-02f, -3.75793993e-01f, -3.69763255e-01f, 3.14612910e-02f, -4.95314896e-01f, -8.37144479e-02f, 6.68469071e-02f,
  -1.65116280e-01f, -3.56642753e-01f, -3.78975838e-01f, -6.53062463e-01f, 5.06269872e-01f, 3.39218616e-01f, -4.56096292e-01f, 5.08428395e-01f, -1.17914587e-01f, 4.56142515e-01f,
  1.57877535e-01f, -8.53276908e-01f, 5.87297618e-01f, -2.86443591e-01f, -1.07219480e-01f, -8.26161504e-01f, -1.59345433e-01f, 2.56573409e-01f, 1.09452888e-01f, 1.50873721e-01f,
  -1.68110371e-01f, 1.90609679e-01f, -1.02949105e-02f, -4.01299298e-01f, 4.51431602e-01f, 3.55831116e-01f, -5.56374788e-01f, 3.17160159e-01f, 1.47699207e-01f, 3.89031976e-01f,
  3.68457109e-01f, 1.99413940e-01f, 2.16068029e-01f, 2.47291803e-01f, -9.43173096e-02f, 1.45766735e-01f, 4.59283561e-01f, -3.48978132e-01f, 7.13462755e-02f, -1.61751598e-01f,
  2.84701884e-01f, 6.13508582e-01f, 2.64547855e-01f, 6.32197320e-01f, -5.47930717e-01f, 6.25532269e-01f, 2.38708138e-01f, -5.27167499e-01f, 2.38335639e-01f, -3.82028341e-01f,
  -2.33465716e-01f, 5.64297199e-01f, -3.61628503e-01f, -6.25229552e-02f, -2.37401858e-01f, 3.43207330e-01f, 3.12621415e-01f, 2.82250613e-01f, 3.43054235e-01f, 4.02302742e-01f,
  -5.62818229e-01f, 4.91772629e-02f, -6.54190421e-01f, 9.21824932e-01f, 7.49486625e-01f, -1.61393315e-01f, 5.25445461e-01f, 9.47142988e-02f, 6.09627426e-01f, 7.46411234e-02f,
  -2.64785469e-01f, -8.67147803e-01f, -4.90188509e-01f, 3.68413895e-01f, 7.70201236e-02f, -7.22086728e-02f, -2.25241214e-01f, -7.07177281e-01f, -3.01544815e-01f, 2.73529828e-01f,
  6.26275837e-02f, -1.41990647e-01f, 3.03890169e-01f, 4.26705927e-01f, 4.98277247e-01f, 4.08544719e-01f, 3.13767791e-01f, -3.28525482e-03f, -1.35482371e-01f, 1.39031842e-01f,
  4.51657623e-01f, 1.67603135e-01f, 1.58235043e-01f, 1.37091532e-01f, -4.43234555e-02f, 6.21671081e-01f, -1.79750070e-01f, 2.95668334e-01f, 2.63354331e-01f, 2.63656545e-02f,
  1.20656975e-01f, -5.82217991e-01f, 8.72139111e-02f, 2.34451652e-01f, 3.35083395e-01f, 3.24049383e-01f, -7.01614439e-01f, 5.53293109e-01f, 6.08549654e-01f, 6.03138469e-02f,
  7.95809850e-02f, -9.46820378e-02f, -2.61592835e-01f, -1.95358694e-01f, 7.15784609e-01f, 1.63202971e-01f, 4.60230261e-01f, -2.14339688e-01f, -5.90759754e-01f, 7.38108635e-01f,
  5.07793605e-01f, -6.90568268e-01f, 4.47228476e-02f, 7.71294355e-01f, 7.14334905e-01f, 5.88833451e-01f, -3.82551163e-01f, -7.03304291e-01f, -7.00651109e-01f, -2.93208748e-01f,
  -7.03269660e-01f, 5.58195889e-01f, -6.51688099e-01f, -7.43186653e-01f, 3.34086776e-01f, -4.29569632e-01f, -2.69119591e-01f, -9.92846414e-02f, 2.38024905e-01f, -8.42814684e-01f,
  -4.37936544e-01f, 1.29921183e-01f, 4.83315617e-01f, -2.67931640e-01f, 4.95554768e-02f, 3.42715949e-01f, 1.03127792e-01f, 2.32967451e-01f, 3.41529369e-01f, -5.74270129e-01f,
  2.62721598e-01f, 9.94392112e-02f, 2.21973822e-01f, -4.78457808e-01f, 2.40134954e-01f, 1.12844840e-01f, 3.32075022e-02f, -4.69821915e-02f, -1.71326980e-01f, -2.96366900e-01f,
  2.18400180e-01f, -4.08941984e-01f, 1.42454103e-01f, -1.76606983e-01f, 1.87260255e-01f, 3.82812947e-01f, 3.41016762e-02f, 1.97287779e-02f, 1.84179395e-01f, -3.95068347e-01f,
  -2.54586548e-01f, -6.75746560e-01f, -3.32146794e-01f, 3.45794201e-01f, -5.62174737e-01f, -1.78674594e-01f, -5.85301995e-01f, 5.07055402e-01f, 4.50032860e-01f, -7.83294678e-01f,
  -7.22762525e-01f, 4.78050828e-01f, -5.43547273e-01f, -5.63899517e-01f, -6.13925278e-01f, 6.26486242e-01f, 6.39819428e-02f, 2.28820853e-02f, 3.57369870e-01f, -4.98079270e-01f,
  -1.95252433e-01f, 1.17226578e-02f, 2.83993840e-01f, -7.21284688e-01f, -5.77321708e-01f, -5.93956053e-01f, -1.40757874e-01f, -3.72796983e-01f, -5.22564769e-01f, -1.31994009e-01f,
  2.39562526e-01f, -1.18303761e-01f, -6.40486419e-01f, -3.34768176e-01f, -1.92888305e-01f, 2.81388551e-01f, 9.44812536e-01f, -8.03443193e-02f, -8.61799195e-02f, -4.09040958e-01f,
  -3.98291290e-01f, -1.84566453e-01f, -4.85883243e-02f, -3.28593254e-01f, -2.96827108e-01f, -1.27128229e-01f, -6.95358664e-02f, 4.24709804e-02f, -1.60683263e-02f, -4.87889536e-02f,
  -4.98339012e-02f, -1.35912314e-01f, 1.77960023e-02f, -2.00547367e-01f, -1.17492937e-01f, -1.05421223e-01f, -2.38979369e-01f, -3.81377555e-04f, -2.30832592e-01f, -1.51059270e-01f,
  8.93931091e-02f, -8.46725181e-02f, -2.21225157e-01f, 5.07089533e-02f, 2.83910125e-01f, -2.62571812e-01f, -2.47592092e-01f, -4.98364642e-02f, 3.21283668e-01f, 3.39465146e-03f,
  2.45487034e-01f, -9.18143839e-02f, 4.06053901e-01f, -3.60467285e-01f, -1.00568756e-01f, 1.90632060e-01f, 1.23133555e-01f, 1.23484857e-01f, -3.32578540e-01f, 3.59002620e-01f,
  -3.64627838e-01f, 2.18037859e-01f, 4.00136113e-02f, 3.03903699e-01f, 2.83766061e-01f, -2.62706548e-01f, -3.62800002e-01f, -7.22950101e-02f, 2.29493260e-01f, 5.06338179e-01f,
  -4.55967486e-01f, -3.47468734e-01f, -3.09643418e-01f, 4.08179164e-02f, 4.90228772e-01f, 3.42405051e-01f, 2.71178246e-01f, -3.75986338e-01f, 5.56504607e-01f, -4.90382940e-01f,
  -2.39954486e-01f, -2.87743658e-01f, -4.04792100e-01f, -1.68316904e-02f, 1.48764968e-01f, -1.66751370e-02f, -3.51812392e-01f, 1.50280356e-01f, 2.21289814e-01f, -4.81229872e-01f,
  -2.85405725e-01f, 9.45063494e-03f, 1.66776016e-01f, -2.93113410e-01f, -5.78409433e-02f, -4.01181906e-01f, 1.12801604e-01f, -1.02821164e-01f, 5.58637455e-02f, -4.01878685e-01f,
  -1.63165569e-01f, 6.20558076e-02f, -1.28045961e-01f, 1.47775799e-01f, 1.06081001e-01f, 1.28916308e-01f, -5.36316596e-02f, -2.99208403e-01f, 3.90366018e-01f, 1.44988656e-01f,
  1.58466190e-01f, -3.20617318e-01f, -9.54253972e-02f, -4.54910807e-02f, 1.05839208e-01f, 2.90630370e-01f, -4.80655104e-01f, -3.28274041e-01f, -6.29916310e-01f, -3.88330072e-01f,
  -4.00155693e-01f, -3.13889474e-01f, 2.74232835e-01f, -3.99384916e-01f, -5.12214780e-01f, -4.52470571e-01f, 4.03250694e-01f, -1.35954261e-01f, 2.59940505e-01f, 7.13452417e-03f,
  -4.14700001e-01f, -6.23763680e-01f, 1.01227455e-01f, -3.30683500e-01f, -3.78386855e-01f, -1.19322166e-01f, 8.42791200e-01f, 3.51680741e-02f, -3.30712110e-01f, -9.79334414e-02f,
  -4.53783602e-01f, 4.44192886e-01f, -7.43135065e-02f, -5.15619099e-01f, -4.92913216e-01f, -2.04941660e-01f, 3.91981304e-01f, 7.94754848e-02f, 9.02962983e-02f, 1.00267597e-01f,
  -4.88758355e-01f, 4.46661144e-01f, 1.85312167e-01f, 2.89476097e-01f, -2.36484110e-01f, -3.25310588e-01f, -1.37738675e-01f, 1.41159107e-03f, 1.61814421e-01f, -6.80677767e-04f,
  -1.76359415e-02f, 8.20363015e-02f, -2.16734812e-01f, 8.85088295e-02f, 1.72107443e-01f, 3.95757526e-01f, -3.14678609e-01f, 1.63189806e-02f, 2.16795921e-01f, -1.15532100e-01f,
  2.19661575e-02f, -2.19294846e-01f, 6.60053074e-01f, -2.25464851e-01f, 2.63269395e-01f, 4.04522955e-01f, 1.69345379e-01f, -2.63645828e-01f, -8.38995203e-02f, 3.38548869e-01f,
  2.45952934e-01f, 6.07141137e-01f, 4.52008814e-01f, 1.83873415e-01f, 7.40957439e-01f, -5.53731263e-01f, -5.49620390e-01f, 3.65787655e-01f, 4.23833817e-01f, 2.45094806e-01f,
  1.03776574e-01f, 5.36627114e-01f, 7.71457076e-01f, -2.55850434e-01f, 3.97171021e-01f, -1.21518157e-01f, -1.62614122e-01f, 4.56740677e-01f, -5.59813738e-01f, -2.70481229e-01f,
  2.70623624e-01f, -2.05599710e-01f, 5.15774727e-01f, -7.51299202e-01f, -5.97574413e-01f, -4.97440487e-01f, -4.38248783e-01f, -2.56999671e-01f, -7.61711836e-01f, 7.71368146e-01f,
  3.22926939e-01f, 1.80030018e-01f, -9.89504978e-02f, 1.67910665e-01f, 2.23323822e-01f, 1.13055639e-01f, 8.82498398e-02f, 3.27729225e-01f, 9.15478989e-02f, 5.86252250e-02f,
  1.38748795e-01f, 1.51060015e-01f, 2.80204713e-01f, 1.48574263e-01f, 2.29654491e-01f, -6.60646781e-02f, 2.70351052e-01f, -3.45823020e-02f, 4.69113588e-02f, 5.09879179e-02f,
  -2.40366161e-01f, -9.78236273e-02f, -1.89256608e-01f, 8.40285271e-02f, -4.10557985e-02f, 4.09455985e-01f, -4.03557718e-02f, -4.73511219e-01f, 2.16668308e-01f, 1.38940498e-01f,
  3.78592223e-01f, 5.82274079e-01f, 3.00372094e-01f, -5.23641109e-01f, -3.35911483e-01f, -3.22552532e-01f, 4.62814540e-01f, -3.87642026e-01f, 2.21957296e-01f, 3.42058063e-01f,
  3.88864428e-01f, -7.43006030e-03f, -5.42788386e-01f, -1.66814238e-01f, -4.25109267e-01f, -2.12178692e-01f, 4.19787049e-01f, 3.90510768e-01f, -1.85951576e-01f, 4.45958316e-01f,
  -6.26159132e-01f, -1.88831598e-01f, 5.80436349e-01f, -9.74790100e-03f, -4.60971385e-01f, 5.32285511e-01f, 6.15836740e-01f, -8.22371781e-01f, -6.51872456e-01f, 4.73302811e-01f,
  -4.23183858e-01f, -6.51481688e-01f, 3.53948097e-03f, -4.07442302e-01f, 2.92625517e-01f, 1.87010705e-01f, 2.72052735e-02f, -1.22284383e-01f, 2.08357766e-01f, 2.49791108e-02f,
  -7.30453581e-02f, 1.61567152e-01f, 1.88387215e-01f, 2.41525337e-01f, -8.35675001e-02f, -1.88816801e-01f, 9.12834778e-02f, -1.01916872e-01f, 1.27109632e-01f, -2.22591579e-01f,
  6.71707559e-03f, 2.12481946e-01f, -9.75725725e-02f, -3.66572440e-01f, 1.69254728e-02f, 1.45926088e-01f, -4.34033051e-02f, -4.30734754e-02f, -1.05483547e-01f, -1.58297837e-01f,
  2.37425461e-01f, -4.88443583e-01f, -4.17875528e-01f, 1.55171216e-01f, -5.22515118e-01f, 5.37890434e-01f, -4.41399604e-01f, -4.97486681e-01f, -3.75452101e-01f, -3.80698681e-01f,
  -2.64716089e-01f, -3.51395071e-01f, -1.88778877e-01f, 1.10504150e-01f, -5.17226994e-01f, -2.88722545e-01f, 3.74598235e-01f, 2.99435675e-01f, 3.74759197e-01f, -1.96441963e-01f,
  -1.10840000e-01f, 4.07648683e-01f, 4.07532722e-01f, 5.16443908e-01f, -3.98578793e-01f, -2.94457257e-01f, -5.53825140e-01f, 2.61126041e-01f, 6.07259214e-01f, 3.70612323e-01f,
  -3.50013137e-01f, -1.19943164e-01f, 9.21077609e-01f, -4.86087084e-01f, -2.58845955e-01f, -2.87889153e-01f, -3.21494073e-01f, -3.88778806e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.05137311e-01f, -5.09405918e-02f, -1.35618508e-01f, -9.56004784e-02f, -2.00015549e-02f, 1.97806120e-01f, 3.89884524e-02f, -1.21263899e-01f, 9.62153357e-03f, -7.54948854e-02f,
  -9.26671028e-02f, -8.53264257e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    