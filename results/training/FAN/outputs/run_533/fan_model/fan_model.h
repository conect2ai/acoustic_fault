/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.87264907e-01f, 3.64974380e-01f, 6.19249754e-02f, 6.35352824e-03f, -1.31666824e-01f, 3.26432586e-01f, -4.06095572e-02f, 1.53516576e-01f, 4.41803746e-02f, 2.75874764e-01f,
  -1.36161381e-02f, 5.87472506e-02f, -7.73586854e-02f, 2.91622132e-01f, -3.90781388e-02f, 2.71127611e-01f, 2.63146073e-01f, 6.37476444e-02f, -1.93416458e-02f, -6.62703887e-02f,
  -4.21622470e-02f, 8.31846148e-02f, 5.57282157e-02f, 9.99300629e-02f, 9.82734114e-02f, -8.85109454e-02f, -2.63510168e-01f, -1.63516879e-01f, 1.55247897e-01f, 4.16745245e-02f,
  -5.61222211e-02f, -1.40334681e-01f, 3.51436995e-02f, 2.70380192e-02f, -1.29784802e-02f, -8.17558989e-02f, -1.05107382e-01f, -6.19124174e-02f, -7.02039078e-02f, 3.75469774e-02f,
  7.54713267e-03f, 2.92792767e-02f, -5.17491903e-03f, -3.71674709e-02f, 4.10767421e-02f, -2.50668284e-02f, 1.91848069e-01f, 9.47172418e-02f, 6.68346509e-02f, 8.47462844e-03f,
  7.60882422e-02f, 6.97111636e-02f, 7.60971045e-04f, 7.15529621e-02f, -6.41270948e-04f, 8.09930861e-02f, -4.62978035e-02f, -6.55639097e-02f, 4.34435792e-02f, -3.25611298e-04f,
  -2.32636370e-02f, -3.91413271e-02f, 1.79140307e-02f, -1.09657804e-02f, 2.37756036e-03f, -3.89630422e-02f, 7.51998648e-02f, -4.96688746e-02f, -2.70073265e-02f, -2.30178721e-02f,
  4.80827317e-02f, -1.34923290e-02f, -1.57399327e-02f, 6.24126792e-02f, -1.38018513e-02f, -2.92657502e-02f, -1.25600034e-02f, 1.12958662e-02f, -1.78791396e-02f, 6.86218664e-02f,
  -3.24510485e-02f, 6.18064739e-02f, -1.60567102e-03f, -6.13061525e-02f, 8.64947215e-02f, -4.97048199e-02f, -1.95727926e-02f, 2.77086850e-02f, 5.07201813e-02f, -1.03603698e-01f,
  1.82570086e-03f, -1.03374541e-01f, 2.56976392e-02f, 3.80827971e-02f, 2.40230151e-02f, 3.56092080e-02f, 5.38460538e-02f, 4.03358452e-02f, 7.21551329e-02f, -5.14068678e-02f,
  -1.21814944e-02f, -1.87382251e-02f, -4.44626845e-02f, 5.44229224e-02f, 1.48842186e-02f, 1.38653200e-02f, -1.46221444e-01f, -6.26746491e-02f, -5.90298995e-02f, 3.34696956e-02f,
  -1.15581483e-01f, -1.11485489e-01f, 9.38195095e-04f, -8.75716284e-02f, -7.66491815e-02f, -1.18102923e-01f, -7.31160715e-02f, -1.58099663e-02f, -2.82505918e-02f, 3.36908959e-02f,
  -7.24508101e-03f, -2.60477215e-01f, -1.11008078e-01f, -1.08155377e-01f, 1.95796877e-01f, 3.32655847e-01f, -1.22418351e-01f, 2.08267301e-01f, 2.81901751e-02f, -1.29089311e-01f,
  -4.40727137e-02f, -2.39288002e-01f, -1.82016373e-01f, -1.73658967e-01f, 1.26424253e-01f, -2.13938609e-01f, -2.09581852e-01f, -1.78612828e-01f, 7.65959173e-02f, 6.35097846e-02f,
  1.91878136e-02f, 8.05335119e-02f, -1.15384132e-01f, 2.64211237e-01f, 1.00220062e-01f, 7.92679861e-02f, -8.63163546e-03f, 9.21281055e-02f, -8.23970437e-02f, 7.48942494e-02f,
  1.45476572e-02f, -6.98129386e-02f, -1.29701067e-02f, 6.62701875e-02f, 4.71470430e-02f, -7.09683672e-02f, -7.46609271e-02f, -3.95583287e-02f, -7.32782250e-03f, 1.10991053e-01f,
  -4.35420006e-05f, 1.08364001e-01f, -1.56420562e-02f, -4.80647907e-02f, 1.16607156e-02f, 1.72081981e-02f, 1.27447098e-02f, -4.45315428e-02f, 1.06456513e-02f, -4.20799740e-02f,
  -7.87071586e-02f, -2.67914720e-02f, -8.77253413e-02f, -4.54459153e-02f, -6.60373122e-02f, 7.99778774e-02f, -5.14799310e-03f, -4.07449566e-02f, 4.74276878e-02f, 6.64085522e-02f,
  -7.22402930e-02f, -1.03854155e-02f, -3.52483988e-02f, 7.66292810e-02f, 5.99867925e-02f, -5.40337153e-02f, -2.94910595e-02f, -8.94850418e-02f, -8.84813592e-02f, 5.61525002e-02f,
  1.32556856e-01f, 1.03551755e-02f, 2.70944145e-02f, 6.38061017e-02f, -2.73170043e-02f, -1.07886389e-01f, -2.40270197e-02f, 9.85871721e-03f, 1.25424154e-02f, -2.63425373e-02f,
  -1.31249819e-02f, 1.08817913e-01f, -5.81899285e-02f, 2.32189726e-02f, 2.52701528e-02f, -3.31129655e-02f, -1.12723984e-01f, -2.27123760e-02f, 3.63903446e-03f, 3.20484824e-02f,
  1.70985013e-01f, -7.00468123e-02f, 3.17768119e-02f, 9.56306159e-02f, -7.23661296e-03f, 2.19991822e-02f, -1.06870875e-01f, 3.76491398e-02f, 6.97831139e-02f, 1.53340567e-02f,
  -5.37074693e-02f, -4.31920104e-02f, 6.77053705e-02f, 5.51107340e-03f, -1.40934475e-02f, 5.21031357e-02f, -4.41661570e-03f, -1.99402552e-02f, 5.82416616e-02f, -2.85884030e-02f,
  -1.31292893e-02f, 2.50800606e-02f, 5.15238084e-02f, 5.62906079e-02f, 2.21084487e-02f, 5.76426648e-03f, 6.67116940e-02f, 2.79775541e-03f, 5.78676909e-02f, -3.81910689e-02f,
  1.98117882e-01f, -9.93285887e-03f, -2.57873803e-01f, 4.42634821e-01f, -1.15108162e-01f, 1.78511903e-01f, -1.10359471e-02f, 1.35409787e-01f, 1.60871342e-01f, 1.02033563e-01f,
  2.08992958e-01f, -1.77764177e-01f, -1.67087555e-01f, 3.32221955e-01f, 1.27012670e-01f, 7.09879398e-02f, 3.74839425e-01f, 1.19990848e-01f, -1.89275295e-02f, 1.76775247e-01f,
  5.22821769e-02f, 3.26494634e-01f, -8.18025619e-02f, 3.40317041e-02f, 1.37491385e-02f, -1.77804157e-02f, 2.15553660e-02f, -2.57215858e-01f, 2.25672171e-01f, -4.12508436e-02f,
  1.79469049e-01f, 1.85374960e-01f, -1.11563258e-01f, -1.21037581e-03f, 7.95527026e-02f, -1.07312247e-01f, -2.12504100e-02f, -2.00619623e-01f, -6.64332435e-02f, -2.17223465e-02f,
  -1.35575473e-01f, 3.96547541e-02f, 1.54563570e-02f, -3.41113582e-02f, 1.28208343e-02f, 1.50013738e-03f, 6.49037864e-03f, -4.03546393e-02f, -8.27233344e-02f, -9.19992775e-02f,
  -6.13827296e-02f, -5.33951120e-03f, -2.99123675e-02f, 2.50572078e-02f, -7.22365379e-02f, 3.85620520e-02f, -7.36874938e-02f, -9.53341946e-02f, 3.79833914e-02f, 1.37388378e-01f,
  5.45056313e-02f, 3.69688720e-02f, 2.87238732e-02f, 2.16208920e-02f, 7.39028379e-02f, -1.92792434e-02f, -2.05194559e-02f, -1.01141641e-02f, 2.40053330e-03f, 6.99544400e-02f,
  2.49143820e-02f, 3.65803414e-03f, 9.13854595e-03f, 6.84351148e-03f, 9.32569429e-02f, -4.86883055e-03f, -5.04040644e-02f, -5.71019773e-04f, 4.07738192e-03f, 1.67363081e-02f,
  -1.56970285e-02f, 2.95536383e-03f, 2.93298066e-02f, -3.21573541e-02f, 4.38659526e-02f, -6.70830458e-02f, -1.82754472e-02f, -7.16767088e-03f, 3.08871474e-02f, -2.97071002e-02f,
  1.81880996e-01f, 2.82240182e-01f, 2.68738847e-02f, 1.02663063e-01f, 3.89741696e-02f, 3.63075323e-02f, -1.38709694e-02f, -2.04108423e-03f, 1.79734770e-02f, 5.37420437e-02f,
  9.81068462e-02f, 3.36811431e-02f, 2.10395525e-03f, 3.72167528e-02f, 5.10901809e-02f, -2.54545249e-02f, 5.20748831e-02f, -4.79161851e-02f, 1.21832892e-01f, 1.86271161e-01f,
  -8.77253187e-05f, -1.48917725e-02f, -1.76672898e-02f, 8.45815688e-02f, 1.14408061e-02f, 4.88002822e-02f, 2.22393591e-02f, 4.28930372e-02f, -7.47017469e-03f, -9.48114321e-02f,
  -2.57105649e-01f, -2.42586751e-02f, -2.96131998e-01f, -2.50592887e-01f, 1.45742660e-02f, 4.22491059e-02f, 1.27361536e-01f, -1.60996363e-01f, -3.65089804e-01f, 2.41115481e-01f,
  2.62042046e-01f, -7.52884597e-02f, 1.50471628e-01f, 1.74702823e-01f, -1.62144378e-01f, 1.27223819e-01f, -1.25080481e-01f, 9.74427015e-02f, -2.18601868e-01f, -1.66914850e-01f,
  -1.40988648e-01f, 3.29654455e-01f, -1.43560812e-01f, -3.24089676e-02f, 8.41768011e-02f, -2.52933443e-01f, 2.78490007e-01f, 7.01816604e-02f, 1.07432313e-01f, 2.48239562e-02f,
  -1.69092789e-02f, 5.58253319e-04f, 4.38786894e-02f, -7.27246180e-02f, -4.01514359e-02f, 9.22433957e-02f, 2.69741453e-02f, 1.17739402e-01f, -1.23408981e-01f, -7.32781440e-02f,
  -2.59808358e-02f, 4.88768332e-04f, -5.21002635e-02f, 7.72546008e-02f, -6.69246763e-02f, -1.12309791e-02f, -5.42989410e-02f, -3.18645276e-02f, -5.33963330e-02f, 3.19388025e-02f,
  -3.37318773e-03f, 3.20506394e-02f, -1.10663667e-01f, 6.77959323e-02f, -1.11080939e-02f, -4.20245528e-02f, 7.54643639e-04f, 2.01108269e-02f, 4.10648845e-02f, -1.42003715e-01f,
  6.92186356e-02f, -2.12097745e-02f, 6.78714812e-02f, -7.03852177e-02f, 6.79706335e-02f, 1.02404458e-02f, 2.83030868e-02f, 7.86521211e-02f, -4.30717096e-02f, 6.30406514e-02f,
  -4.55140322e-03f, 5.55691458e-02f, 2.32141912e-02f, 8.85651261e-02f, 8.18491355e-02f, -2.41431724e-02f, -2.06174236e-02f, 5.34974597e-02f, -1.10863514e-01f, -4.52915719e-03f,
  1.05679939e-02f, -3.30492519e-02f, 2.35340521e-02f, -1.47134392e-03f, 3.84803563e-02f, 1.69915967e-02f, 5.76309375e-02f, -9.72013827e-03f, 1.46755120e-02f, 1.00193746e-01f,
  -1.00020193e-01f, -6.75499067e-02f, -1.03839217e-02f, 3.11008189e-02f, -6.60316041e-03f, 7.42766708e-02f, 2.45400965e-02f, -5.24500683e-02f, 3.14153284e-02f, 8.73677284e-02f,
  3.04599609e-02f, 4.59137857e-02f, -3.97341177e-02f, 8.09037965e-03f, -5.87502904e-02f, 3.73489857e-02f, 9.43803508e-03f, -3.93691622e-02f, -5.23909107e-02f, 5.82911596e-02f,
  1.50589198e-01f, 6.82089180e-02f, 5.35027497e-03f, 1.06505025e-02f, 3.39466557e-02f, 6.92624450e-02f, -6.29292242e-03f, -9.38802660e-02f, 7.02288374e-02f, 3.60825546e-02f,
  2.07641631e-01f, 1.13703109e-01f, -3.38076092e-02f, 4.98462841e-02f, 7.68318623e-02f, 3.48860085e-01f, 4.83159609e-02f, 7.46329874e-02f, -5.68574108e-02f, -9.20534804e-02f,
  -9.17389542e-02f, 1.10347673e-01f, -1.35200888e-01f, 1.46915123e-01f, 2.92929977e-01f, -2.02784643e-01f, 2.20847875e-01f, 1.16107434e-01f, -1.86624750e-01f, 2.49467075e-01f,
  2.41897143e-02f, 1.16419062e-01f, -6.12903200e-03f, 6.22742623e-02f, 1.68537110e-01f, -8.87168944e-02f, -2.12645039e-01f, -7.46931806e-02f, 1.71785250e-01f, 9.39865038e-02f,
  1.26042053e-01f, 2.58475076e-02f, -1.58670172e-02f, -5.68303242e-02f, 2.45341919e-02f, -1.81092937e-02f, 2.42513604e-02f, -1.24467909e-01f, -1.61509458e-02f, 3.78253199e-02f,
  4.63654809e-02f, 7.17604458e-02f, 2.82186531e-02f, -2.63916552e-02f, 5.90273403e-02f, -4.52042650e-03f, 4.09173779e-02f, -7.03191338e-03f, -5.66198975e-02f, 1.52479233e-02f,
  -1.21740382e-02f, 2.40607802e-02f, -6.38692966e-03f, 4.73126844e-02f, -7.53166080e-02f, -4.91749868e-02f, -9.48036313e-02f, 6.02992438e-03f, 1.46460697e-01f, 9.21245590e-02f,
  2.33739410e-02f, -1.05533056e-01f, -2.67765019e-02f, 2.26017479e-02f, 3.18192653e-02f, -2.82123908e-02f, -2.72819307e-02f, 3.04288673e-03f, -9.01256576e-02f, 2.10769717e-02f,
  9.23973545e-02f, -3.70423272e-02f, -5.08098491e-02f, -6.23828173e-02f, -5.39077073e-02f, -9.35696214e-02f, 1.01824747e-02f, 5.23639731e-02f, 3.54738049e-02f, -2.33658683e-02f,
  1.95254162e-02f, 8.52883831e-02f, 3.13044935e-02f, -5.88014685e-02f, 6.88236430e-02f, -2.00330745e-02f, -7.01444522e-02f, 4.23469134e-02f, -4.30138223e-03f, 3.03671509e-02f,
  2.45331362e-01f, 2.46345982e-01f, -4.15559486e-02f, 1.15283482e-01f, 7.09911287e-02f, -6.70969067e-03f, -8.79914388e-02f, 5.38275624e-03f, 4.37224098e-02f, 3.42112817e-02f,
  -7.92891830e-02f, -2.00698022e-02f, -8.91577173e-03f, -1.15202543e-04f, 1.95720252e-02f, 7.70995021e-03f, 9.13806166e-03f, -2.11750325e-02f, 1.10464074e-01f, 6.64497465e-02f,
  6.41969889e-02f, 7.34593347e-02f, -4.68863919e-02f, -1.55428015e-02f, -3.81941609e-02f, 3.23247500e-02f, 9.66723040e-02f, -1.97305437e-02f, -2.57036276e-03f, 3.90098765e-02f,
  -3.25540394e-01f, 7.10798055e-02f, -3.24082166e-01f, -1.35871570e-03f, -6.57892898e-02f, 3.23918581e-01f, 1.77047536e-01f, 4.94098887e-02f, 9.87768918e-02f, 2.63704032e-01f,
  2.32646585e-01f, 4.72552031e-02f, -5.57866879e-03f, 3.26789051e-01f, -9.08401161e-02f, 1.55239642e-01f, 1.06460214e-01f, 2.00630441e-01f, -1.02782607e-01f, -1.17629349e-01f,
  -1.96531773e-01f, 3.67619544e-01f, -4.51016873e-02f, 5.67294136e-02f, 1.78366043e-02f, -1.47881448e-01f, -5.68906553e-02f, -4.82563563e-02f, 3.01043928e-01f, 1.23903140e-01f,
  5.00866175e-02f, 3.42098549e-02f, 5.84953837e-02f, 2.49993950e-02f, 3.86383012e-03f, -1.40866498e-02f, 3.22357565e-02f, -3.57388370e-02f, -6.55986518e-02f, -5.43650910e-02f,
  3.69406193e-02f, -6.68890998e-02f, 5.70248440e-02f, 5.94753958e-02f, -5.76288328e-02f, -5.45884632e-02f, -3.64773497e-02f, -6.51470721e-02f, 7.38240480e-02f, -9.50074568e-02f,
  1.82324543e-03f, -1.14535682e-01f, -4.65087406e-02f, 1.29634207e-02f, -4.44196761e-02f, 5.04505299e-02f, 3.83620374e-02f, -4.96280417e-02f, -6.51953965e-02f, -5.22339530e-02f,
  -4.58370596e-02f, -4.60765354e-04f, -6.17195629e-02f, 1.40303578e-02f, -3.30332927e-02f, 1.47197088e-02f, -5.11421636e-03f, -8.61064624e-03f, -2.98922081e-02f, -5.88768302e-03f,
  -4.53729779e-02f, -3.99306305e-02f, 2.24561300e-02f, 6.14153929e-02f, 5.15285786e-03f, 4.73721921e-02f, -7.29678497e-02f, 3.36089432e-02f, -6.00554794e-02f, 2.26750672e-02f,
  2.70057227e-02f, -3.88259776e-02f, 6.90663159e-02f, 5.24889864e-02f, 1.15748076e-02f, -2.65639387e-02f, 5.41402623e-02f, -2.75927838e-02f, 4.16430496e-02f, -6.30855411e-02f,
  7.66081214e-02f, 1.02894241e-03f, 3.54092903e-02f, 5.45879193e-02f, -5.89464977e-03f, -5.48265763e-02f, 3.89180100e-03f, -2.96884496e-02f, 2.36934405e-02f, -2.75125634e-02f,
  -7.42845014e-02f, 7.20102638e-02f, -1.21811135e-02f, 6.43213391e-02f, -7.19100377e-03f, 2.48761545e-03f, 2.99584419e-02f, 7.78261125e-02f, 2.15724614e-02f, -8.95899627e-03f,
  -1.01637216e-02f, 3.46029028e-02f, -7.56822433e-03f, 1.41829342e-01f, 6.91531319e-03f, 5.09689525e-02f, -3.89105678e-02f, -2.01983526e-02f, -7.13990405e-02f, 2.51081735e-02f,
  -3.73203874e-01f, 2.29935303e-01f, 7.67434537e-02f, 6.83373809e-02f, -1.22535966e-01f, 1.50077865e-01f, 9.18984488e-02f, 1.29038677e-01f, 7.23360106e-02f, 1.65543705e-01f,
  1.13797868e-02f, 1.02983832e-01f, 1.97622880e-01f, 3.09820592e-01f, 1.62019685e-01f, 2.60331124e-01f, 2.32929260e-01f, 4.42315154e-02f, 5.27442321e-02f, 8.24837461e-02f,
  -7.55361170e-02f, 1.72518879e-01f, 2.16453940e-01f, 6.73835278e-02f, -1.62766248e-01f, -1.47199973e-01f, -8.48780125e-02f, 6.37592077e-02f, 6.43638819e-02f, 1.99325774e-02f,
  -2.46251258e-03f, 8.36052671e-02f, 1.81087162e-02f, 3.37226503e-03f, 3.72360162e-02f, -7.33575225e-02f, -9.18849632e-02f, 1.20276213e-02f, 8.09202529e-03f, -3.79624637e-03f,
  -9.86117199e-02f, 4.93342578e-02f, 6.78096116e-02f, 9.40826759e-02f, -1.82931423e-01f, 3.12375464e-02f, 4.57854383e-02f, -1.19065441e-01f, 1.29163131e-01f, -2.68696509e-02f,
  6.73085451e-02f, -1.90969429e-03f, -2.39155069e-02f, 6.77506477e-02f, -3.67792733e-02f, -3.61781679e-02f, 9.25546065e-02f, -8.92230794e-02f, -3.79521437e-02f, 7.46721402e-02f,
  4.66491282e-03f, -6.10059537e-02f, -8.58353153e-02f, -1.22771136e-01f, 8.20624009e-02f, -1.13428213e-01f, -4.46370505e-02f, 8.35248269e-03f, -3.43989320e-02f, 3.20601426e-02f,
  -6.58917800e-03f, 2.97928862e-02f, 1.88136089e-03f, -1.93504412e-02f, 1.93459317e-02f, 4.18802164e-02f, -1.71605870e-02f, 8.28215852e-03f, 1.38255507e-02f, 4.27352302e-02f,
  -8.94512981e-03f, 7.18321130e-02f, 6.44271728e-03f, 1.05427187e-02f, 2.54707690e-02f, 6.54950142e-02f, -1.86549947e-02f, 2.32683886e-02f, -9.19118300e-02f, -4.09121029e-02f,
  1.53144598e-01f, 2.75504440e-01f, 1.32283717e-01f, 1.27104586e-02f, 2.67377794e-02f, 2.63321865e-02f, 3.23589444e-02f, -9.05987341e-03f, 2.39286926e-02f, 7.41428733e-02f,
  -1.39185712e-02f, -1.94175653e-02f, -6.93002939e-02f, -5.79807395e-03f, -3.07958573e-03f, 4.32102010e-03f, -2.64441166e-02f, 7.37180701e-04f, -7.18672574e-02f, -2.23327894e-02f,
  4.93463688e-03f, 3.82353086e-03f, -3.95267084e-02f, -1.49322990e-02f, -4.60678525e-03f, 2.57045142e-02f, -2.25378573e-03f, -3.71212997e-02f, 7.00835362e-02f, 1.63892172e-02f,
  3.25055182e-01f, -1.73607424e-01f, 2.78928578e-02f, 1.48253128e-01f, -1.69403374e-01f, 1.34826511e-01f, 1.30479753e-01f, -2.98477709e-01f, -1.41620681e-01f, 3.62117924e-02f,
  -8.06021094e-02f, 3.85302722e-01f, -9.51363966e-02f, 1.08084522e-01f, 3.20190132e-01f, -5.80150448e-02f, 1.33933783e-01f, 1.80157840e-01f, -2.36969128e-01f, 9.11102816e-02f,
  -7.96144828e-02f, 3.68299559e-02f, 2.72855423e-02f, -1.81852609e-01f, -8.46837163e-02f, -8.41998830e-02f, 5.94926588e-02f, -1.80455819e-01f, 1.20684408e-01f, 6.49921736e-03f,
  -5.87284565e-02f, -5.29569350e-02f, 3.55204232e-02f, 6.87909266e-03f, 4.28908281e-02f, 3.37143242e-02f, 1.65038705e-01f, 3.77342999e-02f, 1.20377690e-02f, -2.15152297e-02f,
  2.05673110e-02f, 1.10562131e-01f, 5.79214655e-02f, -6.64622337e-02f, -2.93582305e-02f, -8.37906525e-02f, 1.01431774e-03f, -1.76983997e-02f, -4.90996130e-02f, 2.67422609e-02f,
  -6.40031770e-02f, 2.78203096e-02f, 3.51430289e-02f, -5.89985028e-03f, -1.94089431e-02f, 5.03606498e-02f, 6.74449727e-02f, 5.56571446e-02f, 7.07207844e-02f, 1.00354880e-01f,
  3.89618427e-02f, -5.33168763e-02f, 3.22699063e-02f, 2.57206205e-02f, -3.02746631e-02f, -8.25262517e-02f, 9.91111025e-02f, 1.45812733e-02f, -1.43551147e-02f, 2.20144168e-02f,
  3.59275304e-02f, 2.50263847e-02f, -9.17862579e-02f, 8.71715974e-03f, 4.84484397e-02f, -1.83205325e-02f, 1.35263056e-01f, 3.67709137e-02f, -3.00497748e-02f, 3.63045372e-02f,
  -8.33221152e-02f, 2.61004921e-02f, -2.68101189e-02f, 5.51438779e-02f, -7.32620293e-03f, 8.53073318e-03f, -4.65417653e-02f, -5.46742417e-02f, -2.71325223e-02f, 3.40417288e-02f,
  -7.48014124e-03f, -7.25930091e-03f, -7.73698390e-02f, 2.10097916e-02f, -7.73459896e-02f, -2.33371351e-02f, -6.33590892e-02f, 5.60492929e-03f, -1.00273630e-02f, -2.45319083e-02f,
  2.90489364e-02f, -8.10525790e-02f, 8.24704096e-02f, -2.35342588e-02f, 1.18660465e-01f, 1.18675067e-04f, 1.37696981e-01f, -3.51089761e-02f, 1.40780702e-01f, -3.01907156e-02f,
  8.82667862e-03f, 9.02638212e-03f, 7.89668038e-02f, -6.99638948e-02f, 9.63671803e-02f, 7.69302696e-02f, 7.78555647e-02f, -5.27804345e-02f, 8.13179277e-03f, 2.94549838e-02f,
  -3.78001541e-01f, 2.27486402e-01f, -2.35510305e-01f, 1.20076008e-01f, 4.58254591e-02f, 1.35222822e-01f, 8.16964358e-02f, 1.72056839e-01f, 8.59918073e-02f, 3.48924488e-01f,
  3.22976083e-01f, -1.65583387e-01f, 3.01469147e-01f, 1.60386905e-01f, -2.60162890e-01f, 2.30800942e-01f, 7.47079998e-02f, 6.23703189e-02f, 1.15032028e-02f, 1.28855601e-01f,
  -3.42224725e-03f, 3.53982896e-01f, 3.17100808e-02f, 1.47445291e-01f, 7.81935304e-02f, -3.95328552e-02f, 1.60201177e-01f, -4.49208431e-02f, 1.86905861e-02f, -1.30292326e-01f,
  3.53649072e-02f, 6.84946179e-02f, -1.29608467e-01f, -8.00026357e-02f, -4.15694993e-03f, -9.18433145e-02f, -8.51548165e-02f, -6.47623837e-02f, 4.80585210e-02f, -3.44147943e-02f,
  -7.74485394e-02f, 5.47725428e-03f, -4.18319888e-02f, -1.46868592e-02f, 3.09499670e-02f, -9.45563689e-02f, -1.24251759e-02f, -1.09543167e-02f, 9.74415988e-02f, -6.28046393e-02f,
  -2.91562248e-02f, -6.42489195e-02f, 1.57135446e-02f, -2.04738956e-02f, -2.25672014e-02f, 1.99519731e-02f, 6.76656049e-03f, -8.92279670e-02f, -1.04609877e-02f, -1.89080164e-02f,
  -3.64641733e-02f, 2.31549088e-02f, 5.34515269e-02f, 5.27603598e-03f, 5.63839860e-02f, 4.16298909e-03f, 9.60623473e-02f, -2.04777140e-02f, -6.66260719e-02f, 9.74563882e-03f,
  -1.83775253e-03f, -8.78332481e-02f, 3.79732363e-02f, 5.58192097e-02f, 3.35715599e-02f, -2.38884501e-02f, -1.29344851e-01f, -3.95259820e-02f, 3.80792357e-02f, -1.05926057e-03f,
  -1.46828266e-02f, -6.93217991e-03f, 7.18951086e-03f, -3.77885103e-02f, 4.18279804e-02f, -1.33731999e-02f, 6.47017434e-02f, -3.07258535e-02f, 1.46479502e-01f, -2.97260396e-02f,
  1.44729644e-01f, 1.93593726e-01f, 7.19441324e-02f, 8.78896564e-03f, 2.07647718e-02f, -1.56284608e-02f, -1.64110325e-02f, -8.90560970e-02f, -7.62991980e-02f, 1.20715968e-01f,
  -1.36583904e-02f, 2.97105722e-02f, -5.50334016e-03f, -5.62917925e-02f, -1.45642273e-02f, 9.93955135e-02f, 7.71726444e-02f, -2.50800047e-02f, -2.67201662e-02f, 2.41712518e-02f,
  6.02413490e-02f, 3.50910611e-02f, -5.43499440e-02f, 3.60161141e-02f, 5.38297817e-02f, -7.40245879e-02f, -3.47622111e-02f, -5.24970181e-02f, 1.85466707e-02f, -4.24717329e-02f,
  6.12976253e-02f, -1.04286991e-01f, -1.71887651e-01f, -4.52830605e-02f, 1.87887684e-01f, -1.35282561e-01f, -2.01967508e-01f, 1.31508904e-02f, 3.43479663e-01f, -1.35552317e-01f,
  -1.90321982e-01f, 5.47350720e-02f, -1.56736642e-01f, -3.04205060e-01f, -7.91528448e-02f, -3.24061215e-02f, -7.71306530e-02f, -1.19288377e-01f, 1.05934143e-01f, -5.33995079e-03f,
  1.04934126e-01f, -1.85803369e-01f, -2.09211335e-01f, -1.10491915e-02f, -1.11299001e-01f, 1.31798267e-01f, -7.87322596e-02f, -5.27257174e-02f, -2.62336791e-01f, -1.69721186e-01f,
  -3.41376476e-02f, 3.21816653e-02f, -1.27024978e-01f, -8.13479573e-02f, -1.08432304e-02f, 1.97250079e-02f, -1.64928034e-01f, -1.28779739e-01f, 6.59001991e-02f, -6.85182363e-02f,
  4.80638957e-03f, 4.72185900e-04f, 1.84716322e-02f, 2.76270472e-02f, 3.12204938e-02f, 9.76427644e-02f, 4.92460057e-02f, 1.54795283e-02f, -3.68570462e-02f, 7.50649301e-03f,
  4.02635373e-02f, -1.40268421e-02f, 2.98051015e-02f, -1.12715006e-01f, 8.08767527e-02f, 1.74481124e-02f, -7.00823516e-02f, -8.34507495e-02f, 2.04592068e-02f, 1.38954427e-02f,
  4.83554304e-02f, 8.33395049e-02f, 1.72960572e-02f, -5.81005123e-04f, 1.51179349e-02f, -8.53058100e-02f, 4.66037914e-02f, -4.56068441e-02f, 1.40834106e-02f, -2.27666199e-02f,
  9.70449299e-02f, 2.88916957e-02f, -3.15613002e-02f, 2.78349388e-02f, -1.54315690e-02f, 5.17941192e-02f, -4.49810661e-02f, -2.06046700e-02f, 3.48085351e-02f, 4.96851420e-03f,
  1.63764064e-03f, -4.80594523e-02f, 7.97114596e-02f, -2.27316469e-02f, -1.97559390e-02f, -7.00507406e-03f, -4.32772785e-02f, -1.44925509e-02f, 5.29571399e-02f, -7.71722272e-02f,
  -2.35859561e-03f, 9.84541476e-02f, 4.65682335e-02f, -1.18241329e-02f, -8.34515095e-02f, -2.65908726e-02f, 5.58736846e-02f, -5.68181742e-03f, 4.60785627e-02f, -2.97945794e-02f,
  -2.02345401e-02f, -6.25763834e-03f, 6.00789376e-02f, 1.55850993e-02f, 1.95391420e-02f, -4.04468598e-03f, -7.41815427e-03f, 2.93186344e-02f, 6.26510978e-02f, -1.55054480e-02f,
  5.01949191e-02f, 1.37413368e-02f, -3.25203836e-02f, 7.32182041e-02f, 3.91763262e-02f, -8.66427273e-02f, 1.42257184e-01f, 2.44749561e-02f, 1.29393693e-02f, 4.24683131e-02f,
  4.27747816e-02f, 1.19328298e-01f, -1.13094792e-01f, -2.88584232e-01f, -2.22121298e-01f, 3.09933834e-02f, -5.78197241e-02f, -2.03245655e-01f, -3.64137702e-02f, 1.29506260e-01f,
  -2.49565125e-01f, 1.87970370e-01f, 1.19285911e-01f, -2.21420929e-01f, -1.79092586e-02f, 8.71421024e-02f, -8.68626088e-02f, 1.43814012e-01f, -6.58836886e-02f, -1.32312790e-01f,
  -8.05066079e-02f, -1.04033500e-01f, -6.26513734e-02f, -1.95575044e-01f, -5.23204096e-02f, -3.47291790e-02f, 5.79970367e-02f, 2.60434579e-02f, -6.80446401e-02f, 8.15096274e-02f,
  -1.17202379e-01f, -1.37144521e-01f, 1.71700101e-02f, 4.64790650e-02f, -4.33967225e-02f, 7.32359886e-02f, 8.76351520e-02f, -7.83882011e-03f, -6.56986535e-02f, -6.60447851e-02f,
  7.40326792e-02f, 4.99206176e-03f, 5.88887408e-02f, 6.62364587e-02f, 1.96621846e-02f, -8.48417655e-02f, -1.54592201e-01f, -8.06063339e-02f, 1.95065234e-02f, 8.56228992e-02f,
  -7.65065402e-02f, 3.76252341e-03f, -1.03718936e-01f, 1.23560026e-01f, -4.30211835e-02f, -9.25640091e-02f, 8.93453881e-02f, 7.05005452e-02f, -1.86436400e-02f, -1.66101810e-02f,
  3.63067649e-02f, 5.37692383e-02f, -4.95736636e-02f, -9.36670527e-02f, -1.29012033e-01f, 1.73745095e-03f, -2.44049355e-02f, -1.41424751e-02f, 1.07541531e-02f, -6.09808750e-02f,
  -5.43596819e-02f, -7.73580372e-02f, -7.25916848e-02f, 3.76250669e-02f, 2.67056492e-03f, 1.06826350e-01f, -4.98281457e-02f, 9.28276405e-02f, -7.22061098e-02f, -5.15403226e-02f,
  9.17972473e-04f, -8.03164989e-02f, -5.44792525e-02f, 3.43805812e-02f, 2.25218907e-02f, -5.35159595e-02f, -7.81777501e-02f, -4.50169966e-02f, -5.84204309e-02f, -1.29422862e-02f,
  1.22022934e-01f, 1.32679790e-01f, 5.64342737e-03f, -3.73989083e-02f, -4.96622324e-02f, -6.29693940e-02f, 5.14692664e-02f, -1.58532158e-01f, 6.41788542e-02f, -6.75554350e-02f,
  -2.95252800e-02f, 5.69152497e-02f, -3.27457972e-02f, -7.50397667e-02f, 4.18365411e-02f, -1.39871248e-04f, 1.04075603e-01f, 8.29445943e-02f, -2.34938376e-02f, 1.97998947e-03f,
  7.38775507e-02f, 1.73463544e-03f, 9.08417627e-02f, -9.25787240e-02f, -4.69386391e-03f, 7.53910318e-02f, 4.25985605e-02f, 1.53715843e-02f, 8.61085299e-03f, 7.58792832e-02f,
  4.74554569e-01f, -2.48896733e-01f, 2.94120103e-01f, 2.90150046e-01f, 3.56795155e-02f, 7.89126605e-02f, 3.72417569e-01f, 7.14995712e-02f, 1.96939275e-01f, -7.29782209e-02f,
  2.15021834e-01f, 1.00892141e-01f, 1.12010315e-01f, 6.01683445e-02f, 1.25922114e-01f, 6.23591803e-03f, 1.91169679e-01f, 1.30918100e-01f, -9.33319330e-02f, 1.38115391e-01f,
  1.03336126e-01f, -1.13419525e-01f, 2.68583685e-01f, -3.44448924e-01f, 2.30090886e-01f, -6.48932979e-02f, -1.83019415e-02f, 7.94084859e-04f, -5.67335859e-02f, -8.56770203e-02f,
  1.86543837e-02f, 2.86531031e-01f, 1.77670002e-01f, 7.73806646e-02f, 1.28866076e-01f, 1.05177850e-01f, -1.38362367e-02f, -6.23406209e-02f, -2.46627722e-02f, -2.58814939e-03f,
  -5.45441024e-02f, -6.13337681e-02f, -1.45238295e-01f, -4.73512933e-02f, 4.54918705e-02f, 8.20702612e-02f, -5.17999977e-02f, 8.40053782e-02f, -3.87133248e-02f, 2.83643287e-02f,
  1.32850885e-01f, -2.55549839e-03f, 1.56746432e-02f, -2.80128922e-02f, -1.13881640e-02f, -5.49688637e-02f, -1.11798737e-02f, 7.50912726e-02f, -3.34776975e-02f, 3.68358828e-02f,
  -5.94074954e-04f, -6.30347524e-03f, 8.18094835e-02f, -1.24612628e-02f, 1.51879955e-02f, 2.29490437e-02f, -5.00127748e-02f, -5.58362827e-02f, -1.58900693e-02f, 1.46915596e-02f,
  -6.17814530e-03f, -1.58284418e-02f, 6.54934382e-04f, 1.33386925e-02f, 1.17143020e-02f, 5.85912168e-02f, -2.83380542e-02f, -2.96579618e-02f, 2.95277201e-02f, -1.98881775e-02f,
  -1.33648394e-02f, -1.93831678e-02f, 9.66855958e-02f, -8.39660987e-02f, -1.59987975e-02f, 4.39454876e-02f, 2.93440418e-04f, 4.33311537e-02f, -2.67220363e-02f, -1.29819708e-02f,
  3.20951380e-02f, 1.00731671e-01f, -3.89937833e-02f, -5.64239025e-02f, -3.78842466e-02f, 5.49731869e-03f, -5.83997294e-02f, -6.48153573e-02f, 2.06590127e-02f, 4.39125746e-02f,
  5.49155958e-02f, -1.14255203e-02f, -2.22740546e-02f, 2.72661187e-02f, -2.75718123e-02f, -2.44037975e-02f, 1.98003110e-02f, -2.73788311e-02f, 4.17347811e-02f, -1.13125108e-01f,
  6.04715981e-02f, 8.67169946e-02f, -2.68048700e-02f, 4.88209240e-02f, -2.38693506e-02f, -7.76103232e-03f, 2.52405647e-02f, -1.30007965e-02f, -8.29819310e-03f, -3.24100964e-02f,
  -5.02490222e-01f, 1.54178832e-02f, -3.07868063e-01f, -2.73393273e-01f, 7.69017115e-02f, 4.95116770e-01f, 9.03040916e-02f, -5.28673902e-02f, -2.80734301e-01f, 9.04687420e-02f,
  1.58771619e-01f, -1.63458407e-01f, -3.20903547e-02f, 1.11965038e-01f, 1.62341803e-01f, 1.06948376e-01f, 1.53737187e-01f, 8.21302682e-02f, -6.20253198e-02f, -1.00623570e-01f,
  -1.70163184e-01f, 3.45875084e-01f, -6.05356917e-02f, 2.01401934e-01f, -1.60668582e-01f, -1.85011029e-01f, 1.58909619e-01f, -8.82497989e-03f, 1.71628937e-01f, 9.34648514e-02f,
  -2.33728141e-02f, -2.96085984e-01f, -1.13295339e-01f, -2.62806043e-02f, 1.04502949e-03f, -2.37798188e-02f, 5.00447117e-02f, -1.21167954e-02f, -7.72322863e-02f, 9.40108579e-03f,
  9.14477650e-03f, 6.98234886e-02f, 6.17615692e-03f, 4.85459864e-02f, -7.41197243e-02f, -2.02324372e-02f, -7.09824562e-02f, 3.39404866e-02f, -9.35568064e-02f, -2.75784954e-02f,
  -1.03957437e-01f, -3.66768092e-02f, -7.12607726e-02f, 6.94713071e-02f, -6.07231930e-02f, 1.70743037e-02f, 5.87184392e-02f, 1.79180056e-02f, 4.66064028e-02f, 3.39496732e-02f,
  -1.34376120e-02f, -3.42649668e-02f, 2.21565999e-02f, -1.80594195e-02f, -1.63359735e-02f, 6.35644272e-02f, -4.68153581e-02f, 1.04796760e-01f, -3.84763852e-02f, 3.24246436e-02f,
  -3.04517504e-02f, -4.59374897e-02f, -6.67952970e-02f, -1.39208976e-02f, -1.36175454e-02f, -2.08280720e-02f, -2.10905690e-02f, -1.28420349e-02f, -6.38788566e-02f, 4.90615964e-02f,
  -2.43837535e-02f, -1.25648398e-02f, -2.77904235e-02f, -1.58374980e-02f, 5.16243875e-02f, 9.59925540e-03f, -3.77968401e-02f, -6.06522188e-02f, -5.23813702e-02f, -1.95279717e-02f,
  1.81636810e-01f, 1.32810026e-01f, 3.87571268e-02f, 6.94954917e-02f, 5.98762520e-02f, 3.09829824e-02f, -7.28172734e-02f, 1.28761427e-02f, 3.66026498e-02f, 4.88341227e-02f,
  6.55086711e-03f, -3.23425978e-02f, 3.08418907e-02f, -5.13544381e-02f, 3.99350859e-02f, 6.13232031e-02f, 6.72433078e-02f, 1.79570951e-02f, 1.04409322e-01f, 4.14640009e-02f,
  1.06079258e-01f, 3.31987813e-02f, 2.60713957e-02f, 2.37617139e-02f, 9.12177488e-02f, -1.14675611e-02f, -3.07018147e-03f, -7.59832934e-02f, 4.92029004e-02f, -2.78867446e-02f,
  -1.32833004e-01f, -1.68579832e-01f, 5.34331463e-02f, 1.21815398e-01f, -9.84978899e-02f, -3.11491311e-01f, -2.91846432e-02f, -2.37873688e-01f, -7.18411356e-02f, -5.63519187e-02f,
  -3.80256921e-02f, 2.05853671e-01f, 1.67533085e-01f, -2.16272678e-02f, 3.36488694e-01f, 4.90909740e-02f, -9.31960940e-02f, 1.79167092e-01f, 6.63654208e-02f, -9.61182714e-02f,
  -1.27588391e-01f, 2.53016800e-02f, 1.68400913e-01f, -1.75494584e-03f, -2.69789815e-01f, 1.50693739e-02f, 1.24407046e-01f, 1.60135999e-01f, -3.39533910e-02f, 1.06100224e-01f,
  -2.21063226e-01f, -6.67296797e-02f, -1.68330356e-01f, 4.34946790e-02f, -2.30317503e-01f, -1.53597862e-01f, 1.93664357e-02f, 5.24031557e-02f, 9.58821625e-02f, 1.21619310e-02f,
  -7.16690393e-03f, -3.54327038e-02f, -2.48714685e-02f, 4.31496873e-02f, -1.19407274e-01f, -1.54515430e-02f, -9.12204268e-04f, -1.42305076e-01f, -1.14262365e-02f, -1.25297055e-01f,
  -7.00180531e-02f, -6.90191314e-02f, -6.10204451e-02f, 4.20209346e-03f, 5.38255386e-02f, -1.54198064e-02f, -2.35304073e-03f, 3.29632610e-02f, 1.60433576e-02f, -4.68667820e-02f,
  1.03444472e-01f, 7.97859281e-02f, -2.03840621e-02f, -3.56818475e-02f, 2.58795004e-02f, -1.16682276e-01f, 2.83309892e-02f, -4.39179316e-03f, 9.70899686e-02f, -5.89668602e-02f,
  -3.30783352e-02f, -7.03541785e-02f, -8.08151811e-02f, -2.55442057e-02f, 2.39847377e-02f, -8.40656310e-02f, 8.15808922e-02f, -9.15051531e-03f, -1.69246599e-01f, -9.20767486e-02f,
  3.96428220e-02f, 5.77896759e-02f, -3.07157543e-02f, -1.07996829e-01f, 1.04510576e-01f, 3.73001806e-02f, -9.58034024e-02f, -7.16321692e-02f, 9.77033377e-03f, 8.88065398e-02f,
  -1.08009681e-01f, 1.87717676e-01f, 3.07203047e-02f, -7.91206956e-02f, 9.96022746e-02f, -9.08450559e-02f, 9.74377058e-03f, -7.63626546e-02f, 1.34706363e-01f, -4.70437016e-03f,
  -1.08537711e-02f, -9.05040726e-02f, 3.91328149e-02f, 2.79476810e-02f, 1.35264277e-01f, -7.01005012e-02f, 8.75397995e-02f, 4.45494838e-02f, 1.34176407e-02f, -8.69318545e-02f,
  7.02483431e-02f, 1.97555386e-02f, -2.71389056e-02f, -1.47247791e-01f, -8.11025314e-03f, -8.83628353e-02f, 1.44614309e-01f, -1.50087604e-03f, 6.27609044e-02f, -6.15534745e-02f,
  -2.33258270e-02f, 2.88792580e-01f, -5.77263869e-02f, 1.39958858e-01f, 6.65694522e-03f, 5.45631126e-02f, 2.01544650e-02f, 1.40120432e-01f, 1.58769876e-01f, 2.51311570e-01f,
  6.17430955e-02f, 7.27432370e-02f, -1.39500648e-01f, 3.20115685e-01f, -3.56805682e-01f, -2.00025767e-01f, 2.08672434e-01f, 1.14652313e-01f, 6.52524596e-03f, -1.40397446e-02f,
  -1.50676921e-01f, 2.42377073e-01f, -1.58720076e-01f, 1.21567115e-01f, 6.86273724e-02f, 6.16363287e-02f, -1.99822605e-01f, -1.04128219e-01f, 1.63162172e-01f, 4.81879804e-03f,
  1.43363237e-01f, 1.03287257e-01f, 4.91782576e-02f, 7.39729628e-02f, -9.42301005e-02f, 1.02391541e-02f, -4.93838228e-02f, -1.73053965e-02f, -6.02854453e-02f, 3.54440436e-02f,
  -5.75996411e-04f, 8.09556171e-02f, 1.01484314e-01f, 3.82170500e-03f, 8.36272538e-02f, 7.74160475e-02f, 4.49949652e-02f, 1.08487410e-02f, 1.14404239e-01f, -5.24052493e-02f,
  -1.92462709e-02f, 4.46848832e-02f, -2.06828606e-03f, 3.93081121e-02f, -9.12583470e-02f, 2.73990370e-02f, 1.92919131e-02f, -1.31282378e-02f, 1.05279192e-01f, 3.69188823e-02f,
  2.17292737e-02f, -7.50149265e-02f, -1.73857249e-02f, 3.04060094e-02f, 7.53901228e-02f, -1.62759225e-03f, 1.74104739e-02f, 3.78106572e-02f, -1.01290017e-01f, 1.21943299e-02f,
  -1.69703346e-02f, 5.83150461e-02f, 1.31372188e-04f, -7.80703640e-03f, -7.34216208e-03f, 7.46340901e-02f, -4.71155569e-02f, -5.73191158e-02f, -2.70383973e-02f, 3.11008946e-04f,
  -6.52680695e-02f, -4.35048155e-02f, -2.92549916e-02f, 4.40140575e-04f, 3.39299589e-02f, -1.43855095e-01f, 6.86872303e-02f, 1.30990613e-02f, 1.32165076e-02f, -7.90503919e-02f,
  -4.94910702e-02f, -1.08019896e-01f, 1.88882835e-02f, 8.78816992e-02f, 5.77674247e-02f, 1.92403905e-02f, -6.27274904e-03f, 3.62567529e-02f, -5.60541302e-02f, -1.13180634e-02f,
  -4.18258905e-02f, -4.59019206e-02f, -9.53620672e-02f, 7.05515966e-02f, -2.29906496e-02f, -9.36135799e-02f, -7.10826814e-02f, -1.99754629e-02f, -4.48484942e-02f, 4.74646948e-02f,
  -6.21510185e-02f, 2.69471910e-02f, -1.58376135e-02f, -3.86530091e-03f, 1.86625719e-02f, -1.08789779e-01f, 1.32792834e-02f, 4.70635016e-03f, -9.46268439e-02f, 3.27798016e-02f,
  -4.56904531e-01f, -1.74646467e-01f, 9.66354460e-02f, -2.58676201e-01f, 2.68432405e-02f, 2.15012699e-01f, 6.93688318e-02f, -1.18808612e-01f, -3.55993390e-01f, -1.17871262e-01f,
  3.80042344e-02f, -3.52286279e-01f, 1.68951616e-01f, -3.44612300e-02f, 8.02314803e-02f, 1.18953682e-01f, 6.46666363e-02f, 7.98149500e-03f, -1.03850491e-01f, -5.74291348e-02f,
  -1.22763291e-02f, 1.20913520e-01f, 2.74699301e-01f, 6.31890446e-02f, -3.44351190e-03f, -7.88370147e-02f, 3.14213783e-01f, 1.64051339e-01f, 3.68827954e-02f, 2.56701838e-02f,
  4.98397052e-02f, -1.94324210e-01f, -3.13471109e-02f, -1.50879482e-02f, 1.54174432e-01f, 1.09431922e-01f, 9.87863764e-02f, 9.76884291e-02f, -3.23471390e-02f, -5.30596869e-03f,
  -2.86223032e-02f, -8.48986208e-02f, -2.43335422e-02f, -1.33925155e-02f, -5.26328944e-02f, -8.02543163e-02f, -9.04326737e-02f, -2.51737889e-03f, -2.67983321e-02f, -5.61518557e-02f,
  3.86127047e-02f, 5.30719608e-02f, 1.24547677e-02f, 4.58170846e-02f, 5.33595979e-02f, -5.80632463e-02f, 3.48127522e-02f, 8.38728100e-02f, 3.26623321e-02f, -1.47682190e-01f,
  -6.12391941e-02f, -1.29717603e-01f, -2.93685459e-02f, -7.55441263e-02f, 9.25574638e-03f, 6.52246475e-02f, -1.47724350e-03f, 1.90299764e-01f, -1.42178759e-02f, 1.04262205e-02f,
  5.21838338e-05f, -7.80156106e-02f, -7.34643489e-02f, -5.78270927e-02f, -7.44966492e-02f, 3.49472649e-02f, 1.33579494e-02f, 1.76901836e-02f, -6.07097596e-02f, -8.82199220e-03f,
  -7.04270005e-02f, 1.61652006e-02f, -2.37929099e-03f, 1.17502913e-01f, 6.27788380e-02f, -2.98363045e-02f, -2.18409896e-02f, -2.93181892e-02f, 7.64677301e-02f, 7.36476034e-02f,
  7.73379132e-02f, -8.35721716e-02f, 7.81468302e-02f, -1.43593000e-02f, 1.09233549e-02f, 1.77178327e-02f, -6.44291118e-02f, -6.81639984e-02f, -3.27904783e-02f, -5.79018006e-03f,
  6.46284297e-02f, 8.89607519e-02f, 1.99435782e-02f, -4.52953093e-02f, 1.08585559e-01f, -3.38366814e-02f, 2.73694675e-02f, 2.89068688e-02f, 1.43272996e-01f, 4.81205545e-02f,
  2.97286566e-02f, -5.42941839e-02f, 1.33698769e-02f, 4.33744565e-02f, 1.92303956e-02f, -5.18992469e-02f, -6.88928217e-02f, -1.01280756e-01f, 2.55080387e-02f, -2.63552479e-02f,
  -4.47340578e-01f, 1.44404918e-01f, -7.20013380e-02f, -1.35187805e-01f, -3.61449718e-01f, -6.54790774e-02f, -3.18581909e-02f, -1.24666907e-01f, 1.20159768e-01f, 2.60811806e-01f,
  -5.56385778e-02f, -1.81327626e-01f, 9.72554386e-02f, -1.23222917e-01f, -3.69130522e-01f, 1.49149582e-01f, -7.16677457e-02f, 1.15119154e-03f, -4.63579968e-02f, -2.35711947e-01f,
  -1.28693640e-01f, -5.56780323e-02f, -1.14612810e-01f, 1.12617753e-01f, -2.10592031e-01f, 1.22873388e-01f, 1.42244846e-01f, 7.26865903e-02f, -7.06832111e-03f, -7.71382824e-02f,
  -1.97950363e-01f, -3.69927138e-02f, -1.31341591e-02f, 4.35423106e-02f, -1.24964463e-02f, 3.42421122e-02f, -3.94042917e-02f, 7.96761289e-02f, -4.89548855e-02f, -9.38133001e-02f,
  3.97714302e-02f, -1.52778149e-01f, -7.83888064e-03f, 9.56272483e-02f, -5.16128843e-04f, -4.35808077e-02f, -7.48313665e-02f, -1.43608870e-02f, -1.20181024e-01f, -2.30369009e-02f,
  -2.32854448e-02f, -1.55612146e-02f, 2.10934337e-02f, 2.33521927e-02f, -5.21162674e-02f, -8.27108696e-02f, 9.33494940e-02f, -1.76278986e-02f, 2.39597936e-03f, -4.60933242e-03f,
  5.28719425e-02f, 1.19097084e-01f, -1.51045267e-02f, -3.71900536e-02f, -3.54496688e-02f, -6.06100075e-02f, 3.17303315e-02f, -7.76659045e-03f, 2.76429784e-02f, -3.13392542e-02f,
  -3.93831022e-02f, -5.94831817e-03f, 1.57109462e-02f, 9.97737870e-02f, 4.12922204e-02f, -3.29752080e-02f, 4.30357233e-02f, -2.98390444e-02f, -5.21714520e-03f, -1.64925940e-02f,
  -5.98982349e-03f, 4.16478813e-02f, 4.53610756e-02f, -5.20030297e-02f, -1.54759679e-02f, -9.16228164e-03f, 7.85746872e-02f, -3.98003682e-02f, -3.97298746e-02f, -1.32186366e-02f,
  -9.70612019e-02f, 1.21249653e-01f, 9.98636112e-02f, -7.45581836e-02f, 5.63759357e-02f, 4.61479509e-03f, 7.72180455e-03f, -1.96302775e-02f, 7.58020356e-02f, 2.74887159e-02f,
  -3.70868556e-02f, 6.13334309e-03f, 5.28523959e-02f, -4.28394042e-02f, 6.54411037e-03f, -6.17976189e-02f, 3.17788981e-02f, 4.36838008e-02f, -1.03634492e-01f, -5.47820218e-02f,
  9.75728966e-03f, -1.85493696e-02f, -2.12321505e-02f, -5.08079827e-02f, -2.01472435e-02f, -2.59749442e-02f, -1.62781086e-02f, 2.91498192e-02f, -3.89084741e-02f, 3.91715877e-02f,
  -3.48981082e-01f, 1.91000685e-01f, -4.29368503e-02f, 1.29140262e-02f, -1.91780582e-01f, -1.39917627e-01f, -1.83712810e-01f, -7.72730261e-02f, -2.24692672e-01f, 1.18344344e-01f,
  -9.84281451e-02f, 2.45679691e-01f, -1.32660747e-01f, 1.05153210e-01f, -3.33478153e-01f, -1.93753749e-01f, 2.81770192e-02f, 5.94747663e-02f, 7.63680488e-02f, -1.95106953e-01f,
  -6.89707845e-02f, -1.87415108e-01f, 5.80166898e-06f, 5.72334230e-02f, -3.04272268e-02f, 2.31121376e-01f, 1.23431198e-01f, 1.01912901e-01f, 3.35667551e-01f, 1.29632309e-01f,
  -9.55169350e-02f, -7.94495866e-02f, 1.41541988e-01f, 9.49862897e-02f, -1.13684200e-01f, 1.09040166e-05f, -7.35657215e-02f, -7.57104019e-03f, -4.72468808e-02f, 5.18756732e-02f,
  5.46835102e-02f, -1.09440602e-01f, 1.45038381e-01f, -6.92604808e-03f, -8.08010250e-02f, 7.91990235e-02f, 4.71831672e-02f, 8.28476027e-02f, 3.16493288e-02f, -4.99635302e-02f,
  6.10361248e-02f, 4.41134050e-02f, -3.12003903e-02f, 1.05808437e-01f, -3.05187255e-02f, 5.15834950e-02f, 9.95204449e-02f, -1.16767408e-02f, -2.43117027e-02f, 1.97310913e-02f,
  2.59782933e-02f, -1.59855541e-02f, 1.09396707e-02f, 4.79320437e-02f, 4.16632928e-02f, -2.40876321e-02f, 4.11866233e-02f, 6.67879581e-02f, 1.65361106e-01f, -2.78657470e-02f,
  -5.58272116e-02f, -3.98192815e-02f, -2.06152722e-02f, -1.49379019e-02f, 1.12177618e-01f, 4.16373312e-02f, -8.10104162e-02f, 6.35660589e-02f, -2.30944045e-02f, -3.15873022e-03f,
  -9.46778245e-03f, -8.35759845e-03f, 3.41794863e-02f, 1.13627598e-01f, -9.29797255e-03f, -6.02933094e-02f, 5.08304425e-02f, 3.39021422e-02f, 7.33835017e-03f, -3.09615489e-02f,
  -1.15195982e-01f, -2.35764846e-01f, 2.09027492e-02f, 8.56472254e-02f, 4.90454175e-02f, 9.89780501e-02f, 9.73929614e-02f, 5.04034534e-02f, -6.88228533e-02f, -5.28683811e-02f,
  -3.37154344e-02f, 1.20491214e-01f, -1.40682859e-02f, 4.43278588e-02f, 2.25988720e-02f, -1.52921885e-01f, -3.90548743e-02f, 4.21697088e-03f, -8.49257484e-02f, 7.58806020e-02f,
  7.96765909e-02f, -5.45086376e-02f, 1.30222604e-01f, -1.41884498e-02f, 3.21527459e-02f, 5.18919751e-02f, -1.48325628e-02f, 1.11194260e-01f, 8.29664525e-03f, 6.27724500e-03f,
  1.56687349e-01f, 1.46096200e-01f, 3.00387710e-01f, -1.33104250e-01f, 3.49097662e-02f, 1.92249596e-01f, 2.54310012e-01f, -3.35735492e-02f, 1.65008232e-01f, 1.49155958e-02f,
  -4.82711233e-02f, -3.99184376e-02f, 1.17508069e-01f, -3.00223321e-01f, -8.66697431e-02f, -1.56990871e-01f, -2.94919580e-01f, -1.46184325e-01f, -2.64230490e-01f, -1.26603082e-01f,
  -2.45215625e-01f, -3.98190290e-01f, -1.24694683e-01f, -2.85296887e-01f, -9.01367143e-02f, -6.36952221e-02f, -1.58021271e-01f, -1.49714835e-02f, -1.42567873e-01f, -2.05907710e-02f,
  -1.32239029e-01f, -4.15433496e-02f, 8.88964385e-02f, 1.06981896e-01f, -4.69894223e-02f, -1.20974798e-02f, -1.85604859e-02f, 1.96313728e-02f, 2.39143204e-02f, -8.96362588e-03f,
  1.45838350e-01f, -5.68962209e-02f, -8.92877653e-02f, 8.53033811e-02f, 7.70736113e-02f, 7.33629242e-02f, 6.66976580e-03f, 1.59848556e-02f, 6.56654686e-02f, 5.07116877e-02f,
  3.97867039e-02f, 3.24517279e-03f, 1.19353324e-01f, 2.14964971e-02f, 6.45614937e-02f, 1.28972933e-01f, 7.13598505e-02f, 1.13816857e-02f, 2.26971414e-02f, 6.00946210e-02f,
  5.21910973e-02f, 6.43865243e-02f, 8.54705870e-02f, 8.60593375e-03f, -2.51872707e-02f, 1.89521983e-02f, 7.41750300e-02f, -2.47239303e-02f, 6.78245723e-02f, -1.97928622e-02f,
  -2.32001320e-02f, -1.34495599e-02f, 1.20290350e-02f, 1.18293174e-01f, -7.51935504e-03f, 6.61602691e-02f, -4.31076698e-02f, 4.19889688e-02f, -6.41091317e-02f, -5.62141426e-02f,
  -1.16288904e-02f, 3.44398506e-02f, -5.88336661e-02f, -2.35104635e-02f, 1.19729973e-01f, -1.41768567e-02f, -5.93500771e-03f, 5.46777807e-02f, -5.49168885e-02f, 2.92569622e-02f,
  -4.05740105e-02f, -2.07051441e-01f, -3.63370590e-02f, 1.55657502e-02f, 3.91348684e-03f, -2.21518911e-02f, -4.32864428e-02f, -4.45986576e-02f, 5.03098650e-04f, -2.03054287e-02f,
  -3.26436535e-02f, -5.03305532e-03f, -1.68231037e-02f, 6.19236496e-04f, -9.73918959e-02f, 4.06990349e-02f, 1.51671683e-02f, -2.30459846e-03f, 1.44978911e-02f, -8.91400874e-02f,
  -7.19266981e-02f, -8.44628811e-02f, -4.96653840e-02f, -1.10713974e-01f, -5.83785549e-02f, -6.28557876e-02f, 3.77399549e-02f, 1.13204345e-02f, -1.16750345e-01f, -3.51618826e-02f,
  7.01814294e-02f, -2.87686050e-01f, 1.03026710e-01f, 1.74310476e-01f, 1.24232307e-01f, 1.63890615e-01f, 7.79899582e-02f, 4.93852310e-02f, 2.40213707e-01f, -4.09556419e-01f,
  -8.73896480e-02f, -2.01381356e-01f, -9.68218744e-02f, -2.17904285e-01f, 4.06846076e-01f, 9.80795473e-02f, -3.27818878e-02f, -3.40512185e-03f, 2.08623901e-01f, -2.06348270e-01f,
  1.90389723e-01f, -2.16429710e-01f, 5.28386720e-02f, -1.56118035e-01f, -7.72150010e-02f, -6.08393364e-02f, -2.13381007e-01f, 8.24466571e-02f, -3.24015260e-01f, 1.09929986e-01f,
  1.21224254e-01f, 5.08439168e-02f, -2.05252366e-03f, -3.15936469e-03f, -3.34762223e-02f, 1.09797036e-02f, 6.12590183e-03f, 1.22605404e-02f, 1.29922897e-01f, -8.69723707e-02f,
  -9.46480110e-02f, -9.30244997e-02f, -1.59130376e-02f, 9.09423530e-02f, -1.69611685e-02f, -3.18730101e-02f, 3.76689620e-02f, -2.46808622e-02f, 4.33621323e-03f, 5.14497608e-02f,
  2.58468613e-02f, 3.14737968e-02f, 1.87266134e-02f, -5.33333868e-02f, 7.47234598e-02f, 7.74461403e-02f, 3.42820361e-02f, -2.36125290e-02f, -1.71091780e-02f, 2.01803464e-02f,
  -6.49477988e-02f, 4.74880673e-02f, -5.41305868e-04f, -2.37977058e-02f, 4.37511690e-02f, 1.11077139e-02f, -5.55097349e-02f, -1.10827275e-01f, 5.97389527e-02f, -4.08581868e-02f,
  -7.28346407e-02f, -6.14237273e-03f, 3.77541594e-02f, 2.15528067e-02f, -1.02017470e-01f, -1.83618236e-02f, -2.23318841e-02f, 1.63921416e-02f, -5.16150221e-02f, 6.39519021e-02f,
  -2.38700304e-02f, 7.61122257e-02f, -2.31809877e-02f, -2.11905334e-02f, 3.45908813e-02f, -1.18116115e-03f, -1.56053171e-01f, -9.54708271e-03f, 2.95000151e-02f, 1.91656984e-02f,
  -1.07899837e-01f, -2.18028083e-01f, 3.90430652e-02f, -1.65480189e-02f, -2.31929938e-03f, -8.26379582e-02f, 4.13032342e-03f, 2.47929022e-02f, -9.43170302e-03f, -4.98949140e-02f,
  -1.31696701e-01f, 6.07964173e-02f, -8.81765187e-02f, 3.08119114e-02f, 4.22092602e-02f, -7.07623363e-02f, -2.07977556e-02f, 8.69801491e-02f, -9.71002355e-02f, -8.57871175e-02f,
  -7.79501069e-03f, -7.38708302e-02f, -4.67328317e-02f, -6.86513111e-02f, -6.23378046e-02f, -3.82321253e-02f, -4.47285287e-02f, 1.38109043e-01f, -1.97743736e-02f, 4.94689122e-03f,
  3.51585835e-01f, -1.76153287e-01f, 1.89272359e-01f, -1.25636697e-01f, 1.36184260e-01f, -1.12997599e-01f, 7.46489093e-02f, -5.79790352e-03f, -7.27613941e-02f, -1.66604996e-01f,
  -2.24831581e-01f, -1.23451456e-01f, -1.32109776e-01f, -3.61388385e-01f, -2.67061651e-01f, -3.52707863e-01f, -3.57939005e-01f, -1.60197929e-01f, -1.42065883e-01f, -5.40813208e-02f,
  -9.14680734e-02f, -2.05059052e-01f, 4.82454188e-02f, 1.23620937e-02f, 2.39003658e-01f, 1.95078373e-01f, -4.75725085e-02f, 1.91535473e-01f, -5.56260720e-02f, 1.36227626e-03f,
  1.28569201e-01f, 7.98776001e-02f, 1.40915304e-01f, 1.10603549e-01f, 3.76428440e-02f, 1.47510797e-01f, 1.52135551e-01f, -7.72384054e-04f, -1.64125487e-02f, 5.31193092e-02f,
  1.86776835e-02f, -3.30596566e-02f, -9.83236358e-02f, -7.13627487e-02f, 8.87478888e-02f, 7.36952946e-02f, -4.33767773e-02f, 2.43949946e-02f, -6.17364980e-02f, 7.33707696e-02f,
  -1.09671382e-02f, -1.05935372e-01f, -6.98320791e-02f, -5.26744723e-02f, -3.70447449e-02f, -6.74770772e-02f, -1.39202643e-02f, 9.78237391e-02f, -6.71855360e-02f, 1.05992675e-01f,
  -6.13866933e-02f, 2.01026183e-02f, -5.61449826e-02f, 5.13837412e-02f, -9.22891423e-02f, 1.19719133e-01f, -1.36393473e-01f, 7.22849742e-02f, 5.37929833e-02f, -7.14772788e-04f,
  -9.35445875e-02f, 4.37524393e-02f, -3.86492983e-02f, -5.86278643e-03f, 6.23137839e-02f, 1.19435541e-01f, 1.16763944e-02f, -6.12396933e-02f, -6.50013611e-02f, 3.10135353e-02f,
  -3.81023660e-02f, -5.88503107e-02f, 4.71764419e-04f, 4.04856056e-02f, -3.77363563e-02f, -1.42359175e-02f, -1.21013150e-01f, 1.63631774e-02f, 4.48547751e-02f, 1.92609280e-02f,
  -8.68191421e-02f, -1.06763214e-01f, 1.26580261e-02f, -1.64607596e-02f, 4.05110344e-02f, -1.01029627e-01f, -6.15344243e-03f, -1.07244149e-01f, 2.19629314e-02f, -4.26570363e-02f,
  8.91445801e-02f, 6.47470951e-02f, -4.26577171e-03f, -1.37602501e-02f, -1.40008831e-03f, -7.87972584e-02f, -4.95414399e-02f, 5.56726865e-02f, 4.45304215e-02f, -2.25977730e-02f,
  9.72960070e-02f, 5.41379303e-02f, 6.61919490e-02f, 6.90882131e-02f, 4.49270718e-02f, -1.27194019e-03f, 4.60558459e-02f, 4.07990701e-02f, -1.51082659e-02f, -1.06828786e-01f,
  -2.61953473e-01f, -9.03121755e-02f, -3.31217870e-02f, -1.67208403e-01f, -2.45744720e-01f, 1.71482060e-02f, 2.51673073e-01f, -2.29612947e-01f, -5.59003092e-02f, 7.92314857e-02f,
  -1.26802340e-01f, 2.28881523e-01f, 3.02075952e-01f, -2.71153778e-01f, 1.41281649e-01f, 2.44066477e-01f, -4.96204980e-02f, 8.38422403e-02f, 6.52933419e-02f, -9.56116393e-02f,
  -1.11754440e-01f, -2.69753128e-01f, 4.33907695e-02f, -3.08594167e-01f, -1.95678562e-01f, -1.89051256e-01f, 3.64935361e-02f, 1.37303919e-01f, -2.53677547e-01f, 8.61202255e-02f,
  -6.90087629e-03f, -8.01176950e-02f, -5.95009141e-02f, 1.21856639e-02f, -2.60906667e-02f, -3.76340114e-02f, 1.08038217e-01f, 8.80626962e-02f, 6.80550784e-02f, 1.81036312e-02f,
  3.58747914e-02f, 6.91804383e-03f, -5.01049757e-02f, 8.83714296e-03f, -9.68078077e-02f, -4.81935851e-02f, -2.66904421e-02f, -5.51784001e-02f, -2.90377345e-02f, -1.19090497e-01f,
  -6.95283040e-02f, 7.49386521e-03f, -4.82096104e-03f, 6.94877133e-02f, -1.36294728e-02f, -2.19325032e-02f, 5.84418401e-02f, 1.18683793e-01f, -5.33336699e-02f, -4.95732538e-02f,
  -6.08464107e-02f, 1.72219341e-04f, -2.92543154e-02f, -3.48016843e-02f, 1.83329955e-02f, -8.04731995e-02f, 1.74992979e-02f, -3.23993787e-02f, 1.42344758e-02f, -1.84521005e-02f,
  -9.44018140e-02f, -1.21202385e-02f, -3.86267342e-02f, 2.01985128e-02f, -4.23204452e-02f, -7.20757023e-02f, 9.31333899e-02f, -6.97132647e-02f, -1.18889036e-02f, -7.26361126e-02f,
  3.60613577e-02f, -1.35652162e-02f, 8.82402435e-02f, 5.10457717e-02f, 6.92365086e-03f, 8.86193570e-03f, -1.25702813e-01f, 1.21600525e-02f, 2.28691548e-02f, 3.94004136e-02f,
  6.91460297e-02f, 7.45212510e-02f, 5.14410287e-02f, 6.61754683e-02f, 3.51958424e-02f, -1.25636533e-01f, 3.94395739e-02f, -2.93638743e-02f, 4.96748649e-02f, -8.16696882e-02f,
  -2.48316061e-02f, 9.64757651e-02f, 1.13808647e-01f, -8.28784332e-02f, 8.37307945e-02f, -6.11220561e-02f, 9.44321975e-02f, 5.07968590e-02f, 7.05316812e-02f, -2.24222224e-02f,
  1.76027082e-02f, -1.25698876e-02f, 7.96226338e-02f, -2.03221198e-02f, 3.52227828e-03f, -1.47406952e-02f, 1.40974298e-02f, -2.41318196e-02f, 8.65086392e-02f, 7.27721676e-02f,
  6.48042038e-02f, 2.51435906e-01f, 8.67908355e-03f, 2.18790397e-02f, -2.17015043e-01f, -3.93966585e-02f, 3.66363674e-01f, -2.67426282e-01f, 2.58302808e-01f, 1.67063907e-01f,
  7.17173070e-02f, 1.41903102e-01f, 2.17546836e-01f, 2.54311979e-01f, -2.65088081e-01f, 2.15535760e-01f, -1.46433823e-02f, 1.48085222e-01f, 1.05552077e-02f, -1.04858853e-01f,
  -1.34231970e-01f, -1.42657101e-01f, -1.83304533e-01f, -1.43049523e-01f, -8.04980621e-02f, -6.16016239e-02f, -2.40404338e-01f, -9.78879109e-02f, -2.29955032e-01f, -2.71089599e-02f,
  2.21618116e-02f, 9.01261494e-02f, 1.41599607e-02f, -4.27941419e-02f, -3.37948799e-02f, 4.53974009e-02f, 5.51389903e-02f, 1.85325593e-02f, 5.56195229e-02f, 1.35895669e-01f,
  1.60657898e-01f, -7.51463026e-02f, -1.51402140e-02f, -2.71916203e-02f, 5.29431924e-02f, -7.06228614e-02f, 3.67321670e-02f, -1.51662817e-02f, 1.09291542e-02f, -9.36262310e-03f,
  5.78403287e-02f, -4.95393686e-02f, 3.16857100e-02f, -4.40248884e-02f, 5.33590501e-04f, -1.37565024e-02f, 2.80108340e-02f, -9.03821811e-02f, 8.07763115e-02f, -6.55275285e-02f,
  -7.52218515e-02f, 6.03616796e-02f, -3.63430530e-02f, 1.43927261e-01f, -8.32295138e-03f, 1.17974587e-01f, 9.22472104e-02f, 3.95912379e-02f, 2.69416887e-02f, -2.49603968e-02f,
  -5.67414872e-02f, 8.81218910e-03f, 9.80196148e-02f, -5.77944927e-02f, -3.01512028e-03f, 6.86110631e-02f, -5.22295870e-02f, -9.88270119e-02f, -9.65544432e-02f, -2.52543464e-02f,
  1.01332948e-01f, 3.87341492e-02f, -9.32417437e-02f, -1.12479785e-02f, 9.20937955e-02f, -5.96435666e-02f, -2.88552605e-02f, -2.94834953e-02f, 2.61554378e-03f, -4.79724817e-03f,
  -5.16868122e-02f, -4.76057641e-02f, 3.45594175e-02f, 9.97410156e-03f, 8.57414231e-02f, -1.76544096e-02f, 1.24571845e-01f, -5.42263919e-03f, -4.12085243e-02f, -4.41316795e-03f,
  -1.52679816e-01f, 4.60430644e-02f, 8.07235762e-02f, -6.42951876e-02f, -6.16154261e-02f, 1.67397514e-03f, 3.98149015e-03f, -2.15504057e-04f, 2.29584929e-02f, -7.39587098e-02f,
  -1.12679690e-01f, 2.01090593e-02f, 1.24339566e-01f, -9.49343219e-02f, -1.02851004e-03f, 3.55189317e-04f, -9.84789953e-02f, -3.14298123e-02f, -2.41093896e-02f, 8.67248327e-02f,
  4.10000205e-01f, -1.81748420e-02f, 6.15797229e-02f, -1.10926628e-01f, 6.06618933e-02f, -8.45561698e-02f, -1.50637761e-01f, 1.63484439e-01f, 1.44358799e-01f, -1.43471450e-01f,
  -1.34569973e-01f, 1.30039454e-01f, -5.79582788e-02f, -2.31143117e-01f, -1.68031275e-01f, -2.25600779e-01f, -1.67823061e-01f, -1.23808742e-01f, -1.58989814e-03f, 6.14474528e-02f,
  3.66522968e-02f, -1.42031521e-01f, 7.78515125e-04f, 7.14239702e-02f, 3.62624228e-02f, 1.19462349e-01f, 1.22193448e-01f, -2.26070490e-02f, -1.45082161e-01f, -7.64333531e-02f,
  7.94216469e-02f, 1.52563259e-01f, -9.65969451e-03f, 1.47412317e-02f, 1.14197664e-01f, 9.42799374e-02f, 7.45934620e-02f, -7.23144040e-02f, -2.25095488e-02f, -2.31708065e-02f,
  9.26873386e-02f, 1.33354003e-02f, -8.69259909e-02f, -4.33956534e-02f, 1.16383076e-01f, 3.90687250e-02f, 2.36995053e-02f, -3.50693315e-02f, 8.18416998e-02f, 8.36839750e-02f,
  4.54009660e-02f, -8.79174750e-03f, 8.01666174e-03f, -7.50572383e-02f, 9.99337733e-02f, -3.91479433e-02f, 4.50268295e-03f, 7.78122619e-02f, -6.82073757e-02f, 1.59032986e-01f,
  8.63365084e-03f, 7.91953206e-02f, -2.54664514e-02f, -7.38075003e-02f, -1.10011287e-01f, 2.20630746e-02f, -6.95135891e-02f, -5.15574776e-02f, 3.65722701e-02f, 5.18433703e-03f,
  -8.60666782e-02f, 9.86233056e-02f, 2.19126958e-02f, -4.67928983e-02f, -7.58411421e-04f, 1.98241156e-02f, -1.73109304e-02f, -7.36622736e-02f, 3.86413857e-02f, -3.38016190e-02f,
  -4.89881001e-02f, -2.23598070e-02f, -1.05470702e-01f, -4.36370336e-02f, -1.01614192e-01f, -2.50260849e-02f, 5.69666065e-02f, 4.95997034e-02f, -5.87460119e-03f, 2.54135579e-02f,
  1.84371322e-01f, 1.81040555e-01f, -7.03417975e-03f, 7.99008086e-03f, -7.06717893e-02f, -7.52231255e-02f, 5.39102145e-02f, 3.13498005e-02f, 9.42064542e-03f, 1.71905046e-03f,
  9.71367285e-02f, 5.18363900e-02f, 8.97006914e-02f, -5.33911539e-03f, -1.28046975e-01f, 8.57321993e-02f, 4.23322525e-03f, 9.07855928e-02f, 1.18359029e-02f, 1.12542901e-02f,
  -8.54846276e-03f, 6.21696636e-02f, -1.26190959e-02f, 6.71921819e-02f, -8.49745348e-02f, 3.44012380e-02f, 3.21606696e-02f, -2.36647520e-02f, -8.72526318e-02f, -4.02950346e-02f,
  3.42049509e-01f, -2.70701259e-01f, -4.26093638e-02f, 4.26355571e-01f, -2.02670291e-01f, 2.07670376e-01f, 1.47829711e-01f, -9.26443264e-02f, 1.02288537e-01f, -6.66686594e-02f,
  5.64117134e-02f, 4.40059900e-02f, -2.58205235e-01f, 3.67179602e-01f, 2.92965591e-01f, 5.30678555e-02f, 3.42268884e-01f, 2.67083466e-01f, -5.99917918e-02f, -3.17679644e-02f,
  9.22562629e-02f, 1.56206742e-01f, 5.18762171e-02f, -1.92055583e-01f, -2.52311025e-03f, -1.40037253e-01f, -4.77325656e-02f, -2.32090697e-01f, 1.72693804e-01f, 7.79341161e-02f,
  3.28714997e-02f, -2.93423906e-02f, -5.64156510e-02f, 5.49913161e-02f, 7.66880214e-02f, -5.85693792e-02f, 4.72358502e-02f, -1.86596322e-03f, 7.16508105e-02f, 3.13356495e-03f,
  -2.57590432e-02f, 4.61670980e-02f, 5.74592054e-02f, -5.21772318e-02f, 6.19459078e-02f, 2.40259394e-02f, 2.54184026e-02f, 2.21143030e-02f, -3.18378545e-02f, 1.80119742e-02f,
  1.03449812e-02f, 4.26111035e-02f, 1.15084991e-01f, 4.39665429e-02f, -5.13823144e-02f, 4.93727401e-02f, 8.55665132e-02f, 2.88851429e-02f, 3.90847623e-02f, 8.88136998e-02f,
  -5.53599857e-02f, -1.25458147e-02f, -2.70469813e-03f, -3.60658355e-02f, 5.29241748e-03f, -5.96649945e-02f, -5.41993359e-05f, -1.31394789e-02f, -2.22149640e-02f, 4.53966530e-03f,
  2.02874243e-02f, 2.61436850e-02f, 3.18098143e-02f, 2.19737310e-02f, 2.31902450e-02f, 6.14543795e-04f, -5.10761589e-02f, -7.20344633e-02f, -8.45758244e-03f, 5.83041348e-02f,
  -1.31544713e-02f, 3.47383991e-02f, -2.45185085e-02f, -1.91614348e-02f, 2.25904044e-02f, -3.90532985e-02f, 2.03648992e-02f, -1.07791517e-02f, -1.53109189e-02f, -1.12903612e-02f,
  6.21811152e-02f, -2.36883331e-02f, -1.05801113e-01f, 1.57197677e-02f, -7.99516067e-02f, -9.07279458e-03f, 3.70989740e-02f, 8.03023390e-03f, -4.56357822e-02f, 2.60285344e-02f,
  5.91172017e-02f, -1.78496037e-02f, -8.42686445e-02f, 2.84823459e-02f, 6.43824367e-03f, -7.28589147e-02f, 3.43920328e-02f, 1.93385035e-02f, 3.99653576e-02f, 1.30636776e-02f,
  1.09845698e-02f, -1.57489683e-02f, 1.37443666e-03f, -7.19184279e-02f, 5.35500720e-02f, -7.32721686e-02f, -3.77072953e-02f, 6.15260517e-03f, -4.05880511e-02f, -5.46570355e-03f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.72203439e-01f, -2.57425874e-01f, -4.36676234e-01f, -6.23595761e-03f, 3.82477194e-01f, 4.13293183e-01f, 2.78602183e-01f, 2.75762588e-01f, 1.67962894e-01f, 8.79663154e-02f,
  3.54910851e-01f, -4.06089038e-01f, -2.42702067e-01f, 2.59276509e-01f, 2.55030170e-02f, -3.00172180e-01f, 2.21211508e-01f, -1.27747599e-02f, -1.18073560e-01f, 2.14621961e-01f,
  1.42969429e-01f, 3.48652273e-01f, -3.26024026e-01f, 1.16465343e-02f, 2.81975269e-01f, -1.85284019e-01f, -1.30412523e-02f, -3.79196137e-01f, -4.07366902e-02f, 6.29569739e-02f,
  1.14237584e-01f, 5.68532944e-02f, 6.18478609e-03f, -9.70995054e-02f, 1.23168435e-02f, 1.77447438e-01f, -1.28813699e-01f, -1.55817270e-01f, -1.10742003e-01f, -5.65097842e-04f,
  -1.60132751e-01f, -4.25555333e-02f, 4.81563210e-02f, -3.18582542e-02f, 1.10688277e-01f, 8.91859755e-02f, 1.06876075e-01f, 3.57857682e-02f, 8.48274305e-03f, 4.60772179e-02f,
  1.87249912e-03f, 7.47623295e-02f, 8.57920870e-02f, -1.31967664e-01f, 6.99668527e-02f, 5.07277884e-02f, -1.22022949e-01f, -8.87232944e-02f, 4.56521567e-03f, 5.72310723e-02f,
  3.59483366e-03f, 1.11307669e-03f, 5.81798479e-02f, 8.53125304e-02f, 1.29265832e-02f, 1.25304854e-03f, 4.77752648e-02f, -6.61362857e-02f, -5.67863276e-03f, 8.00761282e-02f,
  4.86698672e-02f, 3.56823229e-03f, 1.60485655e-01f, 3.33103798e-02f, 1.17998645e-01f, 2.66759731e-02f, -6.22313994e-04f, -3.34592466e-03f, -1.85187850e-02f, -3.14027560e-03f,
  -1.27505347e-01f, 1.00318287e-02f, 3.80216748e-03f, 2.11035889e-02f, -1.06139444e-01f, -3.76080051e-02f, 5.43752834e-02f, 3.09418906e-02f, -3.38617973e-02f, -6.60523772e-02f,
  4.34565321e-02f, -9.76019725e-02f, -4.02750149e-02f, -1.07475929e-01f, -2.45014191e-01f, 1.01319380e-01f, -1.23789988e-01f, 5.46776876e-02f, -7.14734644e-02f, 1.79558441e-01f,
  2.86685135e-02f, -4.22343686e-02f, 1.29969180e-01f, 3.73869273e-03f, -1.05292007e-01f, 1.83236495e-01f, -1.58623293e-01f, -2.55606342e-02f, 8.30653533e-02f, -6.04622327e-02f,
  -6.31095618e-02f, 1.59914866e-01f, -4.65857126e-02f, 1.58211753e-01f, 7.23952204e-02f, 8.24037846e-03f, 7.39267766e-02f, -3.96246873e-02f, -6.16460852e-02f, -7.87987467e-03f,
  -7.44376004e-01f, 2.44893685e-01f, -2.12893084e-01f, 5.08757271e-02f, -5.57983778e-02f, -1.30497709e-01f, 1.62700027e-01f, -6.53356165e-02f, -1.55502498e-01f, 2.48480976e-01f,
  4.51386124e-01f, -3.16104919e-01f, 2.45940685e-01f, 5.00624478e-01f, -5.86829364e-01f, 2.56812960e-01f, 1.44984439e-01f, 4.31234427e-02f, -1.11474730e-01f, -1.30228579e-01f,
  -2.11414471e-01f, 2.60330290e-01f, 1.14805140e-02f, 1.39264697e-02f, 2.21281946e-02f, -1.79970294e-01f, 1.47434771e-01f, -8.32309425e-02f, 1.58870950e-01f, -1.00613654e-01f,
  -3.30160916e-01f, -1.62687391e-01f, -7.13823270e-03f, -1.46818757e-01f, -1.59303278e-01f, -4.35968600e-02f, -4.05848809e-02f, -6.35567605e-02f, -1.22622445e-01f, -1.05083212e-01f,
  -1.10299639e-01f, -6.69663921e-02f, 8.27474520e-02f, 4.07656021e-02f, -2.96577532e-02f, 7.48209469e-03f, 3.68601903e-02f, 1.12578861e-01f, 2.65031736e-02f, 3.99133079e-02f,
  1.02120221e-01f, 1.04477614e-01f, -2.14840043e-02f, 5.03686555e-02f, -2.30184495e-02f, -3.02358046e-02f, 1.79220531e-02f, -7.96426088e-02f, 4.04165909e-02f, -1.19395234e-01f,
  -3.90344933e-02f, 8.43636878e-03f, 1.77474264e-02f, 5.01587279e-02f, 6.80873618e-02f, 8.27925503e-02f, 1.94974849e-03f, 8.49452987e-03f, -2.61871889e-02f, 4.38208552e-03f,
  -7.67012835e-02f, 3.01935691e-02f, -1.96075346e-02f, -5.25236912e-02f, 2.74785887e-02f, -8.25712010e-02f, 1.86788142e-02f, -5.78514822e-02f, 2.23863070e-04f, 2.56053079e-02f,
  -1.70053225e-02f, -1.37399539e-01f, 2.50646174e-02f, 3.07166055e-02f, -4.06797742e-04f, -1.64216217e-02f, 4.74931747e-02f, -1.66460667e-02f, -8.02484080e-02f, -9.94066987e-03f,
  -5.05266130e-01f, -4.46636409e-01f, -3.93867260e-03f, -7.38140792e-02f, -7.29682157e-03f, -9.32610687e-03f, 6.42538667e-02f, -4.32932824e-02f, -6.81478158e-02f, -1.43237472e-01f,
  -8.28247443e-02f, 6.83567896e-02f, -1.12484843e-01f, 2.51172017e-03f, -4.32695486e-02f, 1.25479609e-01f, -1.39675558e-01f, -1.06146656e-01f, -1.27589509e-01f, -2.21861759e-03f,
  -8.62447247e-02f, -1.66005753e-02f, 3.55041251e-02f, 8.56371298e-02f, 2.84111183e-02f, 6.38723299e-02f, -1.20333157e-01f, 4.88601439e-02f, 2.46429304e-03f, 1.05988063e-01f,
  1.67781949e-01f, -4.26546395e-01f, 1.18771836e-01f, 3.36148083e-01f, 3.00214559e-01f, -8.36032182e-02f, 1.10762417e-01f, 1.52975231e-01f, 5.62108457e-02f, -4.30717766e-01f,
  -6.75814273e-03f, -2.01443091e-01f, -1.87002540e-01f, -1.65683106e-01f, 8.42226446e-02f, -3.62531275e-01f, -6.63764700e-02f, -1.25021026e-01f, 1.40027255e-01f, 2.33344957e-01f,
  3.39081496e-01f, 1.51953191e-01f, 3.62983525e-01f, 1.03532068e-01f, 2.61569083e-01f, 2.92199910e-01f, 2.49365211e-01f, 1.92214489e-01f, 2.69856155e-01f, -9.30513442e-02f,
  -1.33788839e-01f, 4.78654541e-02f, 5.29171787e-02f, -1.48302261e-02f, 8.78261179e-02f, 8.49433839e-02f, -4.40672040e-02f, 3.86697873e-02f, 3.46552059e-02f, -1.33877341e-02f,
  1.06882434e-02f, 8.63101780e-02f, -8.55486654e-03f, 1.37209184e-02f, 1.85406357e-01f, 6.13417476e-02f, 1.55211195e-01f, 1.48142308e-01f, 6.07130900e-02f, 1.36467442e-01f,
  -3.13247205e-03f, 5.60638569e-02f, -7.75523335e-02f, -1.40901640e-01f, 1.70310169e-01f, 1.22866638e-01f, 8.33310708e-02f, 2.55456218e-03f, -9.46579501e-02f, 6.33495897e-02f,
  -1.33909121e-01f, 2.98678391e-02f, 1.30535051e-01f, 1.06941849e-01f, -2.36406811e-02f, 4.30685617e-02f, -1.08828738e-01f, -4.52805907e-02f, 8.61454085e-02f, -1.36167258e-01f,
  2.52695242e-03f, -5.99761028e-03f, -5.60800508e-02f, 1.02440417e-01f, -2.04204582e-04f, 2.96268035e-02f, -6.58378154e-02f, -3.19277644e-02f, 1.11996874e-01f, 6.34192079e-02f,
  -1.06692277e-02f, 1.63000058e-02f, -6.32333159e-02f, 3.71492095e-02f, -9.06167999e-02f, 6.28419444e-02f, 1.26563638e-01f, -1.28524452e-01f, 4.47319075e-02f, 5.47721125e-02f,
  -8.99393111e-02f, -1.39840961e-01f, 8.92812014e-02f, 2.29587033e-02f, -1.86178610e-01f, -1.37230486e-01f, -1.24454372e-01f, -6.07136153e-02f, -7.92689323e-02f, -4.21480238e-02f,
  1.41980663e-01f, 4.84156720e-02f, -1.83543742e-01f, 9.72001908e-06f, -6.24171749e-04f, 8.33173320e-02f, 4.29141372e-02f, 2.51361076e-02f, 8.26830864e-02f, 1.98173318e-02f,
  8.60849693e-02f, -2.77333818e-02f, -3.24245319e-02f, 7.72659704e-02f, 9.85081419e-02f, -1.14745542e-01f, -1.38793930e-01f, 2.35391241e-02f, -9.57733393e-02f, -1.20111071e-01f,
  -9.40106958e-02f, 6.92330897e-02f, -4.26017016e-01f, -3.22263688e-01f, 2.58321874e-02f, -3.77648234e-01f, -2.40039110e-01f, 4.59417887e-03f, 1.70418039e-01f, 2.04748318e-01f,
  -2.82225460e-02f, 2.66676396e-01f, 3.74571204e-01f, -4.19353575e-01f, -3.01625907e-01f, -1.20882376e-03f, -3.64554882e-01f, -2.09079325e-01f, 7.70062655e-02f, -1.60639077e-01f,
  1.85448136e-02f, -1.75375061e-03f, -2.99353570e-01f, 1.92213744e-01f, -3.65772545e-01f, -1.30924746e-01f, 1.85343307e-02f, 7.56525472e-02f, -4.27180320e-01f, -5.61024845e-02f,
  -1.04443699e-01f, 5.08929603e-02f, -2.88514100e-04f, 4.96501662e-02f, -8.73485729e-02f, -1.02658883e-01f, -1.52829751e-01f, -3.15269306e-02f, 2.97803283e-02f, 1.13924723e-02f,
  1.79491654e-01f, 1.22333206e-01f, -1.38676204e-02f, 8.02916065e-02f, 6.59343302e-02f, -7.31741637e-02f, -8.46577808e-02f, -1.99827522e-01f, 8.77823904e-02f, -5.20816930e-02f,
  -1.32422864e-01f, -4.41419967e-02f, 7.97231775e-03f, 1.07350163e-01f, 8.24370906e-02f, 1.86716504e-02f, -1.95280835e-01f, -8.68025124e-02f, -5.37985340e-02f, -7.85258859e-02f,
  -2.10872591e-02f, 1.33005790e-02f, -6.98482320e-02f, -3.61142494e-02f, 8.67495779e-03f, 9.48374067e-03f, 7.55131096e-02f, 3.65088433e-02f, 9.53642577e-02f, -7.96037316e-02f,
  -4.25059795e-02f, 1.35062477e-02f, -5.18928021e-02f, -1.12856343e-01f, -3.41050792e-03f, 7.78163299e-02f, 4.24449742e-02f, 2.62394063e-02f, -7.03270733e-02f, -9.22075734e-02f,
  7.64831752e-02f, -7.60668963e-02f, 1.52716085e-01f, 4.46568392e-02f, -1.39291823e-01f, 5.35780676e-02f, 6.54750839e-02f, -3.77295092e-02f, -1.01618119e-01f, 1.35843366e-01f,
  4.35916428e-03f, 1.14005506e-01f, 5.08309267e-02f, 1.00095853e-01f, 1.53355896e-02f, 2.82449499e-02f, -6.50023147e-02f, -2.04452015e-02f, 2.55086902e-03f, 1.16077408e-01f,
  -3.26884799e-02f, 1.13711663e-01f, -1.02990344e-01f, 2.45299637e-02f, -8.38723704e-02f, -1.52368039e-01f, 5.70847392e-02f, 7.79536832e-03f, 4.02682498e-02f, -9.85678807e-02f,
  1.47928298e-01f, 8.27971473e-02f, 6.59032837e-02f, 6.09197542e-02f, 7.56456554e-02f, 1.48204863e-02f, 1.19348556e-01f, 1.52121624e-02f, 1.40531704e-01f, 1.02469757e-01f,
  -3.95103544e-01f, 3.64860505e-01f, -1.43704116e-01f, -1.68112181e-02f, 1.94358632e-01f, -3.79138917e-01f, -9.61854532e-02f, 2.98479617e-01f, -1.58427238e-01f, 2.75232941e-01f,
  -5.73244765e-02f, -1.82514668e-01f, 7.38828331e-02f, -2.05755442e-01f, -5.19766152e-01f, -3.98323178e-01f, -4.44470912e-01f, -1.91996574e-01f, -2.13098809e-01f, 1.53490007e-01f,
  -2.27326289e-01f, 1.08456798e-01f, -1.40725106e-01f, 3.57112676e-01f, 1.34651661e-01f, 1.97383761e-01f, 3.29949051e-01f, 3.29616338e-01f, 1.14383966e-01f, -9.47398841e-02f,
  -2.75533259e-01f, 2.49084815e-01f, 1.01994373e-01f, -9.70007554e-02f, -6.14148378e-02f, 3.10863927e-02f, 7.36064464e-02f, 5.34369089e-02f, 2.57370155e-03f, -4.00153920e-04f,
  -5.10811573e-03f, -5.21736741e-02f, -8.36772099e-03f, 8.79245251e-02f, -3.31704021e-02f, 8.63833874e-02f, -2.28961781e-02f, -7.31806755e-02f, -1.08380197e-02f, -1.88367039e-01f,
  -8.49940255e-02f, -3.93239520e-02f, -5.76281026e-02f, -2.60875635e-02f, -6.90660998e-02f, -1.84916821e-03f, -9.57265273e-02f, -7.89880753e-02f, 5.01003079e-02f, -1.29818975e-03f,
  2.11338215e-02f, -7.31691346e-03f, 2.47818250e-02f, 8.36063235e-04f, -8.59396681e-02f, 1.43850982e-01f, 8.76912624e-02f, 1.57723948e-03f, 7.33406171e-02f, -2.88299955e-02f,
  6.42245710e-02f, 7.62948766e-02f, 7.76676461e-02f, -4.22118939e-02f, 5.16154850e-03f, 2.16128472e-02f, 3.41799669e-02f, 9.14460868e-02f, -9.65987965e-02f, -5.85121987e-03f,
  7.08008036e-02f, -1.13677740e-01f, 6.83306977e-02f, 2.13150913e-03f, -2.89900489e-02f, -1.83441993e-02f, 1.04465550e-02f, -4.43489850e-02f, -8.68802592e-02f, -3.38366218e-02f,
  -1.17937535e-01f, 2.05722064e-01f, 2.08680891e-02f, 7.84834772e-02f, 6.63461983e-02f, -2.23936681e-02f, -9.40441061e-03f, -9.35994908e-02f, -4.43802290e-02f, -4.66347206e-03f,
  8.00876878e-03f, 7.59680495e-02f, -3.20359506e-02f, -8.90976414e-02f, 2.02305987e-02f, -6.33858377e-03f, 1.98461507e-02f, 4.85530384e-02f, 1.09449625e-01f, -1.94136556e-02f,
  1.82360977e-01f, 8.03066865e-02f, -5.21303229e-02f, 2.21844409e-02f, 1.21710949e-01f, 1.18324012e-01f, 5.26848482e-03f, -2.07410753e-03f, 1.27758281e-02f, -6.50505349e-03f,
  5.03681004e-01f, 2.60568887e-01f, 3.41289908e-01f, 6.11757636e-01f, 3.50176841e-02f, -1.29549429e-01f, 1.77899897e-01f, 2.41450876e-01f, 6.51907563e-01f, -3.38986188e-01f,
  -1.77796572e-01f, -1.56346373e-02f, -1.72897950e-01f, 2.77045101e-01f, -1.57339707e-01f, -6.36461750e-02f, 3.27914506e-01f, 2.25765422e-01f, 2.51662850e-01f, 1.40542030e-01f,
  3.53748858e-01f, -2.48427659e-01f, -9.97908264e-02f, -3.60251099e-01f, 2.61325270e-01f, 3.09489727e-01f, -2.33550861e-01f, -1.48669153e-01f, -1.93734273e-01f, -1.22872680e-01f,
  2.74595674e-02f, 1.93037525e-01f, 1.46667361e-01f, -3.98967005e-02f, 1.53119475e-01f, -1.34832844e-01f, -8.23008791e-02f, -1.80073828e-01f, 9.77652986e-03f, -1.14494758e-02f,
  -5.24530113e-02f, -1.28698468e-01f, -7.53601044e-02f, -6.87532574e-02f, 1.20262600e-01f, -3.32288109e-02f, 9.38973501e-02f, 2.31706485e-01f, 2.93956026e-02f, 1.33063346e-01f,
  2.89236400e-02f, 1.59362122e-01f, 2.77361572e-02f, 6.72359839e-02f, 1.32181048e-01f, 9.39096659e-02f, -1.01865157e-01f, 1.35657694e-02f, 5.59385642e-02f, 1.05713122e-01f,
  2.22559303e-01f, 4.65076789e-02f, -1.45434722e-01f, -1.80955201e-01f, -3.32539342e-02f, -1.68588664e-03f, -6.82205781e-02f, -1.76473185e-01f, -9.95614473e-03f, 3.99924442e-02f,
  -6.87971041e-02f, 2.26422269e-02f, 9.46444198e-02f, -2.16637813e-02f, 5.35982102e-02f, -5.58628468e-03f, -2.04206124e-01f, 5.62054031e-02f, 7.62511939e-02f, 3.88740096e-03f,
  1.35427224e-03f, -2.34472435e-02f, -6.86867116e-03f, -9.78351310e-02f, -1.22491799e-01f, -1.43139973e-01f, 4.95584905e-02f, 1.12329528e-01f, 9.77292731e-02f, -4.97211218e-02f,
  3.11781596e-02f, 2.39636719e-01f, 5.00263907e-02f, -2.87846252e-02f, -6.60798848e-02f, -1.22600377e-01f, 4.37119678e-02f, 5.81521243e-02f, 2.80973408e-02f, -8.85745436e-02f,
  1.18871242e-01f, -1.97447330e-01f, -9.47642773e-02f, -1.15167595e-01f, -6.34655878e-02f, -8.30448046e-02f, 5.13247624e-02f, -1.61182284e-02f, -8.74494165e-02f, 1.89394914e-02f,
  -1.17034521e-02f, -6.13708561e-03f, -6.56075478e-02f, 3.53867635e-02f, -5.32507077e-02f, 7.98300281e-02f, 4.16096970e-02f, 8.44584778e-03f, -8.43481869e-02f, -7.04135150e-02f,
  -3.85469258e-01f, 1.30087450e-01f, -1.33009031e-01f, 2.52125233e-01f, -3.64850938e-01f, 6.13705069e-02f, 4.19304103e-01f, -3.00216734e-01f, 1.11841716e-01f, 3.71974915e-01f,
  1.64524540e-01f, 2.54957080e-02f, 2.56430238e-01f, 1.61769554e-01f, -4.17788774e-01f, 2.13910043e-01f, 2.17724204e-01f, 2.78648078e-01f, -1.22476436e-01f, 7.65323937e-02f,
  -8.45852569e-02f, -1.31803915e-01f, -1.13962321e-02f, -2.05907866e-01f, -1.12021957e-02f, 5.01681976e-02f, 4.33131121e-03f, -1.55353844e-01f, 5.21476322e-04f, -3.39607805e-01f,
  9.83732194e-02f, -6.31704330e-02f, 1.15486547e-01f, 9.46809798e-02f, 8.12592730e-02f, 1.67483568e-01f, 1.48638770e-01f, -1.11456536e-01f, -1.22008555e-01f, 8.54658522e-03f,
  9.75549519e-02f, -1.22737274e-01f, -1.25014156e-01f, -2.42495999e-01f, -9.04959068e-02f, 7.71749467e-02f, 1.69964191e-02f, 5.76597899e-02f, -1.24753481e-02f, -1.45142645e-01f,
  5.37922867e-02f, 1.32502830e-02f, 1.22989610e-01f, 7.84861743e-02f, -5.47350757e-02f, -2.93610226e-02f, 1.10733196e-01f, -3.03405970e-02f, 1.60987064e-01f, -2.05339789e-01f,
  -2.98615731e-02f, 1.21338725e-01f, 9.40253884e-02f, -2.66926568e-02f, -3.39692347e-02f, -8.56996700e-03f, 1.44564267e-02f, -6.93956912e-02f, -3.89090367e-02f, -3.90104987e-02f,
  6.44580871e-02f, 7.63320131e-03f, -5.01166992e-02f, 3.85436043e-02f, -9.79737118e-02f, 2.70247031e-02f, -6.91932365e-02f, 3.66804861e-02f, 3.90866324e-02f, -2.43541170e-02f,
  6.34944513e-02f, 6.59492016e-02f, -8.08108747e-02f, 1.55364871e-01f, 1.47048235e-01f, -6.47837901e-03f, -8.01483691e-02f, -1.57399643e-02f, 1.28890902e-01f, -2.16840915e-02f,
  8.40938538e-02f, -1.31311893e-01f, 6.83656260e-02f, 1.35791212e-01f, 9.80389565e-02f, -1.32494047e-01f, -8.47312808e-02f, -7.48654082e-02f, -1.14265501e-01f, -1.70070797e-01f,
  -1.32158756e-01f, 2.11622134e-01f, 5.27458265e-02f, -1.86270580e-01f, -3.26537043e-02f, -3.47010931e-03f, 1.69578597e-01f, 1.24257199e-01f, 1.98178701e-02f, -8.29639584e-02f,
  4.72651757e-02f, 9.06248540e-02f, -8.84806365e-02f, 1.02876179e-01f, 1.60771295e-01f, -7.38716424e-02f, -9.09434184e-02f, -1.45596221e-01f, -3.42202038e-02f, 1.17340721e-01f,
  1.46033987e-01f, 1.70747370e-01f, 1.91358790e-01f, -1.93349123e-01f, -1.29018441e-01f, -1.90132439e-01f, -3.44938785e-01f, -1.90525614e-02f, -1.56102136e-01f, -1.08367749e-01f,
  -2.46260911e-01f, 2.44951770e-01f, -1.26037940e-01f, -1.99545413e-01f, 1.31029904e-01f, 1.31503880e-01f, -3.00891340e-01f, -1.54172644e-01f, -4.83910404e-02f, -2.98048973e-01f,
  -6.38486370e-02f, -5.11027157e-01f, 1.69108629e-01f, -3.76885772e-01f, -1.97279692e-01f, 1.88379243e-01f, 6.05233887e-04f, -1.50385946e-01f, -2.06633806e-01f, -8.08194801e-02f,
  -1.75719559e-02f, -1.47887751e-01f, 8.24397728e-02f, 9.97441038e-02f, -2.12043412e-02f, 1.53925514e-03f, 5.23608997e-02f, 9.13581811e-03f, -1.03075638e-01f, 6.50839508e-02f,
  8.34146813e-02f, -3.07732839e-02f, -3.47073376e-02f, 2.49901637e-02f, -1.23631597e-01f, 4.97526266e-02f, 1.77111313e-01f, 1.70641884e-01f, -5.42256869e-02f, 1.53092116e-01f,
  1.45943642e-01f, 2.18976617e-01f, -5.35518490e-02f, 7.43067265e-02f, 5.85854910e-02f, -1.18929908e-01f, 4.67206687e-02f, 1.07555039e-01f, -4.31184955e-02f, 1.10071735e-03f,
  4.08990122e-02f, -7.99937770e-02f, -8.57980624e-02f, 8.71413723e-02f, -1.85931042e-01f, -1.03324629e-01f, -1.12278260e-01f, 1.05727755e-01f, 4.42124121e-02f, -6.85421601e-02f,
  -5.02345599e-02f, 1.24551974e-01f, -1.64675236e-01f, 3.11943442e-02f, -2.62295473e-02f, 7.78979436e-02f, 5.33126406e-02f, 5.69441170e-03f, -2.18927581e-02f, 1.87638685e-01f,
  -9.18554589e-02f, -1.10356472e-01f, -1.34543851e-01f, -1.32686552e-02f, -1.59030080e-01f, 2.73673167e-03f, 9.57803652e-02f, 1.09843813e-01f, 3.71019952e-02f, 9.52403899e-03f,
  5.35291210e-02f, -5.30310683e-02f, 3.98329422e-02f, -6.24106154e-02f, 3.02860625e-02f, 4.85033877e-02f, 6.23136060e-03f, 1.18425131e-01f, 4.95457128e-02f, -1.84703171e-01f,
  -6.75036479e-03f, 2.46159025e-02f, 8.11731890e-02f, -3.41863595e-02f, -8.69262516e-02f, 4.07509990e-02f, -1.02851696e-01f, 5.65206222e-02f, -1.83002837e-02f, 1.36938021e-01f,
  -1.92176979e-02f, -3.30271162e-02f, 4.32600789e-02f, -1.56892821e-01f, -8.65052082e-03f, 6.29719868e-02f, 1.89568978e-02f, 1.26038030e-01f, -1.42732278e-01f, -4.21755873e-02f,
  -3.44968915e-01f, 3.61866623e-01f, -3.66108492e-02f, -3.75255853e-01f, -1.94532230e-01f, -2.22717389e-01f, -3.69108200e-01f, 1.66573927e-01f, 1.84084043e-01f, 2.41437122e-01f,
  -1.17246695e-01f, 1.21519029e-01f, 3.91047835e-01f, -1.71354204e-01f, -1.41063005e-01f, 3.49903196e-01f, -3.71610671e-01f, -1.68537036e-01f, 1.61667123e-01f, -2.16873318e-01f,
  6.11146167e-02f, -4.03963357e-01f, -1.35096312e-01f, -2.22772583e-02f, -4.22559857e-01f, -1.75170042e-02f, -1.75209805e-01f, 9.88114625e-02f, -3.73976588e-01f, 1.17302835e-02f,
  -3.17722596e-02f, 7.65801892e-02f, 1.22607879e-01f, 2.04089686e-01f, -6.12050705e-02f, -1.17868617e-01f, -2.26710383e-02f, 1.00669228e-01f, -7.07943588e-02f, -8.50281585e-03f,
  1.30683810e-01f, 6.12693429e-02f, -8.30343924e-03f, 5.44491634e-02f, -3.03629246e-02f, 6.83354959e-02f, 4.88084592e-02f, -1.07052289e-01f, 9.46299583e-02f, -1.04478933e-01f,
  -4.11510654e-02f, 3.84273045e-02f, -8.00995678e-02f, 1.42072722e-01f, -4.64030989e-02f, -5.18706441e-02f, -6.39828891e-02f, -9.11787823e-02f, 7.55468309e-02f, -5.51126339e-02f,
  -4.89866175e-02f, -2.42313114e-03f, 3.30798589e-02f, -5.21883406e-02f, -2.71525397e-03f, 4.91313860e-02f, -9.65337008e-02f, -8.99969339e-02f, -9.65238884e-02f, -7.86869749e-02f,
  9.77542698e-02f, 8.03494900e-02f, -7.70445019e-02f, -7.33644217e-02f, -1.62704632e-01f, -8.86382759e-02f, -1.32497549e-01f, 1.18546128e-01f, -4.57941219e-02f, -4.63203192e-02f,
  1.61580831e-01f, 1.79750472e-02f, 5.01354039e-03f, -7.23297382e-03f, -1.52305081e-01f, -4.67879400e-02f, -1.57417715e-01f, 8.34743455e-02f, 1.61924958e-02f, -1.04434364e-01f,
  1.19055055e-01f, 2.21782535e-01f, 1.98455811e-01f, 1.90353289e-01f, 1.34239435e-01f, -1.52729265e-02f, 9.63651482e-03f, 1.38720974e-01f, 2.49441266e-02f, 1.78376157e-02f,
  3.67073007e-02f, -6.31135255e-02f, -4.60235327e-02f, -1.46965131e-01f, -4.67275456e-02f, -1.23103239e-01f, -4.69283946e-02f, 1.51451901e-01f, 6.37068152e-02f, -4.94369082e-02f,
  -8.98079854e-03f, 1.04641477e-02f, 4.44349870e-02f, 1.07030891e-01f, 1.07888773e-01f, -2.63388678e-02f, -1.27876610e-01f, 1.68829784e-01f, 2.47981809e-02f, 4.94909398e-02f,
  4.04765159e-02f, -3.20426077e-01f, -5.49860001e-01f, -1.21082500e-01f, 2.24936441e-01f, 1.88514799e-01f, -1.41064435e-01f, 1.64696693e-01f, -3.99794191e-01f, 2.72192568e-01f,
  4.42982703e-01f, -2.45563999e-01f, -3.94920915e-01f, 3.30365360e-01f, 1.39118180e-01f, -2.33168840e-01f, 2.77820587e-01f, 3.25837910e-01f, -2.04250425e-01f, 6.19985349e-02f,
  -3.72594967e-02f, 3.98518115e-01f, -8.49010423e-03f, 3.15376043e-01f, 2.19145164e-01f, -1.04182541e-01f, 4.09779757e-01f, -3.22519004e-01f, 3.45772296e-01f, 2.50080645e-01f,
  9.83412191e-02f, -1.49699986e-01f, -8.80979300e-02f, 9.40059312e-03f, -2.64420193e-02f, -4.57422547e-02f, -1.04434855e-01f, -1.01591811e-01f, -1.09318532e-02f, -2.07236446e-02f,
  -1.03882007e-01f, 1.27674425e-02f, 1.27995089e-01f, -1.23618305e-01f, 5.24707362e-02f, -1.38374001e-01f, -1.13297692e-02f, 4.04994264e-02f, -8.61099362e-02f, -1.81448013e-01f,
  -2.50162840e-01f, 1.24209978e-01f, 2.13010252e-01f, -1.18782930e-02f, -7.18350634e-02f, -9.82557833e-02f, -3.71391289e-02f, -6.41298071e-02f, 1.78183496e-01f, -2.45572478e-02f,
  2.82734111e-02f, 8.82464722e-02f, 1.44055358e-03f, 6.32862421e-03f, -8.35029632e-02f, 9.41860527e-02f, 9.47476849e-02f, 8.24586600e-02f, -8.48503262e-02f, -1.34346515e-01f,
  -1.86012480e-02f, -7.01794475e-02f, 1.18556693e-01f, -9.63636395e-03f, 8.51059109e-02f, 1.24634691e-02f, -2.97682872e-03f, 3.58213298e-02f, -1.02460526e-01f, 3.53084058e-02f,
  -1.16994958e-02f, -1.64347440e-02f, -7.37244114e-02f, 9.79611203e-02f, 1.44322634e-01f, -2.20531061e-01f, 1.12091236e-01f, -7.12019056e-02f, -4.37898748e-02f, 1.52442068e-01f,
  1.09268323e-01f, -1.17418684e-01f, -1.22471027e-01f, 1.45553827e-01f, -1.19517334e-01f, 9.72269997e-02f, -1.05485730e-01f, 9.23872292e-02f, -1.26209902e-03f, 4.51351553e-02f,
  3.04673854e-02f, -4.67989109e-02f, 1.08407371e-01f, 3.29556467e-04f, 1.57092407e-01f, -8.62629861e-02f, 4.75866832e-02f, -1.20633626e-02f, 1.55810282e-01f, 7.47814327e-02f,
  -4.50828001e-02f, 2.46342979e-02f, 1.27001647e-02f, 1.00992247e-03f, 2.48621013e-02f, 8.90534446e-02f, -5.69011234e-02f, -7.73710534e-02f, 8.70964229e-02f, -6.12433068e-02f,
  -3.85891080e-01f, 6.46874532e-02f, 4.09866035e-01f, -2.59245723e-01f, 1.74897581e-01f, 6.34792820e-02f, 8.41918960e-02f, -9.24027488e-02f, -2.28248581e-01f, 2.65950374e-02f,
  2.45828014e-02f, 2.46641994e-01f, 2.58667648e-01f, -2.80310154e-01f, -1.83415532e-01f, -3.72790918e-02f, -3.32132846e-01f, -1.71013772e-01f, -8.62674043e-02f, -5.27079925e-02f,
  -1.53954834e-01f, -3.85661244e-01f, -2.01720279e-03f, -1.63639724e-01f, 8.39972775e-03f, -4.19583805e-02f, -1.27955735e-01f, 2.56137758e-01f, -1.61834896e-01f, 6.52537942e-02f,
  -1.92843333e-01f, 6.86347671e-03f, 1.10223331e-01f, 1.94266846e-03f, -5.61657883e-02f, 9.05899853e-02f, 1.16052642e-01f, 1.03488930e-01f, 1.08563818e-01f, -7.86970779e-02f,
  1.21768259e-01f, -2.17499472e-02f, -2.08270535e-01f, 6.96180090e-02f, 2.66817957e-02f, 6.13920726e-02f, 4.29542400e-02f, 3.41590606e-02f, -2.03864872e-02f, 1.93326041e-01f,
  1.11695215e-01f, 1.10230163e-01f, 4.40394022e-02f, 3.23303863e-02f, 3.06395292e-02f, -8.97798911e-02f, 7.70342797e-02f, 1.14256419e-01f, 3.41472100e-03f, -3.59074511e-02f,
  4.62090410e-03f, 2.69349813e-02f, 1.41857609e-01f, 2.64742132e-02f, 5.75947165e-02f, 2.80845375e-03f, -2.10482981e-02f, 9.02120322e-02f, 1.06305657e-02f, -4.25149947e-02f,
  -6.72513694e-02f, 2.20271990e-01f, -1.61349438e-02f, -3.71340811e-02f, -1.26262009e-01f, 2.93743145e-02f, 1.01077028e-01f, 1.66440960e-02f, -9.03950781e-02f, -9.34086591e-02f,
  8.72742757e-02f, -3.25729810e-02f, 9.89070237e-02f, 1.28554538e-01f, -8.98003355e-02f, 1.11285392e-02f, -2.40935269e-03f, 7.60406926e-02f, 2.93535721e-02f, -4.12369445e-02f,
  -2.15855986e-01f, -3.95120949e-01f, -5.39792143e-02f, 3.72164026e-02f, -5.49386367e-02f, 1.15505466e-03f, -1.10517487e-01f, -2.55000852e-02f, -4.53442670e-02f, -7.30211735e-02f,
  1.65165775e-03f, -1.05496995e-01f, -1.90698713e-01f, -1.72033161e-02f, 1.92844332e-03f, -4.64004278e-02f, 8.84464458e-02f, -1.22252241e-01f, -4.64364327e-02f, -5.81151731e-02f,
  -6.09309077e-02f, 3.57453227e-02f, 6.10372722e-02f, -6.10946640e-02f, 8.26871991e-02f, -6.56201318e-02f, 1.11253867e-02f, 6.34574750e-03f, 1.43143147e-01f, -7.63015226e-02f,
  -4.29747909e-01f, 4.74113137e-01f, 2.16760281e-02f, 3.33944827e-01f, 2.13601261e-01f, 1.13725048e-02f, 2.92588383e-01f, 2.32448637e-01f, 4.05973047e-01f, 1.75682724e-01f,
  2.62102693e-01f, 1.56190962e-01f, -1.31251793e-02f, 2.56994665e-01f, -5.65004289e-01f, 4.32914160e-02f, 1.64076969e-01f, 2.42067829e-01f, -5.37923910e-02f, 6.70873672e-02f,
  -7.91838989e-02f, -1.24324402e-02f, 1.04791317e-02f, -1.08453050e-01f, -4.62288177e-03f, -1.14806063e-01f, -3.46367717e-01f, -2.29587570e-01f, -5.88481613e-02f, -9.02535617e-02f,
  -2.69007891e-01f, 1.82466075e-01f, -2.46238895e-02f, -3.67581211e-02f, -1.09809093e-01f, 7.84943253e-02f, -1.33493558e-01f, -1.29327908e-01f, -1.42690212e-01f, 3.08327638e-02f,
  6.72160685e-02f, -3.36414278e-02f, -2.62839906e-02f, -5.18168733e-02f, 7.79281110e-02f, 8.53533521e-02f, 2.29170755e-01f, -3.06649096e-02f, 9.09004956e-02f, -2.14614458e-02f,
  9.38078836e-02f, -6.80560991e-03f, 1.05499528e-01f, -1.12639386e-02f, -7.36540481e-02f, -2.68065128e-02f, -4.24898453e-02f, -3.80363278e-02f, 1.20615298e-02f, 1.00957274e-01f,
  -4.85604629e-02f, -5.86487278e-02f, 2.00582877e-01f, 4.51553054e-02f, 4.87375483e-02f, 4.18523476e-02f, 4.48720455e-02f, -1.49578705e-01f, -1.63480699e-01f, -1.01313576e-01f,
  -2.60330494e-02f, 1.44525215e-01f, -6.06329702e-02f, -9.58697498e-02f, 9.40612182e-02f, 8.63314793e-03f, 2.36957744e-02f, -4.48998399e-02f, -3.68089974e-02f, -4.06235047e-02f,
  3.63911800e-02f, 2.49602031e-02f, 4.31647189e-02f, 2.52152197e-02f, 5.85277239e-03f, -6.28633797e-03f, 5.46459295e-02f, 1.43002152e-01f, 8.03335309e-02f, -1.93528607e-01f,
  -5.16882420e-01f, -2.22726375e-01f, -9.47501361e-02f, -5.16161099e-02f, -1.02264121e-01f, -6.01347275e-02f, -1.24634527e-01f, -1.91351086e-01f, -2.25643978e-01f, 2.68700387e-04f,
  -4.23152149e-02f, 1.19754836e-01f, -1.79799840e-01f, -8.56007561e-02f, -1.30563006e-01f, -4.61318716e-03f, -7.26865372e-03f, -3.82209122e-02f, -4.08333391e-02f, -2.11676016e-01f,
  -2.98704803e-02f, 4.55087274e-02f, -1.42112151e-01f, 2.13296637e-02f, -1.22596927e-01f, -2.43864916e-02f, -5.17246500e-02f, 4.01093923e-02f, -1.17575817e-01f, -6.10609213e-03f,
  5.79845428e-01f, -4.34488177e-01f, -3.17826599e-01f, 2.83339083e-01f, 2.53087997e-01f, 2.50100970e-01f, 2.62781382e-01f, 1.11844890e-01f, -2.77507361e-02f, -3.37649763e-01f,
  1.63177371e-01f, -1.59014434e-01f, -2.87017971e-01f, 3.93450707e-01f, 4.10508305e-01f, -2.55007744e-01f, 3.84266913e-01f, 1.48993716e-01f, -6.82695955e-02f, -2.75903363e-02f,
  1.45220816e-01f, 2.22467616e-01f, -3.40063102e-03f, -1.81968175e-02f, 1.56374142e-01f, -7.48962238e-02f, 1.62577108e-01f, -1.67050794e-01f, 9.80884731e-02f, 2.04865560e-01f,
  8.33945721e-02f, 5.38585037e-02f, 7.34202713e-02f, -3.83297205e-02f, 1.91506017e-02f, 9.34690237e-02f, 1.30902426e-02f, 1.31819367e-01f, 8.93262476e-02f, -9.41231474e-02f,
  -7.31491894e-02f, 1.47430226e-01f, 9.23680316e-04f, -3.91838253e-02f, 1.49024818e-02f, 5.35780080e-02f, -1.57798715e-02f, -1.30831629e-01f, -7.27731884e-02f, -5.04763052e-02f,
  1.37253767e-02f, -6.12804778e-02f, 8.15015435e-02f, 1.64005291e-02f, -4.42350432e-02f, 9.52458009e-02f, -8.54875445e-02f, -8.57415348e-02f, -4.14063223e-02f, 3.84227671e-02f,
  1.00767575e-01f, -4.21602651e-02f, -1.03405332e-02f, -2.99944151e-02f, -5.85806519e-02f, 7.91805908e-02f, -3.97997089e-02f, -1.01609670e-01f, -1.21806011e-01f, -2.44076401e-02f,
  1.12593733e-01f, 1.94496755e-02f, -6.13770522e-02f, -1.18897657e-03f, 2.90872846e-02f, 7.52362087e-02f, 8.07746965e-03f, 3.18030342e-02f, -5.16770482e-02f, 2.95358361e-03f,
  8.87631103e-02f, 6.60147369e-02f, -2.84627937e-02f, 6.86702039e-03f, 3.29336151e-02f, -3.95019166e-02f, -8.79774466e-02f, -1.78266130e-02f, -1.35529018e-03f, 3.33614536e-02f,
  -2.31667191e-01f, -4.72101986e-01f, -3.50788608e-02f, 1.46750674e-01f, -1.13650613e-01f, -3.09047252e-02f, 2.85249054e-02f, -2.38694958e-02f, 6.63862098e-03f, -6.68356642e-02f,
  6.19064178e-03f, 1.17676035e-01f, -5.45233861e-02f, 9.14981496e-03f, -8.58244661e-04f, -4.59023342e-02f, 1.46561349e-02f, 3.92044596e-02f, 1.19278483e-01f, -1.08518504e-01f,
  1.02438021e-03f, 6.89108251e-03f, 1.40380356e-02f, 5.51629998e-02f, -2.59031579e-02f, 2.87099406e-02f, 1.39301438e-02f, -1.22656815e-01f, 1.08960913e-02f, -9.21939760e-02f,
  -1.02534018e-01f, 3.66900086e-01f, 1.44505892e-02f, 3.06810271e-02f, -5.16072288e-02f, -5.65395296e-01f, -1.99930623e-01f, -7.27397576e-02f, 3.47843766e-01f, 1.81256384e-01f,
  1.27964262e-02f, 1.68112352e-01f, 2.76653916e-01f, 1.84591636e-02f, -4.73900139e-01f, -7.70421699e-02f, -3.85461897e-01f, -1.49289086e-01f, 1.31869331e-01f, -2.75225669e-01f,
  -1.57232955e-01f, -9.05905068e-02f, -9.56646875e-02f, -1.53627424e-02f, 2.12279540e-02f, 8.56669396e-02f, -1.94936156e-01f, 6.31688982e-02f, -4.51497994e-02f, -3.28177661e-02f,
  -2.64457494e-01f, 7.31321499e-02f, -3.94470431e-02f, -1.22797191e-01f, -1.72057763e-01f, -2.10814774e-01f, -2.02122927e-01f, 4.12718356e-02f, 2.07633451e-02f, 5.56925535e-02f,
  5.63590154e-02f, 1.21515442e-03f, -5.18455431e-02f, 1.87046990e-01f, 6.49735034e-02f, 1.09841399e-01f, -2.62048170e-02f, -1.17272831e-01f, -1.78015046e-02f, 1.22279627e-02f,
  1.27509862e-01f, -6.61562979e-02f, -2.01847479e-01f, 1.18304724e-02f, 1.53048579e-02f, 1.87604353e-01f, -2.33237848e-01f, -1.23221353e-01f, -5.87701090e-02f, 5.82276173e-02f,
  9.80676189e-02f, -6.69715255e-02f, -5.03461286e-02f, 1.60864353e-01f, -8.34952388e-03f, 7.26608699e-03f, 3.20883952e-02f, -8.87090564e-02f, 5.09557240e-02f, 3.44726704e-02f,
  -6.62817881e-02f, 2.88118888e-03f, 5.50033376e-02f, 2.70518251e-02f, -7.92180374e-02f, 1.63965672e-02f, -5.09868562e-02f, 1.05116904e-01f, -9.41881984e-02f, -7.84594417e-02f,
  -2.56502908e-02f, -6.21773526e-02f, 1.80648621e-02f, -1.57315746e-01f, -2.90037263e-02f, 7.85305277e-02f, 5.12047000e-02f, -4.06732187e-02f, -9.88263115e-02f, -1.47598505e-01f,
  -6.10867620e-01f, -2.77107924e-01f, -4.76815142e-02f, 6.49532070e-03f, -3.91553417e-02f, -2.12623641e-01f, -5.74414544e-02f, -6.50025383e-02f, -1.51173677e-02f, -3.43561210e-02f,
  -3.44992243e-02f, -3.39795575e-02f, -4.20139134e-02f, -2.82769985e-02f, -1.19696081e-01f, -9.90105495e-02f, -8.99291486e-02f, 6.07052445e-02f, -1.15876660e-01f, -1.63823605e-01f,
  -9.46831629e-02f, 8.66579711e-02f, -1.28791600e-01f, -1.10418685e-01f, -2.07078472e-01f, 9.37570035e-02f, -1.69930421e-02f, -4.69050929e-02f, -7.19241798e-02f, -2.59645768e-02f,
  -6.87154233e-01f, 2.96820611e-01f, 5.24296403e-01f, -4.23865139e-01f, 2.00347543e-01f, 5.43071032e-01f, 2.51767904e-01f, 5.78030944e-02f, 2.25090850e-02f, -2.40975365e-01f,
  -2.68719077e-01f, 7.55141750e-02f, 1.94170073e-01f, -2.99832791e-01f, 2.54171908e-01f, 2.21578047e-01f, -2.18736261e-01f, -4.17542011e-02f, 1.90883294e-01f, -1.22101018e-02f,
  2.87500285e-02f, -1.39805913e-01f, -5.69806173e-02f, -8.57191219e-04f, -1.96959183e-01f, -1.74516946e-01f, -3.09948802e-01f, 3.47180933e-01f, -3.42512786e-01f, 1.23555034e-01f,
  -1.06973208e-01f, -2.33749300e-01f, 2.26113312e-02f, -5.30313440e-02f, -1.17748588e-01f, 4.60611917e-02f, 5.51873408e-02f, 8.21488872e-02f, -1.06493030e-02f, 1.28861025e-01f,
  -1.20258264e-01f, 2.79027689e-02f, 4.47410122e-02f, 1.09766439e-01f, 1.97884124e-02f, -1.35666490e-01f, -1.06215261e-01f, 4.10786830e-02f, 4.47203852e-02f, 1.43922521e-02f,
  1.38223812e-01f, 8.65347534e-02f, 2.05123667e-02f, -5.84677979e-02f, 8.06356445e-02f, -9.18367952e-02f, -1.38283014e-01f, 1.09411590e-01f, 1.20970279e-01f, 5.43166092e-03f,
  2.24966314e-02f, 1.70598440e-02f, 8.22123960e-02f, 1.60593465e-02f, 3.90480831e-02f, -1.06601663e-01f, -1.62620800e-05f, -1.03878982e-01f, -4.49053384e-02f, -1.03305146e-01f,
  -1.30699769e-01f, -1.17697276e-01f, 6.82249339e-03f, -1.02108277e-01f, -6.49600178e-02f, -1.59998626e-01f, 5.52671999e-02f, -1.20698825e-01f, -3.76554541e-02f, 3.01359911e-02f,
  5.42767495e-02f, 7.38620311e-02f, -1.12711668e-01f, -2.00034484e-01f, 6.92744181e-02f, 9.57392752e-02f, 3.29172835e-02f, -8.64588171e-02f, -1.37367964e-01f, 1.73381880e-01f,
  1.57431498e-01f, 7.41324723e-02f, 4.93355989e-02f, 2.82585877e-03f, 8.16233829e-03f, -1.74003858e-02f, 1.12518273e-01f, -7.24647343e-02f, -1.35999862e-02f, -7.39182085e-02f,
  -6.44827113e-02f, -1.49210691e-01f, -3.30957547e-02f, 8.45102444e-02f, 9.52556729e-02f, 1.33831752e-02f, -8.06338191e-02f, -6.30156249e-02f, 1.30408201e-02f, 6.72885850e-02f,
  -1.24668770e-01f, -3.67451948e-03f, -9.07610822e-03f, -1.86341092e-01f, -1.17036343e-01f, -9.83652547e-02f, -1.51780531e-01f, -4.70745526e-02f, -9.62958613e-04f, -4.35686857e-02f,
  7.34781325e-02f, -5.62990904e-02f, -3.25990319e-01f, 9.02217105e-02f, 6.15870319e-02f, -1.02164552e-01f, -2.22396016e-01f, 4.38089818e-02f, -3.58364820e-01f, 1.33331239e-01f,
  1.33625284e-01f, -3.82934660e-02f, -2.47166142e-01f, 2.15967044e-01f, 1.86603278e-01f, -3.56510073e-01f, 2.29922220e-01f, 1.54352069e-01f, -1.16608970e-01f, 2.44180426e-01f,
  1.78256229e-01f, 3.70798171e-01f, 8.06414858e-02f, 2.92789698e-01f, 2.65033841e-01f, 1.19727217e-01f, 3.61358374e-01f, -1.20177589e-01f, 3.69191527e-01f, 2.48724908e-01f,
  -4.76299264e-02f, 1.23832505e-02f, -9.62326229e-02f, -5.77902347e-02f, 1.05733179e-01f, 1.13224708e-01f, 7.84324035e-02f, 6.12282790e-02f, -4.77643795e-02f, 5.90544045e-02f,
  -3.50091681e-02f, 9.81492177e-03f, 2.19053850e-02f, -1.67288724e-02f, -2.40532239e-03f, 3.73935401e-02f, -1.57745138e-01f, 2.28344016e-02f, -8.39851350e-02f, -6.69793598e-03f,
  -1.27758965e-01f, -1.48283504e-02f, 8.48911405e-02f, 1.40691428e-02f, -1.19467691e-01f, 3.19298394e-02f, 6.44147620e-02f, 6.43144399e-02f, 1.03503931e-02f, 1.49968639e-01f,
  -1.58034102e-03f, 1.93136465e-02f, 2.13756245e-02f, -1.70255974e-01f, 2.98826769e-02f, -9.28704906e-03f, -1.03989571e-01f, -5.29158525e-02f, -1.03425764e-01f, 1.03790879e-01f,
  4.92715947e-02f, -9.75410268e-02f, -1.46285817e-02f, 3.22853662e-02f, 6.92252889e-02f, 6.33598045e-02f, 2.24242057e-03f, 1.01670943e-01f, -2.85394937e-02f, -1.50041908e-01f,
  -4.74010222e-03f, -2.35271119e-02f, 4.48387004e-02f, -4.63667698e-02f, -5.93530014e-02f, 6.45679012e-02f, 3.74222659e-02f, -5.55332452e-02f, 1.01423003e-02f, 9.67073888e-02f,
  6.12442270e-02f, 2.21330687e-01f, -6.13366067e-02f, -2.39078682e-02f, -2.66462900e-02f, 9.94954854e-02f, 7.04900995e-02f, -7.63661414e-02f, 2.91214157e-02f, -5.03523462e-02f,
  9.17550474e-02f, 3.49480063e-02f, 2.08020322e-02f, 5.85277118e-02f, 9.33000818e-02f, 5.00619002e-02f, 1.31575376e-01f, 7.39246011e-02f, 3.60157639e-02f, 9.11229849e-02f,
  1.24644510e-01f, 4.07095514e-02f, 1.27297401e-01f, -1.34092122e-01f, 2.42158789e-02f, -1.98023748e-02f, -4.01838161e-02f, -5.91823161e-02f, 6.65465044e-03f, -2.24727001e-02f,
  3.52923304e-01f, -2.76678324e-01f, 2.11536303e-01f, 3.65294814e-01f, 3.33069026e-01f, 4.07111079e-01f, 3.32564175e-01f, 3.64882588e-01f, 4.96005207e-01f, -2.43039876e-01f,
  8.29553083e-02f, -2.90091932e-01f, 6.87699532e-03f, 1.67477950e-01f, 2.59469211e-01f, 1.41922727e-01f, 3.54087859e-01f, 1.31639183e-01f, 2.87179291e-01f, 1.56352911e-02f,
  1.21683419e-01f, -4.47735749e-02f, -1.61352143e-01f, -1.73424691e-01f, 2.00816821e-02f, -1.72851324e-01f, -2.76042223e-01f, -1.01153582e-01f, -2.42202252e-01f, 1.11812361e-01f,
  1.39558166e-01f, 1.94011703e-01f, -9.44452658e-02f, -1.30898029e-01f, -5.97585030e-02f, 1.28326816e-02f, -4.93139289e-02f, -7.53908046e-03f, 8.20330605e-02f, 1.08734565e-02f,
  -1.73861487e-03f, -3.92962992e-02f, -7.33167157e-02f, -6.87068328e-02f, 1.06112557e-02f, -1.49430931e-01f, -3.98831964e-02f, -5.18955998e-02f, -5.63653558e-02f, -1.06750712e-01f,
  -4.57380377e-02f, -6.97331177e-03f, 7.52356127e-02f, -5.78886131e-03f, 5.11049628e-02f, -1.03710089e-02f, 4.93264049e-02f, -3.61725092e-02f, 7.71140167e-03f, 1.12968154e-01f,
  3.08815539e-02f, 4.59856056e-02f, -9.65198874e-02f, -8.37663636e-02f, 4.84231152e-02f, -6.94869086e-02f, 1.71043854e-02f, 4.66811880e-02f, -3.04956399e-02f, -5.96311428e-02f,
  1.42827509e-02f, -3.02698347e-04f, 7.75967017e-02f, 3.68358940e-03f, 4.09607925e-02f, 8.81055817e-02f, 1.97238522e-03f, -3.61208022e-02f, 4.11770381e-02f, -4.56044450e-02f,
  6.88440632e-03f, -4.65228595e-02f, -8.11190531e-02f, 7.95588549e-03f, -6.54287189e-02f, 4.87615354e-03f, -2.66311746e-02f, 7.55094215e-02f, 7.89636672e-02f, 8.65646973e-02f,
  4.60909344e-02f, 8.99593753e-04f, -1.90861281e-02f, -1.32387638e-01f, -1.19332269e-01f, -1.29354581e-01f, 1.49244964e-01f, -1.12185311e-02f, 1.25589341e-01f, 3.11743096e-03f,
  -6.82944246e-03f, 1.53934630e-03f, -6.70724958e-02f, -5.67745604e-03f, -9.18956250e-02f, 6.74386695e-02f, -2.90708095e-02f, 8.00218955e-02f, -5.54526262e-02f, -7.27891475e-02f,
  -4.45332937e-02f, 6.91838339e-02f, -8.18617176e-03f, -3.59372869e-02f, -1.08732522e-01f, -1.16831698e-01f, -4.88708243e-02f, -7.09815370e-03f, -1.13404147e-01f, 3.71825509e-02f,
  4.65061426e-01f, -3.03683400e-01f, -6.69378042e-02f, 4.47643727e-01f, 9.64833945e-02f, 1.83558255e-01f, 5.79519629e-01f, -1.36525974e-01f, 1.63828343e-01f, -1.70550585e-01f,
  4.08680528e-01f, -1.79025337e-01f, 3.25900972e-01f, 2.05558792e-01f, 3.10843945e-01f, 2.99963981e-01f, 2.49345765e-01f, 8.53579566e-02f, -1.00265294e-01f, 7.06958398e-02f,
  1.41151920e-01f, 1.82208434e-01f, 2.41199404e-01f, -4.80038822e-01f, 1.32609621e-01f, -2.85346329e-01f, -1.35275424e-01f, -9.42680612e-02f, -2.67609328e-01f, -3.69071923e-02f,
  8.56307745e-02f, 1.85622439e-01f, 2.06309129e-02f, -5.73743917e-02f, 1.17718846e-01f, 7.08379745e-02f, 2.76392456e-02f, -1.10557945e-02f, 4.98360619e-02f, 3.27549987e-02f,
  4.54548150e-02f, -7.92748183e-02f, -1.14349000e-01f, -4.53524664e-02f, 2.14199582e-03f, -1.16344124e-01f, 1.26323076e-02f, -1.43039292e-02f, -1.04108110e-01f, 4.79026772e-02f,
  1.42520264e-01f, 4.81970720e-02f, 8.04755464e-02f, -1.30239040e-01f, -5.72858639e-02f, 1.01571239e-03f, -9.04748216e-02f, -1.61219519e-02f, -8.24187472e-02f, -3.03703565e-02f,
  -4.71279211e-02f, -6.49876818e-02f, 1.17428273e-01f, 7.60402754e-02f, 6.18149852e-03f, 8.03448409e-02f, -3.19248103e-02f, -3.87285426e-02f, -5.65442890e-02f, 1.37399472e-02f,
  1.06984772e-01f, 6.43568262e-02f, -8.95969048e-02f, 5.62865473e-02f, 5.98340631e-02f, 3.05822119e-02f, -1.54811079e-02f, -3.97509597e-02f, 3.05572748e-02f, 1.63266752e-02f,
  5.31602725e-02f, -8.85337871e-03f, 4.36791480e-02f, -3.09150964e-02f, -3.58531289e-02f, 7.70299360e-02f, 2.82883625e-02f, 6.35592267e-02f, -1.01316832e-02f, 1.15642399e-01f,
  -1.54835386e-02f, -2.21669108e-01f, 4.20643948e-02f, -1.52114928e-01f, -1.31334484e-01f, -1.03335872e-01f, 3.72958183e-02f, -9.81328264e-02f, -8.97911191e-02f, 1.07748434e-01f,
  -1.33042321e-01f, -1.91131216e-02f, -1.13293808e-02f, -5.36336452e-02f, -4.15421799e-02f, 4.11638469e-02f, 2.77955625e-02f, -1.11563377e-01f, 9.21638981e-02f, -1.03235878e-01f,
  2.18248833e-02f, -2.39764154e-02f, 3.57090160e-02f, 6.72100717e-03f, -6.04673959e-02f, 7.50878826e-02f, -1.76753670e-01f, 9.35838837e-03f, 1.54986922e-02f, -1.02511957e-01f,
  4.91098799e-02f, 4.21896875e-01f, 3.26326013e-01f, 2.75612017e-03f, 1.89583585e-01f, 3.48766744e-02f, -5.01098149e-02f, 1.68426827e-01f, 5.77088259e-03f, 5.03401645e-02f,
  -2.30274007e-01f, 3.83467048e-01f, -1.65504694e-01f, -6.10094965e-02f, -3.63633126e-01f, -2.99917400e-01f, -2.97437876e-01f, -1.97656125e-01f, -9.14232284e-02f, -1.25223964e-01f,
  -1.72206596e-01f, -3.30881774e-01f, -9.11030173e-02f, 2.98805237e-02f, 2.74870127e-01f, 2.88338453e-01f, -2.77061909e-01f, 1.47359118e-01f, 2.29630128e-01f, 9.33912992e-02f,
  -9.30952057e-02f, -1.72951132e-01f, 1.30027503e-01f, 7.60378689e-02f, -1.08944379e-01f, -2.51669367e-03f, 2.12920792e-02f, 7.51696676e-02f, -1.24777937e-02f, 1.04299612e-01f,
  1.35456517e-01f, 1.05652273e-01f, 1.99018046e-01f, -6.09222054e-02f, -1.82863995e-02f, 3.76545191e-02f, 1.24831446e-01f, 3.52428630e-02f, 1.62799567e-01f, 1.60698280e-01f,
  -3.11905630e-02f, 1.61229283e-01f, 9.27797519e-03f, -5.24642877e-02f, -2.27495581e-02f, 2.06562523e-02f, -5.06221205e-02f, 2.09549949e-01f, -4.30360250e-03f, 4.28408049e-02f,
  4.80790138e-02f, -4.76122871e-02f, 7.30436742e-02f, -7.48508573e-02f, 2.05251221e-02f, 1.14359833e-01f, -3.06302290e-02f, 1.24375534e-03f, 4.00106721e-02f, -2.69922521e-02f,
  -6.11572638e-02f, 1.06099360e-01f, -9.51139107e-02f, -9.58344117e-02f, -6.43697754e-02f, -1.31649785e-02f, -4.62315828e-02f, -7.16706663e-02f, -4.74990979e-02f, 8.75518024e-02f,
  -9.39730704e-02f, -1.68806955e-01f, -7.97352474e-03f, -2.86304858e-03f, 6.57071173e-02f, -3.26367803e-02f, -6.58789277e-02f, 1.16975144e-01f, -6.07017390e-02f, -1.23024702e-01f,
  -5.45965731e-01f, -3.73153895e-01f, -1.58738613e-01f, 9.40794647e-02f, -7.23790750e-02f, -1.07948922e-01f, 3.36914100e-02f, 1.00380421e-01f, -1.54007435e-01f, -3.50018702e-02f,
  5.66621497e-02f, 3.25194485e-02f, 3.83766592e-02f, -6.23192005e-02f, -1.59305129e-02f, -1.52146682e-01f, -1.62740931e-01f, 1.67588647e-02f, -5.80947883e-02f, 9.40397829e-02f,
  3.21227536e-02f, -8.87010023e-02f, 3.23209688e-02f, -6.93965331e-02f, -4.94273528e-02f, 1.18841656e-01f, -3.46918181e-02f, 1.64995834e-01f, -8.89670923e-02f, -9.58630163e-03f,
  1.39432311e-01f, 4.93274927e-02f, -2.61174113e-01f, -6.55722171e-02f, -1.40308186e-01f, -1.95661709e-01f, -1.18614636e-01f, 1.43089937e-02f, -1.91795513e-01f, 3.54975194e-01f,
  1.96184084e-01f, -7.14905262e-02f, 1.54457480e-01f, 2.28268832e-01f, -1.03332058e-01f, -2.42982302e-02f, 3.60960513e-01f, 7.38072917e-02f, -1.12867996e-01f, 1.75351307e-01f,
  1.28604695e-01f, 4.05211449e-01f, 4.16550040e-03f, 1.83362931e-01f, 5.77430502e-02f, -1.89926159e-02f, 3.16997349e-01f, -9.95664373e-02f, 2.56504059e-01f, -8.64669085e-02f,
  -7.06045702e-02f, 5.37707061e-02f, -6.36474788e-02f, -1.17341047e-02f, 1.00244686e-01f, 1.08669415e-01f, -1.17618777e-01f, -1.80710666e-02f, -1.36062831e-01f, 1.61471143e-02f,
  5.48802800e-02f, -3.22430022e-02f, -7.60940537e-02f, -2.08265826e-01f, -4.56267707e-02f, -1.73393831e-01f, -1.00034282e-01f, -4.47437279e-02f, -1.46888599e-01f, 1.11651346e-01f,
  -1.24660857e-01f, -3.72989359e-03f, 1.15357779e-01f, 7.50099346e-02f, -5.75081492e-03f, 7.39818141e-02f, -3.69577296e-02f, -1.59439333e-02f, -1.02841947e-02f, -4.29330394e-02f,
  1.27828255e-01f, -2.90373620e-02f, 3.65211442e-02f, 2.09310483e-02f, -1.87414866e-02f, 8.21571723e-02f, 4.43701707e-02f, 9.34909657e-02f, -1.10282466e-01f, 3.59775573e-02f,
  3.39857899e-02f, -4.81965616e-02f, 4.65357192e-02f, 1.16101205e-01f, 3.93607095e-02f, -7.33122453e-02f, -1.20007180e-01f, 4.42405939e-02f, -3.56043652e-02f, -1.30565286e-01f,
  -2.33396944e-02f, 6.48854077e-02f, -4.73600850e-02f, 1.57050490e-02f, -6.26976639e-02f, 1.24383636e-01f, 1.72037050e-01f, 4.68119560e-03f, 9.42005217e-03f, -4.83004600e-02f,
  1.15189463e-01f, 2.74038702e-01f, 1.31741418e-02f, -1.20845124e-01f, 5.97680286e-02f, 7.20899329e-02f, -2.37925984e-02f, 3.93542610e-02f, 6.12064637e-03f, 6.38691187e-02f,
  1.83565170e-01f, -4.05211672e-02f, 8.84021297e-02f, 1.41082061e-02f, 1.58648100e-02f, 1.84526607e-01f, 1.24351159e-01f, -2.71581374e-02f, 1.93199366e-02f, 1.67935774e-01f,
  2.81578787e-02f, -3.54539528e-02f, 9.22828764e-02f, -6.16679937e-02f, -4.31752019e-03f, 6.19592629e-02f, -9.02839750e-03f, -5.19946031e-02f, -3.46750207e-02f, -5.49145304e-02f,
  -7.59079456e-01f, 3.82264197e-01f, 4.97294426e-01f, -3.05210869e-03f, -2.90550023e-01f, 2.00343989e-02f, -4.72061075e-02f, 9.78382081e-02f, -2.72475153e-01f, 2.47276679e-01f,
  2.18126282e-01f, -2.05221608e-01f, 3.14102173e-01f, 3.71004969e-01f, -2.57250350e-02f, 2.61739731e-01f, 2.69246280e-01f, 9.65783522e-02f, -5.00399061e-02f, -2.82887388e-02f,
  4.51609753e-02f, -1.28690556e-01f, 3.11472863e-01f, 3.39638926e-02f, 1.72850162e-01f, -6.62484244e-02f, 1.18258283e-01f, 9.83109847e-02f, 3.55503596e-02f, -1.21062668e-02f,
  -2.45602369e-01f, -6.58734236e-03f, -1.37906009e-02f, -6.87908307e-02f, 6.30950630e-02f, -3.44979833e-03f, 4.69416864e-02f, -2.71404423e-02f, -2.67715231e-02f, 1.18377162e-02f,
  -1.87366039e-01f, 1.50536355e-02f, -6.41190484e-02f, -8.77955481e-02f, -1.62562862e-01f, 9.58736539e-02f, 1.14684984e-01f, 1.28190786e-01f, -2.13954020e-02f, 1.54770955e-01f,
  9.47886705e-02f, 1.86007172e-01f, 1.53318256e-01f, 1.17885500e-01f, 7.44433478e-02f, -5.97543716e-02f, 3.56384739e-02f, 6.30880371e-02f, -2.95954738e-02f, -5.96890133e-03f,
  -4.26191986e-02f, 2.99770720e-02f, 9.30046365e-02f, -5.31527102e-02f, -7.17134997e-02f, 7.37679899e-02f, 6.94628581e-02f, -9.92715824e-03f, 4.48496342e-02f, -8.54359940e-03f,
  -8.59435722e-02f, 3.34467627e-02f, -1.19245633e-01f, -6.44370243e-02f, -9.81420092e-03f, -6.31660521e-02f, 1.37741282e-03f, -7.32428879e-02f, -1.73677374e-02f, 1.69778019e-02f,
  -8.98714513e-02f, -1.07714862e-01f, 5.62264472e-02f, -3.96767370e-02f, 4.39779274e-02f, -3.46343890e-02f, 4.45167720e-02f, 1.14124238e-01f, -2.27663387e-02f, -1.10859480e-02f,
  -4.19809729e-01f, -1.50381833e-01f, -9.49667916e-02f, -1.39778107e-01f, -3.68106104e-02f, 1.78006664e-02f, -1.05772503e-01f, -3.43209319e-02f, 3.24031971e-02f, -9.65750143e-02f,
  -2.60062562e-03f, 2.53324043e-02f, -2.34994199e-02f, -1.16507784e-01f, 8.90350938e-02f, 4.79928264e-03f, -9.83097106e-02f, -2.74090655e-02f, -1.52248785e-01f, -8.37009121e-03f,
  3.72833270e-03f, -5.96435159e-04f, 2.30988767e-02f, -3.09441425e-02f, -4.90465648e-02f, 6.01689098e-04f, -1.63567007e-01f, -4.92533147e-02f, 1.91513337e-02f, 1.82529837e-02f,
  3.23358029e-01f, 1.18603878e-01f, 8.24460611e-02f, 4.23976153e-01f, 2.01102898e-01f, 3.26372236e-01f, 3.53522956e-01f, 2.09614173e-01f, 5.55454493e-01f, -4.28385697e-02f,
  -5.60586452e-02f, -1.56564429e-01f, -2.48182416e-01f, 1.57212749e-01f, 2.61472076e-01f, 1.27186954e-01f, 3.20384502e-01f, 1.52180910e-01f, 2.55793214e-01f, 1.13448605e-01f,
  1.82747677e-01f, 9.65173990e-02f, -2.70307422e-01f, -1.89343899e-01f, -1.03474624e-01f, -2.21312255e-01f, -4.13438469e-01f, -1.60892010e-01f, -2.87168354e-01f, -7.49056190e-02f,
  -7.68062100e-02f, 8.79059881e-02f, -1.02350272e-01f, -9.15469378e-02f, 1.29470542e-01f, -1.27288476e-01f, -8.79210085e-02f, -1.29054993e-01f, -7.80465081e-02f, -3.75154503e-02f,
  4.38395552e-02f, -4.04378250e-02f, 1.75047740e-01f, -5.16402163e-02f, 4.59519178e-02f, -7.38942530e-03f, -3.83658591e-03f, 6.13327026e-02f, 8.61457083e-03f, -8.73970762e-02f,
  1.30320452e-02f, -1.89964604e-02f, 4.76481989e-02f, 3.13480720e-02f, -3.50365825e-02f, 7.04800189e-02f, 1.25709385e-01f, -1.49464821e-02f, 4.58867550e-02f, 2.35401113e-02f,
  -8.50908533e-02f, -1.86005374e-03f, -6.16620034e-02f, -1.04129463e-01f, 3.34116332e-02f, 5.44590168e-02f, 7.60164484e-02f, 3.86244878e-02f, 9.15049240e-02f, 7.53199309e-02f,
  1.40894398e-01f, 1.24706581e-04f, 1.34311393e-01f, -8.95096362e-03f, -1.35533197e-03f, 8.81571621e-02f, -2.65938118e-02f, 8.63861591e-02f, 1.13434866e-01f, -5.45319691e-02f,
  -1.97218116e-02f, 9.05290991e-02f, -4.25771475e-02f, -5.80235198e-02f, 3.18479016e-02f, -1.28023773e-01f, 8.67643133e-02f, 4.09190319e-02f, -9.82405543e-02f, 2.58216988e-02f,
  1.40312359e-01f, 2.81856537e-01f, -1.30942147e-02f, -1.09571368e-02f, -1.53221004e-02f, 1.28112221e-02f, 6.33529499e-02f, 7.91629180e-02f, 1.01763450e-01f, 1.04000270e-01f,
  3.51561829e-02f, -4.57193628e-02f, 9.91608575e-02f, -1.87739179e-01f, -2.00486612e-02f, 1.38651311e-01f, -5.52285239e-02f, 5.51156811e-02f, 6.77194595e-02f, -1.05038613e-01f,
  -2.25438088e-01f, 2.23504044e-02f, 1.02689094e-03f, 1.91756487e-02f, 2.45019663e-02f, -3.73280495e-02f, 4.35277261e-02f, -4.42328975e-02f, -3.56085002e-02f, 8.20810869e-02f,
  -2.99011737e-01f, 2.02653840e-01f, -3.97251278e-01f, -2.61924684e-01f, -3.05886306e-02f, -5.44911802e-01f, -2.71925509e-01f, -1.46918789e-01f, -2.71327496e-02f, 1.63374186e-01f,
  6.29320517e-02f, 1.09988093e-01f, 3.55069906e-01f, -7.77712539e-02f, -4.19014603e-01f, 3.72239560e-01f, -4.48309302e-01f, -1.35143250e-01f, -2.04356611e-02f, -2.24110201e-01f,
  -1.58105984e-01f, -5.91368936e-02f, -2.45666727e-02f, 1.17671825e-01f, -2.17097282e-01f, -1.32753313e-01f, -6.82796761e-02f, 2.14731947e-01f, -3.61631930e-01f, -5.09753684e-03f,
  5.33557422e-02f, 2.70672113e-01f, 1.34851173e-01f, 9.18942913e-02f, -2.96793312e-01f, -6.13232180e-02f, -1.01556331e-02f, 3.10674571e-02f, 8.60954970e-02f, -1.62621588e-02f,
  -9.92748961e-02f, 2.28051357e-02f, -4.04298753e-02f, 1.66272119e-01f, 5.00640906e-02f, 1.09495811e-01f, 3.08926813e-02f, -1.36168644e-01f, 1.02165349e-01f, 1.18626289e-01f,
  -4.12262529e-02f, -1.71493776e-02f, -1.91013157e-01f, 1.02847209e-02f, -4.86889258e-02f, 5.09953648e-02f, -2.05796763e-01f, -1.64302904e-02f, -8.75751749e-02f, -8.00005347e-02f,
  -2.41409428e-03f, -1.45081699e-01f, 2.30740588e-02f, 1.48115456e-01f, 4.24377061e-02f, 6.94237351e-02f, -2.71690022e-02f, 1.52572125e-01f, -7.74733424e-02f, 8.82058144e-02f,
  -1.27688974e-01f, -9.39673707e-02f, 1.27000436e-01f, -1.96419775e-01f, -1.34327248e-01f, -6.16164207e-02f, -7.14720264e-02f, 8.11534673e-02f, -2.11866006e-01f, -8.67017880e-02f,
  2.12102979e-01f, -1.36084735e-01f, -6.69243280e-03f, 1.09584562e-01f, 4.07727174e-02f, 1.64361931e-02f, 3.06283031e-02f, -3.65462080e-02f, 5.46920896e-02f, -1.15186982e-01f,
  -9.36400145e-02f, -9.25837606e-02f, 5.58947772e-02f, 9.87953246e-02f, 2.15854887e-02f, 9.94814262e-02f, 4.43211906e-02f, -1.41100377e-01f, 5.45412907e-03f, -6.20826781e-02f,
  -2.22151905e-01f, -8.12117755e-03f, -2.05011487e-01f, -2.32221950e-02f, -1.43534333e-01f, -1.85034439e-01f, 1.99890174e-02f, -9.23699792e-03f, -8.11649710e-02f, -1.10964544e-01f,
  -5.92174605e-02f, -5.90166338e-02f, -5.57577834e-02f, 6.12148046e-02f, -1.13450453e-01f, -3.55885737e-02f, -3.19283828e-02f, 7.25678131e-02f, -3.85614634e-02f, -3.63555700e-02f,
  -6.18164062e-01f, -3.27995539e-01f, -2.53220387e-02f, -2.03091383e-01f, 1.42167524e-01f, 5.53594530e-01f, -6.20337352e-02f, -1.73571572e-01f, -3.53507072e-01f, 2.17406973e-01f,
  6.78732619e-03f, -5.38313508e-01f, -2.07961634e-01f, -2.19333574e-01f, -8.65215138e-02f, -1.53033048e-01f, 3.95433992e-01f, 1.67809978e-01f, -1.87676355e-01f, -1.40063480e-01f,
  -1.58749402e-01f, -3.92809212e-02f, -1.28764078e-01f, 8.92269835e-02f, 2.88259126e-02f, -1.83161721e-02f, 1.61380053e-01f, 7.74151785e-03f, 3.02578509e-01f, 2.38142628e-02f,
  -6.35687485e-02f, -4.02526528e-01f, -9.87258628e-02f, 1.06915720e-01f, 2.58617550e-01f, 5.74838817e-02f, 2.14055985e-01f, -9.31397080e-02f, -1.92892522e-01f, -1.50547221e-01f,
  1.35363173e-02f, -1.82149738e-01f, -5.49523979e-02f, -1.40701905e-01f, -1.66804969e-01f, -7.32256025e-02f, 3.17807719e-02f, 1.20939106e-01f, -9.78485346e-02f, -1.82894588e-01f,
  -1.76304325e-01f, -3.01846582e-02f, 1.38620168e-01f, 1.02320991e-01f, 5.71606234e-02f, 8.07561129e-02f, 3.01260874e-02f, -3.89000997e-02f, 1.67283073e-01f, 3.24059352e-02f,
  8.65600482e-02f, 1.43500075e-01f, -6.69439882e-02f, 6.10556677e-02f, -1.70689553e-01f, 1.73671380e-01f, 2.31840760e-02f, -1.46766333e-02f, -7.31759518e-02f, 1.08015820e-01f,
  7.30101764e-02f, -1.74411461e-01f, 4.90970537e-02f, 1.00869484e-01f, 7.03379735e-02f, 5.79191633e-02f, -7.01727346e-02f, -4.61145453e-02f, 3.63330776e-03f, 1.46191448e-01f,
  -5.82879819e-02f, 1.34072483e-01f, -3.02809589e-02f, 8.30831081e-02f, 6.18067719e-02f, 3.87870299e-04f, 1.45078432e-02f, 7.95574486e-03f, -3.18326727e-02f, 1.08657904e-01f,
  3.23482692e-01f, 2.16725707e-01f, -1.71905577e-01f, 8.41412991e-02f, -3.77527438e-02f, 8.19564387e-02f, 9.67233405e-02f, -1.02955259e-01f, 6.74521700e-02f, 1.32440124e-02f,
  4.21153791e-02f, -4.78776693e-02f, 2.13787735e-01f, -4.80175838e-02f, 8.96866694e-02f, 2.21049264e-02f, 1.26884893e-01f, 6.74746484e-02f, 2.03617990e-01f, 4.42726910e-02f,
  1.32515043e-01f, 9.69789922e-02f, -1.18899699e-02f, 7.16315061e-02f, 4.70850524e-03f, 9.55203623e-02f, -4.94088046e-02f, -7.41567463e-02f, 1.31140456e-01f, 1.04928561e-01f,
  1.36773616e-01f, -6.03025377e-01f, 9.44701955e-02f, 3.25262785e-01f, 2.69098282e-01f, -1.88533783e-01f, -5.48564084e-02f, 9.71108899e-02f, -9.23104435e-02f, -4.18115139e-01f,
  2.90097594e-01f, -1.46116585e-01f, -2.74746716e-01f, 3.66879851e-01f, 3.15791070e-01f, -6.20458042e-03f, 3.02567095e-01f, -7.58773685e-02f, 1.50286958e-01f, 2.38255784e-01f,
  3.02308321e-01f, 3.29486638e-01f, 3.55699003e-01f, 7.15805292e-02f, 1.32368416e-01f, 3.91603336e-02f, 2.00520039e-01f, -7.08754882e-02f, 1.60124451e-01f, 1.00086937e-02f,
  -2.34096900e-01f, 1.28408358e-01f, 1.45966098e-01f, -1.28797844e-01f, 4.99921180e-02f, -6.28513023e-02f, -1.14846207e-01f, -2.92079411e-02f, 9.52875093e-02f, 1.54087767e-02f,
  -1.28822073e-01f, -1.96455177e-02f, 1.36320248e-01f, -2.63992883e-02f, -1.09149806e-01f, -5.92057742e-02f, -5.33794845e-03f, 3.75316143e-02f, -2.70059649e-02f, 7.11199641e-02f,
  -3.63285504e-02f, -3.60179693e-03f, 1.01279467e-01f, -1.66410618e-02f, 1.75061569e-01f, -1.29992710e-02f, 8.77790898e-02f, -1.06477052e-01f, 4.76324186e-03f, -2.77762897e-02f,
  3.28281857e-02f, -1.27496585e-01f, 5.27198948e-02f, 9.48694423e-02f, 1.19182080e-01f, 1.74316272e-01f, -3.81740741e-02f, 1.37562573e-01f, -4.64576185e-02f, -2.89948704e-03f,
  4.00373377e-02f, 1.29544839e-01f, 1.07147526e-02f, -6.17629290e-02f, 6.07179105e-02f, -3.18358862e-03f, 6.31474033e-02f, 7.87538011e-03f, -1.73822511e-03f, 1.29783794e-01f,
  -1.34339258e-01f, -4.38981354e-02f, -5.45532368e-02f, -8.30090605e-03f, -1.33898467e-01f, 1.04721129e-01f, 1.01183228e-01f, 6.47786856e-02f, 2.02354398e-02f, -7.09367469e-02f,
  -3.61645907e-01f, -1.14948779e-01f, -5.32085672e-02f, -1.00488722e-01f, -1.09610513e-01f, 3.70318703e-02f, 9.54150185e-02f, -5.65071544e-03f, -5.16964011e-02f, 1.40405342e-01f,
  1.37902545e-02f, 7.06169680e-02f, -3.69557515e-02f, 7.94522390e-02f, -6.40890971e-02f, 2.04703789e-02f, 1.29130315e-02f, -1.20529123e-01f, 1.63139738e-02f, 2.02557743e-02f,
  4.06605527e-02f, -1.73303802e-02f, 1.72399487e-02f, 1.22454874e-01f, 8.83957148e-02f, -5.49357161e-02f, -4.77754623e-02f, -5.15876301e-02f, -6.37856079e-03f, 1.98824494e-03f,
  -2.86962325e-03f, -4.46088165e-01f, 1.57983348e-01f, 1.78761080e-01f, 3.66566926e-01f, 1.90395638e-01f, -8.87297019e-02f, 1.56447768e-01f, -7.08961627e-04f, -4.25794035e-01f,
  -1.86282381e-01f, -2.24543989e-01f, -3.29600751e-01f, 1.39773384e-01f, 3.58488441e-01f, -1.10110067e-01f, 1.86522022e-01f, -3.83658074e-02f, 1.74237370e-01f, 1.96419321e-02f,
  2.24367112e-01f, 2.68134534e-01f, 1.67480141e-01f, 2.47207478e-01f, 1.53777346e-01f, 1.00920998e-01f, -4.49645892e-02f, 1.62480384e-01f, 5.68393096e-02f, 1.19957395e-01f,
  -2.94609010e-01f, -1.77252010e-01f, -4.87733148e-02f, -1.27416119e-01f, -1.26843154e-01f, -1.46351963e-01f, -7.27849454e-02f, 2.47369613e-02f, 1.05281807e-01f, 6.28108624e-03f,
  -2.41187021e-01f, 8.44398662e-02f, 4.05988693e-02f, -7.13332836e-03f, 1.18104354e-01f, 8.02868530e-02f, 7.33362064e-02f, 7.61558190e-02f, 5.62921958e-03f, -2.05200855e-02f,
  1.41683072e-02f, -5.50615005e-02f, -3.11034061e-02f, -5.10292947e-02f, 5.42986728e-02f, 6.96547478e-02f, 1.10527724e-01f, -3.60206701e-02f, 4.67631221e-02f, -1.26304934e-02f,
  2.18857899e-01f, 5.09606749e-02f, 8.82140640e-03f, 3.58496886e-03f, -4.57176231e-02f, 5.72434105e-02f, -1.06443628e-03f, -2.18645409e-02f, -2.87966672e-02f, 9.93442722e-03f,
  8.98078829e-02f, -6.62408173e-02f, 7.37288073e-02f, -1.66818947e-02f, -3.52105573e-02f, -8.65045842e-03f, 6.58137947e-02f, -3.51823233e-02f, -1.52928540e-02f, 4.19820808e-02f,
  8.39330330e-02f, 1.15945198e-01f, 5.15369773e-02f, 6.94887415e-02f, -7.86501914e-02f, -1.43604979e-01f, -1.01439878e-01f, 1.50462061e-01f, 1.47550898e-02f, 1.94913819e-02f,
  -6.22436047e-01f, -3.93405139e-01f, -7.13995993e-02f, 4.13131639e-02f, -1.02281563e-01f, -1.17929630e-01f, -6.11650422e-02f, 1.69944063e-01f, -2.42129728e-01f, -4.91691120e-02f,
  -1.35483161e-01f, 2.56853625e-02f, -5.50993253e-03f, -9.62676760e-03f, -1.35412244e-02f, 4.52381186e-02f, -1.37371838e-01f, -1.51082918e-01f, -1.84346080e-01f, -4.01140638e-02f,
  -4.27000225e-03f, 9.34086638e-05f, -4.25449526e-03f, 1.65195122e-01f, -2.15324722e-02f, -9.70483795e-02f, -4.17140946e-02f, 5.55373728e-02f, 1.15849808e-01f, -4.31705862e-02f,
  -4.79068756e-01f, 5.93652368e-01f, -2.84369618e-01f, 3.10528670e-02f, 1.16833963e-01f, 4.21198420e-02f, -2.52506942e-01f, 2.98086703e-01f, -3.01487148e-01f, 2.63458788e-01f,
  3.21313590e-01f, -2.04302490e-01f, 2.50356913e-01f, 3.62972170e-01f, 2.38526329e-01f, 3.33098084e-01f, 3.08971584e-01f, 7.85600543e-02f, 5.81188500e-02f, 2.53582925e-01f,
  1.72279686e-01f, 3.99828911e-01f, 2.85736024e-01f, 2.45342121e-01f, 1.76817477e-01f, 7.80925155e-02f, 1.62362531e-01f, -3.47465128e-02f, 1.56709924e-01f, -2.50241756e-02f,
  -2.47942656e-02f, 4.01853472e-02f, -1.93897471e-01f, -3.21387380e-01f, -1.03393480e-01f, -2.66860783e-01f, -1.48165807e-01f, 2.08980627e-02f, -1.16087824e-01f, -3.76933534e-03f,
  -7.91064575e-02f, 8.66569355e-02f, -9.80952531e-02f, -1.67504936e-01f, -5.12380637e-02f, 1.04968939e-02f, 7.31994733e-02f, 2.38664672e-02f, 8.19639862e-02f, 1.02904543e-01f,
  1.09087050e-01f, 1.92275763e-01f, 8.97971466e-02f, 1.13677084e-01f, 5.62638044e-02f, 6.06281199e-02f, -8.67117122e-02f, -3.95415835e-02f, 1.87971830e-01f, 5.00990860e-02f,
  -1.02203516e-02f, -3.98472957e-02f, 1.17594048e-01f, -4.93758582e-02f, 6.06433908e-03f, 1.13265216e-02f, 1.20955281e-01f, 1.55237326e-02f, -1.07891545e-01f, 4.25940752e-02f,
  5.07753389e-03f, -4.40865904e-02f, 3.95122357e-02f, -9.47546363e-02f, -1.55365337e-02f, 2.05298923e-02f, -2.24753972e-02f, 6.33789375e-02f, -6.14072196e-02f, -6.37425622e-03f,
  -3.29403244e-02f, 1.00289285e-02f, 3.99145447e-02f, 5.14492355e-02f, 1.45934179e-01f, -4.14492525e-02f, 5.22711501e-03f, -3.15686390e-02f, 1.24760205e-02f, 4.83550578e-02f,
  2.71131098e-01f, 2.38691881e-01f, -1.04266174e-01f, -1.33810760e-02f, -2.01511800e-01f, 3.68485898e-02f, -8.64239559e-02f, 1.32347152e-01f, 7.04498589e-02f, -1.16997905e-01f,
  -4.02932353e-02f, -1.14635259e-01f, 3.89824100e-02f, -9.76554602e-02f, 1.85734347e-01f, 6.98090121e-02f, -1.02915712e-01f, -1.46515563e-01f, 5.35988212e-02f, 7.12007061e-02f,
  1.12665594e-01f, 1.35637030e-01f, 5.87421237e-03f, -1.44666564e-02f, 3.66250090e-02f, -1.46825658e-03f, 3.78461666e-02f, -2.87744273e-02f, 1.45410731e-01f, 9.35186446e-02f,
  -2.69044459e-01f, -1.30302414e-01f, -2.27292866e-01f, -2.26032734e-01f, -8.63711461e-02f, -1.18054431e-02f, -2.53668010e-01f, 1.38466626e-01f, 8.35911557e-03f, 2.80467749e-01f,
  1.35401383e-01f, -2.67159820e-01f, 3.33150476e-01f, -3.63536268e-01f, -1.86783016e-01f, -1.05052173e-01f, -3.32025558e-01f, -2.37652346e-01f, -1.17504947e-01f, -2.42378429e-01f,
  -3.53466511e-01f, -2.46836618e-01f, -1.70993835e-01f, 1.65102854e-01f, -3.12211633e-01f, 9.24307778e-02f, 1.92750115e-02f, -8.92516151e-02f, -2.58410633e-01f, -1.91202015e-01f,
  -6.75076246e-02f, 9.79253352e-02f, -1.39082549e-02f, 3.97263765e-02f, 3.98437567e-02f, 9.43242610e-02f, -9.09098163e-02f, -6.63662925e-02f, -6.49362504e-02f, 8.70467424e-02f,
  4.14215140e-02f, 1.16879612e-01f, -2.45993696e-02f, -7.65657276e-02f, 2.34122071e-02f, -6.59945756e-02f, -8.10296237e-02f, 3.13994698e-02f, 3.81650031e-02f, -1.53846011e-01f,
  -1.54294789e-01f, -1.45538270e-01f, 2.02566385e-02f, 1.70618370e-02f, -7.78285041e-02f, 3.84950936e-02f, -3.05670872e-02f, -1.12699986e-01f, 2.74364352e-02f, -5.04808035e-03f,
  -1.35731891e-01f, 4.67912070e-02f, 3.82355563e-02f, 2.73870379e-02f, 4.98447567e-02f, -4.02366230e-03f, -6.48558736e-02f, -2.23057475e-02f, 9.49012190e-02f, -2.93886028e-02f,
  9.46637541e-02f, 4.41044383e-02f, 3.59649062e-02f, -1.79930441e-02f, -1.68583676e-01f, -6.56606853e-02f, -6.80777654e-02f, 1.58199042e-01f, 2.31777299e-02f, -6.71221167e-02f,
  -1.25834003e-01f, -1.52530596e-02f, 8.18081424e-02f, 2.88337301e-02f, 8.14218298e-02f, 3.21901543e-03f, -5.56392595e-02f, -1.82608142e-01f, 3.07708001e-03f, -5.92182577e-02f,
  9.11246687e-02f, 1.25676379e-01f, 1.13962725e-01f, -1.13183062e-03f, -7.67891258e-02f, 7.16019869e-02f, -1.70291498e-01f, -5.75502813e-02f, -8.67923722e-03f, 9.46440995e-02f,
  -1.18482225e-02f, -8.13071057e-03f, 1.69050902e-01f, -6.74355626e-02f, -3.91890667e-03f, 7.87966028e-02f, 3.18953954e-02f, 1.27637148e-01f, 1.00665577e-02f, -9.06580314e-02f,
  1.64103657e-02f, 8.21210817e-02f, 4.19452079e-02f, 1.91182569e-02f, -9.71992593e-03f, 1.21332295e-01f, 1.82390045e-02f, -5.87043539e-02f, 3.53817479e-03f, 1.33279070e-01f,
  -3.33079398e-01f, 1.34157389e-01f, 5.47257066e-01f, -2.45344475e-01f, 3.71503495e-02f, 3.98266852e-01f, 1.98903561e-01f, 2.90460978e-02f, -1.55185238e-01f, -9.32016149e-02f,
  -6.09558448e-02f, 1.73082873e-01f, 6.13080710e-02f, -3.42599163e-03f, -1.03656784e-01f, -4.13490452e-05f, -1.15547575e-01f, -1.38760075e-01f, -6.05865233e-02f, -7.59416318e-04f,
  -6.19601496e-02f, -1.93177357e-01f, 1.63848966e-01f, -1.33337319e-01f, 5.23023568e-02f, 1.08370092e-02f, -2.08869115e-01f, 1.51187330e-01f, -2.45265290e-03f, -6.79888129e-02f,
  -5.41350432e-02f, -2.16620266e-01f, 3.73090394e-02f, 1.58278093e-01f, 1.05941296e-01f, 8.90914202e-02f, 1.31313115e-01f, 7.32862903e-03f, 3.06140855e-02f, 1.13014348e-01f,
  1.56213179e-01f, -3.38621736e-02f, -1.43285617e-01f, 1.19490251e-01f, -3.42005417e-02f, 1.74628012e-02f, 1.56876862e-01f, 1.95903122e-01f, 1.54763207e-01f, 5.58683127e-02f,
  1.76992983e-01f, 2.77926773e-01f, 6.75238250e-03f, -7.70456195e-02f, 3.02591734e-02f, -2.59805564e-02f, 9.63601321e-02f, 1.80419758e-02f, 3.20795663e-02f, -6.15972094e-03f,
  -8.10205638e-02f, -1.75137416e-01f, -1.33395074e-02f, -2.63309777e-02f, -5.85119650e-02f, 4.10206756e-03f, 8.48183185e-02f, -3.36354375e-02f, -2.78209373e-02f, -7.28645846e-02f,
  -5.97517490e-02f, 1.94141790e-02f, 1.68808410e-03f, 9.18088481e-02f, -1.50374487e-01f, -4.87554632e-02f, 2.77101304e-02f, 3.98054644e-02f, -4.31464240e-02f, -7.43845478e-02f,
  -8.77229590e-03f, 6.05632029e-02f, -1.19537547e-01f, 3.02022658e-02f, 1.32201821e-01f, 1.51253596e-01f, -5.52806705e-02f, 1.82785317e-01f, -4.70998138e-02f, 2.96882354e-02f,
  -1.42883942e-01f, -3.14910620e-01f, -1.48016959e-01f, 6.35248199e-02f, 5.09872809e-02f, 1.21120736e-01f, -2.76007298e-02f, 7.51773193e-02f, 1.43606318e-02f, -3.16703282e-02f,
  1.67633623e-01f, -5.46093173e-02f, 8.59931111e-02f, 5.13591059e-02f, -8.37532952e-02f, -5.23590297e-03f, -6.57278150e-02f, -1.88944750e-02f, 5.02794720e-02f, -1.89803705e-01f,
  -3.20239849e-02f, -1.51718706e-01f, -1.38921976e-01f, -5.81666343e-02f, -1.44673884e-01f, 8.73165280e-02f, -1.83485374e-01f, -1.50013836e-02f, -6.55427650e-02f, -5.59700653e-02f,
  4.92130853e-02f, 2.26482406e-01f, -2.80928105e-01f, -2.93374240e-01f, 1.44184709e-01f, 9.14455131e-02f, -1.40078336e-01f, 4.90435138e-02f, -3.18163186e-01f, 1.93923768e-02f,
  2.80176662e-03f, -4.64950830e-01f, -1.12842120e-01f, -2.14869991e-01f, -1.86907127e-01f, -9.15560052e-02f, -1.95650697e-01f, -8.56388509e-02f, 8.75501707e-02f, 2.66666114e-01f,
  6.01798035e-02f, 1.90788642e-01f, -5.38286306e-02f, 4.64411914e-01f, 3.26317489e-01f, 1.08685225e-01f, 1.33955941e-01f, 2.27902472e-01f, 9.03726518e-02f, -5.98635226e-02f,
  -3.38619910e-02f, -2.68178936e-02f, 2.15349458e-02f, -3.37588489e-02f, 5.99513687e-02f, 2.19305977e-01f, 7.59605020e-02f, -1.57232910e-01f, -1.15355119e-01f, -8.12312514e-02f,
  -1.41980484e-01f, 7.97256082e-03f, -1.48700655e-01f, -6.76883152e-03f, 1.17216662e-01f, -9.78883579e-02f, 5.57838753e-02f, -7.93885663e-02f, 7.55800605e-02f, 3.05741448e-02f,
  2.88449693e-03f, -9.89052579e-02f, -2.22345591e-02f, -2.45663419e-01f, -2.34259173e-01f, -8.53022560e-02f, -6.13556691e-02f, -2.72493809e-02f, -1.28534541e-01f, -2.30352759e-01f,
  1.17905758e-01f, 7.79266953e-02f, 1.59254417e-01f, -1.54023856e-01f, 2.98284665e-02f, -2.02649739e-02f, -1.30332232e-01f, -8.99732634e-02f, 4.36363555e-02f, -5.80272730e-03f,
  -2.07923099e-01f, -7.12041184e-02f, -7.17673963e-03f, 1.99264809e-02f, 1.17339544e-01f, -2.57808017e-03f, 8.26666728e-02f, 6.59721494e-02f, -9.03629363e-02f, -7.46360719e-02f,
  -1.53242543e-01f, 7.26050436e-02f, -7.82785043e-02f, -6.71446770e-02f, -8.86986479e-02f, -1.14406817e-01f, 6.50824085e-02f, 9.47882459e-02f, 5.79025336e-02f, 1.40433967e-01f,
  5.69309555e-02f, 8.12022090e-02f, 5.72385127e-03f, -5.78694120e-02f, -2.42352411e-02f, 2.54641811e-04f, 6.35474175e-03f, -9.78686586e-02f, -8.20307434e-02f, -2.73987260e-02f,
  -4.01332416e-02f, 1.56966336e-02f, 7.70975202e-02f, -7.92256296e-02f, -1.09452307e-02f, -4.15055268e-02f, -8.13044310e-02f, -1.58815011e-01f, -1.45901497e-02f, -6.84039816e-02f,
  -1.64083689e-02f, 1.02064181e-02f, -2.56660357e-02f, -1.40831235e-03f, -9.31123719e-02f, -1.01555765e-01f, 2.02809591e-02f, -1.01571478e-01f, 1.51749775e-01f, -2.17647031e-01f,
  4.08249646e-01f, -2.06797078e-01f, 5.13093352e-01f, 7.17998669e-02f, 2.68793792e-01f, 3.71044397e-01f, 2.55704463e-01f, 1.51176125e-01f, 7.82396719e-02f, -3.52056742e-01f,
  -1.43782705e-01f, 1.77473854e-02f, -5.29131815e-02f, -8.75268951e-02f, 1.64027512e-01f, -2.15079665e-01f, -1.79365918e-01f, -3.32301021e-01f, 1.49103999e-01f, -6.34344965e-02f,
  -1.60830896e-02f, -3.27784032e-01f, 2.13898376e-01f, -2.82559812e-01f, 1.06988080e-01f, -1.83923151e-02f, -4.02143806e-01f, -8.95692036e-02f, -2.56938785e-01f, 1.16966823e-02f,
  6.39434606e-02f, -9.42411348e-02f, 1.17824562e-01f, 4.12168577e-02f, 4.40100543e-02f, -1.27706036e-01f, 8.25801045e-02f, -4.39606905e-02f, 6.89755976e-02f, -1.91624928e-02f,
  -1.65065359e-02f, -4.88793058e-03f, -1.64055064e-01f, -4.40106094e-02f, 1.67897195e-01f, 6.54693469e-02f, 4.26581651e-02f, 7.08776563e-02f, 6.39344901e-02f, 1.61304414e-01f,
  2.10288718e-01f, 2.22197071e-01f, 2.54088312e-01f, -2.04363163e-03f, 1.08658418e-01f, 1.13665923e-01f, -2.72916276e-02f, 1.72815293e-01f, 1.54515028e-01f, 7.16134384e-02f,
  9.71243158e-02f, -8.72895196e-02f, -2.34923828e-02f, -2.35883277e-02f, -4.47355136e-02f, 9.96619463e-02f, -6.49100766e-02f, -1.93098243e-02f, -6.62613809e-02f, 7.32599273e-02f,
  2.91200150e-02f, -5.34425490e-03f, 2.16579605e-02f, 7.08114821e-03f, 4.50340435e-02f, 2.89930813e-02f, 2.85680424e-02f, -9.18518752e-02f, -1.91942807e-02f, 5.97301424e-02f,
  -1.14971533e-01f, 3.56652550e-02f, 2.42969058e-02f, 3.84420194e-02f, -2.48001684e-02f, 1.85886975e-02f, -6.75309971e-02f, 1.08429044e-01f, -3.29409167e-02f, -8.56098384e-02f,
  -4.93711531e-01f, -5.88022053e-01f, -1.85118362e-01f, -1.08048551e-01f, -2.04174325e-01f, -8.93232152e-02f, -1.84074894e-01f, -2.83172280e-02f, -1.32138953e-01f, -4.14952375e-02f,
  -1.13358963e-02f, -5.63583933e-02f, -1.16401128e-01f, -4.22252975e-02f, -7.56922737e-02f, -6.78648949e-02f, -1.48069561e-01f, -8.23404267e-02f, -1.06618635e-01f, -6.82687610e-02f,
  7.88609404e-03f, -1.03611298e-01f, -2.20622253e-02f, 1.30166635e-02f, -1.03422455e-01f, -1.56383531e-03f, -8.42383206e-02f, -2.50032055e-03f, 3.84370536e-02f, 4.60710004e-02f,
  -2.73361243e-02f, 5.46649098e-01f, -3.41086864e-01f, -1.46300927e-01f, -4.83134016e-02f, 6.97777629e-01f, 5.58596849e-01f, 7.30944425e-02f, 8.18419680e-02f, 5.19209325e-01f,
  1.96650237e-01f, -1.66438613e-02f, 1.69264674e-01f, 2.83171028e-01f, 2.10799277e-01f, 4.20026720e-01f, 3.47759932e-01f, 2.12247714e-01f, -2.41149396e-01f, 1.81363970e-01f,
  -6.77756071e-02f, 4.38840359e-01f, -1.17788248e-01f, -2.21735965e-02f, 8.08795020e-02f, -3.68843675e-01f, -2.10699424e-01f, -2.89124608e-01f, -1.02552861e-01f, 9.35838930e-03f,
  4.94834073e-02f, -5.06991111e-02f, -1.97373614e-01f, -8.35170224e-02f, 5.88692613e-02f, -6.23142831e-02f, 2.25620880e-03f, -2.41196789e-02f, -2.34806895e-01f, -1.05205536e-01f,
  1.38110633e-03f, -2.08108686e-02f, 7.97159001e-02f, 1.62373355e-03f, -2.25183507e-03f, -6.39845431e-02f, 2.42762715e-02f, 4.91696484e-02f, 3.75632606e-02f, 6.30459264e-02f,
  -5.42273670e-02f, -3.64093222e-02f, -2.55079120e-02f, 8.46457705e-02f, -2.74721347e-02f, 1.12869859e-01f, 1.08250178e-01f, 2.93232761e-02f, 9.25263017e-02f, 1.76318064e-01f,
  -1.82287768e-02f, 1.84409082e-01f, 1.96421772e-01f, -9.50853899e-03f, -6.82413299e-03f, -4.23568413e-02f, -4.82548438e-02f, -8.39369446e-02f, -1.54100601e-02f, 2.29463398e-01f,
  6.25592191e-03f, 4.06392887e-02f, -7.05966651e-02f, 6.48786947e-02f, 9.05581862e-02f, 1.04994498e-01f, -7.04187229e-02f, -6.24709874e-02f, 7.24830776e-02f, -2.51107011e-02f,
  -8.76307040e-02f, 2.17425022e-02f, 3.99434678e-02f, -8.71108398e-02f, 7.27465609e-03f, -1.07314356e-01f, -1.01627186e-01f, -3.11619695e-02f, -6.44826666e-02f, 8.98742955e-03f,
  3.72860819e-01f, 3.58582824e-01f, -7.05225021e-02f, 6.52557760e-02f, -1.24346823e-01f, 5.72044738e-02f, -1.58870444e-02f, 1.73347015e-02f, 1.36538029e-01f, 7.84302056e-02f,
  8.39882120e-02f, 8.52890834e-02f, 4.34581563e-02f, 1.12259006e-02f, -2.54285187e-02f, 2.25086868e-01f, 4.20674421e-02f, -1.51117235e-01f, -6.36587245e-03f, -5.38316816e-02f,
  -5.27991764e-02f, 1.11666314e-01f, -5.88829927e-02f, 4.24699746e-02f, 8.01015645e-02f, 9.98040736e-02f, 1.14583984e-01f, -1.18970677e-01f, 2.67119776e-03f, -5.37098944e-03f,
  -1.11352190e-01f, 4.05527592e-01f, 4.18200999e-01f, 2.37809837e-01f, -1.75149605e-01f, 2.49351174e-01f, 8.31391737e-02f, 5.67514589e-03f, 2.29938865e-01f, 2.70029884e-02f,
  -3.26535940e-01f, 3.47817302e-01f, -4.20623064e-01f, 3.08633029e-01f, -1.16615206e-01f, -2.03900874e-01f, 2.90828705e-01f, 1.00431293e-02f, -2.55592376e-01f, -1.48809195e-01f,
  8.41085836e-02f, -4.45244282e-01f, 7.32367113e-02f, -2.13471666e-01f, 9.71850604e-02f, 8.82874727e-02f, -3.83828431e-01f, -2.51698587e-02f, 2.10569561e-01f, 6.37682015e-03f,
  -1.10995293e-01f, -8.77792910e-02f, -9.26582292e-02f, -1.22801596e-02f, -1.57776661e-02f, 6.49175495e-02f, 5.26110455e-02f, -7.52754882e-02f, -8.42410512e-03f, 1.16402552e-01f,
  -6.47269711e-02f, 4.85977381e-02f, 3.18778642e-02f, -6.71643987e-02f, 1.57139113e-03f, 2.73001511e-02f, 4.73581366e-02f, 1.20076336e-01f, 2.19628848e-02f, 1.25544026e-01f,
  8.76829475e-02f, 1.85024351e-01f, 2.14661315e-01f, 1.48254901e-01f, -5.02845719e-02f, 4.61756659e-04f, 2.24429443e-01f, 7.15941377e-03f, 6.81403056e-02f, 1.21418141e-01f,
  -6.23842049e-03f, -6.60043657e-02f, -1.29365578e-01f, -1.46261277e-02f, 6.96195662e-02f, -3.74048799e-02f, 8.32259059e-02f, -5.33732213e-03f, 8.16490129e-02f, 6.13380596e-02f,
  -8.01859275e-02f, 6.09043278e-02f, -8.70837122e-02f, 3.73339765e-02f, -1.08753599e-01f, 5.30919172e-02f, 3.40505354e-02f, 2.33598351e-02f, -7.97281116e-02f, -7.97382295e-02f,
  -2.40599856e-01f, 4.48053516e-02f, -7.88686424e-02f, 4.81826179e-02f, 3.84305827e-02f, 4.01903270e-03f, -1.25213802e-01f, 2.33769462e-01f, -1.83678269e-01f, -2.50316411e-01f,
  -3.32498193e-01f, -2.74227291e-01f, -9.10209641e-02f, -7.91937932e-02f, -2.42147483e-02f, -2.70222146e-02f, -2.73840558e-02f, -1.60876606e-02f, -6.90811872e-02f, -6.05966449e-02f,
  2.86758188e-02f, 8.64094049e-02f, 3.92797776e-03f, 9.20356624e-03f, -1.03896558e-01f, 2.39242874e-02f, -1.37955323e-01f, -1.14091247e-01f, -1.21859439e-01f, -6.23239093e-02f,
  -1.50058046e-01f, -1.27524495e-01f, 7.06261322e-02f, 2.23850980e-02f, -7.43847266e-02f, -7.65826628e-02f, 1.87605582e-02f, 1.13519266e-01f, 1.72949154e-02f, 5.44675328e-02f,
  -4.35855031e-01f, 3.05321395e-01f, -4.86450223e-03f, -1.13723371e-02f, 2.93564945e-01f, 1.10953502e-01f, 1.31718680e-01f, 3.31137657e-01f, 4.34257418e-01f, -3.55028659e-02f,
  -1.86266676e-01f, 1.60789877e-01f, 2.51324505e-01f, -1.22572824e-01f, -3.53330612e-01f, -9.04256403e-02f, -2.99027383e-01f, -1.57448929e-02f, 4.22878563e-01f, 6.87188655e-02f,
  -9.62615907e-02f, -2.30045188e-02f, -3.02612424e-01f, 3.96348119e-01f, -1.50168926e-01f, 3.97258960e-02f, -5.25101542e-01f, 3.08913857e-01f, -3.82659435e-01f, 1.13718323e-01f,
  -2.48464778e-01f, 1.32596493e-01f, -6.24349304e-02f, 1.31096295e-03f, -2.03232482e-01f, -2.38859896e-02f, -1.26516610e-01f, -4.79163928e-03f, 1.41657487e-01f, 8.88705105e-02f,
  -9.89337489e-02f, 1.39302939e-01f, 9.89868119e-02f, 1.25389621e-01f, 1.51584044e-01f, 4.48405631e-02f, -2.17202101e-02f, -1.92902490e-01f, 1.20476663e-01f, -9.19305310e-02f,
  6.38526902e-02f, -4.87037748e-02f, -2.23855600e-01f, -1.37400597e-01f, -1.52336597e-01f, -8.06053206e-02f, -4.85817641e-02f, -1.43037125e-01f, -9.93993282e-02f, 8.89414847e-02f,
  6.18526377e-02f, 2.84189936e-02f, -2.07745545e-02f, 1.37544736e-01f, 1.59970243e-02f, -3.38742994e-02f, -2.96555664e-02f, -5.40219359e-02f, 5.18827885e-02f, -1.79087117e-01f,
  -8.41301903e-02f, 6.07919507e-02f, 1.51985332e-01f, 6.28392249e-02f, -1.77953858e-02f, 2.31118631e-02f, -2.09337711e-01f, 4.73908186e-02f, 8.39691609e-03f, -1.18418019e-02f,
  1.78834692e-01f, -3.64646837e-02f, -2.24698614e-02f, 2.23166309e-02f, -4.96311039e-02f, 2.08819173e-02f, 1.07800864e-01f, -1.34546742e-01f, 2.36310977e-02f, -3.30603346e-02f,
  -1.47807091e-01f, -8.00759345e-02f, -6.67314008e-02f, 9.01365653e-02f, -1.18916472e-02f, -7.40254857e-03f, 1.08753815e-01f, -2.39200778e-02f, -3.27542797e-02f, 1.05849810e-01f,
  -1.05388798e-01f, 4.45855036e-02f, -3.66120897e-02f, -2.81742681e-02f, -6.65455163e-02f, -1.31407306e-01f, -1.15928531e-01f, -8.17470066e-03f, -8.79108235e-02f, 5.73669113e-02f,
  2.91448701e-02f, 8.34035352e-02f, -7.54494593e-02f, -4.76638451e-02f, -6.44970387e-02f, -1.82453364e-01f, 3.29622999e-02f, -8.46416876e-02f, -2.81403959e-02f, 3.76272574e-03f,
  -6.90238833e-01f, 2.37256035e-01f, -1.65031374e-01f, -2.71585017e-01f, -5.49255908e-02f, -2.43758425e-01f, -8.43952075e-02f, -1.00705564e-01f, -6.80878162e-02f, 3.72149885e-01f,
  1.50466800e-01f, -3.20920974e-01f, 3.32035959e-01f, 2.83421844e-01f, -3.73609453e-01f, 4.04241621e-01f, -8.58196393e-02f, -1.55951157e-01f, 9.21500251e-02f, -2.45468631e-01f,
  -1.90378979e-01f, -4.83927168e-02f, 5.19923903e-02f, 1.33070230e-01f, -2.79908299e-01f, -2.22459689e-01f, -1.12435840e-01f, 2.31414326e-02f, -8.08011368e-02f, 6.15791790e-02f,
  -3.66552562e-01f, -2.78541297e-01f, -2.41954878e-01f, -1.18883975e-01f, -1.39084265e-01f, -1.44567579e-01f, -7.83617944e-02f, -9.84207913e-02f, 2.78471038e-03f, -7.64479190e-02f,
  -1.04971677e-02f, -1.01265654e-01f, 3.46581079e-02f, 6.38066232e-02f, -8.00551195e-03f, -1.24590974e-02f, 1.70148388e-02f, 7.43714422e-02f, -6.61668852e-02f, -5.18899709e-02f,
  -3.76056097e-02f, 6.07465059e-02f, 2.18403302e-02f, -1.36828152e-04f, -8.44915137e-02f, 3.65229510e-02f, 1.41892163e-02f, -9.94731188e-02f, -7.65408203e-02f, -7.60986581e-02f,
  9.70643237e-02f, -3.61227356e-02f, 2.06219126e-03f, 6.32216595e-03f, 8.61642882e-02f, 3.71228494e-02f, 8.48939940e-02f, -4.91427109e-02f, 4.08749692e-02f, 2.74399901e-03f,
  -3.57280448e-02f, -2.84515005e-02f, -9.79576781e-02f, 2.51515675e-02f, 7.60628730e-02f, 2.53875535e-02f, -7.97172729e-03f, -1.34148085e-02f, 1.52286077e-02f, -6.53691441e-02f,
  -6.45456091e-02f, 2.76949331e-02f, 3.08112744e-02f, -3.00135519e-02f, -4.49061505e-02f, 5.50850220e-02f, 4.90254303e-03f, 8.71269107e-02f, 2.89417319e-02f, 6.87692736e-05f,
  -4.88272160e-01f, -5.10124803e-01f, -7.04059228e-02f, -2.39554748e-01f, -4.49155048e-02f, -9.28008184e-03f, 3.89562361e-02f, -6.11295663e-02f, -1.48467615e-01f, 3.23208049e-03f,
  -7.82709047e-02f, 4.07571904e-02f, -3.33429524e-03f, 3.19503359e-02f, 7.85551816e-02f, 3.08107305e-02f, -3.08666900e-02f, -5.88990413e-02f, -2.36440837e-01f, 3.72921699e-04f,
  7.77418318e-04f, -4.66298275e-02f, -5.71106263e-02f, -1.37131274e-01f, -6.51811659e-02f, -1.20886616e-01f, -1.06602497e-01f, 3.53245027e-02f, -1.02171749e-01f, 1.12273462e-01f,
  7.71053359e-02f, -2.32652903e-01f, -4.19612199e-01f, 1.38994068e-01f, 2.89592415e-01f, 2.46451452e-01f, 2.97725387e-02f, 7.15962946e-02f, 9.84869152e-02f, 1.43870637e-01f,
  3.68930370e-01f, -1.91032410e-01f, -3.78660172e-01f, 3.46173584e-01f, 2.04554111e-01f, -1.82197869e-01f, 5.05554259e-01f, 2.29652524e-01f, -1.45193920e-01f, 3.83571275e-02f,
  8.73732790e-02f, 4.18173373e-01f, -3.50653440e-01f, 1.80088803e-01f, 8.62625465e-02f, -1.56706974e-01f, 1.45177126e-01f, -3.05361748e-01f, 3.96002233e-01f, 1.50085405e-01f,
  1.25521541e-01f, -9.36692804e-02f, 5.21892831e-02f, -7.51777366e-02f, 7.35887140e-02f, 8.39860588e-02f, -9.98044480e-03f, -2.38594890e-01f, -8.00247341e-02f, -1.18462451e-01f,
  -5.08486032e-02f, -9.50799957e-02f, -1.42103778e-02f, -6.13468438e-02f, 7.85301104e-02f, 5.56313433e-02f, -6.00680895e-02f, -9.02422294e-02f, 2.83526480e-02f, -2.07777902e-01f,
  -1.03076957e-01f, -2.38137543e-02f, 5.34084775e-02f, -1.11305127e-02f, -2.18437575e-02f, 1.07405977e-02f, -1.43290190e-02f, -2.17414126e-01f, 2.04632804e-03f, -1.68213770e-02f,
  -5.32370396e-02f, 2.92945351e-03f, -1.53414056e-01f, -5.07566482e-02f, -5.74050434e-02f, -3.10525089e-03f, 7.08942786e-02f, 8.33192766e-02f, 7.17287476e-04f, -6.62039593e-03f,
  6.77970052e-02f, 4.04938422e-02f, 1.38585284e-01f, -5.58146946e-02f, 1.80394620e-01f, 1.04335407e-02f, -4.43817675e-02f, -8.82692710e-02f, 3.46491635e-02f, 2.48775259e-02f,
  7.63873905e-02f, 1.18780226e-01f, -1.18186168e-01f, 5.35568297e-02f, 1.65716156e-01f, -1.83153808e-01f, 7.20146000e-02f, 5.64524680e-02f, -8.54401588e-02f, 6.60819486e-02f,
  5.95529154e-02f, -1.35306999e-01f, -8.02562758e-02f, -2.08098646e-02f, 4.71408442e-02f, 1.48452461e-01f, 1.28320903e-01f, -6.60962658e-03f, 5.52573837e-02f, -3.78450602e-02f,
  2.64366865e-02f, 2.12330115e-03f, 1.19910970e-01f, -3.96886431e-02f, 7.46549070e-02f, 2.25014035e-02f, -2.73573976e-02f, -1.63383391e-02f, 8.67872238e-02f, -2.31124330e-02f,
  2.88538896e-02f, 1.70297995e-02f, 5.82093112e-02f, -2.77808704e-03f, 1.39031872e-01f, 7.55316392e-02f, 1.00580186e-01f, -7.00015947e-02f, 3.88373085e-03f, -7.89756253e-02f,
  -2.26080231e-02f, -1.58914790e-01f, -3.30684990e-01f, -2.22749621e-01f, -8.66906345e-02f, 3.41165662e-01f, 3.15971196e-01f, -1.58721000e-01f, -3.13144326e-01f, 2.84818351e-01f,
  3.05221826e-01f, -2.59596974e-01f, 1.94497630e-01f, 4.50688750e-01f, 2.49696031e-01f, 2.81223923e-01f, 1.45100534e-01f, 2.09969997e-01f, 4.72477637e-02f, -1.34516686e-01f,
  -1.38854131e-01f, 3.70749295e-01f, 2.38007352e-01f, -2.20471248e-02f, 4.68898453e-02f, -2.18011573e-01f, 5.76837808e-02f, -4.31190468e-02f, 1.97175682e-01f, 2.22972199e-01f,
  2.04550654e-01f, -1.53864324e-01f, 5.89331724e-02f, -7.60416836e-02f, 1.05501309e-01f, 1.42510638e-01f, -8.56215414e-03f, 6.97883265e-03f, -1.32238835e-01f, -6.41857460e-02f,
  -1.21374018e-01f, -1.29826188e-01f, -1.31396234e-01f, 3.48429531e-02f, -1.63846761e-01f, -1.90728962e-01f, -1.64341211e-01f, -2.91416179e-02f, -1.12343512e-01f, -3.99143770e-02f,
  -3.87321897e-02f, -8.34590346e-02f, -7.79604539e-02f, 5.08171618e-02f, -8.29936862e-02f, -1.48002103e-01f, 6.71768561e-02f, -8.88183992e-03f, -1.20741002e-01f, -6.83633238e-02f,
  -5.38134240e-02f, -6.73243869e-03f, -3.73256579e-02f, -2.82397382e-02f, -8.07152502e-03f, 5.30956350e-02f, -4.99565341e-03f, 8.87108967e-02f, -4.01503071e-02f, -8.97282641e-03f,
  -6.33953586e-02f, -5.79593889e-02f, 1.00865208e-01f, 4.36538309e-02f, 2.16687517e-03f, 5.91667695e-03f, 7.89564401e-02f, -6.95637837e-02f, -1.18263662e-02f, 1.38797536e-01f,
  -4.09450866e-02f, -1.03634387e-01f, 7.40711987e-02f, 8.08263421e-02f, 3.28565799e-02f, -2.29824148e-02f, 2.67302599e-02f, 1.42035544e-01f, -3.31220287e-03f, -4.07201871e-02f,
  1.13303930e-01f, -7.13791102e-02f, 4.54690401e-03f, 3.71972807e-02f, 1.80081517e-01f, 2.98724533e-03f, 1.21978030e-01f, -7.24281222e-02f, -1.08097866e-01f, 5.02782986e-02f,
  6.63760528e-02f, -2.44009066e-02f, -7.15217739e-02f, 2.02040784e-02f, -1.51116043e-01f, 5.81811480e-02f, -4.56358083e-02f, -6.11607321e-02f, -8.34126696e-02f, -1.46074235e-01f,
  2.39627040e-03f, -1.10010363e-01f, -1.17901064e-01f, 1.82151366e-02f, -6.61381707e-02f, 8.19404647e-02f, -4.80069853e-02f, -6.40794709e-02f, -1.16359830e-01f, -3.28396335e-02f,
  3.41786355e-01f, -3.41422677e-01f, -3.12271249e-02f, 3.27609032e-01f, -3.55142131e-02f, -4.05178182e-02f, 3.26549225e-02f, 8.78513679e-02f, 6.22300923e-01f, -2.71066248e-01f,
  -2.26040989e-01f, 1.35200456e-01f, -1.58366933e-02f, -2.35733464e-01f, 3.64958137e-01f, 2.57897794e-01f, 1.93330739e-02f, -8.21062475e-02f, 1.33796304e-01f, 3.76812853e-02f,
  1.23586424e-01f, -3.16806406e-01f, -2.58734107e-01f, -2.65687376e-01f, -3.01681101e-01f, -1.72463343e-01f, -2.12395549e-01f, -2.28522465e-01f, -4.92226660e-01f, -1.86539993e-01f,
  -1.38557166e-01f, 9.78748575e-02f, -8.08495581e-02f, -3.74536254e-02f, 2.02956535e-02f, 1.79189686e-02f, -3.94332688e-03f, -1.09896258e-01f, 1.19240679e-01f, -6.63148239e-02f,
  7.49353543e-02f, -3.35727260e-02f, -3.49632427e-02f, -9.15642083e-02f, 4.50958125e-02f, 2.09860038e-02f, 2.24381555e-02f, -4.03694324e-02f, -7.11232796e-02f, -6.64587468e-02f,
  9.06189978e-02f, -8.33168477e-02f, -6.66058734e-02f, 4.99409810e-02f, -9.14696082e-02f, -9.00579467e-02f, 1.13372333e-01f, -6.88160304e-03f, 6.21591322e-02f, 2.58268919e-02f,
  -7.04695359e-02f, 5.66567369e-02f, -8.38296488e-02f, 1.99288782e-02f, -4.97695245e-02f, 7.00151641e-03f, -1.42913805e-02f, 1.66564528e-02f, 1.48940846e-01f, -5.25421910e-02f,
  -3.98966745e-02f, -7.19148964e-02f, 1.13699853e-01f, 1.89723540e-02f, 1.24310523e-01f, 1.90911889e-01f, -1.78606585e-02f, -1.74945258e-02f, 1.27243415e-01f, -2.76549384e-02f,
  7.89231658e-02f, 5.94044439e-02f, -1.45675912e-01f, -1.88215934e-02f, 1.26196388e-02f, 5.61732277e-02f, -1.09841585e-01f, -3.70789953e-02f, 1.52647868e-01f, -9.35427621e-02f,
  -1.75621789e-02f, -5.60290441e-02f, -6.03459440e-02f, 1.70681886e-02f, 9.73650366e-02f, -9.85194743e-02f, 3.68908644e-02f, 8.62232819e-02f, 5.37306145e-02f, 3.69270071e-02f,
  3.34658213e-02f, -7.60890590e-03f, 1.38179570e-01f, -3.52450460e-02f, -4.15716879e-03f, -1.15383007e-01f, 1.49080008e-01f, -7.91376270e-03f, 3.08883898e-02f, -1.12007685e-01f,
  -1.20993264e-01f, 1.32283673e-01f, 4.96519692e-02f, 1.09229907e-01f, -4.49972926e-03f, -2.70162933e-02f, 1.61050111e-01f, -1.61767617e-01f, 6.02410249e-02f, 1.71600543e-02f,
  -2.52037108e-01f, -7.23742619e-02f, 3.51888239e-01f, 2.91570544e-01f, -2.41324678e-01f, -3.01515758e-01f, 3.71506475e-02f, -5.89430593e-02f, -9.63845626e-02f, -3.06477934e-01f,
  1.71180502e-01f, -1.06248828e-02f, 3.65095705e-01f, 2.46369708e-02f, 3.39204550e-01f, 3.03155810e-01f, 6.90070465e-02f, 4.87312861e-02f, 1.92455098e-01f, 9.55482498e-02f,
  1.66537255e-01f, -1.18322492e-01f, 4.62506056e-01f, -4.96149100e-02f, 1.46351969e-02f, 1.83549449e-01f, 2.35883355e-01f, 2.07462922e-01f, -7.79948756e-02f, 9.32888314e-03f,
  6.43340722e-02f, 7.63280094e-02f, 1.02426544e-01f, -4.97044697e-02f, 3.35218608e-02f, -1.11898378e-01f, 1.09335827e-02f, 1.25708491e-01f, 1.88585073e-01f, 4.95653078e-02f,
  -8.87628347e-02f, 3.52780707e-02f, 7.31676212e-03f, -8.53342116e-02f, -2.26888925e-01f, -9.31722522e-02f, -7.12269619e-02f, 2.43061651e-02f, 9.84319001e-02f, -3.60451937e-02f,
  -3.45364250e-02f, -3.43770869e-02f, -9.48168524e-03f, -5.58162481e-02f, 8.36348683e-02f, -5.70228994e-02f, -1.10430673e-01f, 1.02406196e-01f, -9.16390494e-02f, -7.06562549e-02f,
  -2.13189647e-01f, 8.37964863e-02f, 1.16184674e-01f, 5.21697775e-02f, 1.32202223e-01f, -5.34494258e-02f, -1.29100657e-03f, 3.41938175e-02f, 1.90527327e-02f, -4.65344712e-02f,
  2.74364017e-02f, 6.16352744e-02f, -4.39652652e-02f, -8.36338773e-02f, -3.85590196e-02f, -1.37797415e-01f, 6.32273257e-02f, 2.16871258e-02f, 2.54356246e-02f, 7.78390691e-02f,
  1.81567162e-01f, -1.38171062e-01f, 1.02902554e-01f, 6.03478402e-04f, -1.23236038e-01f, 6.41908273e-02f, -1.43815979e-01f, 1.34024983e-02f, 1.53777480e-01f, 3.62552144e-02f,
  6.52639344e-02f, 1.62104666e-01f, 5.61045110e-02f, 2.50984691e-02f, 1.62035212e-01f, 2.92609129e-02f, -4.64586020e-02f, -6.21245429e-02f, 1.22383330e-02f, -3.98525670e-02f,
  -1.56283438e-01f, 8.57264847e-02f, 5.96780106e-02f, -1.62010863e-02f, 4.16231491e-02f, 2.92407796e-02f, 8.21417198e-02f, 6.28238171e-02f, 9.55851823e-02f, 4.11652476e-02f,
  8.48158896e-02f, -7.34234825e-02f, -6.69343844e-02f, -9.18718427e-02f, -2.13040560e-01f, 7.78939053e-02f, -1.80483889e-02f, -1.87450070e-02f, 4.05511782e-02f, 7.63103515e-02f,
  3.17201138e-01f, -1.23998880e-01f, 8.55055526e-02f, 1.65786162e-01f, 2.07354575e-01f, -2.35488877e-01f, -4.11414623e-01f, 2.59236157e-01f, -2.19427511e-01f, -2.38995463e-01f,
  8.26233849e-02f, -2.11928710e-01f, -3.10658067e-01f, 4.53430444e-01f, 3.83942366e-01f, -1.22537725e-01f, 4.05555159e-01f, 5.17960973e-02f, 5.48428670e-02f, 3.31548095e-01f,
  2.67352164e-01f, 3.74870032e-01f, 4.14604783e-01f, 3.60717714e-01f, 3.88550431e-01f, 1.24279194e-01f, 1.51925370e-01f, -1.29278675e-01f, 1.19655989e-01f, 6.82575330e-02f,
  8.55958238e-02f, 1.67048797e-01f, 2.54623383e-01f, 2.68456824e-02f, 1.71688527e-01f, -1.09760305e-02f, 3.77807803e-02f, 8.86347983e-03f, 1.92157328e-02f, -1.88927531e-01f,
  -1.49163291e-01f, -1.51649127e-02f, 3.17269750e-02f, 1.04812803e-02f, 9.55904052e-02f, 6.88833967e-02f, 5.15153282e-04f, 5.66559210e-02f, -1.41249493e-01f, 1.05033711e-01f,
  4.93180864e-02f, -5.79655059e-02f, 7.69695267e-02f, 4.68919948e-02f, -1.52454942e-01f, -1.60007879e-01f, -1.73616052e-01f, -1.00297585e-01f, -3.79745923e-02f, 9.40691959e-03f,
  6.78140000e-02f, 3.72226760e-02f, -9.08538699e-02f, 1.00846946e-01f, -8.02243780e-03f, 6.46452978e-02f, -4.61290181e-02f, 2.65017357e-02f, -3.95066850e-02f, 7.71778822e-02f,
  -4.27311733e-02f, 9.87444744e-02f, -7.96110108e-02f, -7.79519975e-02f, 3.70752849e-02f, 1.96214505e-02f, -8.53469502e-03f, -5.53002693e-02f, -1.78847071e-02f, 2.09744237e-02f,
  -9.90722105e-02f, -5.72326556e-02f, -3.06754746e-03f, 2.79342849e-02f, 7.06601962e-02f, -7.14051500e-02f, -1.57692120e-03f, -7.00529963e-02f, 1.61109734e-02f, 7.99928457e-02f,
  -6.84433952e-02f, 6.22721128e-02f, -1.25965467e-02f, -1.20227106e-01f, 6.03672629e-03f, 1.47452876e-01f, 1.15272351e-01f, 5.58019951e-02f, -1.36719421e-02f, 2.27026455e-02f,
  9.17111933e-02f, -1.74406022e-02f, 5.50512224e-02f, 1.56864040e-02f, 2.19633356e-02f, -1.79118477e-02f, -1.28593609e-01f, -1.02057062e-01f, -4.88505466e-03f, 3.09270006e-02f,
  1.86245446e-03f, -7.42210969e-02f, 4.60661761e-02f, -4.24866229e-02f, 5.36336526e-02f, -2.21581414e-01f, 3.53334211e-02f, -2.34310776e-02f, 4.01896387e-02f, -9.08461139e-02f,
  6.50479719e-02f, 3.81320953e-01f, -3.11467191e-03f, 3.17014828e-02f, -8.32713246e-02f, 2.82631516e-01f, 1.64236620e-01f, -3.90366092e-02f, 1.73278432e-02f, 3.05317044e-01f,
  -1.44694716e-01f, 2.52385587e-01f, -1.35896698e-01f, 2.46700019e-01f, -4.41452056e-01f, -1.93088144e-01f, 1.42081484e-01f, 2.49801069e-01f, -5.62728867e-02f, 9.31425020e-02f,
  -2.14347497e-01f, -1.74478948e-01f, -2.30053246e-01f, -1.83339119e-01f, 2.63562441e-01f, 1.28090501e-01f, -3.36683989e-01f, -1.32356569e-01f, 1.54159218e-01f, -1.18917674e-01f,
  1.40063018e-01f, 5.43589555e-02f, 8.89256597e-02f, 1.24486633e-01f, 1.15079008e-01f, 1.57107010e-01f, 9.07243639e-02f, -6.99483156e-02f, -9.94362757e-02f, -5.04927002e-02f,
  1.51449232e-03f, -1.21002668e-03f, 5.74178472e-02f, -1.49217084e-01f, 3.20081487e-02f, 1.20745332e-03f, -1.05699167e-01f, 1.11102633e-01f, 1.11149117e-01f, -1.16900336e-02f,
  1.09059453e-01f, 1.20670483e-01f, 2.41788905e-02f, 5.96867595e-03f, 2.05190312e-02f, -6.59457445e-02f, 8.94090459e-02f, -4.52560745e-02f, 2.10234776e-01f, -3.92537601e-02f,
  -5.10451235e-02f, 4.26698476e-02f, 6.85950741e-02f, 5.86168915e-02f, 4.43031117e-02f, -9.20357928e-03f, -2.54160576e-02f, -9.23871920e-02f, -1.58362567e-01f, 7.56394416e-02f,
  8.45905207e-03f, 1.96391120e-04f, -1.82027761e-02f, -5.74128814e-02f, 6.23965934e-02f, 1.75348893e-02f, -2.48104166e-02f, -2.75568310e-02f, 5.16437180e-02f, -4.97849695e-02f,
  -8.63126963e-02f, 1.04753617e-02f, -3.41626145e-02f, -4.80436673e-03f, 1.60135757e-02f, -7.41737187e-02f, -2.61453576e-02f, -6.72946572e-02f, -3.62297590e-03f, -6.59470707e-02f,
  2.28944216e-02f, 3.86269242e-02f, -3.43391150e-02f, -1.69392675e-02f, -1.75952297e-02f, 3.05597968e-02f, -3.31601165e-02f, 1.12478323e-01f, -9.16393846e-02f, -2.47303359e-02f,
  6.82490245e-02f, 6.32825494e-02f, 1.69732213e-01f, -6.01581819e-02f, -1.06171720e-01f, 5.48113808e-02f, 5.13512753e-02f, 2.32081059e-02f, -2.50158478e-02f, -2.85322927e-02f,
  2.12550163e-01f, 1.80162862e-01f, 5.05889431e-02f, -1.30227078e-02f, 1.64672330e-01f, -9.08360928e-02f, 1.02270797e-01f, -2.94910651e-02f, 4.45395447e-02f, 1.99423614e-03f,
  1.48766175e-01f, -4.31388825e-01f, 1.89522073e-01f, 5.61629189e-03f, -7.29988441e-02f, -1.55896038e-01f, 3.69390845e-02f, -2.45660007e-01f, 6.20045923e-02f, -3.58484238e-01f,
  -2.28403479e-01f, 1.70828074e-01f, -1.60489887e-01f, -1.60749227e-01f, 6.05286241e-01f, 2.66349822e-01f, 6.19057706e-03f, 4.04468216e-02f, 5.17398901e-02f, -2.62772262e-01f,
  9.89052653e-02f, -3.35469276e-01f, 4.70838249e-02f, -4.10745114e-01f, -4.28514868e-01f, -1.32016748e-01f, 9.12525281e-02f, -6.63236901e-02f, -6.57807365e-02f, 2.73801744e-01f,
  -2.36626774e-01f, -1.80436864e-01f, -2.29002669e-01f, -9.71980300e-03f, -1.44728243e-01f, 7.66633227e-02f, 1.76076010e-01f, 1.77818775e-01f, 3.05413920e-02f, 2.30692839e-03f,
  2.64471285e-02f, 1.19841564e-02f, -4.63406295e-02f, 7.65955672e-02f, -9.67827886e-02f, 1.62441395e-02f, 9.50976461e-02f, -1.86540157e-01f, -9.18772072e-02f, -2.22589262e-02f,
  -3.09288464e-02f, -1.19691156e-01f, -3.98121141e-02f, 4.30290075e-03f, 1.30200759e-01f, -1.48326065e-02f, 1.65831760e-01f, 5.02560697e-02f, 7.25091174e-02f, 1.82433203e-01f,
  1.88541234e-01f, -3.26367952e-02f, -1.48868278e-01f, -7.29088113e-02f, 7.61140585e-02f, 3.69959436e-02f, 2.68204324e-02f, 2.09693890e-02f, 8.07068497e-02f, -8.29265937e-02f,
  -2.49893796e-02f, -1.72745679e-02f, -2.22860798e-02f, -9.27841812e-02f, -2.89747622e-02f, 1.43260255e-01f, -2.22436879e-02f, -4.98639345e-02f, -4.14961688e-02f, -2.82884371e-02f,
  7.61768147e-02f, -2.16652844e-02f, -2.02895612e-01f, 5.28220572e-02f, -7.64029473e-02f, 7.54164308e-02f, -2.10513145e-01f, -1.12224504e-01f, -2.26635933e-02f, 5.58481216e-02f,
  -3.74852598e-01f, -4.15337712e-01f, -1.16088808e-01f, -1.16296090e-01f, -9.79216173e-02f, 3.69704957e-03f, -1.39886271e-02f, -9.06450897e-02f, -1.64584294e-01f, 7.17584789e-02f,
  -6.15520030e-02f, -2.34545842e-02f, 6.13202155e-02f, 9.82866511e-02f, -5.88045157e-02f, -6.36428967e-02f, -1.23473831e-01f, -1.01578914e-01f, -7.89892823e-02f, -2.88497284e-02f,
  -1.21676847e-01f, 2.36415379e-02f, 1.35839328e-01f, -4.23249826e-02f, 3.88211496e-02f, -1.05546899e-02f, -4.27829511e-02f, 2.02938281e-02f, 2.60361806e-02f, -8.89840443e-03f,
  2.71955520e-01f, -4.47290570e-01f, 1.65805131e-01f, 2.90344387e-01f, 2.12450385e-01f, 2.28062481e-01f, 1.71344042e-01f, -1.64917052e-01f, -1.24187551e-01f, -4.03101921e-01f,
  -4.70641330e-02f, -1.57547310e-01f, -2.88843155e-01f, 1.20992549e-01f, 4.24271673e-01f, -2.07469791e-01f, 5.24044745e-02f, 4.36422974e-03f, 1.19017169e-01f, 1.88555159e-02f,
  1.72546506e-01f, 1.35621235e-01f, 1.78569570e-01f, -4.51090746e-02f, 1.84483454e-01f, 5.39280884e-02f, -5.46879433e-02f, 1.74663082e-01f, 6.57602027e-02f, 2.31219202e-01f,
  -1.14824228e-01f, -1.15240104e-01f, 1.90177578e-02f, -4.49185260e-02f, -3.47515605e-02f, 8.66605863e-02f, -4.95582179e-04f, 4.49602045e-02f, 1.05494089e-01f, 7.10330606e-02f,
  -1.18707955e-01f, 3.37893777e-02f, 6.41927645e-02f, 6.85852244e-02f, 5.03746681e-02f, 4.53011468e-02f, -2.51215808e-02f, -1.82730146e-02f, -4.04916778e-02f, 4.58283499e-02f,
  -1.65587366e-02f, -2.78083179e-02f, 4.61387411e-02f, -7.43360259e-03f, 3.05706505e-02f, 6.19558915e-02f, 4.63531055e-02f, -1.05705457e-02f, -1.43089304e-02f, 8.27536136e-02f,
  -7.61771435e-03f, 3.15623404e-03f, -1.72430314e-02f, -5.25402501e-02f, -5.33037297e-02f, -1.87490452e-02f, 6.22211210e-02f, 2.99970116e-02f, -1.07487440e-02f, -1.35590270e-01f,
  6.48493841e-02f, 8.54759067e-02f, 2.10955497e-02f, 5.23868725e-02f, 7.28505552e-02f, -2.52773594e-02f, 1.33818358e-01f, -9.63520724e-03f, -4.29627374e-02f, 9.55339745e-02f,
  2.41054837e-02f, -6.97632879e-02f, -4.72097211e-02f, 1.03282057e-01f, 2.55253892e-02f, -5.01182713e-02f, -1.17506655e-02f, -5.87836467e-02f, 2.65065506e-02f, 5.99571317e-02f,
  -4.89594340e-01f, -4.72665191e-01f, -2.26312168e-02f, -6.08367696e-02f, -6.36560842e-02f, -1.46260280e-02f, 8.67252871e-02f, 4.15105559e-02f, -1.56473920e-01f, -5.48741743e-02f,
  -3.76239972e-04f, 7.68505558e-02f, -9.37036797e-02f, -1.78026073e-02f, -5.01353331e-02f, -3.12851518e-02f, -6.61178771e-03f, -9.83041078e-02f, -1.02986723e-01f, -1.25487849e-01f,
  -1.33710712e-01f, -6.02840271e-04f, 1.27835125e-01f, 1.09005995e-01f, -3.51046994e-02f, 2.14509573e-02f, 7.06015751e-02f, -1.03175566e-02f, 5.39708808e-02f, -3.81917134e-02f,
  -5.63790381e-01f, 1.76149875e-01f, 4.18325454e-01f, -2.34708428e-01f, -2.54669458e-01f, 3.97409469e-01f, 4.23842311e-01f, -1.08930297e-01f, -1.83078125e-01f, 2.28216425e-01f,
  9.89214480e-02f, -1.45199895e-01f, 3.57777983e-01f, 2.14346841e-01f, 1.59650132e-01f, 2.96012789e-01f, 1.54579192e-01f, 1.94759071e-01f, -2.76210681e-02f, -1.09549858e-01f,
  -1.33878151e-02f, -4.25038673e-03f, 3.87751758e-01f, -1.69849113e-01f, 7.35447630e-02f, -2.88751781e-01f, -4.22291122e-02f, 1.12775318e-01f, -8.67648423e-02f, -1.85285844e-02f,
  -1.90068826e-01f, -3.55758637e-01f, 7.67234862e-02f, -1.75734665e-02f, -4.81754588e-03f, -2.92451661e-02f, 7.19827926e-03f, 9.91980880e-02f, -5.51336184e-02f, -7.81232640e-02f,
  -6.85106888e-02f, -1.09903060e-01f, -5.33074029e-02f, -8.41914043e-02f, -1.25512958e-01f, -1.11496508e-01f, 6.76216185e-02f, 1.04917794e-01f, 8.71655419e-02f, 6.57841116e-02f,
  2.09210604e-01f, 2.47195307e-02f, 2.40478199e-02f, 2.21516117e-02f, 6.10146075e-02f, -2.44390052e-02f, 5.09934165e-02f, -1.26052545e-02f, -4.48087715e-02f, -1.52205065e-01f,
  2.18505040e-02f, -1.63085461e-02f, 2.14328952e-02f, 2.05548871e-02f, -9.22491252e-02f, -4.09420356e-02f, -3.29709388e-02f, -2.83080284e-02f, 1.04656681e-01f, 1.35329559e-01f,
  -4.87747230e-02f, -1.01767322e-02f, -5.20311221e-02f, 8.55205581e-02f, -2.89480500e-02f, -4.82478216e-02f, 8.40097889e-02f, -1.00764200e-01f, 5.89013658e-02f, -6.06650636e-02f,
  5.26155196e-02f, -1.18965618e-01f, 1.19938187e-01f, -8.75945669e-03f, 3.53957005e-02f, 3.05396151e-02f, -2.69148238e-02f, 1.03556387e-01f, 5.86109944e-02f, 6.62641749e-02f,
  -3.28222275e-01f, -3.62078607e-01f, -5.44576831e-02f, -7.59697631e-02f, 2.30566226e-02f, -8.56715292e-02f, 8.60865880e-03f, -1.15681991e-01f, -4.09490019e-02f, 1.14185959e-02f,
  -3.97716388e-02f, 4.32690121e-02f, -1.04121238e-01f, -3.12295668e-02f, 2.13216804e-02f, -3.14633586e-02f, 3.26069482e-02f, -1.44301727e-01f, -2.55297832e-02f, -7.67242908e-02f,
  -7.23596364e-02f, -1.15155198e-01f, 4.94949371e-02f, 4.61166762e-02f, -3.47831771e-02f, -9.83366556e-03f, -1.05481461e-01f, -4.15120684e-02f, -9.90532041e-02f, 5.87037429e-02f,
  2.82094747e-01f, -2.51875550e-01f, -1.05319329e-01f, -2.95732054e-03f, 2.54615128e-01f, 3.62556875e-01f, 3.33329260e-01f, -9.65946913e-02f, -1.41380534e-01f, -6.31243363e-02f,
  3.44995037e-02f, 9.36266035e-02f, -4.07678746e-02f, -6.94483705e-03f, 3.22319895e-01f, -8.67524892e-02f, 1.42523572e-01f, 1.04752183e-01f, -8.60251114e-02f, 7.77431503e-02f,
  3.57897654e-02f, 2.42056772e-01f, -1.42505035e-01f, -1.24762632e-01f, 1.98202878e-01f, -2.31051490e-01f, -1.31013587e-01f, -9.73613709e-02f, -1.12406470e-01f, 6.61113635e-02f,
  4.78037409e-02f, -7.03579560e-02f, 7.42552504e-02f, -4.40980420e-02f, 6.19829036e-02f, 1.44716576e-01f, 2.54272409e-02f, 1.21541321e-01f, -4.30712029e-02f, 4.79759686e-02f,
  1.50675727e-02f, -6.41816705e-02f, -8.24678540e-02f, -4.81550470e-02f, 6.35456815e-02f, -7.67292902e-02f, -8.60741958e-02f, -7.59831592e-02f, -1.65812075e-01f, 2.99621280e-02f,
  -1.20757006e-01f, 1.71171466e-03f, 6.58750907e-02f, -6.68525770e-02f, -1.14764176e-01f, -8.58653858e-02f, -4.18966860e-02f, -6.89517260e-02f, -2.71585248e-02f, 7.39946142e-02f,
  2.78873648e-02f, 6.79947138e-02f, 9.78948548e-02f, -2.94531938e-02f, 1.21676922e-01f, -6.35790080e-02f, 1.33017942e-01f, -1.74392909e-02f, -3.20646390e-02f, 4.21329513e-02f,
  2.43468750e-02f, 3.60528231e-02f, -1.30182141e-02f, 8.29337984e-02f, 1.02188513e-01f, -8.92764926e-02f, 1.09374240e-01f, -5.27443774e-02f, -9.07468423e-02f, -1.33604288e-01f,
  -4.68166284e-02f, 6.00541271e-02f, 8.28678682e-02f, -1.56698272e-01f, 9.25639615e-05f, 8.63212273e-02f, -5.21376692e-02f, 1.01478726e-01f, -1.48117572e-01f, 2.17003375e-01f,
  4.50414279e-03f, -8.63240585e-02f, -8.70535895e-03f, 2.93953940e-02f, -9.82926488e-02f, 6.92241192e-02f, 6.23166412e-02f, 1.21049158e-01f, 1.33927390e-02f, 1.08338371e-01f,
  1.55444462e-02f, -2.84785815e-02f, 9.39141139e-02f, -2.64586248e-02f, -5.76611310e-02f, 1.01411529e-03f, 4.02728841e-02f, -9.15155858e-02f, 3.50176394e-02f, 7.54231140e-02f,
  1.26125021e-02f, 6.78235665e-02f, 5.44080837e-03f, -6.13645986e-02f, -8.64188536e-04f, -1.22229969e-02f, 1.36409272e-02f, -1.85717177e-02f, 4.53847162e-02f, 2.00747121e-02f,
  -2.12227002e-01f, 1.21221960e-01f, 3.34157914e-01f, 3.29349697e-01f, -1.77000180e-01f, -1.34894580e-01f, -1.37657508e-01f, -1.89807907e-01f, -4.54738475e-02f, -2.29795367e-01f,
  -6.87375441e-02f, 3.49912316e-01f, -5.33618093e-01f, 3.13860744e-01f, 1.95489481e-01f, -3.65927249e-01f, 3.80350769e-01f, 1.06034756e-01f, 5.73518015e-02f, 1.42334223e-01f,
  8.05092081e-02f, 6.32566437e-02f, 1.83171660e-01f, 1.15668312e-01f, 2.48014912e-01f, 4.67450112e-01f, 4.44778919e-01f, 3.59913886e-01f, 4.18455780e-01f, 2.55633593e-01f,
  -6.29525483e-02f, -9.14194509e-02f, 3.60373706e-02f, 5.53429984e-02f, 7.31768683e-02f, 1.99178476e-02f, 2.16061890e-01f, 1.03324838e-01f, 2.01119676e-01f, 2.81142294e-02f,
  4.58448716e-02f, 8.40673968e-02f, 1.27634048e-01f, 3.31365131e-02f, -5.18958876e-03f, 1.91494286e-01f, 9.79284644e-02f, -4.66723926e-02f, 3.77600193e-02f, -5.23810685e-02f,
  5.68526313e-02f, -9.90649462e-02f, 9.26093012e-02f, 2.26230070e-01f, 7.53974617e-02f, 8.25444013e-02f, 7.57746845e-02f, 1.86699867e-01f, 1.10461332e-01f, 2.84366533e-02f,
  -1.60423264e-01f, 8.37529376e-02f, -1.21874675e-01f, 2.85071190e-02f, 5.73279820e-02f, -4.63778824e-02f, -4.77833860e-03f, -7.62405321e-02f, 7.47415498e-02f, -4.49150056e-02f,
  2.94037424e-02f, 7.85785019e-02f, 8.74782819e-03f, 6.39281943e-02f, -1.49948850e-01f, -1.26533955e-01f, 1.10416807e-01f, 1.67612284e-01f, 6.68285415e-02f, -1.19124845e-01f,
  -2.04876080e-01f, 1.01095326e-01f, 6.18022196e-02f, -1.44319773e-01f, -1.95327029e-01f, -1.10847786e-01f, 2.01019898e-01f, 4.73505892e-02f, -7.66711310e-02f, 6.29337654e-02f,
  9.00442451e-02f, 3.28419536e-01f, -2.18941066e-02f, 1.19399279e-02f, 1.52214607e-02f, 1.05621410e-03f, -3.17974426e-02f, 8.52420405e-02f, 1.54470071e-01f, 5.75605221e-02f,
  1.57997161e-02f, 8.97821784e-02f, 3.50968912e-02f, 1.71396825e-02f, 1.12325311e-01f, -6.25618122e-05f, 1.31482109e-01f, 5.04916944e-02f, 1.06541559e-01f, 8.32786486e-02f,
  6.13266192e-02f, -1.00774951e-01f, -1.90439895e-02f, 1.45211071e-02f, -7.74668157e-02f, 1.78397109e-03f, -5.13510965e-02f, 8.44092071e-02f, 3.39578800e-02f, 1.57062352e-01f,
  -1.81068461e-02f, -1.14683650e-01f, 2.29278624e-01f, -3.66697520e-01f, 4.11263146e-02f, 3.03689957e-01f, 1.64734852e-02f, -1.84282094e-01f, -4.27407324e-01f, -2.84962326e-01f,
  -2.66690284e-01f, -4.69831191e-02f, 2.76801884e-01f, -3.49546731e-01f, 4.23127055e-01f, 1.86393589e-01f, -1.97976291e-01f, -3.27582866e-01f, -1.51688427e-01f, -2.80383438e-01f,
  -1.95373014e-01f, -3.97632390e-01f, 2.38347471e-01f, -3.28803807e-01f, -1.94068715e-01f, -1.49572089e-01f, -1.95858091e-01f, -6.78284615e-02f, -2.47589588e-01f, -1.15825675e-01f,
  1.85841796e-04f, -8.00992548e-02f, 1.19944513e-01f, 1.07355818e-01f, 1.30161047e-01f, 5.00654941e-03f, 3.26618478e-02f, -6.01496063e-02f, -8.12752023e-02f, 8.97221193e-02f,
  1.80006642e-02f, 2.10602060e-02f, -1.88488871e-01f, 3.09297461e-02f, -1.45321876e-01f, -5.33379987e-02f, -3.53947957e-03f, 1.00094423e-01f, -2.64910646e-02f, 4.74964939e-02f,
  8.22719373e-03f, 2.49959603e-02f, 1.08133294e-02f, -9.32248607e-02f, -5.79481311e-02f, -1.39038146e-01f, 1.57089144e-01f, 1.32338420e-01f, 5.64535782e-02f, -1.56618990e-02f,
  -1.45572245e-01f, 7.18345691e-04f, 5.60484268e-02f, -5.94968945e-02f, 5.44294389e-03f, -6.74451068e-02f, 3.06282584e-02f, -1.03213273e-01f, -1.29420206e-01f, 2.12445110e-02f,
  -6.47074953e-02f, 1.07321620e-01f, -1.24414548e-01f, -5.85080050e-02f, -4.12865914e-02f, 8.05157796e-02f, 4.98803391e-04f, -1.21426946e-02f, -1.40775800e-01f, -1.11151440e-02f,
  -1.08686402e-01f, -3.37968841e-02f, -1.15810342e-01f, -6.95931464e-02f, 9.80075896e-02f, 6.60534501e-02f, -1.39321148e-01f, -6.09022705e-03f, 6.53620660e-02f, 2.55721025e-02f,
  7.81030655e-02f, -2.36898303e-01f, -3.12833535e-03f, -5.61069734e-02f, 4.79132943e-02f, 1.17728285e-01f, -4.96130176e-02f, -6.41774461e-02f, -2.12867768e-03f, 6.03079936e-03f,
  -1.24709234e-01f, 2.64461450e-02f, 1.41774230e-02f, -2.18858666e-04f, -1.04999550e-01f, -9.18202996e-02f, -2.02766612e-01f, -7.13175684e-02f, -1.09089285e-01f, -1.25588492e-01f,
  -1.76939234e-01f, -3.95547561e-02f, 4.88133393e-02f, -9.84432548e-02f, -1.23474069e-01f, 7.49485428e-03f, 7.76809081e-02f, -1.18503802e-01f, 4.61232523e-03f, -8.57346579e-02f,
  -2.34524056e-01f, -1.22759506e-01f, 6.45044744e-02f, -1.73781514e-01f, 2.92487413e-01f, 2.01806858e-01f, -5.51442662e-03f, 2.27878436e-01f, 3.28073949e-02f, 2.04759225e-01f,
  4.36872467e-02f, -2.78438330e-01f, -1.34972557e-01f, -3.40196669e-01f, -3.67509633e-01f, -2.90680796e-01f, -1.45289600e-01f, -2.26835936e-01f, -1.15949303e-01f, -5.38164601e-02f,
  -1.34579241e-01f, -2.43730724e-01f, -5.65292276e-02f, 1.59914628e-01f, 9.54378471e-02f, 1.74579442e-01f, 8.57727900e-02f, 9.07722414e-02f, 7.82542750e-02f, -6.51108250e-02f,
  1.31310239e-01f, -5.98858343e-03f, 1.57112077e-01f, 1.07902586e-01f, 2.28708446e-01f, -1.72003321e-02f, 8.93422812e-02f, -6.32409081e-02f, -6.55774353e-03f, -5.06601036e-02f,
  -8.80869851e-02f, -1.74859330e-01f, -2.20819399e-01f, -5.56396991e-02f, -2.44164909e-03f, 3.64072211e-02f, -6.39153048e-02f, 1.72697693e-01f, 4.98735383e-02f, -2.15250164e-01f,
  -9.15666595e-02f, -2.91856080e-02f, -9.29178391e-03f, -1.08674146e-01f, -2.16924287e-02f, 6.77585378e-02f, 5.72601147e-02f, -6.54074028e-02f, 1.77135002e-02f, -7.42067397e-02f,
  -1.79781333e-01f, 8.48571025e-03f, 1.13086864e-01f, 5.11027835e-02f, -2.47190408e-02f, 8.26689824e-02f, 2.09341682e-02f, 2.07621045e-02f, 2.87347566e-02f, -1.20126987e-02f,
  -2.03016046e-02f, 6.32937923e-02f, 2.19448954e-02f, -6.88980916e-04f, -1.05143830e-01f, 4.38287109e-02f, 3.28531824e-02f, -5.95887937e-02f, -6.25498518e-02f, 5.51624373e-02f,
  5.62955849e-02f, 9.93770920e-03f, -6.95280638e-03f, 5.65566570e-02f, 1.26622707e-01f, -5.07788919e-02f, -1.17699496e-01f, 4.30129617e-02f, 1.42380282e-01f, -5.69050722e-02f,
  1.60491765e-01f, -6.53880881e-03f, 2.06074819e-01f, 1.42879605e-01f, 6.56883419e-02f, 7.07809925e-02f, -4.03262582e-03f, -6.63535073e-02f, 8.89753923e-02f, 2.94282362e-02f,
  1.55564547e-01f, 8.95846933e-02f, 1.10497242e-02f, -1.24680288e-01f, 7.08337203e-02f, 6.02636710e-02f, 8.00025761e-02f, -6.76078629e-03f, 2.02848181e-01f, 2.56564654e-02f,
  8.47867280e-02f, -2.43664309e-02f, -5.35384193e-02f, -9.70098451e-02f, -7.38866627e-02f, -2.27786452e-02f, 8.14929977e-03f, 9.10247937e-02f, -1.06619619e-01f, -1.28735723e-02f,
  2.08406672e-01f, -1.09539650e-01f, -2.98721224e-01f, -3.53665471e-01f, 2.46193960e-01f, 4.00712073e-01f, 2.18290195e-01f, 4.29220730e-04f, -2.37948179e-01f, 2.20973194e-01f,
  4.46888924e-01f, 4.54371125e-01f, 2.28386551e-01f, 2.61111464e-02f, -1.69690102e-01f, -2.01685473e-01f, -2.15158522e-01f, -1.43975988e-01f, -1.01933450e-01f, -8.43172669e-02f,
  -2.36038834e-01f, 1.23650478e-02f, -2.49914274e-01f, 7.47327209e-02f, 3.32340389e-01f, -6.76220935e-03f, 1.25127025e-02f, 4.14476275e-01f, 2.03319758e-01f, 3.70148927e-01f,
  6.36153743e-02f, -6.47919625e-02f, -1.39585361e-01f, -1.60225425e-02f, 7.41295377e-03f, -6.69185221e-02f, -4.48798276e-02f, 2.32662037e-01f, 1.77287221e-01f, -1.34788036e-01f,
  1.89793810e-01f, 7.51315290e-03f, 4.66174930e-02f, 3.54447998e-02f, -1.59955308e-01f, 1.97406828e-01f, 1.63509190e-01f, -9.02488232e-02f, -3.01796068e-02f, 2.27895603e-02f,
  -9.14207697e-02f, -2.59669721e-01f, -1.58838406e-01f, -1.13545425e-01f, 1.22813456e-01f, 1.27729267e-01f, -1.36609972e-01f, 1.40382126e-01f, -1.47360995e-01f, -1.03846282e-01f,
  1.66721731e-01f, 3.69107425e-02f, -1.26368990e-02f, -3.18506174e-02f, 2.49220524e-02f, -5.40736280e-02f, -2.95050035e-04f, 3.53892855e-02f, 6.26436993e-02f, 1.81761906e-01f,
  -1.37715057e-01f, -2.39359052e-03f, 7.96227064e-03f, -1.88979805e-01f, -9.17828232e-02f, -6.58254251e-02f, 5.52376695e-02f, 1.42505348e-01f, -9.49671045e-02f, -6.59074113e-02f,
  8.45018327e-02f, -1.14479639e-01f, 7.16819242e-02f, -1.06363200e-01f, -1.28022239e-01f, 1.32520810e-01f, 2.36716568e-02f, -4.94356975e-02f, -2.21358575e-02f, 9.54700410e-02f,
  6.66713342e-02f, -1.88593149e-01f, 2.99449600e-02f, -7.65936896e-02f, 1.02874506e-02f, 2.88966093e-02f, -9.43392962e-02f, -2.10502767e-03f, 2.32833275e-03f, -5.05604371e-02f,
  -8.48420039e-02f, -5.53287566e-02f, -4.65302207e-02f, 4.35367599e-02f, -2.51673581e-03f, -3.94330472e-02f, 1.62881926e-01f, 2.05264073e-02f, -1.09828152e-01f, 7.30865523e-02f,
  -2.07352601e-02f, 1.26386713e-03f, 1.11767463e-01f, -4.70214151e-02f, -4.32529226e-02f, 3.52327414e-02f, 1.35381371e-01f, 5.76187782e-02f, -7.99033269e-02f, -1.97179154e-01f,
  -2.04494461e-01f, -5.48223034e-04f, 3.26066107e-01f, -1.31314263e-01f, 1.78427592e-01f, 3.53130758e-01f, 2.50693500e-01f, 3.30586702e-01f, 3.54548633e-01f, -3.38784933e-01f,
  -2.99047053e-01f, -2.69272745e-01f, -5.82811888e-03f, -3.73624176e-01f, 5.08853972e-01f, 3.28419030e-01f, 1.35442719e-01f, -1.47258550e-01f, 1.05091728e-01f, -1.97082907e-01f,
  8.41693580e-02f, -3.93890858e-01f, -1.23241901e-01f, -3.76746118e-01f, -3.39571089e-01f, -1.18969873e-01f, -3.13938141e-01f, 6.46580905e-02f, -3.10195565e-01f, 1.66995630e-01f,
  -1.75735667e-01f, -1.39602602e-01f, -2.90369421e-01f, 5.67099601e-02f, -7.50616044e-02f, -4.75655273e-02f, 4.14929204e-02f, 1.14555545e-01f, 1.45634830e-01f, -4.97806109e-02f,
  -9.24337134e-02f, -4.53436933e-02f, 1.99550986e-02f, 8.58964995e-02f, 6.08810857e-02f, 1.61043350e-02f, 9.41212550e-02f, -2.44393405e-02f, 8.75745900e-03f, 2.01519370e-01f,
  -5.18249534e-02f, -5.58578782e-02f, -2.90640779e-02f, 1.20431714e-01f, 4.07216251e-02f, -2.18253816e-03f, 2.92572100e-02f, 1.04120914e-02f, 3.40059586e-02f, 1.36765122e-01f,
  6.86646551e-02f, 1.47461548e-01f, -6.16213195e-02f, -5.55502474e-02f, -1.11825939e-03f, -3.42757776e-02f, -3.47532369e-02f, -1.29976928e-01f, 2.77474653e-02f, -1.11841276e-01f,
  -6.66968301e-02f, -1.00518174e-01f, 7.62373358e-02f, 1.06281936e-01f, -9.00378078e-02f, -7.88274631e-02f, -4.57641669e-02f, 2.62233578e-02f, -4.89397794e-02f, -1.82385724e-02f,
  -6.85931146e-02f, 5.34833409e-03f, -9.65785608e-03f, 1.34104164e-02f, 7.70919323e-02f, 3.45605984e-02f, -9.59659293e-02f, 1.14800617e-01f, -5.92056364e-02f, -1.05507821e-02f,
  7.38389865e-02f, 8.13678801e-02f, -2.02909827e-01f, -2.91218072e-01f, -3.48246433e-02f, -3.72609831e-02f, 5.06398864e-02f, 3.02373897e-03f, 1.20264940e-01f, 4.36527245e-02f,
  -1.35315493e-01f, -1.36256471e-01f, -1.40737131e-01f, 6.90854415e-02f, 2.88953185e-02f, 1.20309182e-01f, -2.42874864e-03f, -1.41219288e-01f, 6.98544458e-03f, -1.12714164e-01f,
  -2.42663667e-01f, -3.42458412e-02f, 5.12890629e-02f, -4.74294759e-02f, -1.47387192e-01f, -5.48900329e-02f, -6.25236332e-02f, 5.53151360e-03f, -3.75019684e-02f, 9.67446491e-02f,
  5.34038022e-02f, 5.07846534e-01f, 3.69246989e-01f, 2.13482410e-01f, -3.31038207e-01f, 1.12914704e-02f, 8.37699920e-02f, 1.42011926e-01f, 2.07549974e-01f, 7.85834864e-02f,
  -3.23067456e-01f, 5.31679869e-01f, -1.97062418e-01f, 1.96663916e-01f, -2.04606175e-01f, -3.00834209e-01f, 2.62701720e-01f, 1.90829337e-01f, 2.78337002e-01f, 2.71358967e-01f,
  -1.59942418e-01f, -2.11724594e-01f, -2.45133564e-01f, -1.06482506e-02f, 2.43169606e-01f, 4.09661442e-01f, -4.51752767e-02f, -5.35912551e-02f, 2.61237055e-01f, 6.21414296e-02f,
  -8.30267891e-02f, 1.42361537e-01f, 2.55479943e-04f, 8.28996226e-02f, -8.41640830e-02f, -1.16559818e-01f, 1.87735893e-02f, -1.85000807e-01f, -2.27971245e-02f, 1.61727576e-03f,
  -4.07059118e-02f, -4.12046053e-02f, 1.87372585e-04f, -1.78168830e-03f, 1.06961846e-01f, 2.30168611e-01f, 3.21243256e-02f, 7.65025914e-02f, 1.11199737e-01f, -6.93319440e-02f,
  7.65587538e-02f, 8.33620131e-02f, -8.79437402e-02f, 1.51892021e-01f, 3.80216390e-02f, 6.76236525e-02f, 1.62349477e-01f, 3.71419801e-03f, 8.40552524e-02f, 9.29006040e-02f,
  1.02432989e-01f, -1.12219550e-01f, -2.11657360e-02f, -1.42038584e-01f, 7.23436773e-02f, 6.22166693e-02f, 1.75257064e-02f, -1.02131493e-01f, -2.06079911e-02f, -1.02469504e-01f,
  -7.39010647e-02f, 6.67843446e-02f, -6.44008368e-02f, -2.34057102e-02f, 1.17453523e-01f, 8.79593492e-02f, -9.63081717e-02f, 1.14102783e-02f, 9.00178701e-02f, -9.06740129e-02f,
  8.88292715e-02f, 6.44105300e-02f, -2.52101589e-02f, -6.07661083e-02f, 2.59037297e-02f, -1.03855422e-02f, 1.19681448e-01f, 3.69794033e-02f, -3.60995680e-02f, 1.84590388e-02f,
  2.13508859e-01f, 4.36849535e-01f, 8.14738125e-02f, -3.24662006e-03f, -1.60057545e-02f, 5.72478659e-02f, 6.79589203e-03f, 3.62210460e-02f, 3.47229540e-01f, -3.33055481e-02f,
  -8.86307433e-02f, -8.82954970e-02f, -6.51938766e-02f, -1.60656020e-01f, -1.46441059e-02f, 2.86176261e-02f, -3.44057791e-02f, 7.03981072e-02f, 4.86052372e-02f, 1.47593364e-01f,
  -2.50732005e-02f, -2.69112568e-02f, -2.56186891e-02f, 3.53338309e-02f, 4.73376326e-02f, -2.39684507e-02f, 1.81970552e-01f, 9.90869552e-02f, -2.95856521e-02f, 1.24116436e-01f,
  4.07790393e-01f, -5.80639727e-02f, -1.77009940e-01f, 2.28843004e-01f, 3.19598645e-01f, 4.53942835e-01f, 2.04341784e-01f, 2.65528560e-01f, 4.47473079e-01f, -1.99303687e-01f,
  -1.45150647e-01f, -2.44940221e-01f, -4.03266817e-01f, 2.39790753e-01f, 3.07979196e-01f, -9.06319246e-02f, 3.22154164e-01f, 3.62595320e-02f, 3.64151537e-01f, 8.37693140e-02f,
  2.94485629e-01f, 2.46032968e-01f, -1.56036898e-01f, 2.94682309e-02f, 9.42650884e-02f, -2.71208100e-02f, -2.37734020e-01f, -1.04419701e-01f, -1.12558350e-01f, 1.64176494e-01f,
  9.88776758e-02f, 1.67222485e-01f, 7.56468698e-02f, 9.84186158e-02f, 9.82349738e-03f, -4.77345176e-02f, -6.18190095e-02f, -1.41001688e-02f, 8.03287625e-02f, -3.15954536e-02f,
  -1.26940429e-01f, -1.71818379e-02f, 1.23891748e-01f, 2.49069203e-02f, 1.38061479e-01f, -4.10735160e-02f, -6.86674193e-02f, -2.97398716e-02f, -1.91498756e-01f, -4.50781584e-02f,
  -6.09096251e-02f, 5.39291166e-02f, 1.19850703e-01f, 4.65236381e-02f, 1.18562065e-01f, 1.77293479e-01f, -8.38940497e-03f, -2.14423805e-01f, -4.12602685e-02f, 6.94719478e-02f,
  -3.69050130e-02f, 3.06913704e-02f, -1.04566971e-02f, -6.02705255e-02f, 1.22198045e-01f, 1.76724672e-01f, 3.95250954e-02f, -3.92678045e-02f, 1.71842337e-01f, -9.76474360e-02f,
  1.88010558e-02f, 8.53158385e-02f, 1.08143851e-01f, 1.27311200e-01f, 1.46828651e-01f, 5.31989001e-02f, -7.57663175e-02f, -1.18525371e-01f, 5.66604175e-02f, -4.85064797e-02f,
  3.00037097e-02f, 9.78342891e-02f, 1.01165976e-02f, -1.06353655e-01f, 1.22437537e-01f, -4.71385084e-02f, -1.73354615e-02f, -1.52326509e-01f, -9.00440961e-02f, -6.92590624e-02f,
  1.43186465e-01f, 2.33888149e-01f, 1.14478022e-01f, 9.55479518e-02f, 4.48585674e-02f, 4.44574282e-02f, 5.35662770e-02f, 8.13783556e-02f, 1.50995985e-01f, 1.28630549e-01f,
  1.77934133e-02f, -3.29233669e-02f, -1.23714216e-01f, -3.25176045e-02f, 1.64162125e-02f, -1.20268455e-02f, -2.16923729e-02f, 1.14546105e-01f, 4.16675732e-02f, -1.12228533e-02f,
  -1.66026652e-01f, 2.31479295e-02f, -7.50777945e-02f, 1.64751440e-01f, 3.82441394e-02f, -1.08850375e-01f, 9.16894674e-02f, 3.08512598e-02f, -1.30605325e-01f, -6.00144304e-02f,
  5.98329484e-01f, -4.96465415e-01f, -3.83543186e-02f, 2.46428132e-01f, 3.66274208e-01f, 2.09779665e-01f, 4.14104164e-01f, -5.11040576e-02f, 1.79396674e-01f, -2.65918106e-01f,
  1.43178120e-01f, -2.17790142e-01f, -3.30097713e-02f, 1.57252669e-01f, 5.02239764e-01f, -1.71661735e-01f, 1.97477952e-01f, 1.00308642e-01f, 5.89641891e-02f, 9.90538895e-02f,
  1.29515216e-01f, 1.86634228e-01f, 1.09403737e-01f, -4.04302597e-01f, 8.94729123e-02f, -2.11298570e-01f, -7.91915283e-02f, -3.56504619e-02f, -7.65567943e-02f, 5.90705946e-02f,
  6.36456385e-02f, 4.85854857e-02f, 1.17983952e-01f, -1.17531374e-01f, 8.71025473e-02f, -1.48156863e-02f, -7.31913224e-02f, 9.95925590e-02f, 1.46213040e-01f, 3.79307978e-02f,
  5.83848683e-03f, 5.36278151e-02f, -7.42735490e-02f, -1.67229697e-02f, 5.15591837e-02f, -1.42617337e-03f, 1.14035174e-01f, -2.32747365e-02f, 3.57688330e-02f, -1.98944137e-02f,
  8.78405350e-04f, -3.38899158e-02f, 1.16152331e-01f, -1.07102044e-01f, -1.42126521e-02f, -2.65320837e-02f, -1.39727993e-02f, -8.63998476e-03f, -1.49006229e-02f, -7.36045837e-02f,
  7.26625929e-03f, -9.31988582e-02f, 2.25567669e-02f, 3.94786932e-02f, 1.38105214e-01f, 6.25748038e-02f, -1.26004713e-02f, 4.69740443e-02f, 4.04582359e-03f, -5.67472652e-02f,
  1.41095459e-01f, 6.93577826e-02f, -5.48217557e-02f, 1.92584973e-02f, 8.16702843e-03f, -4.62221242e-02f, 5.89448549e-02f, -5.48222587e-02f, 6.09051697e-02f, 5.11092506e-02f,
  -3.85508351e-02f, 8.49324986e-02f, 1.63621046e-02f, 8.09401050e-02f, -5.01976199e-02f, 4.25163610e-03f, -1.37579506e-02f, -8.00457597e-02f, -1.22979516e-02f, 1.15718663e-01f,
  -1.37332737e-01f, -4.38280731e-01f, -8.71394202e-02f, -2.86492817e-02f, -1.44471982e-02f, -1.05287634e-01f, -1.38308078e-01f, -4.98321885e-03f, -3.74826975e-02f, 6.96334094e-02f,
  -9.70689133e-02f, 7.29384124e-02f, -2.85043847e-02f, 5.96241653e-02f, -1.23721354e-01f, 2.52681747e-02f, 1.85261376e-03f, -8.19505900e-02f, -1.12592522e-02f, -1.19841829e-01f,
  -1.08347526e-02f, 7.01412335e-02f, -5.45945354e-02f, 7.03971535e-02f, -8.50206167e-02f, 2.80221812e-02f, -8.81985500e-02f, -3.26506943e-02f, 4.20139506e-02f, -6.43419549e-02f,
  4.12490278e-01f, -2.54191279e-01f, -6.89717233e-02f, -2.01598614e-01f, -1.62856042e-01f, -1.69876665e-01f, 2.27415245e-02f, -4.03620362e-01f, -1.46856472e-01f, -2.14258566e-01f,
  -1.96343601e-01f, 2.60439157e-01f, 2.52997279e-01f, -1.54773787e-01f, 4.32730466e-01f, 2.91498035e-01f, -1.38423085e-01f, 1.14351012e-01f, 1.96767282e-02f, -1.48459390e-01f,
  -3.90624441e-02f, -2.14179590e-01f, -9.14668962e-02f, -3.76859099e-01f, -2.04537779e-01f, -2.16887385e-01f, -1.16666973e-01f, -3.82920653e-02f, -3.36507410e-01f, -7.04584867e-02f,
  1.10997170e-01f, -2.44412404e-02f, 1.81644373e-02f, -4.15658280e-02f, 5.52355722e-02f, 6.65468127e-02f, 1.23049200e-01f, -3.20044458e-02f, 5.57941459e-02f, 5.06698713e-02f,
  7.00200275e-02f, 1.13199003e-01f, -1.34650245e-01f, 1.66084602e-01f, -3.45795117e-02f, -7.49625340e-02f, -1.09640481e-02f, 1.03924699e-01f, -1.59639008e-02f, 2.14154541e-01f,
  3.66575196e-02f, 1.55685157e-01f, 5.69659583e-02f, -3.72320078e-02f, -3.13852467e-02f, -3.90292704e-02f, 2.27057375e-02f, 1.61589414e-01f, 4.95875478e-02f, 6.00489490e-02f,
  -2.95141432e-02f, 5.16965725e-02f, 1.44695327e-01f, 5.97694516e-02f, 6.48660632e-03f, -6.87293112e-02f, 6.50200024e-02f, 8.41781870e-02f, 2.83978088e-03f, 3.44740264e-02f,
  3.39241773e-02f, 2.40907874e-02f, -2.94684842e-02f, 7.81716779e-02f, -6.86925724e-02f, 2.12456193e-02f, 4.87322658e-02f, 2.04978976e-02f, 8.69368482e-03f, 3.00108865e-02f,
  -8.62894282e-02f, -1.63852051e-02f, -2.06438787e-02f, -1.25168890e-01f, -3.26590911e-02f, 8.16284330e-04f, -4.66986932e-02f, 1.01228215e-01f, -2.35339571e-02f, 3.79029028e-02f,
  -1.39264941e-01f, -2.56887048e-01f, 1.12049719e-02f, 1.99962985e-02f, 2.53103543e-02f, -2.47754448e-04f, 3.27971727e-02f, -1.00165926e-01f, -5.68911470e-02f, -9.64615345e-02f,
  2.54989062e-02f, 3.81198488e-02f, -8.63831565e-02f, 3.17540430e-02f, -9.34867263e-02f, -1.65408328e-01f, 9.20984149e-02f, 4.20900136e-02f, -9.16927680e-02f, -5.34059033e-02f,
  5.19140847e-02f, 8.83440375e-02f, 4.06058431e-02f, 2.11423337e-02f, -1.39647156e-01f, 1.81731898e-02f, 1.72504894e-02f, 8.76252130e-02f, 2.99053844e-02f, -8.79506990e-02f,
  -1.37478068e-01f, 3.59715581e-01f, 2.36346215e-01f, -3.45730752e-01f, -2.01912019e-02f, 1.22282684e-01f, -4.27331209e-01f, 1.50517255e-01f, -5.59549153e-01f, -5.61392345e-02f,
  -8.18468481e-02f, -3.47193420e-01f, -1.38982618e-02f, -4.51808311e-02f, -2.00189665e-01f, -1.06610283e-01f, -5.45722879e-02f, -2.37486642e-02f, 1.15777202e-01f, 3.51880372e-01f,
  1.49894148e-01f, -1.17026269e-02f, 2.34411746e-01f, 3.46702933e-01f, 1.56854257e-01f, 1.80705637e-01f, 1.83632374e-01f, 9.03245658e-02f, 2.60194570e-01f, -1.50141433e-01f,
  1.46757169e-02f, -9.93290395e-02f, 9.98251960e-02f, -1.08463071e-01f, 1.48426056e-01f, -4.82209735e-02f, -5.40062487e-02f, -9.32481587e-02f, -7.31919110e-02f, -9.68772639e-03f,
  -4.66719642e-02f, 2.88375164e-03f, 1.64769366e-02f, -2.10594490e-01f, -2.71030143e-02f, -5.31669846e-03f, 1.75905555e-01f, -1.07675716e-01f, -9.33693051e-02f, 2.15785697e-01f,
  2.99857435e-04f, -1.59920990e-01f, 2.48290598e-02f, -1.02031402e-01f, 3.33203822e-02f, 4.23944108e-02f, -1.28062710e-01f, 4.04516757e-02f, 2.37519071e-02f, 2.87031438e-02f,
  9.03458446e-02f, 3.23014520e-02f, 6.19948991e-02f, 5.85580654e-02f, -3.27756405e-02f, -1.17775075e-01f, -1.43674640e-02f, 3.50711532e-02f, -1.17668584e-02f, -9.04258862e-02f,
  -1.90539919e-02f, 1.33193880e-01f, -2.43953131e-02f, -1.00648083e-01f, -3.35931182e-02f, -8.76022279e-02f, 5.22553874e-03f, -3.26353870e-02f, 5.44224195e-02f, 5.74879050e-02f,
  -1.74127594e-01f, -1.22487009e-01f, -8.64911526e-02f, 3.32532972e-02f, -1.59333572e-01f, -4.82498743e-02f, 1.01989642e-01f, -6.26824424e-02f, 1.26958802e-01f, 3.51334624e-02f,
  1.35164976e-01f, 1.63236067e-01f, -9.88761261e-02f, -1.29374787e-01f, -3.34638953e-02f, -6.21743947e-02f, -1.10547341e-01f, 1.03249550e-01f, 1.03447177e-01f, -2.99821347e-02f,
  4.81019765e-02f, -2.86206417e-02f, -3.86718363e-02f, -1.58057138e-01f, -4.20891903e-02f, -5.21163398e-04f, -9.30156559e-02f, -3.21092695e-01f, -2.43811563e-01f, 2.15165660e-01f,
  2.52426695e-02f, 1.01750895e-01f, -1.13820113e-01f, 1.28877267e-01f, 7.45705143e-02f, -1.48149997e-01f, 7.04357103e-02f, 5.07225841e-02f, 8.85652155e-02f, 2.14352459e-02f,
  -5.18369913e-01f, -3.76450717e-01f, 1.74819082e-01f, -3.13186109e-01f, 2.01844901e-01f, 3.24392796e-01f, -3.38159055e-02f, -8.25537294e-02f, -2.81744927e-01f, -4.69093084e-01f,
  -2.40594015e-01f, -2.06502542e-01f, -1.24733619e-01f, -3.51212397e-02f, 5.54169059e-01f, 3.18017066e-03f, 7.45849535e-02f, -6.06546849e-02f, 1.21188201e-01f, -4.62549552e-02f,
  1.65027991e-01f, 1.05239153e-01f, 2.99836874e-01f, 2.29475915e-01f, -1.37687055e-02f, -5.34193707e-04f, -9.15251598e-02f, 2.55497307e-01f, 2.35252187e-01f, 2.29862079e-01f,
  2.99037583e-02f, -3.74866158e-01f, -2.52089612e-02f, 1.41617358e-01f, 1.10189877e-01f, -4.97491062e-02f, 7.84269720e-02f, 2.55079240e-01f, 1.09914593e-01f, 1.17970668e-01f,
  9.78211835e-02f, 2.67721772e-01f, -1.13163680e-01f, 9.43074599e-02f, 5.80204725e-02f, 6.70137778e-02f, 1.45177543e-01f, -9.34188894e-04f, 5.67505360e-02f, 2.39594728e-02f,
  3.19640264e-02f, 2.76606753e-02f, -1.55377507e-01f, -9.14703235e-02f, 4.94416691e-02f, 1.08826766e-02f, -1.17118463e-01f, -5.55097917e-03f, -6.04268909e-02f, -7.50456899e-02f,
  -2.49517597e-02f, -9.57886502e-02f, -3.11235208e-02f, 2.88167633e-02f, -1.25121132e-01f, -4.13496010e-02f, -4.82749678e-02f, 4.18579802e-02f, -2.82552466e-02f, 1.01609528e-01f,
  -1.42103788e-02f, -3.05431150e-02f, -5.03716543e-02f, 3.02137202e-03f, 2.05507665e-03f, -1.10217527e-01f, -1.79408584e-02f, -3.92431431e-02f, -6.93491176e-02f, -1.01918429e-01f,
  -1.23127669e-01f, 5.61901145e-02f, -6.68312460e-02f, 6.78042173e-02f, 6.92635924e-02f, -1.43145854e-02f, 1.70270484e-02f, 9.04653873e-03f, 3.00538149e-02f, 1.50711417e-01f,
  -1.94798931e-02f, -5.03985643e-01f, 1.27053499e-01f, 6.51915148e-02f, 4.32183668e-02f, -5.47857769e-02f, 1.01384886e-01f, -2.22129356e-02f, -4.79516434e-03f, -2.98740026e-02f,
  8.54396354e-03f, 1.27619104e-02f, -7.43521899e-02f, 1.04299121e-01f, 1.48138434e-01f, -5.36736101e-02f, -4.47166013e-03f, 5.92014678e-02f, 6.42294958e-02f, -6.35468364e-02f,
  3.77283199e-03f, -1.98701825e-02f, -6.08588196e-02f, -1.17753103e-01f, -1.41793996e-01f, -6.59849793e-02f, -1.05841629e-01f, -7.25725815e-02f, 3.20474319e-02f, 4.12234366e-02f,
  -3.25789303e-01f, 2.73064673e-02f, 6.98014125e-02f, -2.16686338e-01f, -5.24905562e-01f, 1.01306818e-01f, 4.17032182e-01f, -8.73560533e-02f, 9.57017243e-02f, 3.72789383e-01f,
  -1.03941292e-01f, 6.69218078e-02f, 4.06596839e-01f, -1.61810338e-01f, -1.99428722e-02f, 4.74240839e-01f, 4.15542684e-02f, 1.98825046e-01f, -8.13453570e-02f, 3.00223622e-02f,
  -6.75055534e-02f, -2.09617317e-02f, -1.56878904e-01f, -1.06610127e-01f, -5.38954616e-01f, -1.74231142e-01f, -1.23549759e-01f, -7.06587136e-02f, -2.97170579e-01f, -3.96875441e-01f,
  -3.88045639e-01f, -2.88827062e-01f, -1.57396644e-01f, -1.51258364e-01f, -1.34116709e-01f, 8.96014273e-02f, -1.84861924e-02f, 8.06022529e-03f, -3.34531441e-02f, 9.43794176e-02f,
  5.35729118e-02f, -6.95585599e-03f, -2.54505370e-02f, 1.68606296e-01f, -7.15042204e-02f, -2.52051085e-01f, -2.67454505e-01f, -2.67147124e-01f, -9.71900225e-02f, -1.72513783e-01f,
  -1.97862685e-02f, -1.99712068e-01f, -9.38608646e-02f, -3.72379385e-02f, -1.91498518e-01f, -6.13732869e-03f, -7.08911121e-02f, 2.74156854e-02f, -2.46428430e-01f, -2.35754445e-01f,
  -1.07686855e-02f, 2.32166722e-01f, 3.56831006e-03f, 1.37291074e-01f, 7.69175543e-03f, -1.92171514e-01f, 3.08598764e-02f, 7.92006925e-02f, -7.11663365e-02f, -6.02671690e-02f,
  2.20611487e-02f, -1.62069909e-02f, -1.23377033e-01f, -4.97342534e-02f, 5.50981872e-02f, 1.98346213e-01f, 1.69666871e-01f, -2.37277463e-01f, -3.89322289e-04f, -1.18813276e-01f,
  -1.32022109e-02f, -4.80090640e-02f, 3.57434433e-03f, -6.82147639e-03f, -6.15372695e-02f, -1.05863951e-01f, 3.69034745e-02f, -1.27330003e-02f, -7.15750232e-02f, 3.64572145e-02f,
  -2.85190165e-01f, 7.28262067e-02f, -1.52308673e-01f, -2.17019811e-01f, 6.61732182e-02f, -2.38849297e-02f, 1.33353740e-01f, -2.88801510e-02f, -2.75584627e-02f, 2.18387038e-01f,
  1.19518995e-01f, -5.83524331e-02f, -1.41208395e-01f, 1.40444189e-01f, 1.16453469e-01f, -1.22516500e-02f, -3.78244445e-02f, -3.20800357e-02f, 4.29159291e-02f, -3.48307937e-02f,
  -7.89991617e-02f, 1.46841466e-01f, 2.41931558e-01f, -4.56510112e-02f, -2.66738813e-02f, -1.33872300e-01f, -5.00032492e-03f, 2.94255447e-02f, -3.16721022e-01f, -5.72677925e-02f,
  3.47650170e-01f, -1.16104245e-01f, -4.60156739e-01f, -2.07135916e-01f, 1.65288404e-01f, 5.20386457e-01f, 1.45580009e-01f, -7.40961134e-02f, -4.44440275e-01f, 8.05188995e-03f,
  1.11046456e-01f, 1.71893165e-02f, -2.17221886e-01f, 2.86949068e-01f, 4.87856805e-01f, -1.96728081e-01f, 1.30774304e-01f, 2.21006408e-01f, -2.63885140e-01f, 9.80754420e-02f,
  3.56205204e-03f, 3.50395203e-01f, -2.07671970e-01f, 1.47029191e-01f, 2.83250600e-01f, -1.04096942e-01f, 3.71823370e-01f, -3.61156315e-02f, 4.28996176e-01f, 3.13719094e-01f,
  -3.43889333e-02f, 3.40034962e-02f, -1.19771458e-01f, 1.01322057e-02f, 2.59488989e-02f, 3.19739431e-02f, 5.38226292e-02f, 1.24839857e-01f, 3.50711159e-02f, -4.67181951e-02f,
  1.88307583e-01f, 7.03663826e-02f, -1.43255303e-02f, -3.99088636e-02f, 3.79790738e-02f, -4.40448187e-02f, -2.75410130e-03f, -5.85997142e-02f, -3.26658450e-02f, 6.89705759e-02f,
  -2.21688673e-01f, -8.65402166e-03f, -4.36019935e-02f, -3.54520977e-02f, -1.39560431e-01f, -7.97477588e-02f, -3.16286506e-03f, 8.51351991e-02f, 4.74090651e-02f, 4.31243442e-02f,
  4.19907533e-02f, 3.90158556e-02f, 3.08493171e-02f, 1.92459468e-02f, 6.45215139e-02f, -1.16239883e-01f, 4.71571870e-02f, 5.22348173e-02f, -8.47779512e-02f, -4.21643779e-02f,
  -2.91312281e-02f, 1.21356826e-02f, -6.28572851e-02f, -6.70635626e-02f, 2.30950955e-02f, 2.97792256e-02f, 2.17385907e-02f, 2.29440723e-02f, -8.69167373e-02f, -1.66438714e-01f,
  -5.06889373e-02f, -9.30308271e-03f, 5.73038962e-03f, -4.99462970e-02f, -5.06019592e-02f, -4.86412123e-02f, -7.65809789e-04f, 3.22038904e-02f, -2.83816252e-02f, 7.27295727e-02f,
  -3.34188603e-02f, 8.96054059e-02f, -1.20628782e-01f, 7.75935245e-04f, -2.65137292e-02f, 6.87101409e-02f, -5.79192378e-02f, -1.15864482e-02f, 1.06282189e-01f, 1.26218095e-01f,
  1.50442749e-01f, -3.85518521e-02f, -7.41567314e-02f, -8.82601961e-02f, 4.98758517e-02f, -2.44219173e-02f, 2.24077459e-02f, -1.48583636e-01f, -1.65060293e-02f, 9.15683135e-02f,
  5.70962578e-03f, 8.46009851e-02f, -1.64844114e-02f, -1.44389616e-02f, -2.08547395e-02f, 5.60096763e-02f, 5.12926094e-02f, -1.28356814e-02f, 1.09793991e-01f, -9.44011658e-03f,
  -2.42702246e-01f, -3.08973133e-03f, -1.27693396e-02f, -3.09144676e-01f, 2.70585805e-01f, 2.57861972e-01f, 1.76763851e-02f, 3.66900861e-01f, -9.68594551e-02f, 1.63125189e-03f,
  -6.42256532e-03f, -2.37064824e-01f, 1.49608657e-01f, -3.28300595e-01f, -3.57767314e-01f, -2.61298448e-01f, -2.30302915e-01f, -2.65902668e-01f, 9.64969546e-02f, 9.42796171e-02f,
  -5.41032776e-02f, -1.43156782e-01f, -6.14396408e-02f, 2.67997205e-01f, 2.56585717e-01f, 1.11990631e-01f, 8.54272619e-02f, 2.75453150e-01f, -2.24220175e-02f, -1.05561189e-01f,
  4.01694141e-02f, -3.70374992e-02f, 7.71229118e-02f, -7.31088445e-02f, 1.26262277e-01f, 2.43374884e-01f, 5.81297278e-02f, -9.05860960e-02f, -3.56456786e-02f, -9.43479612e-02f,
  1.62160750e-02f, -6.26171529e-02f, -1.17049001e-01f, 1.06425770e-01f, 6.83450326e-02f, 1.31706759e-01f, -2.87408531e-02f, 1.13693692e-01f, 6.32701367e-02f, -7.22398236e-02f,
  9.54599082e-02f, -5.05932234e-02f, 5.22768386e-02f, -3.06147486e-02f, -8.98111388e-02f, -6.88764304e-02f, 3.54342833e-02f, 5.04681095e-02f, -5.79928160e-02f, 3.37272836e-03f,
  2.91706007e-02f, 2.41029020e-02f, 2.22589262e-02f, 1.99618489e-02f, 1.10534653e-01f, -6.38560131e-02f, -1.60374001e-01f, -1.27545342e-01f, 1.19027540e-01f, -1.86653119e-02f,
  8.98179486e-02f, -8.71571973e-02f, -5.64564776e-04f, -2.39879116e-02f, -1.37305604e-02f, -7.92608634e-02f, -2.29033902e-02f, -1.03679493e-01f, 2.92970780e-02f, 7.30720907e-02f,
  -1.32109761e-01f, -7.02333450e-02f, -5.36757745e-02f, 5.07926568e-02f, -1.08921021e-01f, 4.78943810e-02f, 4.83066253e-02f, -1.27533944e-02f, -4.20106500e-02f, 1.19766869e-01f,
  1.63701782e-03f, -2.71946508e-02f, 1.01016439e-01f, -1.09611645e-01f, -6.84340149e-02f, 1.14396356e-01f, -5.14060408e-02f, -6.70328289e-02f, 6.71438947e-02f, 3.96150351e-02f,
  1.39266953e-01f, 1.08665749e-01f, 3.29372920e-02f, 1.12196160e-02f, -1.69205248e-01f, 7.57258385e-02f, -8.91959071e-02f, -3.19200754e-02f, 1.44355357e-01f, -1.39023717e-02f,
  1.03251077e-01f, -4.58272882e-02f, 5.23500368e-02f, 1.09868281e-01f, 1.12253509e-01f, -6.19587041e-02f, 7.81900808e-02f, -5.00096641e-02f, 9.22713056e-03f, -4.73270640e-02f,
  -1.08901396e-01f, -3.24291617e-01f, 4.83555906e-02f, 1.45295784e-01f, -3.91801335e-02f, 1.20170482e-01f, 1.06519900e-01f, -3.35313350e-01f, -2.76428074e-01f, 9.13860127e-02f,
  2.46108547e-02f, 1.78782102e-02f, -3.04329872e-01f, -3.15985680e-02f, -3.27475041e-01f, -3.45269084e-01f, -4.06708010e-02f, 2.79444933e-01f, -1.80529118e-01f, -3.70805478e-03f,
  3.21899354e-02f, -2.83032775e-01f, -1.16270036e-01f, -1.15163408e-01f, 1.05324589e-01f, 2.59550393e-01f, 1.67259142e-01f, 1.48470988e-02f, 2.89782703e-01f, 4.87066843e-02f,
  4.88481559e-02f, -2.09728464e-01f, 1.20080300e-01f, -8.22059251e-03f, -6.33045658e-03f, 6.69638738e-02f, 1.49325550e-01f, -5.95358433e-03f, 1.57509938e-01f, -6.98086619e-02f,
  -1.10140508e-02f, 5.38498797e-02f, -1.45774186e-01f, 3.08620445e-02f, 7.12401643e-02f, 6.32214621e-02f, -2.54750960e-02f, 4.69102263e-02f, -5.25133237e-02f, -2.72911228e-02f,
  -8.08226988e-02f, 4.68314141e-02f, 3.64719220e-02f, 6.40932545e-02f, -3.65339741e-02f, -6.44158050e-02f, 2.51306016e-02f, 1.88202858e-01f, 1.03894234e-01f, 9.54663679e-02f,
  -4.67978492e-02f, -8.98043141e-02f, -1.56653643e-01f, -8.82345363e-02f, -1.61398426e-01f, 9.12835971e-02f, -6.99855536e-02f, -1.33097833e-02f, 6.64847419e-02f, -5.11251613e-02f,
  1.20051131e-02f, 4.44362685e-02f, -1.07901804e-01f, 6.85650185e-02f, -2.18782760e-02f, 2.76227687e-02f, 2.32152164e-01f, -3.28974016e-02f, 4.48137261e-02f, 1.78592950e-02f,
  3.10692401e-03f, 7.15895221e-02f, 1.12713575e-02f, 6.10542186e-02f, -6.66865110e-02f, -1.01892964e-03f, 7.04161525e-02f, 6.48225024e-02f, -6.87704608e-02f, -2.05559433e-02f,
  -3.62610593e-02f, -3.36753875e-01f, -8.72840509e-02f, 9.84870791e-02f, -3.25752050e-02f, -2.08637826e-02f, -2.11366285e-02f, -7.76151493e-02f, -4.92785051e-02f, -1.54264554e-01f,
  1.94161132e-01f, 1.58917055e-01f, -4.32021096e-02f, 1.04239494e-01f, 3.70385945e-02f, -2.90162731e-02f, -4.95297834e-02f, 9.64426845e-02f, 1.17856497e-02f, 5.81619032e-02f,
  -2.46738326e-02f, 1.65408105e-02f, -7.27423951e-02f, -3.91995013e-02f, 1.61071748e-01f, -8.99162218e-02f, 5.85175678e-02f, 4.42241617e-02f, 2.97428239e-02f, 7.22957775e-02f,
  -7.60089234e-02f, 1.65694609e-01f, 3.46014053e-01f, 2.33313367e-01f, -1.59958869e-01f, -3.36207300e-01f, 5.52340448e-02f, -2.08794978e-02f, 1.81699485e-01f, 6.79613426e-02f,
  -8.45241621e-02f, 3.18211526e-01f, 9.34121106e-03f, -1.27128810e-01f, -2.44785938e-02f, -1.23538643e-01f, 2.11463589e-02f, -5.11604920e-02f, -7.21261352e-02f, 3.27438921e-01f,
  7.99817815e-02f, -5.06027229e-02f, -2.04237998e-02f, 7.13667497e-02f, 5.57015836e-02f, 1.63904369e-01f, 9.82755274e-02f, 2.05120876e-01f, -6.21686950e-02f, -8.51478130e-02f,
  -1.86924189e-01f, 1.87980846e-01f, 1.43662408e-01f, 2.53881644e-02f, 6.15392961e-02f, -1.30334988e-01f, -4.66933399e-02f, -3.91939236e-03f, -4.11374234e-02f, -1.19629197e-01f,
  1.04543500e-01f, -5.85086830e-02f, 1.35780619e-02f, 7.03590959e-02f, -3.08272690e-02f, 8.85196105e-02f, 3.29430029e-02f, -5.84301837e-02f, 1.77105248e-01f, 2.26674210e-02f,
  1.39745474e-01f, 8.97356272e-02f, 3.93864699e-02f, -4.19041216e-02f, 1.16741091e-01f, 6.88756676e-03f, -1.10236615e-01f, 2.39340700e-02f, -1.33215953e-02f, -3.66918445e-02f,
  -6.44326583e-02f, 2.19954979e-02f, -1.34460069e-02f, 5.53778857e-02f, -1.47369867e-02f, -1.58632740e-01f, -5.68400184e-03f, -8.37604627e-02f, 4.70145717e-02f, 8.55119750e-02f,
  -3.36130410e-02f, -2.20467225e-02f, -1.56748742e-01f, -5.17012104e-02f, 5.11670448e-02f, 1.86158735e-02f, -1.06684111e-01f, -4.78580035e-02f, -3.92397381e-02f, 1.01138048e-01f,
  5.69932535e-03f, -1.27980933e-01f, -4.86730511e-04f, 3.63308638e-02f, -1.98823079e-01f, -6.07830472e-02f, 6.16554841e-02f, -1.04265921e-01f, -7.38640353e-02f, 2.05108538e-01f,
  3.70066874e-02f, 4.50588644e-01f, 1.42447427e-01f, -5.33930697e-02f, 3.29653807e-02f, -5.61926924e-02f, -1.02876768e-01f, 1.41219320e-02f, 2.28138387e-01f, 5.85709251e-02f,
  5.48504479e-02f, -1.74081828e-02f, 1.62325185e-02f, -5.78853674e-02f, -2.40993183e-02f, 8.67522135e-02f, 1.04253858e-01f, 1.54921666e-01f, 9.78325829e-02f, -4.70011402e-03f,
  1.18838117e-01f, 2.32811030e-02f, 1.34923443e-01f, -5.56005258e-03f, 8.90491158e-02f, 1.48298562e-01f, 3.80207337e-02f, -2.03617141e-02f, 1.44775197e-01f, 4.32410762e-02f,
  -4.12437588e-01f, 4.69743647e-02f, -2.83021361e-01f, -4.21258658e-02f, 1.93178698e-01f, -3.19154799e-01f, -2.61355251e-01f, 1.37358516e-01f, -2.87309289e-01f, 1.83234334e-01f,
  2.38094509e-01f, -3.79485130e-01f, -2.11838353e-02f, -2.85992175e-01f, -4.34995055e-01f, -4.40026253e-01f, -1.64522067e-01f, -1.59866825e-01f, -2.45250911e-01f, 2.71065563e-01f,
  -9.71197262e-02f, 1.55526236e-01f, -2.99176835e-02f, 1.93575278e-01f, 3.06467898e-02f, 1.10723741e-01f, 4.14684683e-01f, 1.31787390e-01f, 1.22461155e-01f, -3.77044901e-02f,
  -5.21175973e-02f, -1.23546295e-01f, -3.65842208e-02f, -2.07231473e-02f, 4.55742888e-02f, 7.58406743e-02f, 1.43123046e-01f, -1.45309344e-01f, -7.90165514e-02f, 4.11246554e-04f,
  1.02381937e-01f, 3.79149579e-02f, -3.23231928e-02f, -4.34731431e-02f, 4.58407588e-03f, 8.75824317e-02f, -1.49991781e-01f, 2.55222637e-02f, -8.48242268e-02f, -9.70756486e-02f,
  1.30254421e-02f, -5.19984253e-02f, 2.76444182e-02f, -1.63269825e-02f, -3.75434868e-02f, 5.00958832e-03f, 1.54786427e-02f, 1.84182912e-01f, -1.36542693e-01f, 9.30474401e-02f,
  1.21318571e-01f, 4.17956673e-02f, 7.57022761e-03f, -1.35338217e-01f, -1.12965861e-02f, 3.88259068e-02f, -1.21750884e-01f, -4.47312817e-02f, -1.02381848e-01f, 7.63486773e-02f,
  8.11350718e-02f, -6.88955635e-02f, -9.25444961e-02f, 1.47916928e-01f, 1.53135816e-02f, -7.01683238e-02f, -6.57192171e-02f, 7.36842230e-02f, 8.48824829e-02f, -1.06906079e-01f,
  9.22613069e-02f, 2.54233945e-02f, 1.33600786e-01f, 1.89116988e-02f, -4.58556190e-02f, 2.26034418e-01f, 4.32226993e-02f, 9.81379580e-03f, 1.14042498e-02f, -7.80048035e-03f,
  1.94667846e-01f, 2.88964897e-01f, -3.74976173e-02f, -1.23819537e-01f, 3.33080217e-02f, -2.61297263e-02f, -1.12066589e-01f, -2.66497619e-02f, 3.32760662e-02f, 1.76267903e-02f,
  1.11505739e-01f, 1.29426986e-01f, 2.61965990e-02f, 1.95848942e-02f, -7.86976069e-02f, 2.09550664e-01f, 1.62520736e-01f, 7.71010667e-02f, 7.91665688e-02f, 1.15069553e-01f,
  1.72122002e-01f, 1.12186715e-01f, -9.36257020e-02f, 3.00785038e-03f, 5.35784066e-02f, 1.26340657e-01f, 2.06127446e-02f, 1.67393222e-01f, -7.22705275e-02f, 1.02240324e-01f,
  1.65806189e-01f, -1.03060015e-01f, -4.11116779e-01f, -2.40875974e-01f, -2.95358658e-01f, -1.21760041e-01f, -1.39573902e-01f, -1.81010395e-01f, -1.30607873e-01f, 3.17433089e-01f,
  1.52153909e-01f, 9.93958041e-02f, -2.35449988e-02f, 3.31249684e-01f, 2.63649583e-01f, 3.37290049e-01f, 3.08029681e-01f, 2.80243009e-01f, 2.17066705e-02f, -8.12144130e-02f,
  -1.00383516e-02f, 2.96999902e-01f, -9.56265554e-02f, -1.52630573e-02f, -2.21140176e-01f, -2.98258930e-01f, 5.78387529e-02f, -3.64025205e-01f, 6.29486144e-02f, 1.08734466e-01f,
  8.51022452e-02f, -7.24158660e-02f, -9.62133706e-03f, 8.26135278e-02f, -1.36957482e-01f, -1.25217047e-02f, -8.75955075e-02f, 3.02798431e-02f, -4.71608192e-02f, -1.11892715e-01f,
  9.21182036e-02f, 9.51484367e-02f, 1.19888455e-01f, 4.90194969e-02f, 2.13721078e-02f, -1.06869482e-01f, -2.64090057e-02f, 5.20724803e-02f, -1.17152236e-01f, 3.41314152e-02f,
  -8.15127492e-02f, 6.82826247e-03f, -1.03344522e-01f, 9.51055735e-02f, -1.21148072e-01f, -1.03367992e-01f, -2.68701091e-02f, -9.93530080e-02f, 5.68058304e-02f, 6.67610392e-02f,
  3.68252844e-02f, -2.30857339e-02f, 4.55132984e-02f, 6.34594560e-02f, 1.54005550e-02f, -9.20075551e-02f, 8.82988498e-02f, 1.06494144e-01f, -6.65671229e-02f, 1.01090651e-02f,
  -2.04070248e-02f, -7.59938210e-02f, 5.17501235e-02f, 5.96331097e-02f, 1.21459305e-01f, -2.51626894e-02f, -7.76262283e-02f, 9.57185123e-03f, -7.17256665e-02f, -8.19276646e-02f,
  2.85918824e-02f, 2.78297197e-02f, 7.73518309e-02f, 1.14193209e-01f, 5.08179180e-02f, 1.16191562e-02f, 4.30277139e-02f, -4.49014409e-03f, -1.05619386e-01f, -9.36962068e-02f,
  -4.93357331e-02f, -9.63059813e-02f, 2.56990883e-02f, 5.86998090e-02f, -1.13141917e-01f, 7.01806545e-02f, 2.94490028e-02f, -3.53743732e-02f, 4.09736224e-02f, -1.73449963e-02f,
  1.69417895e-02f, -2.08439678e-02f, 4.17524762e-02f, -8.58511105e-02f, -1.25584185e-01f, 5.49741536e-02f, 1.21393226e-01f, 9.08563584e-02f, -1.57548517e-01f, 1.90417264e-02f,
  -5.76778315e-03f, -6.23621307e-02f, 5.16188815e-02f, -7.04947487e-02f, 1.30904913e-01f, -6.76826239e-02f, 1.75989047e-02f, 4.66799270e-03f, -2.42635421e-02f, -2.86111236e-02f,
  2.80276030e-01f, -1.93009749e-01f, -5.89499399e-02f, 9.43538770e-02f, 3.22813392e-02f, 1.44030154e-01f, 4.57803279e-01f, -2.26056337e-01f, -3.42503488e-01f, -5.73814027e-02f,
  2.01000795e-01f, 2.11190864e-01f, 4.07727748e-01f, 2.34149024e-01f, 4.71805841e-01f, 3.11609387e-01f, 2.56180260e-02f, 1.06790960e-01f, -3.08695972e-01f, 7.05932677e-02f,
  2.82020681e-03f, 2.27668241e-01f, 2.06270248e-01f, -3.62786621e-01f, 1.87572494e-01f, -3.58586311e-01f, 1.17837459e-01f, 1.67780384e-01f, -1.20796092e-01f, 2.87355304e-01f,
  3.93464081e-02f, 2.05425657e-02f, -7.19476566e-02f, -3.97797376e-02f, -3.73149328e-02f, 1.08634323e-01f, 6.02779258e-03f, 1.98686525e-01f, 1.17766028e-02f, 1.77970827e-02f,
  1.34869665e-01f, 2.27879863e-02f, -1.82758510e-01f, 5.46427853e-02f, -8.20431411e-02f, -2.16099828e-01f, -1.26346678e-01f, -1.24078885e-01f, -1.40259326e-01f, 8.73973668e-02f,
  1.89304091e-02f, -1.10429548e-01f, -1.81386359e-02f, -7.23501593e-02f, 4.00787219e-02f, -7.19740614e-02f, 5.32960631e-02f, 4.42660823e-02f, 1.72059461e-02f, 4.74558957e-03f,
  -2.33379938e-02f, 1.13138430e-01f, -4.27452885e-02f, -2.87447162e-02f, 1.02264034e-02f, -5.52261621e-02f, -3.05811260e-02f, -4.47293147e-02f, -2.32539438e-02f, 1.31175354e-01f,
  -1.45134240e-01f, -1.14758767e-01f, 9.78960842e-03f, -2.77895313e-02f, -6.53058663e-02f, 3.31004299e-02f, 2.67228000e-02f, 3.67427170e-02f, -9.94567201e-02f, 2.13435087e-02f,
  -6.75762014e-04f, 7.41001815e-02f, 5.71482815e-02f, 6.07864708e-02f, -3.46515700e-02f, 1.49846986e-01f, 3.70400734e-02f, 5.63499704e-02f, -7.79700503e-02f, 7.06758797e-02f,
  1.41446106e-02f, -3.99977900e-03f, 2.85789818e-02f, -9.67753306e-03f, -2.37440206e-02f, -7.13809254e-03f, 6.33636564e-02f, -8.75369310e-02f, 1.56913139e-02f, -7.10857809e-02f,
  -1.12438977e-01f, -1.37323767e-01f, -1.44039750e-01f, 1.31309479e-02f, 2.48884577e-02f, 1.49488142e-02f, 8.57325941e-02f, 3.04681845e-02f, 1.04552895e-01f, -9.56262499e-02f,
  1.00369036e-01f, 3.68654430e-02f, 5.79614826e-02f, -4.72830050e-02f, 1.61175411e-02f, 1.21975161e-01f, -6.07274398e-02f, -3.13433185e-02f, -7.63705047e-03f, -3.85714248e-02f,
  6.66707873e-01f, 3.84091109e-01f, 3.00339043e-01f, 3.91253829e-01f, -5.24755493e-02f, 1.39724255e-01f, 2.70214975e-01f, 7.72663355e-02f, 2.71662086e-01f, 2.31461838e-01f,
  -3.04098785e-01f, 3.96111906e-01f, -1.86325878e-01f, 1.51911497e-01f, -1.60651252e-01f, -2.80560881e-01f, -1.27354078e-02f, 1.09250866e-01f, -5.81486374e-02f, 1.53039977e-01f,
  -8.58750641e-02f, -2.60098785e-01f, -1.73223481e-01f, -1.08671501e-01f, 1.91347241e-01f, 1.84775040e-01f, -4.87384290e-01f, -2.25580826e-01f, 6.69567883e-02f, -2.30157942e-01f,
  5.67441853e-03f, 1.06012620e-01f, 2.04734668e-01f, 4.71345149e-02f, 1.32006258e-01f, 7.84479920e-03f, 6.60718232e-02f, -3.64014320e-03f, -4.54358384e-02f, 9.68277305e-02f,
  1.73096538e-01f, -3.97204328e-03f, 1.06931649e-01f, -7.25139827e-02f, 1.93020776e-01f, 2.13837981e-01f, 9.56677496e-02f, 1.09459363e-01f, 1.28040358e-01f, -3.60876285e-02f,
  1.75402388e-01f, 1.82535425e-01f, 1.01261400e-01f, -2.85759903e-02f, -4.12031710e-02f, -4.04420681e-02f, 1.40953600e-01f, -5.12337834e-02f, 9.22007710e-02f, 1.71918780e-01f,
  -1.71433911e-01f, -9.02416930e-02f, -1.45761138e-02f, -1.20189553e-03f, 2.99951825e-02f, -6.22378625e-02f, -1.04284203e-02f, -4.90662130e-03f, 9.78111327e-02f, -1.36817461e-02f,
  8.12195241e-02f, 4.11156639e-02f, -2.19894126e-02f, 9.06420723e-02f, 2.28728708e-02f, 1.92294046e-01f, -4.60882112e-02f, -1.64928082e-02f, 7.17695951e-02f, -1.02450028e-01f,
  -1.32068798e-01f, -1.19528130e-01f, 2.54805237e-02f, -2.28088405e-02f, -3.32633741e-02f, -3.80305238e-02f, -3.37949954e-02f, 1.49726897e-01f, -3.58927362e-02f, -1.03933074e-01f,
  -8.51390064e-02f, -1.99211448e-01f, -3.70258912e-02f, 5.35642877e-02f, 4.34826761e-02f, 1.27450168e-01f, 7.80066699e-02f, 1.64773941e-01f, -4.18479741e-02f, 3.01019102e-02f,
  9.21905041e-02f, 9.74496007e-02f, 3.99856381e-02f, -6.03484027e-02f, -2.70267320e-03f, 9.29263085e-02f, 7.31205894e-03f, -6.90232068e-02f, -5.24165593e-02f, -1.31102115e-01f,
  6.54509664e-02f, 4.03758511e-02f, 1.28387466e-01f, 6.24943189e-02f, 1.35416612e-01f, 2.85539869e-02f, -3.05881404e-04f, 6.57724589e-02f, -5.69030829e-02f, -5.50386049e-02f,
  3.14002216e-01f, 4.03070711e-02f, 1.12644359e-01f, -2.32654512e-01f, 2.44401544e-02f, 4.22645211e-01f, 1.40101492e-01f, 1.01525651e-03f, -9.28531289e-02f, 2.14628845e-01f,
  2.30503380e-02f, 1.23675324e-01f, -7.19542708e-03f, -1.47630155e-01f, 1.78781971e-01f, -1.44155905e-01f, 1.37159780e-01f, 7.58166760e-02f, -8.95989388e-02f, 2.25061476e-01f,
  2.90251244e-02f, -7.67957792e-02f, -2.39884958e-01f, -7.07928389e-02f, 2.02627897e-01f, -7.93888718e-02f, -5.47661372e-02f, 9.18316394e-02f, 3.62478010e-02f, 1.08209290e-02f,
  1.90050416e-02f, -1.07884422e-01f, 6.38434514e-02f, -9.10206512e-02f, 5.65932542e-02f, 1.17520958e-01f, 1.22758485e-02f, -3.54015790e-02f, -4.01273556e-02f, -5.16151227e-02f,
  1.11224800e-01f, -4.53200303e-02f, 2.31496971e-02f, 3.34514678e-02f, 7.10017607e-02f, -3.37256826e-02f, -1.86645538e-01f, -2.92385276e-02f, -2.12719943e-02f, 9.12806690e-02f,
  -7.35621899e-02f, -7.39356503e-02f, -2.16885060e-02f, -2.75987983e-01f, -5.41159175e-02f, -5.68326637e-02f, -5.04074432e-03f, -2.79312339e-02f, -1.18501217e-03f, 1.06326289e-01f,
  -1.72230173e-02f, 1.28803164e-01f, -4.48456872e-03f, -1.39000351e-02f, -1.53412409e-02f, -6.94733113e-02f, 7.14111552e-02f, -1.01393484e-01f, 4.61840369e-02f, 8.31095427e-02f,
  -1.69287380e-02f, -4.41102748e-04f, 8.19532387e-03f, -1.22870766e-01f, 6.48763776e-02f, 9.96802673e-02f, 1.09895051e-01f, 8.53470862e-02f, 4.94323559e-02f, -2.21186318e-02f,
  -8.49034339e-02f, 4.78308350e-02f, 4.00537513e-02f, -8.17912072e-02f, -3.21341492e-02f, 5.40350266e-02f, -1.44785885e-02f, 5.16675785e-02f, -2.29627535e-01f, 5.83651140e-02f,
  7.38076940e-02f, 1.35590076e-01f, 2.28544720e-03f, 1.46905053e-02f, -4.41924371e-02f, 1.70098379e-01f, -3.94845307e-02f, -1.01828687e-01f, -4.24437933e-02f, 1.38778627e-01f,
  -5.36977267e-03f, 7.11516514e-02f, 2.02699229e-02f, -1.63329616e-01f, -9.11676660e-02f, 2.93870945e-03f, -1.56207189e-01f, -1.55827358e-01f, 6.78546205e-02f, -5.53319976e-02f,
  -4.75974940e-02f, -1.79806873e-01f, -3.25253271e-02f, -1.38557285e-01f, -1.33363515e-01f, -5.70030026e-02f, 1.34714738e-01f, 7.06325397e-02f, 6.67704567e-02f, -9.75229740e-02f,
  1.83928564e-01f, -9.09602121e-02f, 2.55562682e-02f, 5.26697099e-01f, 3.17638628e-02f, -3.65492731e-01f, -4.46291000e-01f, 1.72356106e-02f, -2.81011686e-02f, -1.48307338e-01f,
  3.26853067e-01f, -3.50042254e-01f, -2.93983728e-01f, 3.60701501e-01f, 3.23718905e-01f, 1.14382699e-01f, 1.26890510e-01f, -1.41696796e-01f, -1.84334442e-01f, 2.04093739e-01f,
  2.72127777e-01f, 3.67872208e-01f, 2.63441622e-01f, 1.86055154e-01f, 2.07967520e-01f, 3.43764797e-02f, 1.27942815e-01f, -1.72454447e-01f, 2.47591987e-01f, -7.64823034e-02f,
  5.87487333e-02f, 1.56570107e-01f, -5.77485971e-02f, -6.79477602e-02f, 1.37661070e-01f, -3.28780455e-03f, -1.23256780e-01f, -1.27070576e-01f, -7.37416521e-02f, -1.04793936e-01f,
  -9.88843292e-02f, 1.45741642e-01f, 1.34487793e-01f, 1.22047111e-01f, -1.25742462e-02f, 2.41989065e-02f, 3.22714634e-02f, -1.39605939e-01f, -6.04820959e-02f, -6.41452894e-02f,
  4.58280072e-02f, 1.17189422e-01f, 7.00356960e-02f, -2.08589509e-02f, 7.26078749e-02f, 7.88948834e-02f, -3.83173139e-03f, -1.97733551e-01f, 2.90549565e-02f, 6.38171211e-02f,
  -2.48142425e-03f, 3.55833434e-02f, 6.88988194e-02f, 5.54297566e-02f, 5.67882173e-02f, 2.51455251e-02f, 3.50370817e-02f, -1.25496715e-01f, -1.77076217e-02f, 1.56590762e-03f,
  -4.32121642e-02f, 1.32642135e-01f, 1.22644544e-01f, -3.13744098e-02f, 6.20801002e-02f, 2.45482661e-02f, -4.06686813e-02f, 4.30613458e-02f, 4.85545583e-03f, -1.06009550e-01f,
  1.34182423e-01f, 1.39792999e-02f, -6.97639436e-02f, -1.35809422e-01f, -6.30372018e-02f, 1.18243024e-02f, 4.95345406e-02f, 6.53665215e-02f, -1.20397843e-01f, 3.83066759e-02f,
  1.12072369e-02f, 1.49567828e-01f, -7.19695911e-02f, -1.79457720e-02f, 4.61192615e-03f, 2.42853668e-02f, 4.98543382e-02f, 3.60791981e-02f, 1.51963020e-02f, -1.83799043e-02f,
  4.81092334e-02f, 5.43540996e-03f, 2.60378867e-02f, 1.12641305e-01f, -3.82973477e-02f, 5.72363399e-02f, 6.25537708e-02f, 2.97934767e-02f, 5.42431362e-02f, 3.42855160e-03f,
  9.60563347e-02f, -1.17927253e-01f, 6.15456030e-02f, -8.44618529e-02f, 1.55294361e-02f, -4.65877391e-02f, -1.10892594e-01f, 1.31778151e-01f, 1.49962887e-01f, 2.84612793e-02f,
  -1.56928614e-01f, 2.36022890e-01f, 1.63739957e-02f, -2.21662730e-01f, 2.78134137e-01f, -2.29187831e-01f, -1.24458276e-01f, 3.49255532e-01f, 2.11967722e-01f, 8.85026380e-02f,
  -1.83325186e-01f, -3.11349273e-01f, -6.98498264e-02f, -2.91287750e-01f, -3.68024975e-01f, -3.30592215e-01f, -3.95805776e-01f, -2.74805576e-01f, -1.14012763e-01f, -3.14939111e-01f,
  -1.69154942e-01f, -1.02108225e-01f, -1.22200973e-01f, 3.22678506e-01f, 1.80454090e-01f, 3.49089026e-01f, -1.63017720e-01f, 2.74487615e-01f, -1.07956320e-01f, 7.59843364e-02f,
  -1.61789611e-01f, 8.44085589e-02f, 2.68932760e-01f, 1.06136210e-01f, -4.56577875e-02f, -2.09493320e-02f, -1.20504327e-01f, 4.27586213e-02f, 2.60986276e-02f, 6.29027337e-02f,
  -8.77138972e-02f, 8.05951431e-02f, -9.96919721e-02f, 1.21580295e-01f, 2.72958308e-01f, 1.87883470e-02f, -1.29153624e-01f, -5.68781141e-03f, 1.13313220e-01f, -1.57116409e-02f,
  -4.58191000e-02f, -9.57735628e-02f, -1.10041149e-01f, -2.09006473e-01f, 5.16270213e-02f, 4.03027087e-02f, 2.14445386e-02f, -5.26148304e-02f, -4.93072532e-02f, 6.98410720e-02f,
  2.50541065e-02f, -5.45413978e-02f, 7.78133841e-03f, 1.75768211e-01f, -3.66481207e-03f, 9.59776863e-02f, -4.75920439e-02f, -1.29813552e-01f, -2.58653872e-02f, 3.86913344e-02f,
  -2.12539434e-02f, 8.02721679e-02f, 1.42200470e-01f, -7.39398748e-02f, -1.30809799e-01f, 3.04382630e-02f, -9.27633792e-02f, -1.43616870e-01f, -2.15968005e-02f, 1.70535576e-02f,
  1.17758952e-01f, -8.45505744e-02f, -1.50708091e-02f, -2.94549856e-02f, 9.41392779e-02f, -1.01989147e-03f, -4.69546439e-03f, 7.87937120e-02f, -3.27101611e-02f, -7.47213978e-03f,
  -2.36593306e-01f, -2.10949093e-01f, 1.37128353e-01f, 8.47227350e-02f, -3.06381378e-02f, -1.18619449e-01f, -1.78272411e-01f, 1.24802440e-01f, -9.58102345e-02f, 5.77648133e-02f,
  1.80489756e-02f, -2.85565984e-02f, -6.50756899e-03f, -6.06902875e-02f, -4.86459620e-02f, -3.75141837e-02f, -8.78496543e-02f, -1.56248352e-02f, -6.11283705e-02f, -3.54967937e-02f,
  5.18859066e-02f, -8.49402696e-02f, -2.66432972e-03f, 1.89102426e-01f, -5.99134415e-02f, -2.50207651e-02f, -1.06246755e-01f, 1.37965515e-01f, -5.37508018e-02f, -5.91757745e-02f,
  -4.58556235e-01f, 3.38015527e-01f, 2.02501222e-01f, -1.14516474e-01f, -1.08502902e-01f, 5.04622400e-01f, 3.03398967e-01f, -2.69671194e-02f, 3.02641928e-01f, 7.48517662e-02f,
  -2.70306110e-01f, -1.62038252e-01f, 1.16030723e-01f, 7.40817711e-02f, 1.82610378e-01f, 3.86321127e-01f, 2.62308210e-01f, 7.54162520e-02f, 7.46005625e-02f, -1.14120327e-01f,
  1.98602565e-02f, -1.08714961e-01f, 7.47803226e-03f, -1.05683520e-01f, -2.32721925e-01f, -1.82335094e-01f, -2.84649193e-01f, 2.43536886e-02f, -1.32653669e-01f, -2.18280740e-02f,
  9.69241634e-02f, -1.68016329e-01f, -9.21985060e-02f, 2.33169217e-02f, 1.55258188e-02f, -3.88221405e-02f, -9.40079838e-02f, 2.99495310e-02f, -7.85938948e-02f, 5.56695499e-02f,
  -5.98748326e-02f, 8.78143385e-02f, -2.32906230e-02f, -6.42859042e-02f, -4.65570875e-02f, -3.34733166e-02f, 7.78712630e-02f, -1.36508867e-01f, -7.33535886e-02f, 5.54906279e-02f,
  5.87442308e-04f, 1.63140237e-01f, 1.75925270e-02f, 1.01041391e-01f, 1.52086569e-02f, 1.23908028e-01f, 1.86374515e-01f, 2.28492115e-02f, 4.80922423e-02f, 1.04040951e-02f,
  -2.47699302e-02f, 1.81691870e-01f, -5.90342190e-03f, -8.32985155e-03f, -1.35575226e-02f, -9.76197869e-02f, -4.60614227e-02f, -1.07699439e-01f, 7.07140267e-02f, 8.66618846e-03f,
  -5.47615811e-03f, 1.23162484e-02f, -1.10450024e-02f, 1.28318101e-01f, -3.68180685e-02f, -8.47608224e-02f, -4.17216085e-02f, 6.56461576e-03f, -1.50995534e-02f, -3.26601032e-04f,
  -1.26689434e-01f, 5.47988303e-02f, 5.53901196e-02f, 1.99082531e-02f, 1.53583987e-02f, 6.94672987e-02f, 5.00826612e-02f, 3.11498046e-02f, -1.58911720e-02f, -2.71953028e-02f,
  2.25415751e-01f, 2.32422084e-01f, 3.27935703e-02f, -4.93192971e-02f, 1.74899567e-02f, -4.55491208e-02f, 1.73264131e-01f, 3.64459194e-02f, 8.10203403e-02f, -9.99857113e-03f,
  -8.95123854e-02f, 8.86178091e-02f, 5.30659184e-02f, -1.07299350e-01f, 2.24197190e-02f, 4.10044938e-02f, 1.08806327e-01f, -6.09567761e-02f, -2.40627583e-02f, -1.07109703e-01f,
  6.12254664e-02f, 4.74999659e-02f, 7.82587528e-02f, 8.20343867e-02f, -2.11124942e-02f, -8.30688514e-03f, -5.57196550e-02f, 2.75331121e-02f, 4.09619696e-02f, 1.32547408e-01f,
  -4.42135066e-01f, 3.33164424e-01f, 1.89455137e-01f, -4.35683191e-01f, 2.43160844e-01f, -8.12612399e-02f, -4.22768444e-01f, -1.96049791e-02f, -2.14015722e-01f, -1.86937690e-01f,
  -2.08609849e-01f, 1.74078181e-01f, 2.59000927e-01f, -2.61138022e-01f, -1.86217800e-01f, 2.00664714e-01f, -3.28103483e-01f, -2.87328690e-01f, 1.41430959e-01f, -2.39887461e-01f,
  -7.76559114e-02f, -1.97268814e-01f, -8.62432420e-02f, 1.55582651e-01f, -1.19798936e-01f, -1.53846815e-01f, -1.51262164e-01f, 2.14836538e-01f, -2.51731843e-01f, 3.07554156e-02f,
  -1.73874468e-01f, -1.15413256e-01f, -3.00398588e-01f, -7.98095390e-02f, -1.43413454e-01f, -9.30729508e-02f, -1.50996611e-01f, -4.00170404e-03f, -1.71740443e-01f, -5.84995635e-02f,
  2.27446221e-02f, 5.88051602e-02f, -7.72939548e-02f, 4.11187811e-03f, -9.33222920e-02f, 5.55878915e-02f, 6.15838952e-02f, 4.96587865e-02f, 1.27022803e-01f, 9.64787006e-02f,
  6.67654946e-02f, 5.44341616e-02f, -1.81797743e-02f, -5.06877638e-02f, -3.66656072e-02f, -9.54598859e-02f, 3.77597809e-02f, 1.10346682e-01f, -2.71676108e-02f, 3.26455086e-02f,
  3.32924090e-02f, -8.72508213e-02f, 1.96500383e-02f, 5.14279061e-04f, -3.49000767e-02f, -1.26620186e-02f, 4.95340042e-02f, -3.55690457e-02f, -7.22364709e-03f, 1.93577930e-02f,
  4.40714136e-02f, 6.57507032e-03f, 9.14485287e-03f, -9.24237221e-02f, -2.29520039e-04f, -5.59985898e-02f, -5.39044812e-02f, -3.70644927e-02f, 6.85629398e-02f, 2.73148976e-02f,
  2.00048704e-02f, -1.01745151e-01f, 1.31493449e-01f, 5.12369052e-02f, -2.92924512e-02f, -1.59703102e-02f, 5.41609339e-02f, 9.59615260e-02f, -3.96787785e-02f, 8.68605264e-03f,
  -3.97306442e-01f, -2.03927532e-01f, -2.11328983e-01f, -9.76142287e-02f, -1.02553643e-01f, 9.51469410e-03f, -1.08507976e-01f, 6.94345171e-03f, -1.49263531e-01f, -5.71244769e-02f,
  -4.08426002e-02f, -1.06509320e-01f, -1.45122170e-01f, -8.97282511e-02f, -3.54098417e-02f, -8.97177383e-02f, -6.89241439e-02f, -1.59063742e-01f, -1.79677606e-01f, -5.81161380e-02f,
  -9.66380015e-02f, -3.58176008e-02f, 7.21836463e-02f, 4.79946323e-02f, 1.27598317e-02f, -1.48079902e-01f, -7.77507648e-02f, 1.46145448e-01f, 2.66421568e-02f, -1.37810549e-02f,
  -4.24795866e-01f, 3.31027001e-01f, -3.13009368e-03f, -3.28316092e-01f, 1.58254787e-01f, 6.18215561e-01f, 4.76235807e-01f, 3.12436432e-01f, 8.18092749e-02f, 3.18062335e-01f,
  3.38871896e-01f, 1.31797299e-01f, 3.52294683e-01f, 2.19982684e-01f, 2.26562873e-01f, 3.05110186e-01f, 2.47784272e-01f, -2.93853022e-02f, 1.64212227e-01f, -5.97575419e-02f,
  -1.01223804e-01f, 2.12706476e-01f, 3.42823155e-02f, 7.62412697e-02f, -1.44556863e-03f, -2.76187271e-01f, -2.19114602e-01f, 4.80569415e-02f, -8.32116604e-02f, 2.49307647e-01f,
  1.10788248e-01f, -2.79637843e-01f, 5.48235886e-02f, 4.55907211e-02f, -2.98206601e-02f, -1.32232413e-01f, -7.46655986e-02f, -6.92114383e-02f, -8.38793889e-02f, 8.90787095e-02f,
  1.06264846e-02f, -4.51119654e-02f, 9.50434953e-02f, -1.83502622e-02f, 7.80288652e-02f, 5.84549792e-02f, 1.24974370e-01f, 1.68861635e-02f, 5.53390086e-02f, -7.30065629e-03f,
  1.20550543e-01f, -2.74317134e-02f, -3.61842588e-02f, -1.02462195e-01f, 1.28789738e-01f, 7.47157186e-02f, 4.94247722e-03f, -6.89509660e-02f, 1.40581086e-01f, -8.59628152e-03f,
  1.03213981e-01f, -1.57295361e-01f, 2.14203652e-02f, -4.90549579e-02f, 5.87280169e-02f, -1.02238320e-01f, 1.93448237e-03f, -5.30266501e-02f, 3.95803563e-02f, 8.72018188e-02f,
  -7.41937160e-02f, -2.29849350e-02f, -1.04510434e-01f, 6.65537361e-03f, -6.89389184e-02f, -5.52463084e-02f, -5.28453514e-02f, 3.26217636e-02f, -7.96088651e-02f, 1.19914254e-02f,
  -5.03136367e-02f, 3.42353131e-03f, 1.06801085e-01f, -9.97778773e-02f, 1.03192829e-01f, 1.29789725e-01f, 2.01199818e-02f, 8.93251598e-03f, -1.88697129e-02f, -1.20071368e-02f,
  1.45751268e-01f, -6.97383136e-02f, 6.34083012e-03f, 1.29669294e-01f, -2.32759099e-02f, 1.03410609e-01f, 4.45525022e-03f, 9.27270204e-02f, 1.05225585e-01f, 2.14289278e-02f,
  1.91958416e-02f, -1.20609269e-01f, -8.10901672e-02f, 8.46354440e-02f, -7.84355924e-02f, 2.54379183e-01f, -9.31071043e-02f, 2.84042452e-02f, 7.99146071e-02f, 1.45735115e-01f,
  -2.59359293e-02f, -4.88994084e-02f, -9.68808979e-02f, 6.92100003e-02f, -3.61805707e-02f, 7.55851939e-02f, -1.38850138e-01f, -7.50162229e-02f, 7.03130588e-02f, 4.94193519e-03f,
  -1.64893240e-01f, 1.65247038e-01f, 2.40858287e-01f, 1.76296234e-01f, -1.13754876e-01f, -2.96146721e-01f, -3.37971419e-01f, 3.02077353e-01f, 2.40535345e-02f, -8.80205929e-02f,
  -2.01392248e-01f, -1.81445945e-02f, -5.18889949e-02f, -1.13267712e-01f, -2.20118582e-01f, -3.99715453e-01f, 4.39557023e-02f, -2.73140788e-01f, -1.13108829e-01f, 1.62026614e-01f,
  1.32903174e-01f, 1.15074225e-01f, 3.64482373e-01f, 3.27005297e-01f, 1.55224234e-01f, 2.70755053e-01f, 3.16930175e-01f, 1.33923233e-01f, 2.41397411e-01f, -7.26289526e-02f,
  -6.67590201e-02f, 2.78656408e-02f, 2.46914979e-02f, -5.30532226e-02f, 1.74718335e-01f, 6.81815073e-02f, 1.11979023e-01f, -1.22029155e-01f, -3.30934338e-02f, 1.70840714e-02f,
  -1.81521960e-02f, 1.04785562e-01f, 7.29007721e-02f, -7.06203431e-02f, 4.36194278e-02f, 3.57879959e-02f, -2.70459335e-02f, -4.82564094e-03f, 4.80622128e-02f, -1.74497217e-02f,
  1.42770987e-02f, 4.27250825e-02f, 6.59017563e-02f, 7.76253045e-02f, 9.48987156e-02f, 7.72591308e-02f, 3.36329900e-02f, 7.99878463e-02f, 2.75113177e-03f, -1.56489741e-02f,
  1.27707049e-01f, -3.91510613e-02f, -6.79246709e-02f, -3.76490573e-03f, -1.27632335e-01f, -2.48478036e-02f, -9.30894613e-02f, -2.92000063e-02f, -1.16057470e-01f, -4.44141887e-02f,
  6.57427460e-02f, 1.17117628e-01f, -8.38645026e-02f, 1.11228088e-02f, -3.84191349e-02f, 4.47569834e-03f, -1.90226492e-02f, -1.31620318e-01f, -1.58598181e-02f, 4.92665172e-02f,
  -3.82359996e-02f, -8.72392282e-02f, -9.43893939e-02f, -5.62611967e-02f, -1.21138647e-01f, 6.41198978e-02f, 5.42991888e-03f, -1.02423906e-01f, 3.13815735e-02f, 6.87744245e-02f,
  7.01670423e-02f, 1.72117397e-01f, 1.63701609e-01f, -1.17137320e-01f, -5.43756261e-02f, -9.58136544e-02f, 6.20872937e-02f, 8.12630281e-02f, 2.92869797e-03f, -1.17042303e-01f,
  1.31712079e-01f, -1.28797590e-04f, 2.87338588e-02f, -5.40237501e-02f, -1.29494192e-02f, 1.11331351e-01f, -6.28927350e-02f, 6.00687526e-02f, 2.33398378e-01f, 1.92050263e-01f,
  1.37649119e-01f, -6.65115565e-02f, 1.39448851e-01f, 2.14700610e-03f, 1.03220433e-01f, -2.46103350e-02f, -5.18137291e-02f, 9.14641395e-02f, 1.01582944e-01f, -1.93897337e-02f,
  -2.10691646e-01f, -2.86674201e-01f, -3.67094845e-01f, -3.55869353e-01f, 1.40340298e-01f, -6.59281909e-02f, -2.36044526e-01f, -1.12018220e-01f, -2.14496270e-01f, 1.79217767e-03f,
  1.22113332e-01f, -3.28595072e-01f, -7.50302076e-02f, -4.05834079e-01f, -3.04525405e-01f, -3.09346795e-01f, -3.39789361e-01f, -2.21161023e-01f, -2.60712117e-01f, -1.76583067e-01f,
  -1.90843821e-01f, -1.69651553e-01f, -2.77348965e-01f, 1.20281659e-01f, -2.12454990e-01f, 1.77948758e-01f, 2.22839281e-01f, 2.58257389e-01f, 9.21444315e-03f, 9.01697800e-02f,
  -1.96547702e-01f, -1.87186778e-01f, -5.63164763e-02f, -5.69235608e-02f, 8.39309096e-02f, 1.31624892e-01f, 1.05027640e-02f, -1.00945786e-01f, 5.34861647e-02f, -1.75376132e-01f,
  1.39924794e-01f, 7.68436044e-02f, -1.57690078e-01f, 5.37331961e-02f, -2.94293817e-02f, 1.37212528e-02f, -1.27872918e-03f, 5.61800785e-02f, -5.29903248e-02f, -1.92281008e-01f,
  -1.03854790e-01f, 3.88071798e-02f, 3.90405543e-02f, 3.02300286e-02f, 1.64448936e-02f, -7.24916086e-02f, -7.97865316e-02f, 6.80275485e-02f, -2.88730171e-02f, -3.68074165e-03f,
  -3.91461048e-03f, 6.05116710e-02f, -4.59207371e-02f, -8.75726342e-02f, -3.80991511e-02f, 9.14837420e-02f, -2.33260682e-03f, -4.83520608e-03f, 2.14533764e-03f, 5.30426092e-02f,
  2.69156173e-02f, -6.34863377e-02f, 4.56815138e-02f, 7.35274097e-03f, -8.53715539e-02f, -8.25255886e-02f, 2.97157131e-02f, -2.88349874e-02f, -2.54233554e-02f, -3.40773463e-02f,
  -2.91952733e-02f, -4.87302197e-03f, -2.60267332e-02f, 6.23904914e-02f, -8.34979583e-03f, 1.81568135e-02f, 1.16190076e-01f, -8.83661062e-02f, -1.75488740e-02f, 6.86920136e-02f,
  1.71366259e-02f, 4.87886705e-02f, -9.38480273e-02f, 8.40679184e-02f, 1.43044628e-02f, 1.43333659e-01f, -7.02706352e-02f, -1.07881226e-01f, -1.01060187e-03f, -1.07331075e-01f,
  -3.60001810e-02f, 1.43628150e-01f, 2.16366127e-01f, 2.27666572e-02f, -2.78993063e-02f, 5.11392988e-02f, 1.16378963e-02f, 2.30080232e-01f, 6.28159419e-02f, 9.10280496e-02f,
  1.11798368e-01f, 3.27135138e-02f, 3.90501432e-02f, -4.51982394e-03f, 6.58937991e-02f, 1.95086852e-01f, 2.57597733e-02f, -6.29076585e-02f, 1.15324393e-01f, 4.16336283e-02f,
  4.57319647e-01f, 1.34544775e-01f, 2.67788082e-01f, 4.77405846e-01f, -3.88249829e-02f, -3.31955820e-01f, -2.82091111e-01f, 5.66742709e-03f, 3.77737373e-01f, -1.33232206e-01f,
  -1.49809211e-01f, 2.94973195e-01f, -4.37010258e-01f, 2.47259378e-01f, -2.72381365e-01f, -1.79340243e-01f, 1.16342932e-01f, 2.05770776e-01f, 1.98165387e-01f, 1.02513023e-01f,
  2.24453241e-01f, -3.88488412e-01f, -6.86185583e-02f, -4.15329963e-01f, 1.10137671e-01f, 3.17943722e-01f, -2.98762858e-01f, -1.14623256e-01f, 1.15944654e-01f, -2.17494130e-01f,
  8.33394229e-02f, 1.39571339e-01f, 1.67187899e-01f, 3.30380723e-03f, 8.90574455e-02f, -2.66210362e-02f, 1.20894507e-01f, -1.46721050e-01f, 3.92912403e-02f, 2.07993407e-02f,
  6.88468218e-02f, 3.38641629e-02f, 3.05571649e-02f, -2.16730594e-04f, 9.95677039e-02f, 7.33011290e-02f, 2.32496247e-01f, 1.55660346e-01f, -3.41988355e-02f, 8.21644738e-02f,
  1.55046195e-01f, 1.50781140e-01f, 1.63944792e-02f, 2.42936220e-02f, 1.50482431e-01f, 1.13579214e-01f, -9.52712912e-03f, 6.87451363e-02f, 9.96393487e-02f, 6.85584769e-02f,
  -1.73363045e-01f, -4.07124013e-02f, 4.01474088e-02f, 6.32697716e-02f, -5.95649667e-02f, -1.43676214e-02f, -2.86898818e-02f, 2.63641682e-02f, 8.60319138e-02f, -3.07766944e-02f,
  5.20245060e-02f, 7.12026730e-02f, 2.18362734e-02f, 4.15765308e-02f, 4.29048343e-03f, 1.84506565e-01f, -5.36780581e-02f, 7.84204751e-02f, 8.39385316e-02f, 8.53247419e-02f,
  -1.18635468e-01f, -7.53191933e-02f, -1.24269044e-02f, -2.49007214e-02f, -1.72679156e-01f, 1.41474813e-01f, 9.19436365e-02f, 3.20186988e-02f, -8.18701647e-03f, -5.15623614e-02f,
  -1.69027597e-01f, -1.56310946e-01f, -1.01863861e-01f, -4.22433242e-02f, -7.09718317e-02f, -4.42146370e-03f, 7.59082139e-02f, 1.30492389e-01f, -4.46444564e-02f, -7.62770399e-02f,
  -1.94601603e-02f, 7.79847801e-02f, 3.47281471e-02f, 4.77151424e-02f, -1.52203783e-01f, -4.20779735e-02f, -7.49030989e-03f, -7.51222968e-02f, -2.82163043e-02f, 1.50303751e-01f,
  -4.99580018e-02f, -3.64243309e-03f, 2.59183589e-02f, 6.37729838e-02f, -2.98342910e-02f, -3.23309302e-02f, -3.22817378e-02f, 2.38684304e-02f, 3.44029330e-02f, 8.95869061e-02f,
  1.28162101e-01f, -6.14745021e-01f, 2.37193465e-01f, 1.61207706e-01f, 1.71637192e-01f, 1.57460794e-01f, 3.62340599e-01f, -3.51444840e-01f, -2.40279749e-01f, -5.39992511e-01f,
  1.06687576e-01f, 2.24047184e-01f, 4.66433801e-02f, -2.96695530e-02f, 2.86023557e-01f, -7.93930814e-02f, -1.11833930e-01f, 2.39062309e-02f, -9.91844106e-03f, -5.30189089e-02f,
  -4.83117700e-02f, -3.12600732e-02f, 1.33922324e-01f, -3.46072286e-01f, 1.66071028e-01f, -7.54560828e-02f, -9.24953967e-02f, 1.52361467e-01f, -4.02478166e-02f, 1.65010557e-01f,
  -1.35943666e-01f, -7.29410127e-02f, 1.03513420e-01f, -1.57667756e-01f, -5.10043278e-02f, 6.82061389e-02f, 1.30560368e-01f, 1.84628949e-01f, 5.65565191e-02f, -1.33777196e-02f,
  1.12967126e-01f, -9.95628387e-02f, -8.58836770e-02f, 5.01178503e-02f, 1.94925908e-02f, -2.16808785e-02f, -5.64778820e-02f, 2.00206693e-02f, 6.04360774e-02f, 8.02404433e-02f,
  7.25376830e-02f, -9.56109539e-03f, 1.25852153e-02f, 8.87575001e-03f, 1.22303508e-01f, 4.34892206e-03f, 5.28220311e-02f, 1.94869518e-01f, -7.14525804e-02f, -1.83803350e-01f,
  1.86841283e-02f, 4.38829027e-02f, -3.07003409e-02f, -4.93485704e-02f, 5.32932542e-02f, -2.94411685e-02f, -4.06713039e-02f, 2.79118139e-02f, -1.54068442e-02f, -9.68447477e-02f,
  -5.32160364e-02f, -7.14321621e-04f, -2.35673096e-02f, -4.61586677e-02f, 4.66485433e-02f, -5.97185381e-02f, 7.76527748e-02f, -1.93819329e-02f, 3.13483120e-04f, 6.36874279e-03f,
  -2.11330131e-02f, -1.26513932e-02f, -1.87843200e-02f, 5.89142479e-02f, -3.81075405e-02f, -3.38563286e-02f, -6.47531003e-02f, -6.26111776e-02f, 1.81342592e-03f, 1.22784570e-01f,
  -5.44361413e-01f, -4.37356263e-01f, -4.75691184e-02f, -9.45407078e-02f, -8.53742510e-02f, -3.59900855e-02f, 1.58719569e-02f, -1.47682831e-01f, -1.25699537e-02f, -1.51897054e-02f,
  -1.75830930e-01f, 2.41035186e-02f, -5.95560446e-02f, 4.53131311e-02f, 2.23138351e-02f, -1.23699876e-02f, 1.97395738e-02f, -3.73861007e-02f, -5.89189082e-02f, -1.28846928e-01f,
  -5.31267188e-02f, 5.76598309e-02f, 3.85952964e-02f, -5.50413802e-02f, 7.09558576e-02f, -1.94481872e-02f, -6.27342761e-02f, -8.27855691e-02f, 6.12383075e-02f, -3.61367688e-02f,
  1.78120136e-01f, 4.52677310e-01f, 1.32977098e-01f, 2.95898765e-01f, -1.69457227e-01f, -3.98518413e-01f, -1.43798962e-01f, 4.51609455e-02f, 2.21658945e-01f, 3.46759558e-01f,
  -2.74288863e-01f, 5.42242825e-01f, -1.48001742e-02f, -1.88185200e-01f, -4.28492993e-01f, -3.88633281e-01f, 4.13827151e-02f, -1.82923317e-01f, 2.57602986e-02f, 4.06015277e-01f,
  5.63839190e-02f, -4.00945991e-02f, 3.18243131e-02f, 5.30201569e-02f, 1.64656088e-01f, 2.12785214e-01f, 1.97191313e-01f, -8.90775844e-02f, -3.60047929e-02f, -2.46397600e-01f,
  -1.48458304e-02f, 1.48632362e-01f, 1.01870403e-01f, 6.03888370e-02f, 1.22620679e-01f, -9.70104262e-02f, -3.49248983e-02f, -6.94413483e-02f, -1.41305625e-01f, 6.32568747e-02f,
  2.08879486e-01f, 3.53409722e-02f, 1.59422562e-01f, 5.51711069e-03f, -2.83895470e-02f, -3.94274332e-02f, 2.23338827e-02f, -1.35400847e-01f, 5.01450012e-03f, -3.46815921e-02f,
  1.63491428e-01f, -1.00868501e-01f, 8.05898979e-02f, 9.86003950e-02f, -3.89289707e-02f, 7.39079490e-02f, 5.35772368e-03f, 6.97151273e-02f, 1.99027255e-01f, 7.87114948e-02f,
  4.48779091e-02f, -1.08329818e-01f, -1.92323178e-02f, 4.35805432e-02f, -1.42665416e-01f, -5.00911400e-02f, 1.90624684e-01f, 6.35779789e-03f, 1.67346686e-01f, 7.18839839e-02f,
  -8.53063166e-02f, 7.17696780e-03f, -1.49004728e-01f, 1.80581380e-02f, 1.36919441e-02f, 1.70387313e-01f, 4.96148057e-02f, 5.42150550e-02f, 8.84864032e-02f, 1.09634101e-02f,
  1.61268376e-03f, -1.05442263e-01f, 1.12514906e-01f, -1.70112520e-01f, -7.48586357e-02f, 1.47400260e-01f, -1.97307430e-02f, 1.16794176e-01f, -7.76043609e-02f, -3.26515771e-02f,
  1.25102047e-02f, 2.79515356e-01f, 7.20579773e-02f, 2.88382098e-02f, 9.53880847e-02f, -8.78923293e-03f, -1.15217485e-01f, 2.99258828e-02f, -4.74418737e-02f, 1.02765821e-01f,
  1.76531330e-01f, 5.70188388e-02f, 6.49605086e-03f, -1.37309372e-01f, 3.42348330e-02f, 8.52405876e-02f, 1.28830910e-01f, 2.71461289e-02f, 1.24341145e-01f, -8.92743394e-02f,
  1.42312407e-01f, 5.60444333e-02f, 2.10386842e-01f, 1.99412424e-02f, 1.26533777e-01f, 5.39084636e-02f, -1.88575611e-02f, -7.73085803e-02f, 1.32855564e-01f, 3.11703552e-02f,
  -8.06896687e-01f, 6.67176545e-02f, 4.15671021e-01f, -4.29470837e-01f, 1.44036725e-01f, 3.67792845e-01f, 5.54930083e-02f, 1.01024844e-01f, -1.62295356e-01f, 1.25196829e-01f,
  1.71699911e-01f, -1.77644089e-01f, 2.80771643e-01f, 1.42598581e-02f, 1.38985738e-01f, 2.32883632e-01f, -6.11445792e-02f, -1.34150833e-01f, 9.82388295e-03f, -2.39031345e-01f,
  -8.40208083e-02f, -1.71486542e-01f, 3.02833110e-01f, 1.02514721e-01f, -6.92519769e-02f, -2.53668517e-01f, -1.76863462e-01f, 1.43146202e-01f, -3.15716714e-02f, 1.07194975e-01f,
  -3.71592462e-01f, -1.92228898e-01f, -1.52834728e-01f, -8.19990132e-03f, -6.65832758e-02f, -5.38479313e-02f, -8.48444998e-02f, -1.66551191e-02f, -3.80336381e-02f, -2.19448954e-02f,
  -3.08660865e-02f, 6.62612393e-02f, -1.14824802e-01f, 7.47156003e-03f, 2.90320665e-02f, -2.81226542e-02f, 1.99486360e-01f, 8.24200884e-02f, 1.39342044e-02f, 1.62772998e-01f,
  1.73798472e-01f, 1.38721183e-01f, 1.68696240e-01f, -2.23001763e-02f, 1.45001307e-01f, 1.18684784e-01f, 6.82411417e-02f, 5.32928780e-02f, -3.17527428e-02f, -5.42984270e-02f,
  2.29250528e-02f, -5.79572506e-02f, -2.84071527e-02f, -7.67480731e-02f, 2.82285251e-02f, 1.50993600e-01f, -8.88142660e-02f, -7.90651217e-02f, -4.54671681e-02f, 8.31777677e-02f,
  7.66135305e-02f, 2.63134316e-02f, -6.13962300e-02f, -1.51162399e-02f, -1.35005238e-02f, 1.83586664e-02f, 2.01233942e-02f, 2.27795523e-02f, -6.01125183e-03f, 6.89370185e-02f,
  6.94476739e-02f, 1.52093187e-01f, 5.05400561e-02f, -6.42526448e-02f, -3.80352475e-02f, -8.38566199e-02f, -3.17364894e-02f, 3.30657810e-02f, 5.83920814e-03f, -4.22772393e-02f,
  -5.69206178e-01f, -3.65752548e-01f, -1.39240459e-01f, -2.86963191e-02f, -1.00693129e-01f, -5.99029511e-02f, 1.53379403e-02f, -8.67563635e-02f, -1.87678456e-01f, -3.06337588e-02f,
  -5.43022379e-02f, -1.47010572e-02f, -7.47386068e-02f, -1.15276821e-01f, -6.23226687e-02f, 1.32932246e-01f, -1.58488482e-01f, -1.57208756e-01f, -1.13428205e-01f, -1.05105311e-01f,
  2.69345623e-02f, -3.90080288e-02f, 5.89875206e-02f, -1.24996968e-01f, 3.02686524e-02f, -1.35375381e-01f, -1.58301756e-01f, 7.68710598e-02f, 4.11308091e-03f, 1.45636708e-01f,
  1.22455701e-01f, -4.44073677e-01f, -4.07798767e-01f, -1.47303388e-01f, 4.88732129e-01f, 4.29130077e-01f, 1.53325886e-01f, -6.55047894e-02f, -4.45640177e-01f, -1.70091689e-02f,
  7.16551691e-02f, -2.84891665e-01f, -2.51590818e-01f, -1.47909179e-01f, 2.34744340e-01f, -3.93988758e-01f, 8.64060670e-02f, -1.09119145e-02f, -3.13822508e-01f, 2.16938648e-03f,
  -1.53401300e-01f, 1.29396364e-01f, -3.73652637e-01f, 1.46693975e-01f, 2.89363652e-01f, 1.38436228e-01f, 3.94253701e-01f, 3.93905565e-02f, 2.09643528e-01f, 7.76807815e-02f,
  2.00785100e-02f, -2.57555962e-01f, -7.58179054e-02f, -1.06448650e-01f, 1.26299545e-01f, 5.11486009e-02f, 1.47661254e-01f, 1.13143073e-02f, -4.26637866e-02f, -5.02818450e-02f,
  1.14092626e-01f, 4.16411832e-02f, 1.48361817e-01f, -9.15248245e-02f, 9.52151343e-02f, -6.05756678e-02f, -6.84345290e-02f, -2.07778122e-02f, -2.53290474e-01f, -7.51330033e-02f,
  -1.14492722e-01f, 1.31331146e-01f, 1.72714010e-01f, -6.18767403e-02f, 1.05307414e-03f, 3.94955613e-02f, -1.14829265e-01f, 4.18669321e-02f, 1.03555791e-01f, 9.41807125e-03f,
  1.48541778e-01f, 2.31829435e-02f, 1.26933858e-01f, -1.95954740e-02f, 1.34504959e-02f, -2.38937978e-02f, 1.23590156e-01f, -8.74578953e-02f, -3.83878057e-03f, -1.30429357e-01f,
  7.07131848e-02f, 1.41423136e-01f, -1.39012337e-01f, 7.54826590e-02f, 1.09416150e-01f, -1.51072845e-01f, 5.19756563e-02f, -2.29429640e-02f, 3.99596505e-02f, 9.87166911e-02f,
  -2.92082336e-02f, 4.22596093e-03f, -4.66942638e-02f, 3.55252288e-02f, -2.86460761e-02f, -4.91212383e-02f, 2.51833480e-02f, 1.52130583e-02f, -3.72532383e-02f, 1.01068720e-01f,
  7.36881196e-02f, 1.33293733e-01f, -7.17550144e-02f, -8.74002501e-02f, -1.19741736e-02f, 2.07368806e-01f, -5.40292240e-04f, -3.02005708e-02f, -1.33537883e-02f, -1.40659194e-02f,
  2.45113403e-01f, 2.08066866e-01f, 2.93667704e-01f, -1.20221987e-01f, -3.70349176e-02f, 6.60826564e-02f, -1.46292802e-02f, 9.91695672e-02f, 3.33371274e-02f, 4.83544916e-03f,
  7.12318271e-02f, 2.26564825e-01f, 5.36382273e-02f, 1.53186455e-01f, 7.26394504e-02f, 6.05409928e-02f, 2.58213103e-01f, -4.39283550e-02f, 1.82297364e-01f, -1.35183871e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  3.94634962e-01f, 2.06108913e-01f, 3.79739642e-01f, 1.70379207e-01f, 3.60546559e-01f, 3.64111602e-01f, 3.35010946e-01f, 4.07424271e-01f, 4.10459280e-01f, 3.16372365e-01f,
  4.35241044e-01f, 4.11108971e-01f, 3.47355455e-01f, 1.24879360e-01f, 3.02425027e-01f, 2.82770187e-01f, 2.96750039e-01f, 3.02479863e-01f, 3.57824326e-01f, 3.19153368e-01f,
  3.90442997e-01f, 3.52291435e-01f, 1.43875390e-01f, 4.84785318e-01f, 2.32538208e-01f, 2.60522455e-01f, 3.38047653e-01f, 3.32787514e-01f, 2.54935771e-01f, 3.46708089e-01f,
  3.68735820e-01f, 4.69893277e-01f, 4.59496707e-01f, 3.53948474e-01f, 2.88244337e-01f, 3.43203276e-01f, 2.42091373e-01f, 3.52885187e-01f, 3.65025997e-01f, 3.77336591e-01f,
  4.79058564e-01f, 5.25559783e-01f, 2.00495109e-01f, 3.34099501e-01f, 3.69227082e-01f, 3.84889275e-01f, 2.85547435e-01f, 2.87965000e-01f, 4.11864102e-01f, 4.48057294e-01f,
  4.17215586e-01f, 3.80154401e-01f, 2.99242079e-01f, 4.18265790e-01f, 4.89267409e-01f, 3.45400363e-01f, 3.56564015e-01f, 4.18057323e-01f, 3.18117678e-01f, 3.67699504e-01f,
  4.35005814e-01f, 2.74064720e-01f, 2.77359009e-01f, 2.12635741e-01f, 3.60459507e-01f, 3.90096933e-01f, 2.23674312e-01f, 3.50263476e-01f, 3.89338672e-01f, 3.45132887e-01f,
  4.85789895e-01f, 3.74310702e-01f, 2.88637459e-01f, 4.22933728e-01f, 2.45005384e-01f, 4.42710131e-01f, 2.67491788e-01f, 4.53156233e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.79700696e-01f, -2.99034476e-01f, -5.32251643e-03f, -1.76371828e-01f, -1.88225973e-02f, -4.17349249e-01f, -7.83899054e-02f, 9.84881520e-02f, -2.64339864e-01f, -1.51957065e-01f,
  5.26371971e-02f, -4.99492977e-03f, -7.81893358e-02f, -3.39361019e-02f, -1.16878757e-02f, -5.70439324e-02f, -1.52656332e-01f, 6.60979301e-02f, -9.80653092e-02f, 6.62040338e-02f,
  -2.59011865e-01f, 1.19425645e-02f, -1.09842591e-01f, -3.53419006e-01f, 1.17709801e-01f, 1.60466731e-01f, -2.85767347e-01f, 7.81127289e-02f, 1.91769093e-01f, -3.50984514e-01f,
  2.51439840e-01f, 1.67825967e-01f, -5.34710549e-02f, 2.40506455e-01f, -2.91924387e-01f, -5.93133792e-02f, -5.38035780e-02f, 2.24604040e-01f, 4.58887927e-02f, 1.08086325e-01f,
  3.53260338e-01f, 3.86780590e-01f, 1.64421722e-01f, 1.51421577e-02f, -2.47957721e-01f, -5.48482761e-02f, 2.35904485e-01f, 3.45186353e-01f, -1.95189416e-01f, 1.59870327e-01f,
  -9.81613025e-02f, 4.93387789e-01f, -2.25347176e-01f, -3.18967342e-01f, -1.14262320e-01f, -3.18956435e-01f, 5.37982225e-01f, -2.82961160e-01f, -8.95923153e-02f, 1.24161571e-01f,
  -1.11067042e-01f, 3.54662657e-01f, -2.48714283e-01f, 1.10109575e-01f, -4.45348531e-01f, -8.49824250e-02f, -3.97020280e-02f, 2.47666761e-01f, -3.33101898e-01f, 1.37351796e-01f,
  3.93308938e-01f, -1.94466770e-01f, 1.98016673e-01f, 3.05590779e-01f, -1.21686663e-02f, -3.17114711e-01f, 1.92454174e-01f, -7.76234716e-02f, 6.72060698e-02f, -3.04227054e-01f,
  -3.00433606e-01f, 2.02573180e-01f, 9.11585465e-02f, -4.39709425e-01f, 4.60816264e-01f, 5.06536067e-02f, 3.59191418e-01f, -3.54211479e-01f, 2.11925939e-01f, -3.24222863e-01f,
  1.79596290e-01f, -1.11687042e-01f, -2.00457036e-01f, 3.58047098e-01f, -2.18623444e-01f, -1.82446107e-01f, -1.58009782e-01f, 9.11285505e-02f, -4.06161815e-01f, -3.36811453e-01f,
  -3.01992029e-01f, -2.36584499e-01f, -1.75158754e-01f, -7.98685700e-02f, -2.40591988e-01f, -2.33944654e-01f, 3.61355662e-01f, -3.16701174e-01f, -3.18573207e-01f, 1.51566923e-01f,
  -2.27806240e-01f, 8.97373632e-02f, 2.20530123e-01f, 2.51216069e-03f, -2.42964312e-01f, -3.16896617e-01f, 1.50525291e-02f, -3.28105658e-01f, 1.86943352e-01f, -3.56184006e-01f,
  1.05407149e-01f, -1.29870430e-01f, -3.20127457e-01f, -2.48256952e-01f, -2.81729493e-02f, -1.63274378e-01f, 2.23688498e-01f, -3.85579497e-01f, -4.81814593e-02f, 1.86410055e-01f,
  -2.55881220e-01f, 1.56981826e-01f, -2.14924306e-01f, -2.39792883e-01f, -4.41305228e-02f, 4.52640131e-02f, -1.05069533e-01f, -1.04480393e-01f, -4.97312658e-02f, 2.96945274e-02f,
  -1.30482808e-01f, -9.54928435e-03f, -3.16666402e-02f, 3.68250571e-02f, -6.46220148e-03f, -3.09653729e-02f, 9.85901579e-02f, 2.86311768e-02f, -1.48863032e-01f, 1.64183509e-02f,
  1.98078185e-01f, 3.79389785e-02f, 2.11889651e-02f, 2.36280113e-01f, 9.32455510e-02f, 1.90997884e-01f, 3.70023072e-01f, 3.29041153e-01f, 4.54022512e-02f, -5.39878309e-02f,
  1.78678170e-01f, 2.39716157e-01f, -1.26875982e-01f, -9.97640309e-04f, 6.27937989e-05f, 2.46376365e-01f, -2.25181803e-01f, 1.57991812e-01f, -1.09080516e-01f, -3.41768920e-01f,
  -2.56601214e-01f, -3.00162524e-01f, -3.11788857e-01f, -1.58582792e-01f, -3.19125980e-01f, -3.91941480e-02f, -1.01568669e-01f, 2.50396639e-01f, 4.78438675e-01f, -1.08080067e-01f,
  -4.60154384e-01f, -1.47743925e-01f, -2.31138647e-01f, -2.34907195e-01f, -2.55811512e-01f, -1.55728862e-01f, -4.76411700e-01f, 3.54260921e-01f, -2.41771802e-01f, 3.83310020e-02f,
  2.02934518e-01f, -3.26083243e-01f, -1.94741890e-01f, 2.55290270e-01f, 6.89138174e-02f, 2.23120540e-01f, -1.71978220e-01f, 2.70562172e-01f, -2.23508701e-01f, 1.14623047e-01f,
  -5.43821417e-02f, 3.68662402e-02f, -1.52897581e-01f, -3.30825120e-01f, 3.65603238e-01f, -3.32469434e-01f, -2.74318546e-01f, 2.58265257e-01f, -1.99381590e-01f, 4.55297679e-01f,
  -3.23777318e-01f, -2.47575432e-01f, -4.95277703e-01f, 2.53306985e-01f, 2.53393739e-01f, -4.79817659e-01f, -4.74863201e-01f, 1.53083459e-01f, 1.22376293e-01f, -5.29244661e-01f,
  -3.25552136e-01f, -1.12394921e-01f, 3.19170743e-01f, -2.48056233e-01f, -9.69408602e-02f, -2.82874644e-01f, 3.57356369e-01f, -2.74329901e-01f, -1.13890082e-01f, 1.19213060e-01f,
  1.07398145e-01f, 1.11239880e-01f, 1.31983548e-01f, -3.13565373e-01f, -6.88743770e-01f, 4.37788457e-01f, -5.63967824e-02f, -3.07035536e-01f, -3.43183935e-01f, -9.00477171e-02f,
  2.76255548e-01f, 2.85717010e-01f, -4.47648726e-02f, 2.42182150e-01f, 1.29313156e-01f, -2.90351987e-01f, -1.35260209e-01f, -2.20084563e-01f, 3.12491715e-01f, -2.85806388e-01f,
  -1.27170429e-01f, -3.37868363e-01f, -4.90324050e-01f, -2.02973872e-01f, -3.45807970e-01f, 2.40039781e-01f, 4.81956974e-02f, -1.20140888e-01f, -5.37222065e-02f, 3.68077196e-02f,
  -7.53768682e-02f, 8.79549086e-02f, -5.78531362e-02f, -1.36214703e-01f, 5.68043329e-02f, -1.44556873e-02f, -1.87133029e-02f, 1.42879207e-02f, 1.32439900e-02f, 5.73395472e-03f,
  -3.59746367e-02f, 8.52465536e-03f, -1.40575960e-01f, -7.96290562e-02f, -1.78667471e-01f, 1.17165461e-01f, -5.86947016e-02f, -2.28407517e-01f, -2.46613875e-01f, -1.47974476e-01f,
  -3.25647950e-01f, -4.52091545e-03f, 1.94708586e-01f, 8.10975730e-02f, -6.38311356e-02f, 1.96117803e-01f, 2.37827614e-01f, -1.37357414e-01f, 1.47611514e-01f, -2.87593633e-01f,
  -1.04644559e-01f, -1.87596574e-01f, -2.35924646e-01f, 3.02864492e-01f, 1.77962393e-01f, 2.03404933e-01f, 1.47996902e-01f, -6.60327170e-03f, 2.95029104e-01f, -2.73452550e-01f,
  1.69672161e-01f, 1.00647006e-02f, -1.25017896e-01f, -2.50838131e-01f, -1.57556668e-01f, 1.17667302e-01f, 4.83950078e-02f, -1.02300644e-01f, 1.98210537e-01f, -1.23731010e-01f,
  2.72272322e-02f, -3.88634831e-01f, -2.65697986e-01f, -1.82947800e-01f, -1.39019221e-01f, 3.57785910e-01f, -2.91000843e-01f, -2.93148249e-01f, 3.70352328e-01f, -9.30370539e-02f,
  -1.41946092e-01f, 2.89541364e-01f, -9.40470025e-02f, -3.50908339e-01f, 1.50374576e-01f, -1.90376580e-01f, -2.86960542e-01f, -1.62025079e-01f, -2.71630019e-01f, 2.24852771e-01f,
  3.40559453e-01f, 3.41254443e-01f, -2.68745422e-01f, -2.16317773e-01f, -3.12135518e-01f, -9.44950208e-02f, -2.29618132e-01f, -5.37884533e-01f, 1.17192097e-01f, -2.30057836e-01f,
  -6.01254813e-02f, 3.69702607e-01f, -4.61011156e-02f, -2.50224888e-01f, -2.77127057e-01f, 2.53117025e-01f, -2.59330750e-01f, 2.62831032e-01f, 3.59207720e-01f, -3.29234570e-01f,
  3.18587944e-02f, 3.10875148e-01f, -3.95264298e-01f, -8.86802673e-02f, -8.53821337e-02f, -2.02480510e-01f, -2.50091404e-01f, 1.50411919e-01f, 1.63995728e-01f, -1.67834386e-01f,
  -6.52839392e-02f, 3.72970909e-01f, -2.37649024e-01f, 2.24027529e-01f, -2.72065938e-01f, 3.22979450e-01f, -3.58171850e-01f, -1.19421016e-02f, 1.40106156e-01f, -1.88630581e-01f,
  -3.80684435e-01f, -2.47037053e-01f, 2.92769045e-01f, 1.18834190e-01f, -2.93085217e-01f, -1.79048494e-01f, -3.50762635e-01f, 2.04855110e-02f, 8.74355808e-02f, -5.42207919e-02f,
  1.09552525e-01f, -3.11250180e-01f, -2.53373802e-01f, 2.16608375e-01f, 8.54608268e-02f, 2.10332479e-02f, -1.92264631e-01f, 8.31398740e-03f, -2.30388507e-01f, -3.03334147e-02f,
  1.14408150e-01f, -2.26671293e-01f, 1.60507448e-02f, 4.65148538e-02f, 3.50082405e-02f, -2.16668218e-01f, -2.83317417e-02f, -3.34079750e-02f, -6.30113184e-02f, 3.08913048e-02f,
  -1.18236326e-01f, -1.75988272e-01f, 3.04409452e-02f, 1.96382590e-02f, 4.13705334e-02f, -4.67738993e-02f, 3.74920666e-02f, 9.09732431e-02f, -3.06351423e-01f, -1.54350167e-02f,
  2.11784430e-03f, -1.15165040e-01f, 2.42211372e-01f, -1.84690833e-01f, 1.18058190e-01f, 6.14609420e-02f, -1.92666054e-01f, 1.93279952e-01f, 2.33700082e-01f, -7.61765391e-02f,
  -1.75865635e-01f, -3.22727598e-02f, 1.50801003e-01f, 1.80746794e-01f, -2.11265832e-01f, 1.85415402e-01f, 4.94081415e-02f, 2.31074661e-01f, -1.80133387e-01f, 7.94915631e-02f,
  -9.00811255e-02f, 2.04406112e-01f, -3.34496237e-02f, -1.20130517e-02f, -2.44661614e-01f, 3.66221786e-01f, -3.34331632e-01f, 4.14080858e-01f, 3.98532808e-01f, -2.34581769e-01f,
  -3.82862352e-02f, -3.64774376e-01f, 2.95470804e-01f, -4.56974119e-01f, 2.46047258e-01f, 2.26596430e-01f, -8.94051939e-02f, 4.46848303e-01f, 1.46316245e-01f, -3.15177917e-01f,
  -2.71370918e-01f, -7.40742609e-02f, 1.87184885e-01f, -1.20473646e-01f, -1.21630631e-01f, -3.77594531e-01f, 5.02391219e-01f, -4.72519368e-01f, -1.35248736e-01f, -1.37652054e-01f,
  8.52611139e-02f, 1.99006632e-01f, -1.26905560e-01f, 1.65961862e-01f, -4.76983279e-01f, -3.88743818e-01f, -4.59131092e-01f, 4.55354959e-01f, 3.32673252e-01f, -2.93529212e-01f,
  -2.41369605e-01f, -3.43965113e-01f, -1.74390495e-01f, -1.88489243e-01f, -7.30575994e-02f, -4.58136916e-01f, -1.94869801e-01f, -2.25844800e-01f, -2.50994712e-01f, -4.56399947e-01f,
  -3.87485713e-01f, 2.71835662e-02f, 2.98329026e-01f, -4.63806480e-01f, 1.21507846e-01f, -7.42051601e-02f, -2.04117134e-01f, -4.51232523e-01f, -9.88691766e-03f, -1.41656756e-01f,
  1.49795324e-01f, -3.09589535e-01f, 1.40643835e-01f, -2.68012494e-01f, 9.69841480e-02f, 7.02578723e-02f, -2.32359037e-01f, -1.10433690e-01f, -1.18065715e-01f, -2.68251717e-01f,
  2.25630850e-01f, 3.87176722e-01f, -3.87076020e-01f, 3.22775662e-01f, -1.96460541e-02f, 2.49423720e-02f, 4.52421308e-02f, -2.63397396e-01f, 4.45127524e-02f, 1.13542967e-01f,
  3.02529614e-02f, -5.78386068e-01f, -9.77516100e-02f, 5.60921095e-02f, 8.32182541e-03f, 7.88947642e-02f, 1.35785952e-01f, 1.79181099e-01f, 6.29904717e-02f, -6.54849876e-03f,
  1.49649054e-01f, 4.10910137e-02f, 1.28868476e-01f, 1.23712622e-01f, 5.94995283e-02f, 1.92493908e-02f, 2.06889566e-02f, -4.67507765e-02f, 1.43715590e-01f, 6.71161860e-02f,
  -2.63338387e-01f, 2.24413261e-01f, 1.64396450e-01f, 1.91155463e-01f, 8.34162533e-02f, -7.35566672e-03f, 1.09539278e-01f, 3.59028131e-01f, 1.96178555e-01f, -3.19236666e-01f,
  -1.35379419e-01f, -1.40146520e-02f, -4.14069705e-02f, 2.49742180e-01f, -2.41103053e-01f, -6.86901733e-02f, -3.41625996e-02f, -1.11671142e-01f, -3.75070006e-01f, 2.23331600e-01f,
  -1.41018823e-01f, -1.72470048e-01f, 3.03315550e-01f, 3.92990327e-03f, 1.33584598e-02f, -1.93165198e-01f, 2.64921099e-01f, -1.72666401e-01f, 1.08816512e-01f, -1.64784074e-01f,
  -1.22371227e-01f, -4.94288862e-01f, -2.36460581e-01f, 2.62665953e-02f, 1.17641157e-02f, -2.98944443e-01f, -4.02264774e-01f, -4.15813714e-01f, -2.96847880e-01f, 2.06358939e-01f,
  1.53430670e-01f, -2.70157039e-01f, 1.99880064e-01f, 1.83902271e-02f, -3.91696334e-01f, -9.05753747e-02f, 4.48318809e-01f, -2.22443834e-01f, -2.27134719e-01f, -5.99837363e-01f,
  1.38494670e-01f, -2.15014964e-01f, 3.63318652e-01f, -2.34623984e-01f, -1.12675071e-01f, 2.21176609e-01f, -5.86661287e-02f, 2.13728964e-01f, 2.06438541e-01f, 5.92230894e-02f,
  4.35137838e-01f, 1.98434919e-01f, 2.53361911e-01f, -6.08577542e-02f, 2.56992906e-01f, 5.76203130e-02f, 2.03090280e-01f, -3.47217888e-01f, 7.17902035e-02f, -2.95973420e-01f,
  1.92472458e-01f, 2.08742812e-01f, -6.58447593e-02f, -8.79570190e-03f, -2.81454530e-02f, 2.35499039e-01f, -1.68048784e-01f, -6.20978437e-02f, 3.53636265e-01f, 2.02119857e-01f,
  -7.28623569e-02f, 3.18479598e-01f, -1.08031794e-01f, -2.19507292e-02f, -4.47051913e-01f, -2.07219914e-01f, 3.75547945e-01f, 4.77070749e-01f, -3.24078351e-02f, -2.29935840e-01f,
  1.48467362e-01f, -2.98739851e-01f, -5.40303290e-02f, -3.50640923e-01f, -2.71851838e-01f, -4.18376237e-01f, -4.05051894e-02f, 8.69617090e-02f, -2.94477850e-01f, 4.30412553e-02f,
  2.43387416e-01f, 3.43504161e-01f, 2.64915943e-01f, -2.75084581e-02f, -2.30197415e-01f, -3.17093939e-01f, -1.02041766e-01f, -5.02301276e-01f, 4.58009899e-01f, -1.78154141e-01f,
  1.15531251e-01f, 1.46184564e-01f, 1.39578372e-01f, 1.52565002e-01f, 9.90526751e-02f, 1.66153222e-01f, 8.45100582e-02f, 1.00284584e-01f, 1.71387479e-01f, 5.84501252e-02f,
  1.98637813e-01f, 2.53022075e-01f, 3.23422045e-01f, 9.92890373e-02f, 2.19441861e-01f, 1.16744697e-01f, 3.02076638e-01f, 2.89656539e-02f, 2.71007866e-01f, 8.58003721e-02f,
  8.57189447e-02f, -3.34410779e-02f, 3.02751549e-02f, 1.40378684e-01f, 9.26175117e-02f, 2.63166219e-01f, -9.94461961e-03f, 2.92450368e-01f, -3.33008826e-01f, 3.59108269e-01f,
  3.11698586e-01f, 4.27206218e-01f, -1.64154992e-02f, 5.09375148e-02f, 1.72265679e-01f, 1.90454632e-01f, 1.11255310e-01f, 1.74410850e-01f, 2.61954576e-01f, 7.63119906e-02f,
  -3.17001939e-01f, 5.82352690e-02f, -2.21116766e-01f, 1.67692170e-01f, 2.05218956e-01f, -4.34777856e-01f, 2.22519010e-01f, 2.00832933e-01f, -5.46933413e-02f, 2.09032059e-01f,
  -1.97283313e-01f, -4.93859649e-01f, -3.16799313e-01f, 1.71078682e-01f, -4.34872985e-01f, 3.47913355e-01f, 1.53560236e-01f, -2.59238899e-01f, 1.35538012e-01f, -4.89499271e-01f,
  -2.68106550e-01f, 1.37721032e-01f, -1.95949540e-01f, -3.35244864e-01f, 2.93437362e-01f, -2.07133412e-01f, 2.54460603e-01f, -9.95987058e-02f, -4.06368405e-01f, -1.03108071e-01f,
  -3.08411658e-01f, 3.34826738e-01f, -3.42040420e-01f, 2.73632407e-02f, -5.08542597e-01f, -3.05477321e-01f, -2.26744264e-01f, 5.57669699e-02f, -2.13903114e-01f, -4.17051256e-01f,
  -3.68418336e-01f, 3.35678935e-01f, 1.49349034e-01f, 3.10297996e-01f, -1.70393914e-01f, -7.88394883e-02f, -2.26949766e-01f, 2.65465975e-01f, -3.76439653e-02f, -4.15529311e-01f,
  1.45721480e-01f, -1.00762239e-02f, -3.07560533e-01f, -4.97082062e-02f, 2.88379882e-02f, 3.50840032e-01f, -1.22299567e-01f, -1.55501828e-01f, -2.44476378e-01f, 3.74131858e-01f,
  4.01193291e-01f, 2.58449107e-01f, -2.05898643e-01f, 5.76768536e-03f, -4.85127002e-01f, -1.84049860e-01f, 5.74082017e-01f, -9.50109735e-02f, -2.86739081e-01f, -2.00235009e-01f,
  2.09124953e-01f, -3.93600643e-01f, 2.76880059e-02f, -8.71308148e-02f, 1.90835014e-01f, 1.87686116e-01f, -1.01295009e-01f, -4.78156656e-01f, 4.39258844e-01f, -3.17777365e-01f,
  1.00994073e-01f, -2.53154427e-01f, -2.96764791e-01f, -8.68868232e-02f, -4.25211787e-01f, 1.44908011e-01f, -2.58784682e-01f, -1.36259973e-01f, 4.62963507e-02f, -1.87181070e-01f,
  7.13179857e-02f, -2.54021764e-01f, 1.03161365e-01f, 5.08620888e-02f, 4.46318500e-02f, -1.45380422e-02f, 7.29075000e-02f, -3.89257446e-02f, -1.44578382e-01f, -1.84434161e-01f,
  -5.35172522e-02f, 2.78283618e-02f, 1.25736400e-01f, 1.40794450e-02f, -1.52860701e-01f, -1.18384637e-01f, 1.53321862e-01f, -2.82178611e-01f, -1.72298223e-01f, -6.73719794e-02f,
  -7.25135878e-02f, -3.17196175e-02f, -6.42116740e-02f, -1.94747373e-01f, 1.74236000e-01f, 1.53992161e-01f, -1.53530508e-01f, -9.29713547e-02f, -2.68488407e-01f, -2.79895812e-01f,
  -2.07016975e-01f, -3.09991241e-02f, 3.35917592e-01f, -3.38135809e-01f, 1.23274401e-01f, -4.30679440e-01f, -3.30676496e-01f, -2.29293164e-02f, -2.15515822e-01f, -1.78624749e-01f,
  -3.27317566e-01f, 1.71854287e-01f, 2.63968110e-01f, 2.01011643e-01f, -3.56331974e-01f, -2.89928913e-02f, 2.33712777e-01f, 7.05045089e-02f, 3.82688642e-01f, -6.08299812e-03f,
  3.89436632e-01f, -1.21431537e-01f, 1.31519679e-02f, 4.81828064e-01f, -5.78986593e-02f, -1.82315141e-01f, -3.01136196e-01f, -1.93681926e-01f, -3.26350331e-01f, 1.40401542e-01f,
  2.60877311e-01f, 2.75603700e-02f, -5.56186736e-01f, -3.17179143e-01f, 3.74791026e-01f, 3.89712930e-01f, 2.22374126e-02f, -2.13043258e-01f, -2.67717183e-01f, 2.90045947e-01f,
  -2.09659249e-01f, -4.67671305e-01f, 2.13861838e-01f, 2.69178718e-01f, -3.88224572e-01f, -4.09345552e-02f, -1.37070403e-01f, 5.26022092e-02f, 3.58585715e-01f, -3.11080575e-01f,
  8.11167657e-02f, 7.32908994e-02f, -2.05705032e-01f, 8.68877694e-02f, -3.96519244e-01f, 3.75299722e-01f, -5.28844558e-02f, 1.29840747e-01f, -2.58779913e-01f, 1.28690571e-01f,
  2.50234604e-01f, -3.55548173e-01f, 1.02859177e-01f, -4.55482900e-01f, -2.71927297e-01f, 1.74250692e-01f, -5.31927466e-01f, 1.46421105e-01f, -4.81762618e-01f, 3.27747226e-01f,
  3.84991616e-01f, 9.96422116e-03f, -2.37471804e-01f, -1.89733118e-01f, -4.94213998e-01f, -4.44116682e-01f, 2.53936768e-01f, -6.47455156e-02f, -1.01842560e-01f, -1.95447311e-01f,
  -2.66763985e-01f, -2.70800710e-01f, 1.30982205e-01f, -3.45119126e-02f, 1.29684597e-01f, 3.79208833e-01f, -2.50088751e-01f, -2.68376052e-01f, -3.30189794e-01f, 7.83770084e-02f,
  -2.08631724e-01f, 3.03972334e-01f, 7.19754994e-02f, -1.27632514e-01f, -9.72709656e-02f, -4.87771146e-02f, -2.74916738e-02f, 2.31859088e-02f, 1.13940053e-02f, 5.93550615e-02f,
  -1.95658147e-01f, -1.43101916e-01f, -5.96004985e-02f, 7.31713921e-02f, -1.10263087e-01f, -2.24309772e-01f, -1.94994852e-01f, -1.40988439e-01f, 3.92416418e-02f, -1.37982726e-01f,
  -1.90248385e-01f, 1.37361733e-03f, 4.64177653e-02f, 2.92687770e-02f, -1.14665531e-01f, 3.76480841e-03f, 5.26573062e-02f, -1.47437796e-01f, 5.48788048e-02f, 4.80520725e-02f,
  4.56636287e-02f, -2.82017916e-01f, -8.89920667e-02f, -8.49132985e-02f, -5.74117377e-02f, -1.91304699e-01f, -2.64781684e-01f, -2.25035325e-01f, 8.78906250e-02f, -2.87511289e-01f,
  2.62132078e-01f, 2.38563538e-01f, -2.23390639e-01f, -8.89857188e-02f, 1.33386746e-01f, -2.43984118e-01f, -1.93455204e-01f, 7.17284158e-02f, 3.66169997e-02f, -2.23384947e-01f,
  7.69344121e-02f, 3.28484923e-02f, 2.20665380e-01f, -5.07511087e-02f, 1.91335648e-01f, 6.22257255e-02f, -1.35475531e-01f, -2.78080463e-01f, -1.59212396e-01f, 3.74609202e-01f,
  -3.65714699e-01f, -1.45515382e-01f, -2.39704117e-01f, 4.09561366e-01f, 2.96546400e-01f, -6.60868594e-03f, 5.37464917e-02f, -3.80424261e-01f, -2.14182273e-01f, 2.00725108e-01f,
  2.97766645e-02f, -4.33441624e-02f, -1.99345544e-01f, -2.41880909e-01f, -1.89163268e-01f, 3.26928049e-02f, -1.72127277e-01f, -1.82870358e-01f, 2.95389891e-01f, -2.15205863e-01f,
  -1.61897689e-01f, -2.01461792e-01f, -2.39190459e-01f, 2.26958737e-01f, -2.65533596e-01f, -2.44482085e-01f, -1.27386019e-01f, -2.75686145e-01f, -2.32315838e-01f, -1.03633448e-01f,
  1.92539141e-01f, -1.20020010e-01f, -1.42057657e-01f, 3.93793583e-01f, 4.42451090e-02f, -2.02532902e-01f, -2.32188836e-01f, 4.44569737e-01f, -1.98044255e-01f, -3.19548726e-01f,
  -1.98201776e-01f, -1.06106929e-01f, 2.54429847e-01f, -2.23052144e-01f, -2.96582699e-01f, 2.52367407e-01f, -2.29148850e-01f, -3.97894047e-02f, -2.56274611e-01f, 3.26576352e-01f,
  -2.24234164e-01f, -1.28855884e-01f, 2.48229623e-01f, -1.00088499e-01f, -2.49962449e-01f, -2.89459489e-02f, -1.14139967e-01f, -7.97883198e-02f, 2.03387797e-01f, -9.05531645e-02f,
  -2.74909437e-01f, -2.41714418e-01f, -5.54116927e-02f, 8.17012265e-02f, -8.65695328e-02f, 2.65944093e-01f, -2.71147817e-01f, -1.26476318e-01f, 2.69489318e-01f, 1.47640362e-01f,
  -1.51251242e-01f, 2.58309729e-02f, -5.29913697e-03f, -2.38897949e-01f, 1.12188585e-01f, -4.29027416e-02f, -5.49184196e-02f, 4.52180067e-03f, 4.03515249e-02f, -1.10117406e-01f,
  3.40964040e-03f, -8.67798626e-02f, 6.34028167e-02f, 4.49746549e-02f, -9.26187336e-02f, 8.09502006e-02f, -3.28300409e-02f, -4.06204127e-02f, -2.95159612e-02f, -6.45773159e-03f,
  -8.67130682e-02f, -1.44825187e-02f, -2.73364872e-01f, -6.42299801e-02f, 8.87585953e-02f, -7.67956972e-02f, -1.27124488e-01f, 1.03511110e-01f, 1.25058323e-01f, -1.07812613e-01f,
  -2.01007903e-01f, 1.72941938e-01f, -1.43857911e-01f, 5.23809828e-02f, -2.35119745e-01f, 2.64315397e-01f, 1.06249768e-02f, 1.70250744e-01f, -8.48941654e-02f, -1.51426747e-01f,
  1.86820790e-01f, -1.75060362e-01f, 2.54401833e-01f, -1.87171012e-01f, 1.30632713e-01f, -1.25745116e-02f, 9.98226777e-02f, -1.78522125e-01f, -2.29018152e-01f, -2.20198154e-01f,
  -8.74854326e-02f, -2.68414050e-01f, 1.86557367e-01f, 1.02479674e-01f, -3.38249803e-01f, -1.14297219e-01f, 2.78978646e-01f, -1.46956638e-01f, 1.89157501e-01f, 3.68597627e-01f,
  -2.26552054e-01f, 1.04904093e-01f, 7.79273361e-02f, -4.66217194e-03f, -1.41915306e-01f, -1.01600267e-01f, -1.36969253e-01f, -8.42362866e-02f, -2.70974427e-01f, 3.00412267e-01f,
  -1.12023756e-01f, 4.39515039e-02f, -2.60180801e-01f, 2.58466333e-01f, 3.04674864e-01f, -6.16656505e-02f, -2.20175028e-01f, -2.14176923e-01f, 3.28767031e-01f, -1.43010885e-01f,
  3.28797460e-01f, -2.00867400e-01f, -2.21890301e-01f, -3.50167826e-02f, -1.61326259e-01f, -1.61375299e-01f, -1.29451513e-01f, -2.38671690e-01f, -2.33166486e-01f, -8.21191818e-02f,
  -2.63300300e-01f, -1.58608675e-01f, 3.61366153e-01f, 3.39993596e-01f, -2.87844062e-01f, -2.27266863e-01f, -1.72305509e-01f, -1.47048905e-01f, -3.13251853e-01f, 3.71651620e-01f,
  -1.72801197e-01f, -3.07189912e-01f, -3.70292276e-01f, -2.00165957e-01f, 2.93517768e-01f, -1.07705332e-01f, -1.28646925e-01f, -3.22889864e-01f, 2.66714633e-01f, -2.22452939e-01f,
  -3.70790809e-02f, -8.44228640e-02f, -1.13464773e-01f, -3.42676103e-01f, 2.29913771e-01f, 2.44122267e-01f, -1.57193914e-01f, 2.21266784e-02f, -1.57648355e-01f, -1.67522863e-01f,
  3.75997126e-01f, -2.73574471e-01f, -2.48880208e-01f, -2.25312784e-01f, -3.18956733e-01f, 4.15462583e-01f, -2.02827334e-01f, 8.27421024e-02f, -1.75903574e-01f, 3.15599114e-01f,
  -1.30153492e-01f, -1.88308224e-01f, -9.06091649e-03f, -4.34823595e-02f, 9.14013162e-02f, 6.34522140e-02f, 9.92820784e-02f, -5.91289066e-02f, 1.12891912e-01f, 7.13784539e-04f,
  -7.56470710e-02f, -6.46278933e-02f, 1.45147949e-01f, 7.23823998e-03f, 1.70115411e-01f, -1.51295215e-02f, -1.50567830e-01f, 1.11773685e-01f, 3.95299569e-02f, -6.18185960e-02f,
  3.17202369e-03f, -1.06013514e-01f, 1.66328579e-01f, -2.18649190e-02f, 1.08358644e-01f, 1.75232828e-01f, 1.66776851e-01f, -3.64060700e-01f, -8.86694808e-03f, -4.09470767e-01f,
  1.12782061e-01f, -1.12548387e-02f, -5.12691811e-02f, -1.88532233e-01f, 3.64802092e-01f, -2.10650370e-01f, -2.08055064e-01f, 1.42988250e-01f, 3.22205842e-01f, -2.57813856e-02f,
  3.79265696e-01f, -3.50902855e-01f, 3.71868283e-01f, -2.57664025e-01f, -1.31271601e-01f, 2.41802514e-01f, 1.83667958e-01f, 3.13490599e-01f, 4.01321113e-01f, 3.39885987e-02f,
  -1.18525401e-01f, 1.35237366e-01f, -3.36510897e-01f, -2.87165701e-01f, 5.26280217e-02f, -1.75698474e-01f, -2.02503756e-01f, -4.69433308e-01f, -8.05980712e-03f, -2.30884384e-02f,
  -3.74762386e-01f, -3.04641992e-01f, 2.58803904e-01f, -4.07494724e-01f, 1.09696455e-01f, -2.11498290e-01f, 2.36657262e-01f, -2.27982476e-01f, 3.17247845e-02f, 3.43183637e-01f,
  5.34541011e-02f, -3.41937810e-01f, -6.11041524e-02f, -1.62712470e-01f, -1.75804392e-01f, -3.79892625e-02f, 1.58741195e-02f, 1.81786772e-02f, -4.07749534e-01f, -3.27132553e-01f,
  1.48234710e-01f, -3.39850128e-01f, 2.44492605e-01f, -1.88217908e-01f, -1.45651549e-01f, -4.04254824e-01f, -3.11813325e-01f, -3.11922550e-01f, 1.11112364e-01f, 6.79006130e-02f,
  2.98396736e-01f, -2.25563958e-01f, -3.00177604e-01f, 3.71219784e-01f, 2.79566973e-01f, 2.02337205e-01f, 2.82450706e-01f, -6.66328594e-02f, 3.18685234e-01f, -4.28493470e-01f,
  3.77301514e-01f, 1.59866706e-01f, -3.62566292e-01f, -3.33349943e-01f, 3.03154379e-01f, 2.92249590e-01f, -3.77441227e-01f, 2.43342310e-01f, 1.21821389e-01f, 1.25575721e-01f,
  -2.18073905e-01f, 1.54645205e-01f, 3.53152752e-02f, -1.90892115e-01f, -2.49129340e-01f, 4.36859459e-01f, -3.29601377e-01f, 1.32127479e-01f, -3.90723199e-01f, -3.07436615e-01f,
  -1.17380537e-01f, -9.16144848e-02f, -8.99104588e-03f, -3.75809491e-01f, 4.60738055e-02f, -3.77532393e-01f, 4.99277622e-01f, -3.24944586e-01f, 1.02434814e-01f, 1.82375461e-01f,
  -5.24502248e-02f, -2.14211363e-02f, 2.15564474e-01f, -2.72555947e-02f, 1.55056447e-01f, 9.81671661e-02f, 6.08948618e-02f, 3.63569222e-02f, 1.16403833e-01f, -1.21458536e-02f,
  1.38327643e-01f, -1.86553691e-02f, 7.67487586e-02f, 1.36540517e-01f, 6.47418350e-02f, 1.27007589e-01f, 1.00849248e-01f, 1.16417654e-01f, 1.67283952e-01f, -4.31877822e-02f,
  -7.43378028e-02f, 4.06798460e-02f, -3.49276792e-03f, -5.63001707e-02f, -7.11686611e-02f, -2.53096998e-01f, 2.77033359e-01f, -1.19717017e-01f, 1.42631426e-01f, -2.80561447e-02f,
  -1.14901371e-01f, -3.39333177e-01f, -7.65014887e-02f, 1.29635692e-01f, 2.00944185e-01f, 8.84975493e-02f, -1.62884712e-01f, 3.36414367e-01f, -2.56545961e-01f, -1.68838114e-01f,
  3.14228505e-01f, 2.32817307e-01f, 8.32876116e-02f, 3.21739540e-02f, -3.03900033e-01f, 2.00415298e-01f, -5.66754304e-02f, -3.62639219e-01f, 2.00696513e-01f, -3.27852815e-01f,
  1.69739336e-01f, -1.73172101e-01f, 1.41376391e-01f, 7.96590149e-02f, 2.73093909e-01f, -2.65271008e-01f, 1.79477289e-01f, -9.93401781e-02f, -8.21957886e-02f, 1.95634589e-01f,
  3.03207375e-02f, -4.85149264e-01f, -1.98533595e-01f, -4.87137705e-01f, -1.74393415e-01f, 1.38500229e-01f, -2.56271720e-01f, -3.37426752e-01f, -8.39044899e-02f, 1.84909180e-01f,
  -2.44264230e-01f, -1.06814012e-01f, -3.74129504e-01f, 5.72155118e-01f, -3.58898818e-01f, -4.36963499e-01f, -1.07238472e-01f, 2.59318173e-01f, 9.53109004e-03f, 3.01241815e-01f,
  -1.87633261e-01f, -1.10648416e-01f, -3.54836047e-01f, -2.54822820e-01f, -1.47815645e-01f, 1.20910838e-01f, -1.00146569e-01f, -3.88066992e-02f, -2.19267339e-01f, -4.79640245e-01f,
  1.34575233e-01f, -2.10294798e-01f, -2.89647430e-01f, -3.67853791e-01f, -2.10715979e-02f, 2.52939221e-02f, -2.09600925e-01f, 3.30471814e-01f, 1.64012000e-01f, -1.98385715e-01f,
  -9.28176343e-02f, -3.75045568e-01f, -2.39383355e-01f, -2.93667614e-01f, 3.11153889e-01f, -3.50344321e-03f, -8.47171992e-02f, 7.42407590e-02f, 3.48285645e-01f, 2.89388984e-01f,
  5.20729125e-02f, 4.81487066e-01f, -3.07234317e-01f, -3.01918477e-01f, -1.82053655e-01f, 1.65989935e-01f, -4.72493738e-01f, 1.40888199e-01f, -6.81726709e-02f, -1.47151411e-01f,
  -3.70471269e-01f, 1.80787221e-01f, 4.35948521e-01f, -1.90646186e-01f, -1.35443062e-01f, 4.04901467e-02f, -2.90990025e-01f, 4.11193281e-01f, 8.36928859e-02f, 2.25072596e-02f,
  1.30337983e-01f, 4.84145246e-02f, 1.19511016e-01f, 9.89627391e-02f, 7.97639489e-02f, 1.14086442e-01f, -1.04673661e-01f, 6.39671609e-02f, 3.48339714e-02f, 1.35752246e-01f,
  -1.97608635e-01f, 2.39877664e-02f, -6.96119294e-02f, -7.09453896e-02f, -4.80433963e-02f, -1.44617856e-01f, 5.81641831e-02f, -7.34061655e-03f, 3.85541506e-02f, 7.85777047e-02f,
  -4.97486144e-02f, -1.30479438e-02f, 3.99821214e-02f, 2.12553486e-01f, -2.34795451e-01f, -2.11002335e-01f, -2.61507750e-01f, 1.44863099e-01f, -1.60848692e-01f, -2.26832211e-01f,
  2.23443568e-01f, -2.84796327e-01f, 4.92900610e-03f, 5.65581508e-02f, 1.61358446e-01f, -3.12431812e-01f, -2.42961019e-01f, 3.17213476e-01f, -1.69219583e-01f, -9.28563997e-02f,
  3.11649382e-01f, 2.86597580e-01f, -2.24076435e-01f, 3.23222995e-01f, -1.85788482e-01f, 9.68438089e-02f, 1.68824092e-01f, -7.73786455e-02f, -2.24027738e-01f, -7.52508417e-02f,
  -2.43212655e-02f, -2.07190439e-01f, 1.31125096e-02f, 4.16016102e-01f, 2.28693768e-01f, 2.26086840e-01f, 1.79023389e-02f, -1.52283043e-01f, 1.91367641e-01f, 2.76542276e-01f,
  -3.35678935e-01f, 2.76677966e-01f, -1.96781084e-01f, -2.11819023e-01f, -3.60132545e-01f, -1.90236911e-01f, 3.81712615e-01f, -1.41270220e-01f, 1.09233819e-01f, -1.94773316e-01f,
  -1.78406015e-01f, -2.98630863e-01f, -3.73969048e-01f, -2.42705539e-01f, -1.89898059e-01f, -3.95879924e-01f, 2.44689628e-01f, -1.40877351e-01f, 2.61550605e-01f, -3.40666711e-01f,
  5.14484107e-01f, 7.54371192e-03f, -2.69697636e-01f, -1.80476785e-01f, -2.43561357e-01f, -7.17545077e-02f, -2.55293041e-01f, -1.24322444e-01f, 3.84159148e-01f, -1.49155259e-01f,
  -1.51169643e-01f, -9.84998122e-02f, -1.38154373e-01f, 1.71436280e-01f, -6.33516088e-02f, -5.83417080e-02f, 6.47935842e-04f, -3.75270456e-01f, 3.77083838e-01f, -4.13933277e-01f,
  -2.37084478e-01f, 5.24220280e-02f, 1.32333800e-01f, -3.63893121e-01f, -1.81902379e-01f, -1.33138403e-01f, -6.44805729e-02f, 3.12735200e-01f, 1.44759342e-01f, -2.46869996e-01f,
  -1.30076125e-01f, -3.42514247e-01f, 4.58453774e-01f, 1.57010853e-01f, -2.55957484e-01f, 1.24516353e-01f, -2.93455660e-01f, -3.93250473e-02f, -3.25469673e-01f, 1.24317683e-01f,
  -3.07155639e-01f, 4.89243746e-01f, 6.65650144e-02f, 2.69021571e-01f, -2.23563328e-01f, -2.69027442e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.41764507e-02f, 4.78473902e-02f, -1.15940057e-01f, -2.37887241e-02f, -5.86939827e-02f, 7.82387853e-02f, -1.43166380e-02f, 8.84050950e-02f, -9.84903350e-02f, -5.26725128e-02f,
  6.65233098e-03f, 5.18275760e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    