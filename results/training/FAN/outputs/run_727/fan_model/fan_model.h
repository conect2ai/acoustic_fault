/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.15868020e-01f, -1.56876028e-01f, 1.02928039e-02f, -6.83046058e-02f, -1.78502604e-01f, -1.11891992e-01f, -1.66451007e-01f, 1.32606328e-02f, -1.43579811e-01f, -1.62330464e-01f,
  -1.18588306e-01f, -1.04158722e-01f, -2.58564129e-02f, 8.15046951e-02f, 1.00300379e-01f, -8.49447474e-02f, 3.95691507e-02f, 1.51350811e-01f, 2.24815205e-01f, 6.41294122e-02f,
  4.54575866e-02f, -1.76859775e-03f, 6.11988939e-02f, 2.35808361e-02f, -1.33696616e-01f, -8.07636380e-02f, -9.01439339e-02f, -2.42691770e-01f, -9.69893858e-02f, -2.19811365e-01f,
  -1.78500861e-02f, -6.70187250e-02f, 8.40774253e-02f, -8.61259699e-02f, -2.69115809e-02f, 9.06216055e-02f, 6.48694783e-02f, -1.69927143e-02f, -3.68241332e-02f, -1.10770814e-01f,
  -9.05370042e-02f, -1.16334513e-01f, -6.27800450e-02f, -7.80559555e-02f, -1.23897195e-01f, -2.48913523e-02f, 1.87410358e-02f, -6.49028644e-02f, -1.18581746e-02f, -1.77110340e-02f,
  -7.28123710e-02f, -7.13068619e-02f, -1.22087240e-01f, -1.24274053e-01f, -9.34833512e-02f, -8.86176452e-02f, -8.19975063e-02f, -7.02610388e-02f, -9.66652781e-02f, -4.15288620e-02f,
  8.12444389e-02f, -7.99845066e-03f, -5.24240956e-02f, -5.56986742e-02f, 1.41619230e-02f, 6.01963289e-02f, 5.99157140e-02f, 1.89367365e-02f, 6.03083055e-03f, -4.18744097e-03f,
  3.82932387e-02f, 1.37450665e-01f, -4.21222374e-02f, -1.13688903e-02f, 2.84113735e-02f, -6.84143370e-03f, -6.14028201e-02f, 8.05493072e-02f, 9.19224024e-02f, -3.78023274e-02f,
  -1.68266438e-03f, 7.13976398e-02f, 5.78142479e-02f, -1.67637877e-02f, 4.57336791e-02f, -7.89360236e-03f, -2.19748504e-02f, -2.85930652e-02f, -3.76430303e-02f, -5.32827526e-03f,
  -9.45011228e-02f, -5.10248356e-02f, 1.16332658e-02f, -9.02289450e-02f, -6.33528233e-02f, -6.74881116e-02f, 2.76005547e-02f, 2.64391229e-02f, -8.59134644e-02f, 4.82064411e-02f,
  -5.86120039e-02f, 8.63527730e-02f, -1.20046251e-01f, 3.16918194e-02f, 3.00439689e-02f, -4.62762043e-02f, -6.93399906e-02f, -3.26810740e-02f, -7.54417181e-02f, 6.49748696e-03f,
  -3.48552987e-02f, 5.10412417e-02f, 1.26888394e-01f, -2.24897452e-03f, -3.36291902e-02f, 8.93519819e-02f, 1.36005161e-02f, -1.24472217e-03f, 1.30082607e-01f, 1.08678088e-01f,
  -4.06246871e-01f, -3.15921642e-02f, -6.17589988e-02f, 1.62015051e-01f, 2.58911908e-01f, 1.84314474e-02f, 4.06032801e-02f, 4.05042013e-03f, 8.20490420e-02f, 7.79569224e-02f,
  1.33154511e-01f, 1.42214403e-01f, 1.30501866e-01f, 1.85476132e-02f, -1.42314792e-01f, 6.16967157e-02f, 1.92567348e-01f, -1.39107645e-01f, -1.44422948e-01f, -4.96418625e-02f,
  9.18612704e-02f, 6.57558814e-02f, -2.25099385e-01f, -7.13881254e-02f, 1.19146474e-01f, 1.78736687e-01f, 1.26200885e-01f, 9.87535045e-02f, 5.49704991e-02f, 6.47583306e-02f,
  7.30523840e-02f, -2.02207565e-01f, 3.99509817e-03f, -8.13877881e-02f, -7.06510991e-02f, -1.67763501e-01f, -1.63696464e-02f, -7.22052976e-02f, -8.72417018e-02f, -4.97332327e-02f,
  4.96214442e-02f, -1.11770503e-01f, 4.17022631e-02f, 3.75301056e-02f, 2.07550507e-02f, -7.29596242e-03f, -8.61155018e-02f, -1.45081701e-02f, -1.40909016e-01f, -1.01357177e-01f,
  -8.38373031e-04f, 3.76492813e-02f, 4.92787398e-02f, 2.02449597e-02f, -2.59814896e-02f, 4.10585571e-03f, -8.88630375e-02f, -7.16226697e-02f, -7.52815977e-02f, -1.00610470e-02f,
  -4.74213958e-02f, -7.85617903e-02f, -6.45272657e-02f, -3.48360538e-02f, -3.11138816e-02f, 8.18179455e-03f, -1.05508743e-02f, 2.52157217e-03f, -4.79516052e-02f, -1.44710932e-02f,
  -3.64991464e-02f, -1.29356846e-01f, -3.98829486e-03f, -4.34175134e-02f, 3.49445604e-02f, -1.44440718e-02f, -2.46784184e-02f, -1.50308356e-01f, -2.67146118e-02f, -1.24806732e-01f,
  -3.21513191e-02f, -6.73019094e-03f, 2.56161410e-02f, 5.53609198e-03f, -1.14446003e-02f, -9.57437046e-03f, -1.16052084e-01f, -7.98770785e-02f, -1.56135187e-02f, -8.27194378e-02f,
  2.72754073e-01f, -1.02319486e-01f, 3.20957489e-02f, -1.30075985e-03f, 2.95112580e-02f, 8.01846907e-02f, -3.79264704e-04f, -7.67119080e-02f, 3.18302587e-02f, -1.40361919e-03f,
  1.47132734e-02f, -6.71409220e-02f, 1.14790782e-01f, -1.32060861e-02f, 7.02954410e-03f, 2.61320304e-02f, 1.10771500e-01f, 6.46083057e-02f, 9.51121598e-02f, -8.14943947e-03f,
  5.36938198e-02f, 6.62278235e-02f, 2.04895481e-01f, 1.12237863e-01f, 1.31973168e-02f, 4.36202437e-02f, 1.62437707e-01f, 1.77758202e-01f, 9.28095132e-02f, 1.24851964e-01f,
  3.15268487e-01f, -7.49078244e-02f, -2.10908622e-01f, 2.78123021e-01f, 1.69644013e-01f, -1.44614443e-01f, -1.63554713e-01f, -9.95086655e-02f, 2.21326813e-01f, 5.25716618e-02f,
  2.45094761e-01f, 2.16343373e-01f, 1.01157732e-01f, -5.91812022e-02f, -2.45311260e-01f, -1.53443843e-01f, -2.45780542e-01f, -2.42898181e-01f, -1.49932459e-01f, 1.26652986e-01f,
  1.29321635e-01f, 1.19879767e-01f, 7.82883540e-02f, 2.74892878e-02f, 2.07269803e-01f, 8.63878056e-02f, 5.76625438e-03f, 5.53263165e-02f, -6.96439222e-02f, 1.40486240e-01f,
  1.94063351e-01f, 1.05535381e-01f, 4.02727239e-02f, 9.17827189e-02f, 1.60097569e-01f, 1.11632951e-01f, 7.11682215e-02f, 1.41802430e-01f, 1.17999569e-01f, 1.68543398e-01f,
  1.49695367e-01f, 7.74961933e-02f, 1.82531565e-01f, 5.53815626e-02f, 6.02218024e-02f, 1.73226833e-01f, 7.60771111e-02f, -4.93952706e-02f, 6.54041767e-02f, 9.08999294e-02f,
  8.24932903e-02f, 8.30826685e-02f, 3.68959419e-02f, -3.10851578e-02f, 5.61583377e-02f, 2.51083802e-02f, 1.69701517e-01f, 5.29231913e-02f, 3.55340801e-02f, 1.94998413e-01f,
  -1.21592820e-01f, -7.79743791e-02f, -9.79689211e-02f, -1.25538915e-01f, -8.83532986e-02f, -1.14212193e-01f, -1.06958359e-01f, -2.38324106e-02f, -1.47957042e-01f, -1.00378864e-01f,
  -7.29053840e-02f, -1.51737228e-01f, -1.07557446e-01f, -3.20079103e-02f, -1.59140587e-01f, -8.18232596e-02f, -8.67058858e-02f, -1.93667710e-01f, -1.37452140e-01f, -3.39255221e-02f,
  -6.00742176e-02f, -4.58646566e-02f, -1.08634599e-01f, -1.39344469e-01f, -2.54941791e-01f, -1.92465723e-01f, -1.24589197e-01f, -8.18143860e-02f, -1.33633986e-01f, -6.31099343e-02f,
  2.83253819e-01f, 2.68855058e-02f, 1.45260990e-01f, 1.00621887e-01f, 2.25299448e-01f, 7.97668323e-02f, 2.31111929e-01f, 9.48744193e-02f, 2.00762451e-01f, 7.87664205e-02f,
  1.76833019e-01f, 6.23602830e-02f, 1.12004913e-01f, 7.78406188e-02f, 1.80852428e-01f, 1.50523677e-01f, 1.44820675e-01f, 1.04086258e-01f, 1.46185681e-01f, 8.06549788e-02f,
  1.15309149e-01f, 2.10223302e-01f, 1.08605109e-01f, 1.25436693e-01f, 1.89838111e-01f, 1.44472972e-01f, 1.49341881e-01f, 2.11965948e-01f, 4.33046483e-02f, 1.10987172e-01f,
  2.69668311e-01f, -1.90540418e-01f, -3.06852371e-01f, 4.27539170e-01f, -5.14194332e-02f, -2.51090169e-01f, -3.47136647e-01f, -7.76231214e-02f, 1.31485060e-01f, -1.28393829e-01f,
  -6.07013237e-03f, 1.61027148e-01f, 7.66200870e-02f, 1.16266020e-01f, 8.98479372e-02f, -1.94201812e-01f, 7.69739971e-02f, 8.14665407e-02f, 7.08145797e-02f, -1.90821756e-02f,
  1.67830765e-01f, 2.75899976e-01f, 2.73455590e-01f, 2.62619436e-01f, 3.25498402e-01f, 2.61330366e-01f, 3.94147635e-02f, 1.18774034e-01f, -1.58674836e-01f, 1.21809974e-01f,
  -1.61466435e-01f, -3.21723074e-02f, 1.22971311e-01f, 1.51798069e-01f, 1.64727923e-02f, 1.00523271e-01f, 2.55362666e-03f, 6.93948790e-02f, 1.64213181e-01f, 6.52989745e-02f,
  1.59868732e-01f, 1.18062817e-01f, 2.04671949e-01f, 5.71880676e-02f, 1.69875473e-01f, 4.32387032e-02f, 1.96092501e-01f, 1.55750230e-01f, 1.05419368e-01f, -1.50293885e-02f,
  2.17451200e-01f, 1.24298476e-01f, -4.77683060e-02f, -6.88038021e-02f, 1.45026654e-01f, 7.30880871e-02f, -1.83856320e-02f, 1.40867084e-01f, 3.50140370e-02f, 7.64249489e-02f,
  -1.65499300e-02f, -1.27514824e-01f, -7.17143118e-02f, -1.26880735e-01f, -7.54004642e-02f, -1.35815263e-01f, -4.52205986e-02f, -8.84869173e-02f, -1.66485414e-01f, -3.93044427e-02f,
  -1.23573229e-01f, -1.02267876e-01f, -7.75050521e-02f, -1.66435972e-01f, -7.41994306e-02f, -2.05625743e-01f, -3.78190987e-02f, -9.15255249e-02f, -1.03509203e-01f, -1.06993482e-01f,
  -8.74716323e-03f, -1.24259263e-01f, -1.14521153e-01f, -1.09561056e-01f, -1.31284162e-01f, -1.09570399e-01f, 1.79256294e-02f, -1.02352962e-01f, -5.09704314e-02f, -7.67669231e-02f,
  1.10303173e-02f, -4.13724296e-02f, 8.74399617e-02f, 1.69377998e-01f, 1.93584293e-01f, 1.72773600e-01f, 1.27275854e-01f, 1.51982725e-01f, 1.39790758e-01f, 1.99029967e-01f,
  1.57439977e-01f, 1.81120440e-01f, 7.22941458e-02f, 1.32706061e-01f, 7.17988834e-02f, 1.05986483e-01f, 2.21676752e-01f, 7.62874857e-02f, 1.22765884e-01f, 1.69297531e-01f,
  1.26841724e-01f, -3.89194712e-02f, -2.29951143e-02f, -4.41222191e-02f, 1.24908969e-01f, 1.96877737e-02f, 6.40662238e-02f, 1.08620688e-01f, 1.41331158e-03f, 2.34089084e-02f,
  -2.03137293e-01f, -1.13661436e-03f, -1.25374168e-01f, -3.20714675e-02f, 2.33279824e-01f, 3.18253189e-01f, 2.69403547e-01f, 1.46671534e-01f, 7.05024600e-02f, 1.31244874e-02f,
  1.02574542e-01f, 2.27624834e-01f, 2.87704796e-01f, 2.57352114e-01f, 1.46158248e-01f, 2.05622718e-01f, 1.77364945e-01f, 9.32555497e-02f, 2.15477392e-01f, 2.21229792e-01f,
  2.42915064e-01f, -4.39636596e-03f, -1.67313114e-01f, 6.13928633e-03f, 4.10195105e-02f, 2.96581328e-01f, 6.25012070e-02f, -5.81043102e-02f, 1.61494881e-01f, 1.15691625e-01f,
  2.32040524e-01f, -1.21684879e-01f, 2.28947639e-01f, 2.02347323e-01f, 2.23423857e-02f, 6.32136613e-02f, 1.57235622e-01f, -2.48086825e-02f, 8.52558538e-02f, 4.22830172e-02f,
  1.53046668e-01f, 1.52478948e-01f, 9.17660743e-02f, 3.17139663e-02f, 1.15474701e-01f, 2.84656398e-02f, -1.36476401e-02f, -3.71408723e-02f, 1.67414859e-01f, 1.08423695e-01f,
  1.14703856e-01f, 1.48698032e-01f, -6.84699789e-02f, 8.79740492e-02f, 1.02213785e-01f, 1.81328878e-01f, 2.85580475e-02f, 2.16413625e-02f, 5.19690737e-02f, 3.98397706e-02f,
  4.80298176e-02f, -1.70360684e-01f, -1.83676481e-01f, -1.44343629e-01f, -8.67444873e-02f, -4.66308147e-02f, -8.73404071e-02f, -1.48030013e-01f, -1.15658686e-01f, -1.51923746e-01f,
  -4.58492376e-02f, -7.55210146e-02f, -7.66188651e-02f, -1.40388831e-01f, 3.70105766e-02f, -6.90022483e-02f, -5.10730930e-02f, -7.74949417e-02f, -6.84283227e-02f, -8.75878781e-02f,
  -7.32326582e-02f, -2.80581973e-03f, -1.50404379e-01f, -7.88194612e-02f, -6.52064011e-02f, -1.10586159e-01f, 2.55819876e-02f, -1.19947650e-01f, -1.29612982e-01f, -1.00816220e-01f,
  1.36398509e-01f, 1.66642055e-01f, 1.50515378e-01f, 1.40929461e-01f, 1.87065229e-01f, 6.59167320e-02f, 1.82542190e-01f, 1.52396992e-01f, 1.32069618e-01f, 6.96600750e-02f,
  1.28668204e-01f, 4.96088155e-02f, 1.08670846e-01f, 1.04602948e-01f, 1.58725709e-01f, 1.78465769e-01f, 8.52752775e-02f, 1.96390644e-01f, 1.48466378e-01f, 1.08032733e-01f,
  8.64334628e-02f, 1.83444306e-01f, 1.72984242e-01f, 1.95631146e-01f, 2.05589563e-01f, 3.30343068e-01f, 1.76700592e-01f, 1.86886817e-01f, 1.35065362e-01f, 1.92131102e-01f,
  1.82677120e-01f, 2.16336280e-01f, 1.46590322e-01f, 1.61285311e-01f, -1.38388172e-01f, -1.87173918e-01f, -1.07481584e-01f, -6.30505532e-02f, 1.27949014e-01f, 2.38982160e-02f,
  1.25317410e-01f, 1.82278961e-01f, 8.02322105e-02f, 1.83325745e-02f, 9.75437276e-03f, 3.07437815e-02f, -1.06794387e-01f, -1.04591817e-01f, -1.65050834e-01f, -2.88005799e-01f,
  -1.28799215e-01f, -4.55761626e-02f, -2.10201256e-02f, -5.10469265e-02f, 1.49044693e-01f, 4.29564044e-02f, 1.08369872e-01f, 7.48023689e-02f, -2.84301583e-04f, 3.80110517e-02f,
  7.88311362e-02f, 3.31029505e-01f, -1.24738766e-02f, 1.01354815e-01f, 1.46041349e-01f, 1.52932644e-01f, 3.77165750e-02f, 1.41114190e-01f, 1.96302593e-01f, 6.02700971e-02f,
  1.39178455e-01f, 2.83694007e-02f, 1.81650952e-01f, -2.10097488e-02f, 7.83724338e-02f, -8.61267652e-03f, -1.39850425e-02f, 3.88421677e-02f, 7.73687363e-02f, 4.75981496e-02f,
  4.31284234e-02f, 8.76121223e-02f, 9.34780538e-02f, 4.20390517e-02f, 1.55890435e-01f, 1.28522053e-01f, 1.18692599e-01f, 7.59056211e-02f, 2.19103158e-01f, 1.60397246e-01f,
  -1.45014688e-01f, -6.23707809e-02f, -7.63842613e-02f, -1.29342914e-01f, -8.82642046e-02f, -4.06444520e-02f, -1.61295325e-01f, -1.96646795e-01f, -1.70901299e-01f, -9.94745791e-02f,
  -2.08255369e-02f, -1.00670815e-01f, -1.26281664e-01f, -1.52872279e-01f, -1.85402006e-01f, -5.82200438e-02f, -1.87075272e-01f, -8.17313790e-02f, -1.09907746e-01f, -1.71275392e-01f,
  -3.33896764e-02f, -1.42177105e-01f, -3.39082703e-02f, -7.89395124e-02f, -9.49368551e-02f, -4.04125936e-02f, -1.87227264e-01f, -1.05506510e-01f, -3.40393707e-02f, -7.54810572e-02f,
  7.28007779e-02f, 1.80195436e-01f, 6.90003708e-02f, -2.93776896e-02f, -4.95026726e-03f, 5.70078343e-02f, 1.55113623e-01f, 2.26177704e-02f, 1.65538207e-01f, 8.72487351e-02f,
  9.41142291e-02f, 1.10211231e-01f, 1.13215454e-01f, 5.10803796e-02f, -3.76848131e-02f, -2.11251993e-02f, -8.36418867e-02f, -1.76569948e-03f, 8.20873752e-02f, 1.52197868e-01f,
  3.60407084e-02f, -1.07700758e-01f, -3.43180634e-02f, 1.24961831e-01f, 4.60523963e-02f, 5.42735308e-03f, 3.40310601e-03f, 5.08400053e-02f, -5.36990911e-03f, -7.88000226e-02f,
  -3.83669496e-01f, -2.30986148e-01f, -1.23195827e-01f, -1.49545550e-01f, -5.32200821e-02f, -4.97146100e-02f, -1.52680725e-01f, -9.45874453e-02f, -1.26187131e-01f, -2.04641074e-01f,
  -6.64583072e-02f, -3.68649811e-02f, -1.27460742e-02f, -1.04226051e-02f, 1.14376387e-02f, -1.38565257e-01f, -9.83173400e-02f, -8.99599399e-03f, 6.00609034e-02f, 1.15993865e-01f,
  -1.40439663e-02f, -5.98726049e-02f, -2.73333807e-02f, 1.03765033e-01f, 2.95207445e-02f, -4.41122390e-02f, -1.03911556e-01f, -2.99050491e-02f, -3.98741066e-02f, -6.25808090e-02f,
  -2.17207670e-01f, -3.93099524e-02f, 5.71417389e-03f, 1.01775557e-01f, -2.27936613e-03f, 5.83642535e-02f, -1.11772418e-01f, -7.41539523e-03f, 1.74760912e-02f, -9.37228948e-02f,
  -6.16578795e-02f, 8.53991807e-02f, 3.39123160e-02f, 3.06577291e-02f, -1.09742127e-01f, 9.98402853e-03f, -1.35890786e-02f, 7.75732193e-03f, 4.99913096e-03f, -7.41115585e-02f,
  2.49827560e-02f, -6.31638914e-02f, -2.31049880e-01f, -9.42944735e-02f, -4.92058359e-02f, -1.37461960e-01f, -1.17782570e-01f, -6.89069480e-02f, -1.53881699e-01f, -1.24685854e-01f,
  3.03626619e-02f, 3.05754021e-02f, -3.52207907e-02f, 1.24666076e-02f, 6.46466687e-02f, -4.01424319e-02f, 2.26657540e-02f, -2.50854641e-02f, 7.14162588e-02f, -4.59622964e-02f,
  -6.17310917e-03f, -1.63916089e-02f, -1.97787695e-02f, 7.37759247e-02f, 6.19787574e-02f, 2.82850824e-02f, -5.70326783e-02f, -5.87059222e-02f, -2.67869979e-02f, -6.12673275e-02f,
  6.25316128e-02f, -8.14055838e-03f, 1.00194365e-02f, 9.15602222e-02f, 3.14255357e-02f, 2.78043095e-02f, -9.09075812e-02f, -2.52483878e-02f, -4.06712145e-02f, -6.95228651e-02f,
  -2.99820215e-01f, 1.20775186e-01f, -1.81810766e-01f, -3.26854340e-03f, -7.62849525e-02f, -5.70350811e-02f, -1.01322584e-01f, -6.79387078e-02f, 1.96432248e-02f, -1.65453941e-01f,
  -1.23003591e-03f, -7.34143555e-02f, -1.63964108e-01f, -9.27853808e-02f, -8.12531561e-02f, -4.38794643e-02f, -8.70360807e-02f, -1.46851242e-01f, -4.42738384e-02f, -1.55406073e-01f,
  -2.43007421e-01f, -2.29852438e-01f, -2.50134587e-01f, -1.61567271e-01f, -1.41798198e-01f, -1.95728645e-01f, -1.27516910e-01f, -2.29820386e-01f, -1.82067662e-01f, -3.18138093e-01f,
  5.63278422e-02f, 2.43789688e-01f, 3.86840180e-02f, -5.93420677e-02f, 9.53847468e-02f, -3.63032594e-02f, 1.72566295e-01f, -5.30536361e-02f, -2.66514197e-02f, 4.49592061e-03f,
  -9.85725746e-02f, -2.55381018e-01f, -3.34966958e-01f, -2.84617960e-01f, -1.63209721e-01f, -1.60919931e-02f, 9.50530320e-02f, -2.42599770e-01f, -3.07610661e-01f, -1.62235647e-01f,
  -3.09517831e-02f, -3.64762335e-03f, -1.57328546e-01f, -1.55098751e-01f, 7.59234205e-02f, -1.60167500e-01f, 1.16004258e-01f, 1.21222533e-01f, -9.51122120e-03f, 6.81945831e-02f,
  -2.35773653e-01f, 8.43601003e-02f, -3.08933526e-01f, -9.98465791e-02f, -5.73035330e-02f, -1.00529030e-01f, -1.30548840e-02f, 1.26945358e-02f, -5.35961688e-02f, -3.10323723e-02f,
  -6.95508122e-02f, -1.01298124e-01f, -9.25347302e-03f, -4.89047840e-02f, -3.90486345e-02f, -1.49514094e-01f, -1.34207517e-01f, -1.79853708e-01f, -1.77184343e-01f, -1.70578256e-01f,
  -8.32911357e-02f, -9.83362570e-02f, -1.08775444e-01f, -5.72381876e-02f, -7.94709250e-02f, -1.37334034e-01f, -3.94195430e-02f, -1.30870402e-01f, -1.57514364e-01f, -1.18395910e-02f,
  5.26759140e-02f, 1.16907857e-01f, 2.11584926e-01f, 1.41709819e-01f, 1.30724430e-01f, 1.87866494e-01f, 1.76814467e-01f, 1.05351277e-01f, 1.02604099e-01f, 1.76494971e-01f,
  4.35938910e-02f, 9.36534032e-02f, 7.83815309e-02f, 1.11102052e-01f, 6.72890320e-02f, 2.02555031e-01f, 1.31372809e-01f, 9.87921134e-02f, 1.31196633e-01f, 1.43557757e-01f,
  3.61697040e-02f, 1.73018891e-02f, 8.36907774e-02f, 3.53240706e-02f, 1.70513317e-01f, 9.52359438e-02f, 1.20635115e-01f, 1.75613850e-01f, 1.82886258e-01f, 1.56678498e-01f,
  -2.84336686e-01f, -2.32564390e-01f, -1.27115905e-01f, -1.34154215e-01f, -4.49106321e-02f, -7.79164508e-02f, -7.41459802e-02f, -9.41175297e-02f, -5.56670092e-02f, -1.64363131e-01f,
  -8.81652087e-02f, -1.59234732e-01f, -8.64131656e-03f, -1.22089155e-01f, -1.83986351e-01f, -1.42216891e-01f, -5.67282438e-02f, -7.94168711e-02f, -8.89200270e-02f, -1.50004774e-01f,
  -4.23578285e-02f, -1.24510266e-01f, -2.88489372e-01f, -1.52905896e-01f, -6.11200705e-02f, -2.69475579e-01f, -2.00540334e-01f, -1.54139608e-01f, -1.19165018e-01f, -1.38892671e-02f,
  -5.21688521e-01f, -5.03730834e-01f, 1.37432618e-02f, -2.36626804e-01f, -1.26638606e-01f, -1.04361713e-01f, -1.92506671e-01f, -1.21375374e-01f, -1.16207242e-01f, -3.08973312e-01f,
  -3.32323372e-01f, -3.33947271e-01f, -2.19128698e-01f, -2.66254783e-01f, -3.28114212e-01f, -2.33945772e-01f, -1.85292870e-01f, -1.08795837e-01f, -4.49108593e-02f, -2.06215888e-01f,
  -3.48501414e-01f, -1.97835982e-01f, -1.57278463e-01f, -1.14182509e-01f, -1.54878542e-01f, -1.87029764e-01f, -6.43738583e-02f, -1.22356243e-01f, -1.32447109e-01f, -8.44886526e-02f,
  1.54053196e-01f, -2.83364445e-01f, 2.92696934e-02f, -2.56718963e-01f, -1.70368209e-01f, -5.35008386e-02f, -9.41687971e-02f, -1.12126365e-01f, -1.10928394e-01f, -7.09960908e-02f,
  -8.51483569e-02f, -1.71234116e-01f, -7.97736496e-02f, -7.99209699e-02f, -2.02615753e-01f, -1.26945481e-01f, -1.94346309e-01f, -2.31557757e-01f, -6.57618418e-02f, -1.35594532e-01f,
  -2.88727999e-01f, -2.60252804e-01f, -1.24102958e-01f, -5.13341092e-02f, -1.28309622e-01f, -1.88174874e-01f, -1.79959044e-01f, -1.14183560e-01f, -1.13703087e-01f, -1.75821707e-01f,
  7.21590072e-02f, 9.02342275e-02f, 1.16213982e-03f, -5.13429306e-02f, 4.19808701e-02f, 5.54496720e-02f, 6.45935163e-02f, 5.61792683e-03f, 4.14393395e-02f, -1.58840138e-02f,
  2.38579176e-02f, 6.94824383e-02f, 8.06664154e-02f, -3.70583758e-02f, 2.73045674e-02f, 6.85606599e-02f, -2.16081832e-03f, 3.13670002e-02f, 2.21882313e-02f, -2.17606835e-02f,
  4.12577987e-02f, 1.32985637e-01f, -2.23075738e-03f, -2.55316086e-02f, 2.62944642e-02f, -1.94516238e-02f, -3.52596343e-02f, -2.80286446e-02f, 8.16554055e-02f, 1.34642739e-02f,
  -1.50191218e-01f, -1.63113505e-01f, -1.86628595e-01f, -9.14505199e-02f, -1.04066290e-01f, -1.31785467e-01f, -2.14476347e-01f, -1.80338636e-01f, -1.77308515e-01f, -1.63153470e-01f,
  -2.37737700e-01f, -1.15228444e-01f, -2.62374431e-01f, -7.67915547e-02f, -7.66436309e-02f, -3.16363722e-02f, -2.42758855e-01f, -1.06373630e-01f, -1.26727521e-01f, -1.33012801e-01f,
  -9.15453807e-02f, -1.19760767e-01f, -1.85037658e-01f, -1.17196463e-01f, -4.50542457e-02f, -1.45390868e-01f, -9.49819200e-03f, -1.15349777e-01f, -7.94103816e-02f, -2.23349243e-01f,
  -7.45531246e-02f, 9.77477506e-02f, 2.42381155e-01f, 4.98812832e-02f, 1.99037585e-02f, 2.41664574e-02f, 2.12613314e-01f, 2.48740036e-02f, -1.44417867e-01f, 1.08373158e-01f,
  -1.11654997e-01f, -3.62990707e-01f, -1.92376092e-01f, -7.12392181e-02f, -1.21165523e-02f, 2.74849087e-01f, 2.27707475e-01f, 8.93081278e-02f, -1.25473365e-01f, -1.37456909e-01f,
  -1.18872210e-01f, -8.87757838e-02f, -8.84649307e-02f, -2.02391315e-02f, 2.23254766e-02f, -1.77742705e-01f, 1.53805271e-01f, 6.74121752e-02f, 3.87964211e-02f, 1.47831261e-01f,
  1.71766862e-01f, 4.43670861e-02f, -6.07329868e-02f, -2.04620659e-01f, -1.01465836e-01f, -1.20853432e-01f, -1.12894103e-02f, -3.64618562e-02f, -5.85033670e-02f, -3.92756239e-02f,
  1.39894402e-02f, -1.52955174e-01f, -1.10977598e-01f, -1.05906323e-01f, 3.01502217e-02f, -5.45605160e-02f, -4.69952561e-02f, 3.02680768e-02f, 4.83188331e-02f, 8.05111602e-02f,
  -9.92358774e-02f, -6.78318320e-03f, 1.27438664e-01f, 9.25891623e-02f, 5.76917678e-02f, -4.18501757e-02f, 9.49307084e-02f, -9.16773826e-02f, -5.88121638e-02f, 3.41035873e-02f,
  4.53985669e-02f, -3.12530622e-02f, -4.03730310e-02f, -1.00942731e-01f, -4.72066924e-02f, 1.47877894e-02f, 5.53017594e-02f, -4.82006595e-02f, -4.88311984e-02f, -3.01734544e-02f,
  -8.12783316e-02f, 6.86234385e-02f, -1.75209697e-02f, 3.34228277e-02f, -1.17849987e-02f, 7.74058234e-03f, 5.42113110e-02f, 1.37755862e-02f, 4.29980047e-02f, -6.12991080e-02f,
  -5.78508526e-02f, -1.15074660e-03f, -6.18870370e-03f, -3.44401202e-03f, -1.62317157e-02f, -1.63111817e-02f, -1.03981439e-02f, -1.35883108e-01f, -1.43290401e-01f, -7.06842989e-02f,
  -1.76247671e-01f, 3.52906901e-03f, -7.93529227e-02f, -3.27433273e-02f, 3.28568146e-02f, -6.67232946e-02f, -1.34225963e-02f, -4.99310791e-02f, -2.62939148e-02f, -9.48122665e-02f,
  -1.65121872e-02f, 1.10557498e-02f, 7.17067858e-03f, -1.00337230e-01f, -4.59897816e-02f, -3.80920954e-02f, -2.86087822e-02f, -4.23233723e-03f, -9.09665823e-02f, -6.79951115e-03f,
  -1.90880056e-03f, 6.29312322e-02f, -4.12124544e-02f, 1.10299522e-02f, -8.74493942e-02f, 1.16627747e-02f, 9.06981528e-02f, -4.19611149e-02f, -2.63535045e-02f, 7.02192858e-02f,
  6.63389787e-02f, 1.06178448e-01f, -8.56201500e-02f, -1.29969209e-03f, 1.29343588e-02f, 1.11309104e-01f, 1.63142845e-01f, 2.25877509e-01f, 1.24997936e-01f, 2.56709248e-01f,
  2.36480936e-01f, 2.63800651e-01f, 1.14872128e-01f, 1.90574706e-01f, 2.02925444e-01f, 2.29081511e-01f, 3.51582728e-02f, -6.80749565e-02f, 1.08568110e-01f, 2.28038833e-01f,
  4.76297401e-02f, -5.23400158e-02f, 5.56268841e-02f, 8.49061683e-02f, 2.13168468e-03f, 9.57968608e-02f, -5.61115034e-02f, -6.84406757e-02f, 7.03317150e-02f, -2.35790759e-02f,
  2.23537475e-01f, 5.45343384e-02f, 2.28624091e-01f, 2.52447873e-01f, 1.17698304e-01f, 2.04616129e-01f, 2.69578159e-01f, 1.54562876e-01f, 1.62664428e-01f, 2.61504620e-01f,
  1.90874591e-01f, 1.51485279e-01f, 9.97931436e-02f, 1.02039449e-01f, 2.42242947e-01f, 1.79878056e-01f, 1.09026231e-01f, 8.03533942e-02f, 1.02707222e-01f, 2.40756765e-01f,
  1.31137311e-01f, 1.27306536e-01f, 3.93844247e-02f, 2.70841897e-01f, 1.49465248e-01f, 1.96379289e-01f, 1.32707357e-01f, 2.93955386e-01f, 2.20392004e-01f, 2.49273464e-01f,
  2.90448442e-02f, -2.29088366e-01f, -1.66962951e-01f, -2.65073925e-01f, -1.90515622e-01f, -1.42994270e-01f, -1.89333349e-01f, -2.00506628e-01f, -2.17642859e-01f, -1.17891543e-01f,
  -1.82550743e-01f, -2.18540207e-01f, -2.55492777e-01f, -1.17192313e-01f, -1.83906794e-01f, -2.28432149e-01f, -1.61487058e-01f, -1.75473496e-01f, -1.66753277e-01f, -1.53197467e-01f,
  -2.69798338e-01f, -1.80745497e-01f, -2.13683531e-01f, -1.16524391e-01f, -2.15270340e-01f, -2.02441841e-01f, -2.50843376e-01f, -2.54006356e-01f, -2.45340660e-01f, -3.19588453e-01f,
  1.90842256e-01f, 1.98928639e-01f, 3.37868124e-01f, 3.38070273e-01f, 2.32091516e-01f, 3.09285164e-01f, 2.60666758e-01f, 3.45072031e-01f, 2.43798867e-01f, 3.38773310e-01f,
  3.01899582e-01f, 2.46993750e-01f, 2.86408663e-01f, 2.71539271e-01f, 2.11249754e-01f, 3.20172220e-01f, 3.34769368e-01f, 2.12739855e-01f, 2.67833471e-01f, 3.20491701e-01f,
  2.30546936e-01f, 2.43119538e-01f, 2.49215990e-01f, 3.50230992e-01f, 3.05460811e-01f, 2.79461443e-01f, 3.62465590e-01f, 2.87386596e-01f, 3.41261774e-01f, 4.47815001e-01f,
  -5.27420640e-01f, -4.05611187e-01f, -1.98355019e-01f, -3.29540312e-01f, -7.87333995e-02f, 4.23710383e-02f, -6.70636594e-02f, 4.32682335e-02f, -1.02229558e-01f, -2.21107677e-01f,
  5.13449050e-02f, 5.36995158e-02f, -1.56162614e-02f, 2.07412958e-01f, 1.52252465e-01f, -1.61259159e-01f, -1.24143153e-01f, -4.54151854e-02f, 1.11484915e-01f, 8.54398832e-02f,
  6.05226913e-03f, -1.31561160e-01f, -4.43123840e-02f, -2.13326737e-02f, -1.44825146e-01f, -1.12580106e-01f, -1.85212269e-01f, -6.17824048e-02f, -5.38160792e-03f, -4.01591897e-01f,
  -8.24888945e-02f, -1.66640192e-01f, 4.44426723e-02f, -5.45550771e-02f, 7.05467770e-03f, -4.94209789e-02f, -4.56084609e-02f, -5.26404530e-02f, 3.38837728e-02f, -6.88104779e-02f,
  -2.96233110e-02f, 5.82272857e-02f, 1.30962124e-02f, 8.60162452e-02f, 1.93000981e-03f, -9.58911423e-03f, 1.68506242e-02f, 2.64580529e-02f, -6.03351817e-02f, 8.71882215e-03f,
  3.66001874e-02f, -6.38141483e-02f, -5.54940142e-02f, 9.95596522e-04f, -4.47864719e-02f, 8.16384628e-02f, 7.22007751e-02f, -3.19795646e-02f, -1.02446470e-02f, -2.46998504e-01f,
  1.16067022e-01f, -7.45039806e-03f, 1.18450455e-01f, -1.36180334e-02f, 5.51139936e-02f, -7.40887690e-03f, -3.33401412e-02f, 7.41971508e-02f, -2.40390636e-02f, 2.26357579e-02f,
  3.17197070e-02f, 2.61506736e-02f, 7.14555606e-02f, 3.16930488e-02f, 8.39875266e-02f, -3.42748351e-02f, 3.58277522e-02f, -7.23230094e-03f, 8.17051604e-02f, 5.27866222e-02f,
  7.31927678e-02f, -7.00747743e-02f, -6.08013310e-02f, 7.60361999e-02f, -4.20710817e-02f, -2.54680663e-02f, -3.97372060e-02f, 1.08489044e-01f, -9.66836605e-03f, -7.88353309e-02f,
  1.11593194e-01f, 1.49152353e-01f, -7.92706460e-02f, -2.81329714e-02f, -1.23863257e-01f, -2.49876454e-02f, -9.21121240e-02f, -3.66998836e-02f, -1.82531141e-02f, -3.86892073e-02f,
  -5.68513758e-03f, 2.64868177e-02f, -1.00776866e-01f, -1.56320892e-02f, -1.16675661e-03f, 1.15773253e-01f, 3.70185599e-02f, -2.04206002e-03f, 7.60479271e-02f, 2.84070689e-02f,
  -4.50251587e-02f, -1.72368869e-01f, -1.43985838e-01f, -8.42591897e-02f, -5.06200641e-02f, -1.58931911e-01f, -1.88783351e-02f, -6.66219294e-02f, -6.04979992e-02f, -1.88270301e-01f,
  -1.78961754e-01f, 1.11202471e-01f, -2.07952663e-01f, -1.67724982e-01f, 1.19765267e-04f, 1.35082737e-01f, 3.26290019e-02f, -1.46616185e-02f, 7.59654716e-02f, 1.04433537e-01f,
  1.37204260e-01f, 2.13989154e-01f, 7.07647875e-02f, 1.24243781e-01f, 9.17351618e-02f, 2.15854123e-02f, -5.87654673e-02f, -1.25348568e-01f, 9.99108776e-02f, 2.86840647e-01f,
  2.31482461e-01f, -1.06041031e-02f, -5.78838624e-02f, 3.59330103e-02f, 2.28578031e-01f, 1.31285951e-01f, -2.08668690e-02f, 3.21084488e-04f, 8.86663496e-02f, 8.79682302e-02f,
  1.18665181e-01f, -1.32204182e-02f, 1.74830288e-01f, 8.29964951e-02f, 1.76358193e-01f, 1.56874761e-01f, 1.53070405e-01f, 1.64752901e-01f, 1.03853516e-01f, 1.34530827e-01f,
  8.60087723e-02f, 1.64518490e-01f, 1.35131598e-01f, 1.11672282e-01f, 1.67406663e-01f, 2.06461713e-01f, 1.10271186e-01f, 1.77625772e-02f, 1.70536488e-02f, 1.73633486e-01f,
  1.26136586e-01f, 8.57798010e-02f, -4.27406169e-02f, 1.21366315e-01f, 6.63913367e-03f, 7.62916133e-02f, 1.42174870e-01f, 6.46615848e-02f, 1.62986759e-02f, 2.95348708e-02f,
  -1.39517456e-01f, -1.94868222e-01f, -3.99694107e-02f, -1.34767637e-01f, -7.63161480e-02f, -1.24613173e-01f, -1.10383533e-01f, -8.54465142e-02f, -1.10926762e-01f, -6.30608499e-02f,
  -5.99520057e-02f, -1.38997138e-01f, -1.93877250e-01f, -1.30952060e-01f, -5.03737815e-02f, -1.99446753e-01f, -1.21174641e-01f, -8.67849514e-02f, -1.13607764e-01f, -2.27093488e-01f,
  -9.90064144e-02f, -8.95442143e-02f, -1.34022906e-01f, 4.17294241e-02f, -1.24744833e-01f, -1.25788867e-01f, -1.90057978e-01f, -1.50518000e-01f, -7.57368430e-02f, -8.82326961e-02f,
  1.43134117e-01f, 7.90078342e-02f, 1.73691928e-01f, 2.48915225e-01f, 5.64796403e-02f, 2.08922222e-01f, 1.08389728e-01f, 1.55581251e-01f, 1.75696939e-01f, 1.91686094e-01f,
  1.23724118e-01f, 1.82253614e-01f, 1.75556764e-01f, 2.69896597e-01f, 1.94853768e-01f, 2.08398312e-01f, 1.91012681e-01f, 6.79557696e-02f, 7.80308768e-02f, 1.14883907e-01f,
  1.91673025e-01f, -2.08640918e-02f, -2.98378970e-02f, 7.70468414e-02f, 1.03063047e-01f, 1.12388797e-01f, 1.06458649e-01f, 1.34794220e-01f, 1.38307706e-01f, 1.04016483e-01f,
  3.60577941e-01f, -1.82602420e-01f, 1.29386887e-01f, -1.64259180e-01f, -5.48903458e-02f, 1.48650795e-01f, 6.78118989e-02f, 1.05319627e-01f, -9.14556459e-02f, -1.31624609e-01f,
  -1.04844235e-01f, -1.92967430e-01f, -9.52146277e-02f, -9.18521956e-02f, 6.50089700e-03f, -1.75392374e-01f, -1.94489554e-01f, 8.84489641e-02f, 1.75908208e-01f, 1.39979727e-03f,
  -2.92779893e-01f, -1.99631721e-01f, -9.01215300e-02f, -1.04847491e-01f, -4.00388747e-01f, -2.88884312e-01f, -2.54906535e-01f, -1.53178155e-01f, -1.41997591e-01f, -4.44651186e-01f,
  -5.49251251e-02f, 1.64157599e-01f, -1.77502539e-02f, -2.00974002e-01f, -8.75461623e-02f, -1.04636453e-01f, 1.61856469e-02f, -1.46900248e-02f, -7.84965605e-02f, -9.45536718e-02f,
  -1.86396569e-01f, -7.56821334e-02f, -8.97728354e-02f, -1.12091579e-01f, -1.99733786e-02f, -8.69687647e-02f, -6.35105893e-02f, 6.59109745e-03f, -3.39725167e-02f, -1.41916096e-01f,
  -1.82528257e-01f, -8.91166627e-02f, 3.64196450e-02f, -1.51010975e-01f, -5.21458164e-02f, -8.92867744e-02f, -9.10062715e-02f, -9.85832661e-02f, -2.47425474e-02f, -9.46338847e-02f,
  -2.09327758e-04f, 3.73653807e-02f, 3.33860032e-02f, 8.38493183e-02f, -4.80651110e-03f, 3.09475008e-02f, 8.89902413e-02f, -4.40954007e-02f, 8.90441313e-02f, -6.00214154e-02f,
  1.10090837e-01f, 9.06274766e-02f, 1.28629610e-01f, 3.81913856e-02f, -4.92040664e-02f, 3.59589197e-02f, 1.51555371e-02f, 5.01241023e-03f, 7.31324553e-02f, 6.19462468e-02f,
  1.50754368e-02f, 1.33590430e-01f, 1.03825901e-03f, 2.99332403e-02f, 4.66748625e-02f, 3.18559259e-02f, 8.94605443e-02f, 8.04166198e-02f, -1.80708636e-02f, 5.31401634e-02f,
  -1.47643358e-01f, 1.14224985e-01f, -9.24319923e-02f, -9.23037156e-02f, -1.29024729e-01f, -4.29386199e-02f, -8.44210908e-02f, -2.68279035e-02f, -1.25017792e-01f, -6.72430843e-02f,
  1.50938686e-02f, -1.38283059e-01f, -5.15647568e-02f, -1.63482532e-01f, -7.03089908e-02f, -8.84635225e-02f, -1.53817147e-01f, -9.97337401e-02f, -1.63240969e-01f, -9.91196036e-02f,
  -1.60250664e-01f, 6.34776102e-03f, 1.81617178e-02f, -1.02605842e-01f, -7.94451386e-02f, -2.18241531e-02f, -7.40288943e-02f, 1.58201146e-03f, 2.02927343e-03f, -1.96618930e-01f,
  6.76389560e-02f, 9.85082909e-02f, 2.23314270e-01f, 2.53998071e-01f, 1.27032071e-01f, -4.22381796e-02f, -1.29926741e-01f, -1.76407713e-02f, 2.14937516e-02f, 2.34075822e-02f,
  1.43534616e-01f, 4.01390158e-03f, 4.51696701e-02f, -3.86401787e-02f, -7.47010261e-02f, -4.95245121e-02f, 8.68518874e-02f, -2.42931885e-03f, -1.46822989e-01f, -7.91053995e-02f,
  1.92594659e-02f, 1.09908521e-01f, 6.59788772e-02f, 6.06218912e-02f, 1.51518479e-01f, 1.22992858e-01f, 7.96073377e-02f, 1.07135631e-01f, 8.55689570e-02f, 3.44912618e-01f,
  1.48475796e-01f, 1.14093453e-01f, -7.78657645e-02f, -1.19996900e-02f, 9.55152437e-02f, -3.62588391e-02f, 3.66970599e-02f, 5.19492738e-02f, -6.33478537e-02f, 8.27868506e-02f,
  1.09614447e-01f, 6.61452487e-02f, 6.79699555e-02f, 4.40439321e-02f, -1.58134550e-02f, 1.02026783e-01f, 1.25719652e-01f, 1.04152501e-01f, -2.69050784e-02f, -1.42111173e-02f,
  2.37563271e-02f, 7.52043203e-02f, 3.90006863e-02f, 4.14819047e-02f, -4.51607071e-02f, 6.90359324e-02f, 4.74524610e-02f, 1.69177633e-02f, 1.20098433e-02f, 1.24260802e-02f,
  -1.12034835e-01f, 2.02084165e-02f, -1.12106241e-02f, -1.95531063e-02f, 1.05110817e-01f, 3.12128440e-02f, 1.06371507e-01f, -3.26655060e-02f, 3.99100184e-02f, -6.16604276e-03f,
  3.43881957e-02f, 3.96770574e-02f, 4.78235409e-02f, -9.12273228e-02f, 9.00574178e-02f, 1.00372933e-01f, 2.39551123e-02f, -5.56479320e-02f, 3.69885415e-02f, 5.93447946e-02f,
  2.29105707e-02f, 7.91017413e-02f, 9.12965164e-02f, -8.68284702e-02f, 3.77554856e-02f, 2.22459231e-02f, 1.48521469e-03f, -2.34385207e-02f, 4.95992750e-02f, 5.24123646e-02f,
  -1.54511616e-01f, -1.97325110e-01f, -7.75457770e-02f, -1.05483785e-01f, 2.43013012e-04f, 5.42305456e-03f, -8.89041170e-04f, -1.98633131e-02f, 1.19781211e-01f, 1.85525920e-02f,
  3.09325587e-02f, -1.03382550e-01f, 5.38650006e-02f, 3.70505080e-02f, 3.41291204e-02f, 4.79753874e-02f, -1.07005261e-01f, -1.04892990e-02f, -5.69166020e-02f, 5.50068589e-03f,
  5.72881252e-02f, -5.87441511e-02f, -1.73121572e-01f, -1.15839891e-01f, -3.53398360e-02f, -1.46004245e-01f, -1.54990226e-01f, -1.52576298e-01f, -7.95917585e-02f, -9.32408869e-02f,
  3.62690598e-01f, 9.84615926e-03f, 3.38713042e-02f, -3.16603743e-02f, -1.81120858e-01f, -1.79591700e-01f, -3.57526213e-01f, -2.84987874e-02f, -6.83332980e-02f, -1.45048931e-01f,
  1.79601103e-01f, 3.80682312e-02f, 1.42902851e-01f, 1.29545890e-02f, 1.33706197e-01f, -2.93780893e-01f, -2.50999093e-01f, 5.97515441e-02f, -4.24422398e-02f, -1.85127556e-01f,
  -2.18184456e-01f, 1.91004798e-02f, 2.19836339e-01f, 7.62063563e-02f, -1.55649722e-01f, 1.08696870e-04f, -5.85121028e-02f, 3.50221395e-02f, -9.77136642e-02f, -1.25396237e-01f,
  -1.25078887e-01f, 7.96621591e-02f, -2.70604223e-01f, -1.16050266e-01f, -4.88189161e-02f, -1.16560487e-02f, -8.73556063e-02f, -5.98541945e-02f, -4.94561791e-02f, -1.41495675e-01f,
  4.09822352e-02f, -1.01291686e-01f, -1.70700904e-02f, -1.13795914e-01f, -1.14966936e-01f, -6.51135519e-02f, -6.09486923e-02f, 1.35329328e-02f, 8.68860632e-02f, 7.46856853e-02f,
  -3.75915319e-02f, -4.14886102e-02f, 3.09982635e-02f, -9.55075994e-02f, 9.25030559e-02f, 2.55396534e-02f, 6.68557510e-02f, 5.64191826e-02f, 1.62668712e-02f, -5.75206243e-03f,
  -4.62452993e-02f, 6.61960244e-02f, 1.03472844e-01f, 3.85729074e-02f, 2.30107568e-02f, 6.66744635e-02f, 8.83148517e-03f, 3.23284455e-02f, 3.41856643e-03f, 1.33760991e-02f,
  9.31105316e-02f, 1.08907871e-01f, 1.18333533e-01f, -1.56771652e-02f, 5.27776405e-02f, 9.39907953e-02f, 1.20477051e-01f, 8.57061446e-02f, 6.89666569e-02f, 4.56898883e-02f,
  4.88819070e-02f, 1.24584243e-01f, 5.44313900e-02f, 3.67291570e-02f, 1.59374982e-01f, 8.64469558e-02f, 8.64672214e-02f, 1.00372873e-01f, 1.08053148e-01f, 4.38306369e-02f,
  -1.80680826e-01f, 3.57970297e-02f, -2.24664509e-01f, -3.07305828e-02f, -1.61553010e-01f, -1.30976439e-02f, -1.51314020e-01f, -1.32225454e-01f, 4.95313434e-03f, -1.61242962e-01f,
  -1.11443162e-01f, 4.20891121e-02f, -5.03228642e-02f, -4.46082428e-02f, -9.88713801e-02f, -1.55050606e-01f, -1.16631821e-01f, 5.86889568e-04f, -1.26166597e-01f, -1.08477429e-01f,
  -5.97921573e-02f, -1.98921770e-01f, -1.77142128e-01f, -2.33873233e-01f, -1.70323804e-01f, -9.53406915e-02f, -2.27623820e-01f, -1.26648471e-01f, -2.03394860e-01f, -3.55101407e-01f,
  -3.02437216e-01f, 3.12614560e-01f, 8.01863372e-02f, -9.34676751e-02f, -1.10780515e-01f, 9.37697366e-02f, 2.97538251e-01f, 2.08716795e-01f, -4.41211313e-02f, 9.75015536e-02f,
  -1.96403917e-02f, -2.63954729e-01f, -5.52371182e-02f, 4.16677855e-02f, 1.84059590e-01f, 3.31983447e-01f, 2.30686620e-01f, -1.46975800e-01f, -2.65186846e-01f, -1.53250605e-01f,
  -5.95606416e-02f, -3.79884876e-02f, -3.85420769e-02f, 6.01440072e-02f, -8.40452239e-02f, -1.10620381e-02f, 2.17668742e-01f, -5.23076802e-02f, 5.19424230e-02f, 5.76045699e-02f,
  -1.36542261e-01f, 7.45574757e-02f, -9.60147083e-02f, 8.64488930e-02f, 8.10434297e-02f, 5.03426641e-02f, 6.90555125e-02f, 3.52645479e-02f, 9.40863416e-02f, 8.12219381e-02f,
  -1.31153080e-04f, 1.05113730e-01f, 3.91278751e-02f, 3.71778617e-03f, -2.14117412e-02f, -7.81387463e-03f, 2.03963399e-01f, 9.17987153e-02f, 1.32067904e-01f, 9.40848365e-02f,
  6.43960983e-02f, 8.81744549e-02f, 4.32888903e-02f, 6.59654215e-02f, 9.20510069e-02f, -2.00169329e-02f, 1.65973917e-01f, 1.18105263e-01f, 1.94793701e-01f, 4.93372269e-02f,
  -1.88090503e-02f, -9.87367108e-02f, -8.65096599e-02f, -1.04821250e-01f, -1.05046928e-01f, -1.20711900e-01f, -6.40549362e-02f, -1.09342910e-01f, -1.19894043e-01f, -5.99535443e-02f,
  -1.14866503e-01f, -2.19941456e-02f, -1.23220883e-01f, -4.41222265e-02f, -1.80231571e-01f, -1.14642799e-01f, -1.79508850e-01f, -3.91689055e-02f, -6.46745786e-02f, -2.22398695e-02f,
  -1.56985641e-01f, -1.29180893e-01f, -7.56902099e-02f, -6.20346367e-02f, -1.50600702e-01f, -1.12585269e-01f, -1.18292190e-01f, -9.43035483e-02f, -1.38286799e-01f, -1.82692930e-01f,
  6.37892932e-02f, 2.95679420e-01f, -9.54795629e-02f, 6.60894886e-02f, -3.02302360e-04f, 2.72143036e-02f, -3.67172658e-02f, 2.91171689e-02f, 2.58603832e-03f, 3.89986001e-02f,
  3.89920175e-02f, 3.11855227e-02f, 7.61427078e-03f, 1.09314576e-01f, 3.03524472e-02f, 8.34601223e-02f, 8.60273391e-02f, 3.05923074e-02f, 9.04595107e-02f, -4.23540501e-03f,
  6.53036386e-02f, 6.76441789e-02f, -6.06416054e-02f, 1.36556670e-01f, -6.23362279e-03f, -1.53491601e-01f, 3.23929265e-02f, -1.65976435e-02f, -2.48225965e-02f, 1.32058293e-01f,
  2.50991821e-01f, -8.35269764e-02f, -4.93476577e-02f, -1.08762972e-01f, 4.67086248e-02f, 1.11795768e-01f, 2.49667957e-01f, 9.49827582e-02f, 6.46230876e-02f, -1.93192791e-02f,
  4.32862006e-02f, -2.62484550e-02f, -1.18525848e-01f, -1.02186695e-01f, 2.16164012e-02f, -5.88243175e-03f, -4.72669080e-02f, -1.19398173e-03f, 7.18566328e-02f, 1.64679170e-01f,
  1.57097995e-01f, 1.78929269e-01f, 9.53941196e-02f, 2.41384888e-03f, 1.54484361e-01f, 2.39108372e-02f, -3.99211831e-02f, 5.87847382e-02f, 1.06644250e-01f, -1.97820440e-02f,
  -8.94680396e-02f, 7.69781023e-02f, -7.98644871e-02f, 4.27057967e-02f, -1.56338178e-02f, -3.32089737e-02f, 1.20865889e-02f, -6.15531765e-02f, -2.38377787e-03f, 2.49550864e-02f,
  2.25391611e-02f, 7.19452128e-02f, -5.04900478e-02f, -2.85266287e-04f, 1.03552379e-02f, 7.49818981e-02f, 5.29441051e-03f, -5.32681905e-02f, -9.25292447e-02f, 3.49074751e-02f,
  7.11016953e-02f, 3.49601060e-02f, 8.89305323e-02f, -6.92388266e-02f, -6.29717950e-03f, 9.76496488e-02f, 8.14469252e-03f, 1.33742109e-01f, 1.37419388e-01f, 8.87588784e-02f,
  -6.18398823e-02f, -1.31912723e-01f, 2.87563484e-02f, 2.67027523e-02f, 4.03072163e-02f, -6.37795255e-02f, -2.22034119e-02f, -7.76278004e-02f, 5.81341721e-02f, 3.42086740e-02f,
  -1.40199944e-01f, -3.26078781e-03f, -2.29851939e-02f, -3.90452966e-02f, -7.20928982e-02f, -5.44973165e-02f, -3.61090200e-03f, 8.12590942e-02f, -3.67401876e-02f, -2.34327409e-02f,
  -4.95287180e-02f, -6.32641697e-03f, -7.59592205e-02f, -1.60881691e-02f, 3.67332660e-02f, -1.22455768e-01f, 8.14485773e-02f, 4.48492020e-02f, 1.62081588e-02f, 6.24770857e-02f,
  6.66586822e-03f, 9.55234617e-02f, 6.27002120e-02f, -6.37141690e-02f, 1.12919219e-01f, 4.48078774e-02f, 2.09459197e-02f, 3.95089276e-02f, -5.54074682e-02f, -8.38693511e-03f,
  7.36669227e-02f, 4.64646295e-02f, -1.27551571e-01f, -3.17577906e-02f, 1.21204004e-01f, 4.14182842e-02f, -6.79735094e-03f, -6.97065219e-02f, 3.36875506e-02f, -2.56715473e-02f,
  -9.41538885e-02f, 8.90234262e-02f, 1.65218711e-01f, 1.25591401e-02f, -1.37875192e-02f, -5.73062077e-02f, 2.11124178e-02f, 1.62853673e-01f, 1.50460199e-01f, 5.18898591e-02f,
  -2.29260400e-01f, -1.13202319e-01f, 2.12804556e-01f, 2.31975466e-02f, 2.60403931e-01f, 4.31952894e-01f, 1.54665366e-01f, 2.05585375e-01f, 7.27424771e-02f, 6.52409121e-02f,
  2.05933526e-01f, 2.84633815e-01f, 1.31777599e-01f, 1.55587539e-01f, 8.66899714e-02f, 1.46075964e-01f, -1.63847618e-02f, 1.37675554e-01f, 2.58472949e-01f, 1.24263100e-01f,
  5.07645197e-02f, -4.54466715e-02f, 9.00147296e-03f, -2.60258168e-02f, -1.74227968e-01f, -6.96187690e-02f, -3.73046799e-03f, -4.25173603e-02f, -1.57638788e-02f, -7.60461465e-02f,
  2.20760077e-01f, -2.15059653e-01f, -7.71583198e-03f, -8.15966725e-02f, 4.81895208e-02f, -7.16805905e-02f, -1.80839784e-02f, -8.04624185e-02f, 1.15673421e-02f, -3.24234329e-02f,
  6.00049198e-02f, 4.06286567e-02f, 4.98603173e-02f, 3.51444557e-02f, -4.88030650e-02f, 3.90573889e-02f, -1.08206309e-01f, 1.64847821e-02f, 9.15735066e-02f, 1.29387632e-01f,
  2.47813035e-02f, 9.39529091e-02f, 5.68737797e-02f, 1.16735473e-01f, 7.19475076e-02f, 6.48592561e-02f, 1.08787514e-01f, -5.31360246e-02f, 8.80847201e-02f, -1.57424957e-01f,
  -9.28153321e-02f, -7.20135719e-02f, -3.83353326e-03f, -8.60823318e-03f, 7.56295174e-02f, 7.30400458e-02f, -2.89220810e-02f, -6.58084154e-02f, 5.71958050e-02f, -4.83999215e-02f,
  -3.34996323e-04f, 8.36562067e-02f, -1.87412999e-03f, -1.47729041e-02f, 9.23777521e-02f, 6.75158054e-02f, -1.26566058e-02f, 1.43538881e-02f, -5.20553291e-02f, -2.38127895e-02f,
  2.51424126e-02f, 1.28239701e-02f, -8.88781808e-03f, 1.86769422e-02f, 8.44614208e-02f, -1.87875014e-02f, 1.63490267e-03f, 8.40124488e-02f, -2.08318327e-02f, 2.91648246e-02f,
  1.11244991e-01f, 8.78467932e-02f, -3.05735227e-02f, -6.58867285e-02f, 9.82396118e-03f, 6.20822422e-02f, 3.43246572e-02f, -1.48406881e-03f, 5.15005514e-02f, -4.44801152e-02f,
  1.12620458e-01f, 2.08170107e-03f, 4.40935120e-02f, 2.59597823e-02f, 1.39027759e-01f, 5.36567830e-02f, -3.76337320e-02f, 6.23006746e-02f, 4.18727547e-02f, 2.69807484e-02f,
  3.06925420e-02f, 1.51729524e-01f, 7.13176578e-02f, 1.49764314e-01f, 1.39706570e-03f, 1.73197299e-01f, 1.46810532e-01f, 7.40068927e-02f, 2.16176897e-01f, 2.53793355e-02f,
  -2.79967636e-02f, -8.58014897e-02f, -2.62037575e-01f, -3.83485518e-02f, -3.61015052e-02f, -1.18709221e-01f, -2.59222001e-01f, -1.03957601e-01f, -2.90988619e-03f, -4.36693095e-02f,
  -6.89702155e-03f, 1.09899297e-01f, -2.56503373e-02f, -1.51512921e-01f, -1.73372746e-01f, -2.25563958e-01f, -2.43696839e-01f, -3.11558098e-01f, -2.19186634e-01f, -1.15213387e-01f,
  2.28855177e-03f, -1.31887808e-01f, -2.17474610e-01f, -1.87237397e-01f, -1.23698041e-01f, -2.27133811e-01f, -2.88272113e-01f, -2.61999249e-01f, -2.34607667e-01f, -1.68039948e-01f,
  4.90825772e-02f, -1.19183756e-01f, -2.13806525e-01f, -1.22247212e-01f, -1.09479986e-01f, -4.20665890e-02f, -7.83084482e-02f, -1.70272335e-01f, -7.73465410e-02f, -1.41793683e-01f,
  -1.01097316e-01f, 1.06839361e-02f, -9.39776301e-02f, -3.41109373e-02f, -1.57036856e-01f, -1.72926381e-01f, -2.24879175e-01f, -2.07254559e-01f, -2.49578044e-01f, -1.78449348e-01f,
  -1.13823847e-03f, -1.01476096e-01f, -2.41321564e-01f, -2.68836707e-01f, -1.69693083e-01f, -1.85530320e-01f, -1.83566198e-01f, -2.38317162e-01f, -1.58263370e-01f, -2.60394961e-01f,
  9.04292390e-02f, 8.68499577e-02f, 1.82233900e-01f, 1.76100865e-01f, 8.78689140e-02f, 1.64099619e-01f, 1.56954676e-01f, 6.99360892e-02f, 1.73850611e-01f, 1.01111263e-01f,
  1.43625215e-01f, 1.03597075e-01f, 1.53090566e-01f, 2.89878286e-02f, 1.66982204e-01f, 8.67970884e-02f, 8.21114182e-02f, 3.85032557e-02f, -3.46747003e-02f, 4.54962477e-02f,
  4.99742329e-02f, 1.48213968e-01f, 9.50047076e-02f, 1.02181070e-01f, 4.36821617e-02f, 7.97595307e-02f, 2.39609644e-01f, 1.30642995e-01f, 9.10294652e-02f, 1.33733854e-01f,
  1.64151222e-01f, -3.31277549e-01f, -1.91128641e-01f, -1.61579505e-01f, -1.59951597e-01f, -1.96717322e-01f, -1.27621680e-01f, -1.69576153e-01f, -2.21005931e-01f, -1.41994521e-01f,
  -2.10801125e-01f, -1.49762109e-01f, -1.55837968e-01f, -1.67911470e-01f, -6.07594885e-02f, -2.40308344e-01f, -1.98178485e-01f, -2.63094038e-01f, -2.58260757e-01f, -1.65540427e-01f,
  -2.44836643e-01f, -1.05457276e-01f, -1.55022353e-01f, -2.10330278e-01f, -3.05253536e-01f, -2.21131727e-01f, -1.79777950e-01f, -2.30247498e-01f, -2.27289066e-01f, -2.17840865e-01f,
  -8.71143267e-02f, 2.51284726e-02f, -1.20436646e-01f, 9.75531933e-04f, 3.10160307e-04f, -2.22429946e-01f, -2.01803908e-01f, -8.13475028e-02f, -3.21227610e-02f, -7.35879168e-02f,
  -1.87034518e-01f, -6.76036403e-02f, 4.51653963e-03f, -3.55070531e-02f, -1.43004864e-01f, 8.58698934e-02f, 1.02106504e-01f, -4.30771336e-02f, -1.74713731e-02f, -3.43010910e-02f,
  1.71478361e-01f, 1.74336478e-01f, 1.56238757e-03f, 4.54786932e-03f, 1.56203449e-01f, 7.74622336e-02f, 3.87921743e-02f, 2.65080612e-02f, -9.93572846e-02f, 2.48799920e-01f,
  1.57260090e-01f, -5.48241995e-02f, -3.52199213e-03f, -5.35312481e-02f, -3.27832438e-02f, 2.70508584e-02f, -7.85433277e-02f, 8.05145968e-03f, -8.61095358e-03f, -4.71322946e-02f,
  -6.51020110e-02f, -9.76517331e-03f, -6.57921582e-02f, 7.98432529e-02f, 8.03938042e-03f, -1.66742261e-02f, -6.79749325e-02f, 1.45544857e-02f, -1.76316090e-02f, -1.56296510e-02f,
  -2.18903963e-02f, -9.55694467e-02f, -9.25743878e-02f, -3.74871567e-02f, -9.66303796e-02f, -1.16012461e-01f, 4.53564599e-02f, 1.65786054e-02f, -1.34165391e-01f, 9.88425314e-02f,
  -2.27786414e-02f, 8.89673736e-03f, -1.11931324e-01f, 6.03238493e-02f, -2.16802768e-02f, -6.61979169e-02f, 6.99520558e-02f, -3.67680788e-02f, -1.36910174e-02f, 9.15098935e-02f,
  3.04430560e-03f, -3.07747796e-02f, -9.21154767e-02f, -3.83709036e-02f, 5.05995452e-02f, -3.37896720e-02f, -6.25918340e-03f, -3.49063314e-02f, -2.71098651e-02f, -8.38523656e-02f,
  -1.86875798e-02f, -6.05294146e-02f, -2.95088021e-03f, 1.01694725e-01f, -1.84262581e-02f, 1.63773575e-03f, 5.86855076e-02f, -7.69604594e-06f, 3.50798331e-02f, -9.25450996e-02f,
  1.65870801e-01f, -3.19611639e-01f, 8.58518705e-02f, 2.60713287e-02f, 9.63697731e-02f, -3.87561359e-02f, 8.62492323e-02f, 1.93795078e-02f, -1.01676984e-02f, 4.64998186e-02f,
  6.62286580e-02f, 2.69503333e-02f, 2.36194325e-03f, -3.46467793e-02f, 5.90051748e-02f, 1.72923841e-02f, 8.57623369e-02f, -4.09236029e-02f, -3.32324356e-02f, 9.46211740e-02f,
  1.56138036e-02f, -2.72211507e-02f, -5.73429577e-02f, 7.42742512e-03f, -3.20142098e-02f, -1.42858490e-01f, 5.52433915e-02f, -3.37239318e-02f, -1.14054166e-01f, 1.25714585e-01f,
  9.24893282e-03f, -2.76484311e-01f, -1.57503754e-01f, -2.36653343e-01f, -1.80115759e-01f, -1.97582901e-01f, -2.35328481e-01f, -1.24496788e-01f, -2.89904047e-02f, -1.58540070e-01f,
  -2.25273967e-01f, 7.90323596e-03f, -1.38884172e-01f, -5.00600114e-02f, -1.71043694e-01f, -2.99119085e-01f, -1.75650746e-01f, 2.94524077e-02f, -4.17850949e-02f, -6.29108101e-02f,
  -1.72555953e-01f, -1.30567595e-01f, 3.63779142e-02f, -5.39093353e-02f, -7.21187294e-02f, -8.35100189e-02f, 8.36159289e-03f, 1.22000175e-02f, 1.64355896e-02f, -1.47846013e-01f,
  -4.17712063e-01f, -7.86986873e-02f, 2.18028631e-02f, -2.65592020e-02f, -4.89147678e-02f, -9.29122418e-02f, -8.74109194e-02f, -5.63218631e-02f, -1.13347925e-01f, -5.32545410e-02f,
  -9.36508775e-02f, -1.05390392e-01f, -1.65346906e-01f, -2.13966109e-02f, -4.96819727e-02f, -1.39224812e-01f, 6.99742883e-03f, -5.88476025e-02f, 6.60616253e-03f, -1.64401904e-01f,
  -4.53880951e-02f, -3.88905965e-02f, -9.05156950e-04f, -8.07522088e-02f, -7.17759430e-02f, -3.81959602e-02f, -9.24058165e-03f, -1.13701224e-01f, 7.93960392e-02f, -2.36636195e-02f,
  5.55613600e-02f, 9.08263996e-02f, 1.08104862e-01f, 1.20295368e-01f, 1.12015352e-01f, 6.35132492e-02f, -7.89874420e-03f, 6.63457438e-03f, 8.07341486e-02f, 6.35413826e-02f,
  3.17054205e-02f, 1.04964547e-01f, 8.21289122e-02f, -2.09855810e-02f, -9.16995294e-03f, 8.09610263e-02f, 5.26109673e-02f, -1.82837304e-02f, 1.73093565e-02f, 7.00469241e-02f,
  1.04267880e-01f, 2.09517442e-02f, 8.68784189e-02f, 8.98983106e-02f, 9.93914232e-02f, 6.17420636e-02f, 2.86398940e-02f, 9.21084080e-03f, 6.16907366e-02f, 2.06444673e-02f,
  -1.61625713e-01f, 1.58306867e-01f, -2.51291804e-02f, -4.16811816e-02f, -7.98365250e-02f, 2.03450434e-02f, -1.16354953e-02f, 2.93545872e-02f, 2.73462348e-02f, -1.14527419e-01f,
  -9.76698995e-02f, -6.66285157e-02f, -5.08848764e-02f, 2.04782318e-02f, 2.91686766e-02f, -3.87493409e-02f, -1.00734368e-01f, -2.98954435e-02f, 5.53940199e-02f, -7.46063814e-02f,
  -2.04523653e-02f, -3.76014598e-02f, -9.38671753e-02f, 9.16139707e-02f, 6.92975819e-02f, 2.79025305e-02f, -3.46695371e-02f, -1.39155239e-02f, -8.60269889e-02f, -1.17963418e-01f,
  2.41280377e-01f, 1.93489924e-01f, 2.52945244e-01f, 3.48388910e-01f, 2.41381630e-01f, 2.37134606e-01f, 1.83205023e-01f, 2.73924675e-02f, 1.15749851e-01f, 1.79090485e-01f,
  1.27887785e-01f, 4.78607118e-02f, -4.46525849e-02f, -1.04828589e-01f, 3.14342342e-02f, 2.03503147e-01f, 2.06298307e-01f, 5.71432374e-02f, 5.33549972e-02f, 4.26960783e-03f,
  1.60143569e-01f, 5.89488670e-02f, 1.18066957e-02f, 1.29956663e-01f, 1.37671322e-01f, 5.02057746e-02f, 1.20766543e-01f, 1.76813677e-01f, -3.74232605e-03f, 1.55791357e-01f,
  2.32752383e-01f, 4.55828905e-02f, -9.93285775e-02f, -8.40762630e-03f, 1.36241876e-02f, -4.46931608e-02f, 4.16292101e-02f, -1.24840833e-01f, -4.95972894e-02f, 9.14718658e-02f,
  -5.39505258e-02f, 1.02737115e-03f, 3.61304581e-02f, 4.16821055e-03f, -2.84259189e-02f, 4.38318923e-02f, -2.66268086e-02f, -4.60094362e-02f, -7.62150511e-02f, 2.49257348e-02f,
  -1.14303536e-03f, -6.12686351e-02f, 2.67700162e-02f, -9.46569592e-02f, 1.61984097e-02f, 2.32975241e-02f, -6.43246993e-02f, 6.88078031e-02f, -8.01148415e-02f, 1.18194535e-01f,
  7.88524970e-02f, 3.61338183e-02f, -1.62890367e-02f, -7.59056881e-02f, -1.39288664e-01f, -3.66344452e-02f, -1.98520459e-02f, 2.02163830e-02f, -2.24716049e-02f, -2.03382317e-02f,
  -5.73256649e-02f, 6.95767850e-02f, -3.65723576e-03f, -2.31137276e-02f, 7.11261183e-02f, -4.41832207e-02f, 1.81807838e-02f, -2.58197598e-02f, -1.24510810e-01f, -1.17545396e-01f,
  -2.11118422e-02f, 4.09515873e-02f, -3.18011828e-02f, -5.05839065e-02f, 3.61143202e-02f, 4.22153547e-02f, 5.80673851e-02f, -1.40873000e-01f, 2.37866882e-02f, -1.55889057e-02f,
  1.01360613e-02f, -1.75731719e-01f, 7.02020749e-02f, -1.34961501e-01f, 9.41269547e-02f, 3.81121002e-02f, 1.17828995e-01f, -7.90593401e-02f, 4.65261824e-02f, 6.29365444e-02f,
  -4.18397970e-02f, 2.17565894e-02f, 2.72591989e-02f, -9.71150992e-04f, -1.74509473e-02f, -6.85971007e-02f, 3.41390930e-02f, 8.08177218e-02f, -8.02901760e-02f, 1.33012619e-03f,
  7.19492435e-02f, 8.63363687e-03f, -1.78512037e-02f, 4.17260975e-02f, -1.71723799e-03f, -8.80740657e-02f, -3.77454609e-02f, 5.25422627e-04f, -8.20757151e-02f, -4.29109037e-02f,
  -3.00931096e-01f, 3.56630087e-02f, -2.64255375e-01f, 2.14201175e-02f, -3.66339023e-04f, -1.62592992e-01f, -2.98199087e-01f, -1.16332561e-01f, 3.23488526e-02f, 1.51425023e-02f,
  1.16705766e-03f, 7.10714459e-02f, 1.96284652e-02f, -6.64504692e-02f, -1.72709286e-01f, -2.22942233e-01f, -1.78129643e-01f, -3.66692901e-01f, -3.27429324e-01f, -2.61387795e-01f,
  -5.04302122e-02f, -1.07725061e-01f, -1.58633471e-01f, -1.07585274e-01f, -1.48057818e-01f, -3.91045809e-02f, -1.21745214e-01f, -1.35655642e-01f, -2.85646677e-01f, -1.42656684e-01f,
  -3.25122833e-01f, -1.99878350e-01f, -1.34667501e-01f, -3.67258452e-02f, -1.10481150e-01f, -1.16804615e-01f, -9.26793814e-02f, -1.09721631e-01f, -1.39779329e-01f, -9.04174075e-02f,
  -7.80762136e-02f, -3.22445631e-02f, -6.37923703e-02f, -1.77306440e-02f, -1.65268674e-01f, -1.87725678e-01f, -1.09540284e-01f, -1.22629158e-01f, -2.04530135e-01f, -1.09319746e-01f,
  4.56315428e-02f, -9.14473906e-02f, -1.46247506e-01f, -2.26988450e-01f, -1.63564429e-01f, -8.71635675e-02f, -1.82694882e-01f, -2.85478890e-01f, -2.28571460e-01f, -2.40501270e-01f,
  5.96560165e-02f, 3.18035670e-02f, 3.57330739e-02f, 6.59432933e-02f, 1.73059329e-02f, 6.46175668e-02f, 5.98536767e-02f, 1.05231786e-02f, 2.49089543e-02f, -3.26180160e-02f,
  -1.63376126e-02f, 9.80670303e-02f, -4.94445562e-02f, -2.03524902e-02f, 8.00130293e-02f, -9.58504006e-02f, -6.49634525e-02f, 9.60181281e-02f, -9.52493399e-03f, 5.37479520e-02f,
  7.99500123e-02f, 5.58900163e-02f, 7.32855648e-02f, 2.20663147e-03f, -4.74044234e-02f, -7.26271719e-02f, 1.34774605e-02f, 7.26542845e-02f, -2.92808935e-02f, 9.46563017e-03f,
  2.41054520e-02f, 4.19521192e-03f, -3.05750147e-02f, -1.34673312e-01f, -5.25465198e-02f, -1.05638886e-02f, -7.54441395e-02f, -4.35745157e-02f, 6.17383327e-03f, -1.68649375e-01f,
  -6.35539070e-02f, -9.61035267e-02f, -4.39724289e-02f, -6.88578561e-02f, -1.30818456e-01f, -1.38531864e-01f, 5.96766076e-05f, -6.95906505e-02f, -1.18085794e-01f, -1.36588007e-01f,
  -2.26434208e-02f, -9.63516235e-02f, -1.22357607e-01f, -1.42039657e-01f, -9.23463777e-02f, -1.83071539e-01f, -1.00256942e-01f, -2.52912790e-01f, -2.84701526e-01f, -2.42241099e-01f,
  1.92711931e-02f, -9.89312753e-02f, -1.19511522e-01f, 1.38851330e-01f, 1.49120614e-01f, 1.36414662e-01f, 1.72160804e-01f, 4.04033102e-02f, 2.60374751e-02f, 3.48877423e-02f,
  -1.80297508e-03f, -8.70930478e-02f, -1.71917677e-01f, 1.36744101e-02f, -1.26518518e-01f, -8.73984322e-02f, 3.06381527e-02f, -6.38713464e-02f, 5.74045181e-02f, 9.03061926e-02f,
  2.27498740e-01f, 1.01668455e-01f, -3.47630009e-02f, -8.67680162e-02f, 6.15421333e-04f, 1.64215397e-02f, -1.98365487e-02f, 8.23498517e-03f, -1.08764681e-03f, -3.64980333e-05f,
  -2.22119257e-01f, -9.55208018e-02f, 5.43465167e-02f, 8.22808295e-02f, -2.67435852e-02f, -9.92573276e-02f, -8.40893760e-02f, -1.06741071e-01f, 2.59047672e-02f, -2.64040530e-02f,
  5.27212806e-02f, 3.24153565e-02f, -1.11522719e-01f, -6.49960861e-02f, -1.41186565e-02f, -2.35898551e-02f, -2.91662402e-02f, -4.16878276e-02f, -1.01424553e-01f, -2.77697910e-02f,
  2.27512373e-03f, 1.41209215e-01f, -9.68878740e-04f, -8.77020210e-02f, -7.74729401e-02f, 1.27881328e-02f, -1.31277055e-01f, -1.05351694e-01f, -7.98145309e-02f, -7.84196407e-02f,
  -7.75482040e-04f, 5.15866876e-02f, 3.11795082e-02f, 1.20236769e-01f, 9.56833586e-02f, 1.22893257e-02f, -1.00612519e-02f, 6.32822141e-02f, 1.12372436e-01f, -2.83428803e-02f,
  1.05811067e-01f, 7.75808189e-03f, 7.48785809e-02f, 3.09463758e-02f, 6.58296049e-02f, 9.77485813e-03f, -1.42275693e-03f, 2.50542257e-02f, 1.40391160e-02f, 1.01658233e-01f,
  8.49359110e-02f, 1.19814068e-01f, -1.79730989e-02f, -1.68402365e-03f, 1.18865939e-02f, 5.56538962e-02f, 7.37371072e-02f, 6.89150989e-02f, 4.78315353e-02f, 1.16587244e-01f,
  -1.49242893e-01f, -3.74217667e-02f, -6.93353415e-02f, -4.02950607e-02f, -9.73921549e-03f, -9.84291956e-02f, -2.38822773e-02f, 3.71179869e-03f, -9.99845788e-02f, -1.32493168e-01f,
  -1.41021414e-02f, -6.79587647e-02f, -5.12842238e-02f, -3.58834602e-02f, 4.31931466e-02f, 4.05377373e-02f, -4.60441522e-02f, -7.36826062e-02f, 2.48187482e-02f, 4.76611257e-02f,
  5.92811443e-02f, -9.77191050e-03f, -5.48195504e-02f, -1.96413860e-01f, -2.41008829e-02f, -1.19511731e-01f, -2.11117849e-01f, -1.39382064e-01f, -1.74297422e-01f, -6.47111088e-02f,
  -3.06619734e-01f, 3.44659984e-01f, 2.72048980e-01f, -3.97105813e-02f, 1.51562318e-01f, -2.60723978e-02f, -2.81746592e-03f, -6.87085986e-02f, 2.78910585e-02f, 1.80150688e-01f,
  3.31997335e-01f, 2.56019741e-01f, 1.83009088e-01f, 9.59050730e-02f, 1.69862639e-02f, 1.07051536e-01f, -1.06676050e-01f, -1.10714898e-01f, -1.29028916e-01f, -1.24111913e-01f,
  -2.52591707e-02f, -6.94644377e-02f, -1.33275956e-01f, -5.27999215e-02f, -1.86178461e-02f, 7.35998666e-03f, 9.50075015e-02f, 1.04504153e-01f, 1.04009800e-01f, 1.98375806e-02f,
  1.76744908e-01f, 1.46632761e-01f, -3.45418938e-02f, 6.27778396e-02f, 9.67857838e-02f, 1.00244274e-02f, 3.93299870e-02f, 1.40946776e-01f, 7.34580606e-02f, 6.41615549e-03f,
  1.10577948e-01f, 6.26722500e-02f, 6.35379478e-02f, 1.49010748e-01f, 1.10230610e-01f, 7.90565386e-02f, 9.82326940e-02f, 1.14239737e-01f, 6.59486651e-02f, 1.57245800e-01f,
  1.76660493e-01f, 1.54102743e-01f, 1.70895129e-01f, 1.22066019e-02f, 3.55689833e-03f, -3.10113691e-02f, 6.85111657e-02f, -2.32987031e-02f, -7.73186609e-02f, -6.72764033e-02f,
  -1.00823931e-01f, -5.44551313e-02f, -4.11307253e-02f, -1.55245215e-01f, -1.07013315e-01f, -7.74537101e-02f, -4.15418036e-02f, -1.74348969e-02f, -1.78601965e-01f, 1.85416583e-02f,
  -5.43110631e-02f, -5.95813543e-02f, -5.80660217e-02f, -6.14060350e-02f, -7.14498013e-02f, -3.23558040e-02f, -8.37723315e-02f, -4.55710553e-02f, -3.11419126e-02f, 2.60195392e-03f,
  -4.51635942e-02f, -4.21860553e-02f, 1.35048814e-02f, 2.85015181e-02f, -7.59792775e-02f, -8.17631558e-02f, -7.20103234e-02f, -5.96910454e-02f, -4.53119539e-03f, -5.93416020e-02f,
  2.33542576e-01f, 2.01666906e-01f, 8.35398138e-02f, -3.37042497e-03f, 1.46736726e-01f, 1.70543671e-01f, 1.76414400e-01f, 1.68857694e-01f, 1.55271798e-01f, 1.85652599e-02f,
  1.13457873e-01f, 7.10304454e-02f, 1.24000825e-01f, 4.79109176e-02f, 7.66896605e-02f, 1.20741718e-01f, 9.09082368e-02f, 1.08827487e-01f, 6.58725351e-02f, 1.80296764e-01f,
  4.14221399e-02f, -3.32949609e-02f, 8.31583962e-02f, 1.31613225e-01f, -4.76244129e-02f, -3.69154699e-02f, 1.41801789e-01f, 5.97298555e-02f, -7.87158087e-02f, -1.88944995e-01f,
  2.12212026e-01f, -1.00984581e-01f, -2.11537480e-01f, -6.27053007e-02f, -2.55160749e-01f, -3.94725651e-01f, -3.63412976e-01f, -2.21778050e-01f, -2.16613561e-01f, -1.61378279e-01f,
  -3.82862240e-02f, 9.34522822e-02f, 4.56730537e-02f, 6.58452436e-02f, -2.77347048e-03f, -1.37158066e-01f, -2.55167782e-01f, 1.04138546e-01f, 1.21340103e-01f, -7.11424798e-02f,
  5.24813607e-02f, 3.60154659e-02f, 9.08796117e-02f, 1.71009265e-03f, -1.51350588e-01f, 7.52595216e-02f, -7.93966874e-02f, -1.28258437e-01f, -6.78226426e-02f, 7.17100427e-02f,
  2.05013990e-01f, -1.99092939e-01f, -1.25787437e-01f, -7.66417757e-02f, -1.30223513e-01f, -1.56667411e-01f, -8.06987807e-02f, -1.31015718e-01f, -1.14961550e-01f, -1.84311867e-01f,
  -7.72586837e-02f, -1.31825283e-01f, -1.08528100e-01f, -3.16095203e-02f, -6.69967383e-02f, -1.16981976e-01f, -4.08937894e-02f, -1.37977704e-01f, -1.59513831e-01f, -1.81055129e-01f,
  -1.03855304e-01f, -1.33834019e-01f, -2.80852407e-01f, -2.74053901e-01f, -2.01441124e-01f, -9.22204331e-02f, -1.10369198e-01f, -1.33979067e-01f, -1.12405658e-01f, -6.69481233e-02f,
  -1.49772435e-01f, 9.84274447e-02f, 1.35604098e-01f, 1.51537567e-01f, 1.44329906e-01f, 1.43543392e-01f, 1.15056843e-01f, 1.24707662e-01f, 1.34772182e-01f, 1.28459036e-01f,
  2.21807227e-01f, 1.01143643e-01f, 1.83320537e-01f, 1.48621157e-01f, 2.25197271e-01f, 1.80873051e-01f, 1.65995672e-01f, 1.83685243e-01f, 2.69002289e-01f, 2.07282335e-01f,
  1.38236091e-01f, 2.01024100e-01f, 1.51160166e-01f, 2.22076133e-01f, 8.75078738e-02f, 2.10003614e-01f, 1.87100321e-01f, 1.93663880e-01f, 1.12802371e-01f, 1.69247091e-01f,
  -3.05935759e-02f, -1.69984475e-01f, -8.41515735e-02f, -5.45641333e-02f, -9.92479324e-02f, -1.39444828e-01f, -9.75116789e-02f, -8.01246464e-02f, -1.35494292e-01f, -9.89739597e-02f,
  -6.81115612e-02f, -1.20624326e-01f, -9.79385003e-02f, -1.70378998e-01f, -8.87944996e-02f, -1.89778924e-01f, -1.12169340e-01f, -7.35766664e-02f, -1.30795181e-01f, -7.86772147e-02f,
  -1.68326095e-01f, -1.10790789e-01f, -1.00602254e-01f, -1.94479749e-01f, -9.89196524e-02f, -4.66254093e-02f, -1.42026126e-01f, -1.39144003e-01f, -2.44150519e-01f, -1.54391930e-01f,
  -5.80824375e-01f, 1.42958969e-01f, 3.06832403e-01f, -1.05328798e-01f, 1.59165278e-01f, 3.58408660e-01f, 3.49823713e-01f, 1.35259563e-02f, -6.10647723e-02f, -5.60918301e-02f,
  -8.09224620e-02f, -2.05068827e-01f, -2.20752567e-01f, -1.31189525e-01f, 4.47402075e-02f, 1.57134056e-01f, 1.35673866e-01f, 7.40424767e-02f, 1.12619974e-01f, 7.92817846e-02f,
  -6.37055375e-03f, -1.06686071e-01f, -2.11785823e-01f, 8.78770661e-05f, 1.03305215e-02f, -6.69666901e-02f, 1.82744771e-01f, 6.87443689e-02f, 1.10240571e-01f, 1.35133892e-01f,
  9.86931473e-02f, 2.87450999e-02f, -1.43743411e-01f, -2.47245058e-01f, 8.36901926e-03f, -1.33234754e-01f, -5.98409027e-02f, -4.88381982e-02f, -3.48796546e-02f, -6.53833617e-03f,
  2.30388250e-03f, -5.34235165e-02f, -1.27621263e-01f, -9.95937828e-03f, 7.32869667e-05f, -8.71931314e-02f, 3.09557132e-02f, -1.11865588e-01f, 2.50493400e-02f, -8.97321478e-02f,
  -1.22946396e-01f, 8.30214322e-02f, 6.11488707e-02f, -5.37340902e-02f, 2.80233175e-02f, -1.07050538e-01f, 8.96348581e-02f, 3.76400352e-02f, 7.92877078e-02f, -1.53410763e-01f,
  -7.48114008e-03f, 1.70817301e-01f, 1.19854689e-01f, 1.52609408e-01f, 3.87261212e-02f, 1.53210565e-01f, 7.51777813e-02f, 1.12029575e-01f, 8.00909698e-02f, 7.84967616e-02f,
  3.10884193e-02f, 1.19620480e-01f, 1.47726163e-01f, 1.32164299e-01f, 6.08520359e-02f, 1.50758281e-01f, 1.75215438e-01f, 8.44537914e-02f, 1.41232446e-01f, 4.81977761e-02f,
  2.54426505e-02f, 8.67950916e-02f, 1.07419146e-02f, 7.47966617e-02f, 1.06925264e-01f, 2.00098351e-01f, 6.58841655e-02f, 1.18858412e-01f, 1.05295509e-01f, 1.22405656e-01f,
  -2.57345349e-01f, -1.22359721e-03f, -1.12553112e-01f, -1.06497250e-01f, 3.08789071e-02f, -8.88861939e-02f, -6.74898773e-02f, -1.09520622e-01f, -3.62602137e-02f, -5.28832525e-02f,
  5.13990782e-02f, -3.24191735e-03f, -5.34193963e-02f, -3.78556773e-02f, -3.52367088e-02f, -3.99685688e-02f, -9.55392495e-02f, -1.12054981e-01f, -8.27795938e-02f, 8.98923725e-02f,
  1.76145565e-02f, -1.49417548e-02f, -9.63707641e-03f, -7.94283301e-02f, -2.99636535e-02f, -1.49809808e-01f, 7.24972710e-02f, 1.67716090e-02f, 6.25843853e-02f, -1.23441651e-01f,
  2.27668844e-02f, -3.45318556e-01f, -1.29798204e-01f, 1.08806372e-01f, 6.76465556e-02f, 1.49143159e-01f, -1.69567272e-01f, -3.08915917e-02f, 1.55679435e-01f, -8.97641852e-03f,
  1.57812968e-01f, 1.31546870e-01f, 1.06321730e-01f, 8.14227760e-02f, 8.40950236e-02f, 1.49522047e-03f, -5.13841510e-02f, 1.29047960e-01f, 1.96929887e-01f, 2.10473657e-01f,
  -7.51247769e-03f, 4.90447357e-02f, 9.21407118e-02f, 8.75816196e-02f, 1.82122998e-02f, 6.98617399e-02f, -7.47284107e-03f, -6.50686817e-03f, 3.89727560e-04f, -1.47887096e-01f,
  1.25663355e-01f, -2.35289130e-02f, 1.68616027e-01f, 1.01358742e-01f, 1.63475685e-02f, 9.95271429e-02f, 7.53773982e-03f, 4.99763116e-02f, 2.42893049e-03f, 5.45672625e-02f,
  7.53729194e-02f, -5.27501665e-02f, -2.00477336e-02f, -3.42970267e-02f, -6.02132455e-03f, 6.50947094e-02f, -1.70877669e-02f, -4.75207232e-02f, 1.00358121e-01f, 7.03610852e-02f,
  -1.77948084e-02f, -1.09454645e-02f, 3.01120095e-02f, 3.78981940e-02f, 2.34007798e-02f, 5.71619719e-02f, -2.38973461e-02f, -9.86347720e-03f, 2.44107917e-02f, -4.99208011e-02f,
  -1.42700337e-02f, 1.12289570e-01f, 6.69217631e-02f, 3.99792343e-02f, -5.85526647e-03f, 1.79936979e-02f, 5.52609935e-03f, 2.17875969e-02f, 1.18460953e-01f, -1.88231003e-02f,
  8.15283787e-03f, 7.30216969e-03f, -2.03352096e-03f, 1.09506913e-01f, 2.68603023e-02f, -6.41955901e-03f, 8.78839567e-02f, 3.18971910e-02f, 9.23210531e-02f, 6.68695569e-02f,
  -9.71956924e-03f, 7.06484616e-02f, 1.04769781e-01f, 3.84707600e-02f, 1.08120903e-01f, 3.78189683e-02f, 8.26632753e-02f, 1.52929537e-02f, 4.41330746e-02f, 9.31500122e-02f,
  1.55425251e-01f, 4.65281308e-02f, 1.96782481e-02f, -5.55886291e-02f, -7.28112161e-02f, 7.82015398e-02f, -2.49881279e-02f, 8.88836384e-02f, -4.63747531e-02f, 1.35882739e-02f,
  8.85362998e-02f, 3.37480977e-02f, -3.10612861e-02f, -1.36130992e-02f, 5.73918372e-02f, 9.84089598e-02f, -6.49808049e-02f, -7.31028467e-02f, 6.44028112e-02f, -2.81338468e-02f,
  -7.47898147e-02f, -8.86807069e-02f, 5.67885004e-02f, -4.34961207e-02f, -5.66293858e-03f, 1.33151978e-01f, -5.14739717e-04f, 1.41380444e-01f, 1.16194673e-01f, -5.18165119e-02f,
  -1.58270925e-01f, 1.99852377e-01f, 2.48149008e-01f, 6.94773942e-02f, 2.29159832e-01f, 1.58177897e-01f, 1.51622906e-01f, 1.94533113e-02f, 1.40879795e-01f, 9.13921371e-02f,
  9.73826274e-02f, 9.74226519e-02f, 2.48259380e-01f, 2.48294398e-01f, 2.76581019e-01f, 3.51669610e-01f, 3.68392706e-01f, 2.26902872e-01f, 1.62487179e-01f, 4.48329672e-02f,
  2.05482058e-02f, 1.56955197e-01f, 1.11377969e-01f, 1.22747861e-01f, 2.44475715e-02f, -1.33336196e-02f, 1.02264106e-01f, 1.36038303e-01f, 5.37914522e-02f, 6.43236637e-02f,
  2.16145739e-01f, -2.38197367e-03f, -5.54247871e-02f, -6.42752498e-02f, 1.12945825e-01f, -2.61887982e-02f, -1.22748818e-02f, -3.24514396e-02f, 6.88774418e-03f, 3.44322808e-02f,
  1.27809823e-01f, -1.41810467e-02f, 7.08135590e-02f, -3.39088932e-04f, 1.28538847e-01f, 1.01759344e-01f, 1.11680456e-01f, 1.08622976e-01f, 1.54926091e-01f, -1.83724370e-02f,
  7.23692551e-02f, -7.26641864e-02f, 2.88026612e-02f, -1.54724903e-02f, 3.12369168e-02f, 4.60372120e-02f, 1.08027672e-02f, 4.89364713e-02f, 7.13437423e-02f, -1.13227963e-01f,
  -3.94548029e-02f, 1.32240430e-01f, 1.25134829e-02f, 5.51375486e-02f, 1.08838491e-01f, 9.95372161e-02f, 8.12549368e-02f, 1.27372727e-01f, 9.31158513e-02f, 5.91450408e-02f,
  1.79517999e-01f, 1.03066541e-01f, 1.10946856e-01f, 5.55518493e-02f, 1.19905069e-01f, 4.63832729e-02f, 8.83841217e-02f, 8.54315236e-02f, 7.36602582e-03f, 8.65209624e-02f,
  9.34600234e-02f, 1.03010833e-01f, 8.49653706e-02f, 1.17343619e-01f, 1.39767513e-01f, 1.40976056e-01f, 4.72507253e-02f, 1.48606628e-01f, 9.67280343e-02f, 7.42889419e-02f,
  -4.37024869e-02f, 7.49626458e-02f, 5.30917151e-03f, -1.22642726e-01f, -9.17020440e-02f, -3.83134782e-02f, -6.91397041e-02f, -6.61727563e-02f, -6.14756718e-02f, -6.44684508e-02f,
  4.95234691e-02f, -4.36459072e-02f, 5.49594834e-02f, -4.22009304e-02f, 3.03250272e-03f, 2.37672068e-02f, -7.97969103e-02f, 3.00593991e-02f, 3.63965593e-02f, 4.44269106e-02f,
  1.42158503e-02f, -6.95984885e-02f, -1.27859101e-01f, -1.06041387e-01f, -6.80387467e-02f, -1.28987312e-01f, -7.80057684e-02f, -4.22390513e-02f, 2.54515763e-02f, -1.29541576e-01f,
  2.02339754e-01f, -1.86981678e-01f, -2.60743290e-01f, -2.16938015e-02f, -3.24208528e-01f, -9.06215310e-02f, -1.01963066e-01f, 4.71383333e-02f, 1.89546973e-01f, -1.51240945e-01f,
  -2.53338993e-01f, -8.93098190e-02f, -9.39887315e-02f, 2.89823432e-02f, 1.84240058e-01f, -8.97146855e-03f, 1.00825451e-01f, 1.18559264e-01f, 2.36190353e-02f, -5.32777756e-02f,
  -5.00964373e-02f, 1.50502875e-01f, 2.04962134e-01f, 1.62450790e-01f, -1.62773877e-01f, -6.05173595e-02f, -1.62154466e-01f, -1.04517236e-01f, -1.02976233e-01f, -8.56401026e-02f,
  -2.53336579e-01f, -1.12667993e-01f, 1.08647021e-02f, -1.35227993e-01f, -2.78217643e-01f, -7.29133412e-02f, -2.79768649e-02f, -1.20048523e-01f, -1.41730793e-02f, -1.05832323e-01f,
  -1.31926179e-01f, -1.34618878e-01f, -9.55226198e-02f, -1.74168378e-01f, -3.56378034e-02f, -8.70584697e-02f, 5.37578128e-02f, 4.68543246e-02f, 7.03963509e-04f, -1.06130078e-01f,
  -1.53129697e-01f, -2.61099935e-01f, -2.08265364e-01f, -1.53180569e-01f, -2.96609495e-02f, -9.70991254e-02f, -1.28057331e-01f, -1.69375196e-01f, -1.21505663e-01f, 1.54198715e-02f,
  4.00594901e-03f, 3.23638953e-02f, 1.60289139e-01f, 9.91651192e-02f, 1.89525142e-01f, 7.48226866e-02f, 1.72572687e-01f, 7.02959001e-02f, 1.31210342e-01f, 1.57610998e-01f,
  1.28980830e-01f, 1.02124356e-01f, 9.78829265e-02f, 1.36292577e-01f, 1.46111861e-01f, 6.84982985e-02f, 1.33111045e-01f, 1.06613547e-01f, 1.86665922e-01f, 1.65481180e-01f,
  1.54888228e-01f, 9.06527787e-02f, 1.04371533e-01f, 1.40625462e-01f, 1.68281943e-01f, 1.55127525e-01f, 1.03681155e-01f, 8.51601064e-02f, 8.92541334e-02f, 1.62750959e-01f,
  -4.80791479e-02f, -5.07321907e-03f, -1.02326544e-02f, 9.99715179e-03f, -1.42231911e-01f, -1.02263140e-02f, -1.18603691e-01f, -5.12595400e-02f, -1.11470327e-01f, -1.81200847e-01f,
  -9.16530937e-02f, -1.60682768e-01f, -1.04818232e-01f, -4.19424288e-02f, -1.32769376e-01f, -1.11565329e-01f, -5.02888858e-02f, -2.97710691e-02f, -7.91325048e-03f, -1.94855064e-01f,
  -5.61949685e-02f, 6.27879798e-02f, -2.72259489e-02f, -2.11642236e-02f, -8.95682499e-02f, -1.27501175e-01f, -1.02855384e-01f, -1.33529633e-01f, 2.36434843e-02f, 5.30979298e-02f,
  3.43254432e-02f, -8.40381533e-02f, 4.05984461e-01f, 9.83044058e-02f, 8.30917060e-02f, -9.04094353e-02f, -2.83476621e-01f, -1.17323712e-01f, 1.25908256e-01f, -9.16467682e-02f,
  -2.75981426e-03f, 1.32472917e-01f, 2.74476796e-01f, 2.19484121e-01f, 7.22059906e-02f, 3.99681963e-02f, 1.22149549e-01f, 3.15561295e-01f, 1.48088023e-01f, -5.60543723e-02f,
  1.76010060e-03f, -2.41522491e-02f, 3.46829519e-02f, 1.06547579e-01f, 1.08331688e-01f, 2.49333531e-01f, 1.99833304e-01f, 9.63610485e-02f, 6.62361011e-02f, 3.32101822e-01f,
  1.29477367e-01f, -5.55894598e-02f, 1.51560500e-01f, -1.74471848e-02f, 1.11642569e-01f, 7.56694302e-02f, 6.52152374e-02f, 1.33851141e-01f, 4.36987802e-02f, 7.57510215e-02f,
  6.81421906e-02f, 1.14850653e-03f, 6.60841987e-02f, 7.33458400e-02f, -1.38342166e-02f, -1.74229424e-02f, 1.76596630e-03f, 8.88238549e-02f, 1.19588986e-01f, 2.80696945e-03f,
  3.71952578e-02f, -1.97056364e-02f, 9.37146619e-02f, 9.51952040e-02f, 1.30900547e-01f, 9.00936499e-02f, 6.78332150e-02f, 3.21303569e-02f, 5.03283143e-02f, 5.71221709e-02f,
  -1.30708978e-01f, -1.27288131e-02f, -1.69146553e-01f, -8.01763013e-02f, -1.97507143e-01f, -2.88868006e-02f, -7.95031786e-02f, -1.64163738e-01f, -1.39263421e-01f, -9.26135108e-02f,
  -1.66383475e-01f, -1.34152055e-01f, -8.94689485e-02f, -1.36909902e-01f, -1.30279884e-01f, -1.49056956e-01f, -1.79591790e-01f, -1.80389464e-01f, -2.00355425e-01f, -7.99155310e-02f,
  -1.43587530e-01f, -3.10018081e-02f, -1.25449970e-01f, -1.89821690e-01f, -1.26895785e-01f, -1.13957241e-01f, -7.96922296e-02f, -2.10971832e-02f, -6.06244318e-02f, -1.78568155e-01f,
  -8.47258121e-02f, 8.83545503e-02f, 9.97566879e-02f, 4.89053912e-02f, 1.06494136e-01f, 1.24278769e-01f, 3.43126431e-02f, 3.45631801e-02f, 1.11697793e-01f, 1.07673012e-01f,
  6.62363842e-02f, 6.99269623e-02f, 3.84433232e-02f, 3.63522246e-02f, 7.02570900e-02f, -7.16435304e-03f, 2.18634643e-02f, 1.38117373e-01f, 4.43648323e-02f, -2.20316350e-02f,
  3.13839782e-03f, -4.54650931e-02f, 1.21847935e-01f, 7.75475278e-02f, 3.17984298e-02f, 2.07038164e-01f, -3.07399854e-02f, 7.80623108e-02f, 1.00552373e-01f, -1.58337414e-01f,
  1.26649529e-01f, 1.10045530e-01f, 1.28141670e-02f, 1.11361165e-02f, 8.93872790e-03f, 1.27698094e-01f, 2.42367581e-01f, 2.12094322e-01f, -4.79083993e-02f, 5.21467738e-02f,
  -1.54826254e-01f, -2.07411915e-01f, -2.34985963e-01f, -1.07747652e-01f, -3.56814265e-02f, 1.60207435e-01f, 8.31084996e-02f, -3.43780778e-02f, -2.72564590e-02f, 7.36642405e-02f,
  -5.81786372e-02f, 8.04732069e-02f, 5.34487627e-02f, 3.40184830e-02f, -6.62925616e-02f, -1.15415640e-01f, -1.22420773e-01f, -8.87271110e-03f, -1.59308657e-01f, -1.10283397e-01f,
  -1.22171864e-01f, 4.16117162e-02f, 3.30158486e-03f, -3.29391956e-02f, -1.72577381e-01f, -6.65797219e-02f, 7.47203361e-03f, -2.08119042e-02f, -7.30615705e-02f, -4.69820462e-02f,
  -9.30062234e-02f, -4.47526202e-02f, -2.81294473e-02f, 3.20929624e-02f, 7.07134381e-02f, -1.87602565e-02f, 9.17088762e-02f, 6.24758415e-02f, 2.59859604e-03f, -6.46086931e-02f,
  1.61460321e-02f, 1.26407184e-02f, -7.48028280e-03f, 2.08465960e-02f, -1.48478411e-02f, -9.11378488e-02f, -8.07388127e-02f, 5.01459949e-02f, 3.96567257e-03f, 1.08766127e-02f,
  8.64823088e-02f, -6.79524913e-02f, -6.35756105e-02f, -3.95016521e-02f, -9.91352499e-02f, -8.49703252e-02f, -1.23556666e-01f, -1.09879330e-01f, -8.97787809e-02f, -5.36763258e-02f,
  -2.65730582e-02f, -1.31474510e-01f, -1.12853788e-01f, -1.40561322e-02f, -1.82751447e-01f, -1.78956166e-02f, -1.66483611e-01f, -1.32073164e-01f, -1.30966753e-01f, -1.08033396e-01f,
  -8.32761154e-02f, -1.65476799e-01f, -4.65875678e-02f, 1.39365485e-02f, -1.55183643e-01f, -4.73751053e-02f, -2.09098179e-02f, -5.85581250e-02f, -1.07037932e-01f, -5.16272075e-02f,
  -1.09188430e-01f, -9.31367129e-02f, -6.49119145e-04f, -7.73747871e-03f, -1.48025844e-02f, 1.63742695e-02f, -1.00432925e-01f, 4.33578119e-02f, -1.31174237e-01f, 5.95779251e-03f,
  -6.58819079e-02f, -2.32561417e-02f, -3.16086672e-02f, 1.47179544e-01f, 7.89149478e-03f, 3.94651741e-02f, 8.08494017e-02f, -4.38081771e-02f, 5.22983819e-02f, 5.94334006e-02f,
  9.16133523e-02f, 6.51266798e-02f, -5.09406533e-03f, 3.69090820e-04f, 3.64160575e-02f, -1.17032908e-01f, -5.89538068e-02f, -8.17929208e-02f, -6.90020025e-02f, 1.88724827e-02f,
  -1.23951837e-01f, -3.72556835e-01f, -2.81152487e-01f, -1.82365149e-01f, -7.41403997e-02f, -8.17978662e-03f, -1.41063005e-01f, -5.87874576e-02f, -6.71420917e-02f, -7.87771717e-02f,
  -2.12450307e-02f, 1.64314240e-01f, 6.89086169e-02f, 4.12372313e-02f, -1.70872688e-01f, -1.33314803e-01f, -2.70223200e-01f, -1.85695961e-01f, 3.46288108e-03f, -9.50471610e-02f,
  -1.08753830e-01f, -2.00090483e-01f, -2.07242355e-01f, -1.72410205e-01f, -1.19972043e-01f, -2.83838343e-02f, -2.66673476e-01f, -1.59489974e-01f, -1.59938365e-01f, -2.10022718e-01f,
  -2.31820539e-01f, -7.36594796e-02f, -3.29146460e-02f, 8.99235532e-02f, 2.43472476e-02f, 2.86180731e-02f, 3.74609232e-02f, 1.21561009e-02f, 1.21536311e-02f, -5.68048507e-02f,
  2.58127525e-02f, -4.95563820e-02f, 7.18529476e-03f, 1.57151520e-02f, -7.55388364e-02f, -7.36142844e-02f, -8.67579356e-02f, -2.27094293e-01f, -5.25860973e-02f, -8.94559324e-02f,
  5.07902093e-02f, -2.90708467e-02f, -1.23749949e-01f, -1.77642591e-02f, -1.38822332e-01f, 1.67969894e-02f, -9.68523696e-02f, -1.78412646e-01f, -1.93146184e-01f, -3.17950875e-01f,
  -3.46395746e-02f, 1.09824482e-02f, 3.23791094e-02f, -1.33348569e-01f, -1.40769109e-02f, 1.34798177e-02f, -1.00193664e-01f, -5.77468127e-02f, 2.94249207e-02f, -8.71827975e-02f,
  -7.75084272e-02f, -1.11971842e-02f, -5.74343130e-02f, 3.83937760e-04f, 7.20574334e-02f, -6.34351447e-02f, 6.63668811e-02f, -8.26532487e-03f, 8.66020937e-03f, -2.03754585e-02f,
  -6.75026141e-03f, 4.01374064e-02f, -2.64644790e-02f, 1.86077114e-02f, -6.64069131e-02f, -8.86529125e-03f, -7.61623159e-02f, -2.50058118e-02f, -6.44061193e-02f, 3.75142060e-02f,
  -2.41725426e-02f, 1.25392675e-01f, 6.10304950e-03f, -2.24607973e-03f, 2.10036468e-02f, -2.26757349e-03f, -4.55175526e-02f, -7.07444251e-02f, 2.13748831e-02f, -4.62329909e-02f,
  -7.73423091e-02f, -6.01549633e-02f, -1.32365495e-01f, -1.11620337e-01f, -6.75969049e-02f, -5.91816008e-02f, 2.07727365e-02f, -3.88131826e-03f, -2.47633159e-02f, -4.48723882e-02f,
  -1.29896943e-02f, -3.07026953e-02f, -1.25507250e-01f, -1.04072176e-01f, -6.92225248e-02f, -2.45912336e-02f, -2.03181699e-01f, -1.77769706e-01f, -3.79101373e-02f, -2.38106444e-01f,
  1.55064575e-02f, 1.84792876e-01f, 2.31288791e-01f, 1.03890911e-01f, -1.44361451e-01f, -1.29752591e-01f, -2.01514035e-01f, -1.88903809e-01f, -6.76139221e-02f, 1.35979597e-02f,
  1.16962641e-01f, 3.41667011e-02f, 1.26960883e-02f, -9.47855785e-02f, -1.11960843e-01f, -1.70562640e-02f, -1.35527715e-01f, -4.84829992e-02f, -2.56966889e-01f, -3.12629908e-01f,
  -1.02476545e-01f, -1.35486916e-01f, -6.40131459e-02f, -9.31555703e-02f, 1.22855313e-01f, 2.14881171e-02f, 1.26560822e-01f, 1.87322333e-01f, -9.95325297e-03f, 1.18080609e-01f,
  2.27538526e-01f, 3.13502014e-01f, -1.01930439e-01f, 6.08320199e-02f, 2.54952312e-01f, 2.04071850e-02f, 1.42274782e-01f, 1.31860882e-01f, 1.05258197e-01f, 6.22603595e-02f,
  1.50740534e-01f, 3.99554595e-02f, 1.17426261e-01f, 2.47200895e-02f, 9.80909020e-02f, 6.19285554e-02f, 1.03743292e-01f, 5.06171435e-02f, 1.32753626e-01f, 9.91476178e-02f,
  5.28794639e-02f, 7.44755492e-02f, -1.43319264e-03f, 2.50305813e-02f, 1.67414099e-01f, 5.37283272e-02f, 1.59433350e-01f, 3.42187323e-02f, 8.33292231e-02f, 1.01154462e-01f,
  6.16406184e-03f, -2.58809887e-02f, -6.56997114e-02f, 3.86895641e-04f, -8.37195367e-02f, -4.64474363e-03f, 2.10809801e-02f, -5.67257702e-02f, -8.42180997e-02f, -3.42548601e-02f,
  3.44921686e-02f, -3.72968540e-02f, -5.73753491e-02f, 1.58646014e-02f, 4.37600957e-03f, -8.46655816e-02f, -7.61869773e-02f, -9.58925486e-02f, 6.74189851e-02f, -3.85878794e-03f,
  4.72286204e-03f, -4.88527678e-02f, 1.01926036e-01f, -5.88784069e-02f, -5.35080843e-02f, -4.47840095e-02f, -4.19985242e-02f, -8.79593100e-03f, 1.59368683e-02f, 4.08730917e-02f,
  1.46012828e-02f, 6.78624809e-02f, 5.28072342e-02f, 2.07550917e-02f, 1.39546677e-01f, 1.64266795e-01f, 5.66797182e-02f, 7.86016881e-02f, 1.53223276e-01f, 1.35157928e-01f,
  9.90949646e-02f, 1.13640875e-01f, 8.40280801e-02f, 7.07120076e-02f, -3.21362913e-02f, 1.50870169e-02f, 5.91865070e-02f, -4.27486710e-02f, -3.30749117e-02f, 1.01124957e-01f,
  -5.17871976e-02f, -7.93800130e-02f, -1.42821223e-01f, 3.34999301e-02f, 5.00262380e-02f, -1.32353202e-01f, -2.79387236e-02f, -1.23301074e-02f, -1.52586028e-01f, -4.50159684e-02f,
  -2.79602319e-01f, 7.32498839e-02f, -1.32847890e-01f, -1.24153227e-01f, 2.98610865e-03f, 1.06167056e-01f, 9.80788767e-02f, -3.83995511e-02f, 4.97048125e-02f, -5.27622439e-02f,
  2.48825029e-01f, 2.07164064e-01f, 1.72044367e-01f, 1.11438572e-01f, 1.12895250e-01f, -2.05338016e-01f, -2.16179535e-01f, -1.44858107e-01f, -6.63754588e-04f, 3.62315401e-02f,
  1.12810336e-01f, -9.62551460e-02f, 2.46972707e-03f, 1.04522211e-02f, -1.80745833e-02f, 6.11562431e-02f, -6.88415244e-02f, -9.53846145e-03f, 1.71679601e-01f, -1.70965940e-01f,
  3.25498078e-03f, 1.30616754e-01f, 8.71289819e-02f, 1.74691211e-02f, 1.24941826e-01f, 9.89323556e-02f, 1.52944535e-01f, -7.21491873e-03f, 4.05540019e-02f, 1.08590841e-01f,
  2.33970568e-01f, 4.86316420e-02f, 3.15329246e-02f, 1.38065919e-01f, 1.11544408e-01f, 1.12282626e-01f, 1.30458489e-01f, 6.24624602e-02f, 9.09230113e-02f, 1.36030242e-01f,
  7.84386247e-02f, 1.37006789e-01f, 1.24871753e-01f, 2.03821436e-01f, 1.58681795e-01f, 1.52322371e-02f, 1.03917360e-01f, 2.00194001e-01f, 6.93802610e-02f, -4.69607348e-03f,
  -8.14406574e-02f, -2.54267943e-04f, -1.54866725e-02f, -5.37254103e-02f, 4.16953415e-02f, 2.95039825e-02f, -6.04386115e-03f, 3.11156604e-02f, -4.07503285e-02f, 1.26833247e-03f,
  9.42596048e-03f, -3.80553901e-02f, -5.02624139e-02f, -5.23662157e-02f, -3.42550129e-02f, -5.97032495e-02f, -2.90226303e-02f, -3.57980281e-02f, -2.79796068e-02f, -5.23165911e-02f,
  -6.64374903e-02f, 3.52991819e-02f, 1.39675634e-02f, 9.20897573e-02f, -3.63498926e-02f, -3.15162838e-02f, 4.06376012e-02f, 6.61736503e-02f, 8.98547173e-02f, -9.62611008e-03f,
  1.66530296e-01f, 2.02808857e-01f, -5.39907701e-02f, 9.76685509e-02f, 7.25243613e-02f, 2.59779505e-02f, 1.01902083e-01f, 4.34370115e-02f, 8.63587707e-02f, 5.41277602e-02f,
  1.61879748e-01f, 4.37568761e-02f, 3.76148000e-02f, 1.29743204e-01f, 1.02843434e-01f, 5.21318950e-02f, 1.72505602e-02f, 5.23543160e-04f, 8.07227641e-02f, 1.45382702e-03f,
  5.03950715e-02f, -2.21185163e-02f, 1.06783263e-01f, 9.02077276e-03f, 3.05521861e-02f, 1.24027189e-02f, 1.48520201e-01f, 1.24700569e-01f, 1.73087314e-01f, -1.54879093e-01f,
  3.70518744e-01f, 2.26433694e-01f, 1.57247201e-01f, 1.53335556e-01f, 9.13097560e-02f, 1.95671558e-01f, 2.85001755e-01f, 3.02065648e-02f, 1.26654014e-01f, 1.48049653e-01f,
  6.82386383e-02f, -8.36939923e-03f, -1.59434304e-02f, 6.38099015e-02f, 1.63940027e-01f, 1.56696215e-01f, 1.07516341e-01f, 1.64556533e-01f, 6.15103655e-02f, 1.43507943e-01f,
  5.67376502e-02f, 7.91474432e-02f, 2.04619393e-01f, 4.50430699e-02f, 1.07730990e-02f, -2.36981474e-02f, 9.98518467e-02f, -1.21552926e-02f, 6.81126788e-02f, 2.18733892e-01f,
  6.28564656e-02f, 2.53414243e-01f, 1.65035464e-02f, 1.42779842e-01f, 2.31836233e-02f, 9.53117162e-02f, 7.57824779e-02f, 6.47530258e-02f, 9.05790552e-02f, 1.07035547e-01f,
  2.95678191e-02f, 1.08849019e-01f, 1.39618497e-02f, 3.66490781e-02f, 4.69720960e-02f, 3.90861221e-02f, 2.26566195e-02f, 1.62251443e-02f, 9.57816094e-02f, 1.14246838e-01f,
  9.38197076e-02f, 1.72839046e-01f, 2.64264066e-02f, 3.98656353e-02f, -3.66171077e-02f, 1.86994467e-02f, 5.68471476e-02f, -2.66073812e-02f, -7.03807082e-03f, 1.13190413e-01f,
  -1.70106634e-01f, -1.26952127e-01f, -4.04728279e-02f, 2.30832137e-02f, -5.69692515e-02f, -1.16425402e-01f, -3.04957386e-02f, -5.57661690e-02f, 2.09818464e-02f, -1.48496881e-01f,
  2.63542309e-02f, -8.96411836e-02f, -7.29776993e-02f, 3.76131805e-03f, -3.25084627e-02f, -8.58527496e-02f, 1.76909752e-02f, -1.14680625e-01f, -1.96302608e-02f, 5.50170355e-02f,
  -5.89288175e-02f, -4.19042073e-02f, -8.41509551e-02f, -3.74018885e-02f, -8.59004334e-02f, -1.52221378e-02f, -8.48949552e-02f, -1.21693522e-01f, -4.33076769e-02f, 4.09240723e-02f,
  2.71110609e-02f, 1.20995857e-01f, 1.32491574e-01f, 1.41553059e-01f, 4.25624438e-02f, 3.26073468e-02f, 5.47307990e-02f, -3.37375840e-03f, 7.45917559e-02f, 1.33858472e-01f,
  1.69498295e-01f, 4.88401167e-02f, 1.44657895e-01f, 5.05988821e-02f, 1.44170970e-01f, 1.43048763e-01f, 5.52743189e-02f, 1.38787687e-01f, 9.30539239e-03f, 9.72906202e-02f,
  1.61571745e-02f, 1.08721070e-01f, 1.55767187e-01f, 9.33360085e-02f, 1.12202682e-01f, 9.01407674e-02f, 1.51726156e-01f, 5.60722724e-02f, 1.03501365e-01f, 9.50120464e-02f,
  -5.46847656e-02f, -2.88932443e-01f, 2.09463418e-01f, -3.49131040e-02f, 3.56169343e-02f, 9.51536447e-02f, -9.38514695e-02f, 1.26026660e-01f, 1.54241502e-01f, -1.50336936e-01f,
  -7.25994781e-02f, 1.28802925e-01f, 5.55564947e-02f, 1.34423599e-01f, 1.97782934e-01f, 8.06330666e-02f, 3.12988400e-01f, 3.78747433e-01f, 1.71022654e-01f, -9.02669802e-02f,
  -1.28564581e-01f, 2.09348053e-02f, 8.68553221e-02f, -3.41392793e-02f, -1.84688434e-01f, -4.05000086e-04f, 4.06142436e-02f, -5.93782142e-02f, -8.83531347e-02f, -2.10989624e-01f,
  -1.01501532e-01f, -1.81792751e-01f, 9.90995839e-02f, -8.09546188e-02f, -2.01565325e-02f, -1.19221285e-01f, 7.61055341e-03f, 2.35825032e-03f, -1.07800737e-01f, -3.49132605e-02f,
  -4.99613248e-02f, -9.68967900e-02f, 4.87628430e-02f, -3.90761644e-02f, 5.16678719e-03f, -1.98693033e-02f, -1.40308756e-02f, 6.04437254e-02f, 7.56883100e-02f, -1.22614294e-01f,
  -1.39896557e-01f, -1.00056000e-01f, -1.60100702e-02f, 6.36629090e-02f, -1.53316883e-03f, 6.07527494e-02f, -7.69466162e-02f, -1.27995685e-01f, -4.79657762e-02f, -1.36282846e-01f,
  1.34032920e-01f, 8.45179930e-02f, 6.35953695e-02f, 2.05932427e-02f, -1.02245115e-01f, 4.39826027e-02f, 3.34265344e-02f, -6.18958212e-02f, 2.36772876e-02f, 1.85698345e-02f,
  -1.81279948e-03f, -5.05281910e-02f, 1.44625828e-01f, -3.93374674e-02f, 4.15366516e-02f, 6.24646097e-02f, -8.28277916e-02f, 3.89521159e-02f, 1.75932720e-02f, -9.12607089e-02f,
  6.95313066e-02f, -9.20284390e-02f, -2.23975796e-02f, 5.65526001e-02f, -4.61178944e-02f, 7.30524771e-03f, 9.99761894e-02f, 4.50352803e-02f, -4.36148681e-02f, -2.59227175e-02f,
  -4.24253680e-02f, 1.60031617e-01f, -1.05523169e-01f, 9.85350236e-02f, -2.13009585e-03f, -2.36133859e-02f, -8.60052854e-02f, -5.34586348e-02f, -1.22997433e-01f, -2.90921796e-02f,
  -1.35790765e-01f, -1.46654937e-02f, -6.04277030e-02f, -1.07469626e-01f, -1.66003946e-02f, -4.67758514e-02f, -7.81532153e-02f, 6.99515194e-02f, -9.44705456e-02f, -1.76143736e-01f,
  -3.36049870e-02f, 3.60924453e-02f, 1.76721197e-02f, -1.93894014e-03f, 5.74836545e-02f, 1.42244026e-01f, 1.49404223e-03f, -8.70391056e-02f, 9.36885476e-02f, -6.24314807e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.20677519e-01f, 3.30101438e-02f, -6.17123604e-01f, 1.33255988e-01f, -2.69791394e-01f, -3.06442887e-01f, -8.38252306e-02f, 5.49346581e-02f, 4.14155200e-02f, -5.34310341e-02f,
  -1.25720859e-01f, -1.45169571e-01f, -1.46113873e-01f, -1.53819978e-01f, -5.03006876e-02f, -1.45640343e-01f, -2.26956457e-01f, -2.23913342e-01f, -1.98508561e-01f, -1.49348289e-01f,
  -5.95105775e-02f, 5.44560999e-02f, 4.72519919e-02f, -5.52543849e-02f, -2.39579789e-02f, -1.84410900e-01f, -1.73916221e-01f, -1.35179430e-01f, -2.28348151e-01f, -1.75408140e-01f,
  -2.97279477e-01f, -8.41311887e-02f, -1.01207078e-01f, 5.73506095e-02f, 5.92040271e-02f, 5.96796796e-02f, -4.94816229e-02f, 7.78805166e-02f, 5.04278168e-02f, -9.38304067e-02f,
  -5.39415479e-02f, -4.41044718e-02f, -2.56417710e-02f, -1.25733569e-01f, -7.06639439e-02f, -6.68413490e-02f, -7.37262592e-02f, -5.12523465e-02f, 2.76153851e-02f, -5.36547191e-02f,
  -3.26295197e-02f, -1.50987774e-01f, -1.46942422e-01f, -1.07898884e-01f, -1.12342790e-01f, -1.92491189e-01f, -1.60160691e-01f, -1.89594030e-01f, -1.85909972e-01f, 5.08894436e-02f,
  8.78326818e-02f, 3.05975080e-02f, 1.78831741e-02f, 5.48989661e-02f, 1.53193861e-01f, -4.57553230e-02f, 8.39572549e-02f, 9.00612548e-02f, -1.33012906e-02f, 1.26827499e-02f,
  -3.62213841e-03f, 5.48406318e-02f, -3.60660478e-02f, 9.73583683e-02f, -6.61108941e-02f, -4.96931113e-02f, 3.40759531e-02f, 4.61627319e-02f, 4.15526554e-02f, 5.21525852e-02f,
  -4.09117118e-02f, -2.49798000e-02f, -8.51304457e-02f, 1.64988801e-01f, -1.29487112e-01f, -1.81975774e-02f, -7.55400360e-02f, -5.04262745e-02f, 2.06540041e-02f, -1.03502490e-01f,
  1.86284855e-01f, -4.76196818e-02f, 1.10594928e-01f, 1.00712553e-01f, 1.86931919e-02f, -4.09756303e-02f, 5.00263693e-03f, 9.88786966e-02f, -3.69579978e-02f, 5.18905232e-04f,
  -2.77730767e-02f, 4.53896448e-02f, -8.86563361e-02f, -5.63950688e-02f, -5.20192608e-02f, -1.19608909e-01f, 1.30994469e-01f, -1.76684931e-04f, 1.37987069e-03f, -4.59398925e-02f,
  2.46514007e-02f, 1.80308521e-01f, 1.69948786e-01f, 5.25572598e-02f, 3.83681022e-02f, 4.19689603e-02f, -1.14910100e-02f, 2.74861362e-02f, 3.11908592e-02f, 3.37314785e-01f,
  -2.08065644e-01f, 8.21231604e-02f, -4.02985001e-03f, 8.75335783e-02f, 2.02075109e-01f, 4.06337261e-01f, 4.45871592e-01f, 3.49047333e-01f, 1.24381080e-01f, 1.58887042e-03f,
  2.29902212e-02f, -2.16839045e-01f, -1.48298115e-01f, -1.54312834e-01f, -2.22728495e-02f, 2.17218339e-01f, 7.92068169e-02f, -1.94084227e-01f, -1.43221498e-01f, -1.47773605e-02f,
  1.15554087e-01f, 1.24762833e-01f, -3.87663022e-02f, -2.06818338e-02f, 3.23058069e-02f, -7.38674104e-02f, 1.47388026e-01f, 1.73847571e-01f, 1.65251493e-01f, -1.84897721e-01f,
  -3.88664812e-01f, 1.28754526e-01f, -2.10475937e-01f, -2.53784060e-01f, -2.03798845e-01f, -8.30069408e-02f, -7.22334534e-02f, -8.40910524e-02f, 9.13765933e-03f, -6.83826432e-02f,
  -1.62038848e-01f, -1.73634812e-01f, -7.44363144e-02f, -5.51548302e-02f, 4.23291996e-02f, 2.47609504e-02f, -1.34205878e-01f, -6.64608404e-02f, -1.33023068e-01f, -8.07645172e-02f,
  -5.05064894e-03f, 3.23606259e-03f, 7.89337158e-02f, -2.06326228e-02f, -4.52105440e-02f, -1.84721202e-01f, -3.58704850e-02f, -2.11035952e-01f, -1.66013643e-01f, -2.02544659e-01f,
  -5.86949550e-02f, 6.83694184e-02f, -7.15743601e-02f, -1.24578103e-01f, -9.59201828e-02f, 5.88863492e-02f, -1.59291308e-02f, 3.15187201e-02f, 1.81160629e-01f, 8.49703327e-02f,
  1.63741797e-01f, 5.08187488e-02f, 1.95210919e-01f, 2.04874769e-01f, 5.32619618e-02f, 4.34686840e-02f, 1.62646607e-01f, 4.30801362e-02f, 9.31075141e-02f, 1.41613588e-01f,
  6.52174875e-02f, 1.06376588e-01f, 9.31603462e-02f, 1.31445425e-02f, 9.24891084e-02f, -5.01962788e-02f, 8.48872289e-02f, -9.15962644e-03f, 7.53272027e-02f, 3.11536282e-01f,
  2.51758754e-01f, 2.51426339e-01f, -1.22686528e-01f, -1.22812249e-01f, 1.04450390e-01f, 6.53567165e-02f, 2.04621628e-02f, 8.84957537e-02f, 6.52762130e-02f, 1.25518993e-01f,
  -9.20634419e-02f, 8.86666402e-03f, 1.66997597e-01f, 1.37896553e-01f, 2.07550190e-02f, 7.12278560e-02f, -2.47113891e-02f, 2.57982314e-03f, -4.19023149e-02f, -5.11762835e-02f,
  1.38994366e-01f, 1.62043750e-01f, 1.54242024e-01f, 5.10063581e-02f, -4.45100889e-02f, -4.87726694e-03f, 4.23931628e-02f, 4.85055447e-02f, -9.94694047e-03f, 1.28067166e-01f,
  4.88021463e-01f, -3.34676445e-01f, -7.06997156e-01f, 9.96914059e-02f, -9.95618254e-02f, 9.83878132e-03f, 1.91925898e-01f, 2.70785183e-01f, 1.95569605e-01f, -1.73628122e-01f,
  -1.28308624e-01f, -1.06997853e-02f, -2.27237567e-01f, -1.02998219e-01f, 7.80916587e-02f, -2.35916153e-01f, -3.95553589e-01f, -1.31521076e-01f, 3.26806486e-01f, 5.04650533e-01f,
  2.23291382e-01f, 3.29073399e-01f, 2.72761643e-01f, 1.10094234e-01f, -1.23846829e-01f, 4.99839038e-02f, -3.39600950e-01f, -1.33954212e-01f, -2.69193500e-01f, -5.23785233e-01f,
  -1.77323982e-01f, -3.13157529e-01f, 1.15389808e-03f, -3.90122347e-02f, -6.51800036e-02f, 8.47202092e-02f, 1.12255037e-01f, -5.11028431e-02f, -4.53195870e-02f, -1.35826126e-01f,
  -1.71849132e-01f, -1.02782778e-01f, -8.51032361e-02f, -3.35679203e-02f, 7.57911876e-02f, 5.51964454e-02f, -6.56441152e-02f, -1.72467172e-01f, -2.06646651e-01f, -1.68919414e-01f,
  -2.09955916e-01f, -1.74484313e-01f, -2.21762195e-01f, -1.05692573e-01f, -1.79856569e-01f, -1.24977581e-01f, -1.33773088e-01f, -1.84962243e-01f, -1.43695697e-01f, -5.18296938e-03f,
  2.56649703e-02f, -7.77849779e-02f, 7.87511617e-02f, 6.59831241e-02f, 5.41020818e-02f, -1.35130296e-02f, 1.37888435e-02f, 2.83802394e-02f, 7.71573558e-02f, 3.88857797e-02f,
  -1.86056793e-02f, -2.68202610e-02f, 2.62238011e-02f, -6.12306595e-02f, -1.96234342e-02f, -2.98642870e-02f, -1.14267990e-01f, 7.12029263e-03f, -3.36487330e-02f, 1.44416705e-01f,
  6.26427084e-02f, -6.19738884e-02f, 3.32439207e-02f, 8.32594857e-02f, -4.90677394e-02f, -1.10993437e-01f, -7.64387324e-02f, 7.29782730e-02f, 5.07110693e-02f, -9.74253751e-04f,
  4.39667642e-01f, -9.76769328e-02f, 7.04347938e-02f, 9.07205120e-02f, -8.30268189e-02f, 3.19316201e-02f, -8.06019306e-02f, 7.47049078e-02f, -6.10544197e-02f, 1.03857644e-01f,
  -9.49300826e-02f, 3.46905203e-03f, -5.01477905e-02f, 4.11563702e-02f, 1.91433430e-01f, 7.67736230e-03f, 7.79460445e-02f, 1.64520536e-02f, -2.82079563e-03f, 3.65913436e-02f,
  8.89559742e-03f, 2.86287636e-01f, 2.32627317e-01f, 8.02771673e-02f, 1.40913948e-01f, 2.58445978e-01f, 7.03990161e-02f, 1.10747322e-01f, 8.46361741e-02f, 3.44860077e-01f,
  -6.66809499e-01f, 1.53009742e-01f, 3.20577383e-01f, -4.83526915e-01f, -5.81263229e-02f, 2.39451781e-01f, 1.10855252e-01f, -7.69850314e-02f, -1.18821822e-01f, 1.01716071e-01f,
  1.35282412e-01f, -2.60082692e-01f, -3.48051995e-01f, -3.24265361e-01f, -2.64161587e-01f, -7.34500811e-02f, -2.30709434e-01f, -4.67326701e-01f, -5.00414371e-01f, -2.93726474e-01f,
  -3.08603078e-01f, -3.89922857e-01f, -4.71703142e-01f, -3.27228904e-01f, -2.01884672e-01f, -3.51986229e-01f, 1.35458410e-02f, -1.34792790e-01f, 8.98942277e-02f, -1.81886554e-01f,
  -5.84478397e-03f, 5.89032657e-02f, -1.39413804e-01f, -2.13227302e-01f, -5.65880090e-02f, 4.93476726e-03f, -5.67693859e-02f, -4.55186106e-02f, -6.94927014e-03f, -4.92369346e-02f,
  -1.03600636e-01f, 4.77820151e-02f, -6.02057688e-02f, 2.13281959e-02f, -1.78465936e-02f, 2.92619355e-02f, 7.56186545e-02f, -7.72334263e-02f, 1.50809169e-01f, 3.01922232e-01f,
  2.29301348e-01f, 1.73082933e-01f, 3.46541256e-02f, 2.29912236e-01f, 2.52076179e-01f, 6.23904727e-02f, 2.12819502e-01f, 1.63939610e-01f, 2.12970555e-01f, 3.94403636e-02f,
  -1.11238450e-01f, -9.77859646e-02f, -2.93117855e-02f, 1.36143742e-02f, 3.56784090e-02f, 5.42141870e-03f, -6.92810267e-02f, -9.15068910e-02f, -1.13779359e-01f, -1.56561226e-01f,
  1.93963386e-02f, 1.07806757e-01f, -5.68977697e-03f, -1.71812862e-01f, 3.13800536e-02f, 1.84525512e-02f, 1.04556018e-02f, 8.48886147e-02f, 1.04320180e-02f, 1.65345464e-02f,
  -4.85519059e-02f, -3.46218166e-03f, -4.08586003e-02f, 4.52934671e-03f, 2.01626420e-01f, 2.35130545e-02f, 1.64955854e-01f, 1.64928645e-01f, -7.97211155e-02f, 1.45713761e-01f,
  -5.02260864e-01f, 2.18588933e-01f, -2.10313439e-01f, -2.07129315e-01f, -4.19079475e-02f, 1.56009853e-01f, 8.13122988e-02f, -2.40052976e-02f, -1.10611752e-01f, 6.97503313e-02f,
  2.08090872e-01f, -2.35788561e-02f, -6.82452554e-03f, 3.13069895e-02f, -9.12517756e-02f, 2.87863296e-02f, -1.44973854e-02f, -8.01723748e-02f, 1.35503873e-01f, 2.85448819e-01f,
  1.80694968e-01f, 3.76393832e-02f, -1.45443618e-01f, -1.65258884e-01f, 6.56017044e-04f, -2.42216304e-01f, -1.60765409e-01f, 1.00278154e-01f, -6.30360693e-02f, -3.10218692e-01f,
  -2.52269000e-01f, -2.38982830e-02f, 6.10656701e-02f, 3.99969906e-01f, 3.66898686e-01f, 3.86818558e-01f, 2.89566100e-01f, 3.17578554e-01f, 3.77596200e-01f, 1.96547508e-01f,
  2.33255610e-01f, 2.83686548e-01f, 2.53806293e-01f, 2.72252679e-01f, 1.20132960e-01f, 3.36914808e-01f, 3.04781646e-01f, 5.60617074e-02f, 6.07651323e-02f, 2.65919328e-01f,
  3.70941192e-01f, 1.63380429e-01f, -5.50894253e-02f, 1.57248780e-01f, 7.27141649e-02f, 2.20180184e-01f, 1.96157441e-01f, 1.63866907e-01f, 2.19474643e-01f, 1.67683885e-01f,
  -8.19636285e-02f, -1.88011885e-01f, -1.01897605e-02f, -1.78210381e-02f, -1.50682732e-01f, -1.62133813e-01f, -1.31055370e-01f, -1.56505302e-01f, -1.52961478e-01f, 2.27263779e-03f,
  -1.13301650e-01f, -2.01508820e-01f, -7.74444342e-02f, -1.15507811e-01f, -1.25418276e-01f, -2.11649969e-01f, -1.23342060e-01f, 7.17873871e-02f, 7.17350561e-03f, -1.21615892e-02f,
  -5.47127752e-03f, 5.77139817e-02f, 1.69022515e-01f, 5.65683050e-03f, 5.09377494e-02f, 5.45698926e-02f, -4.87141348e-02f, 4.27983887e-03f, -3.31043601e-02f, -5.75484931e-02f,
  3.41167867e-01f, -1.10432869e-02f, -6.16587177e-02f, 1.88706324e-01f, 1.53116332e-02f, -3.45495455e-02f, 1.95894651e-02f, 1.98674276e-01f, 6.50310963e-02f, -3.66854668e-02f,
  -2.72472687e-02f, 1.82281837e-01f, 2.80234609e-02f, 9.08261091e-02f, -6.01058267e-02f, 5.31612746e-02f, -8.72566700e-02f, -4.82981615e-02f, -5.97938113e-02f, -8.58831778e-02f,
  1.14484867e-02f, -1.00600883e-01f, -2.24165708e-01f, -6.25958145e-02f, -7.46336654e-02f, -4.15803939e-02f, 7.58473277e-02f, -2.86343182e-03f, 3.15429308e-02f, 1.71514209e-02f,
  2.15787783e-01f, 3.44437100e-02f, 5.56933321e-02f, -1.05022304e-01f, -9.76358354e-02f, -2.48743802e-01f, -4.73804027e-02f, -4.35699858e-02f, -2.15173557e-01f, -1.76612772e-02f,
  -3.85245718e-02f, -2.26305485e-01f, -8.91811550e-02f, -3.54572088e-02f, -2.12905817e-02f, 3.08316704e-02f, -3.35207582e-03f, 1.79412052e-01f, 5.88491261e-02f, -1.42177781e-02f,
  -1.32993720e-02f, 1.52479157e-01f, 1.50931105e-01f, 1.76601261e-01f, 1.18044272e-01f, 1.36516586e-01f, 2.64718141e-02f, -8.89980868e-02f, 5.19287512e-02f, 1.37123495e-01f,
  7.75039732e-01f, -4.34686959e-01f, -4.84813094e-01f, 3.26884687e-01f, -1.92962810e-02f, 5.22883907e-02f, -1.73007697e-01f, 2.32047796e-01f, 3.92175347e-01f, -1.64071485e-01f,
  6.98303655e-02f, 4.41834003e-01f, 1.62046745e-01f, 8.97896141e-02f, 2.94362694e-01f, -3.66808653e-01f, -3.46395761e-01f, 5.98808527e-02f, 4.87202495e-01f, 3.70079070e-01f,
  8.09444785e-02f, 1.20202512e-01f, 2.56466985e-01f, 8.95016789e-02f, -2.11002409e-01f, 4.50258367e-02f, -4.28740740e-01f, -2.23740906e-01f, -2.96890169e-01f, -5.99446833e-01f,
  -3.41448933e-01f, -1.24768503e-01f, 9.94249582e-02f, 1.29765108e-01f, -1.08025096e-01f, 5.99317960e-02f, -2.35319603e-02f, -5.26169725e-02f, 2.79725119e-02f, -6.51228353e-02f,
  -8.99878517e-02f, 5.30827828e-02f, 6.45039380e-02f, -4.81953248e-02f, -7.20850155e-02f, 4.50583808e-02f, -5.92587814e-02f, 3.37672643e-02f, -8.40818211e-02f, -6.37486950e-02f,
  -4.51479964e-02f, -7.67447576e-02f, -1.61024835e-02f, -3.10840569e-02f, 5.89119755e-02f, 1.66182205e-01f, -1.26593545e-01f, 9.36794207e-02f, 7.07076639e-02f, -4.33408692e-02f,
  -2.27874685e-02f, 4.73732725e-02f, 5.56709506e-02f, 1.82966664e-02f, 1.09632775e-01f, 1.83469858e-02f, 5.03386743e-02f, 4.61631231e-02f, 4.84628230e-02f, -4.16886322e-02f,
  -5.05739301e-02f, 1.60050228e-01f, 3.63923945e-02f, -2.46821321e-03f, 9.67454091e-02f, 6.99728401e-03f, 2.00125575e-02f, 9.63836629e-03f, 5.15156463e-02f, 6.62334040e-02f,
  1.21891357e-01f, -8.09988996e-04f, -5.31845875e-02f, 6.24725968e-02f, -1.13838904e-01f, 6.51318803e-02f, 4.34072278e-02f, 8.94614160e-02f, 8.84674713e-02f, 7.70188943e-02f,
  6.53481036e-02f, 1.09941013e-01f, -2.79941224e-03f, 1.46818543e-02f, -7.16718733e-02f, -6.21209964e-02f, -8.27264711e-02f, 1.13795362e-02f, -1.05364345e-01f, -5.81271425e-02f,
  -1.12703025e-01f, 2.84416638e-02f, -1.43510014e-01f, -1.15056820e-01f, 9.72805917e-02f, 8.87459964e-02f, -2.65732827e-03f, 4.88167349e-03f, 1.59569029e-02f, -1.14559084e-01f,
  -6.35959730e-02f, 8.34838524e-02f, 1.85380995e-01f, 7.27405474e-02f, 1.17253000e-02f, 2.79681206e-01f, -1.63540795e-01f, -3.96106727e-02f, 1.32434398e-01f, 7.47622624e-02f,
  -6.63514912e-01f, -7.84178823e-02f, 3.16959262e-01f, -4.07066792e-02f, 1.02555774e-01f, 2.43599683e-01f, 3.13237727e-01f, 8.41360465e-02f, -8.02046284e-02f, -7.49028921e-02f,
  4.28095385e-02f, -1.13796100e-01f, -5.78642525e-02f, -7.39377514e-02f, 1.50265871e-03f, 1.85310781e-01f, 9.61816311e-02f, -2.80957688e-02f, 2.75012059e-03f, -4.78653517e-03f,
  1.08252324e-01f, 8.69218931e-02f, -4.66721952e-02f, 5.27949519e-02f, 1.60680898e-02f, 2.22270936e-03f, 1.51357502e-01f, 1.97291374e-01f, 1.04749359e-01f, 1.42886639e-01f,
  3.67123574e-01f, -9.11729410e-02f, -1.17318109e-01f, -1.56964198e-01f, -6.38321042e-02f, -9.01209190e-02f, 4.62392122e-02f, 1.93624366e-02f, -6.62794523e-03f, 1.29168212e-01f,
  -4.73262854e-02f, 4.92956489e-02f, -1.63951144e-02f, -2.14529485e-02f, 2.51320638e-02f, -1.14567969e-02f, -1.41618758e-01f, -6.57022595e-02f, 1.32021710e-01f, 2.04350390e-02f,
  -1.07058518e-01f, -7.09855109e-02f, 1.38956159e-01f, 1.20790966e-01f, -1.03081048e-01f, -1.23012766e-01f, 6.58249483e-02f, -7.02045485e-02f, 6.30455837e-02f, 1.96413472e-02f,
  -1.40450031e-01f, -3.22131626e-02f, -7.38375857e-02f, 9.22800675e-02f, -1.46059887e-02f, 9.79063585e-02f, 2.56145567e-01f, 2.44275883e-01f, 2.17864662e-02f, 8.98982733e-02f,
  1.62464976e-01f, 1.17122009e-01f, 2.72105664e-01f, 1.72474951e-01f, -1.39622604e-02f, 5.68497106e-02f, 7.30527565e-02f, 9.03470665e-02f, 1.36616156e-01f, 1.15334004e-01f,
  5.98352104e-02f, 1.72688961e-01f, 1.44623950e-01f, 1.25862241e-01f, 1.45227134e-01f, 8.32315907e-02f, 8.85942578e-02f, 1.21582203e-01f, 4.77778278e-02f, 1.61288247e-01f,
  4.33996946e-01f, -1.00874260e-01f, 5.46718426e-02f, 9.34162289e-02f, 6.69165924e-02f, -3.19545902e-02f, -9.32329968e-02f, -9.45715047e-03f, 1.54052839e-01f, 2.54464149e-01f,
  6.36138469e-02f, -1.57321375e-02f, -1.83039382e-02f, 8.16283002e-02f, 8.55412856e-02f, -5.05302772e-02f, -1.87362507e-01f, 2.16308329e-02f, 9.15667638e-02f, 1.49169713e-01f,
  -3.68482135e-02f, 4.73174453e-02f, 1.55953974e-01f, 9.65618342e-02f, 6.79471344e-02f, -2.36626118e-02f, 6.22774661e-02f, 4.89074811e-02f, 1.03177853e-01f, 3.72501723e-02f,
  8.45479727e-01f, 1.10827997e-01f, 8.12619850e-02f, 2.79785275e-01f, -2.11509224e-02f, -1.04649747e-02f, -6.02597892e-02f, -2.39134561e-02f, 8.10600594e-02f, 2.21748084e-01f,
  1.73972160e-01f, 1.85945570e-01f, 2.00035468e-01f, -4.01643617e-03f, 1.72427110e-02f, -7.15511516e-02f, 2.10527163e-02f, 8.76707360e-02f, 9.04211625e-02f, 2.43359402e-01f,
  5.01365103e-02f, 1.17623106e-01f, 2.77895421e-01f, 1.01867639e-01f, 1.47915900e-01f, 1.61512196e-01f, -6.77159205e-02f, 1.62427038e-01f, 8.56397972e-02f, 1.87302038e-01f,
  4.11390394e-01f, 1.63329586e-01f, -7.03423545e-02f, -1.93685424e-02f, 1.25110745e-01f, 6.09301515e-02f, 1.44974515e-03f, -8.46600756e-02f, 3.27497609e-02f, -5.49924597e-02f,
  -9.09686834e-02f, 6.05816394e-02f, -1.04379803e-01f, -5.25601245e-02f, 2.09007245e-02f, -5.34227453e-02f, 5.29409610e-02f, 3.13266926e-02f, -3.19335610e-02f, -3.89610641e-02f,
  -9.77445245e-02f, -5.22509590e-02f, -7.06791580e-02f, -1.30823314e-01f, -3.49238934e-03f, 6.89073354e-02f, 1.13226874e-02f, 1.08132839e-01f, -5.32426089e-02f, 5.64887300e-02f,
  2.43375227e-01f, 2.53089041e-01f, 1.88906789e-01f, 1.46954134e-01f, 1.80063277e-01f, 1.14485957e-01f, -3.06463800e-02f, 1.59380678e-02f, 5.00030965e-02f, 2.08325870e-02f,
  7.17723370e-02f, 2.01497719e-01f, 8.13442189e-03f, 1.74182709e-02f, 6.02713823e-02f, 1.65523067e-02f, 2.89828666e-02f, -2.90864240e-02f, 1.11659154e-01f, -3.25558372e-02f,
  1.57108590e-01f, 1.00749740e-02f, -6.16914919e-03f, -3.06156538e-02f, -1.16549935e-02f, 1.07461780e-01f, 1.93670541e-01f, 4.32605259e-02f, 1.29370064e-01f, 1.21856816e-01f,
  -4.05310035e-01f, -1.72805384e-01f, 1.65141478e-01f, -1.40424609e-01f, -5.33557637e-03f, -7.83754699e-03f, 7.65492991e-02f, -1.69560209e-01f, -5.57324030e-02f, -6.70307949e-02f,
  -5.74736521e-02f, -2.77557522e-02f, -6.68583214e-02f, -1.17881656e-01f, -9.44394097e-02f, -4.28138375e-02f, -1.20100854e-02f, -1.73715487e-01f, -1.26765668e-01f, -1.04952708e-01f,
  -1.01438537e-01f, -5.94133921e-02f, -1.93650723e-01f, -1.98577762e-01f, -9.58194509e-02f, -9.98601839e-02f, -1.86516456e-02f, -1.24776222e-01f, -1.56597599e-01f, -1.37783170e-01f,
  3.24723274e-01f, -3.24057072e-01f, -5.38818598e-01f, 1.85312733e-01f, 1.80326760e-01f, 1.59784943e-01f, 1.92399360e-02f, 1.71513975e-01f, 1.70784280e-01f, -2.28954017e-01f,
  -2.77739763e-01f, -6.00275919e-02f, -3.57934088e-01f, -1.08867019e-01f, -2.36951873e-01f, -4.13132876e-01f, -4.29853737e-01f, -1.88985646e-01f, 3.64454359e-01f, 5.89933693e-01f,
  3.40175360e-01f, 2.99744517e-01f, 1.49556741e-01f, 4.00711633e-02f, 1.04448184e-01f, -2.12424770e-02f, -3.92674536e-01f, -1.30438909e-01f, -2.80376643e-01f, -3.45691890e-01f,
  -8.92182663e-02f, -1.38944238e-01f, 5.91894127e-02f, -1.13558680e-01f, -2.16832921e-01f, -7.01053813e-02f, 2.95602940e-02f, -9.45262685e-02f, -1.21708669e-01f, -5.56766391e-02f,
  -5.55437654e-02f, -5.13581410e-02f, -2.61379015e-02f, 3.00656836e-02f, 1.60573408e-01f, 6.80753738e-02f, -8.97599682e-02f, -1.34392887e-01f, -1.41291603e-01f, -1.28120497e-01f,
  -1.01081356e-01f, -1.11962989e-01f, -1.51582614e-01f, -2.02529326e-01f, -1.46808729e-01f, -8.69105905e-02f, 3.52248847e-02f, -1.26687447e-02f, -1.46561608e-01f, -6.96944306e-03f,
  2.72678360e-02f, -5.12770414e-02f, 1.49200694e-03f, 5.65330498e-03f, 2.61189267e-02f, -2.04972729e-01f, -1.21492349e-01f, 7.79228210e-02f, 1.03844754e-01f, 6.81626946e-02f,
  -3.27978134e-02f, -7.18276128e-02f, 1.04835525e-01f, -1.61992922e-01f, 3.34681906e-02f, 7.84994569e-03f, 2.77104471e-02f, -1.12615362e-01f, -7.52259791e-03f, 7.96852913e-03f,
  1.81825440e-02f, 1.79572463e-01f, 8.15041214e-02f, 7.28689730e-02f, -9.42827910e-02f, -1.15699641e-01f, 5.02356440e-02f, 1.06722847e-01f, 5.03074527e-02f, 8.36564600e-02f,
  1.45567164e-01f, -3.29106957e-01f, -9.12134126e-02f, -6.27836436e-02f, -6.05442077e-02f, -9.45705548e-02f, -1.42761067e-01f, -3.87799069e-02f, -1.56384081e-01f, 1.31481355e-02f,
  -4.39935029e-02f, -4.62195165e-02f, -1.28750145e-01f, 1.31630003e-01f, 2.47187987e-01f, 1.00638367e-01f, -1.74845353e-01f, -8.17087814e-02f, -3.16152275e-02f, 1.74556077e-01f,
  -3.66296098e-02f, -9.70279239e-03f, 1.59311891e-01f, -2.89163124e-02f, 9.52801034e-02f, 1.05061807e-01f, -2.02303957e-02f, 1.10633560e-01f, -1.03153259e-01f, 1.43837750e-01f,
  -1.63268391e-02f, -5.13828933e-01f, 2.34903589e-01f, -5.04288562e-02f, -5.22018731e-01f, -2.39647433e-01f, -3.46478164e-01f, 7.05456883e-02f, -2.19338581e-01f, -5.11135161e-01f,
  -5.66301703e-01f, -2.47638300e-01f, -1.98803991e-01f, 5.51370941e-02f, 3.53788853e-01f, -1.81078702e-01f, -1.25392703e-02f, 5.00499785e-01f, 7.51636028e-01f, 1.97324872e-01f,
  -3.70137185e-01f, 2.15315640e-01f, 6.35332942e-01f, 4.98121053e-01f, -2.09595114e-01f, 6.09336272e-02f, -5.37257046e-02f, -1.78907424e-01f, -2.69670755e-01f, -3.19326878e-01f,
  -3.27211559e-01f, 1.60448149e-01f, 1.08948275e-01f, 4.34687957e-02f, -2.25946307e-01f, -7.82362465e-03f, 5.10873869e-02f, 6.94919825e-02f, -6.36875778e-02f, -3.68645154e-02f,
  -2.74739027e-01f, 1.34861208e-02f, -1.58400252e-01f, -5.75232506e-02f, 1.58151370e-02f, 9.11823362e-02f, 2.48174995e-01f, 4.08535659e-01f, 1.62872627e-01f, -1.83366854e-02f,
  -3.30919176e-01f, -2.54179180e-01f, -1.38843674e-02f, 5.31009138e-02f, 2.56393224e-01f, 1.50316328e-01f, 1.16147898e-01f, 1.90813661e-01f, 1.31863341e-01f, -9.18275267e-02f,
  -6.06598742e-02f, -1.18976887e-02f, -6.09592013e-02f, 3.79989371e-02f, 7.56564885e-02f, -1.29243031e-01f, 1.70965686e-01f, -7.44689852e-02f, 4.62761242e-03f, -5.95630147e-03f,
  5.48541732e-02f, -1.37430225e-02f, 1.54358327e-01f, 2.02238727e-02f, -1.88302025e-02f, -7.30217546e-02f, -8.94047543e-02f, 2.98123993e-02f, -7.68603310e-02f, 2.18162704e-02f,
  1.66622117e-01f, 2.32074484e-02f, -9.06721503e-02f, 1.36248887e-01f, 3.34919207e-02f, 1.44303113e-01f, -5.37146740e-02f, 1.12740561e-01f, 1.92158148e-02f, -1.40905872e-01f,
  -1.35139912e-01f, 1.29844576e-01f, -1.91215634e-01f, 1.46259516e-01f, -7.70511404e-02f, 3.01874634e-02f, -1.18308932e-01f, -3.90637740e-02f, 4.80611585e-02f, -2.15267409e-02f,
  9.76481438e-02f, 7.46130794e-02f, -1.10200323e-01f, 5.54545373e-02f, -9.89250243e-02f, -1.74594849e-01f, -2.39791527e-01f, -1.52044103e-01f, -2.45044958e-02f, -1.43297002e-01f,
  -2.60538943e-02f, 9.50061344e-03f, -3.01041752e-01f, -2.34931305e-01f, -2.20357046e-01f, -6.75842911e-02f, -1.35837123e-01f, -4.97408286e-02f, -4.70874310e-02f, -2.55603313e-01f,
  2.69738942e-01f, 8.52249637e-02f, -6.70805931e-01f, 3.73878270e-01f, -6.44934401e-02f, -1.43892005e-01f, 1.65520236e-01f, 4.16201949e-01f, 3.29977959e-01f, -3.84754762e-02f,
  -3.42971496e-02f, 2.08785385e-02f, -5.79665862e-02f, -1.44391671e-01f, -5.28248623e-02f, -1.38497606e-01f, -2.59938926e-01f, -3.08487147e-01f, -7.39573129e-03f, 2.13855997e-01f,
  2.66515285e-01f, 2.67647892e-01f, 1.87638178e-01f, 1.45093381e-01f, 8.74249786e-02f, -8.06762353e-02f, -1.56291023e-01f, -1.23151302e-01f, -2.72360325e-01f, -3.93467963e-01f,
  -4.34075624e-01f, -2.19284236e-01f, -1.06389187e-01f, 7.35001564e-02f, 1.39230728e-01f, 2.65359670e-01f, 1.30617902e-01f, 1.51006281e-01f, 9.52391550e-02f, 4.46167924e-02f,
  4.31002975e-02f, -3.13846245e-02f, 1.96398020e-01f, 4.46898229e-02f, 1.54671460e-01f, 6.78229379e-04f, 1.62226092e-02f, -6.28596768e-02f, 6.77410513e-02f, -3.03209070e-02f,
  2.08866838e-02f, -2.46287897e-01f, -3.06031942e-01f, -9.17718485e-02f, -5.86484335e-02f, -2.33608142e-01f, -9.43313465e-02f, -1.02736384e-01f, -2.53814936e-01f, -4.55008522e-02f,
  8.90683755e-02f, 1.36294961e-01f, 5.52559569e-02f, 7.12503120e-02f, 1.03287667e-01f, 5.26222885e-02f, 1.46260820e-02f, -1.12771362e-01f, 8.23924784e-04f, 9.00237858e-02f,
  8.72826762e-03f, -1.44898007e-02f, 1.26111567e-01f, 3.78312636e-03f, -4.44933176e-02f, -1.15364425e-01f, -1.96485370e-01f, 2.53141355e-02f, -1.70423761e-01f, 9.58145931e-02f,
  -6.34073466e-02f, -1.57493383e-01f, -3.32204178e-02f, -1.83773655e-02f, -1.03708923e-01f, -7.36045837e-02f, -3.99360172e-02f, 9.24270004e-02f, 6.06735833e-02f, -6.68528974e-02f,
  4.52647418e-01f, -2.26759791e-01f, -4.25301082e-02f, -9.29462016e-02f, -9.25687775e-02f, -1.02914892e-01f, -9.39631239e-02f, -1.25120267e-01f, 3.04612555e-02f, 5.06475344e-02f,
  -1.23046584e-01f, 2.12651417e-02f, 1.16354734e-01f, 2.32951734e-02f, 1.76726490e-01f, 2.39093509e-02f, 4.93859500e-02f, -1.20927759e-01f, -5.49734049e-02f, 2.06639860e-02f,
  1.09940046e-03f, -2.82082856e-02f, 1.43384952e-02f, -1.06449716e-01f, 1.10710368e-01f, 3.04312948e-02f, -1.10351272e-01f, -4.98203374e-02f, -8.90118554e-02f, 3.03232849e-01f,
  -8.20248961e-01f, 1.31717294e-01f, -1.78956762e-01f, -2.17045903e-01f, 1.56454012e-01f, 2.96860099e-01f, 3.50479960e-01f, 2.19946548e-01f, 1.76225185e-01f, 9.84455366e-03f,
  -5.56142703e-02f, -6.07215390e-02f, 5.85984327e-02f, 4.56147641e-02f, -9.96164382e-02f, 1.77587062e-01f, 2.22738400e-01f, -3.72565120e-01f, -3.38975817e-01f, -5.53060472e-02f,
  1.02215476e-01f, -3.90314341e-01f, -6.19681537e-01f, -2.02925131e-01f, 8.48966911e-02f, -7.59114996e-02f, -3.62814590e-02f, -1.81057557e-01f, 1.96169894e-02f, 2.97528394e-02f,
  -2.24126741e-01f, -7.90805891e-02f, 1.64586142e-01f, -1.63181096e-01f, -1.38595134e-01f, -7.06886426e-02f, 6.87793717e-02f, -1.72032848e-01f, 8.48886464e-03f, -7.37587661e-02f,
  -9.54611078e-02f, 5.05170412e-02f, -1.13686673e-01f, -5.52958511e-02f, -1.52130529e-01f, -6.09385036e-02f, -1.50364950e-01f, -1.34786800e-01f, -1.45668134e-01f, -6.51187971e-02f,
  1.60322070e-01f, -1.99547067e-01f, -2.73189962e-01f, 1.39096290e-01f, 9.07629505e-02f, -1.87451348e-01f, -6.97133318e-02f, -7.95998238e-03f, -2.08494291e-01f, -2.19275653e-01f,
  2.74035577e-02f, -3.74479778e-02f, 3.91971618e-02f, 3.57663184e-02f, 1.47607438e-02f, 5.31776622e-02f, 1.02198951e-01f, 7.47244880e-02f, -9.74701494e-02f, -8.06666836e-02f,
  3.55706103e-02f, -9.69032198e-02f, -4.98132184e-02f, -6.88754544e-02f, 9.74239409e-02f, -4.02142219e-02f, 1.67065896e-02f, -6.35482520e-02f, -3.70388515e-02f, -4.96160099e-03f,
  -9.76143181e-02f, -1.86806712e-02f, -5.96940052e-03f, -6.53868914e-03f, -1.52383256e-03f, -8.39496776e-02f, 6.29366934e-02f, 4.43441458e-02f, 3.58208530e-02f, 4.14575599e-02f,
  -1.47978263e-02f, -6.14330433e-02f, -4.07577604e-02f, 2.39791423e-02f, 9.34254006e-03f, -4.95123118e-02f, -6.72072964e-03f, -8.57113376e-02f, -3.33717726e-02f, -1.39809728e-01f,
  -2.07593963e-02f, -9.76765994e-03f, -8.68578553e-02f, 2.18608379e-02f, -1.67760327e-01f, -1.90123301e-02f, -1.31624311e-01f, -1.82542160e-01f, -1.23353386e-02f, -6.06942214e-02f,
  2.18711421e-02f, -2.50668466e-01f, -3.75145674e-01f, 1.08516579e-02f, 2.75623202e-02f, -3.45923960e-01f, -1.58623964e-01f, -7.53275305e-02f, -2.33460143e-01f, -3.30138624e-01f,
  5.67960799e-01f, -9.17385370e-02f, 1.85516909e-01f, 8.95630494e-02f, 4.32851687e-02f, 1.68203354e-01f, -4.33946634e-03f, -1.84098445e-02f, 3.08604557e-02f, -6.36998266e-02f,
  -6.83734426e-04f, 1.15823187e-01f, 1.36640757e-01f, 8.44237059e-02f, -3.71789970e-02f, -8.24381113e-02f, -1.89821925e-02f, 8.65284055e-02f, 2.11463422e-01f, -2.65538767e-02f,
  -6.48232400e-02f, 6.23438433e-02f, 5.06306477e-02f, 3.85425128e-02f, -1.63717225e-01f, 1.40825966e-02f, -2.78386604e-02f, 9.88580883e-02f, 4.80360165e-02f, -1.84870064e-01f,
  -1.12032726e-01f, 2.36397400e-01f, 9.93991494e-02f, 9.90607440e-02f, 1.61892846e-01f, 1.02340551e-02f, 1.15952142e-01f, -4.21477817e-02f, -7.03592449e-02f, -1.86504245e-01f,
  -1.51473358e-02f, 1.58390015e-01f, 2.71033831e-02f, 3.91049832e-02f, 1.31266728e-01f, 9.58335698e-02f, 1.18093327e-01f, -2.63160709e-02f, 2.10888442e-02f, 5.34062088e-02f,
  7.29454756e-02f, 6.52216226e-02f, 6.07427992e-02f, -4.23461944e-02f, 7.25154346e-03f, 1.46593735e-01f, -2.79184934e-02f, 1.76438130e-02f, 1.71113238e-01f, -5.64403459e-03f,
  2.51359850e-01f, 2.63338506e-01f, 2.27084950e-01f, 6.81313202e-02f, 5.96224293e-02f, 1.24675803e-01f, 1.10595606e-01f, 7.96563253e-02f, 2.42976576e-01f, 2.40336880e-01f,
  9.27576199e-02f, 1.20376945e-01f, 7.48061314e-02f, 5.46704568e-02f, 3.99343401e-01f, 3.10887069e-01f, 2.08310336e-01f, 1.66977540e-01f, 3.09881181e-01f, 1.66287512e-01f,
  1.37568951e-01f, 2.19790190e-01f, 2.49267355e-01f, 6.15663379e-02f, 1.31807253e-01f, 1.94757432e-01f, 2.06741422e-01f, 2.02602610e-01f, 1.85007885e-01f, 2.13387460e-01f,
  -2.80759752e-01f, 2.47382671e-01f, -5.43077774e-02f, -8.18649605e-02f, 2.95463558e-02f, 9.36354510e-03f, -9.20591578e-02f, -1.97446972e-01f, -1.99945524e-01f, -2.16466248e-01f,
  -2.45980509e-02f, 1.22981798e-02f, 7.52364472e-02f, -3.00351661e-02f, 1.19435377e-01f, -8.55678925e-04f, 2.33899280e-02f, -1.38733268e-01f, -1.90897882e-01f, -6.88320249e-02f,
  -3.20339054e-02f, 2.73267329e-02f, -2.78532766e-02f, -8.75366554e-02f, 4.41335738e-02f, 4.07027081e-02f, 7.88443387e-02f, -1.10169418e-01f, 1.19747847e-01f, -9.11252275e-02f,
  -1.81765929e-01f, 6.19230986e-01f, 9.46918130e-02f, -1.84468269e-01f, -1.89259663e-01f, -1.78636670e-01f, 5.84899709e-02f, 2.93509603e-01f, 3.13160457e-02f, 1.49354413e-01f,
  -6.71814829e-02f, -6.86262175e-02f, 6.50706589e-02f, 9.44607556e-02f, 2.54255295e-01f, 3.17680269e-01f, 1.35543481e-01f, 8.89992267e-02f, -2.01139171e-02f, 2.90408824e-02f,
  9.93519351e-02f, 1.87492907e-01f, 2.20714122e-01f, 1.69887051e-01f, 5.67709655e-02f, -1.03527486e-01f, 1.22217208e-01f, -2.63390522e-02f, -2.18265015e-03f, -4.08740826e-02f,
  -3.10393851e-02f, -3.04536313e-01f, 5.65066636e-02f, 8.93377960e-02f, 1.51308864e-01f, 1.83971077e-01f, 1.04877613e-01f, 1.12375431e-01f, 7.32218325e-02f, 2.53490537e-01f,
  1.54221386e-01f, -2.66843736e-02f, -5.56442514e-03f, -2.92584207e-02f, 2.35076640e-02f, 4.11015190e-02f, 1.96278784e-02f, 7.78504461e-02f, -2.32456066e-02f, 7.26541951e-02f,
  1.56000601e-02f, -1.12982698e-01f, -3.51438262e-02f, -1.73499659e-02f, -5.89289032e-02f, -8.09108168e-02f, 5.56744263e-02f, -1.33755758e-01f, -4.11811098e-02f, -1.16151780e-01f,
  2.57565826e-01f, 1.81445092e-01f, -6.09089248e-02f, -1.78482011e-01f, -5.88058233e-02f, 5.37670143e-02f, -9.53601152e-02f, 8.20591599e-02f, 5.49776200e-03f, 2.93329414e-02f,
  3.43992002e-02f, -8.71762261e-02f, -4.69439402e-02f, 2.61529908e-02f, 3.89612317e-02f, 1.63444085e-03f, -3.73096913e-02f, 4.63468814e-03f, -1.77095279e-01f, 3.05826613e-03f,
  -1.33282840e-01f, 9.40699279e-02f, 8.85985419e-02f, 5.64708896e-02f, 4.08090428e-02f, 1.24693744e-01f, 5.13228923e-02f, 1.17428191e-01f, 7.07495287e-02f, 3.33877951e-02f,
  1.87628388e-01f, -5.41436911e-01f, -1.36279792e-01f, -5.74906729e-02f, -1.66647971e-01f, 7.51235336e-02f, -3.26429754e-01f, -1.20063879e-01f, 4.04953435e-02f, 1.24391772e-01f,
  -2.72175949e-02f, 1.40584677e-01f, 1.01829946e-01f, -5.74303744e-03f, 5.12481257e-02f, -7.28339404e-02f, -7.28652254e-02f, -9.26008970e-02f, 1.32889435e-01f, 1.52089983e-01f,
  2.65508384e-01f, 7.23878946e-03f, 1.01435944e-01f, -7.58524006e-03f, -2.80417409e-02f, -2.01822948e-02f, 8.25859047e-03f, 2.37681065e-02f, 5.53911887e-02f, 1.39331341e-01f,
  -4.00948405e-01f, -4.63578522e-01f, 3.40694398e-01f, -4.12641615e-01f, -1.46722674e-01f, 2.84277424e-02f, -2.89513439e-01f, -3.40291947e-01f, -3.05997908e-01f, -2.95993090e-01f,
  -5.08865947e-03f, 2.59376109e-01f, 2.39857197e-01f, 2.94651747e-01f, 2.67128319e-01f, 1.73577741e-02f, 1.38057247e-01f, 4.23744947e-01f, 3.47992420e-01f, 1.15953526e-02f,
  -1.42257228e-01f, -3.03882807e-01f, -7.75460005e-02f, -1.50166929e-01f, -4.16935056e-01f, 2.63842419e-02f, -2.37335674e-02f, -1.92627758e-01f, -3.47937606e-02f, -1.71061426e-01f,
  2.50348091e-01f, -2.55359828e-01f, 8.94552395e-02f, -5.41234724e-02f, -1.20487541e-01f, -9.47152078e-02f, -4.72997688e-02f, -1.15806505e-01f, -5.77504151e-02f, -1.84801668e-01f,
  -1.68497846e-01f, 5.16008474e-02f, -2.47137323e-02f, -9.09006819e-02f, -1.59251407e-01f, -9.62841958e-02f, -1.16274521e-01f, -1.55176818e-01f, 5.24515612e-03f, -4.83748838e-02f,
  4.43929844e-02f, -1.00786900e-02f, 1.18850330e-02f, -6.71017021e-02f, -1.55572537e-02f, 2.44068101e-01f, -1.26909614e-01f, -8.96839648e-02f, 2.08564848e-02f, -2.24087164e-01f,
  1.84110463e-01f, -6.24446720e-02f, -6.78816363e-02f, 2.81013045e-02f, 5.92029095e-03f, -5.09990826e-02f, 1.64372344e-02f, -1.09158196e-02f, -4.89827804e-02f, -3.93137336e-02f,
  -1.65987357e-01f, 5.60872853e-02f, -1.15647521e-02f, -7.62561038e-02f, -2.95661148e-02f, -5.12962602e-02f, -1.40265062e-01f, -5.05043939e-02f, -3.70280421e-03f, -7.17997402e-02f,
  -3.85297872e-02f, -1.32000759e-01f, -4.99200933e-02f, -1.01034448e-01f, -1.60559952e-01f, -7.25619197e-02f, -2.56558601e-02f, 4.82957959e-02f, -3.89857106e-02f, -1.19434536e-01f,
  -8.51750821e-02f, 4.87910151e-01f, -3.90517600e-02f, 3.61035182e-03f, -1.65953580e-02f, -5.88496856e-04f, 7.27171227e-02f, 3.29724723e-03f, -1.11253262e-01f, 1.36271998e-01f,
  1.16413264e-02f, 2.24419273e-02f, 1.09484894e-02f, -1.46761864e-01f, -1.26744788e-02f, 8.17602426e-02f, -8.71114954e-02f, 1.90420169e-02f, 8.41841474e-02f, -7.37193599e-02f,
  -1.16838895e-01f, 1.71063647e-01f, 2.28157669e-01f, 1.62997827e-01f, 9.57189873e-02f, 2.16795936e-01f, 1.81319520e-01f, 1.74857993e-02f, 2.60473460e-01f, -3.55827175e-02f,
  3.73883963e-01f, 5.55639602e-02f, 1.73267692e-01f, 4.17894758e-02f, 1.26792610e-01f, 1.73839644e-01f, 3.73591512e-01f, 1.19482137e-01f, -6.82822093e-02f, -6.85525611e-02f,
  -2.92826891e-01f, -4.52134281e-01f, -2.47480467e-01f, -2.40019187e-01f, -2.90166028e-02f, 1.23239189e-01f, 2.20119357e-01f, 3.96953039e-02f, 5.66096008e-02f, 1.00438155e-01f,
  -8.67823232e-03f, 1.94509551e-01f, 2.90323403e-02f, 2.25582812e-02f, 5.16545549e-02f, -5.61860986e-02f, -6.87398985e-02f, 8.03417191e-02f, -5.58236381e-03f, 1.36121824e-01f,
  -1.60274908e-01f, 2.66544610e-01f, -1.61238104e-01f, -1.64625213e-01f, -1.45176649e-01f, -9.17245820e-02f, -1.44280851e-01f, -1.72915876e-01f, -2.37468146e-02f, 5.57080954e-02f,
  9.07190442e-02f, 8.85600895e-02f, -1.74511913e-02f, -3.78023065e-03f, 3.94192599e-02f, 9.52008888e-02f, -2.41263919e-02f, 6.98611885e-02f, -1.46806270e-01f, -1.31476358e-01f,
  -1.41673416e-01f, 1.20638207e-01f, 4.20393981e-02f, -1.07338615e-01f, -3.86717170e-02f, -1.26931265e-01f, 2.92384364e-02f, -3.41593847e-02f, -1.24095883e-02f, -3.31013054e-02f,
  -3.47969025e-01f, -7.88951516e-02f, 1.81223005e-02f, -1.47841141e-01f, 1.76794101e-02f, 9.25400779e-02f, -2.12479830e-02f, 1.95033494e-02f, 5.65383919e-02f, -3.12605985e-02f,
  -1.59859166e-01f, -1.22807994e-01f, -1.64991826e-01f, -7.20383152e-02f, -2.39705399e-01f, -2.41385680e-02f, -1.46051766e-02f, -1.07405603e-01f, -7.47833252e-02f, -5.72964102e-02f,
  -3.90081853e-02f, 5.44312745e-02f, 2.52111582e-03f, -7.87407681e-02f, -1.23931691e-01f, -1.59924552e-01f, -2.03797892e-01f, -1.46995947e-01f, -1.28262296e-01f, 7.01153511e-03f,
  -3.11161876e-01f, -1.55739158e-01f, 7.00243795e-03f, -2.07086117e-03f, 1.21579081e-01f, -1.13970175e-01f, -2.69885361e-01f, -1.18286155e-01f, 1.43656079e-02f, 6.02417514e-02f,
  8.78760219e-02f, 1.45509373e-02f, -4.59648222e-02f, -6.10960014e-02f, 1.54354693e-02f, 1.51850535e-02f, -2.17696186e-02f, -4.69375402e-02f, -7.64223114e-02f, -1.55751050e-01f,
  1.09525966e-02f, 5.52105084e-02f, -8.26027691e-02f, -1.45091161e-01f, -1.01069622e-01f, -2.74769906e-02f, -2.08422989e-02f, 8.82324297e-03f, -9.85871721e-03f, 5.71110584e-02f,
  -6.51198849e-02f, 5.21605551e-01f, 6.17568076e-01f, -2.34862849e-01f, 2.27126151e-01f, 3.23464841e-01f, 4.68275130e-01f, 2.20695019e-01f, 3.75187062e-02f, 2.21188128e-01f,
  3.97666901e-01f, -3.08119208e-01f, -2.15319633e-01f, -3.03740710e-01f, -1.02704585e-01f, 6.53101131e-02f, -1.42437071e-01f, -2.71955371e-01f, -3.63713235e-01f, -3.12442988e-01f,
  -3.67582470e-01f, -3.06400478e-01f, -2.26367190e-01f, -3.14674884e-01f, -2.85854161e-01f, -4.57385331e-01f, 9.43348408e-02f, -5.00420202e-03f, 8.08487535e-02f, -4.50856417e-01f,
  1.07652560e-01f, 5.79898596e-01f, -2.27794364e-01f, -1.99045241e-01f, 1.47016957e-01f, -1.41374022e-01f, 5.16450368e-02f, 4.20959480e-02f, -2.33796723e-02f, 1.66631415e-01f,
  1.04525171e-01f, 1.81532521e-02f, -6.00811057e-02f, 1.01646679e-02f, 1.00072406e-01f, 4.26249951e-02f, 2.70020626e-02f, -8.26124847e-02f, -6.40053451e-02f, 1.21215582e-01f,
  -2.75689602e-01f, 5.32171540e-02f, 3.22995991e-01f, 8.86025503e-02f, 7.63323605e-02f, -3.02493155e-01f, 2.91783333e-01f, -7.66751692e-02f, 1.59233600e-01f, -3.39840859e-01f,
  -8.42294469e-02f, 6.07994944e-02f, 1.37853161e-01f, 1.77468523e-01f, -6.67719394e-02f, 6.79081753e-02f, -9.11543667e-02f, -7.97547773e-02f, -5.65452538e-02f, -9.59235430e-02f,
  1.36401713e-01f, 1.09368697e-01f, 1.36347756e-01f, 8.03344399e-02f, -1.93718031e-01f, 6.54806867e-02f, 2.14061812e-02f, 1.92479789e-02f, 1.32477731e-01f, -1.77490398e-01f,
  -1.38719589e-01f, -1.33438319e-01f, -1.23525234e-02f, -2.59625494e-01f, 1.08538255e-01f, 4.78760265e-02f, -8.34064707e-02f, -1.37006357e-01f, 1.81752872e-02f, 2.42188901e-01f,
  -3.03577751e-01f, 2.30842873e-01f, -3.41068447e-01f, -2.21338287e-01f, -1.44245690e-02f, 7.36494288e-02f, 3.15255672e-02f, 4.66747284e-02f, 3.45646217e-02f, -1.22611649e-01f,
  2.90735990e-01f, -3.74668501e-02f, 1.58361662e-02f, 2.86614001e-02f, -8.71969610e-02f, 5.46265859e-03f, -1.82828903e-01f, -3.69858742e-02f, -2.05847070e-01f, -1.44884825e-01f,
  -2.90568233e-01f, -3.12041312e-01f, -4.71796334e-01f, -2.08314881e-01f, -2.04252884e-01f, -3.94158363e-01f, -2.19070852e-01f, -2.90233731e-01f, -2.41251618e-01f, -6.07372522e-01f,
  -6.27751946e-01f, 1.16915710e-01f, -3.55694331e-02f, -3.68524224e-01f, 4.60859358e-01f, 1.98957771e-01f, 1.53189808e-01f, -2.09432855e-01f, -1.50197133e-01f, 2.96674166e-02f,
  2.76100904e-01f, 1.21402904e-01f, 2.22639982e-02f, 9.05913562e-02f, -7.26218075e-02f, 1.17715344e-01f, 1.37663960e-01f, -1.65302932e-01f, -1.70608789e-01f, 9.95054469e-02f,
  3.05994481e-01f, -2.48476669e-01f, -4.40169871e-01f, -1.25611261e-01f, -8.77705365e-02f, 1.55566074e-02f, -1.66610256e-02f, -3.67679670e-02f, 2.10996121e-01f, 1.27987877e-01f,
  -2.12632686e-01f, -2.52405614e-01f, -4.46431525e-03f, 1.41620114e-01f, 4.79964353e-02f, -2.66678751e-01f, -1.84755370e-01f, -2.97453791e-01f, 3.17895487e-02f, -1.51931375e-01f,
  4.35741171e-02f, -1.49881998e-02f, 1.25391349e-01f, -1.73050575e-02f, -2.05557495e-01f, -8.53117034e-02f, -1.72809303e-01f, -2.34306812e-01f, -2.61433214e-01f, 1.56026930e-02f,
  4.37477678e-01f, 2.61423945e-01f, -1.46828264e-01f, 2.23358460e-02f, -1.85405195e-01f, -8.91817361e-02f, -1.21741988e-01f, -1.61655828e-01f, -3.31240267e-01f, -2.94319838e-01f,
  5.97659908e-02f, 8.34420025e-02f, 3.43028195e-02f, -1.30696967e-01f, -4.14281944e-03f, 6.09674491e-02f, 1.72759928e-02f, 9.16133225e-02f, 6.82901889e-02f, -3.37481499e-02f,
  1.00613356e-01f, 2.26071533e-02f, 3.54147628e-02f, -4.41058353e-02f, 2.29020994e-02f, -1.96892396e-02f, 8.22231919e-02f, -7.25036636e-02f, 7.86483213e-02f, 2.10115556e-02f,
  -1.69456359e-02f, -5.24748489e-02f, -1.42173231e-01f, -8.62547532e-02f, 1.36284292e-01f, -1.94827188e-02f, -6.12752587e-02f, -6.79275393e-02f, -7.03045651e-02f, -4.68417853e-02f,
  -4.36525762e-01f, -1.08996937e-02f, -2.61783570e-01f, 1.04469955e-02f, -1.19036630e-01f, 6.98931813e-02f, 2.45306306e-02f, 8.58275816e-02f, -2.49351095e-02f, -1.11206092e-01f,
  -1.00385785e-01f, -3.70742120e-02f, -1.02804951e-01f, 6.39907271e-02f, -5.50268032e-02f, -7.24832714e-02f, 1.60279334e-01f, 1.25471413e-01f, 4.71923798e-02f, 1.28099939e-03f,
  3.49065252e-02f, -1.04115359e-01f, -2.03814521e-01f, -8.72735754e-02f, -6.20497093e-02f, -2.05889389e-01f, -1.95694700e-01f, -2.20086366e-01f, -3.06652308e-01f, -4.01916206e-01f,
  8.49109590e-02f, -5.17298467e-02f, 2.63377935e-01f, 6.60898983e-02f, -1.52759468e-02f, 3.08181188e-04f, -1.12047583e-01f, 3.94957997e-02f, 9.09750909e-02f, 5.10406010e-02f,
  1.44713551e-01f, 1.86883077e-01f, 1.86375022e-01f, 1.34840548e-01f, 9.75590199e-02f, -2.08926313e-02f, 1.78101622e-02f, -5.14036119e-02f, 1.20211147e-01f, 1.78534985e-02f,
  -8.14731941e-02f, -1.02529578e-01f, -8.63755420e-02f, -4.57768142e-02f, -7.92592857e-03f, -8.34346786e-02f, 3.57076451e-02f, -1.66140676e-01f, -1.90178260e-01f, -9.92830098e-02f,
  2.83366054e-01f, 3.04151829e-02f, -1.65736377e-02f, 5.79384505e-05f, 8.83331820e-02f, -5.85916713e-02f, 1.58365250e-01f, 7.26277828e-02f, -4.78187837e-02f, -7.04054683e-02f,
  2.49349605e-02f, 1.23338468e-01f, 1.22598611e-01f, 1.40751526e-02f, 5.53967580e-02f, 7.12450817e-02f, 1.27397165e-01f, 3.59229222e-02f, 2.20980272e-02f, 1.26632988e-01f,
  1.28329635e-01f, 8.08117390e-02f, 1.60849765e-01f, 9.01104584e-02f, 1.75583865e-02f, 1.03550829e-01f, 4.06385027e-02f, 8.30038637e-02f, 6.99521303e-02f, 1.30735457e-01f,
  2.26253107e-01f, -2.00408424e-04f, 1.69391051e-01f, 2.77646452e-01f, 1.63824618e-01f, -8.30657955e-04f, -7.21029639e-02f, -9.13852379e-02f, 7.17547387e-02f, -2.36967150e-02f,
  -2.44035516e-02f, 7.00928047e-02f, 1.25674024e-01f, -2.20996380e-01f, 2.55038720e-02f, -7.67315179e-02f, -4.72303256e-02f, 7.34459758e-02f, 1.02671690e-01f, 6.01009615e-02f,
  5.99801354e-02f, -4.32336070e-02f, -1.04704238e-01f, -9.71253589e-02f, -1.66044086e-01f, -3.32309958e-03f, -6.40478125e-03f, 6.22033030e-02f, 6.57187775e-04f, -2.49118552e-01f,
  2.11085603e-01f, 2.28804737e-01f, -1.50825202e-01f, -7.71541595e-02f, -6.75397143e-02f, -4.02545109e-02f, 5.71303826e-04f, -1.36050984e-01f, -2.35034198e-01f, -1.30385339e-01f,
  -1.32240176e-01f, -4.20801248e-03f, -9.60330144e-02f, -5.81874163e-04f, -1.25851072e-02f, -1.66247077e-02f, 1.94876604e-02f, 2.83400174e-02f, -9.59836096e-02f, -5.18841706e-02f,
  -3.79800722e-02f, -4.91029471e-02f, 1.18365094e-01f, -9.24893841e-02f, -9.00741071e-02f, -8.06099772e-02f, -1.43679082e-01f, -1.15762070e-01f, -5.29958494e-02f, -8.17657039e-02f,
  1.05742492e-01f, -5.54620087e-01f, 4.28415909e-02f, 2.60638416e-01f, 1.53088361e-01f, 1.59121811e-01f, 1.44929275e-01f, 2.02498466e-01f, 1.43861905e-01f, -1.28849978e-02f,
  -3.39853525e-01f, -3.55032325e-01f, -3.51254612e-01f, -2.22191393e-01f, -1.80552319e-01f, 1.76739573e-01f, 3.12106729e-01f, 6.58103228e-02f, 1.44627377e-01f, 1.12895936e-01f,
  4.03917767e-02f, 3.09380382e-01f, 1.92249507e-01f, -3.70580740e-02f, -1.04022138e-01f, -2.39469223e-02f, 3.62605378e-02f, 2.15398803e-04f, -2.92973191e-01f, -1.87988177e-01f,
  -1.86250880e-01f, -3.75683457e-01f, 1.22669801e-01f, -1.80087924e-01f, -7.13817477e-02f, -4.18613739e-02f, 7.26424977e-02f, 7.58720189e-02f, -9.04644281e-02f, 7.00772926e-03f,
  -5.96987382e-02f, -1.09623082e-01f, -1.68565631e-01f, -6.21556751e-02f, 8.02157000e-02f, 4.51401509e-02f, -7.90648907e-02f, -1.34263799e-01f, -2.33494580e-01f, -1.34831578e-01f,
  -1.48746282e-01f, -1.76041052e-01f, -1.77803189e-01f, -7.15239123e-02f, -1.26893163e-01f, -6.93666488e-02f, -1.10173032e-01f, -1.59325406e-01f, -1.51600391e-01f, -4.23640572e-03f,
  1.65793732e-01f, -4.77427095e-02f, -1.20656647e-01f, 4.11464460e-02f, -5.41189462e-02f, -1.02438636e-01f, -1.36275187e-01f, -9.99156684e-02f, -2.74907574e-02f, -7.32254684e-02f,
  -1.46994174e-01f, -3.31462473e-02f, -1.01998776e-01f, -1.99452583e-02f, -1.32183418e-01f, -5.05045988e-02f, -8.65239501e-02f, -1.57628775e-01f, -1.53460830e-01f, -6.89013079e-02f,
  -1.17401317e-01f, -4.36990671e-02f, -9.75251943e-03f, -5.85583225e-02f, -1.82623267e-02f, -1.11191005e-01f, 6.94788843e-02f, -6.20841347e-02f, -7.40388110e-02f, 2.18490046e-03f,
  1.67165548e-01f, -1.69609442e-01f, 6.75615594e-02f, -6.26920685e-02f, 2.37834416e-02f, -3.96254174e-02f, -1.10852927e-01f, 3.33527988e-03f, 1.18091768e-02f, -1.41651154e-01f,
  -1.06421381e-01f, -1.37588575e-01f, -2.34004423e-01f, 4.80359886e-03f, 2.34068602e-01f, 1.18489563e-01f, -8.88126716e-02f, -7.15688914e-02f, -2.33899765e-02f, 8.99433419e-02f,
  3.88060100e-02f, 1.40632093e-01f, 2.91734904e-01f, 1.77959383e-01f, 6.11793110e-03f, 2.45011449e-01f, 1.57721862e-01f, 1.57169521e-01f, 1.18218891e-01f, 3.82942736e-01f,
  -4.25086141e-01f, -6.37050271e-01f, 1.29240215e-01f, -5.60960472e-01f, -3.32410038e-01f, -9.86664742e-02f, -5.49416363e-01f, -1.27912521e-01f, -1.99836623e-02f, -4.94595706e-01f,
  -1.17062360e-01f, 1.92674741e-01f, 1.18240707e-01f, 1.71625972e-01f, 1.33865088e-01f, -4.69810426e-01f, -2.94963777e-01f, 1.89740211e-01f, 3.80607545e-01f, -1.49101883e-01f,
  -3.70435864e-01f, -2.86820859e-01f, 1.25091732e-01f, 5.98723777e-02f, -5.90849161e-01f, -5.72690070e-02f, -1.77402154e-01f, -2.66123921e-01f, -2.77010679e-01f, -6.06990516e-01f,
  -2.94509888e-01f, -2.08919905e-02f, 3.61356676e-01f, 1.21071734e-01f, -1.15984343e-01f, 1.14890203e-01f, 2.95732357e-03f, 4.51618470e-02f, 4.07721363e-02f, -6.33295029e-02f,
  2.15813238e-02f, 7.78317302e-02f, -9.66836046e-03f, 1.20046670e-02f, -1.74906582e-01f, 1.80136915e-02f, 3.91851813e-02f, 7.78675601e-02f, -5.59983626e-02f, -1.94675550e-01f,
  -3.42840463e-01f, -2.82238811e-01f, -1.16269412e-02f, 6.48973659e-02f, 7.04314560e-02f, 1.47975102e-01f, 5.45176901e-02f, 1.51036726e-02f, 1.40344620e-01f, -4.50013369e-01f,
  -9.22163427e-02f, 2.40100771e-02f, 3.42574902e-02f, 1.66738722e-02f, 9.10755247e-02f, 1.91874318e-02f, -8.68572295e-02f, -8.44900981e-02f, 9.68881547e-02f, -1.26343280e-01f,
  -5.49692102e-02f, -2.07322352e-02f, 2.75758728e-02f, -1.54656276e-01f, -2.64033377e-02f, -1.22312456e-01f, -1.56656623e-01f, -1.65856451e-01f, -5.72031774e-02f, 8.87326803e-03f,
  3.43307070e-02f, -1.37900421e-02f, -2.06801668e-02f, -1.72747225e-02f, 1.04544967e-01f, 1.75727736e-02f, 8.35581273e-02f, 4.74497750e-02f, -9.18371230e-02f, 3.69951427e-02f,
  -9.68323871e-02f, 4.40636307e-01f, -1.65462956e-01f, 6.15177602e-02f, -1.33225009e-01f, 1.75494924e-02f, 7.08058253e-02f, 2.23833710e-01f, 5.74018545e-02f, -1.12987056e-01f,
  -1.66024622e-02f, -9.85097885e-02f, -2.15752479e-02f, 1.31867155e-02f, 3.68432608e-03f, 6.84233680e-02f, -2.05652863e-01f, -1.93782359e-01f, 3.32169048e-02f, -1.39132500e-01f,
  -2.63249010e-01f, -2.31975272e-01f, -2.15509742e-01f, -9.66591910e-02f, -2.21051961e-01f, 5.32111898e-02f, -6.75909594e-02f, -1.82077602e-01f, 4.71375175e-02f, -5.31178117e-01f,
  6.65117621e-01f, 3.80411625e-01f, -3.03554982e-01f, 4.08532917e-01f, -4.54864383e-01f, -5.05569100e-01f, -4.23338488e-02f, 2.17083395e-01f, 3.54746073e-01f, 3.66823971e-01f,
  -2.02484056e-01f, -5.09764075e-01f, -6.81291223e-02f, -2.63757646e-01f, -1.40175328e-01f, 3.89969319e-01f, 2.98390269e-01f, -1.91256374e-01f, -8.39797437e-01f, -5.87186635e-01f,
  -1.72032356e-01f, 1.03531860e-01f, 1.52682796e-01f, 2.52828095e-03f, 3.36012602e-01f, -1.52607784e-02f, 3.39712054e-01f, 9.42653492e-02f, -3.63741517e-02f, 4.18021351e-01f,
  -1.26359582e-01f, 1.78845450e-01f, -4.66358513e-01f, -1.98627651e-01f, -8.79907981e-02f, 1.24835938e-01f, -8.44231397e-02f, -1.28156999e-02f, -7.98325017e-02f, 9.78830159e-02f,
  -2.48620555e-01f, -1.76681846e-01f, -3.10392529e-01f, -8.98539741e-03f, -4.64510955e-02f, -1.02178991e-01f, 2.34958693e-01f, 4.78171855e-02f, 1.05289429e-01f, -1.23820074e-01f,
  -2.40135074e-01f, -3.76318008e-01f, -3.54237378e-01f, -1.09510824e-01f, -8.13607946e-02f, -3.33101213e-01f, -1.74742699e-01f, -1.60933122e-01f, -8.73291641e-02f, 5.43713868e-01f,
  1.10885188e-01f, 4.91982773e-02f, 3.10625695e-02f, 1.36999741e-01f, 1.57316312e-01f, 3.33667919e-02f, 8.48947540e-02f, 8.85477941e-03f, 1.80346183e-02f, 1.12444542e-01f,
  7.59969559e-03f, -2.52169091e-02f, -7.37742558e-02f, 6.28077984e-02f, 3.53232846e-02f, -5.90274259e-02f, -1.23210670e-02f, 1.37294099e-01f, -1.74255837e-02f, 9.53554064e-02f,
  -1.12249546e-01f, -9.19982791e-02f, -5.19198403e-02f, -3.18545033e-03f, -4.52788658e-02f, -2.44744495e-02f, -8.85513127e-02f, -6.85002729e-02f, 8.87447819e-02f, -6.94569871e-02f,
  1.96013302e-01f, -2.84929216e-01f, 2.23288223e-01f, 2.35132724e-02f, 8.41930136e-02f, 1.80182289e-02f, -2.32081059e-02f, -7.47696357e-03f, -5.29744513e-02f, -7.07957447e-02f,
  -2.47213438e-01f, -5.58127873e-02f, 1.06696203e-01f, 2.51295473e-02f, -2.25848541e-01f, 5.02057653e-03f, 1.60461411e-01f, -1.39247179e-01f, -1.56408295e-01f, -5.48698627e-05f,
  1.77065030e-01f, -6.80293441e-02f, 1.86090097e-02f, 4.88098897e-02f, 2.37232093e-02f, -2.62113661e-01f, -4.74022180e-02f, -6.13035224e-02f, -2.12156504e-01f, 5.54406643e-01f,
  4.18823093e-01f, -1.93384916e-01f, 3.82169634e-01f, 2.15004668e-01f, 1.74872369e-01f, 1.11191235e-01f, -3.45692597e-02f, -7.21619204e-02f, -3.04647926e-02f, -2.17713155e-02f,
  -3.89923722e-01f, -4.06689972e-01f, -4.00739759e-01f, -3.25618178e-01f, -1.72025219e-01f, 2.79316217e-01f, 3.76318932e-01f, 3.94082397e-01f, 2.15451494e-01f, 5.77860288e-02f,
  -3.08570303e-02f, 2.40474984e-01f, 2.02376202e-01f, 1.64646178e-01f, 9.97852683e-02f, -9.84712988e-02f, 2.02038456e-02f, 2.10589126e-01f, -2.97954883e-02f, 1.79614604e-01f,
  -4.25356664e-02f, 1.12432064e-02f, -5.98333515e-02f, -3.52557123e-01f, -1.69656470e-01f, -7.71930814e-02f, 1.13315387e-02f, -1.99541766e-02f, -1.01862326e-01f, 1.82659835e-01f,
  -1.34438589e-01f, -8.55262280e-02f, -2.41934568e-01f, -4.49625589e-02f, 1.06404625e-01f, 5.62503114e-02f, 1.35179348e-02f, 7.43647665e-02f, -1.27166420e-01f, -8.10530484e-02f,
  -3.44719917e-01f, 5.90776876e-02f, 1.97898537e-01f, -1.65059268e-01f, -4.85637151e-02f, -1.27257016e-02f, 2.84468513e-02f, 8.06866959e-03f, -6.55601406e-03f, 8.86379033e-02f,
  -1.11826144e-01f, -2.14703884e-02f, -5.52371666e-02f, 8.93804953e-02f, 5.80659043e-03f, -7.52330944e-02f, -2.99986135e-02f, -1.75258629e-02f, -3.96886766e-02f, 1.67537227e-01f,
  -3.78489383e-02f, 3.28106955e-02f, 8.67341235e-02f, 1.53025715e-02f, -1.91381257e-02f, -2.05679387e-02f, 1.09352991e-01f, 2.11645660e-04f, -1.43084824e-01f, -7.62586743e-02f,
  5.72124980e-02f, 7.59320110e-02f, -5.39814010e-02f, 4.43404168e-02f, -6.52163029e-02f, 1.00794740e-01f, 1.37688905e-01f, -7.97670037e-02f, 9.28994454e-03f, -1.00172986e-03f,
  -3.86816174e-01f, -5.98834455e-01f, 7.94150010e-02f, -2.02696636e-01f, 3.55401076e-02f, -1.52873337e-01f, -2.51463950e-01f, -1.81076437e-01f, 4.79468219e-02f, 3.18346508e-02f,
  -3.62358019e-02f, -1.06677987e-01f, -3.01046371e-01f, -6.43212125e-02f, 1.49879649e-01f, 8.25321823e-02f, 1.80242136e-02f, 2.45638434e-02f, -1.04345284e-01f, 8.89724195e-02f,
  -7.20052347e-02f, 2.07213998e-01f, 1.47928998e-01f, 3.67745832e-02f, -5.89748435e-02f, 9.32960138e-02f, 1.47058815e-01f, 2.52487734e-02f, 1.08778387e-01f, 1.94714099e-01f,
  4.20842528e-01f, 3.90856057e-01f, 2.22264826e-01f, 2.19245508e-01f, 2.42759436e-01f, 2.97979355e-01f, 4.84653622e-01f, 2.60151207e-01f, -6.01146650e-03f, 7.14407638e-02f,
  5.31278700e-02f, 8.49244073e-02f, 1.43322945e-01f, 1.14197329e-01f, 1.52981579e-01f, 4.03505079e-02f, 8.20379108e-02f, 4.48685847e-02f, -2.17827386e-03f, 1.54197454e-01f,
  1.05958186e-01f, 1.42275393e-01f, 1.61044121e-01f, 6.05430566e-02f, 6.18268363e-03f, 1.15961051e-02f, 1.39996931e-01f, 1.96079791e-01f, 9.81830060e-02f, -9.89132151e-02f,
  -1.87286869e-01f, 2.52120346e-01f, -3.50853145e-01f, -2.15329334e-01f, -7.03350976e-02f, -1.75933316e-01f, 4.10759225e-02f, -1.02802701e-01f, -9.00328904e-02f, -4.25554439e-02f,
  -2.17978302e-02f, -1.14802405e-01f, -2.75807865e-02f, 6.09259643e-02f, -4.40180227e-02f, -1.60619188e-02f, -1.07511416e-01f, -8.69962201e-02f, -2.99682934e-02f, -6.23220094e-02f,
  -6.64678514e-02f, -9.95874964e-03f, 1.25419527e-01f, 1.41497031e-02f, 1.35580719e-01f, -1.02946036e-01f, -8.24839324e-02f, -6.78174049e-02f, 7.88291097e-02f, -9.55948457e-02f,
  -1.83955625e-01f, -8.26621503e-02f, 2.68594027e-02f, -5.07701002e-02f, 5.21751903e-02f, -1.44604355e-01f, -1.02429658e-01f, 5.90108000e-02f, -5.91874942e-02f, -4.74309064e-02f,
  -9.94193405e-02f, -7.30351210e-02f, -4.69890796e-02f, 1.15575176e-03f, -4.40008901e-02f, 3.61427553e-02f, -2.59026536e-04f, -8.40144455e-02f, 1.13582596e-01f, -3.77351269e-02f,
  7.34572858e-02f, -1.43870339e-01f, -9.63994786e-02f, -1.81565627e-01f, -2.20008209e-01f, -1.51087180e-01f, -2.18798667e-01f, -1.13478512e-01f, -8.46437216e-02f, -8.38293657e-02f,
  -2.78030992e-01f, 1.73665196e-01f, -1.79972708e-01f, -8.40168223e-02f, 8.34738240e-02f, -9.24850628e-02f, 1.17810853e-01f, -4.15727422e-02f, -1.63005870e-02f, -6.15010597e-02f,
  2.32131016e-02f, -9.34207961e-02f, 3.80881131e-02f, 4.67515551e-02f, -7.98900276e-02f, -6.02530316e-02f, -4.65870686e-02f, -4.71961237e-02f, -6.51284456e-02f, -1.92875117e-01f,
  -1.45136744e-01f, -1.15857020e-01f, -6.16226159e-02f, 6.31487817e-02f, 3.20072286e-02f, -2.68355906e-01f, -8.21030736e-02f, -1.15056254e-01f, -2.31456701e-02f, -8.85029286e-02f,
  2.35615790e-01f, 3.39667320e-01f, -3.86467576e-01f, 2.21008390e-01f, 3.89665753e-01f, -1.14995718e-01f, -7.50737488e-02f, -2.61562228e-01f, -1.26355857e-01f, 1.74245894e-01f,
  3.69110495e-01f, 1.16633274e-01f, -1.42820075e-01f, -3.89719367e-01f, -4.44929659e-01f, -3.20451796e-01f, -4.71027523e-01f, -5.30119956e-01f, -4.61492091e-01f, 3.64146270e-02f,
  3.67570341e-01f, 4.81391281e-01f, 1.44799337e-01f, -1.84410587e-01f, 2.09885836e-01f, -1.17040668e-02f, 8.99114832e-02f, 2.99872488e-01f, 1.04983523e-01f, -9.95464996e-02f,
  -4.75955419e-02f, 1.72991201e-01f, -1.87329933e-01f, 1.53979138e-01f, 1.91894561e-01f, 1.08175658e-01f, 7.24853724e-02f, 8.39521140e-02f, 2.16427729e-01f, 5.51839173e-02f,
  2.31102347e-01f, 1.26937941e-01f, 1.00083433e-01f, 1.02244258e-01f, 1.59640372e-01f, -1.49202142e-02f, -1.09520137e-01f, -3.22478831e-01f, -3.18403572e-01f, -1.52368188e-01f,
  1.86848089e-01f, 2.08700433e-01f, 3.56760956e-02f, -1.08109057e-01f, -1.61924869e-01f, 3.13871056e-02f, 6.53935820e-02f, -6.48437962e-02f, -2.46522114e-01f, -4.97412495e-02f,
  4.16709147e-02f, 5.04562864e-03f, 2.08178647e-02f, 1.19718179e-01f, 1.70806855e-01f, -1.53554520e-02f, 6.01263754e-02f, 8.82503763e-02f, -1.06725648e-01f, 1.29947528e-01f,
  -1.05698340e-01f, -2.04230845e-02f, -2.77762674e-02f, 2.81248540e-02f, -3.76308337e-02f, 2.08934471e-01f, 5.16293682e-02f, 9.03050378e-02f, -6.49847239e-02f, 1.81219980e-01f,
  3.09232362e-02f, -4.14184034e-02f, 1.28221080e-01f, -3.13084424e-02f, 1.30297601e-01f, 1.74686555e-02f, 4.12528254e-02f, 2.20357686e-01f, 1.50327474e-01f, 2.32639804e-01f,
  1.94572255e-01f, 5.94576895e-02f, -5.41781001e-02f, -2.18163833e-01f, 3.15552428e-02f, -4.58996259e-02f, 3.92978787e-02f, -1.89826470e-02f, 2.34647870e-01f, 1.03342578e-01f,
  5.00659794e-02f, -6.78069666e-02f, -7.43819624e-02f, -1.16970651e-01f, -8.96169543e-02f, -7.63606280e-02f, -3.50094624e-02f, -1.75633188e-03f, -2.12551847e-01f, -3.40639651e-02f,
  -3.55591774e-02f, -5.15950359e-02f, -1.19158447e-01f, -1.72733709e-01f, -9.79162008e-03f, -4.85282317e-02f, 3.02742701e-02f, 3.30182053e-02f, -1.87526345e-01f, 1.06321320e-01f,
  -7.40147173e-01f, -2.66676992e-01f, -2.14848757e-01f, -8.00841033e-01f, -8.73408616e-02f, 3.43503863e-01f, 5.09899735e-01f, 1.67220265e-01f, -2.27029830e-01f, -6.99786693e-02f,
  6.13088347e-02f, -7.57222623e-02f, -3.64360064e-01f, 4.82487865e-02f, 2.86074162e-01f, 9.77913383e-03f, -2.38582343e-01f, 6.94138044e-03f, 5.30838788e-01f, 6.02332950e-01f,
  2.41545841e-01f, -2.02281371e-01f, -2.56678730e-01f, -1.09338723e-01f, -3.56120586e-01f, -1.97831407e-01f, -5.41657805e-01f, -2.29915813e-01f, -5.47652273e-03f, -4.51739699e-01f,
  3.24954718e-01f, -4.22978848e-01f, 1.16624780e-01f, -1.52547047e-01f, -1.46598980e-01f, -5.44138849e-02f, 9.47216526e-02f, -1.94055662e-01f, -1.42060190e-01f, -7.93026611e-02f,
  -2.45089367e-01f, 1.61796454e-02f, -8.98419842e-02f, 1.80432126e-02f, -5.27434722e-02f, 1.24248601e-01f, -7.72266909e-02f, -8.58314037e-02f, -1.54427335e-01f, 1.43863305e-01f,
  -2.00283900e-02f, -4.60838974e-02f, -1.04096584e-01f, 5.06973825e-02f, 1.21232718e-01f, -4.74422909e-02f, 1.52832922e-02f, 1.43962517e-01f, 8.29234645e-02f, -7.04584569e-02f,
  1.43350869e-01f, 2.99405456e-02f, 7.57720545e-02f, 4.91234846e-03f, 1.13432974e-01f, 5.46906628e-02f, -6.12726323e-02f, -3.08641549e-02f, -2.90196342e-03f, -4.92044054e-02f,
  -5.64826131e-02f, 4.64034639e-02f, 2.04440411e-02f, -4.17259298e-02f, -1.15013443e-01f, -1.98546931e-01f, 1.52974986e-02f, 9.37345028e-02f, -1.24151759e-01f, -1.35355785e-01f,
  -3.71602327e-02f, -1.18571319e-01f, -1.01275608e-01f, -3.14168595e-02f, 1.51236961e-02f, -7.29613975e-02f, -1.33745328e-01f, 1.04765862e-01f, 3.06648668e-02f, 1.89099535e-02f,
  -9.41188186e-02f, 1.05205722e-01f, -4.97404560e-02f, -7.87120610e-02f, -2.55341619e-01f, -9.60157067e-02f, -2.48362780e-01f, -3.03594377e-02f, -1.27274260e-01f, 1.27332225e-01f,
  1.08712032e-01f, 1.29530989e-02f, -8.35475177e-02f, 2.51999917e-03f, 1.25104353e-01f, 6.89251944e-02f, -2.73452513e-02f, -4.01891991e-02f, -7.55224004e-02f, -4.39390428e-02f,
  -9.49715003e-02f, 1.35728985e-01f, 1.76837191e-01f, 6.77720830e-02f, 5.34390695e-02f, 2.37958029e-01f, 2.18457729e-01f, 1.58102319e-01f, 1.91944197e-01f, 2.08733842e-01f,
  7.55364895e-01f, 4.45616961e-01f, 4.45896126e-02f, 1.46537513e-01f, -3.13110985e-02f, -9.24478620e-02f, 1.11858651e-01f, 8.33934173e-02f, 4.43823338e-02f, 2.36618653e-01f,
  2.33405083e-01f, 2.59670675e-01f, 7.51272067e-02f, 1.43190280e-01f, -3.87711381e-03f, 4.60214773e-03f, -7.76658282e-02f, 9.30412561e-02f, 1.03739239e-02f, 2.14782044e-01f,
  8.09915885e-02f, 1.06169105e-01f, 2.13617995e-01f, 1.03356108e-01f, 1.25322834e-01f, 5.20223156e-02f, 6.48041666e-02f, 1.56439781e-01f, 1.77179784e-01f, 2.12465882e-01f,
  1.17843181e-01f, 4.32854265e-01f, -3.59630078e-01f, -5.94352856e-02f, 3.76498550e-02f, -3.22284214e-02f, -8.14546496e-02f, -1.15175039e-01f, -9.50011536e-02f, -1.24547534e-01f,
  -1.14303626e-01f, 5.91342822e-02f, 8.47009569e-02f, -3.15289199e-02f, -5.79514839e-02f, -1.87864143e-03f, 1.15243755e-01f, 9.80799869e-02f, -3.25418785e-02f, -4.18468714e-02f,
  4.13329862e-02f, 5.96648715e-02f, -6.01967573e-02f, -2.10338503e-01f, -7.13899434e-02f, -1.46782055e-01f, 8.55107792e-03f, 9.82401595e-02f, -9.53561440e-02f, 2.07118154e-01f,
  7.51411244e-02f, 1.79467738e-01f, 1.46883383e-01f, 1.05727404e-01f, 1.85957596e-01f, 8.74365270e-02f, 7.28324056e-02f, 3.66231129e-02f, 6.48979917e-02f, -5.34606688e-02f,
  -3.12790386e-02f, -2.57853754e-02f, -1.09126993e-01f, -1.01883439e-02f, -3.50100100e-02f, -7.49982893e-02f, -3.28767635e-02f, -6.10717982e-02f, -1.09944887e-01f, -8.35964233e-02f,
  5.39361052e-02f, -8.76368210e-02f, 6.67577982e-02f, -9.55443177e-03f, -7.41953924e-02f, -5.12046777e-02f, -9.33847725e-02f, 2.09952937e-04f, -1.03075720e-01f, -1.92411505e-02f,
  -5.62278390e-01f, -2.15446383e-01f, 7.34696612e-02f, -1.88130117e-03f, 1.02534369e-01f, 1.29696052e-03f, 1.43712938e-01f, 3.93440649e-02f, -4.10772711e-02f, -3.98167036e-02f,
  -7.22499713e-02f, -2.38547791e-02f, -7.93095753e-02f, -8.60224292e-03f, -7.32926130e-02f, -3.03025749e-02f, 8.40685740e-02f, -6.37392104e-02f, -5.93575239e-02f, -7.45438337e-02f,
  -1.34842694e-01f, -2.02265576e-01f, -2.07144767e-01f, -1.83220118e-01f, -1.26925677e-01f, -8.25543106e-02f, -1.90308720e-01f, -1.94050580e-01f, -1.07354783e-01f, -1.85750276e-01f,
  -6.26663923e-01f, 2.84092814e-01f, 1.79815978e-01f, -3.03671330e-01f, 4.40036267e-01f, 2.55683124e-01f, 3.10793258e-02f, -3.12844008e-01f, -2.64529347e-01f, 1.53478207e-02f,
  2.60541052e-01f, -8.56171269e-03f, -8.04853514e-02f, -3.10064219e-02f, -1.73495442e-01f, 8.09304044e-02f, 1.79069340e-01f, -1.65222093e-01f, -2.17062473e-01f, 1.06733605e-01f,
  1.70804754e-01f, -2.05010474e-01f, -3.17875326e-01f, -2.24000826e-01f, 2.53980365e-02f, -9.84923318e-02f, 8.63440568e-04f, 8.69459137e-02f, 2.37038985e-01f, 2.56963640e-01f,
  -2.90976260e-02f, -2.26593480e-01f, 8.16675089e-03f, 9.62746963e-02f, 1.45368218e-01f, -2.40357757e-01f, -1.99226737e-01f, -1.63377300e-01f, 1.25201747e-01f, -5.92242777e-02f,
  1.77793220e-01f, 1.45450667e-01f, 1.37744695e-01f, -8.68070498e-02f, -2.71234453e-01f, -1.80549607e-01f, -1.08859085e-01f, -3.21026891e-01f, -2.55799890e-01f, -1.09367251e-01f,
  3.01671624e-01f, 2.31167659e-01f, -9.54778492e-02f, -7.75533319e-02f, -2.62964308e-01f, -1.96574867e-01f, -1.60680935e-01f, -2.37058982e-01f, -3.10961157e-01f, -2.29839668e-01f,
  1.96156204e-02f, 1.57604545e-01f, 9.54791680e-02f, 1.43619941e-03f, 4.64335177e-03f, 5.69775291e-02f, 4.79347892e-02f, -3.41722853e-02f, -7.47976080e-02f, -6.93974644e-02f,
  3.00965104e-02f, -2.35528480e-02f, -1.09101519e-01f, 5.67109510e-03f, -9.23860222e-02f, -4.75750538e-03f, 6.77909479e-02f, -1.16193024e-02f, 1.04823150e-01f, -5.29894195e-02f,
  -1.60578728e-01f, 2.17376221e-02f, 3.80659699e-02f, -4.56651822e-02f, 1.36906326e-01f, -9.02383924e-02f, -6.55519515e-02f, -1.12023219e-01f, -1.60074383e-01f, -1.19132333e-01f,
  -3.35684091e-01f, 1.02286249e-01f, -1.17298134e-01f, -8.61594919e-03f, -1.68248825e-02f, 3.11523583e-02f, -9.68825892e-02f, 7.05142692e-02f, 5.85905612e-02f, -1.43201798e-01f,
  3.30270529e-02f, -3.97138624e-03f, -1.10492319e-01f, -4.32665087e-02f, -1.70113295e-01f, -3.56483683e-02f, 5.45356087e-02f, -6.83211684e-02f, -6.04749806e-02f, -6.54995218e-02f,
  -2.39359736e-02f, -2.26292178e-01f, -3.09629738e-01f, -2.56230861e-01f, -1.54930696e-01f, -3.93074334e-01f, -2.49402121e-01f, -2.68263876e-01f, -3.10259581e-01f, -3.87217075e-01f,
  1.71283018e-02f, 7.45889097e-02f, 1.73857838e-01f, 3.31071094e-02f, -1.41726390e-01f, -2.58943886e-01f, -2.91481078e-01f, -2.11856455e-01f, -1.41332401e-02f, -1.41055122e-01f,
  -2.82924950e-01f, -1.58818644e-02f, -1.49788400e-02f, 1.54130295e-01f, 8.31096545e-02f, 2.49009654e-01f, 3.87069017e-01f, 4.23078775e-01f, 1.90719098e-01f, 4.42702807e-02f,
  2.12683603e-01f, 1.08260892e-01f, 9.19874460e-02f, 2.24803135e-01f, 2.55908221e-01f, 1.26524627e-01f, -3.50956758e-03f, 3.78831290e-02f, 1.23813801e-01f, 6.21281683e-01f,
  1.02102481e-01f, -3.25938135e-01f, -2.14167356e-01f, -5.81382327e-02f, 4.74770181e-02f, 1.23045757e-01f, 4.28543389e-02f, 1.86940715e-01f, -4.04452905e-03f, 1.47748187e-01f,
  1.06126957e-01f, 2.82203928e-02f, 2.17494499e-02f, -2.38569099e-02f, -1.83924809e-01f, -2.34554976e-01f, 5.41454321e-03f, 7.15610534e-02f, 1.16724577e-02f, 8.65634158e-02f,
  1.44438937e-01f, -1.69505924e-01f, -4.43936229e-01f, -2.95633227e-01f, -1.74731165e-01f, -1.12580188e-01f, -3.27952653e-01f, -8.44005793e-02f, -4.86474067e-01f, 1.24355420e-01f,
  -1.53365195e-01f, -4.15925011e-02f, 6.07185662e-02f, 2.46625602e-01f, 1.07000068e-01f, 1.26597673e-01f, 1.07195996e-01f, 4.72506210e-02f, 1.01758800e-01f, 9.82367620e-02f,
  6.62721619e-02f, 7.62661872e-03f, 1.77435234e-01f, 1.45915389e-01f, -1.28426999e-01f, -4.13389653e-02f, 1.15919665e-01f, -7.83798024e-02f, -1.12925798e-01f, -4.72137481e-02f,
  -1.51829375e-02f, 1.54776707e-01f, 6.63113818e-02f, 3.03809047e-01f, 1.94846317e-02f, 1.41126048e-02f, 9.44937766e-02f, -4.33316417e-02f, -9.98840407e-02f, -1.31687716e-01f,
  -3.38233173e-01f, -5.33303559e-01f, 9.14972425e-02f, 1.03901647e-01f, 9.53282639e-02f, -1.99521765e-01f, 5.79410326e-03f, -5.43870917e-03f, -1.01166658e-01f, -2.36414094e-02f,
  -8.41510817e-02f, 6.22530803e-02f, -4.44384553e-02f, 5.53952046e-02f, -2.73973010e-02f, -2.25877494e-01f, -2.94741504e-02f, 3.80917676e-02f, -8.66893977e-02f, 8.85336474e-03f,
  1.11045763e-01f, -3.28605145e-01f, -3.18884075e-01f, -3.61353844e-01f, -1.59196287e-01f, -2.32986152e-01f, -3.14163297e-01f, -2.43379265e-01f, -5.84561706e-01f, -3.44224960e-01f,
  7.88576961e-01f, -3.75572503e-01f, -5.01152456e-01f, 2.10505389e-02f, -1.00360490e-01f, -1.02332883e-01f, -2.79289812e-01f, -1.83209497e-02f, 1.64119586e-01f, -1.72495469e-01f,
  -2.01550841e-01f, 9.48154926e-02f, -7.83029050e-02f, -7.17721954e-02f, -8.78526270e-02f, -4.27429318e-01f, -4.61382985e-01f, -1.24703668e-01f, 1.31473407e-01f, 4.31558825e-02f,
  -1.21621780e-01f, -5.80527559e-02f, 3.11805997e-02f, -8.20314139e-02f, -1.77041158e-01f, -1.20277721e-02f, -3.38883102e-01f, -2.85509467e-01f, -2.00188726e-01f, -4.81146097e-01f,
  -6.20916188e-01f, 2.18612313e-01f, 7.86220953e-02f, 1.48506820e-01f, 3.42087261e-02f, 7.52618238e-02f, 1.08880885e-01f, 4.58642142e-03f, 1.43066168e-01f, -9.72049013e-02f,
  -3.85190509e-02f, 5.99101484e-02f, -5.24434112e-02f, 1.78382248e-02f, 3.04681975e-02f, 1.11756995e-01f, 1.12833425e-01f, 1.79606140e-01f, -2.83608828e-02f, -1.38034876e-02f,
  -1.13502830e-01f, 1.33071050e-01f, 6.63982928e-02f, 2.19300941e-01f, 2.38480076e-01f, 1.36605218e-01f, 1.58013120e-01f, 1.87227175e-01f, 5.47178499e-02f, 1.42129511e-01f,
  -3.78431976e-02f, -5.48578613e-03f, 6.05479069e-02f, 2.08676025e-01f, 1.86474636e-01f, 1.05673976e-01f, 1.44397244e-01f, -9.31313708e-02f, 6.24596886e-02f, 1.52362004e-01f,
  -1.25678211e-01f, -7.51290917e-02f, 9.75135937e-02f, 6.79221284e-03f, -1.40164599e-01f, -3.85428704e-02f, 5.74477650e-02f, -3.68647613e-02f, -7.87495449e-02f, -1.44476732e-02f,
  1.18740480e-02f, -1.02483995e-01f, -1.38519704e-01f, -6.20317236e-02f, -8.25595111e-02f, 2.55064275e-02f, -3.88735719e-02f, -1.07414968e-01f, -1.54274523e-01f, -9.12352279e-02f,
  -2.56702513e-01f, 1.93409935e-01f, -2.35086344e-02f, -2.53830384e-02f, -7.04342872e-02f, 7.15275332e-02f, 8.87497663e-02f, -1.85260586e-02f, -1.15695950e-02f, -8.11022073e-02f,
  3.46860645e-04f, 7.58201331e-02f, -8.16862732e-02f, -6.68205544e-02f, 8.93206000e-02f, 7.90143684e-02f, 2.35708609e-01f, 9.43649486e-02f, -2.15566214e-02f, -1.41142815e-01f,
  -1.08112097e-02f, 1.44564003e-01f, 1.49083033e-01f, 2.09543154e-01f, 1.04339503e-01f, 1.15337797e-01f, 1.02084331e-01f, 7.85307512e-02f, 5.31275906e-02f, 1.22879535e-01f,
  -4.61437404e-02f, 6.61691576e-02f, -3.53108197e-01f, 5.27582392e-02f, -9.28202586e-04f, -1.32331103e-01f, -1.97112098e-01f, -1.54174611e-01f, 1.61383823e-01f, 8.74837786e-02f,
  7.84855038e-02f, -9.90133286e-02f, -2.18929350e-01f, -3.50975722e-01f, -6.19571209e-01f, -3.40134889e-01f, -3.64221096e-01f, -5.59654236e-01f, -5.34850121e-01f, -1.29504845e-01f,
  1.59918185e-04f, -9.68643352e-02f, -3.21290702e-01f, -1.74388692e-01f, 2.91159868e-01f, -6.47745132e-02f, -1.09616801e-01f, -4.45078947e-02f, -1.62281811e-01f, -4.98538837e-02f,
  1.98280141e-01f, 2.78394874e-02f, -2.80077886e-02f, -1.91753253e-01f, 9.05790403e-02f, 8.12515840e-02f, 6.62477389e-02f, -3.88851645e-03f, -1.07476138e-01f, -4.68484946e-02f,
  4.24332768e-02f, 1.23657234e-01f, 8.08224902e-02f, -2.90552769e-02f, 2.62852246e-03f, 8.67941976e-03f, -1.46871820e-01f, -2.60378987e-01f, -1.13669761e-01f, 2.97165234e-02f,
  5.65063283e-02f, -2.48989630e-02f, -3.54082465e-01f, -1.70860082e-01f, 6.43282160e-02f, -5.86281866e-02f, 4.59459461e-02f, 7.88391009e-02f, -2.03944653e-01f, 1.22530095e-01f,
  1.35331467e-01f, -4.47447747e-02f, 4.68557589e-02f, 6.68349490e-02f, 4.86501381e-02f, 7.57257715e-02f, 2.21147165e-02f, -4.42054272e-02f, -7.33870734e-03f, 5.33616580e-02f,
  -5.65703139e-02f, 8.36284235e-02f, 1.29387468e-01f, 3.89359109e-02f, -1.93320125e-01f, -1.87316731e-01f, -1.16895400e-01f, -5.05139790e-02f, -1.53923437e-01f, -2.78032664e-02f,
  -8.59742463e-02f, 3.08420118e-02f, 6.74197748e-02f, -1.07276522e-01f, -3.22536305e-02f, -1.32855959e-03f, 1.95866421e-01f, 4.40195054e-02f, -4.97396886e-02f, -3.15744765e-02f,
  2.40954068e-02f, -2.95505315e-01f, 6.73304722e-02f, -1.28730312e-01f, -3.79261561e-02f, 1.92947417e-01f, 5.24064116e-02f, 2.24989969e-02f, -2.90615596e-02f, -8.59288946e-02f,
  -1.26909301e-01f, 9.08755437e-02f, -3.83549519e-02f, -3.02980747e-02f, -8.47013444e-02f, 7.24228285e-03f, -9.19609144e-02f, -1.73347637e-01f, -2.32985824e-01f, 2.68037975e-01f,
  -4.24354412e-02f, -2.96271861e-01f, -4.73211348e-01f, -3.24847490e-01f, 1.09650239e-01f, -2.02560514e-01f, -2.08259076e-01f, -7.32283667e-02f, -3.62821847e-01f, -1.38281271e-01f,
  1.33508965e-01f, -7.46963322e-02f, 2.73611635e-01f, 1.57225832e-01f, -2.62450814e-01f, -2.34417617e-01f, -4.90082383e-01f, -1.75869718e-01f, 1.33900926e-03f, 7.20516220e-02f,
  -3.49757597e-02f, 1.31439611e-01f, 1.51063830e-01f, 8.36951509e-02f, 5.94797544e-02f, 2.03995388e-02f, 3.72910649e-02f, 3.23318630e-01f, 1.96886003e-01f, -1.20990425e-01f,
  6.09747916e-02f, 2.89549902e-02f, 1.76069900e-01f, 1.37612715e-01f, 2.31228784e-01f, 1.12758256e-01f, 3.49601172e-02f, 6.17358275e-02f, -4.71289717e-02f, 3.24753642e-01f,
  3.60106081e-01f, 2.39263207e-01f, 1.97374061e-01f, 1.54160723e-01f, 8.24512914e-03f, 1.79633759e-02f, 3.10483072e-02f, -3.56448740e-02f, -1.92882374e-01f, -3.77873518e-02f,
  1.08607560e-01f, 4.01403522e-03f, -3.40728387e-02f, -1.21047892e-01f, -1.27672538e-01f, 3.55805382e-02f, -3.55017595e-02f, -3.42866853e-02f, 2.06941068e-02f, 1.20829985e-01f,
  8.35111365e-02f, -4.72112605e-03f, -9.85459760e-02f, -1.80652440e-01f, 1.10451911e-04f, -2.24956730e-03f, -2.31212862e-02f, 4.41869348e-02f, -2.30056327e-02f, -7.47231692e-02f,
  -1.06934085e-02f, -7.74220824e-02f, 2.13165253e-01f, -5.92028908e-02f, -1.00829676e-01f, -2.12181047e-01f, -1.14401922e-01f, -1.49832353e-01f, -4.15826067e-02f, -5.29754609e-02f,
  -1.37203485e-01f, 1.85049288e-02f, 4.53869700e-02f, -1.71737578e-02f, 2.86943257e-01f, 1.06259733e-01f, -1.88330356e-02f, -6.82558352e-03f, 1.14011891e-01f, 1.38073802e-01f,
  -5.61002176e-04f, -1.45330951e-01f, -3.42367925e-02f, 9.25492421e-02f, 9.32954624e-02f, -1.42636383e-02f, 4.12671715e-02f, -4.28687446e-02f, -1.20439507e-01f, -4.21966314e-02f,
  1.43528193e-01f, 4.51878488e-01f, 1.64646938e-01f, 1.55752555e-01f, 2.03746147e-02f, 1.24027289e-01f, 2.74615020e-01f, 8.61684531e-02f, 5.14347479e-02f, 1.02522328e-01f,
  1.36768725e-02f, 1.77493230e-01f, 1.14267819e-01f, -5.66516966e-02f, -1.55844495e-01f, -7.89321885e-02f, 3.90165113e-03f, 1.52540673e-02f, 8.77394080e-02f, 9.25969854e-02f,
  4.56665009e-02f, -4.19971906e-02f, -1.51371911e-01f, -9.81749147e-02f, -3.72530408e-02f, 3.18006687e-02f, 7.14574009e-03f, -6.76070601e-02f, 2.35768259e-02f, -2.37204522e-01f,
  7.59156585e-01f, 6.56452060e-01f, 3.89603823e-02f, 3.47585902e-02f, -1.74694359e-01f, -1.78257361e-01f, 1.28043965e-01f, 1.73065752e-01f, -4.93421257e-02f, 2.27353290e-01f,
  2.01693401e-02f, -1.48340702e-01f, -8.62075165e-02f, -5.76524436e-02f, 6.92451522e-02f, 1.47199020e-01f, -1.33032650e-02f, 4.15759869e-02f, -5.19337074e-04f, -3.79062109e-02f,
  -2.04129443e-02f, 2.57671446e-01f, 4.07014340e-01f, 1.35503858e-01f, 1.14992470e-01f, -1.64245591e-01f, 4.13252376e-02f, 1.18339390e-01f, 3.95854302e-02f, 4.08528000e-02f,
  -1.58722639e-01f, 2.39103675e-01f, -1.16769113e-01f, 4.23703380e-02f, -3.99427908e-03f, 1.69020459e-01f, -1.20343983e-01f, -4.95945774e-02f, -4.57813479e-02f, -2.43357252e-02f,
  1.75331086e-02f, -5.03944904e-02f, -1.63019493e-01f, -1.34967089e-01f, -6.80080242e-03f, -1.12129897e-01f, 1.09606357e-02f, -1.94949284e-02f, -1.69857547e-01f, 3.07900775e-02f,
  -1.02928452e-01f, -3.51859108e-02f, -4.96782660e-02f, -2.44434416e-01f, -1.11416377e-01f, -1.97996110e-01f, 1.09657757e-02f, -1.41181991e-01f, -1.60637543e-01f, -4.27346975e-02f,
  -4.79134560e-01f, -2.52615865e-02f, -1.98112190e-01f, -2.14330688e-01f, -2.49470472e-01f, -2.17805639e-01f, -1.84890777e-01f, -8.78787264e-02f, -1.41084328e-01f, -4.62833494e-02f,
  -9.24444571e-02f, -2.46634915e-01f, -2.20967144e-01f, -3.89215387e-02f, -8.59361291e-02f, -1.04508633e-02f, -6.42416105e-02f, -8.12619030e-02f, -1.86694756e-01f, -9.60729793e-02f,
  -1.91048384e-01f, -3.64735946e-02f, 3.74430418e-02f, -1.17476165e-01f, -7.46313855e-02f, -2.32979253e-01f, -1.39388680e-01f, -1.12459369e-01f, 3.83334458e-02f, 1.64356455e-01f,
  -2.43787631e-01f, -3.58233362e-01f, 5.93716558e-03f, 2.68839538e-01f, 1.68896560e-02f, 2.06151992e-01f, -5.80343977e-03f, 1.07451351e-02f, -1.08329086e-02f, -8.42866972e-02f,
  1.31312758e-02f, 5.51682338e-02f, 1.82839241e-02f, -2.27681287e-02f, -1.02457590e-01f, -6.25400096e-02f, 1.04354486e-01f, -3.62230316e-02f, 3.90336476e-03f, -5.98798729e-02f,
  1.13973431e-01f, -6.42717406e-02f, 4.26744595e-02f, -1.32843196e-01f, -1.09644964e-01f, -1.45947352e-01f, 6.10161126e-02f, -8.28951299e-02f, -1.14993185e-01f, 1.33379474e-01f,
  9.79299545e-01f, -1.04329690e-01f, -2.70052999e-01f, 3.02352905e-01f, -1.51286088e-02f, -1.29612401e-01f, -3.99555385e-01f, -1.36721164e-01f, 1.79844722e-01f, -8.06340575e-02f,
  6.99570477e-02f, 2.15020910e-01f, 1.09939404e-01f, -1.70428045e-02f, -1.17812276e-01f, -4.32638317e-01f, -3.88593137e-01f, -8.18553120e-02f, 7.99836293e-02f, 4.70737740e-03f,
  -5.56709198e-03f, 8.97440463e-02f, 1.31824911e-01f, -8.94156918e-02f, -8.07910636e-02f, 4.57646586e-02f, -3.27283055e-01f, -1.50992215e-01f, -1.87269047e-01f, 1.58875380e-02f,
  -1.19781584e-01f, 7.09546953e-02f, -6.95501640e-02f, 1.29067570e-01f, 3.18321474e-02f, 4.52797525e-02f, -4.01949026e-02f, -6.35235533e-02f, -1.46490186e-02f, -1.07936472e-01f,
  7.98437968e-02f, -7.98838586e-02f, 4.62387167e-02f, -1.00633074e-02f, -2.81230174e-02f, 1.00517245e-02f, -9.76434648e-02f, -8.71879011e-02f, 1.95648409e-02f, -8.23883116e-02f,
  -5.78092188e-02f, 1.45160496e-01f, 8.85946974e-02f, -9.42425877e-02f, -3.57254362e-03f, 3.60278552e-03f, -7.57937208e-02f, -1.58168282e-02f, -6.50345162e-03f, 2.74209138e-02f,
  -3.60626519e-01f, -4.98819649e-02f, -1.21933430e-01f, -6.22376129e-02f, -3.55656035e-02f, -2.35159677e-02f, 4.13618982e-02f, -8.07943642e-02f, -6.94451481e-02f, -1.70919448e-01f,
  -1.30090684e-01f, -1.32869640e-02f, -1.08610643e-02f, -3.27960812e-02f, -3.96870775e-04f, 1.82906501e-02f, 9.40114781e-02f, -6.64368942e-02f, -1.14250772e-01f, 1.15334503e-02f,
  4.85448614e-02f, -2.87333112e-02f, 1.37396739e-03f, -9.63655114e-02f, -9.68151018e-02f, -4.64494266e-02f, -1.35202378e-01f, -7.54680261e-02f, -6.36955202e-02f, -7.30284154e-02f,
  1.44066960e-01f, -3.47140394e-02f, 7.82444328e-02f, 2.75293533e-02f, -1.54670868e-02f, -1.13121562e-01f, -2.73411330e-02f, -9.73402783e-02f, 1.25296846e-01f, 7.22543821e-02f,
  3.92438024e-02f, 4.20895778e-02f, 4.33531664e-02f, -8.80519226e-02f, -4.51199636e-02f, 3.92063707e-02f, -2.65632737e-02f, 2.98211817e-02f, -1.35574443e-02f, 6.54272661e-02f,
  -6.39218614e-02f, 1.11365803e-01f, 5.30566461e-02f, 3.19033898e-02f, -2.15283278e-02f, 1.91389933e-01f, -7.14925006e-02f, -2.68365107e-02f, -9.27811041e-02f, -1.33211479e-01f,
  -2.16083199e-01f, -6.55575888e-03f, -2.67031848e-01f, 3.29835201e-03f, -8.55427161e-02f, -2.22330138e-01f, -2.04997659e-02f, 1.48828879e-01f, 2.07146093e-01f, 5.93020357e-02f,
  -8.52120444e-02f, -2.23172903e-01f, -1.69420794e-01f, -2.17943192e-01f, -3.62262517e-01f, -2.67434180e-01f, -2.49483407e-01f, -4.21180040e-01f, -5.68155766e-01f, -2.49782622e-01f,
  -2.16658294e-01f, -4.73441780e-01f, -3.80070925e-01f, -3.64631116e-01f, -2.00267926e-01f, -3.57305467e-01f, -4.01762217e-01f, -4.25813317e-01f, -4.76927072e-01f, -4.00552660e-01f,
  -4.02198613e-01f, -2.00768039e-02f, -2.49805581e-02f, 6.34038374e-02f, -9.76167917e-02f, 1.51875809e-01f, -1.05297929e-02f, 7.37226307e-02f, 5.66320978e-02f, 1.42203003e-01f,
  8.03006738e-02f, 6.42821118e-02f, -1.01017810e-01f, -6.91836141e-03f, 5.27153760e-02f, -2.38627084e-02f, 1.69575125e-01f, 2.82887425e-02f, 9.16783437e-02f, 2.82411635e-01f,
  1.53807715e-01f, 7.10438285e-03f, 3.65741961e-02f, 2.32862011e-01f, 1.42559916e-01f, 8.94423015e-03f, -4.60978709e-02f, -2.10313546e-03f, -4.38695401e-02f, 1.37324780e-01f,
  -1.06100790e-01f, 1.92372665e-01f, 4.00206000e-02f, 2.21596262e-03f, 1.13158561e-01f, 9.57530513e-02f, 9.10568610e-02f, 8.26533791e-03f, -9.61139575e-02f, -4.78155985e-02f,
  1.46997362e-01f, 1.79390814e-02f, 6.59408197e-02f, -7.24339262e-02f, -1.02303907e-01f, 6.55838549e-02f, -2.66966783e-02f, 3.22289616e-02f, -6.78844750e-02f, 1.76081046e-01f,
  1.08228661e-01f, 6.47785440e-02f, 2.35108640e-02f, -5.67174330e-02f, -5.27694002e-02f, 5.88382892e-02f, 5.88137135e-02f, 2.59920098e-02f, 8.64089578e-02f, 3.88742350e-02f,
  -1.31201521e-01f, -2.52456278e-01f, 1.21891787e-02f, 1.68385923e-01f, 2.69844029e-02f, 1.67942047e-01f, 4.32874542e-03f, 6.90519297e-03f, 4.99287108e-03f, 5.83844706e-02f,
  8.35608020e-02f, 5.53485565e-02f, -5.56803197e-02f, 1.46608084e-01f, 1.27527695e-02f, -8.14904645e-02f, 1.97040200e-01f, -1.25749446e-02f, 3.40007171e-02f, 2.47303426e-01f,
  3.06923032e-01f, 5.09916693e-02f, 1.06581964e-01f, 1.74106508e-01f, 8.60257298e-02f, -1.88397422e-01f, -1.08894311e-01f, 1.65831833e-03f, -2.22649112e-01f, 7.15432018e-02f,
  -3.69976640e-01f, 2.05821723e-01f, -6.36266053e-01f, -7.32308149e-01f, -6.27271354e-01f, -2.78816015e-01f, 1.90412834e-01f, 6.40524691e-03f, -2.89321601e-01f, 9.94558185e-02f,
  1.29156902e-01f, -1.43349499e-01f, -1.02831498e-01f, 6.00106381e-02f, 4.24723685e-01f, 2.07503334e-01f, -2.56679624e-01f, -2.32905000e-01f, -1.56228617e-01f, 1.87352896e-02f,
  3.42455506e-02f, -1.93132102e-01f, -2.54993618e-01f, -1.47769883e-01f, -2.72026151e-01f, -2.56816447e-01f, -3.46825302e-01f, -3.77887726e-01f, -6.25658110e-02f, -2.77976841e-01f,
  8.01759064e-02f, -3.31000149e-01f, -7.41662383e-02f, -4.62056510e-02f, -1.76541626e-01f, 5.56448065e-02f, -6.87608421e-02f, -2.43383318e-01f, -1.49457939e-02f, -3.67839597e-02f,
  -2.20750242e-01f, -6.52704388e-02f, -1.87012315e-01f, 8.30902830e-02f, -1.84622705e-01f, -1.01376526e-01f, -2.34865993e-01f, -1.27034977e-01f, -1.24814875e-01f, 1.27756372e-01f,
  1.77392855e-01f, -9.38150287e-02f, -2.31440160e-02f, 9.65205356e-02f, 2.48704031e-02f, -7.83510804e-02f, 1.08010061e-02f, -7.17603266e-02f, -9.27715972e-02f, 3.80829955e-03f,
  9.75757092e-02f, 1.46649843e-02f, -3.64509746e-02f, -1.46091357e-01f, 1.53069779e-01f, -1.73581410e-02f, -1.02696657e-01f, 9.87877548e-02f, 1.22631617e-01f, 8.42653289e-02f,
  -9.45573226e-02f, 1.55701399e-01f, 9.17226896e-02f, 5.07139824e-02f, -3.96085046e-02f, 6.63154051e-02f, 2.79005110e-01f, 2.03012586e-01f, 1.09728128e-02f, -7.36026978e-03f,
  -1.00742809e-01f, -9.40512046e-02f, -9.50318724e-02f, 1.46364987e-01f, 1.17211193e-02f, 8.50018710e-02f, 1.98600478e-02f, 1.52055189e-01f, -6.21702932e-02f, 2.06610896e-02f,
  2.10786052e-03f, 2.06511855e-01f, 1.12133518e-01f, 8.56804848e-03f, -1.15036123e-01f, -7.38106593e-02f, -1.60740972e-01f, 2.57638413e-02f, -1.61852077e-01f, -8.42842758e-02f,
  -5.65452203e-02f, 9.03151184e-03f, -2.31831353e-02f, 7.49988481e-02f, 2.07690522e-02f, -5.77527545e-02f, 1.83271557e-01f, -6.97755665e-02f, 6.75849244e-02f, 7.69613311e-02f,
  1.07698128e-01f, 2.67212063e-01f, 2.46435955e-01f, 1.11520469e-01f, 7.92430565e-02f, -4.87092622e-02f, 2.26449549e-01f, 1.46530315e-01f, 2.50862718e-01f, 4.39341784e-01f,
  1.49133891e-01f, -1.86999455e-01f, -5.29451966e-02f, 2.46668309e-01f, -7.15665240e-03f, -4.07603353e-01f, -7.57680416e-01f, -2.43955448e-01f, 2.65561610e-01f, -1.65532261e-01f,
  -2.02572107e-01f, 9.21819657e-02f, -2.51389202e-03f, -1.40706271e-01f, -4.05777335e-01f, -4.35954809e-01f, -1.80550769e-01f, -1.44471731e-02f, -8.68184790e-02f, -9.67196599e-02f,
  1.20137958e-02f, 1.16494171e-01f, 1.93861365e-01f, 1.85692891e-01f, 5.13084352e-01f, 1.44978121e-01f, 9.23644453e-02f, 1.39247790e-01f, -8.00762251e-02f, 4.38247204e-01f,
  8.99968222e-02f, 2.31664106e-01f, -1.50551677e-01f, 2.10399300e-01f, 4.15446796e-02f, -2.65354533e-02f, -6.33736402e-02f, 1.35389432e-01f, -6.56028166e-02f, 5.35508245e-02f,
  5.88356443e-02f, 4.63000089e-02f, 1.36703029e-01f, -5.07486658e-03f, 4.95851301e-02f, -1.29384205e-01f, 1.71857681e-02f, -7.10948259e-02f, -4.87581342e-02f, 1.06425341e-02f,
  -1.05706558e-01f, 1.13500562e-02f, -1.63345337e-01f, -1.52376160e-01f, -3.41068283e-02f, -8.25951025e-02f, -1.51793975e-02f, 2.19430089e-01f, -1.69576794e-01f, 2.52681822e-01f,
  9.35102850e-02f, 1.51271641e-01f, -3.73661891e-02f, -1.70322359e-01f, -6.49096742e-02f, 1.60365440e-02f, 1.32401347e-01f, -1.02260988e-02f, -4.25580256e-02f, -6.37408420e-02f,
  -4.03729118e-02f, -5.56599945e-02f, 5.16518876e-02f, 1.61828566e-02f, 3.76442187e-02f, 5.05559631e-02f, 1.00671202e-02f, 1.98530573e-02f, 2.21789069e-03f, 1.02241114e-01f,
  -2.79900655e-02f, -5.35227023e-02f, -2.07885820e-02f, -8.02041311e-03f, -6.37862459e-02f, -5.31655177e-02f, 3.48283164e-02f, -3.46250497e-02f, 1.35109037e-01f, -3.35155353e-02f,
  -8.42111651e-04f, -4.65064406e-01f, -1.46331489e-02f, 8.81848559e-02f, -3.60045545e-02f, -4.83378489e-03f, 9.72491726e-02f, -5.13318591e-02f, 1.23879120e-01f, -3.86432162e-03f,
  -1.16178714e-01f, -1.28777310e-01f, 5.17495573e-02f, -5.61805554e-02f, -5.73950671e-02f, -3.43261026e-02f, -2.32081309e-01f, -9.42118540e-02f, 2.16631293e-02f, 2.28260234e-02f,
  -1.66523904e-01f, -1.84709772e-01f, -4.13909227e-01f, -3.06575775e-01f, 7.88760334e-02f, -3.15581143e-01f, -1.19765811e-01f, 6.05628313e-03f, -4.89928752e-01f, -5.30850947e-01f,
  8.05064499e-01f, 2.33097076e-01f, -2.77082883e-02f, 9.12539959e-02f, -3.52067381e-01f, -1.00019649e-01f, -4.90239747e-02f, -6.21080957e-02f, -6.28539994e-02f, 7.98656642e-02f,
  1.88902482e-01f, 2.33142361e-01f, 2.15201423e-01f, 2.06288055e-01f, 3.09089631e-01f, 7.08336383e-02f, -9.23952237e-02f, 7.78704956e-02f, 7.16738477e-02f, 1.58143658e-02f,
  1.06007163e-03f, 7.13226050e-02f, 1.91126466e-01f, 3.02525014e-02f, -4.14685942e-02f, -7.50038326e-02f, -1.52163535e-01f, -1.93977311e-01f, -4.73403893e-02f, 5.00226095e-02f,
  9.46658850e-02f, 1.22082548e-03f, -1.35277823e-01f, -1.15659110e-01f, -1.31945401e-01f, 2.71262527e-02f, 4.21023257e-02f, -8.26009363e-02f, -9.71772969e-02f, -9.34211537e-02f,
  -1.24635287e-01f, 3.45353186e-02f, 4.16598246e-02f, -7.76826143e-02f, -1.78271562e-01f, -1.57871619e-01f, -6.43933564e-02f, -6.01790994e-02f, -7.50257671e-02f, -7.29559958e-02f,
  -1.13733858e-01f, -1.44108385e-01f, -1.21988216e-02f, -1.88111309e-02f, 6.05061911e-02f, -1.81621742e-02f, 1.19791832e-02f, -9.79465768e-02f, -2.61851177e-02f, 1.44092694e-01f,
  8.70142579e-02f, 1.65383622e-01f, 1.26440182e-01f, 1.23901583e-01f, 1.96226120e-01f, 5.88106252e-02f, -3.23486403e-02f, -8.37192163e-02f, -1.99264772e-02f, 9.61958170e-02f,
  -1.80842970e-02f, -2.52996967e-03f, 3.10854390e-02f, 1.39582425e-01f, 7.38211945e-02f, -3.19139250e-02f, 1.36580328e-02f, 7.73650333e-02f, -1.08043700e-02f, -2.17485651e-02f,
  2.00539473e-02f, -4.48654313e-03f, -5.04925139e-02f, -4.28081769e-03f, -1.09443609e-02f, -6.39012307e-02f, 1.84946768e-02f, -5.24457060e-02f, 1.36266844e-02f, 3.58743630e-02f,
  -1.68139279e-01f, -9.12118852e-02f, 1.07405014e-01f, 1.54252117e-02f, -1.53231531e-01f, -1.25579640e-01f, -4.52712402e-02f, -1.27719447e-01f, -1.81622073e-01f, -3.70106548e-02f,
  -1.88883394e-01f, 1.24761008e-01f, 7.34101608e-02f, -7.22372234e-02f, -7.56647289e-02f, -1.09273627e-01f, 6.72479644e-02f, -1.60993133e-02f, -7.08728284e-02f, -8.52059498e-02f,
  -1.07910924e-01f, 2.78068166e-02f, 5.68265468e-02f, -8.03626403e-02f, 4.86815125e-02f, -3.47527042e-02f, -8.16591978e-02f, -7.30771348e-02f, 8.32692254e-03f, 1.58903852e-01f,
  -2.86742270e-01f, -2.07859531e-01f, -3.09147984e-01f, 4.31133837e-01f, 3.40213805e-01f, 1.27981439e-01f, -5.43276258e-02f, 3.35036442e-02f, 2.21943781e-01f, 1.22848295e-01f,
  2.70153672e-01f, 3.83167356e-01f, 2.67217487e-01f, 8.09951648e-02f, -6.48911344e-03f, 3.92759182e-02f, 2.18998730e-01f, -5.08989133e-02f, -1.26106754e-01f, 2.03443885e-01f,
  3.05585504e-01f, 1.81846485e-01f, 1.16013214e-02f, 3.32930423e-02f, 2.39162743e-01f, 4.16449606e-01f, 1.90352365e-01f, 1.64560378e-01f, 1.77457616e-01f, 2.33525708e-01f,
  1.33959316e-02f, -2.54899532e-01f, 1.25019073e-01f, 3.20478715e-02f, -1.35263979e-01f, -2.10438117e-01f, -1.28411517e-01f, -1.75859705e-01f, -1.19260415e-01f, -8.83797631e-02f,
  1.88462213e-02f, -2.01178208e-01f, -1.16515480e-01f, -9.62255150e-02f, -2.11767972e-01f, -2.11892456e-01f, -1.51004493e-01f, -1.39326841e-01f, -7.53389969e-02f, -9.50479507e-02f,
  6.73225075e-02f, -8.74114335e-02f, -1.88819200e-01f, -5.61475456e-02f, -3.11083626e-03f, 4.24068309e-02f, -9.92849022e-02f, -4.19991463e-02f, -2.13377193e-01f, -1.26136392e-01f,
  2.80424535e-01f, -5.20918332e-02f, -1.22239351e-01f, -1.34452224e-01f, 2.61119287e-02f, 5.62830754e-02f, -1.30812138e-01f, -5.25637455e-02f, 2.04237904e-02f, -1.60404414e-01f,
  -1.26248673e-01f, 3.85148227e-02f, -1.48530096e-01f, 3.20861898e-02f, 5.57028949e-02f, -1.21584639e-01f, -1.40661582e-01f, -1.16459206e-01f, -6.68972507e-02f, -1.80070549e-01f,
  -1.62387546e-02f, -6.06908090e-02f, -1.57435045e-01f, -2.38577813e-01f, -1.51987776e-01f, -1.16751298e-01f, -4.31433842e-02f, -1.25436828e-01f, 9.55641344e-02f, -1.30746337e-02f,
  3.13798904e-01f, 9.52085331e-02f, 9.72989425e-02f, -1.11239128e-01f, -1.78979203e-01f, -1.70113966e-01f, 9.77783203e-02f, -2.24887192e-01f, 5.04779397e-03f, 3.93974222e-02f,
  -7.17081130e-02f, -1.73492283e-01f, 3.31534073e-02f, -1.21787868e-01f, -3.77229154e-02f, -3.36199515e-02f, -2.64565535e-02f, -6.70465082e-02f, -6.79578036e-02f, -1.45247146e-01f,
  -1.82635114e-02f, -6.98964670e-02f, -4.51755151e-02f, -6.82292506e-02f, 2.56828442e-02f, 2.48530731e-01f, -4.87729572e-02f, 3.31698954e-02f, -3.63991819e-02f, -1.41161889e-01f,
  7.79134929e-01f, -3.04443508e-01f, 2.22279653e-01f, 1.52188554e-01f, 8.74964073e-02f, 2.50741243e-01f, 1.08733758e-01f, 7.86567926e-02f, 1.47048205e-01f, -1.95388924e-02f,
  -9.15073752e-02f, -6.57600258e-03f, 8.61995816e-02f, 5.74334152e-02f, 8.38626698e-02f, 6.71890527e-02f, 6.15221038e-02f, 3.27096641e-01f, 3.56717229e-01f, 1.47692814e-01f,
  -5.97195327e-02f, -7.36427605e-02f, 1.91925660e-01f, 8.98823887e-02f, -5.29914685e-02f, 1.44356534e-01f, 5.93616292e-02f, -8.12469423e-02f, -9.61088836e-02f, -3.91644835e-02f,
  -3.65592480e-01f, 1.89029146e-02f, 7.55177513e-02f, -2.20062390e-01f, -1.97197825e-01f, 2.03962135e-03f, -2.77915448e-02f, -9.36670378e-02f, -7.85237551e-02f, -1.54569104e-01f,
  -2.21272595e-02f, -3.47775444e-02f, 1.15287110e-01f, -4.66768928e-02f, 2.25626901e-02f, -1.09812673e-02f, -7.26208016e-02f, 6.94610849e-02f, -8.94653127e-02f, -9.94203091e-02f,
  -1.65409476e-01f, 9.34873074e-02f, 6.81651607e-02f, 6.87246993e-02f, -4.14284505e-03f, 2.09297985e-02f, -4.11541611e-02f, 8.52190182e-02f, 1.12484187e-01f, 9.46256220e-02f,
  -9.38121229e-03f, 4.68614660e-02f, -3.54566798e-02f, 5.25176264e-02f, 6.63748384e-02f, 2.12761357e-01f, -3.86083648e-02f, 2.20268872e-02f, 2.36875378e-02f, 6.16460852e-02f,
  -1.80607068e-03f, -1.20636979e-02f, 7.73657858e-03f, 3.60133499e-02f, 6.28627613e-02f, -4.65261154e-02f, 6.58443123e-02f, -1.36061817e-01f, -2.36302279e-02f, 2.29855608e-02f,
  1.13855906e-01f, -1.69813037e-02f, 3.39872874e-02f, 5.84522299e-02f, -9.96353477e-02f, 4.27779555e-02f, -8.78079620e-04f, -1.52454332e-01f, -1.04939260e-01f, -6.21761382e-02f,
  -4.34105814e-01f, 2.45394051e-01f, 1.35491028e-01f, -8.31989571e-03f, -7.88004920e-02f, -9.52700227e-02f, 2.57763416e-02f, -6.68421760e-02f, -1.54646695e-01f, -1.13196060e-01f,
  -2.54874211e-02f, -4.84470204e-02f, -4.99816276e-02f, -6.10325718e-03f, 4.27749902e-02f, -7.85800517e-02f, -7.41100088e-02f, 4.16829549e-02f, -9.47100669e-02f, -2.09237307e-01f,
  -1.36661619e-01f, 9.03043374e-02f, 1.58354074e-01f, 8.13546404e-02f, 5.22626936e-02f, 1.12080336e-01f, -7.26527814e-03f, 8.11020210e-02f, 1.56589314e-01f, 1.16742924e-01f,
  5.40639997e-01f, -1.86992109e-01f, -4.37869132e-01f, 2.84664601e-01f, -2.61641800e-01f, -3.88148040e-01f, -4.15972769e-01f, 7.88680539e-02f, 3.15893233e-01f, -2.06808135e-01f,
  -3.55580673e-02f, 2.98766941e-01f, 2.45710596e-01f, 1.71968132e-01f, 2.02162370e-01f, -2.89724886e-01f, -2.13323966e-01f, 4.26957309e-02f, 1.22344280e-02f, -1.96059108e-01f,
  -1.34917274e-01f, 1.00495420e-01f, 3.51390123e-01f, 1.78723618e-01f, -2.08387077e-01f, 4.01275679e-02f, -1.56637236e-01f, -2.43043110e-01f, -3.58329147e-01f, -4.54477161e-01f,
  -2.06977352e-01f, -1.40547320e-01f, -4.06136923e-02f, 1.16941884e-01f, -2.21306346e-02f, 1.12509809e-01f, -7.95473978e-02f, -3.95764522e-02f, 1.01869501e-01f, -3.89703065e-02f,
  -3.76918502e-02f, 2.60268971e-02f, -2.22188123e-02f, -1.20367400e-01f, 4.99532605e-03f, -8.47553387e-02f, 8.25567469e-02f, 7.86440745e-02f, 3.16914916e-02f, -2.28806645e-01f,
  -2.64319003e-01f, -2.89500743e-01f, -1.82681352e-01f, -1.26894787e-01f, -1.43809482e-01f, 9.18904692e-03f, -2.95058966e-01f, -2.73741245e-01f, -1.50630325e-01f, -3.05373281e-01f,
  4.96696085e-02f, -1.49168700e-01f, -2.43744440e-02f, -6.36114879e-03f, 6.82961196e-02f, -1.66635178e-02f, -6.94017336e-02f, -8.87639895e-02f, -7.05923364e-02f, -4.73700054e-02f,
  1.07387513e-01f, 5.05932383e-02f, -5.27184224e-03f, -7.53613338e-02f, -7.08587840e-02f, -1.04238436e-01f, -5.97626343e-02f, -7.47665688e-02f, -1.32790223e-01f, -6.83705956e-02f,
  -6.03363500e-04f, -2.03834344e-02f, 9.51733291e-02f, 8.05576667e-02f, -7.97416121e-02f, 7.42904842e-02f, -5.11261038e-02f, -6.48851469e-02f, 1.07304402e-01f, 5.27811411e-04f,
  3.46094906e-01f, 1.01543076e-01f, -2.94173844e-02f, -7.72863328e-02f, -1.44465208e-01f, -2.71716993e-02f, -5.08113168e-02f, 1.08500505e-02f, 1.12925410e-01f, 5.50677814e-02f,
  -2.37660095e-01f, 1.61923006e-01f, -5.04154675e-02f, -2.87033338e-02f, -1.96440029e-03f, 1.86761096e-02f, 3.60867269e-02f, -8.98426250e-02f, -1.04060821e-01f, -2.02108771e-01f,
  5.87963089e-02f, -1.90266799e-02f, 5.72527237e-02f, 5.46777844e-02f, -1.47733659e-01f, 1.40781179e-01f, -2.35307649e-01f, -2.24763855e-01f, 5.60433492e-02f, 6.99001104e-02f,
  5.88670552e-01f, -6.11281216e-01f, 1.48352817e-01f, 2.12405279e-01f, 2.23440468e-01f, 7.34065324e-02f, -1.19776628e-03f, 6.11672439e-02f, 1.35751486e-01f, 3.36330160e-02f,
  -1.81258321e-01f, 1.76665578e-02f, 8.02303851e-02f, -9.89979208e-02f, -1.71577290e-01f, -7.18478393e-03f, 1.09803788e-02f, 7.67865330e-02f, 1.94586173e-01f, -1.35448456e-01f,
  -2.23216683e-01f, -8.37208852e-02f, -5.17485328e-02f, -1.56724632e-01f, -1.81702495e-01f, 3.00281495e-02f, -6.04724288e-02f, -1.53890818e-01f, -2.65985429e-01f, -3.42767984e-01f,
  -1.21269047e-01f, -2.00463027e-01f, 9.80726629e-02f, -8.88649151e-02f, -1.24208771e-01f, 3.07727419e-03f, 1.13529846e-01f, -6.27886057e-02f, 6.24875501e-02f, 1.13813341e-01f,
  -1.17886543e-01f, -7.40573481e-02f, -1.12831555e-01f, 9.88882780e-03f, -8.63167122e-02f, -3.35280038e-02f, -9.66262594e-02f, -1.90630749e-01f, -1.73274264e-01f, -2.00514629e-01f,
  -2.74980754e-01f, -1.12314448e-01f, 3.93726751e-02f, -2.95835212e-02f, -8.56695175e-02f, -5.32532483e-02f, -1.18656084e-01f, -1.00117907e-01f, -3.53439748e-02f, 9.76010114e-02f,
  4.54491973e-02f, 5.77428676e-02f, -1.43352851e-01f, -9.94908530e-03f, 2.56687962e-02f, 1.46460429e-01f, 4.11306433e-02f, 1.98002122e-02f, -1.56439036e-01f, 5.09627499e-02f,
  -7.58900344e-02f, -1.14866383e-02f, -8.34302679e-02f, 7.53391907e-02f, -1.89573660e-01f, -1.35773167e-01f, 4.25356738e-02f, -1.50274217e-01f, -8.63017514e-02f, 5.28192036e-02f,
  -9.77443606e-02f, -7.45375156e-02f, -1.49646610e-01f, -2.35341549e-01f, -2.06248313e-01f, -9.43838209e-02f, -1.13480665e-01f, -1.47332340e-01f, 2.30377335e-02f, -7.09461272e-02f,
  -1.79012716e-01f, -1.14324205e-01f, 2.03069687e-01f, -8.29721615e-02f, -7.74744004e-02f, -1.22260697e-01f, -1.63286313e-01f, -9.91960242e-02f, -9.18458402e-02f, -6.67868415e-03f,
  -6.02233643e-03f, 6.83928877e-02f, -2.53489818e-02f, -1.13045923e-01f, 1.30627230e-01f, 5.03656231e-02f, -9.33956578e-02f, -4.35746135e-03f, -2.46253945e-02f, -1.24346964e-01f,
  -6.68164119e-02f, 6.47509769e-02f, 2.94797748e-01f, 1.27936661e-01f, 7.96707794e-02f, 2.13594422e-01f, 1.54428348e-01f, 5.19645214e-02f, 1.36297643e-01f, 3.25547338e-01f,
  -5.95579624e-01f, 6.66041791e-01f, -7.35323012e-01f, 1.53269833e-02f, -3.71239148e-03f, 1.46658961e-02f, 6.95612252e-01f, 4.02463496e-01f, 2.48107612e-01f, 4.19877261e-01f,
  -6.52289018e-02f, -3.60562682e-01f, -1.84896365e-01f, -1.42020673e-01f, 7.10644573e-02f, 6.23434126e-01f, 4.57469285e-01f, -5.43705702e-01f, -6.63352489e-01f, -8.65917355e-02f,
  3.97874624e-01f, 2.81251464e-02f, -3.64288270e-01f, -2.39955410e-01f, 5.13634793e-02f, -1.40147537e-01f, 1.09821662e-01f, -1.37595803e-01f, 3.27977166e-02f, 3.74287367e-02f,
  -5.75687170e-01f, -2.50708401e-01f, -2.49950886e-01f, -3.48139822e-01f, -2.82658219e-01f, -1.11142389e-01f, -2.58266162e-02f, -3.54462206e-01f, -1.19518518e-01f, -4.50223275e-02f,
  -2.69454539e-01f, -7.89205059e-02f, -2.64350802e-01f, -1.33737493e-02f, -1.22283638e-01f, -1.23813301e-01f, 4.76239882e-02f, -1.74522862e-01f, -2.61396587e-01f, -2.41556838e-01f,
  2.76371360e-01f, -3.12673539e-01f, -5.30373871e-01f, 1.71918094e-01f, -1.29945651e-01f, -2.31754437e-01f, -1.81404173e-01f, -2.87990540e-01f, -3.13455731e-01f, 5.58541715e-02f,
  -4.33860347e-02f, -5.38433082e-02f, -6.46478543e-03f, 5.74106909e-02f, 1.37770027e-01f, 7.30983913e-02f, 8.70972723e-02f, 1.10893818e-02f, -3.05486862e-02f, -8.01598653e-02f,
  -1.54533401e-01f, -1.21434852e-02f, -1.67006046e-01f, 4.52816347e-03f, 4.81225848e-02f, 1.03368200e-02f, -7.59622306e-02f, 1.89049140e-01f, -1.25547945e-02f, 7.14598149e-02f,
  -1.05233602e-01f, 2.70422716e-02f, -6.47694170e-02f, 8.83091055e-03f, 1.30533308e-01f, 2.65126470e-02f, 9.44937766e-02f, -8.46543610e-02f, -1.32020175e-01f, 1.69606552e-01f,
  1.37831867e-01f, 2.47459747e-02f, -9.81472507e-02f, 4.07640971e-02f, -6.12155274e-02f, -1.12071283e-01f, -4.27646376e-02f, 3.36728781e-03f, -8.92766044e-02f, -1.20106660e-01f,
  -1.30532995e-01f, -9.86478925e-02f, 1.19163848e-01f, -3.47821079e-02f, -1.07485741e-01f, 2.17401218e-02f, 3.03805172e-01f, 3.55646387e-02f, 2.10757628e-02f, -3.70745808e-02f,
  5.33497870e-01f, 3.12355876e-01f, -7.14492127e-02f, 1.33283600e-01f, 1.50195569e-01f, -1.40383214e-01f, -1.94281917e-02f, 3.83414961e-02f, 3.33757373e-03f, 6.72362745e-01f,
  6.48705781e-01f, -3.77635628e-01f, 2.01222181e-01f, 2.54198372e-01f, 2.44820252e-01f, 1.58931628e-01f, 1.08613223e-01f, 3.26915570e-02f, 1.95095688e-01f, 1.64529368e-01f,
  -1.58094410e-02f, 2.33502522e-01f, 2.54032642e-01f, 1.27896369e-01f, 1.25092328e-01f, -8.28602761e-02f, 1.04965240e-01f, 1.66154370e-01f, 2.24077344e-01f, 3.42580266e-02f,
  -6.10893555e-02f, -7.17554763e-02f, -3.83773781e-02f, 5.27991615e-02f, -1.67155445e-01f, 7.21198395e-02f, -3.07903159e-02f, -9.20879766e-02f, -1.28366649e-01f, -2.39243135e-01f,
  -2.81142890e-01f, -7.61304125e-02f, 8.44012275e-02f, -6.43431991e-02f, -1.93756804e-01f, 2.02013161e-02f, 2.58987658e-02f, -1.06114723e-01f, -1.26143962e-01f, -1.75473094e-01f,
  -3.75840403e-02f, -8.98791403e-02f, -6.48444742e-02f, -1.82100713e-01f, -6.82572797e-02f, 3.80781330e-02f, -8.68326277e-02f, -7.32260123e-02f, -4.68967948e-03f, 1.25771929e-02f,
  4.43113446e-02f, 1.40831321e-01f, -4.82171401e-03f, 4.55381162e-02f, 2.90189441e-02f, 9.78193711e-03f, -7.85888508e-02f, -3.15582566e-02f, 7.48002436e-03f, -2.07257550e-02f,
  1.78583220e-01f, 1.51116520e-01f, 2.10221857e-01f, 1.38431609e-01f, 1.12552673e-01f, 7.01634288e-02f, 5.09963073e-02f, 6.80560991e-02f, 1.22490808e-01f, 1.11299828e-01f,
  -1.04684584e-01f, 8.55100453e-02f, -1.43939806e-02f, 7.28315040e-02f, 2.28688821e-01f, -3.28869894e-02f, -2.51268428e-02f, -4.65134121e-02f, 2.76929364e-02f, 2.78820843e-02f,
  -4.01447900e-03f, -1.00640520e-01f, -6.76109493e-02f, -1.27354920e-01f, -1.68899680e-03f, -1.63856652e-02f, 5.08445352e-02f, 4.80868146e-02f, -3.67402807e-02f, -7.60105029e-02f,
  -3.01693916e-01f, 2.90539801e-01f, 1.80904523e-01f, -6.00116812e-02f, -8.73077065e-02f, -1.32569432e-01f, 6.85482770e-02f, -9.41547528e-02f, -2.18770638e-01f, -1.03932552e-01f,
  -1.03808358e-01f, 6.60286576e-04f, -3.87376174e-03f, -5.65761589e-02f, 1.38238473e-02f, 8.89593884e-02f, 4.96365987e-02f, 1.14373393e-01f, 1.25654237e-02f, -9.72980633e-02f,
  7.12187169e-03f, 2.19056875e-01f, 2.70193011e-01f, 2.73626238e-01f, 4.26903479e-02f, 3.15522075e-01f, 1.23189285e-01f, 8.21034685e-02f, 1.62487030e-01f, 2.19166607e-01f,
  -2.59807229e-01f, 1.11302383e-01f, 1.86521664e-01f, 1.52737536e-02f, -1.42876953e-02f, -2.19696939e-01f, -3.53617907e-01f, -3.86691093e-01f, -1.51593881e-02f, 1.95368677e-01f,
  -2.30034254e-03f, -1.95879042e-01f, 1.76261634e-01f, -1.65027082e-01f, -4.44034845e-01f, 3.57979424e-02f, 2.19819881e-02f, -2.57763326e-01f, -6.33456409e-01f, -5.62574387e-01f,
  -2.71919608e-01f, -8.35053176e-02f, -2.69015878e-01f, -1.52341843e-01f, 2.62855619e-01f, 1.01639047e-01f, 3.59596193e-01f, 7.76581019e-02f, -5.10222092e-03f, 3.59256893e-01f,
  4.01245534e-01f, -1.89975664e-01f, -8.67390707e-02f, -2.49434307e-01f, 3.78508307e-02f, -1.80356279e-01f, -1.74301326e-01f, 6.22919109e-03f, -9.81299654e-02f, 8.03227164e-03f,
  4.31667008e-02f, -1.85024679e-01f, -2.48927772e-02f, 4.99999104e-03f, -1.22077733e-01f, -1.33293137e-01f, -1.69643342e-01f, -2.49017775e-01f, -7.62486756e-02f, -4.46112193e-02f,
  -1.05738163e-01f, -7.46533871e-02f, 1.15647346e-01f, 1.86080448e-04f, -1.69768885e-01f, -1.20584711e-01f, 8.96526128e-02f, -5.13523668e-02f, 5.84594440e-03f, 2.79179037e-01f,
  -1.48274312e-02f, 1.93785504e-01f, 3.44573433e-04f, 1.02724016e-01f, -2.77576298e-02f, 5.18519841e-02f, 1.35755941e-01f, -1.59335751e-02f, -7.78912455e-02f, -3.94420549e-02f,
  5.27136326e-02f, 1.21649593e-01f, 3.66687104e-02f, -1.43173188e-02f, 8.20738226e-02f, -1.93815455e-02f, 3.62764038e-02f, -1.97861306e-02f, -5.29655851e-02f, 5.77998860e-03f,
  -1.36068761e-01f, -1.17069840e-01f, 5.33337332e-02f, 2.52393503e-02f, -1.12163894e-01f, -5.99170364e-02f, -1.28922775e-01f, -1.03708573e-01f, -1.53493211e-01f, -1.87245607e-01f,
  3.14628303e-01f, -3.70494336e-01f, 1.72486305e-01f, -1.71130314e-01f, 4.53384146e-02f, -9.41832662e-02f, 6.84979334e-02f, -2.51688585e-02f, 1.60453886e-01f, -9.92623642e-02f,
  -1.62502274e-01f, -3.57877091e-02f, 7.62451515e-02f, 4.29573879e-02f, -6.67924210e-02f, -4.63653170e-02f, -6.55187145e-02f, 1.24395512e-01f, -7.88316689e-03f, 4.70637297e-03f,
  1.60339233e-02f, -4.70452569e-02f, 1.60931975e-01f, 1.94769576e-01f, -3.42191495e-02f, 3.04134609e-03f, 2.69532889e-01f, 1.69280559e-01f, -4.24444266e-02f, 3.90784144e-01f,
  -4.59142119e-01f, -4.59284902e-01f, -2.64996052e-01f, 2.30766714e-01f, 3.88223827e-01f, -3.97863328e-01f, -7.83931077e-01f, -5.83018839e-01f, 1.79723054e-01f, -1.69771656e-01f,
  2.53454298e-01f, 4.20496047e-01f, 1.08835891e-01f, 8.33981670e-03f, -5.03747344e-01f, -3.93902451e-01f, -7.98694938e-02f, -1.57680571e-01f, -1.72605217e-01f, 6.30926490e-02f,
  3.46468925e-01f, 2.73903936e-01f, 1.30597707e-02f, -3.48862782e-02f, 3.39451790e-01f, 3.36007237e-01f, 2.67054319e-01f, 2.96966851e-01f, 1.49236328e-03f, 1.90405741e-01f,
  -8.80041197e-02f, -3.85675281e-01f, -6.09876215e-02f, 2.71183997e-01f, 2.61548847e-01f, -2.85388052e-01f, -3.39603662e-01f, -9.11546871e-02f, -1.39267966e-01f, -1.03050761e-01f,
  3.26563269e-01f, -3.52392569e-02f, 1.84454501e-01f, -8.67055655e-02f, -2.45845672e-02f, -2.47438639e-01f, -3.87615375e-02f, -3.23189676e-01f, -3.90428275e-01f, -1.67820111e-01f,
  2.49134406e-01f, 1.69595838e-01f, -2.30757862e-01f, -2.83784539e-01f, -3.79305243e-01f, 1.47850990e-01f, -2.05948442e-01f, -1.97013691e-01f, -4.55637336e-01f, -2.34388247e-01f,
  -9.78985988e-03f, 3.24532986e-02f, -7.49728177e-03f, -7.79543445e-02f, 2.61361394e-02f, 9.65824127e-02f, 4.46503656e-03f, -4.38464992e-03f, -2.91110929e-02f, -9.52802505e-03f,
  1.37690520e-02f, -2.48536821e-02f, -1.37448702e-02f, -1.03580862e-01f, 1.29672199e-01f, -4.24956344e-02f, -6.89195171e-02f, 1.31438579e-02f, 8.57509002e-02f, -8.85801688e-02f,
  -2.22117864e-02f, -2.29191575e-02f, 1.36684120e-01f, -1.26763657e-01f, -9.42153633e-02f, -5.14215492e-02f, 3.26735564e-02f, -1.68366097e-02f, 3.66026685e-02f, -6.03652075e-02f,
  1.52095586e-01f, -9.85711068e-03f, -7.74483606e-02f, -7.79689774e-02f, -2.22955216e-02f, 1.62876889e-01f, 1.22883029e-01f, 5.32343946e-02f, -4.07933071e-02f, -2.06126407e-01f,
  -2.52472103e-01f, -1.63387299e-01f, 4.27393476e-03f, -1.93533506e-02f, -4.14154120e-02f, -3.56848091e-02f, 3.91105227e-02f, 1.74996674e-01f, -2.36771181e-02f, 1.06703356e-01f,
  3.00988108e-02f, -1.83743939e-01f, -2.09458932e-01f, -4.09775823e-01f, -6.60032108e-02f, -1.39337834e-02f, -2.22818360e-01f, -2.24727705e-01f, -3.51645529e-01f, -5.01024067e-01f,
  -5.05172908e-01f, -7.77930543e-02f, 3.45239729e-01f, -1.97953880e-01f, 3.00964892e-01f, 4.34493542e-01f, 5.11615753e-01f, 9.19182077e-02f, -2.61220962e-01f, -1.30754858e-01f,
  -1.54654324e-01f, -4.56268340e-01f, -3.73282105e-01f, -1.72077194e-01f, 9.56514105e-02f, 2.53089190e-01f, 2.38931909e-01f, 1.82813972e-01f, -6.98040705e-03f, 1.34624809e-01f,
  -6.30508289e-02f, 6.61676377e-03f, -1.37012824e-01f, -1.89505920e-01f, -2.23277360e-01f, -3.02363098e-01f, 1.77936301e-01f, 1.08395226e-01f, 1.58753246e-01f, -1.66205719e-01f,
  -1.79343462e-01f, 7.15321749e-02f, 6.19792901e-02f, -1.37714103e-01f, 8.41463134e-02f, -2.19032228e-01f, 2.29407521e-03f, -1.87009096e-01f, -1.37821332e-01f, -1.59725800e-01f,
  -3.02804932e-02f, -1.55759677e-01f, -8.06384254e-03f, 3.13890316e-02f, 7.86015168e-02f, -7.52703846e-02f, 5.65435691e-03f, -3.19275842e-03f, 3.37670371e-02f, 4.84437123e-02f,
  -1.16283387e-01f, 9.97982547e-02f, 2.47535095e-01f, 6.31126091e-02f, -4.36966680e-02f, -8.58816281e-02f, 6.54628277e-02f, -5.45833632e-02f, 1.47232879e-02f, -2.37902060e-01f,
  -2.30696369e-02f, 3.46269533e-02f, 2.62246877e-02f, 1.96304545e-03f, -7.22540021e-02f, -1.60536431e-02f, -1.20907482e-02f, 5.18518910e-02f, 4.64499928e-02f, 1.78300794e-02f,
  2.13191286e-02f, 6.05293103e-02f, 6.98642433e-02f, -1.32746980e-01f, -2.58624583e-01f, -1.49544068e-02f, 3.18297222e-02f, -1.28757417e-01f, 1.73289571e-02f, 1.53026626e-01f,
  -4.52367589e-02f, 1.06943727e-01f, -7.83274919e-02f, 5.80396205e-02f, -3.87905166e-02f, -8.19876716e-02f, -8.11929181e-02f, -1.33651361e-01f, -7.78909251e-02f, 5.98847158e-02f,
  -6.97430149e-02f, 4.77213353e-01f, -1.34235069e-01f, -2.07598116e-02f, -2.15031859e-02f, 7.38251135e-02f, -5.52401468e-02f, 4.41656634e-02f, -2.32588537e-02f, -6.49481043e-02f,
  -7.57069588e-02f, -5.56107163e-02f, 7.23525211e-02f, 3.79798077e-02f, -1.96051039e-02f, -2.02384830e-01f, 3.53198014e-02f, 5.51455691e-02f, 1.33437663e-01f, 1.31750256e-01f,
  7.71956071e-02f, 4.36383151e-02f, -9.10953805e-02f, -5.18709645e-02f, -1.65376619e-01f, -8.79064649e-02f, -1.24978982e-02f, 1.98294204e-02f, 9.47450474e-02f, -1.84279233e-01f,
  -4.10257787e-01f, -1.24756852e-02f, 1.59473747e-01f, -2.60602146e-01f, -3.03947538e-01f, -3.47226173e-01f, -2.25082591e-01f, -2.23502830e-01f, -2.45591968e-01f, -1.06939271e-01f,
  9.56385955e-02f, 3.78335834e-01f, 4.45636690e-01f, 2.42960662e-01f, 1.53215617e-01f, -1.32178748e-02f, -1.08752392e-01f, 4.60151071e-03f, 3.85765173e-02f, -2.33242229e-01f,
  -1.57588497e-01f, -1.79127082e-01f, -1.84766591e-01f, -9.38480273e-02f, 1.08486814e-02f, 2.11126417e-01f, 2.86412351e-02f, -2.02797949e-01f, -1.94693446e-01f, -1.82415619e-01f,
  5.13862967e-01f, -4.63708490e-01f, -3.06180143e-03f, -1.22871168e-01f, 5.50750047e-02f, -5.83977774e-02f, 1.58855729e-02f, -9.86491293e-02f, -1.33961305e-01f, -1.42241508e-01f,
  -2.46620104e-02f, -1.07857101e-01f, -2.61943787e-04f, 5.88148460e-02f, -3.33424509e-02f, 8.44388679e-02f, 1.12603568e-01f, -2.76308004e-02f, -1.23086587e-01f, 1.55049577e-01f,
  -3.29362042e-03f, -1.62044331e-01f, 7.17751086e-02f, 8.12400579e-02f, -6.62771240e-02f, 2.57210620e-03f, 4.80323918e-02f, -1.71089888e-01f, -1.90536119e-03f, -1.64901111e-02f,
  -1.61135793e-01f, 1.19900055e-01f, 1.28830429e-02f, -4.26254002e-03f, 8.51922557e-02f, 6.94051310e-02f, -1.76696852e-02f, 5.41908219e-02f, 1.03795990e-01f, 1.37507960e-01f,
  1.05825961e-01f, 5.56040145e-02f, 2.04386059e-02f, -6.41790479e-02f, -2.87591983e-02f, -3.24842371e-02f, 7.65502406e-03f, 1.35452613e-01f, -1.83402502e-03f, -4.67425659e-02f,
  -3.44532467e-02f, -4.33704145e-02f, -1.46522140e-03f, 6.73150420e-02f, -9.65937003e-02f, 1.30216777e-01f, 3.53017426e-03f, 1.21391721e-01f, 7.60457665e-02f, -1.10056981e-01f,
  4.57231522e-01f, -1.60029635e-01f, 1.95672125e-01f, 7.18079740e-04f, -1.94985092e-01f, -1.38069466e-01f, 5.88298216e-03f, -2.28716269e-01f, -9.97117385e-02f, 4.96762730e-02f,
  -1.31855652e-01f, 5.69600090e-02f, 6.08900748e-02f, -1.96996406e-02f, 3.17372829e-02f, 1.70625802e-02f, -6.39046170e-03f, 5.11311553e-02f, -1.51973233e-01f, -6.27991334e-02f,
  -3.72340158e-02f, -9.65490043e-02f, 2.66220421e-01f, 2.11977661e-01f, -6.45386986e-03f, 8.27127546e-02f, 2.07137480e-01f, 1.79305196e-01f, 1.89045936e-01f, 1.23369470e-01f,
  -6.43010497e-01f, -1.93809867e-01f, -4.00266498e-02f, -1.99628815e-01f, 8.40815604e-02f, -2.33301856e-02f, -1.60868347e-01f, -6.98114783e-02f, -1.69559792e-01f, -3.18456501e-01f,
  -1.41796306e-01f, 4.81764153e-02f, 3.79961170e-02f, 2.48781875e-01f, 1.71804428e-01f, -8.03604946e-02f, 1.45920381e-01f, 1.92563519e-01f, 3.14241111e-01f, 2.37090111e-01f,
  2.12494895e-01f, 5.35066314e-02f, 1.01705909e-01f, 2.61137694e-01f, 4.02212031e-02f, 9.37562883e-02f, -7.87551403e-02f, 1.19899549e-01f, 2.62202900e-02f, 6.55563325e-02f,
  -4.40463603e-01f, -3.16106141e-01f, 1.65211052e-01f, 5.49751818e-02f, 4.21834104e-02f, -1.43044189e-01f, -7.03686401e-02f, 2.55841818e-02f, -5.65729700e-02f, -1.27527505e-01f,
  -1.89710949e-02f, -2.34690495e-02f, -7.84292594e-02f, -2.43699253e-02f, -5.54361381e-02f, -2.94300932e-02f, 1.18267402e-01f, 3.04757943e-03f, 1.16206082e-02f, -9.85649452e-02f,
  2.16148898e-01f, -1.10669009e-01f, -1.58755898e-01f, 4.30595167e-02f, 2.57942341e-02f, 1.27323687e-01f, 2.05623750e-02f, 4.23209593e-02f, -7.64093027e-02f, -2.05785781e-01f,
  1.06576420e-02f, 9.87364575e-02f, 3.00595984e-02f, -7.28649199e-02f, 8.42358097e-02f, -1.34692043e-01f, 1.07657857e-01f, 3.35851982e-02f, -3.61135975e-02f, -1.01909854e-01f,
  -2.48565562e-02f, -3.87756377e-02f, 1.10711411e-01f, -1.30365565e-01f, 2.21094713e-02f, 3.00021954e-02f, -1.06585801e-01f, 2.12236680e-03f, 8.58733617e-03f, -7.21406937e-02f,
  -2.13825749e-03f, 8.64982838e-04f, 9.12990570e-02f, 1.88562512e-01f, -1.50528818e-01f, 6.44358695e-02f, -1.42631352e-01f, -5.20451590e-02f, 3.53741981e-02f, -1.42627805e-01f,
  -3.99250448e-01f, 1.66558146e-01f, -2.20773667e-01f, -3.57040926e-03f, 1.83972903e-02f, 1.33037850e-01f, 2.59835441e-02f, 1.23100497e-01f, -1.01141095e-01f, -5.53829260e-02f,
  -1.84520081e-01f, -6.20048344e-02f, -9.74920914e-02f, 1.18967332e-01f, -7.25806206e-02f, -1.15554765e-01f, 3.65235917e-02f, -1.41150773e-01f, -3.07084247e-02f, 1.77197438e-02f,
  -1.01976963e-02f, -1.44324914e-01f, -3.45599532e-01f, -1.15784362e-01f, -1.12172127e-01f, -1.94543019e-01f, -7.09551796e-02f, -2.53386050e-01f, -3.20188314e-01f, -4.46287632e-01f,
  -6.59434823e-03f, 8.42998102e-02f, 3.96476626e-01f, 1.92374468e-01f, -1.79578528e-01f, -3.51804048e-01f, -5.84846199e-01f, -2.54648864e-01f, 2.42554069e-01f, 7.84389526e-02f,
  -2.31074616e-01f, -2.82785356e-01f, 2.34670818e-01f, -9.00517777e-02f, -3.21838319e-01f, 7.36196861e-02f, 1.46981791e-01f, -2.14856863e-02f, -4.48268712e-01f, -6.54701650e-01f,
  -2.64376789e-01f, -1.10185556e-01f, -4.65888828e-02f, 4.05783542e-02f, 4.59344894e-01f, 1.18131660e-01f, 4.67505008e-01f, 1.59140840e-01f, -1.97391305e-02f, 5.37444293e-01f,
  5.32653451e-01f, 2.67959446e-01f, -1.43947393e-01f, -2.33190894e-01f, -4.99033071e-02f, 6.59258515e-02f, -1.46749523e-02f, 2.78446883e-01f, -5.92947043e-02f, 1.12923659e-01f,
  -6.57670051e-02f, -1.02814861e-01f, 4.76019792e-02f, 9.15251076e-02f, -7.24145472e-02f, -2.40199789e-01f, -5.28380238e-02f, -1.38769224e-01f, 2.92325653e-02f, 5.45806158e-03f,
  -4.16555882e-01f, -1.96935177e-01f, 3.82367708e-02f, -1.08693719e-01f, -1.42830387e-02f, -1.12565994e-01f, 6.14809133e-02f, 2.86805555e-02f, 4.55002375e-02f, 3.25136036e-01f,
  -1.57066677e-02f, 3.67243923e-02f, -4.94567528e-02f, 1.00626990e-01f, -7.85907879e-02f, 4.16263454e-02f, 1.27618283e-01f, -7.05314949e-02f, 3.31122242e-02f, 6.61722422e-02f,
  -9.24850777e-02f, 5.22512645e-02f, 5.21941371e-02f, 7.23854527e-02f, 3.70094292e-02f, 7.45654181e-02f, -1.03963263e-01f, -3.88221368e-02f, 2.61910297e-02f, 8.37101191e-02f,
  -7.61439651e-02f, -8.07967223e-03f, 1.66928157e-01f, 5.50338030e-02f, 2.65650544e-02f, 3.20018604e-02f, -1.98252760e-02f, -9.66666341e-02f, -1.26780476e-02f, 4.74446155e-02f,
  8.33101571e-02f, -4.07578886e-01f, 2.25987464e-01f, -7.93999583e-02f, 8.17112327e-02f, -3.50639112e-02f, 5.67394160e-02f, 1.39783975e-02f, 1.36469617e-01f, -2.08841443e-01f,
  -1.87137023e-01f, -1.98795661e-01f, 2.06144392e-01f, -1.45322770e-01f, -1.58106297e-01f, -1.54394597e-01f, -2.79637575e-01f, -1.79748863e-01f, -1.81843385e-01f, -4.97725978e-02f,
  -7.94750825e-02f, -3.80403042e-01f, -2.46687010e-01f, -5.46114780e-02f, -4.73548211e-02f, -3.55001122e-01f, 3.32309715e-02f, 2.01186277e-02f, -1.56522378e-01f, -1.66263387e-01f,
  5.25484085e-01f, -3.44272643e-01f, -5.47933698e-01f, -1.28586218e-01f, -3.86445463e-01f, -3.08251053e-01f, -4.80719030e-01f, 5.18288650e-03f, 1.41008273e-01f, -4.06862408e-01f,
  -5.84847219e-02f, 2.68326283e-01f, 1.13159247e-01f, 8.49874467e-02f, 9.01431963e-02f, -5.79074025e-01f, -5.59901774e-01f, -1.97672844e-01f, 1.11859925e-01f, -3.49262692e-02f,
  -1.53816551e-01f, -1.12574890e-01f, -1.08586838e-02f, -1.09085880e-01f, -3.51716876e-01f, -1.54192448e-01f, -4.40465778e-01f, -2.96471059e-01f, -3.19975287e-01f, -5.01706958e-01f,
  -3.07741821e-01f, 1.42125711e-01f, 1.94075219e-02f, 6.76819980e-02f, -2.86306739e-01f, 3.39060798e-02f, 3.33194323e-02f, -1.63576812e-01f, 8.19407105e-02f, -3.77511680e-02f,
  -1.47023676e-02f, 1.39475167e-01f, 1.88508376e-01f, -8.94871429e-02f, -1.29574254e-01f, 8.89710858e-02f, -2.34879732e-01f, -3.31360623e-02f, -5.13000786e-02f, -1.14260629e-01f,
  -1.18942499e-01f, 2.87359022e-02f, 7.53772557e-02f, -1.46209300e-01f, 3.28884050e-02f, 5.45806997e-03f, -1.53067932e-01f, -6.18580319e-02f, -6.53138533e-02f, -2.58366793e-01f,
  -1.40506640e-01f, -4.71679047e-02f, -1.14564799e-01f, -7.24410042e-02f, 1.10362716e-01f, 2.26249192e-02f, 1.21195190e-01f, 1.04533903e-01f, -1.83373839e-02f, -6.25623390e-02f,
  -1.25354916e-01f, -1.37164727e-01f, 2.67387778e-02f, 1.86443608e-02f, -1.74458437e-02f, 8.74511674e-02f, -1.90272518e-02f, -1.04350224e-01f, -5.21120615e-02f, -5.97833395e-02f,
  1.12267926e-01f, 6.49431124e-02f, 3.69639285e-02f, -9.25340578e-02f, -8.63026381e-02f, -8.23817626e-02f, 3.26462351e-02f, -9.29182954e-03f, -9.36946571e-02f, -5.21596009e-03f,
  2.87745476e-01f, 5.76776564e-02f, -2.05673315e-02f, 6.85113892e-02f, -1.14861473e-01f, -1.20947115e-01f, -8.20152089e-02f, -9.56990421e-02f, 1.09368190e-01f, 6.74074516e-02f,
  -1.00614272e-01f, 5.16088791e-02f, 5.73746487e-02f, -2.98933890e-02f, -9.10040438e-02f, 1.19183101e-01f, -1.26437515e-01f, 3.78267877e-02f, 5.78126609e-02f, -1.46175861e-01f,
  -1.12521537e-01f, 2.21208721e-01f, 1.85528055e-01f, -1.20590255e-02f, 7.17151985e-02f, 2.27375701e-01f, -1.78518370e-01f, -1.85168795e-02f, 1.60269424e-01f, -1.03126116e-01f,
  3.69211167e-01f, -1.43499702e-01f, -1.78225905e-01f, -3.17477025e-02f, -2.47781500e-01f, -1.84315905e-01f, -6.73158020e-02f, -5.02749830e-02f, -9.42664891e-02f, 2.77107973e-02f,
  1.54588118e-01f, 3.08316648e-01f, 2.87087023e-01f, 1.93399653e-01f, 2.18924165e-01f, -1.88061416e-01f, -2.01207802e-01f, -1.18789282e-02f, 1.31531343e-01f, -1.19020529e-01f,
  -6.09610453e-02f, -4.62154672e-02f, 5.63567085e-03f, 1.96475955e-03f, -1.34613559e-01f, -4.30758856e-03f, -2.03174174e-01f, -2.20554397e-01f, -7.31019303e-02f, -2.65010118e-01f,
  2.70532787e-01f, -1.93154708e-01f, 5.33490500e-04f, -1.25458598e-01f, -1.45657569e-01f, -4.14063074e-02f, -5.11882044e-02f, -5.44297360e-02f, -7.62751773e-02f, -1.89831078e-01f,
  -1.48841664e-01f, -1.49508402e-01f, -3.05196438e-02f, -7.61469379e-02f, -1.37199342e-01f, -3.18218134e-02f, -3.71884778e-02f, 3.12505919e-03f, -1.23670558e-02f, -2.09356192e-02f,
  -1.56282093e-02f, -5.47655001e-02f, -3.38768922e-02f, -9.92092937e-02f, -4.76565883e-02f, 3.13697159e-02f, 1.02330670e-02f, -1.52968466e-01f, -1.19406335e-01f, -9.54156625e-04f,
  -4.80536744e-02f, -1.11432388e-01f, -6.89673126e-02f, 9.88362506e-02f, 6.64892495e-02f, -3.94677073e-02f, -8.05530231e-03f, 3.00122704e-02f, 6.07996136e-02f, -8.91943171e-04f,
  -1.25300854e-01f, -1.33180404e-02f, -7.40483180e-02f, 9.77288745e-03f, 5.55147193e-02f, -6.03010841e-02f, -7.26178661e-02f, -6.99343607e-02f, 7.47446017e-03f, 7.90892635e-03f,
  -3.18376580e-03f, -1.38381451e-01f, -5.74179515e-02f, -5.91366999e-02f, -9.91244987e-02f, -5.04808426e-02f, -2.75333934e-02f, -2.19218084e-03f, -1.02468336e-03f, -1.54473498e-01f,
  2.89505541e-01f, 1.45439953e-01f, 8.29566568e-02f, 3.75896916e-02f, -1.83076560e-01f, -1.39599055e-01f, 4.73239720e-02f, -1.11794308e-01f, -1.06029652e-01f, -6.94533139e-02f,
  -1.69198811e-01f, 9.62627977e-02f, 8.43006596e-02f, -1.04672022e-01f, -2.01540142e-02f, 7.49579445e-02f, 4.04829681e-02f, 8.98524448e-02f, 2.81769130e-02f, -1.53782263e-01f,
  -4.64440472e-02f, 1.51083888e-02f, 1.86637446e-01f, 2.49859244e-02f, -9.96179506e-02f, 4.80341800e-02f, 1.25777081e-01f, 3.58083635e-03f, 2.27172561e-02f, 1.20210104e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.99918166e-01f, 2.53431141e-01f, 3.05315882e-01f, 5.29762745e-01f, 9.49811116e-02f, 4.82545286e-01f, 3.27204525e-01f, 3.11533540e-01f, 2.60257095e-01f, 3.69567335e-01f,
  3.14460158e-01f, 2.75666177e-01f, 3.54221255e-01f, 1.88023329e-01f, 6.08197331e-01f, 4.56413209e-01f, 3.38091463e-01f, 2.57004619e-01f, 1.27777770e-01f, 5.19264519e-01f,
  4.34805661e-01f, 4.85279977e-01f, 5.16446352e-01f, 4.10318315e-01f, 4.98740643e-01f, 3.51934075e-01f, 4.28662270e-01f, 3.01061869e-01f, 1.40790954e-01f, 1.21904276e-01f,
  3.59902322e-01f, 3.48700881e-01f, 5.14622569e-01f, 5.34493268e-01f, 2.60548621e-01f, 4.78053093e-01f, 3.61524761e-01f, 6.38891280e-01f, 1.09641403e-01f, 4.33630407e-01f,
  3.60288352e-01f, 5.07312596e-01f, 5.74915707e-01f, 3.30633759e-01f, 3.39033723e-01f, 2.68959641e-01f, 7.32643247e-01f, 3.50940645e-01f, 3.54054332e-01f, 3.49304885e-01f,
  1.30753174e-01f, 4.57538128e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -3.83299813e-02f, 5.74215222e-03f, -1.16350830e-01f, -1.57416269e-01f, -9.10241306e-02f, -5.91282286e-02f, -2.10189193e-01f, -1.11295983e-01f, 6.41897134e-03f, -1.01719387e-01f,
  -1.70354813e-01f, -2.44440839e-01f, -2.16799807e-02f, -1.22258514e-01f, 2.84916591e-02f, -4.21269536e-02f, -4.03513126e-02f, 3.90311629e-02f, -5.38347475e-02f, -6.11631051e-02f,
  1.06169647e-02f, -1.21066365e-02f, -1.76183283e-01f, -1.54847500e-03f, 1.54369334e-02f, -2.01790612e-02f, 3.80491395e-03f, -8.58298019e-02f, -2.62498200e-01f, -2.48734161e-01f,
  3.21980566e-02f, 9.25903171e-02f, -5.26312999e-02f, -1.06039874e-01f, 1.65171742e-01f, -1.07585669e-01f, -2.04101577e-02f, -1.64034367e-01f, -3.45528349e-02f, -2.42147803e-01f,
  1.99982285e-01f, 2.45896876e-01f, -3.02432142e-02f, 2.11875793e-03f, 1.53556630e-01f, -2.26154476e-01f, 7.80853108e-02f, 6.22434616e-02f, 1.76299494e-02f, -5.60588278e-02f,
  1.45829052e-01f, 1.06349155e-01f, -3.04429289e-02f, 5.18606007e-02f, -9.25672352e-02f, 1.51943654e-01f, -1.22643514e-02f, -4.52505574e-02f, 3.51230428e-02f, -2.00800985e-01f,
  -7.13301450e-03f, 5.89035377e-02f, 6.12583794e-02f, -7.25034699e-02f, 8.82994980e-02f, -1.61887929e-01f, 1.46392554e-01f, 1.78264692e-01f, -2.31434889e-02f, -3.98558564e-02f,
  1.08597569e-01f, 1.28216758e-01f, -2.75905699e-01f, -7.56853148e-02f, -5.55690378e-02f, -3.90463993e-02f, 8.89375433e-02f, -4.44141448e-01f, 5.04872978e-01f, -3.43398191e-02f,
  -5.52826762e-01f, 4.26640004e-01f, -3.64247888e-01f, -1.71677336e-01f, 7.39343762e-01f, 3.53910834e-01f, 2.17189088e-01f, 4.12080511e-02f, -4.43969518e-01f, -9.21759680e-02f,
  -5.33658683e-01f, -4.55899298e-01f, -9.97141749e-02f, -7.76413977e-02f, 6.85451329e-02f, -1.81342632e-01f, 2.21145585e-01f, -8.59774411e-01f, -2.94284523e-01f, -1.75758541e-01f,
  -2.03275140e-02f, 3.83518875e-01f, -1.65119737e-01f, -2.09692046e-01f, -1.66288719e-01f, 3.18231612e-01f, 1.55590996e-01f, 4.15018424e-02f, -5.35594463e-01f, 2.24217325e-02f,
  4.22033519e-02f, -2.24043522e-02f, 2.04873070e-01f, -4.35517937e-01f, -1.13151856e-01f, -4.58344966e-02f, 1.68909341e-01f, -4.80342627e-01f, -2.19641104e-01f, -3.39513868e-01f,
  -6.90614343e-01f, 1.97517395e-01f, -2.69928902e-01f, -3.06720078e-01f, 2.60479212e-01f, -8.76946568e-01f, 2.89288044e-01f, -1.41214088e-01f, 4.41105058e-03f, 5.71388975e-02f,
  -3.51520665e-02f, 2.17913702e-01f, 9.00497511e-02f, 1.62510827e-01f, 9.26631242e-02f, 5.07340878e-02f, 7.20359087e-02f, -9.28310156e-02f, 7.72942901e-02f, 8.24534371e-02f,
  1.28535658e-01f, -9.39840823e-02f, -2.73029655e-02f, 1.64559141e-01f, 5.42902574e-02f, 2.86540352e-02f, 7.83385560e-02f, 4.48409356e-02f, -5.67513146e-02f, -3.09780508e-01f,
  -2.33319387e-01f, 1.75020725e-01f, -2.60284748e-02f, 2.72468496e-02f, 1.46538734e-01f, 5.03509305e-02f, 3.84904481e-02f, -9.19773355e-02f, 4.99796495e-02f, -4.80645010e-03f,
  5.04604839e-02f, -2.14110643e-01f, -7.06726015e-02f, -1.69783104e-02f, 1.76869035e-02f, -5.02748527e-02f, 2.37929299e-01f, -1.01394234e-02f, 1.00096412e-01f, 5.27344935e-04f,
  1.13899879e-01f, 8.06603655e-02f, -3.69261354e-02f, -2.75726080e-01f, -1.18185580e-02f, -1.84876055e-01f, 1.08204685e-01f, 1.48301125e-01f, -8.37676674e-02f, 1.76879808e-01f,
  -1.66460648e-01f, 2.32482374e-01f, -3.00739855e-01f, -2.10270762e-01f, 1.85782030e-01f, 7.10814670e-02f, -1.60680220e-01f, 1.19459331e-02f, 5.05861007e-02f, 5.70129864e-02f,
  -2.13257819e-02f, 8.50693062e-02f, 1.83788940e-01f, -2.13843092e-01f, -3.57543468e-03f, -4.35646288e-02f, 2.24186808e-01f, 7.27988154e-05f, -6.72603175e-02f, 1.79094642e-01f,
  -2.56734192e-02f, 1.43263504e-01f, 9.38690752e-02f, 1.10398464e-01f, 1.09599493e-01f, -1.59631968e-01f, 1.88332930e-01f, -2.97163874e-01f, 7.60783628e-02f, 5.54281950e-01f,
  -3.86237204e-01f, 3.46841365e-01f, -1.03302352e-01f, 4.94799577e-02f, -1.94832087e-01f, -6.97335541e-01f, 1.36966839e-01f, -2.34972686e-01f, 7.49674514e-02f, -1.57085985e-01f,
  -5.63004792e-01f, -2.68342525e-01f, 4.54855189e-02f, -1.33581862e-01f, 4.91521060e-01f, -6.75842464e-01f, -5.71485221e-01f, 1.55135110e-01f, -6.91070139e-01f, -3.43588293e-01f,
  2.18746796e-01f, -6.86538875e-01f, -3.12315851e-01f, 2.85569131e-01f, -9.48065937e-01f, -3.96203063e-02f, -9.35419276e-02f, 2.73772240e-01f, -1.32598758e-01f, 2.03885734e-01f,
  -6.96218431e-01f, 2.83576846e-01f, 1.54474735e-01f, 2.25487649e-01f, 5.55841923e-01f, -6.43046619e-03f, -1.34233391e+00f, 3.82069051e-01f, -3.71710688e-01f, -5.08335590e-01f,
  -6.36788964e-01f, 1.34817317e-01f, -6.80131614e-01f, -5.14737546e-01f, 6.91383958e-01f, 3.42700034e-01f, 1.73168883e-01f, -3.47228274e-02f, 2.57568620e-02f, 1.24341482e-03f,
  1.41180232e-01f, 7.63142407e-02f, 6.75367117e-02f, 1.33124545e-01f, 4.43810737e-03f, 1.18757792e-01f, -7.24925697e-02f, 2.30864778e-01f, 5.63897304e-02f, -1.03706273e-03f,
  1.14151403e-01f, 1.81032345e-02f, 1.79613575e-01f, 1.88301299e-02f, 2.30441093e-01f, 2.25686416e-01f, 3.23502496e-02f, -5.94653888e-03f, 1.60847738e-01f, 6.50787726e-02f,
  1.76877350e-01f, 6.56530932e-02f, -8.68985951e-02f, -1.15042306e-01f, 1.33846387e-01f, 2.16418192e-01f, 1.32960901e-01f, 4.15532663e-02f, 7.85683170e-02f, 2.98470538e-03f,
  4.24964167e-02f, 3.31790000e-02f, 8.08411613e-02f, 3.01606916e-02f, 1.81108862e-01f, -1.59490138e-01f, -2.53227353e-01f, 2.69070029e-01f, -2.22936630e-01f, -3.18957642e-02f,
  6.85238987e-02f, -3.33971173e-01f, 2.28768840e-01f, 6.98016398e-03f, -2.02118352e-01f, 1.63285911e-01f, -6.55958951e-02f, 7.02710003e-02f, 2.37072542e-01f, 1.28986731e-01f,
  3.65301967e-02f, -3.20086628e-01f, 1.20783027e-03f, -3.60247314e-01f, 5.92741836e-03f, 2.70351946e-01f, -1.43007204e-01f, 8.10794085e-02f, -2.87846643e-02f, -7.39043811e-03f,
  8.58373567e-02f, -6.10424466e-02f, 1.75956011e-01f, 3.32825392e-01f, 1.35885462e-01f, 3.45848173e-01f, -1.99197873e-01f, -5.91095500e-02f, 1.50370210e-01f, -1.20015182e-01f,
  -1.71449110e-01f, 3.50524127e-01f, -4.28130120e-01f, -2.91491687e-01f, -3.10794801e-01f, -1.75750971e-01f, -5.64069390e-01f, -8.57868511e-03f, -1.07627675e-01f, -2.98205674e-01f,
  -4.01365310e-01f, 9.62361991e-01f, -1.73468038e-01f, -3.57799590e-01f, 2.74295956e-01f, 1.35682613e-01f, 4.11164135e-01f, -2.61264443e-01f, -3.30233604e-01f, -5.39775155e-02f,
  9.01486948e-02f, 7.30617121e-02f, 6.12612844e-01f, -3.96574467e-01f, -2.65368111e-02f, -2.15224683e-01f, -4.90277022e-01f, -1.74658537e-01f, -4.93570596e-01f, -1.48795284e-02f,
  2.30719432e-01f, -2.48421337e-02f, -6.21961653e-01f, 2.19007492e-01f, -2.35714346e-01f, -8.85012746e-02f, -3.73310953e-01f, -5.65710604e-01f, 6.09759875e-02f, -1.06606416e-01f,
  -1.55085385e-01f, -3.02554499e-02f, 2.42618591e-01f, -3.27535048e-02f, -2.93986082e-01f, -2.41874352e-01f, -3.46229821e-01f, 3.02772939e-01f, 2.14853004e-01f, -1.77414101e-02f,
  6.93712354e-01f, 7.97392279e-02f, -5.67232788e-01f, -4.80725691e-02f, -1.83767080e-03f, 4.78165522e-02f, -3.73426862e-02f, -1.86990768e-01f, -8.30564555e-03f, -5.31134084e-02f,
  -1.02605432e-01f, 7.68538006e-03f, -9.93450359e-02f, 1.24711178e-01f, -1.17964474e-02f, -3.47294092e-01f, -1.05791353e-02f, 8.04207847e-02f, -3.99255678e-02f, 2.11881399e-01f,
  -1.04137741e-01f, -2.47282032e-02f, 1.79378893e-02f, 7.62839392e-02f, -6.65763393e-02f, 6.19545914e-02f, -2.22418346e-02f, 2.94070803e-02f, 9.14819464e-02f, -2.12801591e-01f,
  6.11872971e-02f, 1.74855758e-02f, 3.70250605e-02f, 2.71338522e-01f, -1.02093056e-01f, 7.26226196e-02f, -1.27591556e-02f, -1.10057682e-01f, -9.18157101e-02f, -1.18836213e-03f,
  6.56547844e-02f, 5.41134179e-02f, -4.36946116e-02f, -1.61186546e-01f, -3.07371449e-02f, -3.67535740e-01f, 1.10305265e-01f, 4.31604795e-02f, 1.60395894e-02f, -8.41746032e-02f,
  1.50271073e-01f, -2.21182127e-02f, 3.36537585e-02f, -4.65359315e-02f, 1.93544924e-01f, 8.75175297e-02f, -2.31670395e-01f, -2.65494585e-01f, 2.25609541e-01f, 1.01805948e-01f,
  1.97118580e-01f, 8.97998363e-02f, -1.70567781e-01f, 2.05531254e-01f, -1.18285425e-01f, 9.06261578e-02f, -6.42661899e-02f, 1.76695641e-02f, -2.65959352e-01f, 4.56244856e-01f,
  5.90848811e-02f, -1.35215089e-01f, -1.27458096e-01f, 9.09540877e-02f, -8.51125568e-02f, 8.49361792e-02f, 6.38695061e-02f, 4.14718464e-02f, -1.38591871e-01f, -1.66343138e-01f,
  -2.87896335e-01f, 5.93939498e-02f, -6.48098350e-01f, 5.30506313e-01f, -1.92850351e-01f, -4.60031986e-01f, -6.62221983e-02f, -2.11353064e-01f, -7.95479596e-01f, -2.81327754e-01f,
  -6.86021924e-01f, 3.96276146e-01f, -3.58010262e-01f, -1.41554490e-01f, 3.35003614e-01f, -8.94571096e-02f, 3.85915101e-01f, 5.30657232e-01f, -6.36331379e-01f, -3.49903554e-01f,
  1.78721651e-01f, -4.70655411e-01f, -1.10502116e-01f, -2.70663559e-01f, -4.09022093e-01f, 7.09113359e-01f, -3.08647484e-01f, 5.32954097e-01f, -1.50832534e-01f, -3.52995485e-01f,
  -4.69340011e-03f, -4.54866409e-01f, -3.52424383e-01f, -1.15587962e+00f, 6.21281601e-02f, 4.99540925e-01f, -7.71587729e-01f, -2.06415147e-01f, -4.19996679e-01f, -9.45605412e-02f,
  -3.64395142e-01f, -5.64475298e-01f, 4.54631269e-01f, 4.99036796e-02f, -2.11916357e-01f, -3.77371192e-01f, 5.24791539e-01f, -3.64688069e-01f, 1.35956153e-01f, -4.43243206e-01f,
  -2.77230531e-01f, -5.87278366e-01f, -6.19533136e-02f, 1.71839744e-02f, -7.20768943e-02f, 2.16576874e-01f, 9.82310176e-02f, -3.08416516e-01f, -2.31174696e-02f, -6.36759847e-02f,
  -1.54276922e-01f, 7.15523027e-03f, 6.12160414e-02f, 4.03784402e-02f, 1.43710688e-01f, 2.31337901e-02f, 1.54551640e-01f, -3.87920961e-02f, -5.50237969e-02f, 6.74458146e-02f,
  -5.09694917e-03f, -2.43249714e-01f, 1.54609933e-01f, -1.46401078e-01f, 1.84749663e-01f, -1.18209392e-01f, -1.27874196e-01f, -1.85877070e-01f, 1.75541341e-01f, 9.04917493e-02f,
  7.02290460e-02f, -1.07130565e-01f, 1.22506835e-01f, 6.50810404e-03f, -5.94045147e-02f, 4.74653468e-02f, -1.50172517e-01f, 7.80798569e-02f, -1.54691964e-01f, -4.62352261e-02f,
  -2.94376075e-01f, 2.32613891e-01f, -1.30885132e-02f, 4.93341461e-02f, -6.70619830e-02f, 2.27031127e-01f, 1.10487141e-01f, 1.62089303e-01f, 2.80678850e-02f, -2.08038151e-01f,
  -1.04462858e-02f, 2.77973056e-01f, -9.35030952e-02f, -2.18139157e-01f, 2.21104860e-01f, 1.84312969e-01f, -3.48288822e-03f, -4.51600030e-02f, 3.84250768e-02f, 3.84390652e-02f,
  5.29551320e-02f, 1.29171580e-01f, -2.61220127e-01f, -4.84223813e-02f, -2.05051437e-01f, 1.71741784e-01f, -1.80068508e-01f, -1.27552286e-01f, -4.69204299e-02f, -1.39296874e-01f,
  -6.30258396e-02f, 7.30208829e-02f, -2.86695566e-02f, 1.42261267e-01f, 4.90457639e-02f, 1.61261573e-01f, -1.83229893e-01f, -5.94615377e-02f, -5.04868925e-02f, -6.59662709e-02f,
  -7.58802176e-01f, 3.92848343e-01f, 1.67630568e-01f, -4.90010411e-01f, -1.90993659e-02f, -6.19044304e-01f, -4.58774507e-01f, -4.04778183e-01f, -2.14214414e-01f, 1.88725576e-01f,
  -4.28819805e-02f, 9.67156366e-02f, -2.65763164e-01f, -2.82654017e-01f, 3.29001009e-01f, -1.51877582e-01f, 1.35694608e-01f, -3.38228315e-01f, 5.83389811e-02f, 4.76827085e-01f,
  -3.62998396e-01f, -1.43900782e-01f, -9.51173827e-02f, -8.83925617e-01f, -4.05986123e-02f, 1.15322741e-03f, -6.43473685e-01f, -2.32675746e-01f, 3.17743510e-01f, -5.12432493e-03f,
  -1.19999452e-02f, -1.55891433e-01f, 3.81887555e-01f, -2.23411083e-01f, 4.40257996e-01f, -8.67844597e-02f, -3.06104004e-01f, 2.88204588e-02f, 5.67518920e-02f, -2.55368888e-01f,
  -1.07317455e-01f, 3.77295888e-03f, 5.53230643e-01f, 2.77387381e-01f, -5.99469781e-01f, 4.03601024e-03f, -2.18146250e-01f, 7.98249900e-01f, 2.20009554e-02f, -2.32195988e-01f,
  -9.80312452e-02f, 3.77120152e-02f, 4.88274470e-02f, 2.37043351e-01f, 6.85192570e-02f, 3.18734050e-02f, -6.42475300e-03f, 1.39597386e-01f, 2.55377702e-02f, 1.50946349e-01f,
  -5.88394478e-02f, 1.86564758e-01f, -4.91993129e-02f, 6.36991933e-02f, 1.28497723e-02f, 1.99096665e-01f, 9.78778377e-02f, -6.47683367e-02f, 2.13807374e-02f, 2.80284751e-02f,
  2.46463362e-02f, 1.53894082e-01f, 1.39293864e-01f, 7.49646649e-02f, -6.90023229e-03f, 1.34394810e-01f, -1.03964182e-02f, -3.65397446e-02f, 3.24652530e-02f, -4.25588712e-02f,
  -6.29870668e-02f, -7.16281906e-02f, 1.46725804e-01f, 2.28584468e-01f, 1.41592279e-01f, 2.21908271e-01f, -3.26440297e-02f, 2.97002140e-02f, 1.66436091e-01f, 3.08031924e-02f,
  -3.12177148e-02f, 8.80241096e-02f, -2.93124234e-03f, -3.15543078e-02f, -1.47203103e-01f, 1.43210247e-01f, -2.58316249e-01f, -1.20251037e-01f, 5.51899076e-02f, -1.84836596e-01f,
  -1.06886946e-01f, -2.41977628e-02f, -1.90132573e-01f, -2.00433701e-01f, 5.76688834e-02f, 2.51663744e-01f, -2.21387923e-01f, -9.83903781e-02f, -2.36950982e-02f, 1.54495746e-01f,
  -2.56415367e-01f, 1.32596061e-01f, 9.59115773e-02f, -1.83083326e-01f, -1.30383134e-01f, -2.75500238e-01f, 1.30668342e-01f, -1.46222353e-01f, 2.02679321e-01f, -2.50225633e-01f,
  1.17793113e-01f, 1.42397836e-01f, -1.27083659e-01f, -1.74813364e-02f, 2.58601811e-02f, -1.53308988e-01f, 5.13368607e-01f, 2.05331579e-01f, 3.62581670e-01f, -5.45004249e-01f,
  -7.24486867e-03f, 1.09670147e-01f, -1.72493055e-01f, -1.58923849e-01f, 8.41163620e-02f, -5.58517039e-01f, 6.87493086e-01f, -2.82475770e-01f, -2.90759534e-01f, 2.72522062e-01f,
  -7.57439017e-01f, -4.79697771e-02f, -6.89057946e-01f, -7.35436440e-01f, -1.68441564e-01f, 2.32459739e-01f, -6.91591084e-01f, 9.40016270e-01f, -1.74850628e-01f, -6.48642480e-02f,
  4.92512524e-01f, -3.47512126e-01f, -2.32352003e-01f, -7.26650655e-01f, -5.06470025e-01f, 2.63326801e-02f, 1.18098721e-01f, -2.54463643e-01f, 1.98784456e-01f, -1.44891351e-01f,
  2.08847538e-01f, 3.06658953e-01f, -2.65309900e-01f, 1.09680898e-01f, 3.32257934e-02f, -2.81675220e-01f, 2.42871910e-01f, 6.55622855e-02f, 7.72218585e-01f, -2.47320801e-01f,
  1.93626866e-01f, 3.21256043e-03f, -5.81614852e-01f, -6.80760071e-02f, -4.22863513e-01f, -2.15227112e-01f, -3.32838036e-02f, 3.57825719e-02f, -1.87709797e-02f, -6.95993006e-03f,
  -7.69302547e-02f, -1.56293772e-02f, -1.21588282e-01f, -9.36270505e-03f, 5.63849621e-02f, 3.77912857e-02f, 1.28308594e-01f, -9.01631042e-02f, -5.04025817e-02f, -1.31669343e-01f,
  7.65876193e-03f, 2.44061053e-01f, -8.82950574e-02f, -6.61332905e-02f, 1.26757532e-01f, 4.37638201e-02f, -2.41989285e-01f, 4.36240770e-02f, 8.58134478e-02f, 6.82103708e-02f,
  -9.34847966e-02f, -7.36972317e-02f, 1.86262146e-01f, 8.19582585e-03f, -3.02764252e-02f, 3.33520360e-02f, -4.61033173e-02f, -2.87476946e-02f, -5.37779108e-02f, -2.50085536e-02f,
  5.93749769e-02f, -1.50772825e-01f, -1.03137074e-02f, -1.16503820e-01f, 3.67275928e-03f, 1.58376276e-01f, 9.17287022e-02f, -3.44522893e-01f, -2.02831984e-01f, 1.53946310e-01f,
  -2.14525074e-01f, 1.53994337e-01f, -1.71150882e-02f, 8.84806886e-02f, -1.85035050e-01f, 2.14266077e-01f, -1.05350366e-04f, -2.45120242e-01f, -1.60155162e-01f, -4.06210497e-02f,
  1.75684109e-01f, 2.45724574e-01f, 3.38124186e-02f, -8.58640671e-02f, -2.38176480e-01f, -3.87983285e-02f, 2.39787623e-01f, -1.89344883e-01f, 1.72020242e-01f, -3.29573482e-01f,
  -7.55810225e-03f, -1.78529605e-01f, 2.74292618e-01f, -3.12961973e-02f, -1.29740983e-01f, 1.64755836e-01f, 1.11013927e-01f, 7.05276430e-02f, 1.12263940e-01f, -1.51980177e-01f,
  1.39477804e-01f, -1.55643255e-01f, 2.06411749e-01f, -1.26257371e-02f, -1.96221560e-01f, -5.94158649e-01f, -2.11664468e-01f, -5.13229311e-01f, -2.73154616e-01f, -2.94833779e-01f,
  -2.72453606e-01f, 3.53507757e-01f, -3.53433698e-01f, 4.39197183e-01f, 4.72586975e-02f, -2.63125241e-01f, -1.89989954e-01f, 7.18397722e-02f, -3.60681802e-01f, 1.00915588e-01f,
  -3.34958822e-01f, -8.16254556e-01f, -1.88364089e-01f, -2.34069929e-01f, -4.54241782e-01f, 6.51649415e-01f, 4.49264407e-01f, -1.05979346e-01f, -5.30900538e-01f, -1.59274742e-01f,
  3.61052662e-01f, -5.13203800e-01f, 5.56814969e-01f, -3.04554492e-01f, -5.68606615e-01f, 1.61688849e-01f, 4.40642178e-01f, 2.16262147e-01f, -3.87703449e-01f, -2.08597094e-01f,
  3.02596956e-01f, 4.23742026e-01f, -4.94847894e-01f, -7.16085359e-02f, -4.99628395e-01f, -2.99412429e-01f, -2.82520682e-01f, -3.93609375e-01f, -4.74462390e-01f, -8.27606678e-01f,
  -5.19331694e-01f, -1.60596177e-01f, -1.67953581e-01f, 4.58453119e-01f, -2.17981473e-01f, -1.55873373e-01f, -1.09687842e-01f, -2.07859084e-01f, -1.17496297e-01f, -5.39369322e-02f,
  -1.15376944e-02f, -7.73765147e-02f, -1.43396556e-02f, -1.91951200e-01f, 1.38317674e-01f, -4.13331464e-02f, -7.00797141e-02f, 2.18507182e-02f, -1.13701858e-01f, -2.83897251e-01f,
  -9.23380628e-02f, 4.09627631e-02f, -1.10236742e-01f, -6.64994866e-02f, -1.82165667e-01f, 1.06171250e-01f, -5.89708313e-02f, -1.52281269e-01f, -2.86577810e-02f, 2.12298427e-02f,
  -2.41881162e-01f, -3.29194628e-02f, -8.80551040e-02f, -1.44647226e-01f, -1.63464814e-01f, -1.28322080e-01f, -2.04286635e-01f, -2.25959178e-02f, -1.73446864e-01f, -1.14501882e-02f,
  -5.08230440e-02f, 5.96490055e-02f, 5.48672024e-03f, -6.04213998e-02f, -8.97871256e-02f, 2.14159802e-01f, -5.70037104e-02f, 2.26528615e-01f, 9.54693556e-02f, 2.61243898e-02f,
  1.31722316e-01f, 5.45877814e-02f, 4.59698737e-02f, 1.74125209e-02f, 9.78195816e-02f, -1.99649408e-02f, 8.22322965e-02f, -2.18637660e-01f, 4.81477715e-02f, -3.97636116e-01f,
  2.57266879e-01f, -1.89409867e-01f, 2.63988338e-02f, -7.07798153e-02f, 1.27435908e-01f, -1.47535950e-01f, -3.69675532e-02f, 1.45874694e-01f, 6.17344417e-02f, -1.82333708e-01f,
  -1.91002861e-01f, 1.16344430e-01f, -8.75256434e-02f, -4.72564436e-02f, -2.28309870e-01f, 4.83166473e-03f, 1.01689458e-01f, -1.27875339e-03f, -1.86647594e-01f, -1.28831714e-01f,
  5.58061525e-02f, 1.52956784e-01f, -1.17993608e-01f, 2.09904611e-01f, -4.22242373e-01f, -4.85576957e-01f, 3.25205684e-01f, -6.33705020e-01f, 1.92217305e-01f, -5.94169319e-01f,
  -3.60112190e-01f, -1.59305871e-01f, -9.24186110e-02f, 6.18836105e-01f, -2.93072104e-01f, 4.83912975e-02f, 2.33024776e-01f, -2.03360710e-02f, -3.83852243e-01f, 4.87717777e-01f,
  5.25655970e-02f, -1.16612680e-01f, -4.75037992e-01f, 2.86154419e-01f, -2.57955015e-01f, 2.23526508e-02f, -3.07853520e-01f, -3.52031946e-01f, -1.91321522e-01f, 3.65655392e-01f,
  2.36601323e-01f, -4.36709791e-01f, -3.40283543e-01f, 6.20813146e-02f, -4.76733536e-01f, -1.49881482e-01f, -3.12761307e-01f, -4.61344928e-01f, -3.39350671e-01f, -2.96544224e-01f,
  2.71617889e-01f, -1.13502324e-01f, -3.51379216e-01f, -3.44284654e-01f, 7.42260098e-01f, -7.58205205e-02f, -2.78765202e-01f, -3.35810073e-02f, 3.42547685e-01f, -1.02086812e-01f,
  2.85871148e-01f, -2.89373130e-01f, -8.17904249e-02f, -1.85672626e-01f, 3.23647819e-02f, 1.98113799e-01f, -6.31906912e-02f, -9.73911509e-02f, 4.91057970e-02f, 1.95222832e-02f,
  -7.50616752e-03f, 1.00499302e-01f, 1.41897172e-01f, -4.36257794e-02f, 1.17486097e-01f, -1.03285193e-01f, 3.48081402e-02f, -3.86338830e-02f, -3.16993222e-02f, -3.35936368e-01f,
  9.27267075e-02f, -1.27908260e-01f, 5.33770137e-02f, -1.57465771e-01f, -2.07012929e-02f, 7.35460818e-02f, 6.64398214e-03f, -2.20562518e-01f, 2.49897633e-02f, -1.38641462e-01f,
  1.20412752e-01f, 9.38721523e-02f, -1.20170945e-02f, 1.83430612e-02f, 1.53856993e-01f, 6.23318693e-03f, 1.36480510e-01f, 5.26298210e-02f, 2.28740405e-02f, -8.16403329e-02f,
  2.93459874e-02f, 7.11816475e-02f, 1.68420345e-01f, 2.37154171e-01f, -6.88678026e-02f, -1.80519268e-01f, 7.28245154e-02f, -1.60322085e-01f, -1.74531505e-01f, -1.76826864e-02f,
  2.65153587e-01f, 1.85243309e-01f, -6.17005443e-03f, -1.91391230e-01f, -2.03436211e-01f, 2.65564531e-01f, -2.83221304e-01f, -3.20490837e-01f, -1.12362141e-02f, 2.30057552e-01f,
  1.10726446e-01f, -2.36613587e-01f, -5.44937048e-03f, 8.99669621e-03f, 2.36309648e-01f, -9.67631713e-02f, 1.07576206e-01f, -2.24764809e-01f, -2.33727828e-01f, 2.20615715e-01f,
  1.76735789e-01f, -1.14789635e-01f, -8.40180069e-02f, -7.36776441e-02f, 1.22677855e-01f, -4.84869629e-02f, -6.60808682e-02f, -3.20868701e-01f, 2.12464333e-01f, 3.97240937e-01f,
  -6.58323169e-02f, 2.67771751e-01f, 3.61608922e-01f, -5.60966909e-01f, -1.12105720e-02f, 3.06707826e-02f, 2.40237817e-01f, -1.47113204e-01f, 5.43696344e-01f, -1.64394900e-02f,
  -9.32994410e-02f, -1.27487570e-01f, 1.56788513e-01f, -2.69950956e-01f, 1.82670072e-01f, 3.73403847e-01f, -4.38973963e-01f, -7.81779215e-02f, -1.93980873e-01f, 7.67864525e-01f,
  -4.52725530e-01f, -2.18203336e-01f, 7.30309308e-01f, -1.93417892e-01f, -6.03724420e-01f, 3.21438283e-01f, -5.10332346e-01f, 8.35698321e-02f, 6.81159794e-02f, -6.71862513e-02f,
  -1.93259969e-01f, -3.06788176e-01f, -1.93819612e-01f, -6.80595171e-03f, -5.14886677e-01f, -7.08192766e-01f, -1.59624264e-01f, -3.32453877e-01f, -2.57564485e-01f, 2.79877663e-01f,
  -5.20208597e-01f, 4.34579134e-01f, -1.19081609e-01f, 2.33093247e-01f, -3.57193649e-01f, -3.01184773e-01f, 2.61514425e-01f, -1.54508218e-01f, -3.40507895e-01f, -2.24933445e-01f,
  -6.14854872e-01f, -1.73927426e-01f, -5.29182237e-03f, -2.26182491e-02f, 3.40187252e-02f, -5.17575406e-02f, 1.13946609e-01f, -1.00867637e-01f, 1.17378354e-01f, 9.55472961e-02f,
  2.15448096e-01f, -7.92190954e-02f, -6.62198961e-02f, 1.96250647e-01f, -7.45243281e-02f, -1.28970653e-01f, -1.84105724e-01f, 1.40368417e-01f, -1.73294902e-01f, -7.39090517e-03f,
  1.10336721e-01f, -1.15468882e-01f, -8.69986415e-02f, 3.23899612e-02f, 5.18697267e-03f, 6.22001197e-03f, -1.94621123e-02f, 9.80257988e-02f, -1.46145403e-01f, -6.28338978e-02f,
  6.52661920e-02f, 1.93110526e-01f, -5.91880865e-02f, -8.06292966e-02f, 4.29915413e-02f, 1.78687334e-01f, -1.54296279e-01f, 1.07451618e-01f, 7.83486664e-02f, -8.28260407e-02f,
  -1.68133184e-01f, 1.49298295e-01f, 2.94341058e-01f, 3.48957270e-01f, -7.47235045e-02f, -7.24527314e-02f, 1.05209626e-01f, 1.38873652e-01f, -3.03204924e-01f, -2.13155702e-01f,
  -6.99894652e-02f, -2.95218825e-01f, 2.08108023e-01f, -3.65363598e-01f, 1.52584672e-01f, 1.02496922e-01f, -4.18493807e-01f, 1.11669108e-01f, -1.06296450e-01f, 2.44387120e-01f,
  1.44600362e-01f, 5.05999587e-02f, 6.01616651e-02f, 4.90438074e-01f, 1.89867482e-01f, 2.58435488e-01f, 3.83428067e-01f, -3.23851585e-01f, 6.29693270e-02f, -2.42032498e-01f,
  -1.83720931e-01f, 2.01622814e-01f, -3.11262280e-01f, 6.33991137e-02f, 1.57123625e-01f, -9.20208618e-02f, -5.61648607e-02f, -2.72619069e-01f, -1.72586396e-01f, -4.07670289e-01f,
  -5.23325443e-01f, -1.26424640e-01f, -1.58494711e-01f, -3.92610371e-01f, -9.28048640e-02f, 2.78263956e-01f, 1.76927373e-01f, -9.90814149e-01f, -3.82707238e-01f, -4.42305744e-01f,
  1.54748395e-01f, -6.45427406e-01f, 5.22954427e-02f, -1.00351579e-01f, -6.88371181e-01f, 3.90657634e-01f, -1.87533349e-01f, -2.54458398e-01f, -6.75984621e-01f, -4.02646899e-01f,
  -1.15378201e-01f, -3.28837991e-01f, 7.89479673e-01f, -4.49395835e-01f, 7.81921744e-02f, 4.67617810e-01f, 1.92324758e-01f, 1.55743705e-02f, 4.42639470e-01f, 3.34374726e-01f,
  1.38000935e-01f, 3.36009532e-01f, -3.23186040e-01f, -5.34354866e-01f, 4.36941415e-01f, -1.37257412e-01f, 2.96082258e-01f, -3.72913569e-01f, -9.98826846e-02f, -1.34394154e-01f,
  -7.90637314e-01f, -2.37038925e-01f, 2.28461981e-01f, 8.46931279e-01f, -3.82511526e-01f, -2.64830381e-01f, 1.16846643e-01f, 1.05425507e-01f, -3.08204234e-01f, -1.21504784e-01f,
  2.46276736e-01f, -1.06256224e-01f, 5.73121198e-02f, -1.71295851e-01f, -5.12763597e-02f, 1.43966258e-01f, 3.86464735e-03f, -8.73917565e-02f, 3.21574435e-02f, 1.10147148e-01f,
  4.08799276e-02f, 2.05025449e-01f, -3.50876078e-02f, 1.39936078e-02f, -5.04058376e-02f, -3.39730829e-02f, 1.08361602e-01f, 1.00110479e-01f, 4.90012579e-02f, 1.92041863e-02f,
  9.79567170e-02f, 1.89644739e-01f, 1.31570250e-01f, 1.04564734e-01f, -6.89706951e-02f, 5.60315698e-02f, 7.15445057e-02f, 2.91885734e-01f, 8.73400047e-02f, -5.16016744e-02f,
  5.11211269e-02f, 4.55272645e-02f, -4.97577749e-02f, 1.64503917e-01f, 1.05832405e-01f, 6.46198839e-02f, -7.13109300e-02f, 1.25674561e-01f, -2.20882315e-02f, 3.13338608e-01f,
  5.34993336e-02f, -2.85804629e-01f, 2.50198871e-01f, -1.64165184e-01f, -1.81660103e-03f, -1.81971431e-01f, 1.38864174e-01f, -2.78001666e-01f, 2.23205268e-01f, 1.46650538e-01f,
  1.98409379e-01f, -6.64760694e-02f, -1.61028475e-01f, -2.17140019e-01f, -1.52156800e-01f, -2.30784655e-01f, 2.33758956e-01f, 1.01004899e-01f, 2.78445601e-01f, -3.07273924e-01f,
  -6.35194182e-02f, -4.13308591e-02f, -1.07048593e-01f, 2.64738232e-01f, 2.45749012e-01f, 1.10771120e-01f, 3.29921246e-02f, -3.45058739e-02f, -1.19801089e-01f, -7.09136203e-03f,
  -3.63460481e-02f, -8.82888883e-02f, -6.94807619e-02f, 2.58563608e-01f, -1.79632545e-01f, -1.01512551e-01f, -9.87629741e-02f, -2.08246857e-01f, 4.28334437e-02f, -3.75598073e-01f,
  -3.93831104e-01f, -3.55170995e-01f, 3.44262004e-01f, -2.10224807e-01f, 4.03891765e-02f, -2.02064946e-01f, -1.41115233e-01f, -1.53123528e-01f, -3.67722690e-01f, 1.05822966e-01f,
  5.58700502e-01f, -1.83854491e-01f, -5.54485679e-01f, -3.27334553e-01f, -2.17895000e-03f, -1.00136397e-03f, -4.13069367e-01f, -3.66924822e-01f, -3.00569117e-01f, -1.69439182e-01f,
  -2.26293225e-02f, 6.88724160e-01f, -1.48321658e-01f, -3.71265501e-01f, 5.07855564e-02f, -6.69713259e-01f, -1.08261056e-01f, -4.07898933e-01f, -1.27371013e-01f, -4.12570208e-01f,
  -3.69729221e-01f, 4.41893339e-01f, -1.06527060e-01f, 1.30136698e-01f, -3.56784947e-02f, -3.92558277e-01f, -6.18593752e-01f, 5.58362436e-03f, -6.34696633e-02f, -3.26526105e-01f,
  6.01891935e-01f, -4.11674172e-01f, -3.29768211e-01f, 8.05905700e-01f, -2.22609565e-01f, 1.42371971e-02f, -3.58705431e-01f, 4.77037847e-01f, -1.91609915e-02f, 1.18210405e-01f,
  2.88750269e-02f, 1.29277095e-01f, -5.41838668e-02f, -7.84880593e-02f, 6.33633882e-02f, -7.16210455e-02f, -8.66108313e-02f, -8.80760029e-02f, -9.72850323e-02f, -1.39878169e-01f,
  6.98318034e-02f, -3.73157524e-02f, 2.40403600e-02f, 2.80437805e-02f, 2.51723900e-02f, 5.23102395e-02f, 1.53419182e-01f, 1.20655805e-01f, 1.08432569e-01f, -4.18604016e-02f,
  8.61633103e-03f, 5.16790487e-02f, 4.21152338e-02f, 1.61706135e-01f, -6.35154396e-02f, -1.34384781e-01f, -4.92462963e-02f, 1.00967646e-01f, -7.60112926e-02f, 8.25393647e-02f,
  -4.51484099e-02f, -9.93191544e-03f, 8.21470544e-02f, 4.48223092e-02f, 7.97918662e-02f, 9.91407558e-02f, -2.24875242e-01f, -2.75616497e-01f, -4.00587618e-02f, -4.69122946e-01f,
  -3.33397150e-01f, 2.67228782e-01f, 6.28236979e-02f, 2.63355911e-01f, -2.33661160e-01f, 2.45504394e-01f, -2.08251849e-01f, -1.79486006e-01f, -3.43359649e-01f, 4.86739546e-01f,
  1.63735181e-01f, 2.32017547e-01f, 1.48740590e-01f, 1.65448964e-01f, -5.42836897e-02f, 1.05243558e-02f, -2.75553077e-01f, 2.24819221e-02f, 1.57289535e-01f, -9.50887874e-02f,
  1.31842773e-02f, 1.15104131e-01f, -2.04764947e-01f, 3.19007069e-01f, -2.26844847e-01f, 1.66356310e-01f, -3.80842716e-01f, -2.30384484e-01f, 9.13214013e-02f, -1.03559673e-01f,
  1.86296433e-01f, -1.68724395e-02f, 1.05310775e-01f, -1.03851482e-01f, -2.04629362e-01f, 3.34022552e-01f, -3.96924227e-01f, 2.81373560e-01f, -1.60534292e-01f, -3.78833860e-01f,
  1.16193950e-01f, 3.44090611e-02f, -4.17530149e-01f, -2.47838974e-01f, -2.07809150e-01f, -4.47635114e-01f, 1.97120249e-01f, -2.24757642e-01f, -5.34496546e-01f, 4.41812575e-01f,
  7.89322615e-01f, -4.82969731e-02f, 3.79102491e-02f, -6.10233426e-01f, -1.68822050e-01f, -4.00129199e-01f, 7.21298233e-02f, 4.91913140e-01f, 4.00566548e-01f, -2.38990024e-01f,
  3.58106643e-01f, 1.37108594e-01f, -4.88221884e-01f, -2.80008733e-01f, -1.95506707e-01f, -4.18257415e-01f, 3.73198450e-01f, -8.82906318e-02f, -3.00125957e-01f, -1.17195077e-01f,
  -5.53074956e-01f, 1.60088286e-01f, -3.79150867e-01f, -5.65533824e-02f, -4.08429384e-01f, -3.30256939e-01f, -3.49394113e-01f, -3.60982209e-01f, -1.57537356e-01f, -3.92394245e-01f,
  7.39817560e-01f, -1.91092566e-01f, -2.84764498e-01f, -3.54878068e-01f, -1.43575862e-01f, 1.25924245e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.81694829e-01f, 9.36983749e-02f, 1.53469360e-02f, 1.08072255e-02f, 1.50795160e-02f, -6.97633252e-02f, -6.29057735e-02f, 6.03445210e-02f, -4.91851419e-02f, 1.17081977e-01f,
  -6.34534732e-02f, 3.13945711e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    