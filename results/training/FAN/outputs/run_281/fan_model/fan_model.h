/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.03503647e-02f, -1.32246986e-02f, -8.28031823e-02f, -3.81115787e-02f, 2.43508890e-02f, 4.04176652e-01f, 3.09443772e-01f, -2.64412034e-02f, 1.82159230e-01f, 1.05128996e-02f,
  1.02843367e-01f, 5.94023466e-02f, 1.36017099e-01f, 2.38181233e-01f, 5.14872789e-01f, 3.21020663e-01f, 2.85713077e-01f, 9.33917910e-02f, 5.46282530e-02f, -6.05993532e-03f,
  8.42463002e-02f, 1.11852951e-01f, 8.23039860e-02f, -5.02935126e-02f, -4.25617658e-02f, -1.77209735e-01f, -2.13454247e-01f, -1.65601820e-01f, -2.04800181e-02f, 5.07710129e-02f,
  1.08973995e-01f, 4.33505736e-02f, -6.14861920e-02f, -6.51223138e-02f, -6.56217057e-03f, -1.11266792e-01f, -2.92513818e-02f, -6.15729950e-02f, 2.10327227e-02f, 1.86433252e-02f,
  -1.08633293e-02f, -4.57862988e-02f, -1.99959874e-02f, -7.90132023e-03f, 2.46309955e-02f, -4.80843112e-02f, -1.17886132e-02f, 9.83102946e-04f, -2.74827164e-02f, 4.02438864e-02f,
  1.68228559e-02f, -5.86985499e-02f, -1.07524253e-01f, -4.31378779e-04f, 1.70637816e-02f, 5.90210038e-05f, 3.52919213e-02f, -7.49926921e-03f, -1.93226635e-02f, 3.92676108e-02f,
  4.40973742e-03f, -2.16184333e-02f, 2.71139611e-02f, -3.51534560e-02f, 1.75730679e-02f, -3.94060984e-02f, 4.55302671e-02f, 2.81420909e-02f, 2.33233164e-04f, 6.37142509e-02f,
  2.49038823e-02f, -7.53006758e-03f, -3.37884799e-02f, 5.79536222e-02f, 1.00949146e-02f, -6.90909661e-03f, -2.86335591e-02f, -6.47463696e-03f, 1.74442083e-02f, 6.31879047e-02f,
  -1.73842758e-02f, 1.59206558e-02f, -3.11158672e-02f, 7.09556788e-03f, 1.67401670e-03f, -4.11128439e-02f, -2.35808156e-02f, 6.17650058e-03f, -8.69577937e-03f, 5.43837808e-02f,
  1.60925403e-01f, -2.06737239e-02f, 4.48619500e-02f, 6.22222153e-03f, -1.85248686e-03f, 7.22437277e-02f, 6.05814047e-02f, -2.03849301e-02f, -4.99797147e-03f, -4.93218824e-02f,
  -5.72620444e-02f, 2.75155213e-02f, -2.67438684e-03f, -1.87065694e-02f, -1.45973656e-02f, 2.62172464e-02f, -9.49428044e-03f, -1.66149493e-02f, -5.92367165e-03f, -2.08842177e-02f,
  -7.25973919e-02f, 9.44450777e-03f, 3.06732859e-02f, 1.97415892e-02f, 6.87408610e-04f, 2.38039177e-02f, -1.15695514e-03f, -2.09190231e-02f, -4.48293537e-02f, 9.85195674e-03f,
  5.17507553e-01f, 2.58406818e-01f, 3.70179325e-01f, 1.25760809e-01f, -1.03999346e-01f, -1.93741713e-02f, 1.45071104e-01f, -5.76207526e-02f, 1.32261202e-01f, -6.02468029e-02f,
  -1.05370805e-01f, 1.06874496e-01f, 2.51674742e-01f, -4.60138805e-02f, 2.75742915e-02f, 2.16193810e-01f, -9.85198542e-02f, -1.80572961e-02f, 9.14499536e-02f, 3.76965925e-02f,
  1.02338426e-01f, -1.71752706e-01f, 1.69886962e-01f, -2.20072329e-01f, 2.78700702e-02f, 2.57680975e-02f, -1.91527903e-01f, -1.78510211e-02f, -1.77231923e-01f, -8.50381702e-02f,
  -1.37731414e-02f, 4.65894118e-02f, 2.52966303e-02f, -6.84004799e-02f, -6.63357228e-02f, -4.20059785e-02f, -2.61953939e-02f, 3.61017585e-02f, 9.28233750e-03f, -2.90083047e-02f,
  3.23807611e-03f, -1.14936186e-02f, 2.94887414e-03f, 4.26042220e-03f, -2.23963242e-02f, 2.19406094e-03f, 2.56091319e-02f, 3.95242982e-02f, 6.59756884e-02f, 7.78234303e-02f,
  5.63461967e-02f, 4.14246460e-03f, -1.79967645e-03f, -4.08646502e-02f, 8.27611331e-03f, 3.74356583e-02f, -1.76542327e-02f, 3.98302712e-02f, -3.84786427e-02f, -3.53182591e-02f,
  -6.55789077e-02f, -3.73390131e-02f, 1.38428598e-03f, -9.92636941e-03f, -2.36566197e-02f, 1.19514586e-02f, -4.70708758e-02f, 3.75262019e-03f, 1.72418691e-02f, 2.93574426e-02f,
  -1.01869097e-02f, 1.57280434e-02f, -9.33101121e-03f, 2.70921458e-02f, -1.20798862e-02f, 2.12351196e-02f, -4.64929380e-02f, -2.06770608e-03f, 2.58270255e-03f, 6.21775165e-02f,
  1.49888627e-03f, 2.07866468e-02f, 1.80928805e-03f, -3.52781191e-02f, -1.64403301e-02f, 2.37298775e-02f, 2.34718826e-02f, 6.00234866e-02f, -2.53862073e-03f, -1.61126517e-02f,
  -2.16886461e-01f, -1.23977900e-01f, 1.07275890e-02f, 5.18615320e-02f, -2.36021988e-02f, -3.69625203e-02f, 1.17255829e-03f, -1.00694843e-01f, -3.39196697e-02f, -1.41102364e-02f,
  -4.48307544e-02f, -1.55464150e-02f, -6.05688989e-02f, 5.40701160e-03f, 4.57219481e-02f, 2.81365532e-02f, -1.33884773e-02f, -1.12681881e-01f, -1.12820238e-01f, -1.73315480e-02f,
  -7.73357153e-02f, -7.34104514e-02f, -6.01388477e-02f, -3.21758501e-02f, -2.25218292e-02f, -3.19437645e-02f, -5.94746843e-02f, -2.00994834e-02f, -4.15289328e-02f, 1.26693845e-02f,
  1.39737174e-01f, 2.51546562e-01f, -1.51553407e-01f, -9.20270234e-02f, -2.44870842e-01f, -1.69714451e-01f, -1.06068306e-01f, -1.48149058e-02f, -2.10713923e-01f, 1.48716703e-01f,
  1.02673717e-01f, 2.37406656e-01f, 1.21448971e-01f, 1.69804916e-01f, -2.40419775e-01f, -8.43114778e-03f, -5.13825789e-02f, 7.92614967e-02f, -1.27790973e-01f, 6.98334351e-02f,
  -5.10444418e-02f, -2.59340908e-02f, -2.68518385e-02f, -4.77518253e-02f, -3.20742908e-03f, -5.88025078e-02f, -4.14582230e-02f, -8.21913779e-02f, 6.20719902e-02f, -8.99929255e-02f,
  6.43637553e-02f, 1.20782398e-01f, 8.60807374e-02f, 2.79606618e-02f, 4.34063934e-02f, -2.67022289e-02f, 2.85336282e-02f, -1.08056709e-01f, -9.01800692e-02f, -1.10398652e-02f,
  3.16417287e-03f, -2.24863319e-03f, -4.81922040e-03f, -9.66982543e-02f, -2.38026772e-02f, 1.66342186e-03f, 2.45584287e-02f, 2.70811971e-02f, 7.51215499e-03f, -2.65040267e-02f,
  6.22649789e-02f, 5.00245281e-02f, 7.41200671e-02f, 4.31579119e-03f, 1.42004285e-02f, -6.32243603e-02f, 1.43182166e-02f, 3.48196551e-02f, 9.75698382e-02f, -6.22245949e-03f,
  -9.16603254e-04f, -2.68414710e-02f, 3.14295627e-02f, -7.38555845e-03f, 7.47229084e-02f, 7.46058375e-02f, 8.13875813e-03f, 3.38679031e-02f, -2.32621338e-02f, 4.65953127e-02f,
  7.19357515e-03f, -1.48688629e-02f, 6.40028939e-02f, -3.72456908e-02f, 6.79395534e-03f, 8.35911632e-02f, 4.22878154e-02f, -4.98265587e-02f, -3.01499702e-02f, 4.11879346e-02f,
  5.22834156e-03f, -5.88122495e-02f, -6.85941475e-03f, -8.61170590e-02f, -4.14217729e-03f, -3.67302187e-02f, 6.74996153e-02f, 3.01834587e-02f, -2.43734196e-02f, -2.56480239e-02f,
  8.61507505e-02f, -3.72708477e-02f, 1.49176680e-02f, 5.67307416e-03f, -4.15779166e-02f, 1.39105748e-02f, -6.80361167e-02f, 7.48091983e-03f, -5.06280027e-02f, 3.36690550e-03f,
  1.48432702e-03f, -6.79437164e-03f, -1.96033455e-02f, 1.49490172e-02f, 3.84704918e-02f, -4.83402237e-02f, -2.47625578e-02f, -1.59645528e-02f, 1.83037333e-02f, 4.92602997e-02f,
  1.60797238e-02f, -3.11405193e-02f, 3.24267633e-02f, 2.18537375e-02f, 5.61423367e-03f, 6.36161417e-02f, 6.95729861e-04f, 3.32860984e-02f, -8.79993439e-02f, 3.49563621e-02f,
  -5.68814993e-01f, 9.83272344e-02f, 1.79480761e-01f, -2.82330215e-01f, -1.31906033e-01f, -1.93897679e-01f, 3.82677317e-02f, -1.33596256e-01f, -2.94884413e-01f, -3.52487452e-02f,
  8.42112228e-02f, 1.75901279e-02f, 2.60152191e-01f, 8.38290155e-03f, -2.50663552e-02f, 1.99681193e-01f, -2.78613299e-01f, -1.18448809e-01f, -5.06580472e-02f, -9.99161303e-02f,
  -5.41031212e-02f, -7.44830444e-02f, 1.92787334e-01f, -8.24896097e-02f, -1.35909859e-02f, -7.33958036e-02f, 8.77306759e-02f, 2.53943533e-01f, -3.16275768e-02f, 1.61062628e-02f,
  1.22467980e-01f, -4.63897549e-02f, -2.44083330e-02f, 2.68056151e-02f, 4.56737801e-02f, -2.56203059e-02f, 3.68291289e-02f, 9.93354097e-02f, -2.81983614e-02f, -5.41692637e-02f,
  1.61592364e-02f, 7.18344450e-02f, -4.15212475e-02f, -6.39739400e-03f, -2.31322609e-02f, -4.45312597e-02f, -9.93792713e-02f, -7.83082470e-03f, -1.74971111e-02f, 6.45515844e-02f,
  -2.28882562e-02f, -1.29939651e-03f, 7.24342326e-03f, -6.24105148e-02f, 9.67823416e-02f, -2.56355684e-02f, 2.61103511e-02f, 5.21609113e-02f, -4.73414846e-02f, -9.82317105e-02f,
  -6.09467141e-02f, -7.01242909e-02f, 2.81900447e-02f, -1.95664540e-02f, -6.33808821e-02f, -4.09426577e-02f, -4.49158736e-02f, 4.44923379e-02f, -2.68213656e-02f, 4.36360054e-02f,
  -1.72049589e-02f, -6.37417659e-02f, 3.60566713e-02f, -1.57682355e-02f, -6.36583120e-02f, -2.62075327e-02f, -4.98153828e-03f, -1.23808691e-02f, -3.55140259e-03f, 4.54832874e-02f,
  1.20120430e-02f, -4.48141396e-02f, 9.02886987e-02f, -9.09562130e-03f, -3.76471668e-03f, 3.72433066e-02f, 1.25158122e-02f, 2.92523410e-02f, -5.39482851e-03f, -4.72658649e-02f,
  -4.85668927e-02f, -1.79848745e-01f, -9.71813686e-03f, -6.72453269e-02f, 1.08067943e-02f, -4.46618423e-02f, 8.95335712e-03f, -3.56714465e-02f, 2.89611984e-02f, 1.19887823e-02f,
  -1.46189574e-02f, -1.12980582e-01f, -1.43998396e-02f, 1.55523578e-02f, -4.39914502e-03f, -4.14033942e-02f, 4.72544692e-02f, -6.60389289e-02f, -4.47196774e-02f, 6.29952326e-02f,
  -2.45871898e-02f, -5.52207902e-02f, -6.07370809e-02f, -8.37130565e-03f, -7.04927444e-02f, 8.41529667e-02f, -6.01065829e-02f, -1.05188675e-02f, 1.20349862e-02f, 3.82312387e-02f,
  8.67936462e-02f, -7.90475607e-02f, -1.46279380e-01f, -2.52395477e-02f, -9.69241187e-02f, -1.23656392e-02f, -8.06523263e-02f, -9.83025879e-02f, -2.25378111e-01f, 6.05283082e-02f,
  9.78362635e-02f, -1.86560266e-02f, 1.23071536e-01f, 5.93269877e-02f, 2.11274792e-02f, -5.56460163e-03f, -6.57437146e-02f, -5.18824011e-02f, -3.55096883e-03f, 1.02276849e-02f,
  -7.67535344e-02f, 9.26754773e-02f, 4.48892154e-02f, 1.59294289e-02f, 3.04355118e-02f, -1.00484706e-01f, -2.35194061e-02f, -1.24057010e-02f, -6.92474619e-02f, -2.77530421e-02f,
  9.74043459e-02f, 1.18528344e-01f, 5.54239154e-02f, 2.97372993e-02f, 1.26453042e-02f, 8.77632424e-02f, -6.64568767e-02f, 1.05916876e-02f, 1.60707440e-02f, 2.15989929e-02f,
  2.83435266e-02f, 4.30705994e-02f, 4.29008678e-02f, 5.55709563e-02f, -3.07637583e-02f, -4.88342643e-02f, 2.17891857e-02f, -6.04635328e-02f, -3.75644527e-02f, 2.36265920e-02f,
  -8.79922211e-02f, -1.25899902e-02f, 3.73677798e-02f, -4.24462706e-02f, -4.20100428e-02f, 6.24565000e-04f, 4.07218328e-03f, -5.66379651e-02f, -4.11260389e-02f, -3.72585393e-02f,
  1.13172876e-02f, -4.42839786e-02f, 5.05421050e-02f, -3.77982408e-02f, -1.07722012e-02f, 4.67242897e-02f, -3.02043241e-02f, 4.72191907e-02f, -4.42852341e-02f, 8.00382905e-03f,
  -5.34389988e-02f, -7.72069842e-02f, -6.44979998e-02f, -8.09336603e-02f, 4.23905775e-02f, -8.11682642e-02f, -5.56851365e-03f, 4.54803184e-02f, 5.32210059e-03f, -3.05623114e-02f,
  1.15390338e-01f, 6.23810738e-02f, -1.21362200e-02f, 5.59321865e-02f, -5.57550900e-02f, -5.79876192e-02f, -2.93399822e-02f, 4.86426912e-02f, -1.67234093e-02f, 7.90472329e-02f,
  -2.54138540e-02f, 3.61122191e-02f, -1.35284988e-02f, 4.69925664e-02f, 6.13379143e-02f, -6.05388544e-02f, 4.01534997e-02f, 3.42281051e-02f, -9.00326520e-02f, -2.00751424e-02f,
  3.32356654e-02f, -2.96505243e-02f, 9.24768276e-04f, -6.14584610e-02f, -1.21244676e-01f, -3.72544117e-02f, -5.30898310e-02f, 6.57156706e-02f, 2.44347122e-03f, 4.95736627e-03f,
  1.19930446e-01f, 4.66538081e-03f, 2.62804646e-02f, 8.57045427e-02f, 5.72998682e-03f, 2.89636049e-02f, -4.04201075e-03f, 1.90481939e-03f, 9.28279664e-03f, 1.35019068e-02f,
  5.95974624e-01f, -1.88743159e-01f, 3.84426296e-01f, -6.98611066e-02f, 1.58495784e-01f, -1.30764442e-02f, 9.13710892e-02f, 4.65582348e-02f, 1.16203733e-01f, -4.10119034e-02f,
  6.82729706e-02f, 4.39707860e-02f, 3.52546722e-02f, 2.14978885e-02f, 1.15741372e-01f, -1.13791168e-01f, 3.27655859e-02f, -1.57511067e-02f, -8.50825459e-02f, -1.52804866e-01f,
  3.22200283e-02f, -1.70540243e-01f, 1.49482682e-01f, -9.65534523e-02f, 1.02233015e-01f, 4.98814024e-02f, 4.05985117e-03f, -6.80170208e-03f, 4.07252796e-02f, 6.20622337e-02f,
  1.27704412e-01f, 5.47999814e-02f, 1.18364714e-01f, -1.55516090e-02f, 7.94356540e-02f, 7.53701329e-02f, 1.24638546e-02f, 6.97368383e-02f, 1.19886072e-02f, 6.43146113e-02f,
  -4.02934216e-02f, -2.67053209e-02f, 2.38607395e-02f, 2.49895323e-02f, -6.09398112e-02f, 6.06578887e-02f, -2.62284335e-02f, 2.90174270e-04f, -7.18831085e-03f, -3.73839810e-02f,
  -4.92726676e-02f, -5.71440607e-02f, -5.62906358e-03f, -2.54259910e-02f, 6.19180091e-02f, 6.55375049e-03f, 3.85799399e-03f, 2.54560467e-02f, 2.17757304e-03f, 1.90399084e-02f,
  2.96923183e-02f, 5.16642705e-02f, 7.81101780e-03f, 3.15046264e-03f, 2.32680445e-03f, 8.45575985e-03f, 7.57497270e-04f, 6.60287263e-03f, 2.43536029e-02f, -1.42830973e-02f,
  3.60005014e-02f, -1.52137512e-02f, -1.43206660e-02f, -5.77825159e-02f, -1.43041601e-02f, -2.00228952e-02f, 2.05066558e-02f, -4.26658690e-02f, -1.48882270e-02f, -4.49934835e-03f,
  -5.02713546e-02f, -1.76376794e-02f, 4.54524271e-02f, 2.15391330e-02f, 3.72305736e-02f, 1.61409285e-02f, -3.52517366e-02f, -2.02424470e-02f, 2.76112016e-02f, -2.58460315e-03f,
  -1.22878365e-01f, -1.49877101e-01f, 2.46836655e-02f, -4.62548696e-02f, -5.85050099e-02f, -3.33187468e-02f, 2.89179524e-03f, 5.38532389e-03f, -6.40008301e-02f, -5.98077849e-03f,
  -2.77056694e-02f, 1.52948238e-02f, -1.86274126e-02f, 2.93306671e-02f, -2.72275545e-02f, -5.65797053e-02f, -5.27270511e-02f, -4.19903100e-02f, 5.03735356e-02f, 1.63239669e-02f,
  -2.37693414e-02f, -1.71258450e-02f, 2.01313775e-02f, 4.94229607e-02f, -3.80701423e-02f, 3.59146670e-02f, 1.37532810e-02f, -1.30098760e-02f, -3.61191072e-02f, -1.29958447e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.15208760e-01f, -1.50525510e-01f, -1.79525651e-02f, 1.49803564e-01f, -1.29875362e-01f, -3.73538494e-01f, -3.20519865e-01f, 2.15735622e-02f, -2.11488038e-01f, -1.75879553e-01f,
  1.25284076e-01f, -1.87292337e-01f, -1.67815492e-01f, 2.65412301e-01f, 4.45585608e-01f, -1.52554423e-01f, 2.92350382e-01f, -7.98034444e-02f, -1.09087482e-01f, 1.02398105e-01f,
  1.35810941e-01f, 1.99703127e-01f, 1.47389233e-01f, 2.57674038e-01f, -1.30929440e-01f, 1.81529671e-02f, 2.66847253e-01f, -3.30886468e-02f, 3.09942722e-01f, 1.69309929e-01f,
  -3.86676006e-02f, -6.90647066e-02f, 1.14601655e-02f, 3.02768610e-02f, -6.36275038e-02f, -5.93694411e-02f, -1.29551113e-01f, 2.55558956e-02f, -1.21974964e-02f, 4.43819724e-02f,
  -6.55641183e-02f, 8.84134620e-02f, 8.67876634e-02f, 2.60230657e-02f, -1.54313566e-02f, 8.45974311e-02f, -8.34920444e-03f, -8.23461488e-02f, 1.69093473e-04f, 3.53380367e-02f,
  -1.05849393e-01f, -6.25519902e-02f, 1.20263584e-02f, 2.98777558e-02f, -7.15491222e-03f, 6.95881993e-03f, -1.02940343e-01f, -8.54692608e-03f, -4.09983331e-03f, 9.17834137e-03f,
  2.44484581e-02f, -1.31904036e-01f, -9.80090816e-03f, 3.74683663e-02f, -2.72055734e-02f, -2.89797224e-03f, -3.07642184e-02f, 3.55004407e-02f, 6.83138594e-02f, -1.34634711e-02f,
  5.80240507e-03f, 4.32214979e-03f, 1.02749556e-01f, -6.99387342e-02f, -5.72254742e-03f, -3.01312096e-02f, -9.63436067e-02f, 1.42145544e-01f, 1.47275757e-02f, -1.66462418e-02f,
  -2.15229709e-02f, -3.30110006e-02f, 2.34793201e-02f, -9.69862714e-02f, 7.02884644e-02f, -2.17504930e-02f, 7.73166791e-02f, -5.35739586e-04f, 3.56840319e-03f, -7.32780769e-02f,
  1.78550053e-02f, 1.71012074e-01f, 3.12936716e-02f, -3.50222603e-04f, -5.93026206e-02f, 3.96153610e-03f, -1.64446130e-03f, 1.20971752e-02f, 4.37733941e-02f, -4.66814637e-02f,
  4.31188941e-02f, -4.20901701e-02f, -6.84271008e-02f, 6.06779084e-02f, 4.98621836e-02f, -2.84642074e-03f, 3.22666392e-02f, -8.82762298e-02f, 4.73275147e-02f, 1.12609424e-01f,
  1.01424251e-02f, -2.88463216e-02f, 6.85922662e-03f, -7.25765079e-02f, 5.13286935e-03f, -1.56367809e-01f, 1.52952662e-02f, -1.25560015e-02f, 1.01085249e-02f, -7.96194281e-03f,
  -6.67159557e-02f, -1.60715729e-01f, -1.03789903e-01f, 1.08925343e-01f, 7.86048546e-02f, 5.88720851e-02f, 2.94286702e-02f, 3.97145525e-02f, -6.36656955e-02f, 9.33741871e-03f,
  4.24507149e-02f, -1.20015427e-01f, -1.75416633e-01f, 1.08799577e-01f, -4.07109112e-02f, -8.69041160e-02f, 1.01253651e-02f, 3.68100069e-02f, -2.69307988e-03f, 7.05257664e-03f,
  -9.90423188e-03f, 1.67055726e-01f, -2.84028742e-02f, 3.48539315e-02f, 7.67734423e-02f, -6.66862279e-02f, 1.48631111e-01f, -7.17447326e-03f, 4.22115736e-02f, -6.61183372e-02f,
  1.28985659e-04f, 3.43869925e-02f, -2.35560331e-02f, -2.44452506e-02f, -9.60524678e-02f, -4.61129583e-02f, 1.30201643e-02f, 5.76844737e-02f, -9.17999912e-03f, 2.47158818e-02f,
  5.86965680e-02f, 4.32063416e-02f, 4.11892571e-02f, -2.02887207e-02f, -9.37887877e-02f, 3.98099609e-02f, 2.65846997e-02f, -1.07785359e-01f, -7.65719451e-03f, -2.23062336e-02f,
  -3.62607539e-02f, -6.53675273e-02f, -3.14108729e-02f, -5.95684312e-02f, -6.23152545e-03f, 9.12037417e-02f, 2.26038899e-02f, -7.63383731e-02f, 7.94672668e-02f, 1.08565010e-01f,
  1.95216723e-02f, 5.74817285e-02f, -2.24137846e-02f, 6.84734359e-02f, -2.70967949e-02f, -6.39296770e-02f, -6.74486980e-02f, 5.17992862e-02f, 1.26565248e-02f, 1.64529700e-02f,
  4.41696756e-02f, -6.90671951e-02f, -3.10715009e-02f, 2.35459600e-02f, -8.45023990e-02f, -1.99476667e-02f, -1.64355058e-02f, -5.92359267e-02f, 1.05461076e-01f, -7.99353197e-02f,
  -1.05143175e-01f, 8.88343062e-03f, -3.25846896e-02f, 3.09253708e-02f, -5.71846813e-02f, 6.16510995e-02f, 4.19163443e-02f, 7.38208368e-02f, 3.01378742e-02f, 6.33673444e-02f,
  -4.00367379e-02f, 3.58806811e-02f, -8.97913948e-02f, 1.70213804e-02f, 7.42006116e-03f, 2.92446949e-02f, -7.75170997e-02f, -2.51547061e-02f, -4.10975665e-02f, -2.31605954e-02f,
  -6.25287071e-02f, -2.84181982e-02f, 2.95600630e-02f, -1.03301033e-02f, 1.74163356e-02f, 4.02530516e-03f, 5.44504561e-02f, -5.84651455e-02f, -7.65268505e-02f, 4.31845263e-02f,
  4.46366472e-03f, -1.16828583e-01f, -4.68321703e-02f, 6.69092238e-02f, -2.74983533e-02f, -4.17133123e-02f, -3.70624438e-02f, 8.62920061e-02f, -2.83202692e-03f, -7.49244243e-02f,
  -2.28174835e-01f, -7.73399994e-02f, -7.68613964e-02f, -1.29213318e-01f, -4.04884620e-03f, -3.90117206e-02f, 4.72822506e-03f, 5.73270489e-03f, 1.48743913e-02f, 9.70590785e-02f,
  4.28073518e-02f, -1.56022878e-02f, 1.01465426e-01f, 3.77522036e-02f, -1.41050279e-01f, 2.25514290e-03f, 4.81857825e-03f, 1.95657648e-03f, -9.09799114e-02f, 3.03205345e-02f,
  -1.37887016e-01f, 6.03819825e-02f, -7.31776189e-03f, -1.11300768e-02f, -4.82581109e-02f, 7.94288591e-02f, 5.78901209e-02f, 6.25619898e-03f, 7.82479569e-02f, -1.11016855e-01f,
  -2.49354430e-02f, -3.55662443e-02f, -5.57279550e-02f, -7.80538768e-02f, -4.74886708e-02f, 5.89339398e-02f, -1.92658510e-03f, 4.92533371e-02f, 5.09097753e-03f, 3.53497863e-02f,
  -2.01591593e-03f, -4.55716960e-02f, 5.48563413e-02f, 6.58024698e-02f, 1.82301383e-02f, 5.20847961e-02f, -1.62003487e-02f, -9.08327522e-04f, 8.05225521e-02f, -6.89682970e-03f,
  5.85921519e-02f, 2.05516852e-02f, -4.97378036e-02f, -3.21647301e-02f, -4.83472794e-02f, -5.17693460e-02f, 2.35533845e-02f, -5.51261641e-02f, 4.29668278e-02f, 2.20419727e-02f,
  -1.01566762e-02f, 6.52771490e-03f, -6.26088232e-02f, -8.79525859e-03f, -6.01621196e-02f, -1.02763459e-01f, 1.08703651e-01f, -9.49619431e-03f, 9.24450979e-02f, 7.56392851e-02f,
  -2.38656905e-02f, -3.26211713e-02f, 1.41983796e-02f, 3.23074460e-02f, 2.42253188e-02f, -1.71079207e-02f, 5.79720512e-02f, -4.68855090e-02f, -2.19977610e-02f, 9.24940314e-03f,
  -5.95874786e-02f, 2.38280700e-04f, 2.02350542e-02f, -4.77855951e-02f, 6.04282767e-02f, -4.29835878e-02f, -3.01933731e-03f, -4.66792844e-02f, 3.40203345e-02f, 1.83840487e-02f,
  -5.10193668e-02f, 1.52508086e-02f, 3.87300849e-02f, -9.51722562e-02f, 1.94195416e-02f, -2.13426910e-02f, -6.76991493e-02f, -8.79452154e-02f, -3.42884772e-02f, 7.14891171e-03f,
  5.81675768e-02f, -3.22499834e-02f, -4.86380942e-02f, -1.62789561e-02f, -6.34019915e-03f, 5.64607307e-02f, -1.73077956e-02f, -1.31601198e-02f, 1.61741097e-02f, 4.17338833e-02f,
  -7.09257871e-02f, -9.75637361e-02f, 6.16498962e-02f, 1.75567847e-02f, -1.78919509e-02f, 2.34031547e-02f, 2.37336326e-02f, 4.46808077e-02f, 3.16399634e-02f, -3.75741012e-02f,
  1.08599558e-01f, -7.60470554e-02f, -7.82628283e-02f, -4.76852581e-02f, 7.97813833e-02f, 3.92876342e-02f, 2.01138165e-02f, -8.14361218e-03f, -5.23206182e-02f, -3.57999168e-02f,
  -1.47739053e-02f, -1.05748493e-02f, -5.20212352e-02f, -9.75549370e-02f, 2.98918821e-02f, 7.08273202e-02f, -5.07277511e-02f, 5.86235411e-02f, -3.21430620e-03f, 1.15848938e-03f,
  3.89747582e-02f, -5.91571582e-03f, -7.68381432e-02f, 6.10728487e-02f, 6.27056360e-02f, -2.23458074e-02f, -1.03551727e-02f, 9.44647864e-02f, -1.18399501e-01f, -5.92507944e-02f,
  3.59189250e-02f, -8.45280811e-02f, -8.26827511e-02f, 5.73753305e-02f, 3.79061028e-02f, 6.13001511e-02f, 1.41150755e-04f, -2.47916244e-02f, 1.86589751e-02f, -1.05103433e-01f,
  2.99227554e-02f, -7.33979105e-04f, -1.67179368e-02f, -9.66281816e-02f, -2.70812102e-02f, -1.12261865e-02f, -5.42580597e-02f, -3.02500185e-03f, -4.54761684e-02f, 2.04620194e-02f,
  8.31655860e-02f, 4.63253539e-03f, 2.26517003e-02f, 5.20360991e-02f, 6.99026510e-02f, -5.45919798e-02f, 2.81844120e-02f, 2.58741230e-02f, 8.00640136e-02f, -1.19937425e-02f,
  -6.78295195e-02f, -5.94175123e-02f, 9.00364965e-02f, -3.05661988e-02f, 3.60610634e-02f, -5.69867231e-02f, -7.15060532e-02f, 3.53833698e-02f, -8.16398859e-03f, 5.09994626e-02f,
  -4.77442853e-02f, -8.31711441e-02f, 7.18766376e-02f, 1.27436109e-02f, -6.70788810e-02f, 2.75419280e-03f, 5.07710837e-02f, -6.68275505e-02f, 6.89516738e-02f, -5.71128242e-02f,
  -4.73756120e-02f, 3.48034911e-02f, 1.75051875e-02f, -2.13941056e-02f, -3.59314159e-02f, -6.05616048e-02f, 2.61069071e-02f, -4.00312617e-02f, 2.89099291e-02f, 3.97201069e-02f,
  5.48111610e-02f, -2.30174530e-02f, 1.76941082e-02f, -5.21373302e-02f, -7.61345997e-02f, -3.02133150e-02f, -3.49955410e-02f, 3.22116830e-04f, 7.51380920e-02f, 9.76808928e-03f,
  -6.40261844e-02f, -3.85002606e-02f, -9.56645310e-02f, 4.18523140e-02f, 7.13070855e-02f, 5.15865907e-02f, 5.11293598e-02f, -6.39420822e-02f, -6.72505647e-02f, -2.39556730e-02f,
  4.34663482e-02f, 4.06465456e-02f, 8.77745152e-02f, -1.25979707e-02f, 6.07665554e-02f, 5.11279888e-02f, -7.85879325e-03f, 1.29324263e-02f, 7.43512735e-02f, -6.56566694e-02f,
  5.65282851e-02f, -1.79865565e-02f, -2.31764521e-02f, -5.89876510e-02f, -2.12676525e-01f, -2.61585861e-01f, -2.28828609e-01f, -1.54005274e-01f, 4.42479067e-02f, 5.50134033e-02f,
  -2.14599445e-02f, 1.63304240e-01f, -3.19720991e-02f, 5.23234159e-02f, -7.35951737e-02f, 1.11961484e-01f, -3.07802688e-02f, 6.48254529e-02f, -1.35287840e-03f, 3.56952026e-02f,
  -2.16082688e-02f, 6.59240633e-02f, 9.18373540e-02f, -6.93551898e-02f, 6.12868257e-02f, 5.78987226e-02f, 1.21495418e-01f, -1.53620496e-01f, 4.30913009e-02f, -4.89966162e-02f,
  1.27624720e-01f, 1.78532913e-01f, 1.25234976e-01f, 9.76389125e-02f, -2.65551321e-02f, 5.51091507e-02f, 1.40334098e-02f, -1.42087527e-02f, -3.95432748e-02f, 4.10992280e-02f,
  -1.71186570e-02f, -5.47314584e-02f, 7.30166286e-02f, 1.57663859e-02f, -6.79839076e-03f, -1.21092863e-01f, 2.45226230e-02f, -6.59749210e-02f, 3.32794599e-02f, 9.31712762e-02f,
  1.44529743e-02f, 2.24250443e-02f, -6.44212142e-02f, -1.69349387e-02f, -2.83810962e-02f, -5.82235940e-02f, -1.28921969e-02f, 1.19762264e-01f, -1.32766543e-02f, -2.86201946e-02f,
  1.15034714e-01f, -6.85074851e-02f, 1.94530971e-02f, 4.60449420e-02f, 4.03101183e-02f, -4.61863987e-02f, 9.11112428e-02f, -4.55857329e-02f, -9.22030956e-02f, -2.70197317e-02f,
  5.51478043e-02f, -1.95011646e-02f, -3.93346176e-02f, 2.35111900e-02f, -1.62090901e-02f, 1.00541934e-01f, -1.16081322e-02f, -4.21785899e-02f, -8.31224024e-04f, -6.99371994e-02f,
  6.24995194e-02f, -4.67686448e-03f, 2.17809313e-04f, -2.51044650e-02f, -6.52409643e-02f, 1.86603367e-02f, 1.85723808e-02f, -1.73735619e-02f, 6.00887462e-02f, -4.12825169e-03f,
  -3.61343920e-02f, 3.38539705e-02f, 3.17530222e-02f, 8.96270201e-02f, 7.68346563e-02f, 6.51847124e-02f, 2.97112651e-02f, 1.87234557e-03f, -3.30349319e-02f, -9.07334089e-02f,
  1.28343850e-02f, 4.41780454e-03f, 2.08538696e-02f, -5.20985276e-02f, -2.59914827e-02f, -7.81982392e-02f, -5.31484559e-02f, -1.01653009e-03f, -9.54903215e-02f, 9.45655257e-02f,
  3.93779725e-02f, 1.44148583e-03f, 2.35617142e-02f, 2.84555405e-02f, 2.33917963e-02f, 7.65796378e-02f, 3.18467580e-02f, 3.05828750e-02f, 5.75838201e-02f, 4.83164638e-02f,
  1.02933735e-01f, 3.15328427e-02f, 2.53682762e-01f, 8.03208128e-02f, -2.01946616e-01f, -9.21239704e-03f, 1.44643066e-02f, -5.66289276e-02f, -6.74660504e-02f, 9.02316347e-03f,
  -7.27769732e-02f, 4.58736159e-02f, -6.86535537e-02f, 9.00655165e-02f, -4.98694368e-02f, 6.44523054e-02f, 6.66638091e-02f, 1.11191787e-01f, 5.52657098e-02f, -4.12996709e-02f,
  5.16855344e-02f, -1.49928212e-01f, 1.93279535e-02f, -1.51021421e-01f, 5.03268316e-02f, 2.40731351e-02f, -9.43103209e-02f, 2.74812151e-02f, -1.97706521e-02f, -1.07669055e-01f,
  1.43501712e-02f, -6.32321984e-02f, 6.08061105e-02f, 1.13501586e-01f, 6.42433241e-02f, 1.66913448e-03f, 2.98534110e-02f, -1.29757673e-01f, 1.07970625e-01f, -3.70329432e-02f,
  8.29921439e-02f, 8.27374961e-03f, -8.34875107e-02f, -8.47012997e-02f, -5.79854771e-02f, 4.43646275e-02f, -4.22093049e-02f, 8.02875236e-02f, 1.04577549e-01f, -3.87417786e-02f,
  6.19528927e-02f, 4.45122980e-02f, 7.83449486e-02f, 1.77645721e-02f, 1.53179895e-02f, -1.09034334e-03f, 6.48530424e-02f, 2.70803832e-02f, 1.02014942e-02f, -8.09151330e-04f,
  -1.27359675e-02f, -1.49443686e-01f, -7.95284882e-02f, -2.27798875e-02f, 7.23521188e-02f, -5.21897413e-02f, 4.40893844e-02f, 8.94002430e-03f, 2.24340353e-02f, -1.06019489e-02f,
  2.23544184e-02f, 7.69403875e-02f, -2.76845712e-02f, 6.26531169e-02f, -5.25564067e-02f, 4.35424224e-03f, -2.90508959e-02f, 1.02572486e-01f, 1.08041793e-01f, 5.20640202e-02f,
  -1.41781941e-02f, -9.29634124e-02f, -4.02601548e-02f, 7.33379051e-02f, -2.20029857e-02f, 7.08200783e-02f, -8.33307058e-02f, 2.81172004e-02f, 4.28823642e-02f, -7.10141659e-02f,
  9.17905048e-02f, -1.08219735e-01f, 5.56764901e-02f, 4.72549461e-02f, 7.49797523e-02f, -1.18006635e-02f, 7.18541592e-02f, 2.95413379e-02f, 6.01267330e-02f, 2.78114527e-02f,
  -5.52434176e-02f, -5.85348271e-02f, 4.75566685e-02f, -5.84578561e-03f, -7.24339113e-02f, -4.51312996e-02f, -8.95471796e-02f, 2.36487463e-02f, -4.06189589e-03f, -9.48476195e-02f,
  -1.24293827e-02f, 3.53282355e-02f, 7.46262223e-02f, -6.59998804e-02f, 2.90842224e-02f, 4.42513339e-02f, 7.72560984e-02f, -4.74400967e-02f, -2.78923139e-02f, -3.45225707e-02f,
  1.81321099e-01f, 4.11412179e-01f, 2.39399299e-01f, 2.10249543e-01f, -1.20846964e-01f, -3.58172983e-01f, -2.51348108e-01f, 1.50225461e-01f, 6.86341375e-02f, -4.90891095e-03f,
  -3.55495997e-02f, 1.34149715e-01f, 4.34387363e-02f, 1.77593663e-01f, 5.30461259e-02f, -1.06625080e-01f, 3.01206787e-03f, -5.68874693e-03f, 1.20823653e-02f, 8.98827240e-02f,
  5.09547330e-02f, 3.17326710e-02f, 2.66901374e-01f, 1.77332219e-02f, 9.33828205e-02f, 2.03737572e-01f, 1.42419204e-01f, -9.47092008e-03f, 1.81289464e-01f, -1.16932832e-01f,
  -1.61782548e-01f, 9.64557752e-02f, 4.29696329e-02f, -1.27486363e-01f, -6.50762115e-03f, -1.10001422e-01f, -3.21420957e-03f, -4.23481725e-02f, 3.58487177e-03f, -5.26688360e-02f,
  8.95079225e-02f, -7.26104854e-03f, 8.48400965e-02f, -5.75962849e-02f, -8.34038779e-02f, -6.53029606e-03f, 1.09571569e-01f, 2.36991346e-02f, -4.67772633e-02f, 3.23948599e-02f,
  1.33701116e-01f, 6.87808916e-02f, -8.76166523e-02f, -3.21850134e-03f, 8.14832672e-02f, -4.22990210e-02f, -4.84599397e-02f, 2.48162299e-02f, 9.24406424e-02f, 6.03516325e-02f,
  6.22203089e-02f, -3.86543572e-02f, -5.94008379e-02f, 7.00426176e-02f, -9.11992788e-03f, -2.63250642e-03f, -1.71064716e-02f, -3.86656635e-02f, 4.16016299e-03f, -2.53633652e-02f,
  -1.25667965e-02f, 7.15038925e-02f, 4.45860496e-04f, -8.17850605e-03f, 6.00884063e-03f, -8.54196250e-02f, 3.46664302e-02f, -1.27837777e-01f, -6.51607364e-02f, 1.20576039e-01f,
  -1.98777132e-02f, -1.58793963e-02f, -7.39914104e-02f, 6.37205839e-02f, -6.67550415e-02f, -5.35505228e-02f, 4.47772304e-03f, -1.49713606e-02f, 3.85061316e-02f, -7.49803032e-04f,
  -9.47440118e-02f, 1.91666797e-01f, -6.40818328e-02f, -1.01580195e-01f, 8.58417619e-03f, 7.49131516e-02f, -1.62949525e-02f, 6.23441003e-02f, 6.52568713e-02f, -3.76332477e-02f,
  1.42477686e-02f, -3.21510173e-02f, -7.98567906e-02f, 2.65484490e-02f, 5.22702374e-02f, 2.49255802e-02f, 5.15787043e-02f, 1.26937684e-02f, 8.61067846e-02f, 9.42561701e-02f,
  9.10552815e-02f, 3.28084715e-02f, 5.33454567e-02f, 4.22033928e-02f, 5.60273789e-02f, 2.15382166e-02f, 2.80597825e-02f, -1.63293432e-03f, -1.22152790e-02f, -4.90879221e-03f,
  9.95144174e-02f, 1.09960876e-01f, -9.35737342e-02f, 2.29660403e-02f, -5.15186898e-02f, -6.75250888e-02f, 6.34966418e-02f, 7.79149830e-02f, 1.17319211e-01f, 2.78684567e-03f,
  1.22038320e-01f, -2.84554958e-02f, -6.73369020e-02f, 2.90276315e-02f, 6.31903764e-03f, 7.49719888e-02f, 8.82524103e-02f, 9.36083421e-02f, 1.54680386e-02f, 1.12295158e-01f,
  7.47798905e-02f, 5.19701317e-02f, -3.78417447e-02f, -1.00250110e-01f, 7.76936114e-02f, -4.64495458e-02f, 1.11497454e-01f, -1.07304692e-01f, 4.98047657e-02f, -3.18800807e-02f,
  -1.90142468e-02f, -8.58499017e-03f, 7.34349638e-02f, -5.75839616e-02f, -5.78329526e-02f, -7.09526092e-02f, 3.24089415e-02f, 2.71837879e-02f, -3.77833880e-02f, -1.88675914e-02f,
  -3.76346186e-02f, -5.88024035e-02f, 5.44220097e-02f, -4.67109606e-02f, 5.85459247e-02f, 7.17043206e-02f, -1.70733090e-02f, -2.12098919e-02f, 3.61486003e-02f, 7.94756785e-02f,
  -2.34374739e-02f, -6.77458709e-03f, 3.39369755e-03f, 1.91678368e-02f, 4.58282828e-02f, 5.39947450e-02f, -1.82647388e-02f, 1.78098138e-02f, -2.52233446e-02f, 3.46646062e-03f,
  -5.31688407e-02f, 5.38379662e-02f, 4.68857214e-02f, -5.15602790e-02f, -8.31242725e-02f, 4.09996435e-02f, -1.27029764e-02f, 3.94849814e-02f, 4.58434671e-02f, 7.58567778e-03f,
  2.65468564e-03f, -2.77365022e-03f, -6.92219138e-02f, -2.14643427e-03f, 1.06341556e-01f, 5.73741682e-02f, 5.29671237e-02f, -6.72507957e-02f, -1.17290933e-02f, 5.50029334e-03f,
  4.32897806e-02f, 2.82385089e-02f, 8.71782228e-02f, 4.92866412e-02f, 5.41561982e-03f, -4.69986275e-02f, 1.63504984e-02f, -1.37565881e-02f, -2.82106604e-02f, 5.38610294e-02f,
  -1.00865839e-02f, 1.34273216e-01f, -6.07766248e-02f, 1.23655414e-02f, 5.60632758e-02f, 2.17578281e-03f, 2.42206100e-02f, 3.18337157e-02f, -7.21021369e-02f, 4.52983007e-02f,
  7.18424469e-02f, -5.78897335e-02f, 9.06026959e-02f, -3.07882316e-02f, -1.00847438e-01f, 4.48662564e-02f, 9.97198448e-02f, 8.37232743e-04f, 5.63025400e-02f, -7.58560523e-02f,
  8.34089369e-02f, -2.58409772e-02f, -9.75491777e-02f, -4.05296050e-02f, -6.65920153e-02f, 2.49512438e-02f, 5.22456542e-02f, -4.34243791e-02f, 8.42985958e-02f, -3.19129191e-02f,
  -8.51827413e-02f, 2.33930051e-02f, 7.23021338e-03f, 1.42239332e-01f, -8.70752484e-02f, -3.13770443e-01f, -2.72783726e-01f, 1.81568023e-02f, -1.68818116e-01f, -1.99903116e-01f,
  -6.12768605e-02f, 9.17491391e-02f, -8.42144266e-02f, 8.08258802e-02f, 7.16835782e-02f, -8.26654863e-03f, 9.49649215e-02f, 1.28037229e-01f, 1.34350583e-01f, 1.50991216e-01f,
  1.75723553e-01f, 3.26864794e-02f, 3.07619929e-01f, 1.79260820e-01f, 1.16918288e-01f, 1.27163693e-01f, 1.03654757e-01f, 1.36375325e-02f, 1.79154664e-01f, 1.43404096e-01f,
  -1.59667820e-01f, 3.77371609e-02f, -2.64284178e-03f, -1.17261913e-02f, -3.68359834e-02f, -4.76469994e-02f, -4.38064598e-02f, -4.03773002e-02f, 2.56842580e-02f, -2.57584583e-02f,
  2.38070413e-02f, 1.69645401e-03f, -5.69250993e-02f, -1.02416612e-01f, 2.83730850e-02f, 6.03918135e-02f, -4.48385701e-02f, 5.47972731e-02f, 8.69795829e-02f, 2.72376984e-02f,
  -1.68474764e-03f, 1.77912209e-02f, -6.32075220e-02f, 3.81838642e-02f, 2.73318328e-02f, -2.52548587e-02f, 2.74024494e-02f, 3.79282162e-02f, -1.81590058e-02f, 5.54645322e-02f,
  -4.47725430e-02f, 4.72333245e-02f, 5.07089198e-02f, -1.44946640e-02f, 1.37903010e-02f, -4.89078574e-02f, 6.25358075e-02f, 6.12447113e-02f, -4.53316383e-02f, 8.74078926e-03f,
  -5.49044646e-03f, 4.59218174e-02f, -3.45459133e-02f, 4.42631543e-03f, 7.13400822e-03f, 6.79560285e-03f, 2.96899173e-02f, 2.68000644e-02f, 1.10855214e-02f, -2.85211876e-02f,
  -1.02415755e-01f, 3.04541793e-02f, -9.72337089e-03f, 5.79649471e-02f, -6.96161389e-02f, 3.16924788e-02f, -7.40497978e-03f, -8.79798178e-03f, 5.46926707e-02f, 1.62882488e-02f,
  -5.89808002e-02f, 7.57307485e-02f, -1.17858499e-01f, -7.00033782e-03f, 4.08913903e-02f, -4.04084101e-02f, 2.58070161e-03f, -5.13319261e-02f, 4.62926812e-02f, 1.00363053e-01f,
  -9.08977911e-02f, -2.23986711e-02f, -1.46859482e-01f, -5.21211177e-02f, 1.30016739e-02f, -3.67318168e-02f, -1.14340680e-02f, 1.69243608e-02f, -7.68459365e-02f, 4.86660823e-02f,
  -4.31080647e-02f, -5.00236228e-02f, 4.05432768e-02f, 1.31790647e-02f, -1.91643219e-02f, -1.56783760e-02f, 1.46318637e-02f, -6.90259263e-02f, 6.97242022e-02f, 1.27217472e-02f,
  -4.38722409e-02f, 1.17396511e-01f, 7.04900622e-02f, 1.10527642e-01f, 4.35293699e-03f, 1.39434159e-01f, 1.61445200e-01f, 1.54886231e-01f, 2.59361267e-01f, 1.12266466e-01f,
  3.71013395e-03f, 4.81514037e-02f, -8.29275995e-02f, 1.64280042e-01f, 8.02156329e-02f, 4.50865030e-02f, 1.85472071e-01f, 1.25316799e-01f, 8.51248652e-02f, 5.42429239e-02f,
  -1.70537215e-02f, 1.31721333e-01f, -3.64676416e-02f, -8.83540213e-02f, -2.03485731e-02f, -1.42190278e-01f, -5.47603816e-02f, -6.26567798e-03f, -3.84718329e-02f, 3.28691764e-04f,
  2.47470811e-02f, 2.94507830e-03f, 4.52695973e-02f, -2.96255350e-02f, 8.85865986e-02f, -4.17739153e-02f, -4.98231351e-02f, -6.56389371e-02f, -5.21330610e-02f, -4.66886275e-02f,
  5.16107269e-02f, 2.86705662e-02f, 3.67420949e-02f, 3.95675115e-02f, 2.25505102e-02f, -6.83676377e-02f, 2.42114533e-02f, -6.56278357e-02f, 1.18439589e-02f, -7.22109526e-02f,
  -6.59008920e-02f, 1.01784309e-02f, -5.88001944e-02f, 9.13461670e-02f, 5.92187457e-02f, 3.41619141e-02f, 7.54361227e-02f, -3.54443640e-02f, -4.33192924e-02f, 3.19561064e-02f,
  4.38170917e-02f, -2.96222102e-02f, -3.35720042e-03f, -2.60893293e-02f, 1.64384898e-02f, -2.02741642e-02f, -1.02948900e-02f, -1.53800976e-02f, -3.62448134e-02f, 2.84322668e-02f,
  3.59129682e-02f, -1.50721110e-02f, 4.91439663e-02f, -3.96094210e-02f, -3.35147828e-02f, -4.28934209e-02f, 6.52375296e-02f, 5.30644432e-02f, -8.12497269e-03f, -5.35680018e-02f,
  4.30192472e-03f, 1.24797728e-02f, -1.10041179e-01f, 2.50398088e-02f, -6.29278198e-02f, -3.04317046e-02f, 9.34671611e-03f, 5.21441512e-02f, -6.83089569e-02f, -3.64612676e-02f,
  3.63839045e-02f, 1.32433996e-01f, -9.57911387e-02f, -3.57359909e-02f, 6.53885901e-02f, -5.83229586e-02f, 4.31412533e-02f, 7.59130120e-02f, 2.75290925e-02f, -5.33234188e-03f,
  -4.72796410e-02f, 4.83941548e-02f, 1.28667820e-02f, 4.51122895e-02f, 7.40773454e-02f, 4.12957296e-02f, -3.20171453e-02f, 6.76145777e-02f, -2.72824392e-02f, 5.40476367e-02f,
  1.85199641e-02f, -5.08576147e-02f, 3.66278030e-02f, 3.31335664e-02f, -2.85895411e-02f, -7.28397965e-02f, 8.70086029e-02f, -1.50359133e-02f, 4.60452400e-02f, -5.69747947e-02f,
  6.32114755e-03f, 6.45681471e-02f, -1.40174761e-01f, -1.04202725e-01f, -3.85538451e-02f, -2.73061991e-01f, -2.19826356e-01f, -4.00399342e-02f, -9.41026509e-02f, -3.59062850e-02f,
  -5.58732562e-02f, -1.52466103e-01f, 6.24648482e-02f, -1.33390412e-01f, -7.45368376e-02f, 1.34628683e-01f, -1.40971050e-01f, -5.27909175e-02f, -1.15870446e-01f, -3.62335853e-02f,
  -4.23009023e-02f, -9.47558284e-02f, -5.36319055e-02f, -4.91587296e-02f, -1.38367042e-01f, 3.97853814e-02f, 1.76046446e-01f, -8.39746743e-02f, -1.60010047e-02f, -2.81685479e-02f,
  6.00414388e-02f, 9.47388634e-02f, -2.72671692e-02f, -2.65586376e-02f, -3.34320068e-02f, -5.87988878e-03f, 4.86543141e-02f, -6.43417761e-02f, -6.05811216e-02f, -6.98673278e-02f,
  7.92813376e-02f, -2.93320380e-02f, 2.82243057e-03f, -3.36517245e-02f, -1.09747373e-01f, -3.26968804e-02f, -3.30774561e-02f, -1.87807884e-02f, 3.08894012e-02f, -7.48153264e-03f,
  -5.05030081e-02f, 2.97450386e-02f, -7.23527521e-02f, 1.20661361e-02f, -2.63213739e-02f, 5.99020254e-03f, 1.16293775e-02f, 5.83783817e-03f, -3.27447802e-02f, 4.64679487e-03f,
  -7.54010007e-02f, 8.43134969e-02f, 3.36888283e-02f, 5.56320399e-02f, 7.22141713e-02f, -4.61063050e-02f, 1.51250549e-02f, -1.06357029e-02f, 1.28511405e-02f, -4.30716351e-02f,
  -3.05958670e-02f, -6.68634251e-02f, -6.71990076e-03f, 1.44173848e-02f, -8.37245882e-02f, 1.39960358e-02f, -9.14562345e-02f, -3.10667809e-02f, 8.24434403e-03f, 5.07911481e-02f,
  -1.58976391e-02f, 2.08784956e-02f, 5.14633618e-02f, -7.83583224e-02f, 6.70439303e-02f, -7.22038001e-02f, 6.67081550e-02f, 1.13503583e-01f, -4.91101518e-02f, 4.07475866e-02f,
  5.27782328e-02f, 4.10719775e-03f, 8.16627443e-02f, 1.12365633e-02f, 7.95052052e-02f, 8.26848522e-02f, 8.05570278e-03f, -3.45840119e-02f, -4.78430279e-03f, 1.08037233e-01f,
  7.71119595e-02f, -2.53601512e-03f, -6.78213984e-02f, 8.30342434e-03f, -1.53747741e-02f, -2.00670548e-02f, -8.83999243e-02f, -1.13557791e-02f, 1.52756264e-02f, -1.02987640e-01f,
  -1.73263177e-02f, 1.90833141e-03f, 2.75545404e-03f, -7.54444525e-02f, 1.39109101e-02f, -5.17586134e-02f, -4.52849008e-02f, 7.14055598e-02f, -3.03134751e-02f, -6.51466325e-02f,
  3.10304519e-02f, -1.32646322e-01f, -8.24394673e-02f, 2.94585396e-02f, -6.22397736e-02f, -9.88939553e-02f, -1.54025540e-01f, -3.45914587e-02f, -9.96549129e-02f, 9.13866330e-03f,
  -1.18378717e-02f, 1.48930363e-02f, -9.11298394e-02f, 1.67068299e-02f, -1.12346075e-01f, -1.20679431e-01f, 6.95725158e-02f, -1.03693359e-01f, -4.14888412e-02f, 9.88526568e-02f,
  5.22129983e-02f, -8.71818960e-02f, 9.35104489e-02f, 8.94941241e-02f, -6.35373443e-02f, 1.48827732e-01f, 3.93880755e-02f, 5.73770069e-02f, 7.61015415e-02f, -4.30369331e-03f,
  -7.68627832e-03f, -1.13165073e-01f, 1.22825041e-01f, -6.03051931e-02f, 4.38224114e-02f, 1.29304826e-01f, 1.09789275e-01f, -6.18236512e-02f, -5.76298796e-02f, 7.06518358e-06f,
  -3.93913314e-02f, -1.00036990e-02f, -7.86852762e-02f, 1.89440884e-02f, -6.38121367e-02f, -4.43508886e-02f, -1.77334324e-01f, -2.76880078e-02f, -9.90999714e-02f, -3.49956825e-02f,
  -1.81578146e-03f, -1.00276574e-01f, 2.92130616e-02f, -1.38886999e-02f, -5.43650500e-02f, 4.79384102e-02f, 1.54556741e-03f, -2.56734882e-02f, -4.74097952e-02f, -3.55763696e-02f,
  2.88814381e-02f, 1.65592469e-02f, -3.01041584e-02f, -1.30838722e-01f, -5.57859205e-02f, 4.72030118e-02f, -5.68170398e-02f, -4.86961156e-02f, 4.24311161e-02f, 5.16207889e-02f,
  5.50938733e-02f, -3.93101722e-02f, -8.49070251e-02f, -1.56861823e-02f, 1.36929631e-01f, -2.35614982e-02f, -4.13619690e-02f, 1.93272922e-02f, 6.26347214e-03f, -4.06556949e-02f,
  -6.00793920e-02f, 4.23019975e-02f, 9.28128511e-02f, 6.81986567e-03f, -4.93904538e-02f, -5.66441193e-02f, 1.11610211e-01f, 3.36505612e-03f, -6.32585138e-02f, -2.53956374e-02f,
  5.40416725e-02f, 7.35907480e-02f, -1.56077426e-02f, 2.01171031e-03f, 1.14463188e-01f, 3.99519037e-03f, -3.63131464e-02f, -5.19648157e-02f, 9.24628451e-02f, 1.74491368e-02f,
  5.67553975e-02f, 4.15708274e-02f, 7.53786564e-02f, -1.72924716e-02f, -4.46152724e-02f, -4.20676097e-02f, 2.56346110e-02f, 1.38059619e-03f, 5.50624058e-02f, -5.70862181e-02f,
  -2.98388377e-02f, -8.36391449e-02f, -7.76702613e-02f, -2.47631110e-02f, 6.84451535e-02f, 1.14587747e-01f, -5.05124889e-02f, 5.95525699e-03f, -1.18027283e-02f, 3.12553975e-03f,
  -2.39371404e-01f, 1.52297452e-01f, 1.98922202e-01f, -1.50379077e-01f, -2.18524396e-01f, 1.51040882e-01f, 9.97079238e-02f, 3.17727849e-02f, -1.12829268e-01f, 1.02876127e-01f,
  4.41954471e-02f, -9.75466147e-02f, 1.66153252e-01f, 1.31265044e-01f, 1.61311682e-02f, 9.13680717e-02f, 1.72075406e-01f, 8.45880285e-02f, -2.84583848e-02f, -5.65992296e-02f,
  2.42929589e-02f, -1.37404371e-02f, 1.48324534e-01f, -8.19645729e-03f, -5.63167781e-03f, -2.25354638e-03f, -1.16147436e-01f, -1.30276427e-01f, 8.75793584e-03f, -5.50771803e-02f,
  -1.65987387e-01f, -1.20958172e-01f, -1.03043653e-01f, -6.66661933e-02f, -3.38267088e-02f, 5.63530512e-02f, 4.99997847e-02f, -3.80302742e-02f, -9.43992510e-02f, -6.12075962e-02f,
  -1.10196713e-02f, 3.47223431e-02f, 1.79391541e-03f, -4.77529205e-02f, -7.57822813e-03f, -5.51062413e-02f, -2.54657045e-02f, 7.45805874e-02f, -7.09187463e-02f, 7.15717152e-02f,
  2.91414838e-02f, -2.85920240e-02f, 7.70638734e-02f, 1.55486584e-01f, -2.30290946e-02f, 1.72331668e-02f, -3.55960503e-02f, 6.10967912e-03f, 4.16890755e-02f, 1.56966783e-02f,
  9.17209759e-02f, 1.02952002e-02f, -2.00479981e-02f, -6.84185550e-02f, 5.29727861e-02f, 5.27251586e-02f, -3.06948349e-02f, 3.15755084e-02f, 9.62407812e-02f, 9.23139676e-02f,
  9.93016064e-02f, -3.72412875e-02f, 4.20844108e-02f, 6.59310669e-02f, 7.09611624e-02f, -3.90022546e-02f, -5.72880432e-02f, -2.89820079e-02f, 1.12393692e-01f, 3.05913426e-02f,
  -1.19039230e-01f, 7.47572035e-02f, 8.46733376e-02f, -2.94100456e-02f, -2.37063561e-02f, -1.27332672e-01f, 4.15776335e-02f, 2.90742796e-02f, -4.74407859e-02f, 1.24454526e-02f,
  -1.85506329e-01f, -1.86788440e-01f, -8.06892365e-02f, -6.28011227e-02f, -3.50712053e-02f, -5.55309057e-02f, -5.49473278e-02f, -1.33453727e-01f, -2.10284218e-02f, -2.43445225e-02f,
  1.67168991e-03f, 3.44863757e-02f, 7.90957641e-03f, 5.31622432e-02f, 1.34826973e-01f, 1.62871927e-02f, -4.67367694e-02f, -1.77127570e-02f, -1.20366383e-02f, -1.12471711e-02f,
  5.05368076e-02f, -2.72400435e-02f, 6.97872741e-03f, -7.35073537e-02f, 4.72176112e-02f, 7.31040305e-03f, -2.04548538e-02f, -3.17886993e-02f, -5.47185615e-02f, 8.55916068e-02f,
  -7.54542872e-02f, 7.14808330e-02f, 1.09778933e-01f, -8.09494704e-02f, 1.59752201e-02f, 1.31359845e-01f, 2.04214118e-02f, 8.39869082e-02f, 2.97272149e-02f, -4.86547202e-02f,
  -2.39031613e-02f, -2.50954367e-02f, 9.14618373e-02f, -6.51269034e-02f, 6.86950609e-02f, 7.78790936e-02f, -4.81774658e-02f, -1.00722693e-01f, -4.23742272e-02f, -4.57331501e-02f,
  -7.39163384e-02f, -1.83084354e-01f, 7.98246488e-02f, -4.14593779e-02f, -1.64054602e-01f, -1.02546528e-01f, -1.03398181e-01f, -7.84306377e-02f, 2.81672794e-02f, -6.87764818e-03f,
  1.35106757e-01f, -1.18406460e-01f, 3.38785388e-02f, 4.10197601e-02f, -4.57810313e-02f, 1.06611103e-01f, -4.21625040e-02f, 6.88437670e-02f, 6.66655302e-02f, 6.17211238e-02f,
  -7.26794749e-02f, -1.06813371e-01f, -3.82718146e-02f, -2.15363633e-02f, 2.13873424e-02f, 3.83714177e-02f, 1.48310319e-01f, 2.87918821e-02f, 1.18098902e-02f, -8.16962030e-03f,
  7.17088580e-02f, -1.03266150e-01f, 1.19789038e-02f, -4.71851230e-02f, 2.26799753e-02f, 6.12508580e-02f, 6.79058433e-02f, -3.08630764e-02f, 1.01517767e-01f, -2.46374938e-03f,
  -9.41391587e-02f, -1.02584222e-02f, 4.66835871e-02f, 2.00440036e-03f, 7.41598830e-02f, 3.44552733e-02f, -7.06358925e-02f, -2.35163588e-02f, -4.22223620e-02f, 2.06038333e-03f,
  -2.09990423e-02f, -6.02273829e-02f, -3.41192894e-02f, -1.70193873e-02f, 3.27702388e-02f, -5.39814122e-03f, -9.25458223e-02f, -1.26579124e-02f, -3.25659141e-02f, 5.02496841e-04f,
  7.43620843e-02f, 1.65971108e-02f, -1.03845969e-01f, 3.91006954e-02f, 1.34956054e-02f, 5.32192066e-02f, -4.42058295e-02f, -1.14698291e-01f, -1.60851609e-02f, 5.15254661e-02f,
  1.00448713e-01f, 2.06638537e-02f, -6.58618361e-02f, -2.73772888e-02f, 5.74278347e-02f, 5.34704290e-02f, -6.90727979e-02f, -2.68547069e-02f, 2.59465091e-02f, 1.83698740e-02f,
  6.47614747e-02f, -1.05279714e-01f, 2.25846916e-02f, -4.30026986e-02f, -3.89241502e-02f, -9.96186398e-03f, -2.65582185e-02f, -5.23023261e-03f, -2.93382220e-02f, -5.09237237e-02f,
  -4.88806181e-02f, -4.36980501e-02f, 5.52371852e-02f, 6.62564533e-03f, -3.21978219e-02f, -5.40209711e-02f, 1.53859779e-02f, -1.93292126e-02f, -1.76950060e-02f, 2.70433929e-02f,
  -4.67435792e-02f, -2.24681586e-01f, -3.02973628e-01f, -1.18141606e-01f, -1.55507758e-01f, -4.00132954e-01f, -4.01958376e-01f, -3.30049917e-02f, 1.14497609e-01f, 7.91712552e-02f,
  -1.18148461e-01f, 1.36224449e-01f, 8.85511264e-02f, -1.95917472e-01f, 2.57058144e-02f, 5.45190983e-02f, -3.94273847e-01f, -2.47373655e-01f, -6.00251742e-02f, -2.64159262e-01f,
  -9.65118185e-02f, -2.67792940e-01f, -2.11768135e-01f, -8.98276120e-02f, -1.98725969e-01f, 1.59834176e-02f, 6.87151998e-02f, -8.03596675e-02f, -6.28329813e-02f, 5.21599455e-03f,
  -5.56155033e-02f, 1.29886106e-01f, -8.85848626e-02f, -1.12175792e-01f, -7.72118643e-02f, -7.09134489e-02f, -9.27454755e-02f, 2.08742693e-02f, 4.01704684e-02f, -3.92774865e-02f,
  -1.51562747e-02f, 1.30099505e-01f, 1.94225665e-02f, -3.02167516e-02f, -3.35856192e-02f, -6.19080216e-02f, -3.39388475e-02f, -1.06483593e-03f, 9.87352710e-03f, -3.06193577e-03f,
  -9.59987491e-02f, -5.07878587e-02f, -1.27449304e-01f, 1.43552609e-02f, -2.45205918e-03f, -4.28977795e-02f, 4.71002460e-02f, -1.66740268e-02f, -9.42070186e-02f, -3.12930383e-02f,
  3.60483825e-02f, 2.07588747e-02f, -5.87944314e-02f, -1.62901748e-02f, -1.65994260e-02f, 2.09111143e-02f, -6.23705052e-02f, 6.56620646e-03f, -3.32435817e-02f, 4.32967581e-02f,
  2.55606370e-04f, 6.71957359e-02f, 2.08070632e-02f, -1.43332884e-01f, -8.34003091e-02f, -7.08375126e-03f, 4.68452051e-02f, -6.04710821e-03f, -2.23204717e-02f, 3.19564007e-02f,
  1.27881498e-03f, 7.02348799e-02f, -1.59510667e-03f, -5.34600578e-03f, -5.63332364e-02f, 7.36025572e-02f, -9.07477643e-03f, 3.32884826e-02f, 6.76612705e-02f, -1.86322238e-02f,
  -1.00973472e-01f, -1.48154512e-01f, 1.67520419e-02f, 5.28155966e-03f, 4.68004234e-02f, -7.50272572e-02f, -3.14001106e-02f, -6.14255480e-02f, -9.00245309e-02f, -4.78053614e-02f,
  -1.14806838e-01f, -3.69484127e-02f, -2.30604820e-02f, 6.83726892e-02f, 1.03408536e-02f, 2.18298491e-02f, -2.68316921e-02f, -2.55397297e-02f, -8.89595225e-02f, -6.88467771e-02f,
  1.50652407e-02f, 2.18599699e-02f, 1.38525665e-01f, 1.07446564e-02f, 6.30327547e-03f, 3.74013372e-02f, -6.40953630e-02f, 8.86976905e-03f, -2.58300826e-03f, -4.94731665e-02f,
  1.55307591e-01f, 7.28719076e-03f, 1.54392526e-01f, 2.71439794e-02f, -1.78918261e-02f, 5.24065867e-02f, -8.34819973e-02f, 2.71389894e-02f, -5.76157495e-02f, -1.16023354e-01f,
  -1.02794304e-01f, -1.06953299e-02f, -4.01024744e-02f, -6.76135570e-02f, 2.83822324e-02f, -2.99968608e-02f, 1.83855314e-02f, -3.20375226e-02f, -7.52845593e-03f, 4.45016548e-02f,
  2.73956563e-02f, -5.15428297e-02f, 9.10509452e-02f, -1.54531617e-02f, 5.33804819e-02f, -3.07888184e-02f, 1.04789445e-02f, 6.43562749e-02f, 1.10267187e-02f, 1.01806097e-01f,
  -1.19232431e-01f, -4.66962457e-02f, 2.40949560e-02f, -1.82288177e-02f, -2.06398405e-02f, 3.81395333e-02f, -5.86415455e-02f, -9.08276364e-02f, 5.72609045e-02f, 5.48844673e-02f,
  1.69312693e-02f, 6.17710501e-02f, 6.18849993e-02f, -3.59877897e-03f, 9.46504474e-02f, 5.56727387e-02f, 7.76805654e-02f, -3.14229988e-02f, 1.00313775e-01f, 3.86965163e-02f,
  9.87127423e-02f, -5.02353050e-02f, 1.47438829e-03f, 3.00034061e-02f, -1.58574767e-02f, 5.48356473e-02f, -3.98743562e-02f, -1.15851145e-02f, -3.09211798e-02f, -5.04903086e-02f,
  3.80801111e-02f, 6.27281070e-02f, -2.30310839e-02f, 5.40042594e-02f, 1.90329757e-02f, -3.76588739e-02f, 3.69266085e-02f, 3.25951092e-02f, 5.92284761e-02f, -9.33467224e-02f,
  -9.00853947e-02f, 4.89661358e-02f, -6.06351160e-02f, -3.59029323e-02f, -7.92983547e-02f, 1.91818476e-02f, 8.35088193e-02f, 1.92250405e-02f, -7.72872474e-03f, 8.88227299e-02f,
  6.07218444e-02f, 2.47102547e-02f, 6.84536062e-03f, -3.31932977e-02f, -2.17019246e-04f, 5.75410463e-02f, -6.87841773e-02f, 8.32408667e-02f, 4.13436741e-02f, 8.72822255e-02f,
  -1.55962676e-01f, -8.57660845e-02f, -6.92757517e-02f, 7.18383938e-02f, 1.29096378e-02f, -1.18685579e-02f, 6.97341785e-02f, -2.96680746e-03f, -1.30209669e-01f, -7.79769644e-02f,
  -4.99792211e-02f, 4.55448106e-02f, -3.81949507e-02f, -5.52069619e-02f, 8.69515985e-02f, 2.52176113e-02f, -6.40239380e-03f, 2.54262015e-02f, -2.71318643e-03f, 4.67293896e-02f,
  -5.81453741e-02f, -4.84320186e-02f, 4.88402210e-02f, 2.92106252e-02f, -2.52974927e-02f, -9.41493288e-02f, -7.34303743e-02f, 5.36585338e-02f, 4.77281250e-02f, 4.62691002e-02f,
  -1.13230750e-01f, 8.17717090e-02f, 1.95674613e-01f, -1.77675724e-01f, -5.95031539e-03f, -1.21378563e-01f, -1.94894657e-01f, -5.01708016e-02f, -1.99229389e-01f, -3.09355319e-01f,
  -1.39507890e-01f, 1.04897276e-01f, 9.00825784e-02f, -2.18088001e-01f, 2.72638917e-01f, 1.11196548e-01f, -1.57828540e-01f, -9.38128158e-02f, 9.42091495e-02f, -1.13418072e-01f,
  1.87364072e-01f, -2.91873991e-01f, 1.72303915e-01f, -4.35466655e-02f, -3.88566889e-02f, -9.80023444e-02f, 5.66938818e-02f, 3.85901853e-02f, -8.48660246e-02f, -8.21938142e-02f,
  -1.05332658e-01f, -1.76162086e-02f, 6.01794198e-02f, 3.08512170e-02f, -3.10887676e-02f, -5.56904227e-02f, 4.22267839e-02f, -1.87378787e-02f, -2.40845699e-02f, -4.97654788e-02f,
  1.62573885e-02f, -7.45246746e-03f, -8.07736218e-02f, -2.94750347e-03f, -3.49866748e-02f, 6.06363192e-02f, 5.21126576e-02f, 1.31110093e-02f, 4.69964631e-02f, 4.36543487e-02f,
  7.96366856e-02f, 1.83069799e-02f, 6.61905063e-03f, -1.23920320e-02f, 8.59129131e-02f, -4.20376137e-02f, 2.10421789e-03f, 4.16498631e-02f, -2.96320487e-02f, -6.52184412e-02f,
  3.07819396e-02f, 5.51750995e-02f, 3.78705515e-03f, -3.37762460e-02f, -1.02956474e-01f, 3.37476619e-02f, 5.02710342e-02f, -4.66871932e-02f, 1.78719256e-02f, -1.41645959e-02f,
  -1.17890581e-01f, -2.26172302e-02f, -5.14972880e-02f, -9.04288441e-02f, -4.19847593e-02f, -7.65188187e-02f, 6.30406588e-02f, 1.40364664e-02f, -7.07429498e-02f, -4.29471694e-02f,
  -4.52665947e-02f, -1.43902730e-02f, -2.78781895e-02f, 2.19680760e-02f, 7.55058005e-02f, 5.34222759e-02f, 4.85485978e-02f, 5.63822873e-02f, -1.73396375e-02f, -3.22970469e-03f,
  -9.01451483e-02f, -1.38743237e-01f, -4.84429486e-02f, -1.02262557e-01f, -1.35790119e-02f, 5.62841259e-02f, 2.43040491e-02f, 6.77528158e-02f, -8.10429305e-02f, 3.72431544e-03f,
  -1.31549627e-01f, 1.80637911e-02f, 6.71071708e-02f, 1.77072063e-02f, -4.26615067e-02f, -7.86302797e-03f, -6.88240165e-03f, -5.32749631e-02f, 6.62471214e-03f, 3.69053259e-02f,
  -3.80925052e-02f, 1.92072336e-02f, -4.87459190e-02f, -2.79143988e-03f, -9.92542356e-02f, 4.29761820e-02f, 6.20010495e-03f, -4.40157317e-02f, 5.73081858e-02f, -2.94344295e-02f,
  -4.31759477e-01f, 1.23022541e-01f, 6.86901212e-02f, 1.56706169e-01f, -2.11885184e-01f, 4.91658263e-02f, 1.64149091e-01f, -8.47679973e-02f, 6.78874850e-02f, 2.72921890e-01f,
  1.90154374e-01f, -1.56680956e-01f, 6.41337410e-02f, 1.76446840e-01f, -5.26610315e-02f, 6.98908716e-02f, 8.29177126e-02f, 6.82341158e-02f, -6.12607747e-02f, -1.19212545e-01f,
  -4.32064161e-02f, -7.73377670e-03f, 2.82867774e-02f, 3.92422006e-02f, -8.53573605e-02f, -2.23143934e-03f, -2.55930237e-02f, -2.31280886e-02f, 1.27404660e-01f, 1.05935432e-01f,
  1.15152143e-01f, 2.00128376e-01f, 3.53135616e-02f, 7.40392646e-03f, -1.33935409e-02f, 8.57790411e-02f, -4.33972329e-02f, 1.36752967e-02f, 7.22188968e-03f, 1.22200273e-01f,
  -1.71777233e-02f, -7.44955093e-02f, 1.72400363e-02f, 2.17614360e-02f, -1.23099089e-01f, 9.53134373e-02f, -3.58590037e-02f, -4.76798452e-02f, -2.03443132e-02f, -7.89556652e-02f,
  -1.31388172e-03f, -6.97032884e-02f, 1.38544070e-03f, 2.52708811e-02f, -6.99350610e-02f, 5.73209114e-02f, 2.67313764e-04f, -8.52893218e-02f, 1.31638348e-02f, -3.19710094e-03f,
  -2.23119697e-03f, 6.70759529e-02f, 2.61365417e-02f, 5.13271093e-02f, 4.29132581e-02f, 2.69442871e-02f, -4.28370610e-02f, 2.10684724e-03f, 1.43385697e-02f, -7.07712248e-02f,
  -7.09212199e-02f, 3.94434109e-02f, -1.11441731e-01f, -3.20990197e-02f, 1.71019621e-02f, -1.37156469e-03f, -4.22644708e-03f, 4.32492420e-02f, -4.00581546e-02f, 2.20701471e-02f,
  6.24000430e-02f, -3.87889743e-02f, 3.05746421e-02f, 8.85525420e-02f, 7.13212788e-02f, -3.76908220e-02f, -2.17584167e-02f, 1.41858570e-02f, 3.58974710e-02f, -1.74639910e-03f,
  -2.40524746e-02f, 1.16956033e-01f, 1.48086593e-01f, -3.17476466e-02f, -1.28951725e-02f, -7.89020061e-02f, 3.61469425e-02f, -5.15964106e-02f, 6.02263883e-02f, 2.43602190e-02f,
  -5.76025732e-02f, -5.11830533e-03f, -1.16145663e-01f, -3.34529243e-02f, -9.77260098e-02f, 4.00452279e-02f, 4.54194881e-02f, -2.28939168e-02f, 1.31266519e-01f, 2.65727937e-02f,
  -5.24133630e-02f, 1.56486742e-02f, 9.09441337e-03f, 6.81531280e-02f, -5.43630356e-03f, -4.13651206e-02f, -8.10020193e-02f, 4.68811998e-03f, -1.03997089e-01f, 2.91552525e-02f,
  -3.45791504e-02f, 1.38283342e-01f, 7.63398185e-02f, 1.16232269e-01f, -6.03532940e-02f, -3.90339084e-02f, -1.20688856e-01f, -4.42364067e-02f, 1.32658966e-02f, 1.26490965e-02f,
  2.49085594e-02f, 7.68897356e-04f, 2.73910761e-02f, -9.88960192e-02f, 2.09702901e-03f, -1.27039924e-01f, -7.79436082e-02f, 2.70051546e-02f, 6.60158023e-02f, -4.14996892e-02f,
  -5.67311347e-02f, -5.57352453e-02f, 3.85209583e-02f, 3.22370976e-02f, -3.05821653e-02f, 1.23517640e-01f, 9.55196396e-02f, 8.83763283e-02f, -3.04382630e-02f, -8.76689106e-02f,
  2.53303740e-02f, 2.63935644e-02f, -1.74719666e-03f, 4.95629720e-02f, -9.99651402e-02f, 8.70202854e-02f, 6.56473190e-02f, -1.96190663e-02f, 7.71249607e-02f, -2.99114268e-02f,
  3.75620974e-03f, 6.28802404e-02f, 2.85110995e-02f, -4.05860655e-02f, -5.17182499e-02f, 4.25367169e-02f, -1.87796191e-04f, -7.68491626e-02f, -3.50002386e-02f, 9.72820744e-02f,
  5.12060411e-02f, 3.06735467e-02f, 6.15231916e-02f, -2.81464756e-02f, 1.46406963e-02f, 2.70436853e-02f, 4.99593504e-02f, -2.48507806e-03f, 6.98909909e-03f, -4.83802333e-03f,
  2.15303581e-02f, -2.10234225e-02f, 5.55840805e-02f, -1.00718081e-01f, 4.12996002e-02f, -5.38291335e-02f, 8.83577857e-03f, -9.43932533e-02f, 2.20921319e-02f, 5.91297448e-03f,
  7.43820071e-02f, 3.40021104e-02f, -7.48982280e-02f, 2.43031904e-02f, 5.67798095e-04f, 1.71801895e-02f, -1.05166510e-02f, -8.10454320e-03f, -6.57107532e-02f, 6.01956546e-02f,
  7.30702877e-02f, 3.79882082e-02f, 3.64947431e-02f, -3.50046046e-02f, 5.22736423e-02f, 6.60862997e-02f, -1.24891577e-02f, 4.46325652e-02f, 5.89751080e-02f, -3.80487703e-02f,
  -2.56014313e-03f, -2.88823098e-02f, 3.38980183e-02f, 4.40127142e-02f, -3.85138392e-02f, -8.52358937e-02f, 4.71568219e-02f, 3.33814649e-04f, 5.07633239e-02f, -7.90047124e-02f,
  -2.23910827e-02f, -4.16584760e-02f, -6.46181172e-03f, 3.62273417e-02f, 7.28415698e-02f, -8.79676139e-04f, -2.41232151e-03f, 7.12193698e-02f, 1.19344164e-02f, 9.64435041e-02f,
  3.93901058e-02f, -3.35610509e-02f, 2.61116624e-02f, -4.50247787e-02f, 8.25333223e-02f, 6.28474131e-02f, -4.24614688e-03f, -3.90465781e-02f, 2.58201845e-02f, -3.49426605e-02f,
  -1.01170734e-01f, -2.26991355e-01f, 3.23082842e-02f, -8.76097158e-02f, 2.79096346e-02f, -6.14250675e-02f, -3.81921120e-02f, -1.61683455e-01f, -2.21246213e-01f, -1.48926049e-01f,
  -9.30508822e-02f, 7.23560750e-02f, 1.69631019e-01f, -1.43190339e-01f, 3.00570011e-01f, 1.95496500e-01f, -5.42266818e-04f, -1.14371642e-01f, 3.67423296e-02f, -4.06737775e-02f,
  7.41363540e-02f, -2.58519445e-02f, 1.47026494e-01f, -5.84910363e-02f, -4.57012393e-02f, -1.15676694e-01f, 4.54960056e-02f, 4.74201655e-03f, -1.26157835e-01f, -2.80409902e-02f,
  -1.07050389e-01f, 3.20724770e-02f, 1.23122685e-01f, -4.32200767e-02f, 1.01236075e-01f, -8.26096162e-03f, 9.99472570e-03f, 1.92261375e-02f, 1.65496394e-02f, 8.40071812e-02f,
  -4.84401211e-02f, -2.70376783e-02f, -1.06370322e-01f, 7.83548504e-03f, 2.73601487e-02f, -4.36523408e-02f, 6.93539530e-02f, -5.18901180e-03f, -9.35130566e-02f, 2.04744861e-02f,
  2.68441662e-02f, -4.26090155e-05f, -1.30782723e-02f, 1.30693233e-02f, 5.53752556e-02f, -8.33631605e-02f, -3.42043899e-02f, 7.21107610e-03f, 2.21785884e-02f, 2.76619475e-02f,
  2.76181586e-02f, -7.41984099e-02f, 1.99627820e-02f, -5.84687814e-02f, 5.23453467e-02f, -4.45267595e-02f, -7.69065470e-02f, -8.25475305e-02f, -4.92451116e-02f, -8.40156600e-02f,
  1.12104472e-02f, -1.54836634e-02f, -2.21791249e-02f, 4.19907719e-02f, -5.37964255e-02f, -5.08384220e-03f, -6.17830306e-02f, 2.24704221e-02f, -3.55095938e-02f, -5.61266989e-02f,
  7.39396438e-02f, -5.89168109e-02f, -6.83868900e-02f, -2.54488848e-02f, -7.05530718e-02f, -8.08308460e-03f, -2.77595073e-02f, 2.21269093e-02f, 9.62271318e-02f, 1.36905909e-01f,
  -5.01431152e-03f, -3.05804908e-02f, 5.59071675e-02f, 6.71655685e-02f, -5.15724346e-02f, 2.08422672e-02f, -3.46476398e-02f, -3.10775377e-02f, 1.35115134e-02f, 1.48520339e-02f,
  6.93495348e-02f, 2.14224756e-02f, 1.83488932e-02f, -6.08888343e-02f, 2.44403761e-02f, -1.05418406e-01f, -9.58328694e-03f, 1.29973162e-02f, -5.34022935e-02f, -7.81380907e-02f,
  -3.38605568e-02f, -2.89714541e-02f, -4.06387895e-02f, -4.37590964e-02f, 8.07203469e-05f, 2.11801901e-02f, -2.57471800e-02f, 1.57326311e-02f, -1.62106063e-02f, -1.54446373e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -4.46818955e-02f, 1.25251174e-01f, -3.01856641e-02f, -1.65008996e-02f, 2.36432552e-02f, 1.98571384e-01f, 5.06868251e-02f, -5.78860892e-03f, 8.73793960e-02f, 1.00943737e-01f,
  7.57746473e-02f, 1.14003604e-03f, -3.45083810e-02f, 4.60130870e-02f, -1.22573160e-01f, -1.44222705e-03f, 2.02384725e-01f, 1.03113651e-01f, -5.88079020e-02f, 3.38967890e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.11131877e-01f, 1.56354547e-01f, -1.31497122e-02f, -3.95530500e-02f, -2.98698723e-01f, -2.27479547e-01f, 2.27956563e-01f, -2.92742163e-01f, -2.98278546e-03f, 5.50545864e-02f,
  -3.71274054e-02f, -1.50162727e-01f, 7.41139874e-02f, -1.16154991e-01f, -7.67654926e-02f, -1.85818344e-01f, 7.58846402e-02f, -9.93030369e-02f, 1.05146587e-01f, 2.07436189e-01f,
  -1.57659084e-01f, 1.65480524e-01f, 1.06539920e-01f, 9.27052125e-02f, 1.69512734e-01f, -2.00227514e-01f, 1.11199915e-01f, -2.26435900e-01f, -2.59877115e-01f, 3.30890417e-01f,
  -1.63419694e-02f, 7.58823901e-02f, -7.72787854e-02f, 3.07321846e-02f, -6.64198622e-02f, 1.20536000e-01f, 2.81861071e-02f, 1.80884719e-01f, -1.23954922e-01f, -1.47344634e-01f,
  1.94983318e-01f, 2.68666521e-02f, -1.28383428e-01f, -3.10054928e-01f, -1.27599970e-01f, -2.98263505e-02f, 7.76246786e-02f, -9.91107449e-02f, 2.41056010e-01f, 1.79593265e-01f,
  -4.56936732e-02f, 1.30451337e-01f, 8.25356767e-02f, 8.53175521e-02f, -5.20538129e-02f, -1.54518053e-01f, -3.38059403e-02f, 7.29858130e-02f, 1.77040339e-01f, -1.07989691e-01f,
  6.82747588e-02f, 3.15996110e-01f, 1.96320470e-02f, -1.35547161e-01f, 8.48344192e-02f, -4.72091101e-02f, -1.06475592e-01f, 5.62809221e-02f, -2.20945626e-01f, -1.99224725e-01f,
  4.50545289e-02f, 1.22707784e-01f, 1.66224450e-01f, 3.18097711e-01f, 3.40499245e-02f, -2.31521741e-01f, 4.61753411e-03f, -5.28281331e-02f, -2.25636903e-02f, -4.90807109e-02f,
  2.84169495e-01f, 1.96354479e-01f, -6.39877096e-02f, -1.11477256e-01f, -7.86765590e-02f, -6.77273190e-03f, -1.68521684e-02f, -9.75603163e-02f, 2.44174540e-01f, -9.32618827e-02f,
  2.07693666e-01f, 5.53066917e-02f, -4.00901064e-02f, 1.21212803e-01f, -4.13878262e-03f, -1.49705634e-01f, -3.64213407e-01f, -1.61197528e-01f, 9.72348452e-02f, -1.31973892e-01f,
  -4.33843881e-02f, -1.58778746e-02f, 1.04408950e-01f, -4.93491352e-01f, 2.37388894e-01f, -1.46463722e-01f, 9.57985222e-02f, -6.39321327e-01f, 4.07517523e-01f, 1.80465609e-01f,
  1.98551491e-01f, -1.94016807e-02f, -3.24918143e-02f, -1.25642523e-01f, -1.32844642e-01f, 7.26554077e-03f, -1.10867903e-01f, 1.42982259e-01f, 1.41447365e-01f, 6.46792427e-02f,
  4.33875658e-02f, -2.51689613e-01f, -1.69502929e-01f, -2.91700721e-01f, -2.76170820e-01f, 2.30301246e-01f, -1.23290330e-01f, -2.03225866e-01f, 2.36998752e-01f, 2.41678327e-01f,
  -3.03000659e-01f, -2.46116146e-02f, -9.18855965e-02f, -2.74792373e-01f, 3.58843982e-01f, 1.78112477e-01f, -2.62229681e-01f, 4.09855902e-01f, 1.34146795e-01f, 1.97532967e-01f,
  -5.02968580e-02f, -1.57487661e-01f, -4.43738773e-02f, 1.00616425e-01f, 8.24560076e-02f, -8.20185617e-02f, -1.64771512e-01f, -9.57960933e-02f, -6.74997941e-02f, 1.10795051e-01f,
  5.64500131e-02f, -2.26878405e-01f, 1.27040178e-01f, 9.55663472e-02f, 1.21307112e-01f, -8.01505670e-02f, 2.77961940e-01f, -6.24685623e-02f, -1.49963841e-01f, 2.41567045e-01f,
  1.18479908e-01f, 2.88852423e-01f, -9.45432484e-02f, 2.29416862e-01f, -1.40724495e-01f, -1.31399855e-01f, 5.67236960e-01f, 4.76029128e-01f, -6.80315271e-02f, -1.83296993e-01f,
  -3.58507894e-02f, 3.73016089e-01f, -2.96479523e-01f, -2.95727216e-02f, -5.66145480e-02f, -7.13824928e-02f, 1.76383644e-01f, 2.80101150e-01f, 1.60196096e-01f, 7.94342384e-02f,
  -5.43691963e-02f, 1.96358055e-01f, -2.37349302e-01f, -3.04107647e-02f, 3.15413654e-01f, 2.42433503e-01f, -3.06894571e-01f, 3.01865526e-02f, 4.41854522e-02f, 1.46293566e-01f,
  4.70409207e-02f, -9.71239805e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.29950494e-01f, 7.58798271e-02f, 1.23119496e-01f, -6.26583844e-02f, 1.06627010e-01f, -5.04744472e-03f, 1.23118758e-01f, 5.16165979e-02f, 5.15685156e-02f, -2.58649103e-02f,
  1.73091087e-02f, 3.71745467e-01f, -4.88825105e-02f, 1.55011564e-01f, -1.75179392e-01f, 6.51433393e-02f, 6.12652823e-02f, 2.29627714e-01f, 2.32223749e-01f, 1.26963302e-01f,
  9.10412297e-02f, 2.26369709e-01f, 4.38777953e-02f, -1.83462441e-01f, 1.86375692e-01f, 8.44003633e-02f, -1.73146591e-01f, 1.62087083e-01f, -2.87717916e-02f, -4.79671061e-02f,
  -1.62499756e-01f, -6.62097409e-02f, -5.71378358e-02f, -7.69577250e-02f, -9.36277360e-02f, 1.59983680e-01f, -1.52700804e-02f, -2.43234374e-02f, -1.39468819e-01f, -6.41989633e-02f,
  1.44540127e-02f, -1.72098558e-02f, 5.94582632e-02f, -7.05955923e-02f, 7.52289742e-02f, 2.32402772e-01f, -7.80061856e-02f, 1.40295058e-01f, -1.51620433e-01f, -6.91513121e-02f,
  -1.33115485e-01f, 1.26470715e-01f, -1.17498375e-01f, -3.08333896e-02f, 9.76525769e-02f, 9.31501091e-02f, 8.79072621e-02f, 4.50401828e-02f, -3.10827233e-02f, 1.47771657e-01f,
  -4.74764667e-02f, -1.33878753e-01f, -5.92161454e-02f, -1.07568897e-01f, 3.66982788e-01f, 2.72074938e-01f, 1.55797854e-01f, 1.12296849e-01f, -8.06638747e-02f, 1.25340566e-01f,
  -4.01375927e-02f, -4.31377068e-03f, 5.06278835e-02f, 2.05913156e-01f, 1.06162786e-01f, -3.63284230e-01f, 6.31276742e-02f, -4.22133915e-02f, -3.04494263e-03f, 1.39460037e-03f,
  3.07706386e-01f, -1.51395172e-01f, 3.00549924e-01f, 5.22446632e-02f, 1.73881754e-01f, 1.06307939e-01f, 3.10984284e-01f, -5.51936068e-02f, 1.32793665e-01f, 1.53151631e-01f,
  4.90926206e-01f, 1.13726534e-01f, 3.45189452e-01f, 2.26545148e-02f, -4.06893790e-02f, 4.86024804e-02f, -1.17370605e-01f, -5.76092564e-02f, 6.34438545e-02f, -9.74076800e-03f,
  1.33881662e-02f, -5.19589111e-02f, 5.91717847e-02f, 4.34742197e-02f, 8.71204734e-02f, 6.53668195e-02f, -7.21541569e-02f, -1.62547246e-01f, 6.40477240e-02f, -2.91406531e-02f,
  -1.38747338e-02f, -1.23469204e-01f, 8.00225511e-02f, -1.08407795e-01f, -8.49128887e-02f, -2.81469207e-02f, -1.84340611e-01f, -1.00034647e-01f, -1.05178412e-02f, 1.11627385e-01f,
  6.10183878e-03f, 1.14170626e-01f, -2.76429337e-02f, 1.15010373e-01f, -1.37397215e-01f, -1.21892266e-01f, -1.64977178e-01f, -4.88395691e-02f, -1.77327141e-01f, -8.35778341e-02f,
  1.88059375e-01f, 1.37792706e-01f, 6.31711213e-03f, 2.23244086e-01f, 2.36708969e-01f, 4.40429449e-02f, 7.67099336e-02f, 1.07467890e-01f, 4.07693200e-02f, -3.60775813e-02f,
  -1.56681180e-01f, 4.54901382e-02f, 1.78592026e-01f, -1.58900395e-01f, -1.52507827e-01f, -1.28299594e-01f, -1.70715734e-01f, 1.58070307e-02f, -4.36278246e-02f, 2.26490557e-01f,
  -1.34833694e-01f, 1.00422092e-01f, -2.67555844e-02f, 1.52804971e-01f, -1.91111177e-01f, -1.34621307e-01f, -1.21270590e-01f, 2.01682910e-01f, 1.69576090e-02f, -1.68108761e-01f,
  2.02928439e-01f, 2.58130014e-01f, 1.71777397e-01f, 1.02618963e-01f, 2.18817621e-01f, 2.17319265e-01f, 7.20922947e-02f, -2.71471024e-01f, 1.11675389e-01f, 1.34196684e-01f,
  -2.06636842e-02f, -3.43811065e-01f, -1.55870542e-02f, 1.58876985e-01f, 8.20371583e-02f, -1.12091161e-01f, 8.57654214e-03f, -1.86232068e-02f, 1.24089152e-01f, 1.39637306e-01f,
  2.05903009e-01f, -1.65248692e-01f, 1.54595211e-01f, 1.91180985e-02f, -2.24258940e-04f, -1.00593276e-01f, 1.92815036e-01f, 1.04968295e-01f, 2.36217543e-01f, 1.44438669e-01f,
  -4.36480679e-02f, 8.35969597e-02f, -1.60678744e-01f, -4.99364957e-02f, 1.69510901e-01f, 1.15980603e-01f, 2.27513611e-01f, 1.01048678e-01f, -2.06708655e-01f, -2.42646053e-01f,
  -1.55406475e-01f, 7.34106526e-02f, 1.21631719e-01f, -1.79800779e-01f, -4.07114811e-02f, -5.68940043e-02f, 9.66926888e-02f, -3.93283069e-02f, -1.32267207e-01f, -1.61104143e-01f,
  -5.76507151e-02f, -5.27848154e-02f, -1.71374828e-01f, -2.27428451e-01f, 8.40651020e-02f, 4.47154269e-02f, -1.85046107e-01f, 1.89221818e-02f, 1.57738298e-01f, -1.69504941e-01f,
  -1.01161681e-01f, 1.09644100e-01f, 1.62806585e-01f, -7.59176686e-02f, 3.27686429e-01f, 5.36216974e-01f, 2.86253422e-01f, 1.35536894e-01f, 1.33053824e-01f, 2.15587541e-01f,
  2.38213986e-01f, -1.23218959e-02f, -1.81973487e-01f, 6.41263783e-01f, -2.49512613e-01f, -4.63882446e-01f, -2.80927062e-01f, 8.80306289e-02f, 2.06220895e-01f, -5.75346462e-02f,
  5.77653460e-02f, 9.26591381e-02f, -6.42354041e-02f, -1.75964206e-01f, 2.13835880e-01f, -5.54863587e-02f, 2.02925533e-01f, -1.93394929e-01f, 3.68930310e-01f, 2.65352547e-01f,
  5.22323906e-01f, -7.35100266e-03f, 3.82988423e-01f, 3.65443379e-01f, 5.67988716e-02f, 2.03864858e-01f, 4.18735072e-02f, -1.70537397e-01f, 9.01932940e-02f, -5.98923005e-02f,
  -5.04065119e-02f, 1.91512406e-01f, -2.23461539e-01f, 1.68750867e-01f, 5.82062900e-02f, 8.76474157e-02f, -5.96630611e-02f, 1.18777536e-01f, 1.08493179e-01f, 1.91326246e-01f,
  6.56841137e-03f, 5.54862469e-02f, -1.87917612e-02f, 3.75843607e-02f, 2.04609334e-01f, -1.15131788e-01f, 3.76093797e-02f, 2.85019092e-02f, 3.09886858e-02f, 2.05030307e-01f,
  -1.58315465e-01f, -1.78062290e-01f, -8.51181429e-03f, -9.22917873e-02f, 5.19905351e-02f, -7.51800695e-03f, -6.23873025e-02f, 4.12331522e-02f, 6.89920932e-02f, 1.97625812e-02f,
  2.32127786e-01f, 2.76134551e-01f, 3.19826245e-01f, 2.80556530e-01f, -4.00619119e-01f, 3.10791433e-01f, 2.58534789e-01f, -5.26340492e-03f, 1.25863194e-01f, 3.01985830e-01f,
  4.01491761e-01f, -1.15775935e-01f, -6.87457621e-02f, -9.17610433e-03f, 1.81807324e-01f, 2.39744678e-01f, 4.39613283e-01f, 2.70495582e-02f, 3.40860635e-01f, -1.29190192e-01f,
  2.40700483e-01f, 2.84688622e-01f, 3.29628326e-02f, -7.46170282e-02f, -6.49645180e-02f, -4.57697883e-02f, 2.44987041e-01f, -1.54584691e-01f, 4.92528379e-02f, 1.54344197e-02f,
  -9.97527242e-02f, -9.51340944e-02f, -8.88008624e-03f, 6.73904344e-02f, -1.53718993e-01f, -1.12427652e-01f, 1.98897980e-02f, 6.91355625e-03f, 4.80637178e-02f, 6.11603707e-02f,
  -5.61544821e-02f, -2.31451899e-01f, 6.97695762e-02f, -9.33921710e-02f, 1.48822322e-01f, -5.18164486e-02f, 1.51206970e-01f, 7.44459182e-02f, -1.72424614e-01f, -2.75993068e-02f,
  1.02917343e-01f, -1.17119968e-01f, -1.70901865e-01f, -7.75767565e-02f, 1.45345137e-01f, -5.57389818e-02f, 1.39514461e-01f, -1.89591840e-01f, 2.51628347e-02f, 4.18628678e-02f,
  -9.24638361e-02f, -1.73155427e-01f, 2.48943746e-01f, -1.16281761e-02f, 3.03053856e-01f, 2.42244780e-01f, 1.78531036e-01f, 2.97405988e-01f, -4.00545359e-01f, 5.87527566e-02f,
  2.02347726e-01f, 1.11741930e-01f, 8.80400185e-03f, 6.94217533e-02f, 4.58098114e-01f, -5.53597100e-02f, -1.71528101e-01f, -1.55021355e-01f, 1.48773938e-01f, 2.34323502e-01f,
  4.47225749e-01f, 7.20947236e-02f, 4.27564949e-01f, 1.05274571e-02f, 1.42658889e-01f, 1.55265525e-01f, -1.47101566e-01f, -1.21191386e-02f, -2.19916757e-02f, 6.84749931e-02f,
  2.41385460e-01f, -3.17501910e-02f, 6.68420121e-02f, 1.73358396e-01f, 5.52389883e-02f, 4.08035070e-02f, -6.89070076e-02f, 6.01081736e-02f, 2.78781969e-02f, 5.19815795e-02f,
  7.28692189e-02f, -5.90924956e-02f, -2.99694270e-01f, -2.14556411e-01f, -1.82270020e-01f, 2.22491100e-01f, 5.56291193e-02f, 2.22589001e-01f, 7.20032528e-02f, -1.13497071e-01f,
  -1.39582297e-02f, 9.71983746e-02f, -5.14887227e-03f, 5.99836595e-02f, 2.07160354e-01f, 1.34541318e-01f, -8.07323009e-02f, 1.28945187e-02f, -1.80340514e-01f, -7.32881650e-02f,
  -7.18898028e-02f, -4.63236719e-02f, -6.85364231e-02f, -1.42331079e-01f, -1.68972254e-01f, 2.82736458e-02f, 2.17050985e-01f, 2.36046314e-01f, 2.39305854e-01f, 3.81589159e-02f,
  -9.49849468e-03f, -7.67195225e-02f, 2.10251346e-01f, 1.62447318e-01f, -2.95709670e-01f, 1.02613471e-01f, 2.08916925e-02f, -2.32561287e-02f, -1.94750443e-01f, -1.23492926e-01f,
  2.18930934e-02f, -1.22473307e-01f, 9.29280296e-02f, 1.33555204e-01f, 3.15764435e-02f, 8.11525509e-02f, 1.36994883e-01f, -1.22464821e-01f, 1.47196546e-01f, -1.67358071e-01f,
  1.11835055e-01f, 1.43097311e-01f, 1.85270086e-01f, 6.94359988e-02f, 9.87498611e-02f, -2.77431235e-02f, -1.39760837e-01f, 2.58532643e-01f, -1.55156590e-02f, 2.58214325e-01f,
  4.57644016e-02f, 1.85024031e-02f, 5.19803464e-02f, 1.02724150e-01f, 3.28343391e-01f, -2.27295384e-02f, -1.93529204e-01f, -1.46595165e-02f, -1.59510955e-01f, 1.01638727e-01f,
  -9.00356993e-02f, 7.44817406e-02f, 8.75148736e-03f, 1.07061140e-01f, -1.22472510e-01f, 1.44561887e-01f, 1.21150397e-01f, 9.72323939e-02f, -1.72462285e-01f, 1.97290659e-01f,
  1.73306882e-01f, -1.01615181e-02f, 2.32568458e-02f, -9.94669050e-02f, -7.51219988e-02f, 1.07706130e-01f, 9.46766213e-02f, 2.09884137e-01f, -1.61596969e-01f, 2.08106056e-01f,
  4.43113633e-02f, 7.04897419e-02f, 2.50669685e-03f, 1.34735286e-01f, -9.28623602e-03f, 9.18986835e-03f, -8.74609426e-02f, 2.63531417e-01f, 2.48109147e-01f, -5.09184338e-02f,
  -1.15640700e-01f, 8.55108127e-02f, 2.25616544e-01f, 5.07723652e-02f, 4.60744016e-02f, -1.13751329e-01f, -1.20694801e-01f, -8.09886772e-03f, 3.06071728e-01f, 1.79270566e-01f,
  7.39386156e-02f, -1.41814305e-02f, 3.78028117e-02f, -1.42824337e-01f, -1.68840423e-01f, 1.77521437e-01f, 6.44835532e-02f, 8.11914802e-02f, 3.77325565e-02f, -1.25125730e-02f,
  -2.75754239e-02f, 1.24346629e-01f, 6.49080276e-02f, 7.34875053e-02f, 1.52915552e-01f, -6.05109073e-02f, 1.61291644e-01f, -6.54159561e-02f, -1.34363770e-01f, 1.80160433e-01f,
  -1.03610374e-01f, 3.04220077e-02f, -1.85233533e-01f, 1.45911142e-01f, 1.29768640e-01f, 2.12347247e-02f, -8.14466327e-02f, -5.53013152e-03f, 1.45570766e-02f, -4.10030372e-02f,
  3.15885916e-02f, 3.36064585e-02f, 1.00498721e-01f, -1.17375635e-01f, -6.65937811e-02f, -1.29167318e-01f, -1.71215191e-01f, -1.33329868e-01f, -6.93187341e-02f, 1.77101776e-01f,
  9.41328108e-02f, -1.96988314e-01f, 1.09344594e-01f, -8.29065219e-02f, 2.22039163e-01f, 1.03582390e-01f, -1.57528929e-02f, -4.02412191e-02f, 2.01542869e-01f, -2.63725203e-02f,
  1.89124435e-01f, 5.65612502e-02f, 8.56901854e-02f, -1.60573795e-01f, 1.13513619e-01f, 1.98567539e-01f, 3.16326350e-01f, 1.31677732e-01f, -8.31995010e-02f, 1.54791355e-01f,
  -1.43538997e-01f, 1.03851333e-01f, 2.88874805e-01f, 1.38445854e-01f, 3.67272012e-02f, -4.74857353e-02f, 1.03753448e-01f, -8.18376318e-02f, -1.31961396e-02f, -1.17706992e-01f,
  -2.42947683e-01f, -2.41743084e-02f, 1.87175676e-01f, 5.65023795e-02f, -6.77258447e-02f, 2.59380370e-01f, 4.34651412e-02f, -9.54038799e-02f, -5.57382777e-02f, 1.83756500e-02f,
  -5.77054136e-02f, 1.33156516e-02f, -2.16480643e-02f, 1.31111396e-02f, 4.14749198e-02f, 1.31483227e-01f, -5.74583970e-02f, -8.62697214e-02f, -1.59672886e-01f, -1.35424227e-01f,
  -1.13226965e-01f, 1.56961032e-03f, -9.52425748e-02f, -6.36983439e-02f, 2.47503333e-02f, 3.07441112e-02f, -1.10479482e-02f, 1.29217938e-01f, -5.05002625e-02f, 1.08235464e-01f,
  -3.71465608e-02f, -1.27299875e-01f, -1.08541533e-01f, 8.55130851e-02f, -1.60482258e-01f, -1.35538667e-01f, 4.71304096e-02f, 4.34109531e-02f, 2.44011935e-02f, -7.23562315e-02f,
  -3.26911099e-02f, -8.34502354e-02f, -1.13027506e-01f, 1.86731830e-01f, -1.60341308e-01f, 2.87225749e-02f, 1.79573800e-02f, -1.60135068e-02f, 1.06656522e-01f, 8.31452161e-02f,
  -3.34010902e-03f, -3.39052565e-02f, 1.38892829e-01f, -1.43081963e-01f, -1.01837715e-04f, -1.53265391e-02f, -8.17432776e-02f, -1.05284907e-01f, -9.95480865e-02f, -4.78514358e-02f,
  5.66481575e-02f, -1.44863948e-02f, 4.25301455e-02f, -8.53062719e-02f, -1.26382649e-01f, -1.76895916e-01f, -1.51117265e-01f, 1.91137224e-01f, 1.16796374e-01f, 5.52140772e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.09441513e-01f, 1.59127608e-01f, 1.59884349e-01f, -8.91001225e-02f, -2.67735287e-03f, 1.69892445e-01f, -2.21639220e-02f, 2.79672086e-01f, 1.03192002e-01f, 3.54206830e-01f,
  -2.33734529e-02f, 7.80170038e-02f, -2.23991163e-02f, -6.20016791e-02f, -5.87942041e-02f, 9.76357535e-02f, 4.81075607e-02f, 2.34083921e-01f, -6.86267242e-02f, -1.52659565e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -8.18119645e-02f, 9.42087173e-03f, -1.20472526e-02f, -1.32373452e-01f, 1.56735498e-02f, -1.15167707e-01f, -2.20213875e-01f, -4.07203697e-02f, -1.08225070e-01f, 1.22882515e-01f,
  -4.14926261e-01f, -1.75633475e-01f, 1.59921303e-01f, 4.60282229e-02f, 3.49956728e-03f, 1.50210172e-01f, -1.26201466e-01f, -9.58371907e-02f, -1.54781207e-01f, -4.01462555e-01f,
  4.84500527e-02f, 3.11439991e-01f, -3.64284553e-02f, 1.98391587e-01f, 8.47294405e-02f, -2.04105064e-01f, 5.57924947e-03f, 1.39518142e-01f, 7.00505450e-02f, -1.29358992e-01f,
  -8.29122812e-02f, 6.18584715e-02f, 9.06308889e-02f, 1.08871751e-01f, 3.25080752e-01f, 3.09086666e-02f, 6.64917752e-02f, 3.82039756e-01f, 5.71675077e-02f, -1.04909793e-01f,
  4.09332477e-03f, -4.12015736e-01f, 4.02229816e-01f, 5.95476806e-01f, 1.76733881e-01f, -6.03937767e-02f, -2.31366411e-01f, 2.41884906e-02f, 3.40448022e-02f, -5.05662300e-02f,
  -1.00202754e-01f, 1.02518909e-01f, 2.04017591e-02f, -2.45660365e-01f, -2.06709221e-01f, -2.85554528e-01f, 1.58875689e-01f, -5.83594255e-02f, -1.53866876e-02f, -6.57550767e-02f,
  1.00112148e-01f, 1.73725888e-01f, 1.47565603e-01f, 9.44729149e-02f, 9.99275744e-02f, -1.48914605e-01f, -9.45693552e-02f, 1.37733936e-01f, -8.39729533e-02f, 2.11178020e-01f,
  2.98765749e-01f, 2.35361189e-01f, -5.90095595e-02f, 2.94489890e-01f, 9.32089686e-02f, -8.98958072e-02f, 8.89758542e-02f, -9.74017158e-02f, -1.26086786e-01f, -8.50636605e-03f,
  2.33284786e-01f, 1.67815298e-01f, 1.46675944e-01f, 1.54219911e-01f, -1.35892287e-01f, -2.37273037e-01f, 1.13929072e-02f, -2.85715044e-01f, 1.96094751e-01f, 3.93390842e-02f,
  2.43678212e-01f, -1.48042217e-01f, 6.04223311e-02f, -1.38757303e-01f, 1.03237629e-01f, -1.65273741e-01f, 2.66233712e-01f, 3.23559999e-01f, 1.68153614e-01f, 3.55434656e-01f,
  3.36634964e-01f, -2.45640725e-01f, -3.12145501e-01f, -1.29204154e-01f, -2.10211813e-01f, 9.72091407e-02f, -1.70158103e-01f, -5.29909730e-01f, -1.59334317e-01f, 6.96841776e-02f,
  -2.86831141e-01f, 2.75046788e-02f, 8.56863633e-02f, -4.20316588e-03f, 2.51306742e-01f, -7.99507722e-02f, 1.12059377e-01f, -1.70944139e-01f, -7.36779869e-02f, 6.63634669e-03f,
  2.73387209e-02f, -2.32220501e-01f, -1.52028576e-01f, -7.91119635e-02f, 2.60140061e-01f, -5.05194664e-02f, 1.81120653e-02f, 4.61517629e-04f, 2.74122566e-01f, 3.96072343e-02f,
  -1.51727855e-01f, 3.46741229e-01f, -6.29308298e-02f, 2.38680039e-02f, -2.77657151e-01f, -1.01901628e-01f, -1.29578367e-01f, 3.79548222e-01f, -2.21687198e-01f, -5.21535993e-01f,
  -7.87210390e-02f, 1.93647251e-01f, -1.74301222e-01f, 4.68493029e-02f, -1.82074323e-01f, 4.74581905e-02f, 1.88901156e-01f, -1.12714142e-01f, -1.65371317e-02f, 1.34785190e-01f,
  -5.20153977e-02f, -4.62988466e-02f, 1.62365153e-01f, -4.85576093e-02f, -1.29730850e-01f, -1.03534676e-01f, -8.40242207e-02f, -4.37951386e-02f, -7.37165660e-03f, 8.85070190e-02f,
  1.82945684e-01f, 5.86049482e-02f, 8.61750543e-02f, 3.72835882e-02f, 2.94897705e-02f, 2.66434371e-01f, -1.66296363e-01f, -3.23078394e-01f, 1.04528271e-01f, -4.40477639e-01f,
  2.73999542e-01f, 4.21596467e-01f, 2.21968979e-01f, -5.80017455e-02f, -1.43409401e-01f, 9.03510600e-02f, 1.60347611e-01f, -1.26388744e-01f, -2.35249013e-01f, -5.29310815e-02f,
  -1.71081930e-01f, -6.44057542e-02f, -3.18736397e-02f, -1.73130542e-01f, -3.23954225e-02f, 2.38662228e-01f, 2.20882758e-01f, 4.03050287e-03f, -1.08842902e-01f, -7.26521462e-02f,
  -1.00410700e-01f, -1.77258879e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.48122400e-01f, -1.52222261e-01f, -8.72968137e-02f, -7.66791925e-02f, 1.87191423e-02f, -3.71696684e-03f, 1.04282588e-01f, -1.13155559e-01f, -7.87958354e-02f, -1.64405052e-02f,
  -1.15135923e-01f, -1.23101667e-01f, -1.62832096e-01f, -1.74498573e-01f, -1.63142145e-01f, 1.07948445e-01f, -8.26421753e-02f, -1.55193567e-01f, -1.90786812e-02f, 2.26195659e-02f,
  -9.74090844e-02f, -1.30459920e-01f, 1.02760799e-01f, 8.65405574e-02f, -7.85453245e-02f, -1.13969892e-02f, -1.21011287e-01f, 2.96179689e-02f, -1.44949868e-01f, 6.29939735e-02f,
  -4.51290198e-02f, 1.41512668e-02f, 5.25521487e-02f, 3.86596136e-02f, 1.35528922e-01f, -1.43714875e-01f, 2.11570472e-01f, 8.45207348e-02f, -2.48503014e-01f, 4.69484217e-02f,
  -1.92346230e-01f, -2.27043122e-01f, 4.13149633e-02f, 1.78038463e-01f, 1.51965350e-01f, -1.01650245e-01f, -8.99943411e-02f, -1.00866824e-01f, 1.20974034e-01f, -1.24016538e-01f,
  -1.75236329e-01f, 3.11860461e-02f, -1.20714180e-01f, 1.87490806e-01f, -2.06907183e-01f, 2.34984428e-01f, -4.99092154e-02f, -9.93348360e-02f, -3.90096405e-03f, 3.90102156e-02f,
  -8.49350840e-02f, 1.30127490e-01f, 1.33517042e-01f, -4.16908339e-02f, 1.64737076e-01f, 2.47982770e-01f, 1.87683702e-02f, -3.64321214e-03f, 4.72515002e-02f, 1.29035890e-01f,
  1.50614053e-01f, 2.89143443e-01f, 2.65949741e-02f, 2.87713230e-01f, -3.01266968e-01f, -4.68576282e-01f, -2.10458636e-01f, 6.35294914e-02f, 2.25383684e-01f, -1.28784671e-01f,
  2.09087610e-01f, 3.39899331e-01f, 1.47438124e-01f, 4.25305575e-01f, 8.05767030e-02f, 2.05879301e-01f, -1.30411386e-01f, 2.39354149e-01f, -3.64270271e-03f, -1.08448183e-02f,
  -9.79120377e-03f, -1.18156500e-01f, -1.44457191e-01f, -1.83271423e-01f, -7.29359463e-02f, 1.28635362e-01f, 2.43018456e-02f, 4.45350595e-02f, 1.32216379e-01f, 5.10195903e-02f,
  9.66419950e-02f, -8.10921565e-02f, -8.29586163e-02f, -1.82706580e-01f, -1.62706465e-01f, 3.72053206e-01f, -2.68655479e-01f, -4.37372297e-01f, -1.44236475e-01f, 1.19340472e-01f,
  1.68404356e-01f, -1.05726495e-01f, -1.04947627e-01f, 1.68485299e-01f, 2.52343446e-01f, -7.60440454e-02f, 4.43730243e-02f, 2.62519300e-01f, -1.55797387e-02f, 2.84780234e-01f,
  8.13731030e-02f, -1.33237675e-01f, -9.04125571e-02f, -6.38291314e-02f, 6.97031021e-02f, 2.22459838e-01f, -1.47969276e-01f, 1.78106390e-02f, -7.04338402e-02f, 1.27342135e-01f,
  8.16100016e-02f, 8.69929232e-03f, -9.79880989e-03f, 3.73144418e-01f, -1.66823596e-01f, -1.06379472e-01f, -8.69629160e-02f, -6.17337227e-01f, 2.79168546e-01f, 3.47161174e-01f,
  2.74511993e-01f, 2.26330664e-02f, 1.64283663e-01f, 7.32758343e-02f, -9.58541259e-02f, -1.02131769e-01f, -1.94043621e-01f, 1.71806797e-01f, 1.31973490e-01f, 4.73090798e-01f,
  -1.88514024e-01f, 3.23931605e-01f, -4.78779301e-02f, 2.02063322e-01f, -4.01307717e-02f, 1.48211360e-01f, 5.16148098e-02f, 1.54342145e-01f, 3.36581059e-02f, -8.73106644e-02f,
  1.74152851e-01f, -9.01745036e-02f, -1.40045539e-01f, -1.38347328e-01f, -1.33888394e-01f, 3.03569026e-02f, -4.78269607e-02f, -1.79208204e-01f, -1.02419212e-01f, -5.97019531e-02f,
  1.94081187e-01f, 1.21383272e-01f, 1.19489925e-02f, -3.09328567e-02f, -1.06812410e-01f, -4.26867940e-02f, -1.44375876e-01f, -1.49638399e-01f, 9.51550156e-02f, 9.73564535e-02f,
  1.42887190e-01f, 1.62210658e-01f, 7.92622641e-02f, -1.03008367e-01f, -1.03584334e-01f, 1.48976743e-01f, 1.26632422e-01f, -7.23260641e-02f, 8.12681168e-02f, -9.83663052e-02f,
  7.52540156e-02f, -2.18854677e-02f, 2.06008717e-01f, 1.56960320e-02f, -3.37357894e-02f, -4.60853279e-02f, -1.49877459e-01f, 9.00995284e-02f, -1.03591576e-01f, -2.27177620e-01f,
  5.94812036e-02f, -2.85118937e-01f, 2.45398462e-01f, -1.05813958e-01f, 1.60445347e-02f, -2.76762918e-02f, 5.45170605e-02f, -1.86531454e-01f, -1.71750739e-01f, -1.19556785e-01f,
  1.13827931e-02f, 2.06421167e-01f, -1.59267053e-01f, -8.12964663e-02f, -5.55066653e-02f, -1.11526310e-01f, 3.71323191e-02f, -4.47236933e-02f, 9.39801857e-02f, -7.41750151e-02f,
  5.23314774e-02f, 1.61228493e-01f, 1.04881383e-01f, -6.60869628e-02f, 8.09016526e-02f, -9.38284621e-02f, -9.40372273e-02f, 1.89741269e-01f, -2.47822097e-03f, 3.90210971e-02f,
  -2.03885548e-02f, 2.09948182e-01f, 2.08167583e-01f, 1.74695820e-01f, -2.06998527e-01f, 1.04615904e-01f, 1.11060113e-01f, -5.73726334e-02f, -1.13164596e-02f, 4.99089509e-02f,
  -8.13878998e-02f, -1.29489630e-01f, -1.14180453e-01f, -8.77954140e-02f, -1.49362683e-01f, 6.72049075e-02f, 1.71530217e-01f, 2.27577597e-01f, -6.57723993e-02f, -1.46425262e-01f,
  1.04974329e-01f, 3.89293469e-02f, 9.47822630e-03f, -1.08399545e-03f, 3.99521440e-02f, 3.36564286e-03f, 1.06966317e-01f, 1.63199723e-01f, 4.84967567e-02f, -1.60499647e-01f,
  -1.58465076e-02f, 3.81083906e-01f, -2.36753240e-01f, -2.63152838e-01f, -9.82206464e-02f, -6.38059258e-01f, 4.18554634e-01f, 2.12946787e-01f, -4.42199521e-02f, -1.58437297e-01f,
  2.96966046e-01f, -2.02903688e-01f, 1.03492767e-01f, 1.25920132e-01f, -1.63241979e-02f, 1.40038401e-01f, -5.40564805e-02f, 4.19333458e-01f, -1.92052156e-01f, 2.97384083e-01f,
  -6.27203211e-02f, 1.47735611e-01f, 9.50642601e-02f, 2.11273223e-01f, 1.75735295e-01f, 2.63952792e-01f, -1.89769164e-01f, -1.03991583e-01f, 7.61912465e-02f, -1.28558114e-01f,
  -8.45971704e-02f, -7.09104240e-02f, -1.23418801e-01f, 1.36317730e-01f, 4.65823635e-02f, 2.48984307e-01f, 1.48813590e-01f, 8.91807303e-02f, -7.96467066e-02f, -3.32354665e-01f,
  -1.12837702e-01f, 4.01515365e-02f, 2.14339420e-01f, 9.75743234e-02f, -1.54380113e-01f, 1.43778369e-01f, -1.68807916e-02f, 2.17873320e-01f, 1.34785041e-01f, -4.91396599e-02f,
  7.12520853e-02f, -1.03699833e-01f, 1.31357042e-02f, -3.16844918e-02f, -5.36044240e-02f, 4.78095822e-02f, -5.92386052e-02f, -1.28141209e-01f, 9.15967524e-02f, -7.95383081e-02f,
  1.47385657e-01f, 8.43575224e-02f, -1.76071711e-02f, -5.82033619e-02f, 1.36687979e-01f, 1.46638155e-02f, 2.37084076e-01f, -1.84130967e-02f, -5.59064653e-03f, 2.77024031e-01f,
  6.83703050e-02f, -3.01043689e-01f, 1.43033460e-01f, 1.70451880e-01f, 5.33337593e-02f, -1.00507811e-01f, 6.99116811e-02f, 1.03039220e-01f, -4.70061116e-02f, 1.43835917e-01f,
  7.11392760e-02f, -5.95249049e-02f, 1.84394017e-01f, 1.95443764e-01f, -1.35802925e-01f, -1.62651554e-01f, -2.89606508e-02f, 1.89100578e-01f, -2.09823057e-01f, 1.96860909e-01f,
  4.08084393e-02f, 2.31798869e-02f, 7.69697204e-02f, 1.60842210e-01f, -6.19288301e-03f, -5.78670688e-02f, 1.47607729e-01f, 2.95222878e-01f, -2.02746764e-01f, 2.94513581e-03f,
  -1.64953068e-01f, -2.85541087e-01f, 3.53349000e-01f, 2.43163615e-01f, 4.68066148e-02f, -5.49710132e-02f, 4.77801971e-02f, -7.87185598e-03f, -5.69665097e-02f, 2.38108963e-01f,
  -9.41987801e-03f, 3.77908170e-01f, -2.03527451e-01f, -1.60434008e-01f, -7.21685588e-02f, 4.09801379e-02f, 2.01775849e-01f, 2.87488073e-01f, 2.22275808e-01f, -1.10900372e-01f,
  -1.26165435e-01f, -8.17421898e-02f, 1.71508733e-02f, 8.18715841e-02f, 2.77516276e-01f, 1.79770663e-01f, 1.29052103e-01f, -2.60808002e-02f, 3.19068491e-01f, 1.65030375e-01f,
  4.34086174e-02f, -4.78619970e-02f, -2.65462399e-01f, -1.47807136e-01f, 8.74178335e-02f, 2.24967390e-01f, 2.58657485e-01f, -6.95707276e-02f, -1.89596608e-01f, -1.88960418e-01f,
  -1.58413187e-01f, -1.84997708e-01f, -6.69827163e-02f, -1.38986051e-01f, -6.54535592e-02f, -4.41230386e-02f, 2.18236749e-03f, -3.64797190e-02f, 2.47488737e-01f, 1.88387230e-01f,
  2.13898882e-01f, -8.64276197e-03f, 1.59999460e-01f, 1.88057259e-01f, 1.14210077e-01f, -1.76846191e-01f, 7.64606819e-02f, -7.31827617e-02f, -2.96048857e-02f, -1.64173543e-01f,
  9.05066505e-02f, -2.37946566e-02f, 6.91469982e-02f, -1.74296215e-01f, 1.94035381e-01f, -1.87408701e-01f, -1.54872118e-02f, 2.95021415e-01f, 1.87931582e-01f, -1.69281125e-01f,
  -1.21919416e-01f, -1.69200022e-02f, 1.70866355e-01f, 7.70742670e-02f, 1.03408255e-01f, 1.86462149e-01f, 1.19496465e-01f, -8.37558061e-02f, -1.58515144e-02f, -3.93762775e-02f,
  -1.50884897e-01f, -3.11533194e-02f, 1.56030580e-01f, -1.10365473e-01f, -1.21004447e-01f, 1.53647006e-01f, -7.35616833e-02f, 5.10172024e-02f, 2.18033716e-02f, 1.18752241e-01f,
  2.32373238e-01f, 7.58486688e-02f, -1.01360697e-02f, 1.78918466e-01f, 3.37062299e-01f, 7.30220377e-02f, 1.73190549e-01f, 2.69902766e-01f, 1.52692229e-01f, -6.69510756e-03f,
  9.53965336e-02f, -3.37877721e-02f, 2.87869573e-01f, 1.20189443e-01f, 4.84819524e-02f, 2.47174874e-01f, -1.47788614e-01f, 5.11486828e-01f, -2.05513492e-01f, 8.75984952e-02f,
  7.62799308e-02f, 5.28815612e-02f, -2.02114090e-01f, 1.45189375e-01f, 1.39595091e-01f, 5.63878417e-02f, -1.26278684e-01f, 1.42427668e-01f, 1.13992959e-01f, -1.45838258e-03f,
  3.15535605e-01f, 3.63883168e-01f, 1.43543854e-01f, 1.81547344e-01f, 2.87562788e-01f, 1.52307704e-01f, 2.83739660e-02f, 2.56535858e-01f, -1.21775195e-01f, 2.49541670e-01f,
  -1.90531865e-01f, -2.16795310e-01f, -3.90634760e-02f, 1.32618040e-01f, 1.02988809e-01f, 1.11156911e-01f, 2.02459902e-01f, -7.31924502e-03f, 1.05649827e-03f, -1.84343867e-02f,
  -3.30776675e-03f, 1.01068459e-01f, -3.02341059e-02f, -1.08240157e-01f, 1.00653268e-01f, -1.72266200e-01f, 7.01952428e-02f, 2.39416733e-02f, -6.30050600e-02f, 1.03207774e-01f,
  -3.85442823e-02f, -3.22383642e-02f, 2.12910116e-01f, 1.10463150e-01f, 1.62372455e-01f, 6.50678277e-02f, -1.98217034e-01f, 6.46999627e-02f, 7.80427158e-02f, 4.49501991e-01f,
  3.18787843e-01f, -1.52384594e-01f, 3.07456046e-01f, -3.08239162e-01f, -1.92491114e-01f, 1.16822630e-01f, 6.52706742e-01f, 8.56894106e-02f, -1.21538229e-01f, 3.78680706e-01f,
  1.55290827e-01f, 9.36170697e-01f, -1.05781488e-01f, 2.15698138e-01f, -6.42202422e-02f, 3.24082583e-01f, -1.92719519e-01f, 2.43025705e-01f, -7.67919421e-02f, -1.30829774e-02f,
  1.24856189e-01f, -2.10353151e-01f, 1.37632862e-01f, 1.03634685e-01f, -5.35678081e-02f, -1.62505969e-01f, 9.83522385e-02f, -1.08312391e-01f, -1.10653199e-01f, -1.26730148e-02f,
  8.90642703e-02f, 1.12032615e-01f, 8.71204361e-02f, 6.22447655e-02f, -1.72673330e-01f, 9.55653470e-03f, -1.39021724e-01f, -1.09547772e-01f, -1.48773730e-01f, 1.32434573e-02f,
  -1.60298362e-01f, -1.20930500e-01f, -8.39018729e-03f, 8.98555964e-02f, 4.71630618e-02f, -2.99295448e-02f, -1.78623721e-01f, 6.38883486e-02f, -6.33387594e-03f, 7.24601001e-02f,
  9.80855972e-02f, -1.62404954e-01f, 1.61486611e-01f, 1.64593980e-01f, 1.07911296e-01f, -2.50617359e-02f, 2.87888587e-01f, 3.66303593e-01f, 4.95578311e-02f, 2.02921256e-01f,
  1.58899218e-01f, 3.00492942e-01f, -3.76742363e-01f, -2.28725106e-01f, -3.83055449e-01f, -9.18546468e-02f, -5.28568447e-01f, -1.34403676e-01f, 2.68460482e-01f, 2.00872734e-01f,
  -1.33765727e-01f, -5.53488582e-02f, -9.68707204e-02f, 1.28434390e-01f, -1.39637336e-01f, -4.54749823e-01f, 2.52556026e-01f, 6.85099900e-01f, -2.66761482e-01f, 6.30400002e-01f,
  1.14416167e-01f, -2.75312454e-01f, -1.30448684e-01f, 2.64518738e-01f, 2.75528103e-01f, 3.44870687e-01f, -2.05724254e-01f, -7.75306225e-02f, -8.69588479e-02f, -2.63504572e-02f,
  -2.04062201e-02f, 4.36012894e-02f, -1.79630592e-01f, 4.99393931e-03f, -2.00270310e-01f, -2.21937850e-01f, -8.55931938e-02f, -1.39633223e-01f, 1.74744815e-01f, 1.05500169e-01f,
  1.82332158e-01f, 1.06871426e-01f, -7.90339336e-03f, -1.36832958e-02f, -2.34302972e-02f, -9.45912823e-02f, 1.26506820e-01f, 3.66309322e-02f, -1.32079184e-01f, -1.08473629e-01f,
  1.54477566e-01f, -4.04863842e-02f, 1.20107763e-01f, -8.59096944e-02f, 1.72977433e-01f, -1.52291209e-01f, -4.52548303e-02f, 1.52355313e-01f, 5.89898899e-02f, -2.90331841e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.10062957e-01f, -1.02285326e-01f, 2.38685891e-01f, 1.75859496e-01f, 1.80192664e-01f, -1.26971558e-01f, -4.32037115e-02f, 1.01637177e-01f, 1.39188528e-01f, 2.37938151e-01f,
  9.81184021e-02f, 1.46548182e-01f, 1.87923819e-01f, -3.50773707e-02f, 1.63716227e-01f, 3.93820435e-01f, 1.26041457e-01f, 8.92338455e-02f, 1.58067927e-01f, 3.45285684e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.64870605e-01f, -7.04297097e-04f, -2.75419019e-02f, 2.32902303e-01f, 6.48918450e-02f, 1.23607479e-01f, 3.64035785e-01f, 4.79720980e-02f, -1.22474536e-01f, 2.18548030e-01f,
  8.78811479e-02f, -4.04639393e-02f, 1.60170272e-01f, -6.00734502e-02f, -1.04495689e-01f, 1.39933959e-01f, 4.43097018e-02f, 2.98744906e-02f, 9.63717420e-03f, 1.91773340e-01f,
  1.36825070e-01f, 5.02093807e-02f, 6.89787865e-02f, -2.49383447e-04f, 1.85215414e-01f, -9.44428220e-02f, -1.59019440e-01f, 1.87383354e-01f, -2.94207454e-01f, -1.19020179e-01f,
  4.07420039e-01f, 1.33596241e-01f, 1.52096584e-01f, 1.72355935e-01f, 5.91783114e-02f, -1.17411174e-01f, 1.45466596e-01f, 6.86904863e-02f, -8.39011669e-02f, -2.20099807e-01f,
  4.47564274e-02f, -1.43595785e-01f, -1.05238296e-01f, -9.53358188e-02f, 1.63946941e-01f, 7.53227621e-02f, 2.09130466e-01f, -1.73045829e-01f, -2.06132531e-01f, 4.37990688e-02f,
  -8.38329121e-02f, 9.96651426e-02f, 4.50981669e-02f, 2.26923972e-01f, 8.28211233e-02f, -1.59049869e-01f, -2.34824464e-01f, -1.95176721e-01f, 9.82509181e-02f, -9.90204513e-02f,
  2.79699504e-01f, -3.50617170e-02f, -3.74999225e-01f, -1.49564803e-01f, -2.91124638e-02f, -2.89154444e-02f, 9.54731181e-02f, 1.26098141e-01f, -4.33337642e-03f, 6.15914129e-02f,
  -2.29242489e-01f, 4.49308097e-01f, 7.93964192e-02f, -5.36503077e-01f, -1.83075994e-01f, 1.25714704e-01f, -4.37997915e-02f, -1.59185842e-01f, -1.60789058e-01f, -2.79607296e-01f,
  1.58304840e-01f, 9.05934721e-02f, 9.38121304e-02f, -1.79521590e-01f, 7.17923939e-02f, 1.29995108e-01f, -1.27088269e-02f, 2.54487544e-01f, 6.88153058e-02f, 7.15555996e-02f,
  2.60469705e-01f, 3.56757641e-02f, 2.90533472e-02f, -5.48816063e-02f, -2.74836898e-01f, 9.19083655e-02f, -8.91752690e-02f, 4.37987931e-02f, 1.40950352e-01f, -1.87297687e-01f,
  -1.95119858e-01f, -4.29048240e-02f, -2.20648021e-01f, 1.99096818e-02f, 3.11910152e-01f, -9.58683994e-03f, -1.33593142e-01f, 1.81208819e-01f, 1.55052587e-01f, -4.41116840e-02f,
  -6.80394471e-02f, -1.12900190e-01f, -1.67054668e-01f, -1.41764134e-01f, 1.29359081e-01f, 6.14239164e-02f, -6.74087331e-02f, 1.92239344e-01f, -5.78244925e-02f, 5.36122993e-02f,
  1.24018885e-01f, -1.65642351e-01f, -6.91855848e-02f, 6.26821220e-02f, 3.78993541e-01f, -5.00339679e-02f, -2.90329009e-01f, 3.96677814e-02f, -1.92363262e-01f, 7.00514391e-02f,
  -1.85005143e-01f, 3.46557260e-01f, 2.29446098e-01f, 1.60449725e-02f, -3.65566641e-01f, 1.13372251e-01f, -8.43311194e-03f, -5.06228507e-01f, -3.56977195e-01f, 8.59414935e-02f,
  -1.19249269e-01f, -6.29121438e-02f, 1.49120251e-02f, -2.59137422e-01f, 2.21135005e-01f, -1.78004459e-01f, -1.67883202e-01f, -1.60364613e-01f, 8.09199214e-02f, -1.03206731e-01f,
  1.43052742e-01f, 1.91174805e-01f, 8.45249817e-02f, 1.74201578e-01f, 4.09845524e-02f, -6.09785542e-02f, 1.86819300e-01f, -1.72217980e-01f, -1.08484544e-01f, -1.73366398e-01f,
  -1.17712438e-01f, -3.93694788e-01f, -3.39426011e-01f, 8.61813352e-02f, 1.27607867e-01f, -3.22520703e-01f, -1.54664647e-02f, 2.90487111e-01f, -3.52512822e-02f, -3.14743102e-01f,
  -2.67836034e-01f, 5.01799941e-01f, 1.74514055e-01f, 2.45884076e-01f, -9.61016566e-02f, -2.59478301e-01f, 3.18288237e-01f, -1.41430157e-03f, -1.16203904e-01f, 4.41328138e-02f,
  1.19042374e-01f, -2.54843801e-01f, 1.62445366e-01f, 1.83815062e-01f, 6.30582077e-03f, 2.53070951e-01f, 9.14763361e-02f, -2.03660041e-01f, -2.15623394e-01f, 1.18397541e-01f,
  1.27376571e-01f, 4.30652723e-02f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -2.05487370e-01f, 6.05595559e-02f, -2.28263736e-01f, 2.40128953e-02f, 1.13433972e-01f, -1.84116095e-01f, 2.02302650e-01f, -1.00380570e-01f, -3.31608243e-02f, -4.54812236e-02f,
  1.24179818e-01f, -7.24752694e-02f, 1.17018959e-02f, 2.45113373e-02f, -1.00723997e-01f, 5.96244186e-02f, -3.55167463e-02f, -9.07735154e-02f, 1.17643699e-01f, -1.85705479e-02f,
  1.50154710e-01f, 1.66202590e-01f, 1.26223946e-02f, -1.57161906e-01f, 8.54856670e-02f, -1.97561085e-02f, -1.02499001e-01f, 5.48874028e-02f, -3.98347937e-02f, 1.66783363e-01f,
  3.71279180e-01f, 2.27483939e-02f, -1.90956399e-01f, 1.54796526e-01f, -1.23599701e-01f, 6.10280298e-02f, 2.06942931e-01f, 1.07487418e-01f, 3.32714289e-01f, 2.87748158e-01f,
  -4.84591573e-01f, -1.97087884e-01f, -3.98131972e-03f, 8.03945139e-02f, 4.66060154e-02f, 3.53562593e-01f, -1.37172952e-01f, -1.02082416e-01f, 6.21754348e-01f, 3.91695462e-02f,
  1.24932162e-01f, 1.56191483e-01f, 5.02772808e-01f, -1.28586829e-01f, -1.87448591e-01f, -1.27456024e-01f, 1.77385911e-01f, 1.58966724e-02f, -6.33414537e-02f, -1.54529750e-01f,
  -8.16214457e-02f, 1.22344382e-01f, 7.53949702e-01f, 1.67632818e-01f, 2.00557970e-02f, -1.28821328e-01f, 2.59080291e-01f, -2.83140302e-01f, -1.80250108e-01f, -6.59345388e-02f,
  -8.50653723e-02f, -3.06412458e-01f, 1.34350406e-02f, 4.01270129e-02f, 2.04143941e-01f, -2.06592500e-01f, -4.62766876e-03f, -8.86763856e-02f, 8.68542865e-02f, 1.80828899e-01f,
  -2.10343495e-01f, -1.54787824e-01f, 1.81625485e-01f, -4.83650714e-02f, 3.32703441e-02f, 1.77699804e-01f, 1.25479385e-01f, 1.11875743e-01f, -1.23368025e-01f, 3.53035592e-02f,
  1.33033648e-01f, -2.06846595e-02f, 1.35497972e-01f, 9.06305015e-02f, 2.92139769e-01f, -3.70107293e-02f, -8.23997781e-02f, 2.24160142e-02f, 1.29737392e-01f, -4.25056778e-02f,
  4.75293398e-02f, 9.91153419e-02f, -1.10682264e-01f, 4.84113246e-02f, 3.30007188e-02f, 3.68221626e-02f, 1.66066676e-01f, -4.56667680e-04f, -8.80495757e-02f, 1.13946505e-01f,
  2.42160112e-01f, 7.15223551e-02f, -1.43056244e-01f, -1.91752598e-01f, -1.42734975e-01f, 1.72812399e-03f, -1.37740761e-01f, 1.08456232e-01f, 1.67601779e-01f, -7.69338757e-02f,
  -1.66284628e-02f, -3.95706668e-02f, -3.38357389e-02f, -1.00583797e-02f, 1.55786619e-01f, 1.46563828e-01f, -1.72516763e-01f, 2.60625649e-02f, 1.29880771e-01f, 2.53191262e-01f,
  -8.19987506e-02f, 1.02902107e-01f, 2.12667175e-02f, 1.53545961e-01f, 2.34792769e-01f, -1.77337810e-01f, -1.81501016e-01f, -1.22151539e-01f, 3.35868960e-03f, -8.78435746e-02f,
  -9.92095992e-02f, 1.00307785e-01f, 6.69343248e-02f, -2.14067418e-02f, 3.35547104e-02f, -1.00169435e-01f, -1.08731590e-01f, 2.94209737e-02f, 8.22968334e-02f, -1.56814113e-01f,
  -1.65779099e-01f, -1.79913864e-01f, -2.09653005e-02f, -5.05700298e-02f, -1.18376575e-01f, 2.02870861e-01f, 5.49842715e-02f, -2.25778241e-02f, -2.76800636e-02f, -1.91287935e-01f,
  3.70002501e-02f, -1.01137593e-01f, -9.97808650e-02f, -1.58274412e-01f, -1.78222526e-02f, 8.75338465e-02f, 1.76967546e-01f, -1.81875169e-01f, -1.84403688e-01f, 1.98806927e-01f,
  1.66294247e-01f, 3.20458300e-02f, -5.02722710e-02f, 3.74014750e-02f, -1.39179498e-01f, 2.13472337e-01f, -3.19123864e-02f, -5.24464399e-02f, 9.52216610e-02f, -2.51016729e-02f,
  2.11965606e-01f, 3.62318158e-02f, 4.83443178e-02f, 8.64299983e-02f, 7.06351176e-02f, -1.80121005e-01f, -7.92588964e-02f, 1.82521194e-01f, -2.90959448e-01f, -1.41919866e-01f,
  3.35145503e-01f, -6.35174140e-02f, -2.25834966e-01f, -3.80443782e-02f, -8.22787881e-02f, -2.56815404e-01f, 1.18358232e-01f, -5.27412184e-02f, -1.45166695e-01f, 3.30688693e-02f,
  -1.40044289e-02f, 5.10798469e-02f, -2.09838804e-02f, 3.84270698e-02f, -8.31946805e-02f, -1.07195564e-01f, -4.25073393e-02f, 1.56454802e-01f, 6.41807020e-02f, 7.23030716e-02f,
  2.30729237e-01f, -3.35417092e-02f, 2.96425134e-01f, 1.12206377e-01f, 1.20212115e-01f, 1.72544181e-01f, 4.59216237e-02f, -8.50734934e-02f, 1.43476948e-01f, -1.95624337e-01f,
  4.48040128e-01f, -5.10761142e-03f, 8.86165947e-02f, 1.22483924e-01f, 1.72920730e-02f, 7.40178954e-03f, -1.30308032e-01f, -5.97363599e-02f, -6.72303736e-02f, 1.99795499e-01f,
  -1.54434398e-01f, -4.36326265e-02f, 2.42724761e-01f, -3.41606796e-01f, -1.62761867e-01f, 1.16716132e-01f, -1.74983919e-01f, -1.79577336e-01f, 1.63194433e-01f, -2.33737767e-01f,
  6.87354431e-02f, 8.12658146e-02f, 1.38688833e-02f, -5.43051697e-02f, 1.85717553e-01f, 4.55858931e-03f, 3.53562180e-03f, 2.20686957e-01f, -2.32510120e-01f, 1.02751501e-01f,
  1.05004750e-01f, -1.60965323e-01f, 5.12057245e-01f, 2.64409985e-02f, -1.17481247e-01f, 3.63427214e-02f, 8.84315073e-02f, 2.17403620e-01f, 2.49110982e-01f, 1.42972395e-01f,
  3.22746664e-01f, 3.56754631e-01f, 2.90958583e-01f, -2.92440444e-01f, -2.44297445e-01f, 4.65776712e-01f, 3.23374957e-01f, -2.60992318e-01f, -1.46109909e-01f, 7.98750967e-02f,
  3.75316143e-01f, 4.14212435e-01f, 9.44061503e-02f, -9.25749615e-02f, -1.62383586e-01f, 4.31442447e-02f, 8.56540203e-02f, -6.12872019e-02f, 2.20507324e-01f, -7.10743442e-02f,
  -2.29746863e-01f, -1.73757613e-01f, -3.45811993e-02f, 2.83458710e-01f, -2.62084957e-02f, -1.58025473e-01f, 6.82969034e-01f, -2.28774667e-01f, -3.98769453e-02f, 1.70355923e-02f,
  2.02866718e-01f, -4.36568707e-02f, -1.25081344e-02f, 4.35817204e-02f, 9.68409106e-02f, 1.80498898e-01f, -2.04457030e-01f, 3.58444569e-03f, 2.23745286e-01f, 1.59350887e-01f,
  -7.74605796e-02f, 1.30130529e-01f, -8.64702240e-02f, 7.56716132e-02f, 1.21426500e-01f, -1.03543043e-01f, 1.25348061e-01f, -1.75861213e-02f, -3.63554992e-02f, 8.49108994e-02f,
  -9.55963507e-02f, 1.43568054e-01f, 2.44925082e-01f, -1.24364242e-01f, -1.20574236e-01f, 1.42494202e-01f, -3.13809812e-01f, -1.23231009e-01f, 2.78225332e-01f, 7.38455355e-02f,
  -5.50326966e-02f, -1.35808149e-02f, -3.01695168e-02f, -9.83438194e-02f, -7.78048411e-02f, -1.79186657e-01f, -2.90320575e-01f, 1.61796749e-01f, -8.02347530e-03f, -3.63131166e-01f,
  -2.43130893e-01f, 2.09564343e-02f, -1.01539113e-01f, -1.80715509e-02f, 1.97211429e-01f, -4.22817701e-03f, 2.19068393e-01f, 1.28822833e-01f, 1.79987699e-01f, -5.37761999e-03f,
  1.32301331e-01f, -1.25361234e-03f, 1.30893320e-01f, 2.33091012e-01f, -1.57776505e-01f, 7.84951523e-02f, 3.89804333e-01f, -1.24693282e-01f, 4.73699868e-01f, 1.65737823e-01f,
  -2.18228295e-01f, 1.18938737e-01f, 1.67539671e-01f, -1.47170469e-01f, 3.15265745e-01f, 2.72869825e-01f, 1.96540616e-02f, 1.84632793e-01f, -4.37300950e-01f, 5.40948868e-01f,
  9.47048962e-02f, -9.17201638e-02f, -2.00146720e-01f, 4.87217367e-01f, -2.19030157e-01f, 1.42952383e-01f, -1.72234073e-01f, -2.02947780e-01f, 1.31766364e-01f, 1.10553177e-02f,
  1.88001037e-01f, -2.42835566e-01f, 3.64396304e-01f, -2.44812548e-01f, -1.28557369e-01f, 3.99941355e-01f, 4.92978618e-02f, 8.61132368e-02f, -4.83003557e-02f, 4.69188206e-02f,
  7.51548260e-02f, -1.04540341e-01f, -2.69650429e-01f, 5.41603472e-03f, 3.63363087e-01f, 2.58619040e-01f, 2.74610609e-01f, -1.50125578e-01f, 2.14682217e-03f, 4.73634154e-02f,
  4.15777504e-01f, -2.28390411e-01f, -1.22276552e-01f, 5.86985469e-01f, 3.79318148e-01f, -2.76614010e-01f, 4.19996073e-03f, -1.36425242e-01f, 2.94770241e-01f, 1.61575705e-01f,
  -1.21475816e-01f, -5.57491519e-02f, 2.28888579e-02f, -6.46188110e-02f, -2.08338812e-01f, 8.01409967e-03f, 6.57317638e-02f, 8.49283263e-02f, 6.83487579e-02f, -1.33296803e-01f,
  -3.13316323e-02f, 2.28466406e-01f, -1.93546385e-01f, 1.54049158e-01f, 7.32385457e-01f, 2.40707248e-02f, 1.53935641e-01f, -2.19708905e-02f, 4.14435416e-01f, 2.49434873e-01f,
  2.75727868e-01f, -1.56243280e-01f, -2.49161422e-01f, 6.80277467e-01f, -1.67754769e-01f, 1.46411017e-01f, -2.54476070e-01f, 7.05565274e-01f, -2.23177642e-01f, 1.87246799e-01f,
  -4.00136471e-01f, -2.27673590e-01f, 5.68009734e-01f, 1.82561681e-01f, 2.25361273e-01f, -2.29136005e-01f, 5.68288684e-01f, -9.81573164e-02f, -2.66193330e-01f, 4.01769787e-01f,
  4.54042614e-01f, -1.25095677e-02f, -7.03406632e-02f, -7.43791908e-02f, -2.31668025e-01f, 9.21336710e-02f, 1.02009296e-01f, -5.82718067e-02f, 1.60054892e-01f, 4.41262811e-01f,
  4.42769557e-01f, 5.81843615e-01f, 5.32478213e-01f, 3.19903225e-01f, -6.15351021e-01f, 2.18547925e-01f, 6.69610918e-01f, 5.25629967e-02f, -9.16960016e-02f, -2.12487668e-01f,
  -2.86953803e-03f, -1.73175290e-01f, 5.09228647e-01f, -1.06174767e-01f, -2.24552840e-01f, -2.33777419e-01f, -1.10837765e-01f, 1.72313839e-01f, -3.56339037e-01f, 2.55216420e-01f,
  2.51261801e-01f, -5.84684126e-03f, -1.18887968e-01f, -2.00895220e-01f, 5.75644374e-01f, 4.74809498e-01f, 5.69697618e-01f, -4.09086607e-02f, -1.87250569e-01f, -1.85422897e-01f,
  6.00847416e-02f, -1.68419451e-01f, 1.94848746e-01f, -1.53494343e-01f, -1.26930222e-01f, 2.23105438e-02f, 1.04743764e-01f, -7.74449408e-02f, 1.34836018e-01f, 2.80451417e-01f,
  1.19163230e-01f, -2.37739295e-01f, 1.49393648e-01f, -1.27384998e-02f, 3.13960075e-01f, 2.53639460e-01f, -5.97868953e-03f, -1.40439019e-01f, 1.17177725e-01f, -1.67020872e-01f,
  1.13166735e-01f, 2.28323758e-01f, 1.08796246e-01f, 2.08456554e-02f, 3.02912854e-02f, -4.58085835e-02f, 7.77721554e-02f, 1.52782381e-01f, 3.66552889e-01f, -3.63771128e-03f,
  -4.28188108e-02f, -1.23259217e-01f, 8.12039003e-02f, 5.14483787e-02f, -1.13522440e-01f, 7.33380243e-02f, 1.02615781e-01f, 1.60065852e-02f, -6.71145096e-02f, -2.36785248e-01f,
  1.82930958e-02f, -1.47604221e-03f, 1.74618438e-01f, 2.35817395e-02f, 1.66752324e-01f, 3.12932283e-02f, 1.77565087e-02f, 1.82410851e-01f, -1.73371524e-01f, -1.47196382e-01f,
  -4.33676131e-02f, -1.55869603e-01f, 1.36265397e-01f, 3.30007188e-02f, 2.04229597e-02f, 1.44360662e-01f, 2.56410856e-02f, -7.40168020e-02f, -1.12046368e-01f, -4.37086485e-02f,
  1.53318852e-01f, 1.25373751e-01f, -1.41587034e-01f, 1.39689371e-01f, -1.61979631e-01f, -6.29794821e-02f, -2.13234887e-01f, -1.78484648e-01f, 7.63778314e-02f, 6.52910545e-02f,
  8.34003612e-02f, 1.59526661e-01f, 1.04964726e-01f, -3.64754826e-01f, -2.87676714e-02f, 1.30414888e-01f, -8.20970088e-02f, 6.68276027e-02f, 2.19513282e-01f, 1.26762271e-01f,
  2.39154086e-01f, 8.17566831e-03f, -1.46055788e-01f, -8.48555565e-02f, 3.95491362e-01f, -1.12623245e-01f, 1.47765577e-01f, -2.38584578e-02f, -1.22058131e-01f, -1.04439639e-01f,
  1.29554406e-01f, -1.75683871e-01f, 4.78284299e-01f, -1.62627518e-01f, -2.27085520e-02f, -1.24626316e-01f, 4.75614160e-01f, 3.09880286e-01f, 4.28175151e-01f, 3.69277060e-01f,
  4.10479754e-01f, 5.20409048e-01f, -3.07676941e-01f, 4.90095258e-01f, 4.21033293e-01f, 5.27336821e-02f, -1.28319547e-01f, 1.84485316e-01f, -1.71460539e-01f, 4.16053832e-02f,
  -3.36815864e-02f, 1.00149754e-02f, -2.41262898e-01f, -4.84291315e-02f, -1.94653273e-01f, 6.90503269e-02f, -2.73368154e-02f, -1.12260826e-01f, 1.65902108e-01f, 7.91840851e-02f,
  3.23194444e-01f, 7.80926570e-02f, 3.38622034e-01f, 3.22454780e-01f, -3.42453629e-01f, 1.01378456e-01f, 4.59585339e-02f, -5.15142176e-03f, -1.32557660e-01f, 3.25273238e-02f,
  1.39408350e-01f, 8.84196833e-02f, -1.06623866e-01f, -3.32760550e-02f, -2.11114988e-01f, 3.63318086e-01f, 2.11054400e-01f, -2.69791633e-01f, -2.75433332e-01f, 2.39441186e-01f,
  -1.00137398e-01f, 9.51012969e-02f, -7.43677169e-02f, -1.39425412e-01f, 4.41419706e-02f, 2.51241550e-02f, -9.25512910e-02f, 1.17056683e-01f, 2.53122717e-01f, -2.19381340e-02f,
  -1.30462319e-01f, 9.40409526e-02f, -1.18371740e-01f, 1.91421613e-01f, 4.94470634e-02f, 4.55234610e-02f, 2.01840788e-01f, -2.22229231e-02f, -1.98973671e-01f, 1.35225341e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  -1.10652491e-01f, 1.78387061e-01f, 4.06402163e-02f, -4.05547721e-03f, 4.81405389e-03f, 1.16093345e-01f, -7.20571131e-02f, 5.39227016e-02f, 2.86466748e-01f, 1.52248284e-02f,
  1.92165509e-01f, 2.43267089e-01f, 2.74673998e-01f, 4.51828271e-01f, 4.00272518e-01f, -7.91864619e-02f, 1.84216857e-01f, 2.08354723e-02f, 4.51520354e-01f, -3.06487945e-03f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.32399166e-01f, -1.30285650e-01f, -3.35824102e-01f, 6.62206411e-02f, -3.73343259e-01f, 1.53126672e-01f, -7.23209620e-01f, 4.14159179e-01f, 5.69684684e-01f, 3.98333490e-01f,
  9.06797498e-02f, -1.26501471e-01f, -1.98346138e-01f, -3.45942289e-01f, -1.12413494e-02f, 2.46902168e-01f, -3.30470279e-02f, -1.10572353e-02f, -1.24311596e-01f, 3.51205468e-01f,
  -7.35434473e-01f, -2.08974540e-01f, 3.48506778e-01f, -5.41506596e-02f, -5.12155533e-01f, -6.55330062e-01f, 8.12549710e-01f, -1.42245427e-01f, -1.20636038e-01f, 2.74689551e-02f,
  3.01773220e-01f, 2.05926374e-01f, 1.23735122e-01f, 4.73485708e-01f, 5.86104929e-01f, 1.34379178e-01f, 7.35546887e-01f, 1.14456154e-01f, 6.79823935e-01f, 1.28768623e-01f,
  -4.46472168e-01f, -4.79416430e-01f, 2.79581577e-01f, -6.52706802e-01f, 1.38345538e-02f, -9.31630507e-02f, -2.55387604e-01f, 8.92786682e-02f, 2.59117573e-01f, -7.04376400e-02f,
  -5.54863885e-02f, -1.12961225e-01f, 5.96610785e-01f, -8.44555795e-02f, -3.04571778e-01f, -2.19398886e-01f, 1.45286515e-01f, -4.60778028e-01f, 4.12906408e-01f, -7.90296942e-02f,
  -5.76698519e-02f, 1.45648435e-01f, 6.94064617e-01f, -3.69077414e-01f, -2.79528588e-01f, -3.37268084e-01f, -3.87696117e-01f, -3.84888351e-01f, -2.52976656e-01f, 1.83139220e-01f,
  1.12938909e-02f, -4.13485408e-01f, -4.75964099e-01f, -3.96226048e-01f, -6.17819369e-01f, -1.55690774e-01f, 1.14107527e-01f, 9.54565778e-02f, 2.75193870e-01f, -1.68868020e-01f,
  -1.82033591e-02f, 3.48944843e-01f, -3.51758897e-02f, -5.97280078e-02f, 4.24681127e-01f, 3.56303036e-01f, -1.54706016e-01f, -2.75958538e-01f, 6.33778393e-01f, -3.92959952e-01f,
  -6.67244613e-01f, 6.45233667e-04f, 8.43849906e-04f, -3.83649379e-01f, -1.80503279e-01f, 6.86370954e-02f, 1.50111109e-01f, -4.40838873e-01f, 2.95717508e-01f, 1.61849573e-01f,
  1.93220675e-01f, -7.26639152e-01f, -4.49534446e-01f, 3.09051216e-01f, -4.12462912e-02f, 3.95091861e-01f, 7.88955614e-02f, -3.96686345e-01f, 1.77055039e-02f, -2.77822137e-01f,
  -1.65611841e-02f, 2.40550205e-01f, -9.99356210e-02f, -2.91534007e-01f, 1.29532203e-01f, 3.37116607e-02f, 1.08405352e-01f, -2.27604806e-01f, 2.56227492e-03f, -1.67944625e-01f,
  -2.02236384e-01f, -4.56101060e-01f, 8.12725425e-01f, 4.17345673e-01f, 6.94986582e-02f, -1.61451846e-01f, -1.45800129e-01f, -1.92219198e-01f, 1.21970065e-02f, 2.25863531e-01f,
  -2.79720187e-01f, 5.45867607e-02f, -1.72871754e-01f, -4.39001108e-03f, -7.06816852e-01f, 6.79500997e-01f, 1.86870173e-01f, 2.77346522e-01f, -1.55366780e-02f, 3.09723079e-01f,
  -1.51490584e-01f, -2.21392170e-01f, 1.56461187e-02f, 1.85731128e-02f, 3.14925723e-02f, -5.93523793e-02f, 2.31986061e-01f, 2.73994207e-01f, -1.87864989e-01f, -1.82382956e-01f,
  2.85385996e-01f, 6.74997985e-01f, -2.40276337e-01f, 1.69716358e-01f, 1.22014515e-01f, 9.23967659e-02f, 3.79927233e-02f, 2.94271201e-01f, -3.86294752e-01f, 3.96840394e-01f,
  4.68862116e-01f, 4.36618626e-01f, 3.55072260e-01f, 2.84302473e-01f, 2.07925051e-01f, 6.63209379e-01f, 1.05073877e-01f, -1.87271222e-01f, 5.21444261e-01f, -2.78341696e-02f,
  4.59602565e-01f, -3.72255966e-02f, -7.89240748e-02f, -1.95135847e-01f, -3.06581736e-01f, 2.10964456e-02f, -2.39196625e-02f, -1.04558334e-01f, -1.75584570e-01f, -6.78221509e-02f,
  -1.58325031e-01f, -3.20004523e-02f, -7.52944499e-02f, 4.28601950e-01f, -4.05599296e-01f, 3.92735183e-01f, 5.30185997e-01f, -8.09051171e-02f, -1.46296844e-01f, -5.03343605e-02f,
  7.70380139e-01f, 8.79148617e-02f, 1.75500289e-03f, 9.07708053e-03f, 6.48662567e-01f, 1.45069435e-01f, 4.22811717e-01f, -9.88601893e-03f, 6.32991850e-01f, -5.35340250e-01f,
  3.14046323e-01f, -5.12389719e-01f, 2.19024360e-01f, 2.80062199e-01f, -8.98007955e-03f, 2.55264193e-01f, -4.09913063e-03f, -4.92855012e-02f, -1.74815536e-01f, 1.59255758e-01f,
  -2.27234438e-01f, -3.69073242e-01f, -2.08812132e-01f, 3.59638691e-01f, -3.37974638e-01f, 1.69332728e-01f, -3.62565275e-03f, 8.81319284e-01f, -5.83768904e-01f, 3.73057015e-02f,
  -1.17022961e-01f, -2.42170453e-01f, 2.58504897e-01f, -1.06787197e-01f, -7.66315103e-01f, -5.14238417e-01f, -3.60281646e-01f, -2.10892156e-01f, -9.79603976e-02f, -2.95133829e-01f,
  -1.78894371e-01f, -6.53712898e-02f, 2.23701164e-01f, 4.93857414e-02f, -1.62225172e-01f, -1.37419313e-01f, -9.34646130e-02f, -1.35395482e-01f, 2.43511781e-01f, -8.05898383e-02f,
  8.12623277e-02f, -2.07366705e-01f, 4.29217249e-01f, 5.44050515e-01f, -3.26748133e-01f, -3.26494761e-02f, 5.44954538e-01f, -2.01823696e-01f, -2.90589273e-01f, -3.55710387e-01f,
  -2.55239040e-01f, 3.61989200e-01f, 2.28967667e-02f, 5.46488464e-01f, -5.65464079e-01f, -4.97189641e-04f, -8.91467929e-02f, -5.06351113e-01f, -6.66971445e-01f, -4.70073551e-01f,
  -1.15931742e-01f, -3.77575397e-01f, -3.11231297e-02f, -1.38636142e-01f, -5.35787679e-02f, 2.71788418e-01f, -6.54568300e-02f, 5.46568274e-01f, 4.10109460e-01f, 3.17918807e-01f,
  1.25004072e-02f, 5.47471121e-02f, -2.01401755e-01f, 2.69533575e-01f, 3.12350899e-01f, -1.97298825e-01f, 2.40521520e-01f, -8.51578563e-02f, 9.22462046e-02f, -3.50937843e-02f,
  -1.45522114e-02f, -2.92695433e-01f, -3.55402648e-01f, 1.40934616e-01f, -1.66777402e-01f, 3.20341170e-01f, -3.64067107e-01f, -1.06593832e-01f, 6.60141289e-01f, 3.99567664e-01f,
  -1.64434016e-01f, 2.48868734e-01f, -3.89619470e-01f, -4.42993566e-02f, -1.83456880e-03f, -5.97559698e-02f, 5.07969618e-01f, -1.24267571e-01f, 2.31953993e-01f, 1.49378926e-01f,
  -1.89953446e-01f, 1.82932630e-01f, 2.07799636e-02f, -1.90922067e-01f, 1.71353091e-02f, -2.80263484e-01f, 1.79934219e-01f, 2.44425684e-02f, -3.71511757e-01f, 3.01686525e-02f,
  3.31227958e-01f, 5.83954990e-01f, -5.60865819e-01f, 6.78039551e-01f, -6.03885531e-01f, -5.04623987e-02f, 6.00073533e-03f, -5.51142264e-03f, -1.43923342e-01f, 2.72561699e-01f,
  1.30563408e-01f, 4.23710138e-01f, -4.63875800e-01f, 3.20572615e-01f, 1.15611954e-02f, -3.73423785e-01f, 4.30100620e-01f, -3.91578376e-02f, -7.72136331e-01f, -3.47926617e-01f,
  -6.58078134e-01f, -1.31907940e-01f, -7.19831884e-02f, -7.52740026e-01f, 3.17287147e-01f, 2.32156917e-01f, 2.05147579e-01f, -1.87726617e-02f, -1.71162710e-01f, -5.90477660e-02f,
  5.18673539e-01f, -2.30180591e-01f, -4.11018357e-02f, -4.46650624e-01f, 6.70658886e-01f, -2.61542320e-01f, -8.69537517e-03f, 4.00275767e-01f, 1.65141523e-01f, -2.64329731e-01f,
  -1.79299012e-01f, -1.54783428e-01f, -3.61282527e-01f, 1.09822787e-01f, 4.64358270e-01f, -5.41332781e-01f, -9.09984410e-02f, 1.26765132e-01f, 1.93631545e-01f, -3.36975098e-01f,
  -7.22516894e-01f, -4.51794207e-01f, 2.22372130e-01f, 4.62438077e-01f, -1.20262839e-02f, 8.59240592e-01f, -3.69484544e-01f, -2.21674681e-01f, 2.60657698e-01f, -7.69487349e-03f,
  -2.00099424e-01f, 5.74325435e-02f, 3.05941820e-01f, -7.15791211e-02f, -2.37779915e-01f, -3.02192867e-01f, -7.89547991e-03f, 1.38119012e-01f, -5.42889595e-01f, -3.44023615e-01f,
  -1.53189346e-01f, -8.11399594e-02f, -3.39740425e-01f, -5.65773882e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.18726592e-04f, 9.66553167e-02f, -1.58236757e-01f, 2.17926696e-01f, 2.81385751e-03f, 2.55310148e-01f, 1.05164155e-01f, -2.35417247e-01f, -3.62425447e-01f, -2.80447062e-02f,
  -4.73737456e-02f, 9.19720456e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    