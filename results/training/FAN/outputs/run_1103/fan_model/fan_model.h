/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.18876037e-02f, 1.29912615e-01f, 4.04499471e-02f, -2.44365111e-01f, -5.32647111e-02f, 3.95602547e-02f, 2.74774492e-01f, 1.15242869e-01f, -9.22184438e-02f, 1.29836261e-01f,
  -9.15089697e-02f, -1.22865960e-01f, -1.80166006e-01f, -8.90161395e-02f, 1.85186297e-01f, 2.21125305e-01f, 1.46711260e-01f, -1.87958293e-02f, 7.34317079e-02f, -9.70826391e-03f,
  -1.58037230e-01f, -1.13455556e-01f, -1.10663176e-01f, 3.17041874e-02f, 9.26415399e-02f, 1.56541392e-02f, -3.99813317e-02f, 1.71901938e-02f, 1.76966026e-01f, 1.73901953e-02f,
  6.89259395e-02f, 1.29547998e-01f, -3.02555636e-02f, -1.64955426e-02f, -5.23864105e-02f, -5.21906316e-02f, -6.31253123e-02f, 8.97811875e-02f, -5.46229556e-02f, 3.07556260e-02f,
  9.88323800e-03f, -1.82702951e-02f, -1.61278933e-01f, -6.73681637e-03f, 4.31216210e-02f, 3.08370925e-02f, 6.94753528e-02f, 5.97101590e-03f, 1.27771974e-01f, 1.17656253e-01f,
  -8.62720534e-02f, -8.50148126e-02f, 3.78813618e-03f, 7.27156252e-02f, 1.21582665e-01f, -2.77532414e-02f, 1.71032876e-01f, 1.52619109e-01f, 6.25686273e-02f, 1.68649897e-01f,
  -4.86285950e-04f, -6.85162395e-02f, 2.72408333e-02f, -1.28114611e-01f, -8.79658535e-02f, -9.12440121e-02f, -7.66988918e-02f, 2.84140687e-02f, 6.44952655e-02f, 4.96750772e-02f,
  -1.17817625e-01f, -2.51332875e-02f, 5.94471395e-02f, 4.72614169e-02f, -2.76825950e-02f, 3.09637189e-02f, 9.01072402e-04f, 9.61012691e-02f, 3.63238491e-02f, -4.71212342e-02f,
  1.20276086e-01f, -1.02541607e-03f, 6.51170164e-02f, 3.34190950e-02f, -3.40603180e-02f, -7.37706423e-02f, -3.75702046e-02f, 4.73489240e-02f, -9.83209163e-02f, -2.72396747e-02f,
  2.76308954e-02f, -6.06440902e-02f, 1.57182455e-01f, 7.99120869e-04f, 1.04966154e-02f, 5.24099022e-02f, -8.37505534e-02f, 4.75392416e-02f, -1.00040033e-01f, -2.07933392e-02f,
  8.83020833e-02f, -3.76188718e-02f, 2.13403404e-02f, -1.08862789e-02f, -1.01994641e-01f, -2.12776903e-02f, 4.90586832e-02f, -3.14051621e-02f, 5.61823249e-02f, -1.71487276e-02f,
  -8.14740211e-02f, 6.76052794e-02f, 1.18555911e-01f, 7.12416470e-02f, -7.00918064e-02f, -6.39633462e-02f, 1.46613538e-01f, 1.49770305e-01f, 1.25832111e-01f, 1.85982436e-01f,
  -5.24692714e-01f, -3.48055929e-01f, 6.16567060e-02f, -2.37523820e-02f, 1.54423147e-01f, -1.83894373e-02f, -2.70685196e-01f, -3.81932706e-02f, 1.53550088e-01f, -1.20221175e-01f,
  1.98224917e-01f, 3.38581443e-01f, 2.81547606e-01f, 8.97810534e-02f, 2.29580738e-02f, -2.85058707e-01f, -5.00137135e-02f, 8.74263123e-02f, 9.79309455e-02f, 1.03912994e-01f,
  1.59136243e-02f, -4.69774194e-02f, -1.03766210e-02f, 9.91526097e-02f, -1.69694483e-01f, 1.77244842e-01f, 7.57243335e-02f, -7.69788912e-03f, 6.36603907e-02f, -1.48007557e-01f,
  4.41171229e-02f, -1.47342697e-01f, 1.05184607e-01f, 7.82061964e-02f, 7.62577206e-02f, 1.22207552e-02f, -1.18457861e-02f, -9.20192897e-02f, 6.93513155e-02f, 1.26259308e-02f,
  7.02888146e-02f, 6.54360726e-02f, 2.34933384e-02f, 7.27024898e-02f, -1.54969692e-01f, 3.43790427e-02f, 4.17038277e-02f, -3.76726165e-02f, -2.64351815e-02f, -1.36949912e-01f,
  9.79337841e-02f, 6.19708784e-02f, -1.10180400e-01f, 1.29249111e-01f, 1.55925423e-01f, 1.24386512e-01f, 5.10837995e-02f, 1.07012525e-01f, 1.07947841e-01f, -9.14945975e-02f,
  4.85826321e-02f, 3.32430154e-02f, 3.86062637e-02f, -1.68463716e-03f, 2.75704302e-02f, 9.89527162e-03f, -1.89472027e-02f, -3.01129445e-02f, -1.89437543e-03f, -7.76525363e-02f,
  -9.07077640e-02f, -1.44599900e-01f, -2.32155714e-03f, -6.00891039e-02f, 5.92708075e-03f, 3.07951961e-02f, -8.23279098e-02f, 4.71404120e-02f, -6.61433488e-02f, 8.06665048e-02f,
  -2.87132952e-02f, -2.01284103e-02f, 4.76998501e-02f, -4.12551537e-02f, 9.44186598e-02f, 6.66719452e-02f, 4.28639259e-03f, 6.88293367e-04f, -2.03793030e-02f, 6.75090924e-02f,
  1.54295668e-01f, 2.17578247e-01f, -2.33594477e-02f, -4.33703512e-02f, -5.71742766e-02f, 5.75139001e-03f, -1.16418958e-01f, 2.94442866e-02f, 3.34364474e-02f, -2.70415526e-02f,
  1.86181068e-02f, 7.65048573e-03f, -1.16161481e-01f, -9.99076143e-02f, -5.91038093e-02f, 3.19987126e-02f, 3.73525359e-02f, 5.11922836e-02f, 9.10238773e-02f, -3.46383564e-02f,
  5.95713891e-02f, -1.45807192e-01f, -4.03389260e-02f, -1.79220419e-02f, -4.74193506e-02f, 7.17950836e-02f, -8.83878469e-02f, 4.71834727e-02f, 8.65541026e-02f, -2.59950280e-01f,
  -5.95444679e-01f, 2.21730098e-01f, 1.18104249e-01f, -3.63845408e-01f, 2.19872653e-01f, 1.40470356e-01f, 4.23532665e-01f, -2.10880637e-02f, -2.23584473e-01f, 1.54892579e-01f,
  1.24849632e-01f, -2.05535173e-01f, -9.83176455e-02f, -1.04401357e-01f, -3.12103778e-02f, 2.43075624e-01f, 1.83916882e-01f, -1.49238831e-03f, -2.57585019e-01f, -2.42476426e-02f,
  1.89722121e-01f, -2.73692105e-02f, -1.87171727e-01f, -1.27281889e-01f, 1.39914632e-01f, -6.51241243e-02f, 7.71123096e-02f, 1.36850387e-01f, 1.34942144e-01f, 2.18460083e-01f,
  2.06702314e-02f, -1.45638241e-02f, -1.05358526e-01f, -1.03382312e-01f, 8.80791098e-02f, -5.19802459e-02f, 2.30065966e-03f, -9.20871496e-02f, -5.57130091e-02f, 4.29288112e-02f,
  -2.96267942e-02f, -6.02656007e-02f, -7.17319027e-02f, -1.88719854e-02f, -6.85763806e-02f, -1.41749186e-02f, -1.57781597e-02f, -7.50076026e-03f, 8.11704174e-02f, 1.25325862e-02f,
  8.02914500e-02f, 8.16991851e-02f, 6.56424463e-02f, 7.81105608e-02f, 6.24142848e-02f, -1.63492039e-02f, -1.72090679e-02f, -1.03330920e-02f, 7.89285265e-03f, 5.68783954e-02f,
  -4.70819026e-02f, 1.22074842e-01f, -1.81374792e-03f, -1.82136614e-03f, -5.07399105e-02f, -1.47414403e-02f, 4.75948416e-02f, 2.46189926e-02f, -4.45412397e-02f, 6.76162392e-02f,
  2.15721279e-02f, -1.43826921e-02f, 3.05227209e-02f, -5.62551431e-03f, 2.12567635e-02f, 7.95456693e-02f, -1.85353924e-02f, 5.79960421e-02f, -3.66204642e-02f, -4.18215021e-02f,
  -4.42785881e-02f, 7.36220181e-02f, -4.61991802e-02f, 4.34958823e-02f, -7.72720575e-02f, 3.95613648e-02f, -2.51804590e-02f, -2.92539429e-02f, 5.51847517e-02f, 9.57198814e-02f,
  -1.15827717e-01f, 1.39838066e-02f, -2.24328525e-02f, 1.46743339e-02f, 7.16220634e-03f, 4.51967157e-02f, 8.22398290e-02f, -8.00852999e-02f, 1.52189275e-02f, 4.74878252e-02f,
  -7.53569752e-02f, -9.14184004e-02f, 5.09988144e-02f, 6.75238520e-02f, -3.26199196e-02f, 2.29669487e-04f, -3.66623374e-03f, -9.82080549e-02f, -5.06942421e-02f, 1.72796641e-02f,
  -4.41457853e-02f, -6.16952814e-02f, -3.62928323e-02f, -6.62852153e-02f, -8.31794366e-02f, -1.36528745e-01f, 1.76356845e-02f, -4.19402793e-02f, -1.13225460e-01f, -1.01675704e-01f,
  4.42023039e-01f, 1.32512525e-01f, -1.41614547e-03f, 2.50791937e-01f, 3.15687329e-01f, 2.80423164e-01f, 1.23241760e-01f, 9.23620835e-02f, 1.70474555e-02f, 1.12736918e-01f,
  8.38943571e-02f, 7.65861943e-02f, -3.15397158e-02f, -6.14661947e-02f, -1.35026440e-01f, 5.99271879e-02f, 8.64314586e-02f, 1.38115034e-01f, 2.40862802e-01f, 3.17260593e-01f,
  2.05044344e-01f, 2.24874943e-01f, 1.54321790e-01f, 1.25333846e-01f, 1.89607292e-01f, 1.77515373e-01f, -5.56979440e-02f, 1.42961800e-01f, 9.75357890e-02f, 2.00865582e-01f,
  1.35464162e-01f, 2.55695254e-01f, -6.43504113e-02f, 1.60014763e-01f, 5.47550172e-02f, -7.66528621e-02f, -2.06668153e-02f, 3.05621116e-03f, 3.94402035e-02f, 4.08425033e-02f,
  1.38606697e-01f, -1.04660047e-02f, 3.92217888e-03f, -7.61647597e-02f, 5.23983613e-02f, 7.97888357e-03f, -7.86002278e-02f, 5.12502948e-03f, 7.44967535e-02f, -7.20892921e-02f,
  -9.71216056e-03f, 2.80218758e-02f, -2.93416437e-02f, -1.40162095e-01f, -3.27894427e-02f, -1.92859881e-02f, 6.21409304e-02f, 9.52528790e-02f, -7.28285313e-02f, -5.69571480e-02f,
  9.99197811e-02f, -4.07614894e-02f, -3.97338867e-02f, -4.73710746e-02f, 5.17134480e-02f, -5.51866144e-02f, 5.12800775e-02f, 6.16245195e-02f, 3.18057314e-02f, -1.94815118e-02f,
  -5.86529002e-02f, 5.20658940e-02f, -9.31374729e-03f, -8.35871771e-02f, 9.52808000e-03f, 9.39274728e-02f, 9.06817317e-02f, 2.24775504e-02f, -6.17037434e-03f, 7.14953616e-03f,
  6.83582723e-02f, -7.08863959e-02f, -1.94683875e-04f, -2.88600940e-02f, -6.36637062e-02f, 6.77455142e-02f, 3.54534350e-02f, -3.76703627e-02f, -2.16107890e-02f, 7.85645470e-02f,
  1.31798998e-01f, -5.01186103e-02f, 5.23313656e-02f, 2.19408125e-01f, 1.43121436e-01f, 1.95715167e-02f, -2.85873301e-02f, 1.44797534e-01f, 1.43420575e-02f, 1.13314077e-01f,
  1.74088031e-02f, -2.10364312e-02f, 2.98035331e-02f, -4.70588952e-02f, -1.78510156e-02f, 1.80867627e-01f, -1.49316099e-02f, 1.09699517e-01f, 6.58045113e-02f, -5.94053827e-02f,
  4.73995656e-02f, -1.97917898e-03f, -3.00896075e-02f, -1.17450930e-01f, 5.84647097e-02f, 1.40210807e-01f, -7.40114748e-02f, 1.07483856e-01f, -5.51456250e-02f, -7.05427527e-02f,
  2.51970679e-01f, 1.07293144e-01f, 2.48501986e-01f, 1.60602272e-01f, 1.13838539e-02f, -6.77003264e-02f, -5.23459576e-02f, -8.50498229e-02f, -1.00250334e-01f, -2.92321946e-02f,
  -1.21539056e-01f, -1.52198061e-01f, -1.74384132e-01f, -8.33067968e-02f, -9.22063366e-02f, 5.40979244e-02f, 5.64565957e-02f, 7.03577846e-02f, -4.85072061e-02f, 2.51470525e-02f,
  -8.33334029e-02f, -1.01231672e-01f, 7.72623494e-02f, -1.41375855e-01f, 1.53911963e-01f, -1.05518945e-01f, 1.08866222e-01f, 1.28067642e-01f, 1.47297502e-01f, 1.91262618e-01f,
  -2.28239000e-02f, 3.97847176e-01f, -6.83232769e-02f, 3.76739427e-02f, -1.10411435e-01f, -1.36621848e-01f, -1.44642353e-01f, -1.04565332e-02f, -2.84042042e-02f, -1.33626647e-02f,
  3.45621817e-02f, -8.54033455e-02f, -3.13639715e-02f, -8.11296552e-02f, 9.66321025e-03f, -1.19875288e-02f, -4.81804553e-03f, 1.71263531e-01f, 1.48974666e-02f, 3.47607248e-02f,
  8.69418755e-02f, 1.41242534e-01f, 1.38603821e-01f, 4.23341691e-02f, 2.46568378e-02f, -4.13495302e-03f, 7.08836038e-03f, 1.45814329e-01f, -1.75300557e-02f, 3.54477912e-02f,
  -3.72965671e-02f, 4.88839634e-02f, 9.82797053e-03f, 2.80807335e-02f, -2.23766975e-02f, 1.13566266e-02f, 9.83539149e-02f, -5.73267369e-03f, 6.14265315e-02f, 6.55641928e-02f,
  7.03000277e-02f, 9.71067846e-02f, 8.77884701e-02f, 9.26123038e-02f, 1.13698272e-02f, -5.68114046e-04f, 3.76876220e-02f, 3.79677676e-02f, 1.74632221e-01f, -1.99071337e-02f,
  -3.62771600e-02f, -4.03736085e-02f, 6.27738014e-02f, 2.54686475e-02f, 1.47182737e-02f, 1.20024025e-01f, -7.50066936e-02f, 2.92595625e-02f, 5.48513755e-02f, -5.37962653e-02f,
  -3.44596863e-01f, 5.53073697e-02f, -1.50266692e-01f, -1.39011890e-01f, 3.41261365e-02f, -5.50448485e-02f, -2.33276170e-02f, 1.74452979e-02f, -2.91894674e-02f, -8.19512084e-02f,
  1.05043642e-01f, -2.58183461e-02f, 4.86384183e-02f, -5.46838949e-03f, -6.82685971e-02f, -6.38467595e-02f, -7.90406317e-02f, -8.31401795e-02f, -7.43462443e-02f, -5.17782420e-02f,
  -1.04206175e-01f, -2.15600580e-01f, -7.07836822e-02f, -1.46517873e-01f, -8.26163739e-02f, -1.87154040e-01f, -1.88942179e-01f, -9.22309160e-02f, -1.87788904e-01f, -4.18102503e-01f,
  -2.35886816e-02f, 8.28649476e-02f, 2.12685630e-01f, 1.01613037e-01f, 2.12100800e-02f, -2.35807747e-01f, -2.24266663e-01f, -9.09668058e-02f, -7.43386373e-02f, 2.91846916e-02f,
  -3.09504326e-02f, -4.33408841e-02f, 4.54787128e-02f, 6.49476573e-02f, -1.87715460e-02f, -6.51498735e-02f, 8.95051062e-02f, -2.78788358e-02f, -3.31766278e-01f, -3.08772057e-01f,
  -1.83993727e-01f, -7.58672580e-02f, 2.25050878e-02f, -6.54355586e-02f, 7.56495222e-02f, -7.55241513e-02f, 2.04493105e-01f, 7.57455677e-02f, 1.67626649e-01f, 2.41449356e-01f,
  -5.08826375e-02f, 2.16180295e-01f, -1.38386846e-01f, -7.55239576e-02f, -3.07776667e-02f, -4.29857410e-02f, -1.23437993e-01f, -8.84938464e-02f, -4.29189689e-02f, -1.15561441e-01f,
  -5.77493198e-02f, -6.73345327e-02f, -7.72150084e-02f, 5.77702420e-03f, -7.33807757e-02f, -4.27713543e-02f, -6.93625063e-02f, -6.85458109e-02f, -4.59020399e-02f, -1.28342822e-01f,
  -1.06052406e-01f, 1.12436265e-02f, 4.81998408e-03f, -1.49965987e-01f, -9.07023847e-02f, 4.23827097e-02f, 2.69985548e-03f, 1.12243369e-02f, -5.17465249e-02f, -8.30218196e-02f,
  -1.80997681e-02f, 5.92173785e-02f, -1.79835712e-03f, -3.35277952e-02f, -8.46480578e-02f, -6.26831129e-03f, 2.06470657e-02f, -2.12752670e-02f, -1.74496789e-02f, -1.02091491e-01f,
  -2.21898966e-02f, -2.53176000e-02f, -3.93030904e-02f, 8.24001655e-02f, -1.83976572e-02f, 1.13675296e-02f, -6.73623234e-02f, 9.24044549e-02f, 1.06195465e-01f, 5.23342332e-03f,
  -1.14602707e-02f, 3.73364612e-02f, 5.79430535e-02f, -7.29385838e-02f, 1.49518549e-01f, 2.07856670e-03f, -2.75140665e-02f, 6.28589839e-02f, 1.42032246e-03f, 7.34105185e-02f,
  -2.78330088e-01f, -5.82136326e-02f, -1.55874655e-01f, -1.28520384e-01f, -8.60106274e-02f, -3.60623412e-02f, 7.49255344e-02f, -8.95286426e-02f, -2.57710274e-02f, -9.60882008e-02f,
  -8.69461074e-02f, -6.46982789e-02f, -1.05791308e-01f, -1.10249266e-01f, -1.47346005e-01f, -1.96288303e-01f, -1.05141602e-01f, -1.92978978e-01f, -1.60140976e-01f, -1.95239335e-01f,
  -1.84691653e-01f, -2.29128674e-01f, -2.78314739e-01f, -4.95891720e-02f, -7.31548816e-02f, -2.15838000e-01f, -1.87451303e-01f, -1.70923471e-01f, -1.34628519e-01f, -2.54096031e-01f,
  4.76798087e-01f, 2.54292876e-01f, -1.36017889e-01f, 2.83657819e-01f, 1.66414976e-01f, -3.63370664e-02f, 3.57733846e-01f, 2.05825150e-01f, 9.52280089e-02f, 2.90346950e-01f,
  4.51096380e-03f, -1.53063461e-01f, -9.58557278e-02f, -4.87922393e-02f, 1.57735452e-01f, 3.39909166e-01f, 2.11612985e-01f, 1.12036303e-01f, -4.66959178e-02f, 1.70530170e-01f,
  -2.01820210e-02f, 9.61065516e-02f, 2.85822190e-02f, 9.96951386e-02f, 1.72444642e-01f, -5.39097451e-02f, -5.26537672e-02f, 7.37888590e-02f, -4.87563536e-02f, 4.52656187e-02f,
  -6.43822774e-02f, 2.27661148e-01f, -6.52962178e-02f, -8.67729913e-03f, 2.12942660e-02f, -5.44400886e-03f, 3.80448326e-02f, 1.70931015e-02f, -4.42343913e-02f, 1.15719996e-01f,
  5.20705339e-03f, -7.93754533e-02f, 2.34730262e-02f, -4.03114967e-02f, 5.62511310e-02f, 4.88542952e-02f, 9.60969254e-02f, 2.97689550e-02f, 9.53246951e-02f, 2.21683849e-02f,
  1.07757784e-01f, 2.38549989e-02f, 8.57738256e-02f, 8.81387964e-02f, 5.00687100e-02f, -1.67357810e-02f, -1.59866028e-02f, 2.14264486e-02f, 3.57526205e-02f, 4.24369425e-02f,
  1.65583752e-02f, 2.29364214e-03f, 2.32985080e-03f, 3.20054740e-02f, -6.16050251e-02f, 2.79609822e-02f, 3.02333795e-02f, 1.62590332e-02f, -1.46761565e-02f, -8.40178281e-02f,
  -6.76658973e-02f, -4.05475125e-03f, -1.00901730e-01f, 3.13146436e-03f, -4.85854410e-02f, -1.80718843e-02f, -2.58275848e-02f, 2.77722515e-02f, -3.37113701e-02f, -7.96564519e-02f,
  -6.14188202e-02f, -3.63811329e-02f, 3.75605933e-02f, -8.07936713e-02f, -6.03070064e-03f, 1.80968437e-02f, 2.56223092e-03f, -8.04201663e-02f, -3.99508104e-02f, -6.32633194e-02f,
  -1.29159717e-02f, -5.03832549e-02f, 8.16530455e-03f, -2.83059794e-02f, 2.24837437e-02f, -1.57001689e-01f, -4.82011996e-02f, 1.85082816e-02f, 9.60702542e-03f, 6.70026988e-02f,
  -3.20328213e-02f, 5.09302095e-02f, -1.03415810e-02f, -3.42882648e-02f, 6.73288926e-02f, 1.37207150e-01f, 6.67051747e-02f, 7.80282496e-03f, 9.14434791e-02f, 5.00317663e-02f,
  1.55477926e-01f, 2.01999903e-01f, 7.91686177e-02f, 4.45314460e-02f, -5.53463176e-02f, 1.49114937e-01f, -3.91307324e-02f, 9.91936997e-02f, 5.21279611e-02f, 8.19015875e-02f,
  3.50179784e-02f, 4.01260033e-02f, -3.84654403e-02f, 1.65387556e-01f, -1.02253690e-01f, -2.14560688e-01f, -4.40516561e-01f, -4.98446524e-02f, 2.12010920e-01f, -3.94181944e-02f,
  -7.58042037e-02f, 1.97521880e-01f, 1.99293166e-01f, 1.14310406e-01f, -9.78546143e-02f, -1.20468967e-01f, 1.09174311e-01f, 1.49408385e-01f, -5.03658168e-02f, -8.33534449e-02f,
  -3.51079218e-02f, 4.97476719e-02f, 1.83821574e-01f, 1.62736744e-01f, 1.73949510e-01f, 1.24249093e-01f, 2.30893828e-02f, 1.43726125e-01f, 2.00017825e-01f, 4.54275668e-01f,
  -7.96018615e-02f, -2.32815016e-02f, -1.81150134e-03f, 1.10468827e-01f, -2.24840827e-02f, 2.76481323e-02f, 5.74056879e-02f, 4.61451672e-02f, -5.74632408e-03f, 9.78982449e-02f,
  7.72550255e-02f, 8.20034593e-02f, -3.45877670e-02f, 9.80872139e-02f, -7.80307725e-02f, 5.02833724e-02f, 5.71160838e-02f, 1.26756042e-01f, 1.23842217e-01f, -5.07667214e-02f,
  6.29261658e-02f, 6.64245337e-02f, -8.66283029e-02f, -4.02221158e-02f, 6.22950718e-02f, 6.94572181e-02f, -2.40354259e-02f, 5.48777767e-02f, 6.29459321e-02f, 6.38814718e-02f,
  5.04344702e-03f, -1.61737693e-03f, -5.07771969e-02f, -3.00148167e-02f, -3.40098180e-02f, -5.71953394e-02f, 6.46267757e-02f, -2.28201523e-02f, -4.72820215e-02f, -5.53071909e-02f,
  2.46491320e-02f, -1.18467800e-01f, -5.51952086e-02f, -7.43787661e-02f, -3.02544199e-02f, -4.97534722e-02f, -4.03436683e-02f, 4.01092097e-02f, -7.55422041e-02f, 2.50846129e-02f,
  4.95259697e-03f, 4.82010953e-02f, -1.08756885e-01f, 7.17842439e-03f, 1.80741455e-02f, -4.99788560e-02f, -5.80851063e-02f, -1.67683903e-02f, 7.41885602e-02f, 6.84913173e-02f,
  -9.38906819e-02f, -7.39998594e-02f, -4.23565768e-02f, 6.43719360e-03f, -3.35836895e-02f, 7.72617906e-02f, -3.98377404e-02f, -4.61501116e-03f, -3.15981056e-03f, -1.71535477e-01f,
  -1.09543810e-02f, -5.96260186e-03f, -1.12535749e-02f, 1.78490765e-02f, -7.12976828e-02f, -8.42058063e-02f, -4.57801484e-02f, 4.35701907e-02f, 5.70032597e-02f, 8.86225551e-02f,
  1.96214113e-02f, -7.02269971e-02f, -8.59011561e-02f, 3.24979275e-02f, 7.78591707e-02f, 4.94435802e-02f, -1.48512766e-01f, -8.31213519e-02f, -1.47359431e-01f, -2.23255321e-01f,
  -5.98133087e-01f, -4.18339789e-01f, 2.07840532e-01f, -9.15924236e-02f, 2.56564051e-01f, 1.99428037e-01f, 4.30434421e-02f, -8.55161697e-02f, -1.08477674e-01f, -2.09936369e-02f,
  5.16778342e-02f, 1.09788693e-01f, 1.05409790e-02f, -4.09127064e-02f, -9.39606205e-02f, 2.91032270e-02f, 2.26467893e-01f, 4.05311026e-02f, 1.59403875e-01f, 5.57807088e-02f,
  6.52790815e-02f, -8.40824842e-02f, -2.96631008e-01f, -1.35886282e-01f, 1.03978716e-01f, 1.88402310e-01f, 3.54028866e-02f, 1.41049966e-01f, 4.58285585e-02f, 2.84073293e-01f,
  3.07538122e-01f, -2.07764670e-01f, 2.47846637e-02f, -1.41807258e-01f, 1.83083236e-01f, 2.32323837e-02f, -4.29443233e-02f, -7.63682202e-02f, -1.48182558e-02f, 1.65650565e-02f,
  -5.11111179e-03f, -9.02698562e-02f, 1.55223338e-02f, 1.00018822e-01f, 4.92003337e-02f, 5.04599474e-02f, -5.23293801e-02f, -6.91405013e-02f, -2.11138837e-02f, -1.10547999e-02f,
  -1.25584463e-02f, 1.50851846e-01f, 1.12610966e-01f, -2.26770658e-02f, 2.81141549e-02f, -2.42444444e-02f, 4.95520160e-02f, -2.59274151e-02f, -4.80700459e-04f, 1.58359464e-02f,
  -1.95487589e-02f, -1.26255870e-01f, -6.69424012e-02f, -5.07929362e-02f, -5.78454584e-02f, 1.05850756e-01f, -9.83738340e-03f, -2.89426111e-02f, -5.80743365e-02f, -1.51744122e-02f,
  6.89265206e-02f, 1.53267868e-02f, 6.41888455e-02f, 2.14073490e-02f, 8.66335928e-02f, 6.06735423e-02f, -6.69994056e-02f, -5.85644022e-02f, 6.21998832e-02f, -5.61764985e-02f,
  1.86340157e-02f, 8.59857276e-02f, 4.51411344e-02f, 5.11203185e-02f, -3.16592045e-02f, -2.16892380e-02f, 2.35176887e-02f, -5.51827662e-02f, 6.66044876e-02f, -4.34394293e-02f,
  5.54624647e-02f, -1.51772961e-01f, 2.78359186e-02f, -4.21441533e-02f, 1.72882192e-02f, 1.02235705e-01f, -1.88332032e-02f, -3.96365784e-02f, 4.03213985e-02f, 4.72205020e-02f,
  7.32184872e-02f, 7.99441412e-02f, 4.59494591e-02f, 7.72579387e-02f, 1.60880908e-01f, 4.75277007e-02f, 2.57748384e-02f, 1.32575944e-01f, 1.45308282e-02f, 5.58168218e-02f,
  -4.53560203e-02f, -7.74338609e-03f, 5.83073385e-02f, 5.62611930e-02f, 4.40583415e-02f, 8.56986716e-02f, 1.01641558e-01f, 1.75105274e-01f, 3.09705678e-02f, 6.01659715e-02f,
  -2.36629739e-01f, -1.82427198e-01f, 3.07026297e-01f, 3.24035473e-02f, 1.35097846e-01f, -6.19049259e-02f, -3.64717305e-01f, -2.66599506e-01f, -4.29754332e-02f, -9.59899500e-02f,
  -6.03200756e-02f, -1.04413964e-01f, -1.13056693e-02f, 4.14955504e-02f, -2.75735319e-01f, -1.10793754e-01f, 2.15598077e-01f, 1.81177273e-01f, -4.97412682e-02f, -9.49468240e-02f,
  -5.98413032e-03f, 2.54288763e-02f, 1.71300322e-01f, 2.77021918e-02f, 3.03908866e-02f, 7.12835118e-02f, 1.46508574e-01f, -3.70943993e-02f, 3.41519937e-02f, 1.73480898e-01f,
  6.95457160e-02f, -2.57463218e-03f, 8.02010149e-02f, 9.20251161e-02f, 1.47367373e-01f, 1.84070859e-02f, 1.96906319e-03f, 1.04453467e-01f, 1.21583335e-01f, -9.55241453e-03f,
  9.50900763e-02f, 1.32089481e-01f, 1.39616683e-01f, 6.48679063e-02f, 1.43131554e-01f, 1.29422858e-01f, 1.68235928e-01f, 8.64673629e-02f, 8.15270469e-03f, 4.58340272e-02f,
  5.10954186e-02f, 5.78196198e-02f, 5.62681630e-02f, -4.01028544e-02f, 5.92955723e-02f, 1.04768828e-01f, -8.27536955e-02f, -1.82476807e-02f, -5.49256280e-02f, -5.80648780e-02f,
  7.60629773e-02f, -2.35643554e-02f, -4.03306913e-03f, -6.98297098e-02f, -1.19797908e-01f, 3.07816323e-02f, -1.12462662e-01f, -1.66428968e-01f, -5.82484975e-02f, -6.64320737e-02f,
  -5.25555052e-02f, -9.50619355e-02f, -6.53094947e-02f, -1.05746619e-01f, -4.92629521e-02f, -3.08670457e-02f, 1.08323880e-01f, -8.82189050e-02f, 4.56702486e-02f, 3.64973061e-02f,
  4.97767739e-02f, 3.44536304e-02f, 5.53238839e-02f, -4.88861883e-03f, -2.88054999e-02f, 6.72597364e-02f, -5.99375255e-02f, -7.18627051e-02f, -1.34949476e-01f, -5.09654954e-02f,
  -1.79189384e-01f, -8.25662315e-02f, -2.26252023e-02f, -1.49687808e-02f, 1.98639706e-01f, 1.82770655e-01f, -1.84576621e-03f, 7.39714801e-02f, 1.12052403e-01f, -6.10431172e-02f,
  -1.77210569e-02f, -7.78181246e-03f, 1.08133312e-02f, -1.71771627e-02f, 1.76933911e-02f, 1.17516115e-01f, -6.76883608e-02f, 7.62719102e-03f, 6.24942072e-02f, 2.79649198e-02f,
  -2.60309521e-02f, -4.99347225e-02f, -1.58217952e-01f, -4.37648743e-02f, 1.85667239e-02f, -1.29691675e-01f, -3.17722745e-02f, -1.16189741e-01f, -2.11500674e-01f, -3.30472112e-01f,
  -3.99399668e-01f, -3.31867337e-01f, -5.01879565e-02f, -6.27217144e-02f, 1.44777760e-01f, 1.91434011e-01f, 2.56340653e-01f, 7.41646290e-02f, -7.64585733e-02f, -1.07241057e-01f,
  -1.43060178e-01f, -1.93994846e-02f, -2.66132355e-02f, 9.97292846e-02f, 2.48122260e-01f, 1.69954643e-01f, 8.10999572e-02f, 1.31513581e-01f, 3.43071789e-01f, 2.15394706e-01f,
  1.18418010e-02f, -9.92540568e-02f, -1.88599348e-01f, -5.24464585e-02f, -8.37992281e-02f, 7.89769143e-02f, -1.44738272e-01f, -1.03593729e-01f, -2.50169709e-02f, -3.20128381e-01f,
  -1.16065107e-01f, -2.75628716e-01f, 1.64357916e-01f, 7.73227587e-02f, -1.25424191e-01f, 3.64723839e-02f, -5.38566289e-03f, 3.13685015e-02f, 6.23530373e-02f, -9.70608890e-02f,
  -7.34439045e-02f, -5.85880503e-02f, 2.04206686e-02f, 4.55404483e-02f, 3.14799659e-02f, 9.30555612e-02f, -3.87905091e-02f, 7.96003938e-02f, 1.57148153e-01f, 2.09204736e-03f,
  5.86867593e-02f, -9.74673033e-02f, -1.92282982e-02f, 1.67171597e-01f, 1.57879993e-01f, 1.02766834e-01f, -1.80105981e-03f, -1.89727056e-03f, 1.38921347e-02f, -1.11788668e-01f,
  -8.94664451e-02f, -6.49137646e-02f, 7.25019425e-02f, 1.94794238e-02f, 3.75971608e-02f, -4.09143977e-02f, 4.97530401e-02f, 3.11112776e-02f, 1.06170148e-01f, 4.06982526e-02f,
  2.02271026e-02f, 6.79753125e-02f, 7.71363080e-02f, -1.67468395e-02f, 4.80570160e-02f, 9.52200741e-02f, 4.20623757e-02f, -2.57647261e-02f, 7.26350248e-02f, 9.35101360e-02f,
  8.76819119e-02f, 1.63217291e-01f, -2.09307279e-02f, 1.76871553e-01f, 9.12033767e-02f, 1.45174727e-01f, -4.82129771e-03f, 2.55221967e-02f, -2.34513450e-02f, 4.34826389e-02f,
  4.87368699e-04f, 1.82142913e-01f, -2.94318330e-02f, -2.42004637e-02f, -6.90794215e-02f, -2.56075673e-02f, -9.78611788e-05f, 1.20807765e-02f, -9.50944424e-02f, -1.49624078e-02f,
  3.09149958e-02f, 2.03485615e-04f, -5.94248027e-02f, 9.45193321e-02f, 6.47196546e-02f, -2.98784077e-02f, -2.46689748e-03f, 1.95285708e-01f, 1.57265157e-01f, -4.21318896e-02f,
  -2.08158884e-02f, 8.70697871e-02f, 1.47452191e-01f, 1.88767090e-02f, 2.01470777e-02f, 1.09061725e-01f, 9.21294987e-02f, 1.98305473e-02f, 1.55362248e-01f, -2.79722176e-02f,
  -1.51354879e-01f, 1.29196793e-01f, 2.04064608e-01f, 1.22707337e-01f, 1.35281876e-01f, 1.09511837e-01f, 2.00886220e-01f, 2.79841758e-02f, 9.35465544e-02f, 1.46871181e-02f,
  6.18577637e-02f, -1.36318207e-01f, -4.10155505e-02f, -1.76286455e-02f, 2.79305000e-02f, 2.52606571e-01f, 2.82013655e-01f, 9.59302634e-02f, 6.76875710e-02f, 1.06694952e-01f,
  8.78985673e-02f, 1.64387122e-01f, -2.18542051e-02f, 7.02244192e-02f, 2.33891234e-01f, -1.53427366e-02f, 1.96219668e-01f, 2.06992067e-02f, 1.05098665e-01f, 3.39310110e-01f,
  5.75255491e-02f, 3.51273380e-02f, -2.56493054e-02f, 9.96811166e-02f, 1.54281750e-01f, 7.17458054e-02f, 1.13300696e-01f, 1.24137595e-01f, 1.41783789e-01f, 1.05393462e-01f,
  1.73762769e-01f, 1.60435677e-01f, 1.74425945e-01f, 2.27105111e-01f, 1.88798532e-01f, 1.25409737e-01f, 2.14992389e-01f, 1.80003047e-01f, 1.82321280e-01f, 6.12990297e-02f,
  2.49593779e-01f, 1.43735871e-01f, 2.67223716e-01f, 8.45133439e-02f, 2.56577998e-01f, 1.71809301e-01f, 2.38277391e-01f, 2.14960635e-01f, 9.91406292e-02f, 2.25653201e-01f,
  6.51166290e-02f, -1.63621217e-01f, -1.94675267e-01f, -7.07590505e-02f, -1.12647168e-01f, -1.54885814e-01f, -1.54339656e-01f, -2.33375400e-01f, -1.45000562e-01f, -9.80427563e-02f,
  -9.95350927e-02f, -1.53491572e-01f, -7.45346546e-02f, -2.29692712e-01f, -9.27277803e-02f, -1.20180994e-01f, -1.32203057e-01f, -1.77498803e-01f, -7.63429925e-02f, -1.82774037e-01f,
  -1.42643243e-01f, -7.46383667e-02f, -1.46055311e-01f, -6.32152632e-02f, -1.76278323e-01f, -1.35255650e-01f, -1.73905179e-01f, -1.46275684e-01f, -1.60675630e-01f, -1.16605587e-01f,
  -1.16808534e-01f, 1.10081919e-01f, 3.39008681e-02f, 1.97035521e-01f, 1.29395038e-01f, 6.80556893e-02f, 2.40580570e-02f, 7.97452033e-02f, 1.64310560e-01f, 1.05579339e-01f,
  1.04060434e-01f, 1.63587749e-01f, 6.94110096e-02f, 1.71259642e-01f, 1.87431946e-01f, 1.23836212e-01f, 8.56799781e-02f, 1.16865553e-01f, 2.06559047e-01f, 1.22753970e-01f,
  1.40083954e-01f, 1.06287315e-01f, 2.33018845e-01f, 8.38942677e-02f, 4.94425818e-02f, 1.05613999e-01f, 9.02654454e-02f, 1.80935740e-01f, 1.38140604e-01f, 2.18064245e-02f,
  -6.71623349e-01f, -5.30080721e-02f, 2.20235169e-01f, -1.92527905e-01f, 2.07097352e-01f, 5.66930845e-02f, 1.23355508e-01f, -5.35965115e-02f, -1.31858945e-01f, -7.43017197e-02f,
  6.61263093e-02f, -4.30947281e-02f, -8.90260115e-02f, -3.29422429e-02f, -2.09891558e-01f, 5.25488369e-02f, 7.92697966e-02f, -3.31428014e-02f, -1.08285300e-01f, -6.79388363e-03f,
  7.04168528e-02f, -7.23997504e-02f, -1.95924729e-01f, 2.90829707e-02f, 1.59891486e-01f, 7.28851706e-02f, 1.20733604e-01f, 1.05120823e-01f, 1.08159415e-01f, 2.11441025e-01f,
  -5.08035496e-02f, -3.45696025e-02f, 8.72345716e-02f, 6.20157737e-03f, 1.57717258e-01f, -3.96980345e-02f, 3.04326769e-02f, -1.63129196e-02f, 2.44550053e-02f, 1.12375673e-02f,
  6.85015842e-02f, -5.48291579e-02f, 8.37938786e-02f, 1.40808031e-01f, 9.16334018e-02f, 2.47628763e-02f, 9.02090594e-03f, -8.35244060e-02f, 1.01390958e-03f, -4.14426439e-02f,
  8.59300941e-02f, 1.14851184e-01f, 8.37944523e-02f, 1.29330754e-01f, 1.34060487e-01f, 1.28215209e-01f, 7.55752698e-02f, 1.41658634e-01f, 1.02093548e-01f, 9.07764286e-02f,
  -8.16441327e-02f, 1.22766597e-02f, -1.12369679e-01f, -8.42290930e-03f, -1.70299619e-01f, -6.83387816e-02f, -1.63189750e-02f, 1.04406243e-02f, -5.62157109e-02f, -1.50892034e-01f,
  -5.46796247e-02f, -8.00883844e-02f, -9.00669619e-02f, -2.25140695e-02f, 1.29263848e-02f, 4.79516499e-02f, -4.83912714e-02f, -7.58349448e-02f, -7.69180506e-02f, -5.78217953e-02f,
  -6.85628876e-03f, -8.60271379e-02f, -1.59400366e-02f, 1.51581429e-02f, -1.01903193e-01f, -4.97855656e-02f, -1.15289353e-01f, -9.02268961e-02f, -1.83944218e-02f, -5.94949611e-02f,
  -1.19230524e-02f, 3.26816700e-02f, -8.25884864e-02f, -1.17538935e-02f, 8.32408220e-02f, 1.79018918e-02f, -6.35918230e-04f, 7.43094906e-02f, 5.89211248e-02f, 5.65537834e-04f,
  1.26411557e-01f, -1.11276759e-02f, 6.66499436e-02f, 8.08018893e-02f, 4.32687216e-02f, 6.44745231e-02f, 1.34861097e-01f, 1.67514104e-02f, 3.49882953e-02f, 6.54249191e-02f,
  8.29589218e-02f, 1.35156773e-02f, -6.29677027e-02f, -1.36702862e-02f, 1.77307278e-02f, -6.22981265e-02f, 2.04450458e-01f, 5.29902615e-03f, 4.65127230e-02f, 2.67598685e-02f,
  5.30376099e-02f, -1.21303730e-01f, 3.97501081e-01f, 2.38456786e-01f, 1.26424342e-01f, -5.12206741e-02f, -3.71114090e-02f, -9.32313129e-03f, -1.58784334e-02f, -4.48574312e-02f,
  -1.34653658e-01f, -1.10773139e-01f, -1.91546053e-01f, 4.60359640e-02f, -3.68617699e-02f, 1.20056406e-01f, 3.32565814e-01f, 2.50286609e-01f, 1.77575916e-01f, 3.64668295e-02f,
  -3.55101260e-03f, -3.26330066e-02f, 1.66653078e-02f, 8.51881951e-02f, 1.21742338e-01f, 8.27135518e-02f, 1.82017479e-02f, -5.94315454e-02f, -4.43471409e-02f, 3.45577061e-01f,
  4.15270962e-02f, 6.39775246e-02f, 2.24060878e-01f, 1.29588664e-01f, 1.41105369e-01f, 1.34000573e-02f, 1.30430549e-01f, 1.29718482e-01f, 7.04974681e-02f, 1.55111849e-01f,
  3.93590331e-02f, -9.38224606e-03f, 3.82971391e-02f, 3.93042713e-02f, 8.83069560e-02f, 5.80110103e-02f, 3.85196283e-02f, 1.43273771e-01f, 1.20934568e-01f, 5.66927455e-02f,
  7.10431933e-02f, 1.30930319e-01f, 1.03814758e-01f, 1.24705406e-02f, 2.67524570e-02f, 1.15290515e-01f, 6.88840821e-02f, 1.49677575e-01f, 1.75084416e-02f, 1.73909262e-01f,
  9.42303613e-02f, 5.38778538e-03f, -6.66765571e-02f, -2.63513457e-02f, -5.21206297e-02f, -7.18449205e-02f, 1.97716523e-02f, -4.49572019e-02f, -2.31205989e-02f, 1.46143446e-02f,
  -5.95514616e-03f, 6.95113242e-02f, 8.40141550e-02f, 4.69186679e-02f, 1.53288683e-02f, -3.62135358e-02f, -1.01375587e-01f, -2.26301793e-02f, 2.39193607e-02f, -1.80404203e-03f,
  -4.29433510e-02f, 1.08314484e-01f, 4.53590192e-02f, -1.37137063e-02f, 3.08137853e-02f, 6.51633367e-02f, 2.46530324e-02f, -7.66912624e-02f, -9.76164266e-02f, -1.15354717e-01f,
  -2.10840508e-01f, 1.63727269e-01f, 1.76895096e-03f, 1.45737454e-02f, 6.91248775e-02f, 1.49312774e-02f, 9.35363770e-03f, -5.21838479e-03f, -2.46714167e-02f, 1.09296158e-01f,
  1.36560455e-01f, 4.14293148e-02f, 1.33898007e-02f, 7.76527748e-02f, 4.26891707e-02f, 1.24053471e-01f, -6.92819655e-02f, 1.54691324e-01f, -8.51584424e-04f, 1.82316247e-02f,
  4.96808067e-02f, 3.19755301e-02f, -6.98133782e-02f, 7.86823779e-02f, 3.99056263e-02f, 3.66555639e-02f, 1.67682189e-02f, 2.71827783e-02f, 2.79871393e-02f, -2.05631312e-02f,
  -3.22432697e-01f, 2.04610705e-01f, -2.05708414e-01f, -3.58689815e-01f, -4.07416016e-01f, -2.67150432e-01f, -2.09635600e-01f, -1.54625863e-01f, -5.66245764e-02f, -1.60961837e-01f,
  1.14293911e-01f, 2.44280666e-01f, 7.34621957e-02f, 6.61084726e-02f, -6.73733205e-02f, -1.38765797e-01f, -1.28732458e-01f, -5.92187084e-02f, -1.91930100e-01f, -1.00858703e-01f,
  -3.24067436e-02f, 7.86624923e-02f, 1.72195524e-01f, 9.66401249e-02f, 1.06999250e-02f, 7.97034651e-02f, 5.55062070e-02f, -5.75235151e-02f, 5.97755723e-02f, -8.20843354e-02f,
  5.49779721e-02f, 1.24550924e-01f, 6.29978329e-02f, 1.22924425e-01f, -1.54743537e-01f, -5.39465658e-02f, -3.61617319e-02f, -7.35611767e-02f, 6.62938282e-02f, 1.14358187e-01f,
  -1.32733770e-02f, -4.01765201e-03f, -6.87474292e-03f, 2.52526440e-02f, 3.80884372e-02f, 2.97642574e-02f, -2.23846342e-02f, -4.75418232e-02f, 1.01704337e-01f, 5.07294387e-02f,
  -7.19701464e-04f, 5.53600192e-02f, 9.39549059e-02f, 9.28489640e-02f, 3.56605761e-02f, -8.10318217e-02f, 1.20983720e-02f, 5.49832731e-03f, 1.84934251e-02f, 2.23409547e-03f,
  -1.32187515e-01f, 1.24885961e-02f, -1.38690993e-01f, 1.64968610e-01f, 1.25310048e-01f, 1.78021640e-02f, 1.54597253e-01f, 1.34821743e-01f, 7.33839646e-02f, 9.10562053e-02f,
  1.01902410e-01f, 4.95142564e-02f, 3.54932696e-02f, -4.52613831e-02f, 2.42477395e-02f, 9.60747972e-02f, 7.47149885e-02f, 5.84005378e-02f, 1.04619421e-01f, 1.33730128e-01f,
  1.05908081e-01f, 3.64340469e-02f, -9.50863510e-02f, 1.50496796e-01f, -2.50930265e-02f, 5.32581061e-02f, -1.02836229e-02f, 1.59703251e-02f, 9.55582932e-02f, 5.30917421e-02f,
  6.83065355e-02f, 7.62031823e-02f, 1.01112074e-03f, -1.59535706e-02f, -1.43216252e-01f, 5.62144071e-03f, 1.13509465e-02f, -1.31755359e-02f, 4.43380512e-02f, 8.11914131e-02f,
  1.58029571e-01f, -6.48451746e-02f, 5.67943230e-02f, 3.31845284e-02f, -9.87712443e-02f, 3.58039886e-02f, -9.84271765e-02f, 5.18893301e-02f, 8.65521803e-02f, 3.70805897e-02f,
  8.81898776e-02f, 2.30074930e-03f, -5.66253774e-02f, -4.72783893e-02f, 6.70545548e-02f, -5.54795042e-02f, 9.97371972e-02f, 1.46415338e-01f, 6.99786991e-02f, 3.34082805e-02f,
  -1.00529149e-01f, 4.29216862e-01f, 1.22306287e-01f, 7.75474086e-02f, 7.65174925e-02f, -1.09261952e-01f, 8.38187262e-02f, -3.73986363e-02f, -1.48375109e-02f, 1.88247249e-01f,
  2.26942047e-01f, 2.19329834e-01f, 1.36420563e-01f, 1.06940061e-01f, 8.70298594e-02f, 1.87142998e-01f, 1.83791518e-01f, -4.68710857e-03f, -2.29253367e-01f, -1.11984171e-01f,
  2.13257015e-01f, 2.01737463e-01f, 1.86879039e-01f, 3.77540477e-02f, 2.13349909e-01f, 9.42332894e-02f, 2.13631481e-01f, 2.89194047e-01f, 1.68453574e-01f, 3.96344900e-01f,
  1.55916214e-01f, 2.63647586e-01f, 5.69008812e-02f, 2.80203104e-01f, 1.88536778e-01f, 1.06495753e-01f, 1.31611973e-01f, 1.92821249e-01f, 1.51137114e-01f, 1.02234796e-01f,
  1.92098871e-01f, 2.12187290e-01f, 2.88696259e-01f, 1.73550695e-01f, 1.29266292e-01f, 1.44365087e-01f, 1.87588245e-01f, 1.82343915e-01f, 2.96006143e-01f, 2.71890223e-01f,
  3.61315370e-01f, 2.71025151e-01f, 1.40196204e-01f, 1.93301648e-01f, 2.79696018e-01f, 2.46402726e-01f, 1.35109112e-01f, 2.20525071e-01f, 9.71443206e-02f, 1.65243462e-01f,
  1.77357253e-02f, -1.24227397e-01f, -3.74239199e-02f, -4.63521443e-02f, -1.74629554e-01f, -8.13689679e-02f, -7.09393695e-02f, -2.02729255e-02f, -1.03608295e-01f, -1.38686419e-01f,
  -5.15635386e-02f, -4.81219925e-02f, 3.16193514e-02f, -7.12134093e-02f, 1.23768328e-02f, 9.99482535e-03f, -1.46025762e-01f, -5.35594262e-02f, -1.02271587e-01f, -1.27871454e-01f,
  -4.76749465e-02f, -1.72033653e-01f, -5.23013994e-02f, -2.47872304e-02f, 1.24524077e-02f, -6.85511827e-02f, -7.49614015e-02f, -1.84371307e-01f, -3.65085751e-02f, -2.87409499e-02f,
  4.90124971e-02f, 3.07099313e-01f, 1.60390109e-01f, 1.26925811e-01f, 1.60314664e-01f, 1.62840188e-01f, 1.57242790e-01f, 1.77000284e-01f, 1.33801103e-01f, 2.08170176e-01f,
  1.16117693e-01f, 1.15455784e-01f, 2.63837457e-01f, 1.25282705e-01f, 5.03852330e-02f, 3.13830301e-02f, 1.46338135e-01f, 9.86047387e-02f, 2.22969115e-01f, 1.57420963e-01f,
  2.40277633e-01f, 1.09057657e-01f, 1.51142878e-02f, 1.01167470e-01f, 9.80743468e-02f, 1.71801094e-02f, 1.14775397e-01f, -1.89289916e-02f, -3.35446582e-03f, 3.25533673e-02f,
  5.67782700e-01f, 5.39697073e-02f, -1.24615267e-01f, 7.37919658e-02f, -2.20498100e-01f, -1.72898933e-01f, 2.33426824e-01f, 6.23469092e-02f, -1.68971047e-02f, 3.79413627e-02f,
  -1.83764666e-01f, -3.55960518e-01f, -1.63134575e-01f, -1.18338071e-01f, 7.80058056e-02f, 3.58102083e-01f, 1.51353359e-01f, 2.99418978e-02f, -4.42592576e-02f, -2.85516353e-03f,
  -1.44392803e-01f, -9.16298032e-02f, 2.42921300e-02f, -5.54499356e-03f, 1.71789639e-02f, -1.67763591e-01f, -1.64338633e-01f, -1.49229154e-01f, -8.54985788e-02f, 5.19534647e-02f,
  8.11722595e-03f, 1.99880123e-01f, 7.65630044e-03f, -5.48375212e-03f, -1.70131624e-01f, -1.97394341e-02f, 3.68542857e-02f, -6.91093728e-02f, -6.71588024e-03f, -3.66302803e-02f,
  -4.38364111e-02f, -3.03966794e-02f, -7.85385296e-02f, -4.83647222e-03f, 1.56007083e-02f, 1.26761869e-01f, 6.87843189e-02f, 1.07565289e-02f, 9.49628949e-02f, 8.27130005e-02f,
  -2.62480695e-02f, -1.12064093e-01f, 1.23992078e-01f, 1.13851972e-01f, -1.19852992e-02f, -2.30935104e-02f, -1.07577726e-01f, -6.48696274e-02f, -4.51511070e-02f, 5.89226522e-02f,
  1.05541453e-01f, 5.10357916e-02f, -1.21950740e-02f, -1.46910863e-03f, -4.52704243e-02f, -2.56343819e-02f, -1.08997457e-01f, 4.29618843e-02f, -4.35568169e-02f, -3.40755209e-02f,
  -3.82239223e-02f, -4.23650444e-02f, -5.78694977e-02f, 7.40184113e-02f, -7.92567991e-03f, -3.23945358e-02f, -6.55927360e-02f, 4.31455001e-02f, -2.13028421e-03f, 4.67721820e-02f,
  2.30131391e-02f, -1.33664114e-02f, 1.91317312e-03f, 8.15738142e-02f, 2.09077150e-02f, 6.91611171e-02f, -2.08079517e-02f, -5.12895221e-03f, -5.90980239e-02f, -3.57262455e-02f,
  -1.09473370e-01f, -1.61467850e-01f, 8.25343132e-02f, -1.47986282e-02f, -5.30760139e-02f, 3.38934958e-02f, -1.48604318e-01f, 3.13312747e-02f, -1.20650604e-01f, 6.19934015e-02f,
  -4.82948590e-03f, -1.83443483e-02f, -7.38380179e-02f, -5.30132689e-02f, -9.49812829e-02f, -5.22858053e-02f, -9.45633184e-03f, -7.49316737e-02f, -1.46189202e-02f, 5.93304336e-02f,
  5.66572230e-03f, 6.28337637e-02f, 2.18462646e-02f, 2.78371610e-02f, 7.85285383e-02f, 2.22933423e-02f, -8.12284425e-02f, 3.51122133e-02f, 4.85792346e-02f, 4.61029038e-02f,
  5.77271402e-01f, -1.23240001e-01f, -2.98496604e-01f, 2.44916692e-01f, -2.11760521e-01f, -2.75503069e-01f, -4.15800273e-01f, -2.19681207e-02f, 2.04870030e-01f, -4.37427461e-02f,
  -1.30734250e-01f, 2.84285754e-01f, 1.04581088e-01f, 9.28360373e-02f, 8.56015608e-02f, -2.17707455e-01f, -1.22798987e-01f, 1.17873088e-01f, 1.14408486e-01f, -3.30142044e-02f,
  3.10180429e-02f, 2.06106737e-01f, 3.71193111e-01f, 2.99201399e-01f, -4.27889340e-02f, -3.94546948e-02f, -1.60730481e-02f, 4.29017432e-02f, -1.15094639e-01f, 4.36799861e-02f,
  -1.48057207e-01f, -5.38545363e-02f, -1.57091662e-01f, 7.13729560e-02f, -7.99190179e-02f, 9.11953952e-03f, 6.13576593e-03f, -2.85591353e-02f, -2.05961280e-02f, -7.36926645e-02f,
  2.18984205e-02f, -1.30386963e-01f, 1.49019407e-02f, -2.08355524e-02f, -2.56998949e-02f, -1.72646847e-02f, 8.74018520e-02f, 1.69551477e-01f, 2.40121614e-02f, -1.25870153e-01f,
  -4.98622544e-02f, -1.47511914e-01f, -1.00905038e-01f, -1.14066094e-01f, -2.64849905e-02f, 4.42534089e-02f, -1.01715170e-01f, -5.56529732e-03f, 6.20598868e-02f, 8.99571776e-02f,
  -6.07105009e-02f, -4.93594110e-02f, -1.04236612e-02f, -7.75551051e-02f, 6.28146008e-02f, -3.21972705e-02f, 4.63661104e-02f, 8.25588852e-02f, 4.37164977e-02f, 7.91064575e-02f,
  5.07877842e-02f, -5.38517162e-02f, 2.32882705e-02f, 4.07322422e-02f, 8.78447443e-02f, 1.53831076e-02f, 5.08001260e-03f, 4.81774844e-02f, -4.97912206e-02f, -1.29933767e-02f,
  6.62391856e-02f, 2.08357200e-02f, 6.08819090e-02f, 1.04086295e-01f, -7.36145154e-02f, 4.96077910e-02f, 1.15820458e-02f, 8.20044950e-02f, 1.03587233e-01f, -2.77839527e-02f,
  1.35763153e-01f, -1.51326522e-01f, -1.00265794e-01f, 1.22397607e-02f, -4.54685837e-02f, -9.98873077e-03f, -6.94803223e-02f, -3.75531167e-02f, -1.02473728e-01f, -3.39594185e-02f,
  -7.15096444e-02f, -2.84976549e-02f, -7.92674199e-02f, 1.27151348e-02f, -3.15950364e-02f, -1.60272438e-02f, -6.41053095e-02f, -1.45686194e-02f, 3.16244960e-02f, -6.69633076e-02f,
  4.52032080e-03f, -5.32612801e-02f, 4.41756845e-02f, -1.24723084e-01f, -1.30971409e-02f, -8.31396878e-02f, -9.29462314e-02f, -1.17965162e-01f, -4.78448421e-02f, -1.15450628e-01f,
  -1.01900183e-01f, 2.94556022e-01f, 7.66867995e-02f, -1.15103520e-01f, 1.11878701e-01f, 5.80296405e-02f, 4.10099268e-01f, 2.38521829e-01f, -1.55373663e-02f, 9.31306854e-02f,
  -6.80358559e-02f, -3.27593774e-01f, -1.83026046e-01f, -1.87436983e-01f, -1.99673288e-02f, 3.50083113e-01f, 7.70100430e-02f, -3.57996598e-02f, -1.37513936e-01f, -2.91963499e-02f,
  -8.38315934e-02f, -2.10383590e-02f, -1.49817407e-01f, -1.33381635e-01f, 1.53541550e-01f, -1.33690462e-02f, 1.33811206e-01f, 1.17483050e-01f, 4.00761552e-02f, 4.95295264e-02f,
  -3.62113826e-02f, 1.04201913e-01f, -8.11778754e-02f, -2.37733543e-01f, -1.27588898e-01f, -1.23509884e-01f, 1.01323593e-02f, -7.68360570e-02f, -6.28463030e-02f, -1.01422384e-01f,
  -9.48569328e-02f, -9.19062942e-02f, -7.04051480e-02f, 1.24701150e-02f, 2.45863218e-02f, 5.79790063e-02f, -5.08457869e-02f, -7.13667646e-02f, -2.33862288e-02f, -2.89758500e-02f,
  -8.87720287e-02f, 4.35719267e-03f, -1.53379643e-03f, 3.63974869e-02f, -1.09872920e-02f, -1.43507138e-01f, -6.44847602e-02f, 8.05763081e-02f, -2.77230162e-02f, 1.95125148e-01f,
  -5.81736118e-02f, -1.41963124e-01f, 1.25823664e-02f, -8.33589304e-03f, -1.29791247e-02f, -4.08721045e-02f, -2.02797595e-02f, -8.83691311e-02f, 4.74733599e-02f, -7.98871666e-02f,
  9.68248304e-03f, 6.09990917e-02f, -7.69594535e-02f, 1.29387798e-02f, -4.21056487e-02f, -2.34677345e-02f, 1.16768600e-02f, -1.34028485e-02f, -3.66977863e-02f, 1.20531499e-01f,
  7.13606849e-02f, -4.47665863e-02f, -3.27523798e-02f, 2.65802741e-02f, 8.46323743e-02f, 9.54792276e-02f, -5.33691309e-02f, 5.59765734e-02f, 5.34581169e-02f, -3.04011256e-02f,
  -2.36366019e-02f, -1.82639748e-01f, 2.34479806e-03f, -2.47899983e-02f, -2.17525780e-01f, -1.40372723e-01f, -1.00603782e-01f, -2.72562690e-02f, -1.27627954e-01f, -1.15894251e-01f,
  -4.25278433e-02f, -2.12774232e-01f, -8.82699937e-02f, -7.39170685e-02f, -1.45620145e-02f, -4.44206782e-02f, -5.10094389e-02f, -9.66612175e-02f, -8.25082883e-02f, -1.01578325e-01f,
  -4.62028757e-03f, 3.05645764e-02f, 1.46843433e-01f, 6.66498244e-02f, 5.06745912e-02f, 2.38903370e-02f, 8.24543983e-02f, 8.30875784e-02f, 3.03317308e-02f, 1.68894842e-01f,
  1.74685478e-01f, 3.82452160e-01f, -1.65081680e-01f, -1.11083783e-01f, -8.25205166e-03f, -7.46397376e-02f, 2.47192681e-01f, -4.30782267e-04f, -1.75840214e-01f, 2.44037166e-01f,
  -6.41603197e-04f, -2.11247951e-01f, 1.42897461e-02f, -4.83230054e-02f, -8.84021819e-02f, 1.00520819e-01f, 4.85204682e-02f, -2.45379969e-01f, -3.02980065e-01f, 1.30726770e-03f,
  -3.73374708e-02f, 6.80888966e-02f, -2.74991486e-02f, -9.14818347e-02f, 3.29490155e-01f, -3.22200470e-02f, 2.10559711e-01f, 2.17383549e-01f, 2.06907690e-01f, 4.72220629e-01f,
  9.50405523e-02f, 2.29499996e-01f, -1.07585810e-01f, -2.33029071e-02f, -2.08561565e-03f, 6.60437569e-02f, 1.15391016e-02f, -1.23016667e-02f, -6.59949183e-02f, -5.94542511e-02f,
  1.29402414e-01f, 1.48415314e-02f, -2.48197410e-02f, 2.04514004e-02f, -7.48950318e-02f, -8.88951495e-02f, 5.88980466e-02f, -5.70329428e-02f, -8.84134546e-02f, 3.97545286e-02f,
  1.13202669e-01f, 1.41623363e-01f, -1.12910569e-03f, 4.58227657e-02f, -6.45610765e-02f, 2.37591173e-02f, 1.70395449e-01f, 5.72977364e-02f, 4.59311856e-03f, 2.82946557e-01f,
  2.74195783e-02f, 3.75697576e-02f, 1.25359949e-02f, -1.56637263e-02f, 1.68131471e-01f, 4.14062627e-02f, -6.73398376e-02f, 1.43518783e-02f, 1.23953763e-02f, 4.51466851e-02f,
  -6.13653362e-02f, -2.14222334e-02f, -5.58206104e-02f, -7.07379207e-02f, -7.40276203e-02f, 3.79080959e-02f, -1.69764627e-02f, 4.37461622e-02f, -7.57309645e-02f, 3.95033732e-02f,
  -4.43062820e-02f, 7.31935501e-02f, 8.22733864e-02f, -3.32476944e-02f, -4.81683910e-02f, 1.68577321e-02f, 8.04558247e-02f, -3.78163159e-02f, 1.02336138e-01f, 1.45794451e-01f,
  -9.21795517e-02f, -3.32302541e-01f, 3.95870721e-03f, 1.42571153e-02f, 7.22007453e-02f, -3.58681642e-02f, 2.30327365e-03f, 3.60829197e-02f, -1.23602308e-01f, -2.75461506e-02f,
  5.34627698e-02f, -1.93528440e-02f, -8.69218335e-02f, -2.06737388e-02f, -3.40704396e-02f, 8.28259811e-02f, 2.10166685e-02f, 4.92568240e-02f, -6.73405156e-02f, 1.37375146e-02f,
  6.11123815e-02f, 1.61081508e-01f, -3.37460861e-02f, 1.34850934e-01f, -8.85308441e-03f, 1.30156323e-01f, 4.60017361e-02f, 1.38804503e-02f, -2.97538582e-02f, 1.32126451e-01f,
  5.34218967e-01f, 9.50094759e-02f, 4.00195628e-01f, 1.95804209e-01f, -2.37422399e-02f, 4.58034202e-02f, 1.83691263e-01f, 1.80897698e-01f, 1.01248428e-01f, 9.86863673e-02f,
  1.39589787e-01f, 5.94627187e-02f, 1.23893797e-01f, 9.96142030e-02f, 2.18027860e-01f, 1.35463744e-01f, 1.48943946e-01f, 3.36109996e-01f, 3.67904693e-01f, 1.64220214e-01f,
  -1.95621829e-02f, 1.48704320e-01f, 2.34289542e-01f, 1.32505417e-01f, 1.48160517e-01f, 1.57237902e-01f, 1.62258923e-01f, 3.07194203e-01f, 1.65786982e-01f, 2.83224732e-01f,
  4.64983612e-01f, 4.65935796e-01f, 2.42493242e-01f, 1.26534700e-01f, 1.00472644e-01f, 2.67832935e-01f, 2.43957609e-01f, 2.19995841e-01f, 1.94517538e-01f, 1.63024873e-01f,
  1.51681796e-01f, 1.31860316e-01f, 1.43813953e-01f, 1.05583146e-01f, 1.37223840e-01f, 1.82848573e-01f, 1.45818472e-01f, 2.18808427e-01f, 1.64162606e-01f, 1.79425627e-01f,
  7.63083473e-02f, 2.05994949e-01f, 3.34574282e-01f, 1.13980472e-01f, 1.84588730e-01f, 1.95637301e-01f, 1.79392830e-01f, 1.52556047e-01f, 2.02643543e-01f, 2.54212171e-01f,
  -7.58501887e-02f, -2.19346970e-01f, -9.98046994e-02f, -4.88782376e-02f, -1.07707411e-01f, -2.28895769e-01f, -2.20347390e-01f, -1.45072430e-01f, -1.40632525e-01f, -6.20950721e-02f,
  -1.26803219e-01f, -1.02185830e-01f, -8.83645713e-02f, -7.72367045e-02f, -9.46917087e-02f, -1.16863653e-01f, -1.01577722e-01f, -1.01569504e-01f, -1.86179295e-01f, -7.77890384e-02f,
  -4.68531474e-02f, -5.13319448e-02f, -1.25474304e-01f, -8.56655538e-02f, -7.78427050e-02f, -6.63777441e-02f, 2.19628401e-02f, -1.72573209e-01f, -2.03466058e-01f, 3.55710438e-03f,
  1.54872924e-01f, 2.02457711e-01f, 2.03415468e-01f, 1.87180534e-01f, 1.78312048e-01f, 1.59591764e-01f, 2.03721687e-01f, 3.03701371e-01f, 1.77380040e-01f, 3.03503960e-01f,
  1.10228248e-01f, 2.15142310e-01f, 1.48819864e-01f, 1.86467096e-01f, 9.94663313e-02f, 9.69741121e-02f, 1.02441497e-01f, 2.59902209e-01f, 1.71407163e-01f, 1.12156518e-01f,
  5.06208688e-02f, 1.55023620e-01f, 2.13778526e-01f, 2.68314898e-01f, 2.52958208e-01f, 2.07228437e-01f, 2.73528308e-01f, 2.79471725e-01f, 3.55170935e-01f, 2.66347945e-01f,
  3.98268998e-01f, 3.10400486e-01f, 1.76293015e-01f, 1.63906634e-01f, 7.95685723e-02f, 2.58578598e-01f, 2.99564153e-01f, 2.06387818e-01f, 5.98183312e-02f, 3.58856857e-01f,
  2.02613264e-01f, 7.22169951e-02f, 7.13758394e-02f, 1.49839111e-02f, 1.67097211e-01f, 2.45147988e-01f, 1.98823661e-01f, 1.92516744e-01f, 1.40688524e-01f, 2.55618155e-01f,
  1.53926210e-02f, 1.44477114e-01f, 2.80626208e-01f, 1.37192100e-01f, 1.92211866e-01f, -1.28042921e-02f, 6.51677176e-02f, 9.58781019e-02f, 1.27283022e-01f, 2.95111425e-02f,
  2.19009504e-01f, 2.54548818e-01f, 1.24442726e-01f, 2.31661126e-01f, 2.89173722e-01f, 2.53619462e-01f, 3.14876944e-01f, 3.24338138e-01f, 2.34963223e-01f, 2.18662962e-01f,
  2.39124104e-01f, 2.23693192e-01f, 2.30696261e-01f, 1.60824820e-01f, 2.49084458e-01f, 2.95096219e-01f, 2.18574747e-01f, 2.47396752e-01f, 1.91161841e-01f, 2.97278225e-01f,
  7.47711584e-02f, 2.43561119e-01f, 3.36776316e-01f, 2.33330548e-01f, 2.37867713e-01f, 1.22308917e-01f, 3.34728926e-01f, 1.67506516e-01f, 2.15431958e-01f, 3.36067677e-01f,
  -5.36155403e-02f, -9.54863057e-02f, -6.49659336e-02f, -1.80656684e-03f, -1.20180130e-01f, -1.01856962e-01f, -1.50645718e-01f, -1.98473856e-01f, -9.28591192e-02f, -5.11599891e-02f,
  -1.27798557e-01f, -1.11709677e-01f, -1.23909093e-01f, -1.02923721e-01f, -1.66225612e-01f, -1.81085914e-01f, -8.28059390e-02f, -1.46874646e-02f, -1.43000722e-01f, -1.09788068e-01f,
  -2.00547297e-02f, -1.92470223e-01f, -7.66829327e-02f, -2.11953089e-01f, -1.59037024e-01f, -1.40705347e-01f, -2.07965478e-01f, -1.71516940e-01f, -7.99518153e-02f, -2.15785086e-01f,
  3.27143848e-01f, 8.65519568e-02f, 2.18847558e-01f, 2.15795338e-01f, 1.20563515e-01f, 1.57574609e-01f, 1.00060880e-01f, 3.24320108e-01f, 1.50203764e-01f, 2.76919961e-01f,
  2.34841332e-01f, 2.35227227e-01f, 1.13271855e-01f, 2.22491890e-01f, 1.64009601e-01f, 2.96317399e-01f, 1.39884785e-01f, 2.30343357e-01f, 2.01764420e-01f, 2.12700978e-01f,
  2.59828717e-01f, 2.66618997e-01f, 2.02527255e-01f, 2.45646670e-01f, 2.67864406e-01f, 2.90295601e-01f, 3.17122012e-01f, 3.31926316e-01f, 2.03675345e-01f, 4.52147454e-01f,
  -2.26239160e-01f, -3.59522477e-02f, 3.29553127e-01f, 1.16706014e-01f, 3.72818261e-02f, -1.60579279e-01f, -1.86734214e-01f, -1.57763869e-01f, 1.96127668e-02f, -8.34844485e-02f,
  -7.34944642e-02f, 9.20166895e-02f, 1.29536837e-01f, 1.59299180e-01f, -1.31662205e-01f, 1.34348711e-02f, 2.43706122e-01f, 5.07510714e-02f, -7.81169459e-02f, -2.45620281e-01f,
  9.18231010e-02f, 1.28419340e-01f, -2.42709704e-02f, 1.16363913e-01f, 4.68179397e-02f, -2.38540899e-02f, 1.87011272e-01f, -3.33640687e-02f, -9.66442674e-02f, 1.68371797e-01f,
  -3.09208743e-02f, -1.57663047e-01f, 1.12264536e-01f, -8.06279033e-02f, -3.88621502e-02f, -4.59606685e-02f, -6.80322498e-02f, 1.62140336e-02f, -1.71584338e-02f, -5.48534170e-02f,
  1.72204435e-01f, 2.98841037e-02f, -1.30160555e-01f, 5.43611161e-02f, -3.96501645e-02f, 6.22619502e-02f, 9.70085636e-02f, 4.35464270e-02f, 9.90713239e-02f, 1.33983856e-02f,
  1.27726058e-02f, 6.44858629e-02f, -1.12899225e-02f, -6.28755009e-03f, -3.17115225e-02f, 1.21161729e-01f, -6.56061471e-02f, -5.61191067e-02f, -1.45498693e-01f, -1.39822951e-02f,
  -9.12257805e-02f, 6.10996075e-02f, -3.62022035e-02f, -2.51127519e-02f, 1.46288916e-01f, -5.04359305e-02f, 9.11711305e-02f, 6.29521161e-02f, -1.37305493e-02f, -4.28655855e-02f,
  5.65818548e-02f, 6.90768585e-02f, 3.54029424e-02f, -1.30674616e-02f, 3.01007051e-02f, 8.27993080e-02f, -5.48538659e-03f, 4.43593711e-02f, 8.21547359e-02f, 7.01690093e-02f,
  -7.26603940e-02f, -6.21866584e-02f, -7.78545588e-02f, 5.58310673e-02f, 4.58822660e-02f, 1.19503781e-01f, 7.56094698e-03f, -4.03490439e-02f, 4.52025943e-02f, -4.93298769e-02f,
  -8.85702148e-02f, -4.88535613e-02f, -1.41458381e-02f, -2.10710317e-02f, -6.29873574e-02f, 1.91637781e-02f, 9.16420519e-02f, -2.73042042e-02f, -7.48836715e-03f, 4.04173844e-02f,
  -7.94884488e-02f, -1.30650014e-01f, -6.96517155e-02f, -2.17719357e-02f, -4.23496701e-02f, -1.00120157e-01f, 1.38657517e-03f, 6.08166270e-02f, -5.03051840e-02f, 5.82479350e-02f,
  -7.40080103e-02f, -8.83433297e-02f, -6.23123795e-02f, -1.22265510e-01f, -2.16373250e-01f, -1.06374793e-01f, -6.61805123e-02f, -2.42740646e-01f, -1.85062379e-01f, -2.37028450e-01f,
  -2.42899880e-01f, 4.17291492e-01f, -1.69772312e-01f, 1.46567426e-03f, -6.55757785e-02f, -2.93119609e-01f, -5.18383868e-02f, -1.45732448e-01f, -5.25919348e-02f, 3.08176517e-01f,
  1.52559370e-01f, -4.25446928e-02f, 1.43797100e-01f, 1.55618144e-02f, -1.99831828e-01f, 1.20400891e-01f, 1.51833668e-01f, -1.84077755e-01f, -5.08849621e-01f, -2.25478381e-01f,
  2.38119089e-03f, -1.30501073e-02f, -1.97369412e-01f, -1.03062198e-01f, 3.85903865e-01f, 8.18770081e-02f, 3.13629843e-02f, -1.68951731e-02f, 8.19518939e-02f, 5.07861376e-01f,
  1.22031823e-01f, -2.76349895e-02f, -1.34868890e-01f, -6.25144541e-02f, 1.25216782e-01f, -2.65677087e-02f, -8.09806306e-03f, 1.20805100e-01f, 7.60688409e-02f, 4.54335697e-02f,
  1.13917328e-01f, 2.77134427e-03f, -1.40106715e-02f, 2.79123671e-02f, 6.48684055e-02f, 1.58154424e-02f, -3.04759759e-02f, -1.04180224e-01f, -5.06050177e-02f, 7.41414502e-02f,
  1.28078416e-01f, -6.53249100e-02f, 3.17419805e-02f, 5.73005974e-02f, -7.12316632e-02f, -1.72144264e-01f, 2.69468576e-02f, 2.11008117e-02f, -1.06751032e-01f, 1.31441966e-01f,
  3.41825336e-02f, -1.84952207e-02f, -1.67535394e-02f, -7.82077760e-02f, -2.18944643e-02f, 5.87728508e-02f, -2.80636996e-02f, 7.34883249e-02f, -3.51798721e-02f, 2.58838423e-02f,
  9.61508881e-03f, 2.93345451e-02f, 5.04429080e-02f, 5.62527566e-04f, 8.37202892e-02f, -4.57749404e-02f, -4.08434682e-02f, 3.22768949e-02f, 3.28659303e-02f, 9.59035084e-02f,
  -1.62111446e-02f, 4.60672798e-03f, 1.94065440e-02f, 6.30045831e-02f, -9.43776965e-02f, -4.86452505e-02f, 2.52063964e-02f, -9.86547098e-02f, -7.49449208e-02f, -7.53830373e-02f,
  1.31140903e-01f, -1.99392989e-01f, 1.37677044e-01f, 2.77162082e-02f, 2.69750077e-02f, -6.27568737e-02f, 5.07196821e-02f, -1.31332995e-02f, 1.01508144e-02f, 8.20297655e-03f,
  -1.04295187e-01f, 1.05318226e-01f, 6.12977296e-02f, 8.18472505e-02f, -1.25393802e-02f, -1.18377302e-02f, 1.36333004e-01f, -6.37961701e-02f, -8.69420692e-02f, 2.75634285e-02f,
  8.30511227e-02f, 1.35487933e-02f, -1.16285488e-01f, 1.42631698e-02f, -5.93592231e-05f, -1.02984786e-01f, 7.58993952e-03f, -2.05623005e-02f, -2.25800782e-01f, 1.00835934e-01f,
  -3.43026459e-01f, -4.52799320e-01f, -1.01418672e-02f, -8.02950561e-02f, -2.33710557e-02f, -2.05748722e-01f, -3.59287053e-01f, -2.21979946e-01f, -1.31238148e-01f, -3.00852746e-01f,
  -1.58123717e-01f, 7.04237968e-02f, -2.51651984e-02f, -1.23058110e-01f, -3.10930461e-01f, -3.79273295e-01f, -3.21785986e-01f, -1.08735494e-01f, -1.56957880e-01f, -2.09126145e-01f,
  -1.65910542e-01f, -2.07467318e-01f, -2.19090413e-02f, -1.23603605e-01f, -3.19461018e-01f, -1.47127673e-01f, -1.48643807e-01f, -7.49645159e-02f, -1.98447689e-01f, -2.13969424e-01f,
  -9.20046940e-02f, -1.91593871e-01f, -1.15784854e-01f, -1.49018347e-01f, -1.43406332e-01f, -1.22654893e-01f, -2.47051135e-01f, -1.56677082e-01f, -2.79685974e-01f, -1.29377261e-01f,
  -1.84855536e-01f, -6.69902116e-02f, -2.19770432e-01f, -5.69820069e-02f, -1.26494855e-01f, -2.15023831e-01f, -9.77957472e-02f, -1.94824547e-01f, -1.70233175e-01f, -1.29029676e-01f,
  -2.22245544e-01f, -2.52445996e-01f, -3.02286297e-01f, -1.85488671e-01f, -3.14719647e-01f, -1.65234178e-01f, -1.61655575e-01f, -1.92781463e-01f, -1.33317977e-01f, -1.66141823e-01f,
  -5.97730139e-03f, -1.74634848e-02f, -2.11475372e-01f, 4.06965204e-02f, -5.62042706e-02f, 2.08705999e-02f, -4.21573669e-02f, -1.40787229e-01f, -8.48993137e-02f, 4.52074669e-02f,
  -9.13099851e-03f, -1.07333958e-01f, 9.65351537e-02f, -4.00398970e-02f, 4.72517721e-02f, 3.22791040e-02f, -1.53649434e-01f, -1.63604796e-01f, -4.12914762e-03f, -3.10687572e-02f,
  -1.11849919e-01f, 6.15702979e-02f, 2.05257311e-02f, -2.70650964e-02f, -1.75772280e-01f, -7.96922520e-02f, 3.26437652e-02f, 2.12226678e-02f, 2.01753732e-02f, -1.91022512e-02f,
  -8.29964411e-03f, -4.64053303e-02f, -2.90372878e-01f, -2.21313417e-01f, -3.80923003e-02f, -1.12334147e-01f, -8.12479779e-02f, -1.46818474e-01f, -1.10009007e-01f, -2.09132627e-01f,
  -8.91088843e-02f, -1.47235900e-01f, -6.40073046e-02f, -1.24906972e-01f, -1.46022856e-01f, -1.34990916e-01f, -2.14104187e-02f, -1.20149083e-01f, -2.26724863e-01f, -7.62945041e-02f,
  -7.50738457e-02f, -3.32007349e-01f, -1.80992261e-01f, -1.86151043e-01f, -1.72576040e-01f, -1.72327906e-01f, -1.66828737e-01f, -1.91794246e-01f, -1.87525526e-01f, -2.84322083e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.78225660e-01f, -2.66404152e-01f, -9.89498422e-02f, -3.65824372e-01f, -3.20405871e-01f, -1.15869746e-01f, -2.54014075e-01f, -1.33627385e-01f, -1.58335671e-01f, -1.48593232e-01f,
  1.05360202e-01f, 5.27717583e-02f, -5.25522530e-02f, 3.00271008e-02f, -1.99486151e-01f, -3.85140598e-01f, -3.71023178e-01f, -3.50037575e-01f, -9.31874737e-02f, 1.00431241e-01f,
  -1.82501405e-01f, -2.86403000e-01f, -2.29674622e-01f, -2.04859823e-02f, -5.19034732e-03f, 8.86909515e-02f, -9.76354629e-02f, -1.90613583e-01f, 8.90928358e-02f, -1.44298777e-01f,
  2.20588446e-01f, 1.60477400e-01f, 1.05339296e-01f, -2.40690410e-02f, 6.04480170e-02f, -5.71399927e-02f, -2.30074357e-02f, -6.89760782e-03f, -4.95775305e-02f, -2.03134920e-02f,
  4.73573245e-02f, 1.14430919e-01f, 2.65469328e-02f, 1.30736455e-01f, 1.67923793e-02f, 1.02233760e-01f, 1.16021812e-01f, 6.43716902e-02f, 6.60103485e-02f, 1.51282370e-01f,
  2.86129937e-02f, 9.34693068e-02f, 1.67454690e-01f, 2.33782053e-01f, 7.79159814e-02f, 7.11421892e-02f, 2.77378738e-01f, 1.93081826e-01f, 2.54325300e-01f, 1.93565294e-01f,
  -8.83559063e-02f, 3.49256247e-02f, 1.47597224e-01f, -4.57142200e-03f, 1.21612772e-01f, 3.99117209e-02f, -2.35127490e-02f, -5.13186604e-02f, -1.17619876e-02f, 3.19329873e-02f,
  1.56363949e-01f, -1.13002257e-02f, 1.35455325e-01f, -7.15613589e-02f, 3.89505527e-03f, -5.28987981e-02f, -9.82418004e-03f, -5.67492237e-03f, 1.84843749e-01f, 5.80537692e-02f,
  4.40332554e-02f, 9.20248330e-02f, -1.32563524e-02f, 1.05827324e-01f, 1.23959221e-01f, 5.44311292e-02f, 1.76660158e-02f, 1.04648195e-01f, -9.87028182e-02f, -1.88309234e-03f,
  1.03081144e-01f, 7.31385720e-04f, -4.56802398e-02f, 3.35964225e-02f, 9.68580879e-03f, -3.80959455e-03f, 5.29536568e-02f, -3.16440500e-02f, -1.41402870e-01f, 5.42608239e-02f,
  -2.75769569e-02f, -1.40909175e-03f, -4.28898409e-02f, 4.65431735e-02f, 7.35650435e-02f, 1.12691984e-01f, 6.07246906e-02f, 6.79882243e-02f, 3.42684286e-03f, 5.11021055e-02f,
  7.20376298e-02f, 1.83975268e-02f, 2.05044728e-02f, 8.65100771e-02f, -2.29489952e-02f, -9.30471644e-02f, 1.02127576e-02f, 1.69734135e-01f, -4.13157903e-02f, -1.55259110e-02f,
  -1.71338111e-01f, -1.96260512e-01f, -3.39723736e-01f, -6.98627904e-02f, -1.20431527e-01f, 7.69077688e-02f, -1.99457273e-01f, 1.12876341e-01f, 1.62592500e-01f, -3.22901696e-01f,
  -3.31599303e-02f, 2.00386554e-01f, -1.16047300e-01f, -1.02566816e-01f, 1.09321177e-02f, -4.02803570e-01f, -3.11261564e-01f, -4.31295037e-02f, 2.49697775e-01f, 3.63770843e-01f,
  2.38738671e-01f, 2.15207487e-01f, 3.00021946e-01f, 1.69997171e-01f, -1.82734102e-01f, -4.38453369e-02f, -3.20839614e-01f, -1.17981769e-01f, -2.13860542e-01f, -4.97152567e-01f,
  -4.28903997e-01f, -1.24335205e-02f, -8.18153918e-02f, 1.37426510e-01f, -3.50086279e-02f, 3.41283195e-02f, 6.31456375e-02f, 1.36877513e-02f, 5.65055646e-02f, -3.91941220e-02f,
  4.54750583e-02f, 1.07877329e-01f, 1.57293275e-01f, 1.09728113e-01f, 1.08562164e-01f, 1.81593835e-01f, 8.38240534e-02f, 6.83842078e-02f, -3.50284502e-02f, -4.13179956e-03f,
  4.66326103e-02f, -6.79006726e-02f, -5.63768260e-02f, -2.89977882e-02f, -5.20519055e-02f, -7.82577917e-02f, -1.49471715e-01f, -3.04836277e-02f, -1.01287872e-01f, -4.09213483e-01f,
  -5.71384281e-02f, -2.85575967e-02f, -2.45146416e-02f, -1.99302915e-03f, 7.94251263e-02f, 3.91993858e-02f, -4.17035557e-02f, 3.85464244e-02f, -3.32298912e-02f, -7.57081527e-03f,
  1.18243545e-01f, -1.35329841e-02f, 7.98425078e-03f, -9.62995738e-03f, 5.49688451e-02f, 3.06679271e-02f, -4.80665974e-02f, -6.43519238e-02f, 5.42500429e-03f, -2.49520447e-02f,
  6.39768392e-02f, 3.82290743e-02f, 7.71090612e-02f, 9.99537334e-02f, -3.96086834e-02f, -7.35970587e-03f, -1.37362137e-01f, 5.59294485e-02f, 8.25027749e-02f, 3.13779972e-02f,
  1.24516793e-01f, -1.27071008e-01f, -2.68557757e-01f, 1.34581640e-01f, -2.28369720e-02f, -4.89859562e-03f, -1.91543624e-01f, 1.06474601e-01f, -1.64576340e-03f, 4.85338941e-02f,
  7.64785111e-02f, -5.31762950e-02f, 1.97187401e-02f, 3.50987772e-03f, 1.32759005e-01f, 1.42558143e-02f, -6.90582767e-02f, -8.17925334e-02f, 5.19091450e-03f, 1.02176972e-01f,
  -3.36364619e-02f, 5.87661518e-03f, 1.12148980e-02f, -3.51736769e-02f, -8.45560655e-02f, -1.26284108e-01f, -1.48499638e-01f, -1.63529992e-01f, -1.36555135e-01f, -1.67401016e-01f,
  -1.77171543e-01f, -2.77072489e-01f, -6.07280359e-02f, 1.56752989e-01f, 1.90588623e-01f, 1.01706780e-01f, -2.78119892e-01f, -8.65640491e-02f, 1.58436254e-01f, -3.05591047e-01f,
  2.66469363e-02f, 3.11679170e-02f, -2.04045326e-01f, -2.36928478e-01f, -5.33397317e-01f, -5.64407825e-01f, -4.11794841e-01f, -2.62763649e-01f, -1.39074728e-01f, -7.26381689e-02f,
  7.43041113e-02f, 6.76772296e-02f, -7.10934773e-02f, 8.45431015e-02f, 1.13181293e-01f, 1.91966876e-01f, -5.79396114e-02f, 6.43582121e-02f, 2.93925852e-02f, -1.04086027e-01f,
  -8.53839144e-02f, 3.54216285e-02f, 6.52467012e-02f, -2.80645899e-02f, 1.57155111e-01f, 3.97258960e-02f, -1.52118653e-02f, -4.60915715e-02f, -3.76404338e-02f, 2.70596007e-04f,
  -4.37647812e-02f, -1.40445083e-01f, 1.45063281e-01f, 9.32183862e-02f, -2.27907347e-03f, -5.63880391e-02f, -3.89084592e-02f, -1.24162510e-01f, -5.25386147e-02f, -2.94287335e-02f,
  -7.28380308e-02f, 8.71275961e-02f, -5.23109697e-02f, -3.93526591e-02f, -1.66663975e-02f, 9.89853777e-03f, 1.70184240e-01f, 2.36907125e-01f, 5.16657531e-02f, -1.96244508e-01f,
  -3.00650299e-02f, 4.61722687e-02f, 1.06329277e-01f, -1.63564347e-02f, -4.52566147e-02f, -1.91168301e-03f, -4.71029729e-02f, -4.12380658e-02f, 1.78830568e-02f, -9.90332216e-02f,
  1.73558481e-02f, -5.04922606e-02f, 1.49978418e-02f, -1.86825439e-01f, 6.04555849e-03f, 9.56250262e-03f, 7.85597041e-02f, -8.23315307e-02f, -1.34171974e-02f, 6.65152222e-02f,
  -1.07640043e-01f, 1.91237390e-01f, 1.26333207e-01f, 1.22025535e-01f, -1.30908966e-01f, -1.30731519e-02f, 7.15056360e-02f, 3.56495404e-03f, -2.48172600e-02f, -6.09987229e-02f,
  8.08103904e-02f, 1.86093955e-03f, -3.73434275e-02f, -1.74924672e-01f, -2.18607560e-02f, 1.22258492e-01f, 1.11888647e-01f, -9.37537476e-02f, 6.80743605e-02f, 6.28701225e-03f,
  -1.19197100e-01f, -1.99834481e-01f, -4.55582030e-02f, 7.50504211e-02f, -3.51439975e-02f, -1.45861164e-01f, -1.94596648e-01f, 2.22731158e-02f, -1.04775697e-01f, 7.84481466e-02f,
  -1.15812920e-01f, -9.23845619e-02f, -1.89347908e-01f, -2.14625195e-01f, -7.36281369e-03f, -1.88403860e-01f, -1.17394321e-01f, 1.84506640e-01f, -1.21489175e-01f, -3.98156196e-01f,
  -2.30898619e-01f, 4.92599666e-01f, 7.05588609e-02f, -1.52835906e-01f, 3.53133172e-01f, 4.54302430e-01f, 6.96856380e-01f, 2.12628767e-01f, -3.46723497e-02f, 1.85756177e-01f,
  2.70647019e-01f, -1.83525428e-01f, -3.13191503e-01f, -8.59560370e-02f, 4.97058518e-02f, 9.83550958e-03f, -2.09260434e-01f, -2.86247045e-01f, -1.68896139e-01f, 4.74808551e-02f,
  -1.07836470e-01f, -6.57797456e-02f, -1.18713968e-01f, -2.23119885e-01f, -2.05527321e-01f, -3.67634147e-01f, -4.89945002e-02f, 1.33010121e-02f, 1.27249524e-01f, -3.94605428e-01f,
  -1.47806555e-01f, 2.72329420e-01f, -2.63705313e-01f, -1.68989688e-01f, -2.28724610e-02f, -2.39064083e-01f, -1.30863329e-02f, -3.77612412e-02f, 1.01172686e-01f, -4.86282855e-02f,
  9.12952125e-02f, 1.31869391e-01f, -1.67754889e-02f, 2.92739440e-02f, 2.28268281e-03f, 1.14428133e-01f, 9.42819789e-02f, -5.89738823e-02f, 2.38789413e-02f, 2.05726668e-01f,
  9.61754918e-02f, 1.48313031e-01f, 8.84163901e-02f, 1.45677626e-01f, 2.12819189e-01f, -1.74190044e-01f, 1.43402636e-01f, -2.94694267e-02f, 5.37463613e-02f, -2.24920318e-01f,
  -1.32502019e-01f, 5.45756221e-02f, 4.09585685e-02f, -3.70952114e-02f, -7.93074891e-02f, -2.82741282e-02f, -8.61788914e-02f, 3.00324112e-02f, 5.76828942e-02f, -6.66792225e-03f,
  2.24580374e-02f, -7.28410780e-02f, -1.43693462e-01f, -2.09398493e-02f, -7.58373439e-02f, -1.98728722e-02f, 3.85320969e-02f, -4.34529819e-02f, 1.42461330e-01f, 8.44628215e-02f,
  -9.39345434e-02f, -3.61821726e-02f, 5.61089925e-02f, -9.31399390e-02f, -6.50355243e-04f, -1.46150112e-01f, -7.58865550e-02f, 6.91380352e-02f, 7.20583647e-02f, -3.43804737e-03f,
  -1.30619302e-01f, 3.02346438e-01f, -4.31423962e-01f, 8.04602355e-02f, 4.78624851e-02f, 1.23018347e-01f, -1.01325253e-03f, -2.32721586e-02f, 5.33105917e-02f, -3.56915817e-02f,
  1.56891897e-01f, -1.36339083e-01f, 7.57385269e-02f, 4.05965410e-02f, -1.45786613e-01f, 5.19683026e-02f, 4.18868549e-02f, -1.50411859e-01f, 2.62911599e-02f, -4.83832583e-02f,
  -1.63969368e-01f, -1.78437252e-02f, -2.24293008e-01f, -1.82209760e-01f, -1.96154460e-01f, -3.61603439e-01f, -7.67853484e-02f, -5.09369820e-02f, -3.40278856e-02f, -2.20741093e-01f,
  -2.54145950e-01f, 1.54085338e-01f, -1.81345850e-01f, -1.59869090e-01f, -7.06306323e-02f, -4.09084223e-02f, -1.52924225e-01f, 1.73445657e-01f, 2.02032208e-01f, -1.84877604e-01f,
  5.78639880e-02f, -1.14016188e-02f, -1.51188690e-02f, -1.44923463e-01f, -1.35574669e-01f, -3.69578332e-01f, -3.27726871e-01f, -4.33741182e-01f, -2.77521342e-01f, -1.62408993e-01f,
  -2.44446069e-01f, -3.68180901e-01f, -2.71519274e-01f, -1.12660453e-01f, -1.60504505e-01f, -2.47198299e-01f, -1.49022877e-01f, -9.69120115e-02f, -1.48386031e-01f, -1.63934723e-01f,
  -4.15134043e-01f, 1.85727477e-01f, 1.47714674e-01f, 2.99328640e-02f, -4.64364737e-02f, 1.41868055e-01f, -1.03792265e-01f, 8.94743297e-03f, 1.17195278e-01f, 1.27515644e-01f,
  -2.04852317e-02f, -9.24418028e-03f, -2.49235760e-02f, -1.79254021e-02f, -1.92730799e-02f, 2.41892766e-02f, -4.36299555e-02f, 4.77296971e-02f, 3.66814993e-02f, 1.18024766e-01f,
  6.67082553e-04f, 4.60358076e-02f, 2.89220065e-02f, 9.59948301e-02f, 1.43252432e-01f, 4.04719710e-02f, 1.86643019e-01f, 1.93433329e-01f, 2.17883795e-01f, 3.34884450e-02f,
  5.69966547e-02f, -4.89580445e-02f, -3.60482112e-02f, 6.96304590e-02f, 5.56072779e-02f, 8.91167223e-02f, -1.06630556e-01f, -1.93604916e-01f, 1.88558940e-02f, -4.49805148e-02f,
  7.28971586e-02f, 6.44991323e-02f, 4.21349965e-02f, -1.44227892e-01f, -1.57238573e-01f, -4.69587967e-02f, -1.35548726e-01f, 4.35032742e-03f, -1.02979876e-01f, 9.31524113e-02f,
  1.22116292e-02f, 1.17955273e-02f, -8.66667479e-02f, 4.49264236e-02f, 8.72424915e-02f, 5.65181673e-02f, 5.96956015e-02f, 6.53999299e-02f, -1.09107364e-02f, -8.27680994e-03f,
  -1.54429197e-01f, -5.03113829e-02f, -2.47150660e-02f, 1.02501690e-01f, -7.21973404e-02f, 8.92210528e-02f, 1.42139420e-01f, 7.44050741e-02f, -5.53610958e-02f, -9.63517204e-02f,
  7.91025609e-02f, -2.92541534e-01f, -8.76673087e-02f, -3.59607749e-02f, -4.74474132e-02f, -6.85195848e-02f, -4.01282385e-02f, -5.19051887e-02f, 2.10473104e-03f, -3.54218036e-02f,
  4.73436899e-02f, 4.10241373e-02f, -1.00696564e-01f, 2.00271569e-02f, 6.82239011e-02f, -1.42292827e-01f, -8.70701745e-02f, 4.87937704e-02f, -1.14995211e-01f, 3.77892256e-02f,
  -2.74150729e-01f, -1.50144361e-02f, 1.94684602e-02f, 1.91562876e-01f, 3.15031648e-01f, 3.83028507e-01f, 3.35131168e-01f, 2.53705114e-01f, 1.19224206e-01f, -3.01777702e-02f,
  -1.93258211e-01f, -1.32190427e-02f, 9.22368988e-02f, -2.68516596e-02f, 1.87208638e-01f, 2.30360299e-01f, 2.82832295e-01f, 1.17318287e-01f, 1.15192965e-01f, -1.92473959e-02f,
  4.18679155e-02f, -1.20311983e-01f, -1.47381186e-01f, -6.26401529e-02f, 8.03377330e-02f, 4.11280394e-02f, -6.06300980e-02f, -3.17361988e-02f, 6.92243427e-02f, 3.96380499e-02f,
  -1.76911101e-01f, -7.48767480e-02f, 6.64961636e-02f, -1.11689650e-01f, -1.66356802e-01f, -1.75405562e-01f, -1.25502702e-02f, -1.88617647e-01f, -9.63243991e-02f, -1.25677943e-01f,
  -5.22410311e-02f, -1.11649245e-01f, 8.95770192e-02f, 8.03630725e-02f, -3.10757104e-02f, -2.69909389e-02f, -1.82639975e-02f, 1.03273273e-01f, 1.30373284e-01f, 1.85826253e-02f,
  6.37785047e-02f, 9.94360447e-02f, 1.74210042e-01f, 1.60335720e-01f, 2.39829019e-01f, -1.87084172e-02f, -7.91938324e-03f, 7.71227106e-02f, 3.65775526e-02f, -7.03126518e-03f,
  8.76626447e-02f, 9.60643888e-02f, 6.95001706e-02f, 7.96709210e-02f, 1.69132993e-01f, -1.17051445e-01f, -2.16828473e-03f, 1.27496749e-01f, 2.25277022e-01f, -7.62772234e-03f,
  9.21705216e-02f, 2.44561538e-01f, 1.60905287e-01f, -1.09592780e-01f, -6.53879344e-02f, 4.77036461e-02f, 1.11899883e-01f, 7.73338892e-04f, -9.28172469e-02f, 4.48792195e-03f,
  8.08026269e-02f, 3.80731262e-02f, -5.61842993e-02f, 1.72383368e-01f, -7.99074620e-02f, -1.88182034e-02f, -1.26902768e-02f, 2.56251357e-02f, -4.35939543e-02f, -3.76262963e-02f,
  8.04035813e-02f, 2.31035620e-01f, 1.23228803e-01f, 7.73936212e-02f, -7.56094009e-02f, -2.24089757e-01f, 9.76748914e-02f, -1.03231139e-01f, -6.45918101e-02f, 5.33692492e-03f,
  1.41971803e-03f, -1.25522286e-01f, 4.02872451e-02f, 2.94889770e-02f, -5.86604215e-02f, -7.80528560e-02f, -2.66829096e-02f, 4.59066108e-02f, 6.26742914e-02f, 2.00942089e-03f,
  1.51772439e-01f, 4.90007065e-02f, 6.12332188e-02f, 2.53821939e-01f, 1.68920219e-01f, 2.37200595e-02f, -1.01296030e-01f, 6.26334772e-02f, -3.39910872e-02f, -1.43505365e-01f,
  -5.87722778e-01f, 4.21422720e-02f, 9.44008604e-02f, -1.24786653e-01f, 3.55671138e-01f, 2.93235313e-02f, -4.92226891e-02f, -2.68293351e-01f, -4.86064553e-02f, 3.92347947e-03f,
  1.05209328e-01f, 1.06326558e-01f, 1.03841648e-01f, -3.81920896e-02f, -2.91872323e-01f, 2.11379509e-02f, 2.79302210e-01f, 9.12325382e-02f, -1.77159652e-01f, -2.17900828e-01f,
  1.42562658e-01f, -9.67316981e-03f, -1.84326231e-01f, -6.37238771e-02f, -2.31093611e-03f, -2.82619633e-02f, 1.98497966e-01f, 2.92577390e-02f, 8.29304382e-02f, 1.65082395e-01f,
  -8.64544511e-02f, -1.83424801e-01f, 1.20616123e-01f, 4.11961414e-02f, 2.96785627e-02f, -1.05884649e-01f, 2.55715270e-02f, 7.35618323e-02f, 3.30400355e-02f, -4.75842841e-02f,
  1.51434556e-01f, 1.20032527e-01f, 1.10580094e-01f, 9.42992866e-02f, -1.74414784e-01f, -2.26834685e-01f, -1.32841170e-01f, -1.23388261e-01f, -2.76320189e-01f, -2.18841255e-01f,
  1.20785862e-01f, 5.03064021e-02f, -2.12287515e-01f, -6.56050667e-02f, -1.08681425e-01f, -5.85753918e-02f, -1.62201688e-01f, -2.97196627e-01f, -1.88487917e-01f, -2.09696025e-01f,
  -6.99754879e-02f, 3.84629704e-02f, -1.31449103e-02f, -6.08712882e-02f, -2.90808957e-02f, 5.62627474e-03f, 1.61321416e-01f, 3.76664847e-02f, -2.50692368e-02f, -8.27598125e-02f,
  8.05561170e-02f, 1.50307074e-01f, 8.50831419e-02f, -6.73395693e-02f, 5.42389154e-02f, 9.28880498e-02f, -2.10901145e-02f, -9.36600193e-02f, -1.38973454e-02f, -1.95791740e-02f,
  4.98131029e-02f, -4.70069684e-02f, 4.73122671e-02f, -2.44365171e-01f, 2.27502231e-02f, -6.69642957e-03f, 2.25505307e-02f, -9.07301158e-02f, 1.01108914e-02f, 9.28322151e-02f,
  -2.08431736e-01f, 3.24453622e-01f, -1.09454408e-01f, -6.31630886e-03f, -8.57075229e-02f, -9.96844191e-03f, 1.00917898e-01f, 2.65307091e-02f, 4.00291197e-03f, -1.26892835e-01f,
  -5.78208826e-02f, -7.22711086e-02f, -2.76010130e-02f, 1.45316556e-01f, -6.24958202e-02f, -5.80456667e-02f, 1.07433096e-01f, 5.91290817e-02f, -1.19660892e-01f, -2.07267001e-01f,
  9.02244970e-02f, -1.39611527e-01f, -2.74466813e-01f, -1.98148116e-01f, 5.08708926e-03f, -1.78342387e-01f, -6.87551871e-02f, -1.76925868e-01f, -1.62263811e-01f, -3.32730442e-01f,
  -8.65293324e-01f, 1.39016211e-01f, 2.18178015e-02f, -4.53746170e-01f, -4.68829274e-02f, 1.82932377e-01f, 2.76982874e-01f, 5.57436235e-02f, -1.81498960e-01f, -1.04139633e-01f,
  1.09652132e-01f, -1.68365594e-02f, -4.46368009e-02f, 1.95592731e-01f, 2.26055607e-02f, 8.92583467e-03f, -1.00622766e-01f, -5.55630550e-02f, 7.57595152e-02f, 3.88663739e-01f,
  1.26708552e-01f, -1.65216982e-01f, -2.48948142e-01f, 3.56555940e-03f, -6.02700338e-02f, -1.06183074e-01f, -1.69051722e-01f, -1.55040190e-01f, 1.18035711e-01f, -2.34723389e-01f,
  -9.01647806e-02f, -2.37922385e-01f, 8.75976905e-02f, -1.06071144e-01f, -7.40907416e-02f, 1.80842914e-02f, -3.24325822e-02f, -1.91361666e-01f, -1.43839885e-02f, -9.08724144e-02f,
  -4.91446853e-02f, 1.52441368e-01f, -1.37078390e-01f, 5.14704734e-02f, -9.45188552e-02f, -7.99399838e-02f, 5.71979545e-02f, -8.63919780e-02f, 7.93807581e-02f, 1.43109262e-01f,
  2.08318666e-01f, 1.64920259e-02f, -8.35632384e-02f, 1.31728575e-01f, 3.51045025e-03f, 2.82774381e-02f, 8.79060477e-02f, 8.65519792e-03f, 1.51474148e-01f, -2.84837574e-01f,
  1.17056020e-01f, -1.14134783e-02f, 2.17824858e-02f, -1.41161323e-01f, -6.01208918e-02f, -6.10948950e-02f, -9.36713591e-02f, 1.93367526e-02f, 6.66532442e-02f, -5.56732044e-02f,
  -9.36937109e-02f, 1.04081310e-01f, 2.93214619e-02f, -5.79533167e-02f, -2.92624962e-02f, -9.35473666e-03f, -1.25554442e-01f, -3.00934799e-02f, 1.24473134e-02f, -1.28151476e-01f,
  -6.95214868e-02f, 5.35080507e-02f, -8.39782283e-02f, 7.07616359e-02f, 4.00003120e-02f, -5.97904846e-02f, 4.72366065e-02f, 6.81496710e-02f, 3.30263898e-02f, 4.50371206e-02f,
  -2.91053265e-01f, 1.15451682e-03f, -1.97621912e-01f, 7.08280280e-02f, 2.27473341e-02f, 2.42246743e-02f, -9.71573126e-03f, 9.02874619e-02f, -1.92868963e-01f, 1.99006754e-03f,
  1.42325819e-01f, -1.55511638e-02f, -8.23690370e-02f, 1.26624815e-02f, -3.03679742e-02f, -1.35415550e-02f, 8.00808426e-03f, -1.35944650e-01f, 5.80562018e-02f, 6.39292002e-02f,
  1.50493756e-01f, -8.57030507e-03f, -9.12710130e-02f, 6.69791177e-02f, -2.98167281e-02f, -6.87071756e-02f, 1.35218516e-01f, 8.63124207e-02f, 6.75674935e-04f, -1.88725933e-01f,
  8.22636604e-01f, 1.74477980e-01f, 2.66484320e-01f, 2.58095890e-01f, 2.50125080e-02f, 1.56884015e-01f, 3.97702247e-01f, 2.13999629e-01f, 1.87652171e-01f, 1.47318050e-01f,
  -8.44664425e-02f, -2.24997371e-01f, -9.72872227e-02f, -3.52333225e-02f, 5.93776517e-02f, 1.03088565e-01f, 3.14927846e-02f, 2.02389538e-01f, 1.78743973e-01f, 1.68797866e-01f,
  -1.04150504e-01f, 4.98465896e-02f, 1.61037669e-01f, -1.11904759e-02f, -1.34522393e-01f, -7.99295306e-02f, -3.00404243e-02f, 3.07124313e-02f, -2.27255039e-02f, -2.57776856e-01f,
  -2.73424536e-01f, 1.76252455e-01f, -1.44280240e-01f, -1.96960583e-01f, -3.26871648e-02f, -5.16478531e-02f, 6.73526675e-02f, 1.79969385e-01f, 4.29082736e-02f, -8.71124119e-02f,
  -1.63976997e-01f, 5.83680309e-02f, -1.14765624e-03f, 3.99585739e-02f, 1.28056914e-01f, -5.59624052e-03f, 1.77190289e-01f, 3.36213671e-02f, 7.00516254e-02f, -6.07644655e-02f,
  -1.30565360e-01f, 1.75807104e-01f, 1.45795956e-01f, 2.07456753e-01f, 2.40087584e-02f, -4.76039685e-02f, 3.50094773e-02f, 9.28033441e-02f, 4.66508372e-03f, 1.26629069e-01f,
  -9.43105370e-02f, 1.67950913e-02f, 4.08472344e-02f, 1.35245323e-01f, 6.25244528e-02f, -1.28695995e-01f, -7.80831277e-02f, 2.58691497e-02f, 5.38889877e-02f, 7.84549713e-02f,
  2.14258451e-02f, -8.60951021e-02f, 7.01409057e-02f, 2.22877339e-02f, -6.51688129e-02f, 1.95627734e-02f, 3.39928716e-02f, -2.62303278e-03f, -3.63927558e-02f, 7.54411891e-03f,
  -8.54140520e-03f, -5.12950197e-02f, 1.22480672e-02f, -1.23066651e-02f, 2.99049797e-03f, -3.71389790e-04f, -1.32399246e-01f, -2.79727075e-02f, -6.82276189e-02f, 2.08726190e-02f,
  -3.20822835e-01f, 9.80398734e-04f, -2.35671714e-01f, -1.26815468e-01f, -4.25752625e-02f, 2.19285227e-02f, -1.25086069e-01f, 9.16083828e-02f, -2.50541300e-01f, -1.01498589e-01f,
  -2.33813040e-02f, -9.46024880e-02f, 3.35116871e-02f, 1.13042690e-01f, 1.03840843e-01f, 1.68019217e-02f, -1.04620658e-01f, 6.53941929e-02f, -9.31252763e-02f, -1.99382618e-01f,
  2.52905618e-02f, 8.97359177e-02f, 2.53526032e-01f, 4.71766256e-02f, 4.49600024e-03f, -7.46240094e-02f, -6.90781046e-04f, 1.11129405e-02f, -4.20954498e-03f, 1.47474319e-01f,
  6.73503101e-01f, -3.57008815e-01f, -2.09881946e-01f, 4.92645137e-04f, -2.28700802e-01f, 3.73284258e-02f, -1.76374465e-01f, 1.26256838e-01f, 6.36123344e-02f, -3.04923922e-01f,
  -5.20181470e-02f, 3.49501491e-01f, 2.46919915e-01f, 1.66021734e-01f, 1.68174759e-01f, -4.09074038e-01f, -2.61613160e-01f, 1.29578382e-01f, 3.00120026e-01f, 1.77017197e-01f,
  -1.72244851e-02f, -6.51743412e-02f, 1.56245932e-01f, 2.83734072e-02f, -4.23245847e-01f, -9.80680212e-02f, -4.10681963e-01f, -1.79025784e-01f, -2.52186269e-01f, -5.08266211e-01f,
  -3.15229058e-01f, 8.14900100e-02f, 1.39469326e-01f, 6.66259415e-03f, -1.53273031e-01f, 1.83851600e-01f, 1.35625424e-02f, 9.58238393e-02f, 1.46800980e-01f, 2.75736488e-02f,
  8.57571587e-02f, -1.01382062e-01f, 1.49616599e-02f, -3.64695564e-02f, -1.29551053e-01f, -1.46689070e-02f, -2.93624736e-02f, -3.43563817e-02f, -1.94700658e-02f, -1.43978640e-01f,
  9.91377980e-03f, 3.28413099e-02f, -2.29736641e-02f, 1.00592181e-01f, 1.89505205e-01f, 9.10468325e-02f, -6.89823506e-03f, -1.80980202e-03f, 1.08901247e-01f, -1.60718620e-01f,
  -7.74590224e-02f, 9.68349278e-02f, -6.28738850e-02f, 3.44593935e-02f, -2.95484737e-02f, 3.04615665e-02f, 1.29109502e-01f, -1.78872515e-02f, 9.42750946e-02f, -2.54601091e-02f,
  2.83008367e-02f, -1.38605073e-01f, 4.58194464e-02f, -1.30406348e-02f, -1.02680750e-01f, 1.48095912e-03f, 5.36256656e-02f, -1.20539434e-01f, 6.84019178e-02f, -2.16865521e-02f,
  -5.30923903e-02f, -6.50948361e-02f, -1.00787364e-01f, -9.91248786e-02f, -1.88775465e-01f, 3.11109424e-02f, -9.48067568e-03f, -8.84656385e-02f, 2.05353145e-02f, 2.18750294e-02f,
  -1.38810694e-01f, 1.52922422e-01f, 2.29514036e-02f, 2.14011930e-02f, -5.96920475e-02f, -9.17126089e-02f, 4.88284864e-02f, -5.12590669e-02f, -1.93064306e-02f, 6.78756163e-02f,
  -2.84946933e-02f, 1.09589174e-01f, -6.82026297e-02f, 1.90391042e-03f, -3.78185026e-02f, 7.92202912e-03f, 7.66943991e-02f, 1.49234831e-01f, -9.71264839e-02f, -1.15380496e-01f,
  -1.48381278e-01f, 1.06250159e-01f, 1.82880163e-01f, 2.25872040e-01f, 8.83128196e-02f, 2.38245741e-01f, 4.89732735e-02f, -6.49337396e-02f, 1.02540933e-01f, -2.93639284e-02f,
  -5.19965053e-01f, -3.47422175e-02f, -1.55987442e-01f, -3.31378102e-01f, 1.24443918e-01f, 1.20903760e-01f, 3.64838928e-01f, 7.70346671e-02f, -1.85652301e-01f, -3.26777510e-02f,
  -1.88585714e-01f, -1.10938869e-01f, 6.73463196e-03f, 1.74301431e-01f, 2.36428559e-01f, 2.06865937e-01f, 1.57253802e-01f, 2.09246591e-01f, 1.07078455e-01f, 7.15307891e-03f,
  1.99626014e-01f, -1.92523673e-02f, -2.53363252e-01f, -7.48254135e-02f, -4.03262265e-02f, 2.28015222e-02f, -1.32311210e-01f, -1.35643750e-01f, 1.37433842e-01f, 2.55775601e-01f,
  -2.53753990e-01f, -2.89904624e-01f, 6.66088611e-02f, -1.65437218e-02f, -6.72576800e-02f, -8.04598182e-02f, -7.42986798e-02f, -1.09664299e-01f, -3.43389139e-02f, -8.15499108e-03f,
  3.31180580e-02f, -1.94314774e-02f, 5.26080430e-02f, 2.59830467e-02f, 1.81787519e-03f, 4.13665287e-02f, -8.76584649e-03f, 6.58953041e-02f, -6.23174533e-02f, -1.26194358e-01f,
  1.69090927e-01f, -7.75782019e-03f, -1.69624567e-01f, 3.88064533e-02f, -3.78411114e-02f, -8.87696594e-02f, -6.74977750e-02f, -1.37995809e-01f, -1.07767843e-02f, -2.38603637e-01f,
  -2.39347853e-02f, 2.45726714e-03f, 2.40991847e-03f, 7.49583170e-02f, 7.21954033e-02f, 1.00816302e-01f, 1.09596722e-01f, 1.27104763e-02f, 2.42250357e-02f, 5.32059185e-03f,
  2.12994479e-02f, -1.17299430e-01f, -1.20489458e-02f, -8.87083858e-02f, 1.05652101e-01f, -6.67189062e-02f, 1.66286349e-01f, 2.64016856e-02f, -4.68967929e-02f, -7.34663084e-02f,
  -3.24671715e-02f, -8.71212035e-03f, -5.46448864e-02f, 1.07973918e-01f, 8.01517665e-02f, 4.76969741e-02f, -9.76296440e-02f, -9.24073160e-02f, -1.05832525e-01f, -1.20004445e-01f,
  -3.38744134e-01f, 1.75021335e-01f, -2.30072305e-01f, 1.03314370e-02f, -7.99247995e-02f, -9.22048241e-02f, -1.64975107e-01f, 5.27572855e-02f, -6.57391623e-02f, 1.04954027e-01f,
  -3.98876779e-02f, -5.85819297e-02f, -2.84018852e-02f, 5.26143983e-02f, 1.14287250e-01f, -1.83708102e-01f, 2.16827057e-02f, -2.66282763e-02f, -2.09044833e-02f, -9.92555320e-02f,
  -1.22550517e-01f, -9.06676278e-02f, -2.78282970e-01f, 1.93439797e-02f, -2.09794044e-02f, -1.66629270e-01f, -1.29461274e-01f, -1.56618461e-01f, -7.82933086e-02f, -2.74029016e-01f,
  -2.48392597e-01f, -2.60892928e-01f, 8.67960975e-02f, 6.15684874e-02f, 1.42362602e-02f, 5.23977056e-02f, -1.69018254e-01f, -1.15639418e-01f, -1.82131995e-02f, -2.93955430e-02f,
  -1.91100657e-01f, -4.04019468e-02f, 4.51356359e-02f, -7.37831220e-02f, -1.15517480e-02f, -6.52721375e-02f, 1.03954405e-01f, 1.70442108e-02f, 1.36148393e-01f, 9.08205882e-02f,
  -7.54242688e-02f, -1.86228320e-01f, -1.86331168e-01f, -7.92563781e-02f, -1.13602214e-01f, 1.36731952e-01f, -3.85807157e-02f, 1.21727232e-02f, 1.46622695e-02f, 5.58688566e-02f,
  4.75542307e-01f, -2.03566602e-03f, 8.38260129e-02f, -8.97852238e-03f, -6.31010719e-03f, -1.06178924e-01f, 1.04956478e-01f, 7.42263943e-02f, 2.83783264e-02f, 1.37636766e-01f,
  -7.33005330e-02f, -1.78245917e-01f, -1.60345644e-01f, -4.89858091e-02f, 6.67786272e-03f, -7.18301628e-04f, -2.38326833e-01f, 2.73453188e-03f, 1.10386163e-02f, 4.48298901e-02f,
  -4.25245054e-02f, -5.94548583e-02f, 1.16821274e-01f, 1.24983781e-03f, 4.31087501e-02f, 7.60519281e-02f, -2.65338439e-02f, -8.58422369e-03f, -6.18589018e-03f, -1.36536673e-01f,
  6.43048733e-02f, 8.74686912e-02f, 8.27912167e-02f, -1.11767929e-02f, -8.09488744e-02f, 2.30763443e-02f, 1.02861568e-01f, 2.84540597e-02f, -6.49024695e-02f, -2.43009657e-01f,
  -4.87782201e-03f, 1.42293975e-01f, 6.61693513e-02f, -4.79417555e-02f, -1.06660547e-02f, -3.97559889e-02f, -4.72401793e-04f, 4.01168950e-02f, -8.33487958e-02f, -1.63582355e-01f,
  -1.14957891e-01f, 1.63881585e-03f, -4.62038480e-02f, -1.20531514e-01f, -3.56086083e-02f, -1.04091443e-01f, -5.06406315e-02f, 7.51435233e-04f, -1.44147500e-01f, -1.50212899e-01f,
  4.24418718e-01f, 2.08353966e-01f, 5.65186404e-02f, -3.81397009e-02f, 3.67251933e-02f, -1.01109236e-01f, 1.10928975e-01f, 1.40245631e-01f, 2.59845734e-01f, 2.36270264e-01f,
  2.63600834e-02f, -5.42887999e-03f, -9.93173383e-03f, 3.31355222e-02f, 8.94209817e-02f, 4.87584099e-02f, -2.23447531e-01f, -8.47235322e-03f, 1.33252755e-01f, 2.36615732e-01f,
  -9.70867183e-03f, 1.05974771e-01f, 2.24430650e-01f, 1.13537416e-01f, 5.65855540e-02f, 8.13051090e-02f, 1.37863204e-01f, 1.40161410e-01f, 1.20192140e-01f, 6.10289201e-02f,
  5.22080541e-01f, 5.06575644e-01f, 9.25139710e-02f, 2.26754203e-01f, 2.52545178e-02f, 3.38733494e-02f, 1.10833950e-01f, 9.36167613e-02f, 2.20417138e-02f, 1.27922043e-01f,
  2.81338423e-01f, 1.39482394e-01f, 1.58875093e-01f, 1.76485255e-01f, 1.55892987e-02f, 4.93114255e-03f, -4.21736501e-02f, 5.92172816e-02f, 5.34958914e-02f, -4.20159996e-02f,
  -6.09678254e-02f, -1.73726588e-01f, 4.45932969e-02f, -4.78096306e-02f, -2.50723492e-02f, -3.83493170e-04f, -2.30726134e-02f, -6.78558722e-02f, 3.15661468e-02f, 6.29521161e-02f,
  1.23065569e-01f, 3.20186377e-01f, 8.00807774e-02f, 1.61879942e-01f, 9.49198455e-02f, 1.03052892e-01f, 1.69709966e-01f, 5.42757474e-02f, 1.66374817e-01f, 3.77792828e-02f,
  -1.30688334e-02f, 4.71940637e-02f, -1.34011395e-02f, 1.58690009e-02f, -1.05916739e-01f, -7.35678822e-02f, -3.08078472e-02f, -1.60701293e-02f, 3.54704149e-02f, 9.53199640e-02f,
  3.00006177e-02f, -8.37092921e-02f, -8.71441886e-02f, 2.32249429e-03f, 1.79681368e-02f, -2.14989707e-02f, 9.63427648e-02f, 9.72144306e-02f, 6.12940229e-02f, 6.81757927e-02f,
  -8.32983479e-02f, -6.90602735e-02f, 6.28047436e-02f, -7.64221624e-02f, -1.64135918e-02f, 6.75669163e-02f, 2.80495472e-02f, 5.02529852e-02f, -1.58411205e-01f, -1.08366422e-01f,
  -1.45547226e-01f, 1.25907585e-01f, 1.18946247e-01f, -1.18171424e-01f, -7.91788027e-02f, 2.31775502e-03f, 1.50299191e-01f, 3.39442939e-02f, -6.79227561e-02f, 1.01052895e-01f,
  1.27009759e-02f, 1.07158117e-01f, 1.12463400e-01f, -5.35892881e-02f, 1.27250459e-02f, 9.99546871e-02f, 4.04826254e-02f, 2.78063156e-02f, 4.03889269e-02f, -1.09745897e-01f,
  8.84913057e-02f, 1.43381953e-01f, -1.21663287e-02f, 6.94871917e-02f, 2.09038675e-01f, 4.49000783e-02f, 1.76857933e-01f, 4.90916371e-02f, 1.91587955e-01f, 1.33826241e-01f,
  1.81191310e-01f, 1.88586652e-01f, -3.61582935e-02f, -2.11472884e-02f, -1.09608851e-01f, -1.11224949e-01f, 1.06532000e-01f, 3.77201997e-02f, 4.71401401e-02f, 1.22285344e-01f,
  -3.37268971e-02f, 2.98203691e-03f, -7.71546038e-05f, -7.30879083e-02f, 4.37225681e-03f, 4.29161713e-02f, -7.70896897e-02f, -7.24458396e-02f, -1.10728584e-01f, -2.05865681e-01f,
  4.24662322e-01f, -5.51282525e-01f, 1.31333753e-01f, 1.80638000e-01f, 4.85613989e-03f, 2.09185351e-02f, -2.68077403e-01f, -4.81993519e-03f, 2.12005183e-01f, -1.71347633e-01f,
  9.75733772e-02f, 4.09766167e-01f, 3.95686746e-01f, 2.59607941e-01f, 1.93581432e-01f, -1.60147205e-01f, 2.05891207e-02f, 3.12556416e-01f, 3.39605331e-01f, 8.24655816e-02f,
  -5.73724769e-02f, -2.29889005e-01f, 1.24610312e-01f, -2.94254497e-02f, -2.11358055e-01f, 1.80426821e-01f, -1.27692401e-01f, -1.22191615e-01f, -6.33374304e-02f, -6.61911815e-02f,
  -3.41832265e-02f, -1.22389078e-01f, 2.61216968e-01f, 6.68017417e-02f, -1.71989948e-01f, -9.04769599e-02f, 1.69625711e-02f, -1.32395983e-01f, -6.09884635e-02f, -1.59127727e-01f,
  7.11310059e-02f, -1.35799209e-02f, 3.81829813e-02f, -1.32178560e-01f, -2.72426575e-01f, -9.06300843e-02f, -1.32353514e-01f, 1.93563849e-02f, 1.48690129e-02f, -5.28945141e-02f,
  3.03554069e-02f, -1.99785177e-02f, 8.35862756e-02f, 1.11872954e-02f, 1.02382705e-01f, 2.52462924e-01f, 2.45726723e-02f, -2.11485252e-02f, 8.91805291e-02f, -1.65360793e-01f,
  -2.48640571e-02f, 7.56583735e-02f, 5.88327199e-02f, -1.85666338e-03f, 1.53805045e-02f, 5.89939728e-02f, -3.72653902e-02f, 1.24588180e-02f, 7.70217646e-03f, -6.72021657e-02f,
  5.18669374e-02f, 1.77093893e-02f, -1.83265489e-02f, 1.90400369e-02f, 8.42410102e-02f, 8.61992314e-02f, 9.12486203e-03f, -4.72042011e-03f, 1.13565721e-01f, -8.74135420e-02f,
  8.76203179e-02f, 2.43202858e-02f, -1.29128054e-01f, -6.78363368e-02f, -8.39276537e-02f, -1.07453633e-02f, 1.18870348e-01f, 2.13717930e-02f, 2.30858009e-02f, -2.50260662e-02f,
  -1.59523025e-01f, 4.62944537e-01f, 1.43955037e-01f, 1.18405305e-01f, -9.29380134e-02f, -9.89359245e-02f, 1.29597843e-01f, 2.32234970e-02f, -8.55654329e-02f, -3.30556817e-02f,
  -1.11282654e-01f, 4.80526872e-02f, -3.10312677e-02f, -8.61584619e-02f, 6.25803322e-02f, 3.87980719e-03f, -4.25505266e-02f, 6.00213073e-02f, -1.25479586e-02f, -1.14437506e-01f,
  -4.44815978e-02f, 5.50645068e-02f, 1.69839546e-01f, 1.16280288e-01f, 2.02242553e-01f, 2.94338524e-01f, 6.16344139e-02f, -7.95895606e-02f, 2.17645198e-01f, -1.21931739e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -5.14488108e-02f, 5.65086715e-02f, -2.89406367e-02f, 3.41221064e-01f, 1.10526472e-01f, 6.89756945e-02f, 8.60954821e-02f, 1.67318434e-01f, 3.39933157e-01f, 2.43083574e-02f,
  8.88796821e-02f, -2.10457724e-02f, 6.83633760e-02f, 2.28441477e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.20065132e-01f, 2.42897794e-02f, 1.12896770e-01f, -3.34461443e-02f, 2.81475365e-01f, -1.54689252e-01f, 1.28203213e-01f, 7.94400796e-02f, 4.70631942e-02f, 6.61343485e-02f,
  -1.01765588e-01f, -2.22456618e-03f, 5.59775829e-02f, 1.13556981e-01f, 8.96925405e-02f, 7.42459223e-02f, 1.23600848e-02f, 1.11697778e-01f, -2.01732703e-02f, -4.13527675e-02f,
  4.01638672e-02f, 6.93244413e-02f, 7.80018270e-02f, 4.81083542e-02f, -1.66408136e-03f, -1.47368237e-01f, 1.75258562e-01f, -6.76831231e-02f, -5.68443723e-02f, 2.47862160e-01f,
  4.36296612e-02f, -1.45363703e-01f, 1.40690669e-01f, 7.12169185e-02f, 1.27454296e-01f, -1.51519403e-01f, -8.13626796e-02f, 2.36857290e-04f, -6.62502125e-02f, -1.02853570e-02f,
  4.79984805e-02f, 2.56075561e-02f, 3.71786542e-02f, 1.31988607e-03f, 2.23607086e-02f, -7.57238194e-02f, 8.70265290e-02f, -3.48665565e-02f, 1.65234670e-01f, 1.33916050e-01f,
  -1.65995106e-01f, 9.14685205e-02f, 2.92561203e-01f, 6.40921369e-02f, 1.27573356e-01f, -2.47158289e-01f, 2.39305496e-01f, -2.50882417e-01f, -2.14339077e-01f, -1.06221149e-02f,
  -1.47225022e-01f, -4.70967256e-02f, -9.66737866e-02f, -2.38144826e-02f, 7.71611258e-02f, 7.55550712e-02f, 7.50308707e-02f, 5.09043261e-02f, -6.75349087e-02f, 8.26693922e-02f,
  5.76147810e-02f, -2.05704361e-01f, 3.64338905e-02f, -5.33952601e-02f, -3.83249037e-02f, 4.08862829e-02f, -9.00908783e-02f, 6.05881438e-02f, 1.03526749e-01f, 1.09909520e-01f,
  1.91512369e-02f, 1.09417744e-01f, 1.78903099e-02f, -1.27089638e-02f, 6.04585297e-02f, -4.39666696e-02f, 6.27703592e-02f, 6.34911507e-02f, -9.29076001e-02f, -1.12128310e-01f,
  -1.05847165e-01f, 2.60705918e-01f, 8.42644572e-02f, 4.07523215e-02f, 1.85207620e-01f, 1.99430183e-01f, 1.57985523e-01f, -6.73374608e-02f, -1.09603256e-02f, -2.27178752e-01f,
  -3.08026075e-02f, 1.48473918e-01f, -1.19043142e-01f, 3.31451222e-02f, -4.78842705e-02f, -7.02141747e-02f, -1.43567204e-01f, 1.87666073e-01f, 2.35884935e-01f, -1.41597286e-01f,
  4.70347740e-02f, 1.16441781e-02f, 4.74612117e-01f, -1.66250587e-01f, 7.95128196e-02f, -4.10786718e-02f, -9.65522230e-03f, 1.64374337e-01f, 1.76194429e-01f, -1.10928468e-01f,
  2.07549438e-01f, 2.01745719e-01f, 5.77408001e-02f, -2.04580277e-01f, 3.71542908e-02f, -1.55330524e-01f, 4.33697253e-02f, -4.54439282e-01f, -1.66296829e-02f, 7.21327215e-02f,
  -1.01071902e-01f, -1.05353445e-01f, -1.12913065e-02f, -9.72530246e-02f, -9.26329494e-02f, -3.32684373e-03f, -8.52387324e-02f, -4.51906788e-04f, -1.10377386e-01f, -3.49373627e-03f,
  1.78528689e-02f, 7.15348423e-02f, -3.25192325e-02f, -5.81068657e-02f, -1.38988718e-01f, -1.94940254e-01f, -8.09792355e-02f, 1.20693650e-04f, -1.08751372e-01f, 1.90087333e-02f,
  -1.49663463e-01f, -9.06780828e-03f, -1.50167421e-01f, 8.05057734e-02f, -2.26739854e-01f, -2.14595065e-01f, 1.36880293e-01f, 1.55479789e-01f, -3.12516503e-02f, 1.13206372e-01f,
  -5.61072258e-03f, 7.87532479e-02f, 2.65627149e-02f, -4.00247872e-02f, 5.09278402e-02f, 3.51832025e-02f, 1.74204335e-01f, -1.54957905e-01f, 5.34430556e-02f, 9.83764902e-02f,
  2.38219742e-02f, -2.21045967e-02f, 2.58041434e-02f, 1.00775138e-02f, -4.91716862e-02f, 4.70927395e-02f, -6.40612766e-02f, 4.18766867e-03f, -3.03578824e-01f, 8.80552530e-02f,
  2.41583716e-02f, -2.17343062e-01f, -1.78168654e-01f, 5.20236716e-02f, -1.04744650e-01f, -2.24506781e-01f, -2.28059255e-02f, 7.26481602e-02f, 1.07001446e-01f, 1.56526163e-01f,
  -5.84681220e-02f, -1.68064106e-02f, 4.05991413e-02f, -2.65564630e-03f, 2.26619951e-02f, -1.38876945e-01f, 9.57556963e-02f, -1.23893274e-02f, -1.05887190e-01f, -2.35119369e-02f,
  -5.59666120e-02f, 4.80420180e-02f, 2.68147923e-02f, -9.02452227e-03f, 5.57887368e-02f, -7.02841133e-02f, 1.35680854e-01f, -2.35438626e-02f, -1.27955884e-01f, -1.16321640e-02f,
  -3.57112214e-02f, 1.51131839e-01f, 9.58018526e-02f, -1.07835066e-02f, -2.90370267e-02f, 2.87167039e-02f, -9.48114991e-02f, 4.27003317e-02f, -1.89612001e-01f, 1.91567898e-01f,
  2.56622106e-01f, 4.15836796e-02f, -1.20422408e-01f, 2.22025141e-02f, -1.17527708e-01f, 3.31684016e-02f, 3.49229127e-02f, 1.69479847e-01f, 1.30834088e-01f, 1.71818897e-01f,
  2.76998412e-02f, -1.52063109e-02f, 7.46661564e-03f, 4.26440947e-02f, -1.79676384e-01f, 8.21305886e-02f, 1.26428828e-01f, -1.11306399e-01f, -7.20293075e-02f, -7.85377622e-02f,
  1.25201479e-01f, 1.07949330e-02f, -1.50821671e-01f, -4.23265219e-01f, -1.78626359e-01f, 1.68762952e-01f, 1.92482080e-02f, -5.08055761e-02f, 1.61605835e-01f, -1.62789240e-01f,
  1.59575343e-01f, -1.18103273e-01f, 2.63187638e-03f, -5.49228452e-02f, 2.01959200e-02f, -1.05636291e-01f, -3.27809714e-02f, 3.75071121e-03f, 6.45856140e-04f, 7.66587928e-02f,
  -1.37605309e-01f, -1.23659395e-01f, -1.17447330e-02f, -2.68216759e-01f, -2.32926682e-02f, 1.15008190e-01f, -1.75171465e-01f, -1.84265584e-01f, 1.89337179e-01f, -1.29439786e-01f,
  -1.05988540e-01f, -7.79758170e-02f, -9.82286856e-02f, 8.56855884e-02f, -1.01372913e-01f, 6.50464296e-02f, 3.44743729e-02f, 3.34544331e-02f, 1.53605705e-02f, -2.80386806e-02f,
  -1.27502099e-01f, 1.59792826e-02f, 3.05102412e-02f, 2.12656990e-01f, 6.32078648e-02f, 3.71923596e-02f, 1.11141846e-01f, -4.69913967e-02f, -8.51322785e-02f, 3.36590201e-01f,
  2.01359570e-01f, 1.76910624e-01f, -1.23909861e-01f, 2.70692915e-01f, 5.42266406e-02f, -3.10672671e-01f, -8.18727762e-02f, -2.22486660e-01f, -3.87475222e-01f, 7.48226047e-02f,
  -5.86591400e-02f, 7.74896964e-02f, 5.50905168e-02f, -3.36962231e-02f, -4.84586433e-02f, 8.69288519e-02f, 4.43639122e-02f, -3.11186016e-01f, 1.13932192e-02f, -1.30055442e-01f,
  -1.96535811e-01f, 6.33342713e-02f, 5.36843657e-01f, 1.61624938e-01f, -1.50959581e-01f, -1.53773129e-01f, 1.03579223e-01f, 1.19333498e-01f, -2.24007264e-01f, 1.29471064e-01f,
  -4.22692038e-02f, 8.11177865e-02f, 4.55530472e-02f, -2.07079239e-02f, 1.09019421e-01f, -4.42004204e-02f, -4.44952175e-02f, 2.19259188e-01f, -2.91550253e-03f, 7.86962658e-02f,
  8.86463746e-02f, 9.86628681e-02f, 1.20605677e-01f, -4.89407144e-02f, 1.87650155e-02f, -2.12257430e-02f, 1.11362459e-02f, 4.54014204e-02f, -9.67671163e-03f, 1.33088127e-01f,
  -5.32904640e-02f, 1.54812150e-02f, 2.75536645e-02f, -5.05400449e-02f, 1.01584136e-01f, -1.38279721e-02f, -8.33020136e-02f, 6.17528372e-02f, -2.36625776e-01f, -1.40754595e-01f,
  3.54053378e-02f, 1.04160286e-01f, -1.62793443e-01f, -3.82569246e-02f, -8.99756625e-02f, 6.95942640e-02f, 4.16729227e-02f, -5.41748991e-03f, 9.48922783e-02f, -1.40570793e-02f,
  9.23163537e-03f, 2.41697468e-02f, -1.98601440e-01f, 1.39430866e-01f, -2.29037888e-02f, -1.96891114e-01f, 9.44840237e-02f, -2.64992714e-01f, -2.39131004e-01f, 4.67933491e-02f,
  -8.44686106e-02f, 1.49535194e-01f, -1.65471211e-02f, 2.49692678e-01f, -1.71149373e-02f, 6.97997659e-02f, 5.04541025e-02f, 2.64926583e-01f, 3.57697494e-02f, -1.77274793e-02f,
  -5.87308034e-02f, 3.40340771e-02f, -1.62613183e-01f, 6.84213638e-03f, 6.53551966e-02f, -4.73116599e-02f, 1.31911099e-01f, -7.34814182e-02f, -2.28015147e-03f, -3.51301767e-02f,
  -5.42054251e-02f, -3.60419899e-02f, 6.24194741e-02f, -8.49880129e-02f, 5.42400703e-02f, 1.82290506e-02f, 1.60016581e-01f, 1.06597967e-01f, 5.94373159e-02f, 3.25049311e-02f,
  -1.29866169e-03f, 8.13257545e-02f, -6.10049106e-02f, -1.31638035e-01f, 5.75048067e-02f, 2.30209250e-02f, -9.68959108e-02f, 3.26132141e-02f, 2.40680366e-03f, -1.37681842e-01f,
  -9.93423909e-02f, 1.42157922e-04f, 2.50616193e-01f, 9.37157422e-02f, 3.04646231e-03f, 2.49628397e-03f, -6.75167963e-02f, -7.50471950e-02f, -9.93619636e-02f, -9.73046571e-03f,
  -2.19666343e-02f, -1.96770974e-03f, 1.43018654e-02f, -1.06569789e-01f, 3.39145996e-02f, -9.63791013e-02f, -1.22034980e-03f, -7.76914880e-02f, 1.05774261e-01f, -1.12018362e-02f,
  -8.36557969e-02f, 7.29869232e-02f, 8.94414112e-02f, -7.73039972e-03f, -2.09193870e-01f, -2.00932935e-01f, -6.56008273e-02f, 2.01520205e-01f, -1.93917811e-01f, 1.74841926e-01f,
  2.06656024e-01f, -2.73988754e-01f, 1.92004547e-01f, -2.10353047e-01f, 8.09961483e-02f, 2.43729260e-02f, 7.70020783e-02f, -9.38358996e-03f, 4.74356003e-02f, 7.33061656e-02f,
  -8.36195946e-02f, -1.68548316e-01f, 4.77836542e-02f, 1.17092624e-01f, -1.39561042e-01f, 1.11878753e-01f, 5.08190654e-02f, 4.93079089e-02f, -9.36686695e-02f, 9.64064791e-04f,
  7.55871087e-02f, -6.69797659e-02f, -2.85319954e-01f, 1.41418159e-01f, 2.67915707e-02f, 1.19344130e-01f, 1.90282300e-01f, 6.41291142e-02f, 1.08024120e-01f, 1.74006633e-02f,
  7.72571564e-02f, 1.27553761e-01f, 1.04516692e-01f, 1.25322230e-02f, -9.08093676e-02f, -1.47824973e-01f, 1.17024884e-03f, -2.30827346e-01f, 8.67376998e-02f, 1.86164066e-01f,
  -3.07839572e-01f, -7.39268139e-02f, -1.05306096e-01f, -2.14123931e-02f, 1.71999796e-03f, -3.47103328e-02f, -1.03977144e-01f, -1.32046983e-01f, -3.48889753e-02f, 4.15058732e-02f,
  -1.73877612e-01f, 8.53521079e-02f, -1.45777628e-01f, 1.50695294e-01f, 1.35452673e-01f, -2.31216535e-01f, -8.61569270e-02f, -6.72435388e-02f, -1.33590013e-01f, -3.82015973e-01f,
  -2.57499367e-01f, -3.28962326e-01f, -4.88882251e-02f, -6.89557046e-02f, -2.28964925e-01f, -3.89403820e-01f, 2.77155787e-01f, 1.94077924e-01f, -2.65747041e-01f, 6.57780915e-02f,
  -2.71316227e-02f, 8.39580521e-02f, 2.96235550e-02f, 5.61648458e-02f, 8.94175917e-02f, 1.17813535e-01f, 1.51780859e-01f, -9.57601424e-03f, 1.12692220e-02f, 1.42944474e-02f,
  1.48844615e-01f, 2.29486395e-02f, 2.05278784e-01f, -1.69916853e-01f, 7.57963210e-02f, 2.23550782e-01f, -1.15050599e-02f, 6.38765022e-02f, 4.90692928e-02f, 1.54042825e-01f,
  5.78536764e-02f, -1.35917723e-01f, 9.31706131e-02f, 4.45220992e-03f, 8.64928365e-02f, 3.81896906e-02f, 9.85064432e-02f, -3.04240491e-02f, 4.96009849e-02f, -3.83408964e-01f,
  -2.67186105e-01f, 8.78883898e-03f, 4.19592783e-02f, -9.51552540e-02f, 6.41703680e-02f, -1.35367230e-01f, 6.03808537e-02f, 1.29581774e-02f, 1.02193892e-01f, -5.02926894e-02f,
  2.52022855e-02f, 1.32338151e-01f, 6.74089938e-02f, -4.94117588e-02f, 1.92640334e-01f, -1.09671958e-01f, -2.12816313e-01f, 8.08124989e-03f, 1.93215795e-02f, -1.05134822e-01f,
  -3.09545875e-01f, -2.56964564e-02f, 6.73689619e-02f, 3.91562760e-01f, 1.22880943e-01f, 1.52106313e-02f, 7.31160212e-03f, -1.35709941e-01f, -5.48579693e-02f, -1.18320972e-01f,
  -1.92572355e-01f, 8.57163072e-02f, -9.76192057e-02f, -1.25805348e-01f, -2.66301036e-02f, 2.32588425e-02f, 7.50821531e-02f, 1.40946582e-02f, -4.84954603e-02f, 2.73104981e-02f,
  2.04586964e-02f, 3.72223370e-02f, 8.75883456e-03f, 5.90870418e-02f, 1.63783003e-02f, 1.58292800e-01f, 1.40055716e-01f, -4.24106494e-02f, -1.14607986e-03f, -1.93255901e-01f,
  3.77621427e-02f, -1.01129681e-01f, 3.08313761e-02f, 1.07336685e-01f, 3.57533880e-02f, 1.08206570e-02f, -8.94653320e-04f, 3.82454768e-02f, 1.64951943e-02f, -3.55441980e-02f,
  -2.69201193e-02f, 5.97031377e-02f, -4.19626832e-02f, 9.07948893e-03f, -2.81823486e-01f, -2.38765866e-01f, -1.20970808e-01f, 2.03358326e-02f, -2.83415556e-01f, -1.06944486e-01f,
  -1.67421728e-01f, 6.36321381e-02f, -2.66506411e-02f, 7.62616321e-02f, -8.07120726e-02f, -3.08445562e-02f, 1.41929910e-02f, 7.82563016e-02f, 6.39510825e-02f, 2.94684172e-01f,
  -7.15755671e-02f, -1.22698292e-01f, 2.22590528e-02f, -1.64658740e-01f, -4.56768386e-02f, -1.36121899e-01f, 1.51720375e-01f, 2.68915594e-01f, 5.21276891e-03f, -1.28971664e-02f,
  2.22565636e-01f, -1.14295259e-01f, -4.19820696e-02f, 1.44498333e-01f, -3.08620967e-02f, -3.59582826e-02f, -1.45297661e-01f, -9.43921879e-02f, -1.72258228e-01f, -5.49270101e-02f,
  6.67915270e-02f, 3.18663567e-02f, 2.33089947e-03f, -3.52903083e-02f, -2.65575945e-01f, -4.46815193e-02f, -4.80787978e-02f, 4.04152274e-02f, -7.97874182e-02f, 2.17476711e-02f,
  -5.15308082e-02f, 2.14758720e-02f, 1.11294918e-01f, -5.21818884e-02f, 7.66047314e-02f, -2.50292961e-02f, 1.59268193e-02f, 6.40039425e-03f, -3.37887295e-02f, 6.68118373e-02f,
  3.28259990e-02f, 1.62056834e-02f, 1.10973299e-01f, -7.94311166e-02f, 8.29145983e-02f, 1.77811220e-01f, -3.14599246e-01f, -2.01031432e-01f, 1.20940693e-01f, -6.58096895e-02f,
  -3.48423934e-03f, 1.86466455e-01f, -2.74815679e-01f, -2.16498822e-02f, 4.80127782e-02f, -2.13422149e-01f, -1.32840988e-03f, -4.82465550e-02f, -7.72915259e-02f, -1.52667567e-01f,
  -6.61847964e-02f, 8.51553283e-04f, 1.20743671e-02f, 7.46295899e-02f, -5.84009569e-03f, 1.39968798e-01f, 5.41771166e-02f, -2.50338465e-01f, -3.37701559e-01f, 1.27934203e-01f,
  1.21732064e-01f, -1.84879109e-01f, -3.02994549e-01f, 8.18346813e-02f, -1.01854421e-01f, 2.20053624e-02f, -3.53770375e-01f, -1.88818157e-01f, 2.95062810e-01f, -4.88494299e-02f,
  -4.15756226e-01f, -2.91679669e-02f, -7.98776597e-02f, -8.27565342e-02f, 5.95440343e-03f, 1.57461390e-01f, -8.93256962e-02f, -1.55417677e-02f, 8.98232535e-02f, -6.26081824e-02f,
  -2.02080272e-02f, -1.39498562e-01f, 2.64873616e-02f, -3.99104729e-02f, -6.15501776e-03f, 4.71233483e-03f, -7.75775909e-02f, -1.05457529e-01f, 4.07501729e-03f, 9.59507599e-02f,
  1.09506561e-03f, 5.05255982e-02f, -8.01777933e-03f, 1.30476370e-01f, 9.69947781e-03f, -1.18059903e-01f, 5.73312752e-02f, 9.19357166e-02f, 6.28089160e-02f, 1.23800442e-01f,
  -8.50138366e-02f, -1.37926564e-01f, -1.22327030e-01f, -7.15539604e-02f, -1.28712118e-01f, 6.96448833e-02f, -5.85514605e-02f, -4.77100573e-02f, -7.03951865e-02f, -5.40715531e-02f,
  1.23685095e-02f, -4.50114422e-02f, -6.25090254e-03f, 5.41350953e-02f, 8.75400975e-02f, -6.14998338e-04f, 2.62618922e-02f, -9.77571607e-02f, 5.55713214e-02f, -6.01216294e-02f,
  -3.96387354e-02f, 1.91051848e-02f, 1.07537799e-01f, -2.25894805e-02f, -1.26796633e-01f, -4.92720120e-02f, -1.46848276e-01f, -2.27291733e-02f, -2.18827695e-01f, -8.97679552e-02f,
  -2.54721165e-01f, -2.83713549e-01f, 2.98827533e-02f, -4.49394844e-02f, -2.67573923e-01f, 2.06118330e-01f, 8.18603113e-02f, 5.67697473e-02f, 2.33790755e-01f, 7.83326551e-02f,
  -1.25072584e-01f, -3.73992771e-02f, 1.95452005e-01f, 8.75653848e-02f, -1.07576720e-01f, 2.58279622e-01f, -4.61387495e-03f, 1.31661147e-01f, 6.89690337e-02f, -5.37969463e-05f,
  1.39551582e-02f, 1.80872716e-02f, -2.00937148e-02f, 6.09346889e-02f, -2.47008950e-02f, 7.18552666e-03f, 8.77601951e-02f, -8.19753706e-02f, -1.36804273e-02f, -1.71848416e-01f,
  1.23770490e-01f, 7.79787526e-02f, 1.11017218e-02f, -4.20165509e-02f, 6.78071380e-02f, -5.88318706e-02f, -3.22893560e-02f, -1.49458513e-01f, -2.11730942e-01f, 1.93174586e-01f,
  -2.59835035e-01f, -1.24310620e-01f, -2.62467235e-01f, -3.17669585e-02f, -1.18756749e-01f, -1.34258345e-01f, -1.03965729e-01f, -4.87074740e-02f, 2.73937429e-03f, 8.27156678e-02f,
  -2.03090191e-01f, 5.21886013e-02f, -5.05715050e-02f, -4.76906635e-02f, 1.00006469e-01f, -2.43909478e-01f, -2.71826327e-01f, -1.14579119e-01f, -2.62655526e-01f, 3.76218975e-01f,
  -5.13922535e-02f, 3.34469080e-01f, 4.68514748e-02f, -8.38393122e-02f, -2.65122324e-01f, 7.25221913e-03f, 3.45243849e-02f, -4.31465209e-02f, -3.39760810e-01f, -2.37728611e-01f,
  -7.83529654e-02f, -1.99903175e-02f, 1.82233937e-02f, -2.85158325e-02f, 3.45909223e-02f, -1.19793557e-01f, 5.40727638e-02f, 1.45167664e-01f, -4.70490754e-02f, 9.87295434e-02f,
  7.66258985e-02f, -5.76256663e-02f, 9.29844528e-02f, 1.27889171e-01f, -3.51653919e-02f, 1.29543711e-02f, -2.06043169e-01f, -6.80521652e-02f, 6.88343346e-02f, 5.03443591e-02f,
  4.37757671e-02f, 1.49769768e-01f, -5.35224490e-02f, 1.56564444e-01f, 6.71985894e-02f, 1.31399170e-01f, 1.18726246e-01f, 1.11532591e-01f, -2.20983386e-01f, -1.96911901e-01f,
  6.31586835e-02f, -2.23903984e-01f, 2.53878403e-02f, 8.25891495e-02f, -2.30330110e-01f, -1.66967228e-01f, -2.61910018e-02f, -5.80746913e-03f, 5.63999079e-02f, 2.60578608e-03f,
  -2.65552327e-02f, -1.97971210e-01f, -1.01592004e-01f, 1.09493226e-01f, -2.28062160e-02f, -1.22730933e-01f, -1.98990166e-01f, 2.09875014e-02f, -2.43136659e-02f, -1.46370068e-01f,
  -1.31707981e-01f, -1.36415124e-01f, -5.42128459e-02f, 9.54951793e-02f, -6.43100739e-02f, 2.80946419e-02f, -1.66525170e-02f, -5.18677896e-03f, -2.25751787e-01f, 1.87911242e-02f,
  -6.77165240e-02f, 7.88193122e-02f, -1.33234665e-01f, 1.75088406e-01f, 1.72919497e-01f, 4.63687181e-02f, 1.14085093e-01f, -3.91041487e-02f, 2.67456099e-03f, 6.00614399e-03f,
  9.55388844e-02f, 3.91152017e-02f, 1.22066066e-01f, -4.90548275e-03f, 1.49301842e-01f, -6.53484985e-02f, -7.41112530e-02f, -7.80656263e-02f, -2.91852113e-02f, 1.81295022e-01f,
  9.95919630e-02f, 4.11705375e-02f, -5.02396002e-02f, 2.06632033e-01f, 4.90537323e-02f, 3.53045054e-02f, -2.09120642e-02f, 1.38245840e-02f, 1.07631907e-01f, -2.38994639e-02f,
  6.47656247e-03f, -1.67390794e-01f, -1.75731070e-02f, 3.03713828e-01f, 5.96656725e-02f, 2.11752385e-01f, 1.40741065e-01f, 9.97205600e-02f, 1.29535392e-01f, -1.99810445e-01f,
  1.12568133e-01f, -1.08522810e-01f, 3.97864059e-02f, 1.48395196e-01f, 3.92816886e-02f, 1.40116230e-01f, 3.77716869e-02f, 1.61572248e-02f, -1.70093521e-01f, 3.74856815e-02f,
  -2.24868637e-02f, -8.21749493e-02f, 3.64139229e-02f, 1.93981111e-01f, 1.18863910e-01f, -7.08049312e-02f, -1.90395676e-02f, -2.65860289e-01f, -1.46613568e-01f, 3.10940951e-01f,
  2.74670124e-02f, 1.87923424e-02f, 2.94848323e-01f, 3.55920456e-02f, -7.66301304e-02f, -1.67725578e-01f, 1.74900457e-01f, 5.92055395e-02f, 1.31451160e-01f, -2.31490180e-01f,
  1.43873438e-01f, -6.99614808e-02f, -6.79209307e-02f, 9.02146846e-02f, -1.09069481e-01f, 2.77333051e-01f, 1.76074691e-02f, 9.67297554e-02f, -1.08396001e-01f, 1.71845239e-02f,
  1.81004349e-02f, 6.18349425e-02f, -9.86950696e-02f, -6.97693676e-02f, -3.98893729e-02f, -7.08875135e-02f, -3.54940668e-02f, -7.30802566e-02f, -3.10912970e-02f, 1.44767836e-01f,
  8.82157981e-02f, 1.88573226e-02f, 1.29990712e-01f, -6.97141215e-02f, -1.76101606e-02f, -3.67044397e-02f, -5.85671067e-02f, 2.94121623e-01f, 1.94164515e-02f, -2.49891862e-01f,
  -1.86025858e-01f, 1.69723243e-01f, -2.49250054e-01f, 9.62864608e-02f, -1.78115934e-01f, 1.34294942e-01f, 9.25500691e-02f, -5.17143160e-02f, -2.57917084e-02f, 4.11229767e-02f,
  -8.04472342e-02f, -1.84745565e-01f, -7.82117471e-02f, 5.67844287e-02f, 5.03970832e-02f, -1.73889343e-02f, -7.24474639e-02f, 2.77420301e-02f, -1.64227813e-01f, 4.08685990e-02f,
  1.50608897e-01f, 5.88232912e-02f, -1.56127810e-01f, 1.21404298e-01f, -3.54920030e-02f, 1.23549014e-01f, -1.77140012e-01f, 8.59417617e-02f, 1.09234452e-01f, 1.50502279e-01f,
  2.30524167e-01f, 2.48572841e-01f, 1.76477119e-01f, 5.77525385e-02f, 1.19213853e-03f, -2.42606789e-01f, -2.71990508e-01f, 4.79088873e-02f, 1.48248792e-01f, -9.24721360e-02f,
  -1.66019633e-01f, 6.31472617e-02f, 9.59985796e-03f, -1.66876957e-01f, -8.23878348e-02f, -1.14740403e-02f, -1.68007880e-01f, 3.23531032e-02f, -7.25928321e-02f, -2.03220900e-02f,
  -9.41548273e-02f, -2.57896576e-02f, -1.74353793e-01f, -1.35812774e-01f, -1.90825030e-01f, -1.25411123e-01f, -2.13651508e-01f, -5.78486025e-02f, -6.92232326e-02f, -6.46155179e-02f,
  2.94415224e-02f, 2.43835494e-01f, 2.04337835e-01f, -1.01512289e-02f, -5.91991581e-02f, 6.04300201e-03f, -1.08507559e-01f, 3.47627066e-02f, 1.26372706e-02f, 1.84531793e-01f,
  -5.83564071e-03f, 9.77469087e-02f, -4.44882847e-02f, -4.65218537e-02f, -1.38166651e-01f, -3.40249240e-02f, -3.95164602e-02f, 6.30794466e-02f, -3.38197425e-02f, -9.04572085e-02f,
  -1.35275349e-01f, -6.62450269e-02f, -1.24333035e-02f, -1.10244840e-01f, 8.40381086e-02f, 1.22668240e-02f, -1.20650813e-01f, 3.15288842e-01f, 7.68329948e-02f, 1.85695633e-01f,
  2.63646036e-01f, 2.27738932e-01f, 5.48668355e-02f, -2.62579590e-01f, 2.62348920e-01f, -1.66374687e-02f, 5.66389039e-02f, -2.19946563e-01f, -1.95118412e-01f, 3.11046392e-02f,
  4.48096506e-02f, 1.07593931e-01f, -8.06671977e-02f, -4.50944453e-02f, 1.53402891e-02f, -2.50243396e-01f, -1.59469381e-01f, -7.52904192e-02f, -1.45199746e-01f, 3.67725939e-02f,
  5.26545681e-02f, -2.13852543e-02f, 3.09710875e-02f, -2.21606866e-01f, -2.85123307e-02f, -1.87974647e-01f, 5.36851212e-02f, -7.45879812e-03f, 1.57787558e-02f, 8.83926079e-02f,
  5.24571456e-04f, 4.79394235e-02f, -1.77322440e-02f, 1.80788904e-01f, -2.48479038e-01f, -7.11472034e-02f, 2.08237097e-01f, 1.46989614e-01f, -7.86945894e-02f, 1.67606443e-01f,
  -6.96396455e-02f, -4.25209813e-02f, 1.02293147e-02f, -1.93609789e-01f, 3.07094958e-02f, -9.72233899e-03f, -1.86807215e-02f, -4.67985272e-02f, -7.22922944e-03f, 1.52843753e-02f,
  1.10167507e-02f, 2.07517631e-02f, 2.40220055e-01f, 1.46450818e-01f, -3.28722745e-02f, -1.35867938e-01f, 1.39402315e-01f, -9.87422168e-02f, -4.01631445e-02f, -3.13441381e-02f,
  -3.84327918e-02f, 2.73451246e-02f, -1.07498154e-01f, -4.05814201e-02f, -1.43696308e-01f, -3.23332906e-01f, 1.06663972e-01f, -6.19452931e-02f, 5.15449420e-02f, 4.80666608e-02f,
  1.43675148e-01f, -2.16222778e-01f, 8.28963891e-02f, 5.80975078e-02f, -1.30654156e-01f, -8.75151083e-02f, -4.88730557e-02f, 8.02473649e-02f, -7.66342580e-02f, 9.15294960e-02f,
  -4.00389023e-02f, -6.76625669e-02f, 3.02293506e-02f, -6.48344457e-02f, -1.26000196e-01f, -8.69167503e-03f, -2.47490238e-02f, 4.31487262e-02f, -1.47764266e-01f, 3.47919948e-02f,
  -8.52994919e-02f, -1.82489127e-01f, -3.51160653e-02f, 7.33399540e-02f, -1.05501257e-01f, 1.01648718e-01f, -2.16558501e-02f, 4.39111551e-04f, -1.38088495e-01f, -2.26499259e-01f,
  4.33458388e-02f, -4.60421406e-02f, 2.02290174e-02f, 1.65673882e-01f, -3.70744355e-02f, -3.28405231e-01f, -7.97353238e-02f, -9.19753965e-03f, 4.44355272e-02f, -1.52648538e-01f,
  1.82977002e-02f, 1.36251941e-01f, -4.95633595e-02f, 1.74711451e-01f, 2.82442331e-01f, 8.72530229e-03f, -6.39193729e-02f, 4.07520533e-02f, 1.03448220e-02f, -7.97310546e-02f,
  -4.37592715e-02f, -5.43519706e-02f, -3.11031520e-01f, 3.03355962e-01f, 1.33348435e-01f, 1.08124809e-02f, 1.54438511e-01f, 3.20786163e-02f, -2.63791531e-01f, -1.89191401e-01f,
  -5.04106432e-02f, 1.28428981e-01f, -9.09200981e-02f, 9.59493890e-02f, 9.05091017e-02f, -2.33615446e-03f, 3.27239819e-02f, 9.96791795e-02f, 6.49845675e-02f, 1.07318290e-01f,
  -2.40837842e-01f, 3.94042172e-02f, 2.10909755e-04f, 5.15413433e-02f, -1.96690019e-02f, 7.49181286e-02f, 4.99395207e-02f, 2.52091717e-02f, 7.57256746e-02f, -2.01894473e-02f,
  -1.23520456e-02f, 8.30976442e-02f, 1.26418948e-01f, -1.34460866e-01f, 1.97827265e-01f, 1.07053965e-01f, 1.21206582e-01f, 3.70841585e-02f, 1.77778210e-02f, 8.72715041e-02f,
  -9.93551239e-02f, 4.69542807e-03f, -2.42495626e-01f, -1.78561136e-01f, 5.18018454e-02f, -1.77830860e-01f, -9.88482684e-02f, 2.28726521e-01f, -5.40765822e-02f, -1.67738780e-01f,
  -5.04078828e-02f, -1.36423513e-01f, -7.77348801e-02f, 4.93629985e-02f, -7.99611360e-02f, -3.35513949e-02f, -1.63604859e-02f, -5.52406944e-02f, 1.24911219e-01f, 2.75269359e-01f,
  1.58394992e-01f, 7.03847706e-02f, -7.68385874e-03f, -2.44559959e-01f, -7.90059790e-02f, -1.34024367e-01f, -6.72231466e-02f, -1.35980502e-01f, -1.64318025e-01f, 1.77323282e-01f,
  1.13882490e-01f, -1.49828523e-01f, -1.69347718e-01f, -1.43992841e-01f, 5.82861081e-02f, -2.74996515e-02f, -2.69607753e-01f, 1.21484160e-01f, -1.51816666e-01f, -2.75809526e-01f,
  1.54782254e-02f, 1.49018839e-01f, -8.77060369e-02f, 7.09120259e-02f, 3.00348327e-02f, 3.61005776e-02f, -1.06782734e-01f, 4.60986719e-02f, -4.77103889e-03f, 1.02905326e-01f,
  1.76175922e-01f, -1.01129264e-01f, 1.34470880e-01f, 9.73888338e-02f, -1.36483684e-01f, -1.30616605e-01f, -2.12709919e-01f, 7.71981403e-02f, -2.54023336e-02f, 1.17854618e-01f,
  -3.83860990e-02f, -6.45820424e-02f, -6.98408186e-02f, -1.99316233e-01f, -1.32141456e-01f, -1.14509292e-01f, 2.07235366e-01f, 3.49896967e-01f, 1.16350964e-01f, -6.50180057e-02f,
  -1.22162804e-01f, -1.27218381e-01f, -1.40117601e-01f, 5.48969507e-01f, 5.31149190e-03f, 3.25531065e-01f, 1.97868273e-01f, 3.10491741e-01f, -3.44586582e-03f, -2.80245066e-01f,
  1.36269212e-01f, -3.06261003e-01f, -4.20391709e-01f, 6.90619871e-02f, -2.13240713e-01f, -9.98381060e-03f, -4.30987589e-02f, -6.63652122e-02f, -3.43137711e-01f, -1.39079373e-02f,
  1.22101068e-01f, -5.34529127e-02f, -6.28335550e-02f, 1.47576764e-01f, -2.20491230e-01f, 1.40141487e-01f, 7.00445399e-02f, 2.10590973e-01f, 1.33240689e-02f, -2.77924407e-02f,
  2.15535268e-01f, 1.22520007e-01f, 1.87588960e-01f, 1.33645892e-01f, 2.41065145e-01f, -1.53586054e-02f, 1.15640081e-01f, 1.41340956e-01f, 1.68050766e-01f, 5.84511459e-02f,
  -7.73000121e-02f, -5.20927869e-02f, 1.46961883e-01f, 5.52156791e-02f, 2.91944891e-02f, 9.84517261e-02f, 1.22076347e-01f, 5.85911758e-02f, -2.84979888e-03f, 2.41037887e-02f,
  -5.16377203e-03f, -4.06322218e-02f, 5.97041287e-02f, 9.53594819e-02f, -1.79929838e-01f, 3.02483086e-02f, -1.44833876e-02f, -3.65177542e-02f, -1.40517196e-02f, 7.23221079e-02f,
  4.81068762e-03f, -1.04801297e-01f, -2.53237098e-01f, -2.63094921e-02f, -4.78588864e-02f, -1.56614985e-02f, 2.47386649e-01f, -8.30519125e-02f, 6.63085207e-02f, -7.67610408e-03f,
  1.99162085e-02f, 7.67710283e-02f, 1.61786109e-01f, 1.69316288e-02f, -5.28348722e-02f, 2.13120375e-02f, 3.18381965e-01f, -1.26346692e-01f, -1.46828756e-01f, 4.18736786e-02f,
  -5.46674691e-02f, 6.61821961e-02f, -1.41359970e-01f, -8.26771483e-02f, -1.59758449e-01f, 2.01717705e-01f, -2.74770260e-01f, -4.13004816e-01f, -1.63094148e-01f, 1.50886238e-01f,
  1.16417650e-02f, -2.47549549e-01f, 7.79073536e-02f, 1.93944812e-01f, 3.62866074e-01f, -4.41500358e-02f, 3.23724709e-02f, 1.66785702e-01f, 4.53220531e-02f, 8.32929686e-02f,
  -1.71476662e-01f, -5.90769239e-02f, 1.23110548e-01f, 2.51958482e-02f, -1.10108152e-01f, -2.22712625e-02f, 7.03845732e-03f, 1.73242509e-01f, -5.69927171e-02f, -3.98252420e-02f,
  -4.46812175e-02f, -4.73338738e-02f, -1.87378392e-01f, -7.39200041e-02f, 3.83317471e-02f, -7.58936554e-02f, -2.36568414e-02f, 2.40525510e-02f, -1.55414149e-01f, -1.08170688e-01f,
  2.49571018e-02f, -5.70639558e-02f, 4.28272486e-02f, -1.82799213e-02f, -6.15520142e-02f, 8.49208161e-02f, -6.78302497e-02f, -3.99736390e-02f, -7.79099613e-02f, -3.53533844e-03f,
  -2.20661476e-01f, 4.46949452e-02f, -1.46732390e-01f, 2.51213253e-01f, 2.12311856e-02f, -9.85034974e-04f, 1.13044538e-01f, -1.82932943e-01f, -6.03670813e-02f, -7.11849406e-02f,
  -7.22240880e-02f, 6.62033074e-03f, -2.78718680e-01f, -9.60400552e-02f, -9.58272368e-02f, -2.06886530e-01f, -5.14829695e-01f, -3.27403955e-02f, -1.12111624e-02f, -1.21835442e-02f,
  1.83503120e-03f, -8.53463337e-02f, -1.22380115e-01f, 1.15425497e-01f, 9.52893049e-02f, 2.31264561e-01f, -1.80726767e-01f, 2.42230162e-01f, 3.16761047e-01f, 5.44407740e-02f,
  -1.63535133e-01f, 1.41448438e-01f, -6.36193231e-02f, 7.52137154e-02f, 6.98882937e-02f, -4.81185503e-02f, -7.67611489e-02f, -5.23171723e-02f, -9.74495858e-02f, 1.33783460e-01f,
  -2.73189805e-02f, 1.87622309e-02f, 2.04283968e-02f, -4.62879688e-02f, -4.57671732e-02f, -2.05818221e-01f, -3.54069495e-03f, 4.24034223e-02f, 6.12611100e-02f, -6.63295463e-02f,
  5.98267764e-02f, 1.73960961e-02f, 3.96147817e-02f, -3.70926075e-02f, 6.42324314e-02f, 3.01657375e-02f, 1.40384957e-01f, 7.48947039e-02f, -2.57601976e-01f, 1.52654707e-01f,
  6.11695200e-02f, -2.19765916e-01f, -8.34063292e-02f, -4.77651432e-02f, -3.62103939e-01f, 2.33604256e-02f, -1.44739196e-01f, 2.04775140e-01f, -6.16743565e-02f, -9.08537768e-03f,
  -5.36349788e-02f, 1.38116479e-01f, -1.89542621e-02f, 9.85658611e-04f, -4.02386561e-02f, 1.59708932e-01f, 1.01918802e-01f, 7.64416382e-02f, -2.55295355e-02f, -2.57275254e-01f,
  -7.40717351e-02f, -1.58907659e-02f, 1.94832608e-01f, 1.96740553e-01f, 1.89528421e-01f, 4.12646830e-01f, 1.36224508e-01f, 7.62183368e-02f, 5.98688237e-03f, 1.91819414e-01f,
  3.00226901e-02f, 6.04074076e-02f, -4.35230017e-01f, -2.23006893e-04f, -1.20479740e-01f, -2.14671776e-01f, 1.39809437e-02f, 2.01945398e-02f, -1.16492398e-01f, -2.49029994e-02f,
  -2.51157939e-01f, 3.13628800e-02f, -3.30187418e-02f, -3.16808745e-02f, 2.26120323e-01f, 2.89867148e-02f, 8.03167671e-02f, -8.61799121e-02f, 1.66619673e-01f, 1.79137021e-01f,
  -4.74893628e-03f, 9.31032002e-03f, 1.51043743e-01f, -1.87996954e-01f, 7.60304332e-02f, 1.10283509e-01f, -8.71724486e-02f, 1.35424510e-01f, 2.31506489e-02f, 7.14801699e-02f,
  -1.60820258e-03f, 1.88109204e-01f, -1.46290272e-01f, 1.82678580e-01f, 2.75999606e-02f, -5.64812757e-02f, -2.97942180e-02f, -8.53788927e-02f, -1.14738584e-01f, -2.17065681e-02f,
  -1.85455665e-01f, 1.46719947e-01f, 5.27883321e-03f, 2.82759797e-02f, 1.39382109e-01f, -2.65798792e-02f, -8.43667313e-02f, -8.23294222e-02f, -1.34834751e-01f, 1.11580618e-01f,
  -5.05878497e-03f, 1.68332741e-01f, -3.66723537e-02f, -1.12691276e-01f, -1.86401680e-01f, 5.86662665e-02f, 1.01562403e-02f, -3.00904840e-01f, -2.88101554e-01f, 1.30120963e-01f,
  -4.15267721e-02f, 6.24719672e-02f, -5.51937297e-02f, 2.87861794e-01f, -3.29068005e-02f, 9.37218815e-02f, 2.52371937e-01f, 2.68171340e-01f, 1.49251536e-01f, 1.78187136e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.26118933e-02f, 1.17882360e-02f, 1.98518708e-01f, 1.22417668e-02f, -1.31458104e-01f, 1.19465396e-01f, -3.05192061e-02f, -1.29296377e-01f, 1.60059985e-02f, 2.44766921e-02f,
  8.69459212e-02f, 3.96041535e-02f, 4.16556112e-02f, 1.20903462e-01f, 6.28559440e-02f, 3.05695310e-02f, 1.15374736e-01f, 4.13108058e-02f, 4.16921750e-02f, 1.67115211e-01f,
  -3.41953188e-02f, 1.21059820e-01f, 1.69274192e-02f, 1.57934636e-01f, -7.43525708e-03f, 1.10756993e-01f, -9.12445132e-03f, -2.07985099e-02f, 2.30095521e-01f, 3.37653548e-01f,
  7.69097134e-02f, 1.69118121e-02f, 9.93966013e-02f, -1.57517463e-01f, -2.10262742e-02f, -1.95655897e-01f, 8.31501856e-02f, -8.22097659e-02f, 1.56562284e-01f, 4.07200214e-03f,
  3.38141561e-01f, 3.26228030e-02f, -2.92774457e-02f, -1.18402548e-01f, 2.29749799e-01f, 1.12928592e-01f, -9.21665877e-02f, 1.02250941e-01f, 1.93459153e-01f, -1.37274802e-01f,
  1.73691325e-02f, -1.55514330e-01f, 8.58285576e-02f, 1.56664118e-01f, 1.53176144e-01f, 8.58267024e-02f, -9.55666453e-02f, -3.17763656e-01f, 2.15735152e-01f, -2.94854850e-01f,
  4.20175418e-02f, -5.44872165e-01f, 7.51710907e-02f, -1.43983349e-01f, 1.33019909e-01f, 7.07225651e-02f, 1.20527960e-01f, 1.12528846e-01f, -2.31196046e-01f, -1.34647474e-01f,
  9.57185924e-02f, -4.04791124e-02f, -8.65089148e-02f, 7.70200491e-02f, -2.69241841e-03f, 9.54606980e-02f, -6.30200356e-02f, -7.98081234e-03f, 1.10423565e-01f, -3.65255848e-02f,
  -1.43436849e-01f, -2.03123689e-02f, 1.42243467e-02f, 2.08121493e-01f, 2.22922340e-01f, -7.50338361e-02f, 8.81302431e-02f, 1.68309644e-01f, 7.76462406e-02f, 3.14644068e-01f,
  -4.23353702e-01f, -1.39633179e-01f, 1.84070408e-01f, -1.74828675e-02f, -1.03000104e-01f, 3.91322792e-01f, -1.69173837e-01f, -1.39974535e-01f, -1.85936138e-01f, -1.35986611e-01f,
  1.09533612e-02f, -1.54206976e-01f, 1.26692593e-01f, 6.12423904e-02f, -1.04981981e-01f, 4.07761574e-01f, 2.06549630e-01f, 1.82280809e-01f, 2.94188321e-01f, 5.94520345e-02f,
  -3.14018056e-02f, -2.18152821e-01f, -1.14185080e-01f, -1.46510065e-01f, -2.86037713e-01f, -1.57011330e-01f, -1.41428739e-01f, -3.07966210e-03f, -2.16175914e-01f, -3.12679738e-01f,
  -3.73648137e-01f, -1.13490596e-01f, 1.31690234e-01f, -9.72443447e-02f, -8.68409127e-03f, -7.02704191e-02f, 5.09421863e-02f, -2.85196483e-01f, 2.12716728e-01f, 1.92737773e-01f,
  -1.40503228e-01f, 1.26687437e-01f, 1.48395017e-01f, 1.00537203e-01f, 8.35593492e-02f, -7.66990185e-02f, 2.04540506e-01f, 1.44249499e-01f, 3.22796404e-02f, 2.78743450e-03f,
  7.05507770e-02f, 1.02955282e-01f, -4.54414822e-02f, 1.31286040e-01f, 4.98085096e-02f, 1.72673948e-02f, -8.25916529e-02f, 2.39598230e-02f, 7.01699853e-02f, 8.30152556e-02f,
  7.13633895e-02f, 7.42908791e-02f, 5.48471324e-02f, -1.24907330e-01f, 1.95673898e-01f, 2.18510881e-01f, -2.51884222e-01f, 8.60749260e-02f, -5.68811782e-02f, -5.62314056e-02f,
  1.00600310e-01f, -2.89433412e-02f, 2.31739044e-01f, 2.37336323e-01f, -1.31698756e-03f, 5.60637005e-02f, 1.58680081e-01f, 3.81788090e-02f, 1.01473443e-02f, -5.44806644e-02f,
  -1.14711985e-01f, -2.13602674e-03f, -3.37369174e-01f, -1.44300684e-01f, 1.64605118e-02f, 4.32839841e-02f, -2.33265176e-01f, 1.06485941e-01f, -1.03413477e-03f, 1.92786884e-02f,
  -1.33339033e-01f, 1.31228594e-02f, 1.96376294e-02f, 3.32081944e-01f, 2.80585498e-01f, 3.30496162e-01f, -2.01211497e-01f, -3.63684505e-01f, 3.61587822e-01f, 1.17346540e-01f,
  -1.05239809e-01f, 1.95306852e-01f, 7.56094931e-03f, 2.51097023e-01f, -2.09031347e-02f, -1.62872449e-01f, 7.59991333e-02f, -4.77714557e-03f, 9.31142271e-02f, -4.55882885e-02f,
  -6.80031776e-02f, 1.18026629e-01f, -2.00963065e-01f, 1.63144812e-01f, 1.41888469e-01f, -5.43656461e-02f, 2.79590720e-03f, -1.26628920e-01f, -9.95188802e-02f, 2.06915677e-01f,
  6.63071647e-02f, 2.68470198e-01f, -1.80993766e-01f, 1.01226918e-01f, -1.99943841e-01f, 3.36946622e-02f, 3.94192375e-02f, 1.10716388e-01f, -1.97318703e-01f, -1.07532111e-03f,
  5.66240013e-01f, 4.17334326e-02f, -5.14429361e-02f, 1.50311232e-01f, 1.94923561e-02f, 2.31516823e-01f, 1.10732904e-02f, 2.31676355e-01f, 1.22990817e-01f, 1.74236658e-04f,
  2.36123681e-01f, -3.58820528e-01f, -8.15711543e-02f, 2.63295323e-01f, -1.15241654e-01f, 1.07054211e-01f, 1.45108730e-01f, 1.56261995e-02f, -1.08278925e-02f, 1.09816082e-01f,
  -1.38246745e-01f, -1.72677562e-01f, -3.05849403e-01f, -4.34878737e-01f, -9.34658200e-02f, -2.58225709e-01f, -3.59421641e-01f, 1.78025648e-01f, 3.56652141e-02f, -1.79324865e-01f,
  2.69157946e-01f, 1.86677277e-01f, 2.37608880e-01f, 7.03442516e-03f, -1.59950823e-01f, -9.94429663e-02f, -1.37070477e-01f, 4.28760834e-02f, 1.56211942e-01f, 1.09618828e-01f,
  2.19982445e-01f, 3.37597691e-02f, 1.69098526e-02f, -2.31501497e-02f, 3.32579203e-02f, 1.13786153e-01f, 3.16108554e-03f, 4.09989804e-03f, 4.89927530e-02f, 1.22031413e-01f,
  9.66005847e-02f, -4.27718051e-02f, -7.68178180e-02f, 2.06869036e-01f, 5.57378214e-03f, 5.09982258e-02f, -1.40802087e-02f, -1.07035585e-01f, 9.01622176e-02f, -5.89989650e-04f,
  4.91195768e-02f, -1.12446360e-01f, 2.18889609e-01f, 9.67354849e-02f, -4.42312360e-02f, 1.35542713e-02f, 1.77275743e-02f, -2.84509622e-02f, 9.69434306e-02f, 1.79833565e-02f,
  1.28681198e-01f, -2.09649131e-02f, -5.34975305e-02f, 9.74949375e-02f, 8.52442756e-02f, -2.03750700e-01f, 2.50763306e-03f, -1.17160939e-01f, -5.43418759e-03f, 7.87700247e-03f,
  -1.86177880e-01f, -3.45360003e-02f, -3.70864058e-03f, 1.56954631e-01f, -5.10111824e-02f, -9.00068413e-03f, 3.06929201e-01f, 6.33514151e-02f, 2.34398261e-01f, 1.60349891e-01f,
  1.71152368e-01f, -3.35536689e-01f, 2.59972006e-01f, 2.18336940e-01f, -6.24413192e-02f, -7.12265670e-02f, 1.22500196e-01f, 1.38446197e-01f, 1.01205453e-01f, -1.58671647e-01f,
  1.59100562e-01f, -6.25269115e-02f, 1.00611307e-01f, 2.63442844e-02f, -1.80637002e-01f, 1.19183421e-01f, 1.54770076e-01f, -3.13204974e-02f, 2.69587114e-02f, 9.79082286e-02f,
  1.39000535e-01f, 1.34232670e-01f, 1.45025775e-01f, 1.17133232e-02f, 1.95069015e-01f, 5.46671115e-02f, -1.89839363e-01f, -7.74077745e-03f, 5.50492713e-03f, 1.57897949e-01f,
  -2.26574708e-02f, -1.64285172e-02f, 1.14808194e-01f, 1.75134674e-01f, 2.03426793e-01f, 1.61608122e-02f, -3.15142900e-01f, -4.52982448e-02f, 1.21168770e-01f, 2.22850405e-02f,
  -2.16059074e-01f, 2.62242854e-01f, -6.47042170e-02f, -1.89043403e-01f, -7.71161169e-02f, -1.59494057e-01f, -1.43921813e-02f, -1.43722281e-01f, 3.58779728e-02f, 2.03370471e-02f,
  1.08319089e-01f, 3.83901238e-01f, 7.71033168e-02f, 2.07614452e-01f, 3.48222673e-01f, -3.91774066e-03f, 6.34915903e-02f, -1.38308942e-01f, 6.21634722e-02f, 9.12125260e-02f,
  -2.41067633e-01f, -1.44087866e-01f, -1.03555128e-01f, 1.65212497e-01f, 1.79927230e-01f, -2.44430408e-01f, -1.52176633e-01f, -1.03288591e-01f, 2.43175983e-01f, -1.89451456e-01f,
  -4.05034274e-02f, 4.76602800e-02f, -3.22876163e-02f, -4.57632333e-01f, 1.43078074e-01f, 1.16535962e-01f, -7.59451911e-02f, -1.54700667e-01f, 7.76900426e-02f, 2.14570597e-01f,
  6.08730167e-02f, 2.91605085e-01f, 2.11472027e-02f, 1.05937617e-02f, 2.05499679e-01f, 3.52824330e-02f, 2.61022840e-02f, 5.20417700e-03f, 8.91013741e-02f, 1.25352055e-01f,
  5.88057339e-02f, -1.85383409e-02f, -2.79402500e-03f, 3.97306355e-03f, 1.47385970e-01f, -5.33414632e-02f, 3.08952425e-02f, 6.27349764e-02f, 6.06831349e-02f, -1.62503779e-01f,
  1.55739263e-01f, -2.08969101e-01f, -1.73146844e-01f, -1.05815761e-01f, -1.44718200e-01f, 7.30300769e-02f, 3.91753344e-03f, -2.10832879e-01f, -1.21569879e-01f, 1.84593409e-01f,
  -6.64181709e-02f, 2.16604769e-02f, 3.07831378e-03f, 6.11576289e-02f, 5.28699048e-02f, 1.01538710e-01f, 1.75392434e-01f, -8.00569281e-02f, -1.74854025e-01f, -4.56862301e-02f,
  2.25833934e-02f, -7.79975788e-04f, -2.57183135e-01f, -6.16956204e-02f, 2.37745032e-01f, 2.66675889e-01f, -1.02877179e-02f, 1.03176333e-01f, 2.35847563e-01f, 4.94158342e-02f,
  -2.23755404e-01f, -5.37326224e-02f, 1.49507299e-01f, 5.21287799e-01f, 1.26190752e-01f, -1.48304060e-01f, 1.86601188e-02f, 2.09117845e-01f, -1.27924904e-01f, 7.81856701e-02f,
  3.44880462e-01f, 2.45348737e-01f, -2.54878551e-01f, 1.48034438e-01f, 4.87284064e-02f, 5.25592938e-02f, -1.10489286e-01f, 1.46165207e-01f, 2.44664297e-01f, -1.45502791e-01f,
  -2.16314644e-02f, 4.24762852e-02f, 1.79039463e-01f, -5.24966046e-02f, 6.05259575e-02f, 1.68276310e-01f, 5.14598787e-02f, 2.57412672e-01f, 4.61599268e-02f, 1.10423476e-01f,
  1.44624710e-01f, 1.03832446e-01f, 1.20813459e-01f, -8.13102946e-02f, -9.29195434e-02f, 9.14277360e-02f, -1.72683701e-01f, -2.50542819e-01f, -1.46381557e-01f, -6.34660572e-02f,
  -1.34421080e-01f, 4.02229987e-02f, -1.75944462e-01f, 2.34364286e-01f, -8.60209838e-02f, 1.30499285e-02f, -2.19903648e-01f, 8.98610950e-02f, -1.59633934e-01f, -8.51790085e-02f,
  1.20728083e-01f, 1.14132851e-01f, 6.15820698e-02f, 1.00889012e-01f, 8.66800430e-04f, -4.12596852e-01f, 4.19592500e-01f, 1.18449010e-01f, 8.52542296e-02f, 4.42662649e-02f,
  -2.61758745e-01f, -3.59892994e-01f, -2.63203532e-01f, -3.84807922e-02f, -3.75588357e-01f, 2.22075611e-01f, -3.52091730e-01f, -2.62629628e-01f, -3.33999395e-01f, 1.63596168e-01f,
  -3.32686245e-01f, -2.27178797e-01f, 1.48789570e-01f, 9.93209258e-02f, -2.02522054e-02f, 9.52936187e-02f, 2.68090516e-01f, 4.02129441e-02f, -3.67021263e-02f, 2.29748432e-02f,
  2.16721714e-01f, -5.85967600e-02f, 2.35925213e-01f, -2.80700959e-02f, -8.35500471e-03f, 1.88195318e-01f, -2.81466004e-02f, -1.04536163e-02f, 1.67937964e-01f, 1.04338497e-01f,
  1.22906365e-01f, -1.73094198e-01f, -1.23636145e-02f, -6.24526665e-02f, 2.44902093e-02f, -1.25583112e-01f, 1.63039237e-01f, -8.47416371e-02f, 3.34149271e-01f, -4.17515226e-02f,
  -1.07565656e-01f, 2.31081948e-01f, 3.41998339e-02f, -1.14742473e-01f, 8.68844911e-02f, -2.91143246e-02f, 1.55237794e-01f, -6.56476915e-02f, -7.98770599e-03f, 7.20427632e-02f,
  1.21729463e-01f, 4.18204963e-02f, 1.14002854e-01f, -4.41222526e-02f, 2.17822224e-01f, -1.29277647e-01f, -3.23091060e-01f, 1.36364531e-02f, -3.49673592e-02f, 5.97414188e-02f,
  -3.68734598e-01f, 2.09129751e-01f, 6.45580739e-02f, 9.03247520e-02f, 2.43191738e-02f, 8.81708488e-02f, 9.35309306e-02f, -2.25900412e-01f, -6.09712377e-02f, 1.06715173e-01f,
  -2.31222272e-01f, 9.37032849e-02f, -1.76186506e-02f, -5.07920943e-02f, -1.70815140e-01f, 2.99682438e-01f, 4.15105857e-02f, 1.87285796e-01f, 6.62809387e-02f, 1.97344907e-02f,
  -6.22386560e-02f, -7.79476017e-02f, -1.93589702e-02f, -1.28832251e-01f, -7.91852400e-02f, 1.45354301e-01f, 6.93448335e-02f, 1.81346461e-01f, 6.14737608e-02f, 1.15581840e-01f,
  8.42610598e-02f, -4.52809334e-02f, 3.01879868e-02f, -8.68640840e-02f, -5.89540321e-03f, 8.35052133e-02f, -7.94034526e-02f, 1.06599107e-01f, 2.55700238e-02f, 1.96057782e-01f,
  9.86262858e-02f, 1.15460068e-01f, -3.04392874e-01f, 2.61495382e-01f, 1.02111712e-01f, -6.14127982e-03f, 2.17812173e-02f, 1.12967260e-01f, -2.11038858e-01f, -3.27834481e-04f,
  -1.15645933e-03f, 1.31036609e-01f, 1.14464313e-01f, 1.11960731e-01f, 7.96015561e-02f, -1.77433729e-01f, 7.75740370e-02f, 1.09263338e-01f, -1.69224307e-01f, -3.07100900e-02f,
  1.68928385e-01f, 1.00861765e-01f, -1.88826710e-01f, -1.22609228e-01f, -6.85875937e-02f, -3.56807113e-02f, 2.82698631e-01f, -2.26504266e-01f, -2.25958619e-02f, 3.44494015e-01f,
  -1.41208857e-01f, 3.18585902e-01f, 1.05060905e-01f, 2.25753129e-01f, 2.68985540e-01f, -2.37907916e-01f, 2.69520283e-01f, -4.09394093e-02f, -1.87529679e-02f, 7.64668360e-02f,
  2.21292853e-01f, 1.75289080e-01f, 1.05556287e-01f, 8.88303071e-02f, 5.95563501e-02f, 1.25663266e-01f, 1.91937492e-04f, -2.68982857e-01f, 2.81568617e-02f, 1.80783644e-01f,
  -2.15702951e-02f, 8.32773000e-02f, 1.44074410e-02f, -7.74394069e-03f, -4.69384389e-03f, 9.52407345e-02f, -1.10428303e-01f, 4.07665670e-02f, 7.24050924e-02f, 2.07787946e-01f,
  -1.65130179e-02f, 1.82768833e-02f, 6.70489371e-02f, 2.53356814e-01f, 1.06411614e-01f, 6.95252195e-02f, -1.99438371e-02f, 1.87118024e-01f, -2.30180565e-02f, 2.84808993e-01f,
  -4.96115051e-02f, 9.98988077e-02f, 1.55892327e-01f, -1.01301387e-01f, 1.93623863e-02f, -5.30358292e-02f, -3.54248509e-02f, 6.54679090e-02f, 1.34912744e-01f, 4.74690236e-02f,
  2.62984067e-01f, 3.24763842e-02f, -2.29786113e-01f, -5.23319170e-02f, 1.98579893e-01f, 1.11130476e-01f, -1.45723879e-01f, 4.09292094e-02f, 2.12826580e-01f, 8.70404113e-03f,
  6.19491935e-02f, -1.23861611e-01f, -1.15104549e-01f, 1.78138614e-01f, -3.14986371e-02f, 2.78341603e-02f, 3.03632110e-01f, 7.38338456e-02f, -1.07373402e-01f, -2.20128387e-01f,
  1.33393437e-01f, -3.48940730e-01f, 8.32914934e-02f, -2.69200295e-01f, -1.73059344e-01f, 5.55351265e-02f, 2.60217696e-01f, 4.25497890e-02f, 1.56320661e-01f, 1.12875486e-02f,
  2.16904402e-01f, 4.64124270e-02f, -8.04052036e-03f, 4.95878644e-02f, -1.31860018e-01f, 3.68602201e-02f, 2.19366819e-01f, 5.10502905e-02f, 1.48884133e-01f, 1.55515382e-02f,
  9.12673250e-02f, 1.70501158e-01f, 5.40447161e-02f, 1.97888613e-01f, 6.90529421e-02f, -3.33069526e-02f, -6.52675033e-02f, 6.26673698e-02f, 1.59782201e-01f, -8.08477402e-02f,
  5.86486906e-02f, 7.06709782e-03f, 7.65939951e-02f, 2.19021633e-01f, 6.26001731e-02f, 1.86971221e-02f, 3.29990298e-01f, 4.20614369e-02f, 2.29871184e-01f, -1.20750993e-01f,
  -7.43006065e-04f, 8.85524526e-02f, -1.09945908e-01f, 8.73627886e-02f, 9.69180316e-02f, -1.08322904e-01f, 1.63276792e-01f, -1.81027755e-01f, 2.21341357e-01f, 4.48213294e-02f,
  -8.49230289e-02f, 2.62371898e-01f, 4.06777829e-01f, 7.06790164e-02f, 1.21509857e-01f, -7.89230019e-02f, 3.02412391e-01f, -2.05107182e-01f, -5.64927608e-02f, -1.89803720e-01f,
  3.23214352e-01f, -1.90616503e-01f, -3.53912532e-01f, -2.77543634e-01f, -1.37984946e-01f, 5.23664057e-02f, -6.73425421e-02f, 1.51967183e-01f, -5.27815670e-02f, -8.61285105e-02f,
  6.44953623e-02f, 1.26978785e-01f, 6.01139851e-02f, -8.93625095e-02f, -1.10364128e-02f, 9.15835351e-02f, 9.82163846e-02f, 4.00156900e-02f, 1.44326121e-01f, 6.09780662e-02f,
  7.90331438e-02f, -1.97088607e-02f, -3.39596383e-02f, -1.24230191e-01f, -1.43651113e-01f, 9.12169740e-02f, -8.61721933e-02f, -4.41002548e-02f, -1.96419824e-02f, 6.25956059e-02f,
  -2.25271806e-01f, 2.11920415e-04f, 1.42984791e-02f, 1.61588520e-01f, 2.44156525e-01f, 6.21113293e-02f, -1.59448996e-01f, -4.01038229e-02f, 8.52049142e-02f, -2.10725054e-01f,
  -6.73849657e-02f, -8.07260424e-02f, 1.51241571e-01f, -9.03163925e-02f, 9.56681892e-02f, 1.79115221e-01f, 1.17861897e-01f, 1.61384895e-01f, -6.75490275e-02f, -1.12835936e-01f,
  2.27536216e-01f, 2.48460416e-02f, -2.87903041e-01f, 1.26542598e-01f, 1.80685688e-02f, 1.69040859e-01f, -4.66550261e-01f, 9.36708376e-02f, 2.13387191e-01f, 3.03447604e-01f,
  1.66140601e-01f, 2.62453377e-01f, 7.88550377e-02f, -8.05908293e-02f, -6.40163049e-02f, 2.46568471e-01f, -3.76697928e-02f, 1.08230487e-01f, -2.76172943e-02f, 1.67632382e-03f,
  -2.72847921e-01f, -1.56603783e-01f, 1.30347773e-01f, 1.68609545e-01f, -1.75544307e-01f, 3.94211672e-02f, -1.53051419e-02f, 1.99560579e-02f, -1.54470103e-02f, 1.44538552e-01f,
  9.45085064e-02f, -2.45666448e-02f, 5.00779152e-02f, 1.51222423e-02f, -2.30892543e-02f, 1.44733146e-01f, -5.85077032e-02f, 2.38306709e-02f, -1.06134474e-01f, 3.03252023e-02f,
  -1.58900041e-02f, 3.74610834e-02f, 7.92915449e-02f, 5.61386198e-02f, 2.62268316e-02f, 4.24767174e-02f, -1.00171924e-01f, -6.99597821e-02f, 1.10563904e-01f, -7.43748695e-02f,
  -1.47041589e-01f, -1.16623782e-01f, -1.29971337e-02f, -1.20616825e-02f, -6.69908151e-02f, 5.59119647e-03f, -6.39755428e-02f, 1.36359379e-01f, -7.12964358e-03f, -6.95636719e-02f,
  -9.91255566e-02f, 1.53848842e-01f, 9.16041508e-02f, -2.31708121e-02f, 6.30938038e-02f, -3.06103397e-02f, -1.79780722e-01f, 7.82814771e-02f, 8.22775811e-02f, -1.26418009e-01f,
  -2.16560706e-01f, -2.42692698e-02f, -1.09082706e-01f, 1.33581474e-01f, -1.24565840e-01f, 5.20391576e-03f, -6.96800137e-03f, 5.71417622e-02f, -3.28941554e-01f, -1.14221424e-01f,
  2.31765091e-01f, 3.73779655e-01f, -2.58771032e-01f, 3.17714526e-03f, 2.09952787e-01f, 3.39134425e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.58906235e-02f, 1.17772795e-01f, 5.86620569e-02f, 5.43058813e-02f, 9.24212784e-02f, 7.84397945e-02f, 1.72934651e-01f, 4.49737012e-02f, -1.04558587e-01f, 1.98549360e-01f,
  1.74967557e-01f, 1.12269968e-02f, -1.05274148e-01f, -4.10786904e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.71634272e-01f, 1.68522134e-01f, 2.20191911e-01f, -4.68478017e-02f, -2.04909608e-01f, -2.29975447e-01f, -3.32437344e-02f, 7.62997717e-02f, -1.09561205e-01f, -2.25055397e-01f,
  1.37840733e-01f, -2.30815895e-02f, -2.42067203e-01f, 1.49278700e-01f, -1.05962783e-01f, -1.98869444e-02f, 1.23615503e-01f, -1.55584544e-01f, -1.09177791e-01f, -6.54916763e-02f,
  -6.82159364e-02f, -2.04069898e-01f, -6.96206540e-02f, -5.33686765e-02f, -9.79015902e-02f, 1.14098206e-01f, 1.86222747e-01f, -3.43428999e-01f, 1.59388229e-01f, 3.66203003e-02f,
  -2.93078227e-03f, -2.18771324e-01f, 1.03299413e-02f, 1.21683627e-02f, 1.14836276e-01f, 1.69340655e-01f, 1.02456465e-01f, -2.31371410e-02f, 4.93308119e-02f, 2.93595456e-02f,
  -1.73846349e-01f, 2.32284859e-01f, 2.03968734e-01f, 2.25731179e-01f, 6.86420202e-02f, -6.55848160e-02f, -3.39824557e-01f, -3.27493370e-01f, 1.64016962e-01f, -9.72265825e-02f,
  2.00859070e-01f, 7.35321417e-02f, -3.72984082e-01f, 2.01191604e-02f, 2.12498605e-01f, 6.80751875e-02f, 6.92390129e-02f, 9.65551287e-02f, -1.72231793e-01f, -6.77350089e-02f,
  -5.88435791e-02f, -1.46589652e-01f, 1.49160698e-01f, 9.33061615e-02f, -1.31531209e-01f, 1.91594101e-02f, -1.35796338e-01f, -5.53080924e-02f, 8.35047886e-02f, -8.65259618e-02f,
  1.07058696e-01f, 2.78693855e-01f, 2.44980961e-01f, 9.21265483e-02f, 1.66210011e-01f, -4.23225127e-02f, 1.98132843e-01f, 8.26386586e-02f, 4.06622626e-02f, -5.73761277e-02f,
  1.26438923e-02f, -1.25944927e-01f, 1.37683719e-01f, 1.12145320e-01f, -1.01668492e-01f, -2.12312520e-01f, -1.86231751e-02f, 6.03517964e-02f, 2.52976567e-01f, 6.07081279e-02f,
  4.85514365e-02f, -1.17162988e-01f, -7.04067424e-02f, -1.31812453e-01f, -2.01104283e-01f, 3.46360244e-02f, -2.54213125e-01f, 1.04490789e-02f, -1.04179449e-01f, -8.09471607e-02f,
  -1.23724513e-01f, 8.09384435e-02f, -2.61650592e-01f, 3.03317159e-01f, -6.35228530e-02f, 1.93600893e-01f, 9.13245678e-02f, -2.80374587e-01f, -5.84320687e-02f, -7.94565156e-02f,
  -3.17382328e-02f, -2.67769575e-01f, -1.26862392e-01f, -6.12029955e-02f, 1.58954903e-01f, 2.00718045e-01f, 2.28345785e-02f, -2.23982066e-01f, 3.64753753e-02f, 7.09614679e-02f,
  -1.63866937e-01f, -2.89915532e-01f, 4.80203144e-02f, 3.61580737e-02f, 2.14793980e-01f, 2.14428872e-01f, -3.61976586e-02f, -1.70309797e-01f, -1.73829347e-01f, -2.06883699e-01f,
  -4.03476983e-01f, -1.23158190e-02f, 1.15052849e-01f, 1.16128037e-02f, -7.25566819e-02f, -4.16705459e-02f, -2.21109614e-01f, 2.93755457e-02f, -1.64219365e-01f, -2.13371471e-01f,
  -1.74359810e-02f, 1.86361283e-01f, -3.34783316e-01f, -4.06090878e-02f, -2.03072652e-02f, -2.54684716e-01f, 1.48848342e-02f, -1.17972836e-01f, 2.04327539e-01f, -3.38418514e-01f,
  -1.06985994e-01f, -9.78126824e-02f, -6.65099174e-02f, 6.96736276e-02f, 7.91377276e-02f, 1.07705452e-01f, -2.51539759e-02f, 1.04194349e-02f, 1.06817201e-01f, 1.33880218e-02f,
  -2.22408608e-01f, 9.10603032e-02f, 2.10790589e-01f, -3.65448967e-02f, -3.85046959e-01f, 6.89900368e-02f, -2.15417594e-01f, -2.89773624e-02f, -2.53077894e-01f, 8.23878348e-02f,
  -2.95760214e-01f, -3.51911277e-01f, -2.44953204e-02f, 2.83746123e-02f, -7.11068809e-02f, 6.23582937e-02f, 6.15442125e-03f, -2.92927533e-01f, -5.66230454e-02f, -3.02247405e-01f,
  1.53013840e-02f, 7.69166499e-02f, 2.18487173e-01f, -2.18480621e-02f, -1.66130334e-01f, -3.17720950e-01f, 1.40157193e-01f, -4.20626886e-02f, -6.55526295e-02f, -9.02305990e-02f,
  3.24964970e-01f, -1.77653767e-02f, 1.04141191e-01f, 2.11106569e-01f, -1.94513068e-01f, -2.26613656e-01f, 1.07696466e-01f, -1.06611677e-01f, -8.95735323e-02f, 5.51265315e-04f,
  2.49450635e-02f, -6.13490641e-02f, -6.47407696e-02f, 5.93871213e-02f, -9.91811156e-02f, 1.55490965e-01f, -2.17615306e-01f, 2.18477741e-01f, -2.28810757e-02f, 2.88641155e-02f,
  2.45771427e-02f, 1.52705163e-01f, 1.16231553e-04f, -2.04540879e-01f, -1.38760880e-01f, -2.39256676e-03f, -7.89327696e-02f, 1.26563773e-01f, 3.14337090e-02f, -2.42299512e-01f,
  1.92365587e-01f, -1.53158233e-02f, 4.31757599e-01f, -3.01267445e-01f, 1.96204241e-02f, 1.82125956e-01f, -1.25343829e-01f, 4.60700691e-02f, -1.18173346e-01f, 9.60915759e-02f,
  -1.39556807e-02f, 7.95791969e-02f, 2.84150224e-02f, 1.98260769e-02f, -2.48237863e-01f, -2.29620174e-01f, 1.77711830e-01f, 4.09417506e-03f, -2.20186546e-01f, 1.80481344e-01f,
  4.71056372e-01f, 4.17930894e-02f, 1.40184164e-01f, -3.38178910e-02f, -1.51216865e-01f, -1.99073970e-01f, 2.00967044e-01f, -5.53741604e-02f, 1.33791924e-01f, 8.05051699e-02f,
  8.96486714e-02f, -2.34266639e-01f, 1.70112953e-01f, -1.11641269e-02f, 1.34165198e-01f, 3.76831442e-02f, -2.30234358e-02f, 1.51655868e-01f, -3.50450762e-02f, 2.72743046e-01f,
  -7.46638030e-02f, 4.77821417e-02f, 2.79605594e-02f, 2.74079800e-01f, 3.15437406e-01f, -7.97512308e-02f, -5.45285642e-02f, 4.11414392e-02f, -1.57571375e-01f, -5.55550642e-02f,
  2.73810059e-01f, -4.43322472e-02f, 4.89125922e-02f, 1.62806988e-01f, -5.55294007e-02f, 4.33219690e-03f, -2.53197979e-02f, -1.34004364e-02f, 6.29560649e-02f, -1.99836418e-02f,
  1.49122909e-01f, -6.22612685e-02f, 2.05805391e-01f, -1.24439739e-01f, 4.12511937e-02f, -6.14204183e-02f, -2.11622253e-01f, -9.83077437e-02f, 3.36999372e-02f, 3.95049229e-02f,
  1.58874214e-01f, 9.45655629e-02f, 8.37182105e-02f, 1.63243804e-02f, 8.53966773e-02f, 1.41497940e-01f, 1.66965148e-03f, 8.83385912e-03f, 3.39443147e-01f, 1.73971474e-01f,
  2.14638695e-01f, -1.15566902e-01f, -3.04970920e-01f, -4.33599055e-01f, 3.04756433e-01f, 1.54423103e-01f, 1.28655151e-01f, 2.65812099e-01f, -1.23714328e-01f, -1.53053537e-01f,
  -2.85136681e-02f, 5.66694923e-02f, -3.35388184e-02f, 2.36518621e-01f, -1.44158751e-01f, -1.74782816e-02f, 7.59961903e-02f, 3.41958493e-01f, -1.86885297e-01f, -3.16152662e-01f,
  -1.66609377e-01f, -2.73337904e-02f, 1.68260392e-02f, 2.52997335e-02f, -2.23280981e-01f, -2.69840080e-02f, -5.07393703e-02f, -2.03716263e-01f, -4.28246409e-01f, 1.39316231e-01f,
  1.39000520e-01f, -3.82008292e-02f, 1.02517061e-01f, 2.89316066e-02f, 1.59159899e-01f, -1.10820852e-01f, -2.62660719e-02f, -2.78112316e-03f, -1.66509941e-01f, -9.81786922e-02f,
  8.58720541e-02f, 1.27927121e-03f, -1.85623631e-01f, -1.83885712e-02f, -6.29114062e-02f, 6.25985637e-02f, 5.01876650e-03f, -1.27103224e-01f, -1.23656102e-01f, -3.65144491e-01f,
  -1.96753711e-01f, -2.95630842e-01f, -3.73639166e-02f, 2.34762356e-01f, 3.55710804e-01f, -1.14496201e-01f, -2.06663832e-01f, 1.91451401e-01f, -7.25594759e-02f, -1.38465866e-01f,
  -3.01641315e-01f, 1.47173464e-01f, -1.45324662e-01f, 2.67660558e-01f, 6.16391413e-02f, -3.83805007e-01f, 1.85199872e-01f, -1.48722753e-01f, 5.53337783e-02f, -1.79329634e-01f,
  -3.25233787e-02f, -1.11008100e-01f, -7.13018477e-02f, -3.27597409e-02f, -1.11161478e-01f, -7.99659044e-02f, -1.60935894e-03f, -1.75029606e-01f, 1.43344849e-01f, -9.99181196e-02f,
  2.81077228e-03f, 2.65410524e-02f, 1.62485999e-03f, 4.27252874e-02f, -1.76058784e-02f, -1.19824551e-01f, -2.65751630e-01f, -2.62330435e-02f, 2.33068597e-02f, 1.72045365e-01f,
  -1.92802064e-02f, 2.33424634e-01f, 8.11728761e-02f, 3.13637942e-01f, -2.26534545e-01f, -4.23420928e-02f, 4.71211560e-02f, -8.44793692e-02f, -1.83731467e-01f, -1.67798653e-01f,
  1.17515534e-01f, 3.89797874e-02f, 1.86598971e-01f, 1.59107655e-01f, -9.23058093e-02f, 3.68314497e-02f, 8.97599384e-02f, -7.35080317e-02f, -3.14688240e-03f, 7.98266456e-02f,
  9.12556499e-02f, 6.97933510e-02f, -1.23951532e-01f, -8.94609988e-02f, -1.80479065e-01f, 1.95976794e-01f, -1.79783314e-01f, 9.87740234e-02f, -1.68474346e-01f, -1.75433233e-01f,
  -1.86433390e-01f, 2.28817016e-01f, -6.58750162e-02f, 2.61960894e-01f, -1.73541352e-01f, 1.65440559e-01f, -1.10039346e-01f, -1.94119737e-01f, -5.59155531e-02f, -9.44699571e-02f,
  8.13458040e-02f, -7.43847117e-02f, -8.79030749e-02f, -1.50146857e-01f, 2.26902887e-01f, 1.26299515e-01f, 2.46131495e-01f, -7.71615934e-03f, 7.98200667e-02f, 2.23457873e-01f,
  -2.55910724e-01f, -3.50934058e-01f, 2.88652498e-02f, -1.24220312e-01f, 2.88456291e-01f, -1.33520275e-01f, -9.28834528e-02f, -1.54209863e-02f, -7.90316463e-02f, 1.80592313e-01f,
  -1.57089323e-01f, -5.54179065e-02f, 1.01955228e-01f, 1.97313465e-02f, 7.52032474e-02f, -1.97642013e-01f, 1.43160060e-01f, 3.86492983e-02f, -7.26032779e-02f, 1.11755896e-02f,
  -6.93045557e-02f, 1.51168898e-01f, -1.71020210e-01f, 2.43562594e-01f, 9.89699811e-02f, 2.63165832e-02f, -1.23038463e-01f, 1.15627721e-01f, 7.30044097e-02f, 2.91742943e-02f,
  4.55880351e-02f, 8.47559869e-02f, 1.65178791e-01f, -4.68994901e-02f, -7.25757703e-02f, 1.47083448e-02f, 2.55423218e-01f, 3.31224561e-01f, 3.60145688e-01f, -2.76139945e-01f,
  -4.37517203e-02f, -6.20243363e-02f, 2.62257367e-01f, 9.00907740e-02f, -1.16580024e-01f, 1.21527448e-01f, 2.19516486e-01f, -2.77835757e-01f, 1.13885961e-01f, 2.41557080e-02f,
  -7.02816918e-02f, -2.10525438e-01f, 1.61254495e-01f, 2.15849578e-01f, -2.24128738e-02f, 2.87627012e-01f, 2.52557456e-01f, -4.92646098e-02f, 1.25350729e-02f, -4.21403348e-02f,
  -4.08526249e-02f, 3.19875389e-01f, 1.32644400e-01f, 4.47184965e-03f, -7.20698088e-02f, 3.48664105e-01f, -1.23692945e-01f, -1.01446241e-01f, 1.32928073e-01f, -3.22232470e-02f,
  2.46422648e-01f, -1.34120315e-01f, 1.67900637e-01f, 6.48294436e-03f, 2.33121985e-03f, 6.13336749e-02f, -2.52284437e-01f, 2.61394791e-02f, -1.06972329e-01f, -9.42900106e-02f,
  3.41846645e-02f, -6.71074614e-02f, -8.69124010e-02f, 1.42090961e-01f, 1.17965110e-01f, -1.87844962e-01f, 1.15736559e-01f, 1.26617074e-01f, 1.11117177e-02f, 2.00819090e-01f,
  -2.66078245e-02f, -8.71372130e-03f, -1.89043254e-01f, 2.21564516e-01f, -2.24276353e-02f, 1.34182692e-01f, 2.07077935e-02f, -2.86088623e-02f, 1.09052807e-01f, 1.91905126e-01f,
  1.08188778e-01f, -1.64854661e-01f, -1.68019071e-01f, 1.48839667e-01f, 2.37673372e-01f, 5.81483729e-02f, -1.50415823e-01f, 1.36848137e-01f, 2.31763899e-01f, -1.02591515e-01f,
  2.97776073e-01f, -2.31122255e-01f, 1.02534339e-01f, -1.04479291e-01f, 2.08306029e-01f, 1.38534516e-01f, -4.76604467e-03f, -1.31428987e-01f, 1.59787565e-01f, -1.08409978e-01f,
  9.51779932e-02f, -1.94653273e-01f, -6.33772910e-02f, 2.34904662e-01f, -1.92872211e-01f, 1.32699654e-01f, -1.91844463e-01f, 2.14497492e-01f, 9.84620377e-02f, 3.52441184e-02f,
  -6.15206063e-02f, -1.35282993e-01f, -3.54744047e-02f, -7.55645260e-02f, -2.56456822e-01f, 1.49881080e-01f, -3.31739098e-01f, -7.69849494e-03f, -1.49186522e-01f, 1.14764012e-01f,
  -5.61561733e-02f, 6.52758479e-02f, 2.57002609e-03f, 1.00765154e-01f, 1.06766276e-01f, 2.61603057e-01f, -1.66846234e-02f, 7.46324435e-02f, -3.00776493e-02f, -5.22611197e-04f,
  -9.77356583e-02f, 8.15370213e-03f, 7.87575170e-02f, 1.11804329e-01f, -1.18125565e-01f, 3.08987126e-03f, 1.18943535e-01f, -6.38392791e-02f, 4.10717018e-02f, -2.09638283e-01f,
  -1.21068232e-01f, -2.49955095e-02f, 1.41103685e-01f, -9.45729986e-02f, -1.79619849e-01f, 1.86576769e-01f, -5.70731349e-02f, -1.96489409e-01f, 8.24807510e-02f, -7.00017735e-02f,
  1.35432556e-03f, -8.00083799e-04f, -2.03212708e-01f, 8.04631710e-02f, -9.75197852e-02f, 8.28266814e-02f, -1.47308469e-01f, 3.45737599e-02f, -1.91026524e-01f, -1.57486815e-02f,
  -1.15895970e-02f, -3.79368700e-02f, -3.14452946e-01f, -2.34512120e-01f, 3.40516627e-01f, -2.12562382e-01f, -2.57145893e-02f, -1.05230540e-01f, -2.47663721e-01f, -1.58124864e-01f,
  7.29051605e-02f, 1.30260959e-01f, -1.96225256e-01f, 2.37134099e-01f, -1.31820992e-01f, -1.02867521e-01f, -4.89574820e-02f, 2.09009752e-01f, -3.47643858e-04f, 4.55512553e-02f,
  1.30670056e-01f, -2.24890634e-01f, -6.36965968e-03f, -1.01331264e-01f, 5.39017022e-02f, 3.20616849e-02f, 4.32119928e-02f, -6.36024401e-02f, -1.70877188e-01f, -1.95271298e-01f,
  -1.28333300e-01f, -3.65621924e-01f, -9.81301740e-02f, -2.36579403e-01f, -1.29491553e-01f, -1.05516694e-01f, -2.59562224e-01f, -1.26630634e-01f, -1.90073952e-01f, -1.52804375e-01f,
  8.23208615e-02f, -9.34991464e-02f, -2.15459228e-01f, 2.91063040e-02f, -1.68325931e-01f, 6.55378541e-03f, 7.60898041e-03f, 1.77566215e-01f, -4.26922888e-02f, -1.66451722e-01f,
  5.55077894e-03f, -2.07414299e-01f, -9.03758034e-03f, 4.98554781e-02f, -2.35822305e-01f, -1.49019286e-01f, 1.20763674e-01f, -1.42255038e-01f, -1.79480612e-01f, 2.41561681e-02f,
  -6.85706213e-02f, 1.10330759e-02f, -7.67163262e-02f, 1.10619023e-01f, -6.12597689e-02f, 2.82221120e-02f, 2.60652572e-01f, 1.66868612e-01f, -2.86165953e-01f, 4.27545607e-02f,
  -1.36957973e-01f, -6.28003012e-03f, 1.04565993e-01f, 2.54539903e-02f, -2.19944790e-02f, -1.65271893e-01f, 6.32751212e-02f, -2.78539687e-01f, 1.45133629e-01f, 5.90449572e-02f,
  5.49817085e-02f, -1.10686027e-01f, 1.00216150e-01f, 1.70115530e-01f, -8.36897176e-03f, 2.34938916e-02f, 1.48456991e-01f, 4.92745601e-02f, -7.27690011e-02f, -4.85594496e-02f,
  6.16663583e-02f, -1.27945438e-01f, 1.89738274e-01f, -1.45522028e-01f, -1.02617316e-01f, -3.20377707e-01f, -8.04985687e-02f, -2.28102461e-01f, -5.53979948e-02f, -1.28648117e-01f,
  -2.27155965e-02f, 4.44741100e-02f, -1.46309331e-01f, -3.64367850e-02f, -9.32085365e-02f, 1.46174952e-01f, -1.95982337e-01f, 2.40119353e-01f, -2.27127634e-02f, -1.47126868e-01f,
  -3.27402577e-02f, 2.24476039e-01f, -4.72942963e-02f, 9.40333903e-02f, -1.73584208e-01f, 1.06892087e-01f, -6.88044950e-02f, -1.35421291e-01f, -2.29098991e-01f, -3.27037089e-02f,
  3.99436921e-01f, -2.53934830e-01f, -2.17793569e-01f, -3.82157490e-02f, 6.77524656e-02f, 6.29178807e-02f, 2.69658297e-01f, 2.19896749e-01f, 7.34583363e-02f, -4.97951880e-02f,
  -2.49530748e-03f, 1.96213294e-02f, -2.26472929e-01f, -1.64847732e-01f, 9.59874466e-02f, 1.79384321e-01f, -7.76459128e-02f, 2.44190425e-01f, 6.25173673e-02f, 4.90743015e-03f,
  -1.36641145e-01f, -2.72673190e-01f, -1.69380352e-01f, -5.08381836e-02f, 6.23006746e-02f, 1.36671022e-01f, -2.57307708e-01f, -2.14883447e-01f, 1.39293745e-01f, 2.51640659e-02f,
  1.25635475e-01f, -3.53996456e-02f, -1.36823341e-01f, 1.25701547e-01f, -7.88912848e-02f, -1.55479042e-02f, -1.56390235e-01f, -6.98040724e-02f, 4.97426726e-02f, 9.06357393e-02f,
  1.08730784e-02f, -1.76072180e-01f, 1.42970145e-01f, 1.04960114e-01f, 7.92661011e-02f, -2.75505856e-02f, -9.54421088e-02f, 4.37161922e-02f, 6.53599650e-02f, 3.60860117e-02f,
  3.56451385e-02f, 8.11999943e-03f, -2.25179065e-02f, 1.83261991e-01f, -1.35699376e-01f, -2.45411023e-01f, -1.07863694e-02f, -2.08589315e-01f, -1.12486277e-02f, -7.47566372e-02f,
  -8.41467455e-02f, 2.54449666e-01f, -1.34682715e-01f, -1.96430117e-01f, -8.81162751e-03f, 1.81746364e-01f, -1.19354099e-01f, -9.71857160e-02f, 5.71710654e-02f, -1.43896118e-01f,
  -2.09966362e-01f, 2.65774250e-01f, -9.76269320e-02f, -1.41973510e-01f, 1.69419702e-02f, -6.10023998e-02f, -7.26014599e-02f, -5.14384471e-02f, -1.75978750e-01f, -2.51360368e-02f,
  6.83001950e-02f, -3.48439932e-01f, 1.46347567e-01f, -2.17160732e-01f, 1.53147250e-01f, 1.04508111e-02f, 1.77753061e-01f, -3.89410332e-02f, -1.50559871e-02f, -1.68350562e-01f,
  -1.11892093e-02f, 2.32306287e-01f, 5.85232489e-02f, -9.32859629e-02f, -1.35005832e-01f, -1.82029083e-01f, 6.13524467e-02f, 4.11850512e-02f, -8.00070018e-02f, 8.98912847e-02f,
  -4.05107662e-02f, -1.57666355e-01f, 2.00836480e-01f, 7.86656216e-02f, -1.07864864e-01f, 8.80810022e-02f, -1.42746150e-01f, 6.89264685e-02f, -9.16823596e-02f, -1.30235046e-01f,
  2.53331400e-02f, -2.14044109e-01f, 2.69406177e-02f, 4.62600775e-03f, 1.44837573e-01f, -2.41931260e-01f, -7.95034096e-02f, 8.52848142e-02f, 2.27643121e-02f, -3.67740244e-01f,
  -1.81230586e-02f, -1.58647436e-03f, 1.79386318e-01f, -1.54089868e-01f, 2.44341627e-01f, 1.21062957e-01f, 1.04596168e-01f, 1.54892430e-01f, 1.67737845e-02f, -1.29933551e-01f,
  1.07981257e-01f, 1.17063008e-01f, -8.60495567e-02f, -1.29652545e-01f, -2.61129349e-01f, -7.13373646e-02f, -3.05100847e-02f, -9.94556025e-03f, -3.31934495e-03f, -4.13548052e-02f,
  -6.76560961e-03f, -6.81919232e-02f, -6.87950775e-02f, -2.00372085e-01f, 8.66132230e-02f, -4.31367338e-01f, 4.42139581e-02f, -1.28170401e-01f, 8.57654437e-02f, 2.28892013e-01f,
  1.40506074e-01f, -1.18843123e-01f, -4.68223132e-02f, -2.83318162e-02f, 1.62549257e-01f, 2.38606900e-01f, 4.78505567e-02f, -2.44943112e-01f, -1.03940576e-01f, 1.27119264e-02f,
  2.71005273e-01f, 1.30617499e-01f, -1.32094234e-01f, -9.07672048e-02f, -1.40790984e-01f, 1.12441577e-01f, -1.16053753e-01f, 8.58048052e-02f, 1.62604794e-01f, -1.31925736e-02f,
  -1.06765792e-01f, -1.00735493e-01f, 4.03500535e-03f, -1.49481177e-01f, 1.58072542e-02f, 9.87352654e-02f, 7.91723728e-02f, 6.64213970e-02f, -1.29421309e-01f, -9.30171553e-03f,
  4.85189706e-02f, -9.74210575e-02f, -9.59886760e-02f, 3.24128598e-01f, 1.02459356e-01f, -2.95748413e-02f, 1.57957494e-01f, 1.20697342e-01f, -7.52891973e-02f, -2.16292471e-01f,
  -2.19916895e-01f, 2.85217445e-02f, 9.27970558e-03f, -9.54770073e-02f, -1.37206748e-01f, 1.10654928e-01f, 1.88168921e-02f, -2.57405080e-02f, 7.91170169e-03f, -5.72966114e-02f,
  -1.18122064e-02f, 6.10703975e-02f, 3.65539610e-01f, 2.57468879e-01f, -2.98765689e-01f, -3.30395810e-02f, -2.00926796e-01f, 8.42116773e-02f, 3.40986177e-02f, 3.47001791e-01f,
  1.57359347e-01f, -1.27803773e-01f, -9.07735378e-02f, -2.47168988e-01f, 1.04801528e-01f, -1.35655224e-01f, -8.40815380e-02f, -3.23226810e-01f, 1.18381567e-01f, 1.91893697e-01f,
  1.97688863e-02f, -1.11253776e-01f, 5.24985269e-02f, -8.48090425e-02f, 1.05270907e-01f, 2.40972161e-01f, 3.78620578e-03f, -1.33422017e-01f, -1.30472869e-01f, -6.70885593e-02f,
  1.61773011e-01f, 8.08086544e-02f, -1.13597447e-02f, -1.59554750e-01f, -2.52274964e-02f, -1.57445952e-01f, 4.00864705e-02f, 2.28411350e-02f, 2.33314633e-02f, -5.90492375e-02f,
  8.89518484e-02f, -1.35686576e-01f, -1.51738729e-02f, -1.45032406e-02f, 1.61981024e-02f, 4.45350595e-02f, -4.26283590e-02f, -1.05891243e-01f, -3.01733613e-01f, -1.80696785e-01f,
  -4.82510328e-01f, 1.16075166e-01f, 1.69337824e-01f, 1.64038673e-01f, 3.31083201e-02f, -1.59471676e-01f, 1.59373969e-01f, -2.32485741e-01f, -6.46447837e-02f, -6.72719441e-03f,
  -2.78767914e-01f, -1.75752431e-01f, -1.34729156e-02f, 2.61260957e-01f, -8.79652277e-02f, -1.55119911e-01f, 7.08284006e-02f, -3.10705677e-02f, -3.81765395e-01f, -1.55049741e-01f,
  2.46032476e-01f, -1.04377910e-01f, -1.34385630e-01f, 7.23126009e-02f, 3.85300741e-02f, -1.13459840e-01f, 6.14050357e-03f, -2.97848314e-01f, 1.58618003e-01f, -1.51368022e-01f,
  -3.54932435e-02f, 2.30708972e-01f, 1.20004684e-01f, 1.25009030e-01f, 1.27408430e-01f, -2.19101295e-01f, 1.64370954e-01f, -9.93261933e-02f, -1.98559947e-02f, -1.41727895e-01f,
  2.51446236e-02f, 2.28464648e-01f, 1.67260766e-01f, -9.73342583e-02f, 5.28090112e-02f, -2.91361898e-01f, -1.33738384e-01f, 1.98968917e-01f, -2.34221041e-01f, 1.27109051e-01f,
  -7.81083554e-02f, -2.36650079e-01f, 4.09635268e-02f, -1.36458755e-01f, -1.14096798e-01f, 8.71975347e-02f, -8.63681957e-02f, 2.10475177e-02f, -1.22070163e-01f, -3.59536260e-02f,
  7.81229511e-02f, 6.75043091e-02f, 2.57461667e-01f, 6.92743286e-02f, 8.43695700e-02f, 6.93384409e-02f, 1.45380363e-01f, -2.73112416e-01f, 4.57605273e-02f, -8.94006193e-02f,
  1.02784663e-01f, 1.07708596e-01f, -1.18267149e-01f, 4.42075767e-02f, 1.97164103e-01f, 2.01003790e-01f, 4.11671400e-02f, 2.86881447e-01f, -9.29932222e-02f, 1.76706389e-01f,
  -1.68050397e-02f, 1.38871565e-01f, 6.88954964e-02f, 2.50458300e-01f, -1.17092252e-01f, -2.44705454e-02f, -1.48936466e-03f, -1.27214670e-01f, 4.71143648e-02f, 2.55541690e-03f,
  -1.82444826e-02f, 7.16006383e-02f, -9.53322053e-02f, 1.97851345e-01f, 8.34047720e-02f, -1.72712877e-01f, -1.03525914e-01f, 2.66463220e-01f, -1.28045917e-01f, 2.71195590e-01f,
  -2.30568517e-02f, -4.02522460e-02f, -1.54493645e-01f, -1.06479406e-01f, -1.01881459e-01f, 2.88312286e-01f, 3.79370451e-02f, -1.41717836e-01f, -6.72770813e-02f, -1.39718398e-01f,
  -6.19082339e-02f, -1.70298237e-02f, 2.26244763e-01f, -1.91320181e-01f, 2.90347934e-01f, -9.47186500e-02f, -1.99797284e-02f, -1.79361418e-01f, -1.80087849e-01f, 2.18185913e-02f,
  1.07252292e-01f, -3.15765291e-02f, 8.77056792e-02f, -1.46908522e-01f, 1.32031530e-01f, 7.57493675e-02f, -8.43026768e-03f, -1.17758147e-01f, -2.46779755e-01f, 3.36636335e-01f,
  2.21309275e-03f, -2.31577158e-01f, -2.76810881e-02f, -1.24121852e-01f, -3.68438177e-02f, -2.14439675e-01f, -1.18716300e-01f, 2.20689222e-01f, 5.68970889e-02f, 1.29583031e-01f,
  2.45834216e-01f, 1.67338118e-01f, -1.30167723e-01f, -2.29144707e-01f, -8.46600384e-02f, -2.95551151e-01f, -1.32624954e-01f, -1.80841222e-01f, 1.92350447e-01f, -1.98951014e-03f,
  3.09333473e-01f, -1.09429315e-01f, -6.67353570e-02f, 1.09305255e-01f, -2.19367296e-01f, -5.72600178e-02f, -2.09750503e-01f, 1.45887807e-01f, 1.74387008e-01f, 2.68834889e-01f,
  -1.84925407e-01f, -3.89067456e-02f, 5.74541092e-02f, 1.85303733e-01f, -5.25280647e-02f, -4.47499603e-02f, -1.65796816e-01f, -5.79136796e-02f, 3.25697452e-01f, 1.20400578e-01f,
  -1.10540010e-01f, 2.71196719e-02f, -1.16467603e-01f, -2.08083719e-01f, 6.55091787e-03f, -8.87276456e-02f, 8.74659698e-03f, -1.27760187e-01f, 3.45916040e-02f, -8.20883960e-02f,
  -1.24997698e-01f, -1.56738937e-01f, -8.43365118e-02f, 1.50853753e-01f, 9.25700180e-03f, 1.33752704e-01f, -4.86745834e-02f, -1.37522146e-01f, -8.05483460e-02f, 2.28806958e-01f,
  8.37826952e-02f, -1.58615381e-01f, -2.45483890e-01f, 1.39746234e-01f, -5.30068688e-02f, -1.56649575e-01f, -1.98124424e-01f, -2.26325959e-01f, -8.09852779e-02f, -2.82130688e-01f,
  -2.93641388e-01f, 2.03608707e-01f, -3.56522977e-01f, -1.63367569e-01f, 2.22093821e-01f, 5.62147982e-02f, -9.25180241e-02f, -2.09009498e-01f, 2.87782103e-01f, 2.73028277e-02f,
  -5.21163106e-01f, -7.94174001e-02f, 1.00441456e-01f, -2.73689702e-02f, 8.16960186e-02f, -5.61405979e-02f, -1.12412302e-02f, -2.42746323e-02f, -1.21609628e-01f, -2.38541082e-01f,
  2.57505067e-02f, -1.38432756e-01f, -3.60578783e-02f, 8.20381418e-02f, -2.38654241e-01f, -3.47159691e-02f, 1.71606675e-01f, -2.43934929e-01f, -4.59133089e-02f, -2.72607595e-01f,
  3.05639077e-02f, 4.03643921e-02f, -3.81976426e-01f, -1.36966333e-01f, -2.88057715e-01f, -1.88971445e-01f, 3.76962610e-02f, 2.63811424e-02f, -3.91185619e-02f, -9.24789757e-02f,
  -1.18780158e-01f, 1.30982488e-01f, -2.68571433e-02f, -2.18314797e-01f, 1.32141918e-01f, 3.96934152e-02f, -9.63141769e-03f, -3.40145566e-02f, 3.45873870e-02f, -5.15367500e-02f,
  1.23529091e-01f, 9.14353803e-02f, -1.22193843e-01f, 2.61122048e-01f, 2.05492854e-01f, 7.07719428e-03f, 1.57108292e-01f, -2.54935515e-03f, 6.20939136e-02f, -1.34295329e-01f,
  -6.97984453e-03f, -7.72758620e-03f, 2.42915824e-02f, 1.18067183e-01f, 2.36745089e-01f, -1.61233380e-01f, 2.55842775e-01f, -2.22354680e-02f, 1.55025050e-01f, 2.25924440e-02f,
  -2.07583874e-01f, 1.50923088e-01f, 8.91484320e-02f, 1.79559931e-01f, -1.37559429e-01f, 1.31510362e-01f, 9.05578732e-02f, 2.18544900e-02f, 2.15673268e-01f, 2.89261073e-01f,
  -2.66947299e-01f, -1.28591331e-02f, 1.24893403e-02f, -3.19297835e-02f, -6.84112590e-03f, 2.55495727e-01f, 3.93155925e-02f, -1.85077399e-01f, 1.07187591e-01f, -7.67619461e-02f,
  6.59828708e-02f, -1.35925591e-01f, -1.18147396e-01f, 9.36759189e-02f, 1.75703466e-01f, -1.38491496e-01f, -8.50609690e-02f, 3.77782770e-02f, 1.21599965e-01f, 1.60573944e-01f,
  9.22617409e-03f, -4.72511239e-02f, 2.08435506e-01f, 4.53306437e-02f, -5.31593561e-02f, -2.09605414e-02f, -1.64764538e-01f, -1.31501034e-01f, -7.88098499e-02f, 5.49998023e-02f,
  2.71154102e-02f, 6.77274913e-02f, -1.80410653e-01f, 2.22282745e-02f, -1.36314362e-01f, -6.37500361e-02f, -2.78830770e-02f, 1.63852215e-01f, 6.04909658e-02f, 3.62489849e-01f,
  -3.95149775e-02f, 5.34289982e-03f, -4.21914607e-02f, 1.86594166e-02f, -9.65470001e-02f, -6.72922879e-02f, -2.28952132e-02f, -1.95721656e-01f, -1.89698488e-01f, -4.01659273e-02f,
  -3.88907604e-02f, -7.82284886e-02f, 1.43056244e-01f, -3.73311043e-01f, 9.40780938e-02f, 1.99672133e-01f, 8.10693577e-02f, -3.76326498e-03f, 6.47407472e-02f, 1.11141324e-01f,
  5.30893765e-02f, -2.90538501e-02f, 3.49912047e-02f, 2.13007748e-01f, -2.03787535e-01f, 3.17168608e-02f, -1.35339886e-01f, 6.06937846e-03f, -3.38136964e-02f, 4.12513241e-02f,
  -8.52793306e-02f, -1.17620900e-01f, -1.91220567e-01f, 1.30852610e-01f, 5.33342883e-02f, 1.13311633e-01f, -1.99223712e-01f, 4.59087156e-02f, -9.35541391e-02f, -1.73999280e-01f,
  -1.38552815e-01f, -6.78618550e-02f, 1.29761428e-01f, 1.73738468e-02f, -7.59109333e-02f, 8.66678655e-02f, -9.12210941e-02f, 8.38623643e-02f, -1.20294206e-01f, 1.24360964e-01f,
  -1.66828409e-01f, 1.44090608e-01f, 2.57117376e-02f, 1.80042814e-02f, -4.37948890e-02f, 9.79549345e-03f, -1.50237754e-01f, -1.03953391e-01f, -1.46487817e-01f, 4.57816049e-02f,
  -1.82772987e-02f, 1.28653809e-01f, 1.59886405e-01f, 2.46441856e-01f, 3.49656761e-01f, -1.48584217e-01f, -7.67759308e-02f, -8.65784734e-02f, 1.92970887e-01f, 1.22063763e-01f,
  7.83032179e-02f, 1.25533834e-01f, 8.14817920e-02f, 5.38519993e-02f, 2.06428811e-01f, 1.07148200e-01f, -2.14041993e-01f, -1.28435314e-01f, 4.29477617e-02f, 2.29857132e-01f,
  -1.00413999e-02f, 1.11054033e-01f, 2.92339534e-01f, -1.19154854e-02f, -1.80590540e-01f, 6.18379153e-02f, 7.51457512e-02f, 2.20698584e-03f, -2.70563871e-01f, 6.20182529e-02f,
  -3.82720260e-04f, 2.25705534e-01f, -4.54544723e-02f, 1.47958621e-01f, -2.78645568e-02f, -3.73843223e-01f, 3.61966044e-02f, -1.53673604e-01f, -7.71781728e-02f, 8.56581703e-02f,
  1.54070463e-02f, 2.76723474e-01f, 1.08829821e-02f, -3.60601693e-02f, -7.30372965e-02f, 7.90972784e-02f, 2.04129398e-01f, -7.66043812e-02f, -4.82543372e-02f, -2.19821617e-01f,
  9.11571980e-02f, -1.45564884e-01f, 1.78741187e-01f, -9.46593508e-02f, 8.62832591e-02f, -1.00640714e-01f, 8.99742171e-02f, -6.37758896e-02f, -7.00521320e-02f, -6.28405884e-02f,
  -9.71800685e-02f, -6.60677180e-02f, -1.07540183e-01f, -1.93705037e-01f, 5.83024248e-02f, 3.26738477e-01f, 2.17811987e-01f, 9.74642187e-02f, -2.15553463e-01f, 1.11045919e-01f,
  8.45409036e-02f, 1.79818664e-02f, 1.70438793e-02f, -2.27188561e-02f, 1.06623657e-01f, 5.04992343e-02f, 1.95820421e-01f, 1.67282764e-02f, 2.83427648e-02f, 1.52277082e-01f,
  2.88500279e-01f, -7.49652311e-02f, -1.10567689e-01f, 2.56962210e-01f, 1.66792683e-02f, 1.53600782e-01f, -2.61254847e-01f, 1.88785866e-01f, 8.91748369e-02f, 1.68613464e-01f,
  2.17630535e-01f, 4.97438759e-02f, -1.76994964e-01f, 9.12791565e-02f, -2.37432063e-01f, 9.97742191e-02f, -1.33538947e-01f, 3.60464096e-01f, 1.48992106e-01f, -5.63649535e-02f,
  -9.07676443e-02f, -5.96298277e-02f, 1.13922551e-01f, -1.62493452e-01f, 1.48369998e-01f, 4.17126268e-02f, 1.53468445e-01f, 2.06007287e-01f, 1.42479047e-01f, -3.05513311e-02f,
  5.60928024e-02f, -7.92929381e-02f, -1.98839791e-02f, 7.97091983e-03f, 2.23619208e-01f, -1.34422272e-01f, -3.09249051e-02f, -1.83549419e-01f, 5.42205311e-02f, -9.77687761e-02f,
  -4.67789993e-02f, 1.12719424e-01f, -3.66377458e-02f, -9.03471000e-03f, -8.87483824e-03f, 1.86636388e-01f, 4.69175838e-02f, -7.75624812e-02f, -1.36249587e-01f, 1.79266319e-01f,
  -1.86583236e-01f, -2.71867048e-02f, -2.27447972e-01f, 1.63080096e-01f, 1.27573460e-01f, -4.41399813e-02f, -3.03026885e-01f, -3.33877467e-02f, 1.81367025e-01f, -8.69006068e-02f,
  -2.88913608e-01f, 1.95859611e-01f, 3.96033414e-02f, -3.91197950e-02f, -5.23477085e-02f, -4.62720580e-02f, 3.18980068e-02f, -3.87966298e-02f, 3.24803114e-01f, 2.63546556e-01f,
  -3.76139611e-01f, 2.34498486e-01f, 3.06855850e-02f, -8.51562917e-02f, 2.52230734e-01f, 1.52992636e-01f, -7.05994368e-02f, -5.01678400e-02f, -4.00089892e-03f, -3.76958072e-01f,
  2.68326122e-02f, -2.04369158e-01f, 2.82262508e-02f, 9.18978900e-02f, -3.60063799e-02f, -3.80924083e-02f, 2.32873097e-01f, 3.63302566e-02f, 1.10053256e-01f, -1.92579299e-01f,
  -2.25145951e-01f, 1.12136630e-02f, -8.42435360e-02f, -2.82755289e-02f, 6.89512938e-02f, -4.20692451e-02f, 4.00294587e-02f, 3.52474935e-02f, -2.78060734e-01f, -3.95381600e-02f,
  -8.56705606e-02f, 1.10159824e-02f, -3.14181894e-02f, -1.62832625e-02f, 7.82556981e-02f, -5.47415875e-02f, -1.37768909e-01f, -3.42038125e-02f, 1.59832910e-01f, 6.14637509e-02f,
  1.47287110e-02f, -1.81675062e-01f, 7.18728378e-02f, 4.59621288e-02f, 8.14549066e-03f, -9.32673290e-02f, 5.45193106e-02f, 1.17020331e-01f, 2.76677370e-01f, -2.81680137e-01f,
  7.35442862e-02f, 2.13935733e-01f, 5.10342196e-02f, 1.43084764e-01f, 2.42208287e-01f, 9.49609354e-02f, 2.40866363e-01f, -7.09824860e-02f, 8.56603831e-02f, 4.76478636e-01f,
  9.51859877e-02f, -2.09415355e-03f, 1.74482971e-01f, -4.03705649e-02f, 1.33239627e-01f, 2.30739936e-01f, 5.53408749e-02f, 1.25933856e-01f, -1.02195598e-01f, -9.23339948e-02f,
  2.15405505e-02f, 5.21008670e-02f, 1.94243655e-01f, -1.72106698e-01f, -1.18372992e-01f, 5.53444959e-02f, -1.05436714e-02f, -1.94649711e-01f, -8.52001011e-02f, 1.04385644e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.29372561e-01f, 1.67968169e-01f, 9.93469954e-02f, 9.25945640e-02f, 1.28252923e-01f, 2.84045815e-01f, 1.46553442e-01f, 2.47942477e-01f, 1.06104732e-01f, 4.40061502e-02f,
  1.30956739e-01f, 1.33837670e-01f, 9.57729854e-03f, 2.35781997e-01f, 5.54559864e-02f, -6.30663857e-02f, -4.84895557e-02f, 3.01283121e-01f, -2.02316195e-01f, 1.10777058e-01f,
  -8.88656676e-02f, 3.12491804e-01f, 1.72316477e-01f, 1.62774980e-01f, -3.33847046e-01f, 6.97366297e-02f, 3.13513391e-02f, 7.43582696e-02f, -2.05544248e-01f, 5.97422183e-01f,
  -2.07044203e-02f, -2.10198805e-01f, 2.02204496e-01f, 1.25917122e-01f, -2.37717763e-01f, 3.86409946e-02f, -1.17706388e-01f, -4.54227775e-01f, 7.34780170e-03f, -2.87013680e-01f,
  8.23259428e-02f, -2.89186686e-01f, -3.86052728e-02f, -3.41036916e-01f, 2.65386671e-01f, 3.38371247e-01f, -1.23512380e-01f, -5.54919131e-02f, 2.00589687e-01f, 1.93634883e-01f,
  -1.63563684e-01f, -1.11511387e-01f, -7.52117932e-02f, 2.85812579e-02f, 5.04734367e-02f, -1.46108225e-01f, -3.40881765e-01f, 4.67899472e-01f, -1.15509760e-02f, -1.93405058e-02f,
  -7.59883672e-02f, 3.51172239e-01f, -1.51356637e-01f, -3.43807563e-02f, 1.65322259e-01f, 2.35703439e-01f, -3.92035767e-02f, 9.54029933e-02f, -4.67391759e-02f, -3.19167256e-01f,
  2.81382710e-01f, 1.55673623e-01f, 3.39825004e-01f, -8.48337309e-04f, -1.06635258e-01f, -4.90402803e-02f, 1.61501355e-02f, 6.85585439e-02f, 7.14537725e-02f, 6.23130724e-02f,
  5.27708381e-02f, 3.22430730e-02f, 2.67636538e-01f, 9.38526541e-02f, 2.69016288e-02f, 7.12072551e-02f, -1.56858161e-01f, 4.15762551e-02f, 2.66742297e-02f, -1.35415331e-01f,
  -7.62294158e-02f, 1.93169281e-01f, 3.70847106e-01f, -1.25125110e-01f, 2.91093767e-01f, 2.19847187e-01f, 2.96312314e-03f, -1.95026815e-01f, 3.66246998e-02f, 5.50964177e-01f,
  2.93328371e-02f, 1.88468128e-01f, 1.97507516e-01f, -1.56914338e-01f, 1.26159653e-01f, -1.62576005e-01f, 7.51782134e-02f, 1.26464859e-01f, 2.67056048e-01f, -2.07071230e-01f,
  5.61288111e-02f, -6.58579245e-02f, 3.13370913e-01f, 1.03792936e-01f, -3.27898562e-02f, 2.99808413e-01f, -3.71339440e-01f, 2.97121227e-01f, -3.03915888e-01f, 3.39524716e-01f,
  -1.46868303e-02f, 3.32760029e-02f, -3.32725137e-01f, 7.15140253e-02f, 1.00655571e-01f, -2.13155910e-01f, -7.88970105e-03f, -1.28019601e-01f, 1.18388914e-01f, 7.80180246e-02f,
  2.10444942e-01f, 2.99542904e-01f, 7.52829909e-02f, 2.93707810e-02f, 5.36255121e-01f, 9.25362557e-02f, 2.63056934e-01f, -1.34089701e-02f, 2.42517993e-01f, 1.83378920e-01f,
  1.39626130e-01f, -8.49459171e-02f, 4.21149701e-01f, 1.08041167e-02f, 7.88742080e-02f, 3.59206013e-02f, 3.11392635e-01f, 2.15248793e-01f, -4.23808992e-02f, 9.35650915e-02f,
  1.55765098e-02f, -3.90208103e-02f, 6.65571466e-02f, 1.35266393e-01f, -7.55752474e-02f, 1.05349749e-01f, -2.45986819e-01f, -2.34159887e-01f, -4.44944590e-01f, 1.34324148e-01f,
  -1.14174463e-01f, 3.15856099e-01f, -1.34021088e-01f, -2.16907471e-01f, -1.76212303e-02f, -1.54037729e-01f, 5.44452760e-03f, 1.48760140e-01f, -3.50877106e-01f, -3.25458556e-01f,
  1.19385615e-01f, 1.78634644e-01f, -5.75231314e-02f, -1.25299498e-01f, 2.60580748e-01f, -2.45804891e-01f, -3.05282235e-01f, -2.39736751e-01f, 9.28514153e-02f, 2.43901134e-01f,
  -2.75726557e-01f, -1.34955302e-01f, 9.91368368e-02f, 1.60957202e-01f, -3.72804864e-03f, -1.69294193e-01f, 1.14117414e-01f, -3.81541759e-01f, 1.38256580e-01f, 2.01748669e-01f,
  -1.70262545e-01f, -7.40820095e-02f, 1.89102173e-01f, 2.47571573e-01f, 1.33113623e-01f, 1.36801023e-02f, -3.56523007e-01f, 4.65979278e-02f, -1.58992395e-01f, 1.93410069e-01f,
  5.24517186e-02f, 1.77283615e-01f, 3.73745449e-02f, -3.78726646e-02f, -2.11792588e-01f, 1.18435957e-01f, -5.61529212e-02f, 2.12362185e-02f, -1.24939792e-01f, 8.69096145e-02f,
  9.88835022e-02f, -6.39058053e-02f, -2.41387025e-01f, -1.30634534e-03f, 6.26403987e-02f, 3.63237672e-02f, 5.42806424e-02f, 1.37066752e-01f, 2.70964831e-01f, 5.88166229e-02f,
  2.89499108e-02f, -2.89516509e-01f, -1.38939083e-01f, 4.57890898e-01f, -2.00144872e-01f, -3.14612955e-01f, -3.94775271e-01f, 1.27544463e-01f, -9.01554711e-03f, 1.43582723e-03f,
  5.94381392e-02f, 1.90550685e-01f, -5.14405854e-02f, 4.71130833e-02f, 4.69507843e-01f, 1.66245997e-01f, 5.94420061e-02f, -4.80813831e-02f, -7.12290257e-02f, -2.08385676e-01f,
  -7.96949193e-02f, -2.07337558e-01f, 3.52289230e-01f, 2.42423415e-01f, 8.62563029e-02f, 4.24672365e-02f, -3.34097333e-02f, 2.22600460e-01f, -4.52471413e-02f, -4.60559279e-01f,
  -1.03365615e-01f, 2.43725449e-01f, 2.27831349e-01f, -7.70282224e-02f, -3.78298879e-01f, -2.93436855e-01f, -6.81497157e-02f, 6.82363063e-02f, 6.49799109e-02f, -6.91132471e-02f,
  -1.93589464e-01f, 1.98514879e-01f, -3.80428135e-01f, 3.11552286e-01f, 1.04880810e-01f, 1.01094274e-02f, -3.34672667e-02f, 2.90200356e-02f, -9.62504819e-02f, 2.15679601e-01f,
  -1.01701878e-01f, 1.67807285e-02f, -2.34862193e-01f, 1.24233902e-01f, 1.47811681e-01f, 9.17447433e-02f, 2.45536241e-04f, 1.32644609e-01f, 1.39315880e-03f, -4.52526473e-02f,
  2.04411224e-02f, -9.69484728e-03f, 3.37764859e-01f, -1.90395996e-01f, 1.86971515e-01f, -2.59916902e-01f, -1.55434564e-01f, 3.98440838e-01f, -1.60495147e-01f, -1.81460410e-01f,
  -4.26715970e-01f, 2.00279072e-01f, -1.79388404e-01f, 1.74445748e-01f, 1.01382680e-01f, 3.79767686e-01f, 7.64896050e-02f, -4.95368789e-04f, 4.19338226e-01f, 1.08717315e-01f,
  -1.56888083e-01f, 6.52771071e-02f, -3.59934092e-01f, -2.21128568e-01f, 2.38780528e-01f, 1.84504613e-02f, 4.47206229e-01f, 1.66651472e-01f, -3.85613777e-02f, -9.12342519e-02f,
  5.13091199e-02f, 1.76066145e-01f, -1.16977334e-01f, -4.40295160e-01f, -1.60900861e-01f, 2.30744660e-01f, 3.69756609e-01f, -3.91226001e-02f, -2.56132573e-01f, -2.74965048e-01f,
  6.72865435e-02f, 4.38864022e-01f, 9.69657302e-02f, 1.68563992e-01f, -7.89121836e-02f, 2.05407608e-02f, 3.27763468e-01f, 2.66984224e-01f, 3.03936601e-01f, 5.01639433e-02f,
  7.05100447e-02f, 1.80516422e-01f, -4.17932943e-02f, 3.45643423e-02f, 1.03038989e-01f, 2.32350945e-01f, 4.46725711e-02f, 2.54227370e-01f, 1.04865588e-01f, 1.44438848e-01f,
  -1.14193626e-01f, 3.77899557e-01f, -4.11233865e-02f, -3.43632810e-02f, 9.24937874e-02f, 4.06126902e-02f, 5.20243980e-02f, 1.37017965e-01f, 8.27384964e-02f, 7.28792772e-02f,
  -7.92497918e-02f, 1.19360797e-01f, 2.06740737e-01f, 9.33245271e-02f, -1.66065469e-01f, -2.54881959e-02f, 8.49723071e-02f, -4.99126539e-02f, 2.44180873e-01f, -1.99841052e-01f,
  9.89459455e-02f, -2.15067819e-01f, 2.21491486e-01f, 1.23782113e-01f, 3.11194658e-01f, -4.77055833e-02f, 1.27062336e-01f, -2.03774214e-01f, -4.23302688e-02f, 7.45608062e-02f,
  -1.91178620e-02f, 3.30005407e-01f, -3.19268495e-01f, 2.38188654e-01f, -1.06744282e-01f, 2.82181591e-01f, -9.52761844e-02f, 1.36609942e-01f, -1.01210460e-01f, -7.03040436e-02f,
  1.93120480e-01f, 1.42732069e-01f, -3.72942746e-01f, -7.86644444e-02f, -3.17824662e-01f, 2.99376138e-02f, -5.98897263e-02f, 2.52665848e-01f, 2.91827321e-01f, -1.34734899e-01f,
  2.50630021e-01f, 9.85864177e-02f, 2.68491525e-02f, 7.42118582e-02f, 9.49429646e-02f, -3.58555429e-02f, 3.26658599e-02f, 1.35093808e-01f, 1.94676369e-01f, 5.52240089e-02f,
  -1.13715502e-02f, -1.49297323e-02f, 1.70139998e-01f, 1.84158862e-01f, 1.72416016e-01f, -2.97788799e-01f, -4.31176759e-02f, -6.15273304e-02f, 2.30249256e-01f, 1.08363390e-01f,
  1.86962232e-01f, -2.04504535e-01f, -5.26960827e-02f, 7.75353909e-02f, -1.57233730e-01f, 7.79517591e-02f, -4.58974987e-01f, 3.45226914e-01f, 3.61356921e-02f, -2.99345702e-01f,
  -1.92934364e-01f, -8.49375427e-02f, -1.53708696e-01f, 1.01070300e-01f, -2.58422345e-01f, -2.51115933e-02f, -1.34200498e-01f, -3.35978299e-01f, -1.72735721e-01f, -6.30129725e-02f,
  7.77487978e-02f, -2.52592593e-01f, -1.40738443e-01f, -2.10084766e-01f, 4.50321585e-02f, -1.66913569e-02f, 1.31382912e-01f, -3.90683189e-02f, 8.91010612e-02f, 7.87432268e-02f,
  2.79687680e-02f, -2.50572115e-01f, 1.93630263e-01f, -1.12929352e-01f, 2.20045403e-01f, 1.70740455e-01f, 1.70871079e-01f, -3.02697986e-01f, 7.08752573e-02f, -3.42589580e-02f,
  9.76796746e-02f, -8.70701522e-02f, 2.11576939e-01f, 7.53640085e-02f, 2.27958746e-02f, -1.21387225e-02f, -2.64083415e-01f, -7.33927116e-02f, -1.82212830e-01f, -1.37982115e-01f,
  1.68735102e-01f, 2.49534190e-01f, -1.32813811e-01f, 2.23779276e-01f, 9.23039988e-02f, -1.73464301e-03f, 9.32875723e-02f, 7.96161741e-02f, 1.32098034e-01f, 2.71144211e-01f,
  -5.58425859e-03f, 1.75178856e-01f, 3.70034985e-02f, 2.01574594e-01f, 1.78934075e-02f, -2.21098274e-01f, 1.82837307e-01f, -7.68997753e-03f, 9.90852788e-02f, 1.71804994e-01f,
  -3.45256716e-01f, 1.30565045e-02f, 5.34797087e-02f, -3.01847696e-01f, -3.17373693e-01f, -2.01136425e-01f, -4.64288026e-01f, -1.29072919e-01f, 1.97892915e-02f, 7.23817647e-02f,
  -1.98005453e-01f, -5.82081564e-02f, -7.66241178e-02f, 1.68604776e-01f, 2.21009314e-01f, 9.39084291e-02f, -2.67725646e-01f, 7.15535879e-02f, -2.85908878e-02f, -1.67722091e-01f,
  3.60426009e-01f, 1.99616075e-01f, 1.60574675e-01f, -1.39070705e-01f, 1.46661356e-01f, -8.34176317e-02f, 8.88452008e-02f, 2.00519755e-01f, 2.65617102e-01f, 3.24149698e-01f,
  1.74704492e-01f, -1.89608529e-01f, 2.53231432e-02f, 1.73130274e-01f, -2.66471565e-01f, 2.30728388e-01f, 2.07063451e-01f, -5.85920550e-02f, 8.68901089e-02f, -1.28436998e-01f,
  7.69149438e-02f, 1.58960879e-01f, -2.71170922e-02f, -6.08640909e-02f, -1.84862912e-01f, 2.09083825e-01f, 1.34135559e-01f, 5.25580682e-02f, 6.65607080e-02f, 8.66660029e-02f,
  2.32391149e-01f, 1.19249582e-01f, 5.83211891e-02f, -1.85960710e-01f, -2.27445383e-02f, -5.30392490e-02f, 1.89297020e-01f, 2.94849634e-01f, 3.18342060e-01f, -1.51421651e-01f,
  6.89109489e-02f, -1.60705134e-01f, 2.12196529e-01f, -7.73965567e-02f, -4.64810610e-01f, 7.88299888e-02f, 3.85164887e-01f, -1.30422875e-01f, -4.19868261e-01f, 2.78382719e-01f,
  4.35300805e-02f, 1.69510305e-01f, -1.55146569e-01f, 1.83621854e-01f, -3.15868668e-02f, -1.48381600e-02f, -3.75226587e-02f, 1.35061279e-01f, -4.89778340e-01f, -2.81072825e-01f,
  2.84296423e-01f, -3.78965944e-01f, 4.91527580e-02f, -1.20952204e-01f, 1.27187753e-02f, -3.15265715e-01f, 3.16206664e-01f, -1.43868346e-02f, 2.69156247e-01f, 2.89346930e-02f,
  1.67262048e-01f, 9.37106684e-02f, 1.24379598e-01f, 2.13905275e-01f, 3.45143884e-01f, -1.89948499e-01f, 1.11284116e-02f, 6.30070046e-02f, -1.41469827e-02f, 1.76785335e-01f,
  4.80808951e-02f, 4.49762642e-02f, -7.67954737e-02f, -2.87209421e-01f, -1.77521706e-02f, 1.13818623e-01f, 4.05350141e-03f, 9.70028117e-02f, 1.18514411e-01f, -1.64409801e-01f,
  7.53610432e-02f, -1.62742540e-01f, 1.82534717e-02f, 2.09857747e-01f, 2.15347230e-01f, 6.40473738e-02f, 2.78527271e-02f, -6.83695227e-02f, -3.15034799e-02f, 8.84825960e-02f,
  -1.06977001e-02f, -1.59586728e-01f, -1.02757826e-01f, 5.36298752e-02f, -5.89660509e-03f, 1.97489634e-01f, 2.51740098e-01f, 2.43945122e-02f, 2.09825821e-02f, 5.52994832e-02f,
  -2.16146737e-01f, 1.92141935e-01f, -5.29991239e-02f, 2.36963481e-01f, 4.60444018e-03f, -5.82032762e-02f, 2.03895241e-01f, -9.42948163e-02f, -5.17011024e-02f, -9.75788608e-02f,
  1.24886498e-01f, 7.53649250e-02f, -1.74471706e-01f, 3.30273062e-02f, 1.58388734e-01f, 1.79223806e-01f, -2.70705134e-01f, 1.92963824e-01f, 7.00091291e-03f, -3.22189555e-02f,
  -1.84641913e-01f, 9.30701718e-02f, 4.74796817e-02f, -1.01185717e-01f, -3.15245464e-02f, 3.70816052e-01f, 4.80792895e-02f, -2.42117465e-01f, -2.12285802e-01f, 2.12850004e-01f,
  -4.23529185e-02f, 1.29988953e-01f, 2.01115638e-01f, 8.67013354e-03f, -2.32766077e-01f, 5.06247161e-03f, 5.57462089e-02f, -1.36128187e-01f, -2.64985800e-01f, -1.20923340e-01f,
  2.49873474e-01f, 1.07887946e-01f, -1.54163718e-01f, -1.94271192e-01f, 2.66099591e-02f, -2.01991741e-02f, 2.67197639e-01f, -5.50697111e-02f, 9.02055502e-02f, 1.69644821e-02f,
  8.74382406e-02f, -6.71705082e-02f, 1.03802860e-01f, -6.39583915e-02f, 3.47941995e-01f, 7.14073479e-02f, -1.86666340e-01f, -1.75401583e-01f, 3.16867381e-02f, -1.60457313e-01f,
  6.35738745e-02f, 2.24456936e-01f, 1.74466819e-01f, 1.07312910e-01f, 2.76433766e-01f, -8.09277892e-02f, 2.36454561e-01f, 9.06899124e-02f, 4.87042785e-01f, -3.49934310e-01f,
  -5.97253554e-02f, -1.60592705e-01f, 2.99144536e-02f, 3.19286048e-01f, -1.42979696e-01f, -2.22411320e-01f, 1.22104384e-01f, -9.80657265e-02f, -1.82975754e-01f, -2.71936625e-01f,
  -1.22982664e-02f, 1.04338221e-01f, 1.06881103e-02f, 1.84157789e-01f, 4.78178710e-02f, -6.99620768e-02f, 4.68789011e-01f, 1.92911431e-01f, 1.26389787e-01f, -1.10251635e-01f,
  -3.34115922e-01f, -8.23175162e-02f, 6.56764656e-02f, 1.60949990e-01f, 2.70180553e-01f, 1.61596999e-01f, 1.51184499e-01f, 2.04729289e-01f, -1.52427197e-01f, 4.53338772e-02f,
  5.60776927e-02f, -4.44407901e-03f, -1.57670990e-01f, -8.37358385e-02f, 2.69172817e-01f, 1.95726857e-01f, 5.50573990e-02f, -5.07503524e-02f, 1.06460616e-01f, 1.02505438e-01f,
  -2.13064216e-02f, 1.14177383e-01f, 6.63800761e-02f, 6.27812743e-02f, 4.81416397e-02f, -3.66945751e-02f, 5.65661341e-02f, 1.80809692e-01f, 3.18492919e-01f, 5.82934767e-02f,
  -6.76668435e-02f, 4.92308140e-02f, 5.58957122e-02f, -2.14274675e-02f, 1.50166526e-01f, 2.30983734e-01f, 1.85503498e-01f, 1.39589116e-01f, 3.34458947e-01f, 7.92825446e-02f,
  3.00992608e-01f, 2.67413735e-01f, 5.00242949e-01f, -4.10189211e-01f, 2.05533862e-01f, -2.73940593e-01f, -2.36012995e-01f, 3.85869682e-01f, 6.34445399e-02f, -1.57431781e-01f,
  2.96966136e-01f, 2.03895904e-02f, -1.41161680e-01f, 2.28598602e-02f, 9.01151448e-02f, 1.57260239e-01f, 3.83738428e-02f, 2.23636329e-01f, -2.92849720e-01f, 2.32546449e-01f,
  1.47576883e-01f, -4.99353465e-03f, 4.59267907e-02f, 1.33662924e-01f, -1.94539040e-01f, -5.86836189e-02f, -6.54695630e-02f, -8.45187064e-03f, 3.19207579e-01f, 3.35981101e-02f,
  6.42944798e-02f, 2.71674991e-01f, -5.64629994e-02f, 2.07675412e-01f, -1.48910042e-02f, 1.09237880e-01f, -1.58542395e-02f, 5.16778678e-02f, 3.12079996e-01f, 1.95120305e-01f,
  -2.16470473e-02f, 2.30694711e-02f, 1.81672990e-01f, 9.64207947e-02f, -2.36069597e-02f, -1.89427156e-02f, 2.79341877e-01f, 4.32333238e-02f, 6.03002235e-02f, 4.61139828e-02f,
  5.80872968e-02f, 2.55615935e-02f, 2.08960861e-01f, 7.81456530e-02f, 3.51394676e-02f, 1.69109970e-01f, 2.46908367e-01f, -2.30233595e-01f, 2.90771611e-02f, 7.59408027e-02f,
  2.69842207e-01f, -7.68606260e-05f, 2.13749662e-01f, 2.45245367e-01f, 2.97944278e-01f, 3.86227280e-01f, 5.95375657e-01f, -1.21026784e-01f, 2.49792099e-01f, -1.42885476e-01f,
  1.75305769e-01f, 5.15840769e-01f, 2.30111614e-01f, -1.75973445e-01f, 3.43867272e-01f, 1.33769646e-01f, -4.48459722e-02f, 1.74209476e-01f, 1.33668557e-01f, 2.95429915e-01f,
  -1.15175299e-01f, 3.86853591e-02f, -4.35206920e-01f, 3.16491663e-01f, 1.28146946e-01f, -5.77684008e-02f, -2.14436039e-01f, 6.88844323e-02f, -6.18150197e-02f, -3.25604826e-01f,
  -2.81380296e-01f, 1.29486606e-01f, -2.42482536e-02f, 2.88709074e-01f, -3.99579778e-02f, 2.26655334e-01f, -7.29252249e-02f, -6.24721944e-02f, 3.80810231e-01f, 1.47606686e-01f,
  2.24969536e-01f, 2.26437673e-01f, 1.98180094e-01f, 2.56305933e-01f, -1.34655582e-02f, -1.57738221e-03f, 3.45659614e-01f, 1.18668906e-01f, 1.81531325e-01f, 2.80753434e-01f,
  2.24811465e-01f, 2.19250783e-01f, 1.90929491e-02f, -6.85169473e-02f, 8.45183954e-02f, 1.01436019e-01f, 1.72574371e-02f, 1.42140448e-01f, 1.18348874e-01f, -2.68814772e-01f,
  -1.51472658e-01f, -1.04105912e-01f, -2.11463973e-01f, -1.16101280e-02f, -2.72855293e-02f, 3.40930641e-01f, 1.09198086e-01f, -8.08746740e-03f, 1.67004745e-02f, 6.76618740e-02f,
  1.16327152e-01f, 3.19655240e-01f, -1.50517389e-01f, -1.29086554e-01f, -2.53879428e-01f, -4.38237749e-02f, 1.04708694e-01f, -2.11649612e-01f, 9.35856700e-02f, -2.49781683e-01f,
  3.54794562e-02f, -9.17878374e-02f, 1.02528758e-01f, 3.42435651e-02f, -5.06018847e-03f, -3.72934282e-01f, 1.75102159e-01f, 2.30098471e-01f, 3.41063552e-02f, 7.56446049e-02f,
  -9.56127271e-02f, -8.09934586e-02f, 7.80590698e-02f, 1.54955328e-01f, -9.59803909e-02f, -1.45400897e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -5.19137383e-02f, 2.08966583e-02f, 1.86764136e-01f, -6.15094602e-02f, -3.70387323e-02f, 2.44719207e-01f, -3.99075355e-03f, -3.26702408e-02f, 1.85574651e-01f, 1.41963795e-01f,
  7.04642683e-02f, 4.74438816e-02f, 1.45437300e-01f, 4.31859009e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -7.38233104e-02f, 1.94515407e-01f, 8.34702048e-04f, 5.21276779e-02f, 5.78508042e-02f, -1.07943788e-01f, 5.06712571e-02f, -1.15012582e-02f, -1.39046699e-01f, -3.31687778e-02f,
  8.11997503e-02f, 2.07120284e-01f, -1.79581624e-02f, -3.18250470e-02f, 1.47619456e-01f, 1.52463496e-01f, 3.54248248e-02f, 9.72740725e-02f, -5.91849349e-02f, 2.56138574e-02f,
  1.42801955e-01f, -1.49075568e-01f, -1.72853321e-02f, 4.31879945e-02f, 3.01842447e-02f, 2.22606212e-01f, 1.20658696e-01f, -7.72637352e-02f, 5.06334826e-02f, 7.27689941e-04f,
  -1.11335047e-01f, -2.46345267e-01f, -1.74705535e-01f, 1.37486041e-01f, -1.56013101e-01f, -1.29903749e-01f, 2.36312255e-01f, 8.68038461e-02f, -6.13823943e-02f, -4.92414571e-02f,
  1.34246480e-02f, -1.48598000e-01f, -8.84858239e-03f, 8.44911709e-02f, -1.37389868e-01f, -7.34301731e-02f, -8.10803324e-02f, -1.45396292e-01f, 1.11344181e-01f, 7.91079476e-02f,
  3.61137986e-01f, 1.51399627e-01f, 2.12465942e-01f, -1.30780470e-02f, -1.36606365e-01f, 1.64053485e-01f, 1.05887614e-01f, -6.74731433e-02f, -3.07484984e-01f, -1.48999199e-01f,
  -1.97515681e-01f, 3.29709873e-02f, -7.87919834e-02f, 2.50417471e-01f, 9.46832672e-02f, -9.83451083e-02f, -7.16386586e-02f, -2.67575443e-01f, 8.32212567e-02f, 7.72878304e-02f,
  6.30633160e-02f, 1.05054155e-01f, -2.44041122e-02f, -9.24559683e-03f, 1.02400400e-01f, -8.27220529e-02f, -2.33413260e-02f, 1.99075669e-01f, 1.27110258e-01f, -1.04210570e-01f,
  -1.71920031e-01f, 8.23330358e-02f, 4.97499947e-03f, -9.43931565e-02f, 6.92795515e-02f, -8.63220543e-02f, -1.27646044e-01f, 2.10310161e-01f, -3.07352394e-01f, 3.10700566e-01f,
  2.54315913e-01f, 9.02864244e-03f, 8.40261281e-02f, -1.63090862e-02f, 5.47622070e-02f, 1.19845152e-01f, -1.42047107e-01f, 7.65838549e-02f, -1.99863277e-02f, -1.40309304e-01f,
  -2.96509594e-01f, 2.65624791e-01f, -5.08992933e-02f, -2.51199454e-01f, 1.17465429e-01f, 1.29284292e-01f, 1.36938736e-01f, -1.02653332e-01f, -8.90466720e-02f, -2.90864974e-01f,
  -2.60949582e-01f, 7.64517263e-02f, -3.64119373e-02f, 2.54673678e-02f, -1.76992983e-01f, -5.10514937e-02f, 2.59183913e-01f, 1.89374194e-01f, 9.22005549e-02f, -1.38167478e-02f,
  -2.56805439e-02f, -1.22095406e-01f, 1.60836145e-01f, -2.34036688e-02f, 1.59329146e-01f, 5.38879596e-02f, 1.09108068e-01f, 2.23506927e-01f, -1.68236807e-01f, -4.32072431e-02f,
  6.66046422e-03f, -9.74674746e-02f, 5.81767410e-02f, -8.26565623e-02f, 8.24809521e-02f, -2.93778479e-01f, 1.86906867e-02f, 1.17943019e-01f, -7.63213187e-02f, 8.77974927e-02f,
  1.14349082e-01f, 1.44909665e-01f, 2.85449624e-02f, -3.39566520e-03f, -8.11542273e-02f, 1.28925025e-01f, 6.47218898e-02f, 1.71844378e-01f, -2.05894988e-02f, -1.01071306e-01f,
  -9.53147113e-02f, -5.68731204e-02f, 1.52528966e-02f, 1.12543534e-02f, -2.37816393e-01f, -9.43767130e-02f, 1.83553487e-01f, -3.37854698e-02f, -8.05522427e-02f, -3.40101212e-01f,
  2.36012310e-01f, 3.86174470e-02f, -2.38014549e-01f, -6.49830028e-02f, -2.26663902e-01f, -3.22003931e-01f, 1.07151873e-01f, -6.81540817e-02f, -1.93557486e-01f, -1.51345804e-01f,
  -1.26487181e-01f, -1.09460846e-01f, 2.58270502e-01f, -9.14538354e-02f, 2.79488713e-01f, 9.90003720e-02f, -2.23276600e-01f, 9.28815007e-02f, 2.96544395e-02f, 1.69447988e-01f,
  -1.54371813e-01f, -2.21150368e-01f, -2.24395826e-01f, 8.49541500e-02f, -1.46151885e-01f, 1.15347996e-01f, 2.45704219e-01f, -5.85408621e-02f, 1.88697383e-01f, 1.90193668e-01f,
  1.15665182e-01f, 1.46202162e-01f, -9.70751420e-02f, 6.42224997e-02f, -1.30598813e-01f, -2.65611202e-01f, 6.65038452e-02f, -1.18255094e-01f, 2.06111260e-02f, -1.22202411e-01f,
  5.01856506e-02f, -2.00054467e-01f, -6.76826686e-02f, -6.87594935e-02f, 1.23119857e-02f, -2.61777848e-01f, -2.69386247e-02f, 4.07763571e-02f, -3.01701482e-02f, -2.80475050e-01f,
  -9.94153768e-02f, 2.93048564e-03f, -7.51955733e-02f, 9.50852856e-02f, -8.22348520e-03f, -5.60412295e-02f, -8.50552469e-02f, 4.63280156e-02f, -2.38329232e-01f, 2.89734770e-02f,
  -2.26687521e-01f, 2.44948447e-01f, -5.83297387e-02f, -7.06339628e-02f, 1.59969404e-01f, -5.17666452e-02f, -1.55057311e-01f, -2.04998493e-01f, 1.41265213e-01f, -3.75633061e-01f,
  -4.48932312e-02f, -2.52328962e-01f, -1.60714045e-01f, 9.46469530e-02f, 8.44463531e-04f, -2.40280963e-02f, 7.03687593e-02f, 1.45438120e-01f, 1.68913305e-01f, -5.67469373e-02f,
  8.54282975e-02f, 1.99261844e-01f, -3.10828332e-02f, 8.73547867e-02f, -1.52077481e-01f, 6.82851449e-02f, -1.47503670e-02f, 1.89921081e-01f, -6.29182160e-02f, 1.23635791e-01f,
  -2.09913328e-01f, 1.35428876e-01f, 1.43619254e-01f, 1.21942177e-01f, 1.18429221e-01f, -4.34051342e-02f, -1.04741357e-01f, 1.91614732e-01f, 1.61520123e-01f, 2.24785551e-01f,
  -6.12638555e-02f, 8.57455730e-02f, -2.66270582e-02f, 3.43505204e-01f, -1.15941510e-01f, 1.45175129e-01f, -7.29672387e-02f, 1.15832917e-01f, 3.93214636e-02f, 2.33657181e-01f,
  -5.88689521e-02f, 1.35589391e-02f, -9.00585800e-02f, 1.56444222e-01f, 6.41003922e-02f, -1.13165438e-01f, 3.73781808e-02f, -3.70990001e-02f, -1.20642737e-01f, -1.27631217e-01f,
  -4.92761806e-02f, 1.24015575e-02f, -9.40516889e-02f, -8.33235011e-02f, 1.07806973e-01f, -1.67228281e-01f, 2.03557730e-01f, 8.12914036e-03f, -6.87854961e-02f, 2.72762477e-02f,
  -3.80165987e-02f, 2.24444151e-01f, 1.81463789e-02f, 3.68130386e-01f, 2.84372032e-01f, -1.55137271e-01f, 5.38162068e-02f, 2.49961670e-02f, -9.37263072e-02f, 2.64659494e-01f,
  -1.48240775e-01f, -2.34725580e-01f, 2.79426053e-02f, -3.62387210e-01f, 1.07252479e-01f, -2.45573698e-03f, 2.11288631e-01f, -7.03041852e-02f, 9.97933522e-02f, -8.38048682e-02f,
  -1.74746767e-01f, 5.89893684e-02f, -1.02722339e-01f, 1.47982925e-01f, -3.15042853e-01f, -2.14904845e-01f, -1.15017931e-03f, 7.77136311e-02f, -9.37629417e-02f, 8.83211195e-02f,
  7.51510561e-02f, 6.47087768e-03f, 1.41852528e-01f, 1.69258505e-01f, -1.66820157e-02f, -1.19543999e-01f, -3.82117252e-03f, -1.15428701e-01f, 1.53592736e-01f, 1.65032014e-01f,
  -1.58156350e-01f, 1.13531545e-01f, 1.04450257e-02f, -2.00447902e-01f, 1.00525059e-01f, -2.21408121e-02f, 1.09132223e-01f, -1.96764186e-01f, 7.41178468e-02f, 7.27332234e-02f,
  1.44454494e-01f, -7.83880353e-02f, 7.78005496e-02f, -1.99622456e-02f, 2.02476859e-01f, -9.14717019e-02f, -5.70342578e-02f, -3.05230290e-01f, -1.51006162e-01f, 2.11320389e-02f,
  3.16027296e-03f, 8.50311294e-03f, -4.64167930e-02f, 2.10820794e-01f, -2.24506438e-01f, 1.00082986e-01f, 4.36415792e-01f, -2.33681098e-01f, 2.17854585e-02f, 1.88708290e-01f,
  -1.49239674e-01f, 8.30331743e-02f, 5.49733378e-02f, 1.91263974e-01f, 1.84814587e-01f, 3.03445365e-02f, 1.24495752e-01f, 1.11814789e-01f, 3.30170542e-01f, 1.08284527e-03f,
  2.39293844e-01f, 1.11736357e-02f, 5.62043302e-02f, 2.15350240e-01f, 1.04406893e-01f, 1.01612218e-01f, -1.30219176e-01f, 2.49311365e-02f, -1.79679126e-01f, -4.84060496e-02f,
  -2.00237900e-01f, 9.87682417e-02f, -3.21580097e-02f, -3.87868881e-02f, 8.99295881e-02f, 9.12954584e-02f, -8.25326592e-02f, -1.51830520e-02f, 3.74847613e-02f, -8.00304860e-02f,
  1.82383731e-01f, -5.64823709e-02f, -1.72195837e-01f, 9.93439853e-02f, -1.02159075e-01f, 5.93216419e-02f, -8.55831131e-02f, 1.07510783e-01f, 2.07153678e-01f, 9.95343924e-02f,
  8.22647884e-02f, 1.61427408e-01f, -3.46542783e-02f, 1.62900671e-01f, -1.78981926e-02f, 4.01027836e-02f, -1.84523746e-01f, 1.37231454e-01f, -8.76130685e-02f, 2.64468670e-01f,
  -7.39710554e-02f, -1.44149512e-01f, 2.02540174e-01f, -9.62124169e-02f, -2.05082923e-01f, -2.58738965e-01f, 1.04308330e-01f, 2.82192439e-01f, -2.57936925e-01f, -1.39983207e-01f,
  -1.55699089e-01f, -1.19068600e-01f, 5.21035679e-02f, -2.51626194e-01f, -2.46841654e-01f, 1.95473686e-01f, -2.43674070e-01f, -2.30558097e-01f, -8.73238742e-02f, -2.37093285e-01f,
  1.51321337e-01f, -4.23245914e-02f, -1.68292880e-01f, 3.04433972e-01f, -2.20418319e-01f, 2.09601581e-01f, 6.02128208e-02f, 1.72681268e-02f, 7.32949302e-02f, 5.85249513e-02f,
  -7.66445100e-02f, -1.86001599e-01f, 2.90464729e-01f, 1.04096793e-02f, 3.02116334e-01f, 3.37215625e-02f, 6.09216839e-02f, -5.31109702e-03f, 2.05308706e-01f, -3.66680659e-02f,
  9.27724391e-02f, 1.79033563e-01f, 1.29448399e-01f, -5.12068346e-02f, -4.84534875e-02f, 6.61841407e-02f, 2.84943312e-01f, 1.68729901e-01f, -1.90481860e-02f, -8.10484663e-02f,
  -1.31440878e-01f, -5.05062379e-02f, -1.52893513e-01f, 1.44856367e-02f, -6.73166069e-04f, 3.44561646e-03f, 4.33275625e-02f, 3.49233635e-02f, 1.13726050e-01f, 1.05764270e-01f,
  2.42770880e-01f, 9.19927210e-02f, 1.91106230e-01f, -2.46782005e-02f, -3.51730943e-01f, -1.94808483e-01f, -2.39095464e-01f, -1.45775259e-01f, 2.83685338e-04f, 2.07223818e-02f,
  -1.27523184e-01f, 1.79623768e-01f, -1.58658266e-01f, 1.63194835e-01f, 8.68008807e-02f, -5.48536927e-02f, -4.18217033e-02f, 2.34300315e-01f, -5.23138978e-02f, 3.03348780e-01f,
  -8.94865319e-02f, 9.02805626e-02f, 7.31934309e-02f, 1.89316839e-01f, 4.06049117e-02f, 2.10415363e-01f, 1.37734517e-01f, 2.16493517e-01f, 1.37214333e-01f, -2.32284870e-02f,
  -1.92837361e-02f, 9.78687927e-02f, 8.02400932e-02f, 1.34284645e-01f, -5.88183254e-02f, 3.15540619e-02f, -1.04530104e-01f, 2.92844564e-01f, -5.60717136e-02f, 2.08642427e-02f,
  8.27738568e-02f, -9.35343951e-02f, 3.44089657e-01f, 1.71347678e-01f, 2.17624471e-01f, 1.34182468e-01f, 1.18143596e-01f, 3.25697184e-01f, 1.66471079e-01f, 2.70056725e-01f,
  -7.09006041e-02f, 2.13693708e-01f, -2.71909423e-02f, -1.33026659e-01f, 7.17306882e-02f, 2.88319886e-01f, 4.36069332e-02f, 2.57440299e-01f, 1.48013487e-01f, 2.27496967e-01f,
  1.39617041e-01f, -1.86637156e-02f, -5.97454682e-02f, 9.30963829e-02f, -3.41777988e-02f, 2.99376249e-01f, -5.67347035e-02f, -5.74002378e-02f, -1.36525139e-01f, 9.49185044e-02f,
  4.48668674e-02f, 1.45854177e-02f, -2.33921427e-02f, 2.98112124e-01f, -2.00579405e-01f, 1.10280856e-01f, 7.79913589e-02f, 2.21464112e-01f, -5.67305237e-02f, 4.80909288e-01f,
  1.85036466e-01f, -2.88153253e-03f, 2.57428825e-01f, 1.68220401e-01f, 1.03999320e-02f, -2.22170283e-03f, -3.11568260e-01f, -2.65339892e-02f, -2.13193864e-01f, -1.64311394e-01f,
  -2.67626960e-02f, 1.93122715e-01f, -2.62042545e-02f, -8.69871452e-02f, 1.02703065e-01f, -1.16489291e-01f, -2.49579668e-01f, -1.07931346e-01f, -5.18384390e-02f, -1.84758991e-01f,
  2.54652295e-02f, 1.75193369e-01f, 1.71499953e-01f, -6.96968883e-02f, 6.02922998e-02f, 9.77253262e-03f, -2.76827812e-01f, -1.70671016e-01f, -7.11533874e-02f, -1.02277003e-01f,
  4.29858267e-02f, 3.11188344e-02f, -1.34205058e-01f, -1.18551038e-01f, -8.23738649e-02f, -1.64892554e-01f, 7.77950361e-02f, 1.33837625e-01f, -1.48150162e-03f, -2.34943196e-01f,
  1.19024292e-02f, -1.45866185e-01f, 1.63589255e-03f, -1.74887419e-01f, -8.95177871e-02f, 6.52079508e-02f, -4.03081439e-02f, -1.66965395e-01f, 1.56607434e-01f, -3.32638711e-01f,
  -4.12514843e-02f, -2.32475892e-01f, 1.62311286e-01f, -3.53350975e-02f, 8.87711942e-02f, -3.49662811e-01f, -1.66530028e-01f, 8.51585642e-02f, -1.87485248e-01f, -9.13371705e-03f,
  -1.81764603e-01f, 2.19049871e-01f, 2.50148386e-01f, -1.18959926e-01f, -3.82736474e-01f, 1.18486479e-01f, -1.46259695e-01f, -4.07955656e-03f, 1.30854771e-01f, 3.14634472e-01f,
  8.48062783e-02f, -1.36587366e-01f, 2.58047804e-02f, 1.78429671e-02f, 1.03852332e-01f, -1.43147781e-01f, 2.53979087e-01f, 3.37528065e-02f, -8.25809166e-02f, 1.67814463e-01f,
  1.71089977e-01f, -1.39210880e-01f, 3.54230241e-03f, 1.67794377e-01f, -1.53613433e-01f, -2.30729565e-01f, -5.46815805e-02f, -1.71174020e-01f, -8.54760706e-02f, -9.28127542e-02f,
  -1.75168842e-01f, 7.82840401e-02f, 2.29439050e-01f, -1.26186013e-01f, -3.27099897e-02f, -9.07408521e-02f, 6.78603798e-02f, 4.61359620e-02f, 1.02119848e-01f, -3.52751538e-02f,
  1.14074245e-01f, 3.97891328e-02f, -1.14163850e-02f, -4.44430299e-02f, 7.47964233e-02f, -1.10379234e-01f, -1.97448701e-01f, 5.85348271e-02f, -5.00503369e-02f, 3.40091325e-02f,
  1.91229507e-01f, 3.72833712e-03f, 2.70396203e-01f, 9.42409858e-02f, -1.58454254e-01f, -1.35350868e-01f, 3.07846397e-01f, -3.22242528e-02f, 2.06966549e-01f, -2.76364952e-01f,
  1.38560802e-01f, 2.56573290e-01f, -2.46742785e-01f, -2.61173487e-01f, -4.07867208e-02f, 1.34044468e-01f, -2.78720576e-02f, 1.30115584e-01f, 1.73436418e-01f, 1.77176878e-01f,
  -9.17386785e-02f, 1.07426338e-01f, 3.54251087e-01f, -6.45333230e-02f, 1.34088606e-01f, -3.67686227e-02f, -6.69722855e-02f, 2.23999128e-01f, 7.62951672e-02f, 9.48941186e-02f,
  -8.85962546e-02f, -1.43891141e-01f, -5.66598028e-02f, 3.40789706e-02f, 2.53472537e-01f, -2.24153519e-01f, 1.07233636e-01f, -6.88502192e-02f, 3.20975408e-02f, 1.28282696e-01f,
  -1.94785401e-01f, -5.40438965e-02f, 2.91500986e-02f, -1.46370381e-02f, 1.22964151e-01f, -7.93855786e-02f, -9.82678458e-02f, 1.33391708e-01f, 1.65221110e-01f, -3.64883617e-02f,
  -3.10739893e-02f, 1.28249004e-01f, -6.66588172e-02f, -4.85936739e-02f, -7.86813796e-02f, 1.10940337e-01f, 1.34488389e-01f, 1.66817059e-04f, 7.61028379e-02f, -1.00204013e-01f,
  -2.50303391e-02f, -5.25610410e-02f, -2.12031975e-02f, 5.87712489e-02f, -1.09099142e-01f, -1.57979187e-02f, 1.72730982e-01f, 8.09505805e-02f, -4.78467755e-02f, 2.97354817e-01f,
  1.48698360e-01f, -7.62186423e-02f, -2.32765768e-02f, 4.62999582e-01f, -8.07747915e-02f, -1.31195807e-03f, -4.23773117e-02f, -1.07940122e-01f, 2.79425204e-01f, -1.82362944e-01f,
  2.19926119e-01f, 1.66812800e-02f, -1.30242910e-02f, -3.34027231e-01f, 7.88900629e-02f, -1.81287870e-01f, -1.24696188e-01f, -9.34540704e-02f, -2.39819184e-01f, -1.46973416e-01f,
  -8.98081958e-02f, -2.34948888e-01f, -1.75493032e-01f, -1.55631527e-01f, 1.71239614e-01f, -9.28487852e-02f, 3.01845651e-02f, 3.46849412e-02f, 6.12666756e-02f, -2.40942854e-02f,
  1.15717761e-01f, -1.49710074e-01f, -5.91554120e-02f, 5.55460900e-02f, -8.76109451e-02f, -2.08388284e-01f, -2.60486662e-01f, 4.69051078e-02f, 1.17373496e-01f, -5.11075463e-03f,
  -9.49255656e-03f, 3.43397975e-01f, 1.68990403e-01f, 8.49632397e-02f, 2.35416785e-01f, 1.49071410e-01f, 9.65084434e-02f, -1.08848803e-01f, -2.06967786e-01f, 3.79657060e-01f,
  1.78303018e-01f, 5.91484308e-02f, -3.64663303e-02f, -1.24959156e-01f, 1.63707867e-01f, 2.34252527e-01f, 8.63580480e-02f, -5.98022379e-02f, 1.90984398e-01f, -9.18108318e-03f,
  2.56270915e-01f, -3.74987125e-02f, -8.78593922e-02f, 1.63779423e-01f, 2.77415384e-02f, -1.40668780e-01f, -7.13171586e-02f, 1.14414647e-01f, -1.18660562e-01f, -1.59572717e-02f,
  -2.67305095e-02f, 4.91082296e-02f, -2.65131076e-03f, -1.54232159e-01f, -1.23237662e-01f, -4.68603894e-02f, -1.18716367e-01f, 1.42742805e-02f, 8.68288875e-02f, 6.69207647e-02f,
  -4.36551869e-02f, -1.43419221e-01f, -2.04470783e-01f, -2.17639759e-01f, 5.69887925e-03f, -2.74158001e-01f, 7.86756575e-02f, 9.94251594e-02f, 1.28102869e-01f, 1.73295468e-01f,
  2.36475319e-01f, -1.83612168e-01f, -1.22306928e-01f, 2.27872521e-01f, 6.92888163e-03f, -5.57471551e-02f, -3.56169827e-02f, 6.40726164e-02f, -5.57155497e-02f, 1.31159663e-01f,
  1.43555596e-01f, 3.14564183e-02f, 6.00009039e-02f, -1.68772683e-01f, 8.94370452e-02f, 2.20107049e-01f, -1.00096967e-02f, 9.86903235e-02f, -4.63823266e-02f, 1.77858636e-01f,
  -3.61350849e-02f, 1.44531414e-01f, 8.53836462e-02f, -1.46119788e-01f, -3.56636532e-02f, 8.27300921e-02f, -3.20901535e-02f, 9.99700371e-03f, -3.57074244e-03f, 2.32697561e-01f,
  -1.77013315e-02f, 1.15139790e-01f, -9.77813676e-02f, 2.13433821e-02f, 5.65880723e-02f, 1.51832476e-02f, 1.04102693e-01f, 2.76546299e-01f, 9.78294853e-03f, 7.42633492e-02f,
  -8.68445635e-02f, 3.99215192e-01f, -3.51721905e-02f, 5.34701869e-02f, -2.18125522e-01f, 6.09837845e-02f, 2.02896461e-01f, -9.90588963e-03f, 1.99303150e-01f, 1.17613211e-01f,
  4.77827229e-02f, -1.25084803e-01f, 2.01264754e-01f, -1.43388763e-01f, -8.87621045e-02f, 1.29832342e-01f, -3.53622556e-01f, 1.08384736e-01f, -6.70966431e-02f, -1.67013437e-01f,
  1.05882064e-01f, -1.10842802e-01f, 1.17505059e-01f, -8.60083774e-02f, 2.68983632e-01f, -1.20876841e-01f, -7.63947070e-02f, 1.06699608e-01f, 2.68710814e-02f, 1.28439432e-02f,
  -1.34794965e-01f, -1.80947393e-01f, -6.79731965e-02f, -6.52817562e-02f, -5.85179357e-03f, 8.96939561e-02f, -8.00843537e-02f, 4.43935134e-02f, 1.55386388e-01f, 6.00380357e-03f,
  -1.48863286e-01f, 4.04258333e-02f, -8.08343198e-03f, 7.49965087e-02f, 1.12693094e-01f, 7.44864121e-02f, -1.20239958e-01f, -9.14241821e-02f, -1.82620212e-01f, -3.63530070e-02f,
  1.07882835e-01f, 2.01425552e-02f, 6.14484362e-02f, 2.29972973e-01f, 1.73563376e-01f, 1.22990415e-01f, 1.62678361e-01f, -4.88398820e-02f, 3.90777700e-02f, 1.61172062e-01f,
  -1.10783987e-03f, 2.07103699e-01f, -2.51546234e-01f, -2.13642776e-01f, -1.02998219e-01f, -2.82233357e-01f, -2.98330747e-02f, -2.99875736e-01f, -7.06538334e-02f, -3.79759520e-02f,
  -1.73530281e-01f, 1.09607235e-01f, -6.74039572e-02f, 7.81346783e-02f, 1.62944973e-01f, 2.41609961e-01f, 1.81508988e-01f, -2.43348554e-02f, 7.19344765e-02f, 6.95456341e-02f,
  2.39300445e-01f, -2.78539043e-02f, -1.57255068e-01f, -1.06071942e-01f, 2.23459583e-02f, 2.91669816e-01f, -7.37100244e-02f, -1.31289765e-01f, -1.40411526e-01f, -1.20796278e-01f,
  -1.05818488e-01f, 3.26720215e-02f, -1.50824100e-01f, 1.90632567e-01f, -8.15628171e-02f, 1.29946992e-01f, 2.64669001e-01f, 2.32741952e-01f, 2.74823215e-02f, -1.44048765e-01f,
  -1.29193053e-01f, -5.44580258e-03f, -1.35919005e-01f, -1.75914653e-02f, -7.54535422e-02f, 1.30554512e-01f, -9.23245773e-02f, 1.83654465e-02f, -6.71597868e-02f, 4.23969654e-03f,
  6.88593984e-02f, -1.67161807e-01f, 1.65153936e-01f, 3.59736055e-01f, -3.23952991e-03f, 9.26679075e-02f, -2.79287007e-02f, 8.15014541e-02f, -1.35694118e-02f, 6.87614977e-02f,
  -1.90979600e-01f, -6.30602241e-02f, 7.41842315e-02f, -1.22930519e-01f, 8.61550048e-02f, -7.18268678e-02f, 1.74349412e-01f, 4.59813215e-02f, -6.61660209e-02f, -4.75953929e-02f,
  7.30231777e-02f, -3.18055041e-02f, 2.24263430e-01f, -1.68854252e-01f, -5.02781868e-02f, -2.52061576e-01f, -1.07672326e-01f, -4.48472649e-02f, -4.58029518e-03f, -1.23459503e-01f,
  -1.40116200e-01f, -2.60396063e-01f, -2.47434795e-01f, 1.65887605e-02f, -4.86520045e-02f, -8.89634434e-03f, 1.01237997e-01f, -1.88706651e-01f, -1.52951270e-01f, -2.06390351e-01f,
  2.50594944e-01f, 2.56463364e-02f, 1.04505703e-01f, -2.28710786e-01f, -2.22754851e-01f, 2.47150827e-02f, 1.33509383e-01f, 6.21876232e-02f, 2.14594126e-01f, -2.84365546e-02f,
  5.32923127e-03f, -8.07205364e-02f, -5.88805713e-02f, 1.84932172e-01f, 1.16551621e-02f, 2.13351287e-02f, -7.04800570e-03f, -7.60952979e-02f, -9.25561488e-02f, -5.87099902e-02f,
  -2.22718492e-01f, -1.06104173e-01f, -2.47899532e-01f, -3.12588736e-02f, 3.36816087e-02f, -2.76931077e-01f, -9.12809223e-02f, 1.04689665e-01f, 1.46583039e-02f, -6.87028142e-03f,
  -7.18775839e-02f, -1.55438930e-01f, -7.01192543e-02f, 1.75395548e-01f, -1.45067289e-01f, 4.21301574e-02f, 6.52118176e-02f, -1.29488960e-01f, 2.26479564e-02f, -2.79469758e-01f,
  3.27056915e-01f, 3.53973746e-01f, 3.59163284e-02f, 1.33314207e-01f, 2.43494217e-03f, 3.38122249e-01f, -6.53646141e-02f, -2.05994397e-01f, -1.73244983e-01f, 6.93759918e-02f,
  4.91336733e-02f, 6.11663163e-02f, -7.16599403e-03f, 1.66950911e-01f, -4.85736616e-02f, 1.16447052e-02f, 1.00855246e-01f, 4.96189892e-02f, 7.21343756e-02f, -1.75498892e-02f,
  1.52404115e-01f, 1.22596249e-01f, 2.11794138e-01f, -2.36373320e-01f, -3.32647592e-01f, 1.23034000e-01f, 1.09405562e-01f, 2.40323305e-01f, 1.33786306e-01f, -7.12073669e-02f,
  1.47881165e-01f, 6.94311410e-02f, 1.43185738e-04f, -1.22511871e-01f, -2.13756695e-01f, -5.02206534e-02f, 3.76159907e-03f, 4.12348248e-02f, -1.20480426e-01f, -8.23295787e-02f,
  2.18063816e-01f, 1.98026150e-01f, -6.99436739e-02f, 1.43420368e-01f, 1.13896564e-01f, 3.64498168e-01f, 3.37827593e-01f, 2.19349101e-01f, -1.55039281e-01f, 2.18768761e-01f,
  -2.28846073e-01f, 1.39083304e-02f, -1.62362814e-01f, 8.93052816e-02f, -1.21946171e-01f, -2.66889967e-02f, 3.03508848e-01f, -1.75336808e-01f, -4.68976833e-02f, 1.08248532e-01f,
  -7.73892850e-02f, -7.73648545e-02f, -8.50206539e-02f, 1.69603184e-01f, -1.05217941e-01f, -7.11313263e-02f, -5.23412526e-02f, 8.39283168e-02f, 2.32842490e-01f, 4.46500815e-02f,
  -2.55816102e-01f, -1.36609390e-01f, 3.72176692e-02f, 4.58714105e-02f, 7.46691227e-02f, -1.90401018e-01f, -1.14067391e-01f, 2.50231428e-03f, 1.89810917e-01f, -1.14315815e-01f,
  -9.43598300e-02f, 4.54198457e-02f, -1.18159950e-01f, 7.74445906e-02f, -2.43829206e-01f, -2.89151579e-01f, -5.87695860e-04f, -1.60628647e-01f, -7.41723999e-02f, -3.05127203e-01f,
  -6.90955529e-03f, 1.11611232e-01f, 4.51088650e-04f, -1.60495475e-01f, 1.83495522e-01f, 1.42454401e-01f, 1.57466084e-01f, 4.56601009e-02f, 2.55255364e-02f, -3.10665672e-03f,
  -2.13249147e-01f, 1.50001356e-02f, -1.82416335e-01f, 8.88846908e-03f, 2.85975486e-01f, -1.12802446e-01f, -2.31694520e-01f, 3.26498561e-02f, -1.93177670e-01f, 1.47436187e-01f,
  2.24785820e-01f, 9.38719213e-02f, -1.12018116e-01f, -5.45347892e-02f, -5.09969369e-02f, -3.24955806e-02f, -5.49484193e-02f, 1.49332836e-01f, -3.90392572e-01f, -6.70754910e-02f,
  2.13489141e-02f, -6.53944910e-02f, 9.21223871e-03f, 1.52070090e-01f, -1.87942967e-01f, 1.42717317e-01f, -1.79519475e-01f, 3.11638296e-01f, -9.67596993e-02f, -1.02373458e-01f,
  2.41075512e-02f, 1.48143858e-01f, 9.70928669e-02f, 4.19618115e-02f, 2.08849683e-01f, -1.46484092e-01f, 3.03529203e-01f, -9.26573202e-02f, -1.81306913e-01f, 5.37405312e-02f,
  -4.83164266e-02f, -3.88751626e-01f, 9.28033739e-02f, -1.32579848e-01f, 7.17277601e-02f, 7.90488869e-02f, 1.02413923e-01f, 8.14082026e-02f, 5.14621437e-02f, -1.06826544e-01f,
  -3.08731407e-01f, -1.43892830e-02f, 3.45324904e-01f, -2.30868474e-01f, -3.00939918e-01f, 2.30300594e-02f, 1.82448313e-01f, -1.14986889e-01f, -4.67632674e-02f, -1.38532361e-02f,
  1.48345269e-02f, -1.63008481e-01f, 1.87446564e-01f, 3.05442959e-02f, -3.44607644e-02f, -1.74453959e-01f, -1.29786327e-01f, 1.55648664e-01f, -4.11413796e-03f, 2.29728352e-02f,
  -1.11298278e-01f, -6.90500364e-02f, -6.99772760e-02f, -2.42284432e-01f, 1.82856411e-01f, 1.20701149e-01f, -1.65365547e-01f, 1.46690190e-01f, -1.52685061e-01f, -8.68019164e-02f,
  -6.41914830e-02f, -8.49863514e-02f, -1.35472581e-01f, -3.21789049e-02f, 2.02582464e-01f, 9.58388299e-02f, 7.83054903e-02f, 1.26253024e-01f, 8.23649019e-02f, 4.16504964e-02f,
  -4.09491695e-02f, -1.74579531e-01f, -2.11129650e-01f, -3.21564406e-01f, -7.07630366e-02f, -7.78310820e-02f, 6.72166571e-02f, -3.83695029e-02f, -1.37719199e-01f, 6.41680509e-03f,
  -5.03984354e-02f, 7.18563870e-02f, 1.44591853e-01f, -1.12557285e-01f, 1.14635892e-01f, 1.19867004e-01f, 5.95752243e-03f, 1.53292060e-01f, 3.78492363e-02f, -2.62679160e-02f,
  2.99194306e-01f, -1.04279444e-02f, 1.02497771e-01f, 1.46200418e-01f, 7.19847083e-02f, 2.27725714e-01f, 2.52704144e-01f, -2.04054087e-01f, -2.60683477e-01f, 1.37511283e-01f,
  5.78617528e-02f, -5.46244578e-03f, -2.05936939e-01f, 1.36632368e-01f, -1.95999503e-01f, 2.24725947e-01f, 2.76289433e-02f, 3.46332118e-02f, 1.53943047e-01f, -3.68583016e-02f,
  -1.74392030e-01f, -1.40671045e-01f, -1.70612242e-02f, -5.91521524e-02f, -8.49967729e-03f, -1.42197805e-02f, -1.23138480e-01f, -1.08436421e-01f, -2.27494299e-01f, -1.07951634e-01f,
  -9.14294645e-02f, 1.46598533e-01f, -1.05355933e-01f, 2.89810374e-02f, -2.33614564e-01f, -8.22585935e-05f, -1.93799540e-01f, -9.20023322e-02f, -1.08153284e-01f, -1.34465218e-01f,
  -1.29291102e-01f, 4.36170259e-03f, -9.37961638e-02f, -1.88847438e-01f, -9.54714045e-02f, 2.12083291e-02f, -1.39064655e-01f, -5.31262122e-02f, 1.91873416e-01f, -5.62812202e-02f,
  1.77351847e-01f, -2.82019019e-01f, 3.32786620e-01f, -1.43205062e-01f, 2.55981125e-02f, -1.25424698e-01f, -1.31375715e-01f, -1.40638292e-01f, 7.22143287e-03f, -2.27935556e-02f,
  -2.88957711e-02f, -2.19878152e-01f, -1.37168616e-01f, -2.49362811e-01f, 7.40728825e-02f, 7.68035650e-02f, -1.60822440e-02f, -8.44193697e-02f, -1.47162139e-01f, -7.34128579e-02f,
  -5.99014200e-02f, -2.34666187e-02f, -2.65905052e-01f, -1.58839613e-01f, -2.40962788e-01f, -6.80245906e-02f, 7.52092376e-02f, 1.24724805e-01f, 1.37145102e-01f, 1.46719784e-01f,
  1.30547106e-01f, 2.09165476e-02f, -1.15119759e-02f, 1.74604841e-02f, -2.11916104e-01f, -1.39191747e-01f, -9.09154415e-02f, 7.92129524e-03f, -3.33904922e-02f, -2.06997588e-01f,
  5.74974492e-02f, -3.07255656e-01f, -1.96655735e-01f, -1.74953520e-01f, 2.31810845e-02f, 9.09470618e-02f, 1.19563036e-01f, -2.30291132e-02f, -6.03805576e-03f, 1.02895163e-01f,
  -9.04879421e-02f, -1.52020767e-01f, -3.41658629e-02f, -1.57154188e-01f, -1.60388127e-01f, 6.56026676e-02f, 1.59825850e-02f, -6.76196218e-02f, -2.01530270e-02f, -9.72013026e-02f,
  4.30556573e-02f, 1.31861910e-01f, 9.43448395e-02f, -1.82226668e-05f, 4.42614555e-02f, -2.94965595e-01f, 3.28649491e-01f, -2.69709498e-01f, 1.14679307e-01f, -3.82858336e-01f,
  -7.48580024e-02f, -1.13577165e-01f, -7.92724788e-02f, -1.60591528e-01f, -3.11081260e-01f, -3.15258950e-01f, -1.75192177e-01f, -3.12878489e-01f, 1.42862394e-01f, 2.53117412e-01f,
  2.92579442e-01f, 1.07580282e-01f, -1.37329489e-01f, -8.30476359e-02f, 6.12129942e-02f, 1.49694756e-01f, -1.17527500e-01f, -3.29737931e-01f, -1.29351541e-01f, 2.63764057e-02f,
  2.10784264e-02f, 9.13206674e-03f, 2.01162040e-01f, 5.72366714e-02f, 2.93723922e-02f, 7.06326663e-02f, -1.20890692e-01f, -1.33416459e-01f, -1.72460377e-01f, 9.35504660e-02f,
  2.96699312e-02f, -1.15793698e-01f, 5.34300208e-02f, -7.21809790e-02f, 9.75275189e-02f, -2.43376464e-01f, -7.20525607e-02f, -1.22909240e-01f, 6.74586296e-02f, 1.46116942e-01f,
  3.70905787e-01f, 7.24311769e-02f, 5.97282983e-02f, -5.98820783e-02f, -2.47770384e-01f, -5.82413375e-02f, -1.41986638e-01f, -2.31402963e-02f, 2.94338595e-02f, -1.47479191e-01f,
  2.03213140e-01f, 8.42544585e-02f, -6.76135570e-02f, -6.02019280e-02f, 1.25479132e-01f, -7.72506520e-02f, 2.34715655e-01f, 8.15417320e-02f, -9.76102799e-02f, -1.53257847e-01f,
  2.35803768e-01f, -2.12307125e-01f, -1.89116336e-02f, -3.46151084e-01f, -2.42129862e-01f, -2.57364571e-01f, -1.13701202e-01f, -3.24798614e-01f, -4.07966793e-01f, -1.79504365e-01f,
  -7.10365083e-03f, -2.49394193e-01f, 1.36925489e-01f, -7.25440681e-02f, 1.91894814e-01f, -4.50481996e-02f, -1.31004274e-01f, -1.02772780e-01f, 8.28385875e-02f, -5.48193008e-02f,
  1.72628218e-03f, -5.40105626e-02f, -2.38021046e-01f, 1.76348954e-01f, 2.05628261e-01f, 1.05225593e-01f, 1.30595714e-01f, -6.85065836e-02f, -3.77652645e-02f, 2.15503424e-01f,
  3.28408442e-02f, 4.06820960e-02f, 1.05839282e-01f, -4.43258137e-02f, 2.12637946e-01f, 1.59253806e-01f, 9.70407724e-02f, 1.13957658e-01f, 1.12285636e-01f, 2.95673788e-01f,
  -5.48564158e-02f, 2.52166569e-01f, 1.85451917e-02f, -1.55620411e-01f, -4.77757715e-02f, -7.06283748e-02f, -1.53578088e-01f, 1.57044604e-01f, -1.14806719e-01f, 1.73526138e-01f,
  1.27862382e-03f, -1.59225781e-02f, 5.64183369e-02f, -3.32502350e-02f, -6.41761571e-02f, -5.68512194e-02f, 1.00066096e-01f, 1.55092210e-01f, 1.80676226e-02f, -2.67742351e-02f,
  4.35253531e-02f, 3.82998347e-01f, -2.07730234e-01f, 1.96143582e-01f, -1.12164222e-01f, -1.00184418e-01f, 1.88782141e-01f, 7.37804845e-02f, 3.30204070e-01f, 7.46657699e-02f,
  4.67564911e-02f, -3.14676017e-02f, 4.00192663e-02f, -8.16508681e-02f, -1.90038905e-01f, 2.24466875e-01f, -3.70288968e-01f, 2.93200202e-02f, -2.28259757e-01f, -3.28498274e-01f,
  9.47969630e-02f, 1.29670292e-01f, 8.27043038e-03f, -1.42618129e-02f, 2.64937103e-01f, 1.47820339e-02f, -7.05542043e-02f, 7.20523372e-02f, 1.06024086e-01f, -6.35884553e-02f,
  -1.44239992e-01f, -1.04105674e-01f, -1.48873806e-01f, -6.91350400e-02f, -1.52362630e-01f, 6.78432286e-02f, 1.62495077e-01f, 7.01398179e-02f, -1.13123477e-01f, 2.98465997e-01f,
  -1.41969381e-03f, 1.29127339e-01f, 3.72595084e-03f, -7.63692781e-02f, -5.58475591e-02f, 1.42419234e-01f, 6.34520873e-02f, -6.19250610e-02f, 6.20414279e-02f, 1.00290701e-01f,
  3.33900787e-02f, 1.45014189e-02f, 2.34312162e-01f, 1.31078633e-02f, -2.72775590e-02f, 1.55229978e-02f, 1.02919929e-01f, 9.37039107e-02f, 1.25101700e-01f, 1.35935679e-01f,
  -5.32326251e-02f, -4.08275798e-02f, 1.53998062e-01f, 2.51834150e-02f, -1.55717790e-01f, 2.02313781e-01f, 1.12834767e-01f, 1.27509639e-01f, -6.49798661e-02f, 7.90051445e-02f,
  -1.47294164e-01f, -1.13786869e-01f, 2.58321524e-01f, -1.02179945e-01f, -8.40229392e-02f, 9.13532376e-02f, -1.93084493e-01f, -6.70633167e-02f, -1.63620204e-01f, 7.72900730e-02f,
  -2.49409467e-01f, -1.19982317e-01f, -1.15571404e-02f, 1.39166608e-01f, 7.07428306e-02f, 5.75777749e-03f, -3.66350532e-01f, 1.98943198e-01f, 1.48651198e-01f, 1.23747341e-01f,
  2.00398088e-01f, 1.45090207e-01f, 1.94857925e-01f, -3.59831899e-02f, -3.04791518e-02f, 1.77840590e-01f, -1.22453727e-01f, -8.42830574e-04f, -1.35676842e-02f, 1.43738955e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.16356887e-01f, -2.49120146e-02f, 2.08487630e-01f, -1.48381636e-01f, 2.36460641e-02f, 5.14998063e-02f, -5.17669916e-02f, 2.04296172e-01f, 2.05638751e-01f, -5.98328784e-02f,
  3.01461786e-01f, 1.46367803e-01f, -2.47542635e-02f, -1.12715393e-01f, 1.27939716e-01f, 2.36894473e-01f, 8.42631385e-02f, -4.18876678e-01f, 8.05658624e-02f, -8.88617262e-02f,
  2.83265710e-01f, -6.86596185e-02f, 2.29951367e-02f, -1.73339486e-01f, 1.67153791e-01f, -1.36498004e-01f, 7.79888108e-02f, -3.05728704e-01f, -3.65436316e-01f, -3.13391268e-01f,
  -1.54833809e-01f, 1.67424873e-01f, -3.17494929e-01f, -2.15745732e-01f, -2.71496266e-01f, 2.40737438e-01f, 2.34244421e-01f, 4.13568802e-02f, -1.24994710e-01f, 1.84783742e-01f,
  2.64571428e-01f, -2.00256646e-01f, 5.75088322e-01f, 5.29444814e-01f, -5.11449501e-02f, -8.36294591e-02f, -1.30560890e-01f, 7.27409720e-02f, 4.98183906e-01f, -1.86056480e-01f,
  1.25146098e-03f, -1.36926711e-01f, 3.89196932e-01f, 1.54336050e-01f, 6.72674999e-02f, 2.76055932e-01f, 2.60284096e-01f, 4.18532878e-01f, -3.45244259e-01f, -4.69897129e-02f,
  5.66472821e-02f, 1.69000551e-01f, 3.01628746e-03f, 9.34765264e-02f, 1.78750172e-01f, 2.81540215e-01f, 1.33446053e-01f, 3.63343298e-01f, -1.50715990e-03f, -2.44191736e-01f,
  1.16452456e-01f, -1.43251404e-01f, 2.06930161e-01f, 2.67981917e-01f, -1.00212969e-01f, 3.72058600e-02f, 2.74091929e-01f, 1.93899721e-01f, 1.76518053e-01f, -1.81552097e-01f,
  -5.66497296e-02f, 2.58495480e-01f, -4.92102988e-02f, 1.54783234e-01f, 1.44226104e-01f, 2.47140020e-01f, 3.99352849e-01f, 2.86796004e-01f, -1.87956795e-01f, -1.09615840e-01f,
  1.12415925e-01f, -2.91105658e-01f, 1.72550395e-01f, 4.79438901e-01f, 1.10394426e-01f, 6.72029108e-02f, 9.92306322e-02f, -1.41188905e-01f, 2.15226158e-01f, -1.97744757e-01f,
  -2.25136861e-01f, -9.59937647e-02f, 4.59110439e-02f, -3.59887064e-01f, -4.17127937e-01f, 1.46665692e-01f, 1.41732857e-01f, -4.44475859e-01f, -1.10845789e-01f, -3.61701660e-02f,
  3.40873927e-01f, 3.40535223e-01f, -1.58748344e-01f, -9.61255282e-02f, 4.93665278e-01f, -8.08778331e-02f, -6.58250228e-02f, 1.77679047e-01f, 3.71886164e-01f, -4.01385017e-02f,
  7.86798224e-02f, -5.63886948e-02f, 4.04764056e-01f, 2.85739630e-01f, -3.18045378e-01f, -1.61673144e-01f, -6.47032410e-02f, 4.44504209e-02f, 1.11159414e-01f, 2.58683711e-01f,
  -2.66643107e-01f, 1.36706054e-01f, 1.04932729e-02f, 1.08340949e-01f, -1.35271862e-01f, 1.69009507e-01f, -8.35062340e-02f, 1.61146000e-02f, 1.08467765e-01f, -1.82140753e-01f,
  2.78968979e-02f, 5.30496836e-01f, -4.56775501e-02f, 9.64499712e-02f, 2.73032635e-01f, -6.10360177e-03f, -6.58037439e-02f, 3.75849158e-02f, -1.89201191e-01f, 3.70792598e-01f,
  -1.65367067e-01f, 5.52124120e-02f, -1.38338163e-01f, 5.08942842e-01f, 1.35620162e-01f, 1.61885954e-02f, 2.10818812e-01f, 2.52074480e-01f, 2.26161852e-01f, 6.37942702e-02f,
  4.28405881e-01f, 1.15230650e-01f, 1.50805041e-01f, -3.83952379e-01f, -4.21096832e-01f, 2.43633330e-01f, 1.05244301e-01f, -3.35170597e-01f, -2.24840075e-01f, -1.29916012e-01f,
  -1.80710405e-01f, -3.92608643e-01f, -5.61227985e-02f, -3.58912349e-01f, -2.92855203e-02f, -1.33854151e-01f, -4.19150323e-01f, -1.48660943e-01f, 5.42416461e-02f, -1.32746324e-01f,
  -1.66420579e-01f, 1.40748799e-01f, 2.26106167e-01f, 4.91789430e-02f, -3.36962640e-02f, -8.83787572e-02f, 2.27964789e-01f, -1.58700511e-01f, 2.14556664e-01f, 1.20024018e-01f,
  2.06541136e-01f, 3.16574544e-01f, -3.05383708e-02f, -1.69370428e-01f, 3.79984498e-01f, 2.13826418e-01f, 2.57314950e-01f, 2.99965646e-02f, 8.05006698e-02f, 1.07311420e-01f,
  1.23836450e-01f, 2.62215525e-01f, 1.73709035e-01f, 2.62874573e-01f, 3.23707730e-01f, 3.15495193e-01f, 2.07512781e-01f, 1.09619819e-01f, -1.68423504e-01f, 3.10531318e-01f,
  9.29214358e-02f, 1.56599302e-02f, -9.75469276e-02f, -1.12679213e-01f, 2.73077816e-01f, 7.57855847e-02f, 7.45650604e-02f, -1.26649246e-01f, 1.88390568e-01f, -2.67543308e-02f,
  5.50276265e-02f, -2.79223211e-02f, 7.31527209e-02f, 1.11104853e-01f, 4.88638505e-02f, -3.54862601e-01f, 4.89642993e-02f, 7.36851618e-02f, 6.53321221e-02f, 9.40533578e-02f,
  -1.23420313e-01f, 1.22673087e-01f, 1.40683174e-01f, -3.39393944e-01f, 1.63390294e-01f, 6.68161288e-02f, 4.47934270e-02f, -1.85798749e-01f, -3.85261402e-02f, -2.14371368e-01f,
  5.10008167e-03f, -3.47577721e-01f, -1.50802493e-01f, -5.92964411e-01f, 1.71458155e-01f, -1.71077296e-01f, -1.26720235e-01f, -8.96052793e-02f, 4.29586053e-01f, 5.33170104e-01f,
  4.10336226e-01f, -2.06720695e-01f, -1.23530619e-01f, -8.94444734e-02f, -4.80760008e-01f, 3.21454823e-01f, 8.80835652e-02f, 7.08400905e-02f, -1.24227703e-01f, 2.54836589e-01f,
  -4.24251184e-02f, 1.52591184e-01f, 1.06100596e-01f, 4.08946663e-01f, -6.82658404e-02f, 2.09659755e-01f, 6.54900745e-02f, -2.44407326e-01f, -6.24892935e-02f, 2.30391234e-01f,
  9.09681842e-02f, 2.75803775e-01f, -2.64321089e-01f, 3.60168755e-01f, 1.71367273e-01f, 9.71986651e-02f, -1.05658874e-01f, 7.30297938e-02f, 1.56269968e-01f, -3.78409401e-03f,
  1.44704906e-02f, 5.50156355e-01f, 2.72050232e-01f, 4.01377231e-01f, 2.22137779e-01f, 2.71623671e-01f, 2.06149250e-01f, 2.45254874e-01f, -1.93530366e-01f, -5.17010316e-02f,
  3.69324759e-02f, -9.81605127e-02f, -2.96303511e-01f, 4.29295182e-01f, 9.83264819e-02f, -2.21536487e-01f, -8.92069265e-02f, -1.10933036e-01f, -1.65244304e-02f, -2.61222005e-01f,
  -2.99287528e-01f, -1.36576399e-01f, -2.28528753e-01f, -1.38274908e-01f, -2.71563351e-01f, -3.26029211e-02f, -3.76837641e-01f, 2.74359077e-01f, 1.68218449e-01f, 9.61393490e-02f,
  2.28879571e-01f, 2.33600028e-02f, 2.79379636e-01f, -5.19211479e-02f, 1.10877156e-01f, 2.20142491e-02f, 6.82847351e-02f, 1.76547542e-01f, 2.17394263e-01f, 3.62479061e-01f,
  1.64170608e-01f, 3.00038576e-01f, 4.45182510e-02f, -2.65050177e-02f, 2.23049074e-01f, 6.17847815e-02f, 1.03318051e-01f, 1.87293798e-01f, -4.23716828e-02f, -1.19928129e-01f,
  3.65051031e-02f, 2.40210876e-01f, -3.94875556e-02f, 2.28013080e-02f, -7.76138157e-02f, 3.36839892e-02f, 2.24329501e-01f, 2.03877941e-01f, 1.63589597e-01f, 6.90139011e-02f,
  1.55209124e-01f, 1.37895271e-01f, 5.72866462e-02f, 1.42256454e-01f, -9.35483649e-02f, -3.95674706e-02f, -9.76161510e-02f, -3.15011144e-01f, -2.52814621e-01f, -3.64832759e-01f,
  -1.24954984e-01f, 1.99094012e-01f, -1.24173082e-01f, 1.11913219e-01f, -2.07566217e-01f, 6.47919327e-02f, -1.71549078e-02f, 3.78066837e-03f, -1.63536131e-01f, 3.11763674e-01f,
  -1.47063851e-01f, 3.58638138e-01f, 1.67937309e-01f, -2.35830635e-01f, 2.87311167e-01f, 6.31789044e-02f, -1.30992206e-02f, -4.41060262e-03f, 1.51330605e-01f, 3.99571359e-01f,
  -4.16554034e-01f, 4.39845622e-01f, -1.13998409e-02f, 2.64774621e-01f, 4.26951766e-01f, -1.05517672e-03f, -3.23014557e-01f, 7.76792318e-02f, -2.05562010e-01f, 2.77704209e-01f,
  2.48878554e-01f, 4.27993000e-01f, 4.69893426e-01f, -1.10534411e-02f, -1.28967479e-01f, 2.65568584e-01f, -4.62682918e-02f, 1.92806497e-02f, -8.33202899e-03f, -1.39401302e-01f,
  -1.96372662e-02f, -3.13985273e-02f, -1.85578778e-01f, 1.44186065e-01f, 2.71130621e-01f, 6.70032948e-02f, 8.63591656e-02f, 7.66361356e-02f, 1.27182722e-01f, -1.00349873e-01f,
  1.11574650e-01f, -2.38709986e-01f, -1.79826304e-01f, 1.38601765e-01f, 2.73750454e-01f, -7.09470585e-02f, -1.66168839e-01f, 8.16159323e-03f, 1.88789353e-01f, -9.92424712e-02f,
  3.10667574e-01f, 2.46432275e-02f, 5.10339290e-02f, -1.51305988e-01f, -4.05517399e-01f, 4.62410688e-01f, -7.06155971e-02f, 1.61692530e-01f, -2.46325478e-01f, 8.02933425e-02f,
  2.87645221e-01f, 7.30520263e-02f, -1.17998973e-01f, 1.75632089e-02f, -3.39777201e-01f, 3.91996592e-01f, 2.94487536e-01f, 5.87448431e-03f, 2.31227323e-01f, -2.74010487e-02f,
  1.90855622e-01f, 5.44541299e-01f, 2.36669376e-01f, -1.52419969e-01f, -3.93848032e-01f, -1.10130766e-02f, 3.19487974e-03f, 5.05423725e-01f, 4.52223092e-01f, 2.15107068e-01f,
  2.07838014e-01f, 4.63420361e-01f, 1.38809517e-01f, -1.39515445e-01f, -5.58981180e-01f, -8.97288620e-02f, -1.44902198e-02f, 5.22229224e-02f, 4.31974739e-01f, 8.70463029e-02f,
  -1.99401170e-01f, 2.41564810e-01f, 8.55238140e-02f, 1.11655509e-02f, -1.34643132e-03f, 1.56292602e-01f, 2.80827999e-01f, 7.66879767e-02f, 3.07853706e-02f, -1.92399293e-01f,
  1.62478343e-01f, 2.25155339e-01f, 1.42581165e-02f, 2.61979222e-01f, 4.80892062e-01f, -1.81774870e-02f, 4.61627729e-02f, 2.05691129e-01f, -8.32571685e-02f, 8.10814053e-02f,
  1.16445720e-02f, 5.57190701e-02f, 2.08545148e-01f, 5.02161324e-01f, -1.67519808e-01f, -8.95257294e-02f, -6.44241720e-02f, 8.22137892e-01f, -1.87567770e-02f, 4.22059335e-02f,
  -1.36134354e-02f, 1.36700004e-01f, 4.88633245e-01f, -3.89477313e-01f, -5.81642389e-02f, 6.93976060e-02f, -2.15265155e-02f, -5.49477518e-01f, -2.19524410e-02f, 8.32925960e-02f,
  -3.68481636e-01f, -6.18473105e-02f, -4.60638106e-01f, 1.05653420e-01f, -1.86852291e-01f, -8.16226825e-02f, -9.08299088e-02f, -5.94179183e-02f, 5.47938645e-01f, 1.62736535e-01f,
  3.11334282e-01f, 2.26088524e-01f, 2.47803420e-01f, 3.55903864e-01f, 1.52165949e-01f, -1.68734029e-01f, 1.63111195e-01f, 7.73220137e-02f, -7.73841813e-02f, -2.93250550e-02f,
  6.30945191e-02f, 2.88285524e-01f, -1.29383951e-01f, 1.04819961e-01f, 2.59903222e-01f, 1.24579459e-01f, -2.68238902e-01f, 1.64070636e-01f, 2.24950269e-01f, 2.81798214e-01f,
  -2.54622459e-01f, 1.51100636e-01f, 4.80414890e-02f, -1.91268235e-01f, -2.78753012e-01f, -2.43641660e-01f, 1.35264127e-02f, 3.36286396e-01f, -2.29727730e-01f, 1.45394370e-01f,
  1.26472086e-01f, 1.56940520e-01f, -1.94876507e-01f, 3.24482650e-01f, -1.21509030e-01f, -1.02777416e-02f, 9.42570195e-02f, 2.42775112e-01f, -7.58772492e-02f, 4.43787783e-01f,
  1.74761608e-01f, -2.03312188e-01f, 3.02666247e-01f, -1.78505987e-01f, 2.63181150e-01f, -3.95536005e-01f, -1.36837304e-01f, 2.36960784e-01f, -1.54406190e-01f, -4.26157713e-02f,
  2.27651373e-01f, 3.11663121e-01f, -2.13335440e-01f, -2.38015875e-01f, -2.15575680e-01f, -2.77135938e-01f, -4.14587334e-02f, 4.47753817e-02f, -1.35527343e-01f, -3.61534655e-01f,
  -3.90184045e-01f, -2.70086247e-02f, -1.92018643e-01f, -1.13565221e-01f, -1.17553892e-02f, -3.84752333e-01f, -1.52072564e-01f, -3.55795652e-01f, 3.13211977e-01f, 4.66104299e-01f,
  3.31537992e-01f, -3.54666486e-02f, 2.49880731e-01f, -1.57651994e-02f, -3.59213531e-01f, 7.84807000e-03f, -9.90832504e-03f, -1.63609665e-02f, 1.17763519e-01f, 1.37694016e-01f,
  4.72531319e-02f, 1.83014482e-01f, 1.21046707e-01f, 1.25253767e-01f, 2.91727893e-02f, 1.81799874e-01f, 7.55468756e-02f, 5.85980564e-02f, -1.80017695e-01f, 4.56475504e-02f,
  3.20822120e-01f, -1.27782032e-01f, -7.57426992e-02f, 1.71828210e-01f, 1.09327450e-01f, 6.97591230e-02f, 1.59111589e-01f, -2.75459021e-01f, -1.54341891e-01f, 1.46472648e-01f,
  -1.08619697e-01f, 1.35882676e-01f, -1.29882753e-01f, -2.45448261e-01f, 4.79259975e-02f, -2.59303540e-01f, 2.57885251e-02f, -2.58167475e-01f, -8.37873146e-02f, -3.88996191e-02f,
  -3.59022528e-01f, 3.09774071e-01f, -1.57307640e-01f, 1.62467092e-01f, 1.84140489e-01f, -1.26469076e-01f, 3.83908540e-01f, -1.48988351e-01f, -4.51084934e-02f, 4.68325540e-02f,
  2.19777273e-03f, -3.98069322e-01f, -1.88104287e-01f, -3.20835672e-02f, 1.93416402e-01f, -3.24507430e-02f, -1.41372710e-01f, -1.34804189e-01f, 3.97014380e-01f, -2.38787889e-01f,
  -3.58045310e-01f, 2.21635026e-04f, 2.75691867e-01f, 2.55348474e-01f, 1.81387603e-01f, -1.68627333e-02f, 4.24813747e-01f, 3.88430685e-01f, 1.53379932e-01f, 2.46323347e-01f,
  2.39349037e-01f, -9.29352120e-02f, -2.40717977e-01f, 1.17767408e-01f, 1.72303349e-01f, 1.94996715e-01f, 1.77684829e-01f, 1.35704234e-01f, -1.06386043e-01f, -1.43109187e-01f,
  1.82078868e-01f, 3.57906707e-02f, -1.19232595e-01f, -1.58943504e-01f, 8.29910487e-03f, -1.84778851e-02f, 4.69835937e-01f, 2.08373070e-02f, -4.89542522e-02f, 9.77831557e-02f,
  6.63148314e-02f, -3.02203447e-02f, -8.49910527e-02f, 1.02391742e-01f, -3.87352966e-02f, 1.15727119e-01f, -1.64513305e-01f, -1.20214038e-01f, 9.91535652e-03f, -8.84541050e-02f,
  -1.18869945e-01f, -4.77315113e-03f, 6.72261044e-02f, 4.52824146e-01f, -1.64711788e-01f, 4.69475053e-03f, 1.81394964e-02f, 1.04607254e-01f, -1.60334393e-01f, -1.00079710e-02f,
  1.95908159e-01f, 1.00737698e-01f, -2.54123807e-01f, -1.49273619e-01f, 4.43888195e-02f, -7.18278959e-02f, -7.71972537e-02f, -8.19159150e-02f, 3.91695462e-02f, 3.48534852e-01f,
  -2.92003751e-01f, 3.46731812e-01f, 2.40313098e-01f, 2.19422653e-01f, -1.45537734e-01f, 3.26259732e-01f, -1.76106140e-01f, -2.48371482e-01f, -2.63989896e-01f, 1.41922608e-01f,
  3.40000391e-01f, 3.27716082e-01f, 4.39118057e-01f, 8.83953646e-02f, -1.50280520e-01f, -1.78809345e-01f, 1.77521020e-01f, 1.86903119e-01f, 1.31935388e-01f, -1.60797447e-01f,
  -2.75634509e-02f, 1.25236632e-02f, 3.76862079e-01f, 1.96914285e-01f, 7.13341758e-02f, 3.66977662e-01f, 3.48946601e-01f, -2.36145541e-01f, -1.27787694e-01f, -1.97987873e-02f,
  4.05215353e-01f, -2.48514280e-01f, -1.75933182e-01f, -9.79874469e-03f, 1.80205852e-01f, -2.46263415e-01f, 1.11772031e-01f, 6.42768815e-02f, 1.39170900e-01f, -2.88124502e-01f,
  1.55975223e-01f, -4.39635217e-01f, -4.02774930e-01f, 2.44735152e-01f, -1.93561092e-01f, 2.46381402e-01f, -3.66080739e-02f, 2.40742862e-02f, 8.31488427e-03f, -1.36891842e-01f,
  3.95789891e-01f, -4.74894136e-01f, -5.68713784e-01f, 1.26845941e-01f, -1.08782589e-01f, 4.98986468e-02f, 2.61213452e-01f, 2.16346398e-01f, 3.64631377e-02f, -4.53191102e-02f,
  -7.67536089e-03f, 1.42933369e-01f, 1.03237204e-01f, 3.81861590e-02f, 4.55522127e-02f, 2.48173863e-01f, 9.33559239e-02f, 3.60240728e-01f, 2.65480042e-01f, 3.38448197e-01f,
  7.47314319e-02f, 2.59133339e-01f, -1.80070102e-01f, 2.10030347e-01f, -2.98244864e-01f, -5.59958071e-02f, -8.59122127e-02f, -3.65122445e-02f, 1.08100824e-01f, 2.47070685e-01f,
  -1.44519890e-02f, 3.83538634e-01f, 2.84172386e-01f, -3.34230274e-01f, 5.90285398e-02f, -1.91194668e-01f, -7.20103458e-02f, 1.15591079e-01f, -2.49393761e-01f, 9.68464762e-02f,
  2.78956652e-01f, 1.57881916e-01f, -1.08182371e-01f, -2.89462954e-01f, 2.37341583e-01f, 1.74891844e-01f, -9.59578753e-02f, 1.04865201e-01f, 1.86010376e-01f, 5.49217574e-02f,
  9.27254781e-02f, 1.27828404e-01f, 2.25915611e-01f, -1.74257144e-01f, -6.37682453e-02f, -1.25261098e-01f, -2.71820929e-02f, 2.82887578e-01f, -1.37773111e-01f, -9.23921913e-02f,
  5.65213382e-01f, 9.98854041e-02f, -4.60127071e-02f, -4.28779066e-01f, -3.38713259e-01f, -1.56051576e-01f, 6.54054731e-02f, -3.21312733e-02f, -6.75542772e-01f, 2.88872272e-01f,
  -3.46750081e-01f, -2.50720710e-01f, -8.12003314e-02f, 1.73754409e-01f, 5.89622796e-01f, 6.55183792e-02f, -1.33902699e-01f, 1.97644070e-01f, 4.60710406e-01f, 2.51233250e-01f,
  -2.78398395e-01f, -1.04281448e-01f, -9.41044539e-02f, 1.21111207e-01f, 1.43818140e-01f, 1.71074644e-01f, 1.74543485e-01f, 2.40753323e-01f, -1.53360218e-01f, 1.83630154e-01f,
  1.97396696e-01f, 1.42184690e-01f, 4.34487313e-01f, 6.92425966e-02f, -3.53063077e-01f, -5.74306622e-02f, -7.71889463e-02f, -1.18483352e-02f, -4.60436568e-02f, 1.22355543e-01f,
  1.76460996e-01f, 1.84223980e-01f, 2.66486347e-01f, -1.73940182e-01f, 1.42242759e-01f, -5.17458022e-02f, -5.95618002e-02f, 4.48862985e-02f, 1.98392168e-01f, -2.95315217e-02f,
  -1.10563487e-01f, -4.76663113e-02f, 2.50837266e-01f, 5.66582680e-02f, -2.04654828e-01f, -5.70255518e-02f, 2.13292450e-01f, 2.75413841e-01f, -7.24266395e-02f, -8.74643773e-02f,
  5.78504652e-02f, 4.64547426e-01f, -2.74725914e-01f, 2.63116866e-01f, -3.21295708e-01f, 3.38275075e-01f, 1.80428803e-01f, -2.40500227e-01f, 1.76995814e-01f, 1.33176312e-01f,
  4.84390818e-02f, -6.04501009e-01f, 3.83679792e-02f, 9.90099534e-02f, 1.99567512e-01f, -2.87796687e-02f, -4.30543274e-02f, -8.75186697e-02f, -4.62445915e-02f, 1.23725079e-01f,
  -8.93722773e-02f, -1.62610505e-02f, 1.65943921e-01f, -4.30654027e-02f, 4.16335791e-01f, 2.37388089e-01f, 1.76618934e-01f, 3.83424312e-01f, -9.63551402e-02f, -7.60580003e-02f,
  -1.92529976e-01f, -5.17335050e-02f, 2.25142077e-01f, 1.60970077e-01f, 2.46698067e-01f, 2.69974053e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  9.58050489e-02f, 1.66734666e-01f, -6.18532300e-02f, 1.28252894e-01f, 1.10208310e-01f, 9.00145173e-02f, 2.71657929e-02f, 2.74947792e-01f, 1.61250070e-01f, 2.35373393e-01f,
  1.43147975e-01f, 2.35508204e-01f, 9.04023871e-02f, 1.00759298e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -3.92853737e-01f, 1.51405007e-01f, -3.48494262e-01f, 2.87916303e-01f, -9.23941210e-02f, -2.06965759e-01f, -2.68260449e-01f, 2.12403908e-01f, 3.55152786e-01f, 1.06511973e-01f,
  -7.39683071e-03f, -2.74136126e-01f, -4.19558764e-01f, 2.83062123e-02f, -2.31740013e-01f, -2.34219864e-01f, 1.76455960e-01f, 8.08183327e-02f, -1.59989551e-01f, -2.58696899e-02f,
  -3.67527992e-01f, -3.38453948e-01f, 1.67312130e-01f, -1.33035645e-01f, -1.42707620e-02f, 1.11942217e-01f, -2.66951099e-02f, -6.15816563e-02f, 3.87858897e-02f, -2.31777266e-01f,
  -2.13858515e-01f, -4.33617719e-02f, -4.45919365e-01f, 9.52426419e-02f, -1.24583349e-01f, -4.46749538e-01f, -3.74734849e-01f, -1.69032931e-01f, -3.49853069e-01f, 2.40648940e-01f,
  3.16306740e-01f, -1.32592320e-01f, 2.75846004e-01f, 3.95098537e-01f, -2.48112023e-01f, 9.84551013e-02f, 3.19126159e-01f, 1.39343739e-01f, -1.48127258e-01f, -4.18977320e-01f,
  -2.73354203e-01f, -5.67266524e-01f, 7.83692226e-02f, 9.10215452e-02f, -3.50886583e-02f, -3.91671270e-01f, -5.54870188e-01f, -2.38183066e-01f, 3.61553937e-01f, 1.50688842e-01f,
  -2.13333294e-01f, -2.23073978e-02f, -2.80195743e-01f, -2.65374213e-01f, 1.59754634e-01f, -1.25683442e-01f, 1.19392900e-02f, 1.61001012e-01f, 2.65626103e-01f, 1.74161345e-01f,
  -2.33630776e-01f, -2.64813472e-02f, 2.07533478e-03f, -8.04194510e-02f, 1.61966532e-01f, -2.18297184e-01f, 1.88544080e-01f, -1.69693474e-02f, -1.62816077e-01f, 1.06720626e-01f,
  -2.68008169e-02f, -5.63677773e-02f, -1.16658740e-01f, 1.24241672e-01f, 2.40987346e-01f, 9.84961540e-02f, 3.56830150e-01f, -2.46714219e-01f, 9.28615257e-02f, -2.01631024e-01f,
  4.30431545e-01f, 4.19638366e-01f, 3.17903399e-01f, -9.23959911e-02f, -1.41802475e-01f, 2.49890000e-01f, 1.79486990e-01f, 4.90382671e-01f, -2.66201884e-01f, 2.14691550e-01f,
  -2.84630787e-02f, -2.81497948e-02f, -3.48571688e-01f, -1.16331272e-01f, -3.12509686e-01f, -2.76561379e-01f, -3.17721486e-01f, 3.17155540e-01f, 3.48239958e-01f, 4.41440083e-02f,
  -3.16474885e-01f, -2.56394118e-01f, -6.18128181e-02f, -1.34491310e-01f, 1.38714522e-01f, -4.02222723e-01f, 3.98720205e-02f, -1.63411766e-01f, -9.29166526e-02f, 2.61285871e-01f,
  -1.49021044e-01f, -4.20178711e-01f, -1.14730529e-01f, 2.61971891e-01f, 2.24590614e-01f, -4.25017089e-01f, -3.31231147e-01f, 1.36310011e-01f, 2.51456171e-01f, -4.69830297e-02f,
  1.95609093e-01f, -8.28345641e-02f, -1.63596064e-01f, -1.21595688e-01f, 1.95152551e-01f, 9.54445526e-02f, -1.14553766e-02f, 1.43331543e-01f, -8.06582067e-03f, 1.96451440e-01f,
  1.73126817e-01f, -1.06929196e-02f, -7.54600838e-02f, -1.70244649e-01f, -2.66530275e-01f, -6.99214861e-02f, 1.15902664e-03f, 4.74655069e-02f, 3.70266140e-01f, 9.38301012e-02f,
  2.20253617e-01f, 9.45201609e-03f, -7.56033733e-02f, 3.05692583e-01f, 1.28739383e-02f, 7.25594014e-02f, -1.37091547e-01f, 5.09245694e-01f, -2.88120449e-01f, -5.26448451e-02f,
  -2.16954514e-01f, 1.11846171e-01f, 2.84502134e-02f, 3.23561817e-01f, 1.28873698e-02f, 2.62304842e-01f, 1.13260649e-01f, -2.08406761e-01f, -4.39768471e-02f, -4.22651321e-02f,
  2.00566024e-01f, -6.42548576e-02f, 1.68453455e-01f, -1.43360034e-01f, -3.40312332e-01f, 1.75043285e-01f, 2.73006827e-01f, 1.20122157e-01f, 1.10251963e-01f, -5.71256518e-01f,
  -3.70584905e-01f, 2.91229725e-01f, 2.68990844e-01f, -8.60741809e-02f, -2.37513989e-01f, -6.61653578e-01f, 1.96286127e-01f, 3.02007526e-01f, -1.97341591e-01f, -6.88369513e-01f,
  -3.32911313e-01f, -5.48122406e-01f, -1.18075900e-01f, 1.67554587e-01f, -2.54627973e-01f, -2.99033355e-02f, -2.03785509e-01f, 1.94758698e-01f, 2.88475677e-02f, 2.33485460e-01f,
  3.02123189e-01f, 2.69457012e-01f, 1.23952869e-02f, -1.33447289e-01f, 7.15784803e-02f, -2.58921802e-01f, 1.99353322e-01f, -7.63789937e-02f, -6.85493946e-02f, 2.58064754e-02f,
  -2.03296944e-01f, 1.06702067e-01f, 2.01590657e-01f, 6.98767304e-02f, -3.23073953e-01f, -2.37192512e-01f, 1.20860629e-01f, -2.81845391e-01f, 6.39409646e-02f, 1.31630987e-01f,
  -2.78822690e-01f, -2.04459518e-01f, -1.96428701e-01f, 2.27995649e-01f, -2.15598807e-01f, -5.89407906e-02f, -5.73042668e-02f, 2.99140602e-01f, -1.55982226e-01f, -3.15179080e-01f,
  -2.14974597e-01f, -1.15329348e-01f, 2.76435554e-01f, 2.73298591e-01f, -5.99140823e-01f, -3.65327269e-01f, -2.10246518e-01f, 2.91117609e-01f, 2.52498209e-01f, 2.62713253e-01f,
  -1.42220736e-01f, 1.00500427e-01f, -7.19728529e-01f, 1.02849096e-01f, -5.39533049e-02f, 1.86026290e-01f, -1.45270169e-01f, -3.04800987e-01f, 4.31521058e-01f, -4.30066109e-01f,
  -6.72785491e-02f, 1.01284636e-02f, -3.20600271e-01f, -1.96433097e-01f, 2.37067342e-01f, -4.29204881e-01f, 8.53102133e-02f, -1.20411381e-01f, 4.15389724e-02f, -8.64581242e-02f,
  4.40079905e-02f, 1.05347869e-03f, 4.75683659e-02f, -5.29326677e-01f, -1.11127593e-01f, -3.67057830e-01f, 1.35977179e-01f, -9.54590812e-02f, 1.92030326e-01f, 8.34754333e-02f,
  1.73985679e-02f, 1.19908780e-01f, 2.23868296e-01f, 1.27753302e-01f, 3.43363702e-01f, -3.39217663e-01f, -5.74722923e-02f, -3.89949232e-02f, -2.66968131e-01f, 1.96095839e-01f,
  2.31448725e-01f, -2.92740494e-01f, -1.73062012e-01f, 8.57845545e-02f, -3.86256203e-02f, -2.68247247e-01f, 2.55928099e-01f, 7.21180663e-02f, 1.70317870e-02f, 1.17703967e-01f,
  -1.52304284e-02f, 5.20085059e-02f, 3.39291751e-01f, -9.88575891e-02f, 1.99042439e-01f, -2.63204932e-01f, -1.72696039e-01f, 3.02239023e-02f, 2.22704351e-01f, 2.62843650e-02f,
  2.42743015e-01f, 1.41215026e-01f, 1.45706296e-01f, -2.44314447e-02f, 1.57692581e-01f, 2.86713243e-01f, -4.20952141e-01f, 1.33629337e-01f, 2.26243690e-01f, 1.92023352e-01f,
  2.00379819e-01f, -6.11770004e-02f, -2.89276838e-01f, 1.87262923e-01f, 1.35309502e-01f, -9.37246159e-02f, -2.15686724e-01f, -2.01030180e-01f, -7.99283162e-02f, -2.34617114e-01f,
  -9.90131795e-02f, -1.02359436e-01f, -1.12288788e-01f, -1.19196668e-01f, 1.09752476e-01f, -1.89104993e-02f, -3.46739218e-02f, 2.89225847e-01f, -2.34786093e-01f, -5.07543981e-02f,
  -2.41901159e-01f, 2.60783315e-01f, 7.89121166e-02f, 1.19800590e-01f, 1.01628611e-02f, -1.41122997e-01f, 2.04018620e-03f, -6.73222020e-02f, 1.69347197e-01f, 1.44899473e-01f,
  -9.71239619e-03f, -8.53757281e-03f, -1.89770341e-01f, 1.85649648e-01f, -1.28860176e-01f, 5.76203316e-02f, 5.04643880e-02f, -2.73563683e-01f, 8.07955936e-02f, 1.82540327e-01f,
  -2.48687848e-01f, -3.41470212e-01f, 2.13239267e-02f, 2.15880290e-01f, 3.78362417e-01f, -2.88940012e-01f, -1.48283958e-01f, -8.97436738e-02f, 1.16675846e-01f, 1.92799672e-01f,
  3.27741355e-01f, 6.09312952e-02f, 2.43833348e-01f, -1.21049166e-01f, -2.45447382e-01f, 3.29010077e-02f, -4.02054265e-02f, 7.12985098e-02f, 9.74518340e-03f, 1.18500590e-01f,
  -2.14731321e-01f, -2.92055368e-01f, 2.95852631e-01f, -2.98138976e-01f, 1.75951019e-01f, 6.27074437e-03f, -4.87070948e-01f, 2.27075681e-01f, -1.37751386e-01f, 1.76036641e-01f,
  1.91480264e-01f, -3.92467797e-01f, 1.56385958e-01f, 2.13788301e-01f, -2.12487936e-01f, -1.54984295e-01f, -1.10654235e-01f, 1.37356102e-01f, -1.53995380e-01f, -2.72215545e-01f,
  2.85927653e-01f, -6.78909128e-04f, -1.24636069e-02f, 1.07486323e-01f, -4.39075194e-02f, 2.06117943e-01f, -6.40517846e-02f, 3.83934900e-02f, 1.12682961e-01f, -5.69184832e-02f,
  -1.57973215e-01f, 1.00904122e-01f, -1.21500216e-01f, 2.18705267e-01f, -6.43889084e-02f, 1.70451980e-02f, -1.99333891e-01f, -1.21621437e-01f, -3.58342752e-02f, 4.52102125e-02f,
  8.07737708e-02f, -2.43348315e-01f, 5.15794531e-02f, -9.73274857e-02f, -1.18695743e-01f, 1.90266997e-01f, 1.08490258e-01f, -2.74582416e-01f, 1.61291882e-01f, -1.33976161e-01f,
  1.70713812e-01f, 1.29392132e-01f, 3.85977894e-01f, -2.94062309e-02f, -2.41135538e-01f, -1.24372683e-01f, -2.25278974e-01f, 2.37137899e-01f, -3.51814747e-01f, 1.10873431e-01f,
  9.23644528e-02f, -2.01567113e-01f, 3.67550462e-01f, -9.18754609e-04f, 1.79724455e-01f, -3.12935799e-01f, -3.69144976e-01f, -6.35945499e-01f, 3.93380672e-02f, 5.36661446e-02f,
  1.78182557e-01f, 1.32999763e-01f, -2.30962504e-02f, -1.84609488e-01f, 1.78271443e-01f, 6.77140653e-02f, -3.83899629e-01f, 2.61075169e-01f, 7.82227814e-02f, 2.39649206e-01f,
  1.27101511e-01f, 1.09072663e-01f, 2.84977436e-01f, -1.52673528e-01f, 3.11532244e-02f, -1.71343938e-01f, -2.41894573e-01f, -3.46548796e-01f, -4.32264879e-02f, -1.73709154e-01f,
  2.46366978e-01f, 9.22697559e-02f, 1.55647740e-01f, 6.52424619e-02f, 1.29571587e-01f, 1.60658583e-01f, 2.95630664e-01f, -1.15839317e-01f, 6.55059591e-02f, -7.51176998e-02f,
  -9.76553019e-06f, 2.14617476e-01f, 2.74223208e-01f, -5.04036486e-01f, -3.92492145e-01f, -3.21435630e-01f, 3.22025716e-01f, 2.87096817e-02f, 1.20526358e-01f, -4.12827551e-01f,
  2.60990173e-01f, -3.22888009e-02f, 3.92598771e-02f, 2.99693853e-01f, -2.88418382e-01f, -3.60589296e-01f, -3.52845520e-01f, 2.46611595e-01f, -1.86531678e-01f, 2.19564453e-01f,
  2.49245003e-01f, 1.21443242e-01f, 3.93880337e-01f, -3.02328080e-01f, -1.21976249e-01f, -2.27942318e-01f, 5.58327436e-02f, 3.07818688e-02f, 2.43348360e-01f, -8.90437067e-02f,
  -1.83557332e-01f, -1.22242041e-01f, -2.35380799e-01f, 1.86957315e-01f, 3.58264059e-01f, -5.63688159e-01f, -1.19197644e-01f, -3.87722790e-01f, -3.58901411e-01f, 1.45686761e-01f,
  -8.38453844e-02f, -2.29943365e-01f, 5.64394593e-02f, 3.76621783e-01f, -2.11995840e-01f, -4.14049000e-01f, -4.82355386e-01f, -2.03198060e-01f, 1.46021955e-02f, -1.57134652e-01f,
  1.94577593e-02f, 2.09530339e-01f, 3.11270386e-01f, -4.71849777e-02f, -3.39304984e-01f, -2.70917445e-01f, -5.66854887e-02f, 3.58170241e-01f, -1.56201363e-01f, 1.32299989e-01f,
  -1.70862272e-01f, 9.16306004e-02f, 6.41243486e-03f, -1.25857592e-01f, -1.71683043e-01f, -2.22819030e-01f, 2.99993083e-02f, 4.00148392e-01f, -4.29333806e-01f, 3.85122448e-02f,
  -1.37927905e-01f, -8.43010247e-02f, 3.80417228e-01f, 7.82895312e-02f, -1.10126540e-01f, -7.14818537e-01f, -1.41763642e-01f, -3.20687294e-01f, -1.23571791e-01f, 3.50099951e-01f,
  -4.51087020e-02f, 3.94071698e-01f, -2.88044423e-01f, -3.14955473e-01f, 2.76453108e-01f, -3.67600530e-01f, 1.38065234e-01f, 4.17053029e-02f, 4.57723975e-01f, 1.95952132e-01f,
  8.77963305e-02f, 3.41030419e-01f, -1.10684242e-02f, -7.61417598e-02f, -3.36813539e-01f, 5.94850145e-02f, -6.68712914e-01f, 2.92009950e-01f, -3.21703196e-01f, -8.81240517e-02f,
  -2.41478339e-01f, -6.38400838e-02f, 2.55062282e-01f, 2.65801847e-01f, 2.99549162e-01f, -5.12170307e-02f, -1.02390163e-01f, 2.58301329e-02f, 5.15070697e-03f, 4.61834595e-02f,
  1.14582777e-01f, 3.29233021e-01f, -1.34490520e-01f, 3.24302405e-01f, 1.74918190e-01f, 6.26778975e-02f, -4.20780592e-02f, -1.98104635e-01f, -8.04278925e-02f, -7.28936493e-02f,
  -6.74471036e-02f, 2.93626562e-02f, 2.94844713e-02f, -2.35041790e-02f, -1.23084106e-01f, -3.37716937e-02f, -3.57393414e-01f, -1.84558555e-01f, 2.36924604e-01f, -1.00532584e-01f,
  -1.50422677e-01f, 3.80940467e-01f, 2.01826096e-01f, -1.83696598e-01f, -3.15757573e-01f, -2.34779939e-02f, 1.92694068e-01f, -6.94774687e-02f, -6.99516851e-03f, -1.68993533e-01f,
  1.48713246e-01f, 1.67079493e-01f, 3.48693252e-01f, 1.47449404e-01f, 2.35272914e-01f, -1.79845974e-01f, 4.12062168e-01f, 8.50833729e-02f, 3.17771107e-01f, -1.93438128e-01f,
  -1.22633189e-01f, 1.00947414e-02f, -1.52304068e-01f, -1.45257488e-02f, 2.16194943e-01f, -5.28695695e-02f, 2.55313605e-01f, 3.51654030e-02f, -3.22400302e-01f, 2.50585049e-01f,
  -1.40627706e-02f, -2.64395833e-01f, 1.31928295e-01f, 3.50074768e-02f, -7.43305504e-01f, 1.20353840e-01f, -3.82090271e-01f, 1.96882889e-01f, -2.37435624e-01f, 1.15004696e-01f,
  -1.93747073e-01f, 1.98997453e-01f, -2.78510392e-01f, 7.98728615e-02f, 1.19411871e-01f, 6.90140352e-02f, 2.49260381e-01f, -1.96825583e-02f, 3.05221647e-01f, 6.69146329e-02f,
  -5.27946800e-02f, -2.98557547e-03f, 1.51255608e-01f, 1.57824770e-01f, 1.59882323e-03f, -1.30760461e-01f, -1.47282228e-01f, -1.86853930e-01f, 1.63265362e-01f, -6.31877407e-02f,
  1.62443638e-01f, 9.28636566e-02f, -2.08940402e-01f, 8.55287015e-02f, 1.77278504e-01f, 4.04284388e-01f, -4.08104926e-01f, 1.32546678e-01f, 1.90524966e-01f, 2.54195891e-02f,
  3.75059247e-01f, 1.76531106e-01f, 1.45233154e-01f, -1.03896655e-01f, -1.70088574e-01f, -3.24105978e-01f, 3.40757668e-01f, 2.49215394e-01f, 1.70057759e-01f, -1.87867671e-01f,
  2.90385395e-01f, -1.30794197e-01f, -3.76530439e-01f, 3.11259598e-01f, 3.05288762e-01f, 1.47127798e-02f, 3.07042241e-01f, 1.31108716e-01f, 4.09507826e-02f, -4.04170126e-01f,
  -1.79922596e-01f, 3.57350022e-01f, 1.20944247e-01f, -2.17615575e-01f, -6.78471744e-01f, -4.59727257e-01f, -3.51145446e-01f, 3.61232758e-01f, -4.73936379e-01f, -2.85177112e-01f,
  -2.29918197e-01f, -1.43378317e-01f, 3.01953077e-01f, 1.37961745e-01f, 1.33692585e-02f, -2.94007629e-01f, 2.88939327e-01f, -1.50698557e-01f, -3.97315115e-01f, -1.12965472e-01f,
  -1.91898182e-01f, -9.89912543e-03f, 4.32067178e-03f, 1.20661408e-01f, -3.02612096e-01f, 2.79014051e-01f, -9.53918397e-02f, -1.01221450e-01f, 7.61805475e-02f, -1.36385411e-01f,
  2.28388175e-01f, -1.29158637e-02f, 4.91505601e-02f, 7.56949559e-02f, -4.50049043e-01f, 2.37587951e-02f, 9.63446572e-02f, 9.05266628e-02f, -4.05218780e-01f, -2.57801320e-02f,
  2.10236758e-01f, 6.59459233e-02f, 1.58340082e-01f, -5.27314916e-02f, 6.88301548e-02f, 1.23387091e-02f, -5.21971434e-02f, -1.34401917e-01f, -7.04208836e-02f, 5.52748237e-03f,
  3.70082781e-02f, -1.17674477e-01f, -2.80417025e-01f, -3.06804329e-01f, -2.10251864e-02f, 5.04990458e-01f, -1.80822060e-01f, -1.64957047e-01f, 1.32208094e-01f, -2.31939629e-01f,
  -5.13165891e-01f, -2.24942137e-02f, -1.37574717e-01f, -2.00409696e-01f, -3.18222225e-01f, 4.17630553e-01f, 2.28162065e-01f, -3.54108155e-01f, 1.05773538e-01f, 1.42712399e-01f,
  1.46293730e-01f, 5.42782359e-02f, -4.97756898e-01f, -4.47884589e-01f, -1.10691197e-01f, 3.83761562e-02f, 3.46136726e-02f, 6.80003911e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.60990711e-02f, 8.51758868e-02f, -4.49510105e-03f, -1.34837441e-02f, -9.49562863e-02f, -1.51106685e-01f, 5.44109605e-02f, -3.56056215e-03f, 7.41977915e-02f, 1.06191903e-01f,
  -1.35773227e-01f, -1.30345806e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    