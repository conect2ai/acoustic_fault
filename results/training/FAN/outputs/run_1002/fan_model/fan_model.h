/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.86829418e-01f, -5.40941894e-01f, 2.39406154e-01f, 5.71789928e-02f, 5.16344942e-02f, 1.97745919e-01f, -1.56883478e-01f, 9.68717709e-02f, 1.75953656e-01f, -1.83292717e-01f,
  -2.09102497e-01f, -1.35705963e-01f, -2.22821444e-01f, -6.53940141e-02f, -6.72935471e-02f, -2.50612069e-02f, 1.15359001e-01f, 4.44400311e-02f, 2.74272352e-01f, 1.15027189e-01f,
  -7.61270672e-02f, -3.96748818e-02f, 2.66898628e-02f, 2.12174073e-01f, -1.58170968e-01f, 1.57989696e-01f, -3.76818068e-02f, 8.22048932e-02f, 3.98180401e-03f, -2.88375199e-01f,
  -6.31973594e-02f, -2.48713374e-01f, 3.39590423e-02f, -2.10475355e-01f, -1.44332558e-01f, 3.64840776e-02f, 7.19840229e-02f, 6.96017668e-02f, 1.17818620e-02f, -7.69186765e-03f,
  -1.34015903e-01f, -5.56817017e-02f, 1.48471063e-02f, -2.25774497e-02f, 8.64790455e-02f, -7.89115801e-02f, -1.14427865e-01f, -8.31799209e-02f, -6.12332448e-02f, 8.01127031e-03f,
  -1.44141912e-01f, 2.55702902e-02f, -7.79847950e-02f, 5.27318742e-04f, -9.96742398e-03f, 2.76874546e-02f, -7.20112547e-02f, 3.02465260e-02f, 7.24117234e-02f, -7.61222169e-02f,
  -3.63633186e-02f, 6.42528906e-02f, 3.41620073e-02f, -2.23472379e-02f, 8.51199180e-02f, -3.07825319e-02f, 7.26411492e-03f, -2.50457469e-02f, 6.24485053e-02f, 8.08613375e-02f,
  -3.23018320e-02f, 5.88453449e-02f, 7.27639496e-02f, 5.40134795e-02f, -5.12362970e-03f, -7.78867491e-03f, 2.40761917e-02f, 2.36841347e-02f, 4.82770614e-02f, 2.16516107e-02f,
  1.50808403e-02f, 7.65318349e-02f, 2.78952774e-02f, -4.31810506e-03f, -2.58513261e-02f, -6.82001235e-03f, -1.94646083e-02f, 8.83651376e-02f, 3.38576101e-02f, 1.03312554e-02f,
  1.94512513e-02f, -1.54378846e-01f, -1.25112133e-02f, -2.08524801e-02f, -1.59009211e-02f, -2.99601015e-02f, -8.23002905e-02f, -1.54306320e-02f, -7.12557184e-03f, -4.67352271e-02f,
  -4.11697403e-02f, -1.03944965e-01f, 2.38055494e-02f, -4.20353189e-02f, -1.89345274e-02f, 1.66948116e-03f, -1.56480953e-01f, -1.77442599e-02f, 2.19956785e-02f, 6.04871567e-03f,
  -3.17056030e-02f, 3.52202496e-03f, 5.06151430e-02f, -3.86297069e-02f, -3.24105136e-02f, 3.10850441e-02f, -7.26024061e-02f, 2.08227988e-02f, 2.99148448e-02f, 1.35530323e-01f,
  9.66594666e-02f, -3.89002562e-01f, 1.71837553e-01f, -1.56831697e-01f, 1.80704132e-01f, 2.34636769e-01f, -1.48593681e-02f, -9.69245359e-02f, 9.41596087e-03f, -1.64457977e-01f,
  -1.08845308e-02f, 1.86837427e-02f, -5.14701307e-02f, -7.22154006e-02f, 5.08988984e-02f, -2.97786016e-02f, 8.56599063e-02f, 1.55848727e-01f, 3.39303821e-01f, 1.87971652e-01f,
  6.80159926e-02f, -1.94172740e-01f, -2.99919136e-02f, 1.34688601e-01f, -1.87809572e-01f, 3.77009856e-03f, -2.00131759e-01f, -1.43091604e-01f, 3.09332851e-02f, -3.68375570e-01f,
  2.34871116e-02f, -1.35186911e-01f, 6.83556497e-02f, -2.70412751e-02f, -2.83461548e-02f, -2.72804089e-02f, -9.31767921e-04f, -1.32891923e-01f, -5.15857432e-03f, -4.88467179e-02f,
  2.87793316e-02f, -8.31819139e-03f, 7.34247863e-02f, -1.76231768e-02f, -6.87523261e-02f, 6.71848236e-03f, -1.22664273e-02f, -4.68400978e-02f, -7.15366229e-02f, -1.03377141e-01f,
  -7.37062693e-02f, 5.89635558e-02f, 5.65017015e-02f, -4.48023751e-02f, 1.78012066e-02f, 8.89026076e-02f, -4.66537289e-03f, 6.94869086e-02f, 6.05731830e-02f, -2.13359803e-01f,
  5.22828028e-02f, 4.59523275e-02f, 3.06309182e-02f, 3.91165391e-02f, -7.61195179e-03f, 2.07159594e-02f, 5.26140556e-02f, 6.63603831e-04f, -6.71696709e-03f, -3.03018576e-04f,
  3.61582935e-02f, -3.74060459e-02f, 5.38727082e-02f, -3.90698798e-02f, -4.28988151e-02f, -2.52543911e-02f, 5.02127707e-02f, -5.24733737e-02f, -1.03625059e-02f, -7.33875036e-02f,
  -9.24055057e-05f, 7.07083941e-02f, -3.62268873e-02f, 5.83306141e-03f, -3.28698084e-02f, 3.93653698e-02f, -2.45846082e-02f, 4.44802409e-03f, -2.57616434e-02f, -1.39884716e-02f,
  -2.17627063e-01f, 9.33187306e-02f, -2.43179370e-02f, -5.46582490e-02f, -3.10986843e-02f, -1.67435110e-02f, -2.47441325e-02f, 1.22367125e-02f, -1.34588582e-02f, -2.80023348e-02f,
  8.78257025e-03f, 4.35811989e-02f, -3.84282470e-02f, -3.29294652e-02f, 6.01504073e-02f, -1.64365526e-02f, -4.73959707e-02f, 2.72986777e-02f, -3.86940548e-03f, -1.76323876e-02f,
  -7.63235465e-02f, 2.28583682e-02f, 2.46506408e-02f, 7.74303526e-02f, 1.63554978e-02f, 4.73546758e-02f, 2.00265404e-02f, -3.78825590e-02f, 1.43921748e-01f, -9.65924338e-02f,
  4.47532684e-01f, 2.54851691e-02f, 2.87717700e-01f, 3.54207635e-01f, 2.47917861e-01f, 7.07266033e-02f, 1.39728829e-01f, 7.72447363e-02f, 1.07272729e-01f, 1.66321069e-01f,
  4.00447249e-02f, -2.27478340e-01f, -2.12038189e-01f, -1.63643867e-01f, 6.84388131e-02f, 1.52901888e-01f, 1.43320650e-01f, 8.02065283e-02f, -8.64795893e-02f, -1.85791124e-02f,
  -8.66464004e-02f, 1.80524394e-01f, 1.05205506e-01f, -3.18953618e-02f, -5.47558293e-02f, -6.93205968e-02f, 2.61448294e-01f, 1.17373213e-01f, -1.89370103e-02f, 1.30606145e-01f,
  -2.04446092e-01f, 1.14610605e-01f, 4.27221693e-02f, -5.75299747e-02f, 2.94048358e-02f, 7.85850082e-03f, -8.06182846e-02f, 1.33063393e-02f, 1.53814489e-02f, -8.61494839e-02f,
  2.84771863e-02f, -6.03211112e-02f, -7.37962499e-02f, -4.27819090e-03f, 4.13197763e-02f, 4.09759171e-02f, -3.82147580e-02f, -6.84383733e-04f, 3.38226259e-02f, -7.74809048e-02f,
  -3.56483869e-02f, 7.61456266e-02f, 4.85071167e-02f, -8.81748050e-02f, -4.78146560e-02f, -1.36773353e-02f, -4.84552272e-02f, 1.89045072e-02f, 7.25305602e-02f, -3.31194922e-02f,
  -3.97528447e-02f, -2.60664709e-02f, 2.84650978e-02f, 2.11396907e-02f, -2.60948781e-02f, -4.98834252e-02f, 4.69865790e-03f, -5.58131263e-02f, 3.98301110e-02f, 2.62734722e-02f,
  1.91193027e-03f, 1.99635550e-02f, -6.62539527e-02f, 2.86110863e-02f, -5.21536209e-02f, 7.25049227e-02f, 1.85992457e-02f, -2.70838346e-02f, 1.51870837e-02f, -1.65361091e-02f,
  3.67467366e-02f, -9.82307829e-04f, 4.71052937e-02f, -5.54049015e-02f, 3.67637863e-03f, -5.30648381e-02f, -3.72594707e-02f, -3.05692200e-02f, 2.45236121e-02f, 8.51337016e-02f,
  -1.34594172e-01f, 8.41150954e-02f, -4.99011204e-03f, 4.20237891e-02f, 2.51783989e-02f, 3.48065272e-02f, 1.03746340e-01f, 1.11789200e-02f, 3.83882690e-03f, 8.54791626e-02f,
  5.85848838e-02f, 4.84536365e-02f, 8.28619376e-02f, 3.16065289e-02f, 9.87545699e-02f, 6.58352971e-02f, 6.88065886e-02f, 4.58905622e-02f, -3.17688398e-02f, -6.83042686e-03f,
  1.67772278e-01f, -1.99258178e-02f, 2.74289493e-02f, 8.02189205e-03f, 5.24541661e-02f, -1.17972074e-02f, -3.74240875e-02f, 3.29758674e-02f, -9.56653133e-02f, 5.34713715e-02f,
  -7.45887160e-02f, 2.69060105e-01f, -8.30832943e-02f, -1.25287801e-01f, -3.52867186e-01f, -8.57017040e-02f, 2.26703957e-01f, 1.64599136e-01f, 2.62045320e-02f, 1.44231915e-01f,
  -1.23761287e-02f, 8.36565942e-02f, 9.05617550e-02f, 8.78728107e-02f, 1.41574293e-01f, 1.91256255e-01f, 2.62660421e-02f, 3.22329402e-02f, -9.03160498e-03f, -1.17342931e-03f,
  -8.39381758e-03f, -1.66972447e-02f, -2.59665400e-02f, 1.03960052e-01f, 1.84054181e-01f, 5.38509190e-02f, 1.94359988e-01f, 9.41737518e-02f, 7.11651817e-02f, 3.64957720e-01f,
  1.17804781e-01f, 7.82675892e-02f, 3.56879309e-02f, 1.29470807e-02f, 2.86818799e-02f, 4.43124212e-02f, 4.82574552e-02f, 2.12395806e-02f, 2.52951216e-02f, 1.08747356e-01f,
  8.36948380e-02f, 4.98973541e-02f, 8.08058754e-02f, 9.61294845e-02f, 9.22437906e-02f, 1.13312587e-01f, 8.05057660e-02f, 1.56429291e-01f, 1.32399544e-01f, 1.37469128e-01f,
  -4.28585857e-02f, -1.14072211e-01f, 3.74577492e-02f, 1.62761274e-03f, -1.91524774e-02f, 1.85328815e-02f, 1.63225457e-01f, 2.04778567e-01f, 1.82993039e-01f, 3.68194550e-01f,
  4.48008738e-02f, -3.83107141e-02f, -5.46745695e-02f, -6.77082613e-02f, 6.05507055e-03f, 5.37774935e-02f, -2.54010540e-02f, 3.36351134e-02f, 2.08700150e-02f, -2.62970018e-04f,
  4.40600477e-02f, -3.42343040e-02f, -1.88191868e-02f, -3.42364460e-02f, 5.60322776e-02f, -5.32166027e-02f, -6.06914647e-02f, 3.93335149e-02f, -1.11936428e-01f, 9.34806019e-02f,
  8.34043100e-02f, -1.36062905e-01f, -5.66118844e-02f, 5.08664288e-02f, -7.48635009e-02f, 3.74485217e-02f, -5.62365167e-02f, -8.57836939e-03f, -2.89530363e-02f, 4.62002866e-02f,
  1.75762653e-01f, -1.37870893e-01f, 1.47353455e-01f, 1.13023311e-01f, 1.46405734e-02f, 9.47270691e-02f, -1.39529267e-02f, 3.74074504e-02f, -4.51309234e-03f, 8.62213895e-02f,
  3.56011614e-02f, 8.79514068e-02f, 5.08293100e-02f, -4.11541052e-02f, 5.96135706e-02f, 3.64060327e-02f, -3.17753851e-02f, -9.13416035e-03f, -2.78215744e-02f, 4.69920039e-03f,
  7.04825744e-02f, 5.64175397e-02f, -3.15822810e-02f, 8.57042894e-02f, 1.02307677e-01f, 3.05856462e-03f, 9.93342623e-02f, 2.11954817e-01f, 7.51865357e-02f, 2.43760630e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.17163551e-01f, 4.97764528e-01f, 1.44255117e-01f, -2.32217237e-02f, -8.74707848e-02f, -1.18915796e-01f, 1.95084997e-02f, 1.12017073e-01f, -8.78356472e-02f, 1.13137551e-01f,
  4.95475717e-02f, -1.60671204e-01f, -2.50422359e-01f, -1.94498062e-01f, -1.22180961e-01f, -5.96085638e-02f, -3.63558196e-02f, 7.23952651e-02f, -1.64578304e-01f, -6.39861748e-02f,
  -1.71427369e-01f, 2.33717754e-01f, 2.52096504e-01f, -1.45823821e-01f, 5.39153675e-03f, -6.67711020e-01f, -2.18478128e-01f, 2.00093493e-01f, -9.29324254e-02f, 2.10605547e-01f,
  1.37549326e-01f, 3.81461233e-01f, -5.18275797e-01f, -5.20075001e-02f, 6.32384494e-02f, 1.17410280e-01f, -4.85340878e-02f, 9.30283368e-02f, -5.63324913e-02f, 1.85611602e-02f,
  1.24936678e-01f, 2.20056981e-01f, 6.67394549e-02f, 4.69432622e-02f, 9.51104686e-02f, -9.14364904e-02f, 1.76035747e-01f, 1.14407882e-01f, -1.39425474e-03f, 4.90902402e-02f,
  -2.17559412e-02f, 2.20180973e-01f, 1.28443345e-01f, -7.81758726e-02f, 1.09558009e-01f, -9.74413827e-02f, 2.75817122e-02f, 1.70139343e-01f, -3.22463810e-02f, 2.90052891e-02f,
  -3.41560016e-03f, 1.03623353e-01f, 1.51219936e-02f, 1.15423322e-01f, -8.73191804e-02f, -2.12049913e-02f, -4.18207310e-02f, -1.05793931e-01f, 3.51056978e-02f, 1.16893336e-01f,
  -1.16846323e-01f, -5.88801019e-02f, 1.15302071e-01f, 7.09029089e-04f, -1.43304050e-01f, 7.90157765e-02f, 4.05807905e-02f, -4.17377464e-02f, -1.54264327e-02f, -1.29525326e-02f,
  -2.99968496e-02f, 2.83486713e-02f, -4.96044010e-02f, 8.39855000e-02f, 1.80319212e-02f, 6.29735664e-02f, -6.05992824e-02f, 9.04172137e-02f, 2.75779031e-02f, 1.08908422e-01f,
  -2.73318231e-01f, -1.88171580e-01f, -9.96952802e-02f, -1.80684272e-02f, 1.37036657e-02f, -7.25440830e-02f, -1.31683215e-01f, 5.10606766e-02f, 9.30039883e-02f, -4.39960435e-02f,
  -6.57369429e-03f, -1.83583982e-02f, -5.06346487e-02f, -1.66032165e-02f, -1.12377390e-01f, -2.16786228e-02f, -1.02081485e-01f, -1.03857122e-01f, -1.08089417e-01f, 9.00524184e-02f,
  -5.70473038e-02f, -2.60076940e-01f, -2.44331792e-01f, -1.83335945e-01f, 7.96178877e-02f, -2.84189403e-01f, -2.00539663e-01f, -1.43453643e-01f, -2.05136687e-01f, -2.70478547e-01f,
  -7.87997723e-01f, -8.63281861e-02f, -9.71113816e-02f, -6.28026009e-01f, -8.68191477e-03f, 2.46287867e-01f, -7.02783316e-02f, 1.90996770e-02f, 1.23375524e-02f, 3.68490890e-02f,
  2.00012997e-01f, -1.32281184e-01f, -1.97273716e-01f, 5.38171083e-02f, 6.82901517e-02f, -9.19762179e-02f, -3.45228493e-01f, -3.04473758e-01f, 1.07986946e-02f, 3.75954777e-01f,
  1.84347838e-01f, -3.17074686e-01f, -3.34978372e-01f, 2.25735500e-01f, -7.33732805e-02f, -2.06679791e-01f, -3.93505991e-01f, -1.97435245e-01f, 2.80938894e-01f, -4.17257518e-01f,
  -1.10195801e-01f, 6.70731515e-02f, 4.42998484e-02f, -1.10888198e-01f, -8.75620916e-02f, 1.54601350e-01f, -6.41188771e-02f, -1.66742936e-01f, -4.33504991e-02f, -5.43392487e-02f,
  -3.20095289e-03f, 7.99544826e-02f, -2.49039844e-01f, 4.29198481e-02f, -1.54254109e-01f, 7.33420476e-02f, 7.06572011e-02f, -2.02650446e-02f, -3.50800715e-02f, 2.57917762e-01f,
  6.73736855e-02f, 6.34260476e-02f, -9.67004150e-02f, 1.18447043e-01f, 2.28670865e-01f, -1.50796026e-01f, 2.22008020e-01f, 2.98317373e-01f, 2.13522717e-01f, -1.78920582e-01f,
  3.81740332e-02f, 4.26057652e-02f, 9.78544354e-02f, 2.10785978e-02f, 3.05379387e-02f, -8.51680711e-02f, -1.18260555e-01f, -2.29459293e-02f, 1.10673169e-02f, -1.49993882e-01f,
  -3.20882164e-02f, 3.34846554e-03f, 2.13507414e-02f, -2.26406977e-02f, 7.49569908e-02f, -3.64929326e-02f, -1.87357459e-02f, -2.03191466e-03f, 1.00648701e-01f, 5.31162061e-02f,
  3.31307314e-02f, 7.34278408e-04f, -6.05385788e-02f, 3.32636870e-02f, 1.56953149e-02f, -1.21525032e-02f, -5.20627722e-02f, 1.17612183e-01f, -2.36778669e-02f, 8.66446868e-02f,
  -3.96470517e-01f, -8.06058422e-02f, -1.60269454e-01f, 1.85070515e-01f, 7.06530351e-04f, 5.27440347e-02f, -1.67847276e-01f, 1.15962602e-01f, -4.24720123e-02f, 6.96774423e-02f,
  1.62207007e-01f, -7.38031566e-02f, -1.61473379e-01f, 1.61259443e-01f, 3.22355516e-02f, 4.29873429e-02f, 9.78263617e-02f, -5.75326160e-02f, 1.06588654e-01f, 1.70688257e-01f,
  9.22746286e-02f, -8.26035440e-02f, -2.12740511e-01f, -1.56363249e-01f, 8.76546875e-02f, -1.71407402e-01f, -1.55495703e-01f, 4.83645573e-02f, -9.94365513e-02f, -2.33135507e-01f,
  -6.40137028e-03f, 2.89744884e-01f, -8.55310932e-02f, 3.16448182e-01f, 2.07964286e-01f, 1.46726832e-01f, 2.80196458e-01f, 1.08367868e-01f, 7.70486742e-02f, 2.01345041e-01f,
  2.18891189e-01f, 2.44751602e-01f, 2.43859157e-01f, 2.61217535e-01f, 1.84920609e-01f, 2.42989108e-01f, 4.17856388e-02f, -7.37710148e-02f, -9.14142653e-02f, 2.27698721e-02f,
  1.53883994e-01f, -9.28183198e-02f, -2.39321977e-01f, -9.59370472e-03f, 2.67310217e-02f, 6.83509037e-02f, -2.03622878e-02f, 2.36488692e-02f, 6.13140427e-02f, 9.23984498e-02f,
  -9.49883088e-02f, 7.32991770e-02f, 1.87897220e-01f, -2.92841662e-02f, -1.44338422e-02f, -2.15054184e-01f, -1.02481626e-01f, -2.62906224e-01f, -1.21170960e-01f, -1.53111458e-01f,
  -1.10511094e-01f, -9.97746587e-02f, 1.75443754e-01f, -5.64414226e-02f, -1.98358908e-01f, -1.38434827e-01f, -6.02202155e-02f, -3.44764590e-02f, 1.94272712e-01f, 6.38454482e-02f,
  2.23438025e-01f, -4.39876355e-02f, -3.88796851e-02f, 8.15299973e-02f, 2.18234286e-01f, 1.09148122e-01f, 7.32951462e-02f, 1.03667550e-01f, -6.27581030e-02f, -3.29780132e-02f,
  -2.02009850e-03f, -8.59694742e-03f, 2.09894076e-01f, -3.25317378e-03f, 1.62039667e-01f, 7.70478323e-02f, -8.12530983e-03f, 3.81421037e-02f, 7.73691460e-02f, -1.76719442e-01f,
  1.00173587e-02f, 5.47809154e-02f, 2.86493301e-02f, 3.16360854e-02f, 1.09923005e-01f, -5.76715963e-03f, -1.94898769e-02f, 1.08584259e-02f, 1.46951471e-02f, -1.25036910e-01f,
  8.41487572e-02f, 3.58962491e-02f, -1.56396449e-01f, 1.29731111e-02f, -7.34378165e-03f, -2.42381431e-02f, -5.79763157e-03f, 6.55916259e-02f, 4.55902219e-02f, -1.66637935e-02f,
  -3.00511271e-01f, 2.37291470e-01f, 1.29106835e-01f, 8.60626101e-02f, -2.98991967e-02f, -9.49577168e-02f, 1.27395466e-01f, -2.37682704e-02f, -4.66239639e-02f, -3.89730930e-02f,
  -4.43153381e-02f, -4.21213061e-02f, -1.25322491e-01f, -1.40498340e-01f, -1.26855031e-01f, -1.50208279e-01f, 3.07671400e-03f, 2.63121426e-01f, 5.44673987e-02f, -3.39167975e-02f,
  1.43729702e-01f, -1.02060340e-01f, -2.47096732e-01f, 9.72831920e-02f, 2.23611370e-01f, 5.54231368e-02f, -9.75010544e-02f, -1.37042731e-01f, -3.75491492e-02f, -1.47095770e-01f,
  -8.21648955e-01f, 6.77711785e-01f, 9.52230617e-02f, -3.13229352e-01f, 4.27371740e-01f, 3.39971364e-01f, 8.82986486e-01f, 8.94698575e-02f, -4.28911477e-01f, 1.74618497e-01f,
  1.74809188e-01f, -2.71571249e-01f, -9.77646038e-02f, -3.39359492e-02f, 4.39116508e-02f, 3.05261374e-01f, 2.95602351e-01f, -1.51564658e-01f, -3.58571947e-01f, -1.51579008e-01f,
  2.60400832e-01f, -1.71024948e-01f, -3.73575836e-01f, -2.23911032e-01f, -1.35962635e-01f, -4.68520820e-01f, 6.36035576e-02f, 5.22665828e-02f, 2.15957955e-01f, 7.23041669e-02f,
  -1.79992244e-01f, 1.32275283e-01f, -2.08707154e-01f, -1.49563819e-01f, 2.27180626e-02f, -1.89508215e-01f, -1.02287799e-01f, -6.11652471e-02f, -5.77445747e-03f, -1.47749707e-01f,
  -2.87012793e-02f, -6.51219785e-02f, 1.03501074e-01f, 7.28330612e-02f, 6.83530122e-02f, 7.25291893e-02f, -8.81688669e-02f, -8.22648928e-02f, -5.72892055e-02f, 1.65944591e-01f,
  2.28122979e-01f, 1.99883163e-01f, 1.36724830e-01f, 2.35329390e-01f, 1.08654998e-01f, -8.83760452e-02f, 1.99433029e-01f, -4.00471315e-02f, -2.14566793e-02f, -2.34595716e-01f,
  -9.44484398e-02f, -1.51088359e-02f, 1.72768161e-01f, -1.07230753e-01f, -4.30536829e-03f, -4.13497426e-02f, -5.67626432e-02f, 1.04707286e-01f, 4.74268347e-02f, -7.13728741e-02f,
  1.20143890e-02f, 5.12726344e-02f, 2.29916312e-02f, -1.82694234e-02f, -7.13756904e-02f, 7.35293031e-02f, 1.16670698e-01f, -6.35914356e-02f, -1.26935616e-02f, 4.18125577e-02f,
  -6.89755976e-02f, -7.38028320e-04f, 3.08177266e-02f, 8.64420831e-02f, 1.12464234e-01f, -3.35986577e-02f, -3.42148691e-02f, 9.52946991e-02f, -1.75364211e-01f, 3.12801786e-02f,
  -3.04667830e-01f, 2.12460622e-01f, -3.21162492e-01f, -8.13012421e-02f, 5.50223254e-02f, 6.56769099e-03f, 3.47326621e-02f, -1.16691310e-02f, 4.41408306e-02f, -4.03317250e-02f,
  1.46485344e-01f, -1.41378850e-01f, 1.40593067e-01f, -3.46155837e-02f, -1.26779854e-01f, -1.24485627e-01f, 1.05671629e-01f, -1.11145146e-01f, 1.98573917e-02f, 1.32686170e-02f,
  -4.58288081e-02f, -1.33938760e-01f, -3.41612011e-01f, -1.88883185e-01f, -1.05106950e-01f, -3.55702996e-01f, -1.25996858e-01f, -2.42713019e-01f, 6.93569034e-02f, -2.63713658e-01f,
  5.02723217e-01f, 4.59808946e-01f, -9.62825477e-01f, -1.50261477e-01f, -8.11353326e-01f, -3.06880623e-01f, -3.17334712e-01f, 2.33183593e-01f, 1.79536819e-01f, -3.73577267e-01f,
  1.12884089e-01f, 2.36712277e-01f, 1.01931170e-02f, 2.12472931e-01f, 2.86278158e-01f, -3.24190587e-01f, -3.85762841e-01f, -2.13147923e-01f, -2.35469848e-01f, -7.02189133e-02f,
  -5.74839860e-02f, -2.50626087e-01f, -1.97175696e-01f, 1.81107447e-02f, -4.81426448e-01f, -3.08780164e-01f, -7.91634619e-01f, -5.96769214e-01f, -3.45513135e-01f, -9.39567924e-01f,
  -3.52562517e-01f, 2.24844679e-01f, -4.23513412e-01f, -7.70760179e-02f, -2.44097099e-01f, 1.05343640e-01f, 1.13907874e-01f, 8.53462666e-02f, 1.04559258e-01f, -9.95070860e-02f,
  -1.85092628e-01f, 3.82989459e-02f, 8.90215859e-02f, -3.28277051e-02f, -1.42035156e-01f, -1.72249421e-01f, 1.41782418e-01f, -9.17630047e-02f, -5.46034575e-02f, 1.70514565e-02f,
  2.45836332e-01f, -1.37267217e-01f, -2.34880030e-01f, -1.18933506e-01f, 6.08040690e-02f, -2.46813685e-01f, -3.78944516e-01f, -3.16372007e-01f, -3.45307469e-01f, -3.55094403e-01f,
  4.08554962e-03f, -4.12268527e-02f, -4.95031253e-02f, 1.03754126e-01f, 2.08610389e-03f, -1.96421798e-02f, 2.38496047e-02f, -1.44881129e-01f, 1.46508366e-01f, 5.06129339e-02f,
  -4.07508053e-02f, -1.86305970e-01f, 1.36714488e-01f, 5.45820072e-02f, -1.55593932e-01f, -1.20983899e-01f, 6.81942850e-02f, -3.21741514e-02f, 5.33829331e-02f, -1.05132893e-01f,
  1.00019192e-02f, -8.17940012e-02f, 4.45177704e-02f, 6.59222603e-02f, 7.56971762e-02f, -4.62225601e-02f, -3.52403298e-02f, 1.29298538e-01f, -1.57748256e-02f, 4.12119851e-02f,
  3.82619709e-01f, -1.10414838e-02f, -9.54174027e-02f, 2.28841498e-01f, 4.69161458e-02f, -1.30400574e-02f, 8.68048817e-02f, 2.65934199e-01f, -2.11975817e-02f, 1.20433997e-02f,
  -7.53634945e-02f, 1.61475241e-01f, 1.06895596e-01f, 8.94447491e-02f, -4.87971082e-02f, 7.39003271e-02f, 3.93091254e-02f, -1.04475297e-01f, 5.81583045e-02f, -8.17880407e-02f,
  8.29120502e-02f, -1.08396001e-01f, 1.35343164e-01f, 1.93018485e-02f, -1.82253137e-01f, -5.29379956e-02f, -1.61043778e-02f, -1.88941643e-01f, 1.29281849e-01f, 1.33312762e-01f,
  -1.24960870e-01f, 1.35120556e-01f, -8.85240734e-02f, 2.07833827e-01f, 1.54837638e-01f, -2.85714388e-01f, -5.56911051e-01f, -3.89384657e-01f, 5.95471300e-02f, 1.52739987e-01f,
  -1.04991831e-01f, 1.93660766e-01f, 1.43741980e-01f, 1.67211413e-01f, -1.67149961e-01f, 1.50944576e-01f, 3.85418445e-01f, 1.13660946e-01f, -4.68092710e-01f, -5.73211432e-01f,
  3.29005420e-02f, 9.50036123e-02f, -8.51172358e-02f, -1.63525164e-01f, 3.30519468e-01f, 1.87677085e-01f, 1.07418969e-01f, 2.68232524e-01f, 7.27089643e-02f, 9.03097093e-01f,
  2.43864059e-01f, -2.69827574e-01f, -2.24086672e-01f, 1.97470710e-01f, -1.17123529e-01f, -9.65055600e-02f, -4.45068888e-02f, 1.59664527e-01f, -2.10748672e-01f, 1.70660272e-01f,
  1.17526047e-01f, 9.81098861e-02f, 9.99134332e-02f, -8.93555768e-03f, -2.28461742e-01f, -2.66348839e-01f, 8.76505524e-02f, -9.78912041e-02f, -1.34624511e-01f, -2.38146737e-01f,
  3.46591651e-01f, 7.00398609e-02f, -4.38753724e-01f, -1.86082050e-01f, 3.93165685e-02f, 1.79618612e-01f, -2.41387218e-01f, 9.72797349e-02f, 2.41159927e-02f, 1.67017907e-01f,
  7.30219483e-02f, 2.11923830e-02f, 1.48531884e-01f, 3.71507667e-02f, -4.03463878e-02f, 4.64212410e-02f, 1.21355399e-01f, -4.35947925e-02f, 9.17031020e-02f, -1.30430192e-01f,
  3.16768396e-03f, 2.41058841e-02f, 8.18905979e-02f, -1.23741791e-01f, 5.90302097e-03f, 3.08511294e-02f, -2.67179646e-02f, 7.08988309e-02f, -6.76680505e-02f, 3.10938321e-02f,
  7.98486024e-02f, -9.14876089e-02f, 1.40457705e-01f, -2.35774219e-01f, 1.36421531e-01f, 5.80500029e-02f, 4.71109711e-02f, 2.18429472e-02f, 3.97873148e-02f, 4.21527028e-02f,
  -3.78420085e-01f, -4.26807255e-03f, 7.34750479e-02f, -3.35776694e-02f, 2.53348172e-01f, -8.91428292e-02f, 1.21186994e-01f, 5.61458655e-02f, 1.26360565e-01f, -3.56779933e-01f,
  -1.12567939e-01f, -1.18344553e-01f, 2.45783534e-02f, 1.67898294e-02f, -2.31027886e-01f, -1.01916060e-01f, 7.33906478e-02f, -2.05772445e-01f, 4.62151878e-02f, -2.57960688e-02f,
  -2.07114965e-02f, -2.98296899e-01f, -4.06410575e-01f, -1.67170733e-01f, 8.40115398e-02f, -1.15644962e-01f, -2.47325972e-01f, -1.84277683e-01f, -3.07029545e-01f, -5.13861775e-01f,
  -9.52585101e-01f, 2.06460208e-01f, 2.06762068e-02f, -3.10045868e-01f, -3.01711053e-01f, -2.68138170e-01f, 4.73841995e-01f, 7.90087506e-02f, -3.57691944e-01f, 2.93621331e-01f,
  1.08719967e-01f, -1.78331569e-01f, 1.46570593e-01f, -1.37784824e-01f, 2.84911208e-02f, 1.80620581e-01f, -2.45804578e-01f, -2.24658996e-01f, -4.13376123e-01f, -2.05470681e-01f,
  3.26827504e-02f, -6.22290149e-02f, -3.70791256e-01f, -3.17262143e-01f, 1.55660152e-01f, -3.71320434e-02f, 2.02286661e-01f, -2.15707123e-01f, -2.73655534e-01f, -5.64425066e-03f,
  1.42102480e-01f, -2.10680246e-01f, -2.15914533e-01f, -2.70329893e-01f, -3.50193083e-02f, 8.10144842e-03f, 9.44033489e-02f, 1.51305059e-02f, -2.73793489e-02f, -9.01591703e-02f,
  -6.19490743e-02f, -1.58436239e-01f, -6.03417344e-02f, 7.20332116e-02f, -2.58243307e-02f, -8.03851895e-03f, -4.30205017e-02f, -2.33670220e-01f, -2.20804825e-01f, 1.91550761e-01f,
  1.72628507e-01f, -5.17804772e-02f, -4.10186779e-03f, -2.86060404e-02f, 1.91514418e-02f, -1.77199885e-01f, 7.42966905e-02f, -3.42659861e-01f, -1.17806546e-01f, -4.90231067e-02f,
  7.43654147e-02f, 6.78820387e-02f, 2.47377269e-02f, 5.31402640e-02f, 5.13910055e-02f, 6.08396344e-03f, -5.66011146e-02f, -1.13958633e-02f, 7.93708563e-02f, 1.06285147e-01f,
  -1.96959116e-02f, 2.73984037e-02f, 1.04538329e-01f, -3.78778502e-02f, 8.99391472e-02f, -1.18247226e-01f, 8.80097225e-02f, 6.92139715e-02f, 1.74022093e-02f, -6.14468865e-02f,
  -1.13890588e-01f, 4.22506267e-03f, 3.48452069e-02f, 9.97133404e-02f, -1.22298330e-01f, 9.08095241e-02f, -8.04488286e-02f, 1.34096416e-02f, -6.88155368e-02f, -7.61208162e-02f,
  2.12552398e-01f, -1.90026656e-01f, 7.37262592e-02f, -4.43054549e-02f, -7.24098757e-02f, -2.80346666e-02f, 2.63007451e-02f, 1.75709669e-02f, -5.72898483e-04f, 9.59146768e-02f,
  -1.48887500e-01f, 5.72493151e-02f, 8.48376825e-02f, 5.24737015e-02f, -7.15856180e-02f, -5.26020303e-02f, 6.19955622e-02f, 1.87771972e-02f, -7.60496259e-02f, 2.40813047e-02f,
  -3.00340224e-02f, -8.92720148e-02f, 6.41179830e-02f, -4.19260794e-03f, 5.89179583e-02f, -2.24730205e-02f, 1.18774042e-01f, 2.89381072e-02f, -2.84010712e-02f, 4.26201969e-01f,
  -8.02475452e-01f, -5.03705144e-01f, 3.97130817e-01f, -1.08898126e-01f, 2.19727397e-01f, -1.92487091e-01f, -8.08720589e-01f, -4.67590809e-01f, 1.02796003e-01f, -2.36968279e-01f,
  2.47290343e-01f, 4.07669783e-01f, 1.24218985e-01f, -6.60277903e-02f, -5.41362584e-01f, -6.50845706e-01f, -4.17433739e-01f, -1.42019585e-01f, -1.13881612e-02f, -1.20082594e-01f,
  9.37364623e-02f, 2.64927566e-01f, 1.99399546e-01f, 8.05434883e-02f, -2.04965830e-01f, -8.53927247e-03f, -2.09721532e-02f, 1.19232535e-01f, -1.64119564e-02f, -2.13137820e-01f,
  -2.34773062e-04f, -2.83942968e-01f, 5.18243462e-02f, 3.00865504e-03f, 3.43318224e-01f, -1.42427348e-02f, -1.27230421e-01f, -4.60813418e-02f, -4.20529433e-02f, 1.48366336e-02f,
  3.45828593e-01f, 1.16157584e-01f, 1.85391337e-01f, 1.78986222e-01f, -5.44445328e-02f, -1.28753603e-01f, 7.70629197e-02f, -9.37992930e-02f, -1.08534247e-01f, -2.15302661e-01f,
  1.76545843e-01f, 1.48394272e-01f, -8.08077529e-02f, 2.90732197e-02f, -5.89547306e-02f, 1.77612171e-01f, 2.31123239e-01f, -2.57184021e-02f, -1.35072127e-01f, -4.06454325e-01f,
  4.22789566e-02f, 5.68193663e-03f, -1.00338377e-01f, -2.64641643e-02f, -1.47882113e-02f, 1.07530594e-01f, -9.66488495e-02f, -8.31607953e-02f, 1.11314066e-01f, -4.10805903e-02f,
  8.02359506e-02f, -6.81550754e-03f, 3.61135649e-03f, -9.94597971e-02f, -5.62373623e-02f, 1.84587657e-01f, -3.78873423e-02f, -1.35176912e-01f, -7.59378374e-02f, -1.34093329e-01f,
  -9.83321592e-02f, 7.56791681e-02f, 8.27541649e-02f, -1.87983662e-02f, 1.46512371e-02f, 3.53142209e-02f, 1.31426796e-01f, 1.30563632e-01f, 1.18419521e-01f, 1.03322461e-01f,
  -9.57087055e-02f, 3.83522928e-01f, -3.58173460e-01f, -1.54895643e-02f, -1.29584372e-01f, -1.54525399e-01f, 1.76856920e-01f, 9.92918238e-02f, 1.52329817e-01f, -1.72086969e-01f,
  -8.06363821e-02f, -4.93822917e-02f, -2.18386929e-02f, 8.15849826e-02f, 7.91141670e-03f, -3.05624679e-02f, -2.22500622e-01f, 1.48774348e-02f, -8.49326421e-03f, 1.16142675e-01f,
  -3.73934731e-02f, -4.54949915e-01f, -4.99515146e-01f, -3.98449630e-01f, -2.45977432e-01f, -5.00083089e-01f, -2.59890079e-01f, -2.49144971e-01f, -5.16345620e-01f, -7.22942352e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.66240290e-01f, -9.32535455e-02f, 2.48336911e-01f, 1.66103512e-01f, 3.54197443e-01f, 6.70869410e-01f, 9.39162225e-02f, 1.56786144e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.52598590e-01f, 1.60966307e-01f, 5.22879846e-02f, -2.37699732e-01f, -6.39623702e-02f, -2.32476577e-01f, 1.81192502e-01f, -2.40478180e-02f, 6.12543464e-01f, -4.34402883e-01f,
  -1.98002048e-02f, 1.44958898e-01f, 1.06288545e-01f, -1.14935845e-01f, -1.81236476e-01f, -1.81850433e-01f, 2.15348229e-02f, -7.24893138e-02f, -2.59070307e-01f, -1.86226740e-01f,
  -1.27696469e-01f, -4.70228970e-01f, 5.85462898e-02f, -1.04998291e-01f, 7.12917268e-01f, -3.30449045e-02f, -1.74376860e-01f, -5.03024340e-01f, -3.87669355e-01f, -3.59657705e-01f,
  3.79851431e-01f, 2.41389021e-01f, -2.21060570e-02f, -6.72061322e-03f, -4.05213609e-02f, 6.13328367e-02f, -1.72092184e-01f, -9.94214267e-02f, -2.83239573e-01f, 7.20165437e-04f,
  5.28951526e-01f, -2.88497478e-01f, 2.97245115e-01f, 2.90397912e-01f, -3.40110749e-01f, -2.04440340e-01f, 6.16032720e-01f, -1.79185823e-01f, 6.58822805e-02f, -1.41254202e-01f,
  -1.59519613e-01f, -1.09751992e-01f, -1.48496181e-01f, 2.27593377e-01f, -1.65834576e-02f, -1.20311640e-01f, -1.52074814e-01f, 3.76618326e-01f, -2.37115920e-01f, -2.31867403e-01f,
  2.10061356e-01f, 1.91827696e-02f, 6.92769945e-01f, -2.69212395e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.62632841e-01f, 1.25041306e-01f, 1.45479441e-01f, 7.44738579e-02f, 5.58135323e-02f, -7.74358869e-01f, 1.37801677e-01f, 5.54443374e-02f, 3.20403665e-01f, -2.24569425e-01f,
  -3.11363935e-01f, -8.14822435e-01f, -6.41699582e-02f, 6.42654657e-01f, 5.77130139e-01f, -7.67605565e-03f, 2.75270402e-01f, 4.19852078e-01f, 8.48729536e-02f, 1.72178343e-01f,
  8.36068415e-04f, 6.08646981e-02f, 2.89370209e-01f, -1.13602988e-01f, -5.37811995e-01f, -9.30050135e-01f, 8.15859064e-02f, 5.90513013e-02f, 6.31622136e-01f, 2.78115179e-02f,
  -5.48420548e-01f, -8.20181847e-01f, 2.27153838e-01f, 6.63943410e-01f, 6.41765654e-01f, 2.52471924e-01f, -7.58948088e-01f, -5.73376417e-01f, -1.21021643e-01f, -3.52258176e-01f,
  -4.01537167e-03f, 3.32207739e-01f, 3.45991671e-01f, 3.19734246e-01f, 1.78986713e-01f, 1.00648999e+00f, 5.36176264e-01f, 5.14213204e-01f, 1.87957764e-01f, 2.49687076e-01f,
  -4.24438298e-01f, 2.99805582e-01f, -6.66728318e-02f, 2.84303129e-01f, -3.94160122e-01f, -1.25355557e-01f, 2.42419168e-01f, 2.70858586e-01f, -1.02940835e-01f, 4.10535544e-01f,
  5.54705679e-01f, -2.82662183e-01f, -4.64623183e-01f, 3.67705464e-01f, 2.03005165e-01f, 2.02213719e-01f, -1.96637847e-02f, 2.91975290e-01f, 1.80872291e-01f, 3.73086542e-01f,
  -1.41494840e-01f, 2.60663591e-02f, -4.58898813e-01f, 7.76889801e-01f, -2.59378135e-01f, 9.93755236e-02f, 5.82949996e-01f, 2.89533406e-01f, -2.88889557e-01f, 6.70780122e-01f,
  1.87685207e-01f, 4.33728546e-01f, 6.46809265e-02f, 2.11433902e-01f, -1.69121578e-01f, 1.35578411e-02f, 3.56975384e-02f, 7.21637532e-02f, 1.90123871e-01f, -4.86241840e-02f,
  1.29404336e-01f, -9.62561965e-01f, 8.80511880e-01f, 1.87035933e-01f, 9.60709274e-01f, -8.31238866e-01f, 3.34843397e-01f, 3.81181002e-01f, 8.95312205e-02f, 2.62938291e-01f,
  -1.94311455e-01f, 4.58320200e-01f, -2.40605641e-02f, 6.97152540e-02f, -5.25259018e-01f, 4.27692443e-01f, 4.13319349e-01f, 8.11099172e-01f, -3.55612963e-01f, 1.48592591e-01f,
  2.10738763e-01f, -9.90714133e-03f, 3.69005859e-01f, 5.22042572e-01f, 3.51317495e-01f, 4.03456688e-01f, -2.32474387e-01f, -5.63449502e-01f, 3.64625335e-01f, -2.03464881e-01f,
  4.84202355e-01f, -5.42507172e-01f, -4.15164828e-02f, 7.93091953e-01f, -1.48353696e-01f, 6.51174963e-01f, -1.82926375e-02f, 2.79951185e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.65609354e-01f, 2.29368761e-01f, 5.88884294e-01f, -6.75214455e-02f, 2.13477597e-01f, 4.55318242e-01f, 5.38383536e-02f, 1.50456473e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.34795964e-01f, -4.64412302e-01f, -3.93738151e-01f, -3.21567923e-01f, -3.81298596e-03f, -1.53330058e-01f, 5.79235137e-01f, -3.22174668e-01f, -5.21482825e-01f, 2.36145660e-01f,
  -2.88554758e-01f, 3.56381118e-01f, 8.83214474e-02f, -1.07392669e-01f, 4.50645298e-01f, -5.99336252e-02f, 1.32732719e-01f, -7.80222788e-02f, 2.92075306e-01f, 1.60687536e-01f,
  6.87422156e-02f, 3.13624769e-01f, 5.02443671e-01f, -5.32007754e-01f, -1.58313408e-01f, -3.14950235e-02f, -5.26683740e-02f, 2.00743809e-01f, -7.76008368e-02f, -3.27073544e-01f,
  4.31441255e-02f, 4.04102981e-01f, -9.60711837e-02f, -2.88903750e-02f, -2.27079257e-01f, 2.69870192e-01f, 3.78300756e-01f, -3.02347094e-01f, -5.02463877e-01f, -8.49104226e-02f,
  -3.74438465e-01f, 5.38854837e-01f, -8.69742036e-02f, 3.14015567e-01f, 3.02584946e-01f, -9.23249125e-02f, -1.26545742e-01f, 8.15556478e-03f, -2.62268364e-01f, -1.81988329e-01f,
  2.52666742e-01f, 2.15037718e-01f, 4.21091646e-01f, -5.72688282e-01f, -5.43613732e-01f, -3.16756278e-01f, 3.64315629e-01f, -2.09221747e-02f, 8.76158923e-02f, 4.59350273e-02f,
  -2.58179605e-01f, 1.13839082e-01f, -2.51985192e-01f, 4.06960040e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.43824118e-01f, -5.15175834e-02f, 4.31113750e-01f, 3.12000096e-01f, -2.37833172e-01f, -8.84630084e-01f, -8.33714306e-01f, 1.02971697e+00f, 1.00373492e-01f, 7.37805307e-01f,
  4.14926857e-01f, 3.12589318e-01f, 6.66963398e-01f, 8.41852963e-01f, -9.96515229e-02f, -1.79745644e-01f, -3.47265035e-01f, 2.41733119e-01f, -1.00595944e-01f, -6.70361146e-02f,
  -1.22706637e-01f, -6.47383153e-01f, 8.42194259e-01f, -2.88169365e-02f, -4.07246649e-01f, -7.57737756e-01f, -3.37292887e-02f, 4.25310731e-01f, 4.65398580e-01f, -9.75546241e-02f,
  3.63411188e-01f, -5.44692457e-01f, -6.24341965e-01f, -3.47199053e-01f, -3.17207649e-02f, -1.68241933e-02f, -4.42392260e-01f, -2.13773862e-01f, 2.52710164e-01f, 6.65545881e-01f,
  -8.20603609e-01f, -3.34157854e-01f, 1.74981073e-01f, 5.16776502e-01f, 4.73363429e-01f, 1.38940632e-01f, 4.27778102e-02f, -3.35102797e-01f, -2.37612039e-01f, -2.38109395e-01f,
  4.24938977e-01f, -2.66767502e-01f, 4.17667180e-01f, -2.79951304e-01f, -4.91195358e-02f, -5.52715898e-01f, 3.12947541e-01f, 1.71000198e-01f, 4.24250811e-01f, -2.97209501e-01f,
  -1.33491129e-01f, -6.47812430e-03f, 5.50723433e-01f, 8.95447910e-01f, 2.11458784e-02f, 6.99160576e-01f, 2.40336120e-01f, 3.02073926e-01f, 6.78000525e-02f, 3.62098068e-02f,
  -2.05375448e-01f, 2.59329200e-01f, 3.71350706e-01f, -8.78658354e-01f, 7.77090907e-01f, 4.44952160e-01f, 7.58611023e-01f, -9.91016984e-01f, -1.42202228e-01f, 3.17948192e-01f,
  -9.77258012e-02f, -3.53379399e-01f, 4.67217535e-01f, -6.26346022e-02f, -6.60544354e-03f, 9.59962904e-02f, 2.92861491e-01f, -8.93040061e-01f, -6.17510557e-01f, -3.04810554e-01f,
  5.13981342e-01f, -2.08335906e-01f, 1.14391670e-01f, -3.60092372e-01f, 7.33619213e-01f, 4.68280137e-01f, -1.19047672e-01f, 2.24174663e-01f, 5.51988542e-01f, -6.46806359e-02f,
  1.43302321e-01f, 4.95604366e-01f, 5.82236290e-01f, 1.38357073e-01f, 5.86454690e-01f, -6.46625683e-02f, 3.01436096e-01f, -5.98597050e-01f, -6.12011909e-01f, 1.00240004e+00f,
  -9.77897495e-02f, 9.65890884e-02f, -8.62167180e-01f, 6.58268631e-01f, -1.58003941e-02f, 4.20348138e-01f, 4.66385871e-01f, -3.46184105e-01f, 6.25568509e-01f, 5.34555092e-02f,
  2.80116051e-01f, -3.30524266e-01f, 5.25437929e-02f, 4.43045080e-01f, -1.20052569e-01f, 1.98346991e-02f, -3.24253052e-01f, 4.00307983e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.05798018e-01f, -2.67293528e-02f, -2.57017881e-01f, 6.01367317e-02f, -9.32416692e-02f, 2.24202439e-01f, 2.56636590e-01f, 1.25178978e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -9.07292068e-01f, 3.45543355e-01f, 1.30887121e-01f, -4.87056315e-01f, 8.86717364e-02f, -5.35889082e-02f, -7.23782718e-01f, 2.71854997e-02f, -2.80342162e-01f, 2.36813962e-01f,
  9.59619135e-02f, 1.93538070e-01f, -1.47621095e-01f, 3.33365113e-01f, 4.23657745e-01f, -2.12737009e-01f, 8.14574242e-01f, 5.74575841e-01f, 4.88428235e-01f, 4.45690244e-01f,
  3.66007626e-01f, 1.32269979e-01f, -2.76602209e-01f, -6.24806136e-02f, 5.21909557e-02f, 2.92644631e-02f, 2.76974998e-02f, -2.42487565e-01f, 2.43478149e-01f, 1.68780342e-01f,
  -2.16123775e-01f, 4.58074868e-01f, 1.43255711e-01f, -1.66427359e-01f, 6.82748437e-01f, 3.00904632e-01f, 1.61267474e-01f, 5.29734343e-02f, 5.15123785e-01f, 3.50829810e-01f,
  9.68888402e-02f, 1.06118331e-02f, 2.56214082e-01f, -2.05451995e-01f, 5.19799329e-02f, 4.33587283e-01f, -8.74105617e-02f, -5.30822933e-01f, -4.17893492e-02f, -3.80966097e-01f,
  -4.26702619e-01f, -2.40914747e-01f, 6.26091480e-01f, -8.69628668e-01f, 4.80703801e-01f, -4.38872017e-02f, 3.00798029e-01f, 8.96829367e-02f, -2.64239728e-01f, 6.44378886e-02f,
  -3.36367637e-01f, -1.91407055e-01f, -4.18099940e-01f, 4.34464246e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  1.55928940e-01f, -1.71483263e-01f, -4.84882414e-01f, -4.48845387e-01f, 2.62467653e-01f, 3.39582592e-01f, -8.75623763e-01f, -5.30693054e-01f, -1.09018110e-01f, 6.66669011e-01f,
  4.17149633e-01f, -8.96925986e-01f, 1.55806407e-01f, -6.24053121e-01f, 1.20406158e-01f, 3.01898956e-01f, 2.12242901e-01f, -1.64402366e-01f, 5.13545573e-01f, -6.19322717e-01f,
  -1.08568721e-01f, -3.58015150e-01f, 1.29106653e+00f, 8.52921605e-01f, 5.66566586e-01f, -9.91913140e-01f, -2.46457636e-01f, 4.14432496e-01f, 1.48709148e-01f, 2.75973231e-01f,
  -5.08964419e-01f, -4.27385598e-01f, 7.45140553e-01f, -2.72457033e-01f, 2.12034136e-01f, 9.31790173e-02f, 1.47557527e-01f, 5.88622749e-01f, -3.26254576e-01f, 1.93191152e-02f,
  -4.20021266e-01f, 3.35089952e-01f, 3.13534252e-02f, 7.68507898e-01f, 5.48243642e-01f, 8.74267399e-01f, -3.52800041e-01f, -9.13726985e-02f, 1.20237030e-01f, -1.36875004e-01f,
  -5.14066935e-01f, 1.80745572e-01f, 1.87048748e-01f, -9.30705547e-01f, -6.95590675e-01f, -5.71370840e-01f, 4.25572991e-01f, 4.52978015e-01f, 3.18039536e-01f, 8.60605612e-02f,
  4.38521355e-02f, -3.28776449e-01f, 1.24682617e+00f, 1.35079294e-01f, 2.93813348e-01f, 1.99060559e-01f, -1.51160751e-02f, 2.12399125e-01f, 3.61502282e-02f, -1.68955877e-01f,
  3.01282723e-02f, -2.71747261e-01f, 7.44916856e-01f, 4.00385499e-01f, 6.39044821e-01f, 1.82779163e-01f, 1.60925537e-01f, 1.01739407e-01f, 4.36588854e-01f, -1.07329261e+00f,
  6.29849494e-01f, -6.56548619e-01f, -2.99781710e-01f, -6.19821429e-01f, 3.62398833e-01f, 4.97698307e-01f, 5.47907911e-02f, -3.32901716e-01f, -9.53215599e-01f, 5.35924966e-03f,
  -3.49082887e-01f, 5.92485785e-01f, -1.11722900e-02f, 4.01555300e-01f, 6.00918770e-01f, 7.30324924e-01f, -1.44949424e+00f, -1.16748340e-01f, 6.18591547e-01f, -7.98168242e-01f,
  -7.82310307e-01f, 6.36958957e-01f, 5.63627541e-01f, -3.20146441e-01f, 2.61216819e-01f, -2.43581057e-01f, -5.43473184e-01f, 5.32750003e-02f, 5.26219726e-01f, -3.77485633e-01f,
  3.13621968e-01f, 1.09453750e+00f, -5.99250019e-01f, 2.43107572e-01f, -1.28243908e-01f, -2.42765576e-01f, 2.10594773e-01f, -6.44323647e-01f, -1.59998208e-01f, -8.07036817e-01f,
  2.67271012e-01f, 8.08681905e-01f, 4.03252602e-01f, -6.07730113e-02f, 1.13442862e+00f, -1.58670787e-02f, -5.92021704e-01f, -1.32308587e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -2.03649938e-01f, 4.13002491e-01f, -4.24374826e-02f, 2.42194794e-02f, 4.39437509e-01f, 8.91736597e-02f, 3.11147124e-02f, -3.83351177e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.69348265e-02f, -5.62325493e-02f, 5.52452505e-01f, 3.14478837e-02f, -4.08633530e-01f, 3.74599457e-01f, 3.47739793e-02f, -1.10339016e-01f, 9.06917691e-01f, -5.46062589e-01f,
  -5.63400149e-01f, 2.01138332e-01f, -4.23835665e-02f, -2.62893468e-01f, -7.77742565e-02f, 3.41466844e-01f, -2.37015218e-01f, 7.32188940e-01f, -1.25845134e-01f, -9.44795549e-01f,
  1.15333152e+00f, 5.68281233e-01f, 5.75101256e-01f, -4.12335068e-01f, -6.32398963e-01f, 2.63519138e-01f, -3.40466462e-02f, 2.02137575e-01f, 2.05231875e-01f, -1.92856953e-01f,
  -9.32882011e-01f, -2.31089890e-01f, 2.51235753e-01f, -4.13835287e-01f, 5.40379137e-02f, -4.52304035e-01f, 1.52900517e-01f, 3.01352113e-01f, 2.68921405e-01f, -4.78524089e-01f,
  7.54235592e-03f, 4.66260642e-01f, 1.86121121e-01f, -1.01119566e+00f, -4.77378398e-01f, -8.80343199e-01f, 5.51193237e-01f, 3.31268102e-01f, -1.13665268e-01f, -4.00851816e-01f,
  -4.56946641e-01f, -5.25306389e-02f, -4.93379235e-01f, -5.16751289e-01f, -1.49177170e+00f, 5.94207585e-01f, -8.55611622e-01f, -4.26618159e-01f, 3.82799417e-01f, -9.40910429e-02f,
  2.85650432e-01f, -1.23773885e+00f, -9.07722831e-01f, 3.15621197e-01f, -4.44149703e-01f, -1.94848299e-01f, -6.47527814e-01f, 8.33575845e-01f, 8.51965964e-01f, 3.52114052e-01f,
  2.43039325e-01f, -6.31549895e-01f, -7.62047231e-01f, -1.21433392e-01f, -3.02214384e-01f, 6.45856932e-02f, -9.79790092e-02f, -3.78451169e-01f, 4.09852237e-01f, 5.05703926e-01f,
  -2.47635648e-01f, 4.05769870e-02f, 4.78671968e-01f, -1.26400545e-01f, -2.78664172e-01f, -1.14493597e+00f, 1.84401125e-01f, 6.86562419e-01f, 4.21252325e-02f, 2.33677715e-01f,
  -7.09308982e-01f, 7.09214434e-02f, 1.57107681e-01f, -2.65754282e-01f, 6.64491951e-01f, -9.27778542e-01f, -2.03776181e-01f, 5.42265117e-01f, -2.98447758e-01f, 2.13235140e-01f,
  -3.07153106e-01f, 1.42318681e-01f, 6.87939167e-01f, -4.39081639e-01f, -2.15460718e-01f, -9.17862833e-01f, -2.32143551e-01f, 1.61225349e-01f, -6.53420866e-01f, 4.45423424e-01f,
  6.28060758e-01f, -5.97023010e-01f, -2.37685926e-02f, 8.18872601e-02f, 1.01870440e-01f, -2.20656529e-01f, 2.98468750e-02f, -2.36034513e-01f, 2.61105001e-01f, 3.86149913e-01f,
  3.70380819e-01f, -1.17847733e-01f, 5.93958139e-01f, -3.88775855e-01f, -1.87154397e-01f, 3.20124984e-01f, -1.11657524e+00f, -1.78107724e-01f, -4.25055385e-01f, 4.41213667e-01f,
  -7.94959515e-02f, 1.27741992e+00f, -1.01085031e+00f, 1.10171032e+00f, 9.18078184e-01f, 1.16492474e+00f, 3.52415621e-01f, 7.45722532e-01f, -3.33876878e-01f, -1.03687346e+00f,
  3.58927011e-01f, -4.49085891e-01f, -7.68820047e-01f, -1.05195951e+00f, 4.27911617e-02f, -2.20751509e-01f, 2.69123584e-01f, -4.71878231e-01f, 9.87739116e-02f, -3.82390529e-01f,
  -1.31715643e+00f, 6.65124953e-01f, 1.97985440e-01f, -2.35742584e-01f, 1.47194907e-01f, -2.16439202e-01f, -2.42824987e-01f, 1.66662261e-01f, 4.06702697e-01f, 2.08357066e-01f,
  1.71316043e-03f, 7.91726783e-02f, -2.32575104e-01f, 6.96569741e-01f, 7.41563022e-01f, -1.35554612e+00f, -1.15966356e+00f, -5.85303009e-01f, -3.47131379e-02f, -1.12295449e+00f,
  -8.46184671e-01f, 9.64143574e-01f, -4.43540066e-02f, -9.27866027e-02f, -7.67602026e-01f, -5.23942113e-01f, 4.64529991e-01f, -6.40240788e-01f, 4.18998122e-01f, 2.89621025e-01f,
  7.83784628e-01f, 3.53542417e-01f, 3.08889925e-01f, -7.42214978e-01f, 3.30193460e-01f, 2.64219224e-01f, 4.38753337e-01f, -1.05408788e+00f, -1.60448158e+00f, 4.98922259e-01f,
  3.46431077e-01f, -4.09381598e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.10070014e-02f, 3.42244685e-01f, -2.30545685e-01f, -6.55974150e-01f, -2.10197061e-01f, 2.49592960e-02f, 3.10077488e-01f, -7.91634172e-02f, 3.56512994e-01f, -3.25638056e-01f,
  -1.15691416e-01f, -4.34996150e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    