/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.90670211e-02f, -1.52583167e-01f, -5.28280497e-01f, -8.55077878e-02f, -6.35890737e-02f, -1.81215517e-02f, -9.94423553e-02f, 1.30026415e-01f, 2.92270780e-01f, 8.60806555e-02f,
  1.23277679e-01f, 2.72529393e-01f, 4.18606475e-02f, 1.87508866e-01f, 1.34346515e-01f, -1.83300972e-01f, -2.76500851e-01f, -9.10627767e-02f, 1.11650631e-01f, 1.89726785e-01f,
  1.07526407e-01f, 7.29161054e-02f, 9.75257065e-03f, 8.04031119e-02f, 1.25631317e-01f, 2.16481894e-01f, -8.41241777e-02f, -7.58722946e-02f, -4.31779921e-02f, -1.18131824e-01f,
  -2.48844862e-01f, -3.46455574e-01f, 3.96041572e-02f, 7.53293484e-02f, -6.43288791e-02f, 7.17257848e-03f, 5.03109731e-02f, -9.72409844e-02f, -1.69961364e-03f, 6.64291829e-02f,
  -3.66370976e-02f, -2.18793340e-02f, -1.98548120e-02f, 4.70345616e-02f, 5.98694645e-02f, 3.21934535e-03f, -1.37844816e-01f, -2.03211218e-01f, -1.71984389e-01f, -5.30280061e-02f,
  -4.60465159e-03f, 4.21922617e-02f, -3.75193991e-02f, 4.72662449e-02f, -1.21434242e-01f, -3.30385566e-02f, -4.98383641e-02f, 3.14386263e-02f, -6.83132485e-02f, 1.35440439e-01f,
  -7.72699192e-02f, 1.28123751e-02f, -3.07474826e-02f, -1.30483946e-02f, 1.38009831e-01f, 6.46983162e-02f, 3.98429781e-02f, -4.05260548e-02f, 1.22013018e-01f, 1.28881978e-02f,
  -6.75803870e-02f, -3.12263798e-02f, 1.67252570e-02f, -8.03819895e-02f, 1.35783076e-01f, 2.38064043e-02f, 9.82912555e-02f, -2.06378549e-02f, -3.44652273e-02f, -3.83351333e-02f,
  2.27786880e-02f, 4.30973396e-02f, -1.15715740e-02f, 1.75059668e-03f, -1.85964734e-03f, -4.25554141e-02f, 7.84329232e-03f, 3.74011211e-02f, 7.80549496e-02f, 8.01334623e-03f,
  1.10509180e-01f, -1.80288643e-01f, -2.02286839e-02f, 2.46162917e-02f, 1.03950389e-01f, 4.19342071e-02f, -7.19163045e-02f, 2.31800489e-02f, -2.99968477e-02f, 1.19009249e-01f,
  -3.58866230e-02f, 1.38978716e-02f, -4.25546914e-02f, 5.17179742e-02f, -1.43599799e-02f, 6.33928552e-02f, 1.83649704e-01f, -5.12506999e-02f, 1.21906564e-01f, -1.01887584e-01f,
  3.40224393e-02f, 2.02460855e-01f, 1.80795804e-01f, 1.24043755e-01f, 1.17836632e-01f, 8.66058245e-02f, 1.44871399e-01f, 2.35988330e-02f, 1.44561723e-01f, 2.60909438e-01f,
  6.02105319e-01f, 1.33712530e-01f, 2.01399833e-01f, -6.71621561e-02f, -4.10577476e-01f, -1.78684771e-01f, -2.56899506e-01f, -6.38649017e-02f, -1.57913700e-01f, -1.51940227e-01f,
  1.59027994e-01f, 2.92085707e-01f, 3.57761562e-01f, 1.56391233e-01f, 2.41784349e-01f, -1.47949755e-01f, -2.63407439e-01f, 1.94399133e-01f, 1.74509034e-01f, -1.34168491e-01f,
  -1.85263947e-01f, -8.04085582e-02f, 1.72821730e-01f, 1.10137902e-01f, -1.50423512e-01f, -5.77956289e-02f, -1.29259646e-01f, -6.92041367e-02f, -6.28976477e-03f, -1.55469671e-01f,
  3.31641674e-01f, 1.83181942e-01f, 3.69434282e-02f, 6.06627315e-02f, -2.03987081e-02f, 1.17527552e-01f, -5.56659475e-02f, 1.23403044e-02f, -1.00812095e-03f, 9.87292826e-02f,
  -3.76645811e-02f, 1.78376827e-02f, 1.57110587e-01f, -2.28856206e-02f, -3.36397849e-02f, -6.97996514e-03f, -6.24378491e-03f, 2.13576943e-01f, 1.04637109e-01f, 1.38832808e-01f,
  -4.70919870e-02f, 1.79660264e-02f, 4.61151227e-02f, 3.00567243e-02f, 1.18563399e-01f, 1.03667624e-01f, 2.44927388e-02f, -3.72677185e-02f, 6.70578629e-02f, 4.71942611e-02f,
  1.27868997e-02f, 3.15204635e-02f, -1.15978256e-01f, -4.20455635e-02f, -2.00015632e-03f, -1.05414905e-01f, -9.10741836e-02f, -3.54158320e-02f, -1.56598568e-01f, 1.62195100e-03f,
  2.72465199e-02f, -7.43177235e-02f, -3.93653810e-02f, -9.83362198e-02f, 8.02652631e-03f, -3.02835386e-02f, -6.55996650e-02f, 1.40439649e-03f, 6.24730345e-03f, -1.18563838e-01f,
  -5.33725768e-02f, -1.20061496e-02f, -8.27453956e-02f, -2.52167974e-02f, -2.35683583e-02f, -1.05795544e-02f, -1.05707711e-02f, -7.79972970e-02f, -5.15298657e-02f, -1.54968917e-01f,
  -1.21538706e-01f, 9.45795029e-02f, 8.82230252e-02f, 1.44282386e-01f, 4.63817269e-02f, 1.48371935e-01f, 1.61595672e-01f, 2.49378886e-02f, 8.32531378e-02f, 2.13177106e-03f,
  7.61976019e-02f, 1.24612220e-01f, 1.83654409e-02f, 5.29144816e-02f, -4.33406346e-02f, 9.19700786e-03f, -2.16909759e-02f, 1.54139176e-01f, 1.27520123e-02f, -2.22556032e-02f,
  9.66122076e-02f, 2.01474316e-02f, -2.78939493e-02f, 1.64223254e-01f, -3.44115272e-02f, 2.57055983e-02f, 2.61787008e-02f, 3.69893648e-02f, 1.79525930e-02f, -2.84681246e-02f,
  2.19250038e-01f, -2.87760288e-01f, 1.99095104e-02f, 3.36798932e-03f, 9.74996909e-02f, 2.05741659e-01f, 1.91456854e-01f, 1.47922069e-01f, -7.56994411e-02f, -1.15000434e-01f,
  -2.05679342e-01f, -1.21073589e-01f, -1.77724555e-01f, -4.73883376e-02f, 1.83500215e-01f, 1.05215600e-02f, 9.17484909e-02f, 2.70915061e-01f, 3.33771855e-01f, 9.09546837e-02f,
  -1.08183689e-01f, 4.52996157e-02f, 8.70367512e-02f, 1.08569905e-01f, -2.83456445e-01f, -6.23687916e-02f, -1.51199177e-01f, -6.51308000e-02f, -8.69601890e-02f, -3.73420775e-01f,
  -1.80515110e-01f, -1.76469181e-02f, 2.06355885e-01f, 4.34262790e-02f, 8.85788817e-03f, 3.83993275e-02f, -8.15822743e-03f, -3.05248052e-02f, -1.12378341e-03f, -5.95075823e-02f,
  -1.02973043e-03f, 6.96121454e-02f, -2.33585052e-02f, -1.58771574e-02f, 5.74820936e-02f, 1.43981531e-01f, -2.60218326e-02f, 2.30251513e-02f, 8.05215985e-02f, -3.05887330e-02f,
  -2.44010817e-02f, -1.61144864e-02f, 1.16226628e-01f, 1.54184345e-02f, 2.33341902e-01f, 3.56674977e-02f, 4.25075516e-02f, -1.69148948e-02f, 1.21523157e-01f, -8.13382119e-02f,
  -3.49124186e-02f, -2.55543832e-02f, -1.06308714e-01f, -1.89862084e-02f, -1.05690539e-01f, -1.07686013e-01f, -3.76707350e-04f, -8.66607726e-02f, -3.33602726e-02f, -1.91600472e-02f,
  -1.44415423e-02f, -9.65077281e-02f, 2.21205261e-02f, 1.11217611e-02f, -9.15826634e-02f, -1.25905648e-01f, 2.81376950e-02f, -5.35492823e-02f, -8.95054638e-02f, -6.90711364e-02f,
  4.00661081e-02f, -2.35179253e-03f, 2.55795456e-02f, -5.90838380e-02f, -1.92306750e-03f, 9.16791558e-02f, 2.66675353e-02f, -1.17032286e-02f, 3.86752712e-04f, 6.16538972e-02f,
  -1.81913212e-01f, 2.22889647e-01f, -1.22583687e-01f, 7.41290674e-02f, -2.41748057e-02f, -5.96477538e-02f, 3.55043001e-02f, -5.67803644e-02f, -1.92907676e-02f, -2.18839515e-02f,
  3.96560803e-02f, 3.36151496e-02f, -8.01836997e-02f, -4.62901480e-02f, 9.35564861e-02f, 6.81008724e-03f, -2.03633551e-02f, -7.36388266e-02f, 7.73338377e-02f, -3.55273075e-02f,
  -2.00836174e-02f, 7.24974796e-02f, 4.50022519e-02f, 8.25853180e-03f, -7.98087493e-02f, 4.51079495e-02f, 1.75282136e-02f, -2.64291614e-02f, 1.75245404e-01f, -1.89515222e-02f,
  -3.76895398e-01f, 9.43677798e-02f, -2.68455058e-01f, -4.67762321e-01f, -3.86589468e-01f, -3.05546165e-01f, 1.90988015e-02f, -1.45003155e-01f, -2.53749430e-01f, -9.21844989e-02f,
  -6.42806739e-02f, -7.92642832e-02f, -1.12806603e-01f, -6.29644245e-02f, 4.39376459e-02f, -2.05076277e-01f, -1.96159333e-01f, -1.24215797e-01f, -1.62464753e-01f, -2.58501142e-01f,
  -1.63338661e-01f, -3.23686630e-01f, -2.95282215e-01f, -1.56283766e-01f, -1.03873067e-01f, -1.34509414e-01f, -3.70813459e-02f, -1.29470602e-01f, -1.38617203e-01f, -2.83513755e-01f,
  -1.71890706e-01f, -1.46456689e-01f, -1.71453565e-01f, -1.98278129e-01f, -1.14236787e-01f, -1.57984242e-01f, -5.35055585e-02f, -1.93240777e-01f, -9.96478796e-02f, -1.18737698e-01f,
  -1.61845610e-01f, -1.17373206e-01f, -9.14734006e-02f, -4.34258394e-02f, -2.23722473e-01f, -2.50546843e-01f, -8.05325583e-02f, -1.40109763e-01f, -6.35952428e-02f, -5.71625046e-02f,
  -1.30335093e-01f, -3.92319597e-02f, -6.97649494e-02f, -4.55187401e-03f, -2.60362551e-02f, -8.69552270e-02f, -5.75934984e-02f, -7.43827820e-02f, -1.18621603e-01f, 2.15933062e-02f,
  -2.19072234e-02f, 7.37999752e-02f, 4.65509370e-02f, 3.47938612e-02f, 6.99673742e-02f, 8.37625116e-02f, -7.99622759e-02f, 6.91899955e-02f, 1.58267975e-01f, 5.97448349e-02f,
  1.06085420e-01f, -1.43825104e-02f, 4.77240309e-02f, 9.22646448e-02f, -6.80907676e-03f, -1.53865777e-02f, 1.75936129e-02f, 2.60392036e-02f, 1.56002669e-02f, -6.83540702e-02f,
  -1.01162218e-01f, 6.09677285e-02f, 1.19215623e-02f, 1.39965927e-02f, -7.89311379e-02f, -2.54874472e-02f, -4.57751155e-02f, 1.42183825e-01f, 6.76654726e-02f, 3.33402157e-02f,
  -1.20040469e-01f, -1.02635108e-01f, -2.65010744e-01f, -2.15974420e-01f, -2.31765792e-01f, -1.14134364e-01f, -1.99978992e-01f, -1.99145779e-01f, -1.07958503e-01f, -2.75584072e-01f,
  -1.76441282e-01f, -1.37817979e-01f, -1.45625278e-01f, -7.18152197e-03f, -1.22147344e-01f, -2.29903251e-01f, -1.58633605e-01f, -1.19215526e-01f, -1.39043346e-01f, -8.69611874e-02f,
  3.06788404e-02f, -1.26639485e-01f, 4.24910821e-02f, -1.01229824e-01f, -1.67393416e-01f, -1.16558686e-01f, -9.26304758e-02f, -8.09496939e-02f, -6.97939694e-02f, -3.92508954e-02f,
  2.80987322e-01f, 1.01959862e-01f, 7.44944066e-02f, 2.84110844e-01f, -4.29392159e-02f, -1.04655594e-01f, -3.05944145e-01f, -7.78914243e-02f, 1.05538055e-01f, 6.03615083e-02f,
  -4.59750518e-02f, 3.08559253e-03f, -5.11748493e-02f, -1.12495340e-01f, -2.90783554e-01f, -1.61672950e-01f, -9.99531150e-02f, -1.62264347e-01f, -2.30734587e-01f, -2.83284187e-01f,
  -1.68747216e-01f, 1.03581160e-01f, 3.75084057e-02f, 2.34811381e-02f, 1.67525530e-01f, -4.51943763e-02f, 1.48078814e-01f, 1.40759632e-01f, -4.28651348e-02f, 1.06869176e-01f,
  1.86273247e-01f, 8.38714987e-02f, -7.48707056e-02f, 9.97024402e-02f, 1.32192835e-01f, -6.11996558e-03f, 6.53041154e-02f, 7.29812309e-02f, 6.54390529e-02f, 6.96066320e-02f,
  8.72769728e-02f, 7.30484053e-02f, 7.75587484e-02f, 3.14593054e-02f, 2.48430017e-02f, 7.65624344e-02f, 1.61374837e-01f, 7.62279937e-03f, -2.88790409e-02f, 5.13699278e-02f,
  3.35577503e-02f, 2.36859526e-02f, 1.24407232e-01f, 1.70542389e-01f, 1.58421472e-01f, 1.23340778e-01f, 8.87509882e-02f, 8.58658031e-02f, 1.65018886e-01f, 1.31862730e-01f,
  -2.17867289e-02f, 1.17374882e-01f, -6.70005903e-02f, -1.11576520e-01f, 3.62531766e-02f, 1.56219285e-02f, -1.55438567e-02f, 1.66340899e-02f, -1.05275825e-01f, 4.93840687e-02f,
  -2.49755010e-02f, -1.14710726e-01f, -9.74298269e-02f, -6.24610018e-03f, 1.10112196e-02f, 3.33408974e-02f, -9.41014588e-02f, -1.29466519e-01f, -5.90992831e-02f, -3.13283242e-02f,
  1.06807603e-02f, -1.88503899e-02f, 8.19540620e-02f, -3.76787148e-02f, -3.57895121e-02f, -4.74385694e-02f, -3.57669406e-02f, -3.46905515e-02f, 2.60716472e-02f, 2.73110438e-02f,
  2.68503934e-01f, -9.34377238e-02f, 9.66159999e-02f, -6.16797358e-02f, 3.05274017e-02f, 6.79495856e-02f, 1.74478382e-01f, -8.93945619e-03f, 8.04991275e-02f, 1.25919253e-01f,
  5.50172739e-02f, 3.96404043e-02f, 4.86701541e-02f, 1.09019903e-02f, 4.36461391e-03f, 2.95935548e-03f, 3.78152579e-02f, 1.86336809e-03f, -1.06219172e-01f, 1.15192786e-01f,
  1.32543430e-01f, -1.41124979e-01f, -5.08044511e-02f, 2.34936047e-02f, 6.54260665e-02f, 3.39108109e-02f, -1.70873459e-02f, -6.62870472e-03f, -9.38070565e-02f, -4.98867594e-02f,
  -1.72285095e-01f, 1.56030253e-01f, -6.54260144e-02f, -1.19958490e-01f, 7.63815567e-02f, 1.42362505e-01f, 1.53750852e-01f, 4.09993008e-02f, -7.56466836e-02f, -7.42288493e-03f,
  6.24466687e-02f, 5.22004664e-02f, -1.60195127e-01f, -6.10289648e-02f, -2.06006393e-01f, -2.77977258e-01f, -2.91617364e-01f, -4.10209090e-01f, -1.48174554e-01f, -8.34093168e-02f,
  -4.18068990e-02f, -1.13216445e-01f, -1.11873329e-01f, -6.17520884e-02f, -9.69370902e-02f, -1.24166608e-01f, -6.91251010e-02f, -1.67530715e-01f, -1.28410771e-01f, -3.46255422e-01f,
  -1.73161209e-01f, 4.54620086e-02f, -3.03100515e-02f, -1.07123740e-01f, -1.05274349e-01f, -8.09810683e-02f, -5.43064065e-02f, -1.88492835e-01f, -1.66375071e-01f, -1.17874309e-01f,
  -4.41835895e-02f, 3.31293121e-02f, -1.62641957e-01f, -1.19576260e-01f, -1.51024476e-01f, -1.22838788e-01f, -1.20066911e-01f, -5.71880937e-02f, -5.56986742e-02f, -1.00096688e-01f,
  -9.07253176e-02f, -1.22500643e-01f, -2.51350552e-01f, 4.77796560e-03f, -1.29057929e-01f, -2.46731356e-01f, -4.34617735e-02f, -1.81793109e-01f, -1.55454008e-02f, -5.10223545e-02f,
  8.64139479e-03f, 5.30451946e-02f, 3.16577889e-02f, 4.16322723e-02f, 1.06594488e-01f, 4.62406687e-02f, -7.29744956e-02f, -5.71385697e-02f, -1.83376167e-02f, 8.99157003e-02f,
  8.19246620e-02f, -7.49978647e-02f, -9.04263109e-02f, -6.58007711e-02f, 3.66593036e-03f, -6.04460724e-02f, -5.08172922e-02f, -1.25455767e-01f, -1.15323430e-02f, -2.54927482e-02f,
  1.22101426e-01f, 6.55827969e-02f, -1.57940704e-02f, -4.84320298e-02f, -4.04009111e-02f, -6.56835437e-02f, -1.86786167e-02f, -1.46752624e-02f, 9.26549882e-02f, -1.72100607e-02f,
  -7.90803507e-03f, 8.18466675e-03f, -1.72162622e-01f, -2.28744045e-01f, -1.57817110e-01f, -1.21940807e-01f, -1.23233892e-01f, -1.69831648e-01f, 2.26404052e-02f, -5.72809912e-02f,
  2.95554213e-02f, -3.12143490e-02f, -8.73812139e-02f, -1.34914204e-01f, -7.67913684e-02f, -1.09856933e-01f, -1.54096231e-01f, 8.13438557e-03f, 9.89834964e-03f, -3.04297190e-02f,
  -8.04843754e-02f, -1.02016114e-01f, -1.87763423e-01f, -9.34408829e-02f, -3.68760042e-02f, -1.51091263e-01f, -1.56354740e-01f, -7.00645521e-02f, -1.88381076e-01f, -2.02974752e-02f,
  -3.09502065e-01f, 1.38142258e-01f, 3.19884747e-01f, -2.14564338e-01f, 4.07604761e-02f, 2.86364113e-03f, 1.50285214e-01f, -6.44238740e-02f, -1.32986665e-01f, 1.16339043e-01f,
  -5.28417602e-02f, -1.44242719e-01f, -5.98705187e-02f, -5.50344847e-02f, 5.64761125e-02f, 2.74542421e-01f, 2.84420460e-01f, 3.83420736e-02f, -1.21291496e-01f, -1.60501748e-01f,
  -6.20854236e-02f, -1.84117466e-01f, -1.58487484e-01f, -1.47949263e-01f, 1.26537591e-01f, -8.72229412e-02f, 1.73609890e-02f, 3.12129203e-02f, 1.32710353e-01f, 2.51881480e-01f,
  3.10890764e-01f, 1.19185299e-01f, 2.01462641e-01f, 7.31659681e-02f, 1.06260471e-01f, 1.05793171e-01f, 1.54849291e-01f, 8.14427361e-02f, 1.84448257e-01f, 4.19887044e-02f,
  1.92178383e-01f, 1.89267267e-02f, 1.33216068e-01f, 8.86135250e-02f, -2.33690888e-02f, 8.87833163e-02f, 7.96911791e-02f, 8.29823911e-02f, 1.36146575e-01f, 1.06694825e-01f,
  1.30617648e-01f, 1.83530331e-01f, 1.88012704e-01f, 1.22722909e-01f, 1.53988585e-01f, 2.47333534e-02f, 1.89920798e-01f, 1.44939646e-01f, 6.39938712e-02f, 9.72301736e-02f,
  3.75587083e-02f, -4.38977927e-02f, -2.07769568e-03f, -8.60046074e-02f, -2.01384109e-02f, 6.54746667e-02f, -5.52662835e-02f, -2.19876319e-02f, -1.19297057e-01f, -1.22306675e-01f,
  -5.06266812e-03f, -3.12614962e-02f, -7.11130500e-02f, -2.93350015e-02f, -4.74872850e-02f, -4.96467873e-02f, -1.39608786e-01f, 5.80817014e-02f, -3.48707549e-02f, -2.56312154e-02f,
  3.09837274e-02f, -1.63034294e-02f, -8.09297524e-03f, -2.44754888e-02f, 1.25926882e-01f, -1.84067991e-02f, -1.01354614e-01f, -1.36863038e-01f, -8.35670605e-02f, -1.60118297e-01f,
  -1.61857344e-02f, 1.19309798e-02f, 8.70936736e-02f, 1.01256542e-01f, 3.30479518e-02f, 4.69209068e-03f, 9.52610970e-02f, 9.03012231e-02f, 6.40153959e-02f, 1.20916866e-01f,
  1.31950527e-01f, -1.52568202e-02f, -2.50789691e-02f, 7.25266337e-02f, 2.42993631e-03f, 7.45857880e-02f, 3.32287364e-02f, -6.66258857e-02f, 3.01787760e-02f, 9.33153462e-03f,
  7.90036544e-02f, -1.35924935e-01f, 3.43108810e-02f, 5.40653020e-02f, 1.23744428e-01f, 1.78066306e-02f, 9.17673633e-02f, -1.61567070e-02f, -3.60258855e-02f, -1.50922358e-01f,
  6.55753985e-02f, 3.88610750e-01f, 1.98898807e-01f, 4.79142331e-02f, -1.03511579e-01f, -7.57029839e-03f, 1.38437092e-01f, 4.35966579e-03f, -4.35610376e-02f, 2.05263883e-01f,
  2.50400901e-01f, 4.95899469e-02f, 1.60828397e-01f, -5.05183041e-02f, 3.59362215e-02f, 2.58388609e-01f, 1.79402411e-01f, -6.85322657e-02f, -3.69326591e-01f, -1.53470486e-01f,
  -9.90636926e-03f, -3.00005674e-02f, 4.91561927e-03f, -1.46346735e-02f, 1.79967239e-01f, -5.49609028e-03f, 6.48170188e-02f, 3.10205985e-02f, 9.58953351e-02f, 3.47257525e-01f,
  3.60890806e-01f, 4.22487587e-01f, 1.45090938e-01f, 1.31612048e-01f, 2.91807592e-01f, 2.18328178e-01f, 1.46894827e-01f, 2.33434215e-01f, 2.46856451e-01f, 2.89608032e-01f,
  1.95718840e-01f, 2.71575481e-01f, 2.19395369e-01f, 2.38130853e-01f, 9.27809179e-02f, 1.33808941e-01f, 1.27410933e-01f, 8.14804733e-02f, 2.08113030e-01f, 1.85194388e-01f,
  1.93532109e-01f, 2.18378380e-01f, 2.01157317e-01f, 2.56636679e-01f, 1.36940494e-01f, 1.95110589e-01f, 1.99105546e-01f, 2.59429514e-01f, 5.30332401e-02f, 2.73867786e-01f,
  -6.42749816e-02f, -1.33186460e-01f, -8.78624618e-02f, -4.62915748e-02f, -1.53190702e-01f, -1.07727930e-01f, -1.55830041e-01f, -8.44823122e-02f, -2.08275784e-02f, -1.44382238e-01f,
  -5.31286746e-02f, -2.16813415e-01f, -1.75677508e-01f, -9.45397019e-02f, -1.55758262e-02f, -8.02071840e-02f, -7.14238510e-02f, -9.98181757e-03f, -1.53825367e-02f, -7.30892569e-02f,
  -6.67928532e-02f, -7.80111626e-02f, -1.23855732e-01f, -1.89763293e-01f, -9.32104066e-02f, -1.71915248e-01f, -1.84362486e-01f, -1.12828366e-01f, -1.13060422e-01f, -1.27964303e-01f,
  1.78796068e-01f, 1.00414790e-01f, 1.90913990e-01f, 1.54759318e-01f, 2.19428718e-01f, 1.76862866e-01f, 2.68533468e-01f, 2.90028065e-01f, 1.90594196e-01f, 2.26822719e-01f,
  2.43095651e-01f, 2.31330216e-01f, 2.78451353e-01f, 1.16924450e-01f, 1.72450304e-01f, 2.16250032e-01f, 2.52863556e-01f, 1.30531089e-02f, 6.56845942e-02f, 1.04176603e-01f,
  1.70721233e-01f, 1.62493885e-01f, -4.53153567e-04f, 1.31636605e-01f, 1.74579933e-01f, -9.61250160e-03f, 1.14925757e-01f, 1.79290280e-01f, 4.22706641e-02f, 4.38425876e-03f,
  -1.63414717e-01f, -2.76432186e-01f, 1.68805886e-02f, 6.78501353e-02f, 3.97387818e-02f, -5.06010503e-02f, -3.08825076e-01f, -4.93033230e-02f, 8.34724829e-02f, -6.62405267e-02f,
  -1.00843117e-01f, 1.31342281e-02f, 1.55877685e-02f, 1.19483352e-01f, -6.51779920e-02f, -9.07750726e-02f, 9.45243537e-02f, 3.71882953e-02f, -4.56569920e-04f, -1.30058050e-01f,
  -3.04599255e-02f, -1.84061766e-01f, -1.76683575e-01f, -5.45575991e-02f, 1.05297096e-01f, 7.30559602e-02f, 2.56225578e-02f, 1.16179466e-01f, 1.20146155e-01f, 2.31605411e-01f,
  6.84722960e-02f, 8.14595595e-02f, 6.79192767e-02f, 2.70273220e-02f, 1.44262969e-01f, 1.54612750e-01f, -7.54287392e-02f, 7.41907060e-02f, 9.51997861e-02f, 2.60371063e-02f,
  -1.92273315e-02f, 2.26911977e-02f, 1.19400978e-01f, 1.25021964e-01f, 1.40608862e-01f, 8.40143040e-02f, 1.11692421e-01f, 6.59410730e-02f, 2.11348787e-01f, 2.20451057e-02f,
  1.63009346e-01f, 9.66213644e-02f, -4.04009745e-02f, 1.27874045e-02f, 2.04938322e-01f, 5.82228005e-02f, 1.75825451e-02f, 2.55947232e-01f, 2.19614908e-01f, -2.47491673e-02f,
  1.72839612e-01f, 4.60902937e-02f, 1.30972922e-01f, 8.89465362e-02f, 3.79677378e-02f, 1.50707245e-01f, 2.55290996e-02f, 5.32499291e-02f, -3.40337418e-02f, -7.64076263e-02f,
  6.87031448e-02f, 6.36197552e-02f, 4.35795225e-02f, 9.24224555e-02f, 7.01368302e-02f, -2.68266164e-02f, 1.03936568e-02f, -8.36090818e-02f, 4.52274904e-02f, 6.33530766e-02f,
  4.46051173e-02f, 9.45629105e-02f, 1.15798535e-02f, 1.52790025e-01f, 1.64455593e-01f, 8.99872705e-02f, 1.45589575e-01f, 6.08141068e-03f, -4.84275147e-02f, -2.45397259e-03f,
  -2.62169987e-01f, 7.48245344e-02f, -2.95792017e-02f, -4.79612947e-02f, -7.45208841e-03f, 9.47121903e-02f, 1.76012889e-01f, 8.34711865e-02f, 2.21618742e-01f, 5.51005155e-02f,
  9.09120366e-02f, 8.07774812e-02f, 1.09245569e-01f, 8.35388377e-02f, -1.28962740e-03f, 6.12439215e-02f, 1.95202045e-02f, 9.68712941e-02f, 1.98138371e-01f, 1.63006131e-02f,
  9.25726518e-02f, -1.06463805e-01f, -8.02810639e-02f, -1.07041523e-02f, 2.32286975e-01f, 3.01680826e-02f, -5.97832957e-03f, 1.62247524e-01f, 1.33266719e-02f, -1.29039884e-01f,
  -7.70215869e-01f, -3.15221436e-02f, -1.26250774e-01f, -2.32898861e-01f, 1.92249209e-01f, 1.07108265e-01f, 1.44664869e-01f, -2.10049555e-01f, -8.99350718e-02f, -1.66507345e-02f,
  2.00264499e-01f, 1.30061314e-01f, 1.13793537e-02f, 1.12687230e-01f, -8.84375349e-02f, 1.11157574e-01f, 4.97597121e-02f, -1.22706853e-01f, -6.41849488e-02f, 1.60684317e-01f,
  3.45820785e-01f, -2.33693704e-01f, -3.47538531e-01f, -1.78227663e-01f, 3.17864120e-03f, 1.00736529e-01f, -8.15028623e-02f, -2.14186981e-02f, 2.35782474e-01f, 2.97679603e-01f,
  3.16504687e-01f, -1.42140672e-01f, -5.80630847e-04f, 4.60123681e-02f, -5.21228425e-02f, -7.06702620e-02f, -3.21831345e-03f, -9.08599887e-03f, -5.38381338e-02f, 3.84155065e-02f,
  8.41259360e-02f, -3.11707351e-02f, -3.14618945e-02f, 5.95159717e-02f, -2.88380496e-02f, 7.37687051e-02f, -1.02597922e-01f, -1.99454099e-01f, -1.13185644e-01f, 6.00636750e-02f,
  1.78544551e-01f, 7.51818419e-02f, 6.25287741e-02f, 9.74591896e-02f, 2.26279236e-02f, 9.84573886e-02f, -6.03280915e-03f, 4.87245061e-02f, -8.33778456e-02f, -9.46254805e-02f,
  1.04553238e-01f, -2.40352713e-02f, 5.39491549e-02f, -5.05878925e-02f, 1.27894338e-02f, -1.38631118e-02f, 3.09966635e-02f, 3.90809067e-02f, 3.17170471e-02f, 6.03009481e-03f,
  -4.38207313e-02f, -3.45621966e-02f, 3.02896779e-02f, -1.61652714e-01f, 1.78303700e-02f, -5.46008870e-02f, -5.63431978e-02f, -3.28014642e-02f, 5.06945811e-02f, -1.92740373e-02f,
  -1.98680907e-02f, 3.76204364e-02f, -3.07531152e-02f, 1.38347712e-03f, 7.31013389e-03f, -6.69624135e-02f, -1.17057667e-03f, -2.48890603e-04f, -3.90946977e-02f, 5.23520447e-02f,
  -1.18882544e-01f, 2.40842737e-02f, 7.93110505e-02f, -5.23404367e-02f, 1.91222802e-02f, -9.82275419e-03f, 9.89014432e-02f, 5.45963831e-02f, -2.26470083e-02f, -9.27358773e-03f,
  1.72784738e-02f, -5.11161424e-02f, 5.28705399e-03f, 8.84234309e-02f, 8.24206620e-02f, 2.10930947e-02f, 1.16634825e-02f, 6.44812956e-02f, 1.75262894e-02f, 7.64868334e-02f,
  -1.30954618e-03f, -3.80518697e-02f, -1.05605789e-01f, -2.35839114e-02f, 4.57129702e-02f, -1.07535750e-01f, -3.00634839e-02f, -4.11631428e-02f, -5.80813996e-02f, -1.93878651e-01f,
  3.00914139e-01f, -4.84539419e-02f, 2.49415711e-01f, -2.54592180e-01f, -1.77526459e-01f, 1.18550919e-01f, 3.85439068e-01f, 1.26495570e-01f, -1.16586715e-01f, 4.77847867e-02f,
  3.79315428e-02f, -2.37835556e-01f, -9.41708386e-02f, -3.10560893e-02f, 2.98414916e-01f, 2.55827338e-01f, 8.38524625e-02f, 2.33685091e-01f, 1.84067458e-01f, 5.91371395e-02f,
  -1.86777905e-01f, -1.18530577e-03f, 1.76596254e-01f, 9.93077550e-03f, -7.61118829e-02f, -5.50583228e-02f, -7.68672824e-02f, -4.22781892e-02f, -5.60494810e-02f, -9.76345688e-02f,
  -2.15726905e-02f, 1.34519771e-01f, -5.50220944e-02f, -1.26373917e-01f, -2.23861992e-01f, 2.42437031e-02f, -3.40004861e-02f, -6.11800328e-02f, -1.81063861e-01f, 2.62575652e-02f,
  -1.86222225e-01f, 1.38980644e-02f, -1.39151424e-01f, -6.01215735e-02f, -2.84900572e-02f, -9.37040448e-02f, -4.15462330e-02f, 4.42051608e-03f, 8.66596475e-02f, -7.94010907e-02f,
  -9.58879068e-02f, -2.28359979e-02f, 9.74690989e-02f, -9.53489840e-02f, 2.72964928e-02f, -1.63728908e-01f, -3.84349674e-02f, -4.94773276e-02f, 9.63026732e-02f, -1.06898949e-01f,
  -1.54980668e-03f, 2.53450498e-02f, 1.40255513e-02f, 6.55146241e-02f, 4.52861525e-02f, -3.63811813e-02f, -8.80044922e-02f, 2.52605397e-02f, -7.83631951e-02f, -9.72907320e-02f,
  5.26478179e-02f, -7.70935323e-03f, 2.30309390e-03f, 3.35641094e-02f, -5.33277504e-02f, 2.55506020e-02f, -1.85265020e-03f, -1.41590126e-02f, 1.62957851e-02f, 3.69120599e-03f,
  6.78851306e-02f, -1.24749444e-01f, -3.96067686e-02f, -4.67359684e-02f, 1.70205208e-03f, -5.00920601e-02f, -1.77447516e-02f, -3.14836688e-02f, 3.93514521e-02f, 1.80612653e-02f,
  -8.93209055e-02f, 1.02125071e-01f, -5.19116856e-02f, -7.04326034e-02f, -9.37640667e-02f, -7.10557625e-02f, -1.63251996e-01f, -3.60900015e-02f, -2.63399422e-01f, -6.07315861e-02f,
  -6.30390346e-02f, -1.28166288e-01f, -8.46054256e-02f, -6.78545088e-02f, 4.42352481e-02f, 2.12734677e-02f, -1.04994744e-01f, -4.34214063e-02f, -1.07481532e-01f, -1.23188592e-01f,
  -1.00711823e-01f, -4.00952399e-02f, -1.12867244e-01f, -9.87986848e-02f, -3.59274782e-02f, 2.25174483e-02f, -9.91369486e-02f, -1.80180967e-01f, 1.69090122e-01f, 1.77717358e-02f,
  -1.35274649e-01f, -1.92051932e-01f, -1.90469280e-01f, -9.41121504e-02f, 1.62140310e-01f, 1.47860616e-01f, 3.12495828e-01f, 1.98558435e-01f, -3.78328823e-02f, -5.69509789e-02f,
  5.88101335e-02f, 2.04233170e-01f, -1.69440859e-03f, 1.35625735e-01f, 1.19782388e-01f, -6.74782470e-02f, -1.08852692e-01f, -4.38027866e-02f, 2.93456078e-01f, 3.80936235e-01f,
  1.50830120e-01f, -1.03319220e-01f, -9.06236395e-02f, -3.54815996e-03f, -2.55323023e-01f, -7.72633255e-02f, -2.39517346e-01f, -2.86649406e-01f, -6.96678087e-02f, -2.79475063e-01f,
  -9.25700665e-02f, -1.92146048e-01f, 1.11104205e-01f, 1.51555613e-01f, -5.93572147e-02f, 5.94401136e-02f, -2.79674679e-03f, 2.43148059e-02f, 3.20835412e-02f, 2.21948698e-02f,
  3.80826145e-02f, 1.75950587e-01f, 1.04322091e-01f, 8.12903568e-02f, 8.59529525e-02f, 1.16778128e-01f, 5.01144938e-02f, 6.12625480e-02f, 6.29417822e-02f, 4.67902869e-02f,
  1.21479549e-01f, 6.88708797e-02f, -3.10877226e-02f, 3.14875692e-02f, 1.24550730e-01f, 1.04994342e-01f, -1.66949593e-02f, 9.44449939e-03f, -6.15913793e-02f, -1.90866545e-01f,
  2.57127453e-02f, 2.45982315e-02f, -3.50366868e-02f, -4.25098985e-02f, -6.94913939e-02f, 4.21056226e-02f, -4.94755767e-02f, -2.04654367e-04f, -7.01478645e-02f, 3.03264824e-03f,
  -3.46273147e-02f, -2.26883516e-02f, 1.50299631e-02f, -7.95752928e-03f, 7.07286745e-02f, -7.80427381e-02f, -1.54305045e-02f, -3.81588042e-02f, -5.53750582e-02f, -1.24221668e-01f,
  3.31458636e-02f, -3.74152996e-02f, -1.21933371e-01f, 7.36213177e-02f, 3.24512608e-02f, -4.99880686e-03f, -8.29982683e-02f, -3.51739861e-02f, -1.36335893e-02f, -9.09952912e-03f,
  -3.00767599e-03f, -3.48834768e-02f, -4.80399095e-02f, -1.65570956e-02f, -6.10056557e-02f, -2.88851690e-02f, -7.49725327e-02f, 4.40713540e-02f, 5.51032908e-02f, 1.15396110e-02f,
  2.36957848e-01f, 8.39288607e-02f, -4.01205942e-03f, 9.22721550e-02f, 2.01748058e-01f, 7.68173635e-02f, 4.82254252e-02f, -2.89783366e-02f, 1.96743831e-01f, 1.18843699e-02f,
  8.85943174e-02f, 1.07440278e-01f, 1.48946106e-01f, 4.79737520e-02f, 7.37291425e-02f, 1.33863673e-01f, 6.23933263e-02f, 5.43313809e-02f, 1.40891761e-01f, 1.02484174e-01f,
  5.05565047e-01f, 1.00761756e-01f, -2.43953824e-01f, 3.44329357e-01f, -2.71807164e-02f, 1.30585460e-02f, -2.92856321e-02f, 3.56178470e-02f, 2.01320663e-01f, 1.21575482e-02f,
  -1.89054221e-01f, -6.32036850e-02f, -8.31533223e-02f, -1.22054301e-01f, -1.41271576e-01f, 5.49054705e-02f, 7.77369961e-02f, 3.11587248e-02f, -4.10030670e-02f, 8.72759242e-03f,
  1.60511747e-01f, 3.35844427e-01f, 2.32403159e-01f, 1.25938624e-01f, 1.77412078e-01f, -9.36920792e-02f, 2.73531012e-04f, 2.41295144e-01f, 8.11006315e-03f, 2.16932610e-01f,
  7.72115402e-03f, 2.09746268e-02f, -2.49049023e-01f, 5.58467321e-02f, -9.78739411e-02f, -6.60516247e-02f, -4.17611301e-02f, 1.47277629e-02f, -2.67691668e-02f, -3.25709134e-02f,
  -5.95941767e-03f, 6.80887885e-03f, 6.13400005e-02f, -6.46774992e-02f, 2.31109485e-02f, 6.14579692e-02f, -6.75642863e-03f, 2.82921493e-02f, -1.11049660e-01f, -9.59714800e-02f,
  6.74281865e-02f, 9.99206975e-02f, 1.34387210e-01f, -6.78508580e-02f, -1.41479790e-01f, -2.52005812e-02f, 2.46443506e-02f, 6.97467178e-02f, -1.38898283e-01f, 1.45329624e-01f,
  4.86667678e-02f, -3.15504409e-02f, -1.41572803e-01f, 3.09536234e-02f, 5.86536191e-02f, -2.69411411e-02f, -2.78695244e-02f, -1.63201541e-02f, -8.25573050e-04f, 8.77245963e-02f,
  -1.13780163e-02f, -6.62436187e-02f, -4.87126000e-02f, 3.76667306e-02f, 2.30621500e-03f, -9.33197513e-03f, -1.32049546e-02f, -1.24896519e-01f, -1.71294346e-01f, -1.01473276e-02f,
  -5.22203185e-02f, -1.82250198e-02f, 3.26705887e-03f, -2.28970572e-02f, -1.26695365e-01f, -3.46504599e-02f, -7.17919022e-02f, -6.59094602e-02f, -7.80899674e-02f, -4.04863767e-02f,
  5.11456467e-02f, -3.74754667e-01f, 7.43369609e-02f, -6.60576522e-02f, -4.68655443e-03f, -1.50355697e-01f, -9.97895002e-02f, -8.81281048e-02f, -6.05222099e-02f, 1.48728145e-02f,
  2.47304086e-02f, 7.72025362e-02f, -2.71145571e-02f, -8.02285075e-02f, 2.37285718e-02f, -1.34278499e-02f, 6.16195388e-02f, 4.51270305e-02f, -9.03758705e-02f, 1.19902402e-01f,
  1.06225364e-01f, 1.31575838e-01f, 5.21094836e-02f, -3.83232422e-02f, 6.59191310e-02f, 9.01188776e-02f, 7.58669972e-02f, 4.50355783e-02f, -1.27768472e-01f, 4.20805663e-02f,
  -3.11324447e-01f, -1.13313235e-01f, 4.50315252e-02f, -2.99166441e-01f, -2.37438474e-02f, 2.54242569e-01f, 3.24592352e-01f, 5.01850545e-02f, -2.16775432e-01f, -1.32913753e-01f,
  -1.29957542e-01f, -1.22239649e-01f, -2.04621822e-01f, 1.00578882e-01f, 2.82012999e-01f, 8.83182362e-02f, 2.95157693e-02f, 2.08084006e-02f, 3.02497208e-01f, 1.57962546e-01f,
  -5.07389009e-02f, -7.56653845e-02f, -1.90399632e-01f, -1.80943925e-02f, -1.66537687e-01f, -2.36649010e-02f, -2.21410409e-01f, -1.32759184e-01f, 5.07569797e-02f, -2.55226880e-01f,
  7.16113904e-03f, -2.81685852e-02f, 1.20302707e-01f, 3.37558612e-02f, -2.87033115e-02f, -1.63260754e-02f, -3.47349718e-02f, -1.02280699e-01f, -5.17466851e-02f, -7.29939491e-02f,
  -1.60458162e-01f, 2.32225824e-02f, -7.41562471e-02f, 1.52549427e-02f, 6.02776930e-03f, -6.05398417e-02f, -9.43677202e-02f, 8.97332951e-02f, 1.83880534e-02f, 8.80618673e-03f,
  6.41316846e-02f, -4.15693223e-02f, -8.86808857e-02f, 7.71499146e-03f, 3.45625468e-02f, 6.03891984e-02f, 1.71602946e-02f, -9.13904328e-03f, 4.04436477e-02f, -2.92073302e-02f,
  4.93403301e-02f, 1.13842869e-02f, -5.68033056e-03f, -3.96944135e-02f, -2.46611722e-02f, 1.09484922e-02f, 2.49084998e-02f, 4.44224700e-02f, 1.28518716e-01f, -3.87422070e-02f,
  -2.01922432e-02f, 2.39081997e-02f, 1.42740319e-02f, -3.51270065e-02f, -5.80409132e-02f, -8.72526541e-02f, 5.12709506e-02f, 5.58967665e-02f, 7.10700639e-03f, -4.95801270e-02f,
  -2.41065416e-02f, 2.58265319e-03f, -7.15250894e-02f, -6.84036687e-02f, -2.80116443e-02f, 4.77670990e-02f, -8.17931294e-02f, -2.37423293e-02f, -8.76453072e-02f, -6.85854033e-02f,
  1.19076502e-02f, 2.34661907e-01f, 3.67788039e-02f, 1.63601369e-01f, -2.93030660e-03f, 2.63893288e-02f, 5.82075445e-03f, 1.02470880e-02f, -7.12502152e-02f, 5.38790934e-02f,
  1.05120175e-01f, 1.35889560e-01f, 3.54093760e-02f, -3.48118618e-02f, 1.54597580e-01f, 2.66556833e-02f, -2.21635052e-03f, 1.50920480e-01f, 3.05612367e-02f, 5.12525514e-02f,
  1.59736816e-02f, 7.63434321e-02f, 1.06383696e-01f, 1.28091633e-01f, 7.29321986e-02f, 1.35366604e-01f, 1.71853788e-02f, 1.01223215e-01f, 1.93923861e-01f, 1.18511081e-01f,
  9.28066820e-02f, -3.53246778e-01f, -4.84548122e-01f, 2.03366771e-01f, -5.51834330e-02f, -7.00235590e-02f, -1.50727391e-01f, 4.48395498e-02f, 8.79343003e-02f, -1.55248612e-01f,
  -1.43416956e-01f, 1.51706204e-01f, 1.09102562e-01f, 6.71953112e-02f, 5.97270466e-02f, -3.82682052e-03f, -7.36185610e-02f, -5.78513369e-02f, 1.79107293e-01f, 1.13387942e-01f,
  4.42174971e-02f, 1.48634970e-01f, 7.56092323e-03f, 3.73627916e-02f, -2.83672605e-02f, 1.79103613e-01f, -1.67610511e-01f, -2.17850551e-01f, -1.57351896e-01f, -1.81992561e-01f,
  -7.03369007e-02f, -2.66429394e-01f, 2.34742135e-01f, 7.61231109e-02f, -5.64446636e-02f, 1.23315305e-01f, 5.54615259e-02f, 5.87704629e-02f, 8.41955021e-02f, -5.69647364e-03f,
  -3.37374099e-02f, 4.88611311e-02f, 5.40335923e-02f, 1.59902498e-01f, 2.37007067e-03f, 1.23277284e-01f, -2.82479953e-02f, -1.44372378e-02f, 9.75532159e-02f, 4.67821769e-02f,
  1.61147397e-02f, -1.75637811e-01f, -1.31802276e-01f, -2.46678689e-03f, -6.83647469e-02f, 8.40383694e-02f, -8.50846767e-02f, -6.44529387e-02f, -7.63581395e-02f, 2.55975872e-02f,
  5.79865612e-02f, -1.06543072e-01f, 3.68463695e-02f, -5.48631186e-03f, 2.35846802e-03f, -4.71802159e-05f, -3.28248553e-02f, 9.93664488e-02f, -3.58507894e-02f, 2.32878234e-03f,
  3.80184427e-02f, -5.24914730e-03f, 7.51872212e-02f, -6.81397272e-03f, 3.69398333e-02f, -4.80254134e-03f, 6.72116280e-02f, 7.58603811e-02f, 3.65802720e-02f, 5.48304804e-02f,
  7.80916885e-02f, -6.24718815e-02f, 5.89487376e-04f, 6.58289343e-02f, -3.21183726e-02f, -4.73711966e-03f, 6.82310984e-02f, 2.39948165e-02f, -1.72968488e-02f, -3.63958962e-02f,
  4.12096918e-01f, -6.98260292e-02f, 1.27446443e-01f, 5.54085001e-02f, 2.33465247e-02f, 5.13819009e-02f, -1.51564449e-03f, 1.07403539e-01f, 1.83194522e-02f, 1.85179617e-02f,
  -2.43383143e-02f, 2.72059217e-02f, 3.66159156e-02f, -2.64667124e-02f, 9.51042250e-02f, 7.49641061e-02f, 1.32172495e-01f, 1.60043180e-01f, 9.70232636e-02f, 6.64081946e-02f,
  1.78460628e-01f, 2.25316644e-01f, 1.42975017e-01f, 1.87892467e-01f, 1.80273399e-01f, 2.33669505e-01f, 1.58954456e-01f, 1.62964314e-01f, 1.39129996e-01f, 3.69310856e-01f,
  -2.51206337e-03f, 2.42858808e-02f, -6.10899255e-02f, -6.78007752e-02f, -1.95940435e-01f, -1.69599041e-01f, -1.69785559e-01f, 3.73105548e-04f, -5.43293096e-02f, -1.88044742e-01f,
  1.09598599e-01f, 1.59368113e-01f, 4.23852466e-02f, 1.46775812e-01f, 2.10902184e-01f, -8.46765861e-02f, -4.28306498e-02f, 2.29659602e-02f, 7.19646141e-02f, -1.13333687e-01f,
  -1.75010990e-02f, 3.86480661e-03f, 3.15908752e-02f, 2.54559680e-03f, -6.65960982e-02f, 1.64511502e-02f, -5.81571534e-02f, -4.21441309e-02f, 1.13990173e-01f, -9.69665274e-02f,
  -1.69547752e-01f, 1.10915229e-02f, 1.37742996e-01f, 7.87688568e-02f, 3.70524339e-02f, 1.36199240e-02f, 1.84821673e-02f, 1.12577766e-01f, 4.86401021e-02f, -4.20776429e-03f,
  9.53081772e-02f, 4.80806082e-02f, 1.43137127e-01f, 6.05384894e-02f, -6.12252727e-02f, -1.80529244e-02f, 1.25328764e-01f, 2.97512375e-02f, 8.13079923e-02f, 3.31967957e-02f,
  1.23574920e-01f, 6.22948594e-02f, 1.51483998e-01f, 3.96712832e-02f, 8.40750709e-02f, 1.98170036e-01f, 1.91503674e-01f, 1.42468005e-01f, 1.00615494e-01f, 5.01101092e-03f,
  -5.27174063e-02f, 3.67750973e-02f, 1.03524677e-01f, 7.96481520e-02f, 1.63086027e-01f, 1.14663586e-01f, 9.68892202e-02f, 9.82296914e-02f, -5.14072254e-02f, 1.28110196e-03f,
  4.97537516e-02f, -1.24376394e-01f, -4.10052389e-02f, -4.10694117e-03f, 8.71198401e-02f, 5.53211458e-02f, -1.65912684e-03f, 6.00202829e-02f, 6.13401383e-02f, -3.96171138e-02f,
  6.24173619e-02f, -1.17264889e-01f, 2.85491869e-02f, 1.38605699e-01f, -5.78609817e-02f, 3.40805799e-02f, -8.53457376e-02f, -2.32558753e-02f, -4.61946130e-02f, -6.44738078e-02f,
  1.23031408e-01f, 1.94484338e-01f, 1.54986411e-01f, 1.70252711e-01f, 1.29092922e-02f, 2.24262133e-01f, 1.11434944e-01f, 1.20769046e-01f, 8.40918496e-02f, 7.84180760e-02f,
  7.12992772e-02f, 5.85668907e-02f, 6.13501146e-02f, 8.14861208e-02f, 2.34270636e-02f, 6.98082075e-02f, 6.07036315e-02f, 1.25971407e-01f, 1.48532987e-01f, 2.43620668e-02f,
  5.89979105e-02f, 1.06143132e-01f, 1.44677624e-01f, 4.60391939e-02f, 1.95670545e-01f, 8.12722892e-02f, 8.07419941e-02f, 1.50754511e-01f, 6.14375733e-02f, 2.25997530e-02f,
  -3.22354853e-01f, 8.28754678e-02f, 2.15046763e-01f, -8.97704214e-02f, 1.05750166e-01f, 1.66477397e-01f, 2.30465606e-01f, -1.05351068e-01f, -1.74895301e-01f, 2.85943687e-01f,
  2.24225789e-01f, -1.08580859e-02f, 2.26126596e-01f, 1.54584855e-01f, 1.49500042e-01f, 4.42247838e-01f, 3.04937184e-01f, 6.93660751e-02f, -7.38984393e-03f, -1.10113107e-01f,
  7.65914395e-02f, -3.46014574e-02f, -2.38173798e-01f, -2.15286255e-01f, -1.01404510e-01f, 1.35521546e-01f, 1.62397325e-01f, 3.60855870e-02f, 1.45665661e-01f, 1.41757112e-02f,
  3.26724768e-01f, -2.14524731e-01f, 2.75686625e-02f, 8.20024535e-02f, 1.13887824e-01f, 8.00149329e-03f, 9.69596878e-02f, 6.33000955e-02f, -3.91857438e-02f, 4.54642177e-02f,
  8.49547237e-02f, -3.09264706e-03f, -1.34306308e-02f, -7.00919107e-02f, -8.13212171e-02f, 5.31997997e-04f, -1.14588011e-02f, -9.24805403e-02f, -5.67756314e-03f, 2.97287963e-02f,
  -2.04157755e-02f, 1.05870977e-01f, -7.55998194e-02f, -4.05977666e-02f, -4.12304327e-02f, -1.25090644e-01f, -9.63014588e-02f, -8.64894837e-02f, -6.31338451e-03f, 1.18669331e-01f,
  -3.35128903e-02f, 6.33591935e-02f, -8.27785674e-03f, -6.80377558e-02f, -4.28042710e-02f, 1.34782866e-01f, -3.60707268e-02f, 2.26376988e-02f, 9.15299170e-04f, 1.23722471e-01f,
  -2.70631313e-02f, 6.08801842e-02f, -8.64869729e-02f, 3.92041728e-02f, 3.63536887e-02f, -6.15560263e-02f, 5.44857569e-02f, 8.20579007e-02f, -9.77751464e-02f, -5.60892411e-02f,
  3.47948298e-02f, 3.48396562e-02f, 4.24975008e-02f, 4.89161648e-02f, 2.89659891e-02f, 5.34728132e-02f, -3.16806138e-02f, -3.11036184e-02f, 6.02335297e-02f, -1.00987040e-01f,
  1.21094078e-01f, 1.67377647e-02f, 8.87409449e-02f, 2.57672332e-02f, 1.02636389e-01f, 5.57139777e-02f, 7.56388605e-02f, 9.50560942e-02f, 1.89805795e-02f, 2.22875848e-02f,
  -4.97379154e-02f, 1.45206209e-02f, 8.25730432e-03f, 1.43039823e-02f, -5.11441892e-03f, -1.60152372e-02f, 1.57356903e-01f, 1.47503123e-01f, 1.17486976e-02f, -5.45994751e-02f,
  -2.83168722e-02f, 8.85296166e-02f, 7.99541622e-02f, 1.01759821e-01f, -2.98004039e-02f, 9.54225138e-02f, 1.35913298e-01f, 1.70509759e-02f, 1.17694631e-01f, 2.75674075e-01f,
  -2.77978271e-01f, 7.47270137e-02f, 4.51542079e-01f, -1.54148430e-01f, 6.29836395e-02f, 2.44227007e-01f, 3.60335022e-01f, 5.40680215e-02f, 1.87663734e-02f, 1.48503512e-01f,
  -1.42097354e-01f, -3.55222642e-01f, -2.54113764e-01f, -2.37925127e-02f, 3.36808749e-02f, 4.18605089e-01f, 3.68917674e-01f, 6.93913847e-02f, -7.74805620e-02f, -1.23323463e-01f,
  -1.65080860e-01f, -3.54981571e-02f, -2.26847097e-01f, -7.21236765e-02f, 2.10054979e-01f, -3.12604383e-02f, 2.37436101e-01f, 8.40906575e-02f, 4.56844689e-03f, 2.97599137e-01f,
  6.30835071e-02f, 1.31090172e-02f, 1.28671393e-01f, -6.63215965e-02f, 3.63564342e-02f, 9.31844562e-02f, 7.72977397e-02f, 2.21269801e-01f, 5.40842973e-02f, 1.04473740e-01f,
  -1.28887549e-01f, -1.14239983e-01f, 6.74783066e-02f, 3.51726897e-02f, 7.13154004e-05f, -3.22382711e-02f, -5.07944860e-02f, 1.27241880e-01f, 1.45677820e-01f, 9.55541134e-02f,
  7.81825408e-02f, 2.49497197e-03f, 9.19430386e-05f, 2.11357921e-01f, 1.32651985e-01f, -6.35081753e-02f, 1.30949304e-01f, 8.59724954e-02f, 7.00873211e-02f, 1.51880249e-01f,
  5.05775921e-02f, 2.04691268e-03f, 2.70883124e-02f, 1.63486581e-02f, -8.94692391e-02f, -8.03444311e-02f, -7.85063654e-02f, 2.03810949e-02f, -5.55176772e-02f, -1.84411202e-02f,
  -6.74985871e-02f, -3.78507003e-02f, 7.15598986e-02f, 8.71301442e-02f, -6.97266078e-03f, -3.69217098e-02f, -6.90513104e-02f, 2.75930800e-02f, -1.43878952e-01f, -6.46673841e-03f,
  -1.15932100e-01f, 2.55723000e-02f, -8.00185055e-02f, 1.08645260e-02f, 6.99825063e-02f, 3.87349799e-02f, 1.71028567e-03f, -3.71228866e-02f, -6.44374937e-02f, -1.63526922e-01f,
  -1.03099070e-01f, -3.65624912e-02f, -3.85043323e-02f, -5.85967256e-03f, 8.37324944e-04f, -8.14918652e-02f, 4.77529392e-02f, 1.14590086e-01f, -2.94901486e-02f, -3.53439748e-02f,
  1.17467865e-02f, 2.07199920e-02f, -3.62752117e-02f, 1.08275317e-01f, 3.14820409e-02f, -3.23780701e-02f, -8.41487646e-02f, 3.78936082e-02f, -6.77844556e-03f, -3.46979336e-03f,
  4.23176698e-02f, 3.70435715e-02f, -9.09086615e-02f, 2.03121025e-02f, -8.70170593e-02f, -6.73513561e-02f, 1.11376584e-01f, 9.42225605e-02f, -5.59547683e-03f, 3.17521468e-02f,
  -2.42271975e-01f, 2.50923693e-01f, -3.45148563e-01f, 3.85032669e-02f, 1.75247416e-01f, 2.22570542e-02f, 1.45314485e-01f, 4.02460247e-02f, -4.52031419e-02f, 1.09522894e-01f,
  2.84641743e-01f, 1.03161067e-01f, -1.95696428e-02f, 1.98713448e-02f, -1.05067037e-01f, 1.07345402e-01f, 4.42743078e-02f, -3.08254421e-01f, -2.62728870e-01f, -7.96472952e-02f,
  1.80260643e-01f, 9.44669824e-03f, -3.30347449e-01f, -1.57102704e-01f, 8.69013518e-02f, -1.20632634e-01f, -9.44248289e-02f, -5.92196286e-02f, 9.64383110e-02f, 3.15141499e-01f,
  -1.73106804e-01f, -1.41179517e-01f, -1.13721751e-01f, 7.29989260e-02f, 7.56727085e-02f, -2.20868997e-02f, -2.87972614e-02f, -6.37337938e-02f, 1.00057595e-03f, -3.90988849e-02f,
  7.38163367e-02f, 1.14123680e-01f, 6.42617047e-02f, 5.23388274e-02f, 1.65183078e-02f, 5.22463731e-02f, 9.13012028e-03f, -1.74024124e-02f, -5.94667085e-02f, 7.54436478e-02f,
  2.80845195e-01f, 1.99848667e-01f, -8.49906132e-02f, 5.33350334e-02f, -8.87092128e-02f, -6.60724118e-02f, -5.00671938e-02f, -1.25784874e-01f, -1.19445518e-01f, 7.43309706e-02f,
  -9.85568855e-03f, -1.36345113e-02f, 2.84225121e-02f, 3.50700282e-02f, 6.42396361e-02f, 1.50239309e-02f, 5.56999817e-02f, 5.80103174e-02f, 2.33274419e-02f, 1.98952723e-02f,
  1.56780817e-02f, -5.13897128e-02f, -4.45869640e-02f, -1.71589628e-02f, -5.97275468e-03f, 3.68441120e-02f, 2.54364014e-02f, 9.80193317e-02f, -8.18312094e-02f, 1.01077529e-02f,
  -3.28841503e-03f, -1.17584519e-01f, 1.77523512e-02f, -8.96894708e-02f, 1.23634972e-02f, -1.73511021e-02f, -1.29866935e-02f, 7.04987943e-02f, -2.84376778e-02f, -8.15706477e-02f,
  6.05208194e-03f, 1.03023678e-01f, 6.57428661e-03f, -3.42877954e-02f, -1.52342752e-01f, -1.11450940e-01f, 1.78011153e-02f, -7.28875697e-02f, 4.58242884e-03f, -9.87705067e-02f,
  -1.70078427e-02f, -3.39756673e-03f, 5.09314016e-02f, -5.03387935e-02f, -2.74195038e-02f, -2.06648391e-02f, 8.22398514e-02f, 3.39776427e-02f, 3.23448665e-02f, 3.99152264e-02f,
  8.87930840e-02f, -4.55523916e-02f, -6.57672882e-02f, -1.09740244e-02f, 1.82204507e-02f, -5.03421165e-02f, -3.74592356e-02f, -1.02042630e-01f, -1.82871759e-01f, -6.43815920e-02f,
  2.52202868e-01f, 3.13371494e-02f, -3.05020511e-01f, 1.96175873e-01f, -3.05362701e-01f, -4.01392281e-01f, -5.42420149e-01f, -6.73821196e-02f, 2.46563837e-01f, -2.42502987e-02f,
  -1.35772452e-01f, 6.64275587e-02f, 1.17468119e-01f, -7.27644376e-03f, -1.80698693e-01f, -1.68604448e-01f, -1.60484865e-01f, -1.08347125e-01f, -3.13988000e-01f, -2.44592324e-01f,
  -3.59971151e-02f, 8.41830522e-02f, -5.73676266e-03f, 2.34032366e-02f, 1.04226016e-01f, 1.97869286e-01f, 5.22804223e-02f, 9.95409340e-02f, 2.63182167e-02f, 1.75714254e-01f,
  9.99742001e-03f, -6.61228448e-02f, -1.20843016e-01f, 8.67864564e-02f, -9.24404934e-02f, -4.62498553e-02f, -1.14388600e-01f, -5.92220426e-02f, -1.06271185e-01f, 2.05832627e-02f,
  -9.37087759e-02f, -9.94767528e-03f, -9.83884484e-02f, -1.25123886e-03f, 7.03367544e-03f, -9.94774923e-02f, -1.17746973e-02f, -6.96301982e-02f, -1.46879166e-01f, 1.68781623e-03f,
  -8.43008757e-02f, -1.44894674e-01f, -2.67030388e-01f, -1.26338720e-01f, -1.50033951e-01f, -3.85317951e-02f, -1.04436375e-01f, 4.47720140e-02f, -1.76150173e-01f, 2.05482483e-01f,
  -5.35371155e-02f, 4.16420102e-02f, -4.17461526e-03f, 1.37243241e-01f, 1.64100993e-02f, 3.87913622e-02f, 2.87764929e-02f, 9.91359502e-02f, 4.56341691e-02f, 1.34383947e-01f,
  -2.88184732e-02f, 8.49083364e-02f, 6.37283199e-04f, 4.11579870e-02f, 3.76136554e-03f, -2.26788819e-02f, 5.89296147e-02f, 4.48026061e-02f, 9.81840491e-03f, -5.25789859e-04f,
  2.19703987e-02f, -4.40434702e-02f, 8.90840217e-02f, -2.67605819e-02f, -6.34006485e-02f, -7.75467837e-03f, -1.74700506e-02f, -5.78664504e-02f, 9.19318348e-02f, 3.76687124e-02f,
  2.13921726e-01f, -2.02084348e-01f, 1.75296709e-01f, 2.27425899e-02f, -6.40126541e-02f, 4.64662015e-02f, -8.63191264e-04f, 4.68496457e-02f, 1.03195291e-02f, -6.34514214e-03f,
  -1.42928645e-01f, -6.50944635e-02f, 1.14885814e-01f, -1.58903524e-02f, 6.05654763e-03f, -5.47385700e-02f, -3.94784212e-02f, -3.40159908e-02f, -4.27545011e-02f, -4.42477316e-02f,
  6.90579712e-02f, -6.48707077e-02f, -9.30209830e-02f, -9.49822217e-02f, -2.85993959e-03f, -1.58527404e-01f, 3.01349238e-02f, -3.99631336e-02f, -1.78812250e-01f, 9.62582231e-02f,
  -3.28754008e-01f, 1.33957908e-01f, -7.94588923e-02f, -1.07787266e-01f, 2.44732648e-01f, 8.24636146e-02f, 4.18841019e-02f, -4.79146130e-02f, 4.06291559e-02f, 3.39220390e-02f,
  1.08271174e-01f, 1.61825195e-01f, 1.99401408e-01f, -2.96761002e-02f, -1.74933299e-01f, -5.91235273e-02f, -1.91051081e-01f, -2.94598758e-01f, -1.16371289e-01f, 6.20279908e-02f,
  1.55116409e-01f, -1.01773061e-01f, -3.45577538e-01f, -1.16735741e-01f, 1.06773593e-01f, 1.97467059e-01f, -5.18948697e-02f, -7.66865090e-02f, 3.25408727e-02f, -9.77401435e-02f,
  9.21210423e-02f, 1.24058761e-01f, 1.01677865e-01f, 8.90522450e-02f, 1.23184048e-01f, 1.42086774e-01f, -2.49239281e-02f, 8.87608752e-02f, 1.36790618e-01f, 3.27740163e-02f,
  -2.48851757e-02f, 1.21306807e-01f, 1.26070321e-01f, 2.33318619e-02f, -7.63802081e-02f, -2.16003042e-03f, -2.67728250e-02f, -8.74912962e-02f, -1.23726726e-01f, 8.08409303e-02f,
  1.43770680e-01f, 3.63846160e-02f, -1.32803261e-01f, 2.79123206e-02f, 5.73218018e-02f, 2.79894937e-02f, 1.03354007e-01f, 8.36955570e-03f, -2.65044868e-02f, -1.15229487e-01f,
  -5.22307912e-03f, -6.94896979e-03f, -4.26933169e-02f, 1.00873848e-02f, -4.51096036e-02f, -2.21716543e-03f, -4.18351926e-02f, -1.38271332e-01f, 3.42347473e-02f, -1.47138163e-01f,
  -1.78218912e-02f, -7.33028129e-02f, 4.68569575e-03f, 6.26506433e-02f, 1.69290025e-02f, -1.71944544e-01f, -2.19643507e-02f, -6.88255355e-02f, -1.35702431e-01f, -1.07616968e-01f,
  -6.16390742e-02f, 4.90428917e-02f, -9.69729386e-03f, 1.23006040e-02f, -1.16371907e-01f, -3.36229838e-02f, -2.68965382e-02f, -1.14159301e-01f, -1.09879538e-01f, 2.89624389e-02f,
  1.27809808e-01f, 1.02657929e-01f, 2.59986334e-02f, 2.07571755e-03f, -2.84751914e-02f, 1.03300996e-01f, 6.84738383e-02f, -9.27526504e-03f, 2.02612933e-02f, -4.25770151e-04f,
  -3.49568985e-02f, -1.08745974e-02f, 1.61904812e-01f, 2.91170627e-02f, 1.33139268e-01f, 1.18102930e-01f, -4.42685857e-02f, 1.44851888e-02f, -2.77850069e-02f, 1.07475801e-03f,
  -2.61826883e-03f, -1.41736418e-01f, -2.04070017e-01f, -1.89961605e-02f, 3.75546440e-02f, -6.87951893e-02f, 7.92147666e-02f, 1.08037747e-01f, -2.81009749e-02f, 5.26384858e-04f,
  -5.17786205e-01f, 1.32538572e-01f, -2.36045241e-01f, -1.04476325e-01f, -3.86960432e-03f, -8.49358812e-02f, 1.10263685e-02f, -9.52964649e-02f, -8.53750706e-02f, 1.03053480e-01f,
  -7.43634403e-02f, -2.45639775e-02f, -2.85450742e-02f, -2.89502535e-02f, -4.11296599e-02f, 5.76897524e-02f, 1.21770032e-01f, -1.89930290e-01f, -2.24599704e-01f, -1.56328738e-01f,
  1.80121854e-01f, -8.04987852e-04f, -2.66144454e-01f, -5.05390838e-02f, 8.69911388e-02f, 5.15189255e-03f, -7.84249753e-02f, -1.94337629e-02f, -4.27922495e-02f, 3.42701524e-01f,
  -2.15644702e-01f, -4.50187102e-02f, 9.94214267e-02f, -6.77776560e-02f, -2.81343162e-02f, -1.57542247e-02f, -6.82479069e-02f, -1.26409912e-02f, -7.65041634e-02f, -7.25072548e-02f,
  -1.00505933e-01f, -7.09636360e-02f, -1.40434038e-02f, -1.51458243e-02f, -3.11155263e-02f, -6.59863725e-02f, -3.96444276e-03f, -1.64368555e-01f, 7.25704152e-03f, 1.10250907e-02f,
  -1.70467999e-02f, 1.12012895e-02f, -1.87772617e-01f, 2.99712773e-02f, -6.63426593e-02f, -1.11365184e-01f, -9.76042747e-02f, 3.77693810e-02f, -6.28475249e-02f, -8.30456018e-02f,
  6.39965534e-02f, 8.53961147e-03f, -5.67134880e-02f, -7.79211000e-02f, -5.58145205e-03f, 7.16566220e-02f, 5.97224198e-03f, -1.25542292e-02f, 2.13152543e-02f, -3.99813429e-02f,
  4.63358499e-02f, 8.66901278e-02f, 7.02582449e-02f, 7.52901137e-02f, 3.07376813e-02f, -7.09149390e-02f, 4.70152609e-02f, 4.13370878e-02f, 8.26946199e-02f, -4.64246236e-02f,
  7.87444040e-02f, -5.28278900e-03f, -9.30470228e-03f, 9.94035527e-02f, 5.64484261e-02f, 1.34926558e-01f, 2.95051578e-02f, 6.10088836e-03f, -4.04640809e-02f, 1.02866935e-02f,
  -4.60511632e-02f, -6.22338802e-02f, 6.39973134e-02f, -5.41563891e-02f, -1.20111536e-02f, 2.63172239e-02f, -8.81142542e-02f, -1.69858038e-02f, -4.87809516e-02f, -1.17587879e-01f,
  -2.73244195e-02f, -9.83034745e-02f, -7.56801069e-02f, -1.09683312e-02f, -1.48590595e-01f, -1.04309089e-01f, -5.56146801e-02f, 5.54248272e-03f, 2.87919417e-02f, -9.00914446e-02f,
  2.46047582e-02f, -1.72781989e-01f, -1.40853390e-01f, 1.58826530e-03f, -1.11846358e-01f, -1.36438578e-01f, -1.93076804e-01f, -1.11323252e-01f, -1.29142627e-01f, -1.65976211e-01f,
  4.28921543e-02f, -2.81886548e-01f, -3.03949922e-01f, 4.29466479e-02f, -1.08641468e-01f, -6.24333955e-02f, -2.70229578e-01f, 5.93138114e-02f, 2.33959138e-01f, -1.19552322e-01f,
  -4.73565161e-02f, 2.84820855e-01f, 2.48792604e-01f, 1.38308063e-01f, 4.39560786e-02f, -3.26444983e-01f, -2.89244443e-01f, -5.01011051e-02f, 1.33261070e-01f, 1.02125399e-01f,
  -8.41215998e-02f, 1.39270388e-02f, 1.23567618e-01f, 6.99625760e-02f, -1.64958790e-01f, 6.30146936e-02f, -1.11001953e-01f, 1.23932175e-02f, 1.22394459e-02f, -3.82788658e-01f,
  -2.86895066e-01f, -1.58914790e-01f, -8.45303945e-03f, 5.40842228e-02f, 1.09569905e-02f, 5.97874820e-02f, -2.29931138e-02f, 2.51938053e-03f, 1.26859382e-01f, -2.03643441e-02f,
  6.59766868e-02f, 2.27646483e-03f, 1.54407829e-01f, 8.01015124e-02f, 6.12790622e-02f, -3.24619673e-02f, 2.23789979e-02f, -5.89124858e-02f, 2.48169098e-02f, 2.29160544e-02f,
  -1.20076895e-01f, -1.76554900e-02f, -4.44975607e-02f, -8.51514563e-02f, 4.33767214e-02f, -1.63462886e-03f, -1.18027091e-01f, -2.45742570e-03f, 4.73422967e-02f, -1.48515433e-01f,
  -4.00575697e-02f, -4.82177772e-02f, -1.27482057e-01f, -2.30695847e-02f, -3.19192419e-03f, -1.94085632e-02f, 3.08499765e-02f, -7.13835135e-02f, -7.47668594e-02f, 1.22454306e-02f,
  5.28028570e-02f, -3.05883288e-02f, 1.34249926e-01f, -1.64870888e-01f, 6.04083948e-02f, 3.79387140e-02f, -3.60105070e-03f, -6.34760931e-02f, 8.50200802e-02f, 4.94753420e-02f,
  4.52675894e-02f, 7.54259303e-02f, 5.00501432e-02f, 8.44105054e-03f, 4.33729496e-03f, -5.75777031e-02f, -3.17063928e-02f, 4.17903997e-02f, -1.15192235e-01f, -1.24970935e-01f,
  1.98293298e-01f, 4.65881936e-02f, 7.29519781e-03f, -4.88506146e-02f, -6.47346303e-02f, 1.35420210e-04f, -3.72980833e-02f, -1.12702824e-01f, -6.48628101e-02f, -2.50557382e-02f,
  -4.65048961e-02f, -6.83265701e-02f, 3.82992849e-02f, -7.49505311e-02f, 1.95357632e-02f, -1.10435002e-01f, -1.09814785e-01f, 9.99756716e-03f, -1.18658701e-02f, -1.18230507e-02f,
  -6.04170226e-02f, -5.66694252e-02f, 3.55011411e-02f, -5.74388020e-02f, -4.10605744e-02f, 2.43060421e-02f, -1.39759421e-01f, -6.19928725e-02f, 5.61838076e-02f, -8.40571746e-02f,
  7.13067234e-01f, 1.70505092e-01f, -1.75094157e-01f, 1.40691981e-01f, -1.47418156e-02f, 3.80156748e-02f, 3.65566075e-01f, 9.29008201e-02f, -1.26198465e-02f, 1.62221417e-01f,
  -1.39571488e-01f, -2.60624528e-01f, -3.16467285e-01f, -3.67921025e-01f, -9.68511850e-02f, 1.20704599e-01f, 3.21886614e-02f, -3.40373963e-02f, -2.19034582e-01f, -1.17228076e-01f,
  -1.03262827e-01f, 1.38536751e-01f, 5.55351116e-02f, -5.11152893e-02f, -4.76467833e-02f, -1.99380562e-01f, 1.21892691e-01f, -7.74502829e-02f, -9.27862599e-02f, -4.09665108e-02f,
  -1.33979246e-01f, -2.76732203e-02f, -1.73668236e-01f, -2.07490772e-01f, -9.19635296e-02f, 1.78920738e-02f, -1.26609094e-02f, -2.56391373e-02f, -6.76814616e-02f, 4.52690199e-02f,
  -1.37417587e-02f, -1.30574331e-01f, -6.13926630e-03f, -1.93930104e-01f, -7.60633424e-02f, -3.54226902e-02f, -1.30669028e-01f, 9.72800609e-03f, -1.19315214e-01f, -2.62821913e-02f,
  -1.57853842e-01f, -3.59634534e-02f, -6.10845610e-02f, -1.21245213e-01f, -2.93873088e-03f, -1.66541860e-01f, -5.73014580e-02f, -3.50858979e-02f, -4.53613736e-02f, 9.43169147e-02f,
  2.26991400e-02f, -7.18751848e-02f, 3.10862679e-02f, 5.25010265e-02f, 6.39425740e-02f, 4.61684773e-03f, 1.25935078e-01f, -9.82045569e-03f, -2.37233080e-02f, 2.60741562e-02f,
  1.90623738e-02f, -1.34262117e-02f, -4.70465682e-02f, 6.73386157e-02f, 1.80799961e-02f, -1.70923788e-02f, 1.14667937e-01f, -1.67784896e-02f, 4.43340912e-02f, 5.40520400e-02f,
  6.57436103e-02f, 6.09749332e-02f, 7.91748427e-03f, 1.88728217e-02f, -3.13866958e-02f, -4.05778550e-02f, -6.65362850e-02f, -2.83043124e-02f, 2.65882574e-02f, -6.40239241e-03f,
  -2.08440572e-02f, -3.16612244e-01f, -7.79157355e-02f, -9.59361121e-02f, -9.32023227e-02f, -1.20059535e-01f, -7.15196282e-02f, -7.41092041e-02f, -1.03835031e-01f, -1.54453367e-01f,
  -8.99026170e-02f, 4.97808568e-02f, -8.75492245e-02f, -6.69634938e-02f, 2.46515311e-02f, -1.08207844e-01f, -1.17151756e-02f, -1.48683086e-01f, -1.40412793e-01f, 1.20675443e-02f,
  -5.41158728e-02f, 4.34696637e-02f, 3.92427035e-02f, 5.28680086e-02f, -5.84999174e-02f, -2.75420565e-02f, -6.10908791e-02f, -4.89464700e-02f, 4.96493839e-02f, 1.70356482e-01f,
  4.96910542e-01f, 3.26078087e-01f, -2.99692526e-02f, 1.06210010e-02f, -1.59568980e-01f, -2.16752454e-03f, 3.41291904e-01f, 1.38158038e-01f, 6.93083331e-02f, 1.46256983e-01f,
  5.66852055e-02f, -3.53629217e-02f, -1.87806770e-01f, -5.61613888e-02f, 2.46971607e-01f, 1.40134141e-01f, 2.09196396e-02f, -6.87486902e-02f, -1.20525239e-02f, -6.13445640e-02f,
  -1.41541630e-01f, 6.50806492e-03f, 6.66439310e-02f, 4.84296158e-02f, 6.43339530e-02f, 1.05158985e-01f, -3.61090829e-03f, -1.01861119e-01f, -5.32375202e-02f, -1.40067965e-01f,
  8.23472515e-02f, 1.62667915e-01f, -3.31951790e-02f, 3.37815471e-02f, 3.00789271e-02f, 3.97388227e-02f, 6.46151304e-02f, -6.89421371e-02f, 2.84419134e-02f, -2.10141633e-02f,
  1.28030181e-02f, 6.61707595e-02f, 3.44549939e-02f, 1.47680178e-01f, 1.06422640e-01f, 1.92557603e-01f, 1.02850765e-01f, 1.14044502e-01f, 6.75429329e-02f, 8.33304450e-02f,
  9.31098983e-02f, 6.62146136e-02f, 1.02388136e-01f, 1.73519760e-01f, 1.81726128e-01f, 1.86670367e-02f, 7.95218498e-02f, 1.83478631e-02f, 1.93518519e-01f, 3.01595479e-01f,
  4.42587584e-02f, -3.58049124e-02f, 7.96379671e-02f, 9.97719914e-02f, 9.44532454e-02f, -5.84434345e-02f, -2.39331573e-02f, -5.67429364e-02f, -3.29931490e-02f, 9.40403119e-02f,
  3.36435363e-02f, -3.81456576e-02f, -4.08900976e-02f, -9.62394923e-02f, -1.13378637e-01f, -1.01776011e-01f, -9.64258313e-02f, 2.31442973e-02f, -3.27449441e-02f, 2.14052647e-02f,
  7.67486170e-02f, -1.10356286e-01f, 2.30193045e-02f, -5.40380478e-02f, -4.40395102e-02f, -1.02340847e-01f, -9.30295419e-03f, -7.09628593e-03f, -2.42795460e-02f, -1.51046738e-01f,
  2.24690899e-01f, -1.26257285e-01f, 1.15921326e-01f, 7.24140629e-02f, 3.46939676e-02f, 9.33454558e-02f, 7.91232884e-02f, 9.91245508e-02f, 3.05122621e-02f, 1.69421807e-01f,
  5.46039231e-02f, 5.99078350e-02f, 4.28676456e-02f, 1.09752640e-01f, 1.52406707e-01f, 1.56053901e-01f, 1.57748103e-01f, 7.95808733e-02f, 2.46071853e-02f, 3.40941846e-02f,
  1.75662264e-01f, 1.02384873e-01f, 1.54315740e-01f, 1.39086366e-01f, -2.17347257e-02f, 1.48952112e-01f, 1.42599285e-01f, 1.49952516e-01f, 1.90115273e-01f, 3.69348437e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.16146827e-01f, 2.44509980e-01f, 7.66508356e-02f, 1.07820250e-01f, 1.52155653e-01f, 3.34927589e-01f, 5.79731226e-01f, 3.09693366e-01f, 8.21445137e-03f, 1.05629943e-01f,
  -2.56393626e-02f, -1.28708214e-01f, 1.03830025e-02f, 6.40499871e-03f, -2.03868318e-02f, -1.44446921e-02f, 1.56590138e-02f, -3.52583975e-02f, -1.03896327e-01f, 5.59667051e-02f,
  -1.53434128e-02f, 6.13843724e-02f, -1.55393466e-01f, -4.27301377e-02f, -6.31019399e-02f, -1.17274798e-01f, -2.22102273e-02f, 4.74725515e-02f, 2.14530099e-02f, -1.04089394e-01f,
  -2.74206489e-01f, 2.43106633e-01f, -1.45845581e-02f, -7.66789615e-02f, -3.83691341e-02f, -1.95316058e-02f, 5.36001846e-02f, -1.20213330e-01f, -1.16594955e-01f, -1.66301653e-01f,
  -1.50023863e-01f, -5.78807145e-02f, 2.77195215e-01f, 1.45625278e-01f, 1.49599081e-02f, -2.83405874e-02f, 4.44469862e-02f, 1.07930750e-01f, -1.73903674e-01f, -9.02604014e-02f,
  6.35750294e-02f, 9.59301516e-02f, 1.70674566e-02f, 7.37284198e-02f, 8.67708251e-02f, 9.23487917e-02f, 3.70995961e-02f, 1.54232889e-01f, -3.63180321e-03f, 6.59637675e-02f,
  6.63532410e-03f, -8.80805627e-02f, 1.03384815e-01f, 9.08502266e-02f, -4.48973704e-04f, 2.15013567e-02f, 9.39565599e-02f, -2.26608925e-02f, 1.50152028e-01f, 1.10425182e-01f,
  5.31589501e-02f, 4.26454321e-02f, 7.51432637e-03f, 1.44988745e-01f, 1.31945968e-01f, 7.35237822e-02f, -9.50317457e-02f, 2.91477446e-03f, -6.56797960e-02f, -7.68743083e-02f,
  5.61672747e-02f, 1.23739883e-01f, 1.93517849e-01f, 8.89621228e-02f, 1.12080552e-01f, 3.49451043e-02f, 3.45159844e-02f, 8.29371624e-03f, 3.41285393e-02f, 3.12933922e-02f,
  -4.91808623e-01f, 2.26786003e-01f, 6.17881380e-02f, -3.33081186e-02f, 6.10022023e-02f, 4.02573682e-02f, -5.40455943e-03f, -2.76022777e-02f, -2.55530953e-01f, -1.15012608e-01f,
  -7.09779486e-02f, 1.47392765e-01f, 2.06225961e-01f, 5.59983365e-02f, 1.23759955e-02f, -1.04304977e-01f, 7.28367567e-02f, 1.61983967e-01f, -6.67150691e-02f, -2.81681955e-01f,
  6.32989081e-03f, 2.84892134e-02f, -5.45940138e-02f, 7.03793541e-02f, 4.91775535e-02f, -9.93917808e-02f, 7.39583522e-02f, 6.92092702e-02f, -9.01239458e-03f, -3.54086235e-02f,
  -2.62680709e-01f, -3.20112221e-02f, -3.58306944e-01f, 6.29426986e-02f, 2.27648631e-01f, 1.19697042e-01f, 3.33610103e-02f, -6.87881261e-02f, -5.60167357e-02f, 2.22183135e-03f,
  -6.27241805e-02f, 1.18084334e-01f, 5.29430695e-02f, 1.23190507e-01f, -1.41833574e-02f, 1.56044722e-01f, 3.59548211e-01f, 5.77062406e-02f, -1.25992700e-01f, 2.95348931e-02f,
  3.26045096e-01f, 3.38750239e-03f, -2.94879049e-01f, 4.30130213e-03f, 1.62010714e-01f, 9.17073041e-02f, -2.78117172e-02f, 1.67859927e-01f, 4.54921164e-02f, 4.98138994e-01f,
  -1.92089453e-01f, -2.42977306e-01f, -2.32831053e-02f, 1.42227684e-03f, -3.49520892e-02f, -1.39825106e-01f, -1.05637141e-01f, -1.21691205e-01f, -1.14979208e-01f, -7.55430236e-02f,
  -2.48571318e-02f, -1.18434586e-01f, 1.57632470e-01f, 6.39181435e-02f, -3.95845547e-02f, 4.21995930e-02f, -1.08867444e-01f, -1.63333416e-01f, -3.14002007e-01f, -9.31155235e-02f,
  3.04687530e-01f, 1.99767172e-01f, -5.05656600e-02f, 4.46469001e-02f, -1.08249873e-01f, -7.90908858e-02f, -6.64253235e-02f, -7.95367807e-02f, -4.05016422e-01f, -1.18475564e-01f,
  -3.59863006e-02f, -2.03251094e-02f, -4.42825668e-02f, 6.21781796e-02f, -1.33750653e-02f, 9.67934355e-02f, 1.05830081e-01f, 3.64575870e-02f, 1.15283132e-01f, -1.06960654e-01f,
  1.09890632e-01f, -9.48285963e-03f, -6.02936335e-02f, -9.20605212e-02f, 2.28455644e-02f, -1.45527283e-02f, 1.49521843e-01f, 2.79768761e-02f, 4.10377933e-03f, -1.82880908e-01f,
  -2.37102937e-02f, -2.64014304e-02f, -5.01192287e-02f, 4.60198298e-02f, -6.35588765e-02f, 4.72921617e-02f, -3.79014984e-02f, -7.27865770e-02f, 6.02722494e-03f, 2.70084105e-02f,
  -6.97977394e-02f, -2.30487064e-01f, 1.71623990e-01f, -2.50853281e-02f, -8.33250433e-02f, 9.99883190e-03f, -7.51657709e-02f, -1.85813736e-02f, 6.94681937e-03f, 1.27018383e-02f,
  -1.18352063e-01f, -1.28876314e-01f, -7.22676050e-03f, -1.45670548e-01f, -1.38367862e-02f, -3.99165824e-02f, 7.41659701e-02f, 9.85932127e-02f, -4.50359248e-02f, 2.18098145e-02f,
  1.17222771e-01f, -4.02066819e-02f, 1.40491575e-02f, -4.04236093e-02f, -5.76434135e-02f, -1.24353811e-03f, -8.90563428e-02f, -1.46446913e-01f, -2.46247470e-01f, -9.17712450e-02f,
  -7.25168109e-01f, 3.63020957e-01f, -2.96460986e-01f, -2.02946126e-01f, -1.14240259e-01f, -9.72865447e-02f, -5.32030240e-02f, -6.81812167e-02f, -2.03567937e-01f, 1.01257317e-01f,
  1.16190419e-01f, -1.01342112e-01f, -3.32296699e-01f, -1.52247041e-01f, -4.17345196e-01f, -2.50481009e-01f, -1.94737554e-01f, -6.82897449e-01f, -7.11126685e-01f, -1.57276317e-02f,
  5.68766035e-02f, -3.11354458e-01f, -3.01650435e-01f, -1.89694203e-02f, 2.65248299e-01f, -2.21579015e-04f, -1.33302566e-02f, -1.05109110e-01f, 8.21435899e-02f, 1.22524507e-01f,
  -2.99173474e-01f, -2.17365324e-02f, -7.49201775e-02f, 9.93652865e-02f, 7.85739049e-02f, -4.61490229e-02f, -1.09649219e-01f, -1.13202818e-01f, -3.67864221e-02f, -2.24286281e-02f,
  -4.83007394e-02f, 6.82936385e-02f, -2.56839305e-01f, 1.62143528e-01f, -1.12385087e-01f, -3.69786774e-03f, 1.83204174e-01f, -1.08786061e-01f, 1.24923019e-02f, 1.09927930e-01f,
  2.31574997e-01f, 1.58511344e-02f, 1.01140872e-01f, 1.25578374e-01f, -2.95602176e-02f, -3.57208890e-03f, 2.24259183e-01f, 1.74532607e-01f, 5.20145334e-02f, 2.18923047e-01f,
  -4.10697348e-02f, -1.13626428e-01f, 1.11022756e-01f, 1.00055285e-01f, -3.77803631e-02f, -1.22810826e-01f, -7.70206526e-02f, -5.28355315e-02f, -8.53171125e-02f, 1.12937605e-02f,
  1.27944246e-01f, -3.16010006e-02f, -7.10062459e-02f, 3.21950130e-02f, 1.30617293e-03f, 1.66575871e-02f, -7.85148665e-02f, 4.87220846e-02f, 8.54833424e-02f, 9.35149044e-02f,
  7.64909461e-02f, 8.84786397e-02f, 5.49195195e-03f, 6.88162819e-02f, 4.75025848e-02f, 9.82435420e-02f, 3.79423089e-02f, 8.10677558e-02f, 1.04376338e-02f, 1.82062387e-02f,
  -1.91049621e-01f, -2.19566628e-01f, -5.26225083e-02f, 1.24287955e-01f, -3.03078610e-02f, 1.63357910e-02f, 9.58506763e-02f, 7.72823906e-03f, -1.28369126e-02f, 9.73037928e-02f,
  8.85097012e-02f, -1.09080210e-01f, -1.63755432e-01f, 1.63283020e-01f, -1.34975463e-01f, 3.64915729e-02f, 1.63282350e-01f, 2.80367322e-02f, -8.54138732e-02f, 1.81945086e-01f,
  1.17170870e-01f, 2.82620210e-02f, -7.98156783e-02f, 1.25613838e-01f, -2.25663334e-02f, -1.18301049e-01f, -5.08142589e-03f, -5.52918725e-02f, -1.06705539e-01f, 6.69766441e-02f,
  1.43088087e-01f, -3.99384260e-01f, 2.55258102e-02f, 2.45697156e-01f, 1.26603425e-01f, 2.26323798e-01f, 1.75372399e-02f, 3.02050933e-02f, 2.70462353e-02f, 9.61090103e-02f,
  1.18882343e-01f, 1.89112201e-01f, 1.37173623e-01f, 7.36935958e-02f, 7.41622001e-02f, 2.57525314e-02f, -7.49298334e-02f, 1.59858719e-01f, 3.72605711e-01f, 1.23076782e-01f,
  6.53650388e-02f, -1.09316789e-01f, 1.70326773e-02f, -4.29587364e-02f, -1.82503760e-01f, 1.97510570e-01f, -1.50231361e-01f, -2.11183488e-01f, -7.01488107e-02f, -1.72789812e-01f,
  1.45665621e-02f, -3.45341444e-01f, 1.97622225e-01f, -7.62718841e-02f, 2.59430520e-03f, -3.04344185e-02f, 3.37793715e-02f, -8.74999464e-02f, -1.16253361e-01f, -1.27589896e-01f,
  -1.15924012e-02f, -9.86603051e-02f, 8.77331793e-02f, -1.79632112e-01f, -4.35969830e-02f, -7.93909058e-02f, -1.45226195e-01f, -2.80982535e-03f, -3.32831740e-02f, -5.76781593e-02f,
  -6.76672161e-02f, -1.04639055e-02f, -2.61573587e-02f, -8.87981430e-03f, 9.69911087e-03f, 3.52639053e-03f, -1.08691759e-01f, -1.17561877e-01f, -1.15528945e-02f, 4.76845278e-04f,
  -1.88040566e-02f, 4.47947010e-02f, -9.58790246e-04f, 1.40819922e-01f, 9.77726579e-02f, -3.29839438e-02f, -7.03342631e-02f, 5.20119295e-02f, 3.70295420e-02f, 5.78843206e-02f,
  3.12798955e-02f, 7.20473006e-02f, -2.23620627e-02f, 1.94488361e-01f, 2.18436316e-01f, 8.58692750e-02f, -1.59614086e-01f, -6.17097924e-03f, -1.58293378e-02f, 1.13082282e-01f,
  1.45330250e-01f, 9.39896926e-02f, -6.58518896e-02f, -5.17944619e-02f, 3.70283090e-02f, 6.69295043e-02f, 1.43175933e-03f, 1.05045535e-01f, -1.70014873e-02f, 1.22837827e-01f,
  2.87775183e-03f, -3.30650918e-02f, 1.39830619e-04f, -4.86544035e-02f, -3.12444624e-02f, -1.20463222e-01f, 9.41354260e-02f, -1.07630014e-01f, -2.23260790e-01f, 3.81805748e-02f,
  4.44060843e-03f, -7.15648457e-02f, 1.13349808e-02f, -1.47452548e-01f, 1.73488855e-01f, 1.37178570e-01f, -7.64584094e-02f, 1.00696519e-01f, -6.58875331e-04f, -6.39006272e-02f,
  -5.15115410e-02f, 2.50034094e-01f, 1.83097899e-01f, 1.66212454e-01f, 6.70049861e-02f, 6.72240779e-02f, 3.61910947e-02f, 7.29300007e-02f, 6.50955886e-02f, 1.34450272e-01f,
  2.43229806e-01f, 3.97275575e-03f, 1.09291144e-01f, 4.33781266e-01f, 1.52405888e-01f, 2.91929573e-01f, 1.40420914e-01f, 1.76626682e-01f, 2.29250193e-01f, 1.98878363e-01f,
  2.48192817e-01f, 2.74353325e-01f, 1.38984472e-01f, 1.83039770e-01f, 1.93445608e-01f, 6.86669722e-02f, 5.68158627e-02f, 6.31530583e-02f, 5.22063486e-02f, 2.66367763e-01f,
  1.67399392e-01f, 9.33469608e-02f, -7.56815299e-02f, -3.53359953e-02f, 3.93288285e-02f, 1.09665245e-01f, 9.28736255e-02f, -2.51660738e-02f, 1.07719719e-01f, 1.14126489e-01f,
  -1.28592223e-01f, 1.12622090e-01f, 1.31708950e-01f, 1.38906138e-02f, -8.35848153e-02f, -1.80509746e-01f, -5.37780114e-02f, -6.45835325e-02f, -1.67051345e-01f, -1.79064929e-01f,
  -1.09321013e-01f, -7.84010962e-02f, -2.29036715e-02f, -7.97265097e-02f, -2.22877488e-01f, -1.76852539e-01f, -7.56358877e-02f, -3.08853872e-02f, 1.62961438e-01f, 1.16874993e-01f,
  1.16694614e-01f, 8.44523497e-03f, 5.81464432e-02f, 5.24525493e-02f, 4.74307090e-02f, -2.84352601e-02f, -8.69565532e-02f, -5.50032035e-02f, -1.29496967e-02f, 5.16395904e-02f,
  1.87046528e-01f, -1.79898106e-02f, 4.54031378e-02f, 4.94428072e-03f, 6.65713996e-02f, 4.43783868e-03f, 3.94796673e-03f, 1.14229530e-01f, 3.74297351e-02f, -1.31964847e-01f,
  -1.35194175e-02f, 2.51073718e-01f, 6.87090531e-02f, -9.88142658e-03f, 3.46041843e-02f, 8.25769082e-02f, -6.11393936e-02f, 5.71764819e-02f, 2.49095988e-02f, 3.38593274e-02f,
  6.87014759e-02f, -6.60021305e-02f, -1.68398470e-01f, -7.71571230e-03f, -2.96982517e-03f, 3.84223573e-02f, 6.88240752e-02f, 2.39808392e-02f, -6.97897524e-02f, -2.54460201e-02f,
  -6.11050911e-02f, 3.47157955e-01f, 5.01774177e-02f, 9.57342610e-02f, -1.63753465e-01f, -1.93935782e-01f, 2.41382062e-01f, -7.52748400e-02f, -1.36234701e-01f, -2.05653291e-02f,
  -1.08512692e-01f, -1.34787619e-01f, -3.54109779e-02f, -7.76569322e-02f, -1.39565676e-01f, -9.80982482e-02f, -1.05688520e-01f, 2.77985949e-02f, 1.35930941e-01f, -3.83648612e-02f,
  -3.50871198e-02f, 1.19560696e-02f, 5.57979047e-02f, -2.61018774e-03f, 8.42749104e-02f, 1.33064494e-01f, -8.76118168e-02f, -1.12989560e-01f, 2.74837948e-02f, -1.42552182e-01f,
  -3.49377275e-01f, -2.36709148e-01f, -1.57453045e-01f, -3.46606523e-01f, -3.55164349e-01f, -1.15482494e-01f, -3.16533357e-01f, -2.16479793e-01f, -2.69924313e-01f, -4.17827904e-01f,
  -1.84754908e-01f, 2.86207139e-01f, 2.17478618e-01f, 2.14857370e-01f, 1.46485254e-01f, -3.31049174e-01f, -4.33918655e-01f, 3.98002639e-02f, 5.51903546e-01f, 5.00401147e-02f,
  -1.94995508e-01f, -1.97658483e-02f, 1.60814866e-01f, 1.54513672e-01f, -5.11651002e-02f, 2.12899223e-01f, -1.17667252e-03f, -1.04612783e-01f, 6.20036833e-02f, -3.82494032e-01f,
  1.41293034e-01f, -2.82663912e-01f, -7.88634922e-03f, -2.02685613e-02f, 6.28637075e-02f, -9.89597738e-02f, 8.82925186e-03f, 4.75858189e-02f, -1.54366300e-01f, -1.17835343e-01f,
  -1.29435718e-01f, 3.74707952e-02f, 1.69570327e-01f, 1.36763066e-01f, 1.09843925e-01f, -3.25739309e-02f, 1.11778073e-01f, 3.20411213e-02f, -1.00621711e-02f, -1.51903490e-02f,
  -4.17692922e-02f, -9.75788310e-02f, -1.54137583e-02f, 7.36747235e-02f, -1.98350735e-02f, 1.20632358e-01f, 1.39411688e-01f, 1.74999796e-02f, 6.05548359e-02f, 2.74692830e-02f,
  -3.29376645e-02f, 1.00929672e-02f, 2.45046820e-02f, -2.59697661e-02f, -5.74132688e-02f, -1.04388185e-01f, 3.23750451e-03f, 6.41946914e-03f, 1.45785898e-01f, 4.09701951e-02f,
  -5.59138842e-02f, -8.11696276e-02f, -4.19613831e-02f, -1.78157389e-01f, -1.61983743e-02f, 1.05974125e-02f, -8.02503712e-03f, -3.40037867e-02f, -4.24735621e-02f, 1.03480276e-02f,
  -5.28450087e-02f, 5.71473949e-02f, 6.04773639e-03f, 1.48735270e-01f, -5.91204800e-02f, -2.64732987e-02f, -1.45446071e-02f, 8.90980735e-02f, 3.76331131e-03f, 1.46990642e-02f,
  1.75974131e-01f, -1.55004799e-01f, 1.20190214e-02f, 9.11313295e-02f, -1.76101495e-02f, -6.69591948e-02f, -1.09028906e-01f, 2.54409928e-02f, 9.42355022e-04f, -5.57383783e-02f,
  -2.90078972e-03f, -1.47330761e-01f, 3.98821309e-02f, 3.52366045e-02f, 7.69822299e-02f, 3.25987278e-03f, -8.29817355e-02f, -4.22748961e-02f, -1.02386445e-01f, -1.14003792e-02f,
  -1.33394957e-01f, -1.60103992e-01f, 4.97091673e-02f, 3.69523130e-02f, -4.51563857e-03f, -1.74787249e-02f, 1.10891603e-01f, 9.25293490e-02f, 3.45704146e-02f, -7.49838874e-02f,
  -8.18464085e-02f, -1.07085072e-01f, -5.43856382e-01f, -3.15508425e-01f, -3.45954090e-01f, -2.19247296e-01f, -6.43109679e-02f, 1.15075499e-01f, 3.32374834e-02f, -2.57695258e-01f,
  -3.54001001e-02f, 2.20368579e-01f, 6.51720911e-02f, 7.68855587e-02f, 1.47070708e-02f, -4.02434319e-01f, -3.67371649e-01f, -4.71587069e-02f, 2.70677149e-01f, 1.21392220e-01f,
  1.10906430e-01f, 8.98313820e-02f, 8.51491168e-02f, -2.40934622e-02f, -2.27253795e-01f, -4.98457998e-02f, -2.22318977e-01f, -1.65333331e-01f, -9.68505293e-02f, -4.36149329e-01f,
  -1.69854209e-01f, -9.46433172e-02f, 1.03328094e-01f, 3.57531197e-02f, -1.29762873e-01f, 1.50903806e-01f, 6.45073876e-02f, -2.12663766e-02f, 2.34021284e-02f, -4.99230511e-02f,
  6.34078728e-03f, 4.34355102e-02f, 1.70039564e-01f, -7.12754428e-02f, -1.72806736e-02f, -5.82012348e-02f, -2.41848547e-02f, 6.47048205e-02f, 9.85157192e-02f, -5.44715263e-02f,
  -1.78626888e-02f, 1.02483213e-01f, -2.91785561e-02f, -5.65066263e-02f, 1.85560882e-02f, 8.19372013e-02f, 4.34735417e-02f, 8.01385418e-02f, 2.17934325e-02f, -1.98785365e-02f,
  -2.00726707e-02f, 6.38928935e-02f, 1.22090265e-01f, 1.70154288e-01f, 1.82718456e-01f, 5.13989478e-02f, 4.19932567e-02f, 2.03514621e-01f, 6.48932233e-02f, -5.58546931e-02f,
  -5.87008782e-02f, -9.19139460e-02f, 1.24113292e-01f, 2.26732269e-02f, 1.98150966e-02f, -8.58469531e-02f, -1.06372140e-01f, -2.08573174e-02f, 5.67035824e-02f, 3.81451808e-02f,
  -3.73271927e-02f, 5.64755350e-02f, 3.66264791e-03f, -9.32185352e-03f, -3.88624482e-02f, -5.75898848e-02f, -8.67737159e-02f, 3.06644980e-02f, -4.24546562e-02f, -6.64724633e-02f,
  -1.23949520e-01f, -1.29436627e-01f, -1.07373737e-01f, 1.51127070e-01f, -4.30710763e-02f, -1.03603892e-01f, -9.93183926e-02f, 4.01056595e-02f, 1.34897055e-02f, -2.69718226e-02f,
  -4.01476361e-02f, -6.82060570e-02f, -8.19808245e-02f, -2.00317241e-02f, -1.25408163e-02f, 8.01386014e-02f, -1.38777019e-02f, 6.41236082e-02f, 3.39198746e-02f, -9.53470841e-02f,
  -4.82635088e-02f, 3.22970487e-02f, 1.89308643e-01f, -7.76666775e-02f, -5.94626926e-02f, 1.09311953e-01f, -8.98943096e-02f, 3.93876137e-04f, -2.00562309e-02f, -6.95095211e-02f,
  -1.88425362e-01f, 3.79348665e-01f, 1.55287653e-01f, 4.30144975e-03f, 1.26114100e-01f, 2.94775635e-01f, 4.97046739e-01f, 8.45471919e-02f, -9.50394291e-03f, 1.34804159e-01f,
  2.62928903e-02f, -1.09735362e-01f, 1.52978511e-03f, 1.01918563e-01f, 1.08420432e-01f, 2.79341638e-01f, 2.72817016e-01f, -7.06660375e-02f, -9.02209952e-02f, 8.88412595e-02f,
  1.58263580e-03f, -3.04151792e-03f, -2.14133620e-01f, 2.64888071e-02f, 1.76908508e-01f, -1.36101142e-01f, -2.46665608e-02f, 6.31947070e-02f, 1.07680991e-01f, 2.05767870e-01f,
  -2.26370245e-01f, 1.50212407e-01f, -1.23583049e-01f, -9.92169604e-02f, -1.43695876e-01f, -1.66948229e-01f, -2.94287559e-02f, -6.46714494e-02f, -4.11816984e-02f, -8.22530240e-02f,
  5.53959571e-02f, -2.35724803e-02f, 1.68314725e-01f, 1.38028353e-01f, 3.71417254e-02f, 9.49772745e-02f, -3.10762157e-03f, 3.80866714e-02f, -1.56828716e-01f, -2.25660298e-02f,
  6.20892271e-02f, 5.57594411e-02f, 8.94185305e-02f, 1.89474106e-01f, 1.86869428e-01f, -4.19244170e-02f, -3.19018424e-03f, 1.65896416e-01f, -1.04731098e-01f, -2.12444663e-02f,
  -2.41712630e-01f, -2.93594580e-02f, 9.40888152e-02f, 1.38052041e-02f, -5.34013510e-02f, -5.35999388e-02f, 3.59296203e-02f, 1.26723185e-01f, 2.30780002e-02f, 1.00572765e-01f,
  -8.59644488e-02f, 1.80340298e-02f, -9.14788619e-02f, -5.35876825e-02f, -9.77585986e-02f, 8.63394141e-02f, 1.78744450e-01f, 9.64881200e-03f, 7.62691498e-02f, 8.87547582e-02f,
  3.47566679e-02f, -1.12466313e-01f, -4.01531868e-02f, 2.81530451e-02f, -1.03069814e-02f, -6.03186972e-02f, -3.62085961e-02f, -4.55985516e-02f, -9.82825980e-02f, -1.47379175e-01f,
  -3.87368321e-01f, 3.92562039e-02f, 3.77960801e-02f, 7.51460809e-03f, 5.09187542e-02f, -4.48267646e-02f, -2.39426106e-01f, -8.47211778e-02f, -7.84305483e-02f, -9.78549272e-02f,
  -2.80230120e-03f, -1.32061139e-01f, -3.45985815e-02f, -2.74080075e-02f, -1.20098829e-01f, -3.12725306e-02f, 7.82490894e-03f, -6.01083152e-02f, -1.84944868e-01f, -1.58980653e-01f,
  2.15964951e-02f, 2.02837153e-04f, -2.00381000e-02f, 3.89935300e-02f, -6.84683025e-02f, -2.41667986e-01f, -9.85347182e-02f, -9.09581594e-03f, -1.02483034e-01f, -1.36455044e-01f,
  4.50259745e-01f, 5.46375550e-02f, 1.32436916e-01f, 2.73061041e-02f, -3.95577639e-01f, -5.13041377e-01f, -6.15897059e-01f, -4.29792494e-01f, -2.56077066e-04f, -4.86645009e-03f,
  -8.76236707e-02f, 1.38460636e-01f, 1.54459327e-01f, 2.68906713e-01f, -1.03876311e-02f, -7.55271986e-02f, 2.05597550e-01f, 4.27704066e-01f, 1.33697748e-01f, 3.62138785e-02f,
  1.22023843e-01f, 2.83063680e-01f, 2.84261823e-01f, 1.99986830e-01f, 2.36225352e-01f, 1.14807226e-01f, 3.56807485e-02f, 1.90694287e-01f, 2.10085958e-01f, 6.06133699e-01f,
  2.28750303e-01f, -2.67067347e-02f, -3.10707949e-02f, 1.42924085e-01f, 8.05255622e-02f, 1.38638943e-01f, 4.63435985e-02f, 6.18251748e-02f, -8.70534554e-02f, -6.70601279e-02f,
  8.50499049e-02f, 6.65768608e-02f, 2.63148341e-02f, 7.66928047e-02f, -3.34511064e-02f, -2.40152366e-02f, 1.12707034e-01f, 1.11382246e-01f, 4.30761464e-02f, -1.08628146e-01f,
  -5.98371886e-02f, -9.72299576e-02f, -2.09093288e-01f, -3.46202433e-01f, -1.81994081e-01f, 8.41110796e-02f, -7.16611519e-02f, 1.50597274e-01f, -3.77117866e-03f, 1.94369376e-01f,
  -9.22802240e-02f, 1.03839114e-01f, 1.91285461e-02f, 3.23157944e-02f, 4.71973531e-02f, -1.03519388e-01f, 8.55153427e-02f, -3.49785089e-02f, -4.78314087e-02f, 1.13252044e-01f,
  -1.44851178e-01f, -9.60091874e-02f, -5.62989898e-02f, -1.01530135e-01f, 6.51856065e-02f, 4.94925715e-02f, 5.00711501e-02f, -4.49988358e-02f, -8.35760534e-02f, -2.13904940e-02f,
  3.18222120e-02f, -9.64717939e-02f, 5.27786603e-03f, 8.35934356e-02f, -3.57792457e-03f, 6.58079460e-02f, -2.11832467e-02f, -4.68456373e-02f, -2.56446801e-04f, 1.02689393e-01f,
  -2.31529310e-01f, -1.25159666e-01f, 2.10483119e-01f, 1.39949247e-01f, 7.67873675e-02f, 5.52773811e-02f, 1.30334839e-01f, 7.76229203e-02f, -1.62911639e-02f, 3.55649292e-02f,
  3.68741970e-03f, 5.19601852e-02f, 1.06701488e-03f, 2.63824556e-02f, -1.98237170e-02f, -5.34904480e-04f, 3.82770076e-02f, 2.34077685e-02f, 3.57703306e-02f, -1.31716043e-01f,
  -4.13194075e-02f, -1.63469896e-01f, -1.42098248e-01f, -1.70948833e-01f, -1.01585817e-02f, 3.92002659e-03f, 4.29253356e-04f, 3.56577113e-02f, -7.89719075e-02f, -1.77888855e-01f,
  2.25514665e-01f, -9.26723778e-02f, -1.02854244e-01f, -5.51084653e-02f, -1.30216539e-01f, -2.99734119e-02f, -2.25454956e-01f, -4.94455844e-02f, -1.59479603e-01f, -2.00622633e-01f,
  8.57753232e-02f, 2.76284486e-01f, 3.52506220e-01f, 2.78803378e-01f, 3.05071324e-01f, -7.45847523e-02f, -1.66342214e-01f, 2.76795983e-01f, 4.31317657e-01f, 2.67368883e-01f,
  3.86283249e-02f, -1.15046836e-01f, 6.99060038e-02f, -8.48879069e-02f, -2.03504607e-01f, 1.48029983e-01f, -2.32490793e-01f, -1.83805645e-01f, -9.56668779e-02f, -2.88945347e-01f,
  2.14034915e-01f, -3.45324315e-02f, 9.46359336e-02f, -8.72012973e-02f, -1.46027967e-01f, -3.92718986e-02f, 8.18395317e-02f, -8.73185843e-02f, -5.90495653e-02f, -1.69129714e-01f,
  4.98960912e-02f, -5.95433898e-02f, -6.22366108e-02f, -7.98480287e-02f, -2.26089150e-01f, -3.07614449e-02f, -2.48540789e-01f, 3.46306041e-02f, -9.28933769e-02f, 2.70562600e-02f,
  -3.50997411e-02f, 2.79493053e-02f, 1.74952541e-02f, -4.98065092e-02f, 1.12738246e-02f, 1.64110169e-01f, -1.59551397e-01f, -1.08648948e-01f, -3.29306275e-02f, -2.54707158e-01f,
  -9.50569659e-02f, -1.12868324e-02f, 2.12707054e-02f, 1.05616659e-01f, -1.28765805e-02f, 7.66605511e-02f, 1.21952035e-02f, -1.41450495e-03f, 7.59703219e-02f, 1.74626224e-02f,
  -3.31459120e-02f, -5.60066700e-02f, 4.63062599e-02f, -4.73608486e-02f, 2.10243687e-02f, -5.16458228e-02f, 7.19223469e-02f, 1.47021815e-01f, -4.05102149e-02f, -9.08377171e-02f,
  5.01849875e-02f, 1.58300474e-02f, -6.60555251e-03f, 6.33293539e-02f, 3.68931629e-02f, 2.24916227e-02f, 4.42967489e-02f, 3.99125665e-02f, -4.01409492e-02f, 4.16256227e-02f,
  -4.56043743e-02f, 5.43260500e-02f, 1.35892183e-01f, 3.07341963e-02f, 1.32401688e-02f, 2.81526670e-02f, 1.15258031e-01f, -7.98357949e-02f, -4.05389853e-02f, 4.19267453e-02f,
  8.70652795e-02f, 1.19410746e-01f, -1.24045825e-02f, -6.06698953e-02f, 6.44067079e-02f, 1.02332741e-01f, -1.23803549e-01f, 1.11404002e-01f, 6.22856170e-02f, -4.04210500e-02f,
  -4.19049859e-02f, 9.58205014e-02f, 2.25889087e-01f, 1.95603594e-01f, 9.21673104e-02f, 2.66332507e-01f, 1.28605381e-01f, 3.30704218e-03f, 8.22867602e-02f, -7.45844394e-02f,
  -8.26931477e-01f, -2.16494799e-01f, 1.87209487e-01f, -9.07928944e-02f, 1.46148637e-01f, 1.00975916e-01f, 1.43715143e-01f, -7.46965334e-02f, -1.27551839e-01f, -4.15116958e-02f,
  -4.44992855e-02f, 1.77632598e-03f, 1.13905378e-01f, 1.37868732e-01f, 6.23919778e-02f, 2.26767868e-01f, 2.17833012e-01f, -9.01559740e-03f, 2.36595854e-01f, 2.55511731e-01f,
  1.09774567e-01f, -7.43043646e-02f, -2.33039439e-01f, 2.99110971e-02f, 6.86559081e-02f, 2.73294389e-01f, 2.11289868e-01f, 1.58624515e-01f, 1.92616567e-01f, 8.15336108e-02f,
  3.64096552e-01f, -3.26718271e-01f, 2.72869114e-02f, -1.81203857e-01f, -1.90857083e-01f, -1.80712730e-01f, -5.15370071e-03f, -1.85416713e-01f, -1.53346270e-01f, 3.14584225e-02f,
  -1.03391021e-01f, -1.39815956e-01f, -7.72067457e-02f, -8.58773068e-02f, -6.27411157e-02f, -3.99073139e-02f, -8.52763131e-02f, -7.57845119e-02f, -2.83701960e-02f, 1.10283494e-01f,
  7.26756155e-02f, -4.39241268e-02f, -1.06846113e-02f, 2.80017182e-02f, 3.18004051e-03f, -5.58852032e-02f, 2.02639047e-02f, -3.15347277e-02f, -2.07812451e-02f, 7.21756220e-02f,
  1.88646182e-01f, 6.39201794e-03f, -9.49052945e-02f, 4.28129993e-02f, 1.26704425e-01f, -4.42517400e-02f, 1.43461913e-01f, -2.85989977e-02f, -2.31592488e-02f, -1.46241405e-03f,
  -7.08407909e-02f, -1.71365635e-03f, 3.76051478e-02f, 4.94893640e-02f, -4.05615307e-02f, -1.66922450e-01f, -5.88408951e-03f, 1.36687849e-02f, -1.10459186e-01f, -1.17703259e-01f,
  1.78000201e-02f, 2.37944368e-02f, -3.96717042e-02f, -1.05729431e-03f, -1.02234460e-01f, 3.84093858e-02f, -1.25203971e-02f, -3.79617326e-02f, -1.18864827e-01f, -4.37636748e-02f,
  1.85674921e-01f, -4.64448482e-02f, 1.09393716e-01f, -7.77740851e-02f, -2.69298386e-02f, -1.83280706e-01f, 8.66632387e-02f, 1.14510812e-01f, -4.13227342e-02f, 1.21003233e-01f,
  1.22434348e-02f, -1.53819509e-02f, 1.23758771e-01f, 3.52855888e-03f, 7.94562027e-02f, 9.74733196e-03f, 3.11658327e-02f, 1.35054484e-01f, 6.57184003e-03f, 1.26682311e-01f,
  4.03961800e-02f, 8.13938454e-02f, 1.29436806e-01f, 1.63041696e-01f, 1.86939448e-01f, 1.66496024e-01f, 1.50648072e-01f, 1.48880914e-01f, 1.61424235e-01f, 1.57398343e-01f,
  5.80151796e-01f, -5.06444499e-02f, 4.47141007e-02f, 4.42397557e-02f, 5.36876880e-02f, 6.22674152e-02f, -8.43411461e-02f, 1.46173490e-02f, 3.11250007e-03f, -1.02020651e-01f,
  7.78799281e-02f, 1.40335709e-01f, 5.54612726e-02f, 2.53625624e-02f, 1.39919177e-01f, -9.54547226e-02f, -1.76993012e-01f, 1.04818627e-01f, 1.90883666e-01f, -6.86695576e-02f,
  -2.14092433e-01f, -2.04648793e-01f, -1.19165339e-01f, -1.38311476e-01f, -2.27997139e-01f, -3.16152908e-02f, -1.26297250e-01f, -2.48258084e-01f, -9.80461687e-02f, -3.21009010e-01f,
  2.94948727e-01f, 2.52681494e-01f, 2.59496123e-01f, 8.86632502e-02f, 4.69056852e-02f, 3.72148678e-02f, 1.51386201e-01f, 1.04728863e-01f, 5.70017025e-02f, -1.11509142e-02f,
  2.52910759e-02f, 3.27403508e-02f, -1.87621582e-02f, -1.19287200e-01f, -1.74051826e-03f, 2.20475886e-02f, -1.97851993e-02f, -9.70152114e-03f, 2.45348066e-02f, 2.54521184e-02f,
  3.54289077e-02f, 1.42268240e-02f, 7.78256729e-02f, 1.91145092e-02f, 1.26130372e-01f, 2.03245535e-01f, -2.26207133e-02f, -2.97708921e-02f, -6.87288679e-03f, -7.89723396e-02f,
  -3.92169866e-04f, -7.63851963e-03f, -3.84731144e-02f, -9.63794440e-02f, -1.11219520e-02f, 5.56623191e-02f, 1.01700492e-01f, -9.73641947e-02f, 4.46005678e-03f, -1.44206032e-01f,
  -2.79968195e-02f, 9.40243620e-03f, 7.35094696e-02f, -3.78128365e-02f, -6.02485538e-02f, 2.23148311e-03f, -6.74947947e-02f, -3.77281616e-03f, 4.68114670e-03f, -8.34201947e-02f,
  5.75529784e-02f, -5.02817556e-02f, -1.10220062e-04f, -6.11327738e-02f, -1.26678228e-01f, -4.74061025e-03f, -4.70930450e-02f, -5.06325141e-02f, -1.37740865e-01f, -2.79243961e-02f,
  1.97155014e-01f, 3.05598974e-01f, 8.53748769e-02f, 7.76720718e-02f, -4.73621152e-02f, 1.36660403e-02f, -4.12158892e-02f, 4.00884002e-02f, 7.63055012e-02f, 8.49421024e-02f,
  2.81891990e-02f, 4.86325510e-02f, -8.54807571e-02f, -9.52660814e-02f, -5.00199534e-02f, 1.08483605e-01f, 1.30668031e-02f, 3.54648978e-02f, 1.12117775e-01f, 4.57533486e-02f,
  -1.96509622e-02f, 1.32897079e-01f, 2.14162901e-01f, 1.02985099e-01f, 1.19938821e-01f, 1.39596790e-01f, 4.75969315e-02f, 7.07158446e-02f, 7.64884949e-02f, -1.14635050e-01f,
  -4.14782107e-01f, -4.12886441e-02f, -2.63472259e-01f, 2.23840284e-03f, 2.25822911e-01f, 2.37922803e-01f, 4.09228988e-02f, 2.62463927e-01f, 2.63678819e-01f, -6.53529242e-02f,
  2.04251990e-01f, 1.79433197e-01f, 4.12290730e-02f, -8.66255537e-03f, -1.95712402e-01f, -1.94063082e-01f, -2.44993776e-01f, -5.71534075e-02f, 1.77104145e-01f, 3.39431733e-01f,
  2.86063761e-01f, 2.08942946e-02f, -9.88648757e-02f, -7.96105713e-02f, -1.09726503e-01f, -4.90049720e-02f, -3.17350030e-01f, -1.93824008e-01f, -3.62562984e-02f, -4.82649207e-01f,
  -3.10365647e-01f, 1.20649986e-01f, 1.90370977e-01f, 7.16173276e-02f, 6.73406050e-02f, 2.96302103e-02f, -4.40152362e-02f, -2.46154834e-02f, 8.64139199e-02f, -1.01491861e-01f,
  -6.75893947e-03f, 1.62159167e-02f, 1.58337932e-02f, 5.58988415e-02f, -1.34483529e-02f, 5.64167509e-04f, -1.24204420e-01f, -1.05073594e-01f, -4.28417809e-02f, -1.32874712e-01f,
  1.43746868e-01f, 3.96745875e-02f, -2.79343665e-01f, 8.10096636e-02f, -1.07113376e-01f, -1.05582260e-01f, -1.34085879e-01f, -1.35716617e-01f, -3.24994832e-01f, -5.36675513e-01f,
  -5.91151305e-02f, -5.09081185e-02f, -7.94849619e-02f, -1.35932773e-01f, -3.64135131e-02f, -1.28902430e-02f, -2.18349770e-02f, -5.51446117e-02f, -7.75394440e-02f, 2.35599671e-02f,
  -1.95732415e-02f, 1.60450697e-01f, 4.52943444e-02f, 1.97987948e-02f, 2.34498158e-02f, 3.76674868e-02f, 3.75897884e-02f, -1.19125098e-01f, -4.43615392e-02f, -5.39478026e-02f,
  3.80853899e-02f, -9.19574723e-02f, 8.98167584e-03f, -1.01871297e-01f, -1.09017082e-01f, 4.87684719e-02f, 8.35582763e-02f, 7.30701014e-02f, 1.11632146e-01f, 5.01297601e-02f,
  -8.43849406e-02f, 1.45280451e-01f, -2.05249265e-01f, 1.23948354e-04f, 2.01081578e-02f, -8.50939006e-03f, -1.72656432e-01f, -8.63236785e-02f, -1.34872291e-02f, 4.76947613e-03f,
  8.75399448e-03f, -2.60965735e-01f, -1.89342380e-01f, -8.23460892e-02f, -1.82443839e-02f, -1.69725120e-01f, -1.29877821e-01f, -7.48407543e-02f, 3.01371422e-02f, -7.32877627e-02f,
  -1.64211065e-01f, -6.30556419e-02f, -2.74243474e-01f, -2.30215982e-01f, -4.17674985e-03f, -2.98727740e-04f, -1.36189550e-01f, 6.48023561e-02f, -1.26778781e-01f, -3.03460836e-01f,
  -6.80494010e-02f, 3.45333427e-01f, 9.92867500e-02f, 2.71569461e-01f, 1.78120077e-01f, 9.52448919e-02f, 2.47156367e-01f, 1.17515445e-01f, 1.00128308e-01f, 1.90668583e-01f,
  2.66456515e-01f, 2.77160883e-01f, 2.24126220e-01f, 2.26723731e-01f, 1.61153302e-01f, 1.59870476e-01f, 3.79345752e-02f, -3.96615639e-02f, 3.47605869e-02f, 1.08508691e-01f,
  8.38147923e-02f, 5.06468043e-02f, -5.43774180e-02f, 5.01014292e-03f, 1.97554320e-01f, 2.15155393e-01f, 1.27313346e-01f, -1.28336465e-02f, 1.04305975e-01f, 2.04382598e-01f,
  3.48732352e-01f, -3.07571213e-03f, 1.00854993e-01f, 2.55737230e-02f, 9.35779586e-02f, 5.60156442e-03f, -5.60757332e-02f, 9.66591612e-02f, 9.48598161e-02f, -1.56902410e-02f,
  -9.86796394e-02f, -1.19926661e-01f, 7.15198368e-02f, -4.06335481e-02f, -5.59345400e-03f, -2.68802959e-02f, 5.43004312e-02f, 8.05883482e-02f, 1.34675726e-01f, 6.96865318e-04f,
  1.55305371e-01f, -6.20098710e-02f, 4.10461463e-02f, -2.18390990e-02f, -5.55600598e-02f, -6.54981509e-02f, -7.40737468e-02f, -1.26429498e-01f, 7.08810007e-03f, -5.81100807e-02f,
  -2.18173414e-02f, 5.46548963e-02f, 2.01108083e-01f, 8.34465772e-02f, 4.47685830e-03f, 3.30440998e-02f, 2.23673508e-02f, 3.99568267e-02f, -2.44283006e-02f, -4.60579954e-02f,
  -2.79953051e-02f, 1.60832345e-01f, 1.29177690e-01f, -8.05241168e-02f, 1.75471723e-01f, 1.12784863e-01f, 7.84701854e-02f, 1.04271568e-01f, -6.97632059e-02f, 2.61614379e-02f,
  3.34430933e-02f, -4.57670763e-02f, 4.29858379e-02f, 7.52629712e-02f, 2.87667029e-02f, 2.18587350e-02f, -1.10873550e-01f, 3.18070920e-03f, -7.85702616e-02f, -1.45629287e-01f,
  4.28822190e-01f, 2.47192830e-02f, 1.31991267e-01f, 4.53714207e-02f, -9.49176252e-02f, -4.77356166e-02f, 1.23369217e-01f, 9.00346190e-02f, 1.65613145e-02f, 1.08605186e-02f,
  9.94325206e-02f, -6.33642543e-03f, 6.24000132e-02f, -6.78087324e-02f, -2.62370668e-02f, -1.66884772e-02f, -1.63386613e-02f, 1.38605073e-01f, 3.91648933e-02f, 1.40438482e-01f,
  8.92211869e-02f, -6.61649778e-02f, 5.82383722e-02f, -6.94159651e-03f, -3.30163375e-03f, 9.91409868e-02f, -4.86147404e-03f, -9.53989327e-02f, -8.51017609e-02f, -1.85860530e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.70790130e-02f, -5.29776067e-02f, 2.68866777e-01f, -4.10496332e-02f, -4.44385149e-02f, 3.04575469e-02f, 7.32442364e-02f, 1.61319062e-01f, 6.40888661e-02f, 3.42726745e-02f,
  -4.08107862e-02f, 3.44401821e-02f, 3.27437036e-02f, -6.34702214e-04f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.28900548e-02f, -2.66175330e-01f, -2.31784116e-02f, -5.33429906e-02f, 3.92840356e-02f, 5.50905988e-02f, -2.36251261e-02f, -5.35337180e-02f, -5.17353863e-02f, 8.24556574e-02f,
  1.41188756e-01f, 9.69938119e-04f, 5.26030436e-02f, 1.16316637e-03f, -1.10035636e-01f, -1.32340223e-01f, -3.23724970e-02f, -1.23595245e-01f, -1.09956749e-01f, 9.82460380e-02f,
  -4.43224311e-02f, -1.53689727e-01f, -2.22100586e-01f, 9.67278406e-02f, -3.25133875e-02f, 6.24040626e-02f, -2.01132700e-01f, 3.25462252e-01f, -4.79089916e-02f, -9.19141620e-02f,
  -9.07805935e-02f, -3.01385205e-02f, 5.44836968e-02f, 2.45498866e-03f, 2.09897161e-02f, -1.75345987e-02f, -5.94849996e-02f, -4.57083322e-02f, 2.68685102e-01f, 8.99650082e-02f,
  5.91364596e-03f, -6.84273019e-02f, 6.13282695e-02f, -2.82512531e-02f, -1.74950957e-01f, 1.74415365e-01f, -5.13835698e-02f, 4.74795811e-02f, -7.31572509e-02f, -1.12447709e-01f,
  6.69430569e-02f, 1.53425261e-01f, -3.13843161e-01f, -6.25016019e-02f, -6.23787232e-02f, 3.48055542e-01f, 1.86451897e-01f, 3.09049904e-01f, -1.93921313e-01f, 6.90936074e-02f,
  -8.58874768e-02f, 1.27753308e-02f, 2.40798950e-01f, -1.23390742e-01f, 1.72372460e-02f, -1.42570958e-01f, 1.76686570e-01f, -4.56824973e-02f, -1.52700186e-01f, 1.69052072e-02f,
  -8.27539712e-02f, 2.91313622e-02f, 1.25059053e-01f, -9.59234908e-02f, 1.16371594e-01f, -1.67838007e-01f, -3.01164567e-01f, -8.13562348e-02f, 3.38775441e-02f, -1.43469363e-01f,
  1.11046620e-01f, -7.09157065e-02f, -7.29587302e-03f, 7.51573294e-02f, -1.43987641e-01f, -8.64430219e-02f, -4.30705808e-02f, 2.00715750e-01f, 4.93272170e-02f, -1.01213038e-01f,
  2.33537585e-01f, 1.83135197e-02f, -4.99216653e-02f, -1.83683380e-01f, -1.18215926e-01f, 1.92031950e-01f, -2.52966490e-02f, 2.26888135e-01f, 5.18864691e-02f, -2.06594020e-02f,
  7.01205507e-02f, 5.16811721e-02f, 1.74816951e-01f, -1.75924554e-01f, -9.62053686e-02f, -2.69887269e-01f, 6.33371472e-02f, -5.26589900e-02f, -2.39811659e-01f, -1.14808649e-01f,
  1.76374346e-01f, -1.24925010e-01f, -1.99001566e-01f, -1.18138067e-01f, 1.05111413e-01f, 2.83981618e-02f, 1.73497945e-01f, -1.95393950e-01f, -5.70354275e-02f, -2.45714068e-01f,
  -6.32960945e-02f, 2.39566416e-01f, 3.47822249e-01f, 1.36341542e-01f, -1.49624318e-01f, 1.44237518e-01f, -6.53877035e-02f, -2.76950020e-02f, -3.03839669e-02f, 1.40472844e-01f,
  1.97829343e-02f, -4.20168005e-02f, -9.83546767e-03f, -7.09239691e-02f, 9.43431705e-02f, -4.01617168e-03f, -1.70423817e-02f, 1.52984634e-01f, -9.29149985e-02f, -5.95284179e-02f,
  -7.09312037e-02f, -7.54281739e-03f, -1.04306467e-01f, 6.45560622e-02f, 1.10749148e-01f, 2.53478765e-01f, 1.50951073e-01f, -2.19444856e-02f, -1.78493172e-01f, -8.71645436e-02f,
  5.94842099e-02f, -9.58871841e-02f, -8.18239748e-02f, -1.37199789e-01f, 1.45992413e-01f, -2.99328238e-01f, 1.88909993e-01f, 1.59528941e-01f, -1.31256029e-01f, 4.49679373e-03f,
  -7.73865208e-02f, -1.39952198e-01f, -1.07686952e-01f, 6.91271275e-02f, -1.69091150e-01f, 1.99648831e-02f, -2.02265829e-01f, 4.85146791e-02f, 2.38071047e-02f, -3.49533521e-02f,
  -4.29075696e-02f, -1.65147260e-02f, 2.34878138e-01f, 6.32326677e-02f, 1.82807278e-02f, -5.05891331e-02f, 2.82969456e-02f, 9.95760784e-02f, 4.78953198e-02f, -1.05106428e-01f,
  1.49544477e-01f, 1.72572788e-02f, 3.39178974e-03f, -2.07094282e-01f, -1.62281916e-01f, -6.22686232e-04f, 2.68776715e-01f, -1.69060633e-01f, -1.43098785e-02f, -1.56709746e-01f,
  -1.15826577e-01f, -1.08934931e-01f, 4.36029695e-02f, -6.55225478e-03f, -1.69837981e-01f, 1.07934698e-01f, -3.54693495e-02f, 1.91941131e-02f, -4.98962067e-02f, 2.60696802e-02f,
  8.71390477e-03f, 1.69259191e-01f, -1.36596523e-02f, -3.12335957e-02f, -5.59976846e-02f, -4.08774242e-02f, 1.23179175e-01f, -8.01271126e-02f, -6.12163693e-02f, 2.82009307e-04f,
  -1.04800485e-01f, -1.05549455e-01f, -4.66272458e-02f, -9.61596221e-02f, -8.73024203e-03f, -8.79422855e-03f, -5.10579683e-02f, 1.10797018e-01f, 1.97882697e-01f, -2.31009275e-01f,
  -1.30536586e-01f, 1.22436404e-01f, -4.64468077e-02f, 6.46373779e-02f, 5.93279526e-02f, 1.77012477e-02f, -3.53016481e-02f, -1.31393388e-01f, -9.04984921e-02f, 1.88592762e-01f,
  -2.18177646e-01f, -1.55771244e-02f, -4.51691411e-02f, -1.37752304e-02f, -5.02229482e-02f, 4.68595177e-02f, 3.18261504e-01f, 4.42858674e-02f, 5.21507151e-02f, -7.96044618e-02f,
  1.05909072e-01f, 4.40536216e-02f, 1.52808905e-01f, 1.80540010e-01f, -1.69757172e-01f, 9.80811641e-02f, 6.17257208e-02f, -1.34156749e-01f, -1.55307457e-01f, 8.90571252e-02f,
  1.79572582e-01f, -4.48177457e-02f, -1.59643814e-01f, -2.50279069e-01f, -2.29505390e-01f, 1.81082502e-01f, 3.19080167e-02f, -6.20229729e-02f, -7.43952692e-02f, -1.54432774e-01f,
  -7.59292580e-03f, 1.38997167e-01f, 9.37462300e-02f, 8.16167444e-02f, 5.60509115e-02f, -7.59376138e-02f, 4.79474111e-04f, -4.36413214e-02f, -5.43414466e-02f, -4.17296477e-02f,
  -9.95769911e-03f, 1.34454131e-01f, 3.91146094e-01f, 1.17200367e-01f, -1.66286394e-01f, -8.13826919e-02f, -1.07840486e-01f, -1.87234282e-02f, 2.10338801e-01f, -6.28170595e-02f,
  -1.28354058e-01f, -1.54308990e-01f, -2.13276356e-01f, 1.04486614e-01f, -2.42229968e-01f, 1.45596370e-01f, 3.83764808e-03f, 2.04393901e-02f, -8.67783371e-03f, -4.76627722e-02f,
  1.01172931e-01f, 6.50641322e-02f, -1.40451148e-01f, 1.36924267e-01f, 9.36730877e-02f, -1.68809593e-01f, -5.08683324e-02f, -7.82942697e-02f, -1.06307007e-01f, 2.07117394e-01f,
  -1.37264341e-01f, 1.63347479e-02f, -3.34776603e-02f, -1.85301334e-01f, 8.23777542e-02f, -7.83548877e-02f, 1.99402690e-01f, 7.76071697e-02f, -1.75054193e-01f, 7.29029700e-02f,
  2.22768426e-01f, -1.51486650e-01f, -9.89223346e-02f, 1.72873601e-01f, -3.13243754e-02f, 4.88323383e-02f, 1.91007957e-01f, -6.07045367e-02f, -1.35738090e-01f, 1.97613947e-02f,
  -7.29084364e-04f, -2.01155242e-04f, 1.30976379e-01f, 8.52801576e-02f, -5.75960651e-02f, -1.26593620e-01f, -7.39782378e-02f, -4.98633273e-02f, 7.84384683e-02f, 1.41391814e-01f,
  5.55682667e-02f, 1.31667703e-01f, 1.45226166e-01f, 1.40570804e-01f, 5.93593232e-02f, -1.14308737e-01f, -8.42794329e-02f, 1.06765889e-01f, 1.32219717e-01f, 1.80755198e-01f,
  -8.52123350e-02f, 3.73096243e-02f, 8.05518031e-02f, -9.00741294e-02f, -8.44210908e-02f, -4.04499322e-02f, 1.53827801e-01f, -2.90614754e-01f, 3.97387147e-02f, 1.81585655e-01f,
  8.22691247e-02f, 1.35997131e-01f, 1.74348354e-02f, -1.50646612e-01f, 1.25577487e-02f, -2.41514035e-02f, 4.12398130e-02f, -3.18199575e-01f, -1.58005103e-01f, -3.90923098e-02f,
  -4.31022681e-02f, 1.22978091e-01f, -2.35186458e-01f, 8.12364817e-02f, 1.05738275e-01f, 2.53282338e-01f, 7.69469738e-02f, 3.06059066e-02f, -2.30059505e-01f, -5.91443144e-02f,
  -1.03106223e-01f, -1.17523067e-01f, 8.09734762e-02f, -7.91216195e-02f, -6.84716627e-02f, 1.93319499e-01f, -3.90009061e-02f, -1.87620655e-01f, -1.00170583e-01f, 1.30561411e-01f,
  8.09672996e-02f, 1.12651169e-01f, 2.86127001e-01f, 1.09640345e-01f, 1.84435755e-01f, 2.04884797e-01f, 8.46216306e-02f, 1.02132775e-01f, -4.07376513e-03f, 1.27557486e-01f,
  -1.36108510e-02f, -4.35571335e-02f, 3.57375364e-04f, -1.76386341e-01f, -1.48471212e-03f, 2.56879389e-01f, -1.58548579e-01f, -8.57504159e-02f, 1.36308119e-01f, 3.95002924e-02f,
  -2.87287608e-02f, 1.17813230e-01f, 1.13004580e-01f, -6.15667999e-02f, 1.16966553e-01f, -3.56629267e-02f, 9.82783809e-02f, 1.39080957e-01f, 1.77352261e-02f, 1.19411334e-01f,
  1.07968442e-01f, -2.78144300e-01f, 3.98371704e-02f, -3.26203443e-02f, 1.09420322e-01f, -1.01265766e-01f, 2.10848246e-02f, -6.00819215e-02f, 2.25574300e-01f, -1.64278522e-01f,
  -3.63640785e-02f, 4.49869558e-02f, -8.44475403e-02f, 1.52989045e-01f, 1.25276819e-01f, 1.14153638e-01f, -2.45397002e-01f, 1.65449411e-01f, 3.03189736e-02f, 1.59279570e-01f,
  -3.99112888e-02f, -2.00909525e-02f, -5.63493976e-03f, -7.17460513e-02f, -1.40503809e-01f, -8.89751241e-02f, 3.35344732e-01f, -1.53279632e-01f, -1.83506995e-01f, 7.28498697e-02f,
  4.62711342e-02f, -1.27091646e-01f, -9.19428393e-02f, -2.03038491e-02f, 1.09228104e-01f, -1.43012837e-01f, 1.59018971e-02f, 6.12126663e-02f, 9.51303393e-02f, 1.46986976e-01f,
  6.45088851e-02f, 8.33892822e-03f, -3.28166597e-02f, 1.23698801e-01f, -5.61867515e-03f, 5.34734391e-02f, -9.30458307e-03f, 1.92418009e-01f, -1.68319374e-01f, -1.15800768e-01f,
  1.48968995e-01f, 5.71178943e-02f, -3.71621959e-02f, 6.44691736e-02f, -9.98841599e-03f, -9.74836852e-03f, 2.21217990e-01f, -1.63431555e-01f, 1.12408020e-01f, 1.23747401e-01f,
  4.12596054e-02f, -8.72461870e-02f, -6.97189644e-02f, -2.21420512e-01f, 2.29481682e-01f, -1.64143577e-01f, -3.21048982e-02f, 2.65203744e-01f, -4.55601886e-02f, 3.71735655e-02f,
  1.08878687e-01f, -3.10266837e-02f, -3.74711543e-01f, -8.00455734e-02f, -3.65372486e-02f, 3.64783444e-02f, -5.54447830e-01f, -4.63326983e-02f, 1.47456536e-02f, -1.89049423e-01f,
  -1.99529991e-01f, -1.20318949e-01f, 3.89205098e-01f, 1.85160320e-02f, -8.46186653e-02f, -1.11067947e-03f, 7.97724277e-02f, 1.27524585e-01f, 6.41359091e-02f, -5.78705892e-02f,
  -5.56517253e-03f, 3.69128250e-02f, 7.85709918e-02f, -5.37765361e-02f, 3.96041647e-02f, 1.23495432e-02f, 3.04631084e-01f, -1.27570368e-02f, -4.00622427e-01f, 1.32001806e-02f,
  -1.13970101e-01f, 2.72677988e-02f, 9.79867652e-02f, -6.06044866e-02f, 1.21144056e-02f, -3.95788811e-02f, -1.29387692e-01f, -1.43333167e-01f, -2.33296677e-01f, 1.56517681e-02f,
  -1.52171068e-02f, 7.38477707e-02f, 6.85854405e-02f, -3.58919054e-02f, -1.70323402e-01f, -1.64986998e-01f, -1.46181462e-02f, -6.93334565e-02f, -1.10696197e-01f, -2.14030426e-02f,
  -7.92144537e-02f, -4.87815328e-02f, -6.28698617e-02f, -1.52551264e-01f, -6.85322359e-02f, -4.07859087e-02f, -5.59530705e-02f, -5.54538630e-02f, -4.76959497e-02f, -1.95374489e-01f,
  -7.92017952e-02f, 8.24150965e-02f, -8.54443088e-02f, 1.35183334e-01f, -9.85972211e-02f, -3.04861888e-02f, 3.30317736e-01f, -1.64484769e-01f, 1.39538467e-01f, 4.65101004e-02f,
  1.49051994e-02f, -1.71968669e-01f, -4.88290712e-02f, 7.72574842e-02f, 4.44937237e-02f, 1.42788529e-01f, 1.52368352e-01f, 2.06547827e-01f, 1.18302479e-01f, -8.16299096e-02f,
  -1.06052905e-01f, -1.32817596e-01f, -9.97021943e-02f, 2.16907918e-01f, 1.83959708e-01f, -4.33922894e-02f, -1.31013200e-01f, -1.08659104e-01f, -5.85448965e-02f, 1.74517855e-02f,
  -3.47454869e-03f, 2.55265599e-03f, 8.66779238e-02f, 1.42615438e-01f, 4.52785909e-01f, 1.92567687e-02f, -8.52972120e-02f, 2.55176991e-01f, 8.97274259e-03f, -4.49144356e-02f,
  4.97229546e-02f, 7.51812905e-02f, 1.24160454e-01f, 6.85040653e-02f, -5.19832484e-02f, -1.08470321e-01f, 9.15473998e-02f, -9.39881057e-02f, -2.25661203e-01f, 2.14545485e-02f,
  -1.25680119e-01f, 2.18413383e-01f, 3.77522856e-01f, 3.64172488e-01f, 2.79903054e-01f, -2.42786817e-02f, -3.28724869e-02f, 7.01222420e-02f, 1.62491083e-01f, 5.00549003e-03f,
  -1.99098766e-01f, -7.39134550e-02f, -1.14575170e-01f, -3.30302715e-01f, 1.39047559e-02f, 1.44924372e-01f, 2.21919581e-01f, -1.21278111e-02f, 2.60901302e-01f, -1.48636147e-01f,
  -1.21490657e-02f, -1.23336509e-01f, -2.76917785e-01f, 2.76354015e-01f, -2.44318783e-01f, -2.68780798e-01f, 2.21153325e-03f, -2.18388408e-01f, -6.21050261e-02f, 3.15681010e-01f,
  2.98003517e-02f, 5.21627069e-02f, -4.98789847e-02f, -2.56962627e-01f, 2.45188564e-01f, 3.80607843e-02f, -1.00370169e-01f, -2.64047652e-01f, 7.22731575e-02f, -1.63763523e-01f,
  1.44173773e-02f, -1.04875080e-01f, -7.78601244e-02f, 1.76889345e-01f, 1.20830975e-01f, -2.27409437e-01f, -1.58117607e-01f, -7.80825019e-02f, -1.11861952e-01f, -5.24566472e-02f,
  -9.01867636e-03f, 1.55370057e-01f, -1.70678385e-02f, -7.41103366e-02f, -1.24760782e-02f, -6.42539933e-02f, -1.20491199e-01f, -6.24966361e-02f, -1.84588153e-02f, 3.81026268e-02f,
  4.23592255e-02f, 6.06211163e-02f, -1.49377866e-03f, -1.05769578e-02f, 7.21348301e-02f, 9.52185988e-02f, -2.68423885e-01f, 8.72967094e-02f, -7.93366134e-03f, -1.19818725e-01f,
  -1.37936607e-01f, 3.30386381e-03f, 3.52953374e-02f, -4.48726490e-02f, -6.38276637e-02f, 6.44080862e-02f, -2.64679283e-01f, -2.00120658e-01f, 2.54712794e-02f, 5.70821464e-02f,
  8.91079083e-02f, -1.78888943e-02f, 5.76695576e-02f, -5.02843708e-02f, 2.02067629e-01f, -1.05436571e-01f, -8.55133235e-02f, 4.94541526e-02f, 6.51660236e-03f, -3.62494290e-02f,
  -5.99422306e-02f, 1.80078566e-01f, -9.68469493e-03f, 1.58723101e-01f, 2.83206310e-02f, 1.31763712e-01f, 1.31652027e-01f, 6.70542046e-02f, -1.97263472e-02f, -2.77627800e-02f,
  2.89834235e-02f, 1.41167060e-01f, 3.06119144e-01f, -2.19432004e-02f, -9.61591378e-02f, -9.75792184e-02f, -7.80740008e-02f, 3.60192917e-02f, 6.37353659e-02f, -1.34798229e-01f,
  5.20223677e-02f, -1.69812962e-01f, 2.43494421e-01f, -1.16282091e-01f, 5.10687358e-04f, -2.70888600e-02f, 7.75363520e-02f, 5.55742867e-02f, 2.19949428e-02f, -1.47219002e-01f,
  7.25822300e-02f, -3.68320569e-02f, -6.04018457e-02f, -4.96938042e-02f, -8.01969245e-02f, 1.52954966e-01f, -4.10391996e-03f, 4.13097814e-02f, -1.26426354e-01f, -2.93203555e-02f,
  -2.76025683e-01f, -1.50911048e-01f, 4.00077179e-02f, 4.45573553e-02f, 5.78388311e-02f, -6.76032761e-03f, -1.86588634e-02f, 2.66950484e-02f, 1.14989541e-02f, 1.35298371e-01f,
  1.17608510e-01f, 3.00360739e-01f, -1.67477369e-01f, -1.54284807e-02f, -1.16779268e-01f, -1.69319823e-01f, -6.77247792e-02f, -1.23482039e-02f, -2.40294948e-01f, 1.59944817e-02f,
  1.08262718e-01f, 6.50740489e-02f, 1.49799436e-01f, 1.60077229e-01f, -5.33859320e-02f, 1.41661808e-01f, -1.85560379e-02f, -1.25286326e-01f, -6.34802580e-02f, -9.83581319e-02f,
  -2.19203699e-02f, 2.38583431e-01f, 3.77646424e-02f, -1.42172659e-02f, -1.52872026e-01f, -3.08211803e-01f, -2.80929565e-01f, 2.66243696e-01f, 5.82243362e-03f, 2.66051441e-01f,
  1.21819176e-01f, -2.25409508e-01f, -1.78180367e-01f, 1.37870699e-01f, 1.43387616e-01f, 7.56665319e-02f, -1.21307731e-01f, 6.48459196e-02f, -1.22842036e-01f, -1.98018532e-02f,
  -1.18870661e-01f, -1.02834264e-02f, 6.91458285e-02f, -2.15627104e-01f, -5.26392646e-02f, 1.84971184e-01f, -3.77441347e-02f, 9.28253084e-02f, 1.38146915e-02f, -1.40936539e-01f,
  6.39158040e-02f, 6.64763004e-02f, 5.01115806e-02f, 8.70661810e-02f, -4.01611030e-02f, -8.49100016e-03f, 5.14506511e-02f, 8.99009630e-02f, 5.62355593e-02f, 1.12334780e-01f,
  4.41752225e-02f, 3.13625187e-02f, -2.03293532e-01f, 6.12688810e-03f, -1.27325743e-01f, 1.15750782e-01f, -5.30771576e-02f, 5.67406565e-02f, -1.11074083e-01f, 2.36499626e-02f,
  5.57001273e-04f, -6.88881949e-02f, -4.50542159e-02f, -1.58725772e-02f, -2.66774222e-02f, -6.55288771e-02f, 2.23854873e-02f, 1.53031990e-01f, -3.97108048e-02f, 1.37050420e-01f,
  -6.96831942e-02f, -1.67647824e-01f, -2.27987324e-03f, -8.91341791e-02f, 8.98303390e-02f, 3.37938741e-02f, -1.23372290e-03f, 1.35258645e-01f, -7.48722404e-02f, -9.71868411e-02f,
  -4.41509672e-02f, 1.55727506e-01f, -5.18196374e-02f, 3.85460913e-01f, 1.98929608e-01f, -1.51875079e-01f, -1.25085339e-01f, 5.26984744e-02f, 5.10763377e-02f, -1.03803389e-01f,
  1.70900255e-01f, -9.02406201e-02f, 1.08137773e-02f, 9.65874344e-02f, 4.50055022e-03f, 7.31920525e-02f, -7.44056776e-02f, -5.72323091e-02f, -1.66262448e-01f, 2.27709599e-02f,
  -1.45970946e-02f, -6.74679726e-02f, 1.85158232e-03f, 2.26880908e-01f, 1.27382994e-01f, 9.89546813e-03f, 3.06594491e-01f, 2.08694234e-01f, -1.84529588e-01f, 2.47459509e-03f,
  2.63733044e-02f, -1.66009292e-01f, 8.26035663e-02f, -8.53835940e-02f, 5.94694242e-02f, 1.02577126e-02f, -1.85403954e-02f, 3.86718363e-01f, -1.77275851e-01f, -3.15281332e-01f,
  1.56422276e-02f, 5.32691739e-02f, 3.25376928e-01f, -2.54663285e-02f, 3.22294571e-02f, -2.34589428e-01f, 4.36227232e-01f, -2.84056276e-01f, -5.17838858e-02f, -4.56718262e-03f,
  -1.68905646e-01f, 1.18381456e-01f, 5.17545529e-02f, 1.68794915e-01f, -2.26651683e-01f, 3.76920223e-01f, 2.19871387e-01f, 4.22661781e-01f, 1.93600520e-01f, 1.53576270e-01f,
  -1.34968460e-01f, 6.83079585e-02f, 7.91429356e-02f, 1.92698345e-01f, 1.74623951e-01f, -2.57225782e-02f, 5.48502319e-02f, 2.74284333e-02f, 6.18961044e-02f, 6.67903870e-02f,
  1.78318080e-02f, -8.41730535e-02f, 1.01235151e-01f, 1.26420453e-01f, 1.47478759e-01f, 2.70744115e-01f, -8.18392709e-02f, -2.56967247e-02f, 2.04173531e-02f, -8.74242373e-03f,
  -7.51614687e-04f, 1.54585049e-01f, 1.01689152e-01f, 2.97010932e-02f, 1.57710295e-02f, -1.11375138e-01f, 1.09342299e-01f, 5.63846203e-03f, 1.53661281e-01f, 1.12728789e-01f,
  -1.73900202e-02f, -3.56310420e-02f, 1.35407180e-01f, 4.23790477e-02f, 5.22762015e-02f, 1.33760259e-01f, 2.31630251e-01f, 5.14731668e-02f, -3.41065740e-03f, 3.48078879e-03f,
  4.70568538e-02f, 1.06393628e-01f, 6.19945526e-02f, 5.89401349e-02f, 5.30321002e-02f, -5.34481220e-02f, -4.34282795e-02f, 6.27859086e-02f, 8.85638297e-02f, 2.74520181e-03f,
  -2.07178310e-01f, 9.63291153e-02f, 7.78023973e-02f, -1.34060085e-01f, 2.48933528e-02f, 1.35339811e-01f, -7.31299818e-02f, -7.47034475e-02f, -1.47253662e-01f, -1.35189652e-01f,
  9.35696065e-02f, -7.82933310e-02f, -1.54335974e-02f, 5.47022112e-02f, -9.74206030e-02f, 3.93538997e-02f, -2.12296680e-01f, -9.31636542e-02f, 2.34458297e-02f, -3.08802389e-02f,
  7.81639963e-02f, 2.85862684e-01f, 1.22380339e-01f, -5.14745526e-02f, -1.45367742e-01f, 1.39793158e-01f, -2.10323818e-02f, -1.30677789e-01f, -1.66344628e-01f, 3.18947285e-02f,
  -3.81114557e-02f, 1.10480435e-01f, 7.63190389e-02f, 1.15867957e-01f, -6.67853728e-02f, 1.94632951e-02f, 1.08396150e-01f, -2.80798543e-02f, 1.69789270e-02f, -5.20620942e-02f,
  6.28498616e-03f, -1.84963103e-02f, -3.09230983e-02f, 1.77932233e-01f, -8.77724066e-02f, 7.37331286e-02f, 2.72035778e-01f, 2.71155298e-01f, 1.19273871e-01f, -6.47587776e-02f,
  -9.79329273e-02f, -2.30986513e-02f, 5.74860238e-02f, 1.09362602e-01f, -2.68978387e-01f, -2.99193025e-01f, 2.07177907e-01f, -2.42112532e-01f, -2.53979787e-02f, 3.25624570e-02f,
  -4.01308797e-02f, 1.25176027e-01f, 9.60740075e-02f, 8.11538175e-02f, 7.91642517e-02f, 1.04936205e-01f, -1.09690383e-01f, -5.60937263e-02f, -7.48779997e-02f, -1.64107591e-01f,
  2.59806458e-02f, -1.01968825e-01f, -9.86500364e-03f, 1.44532502e-01f, 4.94185388e-02f, 1.18074782e-01f, 6.91180155e-02f, -9.55666006e-02f, 2.92212772e-03f, -5.51897809e-02f,
  1.11374378e-01f, -1.10107817e-01f, 2.47671589e-01f, -1.03140935e-01f, -8.00669417e-02f, -1.51548043e-01f, 5.51489592e-02f, 2.41982371e-01f, 8.80141649e-03f, -2.28588849e-01f,
  -3.96585107e-01f, 9.49990228e-02f, 6.01464063e-02f, 6.18553609e-02f, -8.44916627e-02f, 4.16784957e-02f, 2.02786475e-01f, 4.13705669e-02f, 1.73260067e-02f, 1.92701638e-01f,
  -5.03222309e-02f, 1.43373189e-02f, -5.40832765e-02f, -5.33898734e-02f, -1.84431467e-02f, 1.68570191e-01f, -4.42477018e-02f, 1.27721965e-01f, -8.27334225e-02f, 2.12053172e-02f,
  1.31022885e-01f, 1.41786546e-01f, 8.70300382e-02f, -5.29461093e-02f, 1.14197135e-01f, 1.17199853e-01f, -4.92062941e-02f, -1.10765129e-01f, 8.36458895e-03f, 1.84539065e-01f,
  1.44426838e-01f, 9.29661319e-02f, -6.24043755e-02f, -9.40488428e-02f, 6.51956722e-02f, 1.30980304e-02f, -3.95984128e-02f, -1.99668914e-01f, -3.29911500e-01f, 1.69938371e-01f,
  -3.50489677e-03f, 3.42099577e-01f, 9.65271369e-02f, 1.84582129e-01f, 6.81377202e-02f, 6.22865744e-02f, 3.32619138e-02f, -1.97737873e-01f, -8.80588032e-03f, -1.76014185e-01f,
  3.71590257e-02f, -9.32795927e-02f, 3.40556115e-01f, 2.06179351e-01f, 2.26329658e-02f, -2.24214792e-01f, -1.24527486e-02f, -3.47128659e-02f, 5.47449589e-02f, -1.81954488e-01f,
  2.12004129e-02f, -1.01182587e-01f, -6.44155964e-02f, 1.67792197e-02f, -2.17094749e-01f, 6.66165054e-02f, -2.21335188e-01f, 1.92046449e-01f, -3.05870883e-02f, 5.61025366e-02f,
  -3.75976339e-02f, 3.82962525e-02f, 7.40933269e-02f, -1.27273351e-01f, 1.00284547e-01f, 1.19914934e-01f, 1.24679483e-01f, 1.81249470e-01f, 1.03486627e-01f, 4.97236587e-02f,
  1.20522231e-02f, 4.76885177e-02f, 9.10644711e-04f, 5.72873466e-02f, 7.03666881e-02f, 5.09580672e-02f, 7.28881806e-02f, -3.45661677e-02f, 9.85789225e-02f, -8.47811848e-02f,
  6.07468486e-02f, 1.90129727e-01f, -2.11541783e-02f, -1.09037735e-01f, 2.43606549e-02f, 1.88076898e-01f, -1.52557909e-01f, 1.36717772e-02f, -1.24318697e-01f, -6.41016141e-02f,
  1.68143231e-02f, 5.29769287e-02f, -1.89657807e-02f, 2.64109373e-02f, -1.14924252e-01f, -4.13203202e-02f, 1.18613333e-01f, -4.09485213e-02f, -2.88480427e-02f, -1.33139774e-01f,
  -4.69628200e-02f, -1.10187255e-01f, -1.00872122e-01f, 9.44688991e-02f, -8.36646482e-02f, -3.05239595e-02f, -1.46724910e-01f, -2.90441755e-02f, 2.07316995e-01f, 2.78506339e-01f,
  -2.07158014e-01f, -3.05899791e-02f, -9.51493084e-02f, 1.68536291e-01f, 1.37777448e-01f, 1.34113193e-01f, 2.23345950e-01f, 5.03976122e-02f, -1.66539118e-01f, -1.41768828e-01f,
  -3.15660350e-02f, 5.71494326e-02f, 1.11292833e-02f, -1.37279987e-01f, 7.88090006e-03f, 6.59015849e-02f, -1.27516225e-01f, 4.88231657e-03f, 1.14210166e-01f, -1.47293760e-02f,
  -6.52862117e-02f, -3.35162550e-01f, 7.95968473e-02f, -1.94177078e-03f, -2.35240236e-01f, -6.80877864e-02f, 4.04728539e-02f, -6.80981437e-03f, 1.65064171e-01f, 4.88762222e-02f,
  -1.00786239e-01f, 3.08180377e-02f, -1.27248481e-01f, -1.02069646e-01f, 2.56004501e-02f, 5.54806211e-05f, -2.96736695e-02f, -4.47178222e-02f, -2.72021770e-01f, 7.42299156e-03f,
  1.98595412e-03f, -2.09182024e-01f, -6.75291568e-02f, -2.38065119e-03f, -4.15813327e-02f, -4.75418717e-02f, 2.81707019e-01f, 9.29861143e-02f, 5.75076416e-02f, 7.53695816e-02f,
  1.80816859e-01f, -7.53298327e-02f, 1.67739913e-02f, 2.01378427e-02f, 6.40913323e-02f, 9.49470773e-02f, -2.50546008e-01f, 2.87545659e-02f, 4.83613610e-02f, -1.75851554e-01f,
  -1.17086872e-01f, -9.54032615e-02f, 1.57551825e-01f, 1.77237943e-01f, 2.32197493e-01f, -1.51372328e-02f, 4.43240963e-02f, -2.80888826e-01f, -9.78405625e-02f, 2.33271599e-01f,
  -1.04533374e-01f, -1.66269064e-01f, -1.27012536e-01f, -1.80530801e-01f, 1.44623101e-01f, -8.10635462e-02f, -3.76443751e-02f, -2.75117103e-02f, 1.46638095e-01f, -2.25352839e-01f,
  6.26035109e-02f, 8.94784778e-02f, -1.46001965e-01f, -8.71802643e-02f, 1.73055902e-02f, 1.02422789e-01f, -1.76773954e-03f, 1.67994127e-01f, 1.47670776e-01f, 5.69807403e-02f,
  -5.44316806e-02f, -1.02636300e-01f, -3.21882367e-02f, -1.04585364e-01f, 3.84310819e-03f, -5.90110756e-02f, -1.20999187e-01f, 1.51352838e-01f, -2.56955683e-01f, 8.73095393e-02f,
  1.73641503e-01f, -2.65745334e-02f, 2.53653318e-01f, 2.46705756e-01f, 7.25654140e-03f, 1.50005832e-01f, 5.13622500e-02f, -8.91396701e-02f, 1.10863820e-01f, 1.78536195e-02f,
  -1.94629028e-01f, -1.50451899e-01f, 1.59536451e-01f, 1.64177150e-01f, -9.27752480e-02f, 1.26072630e-01f, -9.22058057e-03f, -2.35747427e-01f, -3.25161338e-01f, 5.32553568e-02f,
  1.24517888e-01f, 2.30033714e-02f, -2.99960449e-02f, 1.61499456e-01f, 2.16167971e-01f, 1.22867055e-01f, 1.88249454e-01f, -2.19487742e-01f, -5.63284494e-02f, 1.64245982e-02f,
  2.09313154e-01f, -1.97046608e-01f, 2.88845658e-01f, -9.79005098e-02f, -2.62339741e-01f, 1.37632474e-01f, -2.92158306e-01f, 1.26841858e-01f, 1.83429897e-01f, 7.71102086e-02f,
  2.78972924e-01f, 1.78380340e-01f, 1.05998755e-01f, -4.90978651e-04f, -1.24340184e-01f, -2.11747326e-02f, 3.76647413e-02f, 1.31188333e-01f, 1.34985983e-01f, -1.65200103e-02f,
  2.17165761e-02f, 3.11676729e-02f, -4.12329100e-02f, 2.42952369e-02f, 3.68602753e-01f, 2.14230288e-02f, -6.21535815e-02f, 1.14958666e-01f, -5.70694683e-03f, 1.23179920e-01f,
  -1.46895543e-01f, 1.19373195e-01f, 1.27030015e-01f, 1.31626084e-01f, -7.53922760e-02f, -1.72423288e-01f, 1.92395404e-01f, -2.86982656e-01f, 1.64646488e-02f, -4.51463796e-02f,
  -1.37405246e-01f, -2.23589297e-02f, -2.66793948e-02f, 4.85236235e-02f, 1.84861481e-01f, -6.30428791e-02f, -8.66883621e-02f, 2.31400952e-02f, -1.18582979e-01f, -1.34106174e-01f,
  -1.39165401e-01f, -1.24015488e-01f, 4.50696871e-02f, -1.98852643e-01f, 1.90243825e-01f, -9.79431421e-02f, 9.80822220e-02f, 8.06302205e-02f, -2.09815264e-01f, -1.50704786e-01f,
  -1.37504384e-01f, 1.11552693e-01f, -1.64064944e-01f, 7.72627294e-02f, -1.49155140e-01f, 8.72796103e-02f, -1.81301218e-02f, -2.45334595e-01f, 6.31779432e-01f, 3.01988721e-01f,
  2.81045847e-02f, 3.82438526e-02f, -2.62609422e-01f, -3.07280440e-02f, 1.22447439e-01f, 2.88469754e-02f, -1.24499209e-01f, -4.83860224e-02f, -1.09959148e-01f, -1.00564852e-03f,
  -5.76077849e-02f, 5.91301396e-02f, 1.16407178e-01f, 3.09483819e-02f, 3.25068720e-02f, -9.81518105e-02f, 8.05467293e-02f, -6.08401261e-02f, -4.87974063e-02f, 8.12036768e-02f,
  9.76033285e-02f, -4.24505062e-02f, -1.10287152e-01f, -9.94966924e-02f, 6.57582730e-02f, -2.27875262e-01f, -1.15932345e-01f, 3.36365402e-02f, 8.82828683e-02f, 1.56676114e-01f,
  -2.92115882e-02f, -1.61324948e-01f, -1.69323221e-01f, 1.49068564e-01f, -8.44575167e-02f, 6.88014925e-02f, 1.74339209e-02f, -1.21712878e-01f, -1.50301740e-01f, -1.55829221e-01f,
  -1.20366253e-01f, 2.78609872e-01f, -3.05719882e-01f, 1.78270303e-02f, -1.45035803e-01f, -1.99382663e-01f, -1.40601799e-01f, 1.72018006e-01f, 3.30208302e-01f, -1.38393819e-01f,
  7.54097253e-02f, -2.14360803e-02f, 2.81007797e-01f, 5.80862863e-03f, -4.24711071e-02f, 2.00708330e-01f, 3.29235718e-02f, -6.32350966e-02f, 1.59669891e-01f, -4.42985445e-01f,
  -2.10738316e-01f, -1.17412154e-02f, 1.48602426e-01f, -1.22688152e-01f, -1.73931435e-01f, 3.05855647e-02f, -2.44308934e-01f, 1.69278637e-01f, -7.35172406e-02f, 4.34442125e-02f,
  1.05307534e-01f, 1.21989600e-01f, -8.81091207e-02f, 1.60408989e-01f, -1.20501928e-01f, 6.28918083e-03f, 8.72227736e-03f, -9.69085917e-02f, 1.60503656e-01f, 2.39567399e-01f,
  5.49430437e-02f, -4.36128350e-03f, -1.50941938e-01f, 8.22083205e-02f, 2.35765845e-01f, -7.80533478e-02f, -9.41587165e-02f, 8.61778930e-02f, 1.40740350e-01f, 2.76032221e-02f,
  6.51825219e-03f, -9.66951326e-02f, 5.06247878e-02f, 2.63012171e-01f, 5.19514978e-02f, 7.79216662e-02f, -4.99622673e-02f, -1.39308870e-01f, 9.43190511e-03f, -5.97228035e-02f,
  1.22704864e-01f, -1.79595083e-01f, -1.84455097e-01f, -2.18106396e-02f, 2.53423691e-01f, 2.57400513e-01f, 4.42673355e-01f, 1.37525648e-01f, 2.25436121e-01f, 1.79515854e-01f,
  -5.91587685e-02f, 1.00914150e-01f, -8.23795646e-02f, 6.12285174e-02f, -3.74091491e-02f, -4.98408079e-02f, 2.21277669e-01f, 2.15379506e-01f, 3.40564698e-02f, -9.00771935e-03f,
  -1.05046056e-01f, 4.11696918e-02f, 7.69020766e-02f, 5.27397497e-03f, 1.51887804e-01f, 3.69444132e-01f, -3.38646442e-01f, 1.91387102e-01f, 1.72808543e-01f, 8.37613121e-02f,
  -6.87531531e-02f, 1.73649788e-01f, 8.71897936e-02f, 1.74429808e-02f, 3.01820517e-01f, 7.35992715e-02f, -2.09987611e-02f, 1.01284154e-01f, 5.88894216e-03f, -1.16105169e-01f,
  -4.07222882e-02f, 9.51560959e-02f, 1.62878647e-01f, 5.76326363e-02f, -7.55968615e-02f, 5.51106669e-02f, 5.29351644e-02f, 2.55662110e-02f, 9.51362848e-02f, 9.67602581e-02f,
  1.55194372e-01f, 1.61397144e-01f, -5.55681549e-02f, -4.27022800e-02f, 1.32790074e-01f, -3.68548818e-02f, -4.54547592e-02f, -1.01088129e-01f, 1.64632812e-01f, -2.81923581e-02f,
  -1.26307487e-01f, -3.85773778e-02f, 1.27106979e-01f, -1.52600994e-02f, -1.12486549e-01f, 5.20419143e-02f, 1.15963399e-01f, -7.14904889e-02f, 4.66568321e-02f, -1.39169112e-01f,
  -4.58629653e-02f, -1.37451291e-01f, -1.55659914e-01f, -1.98894843e-01f, -1.26615763e-01f, 1.65310517e-01f, 5.50475158e-02f, 2.04506829e-01f, 5.33022843e-02f, 3.42346430e-02f,
  -8.67552832e-02f, -1.08312681e-01f, 6.55606762e-02f, 2.61355191e-01f, -1.70232952e-01f, -5.49650975e-02f, 1.19916521e-01f, 1.08867988e-01f, -2.05357820e-01f, -1.30703986e-01f,
  3.28391880e-01f, 1.14484139e-01f, -1.51705608e-01f, 4.89521306e-03f, -1.26423657e-01f, 1.47848740e-01f, -7.24048261e-03f, -7.64544383e-02f, 1.28613681e-01f, 5.10335229e-02f,
  1.91473141e-02f, -1.84888840e-02f, -7.50003606e-02f, 2.35957857e-02f, 3.65677215e-02f, -3.54350582e-02f, 1.66333690e-02f, 8.66732076e-02f, -5.97542748e-02f, -2.14310996e-02f,
  2.25055218e-02f, 2.74731405e-02f, -1.15506679e-01f, -4.29361016e-02f, 9.01899561e-02f, 1.60611138e-01f, 1.07794903e-01f, 1.37372687e-01f, -1.21504925e-01f, 1.22678000e-02f,
  1.71201434e-02f, 1.18908517e-01f, 2.28521720e-01f, 1.12316847e-01f, 4.27544117e-02f, -5.92704527e-02f, 9.63280722e-02f, -1.49890140e-01f, -7.65293464e-02f, 1.20596640e-01f,
  4.65040058e-02f, -9.10226554e-02f, 1.22225709e-01f, -1.14415869e-01f, -6.16440512e-02f, -3.06447577e-02f, 2.87554134e-02f, -2.06593186e-01f, -3.13448489e-01f, -9.21835154e-02f,
  1.11281991e-01f, 1.06129818e-01f, -1.12288222e-01f, 1.91042766e-01f, -2.87454545e-01f, -1.51368380e-01f, 9.94882584e-02f, -1.89325780e-01f, 3.70729327e-01f, 3.05371475e-03f,
  4.45747897e-02f, -7.42570162e-02f, 3.20295632e-01f, -1.43098354e-01f, 1.85632318e-01f, 3.77269126e-02f, -1.72212601e-01f, -1.48762137e-01f, 1.70852065e-01f, -9.31147020e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -3.20140123e-02f, 4.92060296e-02f, -5.52472584e-02f, -5.48031405e-02f, 1.41244128e-01f, 2.13488042e-01f, 6.08192571e-02f, 4.20831814e-02f, 9.07913521e-02f, -8.66054073e-02f,
  3.53286892e-01f, 1.04449309e-01f, 1.60497189e-01f, 9.84828174e-02f, -4.42035869e-02f, 7.84471259e-02f, 2.50166863e-01f, 1.59506381e-01f, -3.29412632e-02f, 1.24094933e-01f,
  1.74235597e-01f, 9.13703665e-02f, 1.53323323e-01f, -1.83727555e-02f, 2.17736512e-01f, 2.51736969e-01f, 1.24016386e-02f, 2.50511706e-01f, 6.84581697e-02f, -1.18734539e-01f,
  -4.81579006e-02f, 2.56243534e-02f, 9.73912030e-02f, -8.61652344e-02f, 1.01218894e-02f, 5.11330329e-02f, 1.02863200e-01f, 2.81784028e-01f, 3.91338676e-01f, 1.93572834e-01f,
  -4.13621180e-02f, 1.10628627e-01f, 4.37420839e-03f, 7.86415413e-02f, -2.16145381e-01f, -3.88078764e-02f, -1.39423206e-01f, -8.76041129e-02f, 2.35437036e-01f, 1.91565648e-01f,
  1.80301279e-01f, 3.40786576e-02f, -1.05650676e-02f, 1.36444911e-01f, -1.89226344e-02f, 3.03562492e-01f, 5.76795116e-02f, -5.76616712e-02f, -4.86065656e-01f, 1.38184935e-01f,
  1.93584174e-01f, -1.07975237e-01f, -5.66201620e-02f, -5.39558716e-02f, 8.13849121e-02f, 8.67295265e-02f, 4.79363911e-02f, -1.61039997e-02f, -4.29557860e-02f, 8.24466869e-02f,
  -7.76739568e-02f, 6.49485504e-04f, 3.86298560e-02f, 1.83989823e-01f, -1.57487422e-01f, -2.30851918e-02f, 2.98241228e-01f, 2.03338578e-01f, 2.52461433e-01f, 1.98864624e-01f,
  5.96952252e-02f, -5.25216050e-02f, 8.83149877e-02f, -1.38150737e-01f, 4.84537855e-02f, 1.64453149e-01f, 8.11330527e-02f, 4.44439314e-02f, -2.43251532e-01f, 1.51923969e-01f,
  -3.50519806e-01f, -3.43873426e-02f, 9.59950760e-02f, 2.78244108e-01f, 1.99754924e-01f, -2.14965358e-01f, -1.58407405e-01f, 1.71698332e-01f, -1.15137331e-01f, -1.70271486e-01f,
  -1.43136799e-01f, -3.90622541e-02f, -2.82128245e-01f, 3.32113445e-01f, 8.42711553e-02f, -4.92625870e-02f, -2.21569955e-01f, 2.31510133e-01f, 4.45254326e-01f, 1.29159003e-01f,
  3.06255533e-03f, 2.58346558e-01f, 1.87980443e-01f, -1.83447808e-01f, -1.99908763e-01f, -1.75712392e-01f, 3.02621126e-01f, -7.22965524e-02f, 2.05972701e-01f, -1.00957051e-01f,
  1.28196597e-01f, -8.24558064e-02f, -1.99743658e-02f, -3.74548763e-01f, -7.33250454e-02f, -1.23790689e-01f, 3.23844910e-01f, -1.52979851e-01f, 4.50144112e-02f, -1.82411954e-01f,
  1.31776690e-01f, 1.10067260e-02f, 4.07263711e-02f, -2.67801005e-02f, 1.46511272e-01f, -3.93419340e-02f, 8.61571506e-02f, -5.84111847e-02f, 2.15002805e-01f, 1.51008248e-01f,
  -1.30116478e-01f, 9.81369168e-02f, 2.75800556e-01f, 5.99763095e-02f, 1.03746401e-02f, 1.02561526e-03f, -1.07027590e-01f, 2.57663399e-01f, -4.84997034e-02f, -7.68824890e-02f,
  -3.20701711e-02f, 2.46512182e-02f, 6.96902573e-02f, 1.25250384e-01f, -2.79707089e-02f, 9.64050069e-02f, -1.54515609e-01f, -2.18528152e-01f, -2.10556626e-01f, 8.58223364e-02f,
  2.81114859e-04f, -5.59073575e-02f, 2.81956524e-01f, 8.39396268e-02f, 1.74915493e-01f, 8.18114430e-02f, 2.31298119e-01f, -8.35287943e-02f, -2.81352252e-01f, 8.79348218e-02f,
  1.27118737e-01f, 1.19356610e-01f, -2.36959770e-01f, 6.09087460e-02f, 2.04384416e-01f, -1.65081620e-01f, -1.67801324e-03f, -2.78702192e-02f, -1.74207211e-01f, 2.76043952e-01f,
  -3.52299511e-02f, 1.81509376e-01f, 2.06307083e-01f, -1.35580614e-01f, 7.89783373e-02f, 1.97149351e-01f, -2.54087262e-02f, 4.04291973e-02f, 2.28969723e-01f, -1.56380937e-01f,
  1.25337377e-01f, -1.45008937e-02f, 3.26321716e-03f, -1.63177431e-01f, -4.15209308e-02f, -1.80940866e-01f, 8.68352652e-02f, -1.55277044e-01f, -1.86986759e-01f, -5.44012524e-02f,
  -1.52682580e-04f, -1.01174682e-01f, 3.10274940e-02f, -5.00599369e-02f, -1.48228958e-01f, 2.70937160e-02f, 2.06901394e-02f, 1.68975778e-02f, -1.53916597e-01f, 2.05742382e-02f,
  -4.92747277e-02f, -1.19437248e-01f, 7.38925934e-02f, -1.22194089e-01f, -2.03630909e-01f, -2.03480870e-01f, -1.20500326e-01f, -1.16535224e-01f, 2.15033465e-03f, -2.51255095e-01f,
  1.73590064e-01f, -1.09313335e-02f, -1.02319077e-01f, -4.88042869e-02f, 2.83357836e-02f, -6.50627315e-02f, -1.08354934e-01f, -5.24876826e-02f, 7.46442750e-02f, -3.02770108e-01f,
  2.54470613e-02f, 5.93557321e-02f, 8.21280107e-02f, -1.39861807e-01f, 1.58512190e-01f, -1.54846907e-01f, -1.07299536e-01f, -8.64977092e-02f, 2.34018475e-01f, 1.88132022e-02f,
  7.32332692e-02f, -1.71995442e-02f, -2.80558854e-01f, 1.80560321e-01f, -9.49858427e-02f, -1.33805186e-01f, 4.15548161e-02f, -2.10546196e-01f, -2.98882961e-01f, 6.58394545e-02f,
  2.99372464e-01f, -3.91238965e-02f, 1.88181296e-01f, -4.31273207e-02f, -1.59639731e-01f, 1.65698558e-01f, 5.17328456e-02f, -9.33075473e-02f, 1.70286059e-01f, 1.89375743e-01f,
  5.67854233e-02f, 1.01448633e-01f, -5.86101040e-02f, 8.34997594e-02f, 3.63060483e-03f, 2.31631964e-01f, -5.82614588e-03f, -1.46368286e-02f, 2.25278124e-01f, 1.34993941e-01f,
  9.08068717e-02f, -2.33918615e-02f, -2.02538505e-01f, -1.06075332e-01f, -1.33405486e-02f, 3.04009974e-01f, 2.43589938e-01f, 3.10713444e-02f, -5.24056591e-02f, -1.03170956e-02f,
  3.50066908e-02f, 1.16674893e-01f, 2.90989995e-01f, -8.73812065e-02f, 7.60434791e-02f, 1.01806551e-01f, -2.88064964e-02f, -1.60822779e-01f, 1.23802319e-01f, -1.18655384e-01f,
  -8.73563066e-02f, 6.06797896e-02f, 1.29039630e-01f, -4.06261146e-01f, 7.22017810e-02f, 1.77604668e-02f, -9.44135860e-02f, 1.68218054e-02f, -1.75503626e-01f, -2.52994657e-01f,
  7.55122751e-02f, -2.17504185e-02f, -1.25586405e-01f, 1.76518887e-01f, -4.69938487e-01f, 1.13189630e-01f, -5.21514416e-02f, 5.09595014e-02f, -2.21555561e-01f, 7.43772686e-02f,
  1.32149950e-01f, 4.72024560e-01f, 5.40810972e-02f, -7.23500596e-03f, 9.43678319e-02f, 1.93719089e-01f, 1.30706832e-01f, -9.27478522e-02f, -5.69925122e-02f, -1.52963072e-01f,
  6.51631653e-02f, 5.96010648e-02f, 5.73232733e-02f, -2.67253220e-02f, 7.30927438e-02f, -1.73706785e-02f, 2.27456596e-02f, 1.69388577e-02f, -4.61863987e-02f, -5.85921817e-02f,
  1.80744217e-03f, -3.17993790e-01f, -4.56745736e-02f, -5.16125597e-02f, -9.61739793e-02f, 1.05721153e-01f, 6.72077760e-02f, 2.98008714e-02f, -1.45789146e-01f, -1.39685526e-01f,
  -3.58486548e-02f, 3.22668441e-03f, -7.59182544e-03f, 6.89530671e-02f, -4.66326345e-03f, -1.08022995e-01f, -1.06608480e-01f, 1.14705730e-02f, 1.20603209e-02f, 1.35271147e-01f,
  -5.40764481e-02f, 1.70232654e-01f, 7.54665583e-03f, 2.77251806e-02f, -1.92998379e-01f, 1.74264714e-01f, 8.01168568e-03f, 9.41880867e-02f, -1.34113148e-01f, -1.10396154e-01f,
  -9.17092413e-02f, 5.67506850e-02f, 3.12683821e-01f, -2.18858987e-01f, -1.54107362e-01f, -1.98279053e-01f, -1.17149793e-01f, -1.80112883e-01f, 1.58169881e-01f, 1.19636476e-01f,
  3.03301096e-01f, 2.32087281e-02f, -3.57765794e-01f, 4.33331020e-02f, 2.46042937e-01f, -2.88828820e-01f, -1.52870670e-01f, 2.40389511e-01f, -1.85774297e-01f, 1.09821767e-01f,
  7.46691003e-02f, -4.13993634e-02f, -2.76078373e-01f, 1.72325894e-01f, 2.50645764e-02f, -1.45704687e-01f, 3.05996705e-02f, 1.29844904e-01f, -7.89604336e-02f, -7.15985447e-02f,
  -2.55545378e-02f, 4.68356945e-02f, 5.59452809e-02f, -1.83634669e-01f, 1.05200469e-01f, 1.07276939e-01f, -1.76847011e-01f, 2.73077432e-02f, -4.32586577e-03f, -4.44300510e-02f,
  2.07749516e-01f, -7.33511448e-02f, -9.39218402e-02f, 1.89953431e-01f, -1.91396270e-02f, -2.33543798e-01f, 5.65463118e-02f, 1.83604300e-01f, 1.98140908e-02f, 4.60947631e-03f,
  1.10565834e-01f, 4.10479158e-02f, 1.47289589e-01f, -1.53202891e-01f, -6.78767189e-02f, 6.63178936e-02f, 1.23654693e-01f, 6.61585480e-02f, 2.57383913e-01f, 1.05113648e-01f,
  1.80974435e-02f, 5.13647608e-02f, 1.88474491e-01f, -1.40875041e-01f, -1.58011407e-01f, -1.20386168e-01f, -1.96969688e-01f, 3.55442613e-01f, 1.58826485e-02f, 1.40249744e-01f,
  -7.72311091e-02f, 9.71229095e-03f, -6.39991760e-02f, -7.16245398e-02f, 7.29548931e-02f, 1.89092457e-01f, 7.23965690e-02f, -8.90526697e-02f, 9.81300250e-02f, -2.88416624e-01f,
  -4.86203618e-02f, 2.30550244e-01f, 3.60773087e-01f, -7.16239065e-02f, -8.44451692e-03f, -2.15210527e-01f, -7.34238625e-02f, 4.62728925e-02f, 5.10187484e-02f, 1.29066914e-01f,
  5.70452847e-02f, -1.02688037e-02f, 5.05675040e-02f, 2.13907063e-01f, -3.99705283e-02f, -1.01010486e-01f, 1.30180597e-01f, 5.22067323e-02f, 1.93972766e-01f, 5.17910160e-02f,
  2.28263840e-01f, 1.84075981e-01f, -6.48059770e-02f, -7.88209811e-02f, 1.85588658e-01f, 4.48336676e-02f, 8.73131603e-02f, 2.27575630e-01f, 1.87031135e-01f, 4.25707400e-02f,
  -1.13995345e-02f, 5.60376644e-02f, -9.05153975e-02f, 2.54759453e-02f, 8.22897330e-02f, 3.32014233e-01f, -3.74030247e-02f, -1.68189555e-01f, -5.88332005e-02f, -1.05019197e-01f,
  -2.87399925e-02f, 3.20351236e-02f, -2.70954281e-01f, 1.05815500e-01f, 1.62425891e-01f, -5.11930622e-02f, 1.83004335e-01f, 1.36781916e-01f, 1.16527855e-01f, -1.79736957e-01f,
  -7.05095530e-02f, -1.03486970e-01f, -1.23679757e-01f, -3.51530872e-02f, -1.85692217e-02f, 1.93215549e-01f, -6.98598614e-03f, -8.03788826e-02f, 2.52253950e-01f, -9.68935341e-02f,
  -7.63625279e-02f, 1.54413670e-01f, -1.65782973e-01f, 1.55073345e-01f, 2.16419250e-01f, -1.12993240e-01f, -3.20279866e-01f, 1.88154608e-01f, -6.66681603e-02f, 1.53902113e-01f,
  1.72393396e-01f, -2.39202067e-01f, 1.31326482e-01f, 9.79197994e-02f, -1.23485113e-02f, 2.39853375e-02f, 1.92957237e-01f, -1.83864031e-02f, 2.21701831e-01f, 8.47200677e-02f,
  3.64321172e-02f, 2.00312391e-01f, 1.39787659e-01f, -1.48062691e-01f, 2.83668358e-02f, -1.53781623e-02f, 8.46292749e-02f, 1.53985739e-01f, 1.72809228e-01f, 2.63259739e-01f,
  7.62350038e-02f, 6.87315911e-02f, -4.64734659e-02f, 6.98605031e-02f, 3.21642190e-01f, 1.09189801e-01f, -1.89456284e-01f, -4.16745991e-01f, 1.52934223e-01f, -1.29776835e-01f,
  1.46368667e-01f, -1.21740237e-01f, 1.97057575e-02f, -6.34235740e-02f, 2.84277042e-03f, 8.52138624e-02f, 1.48325404e-02f, -1.44001573e-01f, -3.80355626e-01f, -2.79516399e-01f,
  -1.70204788e-01f, -2.39661157e-01f, 9.62374453e-03f, -2.83049673e-01f, -3.75535749e-02f, 5.27792387e-02f, 5.50116599e-02f, -7.83766359e-02f, 9.01840180e-02f, 4.60677482e-02f,
  -2.84886688e-01f, -2.59202093e-01f, -2.02346280e-01f, -3.46275256e-03f, -1.99770123e-01f, -7.65578970e-02f, -3.84678226e-03f, 8.96153301e-02f, -1.37532810e-02f, -1.39668211e-01f,
  4.07464832e-01f, -2.17876926e-01f, -1.00274809e-01f, -2.88215071e-01f, 7.45384991e-02f, -1.22263737e-01f, -8.85608420e-02f, 2.08095163e-01f, 1.96624935e-01f, -4.39826474e-02f,
  7.31158927e-02f, 1.64575521e-02f, -9.64073464e-02f, 5.40476739e-02f, 1.29182771e-01f, 7.88391903e-02f, -4.09371629e-02f, -1.32306010e-01f, -2.51113866e-02f, -4.07671817e-02f,
  -8.05194750e-02f, 1.34708196e-01f, 1.59161374e-01f, 7.70444274e-02f, 2.02633813e-03f, 2.78240554e-02f, -1.44909963e-01f, 1.57666225e-02f, 8.64036530e-02f, -4.55478169e-02f,
  -1.23032622e-01f, -4.22264963e-01f, 3.07730228e-01f, -8.63774791e-02f, 5.81281967e-02f, 3.21709394e-01f, 9.39012468e-02f, 2.03829780e-01f, 1.78105667e-01f, 2.18711689e-01f,
  -5.95134646e-02f, 3.74859385e-02f, -1.04569152e-01f, 8.56833681e-02f, -1.85700670e-01f, -2.32869938e-01f, -9.59636830e-03f, -2.55634367e-01f, -2.40427628e-02f, 6.74227625e-02f,
  1.09437883e-01f, -4.99795042e-02f, -1.18936179e-03f, -5.17559312e-02f, -2.81395763e-02f, -1.62851233e-02f, 2.72797108e-01f, -1.64751559e-01f, -8.07802081e-02f, -2.12517798e-01f,
  -6.08693808e-02f, -5.57133928e-02f, -1.12976484e-01f, 2.01538622e-01f, 1.05697289e-01f, -2.79313892e-01f, -2.32325941e-01f, -1.62179634e-01f, -1.06652081e-01f, 7.27167502e-02f,
  -1.02309048e-01f, -1.67855695e-01f, 7.61589855e-02f, -1.00682177e-01f, 5.31034060e-02f, 9.99839231e-02f, 7.79893622e-02f, -7.83769879e-03f, -4.61404994e-02f, 5.37197515e-02f,
  -3.43597680e-02f, -3.21962126e-02f, 2.88158990e-02f, -5.14895804e-02f, 9.66445263e-03f, 6.68395534e-02f, 1.44238308e-01f, 4.39515822e-02f, -1.20702833e-01f, -2.42260713e-02f,
  4.09604535e-02f, 4.12092370e-04f, -2.59705018e-02f, 1.32395342e-01f, 5.39747626e-02f, -1.88870430e-01f, 1.46345794e-01f, 3.16417366e-01f, -4.10962924e-02f, 8.15601274e-02f,
  4.49340120e-02f, 8.01665261e-02f, -1.08329691e-01f, 2.63264775e-01f, -3.10103476e-01f, 2.00575963e-01f, 2.61642542e-02f, -1.46572858e-01f, 8.68703146e-03f, 1.77106634e-01f,
  1.30297750e-01f, -1.27860397e-01f, 1.96399704e-01f, -1.98117465e-01f, -7.22176135e-02f, -2.44365975e-01f, -2.87790168e-02f, -1.08641669e-01f, 1.15138382e-01f, 2.00004473e-01f,
  2.21641541e-01f, -1.27885550e-01f, -3.58157963e-01f, 1.64615810e-01f, 1.67335346e-01f, 2.23916203e-01f, -3.73201887e-03f, 3.09540927e-01f, 2.59186238e-01f, -4.65714596e-02f,
  -2.08372831e-01f, 3.57236564e-02f, -2.99961209e-01f, -1.81379735e-01f, 4.45630476e-02f, 3.80445980e-02f, 1.95111018e-02f, 5.32940105e-02f, -5.40271103e-02f, -2.84100231e-02f,
  3.50719914e-02f, 4.20671031e-02f, 4.86566238e-02f, 7.45166391e-02f, 4.11092117e-02f, 7.27116466e-02f, 2.92035416e-02f, 2.39748657e-02f, 1.29747033e-01f, -2.95964945e-02f,
  -7.78984949e-02f, 1.42137796e-01f, 7.30607510e-02f, 1.62448585e-01f, 3.23910229e-02f, 7.20180720e-02f, 1.80422857e-01f, 1.06369048e-01f, -5.99977486e-02f, 8.13354254e-02f,
  6.23375699e-02f, -4.18641344e-02f, 1.04525154e-02f, 4.09977399e-02f, 9.19975936e-02f, -9.96523127e-02f, 4.89149466e-02f, 9.88829806e-02f, 2.64888465e-01f, -2.12974951e-01f,
  1.23095289e-01f, -2.65570670e-01f, 1.66027527e-02f, -1.09334461e-01f, -2.30209474e-02f, -4.22742218e-02f, -8.89526904e-02f, 1.50953114e-01f, 9.16077346e-02f, 3.10432523e-01f,
  5.81759699e-02f, 1.59340844e-01f, -2.40480974e-01f, -1.06261216e-01f, 2.51242258e-02f, 8.30017030e-02f, 2.85514832e-01f, 2.02008799e-01f, 2.93682992e-01f, 1.77640855e-01f,
  2.83655375e-01f, -9.21426341e-02f, -1.00028411e-01f, 1.88366383e-01f, 9.47422162e-02f, 7.56809935e-02f, 3.17480862e-01f, 1.59248978e-01f, 1.85755804e-01f, 3.71384956e-02f,
  9.73414853e-02f, 2.13371918e-01f, 1.76243275e-01f, 2.03264758e-01f, 9.79523659e-02f, -1.29774166e-02f, -3.43243666e-02f, 1.97531685e-01f, -1.39734307e-02f, 1.06127828e-01f,
  9.06545892e-02f, -6.84519038e-02f, 3.61398384e-02f, 8.19014832e-02f, -1.04993112e-01f, 1.36065871e-01f, -5.63457683e-02f, -2.01580182e-01f, -6.90526981e-03f, 1.92375500e-02f,
  -4.31327075e-02f, -3.12310718e-02f, 6.16537556e-02f, -3.49372000e-01f, 1.60652936e-01f, 5.46251982e-02f, -1.93282396e-01f, -2.11592834e-03f, -3.77947800e-02f, 2.40129441e-01f,
  -4.19863649e-02f, 2.54517812e-02f, -3.91734727e-02f, 2.06765696e-01f, -2.11909097e-02f, 4.10062186e-02f, -2.79712491e-02f, -1.10592976e-01f, 3.44712213e-02f, -1.97886273e-01f,
  2.14829177e-01f, -8.08140710e-02f, -1.69610426e-01f, -2.75431365e-01f, 1.61375012e-02f, -2.03441456e-01f, -9.80637968e-02f, -1.14028022e-01f, 2.03933492e-01f, 1.07566163e-01f,
  -2.59370863e-01f, -6.62033856e-02f, -1.98985085e-01f, 2.32868478e-01f, -1.86252981e-01f, 1.46256641e-01f, -3.44765820e-02f, -7.29053915e-02f, -1.99737117e-01f, -2.18409017e-01f,
  7.34963687e-03f, 4.61274460e-02f, -6.10110862e-03f, 4.39010151e-02f, 2.65982538e-01f, 2.04390541e-01f, -6.26560599e-02f, 2.05521867e-01f, 9.31717455e-02f, -6.32195771e-02f,
  1.03372405e-03f, 2.26510763e-02f, 5.05115911e-02f, -3.43817286e-02f, -6.21480830e-02f, 3.14538553e-02f, -1.24554612e-01f, -9.16721020e-03f, 2.34969541e-01f, 2.92566121e-01f,
  -3.04769408e-02f, -1.38695449e-01f, 1.48523510e-01f, -6.94773048e-02f, 2.67757654e-01f, 2.31704116e-01f, 2.35858317e-02f, 2.13027839e-02f, -1.35516897e-01f, -1.07880816e-01f,
  -4.06087115e-02f, 7.15340376e-02f, -4.69467118e-02f, 8.11227039e-02f, 1.08659759e-01f, -1.20578654e-01f, 1.11989394e-01f, 2.70726625e-02f, -6.46831002e-03f, 2.99288213e-01f,
  1.30535781e-01f, -6.53669387e-02f, 6.28190190e-02f, -4.73628938e-02f, 2.04601005e-01f, 1.71118289e-01f, 1.72234215e-02f, -3.91231216e-02f, -1.76157817e-01f, -2.31581509e-01f,
  2.84870207e-01f, 7.74485022e-02f, 3.27987760e-01f, 2.44597211e-01f, 2.72415876e-01f, -4.74049821e-02f, -1.72783628e-01f, -2.23507777e-01f, 1.16901368e-01f, 1.10991366e-01f,
  -4.95435148e-02f, -2.44088635e-01f, 5.87063618e-02f, -2.19427109e-01f, 2.63575241e-02f, -1.18840739e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.02111363e-01f, 1.64175808e-01f, 6.21695369e-02f, 1.37009010e-01f, -1.14894956e-01f, 3.34204398e-02f, 1.84209738e-02f, 3.30748670e-02f, 2.44639572e-02f, -4.07373570e-02f,
  1.28099203e-01f, -7.89183229e-02f, 2.30002820e-01f, 2.48245925e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.13887243e-01f, -1.13940135e-01f, -1.11258082e-01f, -5.98741509e-02f, 1.13959581e-01f, 2.81742518e-03f, -2.54278421e-01f, -8.74735415e-04f, -1.69462085e-01f, -3.20101231e-02f,
  2.25650504e-01f, -1.16083346e-01f, -5.00731394e-02f, -1.63609698e-01f, -1.14980437e-01f, -1.20011382e-01f, -2.37513930e-01f, 3.30311172e-02f, -2.04296149e-02f, 4.71669436e-02f,
  -1.15303206e-03f, -2.98100531e-01f, -1.33675352e-01f, -2.40270626e-02f, 8.06333199e-02f, -1.66269168e-01f, -2.66840398e-01f, 1.97537467e-01f, 1.66461736e-01f, 1.96468025e-01f,
  -1.82970390e-01f, 9.41571817e-02f, -2.90851623e-01f, 1.57319337e-01f, 1.62974633e-02f, 7.63091072e-02f, 2.53795177e-01f, 7.79250860e-02f, -1.01359449e-01f, -5.55351675e-02f,
  -6.16665259e-02f, -2.84099519e-01f, -2.44185492e-01f, 6.20382279e-02f, -1.02314904e-01f, -1.31944984e-01f, 4.99185435e-02f, 5.29121049e-02f, -2.97713913e-02f, -2.84258008e-01f,
  2.83696391e-02f, -1.66759580e-01f, 1.04002036e-01f, 1.01039238e-01f, 1.04441727e-02f, 2.53068924e-01f, -7.57569075e-02f, -1.66785866e-01f, -2.71323204e-01f, -1.00867853e-01f,
  1.67134285e-01f, 6.68585598e-02f, -1.62089393e-01f, 1.47009611e-01f, 1.74606759e-02f, 8.56327042e-02f, 1.07133187e-01f, -1.60870865e-01f, -7.87740946e-02f, -2.03126848e-01f,
  -3.47873904e-02f, -6.11492284e-02f, -1.01838544e-01f, -1.17031284e-01f, 1.31919086e-01f, -2.11855516e-01f, -1.62633523e-01f, -1.07430592e-01f, -1.64182261e-02f, -1.51440948e-01f,
  -1.52097009e-02f, 4.67032902e-02f, 7.80175850e-02f, -1.21082328e-02f, -1.12692509e-02f, -2.56986439e-01f, -1.23594418e-01f, 4.68867719e-02f, -4.03783880e-02f, 9.41020176e-02f,
  -2.54788101e-01f, 2.17337713e-01f, 2.73697376e-01f, -1.68374509e-01f, -3.87638919e-02f, 2.23821282e-01f, -6.62143603e-02f, 4.32384223e-01f, -3.18515688e-01f, 2.50706851e-01f,
  2.00103849e-01f, 2.28348359e-01f, 2.76838422e-01f, -1.31917328e-01f, -2.18801290e-01f, -3.00171822e-01f, -3.46973926e-01f, 1.74421668e-02f, -1.96184963e-01f, 3.58997546e-02f,
  1.77426085e-01f, -7.90950507e-02f, 5.76429628e-02f, -1.50256589e-01f, -2.94686168e-01f, 1.16020560e-01f, 1.57321617e-03f, 3.47565114e-02f, 5.15641682e-02f, -2.32316837e-01f,
  -7.47892037e-02f, -2.83857167e-01f, -1.84677809e-01f, -9.06877406e-03f, -1.29169181e-01f, 4.35363054e-02f, -9.80316177e-02f, 1.90993317e-03f, -6.17606789e-02f, -1.44425467e-01f,
  6.85313493e-02f, 5.56252114e-02f, 1.02986945e-02f, -1.83539793e-01f, -5.16951724e-04f, 8.99071321e-02f, 1.12739662e-02f, -2.02131532e-02f, 6.86138347e-02f, 5.95459975e-02f,
  1.23998895e-02f, -2.19706893e-01f, 2.33351767e-01f, -3.63053661e-03f, -1.09053887e-01f, -1.21477224e-01f, -4.24335897e-02f, -1.55031169e-02f, -9.37930029e-03f, 2.56279316e-02f,
  -1.04076810e-01f, -7.50236958e-02f, 1.00902148e-01f, -1.38874829e-01f, -5.58545925e-02f, 5.62798418e-02f, 2.37533480e-01f, 1.22254387e-01f, 1.14917882e-01f, -1.06556490e-01f,
  9.91528854e-02f, 3.37804765e-01f, -9.19030607e-03f, 1.19159818e-01f, -1.42395094e-01f, -2.75602520e-01f, 2.19256766e-02f, -3.34543526e-01f, 1.45426095e-01f, 1.29136741e-01f,
  -9.74996686e-02f, -2.19591454e-01f, -1.28870055e-01f, -3.55057567e-02f, 2.74497420e-01f, -8.64607096e-02f, 1.47295728e-01f, 7.29293600e-02f, -1.90658316e-01f, 2.30905078e-02f,
  -1.25372067e-01f, 1.67687953e-01f, -1.16880752e-01f, 1.45595685e-01f, 6.56013414e-02f, -3.61722022e-01f, -4.31989133e-02f, 1.11655682e-01f, -1.48433834e-01f, -3.12058795e-02f,
  -2.87941918e-02f, 3.21817845e-02f, 3.44330445e-02f, 7.25007653e-02f, -1.92641690e-01f, -2.32455745e-01f, -2.58065999e-01f, 2.25567743e-02f, 1.52991461e-02f, 6.86948479e-05f,
  7.22954497e-02f, -1.51786610e-01f, -5.94941108e-03f, -9.72412080e-02f, -3.80367152e-02f, 1.48481214e-02f, 8.22585374e-02f, 2.32630581e-01f, -6.80391816e-03f, 6.12982064e-02f,
  -3.04241270e-01f, -1.47621512e-01f, 3.53204340e-01f, -1.37929276e-01f, 5.85748814e-02f, 1.60408214e-01f, -1.48406848e-01f, 1.10308230e-01f, 1.31476909e-01f, -2.00954318e-01f,
  -9.57880691e-02f, -1.95313562e-02f, 2.51844317e-01f, 8.34195539e-02f, -3.75242919e-01f, -4.93763275e-02f, 9.75924507e-02f, 8.01460221e-02f, 8.12654570e-02f, 1.00825906e-01f,
  2.15665326e-01f, 8.89834911e-02f, -2.61639833e-01f, 3.29405908e-03f, 7.69639795e-04f, 1.76343307e-01f, 1.09920084e-01f, -2.50392795e-01f, 1.61578923e-01f, 3.31876695e-01f,
  -1.25635073e-01f, 7.19677210e-02f, 2.36065283e-01f, 7.30904713e-02f, 2.40757823e-01f, -1.22744873e-01f, 4.43970524e-02f, -1.01149090e-01f, -3.00717037e-02f, 2.61033535e-01f,
  -1.74580485e-01f, -1.90740749e-01f, -1.58170119e-01f, 6.77232146e-02f, -6.13985620e-02f, 2.42984414e-01f, -8.81206170e-02f, 2.81736590e-02f, 1.70739423e-02f, -1.41704246e-01f,
  -3.47689092e-01f, -3.05466980e-01f, 5.24172671e-02f, 2.36979246e-01f, 3.51858772e-02f, 3.50107737e-02f, -8.65993500e-02f, 1.52359799e-01f, -1.26778930e-01f, -1.46731347e-01f,
  -3.11330426e-02f, 1.36656180e-01f, -1.52878761e-01f, -1.22943535e-01f, 5.37932590e-02f, 6.68203980e-02f, -4.28367183e-02f, 1.83532964e-02f, -1.05187781e-01f, -4.38534800e-04f,
  4.34803180e-02f, 6.81779087e-02f, -1.25627309e-01f, -1.14140198e-01f, -7.66210482e-02f, -1.96904242e-01f, 2.79720664e-01f, 1.71114653e-01f, 2.09298581e-01f, 1.55469373e-01f,
  -4.59779613e-03f, 1.21490695e-02f, 5.14710993e-02f, -1.04723657e-02f, 2.42093325e-01f, -4.68701078e-03f, 6.59078434e-02f, -2.21572772e-01f, -1.92226633e-01f, -3.15348476e-01f,
  5.59254698e-02f, -4.64327298e-02f, 1.50004178e-02f, -1.66393518e-01f, 2.15515718e-02f, -2.38362122e-02f, -5.63931353e-02f, 2.41500258e-01f, -1.26726508e-01f, -2.33540103e-01f,
  8.68318379e-02f, -2.23696202e-01f, -1.50532857e-01f, 1.48409426e-01f, -7.60012940e-02f, -1.06731251e-01f, -1.57461777e-01f, 1.39141098e-01f, -5.08302338e-02f, -1.98377028e-01f,
  -1.72135547e-01f, -3.59464772e-02f, 2.00399131e-01f, -1.59129337e-03f, -5.61165772e-02f, 9.30659298e-04f, -1.07905738e-01f, 2.02445835e-01f, 5.18442318e-02f, -5.10780923e-02f,
  1.51013196e-01f, 2.43527275e-02f, -4.13014963e-02f, -1.13585539e-01f, -3.50174531e-02f, -5.56313880e-02f, 1.51486499e-02f, -1.68792754e-01f, 1.95606798e-01f, -1.60023361e-01f,
  1.76915705e-01f, -9.34047326e-02f, -7.64018297e-02f, 1.37013271e-01f, 1.53370779e-02f, -1.48402765e-01f, -1.38551202e-02f, 2.73775548e-01f, -1.00475363e-01f, -1.61690623e-01f,
  -3.93158831e-02f, 2.56433755e-01f, 3.30799967e-02f, -4.73137535e-02f, 2.35039353e-01f, 2.57246941e-01f, -1.04637183e-01f, 1.20994277e-01f, 1.17124490e-01f, 1.64577663e-01f,
  1.52047649e-01f, -7.33942166e-03f, -5.35634719e-02f, -6.93269670e-02f, 1.61934227e-01f, -1.66695401e-01f, 1.12730108e-01f, 3.16304937e-02f, -1.58335373e-01f, 2.48540223e-01f,
  2.55595893e-02f, 3.64702195e-01f, 3.06506623e-02f, -6.91179931e-02f, -2.15206668e-01f, 1.43472827e-03f, -6.28339350e-02f, -1.26178145e-01f, -2.15971544e-01f, -9.34794247e-02f,
  -1.69413775e-01f, 2.34457761e-01f, -1.78057879e-01f, -1.12028271e-01f, 5.81059456e-02f, 2.14735955e-01f, 1.19830213e-01f, 1.45150810e-01f, 1.55482262e-01f, 9.01565999e-02f,
  -4.43812273e-02f, 1.00362286e-01f, 8.23176056e-02f, 7.87282586e-02f, 1.40899613e-01f, 2.00030413e-02f, 6.31773695e-02f, -1.41028976e-02f, 1.21847197e-01f, -2.38144509e-02f,
  -1.22179082e-02f, -1.77045256e-01f, 1.34198442e-01f, 1.18768781e-01f, -1.66774586e-01f, -1.81050360e-01f, 1.06626302e-01f, -6.86646923e-02f, 1.51900947e-01f, -1.71312690e-02f,
  3.35364938e-01f, -4.44002077e-02f, -2.29975745e-01f, -7.43105412e-02f, 3.43167305e-01f, 1.56841829e-01f, -7.82973878e-03f, 1.22945845e-01f, 2.06211463e-01f, 2.49713346e-01f,
  -2.98614979e-01f, -5.27181141e-02f, 3.76163602e-01f, -3.03180702e-02f, -7.23367780e-02f, -2.76591152e-01f, 1.27383515e-01f, 2.32309371e-01f, -3.89825672e-01f, -5.74680939e-02f,
  -2.44371489e-01f, -2.67002255e-01f, 8.40031505e-02f, 3.91294122e-01f, -4.84924689e-02f, -6.16898527e-03f, 1.55785650e-01f, 1.50623918e-01f, 2.55132109e-01f, -1.44846007e-01f,
  1.49237007e-01f, 1.68676246e-02f, 2.97795832e-01f, 1.70962423e-01f, -5.59044704e-02f, 1.05216168e-01f, 1.01898275e-01f, 7.08052590e-02f, 3.06267701e-02f, -2.78123077e-02f,
  -1.98544770e-01f, 2.27701157e-01f, -3.39737833e-01f, 4.41747941e-02f, -2.29698330e-01f, 1.71996502e-03f, 7.51463175e-02f, 4.02237438e-02f, -9.21402276e-02f, 8.46146122e-02f,
  -1.05630174e-01f, -1.58966154e-01f, 3.07723973e-02f, 2.79419571e-01f, -7.41358176e-02f, 2.13672608e-01f, 2.56527096e-01f, -3.01799864e-01f, 3.16256911e-01f, 5.31947017e-02f,
  -7.41150007e-02f, -3.75370719e-02f, 2.00744078e-01f, -5.83776720e-02f, 1.08871579e-01f, -2.01689512e-01f, -1.50421392e-02f, -9.77306627e-03f, 3.61092463e-02f, -1.25733465e-01f,
  1.85872510e-01f, -2.30595902e-01f, -5.98158538e-02f, -1.52161926e-01f, 8.84295180e-02f, -7.82789569e-03f, 2.73520276e-02f, 1.49572670e-01f, -7.33853579e-02f, 3.62893283e-01f,
  -7.32342526e-02f, -2.73876995e-01f, 3.08346361e-01f, -9.10398662e-02f, 2.45759234e-01f, 2.41675168e-01f, -3.38802151e-02f, 4.16734293e-02f, 9.77645442e-02f, 1.74175471e-01f,
  -5.36485277e-02f, -2.00564280e-01f, 1.17829308e-01f, 3.80452350e-02f, -1.54902026e-01f, 1.76862285e-01f, -3.01427871e-01f, -2.03499347e-01f, -7.07758069e-02f, -7.41513446e-02f,
  -3.59092727e-02f, -4.49668132e-02f, -2.37157911e-01f, 1.12876184e-01f, -7.62364417e-02f, 2.55522970e-03f, -3.67221177e-01f, -2.30110183e-01f, 1.00983016e-01f, 7.77914301e-02f,
  -1.69149324e-01f, -2.43198544e-01f, -2.15053514e-01f, -9.72026587e-02f, 4.05372865e-02f, -1.78649664e-01f, -6.86923414e-02f, 1.61071196e-01f, -4.84497175e-02f, -4.09060009e-02f,
  -1.53585345e-01f, 2.64890313e-01f, -1.75551921e-01f, -1.65831566e-01f, 2.03264784e-02f, -2.74219308e-02f, -1.91019326e-01f, -3.31417099e-02f, 1.70400932e-01f, 7.27066025e-02f,
  2.02464864e-01f, -1.28427535e-01f, 8.99156928e-02f, 2.96040028e-01f, -9.94128361e-02f, 2.37323567e-01f, -3.20006609e-01f, 1.49088576e-01f, 2.69400235e-02f, 5.20751998e-02f,
  2.50166982e-01f, -2.62027085e-01f, 6.21672459e-02f, -4.77843918e-02f, 1.65526807e-01f, -9.75473970e-02f, -7.00631142e-02f, 2.72184193e-01f, -7.19819590e-02f, -2.61135459e-01f,
  -1.68125510e-01f, 1.51185781e-01f, -2.01138273e-01f, 2.33823463e-01f, 3.38632524e-01f, 8.65873247e-02f, 8.85501429e-02f, -8.90026838e-02f, 1.64304480e-01f, -5.08210994e-02f,
  3.50116752e-02f, -9.93177518e-02f, -1.15593411e-01f, 2.21363410e-01f, 7.42455199e-03f, -2.64346767e-02f, -5.46619855e-02f, -2.04673201e-01f, -2.02941924e-01f, 3.99216898e-02f,
  1.77775502e-01f, 2.19474360e-01f, 3.09724305e-02f, -2.80455738e-01f, 1.23854063e-01f, -1.81575969e-01f, -4.59264033e-02f, 7.78726116e-02f, 6.33343756e-02f, -4.94124666e-02f,
  -9.17261317e-02f, -1.30980864e-01f, -8.15927684e-02f, 1.34098694e-01f, -1.02857754e-01f, -1.73732594e-01f, -6.38294667e-02f, 2.57523835e-01f, -5.96804023e-02f, -6.27364591e-02f,
  -7.34580010e-02f, -2.23258704e-01f, 1.61276888e-02f, -1.37099221e-01f, 5.65213040e-02f, 5.65257035e-02f, 2.54589636e-02f, -1.94025680e-01f, 2.86589444e-01f, -3.59438658e-02f,
  9.36458707e-02f, -2.09865764e-01f, -5.26835490e-03f, -3.25275600e-01f, -3.20279449e-01f, 2.12261896e-03f, 9.78667438e-02f, 3.30006510e-01f, -5.40520623e-02f, -2.74570465e-01f,
  5.29255986e-01f, 2.60471225e-01f, 8.41419399e-02f, 2.76343346e-01f, 1.79733232e-01f, 2.25284711e-01f, -8.22993964e-02f, -1.26972198e-01f, 1.77857298e-02f, 4.13277358e-01f,
  -1.60711020e-01f, 9.64642987e-02f, 3.44028063e-02f, -1.78639844e-01f, -6.12917766e-02f, 6.40745908e-02f, 7.18177930e-02f, -1.19701605e-02f, -8.23617801e-02f, -7.19160885e-02f,
  3.35998237e-02f, -4.82574292e-03f, 6.35131216e-03f, -1.69197574e-01f, -1.83248624e-01f, 2.92798883e-04f, -2.47973517e-01f, 6.79275393e-03f, -3.61127630e-02f, -1.78448901e-01f,
  -3.56236808e-02f, 5.28631583e-02f, -1.13992490e-01f, 3.21690030e-02f, -1.47301406e-01f, -2.98210084e-01f, -1.32464200e-01f, 2.47890919e-01f, -2.99201727e-01f, -2.04356015e-01f,
  1.77925661e-01f, -1.88786194e-01f, -7.71280029e-04f, -2.20397078e-02f, 8.54539275e-02f, -1.60021763e-02f, 2.88292213e-04f, 5.88988550e-02f, -3.26142818e-01f, -1.75441742e-01f,
  1.72203347e-01f, 2.35308558e-01f, -1.52426194e-02f, 7.87686557e-02f, -6.93630502e-02f, 2.75985837e-01f, 1.01902619e-01f, -9.14019793e-02f, 1.66350305e-01f, 2.31654167e-01f,
  1.56235352e-01f, -1.10688306e-01f, -3.47202301e-01f, 3.35815400e-02f, 2.18781233e-01f, -9.88443792e-02f, 1.61022559e-01f, 2.08343446e-01f, 2.61441767e-01f, 3.08061522e-02f,
  1.69289127e-01f, -5.00816926e-02f, -3.69505174e-02f, -3.48544754e-02f, -4.43167128e-02f, 1.34000638e-02f, 1.86007135e-02f, 1.28530607e-01f, -3.28071356e-01f, -1.16458818e-01f,
  -8.22468624e-02f, 2.37293303e-01f, -1.13000773e-01f, -2.74474192e-02f, 9.77751538e-02f, -3.31974596e-01f, 1.38065204e-01f, 1.54295877e-01f, 3.08030248e-01f, -1.68419302e-01f,
  -8.12347978e-03f, -9.80004147e-02f, 3.15386616e-03f, 1.23039313e-01f, 6.90303445e-02f, 5.43389954e-02f, 1.64418817e-01f, -1.36423543e-01f, 4.83052097e-02f, -1.45729020e-01f,
  -2.46817200e-03f, 2.19704315e-01f, 1.68214053e-01f, 2.44057000e-01f, -2.19757840e-01f, -3.01626939e-02f, -8.63455907e-02f, 6.20919243e-02f, 2.50389010e-01f, -2.52454251e-01f,
  -1.00246236e-01f, 1.49620533e-01f, -2.96678618e-02f, -1.26657963e-01f, -1.97159842e-01f, -2.38905922e-01f, -1.86460227e-01f, -1.68798566e-01f, 2.83457220e-01f, -2.82853663e-01f,
  -2.64455825e-02f, 6.23550750e-02f, -1.91205053e-03f, -8.06425735e-02f, 1.93238094e-01f, 2.19644979e-01f, -2.12489665e-01f, 2.65071001e-02f, -3.42668504e-01f, 1.96041942e-01f,
  -1.81499898e-01f, 1.11321643e-01f, -6.58401102e-02f, -7.85106197e-02f, 1.32958457e-01f, -8.19365978e-02f, -6.56441897e-02f, -5.39469458e-02f, 2.84580290e-02f, 3.47534828e-02f,
  -7.29646981e-02f, 1.31830228e-02f, 2.78686106e-01f, 2.97229574e-03f, 8.58767852e-02f, -1.99915096e-01f, 1.16396369e-02f, -1.43757075e-01f, 8.00939947e-02f, -1.21893540e-01f,
  -1.39190033e-01f, -1.84677869e-01f, 3.94372195e-02f, 2.95139253e-01f, -6.41078204e-02f, -7.46068433e-02f, -2.46388808e-01f, 1.99547093e-02f, 4.10419554e-02f, -1.72540158e-01f,
  -3.77121493e-02f, 2.06475809e-01f, 1.56788304e-02f, -1.43669844e-01f, 1.16029300e-01f, -2.94578653e-02f, -4.04140949e-02f, 1.89905643e-01f, 1.90489158e-01f, 3.29651497e-02f,
  7.91044086e-02f, -1.26569763e-01f, 3.45263593e-02f, 8.44301134e-02f, 1.26828894e-01f, -1.33894965e-01f, 2.38806859e-01f, 3.03085029e-01f, -1.50328964e-01f, -1.64149269e-01f,
  -1.84237927e-01f, 4.78176922e-02f, 1.10183112e-01f, -1.39158055e-01f, -5.02442867e-02f, -2.32642069e-01f, -1.07440762e-01f, -1.65114239e-01f, -1.77476183e-02f, 1.74093843e-01f,
  8.67744833e-02f, 3.25054407e-01f, -1.22757904e-01f, -9.94445160e-02f, -1.79843754e-02f, 2.70936072e-01f, -1.67781681e-01f, -1.25629485e-01f, 4.13051136e-02f, -1.10498965e-01f,
  -4.18934114e-02f, -2.51856893e-01f, -2.76567072e-01f, 1.68016497e-02f, 7.75221959e-02f, 1.82016969e-01f, 1.11995012e-01f, 1.62544399e-01f, 1.66504815e-01f, -2.95475662e-01f,
  2.57711142e-01f, 2.11169451e-01f, 9.80577990e-02f, 1.61017880e-01f, -1.58746570e-01f, -2.06395146e-02f, -3.72915417e-02f, -1.63991917e-02f, 8.53745639e-02f, 4.22182754e-02f,
  -1.73260570e-01f, -7.22827464e-02f, -5.49306814e-03f, -8.14267918e-02f, 5.69128841e-02f, 1.19803041e-01f, 1.13947153e-01f, -2.02482924e-01f, 9.10239369e-02f, -2.06751183e-01f,
  -2.18261838e-01f, 3.57510783e-02f, 3.23372185e-01f, 9.87340659e-02f, 7.83008635e-02f, 7.58334026e-02f, -1.71317354e-01f, 1.29863650e-01f, 6.42148107e-02f, -2.05280125e-01f,
  -1.85690098e-03f, 2.37025276e-01f, 3.63214985e-02f, -2.01880515e-01f, -4.30977315e-01f, -1.80011943e-01f, -1.57023326e-01f, -7.05543905e-02f, 1.70910396e-02f, -3.34993489e-02f,
  -1.44149035e-01f, -2.42113397e-01f, -1.50877580e-01f, 2.15684354e-01f, -1.63984656e-01f, 5.99255674e-02f, 6.57940507e-02f, -3.05367738e-01f, -9.75668654e-02f, 1.51367411e-01f,
  -1.64293811e-01f, -3.27125758e-01f, -2.52753142e-02f, -7.37549737e-02f, 1.89320907e-01f, -6.01759031e-02f, -2.61576831e-01f, -2.01959983e-02f, 9.58914235e-02f, 1.38457537e-01f,
  -1.67597637e-01f, -1.58591736e-02f, 7.96493068e-02f, -2.43330941e-01f, 1.29706696e-01f, 1.35761434e-02f, 1.58989400e-01f, 1.97695211e-01f, -3.34043764e-02f, -7.03391284e-02f,
  -3.31748515e-01f, -1.26258135e-01f, 1.58822432e-01f, 5.75579628e-02f, 9.62640643e-02f, -1.62774220e-01f, -1.28579676e-01f, -6.27052113e-02f, 2.01113150e-02f, 1.87736198e-01f,
  8.59710127e-02f, -9.41484496e-02f, -5.01572415e-02f, 1.20878816e-02f, -3.62866223e-01f, -1.51446551e-01f, 1.13292150e-01f, 1.49217501e-01f, -7.53173158e-02f, -1.34162214e-02f,
  -2.49166787e-01f, 3.02461565e-01f, 1.88596979e-01f, -7.80861676e-02f, -2.70922799e-02f, 1.54962406e-01f, 1.10986702e-01f, -4.25596952e-01f, 2.03043059e-01f, 1.43282101e-01f,
  -1.79542854e-01f, -5.75376675e-02f, 1.78569078e-01f, -1.87730730e-01f, -2.75880486e-01f, -8.05294663e-02f, 1.37717891e-02f, -2.58425083e-02f, 7.46196657e-02f, -3.09065320e-02f,
  1.99611664e-01f, 4.28651385e-02f, -3.06281745e-02f, 9.11129341e-02f, -1.38626352e-01f, -2.79774219e-01f, -7.98745155e-02f, 2.67939568e-02f, 1.60360709e-01f, 2.31894720e-02f,
  -8.54700729e-02f, 2.53164560e-01f, -7.81475827e-02f, 1.08120769e-01f, -2.16767907e-01f, -4.78597358e-02f, 1.32464543e-01f, -1.30827025e-01f, -1.15237199e-01f, -1.76484361e-01f,
  -1.72826499e-02f, -5.83869442e-02f, -8.74865241e-03f, -2.22640514e-01f, -6.52161986e-02f, -1.86278775e-01f, -1.90671682e-01f, -4.74902913e-02f, -4.99346256e-02f, 6.74167275e-02f,
  -2.47054920e-02f, 8.69830400e-02f, 4.01926376e-02f, -1.67898551e-01f, 8.37818682e-02f, -1.67790696e-01f, 1.84682801e-01f, -1.76841959e-01f, -1.67604312e-01f, -5.72888218e-02f,
  -4.57308367e-02f, 4.79162671e-02f, 8.18959996e-02f, -1.34656966e-01f, 1.62166268e-01f, -1.26211435e-01f, -1.18818119e-01f, -1.13905482e-01f, 1.23464786e-01f, 9.32389051e-02f,
  -3.67691182e-03f, 9.02984291e-02f, -2.69957334e-01f, 4.76258323e-02f, -2.62779325e-01f, -1.11213468e-01f, 1.65518045e-01f, -2.98121404e-02f, -3.20695251e-01f, -5.85303977e-02f,
  -1.18859783e-01f, 2.65177071e-01f, -2.96667159e-01f, -2.27106854e-01f, -1.48778111e-01f, -1.85342997e-01f, 3.09348423e-02f, 2.78159589e-01f, 6.09366857e-02f, -1.66887581e-01f,
  1.20605819e-01f, -2.54213005e-01f, 1.74670696e-01f, 1.13014884e-01f, -2.80516427e-02f, 2.39483014e-01f, 6.36200756e-02f, -1.73788249e-01f, -2.34780073e-01f, -1.21447951e-01f,
  1.83623031e-01f, -1.04486488e-01f, -1.15277467e-03f, -7.77132586e-02f, -1.03194214e-01f, 2.62506176e-02f, 1.84780136e-01f, 2.36113518e-01f, 2.11213827e-01f, 1.92931116e-01f,
  9.70247537e-02f, 4.31155674e-02f, -1.09437451e-01f, 8.19334537e-02f, 2.81205820e-03f, 9.49645489e-02f, 6.27709627e-02f, -4.79143150e-02f, 6.36800006e-02f, -7.07492754e-02f,
  -3.51705223e-01f, -1.39855504e-01f, 2.66570002e-01f, 1.60552129e-01f, 2.66519915e-02f, 1.25342712e-01f, 2.06884984e-02f, 1.04275323e-01f, 1.82298064e-01f, -1.68730974e-01f,
  2.50788242e-01f, 1.58275545e-01f, 8.72571170e-02f, -2.09024623e-01f, 2.30507702e-01f, 1.39813721e-01f, 1.45343184e-01f, 1.42745152e-01f, 3.07663471e-01f, -2.38094386e-02f,
  -2.91380584e-01f, -2.47576177e-01f, 2.97294110e-01f, -1.58543721e-01f, 2.56395936e-01f, 3.68390828e-02f, 1.45403162e-01f, -1.20608650e-01f, 8.56607556e-02f, -1.14512928e-01f,
  1.94603354e-02f, -9.55732018e-02f, 1.18048415e-01f, 3.24801475e-01f, -4.02998738e-02f, 1.49428830e-01f, -1.64131567e-01f, -7.73261441e-03f, -7.72735775e-02f, -1.76915199e-01f,
  -2.01716144e-02f, -4.19926718e-02f, 4.26328182e-01f, 2.21703291e-01f, -9.73682851e-02f, -7.10073635e-02f, 1.02551289e-01f, 5.94651513e-02f, -9.18931291e-02f, -2.96261422e-02f,
  -3.71875949e-02f, -2.37296475e-03f, 1.70372382e-01f, 1.48552433e-01f, -8.15897956e-02f, 3.40774581e-02f, 7.30036497e-02f, 5.01276217e-02f, 9.72423106e-02f, -4.79845367e-02f,
  -1.04275674e-01f, -1.00526875e-02f, 5.44847548e-02f, 2.07805395e-01f, -2.61533499e-01f, -1.18327573e-01f, 1.12668619e-01f, 2.03149572e-01f, -6.04857095e-02f, 3.16814333e-02f,
  -4.61272756e-03f, -1.40963644e-01f, 1.38783595e-02f, -3.49902749e-01f, -2.01293034e-03f, -1.12047747e-01f, -3.70317660e-02f, 3.10931474e-01f, -1.83242813e-01f, -2.08763868e-01f,
  -8.94094780e-02f, -5.73263727e-02f, 1.56139001e-01f, -3.46044302e-02f, -2.10217237e-01f, -3.33180465e-02f, -1.39622450e-01f, -1.91084564e-01f, 2.23538488e-01f, 1.27137229e-01f,
  1.07676862e-02f, -4.81724106e-02f, 9.51117743e-03f, 1.25398934e-01f, 8.72852281e-02f, -1.60798937e-01f, 2.04016834e-01f, 5.77221550e-02f, -7.95606971e-02f, -2.24350616e-01f,
  2.46210977e-01f, 3.11640143e-01f, -2.16924131e-01f, 1.35069281e-01f, -1.79365277e-02f, -2.11251214e-01f, 9.46959332e-02f, 1.17043227e-01f, 9.01188105e-02f, 3.04666255e-02f,
  1.13831960e-01f, 1.47055328e-01f, -2.07138225e-01f, -6.09405227e-02f, -1.12670148e-02f, 8.87495056e-02f, -1.18737176e-01f, 1.25922754e-01f, -5.56358211e-02f, 5.44932019e-03f,
  -5.07280566e-02f, -1.19234160e-01f, 3.33293043e-02f, 1.19470276e-01f, -3.04385461e-02f, -1.21228345e-01f, 5.48651293e-02f, 2.70213038e-01f, -2.62111962e-01f, -1.19894519e-01f,
  2.00431764e-01f, 2.52159446e-01f, -2.61949182e-01f, 1.90488398e-01f, -2.62765765e-01f, -2.31887236e-01f, 2.03292668e-01f, -1.29526004e-01f, -1.95058405e-01f, 1.37702838e-01f,
  9.62802395e-02f, 1.79051161e-01f, -1.59243450e-01f, -8.78938939e-03f, 6.44197986e-02f, 1.46534681e-01f, 4.68388349e-02f, -1.82421744e-01f, -8.98822993e-02f, -2.17887700e-01f,
  3.01073156e-02f, -3.07786018e-01f, 6.74312338e-02f, 3.08570117e-01f, -3.22039351e-02f, -2.10159749e-01f, 1.42024189e-01f, 2.23583039e-02f, 3.26128215e-01f, 5.85462786e-02f,
  1.48337469e-01f, -1.72398642e-01f, -1.84089504e-02f, 5.36690280e-02f, 2.49005690e-01f, 1.70969382e-01f, -3.72880772e-02f, 5.60150892e-02f, 5.50853014e-02f, -3.44500214e-01f,
  -1.40608236e-01f, -1.11290086e-02f, -3.40850241e-02f, -8.61973241e-02f, 4.61604148e-02f, 1.94965363e-01f, -1.29347399e-01f, 4.42326814e-02f, 1.10484794e-01f, -1.67452008e-01f,
  -1.97588336e-02f, 2.25192904e-01f, 3.02910563e-02f, 7.34510124e-02f, -8.00010040e-02f, -2.17684880e-02f, 7.84026738e-03f, 1.77071646e-01f, 1.29046813e-01f, -6.83659175e-03f,
  5.42912334e-02f, 3.78119685e-02f, -8.14366564e-02f, 1.73305556e-01f, 1.30027324e-01f, 9.02696699e-02f, -2.21727610e-01f, -1.46611929e-02f, -9.51772556e-02f, -1.12495802e-01f,
  -7.33224824e-02f, -1.99023396e-01f, -3.99425300e-03f, 1.18969768e-01f, 1.49311498e-01f, -2.47526258e-01f, -2.89321654e-02f, 2.41282135e-01f, 1.22275703e-01f, 7.62063488e-02f,
  1.07187025e-01f, 1.66056708e-01f, -6.65979013e-02f, -7.07604289e-02f, 2.03675792e-01f, -3.30216885e-02f, 9.43499282e-02f, -2.30286233e-02f, -7.65547007e-02f, 1.79612815e-01f,
  5.53868115e-02f, -2.21512377e-01f, 1.65422484e-01f, -9.31400433e-02f, 7.31731504e-02f, 2.13334784e-01f, -6.21428564e-02f, 4.06701386e-01f, -4.54557408e-03f, -1.09203883e-01f,
  -2.44631916e-01f, -2.92062312e-01f, 1.64027601e-01f, 1.72497317e-01f, 2.35496148e-01f, 6.49417937e-02f, -4.62005008e-03f, 1.23411659e-02f, -6.42703772e-02f, 4.78062825e-03f,
  -1.14830412e-01f, -2.11005136e-01f, -1.21050842e-01f, -2.02539355e-01f, -9.08833742e-02f, -4.52087581e-01f, -1.15059905e-01f, -1.90828204e-01f, -1.20749079e-01f, 4.38697971e-02f,
  -6.36990368e-02f, -1.57891795e-01f, -3.17698956e-01f, -6.51738122e-02f, -1.38287067e-01f, -2.13482995e-02f, -1.81040078e-01f, -1.78245351e-01f, -1.19303048e-01f, 2.97718048e-01f,
  -3.26722383e-01f, -1.77242830e-01f, 1.09542049e-01f, 1.61619869e-03f, -1.19277174e-02f, -2.86896169e-01f, 1.40639141e-01f, 4.04144883e-01f, 2.53281206e-01f, -1.23172514e-01f,
  1.59993162e-03f, 1.56214193e-01f, -2.61697143e-01f, 2.71504343e-01f, -8.59179944e-02f, 1.88249767e-01f, 1.69737741e-01f, -2.32145861e-01f, 1.27886280e-01f, -2.11134292e-02f,
  -1.17102206e-01f, -8.60077888e-02f, -4.94777597e-02f, 8.73671025e-02f, -1.52863964e-01f, 2.49277875e-01f, 3.29597183e-02f, -3.30887377e-01f, -7.35209584e-02f, 3.01301256e-02f,
  3.65686119e-02f, -1.27339363e-01f, 1.00304246e-01f, 9.80254710e-02f, 1.10491738e-01f, -2.55233109e-01f, 1.89916730e-01f, -7.28615895e-02f, 1.27134159e-01f, -3.11476290e-02f,
  -1.69346154e-01f, 4.83342074e-02f, -5.34461252e-02f, -1.24230441e-02f, -2.67132670e-01f, -1.17084689e-01f, -1.72477439e-01f, -9.89982709e-02f, 9.18136090e-02f, 2.27162227e-01f,
  -1.09422088e-01f, -1.73501506e-01f, 1.51263863e-01f, -1.35189638e-01f, -1.37449563e-01f, 9.22446474e-02f, -1.99125171e-01f, 4.10871534e-03f, -2.60912538e-01f, 2.13501863e-02f,
  -1.99456602e-01f, 5.59582561e-02f, -2.57692754e-01f, -3.06196213e-02f, -1.44614473e-01f, -5.43639176e-02f, -1.29603922e-01f, -1.85549587e-01f, -4.29280289e-02f, -9.74199250e-02f,
  -3.39770876e-02f, 6.64693937e-02f, -6.30764570e-03f, 4.61846069e-02f, -6.31870776e-02f, -6.72387257e-02f, -3.39024141e-02f, -5.02444021e-02f, 3.41765583e-01f, 1.53382614e-01f,
  -2.28714734e-01f, -3.11927021e-01f, -1.06482208e-02f, 4.04338874e-02f, 5.08566014e-02f, 1.63576379e-01f, 2.64258049e-02f, 2.51793712e-01f, 2.82421440e-01f, -8.82922038e-02f,
  3.11376929e-01f, 6.44601732e-02f, 3.76721561e-01f, -9.36163887e-02f, 4.25695367e-02f, -9.31629259e-03f, -1.12903044e-01f, -1.75641887e-02f, -3.05155516e-01f, 1.91119105e-01f,
  5.84460385e-02f, -8.62758681e-02f, -9.12971944e-02f, 6.00318611e-02f, 1.30675569e-01f, 9.63098481e-02f, -1.66241497e-01f, -1.02827111e-02f, -1.81784257e-01f, 4.05541882e-02f,
  7.68377334e-02f, -4.06593978e-01f, -3.93874906e-02f, -7.64094200e-03f, 1.23073205e-01f, -2.93544531e-01f, 1.61759436e-01f, 4.42088135e-02f, 3.03986333e-02f, -1.74378365e-01f,
  -2.89292093e-02f, -1.42035842e-01f, 1.71987355e-01f, 5.74984625e-02f, 2.86560953e-02f, 1.07993456e-02f, -1.58775151e-01f, 1.61058575e-01f, 9.04643908e-02f, -1.98312566e-01f,
  3.20209116e-02f, 7.57469162e-02f, -7.84811098e-03f, -1.63207039e-01f, 1.52483627e-01f, -1.19557284e-01f, 1.72154889e-01f, 1.54057937e-02f, 8.76315460e-02f, 2.92792171e-01f,
  -8.65175501e-02f, 3.56394708e-01f, 1.38981164e-01f, -2.55707675e-03f, -2.32554376e-01f, 2.47072447e-02f, 2.14493483e-01f, -1.89455360e-01f, -3.56187448e-02f, -1.95808798e-01f,
  -1.18720941e-01f, 1.72144219e-01f, -1.59008935e-01f, -1.69161588e-01f, -3.88464406e-02f, -1.24756850e-01f, 1.37147784e-01f, -9.09016132e-02f, 4.85770032e-02f, 1.84290037e-02f,
  -6.11303039e-02f, 1.96348261e-02f, -2.69542962e-01f, 2.02841476e-01f, 1.32559597e-01f, -1.99232921e-01f, 1.48333306e-03f, 1.52575478e-01f, -1.58540443e-01f, 1.60791397e-01f,
  1.10016059e-04f, 2.14696333e-01f, 5.33777624e-02f, 2.06901893e-01f, -2.14753430e-02f, -3.18321109e-01f, -9.68412608e-02f, 1.56485494e-02f, -4.53899167e-02f, -1.20023452e-01f,
  -6.87737111e-03f, 9.66798794e-03f, -3.00164908e-01f, -1.23974241e-01f, -7.28350552e-03f, 2.55127817e-01f, -5.55174053e-02f, 1.35150515e-02f, 1.83517203e-01f, -1.59409493e-01f,
  -4.88268048e-01f, 1.90437306e-02f, -2.49670353e-02f, -1.66629747e-01f, 7.64031783e-02f, -3.41900601e-03f, -1.28976613e-01f, 6.17040433e-02f, 1.39768168e-01f, -2.19381452e-01f,
  -8.73658583e-02f, 1.36793122e-01f, 3.89760360e-03f, -8.15785527e-02f, -4.17578667e-01f, -1.42768072e-03f, -2.23296970e-01f, 1.23725988e-01f, 1.65776327e-01f, 1.48388848e-01f,
  -1.24265879e-01f, -5.41643985e-02f, -3.01176637e-01f, -1.47042379e-01f, 2.21000798e-02f, 2.41158321e-01f, -1.82498083e-01f, 1.45760149e-01f, -2.76403129e-01f, 8.62396136e-02f,
  -7.55602121e-02f, -1.43394321e-01f, 2.35511199e-01f, -7.29043931e-02f, 2.74782419e-01f, -8.02307576e-02f, 4.91495654e-02f, 2.61743814e-02f, 3.70355658e-02f, 1.04512192e-01f,
  -8.48136917e-02f, -2.95264363e-01f, 1.54276043e-01f, 1.00853994e-01f, -1.04111843e-01f, -1.97602585e-01f, -9.32791978e-02f, -4.45471928e-02f, 6.48615062e-02f, -1.25018418e-01f,
  2.42114160e-02f, 1.21425137e-01f, -5.40540507e-03f, -5.53827547e-02f, 9.59790945e-02f, 1.57853682e-02f, 9.65274945e-02f, -1.39789004e-02f, 1.61576450e-01f, -1.20149672e-01f,
  1.97129354e-01f, 5.63945509e-02f, 5.51220514e-02f, 2.25601792e-02f, -2.70297259e-01f, 2.70159215e-01f, 1.11323193e-01f, -1.76766947e-01f, 1.00725979e-01f, -2.77047195e-02f,
  -5.82593940e-02f, -5.08584902e-02f, 2.77729273e-01f, 9.37218219e-02f, 4.94049974e-02f, 2.01503113e-02f, 1.40088955e-02f, 2.21881256e-01f, -2.10189447e-01f, 2.00451165e-01f,
  1.67360649e-01f, 1.59364268e-01f, -1.87604725e-01f, -9.43224803e-02f, 1.63932353e-01f, -1.71711892e-01f, 3.84968519e-02f, -1.38894454e-01f, -1.85762390e-01f, 3.05300772e-01f,
  -2.16101691e-01f, -3.49588431e-02f, 1.28553629e-01f, 5.62370233e-02f, -7.76881501e-02f, 3.04778330e-02f, 6.88399971e-02f, -1.45351604e-01f, 1.09838657e-01f, -1.23015400e-02f,
  -1.52640924e-01f, -1.44231364e-01f, 2.50755787e-01f, -1.50486127e-01f, 7.04168007e-02f, -4.44006436e-02f, -4.07044850e-02f, -2.17160434e-01f, 1.26951322e-01f, 3.09933871e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.28175631e-01f, 1.15742236e-01f, -2.28028297e-02f, 1.87903479e-01f, -7.80069828e-02f, 8.98740292e-02f, 2.10017040e-01f, 6.23366870e-02f, 1.19290948e-01f, -1.35181755e-01f,
  4.08241712e-02f, 9.14077833e-02f, 2.85614952e-02f, -4.61010151e-02f, -3.59803066e-02f, 3.20907533e-02f, 1.36511959e-02f, 2.70466685e-01f, -3.17360669e-01f, -1.16137668e-01f,
  8.75783041e-02f, 6.90723062e-02f, 7.81484693e-02f, 3.06962669e-04f, -5.35158254e-02f, 1.63952768e-01f, 1.96549565e-01f, -3.52483690e-01f, 3.46957445e-02f, 1.79726984e-02f,
  2.54264861e-01f, -2.89251566e-01f, 2.24414885e-01f, -1.08833134e-01f, -1.84447616e-01f, -2.85764605e-01f, -1.81526110e-01f, -2.30489686e-01f, -1.41179964e-01f, -7.16227815e-02f,
  2.26935759e-01f, 2.71494329e-01f, 1.74253449e-01f, -1.96935624e-01f, 2.67982006e-01f, -8.74367729e-03f, 2.02474132e-01f, 2.71363169e-01f, 1.75238580e-01f, -2.25605182e-02f,
  9.67097282e-02f, -8.29424858e-02f, -2.55855382e-04f, 7.04573169e-02f, -1.88650675e-02f, 2.58977622e-01f, 2.08916739e-01f, 5.11624292e-02f, -7.97448531e-02f, 1.55322105e-01f,
  8.23842362e-02f, -4.80185077e-02f, 1.13388576e-01f, 1.30518600e-01f, -2.27186322e-01f, -7.95567334e-02f, -1.28275216e-01f, 1.50575936e-02f, -4.36699241e-02f, 4.35342371e-01f,
  -1.31690159e-01f, 2.46530920e-02f, 3.37649845e-02f, -5.27275121e-03f, -2.12170988e-01f, 1.35843053e-01f, -4.20350879e-02f, -6.18118010e-02f, 4.35122773e-02f, 2.14344054e-01f,
  4.29731943e-02f, 3.15139502e-01f, 1.11582130e-01f, -1.99446172e-01f, -2.78063357e-01f, -3.32737751e-02f, 1.60695344e-01f, -2.12277561e-01f, 3.26633781e-01f, -1.07259579e-01f,
  1.54227063e-01f, -3.58747542e-01f, -1.17182843e-01f, 9.95816439e-02f, 2.87719280e-01f, 1.78819895e-02f, 2.92812437e-01f, -3.71864468e-01f, -7.90299699e-02f, -1.38693511e-01f,
  -1.69865415e-01f, -7.32076764e-02f, 9.97403786e-02f, -2.79671382e-02f, 1.03371494e-01f, 1.73146382e-01f, -3.70885469e-02f, -5.01849115e-01f, 1.44067377e-01f, 2.71504194e-01f,
  4.77294698e-02f, -1.13299668e-01f, 1.63119867e-01f, 1.62393957e-01f, -2.04059303e-01f, -8.67735818e-02f, -3.81998383e-02f, 2.05927864e-01f, 1.22780651e-01f, -2.92117130e-02f,
  3.14224154e-01f, -1.97776146e-02f, 3.35219055e-02f, 2.34153792e-02f, 3.17558706e-01f, 6.26427531e-02f, 9.47307125e-02f, -6.30011186e-02f, -9.23042744e-02f, 1.96811363e-01f,
  2.56398737e-01f, 1.19677797e-01f, -3.35687965e-01f, -3.63217704e-02f, 7.01743513e-02f, 5.62460870e-02f, 1.16115548e-01f, 8.45289901e-02f, 1.66816920e-01f, 2.37302240e-02f,
  3.50885876e-02f, 2.09447518e-02f, 1.70061812e-01f, -2.79281959e-02f, -7.33207911e-02f, -1.42962724e-01f, 1.54420748e-01f, 1.34313881e-01f, 1.47461578e-01f, 9.52098221e-02f,
  1.10701084e-01f, 4.70946841e-02f, -2.98834831e-01f, 1.84986874e-01f, 2.89074123e-01f, 2.17096716e-01f, 1.16664574e-01f, 1.38167173e-01f, -4.11135890e-02f, 2.09948108e-01f,
  -9.89517495e-02f, 4.38177526e-01f, -8.78999755e-02f, 3.66580039e-01f, -2.28840798e-01f, -1.26372784e-01f, 2.46923104e-01f, -2.33851865e-01f, -7.32411668e-02f, -3.00946444e-01f,
  1.02773242e-01f, 4.22768295e-01f, 1.53691947e-01f, -2.15426907e-01f, 1.32457092e-02f, -1.85361892e-01f, -1.81785207e-02f, 1.35700971e-01f, -1.59854407e-03f, 2.49474630e-01f,
  1.88653454e-01f, 1.12819504e-02f, -7.69219100e-02f, -4.96587902e-02f, 1.01480715e-01f, -9.08680037e-02f, -3.52275558e-02f, -2.71460935e-02f, -3.26446712e-01f, 2.32997537e-01f,
  4.96186502e-02f, 3.29111628e-02f, -2.55233026e-03f, 1.38495609e-01f, 1.00832187e-01f, -1.69577748e-01f, 2.73977835e-02f, 2.22408980e-01f, -3.09013575e-02f, -3.44491042e-02f,
  1.15144916e-01f, -5.48090925e-03f, -6.49051145e-02f, -4.13916185e-02f, 2.25839049e-01f, 8.73482451e-02f, 4.83364761e-02f, 1.13280237e-01f, -1.04336321e-01f, 1.71552658e-01f,
  -5.11421040e-02f, -1.20058082e-01f, -1.85005620e-01f, -7.19143450e-02f, 1.92020595e-01f, -1.60826772e-01f, 1.49584249e-01f, -2.90559977e-01f, 3.56799245e-01f, -1.67059615e-01f,
  2.87453346e-02f, 2.44918000e-02f, 2.92204499e-01f, 2.15139925e-01f, 8.02418813e-02f, -6.96651172e-03f, 2.22935081e-01f, 1.46614537e-02f, -1.44621521e-01f, -6.73941448e-02f,
  2.49542788e-01f, -2.96881218e-02f, 1.47441819e-01f, -1.13568202e-01f, -1.90231562e-01f, 4.79609631e-02f, -1.44924536e-01f, 3.47301960e-01f, -7.85273984e-02f, 3.14120725e-02f,
  2.45194599e-01f, 3.41552228e-01f, -6.95851147e-02f, -1.59052745e-01f, 1.98852539e-01f, -1.13051333e-01f, 1.15460433e-01f, 5.11055887e-02f, 2.12573394e-01f, -9.44838747e-02f,
  2.72464067e-01f, 8.42306986e-02f, -2.73129590e-05f, 1.57441765e-01f, -3.56971356e-03f, -5.03507704e-02f, 1.84048694e-02f, 2.82254606e-01f, -5.64880744e-02f, -1.51900232e-01f,
  1.19907670e-01f, 2.91426689e-03f, -3.66857350e-02f, -1.28598273e-01f, 1.67723686e-01f, -8.33695941e-03f, 7.95399994e-02f, -4.52308208e-02f, 3.08783427e-02f, 1.19159615e-03f,
  2.91653752e-01f, 1.73999950e-01f, 1.18399384e-02f, 1.65984910e-02f, -4.53488499e-01f, 2.02166975e-01f, 1.92868263e-01f, -2.85730034e-01f, -3.18421870e-02f, -8.68915766e-03f,
  -3.85320596e-02f, 2.19589084e-01f, -6.76974580e-02f, -1.86301708e-01f, -1.20044604e-01f, 1.78605065e-01f, -1.05558060e-01f, -7.68327489e-02f, -4.62423146e-01f, 2.21822992e-01f,
  -2.58360714e-01f, -1.84717514e-02f, -1.24744743e-01f, 3.16879898e-02f, 1.68653861e-01f, -2.86414742e-01f, -2.21366122e-01f, -2.61110693e-01f, 1.31310701e-01f, 2.43664399e-01f,
  -4.04482424e-01f, -6.19081296e-02f, -1.74764484e-01f, 2.64639139e-01f, 4.99055423e-02f, -1.37433171e-01f, 3.77026618e-01f, -2.17990801e-01f, 2.28150770e-01f, 1.07590355e-01f,
  1.43707499e-01f, -1.25518471e-01f, 9.47110727e-02f, -7.66013563e-02f, -7.44996592e-02f, -1.54747829e-01f, -2.11452469e-01f, 8.19048509e-02f, 4.74100038e-02f, 1.83409393e-01f,
  1.15156740e-01f, 1.44796371e-01f, -3.52995954e-02f, 3.95161062e-01f, -1.55850425e-01f, 1.93180248e-01f, 2.73692627e-02f, 1.70344010e-01f, 4.12435979e-02f, 4.08545025e-02f,
  -2.17875957e-01f, -1.37277976e-01f, 1.03602588e-01f, 3.47119123e-02f, -1.77695870e-01f, 1.09769754e-01f, 5.06086238e-02f, 7.84289241e-02f, -1.34947732e-01f, -3.30351800e-01f,
  1.59201026e-01f, 2.39652291e-01f, 7.84455314e-02f, 2.04110429e-01f, 1.10813975e-01f, -2.99775340e-02f, -5.43363355e-02f, -9.67465416e-02f, -1.50813535e-01f, 2.70945549e-01f,
  2.24747121e-01f, -1.40989482e-01f, 1.55372232e-01f, -2.97326893e-01f, 2.91015375e-02f, -2.03039244e-01f, -8.97079892e-03f, 1.14707217e-01f, -1.40078530e-01f, 1.78589091e-01f,
  -2.88950294e-01f, 1.93718046e-01f, 1.56713232e-01f, -2.50213832e-01f, 1.95095152e-01f, 1.62926376e-01f, -3.92400250e-02f, 2.82361329e-01f, 7.48178363e-03f, 1.44393623e-01f,
  2.24217728e-01f, -1.65815279e-01f, 2.15519387e-02f, -1.29469037e-01f, 3.53164761e-03f, 3.14357877e-01f, 2.48567104e-01f, -5.88196851e-02f, -3.71831208e-01f, 4.52319644e-02f,
  2.22318113e-01f, 1.78999171e-01f, -1.24063954e-01f, -9.83176082e-02f, 1.44462110e-02f, 1.69325061e-02f, 1.35224581e-01f, 3.08671713e-01f, 1.58598974e-01f, 3.74082960e-02f,
  2.28288084e-01f, 2.90113837e-01f, -8.97611082e-02f, 2.63355315e-01f, 2.50006914e-01f, 1.52548015e-01f, 2.95215040e-01f, 8.13866481e-02f, 1.29464254e-01f, -1.37179092e-01f,
  2.62360927e-02f, 5.34604564e-02f, 2.73640573e-01f, 1.62266880e-01f, 3.07758123e-01f, 3.99471015e-01f, -2.10764408e-02f, 1.46359876e-01f, 1.81655735e-01f, 6.46615848e-02f,
  1.79591477e-02f, 2.13364512e-02f, 8.89916569e-02f, -8.65399688e-02f, 2.07006723e-01f, 1.25760049e-01f, 1.23830922e-01f, 1.05772063e-01f, 1.74222350e-01f, 1.16760775e-01f,
  -2.45356560e-01f, 7.61785060e-02f, 1.72197506e-01f, -1.55703455e-01f, 1.56384617e-01f, -1.23396274e-02f, -1.46322459e-01f, 1.46020785e-01f, 2.12180302e-01f, -2.48081759e-01f,
  -5.10822088e-02f, 2.36364990e-01f, -3.34012300e-01f, -6.75235875e-03f, 2.09617212e-01f, 2.15457752e-01f, -1.56404048e-01f, -2.92553842e-01f, -2.26229399e-01f, 1.56425357e-01f,
  2.68041547e-02f, 1.83832705e-01f, 7.19289109e-02f, 1.13582857e-01f, -6.44494444e-02f, -8.90190527e-02f, 5.79901300e-02f, 3.61466050e-01f, 5.75002395e-02f, -1.55536821e-02f,
  7.97832906e-02f, 2.48877540e-01f, 1.26070172e-01f, 1.67713836e-01f, 5.15642017e-02f, 1.22119680e-01f, 2.80842483e-01f, 1.36338457e-01f, 1.07821181e-01f, 1.86312631e-01f,
  1.53924420e-01f, -1.88093372e-02f, 1.41120628e-01f, -5.23308069e-02f, -2.33888432e-01f, 6.53027520e-02f, 3.41981351e-01f, 4.93997559e-02f, 3.67801189e-02f, 2.68467546e-01f,
  -2.42581099e-01f, 2.40060970e-01f, 1.55613527e-01f, -1.71398848e-01f, -1.93230733e-01f, 9.07975957e-02f, -3.33087482e-02f, -1.04162823e-02f, 5.97234182e-02f, 9.27446857e-02f,
  4.96665806e-01f, 2.03179251e-02f, 3.74627233e-01f, 2.06575282e-02f, -3.59712839e-01f, -1.58527046e-01f, 2.33534276e-01f, -1.85622945e-01f, 1.82582691e-01f, 1.92398876e-01f,
  -7.21112713e-02f, -9.86649916e-02f, 1.62356749e-01f, -1.27097741e-01f, 1.79606244e-01f, 3.56691633e-03f, 1.65140867e-01f, 2.13169396e-01f, 5.27452417e-02f, 1.69211954e-01f,
  -3.19670409e-01f, -5.57090975e-02f, -1.66986272e-01f, 1.34859560e-02f, -1.76923364e-01f, -1.07433878e-01f, 1.62018627e-01f, 3.55489373e-01f, -1.25836343e-01f, -2.09459886e-01f,
  1.28002450e-01f, 3.27537060e-01f, -5.07745100e-03f, 2.09748164e-01f, 7.78085589e-02f, -1.94615364e-01f, 4.47373241e-02f, 8.57556835e-02f, 1.63994819e-01f, -3.08292639e-02f,
  2.24364102e-01f, -2.36670137e-03f, 1.27490267e-01f, 1.64964303e-01f, 1.64510787e-01f, 1.22082122e-02f, 1.24533325e-01f, 2.13181168e-01f, 3.23918760e-02f, 3.96248624e-02f,
  -9.78758261e-02f, 2.14940563e-01f, -4.18715328e-01f, -1.72985047e-02f, 5.93899526e-02f, -2.35283956e-01f, 6.89980164e-02f, 1.14583664e-01f, 3.97102863e-01f, 6.85205013e-02f,
  2.07793117e-01f, 1.22111306e-01f, -1.90115441e-02f, -2.77484149e-01f, 2.13303760e-01f, 1.82073489e-01f, 3.19305924e-03f, -2.66380906e-01f, -2.14490891e-01f, -3.62528950e-01f,
  4.12482116e-03f, -3.77967238e-01f, 1.10773109e-01f, 5.13265207e-02f, 2.54036486e-01f, -1.48642194e-02f, -1.33269608e-01f, 2.53576517e-01f, 4.23483461e-01f, -1.15775019e-01f,
  3.66399288e-01f, -1.57511637e-01f, -4.60437648e-02f, -5.73225170e-02f, 2.13950053e-01f, 2.04402223e-01f, 4.63832021e-02f, -6.70529017e-03f, 1.79308489e-01f, -3.73355836e-01f,
  6.76813945e-02f, 2.29201004e-01f, 1.15951486e-01f, -2.47855842e-01f, 3.22827339e-01f, 1.89151004e-01f, 2.96659619e-01f, 5.38923666e-02f, 1.82198152e-01f, 7.91550353e-02f,
  2.46174604e-01f, 1.83469430e-01f, 1.51719183e-01f, 3.87654044e-02f, 7.25275427e-02f, 1.75479665e-01f, 3.07112068e-01f, 2.57893711e-01f, 1.26961142e-01f, 1.54664755e-01f,
  1.53105453e-01f, 1.85162455e-01f, 2.12152496e-01f, 3.19871902e-02f, 8.80077332e-02f, 2.74648756e-01f, -2.67658412e-01f, 2.23739460e-01f, 3.69602777e-02f, -1.15172043e-01f,
  -1.85551986e-01f, 2.70206004e-01f, 1.52555639e-02f, 8.70230347e-02f, -1.05402797e-01f, 1.25999460e-02f, -6.20041117e-02f, -2.41084620e-02f, 3.55776519e-01f, -1.69557661e-01f,
  9.37558115e-02f, -3.31905872e-01f, -3.89422886e-02f, -9.37837511e-02f, -7.06383660e-02f, -1.63587868e-01f, -3.76355685e-02f, 7.39842281e-02f, 1.26086205e-01f, -2.47056410e-02f,
  5.24285398e-02f, 8.37029591e-02f, -2.00420037e-01f, -1.98695362e-01f, -3.03363316e-02f, -7.14314170e-03f, -1.07208692e-01f, 1.48917183e-01f, -1.81649342e-01f, 4.52566855e-02f,
  4.12332192e-02f, -1.30852655e-01f, 7.64706209e-02f, 9.22978818e-02f, 5.67356825e-01f, 4.80321869e-02f, 1.01084523e-01f, -2.12676510e-01f, 2.25140944e-01f, 5.77101558e-02f,
  1.70040831e-01f, 2.20782943e-02f, 1.45389661e-01f, 1.66964561e-01f, -2.25461021e-01f, 1.45336360e-01f, -1.16713271e-01f, 8.13687220e-02f, 1.91398144e-01f, -6.80537969e-02f,
  -7.12098181e-03f, 3.66772227e-02f, -8.51688832e-02f, 1.26761377e-01f, 1.61737904e-01f, 7.63881439e-03f, 1.04190849e-01f, 1.38064772e-01f, 6.21442273e-02f, -7.83694834e-02f,
  2.03029156e-01f, 1.53594285e-01f, 8.61519482e-03f, -2.25996096e-02f, 2.33467945e-04f, 3.78185630e-01f, -1.15128815e-01f, -1.90527827e-01f, 5.01470231e-02f, 2.53567010e-01f,
  -2.11046921e-04f, -2.94649094e-01f, 2.78734922e-01f, -3.01975906e-01f, -3.76798250e-02f, -2.80212611e-01f, -3.03893924e-01f, -1.09564006e-01f, -3.77959669e-01f, -5.72146922e-02f,
  1.68946147e-01f, 2.34568849e-01f, 3.01416785e-01f, -2.50691306e-02f, 2.09035158e-01f, -2.99489886e-01f, -3.31326984e-02f, -4.44863830e-03f, 2.57987380e-01f, -3.26753296e-02f,
  3.02038044e-01f, -8.67122561e-02f, -2.52058536e-01f, -5.75433001e-02f, 2.62210891e-02f, 2.69877434e-01f, -5.39431255e-03f, -5.22724018e-02f, 7.58888060e-03f, 2.09142670e-01f,
  1.99332595e-01f, -2.50962973e-01f, 2.85923302e-01f, 1.95308119e-01f, 3.80221978e-02f, 6.51997700e-02f, 2.97248885e-02f, -1.48753375e-02f, -1.27907023e-01f, 5.69693744e-03f,
  8.18519667e-03f, 4.46545556e-02f, 1.05321417e-02f, 7.48934448e-02f, -1.44338235e-01f, -7.07412735e-02f, 8.07528123e-02f, 6.03475943e-02f, -8.09107199e-02f, 2.60840207e-02f,
  9.68859022e-05f, -7.10517168e-02f, 3.63441445e-02f, -3.70873362e-02f, -4.25302312e-02f, 5.49976900e-03f, -4.33450285e-03f, -1.65154397e-01f, -7.64904171e-02f, 8.83235708e-02f,
  7.22809732e-02f, 5.87423472e-03f, 2.95432601e-02f, -2.64597852e-02f, 8.88879523e-02f, -1.57386418e-02f, -7.84294978e-02f, -3.63883227e-02f, -4.96708974e-02f, -1.96865741e-02f,
  -1.66418388e-01f, -4.02799062e-02f, -9.37911589e-03f, 9.99567565e-03f, 4.85354252e-02f, -2.16108896e-02f, -2.80741807e-02f, 2.46563964e-02f, -7.32194781e-02f, -7.79903084e-02f,
  9.24778264e-03f, -1.81263257e-02f, 7.94645026e-02f, 7.00930357e-02f, -6.32768199e-02f, -1.03602663e-01f, -7.43510574e-02f, -1.24319829e-02f, -2.47273855e-02f, -1.14551216e-01f,
  -1.29682228e-01f, 6.21496746e-03f, -1.31350744e-03f, -4.29409333e-02f, -1.24657899e-01f, -1.54972360e-01f, -1.25470906e-01f, -1.27325520e-01f, 2.59685218e-01f, -3.80354598e-02f,
  1.44273698e-01f, 1.93923622e-01f, 8.43500271e-02f, 2.33650859e-02f, -1.59306645e-01f, 1.73321709e-01f, 5.18624522e-02f, 2.62800362e-02f, 5.15291095e-02f, 7.18985498e-03f,
  1.25391781e-01f, -7.87823349e-02f, 1.67275533e-01f, 1.95472255e-01f, 2.11679757e-01f, 2.76903123e-01f, 1.01710565e-01f, -9.53044072e-02f, 3.24455440e-01f, -1.38701126e-01f,
  1.33402810e-01f, 1.81716472e-01f, 6.24515235e-01f, -1.26213282e-01f, -1.81079984e-01f, -2.43079796e-01f, -3.23983282e-01f, -2.81056575e-02f, 2.39817545e-01f, 5.22089936e-02f,
  -8.78227130e-02f, -2.46276662e-01f, 6.92943484e-02f, -1.30780175e-01f, -8.52288529e-02f, 2.82850325e-01f, 1.50202468e-01f, 2.61457860e-01f, -5.19516654e-02f, 2.51130909e-01f,
  -2.25657567e-01f, -3.20149630e-01f, 1.27222449e-01f, 9.14780125e-02f, -5.32922968e-02f, 3.30088586e-01f, -2.86951542e-01f, 2.17072561e-01f, 2.58240223e-01f, 1.93674996e-01f,
  -1.30747389e-02f, -4.51982543e-02f, 3.15396637e-01f, 2.90340520e-02f, 1.13827117e-01f, 9.18007642e-02f, -1.38441660e-02f, -1.35074332e-01f, 2.10583627e-01f, 7.61214420e-02f,
  -1.98015019e-01f, 5.74240014e-02f, 2.39432067e-01f, 1.54288962e-01f, 1.81226343e-01f, 4.23187464e-01f, -6.46659583e-02f, 1.64625943e-01f, 1.31903738e-01f, 3.93104441e-02f,
  2.41824105e-01f, 7.11810961e-02f, 2.01480955e-01f, 2.32833147e-01f, -1.21448282e-03f, -1.66826829e-01f, -1.87391974e-02f, 1.43670827e-01f, -2.43721604e-02f, 2.33314142e-01f,
  3.15489769e-01f, 4.99938764e-02f, 3.13239485e-01f, 1.21748090e-01f, 1.77049771e-01f, 5.25778346e-02f, 1.29815921e-01f, 9.08604190e-02f, -1.25707582e-01f, -1.51910692e-01f,
  -2.32239794e-02f, 2.22502008e-01f, -1.57829627e-01f, 1.02922983e-01f, -2.22366042e-02f, -1.76303208e-01f, -7.36650601e-02f, 8.68711844e-02f, 6.87041134e-02f, 6.43277690e-02f,
  1.16993159e-01f, -2.97894627e-02f, -2.83735037e-01f, 1.09705828e-01f, -1.27669856e-01f, 2.08385773e-02f, 2.79717982e-01f, -2.42440999e-01f, 1.75744668e-01f, 2.93222100e-01f,
  -2.08810106e-01f, -9.30365641e-03f, 1.99647442e-01f, 3.76281917e-01f, 4.06461507e-02f, -1.03938065e-01f, -5.40064275e-02f, 8.00096095e-02f, 1.71452731e-01f, 4.54871841e-02f,
  -1.52629331e-01f, -3.97441164e-02f, -3.39975543e-02f, 1.19508617e-01f, -9.55545083e-02f, 2.55677372e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.19225197e-02f, -9.85493511e-02f, 1.78282425e-01f, -1.05106004e-01f, -1.88159570e-03f, -2.36100554e-02f, 1.97914634e-02f, 8.82973447e-02f, -8.06317478e-03f, 1.81425467e-01f,
  1.13211066e-01f, -6.09721057e-02f, 3.92735889e-03f, 2.79189087e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.58718750e-01f, -3.12335398e-02f, -1.76748917e-01f, -1.11608811e-01f, 1.28036126e-01f, 5.12961820e-02f, -2.44318172e-02f, -1.47660477e-02f, 1.63056985e-01f, 1.19546257e-01f,
  -2.87306160e-02f, -5.92246167e-02f, -1.31322205e-01f, -6.29282370e-02f, 9.56568122e-02f, 3.82472239e-02f, -4.10805680e-02f, 3.24413180e-02f, -1.77051067e-01f, -1.87205851e-01f,
  9.44270790e-02f, 1.42369419e-01f, -2.97871888e-01f, -1.13708168e-01f, -3.27600449e-01f, -2.67885141e-02f, -1.79910824e-01f, 5.05222939e-02f, 3.85233723e-02f, -1.07464664e-01f,
  -1.62538793e-02f, -2.93852650e-02f, -1.94255441e-01f, -2.23149359e-02f, -3.86501178e-02f, -1.16117544e-01f, -2.37705484e-01f, 7.34040793e-03f, -9.05394778e-02f, 2.44383544e-01f,
  9.66293514e-02f, -3.87876689e-01f, 2.25277111e-01f, 7.00269490e-02f, -1.09419249e-01f, -2.35546771e-02f, 2.75541991e-01f, 1.31822065e-01f, 3.26608866e-01f, 1.10801905e-01f,
  1.24362737e-01f, 1.11358978e-01f, -4.32830863e-02f, 1.87081307e-01f, -1.69823065e-01f, 1.38448581e-01f, -3.94286923e-02f, -1.43067077e-01f, 2.00211361e-01f, 4.02484043e-03f,
  -6.84875622e-02f, 1.34936431e-02f, -9.58058685e-02f, -1.72927365e-01f, 2.30487555e-01f, -4.22736667e-02f, -5.87205961e-02f, 4.18995600e-03f, -1.42958403e-01f, 2.65667196e-02f,
  -1.16119392e-01f, 1.75239205e-01f, 1.14703901e-01f, 6.27667308e-02f, 1.73254572e-02f, 1.29853492e-03f, 5.82282781e-04f, 1.07581243e-02f, 1.67991722e-03f, -8.21137875e-02f,
  -1.93351358e-01f, 2.35922381e-01f, 1.88015401e-01f, 9.25150439e-02f, -1.29029453e-01f, -7.92096928e-02f, 2.75497395e-03f, -1.96117327e-01f, 2.84739852e-01f, -2.31559444e-02f,
  -2.92315334e-01f, 2.00751871e-01f, 2.48108432e-01f, 1.80994853e-01f, 2.19191574e-02f, -1.05231941e-01f, 8.70220810e-02f, -1.48390681e-01f, 2.77440865e-02f, -1.70196265e-01f,
  7.02577978e-02f, 2.97818929e-01f, 1.22485861e-01f, 1.06502198e-01f, 8.99334718e-03f, 1.25913978e-01f, -1.94381937e-01f, -8.54729414e-02f, 1.69508711e-01f, -1.91224754e-01f,
  -3.50271136e-01f, -1.67020485e-01f, -2.86927998e-01f, 3.35989930e-02f, 7.37047195e-02f, -5.50156645e-02f, -1.39069289e-01f, -3.86974029e-02f, -1.99031189e-01f, 4.72176075e-02f,
  1.23211734e-01f, 2.82000035e-01f, 4.39724587e-02f, 1.66363984e-01f, 5.97416349e-02f, -1.03120785e-02f, 1.62063941e-01f, 4.25603874e-02f, 2.54570723e-01f, 8.62272680e-02f,
  -1.65797934e-01f, -1.71500757e-01f, 1.65354714e-01f, 2.44485453e-01f, 2.29036659e-01f, -1.29391029e-01f, -2.19271377e-01f, 2.62597855e-02f, 1.73754303e-03f, -1.61893383e-01f,
  -7.44452029e-02f, 2.84000248e-01f, 2.48298377e-01f, -9.48218554e-02f, 1.51200354e-01f, 1.12895988e-01f, 1.59986556e-01f, 8.73245001e-02f, 2.43864860e-02f, 2.58237094e-01f,
  2.45614782e-01f, 1.59057602e-01f, 4.00364585e-03f, 2.02664733e-01f, -2.72186399e-01f, 6.26010448e-03f, 1.10207394e-01f, -5.86594641e-02f, -1.29137754e-01f, 2.21578136e-01f,
  6.29224777e-02f, -2.90754437e-01f, 9.92001668e-02f, -1.95057437e-01f, 4.32927832e-02f, 1.30205810e-01f, 6.56721219e-02f, 8.48701820e-02f, -4.13812876e-01f, 1.34005368e-01f,
  -7.98263773e-02f, 2.54527241e-01f, -6.64230883e-02f, 1.98037103e-01f, 1.42502934e-01f, -1.68629587e-02f, -5.82304783e-02f, 1.13809586e-01f, 1.52878255e-01f, -4.41831760e-02f,
  2.67731529e-02f, -3.32457453e-01f, 1.63161561e-01f, -2.09086254e-01f, 1.58634987e-02f, 1.58787385e-01f, 2.92601377e-01f, 1.86477929e-01f, 2.16928441e-02f, 2.23618522e-02f,
  -1.65889636e-01f, 3.49399298e-02f, 2.17084303e-01f, 1.98760927e-01f, -1.34945199e-01f, 3.43119442e-01f, -2.31517285e-01f, 1.03445187e-01f, 5.97460791e-02f, 3.72954905e-01f,
  -3.80426437e-01f, 5.09641096e-02f, 2.36737549e-01f, -7.52896965e-02f, -1.83918044e-01f, -2.55331159e-01f, 4.42919619e-02f, -9.17738080e-02f, 9.81212407e-02f, -1.47491455e-01f,
  6.32073060e-02f, -9.02819559e-02f, -2.23001614e-02f, 1.97572075e-02f, 9.48109776e-02f, -9.46797356e-02f, 6.10380545e-02f, 8.56320001e-03f, 6.25561699e-02f, 2.05868855e-01f,
  -2.30645314e-01f, -4.99853462e-01f, 2.61281371e-01f, 2.10055068e-01f, 3.05459485e-03f, 1.39677212e-01f, 1.51430249e-01f, -1.32188424e-01f, -3.06074712e-02f, -1.26813948e-01f,
  6.80454746e-02f, -2.84450520e-02f, -8.65308568e-02f, -2.42053811e-02f, 2.85706997e-01f, 1.70982704e-01f, -2.56818719e-02f, 1.25476435e-01f, 2.45839208e-01f, 2.03016981e-01f,
  -1.43548787e-01f, -3.15153897e-01f, 7.89312124e-02f, 3.10755521e-01f, 1.07663132e-01f, 1.03192821e-01f, -8.98904353e-02f, 1.20148674e-01f, -1.92850888e-01f, 4.70937900e-02f,
  -3.98689657e-02f, -1.07094795e-01f, -1.32748440e-01f, 3.71910557e-02f, -1.86703309e-01f, 7.82556534e-02f, -3.80383134e-02f, 6.50174469e-02f, 1.17646851e-01f, -1.43555596e-01f,
  2.67131031e-01f, -4.01904285e-02f, 3.30187440e-01f, -1.40566081e-01f, 1.17532834e-01f, 5.59040084e-02f, 7.95050189e-02f, -1.36994794e-01f, 1.34315193e-02f, 3.38333752e-03f,
  1.67434037e-01f, -2.67968178e-01f, -1.08665081e-04f, 4.86803837e-02f, 8.46070126e-02f, 2.92982832e-02f, -1.30481854e-01f, -9.55279451e-03f, -1.91321582e-01f, 1.78556442e-01f,
  -1.45372003e-01f, 7.51640275e-02f, -7.85409510e-02f, -3.40158850e-01f, 2.13708967e-01f, -1.64038911e-02f, 2.86829531e-01f, -5.36899269e-02f, 3.89810726e-02f, 4.96648587e-02f,
  -2.00390995e-01f, 2.36215681e-01f, -3.24517250e-01f, -7.71785602e-02f, -2.03571081e-01f, -1.74020037e-01f, -2.83069313e-01f, -2.04359710e-01f, 3.18341739e-02f, -6.41928911e-02f,
  1.11057319e-01f, -7.96200931e-02f, -2.29459256e-01f, -3.80153693e-02f, 2.76155412e-01f, -7.00505972e-02f, -1.35603175e-01f, 1.63135584e-02f, 2.64325678e-01f, 4.03681844e-02f,
  -9.51052681e-02f, 1.50812671e-01f, 1.10682636e-01f, -9.11545381e-02f, -1.80950776e-01f, 2.04963293e-02f, -9.55999945e-04f, 8.32072869e-02f, 1.58433199e-01f, 2.03000441e-01f,
  -3.59037936e-01f, -1.27355605e-02f, -9.06181335e-02f, 6.62826002e-02f, 3.31868827e-01f, 1.12174645e-01f, 1.68307081e-01f, -2.55802330e-02f, 6.78280890e-02f, -5.72193414e-03f,
  -1.57428786e-01f, 1.09419607e-01f, -3.51221114e-02f, -1.75822601e-01f, -8.22756365e-02f, -7.92391077e-02f, -7.87158534e-02f, 1.36713088e-01f, -8.57914910e-02f, 4.97596599e-02f,
  -1.09735653e-01f, -5.61090112e-02f, -2.72354215e-01f, 1.11618519e-01f, -6.96058795e-02f, 2.67105371e-01f, -8.71446207e-02f, -2.25720719e-01f, 2.52453476e-01f, 9.73662082e-03f,
  -5.02291135e-02f, -3.39178830e-01f, -1.57696471e-01f, 1.68490127e-01f, -2.15279013e-01f, -1.15138493e-01f, -2.49370232e-01f, 4.99258703e-03f, -2.79687345e-02f, 2.12948143e-01f,
  -8.90372619e-02f, -5.15293121e-01f, 1.36340067e-01f, -1.20786585e-01f, -1.65330112e-01f, -1.91885889e-01f, 6.33963421e-02f, -2.19587132e-01f, 2.71309525e-01f, -4.77695875e-02f,
  1.11802109e-01f, -2.49358118e-02f, -6.13706112e-02f, 2.47501597e-01f, -6.03467971e-02f, 2.91838884e-01f, -8.05022642e-02f, -2.49359667e-01f, -1.35375172e-01f, 5.97782470e-02f,
  3.53694558e-02f, -5.98372482e-02f, -9.59343687e-02f, -4.07390445e-02f, -8.39291140e-03f, -3.25129330e-02f, -1.69006497e-01f, -3.31288725e-02f, -1.47107691e-01f, -1.41179740e-01f,
  3.42019498e-01f, 3.53967138e-02f, -1.52879119e-01f, 1.39603078e-01f, 9.51418057e-02f, -2.77813703e-01f, -2.81862766e-01f, -1.71037287e-01f, 1.55946523e-01f, 1.08401462e-01f,
  1.69126824e-01f, -6.42608032e-02f, -1.03839152e-01f, 2.00937744e-02f, 1.28673941e-01f, 4.53943424e-02f, -1.79231405e-01f, 1.41410589e-01f, -1.57416850e-01f, 2.24545803e-02f,
  -1.50297999e-01f, -8.59140977e-02f, 5.78156486e-02f, -8.14480036e-02f, -7.73150325e-02f, 1.80728346e-01f, 5.67834973e-02f, -1.08225860e-01f, 8.23151469e-02f, 7.33302385e-02f,
  -1.27584875e-01f, -6.62392974e-02f, 1.63695782e-01f, 3.69413137e-01f, -9.13724527e-02f, -1.00190781e-01f, 1.00962609e-01f, 6.70140982e-02f, -1.34476453e-01f, -1.52576998e-01f,
  2.32426003e-01f, 6.77994220e-03f, 2.17219025e-01f, -1.40180752e-01f, -1.84904374e-02f, 8.13905001e-02f, 8.59219953e-02f, -1.50372863e-01f, -1.06080763e-01f, 2.10738137e-01f,
  -1.09827720e-01f, -2.45516852e-01f, 1.14642777e-01f, 7.50405202e-03f, 1.61536157e-01f, 8.00201744e-02f, -2.16404632e-01f, 7.58277923e-02f, -1.56082362e-01f, 1.12965122e-01f,
  -1.24523714e-01f, 6.94283620e-02f, 1.26677960e-01f, 4.47938927e-02f, -9.31892544e-02f, -1.37248278e-01f, -4.36642766e-02f, -1.61982074e-01f, 1.43482193e-01f, 1.89707756e-01f,
  -1.66633412e-01f, -3.01658154e-01f, -4.21966948e-02f, -1.94709271e-01f, -1.87007934e-02f, -9.58625451e-02f, 4.21288386e-02f, -9.88432541e-02f, 1.79329202e-01f, 1.96177959e-01f,
  9.00825560e-02f, 1.20923191e-01f, -3.67749147e-02f, 1.60066634e-02f, 1.64054915e-01f, -1.22440666e-01f, 4.48303297e-02f, -7.53647462e-02f, 2.79588640e-01f, -5.51115163e-02f,
  1.60315752e-01f, 1.45712018e-01f, -1.63272440e-01f, 6.53790459e-02f, 5.03243133e-02f, -4.88864556e-02f, -1.04215324e-01f, -4.17191356e-01f, -2.11833745e-01f, 1.40667334e-01f,
  -1.32371902e-01f, -8.22721869e-02f, 2.34531000e-01f, 9.73692909e-02f, 1.64028615e-01f, 6.26860093e-03f, -1.25577569e-01f, -1.24188460e-01f, -1.77983493e-01f, -1.79102749e-01f,
  1.71021193e-01f, -1.76863715e-01f, 2.13602856e-01f, 8.29723943e-03f, -2.72276923e-02f, 3.33366008e-03f, -1.31657422e-01f, -1.00353964e-01f, -1.75523400e-01f, 2.28500888e-02f,
  -2.83405855e-02f, 1.86465159e-01f, 2.41665989e-01f, 1.15750864e-01f, 1.37786090e-01f, -1.04273595e-01f, 2.35971093e-01f, 5.22994623e-02f, 3.12798917e-02f, 1.22695856e-01f,
  1.25688404e-01f, -1.62400112e-01f, 1.40396714e-01f, 1.01827979e-01f, 1.45466000e-01f, -2.25493088e-02f, -1.92383721e-01f, -3.51370536e-02f, 5.19211739e-02f, 5.57907065e-03f,
  -2.06119474e-02f, 3.92736383e-02f, 1.21975556e-01f, -1.13485977e-01f, 9.66198891e-02f, -4.91571687e-02f, 1.41027242e-01f, 2.52385736e-01f, 1.22260682e-01f, -1.43762842e-01f,
  2.34645009e-01f, 6.17031567e-02f, 2.09129276e-03f, -2.78805315e-01f, 9.95793715e-02f, 9.14317816e-02f, 4.08630371e-02f, 1.89362302e-01f, 1.43112302e-01f, 2.16326397e-03f,
  1.24746971e-01f, -2.17933804e-02f, 1.62945867e-01f, -3.84606458e-02f, 1.40690267e-01f, -1.11963777e-02f, -6.20179884e-02f, 4.80735675e-02f, -1.36019513e-01f, -1.23967603e-02f,
  2.23184675e-01f, -1.01428730e-02f, 6.56288415e-02f, 6.37161732e-02f, -1.62371531e-01f, 3.95798534e-02f, 2.72191584e-01f, 2.84642372e-02f, -1.94309205e-02f, -1.76980391e-01f,
  -1.11048080e-01f, -1.21891238e-01f, -1.45784378e-01f, -6.02681860e-02f, 2.01089919e-01f, 4.49670060e-03f, 1.55401409e-01f, 1.61560297e-01f, -2.20882505e-01f, -2.60259449e-01f,
  -2.05581143e-01f, -6.41815364e-02f, -1.95964336e-01f, -4.12160493e-02f, -3.37633826e-02f, -3.75468463e-01f, 2.56387405e-02f, 3.50551642e-02f, -9.47439149e-02f, -2.63572168e-02f,
  -2.26473257e-01f, 9.52419266e-02f, -2.46440500e-01f, -2.19363645e-01f, -2.47129217e-01f, -2.14424774e-01f, 2.10117504e-01f, 6.32992312e-02f, -2.02689499e-01f, -1.43759370e-01f,
  1.02997474e-01f, -5.65495118e-02f, -2.17990987e-02f, 2.99690694e-01f, 1.06640846e-01f, 1.10413820e-01f, -9.70518589e-02f, -2.28569377e-02f, -1.63646370e-01f, -5.82724884e-02f,
  2.17922211e-01f, -1.23826355e-01f, 1.62873566e-01f, 9.41653177e-02f, 9.50056985e-02f, 3.33781354e-02f, 3.07439029e-01f, -2.66828146e-02f, -1.91932563e-02f, 2.05036595e-01f,
  -2.12605614e-02f, 8.50479007e-02f, 1.17381357e-01f, 2.59009480e-01f, 1.58378780e-01f, 3.89362544e-01f, 8.29080641e-02f, 1.99573889e-01f, -4.52847071e-02f, 1.72094539e-01f,
  2.18057409e-01f, 6.26194011e-03f, -3.73900644e-02f, -9.38422307e-02f, 9.39556584e-03f, -1.39071167e-01f, -1.25907715e-02f, -1.02760084e-01f, -1.50192925e-03f, -1.17536247e-01f,
  -1.18237566e-02f, 2.25620404e-01f, -4.65073995e-02f, 5.48605174e-02f, -1.59501657e-01f, 2.23301649e-01f, 1.35331815e-02f, 1.46220952e-01f, 8.22537616e-02f, -4.12850827e-02f,
  5.64478897e-02f, 3.03474441e-02f, 1.93221599e-01f, 3.17791328e-02f, 1.52690619e-01f, -1.13626579e-02f, -1.77025050e-02f, -1.05280899e-01f, -1.53142065e-01f, -1.71367861e-02f,
  3.20417404e-01f, -1.84332594e-01f, 1.72215208e-01f, -3.73291969e-02f, -7.52210543e-02f, -3.24259549e-02f, 1.22261040e-01f, -1.45222470e-01f, -4.00397591e-02f, -1.81577444e-01f,
  1.92938372e-01f, 9.24381986e-02f, -1.39221966e-01f, 1.39114350e-01f, 1.01491556e-01f, 6.79456592e-02f, -1.94842517e-01f, -2.76900440e-01f, -2.83173859e-01f, -2.84316130e-02f,
  1.07118353e-01f, -2.29244307e-01f, 2.21977711e-01f, 2.55585104e-01f, -8.45482796e-02f, 1.65450260e-01f, 1.26334950e-01f, 3.13461006e-01f, 1.98867545e-01f, 4.90933657e-02f,
  -1.21910118e-01f, 5.80457002e-02f, 2.67227978e-01f, 1.12469859e-01f, -4.55999337e-02f, 6.24546483e-02f, -9.60142836e-02f, -6.82896078e-02f, 5.37060834e-02f, -1.64471507e-01f,
  -1.50491253e-01f, 1.02820275e-02f, -7.24781454e-02f, -1.24119982e-01f, -2.73678005e-01f, 1.62807014e-02f, 7.37964585e-02f, 1.09514624e-01f, -9.73737389e-02f, -8.01686347e-02f,
  -1.47207513e-01f, -4.85365884e-03f, -3.45236585e-02f, -9.98848528e-02f, 5.90713620e-02f, -1.12605199e-01f, 2.68945247e-02f, 1.14842966e-01f, 7.62855709e-02f, 2.43818507e-01f,
  -1.92555964e-01f, -4.68131751e-02f, -5.34248725e-02f, 8.94247890e-02f, 1.97196558e-01f, -2.52088979e-02f, -3.49804126e-02f, -9.74194407e-02f, -1.52776733e-01f, -1.66164368e-01f,
  6.47246540e-02f, 2.62223810e-01f, -1.98855743e-01f, -7.20689297e-02f, 9.88295376e-02f, 2.79222697e-01f, -2.52363235e-01f, -1.93850398e-01f, 1.61855206e-01f, 1.40823841e-01f,
  -1.90871712e-02f, 8.14670324e-02f, 1.25603765e-01f, 1.02491088e-01f, 3.58753860e-01f, 8.10045451e-02f, 1.05726598e-02f, 3.08161806e-02f, 1.29595734e-02f, -1.23357743e-01f,
  3.61461163e-01f, 3.11055519e-02f, -3.22488815e-01f, 4.03771214e-02f, 1.47871926e-01f, -1.15471721e-01f, 8.08529258e-02f, -1.65330363e-03f, -2.99713276e-02f, -3.35482061e-02f,
  5.32333665e-02f, 2.49403328e-01f, 6.67411685e-02f, 4.18545026e-03f, 1.54493943e-01f, -1.63847327e-01f, -1.77002862e-01f, -1.43735737e-01f, 1.74093887e-01f, 8.00730288e-02f,
  -1.17598727e-01f, -7.09271207e-02f, -1.25208780e-01f, -6.15795068e-02f, -2.41473272e-01f, -8.56783018e-02f, -3.16573419e-02f, -7.03899488e-02f, -3.60350460e-02f, -1.24334849e-01f,
  2.41992682e-01f, 4.94756177e-03f, 9.47506353e-02f, -3.37231867e-02f, -4.47345525e-02f, -2.28220057e-02f, -1.96048737e-01f, -1.29776597e-01f, -5.36007360e-02f, 1.00505829e-01f,
  -2.18934551e-01f, -1.12452291e-01f, -7.67779723e-02f, -1.86147429e-02f, -3.20531011e-01f, 1.39997452e-01f, 1.99026570e-01f, 7.86163211e-02f, -3.96204829e-01f, -1.98074594e-01f,
  -2.17392430e-01f, 4.84602991e-03f, 2.33709887e-01f, -1.16088495e-01f, 6.53318912e-02f, 2.01416418e-01f, 3.88032645e-01f, 4.08650935e-01f, 2.53294230e-01f, 6.51243106e-02f,
  -1.20748393e-01f, 1.17311336e-01f, 4.73397821e-02f, -1.10205047e-01f, -2.23687828e-01f, 1.07902907e-01f, 6.56403899e-02f, 2.57166713e-01f, 1.72053382e-01f, -5.28099164e-02f,
  2.36115046e-02f, 9.07082018e-03f, 2.03023925e-01f, -7.74985850e-02f, 3.73470113e-02f, -2.28262335e-01f, 1.26284018e-01f, 1.32677197e-01f, 3.66848409e-02f, 5.20159937e-02f,
  -1.21714294e-01f, -2.26033136e-01f, -9.46761593e-02f, 1.43288061e-01f, -4.63941395e-02f, -3.31747606e-02f, -5.46140336e-02f, -1.40079662e-01f, -9.94489044e-02f, -1.22833803e-01f,
  -2.80799150e-01f, 1.38951838e-01f, 1.69214588e-02f, 1.59713700e-01f, -8.05759653e-02f, 4.16328534e-02f, -1.02153651e-01f, 1.03770815e-01f, -1.70093656e-01f, 4.70092669e-02f,
  2.97785848e-02f, -3.14239301e-02f, -7.96956196e-02f, 2.85156190e-01f, -8.72624740e-02f, 9.73759666e-02f, -1.30952656e-01f, -2.27413490e-01f, -1.81104451e-01f, 2.12290823e-01f,
  -2.47226320e-02f, -3.64982821e-02f, 6.36115670e-02f, -3.50038409e-02f, -2.57293135e-01f, 1.49972394e-01f, 1.23053476e-01f, -1.17865928e-01f, -1.91397309e-01f, 1.59386069e-01f,
  -5.53935487e-03f, 6.14669314e-03f, -1.31431803e-01f, 1.67716295e-01f, 1.10184126e-01f, 2.24632218e-01f, 1.57322466e-01f, 8.95028636e-02f, -5.69285871e-03f, 7.70310685e-02f,
  -2.34954178e-01f, 2.71471709e-01f, -1.06885622e-03f, -6.25931770e-02f, 1.72252610e-01f, 1.62202772e-02f, 1.80307329e-02f, -1.83572933e-01f, 1.05268829e-01f, 1.79413721e-01f,
  6.99105263e-02f, 2.66919490e-02f, -5.35777472e-02f, -2.98727211e-03f, -1.06473804e-01f, 5.99906817e-02f, 1.17650060e-02f, -2.79300034e-01f, 5.08169457e-03f, 4.01223563e-02f,
  -1.17173351e-01f, -6.60900325e-02f, 2.02314079e-01f, 1.10039666e-01f, -5.82745112e-02f, 1.68889970e-01f, -2.54604936e-01f, -2.00785011e-01f, -2.69299954e-01f, 1.40376864e-02f,
  6.66051880e-02f, 1.99254796e-01f, 2.07448632e-01f, -6.55498505e-02f, -1.95070595e-01f, -1.11714311e-01f, -4.39176559e-02f, -9.39655527e-02f, -2.17789307e-01f, -9.74849313e-02f,
  4.80193943e-02f, 1.67828217e-01f, -1.36911929e-01f, 3.26899774e-02f, 1.17075525e-03f, 6.71425685e-02f, -1.66508228e-01f, 1.58126295e-01f, 5.57282977e-02f, -1.99485153e-01f,
  -3.12976516e-03f, -6.91445768e-02f, -7.48988837e-02f, -1.00618497e-01f, 1.81798831e-01f, 4.55456614e-01f, -2.79544760e-02f, -1.91812679e-01f, 1.18792601e-01f, -5.30096814e-02f,
  -1.91857666e-01f, -1.79571524e-01f, 9.57903415e-02f, 1.75739482e-01f, 7.38572106e-02f, 8.36785510e-03f, 8.83605927e-02f, 7.85084292e-02f, -2.30138749e-02f, -1.22596752e-02f,
  -1.07623078e-01f, 5.80238935e-04f, -1.64180860e-01f, -7.65442699e-02f, 9.75135937e-02f, 7.01555163e-02f, 2.29159296e-01f, -9.55886692e-02f, -1.01847984e-02f, -1.28313705e-01f,
  -1.70312166e-01f, -1.39379576e-01f, -1.02730282e-01f, -2.25402012e-01f, 2.42774785e-01f, 1.66724354e-01f, -2.17298239e-01f, -4.62550186e-02f, 3.56071927e-02f, -3.18569005e-01f,
  -2.31107071e-01f, -1.08625391e-03f, 2.28985175e-01f, 1.40302837e-01f, -9.83449146e-02f, -1.52639240e-01f, -1.38950348e-01f, 8.39888155e-02f, -1.04004145e-01f, -1.92149833e-01f,
  -2.64702253e-02f, -1.69577718e-01f, -2.15915382e-01f, 9.91220996e-02f, 3.30894440e-02f, 3.67522873e-02f, -1.26597863e-02f, -6.63562268e-02f, 8.93986672e-02f, 1.72169596e-01f,
  -7.85959587e-02f, -3.27230781e-01f, 8.62730965e-02f, 1.70360073e-01f, -2.34652668e-01f, -8.75498634e-03f, 9.10270661e-02f, -1.17466137e-01f, -3.63139175e-02f, -4.61220369e-02f,
  9.64405313e-02f, -8.64176825e-02f, -1.92873523e-01f, -3.85731459e-02f, 1.83366071e-02f, 9.48576257e-02f, -1.41082093e-01f, -1.13764949e-01f, 1.91926524e-01f, 2.30357781e-01f,
  -7.27760643e-02f, 2.49316311e-03f, -1.06812097e-01f, 1.83019698e-01f, 2.94374406e-01f, -3.78856808e-02f, -6.24394342e-02f, -4.02155370e-02f, -1.81793384e-02f, -4.97153737e-02f,
  -1.16641417e-01f, 3.32109630e-02f, 1.57864575e-04f, -9.08947662e-02f, 4.82105985e-02f, -2.72272587e-01f, 5.76741435e-02f, -5.54853156e-02f, -2.22658413e-03f, 1.42319174e-02f,
  7.21914619e-02f, 1.61398947e-01f, 9.14081410e-02f, 1.32082552e-01f, -7.38048106e-02f, 1.54219314e-01f, -1.95897430e-01f, -1.89953223e-01f, -1.69724047e-01f, 6.58202991e-02f,
  1.54270530e-02f, -5.61553286e-04f, 9.15947556e-03f, -1.01023383e-01f, -2.18329772e-01f, -2.39272073e-01f, 2.01765433e-01f, -1.34329170e-01f, 6.84415698e-02f, 1.61402866e-01f,
  -6.61433712e-02f, -1.15138702e-01f, 8.94030705e-02f, 5.82222939e-02f, -1.90722868e-01f, 2.77768850e-01f, 1.78836793e-01f, -4.78129983e-02f, 1.07573569e-01f, -2.74508214e-03f,
  2.68084049e-01f, -2.57986877e-03f, 1.91005230e-01f, 2.52633005e-01f, 7.03215785e-03f, -1.40252054e-01f, -2.19226144e-02f, -1.00018119e-03f, -2.87089407e-01f, 1.77382097e-01f,
  -1.42289132e-01f, 2.06071399e-02f, 1.01236487e-03f, 1.99605189e-02f, 1.11880302e-01f, 7.64151886e-02f, -2.72645921e-01f, -4.27706353e-02f, -1.69698428e-02f, 2.02910066e-01f,
  -4.45058346e-02f, -1.32361576e-01f, -1.95790097e-01f, -2.01160342e-01f, 1.17480688e-01f, -6.25430197e-02f, 1.59032837e-01f, 3.58096398e-02f, 1.11699007e-01f, 8.28905329e-02f,
  -1.16322950e-01f, -6.47181347e-02f, -6.47109300e-02f, -1.49936974e-01f, 4.75468077e-02f, -9.10600945e-02f, -1.60673577e-02f, -3.28376032e-02f, -1.08867034e-01f, 9.85309035e-02f,
  1.67906165e-01f, 6.22022413e-02f, 1.07283033e-01f, -3.22487891e-01f, -8.43357891e-02f, -5.06254984e-03f, 2.19008271e-02f, -1.42794684e-01f, 3.83938514e-02f, 2.77928829e-01f,
  -2.88483679e-01f, 7.11834133e-02f, -2.66083777e-01f, -2.86695480e-01f, -2.80061185e-01f, -2.43896484e-01f, -3.93281803e-02f, -1.60878539e-01f, 2.97203541e-01f, -3.21400225e-01f,
  2.06382737e-01f, 3.18435915e-02f, -4.82211076e-02f, -1.66827124e-02f, -2.62605906e-01f, -4.20159101e-02f, -1.72072798e-01f, -2.09544927e-01f, -2.63567388e-01f, 3.03397290e-02f,
  -7.68529251e-02f, -9.65258554e-02f, 1.74526870e-01f, -1.52869388e-01f, -1.03725128e-01f, 8.57200623e-02f, 1.53280005e-01f, 7.46513754e-02f, -7.67955929e-02f, 2.63481766e-01f,
  1.26717806e-01f, 1.42811373e-01f, -1.60395920e-01f, -1.00183398e-01f, -1.29440567e-02f, 7.24107847e-02f, 3.95283177e-02f, -8.11146647e-02f, -2.19895929e-01f, -9.84878093e-02f,
  1.22030631e-01f, 1.91949293e-01f, 1.72043189e-01f, 2.60657459e-01f, 1.23134315e-01f, 7.41619617e-02f, -1.20149337e-01f, -3.30148846e-01f, -4.72833104e-02f, -5.41229844e-02f,
  -4.59026247e-02f, 5.14022112e-02f, 1.78052485e-01f, -5.51065356e-02f, -3.78865339e-02f, 1.16080888e-01f, 2.91541349e-02f, 2.07058817e-01f, -8.54127109e-02f, 6.35848194e-02f,
  -1.19627779e-02f, 2.15879202e-01f, 3.65269363e-01f, 3.85188401e-01f, -4.81653437e-02f, 1.32924303e-01f, -7.02170879e-02f, -1.52272522e-01f, 1.79734871e-01f, -6.16912544e-03f,
  -5.76604456e-02f, 1.44054256e-02f, 3.63206565e-02f, 1.44181550e-01f, -2.28517249e-01f, 1.14937574e-01f, -1.21198505e-01f, 1.33110315e-01f, -1.39791323e-02f, 5.68279587e-02f,
  -1.40920002e-02f, -2.00114593e-01f, -2.96120942e-02f, 2.66322821e-01f, -1.88730389e-01f, 7.37288147e-02f, 5.04945256e-02f, 4.71527986e-02f, 1.39553264e-01f, -1.93850845e-02f,
  -1.81241736e-01f, 4.81327586e-02f, -9.09613743e-02f, -1.56707168e-02f, 1.44373970e-02f, 1.99631639e-02f, -4.92445230e-02f, -2.14066595e-01f, 2.37135459e-02f, 7.18646795e-02f,
  8.96423161e-02f, 1.04011357e-01f, -1.10455319e-01f, 2.80861568e-04f, -7.27060065e-02f, -1.35383159e-01f, -1.79463983e-01f, -2.24727169e-01f, -1.28192395e-01f, -1.30429149e-01f,
  -3.17970425e-01f, -1.12092555e-01f, 1.15308963e-01f, -1.06935523e-01f, -5.65078631e-02f, -1.78271502e-01f, -5.23467595e-03f, -1.27354667e-01f, 1.58242851e-01f, 5.50418487e-03f,
  2.37776712e-01f, -2.06361651e-01f, -3.35265696e-02f, -1.49083808e-01f, 1.09933481e-01f, -1.14662893e-01f, -3.11197042e-01f, -3.04368705e-01f, -2.39131778e-01f, -8.72512236e-02f,
  -2.76544280e-02f, -2.01147720e-01f, -3.29319574e-02f, -1.92576069e-02f, 7.54290000e-02f, -9.08213332e-02f, 3.61093767e-02f, 2.06539221e-02f, 1.29927188e-01f, -1.74168989e-01f,
  -1.61248967e-01f, 3.02195083e-02f, -1.60554066e-01f, 1.81245700e-01f, 1.93732202e-01f, 1.13247000e-01f, 5.38074486e-02f, -3.28468345e-02f, 5.45449331e-02f, -2.23422080e-01f,
  3.06691322e-03f, -7.65796900e-02f, -1.88183784e-01f, -1.19852565e-01f, 1.26966536e-01f, -6.80226907e-02f, 3.73613946e-02f, -2.37325102e-01f, 2.73340911e-01f, -2.98175644e-02f,
  -1.60693392e-01f, 1.15504116e-01f, 1.30881220e-01f, -8.08522627e-02f, -2.02306598e-01f, -9.29502398e-02f, 1.18179902e-01f, -1.26571074e-01f, 7.68819451e-02f, 1.27114177e-01f,
  5.16820438e-02f, -3.55070502e-01f, -1.05720088e-01f, -2.53958315e-01f, -8.30050372e-03f, -6.24712780e-02f, 1.02355458e-01f, -3.85967016e-01f, 2.03101262e-01f, 1.10658862e-01f,
  -8.52631032e-02f, -1.58162028e-01f, 1.78563923e-01f, 2.37595215e-01f, 5.14079398e-03f, -1.70550629e-01f, 2.09028035e-01f, -4.12998646e-02f, 2.98518166e-02f, 3.61747830e-03f,
  -4.32691090e-02f, 1.90968797e-01f, -1.09044358e-01f, -1.64623559e-02f, -7.88457505e-03f, -7.44038075e-02f, 2.39757225e-01f, -3.40617359e-01f, 2.15626284e-01f, 2.90685683e-01f,
  -1.05831204e-02f, 1.18471853e-01f, 1.63300335e-01f, -2.47079924e-01f, -2.04614580e-01f, 2.03304157e-01f, 1.63965300e-01f, -1.08897731e-01f, -7.31044337e-02f, -6.33430257e-02f,
  -1.25610843e-01f, 1.37159139e-01f, -2.97670931e-01f, -2.42512360e-01f, 3.50872159e-01f, -1.35778993e-01f, -4.32380587e-01f, -9.33477879e-02f, -6.34160265e-03f, 9.96772083e-04f,
  8.57230425e-02f, -5.34655899e-02f, 2.42294576e-02f, -9.23216045e-02f, 5.44695780e-02f, -1.65760130e-01f, 8.96859467e-02f, -1.53023908e-02f, 1.45312361e-02f, 9.97685790e-02f,
  -1.49366260e-01f, 6.51600733e-02f, 7.40132108e-02f, 1.25386983e-01f, 2.96673030e-01f, -2.16717012e-02f, 2.21902773e-01f, -1.68026626e-01f, 1.25775427e-01f, -4.89914268e-02f,
  3.18992376e-01f, 1.03074417e-01f, 1.42062441e-01f, 1.59972638e-01f, 6.98603131e-03f, -3.45505327e-02f, -2.02751279e-01f, -1.00924581e-01f, 8.21441188e-02f, 2.13605314e-01f,
  1.56146730e-03f, 1.17071070e-01f, 1.75247192e-01f, 1.06095307e-01f, 2.00858954e-02f, -1.18565395e-01f, 3.42694879e-01f, 1.07441515e-01f, 1.86788306e-01f, 1.23225421e-01f,
  1.79361790e-01f, -8.57450441e-02f, 1.44317016e-01f, 2.97852885e-02f, 6.06911778e-02f, 2.28948057e-01f, 6.62125945e-02f, -1.92107096e-01f, -1.30936384e-01f, 3.95797715e-02f,
  1.17305160e-01f, -5.34181260e-02f, -6.93380311e-02f, 4.80507128e-03f, -1.28371432e-01f, -5.89011842e-03f, -9.05880183e-02f, -2.35638112e-01f, -5.30790910e-02f, -6.77385107e-02f,
  -2.30671018e-02f, -1.70788780e-01f, -4.80592735e-02f, -1.91845074e-01f, 1.90173965e-02f, -1.81451604e-01f, -6.43513724e-02f, -1.52964681e-01f, 1.31186880e-02f, 8.56303796e-02f,
  2.87535526e-02f, 3.18734124e-02f, 1.02468386e-01f, -1.30417561e-02f, 2.15700582e-01f, 9.56418808e-04f, 2.16667727e-01f, 1.69429407e-01f, 4.92465086e-02f, 1.62733644e-01f,
  -1.24262020e-01f, 1.89357728e-01f, -1.47161022e-01f, -3.71516123e-03f, -1.28424257e-01f, 2.30915263e-01f, -7.15310797e-02f, -2.13237122e-01f, 1.13786750e-01f, -4.17631306e-02f,
  -1.23113953e-01f, 6.25307634e-02f, 8.11364502e-02f, -7.02552199e-02f, -1.30407959e-01f, 8.78460035e-02f, -9.36641321e-02f, 1.20660231e-01f, 2.70179003e-01f, 1.57507569e-01f,
  2.34440506e-01f, 9.23106149e-02f, -1.05261043e-01f, -1.22022651e-01f, 3.89261067e-01f, 1.01221986e-01f, -2.53713220e-01f, -6.07142365e-03f, 2.33193324e-03f, -1.12362504e-01f,
  -2.38497168e-01f, -6.82796761e-02f, -5.24770394e-02f, -3.40946130e-02f, -1.04127191e-01f, 6.57598376e-02f, -8.77717212e-02f, -2.41598174e-01f, -1.66177258e-01f, 1.04354851e-01f,
  -1.09177381e-02f, -5.25630936e-02f, 2.09209129e-01f, -9.33344960e-02f, -2.20797257e-03f, 1.71937749e-01f, -2.23760232e-01f, 8.37582629e-03f, -3.13951634e-02f, 3.96355018e-02f,
  1.09891400e-01f, -1.32429257e-01f, -1.07337646e-01f, -2.19767600e-01f, 1.33020684e-01f, 1.71754032e-01f, 1.10675558e-01f, -4.72847139e-03f, 1.76757127e-01f, -1.87878255e-02f,
  -8.80325660e-02f, -7.23608444e-03f, 1.05488654e-02f, 1.70047507e-02f, 2.38552436e-01f, 8.02438334e-02f, -9.21360925e-02f, 3.24684307e-02f, -8.27014372e-02f, 2.09530890e-01f,
  -2.78550357e-01f, -1.03117544e-02f, 2.95432538e-01f, 1.60735801e-01f, -6.29625702e-03f, -6.88662827e-02f, 3.65342526e-03f, -2.10837960e-01f, -1.05505139e-01f, 1.70946613e-01f,
  1.10376887e-01f, 6.75638616e-02f, -2.80040979e-01f, -4.53104191e-02f, 1.81922317e-01f, 9.75929275e-02f, 1.00338548e-01f, -9.73874480e-02f, 1.20844245e-01f, 2.49696761e-01f,
  -1.77003533e-01f, -3.00793480e-02f, -2.55258791e-02f, -8.80979747e-02f, -1.93021998e-01f, 1.34051532e-01f, -6.60289824e-02f, -2.49008372e-01f, 6.37276769e-02f, 1.83688402e-01f,
  2.10493654e-01f, -8.28061849e-02f, 1.57581761e-01f, 3.56859475e-01f, -5.65290414e-02f, -4.71266881e-02f, 2.28544757e-01f, 1.10984281e-01f, -3.30434263e-01f, -3.98412235e-02f,
  -2.16378689e-01f, 6.97960854e-02f, 5.70901074e-02f, -1.60829693e-01f, 8.68961215e-02f, -6.68156669e-02f, -8.91418830e-02f, -6.32236823e-02f, 2.39927396e-01f, 2.22897768e-01f,
  -8.05135593e-02f, 9.10691395e-02f, 1.01188622e-01f, 1.70691624e-01f, -1.15830444e-01f, -9.96655412e-03f, 8.15452731e-05f, 5.66843115e-02f, -2.00387150e-01f, -2.16585528e-02f,
  3.67831826e-01f, 1.27242297e-01f, -2.03079060e-01f, -1.36057235e-04f, 2.61366218e-01f, 1.17872119e-01f, -3.49720597e-01f, 5.52260131e-02f, 6.40479624e-02f, 1.41165614e-01f,
  -7.21444637e-02f, 2.86660064e-02f, -7.16763139e-02f, 2.91399509e-01f, -1.74497008e-01f, -8.48313048e-02f, 1.34555250e-01f, 1.54193521e-01f, 7.79749302e-04f, -2.48380657e-02f,
  -9.65875313e-02f, 1.58506945e-01f, 2.89749503e-02f, -2.34786272e-01f, 5.80271482e-02f, 3.29279333e-01f, 1.05837174e-01f, -3.50350142e-01f, -1.78910822e-01f, 2.13390570e-02f,
  -8.88131782e-02f, -2.74497569e-02f, -3.13473120e-02f, -1.42759040e-01f, -2.40516111e-01f, -1.09961726e-01f, -1.50313139e-01f, -6.11638278e-03f, 3.04309372e-02f, -1.15293108e-01f,
  1.04904331e-01f, -7.48622837e-03f, 1.20149285e-01f, 8.11908096e-02f, 1.32210195e-01f, 2.06725858e-02f, -1.11019760e-01f, 3.65276724e-01f, -1.46283790e-01f, 2.00839296e-01f,
  1.97048411e-02f, 4.31025364e-02f, -2.00118810e-01f, -3.78921479e-02f, 1.42659411e-01f, 6.44144863e-02f, -2.41873823e-02f, 2.71395091e-02f, -2.62974426e-02f, -2.21163094e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.31534803e-01f, 2.33635202e-01f, 2.02019796e-01f, -3.87442522e-02f, -1.41333761e-02f, -2.14584246e-01f, 3.15461069e-01f, -2.23604720e-02f, 1.12877615e-01f, 2.29855254e-01f,
  3.87039274e-01f, 2.50958025e-01f, -2.36976460e-01f, -2.71017969e-01f, -9.76682976e-02f, 1.82891279e-01f, -1.53740239e-03f, -2.07751036e-01f, 2.80276209e-01f, 3.79538201e-02f,
  1.83206826e-01f, -2.21549775e-02f, 5.90119548e-02f, 5.46765700e-02f, 9.04419497e-02f, -3.67541313e-02f, -1.74602240e-01f, -2.07395643e-01f, 2.25546822e-01f, 1.64694741e-01f,
  3.44321549e-01f, 2.87714511e-01f, 3.13014209e-01f, 5.61398156e-02f, -1.81298167e-01f, 3.47344309e-01f, 5.07896915e-02f, -2.85038382e-01f, 9.18948371e-03f, -3.87834430e-01f,
  -1.04739688e-01f, 3.52288224e-02f, -2.70459592e-01f, -1.72120910e-02f, -3.08313936e-01f, 4.97776419e-02f, -3.23054045e-01f, -1.35840043e-01f, -5.72670773e-02f, -3.82342696e-01f,
  -2.54077520e-02f, -1.30836323e-01f, 1.31503120e-01f, 1.25761877e-03f, 1.46096483e-01f, 3.33200485e-01f, 1.91256002e-01f, 7.79489987e-03f, -2.66496480e-01f, -2.07961708e-01f,
  -2.42147192e-01f, -4.93366383e-02f, 4.36334461e-01f, 3.58204722e-01f, -2.23740086e-01f, 1.17834017e-03f, -1.04846314e-01f, 4.95695472e-01f, -2.22730711e-01f, -1.56476885e-01f,
  -3.62671852e-01f, 2.76767612e-01f, 6.21203473e-03f, 7.76407272e-02f, 1.38160080e-01f, 2.95172840e-01f, -2.40330487e-01f, -8.97707880e-01f, -1.31427750e-01f, -1.19250990e-01f,
  -6.05905771e-01f, 1.63368493e-01f, 1.71631172e-01f, -3.24145079e-01f, -1.10028692e-01f, -4.85802531e-01f, 5.99205494e-02f, -3.38276058e-01f, 3.02021891e-01f, -5.20521514e-02f,
  2.51469724e-02f, -1.22185256e-02f, -1.06070980e-01f, -1.99670658e-01f, -2.57434696e-01f, -2.52070546e-01f, -6.15231581e-02f, 8.87000933e-02f, -6.81093156e-01f, -5.43166161e-01f,
  2.96483219e-01f, 2.06939578e-01f, 2.85391230e-03f, -2.94460040e-02f, 4.36581761e-01f, -2.05260172e-01f, 4.23282497e-02f, -3.10606599e-01f, 7.87702203e-02f, -3.28889221e-01f,
  -3.60244304e-01f, -3.64236504e-01f, -3.15315336e-01f, -3.89782012e-01f, -8.13450217e-02f, -3.31555784e-01f, 4.95613217e-02f, 1.85975552e-01f, -4.75930683e-02f, 1.53526515e-01f,
  1.81164369e-01f, 1.37239859e-01f, -1.28479488e-03f, 3.69091660e-01f, 4.41516154e-02f, -4.35666740e-02f, 1.55263707e-01f, 2.26714045e-01f, -4.11358289e-02f, -7.67401746e-03f,
  -2.35218421e-01f, -4.27270561e-01f, 1.98423669e-01f, 4.53997791e-01f, -1.09166346e-01f, -1.55002236e-01f, 1.19354598e-01f, -3.75194103e-01f, -1.55939654e-01f, 3.57280336e-02f,
  3.18322629e-01f, 1.94190428e-01f, -1.76842421e-01f, -1.29266560e-01f, 1.74198508e-01f, -3.75328451e-01f, -6.43300772e-01f, -8.23001564e-02f, 1.03303142e-01f, -2.69619912e-01f,
  -4.08810556e-01f, -6.91386685e-02f, -2.19252735e-01f, 7.75793865e-02f, -1.58051074e-01f, 2.92291380e-02f, -4.04165313e-02f, 2.33919084e-01f, 6.51183166e-03f, -5.85079789e-02f,
  1.41884610e-01f, 1.51533157e-01f, -2.21142814e-01f, 2.43668571e-01f, -2.98842639e-01f, -3.02811295e-01f, -7.19670802e-02f, 1.42277390e-01f, 1.17532611e-02f, -2.98495919e-01f,
  -8.98923501e-02f, 2.00430024e-02f, -1.46060526e-01f, -4.92248461e-02f, -6.81542307e-02f, 3.34375441e-01f, 3.78457099e-01f, 1.54250860e-01f, 8.98252726e-02f, 2.91813761e-01f,
  3.93452793e-02f, 4.09889221e-01f, 3.80573571e-01f, 1.67758480e-01f, 1.60519232e-03f, -1.89601704e-01f, 1.69931591e-01f, 1.64759666e-01f, -6.08256422e-02f, -8.51183478e-03f,
  5.14608733e-02f, 6.65613711e-02f, 5.81470132e-03f, 4.31613885e-02f, 3.36245418e-01f, 2.13404037e-02f, 2.53611594e-01f, -1.97037850e-02f, -9.16323736e-02f, -1.46220088e-01f,
  3.33903700e-01f, -1.20321447e-02f, -1.53197572e-02f, 1.54047012e-01f, 4.11424726e-01f, 5.89690059e-02f, 1.51971936e-01f, -2.15642989e-01f, 5.56912832e-02f, 3.27515662e-01f,
  2.43634388e-01f, 1.54783949e-01f, -1.84608512e-02f, -2.03928560e-01f, -2.93369144e-01f, 3.68071683e-02f, -7.24770874e-02f, -1.50983870e-01f, -4.98143941e-01f, -3.45906802e-02f,
  4.05952841e-01f, 2.57286280e-01f, 3.96371454e-01f, -1.94734931e-01f, 2.24014726e-02f, 2.22737402e-01f, -1.19251378e-01f, 3.86137575e-01f, -1.05011582e-01f, -2.09405929e-01f,
  -6.49679676e-02f, -3.42864662e-01f, -1.05135091e-01f, 2.41576821e-01f, -2.19979167e-01f, -3.23281974e-01f, -5.43712303e-02f, -3.15951556e-01f, -3.48559499e-01f, -6.93820417e-02f,
  6.03237636e-02f, -1.71376973e-01f, 1.89512912e-02f, 1.42013758e-01f, -2.22658124e-02f, 2.11416885e-01f, -8.37137178e-02f, 1.38923690e-01f, 4.04316783e-01f, 1.88871711e-01f,
  -2.99404114e-01f, -1.24061434e-02f, -1.09649107e-01f, -1.03083961e-01f, 3.52683812e-01f, 2.25566840e-03f, 5.95154837e-02f, -1.90577626e-01f, -4.90245130e-03f, -1.49406359e-01f,
  1.58345729e-01f, 1.90287963e-01f, 1.41576976e-01f, -2.03750983e-01f, 2.86553115e-01f, 3.10386360e-01f, 6.70040175e-02f, 2.05632553e-01f, 3.36051345e-01f, 2.70600677e-01f,
  2.47538716e-01f, -9.54895988e-02f, 1.19260021e-01f, -1.45724058e-01f, -3.01000103e-02f, 3.00285250e-01f, -1.79722067e-02f, 4.25635397e-01f, 7.68171903e-03f, 3.04974914e-01f,
  -6.59184158e-02f, -2.14482710e-01f, -4.10553664e-01f, -4.74779382e-02f, -1.50183529e-01f, -6.30885661e-02f, 3.55222672e-01f, -4.59423289e-02f, 1.27281353e-01f, 1.05064595e-02f,
  3.07123423e-01f, 4.22487855e-01f, -1.70749158e-01f, -3.50090444e-01f, -3.83031398e-01f, -2.65995204e-01f, -4.44626242e-01f, 2.76384890e-01f, -8.64568055e-02f, 2.35511363e-01f,
  2.31031954e-01f, -2.09944114e-01f, 1.09043442e-01f, 1.90121219e-01f, -2.61750251e-01f, -1.79980829e-01f, 1.29168674e-01f, 4.87428606e-01f, 1.12486392e-01f, 2.39096493e-01f,
  -3.32012147e-01f, 3.39458585e-02f, 8.43629539e-02f, 2.33170480e-01f, 2.11530820e-01f, 2.54036754e-01f, -1.83717906e-02f, -3.82534787e-02f, 7.69769549e-02f, 9.22321305e-02f,
  -2.63961852e-01f, -3.91046941e-01f, -7.59895379e-03f, -1.23072460e-01f, 1.14709651e-03f, -4.76892442e-02f, -1.49030596e-01f, 1.02409706e-01f, 1.68793619e-01f, 5.22613414e-02f,
  -3.95831734e-01f, -1.38280774e-02f, 4.26609069e-02f, -2.63836514e-02f, 3.33124138e-02f, 1.07458591e-01f, -2.17406049e-01f, -3.24399248e-02f, -2.17393965e-01f, 1.15575895e-01f,
  1.54756084e-01f, -2.09534958e-01f, 6.56621903e-03f, -8.81436989e-02f, 1.74246892e-01f, 1.13940284e-01f, 5.65485917e-02f, 3.21822502e-02f, -1.35211155e-01f, -3.43240090e-02f,
  -6.03238225e-01f, 2.36092925e-01f, -5.27760148e-01f, -1.47772774e-01f, -2.64534235e-01f, -4.69931453e-01f, 2.47060940e-01f, 2.93405205e-01f, 1.54232711e-01f, -2.00748001e-03f,
  4.80951071e-02f, -1.47727458e-02f, -4.75481302e-02f, -6.63327649e-02f, -4.74536698e-03f, -5.21949083e-02f, -1.98491484e-01f, -1.39911175e-01f, -8.31750631e-02f, 2.44449094e-01f,
  1.54589072e-01f, -9.87368301e-02f, 1.73467807e-02f, 3.84214185e-02f, 2.81292289e-01f, -4.26145084e-02f, 8.64767954e-02f, 4.02490869e-02f, 4.27215070e-01f, 4.67263997e-01f,
  3.43331426e-01f, 1.83218922e-02f, -9.34339985e-02f, 1.42263938e-02f, 5.59104048e-02f, -4.53006834e-01f, 2.98005074e-01f, -2.05863342e-01f, -3.90581340e-01f, 3.41798142e-02f,
  1.75236657e-01f, -5.34363985e-02f, -5.16027473e-02f, 8.16113055e-02f, 1.90508395e-01f, 3.81328389e-02f, -2.03922153e-01f, 2.80422598e-01f, 1.57420114e-01f, 3.27016354e-01f,
  2.10011557e-01f, -1.28543526e-01f, 6.94934726e-02f, 1.09021157e-01f, -4.36832935e-01f, 1.47441432e-01f, 2.16266260e-01f, 1.07363872e-01f, 1.31729007e-01f, -1.20900631e-01f,
  -4.90661897e-02f, 1.45899236e-01f, -4.14464250e-02f, 9.64608118e-02f, -1.65386453e-01f, 3.59320819e-01f, 1.11527614e-01f, -4.55075324e-01f, 2.49257579e-01f, 8.90789330e-02f,
  7.35190511e-02f, -3.96872386e-02f, 3.49299371e-01f, 2.87520796e-01f, -2.53746152e-01f, 4.14516389e-01f, 6.74833497e-03f, -4.33700457e-02f, -2.01023728e-01f, -7.84848705e-02f,
  1.20643392e-01f, -1.24101907e-01f, -2.49988958e-01f, 2.10088887e-03f, 2.08783671e-01f, 7.96710476e-02f, -4.31413978e-01f, 3.22044604e-02f, -1.88055962e-01f, 3.69419575e-01f,
  9.84134525e-02f, 2.70011365e-01f, 9.00046602e-02f, 8.95492658e-02f, 4.11373794e-01f, -1.42172603e-02f, 1.03073806e-01f, 1.06023453e-01f, -9.61023718e-02f, -1.65897906e-01f,
  1.23704672e-01f, -1.36213332e-01f, -1.28669456e-01f, 1.44917443e-01f, 8.08619410e-02f, -2.10837781e-01f, 5.89410774e-02f, -7.90275708e-02f, 1.47122025e-01f, -1.49397373e-01f,
  -4.41242754e-02f, 1.93317056e-01f, -7.97259621e-03f, -1.22924529e-01f, 2.29266480e-01f, -3.39388281e-01f, -1.50484219e-01f, 2.22958475e-02f, -2.95969278e-01f, 1.64626747e-01f,
  5.14712632e-02f, 1.43922806e-01f, 3.86421122e-02f, -8.03627744e-02f, -2.43839502e-01f, 7.71360174e-02f, 6.68011606e-03f, 9.85434726e-02f, -7.53147304e-02f, 1.71196505e-01f,
  2.49513224e-01f, 3.62204500e-02f, 2.79838353e-01f, 1.81044117e-01f, -2.86408573e-01f, -1.81116968e-01f, 7.15886801e-02f, 2.62141317e-01f, -9.87213627e-02f, 2.07987130e-01f,
  -1.95864215e-02f, 1.77328616e-01f, -1.19818775e-02f, -1.34141281e-01f, 1.02052927e-01f, -3.18169110e-02f, -9.93831828e-02f, -3.83930840e-02f, 2.75451671e-02f, 3.26346368e-01f,
  -2.81579942e-01f, 1.47836685e-01f, -2.12615922e-01f, 1.93537191e-01f, 5.29971831e-02f, 1.35004044e-01f, -7.48724043e-02f, -8.08654949e-02f, 1.22067250e-01f, 3.80517356e-02f,
  9.58817452e-02f, 1.11668129e-02f, 1.59043282e-01f, -3.29583794e-01f, 8.43116641e-02f, -1.16071373e-01f, 3.61814857e-01f, 3.83209020e-01f, -8.68089439e-04f, -9.21597332e-02f,
  1.19292356e-01f, 3.23745608e-01f, -6.70828000e-02f, 4.09567267e-01f, 2.59946063e-02f, -1.92623809e-02f, 4.98968139e-02f, 2.75512278e-01f, 3.16789389e-01f, 7.56195486e-02f,
  1.58309475e-01f, 1.31399050e-01f, -1.88425153e-01f, 1.10438615e-01f, 4.53582615e-01f, 2.91315883e-01f, 3.39040250e-01f, -1.35542946e-02f, -2.77941301e-02f, 1.87873356e-02f,
  -2.08018601e-01f, 5.02520092e-02f, -1.80728272e-01f, 2.12202698e-01f, 1.49522543e-01f, -1.03942432e-01f, 1.81426570e-01f, -1.41810119e-01f, 2.29498744e-01f, -1.59990609e-01f,
  -1.33649811e-01f, -1.83388576e-01f, -2.25580752e-01f, 2.51732081e-01f, 1.74173668e-01f, 5.29793724e-02f, -6.72739232e-03f, 2.48253569e-01f, 3.67535762e-02f, -6.40155375e-02f,
  -1.27609909e-01f, -1.25954524e-01f, 3.23245257e-01f, 3.62352997e-01f, -3.36326808e-01f, 2.30822235e-01f, -1.59200549e-01f, 8.11989456e-02f, 6.21093670e-03f, 2.50263214e-01f,
  2.21485943e-01f, 1.43295884e-01f, 2.99085766e-01f, 9.81803983e-02f, 1.91824064e-01f, 1.09230958e-01f, 3.07877004e-01f, 1.85061634e-01f, -2.59580731e-01f, -3.75143737e-01f,
  -2.65908033e-01f, -1.34044841e-01f, 1.44183919e-01f, 8.23769793e-02f, -2.87518233e-01f, -6.64633214e-01f, -3.47290151e-02f, -3.33747655e-01f, 8.65788013e-03f, 1.30447939e-01f,
  2.70247996e-01f, -2.99221665e-01f, -8.60787407e-02f, -1.25754669e-01f, -2.28308037e-01f, -1.28948182e-01f, 3.60926032e-01f, -4.15966138e-02f, 4.14269269e-02f, -1.47722229e-01f,
  1.06415739e-02f, 8.92715715e-03f, 3.00840050e-01f, -3.69991630e-01f, 1.49267182e-01f, -2.18817607e-01f, 9.25958306e-02f, 3.57236490e-02f, 1.05493248e-01f, 2.67808493e-02f,
  -7.71094561e-02f, 1.50188133e-01f, -2.65644342e-01f, 9.83993635e-02f, -9.39291529e-03f, 9.82116610e-02f, -9.06464085e-02f, -2.02387303e-01f, -2.11403221e-01f, -3.08259487e-01f,
  2.63126224e-01f, -2.24748343e-01f, -1.43381849e-01f, 4.67339121e-02f, 4.80959952e-01f, 8.36168304e-02f, 1.00897655e-01f, -4.79537636e-01f, 2.65300751e-01f, -6.99403584e-02f,
  6.11309350e-01f, 2.99226865e-03f, 8.52462053e-02f, -2.69726038e-01f, 6.07443862e-02f, 1.28678799e-01f, -5.44523820e-04f, -6.00822493e-02f, 1.30995706e-01f, 2.53336161e-01f,
  -9.69732106e-02f, -1.85042709e-01f, -1.61701278e-03f, 2.22326651e-01f, 2.52915800e-01f, 4.58026767e-01f, 1.76231667e-01f, 1.22282051e-01f, 9.85661522e-02f, 1.74541980e-01f,
  9.36192553e-03f, 3.25452209e-01f, 4.74764109e-01f, 2.28532746e-01f, 4.28970188e-01f, -7.39263147e-02f, 2.05822036e-01f, 3.87186468e-01f, 5.77068590e-02f, 9.62575227e-02f,
  -2.61635274e-01f, 1.09059326e-02f, 1.33253157e-01f, 1.65500641e-01f, 1.05204411e-01f, 9.20390710e-02f, 1.39347399e-02f, -9.83470902e-02f, -5.33836707e-02f, -2.60393500e-01f,
  -2.35533491e-01f, -5.29501498e-01f, 6.10099807e-02f, -8.15077126e-02f, -4.91575077e-02f, -3.39747638e-01f, 1.00044891e-01f, 1.32337064e-01f, 2.04155460e-01f, 1.10063344e-01f,
  -2.42373496e-01f, 2.39604153e-03f, 3.67224157e-01f, -2.68040359e-01f, 1.57155558e-01f, 3.28511931e-02f, 1.68266073e-02f, -8.38926211e-02f, 1.91141441e-01f, -1.57737061e-01f,
  1.04706280e-01f, 1.96303889e-01f, -3.34490053e-02f, 2.15777352e-01f, -1.26364172e-01f, 2.02066034e-01f, 1.91126570e-01f, 1.31721318e-01f, -8.68897699e-03f, 2.87259072e-01f,
  1.96776152e-01f, -6.52445555e-02f, -1.07158266e-01f, 3.02268546e-02f, -2.43263021e-01f, 6.57478273e-02f, 7.71505088e-02f, -4.01004553e-02f, 1.29501626e-01f, 8.06054026e-02f,
  1.48676887e-01f, 5.96304238e-02f, 1.58111200e-01f, 2.82977074e-01f, -1.41276613e-01f, -8.61433819e-02f, -1.61540657e-01f, 2.99115300e-01f, -6.91609597e-03f, 3.55056942e-01f,
  1.33871764e-01f, -3.62031102e-01f, -3.79754841e-01f, 2.16097191e-01f, 3.01969767e-01f, -8.21813419e-02f, -3.43851358e-01f, 2.40941316e-01f, -8.26221853e-02f, 1.71982750e-01f,
  -1.99111570e-02f, 3.21515113e-01f, -9.88475531e-02f, 1.27347440e-01f, -6.40347376e-02f, 3.42555791e-01f, -1.70011982e-01f, 4.26275171e-02f, 8.66761506e-02f, 4.45096105e-01f,
  -2.15332076e-01f, -2.67198145e-01f, 6.10569566e-02f, 1.66333005e-01f, 2.98442721e-01f, -2.68804193e-01f, 2.84492522e-01f, 3.25662762e-01f, -5.25081933e-01f, 1.13182503e-03f,
  2.37760752e-01f, 2.36441135e-01f, 1.63373664e-01f, -8.24001208e-02f, 2.02799425e-01f, 4.03734237e-01f, -1.18409343e-01f, 3.13686907e-01f, 6.44122297e-03f, 1.20503627e-01f,
  -2.18838662e-01f, -1.03569306e-01f, 3.82350206e-01f, -5.59090711e-02f, 1.18551128e-01f, -6.73648939e-02f, 9.57852527e-02f, -6.15077056e-02f, -2.14296684e-04f, 5.09748042e-01f,
  2.70201474e-01f, 2.34194487e-01f, 4.09772433e-02f, 1.58637300e-01f, 9.04420987e-02f, -1.07250907e-01f, -4.52862561e-01f, 3.07724327e-01f, 6.55234873e-01f, 3.45956326e-01f,
  1.29231706e-01f, -1.19210057e-01f, 2.91832276e-02f, -7.72542059e-02f, -1.49917975e-01f, 1.63556531e-01f, 2.14753166e-01f, -2.26541117e-01f, -2.99760669e-01f, 3.81598115e-01f,
  -5.28280675e-01f, -1.23032652e-01f, -1.14809133e-01f, -9.30856739e-04f, -4.62541342e-01f, 3.44399691e-01f, 1.53820187e-01f, -7.62037113e-02f, 1.48286447e-01f, -3.15993905e-01f,
  2.23207548e-02f, 3.59505296e-01f, 4.45116274e-02f, -3.99509668e-01f, -3.82002145e-01f, 1.74211800e-01f, 5.78288555e-01f, 2.55918503e-01f, 1.88581973e-01f, -7.13365525e-02f,
  4.69107658e-01f, 2.21660748e-01f, -9.87205058e-02f, 2.60458857e-01f, -6.14641570e-02f, 1.36105433e-01f, 2.11249679e-01f, 3.66976023e-01f, 2.28048801e-01f, -3.50784004e-01f,
  4.85973626e-01f, 1.44792408e-01f, 3.97358686e-01f, 2.62637973e-01f, 5.00506938e-01f, 2.67658830e-01f, 1.80637643e-01f, -5.72257563e-02f, 6.71052337e-02f, -7.18898326e-02f,
  6.15328774e-02f, 3.87345016e-01f, 7.59822652e-02f, 5.38286269e-02f, -5.85433915e-02f, -1.69907674e-01f, -1.89744741e-01f, 1.32548735e-01f, 3.58940780e-01f, 4.73862477e-02f,
  -6.19575158e-02f, 1.37342259e-01f, 2.48405561e-01f, -2.09258616e-01f, -1.53123766e-01f, -2.74266656e-02f, 7.55710453e-02f, 9.54392180e-02f, 2.29893893e-01f, -2.63523638e-01f,
  9.73664522e-02f, -3.32450308e-02f, -2.87095875e-01f, -1.96354538e-01f, -1.31680489e-01f, -1.18510112e-01f, 7.56369308e-02f, 1.43080905e-01f, -1.81285352e-01f, -2.26137042e-01f,
  3.29015821e-01f, 8.83689802e-03f, 4.64458950e-03f, 1.96669549e-01f, 4.68534172e-01f, -2.63179451e-01f, 4.90683280e-02f, -4.53737006e-02f, 1.88215785e-02f, 3.26984860e-02f,
  1.38771459e-01f, 3.79109204e-01f, -1.23710588e-01f, -2.81153828e-01f, -8.49429742e-02f, 1.47080436e-01f, -3.38529885e-01f, -1.76618889e-01f, -7.54447207e-02f, -1.83688775e-01f,
  1.95568666e-01f, -2.60809302e-01f, 2.31851593e-01f, -7.64349625e-02f, 6.30093291e-02f, -3.50112021e-02f, 1.84726685e-01f, 4.32713658e-01f, 3.30410525e-02f, -1.84482083e-01f,
  -1.74172372e-02f, -1.69369653e-01f, 2.62733042e-01f, 9.37644467e-02f, 1.44882739e-01f, 3.94482523e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  8.47795457e-02f, 1.93641752e-01f, -8.42190757e-02f, 1.96944982e-01f, 1.72404394e-01f, 9.69910324e-02f, 2.77053006e-02f, -1.75558388e-01f, 8.49273428e-02f, 1.19386889e-01f,
  1.02645293e-01f, 2.64791638e-01f, -4.79115639e-03f, 8.75114724e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.68822438e-01f, 3.74826521e-01f, 2.85707891e-01f, 3.50815415e-01f, -3.12276542e-01f, -3.00182492e-01f, 3.48492384e-01f, -1.38205200e-01f, 2.46615827e-01f, 1.80865824e-01f,
  1.52540341e-01f, 8.31595659e-02f, -1.77065730e-01f, -2.74712015e-02f, 2.80594051e-01f, 2.90624678e-01f, 2.59615600e-01f, -1.45854682e-01f, 8.39586332e-02f, -3.79443765e-01f,
  -1.32580251e-01f, -2.13972911e-01f, 1.99664325e-01f, 1.44838944e-01f, -5.55218160e-01f, -2.09891930e-01f, -1.85839564e-01f, 1.59501165e-01f, 1.12607703e-01f, -1.91861466e-01f,
  -8.95428434e-02f, 4.82382149e-01f, 3.06405783e-01f, 1.47062570e-01f, -2.58158565e-01f, 4.27091986e-01f, -3.12306672e-01f, -2.66865611e-01f, -3.44047129e-01f, -2.11565793e-01f,
  -2.75305390e-01f, -3.00423712e-01f, 2.68895149e-01f, -4.66058515e-02f, 1.51128784e-01f, 1.22794017e-01f, 1.05018266e-01f, 3.84648681e-01f, -1.38342679e-01f, -2.58608669e-01f,
  1.27216637e-01f, -3.61570001e-01f, -1.41885415e-01f, -1.29286587e-01f, 9.64413881e-02f, -4.37271744e-01f, -2.87479728e-01f, 5.30131795e-02f, -4.06555206e-01f, 3.97777826e-01f,
  -2.46252075e-01f, -3.91477674e-01f, -7.47011423e-01f, 2.44418606e-01f, 1.55553788e-01f, 2.63429016e-01f, 2.31784448e-01f, -1.90144122e-01f, -8.69918615e-02f, -1.12335876e-01f,
  3.31209674e-02f, -8.16205293e-02f, 1.45720541e-01f, 5.88488998e-03f, 1.76375225e-01f, -5.48759289e-03f, 1.95718199e-01f, -1.15039863e-01f, -1.18759712e-02f, 6.05323240e-02f,
  5.49943512e-03f, 1.20062374e-01f, -3.65185350e-01f, 3.86229786e-03f, -1.43659264e-01f, 1.06154509e-01f, -1.98692515e-01f, 9.56769846e-03f, -1.52764199e-02f, 3.38563234e-01f,
  1.04412869e-01f, -2.37464547e-01f, 1.52025372e-01f, 1.09718945e-02f, 2.78346896e-01f, 4.40545797e-01f, -1.74203366e-01f, 3.38874817e-01f, 2.26649735e-02f, -5.47375232e-02f,
  -8.95036906e-02f, -1.80808678e-01f, -2.79978156e-01f, 4.23548698e-01f, 5.61354384e-02f, 2.86816418e-01f, 1.57615900e-01f, -1.12869069e-01f, 1.44600108e-01f, 6.50597140e-02f,
  4.86334302e-02f, -3.43000770e-01f, -4.10806984e-01f, 1.34417325e-01f, 1.46359438e-03f, -5.04506528e-01f, 2.05918059e-01f, 5.30428886e-02f, 1.62559420e-01f, -5.19189656e-01f,
  2.42803972e-02f, 2.03320459e-01f, 1.28730219e-02f, -4.48018104e-01f, 2.71057542e-02f, 1.72627777e-01f, -1.34240031e-01f, 1.86494738e-01f, 3.24281126e-01f, -1.51984081e-01f,
  2.39721000e-01f, 8.13875869e-02f, 3.29670101e-01f, 1.28061518e-01f, 2.77816150e-02f, 1.18051939e-01f, 1.70998275e-01f, -7.57773519e-02f, -1.99771091e-01f, 2.35677779e-01f,
  1.17183708e-01f, 2.23523587e-01f, 3.28958243e-01f, 3.03205252e-01f, 1.85354337e-01f, 1.72542810e-01f, 2.35906497e-01f, 2.08744794e-01f, 1.09902434e-01f, 2.10799471e-01f,
  6.93749711e-02f, -9.10372287e-02f, -2.86844999e-01f, 6.69400916e-02f, -1.27164096e-01f, -1.23998150e-01f, -5.25712013e-01f, 3.63150984e-01f, 4.65236157e-01f, -7.45198429e-02f,
  -1.19570740e-01f, -1.15028165e-01f, -3.32499772e-01f, -1.05308831e-01f, 1.92201883e-01f, -1.92259029e-01f, -2.96764821e-01f, 5.21266609e-02f, 1.97574914e-01f, -1.29196674e-01f,
  -6.44798949e-02f, -3.11989069e-01f, -7.89605975e-02f, 2.10995033e-01f, 2.23207787e-01f, 1.69246227e-01f, -1.07650369e-01f, 4.28256124e-01f, -4.63995099e-01f, 3.94433826e-01f,
  1.67485066e-02f, 4.08171713e-02f, 1.35123283e-02f, 3.70428473e-01f, -2.52894461e-01f, -3.77982169e-01f, -1.37055898e-02f, -2.74817050e-01f, 3.51315856e-01f, -1.10246271e-01f,
  -7.86632001e-01f, -3.02276284e-01f, -1.64257079e-01f, 1.32340938e-01f, 2.68826243e-02f, -2.87928700e-01f, -2.85119593e-01f, -2.09476030e-03f, -2.73257613e-01f, -9.97610688e-02f,
  -5.73185571e-02f, 5.70138358e-02f, 3.55355479e-02f, 7.70743936e-02f, 1.92618892e-01f, -1.63081601e-01f, -2.97439277e-01f, 7.87060149e-03f, -2.15826914e-01f, -3.92657727e-01f,
  -2.78169103e-02f, 1.61227420e-01f, -8.29304606e-02f, 2.44673297e-01f, -4.92691956e-02f, 1.56276777e-01f, 2.57687092e-01f, -1.56019703e-01f, 1.25343844e-01f, -1.31804898e-01f,
  -5.41429341e-01f, -1.84113219e-01f, -2.38687649e-01f, -3.04621845e-01f, 1.74931556e-01f, 2.15118468e-01f, 4.14897561e-01f, 1.75864890e-03f, -3.48211788e-02f, 3.41550291e-01f,
  3.52730364e-01f, -8.47168919e-03f, 6.83947980e-01f, 9.54625309e-02f, 4.11858968e-02f, 1.02424815e-01f, 3.24111849e-01f, 4.40770477e-01f, -1.10338204e-01f, 1.95077404e-01f,
  1.99250638e-01f, 1.18365111e-02f, -4.88383658e-02f, -5.42001367e-01f, 2.08365381e-01f, 1.50345549e-01f, 7.82627910e-02f, -1.81317240e-01f, -3.62184376e-01f, -8.73845279e-01f,
  -5.45167148e-01f, 2.71015465e-01f, 3.16661373e-02f, -7.98371792e-01f, 1.66015416e-01f, -3.37794811e-01f, -1.72834277e-01f, -2.64424890e-01f, -2.60485709e-01f, 3.07953537e-01f,
  -1.28532395e-01f, -3.63778293e-01f, -1.10236526e-01f, 1.03456378e-01f, 1.66960418e-01f, 1.62825286e-01f, 2.06595376e-01f, 1.60821065e-01f, 3.27861644e-02f, 1.82717815e-01f,
  -1.54451981e-01f, 7.89520293e-02f, 3.98549531e-03f, -1.36993360e-02f, -1.52905732e-01f, 2.55905181e-01f, 1.63491979e-01f, 2.17807561e-01f, -3.22108269e-01f, -1.60908490e-01f,
  7.02049732e-02f, 8.57643504e-03f, 2.80070245e-01f, -4.05215710e-01f, 2.99800336e-01f, 4.26874697e-01f, -1.17768794e-01f, -7.29720369e-02f, 1.36819825e-01f, -1.72409058e-01f,
  -1.93000436e-02f, 1.69085681e-01f, 3.83527547e-01f, -2.87188441e-01f, 1.85276598e-01f, -7.62478262e-02f, -2.87193626e-01f, -3.67403656e-01f, 2.56488293e-01f, 3.95726234e-01f,
  2.41870522e-01f, 1.72492757e-01f, 9.40245539e-02f, 1.22544914e-01f, 6.77575022e-02f, -3.46191347e-01f, 1.67466760e-01f, 4.77827281e-01f, -5.30889094e-01f, 1.66630149e-01f,
  5.23993708e-02f, -5.00661790e-01f, -4.42086309e-01f, -4.26217824e-01f, -3.97751242e-01f, -1.57226548e-01f, -9.94915813e-02f, 6.45704567e-02f, 1.05936393e-01f, -2.68147022e-01f,
  -2.79181689e-01f, -2.54480749e-01f, 1.36333019e-01f, -3.05473775e-01f, -7.29232058e-02f, 1.29292995e-01f, -8.11776966e-02f, 2.37188682e-01f, 1.91264510e-01f, -2.97817826e-01f,
  -4.26447600e-01f, 1.46919996e-01f, -2.25276023e-01f, 1.85357228e-01f, -1.02022029e-01f, -8.10810477e-02f, 2.63902187e-01f, -6.84678962e-04f, 1.63110793e-01f, -1.08305058e-02f,
  -3.06553960e-01f, -1.29695997e-01f, 3.57827157e-01f, 1.18807800e-01f, -1.89467594e-02f, -1.51745439e-01f, -1.57053828e-01f, 1.37137920e-01f, -5.18516116e-02f, -1.89071223e-01f,
  -3.50604236e-01f, -6.99250549e-02f, 7.22072124e-02f, -4.28030193e-02f, -1.49070531e-01f, -1.77060783e-01f, -5.66860326e-02f, -1.24044558e-02f, 1.10329635e-01f, -2.58343637e-01f,
  -2.66880870e-01f, 1.27552971e-01f, 4.81824353e-02f, -1.86788455e-01f, -4.78926785e-02f, -2.02266201e-01f, -1.24704435e-01f, -1.35480300e-01f, 2.77610272e-01f, -1.89186320e-01f,
  2.08352342e-01f, -9.39901248e-02f, -4.36374068e-01f, 2.21041858e-01f, 3.19429278e-01f, -4.46564317e-01f, 9.08885226e-02f, 8.45273435e-02f, 8.57744962e-02f, -4.81069833e-01f,
  1.76355559e-02f, -3.14294726e-01f, -4.51351963e-02f, 1.23460621e-01f, 2.71216352e-02f, -1.11854911e-01f, -5.96284755e-02f, 2.58918971e-01f, -2.78177410e-01f, -7.15808645e-02f,
  2.64852464e-01f, -1.32139534e-01f, -1.56675987e-02f, -1.32904872e-01f, 8.37104470e-02f, -8.08470026e-02f, -1.56972989e-01f, 3.53842825e-02f, -9.23234075e-02f, -1.33827269e-01f,
  2.23008484e-01f, 2.62102872e-01f, -2.36613713e-02f, -3.32130581e-01f, 2.92146385e-01f, 3.86066400e-02f, -4.73787561e-02f, 3.93723518e-01f, 8.86671767e-02f, 5.45447171e-02f,
  9.94930193e-02f, 8.55936781e-02f, 1.21373639e-01f, 6.57358998e-03f, -1.33513004e-01f, 6.81744218e-02f, 1.48524478e-01f, -5.54170087e-02f, 1.29855767e-01f, -1.07569233e-01f,
  3.16018909e-02f, 2.61092335e-01f, 2.29119122e-01f, 1.60065114e-01f, -2.36769453e-01f, -3.94792408e-01f, -2.68789828e-01f, 4.09574866e-01f, -1.09976679e-01f, -1.85818315e-01f,
  1.55427262e-01f, 2.26919800e-01f, 2.40752041e-01f, 3.21166247e-01f, -6.13631308e-02f, -6.57064438e-01f, -1.89333409e-01f, -3.12093556e-01f, 2.94147313e-01f, 2.29174122e-01f,
  1.64990455e-01f, -4.96467054e-02f, 1.86380982e-01f, -4.90619123e-01f, -6.98964223e-02f, 1.86257064e-01f, -7.17565954e-01f, -4.18893874e-01f, -1.45659730e-01f, -4.29352745e-02f,
  -2.19138980e-01f, 4.82176766e-02f, 1.51581913e-01f, 9.06715766e-02f, -1.07766397e-01f, 1.04026616e-01f, 1.78347945e-01f, -3.01758815e-02f, -1.42639250e-01f, -1.33722574e-01f,
  -1.29414096e-01f, 1.38434451e-02f, -1.01424143e-01f, 5.56302257e-02f, -5.45325466e-02f, 1.89221483e-02f, 7.65104070e-02f, -1.48272187e-01f, 3.77234779e-02f, 2.04577953e-01f,
  3.42804641e-02f, 7.85294101e-02f, 5.18530346e-02f, 3.39877218e-01f, -2.32017085e-01f, -2.16669515e-02f, 1.94572300e-01f, -8.22036192e-02f, 2.70865768e-01f, 2.64812857e-01f,
  -1.45146370e-01f, -1.68307032e-02f, 3.19269985e-01f, 2.18914449e-01f, 3.43547195e-01f, 1.40231520e-01f, 1.18215293e-01f, 2.18806699e-01f, 1.06025912e-01f, -1.93762481e-01f,
  -2.15134680e-01f, 2.84153372e-02f, -5.74178360e-02f, -1.72167361e-01f, -2.40493894e-01f, -2.10387051e-01f, -1.97659925e-01f, -1.93770546e-02f, -1.89249799e-01f, -2.15891957e-01f,
  1.36846751e-01f, -4.29864943e-01f, -3.83520484e-01f, 1.46333873e-01f, -3.39480758e-01f, -1.53914914e-01f, -5.01329660e-01f, 2.04821583e-02f, -4.81369644e-01f, 1.50220796e-01f,
  2.42335692e-01f, 2.20245942e-01f, 4.91787381e-02f, -1.56433180e-01f, -2.07086876e-01f, -8.24288279e-02f, 3.51906329e-01f, 1.01392172e-01f, 4.51773591e-02f, 8.22797976e-03f,
  4.55800518e-02f, -1.18079176e-02f, -6.69518113e-02f, -6.54138625e-02f, 2.98080802e-01f, 1.01705618e-01f, 8.35367069e-02f, -3.62929739e-02f, -1.53036118e-01f, 1.55013263e-01f,
  -3.01923931e-01f, -2.04613984e-01f, 1.88001290e-01f, -2.48995021e-01f, 3.83800045e-02f, 2.12116018e-01f, -1.09512091e-01f, -2.21876368e-01f, 1.34636819e-01f, 3.83791238e-01f,
  -3.71409655e-01f, 8.55216756e-02f, 1.69769153e-01f, 8.67045522e-02f, -3.80276352e-01f, 2.81643629e-01f, -3.18224132e-02f, -2.55555481e-01f, -4.42361355e-01f, 4.52714801e-01f,
  -2.69870430e-01f, 1.83326095e-01f, -1.36899561e-01f, 3.07003111e-01f, -4.11906034e-01f, 4.75168154e-02f, 7.53091499e-02f, -1.92962721e-01f, -1.90379664e-01f, -2.46015996e-01f,
  5.72084486e-01f, -1.80220708e-01f, 8.28697383e-02f, 4.21220273e-01f, -4.07282948e-01f, -1.50620803e-01f, -7.21588254e-01f, 2.43696887e-02f, 2.30529848e-02f, -2.40639046e-01f,
  -2.58411318e-02f, -2.18780432e-02f, 1.43562630e-01f, -4.66838986e-01f, 1.54451579e-01f, 2.59619951e-01f, -5.58033511e-02f, 3.78749557e-02f, -3.54586467e-02f, -5.58583997e-02f,
  3.31086755e-01f, 1.66866258e-01f, 7.31580481e-02f, 2.97727883e-01f, -3.49201798e-01f, 1.03679895e-01f, 1.36447936e-01f, 1.49677664e-01f, 1.41423702e-01f, -3.34187895e-01f,
  2.29492232e-01f, 1.91498995e-01f, -1.52756780e-01f, -1.64326549e-01f, 6.96528628e-02f, -3.49599212e-01f, 2.88676396e-02f, -4.93313111e-02f, -1.99250877e-01f, 9.62244570e-02f,
  -3.50345783e-02f, 2.77717859e-01f, -2.69968039e-03f, 3.11391115e-01f, 4.19345438e-01f, -3.23751450e-01f, -1.53669000e-01f, -2.90789396e-01f, -2.28984430e-01f, -2.10405990e-01f,
  2.85016090e-01f, 2.87945181e-01f, 1.58671096e-01f, 3.18953991e-01f, 7.73002207e-03f, -2.23013267e-01f, -3.95009434e-03f, 1.47774950e-01f, 1.09946810e-01f, 8.81886482e-02f,
  -2.19996482e-01f, -2.93823987e-01f, -3.29604059e-01f, 2.38442108e-01f, 4.24585164e-01f, 3.38550448e-01f, -4.02340055e-01f, 3.43942121e-02f, -1.42974872e-02f, -4.09693062e-01f,
  1.96508780e-01f, -2.50481460e-02f, -4.46661323e-01f, -3.79841059e-01f, 1.24751016e-01f, -8.40745151e-01f, 2.24375337e-01f, -1.12607434e-01f, 2.72042423e-01f, -3.62148106e-01f,
  -1.59367308e-01f, 7.97420666e-02f, -6.11807667e-02f, -1.67550936e-01f, 6.87801316e-02f, 2.19956636e-01f, -3.40441734e-01f, -7.71669149e-02f, -5.75173676e-01f, -3.67496088e-02f,
  1.82504877e-01f, -2.99879014e-01f, -4.17324364e-01f, -5.33124864e-01f, 1.26745760e-01f, -2.03980729e-01f, -2.51059532e-01f, 2.68068582e-01f, 3.79003696e-02f, 3.02711368e-01f,
  2.95994371e-01f, -3.44161421e-01f, -4.10627425e-02f, -2.02368081e-01f, 2.57730901e-01f, -2.23408461e-01f, -2.20777154e-01f, -4.19191867e-01f, -3.52875441e-01f, 1.06228106e-01f,
  -2.24172354e-01f, -5.55733860e-01f, 2.78368890e-01f, -3.49668741e-01f, 4.03116345e-01f, 1.48776859e-01f, -2.27009416e-01f, 4.94287610e-02f, -1.69102296e-01f, -1.85584426e-01f,
  4.53783333e-01f, 5.02440989e-01f, -1.93765908e-01f, -3.81683648e-01f, -2.31584162e-01f, 1.50602236e-01f, -2.65325338e-01f, -4.39809293e-01f, -2.32529104e-01f, 1.11282170e-01f,
  2.78456360e-01f, 9.21926126e-02f, 2.22634599e-01f, -3.07395235e-02f, -5.47221601e-01f, -8.65323767e-02f, -5.07760942e-01f, -6.90990865e-01f, 5.03316261e-02f, 9.67789069e-03f,
  -5.21647871e-01f, 4.61130701e-02f, -8.42656732e-01f, 9.61328074e-02f, 1.46204397e-01f, 3.29075404e-03f, -2.93871671e-01f, -9.55043659e-02f, -1.87828690e-02f, 1.25196919e-01f,
  -1.10998549e-01f, -3.46294016e-01f, -2.17262626e-01f, 3.72395366e-02f, -2.74533331e-01f, -4.45924222e-01f, 6.72039837e-02f, 1.27459109e-01f, -7.62710199e-02f, -4.39594686e-01f,
  1.15262643e-01f, -7.72916228e-02f, -2.12027207e-02f, 3.41842115e-01f, -1.09108351e-01f, -1.61385149e-01f, -5.01896366e-02f, -3.70288283e-01f, -2.56255925e-01f, -1.21209517e-01f,
  6.59664571e-02f, 2.36551881e-01f, 3.60384971e-01f, -3.63588631e-01f, -1.62286535e-01f, 1.10021114e-01f, -1.79134235e-01f, -3.28212947e-01f, -1.54128343e-01f, -1.98807389e-01f,
  3.44252914e-01f, -8.16570744e-02f, 2.48427704e-01f, 2.26726368e-01f, 2.35776007e-01f, 3.78021210e-01f, -3.41163933e-01f, -4.19897616e-01f, 1.20264687e-01f, -3.20886254e-01f,
  -1.97084658e-02f, 1.95055187e-01f, -3.40742879e-02f, -4.53922063e-01f, -3.76503408e-01f, -2.17587382e-01f, -3.84884238e-01f, -4.08706516e-01f, -4.32851762e-02f, 1.81007832e-02f,
  3.73419195e-01f, 8.04005340e-02f, 1.39455825e-01f, -6.20561004e-01f, 1.66855022e-01f, -9.02965441e-02f, 1.21217817e-01f, 8.50299820e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.45536615e-02f, 2.32896321e-02f, -4.20917151e-03f, -5.40581569e-02f, 5.38957380e-02f, -1.34517610e-01f, 1.53068230e-01f, 5.38992733e-02f, -1.29997671e-01f, -1.33411773e-02f,
  2.47956775e-02f, -4.27817255e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    