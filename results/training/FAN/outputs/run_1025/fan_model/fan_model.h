/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.26537636e-01f, -3.10370803e-01f, -2.42973432e-01f, 3.06471288e-02f, -1.56369209e-01f, -9.31656510e-02f, -2.97322810e-01f, 6.77317306e-02f, -1.71893984e-02f, -3.92265394e-02f,
  1.97502449e-02f, 2.04043835e-01f, 1.70176670e-01f, 1.28119811e-01f, -7.32132792e-02f, -1.90260068e-01f, -1.94141194e-01f, -7.72634372e-02f, 1.40141249e-01f, 8.78961086e-02f,
  -6.21954561e-04f, -1.08730629e-01f, 3.10300887e-02f, 5.90808354e-02f, 4.35263664e-02f, 7.73800462e-02f, -9.53793079e-02f, -6.26109764e-02f, -1.81777403e-01f, -1.97851956e-01f,
  1.88449696e-01f, -9.12060440e-02f, 2.52023898e-02f, -7.20665529e-02f, 2.41376879e-03f, 5.04112095e-02f, 2.68341359e-02f, 2.10255571e-02f, 6.45784140e-02f, -5.37931025e-02f,
  -8.96154530e-03f, -4.61169295e-02f, 5.08508645e-02f, -1.22408429e-02f, 9.58064385e-03f, -3.20298970e-02f, -6.40317351e-02f, 2.75577586e-02f, -5.84251098e-02f, -4.29499447e-02f,
  -1.03688359e-01f, -1.29617423e-01f, 3.27303447e-02f, 6.92173466e-02f, -5.85088171e-02f, -5.59361316e-02f, 5.51143065e-02f, -6.01684675e-02f, 6.45155907e-02f, 1.53940320e-01f,
  8.10217410e-02f, 6.87712964e-05f, 1.01809937e-03f, -4.39956523e-02f, 2.95464471e-02f, 2.95707509e-02f, -3.70415971e-02f, -1.31060211e-02f, 4.79795830e-03f, -1.10247836e-03f,
  -4.14440446e-02f, 4.92943116e-02f, -5.01826266e-03f, 9.22111794e-03f, 4.84623350e-02f, -7.80829936e-02f, -7.21725523e-02f, 3.16313431e-02f, 8.67076442e-02f, 4.71004732e-02f,
  1.09663300e-01f, -3.49779576e-02f, -5.20290472e-02f, 7.44894668e-02f, -1.94655117e-02f, -2.48776712e-02f, -2.92096063e-02f, 2.03414988e-02f, 2.36876607e-02f, -1.77747887e-02f,
  1.90073863e-01f, -9.82777998e-02f, 1.50509790e-01f, 1.06865495e-01f, -1.80269461e-02f, -3.82446051e-02f, 1.34268580e-02f, 7.94224627e-03f, -1.08121231e-01f, 2.45711505e-02f,
  7.70553946e-03f, 1.37988636e-02f, -1.73484068e-02f, -4.91383299e-02f, -8.13665055e-03f, 6.71391515e-03f, -6.61949739e-02f, -8.55003372e-02f, -2.08839104e-02f, 6.90399930e-02f,
  -3.61777656e-02f, 8.32163903e-04f, 3.25299464e-02f, -1.08989496e-02f, -2.64378963e-03f, 1.18731074e-01f, 7.32662827e-02f, 4.80599478e-02f, 1.20279752e-01f, 4.72893044e-02f,
  -4.99999613e-01f, 6.72752336e-02f, -2.24486768e-01f, 3.30781080e-02f, 1.35270655e-01f, -5.55014983e-03f, 1.11218631e-01f, 8.00139159e-02f, 4.56401818e-02f, 1.07773326e-01f,
  2.44355038e-01f, 1.71963453e-01f, 4.52848375e-02f, 5.32202907e-02f, -1.25422508e-01f, -6.39073923e-02f, -4.82595861e-02f, -2.96844333e-01f, -6.12451471e-02f, 1.63741067e-01f,
  2.83682525e-01f, -1.76573955e-02f, -7.49712139e-02f, 1.72616336e-02f, 2.31779829e-01f, 1.79255679e-01f, 2.12553889e-02f, 8.95656794e-02f, 8.80935043e-02f, -7.07489299e-03f,
  -1.77299619e-01f, 1.03772036e-03f, 3.51774395e-02f, 1.48081128e-02f, 1.07208602e-01f, 1.61883235e-03f, 2.21874751e-03f, 1.53404204e-02f, 2.42612958e-02f, 2.71478686e-02f,
  1.14402756e-01f, 7.62681141e-02f, 3.65896188e-02f, 8.30833539e-02f, 5.13297990e-02f, -4.76354994e-02f, 7.90107101e-02f, -7.54716247e-02f, 3.95655483e-02f, 8.61609504e-02f,
  9.63799581e-02f, -7.20774895e-03f, -1.28776491e-01f, 1.44766560e-02f, -2.41897311e-02f, 8.88305008e-02f, -1.79540813e-02f, 8.55725035e-02f, -3.46040390e-02f, -6.96226060e-02f,
  -2.21013986e-02f, -4.93684027e-04f, 5.39801717e-02f, 8.08277801e-02f, -5.98488674e-02f, -4.87884693e-02f, -2.78231446e-02f, 2.12952532e-02f, 1.52653297e-02f, -1.67563539e-02f,
  -7.43357465e-02f, -4.05029431e-02f, 4.43069264e-02f, 1.44519908e-02f, -1.63065307e-02f, 3.36136892e-02f, -1.35898054e-01f, 9.73792523e-02f, -3.96329304e-03f, 9.45886131e-03f,
  -3.37259248e-02f, -7.97811598e-02f, -2.94288583e-02f, -1.68294758e-02f, -8.00507516e-03f, -1.17990285e-01f, 2.41628811e-02f, 8.20722580e-02f, -1.25920027e-02f, -1.56811662e-02f,
  1.26733720e-01f, 7.48181716e-02f, 6.15057871e-02f, 1.25582159e-01f, 6.39077695e-03f, 6.64339215e-02f, 6.06851578e-02f, 8.41162913e-03f, 1.00744016e-01f, -4.13136669e-02f,
  -2.92549987e-04f, 1.72071289e-02f, 9.90147069e-02f, 7.13358000e-02f, 3.34825069e-02f, 2.03349888e-02f, 5.71272001e-02f, -1.44595783e-02f, 4.51378971e-02f, 2.77152788e-02f,
  -6.08974136e-02f, -6.55179098e-02f, 1.23581849e-03f, -3.82560119e-02f, 2.90313382e-02f, 4.17121947e-02f, 2.35868990e-02f, 2.95348521e-02f, -2.94398982e-02f, -1.77488670e-01f,
  -3.23082328e-01f, -3.64743233e-01f, 7.35727400e-02f, -2.63368607e-01f, 6.29277080e-02f, 9.79157910e-02f, -1.82760417e-01f, -1.54720293e-02f, -1.10532739e-03f, -1.84630200e-01f,
  1.58638924e-01f, 2.04008847e-01f, 8.94573256e-02f, 2.09349811e-01f, 7.37247616e-02f, -1.54246330e-01f, -1.46359816e-01f, 1.22508027e-01f, 2.28301823e-01f, 1.23877026e-01f,
  8.80790055e-02f, -7.31479824e-02f, 1.04973428e-01f, 3.16139124e-02f, -1.53507024e-01f, 1.17675170e-01f, -3.37147675e-02f, 6.41816184e-02f, -1.91733781e-02f, -3.71176869e-01f,
  9.63212550e-02f, -2.45383620e-01f, 9.97541323e-02f, 2.05291621e-02f, 8.28942358e-02f, 1.27758116e-01f, 1.79833844e-02f, 1.58091076e-02f, 7.52227530e-02f, -5.48594818e-03f,
  9.13755298e-02f, 6.36540204e-02f, -3.52820661e-03f, 5.75640053e-03f, -9.19207186e-03f, -1.41576612e-02f, -8.88237730e-02f, -8.83170068e-02f, 8.37195758e-03f, 9.50378850e-02f,
  -3.79752554e-02f, -4.92540337e-02f, 9.21584293e-02f, 3.17669734e-02f, 5.35029620e-02f, 1.83101982e-01f, 4.44375500e-02f, -1.75103135e-02f, 8.08217898e-02f, -1.94218904e-01f,
  -1.15809299e-01f, 4.56046015e-02f, 7.15196431e-02f, -2.43673548e-02f, 2.97078732e-02f, 6.79735690e-02f, -6.70040101e-02f, -4.46863547e-02f, 5.09000085e-02f, 2.88185682e-02f,
  -2.61265691e-02f, 3.07683162e-02f, 2.68293545e-02f, -2.58406326e-02f, -3.04634161e-02f, -1.63732246e-02f, 5.13415448e-02f, 6.63658837e-03f, 1.49468966e-02f, -4.57115285e-03f,
  -9.04630497e-03f, 4.03048918e-02f, 6.59684762e-02f, -1.40454592e-02f, 6.27250969e-02f, -5.07084094e-02f, 7.36187920e-02f, 1.10249586e-01f, 1.83717683e-02f, -1.38975428e-02f,
  1.46542907e-01f, 1.47702530e-01f, -2.70914845e-02f, 6.42360225e-02f, 3.91224436e-02f, -2.10577492e-02f, -9.17643402e-03f, 6.18862696e-02f, 2.55184565e-02f, 3.22245657e-02f,
  1.65656470e-02f, 4.14791927e-02f, -1.32328728e-02f, 6.66483641e-02f, -2.62089875e-02f, 7.65943751e-02f, 7.41012171e-02f, 6.49143802e-03f, 8.38493705e-02f, -2.97681317e-02f,
  1.03005745e-01f, 7.36629888e-02f, 1.20603211e-01f, 6.23795837e-02f, 4.66977544e-02f, 1.05480097e-01f, 7.52815753e-02f, 1.16469458e-01f, 1.87875420e-01f, 1.18628340e-02f,
  9.31210145e-02f, -1.61339819e-01f, 8.88043419e-02f, 1.31060788e-02f, 1.92524388e-01f, 1.56153575e-01f, 2.93009758e-01f, 3.45260724e-02f, -2.13985089e-02f, -1.13978021e-01f,
  -9.16640088e-02f, -1.84422836e-01f, -1.91934913e-01f, -2.22798154e-01f, -1.39432907e-01f, -1.86643805e-02f, 8.90014246e-02f, -6.36145193e-03f, 6.98675662e-02f, 6.83971196e-02f,
  8.92664585e-03f, -5.79439057e-03f, -7.27584958e-02f, -6.63904324e-02f, -2.76920974e-01f, -5.14403125e-03f, -1.42986000e-01f, -1.27310410e-01f, -1.49230182e-01f, -1.62126213e-01f,
  -3.13457489e-01f, -1.38343483e-01f, 4.46875207e-02f, -8.67223442e-02f, 1.26554742e-02f, -1.14688210e-01f, -4.30528149e-02f, -6.81269243e-02f, -7.49374852e-02f, -8.76798779e-02f,
  -1.47558540e-01f, -9.46510360e-02f, -3.09052970e-02f, -7.04887286e-02f, -1.00955283e-02f, -9.09964740e-02f, -6.68765977e-02f, -1.39864773e-01f, -7.51754716e-02f, -1.40774876e-01f,
  -4.48541567e-02f, 6.31705225e-02f, -1.48117328e-02f, -1.00174248e-01f, -1.47189304e-01f, -3.27696116e-03f, -1.01880282e-01f, -1.26634881e-01f, 3.00474185e-02f, -1.94509719e-02f,
  6.27405196e-02f, -2.79944483e-02f, 4.01752889e-02f, 1.69344852e-03f, 5.33613516e-03f, -3.76154929e-02f, -6.49365038e-02f, -7.34235123e-02f, 1.65089425e-02f, 4.52762609e-03f,
  -2.70633698e-02f, 1.44263292e-02f, -4.42076437e-02f, -6.24606460e-02f, -2.88971793e-02f, -7.88839441e-03f, 2.18631197e-02f, -4.53752056e-02f, -4.17673066e-02f, 9.71014276e-02f,
  -2.19986457e-02f, 3.71879861e-02f, -7.96053559e-03f, -1.99408643e-02f, 7.49990437e-03f, -1.39606278e-02f, -2.40541040e-03f, -9.37572680e-03f, 1.95136387e-02f, 1.13053070e-02f,
  -1.11653566e-01f, 1.82071522e-01f, -8.01659971e-02f, 9.32398625e-03f, -1.26135591e-02f, -3.55520174e-02f, -2.38259751e-02f, -2.15697757e-04f, 6.13928831e-04f, -5.11993133e-02f,
  -3.91154177e-02f, -5.40174283e-02f, -7.04717338e-02f, -8.62810537e-02f, -1.85399093e-02f, -2.52011139e-03f, 3.82639393e-02f, -4.97845840e-03f, 3.86579148e-02f, -5.90325259e-02f,
  -6.08252585e-02f, 1.22605888e-02f, 4.42146994e-02f, 3.51388194e-02f, -1.12351462e-01f, 4.96557839e-02f, -5.41705936e-02f, -4.04492542e-02f, 4.66697849e-02f, 2.64373254e-02f,
  8.55837762e-01f, 9.88226905e-02f, 2.57614404e-01f, 2.59555638e-01f, -1.74750030e-01f, 5.90692647e-02f, -9.67509076e-02f, 7.45064542e-02f, 1.44836247e-01f, 8.14305171e-02f,
  2.66547389e-02f, 1.55449703e-01f, 5.05434088e-02f, 1.24441739e-02f, 2.45765388e-01f, -7.50282034e-02f, -2.42547244e-02f, 2.61125565e-01f, 3.58218908e-01f, 2.14902073e-01f,
  1.37659963e-02f, 1.63354725e-01f, 3.77779454e-01f, 1.16063379e-01f, -3.81683595e-02f, 6.10468090e-02f, -7.50848874e-02f, 1.04871616e-02f, -4.12411466e-02f, -5.89447608e-03f,
  3.67941767e-01f, 1.79869384e-01f, 5.63076474e-02f, 1.13776520e-01f, 5.85838482e-02f, 2.80090123e-01f, 1.91240951e-01f, 1.16576314e-01f, 5.86926714e-02f, 1.54296473e-01f,
  1.03755020e-01f, 8.44629779e-02f, 2.95244697e-02f, 8.28217641e-02f, 1.80918738e-01f, 9.91062894e-02f, 7.68874809e-02f, 2.24022716e-01f, 2.01901048e-01f, 2.76995413e-02f,
  4.41416390e-02f, 1.49248078e-01f, 1.65464208e-01f, 1.25159353e-01f, 1.54871061e-01f, 1.18861340e-01f, 1.27330825e-01f, 9.63125452e-02f, 4.73411232e-02f, 1.97444454e-01f,
  2.55886931e-02f, -4.68622148e-02f, -1.03393734e-01f, -8.01261365e-02f, -6.84845597e-02f, -1.22853078e-01f, -5.70137016e-02f, -1.15085401e-01f, -8.94608051e-02f, -2.15822924e-02f,
  -1.82042092e-01f, -7.71501958e-02f, -6.07143678e-02f, -8.48152116e-02f, -9.35353190e-02f, -3.63391750e-02f, -5.15194014e-02f, -2.99352109e-02f, -1.67433038e-01f, -1.16399430e-01f,
  -6.07168637e-02f, -1.19225688e-01f, -1.01566911e-01f, -5.06669097e-02f, -1.28854319e-01f, -8.33660662e-02f, -1.37944743e-01f, -9.11181420e-02f, -1.09151058e-01f, -8.64665732e-02f,
  1.33839980e-01f, -1.13408245e-01f, 2.08918422e-01f, 6.28854111e-02f, 1.41771778e-01f, 8.44204128e-02f, 6.91177621e-02f, 7.15838820e-02f, 8.80450904e-02f, 1.16016112e-01f,
  1.90909524e-02f, 1.85990721e-01f, 1.48501903e-01f, 6.56112805e-02f, 1.60522580e-01f, 1.43088013e-01f, 1.47165572e-02f, 2.07545266e-01f, 6.03175201e-02f, 1.17434844e-01f,
  9.68028605e-02f, 1.81291938e-01f, 2.13809744e-01f, 1.55610874e-01f, 2.85735298e-02f, 1.53587237e-01f, 1.21035188e-01f, 1.77036822e-01f, 1.35108471e-01f, 2.75003135e-01f,
  3.13641518e-01f, -9.00240839e-02f, -2.52113789e-01f, 1.55444637e-01f, 3.74672702e-03f, 1.55521780e-01f, 1.45550638e-01f, 2.48117119e-01f, 8.69708732e-02f, 6.20142221e-02f,
  -1.26372159e-01f, -1.22184217e-01f, -2.96315532e-02f, 1.00070722e-02f, 2.05044672e-01f, 5.39805815e-02f, -9.57996305e-03f, -6.27637431e-02f, 8.84574279e-02f, 5.87150035e-03f,
  1.50493328e-02f, 1.30465984e-01f, -4.05777283e-02f, 4.77303676e-02f, -1.63212255e-01f, 6.11224025e-02f, -1.84698969e-01f, -1.07841693e-01f, -2.39565372e-01f, -2.95807123e-01f,
  -2.90075243e-01f, -1.19224884e-01f, 1.25261366e-01f, 6.75848499e-02f, -1.05603680e-01f, 5.68724610e-02f, 3.62836011e-03f, -9.46996137e-02f, 6.01341426e-02f, 3.12082889e-03f,
  -9.78897735e-02f, -1.59029681e-02f, -9.34569072e-03f, 4.89070527e-02f, -1.00606168e-02f, -3.65407160e-03f, -1.01631612e-01f, 2.33360007e-02f, 3.81090119e-02f, -8.78391936e-02f,
  -6.70782626e-02f, -1.86994195e-01f, 6.26874436e-03f, -3.86498719e-02f, 4.56654951e-02f, 6.16895873e-03f, -5.46462042e-03f, -1.28179550e-01f, 4.15790901e-02f, -3.17655131e-02f,
  8.76964927e-02f, -3.45338099e-02f, -8.49297419e-02f, -7.43712932e-02f, 2.41633598e-03f, -5.63576370e-02f, -1.45518081e-02f, -8.00930939e-05f, 2.79707424e-02f, 5.29201254e-02f,
  -4.20100950e-02f, -9.07106102e-02f, -1.37800246e-01f, 3.97902951e-02f, -6.33413419e-02f, 2.26148218e-02f, 1.91751879e-03f, 3.03539680e-03f, -7.47025535e-02f, -1.63272284e-02f,
  -7.13841617e-02f, 3.09164030e-03f, -6.24924563e-02f, -4.39193137e-02f, -5.14300428e-02f, -5.38826473e-02f, -1.00162394e-01f, -6.21556081e-02f, -2.12719794e-02f, -5.97446151e-02f,
  2.36306131e-01f, 1.99633427e-02f, 8.51034075e-02f, 3.53265330e-02f, -2.19494645e-02f, 1.24632530e-02f, -9.03999507e-02f, 8.54070298e-03f, -1.03718238e-02f, 4.22008336e-02f,
  1.00809298e-01f, 5.84354624e-02f, -3.48933451e-02f, 2.17831321e-02f, 4.64610606e-02f, 5.46551533e-02f, 3.90075259e-02f, 9.15499404e-02f, 2.67627425e-02f, 3.94352004e-02f,
  1.42478585e-01f, 1.98916480e-01f, 2.17999488e-01f, 9.82437506e-02f, 3.20958756e-02f, 1.77980542e-01f, 8.97506475e-02f, 1.77396864e-01f, 1.11580424e-01f, 3.15466881e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.94432002e-01f, -4.71093565e-01f, 2.97906607e-01f, 3.14715713e-01f, 1.78371862e-01f, 1.17303334e-01f, -1.01026155e-01f, 4.44843285e-02f, 3.17489862e-01f, 1.88541219e-01f,
  -1.68337613e-01f, 7.76956305e-02f, -2.26756353e-02f, 8.41520578e-02f, 1.44987181e-02f, 1.43778160e-01f, 2.46002108e-01f, 2.48475060e-01f, 3.42529625e-01f, 2.62245625e-01f,
  1.64441347e-01f, 1.13396905e-01f, 8.67709517e-02f, 1.16451882e-01f, 2.13535562e-01f, 2.59953588e-01f, 7.04267621e-02f, -3.46427644e-03f, -1.07580032e-02f, 3.47393513e-01f,
  1.76873282e-01f, -1.39571533e-01f, 8.25523883e-02f, -1.24014325e-01f, -1.27520889e-01f, -3.72899547e-02f, 1.26129622e-03f, -1.22400513e-02f, -7.43683369e-04f, -8.94967541e-02f,
  -8.36181492e-02f, -3.90155688e-02f, 1.08934361e-02f, 5.01613803e-02f, -4.87828627e-02f, 2.86484919e-02f, -3.50216143e-02f, -7.71265104e-02f, -6.80646747e-02f, -1.48247227e-01f,
  -3.86051908e-02f, 9.41279437e-03f, -1.03367448e-01f, -1.20052146e-02f, -1.41720563e-01f, 4.66209650e-02f, -9.36202779e-02f, -9.89088640e-02f, 8.21323227e-03f, -1.91355497e-02f,
  -8.65624398e-02f, 5.19593097e-02f, 4.87208553e-02f, 1.45793095e-01f, 5.65774478e-02f, -1.18905574e-03f, 1.18708033e-02f, 7.74149969e-02f, 9.72833559e-02f, 1.17397219e-01f,
  1.11722194e-01f, 1.42178357e-01f, 1.62481014e-02f, 2.61306226e-01f, 1.22477241e-01f, 1.90916270e-01f, 2.40292594e-01f, 9.74473655e-02f, 1.79097205e-01f, 1.21022090e-01f,
  2.33231634e-01f, 1.28424138e-01f, 1.49031812e-02f, 1.55029735e-02f, 2.37386650e-03f, 9.21547487e-02f, 2.51586109e-01f, 5.69261387e-02f, 1.73525829e-02f, 8.56848154e-03f,
  -1.11599997e-01f, -3.48323107e-01f, 1.47873878e-01f, -2.40238640e-03f, -8.86981338e-02f, -8.86650309e-02f, -1.97715797e-02f, -1.05830669e-01f, -1.44739524e-01f, -8.91972557e-02f,
  -5.12422025e-02f, 4.18993495e-02f, -1.66254193e-01f, 1.98072270e-02f, 1.04445234e-01f, -3.18966135e-02f, -1.43928021e-01f, -1.03222784e-02f, -2.14514047e-01f, -4.20671329e-02f,
  -1.73694029e-01f, 4.68384940e-03f, 1.20369293e-01f, 7.97217898e-03f, 1.67980175e-02f, 4.10987101e-02f, -9.13273194e-04f, 1.29227666e-02f, -2.89138351e-02f, 1.56853288e-01f,
  8.57869565e-01f, 5.21577477e-01f, 4.34039265e-01f, 1.41615257e-01f, -1.48993015e-01f, -5.45986071e-02f, 1.26591772e-01f, 2.28306919e-01f, 6.47808015e-02f, 2.00693265e-01f,
  3.02263889e-02f, -2.38165874e-02f, 1.01968542e-01f, 1.62864491e-01f, 2.74461567e-01f, 2.04958767e-01f, 5.82266040e-03f, 2.88698703e-01f, 7.01441988e-02f, 1.44670159e-01f,
  -1.20225944e-01f, -1.24977507e-01f, 6.28745332e-02f, 1.03486754e-01f, 1.24976695e-01f, 5.12523800e-02f, 4.36466746e-02f, -3.58695686e-02f, 1.09795772e-01f, 5.63962199e-02f,
  6.72531947e-02f, 3.83794218e-01f, -1.58033982e-01f, -9.51104611e-02f, -1.89734623e-01f, 1.85425803e-02f, -9.84337926e-03f, -7.31654242e-02f, -6.28596172e-02f, -1.23230062e-01f,
  -1.41981646e-01f, -2.89517976e-02f, 8.53128172e-03f, -6.44503906e-02f, -9.22926068e-02f, 2.79201642e-02f, 5.66312671e-02f, 1.62386656e-01f, 1.94141179e-01f, 7.57539943e-02f,
  -1.63121060e-01f, -2.17488512e-01f, -5.69145987e-03f, 2.13529259e-01f, 1.18629448e-01f, -8.32972527e-02f, 4.03578356e-02f, 5.30386791e-02f, 5.99490404e-02f, 2.35836372e-01f,
  -3.61070372e-02f, 1.09400921e-01f, 1.80550694e-01f, 1.06924348e-01f, 1.36406332e-01f, 1.54676929e-01f, 2.50317883e-02f, 5.46945035e-02f, 1.05316393e-01f, -7.19741778e-03f,
  4.16388959e-02f, 6.42984435e-02f, 5.33946883e-03f, 7.66804814e-02f, 9.22749937e-02f, -8.42215568e-02f, -1.85023412e-01f, -8.43609497e-02f, 1.34679973e-01f, -1.43314362e-01f,
  -5.54429218e-02f, -7.67634762e-03f, -6.90440312e-02f, 1.65807977e-01f, -1.37076616e-01f, 1.60863310e-01f, -8.48336145e-02f, -1.27110213e-01f, -1.20727517e-01f, -1.65352464e-01f,
  -5.65760791e-01f, 3.02587990e-02f, 5.88762574e-02f, 1.67200435e-02f, -9.64796729e-03f, -1.36923566e-02f, 1.00940235e-01f, -9.64222401e-02f, -1.22182809e-01f, 1.73279066e-02f,
  -2.07600780e-02f, 5.69203570e-02f, 9.94125083e-02f, -1.39079038e-02f, -6.83967024e-02f, -2.42652282e-01f, -9.62887481e-02f, -1.82971939e-01f, -9.34431180e-02f, -1.81761831e-01f,
  -1.03165001e-01f, -2.83713043e-01f, -1.25989541e-01f, 3.97637673e-03f, -6.61188588e-02f, -1.36611387e-01f, -1.65622100e-01f, -1.84326112e-01f, -6.47972822e-02f, -5.58045767e-02f,
  3.15086931e-01f, -2.05500680e-03f, 2.82769591e-01f, 3.54195744e-01f, -9.68633161e-04f, -4.53479201e-01f, -5.81906140e-01f, -6.38650656e-01f, -2.19331533e-01f, -2.71961838e-02f,
  -4.19074930e-02f, 1.55156061e-01f, 4.67569642e-02f, -1.02374732e-01f, -2.42081910e-01f, -1.09077588e-01f, 2.16978639e-01f, 2.99269706e-01f, -9.95163769e-02f, -2.26983160e-01f,
  8.58428627e-02f, 4.51234221e-01f, 4.88158375e-01f, 4.78545353e-02f, 2.45460883e-01f, 7.15685636e-02f, 2.83699542e-01f, 3.85064900e-01f, 1.22459367e-01f, 4.89057750e-01f,
  1.90115958e-01f, 1.16322324e-01f, -1.40439078e-01f, 2.41781667e-01f, 2.82212079e-01f, 7.39988359e-03f, -1.03456646e-01f, 4.37900156e-01f, -8.43917131e-02f, 6.51159063e-02f,
  2.60100901e-01f, 5.23492098e-02f, 1.03377581e-01f, -7.32456744e-02f, -1.27638817e-01f, -2.30284110e-01f, 8.59598890e-02f, 4.85219471e-02f, 1.30824178e-01f, -2.44609058e-01f,
  2.54815370e-01f, 3.58570695e-01f, -1.50556609e-01f, -4.05603558e-01f, -2.08595335e-01f, 1.83415011e-01f, -7.57899731e-02f, -2.01136358e-02f, -1.94628447e-01f, -9.30098817e-02f,
  -1.80274546e-01f, -2.02519000e-01f, -1.72554664e-02f, 1.20590933e-01f, -5.19122928e-02f, -3.31555158e-02f, 3.99009977e-03f, -1.16250649e-01f, -6.87650666e-02f, -6.13803826e-02f,
  -1.87025040e-01f, -5.24234325e-02f, 5.61547605e-03f, -3.36979032e-02f, -4.90853004e-02f, 6.06295280e-02f, -2.49411806e-01f, 1.39054190e-02f, 5.18600270e-02f, 7.75599107e-02f,
  6.20188341e-02f, -1.18939914e-01f, 4.78168353e-02f, -1.41946688e-01f, 1.65080354e-02f, 1.16495594e-01f, -5.80277815e-02f, -8.67881626e-02f, -2.08113366e-03f, 1.86764255e-01f,
  -2.14253236e-02f, 1.90364301e-01f, -2.33412877e-01f, -2.10224479e-01f, -2.72223987e-02f, -2.34658904e-02f, 2.30371226e-02f, -6.24768659e-02f, 6.32470567e-03f, -3.88622284e-01f,
  -2.67933488e-01f, -3.66761088e-01f, 1.68909967e-01f, -1.05143443e-01f, -1.35144725e-01f, -1.71269804e-01f, -1.25860959e-01f, -7.12285936e-02f, 5.21117933e-02f, -1.98376000e-01f,
  -2.33265817e-01f, -4.31570470e-01f, -4.95754153e-01f, -3.83657306e-01f, -3.35960001e-01f, -4.22227144e-01f, -4.37332064e-01f, -3.42698306e-01f, -3.93477440e-01f, -5.48268855e-01f,
  7.24588752e-01f, 4.96903151e-01f, -2.74401248e-01f, 1.42883018e-01f, -2.43190691e-01f, -3.97240281e-01f, -2.57134050e-01f, 7.72130117e-02f, 1.70326278e-01f, 3.05588037e-01f,
  2.53351033e-01f, 3.59456301e-01f, 2.54150093e-01f, 2.12055564e-01f, 1.87077835e-01f, -1.33107722e-01f, -1.01367198e-01f, -5.56589402e-02f, -1.28051892e-01f, 6.67925254e-02f,
  1.83467314e-01f, -1.68556180e-02f, 1.73052028e-01f, 2.33707681e-01f, 3.33575159e-01f, 2.45591879e-01f, 2.01230988e-01f, 1.22596696e-01f, 9.13726091e-02f, 3.91029209e-01f,
  1.89094231e-01f, 1.63527668e-01f, 3.02045867e-02f, 1.63144737e-01f, -1.01458887e-03f, 1.50652885e-01f, -7.98350126e-02f, 4.00069319e-02f, 2.86168009e-02f, -4.03045304e-03f,
  3.94287966e-02f, 1.01565592e-01f, -7.54858330e-02f, -5.25306463e-02f, -9.35833156e-02f, -2.11036876e-02f, 2.99516004e-02f, 1.56877279e-01f, 1.50346354e-01f, 4.92810048e-02f,
  1.45415694e-01f, -6.07588701e-02f, -1.12222001e-01f, -1.45452216e-01f, -1.07552059e-01f, -4.40515392e-02f, 6.73032776e-02f, 4.24899533e-02f, 1.79477148e-02f, 2.31380045e-01f,
  -3.56578752e-02f, 9.49631110e-02f, 1.62281066e-01f, -6.60591871e-02f, -9.08584446e-02f, -9.30212364e-02f, -8.66404921e-02f, -1.10948838e-01f, -1.66943386e-01f, -1.61008000e-01f,
  -4.05591689e-02f, -2.16884241e-02f, 6.88322112e-02f, -8.98473263e-02f, 6.47242293e-02f, 5.26976734e-02f, 9.26946197e-03f, 7.25671556e-03f, -1.10393673e-01f, 3.25636007e-02f,
  -3.82716693e-02f, -6.76410794e-02f, 1.26134427e-02f, -6.04415871e-02f, -6.19070604e-03f, 2.89322231e-02f, -4.34004888e-02f, 5.83250895e-02f, 2.34030057e-02f, 8.54102969e-02f,
  2.58806676e-01f, -2.52663702e-01f, 6.06825016e-02f, 1.43153712e-01f, 2.16033291e-02f, 1.06539868e-01f, 3.32763717e-02f, -1.11231226e-02f, 7.93491304e-02f, -2.55032349e-02f,
  -8.17957819e-02f, 4.82275374e-02f, -5.67546338e-02f, -8.80292654e-02f, -1.15049146e-01f, -6.87662000e-03f, 1.62953451e-01f, 7.62631297e-02f, 9.72654223e-02f, 3.85771692e-02f,
  6.83080927e-02f, 7.09698647e-02f, -3.42027806e-02f, -7.30270520e-02f, 5.40532218e-03f, 1.37054762e-02f, 1.36721889e-02f, 1.36369035e-01f, -2.49389894e-02f, 9.60189551e-02f,
  -8.78651738e-01f, 1.19657457e-01f, 1.68429583e-01f, -6.53980792e-01f, -8.43443535e-03f, 3.31827074e-01f, 4.06209618e-01f, 7.45849460e-02f, -2.29113474e-01f, 2.43030060e-02f,
  1.02986060e-01f, -2.89596051e-01f, -2.90452868e-01f, -2.54809931e-02f, -1.10198446e-02f, 1.70359150e-01f, 1.72520988e-02f, -1.58264190e-01f, -8.48470721e-04f, 1.71076134e-01f,
  3.44761834e-02f, -3.97443503e-01f, -3.82233918e-01f, -2.55503327e-01f, -2.80349880e-01f, -3.65383536e-01f, -2.62609601e-01f, -2.36044109e-01f, 1.60939381e-01f, -3.59877974e-01f,
  -2.83094019e-01f, -8.21495950e-02f, 8.55971426e-02f, -6.35615066e-02f, -1.32636830e-01f, -8.30273516e-03f, -1.40916601e-01f, -9.79283378e-02f, 5.13272593e-03f, 5.03516234e-02f,
  -1.73700392e-01f, 1.49749741e-01f, -2.02513412e-01f, 3.52762565e-02f, -1.63964152e-01f, 2.29955874e-02f, 8.95068273e-02f, 3.54810804e-03f, 8.65966305e-02f, 3.00325036e-01f,
  1.65107563e-01f, -1.01772696e-02f, 2.79790964e-02f, 2.82886803e-01f, 2.46156573e-01f, -2.84997467e-02f, 1.36880502e-01f, 1.67718634e-01f, 2.95476198e-01f, -1.87434912e-01f,
  1.25907408e-02f, -1.60402671e-01f, 1.13884602e-02f, 2.79929116e-02f, -9.80205834e-02f, 6.00367486e-02f, -1.34137675e-01f, -9.47566926e-02f, 4.23815437e-02f, -9.71381143e-02f,
  8.19678884e-03f, 1.68638721e-01f, 3.42617673e-03f, -4.13204245e-02f, -5.17398156e-02f, -2.13525631e-02f, -7.83934072e-02f, -7.03366995e-02f, 5.14100678e-03f, -2.33815666e-02f,
  1.40965618e-02f, 8.90058950e-02f, -5.32470569e-02f, 2.27244850e-02f, 1.91264108e-01f, -1.42077982e-01f, 5.63881807e-02f, 1.35202140e-01f, 2.43148860e-02f, 3.90305929e-02f,
  -6.31526232e-01f, 2.28704035e-01f, -2.97007650e-01f, -2.59481929e-02f, -1.30289849e-02f, 1.29314706e-01f, -4.31164391e-02f, 1.21059224e-01f, -1.08866736e-01f, -1.54807055e-02f,
  1.95471555e-01f, -1.88476264e-01f, -2.03341678e-01f, 1.52094662e-01f, 3.91560942e-02f, -6.84008598e-02f, 3.23865786e-02f, -9.16938558e-02f, 2.11157560e-01f, -1.37176346e-02f,
  1.42376617e-01f, 5.50949983e-02f, -2.86366880e-01f, -3.94555293e-02f, 8.13081414e-02f, -2.56605804e-01f, -1.96928725e-01f, -3.39304097e-02f, -7.60672763e-02f, -3.74271214e-01f,
  7.19607353e-01f, -2.60491699e-01f, -4.52746660e-01f, 1.61074907e-01f, -1.18157305e-01f, -3.30546908e-02f, -1.82649642e-02f, 1.84312478e-01f, 2.70772755e-01f, 3.15798679e-03f,
  3.57914686e-01f, 5.06367087e-01f, 3.80647779e-01f, 1.97913304e-01f, 2.65098810e-01f, -3.74668568e-01f, -4.24162835e-01f, -6.49385154e-02f, 2.30628997e-01f, 1.03205636e-01f,
  1.03856534e-01f, -3.20842266e-02f, 1.03852719e-01f, 1.56885937e-01f, -1.68665454e-01f, 6.76200688e-02f, -3.37875873e-01f, -3.11164826e-01f, -2.12350607e-01f, -6.99600816e-01f,
  -2.73189753e-01f, -1.05754875e-01f, 2.06800744e-01f, 4.84429449e-02f, -8.15965384e-02f, 2.73548942e-02f, 1.02732368e-01f, -6.65561780e-02f, 3.34372111e-02f, -1.02244439e-02f,
  -1.18511282e-01f, -8.60560220e-03f, 1.92652773e-02f, -8.06328282e-02f, -7.69328400e-02f, -8.72306377e-02f, -2.15417668e-01f, -2.43027881e-02f, 1.00472793e-01f, 5.00126705e-02f,
  4.57230210e-03f, -1.30183265e-01f, -1.53250456e-01f, -8.48088935e-02f, -3.88304889e-02f, -1.79533456e-02f, -1.55374715e-02f, -1.39829695e-01f, 1.68855470e-02f, -2.23693371e-01f,
  6.79722652e-02f, 6.79499507e-02f, 1.10773362e-01f, -2.00199541e-02f, 5.83363138e-02f, 7.67154694e-02f, -1.00209281e-01f, 2.21013706e-02f, -1.29096974e-02f, -8.63809139e-02f,
  -1.27250716e-01f, 8.39991644e-02f, 3.55566218e-02f, 6.41544610e-02f, 4.39106524e-02f, -6.00175634e-02f, -1.57523826e-01f, -6.04327731e-02f, 3.99262458e-02f, 2.24645883e-02f,
  9.77056324e-02f, -5.62775508e-02f, -1.65718943e-02f, 7.63710439e-02f, 3.05711664e-02f, 4.83024344e-02f, -3.44953872e-02f, 1.25682175e-01f, 7.74686411e-02f, -5.19609451e-02f,
  2.58824348e-01f, 2.91378796e-01f, -1.15920964e-03f, -4.97073196e-02f, -1.89146414e-01f, -1.02927014e-02f, 1.95018612e-02f, 5.16605750e-03f, -4.72609587e-02f, -7.44454982e-03f,
  4.80608903e-02f, 1.03654496e-01f, 4.54711616e-02f, -8.99222270e-02f, -5.84386438e-02f, 9.68624204e-02f, 1.12091415e-02f, 3.73852327e-02f, 1.04006954e-01f, -5.40193915e-02f,
  6.92293420e-02f, 2.82368460e-03f, 9.87834409e-02f, -1.76210492e-03f, 4.37690094e-02f, 1.49629608e-01f, -7.22780526e-02f, 6.87131062e-02f, 8.90430287e-02f, 3.76594476e-02f,
  5.77354312e-01f, -7.58241639e-02f, -9.01262462e-01f, 2.82226115e-01f, -4.46839780e-01f, -4.97975916e-01f, -2.73582280e-01f, 1.41545802e-01f, 3.39586735e-01f, 6.31031618e-02f,
  -1.70453742e-01f, -4.04964685e-02f, 4.32368778e-02f, -2.22990826e-01f, -4.11458135e-01f, -2.82425910e-01f, -3.19637448e-01f, -4.94996488e-01f, -6.81394458e-01f, -3.51241291e-01f,
  -1.10897258e-01f, 1.01283856e-01f, 1.22639686e-01f, -1.28572121e-01f, 1.33446023e-01f, -1.18562512e-01f, -1.86796948e-01f, -1.76586613e-01f, -4.53045905e-01f, -2.37899289e-01f,
  -6.35942101e-01f, -4.30694461e-01f, -2.89790452e-01f, 1.92002803e-01f, -1.82975709e-01f, 5.10980822e-02f, -2.21915781e-01f, 1.38241297e-03f, -6.81539159e-03f, -3.48442495e-02f,
  -1.67940810e-01f, -1.52029350e-01f, -2.94685394e-01f, -1.73344910e-01f, -8.62684995e-02f, -1.55673862e-01f, 6.77625388e-02f, -4.18025464e-01f, -3.14755023e-01f, -1.06426768e-01f,
  -8.03053081e-02f, -3.51145446e-01f, -4.70276773e-01f, -1.77153602e-01f, -2.60296136e-01f, -2.01545224e-01f, -2.93878913e-01f, -4.08559710e-01f, -4.10978168e-01f, 9.12948996e-02f,
  7.91077763e-02f, -6.04479834e-02f, -6.30133301e-02f, 1.27834573e-01f, 1.10216208e-01f, -1.46229416e-02f, -3.15008732e-03f, 9.36306827e-03f, -9.08851798e-04f, 7.88787752e-02f,
  7.57651851e-02f, 7.91632757e-03f, -1.89474151e-02f, -5.87744862e-02f, -9.02406350e-02f, -6.00443222e-02f, 7.23633543e-02f, 4.06353921e-02f, -1.07865125e-01f, -7.38311931e-02f,
  -6.72444403e-02f, -3.57551910e-02f, -3.28089073e-02f, 9.53024104e-02f, -1.00171544e-01f, -2.23364621e-01f, -4.68370318e-02f, 1.15003876e-01f, 1.05994247e-01f, 1.47549445e-02f,
  4.34703767e-01f, -3.60087067e-01f, 2.18751863e-01f, -3.23838927e-02f, -6.90834075e-02f, -4.46756632e-04f, 8.51606280e-02f, 7.61770755e-02f, -2.30915677e-02f, 1.49795562e-01f,
  -2.62531966e-01f, -3.37332375e-02f, -5.45275584e-02f, -2.59466879e-02f, 6.05785958e-02f, -4.90531884e-03f, 1.45706445e-01f, -2.50014782e-01f, -2.11541772e-01f, 2.40937307e-01f,
  3.81615788e-01f, 1.40179411e-01f, 1.59959003e-01f, 9.02703628e-02f, 1.86479002e-01f, 4.45929468e-02f, 1.79331601e-02f, -6.48876429e-02f, -5.77736758e-02f, 6.59471750e-01f,
  -8.77112225e-02f, 2.53340006e-01f, 1.86905608e-01f, 1.11161903e-01f, 2.44259220e-02f, -1.60587236e-01f, 1.56705692e-01f, -7.27967396e-02f, 7.82127827e-02f, 3.40727508e-01f,
  3.65751199e-02f, -4.78755206e-01f, -1.03823766e-01f, -2.58614540e-01f, -5.03703952e-01f, 1.26247823e-01f, -1.51564637e-02f, -4.08276081e-01f, -7.57223845e-01f, -5.89845359e-01f,
  -2.23956317e-01f, -1.14339702e-01f, -3.60819072e-01f, -2.49781728e-01f, 2.66848475e-01f, -7.86235705e-02f, 2.79852152e-01f, 3.21456306e-02f, -6.26695976e-02f, 3.43162626e-01f,
  1.03200704e-01f, 4.13993523e-02f, -1.81326792e-02f, -1.85951799e-01f, 2.03810055e-02f, -7.09327683e-02f, -1.15986884e-01f, 9.15862471e-02f, -1.37806490e-01f, -2.69437023e-02f,
  -1.44680262e-01f, -8.24282542e-02f, -2.27634057e-01f, -1.34472340e-01f, -3.36163193e-01f, -3.39571565e-01f, -3.02784536e-02f, -1.70822650e-01f, 1.63964313e-02f, -1.67466536e-01f,
  -2.61736810e-01f, -1.09213591e-01f, -1.87941547e-02f, 1.29592806e-01f, -6.46468177e-02f, -1.93729684e-01f, 9.48276073e-02f, -3.32213938e-02f, -2.58203372e-02f, 4.69011873e-01f,
  1.38695491e-02f, 3.50639364e-03f, -5.60137592e-02f, 4.79438566e-02f, 6.10507280e-02f, 1.20793721e-02f, -1.19551413e-01f, 1.92014370e-02f, -5.35150282e-02f, -4.81590210e-03f,
  -4.55315337e-02f, 1.53540447e-01f, 3.70117128e-02f, 1.60768762e-01f, 3.86191159e-02f, 3.32435742e-02f, -6.19645938e-02f, 1.13349780e-01f, 2.62821969e-02f, 2.53714155e-02f,
  -9.18048397e-02f, -4.28260453e-02f, 1.63395740e-02f, 1.38355428e-02f, 6.30958527e-02f, 4.00789157e-02f, -9.25452635e-02f, -6.39659027e-03f, 1.43275950e-02f, -1.14767542e-02f,
  2.03508645e-01f, -8.75678733e-02f, 1.18624091e-01f, -5.21334112e-02f, -2.48494539e-02f, 8.60059932e-02f, 5.12201637e-02f, 7.74797425e-02f, 1.02407701e-01f, -4.52043712e-02f,
  -3.21405083e-01f, 2.18170863e-02f, 4.38049994e-02f, -9.15174410e-02f, -1.35947123e-01f, -7.06709549e-02f, 5.01432233e-02f, 3.04354802e-02f, -2.34741587e-02f, 4.80753705e-02f,
  1.27832845e-01f, 1.55554876e-01f, 1.02292053e-01f, 2.27606043e-01f, -1.67391021e-02f, -7.96796381e-03f, 7.69484937e-02f, -3.68793681e-03f, -1.21186607e-01f, 4.45287585e-01f,
  7.50942707e-01f, -3.28944981e-01f, -3.83819729e-01f, 1.17536560e-01f, -2.09678859e-01f, -1.55449778e-01f, -3.85124773e-01f, 2.67657302e-02f, 1.41843230e-01f, -3.77701521e-01f,
  -2.96433307e-02f, 3.70357007e-01f, 1.27775699e-01f, 1.76498458e-01f, 3.20256770e-01f, -3.89887303e-01f, -3.18032503e-01f, 7.56635517e-02f, 5.13983011e-01f, 1.08007215e-01f,
  -1.04113370e-02f, 1.13606006e-01f, 2.88224667e-01f, 2.20735475e-01f, -3.39266747e-01f, 1.28307536e-01f, -3.75344604e-01f, -1.80994630e-01f, -1.89005047e-01f, -4.81636643e-01f,
  -1.72979638e-01f, -1.77010313e-01f, 1.21985450e-01f, 2.67511159e-01f, -1.34808272e-01f, 6.67172447e-02f, -8.52274671e-02f, -1.06780283e-01f, 7.89188668e-02f, -7.72943273e-02f,
  -1.98036224e-01f, 8.43696147e-02f, 7.65897557e-02f, -5.81130832e-02f, -1.20871067e-01f, -5.89928031e-02f, -8.37257248e-04f, 4.18250374e-02f, -2.35164035e-02f, -8.66618529e-02f,
  -1.37228236e-01f, -7.02387840e-02f, -4.62721959e-02f, -2.10139096e-01f, -1.98630951e-02f, 8.84274691e-02f, -3.44474047e-01f, -2.28819162e-01f, -5.71612120e-02f, -3.53195161e-01f,
  -1.94393434e-02f, -9.16787684e-02f, -5.11972196e-02f, -5.90036809e-03f, 5.12157120e-02f, -3.55189927e-02f, -4.64315563e-02f, 9.75802466e-02f, 7.59262964e-03f, 2.61744168e-02f,
  -2.24150363e-02f, 4.96234149e-02f, 2.24794820e-02f, -5.38005382e-02f, -5.85262179e-02f, -1.85741428e-02f, -4.51212898e-02f, -3.14281508e-02f, 2.58417968e-02f, -3.18664708e-03f,
  3.41423787e-02f, 9.65616032e-02f, -5.55152558e-02f, 8.44949707e-02f, 5.87697588e-02f, 4.05683517e-02f, 2.40352396e-02f, 8.33181012e-03f, 2.07227934e-02f, 1.83484722e-02f,
  1.33870468e-01f, 2.51810968e-01f, 8.64627771e-03f, 9.71192569e-02f, 5.79591505e-02f, -1.42782424e-02f, -6.68140501e-02f, -3.11750118e-02f, 9.81638059e-02f, -5.02815656e-02f,
  -8.49078372e-02f, 1.52043507e-01f, -9.89333466e-02f, -7.74829909e-02f, -2.23049354e-02f, -7.13546053e-02f, -2.32254043e-02f, 2.50684857e-01f, 1.60545379e-01f, -7.25309327e-02f,
  3.44746672e-02f, 2.73691118e-01f, 2.86320060e-01f, 1.51481941e-01f, 4.96938080e-03f, 2.26887167e-01f, -3.97227332e-02f, -1.09621026e-01f, 1.73074812e-01f, 7.50373378e-02f,
  -6.59391999e-01f, -3.46524537e-01f, 3.59058566e-02f, -1.10100053e-01f, 1.33838356e-02f, -1.48917928e-01f, -4.35541332e-01f, 3.05245090e-02f, 4.69433144e-04f, -4.53931898e-01f,
  -7.59483874e-02f, 2.14679554e-01f, -2.47267075e-03f, 7.38960654e-02f, -3.10784250e-01f, -5.75787544e-01f, -5.22392988e-01f, -2.07418740e-01f, 1.88296005e-01f, 1.77364737e-01f,
  -2.49163955e-02f, 6.24544732e-02f, 2.93762814e-02f, 1.11444511e-01f, -2.53685623e-01f, -1.07717305e-01f, -2.00186312e-01f, -1.75845832e-01f, -1.73171997e-01f, -4.35917646e-01f,
  -2.15975061e-01f, 1.93992898e-01f, 2.52105802e-01f, -4.55038399e-02f, -5.59546426e-03f, -1.12228759e-01f, -8.55642743e-03f, 6.29381165e-02f, 1.44496128e-01f, -1.68244794e-01f,
  2.77939346e-02f, 7.57725835e-02f, 1.56883910e-01f, 1.57679413e-02f, -1.65241286e-02f, -1.88787282e-02f, -1.67719573e-01f, -1.32071599e-01f, -1.51121065e-01f, -2.08240807e-01f,
  -2.26909086e-01f, -1.61473095e-01f, -3.20001155e-01f, -1.13909960e-01f, -4.04982492e-02f, 5.37538081e-02f, 9.98306721e-02f, 1.19006626e-01f, 6.45146072e-02f, -5.26952267e-01f,
  -2.90361904e-02f, 9.96154249e-02f, 5.41111715e-02f, -1.11890715e-02f, -9.38177630e-02f, -5.62619194e-02f, -5.36683798e-02f, -1.31716475e-01f, 2.08989810e-02f, -1.24342360e-01f,
  1.00598723e-01f, 4.96513098e-02f, -2.23496798e-02f, -6.18550107e-02f, 9.02952924e-02f, -8.84526148e-02f, -2.12084740e-01f, -1.77261949e-01f, 2.99115991e-03f, -6.35100380e-02f,
  3.49658839e-02f, 1.47220626e-01f, -1.20942350e-02f, -2.51364913e-02f, -2.38858253e-01f, -5.46170287e-02f, -3.66964564e-02f, 9.43339095e-02f, 1.18310444e-01f, -4.94605824e-02f,
  3.81181017e-02f, 2.16180801e-01f, -2.93282926e-01f, 1.81931742e-02f, -8.03723708e-02f, -1.71228290e-01f, -1.11729532e-01f, 6.11372404e-02f, -7.15031871e-04f, -9.71458033e-02f,
  1.24736942e-01f, -6.34707883e-02f, -1.26213804e-01f, 8.63058940e-02f, 8.25640038e-02f, -3.04361414e-02f, -4.26770478e-01f, -1.99150458e-01f, 1.13826141e-01f, 4.52113412e-02f,
  -2.62961954e-01f, -2.59710073e-01f, -2.96588302e-01f, -3.73923153e-01f, -2.21182972e-01f, -1.32653028e-01f, -4.78061289e-02f, 2.14764476e-02f, -1.77299544e-01f, -5.04942596e-01f,
  -2.44532481e-01f, -4.39565957e-01f, -4.45573479e-01f, -3.22163105e-01f, -2.83296436e-01f, -1.37137979e-01f, -4.57535237e-01f, 2.07670089e-02f, -3.42920236e-02f, -5.31220078e-01f,
  -3.65906030e-01f, 7.00046793e-02f, -1.42505184e-01f, -9.50396433e-02f, -1.80649310e-02f, -6.88586235e-01f, -5.56371391e-01f, -1.91216066e-01f, 2.05980659e-01f, 1.43660650e-01f,
  -2.26950012e-02f, -2.38623396e-01f, 1.14255615e-01f, 1.70652524e-01f, -2.54551083e-01f, -7.63615444e-02f, -4.27465975e-01f, -1.51960328e-01f, -1.40726894e-01f, -4.53573912e-01f,
  -3.56784642e-01f, 1.13351770e-01f, -1.11639686e-02f, 5.60456514e-02f, -2.03813642e-01f, 1.01797000e-01f, -5.51554002e-02f, -8.03840756e-02f, 1.28036410e-01f, -8.13681260e-02f,
  3.42622176e-02f, 7.17078224e-02f, 1.57135464e-02f, 1.84370447e-02f, -6.92800209e-02f, 3.93627547e-02f, -5.66812651e-03f, 2.40043998e-02f, -2.30772384e-02f, -1.25155702e-01f,
  -8.76201969e-03f, 3.05522103e-02f, -8.06742832e-02f, 1.30085751e-01f, 1.56977937e-01f, 1.77281186e-01f, 5.99176548e-02f, 2.40341827e-01f, 2.67305911e-01f, -5.89297861e-02f,
  6.42056251e-03f, -4.64652218e-02f, -1.00250401e-01f, 8.87019187e-02f, -1.35318320e-02f, 1.81699600e-02f, 6.06089272e-02f, -1.60351142e-01f, 6.31594807e-02f, -1.23672307e-01f,
  9.57321934e-03f, -5.14408760e-02f, 3.36912423e-02f, 9.70340148e-03f, -1.66003127e-02f, 1.38279619e-02f, 4.91644144e-02f, -3.29043828e-02f, 1.49944397e-02f, 3.85984108e-02f,
  -1.14708394e-02f, 4.48522195e-02f, -4.08096723e-02f, 7.45812654e-02f, -1.27404466e-01f, 2.84534376e-02f, 5.51473312e-02f, 5.31542562e-02f, -1.60796922e-02f, 1.04235038e-01f,
  -1.52704045e-01f, 2.86999848e-02f, -2.83065587e-01f, 2.72356756e-02f, -1.04956441e-01f, -5.76309450e-02f, -5.89813627e-02f, 1.74276922e-02f, 3.96712907e-02f, -9.17522311e-02f,
  -4.02696691e-02f, -4.58327197e-02f, -8.91404003e-02f, -3.43332849e-02f, -5.67555726e-02f, 2.77287047e-02f, -1.14048168e-01f, -1.06686383e-01f, 6.36273399e-02f, -9.68104005e-02f,
  -1.03344664e-01f, -3.60208899e-02f, -9.38660577e-02f, -9.10007302e-03f, 6.87050074e-02f, -6.10338673e-02f, -1.05082259e-01f, 1.41780645e-01f, -2.58881541e-04f, -2.21194342e-01f,
  -8.73961568e-01f, 7.27835000e-02f, -5.30360006e-02f, -2.60312885e-01f, 3.93751979e-01f, 3.02716374e-01f, 2.92003721e-01f, -1.08148977e-01f, -3.12670581e-02f, 8.04032758e-02f,
  1.99885756e-01f, 9.19646174e-02f, 2.34075174e-01f, 2.13620678e-01f, 5.80129251e-02f, 3.20151955e-01f, 5.04765630e-01f, -3.34662981e-02f, -1.25217676e-01f, -1.05005041e-01f,
  1.35010064e-01f, -1.89772785e-01f, -6.01771593e-01f, -6.78771883e-02f, 3.31872962e-02f, -2.92252526e-02f, 8.22452886e-04f, -1.39331967e-02f, 1.06201991e-01f, 1.53432414e-01f,
  -3.29095423e-01f, -5.40288389e-01f, 2.29454830e-01f, 1.83521271e-01f, 1.38998017e-01f, -2.21260652e-01f, -9.36928391e-02f, -2.18472928e-01f, 5.40183000e-02f, -1.03117146e-01f,
  7.93072395e-03f, -1.95285156e-01f, 1.91399455e-01f, -1.04578622e-01f, -4.01767641e-01f, -2.89991796e-01f, -5.50894737e-02f, -9.34601575e-02f, -1.45085573e-01f, -1.73222467e-01f,
  5.19516647e-01f, 1.48418352e-01f, -3.90444666e-01f, 6.58426881e-02f, -1.70758560e-01f, -1.28648281e-01f, -2.45413005e-01f, -3.46100569e-01f, -3.16765010e-01f, -5.95163524e-01f,
  1.00573368e-01f, -4.68356200e-02f, 9.37411934e-02f, -4.91890730e-03f, -4.79485467e-02f, 1.90761715e-01f, 5.21336794e-02f, 5.41118011e-02f, 6.02306686e-02f, -7.37538710e-02f,
  8.20413828e-02f, 4.67855018e-03f, -1.62817627e-01f, 4.25120350e-03f, 1.34148821e-01f, -3.54000553e-02f, -4.83524464e-02f, -1.28425248e-02f, 6.91504218e-03f, 4.44713272e-02f,
  -2.81876448e-04f, -6.34298921e-02f, 1.70944072e-02f, -1.15095727e-01f, 1.71404004e-01f, -3.19370590e-02f, -1.12108916e-01f, -2.45124754e-02f, -8.03244784e-02f, -8.94489288e-02f,
  -3.11697662e-01f, 4.22045708e-01f, -8.79930630e-02f, -1.34463888e-02f, -1.30802378e-01f, -1.59917679e-02f, -5.36665507e-02f, -2.64844839e-02f, -7.37034678e-02f, -2.43356407e-01f,
  -2.71601360e-02f, -1.55660197e-01f, 3.69884074e-02f, -1.16292816e-02f, -1.78152040e-01f, -9.69583243e-02f, 1.41863540e-01f, -3.97649519e-02f, -4.94482331e-02f, -2.38043722e-02f,
  -2.03399025e-02f, -1.30508944e-01f, -3.48905385e-01f, -2.42876727e-02f, -1.48032516e-01f, -2.28748754e-01f, -3.13533932e-01f, -4.09268886e-01f, -2.22062200e-01f, -4.92539048e-01f,
  -3.82676989e-01f, -4.22583342e-01f, -1.05826735e-01f, -6.60982355e-02f, -1.78972587e-01f, -5.94967008e-01f, -6.24041736e-01f, -4.10747081e-01f, -3.21034668e-03f, -2.00806201e-01f,
  -3.27141017e-01f, 9.50071216e-02f, 1.28119916e-01f, 3.37728262e-01f, 3.09713781e-01f, 2.62768835e-01f, 6.61216319e-01f, 5.47578990e-01f, 3.38836640e-01f, 1.86004862e-01f,
  2.09805191e-01f, 9.95299965e-02f, 2.23932460e-01f, 4.03256595e-01f, 2.69972473e-01f, 4.38180901e-02f, 3.31836306e-02f, 3.58029120e-02f, 4.13989164e-02f, 6.13344312e-01f,
  1.03154451e-01f, -2.73622453e-01f, 1.42082823e-02f, 8.05865601e-02f, 7.18338266e-02f, -3.98445735e-03f, 2.07086094e-03f, 8.39630589e-02f, 6.96001276e-02f, 8.84758905e-02f,
  4.05798815e-02f, 2.22816132e-02f, 9.84232351e-02f, 1.11462414e-01f, -1.05993105e-02f, -1.29688963e-01f, 1.39748037e-01f, 2.19043940e-01f, -2.36883480e-02f, -4.27623093e-02f,
  2.28528474e-02f, -3.81156690e-02f, -8.98673236e-02f, -1.40632868e-01f, -1.66153371e-01f, 6.79814816e-02f, -2.38829792e-01f, -3.21171656e-02f, -3.51727903e-01f, -1.73034891e-01f,
  1.47776082e-01f, 8.15197974e-02f, -1.27675086e-01f, 5.80168776e-02f, 1.21319599e-01f, -1.42734095e-01f, 1.59128726e-01f, 8.59714076e-02f, 6.03180975e-02f, 2.04471629e-02f,
  2.71316785e-02f, 6.66849688e-02f, 1.00589432e-01f, -2.16961540e-02f, 2.32493412e-02f, 1.20376535e-01f, 4.40789796e-02f, 1.34401947e-01f, 1.62174597e-01f, -7.54265636e-02f,
  1.12686390e-02f, -1.04837053e-01f, 3.48757915e-02f, 2.83312291e-01f, -1.46978348e-02f, 1.45054147e-01f, 7.43925944e-02f, -6.59019053e-02f, -1.61787137e-01f, -2.23504141e-01f,
  -4.06600893e-01f, -7.70218372e-02f, -3.71066877e-03f, 1.56275511e-01f, -5.45824096e-02f, -5.66798374e-02f, 7.43321255e-02f, 2.94765104e-02f, -4.42287289e-02f, -7.49720037e-02f,
  -2.60284275e-01f, -5.07714553e-03f, -1.68710664e-01f, 1.20828405e-01f, -1.68177634e-01f, -2.02316225e-01f, 1.68140993e-01f, 3.43675800e-02f, 7.73181841e-02f, 6.92822188e-02f,
  1.21138273e-02f, -1.97862849e-01f, -2.98839539e-01f, -3.10347229e-01f, -2.04993784e-01f, -1.61739901e-01f, -1.72734827e-01f, -4.08034593e-01f, -4.20995295e-01f, -5.92117071e-01f,
  6.55044377e-01f, -8.57258737e-01f, 3.71560603e-01f, 3.15947592e-01f, 1.90504879e-01f, 6.64505810e-02f, -3.10194105e-01f, 1.92697849e-02f, 2.39789709e-01f, -1.28223285e-01f,
  -3.11048388e-01f, -1.30267188e-01f, 5.34037054e-02f, -1.97024681e-02f, 1.12369861e-02f, -9.43715498e-02f, 2.36748800e-01f, 5.19817591e-01f, 5.23819506e-01f, 1.04995772e-01f,
  -3.23806889e-02f, -3.99427675e-02f, 2.37341374e-01f, 1.78317577e-01f, -2.60086089e-01f, 2.26126313e-01f, -4.86423112e-02f, -7.94852972e-02f, -1.95620060e-01f, -2.41417348e-01f,
  -1.29394412e-01f, -3.05400901e-02f, 3.35640222e-01f, -4.62082736e-02f, -2.91015506e-02f, 2.93553937e-02f, 1.60092637e-01f, -3.39864045e-02f, -1.23688623e-01f, -7.72532355e-03f,
  -3.69757116e-02f, -2.68139411e-02f, -1.07841752e-01f, -6.57952204e-02f, -1.13238150e-03f, -7.47647649e-03f, -1.69280693e-02f, -1.81113444e-02f, -1.09807931e-01f, -1.17681123e-01f,
  -1.54237732e-01f, 5.35459667e-02f, -8.11639149e-03f, 2.17103511e-02f, 7.79593503e-03f, 2.36941934e-01f, -6.29072860e-02f, 3.55319194e-02f, 1.03103824e-01f, 6.85403720e-02f,
  6.81762546e-02f, 6.61807251e-04f, -2.69386973e-02f, -1.27067389e-02f, 2.29199883e-02f, 7.91127831e-02f, 7.77421817e-02f, -3.05437744e-02f, 1.33503914e-01f, -6.87337890e-02f,
  -4.65954766e-02f, 5.92358783e-02f, 1.03916347e-01f, 4.55769077e-02f, 8.92754793e-02f, -1.17720082e-01f, 1.48362210e-02f, -2.74572838e-02f, -6.20278977e-02f, -1.07280694e-01f,
  -3.05393804e-02f, -5.91317452e-02f, -1.57691333e-02f, -6.08250462e-02f, -5.56949861e-02f, 4.14220467e-02f, 1.28336594e-01f, -1.46258742e-01f, 2.28023417e-02f, -8.28943923e-02f,
  -3.66557717e-01f, 3.08158219e-01f, 7.34151602e-02f, -1.88865632e-01f, 7.49344081e-02f, -6.06617741e-02f, 3.66410427e-02f, -5.90491816e-02f, -1.01104490e-01f, -2.21856590e-02f,
  -5.51117249e-02f, 8.28268304e-02f, -8.57925415e-02f, -1.62168935e-01f, 1.67466655e-01f, 2.16945767e-01f, -1.73685953e-01f, 4.67001237e-02f, -1.39789075e-01f, -1.18034378e-01f,
  -1.65468976e-01f, 1.55005351e-01f, 2.83644170e-01f, 2.03997716e-01f, 2.09255636e-01f, 3.42725456e-01f, 1.30001903e-01f, 8.50820215e-04f, 1.96444348e-01f, 8.49825367e-02f,
  1.73107013e-02f, 5.92383504e-01f, 2.91407436e-01f, 1.70094624e-01f, 3.34803402e-01f, 5.03744245e-01f, 6.18044794e-01f, 3.96746099e-01f, 5.21619990e-02f, 2.10975364e-01f,
  2.53415316e-01f, -1.00631796e-01f, 8.47983733e-02f, 2.20507979e-02f, 1.34924963e-01f, 3.11079293e-01f, 1.46370918e-01f, 1.47189423e-02f, -9.46246982e-02f, 5.82394339e-02f,
  -2.17822473e-02f, 1.24899954e-01f, 1.16484813e-01f, 8.29123855e-02f, -7.90176392e-02f, -1.14953578e-01f, 1.16792202e-01f, 3.33957851e-01f, 1.82555735e-01f, -2.10203424e-01f,
  -2.93943018e-01f, 3.48137140e-01f, -2.65451998e-01f, -1.72745466e-01f, 4.83233258e-02f, -4.95838597e-02f, -6.75004795e-02f, -6.77489713e-02f, 5.71314134e-02f, -5.89960814e-02f,
  -8.39231685e-02f, 2.65693683e-02f, 6.32820353e-02f, -6.14405163e-02f, 1.15641877e-01f, 5.80796525e-02f, -5.17059974e-02f, 1.81213439e-01f, 7.70716667e-02f, -6.68129027e-02f,
  -2.84290798e-02f, 1.82511434e-01f, 1.56675041e-01f, 6.04217798e-02f, 1.57870099e-01f, -4.95305546e-02f, 4.69917133e-02f, -3.85392196e-02f, 4.80204225e-02f, -9.77983624e-02f,
  7.12592434e-03f, 5.25155962e-02f, 6.16568439e-02f, -2.53051147e-02f, 5.76322107e-03f, -9.50381458e-02f, -5.51717989e-02f, 1.52999923e-01f, 1.44702997e-02f, -7.88980071e-03f,
  -2.15089531e-03f, 1.05175823e-01f, 6.49840757e-02f, 3.00950445e-02f, -1.30155414e-01f, 9.30119604e-02f, -3.56695168e-02f, 5.83236888e-02f, -8.21649563e-03f, 5.25171384e-02f,
  1.17766738e-01f, 3.01185232e-02f, -5.60528487e-02f, 7.05420226e-02f, -3.49110551e-02f, -3.40796970e-02f, 1.60735715e-02f, 1.19344242e-01f, 1.06654480e-01f, 3.18027958e-02f,
  -8.82159024e-02f, 2.88003713e-01f, -2.74355948e-01f, -1.12299696e-01f, 1.79594662e-02f, -1.94194615e-01f, 3.09751853e-02f, -6.64584786e-02f, -5.61078154e-02f, -1.11650877e-01f,
  5.20649254e-02f, -1.34920359e-01f, 1.49278775e-01f, -3.01716104e-02f, -1.05454952e-01f, -1.02936096e-01f, -7.38574192e-02f, -1.15719521e-02f, 1.01422273e-01f, -1.21826611e-01f,
  -1.51992869e-02f, -5.71647845e-02f, -1.14855044e-01f, -1.26590461e-01f, -4.85165305e-02f, -2.39947990e-01f, -1.62162408e-01f, -1.25684857e-01f, 2.74265856e-02f, -1.54862523e-01f,
  -7.50420690e-01f, -1.26035810e-01f, 9.75489840e-02f, -4.73396391e-01f, 4.54077555e-04f, 1.10128894e-01f, 2.60903895e-01f, -3.69157717e-02f, -1.44648820e-01f, -9.44546312e-02f,
  1.09380176e-02f, -1.44235760e-01f, -1.28306016e-01f, 3.52020077e-02f, -4.50919308e-02f, 8.31945688e-02f, -1.47298640e-02f, 5.33901341e-02f, 1.47323251e-01f, 7.49679282e-02f,
  -1.16580255e-01f, -2.08960980e-01f, -4.22623664e-01f, -2.49239832e-01f, -2.98041612e-01f, -1.39575392e-01f, -1.65293217e-01f, -1.89217344e-01f, -1.25824928e-01f, -3.95898312e-01f,
  7.63500690e-01f, -1.63799748e-01f, -5.05014211e-02f, -5.87660633e-02f, 2.66059935e-02f, -1.01559507e-02f, 1.38254717e-01f, 7.10368678e-02f, 9.70403552e-02f, 1.07344113e-01f,
  1.03225112e-01f, 9.35283378e-02f, 7.18362778e-02f, 1.37640471e-02f, 6.80667385e-02f, 5.91651127e-02f, 3.42010818e-02f, 9.42745954e-02f, 6.54187461e-04f, 4.58620228e-02f,
  1.25090733e-01f, 5.61182685e-02f, 3.20754141e-01f, 2.03094676e-01f, 4.82134223e-02f, 8.13513100e-02f, 7.02112447e-04f, -4.32638731e-03f, 3.76650095e-02f, -1.01051759e-02f,
  3.25649321e-01f, 1.84861407e-01f, 1.60411969e-01f, 1.53854921e-01f, 9.06998888e-02f, 1.30629167e-01f, 1.23519979e-01f, 1.58185586e-01f, 3.70769165e-02f, 1.90674849e-02f,
  1.46411464e-01f, 1.02383114e-01f, 9.30553228e-02f, 6.94019273e-02f, 2.94092633e-02f, 4.57247923e-04f, -4.82797511e-02f, 8.97183046e-02f, 3.77372503e-02f, -1.21312343e-01f,
  -7.43422518e-03f, 5.13044931e-02f, -8.82617459e-02f, 1.41338632e-01f, 1.29244439e-02f, 7.98814348e-04f, 6.72443062e-02f, 5.00579327e-02f, -5.11624254e-02f, -1.35085508e-01f,
  5.53305864e-01f, -2.22650333e-03f, 1.31623643e-02f, -1.42762557e-01f, -1.19654015e-01f, -8.93634856e-02f, -2.64598392e-02f, -2.08509583e-02f, 4.26816978e-02f, 1.25629634e-01f,
  3.36935148e-02f, -1.14733741e-01f, 1.38508379e-02f, 3.99983414e-02f, 8.31142291e-02f, -4.43199370e-03f, -1.15927622e-01f, -1.14283348e-02f, 9.73878279e-02f, 1.62617564e-01f,
  1.66807347e-03f, 1.29156232e-01f, 2.27407008e-01f, 1.90113813e-01f, -6.11464158e-02f, 1.96419045e-01f, 1.94240972e-01f, 9.00243968e-02f, 2.02616856e-01f, 1.24481954e-01f,
  -8.96832645e-01f, -2.49234885e-01f, 2.27058023e-01f, 1.51632056e-01f, 4.98922884e-01f, 4.18405026e-01f, 2.89931595e-01f, 1.67478815e-01f, 1.08977400e-01f, 2.39793379e-02f,
  -1.25610635e-01f, 1.48425475e-01f, 4.96868454e-02f, 1.74863160e-01f, 5.75683452e-02f, 3.22263688e-01f, 3.43922406e-01f, 1.66678518e-01f, 1.48957416e-01f, 3.03757012e-01f,
  2.97473490e-01f, 7.24960119e-02f, -2.15171263e-01f, 9.17198583e-02f, 1.99438170e-01f, 2.37604812e-01f, 1.75105169e-01f, 1.13306887e-01f, 9.18268934e-02f, 1.87315017e-01f,
  2.73452193e-01f, -3.65290582e-01f, -1.11868260e-02f, -1.60476103e-01f, -1.64289594e-01f, -1.90036669e-01f, -9.45260525e-02f, -1.53810382e-01f, -1.53824240e-01f, 3.79942283e-02f,
  -8.44833441e-03f, -5.70609123e-02f, 7.84107745e-02f, -9.03607383e-02f, -6.91688582e-02f, -1.59567386e-01f, -2.43660897e-01f, 6.46821782e-02f, 1.01952143e-01f, -2.26896834e-02f,
  -1.69253573e-01f, -6.95786849e-02f, 7.70721436e-02f, 8.37561563e-02f, -8.06553513e-02f, -1.74987633e-02f, -1.03479564e-01f, -5.35322726e-02f, -8.88280943e-02f, -1.24041475e-01f,
  6.33650646e-02f, -8.87288228e-02f, 5.20428792e-02f, 7.48716667e-02f, -3.45762558e-02f, 1.03916124e-01f, 7.28725269e-02f, 1.46458939e-01f, 1.04733706e-02f, -5.15731238e-02f,
  1.43697396e-01f, 1.07251376e-01f, 2.70629730e-02f, 6.30250722e-02f, -1.23991236e-01f, -1.38179541e-01f, -9.49490443e-02f, -9.58190262e-02f, -1.38784632e-01f, -1.07053131e-01f,
  -4.06043604e-02f, 1.28443921e-02f, -5.39049096e-02f, 5.63814975e-02f, -3.22320722e-02f, 9.14024096e-03f, -8.49969164e-02f, -9.38605219e-02f, -3.75142656e-02f, -3.37454230e-02f,
  3.97506535e-01f, -1.67532265e-01f, 1.74451426e-01f, 2.10522842e-02f, 5.38053699e-02f, -2.75476396e-01f, 9.19213444e-02f, 2.55216807e-02f, 1.30536556e-01f, 1.30947873e-01f,
  -1.08856753e-01f, -1.46295547e-01f, -1.24443449e-01f, -3.77922617e-02f, 8.81573483e-02f, -4.70487848e-02f, -7.14883879e-02f, 1.56502977e-01f, 4.25169580e-02f, -1.08928429e-02f,
  -1.36815488e-01f, 9.94102433e-02f, 1.48668766e-01f, 1.86398089e-01f, 1.23436026e-01f, 1.30180210e-01f, 1.53874040e-01f, 1.31701082e-01f, 1.41493797e-01f, 1.04298115e-01f,
  -2.07424432e-01f, 3.77881601e-02f, -3.16464871e-01f, 1.26631945e-01f, 4.17714745e-01f, -3.63878340e-01f, -6.85609639e-01f, -5.52328527e-01f, 2.87976056e-01f, 2.53669083e-01f,
  5.11258900e-01f, 5.54595411e-01f, 2.59834260e-01f, -6.01386465e-02f, -6.74230099e-01f, -3.79117757e-01f, -2.59067237e-01f, -5.80980539e-01f, -5.78201830e-01f, -2.05901682e-01f,
  2.52734214e-01f, -1.05731271e-01f, -4.06010330e-01f, -3.15885335e-01f, 3.71287465e-01f, 1.78471372e-01f, 1.25619218e-01f, 3.05013396e-02f, 1.77521035e-01f, 3.78966838e-01f,
  2.58316189e-01f, 2.27120835e-02f, 1.10277748e-02f, 3.07700127e-01f, 2.12502167e-01f, -3.83841842e-02f, -7.14333951e-02f, -2.31754139e-01f, 1.33767426e-01f, -2.51318552e-02f,
  3.65415961e-01f, 2.15197280e-01f, 2.91329533e-01f, 1.40395284e-01f, -1.95570700e-02f, -3.13683122e-01f, -2.98952341e-01f, -3.49094629e-01f, -3.77715528e-01f, -2.45424658e-01f,
  2.99410164e-01f, 7.51093253e-02f, -4.06798601e-01f, -3.32100093e-01f, -2.20900014e-01f, 1.00093588e-01f, -1.91953287e-01f, -2.06090584e-01f, -5.47049403e-01f, -3.50885808e-01f,
  3.11022010e-02f, 3.53018083e-02f, 1.33901149e-01f, 4.84395772e-03f, -4.15040776e-02f, 2.06962541e-01f, 2.57462431e-02f, 4.90613729e-02f, 2.65953830e-04f, -1.98115110e-01f,
  -2.03555566e-03f, 5.16041331e-02f, 6.99727535e-02f, -4.57865745e-02f, 3.40967849e-02f, 2.74780043e-03f, -1.05544746e-01f, -1.05937272e-01f, -1.82297885e-01f, 1.43732131e-01f,
  -3.99416080e-03f, 6.26821909e-03f, 1.43908814e-01f, -1.01168044e-01f, -8.31727125e-03f, -1.47337005e-01f, -2.21170802e-02f, -3.89029761e-03f, -1.78272381e-01f, 1.29325062e-01f,
  8.06487501e-02f, -1.96708262e-01f, 5.94022162e-02f, -1.50229692e-01f, -1.62344892e-02f, 9.10157487e-02f, 1.82793185e-01f, -1.03644766e-01f, 1.88145176e-01f, -3.45261842e-02f,
  -7.97215924e-02f, -7.63209164e-02f, 2.34362036e-01f, -6.19897526e-03f, -1.05243243e-01f, 2.18854830e-01f, -4.32281718e-02f, 2.40498912e-02f, -5.84025048e-02f, 7.75213465e-02f,
  -6.42354265e-02f, -4.05364692e-01f, -3.35250854e-01f, -1.95008263e-01f, 4.58527356e-02f, -4.70653102e-02f, -1.16989829e-01f, -1.70531318e-01f, -3.80985856e-01f, -5.15951633e-01f,
  -7.57319152e-01f, 1.51656149e-03f, 2.20623210e-01f, -8.21246743e-01f, -3.57718170e-01f, 9.50525403e-02f, 2.74946302e-01f, -1.65800765e-01f, -5.37572026e-01f, 5.06642014e-02f,
  3.69467467e-01f, 2.09067509e-01f, 7.09990263e-02f, 1.71872541e-01f, 2.66585052e-01f, 1.42220870e-01f, -2.51044124e-01f, -1.72164198e-02f, 3.01010281e-01f, 1.25429899e-01f,
  -5.97050637e-02f, -3.33528697e-01f, -3.87392670e-01f, -1.38920292e-01f, -4.43757266e-01f, 4.91303531e-03f, -2.50939608e-01f, -2.82064557e-01f, 3.81656736e-02f, -4.75500286e-01f,
  5.08849263e-01f, -4.24331218e-01f, 3.00736576e-02f, -1.41256198e-01f, 6.79877913e-03f, -4.85434830e-02f, 1.12154983e-01f, -2.60597706e-01f, 1.23090460e-04f, -7.24003315e-02f,
  -3.75910431e-01f, -5.08966409e-02f, -7.12709501e-02f, -5.46818376e-02f, -2.03101769e-01f, -3.17706764e-02f, -1.51256800e-01f, -1.67748511e-01f, -1.20220967e-01f, 2.22488362e-02f,
  -5.53720258e-03f, -2.12741971e-01f, -2.06757188e-02f, -1.58064086e-02f, -1.51287034e-01f, -5.55208931e-03f, 5.10278903e-02f, -1.19322054e-02f, 1.78300552e-02f, -8.32856819e-02f,
  -1.24362551e-01f, -3.07660270e-03f, 7.06598982e-02f, -1.04906142e-01f, 2.52759364e-02f, 4.12449129e-02f, -3.59599181e-02f, -2.70799361e-02f, -1.12196609e-01f, -3.68210860e-02f,
  -5.20659424e-02f, 6.54279068e-02f, -3.38260122e-02f, 5.63295512e-03f, -9.28578526e-02f, -1.60185829e-01f, 1.11046121e-01f, 1.12642482e-01f, -3.48063298e-02f, -1.13094032e-01f,
  -4.81430143e-02f, -8.48188028e-02f, -1.33649766e-01f, 2.07322836e-02f, 5.62386028e-03f, -1.49886861e-01f, -6.10238267e-03f, 8.61257985e-02f, -7.82501511e-03f, -9.67033301e-03f,
  2.28559837e-01f, 2.34354407e-01f, 1.61013231e-01f, -5.90430684e-02f, -1.40332818e-01f, 3.51437517e-02f, -1.22673497e-01f, 7.10160658e-02f, -1.77749440e-01f, -5.57877049e-02f,
  -3.20940316e-02f, 2.23765932e-02f, -8.56019109e-02f, 5.71952015e-02f, 5.20558991e-02f, 4.56163175e-02f, 1.32351726e-01f, -5.08048758e-02f, -7.60553256e-02f, -4.06812876e-03f,
  -1.06829807e-01f, -7.95085216e-05f, 2.32653484e-01f, 1.97111676e-03f, -8.06904361e-02f, 2.82527298e-01f, 3.73327434e-01f, 9.40196440e-02f, 3.27726901e-01f, 2.31995031e-01f,
  -2.17074364e-01f, -6.34727061e-01f, -2.59310693e-01f, -1.84019476e-01f, -5.06337225e-01f, -2.25028172e-01f, -5.43005407e-01f, -6.42995015e-02f, -1.14493310e-01f, -5.08747876e-01f,
  -3.76501858e-01f, 1.27285197e-01f, -1.66390121e-01f, 1.18277140e-01f, 2.32381746e-01f, -4.38485175e-01f, -2.91132212e-01f, 1.52669713e-01f, 3.20752800e-01f, -3.19362842e-02f,
  -2.26122439e-01f, 7.18844756e-02f, 3.63887578e-01f, 3.69908303e-01f, -4.38262910e-01f, -1.78104565e-01f, -4.46666330e-01f, -1.86627343e-01f, -3.62855971e-01f, -6.53504908e-01f,
  -2.73159355e-01f, -3.51936370e-01f, 1.01698019e-01f, -2.31274646e-02f, -1.59734666e-01f, 1.06647611e-01f, -8.55385736e-02f, 1.18499473e-01f, 9.03198794e-02f, -5.11338226e-02f,
  -2.63648361e-01f, -1.94767490e-01f, -2.55484395e-02f, -5.87746799e-02f, -3.94457653e-02f, -7.55377114e-02f, 1.09563217e-01f, -3.59709896e-02f, 2.15083193e-02f, -3.31027865e-01f,
  -2.50052541e-01f, -2.32073620e-01f, -1.35646284e-01f, 1.33520007e-01f, 3.31057645e-02f, 2.30611086e-01f, -2.06602290e-01f, -2.52841890e-01f, 1.65680815e-02f, -5.49475789e-01f,
  -3.46150436e-02f, 1.95069853e-02f, -1.02504842e-01f, 1.82010594e-03f, 1.99990235e-02f, -3.92878614e-02f, 8.76566619e-02f, 9.07632895e-03f, 3.05293761e-02f, 3.14214081e-02f,
  9.08579156e-02f, 6.73307553e-02f, 5.50761856e-02f, -6.11032322e-02f, -3.93742546e-02f, -5.05607612e-02f, 1.63808130e-02f, -1.09175667e-01f, 2.22650003e-02f, 9.55557916e-03f,
  -4.95383292e-02f, -1.41650736e-01f, -2.03015171e-02f, 7.49640614e-02f, -1.88821107e-01f, 1.57671620e-03f, -1.90471504e-02f, 1.21509060e-01f, -8.05690214e-02f, 4.20154519e-02f,
  2.32259277e-02f, 2.78318375e-01f, -2.64248401e-01f, -6.10429198e-02f, 1.38537586e-01f, 5.34624979e-02f, -1.37364626e-01f, 1.10952556e-01f, 9.06973034e-02f, -1.24614365e-01f,
  -1.80314556e-01f, -1.58677146e-01f, -5.01763262e-02f, 2.75979098e-03f, 3.56080011e-02f, -1.33266911e-01f, -1.22028463e-01f, -3.57046984e-02f, 1.92114681e-01f, 4.83680097e-03f,
  6.01144461e-03f, 5.45516005e-03f, 7.21651316e-02f, 4.22390141e-02f, -1.62399784e-01f, 2.39208434e-02f, -1.23175688e-01f, -1.67767331e-01f, 6.02325983e-02f, -1.79545686e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.61091310e-01f, 4.99230951e-01f, 6.52652442e-01f, 1.26646996e-01f, 1.32822514e-01f, 2.94981360e-01f, 6.30693018e-01f, 5.84695220e-01f, 3.80084544e-01f, 7.80326799e-02f,
  1.73192456e-01f, 2.36619830e-01f, 4.14941728e-01f, 3.45214397e-01f, 6.15842044e-01f, 2.57153839e-01f, 3.85916799e-01f, 1.00751622e-02f, 6.92541063e-01f, 3.70964289e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.41702136e-03f, -6.34368584e-02f, 1.79600909e-01f, 5.51789217e-02f, 6.06204495e-02f, 2.67067254e-02f, 2.30564401e-02f, -1.27449125e-01f, 3.37579399e-02f, -3.96535955e-02f,
  4.33043614e-02f, -8.83554146e-02f, -6.64405432e-03f, 7.43987113e-02f, -1.82718188e-01f, 6.56964779e-02f, 2.57435769e-01f, 3.25336576e-01f, -6.76341876e-02f, -8.06023479e-02f,
  2.68473327e-01f, 2.05109850e-01f, 1.63806573e-01f, 1.29089013e-01f, -3.04345757e-01f, 1.13943592e-01f, -3.37733775e-02f, 2.64541030e-01f, 1.58137456e-01f, -2.69900531e-01f,
  1.12844221e-01f, 1.52408956e-02f, 9.10811052e-02f, -7.74439350e-02f, -2.62658894e-01f, 1.77744016e-01f, -1.57302260e-01f, 8.07817802e-02f, -6.34895489e-02f, 9.66170579e-02f,
  -1.24423034e-01f, -1.63788512e-01f, -1.82010174e-01f, -1.84332713e-01f, 3.87881994e-02f, 2.82956719e-01f, -1.81732357e-01f, 3.49076949e-02f, 4.00604665e-01f, -1.95752278e-01f,
  -2.32944176e-01f, -6.21555932e-03f, -1.05793647e-01f, 2.75479853e-01f, 3.08236986e-01f, 1.38709128e-01f, 4.35676605e-01f, -1.33001581e-01f, -8.65910500e-02f, -2.06460431e-01f,
  -6.05704263e-02f, -2.53739148e-01f, 1.81683019e-01f, -1.01095341e-01f, 1.13841139e-01f, -8.44260827e-02f, -1.19275428e-01f, -1.05563458e-02f, -1.07850052e-01f, -1.06763532e-02f,
  2.12087855e-01f, 6.16769381e-02f, 4.70434465e-02f, 2.18394473e-02f, 1.20648474e-01f, 1.11733630e-01f, 1.76494598e-01f, 1.98541045e-01f, 8.20745081e-02f, 1.15307488e-01f,
  -1.99759185e-01f, 5.73466599e-01f, 1.09408706e-01f, -4.42588568e-01f, 3.27351004e-01f, -5.09146862e-02f, 1.50788128e-01f, -2.93687642e-01f, 1.65991515e-01f, 2.24775597e-01f,
  -2.14956731e-01f, -1.29820317e-01f, -3.48456502e-01f, -2.06218779e-01f, -8.47743154e-02f, 2.74602234e-01f, -1.56642497e-01f, 1.18237948e-02f, 8.85577872e-02f, 2.07171246e-01f,
  4.13993634e-02f, 1.92895651e-01f, -1.73942447e-02f, -1.95090726e-01f, 1.01445325e-01f, 1.85585693e-01f, -2.10401043e-02f, -7.01292157e-02f, -3.72725517e-01f, 1.14114180e-01f,
  1.29584670e-01f, 2.25740094e-02f, -4.95950803e-02f, 2.99501587e-02f, -4.48968671e-02f, 2.61506021e-01f, 2.09276125e-01f, -1.86871588e-01f, -1.81969196e-01f, -9.90186632e-03f,
  -1.27108008e-01f, -7.23741800e-02f, 3.10782999e-01f, 2.16411263e-01f, -3.61732990e-02f, -4.50282782e-01f, 1.76020876e-01f, 4.66223285e-02f, 1.66947935e-02f, -1.07604288e-01f,
  1.37465522e-02f, -6.88008443e-02f, -2.97738165e-02f, 9.53278095e-02f, 1.08412966e-01f, 7.48045966e-02f, 5.71717136e-02f, -2.43540421e-01f, -1.08340889e-01f, -2.53790140e-01f,
  1.97164714e-01f, 6.78365231e-02f, -7.83633962e-02f, 6.50436729e-02f, 7.65371993e-02f, -1.78174898e-01f, 1.56793997e-01f, 2.29237467e-01f, -4.27105486e-01f, 2.41940558e-01f,
  -1.84256416e-02f, -4.53267366e-01f, 2.40800500e-01f, -2.34913945e-01f, -3.12519401e-01f, -8.96980390e-02f, 5.46802431e-02f, 4.14223894e-02f, 4.75719050e-02f, 6.65238220e-03f,
  1.68629829e-02f, -1.13739602e-01f, -1.02565877e-01f, 3.35023776e-02f, -1.34623513e-01f, 3.92840290e-03f, 7.30897412e-02f, -1.59673691e-02f, 1.53388739e-01f, -4.22210172e-02f,
  2.08399996e-01f, 1.14956521e-03f, 1.11089893e-01f, 1.03630973e-02f, -3.80350649e-01f, 1.18664794e-01f, 3.38147432e-01f, 6.63680658e-02f, -1.67134032e-01f, -5.73704958e-01f,
  4.10324484e-01f, -4.91054654e-02f, 3.26887697e-01f, 1.14641197e-01f, 4.77407694e-01f, 1.39124393e-01f, -1.19582139e-01f, -1.76698163e-01f, 1.57288894e-01f, -3.31360251e-01f,
  2.99810201e-01f, 1.17383927e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.85066622e-02f, -1.80964302e-02f, 6.91373497e-02f, 2.97511935e-01f, -1.10669367e-01f, 3.24058205e-01f, -1.40893124e-02f, 7.98285455e-02f, 1.27134934e-01f, 7.21104220e-02f,
  -8.05708840e-02f, 4.67894338e-02f, -1.61873624e-01f, 5.60250103e-01f, 1.12250336e-01f, 2.72992522e-01f, 3.40908945e-01f, 2.68721372e-01f, 2.18888327e-01f, -4.47304189e-01f,
  4.97138232e-01f, 8.69311467e-02f, 1.03424758e-01f, -7.82046095e-03f, 4.03696120e-01f, 2.95484811e-01f, -3.24858308e-01f, 2.65962146e-02f, -4.50505227e-01f, -4.69881952e-01f,
  2.58012325e-01f, 4.53029543e-01f, 3.82007807e-01f, 1.65931389e-01f, 2.52387464e-01f, 2.62205396e-03f, 3.07267070e-01f, -1.96286291e-01f, 1.89047128e-01f, 3.29885669e-02f,
  -2.68152028e-01f, -5.26874185e-01f, 1.44079730e-01f, -5.30202270e-01f, 4.44675565e-01f, -1.20475501e-01f, 5.74993551e-01f, 4.48383391e-01f, -2.03688264e-01f, -6.57518208e-01f,
  2.69534260e-01f, 5.67741692e-01f, -1.23038158e-01f, 2.89779931e-01f, 1.75391749e-01f, -3.05868089e-01f, 6.26851141e-01f, -1.37317464e-01f, -2.75489926e-01f, -4.30296630e-01f,
  -1.40838295e-01f, 5.42962432e-01f, -4.70945150e-01f, 5.02916146e-03f, 4.61436123e-01f, 2.35956475e-01f, 5.87776482e-01f, -6.99674562e-02f, 1.69886008e-01f, -5.28923459e-02f,
  -1.21548794e-01f, -1.56133980e-01f, -1.95279643e-01f, 3.63973439e-01f, 4.81697246e-02f, 1.78940415e-01f, 2.76143372e-01f, -1.95438694e-02f, 4.19468194e-01f, -2.80461699e-01f,
  -4.47304770e-02f, -6.35496259e-01f, 3.48632246e-01f, 9.73022819e-01f, -8.82824287e-02f, -2.80763716e-01f, -1.24793842e-01f, -2.76968271e-01f, 2.97358125e-01f, 3.14181417e-01f,
  -2.48540670e-01f, 1.48768410e-01f, -2.89780144e-02f, 1.04287595e-01f, -2.75768012e-01f, -1.22293763e-01f, 4.34215426e-01f, 5.34901083e-01f, 4.15980637e-01f, 1.93307355e-01f,
  4.64712769e-01f, 1.28229827e-01f, 2.44067788e-01f, -3.74066472e-01f, -4.14057449e-02f, 1.00236155e-01f, 4.97081459e-01f, 1.81958959e-01f, 3.49395514e-01f, 7.95178339e-02f,
  6.34608448e-01f, -3.12085878e-02f, -3.29549551e-01f, 1.77920535e-01f, 1.85301170e-01f, -4.37321365e-01f, 8.00614774e-01f, 9.84441042e-02f, 3.67925256e-01f, -2.40893200e-01f,
  5.62942386e-01f, 5.19839883e-01f, -4.87912893e-01f, -5.55913225e-02f, -1.85995266e-01f, -6.50673956e-02f, -2.77276605e-01f, 2.26500764e-01f, -1.11188307e-01f, -7.67825618e-02f,
  -9.98798609e-02f, 1.33548588e-01f, 1.09402239e-01f, 7.08365142e-02f, 4.43091750e-01f, 1.90267995e-01f, 2.58948058e-01f, -2.88760811e-01f, -2.32434794e-02f, 7.66862258e-02f,
  -1.93216294e-01f, 3.46993841e-02f, -4.82997298e-01f, -1.41979173e-01f, -2.28394344e-01f, 2.54040122e-01f, 3.63708407e-01f, -2.73199588e-01f, 2.36522481e-01f, 2.97305614e-01f,
  1.52186245e-01f, -2.42241278e-01f, 4.88052182e-02f, -6.82013258e-02f, -3.58318090e-01f, 2.69631356e-01f, 4.50900793e-01f, 7.60338306e-02f, 3.88113081e-01f, 2.66307116e-01f,
  3.57763171e-01f, -1.62774786e-01f, 3.30934435e-01f, 9.58334804e-02f, 3.04188699e-01f, 5.97078316e-02f, 5.91086484e-02f, 5.98874509e-01f, 1.94851626e-02f, 3.84624004e-02f,
  -5.91317296e-01f, -3.89104635e-02f, -1.56522691e-01f, 4.62655067e-01f, -2.76316911e-01f, 6.84899930e-03f, 6.13686919e-01f, 2.95607924e-01f, 7.27752209e-01f, 7.80434132e-01f,
  -3.15744951e-02f, 2.91227810e-02f, 3.78288031e-01f, 3.23733717e-01f, -1.63580760e-01f, -3.55197698e-01f, -3.49989772e-01f, 3.18227977e-01f, -1.88924059e-01f, 6.71374083e-01f,
  4.86413091e-01f, 2.20212996e-01f, 4.36417192e-01f, 3.85188967e-01f, 2.29923517e-01f, 4.23834652e-01f, 4.52302247e-01f, 3.95305753e-01f, -1.30189300e-01f, -6.06900513e-01f,
  9.60700214e-02f, 2.21936628e-01f, 4.94382560e-01f, 1.13801338e-01f, 4.10528183e-01f, 5.46244681e-01f, 2.36103356e-01f, -3.35076898e-01f, -3.68310004e-01f, -1.00764390e-02f,
  1.05149209e-01f, -4.98013832e-02f, 7.69765556e-01f, -3.58879060e-01f, -1.80137411e-01f, -5.18239737e-01f, -4.57362175e-01f, 8.32316354e-02f, 5.33188581e-01f, 9.25966054e-02f,
  8.06904212e-02f, -5.90023339e-01f, 7.51514435e-01f, 3.51927847e-01f, 8.53559226e-02f, 4.57879752e-02f, -4.91593853e-02f, 3.64549577e-01f, 3.95042330e-01f, 2.45376602e-01f,
  2.10215941e-01f, 7.80548677e-02f, -1.31989822e-01f, 8.05411488e-02f, 3.11561644e-01f, 5.34481466e-01f, 4.80609164e-02f, 5.99060655e-01f, -4.95494045e-02f, 7.71385580e-02f,
  -2.84891307e-01f, 5.10277867e-01f, 3.58789235e-01f, -2.88138449e-01f, 6.37286365e-01f, 6.40779287e-02f, 3.63253713e-01f, -4.11341518e-01f, -3.15490097e-01f, -1.41343623e-01f,
  4.01090950e-01f, -2.44054541e-01f, -3.19427758e-01f, -1.93907052e-01f, -1.56956270e-01f, 2.85705596e-01f, 3.53997290e-01f, 4.96322602e-01f, 4.85602140e-01f, 3.33755255e-01f,
  5.56516945e-01f, 5.34882188e-01f, -5.70830405e-01f, 3.26918185e-01f, 1.52871519e-01f, 3.01050782e-01f, -4.17634904e-01f, -5.47549546e-01f, -2.71293879e-01f, -2.15701878e-01f,
  2.57427096e-01f, -2.99755782e-01f, 6.68790102e-01f, -2.80009449e-01f, -1.55292088e-02f, 5.33006191e-01f, 1.13239919e-03f, 1.02623880e-01f, -3.94323021e-02f, 8.24859619e-01f,
  1.89758316e-01f, -2.35903725e-01f, 3.85226220e-01f, -4.21792001e-01f, 8.55686050e-03f, 2.56750047e-01f, 9.64998901e-02f, 1.31227955e-01f, 2.70611525e-01f, 2.72241265e-01f,
  1.75646424e-01f, 7.78981820e-02f, -4.72504534e-02f, -2.97529995e-02f, 3.07846993e-01f, -7.54532591e-02f, 6.96487874e-02f, 2.53989428e-01f, 2.25603450e-02f, 3.21073830e-01f,
  1.70633420e-01f, -6.56637698e-02f, -1.47731736e-01f, 3.16529311e-02f, -5.54584444e-01f, 1.62320122e-01f, 3.38819325e-01f, 6.18630767e-01f, 2.42591545e-01f, -5.31018496e-01f,
  -2.40342021e-01f, 8.61509144e-03f, -2.96435446e-01f, 3.87418360e-01f, 4.24692295e-02f, -1.61075279e-01f, 5.26399434e-01f, -7.14413077e-02f, 1.58719361e-01f, 1.45422384e-01f,
  -1.59013584e-01f, 1.08241275e-01f, 7.66772777e-02f, 1.26765162e-01f, 1.34567335e-01f, 1.32971451e-01f, 9.56996679e-02f, -3.68383050e-01f, 4.69676793e-01f, 1.65552005e-01f,
  3.03213418e-01f, 3.31245005e-01f, 4.02390718e-01f, 2.36375809e-01f, -8.72651696e-01f, -4.24392194e-01f, 4.92972583e-01f, -1.38468491e-02f, -2.91795641e-01f, 3.52088995e-02f,
  3.97132188e-01f, 9.99423414e-02f, 9.75684747e-02f, 4.24399346e-01f, -4.89874661e-01f, 2.97108799e-01f, -1.86766852e-02f, 2.93746680e-01f, 5.32540858e-01f, -4.17600200e-02f,
  8.31370592e-01f, 1.06788278e-02f, 1.22084677e-01f, 2.39977881e-01f, -8.13606828e-02f, 4.23085660e-01f, 2.88590819e-01f, 2.65858620e-01f, -1.64483771e-01f, 2.80982442e-02f,
  -4.37846422e-01f, 1.56162426e-01f, -2.43869945e-01f, 1.25399441e-01f, -4.60039414e-02f, 2.98001140e-01f, 1.32120848e-01f, 3.46183171e-03f, 2.12114722e-01f, -5.70092678e-01f,
  1.81071553e-02f, 2.36292332e-01f, -7.31179655e-01f, -1.12782441e-01f, -1.66587204e-01f, 4.47559863e-01f, 2.60268033e-01f, -4.66255277e-01f, 1.42782465e-01f, 5.76020069e-02f,
  4.07685131e-01f, 7.05420256e-01f, -7.68815219e-01f, -8.25707197e-01f, 2.17930838e-01f, 6.71653599e-02f, 4.79484916e-01f, 1.96258113e-01f, 9.46378335e-02f, -1.57608896e-01f,
  2.78627515e-01f, 4.46750283e-01f, -9.06442776e-02f, 1.02674372e-01f, -2.93282419e-01f, 1.74583137e-01f, 3.89511943e-01f, -3.21069121e-01f, 3.30935478e-01f, 1.71159059e-01f,
  1.48425996e-01f, 4.05604243e-01f, 6.07672572e-01f, -1.80165380e-01f, 3.36124986e-01f, 3.65516007e-01f, 5.07975161e-01f, 4.57624704e-01f, 2.84695596e-01f, 2.57920086e-01f,
  -1.51597455e-01f, 2.37536490e-01f, 4.23026919e-01f, 7.43368030e-01f, -7.44126856e-01f, 2.62448490e-01f, 1.31633908e-01f, -7.34741762e-02f, -2.98061430e-01f, 3.34093273e-01f,
  8.95820633e-02f, -2.01670509e-02f, -3.80326897e-01f, -3.80216956e-01f, -3.11723083e-01f, -4.81906049e-02f, -3.46953124e-02f, 1.18112750e-01f, 6.24237992e-02f, 5.85328102e-01f,
  2.19015032e-01f, 1.98410258e-01f, 1.15203306e-01f, -1.04439922e-01f, -5.13765335e-01f, -4.15981174e-01f, -4.75283533e-01f, -4.99641538e-01f, -3.95105958e-01f, 3.62411708e-01f,
  5.73103249e-01f, 8.96709487e-02f, 1.11356631e-01f, -3.26324403e-01f, 2.67526180e-01f, -3.51130307e-01f, -3.63347143e-01f, -9.25966263e-01f, -1.37961060e-01f, 2.02155486e-01f,
  -2.15439484e-01f, 7.38311931e-02f, 1.86563134e-01f, 1.84023455e-01f, 4.00688201e-01f, -4.01332676e-01f, 2.10859865e-01f, -4.05379415e-01f, 1.94452181e-01f, -2.11593658e-01f,
  -6.28794432e-02f, 6.77768350e-01f, 1.62708417e-01f, 1.46039188e-01f, -2.17767239e-01f, 1.82338119e-01f, -1.30982369e-01f, -2.26224437e-02f, 3.17422181e-01f, 4.43701088e-01f,
  3.97262394e-01f, -5.43034136e-01f, 2.95575231e-01f, -5.52643463e-03f, -6.97380528e-02f, 4.78790812e-02f, -1.94745362e-01f, -4.19713110e-01f, 2.91807652e-01f, 4.13484544e-01f,
  3.21181715e-01f, 4.65722471e-01f, 3.39464396e-01f, 3.81484181e-01f, 5.19454360e-01f, 1.66330263e-01f, -2.04295460e-02f, 4.24324051e-02f, -1.48720533e-01f, -1.05236582e-01f,
  2.05736645e-02f, -1.67627066e-01f, -1.67302817e-01f, -1.12329252e-01f, 6.50586009e-01f, 2.98081581e-02f, 5.90879750e-03f, -1.12905828e-02f, 4.50030565e-01f, 7.94898510e-01f,
  -4.66664284e-01f, 2.78950371e-02f, -3.87382418e-01f, -4.29008931e-01f, 1.40852751e-02f, -7.50842810e-01f, 4.53493416e-01f, 4.17066038e-01f, -1.19987667e-01f, 4.35248107e-01f,
  4.52277005e-01f, -2.45423436e-01f, 2.26277560e-01f, 1.86969221e-01f, -2.18743365e-02f, 2.82681081e-02f, 6.76436201e-02f, 1.49126738e-01f, 9.40265227e-03f, -6.67331666e-02f,
  3.25485557e-01f, -2.61072665e-01f, -3.24494392e-01f, -3.85239244e-01f, -3.61549735e-01f, 1.49930775e-01f, -2.62606032e-02f, -9.38386992e-02f, 7.67700016e-01f, -2.96859685e-02f,
  -1.38366625e-01f, 2.65207708e-01f, 2.00557709e-01f, 6.97310150e-01f, 5.89545608e-01f, 3.87117416e-01f, 2.51900524e-01f, 1.18387260e-01f, -3.91813479e-02f, 4.39245880e-01f,
  -4.21839416e-01f, -8.82928148e-02f, -1.32635444e-01f, 6.15416706e-01f, 2.62834847e-01f, 2.71918979e-02f, 2.30220422e-01f, 2.11804956e-01f, 2.74655133e-01f, 3.13096493e-03f,
  3.66772920e-01f, 2.66570985e-01f, 1.98087946e-01f, -1.44445553e-01f, 2.37330422e-01f, 4.18884277e-01f, 3.92241687e-01f, 7.04135075e-02f, 4.31881249e-01f, 9.74621102e-02f,
  -7.05724180e-01f, 5.97197294e-01f, 6.82948887e-01f, -1.23908348e-01f, 4.85441267e-01f, -3.24612767e-01f, 1.00868471e-01f, -2.72850189e-02f, 6.71138242e-02f, 7.73987919e-02f,
  -1.66843966e-01f, -1.43445671e-01f, 1.57764345e-01f, 2.60513633e-01f, 8.49795863e-02f, 2.70694226e-01f, 2.54053295e-01f, 2.23889917e-01f, 3.73037696e-01f, 3.72462004e-01f,
  1.63590133e-01f, -9.64799747e-02f, -2.43313134e-01f, -7.44525120e-02f, 3.55533183e-01f, 2.89090008e-01f, -3.07685792e-01f, 2.38225758e-02f, 3.06451052e-01f, -3.86843234e-01f,
  -3.58086005e-02f, -6.14196539e-01f, 6.21506929e-01f, -2.98274040e-01f, -3.60830903e-01f, 1.10587934e-02f, -1.23171486e-01f, 2.47878358e-01f, -5.17898053e-02f, 8.22079062e-01f,
  5.43374836e-01f, 5.00631213e-01f, -1.45198762e-01f, 9.32724178e-02f, 3.43798369e-01f, 1.26247376e-01f, 6.94860637e-01f, 2.75364667e-01f, 1.94609940e-01f, -1.53562322e-01f,
  -2.95680128e-02f, 1.51644394e-01f, -7.92101026e-02f, 8.27596188e-02f, 2.44942799e-01f, 3.78193073e-02f, 3.09929140e-02f, 3.46317552e-02f, -1.00230090e-02f, -7.74561465e-02f,
  -1.50077417e-01f, 6.06112540e-01f, -5.20382822e-01f, -1.63655095e-02f, 7.92693913e-01f, -3.55199128e-02f, -1.13853261e-01f, -3.02404404e-01f, 1.80712119e-01f, 4.32399660e-01f,
  6.40612543e-01f, 4.30947483e-01f, -1.19015522e-01f, 1.20482735e-01f, 4.18092638e-01f, 1.42223850e-01f, 1.53404726e-02f, 2.20088571e-01f, 2.86665022e-01f, 3.09261531e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.00968527e-02f, 3.82186949e-01f, 6.38138592e-01f, 3.71509463e-01f, 6.63203606e-03f, 3.25327963e-01f, 3.16223055e-01f, 3.40208232e-01f, 2.78911799e-01f, 2.23056614e-01f,
  5.59638776e-02f, 3.36564332e-01f, 2.70297498e-01f, 4.91246998e-01f, 1.31390706e-01f, 8.15292776e-01f, 3.86078320e-02f, 2.10516393e-01f, 2.18697980e-01f, -1.33485168e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.21552461e-01f, -3.66140127e-01f, -5.54242194e-01f, -5.58775663e-01f, -2.82603174e-01f, -1.73807085e-01f, 1.52065888e-01f, 5.51390231e-01f, 3.29793453e-01f, -4.17715520e-01f,
  1.96465030e-01f, 4.48798656e-01f, 3.59767377e-01f, -1.64210767e-01f, -7.18088388e-01f, 1.35566324e-01f, 3.24848443e-01f, 1.26401514e-01f, -6.77369773e-01f, 3.24542075e-01f,
  -4.47027653e-01f, -6.42182171e-01f, -2.05513835e-01f, 5.67115694e-02f, 2.23025054e-01f, -6.89469934e-01f, 2.41988838e-01f, -5.76243401e-01f, 3.02062929e-01f, -1.18678488e-01f,
  -1.35522321e-01f, 2.25578800e-01f, -8.37531984e-01f, 4.20435160e-01f, -3.97305787e-01f, 2.15893015e-01f, -1.29392326e-01f, -6.32578611e-01f, 1.29729822e-01f, -3.54659766e-01f,
  -6.88950717e-02f, 2.15178087e-01f, -4.70708162e-01f, 4.91094708e-01f, 3.09991717e-01f, -4.65420306e-01f, -7.89418995e-01f, 3.24727356e-01f, 2.62051731e-01f, -1.26884624e-01f,
  2.84348965e-01f, 5.48451662e-01f, -1.13594735e+00f, 4.28661071e-02f, 4.89288792e-02f, -1.62797034e-01f, -8.40215944e-03f, 2.53088981e-01f, 3.66625726e-01f, -1.07030535e+00f,
  3.67412418e-02f, 1.81531951e-01f, -5.89412212e-01f, 2.74810120e-02f, 2.81276226e-01f, -1.33424148e-01f, -1.64121047e-01f, 1.97551325e-01f, -6.19628057e-02f, -1.43082350e-01f,
  -7.48807251e-01f, 2.45804265e-01f, 5.67022920e-01f, 3.92109454e-01f, -1.51272908e-01f, 4.49527651e-01f, 3.63071233e-01f, -5.65987937e-02f, -1.16000306e-02f, 4.48752195e-01f,
  -4.66669977e-01f, -7.63892710e-01f, -5.01666171e-03f, -2.42000580e-01f, 3.36741298e-01f, -2.78956205e-01f, -3.78656417e-01f, -9.16908085e-01f, 9.44061354e-02f, -5.11233389e-01f,
  2.17135713e-01f, -5.41156791e-02f, 2.34733716e-01f, -1.22740440e-01f, 5.56428790e-01f, -2.03664392e-01f, -2.47268155e-01f, -5.14134049e-01f, -1.04138032e-01f, 1.39857709e-01f,
  -6.68686330e-02f, -2.72377491e-01f, -7.14079663e-02f, 1.35493472e-01f, 6.68306649e-02f, -4.39092845e-01f, 9.51899588e-02f, 2.89678246e-01f, 1.42510697e-01f, -2.65433788e-01f,
  -5.17164823e-03f, -9.85507905e-01f, -2.48170033e-01f, 2.63705641e-01f, -3.88189703e-01f, -7.06754744e-01f, 3.43068421e-01f, -5.22855401e-01f, 3.83674681e-01f, -5.30593812e-01f,
  -2.25649580e-01f, -5.37848234e-01f, -8.18753600e-01f, -2.07046494e-01f, 1.87589809e-01f, -8.05543363e-01f, 5.57499647e-01f, 3.31015587e-01f, 5.42073369e-01f, 2.34076425e-01f,
  4.79341060e-01f, -2.44552806e-01f, -4.01219815e-01f, -1.18732542e-01f, 6.00884438e-01f, 4.78603423e-01f, -9.09677327e-01f, -2.35874921e-01f, 3.40439260e-01f, -7.50016510e-01f,
  -1.61495700e-01f, 3.24278086e-01f, 3.98377120e-01f, -7.34060943e-01f, -8.78101960e-02f, 3.03841710e-01f, -9.33425069e-01f, -3.14139515e-01f, -1.03390820e-01f, 1.12741783e-01f,
  -5.90268373e-01f, 3.67718637e-02f, 1.86825126e-01f, -1.87596649e-01f, 9.24465805e-02f, 2.93269873e-01f, 2.81329334e-01f, -1.21279418e-01f, -1.33418187e-01f, 9.90788490e-02f,
  4.54059392e-01f, -1.52047038e-01f, 2.40945682e-01f, 1.86485276e-01f, 9.25829411e-02f, 6.71994269e-01f, 5.71741402e-01f, -6.93028152e-01f, 8.39457154e-01f, 5.37591517e-01f,
  -8.09551850e-02f, -6.72703326e-01f, 2.16461420e-01f, -2.45244309e-01f, 3.65560651e-01f, -5.37859239e-02f, 4.99809384e-02f, 3.45505178e-01f, -2.54882202e-02f, 3.23851347e-01f,
  -3.11241359e-01f, 3.45735013e-01f, -6.73288941e-01f, -3.93231124e-01f, 1.84184045e-01f, -2.45022878e-01f, -3.20602417e-01f, 2.95318574e-01f, -2.03765079e-01f, 4.14477795e-01f,
  -8.03401530e-01f, -5.65891206e-01f, 1.70353949e-01f, -1.73430622e-01f, -1.52389541e-01f, 5.99210560e-01f, 4.55773205e-01f, 4.33453828e-01f, -3.13419253e-01f, 3.64436597e-01f,
  7.15711832e-01f, -6.33533448e-02f, 8.19610178e-01f, -9.88519043e-02f, 1.66594297e-01f, 5.21323383e-01f, 2.75980800e-01f, 1.87224314e-01f, -4.14595068e-01f, -6.36109650e-01f,
  -7.74656385e-02f, -1.86475873e-01f, -5.80540597e-01f, -1.38940215e-01f, -2.06481069e-01f, 6.83909431e-02f, -4.19154882e-01f, 4.34823424e-01f, 4.32013422e-01f, 5.58971055e-02f,
  -8.37089062e-01f, -5.69588616e-02f, -1.13457513e+00f, -4.90671217e-01f, -1.50612071e-01f, -4.33054924e-01f, -3.99236411e-01f, -2.48456281e-02f, -2.58872598e-01f, -8.51567388e-02f,
  -3.62105161e-01f, 6.36483803e-02f, -2.51720965e-01f, -4.47790101e-02f, -2.19214335e-01f, 5.22480607e-01f, -6.13204062e-01f, -3.93470317e-01f, -5.74185610e-01f, -5.26234150e-01f,
  9.18276310e-02f, -1.76974550e-01f, -6.82923317e-01f, -3.62998039e-01f, 4.02696073e-01f, 8.31667520e-03f, 1.74798816e-01f, 6.69639826e-01f, 1.63905665e-01f, 3.82648736e-01f,
  -3.70224744e-01f, -4.73330677e-01f, -2.60883272e-01f, -1.18509077e-01f, 4.13895965e-01f, -1.64085217e-02f, -3.54194418e-02f, 1.68924406e-01f, 3.88446242e-01f, 3.57629210e-01f,
  -1.74912602e-01f, 2.00406715e-01f, 2.89939761e-01f, -4.50890154e-01f, 2.55013049e-01f, 2.63349228e-02f, -3.89135003e-01f, -7.92909265e-02f, -4.37972844e-01f, -6.01298332e-01f,
  9.11606014e-01f, 3.85305673e-01f, -1.56673521e-01f, -8.03903818e-01f, 4.45157558e-01f, -5.68138182e-01f, -2.47587085e-01f, 3.94901365e-01f, 4.87490535e-01f, -2.61548311e-01f,
  -9.68213081e-02f, -2.02155814e-01f, -6.02315366e-01f, -8.00059021e-01f, -4.81858134e-01f, -5.24136312e-02f, 7.78842449e-01f, -1.55391619e-01f, -6.25043988e-01f, 3.73639375e-01f,
  6.05448842e-01f, -4.37823646e-02f, 2.55889833e-01f, -3.52450937e-01f, 2.66367085e-02f, -3.57060134e-01f, 1.53807834e-01f, -7.60835052e-01f, 4.05863523e-01f, -1.36515751e-01f,
  -5.49347878e-01f, 4.96212244e-01f, 2.35571653e-01f, 4.10971195e-01f, -6.67368770e-01f, -2.41647840e-01f, -8.86544108e-01f, -8.74150813e-01f, 1.35052800e-01f, -2.69279897e-01f,
  -2.04492450e-01f, 1.06989369e-01f, 4.88919884e-01f, -2.10451007e-01f, -7.16435492e-01f, 2.46234521e-01f, -5.90500712e-01f, 2.82220006e-01f, -1.81552410e-01f, -7.87575424e-01f,
  5.67490235e-02f, 3.61702830e-01f, -3.11229348e-01f, -2.09287494e-01f, -1.11473701e-03f, 2.20117807e-01f, 3.88889730e-01f, -6.28137514e-02f, -3.47225398e-01f, 8.94944295e-02f,
  7.47516274e-01f, 6.34146258e-02f, -4.37555492e-01f, -3.89956266e-01f, -5.49205422e-01f, -8.75965536e-01f, 6.88818216e-01f, 1.93212152e-01f, 2.34921455e-01f, -3.85469377e-01f,
  -6.64640784e-01f, 1.05085112e-01f, 5.89985192e-01f, -6.88308775e-01f, -9.78941679e-01f, -5.52235484e-01f, 3.26145887e-01f, 3.51227731e-01f, -3.85804206e-01f, -8.63744784e-03f,
  2.76851565e-01f, -2.78968930e-01f, 2.63497353e-01f, 4.93418247e-01f, 8.82813632e-02f, -4.34921086e-01f, 2.81647265e-01f, 7.63210729e-02f, -1.14508299e-02f, 2.20907629e-01f,
  -7.19901264e-01f, 5.47936201e-01f, -6.88845336e-01f, -5.71838558e-01f, -6.46773398e-01f, -4.60437715e-01f, -1.06192261e-01f, -3.92895103e-01f, -6.28027320e-01f, -2.83390135e-01f,
  5.69739163e-01f, 4.52319235e-01f, 4.72179681e-01f, -3.25220376e-01f, -1.70727849e-01f, 3.25262100e-01f, -6.30110383e-01f, 1.09695487e-01f, -2.22807288e-01f, 6.92133546e-01f,
  -8.66452754e-02f, -4.60111976e-01f, -6.00399673e-01f, 9.06977728e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.89643341e-01f, -2.08385468e-01f, 2.44587153e-01f, -8.77319947e-02f, 1.84966058e-01f, 2.08444789e-01f, 1.60346657e-01f, -7.42998719e-02f, -9.96817872e-02f, 1.43713206e-01f,
  8.15346912e-02f, 1.89260229e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    