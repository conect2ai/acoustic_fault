/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.79179537e-02f, -1.48192421e-01f, -6.36954367e-01f, -1.00974597e-01f, 2.23406687e-01f, 1.92146620e-03f, -2.44941503e-01f, 1.23882040e-01f, 9.52554196e-02f, 2.25729570e-01f,
  1.23111606e-01f, -2.20384806e-01f, -1.45666942e-03f, 2.78884191e-02f, -1.74946055e-01f, -4.79948483e-02f, 1.54643655e-01f, -2.11687060e-03f, -8.76885280e-02f, 7.96362758e-02f,
  -2.54343264e-02f, 2.91590989e-01f, -2.65211552e-01f, 1.99950323e-01f, -6.43137246e-02f, -1.59403041e-01f, 1.46465927e-01f, -1.04294762e-01f, 7.78706297e-02f, -1.97375547e-02f,
  -1.32460251e-01f, 2.01474614e-02f, -1.07537411e-01f, -7.86642432e-02f, 9.33279470e-03f, 1.51658366e-02f, -4.45214733e-02f, -1.13827832e-01f, -6.13236539e-02f, 1.28344269e-02f,
  -3.50053906e-02f, 2.12221388e-02f, 5.86501248e-02f, 3.53495330e-02f, 8.38161111e-02f, -1.07267732e-02f, 2.48127859e-02f, -2.11884808e-02f, -1.94783900e-02f, -4.89886180e-02f,
  -5.51060177e-02f, -2.65328661e-02f, 1.26661384e-03f, 2.19771229e-02f, -5.83209842e-02f, -1.86537988e-02f, -3.58762257e-02f, -1.09161787e-01f, 3.69916931e-02f, 7.47214258e-02f,
  1.54462174e-01f, 6.86657578e-02f, 8.13039765e-03f, -6.31889794e-03f, -1.61936954e-02f, -2.73153074e-02f, 6.14738092e-02f, 3.20462026e-02f, -5.02387807e-02f, 2.87603494e-02f,
  7.30578508e-03f, -9.45938192e-03f, 6.11476563e-02f, 1.19402790e-02f, 6.46457970e-02f, 1.38389124e-02f, -6.71742409e-02f, 8.98934249e-03f, 1.80144713e-03f, -7.61027709e-02f,
  -1.51300626e-02f, 2.83143185e-02f, 1.52095482e-02f, 5.22915907e-02f, -7.92023318e-04f, -2.47181058e-02f, 4.68473546e-02f, -3.21381493e-03f, 2.80310330e-03f, -8.72959755e-03f,
  1.46146402e-01f, 2.27738649e-01f, -2.08330732e-02f, 1.48368496e-02f, -3.84286009e-02f, 8.08500946e-02f, 2.33496353e-02f, 4.50155325e-02f, 4.82313447e-02f, 3.15306038e-02f,
  6.59838617e-02f, 6.57017715e-03f, -1.81344561e-02f, 7.32240081e-03f, -8.54758695e-02f, 6.79223984e-02f, 4.05996516e-02f, 2.70978659e-02f, 4.53908145e-02f, 6.02250285e-02f,
  2.04105629e-03f, 6.04014061e-02f, -9.67095569e-02f, 2.51681134e-02f, 5.57428263e-02f, -9.75001324e-03f, 1.84261776e-03f, -1.97463240e-02f, 5.36088794e-02f, 5.14875678e-03f,
  9.92944092e-03f, 4.49611485e-01f, -1.30451426e-01f, -3.78822796e-02f, -2.53872965e-02f, -7.50345439e-02f, 5.68738692e-02f, 6.25148118e-02f, 1.74503550e-01f, 4.13939267e-01f,
  -3.19920070e-02f, 1.07824974e-01f, 3.30300666e-02f, 6.32650852e-02f, -5.98139107e-01f, 7.72741511e-02f, -7.46011660e-02f, 3.36657427e-02f, -1.64849181e-02f, -2.96661202e-02f,
  -9.06339809e-02f, -8.30268785e-02f, -2.81509310e-01f, -4.50009629e-02f, -3.30092236e-02f, 1.78608447e-02f, -2.64128268e-01f, -1.16201557e-01f, -5.49852587e-02f, -2.43323036e-02f,
  7.40148500e-02f, 2.82562941e-01f, 6.92330152e-02f, 3.38931642e-02f, -5.40495366e-02f, -3.11798044e-02f, -7.13724345e-02f, -2.39746887e-02f, -7.84373954e-02f, 3.92765291e-02f,
  -3.47605790e-03f, -1.37121957e-02f, 3.27483788e-02f, -4.12866175e-02f, 8.46401080e-02f, 8.11106712e-02f, -1.67791415e-02f, -5.37578650e-02f, 3.33032273e-02f, 2.90561039e-02f,
  4.83376384e-02f, 2.40949094e-02f, -6.90651387e-02f, -2.04077177e-03f, -5.77622950e-02f, 1.20261637e-02f, -2.34054588e-02f, -2.40160301e-02f, 1.02115445e-01f, 5.19807152e-02f,
  8.01593214e-02f, -5.23998477e-02f, -1.93423592e-02f, 2.05758773e-02f, -2.22658031e-02f, -1.00170961e-03f, -2.79151611e-02f, -5.39145432e-03f, -5.08945668e-04f, 2.06863135e-02f,
  -2.99648382e-02f, 2.81529352e-02f, 7.16886716e-03f, 1.08255539e-02f, -2.42504887e-02f, 4.11115289e-02f, -6.66624010e-02f, 9.09143984e-02f, -1.23145096e-02f, -4.24793437e-02f,
  -9.62892268e-03f, -2.45729536e-02f, 1.14663113e-02f, -3.08907051e-02f, 8.13109160e-04f, -1.48919364e-02f, 1.40508013e-02f, 7.84619004e-02f, -7.65907988e-02f, -1.06577650e-01f,
  -4.19860631e-02f, -7.15469569e-02f, -1.67109072e-02f, 4.39786129e-02f, 3.53708789e-02f, 9.74217802e-03f, -2.15489957e-02f, 1.68070272e-02f, -1.60282534e-02f, -5.33725172e-02f,
  1.77713018e-02f, -3.43376510e-02f, -3.44650634e-02f, -3.34297679e-02f, -1.30555481e-01f, 5.28951501e-03f, -4.99067493e-02f, -4.96961027e-02f, -1.29300728e-01f, -1.61931384e-03f,
  -6.01540990e-02f, -3.02565638e-02f, 2.37796064e-02f, -4.56085727e-02f, -3.10400166e-02f, -1.99542418e-02f, -2.46713925e-02f, 6.60649911e-02f, -4.24974412e-02f, -8.99790507e-03f,
  5.47583580e-01f, 9.71302912e-02f, -7.45229051e-02f, 2.03305095e-01f, 1.61952093e-01f, 2.64493555e-01f, 1.47706240e-01f, 1.47496939e-01f, 9.97545645e-02f, 2.48519927e-02f,
  9.12584215e-02f, -4.75980975e-02f, -1.89809024e-01f, 3.42921734e-01f, -2.16543466e-01f, -2.34529004e-01f, 2.39444956e-01f, 9.45449695e-02f, 2.65653487e-02f, 4.00260724e-02f,
  5.05575500e-02f, 1.58926427e-01f, -2.46871728e-02f, 1.64735392e-02f, 2.32943654e-01f, -3.33644636e-02f, -2.32130066e-01f, -1.65467829e-01f, 1.18555121e-01f, 1.99669208e-02f,
  3.40675354e-01f, 5.08967414e-02f, 2.23777406e-02f, -6.29576072e-02f, 7.40191042e-02f, 2.50623282e-02f, -2.34918594e-02f, -6.04014993e-02f, 5.53961657e-02f, 2.07764469e-02f,
  -3.06876842e-02f, 7.29724416e-04f, 7.38104433e-02f, -6.45059198e-02f, 1.25850633e-01f, 2.40864437e-02f, 3.76596153e-02f, 9.58991200e-02f, -1.20794959e-02f, 6.62466362e-02f,
  4.80803363e-02f, 7.75614381e-02f, 8.69740546e-02f, -3.37380320e-02f, -3.68290618e-02f, 1.66438576e-02f, -1.81950647e-02f, -4.02897820e-02f, -1.24220308e-02f, 4.84484471e-02f,
  -4.58542816e-02f, -5.54908477e-02f, -1.75622739e-02f, 4.71649729e-02f, 3.03303879e-02f, 2.23699417e-02f, 1.10617653e-02f, -1.39634199e-02f, -4.66326438e-02f, -7.23659713e-03f,
  2.17291396e-02f, 2.88323201e-02f, 3.33083384e-02f, 4.30840859e-03f, 4.68721576e-02f, 2.72706971e-02f, -5.23526967e-03f, -5.15956357e-02f, 8.75193179e-02f, 4.33022305e-02f,
  -3.63082662e-02f, 2.50670593e-03f, -1.15476279e-02f, -8.57775507e-04f, 4.07535918e-02f, -1.02318777e-02f, -1.84610281e-02f, -2.30282024e-02f, -2.44793110e-02f, -1.29037229e-02f,
  -2.22494796e-01f, -4.14561808e-01f, -6.18401095e-02f, 1.91624779e-02f, -7.62052387e-02f, 4.26028948e-03f, -1.23052001e-02f, 4.97109164e-03f, -6.90230057e-02f, 2.19982099e-02f,
  3.43845524e-02f, -2.35961541e-03f, -2.30589323e-02f, 6.22461289e-02f, -1.40779829e-02f, 3.99240619e-03f, -8.44114348e-02f, -6.85564205e-02f, -3.26446407e-02f, -2.56720912e-02f,
  -3.17132734e-02f, -3.71419117e-02f, -3.21629457e-02f, 4.78661582e-02f, 1.17966542e-02f, -2.77632056e-03f, 1.22714331e-02f, -2.60056108e-02f, -5.59004508e-02f, -3.12827043e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.22791010e-01f, -5.51456928e-01f, -5.71514249e-01f, -2.89530426e-01f, 3.91451716e-01f, 5.76414764e-01f, 3.02105457e-01f, -2.76404113e-01f, -8.05695474e-01f, 1.91369578e-02f,
  3.83453757e-01f, -2.83145849e-02f, 3.49132717e-02f, 8.49966034e-02f, 3.38684827e-01f, -1.47613078e-01f, 1.09924182e-01f, 2.02624395e-01f, -3.34087104e-01f, -2.56756563e-02f,
  -9.85112041e-02f, 3.90381545e-01f, -1.93029642e-01f, -6.15046639e-03f, 2.37166598e-01f, -2.23822698e-01f, 3.07302713e-01f, 8.20200220e-02f, 3.27622712e-01f, 3.83368820e-01f,
  1.36057120e-02f, -2.31435984e-01f, -6.50181770e-02f, -1.53074905e-01f, 3.61401960e-02f, 1.56121373e-01f, 1.20267071e-01f, 2.29972884e-01f, -1.00703873e-01f, -5.62755267e-05f,
  1.32577091e-01f, 1.07176788e-02f, -1.98673513e-02f, 4.53343540e-02f, -3.68782356e-02f, -9.70402732e-02f, -1.01231553e-01f, -1.60988972e-01f, -1.37461111e-01f, 4.30431664e-02f,
  -1.28078669e-01f, -4.26997244e-03f, -4.09937948e-02f, -2.47529522e-02f, -7.36878887e-02f, -2.13212594e-02f, -5.08282408e-02f, 1.39155313e-01f, -4.03251499e-02f, 3.88027006e-03f,
  9.18668434e-02f, 1.03300877e-01f, 9.77351293e-02f, -2.75097843e-02f, 7.67455623e-02f, -2.53911894e-02f, 5.21434918e-02f, 3.00730523e-02f, -9.32295024e-02f, 7.79555440e-02f,
  -5.87018058e-02f, 8.05531070e-03f, -1.84329282e-02f, 5.19219600e-02f, 1.27328753e-01f, -6.24010079e-02f, 6.97427988e-02f, 7.44926631e-02f, -1.01751901e-01f, -6.65337741e-02f,
  -4.45350409e-02f, 2.31117681e-02f, 3.56548019e-02f, 2.30109878e-02f, -3.60516272e-02f, 4.40276302e-02f, 4.72193621e-02f, 2.98702694e-03f, -7.82541558e-02f, 7.65408576e-02f,
  1.61693953e-02f, -5.68324961e-02f, -1.54963449e-01f, 2.27057394e-02f, -7.31802881e-02f, 1.26647726e-01f, -4.70186658e-02f, -7.45438188e-02f, 2.54191719e-02f, -5.18098436e-02f,
  4.40773480e-02f, -3.01062949e-02f, 5.34679554e-02f, 3.33071649e-02f, -4.48089242e-02f, 8.58951584e-02f, 5.15631284e-04f, -1.29356263e-02f, 2.16723680e-02f, -3.19594168e-03f,
  5.51584288e-02f, 1.05335176e-01f, 6.13014027e-03f, -9.21232030e-02f, 2.98812296e-02f, 2.23207865e-02f, 1.71233509e-02f, -2.54151076e-02f, 7.44504035e-02f, -8.38605687e-02f,
  -5.55384830e-02f, 3.68797541e-01f, 1.93257451e-01f, 6.42724335e-02f, 4.49251458e-02f, -4.60298538e-01f, -2.20179304e-01f, 5.84309809e-02f, -1.11676671e-01f, 2.79211402e-01f,
  -9.34758335e-02f, 3.40940177e-01f, -1.51357427e-01f, -2.91819900e-01f, -1.03379095e+00f, -6.66633904e-01f, -4.02846813e-01f, -1.21443406e-01f, -2.47795954e-01f, 1.56723410e-01f,
  -1.69268474e-01f, -3.49462241e-01f, -1.08159199e-01f, 1.92255810e-01f, 3.26125294e-01f, 5.27887464e-01f, 2.42056876e-01f, 2.28382930e-01f, 2.99111724e-01f, -1.46203443e-01f,
  -1.77997962e-01f, -2.34235674e-02f, 1.99341491e-01f, -9.93814245e-02f, 3.28616844e-03f, 1.03894956e-01f, 1.33242741e-01f, -8.83147195e-02f, -2.77080312e-02f, 2.76079141e-02f,
  1.94427460e-01f, 2.97072437e-02f, 1.39623433e-02f, -6.39608428e-02f, 1.22313797e-01f, 7.58749619e-02f, 6.32410422e-02f, 1.10973425e-01f, 9.92582887e-02f, 9.78880301e-02f,
  1.27593651e-01f, 5.67396656e-02f, 1.13807969e-01f, 1.42093012e-02f, -2.43616309e-02f, -3.92763801e-02f, -2.88371071e-02f, 4.46413942e-02f, 2.71004625e-02f, -2.59429216e-02f,
  -2.96340100e-02f, 1.22259287e-02f, -4.43787538e-02f, -6.00512102e-02f, -4.74627838e-02f, 2.46117320e-02f, -3.00851054e-02f, 2.68479791e-02f, 1.87529586e-02f, -1.42218322e-02f,
  4.00273204e-02f, 5.65940142e-02f, -5.80645762e-02f, 2.03400441e-02f, -1.06670437e-02f, -2.02242620e-02f, 3.33492495e-02f, -8.17765202e-03f, -1.32508408e-02f, 3.79353203e-02f,
  -7.42267026e-03f, -6.97704256e-02f, 1.59173906e-02f, 3.00865900e-02f, -1.52055219e-01f, 6.52188808e-03f, 7.73212463e-02f, -4.10898216e-03f, 4.24960628e-02f, 5.56618348e-02f,
  -5.38103320e-02f, 5.97836673e-02f, 1.07842227e-02f, 4.29063886e-02f, -7.56475562e-03f, -3.00248638e-02f, -1.05672456e-01f, 1.21662789e-03f, -5.62397344e-03f, -9.21924040e-02f,
  8.90533999e-02f, 4.50292826e-02f, 3.84996049e-02f, -1.52143715e-02f, -5.11275679e-02f, -7.83687178e-03f, 1.54337455e-02f, 6.53601736e-02f, 7.34040812e-02f, 9.78580117e-02f,
  1.69883206e-01f, 3.13327350e-02f, 4.04282734e-02f, -3.93263586e-02f, 5.23480913e-03f, 5.81085384e-02f, 4.04418409e-02f, 8.11277255e-02f, 9.37004164e-02f, 3.99080627e-02f,
  6.13015890e-01f, 8.02502781e-02f, 4.91659716e-02f, 4.92441267e-01f, 9.49761420e-02f, -3.10837239e-01f, -8.23124591e-03f, 4.04288381e-01f, 2.30697453e-01f, -1.76743865e-01f,
  3.40609491e-01f, -1.21370897e-01f, 1.14810895e-02f, 1.76404968e-01f, 3.78811002e-01f, -6.85783625e-02f, 3.99273455e-01f, -8.00284818e-02f, 1.32369325e-01f, 5.18781185e-01f,
  5.55385947e-01f, 3.82713050e-01f, 2.02254131e-01f, 1.38158023e-01f, 3.01164299e-01f, 1.96714312e-01f, 3.49970371e-01f, -1.21988408e-01f, 7.91936740e-02f, -1.99602634e-01f,
  -1.07752576e-01f, 1.64531037e-01f, 3.46475194e-04f, -1.39335468e-01f, 8.87719989e-02f, 3.34670953e-02f, -1.92722648e-01f, -1.88238367e-01f, -3.43606658e-02f, 4.10401449e-02f,
  -2.91970670e-02f, -6.65183216e-02f, 9.25134588e-03f, -3.92258912e-03f, -5.62400408e-02f, 1.95954293e-02f, 1.19734621e-02f, -1.31246150e-02f, -4.23608571e-02f, 2.67348420e-02f,
  3.91200334e-02f, -1.89267695e-02f, 7.09366947e-02f, -1.19215414e-01f, 2.46069059e-02f, 4.46364842e-02f, -9.61028486e-02f, -1.80770019e-06f, -2.99395826e-02f, 6.83273152e-02f,
  8.87716413e-02f, -9.20687988e-02f, 2.26793941e-02f, -7.92168155e-02f, 5.49415052e-02f, -5.68865687e-02f, 4.66229580e-02f, -8.70218724e-02f, -9.06340405e-03f, 3.19788828e-02f,
  -5.25312461e-02f, 2.38121934e-02f, 1.01552680e-02f, -9.24028903e-02f, 6.03001453e-02f, -7.67592900e-03f, -4.13653776e-02f, -1.72122046e-02f, 3.20083126e-02f, -2.04602652e-03f,
  -1.05846502e-01f, 6.87454492e-02f, -1.36695402e-02f, -6.01367280e-02f, -9.24167335e-02f, 3.89723256e-02f, 4.54141572e-02f, 5.38734235e-02f, 3.51842791e-02f, 6.63312152e-02f,
  9.25095081e-02f, 5.09964108e-01f, 1.53294299e-02f, -1.71558529e-01f, -3.50121483e-02f, 6.28242716e-02f, -6.98878989e-03f, 1.13273121e-01f, 1.22434966e-01f, 6.96666613e-02f,
  8.76426026e-02f, -2.66993232e-02f, -1.91605825e-03f, -3.41596082e-02f, -2.37793755e-02f, 2.25786984e-01f, 2.70033870e-02f, -6.01914013e-03f, 1.05947599e-01f, 1.08592045e-02f,
  6.04046322e-02f, -3.77459899e-02f, 4.65724841e-02f, -3.34441960e-02f, -3.76583859e-02f, 2.83713695e-02f, -2.41491687e-03f, -8.31786916e-03f, 8.75287354e-02f, -1.35706710e-02f,
  -7.87072361e-01f, 5.38733363e-01f, 5.59915423e-01f, -5.69570243e-01f, 8.29164460e-02f, 5.24949491e-01f, -1.52197286e-01f, 2.53153086e-01f, -3.42915475e-01f, -4.11786251e-02f,
  -6.62959442e-02f, -2.40855023e-01f, 2.36811429e-01f, 1.10747330e-01f, 1.34173539e-02f, 2.69258231e-01f, 6.21810406e-02f, -1.01666205e-01f, 6.00390807e-02f, -4.94021438e-02f,
  -1.03127755e-01f, -2.35124812e-01f, 3.86775017e-01f, 2.46965140e-01f, 8.24079141e-02f, -1.17474802e-01f, -2.63233513e-01f, 8.40180591e-02f, 1.24007389e-01f, 1.86572090e-01f,
  5.61181121e-02f, -2.54753202e-01f, 3.32076289e-02f, 6.13622777e-02f, 2.03769300e-02f, -4.53966409e-02f, -3.28508765e-02f, -1.84469465e-02f, -5.08784391e-02f, 1.63526367e-02f,
  -9.12403762e-02f, 1.92344561e-02f, -3.23755406e-02f, -1.29288631e-02f, 2.13613566e-02f, 1.25785008e-01f, 2.11734295e-01f, 1.28902182e-01f, 7.05269948e-02f, 1.85978621e-01f,
  1.71876326e-01f, 1.52665168e-01f, 3.82241011e-02f, 2.56291032e-02f, 1.24435797e-02f, 5.13521209e-02f, 7.53985196e-02f, 4.20108102e-02f, 1.20330274e-01f, -2.83149015e-02f,
  -2.14540437e-02f, -6.06129784e-03f, 1.09373428e-01f, -4.14237306e-02f, -7.18572875e-03f, -4.81337458e-02f, 1.26141384e-02f, 1.60000604e-02f, -1.69700049e-02f, 3.20378728e-02f,
  -3.79833728e-02f, -2.85630357e-02f, -7.00319558e-02f, 2.40087956e-02f, -7.68720582e-02f, -1.18679151e-01f, 3.84586714e-02f, -2.63429899e-02f, 1.05881002e-02f, 4.98985909e-02f,
  -6.88131154e-02f, -2.33026985e-02f, -1.19573930e-02f, -1.49209844e-02f, 2.54123323e-02f, 2.28518210e-02f, 1.70254447e-02f, 9.99166518e-02f, -5.42199425e-02f, -8.23854879e-02f,
  -1.23186864e-01f, -2.98846722e-01f, -3.46814888e-03f, -1.16915688e-01f, -1.45414434e-02f, 1.16547771e-01f, 1.92535669e-02f, 2.52530500e-02f, -2.17343234e-02f, 5.29246312e-03f,
  1.06239077e-02f, -8.84480700e-02f, -3.78874056e-02f, -7.54464045e-02f, -6.94406852e-02f, 5.99302351e-03f, -1.20212175e-01f, -1.21369861e-01f, -7.99646974e-02f, 9.83004496e-02f,
  -3.07064895e-02f, -7.39996433e-02f, -8.64942297e-02f, -3.02713737e-02f, -8.10607672e-02f, -8.99575651e-02f, -1.16558716e-01f, 4.44678683e-03f, 1.50817139e-02f, 8.19865391e-02f,
  2.52760172e-01f, 3.53141814e-01f, 2.94862866e-01f, 3.69426683e-02f, -4.35852772e-03f, 5.07252812e-01f, 5.47197402e-01f, 3.23244482e-02f, 4.58540916e-01f, 1.11060180e-02f,
  -3.58343005e-01f, 4.94946212e-01f, -1.94280278e-02f, -1.94106251e-02f, 3.96981895e-01f, 2.34136298e-01f, 2.31278479e-01f, 2.14928001e-01f, 1.64410532e-01f, 1.11098841e-01f,
  -1.79278683e-02f, -8.01029801e-02f, -2.27228329e-01f, -3.30544680e-01f, -1.56961218e-01f, -2.04431713e-01f, -5.28897166e-01f, -8.65459144e-02f, -3.32016677e-01f, 6.28599748e-02f,
  -9.42002013e-02f, -5.19184135e-02f, -6.06338382e-02f, 9.49398428e-02f, 1.07665630e-02f, -5.86661836e-03f, 2.19831546e-03f, 2.43653785e-02f, -4.70764078e-02f, 3.49452794e-02f,
  9.27662775e-02f, 3.28247771e-02f, 9.08737704e-02f, -1.68413464e-02f, -4.71141003e-03f, -6.54151812e-02f, -5.37226014e-02f, -7.12084845e-02f, 3.16332094e-02f, 8.49032402e-02f,
  2.36339085e-02f, 1.21064857e-02f, -5.29412627e-02f, 3.38919424e-02f, -3.60027328e-02f, 2.55301427e-02f, 1.01949468e-01f, 6.74633756e-02f, 8.89318157e-03f, 1.00827873e-01f,
  1.29057169e-02f, 6.45236969e-02f, 4.48002107e-02f, -9.02398601e-02f, 5.85101917e-02f, -1.08798534e-01f, -8.21415614e-03f, -1.41358236e-02f, -2.12397566e-03f, 2.75990833e-02f,
  -6.89277845e-03f, 1.28209991e-02f, 2.30561029e-02f, -7.88293034e-03f, -3.96705698e-03f, 2.54977457e-02f, 2.07238253e-02f, 4.29527313e-02f, 6.43916801e-02f, -6.42069755e-03f,
  -2.29932331e-02f, 9.76052210e-02f, 1.68053247e-02f, -1.05358459e-01f, 4.03297730e-02f, -7.89641589e-03f, -8.80333502e-03f, -2.02294085e-02f, -8.09705108e-02f, -2.84699760e-02f,
  1.62578315e-01f, 5.32014370e-01f, -6.19347300e-03f, 4.20762505e-03f, -2.84559671e-02f, -2.06553172e-02f, 1.00789912e-01f, 7.11293072e-02f, 1.35391131e-01f, 1.54172033e-01f,
  -3.55261751e-02f, 1.19951402e-03f, 7.77070299e-02f, -2.33046878e-02f, 7.18800575e-02f, 6.64849058e-02f, 6.80425987e-02f, 3.94616500e-02f, 8.37550610e-02f, -7.24776983e-02f,
  -4.80773821e-02f, 3.87423150e-02f, 8.42881203e-02f, -2.35392470e-02f, -3.74028608e-02f, -6.54709116e-02f, 5.88335842e-02f, -7.95772448e-02f, 2.33273711e-02f, 1.18402302e-01f,
  4.70757097e-01f, -1.90789059e-01f, 5.43966033e-02f, 1.26026860e-02f, -4.33193743e-02f, -4.63319838e-01f, -4.74181712e-01f, -1.90526709e-01f, 3.27495873e-01f, -3.00456643e-01f,
  -3.60259414e-01f, 2.57251978e-01f, -1.00808047e-01f, -3.02225292e-01f, 1.19112194e-01f, 9.04779807e-02f, -3.01462114e-01f, -1.22750424e-01f, 2.51179844e-01f, -3.32485735e-01f,
  1.52133480e-01f, -4.58430350e-01f, -5.15462533e-02f, -4.04488862e-01f, -2.80615658e-01f, -7.54710636e-04f, -1.47295386e-01f, -2.91211873e-01f, -1.48912907e-01f, -9.47649404e-02f,
  6.32535741e-02f, 9.46557671e-02f, -2.22889576e-02f, 3.37776579e-02f, 1.53551335e-02f, 6.12372868e-02f, -6.80339783e-02f, -5.33473790e-02f, 8.31336230e-02f, 1.23431003e-02f,
  4.81628254e-02f, 4.76635285e-02f, 2.92435810e-02f, 1.77395344e-02f, -5.26464265e-03f, 9.09265946e-04f, 1.22468196e-01f, 1.24167807e-01f, 2.72025727e-02f, 8.88125747e-02f,
  6.89790249e-02f, 8.55180249e-02f, 2.00576335e-02f, 1.06487758e-02f, 6.37386143e-02f, -1.11526763e-02f, -1.17381187e-02f, 6.96937069e-02f, 6.75709024e-02f, 4.27725613e-02f,
  -7.78304338e-02f, 1.22094601e-02f, -1.34652900e-02f, -4.75979820e-02f, -5.84962405e-02f, -6.95831031e-02f, -1.11414734e-02f, 6.02950677e-02f, 2.94740945e-02f, -4.61179838e-02f,
  -3.35210338e-02f, 4.04250203e-03f, -2.16874853e-02f, 2.00808365e-02f, -1.56704318e-02f, -8.40037782e-03f, -3.02818324e-02f, -6.11397177e-02f, 3.48227806e-02f, 4.20191884e-02f,
  -4.16152440e-02f, -1.88942123e-02f, -1.43139567e-02f, -4.83335406e-02f, -1.79251730e-02f, -2.61668805e-02f, -2.81610503e-03f, -2.44303234e-03f, 1.00342274e-01f, -1.62518565e-02f,
  -1.22149281e-01f, -2.63973415e-01f, -4.91242968e-02f, 1.55132227e-02f, -9.95542780e-02f, -2.14999150e-02f, 3.90709005e-02f, 5.21183200e-02f, -4.46247011e-02f, 2.13908851e-02f,
  3.76104154e-02f, 7.82943610e-03f, -2.39302292e-02f, 4.25223215e-03f, -4.14624019e-03f, -4.19512615e-02f, -1.02059506e-01f, 2.72756815e-02f, -7.35882372e-02f, -3.53210457e-02f,
  -8.81007463e-02f, -1.33832861e-02f, 9.91266873e-03f, 1.19012967e-03f, -6.95030689e-02f, -2.29845904e-02f, 8.93144868e-03f, -9.11369640e-03f, -4.76237759e-02f, 1.00106942e-02f,
  2.83998102e-01f, -7.02464581e-01f, 4.05497462e-01f, 2.67909259e-01f, 2.94530243e-01f, 3.91236752e-01f, 6.28796518e-01f, 5.77644585e-03f, 2.38810837e-01f, -5.93237281e-01f,
  -1.63981780e-01f, -2.79208153e-01f, 2.42483124e-01f, -3.66690576e-01f, 5.31622291e-01f, 1.28292456e-01f, -8.37453529e-02f, -1.37116432e-01f, 3.73146795e-02f, -1.06749266e-01f,
  1.22288041e-01f, -3.18940401e-01f, 8.20262060e-02f, -5.36042809e-01f, -1.16717882e-01f, -2.60763109e-01f, -2.00881690e-01f, 5.05213179e-02f, -4.32443053e-01f, -4.78587151e-02f,
  -1.08420886e-01f, -1.64951310e-01f, -9.38410982e-02f, -1.73263535e-01f, -5.62344939e-02f, -3.31849344e-02f, 1.32653152e-03f, 1.06446572e-01f, 7.00923577e-02f, 9.63538885e-02f,
  -2.06692312e-02f, 1.17813107e-02f, -9.91325676e-02f, 6.93364516e-02f, 5.24634458e-02f, -4.60762456e-02f, 3.19522955e-02f, -4.98556569e-02f, -3.43823293e-03f, 8.31844360e-02f,
  6.55382723e-02f, -4.22386825e-02f, 3.09750866e-02f, -1.18870549e-01f, 3.77146602e-02f, -1.06633911e-02f, 6.49347529e-02f, 5.92859946e-02f, -3.09077613e-02f, 6.42510280e-02f,
  -3.50509188e-03f, 3.57146375e-02f, 2.92505529e-02f, -5.03766537e-02f, 2.17114855e-03f, -3.09130438e-02f, -2.81347651e-02f, -1.59414038e-02f, 2.70812474e-02f, 5.08090407e-02f,
  -5.66260424e-04f, -8.01120400e-02f, 5.80929639e-03f, 3.73056717e-02f, 2.18702218e-04f, 4.90355752e-02f, -1.49170244e-02f, 3.70088667e-02f, -4.92900312e-02f, -4.71358858e-02f,
  6.58072624e-03f, 1.38576888e-02f, -3.24436054e-02f, 1.97249595e-02f, -7.61804432e-02f, 5.24418652e-02f, -7.30484873e-02f, 9.62128043e-02f, 6.97189644e-02f, 4.49303687e-02f,
  -2.39869595e-01f, -4.94598210e-01f, -1.28797114e-01f, -8.41350034e-02f, -1.26427159e-01f, -9.17130411e-02f, 3.35410610e-02f, -5.27563542e-02f, -4.71377186e-02f, -4.83474974e-03f,
  -4.65474017e-02f, 6.82970509e-02f, -5.66605590e-02f, -5.18305935e-02f, -1.10609815e-01f, -4.02015634e-02f, -5.77023178e-02f, -1.11695461e-01f, -7.31315017e-02f, -1.46291867e-01f,
  -6.06791787e-02f, -1.44284358e-02f, 8.34331512e-02f, 3.83233931e-03f, -7.40063861e-02f, -5.26728667e-02f, -1.58387069e-02f, -3.78056383e-03f, -4.52963486e-02f, -7.50470459e-02f,
  3.12884361e-01f, -2.59665638e-01f, 1.09171338e-01f, 5.73905647e-01f, 2.07844347e-01f, 1.14671826e-01f, -1.12115107e-01f, 8.70387033e-02f, 2.13836014e-01f, -3.85916054e-01f,
  -1.83772128e-02f, 1.13905393e-01f, -7.07627475e-01f, 5.04329681e-01f, 3.63184154e-01f, -4.38268483e-01f, 3.33509177e-01f, 1.51560128e-01f, -1.23383419e-03f, 1.33524209e-01f,
  2.64702529e-01f, 2.78042167e-01f, 1.06091008e-01f, 1.23064868e-01f, 3.35702389e-01f, 2.58705974e-01f, -1.83256506e-03f, -2.45347157e-01f, 3.91097814e-01f, 1.22825697e-01f,
  8.50146934e-02f, 1.21983200e-01f, 2.46943422e-02f, -1.47749474e-02f, -6.55652657e-02f, -3.27926055e-02f, 1.20831626e-02f, 8.82839188e-02f, 5.20696826e-02f, 2.13853586e-02f,
  -6.97237700e-02f, 1.22240178e-01f, 1.97026163e-01f, 5.90223959e-03f, 5.02212793e-02f, 9.34465975e-02f, 1.22657001e-01f, -5.58281094e-02f, 4.81517091e-02f, -3.72905470e-03f,
  2.05427315e-02f, -3.19447108e-02f, 3.43120657e-02f, -3.68076935e-02f, 1.26859676e-02f, 7.40997195e-02f, 4.62063849e-02f, -8.53509009e-02f, 1.29272178e-01f, 9.56562832e-02f,
  -8.80882423e-03f, -3.11632082e-02f, -3.36152548e-03f, 4.54571284e-02f, 4.25635092e-02f, -2.88738050e-02f, 5.97701408e-02f, 6.17536530e-03f, -2.29664706e-02f, 1.42879914e-02f,
  7.89527968e-02f, 7.26465657e-02f, 5.91197386e-02f, 2.90456670e-03f, 3.16199549e-02f, 4.54285964e-02f, 4.13428769e-02f, 1.38165066e-02f, -1.01027787e-02f, 1.63207054e-02f,
  -7.10872561e-02f, -6.53864257e-03f, -3.91348964e-03f, 2.23435368e-02f, -2.32794024e-02f, -1.04434155e-01f, 4.24816646e-03f, -8.61519109e-03f, -4.92550917e-02f, 1.68361496e-02f,
  -1.28331169e-01f, -1.84696034e-01f, -9.87136737e-02f, 3.18640657e-02f, -6.78277910e-02f, 4.01468165e-02f, -8.54202546e-03f, 1.91831831e-02f, -1.03472590e-01f, -5.50932111e-03f,
  5.44273481e-03f, -3.77022885e-02f, -1.11696571e-02f, 4.30667698e-02f, -2.10954361e-02f, -2.93449946e-02f, -4.80917171e-02f, 2.46389955e-02f, -4.85363998e-04f, 4.32903133e-02f,
  -3.07437964e-02f, -6.09989651e-02f, 1.74599215e-02f, 9.36191529e-02f, 7.45506659e-02f, 4.08306671e-03f, -3.56931202e-02f, 2.70404276e-02f, -3.54619697e-02f, 4.55256971e-03f,
  -4.65504438e-01f, 4.56518143e-01f, -1.91927209e-01f, 2.06731975e-01f, -5.62783599e-01f, 1.38965309e-01f, 4.56602216e-01f, -1.66066915e-01f, 6.16167672e-02f, 5.90160787e-01f,
  3.54774743e-01f, -9.41739380e-02f, 4.29711699e-01f, 5.85944057e-01f, 5.82282543e-02f, 5.16870499e-01f, 6.18641555e-01f, 5.30466139e-01f, -9.93436500e-02f, 2.65419986e-02f,
  -6.90071806e-02f, 3.23737025e-01f, 1.83126912e-01f, -2.23451927e-01f, -7.11824931e-03f, -3.04036081e-01f, 2.77872887e-02f, -3.08908761e-01f, 9.35613364e-02f, -1.12756692e-01f,
  3.59764956e-02f, -1.68453325e-02f, -1.31876960e-01f, -1.22963555e-01f, -3.56581178e-03f, 1.13929622e-02f, 2.77655777e-02f, -7.63183981e-02f, -1.32667914e-01f, -1.19148530e-02f,
  -8.31967499e-03f, -7.50585273e-02f, -3.70417722e-02f, -2.99145970e-02f, -1.38768718e-01f, -1.10920221e-01f, -8.75561088e-02f, -7.90763944e-02f, -1.54184410e-02f, -1.03741571e-01f,
  -9.14797932e-03f, 2.38852634e-04f, 2.91827880e-02f, 1.47201434e-01f, -6.71095029e-02f, -8.64412077e-03f, 1.02184676e-01f, -1.78670138e-02f, -1.51768802e-02f, 1.00594591e-02f,
  -1.04894422e-01f, 5.99514060e-02f, 2.65803915e-02f, -4.14426848e-02f, -4.73735891e-02f, 2.05902336e-03f, -3.11959605e-03f, 2.75971051e-02f, -4.77186702e-02f, 3.70803103e-02f,
  -4.50959615e-02f, -3.19278017e-02f, -8.51886645e-02f, 2.94933841e-02f, 5.40921912e-02f, 5.88471778e-02f, -2.20656060e-02f, -1.94681175e-02f, 2.98195686e-02f, -9.37104318e-03f,
  4.11704481e-02f, -7.43527710e-03f, 1.73062813e-02f, 2.74363291e-02f, 2.43565012e-02f, -4.07452993e-02f, 3.04909069e-02f, 5.43298014e-02f, 1.13334479e-02f, -3.03724669e-02f,
  3.09744298e-01f, 1.44187748e-01f, 1.06550744e-02f, -8.74762908e-02f, 4.73173968e-02f, -8.08358416e-02f, 8.85532647e-02f, 1.79055315e-02f, 3.63611504e-02f, 2.64660325e-02f,
  1.43598365e-02f, -1.76528785e-02f, 5.69502404e-03f, -7.01396093e-02f, -2.90412214e-02f, 1.01927839e-01f, 1.43209815e-01f, 7.52086714e-02f, 1.57112740e-02f, 3.61013822e-02f,
  -5.99645730e-03f, -1.72105078e-02f, 4.88427803e-02f, -6.37960038e-04f, 3.38274315e-02f, 8.15774426e-02f, -1.24707527e-01f, 2.24157702e-02f, -2.89777461e-02f, 7.16539100e-02f,
  -5.79671621e-01f, 4.01432455e-01f, -2.03327060e-01f, -4.72909927e-01f, 1.72594227e-02f, -3.25988352e-01f, -2.90572047e-01f, -3.18000279e-03f, 1.10961944e-01f, 2.30268344e-01f,
  1.72562048e-01f, -5.20425886e-02f, 6.04852915e-01f, -9.28040072e-02f, -3.03948134e-01f, 2.91627467e-01f, -3.85083079e-01f, -2.66575962e-01f, 1.44074365e-01f, -2.55050391e-01f,
  -2.78108180e-01f, -2.27959733e-02f, -3.15167792e-02f, 2.52436131e-01f, -3.47573072e-01f, -1.74673244e-01f, -1.35627538e-01f, 3.14108104e-01f, -3.31631571e-01f, 5.09303994e-02f,
  -3.22540462e-01f, -9.92578343e-02f, -1.33738413e-01f, -5.03373072e-02f, -2.94486433e-01f, -1.58423722e-01f, -1.69869840e-01f, 5.58573455e-02f, -9.52105410e-03f, -6.26623537e-03f,
  -2.21882779e-02f, 4.35206965e-02f, 7.69776944e-03f, 2.05222666e-01f, -6.36785999e-02f, 6.81041414e-03f, -1.59953032e-02f, -7.67348185e-02f, -1.65537149e-02f, -6.14249036e-02f,
  1.07592428e-02f, -5.15527688e-02f, -1.38453484e-01f, -6.67578802e-02f, -5.43940552e-02f, 4.25550789e-02f, -7.32850656e-02f, -4.64853197e-02f, -1.79046735e-01f, -3.59104201e-02f,
  2.59841233e-02f, -5.28042838e-02f, 2.28847321e-02f, 9.29886475e-02f, 4.55806665e-02f, 2.62146303e-03f, 2.87351757e-02f, 5.18640131e-02f, 2.69765314e-02f, -1.92385390e-02f,
  -4.47129570e-02f, 1.11516681e-03f, 7.39533305e-02f, -1.21664479e-01f, -5.31936288e-02f, -8.18202272e-02f, -1.83351059e-02f, -6.65374994e-02f, -9.35047641e-02f, -3.98067981e-02f,
  4.61413674e-02f, -1.70847960e-02f, 6.72311634e-02f, -7.30820522e-02f, -1.67588126e-02f, 9.22202095e-02f, -5.20488480e-03f, 7.37842824e-03f, 1.15806255e-02f, -4.26145494e-02f,
  -4.23205167e-01f, -2.60587305e-01f, -5.33170365e-02f, 3.08322050e-02f, -6.27312362e-02f, -4.48656268e-02f, 3.77313280e-03f, -5.63451350e-02f, -4.18366641e-02f, 2.86663789e-02f,
  -1.48698017e-01f, -8.11268464e-02f, -1.55770853e-01f, 3.90497409e-02f, -3.05516999e-02f, -4.52632010e-02f, -5.69968596e-02f, -9.53480825e-02f, -9.93326977e-02f, -5.80295511e-02f,
  4.80371676e-02f, 1.49202542e-02f, 2.42196303e-02f, -3.15425396e-02f, -1.02837749e-01f, -8.84749219e-02f, -1.62165582e-01f, 2.28260327e-02f, -7.36577064e-02f, -6.38805851e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.51618445e-01f, 6.18659735e-01f, 4.55308259e-01f, 3.73382598e-01f, 6.02158844e-01f, 1.70992583e-01f, 5.42672992e-01f, 3.98765534e-01f, 3.54911625e-01f, 2.81180412e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  2.11651668e-01f, -8.65774155e-02f, 1.54815435e-01f, 4.36436504e-01f, 3.13104182e-01f, 3.24761599e-01f, -8.59923661e-03f, -4.11004543e-01f, -7.01417744e-01f, 1.73533529e-01f,
  -4.57601488e-01f, -1.73119947e-01f, -1.83067128e-01f, -3.48664254e-01f, 1.50623631e+00f, 1.99009866e-01f, -4.55599278e-01f, 5.44194937e-01f, -2.03075320e-01f, 7.67363369e-01f,
  1.35047371e-02f, 7.43857980e-01f, 1.06187367e+00f, -6.87051415e-01f, 4.26561624e-01f, -1.68203294e-01f, 3.28399241e-01f, -2.96107568e-02f, -6.47723615e-01f, 5.53175919e-02f,
  5.74914575e-01f, -5.27093053e-01f, 2.57117242e-01f, -9.32582617e-01f, -1.97263107e-01f, 3.71363848e-01f, -6.60754442e-01f, 5.60670674e-01f, 6.26828074e-01f, -8.66467655e-02f,
  -2.26889253e-01f, -2.58672595e-01f, -3.29292536e-01f, -2.00924307e-01f, -5.51390767e-01f, 1.26173806e+00f, -4.13917273e-01f, -3.66923094e-01f, 1.49433672e-01f, -7.98294067e-01f,
  -1.15454093e-01f, 3.38867277e-01f, 5.85683525e-01f, -3.23531568e-01f, -3.03327262e-01f, 5.73146939e-01f, -2.22230196e-01f, -9.06242579e-02f, -2.98868358e-01f, -4.18547273e-01f,
  -5.72770655e-01f, -3.58876228e-01f, -5.51946998e-01f, 1.27186370e+00f, 2.00733513e-01f, 2.35245138e-01f, 3.75252962e-01f, -7.58900881e-01f, -7.26266056e-02f, -3.05630356e-01f,
  -1.68375731e-01f, -4.37617630e-01f, -3.05290312e-01f, 1.42264557e+00f, 4.84534651e-02f, -9.78547409e-02f, 3.13167125e-01f, -4.90973502e-01f, -3.10632348e-01f, 4.93757248e-01f,
  6.91675782e-01f, 3.08330864e-01f, 4.08144802e-01f, 1.10915890e-02f, 2.75617272e-01f, -4.11306262e-01f, -4.65462148e-01f, -5.58098078e-01f, -1.03411540e-01f, -5.35958648e-01f,
  1.40635824e+00f, -2.59945840e-01f, 7.54542500e-02f, -1.34256214e-01f, 5.15455067e-01f, -1.66261867e-01f, 4.24217492e-01f, 4.45257157e-01f, -4.44698602e-01f, -4.79563683e-01f,
  -6.07700586e-01f, 8.38515580e-01f, -6.46760166e-01f, -2.00505182e-01f, 4.81069088e-01f, -5.53437173e-01f, 6.31204471e-02f, 3.08666408e-01f, 9.83151495e-01f, 5.19329369e-01f,
  -3.61426204e-01f, -4.53464985e-01f, 5.59073426e-02f, -2.77392089e-01f, -9.10065174e-01f, 2.69404173e-01f, 2.68543124e-01f, -5.12228608e-01f, -1.76514238e-01f, -1.54376119e-01f,
  -3.04113299e-01f, -3.02523017e-01f, -2.05309793e-01f, 1.20425808e+00f, 4.74685192e-01f, -2.21643448e-01f, -1.19835464e-02f, 4.73885685e-01f, 1.16790961e-02f, -3.94315302e-01f,
  -3.30179520e-02f, -1.01120517e-01f, -6.74484253e-01f, -6.95689142e-01f, -4.84796315e-01f, 3.11947882e-01f, 1.30609453e+00f, 5.75657561e-02f, -3.33099484e-01f, -1.12195231e-01f,
  -3.45714778e-01f, 2.95067549e-01f, 1.77747950e-01f, -8.21535140e-02f, -7.77499974e-01f, -5.18536389e-01f, 3.08184087e-01f, -6.59816206e-01f, -8.35125148e-01f, -2.20420375e-01f,
  8.64202619e-01f, -1.00088961e-01f, -5.21555364e-01f, -3.35247248e-01f, 3.52605760e-01f, -1.26970008e-01f, 1.11002719e+00f, -3.68015796e-01f, -1.48746014e-01f, -2.75138259e-01f,
  4.42889668e-02f, 7.14591503e-01f, 5.49370766e-01f, 9.08635020e-01f, 4.45374817e-01f, -5.70405424e-01f, 7.57111013e-01f, 1.08428407e+00f, -2.18392059e-01f, -3.46949100e-01f,
  -5.62482238e-01f, -5.36313057e-01f, -3.20823818e-01f, -5.12986839e-01f, -4.21405107e-01f, -3.69276077e-01f, -1.57515958e-01f, -3.22203249e-01f, 1.28978014e-01f, -1.18532932e+00f,
  8.43210518e-01f, 5.17641246e-01f, -2.88754284e-01f, 1.13018000e+00f, -4.18397278e-01f, 2.11667549e-02f, 9.82864350e-02f, 3.93732846e-01f, -2.90736914e-01f, 3.10052514e-01f,
  -9.28391293e-02f, -4.35524881e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.69901416e-01f, -7.64786974e-02f, 7.57233500e-02f, 1.39765730e-02f, 1.33555800e-01f, 2.69647002e-01f, -4.71991859e-02f, -1.32682398e-01f, -3.96264672e-01f, -2.40641143e-02f,
  -5.29104322e-02f, 9.05089602e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    