/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.10510719e-01f, -1.62667021e-01f, -6.85819685e-02f, -2.76067760e-02f, -6.18269295e-02f, -2.36648887e-01f, -2.25003272e-01f, 2.66114008e-02f, -2.85990030e-01f, -7.30300769e-02f,
  -1.14738196e-01f, -1.83559552e-01f, -1.71481334e-02f, 8.18286464e-03f, 5.73388475e-04f, 7.40539357e-02f, -1.35167420e-01f, -6.23195954e-02f, 1.29766334e-02f, -2.55329479e-02f,
  5.49614131e-02f, 5.61258271e-02f, 5.05641028e-02f, 1.80265736e-02f, -1.43862411e-01f, -3.63937728e-02f, 1.84683889e-01f, 2.37141475e-02f, 1.31557972e-04f, 3.00125722e-02f,
  -1.02048092e-01f, -2.71581765e-02f, -1.97525974e-02f, 8.86306539e-03f, 6.38366491e-02f, -6.46389425e-02f, -1.34928254e-02f, 1.76067129e-02f, 2.85216626e-02f, 2.69025769e-02f,
  -2.30549555e-02f, 2.31269542e-02f, -1.82749759e-02f, 5.50114326e-02f, 1.61903014e-03f, -6.99258922e-03f, -6.54728990e-03f, -2.60261092e-02f, 6.57364205e-02f, -2.10591126e-02f,
  -1.70735251e-02f, -1.57974157e-02f, -7.47454492e-03f, 7.15541393e-02f, 2.35348642e-02f, -6.83473721e-02f, -2.16735415e-02f, 4.18365896e-02f, -3.07110678e-02f, -2.26853024e-02f,
  1.81880128e-02f, 1.88549198e-02f, 1.26293963e-02f, 1.16821853e-02f, -2.04837117e-02f, 3.83646190e-02f, -3.15684602e-02f, 4.15819176e-02f, -7.54330084e-02f, -2.53223870e-02f,
  8.23475607e-03f, -7.63248792e-03f, -2.49766894e-02f, -5.20148352e-02f, -1.43259754e-02f, -1.92693491e-02f, -1.08279477e-04f, 1.17442152e-02f, -5.93252443e-02f, -2.44796481e-02f,
  1.14490446e-02f, 1.09989187e-02f, 8.31613038e-03f, -6.02436205e-03f, 3.68765071e-02f, 1.31889025e-03f, 1.59297641e-02f, 1.42844487e-03f, -5.20235160e-03f, 7.68414978e-03f,
  1.88343257e-01f, 1.71886832e-01f, 1.05306935e-02f, -8.81608352e-02f, 2.40901187e-02f, 1.24882795e-02f, 5.17265648e-02f, -1.11340890e-02f, 4.18033637e-02f, -4.33802838e-03f,
  1.21727614e-02f, 1.68860033e-02f, 4.08335589e-02f, 2.05481015e-02f, 3.28573328e-03f, 4.66001630e-02f, 2.52876640e-03f, -1.75313596e-02f, 3.59784402e-02f, 3.23755555e-02f,
  -2.09444109e-02f, 1.06862318e-02f, 5.36780283e-02f, 2.32055485e-02f, -8.88306797e-02f, 1.70767102e-02f, -3.67198065e-02f, -9.19932406e-03f, 6.11020736e-02f, 7.07275197e-02f,
  -2.65976757e-01f, -1.61578413e-02f, 5.25343418e-03f, 1.29047170e-01f, 3.81122790e-02f, -4.04737145e-02f, -8.12320970e-03f, -1.02537155e-01f, 7.07412884e-03f, 3.70281637e-02f,
  -5.86413182e-02f, -6.94557503e-02f, -1.19519725e-01f, 8.11533257e-02f, -1.55124649e-01f, -1.28812358e-01f, 2.37015598e-02f, 3.74272615e-02f, -3.99449170e-02f, 9.68202576e-03f,
  1.25641646e-02f, -4.04703580e-02f, 4.44736294e-02f, 1.26070127e-01f, -8.86023883e-03f, 3.04889493e-02f, 3.83886024e-02f, -5.70488870e-02f, 7.40131438e-02f, -8.46151933e-02f,
  -1.06418036e-01f, 9.87439454e-02f, 2.80733239e-02f, 4.30155322e-02f, -1.17877975e-01f, 4.80475314e-02f, -2.70771477e-02f, -7.63044730e-02f, 7.52582867e-03f, -7.37154782e-02f,
  -1.07440382e-01f, -7.68933492e-03f, -5.76937513e-04f, -1.86986178e-02f, 5.49372397e-02f, 2.16708183e-02f, 3.66370007e-02f, 3.20965759e-02f, -3.64171416e-02f, 2.21688151e-02f,
  6.93330541e-02f, 1.07948765e-01f, 5.13461009e-02f, 4.61487807e-02f, 2.99335588e-02f, 6.09862730e-02f, 1.13167390e-01f, -5.89275695e-02f, 8.40477571e-02f, 4.19118162e-03f,
  -2.39694840e-03f, 8.96922592e-03f, 6.50760755e-02f, -7.43949413e-02f, 5.60848303e-02f, -1.70709025e-02f, 7.22847506e-02f, -7.92945176e-02f, 4.24638912e-02f, -4.44834419e-02f,
  -7.06388131e-02f, 6.56533390e-02f, -2.74589490e-02f, 5.09328395e-02f, 9.48891118e-02f, 1.55897671e-02f, -6.85245469e-02f, -1.15634073e-02f, 5.47306053e-02f, 2.35468871e-03f,
  -4.05536629e-02f, 5.82188591e-02f, -4.70388159e-02f, -3.88233773e-02f, 2.00824942e-02f, -6.72051460e-02f, 3.99111062e-02f, 1.53293842e-02f, -6.09247908e-02f, -1.22676129e-02f,
  -1.08049110e-01f, 3.49102914e-02f, 4.39487100e-02f, -4.02145498e-02f, 4.11659926e-02f, -3.24247521e-03f, -1.86658781e-02f, -3.37152439e-03f, -2.42628958e-02f, -4.31054085e-02f,
  5.42653576e-02f, -1.42002339e-02f, -4.02790606e-02f, -4.61544581e-02f, -5.23282178e-02f, -6.83741346e-02f, -1.27496170e-02f, -6.76561194e-03f, 1.48579907e-02f, -2.98895035e-02f,
  5.53732924e-02f, -1.61844231e-02f, 3.04876966e-03f, -4.13720205e-04f, 5.58220688e-03f, 5.35760410e-02f, 3.18693370e-03f, 9.14461091e-02f, 7.15787895e-03f, -2.26092781e-03f,
  1.28541633e-01f, 6.47187307e-02f, 1.44636855e-01f, 1.65623128e-02f, 3.11404243e-02f, 1.73481721e-02f, -4.02000770e-02f, 1.72844291e-01f, 3.39235216e-01f, -1.15560874e-01f,
  -1.37715772e-01f, -4.21924604e-04f, 5.12899086e-02f, -3.73128131e-02f, -2.30516776e-01f, 3.34289223e-02f, -4.94227223e-02f, 3.31032276e-02f, 1.95391059e-01f, -2.80104708e-02f,
  8.52396861e-02f, -3.03358287e-01f, -1.12075917e-01f, -2.20796302e-01f, -1.78498790e-01f, 1.55486867e-01f, -2.79557854e-01f, 5.62561303e-02f, -1.91428795e-01f, -8.82542133e-02f,
  6.80611134e-02f, 1.89681873e-01f, 6.24511354e-02f, 5.67946956e-02f, -4.35025916e-02f, 6.72450215e-02f, -5.86029701e-02f, -4.28984985e-02f, 1.06007136e-01f, 7.28532067e-03f,
  -6.79854676e-02f, -3.64273377e-02f, 1.14796376e-02f, -4.73647155e-02f, 7.32170865e-02f, -6.96974546e-02f, 2.24213507e-02f, -3.17164175e-02f, 3.75116542e-02f, 1.90969408e-02f,
  -5.14205694e-02f, 5.30851893e-02f, 1.23473536e-02f, 4.39919867e-02f, -3.29373181e-02f, -4.49679419e-02f, 2.35781707e-02f, 5.52736409e-02f, -8.60740710e-03f, 5.43815047e-02f,
  1.16308685e-02f, 5.78443259e-02f, -4.43923138e-02f, -6.66298643e-02f, -3.76530588e-02f, -3.27247307e-02f, -4.49317656e-02f, -1.00037090e-01f, 4.90327850e-02f, -7.86108151e-02f,
  -4.46436927e-02f, 1.21370042e-02f, -3.08928378e-02f, 4.26583663e-02f, -3.00020445e-02f, -5.14157955e-03f, -2.51382031e-02f, 6.93961931e-03f, -2.64374390e-02f, -4.72644381e-02f,
  -1.66522376e-02f, 4.53210175e-02f, -7.08262548e-02f, 8.24162215e-02f, 4.78288308e-02f, 7.02421516e-02f, -3.12975943e-02f, 6.57373965e-02f, -3.06032784e-02f, -9.11108553e-02f,
  -7.72513822e-02f, -4.19351310e-02f, 5.73040964e-03f, -7.58459643e-02f, 1.89249795e-02f, -6.89310879e-02f, -1.20604606e-02f, 2.01552245e-03f, -2.82157622e-02f, -6.20554984e-02f,
  1.25546642e-02f, -4.27357107e-02f, -2.59229410e-02f, 6.89907447e-02f, 1.52333742e-02f, -2.67562941e-02f, -2.53958404e-02f, 7.41580874e-02f, -1.04360655e-02f, -4.39374112e-02f,
  -5.17007662e-03f, -5.61338253e-02f, 3.37419361e-02f, -7.27868155e-02f, 3.41725427e-05f, -2.97608748e-02f, 1.80362463e-02f, 7.27357268e-02f, -5.23853749e-02f, 4.45524678e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.21069360e-01f, -2.26566717e-01f, 9.73862484e-02f, 3.25127929e-01f, -7.99334869e-02f, -1.35978134e-02f, -8.17037523e-02f, -3.64944302e-02f, 1.70803234e-01f, 6.00153487e-03f,
  -9.50480253e-02f, 1.19808003e-01f, -3.08440119e-01f, 1.21991321e-01f, -1.09272338e-01f, -1.41554892e-01f, -5.09566106e-02f, -3.87252942e-02f, -8.00130814e-02f, 1.74075067e-01f,
  7.64658004e-02f, -7.02682212e-02f, -1.27314804e-02f, -8.57933909e-02f, 8.84915236e-03f, 1.00458041e-01f, -3.86169888e-02f, -1.98129877e-01f, 1.41984344e-01f, -7.92634860e-02f,
  -2.67404653e-02f, 5.80233857e-02f, 8.64285417e-03f, 2.33307704e-02f, -3.46069895e-02f, -3.32059301e-02f, -1.11125670e-02f, -2.20410693e-02f, 9.18742269e-03f, 8.22694227e-02f,
  5.67138307e-02f, 6.42410442e-02f, 1.51393056e-01f, 4.06768173e-02f, -1.24545889e-02f, 1.44120157e-01f, 1.00876875e-01f, 2.63848100e-02f, 3.58656757e-02f, -3.73132303e-02f,
  1.18926026e-01f, -3.02906078e-03f, 7.95455202e-02f, -8.09980780e-02f, -3.69406119e-02f, 1.17533721e-01f, -2.76243854e-02f, -5.57535375e-03f, 2.14711912e-02f, 4.86322902e-02f,
  -1.02418652e-02f, 2.87198145e-02f, -3.28281964e-03f, 3.13059799e-02f, -2.63999160e-02f, 7.08099753e-02f, -5.07716462e-02f, 8.14854205e-02f, -1.16333049e-02f, -2.20051631e-02f,
  -6.94711432e-02f, 7.65390769e-02f, -1.63360983e-02f, 3.01190764e-02f, -3.93349081e-02f, -1.22747654e-02f, -2.77061258e-02f, -2.11986210e-02f, -7.64186904e-02f, -8.43847357e-03f,
  -5.11366725e-02f, 2.95290146e-02f, 4.74449247e-02f, 1.14941392e-02f, -2.20939722e-02f, -5.15587665e-02f, 2.98038423e-02f, 2.72162408e-02f, -2.01363321e-02f, -1.78323984e-02f,
  -2.29653180e-01f, -1.90452576e-01f, -1.13644740e-02f, 4.15342534e-03f, 3.78976129e-02f, 7.23547041e-02f, 2.18035411e-02f, 3.63055319e-02f, -1.05515882e-01f, 4.43721302e-02f,
  1.11714071e-02f, -1.82772148e-02f, -3.17407809e-02f, -3.36826295e-02f, -5.92138395e-02f, -4.15663421e-02f, -1.55867711e-02f, -4.71688956e-02f, 3.70523892e-02f, 2.27504801e-02f,
  4.74503413e-02f, -9.89610031e-02f, 7.73099214e-02f, 4.94943596e-02f, -5.22035966e-03f, -5.59009090e-02f, 3.66820320e-02f, -7.84280300e-02f, -1.67223101e-03f, -1.99489240e-02f,
  -6.21334836e-02f, -2.90609635e-02f, 1.94293827e-01f, 5.90277016e-02f, -1.06712781e-01f, -7.96042234e-02f, -3.41147818e-02f, -1.15681358e-01f, -1.15403816e-01f, -6.71006963e-02f,
  -1.92622207e-02f, 1.00863777e-01f, -4.83655110e-02f, 1.43606625e-02f, 1.11526623e-01f, 6.83141872e-02f, 1.33741796e-02f, -8.72047022e-02f, 2.19670031e-02f, 7.79394582e-02f,
  1.31885603e-01f, 2.23357845e-02f, 1.27683312e-01f, -5.15927337e-02f, 4.87550311e-02f, 1.04029290e-01f, 4.94458042e-02f, 1.42820626e-01f, 2.13807281e-02f, -4.65246513e-02f,
  -4.76783551e-02f, -3.80944461e-02f, -3.45400050e-02f, -4.20585740e-04f, -7.22575337e-02f, 7.58975148e-05f, 9.92410332e-02f, -2.62059066e-02f, 6.94368258e-02f, -6.88061938e-02f,
  7.26808533e-02f, 1.81531813e-02f, 2.37941891e-02f, 1.73069537e-02f, -9.80976745e-02f, -6.40113801e-02f, 8.66868347e-02f, 8.12136475e-03f, 3.50234471e-02f, -2.11516209e-02f,
  4.22092974e-02f, -6.39775321e-02f, 6.46508038e-02f, -2.76066288e-02f, 7.90164247e-02f, -3.09453011e-02f, -2.58306600e-02f, 1.07835770e-01f, 4.82721105e-02f, 3.17325108e-02f,
  -8.75675157e-02f, -5.49650863e-02f, 7.12968409e-02f, 9.04114321e-02f, -2.13024206e-02f, -1.92215685e-02f, 2.30614636e-02f, 3.32515948e-02f, -3.72318290e-02f, -8.76440629e-02f,
  -1.19583798e-03f, -4.07709479e-02f, 4.09818888e-02f, 5.94987012e-02f, -8.92393291e-02f, 6.66361153e-02f, 3.10258586e-02f, 1.99655015e-02f, 8.25063288e-02f, 1.01850808e-01f,
  -8.55770111e-02f, -6.08272441e-02f, -9.65830609e-02f, 4.43090647e-02f, -1.01038096e-02f, -3.97037342e-02f, 1.00016698e-01f, -3.08143292e-02f, 3.66207510e-02f, 2.21392382e-02f,
  -4.36653718e-02f, -1.78258922e-02f, 6.83830753e-02f, -2.09306721e-02f, -6.52716160e-02f, -5.04222251e-02f, -7.89836720e-02f, 6.86028823e-02f, -3.97645459e-02f, -4.30810414e-02f,
  -3.82191576e-02f, 4.50919755e-02f, 2.28221305e-02f, -4.74519935e-03f, 3.23310606e-02f, -6.48260266e-02f, -4.86986823e-02f, 5.19516245e-02f, 2.42077932e-02f, 7.87589252e-02f,
  5.46059869e-02f, -9.41889733e-02f, 2.72210967e-02f, 1.16988104e-02f, 4.47494574e-02f, -8.81479234e-02f, -4.51789871e-02f, 2.12586597e-02f, -7.46817812e-02f, 4.88594957e-02f,
  -3.66578370e-01f, 1.12751283e-01f, -1.58390090e-01f, -2.62427062e-01f, 2.36261524e-02f, -4.93042767e-02f, -5.53774051e-02f, 4.58447374e-02f, -1.65016815e-01f, 1.41936317e-01f,
  -1.76462270e-02f, 3.96641865e-02f, 8.34881235e-03f, -2.54537880e-01f, -2.97478139e-01f, -1.48590997e-01f, -3.56422722e-01f, -1.12983383e-01f, -7.28160590e-02f, -2.76281126e-02f,
  -1.06928550e-01f, -9.94805247e-02f, -1.72035500e-01f, 1.28929451e-01f, -4.49662432e-02f, 9.72806290e-02f, 6.65892661e-02f, 1.89745918e-01f, -1.02870382e-01f, 4.20053825e-02f,
  1.71553478e-01f, 2.36144483e-01f, 1.18218876e-01f, 4.13364545e-02f, 2.27496289e-02f, 2.78241839e-02f, -5.89359775e-02f, 6.83422238e-02f, 3.90160866e-02f, 2.15369761e-02f,
  -2.86141969e-02f, -3.04125343e-02f, -8.84654373e-03f, 1.14584360e-02f, 2.27569845e-02f, -6.64594099e-02f, -5.59862517e-02f, 1.53938858e-02f, 2.53659282e-02f, -4.92693074e-02f,
  -3.71399485e-02f, 1.43142929e-02f, -1.10522874e-01f, -1.20630130e-01f, -1.90840270e-02f, -5.38613349e-02f, -8.35771579e-03f, -8.28483403e-02f, 1.09477360e-02f, -4.59706932e-02f,
  -3.70565057e-02f, -7.46373013e-02f, -1.01178174e-03f, -3.42275351e-02f, 2.36809324e-03f, -2.42489222e-02f, -6.57777637e-02f, 4.55278009e-02f, -7.20619410e-02f, 1.56305032e-03f,
  5.81962876e-02f, -7.26894811e-02f, 3.04579455e-02f, -3.86658614e-03f, -5.47573008e-02f, -1.95832103e-02f, -1.85291916e-02f, 5.38255386e-02f, -5.55538721e-02f, 4.55334559e-02f,
  2.18999851e-02f, 5.65498369e-03f, -9.16523207e-03f, -2.04238109e-03f, -4.32596058e-02f, -6.11541001e-03f, -5.76082878e-02f, 9.11362544e-02f, 3.58148888e-02f, -1.82734779e-03f,
  -2.46646237e-02f, -1.47754494e-02f, -4.99580279e-02f, 1.02331646e-01f, -4.12488133e-02f, 1.50423953e-02f, -1.91525854e-02f, 4.95957490e-03f, -1.01056188e-01f, -4.72554043e-02f,
  -8.88097212e-02f, 1.07032582e-02f, -8.53195637e-02f, -2.98761930e-02f, -9.60085392e-02f, 8.81164148e-02f, -1.30004287e-02f, 4.11127470e-02f, -1.88202020e-02f, -8.94844532e-02f,
  1.13574572e-01f, 4.04128842e-02f, 2.00047269e-02f, -2.41557248e-02f, 6.32065311e-02f, -3.54877412e-02f, -8.20934623e-02f, -3.14493142e-02f, -8.60068947e-02f, -1.15544144e-02f,
  -2.07524166e-01f, 8.16284120e-02f, 4.01862822e-02f, -5.89055419e-02f, -1.97634511e-02f, 2.71030832e-02f, 1.35521889e-01f, -6.95929676e-02f, 8.09065998e-02f, 2.12703478e-02f,
  -2.00665202e-02f, -3.84247638e-02f, 1.25866339e-01f, -3.22609469e-02f, 4.91926484e-02f, 1.83775023e-01f, -9.51766968e-03f, 7.25994408e-02f, 1.09139169e-02f, -6.30973130e-02f,
  -7.00998083e-02f, -7.28577152e-02f, 2.00730320e-02f, -1.03440300e-01f, -9.53354016e-02f, -1.82668656e-01f, 1.38180582e-02f, -2.30725892e-02f, -5.14041819e-02f, -2.61413641e-02f,
  -1.31968245e-01f, -1.75575167e-01f, 3.47016864e-02f, -4.79935743e-02f, -1.23069942e-01f, -4.91717607e-02f, 1.66737102e-02f, 8.23176950e-02f, -7.94057325e-02f, -6.16905279e-02f,
  1.85094718e-02f, -9.21144709e-02f, -1.14124790e-02f, 4.26389761e-02f, 1.23355789e-02f, -3.73535641e-02f, 1.81424525e-02f, -1.21836131e-02f, 3.69926132e-02f, -6.16632344e-04f,
  1.72508303e-02f, 3.15830600e-03f, -4.87250648e-02f, 8.46975134e-04f, -6.61578625e-02f, -7.28133246e-02f, 5.92615232e-02f, 3.96325774e-02f, -4.08319663e-03f, -7.02162161e-02f,
  -1.34592569e-02f, 5.38443625e-02f, 2.38909945e-02f, 6.49384633e-02f, -7.78366700e-02f, 7.89457411e-02f, -2.04999372e-02f, 6.63210228e-02f, 5.98023552e-03f, 3.89095210e-03f,
  -5.03222235e-02f, 2.89134663e-02f, -2.86662299e-02f, 1.76261086e-02f, -5.68967834e-02f, 6.70307204e-02f, 2.19323728e-02f, 4.87136990e-02f, 4.99036461e-02f, -4.32932600e-02f,
  6.55469894e-02f, 2.35610344e-02f, 1.83429606e-02f, 3.87784131e-02f, -1.55610563e-02f, -9.25120839e-04f, 1.34391617e-02f, 4.55526859e-02f, 4.60000262e-02f, -8.05099905e-02f,
  4.27405275e-02f, -1.56834662e-01f, 4.68048081e-02f, -4.63153347e-02f, -9.95852798e-02f, 1.48386871e-02f, -1.10280998e-01f, -7.50443712e-02f, -1.08308375e-01f, 8.52221716e-03f,
  -1.25580341e-01f, 7.92586654e-02f, -9.90478098e-02f, -8.00744817e-02f, -4.62011211e-02f, 7.05084130e-02f, -1.00075364e-01f, -4.40535210e-02f, 7.16194436e-02f, -6.64765090e-02f,
  -4.49715517e-02f, -1.05652064e-02f, -1.28042605e-02f, -7.28314891e-02f, 4.13711295e-02f, -7.69619793e-02f, -2.84042209e-02f, 7.68922176e-03f, 1.03033623e-02f, -5.14851846e-02f,
  -1.06927350e-01f, -5.47647960e-02f, 1.18815556e-01f, 4.29348508e-03f, 1.25061691e-01f, 4.29747738e-02f, -6.03104383e-02f, 9.78620127e-02f, 7.13990033e-02f, -1.26705751e-01f,
  -6.07629716e-02f, -1.50475264e-01f, -4.46128845e-03f, -5.07496111e-02f, -1.23240627e-01f, 1.28162116e-01f, -1.36014923e-01f, -4.87490483e-02f, 3.65992822e-02f, 1.87733429e-04f,
  -4.31856662e-02f, 9.06714424e-02f, 3.72072086e-02f, -3.39028575e-02f, 7.69608021e-02f, -4.05418500e-03f, -3.32374349e-02f, 1.01334833e-01f, -1.10765502e-01f, -1.75027158e-02f,
  3.23697329e-02f, 5.99024668e-02f, 1.91694163e-02f, 1.86603386e-02f, -7.95309246e-02f, -1.03892915e-01f, -1.22064471e-01f, -4.88266945e-02f, -1.33409366e-01f, -5.92408404e-02f,
  -1.82321500e-02f, -6.60648271e-02f, -6.65248111e-02f, 2.39937808e-02f, 3.36378962e-02f, -6.12959974e-02f, 3.76741700e-02f, -6.85278997e-02f, -4.93398169e-03f, 8.68421271e-02f,
  1.99324228e-02f, 2.12852024e-02f, -4.99339364e-02f, -1.26723096e-01f, 1.13700680e-01f, -1.98459942e-02f, -5.08411229e-02f, -5.89038022e-02f, -5.38807549e-02f, -1.19233765e-01f,
  2.14033265e-04f, 1.15509957e-01f, 1.13709398e-01f, -5.78420535e-02f, 8.91292915e-02f, 7.97061995e-02f, 1.15601465e-01f, 6.21856377e-03f, 9.71114710e-02f, 7.88567774e-03f,
  -5.75831085e-02f, 1.29225263e-02f, 8.79970640e-02f, -1.06928553e-02f, -3.17026563e-02f, 5.41768931e-02f, -2.82818861e-02f, -8.06796178e-02f, 3.95511165e-02f, -1.40935285e-02f,
  -1.73431672e-02f, -8.86889733e-03f, -1.05411530e-01f, -5.19616455e-02f, 1.23069738e-03f, 1.20295048e-01f, -9.91198644e-02f, -4.45569493e-02f, -9.35177726e-04f, -3.14636342e-03f,
  -2.35276461e-01f, -1.20937727e-01f, -6.53780848e-02f, -1.03961043e-01f, 2.53568441e-02f, -9.55951512e-02f, -1.36498467e-03f, -3.13458480e-02f, 2.75883209e-02f, 5.80111332e-02f,
  -1.72669590e-02f, -5.06321080e-02f, 1.51363928e-02f, -1.16463415e-01f, 3.30054536e-02f, -8.81563053e-02f, -3.93968113e-02f, -6.53249845e-02f, -1.39396608e-01f, -6.20336365e-03f,
  -1.50287509e-01f, -9.82516794e-04f, 4.46442924e-02f, -3.59014869e-02f, -1.09292820e-01f, -8.61081854e-02f, 3.93217057e-02f, -3.15666273e-02f, -5.50598688e-02f, -3.14509980e-02f,
  2.81999558e-02f, 3.39296162e-02f, 1.88195020e-01f, -8.91055837e-02f, 8.85270387e-02f, -8.48723352e-02f, -2.92998515e-02f, -1.04727387e-01f, -1.06208347e-01f, -1.49850175e-01f,
  -1.64408591e-02f, -5.18543608e-02f, 1.12634294e-01f, 2.39883699e-02f, 1.29841805e-01f, 1.05632164e-01f, -8.70155320e-02f, -9.56387371e-02f, -7.57985562e-02f, -1.44839913e-01f,
  6.59583509e-02f, -6.50901645e-02f, 8.74845237e-02f, 8.68720934e-03f, 3.02581917e-02f, -1.03273027e-01f, 7.47883692e-02f, 9.18193832e-02f, -2.21230257e-02f, 9.65811834e-02f,
  -1.32213742e-01f, 3.35496664e-02f, 6.77143857e-02f, 1.53339999e-02f, 4.37777415e-02f, 7.42106810e-02f, -8.24692622e-02f, -7.18567846e-03f, -9.02162492e-03f, 2.40718834e-02f,
  -3.40212099e-02f, 4.43091020e-02f, -8.89164656e-02f, 3.33783925e-02f, -3.46764289e-02f, 4.58734902e-03f, 8.62871483e-02f, 1.62951276e-03f, 1.76944360e-02f, -5.56853861e-02f,
  9.64061171e-02f, -5.19032106e-02f, -4.49539199e-02f, -4.31937315e-02f, 3.58965099e-02f, 8.39020386e-02f, 7.32354596e-02f, 8.50453898e-02f, -7.24570900e-02f, 3.20374519e-02f,
  9.23761949e-02f, 5.63360378e-02f, 5.15706502e-02f, -4.47199047e-02f, 3.97778265e-02f, -5.14375046e-02f, 7.34710097e-02f, 4.66989279e-02f, 5.46501949e-02f, -1.00747027e-01f,
  -6.94280490e-02f, 6.83072880e-02f, 2.01157089e-02f, 4.71527912e-02f, -8.52469429e-02f, -8.63102973e-02f, 3.67194973e-02f, -8.82046893e-02f, -2.01844657e-03f, -5.82905021e-03f,
  3.73156741e-02f, -4.97448295e-02f, 1.35419937e-02f, -5.22987684e-03f, 6.33530989e-02f, 2.25234162e-02f, 3.23514231e-02f, 2.94459946e-02f, -5.13799675e-02f, -2.27363706e-02f,
  -1.58352107e-01f, -5.06482162e-02f, -1.05109185e-01f, -3.08361910e-02f, -2.30058786e-02f, -1.09955447e-03f, -7.22276792e-02f, -6.50556758e-02f, -4.19250168e-02f, 3.50259431e-03f,
  5.04900850e-02f, -5.96897639e-02f, 1.42081343e-02f, 7.47501552e-02f, -3.83400358e-02f, -8.14572349e-02f, 3.84298265e-02f, 1.51561750e-02f, -7.65909106e-02f, 7.53840373e-04f,
  -3.02691851e-02f, 7.82417059e-02f, 7.53712207e-02f, -1.07565988e-03f, 5.08589000e-02f, -7.39553198e-02f, -4.35919166e-02f, -4.12337519e-02f, -3.22292675e-03f, 8.19240976e-03f,
  -2.35214069e-01f, -8.02230984e-02f, -1.11636326e-01f, -1.79967567e-01f, 6.65917322e-02f, -7.04988465e-02f, -8.82508904e-02f, 2.08914205e-02f, -4.91321906e-02f, 1.67956769e-01f,
  5.96448965e-03f, -1.70564100e-01f, 3.04224901e-02f, -1.03943378e-01f, -1.62439659e-01f, -1.60563856e-01f, -2.07806930e-01f, -1.14994369e-01f, -1.30139947e-01f, -9.17445868e-02f,
  -2.06611320e-01f, -4.06350121e-02f, -2.15040237e-01f, 4.71956544e-02f, 2.29164362e-02f, 6.78881854e-02f, 4.39847037e-02f, 9.97927859e-02f, 3.07833813e-02f, -9.93641280e-03f,
  -8.61018673e-02f, 1.33826450e-01f, 1.98006909e-02f, 1.19107105e-01f, 9.30559188e-02f, 9.30399075e-03f, 5.68060838e-02f, 7.10048676e-02f, -3.82768437e-02f, -2.86526904e-02f,
  -2.55558118e-02f, -5.57478480e-02f, 1.68886818e-02f, -3.83893698e-02f, 9.27885063e-04f, 1.64997149e-02f, 3.96849997e-02f, 2.12429855e-02f, -6.92942813e-02f, 5.96526787e-02f,
  -3.28566097e-02f, -3.67103294e-02f, -5.55124469e-02f, -2.62453891e-02f, -4.40717191e-02f, -5.32515943e-02f, -2.89097112e-02f, -3.25052254e-02f, 5.26072085e-02f, 2.72901170e-02f,
  -8.45573843e-02f, 2.12704688e-02f, -2.04958376e-02f, 3.17547098e-02f, -1.87628437e-02f, 5.05067185e-02f, 5.55793978e-02f, 5.55454120e-02f, 5.02515621e-02f, 6.28572479e-02f,
  -3.21858749e-02f, -4.45301495e-02f, -6.49882779e-02f, -6.10690527e-02f, -5.60783781e-02f, -3.32361087e-02f, -6.76891580e-02f, 7.85617903e-02f, -9.19357017e-02f, 4.94326241e-02f,
  3.46826278e-02f, 4.04992215e-02f, -1.07819866e-03f, 3.77296619e-02f, 2.21253633e-02f, 2.59234495e-02f, 3.61625440e-02f, -8.88220966e-02f, -4.63533886e-02f, -2.06801053e-02f,
  3.01271118e-02f, 1.72323510e-01f, 1.17743090e-01f, 7.67533258e-02f, -3.90864052e-02f, -2.68251672e-02f, -1.39508175e-03f, -6.09768629e-02f, 9.20261070e-03f, 6.19745813e-02f,
  1.23164020e-01f, -3.33142839e-02f, 4.11537513e-02f, 7.57616907e-02f, 1.73703469e-02f, -1.07343532e-02f, -3.76121104e-02f, 7.12243021e-02f, 5.15501127e-02f, -4.26566694e-03f,
  -1.87754594e-02f, -4.00492884e-02f, 1.39347175e-02f, -6.34001642e-02f, -2.76761446e-02f, 4.92671877e-02f, 8.28986168e-02f, 6.51891306e-02f, 2.45257150e-02f, -4.28351685e-02f,
  -7.29541108e-02f, -5.37942722e-02f, 1.39167860e-01f, 3.76217719e-03f, -9.38040577e-03f, -1.12999201e-01f, -7.27879256e-02f, 3.27853374e-02f, -1.87278017e-01f, -1.51136443e-01f,
  1.61402300e-02f, 4.08825614e-02f, -1.20001659e-01f, -5.64570390e-02f, 6.73451871e-02f, -1.53771922e-01f, 8.89549702e-02f, -2.37541664e-02f, -3.90456505e-02f, 1.31838575e-01f,
  1.52910605e-01f, -1.15300473e-02f, 7.61305913e-02f, 1.70763135e-01f, 1.89865772e-02f, 6.69116080e-02f, 1.30820692e-01f, 1.05950097e-03f, 1.85527816e-01f, 2.71770190e-02f,
  -4.35996661e-03f, -6.03007786e-02f, 5.12622744e-02f, -9.77317318e-02f, -4.16778810e-02f, 7.95564950e-02f, -2.12166030e-02f, 1.02690704e-01f, -1.03803026e-02f, -5.17720096e-02f,
  2.93564275e-02f, 5.21435067e-02f, -5.50908744e-02f, 1.03871617e-02f, -8.14330727e-02f, 9.92826447e-02f, 4.47904356e-02f, 5.54431155e-02f, 6.15990311e-02f, 1.08217992e-01f,
  8.69482607e-02f, -4.18695360e-02f, 9.85945947e-03f, 7.13547841e-02f, 1.09073855e-01f, -5.46541400e-02f, 2.46918406e-02f, 1.25892879e-02f, 5.15041389e-02f, 1.27278045e-02f,
  -1.07494384e-01f, -5.99811301e-02f, -6.37667403e-02f, 7.62843862e-02f, -7.05443847e-04f, 4.26114127e-02f, -7.80933052e-02f, 3.32619213e-02f, -6.81420118e-02f, 4.55287397e-02f,
  2.10523140e-02f, -5.26833236e-02f, -6.67427778e-02f, 8.98473412e-02f, -3.35396975e-02f, 9.33721289e-03f, 4.01181281e-02f, -1.18659949e-02f, 2.21501123e-02f, -3.21646407e-02f,
  3.64544429e-02f, 2.95479372e-02f, 4.19701869e-03f, 4.89992499e-02f, -6.55725747e-02f, -7.01960623e-02f, 4.30585369e-02f, 8.85340478e-03f, -4.44886237e-02f, 6.21382799e-03f,
  -1.03931919e-01f, 4.14738730e-02f, -3.95323709e-02f, -4.90771271e-02f, -1.89301446e-02f, 5.11685573e-02f, 2.93798819e-02f, -1.03742585e-01f, -7.30274916e-02f, -3.70806567e-02f,
  -8.10924694e-02f, 5.80626279e-02f, -2.23984681e-02f, 3.47425081e-02f, 1.65925585e-02f, 1.37458779e-02f, -3.34434118e-03f, 4.05960670e-03f, -3.08649298e-02f, 4.28786092e-02f,
  3.04793753e-02f, 6.32149130e-02f, 3.19753699e-02f, 4.82942723e-02f, 9.91983190e-02f, -4.69136834e-02f, 2.16123592e-02f, -1.59797724e-02f, -4.28129882e-02f, 4.34788130e-02f,
  2.05416635e-01f, -6.24318011e-02f, -5.08840308e-02f, 8.20222646e-02f, -1.16022438e-01f, -3.41826260e-01f, -3.16087574e-01f, 3.81878912e-02f, -1.54219627e-01f, -4.23371717e-02f,
  9.87407863e-02f, 4.89634164e-02f, -5.98538518e-02f, 8.33712220e-02f, 1.17191814e-01f, -7.38068894e-02f, 1.82533618e-02f, 1.50964558e-02f, 6.25627041e-02f, 2.18041673e-01f,
  2.04232559e-01f, 3.04704398e-01f, 2.04280794e-01f, 1.99665874e-01f, 2.62364894e-01f, 2.06011251e-01f, 3.15897286e-01f, 3.05087604e-02f, 1.95811465e-01f, 5.91599494e-02f,
  -8.21129158e-02f, 1.06745236e-01f, -7.04175234e-02f, 2.70638578e-02f, -3.09340339e-02f, 9.22150258e-03f, -1.59286745e-02f, -6.31432533e-02f, 3.05085443e-03f, 4.53603603e-02f,
  -2.51760259e-02f, -1.88721751e-03f, 3.70648690e-02f, 4.15662490e-02f, -4.09038365e-02f, -2.73655169e-02f, 2.01335158e-02f, 5.47030643e-02f, -1.04324808e-02f, 5.25063463e-02f,
  -4.29694206e-02f, -5.60761988e-02f, 4.25286628e-02f, -4.90254052e-02f, -3.37716937e-02f, -1.94063708e-02f, 6.12038039e-02f, -2.06258949e-02f, -6.59829378e-03f, -1.46498661e-02f,
  7.67939612e-02f, 1.45159680e-02f, 3.23488340e-02f, 1.52257066e-02f, 1.96347721e-02f, 3.85571979e-02f, -8.31364244e-02f, -1.48267224e-02f, 9.74687468e-03f, -1.54958796e-02f,
  3.56961228e-02f, 1.76766980e-02f, -1.08930813e-02f, 2.70216819e-03f, 1.59477815e-02f, -5.93247563e-02f, 1.15144481e-04f, 4.30645943e-02f, -2.78653856e-02f, -7.91139305e-02f,
  -3.43884304e-02f, 7.16861486e-02f, 5.09089641e-02f, -7.03803822e-02f, 3.19745429e-02f, 6.40864074e-02f, 5.57558537e-02f, 5.92185482e-02f, 4.21322836e-03f, 3.29643674e-03f,
  4.38310094e-02f, 3.17249179e-01f, 2.04261467e-02f, -2.95622125e-02f, -1.40685728e-02f, -4.32094224e-02f, 1.20006744e-02f, 8.20220634e-02f, 2.73198672e-02f, 1.59195438e-02f,
  6.93291472e-03f, -1.03564598e-02f, 6.46285564e-02f, 3.09200678e-03f, 7.34819770e-02f, 4.92352396e-02f, 1.47130489e-01f, 3.91578376e-02f, 1.15914671e-02f, 7.84488693e-02f,
  1.03636630e-01f, 1.79511365e-02f, 6.99373847e-03f, -8.69112313e-02f, -7.20408112e-02f, -1.26553513e-03f, -2.71103997e-02f, -3.36854532e-02f, 4.10308763e-02f, 6.29704818e-02f,
  -5.04329503e-01f, 6.04340658e-02f, -2.18629152e-01f, -2.62712002e-01f, 3.06634270e-02f, -1.79572646e-02f, -1.77183338e-02f, -2.06527323e-03f, -1.77228361e-01f, 6.96995109e-02f,
  5.34031168e-02f, -1.89751029e-01f, 7.27912486e-02f, -1.04456335e-01f, -2.48661473e-01f, -4.13853601e-02f, -2.28798371e-02f, -9.05595068e-03f, -1.53945267e-01f, 2.32351106e-02f,
  -2.05576029e-02f, 8.04780126e-02f, -1.10025398e-01f, 1.10445440e-01f, -7.69317076e-02f, -3.88134358e-04f, 9.42060316e-04f, 1.07414819e-01f, 4.06975374e-02f, -2.95085050e-02f,
  3.24068442e-02f, -1.41982824e-01f, -6.10441566e-02f, -9.54694524e-02f, -6.69226795e-02f, 9.66563746e-02f, 5.49937859e-02f, 9.49412882e-02f, 2.27061324e-02f, 5.14811575e-02f,
  9.19521227e-03f, 8.01008269e-02f, -3.24323773e-03f, -3.29561420e-02f, 8.60156212e-03f, 5.29364534e-02f, 5.12015745e-02f, 4.44719829e-02f, -4.05245423e-02f, -1.02409035e-01f,
  -6.16723709e-02f, -4.25379612e-02f, -1.40936831e-02f, -7.38274008e-02f, -1.07851587e-01f, 8.40118527e-02f, -3.52225602e-02f, 5.26186600e-02f, -1.04017586e-01f, -4.45798934e-02f,
  4.95284982e-02f, -5.28353900e-02f, -5.80823198e-02f, 3.35979946e-02f, -6.14246354e-02f, 7.59880571e-03f, -2.76102126e-03f, 3.80140431e-02f, -4.23211008e-02f, 7.28891790e-02f,
  -2.17832122e-02f, -2.51194611e-02f, 4.59645838e-02f, -1.39144983e-03f, 7.89106339e-02f, 2.55572516e-02f, 6.93808198e-02f, -3.07251886e-02f, 6.31288961e-02f, -7.51920491e-02f,
  -7.16475993e-02f, 7.72284158e-03f, 2.81754918e-02f, -7.61559792e-03f, 1.94121841e-02f, 1.11043472e-02f, -2.00795755e-02f, 7.78298592e-03f, 1.41481040e-02f, -2.37824228e-02f,
  1.59435405e-03f, -1.91121161e-01f, -9.64568406e-02f, -5.47361635e-02f, -3.46807204e-02f, -2.65141260e-02f, -9.09875259e-02f, -1.06104985e-01f, -4.28835824e-02f, -8.93270969e-03f,
  -7.63536012e-03f, 1.05985617e-02f, -4.47028456e-03f, 7.16643557e-02f, 4.24493253e-02f, -2.95283329e-02f, 2.78531257e-02f, 1.09475488e-02f, -9.18441862e-02f, 2.25650035e-02f,
  -1.03479497e-01f, -1.88113861e-02f, -4.35778834e-02f, 7.97165930e-02f, 1.13970526e-01f, 8.23416933e-02f, 1.10748634e-02f, 4.48343381e-02f, -6.44804537e-02f, -3.10017895e-02f,
  1.18870728e-01f, -1.80484373e-02f, -1.23947956e-01f, -8.04618597e-02f, -9.22408476e-02f, 2.59805266e-02f, 2.21563410e-02f, -2.26737279e-02f, -4.59753210e-03f, -3.04596573e-02f,
  2.81771994e-03f, 4.37474735e-02f, 5.00402600e-02f, 8.28456730e-02f, 8.28011706e-03f, -1.35000693e-02f, 6.07113428e-02f, -6.38833968e-03f, -8.15935433e-02f, 9.36935022e-02f,
  -2.14047395e-02f, -2.75590154e-03f, -7.84672424e-02f, -8.72507021e-02f, -7.05919936e-02f, -2.76514590e-02f, 8.02190416e-03f, -5.96006811e-02f, -1.54717863e-02f, -8.22495967e-02f,
  5.68794422e-02f, 6.31930307e-02f, 2.98430081e-02f, 5.83342910e-02f, 1.46382349e-02f, -1.92630999e-02f, 7.88587481e-02f, 6.07700869e-02f, -4.56256270e-02f, -8.36630315e-02f,
  -1.58572569e-02f, 3.26685086e-02f, 6.52434751e-02f, 7.71986367e-03f, 4.05044900e-03f, 6.22054450e-02f, -1.65068544e-02f, 5.72194019e-03f, 5.59816398e-02f, 3.73685248e-02f,
  5.24640046e-02f, -7.11020678e-02f, -5.38011678e-02f, -6.39442950e-02f, -4.75408696e-03f, -3.47919725e-02f, 2.87987757e-02f, 2.34818123e-02f, -5.30732274e-02f, -6.55719712e-02f,
  -8.03538114e-02f, 7.89924189e-02f, -2.53688842e-02f, -4.98681739e-02f, 8.38259421e-03f, -4.27291319e-02f, -2.15306561e-02f, 7.00169057e-02f, 6.55096490e-03f, 4.33949195e-02f,
  6.06220178e-02f, 4.88046072e-02f, 2.64301449e-02f, 3.39503177e-02f, 6.09616973e-02f, 7.68701583e-02f, 8.25558752e-02f, -3.46127003e-02f, 4.57009375e-02f, 3.18434238e-02f,
  1.58442445e-02f, 1.13073634e-02f, -2.02434938e-02f, -7.35451803e-02f, 1.54229440e-02f, -4.89352904e-02f, 2.24846322e-02f, 4.95327450e-02f, 5.74214756e-02f, -4.40793671e-02f,
  5.87863177e-02f, -5.52968383e-02f, -3.28079611e-02f, -6.73817983e-03f, 2.06115730e-02f, 2.19905917e-02f, -1.77776497e-02f, 6.14860542e-02f, 8.98855254e-02f, 2.90053524e-02f,
  -7.34490231e-02f, 7.51478374e-02f, -3.38899866e-02f, -5.30455932e-02f, 2.51685940e-02f, 3.84510048e-02f, 1.55390492e-02f, -6.89738244e-03f, -3.60650779e-03f, -1.12721622e-01f,
  -9.00751632e-03f, 5.23042493e-02f, 6.33888021e-02f, 3.61069217e-02f, -6.57559186e-02f, -2.42383871e-02f, 6.01218492e-02f, -2.44697575e-02f, 2.28233426e-03f, 2.60395482e-02f,
  -3.23710829e-01f, -1.05697826e-01f, -4.51830402e-02f, 3.62911597e-02f, 5.16669005e-02f, 5.65010048e-02f, 1.18419677e-01f, 1.16918147e-01f, -1.88807070e-01f, 2.16389522e-01f,
  1.25653744e-01f, -7.73298740e-02f, -2.92712301e-02f, -3.32247764e-02f, -1.04601495e-01f, -1.05398007e-01f, 9.31877419e-02f, 1.21081538e-01f, -1.80127308e-01f, 1.75108716e-01f,
  -4.47611772e-02f, 1.19644038e-01f, 6.38893768e-02f, 4.05732989e-02f, 6.57925233e-02f, 1.43901289e-01f, 1.83316514e-01f, -2.30954085e-02f, 1.28532872e-01f, 3.32312025e-02f,
  1.06342612e-02f, 3.80693898e-02f, -1.08904643e-02f, 4.72607324e-04f, 1.11576028e-01f, 5.81247173e-02f, 3.84098813e-02f, -9.27166417e-02f, 1.18992375e-02f, -8.59089289e-03f,
  -2.27337293e-02f, 2.37427186e-02f, 8.52955133e-03f, -5.11254109e-02f, -3.99296060e-02f, -8.93450715e-03f, -6.00776263e-02f, 2.73855254e-02f, -6.04651310e-02f, 3.08200829e-02f,
  4.81494889e-02f, 9.77054145e-03f, 7.03362226e-02f, -5.50743043e-02f, -9.30938944e-02f, 1.01331219e-01f, 2.92562544e-02f, 9.60071571e-03f, -1.02633052e-02f, -1.07827568e-02f,
  3.78442276e-03f, 2.30700988e-02f, -3.83698232e-02f, -1.08516768e-01f, -5.41308783e-02f, -2.80493740e-02f, -4.66169715e-02f, -8.82297456e-02f, -1.11351293e-02f, 2.66236030e-02f,
  -4.32581007e-02f, 6.16433620e-02f, 5.60008129e-03f, 5.83850071e-02f, -4.58137989e-02f, 6.02013133e-02f, 6.93946630e-02f, -6.80458546e-02f, -2.97560096e-02f, -6.20687241e-03f,
  7.10424110e-02f, -1.05754182e-01f, 1.20598054e-03f, 6.21472783e-02f, 7.36151412e-02f, -5.81610203e-02f, 8.12643170e-02f, -7.80280605e-02f, -6.27760738e-02f, -3.83762410e-03f,
  2.00391516e-01f, 1.30488902e-01f, -6.72549233e-02f, -3.31491046e-02f, 3.55015732e-02f, -1.41213983e-02f, -5.17163018e-04f, 5.88252284e-02f, -1.58637799e-02f, 7.29251951e-02f,
  1.88562293e-02f, -1.69075597e-02f, 7.70341903e-02f, -5.79800382e-02f, -2.79835402e-03f, -1.09526087e-02f, 1.88325923e-02f, -4.50376086e-02f, 3.80332815e-03f, 4.69605178e-02f,
  8.50573480e-02f, -1.82400469e-03f, 3.38843167e-02f, 2.07754765e-02f, -1.65708195e-02f, 2.08616629e-02f, 8.43820348e-02f, -4.15025763e-02f, -4.89202291e-02f, -3.24658677e-02f,
  2.92530268e-01f, -2.67057180e-01f, -1.87173691e-02f, -2.69233376e-01f, -9.60583389e-02f, -3.62224162e-01f, -1.52906328e-01f, -3.25255513e-01f, -9.44904685e-02f, -3.52236241e-01f,
  -2.45017484e-01f, 1.90589935e-01f, 1.64621532e-01f, -4.24956471e-01f, 2.12208450e-01f, 1.65392652e-01f, -4.16946054e-01f, -1.58689633e-01f, 1.09592795e-01f, -2.52660662e-01f,
  -4.30198051e-02f, -3.06804806e-01f, 6.88160658e-02f, -2.96281576e-01f, -2.94287652e-01f, -3.05501539e-02f, 4.20040600e-02f, 5.34599274e-02f, -3.20966363e-01f, 5.57721145e-02f,
  -7.17650577e-02f, -9.01967511e-02f, -3.53087261e-02f, 1.31260172e-01f, 8.58109817e-02f, -2.68790871e-02f, 7.62591362e-02f, 1.49590820e-01f, 2.16234531e-02f, 4.63026762e-02f,
  4.71679978e-02f, 1.23811767e-01f, -9.06235576e-02f, 7.82067105e-02f, 5.60128177e-03f, 3.08330357e-02f, 2.66416073e-02f, -3.64032499e-02f, -2.00111028e-02f, 6.44645169e-02f,
  -7.24980701e-03f, 9.76371206e-03f, -4.85876836e-02f, 1.85635500e-02f, -8.73325858e-03f, -2.53356267e-02f, 4.50721905e-02f, 7.36860707e-02f, -3.60675752e-02f, -8.76105390e-03f,
  5.67324413e-03f, 2.34243777e-02f, 5.40177934e-02f, 2.28680875e-02f, 8.91679339e-03f, -2.45690122e-02f, -5.36941178e-03f, -1.33311898e-02f, 7.12663755e-02f, 1.52721722e-02f,
  5.13586262e-03f, -3.09965648e-02f, 4.23332676e-02f, 2.79896948e-02f, 2.01883111e-02f, 3.38955894e-02f, 5.36260195e-03f, -6.10225461e-02f, -7.56649673e-02f, -3.90343368e-02f,
  -5.58709316e-02f, 6.10302351e-02f, -1.01292515e-02f, -3.57388109e-02f, 7.64569780e-03f, 4.45170589e-02f, -9.69160348e-02f, -7.06906617e-02f, 1.38729000e-02f, 2.32848502e-03f,
  -1.82486042e-01f, -1.95560023e-01f, -8.43242854e-02f, 2.82018483e-02f, 2.97570229e-02f, -3.61081399e-02f, -7.19417185e-02f, -7.58708343e-02f, 8.40913225e-03f, -7.44331479e-02f,
  -3.94702032e-02f, 1.64744556e-02f, 4.15313169e-02f, -4.83465828e-02f, -7.73037449e-02f, -6.43246323e-02f, 1.92419812e-02f, -6.17260858e-02f, -7.11646304e-02f, 1.62609224e-03f,
  4.10602661e-03f, -8.48363191e-02f, 6.67039454e-02f, -8.40238184e-02f, -2.52492204e-02f, 7.39570484e-02f, 8.18919856e-03f, 4.14521098e-02f, 2.56296005e-02f, -3.86130325e-02f,
  -3.51787448e-01f, -9.39509645e-02f, -7.56667480e-02f, -1.07153513e-01f, -1.17741592e-01f, 1.02292020e-02f, 1.57309890e-01f, -2.05148414e-01f, -5.73957451e-02f, 1.62011355e-01f,
  1.15135051e-01f, -1.34338439e-01f, 1.37797788e-01f, 1.20405601e-02f, 6.37017703e-03f, 2.21780509e-01f, 2.14170711e-03f, 9.41182896e-02f, -1.14046782e-02f, -1.64771408e-01f,
  -4.21507619e-02f, -9.34814885e-02f, 1.42351732e-01f, -6.61668852e-02f, -1.36986328e-02f, -1.01421423e-01f, -7.41789788e-02f, -6.52274415e-02f, -1.04358561e-01f, -4.50674072e-02f,
  -1.44141197e-01f, -2.58068800e-01f, -8.99859741e-02f, -7.25821182e-02f, -6.98587447e-02f, -5.58285676e-02f, 5.69355153e-02f, 4.46254238e-02f, 3.38543877e-02f, -9.03073996e-02f,
  3.62684741e-03f, -1.55348824e-02f, -6.80556297e-02f, -4.22767922e-02f, -5.99479191e-02f, -1.30118832e-01f, -3.14164944e-02f, -6.35788664e-02f, 2.11313702e-02f, 1.80513561e-02f,
  -2.19694041e-02f, -5.74655943e-02f, 7.10975751e-02f, 4.75034863e-02f, 8.02014768e-02f, -3.82991806e-02f, 4.46422026e-04f, -3.32322568e-02f, 1.96329281e-02f, -6.02316968e-02f,
  -8.09326395e-03f, -6.50975760e-03f, -9.44390986e-03f, -9.54904314e-03f, 2.63858587e-02f, -2.75137536e-02f, -1.04226368e-02f, -7.11180046e-02f, 2.16763206e-02f, 1.09672628e-01f,
  -7.07487836e-02f, -2.44201813e-02f, -2.19455566e-02f, 6.07809983e-02f, 4.47894074e-02f, 1.51611445e-02f, 7.03846365e-02f, -5.56133352e-02f, -9.26628336e-03f, 7.00564310e-02f,
  1.07446991e-01f, -2.33076513e-02f, 1.46767944e-02f, 1.34914085e-01f, -1.06633775e-01f, 4.00798619e-02f, 5.52447364e-02f, 6.87805098e-03f, 1.00662289e-02f, -8.43784120e-03f,
  -1.69471517e-01f, -1.44297898e-01f, 3.27397063e-02f, -7.12693632e-02f, 1.37207936e-03f, -5.38850948e-02f, 7.40429163e-02f, -1.54927876e-02f, -6.43849522e-02f, -6.84556291e-02f,
  -1.14233136e-01f, -1.12267166e-01f, 1.18615627e-02f, -3.27623226e-02f, 8.42633322e-02f, -7.40008894e-03f, -3.39970067e-02f, 1.97604485e-02f, -3.90077941e-02f, -1.16579518e-01f,
  7.24240169e-02f, -3.83194163e-02f, 4.33854647e-02f, 6.14450239e-02f, -3.21187861e-02f, -2.90110521e-02f, 1.84659772e-02f, -3.11521031e-02f, -4.03891988e-02f, 5.72598688e-02f,
  -6.94595650e-02f, -2.00327769e-01f, 4.41261902e-02f, 2.44684964e-02f, 1.27252653e-01f, 4.19045351e-02f, -7.36055002e-02f, 7.50548095e-02f, -1.39831483e-01f, -2.20166177e-01f,
  -1.05307614e-02f, -6.85696974e-02f, -1.03113547e-01f, -4.49517102e-04f, 7.00101629e-02f, -1.01237424e-01f, 5.13223968e-02f, -7.73418322e-02f, 4.75497916e-02f, 9.78254993e-03f,
  1.15857281e-01f, 1.58663735e-01f, 2.39374012e-01f, 1.54555127e-01f, 1.04132868e-01f, 8.44670758e-02f, 3.95375676e-02f, 2.68728063e-02f, 2.40757406e-01f, 1.35267526e-01f,
  -4.42581587e-02f, -9.62018445e-02f, 4.73841690e-02f, -1.05213411e-01f, 4.09716517e-02f, -6.02320060e-02f, -5.71092870e-03f, 6.93370551e-02f, 9.18323323e-02f, -2.54242811e-02f,
  3.75568424e-03f, -1.83433462e-02f, 1.12190351e-01f, -3.07030529e-02f, -3.61415558e-02f, 6.17202409e-02f, 3.32601964e-02f, -1.90174337e-02f, 2.63806842e-02f, 5.04194275e-02f,
  -3.36918496e-02f, 5.49293123e-02f, -1.15209796e-01f, 8.81834179e-02f, -5.75274788e-02f, 1.48805464e-03f, -2.38424558e-02f, 4.34293412e-02f, -2.81157047e-02f, 2.73310747e-02f,
  6.03725910e-02f, -7.90643245e-02f, -1.66586265e-02f, 4.10097055e-02f, 5.77167533e-02f, 1.96108036e-02f, 6.85836934e-03f, -5.10279536e-02f, -6.25766888e-02f, 4.54741903e-02f,
  2.08194926e-02f, -6.49253353e-02f, -3.93720157e-02f, -6.18729629e-02f, -3.58359143e-02f, -1.70635041e-02f, 1.80173460e-02f, -4.33592089e-02f, -1.18779033e-01f, 3.31755131e-02f,
  -7.87957683e-02f, -5.34065142e-02f, -4.18415517e-02f, -2.52090096e-02f, -6.69231415e-02f, 1.68991946e-02f, -6.89597502e-02f, -7.02534989e-02f, -2.36264355e-02f, 1.09456740e-01f,
  -2.82957524e-01f, -1.03827827e-01f, 2.24746168e-02f, 1.97357498e-02f, -1.99670810e-02f, -1.20718166e-01f, 6.55513480e-02f, 4.24499139e-02f, -3.85168171e-03f, -3.49633731e-02f,
  2.10785214e-02f, -1.82646811e-02f, -3.71249579e-02f, 1.80377010e-02f, -4.54771779e-02f, -8.95440876e-02f, 4.38369848e-02f, -4.50573526e-02f, -7.39708692e-02f, -6.26763850e-02f,
  6.33893684e-02f, 2.29827445e-02f, 1.48202861e-02f, 1.87383965e-04f, -1.02549657e-01f, 3.40983458e-02f, 5.78223951e-02f, -4.84499559e-02f, 5.00414893e-02f, -2.99240071e-02f,
  -2.37675868e-02f, 6.63428232e-02f, 2.79436801e-02f, -1.04071582e-02f, -9.91723593e-03f, 4.45613358e-03f, -6.36262745e-02f, -5.78486472e-02f, 9.70343873e-02f, 3.18667404e-02f,
  -5.22550121e-02f, 1.85808577e-02f, 4.28068638e-02f, -5.75014316e-02f, -7.72414403e-03f, 9.56311151e-02f, 9.04686674e-02f, 1.12946071e-01f, 7.57026896e-02f, -5.20026265e-03f,
  3.88830937e-02f, -8.41300935e-02f, -3.29025313e-02f, -8.52383748e-02f, 2.22751256e-02f, -5.41242072e-03f, -8.19385424e-02f, -7.28531973e-03f, 5.78277074e-02f, -3.59664497e-04f,
  -4.38742675e-02f, 4.56490740e-02f, 5.53390346e-02f, -7.02737570e-02f, 2.84969360e-02f, -8.95196125e-02f, -1.31914960e-02f, -8.49458054e-02f, -1.27689727e-02f, -2.16446724e-02f,
  3.70032899e-02f, -4.12728041e-02f, -2.49963030e-02f, -7.82311484e-02f, 6.07416295e-02f, -1.24659538e-02f, -8.33848491e-02f, 1.98641568e-02f, 3.72024067e-02f, 3.13665308e-02f,
  -9.63593870e-02f, -7.71818981e-02f, -3.66904996e-02f, -6.43604668e-03f, 2.50425786e-02f, 3.21195610e-02f, -6.42596781e-02f, -2.20922492e-02f, 6.12251721e-02f, 4.24639806e-02f,
  6.48863688e-02f, -6.23921230e-02f, -2.68889610e-02f, -4.31106724e-02f, -4.96329032e-02f, -2.48776879e-02f, 4.75712530e-02f, 3.46492231e-02f, -1.58795640e-02f, 1.12420972e-02f,
  8.14611763e-02f, -8.21798220e-02f, 2.37921579e-03f, 7.82904308e-03f, -3.38329151e-02f, -4.73514237e-02f, 6.45663813e-02f, 6.19156994e-02f, 1.30499452e-02f, 3.15180384e-02f,
  3.56674679e-02f, 6.13855124e-02f, -3.51409540e-02f, -8.28495156e-03f, 3.15844044e-02f, -1.19394036e-02f, -7.29916021e-02f, 4.81616743e-02f, 5.93782775e-02f, -1.48701966e-02f,
  3.98047045e-02f, 5.87904789e-02f, -1.83951631e-02f, -5.40446937e-02f, 8.29176232e-02f, 2.47936621e-02f, 7.76494220e-02f, -6.61162734e-02f, -3.54428068e-02f, 1.12875011e-02f,
  -7.48853460e-02f, -8.79541859e-02f, -3.11656166e-02f, -2.08232757e-02f, 1.10937227e-02f, 6.55074120e-02f, -1.41186756e-03f, -6.06132858e-02f, 5.68134747e-02f, 1.40082752e-02f,
  -6.52520284e-02f, 6.83292523e-02f, 1.42647335e-02f, -1.94280948e-02f, -7.33779445e-02f, -8.20670202e-02f, 1.27411736e-02f, 2.42725685e-02f, -1.95935853e-02f, -3.64853367e-02f,
  2.62113452e-01f, -3.51503968e-01f, -2.59168983e-01f, -6.73940554e-02f, 3.48735482e-01f, 2.48517171e-01f, 8.17624554e-02f, -1.18333697e-02f, -1.92837074e-01f, -1.98605806e-01f,
  1.26981199e-01f, -9.76017937e-02f, -3.22662950e-01f, 2.49864399e-01f, 2.98827142e-01f, -2.01056316e-01f, 1.91074148e-01f, 1.12233564e-01f, -1.62452400e-01f, -1.82866156e-02f,
  6.18147738e-02f, 3.98522675e-01f, -7.15677068e-02f, 1.98058352e-01f, 1.38373241e-01f, 4.25576558e-03f, 1.13147803e-01f, -5.75467609e-02f, 2.10083112e-01f, 1.72344074e-01f,
  1.97919548e-01f, 3.25119495e-02f, 6.16268776e-02f, 1.97623800e-02f, 1.63136609e-02f, 6.41377717e-02f, -2.15044077e-02f, 2.87207104e-02f, -6.68017427e-03f, -7.15977252e-02f,
  -1.25735486e-02f, 8.04110616e-02f, 3.36223692e-02f, -9.12492629e-03f, -2.55259965e-02f, 3.32650021e-02f, 1.13354456e-02f, -3.18612496e-04f, -5.45023233e-02f, -8.44842419e-02f,
  -8.40954557e-02f, -7.00194687e-02f, -1.76152773e-02f, -9.84712411e-03f, -2.42686551e-02f, -5.72653376e-02f, -2.92197801e-02f, -3.04602757e-02f, 3.88019718e-02f, -4.39978763e-03f,
  -3.71443667e-02f, -3.55750434e-02f, 6.41364139e-03f, 5.27774356e-02f, -2.66991314e-02f, -1.58487018e-02f, 4.35684547e-02f, 1.36329792e-02f, 1.35346334e-02f, -3.21961865e-02f,
  -3.14501338e-02f, -2.15995479e-02f, -5.34807369e-02f, -1.04752630e-02f, -2.25725546e-02f, -3.02987434e-02f, -3.74930166e-03f, 1.00744953e-02f, -3.72854024e-02f, -2.00806744e-02f,
  -4.41257842e-03f, 3.17945331e-02f, -3.45539153e-02f, 4.70281616e-02f, -1.35934232e-02f, 2.09580027e-02f, -3.28394473e-02f, -2.46791895e-02f, -3.09151616e-02f, -2.83146501e-02f,
  3.15630506e-03f, -1.84699118e-01f, 2.64492788e-04f, 5.33033125e-02f, -3.19028609e-02f, 9.37160477e-02f, 3.27414237e-02f, -5.94866090e-03f, 2.27636788e-02f, 3.79307158e-02f,
  2.26290501e-03f, -2.78342776e-02f, -4.86542471e-03f, 2.05974635e-02f, 4.04473655e-02f, 3.20610665e-02f, -1.22840188e-01f, -6.83188159e-03f, -1.02321003e-02f, -4.79019359e-02f,
  -2.56918222e-02f, -5.49388900e-02f, 3.45466323e-02f, 4.35985671e-03f, 4.91804481e-02f, -2.17479914e-02f, -9.38051865e-02f, -6.15275539e-02f, -6.43991753e-02f, -4.47004363e-02f,
  -2.23153800e-01f, 7.37863453e-03f, -1.45542711e-01f, -9.38655287e-02f, 1.83726894e-03f, 1.81387782e-01f, 4.46919575e-02f, -3.99645008e-02f, 1.81164853e-02f, 2.62002468e-01f,
  1.75848469e-01f, -7.80476481e-02f, -1.78774484e-02f, 4.50929813e-02f, -1.78718008e-02f, -6.85495585e-02f, 1.71019748e-01f, 1.31752014e-01f, -1.22244619e-01f, 5.67411445e-02f,
  -6.16204273e-03f, 8.10990855e-02f, -1.65021718e-01f, -6.10981807e-02f, 4.13985103e-02f, -6.65066391e-02f, 1.69907231e-02f, -9.45884138e-02f, 1.06054440e-01f, -1.04602706e-02f,
  -4.61632237e-02f, 1.55156953e-02f, -1.08703533e-02f, 1.71924895e-03f, 6.76592812e-02f, 8.21277797e-02f, -8.98022428e-02f, -1.11965150e-01f, -1.16948672e-01f, 5.01196412e-03f,
  4.29712832e-02f, -2.76370049e-02f, -6.58480218e-03f, 9.26381908e-03f, 3.23127978e-03f, 2.32582185e-02f, -1.04934976e-01f, -6.28766194e-02f, -5.07148057e-02f, -5.58668282e-03f,
  -1.14156753e-01f, 4.78726961e-02f, -8.03229511e-02f, -2.84589566e-02f, -1.65001024e-02f, -3.65871675e-02f, -6.35353029e-02f, -2.36974135e-02f, 5.70843779e-02f, 6.30848780e-02f,
  5.96507713e-02f, 8.28767102e-03f, 1.76374465e-02f, 5.06425351e-02f, 2.58514099e-02f, 3.22973356e-02f, 1.26990294e-02f, -6.28632084e-02f, 5.38933165e-02f, -4.16282453e-02f,
  -1.10416105e-02f, 6.92534074e-03f, 6.70263020e-04f, 7.58750038e-03f, 5.70145734e-02f, 5.99233098e-02f, -2.25489382e-02f, -1.70848928e-02f, 1.10129155e-02f, -7.74251372e-02f,
  3.80590558e-02f, 8.18001665e-03f, -1.52854566e-02f, 4.09067832e-02f, -6.82856739e-02f, 3.26363593e-02f, -2.66713221e-02f, 6.49281545e-03f, 1.88651085e-02f, 5.10036200e-02f,
  1.69883922e-01f, 6.20222874e-02f, -1.33049442e-02f, 2.28397790e-02f, -2.94504892e-02f, 1.99857890e-03f, 4.91787419e-02f, 7.57864118e-02f, -3.09093688e-02f, -5.86628169e-02f,
  -2.36507025e-04f, -4.90649901e-02f, -1.27453906e-02f, -4.46703546e-02f, 1.05002848e-02f, 5.66076748e-02f, 6.10246845e-02f, 5.32320328e-02f, -6.28897324e-02f, -7.20467493e-02f,
  -6.68768445e-03f, -1.96331716e-03f, 2.31732731e-03f, 7.42702633e-02f, 8.58237520e-02f, 7.13559762e-02f, 7.32374042e-02f, -4.42078523e-02f, 2.33223476e-02f, -4.37923744e-02f,
  9.78939831e-02f, 3.39811184e-02f, -1.09903254e-01f, -1.41179934e-01f, 1.98887289e-02f, 3.06096934e-02f, -7.81966448e-02f, 2.49589160e-02f, 1.51977554e-01f, 7.48124644e-02f,
  7.97382519e-02f, 1.88365541e-02f, 5.17493337e-02f, -8.75876173e-02f, 7.90930912e-02f, 9.70527828e-02f, -4.88092750e-02f, -4.40295190e-02f, -7.60799348e-02f, -1.96938310e-02f,
  4.94628251e-02f, -5.64643443e-02f, -1.76433504e-01f, -1.03612794e-02f, -8.71500075e-02f, -1.17872939e-01f, 2.79918872e-02f, -4.10009623e-02f, 3.37604433e-02f, -6.65155351e-02f,
  6.54675588e-02f, 1.28661906e-02f, 2.41322871e-02f, -7.56121725e-02f, 1.56500526e-02f, -5.18780909e-02f, -3.39070149e-02f, -6.87848479e-02f, 3.07413992e-02f, 5.07315844e-02f,
  9.32092667e-02f, -8.87108073e-02f, 1.03227384e-01f, 2.39103753e-02f, -9.17131603e-02f, 2.04426283e-03f, 4.34229337e-02f, -2.17497684e-02f, -4.79820445e-02f, -3.73629816e-02f,
  3.61776799e-02f, -1.12147918e-02f, 4.67472803e-03f, -4.01732251e-02f, -7.34600350e-02f, -1.03824968e-02f, 7.47040510e-02f, 1.67997535e-02f, -5.79569042e-02f, 1.31529719e-02f,
  5.75797521e-02f, 4.96462397e-02f, 2.47680675e-02f, -5.25800548e-02f, 1.40050957e-02f, -9.89200026e-02f, 6.52294531e-02f, 7.19187856e-02f, -7.92605579e-02f, 5.17707579e-02f,
  -8.27490017e-02f, 1.00741014e-02f, -2.58442070e-02f, 3.06036696e-02f, 8.34605619e-02f, -4.18198742e-02f, -5.79650253e-02f, 2.52581760e-02f, -5.11307307e-02f, -3.77207734e-02f,
  -3.99256870e-02f, 7.67664164e-02f, 3.83111723e-02f, 9.10530314e-02f, -6.40707323e-03f, -3.18770036e-02f, 9.33170393e-02f, -5.95306680e-02f, 7.91547168e-03f, 1.97573826e-02f,
  1.08309940e-01f, 9.55745354e-02f, 2.03851871e-02f, -7.19175348e-03f, 1.24852294e-02f, 2.26763077e-02f, 2.30080001e-02f, 7.05761462e-02f, -1.22204218e-02f, -4.81362678e-02f,
  -8.56222361e-02f, 7.74549991e-02f, 5.75345568e-02f, -8.23432729e-02f, 4.95275036e-02f, 1.05441210e-03f, -8.62933397e-02f, -4.71087769e-02f, -1.02408990e-01f, 3.75653580e-02f,
  -2.23934595e-02f, -2.16460750e-02f, -2.05926895e-02f, 1.10627580e-02f, 5.52407727e-02f, 4.08629514e-02f, 3.63409854e-02f, -5.82799241e-02f, 5.46254776e-02f, -4.35148999e-02f,
  5.69811985e-02f, -3.09209108e-01f, 1.75940797e-01f, -3.34778125e-03f, 2.37760052e-01f, 1.14102192e-01f, 2.03633964e-01f, 4.01105955e-02f, -1.04385905e-01f, -2.15760648e-01f,
  1.07860655e-01f, -7.04086712e-03f, 1.15654968e-01f, -8.11193809e-02f, 2.81208277e-01f, -1.00620296e-02f, -2.76280679e-02f, 2.66854074e-02f, 5.44143990e-02f, 5.03820218e-02f,
  7.00329384e-03f, -1.12016378e-02f, 1.75633267e-01f, -1.21340225e-03f, 3.35116200e-02f, -3.89606692e-02f, 2.15700809e-02f, 4.83608879e-02f, -1.03551969e-01f, 1.51691109e-01f,
  1.17009645e-02f, 6.30424405e-03f, -6.87003043e-03f, -8.29634815e-02f, 1.15635902e-01f, -2.26559527e-02f, 7.30511099e-02f, 2.62392275e-02f, 5.34876250e-03f, -7.76596516e-02f,
  -1.06642410e-01f, 4.73970175e-02f, -1.15865104e-01f, 6.54023215e-02f, 6.20412966e-03f, 7.73717463e-02f, 1.57805495e-02f, -3.08513884e-02f, -7.56312581e-03f, 7.05217272e-02f,
  -5.15947342e-02f, -5.14174961e-02f, -1.69950202e-02f, 1.30473124e-02f, -3.07121035e-02f, 5.49507625e-02f, -9.16344821e-02f, 8.03114325e-02f, 1.65112093e-02f, -3.75193469e-02f,
  2.83729322e-02f, 7.85105526e-02f, 5.04047098e-03f, 5.71788885e-02f, 2.19716597e-02f, 4.44586836e-02f, 2.46501770e-02f, 8.86974216e-04f, -3.86532047e-04f, 3.16042677e-02f,
  4.94363680e-02f, 5.87553196e-02f, 2.84284018e-02f, -3.01519744e-02f, -1.17585724e-02f, -2.31719986e-02f, 3.29652354e-02f, -5.39136119e-02f, 8.34493805e-03f, -1.55891357e-02f,
  9.44687799e-03f, 3.63447033e-02f, -6.69585913e-02f, -5.77572994e-02f, 1.24378659e-01f, -3.98470983e-02f, 1.62698831e-02f, -1.64326448e-02f, -6.11160137e-03f, 2.14326959e-02f,
  -6.91067874e-02f, -1.50524557e-01f, -8.78103822e-02f, -4.94874362e-03f, -1.86308734e-02f, -1.03075672e-02f, -9.68406035e-04f, -8.71808380e-02f, -7.97002912e-02f, 6.15581833e-02f,
  -4.50666137e-02f, 2.93744877e-02f, 3.52023430e-02f, 5.38035221e-02f, 3.78092304e-02f, -7.81718045e-02f, -7.49704987e-02f, -2.37864675e-03f, 3.52326483e-02f, 1.36042340e-02f,
  -7.21144602e-02f, -9.16486531e-02f, 7.90997893e-02f, 4.56484668e-02f, -6.70929858e-03f, 2.93866377e-02f, 2.02079769e-03f, -2.12059114e-02f, 3.62444073e-02f, -8.96248792e-04f,
  1.69637531e-01f, -2.58508474e-01f, 1.08131148e-01f, 1.23255409e-01f, 1.92170754e-01f, 1.45033509e-01f, 1.38194337e-01f, -1.16848543e-01f, -1.10790446e-01f, -2.51064360e-01f,
  -8.32487196e-02f, -1.51764408e-01f, -8.53365660e-02f, -7.79645666e-02f, 1.52441815e-01f, -8.45128968e-02f, -5.21340035e-03f, -6.71798065e-02f, 5.00599109e-02f, -6.64608702e-02f,
  8.46175179e-02f, 5.38245440e-02f, 2.14688525e-01f, -1.68348812e-02f, -4.29978734e-03f, -1.50254341e-02f, -5.01156412e-02f, 1.12650491e-01f, 1.42982341e-02f, -1.31903871e-04f,
  7.32035264e-02f, -1.53887600e-01f, -4.70512360e-03f, 1.04681766e-02f, -3.85887623e-02f, -4.39381972e-02f, 1.47764180e-02f, 8.79612938e-02f, 9.28275213e-02f, 5.22613190e-02f,
  1.03153437e-02f, -2.75331941e-02f, 7.67096505e-02f, 8.49261731e-02f, 1.57473069e-02f, 6.72124550e-02f, 2.89008468e-02f, 3.24363187e-02f, 7.27117956e-02f, -2.56163650e-04f,
  -8.23900998e-02f, 9.44879204e-02f, 5.76476455e-02f, -8.18122700e-02f, 8.41290057e-02f, 4.84970771e-02f, 8.33301097e-02f, 7.33695179e-02f, -3.26429829e-02f, 2.74206847e-02f,
  9.36451368e-03f, -1.18676461e-02f, -1.00131527e-01f, 1.34678157e-02f, -1.14386663e-01f, -3.37688997e-02f, 2.46082246e-03f, -7.38655180e-02f, -1.85767165e-03f, -4.03361395e-02f,
  -3.77504304e-02f, -1.22512411e-02f, -6.10852577e-02f, 1.73925620e-03f, -1.40873808e-02f, -3.22067440e-02f, 7.04284292e-03f, 1.98713262e-02f, -2.29705451e-03f, 2.19799057e-02f,
  8.54405090e-02f, -1.01628096e-03f, 3.44527662e-02f, 8.70458856e-02f, -6.32052347e-02f, -4.87534739e-02f, 3.96036357e-02f, -6.47229725e-04f, -2.90636122e-02f, 7.11581558e-02f,
  -1.06953770e-01f, -3.87896419e-01f, 3.09789833e-02f, 2.12190449e-02f, -6.72588870e-02f, -7.15924948e-02f, -9.68573168e-02f, -6.31988514e-03f, -3.53620164e-02f, -9.35637802e-02f,
  9.68755875e-03f, 7.91667625e-02f, -2.29227263e-02f, -1.23835020e-02f, 3.43451984e-02f, -2.91606337e-02f, -1.59246493e-02f, -1.84379984e-02f, 5.39981835e-02f, -2.77584642e-02f,
  -6.90743979e-03f, -7.22363442e-02f, 4.28690240e-02f, 1.57665685e-02f, 3.92947765e-03f, 3.95333655e-02f, 1.33689102e-02f, -3.84149328e-02f, 4.39001760e-03f, 2.87417583e-02f,
  -3.51717293e-01f, 3.04221243e-01f, -1.44667208e-01f, -1.24446020e-01f, 7.71994889e-02f, -2.65614241e-01f, -1.96816385e-01f, -1.02468096e-01f, -9.36029777e-02f, -2.45813336e-02f,
  -1.00174539e-01f, 2.19791681e-01f, 1.00462316e-02f, -7.04928786e-02f, -4.05205756e-01f, 1.54611459e-02f, -3.36323678e-01f, -1.39525160e-01f, -5.18632866e-02f, -1.16376430e-02f,
  -1.00429922e-01f, -1.33446855e-02f, -3.55238020e-02f, 1.79731995e-01f, -2.33703433e-03f, 6.92661405e-02f, -9.38382819e-02f, 1.39671922e-01f, 2.27942187e-02f, 1.04271933e-01f,
  2.76189554e-03f, -1.20419599e-02f, 4.38203663e-02f, -6.56705499e-02f, -1.27973482e-01f, -8.49170014e-02f, -6.13937341e-03f, -9.74579807e-03f, -6.60047308e-03f, -5.61621925e-03f,
  5.92783839e-02f, -3.57624982e-03f, -1.94152519e-02f, 1.46662191e-01f, -7.08806142e-02f, 6.60118088e-02f, 3.58721651e-02f, -1.85259711e-02f, 2.24524178e-02f, 8.96904692e-02f,
  3.42349336e-02f, 1.51446648e-02f, -4.63751517e-02f, -2.86524594e-02f, -7.01213256e-02f, 3.69774327e-02f, 4.09413455e-03f, 8.53611855e-04f, 3.94087471e-03f, 3.30118760e-02f,
  7.18418062e-02f, 3.51222261e-04f, -7.23776966e-02f, 3.10740201e-03f, -2.10963283e-03f, -1.70332026e-02f, -2.81006619e-02f, 1.96731761e-02f, 4.73230556e-02f, -5.14420606e-02f,
  -6.69097230e-02f, 1.76772568e-02f, 4.25154157e-03f, -6.22342201e-03f, -3.07449680e-02f, -3.12010180e-02f, 7.16298223e-02f, -4.48912345e-02f, -7.83828869e-02f, 2.20773462e-02f,
  -6.95829373e-03f, -4.09342162e-02f, 7.34489039e-03f, 3.90548147e-02f, -5.69584221e-02f, 7.94009045e-02f, 3.76725234e-02f, -7.58502707e-02f, -3.88359576e-02f, 3.66590545e-02f,
  -2.85833806e-01f, -2.57442653e-01f, 1.63006410e-02f, 1.08228259e-01f, 2.09150333e-02f, 4.33961451e-02f, -3.61186191e-02f, 7.77030736e-02f, -5.51742055e-02f, -1.77789740e-02f,
  2.25272286e-03f, -3.65407541e-02f, 4.09641266e-02f, -1.13360815e-01f, -3.00453976e-02f, 1.09706698e-02f, -1.59175657e-02f, -6.65259659e-02f, -8.43194798e-02f, -2.06331629e-02f,
  -1.15827871e-02f, 3.49546857e-02f, -1.92677453e-02f, -4.36282571e-04f, -1.03617243e-01f, -7.02013308e-03f, -6.37728646e-02f, -6.86731040e-02f, 7.36419559e-02f, -3.12113222e-02f,
  -1.94154710e-01f, -9.53812972e-02f, 1.01093307e-01f, -1.99300736e-01f, 2.39128768e-02f, -1.31648645e-01f, -1.08616382e-01f, 3.48151326e-02f, -4.73222621e-02f, -5.43767735e-02f,
  1.23171359e-01f, -1.40043646e-01f, 1.17923938e-01f, -1.05974488e-01f, -1.96687296e-01f, -8.80258903e-02f, -6.52469248e-02f, -7.74470866e-02f, -7.87148252e-02f, -7.81877413e-02f,
  -2.93972660e-02f, 4.90535945e-02f, -3.12466975e-02f, 1.83805540e-01f, 4.56768274e-02f, 2.13740207e-02f, 5.55700362e-02f, 1.46444723e-01f, 1.31531199e-03f, 2.34575830e-02f,
  -3.05900592e-02f, 6.97375908e-02f, 2.15334557e-02f, 8.90530124e-02f, 3.15729231e-02f, -5.67915775e-02f, -6.36533573e-02f, -3.32149900e-02f, -6.08625971e-02f, -1.94885246e-02f,
  -7.29253665e-02f, 5.94271906e-02f, -5.97637147e-02f, -2.29481421e-02f, 5.94178401e-02f, 7.68865868e-02f, -4.41440828e-02f, -1.88099463e-02f, 2.64687035e-02f, -2.03294097e-03f,
  -1.61062833e-02f, -3.18006054e-02f, 6.32137284e-02f, -2.38442831e-02f, -4.46125641e-02f, 5.22792414e-02f, 2.74821427e-02f, 5.80969453e-02f, 1.85879655e-02f, -9.09091532e-02f,
  1.66064431e-03f, -1.38539942e-02f, 2.20757909e-02f, 3.62150371e-02f, -5.58956936e-02f, 4.87306975e-02f, -3.96988392e-02f, -5.39685450e-02f, 3.13641410e-03f, 1.21220890e-02f,
  4.12297770e-02f, 1.74194686e-02f, -4.53929752e-02f, 2.27787960e-02f, -6.52796626e-02f, 4.15829197e-02f, -8.65401477e-02f, 1.38792284e-02f, -3.32528539e-02f, -7.46880919e-02f,
  3.89848975e-03f, -5.28144911e-02f, 1.20739779e-02f, -2.68518515e-02f, 3.44558209e-02f, 1.68459360e-02f, -1.07192829e-01f, -3.21487673e-02f, -2.86801960e-02f, -5.02998903e-02f,
  -1.77351609e-02f, 1.17786169e-01f, -4.06317227e-02f, 7.06837028e-02f, -2.31063738e-03f, -6.94400957e-03f, 1.18197231e-02f, -3.04665603e-02f, 3.27843092e-02f, -4.71724942e-02f,
  3.07888538e-02f, 8.12826827e-02f, 1.44467074e-02f, 6.03769012e-02f, 8.30750316e-02f, -6.26106188e-02f, -9.68943071e-03f, -6.57175109e-02f, 6.18237630e-03f, -1.95640908e-03f,
  -2.00476348e-02f, 3.57876942e-02f, -1.95043515e-02f, -4.16228548e-02f, 9.12619084e-02f, -3.54703404e-02f, -1.33637041e-02f, 4.79942709e-02f, -6.04913272e-02f, 5.22215385e-03f,
  1.81494653e-01f, 2.08031908e-01f, 1.49962708e-01f, 5.20197749e-02f, -1.60847113e-01f, -1.39364809e-01f, -9.35191065e-02f, 7.89650232e-02f, 2.41337165e-01f, 8.17602649e-02f,
  -9.04532671e-02f, 2.89482117e-01f, -2.33124308e-02f, -1.48541844e-02f, -3.66493404e-01f, -1.09106347e-01f, -7.93424845e-02f, -3.56399752e-02f, 7.09184408e-02f, -7.89631233e-02f,
  -1.42314166e-01f, -1.32045671e-01f, -1.00760676e-01f, -7.75485188e-02f, 1.37295067e-01f, 1.15631290e-01f, -1.85521394e-01f, -2.85203643e-02f, -3.76688130e-02f, 6.69721663e-02f,
  5.91106266e-02f, 1.17650896e-01f, 6.03017136e-02f, 6.84668645e-02f, -2.69534960e-02f, -8.67614523e-02f, 5.48919663e-02f, -5.52556664e-02f, -2.11246144e-02f, 1.55583927e-02f,
  9.12667960e-02f, 7.10713165e-03f, -1.90310255e-02f, 4.69937846e-02f, 6.96289614e-02f, 6.38529211e-02f, -1.49689452e-03f, 4.14999127e-02f, -5.28118089e-02f, 1.08889766e-01f,
  4.39893417e-02f, -3.77660571e-03f, 1.09076127e-02f, 1.38381841e-02f, 4.83274497e-02f, 2.67276205e-02f, -3.10660545e-02f, -1.84655341e-03f, 4.44278616e-04f, 1.17529584e-02f,
  -1.42424271e-01f, -2.92932186e-02f, 3.60113978e-02f, 1.50909364e-01f, 1.58593245e-02f, 8.26002434e-02f, -4.54279175e-03f, -1.89537704e-02f, 7.91063681e-02f, 1.04544973e-02f,
  7.62151331e-02f, 7.09644007e-03f, 2.49547120e-02f, -7.69104511e-02f, 2.12552957e-02f, 7.50730485e-02f, -4.19589989e-02f, -4.17819135e-02f, -1.01715857e-02f, -2.76373811e-02f,
  2.35912111e-02f, -1.12832384e-02f, 6.07253909e-02f, -1.96258891e-02f, 7.26870075e-02f, 2.59762164e-02f, -1.27995491e-03f, 2.09158529e-02f, 2.91998051e-02f, -9.93264243e-02f,
  -1.32297814e-01f, -1.58704579e-01f, 5.19923046e-02f, 6.90260679e-02f, 9.58704799e-02f, -6.82643056e-03f, 2.82710809e-02f, 6.22522160e-02f, 6.48129685e-03f, -4.17014211e-02f,
  -6.70278892e-02f, 8.29634964e-02f, -7.96572492e-02f, -3.75326462e-02f, -4.14190255e-02f, -3.46512310e-02f, -8.49012062e-02f, -8.63176063e-02f, -9.86147076e-02f, -5.79993688e-02f,
  5.19163944e-02f, -3.04117519e-02f, -2.05265339e-02f, 3.27394642e-02f, -1.80011932e-02f, -5.99165559e-02f, 6.29727617e-02f, 5.27176373e-02f, -2.85089146e-02f, -8.93378407e-02f,
  2.18180716e-02f, -9.41316858e-02f, 2.53544033e-01f, 5.29328547e-02f, 1.32369339e-01f, 1.58968642e-01f, 1.65299520e-01f, -2.16129720e-02f, -1.27468333e-01f, -1.28451690e-01f,
  -4.36321534e-02f, -1.15825646e-02f, 1.87937081e-01f, -2.91319080e-02f, 7.34157637e-02f, 3.68834920e-02f, -5.99888675e-02f, -2.89005637e-02f, -5.19934185e-02f, -5.54373562e-02f,
  -3.36154848e-02f, -4.06020880e-02f, 9.04780179e-02f, -1.41983882e-01f, 5.57877198e-02f, -3.69680338e-02f, -5.15382886e-02f, 2.18427882e-01f, -6.32435903e-02f, 1.38280183e-01f,
  -1.30704820e-01f, -4.60385941e-02f, 6.00161441e-02f, -6.63430020e-02f, -7.31455684e-02f, 3.44497040e-02f, 8.63318816e-02f, 6.52376264e-02f, 6.92272708e-02f, -4.75431085e-02f,
  -4.17207256e-02f, 4.31709550e-02f, -4.75629829e-02f, 1.51417032e-02f, 2.11754013e-02f, -5.10101803e-02f, -1.30011719e-02f, 7.68842027e-02f, -9.79355350e-03f, 7.79263377e-02f,
  6.53612092e-02f, 6.41487762e-02f, 5.42161539e-02f, -7.40994886e-02f, -6.15984313e-02f, 3.97067592e-02f, -7.64424652e-02f, -3.64670977e-02f, -8.00409913e-02f, -8.62430409e-02f,
  6.36792928e-02f, 3.40527929e-02f, -7.58161843e-02f, -4.89313714e-02f, 3.72819453e-02f, 1.83425297e-03f, -3.18789482e-02f, 1.03945807e-01f, 7.34568620e-03f, 7.37239495e-02f,
  -1.59550663e-02f, 6.54140860e-02f, -2.12357882e-02f, -7.28116408e-02f, 3.31551172e-02f, 1.54818809e-02f, 8.49975571e-02f, 4.00317274e-02f, -2.83479504e-03f, -6.21629432e-02f,
  5.00502400e-02f, 7.23012760e-02f, 7.31346756e-02f, -3.61774415e-02f, 7.68595785e-02f, 2.07334291e-02f, 5.14632836e-02f, 5.41037582e-02f, -3.04687321e-02f, 7.31543032e-03f,
  -1.35368466e-01f, -1.41734049e-01f, -7.83318728e-02f, -5.69688939e-02f, 1.79086365e-02f, -4.58769500e-02f, 5.78292310e-02f, 1.68807560e-03f, -6.48999736e-02f, -4.27196845e-02f,
  -5.92972115e-02f, -5.05225323e-02f, -8.22558701e-02f, 4.72293533e-02f, -2.14693658e-02f, -1.02925643e-01f, 3.03053297e-02f, -6.62796646e-02f, -6.79034442e-02f, -2.31539328e-02f,
  4.43830453e-02f, 4.15828228e-02f, 5.09860599e-03f, -2.06717029e-02f, -1.05642222e-01f, 3.86584476e-02f, -1.25847617e-03f, -4.05615829e-02f, 3.47163565e-02f, -2.54953951e-02f,
  -6.93869144e-02f, 4.13239673e-02f, -2.70972133e-01f, -1.11978061e-01f, -7.01230839e-02f, 1.09237343e-01f, 6.98660910e-02f, 2.79478766e-02f, 4.23642509e-02f, 1.99656427e-01f,
  1.27251580e-01f, -9.31214243e-02f, 1.12544984e-01f, 1.66795209e-01f, 6.01133425e-03f, 1.91468462e-01f, 4.73019667e-02f, 1.68906406e-01f, -1.28283799e-02f, -4.05060574e-02f,
  -1.12427570e-01f, 1.79614335e-01f, -2.08406150e-02f, -3.51487994e-02f, -6.99410811e-02f, -3.63642424e-02f, -9.04046465e-03f, -1.18363038e-01f, 6.55579343e-02f, -7.47119933e-02f,
  5.66725619e-02f, -8.75533819e-02f, -3.64770293e-02f, -5.39827086e-02f, -4.62399274e-02f, -5.13102300e-02f, -7.20253289e-02f, 3.40549164e-02f, -5.87685443e-02f, -2.71628425e-03f,
  1.12822317e-02f, -1.33024249e-02f, -8.62226170e-03f, -9.70033929e-02f, -5.14017567e-02f, -4.67491522e-02f, 5.13260514e-02f, 2.11136620e-02f, -2.63964683e-02f, -6.12766156e-03f,
  -4.47142981e-02f, 9.33780242e-03f, 4.57005426e-02f, 4.03959937e-02f, -1.00098532e-02f, -4.93586473e-02f, 7.78552610e-03f, 2.49761753e-02f, -2.10827272e-02f, 5.42983525e-02f,
  -4.52477038e-02f, -8.16725474e-03f, 1.07859828e-01f, -4.73543294e-02f, 3.53178121e-02f, -5.71956560e-02f, 4.70761321e-02f, 6.74295425e-02f, -2.34901793e-02f, 5.78193702e-02f,
  -3.76003869e-02f, 3.96643914e-02f, 5.11658378e-02f, 1.83207467e-02f, 2.84756292e-02f, -1.22491755e-02f, -8.93018097e-02f, -5.17888851e-02f, -6.19628169e-02f, 6.03425242e-02f,
  -3.82423401e-02f, 4.43627276e-02f, -1.86835397e-02f, 8.03341717e-03f, 2.93936022e-03f, 5.71913011e-02f, -4.41269614e-02f, 2.13917680e-02f, -3.89339402e-02f, -7.56224990e-02f,
  6.90025613e-02f, -4.23860475e-02f, 9.24774352e-03f, 6.05411567e-02f, 3.84337343e-02f, 2.91110985e-02f, -6.64840564e-02f, 2.18927837e-03f, -3.02892737e-02f, -5.66042494e-03f,
  3.04383393e-02f, -5.24987094e-02f, -3.69144157e-02f, 4.42859344e-02f, -1.08538561e-01f, -1.16489325e-02f, -5.55134788e-02f, -1.01615734e-01f, 6.81219399e-02f, -2.09784955e-02f,
  1.41059551e-02f, -4.72273678e-02f, -6.35151491e-02f, -3.45097370e-02f, 8.11871216e-02f, 7.67908171e-02f, -2.54175235e-02f, -3.10517531e-02f, -3.38181034e-02f, -1.72504950e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -3.01499516e-02f, 1.47792086e-01f, 1.20557375e-01f, -3.95414792e-03f, 2.37521261e-01f, 6.19266964e-02f, 3.08145378e-02f, 1.27297983e-01f, 3.98760214e-02f, 2.55470395e-01f,
  2.65630949e-02f, 1.53117731e-01f, -8.16202685e-02f, 2.43702710e-01f, 1.91051751e-01f, -8.75015408e-02f, 5.29561862e-02f, 1.24385111e-01f, -2.86455099e-02f, 2.64688939e-01f,
  2.55968064e-01f, 3.24402630e-01f, 1.19346399e-02f, 1.33343741e-01f, -2.41461516e-04f, 5.39304577e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.56159814e-03f, -1.40837908e-01f, -5.95522709e-02f, 7.51416683e-02f, -6.97500929e-02f, -2.71684915e-01f, -2.70727783e-01f, -1.31055966e-01f, -1.53064415e-01f, 2.01577321e-01f,
  -2.43045583e-01f, 3.73005755e-02f, 8.62630755e-02f, -4.11197357e-02f, 1.96518376e-01f, -1.74294353e-01f, -1.65511847e-01f, 2.38126993e-01f, 2.54198909e-01f, -3.02159111e-03f,
  -4.94398549e-02f, 3.63280550e-02f, -1.63096264e-01f, 1.77945316e-01f, 5.03042573e-03f, 7.18685910e-02f, -2.18432590e-01f, -2.13994950e-01f, 1.34662762e-01f, -1.80560663e-01f,
  1.10357136e-01f, -6.92991540e-02f, -8.10489729e-02f, -6.36852765e-03f, 1.13305204e-01f, -2.67155349e-01f, -2.00213879e-01f, 1.90713078e-01f, 1.72654018e-01f, 1.40223041e-01f,
  1.28912807e-01f, 2.37219092e-02f, 2.04800397e-01f, 2.58071452e-01f, -2.30536610e-01f, 1.42871678e-01f, -2.87390351e-01f, -1.90165788e-01f, 9.37748104e-02f, -3.22172642e-01f,
  -1.31954491e-01f, 5.76555096e-02f, 2.44743228e-01f, 1.18349493e-01f, 4.60040122e-02f, -2.00273827e-01f, 6.42386684e-03f, 2.68807441e-01f, 2.22778961e-01f, 2.80286908e-01f,
  -1.07040353e-01f, 2.25650281e-01f, 1.55632287e-01f, -1.84763581e-01f, 1.92259446e-01f, 6.96850121e-02f, 1.34099305e-01f, -5.72748601e-01f, -1.54586747e-01f, 2.25665376e-01f,
  1.64968353e-02f, -1.03129506e-01f, -1.62058547e-01f, -4.61441167e-02f, -4.44120690e-02f, -7.79062361e-02f, -2.28080481e-01f, -1.62400439e-01f, -1.51153952e-01f, -8.89707357e-02f,
  1.04915295e-02f, -1.78614840e-01f, 2.53660530e-01f, -1.67321250e-01f, -6.62027746e-02f, -9.10159647e-02f, 1.04815379e-01f, 9.35652405e-02f, 6.95693418e-02f, 1.93511948e-01f,
  1.05175659e-01f, 3.14078666e-02f, -1.54491097e-01f, 1.11765057e-01f, 1.47062153e-01f, 1.24205612e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.54268879e-01f, 2.99033523e-01f, 5.35837486e-02f, 2.31654629e-01f, 9.14621502e-02f, -1.92189112e-01f, -2.26161107e-01f, -8.10947493e-02f, 4.04333621e-02f, -1.46920487e-01f,
  -1.61019657e-02f, -1.61133811e-01f, 2.58580118e-01f, -6.46430533e-03f, 1.69477746e-01f, 2.88203299e-01f, -7.88695514e-02f, 3.87778223e-01f, 5.14677586e-03f, 1.16906516e-01f,
  -4.09856439e-02f, 3.14591639e-02f, -9.22197849e-03f, 3.72473359e-01f, 9.31292325e-02f, -7.63765275e-02f, 8.57554674e-02f, 5.02066575e-02f, -3.74997109e-02f, -1.12917215e-01f,
  -2.37991214e-01f, 2.70657867e-01f, -2.36504935e-02f, 2.25489959e-01f, 1.98602974e-01f, -1.06194526e-01f, -1.60483588e-02f, -2.57450968e-01f, -2.54054397e-01f, -4.92748059e-02f,
  -2.37421423e-01f, -1.25591755e-01f, -1.41445249e-01f, -5.18462947e-03f, -1.53711326e-02f, 7.38609508e-02f, 1.93962425e-01f, 6.20892011e-02f, 1.62738383e-01f, 1.62693337e-01f,
  1.44284621e-01f, 9.26100314e-02f, 4.67060544e-02f, -1.36224136e-01f, 3.47258240e-01f, -9.56762806e-02f, 7.14229941e-02f, 7.82292709e-02f, 8.60434100e-02f, -1.34761930e-02f,
  -1.54866606e-01f, -1.55553684e-01f, 4.33096625e-02f, 1.66764155e-01f, 1.57731414e-01f, 6.66826442e-02f, -6.04636222e-02f, 1.23296604e-01f, 6.89442903e-02f, -1.36426955e-01f,
  1.26148000e-01f, 9.27537978e-02f, -1.13627143e-01f, 1.82760507e-02f, 9.07132626e-02f, -5.03759719e-02f, 1.63453504e-01f, 1.51463509e-01f, 3.90872061e-01f, -1.57370672e-01f,
  -1.02480002e-01f, 2.07368955e-01f, 6.15416355e-02f, -2.50053972e-01f, 5.97374812e-02f, 8.91646892e-02f, 2.66794235e-01f, -9.09137726e-02f, -2.50577219e-02f, -1.21264532e-01f,
  -1.08628206e-01f, -8.36400464e-02f, -4.66159843e-02f, -4.81821820e-02f, -1.68227345e-01f, -1.92781296e-02f, 3.40339959e-01f, -6.69529662e-02f, 1.82856590e-01f, -1.15194105e-01f,
  -2.68306553e-01f, -2.66480446e-01f, -2.88161874e-01f, 1.51142582e-01f, 1.00681059e-01f, 1.41726390e-01f, 6.51840717e-02f, 9.92122367e-02f, -2.14542020e-02f, -2.20306978e-01f,
  5.72394840e-02f, -8.63368362e-02f, -4.60247472e-02f, 1.34940790e-02f, 8.30437958e-01f, 2.86664814e-01f, -7.97589794e-02f, 1.07914202e-01f, 8.06842595e-02f, 1.82424467e-02f,
  1.12122469e-01f, -6.50827587e-02f, 1.20821483e-01f, 1.41880913e-02f, -1.88265890e-01f, -2.09053501e-01f, 2.42622703e-01f, 2.65952889e-02f, 1.93395138e-01f, 1.12316392e-01f,
  -1.48789240e-02f, 6.30281940e-02f, 8.85928050e-02f, -3.46579909e-01f, -6.82225823e-02f, 7.61340857e-02f, -1.34562120e-01f, 1.07342973e-01f, -1.68201834e-01f, 1.15139075e-01f,
  -1.75448030e-01f, -4.22683917e-02f, 2.01321974e-01f, 1.48651348e-02f, 1.58750087e-01f, 9.87571925e-02f, 1.13263577e-01f, 2.05944688e-03f, 2.09778678e-02f, -1.47296488e-01f,
  1.68387383e-01f, 2.30985209e-01f, 1.44772634e-01f, -1.34561032e-01f, -8.88114423e-02f, -9.01271328e-02f, -1.12442978e-01f, -2.17132121e-01f, -2.05281198e-01f, 2.62735456e-01f,
  3.68822783e-01f, 4.05921936e-01f, 3.70922744e-01f, 6.35181516e-02f, 1.65416479e-01f, -8.68065432e-02f, -2.44836688e-01f, 3.74052348e-03f, 1.77799001e-01f, 3.06458324e-01f,
  3.01522434e-01f, 9.41594914e-02f, 1.56612262e-01f, 1.05502866e-01f, 4.48980108e-02f, 3.84194553e-01f, -1.16135783e-01f, -1.24270413e-02f, 2.07378969e-01f, 4.53705698e-01f,
  6.62687719e-02f, -1.64095312e-01f, 1.07432298e-01f, -5.18001951e-02f, -5.52639291e-02f, 1.65731579e-01f, 2.69969314e-01f, 1.31603733e-01f, -3.27404658e-03f, 1.41858524e-02f,
  2.70140231e-01f, 1.58814073e-01f, 2.19907328e-01f, 1.55744553e-01f, 1.35733798e-01f, -3.85284066e-01f, -1.68697327e-01f, -2.54457384e-01f, 6.57264292e-02f, -5.52928932e-02f,
  -1.84867769e-01f, -5.81971034e-02f, 1.69539467e-01f, 1.65511042e-01f, -1.62355840e-01f, 1.59358144e-01f, 2.56163299e-01f, -3.68303880e-02f, -5.25671896e-03f, -1.59645393e-01f,
  2.04450324e-01f, -1.12498090e-01f, 3.89032841e-01f, -1.11111008e-01f, 6.28306746e-01f, -4.66870293e-02f, -4.01977338e-02f, 3.49157631e-01f, 3.85025799e-01f, -5.10592312e-02f,
  1.81376845e-01f, -2.21019939e-01f, 6.82351515e-02f, 5.39953224e-02f, -1.56834647e-01f, 1.90700740e-01f, -3.46044265e-02f, -1.35384426e-01f, 1.81728631e-01f, 1.33590803e-01f,
  2.56729305e-01f, -4.42911312e-02f, 5.20810485e-02f, -1.38499305e-01f, -9.53660756e-02f, 1.79115422e-02f, 7.65363723e-02f, -6.37184680e-02f, -4.90280502e-02f, -8.15826133e-02f,
  -8.20592940e-02f, -1.33694783e-01f, -9.37475339e-02f, -2.14848131e-01f, 3.36411148e-02f, 1.78035915e-01f, 6.21307790e-02f, -4.11635861e-02f, 1.22279704e-01f, -7.58704469e-02f,
  2.13803291e-01f, 2.45611981e-01f, 1.32539108e-01f, 1.91672698e-01f, -3.80243547e-02f, -1.47192448e-01f, 1.41208068e-01f, 2.33376399e-01f, 2.57387489e-01f, -4.56492454e-02f,
  -3.93753648e-02f, -3.11034203e-01f, 6.68997690e-02f, 2.57031620e-01f, -1.86636537e-01f, 1.96729288e-01f, 2.00007260e-01f, 9.67657641e-02f, 5.32645173e-02f, 6.08432405e-02f,
  1.29635423e-01f, -4.27954495e-02f, -1.06202565e-01f, 1.18785918e-01f, -4.52657379e-02f, 1.45108327e-01f, 3.06451648e-01f, -3.35972682e-02f, 3.18616956e-01f, -1.28030241e-01f,
  -2.19922125e-01f, 3.32725048e-01f, 3.64103526e-01f, -1.21546621e-02f, -1.02185614e-01f, -1.52338088e-01f, 1.82141453e-01f, 1.15991324e-01f, -2.11953968e-01f, -3.70662399e-02f,
  1.28604144e-01f, -2.28243172e-02f, -1.10212095e-01f, 1.73481822e-01f, 1.38384447e-01f, -1.88653599e-02f, 1.30477980e-01f, 1.66356847e-01f, 2.91271252e-03f, 7.13964179e-02f,
  1.67582512e-01f, 4.82315905e-02f, -1.44805804e-01f, 8.37685317e-02f, -1.38283387e-01f, -1.00055911e-01f, 1.68184206e-01f, 1.22267656e-01f, 1.67821527e-01f, -1.17239572e-01f,
  -1.68721318e-01f, 8.70279297e-02f, -1.06995188e-01f, 7.96617121e-02f, 1.99199334e-01f, 3.36831629e-01f, 2.26391315e-01f, 1.75478384e-01f, 1.54934406e-01f, 7.07225055e-02f,
  7.67120719e-02f, -8.98685232e-02f, 1.38095409e-01f, 1.52393326e-01f, 1.64520815e-01f, 7.91007504e-02f, -1.70090079e-01f, -7.14690089e-02f, 2.40563229e-01f, -6.01567067e-02f,
  -2.21390054e-02f, 1.09045886e-01f, 5.54200485e-02f, -3.46518755e-02f, -1.51377216e-01f, 1.94978952e-01f, 5.02431430e-02f, 1.74171254e-01f, -1.07260607e-01f, -8.03520083e-02f,
  -4.04855721e-02f, 3.17281112e-03f, -4.10096943e-02f, -1.44081205e-01f, 3.53669152e-02f, 1.29277810e-01f, -2.59989779e-02f, 1.66898772e-01f, 5.57031780e-02f, 1.48844449e-02f,
  1.51323915e-01f, -6.07208684e-02f, 7.31328577e-02f, 1.83432341e-01f, 4.47411053e-02f, 2.74727404e-01f, 2.57781625e-01f, 2.23242536e-01f, 1.64674982e-01f, 1.26250073e-01f,
  3.59701365e-01f, -2.24952579e-01f, 3.25375825e-01f, 2.26504192e-01f, 2.83607811e-01f, 1.26331031e-01f, -9.85357091e-02f, 2.47315630e-01f, -4.04207036e-02f, 1.43494278e-01f,
  -7.00981244e-02f, -1.50200322e-01f, -4.98497523e-02f, -1.33178219e-01f, 1.60379544e-01f, 2.73443628e-02f, -8.25444609e-02f, 1.15681931e-01f, -8.53811800e-02f, 5.08408725e-01f,
  3.22190523e-01f, 3.96131933e-01f, 1.73537508e-02f, -1.37467727e-01f, -7.13967672e-03f, 3.80400270e-02f, 2.30976626e-01f, -3.46077859e-01f, -2.45355815e-01f, 2.20226031e-02f,
  1.34107873e-01f, -1.87971875e-01f, -6.45707026e-02f, 1.32540062e-01f, 1.49870470e-01f, -2.06127495e-01f, -1.38607129e-01f, -1.65165693e-01f, 5.33339903e-02f, -1.42403215e-01f,
  1.02242231e-01f, -1.13782482e-02f, -1.33827358e-01f, -1.73694864e-01f, -6.46202639e-02f, 1.37653530e-01f, 1.98241845e-01f, 2.07291454e-01f, 1.25160083e-01f, 1.03862934e-01f,
  -1.33140862e-01f, -2.81766862e-01f, -1.17196195e-01f, -5.35211600e-02f, -1.95750237e-01f, -7.55629987e-02f, 6.65637553e-02f, 1.42068490e-01f, 2.94674873e-01f, 4.32448655e-01f,
  9.73512456e-02f, -1.62915781e-01f, 5.23549393e-02f, 2.01917768e-01f, 3.20255905e-01f, 5.60855307e-02f, -1.36659518e-01f, -1.34809194e-02f, 2.62585282e-01f, 2.42542371e-01f,
  2.21766755e-01f, 1.20089553e-01f, -1.04008257e-01f, -9.61813144e-03f, -3.88220139e-02f, 7.38735944e-02f, 3.82320061e-02f, -1.63515523e-01f, -1.65997460e-01f, 1.60671115e-01f,
  -1.81856290e-01f, 1.49430349e-01f, -6.73026219e-02f, 1.48428544e-01f, 9.13930982e-02f, -2.21133158e-01f, 9.43022445e-02f, -1.02631614e-01f, 2.31397320e-02f, 2.12149203e-01f,
  1.13133915e-01f, -5.04998975e-02f, -1.15043901e-01f, -2.89593399e-01f, -2.01376975e-01f, 1.58401933e-02f, -1.54307067e-01f, -2.70519964e-02f, -1.03315368e-01f, 2.25458235e-01f,
  1.38109058e-01f, -1.68363556e-01f, 1.33209124e-01f, -1.35391772e-01f, -9.27322283e-02f, -4.93375026e-02f, 3.86192411e-01f, 1.13584884e-01f, 6.46925271e-02f, -7.01620430e-02f,
  1.69471562e-01f, 7.23347627e-03f, 2.08911091e-01f, 2.18402937e-01f, 7.80334398e-02f, -7.87121728e-02f, -1.12003408e-01f, -1.68634742e-01f, -2.13993881e-02f, -9.60393101e-02f,
  -1.17435522e-01f, 1.01718567e-02f, -8.92526582e-02f, -1.54440731e-01f, -4.27614599e-02f, 1.76408201e-01f, 2.35795438e-01f, 7.45212287e-02f, -1.71720628e-02f, -2.86355894e-02f,
  6.15355782e-02f, 3.16349454e-02f, -7.58835152e-02f, 1.42241150e-01f, -3.96568999e-02f, 9.81751755e-02f, 1.69946119e-01f, -1.71443932e-02f, -1.04400396e-01f, -2.42197830e-02f,
  1.38883963e-01f, 1.63957607e-02f, -2.83072107e-02f, -1.73361450e-01f, 5.78164160e-02f, 2.43106276e-01f, 2.48802498e-01f, -8.92968550e-02f, -2.82787699e-02f, 1.26611874e-01f,
  -2.65948754e-02f, -1.04941159e-01f, 1.75845787e-01f, -4.88633141e-02f, 2.52292991e-01f, 1.88461125e-01f, -3.88473319e-03f, -6.45950139e-02f, -1.68457836e-01f, -1.44809885e-02f,
  1.42112970e-01f, 9.04433206e-02f, 1.46084893e-02f, 1.42160924e-02f, 2.53093779e-01f, -1.05249859e-01f, 5.75673534e-03f, 2.35779867e-01f, 4.38022204e-02f, 4.87256087e-02f,
  3.73778135e-01f, 2.57893234e-01f, 7.07410797e-02f, -4.51836064e-02f, -1.59448683e-01f, 1.33804470e-01f, 1.16672896e-01f, -3.31822503e-03f, -1.25039250e-01f, 3.30966979e-01f,
  -5.52277118e-02f, 1.04054451e-01f, 9.78803821e-03f, 1.20215200e-01f, 1.13049768e-01f, 1.49559736e-01f, 9.98860151e-02f, 3.79851758e-02f, 6.72894195e-02f, -1.97749749e-01f,
  -1.72485724e-01f, 2.10198984e-01f, -5.85514382e-02f, -1.03096135e-01f, 9.56235826e-02f, -4.79148366e-02f, 7.16830492e-02f, -5.13074733e-02f, 1.40488267e-01f, -6.68164715e-02f,
  -5.76950163e-02f, -9.42236558e-02f, -1.02659106e-01f, 3.81621234e-02f, -9.85385776e-02f, 1.13312274e-01f, -1.41344577e-01f, -9.36279520e-02f, 1.07577071e-01f, 1.35670274e-01f,
  -1.83571160e-01f, -9.04529542e-02f, 1.43394977e-01f, 1.36504576e-01f, 1.10980660e-01f, -1.69998873e-02f, -1.06362641e-01f, 8.32244456e-02f, 2.86778901e-02f, -1.12521194e-01f,
  2.36295220e-02f, 7.72937089e-02f, 1.44469798e-01f, 1.37184486e-01f, -1.73639074e-01f, -1.77703217e-01f, 4.09790613e-02f, 3.34566161e-02f, -1.16563523e-02f, 2.11623654e-01f,
  1.07336648e-01f, -1.30036101e-01f, -5.06346300e-02f, 1.35810420e-01f, -1.93437934e-02f, -1.86182022e-01f, 1.02225184e-01f, -1.48975521e-01f, -4.29827906e-02f, 7.58637711e-02f,
  -6.73625767e-02f, -1.30089983e-01f, 8.39732438e-02f, 3.18287052e-02f, -1.46365702e-01f, -1.98310502e-02f, 3.05443555e-02f, -1.59649923e-01f, 1.86031178e-01f, 2.75593698e-01f,
  3.16935390e-01f, 1.84051216e-01f, -1.69750508e-02f, 9.12821740e-02f, -1.64940450e-02f, 4.78176251e-02f, 2.33131453e-01f, -7.92938024e-02f, 1.42108172e-01f, -1.19419992e-01f,
  -1.39408987e-02f, 1.61780819e-01f, 1.17581002e-01f, 1.98048875e-01f, 3.17808031e-03f, 1.66770071e-01f, -2.47749880e-01f, 2.21818998e-01f, 2.43790507e-01f, 5.52929156e-02f,
  -4.57000025e-02f, 7.95506537e-02f, -1.16518937e-01f, -8.21815729e-02f, 1.46205127e-01f, 2.71278232e-01f, 1.67442381e-01f, 2.24050730e-01f, -8.32254514e-02f, -1.50110036e-01f,
  1.54487446e-01f, 1.89868063e-01f, -1.02661468e-01f, -1.37843639e-01f, 1.16758205e-01f, -3.55029330e-02f, -1.43646255e-01f, -9.36562791e-02f, 3.96401212e-02f, -1.94964275e-01f,
  -1.25022456e-01f, -8.06320980e-02f, -1.67577118e-01f, 1.33667618e-01f, 3.95133466e-01f, -1.57991648e-01f, -1.46220595e-01f, 8.30547139e-02f, 3.67861688e-02f, -8.46139193e-02f,
  2.25428775e-01f, -4.36009020e-02f, 4.01999652e-01f, 1.53710127e-01f, -1.12279974e-01f, -9.34402198e-02f, -7.95361921e-02f, -6.67333230e-02f, -1.09896906e-01f, -1.48957923e-01f,
  3.22692506e-02f, -7.03623369e-02f, -1.44642800e-01f, 7.12885186e-02f, -8.28548446e-02f, -3.23728412e-01f, 4.03302759e-02f, -4.02768292e-02f, 1.09590590e-01f, -1.82801545e-01f,
  -1.65267125e-01f, 3.45130228e-02f, -1.06752954e-01f, -1.08859487e-01f, -2.10111979e-02f, -5.12943789e-02f, -7.41490051e-02f, 3.03645860e-02f, 3.11374422e-02f, 8.72883871e-02f,
  1.17709227e-01f, 4.14898590e-04f, 1.14338629e-01f, -1.71656013e-01f, 2.79831350e-01f, 9.61435065e-02f, -1.19349733e-01f, 2.23771647e-01f, -5.51959872e-02f, -9.74134207e-02f,
  -1.72612831e-01f, 1.22320212e-01f, 6.19638897e-02f, 9.60282907e-02f, 4.27854322e-02f, 2.41231769e-01f, -6.48695603e-02f, 9.93710533e-02f, -4.39359574e-03f, -2.22267523e-01f,
  -1.31870523e-01f, 2.21235037e-01f, 2.80933492e-02f, -8.03847313e-02f, -1.51335225e-01f, 1.95234463e-01f, 2.49491706e-02f, 1.49029130e-02f, 2.13506564e-01f, -6.25305250e-02f,
  -4.60272208e-02f, 7.36503825e-02f, 1.98219985e-01f, -1.04886726e-01f, 4.32584435e-02f, -1.44857228e-01f, -8.32148716e-02f, -1.69421926e-01f, 1.32110223e-01f, 1.69788733e-01f,
  -9.52606872e-02f, 1.33316204e-01f, 4.91049467e-03f, -1.91166714e-01f, 1.96508020e-01f, -2.16884747e-01f, 1.72107816e-01f, -1.78227320e-01f, -1.52204648e-01f, -2.76059788e-02f,
  -2.00871855e-01f, -1.06508009e-01f, -1.71970315e-02f, -9.06229988e-02f, -1.52917311e-01f, 1.03637464e-01f, -1.25315160e-01f, -2.45831665e-02f, 2.65045499e-04f, -5.51594645e-02f,
  1.34527698e-01f, 1.12862162e-01f, -1.78975426e-02f, -1.97120875e-01f, 2.77810901e-01f, -1.93216447e-02f, 3.02452012e-03f, 8.41925740e-02f, -1.89423755e-01f, -3.49412207e-03f,
  6.72554001e-02f, -4.61107567e-02f, -8.75485986e-02f, 1.90520898e-01f, 7.41553158e-02f, -1.64149880e-01f, -6.51246980e-02f, 2.15583026e-01f, -1.08557232e-01f, -6.00757338e-02f,
  3.45208086e-02f, 5.23459464e-02f, 1.53101981e-01f, 8.50941315e-02f, 9.39378589e-02f, -3.35847288e-02f, 2.37305567e-01f, 7.53984824e-02f, 1.99408069e-01f, 6.25913292e-02f,
  4.53508683e-02f, -5.57215177e-02f, 8.48223045e-02f, -6.83548227e-02f, -1.46419093e-01f, -1.12190463e-01f, -7.01037876e-04f, 4.60224748e-02f, 5.93486317e-02f, -6.56347796e-02f,
  1.18309937e-01f, -7.24237040e-02f, 4.41652387e-02f, -1.34802625e-01f, -1.40808210e-01f, 1.52331874e-01f, 1.49881527e-01f, -6.80518821e-02f, -6.03881776e-02f, 1.13431951e-02f,
  9.45225582e-02f, 1.35006560e-02f, 1.52845457e-01f, 3.80439401e-01f, 1.47509485e-01f, 1.14928680e-02f, 1.20989032e-01f, -2.30077300e-02f, 2.83645898e-01f, 2.20757127e-01f,
  1.87424943e-03f, 5.26579283e-02f, 2.15526894e-02f, -6.31546378e-02f, -1.25346750e-01f, 2.97576874e-01f, 1.28142148e-01f, 1.85169592e-01f, -8.71603265e-02f, 2.59871125e-01f,
  -4.28007655e-02f, 1.45393342e-01f, 2.72067985e-03f, 2.10562453e-01f, 5.07215708e-02f, 2.41242088e-02f, -9.96770486e-02f, 1.32878542e-01f, 8.67679045e-02f, 1.01852469e-01f,
  -1.14564769e-01f, 2.18540341e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.31108159e-01f, 2.04778478e-01f, -5.71681894e-02f, 1.71777159e-01f, 2.85915047e-01f, 4.50216830e-01f, 3.18017393e-01f, 1.98383197e-01f, 2.03867033e-01f, 1.71404764e-01f,
  -1.34956092e-01f, 1.47453114e-01f, 2.86299080e-01f, 1.75718769e-01f, 2.92936508e-02f, 2.24711552e-01f, 4.60374951e-02f, -7.15733692e-02f, 5.28728850e-02f, 1.37838736e-01f,
  1.84162799e-02f, 1.92196041e-01f, -4.72468734e-02f, 1.31747022e-01f, -4.02005576e-02f, 6.11810340e-03f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.13403909e-02f, 1.37065053e-01f, -1.23871624e-01f, -2.73902565e-01f, 3.80373538e-01f, 2.16237053e-01f, 8.36582705e-02f, -1.26570001e-01f, -8.30374882e-02f, -2.34563306e-01f,
  -1.78083494e-01f, -1.81983441e-01f, -1.55000225e-01f, 2.10584641e-01f, -1.92582741e-01f, -3.33609583e-04f, 2.20637117e-02f, 1.60447747e-01f, 2.26427317e-01f, -1.83584616e-01f,
  8.43524262e-02f, 1.71683803e-01f, 1.23748116e-01f, -7.90665448e-02f, 6.45826478e-03f, 1.09396139e-02f, -2.15986997e-01f, 1.81660056e-01f, -5.64106070e-02f, 8.40025023e-02f,
  -4.69515473e-02f, 2.41487756e-01f, 1.36625156e-01f, -4.30920273e-02f, -1.91826113e-02f, 2.38429420e-02f, -7.87586644e-02f, 4.56523687e-01f, 1.93298191e-01f, 4.91842516e-02f,
  -1.11787237e-01f, 2.59568840e-01f, 2.00794667e-01f, 1.28875464e-01f, -6.76860586e-02f, -1.54230610e-01f, -1.21683933e-01f, -1.60750970e-01f, -1.27901509e-01f, -3.72539967e-01f,
  2.53791362e-01f, -1.67050213e-01f, -1.04641356e-01f, -5.35719022e-02f, 1.20562777e-01f, -6.08739108e-02f, 8.37714672e-02f, -3.26306403e-01f, -1.80794701e-01f, 1.91685155e-01f,
  -1.09904215e-01f, 2.22883075e-01f, 4.87088002e-02f, 7.08114952e-02f, 7.21774772e-02f, -6.18504509e-02f, 1.64008528e-01f, -1.02933668e-01f, -8.74176845e-02f, 1.12963937e-01f,
  1.51787354e-02f, -1.01786412e-01f, 3.35607603e-02f, 1.29510343e-01f, -1.17162138e-01f, 1.99409217e-01f, 1.28849298e-01f, 5.35020903e-02f, 3.57883014e-02f, -1.11551389e-01f,
  -6.59669191e-02f, -1.25129344e-02f, -3.03369388e-02f, -8.13528225e-02f, -5.03893159e-02f, -1.71526536e-01f, 9.54303294e-02f, -6.48318091e-04f, -7.95566514e-02f, -9.64339729e-03f,
  -2.44540013e-02f, 5.35628349e-02f, -1.91815183e-01f, 9.09601822e-02f, -7.74197206e-02f, 1.11117482e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -4.06848751e-02f, 8.52111652e-02f, -1.28781199e-01f, 9.85993072e-02f, 1.92012675e-02f, 2.07570139e-02f, -9.77644995e-02f, 2.04093724e-01f, 3.95805649e-02f, 2.80480683e-01f,
  -6.14514248e-03f, 2.35532135e-01f, 3.06819677e-02f, -3.89947705e-02f, -3.65288719e-03f, 1.47397280e-01f, 6.52723536e-02f, -3.56556587e-02f, -1.38959691e-01f, -1.01544619e-01f,
  1.64154887e-01f, -2.65296102e-02f, 2.79353678e-01f, 1.38259366e-01f, -1.34981439e-01f, -9.43126231e-02f, 9.12965909e-02f, 1.40243366e-01f, 2.16242895e-01f, 8.07278156e-02f,
  1.95703015e-01f, -9.18511525e-02f, 2.38065988e-01f, 1.16355874e-01f, 8.91635716e-02f, -1.37323573e-01f, 2.94007093e-01f, 4.43526357e-01f, 4.75212857e-02f, 9.57412049e-02f,
  -1.31422818e-01f, -7.44676143e-02f, -1.33387059e-01f, 2.90972739e-01f, 3.63756150e-01f, 1.35224611e-01f, 2.81448752e-01f, 8.42076540e-02f, -1.09600537e-01f, -1.43197188e-02f,
  2.43439510e-01f, -1.98989719e-01f, 2.99958568e-02f, 9.86690000e-02f, -7.84706473e-02f, -8.76088142e-02f, -5.92212006e-02f, 2.15033647e-02f, -9.19802114e-02f, 1.51989475e-01f,
  1.04351975e-01f, -1.35526165e-01f, 8.01892579e-02f, -7.11617991e-02f, 1.98190689e-01f, 1.91166475e-01f, 1.09660491e-01f, -1.57018006e-01f, 7.63462633e-02f, 9.78694484e-02f,
  2.15345204e-01f, 8.45783856e-03f, -4.63742614e-02f, -1.49886161e-01f, 3.67525779e-02f, 4.85217534e-02f, -1.50646403e-01f, -1.11613378e-01f, -1.21431157e-01f, -1.91950593e-02f,
  -2.66040750e-02f, -1.50145963e-01f, 2.30415925e-01f, -3.52247432e-02f, -1.87452912e-01f, -2.24292818e-02f, -1.05137359e-02f, 9.19565856e-02f, -5.43011129e-02f, 2.30034247e-01f,
  -2.16993559e-02f, 4.24195714e-02f, -1.47212982e-01f, 1.77664440e-02f, 6.56714812e-02f, -9.84527841e-02f, -1.24800857e-02f, 9.25632194e-02f, 6.93023577e-02f, 1.96038261e-01f,
  3.04947704e-01f, 1.62107155e-01f, -1.61798954e-01f, -4.62481827e-02f, -2.69228369e-01f, 5.21184802e-01f, -1.67943403e-01f, 3.85116071e-01f, 2.23690525e-01f, -2.06754357e-01f,
  3.34694803e-01f, 2.75740266e-01f, 3.88168730e-02f, 9.42314714e-02f, -2.22680822e-01f, 1.94531545e-01f, 3.26285183e-01f, 3.55410017e-02f, 3.09908926e-01f, -8.89352933e-02f,
  -9.45179388e-02f, -2.56004445e-02f, -2.25315258e-01f, -1.61329791e-01f, 2.46954396e-01f, 2.49461845e-01f, -1.17388554e-02f, -1.72609519e-02f, 1.26524165e-01f, 2.50166714e-01f,
  1.91646487e-01f, -3.13901931e-01f, 5.64509183e-02f, -2.51614541e-01f, 1.90466136e-01f, -1.58810705e-01f, -9.34990719e-02f, -2.20804751e-01f, -1.11281671e-01f, 1.86025724e-01f,
  -1.98787183e-01f, 3.83021459e-02f, -6.46140203e-02f, 2.16283694e-01f, 1.24290779e-01f, 5.08103192e-01f, -1.79882884e-01f, 2.25270301e-01f, -2.19185278e-01f, 1.47199154e-01f,
  1.84766382e-01f, 2.06743460e-02f, -1.36168092e-01f, 3.04787904e-01f, -5.36474660e-02f, -1.07678071e-01f, 5.43635748e-02f, -9.56192389e-02f, 2.13335529e-01f, 1.74068987e-01f,
  1.50796860e-01f, 1.21712215e-01f, 3.21869433e-01f, 1.37633994e-01f, 1.64821353e-02f, 8.61358941e-02f, -6.52153976e-03f, 1.55988149e-02f, 8.83815959e-02f, -1.28627226e-01f,
  2.10641041e-01f, -2.57210666e-03f, 3.74200463e-01f, 1.00897975e-01f, 3.07641774e-01f, -7.21178725e-02f, -8.50278884e-02f, -4.98568593e-03f, -1.01643182e-01f, 7.24592209e-02f,
  1.42049283e-01f, -7.47730806e-02f, -1.58038288e-01f, -3.61644328e-02f, -5.73814102e-02f, -7.00739725e-03f, 2.63903588e-01f, 1.34702370e-01f, -1.92218348e-02f, -7.88349584e-02f,
  1.99918225e-02f, 5.58815636e-02f, -1.87341988e-01f, 1.56764071e-02f, -1.37244135e-01f, 1.02837726e-01f, 7.06671029e-02f, 7.16784075e-02f, -1.27476975e-01f, -3.06778494e-02f,
  -1.27869874e-01f, -3.13581433e-03f, 3.01254801e-02f, -1.08165070e-01f, 7.76184127e-02f, 9.72930491e-02f, -1.49120227e-01f, -1.42510489e-01f, -1.11112237e-01f, 1.75296336e-01f,
  -1.45923257e-01f, 9.50129256e-02f, -7.72108510e-02f, -1.31640017e-01f, -4.59940806e-02f, -1.48138911e-01f, 1.62501156e-01f, -9.10473764e-02f, -1.80676319e-02f, 8.95831455e-03f,
  -1.05200671e-01f, -1.48725300e-03f, -1.17641091e-02f, -1.25680983e-01f, 5.64453043e-02f, 1.39439270e-01f, 3.18083972e-01f, -4.15960550e-01f, 5.04026890e-01f, 3.84358019e-01f,
  -2.74544150e-01f, 1.30742788e-01f, -1.24263950e-01f, -6.62891986e-03f, 4.91682589e-02f, 2.44910404e-01f, 6.33107662e-01f, 1.20866269e-01f, 4.63284254e-01f, 2.70499457e-02f,
  -1.09980203e-01f, 2.41597340e-01f, -1.01911344e-01f, -1.57629237e-01f, 5.89537449e-05f, 2.08036423e-01f, -2.78391689e-01f, -6.17468804e-02f, 2.39661336e-01f, 1.52135327e-01f,
  2.06839457e-01f, 1.33443639e-01f, -5.61205372e-02f, -2.49466002e-01f, 5.22617809e-02f, -2.63205558e-01f, 3.05295765e-01f, 3.95057648e-01f, 2.00330824e-01f, -1.39465034e-01f,
  -5.87265074e-01f, -7.13116825e-01f, 5.12645066e-01f, 1.03477351e-02f, 1.67437747e-01f, -2.18969688e-01f, 1.15294829e-01f, 4.22728002e-01f, -7.18282461e-02f, 4.15618345e-02f,
  2.88436830e-01f, -1.12633221e-01f, 2.14988068e-01f, 1.48361310e-01f, -2.53420532e-01f, 4.83019233e-01f, -4.42762859e-02f, -1.52757645e-01f, 2.75299430e-01f, 4.43990063e-03f,
  -6.69399323e-03f, 3.58737111e-01f, -2.73608956e-02f, -2.29989246e-01f, 1.10968135e-01f, -9.61281434e-02f, 3.96943763e-02f, 3.16788137e-01f, -6.85816929e-02f, 2.30575651e-01f,
  -6.81720860e-03f, -1.15734883e-01f, 5.04583828e-02f, 2.65195876e-01f, 1.08411357e-01f, 1.75797269e-01f, 1.15425311e-01f, 1.05237111e-01f, -7.65959993e-02f, -1.14066616e-01f,
  -9.42496061e-02f, 1.13404214e-01f, 1.62057012e-01f, -8.26759338e-02f, -6.72137588e-02f, -1.54477462e-01f, 1.20567061e-01f, -5.35760969e-02f, 1.34647712e-01f, -7.38114044e-02f,
  4.46384996e-02f, 2.75459960e-02f, -8.71575475e-02f, 7.80893713e-02f, 7.13280737e-02f, 1.17707467e-02f, -1.09682120e-01f, -1.51484832e-01f, -1.00447694e-02f, -2.00128853e-01f,
  9.79809538e-02f, -3.79478037e-02f, -9.29360837e-02f, 2.73604244e-01f, -3.80473197e-01f, -1.39800400e-01f, 2.64604509e-01f, 1.46028787e-01f, 2.66844720e-01f, -8.80549848e-03f,
  2.06490487e-01f, 1.14094831e-01f, 4.58684862e-02f, 1.99809764e-02f, 1.97308823e-01f, -2.00993448e-01f, -1.88802853e-01f, 4.52061109e-02f, -1.51150897e-01f, 3.24275970e-01f,
  3.33511606e-02f, -3.82204913e-02f, 9.38385129e-02f, 1.44745678e-01f, 1.03285663e-01f, -6.47236034e-03f, 8.59810337e-02f, -1.62112772e-01f, 2.72380769e-01f, -1.54579967e-01f,
  -1.28945962e-01f, -8.68802331e-03f, -9.57876295e-02f, -9.87620205e-02f, 1.14795268e-02f, -1.90821275e-01f, 1.55111253e-01f, -1.27672166e-01f, -5.16370386e-02f, -9.40352604e-02f,
  -1.65502548e-01f, 2.37887073e-02f, 1.17368944e-01f, 1.49606869e-01f, -2.47961171e-02f, 1.16953939e-01f, 3.00809415e-03f, 1.97208613e-01f, 6.14182316e-02f, 2.94559430e-02f,
  4.84880358e-02f, 1.15793630e-01f, -8.93758610e-02f, 3.85678001e-02f, 1.57259017e-01f, -1.02575622e-01f, -1.38720796e-01f, -7.75607228e-02f, -1.07853420e-01f, 8.36539790e-02f,
  -8.78597945e-02f, -3.90781872e-02f, 1.86374143e-01f, -8.70443583e-02f, 3.66173446e-01f, 2.00080588e-01f, 6.93875328e-02f, 2.32350305e-01f, -2.59525061e-01f, 1.18623786e-01f,
  -7.78828980e-04f, 3.04980993e-01f, -1.18213773e-01f, 5.70430338e-01f, 3.35536361e-01f, 4.12026614e-01f, 2.44844511e-01f, -3.12914938e-01f, 2.45420441e-01f, -1.28341407e-01f,
  -2.62159780e-02f, -1.85364977e-01f, 9.00625158e-03f, -1.31248450e-02f, 3.02455306e-01f, 4.67653759e-03f, 2.79031754e-01f, 1.65146932e-01f, 6.44865856e-02f, -7.89586827e-02f,
  1.91551112e-02f, 5.36581874e-02f, 2.49229595e-01f, 1.13753088e-01f, 2.88371816e-02f, 7.67843872e-02f, 2.12915793e-01f, 3.16424966e-02f, -1.47789970e-01f, -1.10812940e-01f,
  -6.73227757e-02f, 1.96332991e-01f, 5.51451789e-03f, 5.21158464e-02f, -2.47576177e-01f, 7.87219256e-02f, -3.49099562e-02f, 3.13157976e-01f, 1.11959176e-03f, -1.05224490e-01f,
  1.65326595e-01f, 1.71177521e-01f, 4.71528657e-02f, -2.16409247e-02f, -5.72326370e-02f, -3.95744629e-02f, -9.82615538e-03f, 1.68659255e-01f, 1.29827127e-01f, -9.94875506e-02f,
  -6.77013919e-02f, 4.48818244e-02f, -1.30349873e-02f, 1.47003487e-01f, -1.77183777e-01f, -1.32113129e-01f, -2.57822853e-02f, 2.49983653e-01f, 3.56781185e-02f, -1.15430735e-01f,
  1.38593733e-01f, 2.13028058e-01f, -7.08852261e-02f, 1.17639124e-01f, 1.37220100e-01f, 7.25896955e-02f, -3.86530645e-02f, 2.40868796e-03f, -1.06981464e-01f, 1.34840623e-01f,
  -9.75416601e-02f, -1.67748854e-01f, -1.43517170e-03f, 4.16960195e-03f, -4.63089272e-02f, 2.13685613e-02f, -1.40026137e-02f, -9.20329541e-02f, 3.08808917e-03f, 1.00447178e-01f,
  -8.37559327e-02f, -5.65293655e-02f, 6.77510947e-02f, -3.42287160e-02f, -9.79777649e-02f, 1.25498667e-01f, -1.34846568e-01f, -2.65362505e-02f, -1.61672868e-02f, 3.51752602e-02f,
  -5.46246581e-02f, -4.24258374e-02f, 1.09911799e-01f, -4.12581190e-02f, -3.58164385e-02f, 8.02478790e-02f, 2.33974442e-01f, 1.69213235e-01f, -1.87626496e-01f, 2.51999557e-01f,
  1.56460434e-01f, 5.10436622e-03f, -1.46519840e-01f, -7.80931190e-02f, -1.09920993e-01f, 2.00194612e-01f, 8.59155226e-03f, 2.48415843e-01f, 1.45099759e-02f, 4.95105311e-02f,
  1.21737994e-01f, -7.69586070e-03f, 7.45221227e-02f, 3.08326948e-02f, -1.29154146e-01f, 1.95042595e-01f, -1.00111581e-01f, -3.23523395e-02f, -2.69159153e-02f, -2.61667813e-03f,
  -1.42803580e-01f, 1.03628606e-01f, 4.55204360e-02f, -6.35057837e-02f, -1.21550851e-01f, -6.06481032e-03f, 3.34236547e-02f, 4.17099446e-02f, -2.10691690e-01f, -4.01345752e-02f,
  -1.41742378e-02f, 9.58307181e-03f, 1.44704342e-01f, 7.53644779e-02f, 1.42573670e-01f, 3.34994979e-02f, 6.11280873e-02f, 1.41927093e-01f, 8.18255544e-03f, 6.76308945e-02f,
  1.43236831e-01f, 4.35180664e-02f, -1.19822077e-01f, 1.30097628e-01f, -1.10503905e-01f, 1.85955673e-01f, 3.85362878e-02f, 5.88564500e-02f, -1.19621769e-01f, 1.24567421e-02f,
  1.77033812e-01f, -1.06802873e-01f, 3.19788419e-02f, -1.17313884e-01f, -2.17139553e-02f, -1.87631220e-01f, -1.04985829e-03f, -1.87158436e-01f, -3.64001393e-02f, -2.26238817e-01f,
  1.93651527e-01f, 1.28670916e-01f, -2.98298318e-02f, 6.38044178e-02f, -7.76980584e-03f, 2.06952035e-01f, -4.01274301e-02f, -9.14018601e-02f, -7.85516500e-02f, 3.79271694e-02f,
  1.02083452e-01f, -1.03273124e-01f, -5.14405593e-02f, 4.92306352e-02f, -1.39542237e-01f, 3.54842804e-02f, -1.61428258e-01f, -1.61585853e-01f, -1.28740619e-03f, 3.12797241e-02f,
  -1.20292969e-01f, -6.64635003e-02f, 1.18765362e-01f, -3.55718359e-02f, -1.09171301e-01f, 3.35930847e-02f, 4.81816232e-01f, 3.28722954e-01f, 3.48936856e-01f, 3.41878682e-01f,
  -5.22768736e-01f, 1.04278557e-01f, 4.00912017e-01f, 4.16086733e-01f, 5.42593226e-02f, 3.03017169e-01f, 4.66129571e-01f, 2.37360239e-01f, 4.45511132e-01f, 1.46782789e-02f,
  6.72304332e-02f, -2.38201320e-01f, -3.57771367e-02f, -1.10863902e-01f, 3.38299602e-01f, -1.02659993e-01f, 3.27390939e-01f, -2.17406049e-01f, -8.75909105e-02f, -6.44589663e-02f,
  -1.73846394e-01f, 1.69276667e-03f, 2.72936523e-01f, 1.30257830e-02f, -6.12993650e-02f, 7.81267807e-02f, -1.30399302e-01f, -9.91194248e-02f, 4.24371287e-02f, 1.08490601e-01f,
  3.92482243e-02f, -4.53873307e-01f, 4.63226944e-01f, -2.02511683e-01f, 6.65389076e-02f, -1.76221237e-01f, 1.00504354e-01f, -2.15302005e-01f, -2.26710320e-01f, 2.94351697e-01f,
  6.32717162e-02f, 3.23306352e-01f, -2.46083997e-02f, 2.69563019e-01f, 4.26528864e-02f, 5.41134417e-01f, -2.74420320e-03f, 3.12225595e-02f, -1.02400549e-01f, 2.52000868e-01f,
  1.17397323e-01f, 1.55597487e-02f, 1.26554444e-01f, 3.22343558e-01f, 9.67665389e-02f, 9.17424485e-02f, -2.58283168e-02f, 4.73505110e-02f, 3.85761224e-02f, 8.53170902e-02f,
  9.74543616e-02f, 7.49434233e-02f, 2.29718775e-01f, -1.44055381e-01f, 2.86820590e-01f, 2.70338982e-01f, 9.37573239e-02f, -5.91190681e-02f, 1.08439453e-01f, -1.85456246e-01f,
  -7.73055926e-02f, 1.88895781e-02f, 4.21381086e-01f, 1.85388625e-02f, 2.75970101e-01f, 1.58110470e-01f, 9.46077928e-02f, 1.62323162e-01f, 2.44188160e-01f, -1.77555606e-01f,
  2.05999557e-02f, 2.44944632e-01f, -1.98809057e-01f, -6.75239787e-02f, 6.17898032e-02f, -1.04877092e-01f, 1.59638599e-01f, -2.39893701e-02f, 1.21702954e-01f, -1.00335114e-01f,
  -1.12703346e-01f, -2.18375862e-01f, 3.49332811e-03f, -4.66256328e-02f, 1.06484428e-01f, -8.14876612e-03f, -1.83272451e-01f, -3.00060987e-01f, 2.11254403e-01f, -9.55729932e-02f,
  -1.76756561e-01f, 1.93805471e-01f, 1.02390073e-01f, 3.41975540e-01f, -5.79823069e-02f, -2.08719760e-01f, -1.28770217e-01f, 6.79973587e-02f, -2.34868024e-02f, 2.84467906e-01f,
  -1.59742326e-01f, 2.10753649e-01f, -1.92683190e-01f, -1.31237730e-01f, 3.96044180e-02f, 5.43761477e-02f, -2.18862772e-01f, 2.32135177e-01f, -2.09169149e-01f, -9.83719006e-02f,
  -1.98415712e-01f, -1.62725702e-01f, 1.43172830e-01f, 2.96538144e-01f, 1.51907176e-01f, -7.32211843e-02f, 2.56840110e-01f, 1.01431198e-01f, 1.45228401e-01f, -2.67112274e-02f,
  -5.16623370e-02f, 2.43830346e-02f, -1.02403641e-01f, -4.83261757e-02f, -9.36966911e-02f, 7.90349841e-02f, -3.91929671e-02f, -1.07328445e-01f, 1.04161233e-01f, -1.61045685e-01f,
  -2.32065208e-02f, 7.50828832e-02f, 2.18293294e-01f, -1.34821832e-01f, 1.78686246e-01f, -1.13323435e-01f, -1.18525378e-01f, 2.08885863e-01f, -4.57551740e-02f, -3.90139669e-02f,
  1.18139490e-01f, 1.22328691e-01f, -3.59279923e-02f, 1.30304834e-04f, 4.40291874e-02f, -5.01793139e-02f, -1.87253803e-02f, -8.71348009e-03f, -1.38879627e-01f, -6.27810508e-02f,
  2.16857672e-01f, -1.38916016e-01f, -1.15645699e-01f, 8.39978755e-02f, 2.73726620e-02f, 1.03444375e-01f, -1.57673880e-01f, 1.94124982e-01f, -7.12203234e-02f, 1.72578186e-01f,
  -1.53146118e-01f, 2.49008507e-01f, 5.50021827e-02f, 2.26308212e-01f, 2.24309713e-02f, 2.06480473e-01f, -9.29142460e-02f, -6.39888495e-02f, 2.59321630e-01f, 5.69632836e-02f,
  1.45235240e-01f, -5.22781648e-02f, -7.99756572e-02f, 1.02071359e-03f, -9.25923213e-02f, 7.55172446e-02f, 2.20152780e-01f, 1.58307806e-01f, 8.82337894e-03f, 1.46047533e-01f,
  5.82657941e-02f, 8.48212396e-04f, -1.33792385e-01f, 1.39178112e-01f, 2.05334350e-01f, 1.22848429e-01f, 1.62518159e-01f, 2.38378003e-01f, 1.29753023e-01f, 9.06343535e-02f,
  7.64369294e-02f, -7.59859234e-02f, 1.25063092e-01f, -2.00257432e-02f, 8.55740458e-02f, -1.29138947e-01f, -9.96255651e-02f, 1.73418090e-01f, 2.39981581e-02f, -1.83297008e-01f,
  -6.28172010e-02f, -8.19617063e-02f, -1.33918151e-01f, 1.56924859e-01f, -3.50503698e-02f, 6.35109767e-02f, -1.01702116e-01f, 1.26613885e-01f, -7.26948157e-02f, 1.20291546e-01f,
  -1.50612891e-01f, 1.73805326e-01f, -5.19267023e-02f, 1.75523441e-02f, 1.37318537e-01f, 1.29538074e-01f, 6.50040712e-03f, 2.84925222e-01f, 2.14648664e-01f, -1.87747832e-02f,
  1.88245192e-01f, -8.39957073e-02f, 3.98543477e-01f, -3.23780775e-02f, 2.31695190e-01f, -8.59161168e-02f, -1.33257300e-01f, -1.28798708e-01f, 6.24451898e-02f, 1.24118567e-01f,
  1.30624205e-01f, -1.69749539e-02f, -1.61079075e-02f, 4.34651896e-02f, 2.04373121e-01f, -5.57287820e-02f, 2.01128334e-01f, 1.01428621e-01f, 1.39452070e-01f, -3.84956114e-02f,
  1.08922953e-02f, -2.29873648e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.41390143e-02f, 2.86928415e-01f, 1.50193036e-01f, -1.41870631e-02f, 1.53913543e-01f, -4.72372733e-02f, -8.47058818e-02f, 1.17235765e-01f, 4.05070722e-01f, 8.14888552e-02f,
  5.09018116e-02f, 5.73951267e-02f, 3.46823603e-01f, 6.20994344e-02f, -8.96300562e-03f, -2.08582468e-02f, -9.33189243e-02f, -8.45107585e-02f, 4.63097632e-01f, 3.59174699e-01f,
  1.29145578e-01f, 1.95782781e-01f, 2.68285386e-02f, -5.73928319e-02f, 1.27698645e-01f, 1.07981771e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.59168914e-01f, -1.57203600e-02f, -1.57715157e-01f, -5.09950876e-01f, -3.45177986e-02f, 6.79114684e-02f, -8.18748623e-02f, -1.48809806e-01f, -2.86914203e-02f, 2.49888286e-01f,
  -1.81234419e-01f, -6.99514225e-02f, -1.15456484e-01f, -2.07291007e-01f, -1.15636334e-01f, -4.72360961e-02f, 1.94653690e-01f, -1.92572951e-01f, 3.62378597e-01f, -5.07648848e-02f,
  2.28795558e-02f, 9.28535387e-02f, -1.18871637e-01f, 8.06093439e-02f, 7.07934946e-02f, -1.69789389e-01f, -2.57016122e-01f, -1.21626146e-01f, 6.33358806e-02f, -1.33333370e-01f,
  1.34621799e-01f, -8.78574848e-02f, -9.16461349e-02f, 8.15823078e-02f, 6.21993989e-02f, -2.03778818e-01f, -2.86160529e-01f, -1.20976597e-01f, -2.79915612e-02f, -1.71611786e-01f,
  2.82082763e-02f, 2.01066285e-01f, 1.18078172e-01f, -2.21162826e-01f, -4.46971096e-02f, -2.74615109e-01f, 1.91925809e-01f, -1.95292562e-01f, 2.72937030e-01f, -8.74659270e-02f,
  4.74669039e-02f, 1.71064869e-01f, 1.28589407e-01f, 1.39771029e-01f, 2.21801057e-01f, -4.15192805e-02f, -2.15986520e-01f, -1.14155345e-01f, 5.52367826e-04f, 9.46930796e-02f,
  -1.61014572e-01f, 1.96197674e-01f, -2.46383175e-02f, -8.63694400e-02f, -1.91137195e-01f, -1.68634176e-01f, -1.11402549e-01f, -3.09276253e-01f, -1.62938029e-01f, 4.32626344e-03f,
  1.61890835e-01f, 1.40666068e-02f, -1.87635183e-01f, -7.17550293e-02f, 5.86920269e-02f, 1.66825935e-01f, 1.48740575e-01f, 1.11863818e-02f, 1.14212371e-01f, -7.71260336e-02f,
  -6.98019713e-02f, 7.02097416e-02f, 1.73841283e-01f, -1.33924289e-02f, 2.94624642e-02f, -3.31045315e-02f, -1.73765719e-01f, 1.15411013e-01f, 1.50175421e-02f, 9.07642543e-02f,
  -6.18903004e-02f, 1.99166030e-01f, -1.16427675e-01f, 1.42345235e-01f, 1.58206761e-01f, 2.24600226e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.24243784e-01f, 1.44710898e-01f, 9.02857035e-02f, 1.49720058e-01f, 4.53617005e-03f, 1.75364733e-01f, 1.44306675e-01f, -1.05556972e-01f, 1.27111480e-01f, 3.12729999e-02f,
  2.84396797e-01f, -2.03874614e-02f, -1.61258906e-01f, -1.29847988e-01f, 3.67037684e-01f, 9.84522849e-02f, 8.80831629e-02f, 6.30217716e-02f, 9.81603265e-02f, 3.73136662e-02f,
  -5.34358658e-02f, 1.11429639e-01f, -1.40154108e-01f, -8.71074721e-02f, -1.32027999e-01f, 3.00585628e-01f, -1.12894274e-01f, 1.69984534e-01f, -1.36500031e-01f, 8.30212981e-02f,
  1.18899621e-01f, -1.70051321e-01f, -1.21251456e-01f, -9.16018859e-02f, 4.30937894e-02f, -3.65838408e-01f, 1.67753369e-01f, 1.14405304e-01f, 2.43456274e-01f, 1.64615840e-01f,
  -2.02820942e-01f, 4.17836457e-01f, -1.20052181e-01f, 1.43612161e-01f, -6.35857210e-02f, 1.75968826e-01f, -3.91632020e-02f, -9.96563062e-02f, 1.46980375e-01f, 1.26509443e-01f,
  4.18699443e-01f, 5.48844151e-02f, 3.81971076e-02f, 6.32439926e-02f, 1.01443209e-01f, -2.42780764e-02f, 1.63411409e-01f, 6.74549192e-02f, -1.78570822e-01f, 7.89518133e-02f,
  1.40560538e-01f, 6.08498082e-02f, -7.95007423e-02f, 1.90032542e-01f, -2.78582815e-02f, 1.00209087e-01f, -1.46477977e-02f, -2.56110609e-01f, -5.32586798e-02f, 4.38672071e-03f,
  -3.98795642e-02f, 1.38679603e-02f, 4.04592529e-02f, -1.43413559e-01f, 3.47934105e-03f, 1.68856964e-01f, 6.97049946e-02f, -2.32977062e-01f, 3.46852511e-01f, 1.61823198e-01f,
  1.54095441e-01f, -1.17114015e-01f, -1.02153523e-02f, 9.73353907e-02f, -5.34130409e-02f, 4.77137305e-02f, -5.75310104e-02f, 7.81758204e-02f, 6.58618286e-02f, -2.25233808e-01f,
  -2.96272095e-02f, 1.67850524e-01f, 5.06650731e-02f, -1.10071391e-01f, -1.15638688e-01f, 2.54869834e-02f, -1.08009383e-01f, -4.50733155e-02f, -1.29984483e-01f, -4.64474894e-02f,
  -1.59034118e-01f, 1.82349440e-02f, 2.31753811e-01f, -2.10636947e-02f, -1.46027967e-01f, 2.37284675e-01f, 2.16280371e-01f, 1.31523117e-01f, -1.83941051e-01f, -7.65774474e-02f,
  2.22887009e-01f, -3.06497607e-02f, -6.93059638e-02f, 1.53395250e-01f, 2.13093922e-01f, 4.19693217e-02f, 1.05756158e-02f, -1.45619974e-01f, -1.39300391e-01f, -3.77786979e-02f,
  1.26796201e-01f, 8.31618682e-02f, -3.09463907e-02f, 1.93749264e-01f, 8.32476001e-03f, 2.96291225e-02f, 9.70392860e-03f, -1.56716228e-01f, -3.54915768e-01f, -1.96088105e-01f,
  7.19364956e-02f, -2.41727680e-01f, 6.27011210e-02f, 7.79952332e-02f, 2.69189686e-01f, -1.34719059e-01f, -1.49623215e-01f, 1.04151703e-01f, 6.98401108e-02f, -1.46340162e-01f,
  -9.87840891e-02f, -2.92071432e-01f, 2.88138181e-01f, 1.09692983e-01f, 2.19912410e-01f, -4.06608023e-02f, 6.94053024e-02f, -4.70900210e-03f, -1.58571914e-01f, 1.48360431e-01f,
  -1.44477800e-01f, -3.22486274e-02f, 1.91357553e-01f, -7.65258307e-03f, -8.20479691e-02f, 1.55109808e-01f, -5.60390390e-02f, 1.76386446e-01f, -5.39101325e-02f, 6.81830496e-02f,
  -1.29421234e-01f, -6.52570277e-02f, -1.83847621e-02f, 1.11298956e-01f, -1.32960200e-01f, -8.80810693e-02f, -1.49788603e-01f, -2.48495594e-01f, -1.73348367e-01f, -1.07833385e-01f,
  1.49985895e-01f, -1.96310058e-01f, 6.37775660e-02f, -5.36240675e-02f, 3.13395470e-01f, -1.22580886e-01f, -1.02372251e-01f, 6.92513287e-02f, 6.99090809e-02f, 1.94637299e-01f,
  7.60893747e-02f, -3.08505483e-02f, -8.54521692e-02f, 1.96775451e-01f, -3.11249308e-02f, 3.52135450e-02f, -2.27168396e-01f, 3.28830481e-01f, 1.74432565e-02f, 1.60359144e-01f,
  1.55605555e-01f, -1.87991142e-01f, 5.79069071e-02f, 1.62097234e-02f, -4.14785109e-02f, -1.74458727e-01f, 2.35566661e-01f, 6.23673797e-02f, -1.00914277e-01f, -2.10777484e-02f,
  2.57869307e-02f, -9.26090404e-02f, 1.76185206e-01f, -6.13716953e-02f, -1.01599842e-01f, -2.69581914e-01f, 1.66289717e-01f, -1.58926502e-01f, 1.90414980e-01f, 6.70260340e-02f,
  1.90380037e-01f, -6.59765527e-02f, 1.12469681e-01f, 2.41782278e-01f, -1.93117917e-01f, 3.20639126e-02f, 2.19003841e-01f, -2.14228421e-01f, -2.16416970e-01f, 1.44666925e-01f,
  -1.83945701e-01f, 1.41729027e-01f, 2.10072413e-01f, -5.95814139e-02f, 2.59422153e-01f, 2.97357291e-01f, 2.64326692e-01f, -4.41957504e-01f, 1.81478545e-01f, 8.38805735e-03f,
  -1.81998387e-01f, -1.21347480e-01f, 8.02735090e-02f, -2.42859453e-01f, -2.68420167e-02f, 2.43108422e-01f, -2.24536031e-01f, -1.05127223e-01f, 4.08048749e-01f, -8.16251561e-02f,
  1.63540408e-01f, -1.15454584e-01f, 2.79727429e-01f, -7.53172338e-02f, -4.40045409e-02f, 1.27196848e-01f, -1.20738082e-01f, 4.96423729e-02f, 5.71364939e-01f, -2.63037145e-01f,
  -5.97006604e-02f, -3.84403095e-02f, 8.59051570e-02f, -2.10036188e-01f, 1.58014372e-01f, 1.21099547e-01f, 3.55915070e-01f, 1.29422218e-01f, 2.31617570e-01f, 3.01148683e-01f,
  -2.07080916e-01f, 2.19900265e-01f, -1.53828770e-01f, 2.94042956e-02f, 1.76288486e-01f, 3.04334257e-02f, 3.45130354e-01f, 2.10714228e-02f, -4.80547771e-02f, -1.29273653e-01f,
  5.72937489e-01f, -1.08917020e-01f, -1.63193509e-01f, 1.08736716e-01f, -6.67153746e-02f, 5.65844439e-02f, -5.17867208e-02f, 1.38098300e-01f, -1.09402023e-01f, 6.65067434e-02f,
  -9.19596180e-02f, 4.79694456e-01f, -5.06708622e-02f, 1.68778971e-01f, 8.18480998e-02f, 5.48609719e-02f, -3.27252895e-02f, -4.01190706e-02f, 2.84347087e-01f, 8.24427754e-02f,
  2.17945695e-01f, -1.37024582e-03f, -1.45658329e-02f, -1.73457533e-01f, 4.35300805e-02f, -3.47876102e-02f, -8.60800520e-02f, -1.55856805e-02f, 3.69775414e-01f, -1.14758044e-01f,
  7.80301541e-02f, -2.85126865e-01f, 3.13690394e-01f, -4.82754149e-02f, -1.19171269e-01f, 1.51249781e-01f, -2.38111988e-01f, 3.32006328e-02f, -4.59987037e-02f, 7.41496161e-02f,
  -1.64555565e-01f, 2.10583642e-01f, -4.51064929e-02f, 9.32349116e-02f, 1.24410696e-01f, 3.16845149e-01f, -2.49549821e-02f, -1.05108824e-02f, -1.36889145e-01f, -2.34045088e-01f,
  2.70923972e-01f, 3.00347358e-01f, 1.18717700e-01f, -4.21956122e-01f, -4.37100410e-01f, -1.08622294e-02f, -1.92654267e-01f, -5.26680201e-02f, 1.72065973e-01f, -2.79296517e-01f,
  1.69706285e-01f, 6.17890321e-02f, -1.28578603e-01f, -2.98653722e-01f, 9.23602819e-01f, -1.48165643e-01f, 4.11904037e-01f, -1.52799249e-01f, 2.95728832e-01f, -4.11306061e-02f,
  7.36745223e-02f, -1.00463890e-01f, -2.01524328e-02f, 1.44293383e-01f, 3.54135513e-01f, 6.59013912e-02f, -3.70635167e-02f, 1.59303859e-01f, 1.07807167e-01f, -2.40863979e-01f,
  1.36095479e-01f, -1.40217885e-01f, 2.35838473e-01f, 3.02930146e-01f, 4.24900025e-01f, 3.47267658e-01f, -3.88487786e-01f, -3.97409834e-02f, 9.33299363e-02f, -2.15096381e-02f,
  1.17907085e-01f, 1.39112473e-01f, 5.69748163e-01f, -6.45617396e-02f, 2.59683281e-02f, -3.16155776e-02f, 1.00694031e-01f, 5.25790416e-02f, -2.44580820e-01f, 6.56511262e-02f,
  -2.06880152e-01f, -6.46676570e-02f, -1.43446773e-01f, 2.46612981e-01f, 9.59645137e-02f, -1.42562538e-01f, -2.09956393e-01f, 6.44568503e-01f, -1.00379877e-01f, 1.37199789e-01f,
  -8.93196762e-02f, 2.17800587e-01f, -4.58549522e-02f, 2.11908631e-02f, -1.24910027e-01f, 8.49998295e-02f, -5.24827912e-02f, -1.84302106e-01f, 1.48640960e-01f, -1.00053690e-01f,
  1.13391943e-01f, -1.78910017e-01f, -2.25274235e-01f, 3.27382296e-01f, -1.12477623e-01f, 1.21378012e-01f, 5.33539616e-03f, 5.26160281e-03f, 7.97323361e-02f, -1.25208169e-01f,
  1.29305124e-01f, 1.45805895e-01f, 2.13955328e-01f, 1.46322913e-04f, -7.54817873e-02f, 6.48750290e-02f, 5.53630926e-02f, -1.39860451e-01f, 3.24457437e-01f, 4.46415553e-03f,
  6.02302514e-02f, -1.42464995e-01f, -4.25790623e-02f, -1.17864817e-01f, 4.99864295e-02f, 1.66823715e-01f, -2.04325691e-02f, -1.58011958e-01f, -2.58566618e-01f, 7.66083365e-03f,
  -1.87957197e-01f, 6.18445575e-02f, 2.26248354e-01f, -1.80255640e-02f, -1.85818285e-01f, 1.50561512e-01f, -8.77121538e-02f, 8.04210082e-02f, -1.37049720e-01f, 2.66155243e-01f,
  -3.20187621e-02f, -6.50779977e-02f, 6.70586852e-03f, 7.30306432e-02f, 4.76663746e-02f, -1.29829422e-01f, -1.19294319e-02f, -9.97757912e-02f, -1.12736903e-01f, 1.09875858e-01f,
  3.21283132e-01f, -1.01801470e-01f, 1.37611046e-01f, -1.80414736e-01f, 1.52296228e-02f, -1.16014808e-01f, 1.08225822e-01f, 1.75096467e-01f, 1.67356879e-01f, 2.71335542e-01f,
  3.68440598e-01f, 3.19889814e-01f, 2.62078702e-01f, 1.67294994e-01f, -1.49109766e-01f, 3.83360863e-01f, -1.07328594e-01f, -1.55297846e-01f, -6.70029819e-02f, -1.05381422e-01f,
  1.40702680e-01f, 2.69460380e-01f, -1.89880133e-01f, 6.26624301e-02f, -2.91219074e-03f, 2.22328976e-01f, -2.32938394e-01f, 1.23806939e-01f, -8.58983472e-02f, -7.57839903e-02f,
  1.42791659e-01f, -1.72225609e-01f, -1.86467858e-03f, 3.04250926e-01f, 3.51221442e-01f, -3.78119461e-02f, -7.79215097e-02f, 9.17954072e-02f, -9.59923142e-04f, -1.22530349e-01f,
  -6.43438399e-02f, 1.97184160e-02f, 2.64912277e-01f, -2.86791831e-01f, 8.06296766e-02f, -5.62269017e-02f, 2.03712687e-01f, -1.80629075e-01f, -4.80706580e-02f, 1.41348884e-01f,
  -6.98386654e-02f, 3.69403847e-02f, -1.54170334e-01f, -2.78421998e-01f, 2.49921352e-01f, 6.52553067e-02f, 3.51138830e-01f, -7.96004012e-02f, 4.43095803e-01f, -1.71847060e-01f,
  3.30243297e-02f, 3.98571044e-02f, 5.35992198e-02f, -1.71983257e-01f, 4.62284803e-01f, -1.91060394e-01f, -2.93346196e-02f, 7.63779692e-03f, -9.56768617e-02f, -1.50248140e-01f,
  9.35027748e-02f, -6.08555973e-02f, -4.86108549e-02f, -1.64830044e-01f, -4.66309069e-03f, -2.23772883e-01f, 2.23788321e-01f, -5.23847416e-02f, -1.33860409e-02f, 3.27819102e-02f,
  -1.44253820e-01f, 1.74521692e-02f, 1.44321239e-02f, 2.10713163e-01f, 6.71290457e-02f, -7.68064931e-02f, -5.59091456e-02f, -3.79909482e-03f, -1.18239328e-01f, 2.02630628e-02f,
  2.03655958e-01f, 9.72647294e-02f, 1.40454873e-01f, -2.82282121e-02f, 8.90176296e-02f, -1.46947175e-01f, 2.92854875e-01f, 1.94889940e-02f, 1.24718621e-03f, -1.89688578e-02f,
  1.81694906e-02f, -7.13667497e-02f, 1.70753747e-01f, 7.94706345e-02f, 5.25720000e-01f, 3.75748396e-01f, 4.46282476e-02f, 7.65004307e-02f, 5.83844304e-01f, 2.77512491e-01f,
  1.79518729e-01f, 3.20234746e-01f, 1.13738822e-02f, 5.20842373e-01f, 1.17428958e-01f, -1.53373957e-01f, -7.88596645e-02f, -1.35441333e-01f, -7.47677535e-02f, 1.03406712e-01f,
  -2.12127686e-01f, 1.07530199e-01f, 5.84760845e-01f, 3.48655492e-01f, 1.55729845e-01f, 1.90714955e-01f, -1.28478751e-01f, -4.40148078e-03f, 2.30668694e-01f, -1.79091021e-01f,
  -1.38026476e-01f, 2.82843322e-01f, -7.63490200e-02f, -7.75969923e-02f, 1.90180913e-01f, -3.05893302e-01f, 2.69324690e-01f, -6.89078718e-02f, 2.84310013e-01f, 2.05231652e-01f,
  -2.96195328e-01f, -1.03838287e-01f, -8.68657883e-03f, -1.27088979e-01f, 1.60228077e-03f, -2.55288035e-01f, 1.77353054e-01f, -4.36811037e-02f, 1.85950957e-02f, 4.07301746e-02f,
  3.82525504e-01f, -8.11752602e-02f, 1.87866405e-01f, 1.73197109e-02f, -2.11340085e-01f, -5.02655618e-02f, 3.41476351e-02f, -2.58021001e-02f, -9.81282368e-02f, -1.40334368e-01f,
  1.05216622e-01f, 8.59570131e-02f, -9.19271559e-02f, 6.75515905e-02f, -1.12150528e-01f, 1.21105962e-01f, 1.33732066e-01f, 1.39697328e-01f, -6.00373633e-02f, -5.13974167e-02f,
  6.83865473e-02f, 9.78689194e-02f, 2.15273574e-01f, -1.21995218e-01f, -1.35376817e-02f, 2.56579220e-01f, 1.61921248e-01f, -8.31520706e-02f, -1.37073979e-01f, -9.36232731e-02f,
  -2.35853866e-02f, 4.74042781e-02f, -1.86881974e-01f, 1.22190908e-01f, 1.41134411e-01f, 1.99901350e-02f, -1.35562317e-02f, 2.06220746e-01f, 1.04511857e-01f, 7.41511062e-02f,
  1.70967311e-01f, 1.49533659e-01f, -8.94078091e-02f, -8.45393017e-02f, 2.12133035e-01f, 8.27732906e-02f, -2.06134077e-02f, -9.11076814e-02f, -1.65852964e-01f, 5.00164228e-03f,
  -3.56497318e-02f, -2.62741409e-02f, 2.06300125e-01f, 6.56513646e-02f, -2.35364199e-01f, 1.85709875e-02f, -2.17755940e-02f, 2.59333670e-01f, 1.01073638e-01f, 6.17547669e-02f,
  4.58600558e-02f, 2.31576577e-01f, -7.16281459e-02f, 6.07142270e-01f, -4.09631357e-02f, 6.68657050e-02f, 4.67335060e-02f, 1.58276662e-01f, 1.76819429e-01f, 3.80474068e-02f,
  1.28656879e-01f, -1.93157196e-01f, 2.12953091e-02f, 7.15783685e-02f, 4.36875112e-02f, 1.64108314e-02f, 2.90284574e-01f, 4.45269644e-02f, -2.86639296e-02f, -1.26924276e-01f,
  9.84651223e-02f, 5.61945401e-02f, -3.49268392e-02f, 1.52826533e-01f, -1.36809096e-01f, -7.11167650e-03f, 3.84492785e-01f, 1.48016408e-01f, 1.11524493e-01f, -5.24438284e-02f,
  1.47151917e-01f, -2.68284678e-01f, -1.98175788e-01f, -5.90610020e-02f, -1.30750179e-01f, -2.17485443e-01f, 9.56895575e-02f, 4.88106795e-02f, 3.51686329e-02f, 1.35771036e-01f,
  1.82545349e-01f, 1.75416648e-01f, -2.37308349e-03f, -9.41695198e-02f, -1.24335177e-01f, 1.67635083e-01f, 3.44019443e-01f, -9.78041217e-02f, 6.97735175e-02f, 4.67023440e-02f,
  1.89327314e-01f, -1.40043423e-01f, -9.99083370e-03f, 1.21980004e-01f, 2.03369856e-01f, 2.66081300e-02f, 8.42910483e-02f, 2.94882115e-02f, -2.30552971e-01f, -3.89980674e-02f,
  -3.62889841e-02f, 3.70156348e-01f, -1.72520980e-01f, 1.74148425e-01f, 1.88058801e-02f, 2.46554777e-01f, -5.18730059e-02f, 7.49415696e-01f, -1.42420426e-01f, 2.46288460e-02f,
  -9.21465233e-02f, -1.07445441e-01f, 1.20879784e-01f, 1.66111410e-01f, 1.44545600e-01f, 1.10362537e-01f, 1.39636129e-01f, 5.35919443e-02f, -1.69082806e-01f, 3.52177382e-01f,
  4.07350808e-01f, -1.65752634e-01f, 5.93820065e-02f, 1.52481228e-01f, -1.52834039e-02f, 2.70474821e-01f, -8.20917711e-02f, -8.75412375e-02f, 3.70835466e-03f, -6.15544356e-02f,
  1.52910456e-01f, -1.22948118e-01f, 4.57564816e-02f, -6.73477277e-02f, -1.12733215e-01f, 1.79223850e-01f, 7.50408843e-02f, -2.78952792e-02f, -3.11503969e-02f, -9.17613134e-02f,
  -2.15589538e-01f, 8.16710144e-02f, -6.02537356e-02f, -1.42663522e-02f, 2.36085191e-01f, 6.47267625e-02f, -7.69778267e-02f, 6.13074675e-02f, 1.34142891e-01f, -4.06367816e-02f,
  2.00822681e-01f, -1.45948276e-01f, -9.43310931e-02f, -4.19659726e-03f, 1.44577131e-01f, 4.03279774e-02f, 1.03658266e-01f, -4.90010716e-03f, 4.92528409e-01f, 2.01748371e-01f,
  3.80894005e-01f, -1.84948549e-01f, 4.19308662e-01f, 1.10287867e-01f, 1.05136521e-01f, 3.21883470e-01f, 1.55649200e-01f, -2.24908143e-01f, -3.36089581e-01f, 3.06169510e-01f,
  -2.96344399e-03f, 3.40175390e-01f, -3.60380948e-01f, 2.91704327e-01f, -1.09701261e-01f, -8.07207823e-02f, 2.70225525e-01f, -1.21589936e-01f, 1.31733701e-01f, -6.30730391e-02f,
  5.41909598e-02f, -2.75936306e-01f, 8.45323086e-01f, -2.23790780e-01f, 1.85816705e-01f, -2.68240273e-01f, 2.06130490e-01f, -2.33980224e-01f, 7.99525157e-02f, 2.62010366e-01f,
  2.04034030e-01f, -1.63522825e-01f, 1.91031083e-01f, -2.13803840e-03f, 1.32469729e-01f, -1.38727188e-01f, -8.96543637e-02f, -1.65778458e-01f, -6.98150173e-02f, 1.21635534e-02f,
  5.43780103e-02f, -1.08665293e-02f, -1.28277048e-01f, -1.51174307e-01f, 1.96413204e-01f, -1.29055142e-01f, -1.51001096e-01f, -5.79907969e-02f, 4.07331102e-02f, 1.62493140e-01f,
  8.97624791e-02f, 6.73030168e-02f, 1.54704988e-01f, -1.46790966e-01f, 3.86623554e-02f, -1.52103007e-01f, 8.23731050e-02f, 1.65326312e-01f, -1.74334243e-01f, 5.10770120e-02f,
  3.05276811e-02f, -1.22121699e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  2.42745373e-02f, -1.82216112e-02f, 7.43084699e-02f, 8.11007991e-02f, 2.15441659e-02f, -7.17239454e-02f, -9.40767378e-02f, 2.03289509e-01f, 4.32442576e-01f, 8.80418941e-02f,
  3.93609464e-01f, 1.47613391e-01f, -1.06426418e-01f, -1.99128672e-01f, 8.00854713e-02f, 2.91333824e-01f, -1.65625244e-01f, 1.10208191e-01f, 1.81831308e-02f, -2.27837190e-02f,
  1.00437969e-01f, -4.62117679e-02f, 9.75041389e-02f, 8.24526176e-02f, 2.17487782e-01f, 1.13521129e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  2.69956350e-01f, 1.25055894e-01f, 3.36682908e-02f, 4.94993389e-01f, 4.97099847e-01f, -4.89698239e-02f, 1.31142527e-01f, -8.03077444e-02f, 2.87842512e-01f, -2.73635350e-02f,
  6.53904527e-02f, 1.76800489e-01f, 3.71857584e-01f, 3.76818061e-01f, 6.36852533e-02f, -2.12501958e-02f, 3.92335325e-01f, -3.57691079e-01f, -5.85163273e-02f, -1.93686590e-01f,
  6.60694763e-02f, 4.99711819e-02f, 1.18041873e-01f, 4.70711172e-01f, -1.03188850e-01f, 1.69055797e-02f, -1.02658108e-01f, 1.51692390e-01f, -3.48103017e-01f, 8.56701508e-02f,
  -4.52873617e-01f, 2.01733261e-01f, 7.51283616e-02f, -1.51292741e-01f, -1.42616168e-01f, 6.32819474e-01f, -6.54283941e-01f, -4.89467457e-02f, -1.80738658e-01f, -9.19475406e-02f,
  1.31594971e-01f, -1.57026574e-01f, 6.64342567e-02f, 1.47025529e-02f, 1.55940592e-01f, 4.94113684e-01f, -3.12248379e-01f, -2.19164222e-01f, -5.76583371e-02f, -2.10948318e-01f,
  1.72988042e-01f, -4.81881835e-02f, -1.34714752e-01f, 1.79197505e-01f, 3.29830915e-01f, -5.67081850e-03f, -7.81133249e-02f, -9.90699008e-02f, -1.51296437e-01f, 4.27455395e-01f,
  -2.97182649e-01f, 2.52952814e-01f, 7.36869812e-01f, 1.03875495e-01f, -2.11441904e-01f, -4.67162699e-01f, -5.84757030e-01f, -2.01858565e-01f, -4.40075845e-02f, 2.70288661e-02f,
  -9.63679478e-02f, 2.35565722e-01f, -9.39157307e-02f, -6.41561896e-02f, 3.72423753e-02f, -1.91092595e-01f, 1.38594564e-02f, 1.76384240e-01f, -2.71257609e-01f, -2.17030570e-01f,
  -1.34763435e-01f, -2.62338430e-01f, 7.28806108e-02f, 4.13918614e-01f, -9.79588181e-02f, -1.15475141e-01f, 8.39309618e-02f, -5.52824020e-01f, -6.41819611e-02f, -1.67248815e-01f,
  4.57207024e-01f, -5.06530926e-02f, 2.28561684e-01f, -1.13299638e-01f, 3.88947815e-01f, -1.53301740e-02f, -5.70279598e-01f, -7.36838043e-01f, -2.86483109e-01f, 1.69320628e-02f,
  2.03983989e-02f, -3.85102779e-02f, 2.21447662e-01f, -1.66229889e-01f, -1.38281062e-01f, 2.53483087e-01f, 3.83718163e-01f, 4.63792473e-01f, 1.55004561e-01f, -6.41199112e-01f,
  4.28930163e-01f, 3.67594838e-01f, -1.23324804e-01f, 5.15755951e-01f, -1.09334610e-01f, 1.25317991e-01f, 1.02458615e-02f, -4.19084787e-01f, -7.42394775e-02f, -8.17501694e-02f,
  2.55578876e-01f, -1.07290424e-01f, -3.37764233e-01f, 1.57489236e-02f, -4.70686667e-02f, 1.23236425e-01f, -3.63625735e-01f, 1.64786905e-01f, 2.85675496e-01f, 3.40789974e-01f,
  4.87376638e-02f, -3.23455483e-01f, 1.07828319e+00f, 2.91379124e-01f, 2.61822641e-01f, 1.30122691e-01f, -1.50220901e-01f, 1.90952539e-01f, -2.34009862e-01f, -8.21212772e-03f,
  -3.21644247e-01f, -9.96451452e-02f, 3.63677830e-01f, 1.50018215e-01f, 3.55604202e-01f, 3.56624991e-01f, 1.54248819e-01f, -1.35139860e-02f, -3.41295339e-02f, -2.34546587e-01f,
  4.59710602e-03f, 3.06482345e-01f, -2.22765207e-02f, -2.11764544e-01f, 8.77068937e-02f, -2.78927505e-01f, 1.89545572e-01f, -1.51101962e-01f, -3.45799506e-01f, 2.82797851e-02f,
  6.91161692e-01f, 5.59942901e-01f, 5.95096827e-01f, -4.72568959e-01f, -7.18621373e-01f, -3.02513093e-01f, 2.23201402e-02f, -1.48988977e-01f, -1.78485811e-02f, -2.02690691e-01f,
  -2.79428810e-01f, -2.73470998e-01f, 1.36155244e-02f, 2.71269053e-01f, 2.92493075e-01f, -1.08372513e-02f, 5.74271083e-02f, -1.45479618e-02f, -3.08319777e-01f, -3.44637662e-01f,
  3.11581612e-01f, 8.27069208e-02f, -1.66079685e-01f, 4.28241730e-01f, 1.02296375e-01f, 5.97879626e-02f, -1.16864797e-02f, 1.51345149e-01f, -2.33437523e-01f, 1.18431956e-01f,
  7.35501766e-01f, 1.65318385e-01f, -3.57816368e-01f, -2.64663339e-01f, 3.55165184e-01f, -5.90930820e-01f, -7.11870909e-01f, 1.69207066e-01f, -2.91851699e-01f, -2.12902188e-01f,
  -1.64946541e-01f, -9.96275842e-02f, -1.08758286e-01f, -3.17019671e-01f, -1.87803969e-01f, -2.03015491e-01f, -2.85108358e-01f, -6.79810196e-02f, -4.87345308e-01f, -2.95199424e-01f,
  -1.84614122e-01f, -1.07872076e-01f, 6.38810873e-01f, -3.65619510e-01f, -1.61027357e-01f, 4.88338582e-02f, -1.15189761e-01f, 1.48363337e-01f, 2.65572518e-01f, -1.47419572e-01f,
  6.93423867e-01f, -1.02782985e-02f, 3.27664882e-01f, -6.54626042e-02f, -4.91539627e-01f, 3.23047280e-01f, -1.62037924e-01f, 3.94843757e-01f, -1.55250743e-01f, 1.12763107e-01f,
  7.57005513e-02f, 3.31747681e-01f, -1.96403563e-01f, 7.49848336e-02f, 3.80124360e-01f, -4.13001105e-02f, 2.64410406e-01f, 7.69416168e-02f, -2.56826073e-01f, 8.25039074e-02f,
  -3.26936245e-01f, -1.87051803e-01f, 3.47779006e-01f, 1.08580709e-01f, -5.00257947e-02f, 4.82215047e-01f, 1.18730739e-01f, 4.66921419e-01f, -3.05900484e-01f, -1.22025594e-01f,
  -2.81489819e-01f, 6.73843175e-03f, -3.78380060e-01f, 2.03212380e-01f, -1.62967205e-01f, 1.32336870e-01f, 1.45184010e-01f, 2.89195627e-01f, -1.11741155e-01f, 7.20067084e-01f,
  2.30459496e-01f, 1.10458508e-01f, -2.83527762e-01f, 3.97395808e-03f, 2.22129732e-01f, 5.43324910e-02f, 3.26271176e-01f, -1.94021031e-01f, 5.36492839e-02f, 3.69729549e-01f,
  -1.46586105e-01f, -3.49299639e-01f, 6.17822587e-01f, -1.52224272e-01f, 9.97619107e-02f, -4.88492697e-02f, -2.18653709e-01f, 5.02488613e-01f, -2.10405048e-02f, -7.52052486e-01f,
  7.13072792e-02f, -7.39781335e-02f, 7.53517821e-02f, -1.38657197e-01f, -7.61548802e-02f, 7.98949748e-02f, -8.57833475e-02f, -1.72704920e-01f, 4.59814191e-01f, -7.51181915e-02f,
  -1.38679385e-01f, 5.89681923e-01f, -3.34178925e-01f, 2.60465473e-01f, -2.83161014e-01f, 3.60685796e-01f, 3.87924165e-02f, -5.25320284e-02f, -4.08757664e-02f, -7.87330866e-02f,
  -2.35166490e-01f, -1.60845309e-01f, -3.67268085e-01f, -1.49520785e-01f, -6.02612972e-01f, -2.69264311e-01f, 2.37372354e-01f, 1.32921994e-01f, -1.52994648e-01f, -1.63057651e-02f,
  1.88863687e-02f, 4.09381449e-01f, -2.54480809e-01f, 1.06034443e-01f, 2.13021457e-01f, -2.15056553e-01f, 3.17725211e-01f, 2.62862772e-01f, 2.70824313e-01f, -9.86555740e-02f,
  6.36262000e-02f, -5.14610410e-01f, -9.69145149e-02f, -4.79736239e-01f, 5.30272067e-01f, 3.51513065e-02f, 2.09547430e-01f, -3.52896631e-01f, 2.09937274e-01f, -1.23078018e-01f,
  7.34940842e-02f, 1.58082560e-01f, 1.53730094e-01f, -4.17957865e-02f, 3.43389481e-01f, 4.77063596e-01f, 6.40270531e-01f, -4.62686736e-03f, -1.08458638e-01f, 2.03648377e-02f,
  -9.02159810e-02f, 2.96097994e-02f, -2.61827976e-01f, -1.73300907e-01f, 4.67610806e-01f, 1.04770057e-01f, -2.10335478e-01f, -1.00673258e-01f, -2.64767468e-01f, 8.73245597e-02f,
  -5.07131338e-01f, 2.05953538e-01f, -4.67718154e-01f, 6.42151654e-01f, 4.70907688e-01f, -5.75767517e-01f, -3.32922861e-02f, 1.75971203e-02f, 1.30459100e-01f, -3.55267495e-01f,
  -1.61185250e-01f, -2.48548970e-01f, -2.94740945e-01f, -4.59228121e-02f, -8.74080881e-02f, -3.66338104e-01f, 4.49439496e-01f, 2.62403134e-02f, -4.10415947e-01f, 7.19835460e-01f,
  -1.96122341e-02f, -1.66298091e-01f, 4.10347909e-01f, -3.55555177e-01f, -2.48318031e-01f, -2.88300902e-01f, 1.83993250e-01f, -1.33466050e-01f, 2.44487941e-01f, -5.42412177e-02f,
  2.97329217e-01f, -1.19333878e-01f, -4.81255621e-01f, -1.32093742e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.59685194e-01f, -3.19854110e-01f, -1.59698948e-01f, -3.01409632e-01f, 3.19350243e-01f, 3.75207961e-01f, 3.01750060e-02f, -1.54279679e-01f, 1.72503870e-02f, -7.87376463e-02f,
  -2.04606593e-01f, 3.46424490e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    