/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.46339220e-01f, 5.37063360e-01f, 1.27996340e-01f, -2.07014963e-01f, 8.06967318e-02f, 3.26977931e-02f, 1.96223229e-01f, -1.11462891e-01f, -2.11221412e-01f, 1.94845214e-01f,
  2.17358395e-01f, 4.98967655e-02f, -4.43938421e-04f, -3.77176399e-03f, 1.02470621e-01f, 5.48675321e-02f, 2.29783967e-01f, 1.54916486e-02f, -2.06323043e-01f, -9.33382884e-02f,
  7.44188800e-02f, -1.20817848e-01f, -1.63379356e-01f, -1.45336762e-01f, 1.55436015e-02f, -1.91318065e-01f, 1.28751481e-02f, 1.07031211e-01f, 1.76555023e-01f, 5.64839065e-01f,
  1.85968205e-01f, 2.22594619e-01f, -7.08312169e-02f, 6.61641583e-02f, 1.79046877e-02f, -5.76845855e-02f, 3.57618332e-02f, -2.26925723e-02f, -7.29070231e-02f, -8.28372687e-03f,
  3.83593142e-02f, -4.35005538e-02f, -7.88738485e-03f, 4.70041595e-02f, -2.73595061e-02f, 3.45498100e-02f, 7.13169202e-02f, 5.71483225e-02f, 3.25921103e-02f, 3.75007018e-02f,
  1.55314431e-01f, 1.28221348e-01f, 5.55692129e-02f, 5.49834482e-02f, 7.79212359e-03f, 5.17823808e-02f, 9.92878079e-02f, 7.71287456e-02f, 9.18189809e-02f, 5.32830991e-02f,
  -1.35678751e-02f, 4.20341715e-02f, 2.38309689e-02f, 2.44804774e-03f, -2.43453309e-02f, -5.26075810e-02f, -1.73660442e-02f, 1.07282465e-02f, -1.36200078e-02f, -3.08857230e-03f,
  -1.38679370e-02f, -2.73263478e-03f, -4.85413708e-02f, -6.06799051e-02f, 1.45961642e-02f, 7.49292597e-02f, -3.90190147e-02f, 3.03257033e-02f, 2.40227412e-02f, 4.08965908e-03f,
  1.26331626e-02f, -1.74365286e-02f, -3.85624380e-03f, -4.38283430e-03f, 8.29380006e-02f, -1.87563971e-02f, 5.43834530e-02f, 4.84227538e-02f, -2.17676256e-02f, 3.36689688e-02f,
  -3.58947515e-01f, 1.73995301e-01f, -5.30187488e-02f, 4.48977835e-02f, -2.54397355e-02f, -8.15577954e-02f, 5.11913113e-02f, 2.61677243e-03f, -1.67464539e-02f, 3.39071713e-02f,
  1.13768905e-01f, -5.04692420e-02f, 2.12747715e-02f, 1.23620443e-01f, -6.64751977e-02f, -3.92212626e-03f, 1.20550208e-02f, -9.96928439e-02f, 5.65848313e-02f, 3.37369926e-02f,
  -3.45783569e-02f, -1.21238269e-01f, -7.28777498e-02f, -2.79417355e-02f, 2.10661665e-02f, -9.19238627e-02f, -3.64946714e-03f, -1.29869074e-01f, -1.20643660e-01f, -2.53773302e-01f,
  -5.52239537e-01f, -4.50601161e-01f, 3.57962817e-01f, -2.02532247e-01f, 5.98509237e-03f, 2.66577780e-01f, 1.68706477e-01f, 5.92746362e-02f, -7.86388442e-02f, -1.28859714e-01f,
  -8.16887170e-02f, 5.57175651e-03f, -1.59445360e-01f, -3.08400691e-02f, 3.14590558e-02f, 5.61486967e-02f, -1.01227835e-01f, 1.96898863e-01f, 5.67233086e-01f, 3.66048634e-01f,
  1.01567306e-01f, -4.87821959e-02f, -1.67097792e-01f, -7.96745121e-02f, 9.38101634e-02f, 9.19762179e-02f, -4.14709300e-02f, -1.58704042e-01f, 4.54064133e-03f, -2.14611903e-01f,
  2.70878911e-01f, -2.13450760e-01f, 2.19044775e-01f, -6.31906092e-02f, 2.85365228e-02f, 9.35464911e-03f, 1.30530491e-01f, -4.90114391e-02f, 7.26930983e-03f, -3.26921545e-05f,
  -9.92831402e-03f, -6.31039441e-02f, 3.84860337e-02f, -2.07298528e-03f, -7.27296248e-02f, 1.91776864e-02f, -3.90560701e-02f, -4.03325632e-02f, -8.12525228e-02f, 3.68262790e-02f,
  -8.55853632e-02f, -1.04063451e-01f, 3.84108350e-02f, -7.30436146e-02f, -3.79561447e-02f, 5.11489585e-02f, -1.35199325e-02f, 3.43180634e-02f, -1.25390254e-02f, -7.55755231e-02f,
  -3.49676888e-03f, -1.10716168e-02f, 4.46542762e-02f, -7.03617036e-02f, 4.46460918e-02f, 2.24728100e-02f, 1.54681932e-02f, 1.10934321e-02f, -4.21843082e-02f, 5.02685681e-02f,
  -7.29467114e-03f, 5.36010824e-02f, -2.80813891e-02f, -2.65543326e-03f, -1.48053132e-02f, 7.33834729e-02f, -3.69590633e-02f, 5.75056532e-03f, 7.52846338e-03f, 1.69262849e-03f,
  2.44335961e-02f, 6.02438599e-02f, -4.13981341e-02f, 7.56583735e-03f, -6.32171053e-03f, -4.29262258e-02f, 8.63641426e-02f, -1.30801443e-02f, -4.21854593e-02f, 4.70787883e-02f,
  3.96007337e-02f, 9.51091293e-03f, 3.54952477e-02f, 8.31796750e-02f, 7.15004280e-02f, 3.27931829e-02f, -3.34939249e-02f, -8.23001191e-03f, -1.03558093e-01f, 6.62540123e-02f,
  1.16429649e-01f, 3.04337707e-03f, -4.39418666e-02f, -4.38239053e-03f, 3.33942287e-02f, 4.39704284e-02f, -4.11942452e-02f, 9.53427628e-02f, 2.36246232e-02f, 5.48936566e-03f,
  -3.31316404e-02f, 1.42344862e-01f, 1.91088200e-01f, 1.48312636e-02f, 1.16727747e-01f, 9.96033847e-02f, 2.63882160e-01f, 3.01382124e-01f, 1.73240170e-01f, 1.91787153e-01f,
  1.71755612e-01f, -6.17880598e-02f, 1.89432308e-01f, 4.16399315e-02f, -2.28525147e-01f, -2.31129661e-01f, 2.19111256e-02f, -9.66017470e-02f, -3.27405967e-02f, 2.06925347e-02f,
  8.91388301e-03f, -4.24320213e-02f, -7.93449134e-02f, -1.06790401e-01f, -1.51587993e-01f, 7.23240450e-02f, -9.65805501e-02f, -6.24453202e-02f, -1.52180955e-01f, -1.52524650e-01f,
  -2.78816909e-01f, 1.64658859e-01f, 4.29639556e-02f, -1.50009975e-01f, 2.25103110e-01f, 7.06795678e-02f, 2.97447801e-01f, 2.04172626e-01f, -5.54110855e-03f, 1.75731361e-01f,
  1.26439095e-01f, 1.02542467e-01f, -1.01815939e-01f, -1.95363119e-01f, 3.39447893e-02f, 4.47606556e-02f, 1.69663951e-02f, 8.29917118e-02f, -1.16085522e-01f, -8.05465803e-02f,
  -8.18195492e-02f, -5.67125455e-02f, -1.15649793e-02f, -1.13253228e-01f, -7.60780796e-02f, -1.33759171e-01f, -8.82334560e-02f, 1.78866610e-02f, -8.86402950e-02f, -4.47231531e-02f,
  -1.54826730e-01f, -1.67290196e-01f, -2.56505068e-02f, -1.59496993e-01f, -1.53985471e-01f, -1.26962319e-01f, -1.55774830e-02f, -4.05589417e-02f, -1.68523952e-01f, 1.60858110e-01f,
  4.62502167e-02f, -4.13869973e-03f, -3.97140160e-02f, 3.38087007e-02f, -1.43016437e-02f, 8.61125216e-02f, -4.25839536e-02f, 3.45019810e-02f, 7.40071526e-03f, 3.91829722e-02f,
  -3.03653665e-02f, 7.47070555e-03f, -2.18470283e-02f, -1.48960603e-02f, 4.46378998e-02f, 3.02389916e-02f, -6.53350875e-02f, -4.14476208e-02f, 1.78246684e-02f, 7.55408825e-03f,
  -1.89978222e-03f, -2.86639556e-02f, -1.45770553e-02f, -7.07073808e-02f, -3.13077308e-02f, -1.51201757e-02f, 5.42246643e-03f, -1.29563391e-01f, 8.65785312e-03f, 4.36580069e-02f,
  -4.67278697e-02f, -2.00276822e-01f, 2.31715709e-01f, 4.53362614e-02f, -4.47368622e-02f, 3.68235167e-03f, -5.47786988e-03f, -1.10719323e-01f, -6.10718057e-02f, -5.25493957e-02f,
  -1.08221047e-01f, -2.65528653e-02f, -7.30320672e-03f, -7.66401216e-02f, -6.64703920e-02f, -5.84044345e-02f, -1.16873123e-01f, -8.39416906e-02f, -1.16091870e-01f, 8.71575847e-02f,
  -9.46841314e-02f, -7.22192600e-02f, -7.78654888e-02f, -6.81262910e-02f, 1.64741110e-02f, 2.20464338e-02f, 3.17867585e-02f, 1.18297249e-01f, -5.68339974e-02f, 2.31561750e-01f,
  -4.59237635e-01f, 1.19486488e-01f, -4.15308446e-01f, 9.27667916e-02f, 8.03927109e-02f, 1.07898675e-01f, -3.16959545e-02f, 1.41863465e-01f, 7.80794844e-02f, -1.39656812e-01f,
  -6.05901070e-02f, 2.93649733e-01f, 7.40256906e-02f, 1.77622974e-01f, -6.22312389e-02f, -1.02513386e-02f, -1.02566220e-01f, -8.62841681e-02f, 2.12883592e-01f, 3.84924322e-01f,
  4.03238505e-01f, -8.42668712e-02f, -1.75469175e-01f, 5.14708050e-02f, -1.95056014e-02f, 3.23223919e-01f, -3.70415956e-01f, -1.15976900e-01f, 1.14037573e-01f, -1.66843578e-01f,
  -1.28252849e-01f, -1.65313303e-01f, 1.54397279e-01f, 2.25253180e-02f, -8.79019033e-03f, 2.27293745e-02f, 6.32878840e-02f, 3.64212203e-03f, 1.75718516e-02f, -2.37294193e-02f,
  -1.20821409e-01f, -4.31274287e-02f, 4.39954735e-02f, 2.23653670e-02f, -3.55695859e-02f, -9.86204445e-02f, -1.60670996e-01f, -1.67067513e-01f, -2.08049580e-01f, -6.85708746e-02f,
  2.38210574e-01f, -5.92142250e-03f, -2.16967434e-01f, 1.05774142e-01f, -2.74948440e-02f, 6.95335269e-02f, 1.56348594e-03f, -2.87903287e-02f, -7.96724036e-02f, -7.96212852e-02f,
  3.85810509e-02f, 2.15835720e-02f, -5.79771586e-03f, 2.56959423e-02f, -3.87676284e-02f, 1.83826629e-02f, 9.88376979e-03f, -4.81574759e-02f, 1.03986777e-01f, -1.81224048e-02f,
  5.31727001e-02f, -2.95302421e-02f, -6.61871443e-03f, -3.06172692e-03f, 1.10029861e-01f, -5.28931580e-02f, 9.85922664e-03f, 1.50196776e-02f, -6.16548490e-03f, -6.13749847e-02f,
  1.26522062e-02f, -2.95403898e-02f, -1.99801549e-02f, 2.98454612e-02f, 1.48108676e-02f, 2.96116043e-02f, 2.11685076e-02f, 1.87964439e-02f, 7.11674541e-02f, -7.56147429e-02f,
  1.26119688e-01f, -5.90715483e-02f, 9.73910559e-03f, -1.46651156e-02f, -1.31983474e-01f, -7.36933425e-02f, 4.67255712e-03f, -2.05147937e-02f, 5.40822260e-02f, -7.38630295e-02f,
  -1.40265031e-02f, 2.76378747e-02f, -2.92256642e-02f, -7.68881524e-03f, 1.52874812e-01f, 7.04744365e-03f, -2.03101852e-04f, 1.20829046e-01f, -4.37490456e-03f, -7.15039223e-02f,
  -3.77902687e-02f, 5.64186685e-02f, 1.75700992e-01f, 5.02264639e-03f, 1.11490257e-01f, 2.33359739e-01f, 5.23458943e-02f, 1.00644836e-02f, -3.10750380e-02f, 7.39174113e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.10547256e-01f, -2.95531958e-01f, 8.03537145e-02f, -6.28770143e-02f, -7.30752766e-01f, -4.33693141e-01f, -7.74690509e-01f, -6.06200732e-02f, 9.28587988e-02f, -3.84933621e-01f,
  -1.18851937e-01f, 2.66084880e-01f, 4.37769115e-01f, 3.36776853e-01f, 5.94721794e-01f, -1.08566932e-01f, 1.74997270e-01f, 7.47174561e-01f, 5.15236914e-01f, -3.08923692e-01f,
  -2.22009078e-01f, 2.09511817e-02f, 5.51323593e-01f, 2.66407430e-01f, -3.60172004e-01f, 2.23229378e-02f, -1.00156359e-01f, -2.72423118e-01f, -8.95085633e-02f, -8.80037993e-02f,
  -1.60499290e-02f, 1.48222119e-01f, 1.79263398e-01f, 7.52157494e-02f, -2.15824366e-01f, 1.00346945e-01f, -5.25282808e-02f, 3.65366824e-02f, -5.52546121e-02f, -7.61058275e-03f,
  -3.70840095e-02f, 7.06200525e-02f, 1.87060162e-01f, 2.46973503e-02f, -9.85564813e-02f, -7.58973602e-03f, 4.76705022e-02f, 1.71828389e-01f, 1.51004657e-01f, -1.63763270e-01f,
  -2.65683681e-01f, -2.02876315e-01f, -2.15844184e-01f, 7.79422512e-03f, 1.88026354e-01f, 5.82170449e-02f, -1.20935306e-01f, 3.78661044e-02f, 1.91577345e-01f, -1.56523854e-01f,
  -1.49000157e-02f, -3.71473772e-03f, -2.03676932e-02f, -1.20550491e-01f, 1.08635984e-02f, -9.02616307e-02f, 7.55440965e-02f, -7.67374337e-02f, 1.34984136e-01f, -1.78194493e-02f,
  -7.91683048e-02f, 3.20791230e-02f, 2.47477852e-02f, -7.72657692e-02f, 1.12093255e-01f, -1.93850454e-02f, -3.68663259e-02f, 3.99701670e-02f, 4.81054187e-02f, 1.56076276e-03f,
  8.63768607e-02f, 5.21755032e-02f, 1.01619782e-02f, 6.19849116e-02f, -8.14147368e-02f, 6.66625500e-02f, 2.49543004e-02f, -1.80109292e-02f, -3.85369509e-02f, -7.03418031e-02f,
  -1.61851019e-01f, 2.07276896e-01f, 5.07160649e-02f, 1.59354389e-01f, -1.38117578e-02f, 1.11981472e-02f, 5.38307354e-02f, 1.35577610e-02f, -1.30404579e-02f, -4.77926359e-02f,
  -2.33088955e-02f, 4.76552024e-02f, -4.81397547e-02f, 4.43637487e-04f, 7.13682398e-02f, -1.30509930e-02f, -1.73881017e-02f, 3.97610068e-02f, 4.29137945e-02f, -1.68189690e-01f,
  -1.68356970e-02f, 2.96350848e-02f, -6.68270960e-02f, -1.98005941e-02f, -7.77893662e-02f, 1.68036357e-01f, -1.31029978e-01f, -1.70734957e-01f, 1.43007368e-01f, -3.47480625e-01f,
  -3.15831482e-01f, -2.81795204e-01f, 4.22762632e-01f, 1.29148096e-01f, 5.19263983e-01f, 4.92744923e-01f, 7.47518897e-01f, 3.14172208e-01f, -4.57625985e-02f, -7.52585158e-02f,
  -1.18250661e-01f, -9.40492824e-02f, -7.68656433e-02f, 3.65749672e-02f, 3.93007919e-02f, 3.09113711e-01f, 3.31978261e-01f, 1.10139683e-01f, 4.04901654e-01f, 2.70978421e-01f,
  7.38173276e-02f, -6.56059459e-02f, -2.67169505e-01f, 3.93597782e-02f, 1.72969818e-01f, -1.97882652e-02f, 8.87618884e-02f, -7.67124519e-02f, -1.17767453e-01f, -1.48541912e-01f,
  3.24723981e-02f, -1.16613343e-01f, 3.23717415e-01f, -1.03947975e-01f, -7.39953965e-02f, -6.89247251e-02f, 2.25600787e-02f, -7.61102303e-04f, -7.02802911e-02f, 5.62918633e-02f,
  -7.50333816e-02f, -1.07828587e-01f, -2.79199481e-02f, -2.64580897e-03f, -5.51245213e-02f, -3.86675894e-02f, -1.53651789e-01f, -1.58355292e-02f, 4.51212674e-02f, 1.46744214e-02f,
  -1.65118650e-02f, 1.34737268e-01f, 1.25712350e-01f, 2.02441216e-01f, 6.32961243e-02f, 2.39848010e-02f, 1.05939060e-02f, -9.48221385e-02f, 3.32228765e-02f, -6.69455081e-02f,
  2.91322380e-01f, 6.48195371e-02f, 4.55471650e-02f, -4.43648472e-02f, -8.49585980e-02f, 5.71008772e-02f, -9.10460800e-02f, -3.41170765e-02f, 3.54508460e-02f, 4.64156233e-02f,
  -6.35022074e-02f, 6.95626065e-02f, -3.89258303e-02f, 9.62007865e-02f, -2.68143378e-02f, 1.63184181e-01f, -8.32070708e-02f, -3.37581858e-02f, -1.19771227e-01f, 4.81130332e-02f,
  6.23912737e-02f, -4.22655838e-03f, -5.43168075e-02f, -5.53884022e-02f, -8.19079205e-02f, -7.46966898e-02f, -6.89195618e-02f, -9.58807245e-02f, -6.31407499e-02f, 1.45028830e-01f,
  9.29434747e-02f, 2.84347147e-01f, 1.26904935e-01f, -9.31782201e-02f, -1.11130774e-01f, -1.78444415e-01f, -2.82318089e-02f, 2.66059395e-02f, 1.11599946e-02f, 7.17962831e-02f,
  -1.55789033e-01f, -1.94189535e-03f, -8.16912949e-02f, 2.37130979e-03f, 2.49878429e-02f, -1.75126512e-02f, -1.22550949e-01f, 2.38792777e-01f, 1.72522262e-01f, -4.02285829e-02f,
  1.93875916e-02f, 1.79706722e-01f, 1.46400645e-01f, 2.07763925e-01f, 3.44574526e-02f, 1.43713076e-02f, 1.22665025e-01f, 6.80610761e-02f, 9.11872163e-02f, 8.57968926e-02f,
  8.72690618e-01f, -1.35124857e-02f, 7.40889430e-01f, 2.20395881e-03f, 2.47301474e-01f, 5.02746642e-01f, 7.56250501e-01f, 2.63081819e-01f, -1.27599373e-01f, -1.00241685e-02f,
  -2.33907580e-01f, -4.15716648e-01f, -3.78761977e-01f, -3.99217635e-01f, 1.45336002e-01f, 1.57228500e-01f, 9.00284350e-02f, 1.68388143e-01f, 3.81081432e-01f, 3.00555021e-01f,
  -2.42298260e-01f, 3.66872400e-02f, 2.56144535e-02f, 7.21517205e-02f, -3.90221365e-02f, -6.49650693e-02f, 1.03208795e-01f, -7.41332397e-03f, -1.42768472e-01f, -2.01155022e-01f,
  2.53023375e-02f, 1.99359015e-01f, -2.00092018e-01f, -2.56769836e-01f, -5.22511378e-02f, -6.46469593e-02f, -1.12317301e-01f, -2.96471566e-02f, -1.26924545e-01f, -5.71745336e-02f,
  -1.11284845e-01f, 4.70966026e-02f, 7.86630884e-02f, -6.95002498e-03f, 2.24050414e-02f, -3.61031294e-02f, 3.84514444e-02f, 8.90479684e-02f, -1.45368157e-02f, -3.80946919e-02f,
  -1.02314353e-01f, 8.01997036e-02f, 1.06084414e-01f, 1.13716964e-02f, 7.16251209e-02f, -1.05452299e-01f, 1.86284240e-02f, -6.38201535e-02f, 1.29390717e-01f, 3.01379673e-02f,
  -1.95491165e-01f, 1.98549747e-01f, 1.92426648e-02f, -2.44246516e-02f, 5.76051790e-03f, 2.15516835e-02f, 8.22826475e-02f, 4.22825329e-02f, 6.09183870e-02f, 2.44142748e-02f,
  1.50820492e-02f, 3.26571837e-02f, -4.09884844e-03f, 5.32282740e-02f, -8.97307694e-02f, 4.89564165e-02f, 9.07338783e-02f, -4.71815355e-02f, -6.35015219e-02f, -5.83350584e-02f,
  1.46943018e-01f, 2.56510731e-03f, 1.29331993e-02f, 8.20874572e-02f, -4.87853102e-02f, 1.21256240e-01f, -4.00089771e-02f, -5.26482016e-02f, -7.50859641e-03f, 6.71832934e-02f,
  -7.68119216e-01f, -1.17459312e-01f, -2.39505827e-01f, -8.87661278e-02f, 1.41462252e-01f, -1.05796523e-01f, -1.46040156e-01f, -1.03623055e-01f, -1.04336977e-01f, -1.01588629e-01f,
  8.96917954e-02f, 1.46819443e-01f, 2.87810210e-02f, 1.01753719e-01f, 2.36908421e-01f, -3.64289470e-02f, -7.19122663e-02f, 7.54640996e-02f, -1.67200550e-01f, -5.74236028e-02f,
  -7.45071024e-02f, 9.32898298e-02f, 1.04992479e-01f, 1.36538567e-02f, -9.88033116e-02f, -1.10383973e-01f, -4.44157012e-02f, -1.05255879e-01f, 8.47798958e-02f, -1.07549280e-01f,
  -8.09715509e-01f, -1.70455337e-01f, -6.79135680e-01f, -9.78461206e-01f, -4.15769488e-01f, 9.22618955e-02f, 3.87919962e-01f, 4.11356837e-01f, -1.30055323e-01f, -3.05109769e-01f,
  -6.85962960e-02f, -4.16910164e-02f, -5.03595412e-01f, 1.25333539e-03f, 1.40230507e-01f, -2.64021873e-01f, -4.92740989e-01f, -2.43335873e-01f, 4.47638839e-01f, 6.70278907e-01f,
  1.88866019e-01f, -3.67194295e-01f, -1.72956347e-01f, 3.62556055e-03f, -4.41906482e-01f, -2.95845538e-01f, -7.64493704e-01f, -5.90689421e-01f, -1.69153556e-01f, -7.88926005e-01f,
  -4.79131788e-01f, -2.25445434e-01f, 6.82566985e-02f, 1.05458491e-01f, -3.06875288e-01f, -9.96010825e-02f, 2.84585040e-02f, -1.96748376e-01f, -2.89281398e-01f, -1.46710813e-01f,
  -2.97173828e-01f, 1.53938964e-01f, -3.05901587e-01f, -3.85773778e-02f, -1.44264072e-01f, 1.40303522e-01f, -2.25753278e-01f, 2.94992421e-02f, -3.96443903e-02f, 1.38665333e-01f,
  -5.89954443e-02f, 8.10859650e-02f, -5.81976213e-02f, 2.97642678e-01f, 2.61755675e-01f, -1.77827090e-01f, 4.05942276e-02f, 5.78520596e-02f, 1.56092510e-01f, -2.20443502e-01f,
  9.04966444e-02f, -1.00529559e-01f, 3.49940583e-02f, 3.66260186e-02f, 5.99077977e-02f, -1.13884047e-01f, 6.87056333e-02f, -7.40239099e-02f, 1.22593157e-01f, -7.77077526e-02f,
  -1.93962231e-02f, -3.98440659e-02f, 1.41640455e-01f, -1.22571297e-01f, -2.72174627e-01f, -6.57642558e-02f, -2.19949372e-02f, -1.21880271e-01f, -1.13019787e-01f, -2.10882593e-02f,
  3.73463295e-02f, -1.23852398e-02f, -1.11773342e-01f, 4.65563945e-02f, 2.13888101e-02f, -9.59228054e-02f, -1.24316325e-03f, 1.51798859e-01f, -1.66460332e-02f, 1.84836909e-01f,
  -2.65902668e-01f, 2.26680338e-01f, -4.00089979e-01f, 8.13860297e-02f, -8.83514509e-02f, 2.06996035e-02f, -4.08769518e-01f, 1.88821126e-02f, -1.30006760e-01f, 1.58612728e-01f,
  2.90459961e-01f, 1.61167994e-01f, -1.71342701e-01f, 1.07771024e-01f, 8.97240918e-03f, 1.72131300e-01f, 2.13829800e-02f, -8.37674364e-02f, 1.17873229e-01f, 7.80007914e-02f,
  -1.64041758e-01f, 1.86330378e-01f, 1.07498281e-01f, 1.65420324e-02f, 5.14105000e-02f, -1.47757635e-01f, -1.20412797e-01f, 4.67045866e-02f, 2.92394400e-01f, 4.50580865e-02f,
  -6.71582699e-01f, 1.73985422e-01f, -3.81478101e-01f, -1.05258834e-04f, 2.49327093e-01f, 3.51139218e-01f, 2.58173257e-01f, 1.88294351e-02f, 2.87986044e-02f, 8.10836479e-02f,
  -3.20583344e-01f, 3.80315036e-02f, 2.46706884e-02f, 2.92023778e-01f, 2.07435980e-01f, 3.02546054e-01f, 6.07703388e-01f, 3.27021122e-01f, -1.46644771e-01f, 4.54860516e-02f,
  4.12519902e-01f, -1.65413991e-01f, -3.94530356e-01f, 2.80567799e-02f, 2.60226190e-01f, -4.17496897e-02f, -2.78580993e-01f, -3.39417905e-02f, 3.83843303e-01f, 6.81772053e-01f,
  -1.37504235e-01f, -2.21289933e-01f, -2.04170883e-01f, -3.33891422e-01f, -7.39954710e-02f, -6.11584671e-02f, -2.01108661e-02f, -1.31437123e-01f, -8.03549811e-02f, 9.39448625e-02f,
  7.02673048e-02f, 1.21087648e-01f, 1.18780829e-01f, -4.21487167e-03f, -9.17825028e-02f, -4.93524931e-02f, -7.58821741e-02f, 5.08833043e-02f, -3.31598759e-01f, 3.11584231e-02f,
  5.24601877e-01f, 1.07759655e-01f, -1.36048123e-01f, 8.37869942e-02f, -1.54317796e-01f, 5.57125434e-02f, -2.68013626e-01f, 2.44867280e-02f, -2.31345952e-01f, 1.13186382e-01f,
  -1.33411074e-02f, 6.02493100e-02f, -1.37790320e-02f, 2.18290444e-02f, 1.42061427e-01f, -6.38494417e-02f, 1.37347445e-01f, 1.88247502e-01f, 1.85677201e-01f, -6.48143962e-02f,
  2.92618908e-02f, -4.70221490e-02f, 8.11140686e-02f, -2.23842058e-02f, 6.51555955e-02f, -3.88191198e-03f, 5.56944795e-02f, 9.69867036e-02f, 1.60507429e-02f, -5.98764010e-02f,
  1.71624087e-02f, -1.39739230e-01f, 2.27595642e-02f, 8.89275149e-02f, -3.88315730e-02f, 7.78039619e-02f, -2.83561926e-02f, -8.43339711e-02f, -7.39251375e-02f, 3.90424044e-03f,
  -3.57789129e-01f, -2.89117713e-02f, -5.20679355e-02f, -6.22847043e-02f, 7.33395666e-02f, -1.82716921e-01f, -1.78180225e-02f, -1.72873437e-01f, -2.67550983e-02f, -2.10633174e-01f,
  -2.46631756e-01f, -3.46501581e-02f, -1.17086001e-01f, 6.65709376e-02f, -1.12247542e-01f, -1.59164086e-01f, -4.39360105e-02f, 1.62819251e-01f, 1.35921150e-01f, -1.99935079e-01f,
  -2.74994913e-02f, -1.03830263e-01f, -2.16724038e-01f, -2.75549769e-01f, -8.46184641e-02f, -1.03383474e-01f, -2.42399231e-01f, -3.27969849e-01f, -4.04317051e-01f, -3.61367017e-01f,
  1.00128329e+00f, -4.37421411e-01f, 4.08920765e-01f, 2.62243003e-01f, 2.46927068e-01f, 5.77468276e-01f, 4.18679833e-01f, 2.55822867e-01f, 8.93540308e-02f, 3.76316458e-02f,
  1.21457592e-01f, 9.14060846e-02f, 1.04799442e-01f, -6.93929270e-02f, 2.62299299e-01f, 6.27769977e-02f, 1.02059238e-01f, 1.71967193e-01f, 3.56902272e-01f, 2.45799080e-01f,
  -2.12839976e-01f, -2.33494788e-01f, -4.58192565e-02f, -4.67750132e-02f, -1.70174539e-01f, -2.17951834e-02f, -1.28880724e-01f, -2.34991163e-01f, -1.27097398e-01f, -3.70817482e-01f,
  1.98560759e-01f, 1.55475467e-01f, 2.20973790e-02f, -6.33895099e-02f, -4.97368723e-02f, -9.19841975e-02f, 3.48557718e-02f, -2.40963474e-01f, -1.31836846e-01f, -1.73425689e-01f,
  -2.23450642e-02f, -7.46510401e-02f, 3.52159813e-02f, -2.17426345e-01f, -2.50128843e-02f, -1.04246475e-01f, -9.72053632e-02f, 6.17532097e-02f, 1.85803771e-01f, 9.42177996e-02f,
  -5.52166142e-02f, 6.40602782e-02f, 1.19001009e-01f, 4.69061313e-03f, 1.96636319e-01f, 3.72476950e-02f, -1.10189751e-01f, -8.70399363e-03f, 1.76368766e-02f, -2.96746586e-02f,
  2.18400329e-01f, -2.07123104e-02f, 1.61421284e-01f, 9.82239619e-02f, 7.06847087e-02f, -1.78931236e-01f, 8.05230066e-02f, 6.84425514e-03f, 5.09885661e-02f, -1.18078835e-01f,
  -1.94820687e-01f, 1.24197483e-01f, 4.08346057e-02f, 8.54646116e-02f, -9.39381495e-02f, 6.77045360e-02f, -5.45859849e-03f, -6.79006875e-02f, -4.75008823e-02f, -3.52446698e-02f,
  -1.98504269e-01f, -2.25289706e-02f, 3.81384194e-02f, -4.88562696e-03f, -7.29602352e-02f, 1.07718885e-01f, -3.44816856e-02f, -5.15759401e-02f, 4.18448895e-02f, -2.81430632e-02f,
  -3.73690784e-01f, 3.22129667e-01f, 3.72633804e-03f, -1.16517972e-02f, -9.46787372e-02f, -2.33538121e-01f, 9.79101509e-02f, -1.45945489e-01f, -1.60631925e-01f, -1.00897744e-01f,
  -1.68441951e-01f, 2.72804592e-02f, 3.77228037e-02f, -9.33479071e-02f, -1.07772127e-01f, -2.62042135e-02f, 2.98479311e-02f, 1.05979674e-01f, -1.19476393e-02f, 1.83368586e-02f,
  -1.02499373e-01f, 1.04164794e-01f, 2.27027476e-01f, -6.13684906e-03f, -6.41417969e-03f, 1.14303909e-01f, -5.78034073e-02f, -6.52968660e-02f, 1.20304145e-01f, -1.47739336e-01f,
  1.77986443e-01f, -3.03273380e-01f, -9.23561335e-01f, 1.09939791e-01f, -6.10598743e-01f, -2.56935328e-01f, -7.54253387e-01f, 4.63965058e-01f, 6.18647039e-01f, -5.43578804e-01f,
  -6.22833408e-02f, 1.73142239e-01f, -6.44789040e-02f, -1.54787630e-01f, -1.84954345e-01f, -8.88871372e-01f, -7.92241514e-01f, -5.36141217e-01f, 4.80388887e-02f, -2.63282895e-01f,
  -4.29756999e-01f, -1.46085843e-01f, 1.80299245e-02f, 3.90736252e-01f, 3.49031538e-02f, 2.58201957e-01f, -7.59243295e-02f, -1.66090980e-01f, -3.10726076e-01f, -6.67671025e-01f,
  -9.07071352e-01f, 3.11323404e-01f, 9.21896696e-02f, -8.43883492e-03f, -2.33508229e-01f, 1.00775361e-01f, -7.62036908e-03f, 8.47076103e-02f, 1.65142894e-01f, -1.63602177e-02f,
  4.27877046e-02f, 6.09679893e-02f, 1.37921169e-01f, 1.85235828e-01f, -9.45155695e-02f, -1.08964920e-01f, 1.93435267e-01f, 6.76208269e-03f, 7.09914267e-02f, 4.33080532e-02f,
  -1.72375560e-01f, -1.51090309e-01f, -1.50123209e-01f, 3.15660864e-01f, 3.23049486e-01f, 7.93842226e-02f, 7.22208843e-02f, 2.10755929e-01f, 2.56503493e-01f, 9.55527425e-02f,
  -1.16846487e-01f, 4.23933938e-02f, -5.37046976e-02f, 2.88130492e-02f, -1.87330469e-02f, 7.39899874e-02f, -9.76958051e-02f, 3.21099199e-02f, -3.08997799e-02f, 1.19289331e-01f,
  1.23028271e-01f, -6.94224313e-02f, 8.83136168e-02f, -1.00261636e-01f, -1.24076143e-01f, -4.59391363e-02f, -2.75163166e-02f, -1.21122733e-01f, -8.14829580e-03f, 1.11873686e-01f,
  1.78160090e-02f, 2.26408765e-02f, 4.42144945e-02f, 1.28571074e-02f, -2.09159270e-01f, 4.12332565e-02f, -1.00733817e-01f, 2.63514891e-02f, 2.06977084e-01f, 2.21313965e-02f,
  3.02548081e-01f, 3.07509080e-02f, -1.65929958e-01f, 6.76172078e-02f, 1.15355514e-01f, 5.49109019e-02f, -8.75108838e-02f, 8.22635368e-02f, 1.90279350e-01f, -9.26049054e-02f,
  1.76474731e-02f, -1.10557908e-02f, -8.31298828e-02f, -4.17828746e-03f, -7.71142915e-02f, -5.93149066e-02f, -1.10720009e-01f, -1.72657236e-01f, 4.05409224e-02f, -4.14307751e-02f,
  -3.22722308e-02f, 3.20642628e-02f, -6.63184896e-02f, 9.36143622e-02f, 1.90436855e-01f, -1.07469618e-01f, 5.65938354e-02f, -1.60398651e-02f, -9.05966163e-02f, -3.82260382e-02f,
  -8.94671619e-01f, -3.27658147e-01f, 4.34436321e-01f, -5.61458707e-01f, 1.00224204e-01f, 1.14176236e-02f, -7.31971264e-01f, -2.59977937e-01f, 1.68026045e-01f, -3.27509433e-01f,
  1.35769829e-01f, 2.04544947e-01f, 1.46036856e-02f, 9.67635810e-02f, -5.53689718e-01f, -6.30277872e-01f, -2.31586114e-01f, -4.01992202e-02f, -1.28961280e-02f, 5.26320376e-02f,
  3.18531133e-03f, -1.22607075e-01f, 2.15874221e-02f, 1.26559407e-01f, -2.22526342e-01f, 6.61570281e-02f, 1.85702369e-01f, -1.35816872e-01f, -1.21013343e-01f, -4.47681338e-01f,
  -2.12121546e-01f, -2.22855806e-02f, 1.31853342e-01f, -1.82217807e-01f, 1.69920757e-01f, 3.36871929e-02f, -1.80033207e-01f, -2.90460903e-02f, 6.02939986e-02f, 1.00764520e-01f,
  7.91393816e-02f, 2.15786770e-01f, -3.45963314e-02f, -8.62204581e-02f, -1.71523303e-01f, -2.50808179e-01f, 1.11241691e-01f, -1.36058763e-01f, 8.23354572e-02f, 8.66165310e-02f,
  -2.04763308e-01f, 6.20900989e-02f, -2.77531385e-01f, 1.94463521e-01f, 1.24788461e-02f, 4.09617633e-01f, 9.11464989e-02f, 4.74137217e-02f, 1.12519026e-01f, -4.59581941e-01f,
  -2.47869343e-02f, 1.12284519e-01f, 5.75688407e-02f, 7.36702047e-03f, -6.79208785e-02f, 4.61394060e-03f, 5.63054234e-02f, -8.19724798e-02f, 8.06960315e-02f, -1.32711992e-01f,
  1.76907718e-01f, 8.17975122e-03f, 6.02157488e-02f, -1.14133246e-01f, 3.88536565e-02f, -1.15798585e-01f, -7.40498900e-02f, 2.13714447e-02f, 1.05143555e-01f, -7.04446957e-02f,
  -1.27743959e-01f, 2.86604911e-02f, 5.99442516e-03f, -3.09000593e-02f, 8.74256045e-02f, 6.28060922e-02f, -1.02001078e-01f, -8.35133367e-04f, -5.84230646e-02f, 1.09743901e-01f,
  -4.66420650e-01f, 4.34950858e-01f, -2.46475369e-01f, -2.10196823e-01f, -8.34688991e-02f, 2.09848788e-02f, 7.42081106e-02f, 4.26051319e-02f, 4.51744497e-02f, -1.14570305e-01f,
  2.73422245e-02f, -7.79031664e-02f, -9.88390073e-02f, 3.42549831e-02f, -1.54476687e-01f, 5.21165803e-02f, -1.19090483e-01f, -1.72803551e-01f, -1.71757773e-01f, -2.97171064e-02f,
  -1.32715598e-01f, -3.78990650e-01f, -5.37689447e-01f, -4.20579612e-01f, -2.25913659e-01f, -2.27844566e-01f, -9.53748524e-02f, -3.37747604e-01f, -3.33596617e-01f, -8.40867817e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.66698241e-01f, 1.18499480e-01f, 2.03966886e-01f, 4.46685910e-01f, 1.48682937e-01f, 7.87972093e-01f, 1.34441748e-01f, 2.54390687e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.22121513e-01f, 4.54248153e-02f, -1.73616841e-01f, -1.01873070e-01f, 4.63031262e-01f, -1.81426615e-01f, 3.00390497e-02f, -7.40352750e-01f, 1.12790331e-01f, -1.55271053e-01f,
  1.13947168e-01f, -3.13530505e-01f, -9.75265503e-02f, -1.00499243e-01f, -7.37964511e-02f, 4.40537959e-01f, 1.12106904e-01f, 3.48320678e-02f, 3.98415685e-01f, 3.29136252e-02f,
  3.65488529e-01f, -2.76854128e-01f, 2.54013315e-02f, 1.81441475e-02f, -5.58572888e-01f, 1.38219088e-01f, -1.62524313e-01f, 2.67366558e-01f, 4.93457645e-01f, -2.05469415e-01f,
  -2.44759411e-01f, -1.49740642e-02f, -1.42890930e-01f, 4.02377635e-01f, 9.20428112e-02f, 1.72042802e-01f, -2.81317443e-01f, 1.89840004e-01f, -1.27315357e-01f, 3.70086461e-01f,
  2.60480136e-01f, -2.77873904e-01f, -4.63054776e-02f, 1.83324695e-01f, 1.45471722e-01f, 7.54061565e-02f, 1.20766155e-01f, 6.70664608e-01f, 3.80888656e-02f, 1.97667792e-01f,
  4.60556634e-02f, -8.84344280e-02f, -4.06129770e-02f, -2.71325946e-01f, 6.76846728e-02f, -3.56252521e-01f, 1.43694058e-01f, 1.34373615e-02f, -1.52513772e-01f, -7.05406293e-02f,
  4.33366835e-01f, -3.81020933e-01f, -3.17393661e-01f, 4.66118865e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.11842671e-01f, 7.58815229e-01f, 1.60994485e-01f, 2.59962171e-01f, -5.49706340e-01f, 1.06797837e-01f, -3.34588140e-01f, 1.07539564e-01f, 9.96058047e-01f, -1.45618245e-01f,
  3.06606621e-01f, 2.05115616e-01f, 7.32849389e-02f, 5.61122477e-01f, 7.30790019e-01f, -7.75378803e-03f, -1.04341432e-01f, 3.63176584e-01f, 4.98828106e-02f, 1.58532917e-01f,
  2.17189845e-02f, 3.56493413e-01f, -2.18702972e-01f, -5.43182909e-01f, -7.68393636e-01f, 3.34753782e-01f, 3.76058131e-01f, -1.71929479e-01f, -9.02484730e-02f, 3.26896280e-01f,
  -3.68146092e-01f, 5.03936946e-01f, -3.91153023e-02f, 4.10518855e-01f, -1.75065994e-02f, -2.00913027e-01f, 3.49066138e-01f, 2.89118022e-01f, -4.19689596e-01f, 7.01528966e-01f,
  5.37439823e-01f, 1.88340351e-01f, -3.57223898e-01f, 7.08091378e-01f, 5.71721852e-01f, 2.59409964e-01f, -6.97167069e-02f, 2.38041095e-02f, 3.53501409e-01f, -5.18443465e-01f,
  4.41230655e-01f, 5.97891271e-01f, -5.47795117e-01f, 7.26585746e-01f, 1.82508469e-01f, 9.48815465e-01f, -7.86853850e-01f, -1.59071729e-01f, 2.91753203e-01f, 7.20229983e-01f,
  1.31359547e-01f, -6.02255911e-02f, 2.75576264e-01f, 6.88740890e-03f, 7.85476863e-01f, 8.45576406e-01f, 6.04562223e-01f, 1.22596622e+00f, 1.57276511e-01f, -6.38788760e-01f,
  3.76289487e-01f, 1.73170149e-01f, -2.05852136e-01f, -2.97140151e-01f, -5.93860865e-01f, 3.45358610e-01f, 9.49201509e-02f, -9.67796072e-02f, 6.01326168e-01f, 9.53529298e-01f,
  -4.35437709e-02f, 2.52213597e-01f, 6.51787102e-01f, 1.27425000e-01f, 3.32180053e-01f, -2.07739156e-02f, 1.49339840e-01f, -5.00101089e-01f, 9.76148605e-01f, -1.33974880e-01f,
  9.09434319e-01f, 3.24759454e-01f, 8.70173454e-01f, 3.76462638e-01f, 6.23368174e-02f, -7.77117372e-01f, -5.19561721e-03f, 2.26716504e-01f, 2.44454682e-01f, 1.52935177e-01f,
  -1.60295084e-01f, -2.45846227e-01f, 5.72635904e-02f, -4.14629161e-01f, 5.51751077e-01f, 1.44305751e-01f, 5.73463678e-01f, -6.68012071e-03f, -5.08582771e-01f, 5.33582568e-01f,
  2.15333804e-01f, -1.63337067e-02f, 1.15631536e-01f, 2.27131620e-01f, 3.87420237e-01f, 2.34288886e-01f, -1.46128726e+00f, -3.63376141e-01f, 2.17069939e-01f, 6.67306244e-01f,
  -8.99246708e-02f, 2.03740463e-01f, 1.66955322e-01f, 2.19826296e-01f, -1.07607566e-01f, 2.72450279e-02f, 3.37947696e-01f, -5.06367385e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.49625701e-01f, -6.67328313e-02f, -5.18444702e-02f, 5.94451725e-01f, 9.56373572e-01f, 5.23996890e-01f, 2.23284662e-01f, 3.27548422e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.06900938e-01f, -1.87152654e-01f, -2.80336469e-01f, -4.14232790e-01f, -2.59407789e-01f, -4.24962133e-01f, -3.30800653e-01f, 3.05334419e-01f, 3.87225240e-01f, -4.44992304e-01f,
  3.30953032e-01f, -6.56136721e-02f, -3.08932513e-02f, -6.95743272e-03f, -2.42931858e-01f, -3.44234407e-01f, -2.25576848e-01f, 1.18612535e-01f, -4.15051654e-02f, -5.20493329e-01f,
  7.03338981e-01f, 3.56494673e-02f, -3.93048495e-01f, -1.99218661e-01f, -3.25590879e-01f, 1.90587178e-01f, -4.88346927e-02f, -1.42437443e-01f, -1.11930124e-01f, 5.41783907e-02f,
  3.66640568e-01f, -2.90896535e-01f, -4.76624191e-01f, 1.54953450e-01f, 4.06237245e-01f, 3.88241053e-01f, 2.91099511e-02f, 1.15686432e-01f, 1.42878488e-01f, 7.10794032e-01f,
  -2.48976737e-01f, -3.40595037e-01f, 5.77073216e-01f, -1.11261345e-01f, 6.67900741e-02f, 2.17547312e-01f, -1.31010100e-01f, -8.70297104e-02f, 6.06202334e-02f, 6.56681806e-02f,
  -1.70272470e-01f, 9.98338312e-02f, -3.47557276e-01f, 6.41757548e-01f, 5.76801062e-01f, -5.96299529e-01f, -3.45442921e-01f, 1.37231261e-01f, -2.00618804e-01f, 2.04393491e-01f,
  -2.57596999e-01f, -1.71689852e-03f, 2.30832666e-01f, 4.38007087e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.78737795e-01f, -4.84289140e-01f, -2.64041483e-01f, 6.12518549e-01f, 8.92785370e-01f, 8.91524911e-01f, -3.82403404e-01f, 1.79482475e-01f, -9.43389162e-02f, 8.04957300e-02f,
  2.90644377e-01f, 1.58000320e-01f, 6.98927343e-01f, -2.48404443e-01f, -2.62032002e-01f, -1.01393843e+00f, 2.78893739e-01f, 6.37468874e-01f, 1.11696947e+00f, 2.53560543e-01f,
  6.54282153e-01f, -2.99211204e-01f, -1.25750971e+00f, -1.08292866e+00f, 2.83080161e-01f, 1.01544313e-01f, -1.02220857e+00f, 5.21369517e-01f, -2.00901002e-01f, 6.77021384e-01f,
  3.47854733e-01f, -9.85721126e-02f, 1.91955805e-01f, -1.93264440e-01f, -4.26876873e-01f, -2.45171979e-01f, 1.31242469e-01f, 2.04525553e-04f, -1.32233834e+00f, -6.29781067e-01f,
  7.18758345e-01f, -2.06906065e-01f, 3.06690812e-01f, 2.37309322e-01f, 5.93151808e-01f, -5.24640858e-01f, 1.47070214e-01f, -8.37656081e-01f, -5.69054931e-02f, -2.06132546e-01f,
  -1.14787924e+00f, 3.05826187e-01f, 8.91251117e-02f, -5.16204476e-01f, 1.22612104e-01f, 3.58174257e-02f, 4.27131563e-01f, -2.69605935e-01f, 7.79994488e-01f, -5.10330856e-01f,
  1.94836948e-02f, 5.88991463e-01f, 2.73987472e-01f, -4.46229279e-01f, 4.80279088e-01f, 9.79767501e-01f, 1.33494616e+00f, 8.60404670e-01f, -2.94098526e-01f, 9.14938509e-01f,
  1.11574447e+00f, -4.94671226e-01f, -3.24601233e-01f, -9.39284563e-01f, -4.38741952e-01f, 8.95604372e-01f, 8.07134688e-01f, -4.04070824e-01f, -7.03557968e-01f, 2.24804401e-01f,
  6.11134246e-02f, -4.90848720e-01f, 9.90686655e-01f, 6.94527805e-01f, 6.08329177e-01f, 8.99096966e-01f, 8.99851203e-01f, 1.02100110e+00f, 1.06667116e-01f, -9.81346786e-01f,
  7.23302782e-01f, 1.12572223e-01f, 1.67831600e-01f, 5.72585642e-01f, -6.76622450e-01f, -6.45308912e-01f, -4.05765951e-01f, -9.79717970e-02f, -4.70301896e-01f, -2.74404734e-01f,
  -1.46863067e+00f, -1.37854099e+00f, 6.28753304e-01f, -4.95277464e-01f, 6.73710942e-01f, -6.79711476e-02f, 3.10451627e-01f, 8.41988266e-01f, 3.38034779e-01f, 1.24035522e-01f,
  -5.02557121e-02f, 6.27300262e-01f, 3.12984318e-01f, 1.24681389e+00f, -8.38425636e-01f, 1.13563228e+00f, 6.63297415e-01f, 1.11947395e-01f, 9.74679947e-01f, 8.80977690e-01f,
  6.07792497e-01f, -5.52522898e-01f, -3.05050492e-01f, -7.28658497e-01f, 5.48217952e-01f, 2.30752826e-01f, 4.16261494e-01f, 9.20910984e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  6.49020612e-01f, 5.37600636e-01f, -1.78093568e-03f, 3.75771821e-01f, 7.07741320e-01f, 2.23496661e-01f, -1.58704832e-01f, 7.52267241e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -9.71816421e-01f, 7.26619542e-01f, 1.93708032e-01f, -4.75025773e-01f, 2.90638208e-01f, -4.51862872e-01f, 2.67706484e-01f, 1.66539308e-02f, -2.25975335e-01f, -8.67648542e-01f,
  3.37426901e-01f, -3.93365592e-01f, 9.91908163e-02f, -5.37745953e-01f, 4.87714142e-01f, -4.98399138e-01f, -3.09267431e-01f, -7.17415512e-01f, -1.50585309e-01f, 4.03823674e-01f,
  5.32760024e-01f, 3.24644595e-01f, -3.94089311e-01f, -2.78806150e-01f, -9.79509175e-01f, -7.24261478e-02f, 1.43908024e-01f, 4.82252836e-01f, -1.45491612e+00f, -1.02887034e+00f,
  5.07342935e-01f, 1.07846715e-01f, -2.51678348e-01f, 5.68325579e-01f, 5.39541066e-01f, -4.33075279e-01f, 5.79984546e-01f, -8.20812523e-01f, 5.64563215e-01f, 7.29864240e-02f,
  2.64447600e-01f, -1.03204739e+00f, 3.80300999e-01f, 2.98818290e-01f, -1.55422449e+00f, -5.89375556e-01f, -2.72101045e-01f, 7.87771225e-01f, -6.43804744e-02f, -5.71817935e-01f,
  -7.12094605e-01f, 2.81376183e-01f, 8.36291432e-01f, 5.85587919e-01f, 1.30387866e+00f, 1.19026870e-01f, 7.61930108e-01f, -1.13453496e+00f, 4.45988357e-01f, -4.42887172e-02f,
  -6.24283776e-03f, 5.21116734e-01f, -2.24031061e-01f, -1.02704585e+00f, 8.51558387e-01f, -8.99895310e-01f, -4.78820562e-01f, 1.28937587e-01f, 7.36000910e-02f, 1.38625810e-02f,
  -9.13503289e-01f, -8.39882076e-01f, 5.30386865e-01f, 3.98505121e-01f, 3.68019849e-01f, -2.36875042e-01f, 2.15767920e-01f, -9.58087444e-01f, -2.82197952e-01f, -1.56511843e-01f,
  7.28885591e-01f, -2.68271178e-01f, 5.39242446e-01f, 4.82846320e-01f, -3.25845838e-01f, 5.35532594e-01f, -2.34017044e-01f, 9.70169365e-01f, -1.68008411e+00f, -4.43650693e-01f,
  -2.04882890e-01f, -5.75788021e-01f, 2.47353166e-01f, -3.77537280e-01f, 4.45831478e-01f, 5.07532418e-01f, 9.41936731e-01f, 8.89761567e-01f, -4.01986629e-01f, -3.13751966e-01f,
  1.71699554e-01f, 8.88280094e-01f, 1.17755413e+00f, -1.04935467e+00f, -9.56250906e-01f, 1.69425026e-01f, -8.01740766e-01f, 1.46108851e-01f, -1.28067636e+00f, 2.98633546e-01f,
  -6.36603594e-01f, 4.70192790e-01f, -3.23562145e-01f, -5.50964214e-02f, -5.76189280e-01f, -4.54310387e-01f, 1.36466488e-01f, 2.34683543e-01f, -2.12867036e-01f, -6.91887498e-01f,
  -5.44510633e-02f, -5.63270390e-01f, -9.50088620e-01f, 4.77578670e-01f, -1.13472104e+00f, 6.24951065e-01f, 2.70632356e-01f, -1.56572258e+00f, -6.36215508e-01f, 5.93738139e-01f,
  -4.80296344e-01f, -3.25211078e-01f, -3.86007577e-01f, -6.40789926e-01f, -3.96632284e-01f, 6.92698300e-01f, -3.41021091e-01f, 8.83668959e-01f, -7.93976426e-01f, -7.44503081e-01f,
  -7.54904568e-01f, -6.22600615e-01f, 3.06764901e-01f, -1.03436232e+00f, -2.58857399e-01f, 3.81157994e-02f, 4.27407980e-01f, 2.24002004e-01f, -5.37359238e-01f, -5.65965116e-01f,
  -1.05897985e-01f, -3.35460573e-01f, 5.11095464e-01f, -1.24489498e+00f, -1.09232950e+00f, 7.74100348e-02f, 2.79565781e-01f, 7.21078992e-01f, -8.82369697e-01f, 8.57389808e-01f,
  3.73416960e-01f, -4.87866223e-01f, 6.21838629e-01f, -5.12150191e-02f, -6.38512373e-01f, -1.95337087e-01f, 7.62847424e-01f, 8.19827914e-01f, -2.78437257e-01f, -2.48725176e-01f,
  -5.02125740e-01f, -1.43651712e+00f, 1.14986241e+00f, -7.64586553e-02f, -7.45821223e-02f, -1.54592383e+00f, -9.37812388e-01f, -4.66224611e-01f, 7.62545645e-01f, 8.48256588e-01f,
  -5.09853482e-01f, 6.58408105e-01f, -5.93982756e-01f, 6.97171092e-01f, -5.11982977e-01f, 9.71770465e-01f, -1.74972773e-01f, 1.64345682e-01f, -5.97259104e-01f, -8.04237783e-01f,
  -1.14229047e+00f, -1.71160832e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.88748944e-01f, -4.20488477e-01f, -2.05014378e-01f, -3.01872432e-01f, 2.72652000e-01f, 8.78899843e-02f, 3.35182339e-01f, 1.73956871e-01f, 1.01487435e-01f, -7.16013229e-03f,
  -1.44049272e-01f, 1.08049110e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    