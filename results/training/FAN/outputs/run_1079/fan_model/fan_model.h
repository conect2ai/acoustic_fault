/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.56437159e-01f, -2.13186204e-01f, 4.57955807e-01f, 3.46603468e-02f, -1.85039192e-01f, -1.06210172e-01f, -2.70926952e-01f, -2.66953617e-01f, -8.65747929e-02f, -1.07953791e-02f,
  -5.30190505e-02f, 6.70386925e-02f, 1.46987393e-01f, -6.75739814e-03f, -2.64614504e-02f, -3.49145606e-02f, -2.44057905e-02f, 2.94870764e-01f, 1.08487196e-01f, -1.87821314e-01f,
  -2.66101301e-01f, 2.22316645e-02f, 1.31908834e-01f, 2.11556610e-02f, -6.08825795e-02f, 8.90962556e-02f, 1.70163900e-01f, 2.43961550e-02f, 6.49350733e-02f, 3.19077313e-01f,
  3.02128136e-01f, 1.24419749e-01f, 3.88214625e-02f, -4.38493043e-02f, 9.43600237e-02f, 3.04925777e-02f, -3.15478556e-02f, 1.90736264e-01f, 7.07351193e-02f, 2.44045649e-02f,
  1.61234774e-02f, 2.43737176e-02f, 4.19962257e-02f, 7.38901570e-02f, -1.29308682e-02f, -2.08624471e-02f, 1.49552096e-02f, 1.00047752e-01f, 1.04228310e-01f, 4.28253897e-02f,
  -9.39866081e-02f, 1.33412644e-01f, 2.11087227e-01f, -5.53460456e-02f, 9.89438519e-02f, 8.23264867e-02f, -2.92966887e-03f, 1.30884022e-01f, 2.11013690e-01f, 1.35581568e-01f,
  -2.70749535e-02f, 8.75157118e-02f, 3.79344560e-02f, 5.52712008e-02f, 1.57307848e-04f, 7.02842139e-03f, 6.24669641e-02f, -4.28966759e-03f, -5.05493693e-02f, 5.88818640e-02f,
  4.71910723e-02f, 2.21936628e-02f, 1.51609099e-02f, -1.43644831e-03f, 4.46658395e-02f, 5.79060316e-02f, 1.19556952e-02f, 1.86141562e-02f, -7.00102467e-03f, 4.69372347e-02f,
  4.16794121e-02f, 2.72160564e-02f, 1.01879142e-01f, 2.44350918e-02f, -1.37509033e-03f, 5.41937724e-03f, -3.78912166e-02f, 1.95505358e-02f, 1.59310121e-02f, 1.47980722e-02f,
  -1.36279672e-01f, 3.41839381e-02f, 8.49778205e-02f, 4.48071100e-02f, -5.27957603e-02f, 1.14305364e-02f, 1.05570275e-02f, -1.74643267e-02f, 7.75596648e-02f, 1.16503825e-02f,
  5.30725718e-03f, 2.94718109e-02f, 3.66542749e-02f, 4.17981893e-02f, 5.04060574e-02f, -1.70737561e-02f, -3.26868743e-02f, 2.52212845e-02f, 1.09821493e-02f, -6.81827590e-02f,
  -6.78307861e-02f, -1.38111174e-01f, -1.70632526e-02f, 8.02406520e-02f, 1.57884024e-02f, 7.72032067e-02f, 5.47062270e-02f, -6.96262494e-02f, 6.13674894e-03f, -1.52297407e-01f,
  2.37341672e-01f, 2.89933592e-01f, 1.49225920e-01f, -9.06488672e-03f, -9.69986897e-03f, 9.24962908e-02f, 1.89453498e-01f, -1.03642650e-01f, -1.90252855e-01f, 1.11233726e-01f,
  9.38664153e-02f, -3.26525159e-02f, -1.37486473e-01f, -2.40207724e-02f, 6.88728839e-02f, 2.28769049e-01f, 1.89707711e-01f, 8.41961056e-02f, -2.96034757e-03f, -1.85331479e-02f,
  -9.51901153e-02f, 7.17230141e-02f, -3.86787951e-02f, -4.90624085e-02f, 5.77131193e-03f, -6.32823482e-02f, 6.62359223e-02f, -3.75333987e-02f, 1.10269310e-02f, 1.70422062e-01f,
  -1.73991472e-02f, 6.52502775e-02f, -3.46129090e-02f, 1.64359897e-01f, 4.51937839e-02f, 3.88063975e-02f, 1.49838775e-02f, 7.03237131e-02f, 9.01117027e-02f, 9.23659652e-02f,
  1.78539738e-01f, 3.10670640e-02f, 1.10538609e-01f, 6.18698522e-02f, 2.91998778e-02f, 8.02236274e-02f, 1.25057399e-01f, 6.13485724e-02f, 7.60914460e-02f, 7.98679218e-02f,
  5.66851310e-02f, 1.99642643e-01f, 2.49852732e-01f, 1.06536478e-01f, 6.65963590e-02f, 1.06018625e-01f, 3.63560952e-02f, 9.57928523e-02f, 4.85553816e-02f, 6.32743165e-02f,
  2.68422384e-02f, -1.17219672e-01f, -1.10870354e-01f, 1.61251407e-02f, -1.17002912e-01f, -5.61043993e-02f, -8.28180183e-03f, -1.87930968e-02f, -5.69959842e-02f, -6.58420548e-02f,
  -6.49753660e-02f, -1.16038129e-01f, -5.25685251e-02f, -7.11883307e-02f, -1.08939521e-01f, 4.11925465e-02f, -6.06862642e-02f, -1.04527481e-01f, -3.87855954e-02f, -7.31241181e-02f,
  -3.44870985e-02f, -1.34264782e-01f, -1.10307291e-01f, -5.58201149e-02f, -7.79385865e-02f, 7.45388567e-02f, -1.04235061e-01f, -4.10836264e-02f, -1.03792166e-02f, 7.01482827e-03f,
  -1.14548959e-01f, -4.30466887e-03f, 7.11048469e-02f, 3.12265288e-02f, 1.16400599e-01f, -7.55836442e-02f, 2.40561832e-02f, 3.95239936e-03f, -3.36995758e-02f, 3.28539163e-02f,
  1.44337177e-01f, 6.87452080e-03f, 7.54592521e-03f, -1.19451806e-02f, 7.89037645e-02f, 6.32118657e-02f, 2.96086036e-02f, 1.80321023e-01f, 5.06839342e-02f, 8.40416029e-02f,
  7.39340335e-02f, 1.79627970e-01f, 6.08002804e-02f, 2.06359494e-02f, -2.44434886e-02f, 7.64271468e-02f, 8.44956934e-02f, 4.89375815e-02f, 3.75198498e-02f, 4.49711569e-02f,
  3.18390101e-01f, -6.60871714e-02f, 3.46101373e-01f, 2.06799850e-01f, 2.35604635e-03f, -2.02305540e-01f, -2.92272598e-01f, -1.67135596e-01f, -9.58019644e-02f, -5.64141385e-02f,
  -1.49831548e-01f, -1.60304859e-01f, -3.98628600e-02f, 5.72686875e-03f, 7.91078992e-03f, 7.29328170e-02f, 3.84615570e-01f, 3.68630826e-01f, -1.58135127e-02f, -1.48764938e-01f,
  -3.62780802e-02f, 1.03985041e-01f, 1.41639233e-01f, 9.73638594e-02f, 2.99985111e-02f, 6.97273389e-03f, 4.73913029e-02f, 1.34385347e-01f, -1.37928098e-01f, 2.20007330e-01f,
  1.35366574e-01f, -4.95837666e-02f, 5.20073511e-02f, 3.22449766e-02f, 2.67660730e-02f, 9.10103098e-02f, -5.79130650e-02f, 8.72604847e-02f, -3.25009525e-02f, 7.21911639e-02f,
  5.39513789e-02f, 2.18092613e-02f, -1.16137099e-02f, 3.47925536e-02f, 1.20122992e-02f, -2.77602859e-02f, 3.03682145e-02f, 1.11224897e-01f, 1.09537154e-01f, -2.30753534e-02f,
  2.09120344e-02f, 1.27429932e-01f, 9.01158378e-02f, -9.40178931e-02f, 2.20400412e-02f, 1.14191458e-01f, 5.36188297e-02f, -5.98377809e-02f, -6.02524616e-02f, 9.05089304e-02f,
  -6.12308122e-02f, -8.40053558e-02f, -3.42893191e-02f, -4.75851446e-02f, -8.49664584e-02f, 6.30141124e-02f, 2.81590298e-02f, -6.60726950e-02f, -9.12324488e-02f, 1.23359321e-04f,
  7.10630615e-04f, 7.63212331e-03f, 6.38848916e-03f, -3.08424905e-02f, -9.55997780e-03f, 2.03516521e-02f, 1.23770218e-02f, -2.35271826e-02f, -2.36625262e-02f, 3.37015986e-02f,
  -5.78374378e-02f, 4.49712612e-02f, -2.83239018e-02f, 5.16972207e-02f, 5.18940575e-02f, -4.83385734e-02f, 4.03306969e-02f, -1.29685491e-01f, 1.68875214e-02f, -1.13702929e-02f,
  -6.18394949e-02f, 3.57122160e-02f, 1.25850856e-01f, -8.53506103e-02f, 6.10756241e-02f, 1.80398822e-02f, 6.39819801e-02f, 7.46724606e-02f, -1.11704627e-02f, 1.71019603e-02f,
  -6.08934127e-02f, -8.24273303e-02f, 1.75117366e-02f, -2.57703196e-02f, -6.88405111e-02f, -2.46853065e-02f, 4.38227598e-03f, 5.92724420e-02f, -1.14301825e-02f, -1.45056443e-02f,
  6.63106218e-02f, 5.62781617e-02f, -2.94651906e-03f, -7.45734340e-03f, 6.87627727e-03f, 6.67605475e-02f, -8.46915245e-02f, -1.01696961e-01f, -5.93522675e-02f, 1.70324072e-02f,
  -7.36032277e-02f, 4.09239940e-02f, 8.66114162e-03f, -1.80720106e-01f, 2.13788405e-01f, 1.32456645e-01f, 1.44170057e-02f, 3.66434529e-02f, -8.71148929e-02f, -8.07253048e-02f,
  2.01449901e-01f, 1.05954684e-01f, 2.76999082e-02f, -3.14944200e-02f, -3.47325131e-02f, -1.75488845e-01f, -1.60834014e-01f, -6.13362789e-02f, -1.21602193e-02f, 1.18055463e-01f,
  5.57627343e-02f, -1.06181480e-01f, -1.69015341e-02f, -3.77533808e-02f, -2.82978892e-01f, -1.61426142e-01f, -1.94720730e-01f, -1.16841130e-01f, -1.33231744e-01f, -4.31785434e-01f,
  -1.52860448e-01f, 6.66151941e-02f, 1.08155305e-03f, -5.46727106e-02f, -5.96606992e-02f, -1.14099912e-01f, -8.73111188e-02f, -1.73145816e-01f, -6.95691968e-04f, -1.66278005e-01f,
  4.05416824e-02f, -8.74851719e-02f, 4.12947349e-02f, -1.54420644e-01f, -1.12598106e-01f, -3.23939063e-02f, -1.05228454e-01f, -2.12907240e-01f, -8.20301399e-02f, -1.07310072e-01f,
  -3.49424593e-03f, 6.71592876e-02f, -1.02129050e-01f, 5.94475865e-02f, -1.29734203e-01f, -2.42301058e-02f, -1.10875741e-01f, -2.27228224e-01f, -1.74946100e-01f, -4.48795319e-01f,
  -3.23114693e-02f, 3.59416455e-02f, 6.32020310e-02f, -4.57846671e-02f, 4.91812676e-02f, 9.70744938e-02f, 2.00578086e-02f, 3.32500413e-02f, 1.14742234e-01f, -3.48434411e-02f,
  4.92788292e-02f, 2.90615950e-02f, -4.49397899e-02f, -1.87254674e-03f, 2.47221254e-02f, 4.90553491e-03f, 7.12022036e-02f, -3.93827911e-03f, 1.09819271e-01f, 6.05034977e-02f,
  5.63506372e-02f, 6.14370368e-02f, 3.24394321e-03f, -7.28062242e-02f, 1.02516606e-01f, 4.64955159e-02f, 4.95545343e-02f, 6.81540892e-02f, 1.39326170e-01f, 1.49900734e-01f,
  -2.17524931e-01f, 2.08500147e-01f, -2.56881922e-01f, -1.27197176e-01f, -1.03565641e-01f, 3.50024668e-03f, -5.33940755e-02f, 5.18218353e-02f, 1.66429789e-03f, -3.80924307e-02f,
  1.29321571e-02f, -2.98119038e-02f, -1.19834132e-01f, -1.06602542e-01f, -5.24990708e-02f, -1.23601891e-01f, -1.09251194e-01f, -4.87461612e-02f, -1.16150631e-02f, -1.94484871e-02f,
  -5.28808273e-02f, -2.95648351e-02f, -6.76564127e-02f, -1.38372913e-01f, -9.56389830e-02f, 8.81545339e-03f, -1.43449634e-01f, -1.25878647e-01f, -1.76486671e-01f, -3.67073774e-01f,
  6.23361528e-01f, -3.10159445e-01f, 1.81559518e-01f, 2.35914260e-01f, -6.52265027e-02f, -1.89024471e-02f, -1.37668282e-01f, -2.74094548e-02f, 5.65672144e-02f, -1.30354375e-01f,
  -9.64949355e-02f, 6.51055435e-03f, 3.89416069e-02f, -1.53543159e-01f, -2.82790493e-02f, 2.79497867e-03f, -1.32038188e-03f, 2.46284589e-01f, 2.45691434e-01f, -7.05279633e-02f,
  -2.42947802e-01f, 6.38445700e-03f, 1.24630980e-01f, -3.09388824e-02f, 8.27592388e-02f, -9.23001245e-02f, 1.58592127e-02f, 3.42691541e-02f, -1.35569826e-01f, 1.47534050e-02f,
  1.00043438e-01f, 1.30786687e-01f, 9.90443900e-02f, -1.02626495e-01f, 3.40797715e-02f, 1.32706603e-02f, -2.79672295e-02f, 9.99695882e-02f, -4.69587836e-03f, -9.71465334e-02f,
  2.70090438e-02f, -6.78168982e-02f, -2.22464721e-03f, 2.08232664e-02f, -3.42301168e-02f, 9.66411922e-03f, 2.79756915e-02f, 1.50514662e-01f, 1.05152719e-01f, -9.41118523e-02f,
  -7.03530163e-02f, -2.85603777e-02f, 1.50313094e-01f, -5.72145805e-02f, 6.86457157e-02f, 5.65433986e-02f, -7.08573833e-02f, 2.55321562e-02f, -5.57499900e-02f, 4.91177365e-02f,
  -1.32839903e-01f, -4.07713503e-02f, -5.18620666e-03f, -2.50831284e-02f, -1.50264157e-02f, -1.51540944e-02f, 3.53413634e-02f, 2.31176764e-02f, 2.54425053e-02f, 1.99774187e-02f,
  -3.29758301e-02f, 3.35005336e-02f, 2.90544722e-02f, 5.86926565e-02f, -2.80577205e-02f, 7.46246502e-02f, -7.39180744e-02f, -9.03869048e-02f, 4.78823623e-03f, -4.39089863e-03f,
  3.55851342e-04f, 3.83830480e-02f, 8.95500780e-05f, -1.52857723e-02f, -1.43385958e-02f, -1.21350503e-02f, 5.49102277e-02f, -9.81579721e-02f, 3.93450819e-02f, 5.95596433e-03f,
  -7.53547624e-02f, -9.36555639e-02f, -4.80835028e-02f, 9.73210931e-02f, -5.08387573e-03f, -5.93569241e-02f, 3.39284949e-02f, -1.05094075e-01f, -4.91164550e-02f, 2.04623453e-02f,
  1.39906825e-02f, 3.04675624e-02f, -3.66351977e-02f, -8.29825997e-02f, -5.10324948e-02f, -3.38932127e-02f, -7.35397190e-02f, -1.74804274e-02f, -1.07369460e-01f, 8.47446173e-03f,
  -1.47840485e-01f, -6.92484993e-03f, 7.92508945e-02f, -4.10765149e-02f, 3.66535946e-03f, 3.15013826e-02f, -2.71554268e-03f, 1.07585285e-02f, 2.00546738e-02f, -1.25907585e-01f,
  2.28371900e-02f, 6.57447651e-02f, 2.54479200e-01f, -9.20512900e-02f, 1.21330962e-01f, 1.46695495e-01f, 2.08212987e-01f, 6.47966415e-02f, -2.58342415e-01f, -1.24700114e-01f,
  -3.85155343e-02f, -2.53214508e-01f, -2.26551652e-01f, 3.40633392e-02f, 1.92949951e-01f, 1.52308598e-01f, 1.83741882e-01f, 2.12589920e-01f, 9.77050290e-02f, 1.02871202e-01f,
  -8.96008983e-02f, 4.07581143e-02f, -1.15999486e-02f, -8.50351378e-02f, -1.18424475e-01f, -1.16311002e-03f, 5.82329705e-02f, -7.21583143e-03f, 1.92964494e-01f, 1.97482035e-02f,
  -1.59807131e-01f, 1.13219857e-01f, 3.09291463e-02f, -1.06688179e-02f, 1.46736488e-01f, 7.59879872e-02f, 8.83730352e-02f, 1.11560179e-02f, 1.40993539e-02f, 5.84907159e-02f,
  2.17185961e-03f, 1.27959400e-01f, 8.85684192e-02f, -2.79197656e-03f, 1.14681400e-01f, 5.98148815e-02f, 4.36576344e-02f, 1.88624665e-01f, 8.88104066e-02f, 1.30700067e-01f,
  2.71023493e-02f, 3.11877299e-02f, 1.68311194e-01f, 3.42457704e-02f, 1.93533897e-01f, 1.02814637e-01f, 5.80366924e-02f, 8.72866735e-02f, 1.72084033e-01f, 4.55378406e-02f,
  -1.20813791e-02f, -1.15310751e-01f, -6.79103949e-04f, -6.45596460e-02f, -1.06541231e-01f, -1.36278272e-01f, -1.14197202e-01f, -4.61293310e-02f, -9.16052535e-02f, -7.67244995e-02f,
  -4.06952426e-02f, -8.17001313e-02f, 2.49902382e-02f, -5.72268665e-02f, -1.66661680e-01f, -6.38742298e-02f, -9.66420472e-02f, -5.17200008e-02f, -1.12373419e-01f, -9.89340395e-02f,
  -7.89938420e-02f, -1.12432659e-01f, -2.05330774e-01f, -7.96356648e-02f, -4.02075192e-03f, -3.26454407e-03f, -7.37200230e-02f, -1.08909711e-01f, -1.90771639e-01f, -9.91038159e-02f,
  -4.03629214e-01f, 2.95880497e-01f, -2.93036923e-02f, 1.17619790e-01f, 3.08080874e-02f, 3.03188991e-02f, -3.95492800e-02f, 9.07140970e-02f, 3.76607664e-02f, 6.76385593e-03f,
  1.51528478e-01f, 6.07266203e-02f, 8.44666585e-02f, 5.91914766e-02f, 7.74374381e-02f, 5.69482446e-02f, 2.61925962e-02f, -1.07811451e-01f, 1.17328703e-01f, 9.85880615e-04f,
  2.76469141e-02f, -4.94768433e-02f, -1.91469178e-01f, -1.35198593e-01f, -3.27798426e-02f, -1.28367245e-01f, 4.57080342e-02f, 6.25168160e-02f, 1.20483704e-01f, -1.21921808e-01f,
  -4.39484388e-01f, 4.83900383e-02f, 4.10870537e-02f, -2.34752029e-01f, -1.54443644e-03f, -2.43422966e-02f, -1.78042844e-01f, -7.71226315e-03f, -7.08973929e-02f, -1.43244445e-01f,
  -9.31479875e-03f, -4.81238291e-02f, -9.45643559e-02f, 1.40522793e-01f, 1.02653414e-01f, -6.02077097e-02f, 1.39671668e-01f, 1.21069938e-01f, -5.90032199e-03f, -1.05255857e-01f,
  -3.98805924e-02f, -1.04200289e-01f, 1.35966450e-01f, 2.00808235e-02f, 9.49577689e-02f, 5.57966717e-03f, 2.81565655e-02f, 8.18167478e-02f, 2.02673867e-01f, 2.54954338e-01f,
  -1.92467868e-01f, 2.81317364e-02f, -9.89887789e-02f, -4.97263335e-02f, 8.18840936e-02f, -4.37113903e-02f, -5.66072576e-02f, 2.49758661e-02f, -6.18040487e-02f, -7.30082244e-02f,
  9.25701577e-04f, -5.43728806e-02f, -7.32119530e-02f, 1.93622988e-02f, -8.06663930e-02f, -5.55377826e-02f, 7.52484426e-02f, 9.34713408e-02f, 9.16843787e-02f, -1.66661032e-02f,
  -1.17108664e-02f, -3.89121706e-03f, -9.20662060e-02f, -8.74563754e-02f, 1.56395920e-02f, 4.16828580e-02f, -5.57446443e-02f, -4.63033915e-02f, 1.11738287e-01f, -7.06591532e-02f,
  -7.83140510e-02f, 2.43076645e-02f, -4.90420091e-04f, -1.15876064e-01f, -5.91485351e-02f, -4.74939011e-02f, -4.20803390e-02f, -4.13466431e-02f, -3.61095220e-02f, -4.13912311e-02f,
  -1.46452682e-02f, -6.72035199e-03f, -3.37970071e-02f, 3.03970724e-02f, 2.19009761e-02f, -5.62295951e-02f, 4.62085567e-02f, 3.57744470e-02f, -2.06488371e-02f, 3.29973511e-02f,
  -7.80095160e-02f, 8.61686766e-02f, 8.93959403e-02f, 3.72903347e-02f, 6.11931086e-02f, 4.97769751e-02f, 4.75628190e-02f, 2.84365728e-04f, -4.05739397e-02f, 7.60135129e-02f,
  -3.01081151e-01f, 1.28267363e-01f, -2.16486976e-01f, -7.49822259e-02f, -2.55906284e-02f, 3.78296860e-02f, -2.38814391e-02f, -1.90398172e-02f, -4.07204069e-02f, -1.03735380e-01f,
  2.12209616e-02f, -1.00358620e-01f, -1.39381234e-02f, -2.53424440e-02f, -1.71759769e-01f, -1.07083723e-01f, -1.07352853e-01f, -1.03760600e-01f, 4.48993072e-02f, -2.48658080e-02f,
  -4.96180356e-02f, -2.14033574e-01f, -3.47853601e-01f, -1.95392475e-01f, -8.48798528e-02f, -1.21045671e-01f, -1.90853283e-01f, -1.99999288e-01f, -1.13753036e-01f, -3.40058386e-01f,
  -4.64082837e-01f, -1.95337012e-01f, 1.76313996e-01f, -1.11825839e-01f, 5.16399182e-02f, 2.08818763e-01f, 1.75386399e-01f, 1.44613326e-01f, -5.42596467e-02f, -2.88575552e-02f,
  -2.91540354e-01f, -3.12815532e-02f, -3.22382450e-02f, 6.28313646e-02f, 2.50455856e-01f, 2.16249660e-01f, 1.93689644e-01f, 2.80319452e-01f, 2.54441410e-01f, 1.63282737e-01f,
  -3.61722894e-02f, -3.93147068e-03f, 5.11163585e-02f, 1.02698311e-01f, -5.42525724e-02f, 3.71760018e-02f, -1.03615627e-01f, 2.15224624e-02f, -6.04543760e-02f, -7.48712420e-02f,
  8.97932723e-02f, -4.97435331e-02f, 1.08984090e-01f, -1.03450671e-01f, -7.83615261e-02f, -2.82974611e-03f, -2.89744921e-02f, 2.99233310e-02f, 3.16012762e-02f, -4.14711572e-02f,
  -7.17353076e-02f, -9.09859613e-02f, 4.45844308e-02f, -5.70281520e-02f, -2.46084966e-02f, 4.76895757e-02f, -3.60384770e-02f, 7.02868700e-02f, 1.31822616e-01f, -1.01948204e-02f,
  -1.77142978e-01f, -1.26718953e-01f, 1.33923203e-01f, 2.36495938e-02f, 1.04660884e-01f, -2.60462556e-02f, 3.12584639e-02f, -6.59397244e-02f, 2.43150573e-02f, -2.11530030e-01f,
  -6.66796640e-02f, -2.84538558e-03f, 2.62155496e-02f, -2.02995613e-02f, -1.12953028e-02f, 2.65650172e-02f, 3.89927551e-02f, -8.47151037e-03f, 8.26490447e-02f, 7.51568936e-03f,
  1.47716864e-03f, 6.51954189e-02f, 2.21681781e-02f, 7.98570830e-03f, 5.53298928e-02f, 1.41916394e-01f, 3.74337398e-02f, 2.98773069e-02f, 2.54478361e-02f, 1.17209524e-01f,
  7.07123503e-02f, -1.43013813e-03f, 6.96427450e-02f, 1.62725858e-02f, 8.66441503e-02f, 8.14458579e-02f, 5.56291714e-02f, 7.53767565e-02f, 6.22979812e-02f, -7.93058984e-03f,
  -8.38408619e-02f, 4.87320125e-02f, 4.30263951e-03f, 1.58803072e-02f, 1.21661320e-01f, 2.46717222e-02f, -1.20902717e-01f, 1.93409976e-02f, -1.12623736e-01f, 3.09744235e-02f,
  1.94150911e-04f, -6.34864718e-02f, -1.26772553e-01f, -9.27868206e-03f, -2.59845774e-03f, 5.35094403e-02f, 1.84975620e-02f, 5.62886596e-02f, 2.46726628e-02f, -5.64726144e-02f,
  1.91470608e-02f, 9.39050019e-02f, 3.53720668e-03f, 4.47707959e-02f, -3.04756295e-02f, 4.43544835e-02f, 8.44631642e-02f, 5.82537688e-02f, 1.51325405e-01f, 1.82033051e-02f,
  -3.31008762e-01f, -2.50448257e-01f, -1.02293625e-01f, 2.49568708e-02f, 7.83525184e-02f, -1.07990168e-02f, -1.28442675e-01f, 8.67824256e-03f, -1.73120934e-03f, -1.89048331e-02f,
  8.39450806e-02f, 2.89082736e-01f, 1.46156058e-01f, 2.04328969e-01f, 8.80708918e-02f, 3.24794166e-02f, 1.29656389e-01f, 1.77201271e-01f, 2.70368695e-01f, 2.38002270e-01f,
  1.76687419e-01f, 7.10218251e-02f, -8.75426605e-02f, 3.06311809e-02f, 1.37042284e-01f, 2.63827056e-01f, 1.72111392e-01f, 6.68216646e-02f, 1.59382433e-01f, 1.83758005e-01f,
  2.36224040e-01f, -1.95841208e-01f, 2.49038965e-01f, 6.63015693e-02f, 2.26833820e-01f, 1.72327533e-01f, 7.50037879e-02f, 4.98403981e-02f, 9.96941105e-02f, 1.01698264e-01f,
  2.12428764e-01f, 1.32229507e-01f, 1.78519607e-01f, 2.60261595e-01f, 9.29558277e-02f, 6.05394803e-02f, 1.52117610e-01f, 9.23400447e-02f, 2.30956674e-01f, 1.65257663e-01f,
  3.38164151e-01f, 1.46288723e-01f, 9.93045717e-02f, 1.68558612e-01f, 2.04072610e-01f, 2.11639687e-01f, 2.21758217e-01f, 2.14190006e-01f, 1.12037644e-01f, 2.11910054e-01f,
  1.26401588e-01f, 7.55284652e-02f, -1.37678519e-01f, 2.60459422e-03f, 6.77932613e-03f, 2.83257831e-02f, 7.90319741e-02f, -7.37516582e-03f, 7.22712278e-03f, 9.02201142e-03f,
  1.77201610e-02f, -2.22072583e-02f, 1.55996019e-02f, -3.54612479e-03f, 1.31054059e-01f, 3.97411361e-02f, 4.36306447e-02f, -6.48200139e-02f, -6.60847053e-02f, -6.68611154e-02f,
  -2.94074323e-02f, -6.34671364e-04f, -8.46469924e-02f, 6.53013438e-02f, -7.72819519e-02f, 1.09691270e-01f, 5.43427691e-02f, -3.96953970e-02f, 5.88850938e-02f, -3.10976282e-02f,
  1.17938749e-01f, 1.69863142e-05f, 9.86209661e-02f, 6.73038885e-02f, 4.58927155e-02f, 1.58058293e-03f, 9.44738686e-02f, 4.91499715e-02f, 1.26493528e-01f, 7.42076859e-02f,
  9.41692442e-02f, 5.54543808e-02f, 7.09188133e-02f, 1.02427356e-01f, 1.43688068e-01f, 1.58817433e-02f, -3.62961255e-02f, 1.35374069e-01f, 1.38209060e-01f, 5.30701503e-02f,
  3.90742980e-02f, 1.45758679e-02f, 2.12188158e-02f, 9.73471068e-03f, 1.76279351e-01f, 6.31387234e-02f, 2.21524641e-01f, 1.56416446e-01f, 5.30373119e-02f, -4.29071262e-02f,
  -2.32480943e-01f, -3.57285142e-01f, -3.33425589e-03f, -1.67498693e-01f, 2.78204978e-01f, 2.91194409e-01f, 2.65389774e-03f, 2.54590213e-02f, -5.81188351e-02f, -1.28763720e-01f,
  -8.70517194e-02f, 1.61704421e-01f, -5.65695129e-02f, 1.07227258e-01f, 5.18000461e-02f, -1.38239399e-01f, -9.00792405e-02f, 1.05767347e-01f, 4.39259291e-01f, 2.55698800e-01f,
  4.87469956e-02f, -2.20126987e-01f, -2.03907400e-01f, -2.82319058e-02f, -2.50410974e-01f, 1.80868924e-01f, -2.36589849e-01f, -1.49970517e-01f, -5.74786738e-02f, -1.39153898e-01f,
  -8.50519687e-02f, -1.60494283e-01f, 1.97811171e-01f, 6.31544665e-02f, 1.06883189e-02f, 8.88323132e-03f, 1.25856129e-02f, -4.17373851e-02f, 5.87976165e-02f, 4.17487361e-02f,
  -6.28372729e-02f, 1.71311349e-02f, 1.80040691e-02f, 6.04949892e-02f, -1.15181550e-01f, 3.77912410e-02f, -6.93629608e-02f, -3.48089002e-02f, 2.45904792e-02f, -7.57386982e-02f,
  -5.52166812e-02f, 1.04760125e-01f, 1.29713435e-02f, 2.60090567e-02f, -2.67335325e-02f, 2.11867362e-01f, 1.00072995e-02f, -5.59421489e-03f, 4.89202924e-02f, -1.47835538e-01f,
  9.03134644e-02f, -4.78027202e-03f, 6.67660683e-02f, -4.88250814e-02f, -8.08664933e-02f, -1.38926916e-02f, 7.68562173e-03f, -4.15669307e-02f, 5.19327782e-02f, -1.11345097e-01f,
  -1.45188551e-02f, -4.37282585e-02f, -3.58407944e-02f, -7.98079967e-02f, -6.85793757e-02f, -5.48537858e-02f, -5.08177765e-02f, -9.05306861e-02f, -3.84285264e-02f, -8.24455395e-02f,
  3.49497348e-02f, -1.18974214e-02f, -8.59587416e-02f, 2.92546004e-02f, -2.06817556e-02f, -2.40551531e-02f, -4.34600888e-03f, -1.87938400e-02f, -2.12894510e-02f, 1.68583672e-02f,
  -1.65466607e-01f, 1.45882323e-01f, 6.65859953e-02f, 1.15738705e-01f, 7.49488845e-02f, 8.70291367e-02f, 1.41545916e-02f, 1.14725538e-01f, 2.02436000e-02f, 9.76099521e-02f,
  9.13666934e-02f, 9.13015455e-02f, -1.20338291e-01f, 4.88038622e-02f, 1.53750971e-01f, 7.92231858e-02f, -4.03337367e-02f, 1.11194536e-01f, 1.83223858e-01f, 1.69808250e-02f,
  2.36716885e-02f, 8.88629556e-02f, 7.36019909e-02f, 8.47464278e-02f, 6.14581928e-02f, 3.47208381e-01f, 1.14363410e-01f, 1.00234665e-01f, 2.85854667e-01f, -1.21884286e-01f,
  2.76726186e-01f, 4.69883204e-01f, -2.79690325e-01f, 2.40068763e-01f, 1.90208659e-01f, -2.12286726e-01f, 1.71094656e-03f, 2.00487636e-02f, 4.82934602e-02f, 1.20348342e-01f,
  1.54331222e-01f, -1.11271642e-01f, -1.34852409e-01f, -2.25772336e-01f, -2.80174494e-01f, -3.30414698e-02f, -4.91917804e-02f, -2.61017501e-01f, -4.36874598e-01f, -2.99540550e-01f,
  5.00802882e-02f, 1.60842776e-01f, 2.09520817e-01f, 1.74602363e-02f, 1.14146709e-01f, -3.69173996e-02f, 2.84786969e-01f, 2.20742151e-01f, -7.02629462e-02f, 8.17341357e-02f,
  -1.91366345e-01f, 1.56153023e-01f, -1.22930020e-01f, 1.46934390e-01f, 7.61575671e-03f, 2.50151586e-02f, -1.13056086e-01f, 1.35677569e-02f, 1.58863857e-01f, 3.15793119e-02f,
  1.07148960e-01f, -4.78728628e-03f, 3.75821302e-03f, -3.67776817e-03f, 3.58804502e-02f, -9.84523818e-02f, 7.33801574e-02f, 3.63059924e-03f, -1.35246173e-01f, -4.47784550e-02f,
  8.51619616e-02f, 1.56793952e-01f, 3.12444381e-02f, -1.31643396e-02f, -1.69379577e-01f, 6.49377033e-02f, -4.99829240e-02f, -4.94573116e-02f, 2.91048270e-02f, 7.83153251e-02f,
  -5.06384484e-02f, 6.97785988e-02f, 3.50144804e-02f, 2.95928009e-02f, 6.19461909e-02f, -1.53683554e-02f, 4.44193333e-02f, -7.28790881e-03f, -7.96425808e-03f, -3.79443844e-03f,
  -1.44143058e-02f, -3.16551067e-02f, -7.92330429e-02f, 7.49721304e-02f, 2.38004457e-02f, 4.24368195e-02f, -1.37912437e-01f, 3.11518684e-02f, 1.10049183e-02f, 4.65684570e-02f,
  5.80640547e-02f, -1.30115762e-01f, 9.32733156e-03f, -5.83898239e-02f, -4.87866029e-02f, -7.98681099e-03f, -2.19418779e-02f, -2.80788969e-02f, 4.44304347e-02f, 1.39598742e-01f,
  3.15021165e-02f, -9.99314561e-02f, -3.06241680e-02f, -7.63782412e-02f, 4.98047657e-02f, 2.33160853e-02f, 9.30475295e-02f, 1.00115843e-01f, 7.88794085e-02f, 5.62535366e-03f,
  2.19191760e-02f, -1.45174712e-02f, -3.82211842e-02f, 1.04750944e-02f, -3.59340608e-02f, 4.56799902e-02f, 1.73550069e-01f, -4.22525816e-02f, 2.11695302e-02f, 3.21407914e-02f,
  1.17006935e-01f, -2.08288990e-02f, -2.93611325e-02f, -2.30051437e-03f, 7.04440176e-02f, -4.27106954e-02f, -4.58780415e-02f, -8.45737159e-02f, -6.54081181e-02f, 1.27856374e-01f,
  4.21874404e-01f, -3.35325778e-01f, -1.21210217e-01f, 1.76973999e-01f, -1.31345108e-01f, -1.60163745e-01f, -3.85274321e-01f, 7.83994347e-02f, 1.77740395e-01f, -1.33852348e-01f,
  -1.85808286e-01f, 2.74127454e-01f, 1.63315311e-01f, 1.71780899e-01f, 2.22271964e-01f, -1.19014874e-01f, -2.25768015e-01f, 2.59053916e-01f, 4.68360633e-01f, 1.59487054e-01f,
  1.14266993e-02f, 1.54732823e-01f, 2.66277194e-01f, 2.41029158e-01f, -3.04020673e-01f, 9.51337069e-02f, -1.51495531e-01f, -2.47921675e-01f, -2.71339953e-01f, -4.28035855e-01f,
  -1.69490054e-01f, -1.98941618e-01f, 7.24712163e-02f, 8.17677081e-02f, -5.56979403e-02f, -2.19161641e-02f, -6.49674833e-02f, -5.20401634e-02f, -2.07374506e-02f, -8.25347751e-02f,
  -6.37586340e-02f, -7.15335608e-02f, -2.61701997e-02f, -6.61373287e-02f, -5.13015911e-02f, -1.78106464e-02f, -3.39386165e-02f, 1.20488301e-01f, 1.89011749e-02f, -9.34835076e-02f,
  -2.41909131e-01f, -1.78831786e-01f, -3.81745547e-02f, -1.31533965e-01f, -1.20385446e-01f, 5.73879257e-02f, -1.37680471e-01f, -9.40205082e-02f, -9.81345400e-02f, -8.18582177e-02f,
  8.35325420e-02f, 2.17267517e-02f, -1.98722351e-02f, 3.32272649e-02f, 5.61759016e-03f, 2.67717000e-02f, 4.07208428e-02f, -8.23165290e-03f, 7.24742413e-02f, 2.97164731e-03f,
  4.95583415e-02f, -5.77483047e-03f, 4.78269272e-02f, 1.06058400e-02f, 2.42337994e-02f, -1.97313931e-02f, -4.21749614e-02f, 2.09668223e-02f, -3.08548994e-02f, -5.03763277e-03f,
  -4.17796746e-02f, -2.81923898e-02f, -2.82592028e-02f, 4.33777384e-02f, -1.20603472e-01f, -1.83181781e-02f, -1.57054346e-02f, -1.57911442e-02f, -3.06085702e-02f, -8.93309191e-02f,
  7.50521049e-02f, 7.16063678e-02f, -5.45135885e-02f, -7.60614127e-03f, -1.02929205e-01f, -1.39242206e-02f, -8.89619663e-02f, 2.45624725e-02f, -1.56782597e-01f, -6.69065192e-02f,
  -4.65175398e-02f, 9.23472345e-02f, 2.89817248e-02f, -4.95917797e-02f, -1.61934793e-02f, 8.64601112e-04f, -6.04235791e-02f, 3.24079171e-02f, 4.76721339e-02f, -8.71699080e-02f,
  -4.31597158e-02f, -6.44294638e-03f, 3.94551046e-02f, -3.74749415e-02f, -2.79575889e-03f, -7.36448856e-04f, -1.28865227e-01f, -2.44952068e-02f, 1.15150005e-01f, -1.44576374e-02f,
  -3.40285003e-01f, 1.33305430e-01f, -1.45270333e-01f, -3.97688538e-01f, -2.02491924e-01f, 1.54551223e-01f, 2.76392967e-01f, 9.29691866e-02f, -6.82219639e-02f, -8.70814733e-03f,
  3.73496711e-02f, -8.68034884e-02f, -2.14856908e-01f, -5.39718121e-02f, -1.03942156e-01f, -1.09215155e-01f, -1.83627933e-01f, -1.98593006e-01f, -3.07768464e-01f, -4.79550101e-02f,
  -1.65649548e-01f, -2.25369230e-01f, -2.85473973e-01f, -2.61749953e-01f, -9.13000852e-02f, -2.06591133e-02f, -3.21512446e-02f, -1.25641555e-01f, 8.37655216e-02f, -1.99963510e-01f,
  -7.04733655e-02f, -1.04640372e-01f, -7.53492266e-02f, -7.56102527e-05f, -8.78295377e-02f, -2.81692501e-02f, -6.07549399e-02f, -2.05235288e-01f, -7.13430494e-02f, -1.13060966e-01f,
  -6.76001683e-02f, -1.09153219e-01f, -1.97174996e-01f, -7.25337788e-02f, -7.33683407e-02f, -8.54056180e-02f, -2.06498399e-01f, -2.15949535e-01f, -1.48640126e-01f, -1.11588173e-01f,
  1.62231997e-02f, -1.67055666e-01f, -2.31991187e-02f, 3.22894491e-02f, -5.74748926e-02f, -1.56839773e-01f, -1.29321893e-03f, -8.25143531e-02f, -8.49529058e-02f, -2.74990336e-03f,
  4.80567217e-02f, 4.27034907e-02f, 8.36964883e-03f, -3.37004871e-03f, 3.42751406e-02f, -2.59064510e-02f, 2.29814183e-02f, -4.68818843e-02f, 1.04005858e-02f, 4.04610373e-02f,
  -6.11978630e-03f, 3.26786116e-02f, 3.63593660e-02f, -6.54795915e-02f, -3.55091318e-03f, -9.90804508e-02f, 3.20858322e-02f, 3.36706229e-02f, -5.20016141e-02f, 2.83584241e-02f,
  -4.20319326e-02f, -5.75984865e-02f, -1.01058139e-02f, 3.97047736e-02f, -5.68377301e-02f, 4.49235737e-03f, -8.81742761e-02f, 6.72339574e-02f, -4.52370988e-03f, -1.07123211e-01f,
  -5.08835874e-02f, -9.34775844e-02f, 2.12600213e-02f, -1.29907668e-01f, -1.36245981e-01f, -8.14457983e-02f, -5.22721279e-03f, -1.19944118e-01f, -9.61679891e-02f, -1.46692991e-02f,
  4.34854850e-02f, -6.98284432e-02f, -4.62855808e-02f, -7.45236501e-03f, -1.25211358e-01f, -9.00505036e-02f, -1.03131011e-02f, -1.13736734e-01f, -8.28406364e-02f, -4.81121168e-02f,
  -4.75175853e-04f, 1.09914191e-01f, 3.88941877e-02f, 1.12946667e-02f, -3.36865596e-02f, -2.29817703e-02f, 3.98419835e-02f, 4.78158817e-02f, 5.36955781e-02f, 1.40482739e-01f,
  -4.28419858e-01f, 1.75237060e-01f, 4.91383448e-02f, -2.39715308e-01f, 1.81725964e-01f, 3.65052670e-01f, 5.26386559e-01f, 6.69585448e-03f, -6.48123249e-02f, 4.00606170e-02f,
  9.19388235e-02f, -1.36086687e-01f, -8.06892477e-03f, -3.82915139e-02f, 4.95919175e-02f, 1.27236754e-01f, 7.05469996e-02f, -1.35539234e-01f, -2.87414119e-02f, 4.95786332e-02f,
  1.77312903e-02f, -1.25544325e-01f, -2.97568142e-01f, -2.26642102e-01f, -1.47899508e-01f, 6.74638301e-02f, -2.68552862e-02f, -1.96063723e-02f, 7.38615245e-02f, -7.83650577e-02f,
  1.53159887e-01f, -1.22468501e-01f, 4.40767892e-02f, 1.23537695e-02f, 4.76341806e-02f, -7.33107701e-02f, -1.99478809e-02f, -1.03360146e-01f, -8.05062130e-02f, -1.33072764e-01f,
  -6.98127747e-02f, -2.92018466e-02f, -1.37613595e-01f, -1.16880275e-01f, -5.51235341e-02f, -4.35707085e-02f, -1.22171275e-01f, -2.08967850e-01f, -2.69937944e-02f, 2.72530317e-02f,
  -2.67704502e-02f, -3.07447948e-02f, -2.35063620e-02f, 1.86769273e-02f, 1.84429949e-03f, 7.38131581e-03f, 1.11900032e-01f, -1.17971629e-01f, 9.98397022e-02f, 1.97848547e-02f,
  5.01565225e-02f, 9.40332711e-02f, -2.44603399e-02f, -3.73364463e-02f, -4.10727076e-02f, 9.45097394e-03f, -1.57562103e-02f, 1.01600811e-01f, -6.58712983e-02f, -2.40853801e-02f,
  -2.51364429e-02f, 5.91048822e-02f, -1.34285819e-02f, 8.16931948e-03f, 8.66488181e-03f, -2.61844136e-02f, 9.91369262e-02f, -4.43628207e-02f, 7.00381324e-02f, -2.49054134e-02f,
  5.37569169e-03f, 8.42737220e-03f, -6.17626607e-02f, 4.65922207e-02f, 3.54188569e-02f, 1.25117777e-02f, 3.50906476e-02f, 7.97797143e-02f, -4.09131013e-02f, 5.95951863e-02f,
  4.64892648e-02f, 7.41242096e-02f, 5.23255318e-02f, -8.23100135e-02f, -1.18430266e-02f, -8.18850007e-03f, 3.85482982e-02f, 7.84484483e-03f, 6.78117722e-02f, 3.47542390e-02f,
  1.04094364e-01f, 1.44124711e-02f, 5.49283735e-02f, -3.96697931e-02f, 2.49174912e-03f, 1.42113175e-02f, 2.38905773e-02f, 4.25878800e-02f, 2.49312390e-02f, -6.98714331e-02f,
  3.25137936e-02f, 1.11118168e-01f, 2.36784950e-01f, 6.42733425e-02f, 4.43416648e-02f, 1.65236577e-01f, 2.08725750e-01f, 1.30430207e-01f, 2.53865212e-01f, 2.57078290e-01f,
  -3.62832367e-01f, 1.69514179e-01f, -3.68429542e-01f, 1.48394883e-01f, -1.07337013e-01f, -1.35593683e-01f, -1.69220418e-01f, 1.18870199e-01f, 1.96960270e-01f, 6.94894046e-02f,
  2.99758241e-02f, 1.71920180e-01f, 2.05710784e-01f, 1.36887699e-01f, -7.53767267e-02f, 5.02409004e-02f, 1.20947156e-02f, -2.24138245e-01f, -2.03369230e-01f, 1.59417018e-02f,
  1.26383856e-01f, 1.22487761e-01f, 2.72293147e-02f, 1.06415361e-01f, 6.37027398e-02f, 2.04493165e-01f, 8.67943168e-02f, 1.03651300e-01f, 3.27986218e-02f, 3.18403803e-02f,
  -1.63168415e-01f, -1.10020399e-01f, 2.41540298e-02f, 1.20282076e-01f, -3.55232134e-03f, 9.73078236e-02f, -3.55286226e-02f, 8.98207724e-02f, 1.59253448e-01f, 1.58708856e-01f,
  6.62811622e-02f, 1.08256221e-01f, -1.99773237e-02f, -2.50958242e-02f, 7.58784637e-02f, 3.41065116e-02f, 7.10235164e-02f, -3.39902006e-02f, 4.15451676e-02f, 6.41945601e-02f,
  6.50915504e-02f, -1.02662183e-01f, -1.07924543e-01f, 7.38101453e-02f, 3.95691991e-02f, 6.48848861e-02f, 2.19501089e-02f, -6.10445477e-02f, 5.41033596e-02f, 1.08898699e-01f,
  -2.45922394e-02f, -1.12180352e-01f, -1.19891636e-01f, -7.91990981e-02f, -1.50238974e-02f, -5.91055416e-02f, -5.76105975e-02f, 3.98570905e-03f, -1.25788882e-01f, -9.25870389e-02f,
  -1.38668250e-02f, -5.54624274e-02f, -1.14072517e-01f, 3.74832377e-02f, 6.09358028e-03f, -1.11662805e-01f, -3.05694677e-02f, -5.33602433e-03f, -5.47654293e-02f, -3.00120260e-03f,
  -2.12075096e-02f, -1.24941379e-01f, 3.19409296e-02f, -1.00376248e-01f, -2.03303397e-02f, -2.13370030e-03f, -3.23093981e-02f, -2.44064815e-02f, -5.93963936e-02f, -5.28536066e-02f,
  1.63283259e-01f, -5.52448966e-02f, 1.42680556e-01f, 4.30263206e-02f, 1.32389173e-01f, 8.30573291e-02f, 4.60658371e-02f, 1.17259294e-01f, 3.92265283e-02f, 9.85888839e-02f,
  -3.49089280e-02f, -3.47916828e-03f, -2.58367769e-02f, 7.60386661e-02f, 3.32766697e-02f, 4.83677536e-02f, 1.60874411e-01f, 8.08523074e-02f, 5.33561222e-02f, 2.49782950e-02f,
  1.78719148e-01f, 8.56230259e-02f, -3.68513470e-03f, 9.97353811e-03f, 1.20183844e-02f, -4.59235199e-02f, 1.68716423e-02f, 6.57866672e-02f, -5.75352274e-03f, 1.07676335e-01f,
  -4.43157762e-01f, -1.09361835e-01f, 1.72764495e-01f, -1.23612806e-01f, 1.70386240e-01f, 8.50778148e-02f, 4.61700074e-02f, -2.64224466e-02f, -1.30662426e-01f, -7.71481991e-02f,
  2.53745079e-01f, 2.85637155e-02f, -5.20876944e-02f, -2.93464828e-02f, -1.42290652e-01f, -1.76338345e-01f, -1.30634308e-01f, -1.11553572e-01f, 1.50425155e-02f, -7.51663372e-03f,
  7.56026292e-03f, 2.22667567e-02f, -4.15937379e-02f, -4.72035110e-02f, -8.29556361e-02f, -4.39215340e-02f, 1.92922913e-02f, 1.13207325e-01f, 3.74161638e-02f, -1.65057957e-01f,
  5.55431694e-02f, 1.03586763e-01f, -8.25666413e-02f, -8.96352604e-02f, 2.56376453e-02f, -1.24453373e-01f, -3.89733352e-02f, 3.74723822e-02f, -3.36136520e-02f, 6.38023205e-03f,
  1.16056696e-01f, -2.71536559e-02f, -2.76198760e-02f, 1.23345712e-02f, 5.53014036e-03f, 1.04283758e-01f, 2.41355579e-02f, 1.12338318e-02f, -9.75552760e-03f, 8.71563610e-03f,
  2.49082092e-02f, 1.16940849e-01f, -2.85670850e-02f, 8.70777816e-02f, -1.49327796e-02f, -8.10143817e-03f, 4.12405357e-02f, -5.44626899e-02f, -2.45484579e-02f, -1.17538832e-01f,
  -1.99379072e-01f, 6.88247681e-02f, 1.19528949e-01f, 9.98068452e-02f, 1.28813639e-01f, 1.61127836e-01f, 7.65848160e-02f, 1.39788836e-01f, 4.79809195e-02f, 5.31703718e-02f,
  1.28279820e-01f, 5.04866466e-02f, 8.67623389e-02f, -5.57580553e-02f, 1.55151010e-01f, 1.46738112e-01f, 1.47621855e-01f, 2.32238676e-02f, 8.22851732e-02f, 1.79055005e-01f,
  1.06192723e-01f, 1.03873856e-01f, 5.55985682e-02f, 1.37130544e-01f, 1.02582134e-01f, 9.53514054e-02f, 4.38951366e-02f, 1.35500863e-01f, 1.58126220e-01f, 6.49218336e-02f,
  -1.88254908e-01f, 1.94404125e-01f, -2.55259842e-01f, -1.57276914e-01f, -1.42477795e-01f, -8.45883712e-02f, -1.06889039e-01f, -8.97257477e-02f, 1.79267973e-02f, -1.52889472e-02f,
  -6.61602542e-02f, -1.91043556e-01f, -8.83829594e-02f, -2.38586050e-02f, -7.08252564e-02f, -7.99092092e-03f, -1.36705533e-01f, -4.81468737e-02f, -1.63154393e-01f, -3.88589315e-02f,
  -1.33957878e-01f, -1.25175700e-01f, -1.30693257e-01f, -2.12308571e-01f, -1.97718263e-01f, -3.17033052e-01f, -2.30597377e-01f, -2.63789237e-01f, -2.92343348e-01f, -4.50397789e-01f,
  -8.45983997e-02f, 1.91329032e-01f, 2.69834846e-01f, 3.01038206e-01f, 3.07971001e-01f, 5.82089834e-02f, 9.49313715e-02f, -6.23792186e-02f, 7.81580061e-02f, 1.23700418e-01f,
  2.12208584e-01f, -7.04811290e-02f, 4.07165140e-02f, -1.73702449e-01f, -2.30223507e-01f, 4.85968888e-02f, 3.03367358e-02f, -1.71827048e-01f, -3.03326756e-01f, -1.73983172e-01f,
  -1.04919538e-01f, -8.70370939e-02f, -2.10204110e-01f, -1.40355781e-01f, 2.28045166e-01f, -5.31376004e-02f, 1.52329326e-01f, 1.49852186e-01f, -5.37903011e-02f, 2.96359807e-01f,
  3.57196599e-01f, 2.47915372e-01f, -1.19714759e-01f, -2.63005737e-02f, 1.27056479e-01f, -1.78726614e-01f, 6.68323115e-02f, -5.35278805e-02f, -2.84228195e-02f, -1.14479968e-02f,
  1.08785845e-01f, -1.09523229e-01f, 1.07686995e-02f, -1.00543573e-02f, 7.83319920e-02f, 8.27730149e-02f, -2.31987573e-02f, -8.19135606e-02f, -1.03844600e-02f, 3.36899757e-02f,
  8.35461766e-02f, 8.82713795e-02f, 1.12478718e-01f, 6.87393323e-02f, -7.22316504e-02f, -4.11648415e-02f, 1.08804226e-01f, -4.92005236e-02f, -8.04059654e-02f, 9.03508589e-02f,
  3.65583152e-02f, 5.79600446e-02f, 2.53636055e-02f, -9.96082351e-02f, -6.63127750e-02f, 2.19411068e-02f, -2.76631601e-02f, 5.10332510e-02f, -5.18073998e-02f, 2.31041536e-02f,
  -1.51369954e-02f, 3.60882133e-02f, -4.71608862e-02f, 1.34621235e-02f, -2.05132761e-03f, 2.37190798e-02f, 1.20015340e-02f, -3.16031352e-02f, 3.50516364e-02f, -7.49447495e-02f,
  -3.40189263e-02f, -2.26974059e-02f, 1.34623170e-01f, -8.66767764e-02f, 2.88302973e-02f, -6.90960616e-04f, 1.79545041e-02f, -5.97623326e-02f, 1.48248896e-02f, 6.34209812e-03f,
  -2.55930740e-02f, -6.62042126e-02f, 8.90005976e-02f, -2.26321295e-02f, 1.00693911e-01f, 3.66999246e-02f, 9.51350853e-02f, -4.59881090e-02f, -3.27343382e-02f, 3.73957753e-02f,
  5.86993434e-03f, -1.80296432e-02f, 1.06342003e-01f, -1.67670548e-02f, -1.02945656e-01f, -5.70329912e-02f, 2.84729209e-02f, 4.22998033e-02f, -4.21508141e-02f, 1.69243421e-02f,
  1.25587368e-02f, 5.01572946e-03f, 4.06135879e-02f, -1.91283450e-02f, 2.34200489e-02f, 1.79689005e-02f, -5.12316972e-02f, 8.66549462e-02f, -1.22278661e-01f, -1.34406820e-01f,
  3.38364094e-02f, 2.76564181e-01f, 1.49880305e-01f, -2.53768831e-01f, 3.67659591e-02f, 1.64142743e-01f, 3.63059640e-01f, 9.36690196e-02f, -2.24066556e-01f, -7.19472673e-03f,
  -1.34079397e-01f, -4.18274343e-01f, -3.13793153e-01f, -1.01217657e-01f, 8.83253589e-02f, 2.89546132e-01f, 3.32823992e-01f, 5.21592572e-02f, -2.80540083e-02f, -1.28403470e-01f,
  1.77204818e-03f, -5.16897924e-02f, -8.63908082e-02f, 1.51392017e-02f, -7.31684119e-02f, -1.23209894e-01f, 5.35224788e-02f, -1.16097979e-01f, 1.30458002e-03f, -6.32631406e-02f,
  -1.83033332e-01f, 9.26555693e-03f, 3.49127166e-02f, -1.53516112e-02f, -5.55652268e-02f, 6.62123337e-02f, 3.93688530e-02f, 1.20865433e-02f, 1.34716900e-02f, -3.42552960e-02f,
  -1.09580256e-01f, -1.48915932e-01f, -1.26180336e-01f, -1.71740949e-02f, -7.52384141e-02f, -8.57954547e-02f, 4.79005054e-02f, -6.11364667e-04f, 5.90059794e-02f, 5.71577586e-02f,
  2.72894576e-02f, -2.82692071e-02f, 6.02017343e-02f, 8.94913152e-02f, -1.28941727e-03f, 1.62762664e-02f, 2.37320252e-02f, -5.43661006e-02f, 9.46154371e-02f, 8.86033103e-02f,
  8.49118829e-02f, 1.50274262e-01f, -2.83014588e-03f, 1.29799590e-01f, 1.90862163e-03f, -2.36761421e-02f, 4.44730185e-02f, -4.28775698e-02f, -1.84161402e-02f, 3.83801386e-02f,
  2.03442164e-02f, -3.76409963e-02f, -5.93618564e-02f, -3.50440033e-02f, -1.29750699e-01f, 4.67514247e-02f, -3.04494016e-02f, 4.21057381e-02f, -5.13922945e-02f, -6.36329502e-02f,
  -6.97749928e-02f, -8.17310214e-02f, -7.10218102e-02f, -6.11621439e-02f, 1.18266409e-02f, -8.75122473e-02f, -1.42891347e-01f, -5.31175062e-02f, 1.27172377e-02f, -4.54871310e-03f,
  -2.92025864e-01f, 1.16200455e-01f, -1.37561232e-01f, 3.93263660e-02f, -2.32432503e-03f, -1.14595033e-02f, 1.55372918e-02f, 3.92166227e-02f, -8.12928192e-03f, -5.21172993e-02f,
  5.14636897e-02f, -1.71891451e-02f, -1.22068815e-01f, 6.53151572e-02f, -2.56828871e-02f, -2.26954501e-02f, 1.23104118e-01f, -4.12537865e-02f, -7.22783012e-03f, 1.19865257e-02f,
  1.15761101e-01f, 5.14299348e-02f, -4.09024879e-02f, 6.58484828e-03f, 6.22494519e-02f, -5.08166067e-02f, -7.26303235e-02f, 9.38000274e-04f, 2.21136734e-02f, 1.45186111e-01f,
  3.29458177e-01f, -1.81539148e-01f, -2.01158807e-01f, 6.80782124e-02f, 6.86953664e-02f, -1.23557732e-01f, -2.45325863e-01f, -4.17855009e-02f, -1.89155377e-02f, -1.38491258e-01f,
  9.65369940e-02f, 2.49328941e-01f, 8.28739107e-02f, 1.19453818e-01f, 7.07369819e-02f, -2.80952781e-01f, -2.60650456e-01f, 8.71135071e-02f, 3.11033875e-01f, 2.81467706e-01f,
  -4.49545728e-03f, 7.27749849e-03f, 1.71021089e-01f, 1.74238592e-01f, -1.34189293e-01f, -7.07543716e-02f, -3.40813518e-01f, -1.45637348e-01f, -5.60672916e-02f, -3.76832575e-01f,
  -1.26979366e-01f, 4.59007919e-02f, 1.05150975e-01f, 1.70022964e-01f, -5.14658913e-02f, -1.34247569e-02f, -3.90648767e-02f, -1.53065369e-01f, 1.02688149e-02f, -8.48751888e-02f,
  7.44253621e-02f, -2.27039922e-02f, 2.33862717e-02f, -1.01115830e-01f, -1.96695626e-02f, -4.08529267e-02f, -1.14524104e-01f, -2.24150419e-02f, -1.38657559e-02f, 7.00497627e-03f,
  4.76437025e-02f, 5.92468269e-02f, 2.36506946e-02f, -5.71220443e-02f, -4.50202301e-02f, 9.32378247e-02f, -1.06399417e-01f, -1.21235982e-01f, 2.34554894e-02f, -3.60563666e-01f,
  4.27462682e-02f, -3.32750268e-02f, 3.14269960e-02f, -5.76407649e-02f, -3.65499128e-03f, -4.39326577e-02f, 5.66690564e-02f, -8.76319632e-02f, 4.92029339e-02f, -7.05061331e-02f,
  3.03988438e-02f, -5.14756627e-02f, -5.96797653e-02f, -4.30992208e-02f, -9.39052701e-02f, -3.85551341e-02f, -4.04843055e-02f, -2.67358813e-02f, -3.70231755e-02f, 6.19830489e-02f,
  6.99735507e-02f, -7.78508261e-02f, 8.31199402e-04f, -2.30420418e-02f, -4.67001162e-02f, -8.69065523e-03f, -4.14283313e-02f, -3.67489569e-02f, 4.95343097e-02f, -3.42736603e-03f,
  -1.34458393e-01f, 9.50125530e-02f, -9.60753858e-02f, -3.90650146e-02f, 2.83680041e-03f, -8.45877230e-02f, -2.17852183e-02f, 7.13685993e-03f, -1.79972406e-02f, -1.43785076e-02f,
  1.25496055e-03f, -1.66937429e-02f, 1.95292290e-02f, -9.96054634e-02f, 4.62000929e-02f, 1.91705376e-02f, 3.41239348e-02f, -9.24325455e-03f, -7.52662793e-02f, -5.73128127e-02f,
  -1.16183735e-01f, -6.39000982e-02f, 4.00354825e-02f, -9.25410986e-02f, -7.95765370e-02f, 7.57530704e-02f, -1.07210554e-01f, -1.87814564e-01f, 8.86167586e-03f, -2.69240737e-01f,
  2.01600850e-01f, 1.19041607e-01f, 3.42646003e-01f, -1.41182259e-01f, 3.42046209e-02f, 9.21520814e-02f, 2.00187355e-01f, -3.45221870e-02f, -2.38593414e-01f, 3.23384777e-02f,
  6.29188418e-02f, -2.00708047e-01f, -1.60516694e-01f, -1.87257931e-01f, -1.06064081e-02f, 7.45372400e-02f, 8.00927728e-02f, -7.28670433e-02f, -2.25546852e-01f, -1.69770733e-01f,
  -2.57344961e-01f, -1.29565939e-01f, -1.93157345e-01f, -6.38248771e-02f, -6.98124692e-02f, -1.38482347e-01f, 1.48414314e-01f, -4.25344333e-03f, -5.39609827e-02f, 1.05363473e-01f,
  1.47691324e-01f, 1.61496609e-01f, -9.24826711e-02f, -2.10937232e-01f, 3.62841561e-02f, -7.60785129e-04f, -1.27183879e-02f, -3.86817455e-02f, 3.71246114e-02f, -4.37722839e-02f,
  3.31361741e-02f, -3.48528996e-02f, -9.11198929e-02f, -7.79625326e-02f, -2.57979464e-02f, 3.85727128e-03f, -9.04333517e-02f, 1.53771592e-02f, -8.30582064e-03f, 2.91350987e-02f,
  -1.10649928e-01f, 4.49434370e-02f, 4.59777005e-02f, -6.08471148e-02f, 3.20946760e-02f, 3.38878408e-02f, -5.27555235e-02f, 1.57600697e-02f, -1.60293300e-02f, -1.16859153e-01f,
  -6.18729293e-02f, -5.01626916e-02f, 4.50839475e-02f, 3.40227522e-02f, -9.63014551e-03f, 7.67628476e-03f, 4.25162865e-03f, -3.76130380e-02f, -1.86842475e-02f, -5.62379025e-02f,
  2.98470557e-02f, 8.81945118e-02f, 1.33347092e-02f, -1.79225765e-02f, 4.58827578e-02f, 8.95226672e-02f, 5.96468449e-02f, -6.19373247e-02f, -5.23462817e-02f, 7.26181641e-02f,
  -5.86153790e-02f, -5.16118594e-02f, 2.28278097e-02f, -9.16220173e-02f, 3.40366960e-02f, 2.88140401e-02f, 8.75066370e-02f, 2.95799021e-02f, 6.57359287e-02f, 6.06043041e-02f,
  -1.71671152e-01f, 4.38667228e-03f, -3.60690877e-02f, -2.05854237e-01f, 1.88336577e-02f, -7.36427978e-02f, -8.56462866e-02f, -6.01236001e-02f, 8.18507746e-02f, -5.55233099e-02f,
  -1.10527817e-02f, -7.36442208e-02f, -2.11617816e-02f, -9.17205960e-02f, -9.13857296e-02f, -5.97559363e-02f, -4.39304747e-02f, -1.52873889e-01f, -6.33709356e-02f, -1.97929069e-02f,
  -2.08280876e-01f, -4.66818362e-02f, -6.11333176e-02f, 1.22815156e-02f, -5.90752736e-02f, -5.32977991e-02f, 1.49521641e-02f, 3.91162559e-03f, 8.98817107e-02f, 7.22042797e-03f,
  8.65572274e-01f, 3.71773057e-02f, 5.71342818e-02f, 2.72815406e-01f, -1.10211886e-01f, 3.90504929e-03f, 1.46785202e-02f, 2.55278423e-02f, 9.66290385e-02f, 1.11261740e-01f,
  1.88711975e-02f, -9.44930539e-02f, -2.79197004e-02f, -9.95132178e-02f, 8.67036059e-02f, 3.07569765e-02f, 3.11994869e-02f, 2.44239196e-01f, 4.96832840e-02f, 8.45827088e-02f,
  -9.07504186e-02f, 7.13317320e-02f, 3.09112310e-01f, 6.16742447e-02f, -8.74611214e-02f, -3.15281786e-02f, -5.83433025e-02f, 6.32447004e-02f, -1.19125023e-01f, -1.49022778e-02f,
  1.69748161e-02f, 2.12798417e-01f, -1.54128805e-01f, 4.74183783e-02f, -4.42072302e-02f, 8.52624774e-02f, 1.43111264e-03f, -3.32561624e-03f, 1.44325923e-02f, -1.73622686e-02f,
  -2.10500825e-02f, 5.21472618e-02f, -2.25725994e-02f, -1.55459076e-01f, 9.67208669e-02f, 5.58188558e-02f, -8.04046690e-02f, 2.02816762e-02f, -1.91248693e-02f, 2.07831394e-02f,
  -8.37108418e-02f, 6.10363595e-02f, 6.60726354e-02f, -1.22905597e-01f, -6.01279438e-02f, 6.50413558e-02f, -1.28622249e-01f, -5.60743324e-02f, -6.08121417e-02f, 8.54030997e-02f,
  -7.54873094e-04f, 9.12156776e-02f, 2.64573097e-02f, 7.79563654e-03f, 4.07017767e-02f, 5.35098016e-02f, 3.13864350e-02f, 4.47363183e-02f, -2.35302318e-02f, 4.74815890e-02f,
  -8.21511820e-02f, 1.12985251e-02f, -2.04451755e-02f, 6.82448447e-02f, 8.25033709e-03f, 1.89689677e-02f, 1.28433436e-01f, 9.47514176e-03f, -1.35943992e-02f, -2.75953412e-02f,
  5.82399145e-02f, -1.57477856e-02f, 2.11069081e-02f, 4.33420092e-02f, 1.07599841e-02f, 2.11474933e-02f, 1.96704529e-02f, 3.06816753e-02f, 6.10612286e-03f, 1.94832031e-02f,
  -7.07541332e-02f, -1.23196460e-01f, 5.22189355e-03f, 3.04028317e-02f, -2.13325620e-02f, -9.22486186e-02f, 4.88941781e-02f, -4.43494581e-02f, -3.32792886e-02f, 2.97057778e-02f,
  -6.29714038e-03f, 8.91417563e-02f, 7.53822699e-02f, -7.18643069e-02f, -4.17746119e-02f, -1.53039079e-02f, 2.08160579e-02f, 2.80976715e-03f, 1.25451088e-02f, -6.91558234e-03f,
  -1.96159631e-02f, 4.78807092e-02f, 8.75753388e-02f, -4.85885479e-02f, 1.32663129e-02f, 1.25233144e-01f, -4.39516716e-02f, 7.64225435e-04f, 7.41998926e-02f, 4.57592160e-02f,
  4.49388504e-01f, 1.47101268e-01f, -1.81650817e-01f, 1.06535576e-01f, -1.84492115e-02f, -8.01601484e-02f, 2.93803471e-03f, -1.40528992e-01f, 4.11766022e-03f, 1.33011654e-01f,
  -2.71183793e-02f, 7.29833320e-02f, 8.46693814e-02f, 4.53904830e-02f, 1.03066601e-02f, 1.31074280e-01f, 1.52949452e-01f, -2.12999433e-02f, 2.76551284e-02f, 2.88056377e-02f,
  1.54020935e-01f, 2.04990000e-01f, -4.13143029e-03f, -1.49597554e-02f, 9.35216546e-02f, -9.35579762e-02f, -1.36871725e-01f, -3.52838896e-02f, -1.40268160e-02f, 7.09404275e-02f,
  -4.73416187e-02f, 3.45855393e-02f, 4.48822342e-02f, 7.98286945e-02f, -1.31202668e-01f, -8.06829557e-02f, 6.54918188e-03f, -1.02096781e-01f, -1.13735393e-01f, 3.10046189e-02f,
  5.05883060e-02f, -5.80458231e-02f, -1.76684130e-02f, -3.97409722e-02f, 7.90894032e-02f, -5.85399866e-02f, 1.25364671e-02f, -5.21701854e-03f, -5.59506789e-02f, 5.37722781e-02f,
  1.48324799e-02f, -4.00584489e-02f, -5.42783663e-02f, -1.58125550e-01f, -5.26032634e-02f, -3.31186727e-02f, -5.59927057e-03f, -1.41517788e-01f, -2.46070176e-02f, -3.98213454e-02f,
  -9.85072553e-03f, -7.49364793e-02f, -5.18065393e-02f, 8.54628235e-02f, 9.40768421e-02f, -7.68517256e-02f, 9.23600271e-02f, 5.99318631e-02f, 4.29971404e-02f, -9.57360491e-02f,
  4.67149215e-03f, -1.48310922e-02f, -2.89597455e-02f, 1.15875579e-01f, 2.74298768e-02f, -4.00062017e-02f, 5.91946170e-02f, 3.17798592e-02f, 5.90138584e-02f, 7.56859034e-02f,
  5.29521890e-02f, -3.04308049e-02f, 5.02300560e-02f, -3.19670402e-02f, 3.70616801e-02f, 5.66237383e-02f, 1.52830509e-02f, -4.88810353e-02f, 6.53481558e-02f, 3.38243172e-02f,
  -1.99225545e-02f, -1.53621972e-01f, 1.33347675e-01f, 9.90314335e-02f, -3.25050987e-02f, -9.74229574e-02f, -9.70760267e-03f, -2.73373618e-04f, -7.25772604e-02f, 6.87509030e-02f,
  -4.87933159e-02f, 1.87604725e-02f, -2.84853391e-02f, -7.64281349e-03f, -9.20526534e-02f, 3.61113437e-02f, 6.35745674e-02f, 3.76629494e-02f, -8.31152592e-03f, -1.20049581e-01f,
  -4.05855887e-02f, -1.71742942e-02f, 6.42909855e-02f, -1.08631954e-01f, -1.78283542e-01f, 1.14867473e-02f, -8.48971456e-02f, -2.84862928e-02f, -1.01411194e-01f, 7.18785524e-02f,
  3.28093439e-01f, -1.28334180e-01f, -3.20378423e-01f, 1.65420756e-01f, -2.16689378e-01f, -3.09005767e-01f, -5.40027142e-01f, 1.32648647e-02f, 1.51406497e-01f, -9.54520106e-02f,
  1.19077340e-01f, 2.41618618e-01f, 3.09860498e-01f, 1.81043044e-01f, 3.16825062e-02f, -1.65274143e-01f, -2.81164467e-01f, 4.50163223e-02f, 4.02866900e-02f, -5.73383309e-02f,
  -6.31274879e-02f, -2.33113561e-02f, 1.23415686e-01f, 3.64744663e-02f, 7.11442390e-03f, 1.46421537e-01f, 6.14020191e-02f, -3.97592783e-02f, 3.20274346e-02f, -1.64741784e-01f,
  -1.46262556e-01f, -7.25315884e-02f, -1.41185075e-01f, 2.50838255e-03f, -3.73425856e-02f, -9.32250917e-02f, -9.21439976e-02f, -1.34388834e-01f, 3.22901867e-02f, -1.25264287e-01f,
  -6.20324425e-02f, -9.70101431e-02f, -6.23640753e-02f, -1.09982744e-01f, -1.50200501e-01f, -1.13328025e-01f, 4.77926154e-03f, -1.01206854e-01f, -3.75052020e-02f, -1.29379362e-01f,
  -9.82148200e-02f, -7.13416263e-02f, -2.06956357e-01f, -1.10458679e-01f, -1.47301137e-01f, -4.12916131e-02f, -1.15973569e-01f, -6.38161879e-03f, -8.10427070e-02f, 2.50512436e-02f,
  3.78773101e-02f, 4.63925600e-02f, 3.21803801e-02f, -5.91409625e-03f, 1.78558640e-02f, 3.91459391e-02f, 2.66856458e-02f, -4.16502263e-03f, -5.46513312e-03f, 1.08604999e-02f,
  -3.00176814e-02f, 2.94872820e-02f, 3.28093618e-02f, -3.01378071e-02f, -9.94455349e-03f, -6.24194592e-02f, -7.24000782e-02f, -2.51740087e-02f, -4.37378511e-02f, 9.17170011e-03f,
  1.51619362e-02f, 2.47415546e-02f, 1.32765904e-01f, -8.08772258e-03f, -6.23941468e-03f, -8.13526809e-02f, -8.72999057e-02f, -2.60788146e-02f, 3.70921791e-02f, 4.81502973e-02f,
  2.03396380e-01f, 1.73936058e-02f, 1.16595134e-01f, 2.67865509e-03f, -1.06845580e-01f, 8.59878026e-03f, -6.11170940e-02f, -8.47472399e-02f, 1.03522036e-02f, -1.19739547e-01f,
  -4.70824651e-02f, -4.23821956e-02f, 2.87675131e-02f, 7.81809911e-03f, -1.36802522e-02f, -1.03780992e-01f, -2.69368198e-02f, -5.86917298e-03f, -1.01761371e-01f, 2.99600419e-04f,
  -9.49871552e-04f, -6.79530576e-02f, 8.31706598e-02f, 5.81194796e-02f, 1.20972982e-02f, 9.28041935e-02f, -8.11714455e-02f, 1.76657606e-02f, -4.07704860e-02f, -2.47727744e-02f,
  -3.69840443e-01f, 1.90206364e-01f, 1.44918442e-01f, -1.22807473e-01f, -4.13035564e-02f, -8.37842748e-02f, -2.91413277e-01f, -1.60363451e-01f, -1.34987503e-01f, 4.60132025e-02f,
  3.20533067e-01f, 2.54030704e-01f, 1.67703494e-01f, 1.56087890e-01f, 8.67541647e-04f, -1.67992309e-01f, -1.63098782e-01f, -1.87073246e-01f, 7.15618348e-03f, 7.75301233e-02f,
  4.49376293e-02f, -1.38789818e-01f, -1.76683947e-01f, -1.31151617e-01f, 5.64766973e-02f, 1.33506030e-01f, -6.49976954e-02f, 4.18878160e-02f, 1.47762150e-01f, 2.29677539e-02f,
  2.22292975e-01f, -1.36777072e-03f, 7.53653422e-02f, 4.13953960e-02f, 7.58616105e-02f, 6.12008944e-03f, 8.00924078e-02f, -2.65663192e-02f, 7.93429017e-02f, 4.87350114e-02f,
  7.46420771e-02f, -2.22708900e-02f, -5.17152622e-02f, 1.52220592e-01f, -4.47319634e-02f, -3.65923643e-02f, -3.11507825e-02f, -1.92890204e-02f, -2.42919754e-02f, 1.64860919e-01f,
  1.47876844e-01f, -6.09294837e-03f, 4.62656654e-02f, 3.73312458e-02f, 4.98783253e-02f, 5.78914359e-02f, 8.81315470e-02f, 3.69282365e-02f, 6.75503314e-02f, 5.47244735e-02f,
  2.28258111e-02f, -6.17656112e-02f, -5.79195209e-02f, -7.19035342e-02f, -1.13485277e-01f, -3.43972743e-02f, -1.24056730e-02f, -2.15467755e-02f, -1.04580253e-01f, -1.11362375e-01f,
  4.08380926e-02f, -9.80257522e-03f, -3.96636575e-02f, -1.09607354e-01f, 2.20297892e-02f, -6.61357492e-02f, -3.51680778e-02f, 5.26414476e-02f, -4.22446132e-02f, -1.24508068e-01f,
  -2.27830615e-02f, -6.27795309e-02f, -5.69167212e-02f, -7.96758607e-02f, -2.76653543e-02f, 1.96797075e-03f, -1.05775081e-01f, 1.09633687e-03f, -4.58747856e-02f, -8.24993104e-03f,
  -1.96052436e-02f, 9.32498053e-02f, -2.78699608e-03f, 3.08515392e-02f, 1.36828005e-01f, 6.45206347e-02f, 1.06288992e-01f, 3.66966128e-02f, 1.85111329e-01f, 8.90541822e-02f,
  1.39361247e-01f, -3.66568603e-02f, 3.49572413e-02f, -2.53391434e-02f, 3.08530908e-02f, 7.74700269e-02f, 4.09555361e-02f, 7.74432532e-03f, 8.95394906e-02f, 5.80767952e-02f,
  -8.16828851e-03f, -4.51198481e-02f, -8.21991861e-02f, -1.54766692e-02f, -1.27841961e-02f, -1.12792589e-01f, -2.74769552e-02f, 8.81750509e-02f, -1.20405015e-03f, -2.43591815e-01f,
  1.92953981e-02f, -1.06406599e-01f, -2.34661996e-01f, -7.15940222e-02f, -1.54236048e-01f, -2.11966380e-01f, -2.37285167e-01f, -6.59529045e-02f, 9.80111212e-03f, -2.79109031e-01f,
  -2.36043707e-02f, -3.14978063e-02f, -7.63597712e-03f, -6.46600947e-02f, -1.85386315e-01f, -2.70109087e-01f, -3.48761886e-01f, -2.24999443e-01f, -1.01542875e-01f, 2.87005100e-02f,
  -1.00100897e-01f, -4.48045656e-02f, 1.15003511e-01f, -5.91761172e-02f, -7.65517652e-02f, -1.17265806e-01f, -1.90391019e-01f, -1.81333744e-03f, -1.73829913e-01f, -2.66100049e-01f,
  -1.93470106e-01f, -1.07646555e-01f, -4.86646928e-02f, -1.22728392e-01f, 1.46456752e-02f, -3.06544676e-02f, -5.65107465e-02f, -1.62903994e-01f, -7.26037994e-02f, -1.28930375e-01f,
  -2.30691787e-02f, -4.14537080e-02f, -5.94778135e-02f, -3.32853235e-02f, -3.03089041e-02f, -5.30915186e-02f, -9.08472613e-02f, -1.10823400e-01f, -3.58415991e-02f, -1.12017184e-01f,
  -1.17159791e-01f, -6.22050092e-02f, -2.22209804e-02f, -4.88532558e-02f, -5.43812327e-02f, 1.59412809e-02f, 6.38287365e-02f, -7.00275525e-02f, 6.88723400e-02f, -1.23152286e-02f,
  -2.45879102e-03f, 1.12380609e-01f, -2.27586757e-02f, 1.13859177e-01f, 6.21422380e-03f, 2.84969416e-02f, 1.65858418e-02f, -4.29886533e-03f, 3.34989540e-02f, 8.13488439e-02f,
  2.93143187e-02f, -3.46188992e-02f, 4.79477132e-03f, -4.64438908e-02f, 5.55570312e-02f, 3.36027779e-02f, 6.32350892e-02f, 2.41946504e-02f, -7.49162491e-03f, 1.07451361e-02f,
  -1.24076130e-02f, 1.04830615e-01f, 6.19171187e-02f, 1.12897366e-01f, 6.89783767e-02f, -6.16966933e-02f, -2.26212237e-02f, 1.02704488e-01f, 7.33062550e-02f, -8.52257386e-02f,
  6.12649582e-02f, 6.57106340e-02f, -1.73643380e-01f, -8.43739361e-02f, -1.15313776e-01f, -1.90503791e-01f, -5.85713498e-02f, -1.29058018e-01f, -1.15920745e-01f, -2.87787132e-02f,
  -4.23236489e-02f, -1.32103786e-02f, -8.22549313e-02f, 2.28895340e-02f, -9.57777128e-02f, -8.74613971e-02f, -9.77548659e-02f, -1.02379069e-01f, -1.40869796e-01f, 2.15539671e-02f,
  -1.14484146e-01f, -1.01409629e-01f, -7.51194879e-02f, -5.88096529e-02f, -5.37898615e-02f, -1.64880738e-01f, -5.27848639e-02f, -6.31928742e-02f, 4.04247409e-03f, -7.46775642e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.85185650e-02f, -7.01273158e-02f, -3.78612757e-01f, 1.62175596e-01f, -6.36031330e-02f, -3.16566974e-01f, -7.67604411e-01f, -2.53949035e-02f, 3.38810563e-01f, -5.22066951e-01f,
  -2.36896500e-01f, 1.29669130e-01f, -1.69335529e-01f, -1.53675035e-01f, -5.89291751e-01f, -7.40582526e-01f, -6.50736988e-01f, -3.81392330e-01f, -1.64533406e-01f, -3.49711329e-02f,
  3.55709642e-02f, -8.94766301e-03f, 5.85645586e-02f, 1.55145163e-02f, 2.27594882e-01f, 1.97628930e-01f, -4.97607291e-02f, 1.80027485e-01f, -6.24436736e-02f, -3.98672447e-02f,
  -2.90200204e-01f, 2.91256785e-01f, 2.01212503e-02f, 2.47338880e-02f, -1.20553402e-02f, 7.23303705e-02f, 4.57598967e-03f, 6.06860742e-02f, 5.53414226e-02f, -1.20681457e-01f,
  3.92974280e-02f, -2.01982092e-02f, 2.13380545e-01f, 1.12493098e-01f, -5.74255697e-02f, -1.10219885e-02f, -1.27546161e-01f, -7.95395225e-02f, -1.93383053e-01f, -1.40183657e-01f,
  -1.39336020e-01f, -1.81964651e-01f, 8.72267410e-03f, 3.61867473e-02f, -4.29997481e-02f, 5.14533930e-02f, 1.37703851e-01f, 2.81702071e-01f, 1.29966930e-01f, 2.41741508e-01f,
  -3.98604758e-02f, 4.13606688e-02f, 1.25640154e-01f, 6.42648935e-02f, -1.31582562e-02f, 8.67157057e-02f, 7.85747543e-02f, -6.88159978e-03f, 6.43487647e-02f, -4.01502773e-02f,
  -6.98866546e-02f, -7.95756280e-03f, -1.28120646e-01f, -6.84918389e-02f, -9.17064399e-02f, 1.54072508e-01f, -2.35808473e-02f, 7.99969491e-03f, -1.09575398e-01f, -2.85836905e-02f,
  -6.07640110e-03f, 4.05693874e-02f, 3.82336564e-02f, 9.94451270e-02f, -1.51125148e-01f, -4.41555120e-02f, 3.75404246e-02f, 1.27317465e-03f, 1.21183999e-01f, -1.11133553e-01f,
  3.47845763e-01f, -4.09533292e-01f, 6.20038025e-02f, -6.86631128e-02f, 7.33620897e-02f, -1.45623490e-01f, 9.98561084e-02f, 8.70052539e-03f, 1.18721239e-01f, -1.21842548e-01f,
  6.17972985e-02f, -5.54679297e-02f, -1.09446958e-01f, 5.67645691e-02f, -4.55667041e-02f, -1.07671089e-01f, -8.57699960e-02f, 9.94125009e-02f, -7.98459277e-02f, 1.31425664e-01f,
  -1.24902055e-01f, -1.98475063e-01f, -1.21698990e-01f, -5.67077734e-02f, 2.00960040e-01f, -5.39423386e-03f, -1.08467601e-01f, 1.15361653e-01f, -1.20116107e-01f, -5.17778695e-02f,
  -5.26107073e-01f, 4.05749232e-01f, 1.71702713e-01f, -5.02189361e-02f, 4.73004043e-01f, 3.41000557e-01f, 1.48193568e-01f, -3.62462029e-02f, -2.33460829e-01f, 6.51690140e-02f,
  3.72088701e-01f, 1.30512923e-01f, 2.10482284e-01f, 1.03783436e-01f, -2.13944376e-01f, 9.27660316e-02f, 1.33287206e-01f, -2.30274230e-01f, -3.90462548e-01f, -2.19181016e-01f,
  -1.32359471e-02f, -1.45214453e-01f, -5.13638794e-01f, -3.20089102e-01f, 1.00281253e-01f, 3.62563878e-02f, 8.70494321e-02f, 4.53956984e-02f, 2.89004415e-01f, 2.12436274e-01f,
  6.49899319e-02f, 1.88931320e-02f, 1.97152402e-02f, 4.04390953e-02f, 1.25044346e-01f, -3.15800905e-01f, -2.87300885e-01f, -1.51145145e-01f, -6.18421007e-04f, -1.54958382e-01f,
  3.26246582e-02f, 1.11583740e-01f, 2.20594823e-01f, 4.98960204e-02f, -1.02694705e-03f, -6.68618903e-02f, 2.77875667e-03f, -1.39148638e-01f, -4.22706932e-01f, -2.45099619e-01f,
  3.09644878e-01f, 3.78782898e-01f, 1.85315341e-01f, 2.23962292e-01f, -1.95352972e-01f, -1.66463941e-01f, -1.01588368e-01f, -2.06999183e-01f, -1.39392450e-01f, -5.92483521e-01f,
  1.39404073e-01f, 1.85587481e-01f, 1.36938542e-01f, 5.67245446e-02f, 1.21587470e-01f, 3.29038478e-03f, 1.50911868e-01f, 8.71474296e-02f, -6.02440396e-03f, -3.23499888e-02f,
  1.67278662e-01f, 8.24739859e-02f, -9.47479978e-02f, 6.43599182e-02f, -3.49903256e-02f, 3.67158651e-02f, 3.98810407e-05f, -1.05821222e-01f, 1.76889226e-02f, 2.11980529e-02f,
  -3.41605246e-02f, 5.89704365e-02f, -5.72281703e-02f, -1.74309328e-01f, 1.87486067e-01f, 2.91529950e-02f, 3.12824473e-02f, 2.49003130e-03f, -8.21147636e-02f, -8.76875892e-02f,
  -3.06880921e-01f, 2.97523975e-01f, -2.68707871e-01f, -9.47308764e-02f, 1.05187945e-01f, 1.13416612e-01f, 2.06921488e-01f, 5.84473908e-02f, 5.87736368e-02f, -1.28806904e-01f,
  -8.08962435e-02f, 7.81708434e-02f, 2.03568805e-02f, -1.48119897e-01f, -2.66166955e-01f, -5.06802127e-02f, 4.35456783e-02f, 6.30441904e-02f, -1.70485675e-01f, 3.39967906e-02f,
  -2.80649513e-01f, -2.79243082e-01f, -2.93910980e-01f, -1.39303029e-01f, -1.43021390e-01f, -1.20549724e-01f, -1.41782850e-01f, -2.70309895e-01f, -3.41577590e-01f, -6.10773146e-01f,
  7.66384676e-02f, 2.84956217e-01f, -2.83495128e-01f, 2.30658889e-01f, 1.18569553e-01f, 9.71217304e-02f, 8.41270164e-02f, 3.92569572e-01f, 3.41214895e-01f, -1.48661509e-01f,
  -6.93319589e-02f, -6.90822005e-02f, -1.48190364e-01f, -2.65491098e-01f, -2.98382968e-01f, -1.64052337e-01f, -4.02103990e-01f, -4.00153875e-01f, -3.39621872e-01f, 8.47889632e-02f,
  -8.15221220e-02f, 5.76907996e-06f, -1.44819751e-01f, -1.71362236e-01f, -9.87135395e-02f, -4.59388852e-01f, -4.05157626e-01f, -2.39749461e-01f, -4.58801687e-01f, -7.83436298e-01f,
  -3.52449447e-01f, 1.99784160e-01f, 4.65734527e-02f, -1.52231455e-01f, 2.77272612e-01f, 1.87758878e-01f, 2.55101472e-01f, 2.57360756e-01f, 1.24091096e-01f, 2.91133877e-02f,
  -1.52270958e-01f, 2.58240085e-02f, 2.01308832e-01f, -4.82375361e-02f, -7.12144822e-02f, -8.23703688e-03f, 1.38609886e-01f, 1.07742794e-01f, -2.30526775e-02f, 1.74221575e-01f,
  5.09508289e-02f, -6.56910464e-02f, -6.46114647e-02f, 5.50811179e-03f, -2.47722175e-02f, -1.27460390e-01f, -4.80033234e-02f, -1.52302861e-01f, -2.08688438e-01f, -2.15903506e-01f,
  2.21899778e-01f, 5.39096966e-02f, -4.98196969e-05f, 2.17579648e-01f, 5.20354789e-03f, 1.16061583e-01f, -6.25388026e-02f, -1.43110633e-01f, -1.24611463e-02f, -1.45856263e-02f,
  1.01901762e-01f, 1.84346754e-02f, 1.05038695e-01f, -8.60938523e-03f, -2.09657043e-01f, 1.01464242e-03f, -1.02092184e-01f, -1.62179589e-01f, -1.89608008e-01f, -3.07480711e-02f,
  -2.07520038e-01f, -2.65000761e-02f, -2.61130538e-02f, -2.36630030e-02f, -1.29352305e-02f, -1.22714117e-01f, -8.18225369e-02f, -1.93027835e-02f, 6.20887578e-02f, 8.29724187e-04f,
  -6.47429898e-02f, -1.99685618e-01f, -1.21217139e-01f, -1.24244519e-01f, -1.24691248e-01f, 9.17300209e-03f, -6.49285838e-02f, -1.68252327e-02f, -1.53014180e-03f, 1.32469246e-02f,
  -1.10043235e-01f, 2.33017299e-02f, -9.29840729e-02f, 5.60572743e-02f, 7.08948895e-02f, -1.75861374e-01f, -9.14840586e-03f, -1.94275051e-01f, -1.92474231e-01f, 1.67715788e-01f,
  4.42682169e-02f, -2.12069497e-01f, -2.97487020e-01f, -9.01493430e-02f, -1.10709062e-02f, -2.61521399e-01f, -9.93208438e-02f, -2.67681003e-01f, -1.70472458e-01f, -1.98359061e-02f,
  -3.25144351e-01f, -6.16944171e-02f, 1.64979711e-01f, 1.84952706e-01f, 3.28007162e-01f, -2.79827505e-01f, -6.77481651e-01f, -7.13136375e-01f, -9.95110199e-02f, -3.05906695e-04f,
  -2.72123553e-02f, 9.17382538e-02f, 3.84923428e-01f, 1.18714198e-01f, -4.05076027e-01f, -8.98187514e-03f, 3.35450023e-01f, 1.48930522e-02f, -3.92352670e-01f, -2.86133170e-01f,
  2.07711697e-01f, -3.41693647e-02f, -1.19889177e-01f, -1.63678348e-01f, 1.64377004e-01f, 5.97627535e-02f, 2.18701571e-01f, 7.59775043e-02f, 4.59746011e-02f, 6.60811424e-01f,
  2.61960000e-01f, -2.50473619e-01f, 1.26080632e-01f, 1.25153482e-01f, 9.68365893e-02f, -5.47185279e-02f, -3.17019045e-01f, 1.98443249e-01f, -8.51107985e-02f, -1.59166288e-02f,
  1.72970384e-01f, -1.81336060e-01f, 2.42406264e-01f, 8.45038518e-02f, -1.28818452e-01f, -3.86085778e-01f, -3.62448655e-02f, -4.55354340e-02f, -8.85351896e-02f, -2.46909574e-01f,
  1.85148537e-01f, 6.83625191e-02f, -1.09968871e-01f, -1.13109715e-01f, -3.02404135e-01f, 1.72827229e-01f, -1.58325985e-01f, -1.14388965e-01f, -3.37251216e-01f, -2.17529491e-01f,
  -2.74575949e-02f, -3.97753157e-02f, 5.86160123e-02f, 1.93309505e-02f, -1.12532809e-01f, 3.93404476e-02f, 2.62960821e-01f, -1.44813403e-01f, 1.04150206e-01f, -1.52680159e-01f,
  -4.01916690e-02f, 3.63506973e-02f, -6.50228783e-02f, -4.44331169e-02f, 1.35575766e-02f, 1.94434654e-02f, 2.09943252e-03f, -3.29216905e-02f, -5.36191314e-02f, -5.22948727e-02f,
  -2.80207731e-02f, 4.99909706e-02f, 5.36506586e-02f, -1.34973824e-01f, 7.36205578e-02f, -3.64463329e-02f, 2.98029054e-02f, -5.93185425e-02f, -2.59869490e-02f, -8.98832735e-03f,
  -1.84776634e-01f, 7.88031593e-02f, 6.08100332e-02f, -8.23103040e-02f, -1.17918730e-01f, 7.17705814e-03f, 1.48175478e-01f, 7.04870448e-02f, 1.54225035e-02f, -1.58962309e-01f,
  -1.20587997e-01f, -1.54089972e-01f, 8.73771086e-02f, 9.08460319e-02f, 4.18266980e-03f, 1.35449007e-01f, -1.25810608e-01f, 3.51222642e-02f, -1.65073186e-01f, 4.17016186e-02f,
  -5.67308813e-02f, -4.13031042e-01f, -2.97836095e-01f, -1.44457504e-01f, -1.74472585e-01f, -1.25355780e-01f, -4.84059118e-02f, 1.00404797e-02f, -3.39118183e-01f, -4.54313725e-01f,
  -3.64042222e-01f, -4.58893925e-01f, -4.49582219e-01f, -3.42090636e-01f, -3.11708719e-01f, -1.07193202e-01f, -2.98962563e-01f, 6.34984523e-02f, 5.64260036e-02f, -4.85433728e-01f,
  -2.33999953e-01f, 4.97116707e-02f, -1.87183723e-01f, -1.60137251e-01f, -8.98308232e-02f, -5.20451069e-01f, -4.65885460e-01f, -1.99843958e-01f, 3.12850475e-01f, 2.98546553e-01f,
  -7.59975314e-02f, -1.67517707e-01f, 3.68702374e-02f, 5.11470549e-02f, -3.50767881e-01f, -2.26362050e-01f, -4.48662102e-01f, -1.60890490e-01f, -2.52702069e-02f, -4.81335282e-01f,
  -3.14539403e-01f, 6.96000457e-02f, 2.86964357e-01f, 1.88635796e-01f, -6.41619265e-02f, 1.44994343e-02f, -1.34072274e-01f, 3.02933324e-02f, 1.31850109e-01f, 7.40912855e-02f,
  6.25861362e-02f, 9.40064341e-02f, -9.57539752e-02f, 7.00336620e-02f, 1.41098900e-02f, 2.10807651e-01f, 1.85188249e-01f, 1.03525139e-01f, -2.16257814e-02f, -1.70655698e-02f,
  1.00604802e-01f, 1.72175486e-02f, 1.80762544e-01f, 2.55644172e-01f, 2.90601760e-01f, 2.15152904e-01f, 2.26858649e-02f, 1.99919552e-01f, 2.45918438e-01f, -4.24937606e-02f,
  -1.57815233e-01f, -1.37905762e-01f, 4.74567860e-02f, 7.26295915e-03f, 6.08205190e-03f, -4.79555987e-02f, 8.51542875e-03f, -2.64319982e-02f, 7.64724240e-02f, -9.85084176e-02f,
  7.78012946e-02f, -1.69837624e-02f, -7.14193375e-05f, -1.09800428e-01f, -4.67928164e-02f, -1.63447186e-02f, -2.08510589e-02f, -3.55592580e-03f, 9.14991722e-02f, 3.26785743e-02f,
  1.46751270e-01f, 6.11899942e-02f, -4.68199477e-02f, -2.43889168e-02f, -2.31191311e-02f, -2.23320462e-02f, 9.89965275e-02f, 8.82852674e-02f, -5.40406965e-02f, 1.60073623e-01f,
  -2.18338862e-01f, 1.53788492e-01f, -2.96060771e-01f, 8.40288103e-02f, -8.13582912e-02f, 3.29791084e-02f, -4.89779152e-02f, 3.86681594e-03f, 6.60201237e-02f, 6.60237446e-02f,
  2.45988116e-01f, -5.29332794e-02f, -1.82251737e-01f, 3.64986574e-03f, -2.65042437e-03f, 4.58817333e-02f, 5.37202060e-02f, -1.05870642e-01f, 1.19834319e-01f, 3.66989188e-02f,
  8.54733735e-02f, 3.41346003e-02f, 1.24937721e-01f, -4.52078581e-02f, 2.60064229e-02f, -2.44092159e-02f, -5.27659506e-02f, 1.23436740e-02f, -1.38302937e-01f, -2.74666756e-01f,
  8.12996253e-02f, -1.14129214e-02f, -1.08279690e-01f, 1.57101363e-01f, -5.79031706e-02f, -2.03841716e-01f, -2.15557426e-01f, -1.79113626e-01f, 1.02992371e-01f, 8.46212879e-02f,
  -1.07465044e-01f, -8.18443447e-02f, 2.80063041e-02f, -1.79089874e-01f, -1.85758337e-01f, -7.20977644e-03f, 5.87055944e-02f, -1.34055838e-01f, -1.18225396e-01f, -2.22876012e-01f,
  -6.10916056e-02f, -6.18763752e-02f, -1.79618046e-01f, -6.79146722e-02f, -1.08508497e-01f, -1.44091874e-01f, -1.27096891e-01f, -7.57489130e-02f, -2.32556015e-01f, -1.55855581e-01f,
  2.46873453e-01f, -1.92269862e-01f, 1.22414500e-01f, 8.81080851e-02f, -3.50115485e-02f, 8.95849988e-02f, -4.72350344e-02f, 9.61131901e-02f, 7.00913668e-02f, 3.53477448e-02f,
  -3.01975831e-02f, -6.11883067e-02f, -6.16011284e-02f, 4.27930290e-03f, 1.52763486e-01f, 1.64405145e-02f, 7.06989132e-03f, -2.22136956e-02f, 1.01593129e-01f, 5.57520017e-02f,
  4.52981815e-02f, -6.00966699e-02f, 1.02108538e-01f, -4.01305184e-02f, -1.25623435e-01f, -6.68710247e-02f, -1.30464286e-01f, -1.17310695e-01f, -7.11237406e-03f, 5.99537939e-02f,
  -2.85324365e-01f, 5.60659915e-02f, 1.34206027e-01f, 5.67662008e-02f, 1.82855353e-01f, 1.39282092e-01f, 1.44154221e-01f, 1.86582446e-01f, -8.55697785e-03f, -6.13821670e-03f,
  1.89099863e-01f, -8.90455693e-02f, 3.08978446e-02f, 8.98440182e-02f, 6.37314990e-02f, -7.97910318e-02f, 1.79485288e-02f, 9.82459038e-02f, -2.44052224e-02f, 1.07129104e-01f,
  1.65810362e-02f, 5.07772788e-02f, 1.05800787e-02f, -3.53885926e-02f, -1.09419655e-02f, 2.74565406e-02f, -2.10084282e-02f, -2.24271029e-01f, -1.37925252e-01f, -8.42611194e-02f,
  6.29579544e-01f, -2.17065543e-01f, 5.10910042e-02f, 1.49987964e-03f, -1.23428591e-02f, 7.37248287e-02f, -7.32701719e-02f, 1.26213789e-01f, 5.54264747e-02f, 1.55411020e-01f,
  3.86539586e-02f, -1.16120927e-01f, 1.28947925e-02f, 1.38949174e-02f, 1.50434643e-01f, 5.59972860e-02f, 5.23317903e-02f, 1.57530352e-01f, 1.29648671e-01f, 9.93868485e-02f,
  1.39984623e-01f, 2.55186081e-01f, 1.34115860e-01f, 1.86146185e-01f, -2.92226523e-02f, 1.66286960e-01f, 1.18857004e-01f, 1.43566623e-01f, 1.65375248e-01f, 1.36213064e-01f,
  -6.39586210e-01f, -1.61527440e-01f, -7.78797790e-02f, 2.25742742e-01f, 3.16169620e-01f, 3.16436082e-01f, 1.61963716e-01f, 1.37980625e-01f, 2.23238513e-01f, 4.64564338e-02f,
  3.06089967e-02f, 1.01222053e-01f, 2.58922517e-01f, 1.53698295e-01f, 1.53751075e-01f, 2.60398716e-01f, 3.82873178e-01f, 1.40825123e-01f, 9.93725285e-02f, 1.41639560e-01f,
  3.02498698e-01f, 3.61527801e-02f, -2.64981598e-01f, 5.82092889e-02f, 2.25281239e-01f, 2.81606972e-01f, 1.27768070e-01f, 9.02712792e-02f, 9.58291963e-02f, 1.01710036e-01f,
  -2.48490378e-01f, -3.42085332e-01f, 1.13695592e-01f, -1.03617437e-01f, -1.51280493e-01f, -1.93894342e-01f, -4.34181988e-02f, -1.72590032e-01f, -7.71511346e-02f, -4.23342874e-03f,
  -1.92398601e-03f, -1.49096966e-01f, -8.61115381e-02f, -9.63917971e-02f, -5.33090159e-02f, -1.73872367e-01f, -8.39934275e-02f, -5.46237677e-02f, 4.11488600e-02f, -5.86519912e-02f,
  1.43317088e-01f, 1.53837666e-01f, 6.85835779e-02f, 1.76830411e-01f, 1.51782751e-01f, 1.54876187e-02f, -2.02676300e-02f, -1.13089317e-02f, 1.83297750e-02f, -7.94648156e-02f,
  3.52103978e-01f, 2.39746412e-03f, -1.06789537e-01f, 1.21257864e-01f, -3.34713757e-02f, 3.25477384e-02f, 1.07559368e-01f, 9.54213813e-02f, 1.82071492e-01f, 3.22494693e-02f,
  1.75447240e-02f, 1.29524529e-01f, 9.49597135e-02f, 7.17313662e-02f, 4.26920690e-02f, -3.51173840e-02f, 9.98839270e-03f, -8.56922641e-02f, -1.84935257e-01f, -1.17222615e-01f,
  -6.81250617e-02f, -1.20246774e-02f, -1.85571268e-01f, -7.38695711e-02f, -2.25870740e-02f, 1.99697744e-02f, 6.51301146e-02f, -7.38965720e-02f, 3.23146582e-03f, 8.25854018e-02f,
  3.26617599e-01f, 1.27304330e-01f, 3.05971354e-02f, -3.89362611e-02f, -7.83856213e-02f, -2.35414192e-01f, 9.90369022e-02f, -1.93109736e-01f, -7.97180235e-02f, 1.83290504e-02f,
  -8.50890484e-03f, -1.94386944e-01f, -1.50662854e-01f, -2.53637768e-02f, -7.21972659e-02f, 4.92908768e-02f, -8.92878696e-02f, 4.04636338e-02f, 3.20496485e-02f, 4.85787448e-03f,
  7.53356591e-02f, 2.32787177e-01f, 1.23058975e-01f, 1.37568519e-01f, 1.84791833e-01f, 2.23326489e-01f, -5.65731823e-02f, 2.05058921e-02f, 1.59271527e-02f, 1.62510425e-02f,
  7.20735610e-01f, 4.07911062e-01f, 1.40709743e-01f, 7.38433599e-02f, -1.17529696e-02f, -1.19807549e-01f, -2.61148274e-01f, -1.47673890e-01f, 2.12065578e-02f, 1.15395598e-01f,
  1.57182291e-01f, -1.21968687e-02f, 1.19121857e-02f, 8.45089480e-02f, -5.04729562e-02f, -5.91743737e-02f, 7.79521912e-02f, 8.00992027e-02f, -1.20111056e-01f, 3.24630877e-04f,
  1.68568671e-01f, 2.02341720e-01f, 2.59877264e-01f, 4.62940000e-02f, 3.19947988e-01f, 1.01510510e-01f, 7.55769610e-02f, 3.44603151e-01f, 1.97742447e-01f, 5.46250582e-01f,
  4.01009798e-01f, 3.11580509e-01f, -3.20527583e-01f, 1.39366120e-01f, 1.20144755e-01f, 1.50899112e-01f, 1.84309459e-03f, -1.47217549e-02f, 2.68600322e-02f, -3.38241272e-02f,
  6.97475448e-02f, 1.76789954e-01f, 1.08370073e-01f, 1.20173879e-01f, -1.94079448e-02f, 5.34747653e-02f, 7.06264973e-02f, 3.69291864e-02f, -1.03588454e-01f, -1.03180883e-02f,
  5.11393957e-02f, 7.25337639e-02f, -1.09424941e-01f, -1.81846172e-01f, 3.77476439e-02f, 8.57281536e-02f, -9.38465353e-03f, 9.12027508e-02f, -1.19962199e-02f, 1.90742776e-01f,
  5.18876165e-02f, 2.24234998e-01f, 1.72540367e-01f, 7.15164170e-02f, 1.31184265e-01f, -1.96124557e-02f, -3.93408313e-02f, 2.45851986e-02f, 4.84171100e-02f, 9.73746032e-02f,
  -7.21473098e-02f, -1.61626097e-02f, -8.83062556e-02f, -1.38544321e-01f, -1.72197640e-01f, 4.12426144e-02f, 1.76291257e-01f, -2.90988144e-02f, -1.45318210e-01f, -6.45612404e-02f,
  1.33615181e-01f, -7.87577964e-03f, 1.30064099e-03f, 8.14545304e-02f, -1.49538480e-02f, 9.84697491e-02f, 4.68795188e-02f, 4.23816219e-02f, 1.13917038e-01f, 1.43708019e-02f,
  -4.39454317e-01f, -3.99877161e-01f, -3.15952748e-02f, 1.93871353e-02f, 1.01545349e-01f, 9.15622562e-02f, 1.15434296e-01f, -1.12922220e-02f, 7.48958532e-03f, -1.38525590e-01f,
  -2.55385623e-03f, 3.21794525e-02f, -7.69940764e-02f, -2.69210674e-02f, -2.42231339e-01f, -6.48527592e-02f, 1.27720132e-01f, -7.90564641e-02f, -2.13198930e-01f, 3.99882309e-02f,
  -1.00850880e-01f, -3.54612201e-01f, -4.69710797e-01f, -3.60848665e-01f, -6.98214099e-02f, -2.13888258e-01f, -1.17252044e-01f, -9.23002437e-02f, -2.40640968e-01f, -1.78225532e-01f,
  -3.35801721e-01f, -3.70773017e-01f, 7.07525015e-01f, -5.21759391e-01f, -5.18574893e-01f, -3.26232940e-01f, -3.82125884e-01f, -2.99658984e-01f, -2.88886875e-01f, -3.34693670e-01f,
  -1.89134970e-01f, 2.24114746e-01f, 1.86980784e-01f, 2.98748523e-01f, 3.70631039e-01f, -1.14355981e-01f, 6.51318952e-02f, 5.22710860e-01f, 5.90000331e-01f, -4.33999635e-02f,
  -2.90471405e-01f, -2.58325934e-01f, 1.97478265e-01f, 4.60994840e-02f, -3.76095772e-01f, 1.36306182e-01f, -7.40512507e-03f, -1.92216054e-01f, -1.10608257e-01f, -2.58919269e-01f,
  2.87416041e-01f, -1.54270247e-01f, 1.27442613e-01f, -1.37813538e-01f, -1.20983034e-01f, 1.00159511e-01f, 1.66095927e-01f, -1.75091699e-02f, -2.08235141e-02f, -3.68756726e-02f,
  -1.86228037e-01f, 9.00966376e-02f, 1.64467871e-01f, 1.53644681e-01f, -1.19978800e-01f, 2.37108022e-02f, 5.01639359e-02f, 1.20325655e-01f, -5.34852743e-02f, 1.71942301e-02f,
  -1.26659632e-01f, -1.49871960e-01f, 2.54585352e-02f, 1.01862252e-01f, 4.90022823e-03f, 9.13449451e-02f, -3.97238927e-03f, 6.04500137e-02f, 1.28737167e-01f, -1.39985889e-01f,
  -5.09117614e-04f, 1.53482407e-01f, -1.01447463e-01f, 9.31930244e-02f, -1.06777642e-02f, -9.09641758e-03f, 1.13799833e-01f, -1.40170651e-02f, 1.18806295e-01f, 2.93944660e-03f,
  1.20164081e-01f, -1.00623146e-01f, 9.40585788e-03f, -4.25166562e-02f, -2.99718343e-02f, -6.44912943e-02f, -1.22050196e-02f, -5.84108569e-02f, 1.34867067e-02f, -1.55964151e-01f,
  5.75920232e-02f, -5.01767583e-02f, -5.86497448e-02f, 2.40446515e-02f, -7.41013363e-02f, 6.08493276e-02f, -3.21595483e-02f, -3.08083817e-02f, 2.72310786e-02f, -3.92011106e-02f,
  8.90593007e-02f, 7.01279938e-02f, -1.27820015e-01f, -4.31315154e-02f, -6.15500882e-02f, -1.13846131e-01f, 1.41929360e-02f, 1.79623123e-02f, -1.28319748e-02f, 8.98981094e-03f,
  -9.30170193e-02f, 1.64881870e-02f, 1.49713475e-02f, 4.02256958e-02f, -8.71787686e-03f, -9.65520144e-02f, -8.26430619e-02f, 1.76212844e-02f, -1.34538591e-01f, -1.27169535e-01f,
  -4.26911376e-02f, -1.34658068e-02f, 2.09243700e-01f, 3.17875892e-02f, -2.17076361e-01f, 2.16516063e-01f, 2.26220071e-01f, 5.95598929e-02f, 1.39168680e-01f, -1.12090826e-01f,
  7.15927184e-01f, 2.40023226e-01f, 2.69658804e-01f, 2.06821471e-01f, 2.36651793e-01f, 2.75024295e-01f, 3.11717719e-01f, 2.79233009e-01f, 1.52905375e-01f, 1.57737210e-01f,
  1.47862151e-01f, 6.15050457e-02f, 1.28101557e-01f, 4.53488639e-04f, 1.63301006e-01f, 3.94613370e-02f, -1.27862900e-01f, 3.53011186e-04f, 8.43214095e-02f, 9.75204706e-02f,
  -1.24455936e-01f, -2.35291906e-02f, 5.71721699e-03f, 7.34243216e-03f, -1.78253546e-01f, -2.00064138e-01f, -7.92706460e-02f, 4.62204171e-03f, -7.86881968e-02f, -2.11344272e-01f,
  2.44165212e-01f, 3.35848957e-01f, 2.38766670e-02f, -2.54106484e-02f, 2.45796368e-02f, 4.97517921e-02f, 8.59340932e-03f, -3.87938283e-02f, 2.11843215e-02f, -1.21196369e-02f,
  -4.74123721e-04f, 1.01248898e-01f, 1.41651481e-01f, 4.30876017e-02f, 3.34138088e-02f, -3.71688679e-02f, -6.45863637e-02f, 6.92945719e-02f, 7.59213651e-03f, 9.59053868e-04f,
  -2.24134848e-02f, 5.36856316e-02f, 3.31855156e-02f, 1.05027452e-01f, 9.94603485e-02f, 6.78484291e-02f, -4.58933152e-02f, 2.69227251e-02f, 1.01810351e-01f, -5.87096177e-02f,
  1.90335512e-01f, -8.39550793e-03f, 5.60628995e-02f, 2.42187474e-02f, 3.32505093e-03f, 2.21980568e-02f, -1.27883330e-02f, -1.32505745e-01f, 1.26926098e-02f, -5.11210300e-02f,
  -1.67551897e-02f, 6.91369548e-02f, 1.89984560e-01f, -1.38205513e-02f, -6.25337437e-02f, -2.20723376e-02f, 6.14007823e-02f, 6.58012107e-02f, 6.25023246e-03f, -6.76198676e-02f,
  8.91945139e-02f, 4.50529046e-02f, 1.25664458e-01f, -5.48432842e-02f, 9.59125534e-02f, -3.97298224e-02f, -4.94740997e-03f, -3.66125107e-02f, -1.07965201e-01f, -6.02695048e-02f,
  3.97494771e-02f, 5.11065483e-01f, -6.27562702e-02f, -1.63250327e-01f, 3.64702265e-03f, -4.46005464e-02f, 8.74922201e-02f, 8.37856345e-03f, -1.65604372e-02f, -6.32406101e-02f,
  -4.51921672e-02f, -1.18685532e-02f, 9.77328867e-02f, -3.65931541e-03f, -1.93762392e-01f, -9.65946168e-02f, 3.00846640e-02f, 1.93947516e-02f, -6.04159338e-03f, -1.64912552e-01f,
  -1.21311679e-01f, -1.86808892e-02f, 3.42479013e-02f, 6.39520139e-02f, 2.79453080e-02f, 6.65713772e-02f, -1.29692942e-01f, -8.51299092e-02f, 1.17907174e-01f, -2.05855429e-01f,
  -6.13589883e-01f, 2.83202976e-01f, 6.66097039e-03f, -1.96290880e-01f, 1.07905708e-01f, 2.68844575e-01f, 4.54379290e-01f, 1.35590568e-01f, -1.43630370e-01f, 1.34288549e-01f,
  -2.77690999e-02f, -1.52417183e-01f, -3.67046148e-02f, -2.64885016e-02f, -7.59947374e-02f, 3.84773910e-01f, 3.68765473e-01f, -8.48256722e-02f, -2.54254758e-01f, -1.09224714e-01f,
  6.33076280e-02f, -2.49661490e-01f, -3.91578287e-01f, -1.79133192e-01f, 1.11092336e-01f, 3.28199640e-02f, 1.24512464e-02f, -4.11424413e-03f, 1.27780318e-01f, 4.78843272e-01f,
  -2.24964350e-01f, -6.70428276e-02f, 1.58913478e-01f, -2.17206612e-01f, -7.47079477e-02f, -4.77282330e-02f, 6.19040765e-02f, 6.45276085e-02f, 4.03718054e-02f, 1.12845443e-01f,
  7.61860013e-02f, 1.26807755e-02f, 1.43805310e-01f, 8.29930082e-02f, -1.37018576e-01f, -3.76711488e-02f, -7.12406216e-03f, 6.28497675e-02f, -3.11857890e-02f, -1.91988032e-02f,
  4.08900946e-01f, -1.45637840e-01f, -3.38256270e-01f, 8.49940032e-02f, 8.37714449e-02f, -3.62161249e-01f, -1.16711199e-01f, -3.48483585e-02f, -2.70273685e-01f, -1.36060938e-01f,
  -1.33156225e-01f, 2.49417629e-02f, 2.06148773e-01f, 2.76648831e-02f, -3.82047407e-02f, 6.29912391e-02f, 2.05456376e-01f, 7.30364546e-02f, -2.23644581e-02f, -5.43350689e-02f,
  8.65397453e-02f, -9.67724249e-02f, -1.17451446e-02f, -7.24749565e-02f, -1.09194294e-01f, -3.05729005e-02f, 7.13909045e-02f, 1.52821979e-02f, -1.16974145e-01f, 1.80118829e-02f,
  -2.99982969e-02f, 2.39556935e-02f, -1.17620550e-01f, 1.65582076e-01f, 1.11476786e-01f, -2.82849427e-02f, -5.07168844e-02f, -7.38991946e-02f, -3.55610773e-02f, -1.55080467e-01f,
  -3.51712167e-01f, -2.22430285e-02f, -1.23685971e-01f, 5.99697940e-02f, -1.18448474e-01f, -2.10042372e-01f, -6.18795827e-02f, 5.93576655e-02f, -9.29731131e-02f, 7.01393932e-02f,
  2.85410080e-02f, -1.54854832e-02f, -1.18530586e-01f, 1.34608811e-02f, -1.54029839e-02f, 9.76095572e-02f, 1.85858533e-01f, 1.22736551e-01f, -4.19424884e-02f, 8.25687796e-02f,
  1.56167075e-01f, -1.53581455e-01f, -1.90534964e-01f, 9.01555642e-02f, -5.76479733e-03f, -4.74232912e-01f, -1.80343792e-01f, -2.97950089e-01f, -2.95082271e-01f, -2.98560083e-01f,
  -1.20637596e-01f, -1.81284130e-01f, -1.15563953e-03f, -5.18801287e-02f, -3.03976331e-02f, -5.85030839e-02f, -5.67666553e-02f, -6.75565004e-02f, -8.86650980e-02f, -2.14624479e-01f,
  -2.16114148e-01f, -5.13444990e-02f, -5.64604290e-02f, -1.07305154e-01f, 5.18436208e-02f, -1.20391592e-01f, -2.63862759e-02f, 1.18046880e-01f, 3.10872775e-02f, -1.70582205e-01f,
  -8.71136859e-02f, -2.57769257e-01f, -2.52161503e-01f, -9.85310972e-02f, -1.37617007e-01f, -5.87435998e-02f, -2.44154096e-01f, -1.53862715e-01f, -2.63768017e-01f, -1.40784919e-01f,
  3.87403548e-01f, -2.58833230e-01f, 1.52769908e-01f, 5.63687570e-02f, -1.66300964e-02f, -4.14846651e-02f, -2.85770800e-02f, 3.12616006e-02f, 9.23507959e-02f, 8.74070972e-02f,
  2.27032453e-02f, 8.30833986e-03f, -1.30625255e-02f, -1.07192686e-02f, 3.63470577e-02f, -8.04715082e-02f, -1.04614183e-01f, 1.55382808e-02f, -1.04162723e-01f, -4.18700203e-02f,
  -7.49043822e-02f, 8.63999575e-02f, 9.48666632e-02f, -2.07797810e-02f, -1.89993829e-02f, 1.63539015e-02f, -6.79188669e-02f, -6.63073659e-02f, 9.03302878e-02f, 3.10044922e-02f,
  1.13930278e-01f, 4.63189296e-02f, -1.30615711e-01f, -4.17023562e-02f, -1.58944447e-02f, -2.09630817e-01f, -7.93249756e-02f, -5.17179444e-02f, 1.39029499e-03f, -9.62270275e-02f,
  -8.42856392e-02f, -7.86264241e-02f, -1.47654891e-01f, 1.93333894e-03f, -1.15882494e-01f, -1.24570303e-01f, -2.97131594e-02f, 4.05542850e-02f, -4.12788764e-02f, -1.52190492e-01f,
  1.65644828e-02f, 3.41279879e-02f, 4.75369114e-03f, -8.00937340e-02f, -1.15300991e-01f, -2.84158532e-02f, -3.60200107e-02f, -1.90405473e-01f, -4.64518555e-02f, 1.79515108e-02f,
  4.99939412e-01f, 5.12945727e-02f, 1.48841172e-01f, 1.32838219e-01f, 7.08280057e-02f, -6.70532882e-02f, 2.40872055e-02f, 1.25621604e-02f, 1.40731364e-01f, 1.59898609e-01f,
  2.78628394e-02f, 4.79914472e-02f, 3.30593772e-02f, -5.43004721e-02f, 1.26359940e-01f, 1.04913428e-01f, -2.12294981e-02f, 1.28280655e-01f, 4.64320406e-02f, 1.10001549e-01f,
  -1.50606111e-02f, 1.59529909e-01f, 2.20412895e-01f, 1.13491848e-01f, 1.77037090e-01f, 2.69152552e-01f, 1.89877838e-01f, 1.76017523e-01f, 2.31400266e-01f, 3.84071916e-02f,
  9.43180442e-01f, -3.98175746e-01f, 1.41437780e-02f, 2.94165939e-01f, 7.97090754e-02f, 1.87675729e-01f, -1.35556921e-01f, 6.15461171e-03f, 9.64999869e-02f, -1.18508311e-02f,
  2.03045145e-01f, 2.50503033e-01f, 2.53084123e-01f, 1.15661263e-01f, 1.57988459e-01f, -4.09198701e-02f, -3.82493846e-02f, 1.33336812e-01f, 3.16604316e-01f, 1.68440998e-01f,
  -1.16236746e-01f, -1.03646137e-01f, 6.47586212e-02f, -2.66225934e-02f, -1.87025502e-01f, -1.57001205e-02f, -6.71544373e-02f, -1.83170438e-01f, -7.88594112e-02f, -2.05525354e-01f,
  -1.59239888e-01f, 1.37487143e-01f, 2.63515443e-01f, 1.70874484e-02f, -4.56843153e-02f, 2.35838033e-02f, 4.49693426e-02f, -1.28464669e-01f, -1.73020791e-02f, -1.69790819e-01f,
  -3.24522816e-02f, 2.60522608e-02f, -4.97523211e-02f, -7.63641298e-02f, -1.46240741e-01f, -2.13769544e-02f, -7.10568577e-02f, -2.26433296e-02f, -1.50838774e-02f, -1.37307504e-02f,
  -1.32445782e-01f, 7.51081035e-02f, 5.03175706e-02f, 4.15518545e-02f, 6.28572926e-02f, 1.36810258e-01f, -3.16582993e-02f, -1.15602754e-01f, 1.08948266e-02f, -3.09943967e-02f,
  2.65429407e-01f, 5.44161350e-02f, -7.97547027e-02f, 1.13993794e-01f, -1.85528584e-02f, 1.18758112e-01f, 7.00449571e-02f, 6.09776117e-02f, 1.01022780e-01f, -6.93682879e-02f,
  1.39059860e-03f, 8.57704207e-02f, -3.12703568e-03f, 1.44246429e-01f, 5.03445752e-02f, 3.02250031e-03f, -4.01380174e-02f, -9.64348763e-02f, 3.24169360e-02f, -8.48320499e-02f,
  7.89536610e-02f, -4.75752614e-02f, -7.07007945e-02f, -2.09154949e-01f, -7.93865174e-02f, -2.73743533e-02f, -4.57960330e-02f, -1.53011546e-01f, -1.06602199e-02f, -5.07051237e-02f,
  -4.37095165e-01f, 2.67211646e-01f, 2.01805040e-01f, 3.89489196e-02f, -6.78247213e-03f, -4.15916368e-02f, 2.25170027e-03f, -1.68793593e-02f, -9.73066688e-02f, -4.82972302e-02f,
  -1.72278937e-02f, -3.60803641e-02f, -1.61021620e-01f, -1.61407411e-01f, 1.30076051e-01f, 2.25085393e-02f, -3.47310454e-02f, 2.07248122e-01f, -2.34827176e-02f, -2.48969886e-02f,
  -1.21873707e-01f, 1.03175677e-01f, 2.87910581e-01f, 2.36284107e-01f, 9.25986394e-02f, 3.24892730e-01f, -2.20012348e-02f, -7.89049938e-02f, 1.53632432e-01f, 1.67108215e-02f,
  5.06128728e-01f, -2.09183007e-01f, 1.53633729e-01f, 2.24819973e-01f, 3.91299605e-01f, 3.91776919e-01f, 5.44415891e-01f, 3.07970673e-01f, 1.24669082e-01f, -7.52735930e-03f,
  -2.38936678e-01f, -4.19304907e-01f, -3.68289739e-01f, -4.15106893e-01f, -2.20765725e-01f, 1.99541971e-01f, 1.88444123e-01f, 1.10407375e-01f, 4.27150764e-02f, 1.54824331e-02f,
  -9.70115811e-02f, 2.19299302e-01f, 1.64040178e-01f, -4.67821844e-02f, 4.98432145e-02f, -1.43399179e-01f, 1.63238987e-01f, -1.00408159e-02f, -9.79105234e-02f, -2.03425422e-01f,
  -4.50183511e-01f, 1.51879355e-01f, -9.76443589e-02f, -1.74459681e-01f, -1.00877628e-01f, -2.05003121e-03f, -6.16579279e-02f, -1.30219877e-01f, 6.13371423e-03f, 5.67034259e-02f,
  -9.68717262e-02f, -1.42959818e-01f, -8.07241946e-02f, 3.37803178e-02f, 2.24961773e-01f, 1.58399343e-01f, -1.24938972e-01f, -6.17709197e-02f, -2.22267628e-01f, -1.66428000e-01f,
  -3.10827851e-01f, 2.00049821e-02f, 8.53127241e-02f, 3.29152681e-02f, -9.00571346e-02f, -1.09005742e-01f, -9.17768553e-02f, -1.53068127e-03f, 1.64208505e-02f, -5.35518490e-02f,
  1.21252649e-02f, -1.30440682e-01f, -1.03597149e-01f, -1.28639694e-02f, -2.70924345e-03f, -1.59198679e-02f, 4.23501134e-02f, -7.25465873e-03f, -4.90143485e-02f, 1.94872767e-02f,
  -1.10186592e-01f, -4.18440327e-02f, -1.73331782e-01f, -1.80797037e-02f, -1.46764725e-01f, -8.74837637e-02f, -4.35100757e-02f, -1.40283242e-01f, -1.45250648e-01f, -7.88828582e-02f,
  -8.08346346e-02f, 1.30923986e-01f, 1.22869313e-02f, -1.46518365e-01f, -3.70882675e-02f, -1.49310604e-01f, -1.31727174e-01f, -1.42933771e-01f, 1.16579130e-01f, 1.22152418e-01f,
  -3.55783790e-01f, -2.66637832e-01f, -1.34616137e-01f, -1.78068981e-01f, 8.44135433e-02f, -1.27384916e-01f, -8.06410834e-02f, -4.63570002e-03f, -2.52856892e-02f, 3.44782248e-02f,
  4.55575809e-02f, -4.03985791e-02f, -5.44419251e-02f, 1.07313186e-01f, 1.73663557e-01f, 1.64082482e-01f, -7.56574720e-02f, -1.18509315e-01f, -1.08728874e-02f, -5.35359867e-02f,
  -8.76437202e-02f, 1.76612198e-01f, 1.93897501e-01f, -2.89397482e-02f, 1.67479888e-02f, 7.84189254e-02f, 3.69775444e-02f, 1.03583783e-01f, 1.47980586e-01f, 2.62449235e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.69559720e-02f, 2.01692984e-01f, 3.81730318e-01f, 2.28234932e-01f, 1.88943386e-01f, 7.85293132e-02f, 2.30522722e-01f, 4.43890393e-01f, 6.84471667e-01f, 3.04019362e-01f,
  2.45371997e-01f, -8.56089368e-02f, 1.47143051e-01f, 4.44101453e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.76702692e-02f, 1.77505597e-01f, 5.57163134e-02f, -6.17772900e-03f, -1.23018548e-01f, 6.21256977e-02f, -1.38787135e-01f, -7.19432533e-02f, 2.09941044e-02f, -1.52082350e-02f,
  6.93850368e-02f, 1.04186773e-01f, 7.45408535e-02f, -2.00817555e-01f, -5.07956259e-02f, -6.17382489e-02f, 1.53059751e-01f, 7.61886686e-02f, 9.42325071e-02f, 8.37082192e-02f,
  1.06356680e-01f, 7.35207349e-02f, 1.29518107e-01f, 5.99409174e-03f, -1.58343837e-02f, 9.85495374e-02f, -1.25243634e-01f, 8.71597901e-02f, -4.45669889e-02f, 1.30251899e-01f,
  2.62985587e-01f, 7.84720853e-02f, 7.65082985e-02f, -1.84829589e-02f, -3.55341658e-03f, -5.54501303e-02f, 8.57229680e-02f, -1.60376370e-01f, -1.47932116e-02f, -1.81869298e-01f,
  1.06446981e-01f, 1.84454229e-02f, 4.35880162e-02f, -1.75290242e-01f, 2.29517981e-01f, 4.97685969e-02f, -7.10660815e-02f, -1.82172880e-01f, -6.70052692e-02f, -1.20099641e-01f,
  -2.51180470e-01f, -2.30305552e-01f, -2.15686888e-01f, -3.68156023e-02f, -3.56004328e-01f, 4.56921197e-02f, 7.94077665e-02f, -1.28101349e-01f, 3.84011686e-01f, 1.02006733e-01f,
  1.60173148e-01f, 6.72675744e-02f, 1.66027397e-02f, 2.33956143e-01f, -2.24040672e-01f, -8.74789357e-02f, 5.17332815e-02f, 4.68288921e-03f, -6.98189139e-02f, -5.49850203e-02f,
  -1.10116191e-01f, -3.45601998e-02f, -1.06433131e-01f, -1.38820991e-01f, -7.71117583e-02f, 8.02483596e-03f, 4.07628603e-02f, 6.27363399e-02f, -9.69248340e-02f, -3.04915514e-02f,
  1.50472345e-02f, -4.24469188e-02f, -3.17429006e-02f, -1.75327495e-01f, -2.17424929e-02f, -8.07893872e-02f, -4.51554060e-02f, 1.61369160e-01f, -1.09034359e-01f, -5.71743138e-02f,
  6.15713410e-02f, -8.19258690e-02f, 8.38444233e-02f, 5.74127287e-02f, 5.35656735e-02f, -5.36270142e-02f, -6.22404218e-02f, -1.26825541e-01f, -1.79883122e-01f, 2.31419414e-01f,
  -1.14007466e-01f, 8.10125396e-02f, -5.69062904e-02f, 1.92939088e-01f, 4.01725024e-02f, -2.03908626e-02f, 1.22431353e-01f, 3.18157971e-02f, 1.00187078e-01f, -1.06128510e-02f,
  -4.62504588e-02f, -6.90262243e-02f, -1.44345369e-02f, -3.30994762e-02f, 3.03485066e-01f, 1.00649871e-01f, 1.82810694e-01f, -5.33842206e-01f, -1.21135980e-01f, 1.28270788e-02f,
  -9.24330652e-02f, -2.55883858e-02f, -3.81258994e-01f, 1.24971658e-01f, -1.72439605e-01f, -2.15610951e-01f, -2.31761023e-01f, 1.39568105e-01f, 4.95869741e-02f, 1.00427484e-02f,
  -8.99390206e-02f, -1.97617766e-02f, 7.21643819e-03f, 7.07597062e-02f, -3.48107927e-02f, -3.93059589e-02f, 1.43375695e-02f, -1.31709829e-01f, 2.30074208e-02f, 5.40779019e-03f,
  1.09896287e-02f, -6.47619292e-02f, -4.88055497e-03f, 9.03100371e-02f, 1.30811825e-01f, -7.82800280e-03f, 7.88755566e-02f, -3.84513959e-02f, 4.53058891e-02f, -9.48462933e-02f,
  -9.10800546e-02f, -7.33408425e-03f, -6.78549185e-02f, -8.91369209e-03f, 6.87814504e-03f, 8.29122886e-02f, -3.91819067e-02f, 2.67031770e-02f, 1.30534451e-02f, 9.63505134e-02f,
  -8.11963901e-02f, 1.57320611e-02f, 5.40235871e-03f, -5.50794937e-02f, 3.61845866e-02f, -6.73380122e-02f, -1.04284011e-01f, 3.48558314e-02f, 7.37791806e-02f, 2.85324138e-02f,
  6.30292520e-02f, 2.30394825e-02f, -1.98698007e-02f, -1.23223923e-01f, 8.76112506e-02f, -6.24324866e-02f, 7.51966909e-02f, 1.39063643e-02f, -1.35857657e-01f, -1.39595151e-01f,
  -2.23424375e-01f, 2.39398867e-01f, -1.92908585e-01f, -8.00075009e-02f, 4.69509214e-02f, 2.35704541e-01f, 1.75391719e-01f, -6.50342256e-02f, 2.90315807e-01f, -3.11254323e-01f,
  4.39908169e-02f, -1.58184558e-01f, 8.36560577e-02f, 8.32443014e-02f, 1.16589844e-01f, 4.82521346e-03f, -6.47351742e-02f, -4.04906347e-02f, -3.67203131e-02f, -6.80150166e-02f,
  -1.71176568e-02f, -9.04969200e-02f, 9.90167912e-03f, 5.13242967e-02f, -2.63279793e-03f, -1.37794465e-01f, 8.46927837e-02f, 3.88892666e-02f, -5.35350926e-02f, -1.76441334e-02f,
  -5.58021441e-02f, 5.01349680e-02f, -9.98876020e-02f, 8.76869932e-02f, 5.40462285e-02f, -9.32925418e-02f, -1.16511710e-01f, 1.59249380e-01f, -4.14674394e-02f, 1.75207302e-01f,
  -5.54375276e-02f, 2.47334763e-01f, 1.04341302e-02f, -6.20924085e-02f, 2.18668044e-01f, 1.54281497e-01f, 2.08593294e-01f, -2.49341458e-01f, -9.95748118e-03f, -1.67653888e-01f,
  -1.04639329e-01f, -4.62235399e-02f, 5.09431539e-03f, 1.16538160e-01f, -2.63196409e-01f, -1.69851538e-02f, -1.61791906e-01f, -3.13385129e-02f, -1.22610994e-01f, -4.07019295e-02f,
  -6.44357726e-02f, -5.00346310e-02f, -1.30477399e-01f, -6.37420714e-02f, -3.90867233e-01f, 2.24843487e-01f, -3.24213542e-02f, 5.38846664e-02f, 1.31166980e-01f, -1.31186739e-01f,
  3.25161010e-01f, -1.74542978e-01f, 1.44029096e-01f, 1.89885482e-01f, 1.22554079e-01f, -1.22825995e-01f, 1.42299041e-01f, -5.40570803e-02f, -3.64143751e-03f, -3.85219418e-02f,
  -3.12808380e-02f, -8.52531642e-02f, 2.98495945e-02f, 3.16233188e-02f, 5.78683577e-02f, 2.98907924e-02f, 3.47073004e-02f, -3.33689302e-01f, 7.85601288e-02f, 7.88074434e-02f,
  -8.10756460e-02f, -1.44640416e-01f, -2.70737201e-01f, -1.36144102e-01f, -1.79006636e-01f, -3.36496830e-02f, -3.77557985e-02f, 4.40155268e-02f, -7.67844543e-02f, 6.10903539e-02f,
  -2.81573255e-02f, 7.82967508e-02f, 5.55517338e-03f, 3.95962186e-02f, 1.57855347e-01f, 4.77677248e-02f, 8.03863406e-02f, -4.77834195e-02f, -1.12275325e-01f, 3.78949493e-02f,
  2.04810530e-01f, -8.46558586e-02f, 1.59086481e-01f, -7.72712454e-02f, 2.26766076e-02f, -9.38923135e-02f, 8.77706856e-02f, 8.48503876e-03f, -2.89867252e-01f, 2.43987069e-01f,
  -5.16935065e-02f, 3.20090428e-02f, 7.97251016e-02f, -3.39860879e-02f, 1.90186948e-01f, 9.88927204e-03f, 3.75359543e-02f, 3.03685486e-01f, -4.81567867e-02f, -1.61152929e-01f,
  4.05447960e-01f, -2.53500670e-01f, -1.35346994e-01f, -1.85291041e-02f, 4.13055569e-02f, 1.44725978e-01f, -1.84980735e-01f, -1.55989617e-01f, 1.24833345e-01f, 4.39907378e-03f,
  8.66232812e-03f, 4.69994098e-02f, -3.43600214e-01f, -1.43544838e-01f, -7.78276473e-02f, -5.37342206e-02f, -6.52752444e-02f, 2.76288092e-02f, 3.07835750e-02f, -5.81929125e-02f,
  3.71371023e-02f, 2.85820402e-02f, 5.65374941e-02f, -1.99566990e-01f, 1.38705764e-02f, -6.71529397e-02f, -2.22664043e-01f, 1.62440930e-02f, -2.56446540e-01f, -9.78771970e-02f,
  -9.44593772e-02f, -1.20351702e-01f, 9.62851197e-03f, 3.75016145e-02f, -1.27627909e-01f, -2.86527663e-01f, -1.88645244e-01f, -1.98767737e-01f, 8.11077841e-03f, -5.99946640e-02f,
  2.51748245e-02f, -6.25258461e-02f, 1.19181208e-01f, 1.03011973e-01f, 3.92397940e-01f, -3.53649050e-01f, 1.43541381e-01f, 5.25009558e-02f, 4.02929820e-02f, 1.03979826e-01f,
  -2.84513365e-02f, -2.06752017e-01f, -6.16094396e-02f, -3.09917554e-02f, -1.83784917e-01f, -2.00789899e-01f, 9.36192423e-02f, -1.47402883e-01f, 7.38364384e-02f, -1.57085657e-01f,
  1.07950702e-01f, 5.56029640e-02f, 1.72279985e-03f, -3.42573285e-01f, 3.11056729e-02f, -1.75526693e-01f, 2.33286947e-01f, -2.88438380e-01f, 1.87748641e-01f, -1.44815490e-01f,
  2.83119291e-01f, 7.98795465e-03f, -3.33378278e-02f, -1.34168938e-01f, -3.13703060e-01f, 7.20494241e-02f, -2.99928665e-01f, -8.63643512e-02f, 8.59571435e-03f, -8.11664537e-02f,
  -9.01776031e-02f, 1.89493701e-01f, 9.02625546e-03f, -1.59374505e-01f, 4.21350040e-02f, 1.06019825e-01f, -9.98971984e-02f, -1.72461659e-01f, 2.44639516e-02f, 1.01104500e-02f,
  -7.07299560e-02f, -7.10830688e-02f, -6.28155768e-02f, -7.21424818e-02f, -6.54991195e-02f, -1.64511036e-02f, -6.07382646e-03f, 1.00530781e-01f, -7.85264298e-02f, -1.88304558e-01f,
  -7.05991462e-02f, -2.58019306e-02f, -1.53392553e-01f, -5.07709794e-02f, 1.55786097e-01f, 6.37553409e-02f, 9.69292670e-02f, 1.15374014e-01f, 7.97488540e-03f, -6.59385920e-02f,
  8.93757567e-02f, -8.72998312e-02f, -1.19625166e-01f, 2.63420921e-02f, -1.71057023e-02f, -1.43597960e-01f, 1.94099754e-01f, -2.13651091e-01f, -1.06804140e-01f, -1.31519675e-01f,
  1.26658216e-01f, -3.84784602e-02f, -1.60649523e-01f, -8.67189914e-02f, -2.06140056e-01f, -7.32233450e-02f, -1.43577307e-01f, -7.84420893e-02f, -1.33668236e-03f, -9.06934068e-02f,
  -2.89594848e-02f, 5.29695190e-02f, -3.07865683e-02f, -2.17357486e-01f, 2.76418149e-01f, 5.08068828e-03f, -2.24063754e-01f, 2.50031650e-02f, 1.58607543e-01f, 4.94606420e-03f,
  -4.99819256e-02f, 7.49565586e-02f, -1.95278553e-04f, -2.96082105e-02f, 8.84599313e-02f, -5.97176813e-02f, 1.25725791e-02f, -2.95376517e-02f, 1.46468624e-01f, -2.17639077e-02f,
  6.39862344e-02f, 1.45459801e-01f, 1.91707313e-02f, -5.92742935e-02f, -1.38009876e-01f, -3.05132009e-03f, -2.04277247e-01f, 8.50143209e-02f, 1.19896449e-01f, 3.29580046e-02f,
  1.31705590e-03f, -2.92732511e-02f, -8.38119164e-02f, -4.78923731e-02f, -1.48019210e-01f, -9.04170498e-02f, 6.14236556e-02f, 1.69121668e-01f, 1.16928788e-02f, -1.01691447e-01f,
  4.95973863e-02f, 1.33748457e-01f, 3.57235849e-01f, -2.30436116e-01f, 1.52794003e-01f, -7.80449957e-02f, -7.70764798e-02f, -4.36662398e-02f, -3.39712948e-02f, 1.57115817e-01f,
  -2.05767453e-01f, 2.13293105e-01f, 1.10418245e-01f, 6.73153549e-02f, 2.09396565e-03f, -1.30261943e-01f, -1.19849026e-01f, -6.26967400e-02f, 2.57585377e-01f, -6.46020472e-02f,
  -3.43640074e-02f, -2.13211089e-01f, -1.22850716e-01f, 1.84782282e-01f, 1.03572369e-01f, -1.75706238e-01f, -4.97411974e-02f, 7.08348751e-02f, -1.67753041e-01f, 2.90484577e-01f,
  2.04696432e-01f, 6.19982369e-03f, -6.83627650e-02f, 1.43819511e-01f, -1.59140900e-01f, 8.71040970e-02f, 7.65197948e-02f, 2.05993354e-01f, 9.66236070e-02f, 1.48462087e-01f,
  -6.77632987e-02f, 1.39578015e-01f, 9.58675519e-02f, -1.54450014e-01f, 1.82448775e-01f, 1.21006332e-01f, 2.27232128e-02f, 1.00218758e-01f, -8.41168873e-03f, -1.21049628e-01f,
  -1.11435890e-01f, -2.81481687e-02f, 1.36831954e-01f, 1.17466085e-01f, 9.63766575e-02f, -9.64109786e-03f, -1.88407376e-02f, 3.47161852e-02f, -9.26968083e-02f, 8.34789202e-02f,
  2.93223374e-02f, -1.09183252e-01f, -6.09694514e-04f, 1.52540952e-01f, -4.00881395e-02f, -6.09958768e-02f, -4.73531261e-02f, 1.14797533e-01f, 1.77959278e-01f, 2.20720053e-01f,
  -1.35131031e-01f, 1.59472674e-01f, -1.19974181e-01f, -3.11098367e-01f, 2.49471869e-02f, 1.53736338e-01f, -1.50617987e-01f, 7.10712862e-04f, 1.12266489e-03f, 1.35120675e-01f,
  7.92536363e-02f, 1.00762084e-01f, 3.46453071e-01f, -7.05685606e-03f, 1.96126625e-01f, 8.08811039e-02f, 2.84042627e-01f, 1.65585741e-01f, 3.88256758e-02f, -1.40866220e-01f,
  -1.97915763e-01f, 1.23058362e-02f, -7.50617981e-02f, -4.64990437e-02f, 1.00994774e-03f, -2.01789692e-01f, 1.71592571e-02f, -3.84167284e-02f, -2.05665417e-02f, -8.23333114e-02f,
  2.16577463e-02f, -5.30105494e-02f, -1.34468168e-01f, 7.07617104e-02f, 6.29850104e-02f, 4.77553532e-02f, 2.01186864e-03f, 6.79911813e-03f, 5.25026396e-02f, 1.94752321e-01f,
  3.23510543e-02f, -4.35572416e-02f, -1.37910381e-01f, -7.43895955e-03f, -5.64265512e-02f, -5.84873222e-02f, -8.06567259e-03f, 7.41243586e-02f, -1.08077563e-03f, 1.11496486e-02f,
  -2.07564724e-03f, -8.11794102e-02f, -8.63159746e-02f, -2.38946721e-01f, -7.79437944e-02f, -1.10785976e-01f, 8.92891437e-02f, -7.69684687e-02f, -1.29011363e-01f, -1.51603028e-01f,
  -4.70119677e-02f, 2.02647492e-01f, 3.92897695e-01f, -5.22899330e-02f, 1.40399076e-02f, -6.33391663e-02f, -3.87122929e-02f, -2.75111139e-01f, 3.67174633e-02f, 1.65198699e-01f,
  -1.81831434e-01f, 3.03109572e-03f, 1.81798816e-01f, 1.80824980e-01f, 9.48756263e-02f, 8.70138258e-02f, 1.28366292e-01f, -1.39707878e-01f, 2.00499937e-01f, -3.28670174e-01f,
  -1.80417821e-02f, 7.07496479e-02f, 3.17741334e-02f, -2.38456011e-01f, -4.37565565e-01f, 1.98764324e-01f, -3.69834363e-01f, -1.75902098e-02f, 2.86340285e-02f, -2.19346419e-01f,
  8.51579532e-02f, 3.13042151e-03f, -1.08125143e-01f, -1.26569211e-01f, -4.98327846e-03f, -4.47574183e-02f, 8.52837712e-02f, -1.65146906e-02f, 6.81167915e-02f, 1.55858053e-02f,
  -2.17153609e-01f, 1.31354943e-01f, -3.40265632e-02f, 9.28625241e-02f, 7.09909052e-02f, -1.83389693e-01f, 2.06725329e-01f, -7.01444820e-02f, 2.22569015e-02f, -2.00444862e-01f,
  -1.07442245e-01f, -2.46177465e-01f, 5.03656603e-02f, 1.06076682e-02f, 1.66984469e-01f, 1.49357151e-02f, -1.26004919e-01f, -1.55305788e-01f, 1.98775977e-01f, -2.93495655e-01f,
  -2.65735537e-02f, 3.14339668e-01f, -3.43122035e-02f, 1.59599870e-01f, -1.56915456e-01f, 2.76301116e-01f, -2.13897586e-01f, 9.71615240e-02f, -1.13860294e-01f, 2.13330850e-01f,
  8.42578709e-02f, -3.23631167e-02f, 2.65209842e-02f, 8.52958038e-02f, 1.58497632e-01f, -1.83988944e-01f, -1.65204972e-01f, 9.30419341e-02f, 7.51367062e-02f, 1.62776932e-02f,
  2.64576048e-01f, 6.86422214e-02f, 2.17240795e-01f, 2.97069788e-01f, -2.00366095e-01f, -1.06915377e-01f, -1.44190341e-01f, -2.45638173e-02f, 6.73280135e-02f, 6.13606069e-03f,
  -3.11687976e-01f, -2.82576159e-02f, -2.50397120e-02f, -3.08823436e-01f, -4.76269312e-02f, 2.62706559e-02f, -1.28453020e-02f, -1.06160231e-01f, -1.50384307e-01f, -1.00970261e-01f,
  3.37041449e-03f, -6.14122786e-02f, -4.14241776e-02f, -1.34613439e-01f, -1.01284295e-01f, 1.11030526e-01f, 5.90329245e-03f, -3.33236605e-02f, 1.39343947e-01f, -1.78441644e-01f,
  2.98782557e-01f, 6.46203756e-02f, 2.43349329e-01f, -5.68668619e-02f, -2.56900996e-01f, -1.44259259e-01f, -8.04884285e-02f, 4.63740062e-03f, 9.34013724e-03f, 2.58325845e-01f,
  4.34329659e-02f, 6.98245242e-02f, -6.23214915e-02f, 1.54062748e-01f, 2.48684525e-01f, 2.37302035e-01f, 3.43105197e-02f, -1.69102371e-01f, -1.38784885e-01f, -5.76207153e-02f,
  -3.62489164e-01f, -2.06457928e-01f, 1.70887455e-01f, 3.30002569e-02f, -3.28956768e-02f, 1.69459790e-01f, 2.20261171e-01f, -2.93202996e-01f, 3.74756128e-01f, 7.89773557e-03f,
  -2.02691391e-01f, -1.52878523e-01f, 3.44897695e-02f, -7.29834884e-02f, -2.87472874e-01f, -5.26647666e-04f, -1.35300770e-01f, 2.84258574e-01f, -6.39933124e-02f, -7.04163909e-02f,
  7.90036917e-02f, 2.96617776e-01f, 4.99063060e-02f, 1.08856298e-01f, 2.88856477e-01f, -1.32011265e-01f, -1.16994031e-01f, 5.44537269e-02f, 9.54694524e-02f, -1.45431027e-01f,
  8.29231590e-02f, -3.24073322e-02f, 4.82408069e-02f, -3.38164158e-02f, -5.61553687e-02f, -1.65502429e-01f, -1.08897552e-01f, 6.67012036e-02f, -2.34233186e-01f, 8.57637897e-02f,
  4.79083546e-02f, -8.24742019e-03f, -2.39042821e-03f, -4.66636755e-03f, -7.25184008e-02f, -1.12273477e-01f, -4.50599799e-03f, -1.03423357e-01f, 3.85722257e-02f, -4.26702984e-02f,
  -7.24378303e-02f, -7.17754513e-02f, -9.58261937e-02f, 6.11502118e-02f, 6.26827627e-02f, 1.18171312e-01f, 1.09782793e-01f, 8.58858898e-02f, 2.54251696e-02f, -1.20619638e-02f,
  7.90141001e-02f, -6.13289513e-03f, -1.94612980e-01f, 2.68126100e-01f, -2.57650316e-01f, -1.06993122e-02f, -1.14267267e-01f, 1.55022085e-01f, 1.52155191e-01f, 4.12224263e-01f,
  -1.70098454e-01f, -8.64505991e-02f, 1.96357831e-01f, -7.91939348e-02f, -1.44477412e-01f, -1.55419394e-01f, 3.68884392e-02f, 8.10479671e-02f, 3.69100384e-02f, 1.01249479e-01f,
  -1.85922086e-02f, 2.68677205e-01f, -1.15213759e-01f, 1.50553703e-01f, -1.36646450e-01f, 2.13798672e-01f, -1.19455144e-01f, -1.25138581e-01f, -7.21150711e-02f, 1.39291084e-03f,
  -1.95657924e-01f, 1.07891068e-01f, -5.06206453e-02f, 1.98801011e-02f, -2.76086759e-02f, -4.77844477e-03f, 8.54705125e-02f, 5.30844778e-02f, -7.38443062e-02f, 1.72255170e-02f,
  1.03555672e-01f, 1.56726688e-01f, -1.14391841e-01f, -1.73863798e-01f, 1.99019715e-01f, -1.28671438e-01f, 4.96871099e-02f, -5.11228591e-02f, -8.81247669e-02f, -3.79383340e-02f,
  -2.02572703e-01f, -1.40448019e-01f, 2.35226210e-02f, 1.16612531e-01f, 1.25136763e-01f, 6.97030798e-02f, -7.54882768e-02f, 5.92649803e-02f, -2.60676909e-02f, 5.84428608e-02f,
  1.78743914e-01f, -9.93032083e-02f, -4.04521748e-02f, 1.18718423e-01f, 5.69255427e-02f, 2.16287598e-01f, 1.78373203e-01f, 1.23141050e-01f, 3.84486377e-01f, -4.91536316e-03f,
  -2.37848777e-02f, 1.15321703e-01f, 7.56047517e-02f, 2.11871088e-01f, -4.51233417e-01f, 2.56547898e-01f, -3.73088360e-01f, -2.95549452e-01f, 8.76846761e-02f, 1.74705043e-01f,
  2.50631630e-01f, 1.19679727e-01f, 2.72481620e-01f, 1.68287992e-01f, -7.55767338e-03f, 2.70395458e-01f, 5.19914404e-02f, -4.75864783e-02f, 7.71671608e-02f, -1.29877567e-01f,
  2.83322096e-01f, -1.99496567e-01f, -6.50383458e-02f, -1.71055824e-01f, -9.74414125e-02f, -3.65004241e-01f, -1.26841217e-01f, 8.43435451e-02f, 4.13964204e-02f, -3.26004368e-03f,
  -5.14975972e-02f, -6.93240836e-02f, -1.64988153e-02f, -4.67267595e-02f, -1.27924711e-01f, 1.64871395e-01f, -1.12633012e-01f, -4.62994725e-02f, 1.22017758e-02f, 1.42796382e-01f,
  -4.65582013e-02f, 1.01182990e-01f, 2.22360939e-02f, -3.23361158e-02f, -5.26577607e-02f, -1.71841100e-01f, 1.67275462e-02f, -1.06359705e-01f, 9.86508131e-02f, 5.01113087e-02f,
  5.12912199e-02f, -1.77989453e-01f, -4.18909714e-02f, -1.78824082e-01f, -6.13580309e-02f, -2.06851423e-01f, 2.62164958e-02f, 1.61155045e-01f, -2.54458431e-02f, 1.26738101e-01f,
  1.12151712e-01f, 9.00751352e-02f, -2.70330161e-01f, 6.09045923e-02f, 2.54896373e-01f, 1.38139635e-01f, 3.08799613e-02f, 1.24784879e-01f, -9.26138237e-02f, -1.57655492e-01f,
  1.86079100e-01f, -3.29290777e-01f, -5.52965328e-03f, 2.48817895e-02f, 1.07263587e-01f, 1.55749321e-01f, 5.50393276e-02f, 3.31185251e-01f, 1.20646119e-01f, 2.66170710e-01f,
  -2.36434400e-01f, -1.13646723e-01f, 1.16354346e-01f, 6.44891709e-02f, 3.06549594e-02f, -1.77150398e-01f, 1.32428050e-01f, -1.52355954e-01f, -1.15151651e-01f, -6.64645955e-02f,
  -1.13648325e-02f, 7.22590983e-02f, -1.60330776e-02f, 9.02183652e-02f, 1.14945909e-02f, -1.89999193e-01f, -1.51877418e-01f, 8.51783752e-02f, -8.85744914e-02f, -1.17085598e-01f,
  3.46701555e-02f, 2.33837545e-01f, 1.63428351e-01f, -1.03190258e-01f, 1.09047845e-01f, 9.70723331e-02f, 1.89888682e-02f, -2.67527476e-02f, 1.82019606e-01f, 1.04249462e-01f,
  6.64108768e-02f, 1.14591643e-01f, 6.87521547e-02f, 6.75138533e-02f, -2.29615923e-02f, 2.93310974e-02f, -3.14970091e-02f, 1.19398972e-02f, -5.55903167e-02f, 1.45574033e-01f,
  1.33786112e-01f, 2.18755975e-01f, 6.08759634e-02f, -9.37431380e-02f, -7.38444179e-02f, 1.06577240e-01f, 1.02866761e-01f, -2.12444991e-01f, -2.06995055e-01f, -2.53392197e-02f,
  4.97141331e-02f, -2.49541610e-01f, 2.56599844e-01f, -2.20754430e-01f, 1.71866342e-01f, 1.03435211e-01f, 5.48287928e-02f, -1.61161512e-01f, -2.61998892e-01f, -1.54664382e-01f,
  -2.07984045e-01f, -2.27296710e-01f, 9.60206613e-02f, 5.54713942e-02f, -2.19431162e-01f, -6.05603866e-02f, -2.31133234e-02f, 6.21101595e-02f, 6.05938584e-02f, -1.24806583e-01f,
  1.22723728e-02f, -1.87106147e-01f, 1.14313383e-02f, 1.44256368e-01f, 1.24660842e-01f, 1.98801070e-01f, -2.79415902e-02f, -4.02081236e-02f, -7.19061494e-02f, 2.01227125e-02f,
  8.12719688e-02f, 4.84225191e-02f, 7.69022256e-02f, -1.06852390e-01f, 6.68523610e-02f, 2.39821270e-01f, -1.75927460e-01f, -1.04483575e-01f, 1.18385702e-01f, 8.87519792e-02f,
  1.93757936e-01f, 3.79195139e-02f, 1.31576672e-01f, 2.02423528e-01f, -8.29523504e-02f, 9.88541823e-03f, 8.84650126e-02f, -8.80661700e-03f, 5.45387603e-02f, -2.00082157e-02f,
  -1.11947857e-01f, 2.59604747e-03f, -2.07602859e-01f, 1.55732542e-01f, -1.37940541e-01f, -1.19966760e-01f, 1.85209066e-02f, -7.75229782e-02f, 1.76377431e-01f, -1.61002517e-01f,
  7.95518532e-02f, -9.12839398e-02f, 1.01754248e-01f, -9.85974520e-02f, -6.82241768e-02f, -1.96656972e-01f, 1.21709816e-01f, 2.85186116e-02f, 1.49412915e-01f, 2.59771854e-01f,
  1.13178007e-01f, -1.89977095e-01f, -1.29352838e-01f, -3.41353603e-02f, -1.89455628e-01f, -3.23052168e-01f, -5.89963049e-02f, -9.11152959e-02f, -1.08422227e-01f, 2.06472337e-01f,
  -1.42370630e-02f, 1.21761464e-01f, 5.35519309e-02f, -1.76974908e-02f, -1.23216592e-01f, 3.04648638e-01f, 1.09161921e-01f, 7.82814175e-02f, -1.96964428e-01f, -5.74845299e-02f,
  -3.51586223e-01f, -1.02218710e-01f, -1.16804659e-01f, -7.04912767e-02f, -4.72592302e-02f, -1.06487060e-02f, 2.43130401e-02f, -1.08447894e-01f, -1.59058288e-01f, 1.27145603e-01f,
  -1.64906487e-01f, -5.93953282e-02f, -3.52253462e-03f, -1.96764655e-02f, 1.40110120e-01f, -1.65999293e-01f, -6.51433170e-02f, 1.98598988e-02f, -1.92305788e-01f, -1.47937134e-01f,
  2.14206502e-01f, 2.32832134e-03f, -7.91243762e-02f, 3.19988909e-03f, -4.37209532e-02f, -4.20481414e-02f, -9.02862549e-02f, -8.93463343e-02f, -1.18900917e-01f, 7.10951760e-02f,
  4.07510623e-02f, 1.23523667e-01f, -4.01620492e-02f, -1.70650944e-01f, -1.54547736e-01f, 1.23598568e-01f, 1.01209313e-01f, -8.62224475e-02f, -2.75189970e-02f, 1.28753647e-01f,
  -6.54662326e-02f, -1.60587400e-01f, 1.89753368e-01f, -7.58128092e-02f, -8.50737933e-03f, -8.42785239e-02f, 3.24205607e-01f, -5.30077964e-02f, 1.94963783e-01f, -1.37285084e-01f,
  1.87552914e-01f, -1.13482131e-02f, -4.24037725e-02f, 2.72235051e-02f, -7.74610117e-02f, 9.95417908e-02f, 1.17110565e-01f, -2.27823153e-01f, -2.44972948e-02f, -7.34750211e-05f,
  -1.10644341e-01f, -2.48655781e-01f, -9.89110842e-02f, -1.17014073e-01f, 3.77404951e-02f, 6.59958944e-02f, 2.03430536e-03f, -4.96470407e-02f, -2.10510194e-02f, -1.21837482e-01f,
  -1.30752236e-01f, -7.09824555e-04f, -2.34371647e-01f, 1.46904185e-01f, -3.12957540e-02f, 8.33182335e-02f, 3.21051525e-03f, -1.61933433e-02f, -1.05325162e-01f, -1.26576036e-01f,
  4.83866632e-02f, -1.90650493e-01f, -7.78812841e-02f, -4.91232201e-02f, 9.01747495e-02f, -7.87853152e-02f, -3.59226055e-02f, -5.67429699e-02f, 9.04398859e-02f, 6.12107664e-03f,
  -3.84629960e-03f, -1.59190416e-01f, -2.22853795e-02f, 2.32586339e-01f, -9.40783992e-02f, -1.21710546e-01f, -2.81333119e-01f, 3.99703205e-01f, -2.60036826e-01f, 1.36653289e-01f,
  -4.02159914e-02f, 1.13813229e-01f, -3.03727817e-02f, 9.08131972e-02f, 1.56262770e-01f, -1.01102285e-01f, 1.79188773e-01f, -1.10711433e-01f, -1.03049845e-01f, -3.42088230e-02f,
  1.20370397e-02f, 8.97898003e-02f, 2.42628768e-01f, 2.39946201e-01f, 7.98926279e-02f, 3.10170114e-01f, -2.19150752e-01f, 1.48903042e-01f, 9.54415649e-02f, 1.24548018e-01f,
  -5.32756507e-01f, 5.17965183e-02f, -1.46389171e-01f, -6.32166862e-02f, 3.37825119e-02f, -6.43179268e-02f, 1.92770490e-03f, 1.21459536e-01f, 4.77109756e-03f, -1.80135101e-01f,
  1.81089423e-03f, -8.48624483e-02f, -8.98922756e-02f, 3.63441110e-02f, -4.61049192e-02f, -6.67040348e-02f, 3.12155224e-02f, 1.22595295e-01f, 8.37548673e-02f, -3.97148952e-02f,
  8.96239653e-02f, -6.36812970e-02f, 3.07752132e-01f, -4.36294898e-02f, 5.56067862e-02f, 5.74862696e-02f, 9.28554626e-04f, -1.16542615e-01f, 2.51528900e-02f, -1.72991931e-01f,
  9.40316636e-03f, -2.95169085e-01f, -1.85267717e-01f, -1.44779444e-01f, -1.30705386e-01f, -1.76227659e-01f, -5.66760041e-02f, -3.81972529e-02f, 1.33024812e-01f, 8.19287598e-02f,
  2.32010812e-01f, -8.76445100e-02f, 7.73692131e-02f, 1.65519547e-02f, 1.98262542e-01f, 9.29415599e-02f, -2.05721203e-02f, -1.56024411e-01f, 3.20200890e-01f, -3.31581920e-01f,
  -1.87029671e-02f, -1.40362427e-01f, 1.11928694e-01f, -7.12901875e-02f, -1.46102056e-01f, -4.18476760e-04f, -2.99542189e-01f, 1.22397818e-01f, -4.84764576e-02f, -4.43904195e-03f,
  -3.65714394e-02f, 4.40341644e-02f, 2.12211892e-01f, -3.55443090e-01f, 1.10945031e-01f, -1.47116199e-01f, 2.63667200e-02f, -1.89509001e-02f, -1.07267797e-01f, 1.50948584e-01f,
  -1.72949340e-02f, -1.43356428e-01f, 3.48871276e-02f, 1.78323779e-02f, -8.69993195e-02f, 6.07969947e-02f, 1.94190428e-01f, -2.86407560e-01f, -2.09903166e-01f, -3.81542630e-02f,
  -6.70211762e-02f, 6.67429566e-02f, 1.39898166e-01f, -9.66872647e-02f, -7.80413821e-02f, -4.01368178e-02f, -1.22247618e-02f, -9.75554511e-02f, -5.12273517e-03f, -1.26557380e-01f,
  -4.02045622e-02f, -7.41432309e-02f, 7.43584409e-02f, -1.51193559e-01f, 8.27399082e-03f, 1.46346077e-01f, 1.29898265e-01f, -7.73481354e-02f, -5.33017479e-02f, 5.60094565e-02f,
  -6.28733635e-02f, -5.07971132e-03f, 1.04065500e-01f, 4.79576252e-02f, 9.22034830e-02f, 1.40112355e-01f, -3.46325248e-01f, -5.50543666e-02f, 1.01057261e-01f, -7.62776136e-02f,
  1.23780727e-01f, 4.44169760e-01f, -1.10773787e-01f, -8.94464925e-02f, 3.36812288e-01f, -1.38141364e-01f, -1.14655986e-01f, -1.80919960e-01f, -2.99531985e-02f, -5.28839454e-02f,
  -3.44592966e-02f, 2.97131985e-01f, 5.13646305e-02f, 4.92974460e-01f, -2.04946116e-01f, -7.57001862e-02f, 1.15229778e-01f, 1.38700441e-01f, -4.46222454e-01f, -4.22399826e-02f,
  2.27017045e-01f, -4.13128026e-02f, 8.06713849e-02f, 3.26415867e-01f, -4.15725214e-03f, 1.00930206e-01f, -7.23621026e-02f, -1.64555341e-01f, -6.18128851e-02f, 6.76870644e-02f,
  1.67641625e-01f, 6.57634288e-02f, 1.14306450e-01f, -5.84024154e-02f, 1.36830300e-01f, -1.75874770e-01f, 2.23817658e-02f, -5.76216988e-02f, -5.16065583e-02f, 5.31624258e-03f,
  -6.65827319e-02f, -2.91595068e-02f, -1.62473142e-01f, 2.57362295e-02f, -6.14641272e-02f, -8.30124598e-04f, 1.86553039e-02f, -3.79039645e-02f, 1.74066573e-02f, 1.22044310e-02f,
  -1.82178825e-01f, -2.24401027e-01f, 7.80117139e-02f, -6.54022917e-02f, 1.22384466e-01f, -2.82768253e-02f, 1.22533798e-01f, 9.87136737e-02f, 2.56547570e-01f, -3.76380026e-01f,
  -2.19828691e-02f, -5.62980138e-02f, 1.67686433e-01f, 4.26672846e-02f, -3.60779315e-02f, -1.01666607e-01f, 1.23018488e-01f, -5.41423773e-03f, 1.63930785e-02f, -1.69113472e-01f,
  -1.50647804e-01f, -1.75729379e-01f, -4.46402282e-02f, -4.09208089e-02f, 3.00636888e-03f, 2.39375904e-01f, -7.21697807e-02f, -1.59299448e-01f, -2.60519590e-02f, -1.23277806e-01f,
  3.38705361e-01f, -2.82540411e-01f, 3.46119821e-01f, 4.23916616e-02f, 2.41010517e-01f, 2.69923378e-02f, 1.59373075e-01f, -2.68812608e-02f, 2.74613984e-02f, 6.39060065e-02f,
  1.50477260e-01f, 7.66961575e-02f, -1.24501199e-01f, -6.36734739e-02f, 1.86503213e-02f, 9.28307399e-02f, -6.63118213e-02f, 3.24408859e-02f, 7.99445156e-03f, -1.31382093e-01f,
  1.02124490e-01f, 5.14266416e-02f, -4.82140994e-03f, -8.17055032e-02f, -2.82257408e-01f, 1.68379806e-02f, 6.27451390e-02f, 1.06683344e-01f, 8.93338490e-03f, 8.17769170e-02f,
  -1.85044799e-02f, 7.61788785e-02f, -7.17957644e-03f, 2.08597302e-01f, -2.32722498e-02f, 1.01584345e-01f, -2.57102493e-02f, 5.19830659e-02f, 1.26930460e-01f, -7.94796646e-02f,
  2.27780510e-02f, -1.21355712e-01f, 7.22581372e-02f, -5.93489930e-02f, -7.24225938e-02f, -2.01429635e-01f, 9.89585519e-02f, -6.10520951e-02f, 8.93012211e-02f, -1.82394534e-01f,
  2.13186145e-01f, 1.19218968e-01f, 1.26085937e-01f, 6.94486946e-02f, 7.29954801e-03f, -3.43724973e-02f, -8.32987130e-02f, 8.62346068e-02f, -3.09944391e-01f, 2.19920173e-01f,
  -3.99287865e-02f, -1.37819201e-01f, -1.54300645e-01f, 1.53841242e-01f, -1.29599780e-01f, -4.84293662e-02f, 4.47072573e-02f, 2.66533107e-01f, -1.25803649e-01f, 2.49128863e-01f,
  1.39026776e-01f, 9.09983143e-02f, -2.72333119e-02f, -4.32987101e-02f, -5.27843647e-02f, -1.10431306e-01f, -8.31032321e-02f, 1.88951522e-01f, 1.11697823e-01f, 2.65237361e-01f,
  6.29475936e-02f, 2.24926054e-01f, -7.99837410e-02f, -2.61899143e-01f, 1.21197188e-02f, -4.43609012e-03f, 3.37121934e-02f, -1.47930250e-01f, -4.67638746e-02f, 3.59185301e-02f,
  -1.87712997e-01f, -3.07027008e-02f, -1.02747366e-01f, -9.85792652e-02f, 9.75674614e-02f, -5.31658344e-02f, 3.56386304e-02f, 1.48490474e-01f, -4.04086150e-02f, 6.88768625e-02f,
  1.96899511e-02f, 9.75433886e-02f, -3.47177661e-03f, 1.78394496e-01f, 5.15632741e-02f, 3.64132337e-02f, 1.73070177e-01f, -2.68661439e-01f, 2.54685223e-01f, -4.76961769e-02f,
  -3.40684280e-02f, 7.89101571e-02f, 8.73197615e-02f, -2.65800487e-02f, -1.04033455e-01f, 2.31129035e-01f, -8.47095624e-02f, -7.59571120e-02f, -1.10935085e-01f, -9.54938028e-03f,
  2.73978949e-01f, 8.02894216e-03f, 1.07492305e-01f, -8.16513319e-03f, 2.15229049e-01f, 8.10214058e-02f, 3.19108009e-01f, 7.30830338e-03f, 1.39560699e-01f, -1.69405378e-02f,
  8.58402848e-02f, 1.55686498e-01f, -5.59191927e-02f, -3.21620703e-02f, -3.65231708e-02f, -4.75527465e-01f, 3.06876227e-02f, 2.11145580e-02f, -4.15053032e-02f, 1.43901482e-01f,
  8.41245949e-02f, -1.25619667e-02f, 2.67049801e-02f, 2.35792711e-01f, 9.15301740e-02f, 1.49595225e-02f, -3.56226414e-03f, -1.27051055e-01f, -6.87581813e-03f, 1.30788386e-01f,
  -8.68274644e-02f, 4.70557399e-02f, -1.09126508e-01f, -4.94167283e-02f, -1.10414758e-01f, 1.38691753e-01f, 6.99509727e-03f, 8.58131871e-02f, -1.76859885e-01f, 1.18890710e-01f,
  -2.07839478e-02f, -1.81155950e-01f, -8.03819224e-02f, 2.71667149e-02f, 8.56865942e-02f, -1.47605687e-01f, -1.94661260e-01f, 7.59177729e-02f, -3.60924453e-02f, 2.40298271e-01f,
  1.15404226e-01f, -2.19352450e-03f, 1.97037145e-01f, 9.91761982e-02f, 5.53603321e-02f, 1.25417829e-01f, -5.97775020e-02f, -1.82060108e-01f, -3.02762270e-01f, 1.32047892e-01f,
  -2.81521946e-01f, -4.23785299e-03f, -4.11203653e-02f, 1.24339752e-01f, -1.10752575e-01f, 8.74437690e-02f, 2.99830467e-01f, 1.28862843e-01f, 1.06918976e-01f, -1.25155047e-01f,
  1.43071264e-01f, 2.36749835e-02f, 2.68616885e-01f, -2.67924160e-01f, -1.39062062e-01f, -8.74593109e-02f, 1.47296069e-02f, -7.24350065e-02f, 1.05604149e-01f, -2.08178848e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.26007068e-01f, -1.18390225e-01f, 3.27343374e-01f, 1.00895308e-01f, 4.23940122e-01f, 8.87669250e-02f, 1.45139858e-01f, -4.08458203e-01f, -4.03369181e-02f, 4.68253970e-01f,
  -1.10151793e-03f, 5.20121343e-02f, 1.32124141e-01f, 5.50624579e-02f, 2.00713560e-01f, -1.03909578e-02f, 2.94557601e-01f, -3.35098714e-01f, -1.34161770e-01f, -1.17273629e-01f,
  5.66952705e-01f, 9.65012908e-02f, -5.79990330e-04f, -6.53331950e-02f, 8.47631395e-02f, -1.26152396e-01f, -1.25207752e-01f, 1.03789777e-01f, 1.03184849e-01f, -1.80687204e-01f,
  -3.34792048e-01f, -3.63755152e-02f, 1.40988827e-01f, 4.14310068e-01f, -1.41503051e-01f, 1.41887680e-01f, -4.73391525e-02f, 2.33297750e-01f, -3.68208349e-01f, 3.57416004e-01f,
  2.15506405e-01f, 2.84484446e-01f, -7.50652552e-01f, 1.87863149e-02f, -2.47724608e-01f, -4.61234838e-01f, -7.78157711e-02f, 2.96758473e-01f, 3.30694884e-01f, 1.03033632e-01f,
  5.48611641e-01f, 2.07666636e-01f, 2.60873437e-01f, 6.66759968e-01f, -1.44634888e-01f, 3.35269049e-02f, 2.15261459e-01f, 1.81025222e-01f, -3.35306555e-01f, -4.98761147e-01f,
  -3.15344602e-01f, -1.67176917e-01f, -1.64144769e-01f, -3.78043920e-01f, 1.90898404e-01f, 1.77363604e-02f, 2.84088135e-01f, 2.17622012e-01f, 2.74621427e-01f, 2.17955947e-01f,
  5.67539409e-02f, -2.77173929e-02f, 2.21139751e-02f, 1.23054810e-01f, 3.78723562e-01f, 1.46621332e-01f, 7.63988644e-02f, 3.50008368e-01f, 6.31638393e-02f, 1.64931901e-02f,
  1.01799875e-01f, 5.98711185e-02f, 1.55543223e-01f, 7.22403452e-02f, 2.85818845e-01f, 3.67016822e-01f, 5.73398396e-02f, 2.40695402e-01f, 5.41755743e-03f, -9.22351182e-02f,
  -1.79357722e-01f, 9.49020963e-03f, 8.36613309e-03f, 2.32868955e-01f, -2.62519360e-01f, -3.42500061e-01f, 1.40747093e-02f, -1.24992803e-01f, 1.41545147e-01f, 8.75114650e-02f,
  2.91469902e-01f, -1.27934106e-02f, 1.54938186e-02f, 9.15343687e-02f, -1.82588056e-01f, -1.91053927e-01f, -1.36912363e-02f, 2.21071690e-02f, -9.26542431e-02f, 2.98870325e-01f,
  1.36334123e-02f, 9.86666605e-02f, -4.18337226e-01f, 3.75883398e-03f, 2.80531526e-01f, -2.36993074e-01f, 3.15834016e-01f, -5.77922106e-01f, 4.45493132e-01f, 3.35359499e-02f,
  3.98409724e-01f, -2.15662941e-01f, -1.70445144e-01f, 6.49648756e-02f, -2.74690479e-01f, -1.43550545e-01f, 2.39605799e-01f, 6.29816234e-01f, 1.75280467e-01f, -2.65227463e-02f,
  1.37590408e-01f, -9.81386527e-02f, 1.58532739e-01f, 1.49217188e-01f, 1.40622005e-01f, 2.64650166e-01f, 2.54497141e-01f, 2.27454945e-01f, 1.91712249e-02f, -1.43571839e-01f,
  -5.19116186e-02f, -8.96847472e-02f, 3.22420895e-01f, 1.49427235e-01f, 3.74242097e-01f, 2.20207825e-01f, -1.17283411e-01f, 2.30761200e-01f, -3.52552459e-02f, -1.00490943e-01f,
  3.66284966e-01f, 4.35570860e-03f, 1.28557324e-01f, 2.50529319e-01f, -2.04408824e-01f, -2.99482584e-01f, 4.18709368e-01f, -1.83476165e-01f, -9.15850326e-02f, 7.90263712e-02f,
  2.50309289e-01f, 2.65031844e-01f, 3.76234591e-01f, -7.65950322e-01f, -2.19587401e-01f, 2.65257448e-01f, 7.40872622e-02f, 1.94166839e-01f, 1.47538275e-01f, 3.17229144e-02f,
  -7.91746452e-02f, -2.90285740e-02f, 8.45525637e-02f, -6.01548672e-01f, -3.93571079e-01f, 1.40084904e-02f, 6.00303471e-01f, 4.96057607e-02f, 4.73410964e-01f, 6.48527205e-01f,
  1.06062062e-01f, 1.26142204e-01f, 3.64271432e-01f, -1.23814784e-01f, 1.47759616e-01f, -3.27089697e-01f, 9.00882006e-01f, 4.71445583e-02f, 5.89966059e-01f, 9.00798365e-02f,
  -1.49640530e-01f, -6.07539952e-01f, -1.80105135e-01f, 1.58623546e-01f, 1.87517643e-01f, 2.87347943e-01f, 3.36698085e-01f, -3.31868301e-03f, -1.60422623e-01f, 2.04012379e-01f,
  -1.06062097e-02f, 4.43482220e-01f, 2.54741181e-02f, 3.79781544e-01f, 8.25643167e-02f, 2.67310262e-01f, 1.00682974e-01f, 1.05007537e-01f, 8.67572576e-02f, 3.40917319e-01f,
  2.15551347e-01f, 6.83802739e-02f, 1.59332320e-01f, 1.07166491e-01f, 1.91112548e-01f, 3.82312052e-02f, 1.10332713e-01f, -5.04441559e-01f, -2.57011741e-01f, -3.90155405e-01f,
  -1.11363910e-01f, -5.36258280e-01f, -3.87647837e-01f, -3.04670572e-01f, -2.16290444e-01f, 9.24464501e-03f, -3.59627932e-01f, 3.10562611e-01f, 6.78587735e-01f, 4.31041777e-01f,
  -2.38674000e-01f, 4.54132676e-01f, -6.94324896e-02f, -5.07851243e-01f, 1.11401878e-01f, -6.38665482e-02f, -5.68663359e-01f, -8.19894969e-02f, 1.28124654e-01f, 4.24375743e-01f,
  -2.22587496e-01f, 2.31024519e-01f, 3.83782327e-01f, -6.03542447e-01f, 5.73860884e-01f, -5.43330908e-01f, -8.03444535e-02f, 1.38831586e-01f, 1.04582198e-02f, -2.26598546e-01f,
  -1.89115316e-01f, -1.18610054e-01f, -4.70710158e-01f, -1.47567555e-01f, -3.27060074e-01f, 6.12730905e-02f, 2.27652583e-02f, -1.74744986e-02f, 4.01359685e-02f, 8.90474170e-02f,
  2.19746783e-01f, 3.51745546e-01f, 2.15949342e-02f, 8.24043080e-02f, 9.90592092e-02f, 2.82795489e-01f, 2.06967458e-01f, 1.67972818e-01f, -1.27597421e-01f, 4.35881525e-01f,
  1.70999825e-01f, 1.90228857e-02f, 3.40032518e-01f, -6.43225061e-03f, 2.89375961e-01f, 4.07132581e-02f, 5.76434433e-02f, -1.53125718e-01f, 1.37566358e-01f, 2.06252173e-01f,
  1.21714240e-02f, -4.43500966e-01f, -2.34569833e-01f, -4.49568689e-01f, 2.66078919e-01f, -4.30440694e-01f, 2.00514365e-02f, 3.31247717e-01f, 2.13735893e-01f, -2.15318631e-02f,
  1.13822900e-01f, 7.20012337e-02f, -3.02384108e-01f, -1.18899435e-01f, 3.49318206e-01f, 4.24890101e-01f, -3.32760997e-02f, 8.95967633e-02f, 7.29850411e-01f, -1.41835958e-01f,
  1.56791992e-02f, -4.02049780e-01f, -7.13517740e-02f, -3.84010106e-01f, -1.05196662e-01f, -1.19496025e-01f, 1.62910551e-01f, 6.45541847e-01f, 6.17145419e-01f, 3.28835160e-01f,
  5.52709997e-01f, 4.88677546e-02f, 2.10258260e-01f, -1.83524817e-01f, -7.73458242e-01f, 1.45570664e-02f, 5.76849818e-01f, -1.48188740e-01f, -5.24873137e-01f, 2.05546558e-01f,
  -2.03571841e-01f, 1.95588041e-02f, -4.35030907e-02f, 5.83095290e-02f, -1.68175951e-01f, 8.94969776e-02f, 2.56329030e-01f, 1.77841514e-01f, 3.97915691e-02f, -3.03219091e-02f,
  1.27366140e-01f, 4.14475471e-01f, -3.29267859e-01f, 7.24409670e-02f, 1.37740418e-01f, 3.23489495e-02f, 2.05128685e-01f, 2.84933895e-01f, 4.83852513e-02f, 2.80239228e-02f,
  -2.56606668e-01f, -3.14697862e-01f, 6.28423020e-02f, 8.92978385e-02f, -2.51753051e-02f, -5.82006462e-02f, 1.99794456e-01f, 2.30613887e-01f, -2.92946965e-01f, 7.84243569e-02f,
  6.88948035e-02f, 1.34878337e-01f, 9.53960791e-03f, -2.00180477e-03f, -2.13390037e-01f, -7.42952600e-02f, 7.22305570e-03f, -1.78552687e-01f, -7.93059841e-02f, 1.29331961e-01f,
  -3.04654866e-01f, 2.56295055e-01f, -8.88080969e-02f, -1.76077988e-02f, -2.89559186e-01f, 9.40180570e-02f, 3.09007972e-01f, 1.06810499e-02f, -2.59660095e-01f, -1.66216463e-01f,
  -6.53783321e-01f, 9.19724777e-02f, -7.84430206e-01f, 1.08020499e-01f, -8.05707633e-01f, -7.83720836e-02f, 3.14852238e-01f, 4.89546686e-01f, -2.56766886e-01f, 2.02478752e-01f,
  7.02825308e-01f, 3.18798749e-03f, 2.70317525e-01f, -1.78896710e-01f, 4.25666243e-01f, 1.76050797e-01f, 4.87117767e-01f, 1.64959371e-01f, 6.49946779e-02f, 2.58706361e-02f,
  3.57176483e-01f, 8.59996006e-02f, 8.21758881e-02f, 2.17178673e-01f, -3.35130952e-02f, -1.57152250e-01f, -2.57033352e-02f, 3.94065648e-01f, 2.49069959e-01f, 8.15493390e-02f,
  1.54095486e-01f, -5.25014512e-02f, 2.95908988e-01f, -2.68937182e-02f, -3.62912565e-02f, -1.00150280e-01f, 1.07323658e-03f, 1.14797249e-01f, 9.54312906e-02f, -2.62964703e-03f,
  2.29797155e-01f, -2.96741754e-01f, 3.36438566e-01f, -1.71453163e-01f, 1.59359157e-01f, 1.56358972e-01f, -2.98073590e-01f, -2.05731213e-01f, -2.51481891e-01f, 4.83422428e-01f,
  -4.54440713e-01f, 2.85229087e-01f, 4.41781193e-01f, 3.11851576e-02f, 1.85970426e-01f, 3.77137959e-01f, 2.97179315e-02f, 1.73510194e-01f, 3.42033803e-01f, -1.01658300e-01f,
  -1.07589893e-01f, 6.45742938e-02f, 3.59317392e-01f, 2.58651882e-01f, 8.06692094e-02f, 1.05908620e+00f, 2.49450669e-01f, 4.42413241e-01f, 1.25657201e-01f, -1.69825733e-01f,
  3.39659452e-01f, 9.62315798e-02f, -6.23030841e-01f, 3.01186200e-02f, 3.23104233e-01f, -1.90205574e-02f, 8.19164608e-03f, 1.39762327e-01f, 2.10308924e-01f, 3.01076651e-01f,
  2.49046177e-01f, 1.08639076e-01f, 3.29715610e-01f, -7.34712044e-03f, 1.40476704e-01f, -2.22639725e-01f, 1.31385729e-01f, 2.99063832e-01f, -1.31440666e-02f, 4.63237852e-01f,
  -2.67463714e-01f, 1.39972242e-02f, 1.78448528e-01f, 2.19259635e-01f, 4.29494679e-01f, 2.20910400e-01f, 1.70177057e-01f, 3.34361821e-01f, 3.21968406e-01f, 3.55510041e-03f,
  1.26355141e-01f, 1.02475777e-01f, 3.22676748e-02f, 5.50761586e-03f, -1.42161399e-01f, -1.71570435e-01f, -2.05365166e-01f, -4.50574160e-02f, -5.48163950e-01f, -3.54254961e-01f,
  -1.39746815e-01f, 6.93807974e-02f, -4.62009996e-01f, 3.29873979e-01f, 1.30882859e-01f, 4.39743221e-01f, -2.44595051e-01f, 2.74544686e-01f, -3.01906466e-02f, 5.27984619e-01f,
  -5.77656329e-01f, -2.39261344e-01f, -3.35147753e-02f, 1.47231771e-02f, 6.62509054e-02f, 3.97798270e-01f, 1.74913913e-01f, 1.86806336e-01f, 5.60988665e-01f, -3.38555336e-01f,
  1.42236382e-01f, 1.45776138e-01f, -2.05497563e-01f, 2.64671624e-01f, -1.31939217e-01f, 4.70200151e-01f, 3.40609491e-01f, -4.56571758e-01f, -1.09982751e-01f, 1.01975106e-01f,
  -2.59661973e-01f, -1.85176924e-01f, 1.02051966e-01f, -2.41863921e-01f, 8.00631419e-02f, 8.63010213e-02f, 3.13151836e-01f, 8.89913365e-02f, 1.20613612e-01f, 2.06433088e-01f,
  4.13739383e-02f, -6.74268883e-03f, 1.09545916e-01f, -1.63928181e-01f, 4.30896096e-02f, 7.48006180e-02f, 7.19807670e-02f, 9.76299029e-03f, -3.57962638e-01f, 7.95909241e-02f,
  -2.76207209e-01f, -3.60390842e-02f, -7.17240199e-02f, -1.43972784e-02f, 4.31149825e-02f, -5.21083071e-04f, -9.06882212e-02f, 1.44576237e-01f, -1.28457189e-01f, -8.59523341e-02f,
  1.82915717e-01f, 2.63421029e-01f, -1.15591019e-01f, -8.80936608e-02f, -1.60994321e-01f, -3.04695275e-02f, 4.43839371e-01f, -3.58733088e-01f, 5.04434645e-01f, 3.42386216e-02f,
  -1.52730629e-01f, 1.31638616e-01f, 1.85944751e-01f, -3.27818930e-01f, -4.37018573e-01f, 4.66658860e-01f, -1.18234828e-01f, 1.06071167e-01f, -2.00763851e-01f, 3.79878461e-01f,
  -9.21122357e-02f, 2.57257104e-01f, 4.25668806e-01f, -2.65953541e-01f, 1.22921631e-01f, -3.29622895e-01f, 3.42894763e-01f, -6.29208982e-03f, -2.19742760e-01f, 3.39218497e-01f,
  2.11300597e-01f, 1.59175515e-01f, -2.26283848e-01f, -2.52841320e-02f, 1.75478935e-01f, -1.95111200e-01f, 2.39087209e-01f, 2.14749679e-01f, 1.63243368e-01f, 3.61532390e-01f,
  2.99497306e-01f, 1.21173523e-01f, 5.35454415e-02f, 2.69073129e-01f, 7.25510120e-02f, 1.53520033e-01f, 3.67301971e-01f, 2.08471894e-01f, 5.84611967e-02f, 2.84060001e-01f,
  2.33165666e-01f, 1.49283156e-01f, 1.11497074e-01f, 3.28952223e-01f, 3.66720587e-01f, 2.89275169e-01f, 2.02585727e-01f, 2.74933457e-01f, 1.85408488e-01f, 2.14528918e-01f,
  2.59786308e-01f, 6.99682161e-02f, -2.49824420e-01f, 7.49167576e-02f, 1.17860166e-02f, 1.17873929e-01f, 5.75125851e-02f, -2.10634589e-01f, 1.71889022e-01f, -1.10035650e-01f,
  3.98111008e-02f, -6.80366382e-02f, 3.52666229e-01f, -7.54771754e-02f, -5.59319854e-02f, -4.75386195e-02f, -1.58641934e-01f, -3.29095483e-01f, -9.77537632e-02f, -5.95182786e-03f,
  2.36463591e-01f, 2.96092838e-01f, -9.83853415e-02f, 2.05478072e-01f, -2.73039430e-01f, 1.14929229e-01f, -1.04800515e-01f, -4.01516885e-01f, -1.58967540e-01f, -3.36771816e-01f,
  1.03363954e-01f, 2.25928659e-03f, -1.72738627e-01f, 3.45686853e-01f, 7.13259637e-01f, 1.01731680e-01f, -2.17310593e-01f, 3.54422294e-02f, 2.13680983e-01f, 6.37948990e-01f,
  -2.25090429e-01f, 6.93123639e-02f, -4.21947807e-01f, -1.06519736e-01f, 1.51253939e-01f, 3.39410275e-01f, -1.55348763e-01f, 1.60992891e-01f, 1.70326203e-01f, 3.29116613e-01f,
  1.25616029e-01f, 2.57376283e-01f, 2.17941195e-01f, -7.28994533e-02f, 1.15997240e-01f, -8.90601054e-02f, 2.32644156e-01f, 3.70932162e-01f, 9.68428105e-02f, 1.21541023e-01f,
  2.56848216e-01f, 1.13593377e-01f, 2.77456522e-01f, 2.13341504e-01f, 1.12745903e-01f, 2.20267102e-01f, -2.82177001e-01f, 6.10228300e-01f, -1.90699890e-01f, 8.98407772e-02f,
  1.30295485e-01f, 9.09386039e-01f, 3.46526027e-01f, 3.39228600e-01f, 2.48402096e-02f, -5.30400097e-01f, 5.26886523e-01f, -5.05087912e-01f, -8.13695788e-01f, 1.37572080e-01f,
  4.33151156e-01f, -4.32223558e-01f, -5.42053171e-02f, -9.67093930e-02f, -5.27783632e-01f, -4.11070436e-01f, -1.31612077e-01f, -1.13878131e-01f, -1.74781233e-02f, 1.07803389e-01f,
  1.10202059e-01f, 1.92929298e-01f, -4.72774394e-02f, 7.74332821e-01f, 2.71931887e-01f, -5.96148252e-01f, 1.39803916e-01f, 2.23337203e-01f, 6.04304612e-01f, -3.20910603e-01f,
  3.88881981e-01f, -5.43619335e-01f, -5.10213852e-01f, -2.02729195e-01f, 3.15155745e-01f, 3.22076529e-01f, 2.15906620e-01f, 2.97117323e-01f, 2.86009610e-01f, 4.97747734e-02f,
  1.93296194e-01f, -4.64663617e-02f, 1.88973412e-01f, 1.68638065e-01f, 3.00715622e-02f, 2.08049566e-01f, 1.77585557e-01f, -4.84319627e-02f, 1.08694427e-01f, 8.64411071e-02f,
  1.14453726e-01f, 2.58920848e-01f, 3.65070194e-01f, 7.05033690e-02f, 1.10244147e-01f, 2.86888301e-01f, 1.66277468e-01f, 2.38227546e-01f, 1.90771878e-01f, 1.10903457e-01f,
  3.96829396e-01f, 3.98457259e-01f, -2.96311080e-01f, 2.60588527e-01f, -1.43871263e-01f, -1.97054550e-01f, -3.70336808e-02f, 3.88943404e-02f, 4.39731628e-02f, 3.87544930e-01f,
  -2.28820473e-01f, -3.51094216e-01f, 4.06721197e-02f, -2.38942385e-01f, -1.18191659e-01f, 2.37959102e-01f, -1.98853955e-01f, -1.39339253e-01f, -2.10713312e-01f, 4.58361864e-01f,
  3.26980531e-01f, -2.40171850e-01f, -3.31755906e-01f, -1.83177203e-01f, -1.42030627e-01f, 3.36604297e-01f, -5.38901150e-01f, 5.13248205e-01f, -5.88566124e-01f, 1.31166026e-01f,
  1.58904091e-01f, 4.24497515e-01f, -5.02899349e-01f, -4.62676696e-02f, 6.54067636e-01f, 1.40503585e-01f, -1.88548237e-01f, 2.65588731e-01f, 1.57382339e-01f, 2.32208252e-01f,
  -1.83323830e-01f, -1.29778326e-01f, 2.17890561e-01f, 2.61251241e-01f, 1.46215126e-01f, 2.62217879e-01f, -4.85200575e-03f, 1.03683397e-01f, 4.63902056e-01f, 1.22487642e-01f,
  1.61403254e-01f, 5.26043549e-02f, 2.16116190e-01f, -2.27259696e-02f, 8.64461064e-02f, -2.59766430e-02f, 2.16167141e-02f, 2.24376470e-01f, 1.32983297e-01f, 1.85500950e-01f,
  4.00171280e-01f, 1.81428373e-01f, 1.48739249e-01f, 4.25675541e-01f, -1.01371957e-02f, 1.71850592e-01f, 3.80497836e-02f, 7.61288591e-03f, 3.42976362e-01f, 3.05170536e-01f,
  -2.99122751e-01f, 2.99105257e-01f, 2.13865250e-01f, -2.37560183e-01f, 9.15393084e-02f, -6.32183775e-02f, -2.89063841e-01f, -9.14306864e-02f, -2.45435778e-02f, -5.63953280e-01f,
  7.62306750e-02f, 5.36926270e-01f, -1.14856534e-01f, 1.01720355e-01f, 7.23763108e-02f, -5.95063679e-02f, 4.25895423e-01f, 1.15879603e-01f, 6.94113970e-02f, 7.74111524e-02f,
  2.94590086e-01f, 3.11320513e-01f, 5.22807837e-01f, -3.45101863e-01f, -6.16738275e-02f, 6.08304501e-01f, 5.71704023e-02f, -4.35948186e-03f, 1.28606603e-01f, -1.80050313e-01f,
  1.98618084e-01f, -5.23355544e-01f, 8.24631900e-02f, 8.80803093e-02f, 7.34113604e-02f, -1.33225635e-01f, -1.87817160e-02f, -4.76647122e-03f, -4.49835509e-02f, -3.02755088e-01f,
  1.25862375e-01f, 1.95114836e-01f, 2.48676389e-02f, 2.44431898e-01f, -5.81940524e-02f, 5.01617938e-02f, 3.85253541e-02f, -6.40726835e-02f, 2.11184070e-01f, -2.97258217e-02f,
  -1.68665163e-02f, -7.56095499e-02f, 2.54908592e-01f, 1.24365240e-01f, 1.68044176e-02f, -2.30012611e-02f, -2.40717649e-01f, -1.40664831e-01f, -1.70968935e-01f, -1.05148675e-02f,
  -1.36510372e-01f, -1.83928654e-01f, -3.52132767e-01f, 8.66405815e-02f, -1.88900650e-01f, 1.40732542e-01f, -8.53757411e-02f, 3.03609401e-01f, 1.31240502e-01f, 4.21225429e-02f,
  -3.11254382e-01f, 6.51723295e-02f, 2.87299659e-02f, 2.19596133e-01f, -4.38540161e-01f, -4.73989472e-02f, -3.32530290e-01f, 9.79847461e-02f, 1.59659863e-01f, 2.69057482e-01f,
  1.17977269e-01f, -4.87305857e-02f, 4.96279836e-01f, -4.41616476e-02f, 3.52153212e-01f, 6.14584029e-01f, 1.99835673e-02f, 2.64229208e-01f, -4.01644707e-02f, -5.11515141e-03f,
  -7.63997793e-01f, 1.58674885e-02f, -1.45041078e-01f, 1.98245078e-01f, 7.69135579e-02f, 6.26184838e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.85733825e-01f, 2.42036298e-01f, 1.79129899e-01f, 2.63269603e-01f, 2.55464852e-01f, 2.14741111e-01f, 1.37542278e-01f, 3.42879802e-01f, -2.39587110e-02f, 1.83623210e-01f,
  2.27867946e-01f, 4.70697194e-01f, 3.49906951e-01f, -2.81843450e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.00287968e-03f, 2.45166272e-01f, -1.74891263e-01f, -2.24109702e-02f, -4.22812432e-01f, -1.76632971e-01f, 3.50508273e-01f, -3.62282455e-01f, 2.62784481e-01f, -3.41054827e-01f,
  -3.29915620e-02f, -5.30236959e-01f, -1.90130278e-01f, -3.04324985e-01f, -2.60992777e-02f, -1.73766002e-01f, -4.13850844e-02f, -1.93960965e-01f, 6.90826401e-02f, -2.14161202e-01f,
  -2.22118810e-01f, 1.04889125e-01f, -2.28329360e-01f, -1.42066360e-01f, -3.35966378e-01f, 5.12397707e-01f, 2.18111724e-01f, 2.26626903e-01f, -1.74007550e-01f, 3.30651969e-01f,
  8.02435398e-01f, 3.05241555e-01f, 4.10963506e-01f, -5.90083003e-01f, 2.99310863e-01f, 3.77437711e-01f, 2.50907689e-01f, -1.54360488e-01f, 3.26006263e-02f, 6.69658137e-03f,
  6.19863905e-02f, -2.69618869e-01f, 2.12550446e-01f, -4.45179880e-01f, -1.82318717e-01f, -2.57606450e-02f, 2.79552847e-01f, -2.69795597e-01f, -4.57999825e-01f, -2.91476101e-01f,
  1.31994173e-01f, 1.20937988e-01f, 1.81679487e-01f, 2.45454699e-01f, 1.46726832e-01f, -7.98830807e-01f, -3.51146519e-01f, -3.19546342e-01f, 3.40287715e-01f, -2.50695825e-01f,
  1.89186305e-01f, -1.24337569e-01f, 1.60933584e-01f, 1.98556215e-01f, 3.45354587e-01f, -1.76134109e-01f, -1.10749528e-01f, 2.53626943e-01f, -5.12795411e-02f, 9.55834538e-02f,
  -7.04866171e-01f, -7.00891256e-01f, -2.97787208e-02f, 2.98521042e-01f, -3.80368647e-03f, -1.15924962e-01f, -3.10330838e-01f, 2.06036076e-01f, -2.89144069e-01f, 1.66196689e-01f,
  1.23856813e-01f, -2.81329662e-01f, -4.48042154e-01f, 1.82264969e-01f, -1.57322183e-01f, -9.73059461e-02f, -6.26238703e-04f, 1.49577007e-01f, -2.60077864e-01f, 5.84951304e-02f,
  -4.90946412e-01f, 1.68006420e-02f, 1.17609836e-01f, 8.51248920e-01f, -1.25206977e-01f, -3.73988859e-02f, 4.78667885e-01f, -2.64635921e-01f, 3.45515370e-01f, -1.96273252e-01f,
  1.06982559e-01f, -5.20637870e-01f, 1.91937417e-01f, -4.67346728e-01f, -7.95420706e-01f, 3.46696526e-01f, -3.02241147e-01f, -1.08423261e-02f, -5.80878615e-01f, 9.27702039e-02f,
  2.82111783e-02f, 5.14681160e-01f, 6.57702386e-01f, 4.84884262e-01f, -4.15579557e-01f, 2.33986378e-01f, 1.04968369e-01f, 1.11265481e-02f, -8.90019298e-01f, 3.11152965e-01f,
  1.27714714e-02f, -6.15591966e-02f, 2.79621869e-01f, 2.25934938e-01f, -6.72433674e-01f, -1.84049457e-01f, 2.88712442e-01f, -1.95558965e-01f, 7.39262030e-02f, -4.54525322e-01f,
  4.08898443e-01f, 3.71969312e-01f, 2.29248460e-02f, -1.71693936e-01f, -3.66978608e-02f, -7.04793856e-02f, -1.89601317e-01f, -7.67554790e-02f, 1.66024446e-01f, 2.08794296e-01f,
  -6.07844815e-02f, -1.04887217e-01f, 2.02153221e-01f, 1.99574009e-01f, 5.94253913e-02f, -1.76540673e-01f, 1.47051126e-01f, -1.30091742e-01f, 1.51609704e-02f, 8.20024908e-02f,
  -6.29981756e-02f, -2.58462280e-01f, 1.07931837e-01f, 4.92160708e-01f, -1.30448461e-01f, 7.08029985e-01f, 3.82063359e-01f, 2.64786988e-01f, -3.63898128e-01f, 2.33103797e-01f,
  -4.07085270e-01f, 3.34117532e-01f, -1.49904981e-01f, 1.60519361e-01f, 4.39029336e-02f, -1.25492215e-01f, 3.58181387e-01f, -2.78391749e-01f, 4.90141690e-01f, -3.66354734e-01f,
  -2.01509848e-01f, -2.35070542e-01f, -4.29224402e-01f, -4.92872775e-01f, 1.55739546e-01f, -5.03325239e-02f, 3.68685454e-01f, -1.65741728e-03f, 1.32997245e-01f, -2.32369155e-01f,
  8.97018537e-02f, -2.97933936e-01f, -5.37907720e-01f, -3.89226705e-01f, -4.43697661e-01f, -6.02243841e-01f, 1.04501419e-01f, 2.87480623e-01f, 7.89028883e-01f, -2.86243469e-01f,
  1.45292431e-01f, 6.98584542e-02f, -9.66191851e-03f, 7.73642818e-03f, 1.14888638e-01f, -1.39114317e-02f, 1.98618993e-01f, 1.31925240e-01f, 4.80539858e-01f, 8.48118216e-02f,
  -8.92023519e-02f, 9.59767401e-02f, -7.84208104e-02f, 3.36469203e-01f, -1.02062136e-01f, 3.06818783e-01f, -5.52991569e-01f, 2.27593239e-02f, 1.95116699e-01f, 1.35859162e-01f,
  1.74003437e-01f, 9.52236950e-02f, -1.34700108e-02f, -4.52590227e-01f, 4.31440026e-01f, -2.42627680e-01f, 8.47176164e-02f, -4.75267828e-01f, -2.58123219e-01f, -1.50324270e-01f,
  -3.62721384e-01f, 2.04738546e-02f, 6.80831134e-01f, 9.21161100e-02f, -2.54004121e-01f, 3.84960890e-01f, -3.29830348e-01f, 2.27993697e-01f, 1.65361136e-01f, -4.92741674e-01f,
  -1.30631283e-01f, 1.46949962e-01f, -3.06784540e-01f, 1.19194068e-01f, 3.19986135e-01f, -2.49931544e-01f, 7.79788911e-01f, 1.44945189e-01f, 7.56496131e-01f, 8.21984038e-02f,
  2.06814587e-01f, 3.12469959e-01f, -2.87116200e-01f, -2.28362158e-01f, 3.81262779e-01f, -2.39642307e-01f, 4.51993823e-01f, -9.51310396e-01f, 3.86873126e-01f, -9.75984752e-01f,
  -5.18870473e-01f, -2.97503263e-01f, 2.25918721e-02f, -7.29520202e-01f, 2.14748368e-01f, -3.57305318e-01f, -4.13368523e-01f, -1.52873844e-01f, 4.00014192e-01f, -3.13101523e-02f,
  4.55459893e-01f, 1.03280738e-01f, -5.64772747e-02f, 8.09889883e-02f, -2.37223178e-01f, 2.10166007e-01f, -7.26501048e-01f, 3.83167267e-01f, 5.41650914e-02f, -5.88712022e-02f,
  -3.60454135e-02f, -1.49336696e-01f, -1.53466314e-01f, 1.25401050e-01f, -3.39874536e-01f, 1.82893559e-01f, 4.11695004e-01f, 5.18042982e-01f, -4.13695455e-01f, -2.77379423e-01f,
  9.46668815e-03f, -3.35203648e-01f, 3.96011829e-01f, -3.01035941e-01f, 4.60652888e-01f, -1.82366267e-01f, -5.85677028e-01f, -1.45126790e-01f, -8.18652362e-02f, 2.53562301e-01f,
  -2.27033123e-01f, -4.51741554e-02f, -6.08431697e-01f, 9.10473108e-01f, 8.07565823e-02f, 6.77221119e-01f, 3.95900272e-02f, -5.16552567e-01f, 5.39793372e-01f, 2.81612962e-01f,
  -2.44336456e-01f, 3.68276983e-01f, -5.92264712e-01f, -2.39418373e-01f, 2.24314764e-01f, 4.74064767e-01f, 3.45111161e-01f, 8.20583850e-03f, 1.81481898e-01f, -4.21511605e-02f,
  9.91805494e-02f, -2.20208950e-02f, 2.94228107e-01f, 2.70219624e-01f, -1.80971429e-01f, -2.37727299e-01f, -3.02615557e-02f, -6.05845451e-01f, -1.65440768e-01f, 1.63195848e-01f,
  2.18454495e-01f, 5.07776380e-01f, -1.79697856e-01f, 9.00232941e-02f, 1.77221805e-01f, -1.65206343e-01f, -3.94025184e-02f, 4.98467892e-01f, -1.96657896e-01f, 3.49126942e-02f,
  1.99691847e-01f, -2.45494157e-01f, 8.73271227e-02f, 1.68644831e-01f, 4.78705406e-01f, 3.94501567e-01f, 1.12891495e-01f, 1.72808126e-01f, 5.77082992e-01f, 2.83541292e-01f,
  -1.70372114e-01f, -3.14603932e-02f, 5.36494255e-02f, 4.28333968e-01f, 3.40544209e-02f, -3.04986179e-01f, 9.51321498e-02f, -4.89547849e-01f, -7.72759616e-01f, -4.13605213e-01f,
  -4.21134144e-01f, -5.19890599e-02f, 5.16365170e-02f, 2.66739100e-01f, 6.98058903e-01f, -5.24354875e-02f, -2.67108619e-01f, -2.66793370e-01f, -1.98249876e-01f, -1.94539979e-01f,
  4.04756814e-01f, 2.03756079e-01f, -9.02725980e-02f, 1.32940531e-01f, 2.38558188e-01f, -4.51169610e-01f, -5.97586453e-01f, -1.25581592e-01f, -1.55586109e-01f, 2.49671847e-01f,
  -1.22741121e-03f, 2.79480606e-01f, -4.79015231e-01f, 7.55488873e-01f, 9.95737500e-03f, -1.99803874e-01f, -4.73955423e-02f, 2.50888348e-01f, -3.31412494e-01f, 1.00715674e-01f,
  -4.76647228e-01f, -5.33971377e-02f, -3.63571882e-01f, 2.04924315e-01f, 1.21952347e-01f, 7.62534738e-02f, -3.74087930e-01f, 1.22853324e-01f, -1.65066585e-01f, -3.79483253e-02f,
  4.74055946e-01f, -2.24564508e-01f, 2.43594065e-01f, -5.10461926e-02f, 2.04737753e-01f, -4.85546261e-01f, 2.12479740e-01f, 6.08468568e-03f, 6.45484030e-02f, -3.06104004e-01f,
  -3.23946536e-01f, 4.35900599e-01f, 5.58667421e-01f, -6.24029860e-02f, 3.68425339e-01f, -2.86575347e-01f, 8.02695565e-03f, 4.09564048e-01f, -2.37131059e-01f, 5.26511848e-01f,
  -3.29334676e-01f, 3.30379337e-01f, 1.08784810e-01f, -6.10549748e-01f, -7.30569437e-02f, 2.52255827e-01f, -6.25617623e-01f, -2.27813199e-01f, 5.15742078e-02f, -4.11195010e-01f,
  3.28067802e-02f, 9.00103897e-02f, -6.39934182e-01f, -4.89636660e-01f, -9.94996279e-02f, 2.31457397e-01f, 5.68998395e-04f, -1.27237201e-01f, -1.56956673e-01f, 1.63621783e-01f,
  -1.83615640e-01f, -3.34860474e-01f, -1.63233474e-01f, -4.02703971e-01f, -9.87165391e-01f, -6.45604670e-01f, -4.94619012e-01f, -5.03365099e-01f, -8.44275057e-01f, 2.36989811e-01f,
  -6.04358852e-01f, 2.44870484e-01f, 7.27233216e-02f, 1.64993718e-01f, 2.64137626e-01f, 3.30476493e-01f, 2.19909921e-01f, -1.58421397e-02f, -3.03000789e-02f, -1.07910700e-01f,
  -5.77553988e-01f, -1.49619997e-01f, -2.28919432e-01f, 1.30342901e-01f, -2.42184371e-01f, 2.62743533e-01f, 8.56310427e-02f, -2.89633244e-01f, -2.38880590e-01f, -1.21964805e-01f,
  2.67438646e-02f, -1.07972771e-01f, -3.45275432e-01f, -1.39510438e-01f, -8.73060152e-02f, -2.01175317e-01f, -3.75108778e-01f, 5.84593192e-02f, -2.88479589e-02f, -2.30303541e-01f,
  6.53209463e-02f, 4.19300795e-02f, -1.02693997e-01f, 1.43038016e-02f, -9.72653031e-02f, 3.70133519e-01f, 2.68277645e-01f, -4.41107482e-01f, 2.11426809e-01f, 4.39033836e-01f,
  -2.95449764e-01f, 1.82292700e-01f, 6.57535270e-02f, -7.87599981e-02f, -1.25043616e-01f, 1.92085460e-01f, 5.48931174e-02f, 2.19053790e-01f, 3.03252012e-01f, -4.91746604e-01f,
  -2.00237304e-01f, 3.26805085e-01f, 5.09984016e-01f, 1.98697507e-01f, 3.00638467e-01f, -4.84260887e-01f, -8.34895149e-02f, 2.42766857e-01f, -2.30396420e-01f, 3.80490832e-02f,
  1.05246589e-01f, -4.55953717e-01f, 2.45952457e-01f, 2.78872728e-01f, 2.27014810e-01f, -5.27134120e-01f, -2.05281097e-03f, -2.98839480e-01f, 2.23307639e-01f, 2.10307315e-01f,
  -6.79922104e-01f, -1.45460233e-01f, -6.12549543e-01f, -1.46681547e-01f, 2.41064861e-01f, 5.22656040e-03f, -6.32497147e-02f, 1.96876988e-01f, 1.83039561e-01f, -6.32737204e-02f,
  -1.66951537e-01f, -7.78963044e-02f, -5.35512507e-01f, 1.82753041e-01f, 2.29037423e-02f, -2.09012836e-01f, -2.13400573e-01f, -3.15425575e-01f, -3.19654942e-01f, -2.55117267e-01f,
  3.93641703e-02f, -2.11749271e-01f, 1.86601281e-01f, 2.13631615e-01f, 1.25942320e-01f, -3.10056627e-01f, 3.38976085e-01f, 4.70388383e-02f, -1.83661684e-01f, -5.22671878e-01f,
  3.80649388e-01f, -6.85670555e-01f, -3.06339979e-01f, -2.53327966e-01f, 6.27358556e-01f, -4.80519146e-01f, -6.82538748e-01f, -5.26612774e-02f, 3.62580121e-01f, -1.35182574e-01f,
  -2.75306642e-01f, -7.92751908e-02f, 4.99276817e-01f, 1.09630808e-01f, -2.33520851e-01f, -7.64876604e-01f, 8.26570988e-01f, 4.35174495e-01f, 6.07507527e-01f, 3.75791907e-01f,
  -6.43773198e-01f, -3.87771994e-01f, -2.45839477e-01f, 3.71550918e-01f, -3.93316478e-01f, -6.38682127e-01f, -4.29599844e-02f, -1.56740472e-01f, -2.21977606e-01f, -1.56045780e-01f,
  -1.88185915e-01f, 1.81227699e-01f, -1.37948751e-01f, 2.21096709e-01f, -6.45864010e-01f, -1.93146423e-01f, -5.21443039e-03f, -2.73708135e-01f, 2.89426953e-01f, -7.17043430e-02f,
  4.12632851e-03f, -2.95276970e-01f, -2.59397775e-01f, 2.65563756e-01f, 2.41728038e-01f, 6.98684081e-02f, 2.46898755e-01f, 3.01526964e-01f, -6.56117946e-02f, 7.19700754e-02f,
  -1.57018602e-01f, 2.40110472e-01f, 4.31604207e-01f, 2.93485612e-01f, 1.14341021e-01f, -2.58928150e-01f, -6.35510087e-02f, -1.16421744e-01f, 2.30342552e-01f, 1.45988345e-01f,
  4.02309179e-01f, -5.31774819e-01f, 1.25128150e-01f, 4.46718633e-01f, 2.76108652e-01f, 1.09543242e-01f, -9.51964110e-02f, -4.60109025e-01f, 8.16189572e-02f, 3.79370719e-01f,
  1.93780083e-02f, 8.03000107e-02f, 2.92442799e-01f, 2.94505090e-01f, 6.99918628e-01f, 6.10463500e-01f, 6.35127164e-03f, -8.93949494e-02f, -1.49898222e-02f, 4.23710376e-01f,
  -2.95051336e-01f, 2.66672760e-01f, -1.79097354e-01f, -3.18899989e-01f, -1.24999201e-02f, -1.96087718e-01f, 6.10580146e-01f, -7.87855446e-01f, -6.91179514e-01f, -5.25356948e-01f,
  -6.37055993e-01f, -2.23245472e-01f, 1.86043248e-01f, 2.55655706e-01f, -3.04812223e-01f, -4.38144624e-01f, -3.33025753e-02f, 3.74968618e-01f, 2.97834486e-01f, 4.18147624e-01f,
  1.27934828e-01f, -4.80206341e-01f, 2.46818811e-01f, -3.74606103e-01f, -2.66651303e-01f, 1.18262850e-01f, 3.67034048e-01f, -7.39212930e-02f, 3.84595603e-01f, -1.07303701e-01f,
  3.74673158e-01f, 5.77173755e-02f, 1.85507953e-01f, 2.68756598e-01f, 4.25942153e-01f, 7.89278001e-02f, -2.16633141e-01f, -1.01146534e-01f, -3.61141205e-01f, -1.22915871e-01f,
  -1.04526877e-01f, -4.03031893e-02f, 1.66110545e-01f, 2.70226836e-01f, 1.40782952e-01f, 5.90021193e-01f, -2.60040760e-01f, -3.59796286e-01f, 3.97501498e-01f, -5.24647295e-01f,
  7.78407574e-01f, 1.63262144e-01f, 2.15542808e-01f, -5.79365492e-01f, -4.85332578e-01f, 7.22274333e-02f, -3.14547062e-01f, -3.69875357e-02f, 4.71059531e-01f, 1.62420049e-01f,
  -4.39144582e-01f, 3.22249949e-01f, 8.18756342e-01f, -4.21413511e-01f, 5.99656343e-01f, -4.79081422e-01f, 4.22889352e-01f, -3.08628683e-03f, 8.48206803e-02f, 5.96670248e-02f,
  2.01781347e-01f, -5.54594219e-01f, 6.45835817e-01f, 2.02439442e-01f, -6.52799606e-01f, -3.38210791e-01f, -3.34265858e-01f, 5.77448666e-01f, -3.50362062e-01f, 2.97612790e-02f,
  -1.81025177e-01f, -2.29854956e-01f, -8.08919549e-01f, -6.54694498e-01f, 4.26668137e-01f, 5.01347959e-01f, 1.21735699e-01f, -1.50806949e-01f, 1.95086494e-01f, -5.35545588e-01f,
  -9.93013829e-02f, 4.86111701e-01f, -5.42708561e-02f, 3.91162395e-01f, 6.78377226e-02f, -1.04898162e-01f, 2.40549922e-01f, -2.49921039e-01f, 1.99193507e-01f, -3.14024352e-02f,
  5.31828880e-01f, -5.45629859e-02f, 1.79353386e-01f, 1.24078400e-01f, -1.99719276e-02f, 3.28588903e-01f, -3.94272476e-01f, -5.72576672e-02f, -2.32028127e-01f, 1.96518600e-02f,
  8.30650389e-01f, -6.08049035e-01f, -7.90447891e-01f, 6.60410464e-01f, 5.46398982e-02f, -7.26366341e-01f, -2.52077013e-01f, -3.80234271e-01f, -1.48434252e-01f, -4.30146813e-01f,
  4.35766935e-01f, 7.07184315e-01f, -1.75958335e-01f, -3.22966993e-01f, -1.76282767e-02f, -5.70194274e-02f, -3.39318782e-01f, 5.70120454e-01f, -7.58032978e-01f, 1.15717642e-01f,
  -6.44335449e-01f, 6.19965553e-01f, -4.56700534e-01f, -4.57031041e-01f, -6.16795123e-01f, -1.23492524e-01f, -1.61429107e-01f, -5.56438923e-01f, 2.56074041e-01f, -2.79451907e-01f,
  4.68322337e-01f, -6.19486332e-01f, 1.32948509e-04f, 7.12624863e-02f, -9.09815788e-01f, 3.16405118e-01f, -2.64452156e-02f, -5.69248796e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.32674867e-01f, -1.15633056e-01f, 8.02755952e-02f, -2.52933800e-02f, -1.71872914e-01f, 3.66445910e-03f, 7.81502128e-02f, 6.77698385e-03f, -3.18652950e-02f, -1.01977602e-01f,
  -8.51673931e-02f, 2.23263457e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    