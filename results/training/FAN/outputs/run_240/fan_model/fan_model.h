/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.45591307e-01f, -1.36094943e-01f, 1.74832210e-01f, -2.74371624e-01f, -1.70593858e-02f, -2.08220407e-01f, -1.21612094e-01f, -2.31936440e-01f, -2.22534183e-02f, -1.84115633e-01f,
  -3.82952765e-02f, 4.91730273e-02f, 1.64931148e-01f, -2.77509063e-01f, -1.85191885e-01f, 7.84833655e-02f, -4.28204656e-01f, -1.75111145e-01f, 2.09499136e-01f, -2.00246647e-01f,
  -5.21298833e-02f, -2.20487893e-01f, -6.97255926e-03f, -4.07528644e-03f, -1.09006599e-01f, 8.75287503e-02f, -6.36598170e-02f, 2.46228978e-01f, -1.88262254e-01f, 2.77330521e-02f,
  2.07425188e-03f, -5.60739711e-02f, 7.23794922e-02f, -1.62676908e-02f, -6.39074594e-02f, -6.51496975e-03f, 1.28509162e-03f, 1.00410961e-01f, 4.88329530e-02f, 1.31727681e-02f,
  4.99873646e-02f, 1.06619718e-03f, -2.02427572e-03f, 5.29256463e-02f, -3.96570973e-02f, 6.04163855e-02f, 3.51142623e-02f, 5.53712435e-02f, 2.42539234e-02f, -5.58414543e-03f,
  8.54951218e-02f, -1.41305784e-02f, -2.38796999e-03f, -3.90277542e-02f, 6.16161041e-02f, 4.36190851e-02f, 4.65342263e-03f, 6.89404160e-02f, -4.98408489e-02f, -2.34372728e-02f,
  2.84032840e-02f, -1.43062416e-03f, 9.37572494e-03f, 2.64709871e-02f, 1.42243765e-02f, 1.94146708e-02f, 1.94446985e-02f, 1.75943077e-02f, 3.74865644e-02f, -2.32470203e-02f,
  -7.14426190e-02f, -8.62668380e-02f, -4.51305462e-03f, -6.05896898e-02f, -4.83915359e-02f, 1.33900344e-02f, -1.47676673e-02f, -4.08850834e-02f, -4.35771532e-02f, 1.34470947e-02f,
  4.70832959e-02f, -5.74290343e-02f, -6.91304740e-04f, -1.42536676e-02f, 9.04394896e-04f, 4.47906146e-04f, -2.65239980e-02f, -3.25672440e-02f, 3.44059058e-02f, -6.21490134e-03f,
  -4.38465625e-01f, -4.16962862e-01f, 2.51790639e-02f, 2.08400041e-02f, -3.73953581e-02f, 3.25533305e-03f, -3.38867912e-03f, 1.07109481e-02f, 3.63966962e-03f, 8.05864204e-03f,
  -2.26074527e-03f, -4.88076918e-02f, -1.09878676e-02f, -2.34771557e-02f, 1.24712689e-02f, -5.58408983e-02f, -3.74629237e-02f, -4.79016602e-02f, -8.75239447e-02f, -4.26745713e-02f,
  -2.66608540e-02f, -1.49902944e-02f, 4.47178185e-02f, 1.71193723e-02f, -5.83013259e-02f, 1.29788322e-02f, -2.58751363e-02f, 6.65463954e-02f, 7.12546892e-03f, -3.87773328e-02f,
  7.69408122e-02f, 6.06009781e-01f, 9.58020613e-02f, 2.76542693e-01f, -4.63697761e-02f, 9.75180343e-02f, 2.31376737e-01f, 1.98589697e-01f, 4.49127883e-01f, 1.81501925e-01f,
  -4.13981415e-02f, 1.19879514e-01f, 1.28799185e-01f, 2.91788906e-01f, -3.18525314e-01f, 1.24040261e-01f, 2.96017051e-01f, 1.37533978e-01f, 2.42756754e-01f, -3.14299837e-02f,
  -4.88405582e-04f, 4.35222462e-02f, -6.70188889e-02f, 5.70129603e-02f, 1.40897542e-01f, 4.53987233e-02f, -3.33544821e-01f, -6.30182251e-02f, -9.37440842e-02f, -2.35641319e-02f,
  5.23648597e-02f, 1.41442418e-01f, 2.90840939e-02f, 3.24178562e-02f, -2.96815969e-02f, -2.55537052e-02f, -8.16006288e-02f, -9.51038226e-02f, -7.32113272e-02f, 6.78041801e-02f,
  1.38662895e-02f, -9.30293649e-02f, 8.77787918e-02f, 2.59295441e-02f, 6.98473603e-02f, -2.09438279e-02f, -5.01115322e-02f, 4.58522327e-02f, 2.13250723e-02f, -1.43768108e-02f,
  1.73261743e-02f, -4.34865542e-02f, -7.52945803e-03f, 5.94808646e-02f, -5.20388149e-02f, -4.58860816e-03f, -4.17298265e-03f, -5.83732836e-02f, 2.33002435e-02f, 6.83477819e-02f,
  -9.26346239e-03f, 6.85929433e-02f, 3.42884548e-02f, 9.31763090e-03f, 3.84949408e-02f, -1.59285951e-03f, 4.61868569e-03f, -6.97308183e-02f, 1.11605730e-02f, -5.87505549e-02f,
  -4.11255248e-02f, 3.74228731e-02f, 5.38501628e-02f, -2.72929575e-03f, -8.04561470e-03f, 1.35078290e-02f, -7.29499236e-02f, 2.63718739e-02f, -3.91514339e-02f, -5.63712455e-02f,
  7.64842555e-02f, 4.81833331e-03f, -5.43954149e-02f, -2.93787960e-02f, 2.59435121e-02f, -6.53266758e-02f, 4.91287336e-02f, 2.58089993e-02f, -4.97106016e-02f, -4.77689765e-02f,
  8.25585723e-02f, 2.13731781e-01f, 2.77410652e-02f, 1.90196242e-02f, 2.42748428e-02f, -1.74607504e-02f, 7.59924501e-02f, 1.51091060e-02f, 2.95095183e-02f, -5.40481461e-03f,
  -6.04886562e-02f, 3.57870422e-02f, -7.72386789e-02f, -7.85541013e-02f, -7.39266351e-02f, -3.15397866e-02f, -7.51333428e-04f, -1.86423268e-02f, 1.52437584e-02f, -1.06694223e-02f,
  -6.61592409e-02f, 5.71562117e-03f, -2.01814156e-03f, 1.98915005e-02f, -1.16801737e-02f, -3.76679450e-02f, -2.18626354e-02f, 3.88528756e-03f, -2.99275778e-02f, 1.02992747e-02f,
  2.73074478e-01f, -2.53250331e-01f, -1.26598954e-01f, 4.07273561e-01f, 1.92086175e-01f, -1.05778992e-01f, -9.40512419e-02f, 1.35417879e-01f, 1.85903370e-01f, -1.26985744e-01f,
  1.77746296e-01f, -1.32711291e-01f, -3.17182809e-01f, 7.62490630e-02f, -1.95120111e-01f, -4.35843855e-01f, 1.46181345e-01f, -5.87888248e-02f, -8.51247925e-03f, 2.23085701e-01f,
  1.52680233e-01f, 1.34207726e-01f, -1.09743185e-01f, 7.90945590e-02f, 1.74045205e-01f, 1.46263421e-01f, 1.35286674e-01f, -7.26832896e-02f, 6.72901571e-02f, -1.03962056e-01f,
  -6.07327558e-02f, 4.95601147e-02f, 1.88336316e-02f, -5.78074269e-02f, 1.01966128e-01f, 3.83068025e-02f, 3.35089527e-02f, -8.26811045e-02f, 3.88949439e-02f, -6.58315420e-03f,
  -1.66158769e-02f, -1.64274406e-03f, 8.89392123e-02f, -6.41033873e-02f, 4.02858183e-02f, 3.24228629e-02f, 1.90528855e-02f, -5.04309172e-03f, 3.05066947e-02f, -1.01574928e-01f,
  -1.06566278e-02f, 3.47387269e-02f, 4.75412123e-02f, 1.99051965e-02f, 7.60081708e-02f, 2.94326711e-02f, -1.84956342e-02f, -5.06973676e-02f, 6.09842791e-05f, 4.13001701e-02f,
  8.49099271e-03f, 4.52502295e-02f, -1.47887738e-02f, 3.46443914e-02f, 5.05395159e-02f, 4.78712842e-02f, 2.96093803e-02f, -9.38858651e-03f, 1.88041013e-02f, 3.29361185e-02f,
  6.69144690e-02f, 3.98953967e-02f, 5.98421693e-02f, 1.18912365e-02f, 4.57493477e-02f, 5.57395592e-02f, -5.15061244e-02f, -3.43328677e-02f, 1.11575641e-01f, 1.77454427e-02f,
  -4.85151224e-02f, 7.58557720e-03f, 1.10058812e-02f, 1.12161543e-02f, -2.52213906e-02f, -6.85978401e-03f, 2.33757664e-02f, -4.10434306e-02f, -3.63824773e-03f, 2.31362842e-02f,
  8.01422745e-02f, 6.70009255e-02f, -9.39740054e-03f, 1.92901623e-02f, -4.79849428e-02f, -5.29239699e-02f, -4.89008836e-02f, 1.38357878e-02f, 7.07828673e-04f, 4.34027985e-02f,
  6.82539567e-02f, 5.41819595e-02f, -7.86270387e-03f, 1.63180754e-02f, -2.56385742e-04f, -2.57909428e-02f, 3.64093408e-02f, 3.91584970e-02f, 5.62079623e-02f, 4.44566980e-02f,
  2.77130660e-02f, 6.40246877e-03f, 3.15445848e-02f, 8.73274282e-02f, -1.88834965e-02f, 6.12976216e-02f, 1.89429950e-02f, -5.60140749e-03f, -2.74583343e-02f, -2.24957312e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.01324973e-02f, 1.62807450e-01f, -9.55383629e-02f, 4.18731198e-02f, 7.28419423e-02f, -1.17059506e-01f, 4.11252317e-04f, 2.78930422e-02f, 1.93288773e-02f, 2.43591502e-01f,
  1.16438761e-01f, 9.60108712e-02f, 2.22439244e-01f, 3.36439647e-02f, -1.02215394e-01f, -4.07140106e-02f, -9.20369755e-03f, 3.92879993e-02f, 5.91546297e-02f, 4.79158349e-02f,
  -1.95602268e-01f, 1.28274009e-01f, -9.01706144e-02f, 2.22515892e-02f, -2.77244430e-02f, -2.69481353e-02f, 8.96675065e-02f, 4.04922813e-02f, -7.86208063e-02f, -1.79719534e-02f,
  -1.89515781e-02f, 8.67487118e-02f, 6.24076556e-03f, -2.64438894e-02f, -2.40680538e-02f, 5.40025905e-03f, -9.54388529e-02f, 5.42849824e-02f, 7.05164075e-02f, -4.56954576e-02f,
  9.30315852e-02f, 1.10912248e-02f, -1.74563043e-02f, 2.20394358e-02f, 6.21518306e-02f, -2.84407362e-02f, -7.85606503e-02f, -5.13671041e-02f, -4.24411893e-02f, -1.14851877e-01f,
  -4.71459776e-02f, -1.10509414e-02f, -1.17370337e-01f, -7.50269890e-02f, -9.45115089e-02f, 2.91532371e-03f, -1.01038128e-01f, -3.68058775e-03f, -2.33209226e-02f, -1.12037644e-01f,
  -3.97704802e-02f, 7.15308264e-02f, -4.12704051e-03f, -2.85653081e-02f, -1.15125272e-02f, -4.25812677e-02f, 6.29515806e-03f, -7.24091977e-02f, 7.14655733e-03f, -8.28422420e-03f,
  -5.15070222e-02f, 4.69689183e-02f, 7.83139393e-02f, -7.54648447e-02f, -4.18610964e-03f, -3.30426544e-02f, 5.78200147e-02f, 5.36901206e-02f, -1.74278847e-03f, -1.03683017e-01f,
  5.09346239e-02f, 3.38611566e-02f, -7.16677681e-02f, -1.87544711e-03f, -6.31676540e-02f, 5.31583317e-02f, 7.43375123e-02f, -5.56066595e-02f, 6.84662536e-02f, 3.11067533e-02f,
  -1.66125208e-01f, -1.19350411e-01f, 4.39934283e-02f, -1.15793152e-02f, -6.67628720e-02f, -7.73348510e-02f, -6.63191304e-02f, 4.76629511e-02f, 9.17735249e-02f, -8.04522634e-02f,
  -1.00639395e-01f, -3.51484343e-02f, 7.67999236e-03f, -4.29191999e-03f, 5.14075533e-02f, 8.81754532e-02f, 4.82731014e-02f, 6.82160258e-03f, 6.52706102e-02f, 2.06796099e-02f,
  -5.45471534e-02f, -3.65279093e-02f, 5.62489852e-02f, -1.82406064e-02f, -5.69400005e-02f, 1.48317255e-02f, 5.42545281e-02f, -4.09107432e-02f, -9.63007472e-03f, -7.30918869e-02f,
  3.55823427e-01f, -4.12051708e-01f, 2.87022650e-01f, 4.58687574e-01f, 6.11378737e-02f, -1.36452526e-01f, 2.60226756e-01f, -8.85791257e-02f, 8.95788819e-02f, -3.84266704e-01f,
  -5.22508333e-03f, 1.29669920e-01f, -1.36956647e-02f, -2.84400098e-02f, 2.55359113e-01f, -5.96914478e-02f, -1.00332879e-01f, 2.64868513e-02f, -3.23697254e-02f, 1.66199636e-02f,
  5.48403598e-02f, 8.95008052e-05f, 1.32116213e-01f, -3.71989220e-01f, 1.06086455e-01f, 1.57633442e-02f, -8.39636102e-03f, 1.47532836e-01f, -1.54990435e-01f, -1.56668499e-02f,
  -2.10620258e-02f, 1.65331189e-03f, -3.93097326e-02f, -8.06431770e-02f, -4.25277092e-02f, -3.98878492e-02f, -1.27985850e-02f, 8.44817683e-02f, 5.71569428e-02f, -9.36076939e-02f,
  8.11132416e-03f, -1.92974322e-02f, 1.00757582e-02f, -6.23035468e-02f, 4.97105718e-02f, -6.46873564e-02f, 7.56570324e-03f, -1.51095241e-02f, 1.92679372e-02f, 8.61164778e-02f,
  3.24983038e-02f, -9.80467647e-02f, 9.97649059e-02f, -8.98051932e-02f, 1.77756324e-02f, 1.63323227e-02f, 1.15581537e-02f, 4.62725721e-02f, -1.21800536e-02f, 7.91418832e-03f,
  -6.87452778e-02f, -3.34146358e-02f, 8.07365179e-02f, -9.52784717e-03f, 5.34893498e-02f, 7.88544938e-02f, -1.93931405e-02f, 9.12993588e-03f, 3.11437994e-02f, 3.43812145e-02f,
  -4.33271658e-03f, 1.07749335e-01f, -5.65044456e-06f, 1.91620253e-02f, -9.00245365e-03f, -3.02136666e-03f, 8.50230530e-02f, -1.82882734e-02f, -9.90158995e-04f, -2.64939815e-02f,
  5.89192882e-02f, 2.68169250e-02f, 3.03387661e-02f, -3.27782109e-02f, -5.68103381e-02f, 3.83901456e-03f, -1.06286347e-01f, -6.43802434e-03f, -3.15242074e-02f, 5.93749061e-02f,
  -1.31062329e-01f, -9.10655633e-02f, -5.05632423e-02f, 7.13749323e-03f, 1.36159267e-02f, -2.37547942e-02f, 3.67529169e-02f, -1.62629351e-01f, -6.27191886e-02f, 1.38714910e-02f,
  -1.21587284e-01f, 6.52409792e-02f, -5.90729117e-02f, 2.03661900e-02f, 8.68680701e-03f, 5.10048307e-03f, 5.32833450e-02f, -3.59181240e-02f, 1.78428681e-03f, -8.20963979e-02f,
  1.08345248e-01f, 1.41389957e-02f, 1.61621962e-02f, -5.46502247e-02f, -8.54779929e-02f, 2.26681922e-02f, 1.45082120e-02f, -6.92533329e-02f, 3.11669875e-02f, -3.11454665e-02f,
  7.48894364e-02f, 1.00230705e-03f, -2.60204613e-01f, 3.30149792e-02f, -6.65801316e-02f, 7.09387064e-02f, 2.43014157e-01f, -1.10524975e-01f, -9.78189930e-02f, 2.76019961e-01f,
  2.76600659e-01f, -1.34124920e-01f, 2.24640056e-01f, 3.33081841e-01f, -9.97391641e-02f, 2.45534852e-01f, 2.76965857e-01f, 2.97780186e-01f, -9.00298059e-02f, 5.94062619e-02f,
  5.56537323e-02f, 1.65087059e-01f, 6.83425292e-02f, -7.11306930e-02f, 1.27215773e-01f, -1.54616669e-01f, 4.95173149e-02f, -1.88780114e-01f, -1.51293352e-02f, -1.06577933e-01f,
  9.01057795e-02f, 6.03416562e-02f, 3.29436697e-02f, -3.94618250e-02f, 1.84588302e-02f, 5.63585572e-02f, 2.33418532e-02f, -1.04527876e-01f, -6.76225964e-03f, 3.81840542e-02f,
  -5.14393002e-02f, -4.28539589e-02f, 1.85834076e-02f, -4.67669714e-04f, -3.19349244e-02f, -9.20937434e-02f, 4.53799814e-02f, 6.00070506e-02f, -2.70064585e-02f, -5.20849265e-02f,
  9.88950022e-03f, -1.37665262e-02f, 7.12368116e-02f, 1.34764276e-02f, 1.95143968e-02f, 3.80418748e-02f, -3.95861752e-02f, -1.62811838e-02f, 2.26031579e-02f, -8.47541913e-02f,
  -5.02588153e-02f, 5.54021597e-02f, 1.23917148e-01f, -3.03526111e-02f, 2.62070280e-02f, 3.45162787e-02f, 3.53758223e-02f, -2.07841545e-02f, -2.75504100e-03f, 1.49415294e-02f,
  -9.00665484e-03f, -6.05727285e-02f, -5.99842221e-02f, 8.15273449e-02f, 7.16415420e-02f, 2.75271703e-02f, 4.38856939e-03f, -2.98921345e-03f, 1.81268007e-02f, 3.30565497e-02f,
  1.20274816e-02f, -9.07633677e-02f, 2.75277551e-02f, 8.48856382e-03f, 2.35244501e-02f, -2.08760742e-02f, -3.43276300e-02f, -1.08296575e-03f, 5.42723648e-02f, 7.70009495e-03f,
  7.57842958e-02f, -1.69708431e-01f, -8.44749957e-02f, -1.55217694e-02f, -8.11116472e-02f, -1.80983040e-02f, 2.00073663e-02f, 1.59647223e-02f, 2.54308786e-02f, 2.02789344e-02f,
  4.87866215e-02f, -5.85519448e-02f, -3.86260301e-02f, -6.32929802e-02f, 4.23069904e-03f, 1.93033423e-02f, -5.42922467e-02f, -8.01902339e-02f, -7.10064173e-02f, -1.41524551e-02f,
  -5.48445545e-02f, 1.72489788e-02f, -9.46294665e-02f, -4.16395850e-02f, -4.10043262e-02f, -2.76215132e-02f, -1.24332249e-01f, 2.91654635e-02f, -3.09842825e-02f, 3.43413763e-02f,
  6.09939620e-02f, 2.24279732e-01f, -7.42603838e-02f, -4.45523411e-02f, -3.80313903e-01f, 2.31488824e-01f, 2.67806917e-01f, -1.53038129e-01f, 6.77484572e-02f, 3.32392722e-01f,
  -3.09019871e-02f, 4.51984219e-02f, 1.05908945e-01f, 2.25827768e-01f, 8.34567286e-03f, 2.30958134e-01f, 3.27306569e-01f, 2.95798689e-01f, -4.45319638e-02f, 4.32893299e-02f,
  -6.44747689e-02f, 2.37727575e-02f, -7.95893520e-02f, -6.42411858e-02f, -1.93434879e-01f, -8.02952796e-02f, -2.16801196e-01f, -1.30785361e-01f, -7.20253363e-02f, -1.23947933e-01f,
  -9.71998181e-03f, -5.01668304e-02f, -7.70991622e-03f, 8.79148841e-02f, 1.01824086e-02f, -4.23588650e-03f, 1.13173395e-01f, -1.54459092e-04f, -6.64347187e-02f, 3.09085529e-02f,
  4.66696694e-02f, 3.91874313e-02f, 1.80824623e-02f, -8.73236358e-02f, -1.00019664e-01f, -2.48130392e-02f, 3.12152156e-03f, -1.27565637e-01f, -3.47891496e-03f, -5.52935898e-02f,
  2.30890419e-02f, 4.54759002e-02f, -9.39370506e-03f, 5.86366691e-02f, -3.49043608e-02f, -4.92315106e-02f, 1.67611048e-01f, -5.27255312e-02f, -8.02029893e-02f, -4.90106493e-02f,
  -1.40283117e-02f, 9.54684839e-02f, 7.94445723e-02f, -4.90547568e-02f, -6.15103962e-03f, -4.97380877e-03f, -2.16113813e-02f, -2.27334015e-02f, -4.03100029e-02f, 5.55121787e-02f,
  7.04793492e-03f, -2.53255703e-02f, -8.16689953e-02f, -6.14710059e-03f, 9.27140936e-02f, 2.71837041e-03f, -7.64528587e-02f, -9.99835692e-03f, 2.56843176e-02f, -3.64349298e-02f,
  -3.34370993e-02f, 1.01601854e-01f, 3.81795615e-02f, 7.23351091e-02f, 3.53356525e-02f, -7.55659863e-02f, 1.06060905e-02f, 4.24069213e-03f, -3.55668813e-02f, -4.55418006e-02f,
  1.46820232e-01f, 1.04888737e-01f, 2.32811645e-03f, 3.36759612e-02f, 6.88131899e-02f, 4.14374880e-02f, -7.92882778e-03f, 6.09938577e-02f, -1.70591585e-02f, 5.97077515e-03f,
  -7.96655267e-02f, 1.00771517e-01f, 8.30048025e-02f, -6.59072325e-02f, 1.95144471e-02f, -1.59319900e-02f, -3.42758670e-02f, 3.16240117e-02f, -2.84631830e-03f, -1.00556575e-01f,
  -8.42370167e-02f, -1.36725511e-02f, 8.69492218e-02f, 1.85326673e-02f, 8.13910738e-03f, 5.06462976e-02f, -2.49854214e-02f, -1.03300530e-02f, -6.07401691e-02f, 7.23600164e-02f,
  2.11690083e-01f, -3.38834338e-02f, -5.15061438e-01f, -3.43503207e-01f, -1.66817904e-01f, -5.59033573e-01f, -5.21373272e-01f, -1.46037623e-01f, 1.17772251e-01f, 5.56782559e-02f,
  6.23422600e-02f, 3.72719280e-02f, 1.98872060e-01f, -3.25634152e-01f, -1.36456192e-01f, 1.16720706e-01f, -4.45749849e-01f, -1.44225582e-01f, -1.27522796e-02f, -1.30731821e-01f,
  -1.23755492e-01f, -6.57512620e-02f, -2.17262864e-01f, -5.68189584e-02f, -3.29893440e-01f, -2.61289626e-02f, 1.77936733e-01f, -5.15606403e-02f, -2.86619365e-01f, -9.93863195e-02f,
  -1.35906264e-01f, 1.46180391e-01f, -1.13624632e-01f, 8.73213913e-03f, -1.74834475e-01f, -8.45995173e-02f, -1.27825975e-01f, -1.18788052e-02f, -1.73504595e-02f, -4.31849100e-02f,
  4.27828077e-03f, 1.21622093e-01f, -4.26541120e-02f, 4.41207327e-02f, 8.07505697e-02f, -5.21436660e-03f, -4.68949527e-02f, -3.99766564e-02f, -4.63004187e-02f, 1.33196181e-02f,
  -9.15484652e-02f, -1.24937426e-02f, -3.34868580e-02f, 7.53148273e-02f, -1.60790160e-02f, -1.81959067e-02f, -2.10923885e-04f, -7.05207586e-02f, 1.64312962e-02f, 8.67396407e-03f,
  9.81583074e-02f, 2.50805765e-02f, 2.26434525e-02f, 7.55191967e-03f, 2.06255075e-02f, -1.16479630e-02f, 4.27299701e-02f, 2.98389979e-02f, -3.35519873e-02f, -2.65496988e-02f,
  -1.03355283e-02f, -7.19175786e-02f, 3.33912335e-02f, -2.09065410e-03f, -3.07750702e-02f, 4.92970943e-02f, 1.44303376e-02f, 2.80641131e-02f, -1.02646627e-01f, -5.35367951e-02f,
  6.77471757e-02f, -3.09573971e-02f, -2.20139716e-02f, 9.96251777e-03f, -7.19000995e-02f, -3.65046002e-02f, 1.67115014e-02f, 2.28767674e-02f, 1.55786928e-02f, 4.52386178e-02f,
  -1.50925159e-01f, -6.28744960e-02f, -6.17259480e-02f, 7.60742128e-02f, -3.77404578e-02f, -2.76391972e-02f, 1.08653298e-02f, -8.09726417e-02f, -7.93621317e-03f, 5.16683655e-03f,
  -7.23391473e-02f, 5.23603568e-03f, -6.54605702e-02f, 1.10518776e-01f, -4.10542339e-02f, -9.88391265e-02f, 5.07950932e-02f, 1.27157578e-02f, -9.17595401e-02f, -1.81041993e-02f,
  -4.40391758e-03f, 5.47243953e-02f, -1.69933159e-02f, -2.17491165e-02f, 4.35252152e-02f, 1.41718034e-02f, -4.38660122e-02f, 9.25518796e-02f, 3.74229066e-02f, -3.27431923e-03f,
  -3.15863460e-01f, -6.09694561e-03f, -3.22315872e-01f, 5.00628017e-02f, 1.01947330e-01f, 2.33271942e-01f, 1.37685165e-01f, 1.10903345e-01f, -1.71361521e-01f, 1.79953530e-01f,
  2.92398125e-01f, -2.24029556e-01f, -9.92804691e-02f, 3.72162700e-01f, 1.15522496e-01f, 1.13239102e-01f, 3.17674965e-01f, 2.58877993e-01f, -9.90024433e-02f, -1.43632188e-01f,
  6.01609647e-02f, 3.51621687e-01f, 1.42117009e-01f, 1.02709487e-01f, 9.78523120e-02f, -1.58666000e-01f, 7.38217011e-02f, -2.23213434e-01f, 2.73400217e-01f, 1.61897361e-01f,
  9.37085133e-03f, -2.87273973e-01f, -1.67213917e-01f, -4.37048525e-02f, -7.23778009e-02f, -9.50491205e-02f, -8.41106325e-02f, -3.97512726e-02f, -8.33064541e-02f, -2.89914533e-02f,
  -1.39081284e-01f, -1.12623889e-02f, 7.10672811e-02f, -5.60534969e-02f, 3.12967114e-02f, 1.16698286e-02f, 4.64935638e-02f, 3.03833224e-02f, -4.28814115e-03f, -5.41005880e-02f,
  -6.61618486e-02f, 8.90223384e-02f, 8.20783526e-02f, 9.63263437e-02f, 2.78414153e-02f, 4.89355884e-02f, 6.87006488e-02f, -3.96317206e-02f, 9.74958390e-02f, 1.04218058e-01f,
  -6.26888722e-02f, -1.01843037e-01f, -3.02540287e-02f, 1.56409033e-02f, 2.47252993e-02f, -1.20491572e-02f, 6.34314418e-02f, 9.80963279e-03f, -3.56691564e-03f, 5.69299050e-02f,
  -4.52987431e-03f, -3.23634185e-02f, 5.77170216e-02f, 2.65238639e-02f, 7.20797526e-03f, -3.36904489e-02f, -6.20378479e-02f, 1.88303385e-02f, 4.84476574e-02f, 1.73906013e-02f,
  -3.34455594e-02f, 2.71573383e-02f, 5.70430197e-02f, -1.11656031e-02f, -5.02784215e-02f, 6.05539884e-04f, 1.49030089e-02f, 1.55039877e-02f, 4.92191166e-02f, 2.69090869e-02f,
  -6.22684173e-02f, -3.41898948e-01f, -6.52128011e-02f, -5.30514121e-02f, 1.86892096e-02f, 7.94556811e-02f, -7.18750730e-02f, 2.26663165e-02f, -2.38724090e-02f, -4.03952450e-02f,
  3.69540267e-02f, 1.09235132e-02f, -5.02340421e-02f, -1.41563574e-02f, -5.51010063e-03f, 6.74178032e-03f, -1.98095455e-03f, -2.15476821e-03f, -1.86832007e-02f, 3.21648791e-02f,
  5.57760894e-03f, -8.60757679e-02f, 4.78060171e-02f, 6.09447099e-02f, 9.40736085e-02f, 6.80663958e-02f, -4.43697013e-02f, -6.79033101e-02f, 7.95429666e-03f, 3.88477109e-02f,
  4.46757644e-01f, -8.29550624e-02f, -9.62670818e-02f, 1.45559371e-01f, 9.47976112e-02f, 1.49374247e-01f, 5.20939156e-02f, 1.88249037e-01f, 1.57599539e-01f, 3.15251127e-02f,
  -3.23348376e-03f, 4.24414054e-02f, -2.10628226e-01f, 9.56574008e-02f, 3.27413119e-02f, -1.15487836e-01f, 1.45743504e-01f, 4.17771786e-02f, 1.37957577e-02f, 1.40581012e-01f,
  9.20592546e-02f, 2.05346510e-01f, -9.71667916e-02f, 4.87622954e-02f, 2.48524144e-01f, 4.71042134e-02f, 3.43806818e-02f, -8.28795061e-02f, 6.04099296e-02f, -7.03733638e-02f,
  6.23235032e-02f, 7.07478747e-02f, -3.91863286e-02f, 1.10035297e-02f, -1.16256420e-02f, -4.05851193e-02f, -9.34637114e-02f, 5.15466975e-03f, 2.41751820e-02f, 1.29588069e-02f,
  -6.65891841e-02f, 6.19446822e-02f, 1.15307264e-01f, -1.44438054e-02f, 8.95506889e-02f, 6.54977188e-02f, 5.65472357e-02f, -6.18159845e-02f, 6.18870892e-02f, 9.82896239e-03f,
  2.66503561e-02f, 8.03594962e-02f, 4.09360938e-02f, -1.03347085e-01f, -4.09516655e-02f, 7.07071200e-02f, -8.69698972e-02f, -6.12974279e-02f, 5.87871671e-02f, 3.77276577e-02f,
  1.59848616e-01f, -7.62980245e-03f, -2.76677236e-02f, -1.79799534e-02f, -2.99291555e-02f, 6.27735863e-03f, -5.11331148e-02f, -6.21808842e-02f, -8.46129656e-02f, -2.88466960e-02f,
  -1.15013979e-02f, -2.62253825e-02f, -4.80964984e-04f, 4.17110622e-02f, -1.69905275e-02f, -3.54543030e-02f, 4.09631506e-02f, -5.55315018e-02f, -1.57353077e-02f, 4.50166613e-02f,
  -9.77334008e-02f, -2.36540567e-02f, -6.48130104e-02f, 7.09225461e-02f, -3.82286981e-02f, -9.60264653e-02f, -1.66588556e-02f, -6.13611843e-03f, 3.26595944e-03f, 3.89762819e-02f,
  -4.75550257e-02f, -3.19439135e-02f, 1.20568732e-02f, -9.26476278e-05f, -1.02097861e-01f, 8.86992887e-02f, -1.24612547e-01f, 1.45070208e-02f, -3.70863341e-02f, 5.77522162e-03f,
  1.46504538e-02f, -3.97504866e-02f, 8.72834772e-02f, 3.01143918e-02f, -1.43744983e-02f, 7.23658949e-02f, -6.29181564e-02f, -6.41662814e-03f, -5.32751493e-02f, 2.06118301e-02f,
  -2.65256129e-02f, 7.86015391e-02f, -6.87855259e-02f, -1.78222451e-02f, -6.24474622e-02f, -7.08351433e-02f, -1.13152107e-02f, 1.47019951e-02f, 5.50690433e-03f, -9.82030407e-02f,
  4.94929478e-02f, -3.49424630e-01f, -4.99256477e-02f, -6.36523217e-02f, -7.84314424e-02f, 3.30617130e-01f, 5.82258344e-01f, -4.04379934e-01f, -4.53059852e-01f, -3.66234481e-02f,
  1.43698245e-01f, 1.69153199e-01f, 2.35521957e-01f, -9.89738386e-03f, 4.42159384e-01f, 1.72481447e-01f, 7.83461779e-02f, 2.41840318e-01f, -2.13422462e-01f, -8.61729160e-02f,
  -1.27778843e-01f, 1.52473882e-01f, 1.72603816e-01f, -2.46767372e-01f, 5.81287481e-02f, -3.16204935e-01f, 1.18941009e-01f, 1.29549563e-01f, -3.95839335e-03f, 2.55412072e-01f,
  9.27691758e-02f, -1.71691626e-01f, -4.52449769e-02f, -1.01710558e-01f, -1.75723422e-03f, 4.96561034e-03f, 1.41817570e-01f, 1.70825034e-01f, 1.54124172e-02f, -1.29456343e-02f,
  1.36177063e-01f, -3.72152366e-02f, -1.67542964e-01f, 3.22112069e-02f, -1.06062785e-01f, -9.48946625e-02f, -1.59715444e-01f, -1.19950816e-01f, -7.73357134e-03f, -5.56215160e-02f,
  -7.31962100e-02f, 1.33668538e-02f, -9.03336331e-02f, 4.06103693e-02f, -4.28539813e-02f, -9.39043015e-02f, 2.20054295e-02f, 1.76993623e-01f, -9.63407308e-02f, -1.27648756e-01f,
  6.94702044e-02f, 4.72915471e-02f, -4.51392931e-04f, 3.91570758e-03f, 3.73642705e-02f, -3.13539244e-02f, 5.72500676e-02f, 1.93593558e-02f, 3.03862114e-02f, 3.31963338e-02f,
  -2.77023464e-02f, -7.48882955e-03f, -4.20911759e-02f, 1.92718636e-02f, -1.38733201e-02f, 1.25806336e-03f, 8.05388689e-02f, -1.92385241e-02f, -2.50002109e-02f, -5.33714285e-03f,
  -4.23943298e-03f, 7.58092338e-03f, -1.98576916e-02f, 9.20315236e-02f, 9.29574072e-02f, 4.96556200e-02f, -3.84948216e-02f, -1.91441029e-02f, -6.40975684e-02f, 1.45623446e-01f,
  -6.83922693e-02f, -1.45530924e-01f, -1.19073847e-02f, -1.36651518e-03f, 3.78872082e-02f, -5.10282218e-02f, 8.42498057e-03f, -5.94433248e-02f, -2.69097406e-02f, -1.01328231e-02f,
  -6.48813769e-02f, 3.75656132e-03f, -3.95622589e-02f, 7.38065913e-02f, 3.25550996e-02f, -1.12431102e-01f, 1.28083825e-01f, 3.09316255e-02f, 4.19141501e-02f, -4.32808064e-02f,
  4.08574753e-02f, 5.63700236e-02f, 2.26292759e-02f, -1.00672297e-01f, 3.45302443e-03f, 4.01159748e-02f, 3.51324975e-02f, -3.64727527e-02f, 4.28236127e-02f, 2.58086845e-02f,
  4.49367136e-01f, -4.46535110e-01f, -1.69955015e-01f, 2.20270455e-01f, 3.25758904e-01f, 1.75367564e-01f, 1.78979546e-01f, -2.92998720e-02f, 3.63955856e-03f, -3.40182155e-01f,
  -3.46981622e-02f, -7.78545588e-02f, -1.34680927e-01f, 1.83003455e-01f, 4.54257876e-01f, -5.63945249e-02f, 1.17040470e-01f, 3.65752578e-02f, 1.11754620e-02f, 3.75235192e-02f,
  1.49780676e-01f, 1.90639347e-01f, -6.57293946e-02f, -7.85810202e-02f, 2.31442422e-01f, -1.42833561e-01f, 3.09895317e-04f, -8.14351439e-02f, -5.66110052e-02f, 1.28916800e-01f,
  1.33464143e-01f, 6.01349398e-02f, 2.28218567e-02f, -6.70110015e-03f, -1.26399854e-02f, 9.93972942e-02f, 2.34417226e-02f, 9.41956863e-02f, -2.42419373e-02f, 4.14756127e-02f,
  4.78062928e-02f, 2.46610455e-02f, -5.06117679e-02f, 9.86077785e-02f, 6.88159838e-02f, 4.79420787e-03f, -4.26814333e-02f, 5.21278474e-03f, -5.33658005e-02f, -2.51654051e-02f,
  -6.94086701e-02f, -9.23555065e-03f, 4.07756492e-02f, -4.07696404e-02f, -5.73816821e-02f, 3.10985986e-02f, 3.76668088e-02f, -9.87397134e-02f, -1.13078460e-01f, 4.91091684e-02f,
  -4.44000959e-02f, 2.23135483e-02f, 4.45888704e-03f, 6.09441176e-02f, 2.62615308e-02f, 4.74123424e-03f, 4.01181616e-02f, -9.54831913e-02f, -3.76112238e-02f, 1.38885528e-02f,
  -4.90716696e-02f, 2.10568239e-03f, 3.52703407e-02f, -2.99805980e-02f, 6.92189783e-02f, 1.39327059e-02f, 3.11086010e-02f, 2.88753002e-03f, -6.39068857e-02f, 4.02531140e-02f,
  1.47063406e-02f, 4.84096557e-02f, -1.21606393e-02f, -6.47476539e-02f, -3.28790061e-02f, 5.33126853e-02f, 5.23114428e-02f, 6.07053116e-02f, 6.74044248e-03f, -2.66264323e-02f,
  -5.27754016e-02f, -2.27328181e-01f, -5.41455261e-02f, -6.50760233e-02f, -7.38950148e-02f, -2.31386125e-02f, 4.43624659e-03f, 3.31389420e-02f, 3.64441611e-02f, 8.60212520e-02f,
  4.60024504e-03f, -3.70101184e-02f, -3.02565983e-03f, -3.63559462e-02f, -1.08742295e-02f, 5.40116355e-02f, -4.73415442e-02f, -9.23649073e-02f, -6.10341392e-02f, -4.52624001e-02f,
  1.09141162e-02f, -7.56046176e-02f, 1.88401453e-02f, 1.60838477e-02f, -4.08782884e-02f, -1.02462415e-02f, -5.49424142e-02f, -4.38047014e-03f, -2.84714140e-02f, -6.28922209e-02f,
  -9.54935998e-02f, 1.30118638e-01f, -2.03840911e-01f, 2.11878750e-03f, -6.74140006e-02f, -3.71090919e-02f, -3.34092081e-02f, -7.82661512e-02f, 6.35363683e-02f, 2.41835415e-01f,
  -9.32485759e-02f, 2.35521629e-01f, 8.71735252e-03f, -2.56691068e-01f, -2.64480412e-01f, -1.72694638e-01f, -3.94629277e-02f, 2.54629981e-02f, 3.80077027e-02f, 7.26927593e-02f,
  -1.39205396e-01f, -9.57654640e-02f, -4.32260185e-01f, -6.27582669e-02f, -9.90451574e-02f, 5.41662565e-03f, 1.11319318e-01f, -2.26089954e-02f, -2.87357671e-03f, -2.30255947e-02f,
  -1.25591949e-01f, -6.20289566e-03f, -5.39605767e-02f, -3.53286900e-02f, 7.84512013e-02f, -2.97730342e-02f, 3.62219289e-02f, -1.07075281e-01f, -5.80200143e-02f, 3.69320367e-03f,
  9.41146463e-02f, 1.76275223e-02f, 1.01910882e-01f, -8.52378272e-03f, 3.83490771e-02f, -4.59251888e-02f, 1.04189059e-02f, -8.42997730e-02f, 3.76787819e-02f, -1.10518098e-01f,
  -8.67137387e-02f, 4.70236689e-02f, 2.77908314e-02f, 3.56347412e-02f, 3.57887186e-02f, 1.56314559e-02f, -4.17215936e-02f, 3.48541774e-02f, 5.58627360e-02f, 1.02997571e-01f,
  5.85258268e-02f, -3.03843850e-03f, 1.17881140e-02f, -8.05749297e-02f, -3.59462947e-02f, -7.52859637e-02f, 1.36652999e-02f, 2.31847111e-02f, 6.86301142e-02f, -1.37300259e-02f,
  -2.78935041e-02f, 3.41901882e-03f, 3.09179965e-02f, 1.71087421e-02f, -5.04769534e-02f, 7.69518092e-02f, -4.17469479e-02f, 1.45223234e-02f, 2.84596011e-02f, -4.04522493e-02f,
  2.41965409e-02f, 1.07090943e-01f, 3.50452363e-02f, -2.38784980e-02f, -4.42658830e-03f, 6.09650239e-02f, -3.37471697e-03f, -3.45890485e-02f, 5.37424441e-03f, -1.60948113e-02f,
  9.62477475e-02f, 3.28232795e-01f, 1.05569147e-01f, -2.39511188e-02f, 1.87136885e-02f, 4.18056808e-02f, 2.16692630e-02f, 6.40033409e-02f, 1.47787035e-01f, 7.14809969e-02f,
  1.01325504e-01f, 1.12403445e-01f, 6.80593178e-02f, -1.18638128e-01f, -4.21433942e-03f, 1.48014814e-01f, -5.24242269e-03f, 1.54114999e-02f, 5.90641685e-02f, -1.78841464e-02f,
  1.07401483e-01f, 4.64888923e-02f, 8.64554793e-02f, 8.06898624e-02f, 1.17306404e-01f, 1.50124012e-02f, 7.57223144e-02f, -7.56946132e-02f, 6.59670681e-02f, 3.96247916e-02f,
  -1.37432501e-01f, -1.42026916e-01f, 5.15732169e-01f, -5.01887314e-03f, 3.43190193e-01f, 6.05960190e-01f, 3.78793776e-01f, 2.82443970e-01f, 4.60463971e-01f, -4.23450589e-01f,
  -1.76519796e-01f, -4.15989161e-01f, 2.52387617e-02f, -3.23762238e-01f, 3.85635585e-01f, 2.22421452e-01f, 1.56296238e-01f, -4.88313884e-02f, 1.80624053e-01f, 1.69371925e-02f,
  9.16438326e-02f, -2.73354024e-01f, -9.27041471e-02f, -1.88592821e-01f, -2.27474108e-01f, -1.81989193e-01f, -4.16987658e-01f, 1.28352702e-01f, -4.06104058e-01f, 4.98823896e-02f,
  -4.47727479e-02f, -1.85445338e-01f, -1.67856961e-01f, 1.37927048e-02f, 4.58368994e-02f, 3.47018300e-04f, -2.61664782e-02f, -3.23279239e-02f, 7.82044008e-02f, 7.95045644e-02f,
  -6.53990582e-02f, -3.27979028e-02f, -5.89224286e-02f, 5.48063144e-02f, 6.19283430e-02f, -3.35295714e-04f, 7.39416778e-02f, 2.60831024e-02f, 3.03527340e-02f, 1.25016272e-01f,
  6.02471493e-02f, 6.94328099e-02f, 2.87944358e-03f, 3.14535201e-02f, -3.11953444e-02f, 2.41915565e-02f, -1.05301840e-02f, 5.11678942e-02f, 1.20583992e-03f, -6.39142981e-03f,
  -4.30082567e-02f, 8.93038437e-02f, -3.94462496e-02f, -6.63751438e-02f, -5.15497057e-03f, -1.35939140e-02f, -4.07786593e-02f, -1.42425835e-01f, 1.28601883e-02f, -2.48655956e-02f,
  -4.26496379e-02f, -1.02133952e-01f, 6.01657405e-02f, 8.04226752e-03f, -5.88169694e-02f, -4.91132997e-02f, 6.23108679e-03f, -1.40989972e-02f, 1.00884363e-02f, -4.96720895e-02f,
  -4.05403227e-02f, 1.65567757e-03f, -5.47307320e-02f, -3.30205970e-02f, 3.51213701e-02f, -6.34624111e-03f, -5.77799268e-02f, 8.83091390e-02f, 2.74280980e-02f, 9.28090978e-03f,
  1.11749142e-01f, 3.05319782e-02f, -1.10852256e-01f, -6.92128763e-02f, 1.35849016e-02f, -6.25423267e-02f, 1.02576651e-02f, 4.73140962e-02f, 1.47805095e-01f, -3.51969078e-02f,
  7.39079388e-03f, -4.85149175e-02f, -7.46912286e-02f, -1.94856562e-02f, 5.04181907e-02f, -1.02742827e-02f, -7.15047568e-02f, 1.02698794e-02f, 3.57555458e-03f, -2.18783822e-02f,
  -1.22531474e-01f, -2.15866510e-02f, 8.79482701e-02f, -1.01559363e-01f, -1.52211741e-01f, -8.34499002e-02f, -2.59510037e-02f, 1.01666786e-02f, 2.92937979e-02f, 9.04335082e-02f,
  5.13945110e-02f, -1.43716946e-01f, -5.42860210e-01f, -2.16227293e-01f, 2.56267726e-01f, 1.58685297e-01f, -1.50672644e-02f, 5.01814224e-02f, -2.61173218e-01f, 2.58658439e-01f,
  2.73080885e-01f, -2.49862209e-01f, -1.41435549e-01f, -1.13338530e-01f, -2.18166381e-01f, -1.89759433e-01f, -5.37805557e-02f, 2.47356873e-02f, -1.70475036e-01f, 8.65154639e-02f,
  -1.35919020e-01f, 2.47113854e-01f, -2.85261154e-01f, 2.66121566e-01f, 2.13926479e-01f, 4.68406901e-02f, 1.82635829e-01f, 2.61907931e-02f, 1.40203550e-01f, 1.48292884e-01f,
  -9.47476923e-02f, -1.29308984e-01f, -1.53662823e-02f, -5.47798276e-02f, 1.08155739e-02f, 1.30903840e-01f, -5.95619145e-04f, -2.72948518e-02f, -8.33930075e-02f, 1.95577983e-02f,
  4.38331626e-02f, 5.73927201e-02f, 1.30718080e-02f, -9.04694125e-02f, -2.90725939e-03f, -7.11938292e-02f, -1.00564942e-01f, -4.63176817e-02f, -1.16135515e-01f, -1.15536945e-02f,
  -1.41513124e-01f, 4.61866297e-02f, 4.54885066e-02f, -7.14467391e-02f, -5.43766953e-02f, -4.30665426e-02f, -9.80572253e-02f, 4.71246652e-02f, 5.46044968e-02f, 3.75364791e-03f,
  9.76910889e-02f, 1.09270088e-01f, 4.07176279e-02f, 1.48651684e-02f, -7.44606107e-02f, 5.77421002e-02f, 1.09171132e-02f, -4.98558022e-03f, -7.07651526e-02f, 2.57008187e-02f,
  -7.36680999e-02f, -2.58959178e-02f, -2.27623545e-02f, 7.01108500e-02f, 4.64818478e-02f, 1.33308477e-03f, -3.30973081e-02f, -1.72209498e-02f, -8.46793056e-02f, -1.34036124e-01f,
  9.28707141e-03f, -3.54115702e-02f, 2.64474098e-02f, -4.93993983e-02f, -3.88233624e-02f, 1.42763555e-02f, 5.54520078e-02f, -3.21925711e-03f, -5.18703833e-02f, 8.95216465e-02f,
  5.71379960e-02f, 1.22824103e-01f, -6.64505735e-02f, -4.75605652e-02f, 2.95398501e-03f, 8.18550438e-02f, 1.58310905e-02f, 2.87950598e-02f, 3.67876962e-02f, -5.77424839e-02f,
  1.02610633e-01f, -5.66177145e-02f, 8.25905874e-02f, -1.17959715e-02f, -1.20480526e-02f, 1.05785944e-01f, 6.28824830e-02f, 6.38287291e-02f, 8.14299583e-02f, 1.43607464e-02f,
  5.78131936e-02f, 5.34805935e-03f, -4.08810824e-02f, 3.09905671e-02f, 7.02364966e-02f, 8.42610970e-02f, 5.05033322e-02f, -8.19424167e-02f, 8.25149640e-02f, 1.50707001e-02f,
  9.57063287e-02f, 2.41322741e-01f, 3.70656326e-03f, 1.75593108e-01f, -5.35099991e-02f, 2.85023868e-01f, 3.93894762e-01f, 6.95110392e-03f, 3.31826180e-01f, 2.46022120e-01f,
  1.28306467e-02f, 1.46083087e-01f, 4.54440415e-02f, 2.66204625e-01f, 1.82319149e-01f, 2.16921732e-01f, 3.48595738e-01f, 2.54920125e-01f, 9.00277123e-02f, 1.84712321e-01f,
  3.17832758e-03f, 1.39172658e-01f, -1.27558246e-01f, -2.39965886e-01f, -1.13135455e-02f, -2.03874543e-01f, -8.79913568e-02f, -2.13854149e-01f, -1.15051679e-01f, 4.58425805e-02f,
  -6.31217426e-03f, 2.02004276e-02f, -1.22917973e-01f, -4.77344245e-02f, 3.89645621e-02f, 4.43348382e-03f, -1.09003065e-02f, -7.96273258e-03f, 1.17246127e-02f, -2.11835429e-02f,
  5.46173714e-02f, -1.30043346e-02f, 2.15259325e-02f, 3.78862992e-02f, 2.84205731e-02f, -3.06353550e-02f, -3.20432484e-02f, -1.23154409e-01f, 6.00452535e-02f, -1.33636653e-01f,
  -7.10229874e-02f, 2.57028975e-02f, 5.98994344e-02f, 7.52017796e-02f, -4.18306142e-02f, 5.18836826e-02f, 2.01908275e-02f, 4.97634709e-03f, 8.04536119e-02f, 6.13352545e-02f,
  3.20346863e-03f, 8.80148336e-02f, 5.47567792e-02f, -4.44088690e-02f, 6.17460832e-02f, -7.67750442e-02f, 2.76504420e-02f, -4.34296057e-02f, 6.57627955e-02f, -1.43634565e-02f,
  -3.95728834e-02f, -6.28596470e-02f, -5.46848699e-02f, -4.26539034e-03f, 9.69113316e-03f, 4.20873947e-02f, 4.66812728e-03f, 2.81953141e-02f, -4.37679747e-03f, 1.30683249e-02f,
  -4.36944515e-02f, 1.56280585e-02f, -3.07240114e-02f, -9.06957462e-02f, -5.50942011e-02f, 2.04482786e-02f, -3.14851590e-02f, 1.13983173e-02f, 1.87722500e-02f, -2.51556304e-03f,
  1.42381415e-01f, 3.50779533e-01f, 2.37006638e-02f, 5.97611219e-02f, 3.41470391e-02f, -4.97541800e-02f, 6.07868582e-02f, 1.42580466e-02f, 6.36806116e-02f, 1.63402095e-01f,
  1.22520622e-04f, -5.17659821e-02f, 2.86873430e-02f, -3.39074135e-02f, 8.07658434e-02f, 5.58972433e-02f, 1.11580066e-01f, 8.33913088e-02f, -3.08865518e-03f, -4.42066118e-02f,
  3.21353674e-02f, -4.30766214e-03f, -1.00315949e-02f, -1.94621067e-02f, 6.32204935e-02f, 3.09282318e-02f, 5.97318728e-03f, -3.62080671e-02f, -7.31692463e-02f, 5.96553832e-02f,
  2.85187125e-01f, 3.59735787e-01f, 2.61413813e-01f, 1.18826680e-01f, -1.69606850e-01f, 4.31253314e-02f, 2.79217772e-02f, -2.41543781e-02f, 3.12807038e-03f, 5.97422235e-02f,
  -1.60775259e-01f, 3.85616988e-01f, -1.66870967e-01f, 5.16185015e-02f, -3.26947510e-01f, -3.65491331e-01f, 9.54070035e-03f, 7.30340183e-03f, 1.77571736e-02f, 1.07931629e-01f,
  -7.52574652e-02f, -3.34225327e-01f, -1.24179296e-01f, -2.16514885e-01f, 2.51906902e-01f, 1.38384283e-01f, -2.45472267e-01f, -5.68777847e-04f, 7.17793107e-02f, -1.54550597e-01f,
  -3.91179658e-02f, -3.52662094e-02f, 1.60455376e-01f, 4.18987721e-02f, -1.37941819e-02f, 1.08376153e-01f, 5.84229752e-02f, -7.90730417e-02f, 2.63752285e-02f, 5.88767752e-02f,
  7.83193409e-02f, 4.59047519e-02f, 8.78962427e-02f, -2.66657099e-02f, 6.14002310e-02f, 5.88457696e-02f, 5.98726682e-02f, 1.34992167e-01f, 1.00416481e-01f, 4.43647169e-02f,
  1.30203784e-01f, 6.38111904e-02f, 2.52772309e-02f, 7.07620978e-02f, -5.05368039e-02f, 6.63874596e-02f, -6.70950045e-04f, 9.31056961e-02f, 1.23335615e-01f, 5.10802530e-02f,
  -8.91865697e-03f, -8.28044862e-02f, 4.80155423e-02f, 7.59337693e-02f, -4.81242035e-03f, -6.16696067e-02f, 6.01574741e-02f, -7.81089440e-02f, -5.50878718e-02f, -6.03836700e-02f,
  2.78433468e-02f, -2.28826478e-02f, -5.89379156e-03f, -4.57705511e-03f, 1.95181277e-02f, 2.63278726e-02f, 6.19401075e-02f, 4.30317707e-02f, 2.88104103e-03f, 4.74311933e-02f,
  -7.10025579e-02f, -2.83801816e-02f, -1.85442194e-02f, 3.70779932e-02f, -6.20255172e-02f, -9.93031114e-02f, 1.01750130e-02f, 1.05450340e-01f, -2.84252223e-02f, -9.85523909e-02f,
  -3.73675302e-02f, -1.55200019e-01f, -8.40849206e-02f, 1.17189791e-02f, -1.68232154e-02f, -2.25291308e-02f, -3.31975706e-02f, -1.80205554e-02f, -6.18077330e-02f, -4.84738611e-02f,
  2.38887426e-02f, -4.00080942e-02f, 1.64295752e-02f, 8.24703276e-03f, -1.92082264e-02f, -7.85120875e-02f, 1.15349097e-02f, -5.21553420e-02f, -8.24142545e-02f, 7.77623951e-02f,
  1.04174241e-01f, 5.14686294e-02f, 5.37914820e-02f, -4.67947684e-02f, -2.72433441e-02f, 5.49105592e-02f, 1.24616083e-02f, 6.88848272e-02f, 8.33822861e-02f, 2.44855862e-02f,
  1.89829469e-01f, 1.16398133e-01f, -9.10247713e-02f, 2.11929798e-01f, -1.38261572e-01f, -2.80926734e-01f, -2.85967469e-01f, -1.15339709e-02f, -9.64532942e-02f, 1.19085480e-02f,
  1.23490661e-01f, 1.37449428e-01f, -6.47457838e-02f, 1.67049050e-01f, 3.03409070e-01f, 1.02160498e-01f, 2.77424961e-01f, -2.40385607e-02f, 1.23887174e-02f, 2.38813654e-01f,
  3.61235857e-01f, 3.08228016e-01f, 2.60144979e-01f, 1.85629442e-01f, 1.19076528e-01f, 2.49069050e-01f, 4.56637383e-01f, -3.77134643e-02f, 2.63094485e-01f, 1.11664936e-01f,
  -1.28533021e-01f, 2.34048739e-02f, -2.15687323e-02f, -1.30138770e-01f, 3.82126272e-02f, -9.44087654e-02f, -2.38129795e-02f, -9.32392329e-02f, -6.18787669e-02f, 9.81510654e-02f,
  1.11654112e-02f, 4.95423153e-02f, -6.24510972e-03f, 1.26458351e-02f, -1.21907108e-02f, 4.36425507e-02f, -1.41521692e-02f, -8.37778149e-04f, -2.44908966e-02f, -5.69742778e-03f,
  -4.40587290e-02f, -7.15635493e-02f, 3.35437525e-03f, 5.51272146e-02f, 5.25892489e-02f, -3.36356316e-04f, -2.37719156e-03f, 1.14516877e-02f, 6.77526891e-02f, 6.71755746e-02f,
  1.12465620e-01f, -8.50461870e-02f, -4.17593345e-02f, -1.05609097e-01f, 4.33160253e-02f, -4.69665602e-02f, 6.50634095e-02f, 1.89379579e-03f, 3.31638008e-02f, 3.27764801e-03f,
  -5.23895863e-03f, 9.96118132e-03f, -2.66542211e-02f, 3.79972570e-02f, 2.02483796e-02f, -1.00182079e-01f, -6.99604675e-02f, 2.64611356e-02f, -2.13420764e-03f, 1.16125168e-02f,
  -6.88967630e-02f, 1.20798526e-02f, 1.93763841e-02f, -4.66959663e-02f, -5.78420050e-02f, 9.38664470e-03f, 1.00237034e-01f, -8.01971089e-03f, -5.37171327e-02f, 1.60551146e-02f,
  1.96829945e-01f, 6.01320982e-01f, 2.81080939e-02f, -8.40213969e-02f, 1.92375928e-02f, 4.57421988e-02f, -3.96160707e-02f, 1.12855993e-01f, 1.77577302e-01f, 4.62353751e-02f,
  1.17771521e-01f, -1.03735268e-01f, 3.56203765e-02f, 2.81523187e-02f, 3.12378490e-03f, 7.26706013e-02f, 1.40372396e-01f, -7.86107033e-03f, 1.17243752e-01f, 8.04374889e-02f,
  6.76140338e-02f, 3.10347453e-02f, 8.42670202e-02f, -1.87531281e-02f, 4.49052714e-02f, 3.66283022e-02f, 2.02922933e-02f, -1.13161178e-02f, 4.48679999e-02f, 1.04486853e-01f,
  -2.76891768e-01f, -1.17585289e-04f, -1.01536505e-01f, -1.17977090e-01f, 1.35133147e-01f, 1.09086873e-03f, -1.29263327e-01f, 7.73252696e-02f, -1.47332549e-01f, 1.13193557e-01f,
  -2.60855779e-02f, -1.46203199e-02f, -1.44548550e-01f, -2.18330398e-01f, -4.37595159e-01f, -3.44735116e-01f, -2.93792754e-01f, -4.90609631e-02f, -2.55758792e-01f, -5.50913103e-02f,
  -1.87341645e-01f, -1.40129700e-02f, -2.24656433e-01f, 1.36214793e-01f, 1.36180162e-01f, 1.42343566e-01f, 1.51955977e-01f, 1.94005013e-01f, 1.87227339e-01f, 8.43117684e-02f,
  3.56137753e-02f, -1.08165279e-01f, 1.98565163e-02f, 3.65643837e-02f, -7.08323047e-02f, 7.82146156e-02f, 7.52021447e-02f, 5.24146929e-02f, -7.25801587e-02f, -8.16105306e-02f,
  8.53709653e-02f, 6.92414492e-02f, 8.12960193e-02f, 4.86844480e-02f, 7.11799115e-02f, 2.37284955e-02f, -6.12922423e-02f, 8.29859525e-02f, 7.12804943e-02f, -1.58575345e-02f,
  -5.71229942e-02f, 6.49023429e-02f, -1.89555939e-02f, 5.67551441e-02f, -5.38193397e-02f, -2.52303742e-02f, -5.32812700e-02f, -8.12084600e-02f, -3.69371250e-02f, -9.71424486e-03f,
  -6.96637705e-02f, -8.49685073e-02f, -8.70210230e-02f, -2.60166954e-02f, -5.91718741e-02f, 2.23631971e-02f, -3.67095545e-02f, -2.35059895e-02f, -2.26481240e-02f, 4.64725420e-02f,
  1.28989313e-02f, 1.19556412e-02f, -2.69296323e-03f, 6.26432747e-02f, -9.65457037e-03f, -2.64247153e-02f, -1.08250789e-02f, 9.98289604e-03f, -7.55220652e-02f, 2.51999199e-02f,
  9.34601426e-02f, -6.57919273e-02f, 1.09522454e-01f, 7.87405744e-02f, 6.46392033e-02f, -3.07772085e-02f, 7.41548464e-02f, 6.22644536e-02f, -7.98192993e-03f, 5.31026088e-02f,
  8.64004530e-03f, -3.16882599e-03f, -7.22505376e-02f, 9.46384668e-02f, 3.98536921e-02f, -4.99455316e-04f, 4.65336964e-02f, -1.31230103e-02f, -2.28995476e-02f, 1.07635651e-02f,
  6.37868643e-02f, -2.92629898e-02f, 3.13839130e-02f, -4.54972237e-02f, 7.37121850e-02f, -1.34038320e-02f, 9.63427424e-02f, -3.57388123e-03f, 4.34508920e-02f, 7.42101967e-02f,
  7.05474019e-02f, 6.33062497e-02f, -2.51199137e-02f, -1.05094565e-02f, 8.66403431e-02f, -1.98556054e-02f, -2.55218819e-02f, 5.67168370e-02f, -4.04912382e-02f, -4.58372124e-02f,
  2.09326949e-02f, 2.64754087e-01f, 3.08815986e-01f, -1.73708111e-01f, -8.64989460e-02f, -1.79689303e-02f, -1.66413978e-01f, 2.72953976e-02f, 4.28024754e-02f, 7.86731914e-02f,
  -1.65903896e-01f, 2.51708597e-01f, 3.37740108e-02f, -6.68090135e-02f, -3.45041364e-01f, -6.64243996e-02f, -2.23004937e-01f, -7.37086087e-02f, -7.23116994e-02f, -9.96137932e-02f,
  -2.36520782e-01f, -3.36656511e-01f, 6.15560152e-02f, -3.19323805e-03f, 8.81191622e-03f, -2.98187863e-02f, -2.13758051e-01f, 4.04647319e-03f, 2.20423955e-02f, -5.60324825e-02f,
  2.43171975e-02f, 1.22367844e-01f, 1.83188125e-01f, 1.93752795e-01f, -5.25527187e-02f, 7.84377307e-02f, 4.74536471e-04f, 3.14445421e-02f, -3.77012901e-02f, -2.03897487e-02f,
  -8.63657147e-02f, -6.34036362e-02f, -1.98222864e-02f, -9.40786749e-02f, 6.81553874e-03f, 8.44288170e-02f, 3.10513712e-02f, 1.70349926e-02f, 1.25119373e-01f, 1.34101331e-01f,
  9.32402164e-02f, 7.72044361e-02f, 1.09035932e-02f, -7.28639439e-02f, 2.51696482e-02f, -7.18026236e-02f, -1.70840397e-02f, -1.38928276e-02f, 5.30812293e-02f, -5.79189211e-02f,
  -5.35887368e-02f, -7.89947808e-02f, 3.32475789e-02f, 6.86878012e-03f, -6.86651282e-03f, 2.58882400e-02f, -7.86428601e-02f, 2.52334718e-02f, 6.48922548e-02f, -3.62930261e-02f,
  6.13251515e-03f, 1.37436822e-01f, -5.93035258e-02f, -9.64805763e-03f, 1.69122070e-02f, -4.24436629e-02f, 4.72662002e-02f, 4.96012047e-02f, -2.42839614e-03f, 8.07255134e-02f,
  -6.39264435e-02f, -9.80632678e-02f, -1.16683980e-02f, -1.98778305e-02f, -8.42228159e-02f, -4.53703031e-02f, 7.03919828e-02f, 9.46175978e-02f, -6.18493147e-02f, -3.24848555e-02f,
  2.92990427e-03f, -8.74247774e-02f, 2.44782935e-03f, 4.21140306e-02f, 7.72346258e-02f, 3.81069491e-03f, 5.51937073e-02f, -5.13196774e-02f, -4.99864295e-02f, 1.55597422e-02f,
  3.47185880e-02f, -9.99724567e-02f, -1.12066500e-01f, 3.70421149e-02f, -4.73584570e-02f, -4.64659519e-02f, -8.03917367e-03f, -6.60163537e-02f, -1.07630312e-01f, 1.08673200e-01f,
  -4.68846075e-02f, -1.00744925e-01f, 2.17460878e-02f, -1.54357925e-02f, -4.43754718e-02f, -7.29715452e-02f, 4.23052162e-02f, 8.07986706e-02f, -2.86011752e-02f, 3.59841585e-02f,
  1.93816394e-01f, -6.75299242e-02f, -3.17503721e-01f, 6.18555176e-04f, 1.98260650e-01f, 1.77417919e-01f, 1.74167994e-02f, 1.99222229e-02f, -1.30537942e-01f, 6.09839335e-02f,
  1.98786288e-01f, 3.76785249e-02f, -2.42868289e-01f, 1.95770025e-01f, 1.03585355e-01f, -1.74493924e-01f, 1.87198386e-01f, 8.02925080e-02f, 2.09549237e-02f, 6.96176067e-02f,
  7.78954383e-03f, 2.81029910e-01f, -1.37539446e-01f, 1.36199996e-01f, 1.66547567e-01f, -7.08337650e-02f, -1.56148542e-02f, -1.64258853e-01f, 1.61505669e-01f, 9.85357314e-02f,
  6.29622266e-02f, 3.04231904e-02f, 3.55078429e-02f, -1.88152958e-02f, 3.35455276e-02f, 3.10789924e-02f, -3.34461182e-02f, 2.71217171e-02f, 1.14936922e-02f, -3.36742625e-02f,
  4.42138189e-05f, -9.76138748e-03f, 6.73163906e-02f, 2.88059637e-02f, 1.16906695e-01f, -7.26318359e-03f, -6.71376735e-02f, -1.18931569e-03f, 2.74701481e-04f, -2.25032233e-02f,
  1.16706709e-03f, -5.78970015e-02f, -2.87877824e-02f, -2.07071081e-02f, -7.13097230e-02f, -1.46258362e-02f, -5.22976182e-02f, -7.50317574e-02f, 8.96091983e-02f, -2.90378295e-02f,
  6.38087615e-02f, -1.20061142e-02f, -2.00126432e-02f, 6.11570366e-02f, 3.85719985e-02f, -2.86648460e-02f, -3.45341302e-02f, 3.34862396e-02f, -5.81176067e-03f, 1.34689931e-03f,
  -2.78095528e-02f, 2.64475942e-02f, 7.32882544e-02f, 2.15918738e-02f, 1.31775308e-02f, 4.71502319e-02f, 1.28059145e-02f, 7.25589842e-02f, -7.47150630e-02f, 4.03210074e-02f,
  -6.47053495e-02f, 8.08656961e-02f, 3.96893397e-02f, 6.84716105e-02f, -2.13472894e-03f, -5.72240129e-02f, 9.71668772e-03f, 4.94652949e-02f, -9.68892723e-02f, -3.99984196e-02f,
  -5.60155138e-02f, -5.68652190e-02f, -4.48247185e-03f, 4.45925184e-02f, 5.14943041e-02f, 9.84384269e-02f, -9.66867153e-03f, 8.65150690e-02f, -8.96907151e-02f, -4.19101119e-02f,
  2.46856920e-02f, 1.21027892e-02f, 4.50077932e-03f, 6.76752105e-02f, -8.81867483e-02f, -1.09755034e-02f, -2.09516678e-02f, -3.88932116e-02f, -2.64637321e-02f, 3.47433463e-02f,
  -6.47293180e-02f, 3.25679071e-02f, 6.28498569e-03f, -2.53010541e-02f, -4.40945197e-03f, -3.86389233e-02f, 6.98460639e-02f, -1.13654479e-01f, -4.70001772e-02f, -6.88505620e-02f,
  -1.16661891e-01f, -8.74437317e-02f, 5.60090803e-02f, 2.56482452e-01f, -2.91398470e-03f, -2.35151619e-01f, -2.80832589e-01f, -1.61899164e-01f, -1.94166601e-01f, -3.24720740e-01f,
  -1.69559658e-01f, 2.18984142e-01f, -3.73107195e-01f, 2.72479922e-01f, 1.81384176e-01f, -2.14819312e-01f, 1.83562234e-01f, 1.23409107e-01f, 1.70841351e-01f, 6.61888346e-03f,
  2.04932287e-01f, 1.89102575e-01f, 3.27177167e-01f, 3.21508020e-01f, 1.03425786e-01f, 2.31460705e-01f, 1.88183367e-01f, 7.97549188e-02f, 4.06595141e-01f, 2.41605461e-01f,
  -1.12818152e-01f, -3.51075679e-02f, -3.55918817e-02f, -9.21969581e-03f, -5.08683100e-02f, -6.27235845e-02f, 7.44181275e-02f, 7.51080066e-02f, 1.12085998e-01f, -3.56244519e-02f,
  -4.16442230e-02f, 4.22892459e-02f, 1.60356686e-01f, 4.47939970e-02f, 1.13557121e-02f, 5.83302192e-02f, 1.34822920e-01f, -6.15816750e-02f, 4.28452455e-02f, 1.89416576e-02f,
  -3.25249881e-02f, 6.82876771e-03f, 1.20179197e-02f, 8.25757086e-02f, 4.99657057e-02f, 3.43268248e-03f, 6.63842112e-02f, 2.93211266e-03f, 3.76748182e-02f, 6.89659715e-02f,
  -4.72150445e-02f, -3.18160355e-02f, -2.80088373e-02f, -9.18453559e-03f, -4.28529382e-02f, -3.10329124e-02f, 5.88430725e-02f, -6.36715293e-02f, 6.68522390e-03f, -8.15986842e-02f,
  5.26807494e-02f, 4.54928353e-02f, -4.51580435e-02f, -4.75499267e-03f, -4.15052585e-02f, 3.01390439e-02f, 7.15298653e-02f, 4.86853383e-02f, -1.46949394e-02f, 4.71338406e-02f,
  1.48635302e-02f, -2.75500063e-02f, -1.65163986e-02f, -1.76430084e-02f, -5.66876978e-02f, -5.42295016e-02f, -4.76576202e-02f, 1.67692285e-02f, -5.16013056e-02f, -1.25975639e-03f,
  -1.90252066e-01f, -8.58598799e-02f, 3.40546109e-02f, 5.38822226e-02f, 4.12609167e-02f, 7.46793870e-04f, 3.70999984e-02f, 7.76719227e-02f, -2.44499482e-02f, -3.28842923e-02f,
  -2.27959063e-02f, 7.26829655e-03f, -3.43997739e-02f, 1.46262273e-02f, 4.36020903e-02f, -7.14411587e-02f, -4.66192886e-02f, 6.37257919e-02f, 5.52561227e-03f, 3.29946093e-02f,
  4.82139885e-02f, -3.07195596e-02f, 4.80469577e-02f, 1.05006723e-02f, 3.27750035e-02f, -3.22640724e-02f, -5.82746742e-03f, 5.61775006e-02f, 1.41574934e-01f, 2.22843252e-02f,
  3.80155742e-01f, -2.40707725e-01f, 1.95266604e-02f, 3.76988411e-01f, 1.00045487e-01f, -2.17255622e-01f, -5.56741916e-02f, -3.17065343e-02f, 3.71731251e-01f, -2.66945302e-01f,
  -2.02200741e-01f, 1.71309695e-01f, -2.34315068e-01f, -2.05346212e-01f, 1.18989505e-01f, -9.51755494e-02f, -1.28188089e-01f, -6.24826038e-03f, 1.71644688e-01f, -1.52082130e-01f,
  9.46710557e-02f, -3.43626738e-01f, -8.27292725e-02f, -4.12977904e-01f, -4.51067463e-04f, 2.09224131e-02f, -1.02709092e-01f, -1.99440151e-01f, -1.85963154e-01f, -1.61628686e-02f,
  -7.40676895e-02f, -4.08803299e-02f, 5.49986213e-02f, -4.00894955e-02f, 2.05371203e-03f, -2.24452186e-02f, 1.30370604e-02f, -3.50698121e-02f, 3.76081355e-02f, 7.06100166e-02f,
  -4.69307695e-03f, -6.58096559e-03f, 2.06214320e-02f, 4.04686201e-03f, 6.97725266e-02f, -2.84421779e-02f, 4.09221128e-02f, 5.79126850e-02f, 2.79416870e-02f, 1.89336110e-02f,
  1.22103758e-01f, 7.25707337e-02f, 1.02008015e-01f, 7.64635876e-02f, 1.01506762e-01f, 1.40711321e-02f, -2.74168197e-02f, 8.27910900e-02f, 8.89153779e-03f, 5.32295182e-02f,
  3.69892456e-02f, 1.28956316e-02f, -2.86217220e-02f, -3.61901745e-02f, -3.78304161e-02f, -2.83069797e-02f, -2.01485911e-03f, -4.40855585e-02f, 3.11074387e-02f, -6.56586215e-02f,
  -5.02590276e-02f, 1.76073015e-02f, 5.37863895e-02f, -1.48172816e-02f, 3.80757730e-03f, 1.18561469e-01f, -9.75423828e-02f, -7.91363046e-02f, 8.40294510e-02f, 1.05038002e-01f,
  -4.43429872e-03f, -2.75098365e-02f, -1.00402478e-02f, 3.32621820e-02f, -4.01862897e-02f, 4.03520949e-02f, -2.23571863e-02f, -2.36283592e-03f, 9.83311087e-02f, 5.59619116e-03f,
  -2.03055799e-01f, -2.26345778e-01f, 2.29201373e-02f, -1.09907072e-02f, -1.22121125e-01f, 3.16447904e-03f, -4.92490008e-02f, 7.98437297e-02f, -1.20498836e-01f, -9.85448435e-02f,
  1.37659931e-03f, -2.06820332e-02f, -2.22598780e-02f, -1.55475279e-02f, -5.35440147e-02f, 2.31328327e-02f, -4.03103866e-02f, -2.24937759e-02f, 3.72207984e-02f, -1.41530842e-01f,
  -6.80718198e-02f, -5.03136404e-03f, -1.71355102e-02f, 2.81976536e-02f, 6.71061575e-02f, -1.33890128e-02f, 9.95536745e-02f, -8.13199505e-02f, -1.01758331e-01f, 5.22642257e-03f,
  -3.48271400e-01f, 6.38725527e-04f, -1.16360016e-01f, -1.04027390e-02f, -2.38616899e-01f, 6.70038238e-02f, 8.83789361e-02f, -2.04133689e-01f, -1.94429323e-01f, 4.68041867e-01f,
  1.28860906e-01f, -1.34158373e-01f, 1.09761029e-01f, -1.92439351e-02f, -4.32584763e-01f, -1.02343913e-02f, 1.26207113e-01f, 1.36608243e-01f, -1.46267131e-01f, -4.53324281e-02f,
  -5.86067028e-02f, -1.35590091e-01f, -1.55190695e-02f, -9.41385776e-02f, -5.04552349e-02f, 1.38681784e-01f, 1.46491647e-01f, -9.56755579e-02f, 1.92176580e-01f, -2.30669320e-01f,
  1.47240711e-02f, -5.31171300e-02f, -2.31679697e-02f, -6.36935830e-02f, 3.08921970e-02f, 1.41691804e-01f, 4.71965745e-02f, -8.52803066e-02f, -8.35536644e-02f, -5.55956457e-03f,
  9.99208167e-02f, -1.34199783e-01f, -1.01693235e-01f, -5.33612296e-02f, -1.58588141e-02f, -1.62947811e-02f, -6.68686926e-02f, 1.15270568e-02f, 1.17518390e-02f, -5.05778119e-02f,
  2.73924842e-02f, -3.94877605e-03f, 1.61487423e-02f, 1.42069623e-01f, -1.07321836e-01f, 1.40041290e-02f, 5.33867255e-02f, 7.67104179e-02f, 8.84829834e-02f, -1.48335725e-01f,
  -3.54316682e-02f, 3.33198234e-02f, -4.72491756e-02f, -5.81987377e-04f, -8.85424986e-02f, 5.66242076e-02f, 1.91999394e-02f, 4.90567498e-02f, -5.70503511e-02f, 2.63892990e-02f,
  -4.08712998e-02f, 6.56751683e-03f, 3.94882038e-02f, 6.71569183e-02f, -2.08309037e-03f, 2.03865711e-02f, 3.26088183e-02f, -2.84320060e-02f, 1.29896283e-01f, 3.16170715e-02f,
  1.53429750e-02f, -5.83810806e-02f, -5.21052480e-02f, 9.88031179e-02f, -3.72134373e-02f, 4.27944921e-02f, 1.52826328e-02f, -4.26430628e-02f, 2.83008087e-02f, -9.35209449e-03f,
  1.05860874e-01f, -6.23548366e-02f, 9.38057154e-03f, -2.61429809e-02f, 5.84434010e-02f, 3.57810222e-02f, 2.89784819e-02f, -7.91158453e-02f, 9.00811888e-03f, -1.16644084e-01f,
  1.04208225e-02f, 9.91180912e-02f, 1.38993450e-02f, -2.10071187e-02f, -1.21670924e-02f, 4.48100939e-02f, 1.04150385e-01f, 9.31992605e-02f, -4.56392840e-02f, -3.84275690e-02f,
  6.38515502e-02f, 7.78914839e-02f, 5.22879660e-02f, -3.93556990e-03f, -1.34299928e-02f, 4.29028310e-02f, -6.83772862e-02f, -2.94517609e-03f, -3.41759622e-03f, 6.64046258e-02f,
  -5.13650402e-02f, 2.52756178e-01f, -2.58679897e-01f, -2.53815297e-02f, 2.67111421e-01f, 1.87664017e-01f, 1.17508821e-01f, 2.26576608e-02f, -1.29075333e-01f, 2.48348787e-01f,
  1.47864997e-01f, 7.16135576e-02f, -9.66965687e-03f, 6.53581619e-02f, -6.23324178e-02f, -1.50069743e-01f, 9.71944630e-02f, 1.55776396e-01f, -7.36375600e-02f, 1.54293790e-01f,
  -1.22235849e-01f, 1.40642345e-01f, -2.75706619e-01f, 1.04153194e-01f, 1.73626140e-01f, -6.37289658e-02f, 1.20865278e-01f, -1.04591355e-01f, 1.47027448e-01f, 7.25594163e-03f,
  -1.63625292e-02f, -1.60384364e-02f, -6.57449439e-02f, -4.22004573e-02f, -2.38649473e-02f, 1.13918304e-01f, 2.08128504e-02f, -3.32877561e-02f, -4.45906334e-02f, -9.57602933e-02f,
  6.17606044e-02f, -8.84306282e-02f, 3.09247859e-02f, 2.58600507e-02f, 4.25033309e-02f, 5.50833605e-02f, 2.97774300e-02f, 4.58156206e-02f, -6.26067668e-02f, 5.74985780e-02f,
  2.45723259e-02f, 6.64774328e-03f, 1.51804220e-02f, 5.31347804e-02f, -1.10698491e-02f, -6.44213939e-03f, 4.77964208e-02f, 3.44027728e-02f, 6.11537732e-02f, -2.24275962e-02f,
  2.05966644e-02f, 1.01719998e-01f, 4.30070646e-02f, -1.15755141e-01f, 7.49935955e-02f, -2.86858920e-02f, 1.00232158e-02f, -5.35118766e-02f, -3.00197713e-02f, 7.77558833e-02f,
  5.76749817e-02f, 7.03723822e-03f, 4.54462096e-02f, -5.92920445e-02f, 6.06830902e-02f, 1.68535132e-02f, 8.10527131e-02f, 3.48822363e-02f, 6.03711158e-02f, -7.28292093e-02f,
  -2.91395336e-02f, -8.16545915e-03f, -5.68092316e-02f, -6.63051428e-03f, -6.77180570e-03f, -7.39390850e-02f, -2.51397956e-03f, -3.81830521e-02f, -3.39153782e-03f, -2.66908612e-02f,
  1.76342428e-01f, 2.89972156e-01f, -8.20698366e-02f, -1.42737022e-02f, -3.52120213e-02f, 1.20444290e-01f, -9.59022343e-03f, -3.74584980e-02f, 1.40167428e-02f, 1.15934402e-01f,
  7.88387880e-02f, 3.22707780e-02f, 5.84789217e-02f, 3.01937312e-02f, -7.85397366e-02f, 8.63631666e-02f, 1.98122840e-02f, 3.01075373e-02f, 1.48098797e-01f, 6.55046180e-02f,
  9.37594753e-03f, 3.15365829e-02f, 4.99262251e-02f, -2.81134695e-02f, -1.12889465e-02f, 3.03118899e-02f, 1.21259421e-01f, 1.94271212e-03f, 7.40594864e-02f, -5.67410365e-02f,
  -2.51608640e-01f, -1.52303919e-01f, -2.30264693e-01f, -1.39627367e-01f, 1.97232485e-01f, 3.84097159e-01f, -1.14955939e-01f, 5.40912803e-03f, -3.13615412e-01f, -5.45650646e-02f,
  -8.55879262e-02f, -2.65821874e-01f, -3.40759993e-01f, 6.13971241e-02f, 1.09553207e-02f, -1.34640247e-01f, 1.98531955e-01f, -8.46467167e-03f, -6.66157762e-03f, -6.30662367e-02f,
  3.55015956e-02f, 2.33073547e-01f, -2.72455551e-02f, 3.41352284e-01f, -6.45542592e-02f, 7.20360726e-02f, 7.56699070e-02f, 4.02142145e-02f, 2.33125553e-01f, 5.97055331e-02f,
  9.94142890e-02f, -2.53336459e-01f, -9.03951749e-02f, -1.01146013e-01f, 7.11541921e-02f, 4.43832688e-02f, 8.95215105e-03f, -3.69757414e-02f, -1.96016859e-03f, -4.45413403e-02f,
  -1.18327498e-01f, 2.91321483e-02f, 1.13402270e-02f, -4.16357443e-02f, -4.61438932e-02f, 5.53311333e-02f, 6.99577108e-02f, -1.63907260e-02f, -1.10966891e-01f, -3.49740796e-02f,
  -7.51164481e-02f, 2.71322555e-03f, 5.20565547e-02f, -5.95056312e-03f, 6.06952980e-03f, -4.39335853e-02f, 2.44918186e-02f, -1.09876823e-02f, -1.26773128e-02f, -2.13712361e-02f,
  1.88602824e-02f, 4.58644815e-02f, 6.16782270e-02f, -7.38235563e-02f, 6.41779602e-02f, 3.35372686e-02f, 2.26196423e-02f, 7.43551925e-02f, -3.49282995e-02f, -1.98161844e-02f,
  -2.40520500e-02f, -6.49156198e-02f, -5.84151261e-02f, 6.43816888e-02f, 3.12239490e-02f, 1.30014755e-02f, 8.26444328e-02f, -1.66500714e-02f, -3.45574059e-02f, 2.03743502e-02f,
  4.61034812e-02f, -1.72343031e-02f, -7.99946263e-02f, 5.24630547e-02f, -2.06708442e-02f, -6.48703352e-02f, -1.09177046e-02f, -3.65354232e-02f, 2.46434603e-02f, 4.90031056e-02f,
  1.78189382e-01f, -2.00809702e-01f, 5.30117080e-02f, 1.36352867e-01f, -1.83378570e-02f, 8.44807848e-02f, 7.23861530e-02f, 1.14895171e-02f, -1.51288584e-02f, 6.69427356e-03f,
  1.66987942e-03f, 9.54747126e-02f, -1.95567887e-02f, -3.60187609e-03f, 7.87184462e-02f, -3.13735269e-02f, -7.52476901e-02f, -9.87857673e-03f, 8.54898766e-02f, 4.15718593e-02f,
  1.06614577e-02f, 1.10342272e-01f, -2.06342600e-02f, 4.84982431e-02f, -4.63662893e-02f, 6.84207082e-02f, 6.19386546e-02f, 4.35295934e-03f, 1.27740636e-01f, -3.47867161e-02f,
  -9.20201957e-01f, 4.66480076e-01f, -1.43707484e-01f, -2.63124287e-01f, 1.86462514e-02f, -2.74461042e-02f, 8.80767331e-02f, 6.80316761e-02f, -3.71026509e-02f, 3.95212770e-01f,
  2.11442932e-01f, -1.81885287e-01f, 3.40654701e-01f, 1.35118186e-01f, -6.27928555e-01f, 2.15883285e-01f, -1.31536126e-01f, -7.67735317e-02f, -2.31744051e-02f, -1.52825475e-01f,
  -2.30049044e-01f, 5.49163520e-02f, 1.93474395e-03f, 3.49586964e-01f, -9.72931311e-02f, -1.62485018e-01f, -1.37016550e-01f, 2.53964573e-01f, -1.40385300e-01f, 6.96133450e-02f,
  -2.49591202e-01f, -3.35413180e-02f, -8.72878283e-02f, -9.76013616e-02f, -1.94514304e-01f, -1.13228902e-01f, -5.92894591e-02f, -5.99421673e-02f, -1.00840330e-01f, -3.52655463e-02f,
  -9.57047716e-02f, 2.53084721e-03f, -2.90103666e-02f, 9.59797651e-02f, -5.17239347e-02f, 4.40040603e-02f, 5.20644262e-02f, -7.96389356e-02f, 6.22627400e-02f, -4.71082889e-03f,
  1.08431190e-01f, 2.28208173e-02f, -9.46435109e-02f, 8.31681537e-04f, -7.93805495e-02f, 9.09250304e-02f, -7.24534988e-02f, -8.03382918e-02f, -2.81157810e-02f, -7.60366917e-02f,
  4.13723625e-02f, 2.43195593e-02f, 7.84606561e-02f, -6.51874533e-03f, 3.32936533e-02f, 5.72074056e-02f, 2.38804650e-02f, 2.04124451e-02f, 3.25756613e-04f, 4.97313477e-02f,
  -5.82096800e-02f, 1.10234125e-02f, 1.12079550e-02f, -4.38118353e-02f, -4.21102233e-02f, -3.38879935e-02f, -3.95125477e-03f, -1.40065262e-02f, -2.89945602e-02f, 4.11614515e-02f,
  6.33641854e-02f, 3.64790112e-02f, 1.00745946e-01f, 2.29374249e-03f, 5.42939231e-02f, -1.29233589e-02f, 6.26336187e-02f, 4.07825224e-02f, 5.68884313e-02f, -1.00161783e-01f,
  -2.98606187e-01f, -1.92646384e-01f, -5.11908755e-02f, 4.69331332e-02f, -6.31068507e-03f, -4.66016717e-02f, -4.18400019e-02f, -6.76981956e-02f, -3.90083529e-02f, 4.12404016e-02f,
  -4.81724367e-02f, 1.78937186e-02f, -1.19566701e-01f, -8.68614763e-02f, -3.18160057e-02f, -4.37678508e-02f, -1.61371008e-02f, -2.48965668e-03f, -8.34264085e-02f, -5.64377494e-02f,
  2.98162233e-02f, 7.75252804e-02f, 3.43811288e-02f, -4.12882678e-02f, -3.33383381e-02f, -5.87013587e-02f, -1.04982473e-01f, -2.20103506e-02f, -3.27733643e-02f, 6.66982979e-02f,
  9.58638489e-02f, 2.00898781e-01f, 2.87167519e-01f, 1.96325690e-01f, -1.47221491e-01f, -2.93860793e-01f, -1.19488955e-01f, 7.09480718e-02f, -2.20500715e-02f, 1.87751874e-01f,
  -1.12833373e-01f, 1.26582220e-01f, -4.44795527e-02f, -7.79556334e-02f, -3.36301923e-01f, -3.31758708e-01f, -2.55248118e-02f, -2.98478696e-02f, -1.34216174e-01f, 1.66715503e-01f,
  8.81409794e-02f, -1.41542822e-01f, 1.06086433e-01f, 4.71392944e-02f, 1.61473468e-01f, 3.68675619e-01f, 6.62984774e-02f, 7.13034421e-02f, 2.44358420e-01f, -1.48720786e-01f,
  -1.26126051e-01f, 2.90109348e-02f, 6.09338097e-02f, 2.61433274e-02f, 1.07472233e-01f, 9.92644653e-02f, -1.84087362e-02f, -1.27386361e-01f, 9.31545720e-03f, 2.99897213e-02f,
  9.32690576e-02f, 1.01881789e-03f, -1.09178588e-01f, -1.18902333e-01f, 8.06089938e-02f, 4.47934866e-02f, 2.19038501e-02f, 1.17842436e-01f, 8.04560483e-02f, 5.39523736e-02f,
  7.72134140e-02f, 8.39014426e-02f, 3.61985750e-02f, -3.05587091e-02f, 1.08529711e-02f, -2.82642264e-02f, 5.84987476e-02f, 1.06757753e-01f, 1.80823286e-03f, 3.15866643e-03f,
  8.85042399e-02f, 6.99450076e-02f, -8.90742391e-02f, -4.10224237e-02f, 4.29381728e-02f, 4.68434300e-03f, -3.47506888e-02f, -1.99412052e-02f, -3.82002890e-02f, 4.21189517e-02f,
  -7.29361698e-02f, -7.90071581e-03f, -5.98039180e-02f, -1.62839070e-02f, 5.85660301e-02f, -9.09846872e-02f, 5.81726879e-02f, -1.06306048e-02f, -3.88075039e-02f, -6.40938655e-02f,
  -6.59881011e-02f, -4.66789901e-02f, -5.45919500e-02f, -6.92176148e-02f, -7.64994994e-02f, 9.83635187e-02f, 5.14657721e-02f, 7.44036585e-02f, 8.44322052e-03f, -2.16435771e-02f,
  4.05299589e-02f, 1.54422343e-01f, 4.65628468e-02f, -5.04034245e-03f, -9.34248616e-04f, -5.41594736e-02f, -2.16134712e-02f, -2.63682678e-02f, 5.94128519e-02f, -3.77910547e-02f,
  5.42127453e-02f, 2.28597801e-02f, 2.42264271e-02f, -6.07641228e-02f, -1.20896092e-02f, -1.24252839e-02f, 8.09854940e-02f, -4.78070453e-02f, 7.80570135e-02f, 3.41264121e-02f,
  6.26506880e-02f, 7.94987427e-05f, -4.00097445e-02f, -7.47485012e-02f, -3.25072333e-02f, 7.30067492e-02f, 4.86945659e-02f, 1.06479503e-01f, -6.30644802e-03f, 8.66186246e-02f,
  -2.56776601e-01f, 2.40327250e-02f, -2.42988784e-02f, -2.57699668e-01f, 1.39522806e-01f, -1.26398250e-01f, 1.60279255e-02f, 2.70969868e-01f, -1.26841918e-01f, 1.37670279e-01f,
  5.36148399e-02f, -3.30787301e-01f, 1.38992742e-01f, -2.63543934e-01f, -2.92787254e-01f, -7.98574388e-02f, -1.04067430e-01f, -1.90102756e-01f, 7.39868209e-02f, 5.83397709e-02f,
  -5.52473255e-02f, 1.82038881e-02f, 1.17346615e-01f, 2.86778122e-01f, 1.47888422e-01f, 5.21004200e-02f, 9.52525586e-02f, 3.01307738e-01f, -7.68912733e-02f, -4.90302630e-02f,
  -2.81833718e-03f, 4.62566800e-02f, 5.91990305e-03f, 8.57316181e-02f, 1.09551713e-01f, 4.75908034e-02f, -7.12779388e-02f, 3.62985879e-02f, -5.28196665e-03f, 1.16615240e-02f,
  -5.65173142e-02f, 7.83330426e-02f, -2.38352790e-02f, -4.79155779e-02f, 7.81133696e-02f, 1.08663635e-02f, 6.13318980e-02f, 1.92326382e-02f, 3.18416534e-03f, 6.18251935e-02f,
  3.95519920e-02f, -1.67348869e-02f, -9.18005705e-02f, 2.12348849e-02f, -1.40929623e-02f, -2.00172719e-02f, -3.61113064e-02f, 5.08348122e-02f, -1.22908391e-02f, -8.96366835e-02f,
  -3.02250683e-03f, 2.78605032e-03f, 2.78276913e-02f, 7.37211555e-02f, -1.15305008e-02f, -3.12031177e-03f, -3.92753407e-02f, -6.22245185e-02f, 1.17357308e-02f, -5.49764894e-02f,
  7.13787749e-02f, -2.30883770e-02f, 1.13228979e-02f, -3.47512439e-02f, -2.69446485e-02f, -1.42431268e-02f, -3.56994569e-02f, -2.32493244e-02f, 6.42843992e-02f, -3.67989354e-02f,
  -5.42262048e-02f, -6.17115013e-02f, 1.74612422e-02f, 7.04642311e-02f, -3.11609209e-02f, 6.43910766e-02f, -7.93329254e-02f, 1.17489044e-02f, -3.17035094e-02f, 4.70808856e-02f,
  1.10833831e-01f, 1.96748346e-01f, 1.75160304e-01f, 2.00630096e-03f, 8.61155093e-02f, -3.46550085e-02f, -6.17360175e-02f, -4.42283899e-02f, -7.60882348e-02f, -1.86307356e-02f,
  1.65518802e-02f, -9.67913680e-03f, -1.82306580e-02f, 7.44348243e-02f, 8.26218165e-03f, -2.31565572e-02f, -5.37108108e-02f, -7.83988908e-02f, -3.86201553e-02f, -4.04638611e-02f,
  6.42722398e-02f, -5.84081858e-02f, -8.58808309e-02f, 6.35683686e-02f, 5.09734824e-02f, 5.56739345e-02f, 4.49803658e-02f, -4.93029319e-02f, -2.27460060e-02f, 4.23376933e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.23268811e-02f, 2.89476812e-01f, 8.31872150e-02f, 2.40903541e-01f, 1.89762682e-01f, 1.47206157e-01f, 2.19161168e-01f, 3.66897523e-01f, 2.21237108e-01f, 4.33603108e-01f,
  6.42153740e-01f, 3.02717358e-01f, 3.01948965e-01f, 1.68202981e-01f, 3.32983375e-01f, 3.03305238e-01f, 1.91475391e-01f, 7.97325596e-02f, 1.34940997e-01f, 4.53650117e-01f,
  2.75022745e-01f, 2.20413893e-01f, 3.49889368e-01f, 4.05841619e-01f, 2.21877351e-01f, 2.66002893e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  2.77381718e-01f, -2.55943649e-02f, -1.20236903e-01f, -2.90717155e-01f, 4.21522915e-01f, -3.17122668e-01f, 1.40310958e-01f, -2.08851397e-01f, 6.30195260e-01f, 4.36115772e-01f,
  -7.12452829e-02f, 6.01640046e-01f, -2.83510864e-01f, 2.83839822e-01f, -3.07714343e-01f, -2.05807567e-01f, -4.95205581e-01f, -2.52772450e-01f, 2.45420858e-01f, -1.65957928e-01f,
  -2.57566005e-01f, -1.80146337e-01f, -7.40153864e-02f, -1.41160619e-02f, -2.61816680e-01f, -3.57439905e-01f, 5.72533369e-01f, -2.81905346e-02f, 2.05139890e-02f, 5.67596972e-01f,
  -2.92685866e-01f, -2.06011813e-02f, -6.16672754e-01f, 8.82838741e-02f, 4.15744305e-01f, -4.10927176e-01f, 4.99753505e-01f, 8.43984485e-02f, 2.79664118e-02f, -3.03767651e-01f,
  3.32182378e-01f, 7.23243058e-02f, 3.54581565e-01f, 4.68448400e-01f, 4.92688358e-01f, 3.72688562e-01f, 3.90135497e-01f, -5.03433459e-02f, -2.82917082e-01f, 5.04809082e-01f,
  3.72015476e-01f, -8.82812738e-02f, 3.53871435e-01f, -1.55140519e-01f, -3.31645533e-02f, 6.20682299e-01f, -4.52751905e-01f, -4.03977841e-01f, -3.77059430e-01f, 6.06097162e-01f,
  1.39029279e-01f, -4.41229254e-01f, -2.38118753e-01f, -1.90807149e-01f, -5.06198294e-02f, -2.89691746e-01f, -2.64371186e-01f, -2.72956371e-01f, -5.45704842e-01f, 4.27411288e-01f,
  -5.34689017e-02f, -9.61481258e-02f, -2.22258717e-01f, -2.56417811e-01f, -2.49226823e-01f, 5.27092993e-01f, 2.44362339e-01f, 1.93441480e-01f, 4.24818695e-01f, -3.14499289e-01f,
  -3.54736388e-01f, 3.20855007e-02f, -2.50277221e-01f, -2.57650822e-01f, 9.19426307e-02f, 3.54044229e-01f, -2.13435486e-01f, 4.72098857e-01f, 8.28135490e-01f, -1.10521298e-02f,
  -3.61845762e-01f, -1.43111393e-01f, 6.14115894e-01f, -1.94292098e-01f, -2.26802632e-01f, -2.26045445e-01f, -6.01896882e-01f, 1.02850832e-01f, 2.72478342e-01f, 4.87401545e-01f,
  2.08700523e-01f, -3.17269623e-01f, 3.67522120e-01f, 2.98187602e-02f, -3.13712955e-01f, -4.07797068e-01f, 4.66519177e-01f, -3.43795210e-01f, -6.97253831e-03f, -2.90400475e-01f,
  -1.44156083e-01f, 2.74996340e-01f, -6.28279328e-01f, 1.93058457e-02f, -1.09502025e-01f, -1.67357534e-01f, -2.26278752e-01f, 3.97009641e-01f, 3.10834438e-01f, 1.88203808e-02f,
  -2.55623013e-01f, -3.79902333e-01f, -1.06263466e-01f, -4.63198870e-02f, -2.23174065e-01f, 1.01534116e+00f, 3.43368202e-02f, 4.74498123e-01f, 2.02567711e-01f, 6.14458263e-01f,
  -3.71799916e-02f, 9.52884316e-01f, -7.05163702e-02f, -9.03756201e-01f, -1.90100119e-01f, -4.57974881e-01f, -2.26589307e-01f, -8.02840516e-02f, -4.27927434e-01f, 2.50661433e-01f,
  -2.61690468e-01f, -1.47703037e-01f, -2.36558825e-01f, -3.02961618e-01f, 8.60781848e-01f, -3.26338500e-01f, -3.22260618e-01f, -9.08542499e-02f, -1.64034680e-01f, -9.46820676e-02f,
  4.62270498e-01f, 8.02775845e-03f, 2.58573204e-01f, -2.55297661e-01f, -2.21886933e-01f, -2.30498344e-01f, 4.86484706e-01f, 6.26854300e-01f, -1.76400945e-01f, 4.00687933e-01f,
  2.38936037e-01f, -6.68948412e-01f, 2.41705164e-01f, -8.37603748e-01f, 6.44731283e-01f, -3.13879728e-01f, -1.07732052e-02f, -1.40740871e-01f, -2.10878313e-01f, 5.95432937e-01f,
  -1.04783867e-02f, -4.24609005e-01f, 5.96806593e-02f, 7.71697685e-02f, -2.42232427e-01f, 5.07287979e-01f, 7.44260788e-01f, -3.80450994e-01f, 8.97146702e-01f, 2.54798774e-02f,
  1.92617252e-01f, -3.92674237e-01f, -1.40336901e-01f, -3.87293212e-02f, -1.43536568e-01f, -3.10675614e-02f, -2.09625393e-01f, 1.34586632e-01f, -2.02940777e-01f, -3.33111823e-01f,
  -1.42342359e-01f, -2.74983913e-01f, 4.67121303e-01f, 5.58736503e-01f, -2.81658173e-01f, 1.97644364e-02f, 4.01664793e-01f, 9.15288925e-01f, -1.56237796e-01f, 5.23497105e-01f,
  8.08263477e-03f, -2.87051886e-01f, -1.24219954e-01f, -1.02607027e-01f, 4.20480013e-01f, -5.13101995e-01f, 5.73203146e-01f, -4.07614470e-01f, 6.45147204e-01f, -2.16126904e-01f,
  1.18837245e-01f, -8.99813175e-02f, -3.58906299e-01f, -2.38806278e-01f, -2.92336255e-01f, 7.71435574e-02f, -1.95670635e-01f, 6.99269593e-01f, -2.98081219e-01f, -3.26311707e-01f,
  1.41850086e-02f, -5.21401107e-01f, -9.23319608e-02f, 2.05385938e-01f, -2.74942130e-01f, -8.18257481e-02f, -5.52505910e-01f, 2.03218535e-01f, -2.87435263e-01f, -3.62598300e-01f,
  -8.39910656e-02f, -5.00454940e-02f, -1.87763408e-01f, -6.82137236e-02f, 1.18476462e+00f, -2.10544333e-01f, -6.99395910e-02f, -1.95616901e-01f, -7.25576282e-02f, 2.06029922e-01f,
  1.64953008e-01f, -2.03278884e-01f, -2.40456611e-01f, -1.57149300e-01f, 1.89374462e-01f, -2.29414478e-01f, 1.69959173e-01f, -1.48122489e-01f, 9.79184136e-02f, 5.24624228e-01f,
  -6.47004396e-02f, -2.01761767e-01f, -2.68358201e-01f, -2.65903056e-01f, -3.01751971e-01f, -1.02017291e-01f, -3.55022401e-01f, 1.60278440e-01f, -1.63883090e-01f, -2.70534873e-01f,
  -1.32478490e-01f, 5.18283188e-01f, -1.13277836e-02f, 1.09513775e-01f, -2.24136695e-01f, -2.61075705e-01f, -1.13015912e-01f, -2.86271065e-01f, 1.72288030e-01f, -2.31623486e-01f,
  -1.70600429e-01f, -2.87512969e-02f, -3.50308686e-01f, -3.06404382e-01f, 5.59138507e-02f, -2.67816812e-01f, 1.16812575e+00f, -1.92792237e-01f, -4.92591374e-02f, -1.39475390e-01f,
  4.58393335e-01f, -3.13238114e-01f, -2.33969927e-01f, 5.96524123e-03f, -3.33708495e-01f, -2.55473077e-01f, 4.28328127e-01f, 1.66337833e-01f, 7.90379569e-02f, 2.20674500e-01f,
  3.64546001e-01f, 5.57473361e-01f, -7.38775313e-01f, -5.67455292e-01f, 1.89797282e-02f, 6.85840189e-01f, -1.51040042e-02f, -1.43053666e-01f, -1.82120264e-01f, -2.59122968e-01f,
  -1.02900319e-01f, 1.14386880e+00f, 3.65524471e-01f, -1.95575446e-01f, 3.61342102e-01f, -2.18877569e-01f, -6.75945729e-02f, -1.45898372e-01f, -2.38331288e-01f, -1.36306956e-01f,
  -4.15319018e-02f, -1.46907344e-01f, -1.58720613e-01f, 1.32125214e-01f, -1.94594443e-01f, -2.23313615e-01f, -2.75395721e-01f, -5.38409412e-01f, -2.86369771e-01f, -2.17386708e-01f,
  3.82774919e-01f, -7.45788142e-02f, 3.00196651e-02f, -4.11069058e-02f, -7.34765828e-01f, 4.76852328e-01f, -1.57237247e-01f, -2.76216447e-01f, -1.99333683e-01f, -3.16678882e-01f,
  -1.08155096e-02f, -1.42822608e-01f, 1.50180131e-03f, -9.11133513e-02f, -3.89465123e-01f, 4.55858022e-01f, -6.71289042e-02f, 7.07765818e-01f, -3.18615735e-01f, -3.17449085e-02f,
  -5.52693754e-02f, 5.91874421e-01f, -6.60118684e-02f, 1.07172638e-01f, -3.65405798e-01f, -2.32469290e-01f, 4.20021445e-01f, 4.31327373e-01f, 3.72441590e-01f, -2.76092794e-02f,
  3.16044122e-01f, 4.47433412e-01f, 2.41604954e-01f, 5.36939315e-02f, 4.15859461e-01f, 1.05380297e-01f, 5.08633792e-01f, 1.42834798e-01f, -6.52677342e-02f, 1.35705993e-01f,
  -6.14489987e-02f, -3.30672897e-02f, -1.02196209e-01f, -1.94713444e-01f, 2.31976286e-01f, -2.08220810e-01f, -2.92150885e-01f, 1.31896690e-01f, -4.13190633e-01f, -3.58848006e-01f,
  -1.29871160e-01f, 1.00469053e+00f, -4.26696688e-01f, 1.45379052e-01f, 6.56869173e-01f, 1.33288130e-01f, 1.47517487e-01f, 4.40932810e-01f, 1.95895627e-01f, 2.52854098e-02f,
  -3.13091487e-01f, -3.71850133e-01f, 5.88297546e-01f, -2.05753461e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.61445439e-01f, -2.52866358e-01f, -2.57350504e-01f, -1.41304448e-01f, 5.15361428e-01f, 3.19027871e-01f, 1.64658263e-01f, -1.44344196e-01f, 1.99494474e-02f, -1.41376415e-02f,
  -2.32400596e-01f, -1.08345207e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    