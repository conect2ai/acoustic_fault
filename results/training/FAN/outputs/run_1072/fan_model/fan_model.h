/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.04825303e-01f, -8.12053829e-02f, -2.09386781e-01f, -4.30054916e-03f, 3.39687057e-02f, -1.64390549e-01f, -2.25174934e-01f, -1.24217771e-01f, -4.97503988e-02f, -4.75692451e-02f,
  1.82806209e-01f, 2.30442017e-01f, 4.49899100e-02f, -6.72379881e-02f, -3.56936455e-02f, -2.82682568e-01f, -2.85012335e-01f, -3.02780509e-01f, -1.53430268e-01f, -2.85528637e-02f,
  6.94297776e-02f, 5.35731465e-02f, -3.62966731e-02f, 3.61606851e-02f, -1.82785448e-02f, 1.18946329e-01f, 6.91062659e-02f, -4.65563983e-02f, -8.67014378e-02f, -1.65720388e-01f,
  -7.89230540e-02f, 1.06904313e-01f, 2.34703701e-02f, 1.05284095e-01f, -1.65957827e-02f, 5.76858222e-02f, 5.01905642e-02f, -2.73998994e-02f, 3.26945010e-04f, 8.96650553e-03f,
  1.34138167e-01f, -2.93216528e-03f, 5.18614873e-02f, 9.16697383e-02f, 4.84864973e-02f, 6.89576045e-02f, 3.07003502e-02f, 3.15680504e-02f, -4.54168990e-02f, -7.30545679e-03f,
  5.52021302e-02f, 1.07925668e-01f, -6.44965917e-02f, -6.58059865e-02f, -1.74657442e-03f, 1.17119417e-01f, 1.27611225e-02f, 8.60324427e-02f, 9.71038789e-02f, -4.28089947e-02f,
  -5.98319322e-02f, -6.79341778e-02f, -5.83397225e-03f, -3.54823694e-02f, 4.52202521e-02f, 6.84503689e-02f, 2.62236781e-02f, 7.85022043e-03f, -4.52760197e-02f, -2.43430790e-02f,
  1.17835000e-01f, -7.17294812e-02f, -4.08474281e-02f, -5.13020866e-02f, 1.32245317e-04f, 3.08321416e-02f, -1.22569902e-02f, 1.49924459e-03f, 1.19480761e-02f, 3.46975029e-02f,
  3.03190220e-02f, 8.06767419e-02f, -1.76434796e-02f, 5.13735190e-02f, 5.85168265e-02f, 4.62612994e-02f, 2.45111971e-03f, 7.95859024e-02f, 4.78082225e-02f, -4.32593785e-02f,
  1.49253845e-01f, 1.54502559e-02f, 4.72699851e-02f, 3.87503281e-02f, 3.93555537e-02f, 8.31414089e-02f, 1.63622592e-02f, 7.50278682e-02f, 1.13781970e-02f, 2.57991422e-02f,
  1.21712826e-01f, 3.98201905e-02f, 3.67536992e-02f, 6.24904558e-02f, 9.18705668e-03f, 1.52343633e-02f, 1.29087716e-02f, -3.70167866e-02f, -3.73264402e-02f, -2.80366596e-02f,
  -3.04859933e-02f, -8.76616091e-02f, -9.98479128e-02f, -3.15785185e-02f, 3.89997028e-02f, 9.42305289e-03f, -4.03929949e-02f, 9.19335429e-03f, -1.45402383e-02f, -4.81856279e-02f,
  2.34233424e-01f, 1.59399465e-01f, -3.43999453e-02f, 8.41077864e-02f, -8.64435211e-02f, -7.63488561e-02f, 8.18096995e-02f, 1.88149133e-05f, 1.15592048e-01f, 1.72866374e-01f,
  1.63178500e-02f, -1.24178216e-01f, -2.02374056e-01f, -1.14632092e-01f, -1.85552895e-01f, -1.95160904e-03f, 1.48352571e-02f, -1.99228272e-01f, -3.46652597e-01f, -1.29594415e-01f,
  -4.92506921e-02f, 1.07404143e-01f, 7.42554665e-02f, -2.51337159e-02f, 7.77646229e-02f, -6.90886378e-02f, 1.85653329e-01f, 1.83820546e-01f, 6.06725998e-02f, 1.42406166e-01f,
  -2.48927213e-02f, 2.78531939e-01f, -1.77237406e-01f, -7.27892742e-02f, 2.52868254e-02f, 3.74906212e-02f, 2.00783405e-02f, 6.80630133e-02f, -5.91267906e-02f, -7.01313885e-03f,
  3.34216803e-02f, 3.42559465e-03f, 4.59298082e-02f, 6.28254637e-02f, 7.78365061e-02f, 8.28067064e-02f, -2.51977146e-02f, -6.60672486e-02f, -3.58654298e-02f, -3.05901114e-02f,
  -7.92132877e-03f, 6.84251636e-03f, -2.32063159e-02f, 2.04271097e-02f, -1.12592116e-01f, -8.72324705e-02f, 2.64131743e-02f, -6.87592402e-02f, 1.09169893e-02f, 2.08557934e-01f,
  8.94341059e-03f, 4.38911431e-02f, -2.20755059e-02f, 1.26870945e-01f, -5.40801957e-02f, 3.08091454e-02f, 5.88491932e-02f, -9.13122296e-03f, 8.74554664e-02f, 1.87602285e-02f,
  2.68351883e-02f, 5.80195943e-03f, 1.02104224e-01f, 5.36882281e-02f, 1.22236405e-02f, 1.11532748e-01f, 2.88445735e-03f, -1.71422865e-02f, 2.19666958e-02f, 6.32258728e-02f,
  -1.17893489e-02f, 5.44781424e-02f, 7.17294887e-02f, 5.15713822e-03f, -1.65397220e-03f, -4.40594144e-02f, 7.28393272e-02f, -3.21590193e-02f, 1.03005916e-02f, 4.02528085e-02f,
  7.15563744e-02f, -2.06821337e-01f, 1.07940175e-02f, -1.19853757e-01f, -6.97410926e-02f, -7.71939084e-02f, -5.45513965e-02f, -1.23875149e-01f, -3.05772945e-02f, 1.11447349e-02f,
  -9.89190638e-02f, -1.19223803e-01f, 3.26515585e-02f, -8.17254707e-02f, -6.23360835e-02f, -1.13422014e-01f, -2.36295648e-02f, -7.97665864e-02f, -8.00842047e-02f, -2.41421517e-02f,
  -1.25102475e-01f, -3.42300534e-02f, -5.69148771e-02f, -1.22897662e-01f, -6.07125200e-02f, -2.25038394e-01f, -1.11073583e-01f, -7.27439253e-03f, -6.67610466e-02f, 3.48072834e-02f,
  1.23342417e-01f, 5.77818640e-02f, 2.89914787e-01f, -1.61339864e-02f, 1.24549903e-01f, 7.52718672e-02f, 1.61521479e-01f, -4.74016480e-02f, -1.70082629e-01f, 3.15636732e-02f,
  -1.60868347e-01f, -8.95641521e-02f, -9.47231576e-02f, -5.93938902e-02f, -4.54065576e-03f, 1.75856322e-01f, 5.61986901e-02f, 6.07930720e-02f, 7.44678378e-02f, 1.46527132e-02f,
  -6.75014928e-02f, -2.24739105e-01f, -1.27333552e-01f, -8.76007453e-02f, -1.31837428e-01f, -1.13469332e-01f, -1.40519008e-01f, -1.30081493e-02f, -6.67231828e-02f, -8.71569142e-02f,
  -4.86917943e-02f, 2.51568407e-01f, -5.13355881e-02f, 1.61521882e-02f, 2.87291314e-02f, 5.55142164e-02f, 7.77382925e-02f, 9.27886814e-02f, -6.95693493e-02f, 6.35055900e-02f,
  2.49511916e-02f, -3.01956069e-02f, -6.57723770e-02f, 3.62648629e-02f, 2.85691805e-02f, 3.56549844e-02f, 1.50093911e-02f, 1.40283676e-02f, -2.23524161e-02f, -1.96418837e-02f,
  -9.50287431e-02f, 9.57061201e-02f, 1.31037831e-01f, -4.59611192e-02f, 1.49876624e-01f, 9.92407184e-03f, -2.76496802e-02f, 4.70929220e-03f, 1.51760904e-02f, -8.85849539e-03f,
  -8.56504068e-02f, -4.00897488e-02f, 2.62723491e-02f, 8.85765627e-03f, -3.33954841e-02f, -4.31965385e-03f, 4.05337922e-02f, 8.18939228e-03f, -2.97600590e-02f, -6.57195076e-02f,
  5.05295284e-02f, -1.29012046e-02f, 1.52304508e-02f, 1.05180778e-01f, 7.73270475e-03f, 1.10560186e-01f, 4.57154680e-03f, -2.85321362e-02f, 8.87961090e-02f, -3.23494710e-02f,
  2.76554096e-02f, 1.16013184e-01f, 4.64956798e-02f, -2.12665349e-02f, 6.73870891e-02f, 8.09164196e-02f, -5.10568637e-03f, 1.77215580e-02f, -2.88948119e-02f, 1.06833756e-01f,
  -3.59859675e-01f, -1.13193989e-02f, -1.38091892e-01f, -4.32127602e-02f, 1.81176905e-02f, -3.41558717e-02f, -1.06517896e-01f, -5.45281395e-02f, 5.84815815e-02f, -1.06504932e-01f,
  5.99191859e-02f, -4.09106016e-02f, -9.43260044e-02f, -7.20636919e-02f, -1.03354670e-01f, 1.02298167e-02f, -1.03062935e-01f, 5.63275702e-02f, -4.49612401e-02f, 5.25695160e-02f,
  -3.67186330e-02f, -6.07579900e-03f, -4.84140739e-02f, -9.41838250e-02f, 5.96353337e-02f, 2.03355011e-02f, -5.90213388e-02f, -6.84142113e-04f, 3.14354338e-02f, -1.45815164e-01f,
  -1.22474939e-01f, 3.90796393e-01f, -2.99910884e-02f, 3.63917612e-02f, 2.25472599e-01f, 1.12815961e-01f, 2.36134917e-01f, 1.26095116e-02f, -1.04805663e-01f, 1.27260059e-01f,
  2.19995260e-01f, 7.55455270e-02f, 7.59210717e-03f, -1.41143762e-02f, -1.49503544e-01f, 4.85000722e-02f, -4.77276631e-02f, -6.40011281e-02f, -2.66279012e-01f, 9.34865996e-02f,
  8.54159519e-02f, -1.42888334e-02f, -4.59418520e-02f, -3.14960033e-02f, 1.94145188e-01f, 1.09400257e-01f, 8.49543512e-02f, 2.42236719e-01f, 3.04621339e-01f, 3.06692541e-01f,
  6.08123615e-02f, 1.68974966e-01f, -1.24025932e-02f, 1.62492961e-01f, 1.90222591e-01f, 1.01306602e-01f, 9.11395103e-02f, 1.12995952e-01f, 1.94753349e-01f, 1.31288767e-01f,
  1.78052977e-01f, 1.11171827e-01f, 1.32870182e-01f, 1.31916672e-01f, 1.19126484e-01f, 9.75624993e-02f, 1.94707550e-02f, -4.24219668e-02f, 7.37593323e-02f, 1.88679591e-01f,
  2.70878285e-01f, 2.93341607e-01f, 7.43245706e-02f, 1.69049725e-01f, 1.63752466e-01f, 1.24184199e-01f, 2.09905997e-01f, 1.14959776e-01f, 1.34296983e-01f, 1.91502795e-01f,
  -2.83127911e-02f, -5.97954467e-02f, -1.27283961e-01f, -1.35762990e-01f, -1.02878518e-01f, -1.58889800e-01f, -9.26077589e-02f, -1.29715741e-01f, -1.03165798e-01f, -1.92711532e-01f,
  -2.07901239e-01f, -7.49290958e-02f, -1.89860463e-01f, -5.95440045e-02f, -1.61518589e-01f, -2.00094357e-01f, -1.02661110e-01f, -1.45832911e-01f, -1.48814157e-01f, -1.39458671e-01f,
  -1.66454971e-01f, -1.13143392e-01f, -2.15846926e-01f, -1.10584155e-01f, -2.24257350e-01f, -1.40294150e-01f, -1.50052950e-01f, -1.42585829e-01f, -1.61726311e-01f, -9.86176729e-02f,
  -1.33452967e-01f, 1.44649848e-01f, 3.20516415e-02f, 9.75791439e-02f, 1.28062278e-01f, 5.21233790e-02f, 1.69976592e-01f, 1.82848632e-01f, 1.77262887e-01f, 1.22129545e-01f,
  1.50139257e-01f, 8.32646415e-02f, 9.42190811e-02f, 1.40178069e-01f, 2.03245096e-02f, 1.26032829e-01f, 1.14985049e-01f, 3.57188545e-02f, 1.40694648e-01f, 9.24638957e-02f,
  9.15601924e-02f, 1.40504539e-01f, -5.39848879e-02f, -8.51271395e-03f, 1.28407106e-01f, 1.11860722e-01f, 1.40720764e-02f, 7.51614869e-02f, -1.13960006e-03f, -3.77131830e-04f,
  9.38818678e-02f, 3.89667332e-01f, 9.67660844e-02f, 1.02526270e-01f, 1.82125673e-01f, 1.88044310e-01f, 2.57633448e-01f, 1.02905743e-01f, -7.26741040e-03f, 2.09742323e-01f,
  1.27508730e-01f, -1.32809617e-02f, -2.30952445e-02f, 2.23773625e-02f, 1.46288052e-01f, 3.00852120e-01f, 1.89652786e-01f, -9.48801860e-02f, -1.29400700e-01f, -7.76444897e-02f,
  7.01248571e-02f, 4.92384657e-02f, -8.52244869e-02f, 7.20022153e-03f, 1.98272303e-01f, 5.88928945e-02f, 1.09785654e-01f, 7.58704245e-02f, 1.44359753e-01f, 2.19901055e-01f,
  -3.26207988e-02f, 2.63709903e-01f, -2.53394675e-02f, 2.11199909e-01f, 7.34633133e-02f, 1.21097967e-01f, 1.12062804e-01f, 1.22462146e-01f, 1.98922172e-01f, 1.62648812e-01f,
  1.88329369e-01f, 1.43188059e-01f, 2.04487309e-01f, 1.92560986e-01f, 2.02455744e-01f, 1.50977373e-01f, 1.65907174e-01f, 7.61040300e-02f, 1.15948118e-01f, 1.87038034e-01f,
  2.42122620e-01f, 2.22007975e-01f, 1.54139668e-01f, 2.22097129e-01f, 2.79315382e-01f, 1.22263260e-01f, 2.14128718e-01f, 1.77856073e-01f, 8.78431499e-02f, 1.56549543e-01f,
  4.10469947e-03f, 4.86883223e-02f, -7.96052814e-02f, -6.40031844e-02f, -1.38625083e-02f, -2.25602463e-02f, -6.71592802e-02f, -4.69919555e-02f, -4.10624556e-02f, -1.11820899e-01f,
  -8.80725309e-02f, -1.23516306e-01f, -2.10087020e-02f, -1.03100583e-01f, -8.39874446e-02f, -1.44218141e-03f, -3.48278843e-02f, -2.87802406e-02f, -1.27877891e-01f, -1.14529785e-02f,
  -9.16241407e-02f, -7.27422014e-02f, -1.22566707e-01f, -1.19958736e-01f, 2.89771762e-02f, -3.37544866e-02f, -6.94103763e-02f, -1.50255203e-01f, -2.83009354e-02f, 2.90061347e-02f,
  -1.24039084e-01f, 3.72290872e-02f, 3.63799222e-02f, 4.76867408e-02f, 1.19814888e-01f, 1.41928390e-01f, 1.09011367e-01f, 4.59613800e-02f, 9.97547358e-02f, 1.97098196e-01f,
  1.30869821e-01f, 1.05909862e-01f, 1.13873906e-01f, 5.30052073e-02f, 1.36596397e-01f, 1.38597071e-01f, 1.78731203e-01f, 1.49020374e-01f, 1.66352481e-01f, 1.34965017e-01f,
  2.26543933e-01f, 2.03137815e-01f, 5.89500554e-02f, 2.02973351e-01f, 1.95077673e-01f, 1.35740295e-01f, 6.76364526e-02f, 1.16651140e-01f, 5.12687750e-02f, 7.84520879e-02f,
  3.13422233e-02f, -1.91288441e-01f, -1.14807405e-01f, 1.79646276e-02f, -3.11022103e-02f, -1.63950063e-02f, -2.56929189e-01f, 4.02350686e-02f, 9.90377143e-02f, -1.03134692e-01f,
  1.07457504e-01f, 2.26922929e-01f, 2.04101726e-01f, 1.02568798e-01f, 8.87218267e-02f, -6.64787516e-02f, -1.61755353e-01f, -2.59377174e-02f, 6.51756600e-02f, 2.65075807e-02f,
  -3.66704054e-02f, -1.88897979e-02f, 1.56361997e-01f, 6.25802651e-02f, -3.84792164e-02f, -4.90492471e-02f, -1.94598809e-01f, -1.82942584e-01f, -1.71679631e-01f, -2.61323512e-01f,
  -1.10198215e-01f, -6.59801513e-02f, 1.05618849e-01f, 2.68523693e-02f, -7.80895576e-02f, -6.10795431e-02f, -2.66947038e-02f, -9.50256363e-03f, 7.04713613e-02f, -5.74974604e-02f,
  -1.68622881e-02f, -6.41229283e-03f, 7.26497099e-02f, -2.10649185e-02f, -9.88960862e-02f, -1.07035443e-01f, 5.85160740e-02f, 5.06764911e-02f, -7.77647942e-02f, 2.68990602e-02f,
  4.62475047e-02f, -1.33142963e-01f, -1.68211043e-01f, -1.05838090e-01f, -7.79399425e-02f, 9.21353474e-02f, -1.17250439e-03f, -1.30604029e-01f, -1.61356986e-01f, -2.46484667e-01f,
  -4.65263054e-02f, -2.68377978e-02f, 8.76104236e-02f, 2.23702304e-02f, 1.99005865e-02f, 5.05107157e-02f, 9.25000478e-03f, 2.20170449e-02f, 3.57369967e-02f, -2.07305681e-02f,
  -1.82381961e-02f, 5.65743335e-02f, -3.84755060e-02f, -2.85190716e-02f, 6.06965348e-02f, 4.77937236e-02f, -4.02990915e-02f, 3.34899104e-03f, 3.36494334e-02f, 2.16950513e-02f,
  1.03128538e-01f, 5.50873503e-02f, 3.20336483e-02f, -3.14247906e-02f, 5.04341386e-02f, 5.87911718e-02f, 5.78177609e-02f, 4.76002553e-03f, 2.28845775e-02f, -3.94539908e-02f,
  -3.19470428e-02f, 2.19354093e-01f, -1.08673461e-01f, 6.12819716e-02f, 6.75195549e-03f, -3.79253626e-02f, -2.42369552e-03f, 4.87817153e-02f, -2.39133332e-02f, -4.65443544e-02f,
  8.72769952e-02f, -1.46259705e-03f, -8.14140663e-02f, -5.46642579e-02f, 3.55822407e-02f, 1.80948284e-02f, 2.38871146e-02f, -9.55120753e-03f, -1.11334994e-02f, -2.16116365e-02f,
  -6.35838881e-03f, -7.34576136e-02f, 3.77193131e-02f, -6.77618235e-02f, -2.67580859e-02f, 8.75277724e-03f, -1.03715256e-01f, -8.82005692e-02f, -4.51354496e-02f, -2.27609277e-01f,
  -4.12666053e-01f, 9.86697599e-02f, 9.84955877e-02f, -1.02308877e-01f, -6.39975742e-02f, -2.32139438e-01f, -1.66558981e-01f, -2.06305504e-01f, -5.02505451e-02f, -7.38215894e-02f,
  3.15559991e-02f, -2.34207511e-02f, -8.31755027e-02f, 4.41741794e-02f, -6.95460662e-02f, 8.19494575e-03f, 6.19100556e-02f, 4.39812206e-02f, -4.37492393e-02f, -2.46750447e-03f,
  5.93794435e-02f, 3.85394543e-02f, 1.68675229e-01f, 6.19118474e-02f, 7.66244605e-02f, 1.23424791e-02f, 2.16643140e-01f, 2.20505834e-01f, 1.48079008e-01f, 3.12714577e-01f,
  8.78657550e-02f, -2.37016845e-02f, -1.21460125e-01f, -2.15792656e-02f, 4.74424399e-02f, 3.57783474e-02f, -7.66640995e-03f, 1.20724607e-02f, 6.08858094e-02f, -5.12993969e-02f,
  3.96649987e-02f, 2.69974805e-02f, 1.50797274e-02f, -6.30676607e-03f, -2.60868780e-02f, 7.52398595e-02f, 5.17372824e-02f, 7.22265169e-02f, 1.90658006e-03f, 8.68428349e-02f,
  6.38442636e-02f, 8.86974856e-02f, 2.61899224e-03f, -6.84150830e-02f, -6.07061572e-02f, 5.52932918e-02f, -1.16732705e-03f, 5.64908832e-02f, 6.91411830e-03f, -4.30623665e-02f,
  -3.51101644e-02f, 3.65063287e-02f, 1.04505695e-01f, 5.17845303e-02f, -2.70546023e-02f, 1.05764754e-01f, 7.29691982e-02f, 3.49866301e-02f, 2.60942094e-02f, 9.01872292e-02f,
  7.77325779e-03f, -4.38464135e-02f, 2.46159565e-02f, -6.99879788e-03f, 8.31386745e-02f, -8.29839148e-03f, 1.01460190e-02f, 1.04374275e-01f, 5.54992594e-02f, 4.60266359e-02f,
  8.90938640e-02f, 9.58057046e-02f, 3.83245163e-02f, 2.33949218e-02f, 6.43045222e-03f, 7.04884902e-02f, 1.09903188e-02f, 9.04084221e-02f, 6.00450439e-03f, 2.39358488e-02f,
  -8.47810134e-02f, -9.28175151e-02f, -5.47361448e-02f, -2.96583977e-02f, 6.52121976e-02f, 5.05290180e-02f, 5.95416548e-03f, 8.84544030e-02f, 1.20920073e-02f, 5.55711500e-02f,
  8.12805668e-02f, -3.37773487e-02f, -4.01079580e-02f, 3.21456790e-02f, 2.93335244e-02f, -6.22115657e-02f, -5.14382273e-02f, 3.23117375e-02f, 7.69202411e-02f, 4.17247564e-02f,
  5.95735833e-02f, -1.22697186e-02f, -1.30373105e-01f, -8.29817168e-03f, 6.57906011e-02f, -1.00637980e-01f, -5.96700348e-02f, 7.52708735e-03f, -6.10060729e-02f, -1.18656769e-01f,
  -3.34011346e-01f, 2.21048132e-01f, -1.75244525e-01f, 2.17466772e-01f, 2.07145717e-02f, -6.97769597e-02f, 4.31605577e-02f, 4.66600768e-02f, 1.19013235e-01f, -4.62453254e-02f,
  6.17380328e-02f, -8.18406232e-03f, 6.89141899e-02f, 1.43733332e-02f, -1.09073177e-01f, -3.02245617e-02f, 1.11481547e-02f, -1.42197594e-01f, -1.49720997e-01f, -7.91299045e-02f,
  1.37059599e-01f, 1.24064714e-01f, -2.64414791e-02f, 8.48356113e-02f, 1.25671640e-01f, 7.84112588e-02f, 5.94044197e-03f, 5.37548922e-02f, -1.86266545e-02f, 3.06411207e-01f,
  -1.18574664e-01f, 9.61888060e-02f, -3.08916736e-02f, 6.73584566e-02f, -1.03209075e-02f, -5.30691147e-02f, -6.52628392e-02f, 8.19791481e-02f, 4.72141802e-02f, 5.68830371e-02f,
  4.41849492e-02f, 1.17643755e-02f, -8.97728000e-03f, 9.27119926e-02f, 1.04723446e-01f, -4.24596481e-02f, 1.45330057e-01f, 1.04384989e-01f, 9.80043784e-03f, 9.99815241e-02f,
  1.53510496e-01f, -4.42704596e-02f, 1.38698872e-02f, -8.97171069e-03f, -1.88457947e-02f, 2.93960869e-02f, 2.34168582e-02f, 6.50958940e-02f, -2.60881074e-02f, 1.58190355e-03f,
  -9.98078883e-02f, -1.02964081e-01f, -1.09043717e-02f, 2.97495034e-02f, -5.86000979e-02f, -7.08648115e-02f, -5.13348319e-02f, -5.16890287e-02f, -7.66586214e-02f, -3.76724675e-02f,
  -1.88797861e-02f, 2.33843531e-02f, -6.90224469e-02f, -9.63323936e-03f, 4.07038890e-02f, 2.79179849e-02f, -4.53944579e-02f, 7.64699504e-02f, -6.14360673e-03f, -4.41080853e-02f,
  4.67308573e-02f, -1.34221077e-01f, -2.71677673e-02f, 3.67568992e-02f, 8.07102211e-03f, 1.64566394e-02f, 6.23853458e-03f, 2.06447989e-02f, -6.97646067e-02f, 3.58201340e-02f,
  -9.47688445e-02f, -2.75347760e-04f, -1.12448502e-02f, 7.05588385e-02f, 1.19655598e-02f, 8.48626569e-02f, 4.51733768e-02f, 1.03280105e-01f, 1.84798297e-02f, 1.00452742e-02f,
  -3.61739397e-02f, 1.98910455e-03f, 9.82521474e-02f, 6.15358315e-02f, -2.37077270e-02f, -1.55763039e-02f, 3.13860690e-03f, 2.50988100e-02f, 4.01406102e-02f, 5.24701625e-02f,
  -4.85935882e-02f, -6.06900454e-02f, -1.07454903e-01f, -6.03236817e-02f, 1.95610672e-02f, -1.55722424e-01f, -6.37087747e-02f, -4.40629087e-02f, -2.32368603e-01f, -1.61218658e-01f,
  -1.99660495e-01f, 2.64126420e-01f, 1.89058930e-01f, 9.96411592e-02f, 7.42386878e-02f, -1.52449280e-01f, -1.66655883e-01f, -6.19059056e-02f, -1.96239389e-02f, 1.23082072e-01f,
  1.42606720e-01f, -1.14527553e-01f, -5.86803108e-02f, 3.30042653e-02f, -1.40715897e-01f, 8.50011706e-02f, 2.38843605e-01f, -2.70038396e-02f, -2.80556232e-01f, -1.93121821e-01f,
  -3.56972888e-02f, 6.13858039e-03f, 5.43920919e-02f, 3.37387174e-02f, 2.20709473e-01f, -4.61597741e-02f, 1.57488301e-01f, 1.77852511e-01f, 9.54930484e-02f, 3.14011484e-01f,
  -3.07221850e-03f, 1.55295491e-01f, -6.69010729e-02f, 1.83302145e-02f, 8.42340663e-02f, 2.52249874e-02f, -4.29223180e-02f, 1.38778374e-01f, 1.29428208e-01f, -7.61138648e-03f,
  1.70011118e-01f, 6.11003712e-02f, 1.23195849e-01f, 3.81273516e-02f, 9.69797224e-02f, -4.64863516e-02f, 9.91738439e-02f, 1.08304232e-01f, 6.26534745e-02f, -6.48019183e-03f,
  1.14544153e-01f, 7.70319179e-02f, 4.24396507e-02f, -2.29436103e-02f, 5.29183336e-02f, 8.53664055e-03f, 8.95949639e-03f, 1.45516515e-01f, -5.27923927e-02f, 4.08457890e-02f,
  -6.27382621e-02f, 1.41344620e-02f, -3.33197117e-02f, -1.13175549e-01f, -1.07357055e-01f, -7.37707764e-02f, 1.22222332e-02f, -5.80311567e-02f, -9.90114734e-02f, -4.84493263e-02f,
  -2.93302462e-02f, -1.85023677e-02f, -4.84898165e-02f, -9.57727879e-02f, -5.06901508e-03f, -1.60878692e-02f, -1.09833777e-01f, -1.25952670e-02f, -8.53776187e-03f, 4.21472080e-02f,
  -6.99082911e-02f, -7.76598901e-02f, -3.75667252e-02f, -5.40753081e-02f, -2.50401087e-02f, -7.46663660e-02f, 9.92778502e-03f, -5.64632341e-02f, -1.01700407e-02f, -1.03825051e-02f,
  -5.42451181e-02f, 1.21584177e-01f, -1.74727533e-02f, 3.61504294e-02f, 9.38020647e-02f, 1.05823100e-01f, 7.33244270e-02f, 7.03688562e-02f, 5.57797886e-02f, 5.35891354e-02f,
  5.24104759e-02f, -3.34038027e-02f, 8.02214295e-02f, 6.66040257e-02f, 1.14289224e-02f, -4.23848480e-02f, 1.65107280e-01f, 4.99353446e-02f, 2.64818892e-02f, 1.07740395e-01f,
  1.27724290e-01f, -7.91616440e-02f, -8.27703774e-02f, -7.85291661e-03f, 9.28030256e-03f, -4.29757647e-02f, -3.79586145e-02f, -7.15184212e-02f, -1.60778373e-01f, -1.89678758e-01f,
  4.86686170e-01f, -7.93614797e-03f, 1.03337646e-01f, 2.12353870e-01f, -1.13907166e-01f, -1.99721918e-01f, -1.74795642e-01f, -3.34403105e-02f, 1.46338224e-01f, 3.08595654e-02f,
  -8.21184425e-04f, 2.30636746e-01f, 1.86223879e-01f, 2.51414418e-01f, 1.16990075e-01f, -5.51051274e-02f, 1.68577656e-01f, 3.01312417e-01f, 1.95880815e-01f, -3.74560915e-02f,
  -1.09395511e-01f, 1.65629998e-01f, 1.59632266e-01f, 1.70827329e-01f, 1.09862365e-01f, 1.87135413e-01f, -7.07233027e-02f, 2.63626333e-02f, -6.26190156e-02f, 1.46442756e-01f,
  1.27094880e-01f, -8.79948661e-02f, 1.37118384e-01f, 7.45705813e-02f, 5.09763807e-02f, 8.16811025e-02f, 9.60935205e-02f, 1.05188526e-01f, 6.07471466e-02f, 7.80048892e-02f,
  2.65706945e-02f, 9.96881798e-02f, 1.14040613e-01f, -2.59453543e-02f, -2.99849790e-02f, 1.50521491e-02f, 7.46662766e-02f, 1.05994277e-01f, 1.52519166e-01f, -2.65677162e-02f,
  -3.26046930e-03f, -2.81830430e-02f, -4.38781045e-02f, 3.84377539e-02f, 5.35309128e-02f, 7.38242939e-02f, -4.46031094e-02f, -8.78318772e-03f, -2.33304463e-02f, 1.88453779e-01f,
  2.51486246e-02f, -2.19363645e-02f, -7.65849790e-03f, -2.07778979e-02f, -7.90605620e-02f, -5.06764464e-02f, 7.32490122e-02f, -5.20543568e-02f, -8.84204060e-02f, -6.53958619e-02f,
  1.11737363e-02f, -8.08255896e-02f, -3.56153846e-02f, -1.33176241e-03f, 8.21183026e-02f, 4.89635728e-02f, 2.65694819e-02f, 1.03892274e-02f, -1.66625291e-01f, -3.24308872e-02f,
  -4.55876440e-02f, -1.51424203e-03f, -1.34983920e-02f, 1.70649611e-03f, -5.74870631e-02f, 8.41728672e-02f, -7.96057843e-03f, -8.90483335e-02f, 1.39064668e-02f, -5.16679212e-02f,
  1.87588260e-01f, 2.65338197e-02f, 1.32327214e-01f, 1.39225334e-01f, -1.40437251e-02f, 1.63654312e-01f, 6.48187101e-02f, 1.11207195e-01f, 6.87949210e-02f, 1.45079166e-01f,
  -7.46970810e-03f, 1.18779846e-01f, 6.57612830e-02f, -8.90916772e-03f, -4.41493206e-02f, -3.10743377e-02f, 1.18925991e-02f, 9.79157388e-02f, 7.88757056e-02f, -4.28133719e-02f,
  5.58580793e-02f, -7.30281183e-03f, 7.41897002e-02f, 8.04116875e-02f, 8.16042200e-02f, 1.78829759e-01f, 5.05391322e-03f, -4.88444269e-02f, 9.01369005e-02f, 1.13966651e-01f,
  -2.56665409e-01f, -8.82982612e-02f, -1.99674845e-01f, -2.37969831e-01f, -9.20298174e-02f, 7.72179514e-02f, -8.96222442e-02f, 3.98606732e-02f, 6.25844672e-02f, -7.83294514e-02f,
  2.53867451e-02f, 1.46494508e-01f, 1.27858818e-01f, 1.79022193e-01f, 2.02882305e-01f, -6.80678189e-02f, 2.50403509e-02f, 1.21521764e-02f, 6.76630065e-02f, 3.71024609e-02f,
  4.84422408e-03f, -7.50367120e-02f, -6.30632862e-02f, 5.70238568e-02f, -8.65230262e-02f, 5.70443533e-02f, -3.78475003e-02f, -6.06879443e-02f, 7.83093367e-03f, -1.28671005e-01f,
  -2.34455198e-01f, -1.01093486e-01f, 1.09849714e-01f, 7.96424821e-02f, 1.87725909e-02f, 1.31494790e-01f, 3.97628881e-02f, 5.76833971e-02f, 1.05084449e-01f, -2.82738935e-02f,
  3.31966876e-04f, 9.27757919e-02f, 7.30911344e-02f, 1.97365345e-03f, 3.10571697e-02f, 1.34461939e-01f, 3.82637233e-02f, 6.40691444e-02f, 1.26347363e-01f, 2.70767938e-02f,
  1.47820398e-01f, -9.43939760e-02f, -6.46799728e-02f, 1.59563273e-01f, 6.91369921e-02f, 1.74212791e-02f, -6.10455498e-03f, 1.58128291e-01f, 1.83732271e-01f, -2.44491138e-02f,
  -7.06119016e-02f, -3.47486436e-02f, -7.04144165e-02f, -8.24540928e-02f, -6.69815168e-02f, -6.99146241e-02f, -8.23181495e-02f, -3.51876579e-02f, -8.46894532e-02f, -3.14185955e-02f,
  -9.18023735e-02f, -8.88280645e-02f, -2.74581015e-02f, -7.62648433e-02f, 2.42065806e-02f, -1.17979601e-01f, -8.89830589e-02f, -6.70326129e-02f, -5.78967147e-02f, -5.36992140e-02f,
  -1.18265651e-01f, -4.51904982e-02f, -8.99169743e-02f, 9.60149430e-03f, -8.44326764e-02f, -1.60016432e-01f, -1.30054221e-01f, -1.03088766e-01f, -7.09157735e-02f, -1.39348745e-01f,
  -2.32748874e-02f, 3.00622761e-01f, 1.49229122e-02f, 2.03019798e-01f, 1.48017749e-01f, 1.01338409e-01f, 1.27662672e-02f, 4.56129573e-02f, 9.36578885e-02f, 4.63901497e-02f,
  2.57392470e-02f, 5.30581251e-02f, 4.27558534e-02f, 1.48975059e-01f, 1.79665759e-01f, 6.18917905e-02f, 8.01060721e-02f, 4.88833785e-02f, 1.53584644e-01f, 1.21058989e-02f,
  8.52294266e-02f, 5.95414490e-02f, 3.23660625e-03f, 1.23550661e-01f, 1.07714958e-01f, 4.62540761e-02f, -1.02766128e-02f, -6.86478708e-03f, 1.07259147e-01f, -1.37210250e-01f,
  -3.51601988e-02f, -2.13705659e-01f, 2.72787660e-01f, 1.93671193e-02f, 1.23338290e-01f, -5.25464453e-02f, -6.90285563e-02f, -1.65743276e-01f, 1.31965233e-02f, 1.28592663e-02f,
  -1.49044588e-01f, -3.29976296e-03f, 1.20527610e-01f, 6.49641454e-02f, -1.09287940e-01f, 3.29377614e-02f, 2.54726768e-01f, 2.57271528e-01f, 1.69501618e-01f, -9.59328562e-02f,
  1.61777120e-02f, -8.01783949e-02f, -4.71196584e-02f, -1.27391353e-01f, -7.35788718e-02f, 1.22966580e-01f, -1.39570475e-01f, -1.83174573e-02f, -1.38291404e-01f, 1.77367941e-01f,
  2.07487531e-02f, -2.60547966e-01f, 3.99630144e-02f, -3.19443494e-02f, -5.34526967e-02f, 1.80145521e-02f, -4.32764675e-04f, -4.05253246e-02f, -2.13757288e-02f, -3.07769328e-02f,
  -3.01205888e-02f, -1.28953740e-01f, 9.45463125e-03f, -7.59463087e-02f, -5.53918518e-02f, -1.07580610e-01f, -1.25479370e-01f, -2.69104559e-02f, 4.37082872e-02f, -9.59076639e-03f,
  6.24833745e-04f, 1.80711634e-02f, -1.03919446e-01f, -6.45900816e-02f, -1.33775949e-01f, 2.80070882e-02f, -8.25015306e-02f, -5.69994040e-02f, -1.50054559e-01f, -3.85831334e-02f,
  1.06781870e-01f, 2.14226525e-02f, 1.49587253e-02f, -3.07419319e-02f, -4.37543727e-02f, 3.64094228e-03f, 7.05778897e-02f, -4.21675965e-02f, -4.57059406e-02f, -6.11044243e-02f,
  -9.63386446e-02f, -7.75157753e-03f, -5.43886423e-02f, -8.05519298e-02f, -1.41365891e-02f, -5.17609119e-02f, 3.03767575e-03f, -1.90771706e-02f, -5.05120046e-02f, -8.91714245e-02f,
  -7.24115297e-02f, 2.01580338e-02f, -2.28624861e-03f, 1.33712916e-03f, -1.19932881e-02f, -7.83359259e-03f, 4.98948619e-02f, -7.40740448e-02f, -4.43324372e-02f, -3.33059393e-02f,
  -4.68479656e-02f, 3.67563479e-02f, 1.50412172e-01f, 6.10418804e-02f, 4.64029610e-03f, -4.62086499e-02f, -2.92837359e-02f, 6.74502598e-03f, 2.98603568e-02f, -5.12982942e-02f,
  -5.96696101e-02f, -3.41666676e-02f, -8.43711868e-02f, -2.56888904e-02f, -1.28294039e-03f, -9.35899839e-03f, -2.35227421e-02f, 4.02700789e-02f, 3.23226117e-02f, -1.32271752e-01f,
  -5.44200540e-02f, 9.91513208e-02f, 1.32784724e-01f, 7.28661777e-04f, 5.07987924e-02f, 9.38757733e-02f, 8.00261125e-02f, 4.59396988e-02f, 5.45113683e-02f, 6.44476637e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.43641549e-01f, -7.86795542e-02f, 2.19701558e-01f, 3.85065302e-02f, -5.88061325e-02f, -8.84049535e-02f, -2.63440430e-01f, -1.60267204e-01f, -4.65666912e-02f, 2.18293648e-02f,
  6.39666319e-02f, 2.40759015e-01f, 2.48313963e-01f, 1.54125497e-01f, 1.10096581e-01f, -5.55364601e-02f, -8.69358331e-03f, 1.84218392e-01f, 1.43586606e-01f, -2.37158407e-02f,
  -8.41114521e-02f, -9.43077132e-02f, -1.58529772e-04f, -3.64056556e-03f, -4.16736044e-02f, 3.83747555e-02f, -5.00642434e-02f, -1.54308468e-01f, -8.73598456e-02f, -1.65433183e-01f,
  3.30229580e-01f, 1.14310116e-01f, 1.90640956e-01f, 7.53893405e-02f, 9.34731886e-02f, 4.95879352e-02f, 1.26419038e-01f, -7.75104109e-03f, 1.79095510e-02f, 5.22967428e-02f,
  -1.50981341e-02f, -7.27113262e-02f, -3.78498919e-02f, -1.57530665e-01f, -1.47554740e-01f, 2.69152652e-02f, -8.56706947e-02f, -8.95852000e-02f, -3.37875746e-02f, -4.53952588e-02f,
  -4.12269384e-02f, 2.33089477e-02f, -2.65120659e-02f, 7.17328340e-02f, 7.46701136e-02f, 1.13919780e-01f, 2.05836426e-02f, -1.21605117e-02f, -2.51746010e-02f, -1.22635201e-01f,
  2.83690035e-01f, 5.62468357e-02f, -3.89497243e-02f, 1.37770057e-01f, 3.17296572e-02f, 1.37968110e-02f, 1.69963166e-02f, -9.71567854e-02f, 2.32457556e-02f, -1.38098404e-01f,
  -1.64768711e-01f, 7.36044273e-02f, 1.67833120e-02f, 1.07896462e-01f, 1.70507908e-01f, -1.09670259e-01f, -5.84711432e-02f, 1.50929615e-01f, 8.41386318e-02f, -7.96551704e-02f,
  6.79886015e-03f, -6.77350312e-02f, -2.53769308e-02f, -8.50417763e-02f, -1.43440709e-01f, 1.84504110e-02f, -3.25966142e-02f, -1.18707672e-01f, -1.41302809e-01f, -1.26476586e-01f,
  -3.29520516e-02f, 3.49028587e-01f, 1.39755160e-01f, 3.92890759e-02f, -8.90473649e-02f, -8.83121863e-02f, 2.11546451e-01f, 1.01966478e-01f, 3.05981692e-02f, 1.75495595e-01f,
  2.01029237e-02f, 7.01066777e-02f, 1.06623575e-01f, -1.69370756e-01f, -6.64782450e-02f, 7.40288496e-02f, -1.47573967e-02f, 4.12991084e-02f, 6.00244775e-02f, -4.58893664e-02f,
  -7.13553950e-02f, 6.36046976e-02f, 2.63132781e-01f, 1.44217506e-01f, 1.00516170e-01f, 2.12755010e-01f, 1.16370045e-01f, 5.38478680e-02f, 1.38223827e-01f, -7.90778399e-02f,
  5.52675962e-01f, 2.94267952e-01f, 4.29877996e-01f, 3.67465732e-03f, -9.44956318e-02f, -1.71527609e-01f, -1.84349149e-01f, 3.12559307e-02f, -7.74497688e-02f, 9.58506092e-02f,
  1.59844488e-01f, -1.69437584e-02f, 8.24519396e-02f, -1.79361049e-02f, 1.11656100e-01f, -2.29189191e-02f, -7.60184675e-02f, 3.08197260e-01f, 1.25063837e-01f, -7.39314035e-02f,
  -1.78285897e-01f, 2.24755257e-01f, 2.69598663e-01f, 2.10754089e-02f, 5.70037887e-02f, -1.60470843e-01f, 2.65956018e-02f, 2.08831564e-01f, -3.57299894e-02f, 7.38959908e-02f,
  3.38228583e-01f, 2.50650287e-01f, -2.92381585e-01f, 1.14390356e-02f, 1.12053074e-01f, -2.20930930e-02f, -3.87565941e-02f, -1.37562202e-02f, -8.37016851e-02f, -5.42123616e-02f,
  2.07837075e-01f, 3.49355228e-02f, 1.12920376e-02f, -5.44667207e-02f, 1.31975589e-02f, -7.75353834e-02f, 5.05910926e-02f, 8.66618082e-02f, -1.35725159e-02f, 3.34858112e-02f,
  -2.05191121e-01f, 3.11945821e-03f, -1.18303364e-02f, -1.15229666e-01f, -3.15390080e-02f, 1.34895183e-02f, 7.25287870e-02f, -2.28966158e-02f, 7.79822050e-03f, -1.30902501e-02f,
  -2.90639877e-01f, 1.72679365e-01f, 1.53143713e-02f, -2.03161135e-01f, -1.79867342e-01f, -1.47083029e-01f, -1.93930313e-01f, -1.83192790e-02f, -7.91155323e-02f, -2.99358312e-02f,
  -1.86434925e-01f, -3.74293104e-02f, -8.01302493e-02f, -1.61905006e-01f, -1.20559581e-01f, -1.32930763e-02f, -1.13052808e-01f, -1.37536731e-02f, -2.69764606e-02f, -9.24695805e-02f,
  3.47422715e-03f, -1.02838881e-01f, 1.24500461e-01f, 3.81207876e-02f, -8.82609412e-02f, -2.46329084e-02f, -1.39681488e-01f, -9.30141564e-03f, 1.35190096e-02f, -2.82372665e-02f,
  -1.02035083e-01f, 4.37964574e-02f, -8.36016536e-02f, -1.08226715e-02f, 1.00935631e-01f, 9.52573866e-02f, -2.58153360e-02f, -3.95958032e-03f, -5.38891144e-02f, -1.00490719e-01f,
  1.56598970e-01f, 7.28064328e-02f, -8.85296613e-03f, 3.82833299e-03f, -2.19527900e-01f, -1.27443140e-02f, -2.01707967e-02f, -1.49585545e-01f, -1.05044372e-01f, 8.10146108e-02f,
  -3.96801485e-03f, -1.04267105e-01f, -8.79388377e-02f, -2.01648936e-01f, -2.99945384e-01f, -3.02021116e-01f, -1.29907399e-01f, -1.96017444e-01f, -1.72514588e-01f, -2.65600324e-01f,
  2.18611091e-01f, -1.86795235e-01f, -6.57229364e-01f, -2.86907315e-01f, -2.81797081e-01f, -5.58436550e-02f, -3.76540422e-02f, 2.46617019e-01f, 9.32188611e-03f, -4.55733836e-02f,
  3.85774858e-02f, 1.69436261e-01f, -1.11106955e-01f, -7.70453513e-02f, 1.92335173e-01f, -1.33728638e-01f, -2.61156470e-01f, -1.22533686e-01f, 1.43199349e-02f, 1.96336105e-01f,
  9.98665858e-03f, -9.72790048e-02f, -2.24160198e-02f, 3.41216400e-02f, -2.38101274e-01f, -1.88086361e-01f, -4.85553473e-01f, -2.79075027e-01f, -3.14550906e-01f, -5.46266496e-01f,
  -3.43310148e-01f, -6.34090826e-02f, 2.11086255e-02f, 7.13487118e-02f, -1.47055134e-01f, -3.26263462e-03f, 7.31742680e-02f, -1.17816336e-01f, -1.81937944e-02f, -1.15510263e-01f,
  -2.11722136e-01f, 8.57787356e-02f, -2.73585487e-02f, -5.86870406e-03f, -1.45373270e-01f, 7.92206600e-02f, -1.52062044e-01f, -1.81543604e-02f, -4.50445674e-02f, 7.19156563e-02f,
  7.41376057e-02f, 7.53455758e-02f, -1.36481389e-01f, -7.87662491e-02f, -2.73139821e-03f, -5.88149615e-02f, -1.28750488e-01f, -3.06247007e-02f, 3.49450670e-02f, -2.50954181e-01f,
  2.10628182e-01f, 3.11554763e-02f, -1.05024569e-01f, -4.70033586e-02f, 1.27193332e-01f, 1.67566966e-02f, 5.26931733e-02f, 5.16310669e-02f, -1.32791493e-02f, 6.09043380e-03f,
  -1.28145088e-02f, -7.58626964e-04f, 5.75864092e-02f, 7.07718953e-02f, -6.55438602e-02f, 1.72840402e-01f, 2.08117872e-01f, 3.94245870e-02f, -5.93543388e-02f, -9.31350663e-02f,
  2.91813463e-02f, 1.14982836e-02f, 1.89954601e-02f, 1.51331559e-01f, 2.60661170e-02f, -8.84597600e-02f, 1.35909310e-02f, 1.77139044e-01f, 4.75369431e-02f, 2.07396433e-01f,
  2.07589939e-02f, 9.94771570e-02f, 9.54375714e-02f, 5.94176874e-02f, -2.76724342e-02f, -6.46093264e-02f, -9.63739678e-02f, 2.10438371e-02f, -1.59311622e-01f, 1.09600052e-02f,
  -2.74123065e-02f, 5.66517785e-02f, 2.08856259e-02f, -1.14764310e-02f, 9.63301733e-02f, 3.37528735e-02f, 1.11138836e-01f, -6.08796440e-02f, 1.19413204e-01f, 1.15152620e-01f,
  6.44354075e-02f, 2.19336376e-01f, 1.22178845e-01f, 4.04103771e-02f, 1.24377973e-01f, -1.67920552e-02f, -5.77836707e-02f, 7.24700093e-02f, 1.38265982e-01f, 1.09252632e-01f,
  -6.01243913e-01f, 6.73758164e-02f, 1.57823026e-01f, -3.08336914e-01f, -4.21864748e-01f, -3.72280806e-01f, -2.38107175e-01f, -2.59315223e-01f, -2.25794718e-01f, 5.83482459e-02f,
  2.74776310e-01f, 2.63121814e-01f, 3.30545127e-01f, 1.88657314e-01f, 7.88535848e-02f, 9.07726884e-02f, -1.32556394e-01f, -1.91036910e-01f, -2.66148478e-01f, -1.88189939e-01f,
  -2.39009112e-01f, -4.54255253e-01f, -4.57483381e-01f, -1.85408399e-01f, -1.42784789e-01f, 4.19339314e-02f, 4.62247245e-02f, -2.97519684e-01f, -7.69528747e-02f, -3.43234614e-02f,
  2.90761322e-01f, -2.16439128e-01f, -1.96827441e-01f, -1.20215811e-01f, 2.37832945e-02f, 2.61059832e-02f, -4.24389392e-02f, -9.40928161e-02f, -9.35142711e-02f, 3.51155214e-02f,
  -9.97449234e-02f, -9.65460762e-02f, -4.00476195e-02f, 8.89749546e-03f, -1.18807837e-01f, -4.25197035e-02f, 3.45954373e-02f, 4.68558595e-02f, 5.27158342e-02f, 1.78771451e-01f,
  2.46141255e-01f, 3.27784382e-02f, 1.51836067e-01f, 1.18200280e-01f, -4.49970774e-02f, -5.15134260e-02f, 4.40381691e-02f, -4.91474830e-02f, 3.75570692e-02f, 3.48090976e-02f,
  -2.77137142e-02f, 2.26788580e-01f, 1.01987300e-02f, -8.83757994e-02f, 8.92292261e-02f, 1.04515329e-01f, 3.78374085e-02f, -1.44624636e-02f, -1.13326438e-01f, 1.38909137e-02f,
  -5.40488586e-03f, 1.15024790e-01f, -3.98165584e-02f, 3.48743945e-02f, 6.60437122e-02f, -1.11801326e-01f, 1.61826238e-02f, 1.54241085e-01f, 3.06723341e-02f, -4.07193564e-02f,
  -4.25113440e-02f, 2.88622342e-02f, -1.06142402e-01f, 4.41214256e-03f, -4.20328714e-02f, 2.33668368e-02f, 1.11817960e-02f, 5.05147539e-02f, 3.79496778e-04f, -9.17006633e-04f,
  2.15907544e-01f, 2.66950130e-02f, -1.29183913e-02f, 7.32857443e-04f, -6.77368119e-02f, 4.95085455e-02f, 5.20309955e-02f, 2.21890155e-02f, -1.18157692e-01f, 1.19454670e-03f,
  5.99910654e-02f, 4.73773479e-02f, -1.60458125e-02f, 3.08988150e-02f, -4.20301482e-02f, -7.03973845e-02f, 2.07402371e-02f, 5.47708012e-02f, 1.21022359e-01f, 1.66819826e-01f,
  1.70044806e-02f, 5.44217899e-02f, 4.67642546e-02f, 1.39552251e-01f, 6.70109168e-02f, 1.36366755e-01f, 1.57785490e-01f, 1.14041664e-01f, 6.65161982e-02f, 9.40342844e-02f,
  -4.40966010e-01f, -4.10718769e-02f, -1.42486453e-01f, -9.99367684e-02f, -1.00669833e-02f, -2.60941923e-01f, -2.67992973e-01f, -1.91169634e-01f, 9.31877941e-02f, 1.16533086e-01f,
  1.67310774e-01f, 1.81254059e-01f, 3.35574560e-02f, -1.22393556e-01f, -4.73658502e-01f, -8.99412706e-02f, -1.15299262e-01f, -3.65136772e-01f, -3.41834754e-01f, -9.59404707e-02f,
  1.42629519e-01f, 4.27941680e-02f, -1.08946241e-01f, -5.14731966e-02f, 3.14931989e-01f, 1.29807219e-01f, 1.75593629e-01f, -1.07178669e-02f, 3.26364636e-02f, 1.39889419e-01f,
  7.29098991e-02f, -1.71013668e-01f, 1.85239632e-02f, 2.74698697e-02f, 1.71803802e-01f, -1.90865237e-03f, -3.52573246e-02f, -1.10673793e-01f, 5.63312396e-02f, 3.96592915e-03f,
  1.04437627e-01f, 5.88959381e-02f, 6.96472898e-02f, 1.31420091e-01f, 2.74261329e-02f, -1.80637464e-01f, 5.78464828e-02f, -1.18271992e-01f, -8.63137543e-02f, 1.54712617e-01f,
  1.37496278e-01f, -1.04562208e-01f, -9.44177583e-02f, -8.99775624e-02f, -4.55637127e-02f, -8.55626166e-03f, 1.20056244e-02f, -7.72851147e-03f, -1.65911257e-01f, 4.30949107e-02f,
  6.00632988e-02f, 1.14506982e-01f, 1.05323389e-01f, 1.03121849e-04f, 3.06192636e-02f, 1.43792585e-01f, 2.21920479e-03f, -1.31276444e-01f, -2.24997029e-02f, -1.74011849e-02f,
  7.82903470e-03f, 1.69311110e-02f, -7.23765567e-02f, -1.07798748e-01f, -8.45915750e-02f, -6.62286431e-02f, -2.23419204e-01f, -2.37206277e-02f, -2.01606192e-03f, -2.05662873e-04f,
  -1.08689591e-01f, 1.43583864e-01f, 1.41794384e-01f, -6.58507049e-02f, -5.91818877e-02f, -1.67576537e-01f, -7.93492123e-02f, -1.74576178e-01f, -5.31694815e-02f, -1.08743288e-01f,
  1.32951289e-01f, -8.57736990e-02f, -4.97037061e-02f, -5.39989211e-02f, -5.96077070e-02f, 1.69015467e-01f, -7.37125054e-02f, -1.75575167e-01f, -1.27538085e-01f, -1.93366334e-01f,
  -1.29904598e-01f, -1.62563726e-01f, 6.06955104e-02f, 5.96716143e-02f, -1.11810286e-02f, 7.34669948e-03f, -2.27207784e-03f, -3.69842015e-02f, -2.75134653e-01f, 5.59093729e-02f,
  -1.77291021e-01f, -4.06740069e-01f, -1.54127896e-01f, -8.49136785e-02f, -5.77030331e-02f, -9.22538936e-02f, -3.32021043e-02f, 1.38568366e-02f, -2.17229381e-01f, -2.88105961e-02f,
  5.33298135e-01f, 2.35521704e-01f, -6.34396732e-01f, 4.00276154e-01f, -6.38853163e-02f, -2.48774901e-01f, 6.00833483e-02f, 1.29482239e-01f, 3.35484535e-01f, 1.69613779e-01f,
  -7.67644169e-03f, -5.26990369e-03f, 3.40148807e-02f, -2.01256678e-01f, -2.14634180e-01f, -2.18780130e-01f, -2.11561218e-01f, -3.16376001e-01f, -4.38496262e-01f, -1.71363741e-01f,
  -5.34328260e-02f, 1.12954289e-01f, 9.93437394e-02f, -1.45752624e-01f, 3.93959321e-02f, -2.26074040e-01f, -1.82535216e-01f, -1.68527752e-01f, -4.11328435e-01f, -2.50042349e-01f,
  -4.01149929e-01f, -7.25200176e-02f, -3.79935540e-02f, 1.01721443e-01f, 6.66993931e-02f, 1.86364427e-01f, -5.48251905e-02f, 6.55722320e-02f, 2.64610827e-01f, 2.02147916e-01f,
  6.67498931e-02f, -1.62353311e-02f, -2.48494372e-02f, 1.62839983e-02f, 1.26973674e-01f, -1.58948614e-03f, 2.09625795e-01f, 4.48561609e-02f, -4.81235385e-02f, -1.53989820e-02f,
  1.11027487e-01f, 1.54328868e-02f, -1.50510706e-02f, 3.92903388e-02f, -9.47661623e-02f, -1.23563781e-01f, -5.44108264e-02f, -9.01977271e-02f, -2.05567986e-01f, 2.86161900e-01f,
  -1.17876299e-01f, 6.30031899e-02f, -1.13922134e-01f, 3.31526175e-02f, 1.08526006e-01f, 1.15299009e-01f, 3.64150070e-02f, 5.60857803e-02f, 2.48006266e-02f, 1.47688538e-01f,
  1.28647849e-01f, 2.14390550e-02f, 2.55276449e-02f, 1.02617912e-01f, -1.52975604e-01f, 5.14879748e-02f, -7.52938241e-02f, 2.96158576e-03f, -9.31190923e-02f, 1.11972272e-01f,
  -1.19404607e-02f, -3.58100608e-02f, -1.07839733e-01f, -7.13704228e-02f, -9.52149779e-02f, 7.79354423e-02f, -1.13974720e-01f, -2.32097190e-02f, -6.19899705e-02f, -1.65319536e-02f,
  2.89790809e-01f, -2.87975550e-01f, 9.32081193e-02f, -2.56692376e-02f, -2.55573727e-02f, 1.11088008e-02f, 1.26602799e-02f, 2.45227776e-02f, -1.46623654e-03f, -3.78951654e-02f,
  -1.77628279e-01f, -6.50690356e-03f, 2.36389656e-02f, 1.23427019e-01f, 3.40007022e-02f, -2.86509786e-02f, 1.19872771e-01f, 8.80853459e-03f, -6.18590750e-02f, -4.05836618e-03f,
  8.34081545e-02f, 1.16153128e-01f, 1.74583063e-01f, 1.05696052e-01f, -2.34494768e-02f, -1.16847269e-01f, -2.32976140e-03f, -7.79368505e-02f, -2.08155945e-01f, 2.58454889e-01f,
  -3.86598468e-01f, 1.06729567e-01f, -2.18455136e-01f, 2.19485298e-01f, 3.18802416e-01f, 1.16443962e-01f, -2.19781920e-02f, 1.02270590e-02f, 3.10265422e-02f, 1.33718386e-01f,
  2.18652003e-03f, 1.03131518e-01f, 1.28746316e-01f, 1.49655372e-01f, 2.32779700e-02f, 1.65134192e-01f, 2.98008382e-01f, 5.09899929e-02f, -7.86306038e-02f, 1.07731409e-02f,
  2.55009562e-01f, 4.70040850e-02f, -2.75106609e-01f, -4.46240194e-02f, 3.24712902e-01f, 1.56381145e-01f, 1.27228838e-03f, 4.11435440e-02f, 8.38923007e-02f, 3.95404100e-01f,
  -4.18431133e-01f, -2.79550523e-01f, -7.60667622e-02f, 6.65763095e-02f, -1.07069999e-01f, -1.63456514e-01f, -1.09479345e-01f, -4.87154126e-02f, -6.04798235e-02f, -1.87060937e-01f,
  -1.24108251e-02f, -9.01940763e-02f, 1.64522231e-01f, -1.53211623e-01f, -6.50081858e-02f, -2.57008612e-01f, -1.59698173e-01f, -2.43437722e-01f, -2.37296924e-01f, -1.36234879e-01f,
  4.31320965e-01f, 6.39192984e-02f, -2.06479192e-01f, -1.48966804e-01f, -2.31785089e-01f, -2.65123338e-01f, -2.34055921e-01f, -3.25814545e-01f, -4.76778090e-01f, -3.07254076e-01f,
  -2.81050317e-02f, -8.57397169e-02f, 3.10343765e-02f, 6.43291743e-04f, 9.07157362e-02f, 1.37517080e-01f, 1.58483669e-01f, 1.68943942e-01f, 1.49101406e-01f, 4.96024862e-02f,
  8.67734328e-02f, -6.72542900e-02f, -3.64904664e-02f, -3.23026516e-02f, 4.14637402e-02f, -1.30547760e-02f, 6.20952286e-02f, 5.40231308e-03f, -1.92468554e-01f, -3.72050591e-02f,
  1.33694202e-01f, 1.97635703e-02f, -1.91918328e-01f, 1.32092461e-01f, 8.44412297e-02f, 8.14310089e-03f, -6.24739043e-02f, -5.01639023e-03f, -5.59042916e-02f, -5.60588278e-02f,
  -2.71714866e-01f, -3.66419017e-01f, -3.59763876e-02f, 1.36068789e-02f, -1.91689640e-01f, -2.84825787e-02f, 5.26414625e-02f, -1.06181189e-01f, 7.91929364e-02f, -2.54092872e-01f,
  -1.52719781e-01f, -1.34888425e-01f, -1.01175129e-01f, -1.22784466e-01f, -9.98292789e-02f, -7.05366209e-02f, 7.22891092e-02f, 2.88481470e-02f, -2.57948856e-03f, -7.31712431e-02f,
  1.03100717e-01f, -1.28642842e-01f, -1.58542886e-01f, -1.29908249e-01f, -5.69626391e-02f, -1.75450131e-01f, -1.59684509e-01f, -1.51328534e-01f, -3.94432962e-01f, -2.73440093e-01f,
  5.02529204e-01f, 7.19919950e-02f, -7.53126368e-02f, 3.52881908e-01f, -2.67091036e-01f, -3.28700840e-01f, -3.03028315e-01f, -2.45127864e-02f, 4.90958430e-02f, 2.08059236e-01f,
  -1.88556775e-01f, -3.97359639e-01f, -1.64770529e-01f, -2.20414400e-01f, -2.08461449e-01f, 1.77411556e-01f, 8.19710270e-02f, -8.97264853e-02f, -4.24706727e-01f, -3.31898957e-01f,
  -5.29500246e-02f, 1.87521771e-01f, 1.29004613e-01f, 3.64881754e-02f, 1.46644711e-01f, -1.02317341e-01f, 2.46418118e-01f, 4.75604683e-02f, -6.14858866e-02f, 3.15872997e-01f,
  -3.65714654e-02f, 1.26925871e-01f, -2.41544053e-01f, -4.05793972e-02f, -2.29282022e-01f, 1.03689156e-01f, -1.13863379e-01f, 7.50408322e-02f, -1.68137178e-01f, -8.55574310e-02f,
  -1.83512315e-01f, -1.55803025e-01f, -1.39232099e-01f, 3.26102898e-02f, 4.88113724e-02f, -5.13249263e-02f, 6.31178170e-02f, 2.44472232e-02f, -4.55017313e-02f, -2.78647523e-02f,
  -4.34933044e-02f, -1.18723020e-01f, -1.58700466e-01f, -1.59405813e-01f, -3.65765877e-02f, -1.03025049e-01f, -2.70536304e-01f, -1.91203728e-01f, -2.38104627e-01f, 2.23918542e-01f,
  -4.91610356e-02f, -1.36343047e-01f, 4.58087660e-02f, -8.15548096e-03f, 6.19512126e-02f, -1.64356618e-03f, 4.93687242e-02f, -6.17720820e-02f, -8.26499164e-02f, -4.43825647e-02f,
  -4.98911403e-02f, -2.16412917e-02f, -6.66950196e-02f, 4.82518151e-02f, 3.81068066e-02f, -9.49050561e-02f, 2.31773010e-03f, 6.84890896e-02f, 5.45096323e-02f, 2.42907573e-02f,
  2.79460754e-02f, -7.25646913e-02f, 8.98124650e-02f, -7.33307973e-02f, -1.88562125e-02f, 5.53100035e-02f, -1.83775891e-02f, 1.15834607e-03f, -5.15106227e-03f, 7.28721358e-03f,
  1.32227942e-01f, -2.86275178e-01f, 1.62211120e-01f, -5.75672761e-02f, -3.01281214e-02f, -1.50609883e-02f, 1.03910537e-02f, 4.48361523e-02f, -4.75842331e-04f, -5.87789454e-02f,
  -2.13153854e-01f, 3.24029550e-02f, 1.08553961e-01f, -5.58045506e-02f, -5.45097962e-02f, 1.75784226e-03f, 1.10403396e-01f, -1.33903280e-01f, -1.24199897e-01f, -1.83879153e-03f,
  1.45754889e-01f, -1.02542322e-02f, 6.13774471e-02f, -2.64530499e-02f, -3.07556037e-02f, -7.18808770e-02f, -5.64844199e-02f, -6.31507263e-02f, -1.53621808e-01f, 2.47374192e-01f,
  5.90777040e-01f, -5.77381514e-02f, -2.11780265e-01f, 1.07349060e-01f, -3.47538382e-01f, -3.72615248e-01f, -1.85219869e-01f, 3.42815854e-02f, 4.36701216e-02f, 5.51280491e-02f,
  -3.33728909e-01f, -2.47254714e-01f, -2.27526382e-01f, -2.11895764e-01f, 2.30488673e-01f, 1.55271217e-01f, 2.64308542e-01f, 2.26550698e-01f, -6.66199848e-02f, -8.58154073e-02f,
  4.54548709e-02f, 3.45739096e-01f, 4.02002484e-01f, 5.64420857e-02f, -5.51613122e-02f, -5.09040132e-02f, -4.84063290e-02f, -1.06772393e-01f, -1.80301800e-01f, 4.27704640e-02f,
  -1.55620143e-01f, -7.14435428e-02f, -6.77537173e-02f, 3.53046763e-03f, -8.02518725e-02f, 2.62102485e-02f, 2.36547273e-02f, -1.89287104e-02f, -1.94143280e-01f, 2.93666584e-04f,
  -1.97436750e-01f, -1.51391357e-01f, -2.47568920e-01f, -6.91712797e-02f, -1.61628053e-01f, -3.77529673e-02f, 2.23824248e-01f, 1.91424355e-01f, 8.10239241e-02f, -3.03291082e-02f,
  -1.63905755e-01f, -8.33192021e-02f, -3.99130695e-02f, 2.39576269e-02f, -1.75576642e-01f, -9.94050130e-02f, -9.76876915e-02f, -2.02174991e-01f, -5.62022142e-02f, 2.64002472e-01f,
  -6.78849146e-02f, 8.93720090e-02f, -4.49319109e-02f, 3.15881073e-02f, -3.46595771e-04f, -1.43612474e-01f, -8.27094167e-02f, 1.27522886e-01f, -2.48053297e-02f, -7.86158964e-02f,
  -7.68361762e-02f, 6.53436929e-02f, -4.37968895e-02f, 4.90256697e-02f, 2.73511261e-02f, -1.33804947e-01f, -6.71395939e-03f, 1.05225295e-01f, -6.11774884e-02f, 5.22318967e-02f,
  -9.17102993e-02f, -5.14964163e-02f, -1.25342637e-01f, 3.90655883e-02f, 5.49109792e-03f, 1.44159552e-02f, -7.01009780e-02f, -1.29381120e-02f, 5.71452975e-02f, -5.34894003e-04f,
  1.62607387e-01f, -8.91105905e-02f, 8.90923738e-02f, 4.96591814e-02f, -6.94931895e-02f, 3.26206312e-02f, -4.56368178e-02f, 1.25751030e-02f, -7.69388974e-02f, 6.68255892e-03f,
  -3.82732414e-02f, -7.87866041e-02f, -3.42801660e-02f, 1.12537583e-02f, 9.08939727e-03f, -6.29258230e-02f, -4.15657833e-03f, -3.54049169e-02f, 4.99463864e-02f, 8.03323463e-02f,
  1.87100857e-01f, 1.70326620e-01f, 2.02043653e-01f, -1.07872905e-03f, -5.63170388e-02f, 3.89568284e-02f, 1.21447265e-01f, -3.69496010e-02f, -3.90837900e-02f, 3.85569483e-01f,
  2.67853707e-01f, 2.21509263e-01f, -5.44732749e-01f, 1.99718699e-01f, -2.59402990e-01f, -2.13964596e-01f, 8.92593488e-02f, 9.00408104e-02f, 2.39422530e-01f, 2.47030750e-01f,
  -6.95593059e-02f, -2.03678012e-01f, -7.62086436e-02f, -1.87524781e-01f, -2.13876769e-01f, 1.23190414e-02f, -1.80708021e-01f, -3.91376674e-01f, -4.97222483e-01f, -2.46676639e-01f,
  -8.27854499e-03f, -7.56028891e-02f, -4.71065342e-02f, -1.12619005e-01f, 7.90710971e-02f, -1.91469062e-02f, 7.90821537e-02f, 4.56271246e-02f, -2.04021707e-01f, 3.37549187e-02f,
  -3.74135464e-01f, 4.46115956e-02f, -3.45888436e-01f, -8.20831656e-02f, -7.62254670e-02f, -2.02427506e-01f, -6.68072924e-02f, 1.44391693e-02f, 7.20577389e-02f, -1.56425193e-01f,
  -9.01542231e-02f, -2.09634259e-01f, -1.22457109e-01f, -1.20716691e-01f, -1.79772690e-01f, -2.09755138e-01f, -1.89105831e-02f, -2.99321473e-01f, -2.18575448e-01f, -1.13821469e-01f,
  -1.16992652e-01f, -2.45055646e-01f, -3.05249810e-01f, -6.30093142e-02f, -1.55935571e-01f, -2.52261907e-01f, -1.44378558e-01f, -2.23351978e-02f, -1.79557443e-01f, 2.29528099e-01f,
  2.02228412e-01f, 1.63281605e-01f, -6.11037612e-02f, 4.19880189e-02f, 2.21805617e-01f, 2.53445446e-03f, 9.21852067e-02f, 8.96027014e-02f, 2.83855945e-02f, -9.31412168e-03f,
  -4.51149829e-02f, 9.48119536e-02f, 1.92887615e-02f, -4.99456897e-02f, -3.48736569e-02f, 6.30836785e-02f, -9.91211459e-03f, 2.84785014e-02f, -1.23719200e-01f, 7.41951074e-03f,
  -1.59246668e-01f, -1.52212176e-02f, 1.44999577e-02f, 5.70489354e-02f, -7.61354491e-02f, 3.39504564e-03f, 3.71309742e-02f, -8.24999511e-02f, 1.07996361e-02f, -5.13385460e-02f,
  1.01006784e-01f, -5.17788790e-02f, 5.26848920e-02f, -4.67241667e-02f, -9.74746123e-02f, -1.94479659e-01f, 4.84436415e-02f, 5.32910675e-02f, 9.40100029e-02f, -4.41465639e-02f,
  -1.76412016e-01f, 5.12023196e-02f, 2.15906110e-02f, -1.09249726e-02f, -2.03662053e-01f, -6.50052577e-02f, 1.52992576e-01f, -8.91285092e-02f, -1.22941263e-01f, 1.27782598e-01f,
  1.35021731e-01f, 9.02988985e-02f, 3.23171616e-02f, 7.42176399e-02f, 2.11362043e-04f, 2.93904860e-02f, -2.90981177e-02f, 1.63971841e-01f, -4.85893190e-02f, 4.25698280e-01f,
  2.80617237e-01f, -5.46197221e-02f, 3.60863283e-02f, 7.85958916e-02f, -2.11512268e-01f, -3.64060521e-01f, -3.12934786e-01f, -2.75480300e-01f, -7.24774599e-02f, -1.41025797e-01f,
  -2.38142386e-01f, -1.73500314e-01f, -1.25038158e-02f, 5.39195798e-02f, 1.49544939e-01f, 1.66593730e-01f, 1.90411717e-01f, 2.11796254e-01f, 2.09579006e-01f, 6.31706119e-02f,
  -6.54182490e-03f, 2.40692034e-01f, 3.10158104e-01f, 2.50729591e-01f, 1.42937288e-01f, 1.44612864e-02f, 2.85679214e-02f, -2.74980478e-02f, 5.33830225e-02f, 3.48084509e-01f,
  -7.97536876e-03f, -6.80633411e-02f, 6.90300241e-02f, -1.25222737e-02f, -7.17262849e-02f, 1.55830249e-01f, 4.86988761e-02f, 4.27733921e-03f, -2.06109490e-02f, -7.02994019e-02f,
  -1.28117371e-02f, -4.35383879e-02f, 4.61039599e-03f, 4.82105687e-02f, 2.02759374e-02f, -1.26438826e-01f, 2.90082041e-02f, 2.12506056e-01f, 1.25427488e-02f, -1.58655681e-02f,
  -7.55927041e-02f, -1.43115148e-01f, -3.30645263e-01f, -1.13503344e-01f, -9.10523534e-02f, -3.83879393e-02f, -1.95276886e-01f, 2.04247292e-02f, -1.67772666e-01f, 1.47053869e-02f,
  -1.99531764e-01f, -5.31366654e-02f, -8.19909051e-02f, -1.36447951e-01f, -1.70125827e-01f, -3.81267555e-02f, -1.28252238e-01f, -5.73299900e-02f, -1.21363830e-02f, 2.37786197e-04f,
  -1.52130991e-01f, -2.23921370e-02f, -1.45726055e-01f, -1.08189834e-02f, -5.20457514e-02f, 1.61852557e-02f, -8.49383473e-02f, -1.23056628e-01f, -4.19816114e-02f, -9.29170325e-02f,
  2.03011222e-02f, -6.44406080e-02f, -1.34757683e-02f, -1.48606757e-02f, 4.77162823e-02f, -1.40276983e-01f, -7.49931205e-03f, -1.96690232e-01f, -9.43089426e-02f, 3.08654141e-02f,
  -2.42925033e-01f, -4.95077036e-02f, 2.36424685e-01f, 2.66097933e-01f, 1.46523073e-01f, 3.99224833e-02f, 6.85720965e-02f, 1.41072661e-01f, -6.75937012e-02f, 8.91841874e-02f,
  -6.93755550e-03f, 1.42683834e-01f, 7.40555003e-02f, 6.51794747e-02f, 4.06621769e-02f, -5.54971211e-03f, -5.24869971e-02f, 1.29785329e-01f, -2.93149315e-02f, -7.37970993e-02f,
  -6.36374131e-02f, -2.31510177e-02f, -1.58974335e-01f, -1.45668551e-01f, -1.23266406e-01f, -1.98640123e-01f, -1.31001770e-01f, -8.14552307e-02f, -1.23379797e-01f, -8.85708854e-02f,
  7.20157444e-01f, 7.37190023e-02f, -6.68419376e-02f, 1.19538426e-01f, -1.46612927e-01f, -2.13241220e-01f, -2.33019039e-01f, 4.72424552e-03f, 8.71577412e-02f, 1.30771413e-01f,
  1.18305333e-01f, 2.29991972e-01f, 2.08097085e-01f, 2.21229941e-02f, 1.82255313e-01f, 6.65049721e-03f, -1.73586413e-01f, 1.58119155e-03f, 1.52255803e-01f, 1.19847395e-01f,
  3.26486453e-02f, -2.66010370e-02f, 1.65825382e-01f, -5.68105467e-02f, -8.05625841e-02f, 7.86649063e-02f, -4.55026180e-02f, -8.35392177e-02f, -6.86911345e-02f, 4.81006838e-02f,
  -2.46764291e-02f, 1.59724683e-01f, 5.33292908e-03f, 1.37756661e-01f, -1.56538546e-01f, 3.07222847e-02f, -1.78529080e-02f, -1.57167673e-01f, -8.57594162e-02f, -1.41814321e-01f,
  -2.99937353e-02f, -1.82447899e-02f, -9.68224481e-02f, -9.18662846e-02f, -1.95613697e-01f, -1.60263360e-01f, 2.21804418e-02f, 4.26869839e-03f, 1.96167734e-02f, -7.92081188e-03f,
  -3.58209945e-03f, 3.76153830e-03f, -1.72106437e-02f, -5.70082814e-02f, -6.95907027e-02f, 1.06582165e-01f, -1.19962789e-01f, 3.41620110e-02f, -9.70599130e-02f, 4.00634557e-02f,
  1.80428237e-01f, 9.77009609e-02f, 9.38048214e-02f, 1.40191808e-01f, 1.68409750e-01f, 5.56647107e-02f, -7.28925765e-02f, 1.13086440e-02f, 4.66104075e-02f, -5.84419407e-02f,
  1.01456288e-02f, 7.99172595e-02f, -1.08033799e-01f, 7.15941712e-02f, 3.45764048e-02f, 5.18164448e-02f, -1.21655434e-01f, 5.31231686e-02f, -4.33901213e-02f, -2.73367036e-02f,
  8.47188160e-02f, -6.54591154e-03f, -4.09247587e-03f, 6.07391521e-02f, 2.31594313e-02f, -3.23575251e-02f, 1.16893994e-02f, 7.52115548e-02f, 1.99062135e-02f, 7.91143030e-02f,
  -2.79150426e-01f, 3.00940126e-02f, 1.22153483e-01f, 1.23928204e-01f, -1.61053032e-01f, -5.38437888e-02f, 8.39454879e-04f, -1.09131187e-01f, -2.20501244e-01f, -1.10810950e-01f,
  -6.83274791e-02f, -3.55150625e-02f, 4.62370226e-03f, -4.32629138e-02f, 1.76197328e-02f, -8.83367062e-02f, 3.47453356e-02f, -5.54156192e-02f, -4.46928628e-02f, -9.08562243e-02f,
  -8.65695812e-03f, 8.10465962e-02f, -2.49292795e-02f, 2.36603594e-03f, -7.61334673e-02f, 1.10306822e-01f, -3.06217186e-02f, -9.87031609e-02f, -8.95177126e-02f, -3.29051502e-02f,
  1.85828999e-01f, -3.30143750e-01f, 2.80914456e-01f, 1.28914416e-01f, 2.54264712e-01f, 1.56608477e-01f, 1.03870049e-01f, 1.30314484e-01f, 7.68345520e-02f, 1.08427048e-01f,
  -3.41133364e-02f, 8.78067836e-02f, 1.24914803e-01f, -4.10876870e-02f, 1.13598153e-01f, 2.05465052e-02f, 2.03592598e-01f, 3.02661777e-01f, 2.88529366e-01f, 1.32859677e-01f,
  -1.12396050e-02f, -2.51559038e-02f, 1.23576097e-01f, -4.84374277e-02f, 3.88419209e-03f, 1.69600695e-01f, -1.48794325e-02f, -4.35796147e-03f, -4.95171398e-02f, 4.33249697e-02f,
  1.80045232e-01f, -2.22068861e-01f, 1.04518719e-01f, -2.00860709e-01f, -1.24545775e-01f, -1.66996568e-02f, 2.47390848e-02f, -1.04481995e-01f, -2.76662707e-02f, 6.38056695e-02f,
  3.92270200e-02f, -3.46192308e-02f, -1.44967297e-02f, -5.11379614e-02f, 1.29340729e-02f, 5.47316018e-03f, -9.72715989e-02f, 1.31380456e-02f, -6.26306832e-02f, -8.19269195e-02f,
  -4.19458598e-02f, 1.09263539e-01f, 2.19662264e-01f, 5.09588458e-02f, 3.25513072e-02f, 6.87992200e-02f, -4.39171679e-02f, 5.11723980e-02f, 1.70229226e-02f, 2.10046838e-03f,
  1.99728444e-01f, 1.58693299e-01f, 1.70221791e-01f, 1.21538557e-01f, -5.55951381e-03f, 7.87852705e-02f, 3.92507724e-02f, 1.45172309e-02f, 1.92230567e-01f, 1.32194385e-01f,
  2.31535584e-01f, 2.19288513e-01f, 1.15893684e-01f, 2.95546781e-02f, 1.16285361e-01f, 9.85670909e-02f, 8.06560367e-02f, 3.69683746e-03f, -6.52176421e-03f, 6.98973760e-02f,
  9.71820876e-02f, 3.42493914e-02f, -1.54260591e-01f, -6.61477149e-02f, 2.07380764e-02f, 3.29083949e-02f, 9.40603614e-02f, 2.63994336e-02f, 1.40153477e-02f, -4.29114103e-02f,
  -1.12274084e-02f, 1.41186669e-01f, 9.07995328e-02f, -2.25027706e-02f, -9.18359980e-02f, -1.29171565e-01f, 1.83846012e-01f, -1.11161537e-01f, -2.02570021e-01f, -7.13761896e-02f,
  -7.18482435e-02f, 1.83281824e-02f, 1.31912623e-03f, 4.70499434e-02f, 1.07695952e-01f, 1.23891458e-02f, -1.81867391e-01f, 2.05964278e-02f, -1.22311689e-01f, -9.42635611e-02f,
  -1.33411318e-01f, 5.19008040e-02f, 2.74552435e-01f, 2.23679140e-01f, 4.85927537e-02f, 2.03127936e-01f, 7.05611855e-02f, 5.25196008e-02f, 9.46062356e-02f, 8.21605101e-02f,
  -4.24333662e-01f, -4.77312952e-02f, 7.32893869e-02f, -3.39007676e-01f, -1.04482718e-01f, 1.19643770e-01f, -8.76234397e-02f, -1.72766104e-01f, -1.93527758e-01f, 1.90785695e-02f,
  -2.22048592e-02f, -1.82617277e-01f, -2.20407262e-01f, -2.43343115e-01f, -2.49080941e-01f, -1.39313027e-01f, -1.55065879e-01f, -1.66776493e-01f, -1.80728272e-01f, -6.48740381e-02f,
  -2.22243294e-01f, -3.65642458e-01f, -2.38768592e-01f, -2.58966953e-01f, -1.73236385e-01f, -2.82255590e-01f, -2.29875579e-01f, -2.66333252e-01f, -1.04437239e-01f, -2.51071036e-01f,
  -1.47862419e-01f, 4.07666638e-02f, -4.93238308e-02f, 1.22676373e-01f, 8.34061280e-02f, 1.85870789e-02f, -2.87046153e-02f, -7.31095076e-02f, 1.40580222e-01f, -2.61592735e-02f,
  9.12059471e-02f, 1.79625768e-02f, 2.10140385e-02f, 4.95694913e-02f, 8.96961018e-02f, 1.41023397e-01f, 2.93094456e-01f, 1.12785205e-01f, 1.22790098e-01f, 1.82391927e-01f,
  2.21096367e-01f, 2.13665798e-01f, 1.14553690e-01f, 2.23526627e-01f, 2.37945274e-01f, 1.65543288e-01f, 1.00649908e-01f, 2.70771772e-01f, 2.52752960e-01f, 1.73198178e-01f,
  1.27132937e-01f, -3.69741768e-02f, 8.45456943e-02f, 1.69079959e-01f, 1.37014210e-01f, 4.05699685e-02f, -8.71354789e-02f, -8.68286416e-02f, -1.36638433e-01f, -3.56550626e-02f,
  1.68669708e-02f, 4.17647213e-02f, 1.15757458e-01f, -1.31816447e-01f, -8.04819092e-02f, 2.20631137e-02f, -3.73721756e-02f, 1.30101303e-02f, -3.75257619e-03f, -5.81473438e-03f,
  6.18438178e-04f, -1.88498478e-02f, -2.75212433e-02f, 1.48574755e-01f, 1.97797254e-01f, 5.85453659e-02f, 9.42956805e-02f, 1.58426642e-01f, 6.86283112e-02f, -1.88515652e-02f,
  -1.54781297e-01f, 2.25358270e-02f, -1.73523366e-01f, -1.53643742e-01f, -6.84021115e-02f, 1.33500714e-03f, -1.19265117e-01f, 1.53549025e-02f, -9.94792134e-02f, 6.77144229e-02f,
  5.55433966e-02f, -1.05777644e-01f, 3.54068354e-02f, -8.55156500e-03f, -1.29318357e-01f, 4.38662022e-02f, 1.75355837e-01f, -3.43851745e-02f, 1.38521940e-01f, 1.46307305e-01f,
  1.63722888e-01f, 1.14328647e-02f, -8.12579170e-02f, 1.13154806e-01f, -2.37783361e-02f, -1.64575711e-01f, -1.22539170e-01f, -5.41466568e-03f, -2.18235116e-04f, -1.20799407e-01f,
  -7.90453851e-02f, -3.18919450e-01f, -7.20446482e-02f, -2.08033159e-01f, -1.70990974e-01f, -1.96395785e-01f, -3.15588742e-01f, -6.22596815e-02f, 8.30845311e-02f, -3.56593072e-01f,
  -1.85815245e-01f, 1.32098794e-01f, -7.71534815e-02f, 1.28385946e-01f, 3.31939086e-02f, -4.41710055e-01f, -3.24680805e-01f, 1.05032638e-01f, 3.26645583e-01f, 6.74911514e-02f,
  -9.45133269e-02f, -9.89471450e-02f, 6.87901005e-02f, 1.72869608e-01f, -2.73722470e-01f, -9.98055190e-02f, -1.71777248e-01f, -1.79104269e-01f, -1.69467166e-01f, -4.28067803e-01f,
  -2.16172531e-01f, 7.31138960e-02f, 2.82581747e-01f, 9.51863006e-02f, -1.45573959e-01f, 7.67344981e-03f, 4.09392007e-02f, 2.26916876e-02f, 6.99814409e-02f, -7.67097995e-02f,
  -6.99233264e-02f, 1.98125288e-01f, 1.61697604e-02f, 5.66924550e-02f, -1.01054855e-01f, 6.66931123e-02f, 2.88982522e-02f, 1.62523072e-02f, -7.59990364e-02f, -9.72901955e-02f,
  -3.01869839e-01f, -1.35205701e-01f, -8.21383595e-02f, 1.43518569e-02f, 1.64250433e-01f, 4.95558418e-02f, 7.39446878e-02f, 1.78145140e-01f, 2.11320296e-02f, -3.59682888e-01f,
  -1.32820204e-01f, 8.81876238e-03f, 6.06410066e-03f, 9.61310565e-02f, -9.97716486e-02f, 3.29707749e-02f, -4.16985378e-02f, -1.00552231e-01f, 1.07311048e-01f, -2.99013080e-03f,
  4.95231859e-02f, 1.84414536e-02f, 4.26993258e-02f, -3.73057760e-02f, -1.00052036e-01f, 2.42638774e-02f, -1.20344087e-01f, -6.35958910e-02f, 6.86694831e-02f, -7.13484287e-02f,
  5.10275289e-02f, 5.02310693e-02f, -1.11853443e-02f, 4.13840869e-03f, 1.07789310e-02f, -1.29815161e-01f, 6.27107322e-02f, -2.69008707e-02f, -4.95755747e-02f, 7.41958618e-02f,
  -1.59148529e-01f, 2.21704051e-01f, -2.04900384e-01f, -1.72668137e-02f, -1.37254968e-01f, -6.80643395e-02f, -3.40177715e-02f, 1.10439822e-01f, 6.41600564e-02f, -2.27161888e-02f,
  -3.95624153e-02f, -1.85965188e-02f, -6.35078177e-02f, -2.58502234e-02f, 3.64155583e-02f, 5.15999161e-02f, -1.60228387e-01f, -3.41469720e-02f, -5.03710471e-02f, -8.47034715e-03f,
  -2.09622338e-01f, -1.71155065e-01f, -1.75597593e-01f, -1.43882111e-02f, -2.06554346e-02f, 7.65207829e-03f, -7.29239285e-02f, -6.70223832e-02f, -8.12525228e-02f, -4.55997020e-01f,
  -6.31184399e-01f, 3.25597495e-01f, 5.56710720e-01f, -4.59256202e-01f, 8.49775001e-02f, 2.99221873e-01f, 3.19707841e-01f, -2.02215403e-01f, -2.90889889e-01f, 2.42354516e-02f,
  2.86695249e-02f, -2.84028918e-01f, -1.49756670e-01f, -8.67842287e-02f, 9.15000662e-02f, 3.02761942e-01f, 2.69477725e-01f, 2.42782623e-01f, 4.65389118e-02f, 1.85888018e-02f,
  8.89029950e-02f, -1.58786312e-01f, -5.55741116e-02f, -6.35396615e-02f, -3.00933629e-01f, -1.88558593e-01f, 1.15809329e-01f, -1.79944020e-02f, 1.92534789e-01f, -1.48409024e-01f,
  -2.03348234e-01f, -1.57576531e-01f, -3.24107856e-02f, -1.63306016e-02f, 1.95203438e-01f, -9.12914202e-02f, -8.07227120e-02f, -8.32642540e-02f, -4.29355502e-02f, -1.17727421e-01f,
  -9.26271155e-02f, -4.95728143e-02f, -6.69788569e-02f, -8.66547897e-02f, -1.43630818e-01f, -1.62559636e-02f, 1.18253538e-02f, -9.97528806e-03f, -3.69524434e-02f, 6.61161169e-02f,
  2.31589019e-01f, -6.68931752e-03f, -1.03239072e-02f, 3.40815037e-02f, -1.77868176e-02f, -3.70672569e-02f, 1.39147431e-01f, -1.24570645e-01f, 3.67360786e-02f, -4.28463548e-01f,
  -1.66256528e-03f, -8.77661223e-04f, 9.53844935e-02f, -8.15072432e-02f, -1.88201934e-01f, 3.38767879e-02f, 2.89764255e-02f, 7.87275508e-02f, 2.46037059e-02f, -9.67422575e-02f,
  -1.96648426e-02f, 9.45805684e-02f, -6.51338249e-02f, -1.00892805e-01f, -1.35184207e-03f, -1.00200303e-01f, 1.26499027e-01f, 1.32061154e-01f, 8.17603320e-02f, 5.37088215e-02f,
  1.55976694e-03f, 4.99923714e-03f, -6.05488792e-02f, -9.06465128e-02f, 2.18810260e-01f, 7.30586750e-03f, 2.61062440e-02f, 1.00875953e-02f, -5.77315129e-02f, 1.59646454e-03f,
  -3.52769792e-01f, 4.76858854e-01f, -3.48395199e-01f, -1.17617496e-03f, -2.00496800e-02f, 1.16588570e-01f, 1.48990629e-02f, 2.55902797e-01f, 2.76612658e-02f, -2.27633566e-01f,
  1.01396576e-01f, -1.01776667e-01f, -2.19410602e-02f, 3.16311866e-02f, -1.31373033e-01f, -5.36207855e-02f, 1.35247156e-01f, 8.85789916e-02f, 1.14134364e-01f, -1.27866277e-02f,
  2.41882265e-01f, -1.26944646e-01f, -1.72523081e-01f, -1.46606430e-01f, -1.79899469e-01f, -1.74516425e-01f, -1.46670997e-01f, -1.11600377e-01f, -2.65619048e-04f, -3.34947675e-01f,
  8.84895846e-02f, -3.89529824e-01f, -1.75014466e-01f, -2.15548560e-01f, -3.03159088e-01f, -1.33107230e-01f, -2.87932783e-01f, -2.83119362e-02f, -5.34281023e-02f, -3.64890367e-01f,
  -2.22943440e-01f, 1.09555565e-01f, 1.15977943e-01f, 1.60218433e-01f, 2.57048368e-01f, -2.81546026e-01f, -2.46795714e-01f, 2.21027926e-01f, 3.43531132e-01f, -5.63083449e-03f,
  -1.30747333e-01f, -7.18359947e-02f, 2.45036840e-01f, 2.49541216e-02f, -3.49742681e-01f, -9.04758051e-02f, -3.43850017e-01f, -2.18662992e-01f, -9.00533497e-02f, -3.85007024e-01f,
  -2.15052962e-01f, -7.37163946e-02f, 1.47775918e-01f, 1.48966089e-01f, -2.94450242e-02f, 1.05806790e-01f, 2.34835222e-02f, 2.88666245e-02f, 1.18938893e-01f, -9.94024128e-02f,
  -1.01870358e-01f, 5.23734204e-02f, 9.42639112e-02f, 6.25920519e-02f, -1.08217485e-01f, -7.95865729e-02f, -2.06537545e-02f, 1.22170016e-01f, 1.27122834e-01f, -2.16165394e-01f,
  -2.22873762e-01f, -1.61083162e-01f, 1.18763447e-02f, -5.80424955e-03f, 4.71996963e-02f, 9.40773338e-02f, -1.49684191e-01f, 8.52323510e-03f, 1.08926155e-01f, -2.66132474e-01f,
  -1.29026487e-01f, -2.76240124e-03f, -7.53241256e-02f, -6.88758865e-02f, 1.13820918e-02f, -8.96821991e-02f, -2.40450632e-02f, -8.11212137e-03f, -4.12462540e-02f, -2.20928481e-03f,
  7.26507977e-02f, 7.28680659e-03f, 8.00734758e-02f, -3.06227189e-02f, 1.16496952e-02f, -8.00415501e-02f, -1.14993393e-01f, -4.45084460e-02f, -9.33527425e-02f, -3.36954258e-02f,
  4.92893234e-02f, -2.17902195e-02f, 5.95205687e-02f, 7.97806233e-02f, -6.98083714e-02f, 1.75145250e-02f, -6.86229244e-02f, 2.71163005e-02f, -1.21841028e-01f, -8.22676346e-02f,
  -8.13165493e-03f, 3.07702363e-01f, -1.57412186e-01f, -1.84854586e-02f, -2.55926512e-03f, 2.18011308e-02f, -4.31549400e-02f, 1.23687245e-01f, 2.15390604e-02f, 8.63076095e-03f,
  3.88041232e-03f, -1.55423477e-01f, 4.66588698e-03f, -3.74949202e-02f, -1.12738237e-01f, -8.43827799e-02f, -6.26195967e-02f, 6.72875196e-02f, 9.71032232e-02f, -1.03586465e-01f,
  -1.03611983e-01f, 7.14414567e-02f, 2.06488892e-02f, -3.69071513e-02f, -8.71932954e-02f, -1.89004408e-03f, -8.16976130e-02f, -2.26619512e-01f, 5.83035918e-03f, -2.73969680e-01f,
  1.98880151e-01f, 2.12222755e-01f, 1.87525257e-01f, 9.34861973e-02f, 2.01807559e-01f, -1.04266880e-02f, -1.08644396e-01f, -2.28287816e-01f, -1.23667531e-01f, 3.32446434e-02f,
  1.58665761e-01f, -5.39573980e-03f, -7.92544112e-02f, -1.64302334e-01f, -4.75776315e-01f, -2.98615724e-01f, -2.94991910e-01f, -2.96016127e-01f, -4.33113098e-01f, -3.27167332e-01f,
  -3.09800386e-01f, -7.77103305e-02f, -4.57558818e-02f, -2.08849192e-01f, 8.61024410e-02f, -7.93236643e-02f, 2.15859666e-01f, 1.80720687e-01f, 9.72768068e-02f, 1.17070936e-01f,
  1.24611519e-01f, 2.64430463e-01f, -1.85669377e-01f, -2.74287686e-02f, 1.22172244e-01f, -4.18146998e-02f, -4.87090051e-02f, 8.22500885e-02f, -5.58922775e-02f, 8.02934021e-02f,
  1.14008121e-01f, 9.50018782e-03f, 5.90215661e-02f, 4.15008962e-02f, -3.37266922e-02f, -3.30017472e-04f, -9.81192738e-02f, -7.06299096e-02f, -1.37955219e-01f, 9.87285748e-02f,
  -4.30820733e-02f, 1.98149458e-01f, 1.63135588e-01f, -3.91907655e-02f, -7.08777308e-02f, -5.55083044e-02f, 1.45899728e-01f, 1.58785954e-01f, 4.79787886e-02f, -1.55006992e-02f,
  -6.40124679e-02f, -9.98288170e-02f, -6.69606403e-02f, 1.37146190e-01f, -1.03948861e-01f, 6.98181093e-02f, -1.52056394e-02f, 2.64560916e-02f, -1.00124881e-01f, -1.24143496e-01f,
  -6.23990186e-02f, 8.74051005e-02f, -3.93294543e-02f, -1.82311870e-02f, -2.94151027e-02f, -3.01579293e-02f, 5.56872506e-03f, -1.68601215e-01f, -6.50724862e-03f, 8.13583583e-02f,
  -6.42470270e-02f, -1.19946497e-02f, -4.05226238e-02f, -1.21133260e-01f, 2.41275579e-02f, 1.88524008e-03f, 4.13131813e-04f, -4.27444018e-02f, 8.93339291e-02f, 8.10189247e-02f,
  -1.79160580e-01f, 2.09686682e-02f, -5.76263182e-02f, -1.42470285e-01f, -8.82251561e-02f, -5.48138842e-02f, 1.68491691e-01f, -9.13287234e-03f, 1.81743324e-01f, -1.49705738e-01f,
  1.25702217e-01f, 9.63316187e-02f, -2.57302299e-02f, -8.03204551e-02f, -1.82054564e-01f, 3.00521776e-02f, -1.52973011e-01f, -8.93413499e-02f, -1.62285924e-01f, 1.02568697e-02f,
  -1.35254771e-01f, -2.77176678e-01f, -2.09165126e-01f, -2.68360645e-01f, -1.42276451e-01f, -2.43109941e-01f, -1.88830942e-01f, -1.80907726e-01f, -3.06717277e-01f, -4.26969618e-01f,
  -2.17221990e-01f, -3.54869843e-01f, -1.46943033e-01f, -1.68143615e-01f, -6.73643574e-02f, -1.47836909e-01f, -3.43150288e-01f, -2.00089052e-01f, 1.39939502e-01f, -8.26132670e-02f,
  3.70989852e-02f, 2.76093960e-01f, -3.00952755e-02f, -3.72417979e-02f, -2.45053038e-01f, -1.86853424e-01f, -1.58569843e-01f, -1.07380345e-01f, 2.20111385e-01f, 1.78872958e-01f,
  1.26734257e-01f, 2.10053980e-01f, 2.36773863e-01f, 1.82304442e-01f, 1.35872185e-01f, 1.46626472e-01f, 5.02970181e-02f, -2.59951651e-02f, -7.85053894e-02f, -1.68614089e-01f,
  -6.75728694e-02f, -2.10030511e-01f, 1.60702705e-01f, 1.12035826e-01f, 1.75047606e-01f, -9.77501124e-02f, -1.11558236e-01f, 4.23856489e-02f, -6.39900416e-02f, 1.92932691e-02f,
  1.20347619e-01f, 1.65911525e-01f, -1.29090056e-01f, 9.49537978e-02f, 6.96499571e-02f, -7.61484802e-02f, 1.32030204e-01f, -1.18461505e-01f, -6.76403493e-02f, -4.60137948e-02f,
  -6.52792528e-02f, 7.88618848e-02f, -2.25800350e-01f, -9.79887098e-02f, -1.99330628e-01f, -6.70571998e-02f, -1.47808030e-01f, -8.60691145e-02f, -1.66082129e-01f, -2.79690623e-01f,
  1.04280055e-01f, 1.21712923e-01f, -1.11709893e-01f, -5.48330955e-02f, -2.25894828e-03f, 5.62730432e-02f, 2.65730638e-02f, 5.25949113e-02f, 1.19062886e-01f, -1.58941135e-01f,
  -2.35432014e-02f, 4.66428511e-02f, 1.61057815e-01f, -4.68569398e-02f, 4.88913544e-02f, 2.06499230e-02f, -5.53034022e-02f, -4.22394350e-02f, 1.32564856e-02f, -1.44303575e-01f,
  5.81946298e-02f, 5.04731052e-02f, 1.15007348e-01f, 3.12740393e-02f, 4.28681821e-02f, -3.57805123e-03f, 2.37836838e-02f, 3.36799212e-02f, -1.18344918e-01f, 1.00925103e-01f,
  -1.11072071e-01f, 2.19467595e-01f, -1.37932271e-01f, 4.86591198e-02f, -3.63028422e-02f, 1.61342304e-02f, -1.00708909e-01f, 1.22071626e-02f, -3.57926935e-02f, -7.15893805e-02f,
  -1.56924292e-01f, -1.42254174e-01f, -9.46725681e-02f, -1.40267178e-01f, -7.80867264e-02f, -7.16514364e-02f, -1.05394594e-01f, -2.18868062e-01f, -4.63933460e-02f, 9.45910141e-02f,
  -2.28831232e-01f, -1.17956385e-01f, -3.17467749e-01f, -3.03542942e-01f, -9.40629840e-02f, -1.26854852e-01f, -1.48631111e-02f, -1.39829814e-01f, -2.86696583e-01f, -5.41116178e-01f,
  1.48599669e-01f, -1.70069933e-01f, -2.17162415e-01f, -1.52831897e-01f, -3.00069243e-01f, -2.82428324e-01f, -3.72894377e-01f, 6.96489448e-03f, 1.12680010e-01f, -4.29483980e-01f,
  -2.25756213e-01f, -4.59017325e-03f, -3.85031737e-02f, -1.28181383e-01f, -1.64392710e-01f, -3.97081405e-01f, -2.66844153e-01f, -1.81651086e-01f, -9.62200910e-02f, -2.20463321e-01f,
  -1.66891113e-01f, -1.05228536e-01f, 3.25766429e-02f, 6.03038147e-02f, -3.19713540e-02f, 3.49274464e-02f, -8.33255425e-02f, 1.97294876e-02f, -1.90880485e-02f, -1.47051588e-01f,
  -3.60003442e-01f, 9.25782472e-02f, 5.71372248e-02f, 9.05034691e-02f, -1.80497378e-01f, 1.23584960e-02f, -1.42935902e-01f, 6.69644699e-02f, 1.65169194e-01f, -8.89501497e-02f,
  -9.68369842e-02f, -8.48156214e-02f, -2.31082998e-02f, -8.32651928e-02f, -1.57814950e-01f, -7.43152499e-02f, -4.86711562e-02f, -1.59393866e-02f, -3.16018835e-02f, -1.12078518e-01f,
  -5.20774052e-02f, -1.12341292e-01f, 5.75446934e-02f, 5.18718623e-02f, 9.11253095e-02f, -3.40027036e-04f, 7.92479664e-02f, 9.60815251e-02f, 2.15304777e-01f, 1.62540421e-01f,
  -1.75929278e-01f, 6.85817972e-02f, 1.35696512e-02f, -6.83210939e-02f, -1.29746735e-01f, -1.36305904e-02f, 3.21494751e-02f, -8.07878077e-02f, -5.24727628e-02f, -8.40605423e-02f,
  -3.37893926e-02f, -8.04130659e-02f, 5.87473921e-02f, 3.52367796e-02f, 5.81525005e-02f, 2.84432005e-02f, 3.97718176e-02f, -5.30095063e-02f, 7.07165822e-02f, -6.26728460e-02f,
  1.03527727e-02f, 2.21125614e-02f, 6.03362583e-02f, 7.27202371e-02f, 9.89818759e-03f, -1.16384685e-01f, 7.54345283e-02f, -1.06750540e-02f, -2.47192066e-02f, -1.43420398e-01f,
  -5.40638193e-02f, 9.76525396e-02f, -4.48320098e-02f, 8.56418237e-02f, -1.75535008e-02f, 5.34577854e-02f, 1.08142057e-02f, -1.56621188e-02f, -5.98219745e-02f, -6.20718226e-02f,
  4.63301092e-02f, -7.67837465e-02f, -1.72162149e-02f, -9.44612622e-02f, -1.79085895e-01f, -1.49335429e-01f, -1.21052913e-01f, -6.71222508e-02f, 1.35617375e-01f, -1.14294235e-03f,
  1.42453630e-02f, 9.90538746e-02f, 4.04487411e-03f, 8.87350589e-02f, 1.38986737e-01f, 3.34209539e-02f, 4.02640365e-02f, 1.84576929e-01f, 1.76022783e-01f, 3.15775983e-02f,
  -4.79271829e-01f, 1.74834266e-01f, 3.16397958e-02f, -9.99345407e-02f, -1.46812916e-01f, -2.41903037e-01f, -8.60349089e-02f, -1.31015152e-01f, -2.72093490e-02f, 3.88114639e-02f,
  1.00700140e-01f, 1.15986235e-01f, -4.46371501e-03f, -8.40150658e-03f, -1.56821191e-01f, -7.38684684e-02f, -2.51888573e-01f, -1.66188717e-01f, -1.53017044e-01f, -9.25000533e-02f,
  -3.28806713e-02f, -1.23681560e-01f, -8.56952071e-02f, 7.85031414e-04f, 5.26141189e-02f, -3.07146795e-02f, 5.93361855e-02f, -1.29459292e-01f, -9.09475982e-03f, -1.15676381e-01f,
  2.17006281e-01f, -3.38552415e-01f, -9.28827822e-02f, -1.76042050e-01f, -2.03057583e-02f, -7.92921335e-02f, -4.53845151e-02f, 1.04708567e-01f, 3.34693678e-03f, 2.00600326e-02f,
  -5.08788936e-02f, -2.65865698e-02f, -7.03608319e-02f, 1.17930286e-01f, 2.29854435e-02f, -2.30554566e-02f, 3.43722291e-02f, -3.71786021e-02f, 4.36708285e-03f, 1.49355799e-01f,
  3.38527597e-02f, -2.52678096e-01f, -1.49172723e-01f, 9.60749015e-02f, -9.49787498e-02f, -2.30495736e-01f, 1.79990143e-01f, -4.19854671e-02f, -1.29507482e-02f, 1.13085814e-01f,
  8.13318864e-02f, 5.66881634e-02f, -1.99068035e-03f, -5.77452816e-02f, 9.01528299e-02f, 3.54472101e-02f, -1.73892714e-02f, 1.71529010e-01f, -2.15589814e-02f, 8.16089287e-02f,
  -2.10044920e-04f, -1.02685258e-01f, 9.58848372e-03f, -6.00605682e-02f, -1.61122400e-02f, -4.08582650e-02f, -6.50912002e-02f, -7.52794091e-03f, -6.83292150e-02f, -1.58824306e-02f,
  -1.19372435e-01f, 6.31223768e-02f, 3.03754560e-03f, 5.26127368e-02f, -1.08402386e-01f, -8.08307603e-02f, -5.60502745e-02f, 3.45049649e-02f, -3.64238322e-02f, 7.35689281e-03f,
  2.44617268e-01f, -4.50593561e-01f, -1.06612168e-01f, -1.14912987e-01f, -1.58929512e-01f, -2.84455158e-02f, -6.86190799e-02f, -6.56838045e-02f, 2.09532715e-02f, 1.18894003e-01f,
  -1.13661913e-02f, 7.50417262e-02f, 9.46163461e-02f, 9.81949344e-02f, 3.40861008e-02f, 2.59357854e-04f, 9.34058875e-02f, -2.38000583e-02f, -6.90629035e-02f, 7.23233223e-02f,
  1.52116194e-01f, -5.63175566e-02f, -2.35712212e-02f, 4.32020761e-02f, 5.53846471e-02f, -5.18485792e-02f, 1.91321567e-01f, 2.94659827e-02f, -4.34816331e-02f, 2.59302944e-01f,
  -4.24529701e-01f, -4.15398806e-01f, -2.60101378e-01f, 1.37438700e-01f, 1.89464957e-01f, -1.65097296e-01f, -2.93157488e-01f, -2.64900029e-01f, -8.46979469e-02f, -1.30052328e-01f,
  -8.51283818e-02f, 1.55010581e-01f, 1.20880373e-01f, 2.77536750e-01f, -1.28779095e-02f, -8.70396271e-02f, 2.77443647e-01f, 2.19194829e-01f, 2.72345454e-01f, 3.64771634e-02f,
  1.97207436e-01f, 2.25294277e-01f, 1.53614031e-02f, 5.53596281e-02f, 1.68189377e-01f, 3.66661012e-01f, 7.91000128e-02f, 6.20951168e-02f, 1.64062008e-01f, 2.95356929e-01f,
  -2.35750467e-01f, -5.13559699e-01f, 1.57700390e-01f, 1.46879017e-01f, -1.01325521e-02f, -6.87595978e-02f, -5.19617721e-02f, 2.51805987e-02f, -1.09225728e-01f, -2.44798526e-01f,
  -8.30121513e-04f, -1.19938828e-01f, 2.36282095e-01f, 6.65850714e-02f, -1.50169075e-01f, -1.81161255e-01f, -4.05357145e-02f, 1.61671005e-02f, -1.35793775e-01f, -2.80696809e-01f,
  3.49765778e-01f, 8.29707906e-02f, -1.54321387e-01f, -2.57330716e-01f, -3.45945060e-01f, 1.80349126e-01f, -2.01805070e-01f, -2.29784146e-01f, -3.78282756e-01f, -2.97178954e-01f,
  4.54114415e-02f, -4.80053830e-04f, -7.11631728e-05f, 2.29999963e-02f, 5.64146116e-02f, 1.21596241e-02f, 1.01424448e-01f, 1.08785965e-01f, 1.15458563e-01f, -1.18038304e-01f,
  5.93527332e-02f, -1.11737654e-01f, -1.05926067e-01f, -1.44617483e-01f, 1.30531713e-01f, -1.04030699e-01f, -5.27485739e-03f, 5.13246842e-02f, 1.39694232e-02f, -1.93965852e-01f,
  -1.54790744e-01f, -1.39446169e-01f, -4.00880761e-02f, 8.11888874e-02f, -6.41771480e-02f, -4.14713398e-02f, -8.02363977e-02f, -1.17764911e-02f, 1.21849328e-01f, -1.75519347e-01f,
  -1.54913217e-01f, 1.53672174e-01f, -2.85341274e-02f, -4.52551022e-02f, 7.12936968e-02f, 2.02153064e-02f, -7.48375729e-02f, 4.43043821e-02f, 1.73490215e-02f, -2.37398535e-01f,
  -1.66099429e-01f, -1.41311064e-01f, 6.89588636e-02f, 1.39384240e-01f, -1.64177403e-01f, -8.56369957e-02f, 1.25140786e-01f, 2.37159804e-01f, 5.49670570e-02f, -3.16342041e-02f,
  4.22038250e-02f, -1.61829799e-01f, -1.42503530e-01f, -8.64455178e-02f, -1.64488405e-01f, 1.95024535e-02f, -1.00307502e-01f, -2.41806671e-01f, -3.75176311e-01f, -3.08434814e-01f,
  -2.20515922e-01f, 1.19247779e-01f, 1.51362613e-01f, 3.64583135e-02f, 8.94380137e-02f, -2.97445744e-01f, -3.59469473e-01f, -4.39461976e-01f, -1.01060145e-01f, 1.84777156e-01f,
  1.33552805e-01f, 2.26135075e-01f, 1.19857088e-01f, -1.49945959e-01f, -3.05510253e-01f, -1.68650642e-01f, -4.42176796e-02f, -2.22558096e-01f, -3.10034066e-01f, -2.29627311e-01f,
  -6.45448342e-02f, 4.42893361e-04f, -2.22080901e-01f, -8.59739110e-02f, 1.72530040e-01f, 1.17933929e-01f, 2.74781346e-01f, 2.16277555e-01f, 9.05434340e-02f, 2.71347165e-01f,
  3.88945818e-01f, 2.80057713e-02f, -1.81573480e-01f, -9.81487483e-02f, 2.15832278e-01f, -9.82802659e-02f, 1.73513778e-02f, 9.96876787e-03f, -1.49669886e-01f, -1.91529877e-02f,
  4.67438251e-02f, -2.02714019e-02f, -1.11125454e-01f, -6.63163811e-02f, -7.28116781e-02f, -1.35766774e-01f, -1.74715221e-01f, -1.34527713e-01f, -8.26920420e-02f, -4.11550589e-02f,
  5.88543601e-02f, -8.56638551e-02f, -2.86924820e-02f, -2.20749617e-01f, -6.27846792e-02f, 6.67346790e-02f, 9.73761752e-02f, -1.31050656e-02f, -3.29280868e-02f, 8.33013654e-02f,
  -1.27122864e-01f, 4.14688066e-02f, 1.31609989e-02f, 1.85602382e-02f, 6.92057004e-03f, 3.67810875e-02f, 1.02289766e-01f, 4.16070744e-02f, -5.71952984e-02f, -1.17358398e-02f,
  1.82522237e-02f, 7.08215982e-02f, 3.91478278e-02f, 1.46698296e-01f, 4.62744646e-02f, 6.21567145e-02f, 4.48672250e-02f, -5.81110716e-02f, 4.82887961e-03f, 6.04236424e-02f,
  7.28782862e-02f, -6.55995086e-02f, 1.97908401e-01f, 3.59847695e-02f, 6.11470789e-02f, -3.76190897e-03f, 3.01478989e-02f, -7.61207342e-02f, 7.53667147e-04f, 4.12594266e-02f,
  2.05336213e-01f, -1.77754030e-01f, 2.59182066e-01f, -9.43300650e-02f, 7.84413591e-02f, -1.74371828e-03f, 6.64619058e-02f, 4.11601318e-03f, 1.79479748e-01f, -4.68397066e-02f,
  -4.00011390e-02f, -6.30538985e-02f, 6.04323968e-02f, 1.32374931e-02f, -2.49099340e-02f, -4.30020913e-02f, -1.06920943e-01f, 9.38015357e-02f, -2.30770633e-02f, 5.77523224e-02f,
  -1.39982790e-01f, -1.64903641e-01f, -6.09438196e-02f, 8.65961462e-02f, -7.60952430e-03f, -3.30461860e-02f, 1.24919318e-01f, 1.39002711e-01f, 4.58557978e-02f, 2.88898814e-02f,
  8.62989277e-02f, -1.78590730e-01f, 3.43694478e-01f, 1.77960649e-01f, -3.09361339e-01f, -2.82894343e-01f, -4.10711199e-01f, -2.31103688e-01f, -6.57352582e-02f, 6.63114265e-02f,
  -1.39347896e-01f, -1.00336194e-01f, 5.00147380e-02f, 1.26441106e-01f, -7.28765726e-02f, 1.00177109e-01f, 3.23238194e-01f, 1.83462784e-01f, 4.63374108e-02f, -1.77176774e-01f,
  -9.66340154e-02f, 4.72589396e-02f, 9.26184207e-02f, 1.49628781e-02f, 1.10337056e-01f, -8.38408917e-02f, 4.64731343e-02f, 7.40631074e-02f, -1.50054069e-02f, 4.85611439e-01f,
  2.95321912e-01f, -1.33099565e-02f, -1.78908855e-01f, 2.26873979e-02f, 2.38435902e-03f, 4.18655062e-03f, 1.24074563e-01f, 2.67504036e-01f, -6.17579632e-02f, 1.63211927e-01f,
  1.04913481e-01f, -2.35741083e-02f, 3.42081115e-02f, 3.50110307e-02f, -9.48760435e-02f, -1.36973396e-01f, 1.58811018e-01f, 2.36488611e-01f, 2.18993068e-01f, 8.96105990e-02f,
  -1.18563212e-02f, -2.37743417e-03f, -1.59088373e-01f, -1.60953254e-01f, -1.85738169e-02f, -4.88318019e-02f, -1.71215013e-01f, -3.20053510e-02f, -2.04948500e-01f, 1.20694548e-01f,
  1.83507521e-02f, 5.33012226e-02f, 4.78651971e-02f, 9.07270163e-02f, 2.82961838e-02f, 4.37577330e-02f, 2.08254233e-01f, -2.04680990e-02f, 8.22525695e-02f, -1.32783726e-02f,
  3.24385464e-02f, 1.24911442e-01f, 4.23628837e-02f, -3.56153771e-02f, 2.14617532e-02f, 4.48939390e-02f, 3.36726457e-02f, 1.39170242e-02f, 1.59290954e-04f, 7.95342624e-02f,
  -2.34170984e-02f, 1.47561207e-02f, 1.39979854e-01f, 4.36007008e-02f, 7.53875598e-02f, 6.30248562e-02f, 1.92979127e-01f, -2.25054771e-02f, -4.96926866e-02f, -1.32076745e-03f,
  -8.14112276e-02f, -2.45946229e-01f, 1.23741701e-01f, 1.38530433e-01f, 1.27378076e-01f, -6.00079373e-02f, 3.68264839e-02f, 1.26321486e-03f, -9.26946197e-03f, -1.02540376e-02f,
  -1.58368543e-01f, -6.00627139e-02f, 1.48972273e-02f, 4.57130931e-02f, -3.41600366e-02f, 2.56794970e-02f, 1.46734208e-01f, -1.68080404e-02f, -4.03306633e-03f, 4.60018441e-02f,
  9.91681963e-02f, -2.25596204e-01f, -3.49165082e-01f, -2.53858626e-01f, -3.10757905e-02f, -2.02602506e-01f, -1.92544162e-01f, -1.50300726e-01f, -2.42073476e-01f, -4.36298043e-01f,
  -8.32178175e-01f, -3.29723537e-01f, 3.26515645e-01f, -3.85698050e-01f, 1.91877872e-01f, 3.08519632e-01f, 3.58561397e-01f, -1.52659854e-02f, -2.78496504e-01f, 1.30509093e-01f,
  -2.33758107e-01f, -3.96951973e-01f, -3.02069128e-01f, -1.41906425e-01f, -1.67991519e-01f, 3.41488630e-01f, 2.82401592e-01f, -2.01132186e-02f, 1.78741794e-02f, 9.49007273e-03f,
  -7.51526654e-02f, -1.47670761e-01f, -3.70476067e-01f, -1.92920774e-01f, -7.51084238e-02f, -2.05563620e-01f, -1.32292965e-02f, -1.43055931e-01f, -7.51109272e-02f, 4.14876044e-02f,
  4.73875552e-01f, -1.78236723e-01f, 1.34192333e-01f, -2.01896042e-01f, -2.32377857e-01f, -1.83294922e-01f, -9.27006900e-02f, -1.44294739e-01f, -1.39576390e-01f, -7.86034614e-02f,
  -1.61277264e-01f, -7.97649398e-02f, -3.31119411e-02f, -2.55150851e-02f, -8.82319734e-02f, -8.35565012e-03f, -8.11922178e-02f, -1.09883035e-02f, -1.30685315e-01f, -1.91524047e-02f,
  -8.06416422e-02f, 1.26173841e-02f, 1.18161738e-02f, 7.60633051e-02f, -1.63089529e-01f, -9.73968282e-02f, 4.31472920e-02f, -1.15778074e-01f, -8.77724681e-03f, 1.75905675e-02f,
  1.05404377e-01f, -8.18831772e-02f, -2.40362361e-02f, -4.02369127e-02f, -1.21065542e-01f, -9.15721976e-05f, 1.92328226e-02f, -8.82620439e-02f, -2.12261360e-02f, -7.22523406e-02f,
  6.05728431e-03f, -4.32245024e-02f, 3.55263166e-02f, -9.67147276e-02f, -1.96439549e-02f, -4.45346311e-02f, -6.16371073e-02f, -8.82772505e-02f, -1.03317291e-01f, -1.13922298e-01f,
  -7.40041137e-02f, 4.82816994e-03f, -1.88066624e-02f, 2.83394102e-02f, 6.60970882e-02f, -4.50719073e-02f, -6.40488267e-02f, -7.65565187e-02f, -1.18705317e-01f, -3.50354053e-02f,
  1.14900701e-01f, 1.38186172e-01f, 1.87943831e-01f, -1.02567263e-02f, 1.42978337e-02f, 4.30175569e-03f, 3.68329547e-02f, 1.21533617e-01f, -5.41075282e-02f, 3.88125144e-02f,
  -1.04022525e-01f, -6.04831055e-02f, -1.63743403e-02f, 5.52536696e-02f, 8.24559256e-02f, 7.65508935e-02f, 5.54956421e-02f, -3.95599082e-02f, 2.57125683e-02f, 1.18512444e-01f,
  -3.84958349e-02f, 1.34380504e-01f, 6.32619113e-02f, 1.72314152e-01f, -2.29262207e-02f, 9.46015194e-02f, 1.75920516e-01f, 7.63992071e-02f, 2.08212063e-01f, 2.02608004e-01f,
  5.43295264e-01f, -5.74318230e-01f, 1.93305194e-01f, 2.76797146e-01f, 1.33012295e-01f, 2.21429944e-01f, 2.48017311e-02f, 2.50031129e-02f, 1.94965303e-01f, 8.99849180e-03f,
  -4.52498704e-01f, -2.83779323e-01f, -3.02218527e-01f, -1.45514086e-01f, -1.01136044e-01f, 1.56342983e-01f, 2.78343022e-01f, 3.72074246e-01f, 3.24082792e-01f, -5.43945935e-03f,
  -9.20512900e-02f, 4.09747362e-02f, 2.13590309e-01f, 1.02340780e-01f, -1.58213004e-01f, -1.08764060e-01f, -1.34382978e-01f, 5.38179614e-02f, -1.47604987e-01f, -1.63474977e-02f,
  -2.72921115e-01f, -9.83649269e-02f, 5.45774251e-02f, -1.66763932e-01f, -2.45591700e-01f, 1.78463738e-02f, -7.46821091e-02f, -1.05984677e-02f, -1.34092733e-01f, 1.78548396e-02f,
  -5.22734113e-02f, -5.53202629e-02f, -3.80982980e-02f, -5.08868229e-03f, -4.03735787e-02f, -7.81712588e-03f, -2.70935912e-02f, -4.51334007e-02f, -1.12512991e-01f, -1.17740139e-01f,
  -2.60958314e-01f, 1.16816230e-01f, 7.44811818e-02f, 5.72173893e-02f, -1.09819651e-01f, 9.67588574e-02f, -8.85584056e-02f, 4.65223715e-02f, 8.28383639e-02f, 1.32358074e-01f,
  -1.69715554e-01f, 3.75840850e-02f, -5.46172969e-02f, 2.53599938e-02f, 4.61901240e-02f, 1.02673724e-01f, 4.41836491e-02f, 2.64902376e-02f, 1.17811905e-02f, -6.15890324e-03f,
  -9.66584012e-02f, -6.49272278e-02f, -9.67368186e-02f, -3.96708176e-02f, -6.77440539e-02f, -1.05319075e-01f, 4.03351784e-02f, -1.43280998e-01f, -7.08883852e-02f, -8.87252241e-02f,
  -1.10614672e-03f, -4.72849887e-03f, -4.60776910e-02f, -1.91681504e-01f, -1.48966894e-01f, -6.92558736e-02f, -4.45286594e-02f, -5.01262806e-02f, 4.37400639e-02f, -4.78960536e-02f,
  -2.75306255e-01f, -1.46129698e-01f, 9.92737804e-03f, -1.47407070e-01f, 7.86539838e-02f, -1.32477164e-01f, -6.19940981e-02f, -5.11888564e-02f, 7.09853470e-02f, -3.71874124e-02f,
  1.67454220e-02f, 1.68482750e-03f, -1.63391292e-01f, -1.57510072e-01f, 1.97818905e-01f, 9.90523249e-02f, -6.66432753e-02f, 1.68434698e-02f, -3.50996070e-02f, -2.24039271e-01f,
  -4.04932871e-02f, 1.48299813e-01f, 1.18942291e-01f, 2.09798232e-01f, 9.12089273e-02f, 2.68980205e-01f, 8.61240327e-02f, 1.65494338e-01f, 9.97113958e-02f, 2.35543132e-01f,
  1.74691767e-01f, -1.52839810e-01f, 4.47614670e-01f, 3.05245053e-02f, -3.00495714e-01f, -3.36760670e-01f, -2.54376471e-01f, -8.56130794e-02f, -2.37939470e-02f, -1.53338864e-01f,
  -2.02360794e-01f, -3.12526487e-02f, 7.66682923e-02f, 1.06435850e-01f, 2.89073259e-01f, 1.27518792e-02f, 9.20597538e-02f, 5.00787318e-01f, 4.33698297e-01f, -7.10426047e-02f,
  -2.55143732e-01f, 1.41856164e-01f, 3.97378534e-01f, 2.48209700e-01f, -2.71508880e-02f, 8.93980563e-02f, 2.62793273e-01f, 4.67002504e-02f, -1.24437012e-01f, -7.39924759e-02f,
  1.63459368e-02f, -2.11513266e-01f, 4.79909293e-02f, -1.26186088e-01f, -4.68025468e-02f, 3.22494730e-02f, 2.46338956e-02f, 1.22718289e-01f, -6.44672546e-04f, -3.93427722e-02f,
  -1.50723174e-01f, -6.39685765e-02f, -1.49120003e-01f, -5.26462309e-02f, 4.33384813e-02f, 1.92091390e-02f, 1.96145922e-01f, 2.72391081e-01f, 1.35496214e-01f, 1.42372362e-02f,
  -2.32662991e-01f, -2.56166071e-01f, -3.87254171e-02f, 6.94294795e-02f, 7.83298686e-02f, 1.11016138e-02f, -7.08256587e-02f, 7.95793831e-02f, 1.27446637e-01f, 1.27175570e-01f,
  6.96152672e-02f, -1.13489550e-04f, -2.73068175e-02f, 7.97662660e-02f, 5.06022908e-02f, 6.74897060e-02f, 1.01270556e-01f, -2.94049866e-02f, -1.08760120e-02f, 2.00400073e-02f,
  9.58384871e-02f, 1.71846837e-01f, 1.36567429e-01f, 2.78582182e-02f, 3.10619175e-02f, -7.75136724e-02f, 1.90313868e-02f, 1.28090158e-02f, -2.47920025e-02f, 6.53540865e-02f,
  1.86481569e-02f, -4.00679186e-02f, 4.91187461e-02f, 1.78987920e-01f, -2.28801575e-02f, 1.10220395e-01f, -1.23097174e-01f, -7.99777582e-02f, -1.16617620e-01f, -1.15800045e-01f,
  -2.89220903e-02f, 3.31212170e-02f, -7.59420171e-02f, 2.50364318e-02f, -9.36906338e-02f, -3.97642218e-02f, -1.01583883e-01f, 6.32814541e-02f, -2.03282997e-01f, -2.49885321e-02f,
  -1.68812126e-01f, 8.93710852e-02f, 2.71821264e-02f, -4.54058908e-02f, -3.43079045e-02f, -8.45776945e-02f, -2.43723989e-01f, -1.51340112e-01f, 1.78091079e-02f, 7.53738917e-03f,
  -1.86954495e-02f, -1.76375344e-01f, -5.64731844e-02f, -8.26861784e-02f, -1.47679001e-01f, -3.28019001e-02f, 3.86851927e-04f, -8.33726022e-03f, 1.03461578e-01f, 6.70183301e-02f,
  3.88051391e-01f, -4.04777974e-01f, -2.80360162e-01f, -1.88397691e-01f, -2.23069906e-01f, -2.68997997e-01f, -3.76158625e-01f, -1.10368796e-01f, -5.92337139e-02f, -3.19744200e-01f,
  -1.13787659e-01f, 4.15659934e-01f, 1.17441691e-01f, 1.85199142e-01f, 3.18884045e-01f, -3.98663640e-01f, -3.57616127e-01f, 2.36980289e-01f, 5.30907214e-01f, 2.03355640e-01f,
  -3.51386890e-02f, 1.18262537e-01f, 2.08076969e-01f, 1.82244703e-01f, -2.54167199e-01f, 5.52752130e-02f, -3.41770679e-01f, -1.09504342e-01f, -1.46935716e-01f, -4.58021611e-01f,
  6.98719397e-02f, -5.09229936e-02f, -4.39433232e-02f, 1.17494673e-01f, -1.58986270e-01f, 3.17264274e-02f, 6.61789402e-02f, -7.21978545e-02f, 2.02409942e-02f, -1.16535895e-01f,
  -5.00154048e-02f, 1.22141711e-01f, 1.11935206e-01f, 8.14980268e-02f, -8.82553309e-02f, -8.11900198e-03f, -1.08577488e-02f, -3.62704173e-02f, -1.05051301e-01f, -8.97624865e-02f,
  -4.09890637e-02f, -7.93880448e-02f, 5.85813373e-02f, -1.62716791e-01f, -5.08292951e-02f, 1.45920843e-01f, -1.04878537e-01f, 3.23139317e-03f, -4.33145426e-02f, -3.09505731e-01f,
  -1.06386714e-01f, -4.79298532e-02f, -5.98306768e-02f, 1.67821925e-02f, -2.07414981e-02f, -5.85492961e-02f, 8.77821594e-02f, -3.01533062e-02f, 4.37032543e-02f, -9.59965587e-02f,
  -5.74150076e-03f, -4.82193455e-02f, 8.55290517e-03f, -7.72773474e-02f, -8.38207230e-02f, 1.31484479e-01f, 4.33087684e-02f, -1.05139889e-01f, -5.42187616e-02f, -2.16878448e-02f,
  9.40500274e-02f, -3.58253978e-02f, -8.42408910e-02f, 2.02064347e-02f, 1.38361508e-03f, 6.03718571e-02f, 4.71667126e-02f, 7.88583085e-02f, 2.53232438e-02f, 7.09619466e-03f,
  1.58047035e-01f, 6.94600493e-02f, -8.47205222e-02f, 6.06578588e-02f, -9.29829404e-02f, -2.31094453e-02f, -1.30296633e-01f, -6.97936490e-02f, -8.88229460e-02f, -4.93949912e-02f,
  2.72526238e-02f, 1.36404231e-01f, -2.16919673e-03f, -2.57302318e-02f, -1.76659487e-02f, 8.67199376e-02f, 6.57632500e-02f, 1.01630397e-01f, 1.87093318e-02f, -2.12859586e-02f,
  -1.40947804e-01f, -1.64392719e-03f, 1.98981449e-01f, 1.02225199e-01f, -7.05853850e-02f, 1.03399284e-01f, -1.63812190e-01f, -1.35295257e-01f, 1.23124570e-01f, -1.27884686e-01f,
  2.39249766e-01f, 3.13894562e-02f, 2.99303204e-01f, 1.46209389e-01f, -7.06482232e-02f, -3.37273687e-01f, -3.12058747e-01f, -2.55121469e-01f, -1.22692227e-01f, -2.48685163e-02f,
  -1.17463820e-01f, -1.61763564e-01f, 8.83770660e-02f, -9.43140760e-02f, -4.44253981e-02f, 1.44734114e-01f, 2.10607976e-01f, 2.65407920e-01f, -1.24591827e-01f, -1.95428565e-01f,
  -1.07554138e-01f, 7.27565661e-02f, 3.44933644e-02f, 9.35810711e-03f, 6.67143166e-02f, -8.81866142e-02f, 7.78416023e-02f, 2.52661198e-01f, 1.40438855e-01f, 4.10606027e-01f,
  2.83881813e-01f, 3.89765501e-01f, -1.65341586e-01f, 3.44867893e-02f, 5.38105443e-02f, -5.68102412e-02f, -9.43073705e-02f, 1.83345780e-01f, 1.82590447e-02f, 1.12220898e-01f,
  1.71583816e-01f, 8.54696929e-02f, 1.64634269e-02f, -1.39260933e-01f, -1.00576632e-01f, -3.07825744e-01f, 2.41695605e-02f, 1.00421943e-01f, 1.30407557e-01f, -7.84572884e-02f,
  -9.27816853e-02f, 1.26624748e-01f, 1.77921221e-01f, -1.94162667e-01f, 2.70555466e-02f, -2.26642638e-02f, 9.23247114e-02f, 1.07017465e-01f, -1.72195613e-01f, 9.42904949e-02f,
  -3.55787091e-02f, 3.20995972e-02f, -6.06127828e-02f, 1.34428412e-01f, -4.06589871e-03f, 7.76169002e-02f, 5.56346625e-02f, -4.79480214e-02f, -7.52509683e-02f, 8.12794045e-02f,
  -8.32189843e-02f, -1.10000968e-01f, 1.63315251e-01f, -6.56955764e-02f, -1.29493460e-01f, 7.63199925e-02f, -1.48382425e-01f, -3.99276316e-02f, 1.67193651e-01f, -7.96282722e-04f,
  5.88369705e-02f, -1.09835774e-01f, 5.21277860e-02f, -5.96417822e-02f, 3.07205226e-02f, 8.55869651e-02f, -8.26293137e-03f, -1.08568773e-01f, 5.79836741e-02f, 2.40312338e-01f,
  -1.17898636e-01f, 3.65039930e-02f, 6.76800460e-02f, 9.69259292e-02f, 7.28746131e-02f, -3.89021412e-02f, -6.77380934e-02f, -2.10539356e-01f, 2.59414278e-02f, -1.30840391e-01f,
  -1.00868002e-01f, -7.12283626e-02f, 1.15206741e-01f, -9.21134353e-02f, -1.97645664e-01f, -2.35396147e-01f, -1.84691608e-01f, -2.19906121e-01f, -8.63323584e-02f, -6.13485761e-02f,
  -8.41991901e-02f, -2.78891921e-01f, -1.94757313e-01f, -1.58441335e-01f, -1.88442990e-01f, -3.43245506e-01f, -2.07320899e-01f, -1.59225732e-01f, -3.81776333e-01f, -2.84550697e-01f,
  -3.27891737e-01f, 8.82717893e-02f, -7.34052882e-02f, -1.89373061e-01f, 5.10976743e-03f, 1.29763549e-02f, 8.82382616e-02f, 6.47011474e-02f, 1.36635825e-01f, 1.40657872e-01f,
  9.77976918e-02f, -1.16946585e-01f, -7.67162889e-02f, -2.36801073e-01f, -2.74760962e-01f, 3.73047702e-02f, -7.50974491e-02f, -3.62484992e-01f, -4.87754017e-01f, -2.35643834e-01f,
  -2.26722404e-01f, -3.02773595e-01f, -4.00767744e-01f, -2.80075759e-01f, 4.03549001e-02f, -2.92228937e-01f, 1.08030234e-02f, -2.70729482e-01f, -5.95611669e-02f, -1.39587224e-01f,
  -6.30388036e-02f, -2.02584326e-01f, 9.87271219e-03f, -1.62527904e-01f, 9.60593149e-02f, 1.31633252e-01f, 1.27623871e-01f, 1.18982054e-01f, 2.27820158e-01f, 1.05102628e-01f,
  -5.45334443e-02f, 2.15070188e-01f, 7.33176619e-02f, -1.46296686e-02f, -1.11220382e-01f, -6.51954561e-02f, 4.19779420e-02f, -2.94875428e-02f, -1.65430419e-02f, 2.08681911e-01f,
  6.98818788e-02f, -7.56814182e-02f, -8.52326602e-02f, -9.31236520e-02f, 6.02302328e-02f, -1.31411478e-01f, -5.88236675e-02f, -9.31373835e-02f, -7.47259781e-02f, -6.52496070e-02f,
  6.74482435e-02f, -8.85693580e-02f, 5.23668267e-02f, -7.71483481e-02f, -1.56556755e-01f, -2.51180883e-02f, -2.41368935e-01f, -1.77883580e-01f, -1.30180150e-01f, -1.45872951e-01f,
  3.56332809e-02f, -2.30021570e-02f, -1.25845715e-01f, -3.63799930e-02f, -1.05624385e-01f, -9.48345140e-02f, -7.28648156e-02f, -1.85556516e-01f, -1.63844511e-01f, -9.86470357e-02f,
  -3.29389609e-02f, -4.02028300e-02f, -3.26200798e-02f, -8.12628493e-02f, -2.92512402e-02f, -1.07209429e-01f, -5.15446924e-02f, 9.03661922e-03f, 7.78841414e-03f, 9.01364014e-02f,
  -4.12578732e-01f, -1.97159693e-01f, -3.85889784e-02f, 2.10478832e-03f, 1.54365720e-02f, 1.15806796e-01f, 5.95412916e-03f, 7.57595524e-04f, 5.58384769e-02f, -1.15840659e-01f,
  -1.13602608e-01f, -1.50309131e-01f, 7.04499800e-03f, 8.59123934e-03f, -2.52831317e-02f, -1.73023999e-01f, -6.34750947e-02f, -1.88414082e-01f, -1.45688996e-01f, 1.46531150e-01f,
  8.62037949e-03f, -1.90662399e-01f, -2.36416668e-01f, -1.38951197e-01f, -7.72548169e-02f, -3.49852532e-01f, -8.10667053e-02f, -8.07516277e-02f, -1.22191265e-01f, -1.75934508e-01f,
  5.17772161e-04f, -1.29537806e-01f, -3.97884935e-01f, -1.02158360e-01f, -3.34083021e-01f, -1.56983197e-01f, -2.65294164e-01f, -1.24136895e-01f, -1.39676332e-01f, -3.01745206e-01f,
  -1.82295382e-01f, 1.85846031e-01f, 1.46237090e-01f, 1.74432043e-02f, 9.22530890e-02f, -3.77587020e-01f, -4.48846906e-01f, -1.12370066e-01f, -8.03671125e-03f, -8.01325440e-02f,
  -9.89662558e-02f, 9.05561596e-02f, 1.45801947e-01f, -6.21128567e-02f, 2.82189175e-02f, 6.70716614e-02f, -2.20878184e-01f, -8.92066881e-02f, -2.31575593e-01f, -2.41060033e-01f,
  3.10518086e-01f, -1.99190512e-01f, 5.27689904e-02f, -1.37481540e-01f, -8.17797408e-02f, -1.76117495e-02f, -2.14287899e-02f, 2.68957317e-02f, 7.15018883e-02f, 7.65874051e-03f,
  -5.46310320e-02f, -1.79342981e-02f, 1.08448461e-01f, 4.14391346e-02f, 5.63263781e-02f, 1.00830436e-01f, -9.66985375e-02f, -8.26296434e-02f, -8.72525424e-02f, -7.17870332e-03f,
  -8.01155195e-02f, -6.54003769e-02f, -5.99690937e-02f, 7.28511363e-02f, -2.94478144e-02f, 2.81012505e-02f, -5.95805384e-02f, -4.00191210e-02f, -7.77453929e-02f, 3.14910784e-02f,
  -4.82579134e-02f, 4.24710698e-02f, -6.70897663e-02f, -5.20146005e-02f, -6.95083961e-02f, -6.82642907e-02f, -1.52925178e-02f, -2.33184956e-02f, -6.14353688e-03f, 2.00996548e-02f,
  -5.05476519e-02f, -3.23901214e-02f, 9.48745757e-02f, -1.74533464e-02f, -1.72763485e-02f, -4.69431616e-02f, 6.15233518e-02f, 3.95796783e-02f, -3.19191180e-02f, -8.69287625e-02f,
  -9.40287113e-03f, -1.29276171e-01f, -3.34630683e-02f, -2.49382202e-02f, -1.11039177e-01f, -1.59993351e-01f, -2.50816084e-02f, 4.74575758e-02f, -7.76927844e-02f, -8.51511434e-02f,
  3.68341655e-01f, -2.73473382e-01f, 1.52399570e-01f, 2.13198494e-02f, -6.27634004e-02f, -4.19750325e-02f, -6.79645780e-03f, -8.42312574e-02f, 2.76442908e-04f, 4.00748104e-03f,
  -1.15477517e-01f, -9.30783823e-02f, 1.30180707e-02f, 6.41916990e-02f, -1.32029414e-01f, 1.11903129e-02f, -7.98530206e-02f, 1.11451363e-02f, -1.19259268e-01f, -4.72329669e-02f,
  -8.57995301e-02f, -6.11509420e-02f, 2.07609460e-01f, 1.10995002e-01f, 1.55303497e-02f, 3.55126932e-02f, 1.93996206e-01f, 5.35868406e-02f, -7.43747652e-02f, 2.70748660e-02f,
  -5.96770167e-01f, -2.51963913e-01f, -2.32228294e-01f, -5.55826664e-01f, -1.66320130e-01f, 1.75251529e-01f, 7.20801726e-02f, 1.27467826e-01f, -1.51766196e-01f, -1.55320480e-01f,
  -6.13010898e-02f, -2.00298175e-01f, -2.89189219e-01f, 9.11396444e-02f, 1.87017247e-01f, -9.94620174e-02f, -1.12386875e-01f, -9.13784727e-02f, 1.48282960e-01f, 3.68135482e-01f,
  1.86936602e-01f, -1.51984870e-01f, 1.85000990e-02f, 3.92998941e-02f, -2.60546237e-01f, -1.41775757e-02f, -9.78990048e-02f, -2.28967205e-01f, 9.63529721e-02f, -4.05850291e-01f,
  -2.20490977e-01f, -1.50955856e-01f, 1.71732098e-01f, -5.32385483e-02f, -1.42092690e-01f, 2.78686807e-02f, 7.85591975e-02f, -1.65682837e-01f, -6.58139810e-02f, -9.50133055e-02f,
  -1.27499431e-01f, 2.05186814e-01f, -2.10747138e-01f, 7.29045346e-02f, 9.38980957e-04f, 1.99829619e-02f, -7.84554929e-02f, 3.46398912e-02f, -9.93861407e-02f, 2.18209699e-01f,
  -5.76376319e-02f, -1.78920001e-01f, -1.75644293e-01f, 1.06866300e-01f, 4.06017490e-02f, -1.96308240e-01f, 7.44829103e-02f, -4.27627452e-02f, 5.52245006e-02f, -2.89565802e-01f,
  1.17339961e-01f, -3.15048695e-02f, 2.17202548e-02f, 4.86358143e-02f, 3.66062252e-03f, 1.02184620e-02f, -1.05473280e-01f, 1.19896114e-01f, 2.34197363e-01f, -5.81560396e-02f,
  6.67483406e-03f, -6.12531090e-03f, 3.65103669e-02f, 1.25791514e-02f, -5.91935255e-02f, -7.43089691e-02f, -2.65180022e-02f, 1.23740785e-01f, 1.06476750e-02f, -2.95230639e-05f,
  -3.95797715e-02f, -4.98226786e-04f, -8.90370607e-02f, -2.10045069e-03f, -1.63876545e-02f, 2.13414542e-02f, 1.16129052e-02f, 4.55851573e-03f, -3.40342373e-02f, 1.81161575e-02f,
  -2.73819059e-01f, 1.29831880e-01f, -1.29569039e-01f, -1.81004032e-02f, -1.66564256e-01f, 6.05329387e-02f, -2.17434660e-01f, 3.12471911e-02f, -1.36925191e-01f, 7.22029731e-02f,
  1.01483632e-02f, -9.34466794e-02f, -2.28896320e-01f, -1.02580907e-02f, 1.30824581e-01f, -2.20008735e-02f, -7.53360167e-02f, -2.26305589e-01f, -3.02958414e-02f, -1.61042288e-02f,
  -1.80281535e-01f, -1.81064308e-02f, -3.23016554e-01f, -1.07651114e-01f, 1.39839035e-02f, -3.31833482e-01f, -1.25583991e-01f, -2.00706378e-01f, -1.88348461e-02f, -2.04167902e-01f,
  2.23710686e-01f, 2.50039518e-01f, -1.86983366e-02f, 2.02666178e-01f, -2.98943445e-02f, 1.97373971e-01f, 2.83476174e-01f, 2.84981728e-01f, 1.47197828e-01f, 3.88391800e-02f,
  -7.55205005e-02f, 9.70708113e-03f, 2.36632481e-01f, 2.39042848e-01f, 2.14409590e-01f, 2.08004609e-01f, 2.46549696e-01f, 2.44085863e-01f, 1.24095930e-02f, 4.06319499e-02f,
  1.00155942e-01f, 1.96590036e-01f, 1.69033200e-01f, 9.64131579e-02f, 7.64442310e-02f, 9.95788872e-02f, 1.64692521e-01f, 1.47254556e-01f, 1.17197327e-01f, -1.67115137e-03f,
  -3.20357412e-01f, 3.86766866e-02f, -1.04063921e-01f, -1.16886310e-01f, -1.48726165e-01f, -3.45086381e-02f, 8.07667077e-02f, -7.25584477e-02f, -8.78080502e-02f, -1.21853473e-02f,
  -1.55116901e-01f, -1.06827386e-01f, 1.47832975e-01f, 4.62958030e-02f, 1.46252085e-02f, -9.69519168e-02f, 1.25590205e-01f, 1.52414158e-01f, 1.31331339e-01f, -4.43176925e-02f,
  -1.20517518e-02f, -8.14047307e-02f, -1.59580365e-01f, 2.44023576e-02f, 8.06750953e-02f, -8.74997079e-02f, -4.36424986e-02f, -7.75428787e-02f, 4.53010350e-02f, 3.87400761e-03f,
  9.74744558e-02f, -2.51572486e-02f, 8.52737278e-02f, 1.13558225e-01f, 1.68248132e-01f, 2.67023202e-02f, 5.01467437e-02f, -7.82281011e-02f, 1.03135742e-01f, 2.06883866e-02f,
  -6.24013878e-02f, -1.13015048e-01f, -1.29965499e-01f, 6.95606694e-02f, 1.92691758e-02f, -7.37484470e-02f, -1.27045378e-01f, -1.80674419e-01f, 1.23840356e-02f, 4.43847701e-02f,
  6.80929562e-03f, -1.11230709e-01f, 3.98114957e-02f, 5.87043315e-02f, -1.83564909e-02f, 8.04702472e-03f, 1.64460652e-02f, -1.03640640e-02f, -3.41196135e-02f, 8.71250592e-03f,
  -8.41825530e-02f, 1.84838757e-01f, -7.50154781e-04f, 9.00841728e-02f, -1.12328745e-01f, -2.96447203e-02f, 8.50499272e-02f, -1.11520462e-01f, -1.25155196e-01f, -2.14263629e-02f,
  -8.65069181e-02f, -3.99246439e-02f, 6.56031221e-02f, 4.34738323e-02f, -8.58640000e-02f, -1.67203799e-01f, -7.48733804e-02f, -1.17963299e-01f, -5.99190742e-02f, -1.77715182e-01f,
  -1.41217515e-01f, -2.23649308e-01f, -2.44875029e-01f, -1.11405052e-01f, -7.27311745e-02f, -7.50764459e-02f, -7.33600482e-02f, -6.69275895e-02f, -5.54122142e-02f, 3.62308137e-03f,
  -4.39602077e-01f, 1.65525675e-02f, -1.89838767e-01f, 2.93052554e-01f, 3.72772813e-01f, 3.79245281e-01f, 2.57491052e-01f, 2.97048777e-01f, 2.11913779e-01f, 1.89732596e-01f,
  1.66310742e-01f, 3.08221012e-01f, 3.14649940e-01f, 2.42132783e-01f, 2.52964705e-01f, 2.34300345e-01f, 2.60448515e-01f, 6.89167827e-02f, 9.15062502e-02f, 1.84499845e-01f,
  3.32835674e-01f, 1.12102054e-01f, -8.64735246e-02f, 1.74462691e-01f, 1.11696430e-01f, 2.75702655e-01f, 1.55068144e-01f, 2.96492606e-01f, 2.29291067e-01f, 1.26034692e-01f,
  1.90062113e-02f, -1.43543586e-01f, 8.81494731e-02f, -1.80357415e-02f, -7.27147982e-02f, -2.38560930e-01f, -5.61954677e-02f, -8.02046880e-02f, -1.47115022e-01f, -1.66219342e-02f,
  -6.08924031e-02f, -9.77760553e-02f, -8.58522952e-02f, -4.66653816e-02f, -7.91874081e-02f, -2.14179158e-01f, -1.58208340e-01f, 2.11347193e-02f, 1.83150917e-01f, -7.66620263e-02f,
  5.08212335e-02f, -1.80094149e-02f, -1.24898907e-02f, 1.41057774e-01f, 1.33749291e-01f, 3.16180401e-02f, -1.47531433e-02f, -5.69876768e-02f, -8.33666027e-02f, -2.91126538e-02f,
  1.74713597e-01f, 5.23857884e-02f, 5.43427058e-02f, -4.87718917e-02f, -1.65855419e-02f, -8.43212530e-02f, 3.76925170e-02f, 1.58847228e-01f, 9.54084992e-02f, -1.57910155e-03f,
  4.96707708e-02f, 2.05300510e-01f, 7.50282705e-02f, -3.76109146e-02f, -1.95661131e-02f, -1.12411566e-01f, -8.98590311e-02f, -2.87069660e-02f, -1.24687724e-01f, -6.99642003e-02f,
  -7.80531615e-02f, -8.68771449e-02f, -1.61078811e-01f, -3.94354425e-02f, -2.39392594e-02f, 2.93901153e-02f, -3.25512625e-02f, 7.14001209e-02f, -8.58908147e-02f, -3.32742892e-02f,
  3.75460744e-01f, 2.06813142e-01f, -6.52937964e-02f, -3.07033472e-02f, -1.43157318e-01f, -2.39235982e-01f, 1.99642144e-02f, -8.74710605e-02f, -3.75056192e-02f, 2.34970497e-03f,
  -3.25220749e-02f, -2.82793909e-01f, -1.39167994e-01f, -1.66775808e-01f, -1.59615263e-01f, -6.25935346e-02f, -1.13436598e-02f, 4.00890596e-02f, 1.66485161e-01f, -9.72221792e-02f,
  1.73515249e-02f, 1.10854983e-01f, 5.24321720e-02f, 6.22386634e-02f, 5.90337552e-02f, 1.63751915e-02f, -9.56294779e-03f, -1.29069194e-01f, -3.34804412e-03f, 8.14827811e-03f,
  -2.80695319e-01f, 3.83463919e-01f, 3.49698275e-01f, -1.84135184e-01f, 6.75838292e-02f, 2.89336473e-01f, 4.39853966e-01f, 5.15673235e-02f, -1.20315157e-01f, 2.44428903e-01f,
  2.10167810e-01f, -3.15048903e-01f, -9.49253291e-02f, -1.90190911e-01f, 8.69536714e-04f, 3.75392824e-01f, 2.29552314e-01f, -1.92296311e-01f, -3.67777884e-01f, -2.95533746e-01f,
  -1.84097603e-01f, -2.69377619e-01f, -3.94979596e-01f, -9.30340588e-02f, -6.04206324e-02f, -2.62164474e-01f, 2.76100695e-01f, -4.08549141e-03f, 2.81865507e-01f, 1.36565432e-01f,
  -1.38409004e-01f, 1.77965701e-01f, -2.33383954e-01f, -2.21741036e-01f, -4.59631979e-02f, -1.22992665e-01f, -3.72249633e-02f, -4.96703312e-02f, -2.73872409e-02f, 8.74818787e-02f,
  -6.55501708e-02f, -3.71370055e-02f, 9.49721932e-02f, -1.69462085e-01f, -2.00860903e-01f, -1.24696061e-01f, -6.55048937e-02f, -1.80811271e-01f, -6.02776594e-02f, -5.23470715e-02f,
  7.04085156e-02f, 2.65508909e-02f, 1.29015759e-01f, -1.10549666e-02f, 1.95296451e-01f, -1.90545619e-01f, 3.56424227e-02f, -8.68471414e-02f, 2.55843196e-02f, -2.68310338e-01f,
  -6.02488182e-02f, -3.95270959e-02f, 4.18854132e-02f, -3.52697559e-02f, 1.30246049e-02f, 1.44250654e-02f, 5.53467460e-02f, 6.58991188e-02f, 6.00504084e-03f, 1.60682271e-03f,
  -4.27208515e-03f, -2.91270968e-02f, -5.94960786e-02f, 2.25362763e-01f, -4.51398417e-02f, 5.10549247e-02f, -6.75312011e-03f, -2.48858053e-02f, 1.09360501e-01f, 4.05523507e-03f,
  -5.94813898e-02f, 2.70076860e-02f, -8.43009874e-02f, -2.89590042e-02f, 1.00719519e-01f, -2.71130111e-02f, 1.11579932e-01f, -1.84643388e-01f, -3.79125401e-02f, 5.03219664e-02f,
  -3.00092429e-01f, 2.35405900e-02f, -2.30062574e-01f, -3.02401818e-02f, -1.93689913e-02f, -5.47443591e-02f, -1.25107719e-04f, -1.98139716e-02f, -1.78372636e-02f, -6.32387847e-02f,
  1.21467762e-01f, 2.00658534e-02f, 1.76028565e-01f, -3.07042133e-02f, -7.53997341e-02f, -4.45321649e-02f, 5.16207656e-03f, -5.31467162e-02f, -1.51517704e-01f, -1.16894774e-01f,
  -4.46593128e-02f, -1.31482959e-01f, -3.65855485e-01f, -5.71285076e-02f, -4.75704558e-02f, -2.42368326e-01f, -1.29304484e-01f, -2.86868721e-01f, -1.08384490e-01f, -2.31193528e-01f,
  6.88008726e-01f, 3.10238421e-01f, 3.72426748e-01f, 9.55146700e-02f, -4.56552245e-02f, 1.90474376e-01f, 2.19572574e-01f, 1.56674355e-01f, -1.29883261e-02f, 8.57462958e-02f,
  -1.15308445e-02f, -1.61757678e-01f, -4.10637027e-03f, -3.11042331e-02f, 1.80002645e-01f, 9.22513381e-02f, -1.79433152e-02f, 1.30229607e-01f, 1.97103426e-01f, -2.02561729e-02f,
  -2.89971251e-02f, 1.69220850e-01f, 2.05613568e-01f, 1.76270932e-01f, -1.07255176e-01f, -1.96920142e-01f, 4.10828888e-02f, 1.22478403e-01f, 7.98482969e-02f, -2.58514285e-02f,
  -8.52896571e-02f, 3.48381311e-01f, -2.19215736e-01f, -2.02989519e-01f, 4.74512093e-02f, 3.04124113e-02f, 5.83477272e-03f, 1.30571155e-02f, -1.04929648e-01f, -1.21673174e-01f,
  -1.74508780e-01f, 6.27854094e-02f, 3.39890979e-02f, 8.86051729e-02f, 7.50232637e-02f, -1.46987764e-02f, 1.10418484e-01f, 2.36888528e-01f, 1.07479699e-01f, 7.82544687e-02f,
  -6.23816289e-02f, 8.94300267e-02f, 5.98984733e-02f, 4.47708070e-02f, 7.43280649e-02f, -9.15062800e-02f, 1.42942145e-01f, 6.02901727e-02f, 1.14366785e-01f, 8.84390101e-02f,
  -9.87703651e-02f, 1.86241127e-03f, 2.16390908e-01f, -1.42125301e-02f, 5.48795536e-02f, 1.77293010e-02f, -4.92493957e-02f, 1.11964576e-01f, 8.67964327e-02f, 1.74903989e-01f,
  4.11929842e-03f, 1.37428954e-01f, 1.09263219e-01f, 4.22517806e-02f, -8.61540586e-02f, -4.41410467e-02f, 9.97742172e-03f, 5.22236153e-02f, 1.70297801e-01f, -9.48337838e-03f,
  8.86129737e-02f, -1.01622865e-01f, 6.40020892e-02f, 8.42750594e-02f, -5.64558320e-02f, 3.33894268e-02f, -2.07650587e-02f, 1.60435792e-02f, 3.50238197e-02f, -1.02061480e-01f,
  -3.28475863e-01f, 3.01238596e-01f, -1.88894048e-01f, -1.25417113e-01f, 3.74580175e-02f, -2.73500234e-02f, -6.07457608e-02f, 3.08966059e-02f, -1.05695650e-01f, -1.51527494e-01f,
  -1.04186885e-01f, 3.98463616e-03f, 1.13725901e-01f, 1.43574193e-01f, -9.29879993e-02f, -1.48072213e-01f, 2.01476328e-02f, -1.21713109e-01f, -3.82547341e-02f, -1.78646356e-01f,
  -1.41240254e-01f, -7.85987452e-02f, -5.88540509e-02f, -1.35403022e-01f, -1.62063897e-01f, -3.00585926e-01f, -4.06842157e-02f, -1.31419569e-01f, -5.48442639e-02f, -3.75654772e-02f,
  1.93280965e-01f, -2.86987871e-01f, -4.28615600e-01f, -9.23174992e-02f, 8.24659690e-03f, -2.66856477e-02f, -1.59451112e-01f, -1.77684110e-02f, 5.34252636e-02f, -3.67325038e-01f,
  -9.14864168e-02f, 1.35107964e-01f, -2.50247478e-01f, -1.59774214e-01f, -1.46041498e-01f, -4.56271678e-01f, -3.72322917e-01f, -4.64584716e-02f, 3.04468602e-01f, 3.71925473e-01f,
  2.59745747e-01f, 1.10950612e-01f, 1.32598788e-01f, 1.23124018e-01f, -1.53978124e-01f, 8.18081349e-02f, -3.50428164e-01f, -1.27061263e-01f, -1.23120248e-01f, -3.51834804e-01f,
  -2.27319792e-01f, -2.03338251e-01f, -4.77509424e-02f, 2.05572415e-02f, -1.57802314e-01f, 2.16884032e-01f, 5.73199354e-02f, -1.45827964e-01f, 2.68662926e-02f, -1.41579568e-01f,
  -4.62142006e-02f, 7.66687989e-02f, 1.43497035e-01f, 2.88628209e-02f, 2.06211582e-02f, 1.55995622e-01f, -1.12315923e-01f, -1.47793338e-01f, -1.29874945e-01f, -8.04625601e-02f,
  -3.78086162e-03f, -1.03517463e-02f, -8.54567364e-02f, -2.04777926e-01f, -1.81967780e-01f, -1.50191903e-01f, -7.28167966e-02f, 7.35594854e-02f, -5.96876219e-02f, -1.15100637e-01f,
  -6.30060956e-02f, -5.83487004e-02f, -5.85628115e-02f, 1.28341973e-01f, 1.42538458e-01f, -3.89301330e-02f, -1.29817262e-01f, -1.32628068e-01f, 6.35917261e-02f, 6.02116995e-02f,
  -7.01609403e-02f, -7.96668679e-02f, -4.08453681e-02f, -6.94474801e-02f, -5.25302216e-02f, -6.96113631e-02f, -1.37003183e-01f, -9.65388119e-02f, 7.97256269e-03f, -5.68498448e-02f,
  1.13193668e-01f, 1.35193318e-01f, -1.33109450e-01f, 9.23161283e-02f, -1.75528869e-01f, -6.97375089e-02f, -5.63782565e-02f, 4.41065133e-02f, 6.48798943e-02f, -3.10603678e-02f,
  -1.73205316e-01f, -2.39289477e-01f, -2.99690992e-01f, -1.26927540e-01f, -7.14864284e-02f, -1.82464458e-02f, -7.05124512e-02f, 1.09622560e-01f, -8.46039280e-02f, 4.69438136e-02f,
  1.21546127e-01f, -1.04224876e-01f, -1.38292611e-01f, -3.49390656e-02f, 1.03083886e-01f, 1.32103279e-01f, -4.43382710e-02f, -8.43310356e-02f, 1.40614491e-02f, 2.44256735e-01f,
  -3.12625244e-02f, -1.30717112e-02f, -5.28835831e-03f, -1.89901024e-01f, 3.92130129e-02f, 4.16127183e-02f, -1.02762967e-01f, 5.10872938e-02f, -2.62849983e-02f, -1.60242006e-01f,
  5.00741303e-01f, 3.69410902e-01f, 2.67574247e-02f, 9.18590501e-02f, 1.00345604e-01f, 7.08623156e-02f, 2.07133442e-01f, 9.43959355e-02f, 1.53075933e-01f, 2.30434895e-01f,
  2.49205619e-01f, 1.09304406e-01f, 8.01988170e-02f, 2.05310628e-01f, 8.07987750e-02f, -4.97843735e-02f, 1.48840025e-02f, 6.73137382e-02f, 7.35050589e-02f, 1.23892911e-01f,
  -2.24800482e-02f, 4.18441854e-02f, 7.19349161e-02f, -4.73270305e-02f, 4.84117568e-02f, 1.13097414e-01f, -2.77692365e-04f, 2.66481955e-02f, 1.09606810e-01f, 7.79659003e-02f,
  -1.62586972e-01f, 8.93529505e-02f, 4.36599553e-03f, -1.32342884e-02f, -9.31291953e-02f, 4.34955582e-02f, -8.66349265e-02f, -1.97035093e-02f, -1.23474682e-02f, -1.71217710e-01f,
  -5.70836030e-02f, -4.22402248e-02f, -2.16866121e-01f, -9.39381123e-02f, -1.14305116e-01f, -5.18606529e-02f, -1.47278029e-02f, 6.44900948e-02f, 3.33569162e-02f, -1.95171367e-02f,
  2.05939431e-02f, -8.21686313e-02f, -2.02705413e-01f, -3.40325274e-02f, 3.93542424e-02f, -9.94435474e-02f, -5.18739186e-02f, 2.73695011e-02f, 6.18450567e-02f, 9.77657661e-02f,
  1.39979739e-02f, 5.46266325e-02f, -1.08327754e-01f, -2.01053992e-02f, -6.70129433e-02f, 4.14184518e-02f, -1.12988286e-01f, -1.03735998e-01f, -2.96015963e-02f, -8.04407448e-02f,
  -7.42349848e-02f, -1.04320206e-01f, -2.10539531e-03f, -2.03816012e-01f, -2.19453834e-02f, 3.16250362e-02f, 3.78063470e-02f, -5.54889031e-02f, -2.02971444e-01f, -3.61400582e-02f,
  -1.38590023e-01f, 6.73625544e-02f, -1.14085980e-01f, -1.60094082e-01f, 3.53766722e-03f, -3.00878137e-02f, -1.16282813e-01f, -1.46747798e-01f, -1.58325195e-01f, -6.60946518e-02f,
  -1.83299378e-01f, -2.45552406e-01f, -9.20536462e-03f, 8.58628601e-02f, 9.18042585e-02f, 6.70166463e-02f, 7.81549793e-03f, 4.88154814e-02f, -5.85157387e-02f, -6.01933002e-02f,
  -7.02236891e-02f, -7.01586381e-02f, -1.22407697e-01f, -8.60230029e-02f, -4.37856801e-02f, -1.33094519e-01f, 1.93111047e-01f, 9.48678926e-02f, 1.11390300e-01f, 1.14733063e-01f,
  1.14362210e-01f, -2.54587433e-03f, -1.39238592e-02f, 1.04285758e-02f, -4.87284036e-03f, 3.79161909e-02f, 2.66462937e-02f, 9.74344015e-02f, 2.87768394e-02f, -6.72781542e-02f,
  -1.23268083e-01f, -1.52850911e-01f, -1.36595950e-01f, 9.25923809e-02f, 1.65810227e-01f, -1.41501680e-01f, -4.76984501e-01f, -3.57694685e-01f, 6.90183491e-02f, 6.27784729e-02f,
  8.24978873e-02f, 2.98833996e-01f, 9.26717147e-02f, 5.48622161e-02f, -3.52516770e-01f, -1.92097813e-01f, -1.22256931e-02f, -1.03085756e-01f, -4.31221463e-02f, -6.04958534e-02f,
  2.82466024e-01f, 2.85156012e-01f, 1.71396583e-01f, -1.72903053e-02f, 1.84441879e-01f, 1.24295160e-01f, 1.23373397e-01f, 2.06673235e-01f, 1.31898880e-01f, 9.74148586e-02f,
  5.07755876e-02f, -1.76114410e-01f, -8.87030065e-02f, 1.72527984e-01f, 1.98768407e-01f, -4.81335111e-02f, -8.70104432e-02f, -2.86079757e-02f, 1.26697472e-03f, -4.83899042e-02f,
  5.00325523e-02f, 6.46531656e-02f, 8.09222385e-02f, 8.38932246e-02f, 7.39531070e-02f, -1.33862868e-01f, -8.01909715e-02f, -2.17289120e-01f, -2.44683385e-01f, 7.27947988e-03f,
  1.07831001e-01f, 1.50769249e-01f, -3.21830273e-01f, -2.02229872e-01f, -2.28131995e-01f, -1.10476147e-02f, -1.75453052e-01f, -1.77970573e-01f, -2.26635441e-01f, -1.89418755e-02f,
  -3.86186764e-02f, 4.53449003e-02f, -1.43134762e-02f, -8.79591927e-02f, -5.28989807e-02f, -2.54110470e-02f, 6.36273669e-03f, -2.28399932e-02f, 4.94925827e-02f, -1.13431431e-01f,
  5.83481602e-02f, -5.06690182e-02f, 6.69195130e-02f, 4.33836244e-02f, 1.48843661e-01f, -8.96914005e-02f, 1.28245484e-02f, -6.18484151e-03f, 2.11432092e-02f, 2.77920216e-02f,
  -1.15585633e-01f, -1.36107042e-01f, 2.34715253e-01f, -1.41346335e-01f, -4.04897295e-02f, -1.78476006e-01f, 4.26850803e-02f, 2.29359847e-02f, -4.50308099e-02f, 8.21402520e-02f,
  2.51082212e-01f, -4.31802720e-02f, -1.83506072e-01f, -2.16631070e-01f, 3.59268263e-02f, 9.23974663e-02f, -6.79953536e-03f, -5.93326278e-02f, -9.03898254e-02f, -8.38928148e-02f,
  -1.09004937e-01f, -1.02880374e-01f, 2.07316697e-01f, -9.97639224e-02f, -2.07720418e-02f, 9.48972404e-02f, -1.20903952e-02f, -1.58924729e-01f, -8.04373696e-02f, 8.37373957e-02f,
  -2.01794639e-01f, -1.35916531e-01f, -1.42312780e-01f, -3.09626251e-01f, 7.48877749e-02f, -8.71624425e-02f, -5.63755073e-02f, -1.42682567e-01f, -8.43642578e-02f, -1.60758510e-01f,
  3.64296943e-01f, -3.72494727e-01f, 1.99301705e-01f, 1.72344491e-01f, -2.28871688e-01f, -2.58608341e-01f, -4.78317976e-01f, -3.54381830e-01f, -1.43818811e-01f, -1.51792541e-01f,
  -1.40465379e-01f, 4.86419238e-02f, 9.23219845e-02f, 2.14419127e-01f, 1.13935776e-01f, -1.04550965e-01f, 6.32961914e-02f, 4.82401848e-01f, 3.05954784e-01f, 2.98916977e-02f,
  -2.58496273e-02f, 3.59372459e-02f, 3.12982351e-01f, 2.62813956e-01f, 1.49847195e-02f, 2.00486779e-01f, -1.56551022e-02f, -4.27647531e-02f, 2.79622525e-02f, 1.89420998e-01f,
  2.30927300e-02f, -1.11289054e-01f, 9.84419808e-02f, 1.07794844e-01f, 1.18183561e-01f, 7.33607933e-02f, -2.90814377e-02f, 8.64787698e-02f, -7.98298195e-02f, 2.36678999e-02f,
  4.04289179e-02f, 5.32990322e-02f, -1.42222103e-02f, 7.18722865e-02f, 1.58592183e-02f, 4.04730104e-02f, 4.08968739e-02f, 8.92621872e-04f, -2.35002721e-03f, 3.41633894e-02f,
  1.64536275e-02f, -1.10984676e-01f, 2.03693025e-02f, -1.71969414e-01f, -4.77948599e-02f, 2.01688990e-01f, 6.00414351e-03f, 3.35658565e-02f, 1.29114892e-02f, -1.03635646e-01f,
  -2.22881604e-02f, 6.58067549e-03f, 5.69370911e-02f, -2.00442616e-02f, -6.37962809e-03f, -4.76602353e-02f, 1.56442896e-02f, -1.30319163e-01f, 1.23564795e-01f, 4.77469712e-02f,
  1.33083677e-02f, 2.23652925e-02f, -3.08667477e-02f, 4.52491641e-02f, 7.48429298e-02f, 1.82795133e-02f, 5.85887879e-02f, 2.58004460e-02f, 1.13850780e-01f, 4.64367382e-02f,
  9.02466699e-02f, -9.65214148e-03f, 3.41780484e-02f, 1.60351321e-02f, -1.61837961e-03f, 4.43478972e-02f, 1.18254595e-01f, -6.52134120e-02f, -7.04536587e-02f, 1.25535047e-02f,
  -2.68290609e-01f, 1.35190755e-01f, 5.52634783e-02f, 1.60197560e-02f, -6.77747186e-03f, 3.46396752e-02f, 2.12281700e-02f, 1.33559136e-02f, 2.38389429e-02f, -5.35119744e-03f,
  -1.10536702e-02f, -4.91300635e-02f, -1.33632451e-01f, -2.20440747e-03f, -6.67178556e-02f, -8.18360671e-02f, -3.48359533e-02f, -1.51340775e-02f, -6.77015781e-02f, 3.99706364e-02f,
  -1.82666611e-02f, -1.98743418e-01f, -1.35091603e-01f, -2.02895656e-01f, -1.13642327e-01f, 6.35867892e-03f, -1.09513022e-01f, -1.35888115e-01f, -9.62825939e-02f, -3.15024376e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -1.11120425e-01f, 5.26139736e-01f, 1.11108683e-01f, 4.69058156e-01f, 2.82531142e-01f, 3.06732118e-01f, 4.79567163e-02f, 3.22278291e-01f, 3.66067439e-01f, 3.66332144e-01f,
  1.77360326e-01f, 4.53888893e-01f, 3.04722190e-01f, 2.18146622e-01f, 1.78334191e-01f, 5.29746890e-01f, 1.27131358e-01f, 3.30855519e-01f, 1.97124913e-01f, -9.92031768e-03f,
  2.14160725e-01f, 3.04317355e-01f, 2.14131415e-01f, 2.41441548e-01f, 5.51896334e-01f, 5.04632115e-01f, 3.45312059e-01f, 1.35991395e-01f, 2.90747732e-01f, 1.99776754e-01f,
  1.53616205e-01f, 8.60204473e-02f, 3.96117896e-01f, 1.70585543e-01f, 3.40883195e-01f, 3.49740744e-01f, 1.24346390e-01f, -1.12494700e-01f, 2.00140491e-01f, 3.39018136e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  9.93907452e-02f, 9.21392813e-02f, 1.57070190e-01f, -5.89912161e-02f, -2.90039345e-03f, 9.75069478e-02f, 1.64370641e-01f, -5.69493957e-02f, -1.03291951e-01f, 8.31943899e-02f,
  -1.20566204e-01f, -8.03154707e-02f, -3.94158401e-02f, 2.41787300e-01f, 4.72569913e-02f, -1.39022261e-01f, 8.58455002e-02f, -4.14849073e-02f, -3.99876237e-02f, -5.13571948e-02f,
  -6.73219860e-02f, 1.74194723e-01f, -2.42908522e-01f, 1.41751528e-01f, -5.56556433e-02f, 1.31331235e-01f, -3.38595710e-03f, -2.20125943e-01f, -1.11729205e-02f, 2.00203791e-01f,
  -8.16833973e-02f, 4.90273945e-02f, 3.50128382e-01f, -3.12840194e-02f, 1.34236008e-01f, 8.75527039e-02f, 1.10728934e-01f, -7.27160871e-02f, -1.01537995e-01f, -2.14731649e-01f,
  1.32954270e-01f, -1.29752666e-01f, -1.51687339e-01f, -1.02746978e-01f, -2.06257731e-01f, -5.91391064e-02f, -1.18782595e-02f, 1.16011865e-01f, -8.33178014e-02f, 2.41931036e-01f,
  1.87336639e-01f, 2.68749148e-01f, -1.25980529e-04f, -4.03581299e-02f, 4.73698564e-02f, -1.76554829e-01f, 1.13141887e-01f, 2.19896212e-02f, -2.40213826e-01f, 8.95294026e-02f,
  1.78421021e-01f, -1.46043450e-01f, -2.18057632e-03f, 1.36435300e-03f, 6.83501065e-02f, -5.14836982e-02f, -7.30676204e-02f, 9.48726945e-03f, 9.28282663e-02f, 1.22043816e-03f,
  -2.53678504e-02f, -1.41784977e-02f, 1.07143912e-02f, -1.00460667e-02f, -5.10422140e-02f, -1.49430707e-02f, 1.66986451e-01f, 7.38802971e-03f, -5.11918589e-02f, 9.23669711e-02f,
  -5.72211947e-03f, -4.02155109e-02f, 1.13120653e-01f, 9.62983891e-02f, 1.13237910e-01f, -1.70035034e-01f, -8.25753659e-02f, -1.84252802e-02f, -7.71367773e-02f, 1.05858281e-01f,
  -2.04733029e-01f, 8.56167600e-02f, 1.56653658e-01f, 8.48651230e-02f, 6.97662681e-02f, 6.27627224e-02f, 9.28194150e-02f, 7.28737563e-02f, -1.59289792e-01f, -1.11711852e-01f,
  -7.00550079e-02f, 1.15352109e-01f, -1.80113629e-01f, 3.04313689e-01f, -2.38371596e-01f, 9.58674327e-02f, 1.40265658e-01f, -5.10401987e-02f, 6.37520105e-02f, -1.59670096e-02f,
  2.90945083e-01f, -1.40698537e-01f, 2.58538157e-01f, -2.40115225e-01f, -3.30327123e-01f, -3.26178223e-01f, 4.69586253e-02f, 1.30616367e-01f, -2.08219230e-01f, 1.86320990e-02f,
  4.06350568e-02f, -1.04664177e-01f, 1.51229024e-01f, -7.31198117e-02f, -1.99822277e-01f, -1.64010212e-01f, -2.04048958e-02f, 1.92127675e-02f, -8.39232188e-03f, -1.78414229e-02f,
  -9.04575177e-03f, 3.89599167e-02f, 3.96678448e-02f, -1.71654746e-01f, -1.30164251e-01f, 1.59084752e-01f, 6.90545589e-02f, -1.03882566e-01f, -1.09005962e-02f, 1.06035300e-01f,
  8.36600065e-02f, -1.17919967e-03f, -3.55688557e-02f, -5.41325212e-02f, -1.05911188e-01f, 1.17149428e-01f, -1.77232176e-01f, -2.08768740e-01f, -1.18268810e-01f, 1.58720985e-01f,
  -6.05342612e-02f, -7.13472590e-02f, 1.83949575e-01f, 5.74691482e-02f, 1.22071661e-01f, -3.01036477e-01f, -1.06762059e-01f, 2.25500569e-01f, -7.07474425e-02f, -1.39832953e-02f,
  1.02271006e-01f, 4.30868790e-02f, -1.12771124e-01f, 3.40153277e-02f, 1.04745723e-01f, -6.35236204e-02f, -3.64105888e-02f, -2.50956804e-01f, 1.62296355e-01f, -5.01790047e-02f,
  6.80056810e-02f, 8.92103836e-02f, -1.49852097e-01f, 4.24865410e-02f, -2.12103203e-01f, -2.58723974e-01f, -1.88613385e-01f, -1.67517230e-01f, 7.43064210e-02f, 3.99214745e-01f,
  -8.74389410e-02f, -4.43172865e-02f, 5.69127500e-02f, -7.04106234e-04f, -4.06377576e-02f, 1.58798575e-01f, -4.18192983e-01f, -3.82193252e-02f, 2.14063510e-01f, -4.98841442e-02f,
  1.40468955e-01f, 1.95410207e-01f, -4.29528914e-02f, -3.49771115e-03f, 1.08304843e-01f, -7.16575533e-02f, 7.64196515e-02f, -1.44674048e-01f, -7.70933852e-02f, 5.10877706e-02f,
  8.59637037e-02f, -2.15974953e-02f, -4.92518991e-02f, 9.12135169e-02f, 1.02850974e-01f, -5.94058223e-02f, -3.93456258e-02f, 1.38256684e-01f, -1.28206626e-01f, 3.32760960e-02f,
  1.54799804e-01f, -4.96511683e-02f, 9.90304723e-02f, -8.25819150e-02f, 4.53908928e-02f, -1.70613065e-01f, 5.64548839e-03f, 2.11289123e-01f, 1.34495301e-02f, -1.55604957e-03f,
  -3.61901261e-02f, -3.14183696e-03f, -2.94310451e-02f, -3.04369152e-01f, -2.19113752e-01f, -1.02244802e-01f, -8.58708248e-02f, 1.42038867e-01f, 1.41664788e-01f, 2.43573621e-01f,
  1.85157701e-01f, -1.48935571e-01f, 7.78597817e-02f, 3.09791684e-01f, 9.94787887e-02f, 1.75114930e-01f, -4.54325713e-02f, 4.77547646e-02f, 1.08563185e-01f, 9.29796100e-02f,
  -2.75450885e-01f, -1.24661386e-01f, -8.72322395e-02f, 9.48450044e-02f, 7.41910189e-02f, 1.13305422e-02f, 1.13255084e-01f, 1.40183032e-01f, -5.44464849e-02f, -1.21925153e-01f,
  -1.23318583e-01f, 2.80464143e-01f, 1.25934422e-01f, 5.98443523e-02f, 9.46685970e-02f, 7.05586001e-02f, 1.42309852e-02f, -2.88275033e-02f, -3.41056958e-02f, -1.69030696e-01f,
  6.66069658e-03f, -1.35442540e-01f, -1.52680591e-01f, 9.25422385e-02f, -3.86207588e-02f, -6.70219027e-03f, -9.93125290e-02f, 4.30567414e-02f, 6.15277179e-02f, -9.62295756e-02f,
  1.00515895e-01f, 6.01132959e-03f, 1.77481282e-03f, -1.91849768e-01f, -7.44083822e-02f, -3.12125627e-02f, -7.11382702e-02f, -8.89729634e-02f, 3.66867259e-02f, -1.47772446e-01f,
  2.80223072e-01f, 6.47569075e-02f, 1.92697972e-01f, 1.09151207e-01f, -6.20317049e-02f, -1.92435712e-01f, 9.56280679e-02f, -3.69662970e-01f, -3.06716263e-01f, -9.17703137e-02f,
  -7.41834268e-02f, 7.97883645e-02f, 1.29193841e-02f, -1.66690350e-01f, 1.11274265e-01f, -1.45805344e-01f, 6.39610887e-02f, -2.18512751e-02f, 7.92220533e-02f, 1.00747101e-01f,
  -3.81906517e-02f, -5.81320971e-02f, -1.20610255e-03f, -1.80980071e-01f, 2.21492331e-02f, -1.26693904e-01f, 4.72181402e-02f, 2.77759135e-01f, -3.51264328e-01f, -2.06503883e-01f,
  1.99752674e-01f, 1.31561235e-01f, -1.21847890e-01f, -3.73178683e-02f, -2.11888358e-01f, 4.62201471e-03f, 1.69737607e-01f, 1.05884217e-01f, -1.01426952e-01f, 6.88945595e-03f,
  -1.33355737e-01f, 9.15188938e-02f, -1.22951657e-01f, 1.16933912e-01f, 1.46066826e-02f, 2.92821713e-02f, 7.63474628e-02f, 9.50740948e-02f, -6.05930537e-02f, -3.24157886e-02f,
  -1.34533510e-01f, -7.19333589e-02f, -1.25259191e-01f, 6.66543767e-02f, 9.83864665e-02f, 1.12543955e-01f, 1.21428683e-01f, -8.47846642e-02f, -4.82110493e-03f, 4.12722193e-02f,
  1.25283673e-01f, 5.41887879e-02f, -1.35122659e-02f, 1.86665431e-01f, -9.47669894e-02f, 1.73003063e-01f, 3.10852975e-02f, 9.93245095e-02f, 6.21167431e-03f, -9.04049724e-02f,
  3.13839801e-02f, 2.66876876e-01f, 1.09767407e-01f, -1.33044943e-01f, 1.13710031e-01f, 1.16829701e-01f, -2.52459478e-02f, -1.59397155e-01f, -1.80984631e-01f, -2.37092245e-02f,
  -1.47061184e-01f, 5.01262806e-02f, -8.42851773e-02f, -8.35231971e-03f, -1.16886944e-01f, -1.75407737e-01f, 4.19409908e-02f, 1.33725226e-01f, 2.61124581e-01f, 1.44160748e-01f,
  -2.90338635e-01f, -2.96884865e-01f, 3.11721295e-01f, -7.53278956e-02f, -1.61972374e-01f, -1.76654905e-01f, -9.11857039e-02f, -8.82571489e-02f, 2.69931644e-01f, 1.04862943e-01f,
  -2.79251605e-01f, 2.04538200e-02f, -9.88219306e-03f, -4.13272791e-02f, -3.92562756e-03f, -5.72188981e-02f, 2.67216474e-01f, -1.01150550e-01f, -5.30549847e-02f, 5.87464832e-02f,
  -2.68600713e-02f, -8.82228315e-02f, -2.40459908e-02f, -8.44005123e-02f, 1.01565234e-01f, 7.09498599e-02f, -8.61199871e-02f, -8.67525488e-02f, -6.62800223e-02f, -2.64132908e-03f,
  -4.94797863e-02f, 1.87820811e-02f, -1.44071639e-01f, -1.29477918e-01f, -9.06653404e-02f, 2.40073949e-02f, -1.04978435e-01f, 4.59088758e-02f, 6.10427037e-02f, -2.14234546e-01f,
  2.18610510e-01f, 3.42978872e-02f, -1.65320992e-01f, -7.84689039e-02f, 1.74627751e-01f, -2.39126042e-01f, -1.16262928e-01f, 4.92159836e-02f, 1.16873220e-01f, 5.10268174e-02f,
  6.36869529e-03f, -2.25297630e-01f, 7.22438470e-03f, 8.50107893e-02f, 3.11302450e-02f, -2.78651536e-01f, -1.40413910e-01f, -1.07981423e-02f, -4.80087809e-02f, -1.34719029e-01f,
  -2.12732539e-01f, -1.73750132e-01f, 1.91362694e-01f, 1.92840129e-01f, -3.09165269e-02f, 2.77292520e-01f, -2.75632739e-01f, -1.62363306e-01f, 1.27471969e-01f, 4.63719256e-02f,
  -1.36158153e-01f, 1.60103828e-01f, -1.25309765e-01f, -1.03829309e-01f, 2.20563754e-01f, 1.13071226e-01f, -1.33515835e-01f, -1.22086391e-01f, 1.00047074e-01f, 1.20239228e-01f,
  1.96267795e-02f, 8.65174308e-02f, -4.40675952e-02f, 1.13172531e-02f, 6.21616561e-03f, -1.85167380e-02f, 1.63269997e-01f, -3.02549843e-02f, 1.25173524e-01f, 1.00301668e-01f,
  -1.10377176e-02f, -4.30216193e-01f, 7.30965883e-02f, 5.41844917e-03f, -7.26328343e-02f, -1.76761523e-01f, -1.23116143e-01f, -2.56131828e-01f, -2.00173169e-01f, -2.03099195e-02f,
  -1.20393233e-02f, 2.51831822e-02f, 7.16822967e-03f, 2.74601847e-01f, -8.00947007e-03f, 1.36805117e-01f, -1.35308579e-01f, -2.27295205e-01f, -1.14416741e-01f, -4.39019173e-01f,
  -1.89574674e-01f, -2.34524116e-01f, -1.48626521e-01f, -4.35437523e-02f, 1.15297444e-01f, 2.68528238e-02f, 2.23501787e-01f, 3.63980383e-02f, 1.76177055e-01f, -1.59009784e-01f,
  4.54938710e-02f, 8.03866610e-02f, -4.94021177e-02f, -7.34514520e-02f, -2.33326614e-01f, -2.69307494e-01f, -3.11786942e-02f, 8.70034024e-02f, 2.55345404e-01f, 3.96480531e-01f,
  -1.96688667e-01f, -1.00801878e-01f, 2.00886697e-01f, 1.55993685e-01f, 6.50538355e-02f, -1.23761244e-01f, -1.22027799e-01f, 2.77249962e-01f, 2.02954501e-01f, -4.40961607e-02f,
  6.10786770e-03f, 1.99809745e-02f, -4.45853807e-02f, 3.73958461e-02f, -9.38056707e-02f, -6.86896294e-02f, -5.81156164e-02f, -4.52854633e-02f, 1.24172613e-01f, 6.18444346e-02f,
  -6.16841167e-02f, 3.64307612e-02f, -6.28848672e-02f, 5.64394034e-02f, -1.22374699e-01f, 4.60422784e-02f, -4.27297205e-02f, -6.41609728e-02f, 1.02393150e-01f, -8.37424304e-03f,
  -1.07945569e-01f, -1.16565242e-01f, -2.07475200e-01f, -1.47542149e-01f, -1.72373891e-01f, -1.20105721e-01f, -1.78439140e-01f, 2.24739723e-02f, 1.31970011e-02f, -2.00137898e-01f,
  -1.27238914e-01f, 1.71170890e-01f, -1.21139981e-01f, -3.27342935e-02f, 8.37677196e-02f, 1.09855160e-01f, 2.14623343e-02f, -1.11445233e-01f, 1.13353156e-01f, 3.31566185e-02f,
  -5.04186936e-02f, 1.21857531e-01f, -2.67924126e-02f, 7.41084218e-02f, -8.49144235e-02f, -1.61000088e-01f, 5.24779484e-02f, -2.85833389e-01f, -2.66546905e-01f, -2.65624136e-01f,
  1.90065578e-01f, 1.61077827e-01f, -8.12126137e-03f, -2.56670177e-01f, 1.12665944e-01f, 5.91949299e-02f, -1.57589167e-01f, 1.10900186e-01f, 8.61372799e-02f, -1.79880425e-01f,
  7.87600502e-02f, 1.58443779e-01f, 1.23674221e-01f, -1.22183412e-01f, -1.04052927e-02f, -1.60541221e-01f, -2.73997579e-02f, 4.77823280e-02f, 8.70141760e-02f, 5.69497515e-03f,
  -6.89689964e-02f, 1.51588306e-01f, 1.65296614e-01f, -1.08513981e-01f, 2.44240984e-02f, 5.28088249e-02f, -7.97957629e-02f, -1.36849470e-02f, -1.21292911e-01f, 6.25878721e-02f,
  -1.12043228e-02f, 4.11234871e-02f, 7.82612420e-04f, -2.05021545e-01f, 7.19024613e-02f, 1.01126105e-01f, -3.48997712e-02f, 2.70508714e-02f, -1.26174670e-02f, 6.91844895e-02f,
  -2.23815084e-01f, 4.86217905e-03f, 6.37506647e-03f, -2.86849327e-02f, -7.10420236e-02f, 4.40975428e-02f, -1.15396474e-02f, 2.59381264e-01f, 3.44680250e-01f, -7.09318146e-02f,
  3.18520844e-01f, -7.30812410e-03f, 2.46884730e-02f, -1.20158657e-01f, -1.09578818e-02f, -1.12378731e-01f, -1.95202246e-01f, -1.22031458e-01f, -1.67503893e-01f, -4.85822521e-02f,
  -7.63204098e-02f, -5.49483709e-02f, 8.19834042e-03f, 8.26568529e-02f, 6.33628294e-02f, 3.31710994e-01f, -5.50929792e-02f, -4.65388447e-02f, 2.46501803e-01f, -2.60806113e-01f,
  -1.02524325e-01f, -5.27034365e-02f, -5.37882671e-02f, -5.74611239e-02f, 1.97883844e-01f, 8.86080191e-02f, -2.31731683e-01f, -2.06921622e-03f, -1.97103068e-01f, 1.02920249e-01f,
  -4.32719178e-02f, -7.42062032e-02f, 1.64146796e-02f, 3.76683883e-02f, -1.01028450e-01f, -4.31639776e-02f, -1.51495248e-01f, -8.18223581e-02f, -3.35047580e-02f, -6.29919395e-02f,
  1.03208169e-01f, -1.24644808e-01f, 5.24072573e-02f, -1.22447252e-01f, -9.35399532e-03f, 5.43405227e-02f, -1.81813151e-01f, 1.17034733e-01f, -1.38302803e-01f, -8.71203393e-02f,
  -1.68519672e-02f, 7.73561969e-02f, -5.94063895e-04f, 1.72473133e-01f, 2.32921064e-01f, -1.67417735e-01f, -1.20383866e-01f, 1.15848467e-01f, 7.27095082e-02f, -4.65959273e-02f,
  -5.26836254e-02f, -5.40412515e-02f, -2.98693985e-01f, 1.76281016e-02f, -2.29896978e-01f, 1.51009485e-02f, 2.42430151e-01f, 2.92276852e-02f, 1.02892928e-01f, -6.53473213e-02f,
  -1.48236621e-02f, 7.01707378e-02f, 5.07040098e-02f, 1.63987190e-01f, 2.73044854e-02f, 1.80200636e-01f, 3.03789794e-01f, -5.09166159e-04f, -1.11595578e-02f, 4.31957617e-02f,
  2.07561344e-01f, 5.52489944e-02f, 3.77193429e-02f, -3.44505943e-02f, -5.93976537e-03f, -2.60504484e-01f, -2.75125980e-01f, 1.95466861e-01f, -2.12947994e-01f, -2.40748867e-01f,
  -1.27978295e-01f, 2.08169818e-02f, 2.50028640e-01f, 1.49858743e-01f, 6.80022612e-02f, -9.91087109e-02f, 1.64511204e-01f, -1.14042386e-01f, -8.17302242e-03f, 8.43890384e-02f,
  -1.61764729e-06f, -3.61967906e-02f, 2.47252788e-02f, -1.30999740e-02f, -5.61805554e-02f, 1.00723937e-01f, 5.09503782e-02f, -4.03792113e-02f, 1.90588549e-01f, 4.13238304e-03f,
  2.03206986e-01f, 1.18433550e-01f, 5.79336248e-02f, -3.44224684e-02f, 9.17890221e-02f, -1.21491440e-01f, 3.08750439e-02f, -3.75359994e-03f, -6.80916309e-02f, -1.95557579e-01f,
  1.38681158e-01f, -5.10034673e-02f, -1.59816802e-01f, -9.39125046e-02f, 1.63005933e-01f, -3.67308520e-02f, 1.67234279e-02f, 1.55582890e-01f, -7.54835531e-02f, 4.79543656e-02f,
  -4.64762338e-02f, 9.04299617e-02f, -1.44949883e-01f, 3.29296440e-01f, -5.61818816e-02f, -1.14581354e-01f, -7.62029067e-02f, 7.72747397e-02f, -8.92374739e-02f, -7.21199289e-02f,
  -4.04602811e-02f, -1.76697508e-01f, 8.72845203e-02f, 2.90588886e-01f, -4.14708734e-01f, -2.13870361e-01f, -1.62480161e-01f, -6.32852167e-02f, -2.63519824e-01f, -3.18583436e-02f,
  6.48931414e-02f, 2.32514739e-01f, 3.30177993e-01f, -7.96861351e-02f, 1.14733335e-02f, -1.46348095e-02f, 6.38748556e-02f, -6.36994541e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.17973714e-02f, 1.26759887e-01f, 3.46514322e-02f, -1.81208663e-02f, 2.15457886e-01f, 2.78888822e-01f, 2.07285121e-01f, 1.98525429e-01f, 5.81420586e-03f, 1.77331567e-01f,
  -3.21071893e-02f, -3.77382785e-02f, -1.97583754e-02f, 3.01796556e-01f, 2.04361044e-02f, 1.96374089e-01f, 1.68367419e-02f, 1.46238646e-02f, 2.84699723e-02f, 1.43674329e-01f,
  2.25435421e-01f, -7.84126371e-02f, -2.17141584e-01f, -1.81552902e-01f, 9.47150984e-05f, 3.59765768e-01f, 5.68697602e-02f, -1.59483790e-01f, 9.53824148e-02f, 3.47752810e-01f,
  2.33211070e-01f, 2.79743493e-01f, 3.19152474e-01f, 3.48975241e-01f, 2.85288066e-01f, 2.47683316e-01f, -2.93320119e-01f, -2.99862862e-01f, -1.49786159e-01f, -1.74096256e-01f,
  -2.28897393e-01f, 3.02135378e-01f, 8.60083997e-02f, -1.54395819e-01f, -1.01143658e-01f, 5.64499460e-02f, 2.66496241e-01f, 1.89546451e-01f, -2.75782458e-02f, -3.36323529e-01f,
  -5.72588563e-01f, -1.57259896e-01f, 4.04101580e-01f, 6.82065859e-02f, 1.47218078e-01f, -3.97764564e-01f, 5.93210608e-02f, -6.37668967e-02f, 4.54149954e-02f, -9.51988716e-03f,
  1.49705932e-01f, 7.08797947e-02f, 3.27303618e-01f, 4.48512882e-02f, 1.18879080e-01f, 7.72608742e-02f, 1.13498226e-01f, 1.07022962e-02f, 6.42627254e-02f, -9.61152539e-02f,
  7.70162567e-02f, -3.13145779e-02f, 1.89421564e-01f, -5.36402166e-02f, 5.37092537e-02f, 6.61697611e-02f, -3.13572176e-02f, -1.61149457e-01f, -1.31005138e-01f, -1.81684241e-01f,
  -1.39766425e-01f, 2.72846669e-01f, -3.95059139e-02f, -1.83336750e-01f, -8.53600129e-02f, 7.40380883e-02f, 5.83411679e-02f, -8.53901356e-02f, 1.22020192e-01f, 4.67020832e-02f,
  1.11410797e-01f, -5.13233319e-02f, -1.33340195e-01f, 2.34385312e-01f, -2.07233757e-01f, -1.32092416e-01f, 8.10630694e-02f, 1.31647944e-01f, -1.02495126e-01f, 1.22705907e-01f,
  -1.38427064e-01f, 2.15677544e-01f, 1.63787574e-01f, 7.04014078e-02f, 3.90884578e-01f, -1.06465481e-01f, 4.78212945e-02f, 2.46833533e-01f, -1.81021262e-02f, 1.62822783e-01f,
  -1.77087143e-01f, -1.95774719e-01f, -3.33572745e-01f, -4.45195585e-02f, 2.58235902e-01f, 5.45581579e-01f, -1.83443338e-01f, -1.52790785e-01f, 2.70258151e-02f, 8.05228427e-02f,
  2.94180721e-01f, -1.01371400e-01f, -4.28736955e-01f, 2.07037076e-01f, 8.75024125e-02f, -7.39303455e-02f, 6.84128776e-02f, -6.08307496e-03f, 1.14530616e-01f, 1.19327687e-01f,
  1.31161744e-02f, 2.48466462e-01f, 1.71963498e-01f, 8.30637291e-02f, -8.62456486e-02f, -7.05009773e-02f, 7.55589455e-03f, -3.13751549e-02f, 1.09229825e-01f, -7.58088604e-02f,
  6.38226233e-03f, -1.50789350e-01f, -1.52010158e-01f, 2.95725800e-02f, -3.00254136e-01f, 8.94324705e-02f, 2.34137625e-01f, 1.57458276e-01f, 2.46945888e-01f, 1.36560142e-01f,
  8.81655663e-02f, 3.72558311e-02f, 7.31601119e-02f, 1.18073501e-01f, 3.72427516e-02f, 1.86525956e-01f, 9.99060571e-02f, 2.88722157e-01f, -1.78114623e-01f, 4.29022014e-01f,
  3.57719719e-01f, 9.68439654e-02f, 3.49959910e-01f, 2.79690713e-01f, 1.70322543e-04f, -1.05479822e-01f, 6.34297505e-02f, -3.71504009e-01f, -2.65488285e-03f, 1.06213011e-01f,
  1.88369527e-01f, 1.48498386e-01f, 2.61504292e-01f, 5.52168079e-02f, 3.08228672e-01f, 5.49051881e-01f, -4.26214308e-01f, -1.56420261e-01f, 3.84660572e-01f, 1.05461493e-01f,
  3.77614558e-01f, 5.63667119e-02f, 1.59882560e-01f, -1.88347846e-01f, 1.87765379e-02f, 5.08255884e-02f, -2.31435955e-01f, -5.43218069e-02f, -1.88526571e-01f, 2.44490102e-01f,
  2.10189417e-01f, 3.59389186e-01f, 7.51066133e-02f, 1.29528910e-01f, 6.63789436e-02f, 2.39054877e-02f, 4.06606086e-02f, 7.70660266e-02f, 5.98373339e-02f, 2.07386255e-01f,
  1.97477266e-01f, 5.58077395e-02f, 2.23508656e-01f, 8.10991228e-02f, 1.74209222e-01f, 1.86024219e-01f, 1.19220898e-01f, 1.57419965e-01f, -5.63459471e-02f, 1.09870434e-01f,
  -2.50972241e-01f, -2.32090309e-01f, -9.05662477e-02f, -2.62796283e-01f, 2.91838609e-02f, -1.71745330e-01f, -1.18988551e-01f, 1.54263690e-01f, 1.83899656e-01f, 9.42076743e-03f,
  2.08935663e-01f, 5.67108810e-01f, -1.70503691e-01f, 4.82652374e-02f, -1.13260306e-01f, 3.58253807e-01f, -2.10151270e-01f, 4.68808934e-02f, -1.03440925e-01f, 2.63059974e-01f,
  1.90398768e-01f, 1.73494607e-01f, 1.06107734e-01f, 2.98970461e-01f, 1.31792843e-01f, 3.46816331e-01f, -2.27138512e-02f, -1.08708516e-01f, 5.14778718e-02f, -3.80914658e-01f,
  -3.04868042e-01f, 9.37150195e-02f, -4.40379500e-01f, -9.95170176e-02f, -5.73925115e-02f, 1.89131007e-01f, 1.08784772e-01f, 3.92154567e-02f, 8.68848562e-02f, 1.06659867e-01f,
  3.62474710e-01f, 4.11970258e-01f, 1.52772158e-01f, 5.22595830e-02f, 8.31046551e-02f, -3.83417130e-01f, -1.08364753e-01f, -6.53042784e-03f, -2.88728415e-03f, 9.67791013e-04f,
  -1.35203302e-02f, -8.47869143e-02f, -7.56366551e-02f, 8.61839857e-03f, 1.47097096e-01f, -2.01024842e-02f, -1.65921241e-01f, -2.10909601e-02f, 1.83904856e-01f, -8.77169222e-02f,
  8.92645307e-03f, 1.14129141e-01f, 4.23300192e-02f, 9.04859900e-02f, 4.26813625e-02f, -6.73512742e-02f, -7.39574209e-02f, -3.60747762e-02f, -1.62180644e-02f, -2.25413546e-01f,
  -7.21583590e-02f, -2.01093525e-01f, 4.24999952e-01f, 5.49693227e-01f, 1.29485920e-01f, -1.60539016e-01f, 1.38306990e-01f, -2.21299678e-01f, -1.06580064e-01f, 8.89241099e-02f,
  -2.57801497e-03f, 1.54609829e-01f, 3.38303894e-02f, 2.32291538e-02f, 2.50152528e-01f, 6.56009465e-02f, 2.01362133e-01f, 7.30914399e-02f, 1.05453268e-01f, 3.47869784e-01f,
  2.16834933e-01f, -3.00157577e-01f, 7.52802864e-02f, -2.27990642e-01f, 1.22615188e-01f, -5.15549630e-02f, -1.36592314e-01f, 4.09452289e-01f, -1.13666482e-01f, 1.70932740e-01f,
  3.28175277e-01f, 1.72104791e-01f, -2.38412976e-01f, -9.35254544e-02f, 4.56922576e-02f, -2.43012130e-01f, 2.93355048e-01f, -1.31517947e-01f, 3.66256014e-02f, -2.07613498e-01f,
  -6.91428781e-02f, 1.27432942e-01f, 1.09391920e-01f, 2.19707787e-02f, -2.70379987e-02f, 1.64738178e-01f, -8.15089568e-02f, 3.06668933e-02f, -4.64003580e-03f, 1.29680876e-02f,
  2.25674957e-02f, 1.41646579e-01f, 2.41565946e-02f, -2.63173729e-02f, -1.79279670e-01f, 2.43139580e-01f, 5.13388552e-02f, 2.13500977e-01f, -3.18816192e-02f, -1.80077832e-02f,
  -1.06493339e-01f, -1.28172219e-01f, 5.36767542e-02f, 2.57691264e-01f, -2.28705723e-02f, -1.39431342e-01f, 3.87025103e-02f, 3.98524344e-01f, 2.50412434e-01f, 3.24355125e-01f,
  8.38508084e-02f, 1.74864009e-01f, -2.13476181e-01f, 3.18189114e-01f, -8.79030004e-02f, 2.46188417e-01f, -5.95969968e-02f, 1.16590761e-01f, 2.24352237e-02f, -2.37641916e-01f,
  -1.38319433e-01f, 2.54110068e-01f, 2.24001110e-01f, 1.62131995e-01f, 9.10498016e-03f, 1.60154507e-01f, 4.24612343e-01f, -2.12182328e-02f, -1.46430731e-01f, -8.63018259e-02f,
  -4.63907272e-01f, -2.09218308e-01f, -1.16962627e-01f, 3.55621457e-01f, 2.13525817e-01f, -7.80539885e-02f, 3.92385060e-03f, 3.86632234e-01f, -8.00644234e-02f, -1.26678303e-01f,
  5.35982624e-02f, 6.77528977e-02f, 3.15337837e-01f, -7.85756949e-03f, 5.69287650e-02f, 2.27619052e-01f, 1.08361878e-01f, 1.03706494e-01f, 5.90992905e-02f, 3.38561870e-02f,
  6.01617023e-02f, -1.15773164e-01f, -4.25733961e-02f, -1.49903717e-02f, 5.06253988e-02f, 1.70165256e-01f, -2.03793585e-01f, -2.00114593e-01f, 1.78932756e-01f, 4.91414545e-03f,
  8.56488124e-02f, 6.92647533e-04f, -3.01543921e-01f, -2.71536112e-01f, -2.76769102e-01f, 2.16887712e-01f, -8.84701163e-02f, 2.82909930e-01f, -1.59430087e-01f, 1.87584251e-01f,
  1.61335424e-01f, 1.91517144e-01f, -4.18245852e-01f, -1.17669761e-01f, 4.52166609e-02f, -2.89765805e-01f, 4.07664180e-02f, -3.94134969e-01f, -2.26608496e-02f, 3.24463695e-01f,
  3.34070712e-01f, 3.90230864e-02f, 4.11991775e-02f, -5.05135395e-02f, 3.17917496e-01f, -5.43211758e-01f, -5.06096959e-01f, 2.83799112e-01f, -2.02983201e-01f, -1.35697141e-01f,
  -3.56735796e-01f, -2.51482856e-02f, 2.94948101e-01f, 3.69716585e-01f, 2.68752277e-01f, 4.48328435e-01f, -3.44885081e-01f, -2.99820364e-01f, -9.78522301e-02f, -2.75534272e-01f,
  1.07702196e-01f, 9.38582886e-03f, -2.14330554e-01f, 1.94408432e-01f, 2.21342400e-01f, -1.82138294e-01f, -4.49211746e-01f, 3.46351624e-01f, -7.30028600e-02f, 2.66283751e-01f,
  1.57057762e-01f, 2.10699514e-01f, 7.69400001e-02f, 4.63986620e-02f, 1.73148543e-01f, 8.85694101e-02f, 8.81478637e-02f, 4.56075780e-02f, 2.37568006e-01f, 9.13806632e-02f,
  -1.35152996e-01f, -5.99737130e-02f, -2.45270327e-01f, -7.95123279e-02f, -1.70008481e-01f, -1.50142342e-01f, -5.22429459e-02f, -1.46689266e-01f, -1.27568588e-01f, -9.59751606e-02f,
  -2.43138783e-02f, -7.58781433e-02f, 7.12328106e-02f, -1.61398277e-01f, -1.11192867e-01f, 1.84730645e-02f, 2.26912782e-01f, 2.55761072e-02f, -1.75342605e-01f, -3.79046686e-02f,
  3.61544341e-01f, -1.68503121e-01f, 9.95433182e-02f, -1.31562412e-01f, 2.30852813e-01f, -1.63810655e-01f, -6.90313205e-02f, 2.88721114e-01f, -1.40613005e-01f, -9.94903520e-02f,
  3.51615667e-01f, -2.45855257e-01f, 1.89599141e-01f, 1.95855990e-01f, -5.77890910e-02f, -5.12310676e-03f, 3.44891161e-01f, 3.87075216e-01f, 4.31590915e-01f, 1.49560636e-02f,
  1.80704147e-02f, -1.23721927e-01f, -8.30981974e-03f, 8.35674480e-02f, -9.94849056e-02f, -1.35152951e-01f, -1.90368161e-01f, -1.47115737e-01f, 2.33774126e-01f, -1.36719063e-01f,
  2.53590852e-01f, 8.29203427e-02f, 1.44871116e-01f, 1.08710133e-01f, 2.24371836e-01f, 2.26929542e-02f, 1.01225190e-01f, 5.11450395e-02f, -7.42180943e-02f, 6.80146143e-02f,
  6.80203438e-02f, -2.64542587e-02f, 1.56647135e-02f, 8.87083635e-02f, 4.11417075e-02f, 8.42293650e-02f, -1.32680044e-01f, -7.06409961e-02f, -7.69906864e-02f, 1.91836849e-01f,
  -2.13830769e-01f, -6.65074512e-02f, -1.82010755e-01f, 1.65520519e-01f, 8.71560425e-02f, 1.06779993e-01f, 1.03554383e-01f, -4.66324911e-02f, 1.65239647e-01f, 5.99651039e-02f,
  -2.55858541e-01f, 1.59753785e-01f, 9.04535800e-02f, 1.55919120e-01f, 2.57494748e-01f, 7.68049285e-02f, -6.36416972e-02f, 2.23715961e-01f, 1.02656677e-01f, -4.19772901e-02f,
  2.48794422e-01f, -3.24527085e-01f, 3.99041057e-01f, -4.10703659e-01f, -2.41654925e-02f, 2.43986964e-01f, 6.24425784e-02f, 1.29185781e-01f, -2.98711240e-01f, -1.03259303e-01f,
  -3.83189172e-01f, 1.10527351e-01f, 3.16802561e-01f, 4.50931042e-01f, -2.39939496e-01f, -1.37635380e-01f, 1.45002380e-01f, -7.46624023e-02f, 2.49979615e-01f, 1.30956218e-01f,
  -1.86095104e-01f, 1.86527446e-01f, 3.06693256e-01f, 3.28340717e-02f, -1.11286134e-01f, 1.25156075e-01f, -1.14145070e-01f, -7.15380162e-02f, 6.10106811e-02f, -6.98575974e-02f,
  1.31704345e-01f, -2.25912370e-02f, 1.66723013e-01f, 1.59231618e-01f, 1.32560506e-01f, -6.38742745e-02f, -6.20917715e-02f, -9.91722476e-03f, 1.68540195e-01f, 3.53270210e-02f,
  2.25620177e-02f, 6.20465577e-02f, 8.81466195e-02f, 1.84674799e-01f, 3.75429727e-02f, 1.65223271e-01f, 2.06867546e-01f, -1.11995399e-01f, -2.07069665e-02f, -1.03598520e-01f,
  -1.76903605e-03f, -2.40718827e-01f, 1.20991036e-01f, 5.58774956e-02f, 2.14547530e-01f, -7.25620538e-02f, 4.16594744e-01f, -9.61014628e-02f, -4.63912994e-01f, 1.58159450e-01f,
  -1.52017206e-01f, -1.39843747e-01f, 1.29074324e-02f, 1.91287979e-01f, 2.33793929e-01f, 4.44001079e-01f, -1.11337915e-01f, 2.96670973e-01f, 4.15412039e-01f, 1.40032336e-01f,
  -1.45714372e-01f, 3.69955063e-01f, 1.89306676e-01f, 1.61783949e-01f, 3.39149475e-01f, -4.26133454e-01f, -4.21153218e-01f, -1.67788178e-01f, 4.35113385e-02f, 2.83100456e-01f,
  -1.99745163e-01f, 4.21290219e-01f, 1.84226420e-03f, 2.51585394e-01f, 3.50781143e-01f, -5.02480984e-01f, 3.14992875e-01f, 3.98279838e-02f, 7.74122104e-02f, 5.48113696e-02f,
  1.66004360e-01f, 7.14139566e-02f, 2.54893869e-01f, 6.86165318e-02f, 2.45194063e-01f, 7.21343011e-02f, 1.04240015e-01f, 8.17368180e-02f, 4.81190048e-02f, 8.42102915e-02f,
  -1.85383502e-02f, 6.99648038e-02f, -2.47617245e-01f, -2.04587534e-01f, 1.78922459e-01f, 1.75151810e-01f, -1.71741862e-02f, 1.78230107e-02f, 3.89669895e-01f, 1.58280984e-01f,
  1.57052264e-01f, 1.63428605e-01f, 2.67913491e-01f, 6.92911893e-02f, -2.89666861e-01f, -6.23220503e-02f, 1.14421107e-01f, -3.72050256e-02f, 1.88011914e-01f, -2.55427897e-01f,
  2.98478127e-01f, -1.38478607e-01f, -2.13546418e-02f, -1.84432656e-01f, 8.76095667e-02f, -3.09053689e-01f, -1.48688659e-01f, 2.65232116e-01f, 1.58552587e-01f, 6.35823190e-01f,
  2.32273400e-01f, 9.76371858e-03f, 1.21356085e-01f, -1.24145925e-01f, -7.98737332e-02f, 2.51017302e-01f, -1.73417345e-01f, 2.72838116e-01f, 3.29825789e-01f, 9.56847370e-02f,
  3.43295187e-01f, 6.19328022e-02f, 2.01619089e-01f, 1.20956302e-01f, -2.46940970e-01f, 3.34434181e-01f, 1.70247480e-01f, -2.30659209e-02f, 4.13957179e-01f, 4.09348644e-02f,
  -3.40880714e-02f, -2.09392607e-01f, -1.05429895e-01f, 3.05722088e-01f, 1.74897343e-01f, 2.69135326e-01f, 1.64854929e-01f, 2.52698362e-02f, 2.22803727e-01f, 2.20732942e-01f,
  2.60361314e-01f, 1.34346962e-01f, -1.84958473e-01f, 1.81420952e-01f, 5.60395643e-02f, -5.12849800e-02f, -1.75247669e-01f, -1.15995795e-01f, -8.21360424e-02f, -1.66890115e-01f,
  -1.53564960e-01f, -5.98767027e-02f, 1.50657475e-01f, -1.63741663e-01f, -3.41898836e-02f, 2.37127140e-01f, -1.03961296e-01f, 1.76581934e-01f, 7.91442171e-02f, 2.66465694e-01f,
  -1.97543666e-01f, 1.11565746e-01f, 1.43556483e-02f, -1.88115478e-01f, -5.29289544e-02f, 5.70632555e-02f, 1.60256431e-01f, -3.28163922e-01f, 3.35370034e-01f, 1.79407343e-01f,
  2.03605250e-01f, -2.31894195e-01f, -1.36625236e-02f, 1.34381339e-01f, -7.86895156e-02f, -6.43408820e-02f, 2.74006836e-02f, -2.28413507e-01f, 2.37340957e-01f, 2.68972218e-01f,
  3.58265519e-01f, 4.52972561e-01f, 4.89840329e-01f, 2.79902101e-01f, 4.35568333e-01f, 3.00553709e-01f, 4.19252425e-01f, -2.06916764e-01f, 1.15663774e-01f, -3.25226635e-01f,
  -2.32912838e-01f, -3.44543964e-01f, -4.19555008e-01f, -1.09632067e-01f, 4.77841217e-03f, -7.92563409e-02f, 1.20304503e-01f, 4.14035529e-01f, 9.09108520e-02f, 6.87993094e-02f,
  2.81787038e-01f, -5.20389453e-02f, 1.39755145e-01f, -5.68263009e-02f, 5.22921346e-02f, -1.20615356e-01f, -7.22340345e-02f, 8.79054368e-02f, -8.34884122e-02f, 5.08517586e-02f,
  1.69401750e-01f, 3.46529752e-01f, 1.74118981e-01f, -7.55409673e-02f, 1.63778782e-01f, 1.60843983e-01f, -2.80528385e-02f, -6.72527775e-02f, 5.91460019e-02f, -3.60536948e-03f,
  -1.44629508e-01f, 2.85805851e-01f, 3.49128470e-02f, 1.44212153e-02f, 1.89872086e-01f, -2.08194479e-01f, -8.54961872e-02f, 1.29873544e-01f, 4.17471319e-01f, -2.16289666e-02f,
  -2.25328226e-02f, 1.18235806e-02f, 1.65125102e-01f, 2.45266065e-01f, 3.48364174e-01f, -1.27035484e-01f, 1.69893891e-01f, -3.43221575e-01f, 3.02016258e-01f, 2.78835237e-01f,
  3.22462283e-02f, 2.48327956e-01f, -1.71538427e-01f, 2.79339761e-01f, 1.90324932e-01f, 2.61819303e-01f, 5.23128472e-02f, 1.05210721e-01f, -3.67065221e-01f, 2.32725576e-01f,
  1.90677658e-01f, -2.67226666e-01f, 1.62219182e-01f, -3.43869835e-01f, 1.82266772e-01f, 1.64471209e-01f, 4.25865278e-02f, -2.91675376e-03f, 2.78479576e-01f, 2.18359176e-02f,
  1.01369292e-01f, 1.35755077e-01f, 1.39858037e-01f, 2.24895671e-01f, 1.47103623e-01f, 8.53466094e-02f, 9.41525474e-02f, 2.54775375e-01f, 2.65517861e-01f, 1.75844759e-01f,
  1.69421777e-01f, 1.98076248e-01f, 2.85149008e-01f, 1.59165382e-01f, -1.06097639e-01f, -5.63990548e-02f, -5.02022803e-01f, -1.76811025e-01f, -1.04094759e-01f, -2.11492822e-01f,
  -1.05837487e-01f, 9.86957923e-02f, -1.67422473e-01f, -1.18286930e-01f, 6.84109926e-02f, 9.75606963e-02f, -2.46685490e-01f, -3.78452599e-01f, 3.05806011e-01f, 3.31816733e-01f,
  2.57448643e-01f, 6.75334409e-02f, 2.85148829e-01f, 2.40837336e-01f, 2.17045322e-01f, 2.54733592e-01f, 1.58219412e-02f, -2.50552505e-01f, -1.66091770e-01f, -1.21497110e-01f,
  -3.01203668e-01f, 1.60422370e-01f, -2.23955303e-01f, -5.23077548e-01f, -1.13972113e-01f, -9.58606899e-02f, 3.14431041e-01f, 2.94912755e-01f, 1.78242531e-02f, -1.82113573e-01f,
  3.08690250e-01f, -3.35574895e-01f, -1.00353070e-01f, -1.08673930e-01f, -5.29937863e-01f, 1.86734134e-03f, 8.45319182e-02f, 1.46608338e-01f, 2.31564224e-01f, 3.40191871e-01f,
  8.53226110e-02f, -1.54551119e-01f, 2.15126183e-02f, -1.23790301e-01f, 2.51809359e-01f, -4.28960919e-01f, 1.13901868e-01f, 2.70941835e-02f, 1.09333031e-01f, 5.32381460e-02f,
  3.41661759e-02f, 1.19681671e-01f, 8.57778266e-02f, 1.87658027e-01f, 2.61919469e-01f, 6.03029542e-02f, 5.87134510e-02f, 2.62674153e-01f, -2.28717513e-02f, -5.18250093e-02f,
  -5.20115905e-02f, 1.60084665e-02f, 8.37217569e-02f, 2.23427713e-02f, -1.96701080e-01f, -9.88093540e-02f, -1.21133655e-01f, -1.88280329e-01f, 9.14148688e-02f, -2.02091917e-01f,
  -1.68713987e-01f, 2.00260282e-01f, 3.74556124e-01f, 3.39851558e-01f, 1.68290332e-01f, 2.84551680e-01f, -1.68081015e-01f, 8.88480321e-02f, 2.55033486e-02f, 3.61526072e-01f,
  -1.69081807e-01f, -1.63143709e-01f, -1.30534083e-01f, 2.66271144e-01f, 1.49645591e-02f, 4.31005418e-01f, -1.56070471e-01f, 1.23299370e-02f, 1.03859417e-01f, 1.96012646e-01f,
  2.24275038e-01f, -2.72744685e-01f, -1.16900001e-02f, -2.32780114e-01f, 2.92414963e-01f, -3.11498970e-01f, -1.99621785e-02f, -3.08280468e-01f, -2.72118330e-01f, 1.97374269e-01f,
  7.73868412e-02f, 4.29033011e-01f, 2.90281773e-01f, 1.20066389e-01f, 5.06534755e-01f, 2.58714706e-01f, -2.19343320e-01f, -3.84486802e-02f, 1.34385064e-01f, -5.01071870e-01f,
  2.02397391e-01f, 3.02995026e-01f, 1.58789873e-01f, 9.83903483e-02f, -3.39451693e-02f, 8.96929279e-02f, 1.97669879e-01f, 2.72004962e-01f, 8.10592324e-02f, 1.94725692e-01f,
  1.99146122e-01f, 1.24204986e-01f, -6.64168224e-02f, -4.28434387e-02f, -1.87594250e-01f, -3.99253331e-02f, -1.29945114e-01f, -1.09377570e-01f, -1.54713452e-01f, -1.38144448e-01f,
  -2.95725763e-01f, -4.50724885e-02f, -1.82288006e-01f, 1.93965435e-02f, -7.29038715e-02f, -9.61626545e-02f, 2.22086329e-02f, 9.41612795e-02f, 2.92252481e-01f, 1.81280538e-01f,
  5.65477461e-02f, 2.80156910e-01f, 1.62443355e-01f, 1.96481720e-01f, 1.93608403e-01f, -1.12368546e-01f, 2.31470972e-01f, -3.36326569e-01f, -4.27521944e-01f, -1.39071167e-01f,
  -2.58275211e-01f, -2.98616767e-01f, -1.24077260e-01f, -8.39483142e-02f, 2.56024390e-01f, 2.15410605e-01f, 1.84132636e-01f, 4.89304252e-02f, 3.18481654e-01f, 3.37176710e-01f,
  1.37208447e-01f, -6.13548905e-02f, 2.73082848e-03f, 1.52176559e-01f, 2.92360216e-01f, -2.19543457e-01f, -1.20481856e-01f, -1.11708157e-02f, -3.26716989e-01f, -1.49187237e-01f,
  -3.74047639e-04f, -2.52879620e-01f, 3.52148414e-01f, -2.22616211e-01f, -6.95031434e-02f, 2.31471717e-01f, 9.71107930e-02f, 6.61406592e-02f, -1.42888550e-03f, -6.52108938e-02f,
  1.20008990e-01f, 6.39643446e-02f, 1.01142384e-01f, 2.51459628e-01f, 6.27736673e-02f, -7.24865049e-02f, -1.57053292e-01f, -5.26879840e-02f, 1.78821404e-02f, -8.46769512e-02f,
  2.49387007e-02f, 1.83509439e-01f, -1.98620260e-01f, -1.84189230e-01f, -2.21425906e-01f, -1.80571899e-01f, 8.41437429e-02f, 4.24601734e-02f, -2.52261106e-02f, -2.16660932e-01f,
  1.44134164e-01f, -1.35447681e-01f, 1.37294054e-01f, -3.02188814e-01f, 2.07641959e-01f, -3.09326708e-01f, -1.45909429e-01f, -1.31621733e-01f, 2.91063450e-02f, -2.92724103e-01f,
  2.15199113e-01f, 1.17253751e-01f, 4.04286712e-01f, 6.10931158e-01f, 2.48869374e-01f, -2.45048016e-01f, 1.24625087e-01f, 8.44533443e-02f, 4.09321971e-02f, 3.57716054e-01f,
  -3.41762573e-01f, -1.51156500e-01f, 2.91105568e-01f, 3.91945064e-01f, 4.04393941e-01f, 3.84443194e-01f, -1.08065203e-01f, 1.07534614e-03f, 6.13665618e-02f, 4.11645710e-01f,
  8.16232786e-02f, 2.03096762e-01f, 3.14682066e-01f, -3.16917658e-01f, 3.72389674e-01f, -1.58169016e-01f, 3.19578834e-02f, 1.66073918e-01f, 8.75712335e-02f, 2.43908674e-01f,
  4.47300225e-02f, 7.23427013e-02f, -3.13354284e-02f, 7.52328187e-02f, 6.51420727e-02f, 2.47560050e-02f, -2.77941115e-03f, 9.40117091e-02f, 2.22887218e-01f, 2.38306448e-02f,
  1.23062506e-01f, -2.05155313e-01f, -3.05749029e-01f, -7.97019992e-03f, -1.51241481e-01f, 2.59649813e-01f, 4.74311858e-02f, -8.53859335e-02f, -6.49213865e-02f, 5.75033836e-02f,
  1.02056958e-01f, -6.10521510e-02f, 2.67279036e-02f, 2.38900203e-02f, 1.70633689e-01f, 2.86998391e-01f, 3.97733390e-01f, 3.69420350e-01f, 7.81728402e-02f, -1.66907862e-01f,
  -1.20941773e-01f, 2.74264604e-01f, -1.69377744e-01f, 2.52774116e-02f, -1.53301612e-01f, 3.90478432e-01f, 7.90633708e-02f, 1.96935475e-01f, 2.18798235e-01f, 1.98280867e-02f,
  3.57525945e-01f, 2.26492763e-01f, 1.68150201e-01f, 2.55927563e-01f, 1.39866501e-01f, -2.70999759e-01f, -1.94696486e-02f, -1.62201852e-01f, 4.06765789e-02f, 3.98590654e-01f,
  -1.58901930e-01f, 2.95246124e-01f, 2.53584772e-01f, 2.68262208e-01f, 1.26984477e-01f, -2.34460384e-02f, -2.79047847e-01f, -1.89032013e-04f, 1.73472926e-01f, -6.39104284e-03f,
  3.77810597e-01f, -1.22613814e-02f, -5.28179072e-02f, 7.98245668e-02f, -8.05937350e-02f, -2.10903324e-02f, 1.00475460e-01f, 1.31386101e-01f, 1.33801371e-01f, 9.33226123e-02f,
  7.15432316e-02f, 3.00176233e-01f, 7.09599033e-02f, 7.95468539e-02f, 1.98319614e-01f, 2.99991369e-01f, 3.91631126e-02f, 5.84049895e-02f, 3.01333386e-02f, -1.13979861e-01f,
  5.59055172e-02f, 3.67688715e-01f, 1.68930501e-01f, -2.46867049e-03f, -1.96410462e-01f, -2.36261159e-01f, -3.04003626e-01f, 2.82030433e-01f, 6.84563369e-02f, -6.72930554e-02f,
  1.75290316e-01f, 5.62031031e-01f, -5.57274595e-02f, 5.70150137e-01f, 2.99418628e-01f, 2.64273524e-01f, 4.39453013e-02f, 6.84195235e-02f, 7.06294132e-03f, 8.72483579e-05f,
  -1.29864186e-01f, -3.41646492e-01f, -2.36673281e-01f, 3.08173716e-01f, 3.78700569e-02f, 1.70803338e-01f, -1.45766968e-02f, -1.73803434e-01f, 3.09249878e-01f, 3.44505399e-01f,
  -4.31822479e-01f, -1.21789776e-01f, -4.04355258e-01f, -2.21755400e-01f, 2.46011779e-01f, 4.33621481e-02f, 6.04752712e-02f, -2.25595757e-01f, 1.72900796e-01f, 1.07171582e-02f,
  1.22121528e-01f, 1.50794268e-01f, 4.84522358e-02f, -6.73680976e-02f, 2.44194284e-01f, -3.76086459e-02f, 1.95967913e-01f, 2.93330178e-02f, -6.47181645e-02f, 4.20924388e-02f,
  6.97627738e-02f, -1.88516706e-01f, 1.10617727e-01f, 3.76971550e-02f, 1.27659470e-01f, -2.11642799e-03f, 1.40944272e-01f, 1.06694698e-01f, 2.93378346e-02f, 7.91150786e-04f,
  1.97167441e-01f, 1.01377010e-01f, 6.81734225e-03f, -3.25685106e-02f, -8.74551684e-02f, -3.45518664e-02f, 1.95279092e-01f, -2.63010561e-01f, 6.79221451e-02f, -1.34804964e-01f,
  3.08909826e-02f, 5.19946516e-01f, 1.51526064e-01f, -2.39488464e-02f, -1.92631274e-01f, 5.29261678e-02f, -3.28441948e-01f, 2.24798441e-01f, 3.46998684e-02f, 8.61534923e-02f,
  -1.10742986e-01f, 1.14182375e-01f, -1.03737330e-02f, 3.53369057e-01f, 3.53989482e-01f, 3.49569917e-01f, 1.84488252e-01f, 2.68738061e-01f, 3.03976070e-02f, 2.24731386e-01f,
  -9.45948362e-02f, -2.57807255e-01f, -3.05301756e-01f, -8.47493783e-02f, -2.77462542e-01f, 4.16063190e-01f, 1.55694962e-01f, -7.19287898e-04f, 2.81314164e-01f, 7.42278770e-02f,
  -1.74120173e-01f, 3.05370182e-01f, 1.86637361e-02f, -2.98102647e-02f, 4.43906456e-01f, 6.30289912e-01f, -8.67235288e-02f, 1.52652398e-01f, 8.06874260e-02f, -6.91226497e-02f,
  1.05701163e-01f, 1.33860692e-01f, 1.63583010e-01f, -2.06391700e-02f, 1.49858937e-01f, 1.97325181e-02f, 1.39918402e-02f, 7.43434206e-02f, 1.23503476e-01f, 1.28521159e-01f,
  1.10018170e-02f, 3.72777171e-02f, -6.85668066e-02f, 2.44239613e-01f, 5.49642853e-02f, 9.12938192e-02f, 3.91594231e-01f, -1.23042956e-01f, -1.41305506e-01f, 1.00984372e-01f,
  1.47247985e-01f, 8.85438472e-02f, -3.40275347e-01f, 1.92282274e-01f, -3.79349031e-02f, 1.40666828e-01f, -2.20889762e-01f, -9.49132536e-03f, -1.93549097e-01f, 1.42393455e-01f,
  3.73980403e-01f, 9.17259231e-02f, -3.61360073e-01f, -2.50399619e-01f, 1.69127733e-01f, 2.80329049e-01f, 1.78900331e-01f, -2.73532961e-02f, -4.07028079e-01f, -2.73606665e-02f,
  -4.76302773e-01f, 2.78545290e-01f, -2.64123440e-01f, -3.33397150e-01f, -2.65693128e-01f, 1.85256422e-01f, 1.21855132e-01f, 9.32863504e-02f, 9.81242508e-02f, -5.73463999e-02f,
  -2.22129390e-01f, 5.61270863e-02f, 1.46401525e-01f, -3.88823718e-01f, -2.49722257e-01f, -1.73250809e-01f, 3.22462499e-01f, 2.50379920e-01f, 3.48559797e-01f, 5.49820125e-01f,
  -1.61020070e-01f, -4.80747670e-02f, -2.30399221e-01f, -9.27155241e-02f, 1.23330913e-01f, -5.56967705e-02f, 3.15174498e-02f, -1.18760001e-02f, -2.20050104e-02f, -2.10269745e-02f,
  4.24613878e-02f, -2.58049872e-02f, 1.84206396e-01f, 2.95387991e-02f, 1.56155676e-01f, 7.86398053e-02f, 1.01034664e-01f, 5.16845919e-02f, -6.68508038e-02f, -3.50898951e-02f,
  -1.76987857e-01f, 3.50503996e-02f, -3.83967012e-02f, -9.00859535e-02f, -2.12592229e-01f, 8.13246891e-02f, 3.83539498e-02f, -1.88340336e-01f, 1.15882963e-01f, 3.28152210e-01f,
  2.17007801e-01f, -2.41757464e-02f, -2.48932168e-01f, 2.47111961e-01f, -6.69718906e-02f, -8.20351541e-02f, 1.97716802e-01f, -2.83356849e-02f, -1.79174058e-02f, 2.56705791e-01f,
  -1.00577764e-01f, 1.53703079e-01f, 2.30711728e-01f, -2.82195896e-01f, 3.18553746e-01f, -3.81559543e-02f, -1.07515477e-01f, 6.64565042e-02f, 5.36619406e-03f, -1.18481651e-01f,
  -1.55348659e-01f, -1.50851086e-02f, -2.91706502e-01f, -9.37253162e-02f, 2.94962943e-01f, 5.96172214e-01f, 7.43972212e-02f, -2.30410337e-01f, 2.38513336e-01f, -2.81382352e-03f,
  2.05268666e-01f, -1.99693814e-02f, -3.14388365e-01f, 3.51125717e-01f, 2.05186933e-01f, 3.03490125e-02f, -1.29542410e-01f, -2.00180039e-02f, -6.36376292e-02f, 8.35859030e-02f,
  2.66160548e-01f, 9.67075303e-02f, 1.73914462e-01f, 7.07218200e-02f, -9.72685963e-02f, -5.31086847e-02f, -3.57288048e-02f, 1.94005027e-01f, 7.07896724e-02f, 6.70164227e-02f,
  3.37617807e-02f, 1.55370399e-01f, -2.00995215e-04f, -9.77069214e-02f, -1.37636319e-01f, 3.57127190e-02f, -2.81193554e-02f, 1.66808218e-01f, -2.18962520e-01f, 3.21418315e-01f,
  -3.62611450e-02f, 2.46156007e-02f, 2.28563845e-01f, 1.20565295e-01f, 5.67196049e-02f, -3.23970228e-01f, 3.44907679e-02f, 2.11338341e-01f, 1.69456914e-01f, 1.73833847e-01f,
  4.40761834e-01f, -5.04050329e-02f, 2.57208914e-01f, 3.12536716e-01f, -1.27761647e-01f, 1.44437730e-01f, 1.29348263e-01f, -2.36152634e-01f, 9.28260908e-02f, -1.40073642e-01f,
  1.73702203e-02f, 1.05495937e-01f, 1.02870628e-01f, 3.01325411e-01f, -2.33358771e-01f, 2.90470570e-01f, -1.79033831e-01f, 4.58431184e-01f, 4.59249169e-01f, 4.40688431e-01f,
  -2.43496187e-02f, -1.49142221e-01f, 2.00700626e-01f, 6.89180568e-02f, 2.04014443e-02f, -2.11760312e-01f, -3.85065675e-01f, 1.17932037e-01f, 3.52872282e-01f, 3.40606384e-02f,
  7.06744343e-02f, 4.03374791e-01f, 1.58413798e-01f, 2.00272590e-01f, 1.57132953e-01f, 9.50745046e-02f, 5.12568727e-02f, 2.68633932e-01f, 2.27436483e-01f, 2.49670297e-01f,
  1.46308273e-01f, 5.11106476e-02f, 1.52524123e-02f, 1.53132051e-01f, -2.88174003e-01f, 1.96841974e-02f, 8.60721618e-02f, 2.01479658e-01f, 8.32756981e-02f, -3.31007391e-01f,
  -5.18493727e-02f, -1.14967242e-01f, -2.81559110e-01f, -2.42348239e-01f, -1.37050860e-02f, 5.24639338e-02f, -1.49509788e-01f, -1.76901713e-01f, 1.11235708e-01f, 1.35025144e-01f,
  -2.78950632e-02f, -1.45823911e-01f, 1.93851963e-01f, -1.85946554e-01f, 1.20751612e-01f, -2.62126420e-02f, 1.26725912e-01f, -2.43943587e-01f, 1.37395188e-01f, -5.01170009e-02f,
  -2.88358599e-01f, 3.72559160e-01f, -1.18477605e-01f, -4.09496762e-02f, -2.89790124e-01f, -2.27630764e-01f, 1.52498469e-01f, 7.86647871e-02f, 2.41770089e-01f, -2.37730354e-01f,
  4.75388855e-01f, 4.18651104e-01f, -2.29091048e-01f, -9.06259418e-02f, 1.73972175e-02f, -5.65214902e-02f, 9.06885043e-02f, 1.18423104e-01f, -2.32621953e-02f, 4.76788729e-02f,
  3.21214259e-01f, -6.34250268e-02f, -4.71928082e-02f, -9.23802629e-02f, -2.59763398e-03f, -1.80650339e-01f, 3.90906855e-02f, -7.44058415e-02f, 1.48431942e-01f, -7.40873218e-02f,
  2.02709689e-05f, 9.84136760e-02f, 2.64723688e-01f, 7.54174888e-02f, -6.16031215e-02f, 6.34530559e-02f, 1.43217847e-01f, 3.89263779e-02f, 1.41951814e-01f, 1.77411333e-01f,
  1.49083093e-01f, 1.22666873e-01f, 3.70070785e-02f, -2.08321456e-02f, 3.60239148e-01f, 2.10805446e-01f, 3.78976345e-01f, -5.70504144e-02f, -9.07430798e-02f, -8.62640664e-02f,
  -2.39305645e-01f, 5.54060102e-01f, -1.44303009e-01f, -1.07255340e-01f, 1.18192784e-01f, -7.40102679e-02f, -1.57509565e-01f, 1.65683523e-01f, 9.26688910e-02f, -7.19643235e-02f,
  1.13273263e-01f, -1.28031507e-01f, 3.68220285e-02f, 8.67997333e-02f, 1.57728136e-01f, 2.90663421e-01f, -2.98274588e-03f, 4.85158086e-01f, 1.50212049e-01f, -8.49952176e-02f,
  3.28821056e-02f, -9.74723324e-02f, 3.69541317e-01f, 4.34145331e-01f, -4.16222513e-02f, 1.16489492e-01f, 2.80949205e-01f, -1.81406602e-01f, 7.10604966e-01f, 3.12678441e-02f,
  -2.21278109e-02f, -3.17913927e-02f, -1.45189881e-01f, -2.32961714e-01f, 3.36710453e-01f, 3.68644267e-01f, -1.39316574e-01f, 1.03154946e-02f, 1.90178901e-02f, 2.34962389e-01f,
  1.26000002e-01f, 1.68632984e-01f, 1.29627287e-01f, 2.23301328e-03f, 4.15385254e-02f, -4.29514162e-02f, 1.11956283e-01f, 1.84268922e-01f, 6.35404214e-02f, 6.53531030e-02f,
  4.60734144e-02f, 1.51163433e-02f, 2.14351743e-01f, -2.17155248e-01f, -5.95930889e-02f, 5.97149357e-02f, -3.09431553e-02f, -8.66613463e-02f, 2.44610175e-01f, 1.90483198e-01f,
  3.12110662e-01f, -2.32400909e-01f, -1.73096806e-02f, -9.05416012e-02f, 4.90024500e-02f, 3.53870600e-01f, -1.00257762e-01f, 4.39916551e-01f, 3.79594862e-01f, -2.75998205e-01f,
  8.51876289e-02f, -4.53162253e-01f, -3.85215491e-01f, -7.00720176e-02f, -2.13801265e-01f, -2.20790207e-01f, 1.32325828e-01f, 4.23043489e-01f, 2.68027276e-01f, 4.77798909e-01f,
  -5.08561619e-02f, 4.48447704e-01f, 3.57534289e-01f, 1.00651361e-01f, 1.93549499e-01f, 2.24500135e-01f, 3.43679190e-01f, -6.14056326e-02f, 2.40773156e-01f, -2.55521894e-01f,
  9.94996279e-02f, -8.48377049e-02f, 1.26246065e-01f, 2.82814354e-01f, 1.44899413e-01f, 1.97191969e-01f, -2.58389473e-01f, -3.70639771e-01f, 3.18909734e-01f, 7.48122931e-02f,
  6.27202019e-02f, -2.45827436e-01f, 3.06258649e-01f, 1.34315938e-01f, 6.12585396e-02f, 1.34387970e-01f, 1.08108912e-02f, 8.16502422e-02f, 1.04629390e-01f, 2.65953422e-01f,
  -1.47731705e-02f, 1.75521702e-01f, 1.73584580e-01f, 1.65295586e-01f, 2.81468946e-02f, 1.70161679e-01f, 7.95912221e-02f, 9.84991267e-02f, -2.51031578e-01f, -7.90488720e-02f,
  -6.01396710e-02f, 2.06855536e-01f, 2.98263822e-02f, 1.57474771e-01f, 8.20619762e-02f, 1.24075070e-01f, 1.47887394e-01f, -8.38377774e-02f, 1.29676703e-02f, 1.96010903e-01f,
  2.42681608e-01f, 2.59718806e-01f, 3.24714333e-01f, 3.45353633e-01f, -8.48813429e-02f, 3.09978694e-01f, 2.93952674e-01f, 3.69150907e-01f, -1.49885267e-01f, 3.96665372e-02f,
  -2.10437164e-01f, -1.04442174e-02f, 2.88512874e-02f, 4.69713891e-03f, 1.61670864e-01f, -2.39589289e-01f, 4.20174807e-01f, 8.62867609e-02f, 2.24801563e-02f, 2.59437799e-01f,
  1.36387706e-01f, 2.86206782e-01f, -1.07771374e-01f, -1.19704701e-01f, 3.10272157e-01f, 6.55818824e-03f, 2.45175231e-02f, 2.46150076e-01f, 1.41194407e-02f, 5.85756376e-02f,
  1.30514011e-01f, -3.72145772e-02f, -2.96162665e-01f, -2.68339336e-01f, 8.08465481e-03f, -1.24175876e-01f, 3.92644674e-01f, 1.94884211e-01f, 4.68267463e-02f, 1.95179820e-01f,
  1.14246204e-01f, 7.67990872e-02f, 1.28901973e-01f, 2.30012923e-01f, 1.72916368e-01f, 1.17479667e-01f, 9.03884023e-02f, 2.48630922e-02f, 1.26895815e-01f, 7.85149634e-02f,
  -4.90701273e-02f, 3.43514800e-01f, -6.91650715e-03f, -1.24548331e-01f, 6.63098320e-02f, -1.87954307e-01f, -4.70242724e-02f, -6.84071705e-02f, 5.87610751e-02f, 7.60267898e-02f,
  -1.95029646e-01f, 2.79075303e-03f, -3.20373744e-01f, 2.32962623e-01f, 6.51388243e-02f, -2.24338800e-01f, -4.79791909e-02f, 4.50924307e-01f, -1.12278029e-01f, 5.80200315e-01f,
  5.77854753e-01f, 2.47588962e-01f, 1.24490909e-01f, 1.45970117e-02f, 6.61733523e-02f, -9.70831588e-02f, -1.45566121e-01f, -2.13301405e-01f, -2.33986631e-01f, 6.18303530e-02f,
  1.57274291e-01f, -9.30249542e-02f, -3.43459398e-02f, -1.47441283e-01f, 1.08798526e-01f, 3.52515727e-01f, 9.72232446e-02f, 3.21680605e-01f, 1.66567087e-01f, -3.44566464e-01f,
  3.28552604e-01f, 2.15974614e-01f, -9.21433270e-02f, -1.82612285e-01f, 1.49072036e-01f, -1.99992597e-01f, -1.85184464e-01f, 1.24283925e-01f, 6.68216646e-02f, 1.61050707e-02f,
  1.99865103e-01f, 9.92517620e-02f, 1.87096193e-01f, 9.55982134e-02f, -3.14936265e-02f, -8.27557966e-02f, -3.22563411e-03f, 1.20922096e-01f, -6.80023292e-03f, -1.15090013e-01f,
  -4.13435474e-02f, 1.99657887e-01f, 8.07380676e-02f, 2.19217137e-01f, 1.30164608e-01f, -1.75175108e-02f, -2.63304234e-01f, 5.71493357e-02f, 4.90096696e-02f, 1.87083691e-01f,
  -2.30660185e-01f, -7.21485019e-02f, -5.98098412e-02f, 1.17261954e-01f, -3.17259580e-02f, 1.62215680e-01f, -3.37332375e-02f, 1.42376348e-01f, 1.28203422e-01f, 2.81288832e-01f,
  7.92489573e-02f, 2.49383822e-01f, 2.61335164e-01f, -4.19281162e-02f, -2.30329350e-01f, 1.88738033e-01f, -1.21018052e-01f, 2.05636308e-01f, -6.77946359e-02f, -2.53214359e-01f,
  -1.23182368e-02f, -2.88821578e-01f, 7.69258067e-02f, 4.21223529e-02f, -1.27939865e-01f, 8.29321444e-02f, 4.99658100e-02f, 2.72445798e-01f, 4.53776091e-01f, -2.13232592e-01f,
  -1.05298191e-01f, -1.34456530e-01f, -3.52362335e-01f, 2.92595565e-01f, -1.37121528e-01f, -4.84656878e-02f, 3.62151653e-01f, -3.56421351e-01f, 2.03722998e-01f, 3.46634388e-01f,
  -2.06352457e-01f, 1.79325670e-01f, 9.90812704e-02f, 5.12592010e-02f, 1.10953420e-01f, -4.53297906e-02f, 4.26185653e-02f, 2.57914811e-01f, 7.31034651e-02f, 7.04583451e-02f,
  -4.71246503e-02f, 7.39111975e-02f, 2.73699015e-01f, 1.52767733e-01f, 1.71704173e-01f, 1.42542943e-01f, 1.24735758e-01f, 1.72190785e-01f, 7.76761249e-02f, 1.78603426e-01f,
  5.73158339e-02f, 9.46782976e-02f, 3.29072848e-02f, -5.48273921e-02f, 2.91778356e-01f, 2.12037981e-01f, 4.03536975e-01f, -1.55199170e-01f, -1.20650314e-01f, -1.50363639e-01f,
  -7.86236003e-02f, 4.14836019e-01f, -1.01662159e-01f, 1.46743223e-01f, 7.35563859e-02f, -1.84026361e-01f, 9.38700140e-02f, -6.34271353e-02f, -1.76927105e-01f, -7.00255260e-02f,
  -2.30927137e-03f, -1.82263702e-01f, -3.19062769e-02f, 2.02414826e-01f, -8.55373070e-02f, 6.11692727e-01f, -1.25260055e-01f, 3.27957958e-01f, 1.04543723e-01f, -4.55571637e-02f,
  -1.96532975e-03f, 1.48626298e-01f, 3.26440334e-01f, 2.97950536e-01f, 4.95869994e-01f, -1.44770578e-01f, -1.68254048e-01f, -3.09873492e-01f, 3.63832295e-01f, 1.29386544e-01f,
  -1.54868454e-01f, -1.03880338e-01f, -1.40996799e-01f, -1.26838773e-01f, 5.34179568e-01f, 2.46076643e-01f, -1.71694919e-01f, -3.72206606e-02f, 1.44183636e-01f, 2.31150985e-02f,
  -1.87925979e-01f, -1.59402210e-02f, -1.51686361e-02f, -8.91906582e-03f, 6.03085523e-03f, -3.21601897e-01f, -9.53084964e-04f, 8.32304358e-02f, 6.97210431e-02f, 1.11625448e-01f,
  -1.00012660e-01f, -2.15616211e-01f, 1.83825806e-01f, -8.90238583e-02f, -9.82190296e-02f, 1.80998400e-01f, -6.20372072e-02f, 1.75637212e-02f, 1.91248417e-01f, 2.26515740e-01f,
  -9.30116251e-02f, -3.07729274e-01f, -3.85892089e-03f, -2.99937844e-01f, -3.79835546e-01f, -2.51285881e-01f, 9.48822498e-02f, -2.71116886e-02f, 3.14439327e-01f, -1.58580113e-02f,
  5.74909560e-02f, -9.47480369e-03f, -3.26131761e-01f, 1.19151294e-01f, 4.47830707e-02f, -3.68080109e-01f, -5.68694472e-02f, 1.80298567e-01f, 2.22291052e-01f, -1.18484810e-01f,
  4.32067141e-02f, 1.88465983e-01f, 3.44668210e-01f, 1.41747549e-01f, 2.11324051e-01f, 6.27725273e-02f, -2.41452139e-02f, -9.67659354e-02f, -7.10944980e-02f, -2.51103103e-01f,
  -8.09532255e-02f, 1.44333050e-01f, -1.14499383e-01f, 2.80892134e-01f, 7.63551192e-03f, 2.96012998e-01f, -3.27828854e-01f, -3.21970731e-01f, 7.14143366e-02f, -8.54052976e-02f,
  3.68442535e-01f, 7.43546113e-02f, 2.91661564e-02f, -1.24268726e-01f, 1.16949473e-02f, 7.27486983e-02f, 1.05565347e-01f, 1.00088134e-01f, 1.32241219e-01f, 1.55860648e-01f,
  1.09804623e-01f, 1.03985913e-01f, -1.23432092e-01f, 4.95851077e-02f, -1.50462210e-01f, -5.08498698e-02f, -5.51913716e-02f, 1.65542364e-01f, 1.21042639e-01f, 1.77476883e-01f,
  3.53758037e-01f, 4.50019464e-02f, -3.52336280e-02f, 1.56443775e-01f, 2.10277587e-01f, 1.50858715e-01f, -1.31028131e-01f, -1.37782693e-01f, 4.42138873e-02f, 2.41574839e-01f,
  -6.26322329e-02f, 4.48773503e-02f, -1.21843055e-01f, -3.10129970e-01f, 2.55862921e-01f, 5.77089563e-02f, -7.72837969e-03f, -4.11855709e-03f, 7.08021000e-02f, 8.04237649e-02f,
  -1.73258930e-01f, -1.40890777e-01f, 9.10758376e-02f, 4.00499731e-01f, -7.20532760e-02f, 2.82568544e-01f, -1.19822815e-01f, -2.17442617e-01f, -8.73548537e-02f, 1.23492002e-01f,
  -8.11802596e-02f, 2.02162281e-01f, 1.65306136e-01f, -2.38084391e-01f, -1.46699876e-01f, -1.85241461e-01f, 2.85530925e-01f, -5.53676561e-02f, -1.45646140e-01f, 1.46840692e-01f,
  1.59361258e-01f, 1.71455726e-01f, 4.00415421e-01f, 2.54758243e-02f, 3.82687375e-02f, 4.13981415e-02f, -1.54366150e-01f, -1.37722358e-01f, 1.46715552e-01f, -2.91447639e-02f,
  1.25303671e-01f, 1.90859854e-01f, 1.66985527e-01f, 5.48580065e-02f, -6.97464645e-02f, 2.42898628e-01f, -5.20294756e-02f, -6.20977581e-02f, 1.82596982e-01f, 1.78947166e-01f,
  2.63193101e-02f, -6.73955679e-02f, -1.09082405e-02f, -1.38507426e-01f, -2.23163553e-02f, -9.86447185e-03f, 1.44497037e-01f, -1.76347643e-01f, -2.39389203e-02f, 1.66343555e-01f,
  -1.50301501e-01f, 1.37289375e-01f, -6.69400617e-02f, 2.09611714e-01f, 3.61801833e-02f, 3.86704892e-01f, 5.88642955e-02f, 2.39208937e-01f, -9.45049524e-02f, 3.90450478e-01f,
  3.36593449e-01f, 1.89459473e-01f, 1.54516220e-01f, 3.28973472e-01f, 2.12943889e-02f, -3.80568020e-03f, -1.62036389e-01f, -5.08258998e-01f, 6.86559593e-03f, -8.61028433e-02f,
  -1.59733057e-01f, -7.43553042e-03f, 2.72547424e-01f, 1.39172170e-02f, 3.88508290e-01f, 3.74804258e-01f, -1.34285673e-01f, 4.75397594e-02f, 1.63606241e-01f, 7.96939135e-02f,
  1.26953453e-01f, 4.89630289e-02f, 2.14246958e-01f, -2.48818532e-01f, 1.55767277e-01f, -5.36789484e-02f, -8.40846524e-02f, 1.41915798e-01f, -2.93056101e-01f, -1.08515762e-03f,
  1.86548337e-01f, 4.77896370e-02f, 1.79960340e-01f, 6.17420394e-03f, 1.61874145e-01f, -9.88634303e-02f, 1.43218964e-01f, 1.27089480e-02f, 1.33500233e-01f, 1.14716373e-01f,
  8.98160860e-02f, -6.94255764e-03f, 2.26412788e-02f, -6.50577666e-03f, 1.01974024e-03f, 5.87065220e-02f, 9.40386727e-02f, 1.43139869e-01f, -1.50538757e-01f, 1.46155860e-02f,
  1.91337302e-01f, 1.35784298e-01f, 3.71681184e-01f, 3.05874735e-01f, -9.98544693e-03f, 1.00176238e-01f, 1.09542198e-01f, 2.60615885e-01f, -1.42919913e-01f, -9.47397202e-02f,
  4.99265094e-04f, -4.50453050e-02f, 1.60336778e-01f, 2.15890154e-01f, 3.93909067e-02f, -1.42634273e-01f, 3.42860550e-01f, 2.60931790e-01f, 1.67133793e-01f, -6.64258301e-02f,
  3.62237632e-01f, -2.06102967e-01f, 1.66826099e-01f, 1.69325098e-01f, 2.26195842e-01f, -1.21199116e-02f, -2.69387096e-01f, 4.31353480e-01f, 2.55168289e-01f, 5.38597941e-01f,
  1.74246460e-01f, -3.42727383e-03f, 2.27670848e-01f, 2.61523724e-01f, 3.28990519e-01f, -1.21246226e-01f, 9.17819291e-02f, -2.44011849e-01f, -3.91770862e-02f, -3.01533759e-01f,
  -1.85933545e-01f, -1.25819504e-01f, 2.22036630e-01f, -5.84657677e-02f, 8.43404904e-02f, 4.73608404e-01f, 3.24030332e-02f, 1.02531412e-04f, 3.80140282e-02f, 1.71694495e-02f,
  2.98515763e-02f, -1.69384092e-01f, -8.89726728e-02f, -1.81965996e-02f, 1.29653975e-01f, -1.95337519e-01f, -6.00384623e-02f, 8.77310559e-02f, 1.78630084e-01f, -1.19997241e-01f,
  1.34577051e-01f, 2.71736141e-02f, -1.69003122e-02f, 9.84950215e-02f, -1.37770120e-02f, -5.15357405e-02f, -1.23191029e-01f, -1.08870678e-01f, 1.77133258e-03f, 1.05819032e-01f,
  -4.40295264e-02f, 9.35215726e-02f, 3.19862396e-01f, 4.00709689e-01f, 1.10124566e-01f, -6.33098707e-02f, -3.77628058e-02f, -3.89924139e-01f, -3.34609240e-01f, 8.57726634e-02f,
  -6.24473654e-02f, 3.51410925e-01f, 7.98524544e-02f, 2.35546440e-01f, 4.92576867e-01f, -7.16810897e-02f, 2.90900052e-01f, 2.50239968e-02f, 1.12438634e-01f, 3.84648323e-01f,
  -1.96477734e-02f, -2.03218117e-01f, -1.79763332e-01f, -1.13881074e-01f, -5.97019196e-02f, 1.90913469e-01f, 5.49514219e-02f, 4.55940574e-01f, -2.38263309e-01f, 1.50719672e-01f,
  5.52312396e-02f, 3.34519118e-01f, 1.62043497e-01f, 1.51764631e-01f, 2.01525822e-01f, 2.12748244e-01f, 1.80112585e-01f, 1.14521012e-01f, -3.29414010e-02f, -4.34621237e-02f,
  -1.13776103e-01f, 1.44782603e-01f, 2.94161085e-02f, 4.36816849e-02f, -1.12819001e-01f, 3.33101228e-02f, 9.05295536e-02f, 1.12797283e-01f, 1.47672415e-01f, 1.60094481e-02f,
  -3.84801775e-02f, 3.17112170e-02f, 4.19599712e-02f, 8.60465020e-02f, -1.03001200e-01f, 9.06666592e-02f, -9.35476124e-02f, 2.00965077e-01f, 4.01649177e-02f, 2.45500281e-01f,
  8.38726945e-03f, -1.04009956e-01f, 1.47364095e-01f, -4.84226719e-02f, 4.36656252e-02f, -1.87064245e-01f, -2.30579171e-02f, -2.49682337e-01f, 2.44333237e-01f, 2.62594253e-01f,
  1.32051378e-01f, 1.41930385e-02f, 1.45073412e-02f, 2.74193913e-01f, -8.28274414e-02f, 2.03690352e-03f, -1.09391920e-01f, 3.27823728e-01f, 1.08115122e-01f, 2.62620658e-01f,
  6.87132105e-02f, 1.32290468e-01f, 4.99464601e-01f, 1.36178464e-01f, 6.09473279e-03f, 3.24974686e-01f, -3.63713950e-02f, -1.13988221e-01f, 1.29491463e-01f, 9.89256948e-02f,
  -2.00877815e-01f, -9.47350562e-02f, -1.43620521e-01f, 3.76256377e-01f, -8.07944089e-02f, 3.87001395e-01f, -4.34804633e-02f, 4.81154732e-02f, -2.24959865e-01f, -2.79785305e-01f,
  3.36665034e-01f, 7.93326274e-02f, 3.15845281e-01f, 1.72571108e-01f, 1.03332058e-01f, 7.76452990e-03f, -4.76762056e-02f, 2.69101858e-01f, -2.16366928e-02f, 1.47827119e-01f,
  1.03029370e-01f, 1.81109235e-01f, 6.50100857e-02f, 1.91131383e-01f, 1.89906538e-01f, -4.66194376e-02f, -1.54868960e-01f, -1.47678675e-02f, -1.83691289e-02f, -6.35272786e-02f,
  6.53732717e-02f, -7.81134292e-02f, -1.80056408e-01f, 1.47002721e-02f, 7.95664862e-02f, 6.04177006e-02f, -2.98323929e-02f, -8.34308192e-02f, -6.91817105e-02f, 2.95096878e-02f,
  -5.54981921e-03f, -1.19131599e-02f, 1.27996981e-01f, 2.24587217e-01f, 6.34844676e-02f, 4.19538856e-01f, 2.65322089e-01f, 3.70139956e-01f, 9.86238495e-02f, 2.37465221e-02f,
  -4.97297868e-02f, -2.09393486e-01f, -2.18159378e-01f, -1.78237483e-01f, -9.58291963e-02f, 3.42457965e-02f, -1.99523479e-01f, -3.02918311e-02f, 1.30888790e-01f, -1.16489954e-01f,
  1.29383221e-01f, 1.59921721e-01f, -2.03357249e-01f, 9.44528133e-02f, -6.12667426e-02f, -3.59284937e-01f, 2.46611506e-01f, 1.58271834e-01f, 4.07954380e-02f, -1.38580576e-01f,
  1.42550886e-01f, 2.87933826e-01f, 3.30550164e-01f, -1.13397047e-01f, -1.24144964e-01f, 2.93457538e-01f, 1.26424208e-01f, -2.57332385e-01f, 2.71826804e-01f, 3.03186655e-01f,
  1.09043054e-01f, 8.15060884e-02f, 2.53852725e-01f, 9.66405943e-02f, 1.50361136e-01f, 2.65067786e-01f, 7.46426657e-02f, 2.49635413e-01f, 1.72015235e-01f, 1.96145192e-01f,
  -1.45496711e-01f, 2.88101938e-02f, 2.68961459e-01f, 8.62622727e-03f, 5.56297414e-02f, -1.90424412e-01f, -3.66564304e-01f, -3.83985192e-01f, -2.65504658e-01f, 6.31223395e-02f,
  -3.06974351e-02f, -9.17518362e-02f, -1.51168957e-01f, 2.07332820e-01f, 3.01145077e-01f, 1.30184382e-01f, -3.06788892e-01f, 1.66978955e-01f, -1.66853949e-01f, 7.83349127e-02f,
  4.88811553e-01f, 4.45614569e-02f, -1.95947587e-02f, 1.63767859e-01f, 3.27664554e-01f, 3.92043069e-02f, 4.31684777e-02f, 4.08637911e-01f, 9.32952762e-02f, -1.83416680e-01f,
  -1.71927005e-01f, -2.65627663e-04f, -2.14488760e-01f, -2.51665711e-01f, -3.91228497e-01f, -1.60369948e-01f, 3.17469060e-01f, 5.64416289e-01f, 3.37328851e-01f, 7.55470619e-02f,
  1.29743889e-01f, -7.67632341e-03f, -9.21679288e-02f, 1.92085102e-01f, 2.83874869e-01f, -1.24292367e-03f, 3.24439585e-01f, 5.08614838e-01f, -6.42550513e-02f, -1.11313641e-01f,
  -3.49601954e-01f, 3.98025773e-02f, -9.86747071e-02f, 1.53154746e-01f, 5.43889357e-03f, -3.92307900e-02f, -1.12757206e-01f, 1.04034901e-01f, 1.45958170e-01f, -1.14650130e-01f,
  3.92203145e-02f, -1.00795805e-01f, 6.17630966e-02f, 1.79716200e-02f, 7.18187615e-02f, 2.09996864e-01f, -1.81574579e-02f, 2.65191466e-01f, -1.27689570e-01f, 1.52419701e-01f,
  6.51872009e-02f, -2.26477031e-02f, 1.42564457e-02f, 3.88766080e-02f, -7.67717063e-02f, -3.74028571e-02f, -1.55150861e-01f, 2.81580817e-02f, 2.33325318e-01f, -3.67091328e-01f,
  1.02418035e-01f, 4.73638773e-01f, 1.76949307e-01f, -9.98008028e-02f, 1.53244987e-01f, 3.56748343e-01f, -4.20552194e-02f, 2.44465932e-01f, 3.25254142e-01f, 9.86328498e-02f,
  -1.27229661e-01f, -2.99751937e-01f, -2.48470888e-01f, 1.88773155e-01f, 2.20617071e-01f, -1.82881758e-01f, -6.19986020e-02f, 2.82285571e-01f, 3.50737035e-01f, -1.40599664e-02f,
  -2.33449847e-01f, -6.89097196e-02f, -6.91892326e-01f, 4.68457537e-03f, -1.22891545e-01f, 7.38364607e-02f, 1.81720018e-01f, -1.29840925e-01f, -2.30692178e-01f, 4.39455807e-02f,
  -5.13295352e-01f, 3.79005224e-02f, 7.45741069e-01f, -1.86618730e-01f, 4.42097574e-01f, 1.97446361e-01f, 1.11320257e-01f, 1.89675018e-01f, 3.16500776e-02f, 1.60703227e-01f,
  4.64352369e-02f, 6.90290779e-02f, 1.17984600e-01f, 1.46841168e-01f, -1.01946592e-01f, 1.28691614e-01f, 4.25179340e-02f, 1.19963333e-01f, -1.23742953e-01f, -1.03574850e-01f,
  2.40034238e-02f, -1.24181367e-01f, 2.00688556e-01f, 1.09665394e-01f, 1.10724129e-01f, 8.15629773e-03f, 1.49283409e-01f, 7.98406079e-02f, 1.15150930e-02f, 2.67976224e-01f,
  9.33724269e-02f, -1.41610920e-01f, -2.85615891e-01f, 4.66888636e-01f, 2.78748870e-01f, -1.95466548e-01f, 3.47955078e-01f, -5.01243472e-02f, -3.16970527e-01f, 5.08797131e-02f,
  -1.11840978e-01f, -1.95290893e-01f, 3.44818741e-01f, -3.20169292e-02f, -1.40970677e-01f, 2.00453550e-01f, -8.16044882e-02f, 9.46534276e-02f, 3.47168297e-02f, 1.60078660e-01f,
  2.10776895e-01f, 3.73728275e-01f, 4.38767374e-01f, 1.63853630e-01f, 4.83981937e-01f, -2.15270102e-01f, -1.67215869e-01f, -1.31446391e-01f, 6.94547445e-02f, 8.48945677e-02f,
  8.93046409e-02f, -1.37186706e-01f, -5.03564887e-02f, 4.20341015e-01f, 9.38015357e-02f, -3.82605225e-01f, -1.92439482e-01f, -1.05874971e-01f, 1.96323276e-01f, 7.32606351e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.58256128e-01f, 8.35570469e-02f, 7.71865398e-02f, 1.71413034e-01f, -1.03405546e-02f, 3.47074270e-02f, 1.95414469e-01f, -1.16147688e-02f, 3.30635048e-02f, 1.08879674e-02f,
  7.17968792e-02f, 9.16176364e-02f, 1.89249024e-01f, 1.51830554e-01f, 1.52516544e-01f, 1.34250104e-01f, 1.43254146e-01f, 1.03269808e-01f, 8.73017237e-02f, 1.46453157e-01f,
  1.64111048e-01f, 6.12373948e-02f, 2.64387950e-02f, 2.38199100e-01f, 1.91068992e-01f, 1.03182092e-01f, -8.15660506e-03f, 1.50193691e-01f, 2.27917537e-01f, 2.46231824e-01f,
  8.52607861e-02f, 1.06165618e-01f, 1.59984574e-01f, 6.34859800e-02f, -1.17198102e-01f, 1.48266390e-01f, 2.27747351e-01f, 2.50643909e-01f, 6.48864210e-02f, 2.38160715e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.67200358e-02f, -3.30659896e-02f, -2.92181700e-01f, -1.66417494e-01f, -6.83856234e-02f, 4.11313623e-02f, 1.16392553e-01f, -2.25293830e-01f, -8.51980671e-02f, 1.50716096e-01f,
  6.17572777e-02f, -2.06397384e-01f, -5.07200658e-02f, -3.97129327e-01f, 2.94348121e-01f, -3.28569889e-01f, 3.58794600e-01f, 6.25015080e-01f, -8.21096823e-02f, 1.85598820e-01f,
  3.00851732e-01f, 2.79479355e-01f, -1.78521916e-01f, -1.87823668e-01f, -2.44785085e-01f, 2.33811915e-01f, -1.03643788e-02f, 1.19684324e-01f, 1.27369434e-01f, 1.25389704e-02f,
  -7.54962921e-01f, -8.90509598e-03f, 5.12791015e-02f, 5.54260537e-02f, -9.36304927e-02f, -2.80358702e-01f, -2.29261711e-01f, -4.39267792e-02f, 5.48633970e-02f, -2.17565805e-01f,
  1.55899584e-01f, 1.98221013e-01f, -1.31628528e-01f, 5.03972732e-02f, -7.26376593e-01f, 1.34166270e-01f, 2.25903586e-01f, -4.68306273e-01f, -3.54170769e-01f, 1.00071736e-01f,
  8.96748975e-02f, -2.87590414e-01f, -9.04125124e-02f, -4.22092766e-01f, 2.54574567e-01f, -4.75596130e-01f, -3.38668197e-01f, -1.27915919e-01f, 9.01370123e-02f, 2.15416402e-01f,
  -4.88734335e-01f, -3.34111571e-01f, -4.82009687e-02f, -4.26247090e-01f, 6.39830679e-02f, -5.28422713e-01f, -2.12191463e-01f, -1.42015249e-01f, 1.93542138e-01f, -1.12983532e-01f,
  1.10457882e-01f, -1.13079637e-01f, -1.34727523e-01f, 2.84304559e-01f, -1.13804368e-02f, 1.22723281e-01f, 2.93261707e-01f, -2.16068447e-01f, 3.17560762e-01f, 2.19693542e-01f,
  7.58684039e-01f, -1.01606376e-01f, 6.18758500e-01f, 1.77424058e-01f, -4.72872645e-01f, -3.68926466e-01f, 4.07019228e-01f, 1.72694251e-02f, -2.80047685e-01f, 2.76067764e-01f,
  7.34845623e-02f, 4.01175767e-02f, 2.53949642e-01f, -2.45639253e-02f, 2.13947594e-01f, -2.03787103e-01f, 2.96918631e-01f, -3.32212001e-01f, -3.82966548e-01f, -1.26453459e-01f,
  1.01105265e-01f, -3.91367167e-01f, -1.36177272e-01f, -2.46261612e-01f, -1.14743812e-02f, 8.02026913e-02f, -3.64949137e-01f, 8.77879858e-02f, 2.02228233e-01f, 2.73596913e-01f,
  2.24458471e-01f, -2.13921219e-01f, -4.04619515e-01f, -3.94467175e-01f, -1.04136504e-02f, -3.64643186e-01f, 1.98196158e-01f, -4.31851327e-01f, -3.65470916e-01f, -4.93417829e-02f,
  1.20898679e-01f, 2.27598808e-04f, 1.88117236e-01f, -1.07935980e-01f, -1.92840621e-01f, 1.68691382e-01f, -2.28134319e-01f, -1.06058501e-01f, 4.76306826e-02f, 1.90896004e-01f,
  8.45783949e-02f, -1.02392480e-01f, -1.60931662e-01f, -1.00344762e-01f, 6.73713279e-04f, 9.33063477e-02f, -2.43604019e-01f, -2.23080024e-01f, -1.57000691e-01f, 1.38679087e-01f,
  -5.26218787e-02f, -2.47836858e-01f, 3.40310007e-01f, 2.06568941e-01f, -1.73138529e-01f, -3.73026252e-01f, -1.36367679e-01f, 2.32760802e-01f, -4.93726134e-01f, -1.48445800e-01f,
  5.94909005e-02f, -1.51186273e-01f, -2.35704944e-01f, 2.57314175e-01f, 8.61978307e-02f, -3.09885591e-01f, -5.38215518e-01f, -3.84048641e-01f, -2.54539341e-01f, 3.08211088e-01f,
  -4.29953169e-03f, -1.21420614e-01f, 3.73030424e-01f, 3.00043523e-01f, -1.93975419e-01f, -5.38035095e-01f, -2.86341488e-01f, -2.16385290e-01f, 3.04738313e-01f, 1.28222287e-01f,
  -5.44041336e-01f, 1.25986412e-01f, -6.51585460e-01f, 7.18660951e-02f, 2.19441608e-01f, -2.46557623e-01f, 2.65204996e-01f, 1.96411073e-01f, 1.96324229e-01f, -1.44981682e-01f,
  -5.43237329e-01f, 1.33413002e-01f, -5.24107456e-01f, -1.70155138e-01f, -2.56930858e-01f, 2.21059501e-01f, -1.20715044e-01f, 1.33808672e-01f, -4.32274342e-01f, -8.39628372e-03f,
  -5.75645566e-01f, 4.68498468e-03f, -1.47047147e-01f, 4.25085016e-02f, -1.62059739e-01f, -1.04115587e-02f, 9.38632190e-02f, -6.79074153e-02f, -5.84330037e-03f, -8.60527754e-02f,
  1.29629701e-01f, -3.30763049e-02f, 9.19128954e-02f, -1.83618292e-01f, 6.52235374e-02f, 3.33047539e-01f, -1.32525101e-01f, 1.89433843e-01f, -2.57397327e-03f, 1.59346759e-02f,
  -1.24930263e-01f, -2.53942199e-02f, 4.48260367e-01f, -1.09393068e-01f, -2.48148903e-01f, 5.55125058e-01f, -5.10172367e-01f, -1.45281702e-01f, -3.79274070e-01f, 8.34990144e-02f,
  1.50942162e-01f, 1.78092904e-02f, 1.74768090e-01f, -5.91749474e-02f, -3.83364797e-01f, 1.51195675e-01f, 3.31760496e-01f, -3.69061679e-01f, -6.88402534e-01f, 1.06724717e-01f,
  2.81353861e-01f, -3.07614475e-01f, 1.88611209e-01f, 5.64227402e-02f, -5.74091494e-01f, 1.23220429e-01f, -5.46943128e-01f, -3.85548443e-01f, -6.17116153e-01f, 2.17153132e-01f,
  -6.90616146e-02f, 2.12302849e-01f, -6.14611851e-03f, -4.79918629e-01f, -5.16517699e-01f, 1.16375528e-01f, 7.81730413e-02f, 7.50435293e-02f, -4.04238522e-01f, -5.82534790e-01f,
  1.26870915e-01f, 7.55552873e-02f, -3.58282357e-01f, 2.60721773e-01f, -1.14967704e+00f, -2.72437837e-02f, -2.34151319e-01f, 1.60180956e-01f, 5.63736446e-02f, -1.26521334e-01f,
  1.16052896e-01f, -2.63602704e-01f, -4.68199313e-01f, 1.05791822e-01f, 9.64318439e-02f, -2.81321347e-01f, -6.47106171e-02f, -3.90990116e-02f, -3.96538705e-01f, 6.72228992e-01f,
  -5.07438600e-01f, -3.34621072e-02f, -5.14349759e-01f, -2.11765245e-01f, -4.13366318e-01f, -1.46837756e-01f, 1.19547084e-01f, 4.02751332e-03f, 2.90309787e-01f, 1.50355935e-01f,
  -6.02133609e-02f, -1.49017319e-01f, 1.83796048e-01f, 1.78390935e-01f, 6.00842014e-02f, 2.04708174e-01f, -1.34354427e-01f, -2.07546368e-01f, -1.72559619e-01f, 4.18918133e-02f,
  -1.46420956e-01f, -2.38938257e-01f, -6.88626692e-02f, -3.67241353e-01f, 8.13007429e-02f, -1.22896835e-01f, -1.17217019e-01f, 8.95736963e-02f, 1.68084174e-01f, 7.92005956e-02f,
  -1.44906834e-01f, -2.23930016e-01f, -3.45899373e-01f, -5.02076566e-01f, 2.52971143e-01f, 1.42893925e-01f, 7.99375400e-02f, -1.02450602e-01f, 6.87238649e-02f, 1.28809130e-02f,
  7.62836039e-02f, -2.13501796e-01f, 7.32627511e-02f, -1.60206124e-01f, 7.42827654e-02f, 7.29113817e-02f, 2.07560256e-01f, -4.29057300e-01f, -4.32918638e-01f, 2.20873937e-01f,
  -7.33975917e-02f, 3.96482706e-01f, -9.63118114e-03f, 1.45807251e-01f, 2.57798582e-02f, 1.52385175e-01f, 3.01088989e-01f, 2.12330207e-01f, 5.80374226e-02f, 1.19330831e-01f,
  2.46235058e-01f, -1.18100410e-02f, 4.61602630e-03f, -6.40658056e-03f, 5.42243958e-01f, -5.66311739e-02f, -5.51690519e-01f, -1.66033357e-01f, -2.42237240e-01f, -2.23264232e-01f,
  3.79771411e-01f, -1.84938177e-01f, -1.80402845e-01f, 7.57148042e-02f, 1.25672698e-01f, 3.20173129e-02f, 1.62927255e-01f, 9.51741263e-02f, -1.10429361e-01f, 9.27460045e-02f,
  -6.62044644e-01f, -3.50978374e-02f, 7.38066360e-02f, -3.47955316e-01f, -3.86699229e-01f, -3.00765306e-01f, -2.25899264e-01f, 4.94524926e-01f, 2.39822805e-01f, 1.54007748e-01f,
  -1.91711336e-01f, 1.09630868e-01f, 3.53771001e-01f, 2.30300333e-02f, -3.46518606e-01f, 4.35214490e-03f, 6.21927641e-02f, -6.22036085e-02f, -6.58081770e-01f, -4.75951999e-01f,
  2.13525176e-01f, 3.54633987e-01f, 3.04015633e-02f, -5.29538691e-01f, -2.85400271e-01f, -1.01252809e-01f, 1.39862329e-01f, -3.35864156e-01f, -7.30023012e-02f, 4.91714738e-02f,
  3.97862047e-01f, 8.15835521e-02f, 3.45548242e-01f, -2.52468020e-01f, -3.67012769e-01f, -8.46596733e-02f, 5.72904758e-02f, -1.24446368e-02f, 1.34041592e-01f, -1.06966324e-01f,
  -2.19440296e-01f, -5.64811332e-03f, 1.00928865e-01f, -2.79412001e-01f, -2.42633492e-01f, -1.94331244e-01f, 1.33180633e-01f, -2.08238691e-01f, -1.14888929e-01f, 3.00346971e-01f,
  5.01760468e-02f, 1.56979501e-01f, -1.99440032e-01f, -2.45712817e-01f, -1.04885213e-02f, -1.30960103e-02f, -3.47425461e-01f, -2.34573200e-01f, 1.92868471e-01f, -1.14401951e-01f,
  2.92737484e-01f, -6.55660450e-01f, -2.95861792e-02f, -4.50591832e-01f, -2.75532424e-01f, -1.97134078e-01f, -9.78535488e-02f, -5.00160992e-01f, 1.45325243e-01f, 1.20475933e-01f,
  -8.22631940e-02f, -4.96055126e-01f, -4.71198559e-01f, -4.40172344e-01f, -6.68460906e-01f, -4.48939860e-01f, 2.26496503e-01f, 1.04883768e-01f, -1.27499685e-01f, 1.41621277e-01f,
  2.53117383e-01f, -3.29038173e-01f, 3.33339334e-01f, -4.98391628e-01f, -3.88275124e-02f, 3.96118820e-01f, -5.31836510e-01f, -2.06955187e-02f, -2.40477577e-01f, 1.34794712e-01f,
  2.24125713e-01f, 2.34134465e-01f, -2.92380840e-01f, -3.49412739e-01f, 1.35842592e-01f, 1.03886448e-01f, -7.51810014e-01f, -5.72092354e-01f, 2.20929250e-01f, 7.67508894e-02f,
  -9.98477191e-02f, 1.55705050e-01f, -3.89782816e-01f, 2.07456965e-02f, 1.76178455e-01f, -1.19560473e-01f, -4.15270984e-01f, -2.10453391e-01f, -9.40199867e-02f, -1.17389441e-01f,
  -1.02691345e-01f, -1.70088515e-01f, -2.92280346e-01f, -4.46649939e-01f, -9.21493247e-02f, 1.31136745e-01f, 1.08020216e-01f, -2.63404369e-01f, -1.71181664e-01f, 7.79549330e-02f,
  -3.72607559e-01f, -5.90641284e-03f, 4.15801294e-02f, -2.17657283e-01f, -1.94312975e-01f, -9.37520713e-02f, -4.14519727e-01f, 8.43935311e-02f, -2.03462556e-01f, -2.49573395e-01f,
  -2.57300436e-02f, 2.87961423e-01f, 3.16470057e-01f, -4.66793209e-01f, 1.06470257e-01f, 5.75927556e-01f, 1.33303395e-02f, -2.26492345e-01f, 1.99100271e-01f, -3.49968746e-02f,
  -8.81877318e-02f, -2.31402233e-01f, 9.53717828e-02f, -2.03122571e-01f, -1.70920521e-01f, 1.69715300e-01f, -2.72989333e-01f, -3.19991738e-01f, -1.47045314e-01f, -3.27447861e-01f,
  1.52486607e-01f, 1.53846331e-02f, -3.16503197e-01f, 1.72607318e-01f, -3.93052548e-01f, -2.78677810e-02f, -1.46071628e-01f, -3.82358469e-02f, 1.09336376e-01f, -2.82499492e-01f,
  -5.17756760e-01f, 3.52293223e-01f, -3.55942696e-02f, -4.31217995e-06f, 2.26505101e-01f, 1.34137541e-01f, 4.67472188e-02f, -1.35448882e-02f, 1.07511930e-01f, -1.54819647e-02f,
  1.85262173e-01f, -3.35043967e-02f, 1.91233560e-01f, -3.90685461e-02f, 3.15344721e-01f, -1.69842780e-01f, 1.79963149e-02f, -4.07402128e-01f, -2.97720760e-01f, 4.44458067e-01f,
  2.81024158e-01f, 1.58512831e-01f, 5.04696310e-01f, 4.71886188e-01f, 3.13895017e-01f, 1.02546439e-01f, -3.85471970e-01f, -5.19985676e-01f, -4.51534688e-01f, -1.25237674e-01f,
  -3.18849027e-01f, -3.75758111e-01f, 4.58508104e-01f, 3.11659038e-01f, -8.39544982e-02f, -3.15665096e-01f, 1.90029014e-02f, 1.85183257e-01f, 9.21621323e-02f, -1.66938424e-01f,
  -3.18386555e-01f, 3.66428912e-01f, 3.60790223e-01f, -5.11827588e-01f, -3.68641436e-01f, 2.09066402e-02f, -8.09842423e-02f, -3.77623677e-01f, 9.49764550e-02f, 3.74636203e-01f,
  -8.49439502e-02f, -3.28540176e-01f, -5.28499365e-01f, 4.35531884e-01f, -4.08273637e-01f, -1.57583162e-01f, -8.47810283e-02f, -2.92133331e-01f, -2.81341001e-02f, 1.75004769e-02f,
  -9.57506895e-02f, -2.68720418e-01f, -1.01227202e-01f, 4.11054432e-01f, -1.17466614e-01f, 7.81615600e-02f, 1.57404467e-01f, -1.90988649e-02f, 2.16606274e-01f, -1.19161502e-01f,
  -2.38673523e-01f, 2.99820274e-01f, -1.01575755e-01f, -5.87689504e-02f, -9.64322090e-02f, 4.29122895e-01f, 3.79743010e-01f, 1.60238609e-01f, -7.02072904e-02f, 1.44890174e-01f,
  1.42231658e-01f, -3.66055183e-02f, 1.25173330e-01f, 4.20971662e-01f, 1.23361357e-01f, -3.07931572e-01f, -1.13450401e-01f, 3.01686704e-01f, 1.04678318e-01f, -1.78220183e-01f,
  3.59400213e-01f, -4.34030473e-01f, 1.29374504e-01f, -1.39695168e-01f, -2.14353859e-01f, 1.91701129e-01f, -9.02030617e-02f, 8.08188990e-02f, -4.70476776e-01f, 1.62569415e-02f,
  -1.10172540e-01f, 2.65147328e-01f, 1.40120670e-01f, -4.85871613e-01f, -7.74207413e-01f, -6.31806022e-03f, -4.13094491e-01f, -7.86923617e-02f, 1.88861504e-01f, -2.20538482e-01f,
  -9.55381393e-02f, -3.76805127e-01f, 8.30431804e-02f, 8.92083049e-02f, 7.74652213e-02f, 3.30309086e-02f, -1.15581676e-02f, 7.48297898e-03f, 9.42880958e-02f, 1.78731307e-01f,
  -3.01979482e-01f, -5.45770396e-04f, -9.45384800e-02f, 3.00732017e-01f, -5.55845439e-01f, 8.20863917e-02f, -1.79556563e-01f, -5.31888545e-01f, 6.67484879e-01f, 7.67912492e-02f,
  1.36703640e-01f, 8.64588097e-02f, -3.52429450e-02f, 1.23602338e-01f, -1.09211743e-01f, 1.06478170e-01f, 6.78483471e-02f, -1.98558480e-01f, 8.25631395e-02f, 7.40429163e-02f,
  -7.97175094e-02f, -1.22415178e-01f, -9.79762524e-02f, 2.60800600e-01f, -1.22228019e-01f, -6.37572333e-02f, 3.79116714e-01f, -1.38712093e-01f, 1.99406207e-01f, 2.23301172e-01f,
  -2.03146189e-01f, -3.25140715e-01f, 1.32983759e-01f, -3.57708395e-01f, -3.43452245e-01f, -2.27193221e-01f, 3.53062488e-02f, -5.52107930e-01f, 1.89981624e-01f, 1.87175013e-02f,
  -2.38325343e-01f, 2.08008811e-01f, -2.38565490e-01f, -4.51074600e-01f, -2.72096664e-01f, 3.79309356e-01f, -5.97941637e-01f, 5.87072134e-01f, 1.17322437e-01f, 3.82794678e-01f,
  -1.31085798e-01f, 1.60437956e-01f, -5.39236784e-01f, -5.87139010e-01f, -8.13048124e-01f, -5.61019480e-02f, -2.20848769e-01f, 3.00255299e-01f, -2.91452020e-01f, 3.17901552e-01f,
  2.96653472e-02f, -4.04270023e-01f, 2.79764444e-01f, 2.46902369e-02f, -3.37181240e-01f, -3.06872517e-01f, 2.76197165e-01f, -2.34956592e-01f, -1.54590830e-01f, -4.24140573e-01f,
  -9.00898948e-02f, -1.67217910e-01f, -7.93610930e-01f, 3.51089925e-01f, 2.49674976e-01f, 1.52000800e-01f, -1.40299825e-02f, -3.43784653e-02f, 2.22774148e-01f, 3.18264030e-02f,
  1.11607283e-01f, 2.16891900e-01f, 1.21524125e-01f, 1.65855542e-01f, -1.82029173e-01f, 2.49529183e-01f, 2.50581563e-01f, 5.96432276e-02f, -2.33508274e-01f, 1.86035693e-01f,
  -2.15000883e-01f, 3.24154437e-01f, -3.74600381e-01f, 2.69815892e-01f, 3.44267398e-01f, 3.30916524e-01f, -3.22407514e-01f, 2.39567682e-01f, 2.26576850e-01f, -6.58192039e-02f,
  -3.60457659e-01f, 4.62070614e-01f, -5.13630748e-01f, -4.01814997e-01f, -1.29247621e-01f, -3.05215955e-01f, -2.54784048e-01f, -4.52740520e-01f, -7.58756399e-02f, -4.22774404e-01f,
  -1.11435354e-01f, -4.83002126e-01f, 3.62167656e-01f, -5.44034243e-01f, -2.07570612e-01f, -2.95846034e-02f, 3.06360513e-01f, 3.29257637e-01f, 9.86166596e-02f, 1.17825419e-01f,
  -3.80451053e-01f, 1.16305716e-01f, 4.23272222e-01f, 2.35008612e-01f, -6.89990580e-01f, 5.15764281e-02f, -2.73338277e-02f, 3.63860339e-01f, -2.80571043e-01f, 1.76160514e-01f,
  -2.24149033e-01f, -2.48500735e-01f, -1.61589056e-01f, -4.08321470e-01f, 9.60414112e-02f, 2.48909086e-01f, -3.96296382e-02f, -5.18067896e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.03189108e-02f, -8.97901431e-02f, 3.54289785e-02f, -1.38520464e-01f, 6.65103421e-02f, -7.59782642e-03f, 7.41356835e-02f, 9.04785991e-02f, 4.48182970e-02f, -8.62131566e-02f,
  4.31540720e-02f, 1.53589204e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    