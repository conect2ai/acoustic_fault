/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.61477679e-01f, 1.00041464e-01f, 1.00373263e-02f, -7.87618533e-02f, -7.06849794e-04f, -1.66619331e-01f, -3.39325853e-02f, 5.18675968e-02f, -3.57324928e-02f, 1.45407796e-01f,
  2.13584453e-01f, -1.67880386e-01f, 2.16327891e-01f, 3.95523570e-02f, -3.23703438e-01f, 1.75267369e-01f, -9.80392396e-02f, -8.71729925e-02f, -1.21540334e-02f, -1.02176882e-01f,
  -8.25997069e-03f, 3.26292180e-02f, 9.97823477e-02f, 1.70206502e-02f, -9.72839892e-02f, 4.20214310e-02f, 8.28955695e-02f, 3.03201303e-02f, -2.94026639e-02f, 4.60000597e-02f,
  -1.35954306e-01f, 1.46491006e-01f, -2.06933003e-02f, 5.21222018e-02f, -7.32755959e-02f, 3.10359132e-02f, -7.68084303e-02f, 4.76908460e-02f, 5.40370531e-02f, -1.62232108e-02f,
  -5.50099798e-02f, -2.20024493e-02f, -7.24783242e-02f, -6.16520038e-03f, 5.03475964e-02f, 1.18481200e-02f, 2.00563669e-02f, 2.68547609e-02f, -3.74351665e-02f, -5.29989079e-02f,
  4.96546291e-02f, -6.00500740e-02f, 4.55435291e-02f, -1.30428383e-02f, -3.48561406e-02f, 3.10985763e-02f, -7.32245818e-02f, -5.55618666e-02f, -3.55173536e-02f, -6.56873807e-02f,
  -1.51873371e-02f, -1.96420904e-02f, 1.71913374e-02f, -2.07424946e-02f, 1.73668656e-02f, 6.10274896e-02f, -5.35019375e-02f, -4.15399787e-04f, 1.07607348e-02f, -4.93432023e-02f,
  -5.80749102e-02f, 1.94641743e-02f, -2.60564424e-02f, 2.12772526e-02f, 2.62891594e-02f, -3.19931433e-02f, 3.00489534e-02f, -1.77531112e-02f, -4.56604771e-02f, 2.58635320e-02f,
  2.17999481e-02f, -5.29691316e-02f, 6.16962127e-02f, -1.10186599e-02f, -2.98449825e-02f, -1.21985776e-02f, 6.00498989e-02f, 2.75649391e-02f, 5.60827069e-02f, -1.02954246e-01f,
  -3.11366290e-01f, -2.61170238e-01f, 6.42368868e-02f, -3.82440425e-02f, -2.60243602e-02f, -9.05014947e-02f, 1.85333155e-02f, -5.00001758e-02f, -1.08996499e-02f, -9.49466601e-03f,
  -9.64156985e-02f, -4.84267771e-02f, -2.20503416e-02f, 1.14739994e-02f, -8.07205290e-02f, -3.54615189e-02f, -2.18376075e-03f, -8.16699117e-02f, -2.36354303e-02f, 1.04624582e-02f,
  -1.06497863e-02f, 3.04484535e-02f, -2.85579567e-03f, -1.64174866e-02f, 2.99191233e-02f, -2.34367140e-02f, -4.21182700e-02f, 2.92519983e-02f, -1.23502120e-01f, 9.25966352e-03f,
  2.85065230e-02f, 1.45040542e-01f, 3.05937916e-01f, -2.80355290e-02f, 2.70578619e-02f, -2.25979030e-01f, -3.13800663e-01f, 1.87305976e-02f, 1.96098477e-01f, -1.77339002e-01f,
  -1.53691977e-01f, 2.31237441e-01f, 9.13481414e-03f, -1.58470511e-01f, -3.23689967e-01f, -1.04977377e-01f, -2.80992001e-01f, -1.89941302e-01f, 1.68722093e-01f, -9.31411460e-02f,
  -6.75906078e-04f, -2.52785385e-01f, 8.61967877e-02f, 6.05357289e-02f, -3.54758315e-02f, 1.65407032e-01f, -1.91653684e-01f, 1.71225026e-01f, -3.50519456e-03f, -6.39959946e-02f,
  -1.11428745e-01f, 8.33457932e-02f, 1.55504137e-01f, 8.41740966e-02f, -5.97296134e-02f, -5.39475046e-02f, -2.97304634e-02f, -1.79956444e-02f, -2.09223367e-02f, 2.73709502e-02f,
  -3.79060656e-02f, 3.33295353e-02f, 3.83590185e-03f, 9.62119848e-02f, 1.60612036e-02f, 6.60498217e-02f, 7.31940866e-02f, 1.44770928e-02f, 9.28535163e-02f, 9.25352275e-02f,
  5.54166213e-02f, 5.22357859e-02f, 3.86101641e-02f, 5.53322770e-03f, 4.48448434e-02f, 1.40796676e-02f, 1.98542047e-02f, 3.25509784e-04f, -5.49144205e-03f, 1.43244471e-02f,
  4.00114506e-02f, -5.11182062e-02f, 3.47362570e-02f, 4.67493292e-03f, -7.53462268e-03f, 2.03492753e-02f, 1.62367225e-02f, -3.49891968e-02f, 5.10060377e-02f, -8.15107450e-02f,
  -1.98140088e-02f, -2.98510585e-02f, 3.53162475e-02f, -4.32548337e-02f, -5.20202480e-02f, 2.68123709e-02f, 2.80634239e-02f, -1.09216711e-03f, -8.79943650e-03f, -1.50198772e-04f,
  -2.32591294e-02f, -4.05402444e-02f, 1.61302220e-02f, -6.27532043e-03f, 5.89423701e-02f, 2.10242234e-02f, 4.53090481e-02f, 5.24038672e-02f, 8.33695102e-03f, -4.00679372e-02f,
  -3.34280938e-01f, -2.00936317e-01f, -4.75089438e-02f, -3.86520922e-02f, -6.28296286e-02f, -2.70393416e-02f, -2.78258906e-03f, 7.24928305e-02f, -5.55455759e-02f, -1.27559630e-02f,
  2.83781881e-03f, -3.47746238e-02f, -3.94625179e-02f, -2.32108142e-02f, -5.20701334e-02f, -4.16982770e-02f, -6.20902404e-02f, -3.40365879e-02f, -1.12859182e-01f, -5.83896786e-02f,
  -2.92564724e-02f, -1.62382871e-02f, 2.62918347e-03f, -2.29906440e-02f, -5.52680343e-02f, -3.30393249e-03f, 1.26272673e-02f, 7.63880759e-02f, -7.11528510e-02f, -1.78592131e-02f,
  -2.76682526e-01f, 4.38719094e-01f, 1.53063819e-01f, 2.19276678e-02f, -1.77925497e-01f, -2.16907710e-02f, -7.49075189e-02f, 4.96378988e-02f, 1.55964166e-01f, 1.22039534e-01f,
  -7.05733374e-02f, 1.55199766e-01f, 6.75750077e-02f, 5.42219169e-02f, -3.97859126e-01f, -1.14875762e-02f, -1.07066281e-01f, -2.37383111e-03f, 6.43218011e-02f, -5.56340301e-03f,
  -9.25053135e-02f, -6.77592307e-02f, -5.63210947e-03f, 8.26090053e-02f, -5.17427772e-02f, 1.12107381e-01f, -2.61387140e-01f, 1.00945972e-01f, 2.53633335e-02f, -8.89502987e-02f,
  1.96342561e-02f, 7.62612075e-02f, 7.33965710e-02f, 1.04017824e-01f, 1.49216717e-02f, -4.63270321e-02f, 7.49376277e-03f, 4.10128431e-03f, -2.81362664e-02f, 4.97487709e-02f,
  -1.76302548e-02f, 7.87721947e-03f, 2.16317959e-02f, -3.34476419e-02f, 5.89935146e-02f, 8.62216428e-02f, -9.92660690e-03f, -7.56834522e-02f, 9.49434489e-02f, 4.58461344e-02f,
  3.59876156e-02f, 1.11128567e-02f, -5.79913892e-02f, 3.05752596e-03f, 4.02582325e-02f, -1.29371006e-02f, 1.08510852e-02f, -3.17863822e-02f, 6.50696009e-02f, -5.01343701e-03f,
  -5.84585182e-02f, -6.22612424e-02f, -6.68057725e-02f, -3.83598097e-02f, 4.36807461e-02f, -3.39332037e-02f, -3.37070487e-02f, 5.67073673e-02f, -1.71026997e-02f, -3.10073718e-02f,
  3.96487154e-02f, 2.15654392e-02f, -4.48068157e-02f, 1.05054714e-02f, -7.51089826e-02f, -1.68438088e-02f, -1.74466465e-02f, 3.80001403e-03f, 5.00238240e-02f, -2.39860127e-03f,
  -3.60141695e-02f, -3.94347981e-02f, -2.12751608e-02f, -5.32413796e-02f, 4.48157499e-03f, -6.66020960e-02f, 4.69370326e-03f, 2.33488623e-02f, -3.84371765e-02f, -9.94967669e-02f,
  -5.32184802e-02f, 1.09641604e-01f, -9.02668387e-03f, 3.89392711e-02f, 3.93080749e-02f, -2.83678118e-02f, 9.74312134e-04f, -8.01492948e-03f, 4.03855108e-02f, -1.63771752e-02f,
  -6.57874867e-02f, -2.33187489e-02f, -7.25677237e-02f, -1.41222645e-02f, -9.55041498e-03f, -4.21682708e-02f, 4.22502635e-03f, -3.51724550e-02f, -4.89431024e-02f, 1.32796466e-02f,
  -2.37018429e-02f, -5.25405332e-02f, 3.29938568e-02f, -1.84243582e-02f, -5.07217012e-02f, -2.13025436e-02f, -1.30966166e-02f, 9.62506980e-02f, -5.39280176e-02f, -1.71833858e-02f,
  -4.86366361e-01f, 6.12754263e-02f, -1.50427714e-01f, -1.98598221e-01f, -1.98964011e-02f, -2.15576023e-01f, -1.10919647e-01f, -6.45590620e-03f, -7.49945417e-02f, 1.85710773e-01f,
  1.28610879e-01f, -1.09346725e-01f, 2.07688168e-01f, -1.13574885e-01f, -1.69373691e-01f, 1.07709803e-01f, -1.63233534e-01f, -6.82825446e-02f, -4.05942015e-02f, 1.05343321e-02f,
  -9.52649340e-02f, -3.88517827e-02f, -2.50461581e-03f, 1.32368997e-01f, -7.61368573e-02f, -6.66017309e-02f, 1.53427988e-01f, 1.02467932e-01f, -7.04565644e-02f, -9.47323740e-02f,
  -1.01828553e-01f, -6.57635101e-04f, -3.99957746e-02f, 4.14209291e-02f, 4.68027918e-03f, -7.36405998e-02f, 1.58268232e-02f, -6.23417087e-02f, 2.67507765e-03f, -1.66022591e-02f,
  -5.21981604e-02f, -6.72397837e-02f, -7.66190886e-02f, 2.76324302e-02f, -8.18411931e-02f, -3.57630849e-03f, 4.16225120e-02f, -7.50098974e-02f, -5.46426997e-02f, 1.92344394e-02f,
  -7.91476890e-02f, -6.88975751e-02f, -3.69767770e-02f, -5.52055314e-02f, 2.81205610e-03f, -5.56769818e-02f, -7.52152577e-02f, 2.53739152e-02f, -7.95044377e-02f, -8.10260177e-02f,
  3.35476287e-02f, 1.35910995e-02f, 5.40160798e-02f, -1.87844224e-02f, -6.46689162e-03f, 5.70246987e-02f, 1.66123528e-02f, 2.05026865e-02f, -6.25874326e-02f, 5.98791912e-02f,
  -3.72694097e-02f, 1.56865548e-02f, -3.75718437e-02f, -3.22762020e-02f, -5.34469672e-02f, -4.56018224e-02f, 3.81131098e-02f, 3.97263393e-02f, -3.59699801e-02f, 2.25250814e-02f,
  2.30792351e-02f, 3.55854705e-02f, 2.81662606e-02f, 1.61176326e-03f, 5.64977303e-02f, 5.78329414e-02f, 2.44308989e-02f, -9.63736847e-02f, 7.04971552e-02f, -9.21688136e-03f,
  2.04781303e-03f, 1.61628067e-01f, 8.00154284e-02f, 4.13683578e-02f, 9.65034440e-02f, 2.19247155e-02f, -2.10164674e-02f, 2.32892111e-02f, 5.49290441e-02f, -2.03158968e-04f,
  -2.12911479e-02f, 3.53400297e-02f, 2.62065250e-02f, -5.25404233e-03f, 5.03915548e-02f, -1.49608869e-02f, 4.09047641e-02f, 1.34929447e-02f, -3.24256495e-02f, -2.87559237e-02f,
  6.58947229e-02f, -2.26508137e-02f, -6.55986369e-04f, 2.06605382e-02f, 2.28812229e-02f, 2.41954103e-02f, -7.20249210e-03f, -4.37871106e-02f, 2.43956707e-02f, 2.52641435e-03f,
  -1.69121087e-01f, 2.01791689e-01f, 2.08315924e-02f, -8.67880061e-02f, -1.06517509e-01f, -2.26754636e-01f, -2.02408850e-01f, -8.42888877e-02f, 2.06077412e-01f, 5.76100871e-02f,
  -2.65826076e-01f, 2.81856149e-01f, 9.25971940e-02f, -8.97806659e-02f, -1.65491566e-01f, 1.37179598e-01f, -2.04681739e-01f, 9.13692079e-03f, 1.10804252e-01f, -1.11043602e-02f,
  -8.94857422e-02f, -2.60722227e-02f, -4.45466936e-02f, 1.12118414e-02f, -1.94741488e-01f, 8.28665197e-02f, -1.53331652e-01f, 1.11123331e-01f, -1.20074533e-01f, 1.03517380e-02f,
  -8.66681188e-02f, 7.73135200e-02f, -3.56240571e-02f, 1.36143714e-01f, -7.74691775e-02f, -8.00111368e-02f, 3.40310149e-02f, 5.25072310e-03f, 1.00358920e-02f, 5.44667877e-02f,
  8.36195126e-02f, -2.16396879e-02f, 1.17587887e-01f, 1.10444777e-01f, -1.82525031e-02f, 4.17477041e-02f, -4.27348493e-03f, -9.22907367e-02f, 6.27791462e-03f, -4.67931703e-02f,
  2.96367034e-02f, -5.83524890e-02f, -1.67939402e-02f, 2.65550800e-02f, 2.01892629e-02f, 2.03634659e-03f, 1.30172307e-02f, 2.34939754e-02f, -2.63730008e-02f, -3.15218903e-02f,
  -5.98165505e-02f, 9.08464715e-02f, 2.47395542e-02f, 7.13447016e-03f, 1.19925160e-02f, -5.14007695e-02f, -5.07212291e-03f, -1.06592597e-02f, 6.89263493e-02f, -5.98817989e-02f,
  6.26705363e-02f, -1.67884640e-02f, -6.97809756e-02f, -3.80453952e-02f, -7.56891444e-02f, -2.34557949e-02f, -6.19596168e-02f, 7.98945781e-03f, -4.23889533e-02f, -5.33691272e-02f,
  5.26030399e-02f, -6.51345309e-03f, -1.02816811e-02f, -2.07859576e-02f, -4.90235724e-02f, -2.51943674e-02f, -4.96667437e-02f, -4.23492864e-02f, 1.98524985e-02f, -7.06356466e-02f,
  -1.29082933e-01f, 1.64667398e-01f, 8.67040008e-02f, -3.39162126e-02f, 2.14218106e-02f, -2.69693285e-02f, 1.78367812e-02f, -3.99658866e-02f, 5.74974008e-02f, -5.39131016e-02f,
  -1.12100437e-01f, -7.03101186e-03f, -4.67647202e-02f, 1.11221503e-02f, 5.22907861e-02f, -5.21972552e-02f, 6.12821057e-02f, 6.78509995e-02f, -1.09374486e-02f, -7.10572526e-02f,
  -5.35080917e-02f, 4.93640825e-02f, 3.16365436e-03f, -3.31692025e-02f, 2.99297310e-02f, -4.70243581e-02f, -1.08986497e-02f, -1.44064175e-02f, 6.12403564e-02f, 9.04505402e-02f,
  1.37817413e-01f, 1.37293890e-01f, 1.27190396e-01f, 6.57419302e-03f, 8.97839442e-02f, -1.75616637e-01f, 7.76650980e-02f, -1.09263070e-01f, -1.65831193e-01f, 3.11259720e-02f,
  -1.01410029e-02f, 1.46036595e-01f, 5.62617667e-02f, -1.70138568e-01f, -1.73452452e-01f, -1.12359554e-01f, -1.81074858e-01f, -5.63527979e-02f, -7.83225819e-02f, 1.47328481e-01f,
  -1.07045077e-01f, -1.46752382e-02f, -1.44623714e-02f, -2.76403595e-02f, 9.61002484e-02f, 9.58471075e-02f, 1.07925706e-01f, 7.55829066e-02f, 1.08488992e-01f, -6.60905316e-02f,
  8.15665256e-03f, 7.65513256e-02f, 7.17095435e-02f, 6.88294247e-02f, 6.97559267e-02f, 7.98971429e-02f, -4.11683135e-02f, 6.51033446e-02f, 3.25023606e-02f, -4.71342169e-02f,
  6.40223548e-02f, 6.38585314e-02f, -3.35253999e-02f, -7.81985745e-02f, -5.26626743e-02f, -1.85013860e-02f, -6.54922798e-02f, -3.32617834e-02f, 2.24275738e-02f, 2.90006213e-02f,
  3.31208184e-02f, -3.97265628e-02f, 3.95696126e-02f, 1.14743542e-02f, -1.14252232e-02f, -2.33637113e-02f, -3.96770164e-02f, -8.10662191e-03f, 1.54790888e-02f, -6.11986704e-02f,
  -2.48800199e-02f, -4.46506478e-02f, 6.25686124e-02f, 4.95374994e-03f, 4.76073623e-02f, 4.03422303e-03f, 4.60105166e-02f, -3.91916698e-03f, 3.14398631e-02f, 8.60861503e-03f,
  -8.99626687e-03f, 2.21204516e-02f, -5.94127215e-02f, 4.53420244e-02f, -1.11869788e-02f, 3.95226963e-02f, 9.52738598e-02f, 9.85221043e-02f, -1.71157997e-02f, 4.83588688e-02f,
  -6.37975112e-02f, 1.29808560e-02f, 9.71634686e-03f, 3.81451584e-02f, -6.44608960e-02f, -5.75053506e-02f, -4.90269661e-02f, -7.86917061e-02f, 9.12159588e-03f, 6.97050765e-02f,
  1.63893744e-01f, 1.49411276e-01f, 5.14014885e-02f, 7.30199590e-02f, -4.47108112e-02f, -7.67086148e-02f, 2.77260598e-02f, -7.79592693e-02f, 5.04284108e-04f, -1.30643798e-02f,
  5.41472062e-02f, -7.38440827e-02f, 5.68216480e-02f, 1.05777206e-02f, -1.13536445e-02f, 7.91919697e-03f, 1.06057763e-01f, -2.87458617e-02f, -6.14914484e-03f, 1.11943021e-01f,
  1.39138326e-01f, 1.16559722e-01f, -6.82769809e-03f, -7.56973028e-02f, -2.53490191e-02f, -5.21497009e-03f, 3.33747678e-02f, -7.67512172e-02f, -2.44166758e-02f, 1.99180581e-02f,
  -1.22007437e-01f, 1.70384586e-01f, 4.97620441e-02f, -1.10338703e-02f, -1.21194176e-01f, 2.72323877e-01f, 2.86705554e-01f, -1.92416683e-01f, -6.95240870e-02f, 1.68162316e-01f,
  5.72211901e-03f, 1.61038816e-01f, 1.05066225e-01f, 2.85476387e-01f, 7.19882101e-02f, 2.46871799e-01f, 1.29182205e-01f, 2.33924329e-01f, 3.92370038e-02f, 2.61154696e-02f,
  -1.04883283e-01f, 4.96443212e-02f, -1.42851220e-02f, -1.73018381e-01f, -3.75802107e-02f, -2.36669302e-01f, -1.86346918e-01f, -1.12007245e-01f, 5.04479297e-02f, 6.91483840e-02f,
  3.63088548e-02f, 2.98536234e-02f, -3.91594321e-02f, 2.98495721e-02f, -4.57109921e-02f, -6.43019676e-02f, -1.20606795e-02f, 4.47335765e-02f, -6.16938658e-02f, -4.65833861e-03f,
  6.42529353e-02f, -6.48750737e-02f, -4.23477329e-02f, 1.76059697e-02f, -5.45315035e-02f, -3.84400859e-02f, 3.58387688e-03f, -2.85326503e-02f, 4.10548076e-02f, 4.38921116e-02f,
  -1.63037479e-02f, 3.18098553e-02f, 1.93935353e-02f, 2.38450081e-03f, 1.37801059e-02f, 3.65061406e-03f, 9.60943624e-02f, 3.14384066e-02f, 4.56037140e-03f, -5.02047176e-03f,
  -6.03363104e-02f, 2.89326534e-02f, -1.67184055e-03f, 3.43367569e-02f, -3.48741189e-02f, 1.05527770e-02f, 4.60107476e-02f, 2.18324759e-03f, -1.56453699e-02f, 1.78741887e-02f,
  -1.69399045e-02f, -1.65362246e-02f, -4.42395769e-02f, -1.15726395e-02f, 2.76968051e-02f, -3.53982393e-03f, 8.69546365e-03f, 4.96915020e-02f, 1.57583635e-02f, 3.75966392e-02f,
  3.88626792e-02f, -2.20482871e-02f, 1.40361488e-02f, 1.15708262e-03f, 9.13767330e-03f, -2.14839075e-02f, 1.06407772e-03f, -2.94237714e-02f, -3.41823958e-02f, 1.03509920e-02f,
  9.68077555e-02f, 3.63802910e-02f, -4.33881469e-02f, 4.61093560e-02f, 5.81527874e-02f, 6.14950806e-02f, 9.65911895e-02f, 2.82297507e-02f, -6.54633995e-03f, 2.28333734e-02f,
  2.65978593e-02f, 3.01946923e-02f, 2.15165108e-03f, -3.03310454e-02f, 6.12133369e-02f, 5.67158498e-02f, -7.09659129e-04f, 3.38898674e-02f, -9.61864740e-03f, -4.66677211e-02f,
  -5.53610176e-02f, -1.88177358e-02f, 5.11633009e-02f, -3.33628915e-02f, -9.15318448e-03f, -5.77097423e-02f, -1.30390637e-02f, 1.72572222e-03f, -2.79752407e-02f, 1.05055189e-02f,
  -2.97428906e-01f, 2.87255142e-02f, -3.39011639e-01f, -2.95955300e-01f, 3.48875970e-02f, 1.90537460e-02f, -2.81957805e-01f, 2.35848594e-02f, 2.93465480e-02f, 1.94368333e-01f,
  -2.76722610e-02f, -4.50243540e-02f, -3.97509038e-02f, -1.49690956e-01f, -2.34283775e-01f, -8.31308588e-03f, -1.27223268e-01f, -4.00351547e-02f, 1.28766727e-02f, -9.07201692e-02f,
  -9.33285356e-02f, 7.92772323e-02f, -3.06178391e-01f, 1.11342080e-01f, -1.68115288e-01f, -4.62104194e-02f, 8.44682604e-02f, 3.43103968e-02f, 3.16429399e-02f, 3.06382086e-02f,
  -1.13083273e-01f, -5.08770347e-02f, -8.48320946e-02f, -1.06878234e-02f, -2.22835410e-02f, -2.10796623e-03f, -2.76296362e-02f, -5.90001494e-02f, -7.92729780e-02f, 3.63314860e-02f,
  2.76116040e-02f, -2.37047188e-02f, 5.09141833e-02f, -8.99331458e-03f, -1.52900135e-02f, 2.89504267e-02f, -7.65169039e-02f, -4.00695503e-02f, -2.18672398e-02f, -4.70543802e-02f,
  -3.95815969e-02f, -2.99741118e-03f, -9.63553041e-03f, -4.57590166e-03f, -3.75283435e-02f, -2.25871019e-02f, 4.51939218e-02f, 5.01580127e-02f, 2.35210396e-02f, 7.28093162e-02f,
  9.08401981e-02f, -1.12805683e-02f, -2.67541446e-02f, -2.14742613e-03f, -6.50703311e-02f, -1.26670711e-02f, -2.10650899e-02f, 3.47917676e-02f, -2.65587494e-02f, 3.35493460e-02f,
  -3.47081311e-02f, 4.74332273e-03f, 1.42398407e-03f, 1.10942572e-02f, -1.46646472e-02f, -1.70141384e-02f, -6.96814135e-02f, 5.01605086e-02f, 2.88821815e-04f, -5.60114644e-02f,
  -8.18903279e-03f, 7.69666135e-02f, -1.76019687e-02f, 4.56888154e-02f, -2.71597262e-02f, -2.67791077e-02f, 5.18961474e-02f, 1.06545109e-02f, -2.75289062e-02f, -5.07483929e-02f,
  1.80614948e-01f, 2.41100222e-01f, -1.85413088e-03f, 3.54617238e-02f, 6.04444630e-02f, 8.31883326e-02f, 4.24860716e-02f, -8.75703245e-03f, 3.82715836e-02f, -1.64450184e-02f,
  5.85299768e-02f, -2.36939527e-02f, 6.98660240e-02f, 1.53372493e-02f, 2.81600934e-02f, 5.79095865e-03f, 8.54797885e-02f, 2.34310199e-02f, -2.15099799e-03f, -1.46699976e-02f,
  -2.73446739e-02f, -5.35578758e-04f, -2.80402694e-02f, 7.49782771e-02f, 8.28642398e-02f, 9.03687999e-03f, 3.44898105e-02f, -4.67249379e-02f, 3.22515890e-02f, 6.33501622e-04f,
  -1.85506985e-01f, 1.22935601e-01f, -1.78801060e-01f, -3.83677989e-01f, 6.34101629e-02f, 8.21281150e-02f, -4.80328035e-03f, 9.82817560e-02f, 9.97402221e-02f, 1.22491620e-01f,
  9.38932523e-02f, -1.77521363e-01f, 1.52856082e-01f, -1.82410777e-01f, -1.73659101e-01f, 1.39712572e-01f, -1.96893029e-02f, -7.45230615e-02f, 1.55296922e-01f, -7.61488006e-02f,
  -1.48508906e-01f, -5.35304286e-02f, -1.80970758e-01f, 4.92936783e-02f, -1.77317351e-01f, -1.18080363e-01f, -1.22352839e-01f, 1.02238968e-01f, -2.49414831e-01f, -3.64703536e-02f,
  5.95134087e-02f, 2.08881521e-03f, -1.39788702e-01f, 4.00319435e-02f, -1.03127122e-01f, -3.37680168e-02f, 6.03582663e-03f, 4.87664714e-02f, 5.11245430e-02f, 4.34152186e-02f,
  -2.54001468e-02f, -7.69598270e-03f, 3.35706361e-02f, 9.88970697e-02f, 4.58195806e-02f, -6.20074682e-02f, -1.80496164e-02f, -6.09631836e-02f, -3.04465368e-02f, 1.31947557e-02f,
  -6.83418661e-02f, -6.00554608e-02f, -4.93159704e-02f, 4.78056893e-02f, -2.38375715e-03f, 1.00097507e-02f, -6.19326569e-02f, -9.62146372e-02f, -4.77753580e-02f, -9.11797583e-02f,
  6.53900802e-02f, 6.20033406e-02f, -2.04162169e-02f, -2.89980080e-02f, -5.20140342e-02f, 2.17124037e-02f, -6.13509901e-02f, 1.24330269e-02f, -4.69837934e-02f, 2.05328744e-02f,
  -5.27361594e-02f, 2.82595363e-02f, 1.75752435e-02f, -7.24305287e-02f, -3.37889455e-02f, -6.20304793e-02f, 1.06406510e-02f, 3.83901559e-02f, -4.30195704e-02f, -5.37312329e-02f,
  -2.12192424e-02f, 3.26439850e-02f, -1.41425245e-02f, -5.54925203e-02f, -4.89608198e-03f, 7.57421926e-03f, 4.02072109e-02f, -1.68084316e-02f, -4.32377458e-02f, 1.14584500e-02f,
  1.47893667e-01f, 1.99736618e-02f, 4.66316044e-02f, 4.70760837e-02f, 7.91497622e-03f, 1.09519288e-02f, 4.70401160e-02f, 3.64598408e-02f, 1.37199154e-02f, 1.85768008e-02f,
  2.21113618e-02f, -9.67796601e-04f, -3.85865755e-02f, -1.73318945e-02f, -2.69227494e-02f, -3.67321298e-02f, -7.32683241e-02f, 1.61787681e-02f, 2.56910045e-02f, 4.50782999e-02f,
  -6.16852008e-02f, 2.12198887e-02f, -5.84766604e-02f, 1.41306641e-02f, -1.15580549e-02f, -8.81153941e-02f, 8.14225338e-03f, -3.15273479e-02f, -3.96130569e-02f, 5.19255400e-02f,
  -1.39408037e-01f, -2.91294325e-02f, 1.46392167e-01f, -1.46821991e-01f, 1.11243995e-02f, -2.38723636e-01f, -7.61896074e-02f, -1.59002528e-01f, -2.13114321e-01f, -1.05931692e-01f,
  -5.99928871e-02f, 4.04003225e-02f, 2.04267263e-01f, -2.50266165e-01f, -1.65459424e-01f, -1.56787291e-01f, -2.63550669e-01f, -2.04273254e-01f, -6.03374839e-02f, -6.03887998e-03f,
  -8.35798681e-02f, -1.74607143e-01f, 3.25455070e-02f, -1.12952039e-01f, 1.51272221e-02f, 9.39772129e-02f, 1.06074817e-01f, 2.63080716e-01f, 1.46959967e-03f, -2.50353012e-02f,
  -8.65807906e-02f, 3.24429646e-02f, -3.21111940e-02f, -5.43881096e-02f, -2.24291645e-02f, 5.08137643e-02f, -6.34742342e-03f, -1.47252204e-02f, -4.77807038e-02f, -2.90455800e-02f,
  5.49651776e-03f, -4.71164007e-03f, -2.16581076e-02f, -4.56384346e-02f, -6.53615519e-02f, 2.39787381e-02f, 3.20431739e-02f, 2.39199549e-02f, 3.21114697e-02f, 3.36588100e-02f,
  1.69815477e-02f, -2.99210921e-02f, 9.24462729e-05f, -1.98002048e-02f, 3.63406129e-02f, -1.83860678e-02f, 6.35220706e-02f, 1.06195509e-01f, -2.47417632e-02f, -5.87657876e-02f,
  2.67267087e-03f, 3.14723514e-02f, -3.08963098e-02f, -7.18245581e-02f, 5.30541390e-02f, 2.95549501e-02f, -4.20581773e-02f, 7.47747272e-02f, -1.77774783e-02f, -6.23670500e-03f,
  2.03361511e-02f, -3.93513180e-02f, -3.42455544e-02f, -1.88900698e-02f, 5.45274690e-02f, -2.75345258e-02f, 6.63192663e-03f, 3.60231437e-02f, -6.32438287e-02f, 2.05505989e-03f,
  2.46938970e-02f, -6.21144548e-02f, 7.87783191e-02f, 3.12873125e-02f, -7.21404478e-02f, 2.85589844e-02f, -3.32782641e-02f, -8.28219636e-04f, 1.42665170e-02f, 1.07250605e-02f,
  1.08264312e-02f, 7.15039065e-03f, -2.29400326e-03f, -4.73832563e-02f, 5.44049032e-02f, -4.54334021e-02f, -2.76258681e-02f, -3.98702584e-02f, 6.80195019e-02f, -5.81775606e-02f,
  4.89865504e-02f, -5.09191267e-02f, 3.24738547e-02f, 4.28336896e-02f, 5.81154972e-02f, -5.02675362e-02f, -2.23788363e-03f, 1.66931637e-02f, -1.80425309e-02f, 4.94795479e-02f,
  9.40941796e-02f, 5.39482757e-03f, 3.56490314e-02f, -1.01267779e-02f, 6.55459845e-03f, 4.53804433e-02f, 1.94880739e-02f, 6.53747022e-02f, 6.73892675e-03f, -5.35954684e-02f,
  -1.13053329e-01f, 6.67743161e-02f, -2.21306132e-03f, 1.22613072e-01f, -4.64643911e-02f, -2.89927453e-01f, -1.22539073e-01f, 6.88931346e-02f, -2.73344442e-02f, 8.42731819e-02f,
  -1.35593072e-01f, 1.14487652e-02f, -2.50753671e-01f, 8.03838447e-02f, -3.61045331e-01f, -2.61726767e-01f, -3.65370922e-02f, -9.30657145e-03f, 4.17391509e-02f, -1.59422737e-02f,
  2.75593549e-02f, -8.09844658e-02f, 6.08786978e-02f, 1.80089742e-01f, -2.84813773e-02f, 2.33846277e-01f, -5.20695350e-04f, 3.29236016e-02f, 3.53119075e-02f, -5.83389886e-02f,
  -6.65949211e-02f, -1.22913811e-02f, 4.97108661e-02f, -4.40853275e-02f, -8.26392174e-02f, -2.54715439e-02f, 4.88592051e-02f, 2.97620930e-02f, 4.06457782e-02f, -5.42062372e-02f,
  -5.47581352e-02f, 9.09678638e-03f, 9.41014215e-02f, -4.59507369e-02f, -1.88518781e-02f, -1.24721173e-02f, -1.21806180e-02f, 5.11705466e-02f, 5.44725731e-02f, 3.64236683e-02f,
  -1.79691892e-03f, 3.00911143e-02f, 6.41346499e-02f, 1.28256753e-02f, 3.86041030e-02f, 5.46004325e-02f, -1.74366252e-03f, -4.35615890e-03f, -9.59170144e-03f, -5.24800718e-02f,
  7.71230012e-02f, 3.13513502e-02f, -3.49152051e-02f, 2.08644308e-02f, -9.72843170e-03f, 2.11416488e-03f, 2.75670625e-02f, -1.78681426e-02f, -4.74046506e-02f, -8.51259977e-02f,
  -4.39269841e-02f, -1.38274608e-02f, 4.75608259e-02f, -3.04212682e-02f, 2.67784204e-02f, 2.85659414e-02f, 4.22216207e-02f, -1.20035699e-03f, 6.46525398e-02f, -4.84737866e-02f,
  3.25009264e-02f, -7.00158998e-02f, 6.48602843e-02f, -2.29015257e-02f, -3.06901708e-02f, 3.71670835e-02f, 1.88955991e-03f, -2.29512546e-02f, 2.65680160e-03f, 1.64584145e-02f,
  -2.94989884e-01f, -1.49763584e-01f, 2.64823698e-02f, -6.11451715e-02f, -8.40564445e-03f, -2.50396132e-02f, 2.59336568e-02f, -1.71482861e-02f, -7.97392577e-02f, 8.63651559e-03f,
  5.04812524e-02f, -9.65868589e-03f, -3.51376161e-02f, -1.95198972e-02f, -6.65055364e-02f, 2.30692159e-02f, -3.12621668e-02f, -1.58358011e-02f, 2.09148740e-03f, 7.41591025e-03f,
  3.91989313e-02f, 3.87991546e-03f, -1.82456430e-02f, 3.62572707e-02f, -3.29131633e-02f, -1.28098791e-02f, 5.62376902e-02f, 8.60829949e-02f, 8.55128560e-03f, -2.57163085e-02f,
  4.34184045e-01f, 1.07198171e-02f, 1.44380644e-01f, 2.23429143e-01f, 1.68805588e-02f, -5.37267737e-02f, 1.86251193e-01f, 7.33701140e-02f, 5.80351911e-02f, -5.67696150e-03f,
  -5.88294938e-02f, 2.36592710e-01f, -2.08046570e-01f, 1.68151960e-01f, 2.27292612e-01f, -1.52540371e-01f, 1.74969539e-01f, 7.87529051e-02f, 5.46539377e-04f, 1.76150277e-01f,
  4.98409048e-02f, -6.81724353e-03f, 1.11808591e-01f, -1.70627400e-01f, 1.39047757e-01f, 1.11680880e-01f, -7.15331063e-02f, -1.04207270e-01f, 3.37821916e-02f, 3.63748595e-02f,
  2.13176422e-02f, 2.58661825e-02f, 1.05821878e-01f, 1.09982670e-04f, -3.85337602e-03f, 1.01240007e-02f, 9.88873001e-03f, -1.77961141e-02f, -4.29001600e-02f, 7.00881407e-02f,
  3.66231985e-02f, -7.03714415e-03f, 4.81555164e-02f, 2.54757684e-02f, 6.58838823e-02f, -5.82426265e-02f, -4.37405594e-02f, 4.29316983e-02f, -1.33029679e-02f, 5.43623678e-02f,
  7.22309947e-02f, 1.70869324e-02f, -3.94789828e-03f, -1.49739231e-03f, -8.64278339e-03f, 1.85122062e-02f, -5.76079171e-03f, 5.76846041e-02f, 2.63711670e-03f, 1.13684237e-02f,
  5.98218925e-02f, 3.85195799e-02f, -3.60776810e-03f, -2.15790980e-02f, -3.06824241e-02f, -4.69408222e-02f, 4.98487651e-02f, -5.72388954e-02f, 6.86675534e-02f, -3.00652813e-02f,
  -4.59139189e-03f, -1.10349432e-02f, 2.07743943e-02f, -1.93161853e-02f, 4.18630103e-03f, 2.19991710e-02f, 2.39417218e-02f, 2.98346430e-02f, -1.88864376e-02f, -3.72077860e-02f,
  -6.40607849e-02f, 3.03037949e-02f, 2.23245509e-02f, -1.84366794e-03f, -5.75270988e-02f, -2.89543029e-02f, -7.91593641e-03f, -1.08226910e-02f, -5.93365319e-02f, 5.62430825e-03f,
  -2.54313666e-02f, 1.90425768e-01f, -7.65571743e-02f, -9.04685780e-02f, -3.07275895e-02f, 3.22905295e-02f, 2.94408738e-03f, 6.94740564e-02f, 3.08439508e-02f, -2.49448884e-02f,
  -1.40067451e-02f, 4.95809689e-03f, 5.12036902e-04f, -2.93672048e-02f, 7.99723435e-03f, 5.93674481e-02f, 8.82207677e-02f, -6.76336959e-02f, 9.73707587e-02f, -1.74824279e-02f,
  1.04539776e-02f, -2.63963435e-02f, 6.92157298e-02f, 1.69099215e-02f, 5.12006767e-02f, 3.32090911e-03f, 6.37769103e-02f, 2.33633537e-02f, -4.81172116e-04f, -5.42726666e-02f,
  -2.21273899e-01f, -6.61189035e-02f, 1.52333826e-01f, -1.99509829e-01f, -1.16362134e-02f, 1.17903851e-01f, -3.96425650e-03f, -7.97003284e-02f, -2.95329511e-01f, -1.68572873e-01f,
  -8.73069465e-03f, -4.12152931e-02f, 1.82936072e-01f, 5.21696247e-02f, 2.38943845e-01f, 2.27852851e-01f, -1.00623123e-01f, -1.05950572e-02f, -2.96790916e-02f, -1.97892323e-01f,
  -6.47345558e-03f, 1.67744011e-02f, 2.39500180e-01f, 3.74484956e-02f, -4.27277200e-02f, -7.97209442e-02f, -5.76218255e-02f, 2.34111790e-02f, 8.19330364e-02f, 1.24162756e-01f,
  6.78961445e-03f, -2.36244828e-01f, 3.72608542e-03f, -9.03763168e-04f, -2.57562427e-03f, -4.77826362e-03f, -3.66208628e-02f, 8.92096832e-02f, -3.37281115e-02f, -1.64675538e-03f,
  5.12794182e-02f, 7.10699558e-02f, 4.23501432e-02f, 1.68616865e-02f, -5.39626740e-02f, 9.43336263e-03f, 4.37296042e-03f, 4.61338386e-02f, -5.18184267e-02f, 8.72732848e-02f,
  4.48871255e-02f, 2.51817256e-02f, -3.22665088e-02f, -3.88512574e-02f, 2.56271828e-02f, 2.69489475e-02f, -1.79065689e-02f, 2.15783753e-02f, -8.40811431e-02f, -2.55805403e-02f,
  -6.44820258e-02f, -5.04629966e-03f, 1.19220968e-02f, 2.01198664e-02f, -3.76713723e-02f, 1.56886708e-02f, -1.28860008e-02f, 5.34498766e-02f, 1.52374981e-02f, -4.62413132e-02f,
  -2.42436212e-02f, -5.91419041e-02f, -3.16726440e-03f, -5.77749461e-02f, 5.99427102e-03f, -1.11864641e-01f, 8.69956538e-02f, -5.06604416e-03f, -5.98803796e-02f, 2.75796615e-02f,
  -7.12629184e-02f, 9.81066027e-04f, 5.05971164e-03f, -3.62325124e-02f, 4.95160855e-02f, -1.74000300e-02f, 2.44705845e-02f, -3.56662087e-02f, -2.87235379e-02f, -2.64614858e-02f,
  -2.86483794e-01f, -2.67597407e-01f, 1.45253660e-02f, -1.83222853e-02f, -5.33983996e-03f, -5.03454320e-02f, 4.96464893e-02f, 5.60880173e-03f, -5.50343283e-02f, -4.31737378e-02f,
  -6.86896220e-02f, -5.80409877e-02f, -6.36682957e-02f, -2.34571774e-03f, 9.51359980e-03f, 8.85865837e-03f, 7.22413557e-03f, -7.12542087e-02f, 2.58992761e-02f, -6.49584010e-02f,
  2.01190971e-02f, -6.04823865e-02f, 1.15300184e-02f, 3.39168310e-03f, 1.74146108e-02f, -5.20182922e-02f, -4.54665497e-02f, -7.75097217e-03f, 2.16892944e-03f, 4.47782837e-02f,
  1.32414520e-01f, -5.17798603e-01f, -5.26004098e-03f, -2.83699214e-01f, 1.56573325e-01f, -2.50174478e-02f, -1.39506906e-01f, -1.25099644e-01f, -1.91600606e-01f, -3.18814695e-01f,
  -1.18656516e-01f, -1.52427748e-01f, -1.88392907e-01f, -2.53068238e-01f, 1.41085267e-01f, -1.51387900e-01f, -2.28395641e-01f, -1.85339555e-01f, -1.21349348e-02f, -1.23038895e-01f,
  -2.21748520e-02f, -1.93696588e-01f, 2.77148150e-02f, -9.04331505e-02f, -1.05759569e-01f, -7.62609094e-02f, -3.55481170e-02f, 1.43466279e-01f, -1.90977415e-03f, 1.17673963e-01f,
  4.65454236e-02f, -1.34804904e-01f, 3.67198326e-02f, 3.77196036e-02f, -1.25675006e-02f, 3.67185809e-02f, 7.96303675e-02f, 7.53558949e-02f, 8.06801990e-02f, -1.27324397e-02f,
  5.25427284e-03f, -3.17456038e-03f, -1.35789495e-02f, -2.89512146e-02f, -5.43453246e-02f, 6.67617172e-02f, -7.46311108e-03f, -1.61937326e-02f, 3.76536790e-03f, 4.39956188e-02f,
  -1.76444687e-02f, 7.23863021e-02f, -2.75143143e-03f, -5.77994920e-02f, 4.37948387e-03f, 3.25400452e-03f, 2.20206324e-02f, 4.44754101e-02f, -8.21209103e-02f, -5.22040986e-02f,
  -5.21888882e-02f, -1.95741351e-03f, -5.59010319e-02f, 6.87746927e-02f, -2.25591790e-02f, 3.66746858e-02f, -7.97893794e-04f, -2.34452039e-02f, 9.91487037e-03f, 2.84751016e-03f,
  1.57758892e-02f, 1.22953681e-02f, -7.02578854e-03f, 1.23278648e-02f, -2.52163019e-02f, 3.57435569e-02f, 6.00574426e-02f, -4.22450341e-02f, 2.62433998e-02f, 2.86695100e-02f,
  -1.95015501e-02f, 3.63071798e-03f, -2.73300912e-02f, 5.47868162e-02f, 1.46046514e-02f, -1.18523380e-02f, -3.54627445e-02f, -2.66406382e-03f, 2.08215490e-02f, 4.81891856e-02f,
  -2.03390092e-01f, -3.11111927e-01f, -4.05123048e-02f, -3.83103080e-02f, 2.83885580e-02f, 6.02873564e-02f, -4.70000319e-02f, -4.97265197e-02f, -7.19674677e-02f, 2.39848495e-02f,
  6.23547733e-02f, 1.56605672e-02f, -2.87476722e-02f, 2.16037389e-02f, 9.72483493e-03f, -8.36450532e-02f, 3.11376108e-03f, 4.24318612e-02f, -2.10753512e-02f, -4.91087586e-02f,
  -7.13237599e-02f, -2.81464290e-02f, 5.24654724e-02f, 2.85334159e-02f, -2.31050383e-02f, 3.52860405e-03f, -2.16991100e-02f, -9.01153032e-03f, 2.40907958e-03f, -4.54720296e-03f,
  4.26234424e-01f, -8.45656320e-02f, 1.20952316e-01f, 4.72734272e-01f, -4.13897485e-02f, -1.22836702e-01f, 1.43977135e-01f, -4.02200297e-02f, 3.31210315e-01f, -1.67696714e-01f,
  -2.32202150e-02f, 6.46799877e-02f, -1.60490185e-01f, 7.30134994e-02f, 1.69522151e-01f, -1.81408763e-01f, 1.46060765e-01f, 8.51048976e-02f, 3.21851708e-02f, 1.08417325e-01f,
  2.20726058e-01f, -4.66965772e-02f, 2.29691248e-03f, -1.68072164e-01f, 5.71399406e-02f, 1.07079946e-01f, -1.13965549e-01f, -8.85436311e-02f, 5.85379545e-04f, -9.45516378e-02f,
  -2.12977994e-02f, 4.33974639e-02f, 1.49321817e-02f, -3.06778848e-02f, -1.87386405e-02f, 2.98827831e-02f, 1.08318059e-02f, 3.23798098e-02f, 7.69473761e-02f, 7.00746849e-02f,
  3.51597331e-02f, 5.54228434e-03f, 7.77951851e-02f, -1.74643863e-02f, 9.79568735e-02f, 9.21186134e-02f, -1.94029801e-03f, -2.69787144e-02f, 2.24466082e-02f, -5.09701786e-04f,
  4.28689411e-03f, -3.73297371e-02f, 6.61350861e-02f, -8.63432139e-02f, 3.05184629e-02f, 2.10639220e-02f, -5.77722043e-02f, 2.70968638e-02f, -1.33998031e-02f, 7.41418079e-02f,
  4.06784676e-02f, -4.25833091e-02f, 9.90237109e-03f, -3.00980881e-02f, 1.20087741e-02f, 2.42963471e-02f, -5.61755337e-02f, -3.02001368e-03f, -2.30043046e-02f, -1.28204161e-02f,
  6.89352900e-02f, 8.25850642e-04f, -4.10682671e-02f, 6.07109293e-02f, 1.85370781e-02f, 4.63311444e-04f, -5.90700917e-02f, -6.52592555e-02f, 5.44362999e-02f, -1.14529692e-02f,
  -6.35404959e-02f, -1.42472591e-02f, -3.80389169e-02f, -4.74543199e-02f, 1.49788130e-02f, -5.41413156e-03f, 4.88154218e-02f, -3.01217251e-02f, 2.85163019e-02f, 4.29403260e-02f,
  6.32182043e-03f, -2.35947259e-02f, 3.60648930e-02f, -7.48087652e-03f, 2.55104937e-02f, -5.34867160e-02f, 1.38891451e-02f, -2.73369439e-02f, -4.51398455e-03f, -1.85916610e-02f,
  -1.20255994e-02f, -2.26049609e-02f, -1.50580460e-03f, 5.10951243e-02f, -2.26112623e-02f, -5.76425008e-02f, 5.11775687e-02f, 4.17299345e-02f, 2.29097456e-02f, -4.92894650e-02f,
  -2.41774712e-02f, 2.00433880e-02f, 3.41657177e-02f, 4.24746238e-02f, 8.91155843e-03f, 1.29180411e-02f, 7.94485062e-02f, -5.66308945e-03f, 1.45375514e-02f, -6.24594539e-02f,
  3.16599131e-01f, -5.78043126e-02f, -2.22144648e-02f, 2.35888392e-01f, -2.26562992e-02f, -1.09979503e-01f, -1.44813396e-02f, -8.82609561e-02f, 1.10013701e-01f, -1.30271822e-01f,
  -1.45839853e-02f, 1.53540045e-01f, -1.24966435e-01f, 2.51434296e-02f, 2.87049890e-01f, 5.89571372e-02f, 3.32023576e-03f, 9.65056568e-02f, -2.88252980e-02f, 1.69896126e-01f,
  5.06919026e-02f, -3.20655853e-02f, -1.44813538e-01f, -1.56811237e-01f, 9.33552906e-03f, -8.67282450e-02f, 1.62990894e-02f, -1.86756939e-01f, -2.04319302e-02f, -5.08420281e-02f,
  9.65382680e-02f, 1.56064853e-01f, -7.54402205e-02f, 1.17479712e-02f, -1.52896419e-02f, -7.02313939e-03f, 4.10123803e-02f, -7.88054313e-04f, 5.10490648e-02f, -5.88918850e-02f,
  7.18665719e-02f, -5.44245318e-02f, 5.95579967e-02f, -5.97492829e-02f, 3.46120633e-03f, -1.12669669e-01f, -2.84636244e-02f, -7.95127451e-02f, -7.63205215e-02f, 4.82043400e-02f,
  -4.06707078e-02f, -7.36613497e-02f, -9.93004069e-03f, -5.16899414e-02f, -5.31764217e-02f, 5.25423661e-02f, -1.24799227e-02f, -1.50507726e-02f, -1.98246259e-02f, 1.60700288e-02f,
  -5.02579063e-02f, 3.07119451e-02f, -7.54922330e-02f, 8.14583227e-02f, -1.29847517e-02f, -4.44338396e-02f, -2.50639785e-02f, -3.85282747e-02f, -3.97547558e-02f, -3.78849283e-02f,
  -4.01214100e-02f, 2.85470318e-02f, 6.81354627e-02f, -5.55118732e-02f, 1.46680996e-02f, -3.43556399e-03f, -4.25751470e-02f, -2.99328901e-02f, -3.86934206e-02f, 3.55190746e-02f,
  -1.69423688e-02f, 1.04604535e-01f, -6.91966191e-02f, -3.68120968e-02f, -2.33636377e-03f, -6.56241551e-03f, -6.48369417e-02f, -5.72638959e-02f, 1.08573092e-02f, -5.76744229e-02f,
  1.51954293e-02f, 2.36646794e-02f, 4.99225147e-02f, 5.74724935e-02f, 5.03978506e-02f, 4.86414135e-03f, 7.06102746e-03f, 2.12389175e-02f, -1.20867754e-03f, -1.76527929e-02f,
  2.75469688e-03f, 1.52671402e-02f, 3.79075035e-02f, -1.66590307e-02f, 9.67688626e-04f, 3.07551194e-02f, 1.01025276e-01f, 5.84293455e-02f, -2.49812920e-02f, 4.39908504e-02f,
  9.75450780e-03f, -7.38496752e-03f, -1.84870679e-02f, -1.21088196e-02f, 5.09947203e-02f, -2.81259008e-02f, 9.94951949e-02f, 3.78592014e-02f, -4.78186198e-02f, -4.70592678e-02f,
  6.38903975e-02f, -1.05897477e-02f, -3.44626367e-01f, -2.00599991e-02f, 5.11895679e-02f, -1.41975107e-02f, 1.43040821e-01f, -1.93172023e-02f, -5.01701608e-02f, 3.12710106e-01f,
  2.97653049e-01f, -1.41043857e-01f, -1.08862728e-01f, 1.82385266e-01f, -4.28152651e-01f, -9.82234031e-02f, 6.79401308e-02f, 1.06502369e-01f, -1.33492872e-01f, 7.95496479e-02f,
  -6.79804385e-02f, 1.99195996e-01f, -2.11829960e-01f, 1.58188000e-01f, 1.59017846e-01f, -1.48722273e-03f, 7.14899078e-02f, -1.47622809e-01f, 1.29513785e-01f, -6.26316890e-02f,
  5.68892322e-02f, 6.56946078e-02f, -1.47056878e-02f, -6.28319383e-02f, 2.93156207e-02f, 1.55539379e-01f, -3.51875909e-02f, -4.62957099e-02f, -3.05834934e-02f, 4.72812913e-02f,
  -4.87481477e-03f, 4.74511683e-02f, 4.08399180e-02f, 3.10471430e-02f, 2.45391354e-02f, 4.57023457e-02f, -5.05811200e-02f, 7.87433907e-02f, -1.44856600e-02f, -4.86814156e-02f,
  -9.05057415e-03f, -9.57395975e-03f, -4.38722828e-03f, 8.76618773e-02f, -6.88566566e-02f, -5.75523041e-02f, 1.73584663e-03f, -4.06060889e-02f, -5.78629896e-02f, -7.09719071e-03f,
  4.17565852e-02f, 2.27124207e-02f, 5.53047284e-02f, 4.19417508e-02f, 1.56583097e-02f, 6.77149370e-02f, 3.12850587e-02f, 1.61304586e-02f, -1.09884469e-02f, 4.74417470e-02f,
  7.94783700e-03f, -1.65741332e-02f, 8.91949013e-02f, 6.04239441e-02f, 1.65070184e-02f, 4.05948944e-02f, -5.73936813e-02f, 8.13319534e-03f, -2.62227319e-02f, -3.38651501e-02f,
  -1.78682804e-02f, 9.20788909e-04f, -2.34255120e-02f, 5.76865524e-02f, 1.13697350e-02f, -3.13530788e-02f, 6.16443492e-02f, -2.84831505e-02f, 1.90960057e-02f, -5.20763956e-02f,
  -7.99101144e-02f, -3.01062204e-02f, 6.69714855e-03f, 3.52637954e-02f, -7.71677196e-02f, 3.25182267e-02f, -2.66909413e-02f, -6.64545447e-02f, -2.24789307e-02f, -6.50733039e-02f,
  8.61247256e-02f, -9.74305347e-03f, -8.02090112e-03f, -1.97656304e-02f, -2.50848010e-02f, 2.28187945e-02f, 1.84327178e-02f, -3.47953811e-02f, 5.61882108e-02f, 5.09588420e-02f,
  4.72460175e-03f, 6.59273192e-02f, -3.76082249e-02f, 1.29187806e-02f, 6.40663803e-02f, 6.62464425e-02f, -1.45216882e-02f, -5.13855144e-02f, 2.56805699e-02f, -3.12961377e-02f,
  -3.97887602e-02f, 1.22140393e-01f, -1.84745267e-01f, -9.82993692e-02f, 1.59890652e-01f, -1.91248930e-03f, -2.11442947e-01f, 1.01780817e-01f, -1.21434189e-01f, 5.96147403e-02f,
  8.99298768e-03f, -2.39741541e-02f, -2.16168195e-01f, 3.61553603e-03f, -1.56884357e-01f, -1.55820698e-01f, -2.41642748e-03f, -1.18363574e-01f, 3.81103680e-02f, 7.38745406e-02f,
  7.35114142e-02f, 1.35646701e-01f, -8.81314427e-02f, 2.46702492e-01f, 1.26054272e-01f, 5.87787367e-02f, 1.33035749e-01f, -4.20443900e-02f, 2.07346767e-01f, -4.62102890e-03f,
  3.30346040e-02f, 1.61085222e-02f, 8.49987417e-02f, 7.96234887e-03f, 1.13495752e-01f, -3.83010693e-02f, -9.44031402e-03f, -8.69107842e-02f, -3.16874422e-02f, -6.65072203e-02f,
  1.20584397e-02f, -3.28810550e-02f, 1.08158059e-01f, -4.70316708e-02f, -2.58576386e-02f, -1.67342126e-02f, 5.35129867e-02f, 5.60113974e-02f, -1.73368361e-02f, 1.16292592e-02f,
  -1.14994729e-02f, 1.12235941e-01f, -2.30667144e-02f, -2.94583160e-02f, -2.35049287e-03f, 3.93494628e-02f, -3.06241289e-02f, -4.52227071e-02f, 2.25090869e-02f, 6.52853623e-02f,
  -6.26253476e-03f, 9.07970220e-02f, 1.68143325e-02f, 1.33787785e-02f, 6.80407090e-03f, 7.54302321e-03f, -1.83178466e-02f, 1.62763000e-02f, -2.26025973e-02f, 9.48559418e-02f,
  4.88938019e-03f, 5.97003773e-02f, 2.98078060e-02f, 2.51139309e-02f, -1.02048032e-02f, -1.15283858e-02f, 2.16000788e-02f, 1.10600814e-02f, 4.04095352e-02f, 3.53698917e-02f,
  -8.48279074e-02f, -5.56469113e-02f, 3.94890420e-02f, 4.78702337e-02f, 8.18128418e-03f, 1.96127640e-03f, 8.62545744e-02f, 3.13079916e-02f, -1.47266695e-02f, -5.60887754e-02f,
  2.44654253e-01f, 1.22397184e-01f, 4.34141308e-02f, 1.14137769e-01f, -4.36487608e-02f, 1.14982650e-02f, 3.85547653e-02f, 7.39176050e-02f, -3.40189561e-02f, 4.08297852e-02f,
  7.08558932e-02f, -5.75409979e-02f, -1.80116936e-03f, -2.73038764e-02f, -4.53463420e-02f, 4.62485524e-03f, 4.83029569e-03f, 5.31344339e-02f, 3.84520032e-02f, 4.33756746e-02f,
  1.12328678e-01f, -4.07767966e-02f, -5.57191037e-02f, -1.27002131e-03f, 4.86978143e-02f, -4.61946242e-02f, -1.21544199e-02f, 5.54605899e-03f, 6.09404743e-02f, -3.96369305e-03f,
  -6.43377081e-02f, 3.51140082e-01f, 1.66042715e-01f, -1.30360827e-01f, -1.08024426e-01f, 7.03043416e-02f, 6.14464246e-02f, 1.10544577e-01f, 3.36328670e-02f, 2.54241765e-01f,
  -1.56103492e-01f, 1.63648665e-01f, 1.87743101e-02f, -1.26400024e-01f, -4.27264452e-01f, -4.63744365e-02f, -1.43407181e-01f, 4.60866019e-02f, 5.51423198e-03f, -2.01176247e-03f,
  -1.55608743e-01f, -2.84804821e-01f, -7.37248436e-02f, 2.63794102e-02f, -2.14379486e-02f, 1.89082652e-01f, -1.86542824e-01f, 8.01206380e-02f, -3.92838456e-02f, -1.00750133e-01f,
  -5.21620847e-02f, 8.65612328e-02f, 6.06756844e-02f, -8.30395706e-03f, -2.46149451e-02f, -3.15825120e-02f, 1.95828676e-02f, -6.14345074e-02f, -3.17216129e-03f, 6.02257140e-02f,
  3.40597853e-02f, 2.89735384e-02f, 2.75421459e-02f, -6.27292246e-02f, -5.02729192e-02f, 5.69548309e-02f, 4.50360663e-02f, -1.54554565e-02f, -1.07371742e-02f, -1.78796258e-02f,
  5.35946563e-02f, -1.85848605e-02f, -2.77023483e-02f, 3.00315134e-02f, 1.17497807e-02f, 1.28917443e-02f, 4.93486114e-02f, 4.92253192e-02f, 7.00393226e-04f, -1.06079923e-02f,
  -1.23322597e-02f, 1.87340230e-02f, -1.66778341e-02f, 6.31535575e-02f, -6.06140122e-02f, -1.20072383e-02f, 2.59082429e-02f, -7.92837888e-03f, -3.73038352e-02f, 5.60435802e-02f,
  -3.76061276e-02f, 1.77645925e-02f, -2.99319602e-03f, -1.72163788e-02f, -1.41686182e-02f, 1.53054222e-02f, -8.24566409e-02f, -3.47222295e-03f, 2.29754429e-02f, -1.45657975e-02f,
  7.99359381e-03f, -1.55634871e-02f, -2.12084893e-02f, -4.42138314e-02f, -2.33808588e-02f, -2.65448969e-02f, 1.90989170e-02f, 3.86725180e-02f, -2.94423569e-02f, -7.14324135e-03f,
  6.61179470e-03f, 1.23912454e-01f, 4.89122346e-02f, 9.62737296e-03f, 5.88931553e-02f, -5.28559946e-02f, -3.05693690e-02f, 6.16534874e-02f, -2.90403850e-02f, 1.97579041e-02f,
  3.97790745e-02f, -1.98845342e-02f, 1.51657062e-02f, -2.25052703e-02f, 2.84369644e-02f, -3.90147939e-02f, -4.50004600e-02f, 2.10982915e-02f, -1.46049792e-02f, 7.10871676e-03f,
  -1.93930976e-02f, 6.53396780e-03f, -4.68143970e-02f, -4.89180088e-02f, -2.21270248e-02f, 2.54649278e-02f, -3.95866409e-02f, 2.30742730e-02f, 4.91107116e-03f, 2.44331025e-02f,
  -3.59623671e-01f, 1.20874174e-01f, -1.09161787e-01f, -2.32308686e-01f, 2.07760744e-02f, 1.45074353e-01f, 2.02213019e-01f, 1.32423222e-01f, 2.71620452e-02f, 2.22256437e-01f,
  1.28061235e-01f, 3.49969193e-02f, 3.20135295e-01f, 1.49402097e-01f, -1.59763008e-01f, 2.53374010e-01f, -3.53299379e-02f, -2.24350225e-02f, -7.53294816e-03f, 4.81049195e-02f,
  -8.29988867e-02f, 1.27694935e-01f, -1.26247182e-02f, 3.66975516e-02f, 7.69931357e-03f, -2.01852009e-01f, -1.50881827e-01f, 1.14154778e-01f, -1.93705797e-01f, 7.93904513e-02f,
  8.73905569e-02f, 8.16060603e-02f, -5.40014021e-02f, 1.42281791e-02f, -1.33368030e-01f, -1.44690303e-02f, -2.26107184e-02f, -1.52828479e-02f, -4.79197651e-02f, -4.73372750e-02f,
  -3.07510998e-02f, -3.15880962e-02f, -6.80198148e-03f, 6.72409264e-03f, -1.22144157e-02f, 7.96753634e-03f, -7.31001869e-02f, -8.59396718e-03f, 8.09070095e-02f, -2.90741343e-02f,
  4.35522720e-02f, -1.90087464e-02f, -6.96659982e-02f, -6.63208738e-02f, -2.94904206e-02f, 2.33489275e-02f, -7.36975810e-04f, 3.09793185e-02f, -4.95648868e-02f, -7.73146302e-02f,
  -1.35113755e-02f, 3.62925492e-02f, 1.07124988e-02f, 4.88646235e-03f, -6.54106513e-02f, -5.53971566e-02f, 7.14935735e-02f, 1.31942024e-02f, 1.80056356e-02f, 3.11616156e-02f,
  -1.79286096e-02f, 4.76087891e-02f, -1.19094935e-03f, 4.70646024e-02f, 2.70747244e-02f, 4.33744416e-02f, -5.82407564e-02f, 1.37954727e-02f, -7.48670325e-02f, -1.18800709e-02f,
  1.57756489e-02f, 5.28329350e-02f, 1.54425241e-02f, -2.22357102e-02f, 1.86218191e-02f, 1.79813076e-02f, -3.84641401e-02f, 7.24638775e-02f, 2.93539204e-02f, 1.27072111e-02f,
  -1.06301419e-02f, 1.20098159e-01f, 6.64742216e-02f, -6.19800048e-05f, -4.36284356e-02f, -1.30943684e-02f, -4.68962379e-02f, 4.91793081e-03f, -1.88249853e-02f, 6.84766918e-02f,
  -6.31775334e-02f, -3.51552404e-02f, 2.33773030e-02f, -7.60594616e-03f, -5.61104529e-02f, -3.83191146e-02f, 3.47799249e-02f, -9.31340456e-02f, -1.02554448e-01f, 1.86967757e-02f,
  -7.48138269e-03f, 4.28499505e-02f, 5.60483662e-03f, -5.57435378e-02f, -2.77526621e-02f, 3.86375636e-02f, -4.41076607e-02f, -5.29203750e-02f, -4.76082079e-02f, -1.69383213e-02f,
  1.10363342e-01f, 2.03570783e-01f, -4.66437973e-02f, -8.02526809e-03f, -1.45529389e-01f, 5.10536507e-02f, 1.60910830e-01f, -5.17312959e-02f, -3.01653845e-03f, 2.41149679e-01f,
  1.31615415e-01f, 8.43077078e-02f, 2.13369787e-01f, 1.85610965e-01f, -1.45491794e-01f, 2.41138011e-01f, 1.23971723e-01f, 1.20647676e-01f, -1.07039109e-01f, -6.94509894e-02f,
  -1.45401612e-01f, 1.31927267e-01f, 2.71708053e-02f, -1.28823906e-01f, 5.38358204e-02f, -1.83241621e-01f, -1.67314466e-02f, -1.29494414e-01f, -1.96045376e-02f, -9.58372727e-02f,
  2.92836148e-02f, 8.86933580e-02f, 4.30926979e-02f, -5.30376211e-02f, 5.18742129e-02f, -1.19786980e-02f, 2.57492755e-02f, -1.13112153e-02f, -2.36421358e-02f, 1.90386698e-02f,
  2.00131852e-02f, -3.33006494e-02f, 5.15903160e-02f, 2.45714281e-02f, -9.71755460e-02f, -4.54168953e-02f, -3.87920924e-02f, -6.61071315e-02f, -3.58826295e-02f, -1.23013370e-02f,
  3.40967141e-02f, 5.53316064e-02f, 2.60022498e-04f, 6.58303872e-02f, 3.83239123e-03f, -3.56008634e-02f, -2.66700219e-02f, 5.18183708e-02f, -9.87574458e-03f, 4.31604963e-03f,
  3.28229517e-02f, 3.51827070e-02f, 4.73343395e-02f, 2.78532263e-02f, 6.82111010e-02f, -4.11512516e-03f, 1.71454251e-02f, -4.48764861e-02f, -6.94293827e-02f, 5.36297038e-02f,
  -3.37676480e-02f, 1.83635056e-02f, -7.34719038e-02f, -2.08823811e-02f, -4.81088384e-04f, -3.79008725e-02f, 2.16229372e-02f, 2.09706314e-02f, 5.29169217e-02f, -6.10223673e-02f,
  1.66866574e-02f, -4.39349189e-02f, 7.72181824e-02f, 6.02187850e-02f, 8.30991310e-04f, 2.94279959e-02f, 5.04637882e-02f, -2.21470874e-02f, -1.57142542e-02f, -3.59413959e-02f,
  4.79266383e-02f, 4.47166599e-02f, 6.01992756e-03f, -1.96193177e-02f, -3.89223024e-02f, 3.75198456e-03f, 5.11964448e-02f, -5.80480844e-02f, -3.14012654e-02f, -5.22009470e-02f,
  -3.88124492e-03f, -7.19612911e-02f, -4.02888656e-02f, -7.22572431e-02f, 2.03600693e-02f, -2.31771293e-04f, -1.06360009e-02f, -4.38045301e-02f, -6.33582473e-02f, -2.30251197e-02f,
  -1.88078824e-02f, 8.83232430e-03f, -6.94144797e-03f, -4.63266969e-02f, -2.69973874e-02f, 7.53271207e-02f, -4.00645509e-02f, -5.84660843e-02f, 4.28892625e-03f, 6.02709837e-02f,
  -5.32019854e-01f, 8.66446644e-02f, 1.63326226e-02f, -1.34735554e-01f, -5.52419834e-02f, 1.21421106e-01f, 7.46935457e-02f, -1.12990424e-01f, -1.76712424e-01f, 2.12698355e-01f,
  1.61706656e-01f, -1.02868505e-01f, 1.52390793e-01f, 1.23662598e-01f, -1.25658765e-01f, 2.01836944e-01f, 1.85911264e-02f, 2.00356245e-02f, 2.32637320e-02f, -1.27255052e-01f,
  -1.61959365e-01f, 1.50970727e-01f, 8.52419212e-02f, 4.02644984e-02f, -1.15588553e-01f, -1.36524364e-01f, 6.97485134e-02f, 8.81417841e-02f, 2.13921349e-02f, 4.68927659e-02f,
  -9.96270180e-02f, -2.28698865e-01f, 3.07825170e-02f, -5.25113419e-02f, -4.73112538e-02f, -3.32293622e-02f, 1.15590096e-02f, 6.93953857e-02f, -6.74586669e-02f, -5.32586873e-02f,
  3.81937763e-03f, -7.60383019e-03f, 2.54738331e-02f, 6.41066656e-02f, -5.25396578e-02f, -4.49491367e-02f, 9.25694068e-04f, -2.58753862e-04f, -3.82903474e-03f, -2.62423325e-02f,
  2.90643685e-02f, 2.79972516e-02f, 4.97074891e-03f, 4.54111174e-02f, -5.99947106e-03f, 2.51105465e-02f, -3.45469750e-02f, -1.09141450e-02f, -5.40806800e-02f, 2.83003482e-03f,
  -1.09079078e-01f, -4.55471538e-02f, 7.63650164e-02f, -4.41754572e-02f, 5.11155017e-02f, -2.58042086e-02f, 2.15405002e-02f, 2.14243531e-02f, -1.36889238e-02f, -1.39599638e-02f,
  -4.47812937e-02f, -9.28863809e-02f, 1.22077670e-02f, 4.44008186e-02f, 2.24683825e-02f, -2.68458650e-02f, 2.13175896e-03f, -3.97731476e-02f, 1.96908657e-02f, -4.08770517e-02f,
  3.93184423e-02f, -9.31780692e-03f, 1.46862641e-02f, 1.57298446e-02f, 2.39113718e-02f, 1.85608491e-02f, 1.45279439e-02f, -1.93660408e-02f, 2.31114198e-02f, 2.46662516e-02f,
  -6.70589209e-02f, -2.28034303e-01f, 1.60227027e-02f, -7.56769106e-02f, 4.40096967e-02f, 2.27434412e-02f, -1.72701683e-02f, 2.17235126e-02f, 3.61244828e-02f, -3.87116754e-03f,
  1.42496703e-02f, -5.90710081e-02f, -8.52052867e-02f, -2.14684233e-02f, 6.15038872e-02f, -1.18537480e-02f, 3.32513079e-02f, 5.58463968e-02f, -4.72581722e-02f, 3.79053168e-02f,
  3.17732501e-03f, -6.91962987e-02f, 5.88257331e-03f, -2.54828371e-02f, 4.68289033e-02f, -3.43746655e-02f, -7.34892813e-03f, 3.66413929e-02f, 4.86060269e-02f, -9.92422178e-03f,
  5.75239472e-02f, 2.13532016e-01f, 1.60643831e-01f, -1.38998657e-01f, 4.49334905e-02f, 3.17622125e-01f, 2.08977684e-01f, 4.69333790e-02f, -6.33075982e-02f, 6.36611357e-02f,
  7.55641470e-03f, -7.79785886e-02f, 1.86407551e-01f, 1.36466203e-02f, 8.38925242e-02f, 2.74686422e-02f, 3.86978276e-02f, 6.95322752e-02f, -6.12237677e-02f, -2.72555742e-02f,
  4.13384959e-02f, -1.77266804e-04f, 8.56658518e-02f, -1.47106692e-01f, 4.92873117e-02f, -1.90494925e-01f, -2.22492531e-01f, 7.44702071e-02f, -2.26598810e-02f, -1.90712828e-02f,
  1.13898046e-01f, -8.09764937e-02f, 6.94580227e-02f, -1.35227526e-02f, -1.81477387e-02f, 2.16047652e-02f, -4.45601493e-02f, 3.55342813e-02f, -5.46390265e-02f, -8.17166269e-03f,
  -8.06426816e-03f, -1.21020963e-02f, 5.67937316e-03f, 4.75656390e-02f, -5.20168394e-02f, 2.83013228e-02f, 5.90991229e-02f, 8.71343464e-02f, 5.72621077e-02f, 6.57563582e-02f,
  4.26223576e-02f, 5.82237840e-02f, 2.43631266e-02f, -2.10446231e-02f, -5.85418716e-02f, 3.30475606e-02f, -4.82715182e-02f, 5.90805337e-02f, 1.08256750e-02f, -2.36720201e-02f,
  3.97374369e-02f, 3.85390595e-02f, -4.64144599e-04f, 5.80194406e-02f, 6.83862045e-02f, -6.25261366e-02f, -5.73930936e-03f, 3.71377096e-02f, -4.12990991e-03f, -3.45648825e-02f,
  -5.01439422e-02f, -7.74331316e-02f, -7.15776384e-02f, -6.53715655e-02f, -6.50181323e-02f, 3.74722853e-02f, -2.30996087e-02f, -9.92138684e-03f, 1.87601589e-04f, 2.33276058e-02f,
  -1.80576127e-02f, 3.26853432e-02f, 3.34960409e-02f, 1.76272832e-03f, -3.46930511e-03f, -2.25751698e-02f, -5.15574440e-02f, 4.39960919e-02f, 2.67642718e-02f, -3.47479023e-02f,
  3.96664664e-02f, -2.16558099e-01f, -4.61023450e-02f, 6.26373384e-03f, 4.46386859e-02f, -4.09953929e-02f, -1.18337451e-02f, 3.53944264e-02f, 1.51486183e-02f, 2.61441581e-02f,
  -2.96321511e-02f, -7.05318004e-02f, -5.26937209e-02f, -9.35804099e-02f, -9.89990756e-02f, 1.84323881e-02f, -4.76555601e-02f, -8.81176218e-02f, -7.21309558e-02f, -6.01338521e-02f,
  -1.09358095e-02f, -7.26623833e-02f, -2.77221110e-02f, -2.01695170e-02f, -7.04302490e-02f, -3.78436246e-03f, -6.11850340e-03f, -5.28412908e-02f, 5.53283282e-02f, -7.95051903e-02f,
  1.62265956e-01f, -3.12131435e-01f, 7.62272580e-03f, -1.52162299e-01f, 7.57863522e-02f, 2.43002608e-01f, 1.10484555e-01f, -1.50807768e-01f, -1.23374149e-01f, -1.42541736e-01f,
  3.35131492e-03f, 8.16891268e-02f, -9.87803563e-02f, -1.96490556e-01f, 4.06081341e-02f, -1.90185755e-01f, -9.13164839e-02f, 8.01470801e-02f, -1.35706916e-01f, -7.62568563e-02f,
  -1.22207247e-01f, -2.11200103e-01f, -8.03686678e-02f, -1.39788792e-01f, 2.51523312e-02f, -5.27798720e-02f, 1.54072477e-03f, -1.23789273e-02f, 1.33312056e-02f, 5.84822930e-02f,
  -8.92127678e-03f, -8.91562104e-02f, 1.04589283e-01f, 1.08690411e-01f, 8.08839276e-02f, 1.17958494e-01f, 1.34312198e-01f, 7.37800300e-02f, 3.44705209e-02f, 5.31181060e-02f,
  1.12898335e-01f, 2.30627730e-02f, -8.82110447e-02f, 1.21164331e-02f, 5.13842702e-02f, -7.66303986e-02f, 2.12384854e-02f, -3.54330102e-03f, -3.94119807e-02f, 3.98434848e-02f,
  1.86680933e-03f, 6.82463422e-02f, -1.99730098e-02f, -2.69467663e-02f, 2.78157871e-02f, -5.75573929e-02f, 1.87648907e-02f, 8.65400434e-02f, 3.98849919e-02f, -1.20261405e-02f,
  5.02759591e-02f, 2.38981983e-03f, -3.85672525e-02f, -5.64604241e-04f, -3.68941315e-02f, 9.10511706e-03f, -1.41565418e-02f, 4.81341081e-03f, 6.67682961e-02f, -5.32376207e-02f,
  2.33449005e-02f, -6.10004850e-02f, -1.12251695e-02f, -7.49077089e-03f, -1.36003112e-02f, 5.10429293e-02f, -3.07482132e-03f, 9.38946940e-03f, 1.06506106e-02f, -5.11072911e-02f,
  -3.03212814e-02f, -3.24154496e-02f, -1.10064214e-02f, -2.57747602e-02f, 5.27546182e-02f, 2.32788604e-02f, 7.37306895e-03f, -2.35687215e-02f, -1.52506717e-02f, -4.38383371e-02f,
  1.92293096e-02f, -1.01650283e-01f, -9.48917046e-02f, -5.61587289e-02f, -7.92963281e-02f, -5.59618734e-02f, -1.04960494e-01f, -3.95973250e-02f, -5.99441268e-02f, -5.46461083e-02f,
  3.39433327e-02f, 2.26180796e-02f, 1.12720355e-01f, -4.42050546e-02f, -1.13942204e-02f, -5.96997142e-02f, 1.49311451e-02f, -2.23969128e-02f, 9.26438272e-02f, -1.46468461e-03f,
  1.31531646e-02f, 6.80189282e-02f, -2.45660227e-02f, 8.33819155e-03f, 4.90117297e-02f, 2.19048485e-02f, 4.28998359e-02f, -3.02249333e-03f, 1.28753856e-03f, 1.28510175e-02f,
  3.98804173e-02f, -1.76229089e-01f, 1.30491853e-01f, -4.18248214e-02f, 4.13994163e-01f, 2.34608918e-01f, 5.80449104e-02f, 1.68564573e-01f, 1.91044375e-01f, -3.37621629e-01f,
  -6.24874830e-02f, -1.78192496e-01f, -5.59418239e-02f, -8.38114694e-02f, 4.18667719e-02f, -9.13916007e-02f, -2.30868645e-02f, -9.73417759e-02f, 1.45183533e-01f, 2.11259462e-02f,
  4.87964936e-02f, -8.73672403e-03f, -5.45604825e-02f, 3.99205834e-02f, 1.44702913e-02f, -2.31821067e-03f, -1.37666926e-01f, 9.71470326e-02f, -1.47099718e-01f, 7.41402805e-02f,
  8.36060569e-02f, 6.11258410e-02f, 3.98480846e-03f, 9.46509559e-03f, -6.14630729e-02f, 1.18178176e-02f, -6.65602982e-02f, -2.14629676e-02f, 2.61152387e-02f, 6.35451684e-03f,
  -6.58104122e-02f, -2.00178362e-02f, -2.45388299e-02f, -2.47642212e-02f, 2.96663139e-02f, -1.56614613e-02f, 6.31417260e-02f, -1.98238101e-02f, 4.52820696e-02f, 1.10442996e-01f,
  4.57255542e-02f, 2.09715758e-02f, 1.62256397e-02f, -2.24281102e-02f, 8.82660821e-02f, -2.79296022e-02f, 2.03716550e-02f, -1.03753638e-02f, 2.40705553e-02f, 7.68842921e-02f,
  3.19842212e-02f, 5.61344484e-03f, -7.38070300e-03f, -5.35876341e-02f, -2.11605597e-02f, 2.33095586e-02f, -5.29909953e-02f, -6.27939776e-02f, -1.96800660e-02f, 7.67689757e-03f,
  -1.98303014e-02f, -2.54975203e-02f, 1.23888277e-01f, 1.04676490e-03f, -9.95613411e-02f, -8.01030546e-02f, -9.56170727e-03f, -7.00311828e-03f, 1.93236396e-02f, 1.38067706e-02f,
  -2.52052257e-03f, -7.40835629e-03f, -4.12199385e-02f, -5.26093058e-02f, -5.35672493e-02f, -3.68721485e-02f, 2.82178596e-02f, -3.25802378e-02f, 4.10569869e-02f, -3.73918489e-02f,
  -1.82555377e-01f, -2.38843873e-01f, 3.62796746e-02f, -3.31291333e-02f, -1.09625235e-01f, -5.13076484e-02f, -8.09621532e-03f, 3.73350270e-02f, 6.97379187e-03f, -3.13622281e-02f,
  -4.57251066e-04f, 3.27365560e-04f, -2.18502507e-02f, -1.85551755e-02f, 5.31408675e-02f, -1.23637589e-02f, -3.74736823e-02f, 1.02045298e-04f, -1.35458745e-02f, -4.21129493e-03f,
  -3.09186522e-02f, -3.49936336e-02f, 5.05331419e-02f, -5.51455654e-02f, -1.90318339e-02f, 1.53019410e-02f, -2.02467237e-02f, -2.93953009e-02f, -4.53613438e-02f, -6.13352424e-03f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.23458505e-01f, -8.60228576e-03f, 3.73089574e-02f, -2.38796882e-02f, 5.95531426e-02f, 8.16487819e-02f, -3.75407077e-02f, 1.14440033e-02f, 1.04391836e-02f, -6.27780482e-02f,
  1.71815623e-02f, -1.17765836e-01f, -9.97395590e-02f, 4.97407354e-02f, -8.83610267e-03f, -1.26982816e-02f, 1.16164982e-01f, -5.83679695e-03f, -6.30532876e-02f, 8.37517437e-03f,
  6.92792982e-02f, 3.99036007e-03f, -8.26120563e-03f, 3.71205956e-02f, 1.11654401e-01f, 3.70738879e-02f, 9.54887494e-02f, -9.01620537e-02f, 1.11348569e-01f, 4.44944203e-03f,
  5.73031567e-02f, 5.06132059e-02f, -6.01763502e-02f, -4.30128314e-02f, -1.50831500e-02f, 4.28873450e-02f, -9.17138904e-02f, 5.05865440e-02f, 8.69034156e-02f, -2.59414222e-02f,
  1.19955456e-02f, -2.64381357e-02f, -4.06693928e-02f, -8.62754229e-03f, 5.40488325e-02f, 7.17741922e-02f, -2.92643774e-02f, -5.33297192e-03f, -9.26051438e-02f, -5.11429086e-02f,
  -3.50168236e-02f, 7.33247176e-02f, 7.13311881e-02f, -5.98480888e-02f, -1.49917230e-02f, -2.58210152e-02f, -4.81996089e-02f, -8.40482786e-02f, -2.86796410e-02f, -7.19981873e-03f,
  -3.96462977e-02f, 1.24196820e-02f, -6.02428354e-02f, 4.23091948e-02f, 6.37569726e-02f, 4.87361178e-02f, -1.05580490e-03f, -3.20743732e-02f, -5.17172478e-02f, -9.18958858e-02f,
  6.80526271e-02f, 2.16657147e-02f, 6.93668276e-02f, 2.86505315e-02f, 4.20068875e-02f, -3.08504924e-02f, 4.15968783e-02f, -7.52238333e-02f, -5.59671856e-02f, 3.36207487e-02f,
  4.63312678e-03f, 7.89602026e-02f, 6.59561902e-02f, -7.86260664e-02f, -4.60265018e-02f, -8.74134898e-02f, -2.49787048e-02f, -7.16996193e-02f, -6.42838702e-02f, -7.33310282e-02f,
  -9.42435488e-02f, 5.12754591e-03f, 3.77294570e-02f, 1.71799809e-02f, -2.22501364e-02f, -1.54918898e-02f, 2.75047105e-02f, 5.11712804e-02f, 4.36110385e-02f, 4.48621716e-03f,
  7.73483589e-02f, -7.37400353e-02f, 3.63201126e-02f, 5.04678348e-03f, 6.31189570e-02f, -3.76751320e-03f, 4.06474359e-02f, 7.46836811e-02f, -5.55886626e-02f, -1.58397667e-02f,
  3.99811789e-02f, 1.88865084e-02f, -3.82908359e-02f, 7.27323070e-02f, -6.82200305e-03f, 1.05707720e-02f, 2.92455107e-02f, -8.75888169e-02f, 1.80664752e-02f, -8.12719986e-02f,
  -4.70303074e-02f, -2.92781591e-02f, -4.11680043e-02f, 7.70667940e-02f, 1.26398057e-02f, -1.18716985e-01f, -7.98478350e-02f, 8.38796236e-03f, 1.45692667e-02f, 6.79562390e-02f,
  -1.20984621e-01f, -2.09303815e-02f, -4.80301827e-02f, -9.23289135e-02f, 3.41114821e-04f, 4.00448851e-02f, -9.56669822e-02f, 1.98713616e-02f, -3.95364799e-02f, 9.00076479e-02f,
  1.11908637e-01f, -1.28505200e-01f, -6.12025186e-02f, -1.21401429e-01f, -1.10746631e-02f, 1.66317690e-02f, 2.95663886e-02f, -1.37686422e-02f, -6.02215007e-02f, -1.33940935e-01f,
  2.10639462e-02f, 2.36203591e-03f, -6.96341274e-03f, -3.90609130e-02f, 3.72465253e-02f, -2.06394028e-02f, -6.75672442e-02f, -5.00074588e-02f, -3.80712040e-02f, 2.40806378e-02f,
  1.02602728e-01f, -1.44130690e-02f, 2.03056051e-03f, -1.36155041e-03f, -3.24391909e-02f, 5.57795428e-02f, -2.48745941e-02f, -2.15269197e-02f, 7.71333352e-02f, 2.03967486e-02f,
  -8.95487294e-02f, -2.21380163e-02f, 4.55092788e-02f, 8.02451223e-02f, -3.77231874e-02f, -3.29112150e-02f, 7.78422281e-02f, -3.39176133e-02f, 6.51750937e-02f, 2.67093293e-02f,
  9.15988535e-03f, -1.61912777e-02f, -1.14425801e-01f, -1.01844229e-01f, -4.19860259e-02f, 8.60370696e-02f, 1.39957368e-02f, 8.97201747e-02f, 9.41000208e-02f, -9.04822126e-02f,
  -2.70736329e-02f, -6.94851205e-02f, 5.70627712e-02f, 2.54434533e-03f, 9.83322933e-02f, -4.80827652e-02f, -3.62067088e-03f, 7.76515380e-02f, 8.02834779e-02f, -1.17717506e-02f,
  4.45139483e-02f, -8.89340490e-02f, -9.14944783e-02f, 5.54627962e-02f, 4.68204916e-02f, -3.89287733e-02f, -8.64981860e-03f, 4.86842990e-02f, -2.79158540e-02f, 8.19202065e-02f,
  -2.76651829e-02f, 1.12135157e-01f, 7.96035528e-02f, 6.31501973e-02f, 3.94258322e-03f, 1.28332675e-02f, -1.27027426e-02f, 2.03233045e-02f, 2.36256234e-02f, 7.18107074e-02f,
  7.20672831e-02f, -2.89926957e-02f, -7.82257020e-02f, -5.30353375e-02f, 7.56391883e-02f, 7.69001171e-02f, -6.18380718e-02f, 1.05863817e-01f, 6.40018955e-02f, 8.94245133e-03f,
  5.66391870e-02f, 5.42109385e-02f, -2.26623360e-02f, 3.68688963e-02f, 2.38802638e-02f, -4.83717583e-02f, -2.83081494e-02f, -7.48192985e-03f, -6.00433983e-02f, 9.04253647e-02f,
  -5.18986061e-02f, 2.79487371e-01f, 1.37523159e-01f, -1.67507324e-02f, -1.13294996e-01f, -4.32701074e-02f, -1.35947347e-01f, 4.67313416e-02f, -9.44889337e-03f, 4.89860214e-02f,
  -1.06288388e-01f, 1.72639579e-01f, 8.17722827e-02f, 2.79432014e-02f, -1.50775805e-01f, -1.47182077e-01f, -1.10929415e-01f, -5.77094033e-02f, 7.71466792e-02f, 1.06974840e-01f,
  -6.95125163e-02f, -1.50218830e-01f, 1.00538187e-01f, 5.69841499e-03f, 9.79559869e-03f, 9.76132527e-02f, -5.05621396e-02f, 1.44751891e-01f, 2.93353777e-02f, 1.95534546e-02f,
  -4.55460139e-03f, 3.64078246e-02f, -6.23701587e-02f, -7.35128373e-02f, 3.26287039e-02f, -3.43320221e-02f, 6.53814301e-02f, -1.23504652e-02f, -5.93536124e-02f, 1.50696156e-04f,
  -4.03174870e-02f, 2.74635442e-02f, -8.56329426e-02f, 7.16663525e-02f, 8.07698891e-02f, 6.83107674e-02f, 1.08210884e-01f, 8.64820480e-02f, 9.86181349e-02f, 1.04597107e-01f,
  3.92233245e-02f, 1.89145736e-03f, -4.11642715e-03f, -8.39914978e-02f, -2.38023698e-02f, 7.16840923e-02f, -7.86543190e-02f, 6.73166513e-02f, 4.04032767e-02f, -7.33143166e-02f,
  8.17495398e-03f, -1.33069912e-02f, 5.83897680e-02f, 4.09781337e-02f, 6.16998449e-02f, -1.01552214e-04f, -6.28791004e-02f, 5.98629983e-03f, -3.99095304e-02f, 2.41989810e-02f,
  5.36587946e-02f, 1.00506499e-01f, 5.12639731e-02f, -8.37010741e-02f, -2.33276114e-02f, -8.35854858e-02f, -6.32567853e-02f, 2.16582082e-02f, -1.77978873e-02f, -4.78155315e-02f,
  7.40083531e-02f, -5.12230694e-02f, -3.14535648e-02f, 6.92971274e-02f, 8.14192276e-03f, 2.52487790e-03f, 4.22493853e-02f, 5.28370962e-03f, -5.61542287e-02f, 7.62798041e-02f,
  -8.67371336e-02f, 8.36006328e-02f, 8.35180655e-02f, -7.17052296e-02f, -3.48292030e-02f, 8.32649320e-02f, -6.08784743e-02f, 3.64620276e-02f, -5.28035536e-02f, -8.06373805e-02f,
  5.09241149e-02f, 1.43882902e-02f, -3.42571922e-02f, 7.47154653e-02f, -8.34674910e-02f, 4.60161269e-03f, -2.16933526e-03f, -4.73204702e-02f, -3.31564359e-02f, 5.63309602e-02f,
  1.05913028e-01f, 5.97714595e-02f, 7.67948553e-02f, -9.41486098e-03f, 4.45651785e-02f, 3.04026604e-02f, -1.65861137e-02f, -1.11090606e-02f, 3.08833700e-02f, 5.93211688e-02f,
  -5.24714142e-02f, -3.22047994e-03f, 7.24233165e-02f, 7.42738834e-03f, -2.87990831e-02f, -1.17908372e-02f, 5.68476804e-02f, 1.38246864e-01f, 7.04702809e-02f, -1.72962323e-02f,
  7.50946626e-02f, 1.74733363e-02f, 3.30904573e-02f, -4.46530022e-02f, -1.23706833e-01f, 5.86045347e-02f, 7.96734076e-03f, 3.22770998e-02f, -3.49152982e-02f, 1.05863407e-01f,
  -2.53981426e-02f, -2.38958336e-02f, -7.03577995e-02f, 9.61384699e-02f, 4.66672815e-02f, 9.24616456e-02f, 9.41321403e-02f, 6.84648082e-02f, 4.28181514e-02f, 7.66868219e-02f,
  -5.86414561e-02f, -1.64675396e-02f, -8.59885141e-02f, -9.37230214e-02f, -6.78875903e-03f, 3.40892114e-02f, 2.11634878e-02f, 1.07411733e-02f, -4.71542664e-02f, 6.00567497e-02f,
  -8.90979543e-02f, 1.65618490e-02f, 8.11825395e-02f, -2.66392101e-02f, -1.83423124e-02f, 7.69026875e-02f, 7.89567083e-02f, 5.69749363e-02f, -2.28711553e-02f, -4.54826057e-02f,
  -2.88985055e-02f, -1.24229975e-02f, 2.42842473e-02f, 1.45672411e-02f, -1.44792087e-02f, -2.02457886e-02f, 6.76004589e-02f, 7.69420341e-02f, 5.26853018e-02f, 5.65082617e-02f,
  3.92098688e-02f, -7.36622363e-02f, 5.74611053e-02f, -3.44123356e-02f, 7.60217160e-02f, 3.16879041e-02f, 6.69302642e-02f, 5.79192899e-02f, -7.31395781e-02f, 2.86905505e-02f,
  -5.46847917e-02f, -1.58266779e-02f, 2.33657528e-02f, -6.65122047e-02f, -2.44554691e-02f, 3.30812521e-02f, -6.44079745e-02f, 7.07082599e-02f, -2.34143566e-02f, -6.14356715e-03f,
  -1.40748965e-02f, -8.24851394e-02f, 1.79795967e-03f, -7.21935183e-02f, 7.81738535e-02f, 1.78915728e-02f, -7.60677457e-02f, 4.07689586e-02f, 4.95034531e-02f, -7.98636526e-02f,
  -6.81712329e-02f, -4.57649305e-02f, 1.85140059e-03f, 7.80492052e-02f, -5.29793687e-02f, 9.51066986e-03f, 7.04595223e-02f, 3.61465407e-03f, -8.88701230e-02f, -2.78921612e-02f,
  -9.26465616e-02f, 6.77618943e-03f, 7.58034587e-02f, -8.45144540e-02f, -5.65212257e-02f, 4.33359332e-02f, -2.16154940e-02f, 7.12342858e-02f, -9.06455517e-02f, 8.42816234e-02f,
  -2.18707509e-02f, -3.50563601e-02f, -1.99636742e-02f, 1.98851377e-02f, 7.00002536e-02f, 2.30128691e-02f, 2.92135179e-02f, -2.14564148e-02f, 7.01704547e-02f, -1.32494476e-02f,
  -1.22704938e-01f, 8.03806037e-02f, -6.15353324e-02f, -1.32082358e-01f, 3.59298550e-02f, 1.01427764e-01f, 1.08255595e-01f, 9.39153880e-02f, -1.51829407e-01f, 4.30616103e-02f,
  1.07192568e-01f, -8.25762600e-02f, 4.26592454e-02f, -2.12538298e-02f, -9.85622406e-02f, -2.18517277e-02f, 5.44101037e-02f, 9.05238837e-02f, -1.13836356e-01f, -2.11523883e-02f,
  2.36422028e-02f, -6.98625147e-02f, 1.06785163e-01f, 5.11754863e-02f, 6.96820114e-03f, 1.55717013e-02f, 2.90836878e-02f, 3.14526111e-02f, 1.17357604e-01f, -5.87659925e-02f,
  6.75322637e-02f, 3.01894639e-03f, 1.04028344e-01f, -1.54047729e-02f, 9.55781937e-02f, 3.03381737e-02f, 7.08590001e-02f, -1.00735441e-01f, -3.27548967e-03f, -4.27770838e-02f,
  1.19912531e-02f, -1.10476524e-01f, -5.74382246e-02f, 2.24315394e-02f, -2.34618541e-02f, 5.79528026e-02f, 8.63660011e-04f, -3.15845944e-02f, 7.41742179e-02f, 6.79955557e-02f,
  -2.75865663e-02f, -3.25933546e-02f, -5.37084602e-02f, -6.08456694e-02f, 4.26317565e-02f, 1.96650848e-02f, -5.59925810e-02f, -1.32256839e-02f, -4.53428738e-02f, -9.98246856e-03f,
  -6.32272437e-02f, -6.80556148e-02f, 7.79594183e-02f, 8.53837207e-02f, -1.54645024e-02f, 3.82092483e-02f, 2.13213135e-02f, 3.61324698e-02f, -1.09570706e-03f, -3.96280102e-02f,
  -1.33873038e-02f, -5.29463179e-02f, -8.65725949e-02f, 6.93040118e-02f, 1.61106251e-02f, 6.68599233e-02f, -4.27033380e-02f, 3.16020772e-02f, -6.13810979e-02f, 1.59377493e-02f,
  1.84350777e-02f, 1.43177211e-02f, 5.70385419e-02f, 7.33809844e-02f, 6.61462024e-02f, 5.30092344e-02f, -5.60370721e-02f, -4.62929197e-02f, 9.16195810e-02f, -2.38636490e-02f,
  9.47378874e-02f, -1.06392436e-01f, -3.26716192e-02f, -9.10935050e-04f, -3.41586657e-02f, 4.75087613e-02f, -5.44320159e-02f, 2.83965636e-02f, -1.14155166e-01f, -8.45078751e-02f,
  7.72062093e-02f, 1.03663364e-02f, -6.47901371e-02f, 7.92233180e-03f, -3.74863073e-02f, -5.07559702e-02f, 1.56777501e-02f, -4.61248569e-02f, 3.64874527e-02f, -3.88887711e-02f,
  1.37538807e-02f, -6.80619776e-02f, 3.38806175e-02f, -6.38569891e-02f, 6.64232895e-02f, -7.81242102e-02f, -2.55144425e-02f, 8.84784237e-02f, 5.29797561e-02f, 2.77143586e-02f,
  -3.29421274e-02f, 1.66435346e-01f, -1.84554890e-01f, -7.74351805e-02f, 9.33651999e-02f, -2.08821371e-01f, -9.33918804e-02f, 8.53505284e-02f, 1.05215609e-01f, 1.34307653e-01f,
  6.90441728e-02f, -1.14729568e-01f, 7.48878419e-02f, -4.88212630e-02f, -2.00123146e-01f, -1.06397614e-01f, -2.08098859e-01f, -1.82400481e-03f, -6.47317246e-02f, -2.53594238e-02f,
  -5.51954284e-02f, 5.66308275e-02f, -2.01491356e-01f, 1.63613006e-01f, 3.43593918e-02f, 4.23364230e-02f, 1.18036121e-01f, 4.75598266e-03f, -1.52547315e-01f, -2.59517208e-02f,
  -7.29144141e-02f, 8.75984356e-02f, 1.06632272e-02f, -1.78380813e-02f, 4.09040675e-02f, 1.45757459e-02f, -2.89988313e-02f, -9.12030935e-02f, -8.96782428e-02f, 6.78615719e-02f,
  6.76121190e-02f, 7.99837336e-02f, 4.49998900e-02f, 3.01484540e-02f, 2.17913277e-02f, -2.04990548e-03f, -1.04727522e-01f, 1.42387180e-02f, -7.85843432e-02f, -8.02408755e-02f,
  -1.08200938e-01f, -9.00445506e-02f, -1.77632961e-02f, -9.17667598e-02f, -9.56097245e-02f, -8.26344080e-03f, -1.07478797e-01f, -5.36204427e-02f, -5.55413254e-02f, -7.38925859e-03f,
  -9.45373718e-03f, 9.34965760e-02f, -7.25100860e-02f, 4.64606285e-02f, 4.62707840e-02f, -7.43314177e-02f, 9.29425582e-02f, 4.13205884e-02f, 7.34836794e-03f, 5.59018292e-02f,
  -7.76108587e-03f, -1.78615358e-02f, 1.40842255e-02f, -5.20431139e-02f, 1.63545385e-02f, 7.65600950e-02f, 8.06011409e-02f, -6.79225922e-02f, -2.77126813e-03f, -1.01806670e-01f,
  1.03223197e-01f, -4.44993824e-02f, -2.66027432e-02f, 6.72080293e-02f, 7.06894547e-02f, 4.75614555e-02f, 9.62683260e-02f, -7.19212294e-02f, -2.04778295e-02f, -6.55337498e-02f,
  -2.21471228e-02f, 3.50930803e-02f, 4.99621816e-02f, 8.96366537e-02f, 6.42067939e-02f, 1.87643082e-03f, -7.11498708e-02f, 8.40887800e-03f, -4.66620214e-02f, 6.80754706e-02f,
  -3.37781897e-03f, 8.67894664e-02f, -1.07882135e-01f, -5.47335409e-02f, 6.67282343e-02f, -4.03045341e-02f, 1.17651232e-01f, 2.09806263e-02f, -6.81882259e-03f, 1.90768652e-02f,
  1.83609240e-02f, 6.16841987e-02f, 3.94563563e-02f, -5.79691529e-02f, -1.99919399e-02f, -6.22059293e-02f, 3.27775851e-02f, -3.49911973e-02f, 2.58539198e-03f, -5.03858691e-03f,
  9.60570872e-02f, 1.42085016e-01f, 2.52904301e-03f, -1.09760158e-01f, -5.27321696e-02f, 1.11053273e-01f, 4.23239432e-02f, -1.13560490e-01f, -1.11549824e-01f, -1.64328667e-03f,
  1.19201481e-01f, -2.10672399e-04f, 3.44856679e-02f, 2.09151134e-01f, 1.00763813e-01f, 1.75995588e-01f, 1.56935796e-01f, 1.11695804e-01f, 4.10050899e-02f, 3.72538180e-03f,
  -6.34755492e-02f, 7.50462264e-02f, -1.52922226e-02f, 7.49331564e-02f, 5.79146594e-02f, -4.57682945e-02f, -9.84232947e-02f, -4.43950035e-02f, 9.05202553e-02f, -7.15830103e-02f,
  1.00799270e-01f, 7.22815692e-02f, -3.22535746e-02f, 1.52818235e-02f, -4.25033867e-02f, 1.03517704e-01f, -5.07808030e-02f, -1.83830336e-02f, 3.55521515e-02f, 7.13841245e-02f,
  -7.50477090e-02f, -3.69636863e-02f, 6.68800399e-02f, 6.20503239e-02f, -9.68420878e-02f, -6.58305362e-02f, 2.21110415e-02f, -5.88995442e-02f, 2.87033468e-02f, 8.49978253e-02f,
  8.33738875e-03f, -4.89363298e-02f, 2.12009251e-03f, -6.88337237e-02f, -1.10515423e-01f, -2.49193888e-02f, 8.30705091e-02f, -9.20370743e-02f, -4.28115390e-02f, 5.93093112e-02f,
  -1.09380923e-01f, 3.35730962e-03f, 6.23296089e-02f, 1.11556500e-02f, -1.03381546e-02f, 2.32038703e-02f, 5.25652384e-03f, -2.34100549e-03f, -8.55916217e-02f, 3.22455913e-02f,
  -8.39250349e-03f, -8.02286789e-02f, 1.65723003e-02f, 5.81365824e-02f, 5.36004752e-02f, 8.66495147e-02f, -7.96884149e-02f, -7.45274350e-02f, 1.20085916e-02f, -7.04287812e-02f,
  -2.86672427e-03f, 7.81443194e-02f, 1.56163620e-02f, 7.13201389e-02f, -3.05669289e-03f, 2.75813062e-02f, 2.86540873e-02f, 3.22379842e-02f, -8.10661763e-02f, -8.59313160e-02f,
  1.21389277e-01f, -9.89957377e-02f, 3.38434055e-02f, 1.48113817e-03f, 3.09873726e-02f, 1.07452445e-01f, -3.16804741e-03f, 3.20081078e-02f, 2.66609024e-02f, -4.79636295e-03f,
  -3.16857323e-02f, -8.83331075e-02f, 1.45330618e-03f, -5.88372014e-02f, -8.09137449e-02f, -2.86807269e-02f, 4.49885316e-02f, -9.18963179e-02f, -3.81765189e-03f, -1.31648518e-02f,
  -5.23674153e-02f, -6.68595061e-02f, -1.90647673e-02f, 6.72194064e-02f, 3.91417667e-02f, -9.23430100e-02f, 2.23993529e-02f, 5.56419641e-02f, -3.29062305e-02f, -1.07921861e-01f,
  -5.97261079e-02f, -3.17622758e-02f, 3.60642299e-02f, -1.91463269e-02f, 2.86759418e-02f, -1.77737087e-01f, -1.58970013e-01f, -7.93037042e-02f, -9.31281298e-02f, 1.35156304e-01f,
  5.96373230e-02f, -6.14357851e-02f, -7.12617412e-02f, -1.05999388e-01f, -2.41038099e-01f, -1.67870104e-01f, -2.26905778e-01f, -9.03570354e-02f, -6.01333752e-02f, 6.34838417e-02f,
  -7.52186328e-02f, -2.66690869e-02f, -9.11346152e-02f, 1.24012232e-01f, 6.43584579e-02f, 8.24493244e-02f, 8.36615264e-02f, 8.14305469e-02f, -3.03466730e-02f, 1.87063199e-02f,
  -1.08587287e-01f, 7.43237510e-02f, 5.41667454e-02f, -8.45416263e-02f, -3.85390641e-03f, -1.59975402e-02f, 7.75394365e-02f, -7.77275935e-02f, -7.97598287e-02f, 3.28831784e-02f,
  1.75558887e-02f, 1.37337064e-02f, -2.79093627e-02f, 1.23846205e-02f, 8.54094140e-03f, -5.57785807e-03f, 7.09160417e-02f, -3.98861617e-02f, -6.57667816e-02f, -7.68538043e-02f,
  -5.65519892e-02f, -4.26114574e-02f, 2.60499138e-02f, 4.19005658e-03f, 4.67756912e-02f, -2.90528554e-02f, -7.60596767e-02f, 3.81766111e-02f, 8.72382447e-02f, 5.85020594e-02f,
  7.70523399e-02f, -6.35638759e-02f, -2.36110389e-02f, 3.43229063e-02f, -5.63812628e-02f, 6.58076480e-02f, -7.84320310e-02f, -3.69703285e-02f, -4.88270745e-02f, 8.67569260e-03f,
  2.63254959e-02f, 6.55064881e-02f, -8.12072530e-02f, 1.85410231e-02f, -8.60168412e-03f, 1.09343687e-02f, -8.81038327e-03f, 8.87379348e-02f, -5.59761189e-02f, 1.87642686e-02f,
  2.18627658e-02f, 2.15070676e-02f, -8.64043683e-02f, -5.65270260e-02f, -6.53091073e-02f, 4.38099913e-02f, -4.42903079e-02f, -3.94958705e-02f, -5.45794517e-02f, 6.02391437e-02f,
  5.01345061e-02f, 7.53590986e-02f, -2.50997161e-03f, 3.89554650e-02f, 2.44167298e-02f, 6.21506236e-02f, 4.87149321e-02f, 1.20369368e-03f, -1.82218645e-02f, 7.17180409e-03f,
  7.97627196e-02f, 1.52774332e-02f, 3.74623314e-02f, 7.15766251e-02f, 3.91980633e-02f, 7.75273740e-02f, 3.36636640e-02f, 1.16319163e-02f, -1.85494870e-02f, 3.86360288e-02f,
  1.24467686e-01f, 1.08239599e-01f, 5.39279170e-03f, 5.83075918e-02f, -1.89518537e-02f, 8.37286189e-02f, 1.02369033e-01f, 8.46499428e-02f, 1.75767913e-02f, 3.15662026e-02f,
  6.22445382e-02f, -1.58590391e-01f, 5.75179942e-02f, 1.18966684e-01f, 2.96356697e-02f, -4.98296060e-02f, 6.31766170e-02f, -1.15579978e-01f, -7.00805783e-02f, -2.24875093e-01f,
  -9.38870907e-02f, 1.03862360e-01f, -2.29451396e-02f, 3.80748995e-02f, 1.00080334e-01f, 6.65650889e-02f, 3.85809354e-02f, 9.53904465e-02f, -8.09693784e-02f, -2.77704019e-02f,
  5.52819967e-02f, -4.34639566e-02f, 1.03825249e-01f, 1.64680742e-02f, 9.07294154e-02f, -4.10241820e-02f, 6.51917011e-02f, 1.25377789e-01f, 7.47681260e-02f, 3.48517187e-02f,
  -7.89627358e-02f, -7.71174580e-02f, 6.28866777e-02f, 7.10815117e-02f, -1.19013287e-01f, -1.24499155e-02f, 9.18316320e-02f, 9.17927846e-02f, -2.02905713e-03f, -6.23895787e-02f,
  4.26355936e-02f, 1.47481747e-02f, 7.32420012e-02f, 9.37408060e-02f, -1.52382767e-03f, 8.79126117e-02f, -7.58644193e-02f, -2.05789972e-02f, -2.67675985e-02f, 7.86176026e-02f,
  6.12991722e-03f, -2.09490443e-03f, 6.92583993e-02f, 6.95248917e-02f, -1.54318763e-02f, -9.00582150e-02f, 8.54333416e-02f, 2.61678826e-02f, 4.62082289e-02f, -7.74420947e-02f,
  -6.97897673e-02f, 5.22270314e-02f, 1.93335693e-02f, 6.31619096e-02f, -1.52306585e-02f, 4.87537757e-02f, -4.22035083e-02f, 8.46769288e-02f, -6.62323609e-02f, 1.53969526e-02f,
  5.73475007e-03f, 4.54389080e-02f, -5.34255058e-02f, -5.35369217e-02f, 2.83536222e-02f, -2.08650809e-02f, -4.14438508e-02f, 4.35775407e-02f, 5.92380986e-02f, 6.87488690e-02f,
  4.53784689e-02f, -2.30223257e-02f, 3.37402262e-02f, 3.77798565e-02f, -6.08880743e-02f, -2.53819600e-02f, 1.65662467e-02f, 7.86702186e-02f, -5.42879887e-02f, -3.18847522e-02f,
  -1.89280808e-01f, -8.72126445e-02f, -7.26899728e-02f, -1.03441447e-01f, -8.24774504e-02f, -9.43434834e-02f, 9.19626728e-02f, -6.68365881e-03f, -1.73964538e-03f, 6.82305638e-03f,
  4.57196869e-02f, 7.11180121e-02f, 4.22178656e-02f, -7.78124034e-02f, 1.39763476e-02f, 5.12049627e-03f, -3.96620110e-03f, -9.14772749e-02f, -1.45557495e-02f, 8.27125236e-02f,
  -1.30187562e-02f, -8.81148428e-02f, 4.19349968e-02f, 8.02514050e-03f, 3.43408100e-02f, 6.79218993e-02f, -7.62365162e-02f, -4.70581055e-02f, 5.01333885e-02f, 4.67178524e-02f,
  -6.25502393e-02f, -2.69701965e-02f, 1.33607119e-01f, 1.27339035e-01f, -1.51458025e-01f, -6.04548268e-02f, -6.90930411e-02f, -1.13333710e-01f, -1.39330447e-01f, -8.08469132e-02f,
  1.03689559e-01f, 6.94069713e-02f, 5.66387177e-02f, 5.44350371e-02f, 8.50012004e-02f, -3.40973474e-02f, 2.77505331e-02f, 2.08829846e-02f, 2.36839373e-02f, 7.90705532e-02f,
  8.08501244e-02f, 3.06541882e-02f, 1.04173802e-01f, 1.53407799e-02f, 4.69804965e-02f, 7.71550462e-02f, 1.91691712e-01f, 1.09532423e-01f, 8.99838582e-02f, 6.57251254e-02f,
  -9.13962647e-02f, -3.80952004e-03f, -2.18151119e-02f, -1.22471973e-02f, -8.62498134e-02f, -3.09150610e-02f, 9.14559290e-02f, 7.41642565e-02f, 6.72155842e-02f, -8.83828625e-02f,
  8.57003406e-02f, -4.51957434e-02f, 5.43414429e-02f, 8.05947483e-02f, 3.34232450e-02f, 3.72087508e-02f, -7.41307810e-02f, -5.08706309e-02f, 4.76837568e-02f, -5.85292280e-02f,
  6.87256306e-02f, 6.85134437e-03f, -6.59807771e-02f, -3.57217230e-02f, -2.60432474e-02f, 3.44697200e-02f, -4.75154705e-02f, -1.88708995e-02f, -1.62787549e-02f, 2.37552281e-02f,
  -7.68265203e-02f, -3.76088684e-03f, 7.63026848e-02f, -4.06696908e-02f, 6.62040114e-02f, -2.98518930e-02f, 2.52973493e-02f, 4.35391590e-02f, 8.43569040e-02f, 3.96884270e-02f,
  -1.38809963e-03f, 5.99528439e-02f, 7.83911049e-02f, 7.19097331e-02f, 4.43878248e-02f, -3.96131277e-02f, 8.35751593e-02f, -5.65488711e-02f, 2.44417172e-02f, -9.86427814e-03f,
  5.45021743e-02f, -1.69816185e-02f, 9.56667308e-03f, -3.62515599e-02f, 6.76514357e-02f, 9.24815536e-02f, -5.36445249e-03f, -1.53324241e-02f, 2.05718484e-02f, 1.40004857e-02f,
  -6.38322085e-02f, 1.03002168e-01f, 2.34216228e-02f, 6.14403095e-03f, 6.76345229e-02f, -1.45022953e-02f, 1.88236255e-02f, -1.21074747e-02f, -2.82759853e-02f, 5.44633232e-02f,
  1.94397196e-02f, 5.20508289e-02f, 5.55032305e-03f, -7.71078654e-03f, 6.67008236e-02f, 1.28273303e-02f, 9.44901928e-02f, 8.04479718e-02f, 9.04824808e-02f, -6.31403700e-02f,
  -4.18151123e-03f, 5.97749911e-02f, 1.39833959e-02f, -1.50185907e-02f, 6.23550043e-02f, -5.76341078e-02f, 2.64487360e-02f, -5.77857606e-02f, 5.48641197e-02f, -5.68345524e-02f,
  -1.61628172e-01f, 1.97678655e-01f, -5.29606082e-03f, 1.14461511e-01f, -1.41602755e-02f, -1.99302062e-02f, 3.26561183e-02f, 4.55911718e-02f, 1.84036762e-01f, -4.36255097e-04f,
  -1.35922045e-01f, 1.12487748e-01f, 9.59399641e-02f, 4.80420627e-02f, 6.79928437e-02f, -6.91041537e-03f, 1.90960646e-01f, 1.10264152e-01f, 1.74478367e-01f, 9.08505097e-02f,
  8.41077641e-02f, 7.89375696e-03f, -8.83752108e-02f, -3.00967582e-02f, -1.34237915e-01f, -8.91543478e-02f, -1.22238390e-01f, 3.94245498e-02f, 2.88600363e-02f, 8.90121162e-02f,
  -1.93331819e-02f, 7.94524699e-02f, -7.80371651e-02f, 8.00155774e-02f, -3.57510708e-02f, -3.49305347e-02f, -9.12496448e-02f, -6.87361928e-03f, 4.43153828e-02f, 5.86403050e-02f,
  -1.77515242e-02f, 6.43898398e-02f, -3.10366694e-02f, 6.94367439e-02f, -4.58504222e-02f, 2.66582780e-02f, 7.37364814e-02f, 5.24203219e-02f, -5.02378345e-02f, 1.48459142e-02f,
  5.49604259e-02f, 6.65987954e-02f, -8.30207020e-02f, 6.14582747e-02f, -1.65091045e-02f, -7.45900497e-02f, 6.03326317e-03f, -5.88214286e-02f, -5.17593250e-02f, 1.11111246e-01f,
  1.84613671e-02f, -1.04363775e-02f, -3.60147543e-02f, -5.50194085e-02f, -3.23452614e-02f, 8.31010640e-02f, 1.78034771e-02f, -3.28035355e-02f, -2.37248670e-02f, 1.23351589e-02f,
  -9.25561413e-02f, -5.88817149e-02f, 2.56062523e-02f, -1.47939799e-02f, -3.59665006e-02f, -5.34520708e-02f, 3.42213511e-02f, 7.33329132e-02f, -2.90012993e-02f, -9.13377032e-02f,
  -2.16246862e-02f, 5.40652871e-02f, 3.52686010e-02f, -4.15260382e-02f, 5.19639291e-02f, -2.62257773e-02f, 5.14424630e-02f, 6.53018104e-03f, 1.60147455e-02f, -5.30519113e-02f,
  1.35341838e-01f, 2.80767560e-01f, -4.48686592e-02f, 4.67313593e-03f, -3.74413648e-05f, 2.66726762e-02f, 5.04825525e-02f, 3.91996950e-02f, 1.44044831e-01f, 5.95156923e-02f,
  -6.99481578e-04f, 6.42088428e-03f, -8.21721479e-02f, -1.02589540e-01f, 1.75503623e-02f, -7.25309551e-02f, 1.39920879e-02f, 5.23457564e-02f, 2.63001882e-02f, 2.74933986e-02f,
  4.38924842e-02f, -1.52214672e-02f, -3.92169766e-02f, -4.09107916e-02f, 8.37785080e-02f, -5.09965159e-02f, 6.66586980e-02f, -2.54920628e-02f, -3.02973203e-02f, -3.18607092e-02f,
  -1.29699841e-01f, -9.63079557e-03f, -1.31509468e-01f, -8.51225108e-02f, -1.23011991e-01f, 5.77358790e-02f, -4.42631543e-02f, -2.00503111e-01f, -8.08729231e-02f, 1.88773528e-01f,
  6.31182194e-02f, -1.16483621e-01f, 1.66689485e-01f, -6.21421970e-02f, -2.90741771e-02f, 9.94957015e-02f, 3.62065621e-02f, 4.32236902e-02f, -1.32106602e-01f, -1.77055314e-01f,
  -1.09804288e-01f, -9.76392552e-02f, 3.90291885e-02f, -4.16277237e-02f, -3.23916711e-02f, -3.49419303e-02f, 8.69678706e-02f, 4.46244851e-02f, 4.33365814e-02f, 3.08343731e-02f,
  2.65530334e-03f, -1.48120195e-01f, -1.18869454e-01f, -1.26634794e-03f, 4.70492095e-02f, 4.09673415e-02f, 2.49432661e-02f, 4.82803844e-02f, 3.82328555e-02f, 4.04602475e-03f,
  -6.84012622e-02f, 8.06443859e-03f, -5.39972484e-02f, 2.92570740e-02f, -1.51693411e-02f, -2.99654063e-02f, -1.60507578e-02f, -1.81630682e-02f, 2.61297519e-03f, -6.95108250e-02f,
  7.30502885e-03f, -2.03120485e-02f, 7.76360258e-02f, 4.67228703e-02f, 2.17400808e-02f, 1.11058950e-02f, 6.85880333e-02f, 5.81502132e-02f, 5.76975159e-02f, 3.35436724e-02f,
  6.71009943e-02f, 5.23690023e-02f, -1.15775287e-01f, 4.82937247e-02f, -4.46991324e-02f, 1.84132420e-02f, 4.03689146e-02f, 4.74792495e-02f, -8.88469443e-03f, -5.43024242e-02f,
  7.12508112e-02f, -1.29413381e-02f, 9.21529531e-03f, -7.66582116e-02f, 2.62503326e-02f, 7.31500238e-02f, 2.30923085e-03f, 4.92328592e-02f, -2.72636786e-02f, -2.59960312e-02f,
  -7.80249685e-02f, -5.54436557e-02f, -3.67605388e-02f, -4.04513516e-02f, -8.54682699e-02f, 1.47232627e-02f, 3.27150002e-02f, 8.06792751e-02f, 9.76365954e-02f, 7.69390762e-02f,
  -1.93824805e-02f, -1.50029972e-01f, -9.38147604e-02f, -2.92392168e-02f, 6.27505705e-02f, -3.58204097e-02f, -2.05344576e-02f, -8.07109326e-02f, 9.58693027e-03f, -5.57587817e-02f,
  4.56656981e-03f, -4.80600968e-02f, -2.61762571e-02f, 8.29038993e-02f, 8.87617189e-03f, -8.73441175e-02f, -5.99623285e-02f, 9.90491807e-02f, -7.98835829e-02f, -3.41655500e-02f,
  7.46284276e-02f, -2.88432501e-02f, 6.78082928e-02f, -6.71691000e-02f, -3.22307907e-02f, 8.41484889e-02f, -1.62063260e-02f, -7.72608593e-02f, -1.50955664e-02f, 1.18748099e-02f,
  1.95388228e-01f, -9.97338369e-02f, 7.82939568e-02f, 2.99814165e-01f, 5.00539578e-02f, -2.85331104e-02f, 1.78642049e-01f, 2.46077124e-03f, 3.03768277e-01f, -1.78553030e-01f,
  -8.58169124e-02f, -3.91564844e-03f, -9.34740156e-02f, 1.32090583e-01f, -5.86699769e-02f, 7.04839081e-02f, 2.78317481e-02f, -3.25416140e-02f, 1.44965351e-01f, 3.77910701e-03f,
  4.44215052e-02f, -7.64625752e-03f, 1.48712080e-02f, -1.28607526e-01f, 1.00748882e-01f, -4.97803204e-02f, -6.54588267e-02f, -1.42911941e-01f, -1.35163605e-01f, -1.32944494e-01f,
  -1.15181468e-02f, 1.36638716e-01f, 1.05035171e-01f, 7.38245472e-02f, 2.88205240e-02f, 4.29854691e-02f, -9.05352756e-02f, -5.74593991e-02f, 8.63101706e-02f, -4.86093350e-02f,
  1.39156962e-02f, -6.93579391e-03f, 9.50427074e-03f, 3.05949915e-02f, 1.05196886e-01f, -3.12318746e-03f, 8.41485485e-02f, 7.76302889e-02f, -3.19726430e-02f, 1.63743328e-02f,
  9.99021381e-02f, -7.42948651e-02f, 2.08021645e-02f, -7.27214441e-02f, -2.94222552e-02f, 6.43777894e-03f, -6.90278038e-02f, -1.18717775e-01f, 3.37803885e-02f, 6.84472397e-02f,
  -9.19533893e-02f, 3.69505621e-02f, -3.65118124e-02f, -9.76224523e-03f, -4.10858393e-02f, 4.39705513e-03f, -4.81033921e-02f, -3.92100215e-02f, 8.11054483e-02f, -1.09322853e-02f,
  1.07405402e-01f, -6.44812137e-02f, -5.31580746e-02f, 6.44242316e-02f, 7.24084815e-03f, -5.41897565e-02f, -9.97605175e-03f, -8.26880801e-03f, 4.58691381e-02f, -1.59627385e-02f,
  5.84817119e-02f, -1.05040963e-03f, 4.81311977e-03f, 4.75516468e-02f, 4.08225730e-02f, 3.20889316e-02f, -8.85378346e-02f, 1.29379123e-03f, 6.98775426e-03f, -6.06674664e-02f,
  -5.98670132e-02f, -3.26504745e-02f, 8.10751691e-02f, -7.46385008e-02f, -3.56528163e-02f, 4.60862461e-03f, 2.01948918e-02f, 4.12568785e-02f, 2.75625549e-02f, -2.53560580e-02f,
  -1.51236337e-02f, 6.96397796e-02f, -4.14863564e-02f, 2.48597879e-02f, -2.25090981e-02f, 1.80914234e-02f, -8.91519412e-02f, 4.56374213e-02f, 4.52000909e-02f, -6.12742789e-02f,
  2.59039067e-02f, 8.15993994e-02f, 8.76625180e-02f, 3.44158672e-02f, 4.11908850e-02f, -2.64616068e-02f, -6.52823597e-02f, -1.39102861e-02f, 3.88090089e-02f, 3.22676376e-02f,
  -1.86990909e-02f, 2.18844712e-02f, 1.22276753e-01f, 1.90629750e-01f, -8.62555280e-02f, -2.00280800e-01f, -1.27439812e-01f, 1.26639307e-01f, 4.74445708e-02f, -8.39088485e-02f,
  9.87061299e-03f, 5.19182384e-02f, -2.45282818e-02f, 4.84295422e-03f, 8.00151676e-02f, 4.79898863e-02f, 8.85592848e-02f, -1.20909519e-01f, 1.08967433e-02f, 1.24749154e-01f,
  8.84461328e-02f, 8.26464370e-02f, 1.21093951e-01f, 1.07335560e-01f, -1.05271479e-02f, 1.26172081e-01f, 1.47467867e-01f, -5.99043705e-02f, -6.37957305e-02f, -6.75173700e-02f,
  -1.14251606e-01f, 9.80095044e-02f, -5.01501299e-02f, -2.80941054e-02f, -2.08518878e-02f, 4.14025709e-02f, -5.32539487e-02f, -5.65876886e-02f, 1.66407190e-02f, 5.56136249e-03f,
  -2.98739448e-02f, -1.00698188e-01f, -7.85509050e-02f, -5.81017546e-02f, -3.75188515e-02f, -2.41717864e-02f, 8.29145908e-02f, -4.71984968e-02f, 7.30594173e-02f, -6.53082728e-02f,
  -2.95136254e-02f, -3.13635133e-02f, -6.28350228e-02f, -3.53928134e-02f, 2.56195422e-02f, -3.83144431e-02f, 4.11074832e-02f, 3.60889062e-02f, -4.15024906e-02f, 5.42772003e-02f,
  -1.83410663e-02f, 6.16230592e-02f, -8.51223767e-02f, -9.37189721e-03f, 3.64273638e-02f, -2.26476770e-02f, 9.11045820e-02f, -1.46118449e-02f, 8.36175904e-02f, 2.91119982e-02f,
  4.58073728e-02f, -6.33555697e-03f, -7.39933178e-02f, -8.95602256e-02f, -9.36118606e-03f, -9.98106077e-02f, 3.94297056e-02f, -3.98789831e-02f, 2.03697961e-02f, 2.44200439e-03f,
  5.65249100e-02f, -1.80093125e-02f, 7.01187272e-03f, 6.61594747e-03f, 5.12873456e-02f, -2.32080547e-05f, -4.55847867e-02f, 6.78586736e-02f, -3.39903384e-02f, 3.65845412e-02f,
  1.54496148e-01f, 3.02990854e-01f, 2.02838182e-02f, 2.55734660e-02f, 9.21468996e-03f, -1.23299807e-02f, 2.74285860e-02f, -4.57369238e-02f, 8.31212103e-02f, 7.68698305e-02f,
  5.44403307e-02f, 4.78615612e-02f, -7.10088313e-02f, 3.28259589e-03f, -4.14658748e-02f, -2.15178891e-03f, 2.81598177e-02f, -1.98307727e-02f, 7.99953714e-02f, 1.16985634e-01f,
  1.19637251e-02f, -3.95959020e-02f, 4.30391803e-02f, -4.33769217e-03f, -2.98679266e-02f, -5.98028451e-02f, -5.61688356e-02f, -3.29499692e-02f, 6.46948218e-02f, -4.29042019e-02f,
  1.69680685e-01f, -6.10277951e-02f, 7.83955380e-02f, 2.11516291e-01f, 7.89188966e-02f, 1.35537103e-01f, 8.33896771e-02f, 1.96548834e-01f, 3.76152575e-01f, -9.55134928e-02f,
  2.94384696e-02f, -6.76461607e-02f, -1.73682317e-01f, -8.73154402e-03f, 2.49311887e-02f, -5.95690508e-04f, 9.87465978e-02f, 3.17252502e-02f, 1.59685805e-01f, 1.17311962e-01f,
  1.30845279e-01f, -7.23563656e-02f, -1.46486580e-01f, -3.12259812e-02f, -5.08267693e-02f, -2.13490101e-03f, -1.27878770e-01f, -1.04222082e-01f, -1.83475122e-01f, -1.09213933e-01f,
  -1.86544154e-02f, 1.13246597e-01f, 1.26583138e-02f, -7.65764574e-03f, 3.47359851e-02f, 4.28167284e-02f, -1.07175820e-01f, -1.16610758e-01f, -6.07925877e-02f, -8.36413354e-03f,
  5.24038740e-04f, 1.80806145e-02f, 3.68847959e-02f, -3.92177254e-02f, -2.86558829e-02f, 4.80483472e-02f, 4.69064014e-03f, 5.22028208e-02f, -6.86604232e-02f, -5.40323444e-02f,
  -7.26654939e-03f, -7.65720895e-03f, 4.56736386e-02f, -1.15038477e-01f, -9.08929557e-02f, 3.75909060e-02f, -9.07818973e-02f, -5.75197041e-02f, -5.03541604e-02f, 6.37245998e-02f,
  -1.75161380e-02f, -1.92096159e-02f, -2.90261097e-02f, 9.35648903e-02f, -9.99241043e-03f, 3.13987061e-02f, 5.57341203e-02f, -3.56646180e-02f, 8.91189128e-02f, -8.71171430e-02f,
  -6.66474253e-02f, 3.87155451e-02f, -4.88030836e-02f, -8.78169015e-02f, 1.20520182e-01f, 1.06762044e-01f, -1.08551338e-01f, 9.28378850e-02f, -4.37582731e-02f, -1.99035532e-03f,
  -5.09691350e-02f, -7.92986155e-02f, 2.75529064e-02f, 6.96238279e-02f, -2.44673248e-02f, 1.05156582e-02f, -5.38841486e-02f, 3.36743668e-02f, -9.17415414e-03f, -3.76512557e-02f,
  8.31152871e-02f, 1.18376479e-01f, -4.86352853e-02f, -7.86420237e-03f, -7.47333094e-03f, -6.64657652e-02f, 6.62902147e-02f, -2.79325563e-02f, 6.77562505e-02f, 4.59779240e-02f,
  6.64030537e-02f, 4.74048369e-02f, -3.38731483e-02f, -3.93948369e-02f, -4.48391587e-02f, 4.25438993e-02f, -3.66388410e-02f, 4.66807932e-02f, -2.99812667e-02f, -1.23622157e-02f,
  -2.24569459e-02f, -3.30782942e-02f, -6.49619401e-02f, 9.50332433e-02f, 3.02808564e-02f, -4.36914265e-02f, 2.60331412e-03f, -2.56960168e-02f, -8.23798627e-02f, 3.54600921e-02f,
  1.70367599e-01f, 4.46837395e-02f, 3.36837992e-02f, -5.54969162e-03f, 4.35794443e-02f, -7.00272247e-02f, -6.66102096e-02f, -7.50441030e-02f, -5.25880270e-02f, 7.04546720e-02f,
  -2.10961569e-02f, -2.07824279e-02f, 1.01018488e-01f, -5.35297506e-02f, -1.12802856e-01f, 2.79000327e-02f, -1.71485782e-01f, -6.66159615e-02f, -2.27219127e-02f, -1.06846936e-01f,
  -1.35894284e-01f, -6.95862025e-02f, -9.14078951e-02f, -2.29013339e-02f, 4.42298548e-03f, 6.89358413e-02f, -9.25761089e-02f, 1.96594521e-02f, 3.83126549e-02f, -2.34534708e-03f,
  -3.87978517e-02f, 1.59192625e-02f, 1.04386648e-02f, 4.49050143e-02f, 4.13898379e-03f, -1.67729426e-02f, -5.54948337e-02f, 1.13938101e-01f, 7.27818087e-02f, -3.80835049e-02f,
  -6.28450811e-02f, -5.40396273e-02f, -4.01137881e-02f, 8.69481117e-02f, -6.98300079e-02f, -5.42334914e-02f, 4.11766469e-02f, 2.55240072e-02f, -5.70353237e-04f, -4.74514030e-02f,
  -8.71533006e-02f, -9.67421532e-02f, -7.13252798e-02f, -4.44634780e-02f, 3.76357548e-02f, -4.78929020e-02f, -9.18058902e-02f, -6.48739710e-02f, 4.47013900e-02f, -5.57466876e-03f,
  3.48942191e-03f, 5.93238464e-03f, -1.49846151e-02f, 4.77989130e-02f, -8.00409019e-02f, -2.47871671e-02f, 8.14763084e-02f, 1.36760110e-02f, -5.82180843e-02f, 2.60074511e-02f,
  6.12797169e-03f, -2.12320518e-02f, 1.21403290e-02f, 4.43831272e-02f, -9.65092257e-02f, 9.32901632e-03f, -4.48851148e-03f, -4.55259569e-02f, -5.72324805e-02f, -5.32496311e-02f,
  8.95634666e-02f, -8.50792453e-02f, 4.90269214e-02f, -6.60057664e-02f, 6.19690754e-02f, -7.25833923e-02f, 2.09991131e-02f, 2.48400327e-02f, 1.84057597e-02f, -4.79878969e-02f,
  -5.54275000e-03f, -7.80397281e-02f, -8.39662775e-02f, -2.18309928e-02f, -8.34133383e-03f, 7.37047419e-02f, 6.47518039e-02f, 2.65211612e-02f, 7.37031875e-03f, 2.02023014e-02f,
  1.76911056e-02f, -6.84944242e-02f, -8.83097127e-02f, -6.18144013e-02f, 1.07729016e-02f, -4.41373400e-02f, 6.42261282e-03f, -2.79053953e-03f, 6.09460101e-02f, -9.57253426e-02f,
  3.86709087e-02f, 2.98244320e-02f, 5.33044748e-02f, 5.17375357e-02f, -6.37365431e-02f, -1.39720645e-02f, 6.34325147e-02f, -4.25552949e-02f, 4.89961058e-02f, 6.03186479e-03f,
  -1.59880489e-01f, 1.22252792e-01f, -1.02994805e-02f, 7.86492154e-02f, -1.01901196e-01f, -9.56696644e-02f, 8.52767229e-02f, -3.76782641e-02f, -1.52623713e-01f, 1.02730215e-01f,
  1.64536536e-01f, -4.26909216e-02f, 1.40644953e-01f, 1.29573911e-01f, 1.08885122e-02f, 8.98948237e-02f, 4.65520956e-02f, 1.00693427e-01f, -3.18818130e-02f, 1.41531065e-01f,
  -1.64048094e-02f, 1.19554222e-01f, 1.24969490e-01f, 3.23916227e-02f, -5.16724847e-02f, 1.31858448e-02f, 1.85751006e-01f, 8.76258835e-02f, 1.66148797e-01f, 3.38868424e-02f,
  6.73328415e-02f, 3.61480564e-02f, -5.79560408e-03f, -4.56120595e-02f, -1.70056857e-02f, 2.53464617e-02f, 8.17594156e-02f, -3.20083052e-02f, 2.20801961e-02f, 5.45956455e-02f,
  -6.51853532e-02f, -4.99298470e-03f, 2.19685994e-02f, 4.72894870e-02f, -6.31072447e-02f, -7.92261511e-02f, -2.00838950e-02f, -7.56191090e-02f, 6.44180924e-02f, 3.16628814e-02f,
  -1.78921409e-03f, 4.27339822e-02f, 4.91674244e-02f, 7.82852471e-02f, 5.87292314e-02f, -2.73393672e-02f, 6.07314818e-02f, -4.37252112e-02f, -1.00783817e-01f, 1.90095380e-02f,
  5.19283190e-02f, 5.52965403e-02f, 1.71692669e-02f, 1.46877524e-02f, -3.49460989e-02f, 6.78429455e-02f, 4.27240804e-02f, -2.78057195e-02f, 7.32546821e-02f, -5.19092642e-02f,
  4.71320525e-02f, -5.02425656e-02f, -3.60787623e-02f, 3.90176736e-02f, 7.95041174e-02f, 8.70259106e-03f, -5.08066416e-02f, 7.32677663e-03f, -4.29098345e-02f, 5.95709756e-02f,
  1.07754953e-01f, 1.81656443e-02f, 1.10923968e-01f, -7.80387819e-02f, 4.80158888e-02f, 5.50069287e-02f, -7.53663331e-02f, -1.62728094e-02f, -3.28434035e-02f, -7.47488365e-02f,
  3.41160595e-02f, 6.47758543e-02f, -7.00127659e-03f, -5.39472811e-02f, -1.14273410e-02f, -5.93845081e-03f, 8.61542579e-03f, -8.20674673e-02f, 7.00194463e-02f, -3.03080697e-02f,
  -1.16707738e-02f, 4.58338186e-02f, -1.72328707e-02f, -6.46506026e-02f, -1.74413864e-02f, 5.57183437e-02f, -2.02284791e-02f, 4.69515696e-02f, 1.37031637e-02f, 3.96943092e-03f,
  -6.71474263e-02f, 5.44818677e-02f, 1.97320171e-02f, 1.29643884e-02f, -5.93139464e-03f, 4.21304181e-02f, -1.21278547e-01f, -4.74128984e-02f, 3.87583561e-02f, -3.91675681e-02f,
  -1.03511564e-01f, 1.66551068e-01f, 6.76656291e-02f, 1.03309259e-01f, -1.37047432e-02f, 8.32358375e-02f, 5.69643266e-02f, 3.74061465e-02f, 1.60655510e-02f, 8.32018107e-02f,
  -1.72199158e-03f, 1.48582950e-01f, -7.04223141e-02f, 4.03267238e-03f, -1.80228531e-01f, -1.56510413e-01f, 2.93057933e-02f, 2.03922223e-02f, -2.15287134e-02f, 6.68040961e-02f,
  4.55424264e-02f, -6.76150769e-02f, -2.11836137e-02f, -1.01106204e-01f, -4.28231695e-04f, 7.19760135e-02f, -1.36462182e-01f, -6.65624812e-02f, 4.22658734e-02f, -1.17404148e-01f,
  -9.04474407e-02f, -1.04619330e-02f, -4.34941240e-02f, 1.14615045e-01f, 5.94378188e-02f, 4.46607247e-02f, -7.28425430e-03f, -1.28950961e-02f, 4.45899405e-02f, -2.36149188e-02f,
  8.68882760e-02f, 7.93268532e-02f, -1.28579065e-02f, 3.89562026e-02f, 1.10270433e-01f, 6.85456917e-02f, -1.59517080e-02f, 4.29647937e-02f, 7.87995458e-02f, 1.31781399e-01f,
  1.57046452e-01f, 1.37863327e-02f, -3.93578373e-02f, -2.66709812e-02f, 1.42150710e-03f, 6.21156879e-02f, 1.00929290e-01f, 4.13229130e-02f, 3.74624878e-02f, -7.20643625e-02f,
  3.56658781e-03f, 1.99475084e-02f, -2.53774039e-02f, -7.06602186e-02f, 3.56819853e-02f, -3.19542103e-02f, 7.43267387e-02f, -8.35320801e-02f, 6.69260249e-02f, -2.67017148e-02f,
  -6.14641830e-02f, 5.82057610e-03f, 2.34037209e-02f, 1.50695667e-02f, 3.30192111e-02f, 6.52539358e-02f, 4.26392406e-02f, -5.31566888e-02f, -2.47935709e-02f, 4.57600318e-02f,
  2.57366765e-02f, 4.48787101e-02f, -3.92152630e-02f, 7.81142339e-02f, 8.51297285e-03f, 5.81318028e-02f, -8.37038923e-03f, 1.05494663e-01f, 5.18085174e-02f, -5.59339114e-02f,
  -7.10984096e-02f, -5.79312369e-02f, 4.09392677e-02f, 8.88988972e-02f, 4.57031317e-02f, -2.72589102e-02f, -4.73070666e-02f, -3.24418098e-02f, -5.33341877e-02f, 6.46084473e-02f,
  5.84103167e-02f, -3.35139334e-02f, -7.98740331e-03f, -7.73374736e-02f, 9.16364416e-03f, -8.75836685e-02f, -5.71802184e-02f, 9.57932025e-02f, -6.55517727e-02f, 7.06874505e-02f,
  1.45925749e-02f, 9.57135558e-02f, 3.29327062e-02f, 8.40184018e-02f, 9.93983597e-02f, -7.10377395e-02f, 5.35918586e-02f, 3.60038541e-02f, 8.46034009e-03f, 3.61002982e-02f,
  -1.23051874e-01f, 2.63523012e-01f, 1.13709226e-01f, -5.18994667e-02f, 7.59649947e-02f, 4.14220355e-02f, -7.62260407e-02f, 5.44880331e-02f, -4.02503572e-02f, 2.02311188e-01f,
  -2.05349773e-02f, 5.68528809e-02f, -6.41907528e-02f, 9.09807086e-02f, -2.60738760e-01f, 1.32470801e-02f, 3.31222080e-02f, 1.27786860e-01f, -2.53174827e-02f, 2.27986015e-02f,
  -1.06108665e-01f, -9.78303328e-02f, 2.01904122e-02f, 6.10685237e-02f, 3.05935610e-02f, -3.45512070e-02f, -1.52166888e-01f, -5.95634952e-02f, 1.13158487e-01f, -6.99132755e-02f,
  1.56939458e-02f, -1.17892019e-01f, -4.43318449e-02f, -1.77282151e-02f, -2.80977581e-02f, 4.40013297e-02f, -7.30776787e-03f, -2.66752224e-02f, 7.75920693e-03f, -3.75707224e-02f,
  4.03552093e-02f, -2.11987868e-02f, 5.50631732e-02f, 6.39660656e-02f, 6.19399361e-02f, -1.02751947e-03f, 5.73870242e-02f, 8.22201222e-02f, 5.74522242e-02f, 1.44971292e-02f,
  -3.45022939e-02f, 6.99961931e-02f, 1.32918078e-02f, -7.83873200e-02f, -1.02718107e-01f, 2.26644464e-02f, -2.61031352e-02f, 3.61232758e-02f, 2.41324492e-02f, -3.86026092e-02f,
  -1.38119087e-02f, 1.62640624e-02f, -9.06659290e-02f, 3.71505842e-02f, 4.82943505e-02f, 1.92051083e-02f, -4.10986431e-02f, 2.03990638e-02f, 2.43748724e-02f, -5.22800945e-02f,
  -4.33646850e-02f, -5.70338406e-02f, -3.70011665e-02f, 8.15058798e-02f, 4.32794392e-02f, -5.00428863e-02f, 7.02020898e-02f, -7.13413581e-02f, -2.35135444e-02f, 3.73567306e-02f,
  -7.57146478e-02f, 3.76389697e-02f, -5.02077900e-02f, 2.18510218e-02f, 1.88401453e-02f, 6.03889674e-02f, -9.05950591e-02f, 2.58009378e-02f, -1.66682545e-02f, 2.65313336e-03f,
  -8.84526595e-02f, -4.07744758e-02f, 5.81463166e-02f, -4.49325703e-02f, 2.28464212e-02f, 6.07011504e-02f, -6.35256395e-02f, -3.66410278e-02f, -3.59889343e-02f, -7.44367996e-03f,
  -4.69536074e-02f, 4.93790843e-02f, 2.57434119e-02f, 1.85105950e-02f, 6.59483895e-02f, 2.47855540e-02f, 3.78328599e-02f, -4.36224528e-02f, 6.60167262e-02f, 6.58261916e-03f,
  -6.35771034e-03f, -3.24053294e-03f, -2.81949230e-02f, -1.52458269e-02f, 3.34909037e-02f, 4.31901701e-02f, -4.16067056e-02f, 6.18132763e-02f, -4.76819202e-02f, -6.32703975e-02f,
  4.04382348e-02f, 9.07596946e-02f, -2.10281372e-01f, 2.09305007e-02f, 4.67975810e-02f, -1.23298630e-01f, -8.27929229e-02f, -1.61265209e-02f, -2.20369637e-01f, 1.09358132e-01f,
  1.21312089e-01f, -3.56169306e-02f, -6.05411455e-02f, 2.94435412e-01f, 2.34282970e-01f, -3.15144360e-02f, 2.64973700e-01f, 1.64564326e-01f, 3.39318849e-02f, 1.70216277e-01f,
  5.62194996e-02f, 4.19461548e-01f, 1.37180939e-01f, 1.99035212e-01f, 1.56093910e-01f, 5.24303094e-02f, 2.56781191e-01f, -3.59476134e-02f, 2.86097527e-01f, 1.23328686e-01f,
  7.62923062e-02f, 7.25298971e-02f, -6.08341172e-02f, -2.97035817e-02f, -4.30432037e-02f, -4.59026545e-02f, -6.74030185e-02f, -2.62750033e-02f, 9.90510173e-03f, 1.13332802e-02f,
  -4.72006537e-02f, 6.22169115e-02f, 3.29394788e-02f, -2.50823359e-04f, -9.53332111e-02f, 3.26928645e-02f, -9.54754427e-02f, -5.71207926e-02f, -5.96017838e-02f, -2.33135819e-02f,
  -7.33218640e-02f, 7.13557228e-02f, 5.71654327e-02f, 8.81514549e-02f, -6.07256629e-02f, 4.87331450e-02f, 6.20162524e-02f, -3.91946472e-02f, 6.34168386e-02f, -5.36282435e-02f,
  1.00105762e-01f, 7.58721083e-02f, -8.90351310e-02f, 1.63755044e-02f, 7.18637183e-02f, -7.58308396e-02f, 6.65749684e-02f, 6.80366084e-02f, -2.14927793e-02f, 5.19487783e-02f,
  -4.30060364e-02f, -6.94490373e-02f, -1.86378025e-02f, 1.68707734e-03f, -4.55738418e-02f, -1.01112634e-01f, 2.02880912e-02f, -2.87206508e-02f, 5.35767712e-02f, -5.12238815e-02f,
  -3.75120863e-02f, -2.33316217e-02f, -8.02508295e-02f, 6.97308704e-02f, 6.65036738e-02f, -1.86861325e-02f, 6.89891353e-03f, 2.09282711e-02f, -2.26270296e-02f, -9.67078377e-03f,
  6.48468584e-02f, 2.02755123e-01f, -8.59083012e-02f, -7.22622573e-02f, 4.00688313e-02f, -2.58952938e-02f, -5.53739741e-02f, -5.97814051e-03f, 1.11562833e-02f, 1.53043559e-02f,
  5.66821769e-02f, 2.60924231e-02f, 1.97438654e-02f, 1.29693642e-03f, -3.81163470e-02f, 3.95083912e-02f, 8.38492513e-02f, -3.38664721e-03f, 1.01931408e-01f, 1.41102374e-01f,
  4.08239141e-02f, -2.52598487e-02f, 5.84684350e-02f, -1.17256278e-02f, 9.54889655e-02f, 4.08306792e-02f, -3.29826437e-02f, -1.60925593e-02f, 1.19630136e-01f, -2.07165778e-02f,
  -6.59487071e-03f, -1.17223738e-02f, 1.92766055e-01f, -3.61294695e-03f, -1.05309390e-01f, 1.16827317e-01f, 1.88612595e-01f, 1.47043234e-02f, 1.58867836e-01f, -3.12388130e-02f,
  -1.78876474e-01f, -5.28968126e-03f, -9.62802302e-03f, -1.44690454e-01f, 2.80907720e-01f, 1.13660976e-01f, 2.84927040e-02f, 1.33530898e-02f, 1.33150995e-01f, -6.83071045e-03f,
  2.29440350e-02f, -1.94029987e-01f, -1.17536917e-01f, -5.89374639e-02f, -9.69219506e-02f, -1.33866504e-01f, -1.96982682e-01f, 4.99027260e-02f, -1.91328838e-01f, -3.13990824e-02f,
  2.37285183e-03f, -7.57212639e-02f, -4.89084795e-02f, -2.23542787e-02f, 1.08500794e-02f, -9.67555493e-03f, 4.36371081e-02f, 3.01862806e-02f, -2.01063957e-02f, 4.72777709e-03f,
  -4.88922261e-02f, -7.92594776e-02f, -3.47171798e-02f, -3.59040275e-02f, -9.58447456e-02f, 1.69230476e-02f, -5.84677421e-02f, 1.97853651e-02f, 1.23103196e-03f, 2.22058296e-02f,
  6.38738498e-02f, -2.27940436e-02f, 5.59900068e-02f, 6.62708580e-02f, -8.07742774e-03f, -1.71489194e-02f, 3.76011841e-02f, 3.65282334e-02f, -3.45379375e-02f, 1.51228597e-02f,
  4.95380461e-02f, 6.87688068e-02f, 6.08562008e-02f, -6.43798932e-02f, 6.97931796e-02f, -5.20646982e-02f, -3.82112376e-02f, -5.14439158e-02f, 8.32822621e-02f, -7.92260915e-02f,
  9.84170213e-02f, -9.77517739e-02f, 1.85175315e-02f, -3.63108367e-02f, 5.06132729e-02f, -5.51809669e-02f, 1.73897408e-02f, -6.98226988e-02f, -2.54112966e-02f, -7.78579712e-02f,
  1.67235658e-02f, 5.24857603e-02f, -8.67469013e-02f, -6.18043728e-02f, -1.49396881e-02f, -7.13174939e-02f, 2.04363987e-02f, 2.10763491e-03f, -1.07076898e-01f, -4.46185982e-03f,
  1.53278038e-01f, 1.73506200e-01f, 5.91806956e-02f, -5.49245179e-02f, 8.83934721e-02f, 2.71040667e-02f, 2.09157113e-02f, -1.52322361e-02f, 7.07998797e-02f, -5.47136180e-02f,
  -3.24321836e-02f, -8.60896856e-02f, 3.14585529e-02f, 4.54997867e-02f, -7.55623132e-02f, 1.89163795e-04f, -3.35221738e-02f, 4.25938740e-02f, -4.09606583e-02f, 2.71917656e-02f,
  -8.38556513e-02f, -2.73191724e-02f, 7.69712999e-02f, -2.55792029e-02f, 3.84263247e-02f, 3.17578577e-02f, 4.93087806e-02f, 2.10095700e-02f, -6.63284585e-02f, 5.90690449e-02f,
  -1.71512067e-01f, 5.17409071e-02f, 1.30236372e-01f, -2.55239636e-01f, 9.44798663e-02f, 7.75606036e-02f, 3.46098505e-02f, 9.72755328e-02f, -2.35859752e-01f, -1.65524781e-01f,
  1.42414840e-02f, -1.27911881e-01f, 5.55219389e-02f, -1.23723485e-01f, 1.31953403e-01f, -6.73363777e-03f, 3.37482840e-02f, -7.52216950e-02f, 8.26428160e-02f, -7.92327225e-02f,
  -2.31773481e-02f, -1.19216762e-01f, 7.24203140e-02f, 5.98737635e-02f, -3.08669992e-02f, 1.87731832e-02f, -9.51489136e-02f, 6.76430985e-02f, -6.08578362e-02f, -9.58314538e-02f,
  6.26545250e-02f, -2.63244212e-02f, 1.10057080e-02f, -4.69767638e-02f, 5.43009378e-02f, 6.49026036e-02f, 6.89235330e-02f, 1.32491784e-02f, 7.97351524e-02f, 8.39642063e-02f,
  6.69378564e-02f, -3.99744622e-02f, -1.07701048e-01f, 7.90702254e-02f, 1.55238144e-04f, -5.21368943e-02f, 8.51737484e-02f, -3.01114023e-02f, -7.08389794e-03f, 8.48011822e-02f,
  2.12213192e-02f, -7.13000074e-02f, -5.44596128e-02f, -2.52876133e-02f, -4.27784994e-02f, -3.24827209e-02f, 8.50928128e-02f, -5.42235896e-02f, 2.94667240e-02f, 3.46383080e-02f,
  -7.38352761e-02f, -2.08843499e-03f, 2.51432266e-02f, -3.09146512e-02f, -2.60529835e-02f, 3.12983170e-02f, -2.82742120e-02f, -7.55959973e-02f, -2.12452821e-02f, -1.49457995e-02f,
  -5.96350916e-02f, 6.30258843e-02f, 1.16971256e-02f, -9.28545520e-02f, 5.84193282e-02f, 5.35734035e-02f, 1.71507634e-02f, -4.71078083e-02f, -2.52149813e-02f, 3.67172509e-02f,
  1.38294753e-02f, 5.30766211e-02f, -7.86571428e-02f, 3.24478820e-02f, 5.16881682e-02f, -7.75883421e-02f, -4.07903939e-02f, -5.44351563e-02f, 8.09611380e-03f, -5.13950326e-02f,
  5.80218770e-02f, -6.32503107e-02f, -6.84486553e-02f, -2.53516603e-02f, 1.78896748e-02f, 1.07035942e-01f, 2.95413136e-02f, -1.12058464e-02f, 2.21532155e-02f, 7.36797228e-02f,
  5.68961427e-02f, -2.05478854e-02f, -1.65650565e-02f, 7.16089876e-03f, -2.27400567e-02f, 7.29732066e-02f, 5.09276055e-02f, 3.17356847e-02f, 1.93404239e-02f, 1.01283267e-01f,
  9.95268114e-03f, 8.63229297e-03f, -3.69514339e-02f, -8.41244310e-02f, -8.65283385e-02f, -8.26547816e-02f, 2.29201298e-02f, 3.95636074e-02f, -2.19788845e-03f, -8.96581039e-02f,
  9.38085280e-03f, 1.75493211e-01f, 4.16179486e-02f, -9.21997800e-02f, -1.48399666e-01f, -2.41167158e-01f, -1.61375493e-01f, -8.34167749e-02f, 5.67299761e-02f, 7.00377971e-02f,
  -3.33075002e-02f, 1.95714965e-01f, 1.02852210e-01f, 1.30370175e-02f, -6.49417713e-02f, 2.41699144e-02f, -3.49328294e-02f, 6.50050938e-02f, -7.18135089e-02f, -4.91335429e-02f,
  -5.55188507e-02f, -1.36821210e-01f, -8.08517933e-02f, -3.34295258e-02f, -9.56606045e-02f, -5.21805622e-02f, -8.64373222e-02f, -9.80835333e-02f, -1.12576246e-01f, -1.17311947e-01f,
  -1.57532007e-01f, -1.12203643e-01f, 7.46503696e-02f, -1.60435438e-02f, 3.09467083e-04f, -3.98403034e-03f, -1.63043533e-02f, -6.63590655e-02f, 2.90356800e-02f, 7.58069307e-02f,
  5.40877022e-02f, -8.15806016e-02f, 6.61607459e-02f, 7.75137916e-02f, -2.79118586e-02f, -5.84155619e-02f, 5.69830276e-03f, 5.83398156e-02f, -3.30040865e-02f, -4.33704145e-02f,
  -2.17105690e-02f, 7.67278224e-02f, -3.89868170e-02f, 9.77553278e-02f, -8.92514065e-02f, 3.64913791e-02f, -3.62350568e-02f, -5.93755394e-02f, 3.61642092e-02f, -5.11378609e-02f,
  6.66784048e-02f, 8.69270694e-03f, 3.80476825e-02f, 1.03445360e-02f, -9.91940051e-02f, 4.86685373e-02f, -2.23770775e-02f, -5.46202064e-02f, -6.22957386e-02f, 5.52157126e-02f,
  3.43843736e-02f, 4.46010679e-02f, 4.79461402e-02f, -6.36480451e-02f, 8.65587220e-03f, -2.53609885e-02f, -8.18455815e-02f, 8.09209188e-04f, 5.75869977e-02f, 3.15915234e-02f,
  -2.06814241e-02f, 4.43841480e-02f, -1.46366907e-02f, -5.05796596e-02f, -9.07423422e-02f, -4.62810509e-03f, 2.94211954e-02f, 9.57972705e-02f, 3.13166082e-02f, -7.40864128e-02f,
  -1.96791202e-01f, -2.37893000e-01f, -8.70199502e-02f, -8.69620219e-02f, 2.20655072e-02f, -1.70695074e-02f, -7.98878074e-03f, 6.06137654e-03f, -5.60793020e-02f, -9.98235568e-02f,
  -3.33262682e-02f, 1.78487748e-02f, -4.18224633e-02f, -6.27660453e-02f, -5.55680692e-02f, 1.93505883e-02f, 7.58796036e-02f, 8.31273571e-02f, -5.29959723e-02f, 4.69612069e-02f,
  -4.57958356e-02f, -8.65880400e-02f, 5.09659424e-02f, -5.91107868e-02f, -5.26218712e-02f, 4.47713584e-03f, 2.84704138e-02f, -1.26822833e-02f, -1.46136265e-02f, 3.29207629e-02f,
  -1.57347888e-01f, 3.63842957e-02f, 9.48248245e-03f, -3.87770049e-02f, -1.76965632e-02f, 1.34937108e-01f, 6.37973994e-02f, 6.29790425e-02f, 6.01609121e-04f, 8.73329341e-02f,
  -9.81875956e-02f, -5.80542609e-02f, 2.36131717e-02f, 5.98065406e-02f, 5.73369786e-02f, 1.72682896e-01f, 1.15721792e-01f, 1.36477217e-01f, -4.25149202e-02f, 8.84944387e-03f,
  -7.01443553e-02f, -5.49867451e-02f, -3.72867063e-02f, 1.96498837e-02f, -9.71884951e-02f, 2.39784662e-02f, -1.54304832e-01f, 1.61362477e-02f, -5.65284155e-02f, -5.87503687e-02f,
  -2.91213598e-02f, 1.57672744e-02f, 5.74257895e-02f, -5.88636398e-02f, -9.41769853e-02f, -9.08330828e-02f, 5.08915521e-02f, -9.59427878e-02f, 7.58646056e-03f, -8.32504556e-02f,
  -2.40962394e-02f, 6.84560314e-02f, -3.70120001e-03f, 8.12340602e-02f, -3.59845795e-02f, -9.79343131e-02f, -5.99591471e-02f, 2.14157626e-02f, 6.00795113e-02f, -5.49977385e-02f,
  2.77536791e-02f, -8.53103399e-02f, -3.82165425e-02f, -2.20955964e-02f, -7.67960176e-02f, -2.07529012e-02f, 1.20737016e-01f, -4.98187030e-04f, -7.30196387e-02f, 1.47675304e-02f,
  -4.31070551e-02f, -1.63713042e-02f, -9.64518823e-03f, -6.26090392e-02f, 3.89720201e-02f, -7.13677257e-02f, -6.12874469e-03f, -2.86869053e-02f, -6.79811686e-02f, -2.46354155e-02f,
  3.05489898e-02f, -4.75880317e-02f, -4.18279842e-02f, -1.45844864e-02f, -3.46613564e-02f, 8.80658850e-02f, -5.65170385e-02f, -5.21745719e-02f, 6.13338426e-02f, 8.38824660e-02f,
  2.89028902e-02f, -5.80900945e-02f, -8.30619112e-02f, -3.77163058e-03f, -5.09826094e-02f, -6.93580182e-03f, 4.74594049e-02f, -5.71027249e-02f, 2.47965362e-02f, 6.70628846e-02f,
  -6.07370585e-02f, 3.02660726e-02f, 1.17061604e-02f, -4.61446084e-02f, -8.24032500e-02f, 3.85149084e-02f, -2.48106644e-02f, 4.06356715e-02f, -5.65797836e-02f, -8.12040120e-02f,
  -4.50863317e-02f, -8.08485374e-02f, 5.60493842e-02f, -1.25612868e-02f, 6.38053268e-02f, -6.62170276e-02f, -1.71812568e-02f, 5.57412440e-03f, -6.40621632e-02f, 5.78652658e-02f,
  1.02199633e-02f, -3.26522514e-02f, -5.25006242e-02f, -2.81848316e-03f, 6.28645197e-02f, 3.83781679e-02f, -3.21257971e-02f, -4.55086641e-02f, -3.42111103e-02f, -2.42251046e-02f,
  -1.83230247e-02f, -1.11716874e-01f, -3.09653357e-02f, -5.47412857e-02f, -1.02439091e-01f, -1.76815450e-01f, 5.17235184e-03f, -1.87466800e-01f, 8.13331977e-02f, 3.64519726e-03f,
  -4.00303975e-02f, 4.73561436e-02f, 8.35414827e-02f, -4.91454229e-02f, 9.78706330e-02f, 2.74711791e-02f, -3.34303342e-02f, 6.28017187e-02f, 1.62346773e-02f, -2.75412109e-02f,
  4.49694432e-02f, -1.40968710e-01f, 4.13123854e-02f, -1.61233157e-01f, -1.58957347e-01f, -2.31464524e-02f, 1.16731068e-02f, -1.21196449e-01f, -3.55333425e-02f, -8.68520066e-02f,
  1.33654568e-02f, -3.46083306e-02f, -3.81789505e-02f, -5.15311211e-02f, 1.54630495e-02f, 7.00132400e-02f, -3.13801467e-02f, -4.92384136e-02f, -1.01409756e-01f, -4.23763357e-02f,
  -6.31710142e-02f, 2.97043156e-02f, -9.25785303e-02f, -4.69154455e-02f, -1.25490487e-01f, -8.13415200e-02f, -2.69192690e-03f, 6.12806529e-02f, 5.22024296e-02f, -5.88375404e-02f,
  3.40992808e-02f, 1.82337444e-02f, 1.16943553e-01f, -1.34765403e-02f, -2.71061212e-02f, -4.07480225e-02f, 6.94010258e-02f, 7.77994916e-02f, 4.07362403e-03f, 7.17663541e-02f,
  -7.15129152e-02f, 5.15678152e-02f, 8.18290263e-02f, 6.06073923e-02f, -9.91265029e-02f, -1.50977343e-04f, -6.57532588e-02f, 4.37432015e-03f, -4.65269275e-02f, -5.26940525e-02f,
  -6.47953078e-02f, -1.49011444e-02f, 3.86869721e-02f, -1.97905134e-02f, 1.80407967e-02f, 4.13040072e-03f, -4.61487882e-02f, 3.35372686e-02f, 3.70258726e-02f, -5.79475835e-02f,
  -5.47134643e-03f, 5.45191169e-02f, -8.71041045e-02f, 1.25542199e-02f, -3.95570844e-02f, -3.75189073e-02f, -1.28918551e-02f, -7.14905187e-02f, 1.31945889e-02f, 5.20509668e-02f,
  -1.66011840e-01f, -9.46397781e-02f, 1.99321080e-02f, -8.22496787e-02f, -6.73950016e-02f, 3.35963219e-02f, -7.33060017e-02f, -6.30801916e-02f, -2.48602293e-02f, -2.88789980e-02f,
  6.13614805e-02f, 1.57697836e-03f, -8.89191926e-02f, 1.18679618e-02f, 1.89109296e-02f, -9.63676944e-02f, -3.17765884e-02f, 8.98248106e-02f, -5.66284452e-03f, 2.44488716e-02f,
  8.28565657e-02f, -8.35761800e-02f, -1.65313240e-02f, 7.31971562e-02f, -5.30955708e-03f, 3.45775411e-02f, -4.63080853e-02f, -1.24744931e-02f, -8.28763321e-02f, -2.68464219e-02f,
  9.42695588e-02f, -5.35738394e-02f, 1.60886467e-01f, 2.65133649e-01f, 1.65006742e-01f, -1.00271776e-01f, -2.63347523e-03f, 7.92484805e-02f, 1.00716971e-01f, -2.52490863e-02f,
  -7.51370862e-02f, 5.42484643e-03f, -1.81114092e-01f, 1.29876018e-01f, -2.11714450e-02f, -1.99240476e-01f, 1.81509331e-02f, -8.98823589e-02f, 7.28263929e-02f, -6.99172392e-02f,
  1.38475880e-01f, 1.84418019e-02f, -5.82745671e-03f, -7.75503218e-02f, 6.90111518e-02f, -2.22669560e-02f, -7.78668821e-02f, -1.63427964e-02f, 9.40432474e-02f, 1.37757752e-02f,
  7.20521882e-02f, 6.79484196e-03f, -6.88283611e-03f, 1.04328275e-01f, -5.26207089e-02f, -1.77710094e-02f, 1.25723053e-02f, 5.02042137e-02f, 7.13096336e-02f, 6.65597394e-02f,
  3.37296240e-02f, -1.08400881e-02f, 9.54947397e-02f, -5.25542572e-02f, 8.40801969e-02f, 1.37599632e-02f, -2.36008577e-02f, -6.48552626e-02f, -1.26171475e-02f, -1.06518179e-01f,
  8.41570348e-02f, -4.95159850e-02f, -3.13712023e-02f, 3.22398059e-02f, 5.59499674e-02f, 2.70811170e-02f, 4.96554673e-02f, -9.51845199e-02f, 5.98212257e-02f, 1.04059167e-01f,
  -9.47261080e-02f, 1.64373256e-02f, 1.42426901e-02f, 3.22399884e-02f, -4.49070297e-02f, -4.50801067e-02f, -3.07111554e-02f, -4.40839231e-02f, -1.33895157e-02f, -1.06507592e-01f,
  -8.75936002e-02f, 7.77427703e-02f, 6.17532320e-02f, 1.88370645e-02f, 9.45517942e-02f, -3.34629007e-02f, 4.53313626e-02f, 4.73559387e-02f, 6.52840408e-03f, 6.08164631e-02f,
  -4.34917770e-02f, 8.89877453e-02f, 9.16561298e-03f, -8.00717026e-02f, -3.91267277e-02f, 1.46004104e-03f, -7.97583386e-02f, 3.50067094e-02f, 2.32165419e-02f, -5.34690954e-02f,
  2.23480724e-02f, -5.93626723e-02f, 4.61485013e-02f, 8.04686174e-02f, 6.70769736e-02f, -8.27008709e-02f, -1.41162481e-02f, -4.68807556e-02f, -2.25847606e-02f, -5.20210452e-02f,
  -1.10760366e-03f, -5.05815372e-02f, -6.51219022e-03f, 4.63115238e-02f, 1.23778004e-02f, -7.55661577e-02f, 6.39299750e-02f, 7.93027356e-02f, -4.61491495e-02f, 5.63020594e-02f,
  3.36099155e-02f, 4.29978855e-02f, 9.52954888e-02f, 3.54805887e-02f, -6.48582131e-02f, 2.52268761e-02f, 2.34563872e-02f, 7.81040341e-02f, -3.44840698e-02f, -2.57316604e-02f,
  4.76915836e-02f, -5.28896004e-02f, -2.50218540e-01f, -4.25794497e-02f, -9.40217301e-02f, 9.32605565e-02f, -1.34492710e-01f, -6.38510063e-02f, -1.14211172e-01f, 1.49968430e-01f,
  7.22213164e-02f, 6.70121983e-02f, 2.25556344e-02f, -1.67746376e-02f, 1.02391139e-01f, 4.89670550e-04f, -1.98868271e-02f, 9.39149335e-02f, 1.80175304e-02f, -2.17056870e-02f,
  7.77558088e-02f, 1.12543784e-01f, -7.69911930e-02f, -4.59636934e-02f, -9.50497389e-02f, -9.74230990e-02f, 1.79959387e-02f, -1.34006977e-01f, -4.28738967e-02f, 9.07098427e-02f,
  -4.24613282e-02f, 7.85102546e-02f, 2.13265084e-02f, 8.80286563e-03f, 6.30669221e-02f, -1.83235724e-02f, 7.23310485e-02f, -2.15421580e-02f, 1.77430976e-02f, -6.14899844e-02f,
  -4.83982787e-02f, -1.75366066e-02f, 8.01226720e-02f, -3.77411284e-02f, 5.57689071e-02f, -1.05982915e-01f, 6.08471408e-03f, -5.33593260e-03f, -2.04953309e-02f, -6.69991001e-02f,
  2.99814418e-02f, -7.94257745e-02f, -8.25240314e-02f, -9.09636766e-02f, -5.04579172e-02f, -7.28045702e-02f, 7.15016108e-03f, -8.70368034e-02f, 9.41790640e-02f, -7.37617612e-02f,
  6.39328584e-02f, 4.70842719e-02f, 1.08789158e-04f, -1.02608494e-01f, 7.77479410e-02f, 1.80936120e-02f, -8.20503607e-02f, 1.30381566e-02f, 6.09499589e-02f, 1.57814678e-02f,
  -9.39366501e-03f, 4.43503968e-02f, -7.70356432e-02f, -2.24752584e-03f, -2.29872707e-02f, 3.63344513e-02f, 5.62351458e-02f, 3.56683545e-02f, -9.28254146e-03f, 1.20157227e-02f,
  -1.40224248e-02f, -8.36827792e-03f, -6.35828376e-02f, 5.41512743e-02f, 5.98434471e-02f, 5.61061464e-02f, 6.72007948e-02f, 5.09854369e-02f, 2.25470169e-03f, 5.36189713e-02f,
  1.00569524e-01f, 1.06820818e-02f, 4.66770940e-02f, 2.27533211e-03f, 7.50315115e-02f, 1.09519005e-01f, -1.49618154e-02f, 1.19566917e-02f, -1.25642307e-02f, 6.43351078e-02f,
  -1.68031286e-02f, -9.20434818e-02f, 2.14891881e-02f, 2.76389774e-02f, 2.14332622e-02f, 8.86050016e-02f, -1.44604482e-02f, 7.53583312e-02f, 6.79330230e-02f, 6.95908815e-02f,
  -3.32276672e-02f, -5.56528270e-02f, -5.42625003e-02f, 4.85384203e-02f, -8.04212168e-02f, 8.89655873e-02f, -5.42301349e-02f, -5.24271056e-02f, 2.10256614e-02f, 7.38561675e-02f,
  -1.03235506e-01f, 4.93274517e-02f, -6.33862764e-02f, -1.20725915e-01f, -1.06427230e-01f, -1.09772217e-02f, -1.51341900e-01f, 2.48150027e-04f, 7.06194565e-02f, 6.96739256e-02f,
  1.53366625e-02f, -1.25978813e-01f, 3.02809384e-02f, -2.31182948e-01f, -3.67813706e-02f, -4.00555730e-02f, -1.30865648e-01f, -5.00755571e-02f, -8.09629783e-02f, -6.32004961e-02f,
  -8.45456496e-02f, -1.20729566e-01f, -1.79139942e-01f, 6.56193420e-02f, -1.17324278e-01f, 5.96745349e-02f, -3.24171931e-02f, -1.03608005e-01f, -9.13891047e-02f, -1.34771317e-01f,
  -4.02236879e-02f, -6.33316264e-02f, 8.02660435e-02f, 3.58778227e-04f, -1.15839494e-02f, -6.58100098e-02f, -5.47382459e-02f, 4.08101790e-02f, -7.02559352e-02f, -2.43641958e-02f,
  -4.96717393e-02f, -4.46212739e-02f, -6.78670779e-02f, -1.64467264e-02f, 4.08531986e-02f, -1.65200345e-02f, 4.00613062e-02f, 5.11953011e-02f, 3.83072756e-02f, -3.09345927e-02f,
  -1.10447504e-01f, -5.57081103e-02f, -7.30035156e-02f, 4.03820872e-02f, 8.27378556e-02f, 6.47486448e-02f, 1.30987363e-02f, -5.34576401e-02f, -3.94727550e-02f, 3.77179869e-02f,
  -4.63241152e-02f, -3.04793771e-02f, 4.95563075e-03f, -1.33146234e-02f, 2.70649623e-02f, 3.51723768e-02f, -6.69906661e-02f, 5.07670715e-02f, -2.36204937e-02f, -5.37198372e-02f,
  3.75814587e-02f, -6.94591552e-02f, 5.37716560e-02f, 7.68500417e-02f, -1.11911660e-02f, 5.60505092e-02f, -5.42432778e-02f, 3.72499712e-02f, -1.49726011e-02f, -1.31257623e-02f,
  -8.66462067e-02f, 4.04260084e-02f, 8.35532416e-03f, -6.13063797e-02f, 4.96905074e-02f, 4.41431813e-02f, -7.17041194e-02f, -5.01916595e-02f, -7.51961395e-02f, 4.00624722e-02f,
  -1.30658913e-02f, 1.49939328e-01f, 1.01264782e-01f, 6.95805773e-02f, -6.01912150e-03f, 3.85153554e-02f, 2.41526333e-03f, 4.46480103e-02f, -3.02844793e-02f, 9.11122933e-03f,
  4.75942083e-02f, 6.79508895e-02f, 1.00994192e-01f, -4.02601883e-02f, 5.85284121e-02f, -5.70706688e-02f, 7.48655647e-02f, 1.02568425e-01f, 5.16659841e-02f, 1.03031704e-02f,
  -5.95476991e-03f, 1.17403045e-01f, 9.59322304e-02f, 6.87711388e-02f, 3.04606259e-02f, 7.67151117e-02f, 7.95382932e-02f, -1.94093138e-02f, -1.16337053e-02f, 9.07342136e-02f,
  1.64812133e-01f, -1.19821206e-02f, -5.59374802e-02f, -4.74404693e-02f, 1.62746593e-01f, 1.16681598e-01f, 6.81090131e-02f, 6.40872195e-02f, 7.42519696e-05f, -1.18169270e-01f,
  4.97790128e-02f, -1.06893212e-01f, 2.84675788e-02f, 6.28070012e-02f, 1.38838097e-01f, -1.19882841e-02f, 6.87649250e-02f, -1.94107983e-02f, 1.11404918e-01f, 1.19034007e-01f,
  1.87686775e-02f, 4.34419997e-02f, -2.91506331e-02f, -8.21002126e-02f, 1.74460504e-02f, -1.60731047e-01f, -1.38213351e-01f, 1.82881467e-02f, 1.42770205e-02f, -2.61521209e-02f,
  -1.53738065e-02f, 8.69963095e-02f, -5.87340631e-02f, 3.28793265e-02f, 2.57517304e-02f, -5.07644489e-02f, -6.25113919e-02f, -6.42903447e-02f, 4.21861224e-02f, 5.92084974e-02f,
  -3.45092677e-02f, 3.48979272e-02f, -8.08928814e-03f, 6.62890524e-02f, 4.11893688e-02f, 7.27213081e-03f, -8.74427110e-02f, -8.76220614e-02f, -1.47969527e-02f, -4.36419185e-04f,
  6.02310300e-02f, -8.22453201e-02f, -7.81981274e-02f, -1.31658271e-01f, 6.18604086e-02f, 6.11776859e-02f, -5.99446110e-02f, -6.14281967e-02f, -2.07458530e-02f, -3.10706869e-02f,
  3.49395834e-02f, -1.56722926e-02f, 6.90884888e-02f, 6.91133142e-02f, 6.65124655e-02f, -4.51695584e-02f, 3.57709788e-02f, 7.04557672e-02f, -1.01240940e-01f, 2.23651528e-02f,
  7.40061107e-04f, 7.92733580e-02f, -2.06703357e-02f, 7.75665119e-02f, 8.08324739e-02f, -3.19135711e-02f, -8.19633454e-02f, 7.63241500e-02f, -6.32081777e-02f, 1.38717219e-02f,
  -3.60211059e-02f, 8.36312547e-02f, 3.32138464e-02f, -1.11095332e-01f, -2.33454090e-02f, -8.26722682e-02f, -3.26099135e-02f, -1.15278959e-02f, -8.63119289e-02f, 4.00546640e-02f,
  8.26267600e-02f, -7.31164217e-03f, 2.88140494e-02f, -1.09192036e-01f, 3.43079232e-02f, 1.15184769e-01f, 9.19448808e-02f, 7.48388916e-02f, -3.39246020e-02f, 7.10903713e-03f,
  3.05159334e-02f, 4.17328514e-02f, -9.20681376e-03f, 7.65628219e-02f, -8.41723979e-02f, -1.35354409e-02f, -2.56145485e-02f, 5.01198284e-02f, -7.60995522e-02f, 1.77912472e-03f,
  -4.71614301e-02f, 1.29020205e-02f, 4.54766899e-02f, 6.68436512e-02f, 3.82081755e-02f, -6.92404360e-02f, -4.98605631e-02f, 1.42252631e-02f, 5.11202253e-02f, -7.04303682e-02f,
  2.70312540e-02f, 7.95041323e-02f, -1.92204453e-02f, -1.41039351e-03f, -7.54483789e-03f, 3.52268331e-02f, -5.46760187e-02f, -9.05269906e-02f, -1.65155791e-02f, 4.86335717e-03f,
  7.76263326e-03f, 5.01387268e-02f, 9.29312706e-02f, -1.81663334e-01f, 5.03063463e-02f, 6.30051345e-02f, -8.40706453e-02f, 5.65393008e-02f, 2.96230298e-02f, -4.53069508e-02f,
  -1.31983057e-01f, -5.74628972e-02f, -1.06379069e-01f, -8.53225738e-02f, -1.59395322e-01f, -9.42540318e-02f, 1.61116440e-02f, 1.18643403e-01f, -1.83331519e-01f, 4.30460880e-03f,
  -6.45660833e-02f, -5.66634117e-03f, 8.51819571e-03f, -9.83403344e-03f, -6.86325580e-02f, 3.42307873e-02f, -9.11610574e-02f, -5.20888418e-02f, -3.34981419e-02f, -4.30267751e-02f,
  3.73499282e-02f, 6.24256693e-02f, 1.19360331e-02f, 9.66013446e-02f, -2.51129102e-02f, -5.05536683e-02f, -2.70893238e-02f, 2.28296183e-02f, -2.45689191e-02f, 6.15537800e-02f,
  -7.14636147e-02f, -1.01725375e-02f, 2.92179771e-02f, -4.37630191e-02f, -8.35932717e-02f, -6.96033686e-02f, -7.47728199e-02f, 4.57146158e-03f, 1.18038608e-02f, -5.40302917e-02f,
  8.61789584e-02f, -9.73794726e-04f, -3.66435270e-03f, -6.99123070e-02f, -5.45088537e-02f, -6.21112101e-02f, 7.87971392e-02f, 3.73750627e-02f, 5.74263930e-02f, -3.36855953e-03f,
  -3.65468599e-02f, -5.15127629e-02f, 6.93791285e-02f, -4.74554636e-02f, 6.67232946e-02f, -4.62951362e-02f, 7.99666718e-02f, 2.18030866e-02f, 1.90164745e-02f, 7.34945685e-02f,
  2.22712122e-02f, -3.43227051e-02f, 8.47745016e-02f, 7.27223679e-02f, 8.78821015e-02f, -3.57419066e-02f, -1.01594999e-02f, 4.52360623e-02f, -5.65036992e-03f, 4.27157581e-02f,
  -6.66594803e-02f, -9.39897001e-02f, 3.38675827e-02f, 3.20224017e-02f, 5.83081953e-02f, -5.50196646e-03f, -3.41656022e-02f, 2.49999529e-03f, 4.96059358e-02f, -8.03682059e-02f,
  -2.66419287e-04f, -2.90681683e-02f, -2.43090279e-03f, 1.05480313e-01f, -8.26231018e-02f, -8.02225173e-02f, -4.40809391e-02f, 2.07827892e-03f, 6.14041500e-02f, -1.27050374e-02f,
  2.31553949e-02f, 2.56589847e-03f, -4.88796718e-02f, 3.84382382e-02f, 5.69056235e-02f, -4.76802476e-02f, -1.45828128e-02f, 6.36983812e-02f, -4.43219878e-02f, -5.81628643e-02f,
  8.50578099e-02f, -1.60403606e-02f, 3.77573706e-02f, 1.72035635e-01f, -4.99923304e-02f, -6.04327396e-02f, 5.97746000e-02f, 3.40271108e-02f, 1.48979902e-01f, -1.14062369e-01f,
  -8.69746283e-02f, 1.09481074e-01f, -1.37658790e-01f, 7.92012736e-02f, 7.91933686e-02f, 2.18294710e-02f, 9.25698206e-02f, 4.55259569e-02f, 6.49670288e-02f, -7.19661787e-02f,
  6.47184253e-02f, -1.08471112e-02f, -5.80093749e-02f, -7.32247829e-02f, 3.04278713e-02f, -4.32172343e-02f, -6.78591952e-02f, -8.65034088e-02f, 9.38053150e-03f, -1.22303344e-01f,
  1.05285697e-01f, 6.59865513e-03f, -4.83163036e-02f, -3.91301326e-02f, 4.15084027e-02f, 2.26380415e-02f, 3.02108768e-02f, -3.44557501e-02f, 8.75407979e-02f, 6.29519671e-02f,
  -8.41971338e-02f, 1.62158422e-02f, 2.45841201e-02f, 5.40679432e-02f, 8.41215104e-02f, 8.06029066e-02f, 6.49543330e-02f, 3.30535471e-02f, 4.67076823e-02f, -8.05035641e-04f,
  7.96095803e-02f, -4.66670655e-02f, 4.34588008e-02f, 1.88216649e-03f, -6.29776940e-02f, 7.59494677e-02f, -5.82620800e-02f, -6.65428042e-02f, 1.27677750e-02f, -8.57368112e-02f,
  -5.07350527e-02f, -2.52435561e-02f, 5.32616042e-02f, -4.93716933e-02f, -4.99705747e-02f, 8.74397159e-02f, -2.31906474e-02f, -4.25056554e-02f, 1.84909683e-02f, -4.98668402e-02f,
  5.96833825e-02f, 5.62758148e-02f, 1.40950950e-02f, 2.24817786e-02f, 5.70993798e-05f, -2.90778354e-02f, 3.86377312e-02f, -7.54480883e-02f, 4.13575321e-02f, -4.16195355e-02f,
  -8.81258771e-03f, -6.16039671e-02f, -3.58973816e-02f, 6.51415288e-02f, -1.05009235e-01f, 7.90313911e-03f, 2.39053518e-02f, -6.98715299e-02f, -3.63986902e-02f, 6.96311221e-02f,
  -3.24500427e-02f, -2.54239235e-03f, -1.37544414e-02f, 8.55465829e-02f, 4.04755287e-02f, -3.83847877e-02f, 4.60895635e-02f, -3.90988253e-02f, -5.25422432e-02f, 7.93228075e-02f,
  -2.70624328e-02f, -3.91822606e-02f, 4.06696275e-02f, 8.74455571e-02f, 3.95985097e-02f, -3.05901095e-02f, 1.76347978e-02f, -7.75282234e-02f, 7.19595701e-02f, -8.19341838e-02f,
  3.16746421e-02f, 9.04472917e-02f, 8.31008926e-02f, -1.26836449e-02f, -6.23755855e-03f, 8.56330469e-02f, -3.79626304e-02f, -9.94387567e-02f, 1.51286938e-03f, -7.36171305e-02f,
  -1.40868139e-03f, -1.39193997e-01f, -2.02253480e-02f, -8.57138354e-03f, -1.27496244e-02f, -3.17421928e-02f, 7.89838433e-02f, -9.70534682e-02f, -8.86221975e-02f, -1.78601425e-02f,
  8.52423608e-02f, 9.84404609e-02f, -1.88231911e-03f, 1.59878120e-01f, 1.92042857e-01f, -1.39681315e-02f, 1.31184846e-01f, 4.08604555e-03f, 4.83871549e-02f, -1.16222665e-01f,
  -2.94014085e-02f, 6.98899403e-02f, -7.81798065e-02f, 3.47574875e-02f, -8.40690583e-02f, -2.26809606e-02f, 9.93036479e-02f, 1.11543238e-02f, 1.49844632e-01f, 6.90764263e-02f,
  -5.14690913e-02f, -1.30421668e-01f, 5.70353307e-02f, 2.61668283e-02f, -7.04471990e-02f, -8.16327333e-02f, -7.83619750e-03f, -4.12186142e-03f, 4.58898656e-02f, 4.96993251e-02f,
  5.65021783e-02f, -6.57079071e-02f, 3.29146981e-02f, 6.38567805e-02f, 3.19013707e-02f, -4.77972217e-02f, -7.52546713e-02f, 3.57486494e-02f, -2.73468699e-02f, -5.66249266e-02f,
  -4.33701612e-02f, -3.37762479e-03f, -6.79987520e-02f, -9.78006748e-04f, 4.24291156e-02f, -3.68043315e-03f, 6.21110946e-02f, 3.12568591e-04f, 1.58837880e-03f, 8.00119415e-02f,
  1.34715596e-02f, -9.57959965e-02f, -8.61577541e-02f, 6.63500205e-02f, 1.62843317e-02f, -3.54774185e-02f, -1.39992340e-02f, -4.42932919e-02f, -8.93412381e-02f, -4.43924591e-02f,
  5.41407093e-02f, 6.86930493e-02f, -2.14723311e-02f, -5.01975864e-02f, -5.37150651e-02f, -3.74289155e-02f, 6.18009679e-02f, 5.40258083e-03f, -2.86734756e-02f, -6.69466406e-02f,
  -6.45161942e-02f, -1.97503250e-02f, 5.31947939e-03f, -1.21553307e-02f, -2.17064079e-02f, -7.27637559e-02f, 6.02008291e-02f, 7.50477538e-02f, -6.08803853e-02f, -1.94406603e-02f,
  -3.17266807e-02f, -1.18246228e-01f, 3.24234031e-02f, -3.02708498e-03f, 1.46116102e-02f, -5.30130416e-02f, 4.46696132e-02f, 3.93581353e-02f, 1.13844788e-02f, -1.04332296e-02f,
  1.09181004e-02f, -6.95220940e-03f, 3.18552777e-02f, -1.36018889e-02f, 6.86434656e-02f, -1.03012897e-01f, 7.09333271e-02f, -1.18120844e-02f, -1.07740257e-02f, -3.17922831e-02f,
  -8.31607431e-02f, -6.41245097e-02f, 1.87979713e-02f, -5.36536947e-02f, -6.75027221e-02f, -5.85779734e-02f, -7.75865987e-02f, -5.98801896e-02f, -3.30685116e-02f, 2.82379147e-02f,
  -1.85001507e-01f, 2.71282315e-01f, 2.33054727e-01f, -5.32074571e-02f, -8.86107795e-03f, 1.65716127e-01f, 7.84317683e-03f, 1.85647935e-01f, 1.31366313e-01f, 1.32443294e-01f,
  -5.29540256e-02f, 1.49588749e-01f, -1.03835717e-01f, 1.18109703e-01f, 5.84311783e-02f, 1.14464916e-01f, 1.34224385e-01f, 1.03295846e-02f, -4.47137374e-03f, 6.34412766e-02f,
  -4.75921929e-02f, -2.03571469e-01f, 3.80418301e-02f, -7.96027854e-02f, -9.94259715e-02f, -3.68535109e-02f, -1.79682553e-01f, -1.57237098e-01f, -5.49064688e-02f, -2.86546862e-03f,
  -8.94417018e-02f, -1.07295580e-01f, 1.74451116e-02f, 3.18869054e-02f, 8.70931670e-02f, 4.52583842e-02f, -1.23743722e-02f, 1.85655802e-02f, -5.08216992e-02f, -6.12123869e-02f,
  -6.16170056e-02f, 4.04437110e-02f, 6.12202138e-02f, -8.31799284e-02f, -2.14907508e-02f, 9.54729244e-02f, 6.05089366e-02f, -5.65101840e-02f, -2.83641219e-02f, 2.68582571e-02f,
  -1.77290402e-02f, 1.40981019e-01f, 9.89010781e-02f, 1.23827346e-01f, -4.84240092e-02f, 6.90066293e-02f, -1.79672334e-02f, 6.30716830e-02f, 7.15207160e-02f, 1.28593192e-01f,
  7.05160797e-02f, -4.56318595e-02f, 3.81516479e-02f, -6.52656183e-02f, -1.88917909e-02f, 7.36313984e-02f, -8.17643702e-02f, -8.39478076e-02f, 1.19582890e-02f, -7.45088831e-02f,
  -3.59856561e-02f, -4.15114500e-02f, -3.01835779e-02f, 9.64436010e-02f, -1.21305266e-03f, 6.89061135e-02f, 2.84417323e-03f, -2.27389857e-02f, -1.79540813e-02f, 6.24723993e-02f,
  -4.63170670e-02f, 6.91592842e-02f, 5.34518510e-02f, -6.00681230e-02f, 9.09438431e-02f, 5.43811545e-03f, -3.67124565e-02f, -1.36410643e-03f, -1.22466618e-02f, -7.32602477e-02f,
  5.34167923e-02f, 3.64135690e-02f, 1.75616276e-02f, -7.90421516e-02f, -5.37173711e-02f, -4.46385071e-02f, -2.31054295e-02f, 7.69095570e-02f, 7.91671649e-02f, 5.95274046e-02f,
  -1.22076934e-02f, -7.51025230e-02f, 9.33386460e-02f, -2.95859622e-03f, 9.99699757e-02f, 3.61529626e-02f, -9.52137485e-02f, -6.32613152e-02f, 6.38042018e-02f, -6.31144419e-02f,
  -8.14791992e-02f, 4.32109460e-03f, 2.10971124e-02f, 4.18379270e-02f, -3.90986241e-02f, -1.10805500e-02f, -1.89046301e-02f, -7.11225793e-02f, 4.42036726e-02f, 7.60881305e-02f,
  -1.38595298e-01f, 1.87828064e-01f, 1.41851500e-01f, -1.78720076e-02f, -1.87785402e-01f, 6.22981824e-02f, 2.34463602e-01f, -5.73230200e-02f, 2.17567906e-02f, 1.73658639e-01f,
  -8.93552452e-02f, 7.65159875e-02f, 6.97736964e-02f, 1.52185932e-01f, 3.35808247e-02f, 2.10770890e-01f, 3.94086465e-02f, 6.20826185e-02f, 1.00562803e-01f, -8.96762982e-02f,
  -9.42537710e-02f, 1.82064692e-03f, -3.64308879e-02f, -1.51060864e-01f, -3.17676924e-02f, -4.18937989e-02f, -1.97232127e-01f, -5.78825474e-02f, -2.41267867e-02f, 7.95364305e-02f,
  7.54033998e-02f, -7.21935853e-02f, 3.97307575e-02f, -8.49384721e-03f, 3.94128412e-02f, -7.20789209e-02f, 1.36682801e-02f, 5.06537734e-03f, -4.03199419e-02f, 4.70645120e-03f,
  3.80550362e-02f, -6.35265335e-02f, 1.20238112e-02f, -7.02709332e-02f, -3.02402377e-02f, -2.39680223e-02f, -1.44652324e-03f, 4.35939655e-02f, -7.12957978e-03f, -6.62157387e-02f,
  2.13728845e-02f, 7.14994594e-03f, 4.11498137e-02f, 8.15329030e-02f, 5.22550866e-02f, -1.10959709e-02f, -4.27486338e-02f, -6.51287660e-02f, 8.31443667e-02f, 5.32569624e-02f,
  -8.03603679e-02f, -7.28074536e-02f, 9.45475623e-02f, 6.76277727e-02f, 6.08398877e-02f, -3.92779224e-02f, 3.42952982e-02f, 1.36540551e-02f, 6.72043115e-02f, -6.85492977e-02f,
  -3.68840471e-02f, 1.90810021e-02f, 6.18445538e-02f, 5.96225746e-02f, 3.32167633e-02f, 4.57421690e-02f, 4.40299138e-03f, 7.53502995e-02f, -4.84414436e-02f, 6.57306537e-02f,
  -1.24813644e-02f, 1.13518415e-02f, -2.08451897e-02f, 9.88624431e-03f, 3.46960388e-02f, -7.24732280e-02f, -5.02067544e-02f, -5.46043590e-02f, -1.97869241e-02f, 2.90591437e-02f,
  3.54836024e-02f, -6.84726387e-02f, 5.02679460e-02f, 4.92327586e-02f, 5.21437079e-03f, -1.12501055e-01f, -1.54825589e-02f, -5.22352383e-02f, 1.12225804e-02f, 2.19113845e-02f,
  2.12414619e-02f, 9.92839038e-02f, -7.88017064e-02f, 2.60494947e-02f, -3.61316726e-02f, 1.69292488e-03f, -3.14680897e-02f, 6.29350469e-02f, -6.47298917e-02f, 3.03711612e-02f,
  6.57885745e-02f, 3.63960527e-02f, -3.99968848e-02f, 3.39202657e-02f, -6.19590506e-02f, -1.14311688e-02f, 3.40142660e-02f, -9.87543538e-03f, 2.60372609e-02f, 9.18932855e-02f,
  -1.30306154e-01f, 7.29085505e-03f, -2.08771482e-01f, 4.97898599e-03f, -2.01535568e-01f, -1.71744868e-01f, -1.31886810e-01f, -1.34075925e-01f, -6.94923997e-02f, 2.23796785e-01f,
  6.44046068e-02f, -3.86769325e-02f, 4.51742448e-02f, 1.57107875e-01f, -3.89384367e-02f, 2.40647480e-01f, 1.92318663e-01f, 1.95026636e-01f, 9.20128822e-03f, -5.29361367e-02f,
  5.04916459e-02f, 4.36896794e-02f, 1.21045537e-01f, -1.18851237e-01f, -2.62115393e-02f, -1.29114226e-01f, 1.70476940e-02f, -1.78303704e-01f, 8.15756270e-04f, -1.15309499e-01f,
  -5.69486953e-02f, -6.16236329e-02f, -8.89230371e-02f, 4.25777249e-02f, 1.45526202e-02f, 6.86830804e-02f, 9.97301936e-03f, -2.02828515e-02f, 3.07699870e-02f, -1.11410126e-01f,
  -3.12769897e-02f, -5.80638014e-02f, 5.01324087e-02f, -4.72093523e-02f, -1.71234198e-02f, -7.13590011e-02f, 6.21125065e-02f, -4.47201766e-02f, -2.53239162e-02f, -6.48486093e-02f,
  5.44137917e-02f, 3.23735662e-02f, 3.87712270e-02f, 3.70674878e-02f, -2.78786793e-02f, 4.76163393e-03f, -2.56405417e-02f, -6.71186158e-03f, -9.68625676e-03f, 9.31057893e-03f,
  6.33136407e-02f, 3.99887525e-02f, 9.28540751e-02f, 7.44415075e-02f, -7.06617609e-02f, 7.36678839e-02f, 7.56441802e-03f, 6.94581047e-02f, 4.17933948e-02f, 4.80203554e-02f,
  2.40669716e-02f, 6.49802089e-02f, -5.94611615e-02f, 3.83203328e-02f, -5.81589062e-03f, -2.49262974e-02f, 1.63561106e-02f, -6.95329458e-02f, 7.25563467e-02f, -5.35079166e-02f,
  5.71665727e-02f, -7.68308416e-02f, -1.91188846e-02f, 2.12794803e-02f, -5.70641533e-02f, -9.27878951e-04f, 1.87794603e-02f, -7.44203702e-02f, -5.18357418e-02f, -5.47402389e-02f,
  -6.86936155e-02f, -4.46432829e-02f, 7.20510110e-02f, -1.67132206e-02f, -1.45814195e-02f, 9.65078361e-03f, -2.47391406e-02f, 4.70713377e-02f, -1.09171882e-01f, -4.58861589e-02f,
  -8.17143321e-02f, -1.54185379e-02f, 2.62457561e-02f, 8.80567804e-02f, -6.16946667e-02f, -3.99008021e-02f, -3.93822901e-02f, -3.08019780e-02f, -2.74642985e-02f, -3.86373629e-03f,
  -8.77853408e-02f, -7.92325288e-03f, 5.18450439e-02f, 4.05728370e-02f, 5.81267662e-02f, -7.22619742e-02f, 4.35057506e-02f, 5.25484793e-02f, 1.42808259e-02f, -4.37655263e-02f,
  -3.92204411e-02f, 1.79887097e-02f, -1.50443558e-02f, -8.66531208e-02f, -1.11813210e-01f, 1.82574078e-01f, 1.20045155e-01f, -2.82282997e-02f, -7.17325509e-02f, 1.73262462e-01f,
  9.64912698e-02f, 6.90063760e-02f, 5.03067188e-02f, 2.59258188e-02f, -7.38342479e-02f, -2.38950234e-02f, 1.18736565e-01f, 1.30330384e-01f, -9.32891294e-02f, 7.84847587e-02f,
  9.48185287e-03f, 5.45408539e-02f, -9.34926942e-02f, 5.31179830e-02f, 8.39762241e-02f, 2.97258273e-02f, -3.00943181e-02f, -1.90565474e-02f, 1.20126963e-01f, -3.66834030e-02f,
  8.64605084e-02f, -3.63761932e-02f, -9.00998637e-02f, 2.70568710e-02f, 9.86810252e-02f, 1.60239667e-01f, 1.14911020e-01f, 3.62077281e-02f, -5.63005395e-02f, -5.94060831e-02f,
  1.08498141e-01f, -2.79432572e-02f, -6.48190826e-02f, -8.46904367e-02f, 5.45906909e-02f, -2.53569726e-02f, 1.09533491e-02f, -5.96984625e-02f, 7.65475109e-02f, -1.07858134e-02f,
  4.90963608e-02f, -1.47831654e-02f, 7.62482779e-03f, 5.45824356e-02f, -6.88459203e-02f, 6.02529347e-02f, -1.53951244e-02f, 9.93048400e-02f, -3.64504531e-02f, 6.23399988e-02f,
  6.18646815e-02f, 4.18648235e-02f, 6.81471229e-02f, -2.48249602e-02f, 6.21453039e-02f, -9.27359611e-02f, -3.13398875e-02f, 8.36067647e-02f, -5.95095716e-02f, 3.88222896e-02f,
  -9.79920104e-02f, -3.16822156e-02f, 3.85516472e-02f, -4.77216542e-02f, -1.75761674e-02f, -7.49166086e-02f, 1.11958776e-02f, 6.56414255e-02f, 1.00369006e-02f, 6.97278008e-02f,
  -1.34857912e-02f, 3.12857181e-02f, 9.46645215e-02f, 2.55720820e-02f, -1.31625691e-02f, -6.38150871e-02f, -2.52517201e-02f, -2.86291875e-02f, -5.33269942e-02f, -1.49681969e-02f,
  1.29128814e-01f, 8.38113651e-02f, 1.17009715e-03f, 1.89305115e-02f, 6.66493550e-02f, 1.25802040e-01f, 9.25944522e-02f, 5.79415299e-02f, 5.56953326e-02f, -5.82919233e-02f,
  1.51176959e-01f, 5.78982271e-02f, 8.05202127e-02f, -4.91658971e-02f, -3.10535692e-02f, 1.09541327e-01f, -6.86114980e-03f, 2.64511760e-02f, 1.10119032e-02f, 3.76086123e-02f,
  -1.03090266e-02f, -2.30845623e-02f, -6.42888322e-02f, -4.41955179e-02f, -3.81217189e-02f, -2.50164736e-02f, 7.09024891e-02f, -3.49522382e-02f, -5.43923043e-02f, -1.08419545e-02f,
  -6.46154806e-02f, -1.76746532e-01f, -1.27219886e-01f, -1.01515844e-01f, 8.37032199e-02f, 1.32929534e-01f, -7.78849572e-02f, -2.24712887e-03f, -1.28093824e-01f, 5.27022742e-02f,
  -2.91731507e-02f, -2.17513330e-02f, -1.14588805e-01f, -1.21102467e-01f, -1.36962399e-01f, -1.87661767e-01f, 2.32178699e-02f, -1.95015669e-02f, -1.41583651e-01f, -5.49517199e-02f,
  -1.10297412e-01f, 2.28743125e-02f, -5.82787115e-03f, 1.27946034e-01f, 1.38285592e-01f, 2.98352242e-02f, 2.00955331e-01f, 6.97206259e-02f, 1.82011262e-01f, -3.44243944e-02f,
  -2.74721757e-02f, -1.47312790e-01f, 1.28479814e-02f, 6.37446493e-02f, 1.09725140e-01f, 9.07250121e-02f, 8.35834295e-02f, 5.41659258e-02f, -2.42714537e-03f, -2.90739238e-02f,
  -3.42404917e-02f, 1.67788491e-02f, 1.20547563e-02f, 2.65203621e-02f, 6.32454082e-02f, -7.24463388e-02f, -4.12581638e-02f, -4.61469218e-02f, -5.96704818e-02f, -8.33250880e-02f,
  -5.47521152e-02f, -6.33286163e-02f, 2.04718634e-02f, 8.37741513e-03f, 5.06496094e-02f, -3.09082326e-02f, -5.02053015e-02f, 9.98718664e-02f, 3.40748057e-02f, -2.52258331e-02f,
  -3.45776491e-02f, 4.32309993e-02f, 4.74772714e-02f, 8.27201363e-03f, -7.82146826e-02f, 5.07730944e-03f, 1.88451596e-02f, 7.38261640e-02f, 6.96381107e-02f, 3.34062316e-02f,
  3.83498035e-02f, -8.67673233e-02f, -3.99726108e-02f, 4.81269993e-02f, 4.99270149e-02f, 1.49965612e-03f, -1.35150766e-02f, -2.52493545e-02f, -5.10318615e-02f, 4.29471359e-02f,
  -7.63616562e-02f, 6.08928036e-04f, 4.49604765e-02f, -6.08186563e-03f, -6.77681491e-02f, 5.18339947e-02f, 7.63691142e-02f, -7.36606717e-02f, 7.22187757e-02f, 5.26188910e-02f,
  1.09288275e-01f, -7.51657411e-02f, -5.26479706e-02f, 3.49390949e-03f, 6.77187219e-02f, 5.77586964e-02f, 2.89314725e-02f, 1.47340493e-02f, -3.91305909e-02f, -7.53780752e-02f,
  3.88369933e-02f, 6.64205998e-02f, 5.02402000e-02f, -8.00926238e-02f, -5.67658395e-02f, -4.18098196e-02f, -3.08664739e-02f, 8.53091553e-02f, 3.48243043e-02f, 6.61802292e-02f,
  -4.68911901e-02f, -2.08421089e-02f, 7.22958073e-02f, -4.77042310e-02f, -2.80535631e-02f, 9.54559073e-02f, 3.32874693e-02f, -2.68295333e-02f, 1.04105964e-01f, -3.12746875e-02f,
  1.86141416e-01f, -7.76814222e-02f, -2.20483512e-01f, -1.76120684e-01f, -6.53857440e-02f, -2.86486894e-01f, -3.65483165e-01f, -7.40965158e-02f, 1.45782501e-01f, -8.32502618e-02f,
  -2.07735717e-01f, 3.36733721e-02f, 6.89309910e-02f, -2.21598685e-01f, 8.19030106e-02f, 2.24434838e-01f, -2.48199910e-01f, -1.13285653e-01f, 1.00460514e-01f, -1.22148931e-01f,
  -2.81561986e-02f, -2.59606928e-01f, -1.37035489e-01f, -1.93863332e-01f, -3.68305564e-01f, -2.49750596e-02f, -6.58456907e-02f, -2.32711911e-01f, -2.62018651e-01f, -1.04929037e-01f,
  -6.31876364e-02f, 1.20084390e-01f, -1.35643184e-02f, -8.06220621e-03f, -9.76528302e-02f, -1.26879126e-01f, 2.29482632e-02f, 6.99721649e-02f, 4.00580540e-02f, 5.67057319e-02f,
  -3.10486667e-02f, 6.75566345e-02f, 2.52096560e-02f, 4.82689887e-02f, -4.10773084e-02f, 4.84746955e-02f, 2.25039870e-02f, -6.15253411e-02f, -6.33499175e-02f, -4.38576899e-02f,
  -8.11311826e-02f, 3.63830067e-02f, -3.48543227e-02f, -1.86121911e-02f, 5.39777912e-02f, -2.04886124e-02f, -3.47129218e-02f, 6.97387084e-02f, 8.62697046e-03f, -3.47231664e-02f,
  -1.17624640e-01f, 3.39453444e-02f, -9.16754603e-02f, 1.71958152e-02f, -4.41113710e-02f, -8.16652551e-02f, -3.58866947e-03f, -2.70827580e-02f, -5.15836931e-04f, -2.66541094e-02f,
  -6.61126822e-02f, -8.50856900e-02f, 5.13760000e-02f, 4.89400662e-02f, 2.12305691e-02f, -5.16765565e-02f, 4.61842492e-02f, 4.78741936e-02f, 1.29101360e-02f, 9.73414481e-02f,
  3.77163254e-02f, -5.69492914e-02f, -2.38800887e-02f, 3.50629427e-02f, 1.38911307e-02f, -4.75686193e-02f, -6.88594654e-02f, -5.62627316e-02f, 1.29434988e-02f, -7.24196211e-02f,
  -2.18337290e-02f, -1.00851864e-01f, -3.52333002e-02f, -4.18622373e-03f, -8.61420706e-02f, -5.50485924e-02f, 5.47526740e-02f, -5.48221022e-02f, -1.93546098e-02f, 3.04275751e-02f,
  -6.41063452e-02f, -4.90648784e-02f, -7.21690282e-02f, -7.26775127e-03f, 3.28066535e-02f, -7.84169137e-02f, -8.30113068e-02f, -3.42238657e-02f, -4.71588336e-02f, 9.03838873e-02f,
  -6.24911860e-02f, -2.90733241e-02f, -8.07907060e-03f, -1.91965839e-03f, -5.60538135e-02f, -4.42634411e-02f, 2.52186228e-02f, 3.21121537e-04f, -8.52976739e-02f, 5.01448922e-02f,
  -5.74949272e-02f, -8.26693326e-02f, 2.47794166e-02f, -1.81168839e-02f, 1.43964097e-01f, 1.05306327e-01f, 1.07284039e-01f, 6.02037944e-02f, 1.46209478e-01f, -6.94378316e-02f,
  -9.59021524e-02f, -7.72661669e-03f, 7.05843866e-02f, -1.04599677e-01f, 4.44326699e-02f, -7.25849643e-02f, 1.57767273e-02f, 1.66066568e-02f, 6.31309673e-02f, 2.30235793e-02f,
  1.28149837e-02f, 2.17729211e-02f, 3.53772566e-02f, -5.53960949e-02f, 4.94591072e-02f, 1.21886194e-01f, -5.24433516e-02f, 9.54357814e-03f, -5.20625338e-03f, -5.50339408e-02f,
  -2.66172132e-03f, -6.00167830e-03f, -7.93182328e-02f, -6.37813136e-02f, 9.60060582e-02f, 8.32164213e-02f, 9.38168019e-02f, -2.31024548e-02f, 4.50995415e-02f, -5.51465265e-02f,
  -4.93668951e-02f, -1.31344469e-02f, 7.49345049e-02f, 1.51604218e-02f, -2.21076757e-02f, -3.69342864e-02f, -6.02439716e-02f, 7.40979463e-02f, -2.45775059e-02f, -1.03002004e-01f,
  -7.15711340e-02f, -3.75474058e-02f, 6.60455301e-02f, -2.35488806e-02f, -5.46338074e-02f, 4.87510823e-02f, 9.19976234e-02f, -6.87610060e-02f, -5.84060997e-02f, -4.12793607e-02f,
  -6.03940822e-02f, -4.68845703e-02f, 3.59551003e-03f, 5.89385815e-02f, -5.75713217e-02f, 1.53127192e-02f, -4.53748778e-02f, -7.62497261e-03f, -2.77063195e-02f, -8.59830230e-02f,
  8.79192054e-02f, -3.63362543e-02f, -2.51305718e-02f, 8.31661001e-02f, -4.39401269e-02f, -6.12650290e-02f, -9.79842544e-02f, -7.95234181e-03f, 3.27256434e-02f, 4.08736244e-02f,
  -7.96116367e-02f, -5.92962056e-02f, -3.24482247e-02f, 5.79052791e-02f, -8.62159878e-02f, 2.23427135e-02f, -9.46746245e-02f, 1.20028974e-02f, 8.96000415e-02f, 3.22251543e-02f,
  1.22579500e-01f, -7.19458237e-02f, 3.99752632e-02f, 5.23683615e-02f, 9.72182900e-02f, -9.42647234e-02f, -7.82214478e-02f, -1.51044345e-02f, -5.83871501e-03f, -5.58987632e-02f,
  1.03440456e-01f, -6.77999333e-02f, 8.78204852e-02f, -1.96023900e-02f, -5.38220443e-02f, -5.91920204e-02f, 8.27860460e-02f, 5.72639182e-02f, 1.25935227e-02f, -3.71076241e-02f,
  4.75701652e-02f, 5.67928590e-02f, -3.28375734e-02f, 8.74043442e-03f, -5.57329766e-02f, 6.52927682e-02f, 3.17287724e-03f, -3.72734331e-02f, -5.24040982e-02f, -5.85042126e-02f,
  -4.30004299e-02f, -9.96336564e-02f, -1.96707293e-01f, 2.32896488e-03f, -1.04634471e-01f, -1.01581007e-01f, -2.20775362e-02f, 2.24361755e-02f, -3.67717780e-02f, 1.43284112e-01f,
  -4.73836102e-02f, 5.48742304e-04f, 1.19871639e-01f, -8.17188621e-02f, -9.78406668e-02f, 1.00767784e-01f, -4.95772846e-02f, -7.64792189e-02f, 5.65902367e-02f, -5.58006652e-02f,
  -2.03413889e-02f, 5.99078424e-02f, -1.22471221e-01f, 6.40077740e-02f, -7.74933770e-02f, 6.58769459e-02f, 1.13634013e-01f, -6.56264648e-02f, -3.71935852e-02f, -4.82029021e-02f,
  -6.79943189e-02f, 4.22739871e-02f, -5.95185608e-02f, 6.05245009e-02f, -7.86386505e-02f, 4.91941767e-03f, -9.72615462e-03f, -7.16512874e-02f, -3.28106396e-02f, -4.91886362e-02f,
  6.18221685e-02f, 2.58510299e-02f, 4.45944779e-02f, -5.31378202e-02f, 3.91901061e-02f, 3.21005099e-02f, -5.65476082e-02f, -3.49523574e-02f, -1.12973144e-02f, -8.88833031e-02f,
  -7.96151534e-02f, 3.40244323e-02f, 5.78956725e-03f, -4.22867872e-02f, 8.39539021e-02f, 6.41021580e-02f, -4.33071591e-02f, -3.46631780e-02f, 4.90205809e-02f, -7.18201399e-02f,
  -1.20309614e-01f, 9.75394696e-02f, 4.86031286e-02f, 3.73887643e-02f, -4.41878922e-02f, 2.28695162e-02f, 1.79443881e-02f, 7.90137798e-02f, 1.73321292e-02f, -2.72581372e-02f,
  3.57507877e-02f, 1.94714405e-02f, 8.00184719e-03f, 2.09289812e-03f, 1.10056372e-02f, -4.96593080e-02f, 4.90736924e-02f, 2.10085250e-02f, -2.94816284e-03f, -6.35571480e-02f,
  -6.57118186e-02f, -7.89224729e-02f, 3.21918465e-02f, -5.88944182e-02f, -4.42428365e-02f, -6.67737052e-02f, 2.45892839e-03f, -4.44350950e-02f, -3.43867391e-02f, 4.28024195e-02f,
  2.99888365e-02f, -2.70393211e-02f, -3.89566272e-02f, 2.07867455e-02f, -4.08848263e-02f, 6.80758953e-02f, -3.22716497e-02f, -7.69888684e-02f, 1.38558410e-02f, 3.98118086e-02f,
  5.70628755e-02f, 4.11060676e-02f, 8.90604928e-02f, -4.53155488e-02f, 6.16248697e-02f, -4.70638312e-02f, 5.27783595e-02f, 4.64240350e-02f, 3.45567502e-02f, -5.16122058e-02f,
  7.79974507e-03f, 7.99902678e-02f, 9.93323922e-02f, 9.18199643e-02f, 1.12150535e-01f, 3.05627100e-02f, -4.24022675e-02f, -3.20484601e-02f, 1.72689054e-02f, 8.85309130e-02f,
  7.00355172e-02f, -1.48993358e-01f, 1.60752594e-01f, 1.02000713e-01f, 3.17223221e-02f, 3.06332894e-02f, 2.90602356e-01f, -7.70803094e-02f, -4.72313091e-02f, -1.20441481e-01f,
  -1.21450342e-01f, 1.19561777e-01f, 1.49840489e-01f, 6.04764745e-02f, 2.44246468e-01f, 9.46480110e-02f, 7.69509897e-02f, 1.44495368e-01f, 5.40271774e-02f, -1.30045250e-01f,
  -7.48173818e-02f, -8.43225271e-02f, 1.86283402e-02f, -1.88092530e-01f, -5.01668043e-02f, -1.63993463e-01f, -7.76750073e-02f, 2.74777189e-02f, -3.76357604e-03f, -3.10349092e-02f,
  2.81729959e-02f, -4.90683839e-02f, 1.75743029e-02f, 4.39235419e-02f, 5.29604852e-02f, 7.16357492e-03f, 6.46294802e-02f, 9.84067172e-02f, 2.43213251e-02f, -3.23215649e-02f,
  3.81443426e-02f, -9.92322415e-02f, -8.70177671e-02f, 1.36665357e-02f, -8.14571306e-02f, -3.00707240e-02f, 5.50300740e-02f, -4.49682549e-02f, 1.02079799e-02f, -8.57445449e-02f,
  -1.92328226e-02f, -5.19731119e-02f, -6.33460209e-02f, 4.35626060e-02f, 4.97334749e-02f, -6.34292364e-02f, 3.33489887e-02f, 9.53807607e-02f, -8.88541192e-02f, 2.77551208e-02f,
  9.20775682e-02f, 5.43644093e-02f, -2.31679082e-02f, -1.84166804e-02f, -4.82055265e-03f, -1.87623128e-02f, 1.12231346e-02f, -7.56617635e-02f, 1.43782226e-02f, 5.71861304e-02f,
  -3.31060402e-02f, 2.62198523e-02f, -1.60661507e-02f, 5.87898642e-02f, 5.87024987e-02f, -3.05127427e-02f, 7.27156699e-02f, 5.69945648e-02f, 6.34653047e-02f, 2.73857694e-02f,
  8.58569890e-02f, 1.52669922e-02f, 2.69339159e-02f, 6.37099296e-02f, 3.21255401e-02f, 4.84490581e-02f, -2.45065112e-02f, -4.65461053e-02f, -5.69474921e-02f, 2.91038658e-02f,
  -1.40438288e-01f, -5.18892296e-02f, -4.52554077e-02f, -3.62967625e-02f, 2.10239664e-02f, -8.69211778e-02f, 1.12362625e-02f, -6.55734614e-02f, -6.06569089e-02f, -6.89040348e-02f,
  5.61752133e-02f, 3.28756087e-02f, -5.14657497e-02f, 5.98458108e-03f, -2.88881622e-02f, -6.59072474e-02f, 1.12863136e-02f, 4.64551374e-02f, 3.88722494e-02f, -1.22921847e-01f,
  -1.11878722e-03f, -2.56045591e-02f, 1.53018273e-02f, -1.93744134e-02f, -1.34717021e-02f, -5.92801049e-02f, 6.27124161e-02f, -3.59270200e-02f, 3.69749591e-02f, -9.21632499e-02f,
  3.64404544e-02f, -6.05108887e-02f, -1.11488201e-01f, 9.81861725e-02f, 7.38803074e-02f, 5.02011031e-02f, 1.36255831e-01f, -1.03812620e-01f, -6.89194873e-02f, -7.80344456e-02f,
  4.24030498e-02f, 7.27261081e-02f, -9.35797766e-02f, -1.56926196e-02f, 8.00583884e-02f, -1.19480841e-01f, 7.06508160e-02f, 2.97037065e-02f, 3.55414450e-02f, -1.52769657e-02f,
  9.05965921e-04f, 1.18416689e-01f, 4.44924012e-02f, -1.05789058e-01f, -1.28518920e-02f, -2.47441838e-03f, 6.84659183e-02f, -7.35993013e-02f, 1.09665878e-01f, 1.33894840e-02f,
  6.60066530e-02f, 4.33553616e-03f, -4.45085093e-02f, 3.07415333e-02f, -1.74756814e-03f, 6.68107718e-02f, 1.05889536e-01f, 1.07930884e-01f, -1.94778305e-03f, 3.65563035e-02f,
  8.66421387e-02f, -2.54081916e-02f, -5.02634607e-02f, 8.71714130e-02f, -6.25308156e-02f, 1.00615878e-04f, -9.15360823e-02f, -2.17780434e-02f, 2.19610259e-02f, -1.10135749e-01f,
  -2.14148109e-04f, -2.53787376e-02f, -6.26641884e-02f, 5.21672852e-02f, 5.60950637e-02f, -6.76025674e-02f, 4.11270820e-02f, -5.81134222e-02f, -6.81642741e-02f, -8.40589553e-02f,
  8.47428441e-02f, 6.94673955e-02f, -4.72381525e-02f, 8.01127627e-02f, 2.47746501e-02f, 4.05399501e-03f, 5.65481149e-02f, -2.38264930e-02f, -9.08659771e-03f, -4.20882851e-02f,
  -6.95136338e-02f, 4.54392731e-02f, -7.67274797e-02f, -5.34490906e-02f, -7.35105127e-02f, -7.69809587e-03f, 8.44859285e-04f, 1.02917692e-02f, -2.23889686e-02f, -2.87332758e-02f,
  -7.73409531e-02f, -6.84080794e-02f, 7.30605721e-02f, 5.50376996e-02f, 1.93631779e-02f, 4.06035259e-02f, -8.91909283e-03f, -8.98832604e-02f, 3.98744605e-02f, -7.88548961e-02f,
  -4.52383654e-03f, -6.98887184e-02f, -8.01875070e-02f, -5.82705811e-02f, -1.71444044e-02f, -9.48424861e-02f, 3.34164873e-02f, 2.03586966e-02f, -2.97528803e-02f, -6.70120344e-02f,
  2.27609351e-02f, 8.29617530e-02f, -7.24100173e-02f, 1.01239495e-01f, -5.61056510e-02f, -5.69590405e-02f, 9.29058343e-02f, -2.43297759e-02f, 1.04678564e-01f, 4.95338775e-02f,
  -4.18335982e-02f, 4.18554395e-02f, -3.79921049e-02f, -7.27899075e-02f, 9.71734971e-02f, -3.58134918e-02f, -7.41150603e-03f, -9.96315926e-02f, -7.11973533e-02f, -2.21747290e-02f,
  -8.38117003e-02f, 3.31728607e-02f, 1.02868818e-01f, -5.38649620e-04f, -5.07700741e-02f, 6.36972338e-02f, -1.56760458e-02f, 4.98584704e-03f, -3.14302146e-02f, 3.13288309e-02f,
  9.06447396e-02f, -1.00916669e-01f, 7.34891444e-02f, -1.14551121e-02f, -6.48741499e-02f, 9.24178511e-02f, 7.16107413e-02f, 4.62236740e-02f, -1.65127367e-02f, 4.10999507e-02f,
  -8.08371115e-04f, -1.29915448e-02f, 7.37802759e-02f, -9.04388800e-02f, 7.03942031e-02f, -1.03790402e-01f, -3.24992724e-02f, 3.13117690e-02f, 4.58141379e-02f, 5.69122769e-02f,
  -6.36262745e-02f, -9.62189585e-02f, 1.10852905e-01f, -7.64148757e-02f, -6.46554157e-02f, 6.49166554e-02f, 8.80639255e-02f, -3.85567024e-02f, -6.31701946e-02f, -6.14972459e-03f,
  2.84153642e-03f, 2.12668311e-02f, -8.95790607e-02f, 3.23742367e-02f, -7.33952969e-02f, -2.76955478e-02f, 6.96836263e-02f, 8.65935981e-02f, 7.61830285e-02f, 8.49017054e-02f,
  8.72313511e-03f, -4.78049461e-03f, 1.26048878e-01f, 1.07485764e-02f, 4.10365574e-02f, 2.55730818e-03f, 2.48988587e-02f, 4.42118570e-03f, 1.96637325e-02f, -1.51034668e-02f,
  -3.91970091e-02f, -3.91247682e-02f, 6.47912472e-02f, 7.57519826e-02f, -9.94166732e-02f, -3.27563323e-02f, 2.73591932e-03f, -5.92332631e-02f, 1.71718132e-02f, -2.02533826e-02f,
  5.00822477e-02f, -2.47714389e-02f, -2.38295901e-03f, 7.69389197e-02f, -4.91041988e-02f, 5.20938374e-02f, 6.20618314e-02f, 6.90637603e-02f, 2.91420240e-02f, -5.43630533e-02f,
  3.10965907e-02f, 1.09726498e-02f, 5.15009314e-02f, -5.35333827e-02f, -8.03965982e-03f, 9.98012200e-02f, 1.24914583e-03f, 1.94158703e-02f, -4.86977845e-02f, 4.28880565e-02f,
  -6.13198839e-02f, 3.59796896e-03f, 6.54346421e-02f, -2.58524474e-02f, -1.50420554e-02f, -5.47273830e-02f, -4.33376282e-02f, -9.68392342e-02f, 6.88624829e-02f, -4.17699628e-02f,
  5.17717823e-02f, -4.20155227e-02f, 6.48237765e-02f, -4.96168844e-02f, 3.89818512e-02f, 3.97251211e-02f, 5.89108877e-02f, -2.21114904e-02f, -6.31549507e-02f, -4.76350971e-02f,
  -8.20811093e-02f, -7.51088634e-02f, -6.03167079e-02f, -5.02386084e-03f, 6.26556277e-02f, -2.50668190e-02f, 5.90933040e-02f, -9.24623609e-02f, -4.29339260e-02f, -6.34698868e-02f,
  8.07486773e-02f, 1.30071146e-02f, -1.61747202e-01f, -1.37213647e-01f, -1.86149999e-02f, 2.32583308e-03f, 1.12754740e-02f, -1.18724681e-01f, 4.86664139e-02f, 1.48286983e-01f,
  7.33606443e-02f, 9.38883424e-02f, 4.95832339e-02f, -1.73814416e-01f, -1.24123432e-01f, 1.31766438e-01f, -1.75929114e-01f, 6.50386959e-02f, -7.52580762e-02f, -1.21746279e-01f,
  -9.44202617e-02f, -1.38624934e-02f, -1.73601583e-01f, -6.98752478e-02f, -7.35509917e-02f, -3.72728333e-02f, 1.16424501e-01f, 1.13370024e-01f, -6.79156333e-02f, -7.64182508e-02f,
  6.91222548e-02f, 6.74218759e-02f, -7.22278506e-02f, -7.35977665e-02f, -1.02075256e-01f, 6.13525324e-03f, -3.43685336e-02f, 1.78813860e-02f, 3.45727764e-02f, 5.14899082e-02f,
  1.08024314e-01f, 4.57134545e-02f, -3.19831586e-03f, 5.67274215e-03f, -6.70061409e-02f, 4.28019576e-02f, -7.55308643e-02f, -9.63893079e-04f, -1.81192569e-02f, -4.51510139e-02f,
  -7.12283775e-02f, -3.90527919e-02f, 5.82078956e-02f, -2.06863470e-02f, -4.21522707e-02f, -2.74428129e-02f, -5.29878214e-03f, -7.03281164e-02f, 6.69382513e-03f, -6.87972903e-02f,
  3.73740047e-02f, 3.99428196e-02f, 3.36105041e-02f, -3.32718864e-02f, -1.31555088e-02f, 4.26752977e-02f, -3.42062563e-02f, -6.10098653e-02f, 7.24483579e-02f, 3.74645181e-02f,
  -7.30629079e-03f, -5.87335080e-02f, 8.46847817e-02f, -4.19539064e-02f, 4.76986356e-02f, 5.16350474e-03f, -3.48711349e-02f, 2.13323291e-02f, -8.85560215e-02f, -5.84817827e-02f,
  5.51506318e-02f, 2.97501795e-02f, 3.26724090e-02f, 6.50505200e-02f, 8.21451843e-02f, -2.41028238e-02f, -1.42577046e-03f, 4.88116406e-02f, 2.85753328e-02f, 1.23538049e-02f,
  -6.73804656e-02f, 4.24623340e-02f, -2.67672967e-02f, -2.33491883e-02f, -4.25321497e-02f, -4.01264913e-02f, 7.56732672e-02f, -1.74720995e-02f, -3.12769301e-02f, -3.38846929e-02f,
  2.86860886e-04f, 1.09664509e-02f, 2.13923845e-02f, 3.50553356e-02f, -1.83843952e-02f, 1.06459726e-02f, 4.29409109e-02f, 2.01164652e-02f, -1.66538842e-02f, 3.07303872e-02f,
  3.50649543e-02f, 7.78577849e-02f, -4.95923962e-03f, 8.35093930e-02f, 3.63039821e-02f, -5.12999808e-03f, -5.66023216e-02f, 7.96003863e-02f, 1.48283932e-02f, 5.71728125e-02f,
  6.61472678e-02f, 2.83866432e-02f, 1.24171466e-01f, 7.37063214e-03f, 1.44466102e-01f, 5.25094792e-02f, 1.43642649e-02f, 1.84282839e-01f, -1.33825177e-02f, -3.90485972e-02f,
  3.63368504e-02f, -1.26942396e-01f, -2.60306206e-02f, -1.07208587e-01f, -1.62087604e-02f, -1.57112896e-01f, -1.14251427e-01f, -1.01734519e-01f, 8.60744156e-03f, -9.07564834e-02f,
  7.92954490e-03f, -1.13567196e-01f, -1.17025852e-01f, -4.38859686e-02f, 3.09107881e-02f, 3.00524887e-02f, -5.71447760e-02f, -3.55233811e-02f, 7.21898675e-02f, 1.22008612e-02f,
  -4.65988666e-02f, 4.50174287e-02f, 1.01147301e-01f, 2.80713160e-02f, -3.72713208e-02f, -4.62477803e-02f, -6.42322600e-02f, 4.90640961e-02f, 6.04588538e-02f, 3.40307616e-02f,
  8.76721181e-03f, -1.09440841e-01f, 5.95454015e-02f, -3.04348376e-02f, -3.64078321e-02f, 1.86694004e-02f, -1.55419158e-03f, 1.14874221e-01f, -3.94952297e-03f, 6.90910071e-02f,
  8.24906304e-02f, 6.09554984e-02f, -6.42321259e-02f, -1.13026828e-01f, -1.12042604e-02f, -6.76064864e-02f, 3.32260616e-02f, -7.54780471e-02f, 2.24749893e-02f, 1.24430647e-02f,
  -7.63360411e-02f, -9.16130394e-02f, 6.00264892e-02f, -2.88948696e-02f, 1.06946915e-01f, 7.94863154e-04f, 5.89686036e-02f, 5.09405024e-02f, -8.99326522e-03f, 8.47970694e-02f,
  -5.11714406e-02f, 6.39752373e-02f, -4.30903919e-02f, 1.22082199e-03f, -5.89340813e-02f, -8.15704465e-02f, -3.75559703e-02f, 8.20547193e-02f, 8.12390745e-02f, 4.63753976e-02f,
  1.36501584e-02f, 2.86036748e-02f, -1.20530222e-02f, -9.54940170e-03f, 1.92247164e-02f, -7.90475085e-02f, -6.61355630e-02f, 1.40711637e-02f, 2.10027248e-02f, -5.20196855e-02f,
  1.22993160e-02f, -1.02547808e-02f, 4.79408316e-02f, -4.30089831e-02f, -5.02597028e-03f, -5.27785458e-02f, -4.16366048e-02f, 5.50382882e-02f, -4.57090177e-02f, -5.94559647e-02f,
  -4.30253781e-02f, -2.07216293e-02f, -3.38029973e-02f, 6.84654266e-02f, -7.32613504e-02f, -2.04572384e-03f, -2.32096277e-02f, -7.02048838e-02f, 3.91294584e-02f, -4.56132181e-02f,
  -4.64839377e-02f, -1.49946800e-02f, 6.14632890e-02f, -7.04980120e-02f, 7.49115050e-02f, -4.88873571e-02f, -5.11883236e-02f, -7.10715353e-02f, -1.38014331e-02f, -3.12731080e-02f,
  2.04835236e-01f, -1.60234854e-01f, -3.13158095e-01f, 6.94090128e-02f, 7.35033453e-02f, 4.25805785e-02f, -4.44694534e-02f, -5.00597619e-02f, -2.48857096e-01f, 2.19536014e-02f,
  6.08785711e-02f, 8.17477331e-02f, -1.91413194e-01f, 2.42900372e-01f, 2.08374277e-01f, -1.41412109e-01f, 1.96667641e-01f, 2.00095713e-01f, -1.20816663e-01f, 1.12368941e-01f,
  9.74073261e-02f, 3.71412754e-01f, -2.29632929e-02f, 1.47212565e-01f, 2.23926440e-01f, -4.65134606e-02f, 2.03194916e-01f, -1.19071402e-01f, 3.03925335e-01f, 1.45189688e-01f,
  -4.56933193e-02f, -5.64389415e-02f, 1.90794282e-02f, -3.59209180e-02f, -3.54762189e-02f, -1.10462587e-02f, 6.34796498e-03f, 1.67785529e-02f, -7.96366706e-02f, 7.92856794e-03f,
  -4.70052920e-02f, -3.73151228e-02f, 4.68437187e-03f, 5.10424450e-02f, 8.94133374e-02f, -4.48724031e-02f, 4.70125712e-02f, -4.56011258e-02f, -5.99313006e-02f, -4.94092777e-02f,
  -1.21075280e-01f, -8.06554481e-02f, -5.24400733e-02f, -4.91912290e-03f, -7.66922068e-03f, 3.24305557e-02f, 5.72396629e-02f, -5.95046505e-02f, 9.16359201e-02f, -1.76827200e-02f,
  -2.49808542e-02f, -1.01566035e-02f, 1.84090459e-03f, 1.88313995e-03f, 2.59907488e-02f, 7.22644776e-02f, 1.38464104e-02f, -1.01508256e-02f, -9.85134616e-02f, -4.63679545e-02f,
  5.67556098e-02f, -7.39266425e-02f, 6.99770078e-02f, -6.58251196e-02f, 2.10310575e-02f, -6.38061240e-02f, -6.29635751e-02f, 8.79732519e-02f, -9.97101963e-02f, -1.18286356e-01f,
  -1.64182130e-02f, 1.58296642e-03f, -7.65100401e-03f, -4.04962450e-02f, -2.02592202e-02f, 2.95446012e-02f, -1.71258450e-02f, 5.96430004e-02f, -4.07416634e-02f, 6.63146302e-02f,
  5.04625328e-02f, 9.26389098e-02f, -9.22872219e-03f, 6.78421855e-02f, 2.33008247e-03f, 1.05267689e-02f, 1.65092421e-03f, 9.62383486e-03f, 2.14796998e-02f, 5.35256565e-02f,
  5.96065633e-02f, 1.95059497e-02f, 2.16198582e-02f, 8.92534479e-02f, 1.00341747e-02f, 3.56321186e-02f, 7.22268000e-02f, 1.22691300e-02f, 2.51298174e-02f, 1.73128564e-02f,
  -6.77465424e-02f, 6.26450852e-02f, -5.86488023e-02f, -7.07297549e-02f, -1.76655743e-02f, 9.43064690e-02f, 1.95456017e-02f, -2.75509916e-02f, -1.73504949e-02f, -4.16904502e-02f,
  -6.37922622e-03f, 2.50210194e-03f, 3.34527786e-03f, 5.68324588e-02f, -6.31992966e-02f, -5.00616059e-03f, 8.65558919e-04f, 5.40095195e-02f, 1.13753811e-01f, -5.22459671e-02f,
  -6.64756149e-02f, 1.04498677e-01f, -8.70394930e-02f, 1.22135906e-02f, -8.26328844e-02f, -2.83203367e-02f, 8.96687210e-02f, 1.71291735e-02f, -3.20478752e-02f, -1.93747133e-02f,
  1.71413776e-02f, 1.48500670e-02f, -1.12483598e-01f, -2.40785275e-02f, -1.63625591e-02f, 2.24826206e-02f, -1.50816798e-01f, -8.45576730e-03f, 4.97192182e-02f, 2.46895123e-02f,
  3.89304496e-02f, 8.50041863e-03f, -6.92631602e-02f, -5.81482686e-02f, -2.26618666e-02f, 9.72982720e-02f, -6.78947046e-02f, -2.85454094e-02f, 5.96705787e-02f, -1.24674081e-03f,
  -4.37518023e-02f, -1.02145728e-02f, 1.35658542e-02f, 8.36722255e-02f, 5.14027476e-02f, 2.34663989e-02f, 3.12980376e-02f, 2.95315422e-02f, -1.46184443e-02f, 7.81776011e-02f,
  -5.09941019e-02f, 5.07221296e-02f, 3.90522368e-02f, 9.59818624e-03f, 5.43524325e-02f, 1.43737951e-02f, -2.29583327e-02f, -4.69083302e-02f, -6.19665049e-02f, 6.01238981e-02f,
  9.18214768e-02f, 1.72225554e-02f, 8.99650231e-02f, 4.95579503e-02f, 6.09443076e-02f, -6.05785288e-02f, -9.22530517e-02f, 3.10313841e-03f, -4.25675660e-02f, 6.52211756e-02f,
  2.44685188e-02f, -1.06983520e-02f, -7.69828409e-02f, 6.24113902e-02f, -2.20469236e-02f, 4.12583305e-03f, 1.44519806e-02f, -8.09148550e-02f, -8.18305239e-02f, 2.24536993e-02f,
  3.77439782e-02f, 8.66978467e-02f, 5.69904745e-02f, 6.03034813e-03f, 5.88360503e-02f, -9.23321303e-03f, -1.41620953e-02f, -5.55553436e-02f, -8.69633630e-03f, -4.42528576e-02f,
  3.56894918e-02f, 4.96318340e-02f, 6.03238940e-02f, 4.87110484e-03f, -1.37710888e-02f, -6.43934831e-02f, 9.64282826e-02f, 6.96455538e-02f, -3.57493386e-02f, 3.84802371e-02f,
  7.31064752e-02f, 6.62334338e-02f, 3.90781052e-02f, 9.28841978e-02f, -9.63011198e-03f, -3.98776978e-02f, 7.39448443e-02f, -3.95398354e-04f, 6.18617609e-02f, 4.15714309e-02f,
  4.20159772e-02f, 1.46979149e-02f, 2.23571435e-03f, 7.74496868e-02f, -5.80742210e-02f, 5.44987768e-02f, 1.00024566e-02f, -3.36008295e-02f, 3.63603905e-02f, 6.66149706e-02f,
  1.51912078e-01f, 2.66911145e-02f, -1.37177348e-01f, -1.25655651e-01f, 5.61044328e-02f, 1.48957253e-01f, -1.75064988e-02f, 4.22708690e-02f, -1.33076474e-01f, -7.24636167e-02f,
  -4.80092801e-02f, -1.27051771e-01f, -6.72573373e-02f, 7.21208006e-02f, 1.55668363e-01f, 7.65637308e-02f, -2.53925696e-02f, -1.64721143e-02f, 5.58141619e-02f, -6.76517487e-02f,
  -4.18329872e-02f, 7.77103007e-02f, -5.15779369e-02f, 2.80390773e-02f, 4.31014188e-02f, -1.16631515e-01f, -3.88909914e-02f, 3.93080078e-02f, 1.53041398e-02f, 2.81039588e-02f,
  1.52734974e-02f, -7.85171688e-02f, 1.08493511e-02f, 4.31199074e-02f, 1.99838802e-02f, 6.46597221e-02f, -5.89961484e-02f, 9.72384661e-02f, -7.29134530e-02f, -1.60756484e-02f,
  -3.31455767e-02f, 3.78436781e-02f, 3.25609967e-02f, -5.65995313e-02f, 6.01929091e-02f, -2.01936178e-02f, 6.56152591e-02f, -3.23914997e-02f, -9.82959270e-02f, 4.91156196e-03f,
  -8.63441750e-02f, -6.81736693e-02f, 4.46349308e-02f, -8.33491758e-02f, -1.16068386e-01f, 2.54056919e-02f, -5.45725115e-02f, -3.15035693e-02f, -3.00117377e-02f, -1.49519974e-02f,
  7.18724579e-02f, 5.78667372e-02f, 1.05206922e-01f, -1.15556791e-02f, 5.89985698e-02f, -5.95289730e-02f, 6.24271631e-02f, 2.80375537e-02f, 1.75636495e-03f, -3.34270857e-02f,
  -1.52978851e-02f, -7.53919873e-03f, -4.71758656e-02f, -8.12203065e-02f, -1.86207201e-02f, -2.98819337e-02f, -1.46273747e-02f, 5.73975965e-03f, -5.63830063e-02f, -6.10671677e-02f,
  -8.10539499e-02f, -2.04729028e-02f, 8.14604089e-02f, -5.36535457e-02f, 2.18228530e-02f, -2.85426825e-02f, 1.91776007e-02f, -3.69802080e-02f, 5.28590381e-02f, 3.01422477e-02f,
  1.26606738e-02f, 9.22364816e-02f, -3.60032581e-02f, 4.32759300e-02f, 6.62639812e-02f, -4.36452031e-03f, -8.21914002e-02f, 7.29329735e-02f, -7.75566027e-02f, -6.14990201e-03f,
  4.17659804e-02f, -1.01277567e-02f, -2.58017052e-02f, -2.74232887e-02f, 4.22621109e-02f, 9.52562690e-02f, -1.00314893e-01f, -5.63141853e-02f, 2.87499744e-02f, -6.50254544e-03f,
  -2.08355002e-02f, 6.54549077e-02f, -3.34014595e-02f, -3.17902826e-02f, -5.87316342e-02f, 3.69150117e-02f, -6.28269836e-02f, -8.46496373e-02f, 7.06738734e-04f, 6.32536337e-02f,
  -2.85140816e-02f, 1.87919959e-01f, 1.17458493e-01f, -1.32827144e-02f, -1.05820060e-01f, -8.31802860e-02f, -4.04856727e-02f, 5.40154316e-02f, -4.29947823e-02f, 6.66885749e-02f,
  -9.95572954e-02f, 1.80485159e-01f, -1.22351088e-02f, 4.98606302e-02f, -2.43225560e-01f, -1.22299060e-01f, 5.01951911e-02f, 3.54898721e-02f, 1.71416197e-02f, 7.50830844e-02f,
  2.27347799e-02f, -1.36351570e-01f, 4.07607201e-03f, -5.48762605e-02f, 9.14729387e-02f, 1.54523149e-01f, -5.68131134e-02f, -3.40418518e-02f, 1.94398910e-02f, -5.09451292e-02f,
  -2.88613364e-02f, -2.88053118e-02f, 1.40399069e-01f, 7.36376047e-02f, -5.71745336e-02f, 1.04385339e-01f, 1.10116370e-01f, -1.27601419e-02f, 5.26942275e-02f, 5.45470975e-02f,
  6.26150221e-02f, -6.46861345e-02f, -5.26167043e-02f, -2.51166690e-02f, 9.13501084e-02f, 5.39270639e-02f, 2.66647320e-02f, 1.17857613e-01f, 4.51552235e-02f, 1.90068521e-02f,
  4.19626124e-02f, 1.41023681e-01f, 5.81138544e-02f, 1.04557432e-01f, 3.31940576e-02f, 7.30695203e-02f, 9.80792791e-02f, 1.83490384e-02f, -3.82787138e-02f, 2.86751632e-02f,
  -8.29620063e-02f, -1.85539592e-02f, -1.19709158e-02f, -4.31906842e-02f, -7.35033080e-02f, 6.75086910e-03f, -9.72123444e-03f, -3.54196168e-02f, -2.32558176e-02f, 6.18354650e-03f,
  1.52431510e-03f, 9.16151255e-02f, -7.98738450e-02f, 1.49978688e-02f, 1.74472034e-02f, -1.10556523e-03f, 9.84943472e-04f, 1.04175895e-01f, 1.14817061e-02f, 1.18095260e-02f,
  -1.11790895e-01f, 2.58619208e-02f, 3.93229760e-02f, -3.19007523e-02f, -6.09509759e-02f, -8.10470358e-02f, -5.67461401e-02f, 1.03898056e-01f, 6.04643188e-02f, -8.33537653e-02f,
  -7.16894269e-02f, -3.71011812e-03f, 6.73002824e-02f, 6.47097528e-02f, 8.69602785e-02f, -1.88482497e-02f, -5.44349924e-02f, -2.99261510e-02f, 3.21295708e-02f, 7.18783438e-02f,
  -5.08535374e-03f, 6.77871555e-02f, 2.80399658e-02f, -3.35017405e-02f, 8.70739017e-03f, -4.01991494e-02f, 2.73907427e-02f, 4.15440053e-02f, 1.92094557e-02f, -4.77901697e-02f,
  4.02839780e-02f, -1.92260258e-02f, 7.81318843e-02f, -1.17338933e-02f, 7.98088834e-02f, 6.48456514e-02f, -8.58163387e-02f, -5.10715507e-03f, -3.19514200e-02f, 4.69808541e-02f,
  -1.05250508e-01f, 3.28064077e-02f, 1.81831382e-02f, 3.98236932e-03f, 4.44151014e-02f, 1.43799856e-01f, -1.97755843e-02f, 4.26986031e-02f, -9.03191511e-03f, -3.88201289e-02f,
  -4.60233651e-02f, -3.65547352e-02f, -1.11903176e-01f, 1.16025649e-01f, 6.25251755e-02f, 9.02543440e-02f, 6.04088679e-02f, 5.02651595e-02f, 5.71289174e-02f, -6.96160197e-02f,
  5.95451184e-02f, 2.60107685e-02f, 3.05017121e-02f, -4.35248166e-02f, -1.14215150e-01f, -1.02436855e-01f, -9.18713864e-03f, -4.69910577e-02f, 5.00897653e-02f, 9.02637560e-03f,
  -7.59167820e-02f, -3.28136347e-02f, -1.45889368e-04f, -3.97019908e-02f, -4.10703942e-02f, -4.12567295e-02f, -8.47987831e-02f, 5.03981411e-02f, 1.40836015e-02f, -2.49986891e-02f,
  3.88042163e-03f, 6.02279864e-02f, 7.25551322e-02f, 4.06019129e-02f, -3.39703150e-02f, -6.50720373e-02f, 9.31121632e-02f, -7.91521072e-02f, 7.44970441e-02f, 6.37996048e-02f,
  1.76939052e-02f, -3.89874540e-02f, 3.06083187e-02f, -1.94052715e-04f, 2.32255552e-02f, 3.01428959e-02f, -4.06013802e-02f, 7.89480060e-02f, -2.17210222e-02f, 1.09477177e-01f,
  6.86983839e-02f, 9.89294425e-02f, -2.33659092e-02f, 3.34760509e-02f, -2.87809055e-02f, -8.90826732e-02f, -5.91554791e-02f, 1.27621917e-02f, 8.12353715e-02f, -5.90470154e-03f,
  6.96899816e-02f, 5.87267615e-02f, 2.38520652e-02f, 6.66437969e-02f, -9.03750956e-02f, -4.71168980e-02f, -1.59388743e-02f, -6.41191229e-02f, -3.43453065e-02f, -3.46955433e-02f,
  -5.15758991e-02f, -3.74461971e-02f, 6.11492200e-03f, 5.65215722e-02f, 5.52057289e-02f, 5.18515380e-03f, 1.41395722e-02f, 2.25187875e-02f, -2.36475337e-02f, 1.94453560e-02f,
  3.87942814e-03f, 1.10178180e-01f, 7.40052527e-03f, -7.94621184e-02f, 4.43914644e-02f, 4.24207002e-03f, -5.43314293e-02f, 7.02961832e-02f, 1.55204143e-02f, 5.52839739e-03f,
  5.13406359e-02f, 7.44910038e-04f, 2.86249071e-02f, -4.40910049e-02f, 4.91606407e-02f, -9.27225053e-02f, -2.57259398e-03f, -4.81711887e-02f, -3.96511853e-02f, -2.55179182e-02f,
  -4.60467339e-02f, 6.71018362e-02f, 6.80645332e-02f, -5.93614839e-02f, 2.86806971e-02f, 9.01783183e-02f, -7.01819286e-02f, -5.77323064e-02f, 6.43609390e-02f, -4.65971380e-02f,
  -1.77694689e-02f, -1.99565142e-02f, -1.55059487e-01f, 9.74803194e-02f, 1.94216147e-01f, 2.86427557e-01f, 1.80345267e-01f, 1.73369363e-01f, 2.42799133e-01f, 2.05903966e-02f,
  9.27097276e-02f, 2.46993732e-03f, -8.12683553e-02f, 1.80979252e-01f, 1.65121749e-01f, 1.09518185e-01f, 1.57645985e-01f, 1.69888154e-01f, 4.25037853e-02f, 1.47543848e-02f,
  6.31070957e-02f, 8.98218378e-02f, -1.15910314e-01f, -3.92990261e-02f, -8.11992362e-02f, -1.70703173e-01f, -5.25803715e-02f, -7.34736472e-02f, -6.95891604e-02f, -2.25977339e-02f,
  5.51858619e-02f, -3.04620489e-02f, -8.91667902e-02f, -5.58717847e-02f, 6.71037585e-02f, -3.96981388e-02f, -1.15417756e-01f, -5.72950207e-02f, -8.10773671e-02f, 3.93495113e-02f,
  -5.00809699e-02f, -7.66290352e-02f, -4.96323854e-02f, -2.68792175e-02f, 7.12918714e-02f, -4.39423323e-02f, -3.00950296e-02f, -3.14925425e-02f, 9.93716344e-03f, 1.27843646e-02f,
  -5.20146228e-02f, 5.57661690e-02f, 2.90215127e-02f, 7.88211226e-02f, 7.38958120e-02f, 9.29991230e-02f, 1.47323674e-02f, 1.32866250e-02f, 6.54195920e-02f, 5.86839579e-03f,
  4.14122082e-02f, -2.98858173e-02f, -2.74515562e-02f, 5.92477769e-02f, -6.80418164e-02f, -4.63081384e-03f, 3.07806544e-02f, -9.01451483e-02f, 1.88505463e-02f, -2.61075068e-02f,
  1.21899983e-02f, -3.49364504e-02f, 8.83302465e-02f, 8.77653360e-02f, 1.01382956e-01f, 6.55574650e-02f, -5.54696172e-02f, -6.92479089e-02f, 7.68934786e-02f, 6.10070042e-02f,
  -3.58362757e-02f, 2.05119327e-02f, -2.81859934e-02f, 3.25309671e-02f, 9.46841985e-02f, 4.82646003e-02f, 4.18888070e-02f, -5.88243678e-02f, 2.91691553e-02f, -7.96423666e-03f,
  1.46891668e-01f, 3.89674976e-02f, 2.77919117e-02f, 2.76456424e-03f, 6.27717227e-02f, -4.69426177e-02f, 6.91685379e-02f, -3.33892293e-02f, 8.65851715e-02f, 9.68622416e-02f,
  -5.48822172e-02f, 4.49051894e-02f, 2.60017123e-02f, -7.87386596e-02f, -5.05109578e-02f, 2.74478458e-02f, 3.37754004e-02f, -1.95288956e-02f, -1.53193390e-03f, 1.25583531e-02f,
  -2.07360499e-02f, 9.52107608e-02f, -2.44382862e-02f, 6.21688813e-02f, -8.98113474e-02f, -1.77414510e-02f, 9.64891389e-02f, 3.93702462e-02f, -7.17895404e-02f, 8.80631357e-02f,
  -2.52291523e-02f, -8.37480277e-02f, -1.83490962e-02f, 1.46604374e-01f, 2.25600153e-01f, -2.00974587e-02f, 8.29935595e-02f, 1.37071580e-01f, 1.89209968e-01f, -7.55429044e-02f,
  1.40026301e-01f, -1.64596483e-01f, -1.46640554e-01f, 1.14240162e-01f, 6.90583661e-02f, -2.14380231e-02f, 1.50719747e-01f, 8.74142125e-02f, 1.20486960e-01f, 8.39978233e-02f,
  4.48339172e-02f, 7.17625022e-02f, -5.45547754e-02f, 8.99611786e-02f, 1.10699080e-01f, 3.93513143e-02f, -7.69832358e-02f, -4.05526049e-02f, 3.92019283e-03f, -1.41717970e-01f,
  -6.36961460e-02f, 1.45303667e-01f, 6.41413406e-02f, -9.05902237e-02f, 9.69724879e-02f, 5.96742444e-02f, -2.84975320e-02f, -4.38765399e-02f, 5.21369465e-02f, -1.30169326e-02f,
  2.73797475e-02f, -1.59675702e-02f, -3.36755849e-02f, -3.04791965e-02f, 2.50053685e-02f, 3.73470015e-03f, 3.30529436e-02f, 6.43091351e-02f, -3.48233953e-02f, 6.02055937e-02f,
  -2.18199872e-04f, 2.12153345e-02f, 8.43542367e-02f, 4.47434820e-02f, 1.02941029e-01f, 1.31486198e-02f, -6.82599619e-02f, 2.54981536e-02f, 1.60413166e-03f, 2.07183231e-02f,
  -1.02572732e-01f, -8.16364288e-02f, 3.15394476e-02f, -2.10694782e-02f, 1.26080234e-02f, 4.68341075e-02f, -9.96652525e-03f, 6.93716183e-02f, -3.22234109e-02f, 9.61734429e-02f,
  1.48122739e-02f, 1.32206818e-02f, -4.58454229e-02f, -1.77652631e-02f, 2.85237692e-02f, 4.10589669e-03f, -1.10349813e-02f, -2.89313117e-04f, 5.40127493e-02f, 7.88085014e-02f,
  1.43446773e-03f, -1.04720201e-02f, -3.50834019e-02f, -5.22223413e-02f, -4.27172184e-02f, -6.49236739e-02f, -1.89110246e-02f, -2.24551582e-03f, 9.09628719e-02f, -3.96896712e-03f,
  -8.91133770e-03f, -4.75283936e-02f, -8.37299004e-02f, 1.94928478e-02f, 1.28152659e-02f, -3.00201010e-02f, -1.16759151e-01f, 8.34990963e-02f, -7.40975738e-02f, -5.20258732e-02f,
  3.53786387e-02f, -2.34976914e-02f, -6.57454655e-02f, -8.31541717e-02f, -1.00321807e-01f, -2.15520021e-02f, -5.39600328e-02f, -3.02674808e-02f, -5.82915321e-02f, -8.74887332e-02f,
  -1.43799754e-02f, -6.36411160e-02f, -7.55216777e-02f, -1.64007992e-02f, 5.56357428e-02f, 1.37133235e-02f, -3.14426445e-03f, -2.45211534e-02f, -1.70889720e-02f, -3.67040820e-02f,
  -1.69503242e-01f, -2.96544760e-01f, -1.09205559e-01f, 4.68519293e-02f, 1.60589725e-01f, 4.14679348e-02f, -7.70990252e-02f, -2.76572257e-02f, -1.72981963e-01f, -1.60076499e-01f,
  -1.06817052e-01f, -1.30087778e-01f, -3.38326991e-01f, 1.08969457e-01f, 1.15001976e-01f, -5.83808981e-02f, 9.48379114e-02f, -5.99658377e-02f, 6.62785769e-02f, -1.19089969e-01f,
  9.94442925e-02f, 1.94839120e-01f, 1.38080224e-01f, 2.31769010e-01f, 9.47713926e-02f, -4.37625162e-02f, 2.52597984e-02f, 8.33180174e-02f, 7.96816647e-02f, 1.12382405e-01f,
  -1.79989301e-02f, -1.63790032e-01f, -1.16122782e-01f, 6.97052255e-02f, -4.76890542e-02f, -2.26492975e-02f, -5.59128709e-02f, 7.61344358e-02f, 3.50174010e-02f, -2.67109443e-02f,
  -6.42515346e-02f, 1.38610601e-01f, 9.84846726e-02f, 7.15314820e-02f, 2.64231022e-03f, -7.23938411e-03f, -2.36733705e-02f, -9.92688164e-02f, 1.14965122e-02f, -8.30958784e-02f,
  -8.90013576e-02f, 1.63113102e-02f, -2.84083970e-02f, -3.64745781e-02f, 6.94833621e-02f, 2.68747768e-04f, -6.50848597e-02f, 1.50525384e-02f, 3.15371831e-03f, 1.82391834e-02f,
  6.93224464e-03f, 4.96952469e-03f, -3.41033638e-02f, 5.98491095e-02f, -7.99015537e-02f, 9.99244303e-02f, 8.92556682e-02f, 6.56295270e-02f, 1.13097355e-02f, 6.98570162e-02f,
  5.14823981e-02f, -2.71327160e-02f, -4.75827716e-02f, 6.80984780e-02f, 3.63891316e-03f, -4.18259241e-02f, 2.88649742e-02f, 7.43429065e-02f, 3.29520390e-03f, 7.23561719e-02f,
  4.78957780e-02f, -3.85361426e-02f, -3.57914232e-02f, 5.76434508e-02f, 2.29595713e-02f, -1.42898876e-03f, -8.70255753e-02f, -3.73663753e-02f, -8.20320323e-02f, 8.16395953e-02f,
  -7.59368688e-02f, -3.29766989e-01f, -5.11682332e-02f, 9.51744318e-02f, 1.18797421e-02f, -7.32608661e-02f, 6.42059743e-02f, 4.67825755e-02f, -1.88224297e-02f, -1.16702244e-01f,
  -1.08002990e-01f, 4.61551286e-02f, 2.61073690e-02f, 2.22252980e-02f, 1.18304072e-02f, -5.67695461e-02f, -7.76614100e-02f, 1.38484128e-02f, -5.65695316e-02f, -3.35601419e-02f,
  -2.76675280e-02f, -8.43901411e-02f, -6.12813188e-03f, 2.41443273e-02f, -3.46086174e-02f, 3.20951687e-03f, -7.94725195e-02f, -4.62121405e-02f, 7.32010528e-02f, -3.95143256e-02f,
  -7.65335634e-02f, 5.07413223e-02f, -4.77706194e-02f, -1.29856735e-01f, -1.43032268e-01f, -1.14560485e-01f, 4.85747568e-02f, -1.00065723e-01f, -2.24006977e-02f, 1.46440538e-02f,
  -1.37533009e-01f, -2.43891738e-02f, 1.65909722e-01f, -1.28337592e-01f, 2.30512042e-02f, 5.23527861e-02f, -1.68913305e-01f, 6.07811101e-02f, -5.84018417e-02f, -1.51632456e-02f,
  3.96177731e-02f, -2.03176245e-01f, -9.03384313e-02f, -4.46962714e-02f, -2.64325559e-01f, -1.76824376e-01f, 3.30389589e-02f, -8.12583044e-02f, -1.02195054e-01f, -1.25274286e-02f,
  -1.44870862e-01f, -1.48271248e-01f, 5.87436445e-02f, 2.69785263e-02f, -1.42245712e-02f, 3.19858603e-02f, -5.39131016e-02f, 8.73286575e-02f, -2.65972894e-02f, -2.11650077e-02f,
  -2.53552254e-02f, 6.56128535e-03f, -9.43755433e-02f, 3.28008384e-02f, -3.52274477e-02f, 4.89679538e-02f, 4.49287891e-02f, -5.44059351e-02f, 5.45737669e-02f, 3.12424209e-02f,
  1.65120978e-02f, 3.45193557e-02f, -2.04326939e-02f, 8.53779614e-02f, 6.89390376e-02f, -3.52436379e-02f, -4.44917269e-02f, 9.63367969e-02f, 3.45497369e-03f, 8.02574158e-02f,
  -4.59817685e-02f, 1.03133589e-01f, -5.32780960e-02f, -1.27076330e-02f, -5.19704409e-02f, -9.27733332e-02f, 8.48104954e-02f, -1.31854648e-03f, 2.62870509e-02f, 5.79650737e-02f,
  -8.03571641e-02f, -3.95002738e-02f, -2.69883517e-02f, 8.62950310e-02f, -1.01668358e-01f, -1.97221693e-02f, -8.72066990e-02f, 7.58041628e-03f, 2.22051027e-03f, -8.54454711e-02f,
  -7.16817230e-02f, -2.50916239e-02f, 1.04322396e-02f, 1.23269428e-02f, -7.05422685e-02f, 6.70307353e-02f, -3.46726784e-03f, 7.24477395e-02f, 7.82894120e-02f, 4.35251668e-02f,
  -1.14057817e-01f, 4.00554352e-02f, -7.93858245e-03f, 4.44772933e-03f, -5.96208684e-02f, 6.04849085e-02f, 2.50595585e-02f, -2.72966325e-02f, -6.13210462e-02f, 2.42532101e-02f,
  5.17267063e-02f, 3.91422100e-02f, -6.43881485e-02f, 9.71694067e-02f, 8.58404264e-02f, -3.23236063e-02f, -5.05618639e-02f, -6.02690279e-02f, 1.42650330e-03f, 1.83345042e-02f,
  5.56350164e-02f, 3.15279774e-02f, 7.26913363e-02f, -7.78795704e-02f, 3.17540243e-02f, -3.08804493e-02f, 9.32052806e-02f, -6.07150085e-02f, 6.18229806e-02f, -1.74361393e-02f,
  -6.12958446e-02f, 3.54131535e-02f, -2.43588760e-02f, -1.07355136e-02f, 4.86919135e-02f, 1.47583678e-01f, 8.39571580e-02f, 1.24839671e-01f, 2.92385053e-02f, 1.04169331e-01f,
  8.07447657e-02f, 4.46907850e-03f, 6.11564552e-04f, 3.26549122e-03f, 7.96339288e-02f, -1.13242790e-01f, -3.74602876e-03f, 8.16752985e-02f, -3.45195979e-02f, -2.98436508e-02f,
  6.54681399e-03f, 7.82526731e-02f, -7.21886382e-02f, 1.89973079e-02f, 4.81346585e-02f, -1.35036379e-01f, 4.90252599e-02f, -1.02334052e-01f, 9.44367796e-02f, 9.54980478e-02f,
  9.51135829e-02f, 4.61216196e-02f, -1.04197450e-01f, -6.79185288e-03f, -5.18212169e-02f, -6.67780563e-02f, -1.28791183e-02f, -4.73794527e-02f, 4.80928011e-02f, 1.38669340e-02f,
  -3.69408354e-02f, -5.23813143e-02f, 9.14978832e-02f, 2.83895545e-02f, 9.27217603e-02f, 2.03781314e-02f, -6.70384690e-02f, -3.83019447e-02f, -7.67877474e-02f, -4.44453023e-02f,
  3.05796880e-02f, 1.29772751e-02f, 1.04917005e-01f, 6.01380542e-02f, 4.28352579e-02f, -6.29955530e-02f, -2.74871755e-02f, 6.44673407e-02f, 1.37315197e-02f, 7.34873936e-02f,
  4.26169485e-02f, 8.47449154e-02f, 8.79220944e-03f, 4.98206727e-02f, -6.66170716e-02f, -9.31661949e-02f, 5.30103594e-02f, -3.25545445e-02f, 4.25490998e-02f, 6.97679818e-02f,
  8.22619200e-02f, -9.28041264e-02f, -5.24311140e-02f, 4.05304059e-02f, -6.64512217e-02f, -8.56412202e-02f, 7.96982050e-02f, 4.95433472e-02f, -5.80005608e-02f, -5.15305530e-03f,
  -7.23772869e-02f, 2.58407481e-02f, 1.48303946e-02f, 3.58573947e-04f, -7.47730732e-02f, 1.99721847e-02f, -2.12205891e-02f, 7.95150027e-02f, 4.44091558e-02f, 9.23613645e-03f,
  1.16342686e-01f, -6.34279922e-02f, -9.01551619e-02f, -3.84251922e-02f, 2.06032535e-03f, 4.06016782e-02f, 4.50677089e-02f, 6.53201640e-02f, -5.18598817e-02f, 8.65874160e-03f,
  -4.10073474e-02f, 1.54877985e-02f, -5.56721352e-02f, -4.48395684e-02f, -7.29724094e-02f, 1.14158116e-01f, 1.66210495e-02f, 3.01527884e-02f, 8.64303559e-02f, -4.89752516e-02f,
  -9.72619653e-03f, 2.84204409e-02f, -1.78060196e-02f, 6.49597421e-02f, 8.44867527e-02f, 6.19466975e-03f, 8.72312300e-03f, -7.77878836e-02f, 5.05389087e-03f, 8.93162414e-02f,
  5.42513328e-03f, -2.54474521e-01f, 1.52672410e-01f, 9.62643623e-02f, 1.41100079e-01f, 1.22293197e-01f, 2.96728294e-02f, -4.05339943e-03f, -3.24274749e-02f, -2.53280431e-01f,
  8.28421786e-02f, -1.04671627e-01f, 1.06670350e-01f, -9.09404904e-02f, 7.62509704e-02f, 1.72667280e-02f, -4.55627479e-02f, 6.53517083e-04f, 1.29191414e-01f, 1.35834828e-01f,
  1.43924668e-01f, -1.22019485e-01f, 3.67058106e-02f, -1.19691588e-01f, -4.24493924e-02f, 5.72531261e-02f, -8.77157003e-02f, 1.07231028e-01f, -1.70838997e-01f, -8.74445960e-02f,
  -7.97605589e-02f, -2.05962826e-02f, -4.45017219e-02f, -5.21648228e-02f, 6.54301196e-02f, 2.17048675e-02f, -1.92031842e-02f, -7.34997466e-02f, 8.26821327e-02f, -1.76102370e-02f,
  -5.60847223e-02f, 2.12977622e-02f, -1.58285853e-02f, -5.80011383e-02f, 4.82887588e-02f, -1.70016326e-02f, -5.92010655e-02f, 1.03135936e-01f, -7.79095963e-02f, 8.09464231e-02f,
  6.11256175e-02f, -3.48570682e-02f, 7.68886283e-02f, -7.44513944e-02f, 1.32118329e-01f, 1.41443964e-02f, -3.88428420e-02f, -6.90922793e-03f, 1.50385080e-02f, -5.17066792e-02f,
  3.27764452e-02f, 9.06085223e-02f, -8.97342116e-02f, 3.29978876e-02f, 7.11208433e-02f, -6.03259727e-02f, -3.79093103e-02f, 2.40856409e-02f, -9.33138952e-02f, -3.99105214e-02f,
  1.11811152e-02f, 1.00576364e-01f, 1.00871758e-03f, 2.34838575e-02f, -7.58824721e-02f, 2.97403093e-02f, -1.15512256e-02f, 1.20035838e-02f, 4.29903530e-02f, -4.93219793e-02f,
  9.95735899e-02f, -1.52184339e-02f, 1.77051015e-02f, -9.12713725e-03f, 7.97199144e-04f, -5.06327003e-02f, -7.59668052e-02f, 4.18386087e-02f, -4.86895107e-02f, -1.85232109e-03f,
  -1.32681370e-01f, -8.47976422e-04f, 5.11968434e-02f, -9.31574497e-03f, -1.13280967e-01f, 2.60888506e-02f, 3.83801907e-02f, 5.80349527e-02f, 3.67916562e-02f, -1.45007456e-02f,
  9.16222576e-03f, -3.95635366e-02f, -7.22190142e-02f, -3.17530744e-02f, 7.92715102e-02f, -5.57964994e-03f, -4.72368263e-02f, -1.20668858e-01f, -6.76639006e-02f, -4.12054546e-02f,
  -4.06837165e-02f, -4.73578982e-02f, 1.46194929e-02f, -4.25167866e-02f, 5.45867607e-02f, -1.59826793e-03f, 7.07443384e-03f, 3.95388603e-02f, 6.07579313e-02f, 6.61838427e-02f,
  -7.49006867e-02f, -1.50424197e-01f, -2.16579899e-01f, 9.39017385e-02f, 1.52717486e-01f, -6.18246421e-02f, -1.43558264e-01f, 8.96583498e-02f, -1.00456364e-01f, 6.62283823e-02f,
  1.48423314e-01f, -1.62930518e-01f, -8.33367333e-02f, -2.36626901e-02f, 1.12335840e-02f, -2.61981875e-01f, 8.63234140e-03f, -1.25951454e-01f, -7.10969567e-02f, 8.08635429e-02f,
  1.37750793e-03f, 2.23689809e-01f, 1.03838360e-02f, 2.69148767e-01f, 8.73258859e-02f, 1.71155974e-01f, 2.05488220e-01f, 1.46691561e-01f, 1.93117261e-01f, 5.84749021e-02f,
  -7.61270225e-02f, 2.51663942e-02f, -5.77945001e-02f, -7.98974857e-02f, 1.40717685e-01f, -9.55617148e-03f, 3.21354792e-02f, -1.15485052e-02f, 7.89374672e-03f, 4.50806767e-02f,
  -3.42097059e-02f, 6.83591515e-02f, 7.45321140e-02f, -3.72331887e-02f, 9.95970070e-02f, 4.53079268e-02f, 6.55815005e-03f, -7.22160935e-02f, -2.35139746e-02f, -9.43436772e-02f,
  -7.19211325e-02f, 9.72102582e-03f, 4.24446277e-02f, 3.05170920e-02f, -5.76044656e-02f, 2.98517738e-02f, -8.16673860e-02f, 3.70806903e-02f, 1.16917687e-02f, 6.47406653e-02f,
  -1.22868456e-03f, 4.74251620e-02f, 4.49249595e-02f, 2.70961877e-02f, 7.36528933e-02f, -8.92821793e-03f, 3.13503221e-02f, 2.37197522e-02f, 1.82890594e-02f, -6.77509457e-02f,
  2.91497726e-02f, 6.60640970e-02f, -4.62560616e-02f, 2.14054566e-02f, -4.12456393e-02f, 4.52399021e-03f, -1.65033359e-02f, -4.07089554e-02f, -5.53956702e-02f, -3.84088121e-02f,
  -1.35192024e-02f, 7.28890151e-02f, -2.66196337e-02f, -5.88423805e-03f, -7.03786016e-02f, -1.03629649e-01f, -9.38667916e-03f, -1.03202527e-02f, 1.41332615e-02f, 6.75729737e-02f,
  -3.40309478e-02f, 1.28179984e-02f, 5.96266314e-02f, -1.35594455e-03f, -2.39605587e-02f, 8.14239383e-02f, -8.75466838e-02f, 7.09335431e-02f, -7.52713764e-03f, 1.55437943e-02f,
  4.06602630e-03f, -3.90904816e-03f, -5.47779016e-02f, 7.78525472e-02f, 4.15310636e-02f, 3.72613110e-02f, 3.57468836e-02f, 1.27238045e-02f, -1.66133065e-02f, 3.34164351e-02f,
  6.17223717e-02f, -6.69120103e-02f, 5.11340797e-02f, 9.91254821e-02f, -1.99191850e-02f, 8.26054066e-02f, 9.74657461e-02f, -6.16528988e-02f, -1.05750579e-02f, -1.41829299e-02f,
  -1.63876221e-01f, 2.26729095e-01f, -5.50495349e-02f, -1.38338432e-01f, -2.76352689e-02f, -8.97145569e-02f, -1.26978174e-01f, 9.26962271e-02f, 4.15446311e-02f, 1.13725901e-01f,
  4.72771451e-02f, 2.57299468e-02f, -1.50277708e-02f, 7.73183331e-02f, -1.80396110e-01f, -5.59469722e-02f, -5.10446168e-03f, 2.21869834e-02f, 1.21930176e-02f, 1.41894231e-02f,
  -1.31758079e-01f, -4.36095744e-02f, 2.94866413e-02f, 9.93870795e-02f, -2.18785573e-02f, 3.39591838e-02f, -8.25461149e-02f, 7.50842988e-02f, 8.46717432e-02f, 1.03846431e-01f,
  -1.32980525e-01f, -1.00838631e-01f, -1.04789972e-01f, -2.35731043e-02f, -1.42840371e-01f, -1.22683972e-01f, -1.29519403e-01f, 8.17535073e-02f, -1.01419568e-01f, -6.34132773e-02f,
  6.18517734e-02f, 2.59285755e-02f, -2.85140723e-02f, 1.53312515e-02f, -3.45504433e-02f, 4.28323224e-02f, 5.68662630e-03f, -1.23990234e-03f, -6.80203065e-02f, -2.66798330e-03f,
  1.02224983e-01f, -8.80982280e-02f, 2.48372462e-02f, -2.05450449e-02f, -1.35478359e-02f, -1.53308846e-02f, 8.77758488e-03f, 1.23179648e-02f, 3.97134200e-02f, 5.61206602e-03f,
  9.90246981e-03f, -4.62960266e-02f, 2.47812439e-02f, 5.48022762e-02f, -2.89577246e-02f, -1.79663431e-02f, -6.36277869e-02f, 7.87289143e-02f, 1.32220630e-02f, 6.06501065e-02f,
  6.75312877e-02f, -3.71583155e-03f, -3.74222398e-02f, 5.39307632e-02f, 6.99220225e-02f, -2.10608598e-02f, -7.84295276e-02f, -2.49772742e-02f, -8.90648216e-02f, 4.47566994e-02f,
  1.27084395e-02f, -2.26652343e-02f, -1.47455363e-02f, 5.25677279e-02f, 3.24175879e-02f, -4.67599854e-02f, 8.24536905e-02f, -2.99192090e-02f, -5.17087616e-02f, -3.40498574e-02f,
  -1.09469190e-01f, -4.06023897e-02f, -3.39720324e-02f, 3.21925655e-02f, 5.42072952e-02f, -1.02078222e-01f, -5.55684306e-02f, -1.96112972e-02f, -1.31627880e-02f, 3.77279855e-02f,
  -8.98707584e-02f, -8.83787945e-02f, 2.89791089e-04f, -6.70011193e-02f, -7.02599883e-02f, -8.14630017e-02f, -8.92608911e-02f, -8.10067356e-03f, 1.92054454e-02f, -3.75384018e-02f,
  -2.19204929e-02f, -6.51115403e-02f, -1.61758736e-02f, 3.18942815e-02f, -1.86776649e-02f, -7.57559761e-02f, -9.65810344e-02f, 2.74694506e-02f, -3.37609798e-02f, 1.11919153e-03f,
  -1.28025144e-01f, -1.89077239e-02f, 1.55428136e-02f, -1.30413964e-01f, 6.00363053e-02f, -6.01139106e-02f, 1.20482817e-01f, 3.00849285e-02f, 1.04735993e-01f, 5.52239530e-02f,
  -1.24013443e-02f, -1.22451738e-01f, 9.76236463e-02f, -9.59412903e-02f, -1.19250260e-01f, 3.46976668e-02f, -2.01770794e-02f, 1.56612527e-02f, 9.94929373e-02f, 2.27449602e-03f,
  5.87078892e-02f, -1.32615445e-03f, -3.05351950e-02f, -5.72164357e-02f, -1.09066255e-01f, -1.12754129e-01f, -6.53864816e-02f, -4.17615622e-02f, -1.57614812e-01f, -1.23949945e-01f,
  2.05111573e-03f, -1.27459675e-01f, 2.32089963e-02f, -6.74466416e-02f, -1.47411944e-02f, -8.33924115e-02f, -2.56393105e-03f, 3.20932269e-02f, 6.99260756e-02f, 2.78147664e-02f,
  1.09794401e-02f, -5.86723946e-02f, -9.27717462e-02f, 4.93197329e-02f, -2.38313116e-02f, -6.77134544e-02f, -8.54869559e-02f, 8.08271319e-02f, -1.94556434e-02f, -9.12504867e-02f,
  -7.70778805e-02f, -6.57773837e-02f, -8.83327574e-02f, 1.13466177e-02f, -5.61739951e-02f, 1.00733437e-01f, 5.22736348e-02f, -9.79824364e-02f, 1.33011607e-04f, 3.09903380e-02f,
  8.96859244e-02f, 8.21135789e-02f, -3.61401513e-02f, -1.19902473e-02f, 8.17733235e-04f, -6.70722649e-02f, -2.44513825e-02f, 5.00666834e-02f, 1.04906708e-01f, 5.46033606e-02f,
  2.73233149e-02f, -2.60861069e-02f, 3.01945601e-02f, 4.36301604e-02f, -7.58024976e-02f, 8.72580037e-02f, 2.94466894e-02f, -4.48175445e-02f, 8.50188658e-02f, -6.31854832e-02f,
  -7.98133984e-02f, -4.20383923e-02f, 1.05195343e-02f, -5.76368496e-02f, -1.59036741e-02f, 7.20144063e-02f, -2.42869500e-02f, 4.58169729e-03f, -7.24319145e-02f, -5.98604232e-02f,
  -1.12583786e-01f, -1.40780024e-02f, -2.93708816e-02f, -5.12273759e-02f, -2.13602856e-02f, 3.56807299e-02f, -8.71140137e-02f, 4.60960567e-02f, -9.79628414e-02f, -5.67513630e-02f,
  5.42795435e-02f, -1.76431015e-02f, -1.88113805e-02f, 7.23303854e-02f, -4.43376228e-02f, -2.15114243e-02f, 5.79733886e-02f, -3.22134160e-02f, 5.53704500e-02f, -6.34840354e-02f,
  2.80047692e-02f, -7.43050352e-02f, -2.55536530e-02f, 3.56025435e-02f, -6.69828728e-02f, 6.38813525e-02f, -8.44930336e-02f, -7.17537552e-02f, 5.54275997e-02f, -3.93003263e-02f,
  -2.05919221e-01f, 2.10564688e-01f, -2.88234875e-02f, -1.17843933e-01f, 4.40245606e-02f, -1.39263973e-01f, -2.00074658e-01f, -3.50511298e-02f, 4.00253721e-02f, 1.08395712e-02f,
  -9.44104120e-02f, -5.20677045e-02f, -1.36205032e-02f, -8.91897827e-02f, -9.18220580e-02f, 1.16964802e-01f, -1.04015239e-01f, -9.99469459e-02f, 8.21198970e-02f, -7.05985576e-02f,
  5.91791719e-02f, 3.93302478e-02f, 3.73198907e-03f, 1.55188814e-01f, -6.89741075e-02f, 1.45737035e-02f, -7.11404830e-02f, 4.08227257e-02f, -1.09227665e-01f, -1.58311091e-02f,
  -1.05256453e-01f, 1.88941564e-02f, -1.39029264e-01f, 8.82278848e-03f, -1.07960412e-02f, 4.38980982e-02f, -1.04290776e-01f, -1.02024913e-01f, -8.78638178e-02f, 6.48169741e-02f,
  5.46630360e-02f, 3.68635952e-02f, 2.61637624e-02f, -4.69786674e-02f, 5.85408546e-02f, -6.04974814e-02f, 7.87519068e-02f, 3.12989280e-02f, -5.01144826e-02f, 2.98265722e-02f,
  3.91133055e-02f, -1.68982074e-02f, -6.09949930e-03f, 2.20705811e-02f, 5.23357540e-02f, -3.16951126e-02f, -7.22839013e-02f, 5.87338544e-02f, -9.06044710e-03f, -8.21026266e-02f,
  7.88950622e-02f, -2.15566847e-02f, -5.85870594e-02f, 8.75898600e-02f, -1.98068423e-03f, -4.57118638e-02f, 2.90751383e-02f, -2.49696281e-02f, 5.07138148e-02f, 1.26937244e-04f,
  -6.51961043e-02f, 7.42812082e-02f, 3.21589559e-02f, 2.79374942e-02f, 4.64846715e-02f, 1.38493348e-02f, -7.77019933e-02f, 2.86710747e-02f, -3.22122276e-02f, -9.93817952e-03f,
  7.43678957e-02f, 5.27335424e-03f, 4.72226217e-02f, 4.48569134e-02f, 1.29495524e-02f, 5.29064760e-02f, -2.53093299e-02f, 7.58537948e-02f, -3.97730991e-02f, -2.20957268e-02f,
  -3.84067148e-02f, -6.27130866e-02f, -5.52980043e-02f, 5.48943020e-02f, -6.52737841e-02f, -9.61771607e-03f, -9.42699090e-02f, -1.07531436e-01f, -3.58162224e-02f, 2.43295878e-02f,
  5.45974709e-02f, -2.88186390e-02f, 3.36023867e-02f, 7.50228912e-02f, -9.70201939e-02f, 1.60173997e-02f, -3.06729488e-02f, -8.24806243e-02f, 1.98177658e-02f, 1.31874951e-03f,
  -3.48743726e-03f, 9.67349485e-03f, -1.00797124e-01f, 7.50129521e-02f, -9.50461775e-02f, -7.60855079e-02f, -4.47198786e-02f, 1.74328797e-02f, -1.57122612e-02f, 5.09046651e-02f,
  1.21184595e-01f, -1.10936902e-01f, 6.86345324e-02f, 9.03717950e-02f, 8.81872922e-02f, 1.07210420e-01f, 4.37281169e-02f, -8.03907812e-02f, 1.41474595e-02f, -8.45595002e-02f,
  -6.41075745e-02f, 3.46817970e-02f, -4.12097573e-02f, -9.31798071e-02f, 1.48955463e-02f, -2.47522872e-02f, -1.10618725e-01f, 7.96825439e-02f, 3.03005637e-03f, 3.70553508e-02f,
  -3.81219760e-02f, 3.49850506e-02f, -9.50574204e-02f, -3.29785161e-02f, 2.50607636e-02f, -6.77164048e-02f, 6.13043904e-02f, 2.67373696e-02f, -1.60891190e-02f, 1.07553646e-01f,
  4.45002615e-02f, -1.08221941e-01f, 1.12644099e-02f, -2.96405405e-02f, 2.03475785e-02f, 1.81736797e-02f, 3.62591222e-02f, 1.18021846e-01f, 8.33961368e-02f, -7.17347371e-04f,
  -2.23721899e-02f, -3.62778716e-02f, 3.69780660e-02f, 4.17943262e-02f, 5.76064363e-02f, 2.95387954e-02f, 2.64875572e-02f, -8.29600915e-02f, -8.80223513e-02f, -8.74854401e-02f,
  4.66174781e-02f, -1.57749336e-02f, -9.89559758e-03f, 8.79863575e-02f, 9.64327306e-02f, -5.69613092e-02f, -4.95341457e-02f, 4.37085666e-02f, 8.07310268e-02f, -3.09011023e-02f,
  6.38903603e-02f, 6.54717982e-02f, -3.50935920e-03f, -1.07933646e-02f, 8.25347304e-02f, 3.22678685e-02f, -3.12042776e-02f, -1.76796075e-02f, 8.83756429e-02f, 1.61368754e-02f,
  5.29503403e-03f, -3.01661287e-02f, 3.58469747e-02f, 1.37307597e-02f, -1.10907909e-02f, -2.35062726e-02f, 9.30782259e-02f, 5.61455898e-02f, 5.09581119e-02f, -1.03263706e-02f,
  4.35717124e-03f, 7.29066432e-02f, -8.19384158e-02f, 7.46290088e-02f, -9.89344064e-03f, 2.28561703e-02f, -6.94647208e-02f, -8.60161800e-03f, -1.72712989e-02f, -2.37258654e-02f,
  -1.24040060e-02f, -4.37383167e-02f, 7.67944800e-03f, -6.63721859e-02f, -4.60246298e-03f, 4.22081575e-02f, 1.94202513e-02f, 1.64676942e-02f, 1.77795868e-02f, -7.87467808e-02f,
  -8.15491080e-02f, -4.04428691e-02f, -3.69892381e-02f, 9.35643259e-03f, -6.56862333e-02f, -5.69516001e-03f, 6.19084239e-02f, -7.59641528e-02f, -1.73212774e-02f, 1.44062387e-02f,
  -9.09975618e-02f, -2.97189020e-02f, -3.04281358e-02f, 9.36648548e-02f, 2.28917189e-02f, -2.29659937e-02f, -7.84031004e-02f, 2.89524868e-02f, -6.57426938e-02f, 5.78167737e-02f,
  -1.03027374e-01f, 3.15728337e-02f, -5.36372587e-02f, -1.50750969e-02f, -5.71083240e-02f, -1.53187901e-01f, 3.83364521e-02f, -3.21976058e-02f, -1.01272590e-01f, 2.09844131e-02f,
  7.62567669e-02f, -5.72676249e-02f, 1.67710692e-01f, -8.40375274e-02f, 1.44212982e-02f, 1.06293991e-01f, -8.92676786e-03f, -6.17732927e-02f, -9.94003937e-02f, 5.59967272e-02f,
  -5.42372800e-02f, 1.01791605e-01f, 1.30868927e-01f, 1.15180962e-01f, -3.38094458e-02f, 1.09790951e-01f, 9.03148949e-02f, 3.45976725e-02f, -2.60892268e-02f, -6.01987615e-02f,
  -5.91751980e-03f, 1.56498551e-01f, 8.69490057e-02f, -4.77196351e-02f, 3.45833451e-02f, -6.80163428e-02f, 5.26500493e-02f, 5.11912480e-02f, 8.16696733e-02f, -2.24644896e-02f,
  7.75945783e-02f, -5.31376041e-02f, -3.62188406e-02f, 6.91325963e-02f, -5.06372377e-02f, -2.78237537e-02f, -2.74916440e-02f, -1.13558974e-02f, -8.56917650e-02f, -1.91520248e-02f,
  8.36623386e-02f, 9.43298265e-03f, -4.47460227e-02f, -8.42184797e-02f, -2.94798869e-03f, 5.33834696e-02f, 1.46737127e-02f, 6.08954877e-02f, 1.96790462e-03f, -2.14290153e-02f,
  -1.63990464e-02f, 1.51177235e-02f, 8.33667889e-02f, -4.00515907e-02f, -3.30858715e-02f, 6.71017393e-02f, -8.70432407e-02f, 3.53646576e-02f, 2.34511085e-02f, 7.43640214e-02f,
  9.81965363e-02f, 1.06716426e-02f, -4.27988591e-03f, -5.02667055e-02f, 2.20177341e-02f, 3.73578444e-02f, 5.61563447e-02f, 8.24011788e-02f, -6.11721165e-03f, -5.90911619e-02f,
  -5.63228279e-02f, 6.22804090e-02f, 3.23598459e-02f, -2.14568954e-02f, -6.78452626e-02f, 6.91373572e-02f, 3.04450784e-02f, -8.04707706e-02f, -6.33808151e-02f, 2.80456748e-02f,
  -3.30964774e-02f, 1.66822597e-01f, 2.89218128e-02f, -7.19473809e-02f, -2.46533267e-02f, 4.65659797e-02f, -5.34362681e-02f, -8.59602690e-02f, 9.69915092e-02f, 1.98040698e-02f,
  3.83943766e-02f, 8.71320143e-02f, -1.49580156e-02f, 8.23511705e-02f, 7.69266766e-03f, -5.37391379e-02f, -1.79830622e-02f, -3.11963838e-02f, 8.39390010e-02f, 8.91884714e-02f,
  1.87029559e-02f, 7.50042200e-02f, -5.53981066e-02f, -7.53103048e-02f, 5.74705489e-02f, 8.41539651e-02f, -6.30880669e-02f, -2.22386848e-02f, 6.66261315e-02f, -9.03905556e-03f,
  -8.67834538e-02f, 7.69959837e-02f, 1.37568964e-02f, -3.78787480e-02f, 6.00496167e-03f, -9.78549495e-02f, -5.22802472e-02f, 1.63615271e-01f, -8.43253508e-02f, -5.19583635e-02f,
  2.72774231e-02f, -2.34021731e-02f, 9.68337953e-02f, -1.78939309e-02f, -1.44406170e-01f, -3.03858221e-02f, -1.52033225e-01f, -1.56409085e-01f, 9.91060212e-02f, 1.08228050e-01f,
  6.96012154e-02f, 1.19963706e-01f, 4.64834459e-03f, 2.09281385e-01f, 4.76206280e-02f, 2.55336016e-02f, 4.89063524e-02f, 1.55848905e-01f, 2.08059251e-02f, -1.49753625e-02f,
  3.25686596e-02f, 4.82372530e-02f, -3.88144031e-02f, -6.54812828e-02f, -1.00513780e-02f, 2.47528777e-02f, -3.36073264e-02f, 4.15719859e-03f, -7.73285283e-03f, -3.39048803e-02f,
  3.58787701e-02f, 6.50522346e-03f, -9.11387205e-02f, -6.46245405e-02f, 1.14701157e-02f, 8.94732326e-02f, -4.45285477e-02f, -5.01803197e-02f, 9.63667855e-02f, -1.70703307e-02f,
  -5.30521460e-02f, -1.03623122e-02f, -5.80131449e-02f, -1.38389682e-02f, -9.01618786e-03f, 4.84499782e-02f, -8.29373896e-02f, -2.40273420e-02f, -7.48164132e-02f, 6.51220307e-02f,
  6.34962469e-02f, -1.20630719e-01f, -5.21539412e-02f, 2.18338165e-02f, -7.34851882e-02f, 1.45116430e-02f, -2.42338516e-02f, -7.95208812e-02f, 1.32205226e-02f, -8.80013406e-02f,
  -4.46330719e-02f, -6.93287849e-02f, 7.58966729e-02f, -9.04846117e-02f, -9.01574343e-02f, 3.31860706e-02f, -3.27862762e-02f, 4.75858226e-02f, -1.93464593e-03f, 6.73849210e-02f,
  -5.99341057e-02f, 4.86168265e-02f, -5.08769415e-02f, 3.83533090e-02f, -2.47406196e-02f, 1.64154004e-02f, 7.90092275e-02f, 6.89688325e-02f, 1.45170959e-02f, 6.13192879e-02f,
  -8.40017870e-02f, 7.83168897e-02f, 9.78113934e-02f, -6.17581494e-02f, 2.50007790e-02f, 8.88940785e-03f, -6.36034459e-02f, 8.46068412e-02f, -1.70603674e-02f, -7.52573088e-02f,
  3.32623662e-04f, -5.22339493e-02f, 2.72252550e-03f, 9.61371884e-02f, -4.92170043e-02f, 7.30210245e-02f, 6.66007549e-02f, 5.53464424e-03f, 9.92049463e-03f, 6.20517554e-03f,
  -4.99800667e-02f, -1.26300752e-03f, 5.52707873e-02f, 8.59116539e-02f, -8.93132463e-02f, -2.14545093e-02f, -6.01579025e-02f, -3.95556986e-02f, 4.28169370e-02f, 4.39488292e-02f,
  -9.40903053e-02f, 8.41843486e-02f, 8.00607353e-02f, 1.37942821e-01f, -1.51237354e-01f, -1.38888195e-01f, 3.14387903e-02f, -6.01398461e-02f, -1.39199710e-02f, 9.92899686e-02f,
  5.67770489e-02f, 2.94516813e-02f, -3.79128531e-02f, 6.73582628e-02f, -5.60318008e-02f, 6.49217740e-02f, 5.86320385e-02f, -5.70608489e-02f, -9.82453451e-02f, 6.28706962e-02f,
  7.99613521e-02f, 6.94223568e-02f, 2.96971295e-03f, -2.59239376e-02f, 8.71744007e-02f, -1.29741821e-02f, 1.14257991e-01f, 5.16530834e-02f, 1.00208431e-01f, 6.49709851e-02f,
  -1.04870554e-02f, 9.91089717e-02f, 1.69930700e-02f, 6.40206933e-02f, -5.89229772e-03f, -6.93543330e-02f, 7.39875212e-02f, 5.27249426e-02f, 6.94552734e-02f, -4.79138456e-02f,
  2.00813618e-02f, -4.76899669e-02f, 1.12479925e-02f, -6.15785643e-02f, -2.37951893e-02f, 8.19621012e-02f, -2.33364683e-02f, 1.84744485e-02f, -4.69585396e-02f, 3.33301239e-02f,
  -1.94171779e-02f, 6.71661133e-03f, 4.90623116e-02f, 2.46235682e-03f, -9.59611982e-02f, 5.16948700e-02f, -1.80810764e-02f, 4.15165499e-02f, -5.52437315e-03f, 5.01328446e-02f,
  -6.96776360e-02f, 1.20541826e-02f, -6.21969029e-02f, -6.52702004e-02f, 1.23780146e-02f, -2.58550234e-02f, 2.07807943e-02f, -6.27343357e-02f, 5.85052483e-02f, 4.03306745e-02f,
  1.07358480e-02f, 3.51758627e-03f, 4.01656218e-02f, 2.90040672e-02f, -3.78344841e-02f, 7.47681335e-02f, 2.96432078e-02f, 7.82369524e-02f, -4.13123555e-02f, -7.82320350e-02f,
  -6.97032511e-02f, -5.45793697e-02f, -1.87120109e-03f, 3.24897729e-02f, 1.58433453e-03f, -3.97725627e-02f, -7.23545328e-02f, 1.74548700e-02f, 7.11522922e-02f, -1.43438904e-02f,
  -2.99038347e-02f, 1.84261147e-02f, 1.87818171e-03f, -7.59121701e-02f, -4.18203287e-02f, -3.71496775e-03f, 9.44571942e-02f, -6.52757473e-03f, 6.78982586e-02f, 2.91022230e-02f,
  -4.21986282e-02f, 4.12546806e-02f, -9.24291313e-02f, -5.61071448e-02f, 7.05970172e-03f, -1.89420432e-02f, 2.36410871e-02f, 7.63214827e-02f, -2.04782095e-02f, 7.70711079e-02f,
  8.99085253e-02f, 4.62162644e-02f, -4.40561548e-02f, 2.43212692e-02f, 8.90266076e-02f, -5.07683195e-02f, 2.11704150e-02f, 5.80481514e-02f, -6.13922216e-02f, 5.60934804e-02f,
  -3.90127301e-02f, -3.25548738e-01f, -2.98882779e-02f, -5.56427911e-02f, 6.42335564e-02f, 1.72753066e-01f, 1.54329062e-01f, -1.48792684e-01f, -2.14489654e-01f, -1.66808918e-01f,
  3.39518748e-02f, 6.17926270e-02f, 7.29035810e-02f, -2.24720076e-01f, 1.89155146e-01f, -9.86382812e-02f, -1.63888678e-01f, 1.12704322e-01f, -1.15018919e-01f, 2.12320890e-02f,
  6.36490136e-02f, 8.10013909e-04f, 1.04685813e-01f, -1.30686998e-01f, -6.99136034e-02f, 2.95450315e-02f, 1.70202717e-01f, 1.29370585e-01f, -7.80767053e-02f, 6.00336157e-02f,
  -2.60100234e-02f, -1.48540169e-01f, -9.00739338e-03f, -4.78096791e-02f, 5.87026253e-02f, 1.21299684e-01f, 1.57352462e-01f, 5.04806228e-02f, 2.43065152e-02f, 8.94240886e-02f,
  -2.53890525e-03f, 1.27854496e-02f, -6.25370666e-02f, -7.91144446e-02f, -1.36035727e-02f, -1.08122304e-01f, -1.17919534e-01f, 7.78659061e-03f, -3.70285101e-02f, -5.22831222e-03f,
  6.29151091e-02f, 1.55060012e-02f, 4.65034656e-02f, -5.95399924e-02f, -6.20739497e-02f, -2.74123624e-02f, -8.67157131e-02f, 1.05414383e-01f, -9.28177387e-02f, -1.52191555e-03f,
  -2.79604960e-02f, 2.05906127e-02f, -4.52412479e-02f, -8.51373225e-02f, 7.22630695e-02f, 2.07322910e-02f, 3.98410968e-02f, -2.46117283e-02f, -1.31134391e-02f, 6.00336958e-03f,
  -4.31971960e-02f, -5.27258106e-02f, -9.33864191e-02f, -6.46697823e-03f, 5.18197007e-02f, -7.76913529e-03f, 6.51972145e-02f, -1.93165150e-03f, 6.74199462e-02f, 1.26380892e-02f,
  -8.26662779e-02f, -4.21580039e-02f, -6.30253106e-02f, 9.22442302e-02f, -3.94896753e-02f, 6.69445768e-02f, 1.05765443e-02f, 6.34842217e-02f, 7.88036436e-02f, 9.76855531e-02f,
  -5.53037301e-02f, 1.75369997e-02f, -4.05070148e-02f, -5.78022525e-02f, -5.23371212e-02f, 5.89381196e-02f, -2.24066935e-02f, 2.28444897e-02f, 2.04212684e-02f, 1.82915404e-02f,
  1.05278790e-01f, 3.53010334e-02f, -3.98709141e-02f, 2.52844933e-02f, -8.10071155e-02f, -1.04161017e-01f, -3.53971720e-02f, 3.06188185e-02f, -6.34055361e-02f, -5.07073440e-02f,
  4.30585630e-02f, 4.58881306e-03f, 1.60317961e-02f, -6.98765144e-02f, -1.09022424e-01f, 1.10154852e-01f, -2.40059663e-03f, 1.37398168e-02f, 5.07783610e-03f, 7.72989243e-02f,
  1.42578676e-01f, 7.40309879e-02f, 4.49634865e-02f, 1.81659326e-01f, -6.45262422e-03f, -5.38007841e-02f, -2.16383543e-02f, 1.26846701e-01f, 3.89166437e-02f, -9.84602720e-02f,
  5.60966171e-02f, -2.82270554e-03f, -1.44396201e-01f, 1.72800735e-01f, 1.50532007e-01f, 4.50740457e-02f, 1.32020891e-01f, 4.95614447e-02f, 8.59327465e-02f, 1.97035179e-01f,
  1.63007438e-01f, 1.41025603e-01f, 1.84171245e-01f, 1.81028008e-01f, 8.35119486e-02f, 1.41927466e-01f, 1.43059418e-01f, 2.71930546e-02f, 1.80861920e-01f, -1.77184679e-02f,
  8.11958089e-02f, 7.47536570e-02f, 4.08489816e-02f, 3.09359864e-03f, 1.06027704e-02f, 5.57380021e-02f, 1.53711988e-02f, -9.71149504e-02f, -6.76400661e-02f, 9.56815779e-02f,
  1.29255457e-02f, -7.32508600e-02f, 1.17390811e-01f, -7.87327625e-03f, -8.00445601e-02f, 3.45818922e-02f, 4.11327891e-02f, 4.82563898e-02f, 6.50145933e-02f, 9.94170308e-02f,
  -4.85855937e-02f, 5.19068725e-02f, -2.21382547e-02f, -9.04678181e-02f, -1.27544524e-02f, -1.12606883e-01f, -8.54300112e-02f, 4.30100374e-02f, 2.10994482e-02f, 1.03495188e-01f,
  6.26295879e-02f, 2.09846068e-02f, -8.04257989e-02f, -1.24197546e-02f, -3.91469337e-02f, -4.76131178e-02f, 4.69141379e-02f, -1.53239463e-02f, 3.32122780e-02f, 2.74589062e-02f,
  -2.66423356e-02f, 8.22611079e-02f, 8.30904953e-03f, -3.07947807e-02f, 1.71578638e-02f, -1.98575780e-02f, -9.30906832e-02f, -9.27789719e-04f, 5.85558042e-02f, 8.20781812e-02f,
  -9.21446159e-02f, 1.98712647e-02f, 6.42575696e-02f, -5.98787740e-02f, 3.50750349e-02f, 3.72320637e-02f, 3.10659949e-02f, 6.02110028e-02f, -6.34971634e-02f, -6.76348247e-03f,
  4.86853532e-02f, 6.75853267e-02f, 7.55176507e-03f, 3.72389443e-02f, 1.19073400e-02f, 8.63782018e-02f, -1.02971857e-02f, 2.18863860e-02f, -2.79598664e-02f, 7.82734528e-02f,
  -5.59907369e-02f, -1.04284413e-01f, 4.11141403e-02f, 5.61202168e-02f, 6.93343729e-02f, -2.53853165e-02f, 2.50800494e-02f, -6.61210865e-02f, -3.04019805e-02f, 4.18620072e-02f,
  -5.73647656e-02f, -1.28037157e-02f, 9.61028226e-03f, -7.47043267e-02f, 6.08595423e-02f, -3.53424549e-02f, -1.79563053e-02f, -6.57530427e-02f, -6.91103414e-02f, 4.29509990e-02f,
  1.12639815e-01f, 9.77796614e-02f, 2.37497076e-01f, 1.72219411e-01f, -1.46316886e-01f, -2.03445971e-01f, -2.05553263e-01f, 7.80620473e-03f, 1.06471099e-01f, -5.77692799e-02f,
  -9.91867408e-02f, 2.95811981e-01f, -1.08400047e-01f, -2.28743311e-02f, -8.15633386e-02f, -9.51905921e-02f, -1.61083400e-01f, -1.97768528e-02f, 1.06188670e-01f, -2.32005809e-02f,
  -2.58403420e-02f, -1.81996986e-01f, 1.02469370e-01f, -4.45074551e-02f, 7.55461231e-02f, 1.89320296e-01f, -5.84840477e-02f, 1.03353998e-02f, -5.29297031e-02f, 1.02650216e-02f,
  3.83470543e-02f, 1.00789450e-01f, 2.04668213e-02f, 3.29941399e-02f, -9.18156058e-02f, -2.41955910e-02f, -2.45216135e-02f, 7.08141103e-02f, -7.78116519e-04f, 1.60221290e-02f,
  5.34008369e-02f, -6.49409965e-02f, 8.60983133e-02f, -5.06048314e-02f, -5.60282804e-02f, -1.24297654e-02f, 4.84909117e-02f, 3.62992473e-02f, -3.00671607e-02f, 3.37885991e-02f,
  5.70790768e-02f, -5.87872788e-02f, 9.62935854e-04f, 4.37952280e-02f, 4.76075299e-02f, -2.58651525e-02f, 5.09278812e-02f, 5.43600433e-02f, 6.41862489e-03f, 2.85304640e-03f,
  7.14736432e-02f, -9.87476483e-02f, -7.48788044e-02f, 3.24141234e-02f, -4.74800244e-02f, -7.90860951e-02f, 7.78331980e-02f, -6.12666570e-02f, 5.40984832e-02f, 5.73443249e-02f,
  -8.85298252e-02f, 9.18119475e-02f, 4.15897407e-02f, -9.49578732e-02f, 8.34823325e-02f, 8.69126096e-02f, 2.11209543e-02f, -5.53404279e-02f, -4.17200066e-02f, 7.99012091e-03f,
  5.73337413e-02f, -5.91784343e-02f, 4.33572382e-02f, -2.57341247e-02f, -2.02680416e-02f, 3.62438187e-02f, 4.12899964e-02f, 1.95102263e-02f, 6.83716610e-02f, -5.15562259e-02f,
  -8.40305090e-02f, 9.11207423e-02f, -3.11906710e-02f, -3.98402214e-02f, 7.66470656e-02f, 7.01272488e-02f, -8.31853375e-02f, -2.03522760e-02f, 9.49120335e-03f, -5.40437400e-02f,
  -2.61877626e-02f, 3.31258439e-02f, 5.16078509e-02f, -4.33802865e-02f, 3.23479958e-02f, -3.83801758e-02f, 3.53403427e-02f, 9.10557434e-03f, -8.98342356e-02f, -1.26721440e-02f,
  1.36459945e-02f, -6.25227988e-02f, -6.81910738e-02f, -6.56310469e-02f, -1.97136141e-02f, 5.10820672e-02f, 4.33288887e-02f, -4.71931584e-02f, 2.74714231e-02f, 5.32834455e-02f,
  -7.40090236e-02f, -1.88615113e-01f, 8.98189694e-02f, 1.48105621e-01f, 1.90457664e-02f, -6.18085302e-02f, -7.97734037e-02f, -8.48399326e-02f, 2.45217439e-02f, -1.76956773e-01f,
  1.01492986e-01f, -2.08572373e-02f, -7.32320994e-02f, 1.65242448e-01f, 1.11118853e-01f, 5.59256673e-02f, 2.59628743e-02f, -4.24408317e-02f, -4.74459305e-02f, -1.36469724e-02f,
  1.17420159e-01f, 1.78110197e-01f, 6.18119985e-02f, 1.09295070e-01f, -1.33767044e-02f, 1.02288805e-01f, 1.31786749e-01f, 1.78173501e-02f, 1.40911356e-01f, 6.61236048e-02f,
  -4.82155979e-02f, 5.95174544e-02f, -3.30853947e-02f, -3.65378670e-02f, -1.00049362e-01f, -3.61878611e-03f, 5.47828786e-02f, 9.63303968e-02f, 9.93418172e-02f, -1.13811269e-02f,
  -7.84113407e-02f, 2.72048395e-02f, 8.26553255e-03f, 6.03735866e-03f, -8.97578970e-02f, 4.17828746e-02f, 7.08554909e-02f, -9.40593332e-02f, -6.68428615e-02f, -5.57950251e-02f,
  -8.07551518e-02f, -6.06003404e-02f, -6.88331127e-02f, -5.81767410e-02f, 1.52953379e-02f, -2.70140003e-02f, 3.73581052e-02f, -8.98273811e-02f, -4.36274894e-02f, 3.97418141e-02f,
  5.64686358e-02f, 6.00499287e-02f, -5.14407046e-02f, 1.90280238e-03f, 1.07749812e-02f, -5.13844676e-02f, -2.03869846e-02f, -9.16067103e-04f, -1.90618783e-02f, -1.10212350e-02f,
  5.48470840e-02f, 6.29265755e-02f, -6.04546554e-02f, 6.95774611e-03f, 7.18024746e-02f, -3.49915065e-02f, -4.16607298e-02f, -7.72218853e-02f, -6.28148168e-02f, 4.65145856e-02f,
  2.00198330e-02f, 8.60750675e-02f, -4.24992479e-02f, 4.28265743e-02f, 6.19000383e-02f, 6.81504980e-02f, 3.52649763e-02f, -6.36348426e-02f, -2.15180852e-02f, 4.30321466e-04f,
  -1.37714624e-01f, -1.38977081e-01f, 2.62460578e-02f, 1.09906858e-02f, -6.03046604e-02f, -4.56055161e-03f, 4.25397716e-02f, -1.02200899e-02f, 4.61147688e-02f, -4.37333807e-02f,
  -5.69493212e-02f, -4.38573398e-02f, -3.41746248e-02f, -3.11341565e-02f, 2.71926019e-02f, 5.36086187e-02f, -8.72031301e-02f, -3.08918823e-02f, -2.36784909e-02f, 5.70507981e-02f,
  -3.28398086e-02f, -5.02165705e-02f, 6.41626343e-02f, 4.69485223e-02f, 2.91211018e-03f, 7.58201107e-02f, 6.15215488e-02f, 6.94592744e-02f, -4.87621762e-02f, -2.22897511e-02f,
  5.91670536e-02f, -5.38430661e-02f, 2.03976855e-01f, 1.92154441e-02f, -1.03293642e-01f, 1.02173381e-01f, 6.00559376e-02f, 7.53449872e-02f, -2.36309599e-02f, -9.75499153e-02f,
  2.34724861e-02f, 8.95792246e-02f, 9.40019935e-02f, -1.00408336e-02f, 2.46524974e-03f, 9.09197628e-02f, 7.00057819e-02f, -4.11677584e-02f, -3.20258574e-03f, -9.76353511e-02f,
  8.98026004e-02f, -1.24732688e-01f, 5.12048900e-02f, -1.37106523e-01f, -1.51176965e-02f, 3.57365124e-02f, -7.20196813e-02f, 1.01507604e-01f, 3.83305587e-02f, -5.03273308e-02f,
  2.02104868e-03f, -1.03148952e-01f, 1.46767255e-02f, 4.92387712e-02f, -3.37744877e-02f, 2.43234355e-02f, 3.94243468e-03f, -9.56400260e-02f, -1.11119971e-02f, -6.00290075e-02f,
  -4.58039809e-03f, 3.84939983e-02f, -3.29835378e-02f, -1.85688008e-02f, 1.60926525e-02f, -6.38841465e-02f, 4.23538797e-02f, -1.94579586e-02f, 7.46446401e-02f, 1.14937320e-01f,
  2.01209188e-02f, 4.57527786e-02f, 1.05872333e-01f, 1.85168013e-02f, -6.02600947e-02f, 4.24353965e-02f, 1.05090365e-02f, 3.24177295e-02f, 2.17816681e-02f, 1.12632895e-03f,
  -7.11555174e-03f, -1.85120609e-02f, 6.46655262e-02f, 7.28335977e-02f, -3.77217308e-03f, -4.88022417e-02f, 6.84148893e-02f, 8.17434043e-02f, 3.49383913e-02f, 5.70948832e-02f,
  -3.60902026e-02f, 9.14218351e-02f, 4.37344164e-02f, 4.93409000e-02f, -3.47085670e-02f, -2.69718543e-02f, 3.77739258e-02f, 4.37863320e-02f, 6.89149052e-02f, 6.93260208e-02f,
  -7.20919818e-02f, 4.38653529e-02f, 1.64678227e-02f, 2.16883793e-02f, -1.58860683e-02f, -1.67494249e-02f, 7.05253109e-02f, 4.77351211e-02f, 2.14577392e-02f, -8.29686001e-02f,
  -4.38672528e-02f, -1.19542979e-01f, -4.71231937e-02f, -7.90677369e-02f, 2.07188819e-02f, -9.22488719e-02f, -1.07896604e-01f, -5.68677410e-02f, 3.75243351e-02f, -2.08569895e-02f,
  6.21473696e-03f, -7.00666830e-02f, -5.96239083e-02f, -2.71737576e-02f, -7.01889768e-03f, 5.88190160e-04f, 1.94661487e-02f, 2.16029264e-04f, -5.03446758e-02f, 1.65471826e-02f,
  -1.81611329e-02f, -5.56617081e-02f, 1.68259032e-02f, -7.27647468e-02f, 3.26172635e-02f, 5.68002723e-02f, -3.86900790e-02f, 4.39211614e-02f, -2.68636700e-02f, 7.77871013e-02f,
  -8.32903609e-02f, -3.34562734e-02f, -5.54426499e-02f, -1.04512516e-02f, 7.42726326e-02f, 1.74828440e-01f, -1.37857515e-02f, -5.07512093e-02f, -4.65767495e-02f, 3.01219597e-02f,
  6.62999749e-02f, -9.04738605e-02f, -1.09808892e-01f, 2.74703324e-01f, 1.74947128e-01f, 4.60959226e-02f, 2.05896303e-01f, 1.85449049e-01f, -8.29694569e-02f, 4.10173312e-02f,
  9.72710699e-02f, 1.51098967e-01f, -5.26802056e-02f, 1.41176447e-01f, 8.33684951e-02f, -4.29777279e-02f, 8.31253827e-03f, -8.96476731e-02f, 1.83523268e-01f, 1.68246880e-01f,
  1.00330316e-01f, -7.38658234e-02f, -3.62100676e-02f, -8.89580101e-02f, -6.58884412e-03f, 2.21234988e-02f, -2.16657314e-02f, -1.35625256e-02f, -1.69164445e-02f, -5.26162833e-02f,
  3.23289074e-02f, 6.22191513e-03f, 5.15680127e-02f, 1.51576186e-02f, -8.30513015e-02f, 2.69779358e-02f, 1.92975029e-02f, 2.10718885e-02f, -5.54199032e-02f, -9.39883515e-02f,
  -1.09282821e-01f, 2.02105176e-02f, -2.31769960e-02f, -4.55770455e-03f, 2.35835388e-02f, -4.78161909e-02f, 9.22060199e-03f, 4.51210849e-02f, 3.78302597e-02f, -4.25686911e-02f,
  -6.89724013e-02f, -9.12808627e-02f, -7.67208263e-02f, -1.03992375e-03f, -2.03350242e-02f, 5.38612120e-02f, 5.87390251e-02f, -2.10519955e-02f, 3.12776230e-02f, 1.19984318e-02f,
  7.27128163e-02f, 8.16007778e-02f, 7.00051114e-02f, -7.49133080e-02f, -3.59669216e-02f, -2.71173138e-02f, 4.51267287e-02f, 1.63773466e-02f, 2.67709349e-03f, 5.28933555e-02f,
  -3.57140903e-03f, 9.27200615e-02f, 1.83713809e-03f, 4.18655537e-02f, -6.45707771e-02f, 7.85499718e-03f, 2.11735759e-02f, 6.88158572e-02f, 7.01854676e-02f, 5.17718345e-02f,
  -2.87254583e-02f, 7.12916404e-02f, 4.19090800e-02f, -6.13293909e-02f, 7.84616843e-02f, 1.00918300e-01f, -5.27430931e-03f, -3.37444246e-02f, 3.52158546e-02f, -7.04655424e-02f,
  -8.70561823e-02f, -9.98219196e-03f, 3.22039723e-02f, -4.04758230e-02f, 5.69705218e-02f, 3.75025794e-02f, -7.63134509e-02f, 4.15666625e-02f, 1.01402856e-01f, 1.10867647e-02f,
  2.31642090e-02f, -3.98850441e-02f, 2.28576884e-02f, -8.61667283e-03f, -3.01552713e-02f, -3.99961621e-02f, 6.73877597e-02f, -1.47785724e-03f, -2.80708168e-02f, 4.19240780e-02f,
  1.26492353e-02f, -2.07981348e-01f, 1.66429013e-01f, 1.80900723e-01f, 6.47843676e-03f, 1.15762927e-01f, 1.74931705e-01f, -7.24553317e-02f, 5.12222089e-02f, -1.53949663e-01f,
  3.85601074e-02f, 1.05497763e-02f, 6.96056783e-02f, 2.21682638e-02f, 2.60251701e-01f, 1.60997540e-01f, -5.24231680e-02f, 6.56223949e-03f, 1.23414246e-03f, -6.75810799e-02f,
  8.97532180e-02f, -4.42161635e-02f, 8.07990804e-02f, -2.00963199e-01f, -8.93374756e-02f, -1.55283377e-01f, -1.84776150e-02f, 1.45339713e-01f, -1.54821977e-01f, -2.36359295e-02f,
  -9.73568559e-02f, -3.74051593e-02f, -9.01035964e-02f, 4.32679653e-02f, -2.53489912e-02f, -8.25123191e-02f, 3.31029445e-02f, 1.27223566e-01f, 3.17667238e-02f, 2.76811123e-02f,
  -7.62372836e-02f, -3.68012786e-02f, -9.70942453e-02f, 6.00115508e-02f, -2.71065570e-02f, -9.50658023e-02f, 2.25008558e-02f, -3.40319052e-03f, 2.12983582e-02f, 1.22009953e-02f,
  -3.52123119e-02f, -3.58612761e-02f, -3.96947935e-02f, 3.72765586e-02f, -1.93691812e-02f, 5.22518717e-02f, 2.46249307e-02f, 9.58747938e-02f, 3.46508529e-03f, 2.32205745e-02f,
  -4.62510847e-02f, 1.76308341e-02f, -6.52679354e-02f, 2.30745543e-02f, -6.12489395e-02f, -7.97474608e-02f, -9.09464248e-03f, 5.98915406e-02f, -4.56316210e-02f, 6.50734752e-02f,
  -1.01189464e-01f, -7.21745715e-02f, 5.48143201e-02f, -8.21539983e-02f, -1.57529749e-02f, -3.33576761e-02f, -5.83639368e-02f, -2.18702145e-02f, -7.04994006e-03f, -4.57006469e-02f,
  7.58200139e-03f, 6.16506822e-02f, -6.01247177e-02f, 5.38623258e-02f, 2.68841684e-02f, 6.30933121e-02f, 2.02932842e-02f, 7.47730285e-02f, 8.85031074e-02f, -4.48068716e-02f,
  -1.48487225e-01f, -2.80195698e-02f, -4.52469289e-02f, -2.98313610e-02f, 2.46548820e-02f, -1.22899134e-02f, -5.53314611e-02f, -1.16274275e-01f, -3.16547900e-02f, -2.70155184e-02f,
  -6.80776834e-02f, 3.02016251e-02f, -4.48938794e-02f, 1.92842316e-02f, -7.36878440e-02f, -3.94927785e-02f, 1.61842816e-02f, 4.42935154e-02f, 2.77979597e-02f, -1.00671634e-01f,
  -1.09791584e-01f, 3.98400165e-02f, -4.91799749e-02f, -5.29305637e-02f, -1.60642490e-02f, -1.02962395e-02f, -6.57538045e-03f, -2.49904227e-02f, -4.17531505e-02f, -6.41143844e-02f,
  -5.25798872e-02f, -2.33256500e-02f, -1.35441190e-02f, 7.29881972e-02f, -3.42461579e-02f, -1.06752559e-03f, 1.83092132e-02f, 3.86429280e-02f, 9.71906930e-02f, 5.59843704e-02f,
  2.48096846e-02f, -1.28234848e-01f, -2.33685388e-03f, 1.02774516e-01f, 8.37191641e-02f, 5.35281114e-02f, 1.51686519e-01f, 1.49758413e-01f, -6.87677413e-02f, 2.49464829e-02f,
  3.87332104e-02f, 7.48807937e-02f, 7.57681131e-02f, -1.51983231e-01f, -7.14783967e-02f, -1.18505225e-01f, 5.75104244e-02f, -4.50089648e-02f, -5.24815917e-02f, -6.57093450e-02f,
  -3.85477580e-02f, 2.07758714e-02f, 6.62885308e-02f, -7.67472833e-02f, -3.38491686e-02f, -5.28687425e-02f, -4.52485047e-02f, -9.57676321e-02f, -1.53831495e-02f, -2.40560193e-02f,
  -4.02956791e-02f, 5.15112057e-02f, -5.55792525e-02f, -8.93308073e-02f, -4.89381105e-02f, 5.89091182e-02f, 2.53601391e-02f, 6.94287866e-02f, -9.44968238e-02f, 9.48186126e-03f,
  -8.15316942e-03f, 8.22722837e-02f, 9.05730575e-02f, 3.97727489e-02f, -6.40706792e-02f, 5.03472574e-02f, -2.14451142e-02f, -9.60058644e-02f, -4.16681767e-02f, 2.69692466e-02f,
  2.66054180e-02f, 6.62535205e-02f, -8.88692439e-02f, 7.71598816e-02f, -1.06992712e-02f, -5.56968041e-02f, -6.35428801e-02f, 1.50127308e-02f, -1.36801163e-02f, -8.38610455e-02f,
  5.87410629e-02f, 3.06320824e-02f, 3.10520418e-02f, -6.57705441e-02f, 2.84017101e-02f, 6.17561862e-02f, 5.91556057e-02f, 1.09589463e-02f, 4.46009226e-02f, -1.55530637e-02f,
  -6.63732514e-02f, -7.14901537e-02f, 5.58128916e-02f, 8.41893107e-02f, -7.75424764e-02f, 8.15252364e-02f, -2.06253901e-02f, -2.68112328e-02f, -8.21944028e-02f, -3.64467390e-02f,
  -7.02493638e-02f, -9.14699361e-02f, -2.02738214e-02f, -2.85577513e-02f, -8.08382183e-02f, 1.82115026e-02f, 5.30197583e-02f, 9.32926387e-02f, 4.14079502e-02f, 4.59494777e-02f,
  -6.86576068e-02f, -1.00044217e-02f, 8.13849550e-03f, -3.33940461e-02f, -1.86323412e-02f, -4.89597507e-02f, -7.73124471e-02f, 2.48542503e-02f, 1.63728502e-02f, 9.42276232e-03f,
  4.25018690e-04f, -5.55369742e-02f, 2.57205293e-02f, 8.92453194e-02f, 5.93992844e-02f, -3.97438928e-02f, -9.51870829e-02f, -1.01531118e-01f, 3.31596546e-02f, 2.01592036e-02f,
  -2.35887170e-01f, 1.52224107e-02f, 1.77885219e-01f, -2.38786206e-01f, 1.11748241e-01f, 2.28303671e-01f, 1.19280763e-01f, -6.01031817e-02f, -2.72635072e-01f, -2.21633241e-01f,
  -9.15261731e-02f, -1.69481426e-01f, -4.38940600e-02f, -3.77868935e-02f, 1.46864772e-01f, 2.01603472e-02f, 3.97603698e-02f, 2.54833475e-02f, -1.76239293e-02f, -1.39553547e-02f,
  -7.74144605e-02f, -6.94946572e-02f, 1.51446953e-01f, -1.84447467e-02f, -9.06118900e-02f, 1.10736145e-02f, -5.22534139e-02f, 2.78883558e-02f, -2.11139917e-02f, -1.82038229e-02f,
  -6.32405728e-02f, -1.73789665e-01f, 5.38353063e-02f, 1.05982944e-01f, 6.93723327e-03f, -9.37169716e-02f, 9.74845025e-04f, 8.75481218e-02f, -2.68372875e-02f, 6.53635934e-02f,
  -9.13145691e-02f, -2.96716187e-02f, -5.27083799e-02f, -2.09673820e-03f, 8.74062255e-03f, 5.36833182e-02f, -9.11538396e-03f, 8.74828175e-02f, -1.78215876e-02f, 1.14061579e-01f,
  3.34291486e-04f, 3.97832319e-02f, 3.20322923e-02f, -6.99906126e-02f, -2.32446138e-02f, 1.83843616e-02f, 4.20778356e-02f, 2.58118808e-02f, -3.10870614e-02f, -5.45556135e-02f,
  -8.13553575e-03f, 9.33411252e-03f, -6.13462776e-02f, 7.64408335e-02f, -4.50572632e-02f, 5.86821176e-02f, -2.56350096e-02f, -4.70373183e-02f, 3.64363678e-02f, 2.78969798e-02f,
  3.64552215e-02f, -3.83642055e-02f, 1.89115778e-02f, 9.92929190e-02f, 4.45115268e-02f, -8.87590274e-02f, 2.60548554e-02f, -5.14792316e-02f, -7.19641894e-02f, -1.28643671e-02f,
  -3.60607468e-02f, 5.25611863e-02f, 3.26907262e-02f, -3.68685797e-02f, 7.94482976e-02f, 6.63748905e-02f, -7.97673762e-02f, 7.09527731e-02f, -2.22390890e-02f, -7.17116520e-02f,
  3.80880646e-02f, -2.94325966e-02f, 5.49297370e-02f, 7.21322596e-02f, 7.11534098e-02f, 3.75735350e-02f, 4.92427722e-02f, -2.18354017e-02f, -1.17018223e-02f, 5.31081893e-02f,
  -5.64443460e-03f, -1.34474589e-02f, 1.16886571e-02f, -4.46216799e-02f, -2.01516766e-02f, -4.00786623e-02f, -8.95038992e-03f, 5.71002811e-02f, -2.47672368e-02f, 7.63724968e-02f,
  -5.06945588e-02f, 4.28594230e-03f, -1.09635361e-01f, 1.31573640e-02f, -1.05877509e-02f, -1.23624757e-01f, -3.03030685e-02f, 1.81853957e-02f, -4.47150227e-03f, -6.89127948e-03f,
  -8.73625875e-02f, 6.28368556e-02f, 3.17734443e-02f, -1.12768523e-01f, -2.26942394e-02f, 8.88382196e-02f, -7.83472955e-02f, 9.01438445e-02f, -9.01195034e-02f, 2.21626833e-03f,
  1.19663201e-01f, -2.50044838e-02f, 7.89298117e-02f, 4.50478271e-02f, 8.91982540e-02f, 1.16938047e-01f, -9.51019600e-02f, -9.77444649e-02f, 1.01568587e-02f, 6.49926215e-02f,
  -5.42492233e-02f, -2.07645316e-02f, 5.96246831e-02f, 1.23282656e-01f, 6.79426864e-02f, -1.85240281e-03f, 2.61496920e-02f, 7.89916590e-02f, 6.70812931e-03f, 1.08067647e-01f,
  -2.26486046e-02f, 6.30302057e-02f, 7.58011043e-02f, -7.25282729e-02f, 1.42088924e-02f, 4.17759195e-02f, 1.77716929e-02f, -1.43594611e-02f, -6.48845881e-02f, -6.98360801e-02f,
  -8.83960426e-02f, 9.94431451e-02f, -9.98178199e-02f, -4.07433845e-02f, 1.19021730e-02f, -9.14480910e-02f, 4.64364700e-02f, -3.83693539e-02f, 4.53344025e-02f, 8.74230918e-03f,
  4.84957211e-02f, 6.47103712e-02f, -8.11488852e-02f, -6.90028518e-02f, 5.53333163e-02f, -7.49014020e-02f, 6.92163035e-02f, 6.60861433e-02f, 6.38026521e-02f, 8.15207735e-02f,
  3.22285593e-02f, -7.37016946e-02f, 1.89922669e-03f, 7.02005699e-02f, -1.23615162e-02f, -9.64247137e-02f, -4.64437753e-02f, -1.34525662e-02f, -3.97292934e-02f, -4.93989661e-02f,
  -7.54251033e-02f, -2.33470537e-02f, -6.98338524e-02f, -5.89422360e-02f, -8.57814625e-02f, 1.53781846e-02f, -6.81632832e-02f, -4.03890647e-02f, -1.56876836e-02f, -5.94216809e-02f,
  2.98260879e-02f, -9.54174921e-02f, -7.13207275e-02f, 1.68853384e-02f, -4.98247184e-02f, 6.82512894e-02f, -2.81846691e-02f, -7.40688890e-02f, -9.98401418e-02f, 7.28080645e-02f,
  5.06926365e-02f, -4.87714447e-03f, -8.82702973e-03f, -4.85474467e-02f, 7.80015066e-02f, -2.72845533e-02f, 5.04425690e-02f, 7.62814805e-02f, 9.33245048e-02f, 1.04785219e-01f,
  -8.73179957e-02f, -3.36115137e-02f, -2.28826087e-02f, 5.31605333e-02f, -7.03443810e-02f, -6.83868974e-02f, 9.61054638e-02f, 8.00130889e-02f, 3.40862758e-02f, -6.73253834e-02f,
  7.45981410e-02f, 6.31800070e-02f, 8.15439895e-02f, 6.14056103e-02f, 5.83607703e-02f, -4.19741916e-03f, 8.06018710e-02f, 1.09067373e-02f, 5.53070754e-02f, 1.75691601e-02f,
  -5.23854829e-02f, 1.81067325e-02f, 1.37278035e-01f, -1.16993994e-01f, -1.89977046e-02f, -9.58494842e-02f, 2.20124908e-02f, 9.34136957e-02f, 1.27746060e-01f, -8.24405551e-02f,
  -9.71306711e-02f, 3.43394801e-02f, 1.19096853e-01f, -6.54904619e-02f, -5.86713292e-02f, 6.57022446e-02f, -1.68955892e-01f, 3.08469613e-03f, 9.62944180e-02f, -6.39522746e-02f,
  -8.57016891e-02f, -1.98845819e-01f, 5.87208830e-02f, 2.70357300e-02f, 4.82552648e-02f, 4.11947072e-02f, -1.08741619e-01f, 4.03300561e-02f, -6.71973601e-02f, -9.25917272e-03f,
  -3.34680267e-02f, 5.01436647e-03f, 1.35889158e-01f, 1.06959350e-01f, -1.07975611e-02f, -8.51138495e-03f, 7.83395767e-02f, 3.94348465e-02f, -3.19953822e-02f, -5.64898318e-03f,
  -1.06345043e-02f, 7.32776523e-02f, 5.42695783e-02f, 7.47201825e-03f, 1.02462232e-01f, 1.03360608e-01f, 8.75624735e-03f, 3.68608278e-03f, 9.10166502e-02f, 1.50932316e-02f,
  1.24075510e-01f, 6.78147525e-02f, 2.52008275e-03f, -3.70973498e-02f, 6.40757978e-02f, -3.99689637e-02f, 1.14701241e-02f, -3.84372869e-03f, 5.29434122e-02f, -9.13820975e-03f,
  -3.38938721e-02f, -9.19595584e-02f, -1.81893799e-02f, 7.84159824e-02f, 5.69687560e-02f, 3.80416848e-02f, 6.72861710e-02f, -5.26068695e-02f, -3.86996455e-02f, -1.40444199e-02f,
  -5.45708463e-02f, -7.25287572e-02f, 2.91489512e-02f, -9.71660763e-02f, 2.39454620e-02f, 6.08183332e-02f, -9.08580944e-02f, -9.83172506e-02f, 1.68315731e-02f, 6.35734722e-02f,
  3.15131135e-02f, 4.86126803e-02f, 8.72482359e-03f, -3.16474102e-02f, 3.98143493e-02f, 5.12549505e-02f, -2.04666890e-03f, -7.21599460e-02f, 3.49407829e-02f, 2.52716076e-02f,
  4.47848253e-02f, -1.15362547e-01f, -2.84326896e-02f, 2.82573514e-02f, 2.40094662e-02f, -1.83053259e-02f, -4.22799066e-02f, 8.33717436e-02f, 1.58056878e-02f, -8.22798014e-02f,
  -2.22765189e-02f, 2.23284587e-03f, -1.71708670e-02f, 4.57486771e-02f, -8.41123983e-02f, -4.35395986e-02f, -5.25268465e-02f, -9.16735157e-02f, -1.16557656e-02f, -1.63844582e-02f,
  -8.38356689e-02f, 2.11494006e-02f, -2.82081775e-02f, 1.77345909e-02f, 1.80732645e-02f, -9.13398266e-02f, -4.49645892e-02f, 3.84004116e-02f, -9.91245434e-02f, 4.62886356e-02f,
  2.07319915e-01f, 2.96292342e-02f, -1.25196248e-01f, -5.37499450e-02f, 6.65856674e-02f, 1.50365770e-01f, -7.11723939e-02f, 1.06058605e-01f, 8.75149369e-02f, -7.87536576e-02f,
  1.08583868e-01f, -1.84290465e-02f, -1.21609338e-01f, 1.13231912e-01f, 2.53340065e-01f, 6.30316418e-03f, 2.09963486e-01f, 4.94810492e-02f, -1.60420267e-03f, 4.94726188e-02f,
  1.25873625e-01f, 1.98263809e-01f, 7.35412091e-02f, 1.22298107e-01f, 1.53204441e-01f, 1.80777609e-02f, 2.44854838e-02f, -6.49110004e-02f, 1.11496121e-01f, 4.11512330e-02f,
  5.22825904e-02f, 3.46091464e-02f, 2.94256844e-02f, -1.01587892e-01f, -5.33268191e-02f, -4.92028370e-02f, 2.66827624e-02f, -4.82312255e-02f, -8.98409355e-03f, -7.00546429e-03f,
  -2.76702810e-02f, -3.67591530e-02f, -4.97755744e-02f, -9.52501968e-03f, -7.54235610e-02f, 3.84833887e-02f, -5.55062257e-02f, -1.20377325e-01f, 3.67855765e-02f, 9.16384459e-02f,
  -8.93336162e-02f, -6.60635829e-02f, -1.93455687e-03f, 5.07569090e-02f, 6.55154586e-02f, -7.96085894e-02f, 6.59069791e-02f, 7.91603997e-02f, 2.69466471e-02f, 1.15629219e-01f,
  4.90259081e-02f, 2.06687022e-02f, -5.97576760e-02f, 7.12641627e-02f, 2.81857271e-02f, -8.97668675e-02f, 3.06156389e-02f, 4.71284054e-02f, 7.78819099e-02f, -3.61887477e-02f,
  -6.00605980e-02f, -5.63932322e-02f, 4.07016650e-02f, -1.79771408e-02f, 1.13863230e-01f, 4.12893621e-03f, 6.14921972e-02f, 1.22860968e-02f, -6.60163984e-02f, 6.63792118e-02f,
  -6.42245263e-02f, 1.98499318e-02f, 8.97214189e-02f, -7.77458474e-02f, -2.61633564e-03f, -7.24287927e-02f, 4.22538668e-02f, -3.71539257e-02f, 1.93701107e-02f, 4.25618179e-02f,
  9.81231928e-02f, 2.11171031e-01f, 7.70300254e-03f, -6.59486726e-02f, -7.58751929e-02f, -2.09918548e-03f, -6.17712401e-02f, 5.02965413e-02f, 9.77006368e-03f, 4.85458300e-02f,
  8.65002126e-02f, -9.55791697e-02f, 2.04390604e-02f, 9.65930428e-03f, -4.79542725e-02f, 5.90608530e-02f, -7.15394914e-02f, 8.24559629e-02f, -2.11287849e-03f, 2.87943576e-02f,
  5.62799871e-02f, 4.83060405e-02f, 1.06452536e-02f, -8.52265209e-02f, 3.89122069e-02f, 8.38378072e-03f, 3.07864901e-02f, 1.39139313e-03f, 6.84705228e-02f, 7.66994432e-02f,
  8.07378441e-02f, 3.97806540e-02f, 6.79980963e-02f, 1.05908096e-01f, -3.94725725e-02f, -5.98878339e-02f, 7.70608112e-02f, 3.54831740e-02f, 9.33987200e-02f, 3.61157544e-02f,
  -8.14832598e-02f, 6.79564700e-02f, 1.51967742e-02f, 1.66702773e-02f, -3.78837846e-02f, 5.43804746e-03f, -4.34884056e-02f, -6.67589009e-02f, -4.67148460e-02f, 7.65369982e-02f,
  -3.33622620e-02f, -7.97078237e-02f, 5.77561967e-02f, -2.20847819e-02f, 2.70446911e-02f, -5.31536788e-02f, 3.41380127e-02f, -5.28119244e-02f, -9.98804532e-03f, -4.12904061e-02f,
  -1.85633246e-02f, 5.78959435e-02f, 4.22698930e-02f, -6.36312924e-03f, -6.31348267e-02f, -6.49793148e-02f, -5.10102697e-03f, -6.58383742e-02f, 1.16151171e-02f, 6.10971265e-02f,
  -5.20059913e-02f, 6.51539341e-02f, -3.27182934e-02f, 5.98326586e-02f, 6.71606138e-02f, -2.20988833e-04f, 8.54738280e-02f, -5.83885238e-02f, 8.71550944e-03f, -9.12500322e-02f,
  -6.69897795e-02f, -5.19331470e-02f, 8.64230618e-02f, 1.64312273e-02f, -5.45225218e-02f, -6.76403642e-02f, 8.39694031e-03f, 6.15766495e-02f, -4.09305021e-02f, 1.76175386e-02f,
  -5.61369061e-02f, -6.40721843e-02f, -1.93267083e-03f, -1.76377557e-02f, -1.20775029e-02f, 8.86361450e-02f, 3.70658934e-02f, -2.28709392e-02f, 6.27703890e-02f, 2.63741668e-02f,
  -5.25557287e-02f, -3.30561819e-03f, 8.97393748e-02f, -4.48177196e-02f, 5.01476554e-03f, -7.49446377e-02f, -9.78900865e-02f, 1.00540537e-02f, -7.50548169e-02f, 3.44578773e-02f,
  -8.09678212e-02f, 3.17140594e-02f, 4.02292162e-02f, -5.19207418e-02f, -5.76967187e-02f, 6.18491061e-02f, 4.33238177e-03f, -6.73518628e-02f, 2.49181632e-02f, 6.69080913e-02f,
  -3.54472059e-03f, 4.15507890e-02f, 7.92891309e-02f, -4.18262891e-02f, 1.00792244e-01f, -8.21618065e-02f, -2.28382293e-02f, 8.98070410e-02f, -6.25881404e-02f, 4.67003509e-02f,
  -3.45547237e-02f, 4.79115695e-02f, 7.23357797e-02f, -4.62503508e-02f, 3.97145599e-02f, -1.83740929e-02f, 7.19561726e-02f, -4.60193530e-02f, -4.10915464e-02f, -3.53254862e-02f,
  5.55668995e-02f, -4.95970808e-02f, -1.61651559e-02f, 5.53941242e-02f, -6.75408244e-02f, 5.67460731e-02f, 2.79162284e-02f, 5.34947962e-02f, 5.79103194e-02f, 1.30876414e-02f,
  -1.41584024e-01f, 1.56100959e-01f, -2.42203269e-02f, 1.12974532e-01f, -6.97878227e-02f, -2.23814800e-01f, -1.50987014e-01f, -2.72536986e-02f, -2.21929122e-02f, 2.54073571e-02f,
  -8.70935544e-02f, 5.53299300e-02f, -1.54207069e-02f, 1.35369778e-01f, -7.12962896e-02f, -8.48008972e-03f, 4.80115525e-02f, 4.90273014e-02f, -5.92691489e-02f, 1.23974919e-01f,
  1.18507668e-01f, 2.17962954e-02f, 1.44608647e-01f, 1.64698705e-01f, 7.80344829e-02f, 8.21275786e-02f, 1.37590885e-01f, 6.84583336e-02f, -3.30029540e-02f, 5.08692861e-02f,
  6.65024444e-02f, 1.75937507e-02f, -3.05125806e-02f, 5.87749779e-02f, -9.25965980e-02f, 3.57736051e-02f, 2.92277578e-02f, -9.59174260e-02f, -5.53660952e-02f, -8.81789550e-02f,
  -3.22131469e-04f, 4.30207103e-02f, -3.45043838e-02f, 9.02480558e-02f, 2.03076713e-02f, 8.50372389e-02f, -1.79311894e-02f, 4.98065464e-02f, -2.81687714e-02f, -5.28474748e-02f,
  2.48568002e-02f, -2.17445344e-02f, -1.85451154e-02f, 1.78465489e-02f, 8.79099742e-02f, 1.86924040e-02f, -2.00846791e-02f, 1.02321468e-01f, -7.91853517e-02f, 1.78651996e-02f,
  -7.01613352e-02f, -1.60083231e-02f, 2.91617811e-02f, 2.90061980e-02f, 3.62093858e-02f, 4.34079580e-02f, -2.48058401e-02f, -5.57316206e-02f, -8.07932392e-02f, -1.53151406e-02f,
  9.30835158e-02f, -1.30364681e-02f, 3.25196572e-02f, -1.93808805e-02f, 1.03133777e-03f, 7.37766027e-02f, 1.97932180e-02f, 2.02550590e-02f, 5.91670685e-02f, -7.07860962e-02f,
  -2.83704121e-02f, 3.77675928e-02f, -5.26610613e-02f, -1.91730838e-02f, 1.77605972e-02f, 4.03201208e-02f, 3.70835848e-02f, 2.79061534e-02f, 8.19248781e-02f, -7.60713965e-02f,
  4.28786241e-02f, 1.24789335e-01f, -8.20619166e-02f, 4.73700687e-02f, -1.69574600e-02f, -1.04995646e-01f, 9.17151943e-02f, 3.77485305e-02f, -8.48279819e-02f, 9.41332371e-04f,
  8.60917568e-03f, -3.82040925e-02f, 6.52201921e-02f, -4.03348468e-02f, 7.17646405e-02f, -7.81154037e-02f, 5.92679195e-02f, 9.81078818e-02f, 2.19043773e-02f, -1.17626879e-02f,
  2.84823608e-02f, 4.10446748e-02f, -6.26203939e-02f, 4.18756017e-03f, -7.04699382e-02f, -9.79528725e-02f, -1.52584044e-02f, -3.00979614e-02f, 6.47705570e-02f, 9.94910374e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  -5.28952889e-02f, -1.78965796e-02f, 1.14163667e-01f, -6.84604272e-02f, 1.11688003e-01f, 1.19101249e-01f, 6.63721263e-02f, 1.71486899e-01f, 1.49440523e-02f, 9.16300789e-02f,
  6.99003115e-02f, 1.41661376e-01f, 1.80969134e-01f, 3.03368922e-03f, 1.69737846e-01f, 5.57440855e-02f, 9.24453288e-02f, 1.04025729e-01f, 9.30203721e-02f, 2.33702600e-01f,
  1.86180606e-01f, 7.42957219e-02f, 1.30621269e-01f, 4.79963748e-03f, 8.53991732e-02f, 1.04704291e-01f, 9.81406197e-02f, -1.53747471e-02f, 5.99184958e-03f, 4.54823449e-02f,
  -2.99923681e-02f, -3.51614319e-02f, 1.01165786e-01f, 1.83167547e-01f, 1.40377328e-01f, 1.90538287e-01f, 5.52000478e-02f, 1.10551259e-02f, 5.02232425e-02f, 5.62323332e-02f,
  3.66996750e-02f, 4.84139472e-02f, 1.09815829e-01f, 1.41750723e-01f, 7.10607544e-02f, 1.37941286e-01f, -7.54050389e-02f, 1.41800297e-02f, 1.83030833e-02f, -1.05637209e-02f,
  1.94661364e-01f, 1.92097179e-03f, 1.82957903e-01f, 1.47985399e-01f, -1.16411480e-03f, 1.34830326e-01f, 1.72426969e-01f, 1.11338846e-01f, 1.32594049e-01f, 1.49547577e-01f,
  8.44902694e-02f, -4.73974767e-04f, 1.36677906e-01f, 1.34779634e-02f, 5.01859486e-02f, 1.40548155e-01f, 1.61328301e-01f, 3.11348513e-02f, -3.73683358e-03f, 1.08944140e-01f,
  1.99787796e-01f, -2.36484744e-02f, 9.97745693e-02f, -1.34646231e-02f, 2.62524169e-02f, 1.91534627e-02f, -4.32038829e-02f, 4.45991345e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.27778256e-01f, -1.37703970e-01f, 1.38926089e-01f, 1.47296162e-02f, 1.16603062e-01f, -1.33379593e-01f, -2.61660099e-01f, 6.71251416e-02f, 1.17577031e-01f, 5.19029126e-02f,
  7.99835175e-02f, 5.22129983e-02f, -1.88611615e-02f, -1.57924965e-01f, -1.62796751e-02f, 5.63258119e-02f, -1.18507735e-01f, -4.37214263e-02f, 1.04442202e-01f, -2.36958429e-01f,
  -2.98058033e-01f, -5.25449157e-01f, -9.02047008e-02f, 2.28111930e-02f, -7.84357786e-02f, 4.74050790e-01f, -4.47698951e-01f, 5.95810078e-02f, 3.15931946e-01f, -1.52790040e-01f,
  -1.98707238e-01f, 3.98934901e-01f, 1.46411760e-02f, 7.40560219e-02f, -3.05292964e-01f, 1.68080889e-02f, -2.61519790e-01f, 1.94657385e-01f, -3.90559942e-01f, -2.86325037e-01f,
  -2.64965653e-01f, 3.93487900e-01f, -2.91885793e-01f, -4.43746969e-02f, 1.97456703e-01f, 3.45134854e-01f, 5.16531110e-01f, 1.14269100e-01f, -2.61438191e-01f, -4.13304567e-01f,
  -1.37957986e-02f, -5.49180098e-02f, -1.14808492e-01f, 4.49623428e-02f, 2.27089494e-01f, 9.13903117e-03f, 2.61908889e-01f, -1.97174415e-01f, -5.91664873e-02f, 3.88155691e-02f,
  -2.19661836e-02f, 2.51939744e-01f, -6.25904556e-03f, -1.04663461e-01f, -8.19048211e-02f, -8.88985544e-02f, 2.79490352e-01f, 5.74179702e-02f, 1.69696838e-01f, 1.34020567e-01f,
  -2.05146536e-01f, -1.20308205e-01f, 1.58038899e-01f, 1.68775529e-01f, 1.48225382e-01f, -1.39218599e-01f, 8.09010118e-02f, -4.26311605e-02f, -1.12963319e-01f, -5.70615828e-02f,
  2.91594304e-02f, 1.13430165e-01f, 9.47739556e-02f, 3.34626764e-01f, 4.99447167e-01f, 2.17625603e-01f, -1.17183380e-01f, -1.92659721e-01f, -1.16020599e-02f, 1.32836610e-01f,
  7.96082690e-02f, 5.76543435e-02f, 1.94271296e-01f, 6.50976896e-02f, -2.18296215e-01f, -5.18653169e-02f, -1.04435027e-01f, -1.01626597e-01f, -9.05834883e-03f, 2.10848190e-02f,
  1.19267717e-01f, 5.00657298e-02f, -9.78588089e-02f, 1.85568705e-02f, 7.34446645e-02f, -1.44161701e-01f, -1.76321134e-01f, 5.62866330e-02f, 1.42349526e-01f, -5.59003698e-03f,
  -1.49810001e-01f, 6.48272708e-02f, -1.68195322e-01f, 1.37140274e-01f, -9.99878719e-02f, -2.50520986e-02f, -2.40616217e-01f, 1.46418409e-02f, 1.31815402e-02f, 1.65773287e-01f,
  6.37294948e-02f, 2.69250631e-01f, -2.73899883e-02f, -1.33953085e-02f, -6.11411706e-02f, -2.03354836e-01f, 8.42443295e-03f, 1.00789592e-01f, 3.68454829e-02f, -4.31334347e-01f,
  -1.45070463e-01f, -1.33706620e-02f, -8.36605579e-02f, -1.75691687e-03f, -9.70531031e-02f, 8.86908770e-02f, 2.56451964e-01f, -1.52336761e-01f, -2.27887958e-01f, 7.49820173e-02f,
  6.28058985e-02f, -2.47712597e-01f, 1.55565009e-01f, 6.07936345e-02f, -1.46769449e-01f, 8.86771455e-02f, 6.78124800e-02f, -9.41532198e-03f, 8.15563947e-02f, 1.71743929e-01f,
  -4.49004397e-03f, 7.60080591e-02f, -1.65507803e-03f, -2.73329407e-01f, -4.35920984e-01f, -2.69444019e-01f, -1.54258713e-01f, -4.14078921e-01f, 7.40998834e-02f, 2.18866751e-01f,
  9.19914395e-02f, 3.35174799e-02f, -1.95125222e-01f, -3.93859506e-01f, 2.38497078e-01f, -1.76724568e-01f, -3.16998929e-01f, -9.00508389e-02f, 1.33046180e-01f, 4.90314364e-01f,
  4.23091143e-01f, -3.76652777e-01f, 2.89716691e-01f, 4.05592114e-01f, 1.34123668e-01f, 2.11060479e-01f, 5.20712743e-03f, -2.06712216e-01f, 7.96435177e-02f, -1.84974030e-01f,
  -8.80222246e-02f, 1.19045442e-02f, -1.44341765e-02f, 7.07227811e-02f, 2.66500503e-01f, -5.21396846e-02f, -2.25558445e-01f, -1.41339958e-01f, 3.37660569e-03f, -1.31117314e-01f,
  -1.05841026e-01f, -8.87500420e-02f, 6.91167638e-02f, 7.66139403e-02f, -1.84688084e-02f, -8.63036215e-02f, 2.13879887e-02f, 3.50609571e-01f, -1.62709817e-01f, -5.77122979e-02f,
  -1.38009921e-01f, -8.48149210e-02f, -1.66017607e-01f, -1.62392616e-01f, 2.76109159e-01f, -1.73416018e-01f, 2.52548277e-01f, -7.60097355e-02f, -3.71428989e-02f, 2.32646503e-02f,
  5.79280443e-02f, -3.90523151e-02f, 6.81382865e-02f, 2.17728958e-01f, 1.28338281e-02f, -1.73324766e-03f, -1.41908661e-01f, -9.21860486e-02f, -7.90264010e-02f, 1.31703280e-02f,
  8.78320308e-04f, -5.75225381e-03f, -9.89184678e-02f, 5.17061114e-01f, 6.21245429e-02f, 2.83018142e-01f, -1.43445045e-01f, -2.38665845e-02f, 3.05480599e-01f, 1.48935691e-01f,
  -1.19559579e-01f, -1.97436139e-01f, 2.50789553e-01f, -2.05530345e-01f, 8.56603384e-02f, -2.42630411e-02f, -1.14816934e-01f, -4.21557240e-02f, -5.44166416e-02f, -4.25969437e-02f,
  2.56823599e-02f, -3.43814082e-02f, -3.94533351e-02f, 1.53270543e-01f, -2.71550238e-01f, -1.87196046e-01f, -1.34616703e-01f, 2.49018207e-01f, -2.53568947e-01f, 4.99929711e-02f,
  -7.21014515e-02f, 7.43274465e-02f, -1.86699942e-01f, 3.86482865e-01f, -1.38476580e-01f, -1.05966039e-01f, -6.86327964e-02f, -2.83808783e-02f, -1.43715709e-01f, -1.30057469e-01f,
  -1.11832179e-01f, -1.03343718e-01f, 3.04385461e-03f, 7.96508640e-02f, -2.23796993e-01f, -1.75611630e-01f, -9.96611267e-02f, -5.54733630e-03f, -7.44048581e-02f, -4.71631736e-02f,
  4.12234031e-02f, -3.41455117e-02f, 8.48699585e-02f, -1.12281226e-01f, -3.06752294e-01f, -2.63828635e-01f, -7.60243833e-02f, -5.86540140e-02f, -1.52401990e-04f, 3.33287474e-03f,
  1.26533672e-01f, -8.77076909e-02f, -1.39388144e-01f, -2.31992513e-01f, -2.29891330e-01f, -9.44875479e-02f, -2.06265628e-01f, -1.24231033e-01f, -9.87477377e-02f, -2.31043056e-01f,
  -1.67455107e-01f, 2.55390018e-01f, 4.01430167e-02f, 1.73749670e-01f, 4.22136039e-01f, 1.48774326e-01f, 7.24917650e-02f, 6.58538640e-02f, 7.78865740e-02f, -2.11464465e-01f,
  -3.06225061e-01f, -3.18053305e-01f, 2.06381194e-02f, -2.61298060e-01f, 6.99641407e-02f, 1.91475600e-01f, 1.12004675e-01f, -3.33324373e-02f, -1.21681072e-01f, 2.67059971e-02f,
  -7.35409036e-02f, -1.45906195e-01f, -2.96951104e-02f, 1.18646668e-02f, 1.94971815e-01f, 9.62639451e-02f, -5.84674291e-02f, -6.05951846e-02f, -8.37188363e-02f, -1.79788142e-01f,
  -1.26452789e-01f, -3.72116081e-02f, -5.68329170e-02f, -8.46995711e-02f, 2.37929286e-04f, 3.17438424e-01f, -2.14012235e-01f, -9.13989171e-02f, -1.22087687e-01f, -8.15630481e-02f,
  -3.46648842e-02f, 1.76704839e-01f, 1.57446251e-03f, -8.99915993e-02f, -8.33891183e-02f, -1.03436351e-01f, 6.51751384e-02f, 2.70033777e-01f, -1.16062604e-01f, -9.54507664e-02f,
  7.53051369e-04f, -8.54422078e-02f, 1.80364773e-01f, -1.07733198e-01f, -4.44899946e-02f, 9.90895648e-03f, -9.38688666e-02f, 2.23223746e-01f, -1.58276498e-01f, -1.90770552e-01f,
  -4.20930274e-02f, 5.19407034e-01f, 1.44669404e-02f, 3.03463973e-02f, -5.88062257e-02f, 1.29325300e-01f, -3.50902006e-02f, 7.40705803e-02f, 6.25123382e-01f, -1.72005579e-01f,
  4.38932888e-02f, -1.43447399e-01f, 3.82781059e-01f, 1.00340052e-02f, -2.14425310e-01f, -8.76357555e-02f, 9.30052772e-02f, -2.12994143e-01f, -3.11609283e-02f, 7.16845691e-02f,
  -2.74917320e-03f, 1.84696719e-01f, -7.87651539e-02f, 3.44626337e-01f, -1.14531413e-01f, 3.36546153e-01f, -7.52456859e-02f, 1.67811234e-02f, 9.91065055e-02f, -5.21278493e-02f,
  -1.51589513e-01f, 1.50733590e-01f, -1.02605961e-01f, 2.15325933e-02f, -3.50948900e-01f, -2.31403902e-01f, -1.98115513e-01f, -3.07389766e-01f, -1.54799327e-01f, 1.20934114e-01f,
  1.52049497e-01f, -1.59673020e-01f, -2.56062210e-01f, 1.94093045e-02f, -2.92136706e-02f, -2.61466444e-01f, 7.53360940e-03f, 1.35411635e-01f, -1.05598137e-01f, -7.53475428e-02f,
  2.21736785e-02f, 1.86587021e-01f, -2.12665394e-01f, -2.15731367e-01f, 7.70584797e-04f, -1.30783364e-01f, 1.03606507e-01f, 1.26120821e-01f, 1.11676842e-01f, 3.87885958e-01f,
  5.12276888e-01f, 4.12337154e-01f, 3.75906527e-01f, 4.54088986e-01f, 1.70690060e-01f, -1.82308927e-01f, 4.61199671e-01f, 2.87461817e-01f, 3.06477576e-01f, 2.88391382e-01f,
  -2.85779327e-01f, -2.88395006e-02f, -2.05859151e-02f, -3.23311716e-01f, -1.24648415e-01f, 1.35239288e-01f, 1.34226322e-01f, 1.39833659e-01f, 4.24830168e-01f, -3.01494878e-02f,
  2.99000710e-01f, -2.95114666e-02f, -2.82966912e-01f, 3.57665867e-02f, -6.42175525e-02f, 5.16971899e-03f, 2.19220191e-01f, 1.09736815e-01f, 1.62853468e-02f, 4.29986626e-01f,
  -1.22680411e-01f, 2.62918830e-01f, -1.12782061e-01f, 7.92339630e-03f, 3.60080004e-02f, 3.28982458e-03f, -9.11071897e-02f, -3.38181891e-02f, -2.69352384e-02f, 1.87928259e-01f,
  8.16922914e-03f, -1.75481997e-02f, 1.54265985e-01f, -2.04374760e-01f, -2.60191739e-01f, -1.07264288e-01f, 1.14362240e-01f, -7.13721961e-02f, -1.34048432e-01f, 3.69187724e-03f,
  -9.22275558e-02f, 1.49364024e-01f, -9.32303816e-02f, 1.28818944e-01f, -1.03882939e-01f, -2.72117276e-02f, -2.55757332e-01f, -1.16535956e-02f, -3.06542646e-02f, -1.51398733e-01f,
  -1.21221848e-01f, -4.72638793e-02f, -7.11112097e-02f, 1.20947093e-01f, -2.10720956e-01f, -8.28244612e-02f, -4.33506109e-02f, 2.22263038e-01f, 1.36778457e-02f, -2.52998978e-01f,
  9.42898987e-05f, -6.25039041e-02f, -5.99108776e-03f, -1.03640184e-01f, -1.99511066e-01f, -4.00540270e-02f, 5.56798950e-02f, 4.63769771e-02f, -5.32216653e-02f, -8.48220438e-02f,
  1.39281601e-01f, 3.12801957e-01f, 1.87470704e-01f, 3.06051105e-01f, -6.98840395e-02f, 1.70690969e-01f, 3.09391290e-01f, 4.47725318e-02f, -2.24791676e-01f, -2.03123361e-01f,
  4.83324341e-02f, 2.90393867e-02f, -2.23853678e-01f, -1.76846415e-01f, -1.19381100e-01f, -1.74917430e-01f, -1.65119424e-01f, 1.17305435e-01f, 1.41285360e-01f, -1.35382429e-01f,
  9.04848576e-02f, 1.10361494e-01f, 1.12216808e-01f, 2.22583160e-01f, 1.08927935e-01f, 2.37747788e-01f, 2.54031658e-01f, 5.40915281e-02f, 2.82057881e-01f, 3.06023598e-01f,
  1.12199277e-01f, 2.79077232e-01f, 8.62194076e-02f, 1.45125231e-02f, -1.86537459e-01f, 1.26047090e-01f, 1.09060861e-01f, -2.44492423e-02f, 1.90202426e-02f, 5.64856157e-02f,
  1.04287325e-03f, 6.00966252e-02f, 5.26635870e-02f, -2.37395149e-02f, -1.08485669e-01f, 3.74116227e-02f, -7.81766251e-02f, 2.84409344e-01f, 4.39805120e-01f, 2.29880944e-01f,
  1.67471081e-01f, 3.63703519e-02f, -2.93107599e-01f, 1.40032798e-01f, 1.26803266e-02f, 3.18062991e-01f, 3.78250815e-02f, 1.20347803e-02f, -3.52184445e-01f, 4.83718991e-01f,
  2.58269340e-01f, -6.12750709e-01f, -4.58933204e-01f, -5.10812581e-01f, -5.60885035e-02f, 2.23427266e-01f, 2.42728516e-01f, -1.46176085e-01f, 3.80563408e-01f, 4.03829306e-01f,
  -6.08033687e-02f, 3.86431932e-01f, -8.87087956e-02f, -8.25309232e-02f, 1.78433105e-01f, 1.65790208e-02f, 1.57857269e-01f, -2.68185049e-01f, 1.00604802e-01f, -1.33661717e-01f,
  -3.00177410e-02f, -1.24628708e-01f, -2.15265118e-02f, 8.94138962e-03f, -1.21989481e-01f, -6.16503581e-02f, -6.15086295e-02f, -6.13398142e-02f, -5.37255406e-02f, 6.11214228e-02f,
  1.27698675e-01f, -9.68245119e-02f, 8.77917409e-02f, 4.24013346e-01f, -1.43462345e-02f, 9.69831571e-02f, -1.18253328e-01f, -1.74898311e-01f, -6.89534172e-02f, 9.89935640e-03f,
  7.70762414e-02f, -3.75568606e-02f, -1.57339439e-01f, -9.42741409e-02f, 3.31108391e-01f, 1.43462002e-01f, -1.16690777e-01f, -1.13772703e-02f, -1.72509234e-02f, -3.82732823e-02f,
  5.65811992e-02f, -1.98370159e-01f, -1.04972489e-01f, -2.06075311e-01f, 1.24435574e-01f, -1.72501639e-01f, 1.21040724e-01f, -1.76976860e-01f, -2.27028821e-02f, 1.19187355e-01f,
  -1.25418985e-02f, 1.21828504e-01f, -1.05328135e-01f, -3.33013311e-02f, 2.21287623e-01f, 2.84482241e-02f, 4.27306890e-02f, 1.56220421e-01f, -1.06248021e-01f, 1.17151499e-01f,
  8.92952085e-02f, 2.29070485e-01f, -8.60401616e-02f, -5.33255637e-02f, 1.07598551e-01f, -9.92698595e-02f, -3.16646323e-03f, 2.55078599e-02f, -1.62010193e-01f, -1.27867863e-01f,
  1.30496040e-01f, -3.46222557e-02f, -8.48498009e-03f, -8.31002742e-03f, 4.77957994e-01f, 2.00091004e-01f, 2.27028146e-01f, -2.71802954e-02f, -6.70010671e-02f, -6.76395791e-03f,
  6.13906495e-02f, 3.39050949e-01f, 2.14051142e-01f, 7.77026340e-02f, 1.72897607e-01f, 9.81399044e-02f, -8.83392319e-02f, 2.82031745e-01f, -1.37481183e-01f, 7.87860826e-02f,
  5.58813624e-02f, 7.80302659e-02f, -2.25456618e-03f, 9.64875054e-03f, 1.66198999e-01f, 5.92698306e-02f, 9.14846212e-02f, 7.95351900e-03f, 1.85773969e-01f, -6.15532994e-02f,
  6.39802888e-02f, 2.32769683e-01f, 2.44076233e-02f, 8.24213251e-02f, 6.11914061e-02f, -4.14837748e-01f, -4.87891823e-01f, 2.80954033e-01f, -1.70959115e-01f, 4.22284514e-01f,
  -1.50724918e-01f, 4.15155083e-01f, 1.49259597e-01f, 1.87864780e-01f, -3.41294914e-01f, -3.75051081e-01f, 1.84562877e-01f, -3.62886846e-01f, -6.38910711e-01f, 2.86782682e-01f,
  2.18680725e-01f, -3.00861716e-01f, -2.08992913e-01f, 2.56355762e-01f, 7.62555450e-02f, 1.75618976e-01f, -1.18236586e-01f, -7.33542256e-03f, -5.23240268e-02f, 3.07687791e-03f,
  -1.12889424e-01f, 1.40725255e-01f, -8.02560300e-02f, -3.82768400e-02f, -2.09851757e-01f, -9.21167806e-03f, 1.52746346e-02f, -1.46743730e-01f, -1.42379701e-01f, 3.27855162e-02f,
  3.94264728e-01f, -1.72506645e-01f, 1.14525110e-01f, 9.22216773e-02f, 3.12365711e-01f, -7.98257291e-02f, -1.11464694e-01f, 8.73223394e-02f, -5.04062371e-03f, -2.01827124e-01f,
  4.00484771e-01f, -1.07124574e-01f, -4.30236161e-02f, 1.65181786e-01f, -1.11066207e-01f, 9.10241157e-02f, 4.53745387e-02f, 1.24585919e-01f, 7.56207034e-02f, 8.22514594e-02f,
  6.30009323e-02f, 3.31664123e-02f, 3.29086334e-01f, 3.01934153e-01f, -7.82126635e-02f, 1.24755166e-01f, -2.13574767e-01f, -1.23756863e-02f, 1.02453887e-01f, 9.71875489e-02f,
  9.30049792e-02f, -3.41439992e-03f, -8.78203064e-02f, 3.82533409e-02f, -1.65151834e-01f, -9.81857926e-02f, 1.54886812e-01f, -1.28495013e-02f, -1.91457868e-02f, 1.45665094e-01f,
  2.85852581e-01f, -8.71952176e-02f, -2.82477617e-01f, 1.24915071e-01f, 6.78502917e-02f, -1.27502009e-01f, -2.52962142e-01f, -1.12783439e-01f, 9.71035659e-02f, -8.31560194e-02f,
  2.20515188e-02f, -5.88596687e-02f, -1.26746789e-01f, 1.63331628e-03f, -1.56650349e-01f, -8.88692737e-02f, -8.86020139e-02f, -1.14824176e-01f, -9.18832794e-02f, -2.74893045e-02f,
  5.90727702e-02f, -3.61349508e-02f, -6.81696758e-02f, -4.93482454e-03f, -8.69526044e-02f, 9.60179269e-02f, 1.19440280e-01f, -4.15281765e-02f, 1.86677143e-01f, 1.12796567e-01f,
  1.40999898e-01f, -1.75111979e-01f, 4.04117256e-02f, 1.04435436e-01f, -1.17729507e-01f, -4.02629860e-02f, 5.77635542e-02f, 7.88849667e-02f, 2.75234319e-02f, -1.82727166e-02f,
  2.40891010e-01f, 3.36559415e-01f, -3.25638592e-01f, -1.22539714e-01f, 5.23192398e-02f, 6.95220307e-02f, 7.00520054e-02f, 1.30842805e-01f, -7.26194233e-02f, -1.02118604e-01f,
  1.92051753e-01f, 4.71177734e-02f, -3.76015127e-01f, -1.72668938e-02f, 2.59435147e-01f, -3.08807909e-01f, -2.95058638e-01f, -2.46268570e-01f, -2.20347166e-01f, -2.84876049e-01f,
  -3.75812382e-01f, -1.56299740e-01f, -3.25069934e-01f, 6.49746507e-02f, 1.72592297e-01f, -2.35724911e-01f, 3.03795606e-01f, 3.89769882e-01f, 1.02398276e-01f, 8.23883899e-03f,
  -1.45764142e-01f, -1.81432977e-01f, -2.79050350e-01f, -1.53756604e-01f, -4.07914639e-01f, 9.45952162e-02f, 2.57574022e-02f, 4.77072716e-01f, 8.59731436e-02f, 6.02448545e-02f,
  -1.54609203e-01f, 1.57426391e-02f, -1.67407375e-02f, -2.72114705e-02f, -3.44045907e-02f, -1.10035270e-01f, -2.14791056e-02f, -2.11651430e-01f, -9.16408822e-02f, -2.73628920e-01f,
  5.04972100e-01f, 4.16337475e-02f, 4.87843007e-01f, 2.53616745e-04f, -2.57285744e-01f, -1.91688561e-03f, -1.63123906e-01f, -3.85877311e-01f, 9.57341772e-03f, -1.33154750e-01f,
  -1.15539037e-01f, -6.33447841e-02f, 2.62088217e-02f, 2.59639055e-01f, -1.52682677e-01f, -1.40548646e-01f, 1.86344638e-01f, -1.00848444e-01f, 2.80171037e-01f, -1.35431468e-01f,
  -7.94921741e-02f, -8.81093144e-02f, -9.11005437e-02f, -2.40283743e-01f, -1.63589686e-01f, 2.99796611e-02f, 2.06662580e-01f, -2.98414342e-02f, 5.84024675e-02f, 6.66592177e-03f,
  1.41590135e-02f, -1.15099221e-01f, 1.62337333e-01f, -2.17335403e-01f, 2.34428626e-02f, -9.83880460e-03f, -1.67116344e-01f, -3.54140252e-02f, 2.06784815e-01f, 3.89136255e-01f,
  4.91028242e-02f, -2.66098648e-01f, 4.34145592e-02f, 3.00765902e-01f, 7.69262686e-02f, -2.23811850e-01f, 1.16381317e-01f, -6.47675619e-02f, 1.06794924e-01f, -9.21178460e-02f,
  -8.89464933e-03f, -1.35355949e-01f, -1.28449380e-01f, 1.04167216e-01f, -3.79611291e-02f, -1.03929928e-02f, 3.88310440e-02f, -1.08231165e-01f, 1.99213862e-01f, 1.89047188e-01f,
  -1.67557895e-01f, -1.39714077e-01f, 6.53650835e-02f, -4.06827256e-02f, 1.05907902e-01f, -1.90978393e-01f, 1.53135099e-02f, -2.20654868e-02f, -2.71689221e-02f, -3.91471423e-02f,
  -2.13316381e-01f, -7.02696368e-02f, 1.41548403e-02f, -1.70400515e-01f, -1.27631694e-01f, -2.84856576e-02f, -9.01248232e-02f, -1.21193290e-01f, -5.16578071e-02f, -1.33586287e-01f,
  -2.77625937e-02f, -1.36121511e-02f, -6.02001846e-02f, -8.65232199e-02f, 3.44944671e-02f, 1.66232456e-02f, -5.48282787e-02f, 2.27087759e-03f, -2.23070055e-01f, 1.18033343e-03f,
  -6.34703264e-02f, 1.02848515e-01f, 2.14895219e-01f, -2.29934394e-01f, 1.27432823e-01f, 1.58452049e-01f, -1.11167945e-01f, -1.44760400e-01f, 3.39886218e-01f, 5.33175841e-02f,
  1.34688199e-01f, -3.73818912e-02f, -1.82170391e-01f, 5.35217375e-02f, 3.53967369e-01f, -1.15166329e-01f, 2.04504207e-01f, -2.65878618e-01f, -3.74888815e-02f, -1.38767362e-01f,
  -2.18297631e-01f, -7.94886351e-02f, -7.66377375e-02f, -1.36309624e-01f, 6.82729036e-02f, -1.73322558e-01f, -1.27972350e-01f, 1.64653659e-01f, -4.51921113e-02f, -1.57015532e-01f,
  -9.23067108e-02f, 4.40312847e-02f, -8.37816969e-02f, 4.19290252e-02f, 3.09640877e-02f, -5.70666604e-02f, -9.01988968e-02f, 1.64443597e-01f, -5.81855923e-02f, 4.21167724e-02f,
  1.30966818e-02f, 1.27289265e-01f, -1.46055117e-01f, -1.98795736e-01f, -1.73861548e-01f, -3.23031992e-02f, 9.37816352e-02f, 3.77229266e-02f, 3.37480545e-01f, -5.31628057e-02f,
  2.97235996e-01f, -1.45084336e-01f, 1.57301694e-01f, 2.80881196e-01f, -9.76585969e-02f, 2.19353795e-01f, 3.48550864e-02f, 4.65051681e-02f, -1.09020166e-01f, -2.46311980e-03f,
  2.46917650e-01f, -2.02135101e-01f, -4.20552306e-02f, 8.29700947e-01f, -1.32089868e-01f, 1.80062637e-01f, 9.45946854e-03f, -4.84712124e-02f, -5.29588200e-02f, 2.30496511e-01f,
  -3.00232749e-02f, -5.34925796e-02f, 1.35567654e-02f, -2.09765956e-02f, -9.09890532e-02f, -3.73374745e-02f, -1.34214863e-01f, -1.70616150e-01f, -7.12765288e-03f, 3.33535165e-01f,
  -1.14524439e-01f, -1.82765303e-04f, -1.69319540e-01f, -5.91645502e-02f, 1.49067447e-01f, 1.94345757e-01f, -3.43063078e-03f, -3.33144180e-02f, -1.16527349e-01f, -7.01294392e-02f,
  -1.44642210e-02f, -7.43514895e-02f, 1.63690373e-01f, -6.72351047e-02f, 1.85471140e-02f, -1.65548369e-01f, 2.34264638e-02f, 8.92258622e-03f, -1.29845247e-01f, -4.70857956e-02f,
  1.14428014e-01f, -6.14524111e-02f, 3.84054892e-02f, 3.82643826e-02f, -6.72523975e-02f, 8.82236958e-02f, -1.27392244e-02f, 1.05327010e-01f, -6.76523224e-02f, -5.16574234e-02f,
  -1.33416921e-01f, -7.62294829e-02f, -2.83112854e-01f, -4.62579429e-02f, 7.45237395e-02f, -1.85040891e-01f, 5.14823804e-03f, -1.61868289e-01f, -3.24759893e-02f, -3.04843616e-02f,
  -1.77862775e-02f, -1.01517141e-01f, 5.53195998e-02f, -1.40306562e-01f, -2.07854528e-02f, 3.47020663e-02f, -1.01824224e-01f, -3.34931821e-01f, -2.57274508e-02f, 3.54983285e-02f,
  -3.57741266e-02f, -2.65127104e-02f, 1.17360249e-01f, 1.40443072e-02f, 2.30513364e-01f, -1.86365321e-01f, -2.49533504e-01f, -3.45367670e-01f, 1.55283257e-01f, 9.34131891e-02f,
  1.90925747e-01f, -9.79366750e-02f, -3.46548051e-01f, 2.18389288e-01f, 7.92565644e-02f, -1.86448738e-01f, 8.82736146e-02f, -1.15100063e-01f, -1.71810389e-01f, -1.21779121e-01f,
  -2.37058535e-01f, -2.98805594e-01f, -4.54546362e-01f, -3.57991546e-01f, -5.12760133e-03f, 1.17558800e-01f, 1.75850675e-01f, 5.83868697e-02f, -6.71749115e-02f, 2.70273164e-03f,
  -5.85755967e-02f, 9.69977230e-02f, -1.01889065e-03f, 3.32363665e-01f, 1.47589281e-01f, -1.73925817e-01f, 2.23620720e-02f, 4.44502920e-01f, 2.95376945e-02f, -1.61347702e-01f,
  2.66317576e-01f, -1.19559884e-01f, -1.68044493e-01f, 5.01738250e-01f, -3.93677652e-02f, -4.07563746e-02f, -1.47757918e-01f, -1.18507437e-01f, -5.15447184e-02f, -5.21352573e-04f,
  -4.90022823e-02f, -7.85686299e-02f, -8.83797780e-02f, -1.73658550e-01f, -4.16359119e-03f, -8.42323899e-02f, -7.44735226e-02f, -1.32125318e-01f, 7.10894018e-02f, -5.06560542e-02f,
  -1.70144841e-01f, -9.01339650e-02f, -9.39920843e-02f, -1.76405925e-02f, -1.65589094e-01f, -8.26083198e-02f, 2.73236930e-02f, -2.00167045e-01f, -1.12948708e-01f, 1.88327000e-01f,
  -5.09572700e-02f, -8.68373811e-02f, 5.27867414e-02f, -3.77268577e-03f, -1.41957119e-01f, 1.13167860e-01f, -1.94951221e-01f, -9.67113376e-02f, -1.15516469e-01f, 9.22090337e-02f,
  2.50753403e-01f, 1.98249482e-02f, -1.55266359e-01f, 4.54771845e-03f, -1.63206354e-01f, 2.22405046e-01f, 2.47357279e-01f, 2.18154803e-01f, -2.11306848e-02f, 4.44564462e-01f,
  2.03786045e-01f, 1.45824447e-01f, 2.84155719e-02f, 3.13126259e-02f, -5.59098599e-03f, 1.52432323e-02f, -5.37805185e-02f, 1.37459993e-01f, -6.03931732e-02f, 2.46978074e-01f,
  1.06489919e-01f, 3.31264257e-01f, 1.46561237e-02f, 1.46997824e-01f, -1.38327941e-01f, 1.18097045e-01f, -1.28015270e-02f, 1.21862479e-01f, 1.21606514e-01f, -1.67911977e-01f,
  9.15393233e-02f, 1.68431416e-01f, -2.46332120e-02f, 1.49964899e-01f, -1.28621280e-01f, -1.37649477e-01f, 2.58681059e-01f, 1.81760624e-01f, -1.69587970e-01f, -1.90101787e-01f,
  1.04141422e-01f, 1.58377841e-01f, 3.66401486e-02f, 1.40987977e-01f, -1.00331008e-01f, -1.73007950e-01f, 1.63327232e-01f, -1.06733337e-01f, -1.41023234e-01f, -3.85978580e-01f,
  -2.08062962e-01f, -1.18367955e-01f, 1.35878325e-01f, 2.21318722e-01f, -3.96310657e-01f, -2.18878821e-01f, 2.85516709e-01f, -4.14517611e-01f, 1.28271028e-01f, 4.24017727e-01f,
  3.86720300e-01f, 9.92868915e-02f, 1.25301629e-01f, -2.96007335e-01f, -3.95607799e-01f, -3.50760967e-01f, 1.91105232e-02f, -3.57467495e-02f, 9.04218629e-02f, 1.84147939e-01f,
  4.88597840e-01f, 2.10158497e-01f, -7.83512965e-02f, -6.40256107e-02f, -5.47409765e-02f, -6.96298704e-02f, -3.83753963e-02f, -2.33655781e-01f, -9.88899823e-03f, -4.44772542e-02f,
  2.18451411e-01f, 1.50551870e-01f, -2.05340847e-01f, 7.56252110e-02f, -7.40796551e-02f, -1.25302985e-01f, -2.61127949e-01f, 7.74879530e-02f, -3.89678124e-03f, -1.52844831e-01f,
  -2.40785137e-01f, -2.02601939e-01f, 1.55518234e-01f, 4.87640239e-02f, -1.11736238e-01f, -5.37254699e-02f, 1.26485035e-01f, -9.28570554e-02f, -9.68482345e-02f, -1.35036975e-01f,
  6.20861687e-02f, 1.36608288e-01f, -2.34286785e-02f, 1.64214402e-01f, -2.37381279e-01f, 1.08589649e-01f, -9.40116420e-02f, -5.58823049e-02f, -6.03735782e-02f, -9.08368379e-02f,
  5.25856279e-02f, -4.36668806e-02f, 4.74670738e-01f, 1.57140747e-01f, 9.90408808e-02f, 9.53839496e-02f, -1.40192077e-01f, -5.25312647e-02f, -5.50824851e-02f, 2.44947076e-02f,
  -1.49060994e-01f, -8.37633535e-02f, -1.39980450e-01f, -2.28630871e-01f, 1.17840134e-02f, 9.82951596e-02f, -4.65943925e-02f, 2.50308841e-01f, -1.55581489e-01f, -1.80197135e-01f,
  8.29853863e-02f, -2.49995500e-01f, 1.90302819e-01f, 8.07266980e-02f, -6.64264038e-02f, -2.56809574e-02f, 5.15516222e-01f, -1.61272258e-01f, 7.23650912e-03f, 8.49424303e-02f,
  1.31064102e-01f, -8.83144289e-02f, 4.52093244e-01f, -1.98436864e-02f, 2.08634317e-01f, 5.86996451e-02f, -9.29898024e-03f, -1.08780600e-01f, -3.08466470e-03f, -1.42862469e-01f,
  2.33292431e-01f, 2.20699102e-01f, 3.16929430e-01f, 9.84422490e-03f, 1.36827439e-01f, -8.51769745e-02f, 8.93521030e-03f, -1.63162798e-01f, 2.24811390e-01f, -1.06578454e-01f,
  1.96859837e-01f, 9.26419348e-02f, -3.92737202e-02f, 1.14187412e-01f, 3.21773887e-02f, 6.99029937e-02f, -6.64129406e-02f, -4.91527207e-02f, 6.10013939e-02f, 2.11842880e-01f,
  2.63884142e-02f, 1.26475945e-01f, -1.36157433e-02f, 1.08325668e-01f, 1.66692600e-01f, -8.78463537e-02f, -1.25642493e-01f, -6.76729530e-02f, 2.97537327e-01f, -1.86229557e-01f,
  2.62452871e-01f, -2.44212925e-01f, 5.09469271e-01f, 1.28979772e-01f, 3.27905983e-01f, 1.63307428e-01f, -2.59230107e-01f, -3.70230287e-01f, 2.28834093e-01f, -2.49148384e-01f,
  -1.68406472e-01f, 3.62927258e-01f, 4.44490761e-01f, 2.42458493e-01f, -1.25019163e-01f, -2.35092983e-01f, -3.54921818e-02f, -1.93947881e-01f, 3.42672378e-01f, -1.47248164e-01f,
  -3.02442238e-02f, 1.19433977e-01f, 1.58887897e-02f, -7.90298975e-04f, 1.59999207e-01f, 1.61758557e-01f, -2.49429330e-01f, 3.52961302e-01f, -1.95659757e-01f, 2.00301446e-02f,
  -1.74833626e-01f, 1.20757133e-01f, -2.34884322e-01f, -4.14651912e-03f, -1.79412141e-02f, -1.80634093e-02f, 1.87988151e-02f, 4.04249318e-02f, 3.53214443e-02f, 2.85931844e-02f,
  -1.60246029e-01f, 6.89239502e-02f, -2.44960099e-01f, -1.43978626e-01f, -2.20260452e-02f, -1.29656285e-01f, 9.21148900e-03f, 2.17500120e-01f, -1.00252032e-01f, -3.64001729e-02f,
  -1.24793708e-01f, -1.51954755e-01f, -1.51021183e-01f, -2.66673177e-01f, -1.45202041e-01f, 2.14967564e-01f, 3.92927468e-01f, -3.05629224e-01f, 1.40128538e-01f, 1.92113474e-01f,
  -1.81060657e-01f, 1.28347008e-02f, 1.76363420e-02f, 1.18841834e-01f, -1.22643001e-02f, 6.60882238e-03f, -1.20282471e-02f, -6.01145849e-02f, 5.64118754e-03f, -1.08140610e-01f,
  -1.02777600e-01f, -1.49078555e-02f, -1.32781729e-01f, -3.89356576e-02f, 1.06068864e-01f, 2.55041923e-02f, 3.39418709e-01f, -1.44544691e-01f, 2.28319801e-02f, -7.69811124e-03f,
  6.43364638e-02f, 7.39661381e-02f, 2.33190414e-02f, -3.48973386e-02f, 2.70981103e-01f, -1.66177958e-01f, -2.19245970e-01f, -1.80917978e-01f, -1.44456834e-01f, -9.85966325e-02f,
  -1.89028680e-01f, -5.51280603e-02f, 1.84843410e-02f, 4.43056114e-02f, -1.80247486e-01f, -1.45801425e-01f, -2.63307374e-02f, -4.66322750e-02f, 7.42827728e-02f, -3.37778986e-01f,
  -8.75090361e-02f, 4.57349932e-03f, 7.87416995e-02f, 1.01335589e-02f, 1.37455434e-01f, 1.20824009e-01f, 7.89961964e-02f, -1.39424307e-02f, -9.83266905e-03f, -3.37995365e-02f,
  -8.19986034e-03f, 7.52089769e-02f, 1.33205816e-01f, 1.47367239e-01f, 1.46128252e-01f, 9.07725692e-02f, -2.54260123e-01f, 6.61295280e-02f, 1.10581644e-01f, 4.57409360e-02f,
  1.46830171e-01f, 9.17906761e-02f, 6.88366666e-02f, -9.70676020e-02f, 5.54272234e-01f, 4.62576061e-01f, -3.39179128e-01f, 1.85699925e-01f, 2.92777389e-01f, 4.94141057e-02f,
  -2.31300503e-01f, -3.54365408e-01f, 1.12958394e-01f, 4.35906708e-01f, 3.27276200e-01f, -1.73532069e-01f, -1.78858086e-01f, 2.72522539e-01f, 1.12386063e-01f, 1.19280219e-02f,
  5.24127036e-02f, 5.19706726e-01f, -2.44440839e-01f, 3.09860967e-02f, -2.43498415e-01f, 1.40831247e-01f, 2.20777750e-01f, -1.13821365e-01f, -5.49352989e-02f, 5.82524389e-02f,
  3.25410336e-01f, 4.43493687e-02f, 1.78761855e-02f, -1.01694502e-01f, 3.44409235e-02f, 9.22725126e-02f, 2.43064500e-02f, -5.21610549e-04f, -2.52579544e-02f, -1.03872985e-01f,
  1.12071797e-01f, -1.03610128e-01f, 5.94656169e-03f, 9.03914943e-02f, -1.31073818e-01f, 3.53319108e-01f, 2.71880120e-01f, -2.28881240e-01f, -8.67159069e-02f, -1.48934394e-01f,
  2.43713900e-01f, -5.76409623e-02f, 6.88984618e-02f, 1.96682975e-01f, -7.59236962e-02f, -7.52760768e-02f, -2.16329172e-01f, -2.46289819e-02f, 1.23083569e-01f, -2.84182709e-02f,
  1.84921473e-01f, 1.47689432e-01f, 6.38422789e-03f, 9.80431736e-02f, -3.07992306e-02f, -5.58877252e-02f, -5.78877628e-02f, -1.53244674e-01f, -1.07967928e-02f, -8.60341266e-03f,
  3.70724276e-02f, -3.94657515e-02f, 4.59580086e-02f, -1.55853823e-01f, 1.24002665e-01f, -2.13120028e-01f, 4.35520679e-01f, -1.19331241e-01f, -3.21623504e-01f, -1.08952299e-01f,
  -2.50818700e-01f, -2.18797605e-02f, -8.69360566e-02f, -1.59588963e-01f, -2.36756250e-01f, 6.26177490e-02f, -1.10935934e-01f, -1.76258106e-02f, -6.04448747e-03f, -1.73766360e-01f,
  -1.07930219e-02f, 1.14122339e-01f, -1.76877961e-01f, 3.76276858e-02f, 4.03023541e-01f, -1.43427908e-01f, 1.14144661e-01f, -1.69402689e-01f, -2.13351741e-01f, -7.13243112e-02f,
  -1.30551293e-01f, -9.80262086e-02f, 1.45444483e-01f, -1.58441782e-01f, 5.17420098e-02f, 7.81119615e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.35125691e-02f, -2.70061549e-02f, -4.90377732e-02f, 6.02122955e-02f, 5.85267283e-02f, 1.60444267e-02f, 1.80183984e-02f, -2.12082081e-02f, -4.92035225e-02f, 6.62837848e-02f,
  3.88498530e-02f, 2.78533790e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    