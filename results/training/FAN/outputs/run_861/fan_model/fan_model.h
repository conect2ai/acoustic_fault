/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.18236405e-01f, -1.27608046e-01f, 1.03037931e-01f, -5.24846494e-01f, -6.17699325e-02f, -4.39733118e-02f, -2.82784197e-02f, -7.08024297e-03f, -1.77577421e-01f, -5.13383821e-02f,
  6.10356778e-02f, -1.16249613e-01f, -4.12999056e-02f, 4.63667586e-02f, 1.79410145e-01f, 4.15538363e-02f, 2.35715173e-02f, -8.47400278e-02f, 4.04447690e-02f, -6.26412630e-02f,
  1.71806823e-04f, -2.86143392e-01f, -1.82978004e-01f, 3.25382650e-02f, -1.22898333e-01f, -5.51581383e-02f, 4.57217097e-02f, -6.49460256e-02f, 1.58846244e-01f, -3.16389620e-01f,
  1.18691027e-01f, -1.47013934e-02f, -7.65897427e-03f, -7.89862573e-02f, -2.17470955e-02f, 2.84006782e-02f, -9.72785950e-02f, 1.95562914e-02f, 3.60168144e-02f, 4.30552252e-02f,
  -2.18681060e-02f, 2.86341365e-02f, -1.25515744e-01f, 1.69595573e-02f, 1.55182257e-02f, -3.67756262e-02f, 8.02282169e-02f, 6.28152955e-03f, 6.14693649e-02f, -2.04810244e-03f,
  -1.12534508e-01f, -2.38701515e-02f, 4.14373763e-02f, 3.18718627e-02f, 9.41786021e-02f, -1.07082594e-02f, 1.98221039e-02f, 6.82882145e-02f, 1.07538529e-01f, -8.02478567e-02f,
  -1.07206196e-01f, 6.28883019e-02f, 5.18747866e-02f, 1.25890085e-02f, -1.21252630e-02f, -6.11035861e-02f, 2.06250455e-02f, -6.53818846e-02f, 3.36508900e-02f, -2.90469117e-02f,
  3.83302346e-02f, -3.34513485e-02f, 1.98994782e-02f, 1.99597031e-02f, -1.33576496e-02f, -4.86288555e-02f, -2.59377453e-02f, -2.62468662e-02f, 6.60274029e-02f, -2.37445477e-02f,
  -8.63119774e-03f, 3.81779708e-02f, 6.34355145e-03f, 5.00772856e-02f, -4.44363914e-02f, -1.02235340e-01f, 1.03675928e-02f, 7.77870417e-02f, 2.68445499e-02f, 5.41085377e-02f,
  -9.19062123e-02f, 9.27050486e-02f, -5.59544750e-02f, 3.31381895e-02f, 2.91958060e-02f, 1.47323795e-02f, -3.85007188e-02f, 5.46803214e-02f, 2.90742870e-02f, -4.19497304e-02f,
  -1.50712216e-02f, -4.75758594e-03f, -3.53449360e-02f, 3.78740057e-02f, -6.97037159e-03f, 7.90419504e-02f, -2.25639585e-02f, -1.11843288e-01f, 9.90969986e-02f, -5.98594546e-03f,
  3.06536406e-02f, 2.10869592e-02f, 2.13401625e-03f, 1.19416537e-02f, 5.50724007e-02f, -1.31790936e-01f, -1.61491316e-02f, -2.56676152e-02f, 8.27103257e-02f, -2.35966966e-02f,
  -1.23103313e-01f, 3.35152388e-01f, 2.81815976e-01f, 9.66575220e-02f, -5.77953421e-02f, -1.54595941e-01f, -1.08461507e-01f, -8.04733187e-02f, 1.94533560e-02f, -2.91350223e-02f,
  5.23541905e-02f, -5.17657772e-03f, -4.00188826e-02f, -6.69248551e-02f, -1.07372366e-01f, -8.49788170e-03f, 2.12186024e-01f, -7.47505063e-03f, -2.76577920e-01f, -1.99156612e-01f,
  -4.39841338e-02f, 6.90000728e-02f, 5.10168113e-02f, -2.82837637e-02f, 3.46011594e-02f, -2.66182542e-01f, 1.36865407e-01f, 2.23879457e-01f, -5.16148508e-02f, 1.26941890e-01f,
  -2.89199017e-02f, 1.87533900e-01f, -1.19246408e-01f, -7.10205659e-02f, 1.02332622e-01f, -6.09192401e-02f, -3.53824496e-02f, 3.37944031e-02f, 3.18000726e-02f, 3.68234552e-02f,
  5.82322776e-02f, 4.11243364e-02f, 5.73905297e-02f, -9.00177658e-03f, -8.40503053e-05f, -3.07797808e-02f, 1.17746346e-01f, -5.97196445e-03f, -3.74452281e-03f, -6.51102439e-02f,
  8.09668005e-03f, 1.14066079e-01f, 6.01311922e-02f, -3.08426023e-02f, -4.27860729e-02f, 2.70438176e-02f, 1.07878377e-03f, -8.51906557e-03f, -3.13557200e-02f, -1.09686747e-01f,
  -3.06665823e-02f, 7.69135877e-02f, -1.56137608e-02f, 7.31607676e-02f, -7.66615421e-02f, -3.78492265e-03f, 3.55625488e-02f, -5.31695411e-03f, -2.90339142e-02f, 2.18183850e-03f,
  4.22772802e-02f, 8.72817542e-03f, -2.37713326e-02f, -2.01060921e-02f, -1.63104460e-02f, -7.74824619e-03f, 4.99428995e-03f, -7.90652186e-02f, 9.39281832e-04f, -5.51527850e-02f,
  3.31828482e-02f, -8.52662995e-02f, -1.09525733e-02f, 3.21125872e-02f, 2.25572120e-02f, 8.51836428e-02f, 4.59597184e-04f, -6.76775677e-03f, -4.88061011e-02f, -3.36559080e-02f,
  -2.15440378e-01f, -1.34415720e-02f, -6.45064414e-02f, -3.53930853e-02f, -3.39821056e-02f, 1.14152692e-02f, 3.88729237e-02f, -2.45334338e-02f, 8.31418633e-02f, -3.28966007e-02f,
  -9.29256380e-02f, 1.28776908e-01f, 3.96644548e-02f, 3.63276564e-02f, -5.38838468e-02f, -7.04610199e-02f, -1.55396024e-02f, -7.37959370e-02f, -4.66644466e-02f, 1.29645988e-01f,
  -1.02709308e-02f, -1.77096680e-01f, -2.25289658e-01f, -5.24912477e-02f, -3.42899412e-02f, -1.29905656e-01f, -1.50458500e-01f, -1.31043270e-01f, -2.43443087e-01f, -3.86511564e-01f,
  -1.86560407e-01f, 1.00504391e-01f, 5.94613180e-02f, 5.72026223e-02f, 1.58413514e-01f, 1.58781126e-01f, 3.23614597e-01f, 1.08045034e-01f, -1.15017511e-01f, 2.88180206e-02f,
  7.97021315e-02f, -1.44842595e-01f, 9.05163761e-04f, -3.34873646e-02f, 8.46856162e-02f, 1.51965484e-01f, 6.42998442e-02f, 1.16340406e-01f, -6.15492091e-02f, 5.76153956e-02f,
  1.03996165e-01f, -1.05731813e-02f, -1.48180768e-01f, -3.37131694e-02f, -1.56350687e-01f, -2.30733887e-03f, -3.06010321e-02f, -8.19254890e-02f, 7.34126046e-02f, 1.65348966e-02f,
  -1.69721723e-01f, -6.67287782e-02f, 4.54176962e-02f, -2.72168070e-02f, 4.61531840e-02f, 1.72685254e-02f, 4.27046455e-02f, -8.05813149e-02f, -2.28985697e-02f, -6.78831264e-02f,
  -2.14254279e-02f, 1.25667587e-01f, -3.83887887e-02f, 9.93052348e-02f, -8.27364624e-02f, 4.98542488e-02f, 5.21211885e-03f, 1.38407119e-03f, -3.06244064e-02f, -2.27015023e-03f,
  9.09877792e-02f, -6.35446236e-02f, -8.43162015e-02f, 5.97272720e-03f, -5.79064526e-02f, -6.77834451e-02f, -1.03622153e-01f, -9.80604813e-02f, 3.81838270e-02f, -2.24875230e-02f,
  4.81982157e-02f, -1.52964742e-04f, 6.26175478e-02f, -5.99431060e-02f, 5.16471900e-02f, 2.00898689e-03f, -3.00827827e-02f, 6.31617801e-03f, 3.54243629e-02f, -3.47323641e-02f,
  4.75622937e-02f, -3.30074430e-02f, -1.73317567e-02f, 1.21808583e-02f, 1.33661805e-02f, 1.18965078e-02f, 3.93860750e-02f, 3.22080106e-02f, 1.38018141e-02f, -1.39594376e-01f,
  -7.77805503e-03f, 6.78317174e-02f, 1.89410262e-02f, 3.48103419e-02f, -2.17234213e-02f, 7.55917951e-02f, -7.90529884e-03f, 1.29489368e-02f, -1.03143908e-01f, -6.57628402e-02f,
  -1.62606269e-01f, 1.26567811e-01f, -3.78715806e-02f, -4.09533232e-02f, 2.75293905e-02f, -7.18259066e-02f, -1.25347618e-02f, 1.81770208e-03f, 3.12403981e-02f, 6.23733960e-02f,
  -3.67770381e-02f, -3.21946689e-03f, 8.68428200e-02f, 1.09441904e-02f, 1.17279865e-01f, -4.50464897e-02f, -1.69061758e-02f, -3.17029655e-02f, -6.03520796e-02f, -1.88635197e-02f,
  -4.08601090e-02f, -6.47397637e-02f, -1.41003087e-01f, 2.63984594e-02f, -1.37021542e-01f, -1.99864451e-02f, -3.09952740e-02f, -3.32316905e-02f, 5.34077287e-02f, -4.29429710e-02f,
  -2.60203063e-01f, 1.85561061e-01f, -3.80324960e-01f, -2.23627210e-01f, -3.55060041e-01f, -3.28647047e-01f, -3.34467739e-01f, -8.97002593e-02f, -1.71343214e-03f, -7.14557916e-02f,
  7.02995360e-02f, 1.99587628e-01f, 3.03582907e-01f, 3.23647529e-01f, 1.25051692e-01f, -1.21867806e-01f, -1.63639367e-01f, 3.86665878e-03f, -1.55840144e-01f, -2.77010798e-01f,
  8.77069309e-02f, 5.39460480e-02f, 8.58307034e-02f, 4.64650393e-02f, -1.67021364e-01f, 9.99023765e-02f, -1.34972008e-02f, -8.33480284e-02f, 1.00867063e-01f, -3.97855463e-03f,
  -1.85675081e-02f, -2.38554314e-01f, -9.08926725e-02f, 9.27865356e-02f, -3.12250871e-02f, -6.50279447e-02f, 4.62891161e-02f, 3.69873792e-02f, 3.64071168e-02f, 3.82208498e-04f,
  4.11147848e-02f, 6.59624860e-02f, -4.01066430e-02f, 1.02837928e-01f, -1.77394543e-02f, -4.95613553e-02f, 1.08030699e-01f, -6.63217977e-02f, 6.18835390e-02f, -3.43453698e-02f,
  5.61579019e-02f, -5.07169068e-02f, -1.35265708e-01f, -6.69266880e-02f, -7.30204806e-02f, -2.54336791e-03f, -1.99701488e-02f, -7.40842968e-02f, -6.38434514e-02f, 6.91556605e-03f,
  -1.73954628e-02f, 1.52979847e-02f, -1.93821769e-02f, 4.86643985e-02f, 1.88775752e-02f, -8.70899856e-03f, -5.35813756e-02f, 5.54599352e-02f, -9.83892158e-02f, 2.77865008e-02f,
  1.24411732e-02f, 5.42251626e-03f, -9.61574074e-03f, -2.78498512e-02f, 9.47897881e-02f, -6.99254945e-02f, -1.16580417e-02f, 2.92712022e-02f, -8.45577475e-03f, 9.04086046e-03f,
  -4.99023981e-02f, -3.75511833e-02f, -8.73411540e-03f, 3.83769572e-02f, -1.52712604e-02f, -6.03692001e-03f, 1.70546174e-02f, -1.94210950e-02f, 3.40762525e-03f, -1.37332929e-02f,
  1.57720625e-01f, 6.19384684e-02f, 9.81894508e-03f, 3.85905914e-02f, -1.52605223e-02f, 6.83461502e-02f, -1.78015493e-02f, -3.15126888e-02f, 3.04949470e-02f, -3.47229391e-02f,
  -4.86745015e-02f, 2.24780161e-02f, 3.51045281e-03f, -2.21044328e-02f, -1.05039030e-01f, -8.48790184e-02f, 2.61014458e-02f, -1.58919841e-02f, 6.81592035e-04f, 3.51243727e-02f,
  6.73925877e-02f, -3.99178118e-02f, 2.93061379e-02f, 1.08169820e-02f, 2.20818892e-02f, 2.47197375e-02f, 4.27821800e-02f, -5.28439991e-02f, 1.89772192e-02f, 3.25843357e-02f,
  4.18474585e-01f, -1.62086576e-01f, 1.57501370e-01f, 1.48231223e-01f, -8.24441388e-02f, -5.42789847e-02f, -1.13766074e-01f, -2.53047347e-02f, -4.58830707e-02f, -4.61885631e-02f,
  -1.62502415e-02f, 4.81854491e-02f, 1.11159988e-01f, -6.75074980e-02f, 9.82001349e-02f, -5.39783165e-02f, -2.24965259e-01f, 1.35026827e-01f, 1.92769408e-01f, 9.82964635e-02f,
  -1.62672654e-01f, 8.28205869e-02f, 3.32492106e-02f, 8.31385702e-03f, -2.03326225e-01f, -3.05991843e-02f, -1.74998894e-01f, -8.92082751e-02f, -1.43848255e-01f, -2.99027413e-01f,
  7.72224218e-02f, 8.20548460e-02f, 6.23252802e-02f, 2.88219452e-02f, 9.74000152e-03f, -5.14336023e-03f, 3.90271991e-02f, -4.48985361e-02f, -3.29363234e-02f, -3.71939726e-02f,
  4.31101285e-02f, 7.60930032e-02f, 9.73342210e-02f, -6.55437708e-02f, 2.22704764e-02f, -8.00707787e-02f, -1.96460895e-02f, -4.70471121e-02f, 1.00193648e-02f, -5.32984920e-02f,
  -1.37447845e-02f, -7.89918676e-02f, 2.49878280e-02f, -1.13127857e-01f, -1.05346087e-02f, -3.65118459e-02f, -1.32485956e-01f, -9.26446170e-02f, -3.02039925e-02f, -2.45520324e-02f,
  -5.23315594e-02f, -4.95829582e-02f, 8.47240351e-03f, 6.36608666e-03f, -2.85780132e-02f, 4.86357771e-02f, -6.24065027e-02f, -5.31832390e-02f, -1.04428427e-02f, 9.28866863e-03f,
  -1.54980700e-02f, 7.34169632e-02f, -2.55142599e-02f, -2.55699903e-02f, -4.37143818e-02f, -2.89282016e-02f, 3.60994413e-02f, -1.07217515e-02f, 1.31758219e-02f, -5.61163388e-03f,
  1.01621859e-01f, 1.11369276e-02f, -5.39226942e-02f, 5.55903837e-02f, 5.47532327e-02f, 3.03842928e-02f, -1.61548480e-02f, 1.34075340e-02f, 2.86805686e-02f, -7.17797279e-02f,
  9.55981836e-02f, 3.05795502e-02f, 3.21651846e-02f, 8.30575824e-03f, 5.54038472e-02f, 2.12939139e-02f, 2.67904326e-02f, 2.77730040e-02f, 9.56414174e-03f, -9.54976752e-02f,
  6.65594041e-02f, 1.04574956e-01f, 1.39870299e-02f, -3.03838737e-02f, 2.07026303e-02f, -2.49623265e-02f, -3.34010855e-03f, 3.66867445e-02f, -2.46425923e-02f, -5.53249307e-02f,
  -3.38325836e-02f, -1.86615065e-02f, 6.83166161e-02f, -7.17385579e-03f, -6.73988312e-02f, 1.01839654e-01f, -3.04470193e-02f, 2.19463687e-02f, 1.17052570e-01f, 4.43588682e-02f,
  -5.58965266e-01f, 1.61845163e-01f, -1.94695011e-01f, -1.39863074e-01f, 9.30350870e-02f, 1.54507875e-01f, 2.60793567e-01f, 2.78664008e-02f, 2.26297081e-02f, 2.81468015e-02f,
  -5.62876575e-02f, 5.23589924e-02f, 4.43832055e-02f, 3.48225534e-02f, 4.95086536e-02f, 7.83603787e-02f, 1.55472651e-01f, 1.59942210e-05f, -1.49936497e-01f, -3.74217965e-02f,
  1.67665318e-01f, -1.26361832e-01f, -2.42752165e-01f, -6.86042458e-02f, -3.18644606e-02f, -2.76483521e-02f, -6.76022321e-02f, -1.01277992e-01f, 1.11591436e-01f, 3.95488888e-02f,
  -1.90151617e-01f, -4.60424349e-02f, 2.55472101e-02f, 1.08771525e-01f, 3.73031653e-05f, -4.64707874e-02f, -4.91375849e-02f, -3.05561218e-02f, 5.91222197e-03f, 8.27105641e-02f,
  1.29439071e-01f, 7.40579665e-02f, -1.99828018e-02f, 1.07921585e-01f, -1.60035603e-02f, -6.10416173e-04f, 2.85284892e-02f, -1.76845957e-02f, -2.56036445e-02f, 4.19568382e-02f,
  1.30095512e-01f, 3.71653996e-02f, 6.01970823e-04f, 6.62445575e-02f, -2.44004522e-02f, 2.15729754e-02f, -4.08546515e-02f, 2.05702744e-02f, -2.19820347e-02f, -7.55869448e-02f,
  9.31901932e-02f, -1.15937265e-02f, -9.38731339e-03f, 9.73008946e-02f, -3.55594680e-02f, 9.92614869e-03f, -5.20308204e-02f, 2.58656032e-02f, 6.93454221e-02f, -4.22569104e-02f,
  1.20761264e-02f, -7.10817575e-02f, 5.81965433e-04f, -6.15960658e-02f, 1.04768565e-02f, 1.11289173e-02f, 4.80487868e-02f, 2.91140638e-02f, -8.51372555e-02f, -1.43168597e-02f,
  7.28576705e-02f, -7.01397378e-03f, -3.24088670e-02f, -3.31332814e-03f, -1.82971600e-02f, 7.93402791e-02f, 5.74707650e-02f, 7.04471543e-02f, -5.79637140e-02f, 1.03742834e-02f,
  -8.23488608e-02f, 1.18105739e-01f, 3.51657383e-02f, 3.68434526e-02f, 2.33067963e-02f, -5.15858829e-02f, -4.64495197e-02f, -7.92009309e-02f, -4.87319529e-02f, -3.66693623e-02f,
  1.83836930e-02f, 4.57551517e-02f, 1.57483816e-01f, -2.50776000e-02f, 6.91836979e-03f, -2.02116482e-02f, -1.30121340e-03f, 9.20606107e-02f, -3.91207263e-03f, -3.84757146e-02f,
  8.12545642e-02f, 4.18020003e-02f, -7.70671889e-02f, -1.04312383e-01f, 6.86609596e-02f, -6.67773634e-02f, 2.74309106e-02f, -4.11375612e-02f, 3.46180461e-02f, -5.95309064e-02f,
  -4.72529024e-01f, -2.40192637e-02f, 1.74090266e-01f, 2.01298539e-02f, 1.26123028e-02f, -2.01608874e-02f, -1.80488244e-01f, 7.54228905e-02f, -2.47882959e-02f, -1.90245926e-01f,
  -4.09528613e-02f, -1.31892607e-01f, -2.03130543e-01f, 2.93017197e-02f, -2.04251155e-01f, -2.42611706e-01f, -1.42584518e-01f, -1.54533815e-02f, -2.23862417e-02f, -8.50873291e-02f,
  -1.84307154e-02f, -8.74182582e-02f, 1.07110202e-01f, 9.82041433e-02f, -1.56194884e-02f, 9.44465324e-02f, 1.04729861e-01f, 2.26678587e-02f, 9.35727805e-02f, -1.78983063e-01f,
  -1.14931002e-01f, -6.46470115e-02f, -6.62178323e-02f, 5.11891069e-03f, 1.37663975e-01f, 8.59720185e-02f, -1.16285179e-02f, 6.20038956e-02f, -3.18380371e-02f, -3.25585541e-04f,
  3.56828719e-02f, 9.26648080e-02f, -3.94740626e-02f, 4.44298498e-02f, 4.57238071e-02f, -2.76074316e-02f, -6.92185247e-03f, -3.57074104e-02f, -5.15358150e-02f, -1.87589489e-02f,
  -7.33372150e-03f, 1.84601285e-02f, 4.49182726e-02f, 5.05480468e-02f, -1.18303187e-01f, -1.05348505e-01f, 7.01472461e-02f, 2.93623060e-02f, 4.55957688e-02f, 1.14233844e-01f,
  2.31139548e-02f, 6.30784221e-03f, -9.19295009e-03f, 2.58671120e-02f, -1.97334159e-02f, -2.07714457e-03f, -4.82253917e-02f, 3.52770905e-03f, -3.99633497e-02f, 3.32992077e-02f,
  -5.82898110e-02f, -7.05991983e-02f, 1.92429088e-02f, 3.91012430e-02f, -5.44604883e-02f, 9.10523087e-02f, 1.17143961e-02f, 3.81072313e-02f, -2.17959080e-02f, -4.65676794e-03f,
  -2.87846308e-02f, 6.82682469e-02f, -5.75437434e-02f, 7.03823790e-02f, -2.44885311e-03f, -4.45819236e-02f, -1.79881472e-02f, 2.41093021e-02f, -2.96073742e-02f, 1.34927733e-02f,
  -4.42415010e-03f, -1.36280313e-01f, -8.97622406e-02f, 3.07328235e-02f, -8.28299969e-02f, -1.93526165e-03f, 3.69693264e-02f, 2.36587618e-02f, -4.40581739e-02f, 6.05899282e-02f,
  -1.28047215e-02f, 4.80975285e-02f, 5.95715605e-02f, 1.48779368e-02f, -5.66354692e-02f, 8.70834477e-03f, 1.34358993e-02f, 2.40955688e-03f, -4.22741137e-02f, 1.80842027e-01f,
  4.08829004e-02f, -5.31428978e-02f, -4.45065816e-04f, -2.72075739e-03f, -8.47049505e-02f, -3.83483171e-02f, -5.20059234e-03f, 1.06556416e-01f, -9.43918899e-02f, 1.12313867e-01f,
  -1.04906589e-01f, -4.54191398e-03f, 1.37517214e-01f, 5.14118560e-02f, 1.30358234e-01f, 4.77446156e-04f, 1.08504929e-01f, -3.83350998e-02f, -1.32374331e-01f, 6.05289899e-02f,
  -7.39947110e-02f, -1.25715196e-01f, -7.78954923e-02f, -1.07805982e-01f, -7.38058165e-02f, -1.03508651e-01f, 1.10886894e-01f, -8.35858211e-02f, -1.20700859e-01f, -6.11831397e-02f,
  2.79466677e-02f, -4.82876785e-02f, -9.71698612e-02f, -5.93046248e-02f, 6.08823933e-02f, -3.42964530e-02f, 1.74151793e-01f, 1.11676306e-01f, 1.60482094e-01f, 2.39003941e-01f,
  -8.83698836e-03f, 2.44062617e-01f, -3.90207698e-03f, -2.01862082e-02f, 1.04523048e-01f, -1.10161975e-01f, 3.81227322e-02f, 1.16520114e-01f, 3.46803814e-02f, 4.24263999e-02f,
  3.27520072e-02f, -1.87910683e-02f, 3.98671441e-02f, 1.17818631e-01f, -7.82411639e-03f, -3.26402150e-02f, 5.30851744e-02f, 5.83871156e-02f, 7.59967119e-02f, -1.07224304e-02f,
  8.16828460e-02f, 1.59397990e-01f, 6.56585321e-02f, 7.67552704e-02f, 3.00717950e-02f, -4.04277369e-02f, 3.24598737e-02f, 1.22960165e-01f, 4.02616970e-02f, 6.84328750e-02f,
  -3.18519473e-02f, 1.66165773e-02f, 8.45461339e-02f, 8.52537900e-02f, -3.46489251e-02f, -1.70727316e-02f, 7.05702379e-02f, 5.75460494e-02f, -3.54126953e-02f, 2.07470655e-02f,
  5.94880059e-03f, -5.75835146e-02f, -7.92417750e-02f, 6.66578785e-02f, -3.39395404e-02f, 3.43587026e-02f, 8.15469325e-02f, -6.92938492e-02f, 5.87544292e-02f, 3.38550508e-02f,
  2.25386187e-03f, 8.83808583e-02f, 7.61168916e-03f, 1.89318955e-02f, 7.07082376e-02f, -4.01678495e-02f, -2.54443176e-02f, -3.42655256e-02f, -5.55169210e-02f, 3.94798554e-02f,
  -2.96314389e-01f, 2.18914151e-02f, -6.65357187e-02f, -9.75832995e-03f, 1.05258502e-01f, -5.78099564e-02f, 1.54225319e-03f, -5.34500703e-02f, -9.41033382e-03f, -5.82808852e-02f,
  -5.62798455e-02f, -6.97677284e-02f, -5.29061891e-02f, -2.55342424e-02f, -1.37796462e-01f, -1.10463016e-01f, -9.96434316e-02f, -3.30981091e-02f, -7.50247091e-02f, 5.75380437e-02f,
  -9.74923819e-02f, -1.86108544e-01f, -1.21042937e-01f, -1.55325413e-01f, -8.29138681e-02f, -8.48654583e-02f, -9.12569091e-02f, -1.10402051e-02f, -1.18830711e-01f, -3.64334911e-01f,
  -3.08057219e-01f, 2.59761512e-01f, -1.47151291e-01f, -7.78202415e-02f, -2.12552682e-01f, -2.59910494e-01f, -2.34961733e-01f, -2.73860190e-02f, 3.10300253e-02f, 3.91395241e-02f,
  9.57095027e-02f, 8.34905654e-02f, 8.96382183e-02f, 1.09858848e-01f, -7.38306865e-02f, -2.37244065e-04f, -1.00628613e-03f, -4.23100889e-02f, -1.96914956e-01f, -8.77060071e-02f,
  3.13054323e-02f, 1.05974730e-02f, 5.07253595e-03f, 9.23722908e-02f, 2.20998496e-01f, -1.44217968e-01f, 3.90412770e-02f, 4.94309701e-02f, 4.87453863e-02f, 2.10016966e-01f,
  2.40078688e-01f, 5.22792563e-02f, -1.03425279e-01f, -1.96483731e-02f, -3.22505720e-02f, -8.04154500e-02f, -1.25199230e-02f, 3.22981514e-02f, -1.09672248e-01f, -8.70832428e-02f,
  2.43821982e-02f, 8.13452974e-02f, -5.77129424e-03f, 4.98939538e-03f, -1.77681670e-02f, -7.90323317e-02f, 1.11922733e-02f, 8.09301063e-02f, 5.56426309e-02f, 4.78405692e-02f,
  4.62597124e-02f, -9.84681770e-02f, -4.17191274e-02f, 2.40700319e-02f, 8.87383614e-03f, -1.29197035e-02f, -1.39837004e-02f, -4.83475551e-02f, -3.41496728e-02f, 2.39585236e-01f,
  2.45288271e-03f, -3.06722205e-02f, 4.41875076e-03f, 1.38541143e-02f, -3.01701128e-02f, 2.09668986e-02f, 2.15333067e-02f, -4.25865985e-02f, 2.37796344e-02f, 5.43906307e-03f,
  4.04565558e-02f, -7.36319125e-02f, 5.06324582e-02f, -1.50790913e-02f, 5.91448247e-02f, -6.69624358e-02f, -2.05680300e-02f, 8.67408738e-02f, 5.92319258e-02f, 1.46319149e-02f,
  3.50649692e-02f, 2.23686509e-02f, 4.78147566e-02f, 7.28995353e-02f, -1.89292699e-03f, -4.52296212e-02f, 4.57850508e-02f, 7.07665756e-02f, -2.62753572e-02f, -1.23231389e-01f,
  1.87250152e-01f, -1.49744123e-01f, 6.77452832e-02f, 2.41776332e-02f, 1.48789468e-03f, -3.28516811e-02f, 2.37906538e-02f, 5.71841411e-02f, 1.45325409e-02f, 5.11979125e-02f,
  6.29256072e-04f, -3.26330066e-02f, -3.88791203e-03f, -4.30008071e-03f, -3.03016715e-02f, 2.24555731e-02f, 5.57329580e-02f, -6.70718253e-02f, -2.44889352e-02f, 3.00020538e-02f,
  2.46098060e-02f, -3.44624631e-02f, 3.42457220e-02f, -5.23797832e-02f, 4.56771068e-02f, -9.83844325e-02f, -5.49809523e-02f, 9.07946080e-02f, -6.76854029e-02f, 2.11680736e-02f,
  -5.31446673e-02f, 5.17786480e-02f, 5.75650930e-02f, -3.00362781e-02f, 4.50510792e-02f, -1.52535259e-03f, 9.33790728e-02f, -9.61275995e-02f, -1.38777927e-01f, 2.50188708e-02f,
  -1.40212327e-01f, -2.14046448e-01f, -1.49285188e-02f, -3.82837392e-02f, -9.57632530e-03f, 1.17978536e-01f, 2.49351829e-01f, 1.46214813e-01f, -1.39675364e-01f, -1.14880204e-01f,
  -4.99635860e-02f, 5.20049632e-02f, 8.09687600e-02f, -1.74920768e-01f, 7.13625103e-02f, -2.63511211e-01f, 4.26944904e-02f, 1.33126050e-01f, -1.23979812e-02f, 3.49199295e-01f,
  1.00415170e-01f, -8.64958242e-02f, 3.06346156e-02f, 2.98475921e-02f, -1.03871068e-02f, 9.43020433e-02f, 6.67180587e-03f, -1.59511548e-02f, -6.65805340e-02f, 1.95949487e-02f,
  1.49344914e-02f, -3.81268299e-04f, 3.47465128e-02f, 2.17149202e-02f, 7.95311704e-02f, -5.60833933e-03f, 1.46457940e-01f, -3.99213992e-02f, 2.24029906e-02f, -2.60516163e-02f,
  4.96203601e-02f, 4.66971099e-02f, 9.26445331e-03f, -5.74351735e-02f, -4.94362675e-02f, 4.99748476e-02f, -6.58777133e-02f, 3.03877834e-02f, -8.29244480e-02f, -1.28964614e-02f,
  -3.38552706e-02f, -7.55272899e-03f, 5.34869060e-02f, 4.11544330e-02f, -3.21428701e-02f, -2.68942006e-02f, -4.45349701e-02f, -6.46826103e-02f, -7.89198354e-02f, -4.98986654e-02f,
  -2.77458280e-02f, 4.39879671e-02f, -2.17052083e-03f, -1.31566944e-02f, -1.46780536e-02f, 5.13083525e-02f, -2.45196391e-02f, 1.61785726e-02f, -8.36458579e-02f, 2.04337258e-02f,
  -5.59404492e-02f, -6.15611523e-02f, -3.45196575e-02f, -5.35977259e-03f, 3.12666781e-02f, -4.60504070e-02f, 3.71860899e-02f, 2.42119711e-02f, 1.21771678e-01f, 1.02204807e-01f,
  -6.78216591e-02f, -1.81296689e-03f, 4.07869741e-02f, 1.60946567e-02f, -2.91188154e-02f, 1.94196850e-02f, 1.50834136e-02f, -1.82669908e-02f, -3.89385521e-02f, -6.93763644e-02f,
  7.99530521e-02f, -7.10569322e-02f, -3.30822691e-02f, 6.58062473e-02f, -1.02155440e-01f, 2.13581286e-02f, 9.11929011e-02f, -1.74392797e-02f, 1.23853676e-01f, 7.05790296e-02f,
  1.40237272e-01f, 5.27703762e-02f, -3.93623933e-02f, -1.54123837e-02f, -7.35963136e-02f, -3.33848447e-02f, -7.55551830e-02f, -7.98253119e-02f, -3.47775817e-02f, 1.12785036e-02f,
  6.64563298e-01f, 5.62038720e-02f, -8.47005546e-02f, 6.13294169e-02f, -9.58470553e-02f, 4.98464331e-02f, 2.51774162e-01f, 2.03372568e-01f, -5.25800046e-03f, 7.96463713e-02f,
  -8.81835371e-02f, -1.56336978e-01f, -1.23843864e-01f, -6.21355586e-02f, 2.88208872e-01f, 9.43227485e-02f, 2.59908363e-02f, -4.58946414e-02f, 1.27105834e-02f, 2.04023030e-02f,
  -6.73849508e-02f, -3.20473313e-02f, 6.79012388e-02f, 1.71978343e-02f, -4.14391495e-02f, -1.06681753e-02f, -4.26658094e-02f, -7.04096109e-02f, -5.12265749e-02f, -1.12467043e-01f,
  -1.73946247e-01f, 5.34315705e-02f, -7.00452626e-02f, 1.63408124e-03f, -2.76230648e-02f, 5.60680404e-02f, 5.26287034e-02f, 5.86940274e-02f, -7.98105970e-02f, 4.37104441e-02f,
  -1.04458638e-01f, 9.42367781e-03f, 1.31989410e-02f, -2.52238326e-02f, 6.57824501e-02f, -2.51448210e-02f, 8.83302167e-02f, 3.88351977e-02f, 1.42041549e-01f, -2.06357595e-02f,
  -9.92756560e-02f, -5.30417114e-02f, 1.65263042e-02f, 4.35346700e-02f, 7.75815621e-02f, -1.36153862e-01f, -3.69384997e-02f, -1.22247174e-01f, -6.34680837e-02f, 4.30178363e-03f,
  2.78010406e-02f, -2.39544250e-02f, -4.39642631e-02f, 6.39438704e-02f, 2.64079925e-02f, -4.97565083e-02f, -8.40035360e-03f, -7.15637300e-03f, 7.34360740e-02f, 2.40806993e-02f,
  -9.12593380e-02f, -3.42749432e-02f, -4.44516465e-02f, -1.60146542e-02f, -2.83823162e-02f, 2.41307858e-02f, 6.21477887e-02f, 7.23661184e-02f, -8.33091512e-02f, 1.37205776e-02f,
  -5.17188758e-02f, 5.02200648e-02f, 1.95364980e-03f, -6.41015843e-02f, -9.33504291e-03f, -4.60263155e-02f, -2.69311704e-02f, 7.72799551e-02f, -3.68346907e-02f, -7.30596632e-02f,
  1.17973955e-02f, -7.58633390e-02f, -2.24064682e-02f, -9.50207859e-02f, 5.79720326e-02f, -1.35709181e-01f, -1.05841734e-01f, -7.56840641e-03f, -1.00041822e-01f, -3.76058295e-02f,
  6.77953884e-02f, 4.32651788e-02f, -5.68353347e-02f, -7.47839408e-03f, 5.32330107e-03f, 2.86920387e-02f, 7.92595595e-02f, 7.56562650e-02f, -1.25801994e-03f, 2.79606767e-02f,
  -6.52169669e-03f, 5.15674613e-02f, 1.36317343e-01f, 1.15105800e-01f, -2.29294989e-02f, -1.67625807e-02f, 9.40635800e-03f, -6.30154386e-02f, 6.59449995e-02f, 2.48915628e-01f,
  7.12159216e-01f, 3.45202871e-02f, 8.41145962e-02f, -3.63655575e-02f, -7.81977922e-02f, 1.73486285e-02f, 9.22013670e-02f, -2.39142813e-04f, 9.82286502e-03f, 4.74428684e-02f,
  -6.18460290e-02f, -1.78389296e-01f, -9.31349769e-02f, -1.74203038e-01f, 2.67921221e-02f, 6.32573664e-02f, -5.02517335e-02f, 9.85547602e-02f, -2.73344908e-02f, -4.14026603e-02f,
  -4.15341631e-02f, 4.33558561e-02f, 5.16049974e-02f, -5.72764175e-03f, -7.17865452e-02f, -1.54928237e-01f, -5.28850183e-02f, 3.82917793e-03f, -6.79672509e-02f, -5.98816015e-02f,
  1.11561209e-01f, 2.01851666e-01f, -8.72002691e-02f, 6.68082237e-02f, -4.07417230e-02f, 4.40247953e-02f, -6.27226606e-02f, 6.16825856e-02f, 3.85211632e-02f, 4.85588349e-02f,
  3.37517187e-02f, 4.71188053e-02f, -4.41040695e-02f, -4.70311847e-03f, 7.18326401e-03f, 1.26831040e-01f, -1.32146745e-03f, 1.62050411e-01f, -7.83414021e-03f, 1.54927880e-01f,
  -8.98424163e-03f, 5.31277955e-02f, 1.27342835e-01f, -4.11020778e-02f, 1.17046498e-01f, -6.90585896e-02f, 3.93242352e-02f, 1.09266870e-01f, 2.25836020e-02f, 9.13674384e-02f,
  2.18406413e-02f, 5.65116517e-02f, 3.14087868e-02f, 5.89786284e-02f, -6.64646104e-02f, -9.60043818e-03f, -1.11761495e-01f, 9.34167951e-03f, -4.52122092e-02f, 7.28298128e-02f,
  -2.31452920e-02f, 2.21237130e-02f, 1.73853990e-02f, 4.70067225e-02f, -3.43210101e-02f, 4.47598845e-02f, 3.47952843e-02f, -2.18281671e-02f, 6.87732548e-02f, -2.07409039e-02f,
  6.40125871e-02f, -1.72661263e-02f, 5.08399084e-02f, 2.82835178e-02f, -6.49621012e-03f, -5.31449467e-02f, 7.28309900e-02f, -4.53746133e-02f, -4.58241664e-02f, 2.03680675e-02f,
  -1.01586297e-01f, -6.29990697e-02f, 4.76627843e-03f, 3.03590111e-03f, -1.03989922e-01f, -4.15598787e-02f, 1.50119737e-02f, -3.14322226e-02f, -3.59278060e-02f, 2.64053680e-02f,
  -2.23384071e-02f, 1.10982828e-01f, 1.98534969e-02f, 2.15883721e-02f, -1.40570775e-02f, -2.35542469e-02f, -1.22499026e-01f, -6.32962286e-02f, 3.23495548e-03f, 6.28499910e-02f,
  8.54023919e-02f, 9.66159627e-02f, 5.29251769e-02f, -1.40786422e-02f, 4.79237027e-02f, -3.73503454e-02f, 2.44996268e-02f, 1.30641595e-01f, 7.55907148e-02f, 1.01399109e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.16328025e-01f, 1.14227936e-01f, 5.59825450e-03f, -7.14513287e-02f, -8.12084675e-02f, -1.48601100e-01f, -1.13195464e-01f, -3.87660637e-02f, 5.81490472e-02f, 7.17151761e-02f,
  -1.01447135e-01f, 3.47753018e-02f, 6.47211671e-02f, 4.77459915e-02f, 3.93995233e-02f, -1.53255742e-02f, -7.40258535e-03f, 3.59481908e-02f, 1.51193723e-01f, -5.48247015e-03f,
  -1.78276598e-02f, 1.81476921e-01f, 2.26187930e-01f, 9.20588821e-02f, 2.58796643e-02f, 3.13410796e-02f, 5.61533496e-02f, 1.51630655e-01f, 1.11075670e-01f, 1.76695243e-01f,
  2.22024396e-02f, 3.62786613e-02f, 1.20759327e-02f, -6.71537966e-02f, 8.39899480e-02f, 4.81634848e-02f, 3.61570120e-02f, 9.24196839e-02f, 2.40068585e-02f, 5.98697625e-02f,
  2.14046948e-02f, 4.15542684e-02f, -1.23811193e-01f, -2.15382013e-03f, 6.16310462e-02f, -4.65173945e-02f, -1.92079693e-02f, 1.09279431e-01f, -7.87253007e-02f, -1.05883524e-01f,
  -7.03395754e-02f, 8.96343775e-03f, -1.53765930e-02f, -4.22573276e-02f, -5.37948944e-02f, -7.35215098e-02f, 1.69600435e-02f, 1.72616523e-02f, 4.61348034e-02f, 1.27727047e-01f,
  -6.02052063e-02f, -1.02191269e-02f, -3.29772010e-02f, -7.82428011e-02f, -5.02561890e-02f, -6.58266842e-02f, 1.09714247e-01f, 6.31722584e-02f, 7.06205890e-02f, 9.18479115e-02f,
  -1.20191373e-01f, -2.95872912e-02f, 2.89774407e-02f, -1.91771537e-02f, 3.64041999e-02f, 3.18747945e-02f, -1.72110777e-02f, -7.46655241e-02f, -9.95399132e-02f, -3.27777863e-02f,
  4.93892953e-02f, -5.99468825e-03f, -1.28840776e-02f, 2.80818483e-03f, 1.37437955e-02f, 7.31756017e-02f, 3.35294046e-02f, 2.85323411e-02f, 2.48283911e-02f, -1.69003438e-02f,
  8.60656500e-02f, -2.12554738e-01f, 1.90321561e-02f, 1.08568288e-01f, 1.24153242e-01f, 1.03649065e-01f, -6.58512935e-02f, 2.60866415e-02f, 1.50633696e-02f, -2.64700148e-02f,
  -6.76046778e-03f, 2.64869314e-02f, 2.22348385e-02f, -4.02419083e-02f, 3.11221685e-02f, 9.63405073e-02f, -1.32765070e-01f, -1.20812273e-02f, -1.81565974e-02f, -1.93294119e-02f,
  2.31709983e-03f, -5.32839261e-02f, -1.33071110e-01f, -1.23955108e-01f, 2.14008465e-02f, -1.29062399e-01f, 5.78025207e-02f, 6.02835342e-02f, 3.85595895e-02f, -1.37563711e-02f,
  3.57224233e-02f, 6.32409155e-02f, -1.22889802e-02f, 9.93910134e-02f, 4.71356250e-02f, 8.70984718e-02f, 1.28015235e-01f, 1.00510471e-01f, 4.79195565e-02f, -2.31199972e-02f,
  1.13378443e-01f, 1.71943665e-01f, 9.29364190e-02f, 1.54169217e-01f, 2.71239970e-02f, 1.24496087e-01f, 9.65415612e-02f, 9.59822349e-03f, 7.61030167e-02f, 1.31332846e-02f,
  1.13430955e-01f, -8.90970975e-02f, -5.20607084e-02f, 6.58501312e-03f, -6.59973174e-02f, 1.15168296e-01f, -4.60459031e-02f, -1.00939088e-01f, 3.13148126e-02f, -2.00636908e-02f,
  -7.13728815e-02f, 1.96548235e-02f, 1.31255865e-01f, -6.12119697e-02f, -4.19223048e-02f, 4.70551401e-02f, -2.54714005e-02f, -5.33593856e-02f, -6.61022142e-02f, -3.44833569e-03f,
  -2.79277209e-02f, 8.32737144e-03f, -6.44727191e-03f, -1.38116807e-01f, -7.73232654e-02f, -4.55103554e-02f, -8.32854286e-02f, 7.14460835e-02f, 6.91326335e-02f, 7.95683041e-02f,
  1.18584774e-01f, -5.64192012e-02f, 3.27288881e-02f, -3.57486643e-02f, -2.67553851e-02f, -1.44944876e-03f, 7.38054588e-02f, -1.00220308e-01f, -5.19224219e-02f, -1.98293284e-01f,
  -1.96838863e-02f, -4.87879328e-02f, -1.10470904e-02f, 9.26933531e-03f, -3.05883288e-02f, -1.00001670e-01f, -1.46455420e-02f, 2.59342156e-02f, 4.46504131e-02f, -5.14202192e-02f,
  -5.31124696e-02f, 5.84535375e-02f, 8.96552727e-02f, -5.70936389e-02f, 2.21471116e-02f, 8.10525287e-03f, -1.24913333e-02f, -6.81760311e-02f, -4.54281224e-03f, -1.08234733e-01f,
  -9.49029401e-02f, -8.24865326e-03f, -3.99518386e-02f, 7.09636062e-02f, 6.33569509e-02f, 4.10070531e-02f, -4.12841626e-02f, 8.93674418e-03f, -2.89794765e-02f, -4.92061712e-02f,
  -1.22059941e-01f, 2.24240825e-01f, 2.10844204e-02f, -5.06642088e-03f, -1.27238169e-01f, -1.18714198e-02f, 1.03401706e-01f, 1.58130117e-02f, 7.14534968e-02f, -7.78525928e-03f,
  4.29076739e-02f, 3.17619368e-02f, -5.96439280e-02f, -1.38392910e-01f, -1.52570782e-02f, -3.71981226e-02f, -6.76555485e-02f, 1.52337059e-01f, 1.12991445e-01f, 8.68611634e-02f,
  5.89080676e-02f, -6.40069470e-02f, -8.13221261e-02f, 1.03025563e-01f, 3.94123271e-02f, 2.21372992e-02f, 7.51638040e-02f, 3.13559584e-02f, -1.19073642e-02f, -4.55453852e-03f,
  1.27416566e-01f, -9.79980379e-02f, -1.13889202e-01f, 1.14431180e-01f, 1.78155884e-01f, 1.01595812e-01f, -1.11313434e-02f, 1.91205174e-01f, 1.02896444e-01f, -7.88293406e-02f,
  -4.12585922e-02f, 5.89954592e-02f, -1.13697335e-01f, -7.73448199e-02f, -1.41283646e-01f, -1.61069840e-01f, -1.69767946e-01f, -9.24894959e-02f, 1.79668874e-01f, 2.34146506e-01f,
  1.11577675e-01f, 6.82140812e-02f, -6.14660047e-02f, 9.45257694e-02f, -1.33668423e-01f, -1.12941712e-01f, -2.41147906e-01f, -1.32139146e-01f, -2.04305246e-01f, -4.02517408e-01f,
  -1.33914933e-01f, 1.89391091e-01f, 3.11481301e-02f, -3.21017541e-02f, -1.18883163e-01f, 5.56936115e-02f, 1.42704258e-02f, 2.49515027e-02f, 3.39274257e-02f, -2.29449999e-02f,
  -1.32096745e-02f, 8.67557749e-02f, 1.81442387e-02f, 4.43406887e-02f, 3.23177874e-02f, 1.60928909e-02f, 7.54168853e-02f, 5.20076007e-02f, -1.61384828e-02f, 2.98653878e-02f,
  1.22278202e-02f, 1.07333779e-01f, -1.95474620e-03f, -3.96449585e-03f, 9.38645229e-02f, 5.83930463e-02f, -1.18395751e-02f, -4.88395169e-02f, -1.66974798e-01f, -2.34408200e-01f,
  3.46464920e-03f, -3.13140824e-02f, 1.96851920e-02f, 8.95765796e-02f, -5.69601655e-02f, -2.74940804e-02f, -1.01412386e-02f, -1.26324110e-02f, 2.13163327e-02f, -4.32134829e-02f,
  2.56121177e-02f, 1.89877655e-02f, 9.04650427e-03f, -1.91023294e-02f, -2.44250204e-02f, 2.74435207e-02f, -2.84613762e-03f, -5.03936335e-02f, -3.01508494e-02f, 9.61409882e-03f,
  4.74392157e-03f, -9.00791511e-02f, 7.48879835e-02f, -1.41429203e-02f, 5.09680435e-03f, -4.04521078e-02f, 6.55769631e-02f, 3.58041748e-02f, 7.25419968e-02f, 3.41440849e-02f,
  -1.02940187e-01f, -7.69284144e-02f, -3.48747857e-02f, 4.35129739e-02f, 4.29858230e-02f, -7.04659447e-02f, -2.64321156e-02f, -5.23015186e-02f, -2.91709192e-02f, -6.51522167e-03f,
  4.43951525e-02f, -1.18484735e-01f, -1.09332100e-01f, 2.33936924e-02f, -5.09129725e-02f, 4.16377410e-02f, -5.63125610e-02f, -9.14403126e-02f, 9.56993699e-02f, 3.94368172e-02f,
  1.35341911e-02f, -2.38604378e-02f, -1.19110368e-01f, -7.97826052e-02f, 6.12471765e-03f, -7.01437593e-02f, -1.28072709e-01f, -4.23206426e-02f, -1.32613957e-01f, -3.40109140e-01f,
  -8.02134424e-02f, 7.21942559e-02f, 2.22643301e-01f, 7.59915188e-02f, 6.10427409e-02f, 2.05114409e-01f, 1.32969946e-01f, 8.09327886e-02f, -9.43181515e-02f, 1.27047718e-01f,
  6.36146218e-02f, 9.36236307e-02f, 1.01337597e-01f, 1.03691570e-01f, 2.86926832e-02f, 5.48242182e-02f, -4.08258438e-02f, 7.97685161e-02f, 1.42976031e-01f, 1.02677047e-01f,
  2.79230941e-02f, -4.10502451e-03f, -5.16115092e-02f, -1.01740263e-01f, -3.55671979e-02f, 2.09247366e-01f, 1.01655513e-01f, -1.12077326e-01f, 3.72370668e-02f, -9.48736742e-02f,
  3.41229260e-01f, -9.89468321e-02f, 6.04319163e-02f, -3.04849877e-04f, 1.91263072e-02f, -3.68168876e-02f, 1.39822327e-02f, -1.69147804e-01f, -7.77800158e-02f, -2.21573678e-03f,
  -9.20728147e-02f, -1.18428275e-01f, -1.65530108e-02f, -1.51156085e-02f, -3.80890518e-02f, 5.66205978e-02f, -8.81858245e-02f, -9.99799371e-02f, 4.43387069e-02f, -5.18708937e-02f,
  4.80610877e-02f, 6.51791915e-02f, -1.23750307e-02f, 1.54032469e-01f, 7.74805918e-02f, 7.18557015e-02f, 2.56371815e-02f, 9.82960537e-02f, 7.57082850e-02f, -5.71892746e-02f,
  -6.29503950e-02f, -2.52310745e-03f, 8.83631557e-02f, -8.63137096e-02f, -5.18447794e-02f, -2.54264679e-02f, 2.16931030e-02f, -1.91572756e-02f, 5.40682077e-02f, -1.15229888e-02f,
  -1.58812283e-04f, 1.41693413e-01f, 1.49891824e-02f, 1.36468872e-01f, 6.67456016e-02f, -3.23975161e-02f, -3.37869041e-02f, 4.98373955e-02f, -9.94090661e-02f, -5.70660867e-02f,
  1.03799723e-01f, 7.67894182e-03f, -1.35735616e-01f, 2.13720575e-02f, 5.49867116e-02f, 6.55618235e-02f, 7.12206140e-02f, -1.12406025e-02f, 1.05958618e-01f, 3.62022151e-03f,
  4.52186242e-02f, -6.61728680e-02f, -3.81070636e-02f, 2.84909252e-02f, -1.62847027e-01f, 4.47097830e-02f, 7.27019161e-02f, -3.37512307e-02f, -9.08625945e-02f, -8.74276981e-02f,
  -2.74179559e-02f, 3.85464616e-02f, -4.54890579e-02f, 2.51896624e-02f, -1.72176363e-03f, 5.78443566e-03f, -5.91182820e-02f, -1.53970979e-02f, -7.62498453e-02f, 3.83920856e-02f,
  8.37149024e-02f, -6.61037117e-03f, -3.15187871e-02f, 6.16834536e-02f, -8.33531693e-02f, 5.46573177e-02f, 4.15010899e-02f, 1.09076640e-02f, -6.58005700e-02f, 9.33625624e-02f,
  -6.44382536e-02f, -1.67559415e-01f, -1.46986902e-01f, -7.73117021e-02f, 6.27641240e-03f, -4.39991504e-02f, -1.08365968e-01f, -2.94011198e-02f, 6.46423409e-03f, -3.98095278e-03f,
  -2.40620133e-02f, 1.56296998e-01f, 4.24647480e-02f, 1.17671028e-01f, -7.44779268e-03f, -1.14994779e-01f, -4.97801676e-02f, -3.86204980e-02f, -5.74136246e-03f, -2.03307066e-02f,
  -7.98923224e-02f, -8.09589252e-02f, 6.57099718e-03f, 1.35184959e-01f, -4.38427180e-02f, 1.06422275e-01f, -1.52163818e-01f, -7.87697509e-02f, -1.53564783e-02f, -1.45057261e-01f,
  -4.39164899e-02f, 1.53084502e-01f, 6.94371983e-02f, 7.31941611e-02f, -1.13011040e-01f, -1.04061738e-02f, 4.66478243e-02f, 1.88753419e-02f, 6.04391620e-02f, 2.58685555e-02f,
  6.71793520e-02f, 6.05401807e-02f, 2.51123086e-02f, -5.26076034e-02f, -8.50055143e-02f, -7.85358474e-02f, 3.47579904e-02f, 5.51690795e-02f, 1.03040136e-01f, 7.19561353e-02f,
  -1.80084389e-02f, 9.52735320e-02f, 5.77045698e-03f, -4.61130440e-02f, 1.49505660e-01f, 8.16973746e-02f, 4.42590378e-02f, 2.93830652e-02f, 3.45777757e-02f, 1.08845480e-01f,
  -3.02263536e-02f, 2.07105447e-02f, 1.09989412e-01f, 8.13881457e-02f, -4.97265272e-02f, 2.54292525e-02f, 4.34791408e-02f, -9.88506302e-02f, -5.29296510e-02f, -1.88924223e-02f,
  1.16114970e-02f, -4.27195482e-04f, -7.68001229e-02f, -5.97011372e-02f, 7.49326646e-02f, -6.26820177e-02f, 8.25990457e-03f, 7.87870958e-02f, -2.30757184e-02f, -1.77369732e-02f,
  -8.04307759e-02f, 5.63848671e-03f, -8.71617347e-02f, 4.98507544e-02f, -3.33418250e-02f, 5.87998591e-02f, 9.69780236e-02f, -4.78333719e-02f, 4.84304987e-02f, 1.09858155e-01f,
  9.63978283e-03f, 2.37215478e-02f, -3.09313424e-02f, 5.73938079e-02f, -1.44243678e-02f, 4.70652543e-02f, -2.83717476e-02f, -5.83074987e-02f, -5.46931289e-02f, -2.40494311e-02f,
  1.00561380e-01f, -8.31946656e-02f, -1.16793007e-01f, 6.41803518e-02f, -8.01447630e-02f, 7.40040466e-02f, 1.03650160e-01f, 1.43039837e-01f, 5.13189547e-02f, 8.69697630e-02f,
  2.84701232e-02f, 1.86150763e-02f, 4.94899414e-02f, -8.77054706e-02f, 8.07474926e-02f, 6.08021254e-03f, -1.36652598e-02f, 1.40439775e-02f, 5.18590249e-02f, -4.83305044e-02f,
  -1.36513673e-02f, 7.31479377e-02f, -1.30374625e-01f, 5.27508743e-02f, 3.33922952e-02f, 4.14174907e-02f, 8.42827037e-02f, 1.06252939e-01f, 2.21747719e-02f, 6.28753230e-02f,
  5.17830700e-02f, -5.91478497e-02f, 2.53853239e-02f, -6.16760924e-02f, 1.05051813e-03f, -7.59855434e-02f, 3.52342576e-02f, -1.05044059e-01f, -5.10997809e-02f, -6.85765296e-02f,
  -7.85171688e-02f, -8.37521628e-02f, -2.19424330e-02f, -1.03229783e-01f, 2.18985528e-02f, -3.38769741e-02f, -6.05625585e-02f, -8.89845267e-02f, -5.20934500e-02f, -6.97830170e-02f,
  -4.59063463e-02f, 1.42900608e-02f, -8.23571533e-02f, 2.64675524e-02f, 2.70930910e-03f, -3.61502431e-02f, -6.98918253e-02f, -8.13764855e-02f, 1.27087841e-02f, -1.86421294e-02f,
  4.03744280e-02f, -3.98086160e-02f, 9.08188969e-02f, -3.95285040e-02f, -7.58905634e-02f, -6.95972219e-02f, 3.81045491e-02f, 3.05560920e-02f, 3.88527848e-02f, 5.16849458e-02f,
  3.55976750e-04f, 7.45519698e-02f, -6.85493872e-02f, -7.36796856e-02f, 4.97968905e-02f, -9.72710401e-02f, -8.39269534e-02f, 9.51028522e-03f, 1.77228488e-02f, 7.80899599e-02f,
  -2.32756231e-02f, -2.34722756e-02f, -5.28742494e-05f, -5.37750833e-02f, 3.35043967e-02f, -1.46921109e-02f, 3.81681807e-02f, 1.03243720e-02f, -8.25494602e-02f, -5.12025505e-02f,
  5.07800095e-03f, 7.83257484e-02f, -6.56875372e-02f, -4.35265638e-02f, -9.42382589e-02f, -9.03440043e-02f, 8.41691718e-02f, 5.11645004e-02f, -8.19273368e-02f, 4.45778631e-02f,
  2.33050250e-02f, -6.13990054e-02f, 4.53100987e-02f, 1.18900696e-02f, -4.26721871e-02f, -4.89012972e-02f, 1.15482649e-02f, -3.06663048e-02f, 3.32621299e-02f, 1.99953448e-02f,
  9.51478332e-02f, 8.27671513e-02f, 4.34871279e-02f, 1.00903343e-02f, -9.69820097e-02f, -9.98037234e-02f, 6.06344566e-02f, -7.57893249e-02f, -5.34093454e-02f, 1.11600058e-02f,
  -2.86347307e-02f, -9.35653690e-03f, -1.40202539e-02f, 3.96212190e-02f, -6.46286756e-02f, 6.29653111e-02f, 9.81835052e-02f, 2.06853803e-02f, -3.74942906e-02f, 7.67457783e-02f,
  2.79462663e-03f, -5.46136796e-02f, 2.25720461e-02f, 6.97222129e-02f, -9.25542861e-02f, 2.71810926e-02f, -6.72184527e-02f, -1.04088068e-01f, 3.92187685e-02f, -5.16582504e-02f,
  -4.32571560e-01f, 8.41132700e-02f, -7.62769859e-03f, -1.19937457e-01f, 1.23004340e-01f, 1.05404094e-01f, 1.43726170e-01f, 1.34117305e-02f, -7.00259209e-02f, 6.47112057e-02f,
  4.06005420e-02f, -4.75108847e-02f, 2.27380116e-02f, 1.07664436e-01f, -3.35388863e-03f, -5.50635308e-02f, -2.41742004e-02f, -6.24124669e-02f, -5.35126179e-02f, 7.57628307e-02f,
  2.77557988e-02f, -1.92731485e-01f, -2.23897159e-01f, 2.32586097e-02f, 4.88931462e-02f, -4.49285097e-02f, -2.10653860e-02f, -6.85845986e-02f, 3.06612328e-02f, 5.46925701e-02f,
  -6.84863403e-02f, -4.75604720e-02f, -3.50985164e-03f, -1.00177579e-01f, 3.59443179e-03f, 2.03196947e-02f, 5.02440929e-02f, -1.61083844e-02f, -5.74042909e-02f, 1.89864295e-04f,
  -1.06980920e-01f, -3.04301158e-02f, -1.97040918e-03f, -1.34871587e-01f, 2.40264125e-02f, 4.60356101e-02f, -5.32243364e-02f, -8.12989026e-02f, -2.62496304e-02f, -1.65142529e-02f,
  4.15559225e-02f, 5.51951341e-02f, -5.89690618e-02f, 7.18928725e-02f, 6.76233098e-02f, 9.44372453e-03f, -6.15210570e-02f, 6.25325693e-03f, 2.61552050e-03f, -2.29938496e-02f,
  3.60210799e-02f, 1.91171486e-02f, -7.04763979e-02f, 2.07400173e-02f, -5.15453592e-02f, -2.58762836e-02f, -2.58349013e-02f, -5.26224868e-03f, 5.82621060e-02f, -3.10203414e-02f,
  2.60489322e-02f, 8.75838101e-02f, 2.67011393e-03f, -2.08882634e-02f, -5.68860024e-03f, 7.45838881e-03f, 3.24060656e-02f, -1.16409613e-02f, 1.40558362e-01f, -6.62900787e-03f,
  2.02933457e-02f, 4.00248654e-02f, -8.79620388e-02f, -3.86419557e-02f, 1.10598281e-01f, 1.25982508e-01f, -4.13903184e-02f, -3.28361429e-02f, -7.70981312e-02f, -1.06280416e-01f,
  -2.66179025e-01f, 1.72742531e-01f, -1.08530588e-01f, -5.57853691e-02f, -1.12593561e-01f, 6.13376610e-02f, 1.60034504e-02f, -1.41991768e-02f, -5.55570461e-02f, -6.38204142e-02f,
  -4.82065603e-02f, 3.97668183e-02f, -7.65497535e-02f, -1.67449601e-02f, -6.62354976e-02f, -6.29602820e-02f, -1.10730551e-01f, -1.55079849e-02f, 8.37299079e-02f, -4.10916321e-02f,
  3.67614180e-02f, 1.08394817e-01f, 5.54516986e-02f, 3.52549367e-02f, -1.88308693e-02f, 6.96874931e-02f, -6.02662154e-02f, -6.27683401e-02f, -2.48498321e-02f, -9.18145850e-02f,
  1.52872279e-01f, -2.73908198e-01f, -7.82409608e-02f, -5.42909764e-02f, 7.51794800e-02f, 8.45092237e-02f, -1.26371741e-01f, -1.83765423e-02f, 6.30664378e-02f, -1.53480962e-01f,
  -1.32752627e-01f, 1.13514259e-01f, -4.54531051e-02f, -1.35861598e-02f, 8.15625712e-02f, 4.35885750e-02f, -4.80645783e-02f, 1.15967244e-01f, 1.80812478e-01f, 5.58790304e-02f,
  -1.25897914e-01f, -2.68778186e-02f, -1.34280503e-01f, -7.70234615e-02f, -3.99047397e-02f, -1.01426458e-02f, -6.16401061e-02f, -7.48790652e-02f, 7.36091658e-02f, -4.36712131e-02f,
  -2.20854152e-02f, -9.82760489e-02f, 7.34504983e-02f, 6.22271979e-03f, -5.56351803e-02f, 7.81687722e-02f, -3.58401500e-02f, -5.90652004e-02f, -4.45328541e-02f, 1.37647111e-02f,
  -2.41761617e-02f, -2.59549934e-02f, 1.32389173e-01f, -6.56479001e-02f, 1.50596062e-02f, 6.51270747e-02f, -1.11227341e-01f, -1.39582772e-02f, -1.82287749e-02f, -2.30234619e-02f,
  -1.31165218e-02f, 3.67940962e-02f, -9.90380719e-02f, -3.37728076e-02f, 5.93226142e-02f, 6.20480999e-02f, -1.64533764e-01f, -2.04025656e-02f, -7.91112632e-02f, -1.93438634e-01f,
  -1.58827119e-02f, 1.62695777e-02f, -2.90081538e-02f, -3.79821546e-02f, -2.78412588e-02f, 4.67673428e-02f, 9.66332555e-02f, 7.96986669e-02f, 4.05231025e-03f, -4.09980491e-02f,
  -1.32381087e-02f, -1.27513111e-01f, -5.07436357e-02f, -6.51792344e-03f, -1.33130446e-01f, -7.40666613e-02f, 2.01946776e-02f, -4.04366665e-02f, 5.82314283e-02f, 1.40177429e-01f,
  2.69403271e-02f, 1.01407897e-02f, 1.24340523e-02f, 1.16352756e-02f, -4.97134775e-02f, 4.36241850e-02f, 3.86228673e-02f, -9.49175190e-03f, 5.02557084e-02f, 3.81226465e-02f,
  -1.00081190e-02f, 6.92331642e-02f, 9.11677107e-02f, 2.81441305e-02f, 5.54183647e-02f, 1.47314453e-02f, 2.60930285e-02f, 5.13983481e-02f, 1.85957570e-02f, 8.46008509e-02f,
  -1.20445658e-02f, -5.63338445e-03f, 5.54749854e-02f, -7.39284903e-02f, 2.10711937e-02f, 1.19574271e-01f, -8.85517001e-02f, 4.96490747e-02f, -1.03390943e-02f, 7.48025253e-02f,
  -1.13647267e-01f, 8.06390271e-02f, 1.13508008e-01f, 2.96987798e-02f, 6.88690394e-02f, 2.04874754e-01f, 1.42549407e-02f, 8.50066394e-02f, 1.20176516e-01f, 1.25130732e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.96644515e-02f, 9.40363556e-02f, 1.22997407e-02f, 8.79757106e-02f, 2.73641497e-02f, 5.94559573e-02f, 1.89229418e-02f, -5.57783525e-03f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.18702927e-01f, 8.66617411e-02f, -2.79509813e-01f, 3.19403976e-01f, -8.59412551e-02f, -1.35099217e-01f, -1.67068049e-01f, 1.71654709e-02f, 4.50473800e-02f, -1.19426273e-01f,
  -1.38119057e-01f, -1.36461765e-01f, -8.02397951e-02f, 1.74625114e-01f, 1.98179394e-01f, -7.07195029e-02f, -3.56128544e-01f, 2.73015022e-01f, -4.72783297e-02f, 2.50784069e-01f,
  1.83894023e-01f, 9.89020243e-02f, -3.41306180e-01f, -1.43474758e-01f, 1.95273627e-02f, 7.57047087e-02f, -1.62235975e-01f, -2.79814035e-01f, 2.12271869e-01f, -1.26017630e-01f,
  3.44282299e-01f, -1.45453230e-01f, -2.37717368e-02f, -1.92945182e-01f, -1.55048147e-01f, -5.35851792e-02f, -1.39075324e-01f, -2.63555110e-01f, -8.09554085e-02f, -2.04201229e-02f,
  -1.80944815e-01f, -1.47872895e-03f, -4.52850163e-02f, -4.38169539e-01f, -2.38470837e-01f, 2.01401144e-01f, 3.14219133e-03f, -4.11343426e-01f, -1.87285215e-01f, 1.23801604e-01f,
  -2.99500138e-01f, 3.51633281e-01f, -1.22922316e-01f, 2.56264895e-01f, -1.30725335e-02f, 1.93581566e-01f, 1.01541243e-01f, 1.91242680e-01f, 4.98916209e-02f, 9.45460722e-02f,
  -1.20649986e-01f, -1.55033367e-02f, 7.05691986e-03f, -9.95176509e-02f, 7.48642087e-02f, -1.92141369e-01f, 7.16990035e-04f, -6.44654632e-02f, 1.08584866e-01f, 1.60758212e-01f,
  -2.99230069e-02f, 1.01227082e-01f, -2.56010056e-01f, -8.69227424e-02f, -6.76220879e-02f, -4.36155349e-02f, -6.02700561e-02f, 1.31855577e-01f, -1.96239710e-01f, -5.87640284e-03f,
  1.52313337e-01f, -1.48631394e-01f, 1.22295871e-01f, 6.77636266e-03f, 1.87820956e-01f, -1.28261209e-01f, -6.68085963e-02f, -1.23069346e-01f, 2.04403102e-01f, -5.61223514e-02f,
  -1.00606300e-01f, -1.81943625e-01f, 4.92911115e-02f, 1.06854007e-01f, -2.26291999e-01f, 6.62979707e-02f, 5.62411286e-02f, 6.40011951e-02f, -1.70057729e-01f, 2.25141346e-01f,
  -1.17291018e-01f, -3.18991169e-02f, -2.09639683e-01f, -6.50462089e-03f, 1.89313442e-02f, -1.99034348e-01f, -1.66620519e-02f, 1.09502032e-01f, -1.31880958e-02f, 1.72693118e-01f,
  3.50401108e-03f, 2.38376483e-01f, 1.94638163e-01f, 1.39289320e-01f, 2.17730775e-01f, -5.04442155e-02f, -4.26371163e-03f, -2.45194912e-01f, -1.18202176e-02f, -1.47014782e-01f,
  1.44787058e-01f, -2.26315439e-01f, 3.03241849e-01f, -1.17775723e-01f, 2.34767884e-01f, 2.16949463e-01f, -4.19159159e-02f, -1.12883709e-01f, -1.96462035e-01f, 4.68465686e-02f,
  8.95291716e-02f, 3.95913303e-01f, -2.70294964e-01f, -3.41334902e-02f, -3.50832880e-01f, -1.34149581e-01f, 3.14524621e-01f, -1.51965916e-01f, -4.72864695e-03f, 1.09674580e-01f,
  2.20071562e-02f, -9.23276588e-04f, 5.51814251e-02f, 3.59783113e-01f, -1.85513832e-02f, 4.80388254e-02f, 2.38061994e-01f, -4.72630486e-02f, -2.88432706e-02f, -1.11494273e-01f,
  -1.63809553e-01f, -1.92416295e-01f, 9.74809006e-02f, 3.07323545e-01f, 2.49679074e-01f, 1.72734082e-01f, 4.39693220e-02f, 1.58132479e-01f, 1.19196102e-01f, -1.70988888e-01f,
  2.54643530e-01f, -2.51189560e-01f, 1.27479909e-02f, -3.91216308e-01f, 2.61943992e-02f, 2.89359957e-01f, -6.61267936e-02f, -7.83403516e-02f, -5.83138801e-02f, 1.79103129e-02f,
  5.85678848e-04f, 7.62963295e-02f, 2.89127082e-01f, -3.31429571e-01f, 3.23701166e-02f, -1.84236646e-01f, 7.60232732e-02f, -2.21155524e-01f, 1.06943510e-01f, -1.00707553e-01f,
  -1.83497936e-01f, -3.04828972e-01f, 3.52254480e-01f, 1.95643753e-01f, -1.27414122e-01f, 1.59269899e-01f, 2.38422602e-01f, 3.59836817e-01f, 9.37785283e-02f, -9.50538516e-02f,
  -4.03150886e-01f, 1.84990421e-01f, 1.26482889e-01f, 1.38291523e-01f, 1.05584346e-01f, -3.26867431e-01f, -1.97064374e-02f, -2.22768888e-01f, 1.94339782e-01f, 1.93056881e-01f,
  -1.78528801e-01f, 1.87217206e-01f, -4.31868546e-02f, 5.79110123e-02f, -2.04461992e-01f, -1.46268129e-01f, 2.53438920e-01f, -2.04220533e-01f, 9.90932900e-03f, -2.91388556e-02f,
  -2.80467242e-01f, -6.73894286e-02f, -2.45529115e-01f, 1.99986860e-01f, 3.40389431e-01f, 1.83159932e-01f, -7.17646405e-02f, -7.71035329e-02f, -1.84612006e-01f, -1.12056891e-02f,
  6.86026365e-02f, 1.34273931e-01f, -9.29858610e-02f, 3.36769909e-01f, -3.73708159e-01f, -6.39595166e-02f, -2.26343200e-01f, 1.45919189e-01f, -7.96259716e-02f, -1.68088585e-01f,
  -1.43735141e-01f, 8.15481693e-02f, 2.26313055e-01f, -4.60027345e-02f, 3.33273225e-02f, -1.11780554e-01f, -7.90499672e-02f, -5.96258044e-02f, 2.65201151e-01f, -7.53377378e-02f,
  -1.67744666e-01f, 3.16772163e-01f, -6.26301244e-02f, 3.95337865e-02f, -6.16135448e-02f, 1.05292965e-02f, -3.39933783e-02f, -1.19510069e-01f, -1.89675808e-01f, 1.22111015e-01f,
  2.22563833e-01f, 1.97903261e-01f, 5.57981767e-02f, 2.19852373e-01f, 3.28740567e-01f, -1.31267399e-01f, 3.22041474e-02f, -1.76838845e-01f, 7.74651021e-02f, 1.43586636e-01f,
  -1.48562416e-01f, 7.84638226e-02f, -2.12479621e-01f, -1.27815872e-01f, 5.29757924e-02f, -9.71538424e-02f, 1.54108688e-01f, 2.54598409e-02f, 2.38613978e-01f, 3.05227607e-01f,
  -7.94890523e-02f, -6.38330653e-02f, -1.20046735e-02f, 6.88594878e-02f, 1.81407884e-01f, 1.72280252e-01f, 1.92655876e-01f, 1.52339756e-01f, -4.42946464e-01f, -3.55988204e-01f,
  -1.35994479e-01f, 1.46161795e-01f, 4.51788962e-01f, -2.15821221e-01f, 1.83286428e-01f, -6.86051995e-02f, 6.17022328e-02f, -2.13020388e-02f, 1.61539450e-01f, 2.39464045e-02f,
  2.65782475e-01f, 2.15598732e-01f, 1.59656405e-01f, 1.58676416e-01f, -5.47341444e-02f, 1.20150950e-02f, 1.88518874e-02f, -1.07261181e-01f, -2.23529503e-01f, 1.30121052e-01f,
  1.10664330e-01f, 5.43361064e-03f, -1.87379047e-01f, 1.92812905e-01f, -2.12628067e-01f, 1.66766077e-01f, 3.12383652e-01f, -1.03871316e-01f, 2.80178159e-01f, 6.63126409e-02f,
  -9.89588574e-02f, -1.34831026e-01f, 2.56251782e-01f, -3.71219993e-01f, 2.11575270e-01f, 2.21080482e-02f, -2.12625474e-01f, -3.86836231e-02f, 1.93253741e-01f, -2.44132131e-01f,
  -2.25139618e-01f, 1.44358175e-02f, -2.92291075e-01f, 8.90440643e-02f, 1.06463380e-01f, -2.25693747e-01f, -2.05421478e-01f, 2.91333664e-02f, 1.98594686e-02f, -1.75683603e-01f,
  -1.23995198e-02f, -2.37312123e-01f, -2.44690910e-01f, 2.90327698e-01f, -1.63124651e-01f, -1.03403121e-01f, -1.51055574e-01f, 1.25498441e-03f, 7.76967034e-02f, 2.03991532e-01f,
  2.37497121e-01f, 2.09159896e-01f, -1.57051370e-01f, 1.89442530e-01f, 1.42743796e-01f, 1.17620677e-01f, 2.98350882e-02f, -2.62749255e-01f, -1.14573084e-01f, 1.06348366e-01f,
  1.11553952e-01f, -5.77597767e-02f, 1.12443402e-01f, -2.72649061e-02f, 1.12703763e-01f, 1.45351589e-01f, 2.48856470e-03f, -3.13561708e-02f, 2.34476328e-01f, -1.52106404e-01f,
  -4.41616625e-02f, -1.52682677e-01f, -5.45955189e-02f, 1.54519603e-01f, -1.25803813e-01f, -7.82402828e-02f, -1.56648263e-01f, 3.14096101e-02f, -1.45271808e-01f, -1.02381945e-01f,
  1.58238396e-01f, -1.39568374e-01f, 1.16968937e-01f, 2.28321314e-01f, -4.32430319e-02f, 8.82226881e-03f, -6.72941729e-02f, -1.15235031e-01f, -2.43012294e-01f, 5.97569905e-02f,
  2.97366921e-02f, 1.19196407e-01f, -8.36961379e-04f, -1.78098693e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.22087002e-02f, 8.87160674e-02f, 8.78888741e-02f, -2.73763817e-02f, -6.25456199e-02f, 2.57505924e-01f, -7.17449710e-02f, 2.47498274e-01f, -1.86783001e-02f, -1.58558950e-01f,
  1.29704013e-01f, 1.59201533e-01f, 1.84944436e-01f, -1.78532749e-01f, -5.45518771e-02f, 3.87657881e-02f, 1.63569435e-01f, -1.42096832e-01f, -5.53344823e-02f, 7.21030012e-02f,
  -7.32186437e-02f, -2.70719916e-01f, 3.56423296e-02f, -1.08644247e-01f, -1.77501082e-01f, 1.17588207e-01f, 5.09586036e-01f, -3.25149894e-02f, 2.76968092e-01f, 1.51004922e-02f,
  -7.62978122e-02f, -1.61204487e-02f, -3.25015783e-02f, -3.26114930e-02f, -6.32114559e-02f, -1.88664928e-01f, 4.91438396e-02f, -7.94664770e-02f, 7.69818574e-02f, 5.08143976e-02f,
  9.97740030e-02f, 9.98455212e-02f, -1.46584865e-02f, -6.82007074e-02f, 3.27707939e-02f, 1.77491933e-01f, -1.18593507e-01f, -7.89739490e-02f, -8.67324173e-02f, -1.10274978e-01f,
  1.46436363e-01f, 4.16970104e-02f, -3.01737301e-02f, -9.57378969e-02f, 1.01556242e-01f, 1.31093428e-01f, 5.52226938e-02f, 1.92181349e-01f, 9.31925327e-02f, 1.65848136e-01f,
  1.71136469e-01f, -9.05858800e-02f, -1.48506746e-01f, 1.44841939e-01f, 4.74177748e-02f, -8.24039429e-02f, 4.08618972e-02f, 5.57580031e-02f, -1.26074687e-01f, 2.30032384e-01f,
  -1.45176619e-01f, 1.26940280e-01f, 4.91995998e-02f, -1.11449875e-01f, 5.13762385e-02f, 1.73102185e-01f, 2.31079221e-01f, -3.22228521e-02f, -1.78767219e-01f, 1.64491430e-01f,
  -2.10747510e-01f, 1.71200350e-01f, -4.93424982e-02f, -8.26319456e-02f, 4.09060903e-02f, -9.66497362e-02f, -2.61505008e-01f, 8.24525654e-02f, -4.22953926e-02f, -1.28507644e-01f,
  2.75869220e-01f, -9.51488242e-02f, -1.48665803e-02f, 6.45373613e-02f, -7.57657886e-02f, 7.77000338e-02f, 1.15033105e-01f, 5.48420288e-02f, 1.03755519e-01f, -1.17562912e-01f,
  1.10534085e-02f, -9.94951129e-02f, -1.21433672e-03f, -1.41518638e-01f, -1.61256358e-01f, 1.42705649e-01f, -9.01502818e-02f, -9.39561427e-03f, -1.76373780e-01f, -1.00387253e-01f,
  1.17806988e-02f, 2.04537645e-01f, 8.12087283e-02f, 1.25137493e-01f, -1.27183363e-01f, 3.53936739e-02f, -2.13318318e-02f, -2.77360361e-02f, -3.32276225e-02f, 1.97821576e-02f,
  -9.52679589e-02f, -8.99765342e-02f, -1.18764609e-01f, -1.32546932e-01f, -3.58489640e-02f, 6.30672555e-03f, -1.29920989e-01f, 6.89875111e-02f, 1.87092319e-01f, 1.20391194e-02f,
  -1.03585757e-01f, -4.18409966e-02f, -2.34459098e-02f, -1.92923844e-01f, -6.88228235e-02f, -1.19528860e-01f, 3.63577642e-02f, 3.22115235e-02f, -4.24328968e-02f, -3.17238979e-02f,
  7.13916346e-02f, -6.18347935e-02f, -7.96284303e-02f, -4.35632654e-02f, -1.12178355e-01f, 2.19217222e-02f, -6.01525754e-02f, 8.24546143e-02f, 2.59482097e-02f, 8.23253691e-02f,
  -3.22888494e-02f, 6.23922683e-02f, 3.57716568e-02f, 9.23835486e-02f, 9.03754234e-02f, -1.20350502e-01f, 1.90470871e-02f, 2.25353818e-02f, 1.16352020e-02f, 8.86481702e-02f,
  1.73634887e-01f, 1.14506401e-01f, 3.85572076e-01f, 8.76728222e-02f, 4.93202239e-01f, 2.06435293e-01f, 2.25058123e-01f, 8.60958919e-02f, 3.04766744e-01f, 2.19728604e-01f,
  -5.86597994e-02f, 2.72019446e-01f, -2.81938314e-01f, 5.82457006e-01f, -2.15872243e-01f, -8.13633949e-02f, 3.60880345e-02f, -1.39933929e-01f, -2.63535976e-01f, 2.97126085e-01f,
  4.58326191e-01f, 3.40797812e-01f, 9.44473594e-02f, 2.40335315e-01f, 4.22509432e-01f, -1.64750949e-01f, -2.78387100e-01f, -3.03608745e-01f, -1.53901026e-01f, 1.62851095e-01f,
  -6.38734996e-02f, -2.40942672e-01f, -1.37218922e-01f, -1.40142888e-01f, -4.47998680e-02f, 5.37291430e-02f, -4.78661992e-02f, 4.99326698e-02f, -3.96200549e-03f, 7.40991533e-02f,
  -9.36680585e-02f, -7.33380765e-02f, -1.41970709e-01f, 9.30896029e-02f, 1.59276694e-01f, 1.38235077e-01f, 1.86828189e-02f, -1.32012933e-01f, -7.08818659e-02f, -9.17909741e-02f,
  3.15192640e-02f, -1.50940761e-01f, 1.69075355e-01f, 1.89114392e-01f, 1.11579336e-01f, 1.50233023e-02f, -1.27363473e-01f, 1.67693168e-01f, 8.63159746e-02f, -1.31475434e-01f,
  -1.22466773e-01f, -1.11786179e-01f, -1.06135837e-03f, 6.42275612e-04f, 1.84993118e-01f, -1.66796878e-01f, 1.33597657e-01f, -1.26926973e-01f, -1.68786392e-01f, -1.45017743e-01f,
  1.10932268e-01f, 1.79340243e-01f, 4.94879205e-03f, -1.37710705e-01f, 2.11530942e-02f, -1.54787615e-01f, 3.54872197e-02f, -4.71452512e-02f, -7.83021823e-02f, -3.73597890e-02f,
  7.21266046e-02f, 4.38543744e-02f, -7.23918304e-02f, -7.53390342e-02f, -1.87366173e-01f, 4.16421518e-02f, -1.39626369e-01f, 1.34539977e-01f, 1.67896032e-01f, -9.36056748e-02f,
  1.76055953e-01f, -5.91254383e-02f, 8.55028406e-02f, -7.16919228e-02f, 1.77907199e-02f, -1.55974269e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.55169517e-01f, -5.13034165e-02f, 2.07571015e-01f, 1.28934428e-01f, 1.45031318e-01f, 1.49200037e-01f, -1.33695975e-01f, 5.99869713e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  9.71044376e-02f, 7.07144737e-02f, -1.53369650e-01f, -1.71406165e-01f, 3.09842173e-02f, -1.12411924e-01f, -2.45375410e-01f, 7.98138604e-02f, -7.84991905e-02f, -7.06516132e-02f,
  1.15309544e-02f, -2.05984339e-01f, -5.13481721e-02f, -5.28305024e-02f, 1.94924042e-01f, -2.85299242e-01f, -4.01446432e-01f, -3.77426818e-02f, 1.47412136e-01f, -3.40461701e-01f,
  -1.43707976e-01f, 1.20280951e-01f, 2.44875148e-01f, 3.03173035e-01f, -2.01906070e-01f, -1.46924451e-01f, -1.25945464e-01f, 1.58962965e-01f, 1.36879206e-01f, 4.67409670e-01f,
  1.41194582e-01f, 7.13078976e-02f, 1.59711063e-01f, -7.13407397e-02f, -7.98966438e-02f, -1.42820226e-03f, 2.21316472e-01f, -4.64354940e-02f, 1.41966820e-01f, 5.12523286e-04f,
  -1.17420845e-01f, -6.76337928e-02f, 1.44394130e-01f, 1.10328265e-01f, 2.82251209e-01f, -5.63345179e-02f, -9.35348403e-03f, 7.26001710e-02f, 1.30881980e-01f, -1.79857105e-01f,
  -3.56731176e-01f, 1.95771471e-01f, 4.33041364e-01f, 1.47303402e-01f, 2.32230961e-01f, -1.92964971e-01f, 1.67138174e-01f, -1.55605646e-02f, 2.46790558e-01f, -1.96919486e-01f,
  -2.49891486e-02f, -2.18439057e-01f, -1.29012227e-01f, -6.58278167e-02f, -3.50037992e-01f, -1.27287731e-01f, -3.70169729e-02f, -3.41256618e-01f, -2.72832900e-01f, -8.16785544e-02f,
  -2.12773189e-01f, 2.09448203e-01f, -6.45773411e-02f, -1.51911810e-01f, -4.14585210e-02f, 8.93362239e-02f, -2.47439340e-01f, -1.05293646e-01f, 1.90162256e-01f, 4.56502102e-03f,
  4.67303768e-02f, 4.29314077e-01f, -1.72218770e-01f, -2.56759673e-01f, 5.82597777e-02f, -3.12153082e-02f, -3.42629284e-01f, -1.32164419e-01f, 2.33097240e-01f, 1.46880135e-01f,
  2.53175914e-01f, -1.33039683e-01f, 1.08283032e-02f, -4.20426995e-01f, 1.21241756e-01f, 1.58943817e-01f, -1.16489105e-01f, 7.17852712e-02f, -8.50042924e-02f, 1.19662575e-01f,
  2.34142616e-01f, 2.57808924e-01f, -1.16461001e-01f, 1.56267419e-01f, 3.20762508e-02f, -6.79866299e-02f, -1.01076178e-01f, 1.14344782e-03f, 9.54279229e-02f, -3.89188498e-01f,
  1.12686167e-03f, 3.03522140e-01f, 2.52806336e-01f, -4.33244780e-02f, -2.72978306e-01f, 5.43481335e-02f, 2.77448762e-02f, 1.93488687e-01f, -2.34702855e-01f, -6.23039203e-03f,
  9.34955925e-02f, -2.38218576e-01f, 2.48231441e-01f, -6.15643896e-02f, -1.81907400e-01f, -2.56021142e-01f, -8.49374607e-02f, -1.99301064e-01f, 2.29252074e-02f, 1.02986440e-01f,
  -8.06072876e-02f, 1.59049019e-01f, 7.38728121e-02f, -2.87061464e-02f, 1.35094032e-01f, -9.45642442e-02f, -1.37023702e-01f, -1.09517299e-01f, 2.51138419e-01f, 6.74921945e-02f,
  2.37313613e-01f, -2.08817750e-01f, 2.25288272e-01f, 4.99222279e-02f, 1.70596782e-02f, -3.83000970e-01f, -2.17900917e-01f, -1.18976578e-01f, 1.93644717e-01f, 3.12685579e-01f,
  3.31590503e-01f, -2.29003169e-02f, -8.19729865e-02f, 8.62395316e-02f, -1.18160017e-01f, 1.39017686e-01f, -6.89105764e-02f, 4.13006932e-01f, -2.72267666e-02f, -1.36305913e-01f,
  -2.00501144e-01f, 1.41091511e-01f, 2.37792835e-01f, -9.46891531e-02f, -1.95494428e-01f, -9.89700407e-02f, 1.90706939e-01f, -1.17577583e-01f, 2.31945351e-01f, 2.65410393e-01f,
  -4.41328902e-03f, -2.21182872e-02f, -2.18299970e-01f, 5.41334093e-01f, -1.76732108e-01f, -2.10194513e-01f, -1.41492680e-01f, -8.02668333e-02f, 3.54068041e-01f, 7.54023716e-02f,
  -3.71936619e-01f, -3.18857223e-01f, 1.11355647e-01f, -2.87757397e-01f, 1.57179125e-03f, 9.16059166e-02f, -2.38959342e-01f, -5.36338128e-02f, 4.57269326e-02f, 9.34369043e-02f,
  1.74427912e-01f, 6.87510753e-03f, -3.57361175e-02f, -2.31910795e-02f, 1.04863621e-01f, -4.39443067e-03f, -1.05156533e-01f, 4.66838509e-01f, -1.56112522e-01f, 2.26649910e-01f,
  -9.35157984e-02f, 4.63952916e-03f, 4.30040620e-02f, 1.13849178e-01f, -4.69764888e-01f, -2.36919612e-01f, 3.13072026e-01f, -9.34969261e-02f, -2.63135195e-01f, 3.54043067e-01f,
  3.39129604e-02f, -3.18370283e-01f, -2.03486845e-01f, -1.43479437e-01f, -1.72356188e-01f, 8.64311978e-02f, 2.43433267e-01f, 7.43307769e-02f, 3.42386328e-02f, 3.56867015e-02f,
  9.21627954e-02f, 5.47375455e-02f, -3.20857987e-02f, 9.31406219e-04f, -2.10406706e-01f, -1.14062712e-01f, 8.57700258e-02f, 3.81642729e-02f, 3.88486870e-02f, 2.35251952e-02f,
  1.45204412e-03f, -1.74666122e-01f, 2.50654966e-01f, -8.38897824e-02f, -1.85273930e-01f, 6.47730008e-02f, 9.64711830e-02f, 1.49596050e-01f, -2.00466335e-01f, -7.79175386e-02f,
  1.89420898e-02f, 2.30059862e-01f, 1.25715643e-01f, 3.45775604e-01f, 1.57171369e-01f, -2.22179100e-01f, -1.65991560e-01f, -2.33015314e-01f, 2.27715597e-01f, 9.17242095e-02f,
  -1.78189762e-02f, -1.47727996e-01f, -6.19535241e-03f, -4.82037693e-01f, -1.13374390e-01f, -9.60767940e-02f, -6.48330897e-02f, 2.78706878e-01f, 1.08017012e-01f, -1.38002470e-01f,
  -2.45426819e-01f, -3.77332792e-02f, -3.07082921e-01f, 2.36021861e-01f, -1.10143341e-01f, -9.71200243e-02f, 4.60958667e-02f, -7.56438151e-02f, 1.23908423e-01f, 2.73526222e-01f,
  1.36957362e-01f, 6.83663040e-02f, -3.40181261e-01f, 1.16044648e-01f, 2.63335645e-01f, -3.13459903e-01f, -1.07687443e-01f, 5.30582257e-02f, 2.59277254e-01f, -9.10329819e-02f,
  1.18089877e-01f, 6.81234673e-02f, -1.09272227e-01f, -1.51813924e-01f, -1.01331994e-02f, 3.49652857e-01f, -8.98135640e-03f, -2.93231197e-02f, -2.04945371e-01f, 1.40013872e-02f,
  9.06102583e-02f, -2.10085195e-02f, -1.05767846e-01f, -2.05512896e-01f, -1.19657129e-01f, -1.61269978e-02f, 2.86927760e-01f, 2.79416710e-01f, -1.29010361e-02f, 1.66459411e-01f,
  -1.59293860e-01f, 1.76885128e-01f, -5.64927869e-02f, -1.36217058e-01f, -1.82821155e-01f, 2.96820641e-01f, 2.84565240e-01f, 4.77803871e-02f, -3.50693375e-01f, -5.12578905e-01f,
  -1.54935326e-02f, -2.08557636e-01f, 2.05914661e-01f, 1.87146515e-01f, -1.62087888e-01f, -9.32570994e-02f, -5.89873008e-02f, -3.95147204e-02f, -5.79578690e-02f, -7.79787451e-02f,
  -2.13002160e-01f, -6.34059981e-02f, -8.85836221e-03f, 3.79714780e-02f, -1.43645003e-01f, 1.91118419e-01f, -1.55310109e-01f, -6.70288056e-02f, 1.25539288e-01f, -8.69624689e-02f,
  -1.72554389e-01f, -1.27261847e-01f, -3.45159262e-01f, -2.06033558e-01f, -1.79970428e-01f, 1.07872710e-01f, -1.75727621e-01f, 4.48925883e-01f, 1.94819435e-01f, -1.46618158e-01f,
  -2.98115343e-01f, -2.36451462e-01f, -3.21616709e-01f, 1.84467018e-01f, -7.65057281e-02f, -4.53242585e-02f, -7.02191889e-02f, 1.75398901e-01f, -9.41260830e-02f, -3.57247233e-01f,
  -1.09439261e-01f, 9.69299767e-03f, 3.04890126e-01f, -2.29268838e-02f, 1.26558259e-01f, 2.71404624e-01f, 3.51051927e-01f, -1.53967775e-02f, 3.11119229e-01f, -4.86856438e-02f,
  3.03102702e-01f, 2.00530380e-01f, 2.07018554e-01f, 2.11885408e-01f, 1.83223963e-01f, 2.58393526e-01f, -1.15235835e-01f, -1.75783396e-01f, -7.46673346e-02f, -3.48770827e-01f,
  -9.41773430e-02f, 2.46427029e-01f, -1.80858463e-01f, -8.03330988e-02f, 1.90085694e-01f, 8.61578882e-02f, -1.38765648e-01f, 1.40986219e-01f, -1.74130853e-02f, -5.87327965e-02f,
  1.07823648e-01f, 4.12225753e-01f, 2.98507232e-02f, -1.73354208e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.69819921e-01f, 2.61905622e-02f, 2.17488006e-01f, 4.60976589e-04f, 1.72306582e-01f, 1.59894973e-01f, 1.04633979e-01f, 4.38612364e-02f, 4.90814745e-02f, -1.34011125e-02f,
  2.07596436e-01f, 6.41552061e-02f, 1.92086697e-01f, -1.52857035e-01f, 1.51047399e-02f, 9.18109119e-02f, 1.86356679e-01f, -2.24649221e-01f, -1.64209589e-01f, 1.83110423e-02f,
  5.89853562e-02f, 2.72941381e-01f, 3.23022380e-02f, 1.98041610e-02f, -2.63443980e-02f, 4.73485179e-02f, 2.16382369e-02f, -8.71488173e-03f, 8.29505548e-02f, 2.34734699e-01f,
  1.01405002e-01f, 1.00387588e-01f, 1.17969856e-01f, -7.79364109e-02f, 9.79952216e-02f, -2.09564552e-01f, -1.27431050e-01f, -8.36211592e-02f, -3.48631591e-02f, 1.59183070e-02f,
  5.87431015e-03f, -2.73400061e-02f, 2.78045952e-01f, 2.37438619e-01f, 4.20377403e-02f, -1.85897842e-01f, 1.06935166e-01f, 2.57646114e-01f, 2.82771111e-01f, -5.37600704e-02f,
  -1.91571698e-01f, 2.81488061e-01f, 3.42453182e-01f, -4.00165021e-02f, -1.27548754e-01f, -2.04152644e-01f, 5.20097196e-01f, 1.94370300e-01f, 9.63826030e-02f, -1.02737799e-01f,
  -2.45489907e-02f, 3.23172845e-02f, -2.89532263e-02f, 2.25021783e-02f, 3.45575511e-02f, 1.86998576e-01f, 2.35320814e-02f, 1.32805541e-01f, -1.53040290e-02f, -1.49430081e-01f,
  -6.08656965e-02f, 5.89766353e-02f, -6.55970499e-02f, 2.33502258e-02f, -1.29476890e-01f, 1.42586738e-01f, 1.52397528e-01f, -9.06607434e-02f, -2.37625048e-01f, 1.82201236e-01f,
  2.53186047e-01f, -1.85491219e-01f, 1.22686721e-01f, 1.06499061e-01f, 2.64047291e-02f, 8.84716809e-02f, -9.60058048e-02f, 3.35162692e-02f, 1.89115390e-01f, -1.97353125e-01f,
  8.76601785e-02f, 1.12175487e-01f, 1.10255614e-01f, -1.83359161e-01f, -1.78574651e-01f, 1.11884736e-01f, 3.09430450e-01f, -1.57949030e-02f, 2.07098220e-02f, 8.15205425e-02f,
  1.02485478e-01f, -2.77095467e-01f, 3.29013050e-01f, -1.40542001e-01f, 2.69908488e-01f, 1.12689808e-01f, 1.25225812e-01f, 5.68021275e-02f, 3.98792624e-01f, 2.76563793e-01f,
  -3.59637514e-02f, -9.38933641e-02f, 1.43126294e-01f, -1.69809312e-01f, 1.04549780e-01f, 2.92487890e-01f, -6.88283965e-02f, 3.68415867e-03f, 1.19460352e-01f, 3.17871869e-02f,
  5.64348660e-02f, -1.27724543e-01f, -4.12202477e-02f, -1.78141221e-01f, -1.24118514e-01f, 2.62946993e-01f, -2.76695453e-02f, -2.05160663e-01f, -3.87811437e-02f, 1.46575933e-02f,
  1.82065904e-01f, 2.19173104e-01f, 2.46179938e-01f, 3.08817536e-01f, 2.59912431e-01f, -8.87009203e-02f, 6.02566525e-02f, 2.62800068e-01f, 1.32230863e-01f, 1.02238655e-01f,
  -1.38003305e-01f, 4.29814339e-01f, -8.79870951e-02f, -4.67300080e-02f, -1.49582222e-01f, -1.08132824e-01f, 2.42604166e-01f, 8.63867477e-02f, -8.33307728e-02f, -4.00676345e-03f,
  1.86527483e-02f, -3.26345600e-02f, -1.57748342e-01f, -1.50224296e-02f, -1.20533191e-01f, 1.46069840e-01f, 1.38657212e-01f, 6.17284656e-01f, -6.05575517e-02f, -3.06932461e-02f,
  -1.56290665e-01f, -3.36215040e-03f, 5.22257350e-02f, -7.16086105e-02f, -9.82813612e-02f, 4.13857074e-03f, -7.50445127e-02f, 1.26958653e-01f, 7.81646520e-02f, -6.83552474e-02f,
  1.17092378e-01f, -3.47906686e-02f, 8.98674279e-02f, 8.15252773e-03f, 2.73652300e-02f, -1.51795372e-02f, -1.68223828e-02f, 1.74896363e-02f, 1.71183228e-01f, -1.82242349e-01f,
  -1.23339050e-01f, 1.62281066e-01f, 7.87665322e-02f, 1.19832985e-01f, -3.55629921e-02f, 6.11262210e-02f, -2.04257653e-04f, 1.27287373e-01f, 1.12320021e-01f, 2.17090681e-01f,
  1.46834822e-02f, -1.57956481e-01f, 9.71947908e-02f, 1.83295354e-01f, -1.17437849e-02f, 7.92226791e-02f, -1.17501982e-01f, -5.00203632e-02f, 1.30178422e-01f, -1.67945459e-01f,
  1.89959481e-02f, -3.72168161e-02f, -4.30406667e-02f, 1.45570990e-02f, 1.98988337e-02f, 9.86351445e-02f, -2.17530861e-01f, 2.07084287e-02f, 8.08726028e-02f, -7.81796500e-02f,
  -7.97253028e-02f, 1.28128126e-01f, 1.43261537e-01f, -9.35287867e-03f, 2.05563113e-01f, -8.94451663e-02f, -1.41416371e-01f, 3.39332595e-02f, -6.10231124e-02f, -1.18362911e-01f,
  9.04972255e-02f, -3.19142416e-02f, -9.56442207e-02f, -9.80745330e-02f, -1.14542350e-01f, 1.37018755e-01f, -9.99371931e-02f, 1.25838920e-01f, -3.36057879e-02f, -2.06141546e-01f,
  -9.92920026e-02f, -1.06353760e-01f, -8.47264081e-02f, 7.13975281e-02f, 1.24926426e-01f, 1.89211309e-01f, 1.65575266e-01f, 1.65425334e-02f, -1.22270375e-01f, -8.20735991e-02f,
  -5.93737029e-02f, -1.05185278e-01f, -9.19620246e-02f, 5.75602241e-02f, 8.20796192e-03f, -1.74597621e-01f, 6.85348213e-02f, -1.14838213e-01f, 2.80283578e-02f, 1.35804415e-02f,
  1.51491046e-01f, -2.58067809e-02f, -2.15502977e-02f, -2.68225633e-02f, -9.25758108e-02f, 3.02128159e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.89579800e-01f, -4.43229154e-02f, 1.01543687e-01f, 1.27137259e-01f, 1.02937549e-01f, 5.51578999e-02f, 1.38148904e-01f, 1.72320664e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  4.63397875e-02f, 3.89719792e-02f, -2.38335565e-01f, -1.32609710e-01f, -2.37859022e-02f, -1.17509931e-01f, -2.72554427e-01f, -2.12008134e-01f, -2.50868022e-01f, 1.64767615e-02f,
  1.53584462e-02f, -1.65969923e-01f, 3.50757778e-01f, -3.77489835e-01f, -1.28362060e-01f, -5.17945290e-01f, -1.41040966e-01f, 3.86061907e-01f, 1.49660811e-01f, -7.04217255e-02f,
  4.43358511e-01f, 9.15173218e-02f, -4.93528582e-02f, -2.38613691e-02f, -6.26870021e-02f, -4.73176330e-01f, 8.10587965e-03f, 1.20118864e-01f, 2.72219926e-01f, 4.59280610e-02f,
  8.15779865e-02f, 5.93349263e-02f, 1.73222065e-01f, 6.00429960e-02f, -5.40598296e-02f, -7.48787299e-02f, 7.55646899e-02f, -2.17446744e-01f, 3.42310928e-02f, -2.78164148e-02f,
  1.30266882e-02f, -2.89204121e-01f, -2.24659309e-01f, -2.90134579e-01f, -1.52938545e-01f, -5.12032807e-02f, -8.39368328e-02f, -2.08752990e-01f, 6.15870170e-02f, 3.50543618e-01f,
  -2.45405644e-01f, 2.24503681e-01f, -8.67471024e-02f, 2.71122843e-01f, -1.06032021e-01f, 1.70597509e-01f, -3.22158309e-03f, -1.63778707e-01f, -8.63884613e-02f, 1.68199856e-02f,
  1.81634590e-01f, -1.35420471e-01f, -3.89652662e-02f, 7.38359019e-02f, 2.15694174e-01f, -9.05825868e-02f, 7.48678818e-02f, 9.43499282e-02f, 1.44379511e-01f, -2.54286528e-01f,
  -2.93522596e-01f, 2.29536351e-02f, -1.15084775e-01f, 9.92378443e-02f, 1.34421691e-01f, 1.55174956e-01f, 1.87718302e-01f, -4.62487817e-01f, 1.70854300e-01f, -1.09440528e-01f,
  -1.82764813e-01f, 2.96379358e-01f, 4.10854906e-01f, -1.04886957e-01f, 3.32409710e-01f, 8.78702477e-02f, 2.68159330e-01f, 1.59962252e-01f, -7.02657551e-02f, -2.56399423e-01f,
  -2.72215098e-01f, -2.23105639e-01f, 2.07941815e-01f, 1.53348073e-01f, 3.77621986e-02f, 5.15345437e-03f, 3.11234109e-02f, 2.09528521e-01f, -3.07843685e-02f, 7.95749947e-02f,
  1.12939350e-01f, 1.66965336e-01f, 1.24376163e-01f, 1.90909743e-01f, 3.09868276e-01f, 3.28792155e-01f, 1.58731833e-01f, -9.25520062e-02f, -1.57906801e-01f, 3.19193780e-01f,
  -3.20307016e-01f, 3.50899845e-01f, 1.54007897e-01f, -3.26020628e-01f, -2.85146832e-01f, -8.52677077e-02f, -2.25102365e-01f, -2.31130496e-01f, -2.91393578e-01f, 3.36156338e-01f,
  2.88965523e-01f, 1.19657777e-01f, -9.66753289e-02f, 3.50608230e-02f, 2.98905210e-03f, 5.63451461e-02f, 1.97565332e-01f, -1.00726016e-01f, 3.12597871e-01f, -1.24822021e-01f,
  4.12738979e-01f, 1.34045333e-01f, -1.35527169e-02f, 1.22813970e-01f, 7.34664500e-02f, 1.52244538e-01f, 2.65703171e-01f, -1.64117724e-01f, 2.17491895e-01f, 4.58996713e-01f,
  -7.12538883e-02f, 2.39294305e-01f, 3.90847057e-01f, 2.27138042e-01f, -2.61086047e-01f, -3.75176668e-01f, 2.87099689e-01f, -7.09284768e-02f, -1.37737580e-02f, -7.27316439e-02f,
  1.02972798e-01f, 8.21124613e-02f, 5.01762331e-02f, 3.03965181e-01f, -1.42710224e-01f, -3.68019968e-01f, -3.14322531e-01f, -1.26854897e-01f, -7.60159120e-02f, -1.09558336e-01f,
  -1.92059621e-01f, -2.52870739e-01f, 1.60975501e-01f, -5.28094657e-02f, 3.90286356e-01f, 1.28547162e-01f, -2.89163917e-01f, 2.32619420e-02f, -2.72201270e-01f, -5.01133204e-02f,
  3.47671777e-01f, 4.11440790e-01f, 1.80151641e-01f, -2.60777712e-01f, 3.32706064e-01f, 1.73858732e-01f, -1.02898143e-01f, -1.39174849e-01f, 2.62318581e-01f, 6.12838194e-02f,
  8.71997848e-02f, 1.84021950e-01f, 2.86593229e-01f, -1.08675472e-01f, -8.93218294e-02f, -7.33504305e-03f, 1.45656019e-01f, -2.13484585e-01f, -1.52523994e-01f, -3.79273705e-02f,
  -9.03576836e-02f, 7.98392594e-02f, 1.13636725e-01f, 2.57172376e-01f, -1.77905127e-01f, 2.43712276e-01f, 8.97991508e-02f, -6.41117096e-02f, -7.22385421e-02f, 4.28266287e-01f,
  3.58066964e-03f, -4.69763540e-02f, 7.12224692e-02f, -3.13206732e-01f, -4.49661523e-01f, 8.67337212e-02f, 1.03588350e-01f, 4.22266386e-02f, -3.34674060e-01f, 1.02900133e-01f,
  -3.56477678e-01f, 2.40637258e-01f, -1.85482472e-01f, 3.75698358e-01f, 1.78334564e-01f, 1.53969452e-01f, -6.50833845e-02f, -8.74203071e-02f, 1.30711384e-02f, 1.88999414e-01f,
  -3.06806806e-02f, -2.27947205e-01f, 1.79452792e-01f, 7.77881313e-03f, 1.17348671e-01f, 1.53052717e-01f, 1.99902609e-01f, 1.36178657e-01f, 9.23941806e-02f, 2.17823550e-01f,
  2.14125499e-01f, 5.94747551e-02f, 6.05080016e-02f, 1.18411303e-01f, -3.28814387e-02f, -2.95276821e-01f, -2.19971985e-01f, 1.35746494e-01f, -3.83329242e-01f, 2.33061180e-01f,
  2.68240601e-01f, -2.97458321e-01f, -3.03143650e-01f, -2.27183312e-01f, -3.18609625e-01f, -2.88689345e-01f, -1.39546826e-01f, 1.94175318e-01f, 8.25057998e-02f, -2.25968122e-01f,
  5.38754463e-02f, 1.26605332e-01f, 4.49056597e-03f, -5.31042321e-03f, -1.20418295e-01f, -1.03051431e-01f, -2.06307471e-01f, 1.41646326e-01f, -8.42575654e-02f, -2.41122469e-01f,
  1.35630086e-01f, -3.14560801e-01f, -1.39085695e-01f, -1.09054811e-01f, -3.29132617e-01f, -2.53789455e-01f, 2.07750395e-01f, 2.34777573e-03f, 2.31153425e-02f, -4.94679004e-01f,
  3.63401026e-01f, -1.98822469e-01f, -3.15902382e-01f, 3.12799990e-01f, 3.03571433e-01f, 2.98066199e-01f, 8.05959553e-02f, 3.15249383e-01f, 3.09477687e-01f, -2.13314801e-01f,
  -3.42188179e-01f, -2.33041868e-01f, -2.52258569e-01f, -1.05235018e-01f, 2.65313983e-02f, 1.83225453e-01f, -8.86545703e-02f, -9.66117531e-02f, -2.38535389e-01f, 7.23914206e-02f,
  -4.34398919e-01f, 1.46252930e-01f, -4.17722523e-01f, 1.72361627e-01f, -7.20634237e-02f, -2.64127441e-02f, -3.90701257e-02f, 9.03498605e-02f, -3.24328780e-01f, -3.35014254e-01f,
  -2.58531608e-02f, -2.54460096e-01f, -2.49541789e-01f, -4.57778066e-01f, 2.12880790e-01f, 4.51787382e-01f, -2.99964935e-01f, -1.84604041e-02f, 4.00748730e-01f, 5.21949530e-02f,
  -6.98750168e-02f, -6.33570999e-02f, -1.63801424e-02f, -2.24972814e-01f, 1.03275441e-01f, 3.36508572e-01f, 3.90176550e-02f, 8.65485072e-02f, -4.13641008e-03f, -7.00663626e-02f,
  -3.56470346e-02f, 2.00472418e-02f, -3.24492306e-01f, 2.07066685e-01f, -1.60045456e-02f, 3.61552358e-01f, 1.35357723e-01f, -9.87713933e-02f, 1.56827658e-01f, -4.65491181e-03f,
  -1.29607767e-01f, -2.72946298e-01f, -1.08190693e-01f, 1.69364765e-01f, -3.28530371e-01f, -1.83568984e-01f, 3.50642860e-01f, 1.91840991e-01f, -5.24196267e-01f, -1.26670986e-01f,
  -1.18822694e-01f, -2.88011849e-01f, -3.66390705e-01f, 1.11388735e-01f, 1.15610152e-01f, -1.15930945e-01f, 3.96919511e-02f, 3.00478280e-01f, 1.11706167e-01f, 7.96078742e-02f,
  2.09076986e-01f, 1.62343264e-01f, -1.99400097e-01f, 2.47863848e-02f, 3.91371325e-02f, -2.23696120e-02f, 4.92323525e-02f, 1.36643618e-01f, -6.05489453e-03f, 3.67717594e-01f,
  -1.62275421e-04f, 6.10815361e-02f, 1.30649477e-01f, -1.40959695e-02f, -4.73726839e-01f, 4.16152716e-01f, 1.43653765e-01f, 6.05692208e-01f, -1.77715451e-01f, -2.84514517e-01f,
  -3.32130462e-01f, 2.92169660e-01f, -6.98175192e-01f, -1.26222640e-01f, 6.11763708e-02f, -1.27548903e-01f, -7.38409013e-02f, 1.45717815e-01f, 2.65661955e-01f, 2.14782476e-01f,
  -1.57313973e-01f, -1.62592366e-01f, -2.93405261e-02f, 9.00627896e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  7.42677227e-02f, 9.98081490e-02f, -8.42624307e-02f, 5.55381551e-02f, -6.46267235e-02f, 2.14753926e-01f, 3.41326922e-01f, -1.93752512e-01f, 2.87240297e-01f, 4.34258223e-01f,
  1.32259294e-01f, -3.54083389e-01f, 4.78826582e-01f, -2.45611355e-01f, -3.81820500e-01f, -4.07710731e-01f, 4.86495405e-01f, 1.18612722e-01f, 4.32614923e-01f, -3.51441175e-01f,
  4.89224076e-01f, 1.21844128e-01f, -5.31689882e-01f, 6.42897636e-02f, 2.78781384e-01f, 8.81698355e-02f, -2.44518548e-01f, 8.74602199e-02f, 6.22448862e-01f, -2.73679011e-02f,
  -1.28229424e-01f, -1.98002189e-01f, 2.12294623e-01f, 1.52986065e-01f, 1.19914182e-01f, 2.66478837e-01f, 2.14064196e-01f, 2.81752318e-01f, -2.88263410e-01f, 2.42956087e-01f,
  2.02391982e-01f, 1.72155008e-01f, 8.04489478e-02f, -1.03736766e-01f, -7.23491386e-02f, -3.09328347e-01f, -5.37884682e-02f, -1.21295527e-02f, 1.71933360e-02f, 3.65492135e-01f,
  2.69344240e-01f, 1.65691804e-02f, 8.14438984e-02f, 1.87902316e-01f, 1.43008485e-01f, 2.94727832e-01f, -8.41478258e-02f, -3.04854270e-02f, 4.48794998e-02f, -1.01096764e-01f,
  2.93137789e-01f, -5.02507202e-02f, -1.07576540e-02f, 1.14611164e-01f, -7.17006903e-03f, 2.08251074e-01f, -1.52138367e-01f, 1.02786906e-01f, 1.39566079e-01f, -7.28884265e-02f,
  1.03964731e-01f, 8.13907832e-02f, 3.25710736e-02f, 3.10610920e-01f, 2.99133658e-01f, -3.58763784e-02f, -3.61090451e-02f, 2.71334350e-01f, 2.30582312e-01f, 2.52139062e-01f,
  -1.33332968e-01f, -4.42456067e-01f, 1.92900211e-01f, -5.60087375e-02f, -3.24354410e-01f, -1.98300734e-01f, -1.11397140e-01f, 1.62663236e-02f, 4.29799445e-02f, 6.25327304e-02f,
  8.83681849e-02f, 7.43817091e-02f, -1.29973337e-01f, -7.92559516e-03f, -1.38890937e-01f, 2.00977344e-02f, -8.58753696e-02f, 3.13849151e-01f, -1.53822333e-01f, 6.01249002e-02f,
  -3.56637865e-01f, 6.23861291e-02f, 2.66929328e-01f, -3.62232417e-01f, 1.06811866e-01f, -3.73275019e-02f, -2.85389572e-01f, -1.57017872e-01f, 2.63331205e-01f, 8.92605335e-02f,
  4.83795069e-02f, -4.69308570e-02f, 1.57723650e-01f, -3.39431576e-02f, -9.40426216e-02f, -6.80783466e-02f, -1.36985527e-02f, -6.56241328e-02f, -2.97670424e-01f, 1.18198358e-02f,
  1.50295079e-01f, -8.62565711e-02f, -1.12257181e-02f, 1.33609638e-01f, 1.47886589e-01f, 5.38582988e-02f, -1.13236263e-01f, 1.83728675e-03f, 8.43204781e-02f, 9.06944722e-02f,
  -7.69972950e-02f, -7.63213336e-02f, 1.95282385e-01f, -1.62762180e-01f, 1.62580132e-01f, 3.54491681e-01f, 1.94795758e-01f, -9.39580500e-02f, 8.01892206e-02f, -2.18305036e-01f,
  -1.49026126e-01f, 1.03784941e-01f, -1.21636800e-01f, -4.17822093e-01f, -4.47873361e-02f, 5.36810756e-01f, -2.07807675e-01f, 2.27324545e-01f, 5.34635782e-02f, 3.96635234e-01f,
  -3.23864877e-01f, 4.87110466e-02f, -6.16681166e-02f, -1.02728523e-01f, -5.24122501e-04f, 3.11601430e-01f, 3.62914890e-01f, -2.79902574e-02f, 1.97703227e-01f, 1.93381935e-01f,
  2.67817616e-01f, 1.21446848e-01f, 3.17699850e-01f, 3.12594417e-03f, -9.23079550e-02f, -6.91609159e-02f, 1.69200897e-01f, 2.86433231e-02f, 3.04837286e-01f, 2.51382291e-01f,
  1.43893836e-02f, -4.34999876e-02f, -2.23309293e-01f, 4.24395889e-01f, -1.27019942e-01f, 4.47810203e-01f, 3.77113074e-01f, -4.55908090e-01f, -8.36375132e-02f, -3.80503595e-01f,
  -3.07881624e-01f, -4.60736781e-01f, -2.81502545e-01f, 3.68211031e-01f, 2.89795667e-01f, 8.45414326e-02f, -1.26773193e-02f, -8.08405057e-02f, -4.24787067e-02f, -3.03418189e-02f,
  2.23723501e-02f, -9.90423635e-02f, 6.56811595e-01f, 2.70663589e-01f, 3.50776851e-01f, 4.40994918e-01f, 2.97049701e-01f, 4.71893042e-01f, -1.47444203e-01f, 4.54999596e-01f,
  1.71018496e-01f, 1.29477501e-01f, 5.88156044e-01f, -4.03418243e-02f, 9.86106023e-02f, -5.56809902e-01f, -3.99190933e-01f, 7.57560581e-02f, -1.26430422e-01f, -1.21477954e-01f,
  5.60708225e-01f, -3.56065184e-01f, -3.62130463e-01f, 1.93594292e-01f, 4.65490937e-01f, 3.07122201e-01f, -3.05445716e-02f, -4.55876619e-01f, -1.67672113e-01f, -1.31479844e-01f,
  2.13597849e-01f, -4.86504361e-02f, -2.76008528e-02f, -1.81774899e-01f, 6.39806166e-02f, 8.51767324e-03f, 1.58490151e-01f, -1.09892905e-01f, 2.55344480e-01f, -1.24977604e-01f,
  -2.07782879e-01f, -1.73380375e-02f, 1.12314291e-01f, -3.23138349e-02f, 3.38725328e-01f, -2.05721185e-02f, 3.47033054e-01f, -7.24045560e-02f, -2.26673186e-01f, -1.15057677e-01f,
  -7.94320107e-02f, 1.55066354e-02f, 1.64438292e-01f, -2.86838055e-01f, 4.53513674e-02f, 2.05006078e-01f, -7.71568855e-03f, 2.40468338e-01f, -1.19734690e-01f, -2.49061435e-01f,
  -9.61919278e-02f, -1.65294871e-01f, 2.96243101e-01f, 1.75450712e-01f, -1.50640830e-01f, 1.03580288e-03f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.33833134e-01f, 8.64396393e-02f, 2.18152598e-01f, 1.78231984e-01f, 2.98192531e-01f, 3.13049078e-01f, 3.50656003e-01f, -9.08821747e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -5.39276361e-01f, -2.64307678e-01f, -1.32529913e-02f, -2.04582602e-01f, -4.43714559e-01f, 1.70702130e-01f, 2.14716375e-01f, 4.11790520e-01f, -2.30718821e-01f, -5.69844663e-01f,
  3.05180609e-01f, -4.77170587e-01f, -2.49305218e-02f, -4.30999190e-01f, -5.95900595e-01f, 4.14510161e-01f, 3.08288932e-01f, 5.32561481e-01f, -2.31096864e-01f, -1.85962617e-02f,
  -3.60075563e-01f, 2.80441553e-03f, -6.08509719e-01f, 6.81186020e-02f, -5.17641664e-01f, -4.33927774e-01f, 5.13076484e-01f, -1.85687169e-02f, -1.87542588e-01f, 2.37684429e-01f,
  -6.86338127e-01f, -8.47219527e-02f, 4.08531308e-01f, 1.61695644e-01f, 8.52390379e-02f, 7.87444711e-01f, -8.44122842e-02f, 1.21367022e-01f, -2.71764308e-01f, 3.47312093e-01f,
  6.36635005e-01f, 1.91290498e-01f, -2.54704952e-02f, 6.73042297e-01f, -5.47013998e-01f, 1.89613417e-01f, 5.60559392e-01f, -1.54293403e-01f, 2.63931394e-01f, 7.44962469e-02f,
  5.92968941e-01f, -4.30528313e-01f, 4.78414088e-01f, -4.78953212e-01f, -3.93076390e-01f, 5.10378540e-01f, -6.24249935e-01f, 3.95144343e-01f, -1.43536657e-01f, -1.01865254e-01f,
  2.89995432e-01f, -4.24781501e-01f, 6.62699997e-01f, -2.25509599e-01f, 8.42654586e-01f, 9.72618088e-02f, 1.76414251e-01f, -3.85743946e-01f, 8.04126799e-01f, -1.27009496e-01f,
  1.54848978e-01f, -2.80449957e-01f, -4.37731683e-01f, 4.65147823e-01f, -2.44040325e-01f, 5.98912835e-01f, -4.16310519e-01f, -1.52748778e-01f, -4.20967042e-01f, 1.41211301e-01f,
  -3.09953064e-01f, -3.69854331e-01f, -1.12036183e-01f, 9.28491652e-02f, -1.34062350e-01f, -1.83939673e-02f, 5.61502814e-01f, -3.26638788e-01f, 4.80434656e-01f, -2.58445498e-02f,
  1.96924746e-01f, 7.65567645e-02f, -3.20408583e-01f, 2.39733264e-01f, 4.12931025e-01f, -4.57676984e-02f, -3.61703306e-01f, 1.14766963e-01f, -7.24968433e-01f, -4.32300895e-01f,
  4.27016884e-01f, -4.29385602e-02f, 3.07550430e-01f, -5.85505843e-01f, -8.45592842e-02f, 3.27207625e-01f, -5.13210654e-01f, -6.24088109e-01f, -3.40192199e-01f, 5.41679515e-03f,
  -1.86192632e-01f, -1.44193858e-01f, 2.35270597e-02f, -3.50737929e-01f, 2.38599584e-01f, 1.40730143e-01f, 5.01176357e-01f, -3.65179926e-01f, 3.32716316e-01f, 2.61454761e-01f,
  -4.37655985e-01f, -3.65482509e-01f, 1.39272434e-03f, 2.14609727e-02f, 8.47880393e-02f, 6.87226713e-01f, -3.68769020e-01f, -9.66206342e-02f, -5.03614604e-01f, 4.60446738e-02f,
  1.66256770e-01f, -3.06411296e-01f, -2.41488099e-01f, 1.02504594e-02f, -3.76571938e-02f, -1.35685086e-01f, -6.24950469e-01f, -3.95166814e-01f, 4.31709349e-01f, 5.62706828e-01f,
  -4.79837805e-01f, -1.28100231e-01f, -6.19602144e-01f, 1.87109962e-01f, 5.07353187e-01f, -3.36698204e-01f, -4.88555342e-01f, 2.05185622e-01f, 2.91703522e-01f, -6.11970007e-01f,
  2.91762233e-01f, 6.01405084e-01f, 3.52945775e-02f, -2.28819966e-01f, -7.24311247e-02f, 4.35343422e-02f, -8.47614408e-02f, 6.99049294e-01f, -3.80873114e-01f, -1.93731606e-01f,
  4.00601327e-01f, -8.70764479e-02f, -1.42051190e-01f, 1.66439235e-01f, 4.85106349e-01f, 3.93757850e-01f, 3.06077361e-01f, 5.90697750e-02f, 3.31044436e-01f, 3.86763006e-01f,
  2.42224187e-01f, 3.92151684e-01f, -1.10382251e-01f, -3.22863340e-01f, 2.85144866e-01f, 4.61160868e-01f, -3.80689725e-02f, 2.35568687e-01f, -8.27520266e-02f, 2.46023193e-01f,
  -5.69218755e-01f, -3.45460832e-01f, 1.30034000e-01f, -1.97446093e-01f, 2.46620998e-01f, 4.32073474e-01f, -3.29015076e-01f, -2.28914618e-01f, -3.00390810e-01f, -1.59811601e-01f,
  7.21486986e-01f, 3.11777979e-01f, -5.43598056e-01f, -1.11278221e-02f, 1.29739165e-01f, 3.07943314e-01f, -1.70432761e-01f, -6.18186183e-02f, -3.76091115e-02f, 4.21197005e-02f,
  5.04981637e-01f, -2.01277763e-01f, -2.97218204e-01f, -5.14914513e-01f, -4.36527990e-02f, 9.21210125e-02f, 3.60554814e-01f, -1.41404197e-01f, 1.87052578e-01f, -3.24912697e-01f,
  -2.34016955e-01f, -2.82186359e-01f, 1.47763669e-01f, 1.68877304e-01f, 2.08889529e-01f, -1.89236149e-01f, 7.07533062e-01f, -2.37123109e-02f, -2.40772888e-01f, 1.78118512e-01f,
  3.92814636e-01f, -4.38884318e-01f, -6.83651268e-01f, -1.76372796e-01f, 3.58155698e-01f, -1.61598414e-01f, 2.09271222e-01f, -2.27540269e-01f, -1.59017801e-01f, -6.81188405e-01f,
  -6.71341956e-01f, -9.65680555e-02f, -2.89260209e-01f, -2.14035586e-02f, -4.99064386e-01f, 2.57602692e-01f, 2.04158977e-01f, 4.36964810e-01f, -2.56652147e-01f, 1.67184725e-01f,
  -4.68796462e-01f, -2.15605572e-01f, 5.80407560e-01f, 3.02523792e-01f, -2.41305113e-01f, 5.45335114e-01f, 4.66852933e-02f, 3.62926245e-01f, 1.01641022e-01f, 1.93482384e-01f,
  -1.21237293e-01f, -8.04162920e-02f, 8.43416452e-01f, -1.30226761e-01f, -2.13526130e-01f, -2.31440216e-01f, -1.06642097e-02f, 5.13564534e-02f, -7.03487754e-01f, -1.28661543e-01f,
  2.69522995e-01f, -2.33542733e-02f, 1.98343143e-01f, -3.49080354e-01f, 1.33177832e-01f, 2.59125173e-01f, -6.27268776e-02f, -3.80060583e-01f, 7.43222594e-01f, 1.59470569e-02f,
  2.98496395e-01f, -9.10703719e-01f, 3.12737793e-01f, 5.56673646e-01f, -1.70999900e-01f, -7.06763327e-01f, 5.46501160e-01f, -1.39433406e-02f, -5.90789020e-01f, -5.80810964e-01f,
  -1.97698087e-01f, 3.51960927e-01f, -2.91545659e-01f, -1.57702759e-01f, 7.18290731e-02f, -2.25525320e-01f, 4.33037728e-01f, 2.96077698e-01f, 2.61577755e-01f, 4.84687388e-02f,
  4.83988613e-01f, 2.65706461e-02f, -9.17592496e-02f, -1.63397074e-01f, 3.93482447e-01f, 1.81317644e-03f, -4.72439855e-01f, -2.54557073e-01f, -3.78236353e-01f, 2.93003842e-02f,
  6.59412324e-01f, 4.57322635e-02f, -3.01279247e-01f, 3.83570343e-01f, -6.93753660e-01f, -5.82963787e-02f, -2.31850281e-01f, 1.91030830e-01f, -3.41911167e-01f, 6.28270328e-01f,
  2.61035115e-01f, -7.36761034e-01f, 6.74868643e-01f, -2.14181632e-01f, -2.74816602e-02f, 5.73639989e-01f, 5.19002136e-03f, -2.47459635e-01f, -4.02266860e-01f, -2.57958263e-01f,
  -1.55244529e-01f, -8.20679069e-02f, 6.43982470e-01f, -2.95336284e-02f, -4.15521562e-02f, 1.66579410e-01f, -7.25263059e-02f, -1.37612462e-01f, 3.71869773e-01f, -4.29138064e-01f,
  1.22433953e-01f, -1.88408509e-01f, -6.82294011e-01f, -1.41772866e-01f, 1.77492887e-01f, 3.30598861e-01f, 3.14090550e-01f, 2.16809392e-01f, 1.54342905e-01f, 2.82755107e-01f,
  -2.13346750e-01f, -9.96759683e-02f, -4.28160042e-01f, 5.62396109e-01f, -5.58454931e-01f, -1.27242818e-01f, 4.33753878e-01f, -1.88337266e-01f, -4.03809100e-01f, 2.99395204e-01f,
  7.37083793e-01f, 2.55520716e-02f, -4.00631160e-01f, -2.24668622e-01f, -2.38481507e-01f, 3.98494124e-01f, -3.08670074e-01f, 2.61679083e-01f, 1.93058269e-03f, -4.67334650e-02f,
  1.14181481e-01f, 2.59278387e-01f, 2.34574169e-01f, -4.97963011e-01f, 1.48979351e-01f, 3.29819769e-01f, 4.46202427e-01f, -2.27286369e-01f, -6.01310074e-01f, 7.19842687e-02f,
  1.52385309e-01f, -2.04142407e-01f, 1.45695895e-01f, 5.61743975e-01f, -4.98806685e-02f, -2.22597435e-01f, 5.37080407e-01f, 9.02349874e-02f, -2.97990888e-01f, -4.43856359e-01f,
  4.41059291e-01f, -4.23287898e-01f, 2.67214715e-01f, 4.88940269e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.87872291e-01f, 2.91239768e-01f, -2.12828234e-01f, -2.45919321e-02f, 9.70616713e-02f, -1.34167701e-01f, 8.44904333e-02f, -2.23579612e-02f, -1.41594578e-02f, -1.08092256e-01f,
  -1.51511967e-01f, -4.96453866e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    