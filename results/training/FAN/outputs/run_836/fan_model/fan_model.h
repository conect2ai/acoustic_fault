/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.86089645e-02f, 1.58266112e-01f, 4.14814591e-01f, -6.79146964e-03f, 1.38518691e-01f, 1.66853458e-01f, 3.55983287e-01f, 2.24199351e-02f, -1.35799050e-01f, 8.26360583e-02f,
  -2.88362615e-02f, -7.45806172e-02f, 1.16965145e-01f, 3.57516594e-02f, 2.64891148e-01f, 3.87791902e-01f, 3.28240067e-01f, 1.99587733e-01f, 9.59386975e-02f, 2.03433465e-02f,
  -8.61985907e-02f, -1.60548817e-02f, -1.72194973e-01f, -2.64318450e-03f, -6.55444935e-02f, -4.90851402e-02f, 6.12209085e-03f, -2.25586109e-02f, 4.36456054e-02f, 1.46813348e-01f,
  1.55856848e-01f, -3.43839899e-02f, 2.99495962e-02f, -8.02421570e-03f, -1.92310300e-03f, 2.45480686e-02f, -4.02178802e-02f, -9.78976563e-02f, -1.09592475e-01f, -1.00512855e-01f,
  -2.25113295e-02f, -1.07254675e-02f, -1.19695077e-02f, -3.27520967e-02f, -4.13571820e-02f, 3.21579985e-02f, -9.59448069e-02f, 4.65980507e-02f, 3.66273671e-02f, 7.60198981e-02f,
  -8.88596624e-02f, -2.68836636e-02f, 2.44877692e-02f, 1.54356007e-02f, 7.03984350e-02f, 5.32849915e-02f, -6.31956235e-02f, -5.39256819e-02f, 9.44272894e-03f, -5.63729405e-02f,
  1.01731226e-01f, -5.15984464e-03f, 1.75670173e-03f, -4.15777750e-02f, -5.40429202e-04f, -1.01422824e-01f, -7.03325169e-03f, -3.99361849e-02f, 1.78092867e-02f, -5.08276038e-02f,
  -3.26816626e-02f, 6.35446683e-02f, -8.93160328e-03f, 6.53566569e-02f, -7.59347379e-02f, 7.68330647e-03f, -2.34358907e-02f, 7.19337538e-02f, -1.10152792e-02f, -1.46174124e-02f,
  -2.85969935e-02f, -1.48196638e-01f, -1.92643870e-02f, -1.01364568e-01f, 9.46064442e-02f, 3.46554369e-02f, -1.24774035e-02f, 7.76475295e-02f, -3.52180004e-02f, -6.52532950e-02f,
  -2.48224705e-01f, 2.44968876e-01f, -3.49504948e-02f, 4.47301492e-02f, 3.98770086e-02f, -3.94905843e-02f, -4.81083849e-03f, -5.84663637e-03f, -2.82000564e-02f, 5.38639687e-02f,
  2.30130763e-03f, -5.94379082e-02f, 5.82673028e-02f, -9.06115547e-02f, -7.54232425e-03f, 2.48199590e-02f, -5.96876889e-02f, 3.64333130e-02f, 3.71291651e-03f, -3.43389958e-02f,
  -8.03354234e-02f, -2.70780884e-02f, -2.02687621e-01f, -3.24335657e-02f, -2.04692758e-03f, 6.42388314e-02f, -4.32901196e-02f, -6.52288273e-02f, 7.66674653e-02f, -1.38826892e-01f,
  1.42781250e-02f, 1.01275779e-01f, -6.41961336e-01f, 2.46103406e-01f, 2.85172164e-01f, 1.82550699e-01f, 2.32483953e-01f, 1.52862653e-01f, 2.42970940e-02f, 1.90380332e-03f,
  1.17271870e-01f, 1.03772040e-02f, -5.91744073e-02f, -1.34087384e-01f, -6.18203245e-02f, -6.51817471e-02f, -5.08338101e-02f, -3.16724658e-01f, -2.47700691e-01f, 1.06227994e-01f,
  3.38185757e-01f, 9.46352556e-02f, -1.07337581e-02f, -1.65593345e-02f, 1.39453253e-02f, 5.90417236e-02f, -2.72191286e-01f, 1.57753564e-02f, -4.16716821e-02f, -3.46390754e-02f,
  -4.03959125e-01f, -8.70072544e-02f, -1.17749749e-02f, 1.05380297e-01f, 2.80576479e-02f, -2.30068862e-02f, -4.40935865e-02f, -9.21114683e-02f, 6.50317818e-02f, -1.07886992e-01f,
  7.46794343e-02f, 8.01310763e-02f, 7.01925233e-02f, -3.99581455e-02f, 8.14999454e-03f, -1.73416194e-02f, -7.24365488e-02f, -1.36449128e-01f, -1.20990157e-01f, -1.33070946e-01f,
  2.08048582e-01f, 6.76495954e-02f, -2.44694501e-02f, 3.54017317e-03f, 4.90880869e-02f, 6.86160987e-03f, 4.01037633e-02f, -5.43995313e-02f, -1.34851607e-02f, -3.87975201e-02f,
  3.91292684e-02f, -7.12291384e-03f, 1.78450160e-02f, -2.95573659e-02f, 7.33594224e-02f, -3.06573100e-02f, -2.02966351e-02f, 1.28103821e-02f, 6.91852719e-02f, -4.54036556e-02f,
  -2.67170053e-02f, -3.92142497e-02f, -1.98210161e-02f, -1.57286506e-02f, 3.63601707e-02f, 3.50454776e-03f, -3.99146043e-02f, 1.08384276e-02f, -3.21285166e-02f, -2.99417824e-02f,
  6.96836561e-02f, -5.58955409e-03f, -1.69672817e-02f, -1.67914219e-02f, 1.40251461e-02f, -3.90544832e-02f, 1.33548435e-02f, -3.57969804e-03f, 7.34578725e-03f, 6.86060339e-02f,
  9.75284576e-02f, 6.94640204e-02f, -1.15178473e-01f, -1.88721512e-02f, 4.28865571e-03f, 1.36484336e-02f, 1.92567930e-02f, -7.09921774e-03f, 5.39561100e-02f, -3.17880996e-02f,
  1.25735095e-02f, -1.61503628e-02f, -4.43805717e-02f, 1.34408120e-02f, 7.06720948e-02f, 3.12621854e-02f, 6.44818619e-02f, -5.76046817e-02f, -2.88320482e-02f, -2.61380468e-02f,
  8.31714198e-02f, -1.06279952e-02f, -7.16451630e-02f, 3.96269746e-02f, -2.23409478e-02f, 1.25544788e-02f, -1.18021853e-01f, -6.07195646e-02f, -7.29540884e-02f, 9.82822627e-02f,
  -2.47115925e-01f, -2.13095680e-01f, 1.17837317e-01f, -2.45747507e-01f, -1.52652621e-01f, 7.39030838e-02f, -2.60430854e-02f, 6.73325658e-02f, -1.10321017e-02f, -2.23465919e-01f,
  4.43940535e-02f, 1.21384144e-01f, 9.08740088e-02f, 2.00671688e-01f, 3.13496798e-01f, 1.29471673e-02f, -9.44123492e-02f, 1.61924750e-01f, 3.15681189e-01f, 2.23579392e-01f,
  5.17363362e-02f, -1.06108241e-01f, -1.54601280e-02f, 7.18782246e-02f, -2.79843301e-01f, -4.08744775e-02f, -2.29108796e-01f, -2.46963248e-01f, -9.81968734e-03f, -4.50435132e-01f,
  -1.49304271e-01f, -1.18384540e-01f, 1.75541595e-01f, 1.05204150e-01f, -6.80340156e-02f, 5.36347106e-02f, 2.87426077e-02f, -1.48815811e-01f, 2.32796129e-02f, -8.00936371e-02f,
  -5.88740706e-02f, 1.75608955e-02f, -1.84952207e-02f, -2.52747592e-02f, -6.42145872e-02f, 1.25217270e-02f, 2.97880522e-03f, 1.50242403e-01f, 1.11921132e-01f, 5.17604537e-02f,
  -6.85940012e-02f, -1.66084409e-01f, -2.72891074e-02f, 6.55426309e-02f, 1.08874030e-01f, 1.10770948e-01f, -3.82177532e-02f, -8.66536051e-02f, 4.27540615e-02f, -4.57678735e-01f,
  1.22151366e-02f, -7.11769536e-02f, -8.40136129e-03f, -3.81763093e-02f, 2.61408649e-02f, -2.72063427e-02f, -5.30757234e-02f, -1.43753793e-02f, 4.54363227e-02f, -9.48893949e-02f,
  5.51757775e-02f, 1.35101285e-02f, -9.35505051e-03f, -1.24047138e-02f, -1.44923534e-02f, -6.81889206e-02f, 1.68806519e-02f, -3.26390266e-02f, 8.18466321e-02f, -8.83136969e-03f,
  3.73638980e-02f, 2.23407727e-02f, -8.84982944e-02f, 4.83079776e-02f, 8.92026052e-02f, 4.94546592e-02f, -2.45103915e-03f, 8.71606451e-03f, 2.57052518e-02f, -3.91931497e-02f,
  -9.21194702e-02f, 3.39771450e-01f, -1.49655566e-01f, 2.15374418e-02f, -7.15319142e-02f, 2.62614582e-02f, -8.94061103e-02f, 1.24083400e-01f, -5.54675423e-03f, 9.07964483e-02f,
  9.10643265e-02f, -1.39017310e-02f, -2.38663666e-02f, 5.21616153e-02f, 1.77537538e-02f, 4.57231030e-02f, -1.24342712e-02f, -3.43926139e-02f, 5.39759137e-02f, -1.24543406e-01f,
  -5.97414514e-03f, -7.46039897e-02f, -1.08897248e-02f, -2.52504405e-02f, -1.07745714e-01f, 9.43051651e-02f, -7.03951344e-02f, 1.84211228e-02f, 1.06498614e-01f, -3.05132449e-01f,
  3.65429252e-01f, -2.18344063e-01f, 4.67660185e-03f, 1.46479160e-01f, 5.46854772e-02f, 2.77440622e-02f, -2.81076059e-02f, -9.07443017e-02f, 4.90611605e-02f, -8.52736607e-02f,
  -2.24025652e-01f, -1.12713255e-01f, -1.57840356e-01f, -3.78325116e-03f, 4.14235145e-02f, 9.97419655e-02f, 3.41009438e-01f, 2.35147759e-01f, 1.87770888e-01f, 2.45260581e-01f,
  1.91522032e-01f, 1.76042244e-01f, 3.44580740e-01f, 1.06989361e-01f, 3.59434150e-02f, 1.52157610e-02f, -1.11641541e-01f, 7.76714459e-02f, -1.04729012e-01f, 1.80592433e-01f,
  -9.14003775e-02f, -8.89901072e-02f, 7.81335682e-02f, 1.19885892e-01f, -1.17393434e-01f, 3.72916907e-02f, -6.12018071e-02f, 5.31109162e-02f, -8.60348791e-02f, 8.04482847e-02f,
  -1.20994607e-02f, 1.22837191e-02f, 1.48502793e-02f, -3.76878344e-02f, 7.81712085e-02f, 1.18858798e-03f, 7.86732808e-02f, 5.43702282e-02f, -8.53350237e-02f, -1.06441252e-01f,
  3.78128345e-04f, 8.53702724e-02f, 7.32631236e-02f, -6.44012317e-02f, -8.73891860e-02f, 8.24738368e-02f, -1.26287013e-01f, -3.39996032e-02f, -4.10419442e-02f, -5.18475808e-02f,
  -1.99766494e-02f, -1.81143023e-02f, 1.22938976e-02f, 2.79287645e-03f, 7.92692974e-02f, 7.91400671e-03f, -6.36569783e-02f, 3.29657346e-02f, 2.27832422e-02f, 8.06902442e-03f,
  -4.04464193e-02f, -5.73500022e-02f, -3.97302434e-02f, -7.10946098e-02f, 2.06600148e-02f, 6.11042865e-02f, 3.36375535e-02f, -3.46927159e-02f, -3.70106958e-02f, 1.31866589e-01f,
  -1.47747193e-02f, 7.48232454e-02f, -7.85298795e-02f, 2.09708083e-02f, 6.31058775e-03f, -3.22366133e-02f, -3.06174289e-02f, -1.71955805e-02f, 3.50371040e-02f, 7.39098573e-03f,
  -1.00239381e-01f, -2.25488674e-02f, -7.17001483e-02f, 7.43326545e-02f, -9.22269654e-04f, -5.50017506e-02f, -1.00245953e-01f, 1.98023021e-02f, -8.70958492e-02f, -9.94932489e-04f,
  -2.29266193e-02f, -1.23834368e-02f, -1.34612754e-01f, -1.41662583e-02f, 6.42199814e-02f, 9.15556550e-02f, 7.28975311e-02f, 3.06368638e-02f, 8.72195289e-02f, -6.82025105e-02f,
  -5.15022650e-02f, 1.47707909e-01f, 1.55991599e-01f, -4.17737104e-02f, -1.44329136e-02f, 1.00051135e-01f, -4.78541963e-02f, 8.96037649e-03f, 8.93880799e-03f, -4.58948873e-03f,
  4.56212312e-01f, -3.91452342e-01f, -4.60662335e-01f, 6.97327629e-02f, -8.27938467e-02f, -1.46127865e-01f, -4.56996322e-01f, 8.17417055e-02f, 2.86438644e-01f, -8.23504031e-02f,
  -9.95584950e-02f, 2.57456392e-01f, 3.25200766e-01f, 8.71787146e-02f, 3.63472924e-02f, -3.32633436e-01f, -1.94436848e-01f, -2.85268258e-02f, 2.97075897e-01f, -1.35335801e-02f,
  -2.00362075e-02f, -1.99672356e-02f, 9.49121416e-02f, 1.14054106e-01f, -3.94458733e-02f, 2.82639802e-01f, -8.63386765e-02f, 2.71028024e-03f, -8.09397176e-02f, -2.30213448e-01f,
  -1.59458771e-01f, -3.13248813e-01f, 9.32824016e-02f, -2.38893684e-02f, -7.36881346e-02f, 4.09370251e-02f, -1.90916397e-02f, 6.09408319e-02f, 2.10589822e-02f, -7.62630478e-02f,
  -6.45043403e-02f, -7.33874142e-02f, 4.53154072e-02f, -6.43338785e-02f, -7.02322498e-02f, -7.98478276e-02f, -3.92653570e-02f, -1.25865526e-02f, 3.77260111e-02f, -1.16246186e-01f,
  -1.19158767e-01f, -8.48259628e-02f, -1.55672818e-01f, 4.54826616e-02f, -7.44530559e-02f, 2.66699735e-02f, -9.57794040e-02f, -1.45710826e-01f, -1.85018722e-02f, 6.05411548e-03f,
  4.08744365e-02f, -2.96463654e-03f, -1.78807639e-02f, 2.17660628e-02f, 8.46143663e-02f, 3.79371606e-02f, -4.09343056e-02f, 2.74070464e-02f, -5.22340229e-03f, 7.95128644e-02f,
  -3.33784595e-02f, -3.28418128e-02f, -4.44650883e-03f, 2.10546069e-02f, 1.35160591e-02f, -3.91233116e-02f, 1.36312339e-02f, -2.31333226e-02f, 2.95152124e-02f, 4.90581617e-03f,
  -9.01469868e-03f, -4.73181494e-02f, 4.46853861e-02f, -2.86116321e-02f, -5.11684008e-02f, -5.68386056e-02f, 8.86566285e-03f, -5.86560322e-03f, 3.89508270e-02f, 1.04376804e-02f,
  2.78311640e-01f, -5.42117748e-03f, 4.38036434e-02f, 3.11485846e-02f, -3.49521311e-03f, 5.93307503e-02f, 9.06713679e-03f, 4.12557647e-02f, 1.21372258e-02f, -5.19390823e-03f,
  -4.23800945e-03f, 4.90717143e-02f, -4.50922437e-02f, -5.09160571e-02f, 9.00488719e-02f, 6.96259663e-02f, 7.09453374e-02f, 3.62671055e-02f, 5.83382659e-02f, -5.20951264e-02f,
  -2.34675817e-02f, 9.59860086e-02f, 2.09632501e-01f, 7.60675445e-02f, 1.01498947e-01f, 2.16686457e-01f, 4.90417965e-02f, 7.04363585e-02f, 1.54187709e-01f, 2.09305987e-01f,
  1.76306918e-01f, -1.51848122e-01f, 4.30923581e-01f, -1.10551752e-01f, -1.67844474e-01f, 5.61133735e-02f, 2.01447550e-02f, -4.87988032e-02f, -1.92796871e-01f, -9.72335786e-02f,
  -1.65364668e-01f, -3.13721925e-01f, -6.99653104e-02f, 1.00239003e-02f, 3.74783911e-02f, 1.47283256e-01f, 2.64535308e-01f, 2.80226678e-01f, 1.64433733e-01f, -1.82570428e-01f,
  -1.04216017e-01f, -1.31455526e-01f, 1.64868578e-01f, -4.70913053e-02f, -1.27356082e-01f, -2.21369043e-01f, 2.26467531e-02f, 4.74163257e-02f, 8.62204954e-02f, 2.00738218e-02f,
  1.88368764e-02f, 1.10524930e-01f, -6.63468614e-02f, -6.31296709e-02f, -5.12193982e-03f, 8.52415338e-02f, 3.17419111e-03f, 7.14015290e-02f, 2.47073229e-02f, 2.73294514e-03f,
  -9.97292995e-03f, 3.86382230e-02f, 2.31458098e-02f, -7.85184801e-02f, 8.41944292e-02f, -4.82150540e-03f, 1.28678530e-01f, 6.22685328e-02f, 1.35501936e-01f, -4.51034084e-02f,
  -1.41208947e-01f, -6.52945489e-02f, 1.00202717e-01f, -4.69159484e-02f, 9.03426632e-02f, 5.23158759e-02f, -2.92706415e-02f, -5.08078523e-02f, 6.20248076e-03f, -5.13610728e-02f,
  -5.49621843e-02f, 3.77701297e-02f, -1.69001836e-02f, -2.26159189e-02f, 3.22084948e-02f, 2.56400965e-02f, -1.78434458e-02f, -2.20206156e-02f, -3.11077051e-02f, 1.97825413e-02f,
  -5.86347766e-02f, 5.51306903e-02f, -2.32624523e-02f, -1.34030534e-02f, -2.99992710e-02f, -2.19635759e-02f, 1.70677714e-02f, 2.60705911e-02f, 1.55122275e-03f, -2.32812054e-02f,
  -5.52553264e-03f, 4.72173616e-02f, -2.00626231e-03f, 1.23427564e-03f, 5.10004647e-02f, 1.46500804e-02f, 7.56622776e-02f, -6.89499155e-02f, -8.88448730e-02f, 6.83843568e-02f,
  -2.01331526e-01f, 9.96936634e-02f, -2.35235840e-02f, 6.38680235e-02f, 3.16879749e-02f, 1.83802564e-02f, -9.32513387e-04f, 2.79199705e-02f, 1.96681786e-02f, -4.37251944e-03f,
  2.04493329e-02f, -1.72520243e-02f, -1.62063781e-02f, 3.12098879e-02f, 1.63645800e-02f, -1.04675330e-01f, -2.30591930e-02f, 2.31314581e-02f, -4.59935181e-02f, -3.69437933e-02f,
  7.12659284e-02f, 1.63501743e-02f, -5.73561750e-02f, 4.08862159e-02f, -9.90151018e-02f, -9.04600769e-02f, 3.25686373e-02f, 1.79426558e-02f, 4.95118126e-02f, 2.16369964e-02f,
  4.23848987e-01f, -4.52362806e-01f, 7.08415657e-02f, -3.16715613e-02f, -7.77959451e-02f, 9.69192684e-02f, -9.88978222e-02f, -2.88133100e-02f, 1.15701713e-01f, -1.36379570e-01f,
  -2.90481560e-02f, 1.30902708e-01f, 7.36689568e-02f, 1.40478518e-02f, 1.66141555e-01f, -1.57958686e-01f, -2.99480021e-01f, 9.90807489e-02f, 2.97720134e-01f, 1.58077076e-01f,
  -1.28864259e-01f, -3.91695201e-02f, 4.89217788e-02f, 8.78148079e-02f, -2.18576282e-01f, 3.62864174e-02f, -1.11809261e-01f, -1.78369612e-01f, -9.95750204e-02f, -5.50083041e-01f,
  2.39993744e-02f, -3.21173184e-02f, 1.08942933e-01f, 3.60759646e-02f, 1.08032636e-02f, 9.31737106e-03f, 1.96756739e-02f, -6.50143018e-03f, 1.10188201e-02f, -4.24039476e-02f,
  -4.04578522e-02f, -8.00681487e-03f, 1.98094081e-02f, -6.22036420e-02f, -2.03460045e-02f, 9.20924079e-03f, -5.32467365e-02f, -7.64999248e-04f, 3.45137864e-02f, -3.09029478e-03f,
  -1.59998804e-01f, -5.38674966e-02f, 7.03171790e-02f, 2.74819899e-02f, 5.42451181e-02f, 3.49919610e-02f, -7.61186966e-05f, 1.12426780e-01f, 2.22578704e-01f, -1.86451793e-01f,
  1.52814193e-02f, -2.79578976e-02f, 3.73185216e-03f, -4.42385823e-02f, -8.41309652e-02f, 3.97687405e-02f, -9.18309540e-02f, -3.25206593e-02f, 4.66308147e-02f, -6.02753460e-02f,
  2.49223951e-02f, -2.31922399e-02f, 7.13635981e-03f, -4.69143968e-03f, 4.15868638e-03f, -3.62285972e-02f, 4.16322332e-03f, -4.15537544e-02f, 5.35439551e-02f, 6.77990243e-02f,
  3.29563096e-02f, 6.88120052e-02f, 2.97495406e-02f, -2.64101699e-02f, -3.41020785e-02f, -5.45625016e-02f, -3.03667504e-02f, -5.76033583e-03f, -5.03603481e-02f, 1.31474342e-02f,
  8.15579072e-02f, 3.03841025e-01f, -4.84258421e-02f, 3.35734598e-02f, 2.04505045e-02f, -1.10544106e-02f, -1.93528421e-02f, 1.38013409e-02f, -7.43811578e-02f, -4.48973812e-02f,
  5.60769327e-02f, 1.20766358e-02f, 1.62781700e-02f, 2.70732511e-02f, 4.23323251e-02f, 3.90965631e-03f, -3.25888433e-02f, 4.63404879e-02f, 9.63153616e-02f, 3.95660959e-02f,
  -7.68309012e-02f, 8.47037435e-02f, 1.30248204e-01f, 2.89199818e-02f, 1.08887414e-02f, 1.90526575e-01f, 3.73958535e-02f, -1.74075644e-02f, 2.76846379e-01f, -4.40966245e-03f,
  -2.89898425e-01f, -2.48718992e-01f, -3.43448445e-02f, 3.96751724e-02f, 9.38613042e-02f, -1.70725882e-01f, -6.36543751e-01f, -1.88579813e-01f, 1.57670811e-01f, -1.21067084e-01f,
  5.10888547e-02f, 2.15309307e-01f, 1.01457171e-01f, 1.95772424e-02f, -1.32507801e-01f, -3.31526101e-01f, -4.45766747e-02f, -7.57030258e-03f, -7.44896457e-02f, -4.22946876e-03f,
  -2.00231075e-02f, -2.05611605e-02f, 1.80722994e-03f, 4.25576456e-02f, 2.63847083e-01f, 2.43885413e-01f, 7.24621192e-02f, 4.94526327e-02f, 2.95148697e-02f, 3.72641355e-01f,
  3.85596193e-02f, -1.31544294e-02f, 2.46199332e-02f, 5.18218763e-02f, 6.68034852e-02f, -6.77940771e-02f, -9.98429805e-02f, 6.09073006e-02f, 1.23317027e-02f, 2.98130214e-02f,
  1.03340194e-01f, 1.75916448e-01f, 8.11931565e-02f, 1.63177103e-01f, -1.26456171e-02f, -1.77138168e-02f, 7.15340301e-02f, -1.14664935e-01f, -4.38252650e-02f, -3.38989273e-02f,
  8.94502103e-02f, 5.68717793e-02f, -6.29025921e-02f, -2.55398620e-02f, -1.00308500e-01f, 1.85621589e-01f, 8.63467809e-03f, 6.03295155e-02f, 2.43575424e-02f, -5.96219115e-03f,
  -1.93200428e-02f, 2.16634590e-02f, 3.43554914e-02f, -6.71525449e-02f, 8.87856446e-03f, 5.65336831e-02f, 2.97136176e-02f, -4.24514823e-02f, 1.48418965e-02f, -4.80982400e-02f,
  5.37599735e-02f, -1.48782404e-02f, -1.16874194e-02f, -5.54872938e-02f, 4.57280427e-02f, 3.12890336e-02f, -2.83551291e-02f, 1.01627354e-02f, 6.40300289e-03f, -1.48328440e-02f,
  2.72092875e-02f, 2.75292143e-04f, 5.00516035e-02f, 1.56846028e-02f, -8.98528658e-03f, 9.62525159e-02f, 7.37037286e-02f, 1.01638846e-02f, 1.59720872e-02f, -8.68522737e-04f,
  -1.15270272e-01f, -3.69593464e-02f, -5.29317856e-02f, -5.38157113e-02f, 2.79562511e-02f, 5.33622615e-02f, 4.94781360e-02f, 7.78548419e-04f, 2.57328097e-02f, -9.08393785e-02f,
  -4.92940173e-02f, -7.57623389e-02f, -3.93545106e-02f, -2.43135914e-02f, -6.92683309e-02f, -7.43233487e-02f, -8.40432271e-02f, 1.75531656e-02f, -9.58325788e-02f, 1.03804292e-02f,
  -6.46921694e-02f, -1.40532836e-01f, -2.30259314e-01f, -1.98527187e-01f, -3.72672789e-02f, -1.17268234e-01f, -1.22300491e-01f, -6.26273826e-02f, -2.54605860e-01f, -4.04633164e-01f,
  1.99140161e-02f, 3.34123552e-01f, 3.82970646e-02f, -1.78353116e-01f, -1.06755547e-01f, -2.00217530e-01f, -1.36147708e-01f, 2.06282530e-02f, -1.08222932e-01f, 3.24549340e-02f,
  1.32200480e-01f, -2.73095071e-03f, -1.34355547e-02f, -4.97745797e-02f, -1.42321646e-01f, -1.25413954e-01f, -2.91489482e-01f, -2.04016432e-01f, -1.99340910e-01f, -7.97304064e-02f,
  -1.39425779e-02f, 3.42158824e-02f, 1.43290564e-01f, -2.66957637e-02f, -2.17739493e-02f, -6.23119995e-02f, 1.09586522e-01f, 1.77342385e-01f, 8.27486813e-02f, -4.28025648e-02f,
  2.01469272e-01f, 9.88615677e-02f, -1.30399227e-01f, -9.88937765e-02f, 1.17988484e-02f, 5.37775829e-02f, -8.80895741e-03f, 4.04465348e-02f, 1.38551490e-02f, -6.35321066e-02f,
  3.57062854e-02f, -3.42601277e-02f, -9.17912796e-02f, 6.11725412e-02f, 4.11924608e-02f, 1.05532976e-02f, 1.39063254e-01f, 4.88503976e-03f, -3.84819545e-02f, 1.13549396e-01f,
  -3.78223998e-03f, -7.67001882e-02f, 7.56962001e-02f, -2.43795086e-02f, -2.33110990e-02f, -3.01177818e-02f, 4.45027314e-02f, -1.90921519e-02f, 5.16347140e-02f, 9.62920487e-02f,
  -4.58808243e-02f, -1.72027275e-02f, -4.12160195e-02f, 3.72811146e-02f, 4.62321751e-02f, -3.71438935e-02f, -8.78831595e-02f, -3.55203226e-02f, -3.53719555e-02f, 1.84342731e-03f,
  4.85650636e-02f, -1.32930959e-02f, 6.27382994e-02f, -1.08938757e-02f, -1.81058161e-02f, -2.93954499e-02f, -4.19278182e-02f, -2.05855258e-02f, -2.10900921e-02f, 8.02922919e-02f,
  1.19182587e-01f, 3.93792018e-02f, 6.98354421e-03f, 2.23573726e-02f, -5.65378368e-02f, 4.53516003e-03f, -2.16921605e-02f, 1.59191899e-02f, 6.58758730e-02f, -1.52348783e-02f,
  2.37003252e-01f, 2.61840504e-02f, -1.07541554e-01f, 2.81676613e-02f, -1.09078027e-02f, 9.55354124e-02f, -8.31431523e-03f, 4.43551578e-02f, 3.36989947e-02f, 3.91703919e-02f,
  2.51666307e-02f, 6.51895255e-02f, 1.12073310e-01f, 7.33268633e-02f, 2.44199373e-02f, -4.04711924e-02f, -5.88882109e-03f, -7.70842433e-02f, -2.54875813e-02f, 9.07440390e-03f,
  3.10888980e-02f, -1.22013584e-01f, -1.14340700e-01f, -1.04822423e-02f, -2.87396405e-02f, -1.18894994e-01f, 4.07474302e-02f, -6.45333668e-03f, -1.55281633e-01f, 6.71524368e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.80399132e-01f, 3.10255941e-02f, 7.22244307e-02f, -3.77006680e-01f, -8.83477107e-02f, 1.22160159e-01f, 1.06873870e-01f, 2.72454713e-02f, -1.10428043e-01f, 7.14392588e-03f,
  1.62557401e-02f, 1.96444839e-02f, -8.39005783e-02f, -7.98289776e-02f, -6.18886985e-02f, 7.95869008e-02f, 1.17798299e-02f, -2.76859440e-02f, -2.18716450e-02f, -2.72633266e-02f,
  -1.33340344e-01f, -1.93035349e-01f, -2.40817070e-01f, -9.33101997e-02f, -1.33363396e-01f, -2.59063672e-02f, 5.85636357e-03f, -1.56421095e-01f, 2.30741054e-02f, -1.93593994e-01f,
  4.19350117e-01f, -2.98409909e-01f, 3.29578519e-02f, -2.59017557e-01f, 7.39870369e-02f, 3.12443804e-02f, -6.23005219e-02f, -5.93886189e-02f, -1.05188094e-01f, -3.58087830e-02f,
  -6.46264032e-02f, 8.59348197e-03f, -5.15941158e-03f, -6.66993111e-02f, -9.77867544e-02f, -6.08549453e-02f, -5.30793928e-02f, -8.30287710e-02f, -5.44300787e-02f, 8.88995305e-02f,
  -3.57854664e-02f, -7.78180212e-02f, 1.14542708e-01f, 8.16374049e-02f, -2.42348406e-02f, -8.50133598e-02f, 6.56005507e-03f, -1.26893356e-01f, -1.12710670e-01f, 3.11706476e-02f,
  -6.05260115e-03f, 5.46641939e-04f, -4.68273535e-02f, -6.28687516e-02f, 1.82961393e-02f, 8.84380639e-02f, -4.91934493e-02f, 1.39681801e-01f, -1.64601337e-02f, -4.00169147e-03f,
  2.13811919e-02f, 3.44183855e-02f, -3.90485711e-02f, 1.40843606e-02f, -1.90171860e-02f, -2.20161509e-02f, -2.76772548e-02f, 3.88616398e-02f, 4.55644540e-02f, -1.03513859e-01f,
  -4.12458107e-02f, -4.15577693e-03f, -4.19079177e-02f, 3.54080349e-02f, -3.32682282e-02f, -5.12102135e-02f, 1.65929515e-02f, -1.34919174e-02f, -3.14747319e-02f, -6.02570325e-02f,
  2.97821075e-01f, -1.38246462e-01f, 1.03795126e-01f, -3.13071199e-02f, -4.98759225e-02f, 1.22856274e-02f, 1.81784686e-02f, -4.53895070e-02f, -2.17285156e-02f, 3.97010185e-02f,
  -1.72931589e-02f, -5.66199720e-02f, -5.43018095e-02f, 9.57644582e-02f, 8.63641724e-02f, 6.91260919e-02f, 3.69287394e-02f, -8.09136182e-02f, 9.91369411e-03f, 1.07250549e-01f,
  7.05935284e-02f, 8.58979002e-02f, 1.01406664e-01f, 8.33053738e-02f, -5.63174079e-04f, 1.13132847e-02f, 2.00381443e-01f, 8.92144740e-02f, 8.26496929e-02f, 2.21936807e-01f,
  9.47375521e-02f, -1.30577818e-01f, 6.81865439e-02f, 8.56595188e-02f, 1.11483425e-01f, -2.36679930e-02f, -4.08007437e-03f, 6.41413480e-02f, 1.03922307e-01f, 1.11972436e-01f,
  1.15249947e-01f, 1.71710953e-01f, 2.77454406e-01f, 1.36555642e-01f, 1.25024542e-01f, 4.94228266e-02f, 7.77048692e-02f, 3.68391313e-02f, 5.42838760e-02f, 1.47840291e-01f,
  6.22401573e-02f, -1.15194395e-01f, -1.04425006e-01f, 3.29799689e-02f, 7.95375034e-02f, 1.37706995e-01f, -5.16531467e-02f, -5.71698230e-03f, -3.04254889e-02f, 2.18767580e-02f,
  1.87230453e-01f, 2.03763153e-02f, 1.53342456e-01f, -1.88189652e-02f, -6.30147681e-02f, -7.76308849e-02f, -9.16719809e-03f, -3.19608264e-02f, -4.09847610e-02f, -1.34213895e-01f,
  1.90118011e-02f, -8.55616406e-02f, -3.23796598e-03f, -9.20778066e-02f, -4.04484309e-02f, -6.13659918e-02f, 3.96779440e-02f, 7.18163624e-02f, -1.70445032e-02f, 7.48585686e-02f,
  7.70114437e-02f, 3.36668566e-02f, 1.07407337e-02f, 6.24360330e-02f, 6.09265119e-02f, -2.62734480e-02f, 3.49859558e-02f, 7.24428426e-03f, 8.15071259e-03f, -3.24581563e-02f,
  -2.85057537e-02f, 5.56472018e-02f, 1.35572672e-01f, 5.60443625e-02f, 5.61063662e-02f, 1.18742377e-01f, 6.52514398e-02f, -6.98247412e-03f, -8.42992868e-03f, -6.81337789e-02f,
  1.20742269e-01f, 1.07757002e-01f, 9.52273086e-02f, 7.87763521e-02f, -5.06119952e-02f, -2.19183024e-02f, -2.73509100e-02f, -2.54384317e-02f, -8.67104798e-04f, 2.27403361e-02f,
  9.16133523e-02f, 1.01302803e-01f, -2.78353505e-02f, 8.95812809e-02f, -9.51851904e-03f, 4.61018719e-02f, 4.04668855e-04f, 2.39352533e-03f, -1.09814711e-01f, -1.25171207e-02f,
  -8.66900608e-02f, 1.44869402e-01f, 2.99549364e-02f, 7.54814744e-02f, -3.89079563e-02f, -1.11363016e-01f, -8.31520744e-03f, -7.70853013e-02f, -6.91397190e-02f, -3.13387699e-02f,
  -3.27621885e-02f, -1.31974537e-02f, 4.93370369e-02f, -8.04022793e-03f, 4.18765955e-02f, -9.55489203e-02f, -3.35533209e-02f, 4.52869087e-02f, 4.74313274e-02f, -3.55713703e-02f,
  -2.83864941e-02f, -5.52685075e-02f, 1.10322319e-01f, 2.03887057e-02f, 2.33670045e-02f, 1.52703077e-01f, -4.41214480e-02f, -3.85155692e-03f, 3.52575108e-02f, -1.23640612e-01f,
  3.02956067e-02f, 2.55499005e-01f, 6.93960190e-02f, -9.39438790e-02f, 1.24588124e-01f, 1.15950838e-01f, 2.72894502e-01f, 8.01691785e-02f, 9.57034342e-03f, 8.82076323e-02f,
  1.71710625e-01f, -7.69272000e-02f, -4.07885127e-02f, -1.52983263e-01f, 2.67294049e-02f, -1.26352478e-02f, -1.10870652e-01f, -2.33770952e-01f, -1.87670052e-01f, -9.68098640e-02f,
  -2.52390914e-02f, -5.43344729e-02f, -2.00659618e-01f, -1.90705165e-01f, -1.45533517e-01f, -1.19138233e-01f, -1.61733404e-02f, -1.36814952e-01f, 4.38496135e-02f, -2.59054810e-01f,
  -8.00965056e-02f, 1.40305698e-01f, 1.03371972e-02f, -7.15956241e-02f, 4.01245542e-02f, -1.35461893e-02f, 7.02508539e-02f, -6.45440966e-02f, 6.16885759e-02f, 7.12784827e-02f,
  7.61786243e-03f, 4.19953763e-02f, -6.76872805e-02f, 4.10444662e-02f, -3.81215177e-02f, 8.88004377e-02f, 5.09943515e-02f, -8.14922825e-02f, -7.92990923e-02f, 4.20760512e-02f,
  1.75842762e-01f, 8.69705528e-02f, 5.59696481e-02f, 1.33780897e-01f, -5.29746804e-03f, 2.61676572e-02f, 3.50308605e-02f, 1.08752191e-01f, 3.90419140e-02f, 2.19734237e-02f,
  1.23692723e-02f, 1.55290768e-01f, -3.09368335e-02f, 1.11936212e-01f, 2.81374976e-02f, 3.90814878e-02f, -3.07871383e-02f, -1.85566097e-02f, -4.10049409e-02f, 1.20546473e-02f,
  -2.21296102e-02f, -1.72639675e-02f, -4.88178320e-02f, -1.14083573e-01f, -6.17585182e-02f, -3.81095111e-02f, 8.92873704e-02f, 1.19743347e-02f, 1.02577277e-01f, -3.61810926e-05f,
  -3.56053337e-02f, 3.12197581e-02f, 6.90193102e-02f, -3.13061401e-02f, 3.40679809e-02f, 5.71470968e-02f, -4.18113880e-02f, 3.42681096e-03f, -6.00586273e-02f, -8.73392634e-03f,
  -2.80098647e-01f, 9.06311125e-02f, -1.10402666e-01f, -8.86863694e-02f, 2.60081775e-02f, 7.81444833e-02f, 3.54138613e-02f, -2.87108459e-02f, 3.78031693e-02f, -3.57087962e-02f,
  -3.30416975e-03f, -8.53064209e-02f, 8.04957077e-02f, -4.49782088e-02f, -4.99451086e-02f, 5.51308431e-02f, 1.46046445e-01f, -1.97278820e-02f, -6.44739494e-02f, 1.04630925e-01f,
  2.08484396e-01f, 1.36631265e-01f, 1.28968172e-02f, 4.94039170e-02f, -4.60444652e-02f, -9.41955373e-02f, -5.87946512e-02f, -2.63900608e-02f, -2.06725206e-02f, 1.18278600e-01f,
  -2.36324459e-01f, -5.86251244e-02f, -1.05617113e-01f, -1.65165931e-01f, 1.81448329e-02f, -5.81667759e-02f, -2.50466727e-02f, -4.87095900e-02f, -1.11531377e-01f, -5.76073043e-02f,
  1.23837754e-01f, 2.51589599e-03f, 6.16967119e-02f, -6.18622899e-02f, -9.77974385e-03f, -9.56529975e-02f, -1.35008648e-01f, 5.38221896e-02f, 1.28380954e-02f, -2.67125517e-02f,
  5.47137596e-02f, -1.04090109e-01f, 3.62006836e-02f, -2.62356307e-02f, -5.85750341e-02f, 6.29375577e-02f, -2.37246770e-02f, 4.87122014e-02f, 1.16239280e-01f, 6.76962882e-02f,
  -6.69565285e-03f, 6.83461204e-02f, 1.02727249e-01f, -6.19875174e-03f, -3.62027233e-04f, -3.19382846e-02f, 3.34801525e-03f, -4.58316579e-02f, 7.31944665e-02f, -3.23973522e-02f,
  4.94446754e-02f, -2.95943930e-03f, -9.47723389e-02f, 3.13663967e-02f, -1.73215885e-02f, 7.05415849e-03f, -1.42475501e-01f, -1.38365582e-01f, 3.00648436e-02f, -4.88359183e-02f,
  -1.31656229e-02f, 6.01446405e-02f, 4.20155041e-02f, -1.23190992e-01f, -8.90504941e-02f, -1.74242835e-02f, -5.53515814e-02f, -1.26786232e-01f, -1.46419778e-01f, -1.73038810e-01f,
  1.05809607e-01f, -5.49856536e-02f, 8.98289755e-02f, 4.24889214e-02f, -3.36429961e-02f, -4.01435494e-02f, 7.93456137e-02f, 7.05323145e-02f, 1.14690196e-02f, -1.11800432e-02f,
  5.41746542e-02f, 7.92966187e-02f, 6.13226369e-03f, -3.11297793e-02f, -5.94410598e-02f, -1.81506667e-02f, 1.02272339e-01f, -6.18054718e-02f, -5.57934009e-02f, -5.25452122e-02f,
  -3.87634672e-02f, -6.23093024e-02f, -4.23044562e-02f, -2.45665200e-02f, 4.71948385e-02f, -2.67441124e-02f, 4.97173741e-02f, -3.36527228e-02f, -1.16528884e-01f, -6.90373853e-02f,
  -2.16201216e-01f, 1.95016995e-01f, -5.17168194e-02f, -8.25044960e-02f, 3.61016504e-02f, -5.90979420e-02f, 2.79660039e-02f, -4.06717286e-02f, 6.14374317e-02f, -7.32184350e-02f,
  6.70832256e-03f, -1.22218207e-01f, -7.70699307e-02f, -2.48376764e-02f, -6.55610040e-02f, 3.02672992e-03f, -5.87757565e-02f, -4.49674651e-02f, -8.62569734e-02f, -1.03621833e-01f,
  -1.08858310e-01f, -1.66063786e-01f, -1.47298455e-01f, -1.55341513e-02f, -2.93653868e-02f, 1.65734999e-02f, -9.71015468e-02f, -1.52659163e-01f, -1.97879389e-01f, -2.17095971e-01f,
  7.84431025e-02f, 1.75419807e-01f, -7.32854456e-02f, 1.03753349e-02f, 7.40784109e-02f, -3.85330804e-02f, -5.83217889e-02f, -9.98346582e-02f, -4.40061279e-03f, 1.59365758e-02f,
  1.15803972e-01f, 8.72631595e-02f, -4.77883145e-02f, -4.81546596e-02f, 7.89123178e-02f, 5.55756688e-02f, -5.21097286e-03f, 5.64470701e-02f, 9.04982816e-03f, 2.10253727e-02f,
  1.63827315e-01f, -4.90405411e-02f, 2.32409425e-02f, 4.65795547e-02f, 1.82457015e-01f, 2.16095131e-02f, 3.01770680e-02f, 8.09375942e-02f, 1.85408071e-01f, 3.01750779e-01f,
  1.16118990e-01f, 1.15087450e-01f, -9.86108035e-02f, 4.47003283e-02f, 4.08017188e-02f, -2.96133161e-02f, 8.98928121e-02f, 5.11552058e-02f, 7.49809965e-02f, -5.57709448e-02f,
  4.38600406e-02f, 3.99390087e-02f, 6.36751205e-02f, 2.98556266e-03f, -8.44918266e-02f, -8.43407586e-02f, -1.92057043e-02f, -1.79301295e-02f, -6.51947632e-02f, -3.30956839e-02f,
  8.33351922e-04f, 8.61413404e-02f, -4.96023968e-02f, -7.53150061e-02f, -2.46515987e-03f, 4.94038127e-02f, 5.18088639e-02f, -3.67611125e-02f, -4.71735671e-02f, -6.92825839e-02f,
  4.72226692e-03f, -4.61485051e-02f, -5.47748096e-02f, -4.39274684e-02f, 1.59023441e-02f, -6.65608495e-02f, -3.54866646e-02f, 4.44433838e-03f, -5.17148897e-02f, -4.83265966e-02f,
  -3.07595897e-02f, -1.17445216e-01f, 1.09142661e-02f, 1.20029384e-02f, -6.27589971e-02f, -3.38560529e-02f, -1.36668039e-02f, -4.18167971e-02f, 1.33386878e-02f, 3.85699142e-03f,
  -1.68927033e-02f, 1.56950317e-02f, -5.85929416e-02f, -3.80513165e-03f, 7.58130923e-02f, -9.07563120e-02f, 4.53054644e-02f, -1.04790673e-01f, 1.06836669e-02f, 3.14141437e-02f,
  -1.57443881e-01f, -1.63392220e-02f, 1.64515171e-02f, -1.44570144e-02f, -4.12262492e-02f, 5.10783046e-02f, -4.71216291e-02f, 1.73106771e-02f, 6.71475977e-02f, -4.81146090e-02f,
  2.26647872e-02f, -3.90460193e-02f, 4.76958528e-02f, -3.83711196e-02f, -5.96090034e-02f, -8.21313709e-02f, -9.47023779e-02f, -5.01832403e-02f, 3.15087326e-02f, -1.13180708e-02f,
  -2.56319251e-02f, -4.67718132e-02f, -1.54060856e-01f, -9.61669013e-02f, 4.55680229e-02f, -1.53999984e-01f, -8.57469812e-02f, -1.20316207e-01f, -1.34973556e-01f, -1.24431863e-01f,
  1.18602544e-01f, 2.02117004e-02f, -3.03412229e-01f, 1.24322765e-01f, 1.04467878e-02f, -6.94912001e-02f, 5.09935580e-02f, 1.38352379e-01f, 3.36012915e-02f, 3.49608399e-02f,
  -1.08972646e-01f, -2.09913719e-02f, -4.47718054e-02f, -1.46462828e-01f, -6.69826614e-03f, -7.49808699e-02f, -2.13400751e-01f, -2.10295379e-01f, -1.45526171e-01f, 4.77066301e-02f,
  -2.75567230e-02f, -3.48077901e-03f, 3.15366872e-02f, 3.27356742e-03f, 1.06980847e-02f, -1.34050861e-01f, -1.34348124e-01f, -8.88924953e-03f, -1.65446967e-01f, -2.03527808e-01f,
  -1.14974052e-01f, 1.31234266e-02f, 2.40219254e-02f, -6.49035722e-02f, 1.37074189e-02f, 3.78285535e-03f, -7.63342902e-02f, -1.21300392e-01f, 6.06332682e-02f, 1.48134194e-02f,
  -5.90085201e-02f, -1.55014871e-03f, -5.21092378e-02f, -2.05957051e-02f, -1.86914876e-02f, -1.03300408e-01f, 8.52555111e-02f, -1.10404834e-01f, -4.17506769e-02f, -2.61925440e-03f,
  -8.48363265e-02f, -1.65759251e-01f, -2.06333082e-02f, -1.11641295e-01f, 2.12105978e-02f, -2.30941288e-02f, -1.09273076e-01f, -9.21008512e-02f, 9.47781187e-03f, 8.03246051e-02f,
  8.92754123e-02f, -4.31081653e-02f, 8.35266430e-03f, 6.09150380e-02f, 7.96046853e-02f, -8.02878365e-02f, -1.30066101e-03f, 2.93789506e-02f, -2.42417827e-02f, 7.94357732e-02f,
  5.91676645e-02f, 7.14079663e-02f, 5.72732054e-02f, 4.79317307e-02f, -1.00066438e-01f, 2.13496909e-02f, 1.19600380e-02f, -1.08249597e-02f, -2.64458247e-02f, -1.63102411e-02f,
  -9.52331051e-02f, 2.31310241e-02f, -3.90051939e-02f, -7.62160271e-02f, -8.06201473e-02f, -6.30763099e-02f, 5.22843301e-02f, -9.27463919e-02f, 6.12048083e-04f, -7.73845389e-02f,
  2.05561057e-01f, -6.28880262e-02f, -5.92435002e-02f, 8.66194814e-02f, -2.38969568e-02f, -8.02955031e-02f, -5.12703285e-02f, 5.98500967e-02f, -6.11169487e-02f, -9.37845334e-02f,
  1.35043161e-02f, -1.97307914e-02f, -6.79997355e-02f, -1.00296482e-01f, -6.92297965e-02f, -5.95732108e-02f, -1.09363887e-02f, 5.56567200e-02f, -1.95712186e-02f, -5.31291515e-02f,
  6.30408002e-04f, -1.68870259e-02f, 5.13428301e-02f, 5.76741621e-02f, -7.59333149e-02f, -5.05270390e-03f, -8.59105512e-02f, -6.65439814e-02f, 5.01268916e-02f, 1.36462167e-01f,
  1.60126045e-01f, 2.41101637e-01f, 1.23870812e-01f, 1.41723081e-01f, 5.60667440e-02f, 3.91911343e-02f, 1.60884097e-01f, -5.19348441e-06f, -8.78446773e-02f, 1.80495903e-02f,
  1.78192049e-01f, 3.05672195e-02f, 6.73969388e-02f, -8.88408050e-02f, -1.02676697e-01f, -1.66478269e-02f, -1.21265240e-01f, -4.09254842e-02f, -6.67701364e-02f, -3.14080641e-02f,
  -7.24072009e-02f, 3.84894721e-02f, 1.07585236e-01f, -7.33330548e-02f, 1.45881213e-02f, -4.22536768e-02f, -3.95490043e-02f, 9.27755237e-03f, -4.72989082e-02f, -3.17223817e-02f,
  6.95312396e-02f, 2.30063498e-01f, -1.17929198e-01f, -1.19690582e-01f, 1.30222559e-01f, -5.48615083e-02f, 1.57260727e-02f, -4.84031774e-02f, -1.87234934e-02f, 3.33135724e-02f,
  5.07765673e-02f, 3.22081819e-02f, 7.70676602e-03f, -8.77071396e-02f, 6.88266829e-02f, -8.50111097e-02f, -1.03607506e-01f, 4.72442284e-02f, -1.97711177e-02f, -5.22241965e-02f,
  -1.04293518e-01f, 9.26195532e-02f, 8.23934749e-02f, -5.78369386e-02f, 3.44950482e-02f, 6.96994737e-02f, 8.95190910e-02f, 7.24138170e-02f, 1.49055338e-02f, 6.00048602e-02f,
  -3.20505649e-02f, 7.99948126e-02f, 1.33958505e-02f, -1.11199431e-02f, 1.54670551e-02f, 1.98556725e-02f, 1.15768602e-02f, 1.08781168e-02f, 3.80367041e-02f, -4.77548242e-02f,
  2.35249978e-02f, -5.36517659e-03f, 1.43211847e-02f, 2.89345589e-02f, -4.71557602e-02f, -2.13215491e-04f, -6.93415254e-02f, 5.93695119e-02f, 4.05883268e-02f, 8.07175487e-02f,
  -4.44106497e-02f, -2.47079618e-02f, 6.28395081e-02f, -4.95931879e-02f, -2.24022567e-03f, 3.51349153e-02f, -6.27207980e-02f, -3.26652117e-02f, 7.26046413e-02f, 8.45871195e-02f,
  -2.56607700e-02f, 1.34327844e-01f, -5.84730459e-03f, -3.30611914e-02f, 6.22871565e-03f, -4.07179631e-02f, 9.09074396e-02f, -6.94321841e-02f, -4.55855466e-02f, -6.67390078e-02f,
  2.83089075e-02f, -3.48396003e-02f, 5.89080378e-02f, 4.85672839e-02f, -2.67940499e-02f, 2.85727251e-02f, 1.01656318e-02f, 3.61135677e-02f, -1.13198906e-02f, 6.59418106e-03f,
  -8.74595270e-02f, 3.77646759e-02f, -1.07845113e-01f, -2.97825839e-02f, -1.14238650e-01f, -9.30594280e-02f, 2.26445794e-02f, -1.14091486e-01f, 2.96251420e-02f, -1.05677307e-01f,
  6.04116619e-01f, -7.59062991e-02f, 1.99333161e-01f, 1.57932937e-01f, -5.08971475e-02f, 2.21890441e-04f, -3.30333388e-03f, -5.26119545e-02f, -2.28565615e-02f, -1.16446413e-01f,
  -2.61001378e-01f, -1.29442677e-01f, -1.10141382e-01f, -5.61042130e-02f, 8.20277333e-02f, 1.33204326e-01f, 4.01910208e-02f, 1.45003170e-01f, 2.33261690e-01f, 1.22286789e-01f,
  -8.08127671e-02f, 7.00855553e-02f, 2.36380711e-01f, 5.11516072e-02f, -1.69728342e-02f, -1.33606195e-01f, -1.05586700e-01f, 3.96047086e-02f, -4.24313471e-02f, -1.74294412e-02f,
  -5.19571118e-02f, 1.42944634e-01f, 3.08793336e-02f, -8.17838386e-02f, -1.22755781e-01f, 2.57697906e-02f, 4.51529101e-02f, -3.27661857e-02f, -1.00076526e-01f, -1.70187181e-04f,
  -1.04259543e-01f, 3.13355178e-02f, -3.37170921e-02f, -2.20553055e-02f, 7.96767101e-02f, 4.83461320e-02f, 9.13939103e-02f, 1.11673944e-01f, 6.17487058e-02f, -1.33781265e-02f,
  -1.87051147e-01f, -4.76165023e-03f, 8.32113996e-02f, -1.60191637e-02f, -2.09713187e-02f, 4.42668870e-02f, -9.43482071e-02f, 3.36814076e-02f, 4.68798056e-02f, 6.10510074e-02f,
  1.90572832e-02f, 2.71368958e-02f, 2.32618507e-02f, -5.01796603e-02f, -3.84500809e-02f, -5.56890629e-02f, -4.52226289e-02f, -5.20021617e-02f, 3.05846464e-02f, 8.85539353e-02f,
  3.29140685e-02f, 7.63503090e-02f, 4.93716113e-02f, 2.83652302e-02f, -9.85543579e-02f, 3.13075893e-02f, 1.67645924e-02f, 1.19253565e-02f, -3.15604806e-02f, 4.76171561e-02f,
  6.35793582e-02f, 9.68663543e-02f, 6.45964295e-02f, -2.34040841e-02f, -4.64795232e-02f, 8.47449601e-02f, -2.52820961e-02f, -1.21349329e-02f, -4.53825928e-02f, 9.55185071e-02f,
  -1.77624285e-01f, -1.65663555e-01f, 5.01291901e-02f, 7.20591992e-02f, -4.44799848e-03f, 5.61471796e-03f, -1.02696717e-01f, -5.59286661e-02f, -8.18412006e-02f, -5.23591116e-02f,
  -3.09340935e-02f, 2.66826432e-02f, 1.85629912e-02f, 5.08113280e-02f, 6.14414960e-02f, 1.81503091e-02f, -1.24376707e-01f, -4.39979769e-02f, -2.67077088e-02f, -1.07913412e-01f,
  -5.08592092e-02f, 1.17110223e-01f, 1.87131271e-01f, -4.47892994e-02f, 1.55069241e-02f, 1.33141614e-02f, -5.43621927e-02f, 5.37669100e-02f, 1.16980657e-01f, 1.16160385e-01f,
  -6.69254968e-03f, -7.36322179e-02f, 2.65777469e-01f, -1.15797020e-01f, -1.89718515e-01f, -1.81799263e-01f, -3.64701748e-01f, -1.65820718e-01f, -1.22392572e-01f, -1.83613688e-01f,
  -3.44313011e-02f, -1.39178053e-01f, 2.20968165e-02f, -1.49203138e-02f, -2.21547801e-02f, -8.49206820e-02f, -4.48300649e-04f, 1.53789967e-01f, -7.07680732e-02f, -2.58872628e-01f,
  -1.95202559e-01f, -1.25060216e-01f, 7.51241222e-02f, -6.71442002e-02f, -1.30446315e-01f, 1.35161737e-02f, 1.14982605e-01f, -3.69849168e-02f, -9.93938819e-02f, -1.52262956e-01f,
  -9.39293951e-02f, 1.52746320e-01f, 5.08351922e-02f, 5.02032079e-02f, 2.66623423e-02f, 7.44245807e-03f, -2.55984459e-02f, 4.23724540e-02f, 9.07904804e-02f, -6.91825971e-02f,
  1.29100238e-03f, -7.11550936e-03f, 5.27028628e-02f, -1.11247972e-01f, -3.84451337e-02f, -6.68432862e-02f, 1.04867049e-01f, 6.75559193e-02f, 1.16557613e-01f, -9.22080055e-02f,
  -6.12951033e-02f, -1.45842269e-01f, -4.08496074e-02f, -2.18656808e-02f, 1.42027391e-02f, 2.21774937e-03f, -4.25530858e-02f, -2.10944526e-02f, 9.49441493e-02f, -1.81619391e-01f,
  -9.54926759e-02f, 8.42021629e-02f, -6.61528707e-02f, -3.13929617e-02f, -1.35551384e-02f, -8.21283367e-03f, 7.54153654e-02f, -1.56692080e-02f, -1.57432817e-02f, 8.68898071e-03f,
  -3.98144685e-02f, 3.34474407e-02f, -6.11587428e-02f, 1.42806964e-02f, -1.06746018e-04f, 5.06368540e-02f, -8.14606622e-02f, -6.26670569e-02f, 4.60499749e-02f, -1.15476372e-02f,
  -6.93061799e-02f, 5.15462412e-03f, -4.67180535e-02f, 2.03709956e-02f, 9.80757698e-02f, 5.07600904e-02f, -7.54955858e-02f, -1.77437924e-02f, -2.34335297e-04f, -7.27576241e-02f,
  -7.19066188e-02f, 3.58433336e-01f, -1.47211820e-01f, -5.35167828e-02f, 5.99316806e-02f, 1.25850877e-02f, 3.69330272e-02f, 3.92428264e-02f, 4.95535582e-02f, -6.14900477e-02f,
  3.32633629e-02f, -6.28714636e-02f, 2.20435411e-02f, -7.10274652e-02f, -1.29644543e-01f, -4.46931459e-02f, -1.18532777e-01f, 3.93210016e-02f, -5.62938452e-02f, -1.52892787e-02f,
  -1.02951154e-01f, -7.17061460e-02f, -9.89947766e-02f, -5.99893145e-02f, -7.54642189e-02f, -5.19344304e-03f, -7.00206831e-02f, -5.77701963e-02f, -1.15772448e-01f, -1.43494323e-01f,
  -4.79345590e-01f, -2.93775406e-02f, -1.35830035e-02f, -3.98302078e-01f, 1.35964276e-02f, 2.68325895e-01f, 1.80044651e-01f, -9.36639495e-03f, -8.76258612e-02f, -1.65014006e-02f,
  -7.01917112e-02f, -1.03400134e-01f, -1.33421883e-01f, -3.80740911e-02f, -7.93407299e-03f, -1.94438733e-02f, -1.23338297e-01f, -5.61875366e-02f, 1.02124512e-01f, 3.19604911e-02f,
  -3.84206399e-02f, -2.49749944e-01f, -2.60659128e-01f, -2.83906348e-02f, -1.01190940e-01f, -9.83320028e-02f, -1.56182185e-01f, -1.53488191e-02f, 4.90256697e-02f, -1.16659254e-01f,
  6.68720081e-02f, -1.32011831e-01f, 9.43674520e-02f, -9.28326845e-02f, -1.01349331e-01f, -3.85955274e-02f, 8.30923673e-04f, -9.06955227e-02f, 6.89497450e-03f, -8.41495022e-03f,
  -8.15213099e-03f, 1.97434071e-02f, -1.20007016e-01f, -5.23661003e-02f, -5.75757399e-02f, 1.00003466e-01f, -4.00136784e-02f, -1.02893688e-01f, 9.54426378e-02f, 1.22443795e-01f,
  3.50112207e-02f, 9.06348228e-02f, 1.10678092e-01f, 1.52974367e-01f, 2.37629283e-03f, 9.27905664e-02f, 1.52463481e-01f, 1.92821622e-02f, 1.61741644e-01f, 1.86037598e-03f,
  3.47615331e-02f, -1.42368441e-02f, 1.56794488e-02f, -2.55750455e-02f, 4.10410240e-02f, -4.61544953e-02f, 6.82915077e-02f, -3.09841260e-02f, -3.18937786e-02f, -7.09211873e-03f,
  5.44600077e-02f, 3.92186902e-02f, 1.31413732e-02f, -5.25581464e-02f, 3.25642526e-02f, 2.10115984e-02f, 5.74245043e-02f, 2.28048139e-03f, 1.84122026e-02f, 4.34024669e-02f,
  6.42984733e-02f, 8.51489231e-02f, -1.08596765e-01f, 3.73024754e-02f, 1.26455696e-02f, 1.10582542e-02f, -5.92665281e-03f, 7.72776008e-02f, -4.30607684e-02f, -9.09308437e-03f,
  -2.04590157e-01f, 1.57456860e-01f, -1.51254684e-01f, -1.36103868e-01f, -7.20241740e-02f, 1.00895092e-02f, -1.76019780e-02f, -5.21356650e-02f, -8.12853426e-02f, 3.23762111e-02f,
  -2.02458631e-03f, 1.73686687e-02f, -1.91374030e-02f, 6.56561032e-02f, -1.32358102e-02f, -3.68737951e-02f, -7.58018047e-02f, -7.21836537e-02f, 9.32739154e-02f, -5.38231060e-02f,
  3.02263182e-02f, 1.11308023e-01f, -2.01733429e-02f, -4.11243327e-02f, 1.26271471e-01f, 9.68230143e-03f, 2.37549823e-02f, 7.44046047e-02f, 4.29496095e-02f, -9.66753438e-02f,
  2.88342148e-01f, -1.13653071e-01f, -7.27805570e-02f, 9.19843987e-02f, -7.79240131e-02f, -7.31211295e-03f, -1.43615216e-01f, 4.70143463e-03f, 5.10448553e-02f, -6.32790700e-02f,
  1.84948687e-02f, 1.05945677e-01f, 2.20122561e-03f, 1.37823028e-02f, 9.08532143e-02f, -5.82623202e-03f, -5.52080832e-02f, 6.45436421e-02f, 1.16774574e-01f, 7.88052157e-02f,
  -1.15807816e-01f, -5.29289362e-04f, -5.73802041e-03f, -5.31822536e-03f, -1.57677695e-01f, -3.94771546e-02f, -7.67283468e-03f, -1.49526864e-01f, -1.32491902e-01f, -1.79958999e-01f,
  -7.61702061e-02f, 8.37883949e-02f, 4.83136587e-02f, 1.95879024e-02f, -7.42581487e-02f, -5.39563373e-02f, -1.33718541e-02f, 3.07729281e-03f, 2.74380911e-02f, -2.53158584e-02f,
  -5.06390594e-02f, 8.11320171e-02f, -6.19256608e-02f, 1.12659112e-02f, -1.06341660e-01f, -8.22500288e-02f, -2.30745208e-02f, -4.71202321e-02f, -1.62569061e-02f, -1.83572900e-02f,
  2.64706071e-02f, 2.49818042e-02f, 1.10797457e-01f, 1.59644671e-02f, 8.72708932e-02f, 1.02609947e-01f, 6.63777580e-04f, -5.06124087e-03f, 1.00543626e-01f, -1.03074498e-01f,
  -8.64427909e-02f, 1.79229807e-02f, -4.44159470e-02f, 6.56849816e-02f, 4.58413623e-02f, -5.88860549e-03f, 7.41809085e-02f, 4.80283834e-02f, -2.64384188e-02f, -4.17049266e-02f,
  2.58346554e-02f, -4.21437584e-02f, 2.34306813e-03f, -4.37295996e-03f, -2.45381519e-02f, 4.73173559e-02f, -8.52996111e-02f, 4.64528650e-02f, -4.31376137e-02f, 1.62898854e-03f,
  1.74279772e-02f, 1.63632575e-02f, -4.32410501e-02f, -2.60825958e-02f, -8.37955624e-03f, 9.35144350e-03f, 2.26219557e-02f, -5.40440045e-02f, -6.79622917e-03f, -3.25781740e-02f,
  1.07099943e-01f, 2.23798141e-01f, 9.66403410e-02f, 3.81789021e-02f, 5.70494421e-02f, 6.57711737e-03f, 1.07041597e-01f, 4.35694121e-02f, 7.57148042e-02f, 4.95554693e-02f,
  2.43959893e-02f, 8.90023410e-02f, -7.00028539e-02f, -6.28938675e-02f, -6.33944348e-02f, -4.38780449e-02f, 8.77774209e-02f, 6.34722933e-02f, 7.48508796e-02f, -7.03192800e-02f,
  -8.44560191e-02f, 3.81485708e-02f, 1.74886659e-01f, 8.65534320e-02f, 3.84500325e-02f, 1.52986705e-01f, 1.71903726e-02f, -6.08369745e-02f, 3.26740667e-02f, -2.90125012e-02f,
  2.14054152e-01f, -3.22950989e-01f, 2.37091914e-01f, 6.10198006e-02f, 2.25966841e-01f, 3.37766051e-01f, 1.99789524e-01f, 1.07085221e-01f, 7.82153159e-02f, 5.83885908e-02f,
  -1.34539902e-01f, -4.01175544e-02f, -5.79748582e-03f, -1.31233752e-01f, -3.18918470e-03f, -4.42831144e-02f, 6.47549406e-02f, 5.15799075e-02f, 2.21103951e-01f, 6.88885376e-02f,
  8.68711155e-03f, 3.73814851e-02f, -8.16399530e-02f, -3.28956731e-02f, -1.24555811e-01f, 9.76451784e-02f, -2.13442575e-02f, -1.04397692e-01f, -1.49159282e-01f, -1.50300980e-01f,
  1.08362352e-02f, 2.76483726e-02f, 1.86005920e-01f, -1.57976538e-01f, -7.01329857e-02f, -3.93376462e-02f, 8.72643664e-02f, 7.43954442e-03f, -4.76323739e-02f, 5.24293147e-02f,
  -6.33306950e-02f, 5.18394867e-03f, 6.20152876e-02f, 2.53806002e-02f, -4.32286672e-02f, -1.71533246e-02f, -6.20444603e-02f, -1.52845278e-01f, -6.14938885e-02f, -1.47865400e-01f,
  -2.31326550e-01f, 6.94016740e-02f, 7.35342279e-02f, 1.08563699e-01f, 3.77807915e-02f, -4.70216945e-03f, -9.22795981e-02f, -5.71634322e-02f, 2.36562919e-02f, -1.49034798e-01f,
  3.13673466e-02f, 7.29359640e-03f, -5.30512989e-05f, -1.88007802e-02f, -5.87560190e-03f, 5.11605386e-03f, 7.68742487e-02f, -4.41297926e-02f, -3.18175592e-02f, 9.38873291e-02f,
  -4.53775190e-02f, 8.85294527e-02f, 2.61282586e-02f, 6.39965311e-02f, -3.64220962e-02f, -1.31819109e-02f, 6.64739981e-02f, -6.18445575e-02f, -4.66996059e-02f, 2.70513282e-03f,
  -1.33568635e-02f, -1.74696967e-02f, -1.88505184e-02f, -1.27823716e-02f, 9.68723930e-03f, -6.58328459e-02f, 6.59779832e-02f, 1.61617193e-02f, -3.52905947e-03f, -5.17483018e-02f,
  7.00222552e-02f, 7.29383603e-02f, 6.91725761e-02f, -4.24446650e-02f, -3.24497595e-02f, -5.76804988e-02f, -7.12806582e-02f, -8.70398358e-02f, -1.40879415e-02f, -1.63916685e-02f,
  8.03065151e-02f, 1.26527762e-02f, -6.91705570e-02f, -7.63971284e-02f, 1.40031829e-01f, 4.23352569e-02f, -1.88271657e-01f, 1.23475261e-01f, -3.54064219e-02f, -1.15587013e-02f,
  -3.76387239e-02f, 2.16029540e-01f, 2.84367085e-01f, 1.19014442e-01f, 5.17795160e-02f, 3.06158245e-01f, 1.15673520e-01f, 1.00425802e-01f, 1.09094568e-01f, 2.33072657e-02f,
  -1.76894113e-01f, -2.71046191e-01f, -3.49657863e-01f, -1.18909232e-01f, -1.28451139e-01f, -4.62491401e-02f, -1.78790256e-01f, 1.06071597e-02f, 2.37282608e-02f, -3.14933807e-01f,
  -1.89686090e-01f, -1.28053829e-01f, -2.06866905e-01f, -7.83153400e-02f, -1.03594400e-01f, -2.71461546e-01f, -3.18719506e-01f, -3.42580408e-01f, -4.87751924e-02f, 1.37029395e-01f,
  -9.67882425e-02f, -2.66838580e-01f, -1.88899085e-01f, 5.45934550e-02f, -1.38207376e-01f, -2.67253071e-01f, -3.45296174e-01f, -2.19098032e-01f, -1.54803097e-01f, -4.06467497e-01f,
  -2.65228689e-01f, 1.85206100e-01f, 1.08691253e-01f, -1.42786160e-01f, -3.14204767e-02f, 3.66344601e-02f, -3.40639837e-02f, -8.88210163e-03f, 5.89857660e-02f, 6.15505278e-02f,
  -3.37230898e-02f, 1.49025336e-01f, 7.30197206e-02f, -8.99805967e-03f, 4.51733777e-03f, -8.16935580e-03f, -6.53584674e-02f, -1.28480375e-01f, -5.57498783e-02f, 5.74756414e-02f,
  -1.05335917e-02f, -1.64564922e-02f, -7.54974559e-02f, 1.11675285e-01f, 1.32063255e-01f, -8.68704244e-02f, -4.67757732e-02f, -1.24775642e-03f, -9.99294817e-02f, -1.39936864e-01f,
  -4.20409739e-02f, -5.37803769e-03f, -9.04628169e-03f, -2.51166429e-03f, -4.03520130e-02f, 3.26239951e-02f, -5.94801605e-02f, -2.15862282e-02f, 2.59841550e-02f, -5.29243425e-02f,
  -5.27507067e-02f, 5.89431077e-02f, -3.80317718e-02f, 2.52977312e-02f, -1.73067339e-02f, -8.68438035e-02f, -1.53858345e-02f, 5.13523147e-02f, -7.49723241e-02f, -3.50699127e-02f,
  -4.35250737e-02f, 6.45319745e-02f, -9.65003222e-02f, -3.68356369e-02f, -9.78904888e-02f, -1.13168634e-01f, 4.10109498e-02f, 9.39951614e-02f, 8.76286179e-02f, 9.88576263e-02f,
  -1.08475193e-01f, -2.99076289e-02f, -9.08238441e-02f, 6.09522015e-02f, -2.81530409e-03f, -1.41275749e-02f, -5.59398830e-02f, 3.66416425e-02f, -4.74601565e-03f, -4.19296622e-02f,
  6.02392294e-02f, -1.84978843e-02f, -9.10192281e-02f, 1.89677789e-03f, 3.56967300e-02f, 5.85646294e-02f, -8.10792521e-02f, -9.59444568e-02f, 3.90787004e-03f, 1.41517445e-01f,
  -9.07625034e-02f, -8.15161541e-02f, 2.50189868e-03f, -1.01618819e-01f, 1.08824663e-01f, -1.51939765e-01f, 3.19932252e-02f, -3.81408585e-03f, -1.73556525e-02f, -1.30962819e-01f,
  4.38113898e-01f, 3.01815391e-01f, 1.69159099e-01f, 8.90512019e-02f, 8.51643831e-02f, 5.18849567e-02f, 2.54281372e-01f, 6.96735233e-02f, -1.82156954e-02f, 1.07410466e-02f,
  4.11462374e-02f, -1.49027839e-01f, 3.32620926e-03f, -5.62615022e-02f, 3.04781329e-02f, 6.42082244e-02f, 7.01390430e-02f, 1.06446505e-01f, 8.49488601e-02f, 4.58691902e-02f,
  3.76770496e-02f, -2.90152673e-02f, 1.83536366e-01f, -1.45377126e-02f, 2.20912532e-03f, -1.82045579e-01f, -8.24475512e-02f, 8.68105665e-02f, 8.62165987e-02f, -5.63348234e-02f,
  -8.89071524e-02f, 3.13645512e-01f, -1.44191831e-01f, -1.20214716e-01f, -6.88039735e-02f, 8.74425322e-02f, 4.11882857e-03f, 4.74934131e-02f, 4.40412536e-02f, -2.74850670e-02f,
  -6.69983178e-02f, -1.76357012e-02f, 7.78191686e-02f, 2.65038498e-02f, 9.51194987e-02f, 7.86477253e-02f, 1.80566078e-03f, 4.84699160e-02f, -4.15406637e-02f, 3.67678981e-03f,
  -3.59209850e-02f, 6.78082481e-02f, 1.62461877e-01f, -6.63100034e-02f, -2.51111351e-02f, -7.74068832e-02f, -2.93210950e-02f, 4.15516347e-02f, 6.12320900e-02f, 4.17228155e-02f,
  -3.83031256e-02f, -8.24470147e-02f, 1.98530629e-02f, 9.91102681e-02f, 4.42149527e-02f, 4.10961658e-02f, -1.88679323e-02f, -3.22922841e-02f, 9.28557757e-03f, 1.93944313e-02f,
  2.48784199e-02f, -1.35130594e-02f, 3.65427211e-02f, 8.04590806e-02f, -8.31386372e-02f, -2.52268068e-03f, 4.17659134e-02f, -7.41123185e-02f, 3.98003310e-02f, 4.25803848e-02f,
  3.65043245e-02f, 2.98222788e-02f, 9.02616698e-03f, -4.71547619e-02f, 3.64937936e-03f, -7.54221305e-02f, -3.60929258e-02f, -5.43124862e-02f, 7.56801888e-02f, 7.81581737e-03f,
  -2.40091860e-01f, -3.04689538e-02f, -1.67764693e-01f, -7.36441985e-02f, -5.05719036e-02f, -3.26681882e-02f, -1.25968799e-01f, 6.78990781e-02f, -2.01815590e-02f, 5.91930002e-02f,
  -2.56807841e-02f, -4.10949439e-02f, -7.91497156e-02f, -4.86167409e-02f, -4.81696054e-02f, -1.24839820e-01f, -8.80660675e-03f, -6.93406211e-04f, -1.22094072e-01f, -6.91435160e-03f,
  -8.16051513e-02f, -8.88524577e-02f, 2.85678115e-02f, 4.54451554e-02f, -5.47541864e-02f, -6.94908127e-02f, -2.87333857e-02f, -7.03195035e-02f, 8.30866322e-02f, 1.86341740e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.07956398e-01f, 1.74328655e-01f, 1.69556767e-01f, 1.56679004e-01f, 1.96149889e-02f, 2.54791349e-01f, 2.11570084e-01f, 2.10357711e-01f, 3.03484350e-01f, 1.63621247e-01f,
  -3.86518426e-02f, 2.02777609e-01f, 2.20789611e-01f, 1.29983723e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.37987444e-01f, 2.26022750e-01f, -7.20850751e-02f, 6.75356714e-03f, -3.33796553e-02f, -2.31169090e-02f, 1.09815300e-01f, 2.42221169e-03f, -3.85306515e-02f, -1.55392632e-01f,
  4.34004247e-01f, 5.74492574e-01f, -5.48308641e-02f, 1.84504688e-01f, -3.32010776e-01f, 3.18968713e-01f, -3.61053675e-01f, -2.50967175e-01f, -1.11228719e-01f, -1.90932333e-01f,
  1.72993526e-01f, -4.68330793e-02f, -2.33434021e-01f, 1.14297383e-01f, -1.18396662e-01f, 7.73424329e-03f, -2.12655395e-01f, 1.73377559e-01f, 1.12892024e-01f, 1.00446507e-01f,
  2.94355243e-01f, -4.14556637e-02f, 1.54124364e-01f, -2.34669775e-01f, 2.20989078e-01f, 1.00027747e-01f, -4.09723133e-01f, -1.75406381e-01f, 4.56438698e-02f, 4.61565107e-01f,
  -8.32616612e-02f, 3.50957692e-01f, -3.25105727e-01f, -2.23625768e-02f, 5.38717024e-02f, 8.74874741e-02f, 3.26190829e-01f, 1.75076917e-01f, -6.40469909e-01f, -1.19037107e-01f,
  2.73786157e-01f, 5.33869490e-03f, -6.84801117e-02f, -1.81600913e-01f, -2.68428564e-01f, 6.69417381e-02f, 4.16750498e-02f, 3.53276283e-01f, 2.08108779e-02f, 1.80384312e-02f,
  4.00545776e-01f, 4.89276767e-01f, -1.97299138e-01f, 1.50118157e-01f, -3.50046843e-01f, 2.71328032e-01f, -2.14796022e-01f, 1.06580429e-01f, -1.85468718e-01f, -2.55835682e-01f,
  3.85882705e-01f, 6.49204478e-02f, 4.48207818e-02f, -3.59314829e-01f, 2.48187110e-02f, 5.97576022e-01f, -4.42963958e-01f, 4.25020039e-01f, -3.21049958e-01f, 3.73992413e-01f,
  -1.26816422e-01f, 1.55391291e-01f, -1.47315785e-01f, 7.62172043e-02f, 2.81053424e-01f, -7.90450349e-02f, -6.78506270e-02f, 2.47931648e-02f, 2.24579006e-01f, -8.71539414e-02f,
  9.53456983e-02f, 7.37666860e-02f, 1.09815776e-01f, -1.70626849e-01f, 1.77489400e-01f, 1.94974035e-01f, 8.30608681e-02f, 1.04813799e-01f, 2.39555001e-01f, -1.44621626e-01f,
  4.16102886e-01f, 8.25515464e-02f, 4.01945323e-01f, -3.23263705e-01f, 2.45868176e-01f, -3.30213547e-01f, -5.20802259e-01f, -4.08758283e-01f, -1.11658968e-01f, 4.02377278e-01f,
  -9.58723351e-02f, -3.06946993e-01f, 2.13048652e-01f, 3.44580054e-01f, 1.76918097e-02f, -4.50866148e-02f, -1.59013107e-01f, -1.02991141e-01f, -4.13353182e-02f, 9.66621414e-02f,
  4.48927581e-02f, 1.30700886e-01f, 2.05252707e-01f, -2.64807314e-01f, -1.14739306e-01f, -3.77099127e-01f, -1.11088015e-01f, -1.38040990e-01f, -4.20641452e-01f, -3.37758273e-01f,
  3.75769697e-02f, 1.79560035e-01f, -2.42319793e-01f, 1.08884931e-01f, -1.37154907e-01f, 8.73082876e-02f, -8.79011750e-02f, -1.16944417e-01f, 4.28363681e-01f, -3.41779552e-02f,
  -3.19333285e-01f, -3.93505841e-02f, -4.80652153e-01f, -2.30368137e-01f, -2.68748462e-01f, 1.31487712e-01f, 2.69278824e-01f, 1.83532208e-01f, -1.58939198e-01f, 4.78682481e-03f,
  4.31850217e-02f, 1.86643541e-01f, 3.35193463e-02f, -4.61302042e-01f, -3.28236431e-01f, 1.57215878e-01f, -8.78594369e-02f, -9.22974348e-02f, 2.24295437e-01f, -1.77980185e-01f,
  1.53226718e-01f, 1.42780915e-01f, 4.58962992e-02f, 6.13733232e-02f, -2.62482762e-01f, 2.15200886e-01f, 8.81900862e-02f, 1.16510198e-01f, 2.54007190e-01f, 4.99640629e-02f,
  7.72792324e-02f, -6.68121576e-01f, 3.12486798e-01f, -2.56002009e-01f, 1.68954238e-01f, -3.96678478e-01f, -3.88926193e-02f, 3.67729217e-02f, -1.55511886e-01f, -2.94517487e-01f,
  -8.59599281e-03f, -3.40314955e-02f, 1.66010529e-01f, -5.22366874e-02f, 9.37821418e-02f, 2.46141002e-01f, 1.97404429e-01f, -2.09958389e-01f, -8.14290345e-02f, -3.93700987e-01f,
  -2.18598545e-01f, 2.79711455e-01f, 4.93390054e-01f, 1.02078013e-01f, -3.16310138e-01f, -3.84903699e-02f, 1.52357087e-01f, 8.73345062e-02f, 1.76978588e-01f, -1.27332389e-01f,
  6.04589880e-02f, 2.46047024e-02f, -2.94699460e-01f, -5.52820027e-01f, 1.89586118e-01f, -3.66240591e-01f, 1.17887862e-01f, -3.18181664e-01f, 1.51496366e-01f, 1.01278149e-01f,
  6.93618646e-03f, 1.28845004e-02f, -8.17269236e-02f, 1.66390091e-02f, 9.18110088e-02f, -1.25004530e-01f, 3.90128084e-02f, 1.41340479e-01f, -9.94119719e-02f, 1.81789726e-01f,
  -2.22155973e-01f, -3.59254214e-03f, -2.27073193e-01f, 4.50692931e-03f, -2.99869835e-01f, 3.66994664e-02f, -9.03076530e-02f, 3.90568525e-01f, -7.77520761e-02f, -9.98229682e-02f,
  -4.43132877e-01f, -2.57491972e-03f, -1.46505788e-01f, -2.67196000e-01f, 3.58700603e-01f, 1.33535787e-01f, 1.17209218e-01f, -6.32222742e-02f, -4.10747260e-01f, -8.06905404e-02f,
  4.06579345e-01f, -1.05945043e-01f, -4.00811642e-01f, 3.40555042e-01f, -8.33839998e-02f, 2.45527789e-01f, 6.26667067e-02f, -1.03489764e-01f, 2.63373051e-02f, -7.87484348e-02f,
  4.47308347e-02f, -3.02430719e-01f, 2.87136763e-01f, -2.06596285e-01f, 2.57641137e-01f, -3.10523599e-01f, -1.08566970e-01f, -1.84303790e-01f, 1.98559344e-01f, 2.90875375e-01f,
  -5.25802732e-01f, -8.49597082e-02f, -9.96496826e-02f, 5.01634181e-01f, 6.05079532e-02f, 3.18553597e-01f, 5.23124397e-01f, -1.19792081e-01f, 1.95997924e-01f, -3.36628407e-01f,
  -1.81556251e-02f, -8.19166973e-02f, -4.31483924e-01f, -8.47707596e-03f, 3.57304439e-02f, -7.23075196e-02f, 2.35601515e-01f, -1.47461399e-01f, -1.00388534e-01f, 2.68541813e-01f,
  1.32152244e-01f, 1.88553631e-01f, -1.40262440e-01f, -1.99282289e-01f, 1.72518879e-01f, 6.22817501e-02f, -1.34325221e-01f, 3.13712716e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.08199155e-02f, 1.57287568e-01f, 3.06468040e-01f, 4.47216630e-02f, -1.62061960e-01f, 8.25507566e-02f, -8.61642584e-02f, 3.99537295e-01f, 2.22456455e-01f, 5.26270680e-02f,
  -3.31558168e-01f, -1.92310121e-02f, -6.61854772e-03f, -2.59721398e-01f, 2.73788363e-01f, 1.20567635e-01f, -2.51516789e-01f, 1.41125964e-02f, -1.73871562e-01f, 2.24588633e-01f,
  -1.05797373e-01f, -9.57574099e-02f, -2.57846210e-02f, -5.87096438e-02f, 3.30407739e-01f, 3.19742739e-01f, 3.54686201e-01f, -4.81074750e-02f, 1.04310289e-01f, 1.62976235e-01f,
  1.33591875e-01f, 3.56284112e-01f, -2.06166819e-01f, -1.37590200e-01f, 2.43659951e-02f, -9.33884755e-02f, 1.23217851e-01f, 8.63144025e-02f, -2.71396875e-01f, 4.20937002e-01f,
  -1.13983955e-02f, 2.87011594e-01f, -2.68118113e-01f, -2.93161064e-01f, 3.46497715e-01f, -3.58003169e-01f, 3.25439796e-02f, -2.20566347e-01f, 3.47409725e-01f, 2.04653591e-02f,
  -1.75553381e-01f, 1.57942310e-01f, -1.41654298e-01f, -1.73691943e-01f, 2.93768734e-01f, -1.65591270e-01f, -1.63964719e-01f, 3.20389271e-02f, -3.13275158e-01f, 3.17861438e-02f,
  -5.99639937e-02f, -2.44009197e-01f, -2.36066833e-01f, 2.32691064e-01f, -2.58756638e-01f, 2.97255397e-01f, 7.81691372e-02f, 5.66141754e-02f, -3.25303003e-02f, -5.13748042e-02f,
  3.58885229e-01f, -1.60591274e-01f, 2.78867215e-01f, -3.52766588e-02f, 4.56728399e-01f, -5.45581281e-02f, 1.48324249e-02f, 4.27230075e-02f, -3.42191398e-01f, 1.13045692e-01f,
  1.21394724e-01f, 1.19065754e-01f, -1.16466478e-01f, -1.15838103e-01f, 3.47678900e-01f, 1.26700938e-01f, 1.35523453e-01f, 3.47263902e-01f, 2.40296394e-01f, 4.04439308e-02f,
  3.81928831e-02f, -4.06362750e-02f, -1.49192065e-01f, -8.01938996e-02f, 6.04673743e-01f, 3.00894499e-01f, 2.20939353e-01f, 4.00910795e-01f, -3.35087180e-01f, 2.75658697e-01f,
  -3.97798985e-01f, 1.55580088e-01f, -1.77559972e-01f, 3.29021066e-01f, 4.58622307e-01f, 2.00553522e-01f, -2.22795546e-01f, 5.24727643e-01f, -1.61678135e-01f, -4.28620487e-01f,
  3.25250208e-01f, 1.26512587e-01f, -6.28459007e-02f, 1.17355280e-01f, 1.80345118e-01f, 7.31773525e-02f, 3.28404188e-01f, 2.34403059e-01f, 1.54278889e-01f, -1.52761620e-02f,
  2.03307923e-02f, 1.82640910e-01f, 2.69088566e-01f, 5.90533197e-01f, -5.25303185e-04f, -1.64236441e-01f, 4.63207901e-01f, 1.73332214e-01f, 6.29144982e-02f, 2.47252777e-01f,
  7.27676600e-02f, 2.76683867e-01f, 5.04412651e-02f, 1.79865599e-01f, 4.70087171e-01f, 1.56773657e-01f, 2.90067911e-01f, -3.63791376e-01f, 5.93074024e-01f, -2.98213482e-01f,
  -1.74509153e-01f, 5.70929766e-01f, -1.17938966e-01f, 2.13981941e-01f, -5.11099756e-01f, 2.73800731e-01f, 2.67216749e-02f, -1.58852652e-01f, 2.43858695e-01f, -2.30244681e-01f,
  -1.29564226e-01f, 3.58454227e-01f, 3.50793675e-02f, 5.52872010e-02f, -2.18766972e-01f, 2.51871184e-03f, -2.22106129e-01f, 1.76194310e-01f, 3.24408948e-01f, 2.51412392e-01f,
  -2.38907173e-01f, 1.82990190e-02f, 4.02826995e-01f, -1.95274353e-01f, 1.97308764e-01f, 6.48022443e-02f, 2.95384496e-01f, 1.27991661e-01f, -1.93526894e-01f, -3.93055350e-01f,
  -1.42206073e-01f, -8.64232406e-02f, -2.25695506e-01f, 4.14974660e-01f, 3.25583410e-03f, 7.25355968e-02f, 6.20728061e-02f, 2.56663352e-01f, 1.44734338e-01f, -1.12214806e-02f,
  1.78137779e-01f, -1.93666428e-01f, -1.69118240e-01f, 3.79869580e-01f, -2.32289564e-02f, 6.38000891e-02f, 3.11012473e-02f, -1.91395149e-01f, 1.08518027e-01f, -5.44508882e-02f,
  1.38576850e-01f, -5.77442609e-02f, 6.86814487e-02f, 2.71603078e-01f, -2.31725611e-02f, -2.24944934e-01f, 4.02909458e-01f, 4.11107726e-02f, 2.13149160e-01f, -1.92727819e-01f,
  -5.03541948e-03f, -1.96832642e-01f, -2.07782295e-02f, 9.70648881e-03f, -3.08009565e-01f, -3.62917751e-01f, 1.86985508e-02f, -1.43048823e-01f, 3.07875276e-01f, 6.77546188e-02f,
  1.88672602e-01f, -1.36623845e-01f, 3.44508320e-01f, 2.22341120e-01f, 2.89944679e-01f, 1.91406347e-02f, 1.60780191e-01f, -2.67007619e-01f, 1.91997409e-01f, 2.47892812e-01f,
  -2.21675351e-01f, -2.12256432e-01f, 3.38897943e-01f, -1.42747045e-01f, 1.16855659e-01f, -1.52879745e-01f, -3.74696590e-02f, 3.92926484e-02f, 1.13086350e-01f, 1.60112940e-02f,
  3.93358856e-01f, 3.25413436e-01f, 2.20995963e-01f, -3.53960901e-01f, -3.20522673e-02f, 2.46100314e-02f, -3.65523338e-01f, 3.51216018e-01f, -3.69749159e-01f, 2.20910355e-01f,
  -2.82987863e-01f, 5.87902702e-02f, 4.83227015e-01f, -3.48367505e-02f, 1.80825397e-01f, 1.08486637e-01f, -2.17008203e-01f, 4.40626666e-02f, -1.47308484e-01f, -2.77349770e-01f,
  1.21577270e-02f, 1.27504647e-01f, -2.12095566e-02f, -6.55436665e-02f, 3.20259184e-01f, -1.52770355e-01f, -2.85056531e-01f, 2.81157821e-01f, 2.04628423e-01f, 2.78571378e-02f,
  2.42287125e-02f, 1.31252632e-01f, -3.25102150e-01f, -3.34951691e-02f, -2.08067387e-01f, -2.77990669e-01f, 8.59611034e-02f, 1.04001448e-01f, -1.44607827e-01f, 4.49213833e-01f,
  -1.10905863e-01f, 2.97027439e-01f, 9.35360938e-02f, -2.16849804e-01f, -1.34925768e-01f, 3.59172344e-01f, -2.60016590e-01f, -1.08175687e-01f, -6.12281971e-02f, 2.77832329e-01f,
  1.03057576e-02f, 2.43842572e-01f, 2.18297318e-01f, -2.54827529e-01f, 8.33687410e-02f, 3.21918488e-01f, 5.26747942e-01f, 1.83017358e-01f, 6.07578196e-02f, 1.44728702e-02f,
  1.38617620e-01f, 1.05860136e-01f, 1.89866304e-01f, 1.44093722e-01f, -3.41274291e-02f, -1.84402578e-02f, -9.51518193e-02f, -2.29213312e-01f, -1.48584425e-01f, -2.09703624e-01f,
  -1.99388802e-01f, -4.55054253e-01f, -1.85895786e-01f, -3.58222067e-01f, 1.71611220e-01f, 1.51946440e-01f, 1.71983764e-01f, 2.14854181e-01f, 2.70468920e-01f, 3.26825798e-01f,
  5.23430556e-02f, -7.89529234e-02f, 2.59524941e-01f, -3.54728669e-01f, 1.28860995e-01f, 1.16717577e-01f, -2.12311611e-01f, 2.16573980e-02f, 1.84023038e-01f, 1.15341686e-01f,
  1.68842837e-01f, -1.30514707e-02f, 3.39398652e-01f, -2.01203153e-01f, 3.45424563e-01f, 1.28623754e-01f, 3.54532719e-01f, 2.40847990e-01f, -3.95983867e-02f, -1.80311918e-01f,
  -5.15790939e-01f, 3.31048846e-01f, -1.97369784e-01f, -9.86465346e-03f, 1.86624318e-01f, 2.09527854e-02f, 1.62934169e-01f, 2.00547233e-01f, 2.05512390e-01f, -4.64857705e-02f,
  4.84650470e-02f, -1.78519636e-01f, -2.21781865e-01f, -6.58192346e-03f, 2.75037671e-03f, 3.66912335e-02f, 3.39740247e-01f, -1.95859671e-01f, -1.04555652e-01f, -1.58647392e-02f,
  1.54748531e-02f, -8.87079611e-02f, 3.30676556e-01f, 3.37716907e-01f, 2.23632082e-01f, -1.85037598e-01f, 9.13089048e-03f, 2.39509121e-01f, 1.37741640e-01f, -3.31228673e-02f,
  -1.13069616e-01f, -1.74633667e-01f, -2.26312280e-01f, -1.82441011e-01f, -1.91785857e-01f, 3.67683172e-01f, -3.73951904e-02f, 1.41106606e-01f, -5.16133726e-01f, -5.80750816e-02f,
  6.33776009e-01f, 1.04483284e-01f, -6.91158772e-02f, -2.28349760e-01f, 2.76323333e-02f, 7.59819597e-02f, 1.63117945e-02f, 3.47964883e-01f, -9.38559547e-02f, 1.59001991e-01f,
  -1.83910653e-01f, 3.45192552e-01f, -1.10719532e-01f, -1.74813479e-01f, 2.26726398e-01f, 1.83216110e-01f, -3.77914794e-02f, 3.12938541e-01f, 2.21903119e-02f, 9.74777713e-02f,
  5.11083379e-02f, 2.11062789e-01f, 1.78157285e-01f, 3.06274354e-01f, -2.09333360e-01f, 5.89148343e-01f, 3.43110681e-01f, 4.39605266e-02f, 2.50078857e-01f, 2.87792832e-01f,
  2.76765823e-01f, -7.31030554e-02f, 4.73653376e-02f, 2.45227516e-02f, -2.63728965e-02f, 1.65448532e-01f, -1.78163797e-01f, 6.81382865e-02f, -1.38854399e-01f, -7.53359795e-02f,
  4.07883763e-01f, 2.18377829e-01f, 2.75805723e-02f, -1.62052333e-01f, 6.29782081e-02f, -1.38051420e-01f, 2.42313042e-01f, -1.37462020e-01f, 3.46617490e-01f, -1.81618288e-01f,
  2.21738398e-01f, 2.18135998e-01f, 4.48778808e-01f, 1.32615477e-01f, 1.34289205e-01f, -1.62175700e-01f, -4.70246017e-01f, -2.13229373e-01f, -3.47981870e-01f, -1.80307850e-01f,
  -1.33813635e-01f, -1.42447248e-01f, 3.48343492e-01f, 4.59931314e-01f, 2.75087684e-01f, 1.02366723e-01f, 1.01418547e-01f, -1.06281400e-01f, -6.47816574e-03f, -5.92989251e-02f,
  1.45961478e-01f, -2.52375633e-01f, 2.71740973e-01f, 1.42706081e-01f, -1.65570602e-01f, -1.02514550e-01f, -1.07712865e-01f, -1.45388052e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.22699672e-01f, 3.15102607e-01f, 3.16837020e-02f, 1.52682737e-01f, 3.45142126e-01f, 4.41654176e-02f, 5.91600873e-02f, 8.21082294e-02f, 3.71878028e-01f, 3.29668343e-01f,
  1.22433819e-01f, 1.53190583e-01f, 1.19553871e-01f, 4.19148713e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -6.09317899e-01f, -1.91462547e-01f, -6.34447932e-01f, 1.30142402e-02f, -4.56840664e-01f, -3.93565059e-01f, -5.43450356e-01f, -2.08486840e-01f, -2.34942749e-01f, 1.08229190e-01f,
  -3.04976761e-01f, 8.04600772e-03f, -2.72099245e-02f, 2.88612932e-01f, -2.32982770e-01f, 5.27362227e-02f, 5.31363428e-01f, -3.99600953e-01f, -2.61094511e-01f, -2.06975535e-01f,
  6.31478310e-01f, 6.56825230e-02f, 2.85669446e-01f, 1.02496035e-01f, 3.93848531e-02f, 2.58398682e-01f, 3.49300563e-01f, -1.64692491e-01f, -4.26663160e-01f, -3.13339025e-01f,
  3.68715897e-02f, -3.35439205e-01f, -2.92671174e-01f, 2.36658361e-02f, -1.44643309e-02f, 3.42013761e-02f, 2.42942154e-01f, 3.14551145e-01f, -3.22270066e-01f, 4.79776114e-01f,
  3.36116105e-01f, 4.10804659e-01f, 5.98622024e-01f, 8.29623103e-01f, -5.08197725e-01f, -1.74279734e-01f, -6.05343163e-01f, -3.90247256e-01f, 4.71415341e-01f, 2.46992290e-01f,
  4.58145231e-01f, -4.30845805e-02f, -1.73411235e-01f, 3.92223150e-01f, 5.35736140e-03f, -3.52569669e-02f, -4.47728366e-01f, -2.00728290e-02f, 6.42198205e-01f, -3.09500456e-01f,
  -1.88558828e-02f, 1.61724567e-01f, 1.35116756e-01f, -5.21564841e-01f, 2.09405154e-01f, 4.03195500e-01f, 7.06503570e-01f, -1.18891574e-01f, -5.93420327e-01f, 6.00572944e-01f,
  1.71066612e-01f, 1.43976539e-01f, -3.25303674e-02f, -2.06898525e-01f, -4.15622801e-01f, 1.86587155e-01f, 4.97564107e-01f, -6.93589985e-01f, 2.12236211e-01f, -5.99488057e-02f,
  -9.02764052e-02f, -7.22817540e-01f, 1.10676251e-01f, -4.83442307e-01f, -2.62627721e-01f, 1.77466124e-01f, -3.66214693e-01f, -8.15908536e-02f, -5.64928129e-02f, -9.92315561e-02f,
  -2.01023549e-01f, -2.52588332e-01f, 3.92592192e-01f, -2.38936245e-01f, 7.75990248e-01f, 1.87633574e-01f, -3.11503142e-01f, 2.57336609e-02f, -8.17507505e-02f, 9.40915272e-02f,
  1.86653689e-01f, 1.59912184e-01f, 2.90364116e-01f, -1.13533728e-01f, -3.53424214e-02f, 4.93956536e-01f, -3.97864521e-01f, 3.12158167e-01f, -4.48597759e-01f, 2.35103164e-02f,
  -3.68095130e-01f, -7.72915874e-03f, -2.37332821e-01f, -4.54220146e-01f, -2.95953095e-01f, -1.44371703e-01f, -7.53872618e-02f, 8.75898659e-01f, -7.35359713e-02f, -4.81004536e-01f,
  4.16535676e-01f, 2.78436482e-01f, -6.93559647e-01f, 1.96187213e-01f, -7.00608790e-02f, 7.18675703e-02f, 2.16832921e-01f, -2.96218265e-02f, 2.21713483e-01f, -3.82585049e-01f,
  -2.65127420e-01f, -4.38362390e-01f, 2.21136346e-01f, 1.51474535e-01f, -8.53128731e-02f, 1.53170943e-01f, -5.36956310e-01f, 3.76180202e-01f, -3.61265957e-01f, 6.92256749e-01f,
  4.85152960e-01f, 1.15461890e-02f, -4.75277990e-01f, -2.66637832e-01f, 1.03253849e-01f, -1.69853449e-01f, -9.86703788e-04f, 6.48966581e-02f, 1.86932608e-01f, -3.55356157e-01f,
  -1.45816624e-01f, 5.04695415e-01f, 6.06768370e-01f, -9.04854015e-02f, 1.13365822e-01f, 4.15026277e-01f, 4.99161005e-01f, -1.56839907e-01f, -3.62445831e-01f, 5.70205390e-01f,
  -1.35549232e-01f, 6.18033230e-01f, 8.31236988e-02f, -9.41224545e-02f, 4.92290743e-02f, 2.34707505e-01f, -7.90134519e-02f, 3.68009269e-01f, 1.03951201e-01f, 6.27050817e-01f,
  2.42192611e-01f, 4.25843626e-01f, 4.64108348e-01f, 1.87868446e-01f, 1.80208713e-01f, -3.67090434e-01f, -4.08408403e-01f, 5.00795841e-01f, -3.52069080e-01f, -1.15534514e-01f,
  3.57979447e-01f, -6.40457451e-01f, 1.13828647e+00f, 4.98501450e-01f, -2.64443338e-01f, 4.38647091e-01f, -6.38877004e-02f, -3.67473543e-01f, -4.32118401e-02f, 4.98152860e-02f,
  -2.09932670e-01f, -2.51929432e-01f, -5.53879142e-01f, 3.75517726e-01f, -3.40988487e-01f, 2.42057629e-03f, -3.06287348e-01f, -7.63118923e-01f, -5.22417843e-01f, 1.66668117e-01f,
  5.50984144e-01f, -2.62751877e-01f, 5.26369028e-02f, -6.31292105e-01f, 4.49168354e-01f, -2.83624411e-01f, 1.91286340e-01f, 3.64575863e-01f, -2.33321309e-01f, 4.03096646e-01f,
  3.94962251e-01f, 7.25406349e-01f, -3.43815237e-01f, 6.90751299e-02f, -5.31276047e-01f, -1.99797060e-02f, -3.95659566e-01f, -1.21644296e-01f, -3.26275259e-01f, -2.14571178e-01f,
  4.77219708e-02f, -2.82997906e-01f, 1.07071862e-01f, 1.81332141e-01f, 5.46260774e-01f, 2.22167835e-01f, -1.00785736e-02f, -3.51532817e-01f, 3.43039870e-01f, 1.79814741e-01f,
  2.67723709e-01f, -2.79293209e-01f, 1.19910352e-01f, -2.01812848e-01f, -5.97147703e-01f, -7.44839370e-01f, -9.11015749e-01f, 7.75673747e-01f, 2.95085251e-01f, -2.86479712e-01f,
  6.19385779e-01f, 7.93951511e-01f, -9.87963658e-03f, 4.63435650e-01f, -1.36707589e-01f, -2.56528109e-01f, -5.80033004e-01f, -6.67876080e-02f, -2.38982812e-01f, -4.63635683e-01f,
  1.12942010e-01f, 1.73407361e-01f, -2.44822666e-01f, -1.73382148e-01f, 1.34421259e-01f, -1.93239778e-01f, 1.69343621e-01f, -6.53213143e-01f, 1.33450598e-01f, 1.34537175e-01f,
  -5.69901407e-01f, 3.89995813e-01f, 2.64100552e-01f, -4.36711580e-01f, 2.58114904e-01f, 3.62812430e-01f, 5.34986556e-01f, -9.23776805e-01f, -3.35312515e-01f, -3.87476325e-01f,
  -1.07706703e-01f, 1.87709138e-01f, -5.85377216e-01f, 2.58755952e-01f, 1.28531888e-01f, -3.08398455e-01f, -1.99482396e-01f, -4.67736274e-01f, 2.03775048e-01f, 2.51797792e-02f,
  -1.33864045e-01f, -4.57012534e-01f, 2.30578989e-01f, -3.67557049e-01f, -1.15594842e-01f, 8.17289710e-01f, -1.42021433e-01f, -4.35225278e-01f, -6.98909312e-02f, -6.06727719e-01f,
  1.96837947e-01f, -1.12862825e-01f, 5.83963752e-01f, -2.62935311e-01f, -3.47270757e-01f, 3.88025075e-01f, 5.19162118e-01f, -6.07040107e-01f, -8.95175278e-01f, -5.89971602e-01f,
  4.49373275e-01f, -4.85929728e-01f, 7.95363665e-01f, 5.83199978e-01f, 6.27921939e-01f, -7.56843030e-01f, -3.10919553e-01f, -6.27428740e-02f, 1.59511909e-01f, -2.46411011e-01f,
  -2.18943711e-02f, -1.85511246e-01f, 3.07276607e-01f, -2.40722716e-01f, -1.20210275e-01f, 4.06901330e-01f, -4.02276307e-01f, -9.45565850e-03f, -2.90673494e-01f, 2.82481223e-01f,
  -9.13580041e-03f, -1.99435234e-01f, 2.77437031e-01f, -3.41453701e-01f, -1.62136599e-01f, -1.68530360e-01f, 7.73102790e-02f, -6.86826766e-01f, 2.94097532e-02f, -8.47357512e-02f,
  4.51944411e-01f, 2.68043935e-01f, 4.32317972e-01f, 5.97464204e-01f, -3.58835399e-01f, -1.38601452e-01f, -3.21818143e-01f, -2.82598883e-01f, -1.72724381e-01f, 1.20931126e-01f,
  -4.88400102e-01f, -5.23500323e-01f, 2.97692753e-02f, 3.81598055e-01f, -1.68493807e-01f, 5.99745393e-01f, -3.13496500e-01f, 1.17100038e-01f, 3.78218681e-01f, 6.75447226e-01f,
  -2.19869047e-01f, 5.47842979e-01f, 3.82961750e-01f, 1.74192965e-01f, 4.87429947e-01f, 3.00815940e-01f, 1.86671078e-01f, -8.27953935e-01f, 4.78747226e-02f, 2.03442618e-01f,
  -6.93359792e-01f, -3.15223068e-01f, 7.93535650e-01f, 4.86095995e-02f, -4.05256689e-01f, 3.78212333e-02f, 3.51777017e-01f, 1.44690186e-01f, -4.81617272e-01f, 5.24308860e-01f,
  4.83525515e-01f, -3.15752000e-01f, 4.09504890e-01f, 3.59017640e-01f, 1.87775984e-01f, -2.23011866e-01f, -3.88912931e-02f, -3.99704993e-01f, -4.49953705e-01f, 1.53111666e-01f,
  -3.36538792e-01f, -1.16442904e-01f, -2.41947487e-01f, 9.43396837e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.39418617e-01f, 3.05038262e-02f, -7.99660385e-03f, -3.90635312e-01f, -9.41508263e-02f, -1.08099490e-01f, 1.63039804e-01f, 2.55416691e-01f, -9.40533429e-02f, 1.92961454e-01f,
  -1.40295655e-01f, -3.66730131e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    