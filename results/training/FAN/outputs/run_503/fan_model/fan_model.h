/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.55376208e-01f, 1.34689435e-01f, -2.70633787e-01f, -3.06429088e-01f, 2.53284514e-01f, 2.80345023e-01f, -3.04994322e-02f, 1.47683039e-01f, -2.42654294e-01f, 1.20913155e-01f,
  1.77423656e-01f, -2.37356693e-01f, -1.80700459e-02f, 1.92657914e-02f, -2.76076376e-01f, -1.35399178e-01f, -2.08183467e-01f, -7.27354586e-02f, -1.41760707e-01f, 6.61288574e-02f,
  -1.62977025e-01f, 2.56593138e-01f, -9.79386196e-02f, 2.25689024e-01f, 1.17202327e-01f, -1.43575385e-01f, -3.06471740e-03f, 4.60182205e-02f, 1.24034114e-01f, 1.58876982e-02f,
  1.11355476e-01f, -3.98111977e-02f, 1.85618717e-02f, 2.60509434e-03f, 4.70960103e-02f, 1.12840114e-02f, -2.95711868e-02f, 1.26549369e-02f, -2.49424540e-02f, -4.04159762e-02f,
  -4.29537892e-02f, -3.13594826e-02f, 6.39701337e-02f, -1.58228874e-02f, -2.15046126e-02f, -1.45793268e-02f, 8.11230019e-02f, 1.56591740e-02f, 1.17516993e-02f, 2.49817967e-02f,
  3.57981957e-03f, -2.60968488e-02f, -7.18011856e-02f, 1.86683051e-02f, -5.36951050e-02f, 1.54766692e-02f, -5.23748472e-02f, -1.12821609e-02f, 6.72983751e-03f, 1.15356292e-03f,
  5.28981090e-02f, -1.16492473e-02f, 2.91489437e-02f, 1.13729173e-02f, 1.86476577e-02f, -1.36764972e-02f, 3.35905775e-02f, 2.89816987e-02f, -7.87236616e-02f, 4.03221175e-02f,
  -9.22590941e-02f, 3.27433199e-02f, 4.60894108e-02f, -1.68178265e-03f, 2.83300765e-02f, -5.03618130e-03f, -3.28898281e-02f, -1.09433243e-02f, -7.68551305e-02f, 6.38212562e-02f,
  3.82718630e-02f, -2.17840932e-02f, 3.12195625e-02f, -2.70851534e-02f, 1.55771524e-02f, -1.42511341e-03f, -3.19075845e-02f, -6.19288087e-02f, -1.93569977e-02f, -5.08475900e-02f,
  5.28037995e-02f, -1.01714574e-01f, -2.89208405e-02f, 5.20986542e-02f, 4.29206295e-03f, 5.08388579e-02f, -4.77829762e-02f, -1.87395457e-02f, 2.58033983e-02f, 6.27273619e-02f,
  4.99859778e-03f, -5.39987236e-02f, -5.45896403e-02f, -5.71529940e-02f, -1.91977024e-02f, 1.45591460e-02f, 1.61657389e-02f, 1.63822733e-02f, 3.78498323e-02f, 2.17834413e-02f,
  5.29716164e-02f, 4.15278003e-02f, 2.12659147e-02f, 5.76773398e-02f, -5.37714660e-02f, 8.34856555e-03f, -2.11934745e-02f, -7.32791126e-02f, 4.30986471e-02f, -3.30318771e-02f,
  1.31294653e-01f, 4.05108482e-01f, 3.55958790e-01f, 7.49247968e-02f, -9.52646658e-02f, -1.31571308e-01f, -2.12840572e-01f, 1.70123294e-01f, 2.10745990e-01f, -1.05588764e-01f,
  -2.20627367e-01f, 2.87062913e-01f, -5.19080572e-02f, -1.94742978e-01f, -4.25101966e-02f, -3.31880935e-02f, -1.37214214e-01f, -1.06619149e-01f, 1.26556620e-01f, 8.23611468e-02f,
  7.83867687e-02f, -1.86243951e-01f, 6.07577860e-02f, -2.08602473e-02f, -9.29523781e-02f, 1.28908977e-01f, -2.28960216e-01f, 3.64428833e-02f, -1.85112864e-01f, -8.11295807e-02f,
  -5.36485799e-02f, 1.39711455e-01f, 8.05329084e-02f, 1.50895556e-02f, -1.22847352e-02f, -3.50289606e-03f, -8.91472027e-02f, -6.10044152e-02f, 1.78671274e-02f, 4.25343364e-02f,
  -7.43877068e-02f, -5.63961156e-02f, -8.64782743e-03f, 7.20919762e-03f, 4.96138781e-02f, 7.71550555e-03f, -4.45156805e-02f, -5.55761578e-03f, 1.19610682e-01f, 2.30290159e-03f,
  6.71041533e-02f, -2.16758996e-02f, -4.68378067e-02f, -2.33373102e-02f, 4.30624746e-02f, 2.04072054e-02f, 3.98045704e-02f, 4.64664679e-03f, -1.39104817e-02f, 8.37312713e-02f,
  -5.46941496e-02f, 4.60292101e-02f, -3.45987119e-02f, -5.18327728e-02f, 3.26017924e-02f, -5.68954833e-02f, 1.80779048e-03f, -3.30457129e-02f, 5.43498844e-02f, -3.19809802e-02f,
  -5.22976145e-02f, -3.39895370e-03f, -3.43861692e-02f, -9.29033011e-02f, -6.68263063e-02f, 2.47817431e-02f, -2.02565230e-02f, -5.52623384e-02f, 1.45246983e-02f, -7.06589296e-02f,
  -5.85060858e-04f, 7.76082743e-03f, -7.74279237e-03f, -6.51239157e-02f, -3.33778746e-02f, 2.85203625e-02f, -2.05933098e-02f, 4.49602194e-02f, -2.79199257e-02f, -3.06101255e-02f,
  8.14999491e-02f, 1.40832275e-01f, -4.16007638e-02f, 5.62408268e-02f, -3.32665145e-02f, -6.99097812e-02f, 9.86136496e-02f, -4.27663773e-02f, 8.96298513e-02f, -2.40159426e-02f,
  -3.92952003e-02f, 1.22464243e-02f, 7.58892894e-02f, -5.07356003e-02f, 9.07278713e-03f, -1.96601357e-02f, 4.80199931e-03f, -4.90836538e-02f, -6.78719431e-02f, 6.61150925e-03f,
  -1.06399961e-01f, -2.33952347e-02f, 1.10921403e-02f, -5.57342321e-02f, -1.38188124e-01f, -8.19888990e-03f, -1.72452928e-04f, -1.63764935e-02f, -3.32620591e-02f, 1.53949754e-02f,
  -3.21116924e-01f, 3.10651988e-01f, -2.94493511e-02f, -5.39688170e-02f, -2.61167824e-01f, -2.23342106e-01f, -5.17264083e-02f, -1.12841472e-01f, -1.59002930e-01f, 1.80978775e-01f,
  -5.08724637e-02f, 1.50259733e-01f, 1.27353311e-01f, -1.34275854e-01f, -1.51484624e-01f, -4.90677059e-02f, -1.40715361e-01f, -2.35917028e-02f, -1.45180777e-01f, -1.26147181e-01f,
  -1.81824937e-01f, -1.84843749e-01f, -1.17161468e-01f, -2.23216731e-02f, 9.00629535e-03f, -8.84838775e-03f, 1.06437661e-01f, 6.05802238e-02f, 6.28844202e-02f, -6.20981678e-02f,
  4.00404744e-02f, -2.22352240e-02f, 5.13465144e-02f, 7.58574232e-02f, 8.53290036e-02f, 5.16243167e-02f, 9.39617380e-02f, -2.43161656e-02f, -6.13746643e-02f, -6.39823377e-02f,
  1.92640275e-01f, -8.87574330e-02f, -1.68966111e-02f, 2.20166822e-03f, -2.29484290e-02f, -4.05108742e-02f, -8.22630450e-02f, -1.26318112e-02f, -6.23655170e-02f, -1.08911477e-01f,
  -5.16835414e-02f, 2.60867272e-02f, -2.71675922e-02f, 1.97637416e-02f, 1.39250979e-02f, -5.50967157e-02f, -3.17219459e-02f, 9.43184569e-02f, -3.35706212e-02f, -2.26908270e-03f,
  -6.00619428e-03f, 9.98653769e-02f, 1.34467771e-02f, 1.08587816e-02f, -2.60911863e-02f, -4.00135294e-02f, -4.14628498e-02f, 4.93416935e-02f, 5.91047294e-02f, 6.07410334e-02f,
  5.26985899e-03f, 8.51178635e-03f, -5.37910219e-03f, 8.03170074e-03f, 9.81757864e-02f, -3.93113345e-02f, 2.33922638e-02f, 2.20637098e-02f, 5.23830764e-03f, 4.62725349e-02f,
  -1.28301210e-03f, -8.60632285e-02f, 5.91959879e-02f, -5.52172167e-03f, -3.48700620e-02f, 1.10650621e-03f, 5.70399351e-02f, -3.77934650e-02f, -9.68760869e-04f, -5.15948609e-03f,
  3.06372225e-01f, 2.18763679e-01f, 1.26305257e-03f, 3.58709171e-02f, 6.90184757e-02f, 9.82338563e-02f, 1.38682062e-02f, -5.50957061e-02f, 9.33657512e-02f, -6.82161450e-02f,
  3.70033607e-02f, -4.18104278e-03f, 5.30010983e-02f, -1.22713700e-01f, 4.33794893e-02f, 4.83125560e-02f, 5.77877387e-02f, 7.40177333e-02f, 7.20378757e-02f, 6.45011142e-02f,
  9.03468356e-02f, 4.95390631e-02f, 3.91346542e-03f, -6.81497082e-02f, 1.03062382e-02f, 5.93280084e-02f, 5.03451414e-02f, -1.01973079e-01f, -3.96473855e-02f, 8.75405669e-02f,
  -3.67625237e-01f, 3.05209458e-01f, -1.99043408e-01f, 2.31381044e-01f, -1.65230632e-01f, -8.48744903e-03f, 8.79685432e-02f, 1.56152114e-01f, 8.42146724e-02f, 2.82218158e-01f,
  7.83989355e-02f, 3.70331593e-02f, 2.30771050e-01f, 1.94756344e-01f, 2.89077554e-02f, 1.80106178e-01f, 1.52443677e-01f, 1.33014321e-01f, 1.57040402e-01f, 1.95229679e-01f,
  1.95374582e-02f, 2.15540335e-01f, 1.00386664e-01f, 1.84748650e-01f, 2.52687298e-02f, 6.45265207e-02f, -5.78411780e-02f, 6.01664633e-02f, -4.02478054e-02f, 3.89221720e-02f,
  2.50113802e-03f, -2.34068162e-03f, -1.28004789e-01f, -9.55031663e-02f, -2.81904582e-02f, -1.69311807e-01f, 1.52935619e-02f, -9.75347906e-02f, -1.13046035e-01f, -5.29434532e-02f,
  -9.27971676e-02f, -2.47368123e-02f, 2.53957603e-02f, -4.49294336e-02f, -9.55197960e-02f, -4.89004888e-02f, 9.29179543e-04f, 1.22681456e-02f, 2.09997594e-02f, 6.54100021e-03f,
  7.61131793e-02f, -7.24363849e-02f, -4.71114479e-02f, 5.05028181e-02f, -6.30329996e-02f, 1.18588994e-03f, 1.40499920e-02f, -5.95649183e-02f, 4.96335961e-02f, -6.33954480e-02f,
  -1.67686921e-02f, -4.06975634e-02f, 5.52034229e-02f, -5.83965182e-02f, -2.77082752e-02f, -7.27450177e-02f, 1.21378891e-01f, -8.92751478e-03f, -3.50710861e-02f, 1.87277943e-02f,
  4.38115634e-02f, -4.29489277e-02f, 6.38521239e-02f, 1.10567175e-02f, 4.29742737e-03f, -3.87687534e-02f, -6.26790151e-02f, 4.10647430e-02f, 2.57476233e-02f, 2.02122759e-02f,
  1.81337018e-02f, 7.91959316e-02f, 1.26560256e-01f, -3.67999449e-02f, -4.92414786e-03f, 3.01416125e-02f, 4.10404801e-02f, 3.09408102e-02f, -3.50530725e-03f, 2.14160364e-02f,
  1.58808470e-01f, 1.80836707e-01f, 6.69940934e-02f, 9.59799513e-02f, -4.69611771e-02f, -2.57967878e-02f, -3.63302380e-02f, 3.57068889e-02f, 6.47469386e-02f, 7.84012079e-02f,
  -4.68800701e-02f, 1.26984145e-03f, -9.40319076e-02f, -1.19968802e-02f, 8.11416507e-02f, 5.65977581e-02f, 8.34330916e-02f, -6.84769172e-03f, -2.29409672e-02f, 3.27960066e-02f,
  8.73881355e-02f, 8.59662369e-02f, -4.70602326e-03f, -8.75405315e-03f, 7.12018693e-03f, -4.75067310e-02f, -6.92597255e-02f, -6.61083322e-04f, 1.13454936e-02f, -5.54392524e-02f,
  2.58633614e-01f, -2.72836536e-01f, -6.19253749e-03f, -9.45175365e-02f, -1.02375418e-01f, -3.81095022e-01f, -2.99097478e-01f, -2.00865552e-01f, -1.96039408e-01f, -9.40121338e-02f,
  -6.60722032e-02f, 4.74057160e-02f, -1.36360615e-01f, -2.11584017e-01f, 1.75789207e-01f, -2.29043022e-01f, -9.08774361e-02f, -1.19154878e-01f, -6.86785206e-02f, -6.30507544e-02f,
  1.03423987e-02f, -1.83142498e-01f, 1.10156097e-01f, -1.85848475e-02f, 5.23026800e-03f, 1.23448610e-01f, 2.54353672e-01f, 1.07772708e-01f, 1.55077398e-01f, 5.73021956e-02f,
  -1.97174791e-02f, -1.68868661e-01f, 7.23543614e-02f, 8.61871813e-04f, -2.73669418e-02f, -8.86852015e-03f, 5.04295938e-02f, 5.17273694e-02f, -2.93287188e-02f, -8.58327001e-02f,
  3.82195832e-03f, 6.90413341e-02f, -9.32401046e-02f, -4.43259487e-03f, -3.25869620e-02f, 5.21659926e-02f, 2.91331075e-02f, 1.27091026e-02f, 7.46498024e-03f, 3.40979756e-03f,
  1.12926280e-02f, 2.35793218e-02f, -6.68182503e-03f, -3.27448524e-03f, 7.54353255e-02f, 1.62552632e-02f, 5.22330927e-04f, 3.51823084e-02f, 1.94631442e-02f, -4.66526784e-02f,
  -1.51448138e-02f, 3.34536843e-02f, 7.59680755e-03f, 1.54387895e-02f, 2.14736201e-02f, -1.58867780e-02f, 8.73634033e-03f, 5.39121125e-03f, 2.68693436e-02f, 3.62496935e-02f,
  -2.09168885e-02f, -2.60484088e-02f, -5.95223159e-02f, -1.78820435e-02f, -1.19604394e-02f, 1.64362462e-03f, -3.57577242e-02f, 1.09272369e-03f, 3.53880227e-02f, 2.89621055e-02f,
  -2.92605944e-02f, -2.92592254e-02f, -2.72601452e-02f, 4.60688621e-02f, 1.49392467e-02f, 6.56239409e-03f, -2.05741655e-02f, 6.23839051e-02f, -1.02735385e-02f, 4.36549932e-02f,
  -1.11598447e-01f, -8.87840614e-02f, -6.29701689e-02f, -1.66813675e-02f, -5.69173731e-02f, 4.78869528e-02f, -5.18468358e-02f, -3.30944285e-02f, 8.48872215e-03f, 1.95403919e-02f,
  -7.07006603e-02f, -2.58627366e-02f, 8.51127654e-02f, 2.76945140e-02f, 3.67541276e-02f, -3.76548916e-02f, 5.03851771e-02f, -1.09277014e-02f, -2.04800088e-02f, 1.23365242e-02f,
  3.73870097e-02f, -6.51165843e-02f, 7.05665946e-02f, -5.52042127e-02f, -2.15752386e-02f, 7.18338415e-02f, -8.46196711e-03f, 4.59407717e-02f, 5.77305853e-02f, -8.18750914e-03f,
  -2.03102916e-01f, 3.27848405e-01f, -2.04891488e-01f, -1.68095976e-02f, 1.53464958e-01f, 2.06322297e-02f, -1.48814276e-01f, 7.29635134e-02f, -2.06323937e-01f, 1.99014589e-01f,
  7.64366658e-03f, 3.91591564e-02f, -5.66381104e-02f, 2.09498227e-01f, -2.22192742e-02f, -2.38711655e-01f, 4.74076495e-02f, 5.04413545e-02f, -1.63307011e-01f, 2.05515981e-01f,
  -1.42413586e-01f, 2.23365992e-01f, 8.59102234e-03f, 1.97599724e-01f, 1.10411555e-01f, -3.41812475e-03f, 1.14355944e-01f, -4.57884520e-02f, 1.86474636e-01f, 3.70123461e-02f,
  -6.64508119e-02f, -4.58532050e-02f, -1.67891011e-02f, -6.92045987e-02f, 7.20903883e-03f, 9.11794230e-02f, 2.95478795e-02f, -7.31177181e-02f, -8.28881189e-02f, 5.15305204e-03f,
  -1.77581646e-02f, -9.05699804e-02f, -6.23712987e-02f, -1.50071306e-03f, 5.00955172e-02f, -7.15342760e-02f, 2.48585362e-02f, -2.38105119e-03f, -3.79103422e-03f, 2.05743983e-02f,
  -4.44870554e-02f, 6.98834881e-02f, 1.23314466e-02f, 3.10422070e-02f, -2.52401810e-02f, -5.28639965e-02f, 7.16313720e-02f, 4.02149186e-02f, -3.60662350e-03f, -1.85709931e-02f,
  1.85239874e-02f, 4.44047293e-03f, -1.19221583e-02f, 8.90985038e-03f, -7.98896607e-03f, 4.74105477e-02f, -4.28507663e-02f, -1.35232704e-02f, -6.49013668e-02f, 5.62716313e-02f,
  6.68758228e-02f, 2.17792224e-02f, 1.76593789e-03f, 4.29211929e-02f, 5.51979132e-02f, -1.40976887e-02f, -3.97287607e-02f, 2.13802140e-02f, 8.83688778e-03f, -3.78104746e-02f,
  1.04626650e-02f, 5.95345460e-02f, -1.95203573e-02f, -6.72803596e-02f, 2.44435035e-02f, -5.92346415e-02f, -3.51622999e-02f, -6.80436194e-02f, -1.23052085e-02f, 3.92938554e-02f,
  1.68065369e-01f, 2.42288366e-01f, -4.15572450e-02f, 1.17058344e-02f, -2.91620232e-02f, 6.17770292e-02f, -8.06248635e-02f, 6.08419767e-03f, 1.44677050e-02f, -2.09669322e-02f,
  8.25575888e-02f, 1.41774714e-02f, 6.39658570e-02f, 9.30954441e-02f, 3.91854346e-03f, 5.42132482e-02f, -2.16071494e-03f, -2.42049918e-02f, 1.41491130e-01f, -8.16670060e-03f,
  6.57218173e-02f, -1.68737713e-02f, 1.72155984e-02f, 1.18174683e-02f, 9.47425142e-02f, 1.01535670e-01f, 8.13420415e-02f, -3.20872106e-02f, 6.66703507e-02f, 6.98237270e-02f,
  2.43988670e-02f, 8.33130851e-02f, 2.50754178e-01f, -7.77838454e-02f, 2.90950298e-01f, 3.46753933e-02f, 1.30475000e-01f, 1.05604589e-01f, 2.69723296e-01f, -2.36259878e-01f,
  -2.02109292e-01f, 9.02748015e-03f, -1.80753320e-01f, -1.82814047e-01f, -1.89638004e-01f, 1.04918918e-02f, 5.94077408e-02f, 3.22929546e-02f, 2.72582650e-01f, -2.24450305e-02f,
  -2.18150299e-02f, -2.31096387e-01f, -3.02569382e-02f, 3.84287499e-02f, -1.63054522e-02f, 6.58361847e-03f, -2.79473782e-01f, 1.49348632e-01f, -2.26829618e-01f, 8.80483687e-02f,
  1.08015575e-02f, -1.82704721e-02f, -1.24194892e-02f, 3.83954309e-02f, -3.58959883e-02f, -6.22576289e-02f, 4.84409882e-03f, 1.77187428e-01f, 1.14629261e-01f, 7.02688098e-02f,
  1.27353938e-02f, -1.96375754e-02f, 7.57261366e-03f, 2.84842644e-02f, 1.16424009e-01f, 5.87592535e-02f, 8.42614546e-02f, 2.58208532e-02f, 7.68214837e-02f, 9.08575654e-02f,
  1.61248911e-02f, -7.09452375e-04f, -2.83662546e-02f, -1.20380893e-02f, 1.35881198e-03f, 4.17988934e-03f, 4.53862213e-02f, 1.78957283e-02f, -5.21772727e-02f, 3.18051204e-02f,
  1.25229061e-01f, 6.20366484e-02f, -2.18112376e-02f, -2.87880842e-02f, -4.71607111e-02f, -9.51075628e-02f, -6.10233769e-02f, -7.56282285e-02f, -6.79642335e-02f, -5.01478091e-02f,
  -6.14004806e-02f, -1.72830839e-02f, 1.02572598e-01f, 7.99164772e-02f, -3.76972966e-02f, -1.02535367e-01f, -5.20940218e-03f, 1.55792572e-03f, -7.72731453e-02f, -4.37820517e-02f,
  2.25746538e-02f, -2.18938142e-02f, -7.49691278e-02f, 1.08746802e-02f, 1.29971392e-02f, 5.03206700e-02f, -4.83379252e-02f, 4.13967334e-02f, 1.08456258e-02f, -1.91862024e-02f,
  -1.48764968e-01f, -1.10051244e-01f, 6.49826229e-02f, -6.77298009e-02f, -6.77513517e-03f, -2.30148248e-02f, 5.46291359e-02f, -1.22246603e-02f, -3.99103435e-03f, -7.08823130e-02f,
  -4.86607850e-02f, -6.44359887e-02f, -5.60401641e-02f, 1.02107912e-01f, -3.92907858e-02f, -1.01587594e-01f, -5.00883348e-02f, -1.03097633e-02f, -7.83256218e-02f, 8.17559566e-03f,
  -1.27202541e-01f, 1.67777447e-03f, -6.73074350e-02f, -5.63624837e-02f, 3.36982496e-02f, -5.89925982e-02f, -1.59857627e-02f, 8.86190832e-02f, 3.39921974e-02f, 1.34901656e-03f,
  -3.15479398e-01f, -8.93215125e-04f, 1.45080760e-02f, -2.57833362e-01f, 4.98050712e-02f, -1.50672048e-01f, -2.61962205e-01f, -2.05801316e-02f, -1.74955055e-01f, 5.80299757e-02f,
  -1.27552912e-01f, 1.80768743e-02f, -1.41237736e-01f, -3.11845243e-01f, -3.72806877e-01f, -1.10593095e-01f, -2.90787876e-01f, -8.34712684e-02f, -9.54712108e-02f, -4.61049117e-02f,
  -1.44698665e-01f, -1.67813435e-01f, -1.20478407e-01f, 1.59948155e-01f, -8.93220007e-02f, 2.16979817e-01f, 1.68891922e-01f, 1.46162167e-01f, 7.77495727e-02f, -4.52777445e-02f,
  -3.86495590e-02f, -4.96640727e-02f, -1.72912497e-02f, 9.47285630e-03f, -2.56578121e-02f, 7.82529935e-02f, 1.39357997e-02f, -8.13939329e-03f, 7.32144564e-02f, 4.40585762e-02f,
  6.19324483e-03f, -1.89597008e-03f, -5.52585311e-02f, 2.61170752e-02f, -4.06212686e-03f, -6.63277060e-02f, 2.98866201e-02f, 5.24484552e-02f, -1.93560924e-02f, -2.91182436e-02f,
  -5.08295186e-02f, 6.45517409e-02f, -1.33197568e-02f, 9.37797725e-02f, 3.74519825e-02f, -5.50209545e-02f, -1.92751922e-02f, 1.05520450e-01f, 7.95436725e-02f, 6.68134019e-02f,
  2.36608312e-02f, 5.22617251e-02f, -3.73462550e-02f, 2.10723411e-02f, -4.16754521e-02f, -1.47238784e-02f, -2.19410605e-04f, 4.67974599e-03f, 4.37424481e-02f, -5.54241054e-02f,
  -1.65012907e-02f, 8.38457234e-03f, -6.43790737e-02f, 1.49550140e-02f, 3.01563106e-02f, -1.21313874e-02f, 3.77348699e-02f, 5.19897267e-02f, 9.68987122e-03f, 1.09412065e-02f,
  -2.00295318e-02f, 8.95287097e-03f, 7.90788084e-02f, 2.75376048e-02f, -1.06023930e-01f, 3.28381658e-02f, 2.59272102e-02f, 2.81553306e-02f, 2.75627337e-02f, 2.97373217e-02f,
  1.00503373e-03f, -1.85357817e-02f, 5.56054562e-02f, 1.16925929e-02f, 3.41669060e-02f, -1.00392848e-02f, -7.72180930e-02f, 4.76811863e-02f, -9.78948921e-02f, -7.77944624e-02f,
  5.13175055e-02f, 5.93146263e-03f, 1.51944831e-01f, 2.54166387e-02f, 6.60378337e-02f, -4.06100824e-02f, -3.25919315e-02f, 1.06029876e-01f, 7.62295574e-02f, 3.64897102e-02f,
  4.62315194e-02f, -9.29527357e-03f, -3.65179926e-02f, 3.16245034e-02f, 6.96910620e-02f, 6.73858076e-02f, 1.22379221e-01f, -4.21515200e-03f, 2.10441351e-02f, -2.09227111e-02f,
  -3.34536105e-01f, 2.80847609e-01f, -2.44299471e-02f, -1.34419471e-01f, -2.60933131e-01f, 3.64488453e-01f, -3.04163732e-02f, 3.40388753e-02f, 7.34674186e-02f, 2.85406947e-01f,
  -7.67106842e-03f, 1.00026377e-01f, 5.22607602e-02f, 1.23539723e-01f, -1.73857853e-01f, 1.22340076e-01f, 5.50071001e-02f, 6.72253594e-02f, -6.00315481e-02f, -7.97526911e-02f,
  -1.41450286e-01f, -4.93646674e-02f, -1.05114639e-01f, -7.25802258e-02f, 1.22285364e-02f, -5.86072206e-02f, -5.58789447e-02f, -1.82580296e-02f, 8.26843157e-02f, 1.04994543e-01f,
  -1.11331493e-01f, -2.52470315e-01f, 1.62849873e-02f, 6.58531636e-02f, -7.99500346e-02f, 3.08643183e-04f, -1.02392100e-02f, -4.63421904e-02f, -7.12825432e-02f, 1.32031767e-02f,
  2.68280338e-02f, -2.17096023e-02f, -7.76049914e-03f, 2.47919075e-02f, 8.57610628e-02f, 2.65781265e-02f, -1.61541815e-04f, 1.00492187e-01f, 3.42602804e-02f, 2.96704322e-02f,
  4.01659831e-02f, 3.00385039e-02f, 8.32998902e-02f, 6.53423592e-02f, 2.67399438e-02f, 3.78732122e-02f, -7.62982145e-02f, 4.40723673e-02f, 8.20398480e-02f, -8.27195868e-03f,
  -8.19556862e-02f, -1.60353966e-02f, -5.38981035e-02f, 8.12059194e-02f, -8.31785984e-03f, 2.84290314e-02f, 3.85448486e-02f, -7.47581199e-02f, 7.53312781e-02f, 1.43882716e-02f,
  4.73874016e-03f, 1.75959859e-02f, -5.08272685e-02f, 5.51493689e-02f, -5.69742844e-02f, -3.14282849e-02f, -6.39908090e-02f, -4.14782390e-02f, 9.00682807e-03f, -8.73582810e-03f,
  -2.03125607e-02f, 1.72753464e-02f, -2.62912475e-02f, -3.73900309e-02f, 5.19771017e-02f, -1.50240809e-02f, 6.50024936e-02f, 1.04087636e-01f, -4.40661199e-02f, -2.15728059e-02f,
  -1.15947239e-02f, -7.14170188e-02f, -8.06683749e-02f, -1.42240562e-02f, 5.93049712e-02f, 4.89394404e-02f, 3.78643302e-03f, 4.67614755e-02f, 1.05190299e-01f, -2.85644587e-02f,
  -4.98162061e-02f, -7.94555619e-02f, 1.23390257e-02f, 4.45379727e-02f, 3.36579718e-02f, -3.13400589e-02f, -2.90998556e-02f, -8.51092115e-03f, 7.72190699e-03f, 2.77806744e-02f,
  2.50509232e-02f, -1.18817605e-01f, -3.48593183e-02f, -6.42580241e-02f, -3.62446420e-02f, -5.24362456e-03f, -5.83732128e-02f, -1.82395224e-02f, -4.37108502e-02f, 7.58893639e-02f,
  -1.28295145e-03f, 6.99669197e-02f, 2.82970846e-01f, -1.35323526e-02f, -2.32672438e-01f, 1.87008843e-01f, 2.86786586e-01f, -7.90341944e-02f, -1.40191033e-01f, -8.31983835e-02f,
  1.94925014e-02f, -1.94853202e-01f, 1.61429062e-01f, 1.74861372e-01f, 1.33761346e-01f, 2.75072724e-01f, 1.12798519e-01f, -1.86383948e-02f, -1.44407570e-01f, -4.86525930e-02f,
  4.77095842e-02f, -1.53874755e-01f, 3.67760926e-01f, -2.41957292e-01f, -2.43054684e-02f, 6.18317211e-03f, -1.19659573e-01f, 4.83388975e-02f, -1.03634506e-01f, -7.28686601e-02f,
  1.38724148e-01f, 3.17258351e-02f, 5.55897504e-02f, 1.50147351e-02f, 1.35205574e-02f, 9.15956870e-02f, -1.63395926e-02f, 4.99739610e-02f, -3.09074372e-02f, 5.08806761e-03f,
  1.64028760e-02f, -1.29265696e-01f, -7.05599636e-02f, 2.40587872e-02f, -4.91015427e-02f, -1.28328353e-02f, 5.05021475e-02f, 8.15402269e-02f, -7.69166648e-02f, 1.98248029e-02f,
  1.25869066e-01f, 9.90990922e-02f, 8.02459717e-02f, -7.97900930e-02f, -3.14167179e-02f, -4.36949022e-02f, 1.47552222e-01f, 9.02665034e-02f, 2.76938383e-03f, -7.10823610e-02f,
  -6.08767122e-02f, -2.26575285e-02f, 4.47855256e-02f, -4.46430631e-02f, -2.36952715e-02f, -1.87833216e-02f, 3.94574888e-02f, 3.04768626e-02f, -6.25100285e-02f, 1.83227356e-04f,
  -1.78645123e-02f, -8.10246263e-03f, -5.97990975e-02f, 2.26618722e-02f, -1.42395904e-03f, 1.11558046e-02f, -1.46708009e-03f, -6.82204068e-02f, 5.23269363e-02f, -3.47944302e-03f,
  -5.53863905e-02f, -1.62305124e-02f, 1.29547929e-02f, 1.43617183e-01f, 2.98040230e-02f, -5.77550083e-02f, -5.43601923e-02f, 2.95892674e-02f, 3.03271059e-02f, 3.87697318e-03f,
  -2.85633616e-02f, -2.33601391e-01f, -1.48562687e-02f, -1.07800387e-01f, -4.91502658e-02f, -3.70399072e-03f, 6.71398118e-02f, 1.90288387e-02f, -4.16888595e-02f, 9.87550616e-03f,
  -7.11945072e-02f, 4.54333872e-02f, -6.07640967e-02f, -9.76431593e-02f, 2.38539819e-02f, 3.07457428e-02f, 4.96411361e-02f, -7.68686160e-02f, -5.90521507e-02f, -4.15743068e-02f,
  -3.96522507e-02f, -1.67455859e-02f, -6.15791641e-02f, 4.40262305e-03f, -2.52017602e-02f, 1.68277081e-02f, -1.21952079e-01f, -5.95675409e-02f, -5.40545397e-02f, 6.74852431e-02f,
  2.49109954e-01f, -1.05821723e-02f, -4.80239615e-02f, 2.10392773e-01f, -9.71011892e-02f, 3.11389506e-01f, 2.69523829e-01f, -4.77215089e-02f, 1.67049635e-02f, 4.20250930e-02f,
  1.38436288e-01f, -4.67577986e-02f, 7.64722973e-02f, 1.11578144e-01f, 1.36323854e-01f, 9.18578804e-02f, 2.84158051e-01f, 1.24469347e-01f, -8.96514431e-02f, 1.04357846e-01f,
  6.88743144e-02f, 1.80622756e-01f, 1.19822033e-01f, -3.43181118e-02f, 2.35840492e-02f, 4.80668247e-02f, 2.83427499e-02f, -7.49288127e-02f, 9.44215655e-02f, -3.38161066e-02f,
  5.19082136e-03f, -1.36904538e-01f, -1.27951503e-01f, -8.32514316e-02f, 1.13275550e-01f, -1.08394166e-02f, 7.99536780e-02f, 2.90096123e-02f, -6.76714927e-02f, -4.88289818e-03f,
  -1.93042178e-02f, -3.14965695e-02f, 2.19410914e-03f, -9.99003556e-03f, 1.54461218e-02f, -1.20678134e-01f, -9.66117159e-02f, -1.84776559e-02f, -7.53088593e-02f, -6.57436578e-03f,
  -2.73857638e-02f, 4.17200550e-02f, 4.70147170e-02f, -1.42863905e-03f, -2.63144728e-02f, 4.37758677e-02f, -8.90550949e-03f, -8.52214172e-03f, 3.84414122e-02f, 3.92216891e-02f,
  7.42731541e-02f, 7.39553049e-02f, 3.04742949e-03f, -2.03699572e-03f, 2.12029535e-02f, -3.49502638e-02f, -6.47635162e-02f, -1.30597176e-02f, -1.92171726e-02f, 3.06925420e-02f,
  5.88622876e-02f, -9.66653228e-03f, 1.28237240e-03f, -3.31629403e-02f, 8.19051117e-02f, -8.98378436e-03f, 1.14502488e-02f, -1.24239400e-02f, 6.14385568e-02f, -9.33244079e-03f,
  2.11505573e-02f, -1.28101623e-02f, 4.89688925e-02f, 2.94911265e-02f, 3.56383584e-02f, -2.66154902e-03f, 1.45853672e-03f, 3.36829461e-02f, -3.84241119e-02f, 5.74716777e-02f,
  1.22713178e-01f, 1.30104557e-01f, 4.34431098e-02f, 3.06910798e-02f, -7.53570944e-02f, 4.11122069e-02f, 4.61704656e-02f, -2.34096888e-02f, 3.35317366e-02f, 1.02548487e-01f,
  8.62793438e-03f, 1.92221124e-02f, 1.18721582e-01f, -3.37925702e-02f, -2.00666487e-02f, 8.97329450e-02f, 6.54427055e-03f, -1.99672468e-02f, 5.85753731e-02f, 7.96722900e-03f,
  1.38080644e-03f, -6.96068490e-03f, -4.03382480e-02f, 5.20104393e-02f, -1.43263303e-02f, -1.95032898e-02f, 1.49738630e-02f, -7.89790042e-03f, 5.49584329e-02f, -3.72180864e-02f,
  -6.89514577e-02f, -2.16396078e-01f, -2.01874793e-01f, 1.62741497e-01f, -8.47444236e-02f, 4.34592962e-02f, 1.92987069e-01f, -7.46523216e-02f, 1.97207242e-01f, 1.10986002e-01f,
  1.34252906e-01f, -1.61410391e-01f, 8.46836269e-02f, 3.26827243e-02f, 1.64786682e-01f, 6.35158271e-02f, 2.43305579e-01f, -5.84409423e-02f, -2.15088334e-02f, -7.98056871e-02f,
  -3.67448218e-02f, 1.07742497e-03f, 2.02744957e-02f, -1.24702096e-01f, -1.24498092e-01f, -4.48210351e-02f, 2.76548028e-01f, -5.87590262e-02f, 1.44572049e-01f, -1.63304672e-01f,
  -1.62002817e-01f, -1.89985126e-01f, -8.00523832e-02f, -8.64785984e-02f, 8.42577145e-02f, 5.91378659e-02f, 2.59547611e-03f, -3.51032242e-02f, -8.47635195e-02f, -3.47045325e-02f,
  1.32761281e-02f, -1.67405814e-01f, 4.72542178e-03f, 4.95611690e-02f, -3.63839529e-02f, -1.07097119e-01f, -1.30560556e-02f, -4.48332448e-03f, 1.32701658e-02f, -5.51223084e-02f,
  -1.88691430e-02f, -7.98120275e-02f, 5.64529821e-02f, 3.52870789e-04f, -4.57152277e-02f, -4.81597334e-03f, 3.60539667e-02f, 6.33948250e-03f, -1.00197673e-01f, -1.30049745e-02f,
  4.71223481e-02f, 7.24932104e-02f, -1.34780966e-02f, -3.54254507e-02f, 5.91158047e-02f, -2.08788225e-03f, 5.75366989e-02f, -1.00645004e-02f, 6.59121051e-02f, -3.78342136e-03f,
  8.83594081e-02f, 1.89682301e-02f, 1.38244610e-02f, 5.94398640e-02f, 5.19447289e-02f, 4.37974110e-02f, 5.49076125e-02f, -6.03581332e-02f, 4.54110652e-02f, 7.14650471e-03f,
  -2.06546448e-02f, 1.88947730e-02f, 4.85785864e-02f, 4.66461703e-02f, -1.41761107e-02f, -1.82325374e-02f, 2.26615742e-02f, -3.33488099e-02f, 5.14999777e-02f, -3.19756195e-02f,
  -4.88770790e-02f, 5.62136509e-02f, -2.70632170e-02f, 4.61509917e-03f, 3.10705206e-03f, 1.55751863e-02f, 1.66858789e-02f, -7.56838266e-03f, 1.24901384e-02f, 9.74114239e-02f,
  1.12612275e-02f, 5.41057587e-02f, 2.98102666e-02f, -1.64555777e-02f, -3.14571224e-02f, 1.22596644e-01f, 2.84520406e-02f, 3.97160724e-02f, 1.00337856e-01f, -2.76941732e-02f,
  4.77142669e-02f, 1.28155602e-02f, -9.03857350e-02f, 1.86129287e-02f, 3.42175700e-02f, 3.91338579e-02f, 2.27998625e-02f, 3.13593000e-02f, 5.37447864e-03f, 5.88735752e-02f,
  -2.29909822e-01f, -3.03466171e-01f, -3.81742045e-02f, -2.23141253e-01f, -8.91372561e-02f, 7.01504052e-02f, 4.47263196e-02f, -9.86649394e-02f, -1.30490988e-01f, -1.16800912e-01f,
  5.44048846e-02f, -1.28390282e-01f, 1.44504815e-01f, -1.33124158e-01f, 1.08592458e-01f, 2.93291539e-01f, -3.67667556e-01f, -1.43790707e-01f, 1.00068115e-01f, -2.22428307e-01f,
  -7.92159175e-04f, -1.60924688e-01f, 1.09751754e-01f, -1.83626369e-01f, -4.53774408e-02f, 3.16083170e-02f, -8.33107531e-02f, 8.36359859e-02f, -9.08227935e-02f, -1.37640722e-02f,
  9.35874283e-02f, -9.97497421e-03f, -5.71363853e-05f, 6.53742105e-02f, -5.88561296e-02f, -2.01369822e-02f, -4.10056151e-02f, 9.90014523e-02f, -2.05309894e-02f, -2.16614436e-02f,
  5.83203621e-02f, 6.57042563e-02f, -6.05897605e-02f, -3.00040748e-02f, -4.76550050e-02f, -4.90112789e-02f, 8.46522897e-02f, -1.68210715e-02f, -2.71867495e-02f, 4.63233851e-02f,
  6.34992030e-03f, 3.90428379e-02f, -1.32448571e-02f, -9.12096649e-02f, 6.04950963e-03f, -2.40724031e-02f, 3.74155305e-02f, 7.50101209e-02f, 8.70317817e-02f, -4.94708642e-02f,
  -4.92524095e-02f, -3.52288932e-02f, 5.00648702e-03f, 6.52156621e-02f, -1.28887389e-02f, 2.94494331e-02f, -2.78967805e-02f, -2.14761756e-02f, -2.20878571e-02f, 8.70033051e-04f,
  -5.33802360e-02f, -1.32514751e-02f, -2.34481320e-02f, 4.51587588e-02f, -5.10921218e-02f, -4.09688288e-03f, 2.77846027e-02f, 3.96918990e-02f, -7.60119483e-02f, 3.68827209e-02f,
  9.15574431e-02f, -4.34896126e-02f, 8.65461230e-02f, -3.05835884e-02f, -3.15437131e-02f, 2.94697713e-02f, 3.38719524e-02f, 7.19584990e-03f, 4.73388024e-02f, 1.67881809e-02f,
  -3.47037278e-02f, -1.57202452e-01f, -3.24727595e-02f, -8.16873088e-02f, -5.15998267e-02f, -2.60785650e-02f, -7.14616477e-02f, -6.28848001e-02f, -4.74541448e-03f, 3.75152100e-03f,
  -2.88816821e-02f, -8.32819343e-02f, 1.35708286e-03f, -1.12385498e-02f, -6.81162020e-03f, 3.20758969e-02f, 2.36309581e-02f, 7.03036413e-03f, -3.41621637e-02f, -9.91254812e-04f,
  6.06990559e-03f, -3.19882892e-02f, 1.86881348e-02f, 9.09407157e-03f, -5.49206622e-02f, 1.79705843e-02f, -7.25401118e-02f, 2.03824639e-02f, 6.98638260e-02f, -4.38039452e-02f,
  1.89592227e-01f, -1.20741002e-01f, 3.18785906e-01f, 6.46942034e-02f, 7.54248276e-02f, -1.85677987e-02f, 1.01526387e-01f, 5.40778448e-04f, 3.21201563e-01f, -2.28706941e-01f,
  -2.12943628e-01f, 2.07123265e-01f, 9.63465422e-02f, -2.07360670e-01f, 1.84941128e-01f, 1.36576489e-01f, -1.27350301e-01f, -3.00779231e-02f, 1.66144535e-01f, -8.36741179e-02f,
  -7.17139570e-03f, -1.96697757e-01f, 7.59191439e-02f, -2.56351769e-01f, -7.92789236e-02f, -1.05931297e-01f, -3.45758855e-01f, 1.00296892e-01f, -3.79148304e-01f, 4.49813269e-02f,
  -1.57769155e-02f, -3.13101895e-02f, 1.39609408e-02f, -2.30946001e-02f, -8.38820189e-02f, 1.62039045e-02f, 6.84682056e-02f, 1.11485049e-01f, -3.02155241e-02f, -5.07755205e-02f,
  2.92800236e-02f, -6.45782391e-04f, -2.51945909e-02f, -1.70639269e-02f, 1.32106200e-01f, -6.46402314e-02f, 3.15157846e-02f, -5.82051203e-02f, 8.03704932e-02f, 7.81085296e-03f,
  9.49428454e-02f, 5.34183122e-02f, -1.22616589e-02f, -3.14109437e-02f, 3.62758897e-02f, 6.12646248e-03f, -1.80212129e-02f, -1.63646583e-02f, -1.01276569e-03f, 1.11940829e-02f,
  1.17195211e-01f, 1.11258745e-01f, 1.42668197e-02f, -2.08407827e-02f, -4.85774577e-02f, 2.67949272e-02f, -6.04371801e-02f, -6.00577481e-02f, 1.92360580e-02f, -9.27494764e-02f,
  -6.03668205e-02f, 1.67325195e-02f, 1.65529363e-02f, 3.02827754e-03f, -7.64360093e-03f, -1.25119770e-02f, -1.02175735e-02f, -7.10403770e-02f, -8.32514372e-03f, 5.71100451e-02f,
  1.09741680e-01f, 4.12184261e-02f, -3.92810255e-02f, -1.55058270e-02f, -1.05364444e-02f, 4.26507592e-02f, -2.41788533e-02f, 1.93640534e-02f, -6.72088983e-03f, -5.04149199e-02f,
  -2.24692136e-01f, -5.54947630e-02f, -9.12780017e-02f, -1.36047363e-01f, -5.57796471e-02f, -6.31574914e-02f, 1.32129183e-02f, -8.54630694e-02f, 8.36118236e-02f, 1.52316066e-02f,
  -6.16611820e-03f, -7.86226988e-02f, -2.24224497e-02f, 7.36318305e-02f, 8.90684053e-02f, -2.37993784e-02f, -3.09457649e-02f, -4.36363816e-02f, -1.35094658e-01f, -6.60387278e-02f,
  -1.61634475e-01f, -4.57215589e-03f, 6.61406517e-02f, 1.18036196e-02f, -7.07996413e-02f, -9.53371972e-02f, -3.79549377e-02f, 7.05410093e-02f, -3.61701697e-02f, 1.65937177e-03f,
  -4.29440558e-01f, 3.07422310e-01f, -1.51924193e-01f, 5.31916171e-02f, -9.76071283e-02f, 9.48370919e-02f, 7.29460968e-03f, -1.31879821e-01f, -1.84988052e-01f, 2.40086332e-01f,
  -1.78106666e-01f, 3.64190899e-02f, -4.07368690e-02f, -8.18504859e-03f, -3.97207022e-01f, 1.13393337e-01f, -8.16793442e-02f, 1.32054202e-02f, -3.56333330e-02f, -1.92635715e-01f,
  -7.94566721e-02f, -9.81538519e-02f, -2.29264289e-01f, -1.10206388e-01f, -1.28849044e-01f, 8.57785053e-05f, -3.84259708e-02f, -4.24749292e-02f, -5.55210821e-02f, -1.09655790e-01f,
  5.67595884e-02f, 7.40575194e-02f, -6.61649108e-02f, -8.32130313e-02f, -3.48596461e-02f, 1.61264412e-04f, 5.40842069e-03f, 1.24268711e-03f, 4.16708998e-02f, -2.58472748e-02f,
  3.56471986e-02f, -5.53015992e-02f, -5.40502667e-02f, -2.82810628e-02f, -2.90575046e-02f, 2.90874820e-02f, 2.12171990e-02f, -7.62245208e-02f, 7.71972239e-02f, 1.05348472e-02f,
  -1.94731895e-02f, 4.30912292e-03f, -2.40839384e-02f, 6.66867942e-03f, -9.36844572e-02f, -4.08985019e-02f, 8.76062885e-02f, 3.93654481e-02f, 2.95749344e-02f, -2.33272109e-02f,
  -9.40319989e-03f, 3.99390683e-02f, 3.42711397e-02f, 4.82308492e-02f, 7.91595317e-03f, -1.61596127e-02f, 4.02358398e-02f, 1.41354334e-02f, -2.36169789e-02f, 3.89675014e-02f,
  -2.74277758e-03f, 3.96849774e-03f, -1.81483272e-02f, -5.57955466e-02f, 6.32746071e-02f, 4.30123284e-02f, 4.32878174e-02f, 1.79446694e-02f, -4.37511830e-03f, -1.36048272e-02f,
  -1.60368700e-02f, -1.06472589e-01f, 3.05239409e-02f, 3.41887213e-02f, -2.20444500e-02f, -1.03104517e-01f, -4.90633920e-02f, -2.47485517e-03f, 9.81178507e-03f, 3.66030335e-02f,
  1.19696639e-01f, -1.31382709e-02f, -2.84725688e-02f, 5.86599484e-02f, -6.07766099e-02f, -7.26319775e-02f, -1.12485318e-02f, -6.90644756e-02f, -2.98792366e-02f, -5.25484420e-02f,
  -1.44116941e-03f, 3.73214483e-02f, 7.06677660e-02f, -7.25308955e-02f, -4.75627296e-02f, 5.22303991e-02f, 3.81697640e-02f, -2.31400505e-02f, -7.23298788e-02f, -9.06153768e-03f,
  -2.87466701e-02f, 4.80078869e-02f, 1.82777718e-02f, -1.97027866e-02f, -2.96050347e-02f, 5.51330950e-03f, 2.84099597e-02f, 6.91982806e-02f, 6.31857216e-02f, -8.12816843e-02f,
  2.84969002e-01f, -2.19765808e-02f, -1.01770200e-01f, 2.99045891e-01f, -2.99966913e-02f, 2.41638497e-01f, 2.95670182e-01f, -1.31833240e-01f, 2.10526735e-01f, 2.05147400e-01f,
  2.87471920e-01f, -6.17085360e-02f, 3.21537368e-02f, 4.29144442e-01f, 1.00082375e-01f, 1.32648200e-01f, 3.01123708e-01f, 2.39238620e-01f, 1.61224715e-02f, -8.66471678e-02f,
  -3.96774784e-02f, 8.61844718e-02f, 2.71570869e-02f, -2.62788147e-01f, 1.86836451e-01f, -3.07687134e-01f, -1.20609678e-01f, -1.49427265e-01f, 2.04878114e-02f, -4.08450253e-02f,
  1.47040159e-01f, 2.63974462e-02f, 5.01184538e-02f, -2.79029366e-02f, -1.59363225e-02f, -4.25148010e-02f, -7.71689191e-02f, -2.85505578e-02f, 1.28267733e-02f, -7.61279371e-04f,
  4.10209969e-03f, -3.94756645e-02f, -8.28129426e-02f, -6.41077815e-04f, 2.16754014e-03f, -2.27046665e-02f, 3.58688533e-02f, 1.29778937e-01f, 2.60957330e-02f, 2.98538767e-02f,
  5.80184199e-02f, -1.67212673e-02f, -1.85592473e-03f, -6.73028752e-02f, -9.04521346e-03f, 1.02825311e-03f, 3.09948325e-02f, -3.13132405e-02f, -2.54763886e-02f, 4.27528517e-03f,
  -6.71740174e-02f, -4.97988053e-02f, -6.35241941e-02f, 2.18064860e-02f, -2.28485465e-02f, 3.70665528e-02f, 6.76966980e-02f, 2.33222661e-03f, -3.29988077e-02f, 3.19346413e-02f,
  3.85273509e-02f, -5.25699463e-03f, 1.27343666e-02f, -6.55304082e-03f, 3.03035020e-03f, 8.84384140e-02f, -4.35506552e-02f, -2.36597639e-02f, 5.29308803e-02f, 9.67773497e-02f,
  1.00016281e-01f, -4.40430967e-03f, 5.88755216e-03f, 1.41097996e-02f, 1.37325795e-02f, -7.00736418e-02f, 3.58814094e-03f, 3.57115343e-02f, -3.32990699e-02f, -3.81916924e-03f,
  -4.51921858e-02f, -2.25472316e-01f, -2.64490098e-02f, 6.93919957e-02f, 5.80601022e-02f, 4.44154516e-02f, 7.68370405e-02f, -3.07064001e-02f, -1.10711396e-01f, -5.52098155e-02f,
  -7.98467621e-02f, -2.48475820e-02f, -2.90568713e-02f, -2.69664899e-02f, 6.84851920e-03f, -2.04001972e-03f, -3.07063404e-02f, -4.34050858e-02f, -4.71868552e-02f, -2.07051560e-02f,
  -1.01093613e-01f, 1.13027608e-02f, 2.38844957e-02f, -3.31825763e-02f, 4.64221910e-02f, 3.42127904e-02f, -4.50545885e-02f, -4.49076248e-03f, 3.56811285e-02f, -4.93738661e-03f,
  -2.08317429e-01f, 4.43918398e-03f, 1.63137898e-01f, -1.22976482e-01f, -4.53696214e-02f, 5.40655479e-02f, 1.88054696e-01f, -2.24901021e-01f, -1.11998059e-01f, 7.96173811e-02f,
  -2.18659833e-01f, 1.57528490e-01f, 7.47257173e-02f, -2.25339457e-01f, -3.85642529e-01f, -5.88248819e-02f, -1.71122447e-01f, -1.17301911e-01f, -9.42582190e-02f, -9.64083672e-02f,
  -1.22252889e-01f, -2.33847409e-01f, 7.55654871e-02f, -8.65740553e-02f, 1.02792434e-01f, 8.63615498e-02f, -2.47026738e-02f, 1.41780987e-01f, -1.07843792e-02f, 7.43248314e-02f,
  -1.23454452e-01f, -1.64266437e-01f, 1.24356851e-01f, -5.96203096e-02f, 4.51515093e-02f, -6.14110334e-03f, 1.34821430e-01f, 1.04146041e-02f, -2.19055451e-03f, 1.66821238e-02f,
  7.76946843e-02f, -1.31492037e-02f, 2.08753478e-02f, 1.15583055e-02f, 1.98141392e-03f, -2.75453683e-02f, -2.55257655e-02f, 7.13470280e-02f, 2.15698890e-02f, 2.98102740e-02f,
  5.03520034e-02f, 1.40174879e-02f, 8.19862559e-02f, 1.42927552e-02f, -1.35782827e-02f, -2.72869505e-03f, 3.19199264e-02f, 1.82433411e-01f, -4.52378131e-02f, 2.78637949e-02f,
  3.14113498e-02f, 2.93946620e-02f, -3.45235579e-02f, -9.29046348e-02f, -4.47869748e-02f, -2.75609642e-02f, 2.56458391e-02f, -9.19818785e-03f, 5.42990416e-02f, -5.71120717e-02f,
  -5.63848652e-02f, -1.22819154e-03f, -4.08620425e-02f, -2.55888905e-02f, 7.47302100e-02f, -4.29076254e-02f, 5.56318425e-02f, 2.09970046e-02f, 6.25903681e-02f, -1.02485843e-01f,
  2.94288024e-02f, -1.59427002e-02f, 7.40993023e-02f, 4.70364206e-02f, -7.28747770e-02f, 1.08634040e-01f, 8.02994240e-03f, 3.96478362e-02f, 4.10880242e-03f, -2.50014514e-02f,
  -2.83620991e-02f, -1.01798534e-01f, -2.61972118e-02f, -1.85401011e-02f, -1.89722423e-02f, 1.93907320e-02f, 4.91329143e-03f, -1.66252330e-02f, -3.32733653e-02f, -4.70027626e-02f,
  1.83770731e-02f, 1.46027673e-02f, 1.59275718e-02f, -1.47926081e-02f, 3.24350819e-02f, -1.10236565e-02f, 2.58588362e-02f, 6.62210509e-02f, -1.83361806e-02f, -5.53041734e-02f,
  -4.65947064e-03f, 2.73200069e-02f, 2.42297184e-02f, -3.49798612e-02f, -7.56885344e-03f, 3.42919789e-02f, -4.38942239e-02f, 6.37171492e-02f, 1.97849516e-02f, 8.09726790e-02f,
  -2.20000669e-01f, 1.10329218e-01f, 1.76951792e-02f, -2.54074149e-02f, -2.28773635e-02f, -1.35361403e-01f, -2.01713800e-01f, 1.49292856e-01f, -3.06429952e-01f, 1.62804723e-01f,
  2.04184026e-01f, 5.29506430e-02f, -1.85565813e-03f, 2.46683463e-01f, -3.33728880e-01f, -1.08095042e-01f, 7.50344247e-02f, 2.25748084e-02f, -2.57473420e-02f, 1.10120565e-01f,
  -2.54123360e-02f, 2.46623293e-01f, 9.13830101e-02f, 1.48970246e-01f, 1.60544872e-01f, 6.47662506e-02f, 1.12608299e-01f, -3.33675579e-03f, 2.42356524e-01f, 8.87382329e-02f,
  1.57494359e-02f, 8.08290988e-02f, 7.49417692e-02f, -8.29833522e-02f, -3.21829021e-02f, 1.21551417e-02f, 3.33001614e-02f, 2.34286953e-02f, -2.74256840e-02f, -1.09184338e-02f,
  -5.16322330e-02f, -4.87250788e-03f, -6.63058981e-02f, -3.43996622e-02f, 3.79415229e-02f, -2.19807960e-02f, -3.92094105e-02f, 2.31646448e-02f, -2.99236574e-03f, 4.48551327e-02f,
  -4.39981036e-02f, -1.20658604e-02f, -3.78131270e-02f, -7.18480572e-02f, -3.07850796e-03f, -1.85217732e-03f, -1.09689526e-01f, -1.09240981e-02f, -7.83505291e-02f, -6.87088221e-02f,
  1.63948033e-02f, -4.51287553e-02f, 4.73175608e-02f, 8.98581445e-02f, 1.08718900e-02f, 1.12055376e-01f, 5.45737008e-03f, 5.92948273e-02f, -1.17054675e-02f, 3.28521989e-02f,
  3.60575728e-02f, 2.89502982e-02f, 3.27069536e-02f, -3.61915096e-03f, 3.47887166e-02f, 2.81628929e-02f, 4.16146033e-03f, 2.71500722e-02f, -4.20572869e-02f, 1.55018447e-02f,
  6.93714246e-03f, -2.21153125e-02f, -7.68837333e-03f, -4.04788144e-02f, 1.56367943e-03f, -4.62501757e-02f, 4.86959442e-02f, 1.36192907e-02f, -1.33852391e-02f, -1.36028146e-02f,
  -8.79165009e-02f, -4.56901863e-02f, -6.10889420e-02f, 1.02115013e-01f, -7.31017254e-03f, 1.03838369e-01f, -5.03072962e-02f, 1.21853054e-02f, -3.59956138e-02f, 4.61585484e-02f,
  6.65528998e-02f, 8.74362513e-02f, -3.04953977e-02f, 2.19228007e-02f, -6.31953701e-02f, -4.85969260e-02f, 2.03729048e-02f, 3.63595900e-05f, -1.03665525e-02f, 6.61530718e-02f,
  -6.54046796e-03f, -6.56531285e-03f, -6.97949827e-02f, 2.16035675e-02f, 1.65111478e-02f, -5.87102920e-02f, -3.32374610e-02f, -2.76045632e-02f, -6.81550242e-03f, -4.11410369e-02f,
  -3.63994688e-01f, -9.60575510e-03f, 4.31309529e-02f, -2.28318945e-01f, -5.48537970e-02f, 9.59125236e-02f, -2.80652884e-02f, -2.26863682e-01f, -3.31069738e-01f, 3.05194445e-02f,
  1.27684504e-01f, -1.30010575e-01f, 1.68860838e-01f, 1.44115657e-01f, 1.18981816e-01f, 2.27920622e-01f, -1.04537997e-02f, -2.51956843e-02f, 1.44705493e-02f, -9.31053087e-02f,
  -1.05087101e-01f, 1.35529861e-01f, 2.59929925e-01f, 1.34378538e-01f, 4.77630198e-02f, -1.04470290e-01f, -3.91006330e-03f, 9.58851054e-02f, 6.45997748e-02f, 6.23933300e-02f,
  7.86366761e-02f, 8.50937665e-02f, 2.34895460e-02f, 2.78233103e-02f, -9.07714814e-02f, 7.68531263e-02f, 3.28534581e-02f, 1.10533364e-01f, -4.18052189e-02f, -3.17606404e-02f,
  -1.37811741e-02f, -2.29935758e-02f, -7.77905583e-02f, -4.31708992e-03f, -1.37454078e-01f, -3.83165106e-02f, -3.30347717e-02f, -6.07879162e-02f, -3.21368873e-03f, 3.86830121e-02f,
  5.71989976e-02f, 5.10164723e-02f, -7.12132920e-03f, -1.81011148e-02f, -5.12794964e-02f, -6.03126511e-02f, -1.04844384e-02f, 8.68382528e-02f, 3.14699784e-02f, -6.71963766e-02f,
  -1.30555006e-02f, -8.01201388e-02f, -8.91181827e-03f, -5.78044262e-03f, 5.09906523e-02f, 1.13979040e-03f, 6.64148405e-02f, 2.66864430e-02f, -4.78554182e-02f, -4.00527455e-02f,
  -7.18386918e-02f, -4.38602157e-02f, -1.66156851e-02f, -4.21828628e-02f, 3.15586179e-02f, -2.85961404e-02f, -1.99859813e-02f, 8.40130895e-02f, -5.83230481e-02f, 6.70996979e-02f,
  9.85543896e-03f, -6.42778426e-02f, 3.71442363e-02f, 7.82212317e-02f, 5.13503402e-02f, 1.59955397e-02f, -5.49614057e-02f, 4.83730733e-02f, 5.28981313e-02f, 3.27963680e-02f,
  -4.61426862e-02f, -5.71908392e-02f, 5.75981513e-02f, -1.15679773e-02f, 6.85767978e-02f, -5.03796637e-02f, -6.61700219e-02f, -6.15859590e-02f, 3.51897478e-02f, -1.68060698e-02f,
  -2.74735130e-02f, -1.42610958e-02f, -6.71294481e-02f, 6.90820068e-02f, -3.37934941e-02f, -2.37206928e-02f, 4.19434495e-02f, -8.43426399e-03f, -2.76233014e-02f, 1.22383293e-02f,
  -9.96474326e-02f, -1.07051924e-01f, -4.07770947e-02f, -3.11281886e-02f, 3.74520454e-03f, -4.26548943e-02f, -5.78249693e-02f, -2.16300823e-02f, 6.92927018e-02f, -7.70436078e-02f,
  -1.19544260e-01f, 2.51496047e-01f, 9.55461115e-02f, -7.85018802e-02f, -1.04619771e-01f, 3.55396718e-01f, 3.25611979e-01f, -1.19104989e-01f, -1.85155541e-01f, 2.06165105e-01f,
  5.90935014e-02f, 1.73578307e-01f, 4.54243124e-02f, 2.91619778e-01f, -5.18640168e-02f, 1.24123253e-01f, 1.22467034e-01f, 2.14796051e-01f, -1.89712122e-01f, 8.70923176e-02f,
  -1.06983244e-01f, -1.17915422e-02f, 3.16794328e-02f, -1.36628792e-01f, 1.26979321e-01f, -8.15501213e-02f, -1.83846876e-01f, -6.18374012e-02f, 1.10932633e-01f, -2.40418855e-02f,
  8.92178640e-02f, 3.80551699e-03f, 2.75109224e-02f, 9.08438116e-02f, 2.62682494e-02f, 6.55277818e-02f, 9.60379243e-02f, -1.04121631e-02f, -2.14574356e-02f, -1.84982398e-03f,
  7.14694262e-02f, -4.99590375e-02f, -3.72387655e-02f, -5.42014651e-02f, -6.77340180e-02f, -1.09025054e-01f, -2.71612704e-02f, 3.98535766e-02f, -7.03422949e-02f, 6.11005276e-02f,
  -1.73206832e-02f, 5.45592830e-02f, 5.84485531e-02f, 2.99483296e-02f, -8.62187333e-03f, -1.69522557e-02f, 1.25046760e-01f, 3.39807123e-02f, -7.23072328e-03f, 1.59944780e-02f,
  -5.90676069e-03f, 6.65551424e-02f, 2.87239812e-02f, 3.06992009e-02f, -4.07186933e-02f, -9.07745138e-02f, -1.19860331e-03f, 2.78970990e-02f, -4.98361140e-02f, 5.19328937e-02f,
  -7.52855092e-02f, 4.60948162e-02f, -4.45400588e-02f, 1.32631622e-02f, -1.38886413e-02f, 8.62370990e-03f, 1.86613027e-03f, 4.10361476e-02f, -6.34836251e-05f, -4.54536155e-02f,
  2.38457741e-03f, 1.68396346e-02f, 4.45235111e-02f, -8.66485294e-03f, -6.31306693e-02f, 2.10348796e-02f, 1.02635482e-02f, -3.65791842e-02f, 3.37042217e-03f, -7.03869388e-03f,
  5.76282814e-02f, -2.29175091e-02f, -4.40293737e-02f, -6.65574148e-02f, -1.02229215e-01f, -2.43294779e-02f, -4.61257994e-02f, 3.61624509e-02f, -2.20138114e-02f, -6.17084391e-02f,
  -1.94564015e-02f, 8.79084505e-03f, 6.09488413e-02f, 2.27865335e-02f, 1.77147482e-02f, 2.94026844e-02f, 5.42777888e-02f, 2.87337676e-02f, -2.38636378e-02f, -1.16693772e-01f,
  1.43041490e-02f, -1.45131573e-02f, 2.14499366e-02f, -9.63038998e-04f, 3.28485295e-02f, 2.96018347e-02f, -1.47844767e-02f, 1.19023202e-02f, -2.53140312e-02f, -9.07765515e-03f,
  -4.82814878e-01f, 2.63486177e-01f, 2.46395186e-01f, -1.87227696e-01f, -1.65853780e-02f, 1.67477250e-01f, -2.79351952e-03f, 1.00864597e-01f, 1.33425832e-01f, 9.59668159e-02f,
  6.94431961e-02f, 8.48464370e-02f, 7.12009072e-02f, -8.83104205e-02f, -1.39708603e-02f, 1.67130321e-01f, -1.30277798e-01f, -6.77586347e-02f, -1.82403605e-02f, -8.31335858e-02f,
  3.80963506e-03f, -3.33196074e-02f, -5.15352376e-02f, 1.76648587e-01f, -6.75856546e-02f, -5.81575669e-02f, -9.13827121e-02f, 1.93198636e-01f, -2.12970246e-02f, 3.11193131e-02f,
  -1.85449177e-03f, 8.48511010e-02f, -1.68225601e-01f, 4.82631922e-02f, 7.52386749e-02f, -2.17658803e-02f, -1.58038530e-02f, -4.02608961e-02f, -2.16656905e-02f, 1.59129482e-02f,
  -1.55821154e-02f, 9.79871452e-02f, -4.79515232e-02f, -2.75994628e-03f, -3.03747482e-04f, 7.59165436e-02f, 1.15838364e-01f, -1.37129892e-02f, 5.54701090e-02f, 1.20790482e-01f,
  7.45477304e-02f, -2.16289032e-02f, -3.51850279e-02f, 3.20578627e-02f, 5.53770252e-02f, 1.24684349e-02f, 4.01974283e-03f, 3.98660302e-02f, -3.70685495e-02f, 6.92635551e-02f,
  -8.18875730e-02f, -3.15241963e-02f, 5.18076867e-02f, -1.49344709e-02f, 8.43358785e-02f, -2.68707965e-02f, -5.59868664e-02f, 4.16814536e-02f, 9.07452404e-03f, 2.39115059e-02f,
  2.32630968e-02f, -6.35048002e-02f, 1.87072773e-02f, 1.24426594e-03f, -1.42102139e-02f, -1.90185737e-02f, -1.19599104e-01f, 2.36572195e-02f, 8.94053280e-02f, -2.37969551e-02f,
  4.48128581e-02f, 2.77965423e-02f, 2.95426734e-02f, 1.61635019e-02f, 4.35822923e-03f, 1.11338142e-02f, 2.99057513e-02f, 5.66976368e-02f, -7.31390789e-02f, -1.44398380e-02f,
  1.66997139e-03f, 7.87876472e-02f, 3.07809212e-03f, -1.78775173e-02f, -1.71079824e-03f, 8.44572783e-02f, -1.02619804e-01f, -2.97369789e-02f, 4.05539162e-02f, 2.56176596e-03f,
  1.58099066e-02f, -1.03047617e-01f, -1.25734915e-03f, 3.34155373e-02f, -3.25626470e-02f, 3.39828543e-02f, -1.52959311e-02f, 3.10822297e-03f, -4.87141171e-03f, -3.83840986e-02f,
  -8.33732560e-02f, -1.39791341e-02f, 5.17323911e-02f, -3.14279199e-02f, -1.08840458e-01f, 5.61849913e-04f, -9.09421667e-02f, 3.33923986e-03f, 5.37432171e-02f, 2.09926721e-02f,
  3.19493294e-01f, 8.98234488e-04f, -1.19412959e-01f, 1.62964016e-01f, 1.48869604e-01f, 1.89993650e-01f, 8.62087980e-02f, 3.84058505e-02f, -5.94134144e-02f, -1.71666350e-02f,
  9.21215862e-02f, -4.16743904e-02f, -1.38807207e-01f, -3.12592499e-02f, 2.12904543e-01f, -1.61303714e-01f, 1.01151764e-01f, 8.34565610e-02f, -4.47970107e-02f, 1.57980591e-01f,
  -4.35541756e-02f, 7.78273568e-02f, -1.24649286e-01f, -2.45760195e-02f, 5.65525927e-02f, -1.51799561e-03f, -4.98483591e-02f, 4.07295069e-03f, 4.48809005e-02f, -2.98780501e-02f,
  1.38428673e-01f, -2.11025905e-02f, -3.95233408e-02f, 2.28588451e-02f, 1.57656297e-02f, -3.70203741e-02f, -5.23966476e-02f, -4.90829982e-02f, -6.54617250e-02f, 7.66105428e-02f,
  8.94805863e-02f, 1.91821642e-02f, 2.06466150e-02f, -8.02886859e-02f, 5.78808114e-02f, -1.18312554e-03f, -4.74372283e-02f, 9.68777537e-02f, -1.15899377e-01f, 1.51812914e-03f,
  1.54006714e-02f, -4.34462875e-02f, -1.44260088e-02f, -6.12075850e-02f, -2.63203960e-02f, -5.92013188e-02f, -3.33816297e-02f, 4.92463298e-02f, 1.52911365e-01f, -5.06508723e-03f,
  4.65669520e-02f, -6.50247708e-02f, -4.17802632e-02f, 2.98593771e-02f, 3.71960513e-02f, -4.29099500e-02f, 3.51616330e-02f, 6.01710752e-03f, -6.64591938e-02f, 3.35092028e-03f,
  8.18878561e-02f, 4.29791659e-02f, 2.38987599e-02f, 1.80614982e-02f, -1.13217644e-02f, 1.81092881e-02f, 6.11795187e-02f, 3.98006141e-02f, 2.39507649e-02f, -3.28997783e-02f,
  -6.75974935e-02f, 2.26207506e-02f, 2.83887628e-02f, 3.48077193e-02f, -8.44503287e-04f, -2.85669621e-02f, -5.56060709e-02f, -5.63073605e-02f, 2.56992644e-03f, 9.56511572e-02f,
  2.56883055e-01f, 1.06911018e-01f, -2.08331970e-03f, -7.59673631e-03f, -1.19611649e-02f, -3.00668068e-02f, -1.34300157e-01f, -5.99409733e-03f, 8.94258767e-02f, 1.80344395e-02f,
  3.26224156e-02f, 1.30119883e-02f, 5.64347357e-02f, 6.56650811e-02f, 3.84300686e-02f, -3.71185131e-02f, 5.48000708e-02f, 1.07628860e-01f, 1.41838491e-01f, -5.59431687e-03f,
  5.53320535e-02f, 6.30786717e-02f, -4.26208414e-02f, 3.12021002e-02f, 7.37745035e-03f, -2.29846612e-02f, 6.68337867e-02f, -5.90427145e-02f, 5.53778447e-02f, 1.26004836e-03f,
  -2.94747263e-01f, -1.27537772e-01f, -2.72332489e-01f, -2.66284615e-01f, -8.88731182e-02f, 1.91975534e-01f, 1.68930203e-01f, -1.64810091e-01f, 8.60207900e-03f, 2.26821095e-01f,
  -1.31233826e-01f, 4.77550924e-03f, 1.22791760e-01f, -1.76571444e-01f, -1.05378523e-01f, 1.09463193e-01f, -5.51513843e-02f, 6.80016428e-02f, 5.94760180e-02f, -1.08788989e-01f,
  -1.04145117e-01f, 6.17649266e-03f, -2.18293235e-01f, -1.28264979e-01f, -2.29169682e-01f, -9.04456899e-02f, -7.10900221e-03f, -1.07096203e-01f, -5.64410537e-02f, 4.39184010e-02f,
  -1.92129333e-02f, -3.96396108e-02f, -4.88270260e-02f, -3.76987942e-02f, -4.08167094e-02f, 1.69280861e-02f, 7.03212917e-02f, 6.35792837e-02f, -1.44456616e-02f, 1.57717094e-02f,
  2.35070921e-02f, -1.11326147e-02f, 5.57282101e-03f, -1.21013457e-02f, -3.37090599e-03f, -6.03758618e-02f, -3.49368863e-02f, -4.93165776e-02f, -7.30583668e-02f, -3.65850329e-02f,
  -3.53532024e-02f, -3.87987345e-02f, -3.84919159e-03f, 1.03223525e-01f, -8.43071472e-03f, 4.07365151e-02f, 2.89789569e-02f, 5.47675090e-03f, -2.23592930e-02f, 4.44966406e-02f,
  7.54087418e-02f, 3.59480344e-02f, -8.19279477e-02f, -9.98318642e-02f, -9.08153355e-02f, 1.36167351e-02f, 1.73898451e-02f, -2.09828746e-03f, -5.55322617e-02f, 8.99578445e-03f,
  -6.35351017e-02f, 7.22000515e-03f, 2.01425306e-03f, 2.68681347e-02f, 7.76404981e-03f, -5.58675313e-03f, 2.41535287e-02f, 3.57244313e-02f, 3.23532410e-02f, -4.91010807e-02f,
  7.64741451e-02f, 4.04416118e-03f, 1.66613347e-04f, 1.21059660e-02f, 3.07258610e-02f, -1.41539145e-02f, -3.93758900e-02f, -4.67062108e-02f, -4.26224209e-02f, -2.06278544e-02f,
  1.13158330e-01f, 9.79621410e-02f, -3.94812305e-05f, 1.99299976e-02f, 6.98718801e-02f, -3.44169289e-02f, -4.30724137e-02f, -2.43304037e-02f, 8.35973918e-02f, -8.83306842e-03f,
  4.42364328e-02f, 6.32922426e-02f, 8.55784416e-02f, 7.78552145e-03f, -5.26942201e-02f, 3.21705043e-02f, 8.72659609e-02f, 3.85275260e-02f, 1.09345689e-02f, -2.06867000e-03f,
  -1.32127972e-02f, 1.10659949e-01f, 3.94459628e-02f, 4.37711701e-02f, 5.23903184e-02f, 1.09668031e-01f, 2.94208284e-02f, 4.10148464e-02f, 1.62442122e-02f, 7.40625635e-02f,
  -5.06624341e-01f, 1.40623406e-01f, -1.41512394e-01f, 3.86662371e-02f, -2.40369543e-01f, -2.02396795e-01f, -1.39346048e-01f, -8.02553296e-02f, -2.52904028e-01f, 1.23234384e-01f,
  4.74429177e-03f, 2.52653169e-03f, 1.92289934e-01f, 1.63533427e-02f, -1.22474685e-01f, 1.72181532e-01f, -1.21019792e-03f, 1.47957683e-01f, 2.17551813e-02f, 5.90687580e-02f,
  -1.84031855e-02f, 8.27496871e-02f, 1.43684477e-01f, 6.66172132e-02f, -1.90733168e-02f, 2.49373075e-02f, 2.53906876e-01f, 4.90742810e-02f, 1.64376631e-01f, -5.66247143e-02f,
  -6.48602396e-02f, 7.19592273e-02f, 1.74628943e-02f, -1.03432387e-01f, 3.34589444e-02f, -5.40091060e-02f, 1.51141025e-02f, -1.30791105e-02f, -5.35240807e-02f, 2.80095376e-02f,
  4.90207821e-02f, -6.48514777e-02f, -3.35475504e-02f, -1.31508932e-02f, -2.14632004e-02f, -1.99701041e-02f, -7.79491290e-03f, -8.12816620e-02f, -2.00757980e-02f, 4.22409689e-03f,
  -4.99813072e-03f, -1.25201885e-02f, -1.43812159e-02f, 4.54437584e-02f, 4.63335738e-02f, -1.97194554e-02f, 5.30379219e-03f, -2.63724453e-03f, 1.37459040e-02f, 1.74756311e-02f,
  6.56608120e-02f, 1.94558932e-03f, 2.15691703e-04f, 1.13980221e-02f, -7.41138160e-02f, 9.59150773e-03f, 7.14063039e-03f, 7.54830390e-02f, -3.33309313e-03f, 3.63650476e-03f,
  -2.61353478e-02f, -2.93032620e-02f, -5.71251847e-02f, -6.37654215e-02f, -4.67515215e-02f, -7.31401471e-03f, -1.23006841e-02f, 5.18397801e-02f, -1.10682137e-02f, -2.59912778e-02f,
  -6.59033470e-03f, 1.32366801e-02f, 1.14993323e-02f, 3.55344675e-02f, -2.24891771e-02f, 2.72211991e-02f, 9.06246342e-03f, -2.63036881e-03f, -1.11034082e-03f, 1.51102049e-02f,
  8.57846141e-02f, 1.70505852e-01f, 4.87856716e-02f, -5.59604773e-03f, -6.94997550e-04f, -1.10842222e-02f, 1.39191039e-02f, -6.06527785e-03f, 9.36547741e-02f, -4.25455114e-03f,
  2.18296368e-02f, 2.56326236e-02f, 2.48389933e-02f, 2.38781344e-04f, 1.10702580e-02f, 1.67735126e-02f, 1.65808424e-02f, 3.04766055e-02f, 6.46438962e-03f, 2.64102612e-02f,
  -2.14041490e-02f, -1.67748835e-02f, 2.43148021e-02f, -1.11344662e-02f, 2.58028489e-02f, -3.11873527e-03f, -6.47749677e-02f, -4.37459871e-02f, -3.85070289e-03f, 2.73859389e-02f,
  -3.05323750e-01f, 9.48881507e-02f, 9.21708066e-03f, 1.54552788e-01f, -2.36574814e-01f, -9.68228430e-02f, -4.14224304e-02f, -3.80713195e-02f, 2.71387756e-01f, 2.23484576e-01f,
  -2.68871989e-02f, -2.61333641e-02f, 1.26557410e-01f, 1.82774216e-01f, -1.38895333e-01f, 2.51219869e-01f, 1.06487736e-01f, 3.96301895e-02f, -1.83841344e-02f, -1.59264401e-01f,
  4.28478885e-03f, -2.07871199e-02f, -9.68488902e-02f, -1.19569436e-01f, -8.59923586e-02f, -1.55510783e-01f, 7.32411593e-02f, -6.82789981e-02f, -1.16035432e-01f, 5.02671488e-02f,
  -1.49610102e-01f, -2.92171091e-02f, -9.76860225e-02f, -7.40363402e-03f, -1.70368060e-01f, 6.34010369e-03f, -7.26619810e-02f, -2.81711621e-03f, -5.46832718e-02f, 4.63943556e-02f,
  6.97819963e-02f, -6.89252615e-02f, 2.42812671e-02f, 6.49017841e-02f, 1.79293826e-02f, 7.75903463e-02f, -7.64973387e-02f, 1.67338178e-02f, -1.46210035e-02f, -1.20194353e-01f,
  -6.32607797e-03f, -1.45865664e-01f, 8.96031111e-02f, 3.92377041e-02f, -8.73832703e-02f, -1.19183566e-02f, 4.29430604e-03f, -1.57891542e-01f, 7.26901963e-02f, -2.46561412e-02f,
  9.99704003e-03f, 3.11489170e-03f, -3.27841192e-02f, 4.22353251e-03f, 2.23773010e-02f, -2.41147373e-02f, 1.06767394e-01f, 3.99317071e-02f, -3.52831781e-02f, 4.11014212e-03f,
  -8.56265649e-02f, 7.02028126e-02f, 2.41321772e-02f, 7.78297484e-02f, -3.92222703e-02f, 4.32672352e-02f, -2.80984603e-02f, -4.36655916e-02f, -9.23617631e-02f, 1.69266351e-02f,
  1.54881984e-01f, 5.63841313e-02f, -9.74057689e-02f, 3.04064006e-02f, 1.26880854e-02f, 1.23296799e-02f, 1.41791046e-01f, 6.11847937e-02f, 2.84287264e-03f, -4.33730036e-02f,
  -7.94437900e-03f, 3.30761969e-02f, 3.32314372e-02f, -1.14947325e-02f, 8.79561454e-02f, 3.73420902e-02f, 1.28821105e-01f, 9.11512692e-03f, 1.45570077e-02f, -5.32393642e-02f,
  -1.26517430e-01f, 6.85579553e-02f, -2.25616823e-04f, -6.96831942e-02f, 6.42475113e-02f, -9.56832338e-03f, -8.39928072e-03f, -1.43017173e-02f, 1.18937595e-02f, -6.42873794e-02f,
  1.94487628e-02f, -4.74257059e-02f, -8.63880571e-03f, -8.40217099e-02f, -1.42981031e-03f, -5.36908060e-02f, -2.14694235e-02f, -9.67526734e-02f, -1.51496399e-02f, 9.34206620e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.09599248e-01f, -5.17057516e-02f, -2.38390401e-01f, 1.11666314e-01f, 1.68113545e-01f, -2.94065356e-01f, -2.59175926e-01f, 1.22601144e-01f, 4.56651181e-01f, -1.23968840e-01f,
  -5.62852360e-02f, -1.25164717e-01f, -5.28560914e-02f, -1.09807171e-01f, -2.21848965e-01f, 1.93598643e-01f, -2.52796680e-01f, 2.86460239e-02f, 2.09989861e-01f, -3.04772824e-01f,
  9.35041532e-02f, -3.03139776e-01f, -3.21453094e-01f, -2.34125644e-01f, -1.95633113e-01f, -1.35696769e-01f, -3.74752909e-01f, -1.56945035e-01f, -4.53901857e-01f, -1.23732626e-01f,
  -3.32458168e-01f, 1.76902547e-01f, -2.60284513e-01f, -3.19883437e-03f, -4.75694239e-02f, -4.42356057e-02f, -2.39068344e-01f, -7.89237916e-02f, -1.68594196e-01f, -2.27444246e-02f,
  3.53195518e-02f, -4.84495908e-02f, 7.31013492e-02f, 3.21545452e-02f, 8.86449367e-02f, -8.15179721e-02f, 5.23648039e-02f, -3.46438624e-02f, -9.53185707e-02f, 4.58438322e-02f,
  -1.39596000e-01f, 6.72214106e-02f, 2.60034334e-02f, 4.08848748e-02f, -1.05449669e-01f, 4.08555893e-03f, -7.57634416e-02f, -4.08291519e-02f, -8.57043117e-02f, 9.19864103e-02f,
  -6.89950903e-05f, -1.06286995e-01f, -4.48072851e-02f, -1.87536981e-02f, -4.87382598e-02f, 9.77619365e-02f, 1.93189606e-02f, -5.00463368e-03f, 2.02122591e-02f, -2.35440955e-02f,
  7.89413750e-02f, -7.69877657e-02f, 3.47231627e-01f, 6.87386319e-02f, 7.65212178e-02f, 9.34823602e-02f, -8.27682912e-02f, 2.21600220e-01f, 1.54768437e-01f, -8.48539695e-02f,
  -2.18555555e-02f, -1.19514413e-01f, 2.76610572e-02f, 7.59968758e-02f, -1.19394876e-01f, -8.36675093e-02f, -1.08666182e-01f, -2.89657037e-03f, 9.72630605e-02f, -9.08370465e-02f,
  -3.52930307e-01f, -1.64308310e-01f, -2.68357724e-01f, -1.39444685e-02f, -1.48538932e-01f, -1.22874826e-02f, -5.92911765e-02f, 6.54369742e-02f, -1.89495936e-01f, 8.40199217e-02f,
  4.78669479e-02f, 7.15185702e-03f, -1.16949551e-01f, 1.32174194e-01f, -7.48523995e-02f, -1.02851242e-01f, -1.88983768e-01f, 4.49490659e-02f, -2.99047828e-01f, -1.36220232e-01f,
  -1.21625409e-01f, -3.70399319e-02f, -5.63984774e-02f, 3.04581746e-02f, -3.03681660e-02f, -7.45865032e-02f, 1.54769957e-01f, -7.05240965e-02f, -5.54217361e-02f, -6.94700032e-02f,
  -1.77256733e-01f, 3.49377096e-01f, 3.02161932e-01f, -2.54009012e-02f, -2.80755550e-01f, 1.00174889e-01f, 8.32970161e-03f, 7.61101469e-02f, 2.38689780e-01f, 2.87727684e-01f,
  -2.69407630e-01f, 4.39025283e-01f, 7.56189376e-02f, 1.19727291e-01f, -1.83097944e-01f, -4.37882505e-02f, -5.15425717e-03f, 1.90020978e-01f, 1.25225365e-01f, -6.21408690e-03f,
  -1.09859243e-01f, -2.63507515e-01f, -1.36302352e-01f, -4.58274521e-02f, -2.10923348e-02f, 7.18743652e-02f, -3.71113539e-01f, -1.06405154e-01f, 3.06274537e-02f, 3.21464352e-02f,
  -8.57333392e-02f, 1.64000154e-01f, -1.79375429e-02f, 1.62831858e-01f, -8.81753303e-03f, 1.81510542e-02f, 1.70264989e-02f, 9.68031958e-02f, -6.71205148e-02f, -6.53857458e-03f,
  1.13929652e-01f, 6.22442961e-02f, 4.08040695e-02f, -8.73479173e-02f, 1.55992702e-01f, 4.67638373e-02f, -4.63682646e-03f, -5.73632494e-02f, 6.28201067e-02f, -7.12691471e-02f,
  6.09134622e-02f, 1.17227338e-01f, -4.54128385e-02f, 1.41952410e-01f, 1.22863594e-02f, 3.84868197e-02f, 9.41093341e-02f, -1.24595739e-01f, 9.66741592e-02f, -3.60124023e-03f,
  2.84466054e-02f, -3.22607905e-02f, -9.32198092e-02f, 1.67558398e-02f, 8.17771032e-02f, -6.72877654e-02f, 5.88244013e-02f, -1.00609235e-01f, 1.51480049e-01f, -1.87988542e-02f,
  8.53349566e-02f, 1.01493010e-02f, 5.29945418e-02f, -1.00507922e-01f, -9.19836834e-02f, 5.37694953e-02f, 4.69313338e-02f, 7.39030689e-02f, 1.08158877e-02f, -9.53341275e-02f,
  7.12663606e-02f, 6.32710233e-02f, 6.14252640e-03f, -1.86417431e-01f, -1.09543931e-02f, -4.46587577e-02f, -2.07036883e-02f, 6.33223578e-02f, -4.60313819e-02f, -1.16347179e-01f,
  6.13548383e-02f, 1.19461842e-01f, 9.12851468e-02f, 1.85155794e-01f, 1.29535049e-01f, -1.05175354e-01f, 1.07962452e-02f, -1.09500654e-01f, -2.12980143e-04f, 9.09780040e-02f,
  -3.45212705e-02f, 7.14941993e-02f, -7.99551755e-02f, -6.30028844e-02f, 1.15671150e-01f, -5.67107610e-02f, -6.08162619e-02f, 5.51072806e-02f, -3.40414345e-02f, -9.42190588e-02f,
  4.98054139e-02f, 7.10635334e-02f, -2.45785266e-02f, -1.70113873e-02f, 6.00262247e-02f, -1.26286242e-02f, 3.70118022e-02f, 1.68197155e-01f, -1.31598264e-01f, 2.93881018e-02f,
  7.30170459e-02f, 1.87205300e-01f, -4.62317616e-02f, 2.31281832e-01f, -3.44663829e-01f, -3.56004536e-01f, -4.02881831e-01f, -1.02910444e-01f, -1.43074216e-02f, 6.29808158e-02f,
  -4.00220975e-02f, 2.89080441e-01f, 2.11922199e-01f, 2.61755258e-01f, 1.87778831e-01f, 3.42041135e-01f, 1.46990186e-02f, -7.72058293e-02f, 1.48261100e-01f, 2.26659738e-02f,
  1.29823595e-01f, 2.31962949e-01f, 1.96240708e-01f, -4.72175516e-02f, -9.22498927e-02f, 5.42310923e-02f, 3.84379804e-01f, 3.93164530e-02f, 1.01758383e-01f, 5.29297367e-02f,
  -9.70087200e-03f, 3.30428511e-01f, -1.45127364e-02f, 4.96982224e-02f, 5.76352179e-02f, -1.59595519e-01f, -6.56844974e-02f, 3.28453034e-02f, -7.36966133e-02f, 8.39069635e-02f,
  1.02588996e-01f, 3.97462845e-02f, -1.82578024e-02f, 8.52005556e-02f, -7.44936988e-02f, 3.78740719e-03f, 2.93534860e-04f, -2.09665045e-01f, -7.03798607e-02f, 4.19971347e-02f,
  -1.34777129e-01f, 7.58304968e-02f, -1.82600264e-02f, 9.23919603e-02f, 1.85331237e-02f, 4.80745547e-03f, 4.24041338e-02f, 9.28671658e-02f, 1.22127585e-01f, 4.07446474e-02f,
  6.59572557e-02f, 2.42059436e-02f, 7.57718412e-03f, -1.49950096e-02f, -2.13514715e-02f, -6.28758445e-02f, -7.20331818e-02f, -1.01771511e-01f, 8.91396776e-02f, 6.83122650e-02f,
  -6.14175983e-02f, 3.40432301e-02f, -7.61095658e-02f, -1.33310454e-02f, 3.66847627e-02f, 3.90752703e-02f, -5.43730296e-02f, 1.73630659e-02f, -5.89659400e-02f, 3.40771377e-02f,
  7.52932653e-02f, 1.89813916e-02f, 8.77294838e-02f, 2.60002166e-02f, -6.47201613e-02f, 2.80472115e-02f, 1.05643630e-01f, 3.50604542e-02f, -1.10165857e-01f, -1.52621478e-01f,
  1.30003631e-01f, 4.86893088e-01f, -8.44668373e-02f, 7.43646454e-03f, 4.82907370e-02f, -3.86577770e-02f, 5.29478788e-02f, 8.74283984e-02f, 1.87400237e-01f, -6.95275958e-04f,
  -8.01406130e-02f, -1.22556657e-01f, 2.86494717e-02f, 3.27826142e-02f, -4.09568660e-02f, 6.50998279e-02f, 1.50897682e-01f, 9.71211717e-02f, 7.64136985e-02f, 7.73445070e-02f,
  2.69113276e-02f, -3.51947136e-02f, 9.76332873e-02f, -5.35687990e-02f, 7.34772999e-03f, 1.21478759e-01f, -4.77799699e-02f, 8.70055461e-04f, 8.63723010e-02f, 9.65529010e-02f,
  -2.53296435e-01f, 3.58579531e-02f, 5.19228995e-01f, -4.67029244e-01f, 3.28457318e-02f, 3.56679499e-01f, 1.90050662e-01f, -7.34482659e-03f, -2.32068598e-01f, -1.78266257e-01f,
  -1.51581794e-01f, -4.55262847e-02f, 3.02259684e-01f, -1.36059910e-01f, 4.42513496e-01f, 1.89812288e-01f, -1.43722624e-01f, -9.07002538e-02f, -8.83854553e-03f, -1.68708220e-01f,
  -1.11477770e-01f, -3.53450000e-01f, 2.41646037e-01f, -1.54314697e-01f, -5.27462661e-02f, -1.43741593e-01f, -1.04499489e-01f, 1.82574615e-01f, -2.12451831e-01f, 4.51656990e-02f,
  7.30027035e-02f, -1.30261019e-01f, -2.94342563e-02f, 1.76134370e-02f, 1.51507324e-02f, 9.69874635e-02f, -4.26255679e-03f, 8.56313258e-02f, -1.19806871e-01f, -5.29788435e-02f,
  -3.60835418e-02f, 2.73919869e-02f, -1.60221413e-01f, 7.19478354e-02f, -1.46294206e-01f, -7.68735409e-02f, -1.99662782e-02f, 4.86974381e-02f, 9.29014850e-03f, 1.11451730e-01f,
  1.48846373e-01f, -4.83796485e-02f, -1.32087111e-01f, -9.24027786e-02f, -3.75209935e-02f, -5.65297492e-02f, -3.32115665e-02f, 5.23537472e-02f, -1.10092320e-01f, -1.20988794e-01f,
  -6.15296327e-02f, 7.29636922e-02f, 6.57409951e-02f, 2.95366403e-02f, -4.35057245e-02f, -1.50653655e-02f, -5.55862859e-02f, 3.29668820e-02f, -1.29505351e-01f, -7.71973878e-02f,
  -5.32323904e-02f, -2.99159940e-02f, -1.85096413e-02f, -4.74315770e-02f, -4.15904112e-02f, -6.27937838e-02f, 3.41988057e-02f, 6.74814126e-03f, 2.96150651e-02f, -3.48074324e-02f,
  -1.47334024e-01f, -6.26467839e-02f, 3.53890881e-02f, -4.50699357e-03f, 1.23873986e-01f, 8.00252613e-03f, -9.51807871e-02f, 9.09673888e-03f, 7.62370764e-04f, 5.95405065e-02f,
  -2.27766559e-02f, -2.01884300e-01f, 1.97876450e-02f, -3.70686571e-03f, 1.02997832e-01f, 6.54072016e-02f, -1.38512282e-02f, -5.31936102e-02f, -7.58629898e-03f, 1.92045253e-02f,
  -5.05961254e-02f, -5.78259155e-02f, 3.67670916e-02f, 2.12296676e-02f, 3.54844444e-02f, 4.96115126e-02f, -3.38301100e-02f, -4.06684577e-02f, -4.68823947e-02f, 1.46550545e-02f,
  -4.08635326e-02f, -7.28716403e-02f, -7.58488663e-03f, -2.17076823e-01f, -1.30212262e-01f, -1.17757402e-01f, 2.71292720e-02f, -3.55354436e-02f, 3.74069102e-02f, 3.37938480e-02f,
  1.43056914e-01f, -2.15640873e-01f, -3.65428418e-01f, -2.43790802e-02f, 1.78777933e-01f, 3.47832203e-01f, -8.29113945e-02f, -1.41436353e-01f, -3.11684549e-01f, -3.09597161e-02f,
  1.47142902e-01f, 5.88365458e-03f, -2.41968960e-01f, 3.64311755e-01f, 4.12962735e-01f, -2.78028101e-01f, 2.95746416e-01f, 2.25520730e-01f, -2.37252042e-01f, 2.46769823e-02f,
  4.62323576e-02f, 4.80750322e-01f, -1.71262279e-01f, 2.41618887e-01f, 2.00925037e-01f, 7.31439609e-03f, 3.19771200e-01f, 4.52390425e-02f, 4.45341170e-01f, 3.53741884e-01f,
  6.02549687e-02f, 1.38590243e-02f, -8.25925171e-02f, -6.06508814e-02f, -6.12039417e-02f, 2.81833187e-02f, 1.03998281e-01f, 2.30087206e-01f, 3.70261222e-02f, -2.84377132e-02f,
  1.02075204e-01f, 1.10790268e-01f, 2.77070180e-02f, -3.06517788e-04f, 6.48620054e-02f, -3.53381708e-02f, -7.27037936e-02f, -2.07571059e-01f, 4.65726480e-03f, -8.28717798e-02f,
  -2.33851820e-01f, -7.49410316e-02f, -3.04785389e-02f, -2.76702084e-02f, -1.36520341e-01f, -1.44918067e-02f, 8.16001091e-03f, 8.56008306e-02f, 1.58402126e-03f, 1.01385050e-01f,
  6.07247390e-02f, -3.25583890e-02f, -3.46895009e-02f, -1.07294984e-01f, -7.01745525e-02f, -2.88012587e-02f, 4.56324853e-02f, -2.42810813e-03f, -1.00662820e-01f, -4.06724475e-02f,
  -8.89048874e-02f, -4.33299541e-02f, -4.29592244e-02f, -5.28645702e-02f, 6.36957735e-02f, -8.94645676e-02f, -6.80773612e-03f, 7.51703382e-02f, -1.40433460e-01f, -5.09208739e-02f,
  8.21733400e-02f, -5.96820097e-03f, 3.34155336e-02f, -1.15618948e-02f, 1.51905073e-02f, 7.14628166e-03f, 1.09408818e-01f, 2.88626831e-02f, -1.01068430e-01f, -5.53641506e-02f,
  1.50202021e-01f, 1.03403918e-01f, -2.71537527e-02f, 6.22625314e-02f, -1.01085000e-01f, 5.04424162e-02f, 1.27252154e-02f, 3.08850370e-02f, 5.88658601e-02f, -4.72145826e-02f,
  7.34132007e-02f, 3.44989114e-02f, -2.26721577e-02f, 2.48367544e-02f, 1.28970250e-01f, -3.89455780e-02f, -3.51663977e-02f, 4.68130149e-02f, -6.43429980e-02f, 1.56298369e-01f,
  -1.27672730e-02f, 2.11919611e-03f, 3.76102366e-02f, -1.20959461e-01f, -7.66968820e-03f, -3.26554552e-02f, 1.22571759e-01f, 4.81372923e-02f, 2.46203467e-02f, -4.70745750e-02f,
  2.21846908e-01f, 2.33458117e-01f, 2.07763031e-01f, 2.76277542e-01f, -4.33851816e-02f, -3.96574348e-01f, -1.74074158e-01f, 2.19065342e-02f, 2.55693644e-01f, -2.06934676e-01f,
  -1.59516811e-01f, 1.06640898e-01f, -2.18454674e-01f, 4.51880246e-02f, 1.94989994e-01f, -1.36468932e-01f, 1.31923988e-01f, -4.38255705e-02f, 3.71453986e-02f, 7.65673816e-02f,
  2.71477878e-01f, -2.48580761e-02f, 1.84406564e-01f, -1.87525572e-03f, 8.98511559e-02f, 1.67484790e-01f, 3.17567706e-01f, 2.28059595e-03f, 1.17390350e-01f, -1.48446366e-01f,
  1.13684591e-02f, 6.76923096e-02f, 9.50666666e-02f, -6.50932938e-02f, 1.67611554e-01f, -4.64732796e-02f, -7.10812137e-02f, -2.09577270e-02f, 2.60033123e-02f, -6.10055216e-02f,
  1.68804284e-02f, -1.04207583e-01f, -7.00279474e-02f, -3.92229622e-03f, -4.46903296e-02f, -8.42603017e-03f, 2.30929721e-02f, 6.98914975e-02f, 6.56844154e-02f, 5.94257824e-02f,
  1.97991878e-01f, 1.36331031e-02f, 2.46238317e-02f, -4.00946401e-02f, 1.64981887e-01f, 4.84985188e-02f, -1.49977105e-02f, 6.42943159e-02f, 4.68618870e-02f, 1.16092607e-01f,
  1.83805022e-02f, -2.13442836e-02f, -1.83155201e-02f, 5.28794415e-02f, -2.28270856e-05f, 1.08232699e-01f, 1.23221859e-01f, -3.99501063e-02f, 1.20600648e-01f, 3.07368487e-03f,
  1.34666534e-02f, -3.53615284e-02f, -1.91836543e-02f, -6.86455593e-02f, -1.31903723e-01f, 4.84424345e-02f, -1.17107332e-02f, -1.74593940e-01f, 2.86890268e-02f, 1.24200270e-01f,
  1.43419243e-02f, -7.75207058e-02f, 5.75856268e-02f, -4.91470955e-02f, -1.11541495e-01f, -4.71063256e-02f, 2.01670490e-02f, -7.88220484e-03f, 3.41160782e-02f, 1.39756994e-02f,
  6.51580915e-02f, 1.68839395e-01f, 9.44458619e-02f, -7.35496432e-02f, 9.03704844e-04f, -4.51606438e-02f, -5.70108481e-02f, -5.72905317e-03f, 1.21724635e-01f, -3.29016596e-02f,
  1.05767604e-02f, 6.59355968e-02f, -2.70477794e-02f, -9.20875743e-02f, 1.04613684e-01f, 1.20348319e-01f, 5.78497276e-02f, 6.95168227e-02f, 9.48144197e-02f, 1.22490646e-02f,
  -5.71812764e-02f, -1.82216182e-01f, 1.11340508e-01f, 4.15097550e-02f, -6.42262548e-02f, 2.95023676e-02f, -9.46447924e-02f, -4.36563697e-03f, 5.21312691e-02f, 1.60460267e-02f,
  5.23122132e-01f, 3.28578055e-01f, 4.17808652e-01f, 5.01695335e-01f, -8.64275843e-02f, -2.52105772e-01f, -1.71534661e-02f, 9.11140516e-02f, 1.70548722e-01f, -2.22363591e-01f,
  -1.42023042e-01f, 2.02271014e-01f, -1.55168504e-01f, 2.41496608e-01f, -1.61172897e-01f, -2.31939778e-01f, 1.87918663e-01f, -3.87183949e-03f, -3.47397737e-02f, 1.79806665e-01f,
  7.92157575e-02f, -9.63196903e-02f, 1.82331130e-01f, 1.99982361e-03f, 3.06644171e-01f, 2.33785376e-01f, 1.94821786e-02f, -5.08918837e-02f, 2.65230834e-01f, -2.53326207e-01f,
  -6.64930493e-02f, 1.05308391e-01f, 1.28535658e-01f, -8.73234272e-02f, -2.73948405e-02f, 2.74013169e-02f, -3.92286405e-02f, -1.28720835e-01f, 3.55667211e-02f, -1.13767341e-01f,
  -1.20550375e-02f, -5.65674901e-02f, -2.37999260e-02f, -3.64489928e-02f, -6.52492121e-02f, 3.55204679e-02f, 1.46546811e-02f, 1.50398672e-01f, 4.14147489e-02f, 1.53640518e-02f,
  2.44322643e-01f, 9.39655304e-02f, 8.51251930e-02f, 6.53241482e-03f, 6.22319132e-02f, 4.67708968e-02f, -2.00356003e-02f, 1.17294014e-01f, 4.78330776e-02f, 4.28905375e-02f,
  -6.48357868e-02f, -2.04760395e-02f, 3.22214663e-02f, 1.41787708e-01f, -2.23127380e-02f, 1.31163290e-02f, -8.05203989e-02f, -2.29745191e-02f, -1.75167064e-04f, -2.79532775e-04f,
  5.30006327e-02f, 3.15024406e-02f, 2.85631754e-02f, 1.20595461e-02f, 2.29816437e-02f, 5.71363829e-02f, -3.33977491e-02f, -6.07167594e-02f, 8.73115584e-02f, -5.47933578e-02f,
  3.44014131e-02f, 6.47654058e-03f, -9.43184551e-03f, -6.52799532e-02f, 1.72801912e-02f, -6.99085072e-02f, 7.05635324e-02f, 8.64160508e-02f, 1.93576869e-02f, -8.74653906e-02f,
  -1.90992668e-01f, -2.12324783e-02f, -1.98883907e-04f, -1.40601218e-01f, -1.33734807e-01f, 4.62845974e-02f, 3.69401984e-02f, 5.00493497e-02f, -4.62264009e-02f, -1.05437182e-01f,
  4.91796881e-02f, -1.82171725e-02f, -1.30382270e-01f, 9.09416750e-03f, -1.18226737e-01f, -1.46436431e-02f, 6.69351444e-02f, -1.26304179e-02f, -7.82947168e-02f, 5.79055361e-02f,
  1.24513410e-01f, -1.81014970e-01f, -1.04236249e-02f, 1.34233907e-02f, -2.64504459e-03f, -8.70987102e-02f, 1.08997673e-01f, -2.21593566e-02f, 8.95198085e-04f, 5.48114032e-02f,
  -2.47829556e-01f, 4.77892101e-01f, -2.58995235e-01f, 3.43167931e-02f, -2.10673824e-01f, 5.53001046e-01f, 4.40631568e-01f, -5.38045987e-02f, -9.58843678e-02f, 2.22409233e-01f,
  3.33557799e-02f, -1.83273390e-01f, 1.45218447e-01f, 4.12349790e-01f, -8.47220700e-03f, 4.95986521e-01f, 2.66311884e-01f, 1.73943818e-01f, 1.72976658e-01f, 1.41244501e-01f,
  -7.19469264e-02f, 2.33430535e-01f, 7.36589432e-02f, 8.77724588e-02f, -8.01740438e-02f, -2.36945629e-01f, -1.00355268e-01f, -1.75132662e-01f, -1.58846140e-01f, 9.59814992e-03f,
  8.68925601e-02f, -2.86376048e-02f, -7.47382492e-02f, -6.40759692e-02f, -1.03308428e-02f, -4.92394231e-02f, -2.20254529e-02f, -6.96516111e-02f, -6.46756962e-02f, 2.60410123e-02f,
  6.52840734e-02f, 4.23331447e-02f, 7.80592039e-02f, -4.66688201e-02f, -1.15641542e-01f, -5.07243760e-02f, -1.97634604e-02f, 1.45833166e-02f, 9.39418077e-02f, 8.37112069e-02f,
  -7.39861429e-02f, 7.40475729e-02f, -1.05742447e-01f, 8.54812264e-02f, -1.35687441e-01f, 9.11994427e-02f, 3.60476784e-02f, -4.97611091e-02f, 6.01855926e-02f, 4.67668846e-02f,
  -5.13010062e-02f, 3.87969539e-02f, 4.74951640e-02f, -5.15170954e-02f, 6.11974299e-02f, -3.89523581e-02f, -4.50526588e-02f, -3.27297188e-02f, -6.26657298e-03f, 1.72214524e-03f,
  -5.27382419e-02f, -5.67879751e-02f, -2.31558047e-02f, 1.20760761e-02f, 9.03820340e-03f, 6.93578422e-02f, 1.53312208e-02f, -1.72565021e-02f, -5.18332794e-02f, -1.89331621e-02f,
  -4.20150533e-02f, -4.69150469e-02f, -3.67080234e-02f, 2.18360405e-02f, 1.06172785e-01f, -3.02232038e-02f, -9.37239453e-02f, -4.60606851e-02f, 3.97387110e-02f, -1.69999469e-02f,
  2.02098519e-01f, 5.05027957e-02f, 1.51550740e-01f, 3.46925147e-02f, 2.50295885e-02f, 3.49363647e-02f, 6.51685447e-02f, 3.51250172e-02f, 4.43607979e-02f, 7.05195963e-02f,
  -6.76062703e-02f, 3.04944813e-03f, -8.05891454e-02f, -3.12076509e-02f, 4.09763195e-02f, 1.02067932e-01f, 7.70105720e-02f, -7.91771933e-02f, -7.33176619e-02f, -4.60626977e-03f,
  1.69348139e-02f, 6.77490234e-03f, -1.74284074e-02f, 1.87005568e-02f, -3.29212546e-02f, 3.77958380e-02f, -2.98154484e-02f, 9.84966941e-03f, -1.17900372e-01f, 2.71684453e-02f,
  -3.86459269e-02f, -2.67225415e-01f, -3.81301850e-01f, -3.56286824e-01f, -9.97991581e-03f, -3.58470708e-01f, -1.82551369e-01f, -4.65604663e-02f, -1.69120625e-01f, 2.65696943e-01f,
  8.21367279e-02f, -2.68686473e-01f, 2.36477628e-01f, -3.98789316e-01f, -6.11591697e-01f, -2.50682116e-01f, -4.33583111e-01f, -3.29266071e-01f, -1.14916913e-01f, -1.04539044e-01f,
  -1.88877299e-01f, -1.29422978e-01f, -3.68080229e-01f, 1.28014028e-01f, -1.71507969e-01f, 8.16551521e-02f, 3.28597814e-01f, 2.55012393e-01f, -2.29710162e-01f, -1.21062860e-01f,
  5.51406965e-02f, 6.87667057e-02f, -2.98227593e-02f, -2.61584129e-02f, 7.97276795e-02f, 2.29511082e-01f, -3.53088677e-02f, -8.74282047e-02f, -1.37848958e-01f, -6.55891225e-02f,
  -2.30517518e-02f, 1.15761282e-02f, -9.14888903e-02f, 3.23425159e-02f, 7.13177770e-02f, -4.62219194e-02f, -1.67965978e-01f, -3.93230207e-02f, -1.22409604e-01f, -6.61750138e-02f,
  -6.53129369e-02f, -1.11608870e-01f, -4.98082303e-02f, -1.20877035e-01f, -1.34894863e-01f, -1.41012017e-02f, -9.58701596e-03f, -3.78474928e-02f, -4.82602045e-02f, -8.53128582e-02f,
  8.56814682e-02f, 1.17033899e-01f, -6.23837821e-02f, -2.47434396e-02f, 1.88216101e-03f, 4.38457467e-02f, -1.65040456e-02f, 4.62634563e-02f, -1.07286647e-01f, 4.80760336e-02f,
  -1.76575854e-02f, -1.08630583e-01f, 9.33020040e-02f, -1.36141339e-02f, -6.95788339e-02f, 1.04695940e-02f, 4.64941971e-02f, -1.09778168e-02f, -5.05737960e-02f, -1.69158444e-01f,
  4.41658609e-02f, 7.45613649e-02f, -3.71512622e-02f, 1.11815326e-01f, -5.15494309e-02f, 6.36064783e-02f, 7.22323805e-02f, -7.49907270e-02f, 1.17894066e-02f, 7.57441297e-02f,
  1.84198003e-02f, 2.56804734e-01f, 2.13434659e-02f, -9.02391076e-02f, 2.54080910e-02f, 5.44436388e-02f, -3.85519154e-02f, -1.15018897e-01f, -1.24630211e-02f, 3.61204334e-02f,
  9.32330191e-02f, -3.06290891e-02f, -4.02542157e-03f, -2.59701014e-02f, -1.76216774e-02f, 5.46888188e-02f, 9.93062109e-02f, -4.40136455e-02f, -1.04273625e-01f, 1.40737905e-03f,
  1.11194111e-01f, 3.89484502e-02f, 1.30390516e-03f, 6.81216866e-02f, 1.01012126e-01f, 4.59099887e-03f, -6.79998100e-02f, -2.55087018e-02f, 1.65150072e-02f, -5.71076684e-02f,
  5.24471283e-01f, 2.77526915e-01f, 3.77365530e-01f, 4.64494199e-01f, -9.02706608e-02f, -1.92244187e-01f, -6.46182075e-02f, 1.36909168e-02f, 1.03269637e-01f, -9.32731181e-02f,
  -1.27625793e-01f, 2.31259748e-01f, -1.02601446e-01f, 2.57846445e-01f, -2.71839410e-01f, -1.38257846e-01f, 1.41262487e-01f, 4.59118411e-02f, 1.66751761e-02f, 2.64102012e-01f,
  9.26445797e-02f, -1.89059228e-01f, 1.27273217e-01f, -2.44942337e-01f, 3.13936412e-01f, 2.12145194e-01f, -1.71801925e-01f, -1.13450892e-01f, 1.91124648e-01f, -1.90437630e-01f,
  -5.24584800e-02f, 1.49996758e-01f, 8.85901749e-02f, 1.47921303e-02f, 6.94098398e-02f, 2.20167600e-02f, 1.32828383e-02f, -1.06496751e-01f, -1.48274377e-01f, 4.16918062e-02f,
  1.05721233e-02f, -8.63994285e-03f, 5.97407594e-02f, -6.64420575e-02f, -1.95884574e-02f, 8.67193788e-02f, 1.96315631e-01f, 8.07870477e-02f, 6.06571138e-02f, 7.44739473e-02f,
  1.75215509e-02f, 1.08421758e-01f, 1.23245969e-01f, 5.67131862e-03f, 1.83717422e-02f, 7.61965513e-02f, -5.95393181e-02f, 2.35773195e-02f, -1.11798616e-02f, 9.53410342e-02f,
  4.60638069e-02f, -4.07447293e-02f, -1.15417838e-01f, -7.34621137e-02f, -7.32995644e-02f, -5.16701527e-02f, 8.57310928e-03f, 1.99215370e-03f, -1.23624250e-01f, -2.22076960e-02f,
  -3.51260938e-02f, 4.38393988e-02f, -1.18518323e-01f, 7.04877302e-02f, 1.22506015e-01f, -5.94375003e-03f, 5.64318784e-02f, 2.26100162e-02f, 1.13791600e-01f, 9.13680121e-02f,
  -1.61429167e-01f, -1.07857756e-01f, 6.65953085e-02f, 2.58450699e-03f, -1.10624030e-01f, -5.56986593e-02f, 7.20445439e-02f, 1.16160780e-01f, -6.41160235e-02f, 1.09555619e-02f,
  -9.43686068e-02f, 2.73913294e-02f, 5.81721142e-02f, -5.44425771e-02f, -4.04321328e-02f, 3.15920264e-03f, -6.76878914e-02f, 8.51840451e-02f, -4.91849706e-03f, -7.12013384e-03f,
  1.61877032e-02f, -9.41592008e-02f, -8.01849291e-02f, 8.58053714e-02f, -1.90875854e-03f, 7.13643059e-02f, -2.72602629e-04f, -1.77252740e-02f, -4.73599248e-02f, 6.06948212e-02f,
  1.19253397e-02f, -4.50973585e-02f, -8.28257650e-02f, 7.94096813e-02f, -5.50199766e-04f, 5.73803373e-02f, -1.00250235e-02f, 1.38290882e-01f, -1.72199830e-02f, 1.16407620e-02f,
  1.26446366e-01f, -3.79051328e-01f, 5.60735129e-02f, -1.23338588e-01f, -5.81846535e-02f, -1.30820647e-01f, 7.72326365e-02f, -4.60788667e-01f, -2.84274638e-01f, -2.79558808e-01f,
  -2.99965795e-02f, 3.62396210e-01f, 3.81386578e-01f, -3.31685841e-01f, 5.80032349e-01f, 2.80662537e-01f, -2.66076773e-01f, 8.95555690e-02f, -7.66823143e-02f, -1.86036676e-01f,
  -3.96685936e-02f, -2.91693538e-01f, 1.33264571e-01f, -4.61411238e-01f, -2.29213923e-01f, -2.22135112e-01f, 7.30540082e-02f, 1.44452766e-01f, -1.64586678e-01f, 1.37475714e-01f,
  -2.95469850e-01f, -3.13655615e-01f, -1.09164730e-01f, -9.43353921e-02f, -1.64793119e-01f, -3.21844332e-02f, 5.62812574e-02f, 2.05538824e-01f, -2.38561723e-02f, 2.40019914e-02f,
  6.34341314e-02f, -3.42107639e-02f, -1.29567862e-01f, 9.48047936e-02f, -1.39238492e-01f, -1.66861743e-01f, -5.72296344e-02f, -5.60265481e-02f, -9.28013399e-02f, 1.32402748e-01f,
  6.09117188e-02f, -1.49864312e-02f, -8.42852741e-02f, 3.42041366e-02f, 4.04193364e-02f, -1.50780082e-01f, -2.67306790e-02f, 1.95958227e-01f, -1.10515850e-02f, -8.84672329e-02f,
  -3.94942351e-02f, -1.91985455e-03f, -7.62374178e-02f, -7.81043665e-03f, -2.08650120e-02f, -5.50222509e-02f, -2.06884518e-02f, 7.71087259e-02f, 1.62999015e-02f, -1.50539996e-02f,
  1.21499375e-02f, -2.09659375e-02f, -1.00685373e-01f, 4.10307571e-02f, -2.93042157e-02f, -6.08624257e-02f, 6.94535449e-02f, 2.47739013e-02f, -6.09816425e-02f, 2.73485351e-02f,
  8.43487680e-02f, 3.41006145e-02f, -1.13322325e-02f, 2.79789455e-02f, -1.11437969e-01f, 7.68644214e-02f, -5.84539063e-02f, -2.43301480e-03f, 5.08035347e-02f, 1.38348505e-01f,
  -2.04840526e-01f, -2.97070801e-01f, -7.77207762e-02f, -4.52775061e-02f, -3.34637463e-02f, -4.94136028e-02f, -2.52159256e-02f, -8.52348879e-02f, -5.51426783e-02f, -7.16505945e-02f,
  -4.14637141e-02f, 4.19681594e-02f, -9.54708233e-02f, 6.26129806e-02f, 1.06614288e-02f, -6.63272589e-02f, 5.90871833e-02f, 1.77780874e-02f, 8.61119330e-02f, -9.42564458e-02f,
  3.05994395e-02f, 3.59001346e-02f, 7.05565438e-02f, -5.33769391e-02f, -5.40767871e-02f, 9.74511206e-02f, -3.05857626e-03f, -7.43808597e-02f, 2.07851399e-02f, -3.88011597e-02f,
  -4.98215258e-01f, -4.27035183e-01f, 1.65564016e-01f, -1.04523569e-01f, 3.66841704e-01f, 3.52063090e-01f, -7.38243461e-02f, 2.19406605e-01f, -1.79463565e-01f, -3.48330647e-01f,
  -9.11196247e-02f, -1.85785592e-01f, -2.38559052e-01f, 1.70300663e-01f, 4.77150947e-01f, 1.76119879e-02f, 2.08525360e-01f, -4.30153422e-02f, 1.22800678e-01f, -2.10523486e-01f,
  6.88088760e-02f, 2.51201153e-01f, 1.87703118e-01f, 1.41193494e-01f, 1.07810937e-01f, -6.46010637e-02f, -1.55574292e-01f, 1.55264139e-02f, 2.17881143e-01f, 1.46533906e-01f,
  -1.56075314e-01f, -4.64765638e-01f, -2.28258893e-01f, -1.03879854e-01f, 4.65290099e-02f, -2.06176206e-01f, -8.76994804e-02f, -1.59150790e-02f, -4.73695025e-02f, 2.47780010e-02f,
  -8.04337040e-02f, 4.59882282e-02f, 1.10931933e-01f, 3.71469297e-02f, 1.88049320e-02f, 1.52819352e-02f, 2.10038051e-02f, 1.48000583e-01f, -2.01131236e-02f, 6.95210546e-02f,
  6.09748438e-02f, 1.00238785e-01f, 5.05704135e-02f, 1.48277715e-01f, 1.68369263e-01f, 8.31424147e-02f, 1.80396009e-02f, 2.34707687e-02f, 1.02065198e-01f, 7.90103674e-02f,
  -7.89391156e-03f, -5.75171635e-02f, -1.24993764e-01f, 1.64225884e-02f, -2.59159561e-02f, 9.99746174e-02f, 8.11229926e-03f, 2.95810308e-02f, -3.01207956e-02f, 8.30140710e-02f,
  9.57682729e-02f, 1.51670221e-02f, 8.86022486e-03f, -8.10753927e-02f, -5.61208837e-02f, -1.16328150e-02f, -2.69404501e-02f, 3.66694331e-02f, 3.32287624e-02f, 8.67465883e-02f,
  -5.61958663e-02f, 4.42763306e-02f, -2.41750628e-02f, -2.01206421e-03f, -1.15635574e-01f, -1.21224232e-01f, -9.56529472e-03f, 1.83931682e-02f, -8.06519911e-02f, -2.96949726e-02f,
  -7.17493117e-01f, -4.31165308e-01f, -1.84627287e-02f, 6.37402609e-02f, -6.27038702e-02f, -3.08020543e-02f, -4.33064103e-02f, -8.18401668e-03f, -1.16207510e-01f, -7.79124498e-02f,
  -9.29219425e-02f, 1.96846630e-02f, -7.69151375e-02f, -3.87479253e-02f, 6.62861243e-02f, 2.44342778e-02f, -1.37330860e-01f, -2.09781453e-01f, -1.02794349e-01f, 2.97896028e-03f,
  4.20514308e-02f, -4.22536209e-02f, 1.54021859e-01f, 4.04198989e-02f, -3.32941860e-02f, 5.88248335e-02f, -6.49679825e-02f, -3.26416502e-03f, 7.39603043e-02f, 1.07467398e-01f,
  1.02054596e-01f, 2.76533455e-01f, 1.13730811e-01f, 1.65451635e-02f, -1.00653209e-01f, -1.00058094e-01f, 3.86221409e-02f, 4.62211519e-02f, 8.81202817e-02f, 3.63411903e-01f,
  -1.08416446e-01f, 4.43080783e-01f, -7.24180182e-03f, -8.37852433e-02f, -4.10493374e-01f, -3.52447659e-01f, -3.11968327e-01f, 1.10102624e-01f, -1.71404611e-02f, 1.59196734e-01f,
  -3.09078217e-01f, -3.88729155e-01f, -1.84436098e-01f, -7.16783330e-02f, 2.20873237e-01f, 3.26788574e-01f, -8.15957561e-02f, 7.34114870e-02f, 1.43996209e-01f, -1.18411034e-01f,
  2.48147231e-02f, 7.08385631e-02f, 1.88586980e-01f, 1.11561902e-01f, -2.72032898e-02f, 9.65765342e-02f, 4.61098179e-02f, 1.82005782e-02f, -6.84900060e-02f, 1.05631582e-01f,
  8.91806185e-02f, 4.92512472e-02f, 2.14908663e-02f, 7.72284940e-02f, 1.32786348e-01f, 1.23471469e-01f, 1.32799344e-02f, 1.42508382e-02f, 1.02318473e-01f, 9.64226127e-02f,
  8.25507641e-02f, 8.86822212e-03f, -5.21121286e-02f, 6.05857000e-03f, -1.86605547e-02f, 5.45978807e-02f, 3.69084738e-02f, -1.70462101e-03f, 1.10443167e-01f, -2.08407715e-02f,
  -7.79356137e-02f, -4.03511710e-02f, 1.93252284e-02f, 2.79909689e-02f, 9.30016264e-02f, 1.51001243e-02f, 3.12485528e-04f, 2.30597798e-02f, -2.03438476e-02f, 7.52915908e-03f,
  -7.36203864e-02f, 1.67670324e-01f, -9.65305343e-02f, 7.99716711e-02f, -8.13400373e-02f, 1.14961386e-01f, -8.64513218e-02f, 8.49663652e-03f, -7.92556405e-02f, 8.77184272e-02f,
  -9.62461159e-02f, -6.74261376e-02f, 1.09868899e-01f, 4.72779311e-02f, -6.81181625e-02f, -1.40927834e-02f, -1.94065515e-02f, 1.10222504e-01f, 3.11711989e-02f, -1.11381695e-01f,
  -8.82429853e-02f, 3.96991335e-03f, -1.38484817e-02f, 8.93206000e-02f, -6.08051254e-04f, 4.50325310e-02f, -1.10617645e-01f, 1.55593812e-01f, -4.48419750e-02f, 3.49269360e-02f,
  -4.96349744e-02f, 1.34070471e-01f, 3.59061807e-02f, -4.39750962e-02f, -5.13678789e-02f, -8.58987570e-02f, -7.32252747e-02f, -7.16675222e-02f, 5.36534451e-02f, 1.00058421e-01f,
  1.10938683e-01f, -3.65165509e-02f, 5.75967953e-02f, -6.13592342e-02f, -2.86321398e-02f, -5.28526083e-02f, 3.84455360e-02f, 1.04436122e-01f, 1.87673769e-03f, -1.38807520e-01f,
  -6.67722404e-01f, 3.21842432e-01f, -1.53977782e-01f, -8.63805786e-02f, -1.79033689e-02f, -3.13435912e-01f, -1.05969183e-01f, -4.19493653e-02f, -1.91889200e-02f, 2.59564102e-01f,
  2.61474907e-01f, -1.81303218e-01f, 3.25059563e-01f, 2.86191404e-01f, -4.65293437e-01f, 2.77116328e-01f, -1.42018676e-01f, -3.86986732e-02f, 3.67691219e-02f, -9.82631743e-02f,
  -2.31720999e-01f, 3.23284566e-01f, 5.48577011e-02f, 2.50742078e-01f, -1.53069735e-01f, -9.11500230e-02f, -6.03758823e-03f, 1.20123826e-01f, -6.12682886e-02f, -3.86370346e-02f,
  -5.13766766e-01f, -1.90714806e-01f, -9.98838246e-02f, -1.40945345e-01f, -2.28236824e-01f, -1.58465311e-01f, -7.12104887e-02f, 4.14912365e-02f, -4.04948965e-02f, -4.30080518e-02f,
  -5.93118295e-02f, -2.35231929e-02f, 1.13784969e-01f, 7.68435672e-02f, -1.48289815e-01f, -3.53719443e-02f, 1.85150132e-02f, 3.30433771e-02f, 8.27634707e-03f, -7.66264647e-02f,
  5.95674552e-02f, -2.61308830e-02f, -3.51238735e-02f, 4.44820859e-02f, 1.25487940e-02f, 3.83498780e-02f, 3.51133309e-02f, -4.52429391e-02f, -1.38496175e-01f, -1.34793773e-01f,
  3.83839235e-02f, -6.34535700e-02f, -6.26678113e-03f, 1.79317463e-02f, 1.39421616e-02f, 8.84921178e-02f, -3.75379287e-02f, 6.85103238e-02f, -6.12844639e-02f, -2.30137724e-02f,
  4.62896377e-02f, -5.21202944e-02f, 1.57650616e-02f, -1.03640761e-02f, -4.73324582e-02f, -5.85016422e-02f, 6.96910024e-02f, -6.48490041e-02f, 5.50653145e-04f, -6.01708703e-02f,
  1.45686409e-02f, 1.27603663e-02f, 6.13872409e-02f, 3.04405461e-03f, -1.73537750e-02f, 2.35381052e-02f, -1.66646820e-02f, 1.64254922e-02f, -3.63791585e-02f, -1.90321896e-02f,
  -7.25923896e-01f, -4.68799114e-01f, 4.40529026e-02f, -1.29747152e-01f, -8.06137994e-02f, -6.64447471e-02f, -3.07439524e-03f, -4.44892421e-02f, -1.44316375e-01f, -3.67133096e-02f,
  -6.90032467e-02f, -4.02374156e-02f, -1.37425318e-01f, 6.65597767e-02f, 5.75350411e-02f, -3.40091437e-02f, -4.26735282e-02f, 1.27107638e-03f, -1.30584389e-01f, -6.55263513e-02f,
  -3.01761534e-02f, 3.71323228e-02f, -2.50234250e-02f, 5.08219674e-02f, -1.91551298e-02f, -4.92131673e-02f, -1.02135748e-01f, 5.75923398e-02f, -2.27977540e-02f, 9.76174604e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.97030503e-01f, 2.12425247e-01f, 3.70122343e-01f, 3.26640874e-01f, 3.07764828e-01f, 1.46842763e-01f, 3.48714590e-01f, 3.53813052e-01f, 3.62335384e-01f, 2.12360978e-01f,
  2.92779565e-01f, 5.21258950e-01f, 1.45052552e-01f, 2.04301342e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -8.70004594e-02f, -9.46860090e-02f, -1.17574073e-01f, -1.56010827e-02f, -9.19305757e-02f, -7.35775232e-02f, -1.67243227e-01f, 3.61751728e-02f, -2.59181470e-01f, 2.05561370e-02f,
  -5.68389595e-02f, 2.27219649e-02f, 6.34452030e-02f, 1.10819042e-01f, -1.06823258e-01f, -3.36326621e-02f, -1.57509997e-01f, -5.65734208e-02f, -1.36740610e-01f, -2.71618694e-01f,
  2.36318409e-02f, -2.74545122e-02f, -1.31073192e-01f, -2.52443314e-01f, -8.21759477e-02f, -1.21884339e-01f, 9.70612019e-02f, -1.95062295e-01f, 1.08919993e-01f, -1.78466588e-01f,
  -2.24634148e-02f, -1.38216749e-01f, -1.79730877e-01f, -5.40905639e-05f, 2.24503756e-01f, 1.28592938e-01f, -8.31880644e-02f, -1.61611870e-01f, -6.41770586e-02f, -2.65840352e-01f,
  1.51489839e-01f, -2.10659117e-01f, 1.65903389e-01f, -6.57487661e-02f, -1.34051936e-02f, -2.59918809e-01f, -6.02388196e-02f, -2.80855000e-01f, -1.34711400e-01f, 1.31256431e-01f,
  2.77711213e-01f, -4.29339781e-02f, 1.62329301e-01f, -3.02495301e-01f, -6.45326674e-02f, 1.23659000e-01f, 3.20846498e-01f, 2.20971610e-02f, -1.26087666e-02f, 1.11503236e-01f,
  -3.25497240e-01f, 1.50797904e-01f, 7.33776018e-02f, 3.51380706e-01f, 1.02313407e-01f, 1.74369290e-01f, 9.47243720e-02f, 1.22449204e-01f, -6.81847110e-02f, 1.04160935e-01f,
  3.28838341e-02f, -1.39892086e-01f, 1.19114414e-01f, 1.22179464e-01f, -1.20371610e-01f, 2.04932570e-01f, -6.29140362e-02f, 4.12235744e-02f, 1.06605135e-01f, -2.09992845e-02f,
  5.51626310e-02f, -2.41152886e-02f, 1.37058303e-01f, 4.88620065e-02f, 2.78544903e-01f, 5.37536442e-02f, -3.35144028e-02f, 4.41100672e-02f, 2.04232395e-01f, -2.97866613e-01f,
  2.69719005e-01f, 1.76651463e-01f, -2.00596750e-02f, 7.22998679e-02f, -1.56676635e-01f, 2.15281770e-01f, 1.56815961e-01f, -7.64066279e-02f, -1.57615244e-01f, -2.25613900e-02f,
  -1.16052739e-01f, -1.86571628e-01f, 1.68837085e-01f, 6.53091669e-02f, -1.64352015e-01f, -9.51203406e-02f, 1.24501184e-01f, -1.31049767e-01f, -1.55585483e-02f, -5.05439118e-02f,
  -3.49055068e-03f, 5.80168189e-03f, 7.08055049e-02f, 1.44238204e-01f, 1.68088600e-01f, 2.11675987e-01f, 8.03665221e-02f, -1.25760406e-01f, -1.93159893e-01f, 2.07553655e-01f,
  1.28523275e-01f, -2.97461171e-02f, 1.29434410e-02f, 1.73564434e-01f, 1.68447286e-01f, -3.80427808e-01f, 1.49644777e-01f, 1.37899175e-01f, 5.49071142e-03f, 2.41804030e-02f,
  5.79869710e-02f, -1.27987564e-01f, -1.30099386e-01f, 6.30792007e-02f, -1.61400035e-01f, 1.52069122e-01f, -5.80376573e-02f, 1.77053586e-02f, 4.63004597e-02f, 5.61323278e-02f,
  1.78949848e-01f, -3.39547023e-02f, -1.05383947e-01f, -9.54110101e-02f, 4.82827425e-02f, -7.76621606e-03f, -1.03079148e-01f, -5.43957762e-02f, -1.78821221e-01f, -2.11617425e-01f,
  1.30889937e-01f, -1.31276920e-01f, -6.08985138e-04f, 1.91674426e-01f, 3.21756043e-02f, -1.39089465e-01f, 1.55398950e-01f, -2.56819189e-01f, -3.50670144e-02f, 1.97652891e-01f,
  -3.26330513e-01f, 2.60857761e-01f, 2.74466544e-01f, 1.36930615e-01f, -1.91231608e-01f, 1.03480890e-01f, -5.96171292e-03f, 2.74389833e-02f, 9.40398201e-02f, -3.07833701e-01f,
  -1.85418036e-02f, 7.57946894e-02f, 1.43176138e-01f, 2.44248196e-01f, 6.97149336e-03f, -5.01240008e-02f, 6.30386397e-02f, 2.32191116e-01f, 2.12445527e-01f, 2.50283599e-01f,
  1.18186455e-02f, 8.40983726e-03f, -1.67813495e-01f, -1.66969281e-02f, 3.72500122e-02f, 3.95525932e-01f, 3.74498963e-02f, 6.49981722e-02f, -4.12053436e-01f, 1.48299076e-02f,
  5.07087037e-02f, 2.91448653e-01f, -1.08903520e-01f, -1.13811582e-01f, -1.58624956e-03f, 2.76981816e-02f, 1.73798472e-01f, -1.75391391e-01f, -4.12230976e-02f, -8.61121416e-02f,
  1.18777901e-02f, -3.36437039e-02f, -2.56150305e-01f, -1.42107099e-01f, 4.07751240e-02f, 4.59659062e-02f, -1.24481823e-02f, -4.12544087e-02f, 7.56991282e-02f, 1.29897848e-01f,
  2.99266297e-02f, -1.53304366e-02f, 6.70948997e-02f, -9.48276073e-02f, 1.14832977e-02f, -1.06643811e-02f, 5.56103438e-02f, 3.34742963e-01f, -1.60732552e-01f, 1.28566876e-01f,
  2.72653222e-01f, -2.42036000e-01f, 9.67818275e-02f, -1.95430264e-01f, 2.36804649e-01f, 2.49242619e-01f, 1.03325255e-01f, -2.51532108e-01f, -1.36273235e-01f, 1.63739458e-01f,
  -2.14634284e-01f, 2.79063374e-01f, -2.17802718e-01f, -6.64319750e-03f, 2.37282872e-01f, 2.27123126e-01f, -7.09477291e-02f, 1.10362098e-01f, -8.79744664e-02f, 2.20983461e-01f,
  2.55993873e-01f, 5.94196059e-02f, -3.09175644e-02f, -1.19879499e-01f, 9.97455642e-02f, -9.93795507e-03f, 7.39159202e-03f, -1.09346360e-01f, -1.67272463e-01f, 1.20937273e-01f,
  1.73385203e-01f, -1.71145990e-01f, -4.48960103e-02f, 4.76589911e-02f, -7.21108168e-02f, 1.96292713e-01f, -1.09345600e-01f, -3.62776108e-02f, 1.61577806e-01f, 6.86353818e-02f,
  1.28303260e-01f, 1.60261929e-01f, 1.17437385e-01f, -1.04768455e-01f, 3.19798976e-01f, -6.94755390e-02f, -1.11464642e-01f, -4.14256267e-02f, -1.36518970e-01f, 1.49088234e-01f,
  8.17923918e-02f, 1.64848372e-01f, 1.09095953e-01f, -1.48564011e-01f, 8.16864148e-02f, 1.66260287e-01f, 1.90033183e-01f, -4.84268507e-03f, -8.49999264e-02f, 7.86542147e-02f,
  1.88766778e-01f, 6.58301637e-02f, 2.00637907e-01f, 2.24587992e-01f, 1.36214778e-01f, 4.90359887e-02f, 5.83127066e-02f, 2.80509114e-01f, 2.37394765e-01f, 8.43897983e-02f,
  -2.23864704e-01f, -1.21500269e-01f, -1.75820172e-01f, 5.77878766e-03f, 9.83378068e-02f, 1.54603243e-01f, -3.26920152e-01f, -2.53566336e-02f, 1.97364837e-01f, 6.99446630e-03f,
  -1.10824630e-01f, 2.42026195e-01f, -1.19714469e-01f, 9.57877934e-02f, 2.26814061e-01f, 1.04718596e-01f, 6.15598857e-02f, 2.37794474e-01f, 2.59480961e-02f, 3.92130725e-02f,
  -5.41507676e-02f, 9.76360738e-02f, 6.14954568e-02f, -8.29275418e-03f, 2.82660834e-02f, 4.37946804e-02f, -1.02896787e-01f, -2.95565486e-01f, 1.63574487e-01f, 5.15420102e-02f,
  -1.03847586e-01f, -4.28044200e-02f, 9.18039829e-02f, -8.51653069e-02f, 2.29894042e-01f, 6.73269182e-02f, 4.64941077e-02f, 2.02812463e-01f, -1.49573728e-01f, -1.32808844e-02f,
  -4.97384369e-02f, 4.31207120e-02f, -4.73452872e-03f, 5.05373888e-02f, 1.04633145e-01f, 1.04530882e-02f, 1.41907111e-01f, 4.84289676e-02f, -3.42765823e-02f, -1.03678413e-01f,
  6.06242241e-03f, 1.32411033e-01f, -1.60736233e-01f, 7.36710243e-03f, 1.31905824e-01f, 1.13651372e-01f, 1.03126310e-01f, 6.89266324e-02f, -4.19871807e-02f, 1.21101521e-01f,
  2.33702306e-02f, -3.25669609e-02f, 3.54080319e-01f, -1.25100330e-01f, 1.31102994e-01f, -2.93464780e-01f, 7.61592761e-02f, 1.71485454e-01f, 6.71736300e-02f, 1.79833606e-01f,
  -2.77935714e-01f, 1.31449461e-01f, 2.77736485e-01f, 2.53897727e-01f, -1.63168624e-01f, -1.41143203e-02f, -3.45319122e-01f, -1.10596418e-01f, 2.93608814e-01f, -4.14214446e-04f,
  1.77239656e-01f, 6.98140939e-04f, 9.00580436e-02f, 3.17671262e-02f, -1.88542619e-01f, 1.50057495e-01f, 1.31810188e-01f, 2.35830285e-02f, 9.22551975e-02f, 8.17878321e-02f,
  -1.90156884e-02f, -3.14181596e-02f, 1.17379479e-01f, 3.19225758e-01f, -4.18360606e-02f, 9.54490155e-02f, -1.77140832e-01f, 1.48569897e-01f, 2.85166670e-02f, 3.01925577e-02f,
  1.00298025e-01f, -2.01503009e-01f, 9.34273973e-02f, -1.66685581e-01f, 2.45809928e-01f, 1.84682384e-01f, 1.20493941e-01f, -1.15484968e-01f, -1.55648977e-01f, -1.42501175e-01f,
  1.65582418e-01f, -7.18433782e-02f, 1.22498967e-01f, -5.80182783e-02f, 2.12075457e-01f, 1.35742396e-01f, 1.34881422e-01f, -1.30487025e-01f, -1.67479947e-01f, -1.72691673e-01f,
  -2.49412119e-01f, -3.37856859e-02f, -3.19691181e-01f, 1.75989941e-01f, -3.18230182e-01f, -6.80076182e-02f, 8.29965696e-02f, -3.08927447e-01f, -1.36600062e-01f, 9.32880417e-02f,
  1.61853969e-01f, 1.77385569e-01f, 1.73305362e-01f, -1.58935770e-01f, 9.48697701e-02f, -1.17907748e-01f, -2.59782821e-01f, -2.48238057e-01f, -1.75369069e-01f, -1.20599203e-01f,
  3.40534784e-02f, 1.75644055e-01f, -1.26801074e-01f, -2.53022075e-01f, -9.61255431e-02f, -2.70718902e-01f, -1.47737652e-01f, -8.73371363e-02f, -1.08410932e-01f, 2.65098549e-02f,
  -1.60034209e-01f, -3.33543837e-01f, 3.15845162e-01f, -1.36542022e-01f, 3.27089906e-01f, -6.03270195e-02f, -5.84608838e-02f, -3.45616311e-01f, 1.82186160e-02f, 2.46212222e-02f,
  -2.60169990e-03f, -2.29575112e-02f, 1.70542598e-01f, 6.88636675e-02f, 8.48017931e-02f, -1.24881752e-02f, 2.01451883e-01f, 8.15734118e-02f, -1.78507715e-01f, -1.49329394e-01f,
  -3.52201797e-02f, 3.58248278e-02f, -1.24107469e-02f, 5.73777221e-02f, 1.37119126e-02f, 8.25741366e-02f, 1.28583014e-02f, 5.60534112e-02f, 2.15840489e-02f, -3.28003131e-02f,
  1.87589571e-01f, 1.85275748e-01f, 2.69597732e-02f, 2.92027712e-01f, 4.23194049e-03f, 1.78385422e-01f, 5.88147491e-02f, -2.28005454e-01f, 1.55837387e-01f, 1.30721718e-01f,
  2.39613488e-01f, 2.53044516e-01f, -9.24460292e-02f, -2.81834036e-01f, -1.48886278e-01f, 1.53274506e-01f, -1.21148400e-01f, 2.44038701e-01f, -2.23977238e-01f, 1.57420728e-02f,
  1.85014874e-01f, 1.95024535e-01f, 8.20801854e-02f, 1.94749892e-01f, -1.55467421e-01f, 1.73538089e-01f, 1.87405467e-01f, -3.46606132e-03f, -2.13412978e-02f, -1.07347695e-02f,
  -1.32021695e-01f, 4.13965099e-02f, 4.18628938e-02f, -1.64537311e-01f, -5.93039505e-02f, 1.12096950e-01f, 1.99959889e-01f, -1.34106860e-01f, -2.09304765e-01f, 1.33803278e-01f,
  2.23398834e-01f, 1.76297501e-01f, -6.15049228e-02f, -1.01110980e-01f, 6.00681938e-02f, -5.97455576e-02f, 2.24846393e-01f, 9.94469523e-02f, -3.26363407e-02f, -2.73302849e-02f,
  7.16634244e-02f, -6.79160580e-02f, -1.09796681e-01f, 2.05325969e-02f, -1.19665109e-01f, 1.11875258e-01f, 5.74208573e-02f, -1.08260743e-01f, 2.17139535e-03f, 1.47334009e-01f,
  -3.14429998e-02f, 4.84963320e-02f, 1.86541498e-01f, 1.60170626e-02f, -1.52210936e-01f, -3.98813933e-02f, 4.98192199e-02f, 2.42174596e-01f, -2.64725480e-02f, 2.48224258e-01f,
  9.47886258e-02f, -7.45490789e-02f, 1.29841967e-02f, 7.76190162e-02f, 2.43804857e-01f, 8.03384632e-02f, 1.31522328e-01f, -2.73300469e-01f, 2.85826046e-02f, 1.46658197e-01f,
  -7.84055516e-02f, 3.00660700e-01f, -2.23687842e-01f, 1.20905504e-01f, 1.75528049e-01f, 1.09628096e-01f, -1.60816103e-01f, -2.50079799e-02f, -2.54888952e-01f, -6.39363229e-02f,
  3.70311618e-01f, -1.25597343e-01f, 1.18200622e-01f, 3.01560350e-02f, 1.09669901e-01f, 5.03690541e-02f, -1.83241606e-01f, 1.72615170e-01f, 1.66137040e-01f, -8.41587633e-02f,
  3.83150242e-02f, 2.32551359e-02f, -2.82423705e-01f, -1.07614137e-01f, 1.53553441e-01f, 3.19316387e-01f, -1.47001952e-01f, -1.46752074e-01f, -2.88157105e-01f, 5.36877178e-02f,
  -1.08033657e-01f, 3.27005200e-02f, 1.50487944e-01f, -5.78315854e-02f, -2.68414188e-02f, -2.60205679e-02f, -1.95488825e-01f, -5.16955703e-02f, 6.28785715e-02f, -2.88365725e-02f,
  -8.55243430e-02f, -1.37723565e-01f, -1.44996986e-01f, -7.30461255e-02f, 1.17486589e-01f, 9.37078893e-02f, -1.19117717e-03f, 8.68171379e-02f, -1.22514501e-01f, 2.58198362e-02f,
  -8.52229353e-03f, 1.30463719e-01f, -1.96724787e-01f, 1.78738967e-01f, -5.36750071e-02f, 2.76164770e-01f, 1.15915231e-01f, -1.72534361e-01f, 2.31295660e-01f, -2.62234390e-01f,
  -2.81228006e-01f, -1.45708337e-01f, 2.04909593e-01f, -1.38374239e-01f, -1.56698272e-01f, -1.19517352e-02f, -1.89642549e-01f, 9.89678353e-02f, 2.32388109e-01f, 3.85543983e-03f,
  -2.79710561e-01f, -2.10706398e-01f, -2.08506092e-01f, 1.22999497e-01f, 2.31687069e-01f, -3.71966250e-02f, 9.28828269e-02f, -1.74541324e-01f, 4.50667553e-02f, -1.28006995e-01f,
  1.50595635e-01f, 7.27478042e-02f, -9.60255042e-02f, -2.35120252e-01f, 2.66063754e-02f, -6.38082772e-02f, 4.77012806e-02f, 2.40550749e-02f, -3.47042941e-02f, 1.74958885e-01f,
  -1.23015959e-02f, -9.50986966e-02f, 8.87426808e-02f, 4.28553969e-02f, 9.25183222e-02f, 5.56516759e-02f, 6.50692806e-02f, 4.62237746e-02f, -1.01223111e-01f, -1.10864505e-01f,
  6.38264269e-02f, -1.65927097e-01f, 1.34970592e-02f, -4.95009832e-02f, -1.69336870e-01f, 5.66730415e-03f, 5.84729798e-02f, 2.17224479e-01f, -6.98647350e-02f, 2.43004218e-01f,
  1.62238237e-02f, -7.91161973e-03f, 2.07658991e-01f, 7.31467530e-02f, -1.73739403e-01f, 3.29555392e-01f, -2.73018122e-01f, 2.19732095e-02f, -3.64457816e-02f, 1.72903970e-01f,
  1.70801997e-01f, -1.92307770e-01f, 3.95053402e-02f, 8.64941925e-02f, 5.66820614e-02f, 5.95105253e-03f, 5.58503717e-02f, 1.84436023e-01f, -2.87395090e-01f, 9.71260443e-02f,
  -6.35193214e-02f, 1.29744247e-01f, 7.07481131e-02f, 3.71831030e-01f, 5.89358062e-02f, 2.20449511e-02f, -7.40470290e-02f, 1.76847920e-01f, 1.12745829e-01f, -6.55755848e-02f,
  -2.85438806e-01f, -7.86847100e-02f, -8.69303048e-02f, 1.51993021e-01f, 1.66927963e-01f, -2.27698103e-01f, -1.52242184e-01f, 6.40750974e-02f, 6.49465695e-02f, -2.53555208e-01f,
  9.66662988e-02f, 3.33833694e-01f, -2.06119597e-01f, 2.06186444e-01f, -1.38514321e-02f, 1.02742121e-01f, 2.51597315e-01f, 1.86817572e-02f, -1.95172876e-01f, 2.10179184e-02f,
  -2.48591751e-02f, 2.15046167e-01f, 5.75984679e-02f, 1.78589430e-02f, -1.02833450e-01f, -1.48768947e-01f, 2.10216809e-02f, 7.53236236e-05f, 2.00263485e-01f, 2.04820812e-01f,
  2.62545468e-03f, 4.64420505e-02f, -6.76526455e-03f, -3.96814011e-02f, -7.90707991e-02f, -7.53776357e-02f, 6.36110976e-02f, 2.60003388e-01f, 1.05082460e-01f, 2.32626647e-02f,
  1.08299285e-01f, 1.12228967e-01f, 2.35504299e-01f, -2.46007815e-01f, -4.20824476e-02f, 2.30400994e-01f, -1.80485338e-01f, 3.97783309e-01f, 1.94538191e-01f, 1.76726341e-01f,
  -3.27073753e-01f, 4.75892760e-02f, 6.39467835e-02f, 2.73949523e-02f, 7.80601352e-02f, 4.35383953e-02f, -8.72189552e-02f, 8.03328305e-02f, 2.71908462e-01f, 2.92792380e-01f,
  2.20593989e-01f, 2.92286742e-02f, -5.66551015e-02f, 5.27754724e-02f, -1.81563541e-01f, 2.82486856e-01f, 4.35713679e-02f, 2.07252085e-01f, 4.67186607e-02f, -2.26368293e-01f,
  1.08427890e-02f, 2.11939022e-01f, -4.16261815e-02f, -9.01008397e-02f, 1.21462252e-02f, -1.23017080e-01f, 1.26761690e-01f, -1.43515229e-01f, -6.11569658e-02f, -2.60053482e-02f,
  -3.96410003e-03f, -7.67165348e-02f, 4.68314029e-02f, -4.80117425e-02f, -3.49684060e-02f, -8.33152011e-02f, 3.66341248e-02f, -9.71148014e-02f, -1.04615996e-02f, -1.23828776e-01f,
  -9.24023427e-03f, 1.27503863e-02f, -2.04922110e-02f, -9.01621804e-02f, -1.78746507e-01f, 2.44448021e-01f, -2.70861611e-02f, 7.98131824e-02f, -6.19728714e-02f, -3.68521847e-02f,
  1.86714500e-01f, 1.44321576e-01f, 3.53026800e-02f, 3.81734073e-01f, -2.85128653e-01f, 2.27449134e-01f, -6.45836592e-02f, 2.72328611e-02f, 2.96470284e-01f, -2.26071581e-01f,
  1.50269330e-01f, 2.03395009e-01f, -1.04548730e-01f, -1.21683814e-01f, -1.91177770e-01f, -8.37570950e-02f, -2.69159347e-01f, 2.33461991e-01f, 7.76187852e-02f, 1.13416836e-01f,
  2.67289728e-01f, 9.52517316e-02f, 1.35775447e-01f, 1.99325576e-01f, 1.03981011e-01f, 1.04857430e-01f, -3.45065780e-02f, -2.02769011e-01f, -1.40205428e-01f, -9.02634580e-03f,
  -1.11453608e-01f, -1.91736653e-01f, 1.44396722e-01f, -2.86640406e-01f, -2.69927233e-02f, 1.08236581e-01f, 1.80340469e-01f, -1.42373275e-02f, -1.07568227e-01f, 1.48624107e-01f,
  1.77491799e-01f, 2.44965777e-01f, -1.58637930e-02f, -1.07969813e-01f, 3.08332611e-02f, 1.44924372e-01f, -1.09229229e-01f, 2.38689110e-01f, 1.87045947e-01f, -1.08858883e-01f,
  1.74290717e-01f, -2.03083884e-02f, 4.47662957e-02f, 4.65271920e-02f, -9.60493088e-02f, 1.64801866e-01f, 2.87099276e-02f, 2.46975422e-01f, -6.10178860e-04f, -8.31415430e-02f,
  1.46200255e-01f, 6.38364032e-02f, -4.36415710e-02f, -9.63049680e-02f, -2.21863738e-03f, 2.38638669e-01f, 1.76483229e-01f, -2.34774649e-01f, 1.41172737e-01f, -8.38001259e-03f,
  -2.68781483e-01f, 2.79543519e-01f, -5.47444401e-03f, 2.36673892e-01f, 2.81011194e-01f, -1.82087291e-02f, -3.21970433e-01f, -1.78486750e-01f, -9.51592177e-02f, -6.39521182e-02f,
  1.82708740e-01f, -2.60969307e-02f, 6.14617094e-02f, 4.38690782e-02f, -6.32238761e-02f, -8.42958242e-02f, -5.30043095e-02f, 1.11037283e-03f, 9.51800030e-03f, -5.43672629e-02f,
  -1.83341250e-01f, -1.13045759e-01f, -2.94527095e-02f, 3.46193165e-01f, -5.74999414e-02f, 2.95957047e-02f, 1.76521808e-01f, -1.10453874e-01f, -1.00693792e-01f, -6.34987727e-02f,
  -9.41632539e-02f, -5.58137745e-02f, 2.42194265e-01f, 3.60537469e-02f, 1.78485960e-01f, -9.07118525e-03f, -4.69610328e-03f, -1.39154375e-01f, 3.04758120e-02f, -1.57624092e-02f,
  3.87495086e-02f, -1.38439834e-01f, 6.64016977e-02f, -2.39584055e-02f, 1.55082233e-02f, -1.55693442e-01f, -1.93275779e-01f, 1.34452293e-02f, -5.86367734e-02f, 1.70591161e-01f,
  -1.30212186e-02f, -3.06138039e-01f, -6.39573410e-02f, -1.26883790e-01f, 1.21129490e-01f, -1.05549499e-01f, 4.49421667e-02f, 1.05293961e-02f, -2.44009241e-01f, -4.63427678e-02f,
  -9.71104726e-02f, 1.11542597e-01f, -1.93715200e-01f, 2.71859854e-01f, 2.22378746e-01f, -5.47615588e-02f, -4.29727174e-02f, -1.81086704e-01f, 6.75524697e-02f, -9.25963465e-03f,
  -9.08684805e-02f, -1.78971648e-01f, 1.48222461e-01f, -2.98655871e-02f, -2.35036612e-01f, 2.55468220e-01f, -1.57174945e-01f, 6.47627786e-02f, 3.27878922e-01f, 9.81353968e-02f,
  -3.16950053e-01f, -1.00424297e-01f, -9.65731442e-02f, 2.06802592e-01f, 3.40975910e-01f, 2.31958374e-01f, 1.19685754e-01f, -3.05047203e-02f, 2.35979259e-01f, -1.38913810e-01f,
  -7.18139410e-02f, 6.07777983e-02f, 7.44802039e-03f, 5.57482243e-02f, 9.08924937e-02f, -1.64609868e-02f, -6.33272901e-02f, -8.69247913e-02f, 3.49202007e-02f, 2.21428618e-01f,
  -7.28705525e-02f, -1.71713228e-03f, -2.50401124e-02f, 7.63845593e-02f, 1.44277439e-01f, -1.45079717e-01f, 1.18932940e-01f, -1.17144324e-01f, 1.70729890e-01f, 4.40111943e-02f,
  -1.33551076e-01f, 1.82953537e-01f, -3.26363817e-02f, -7.44551197e-02f, -1.34592846e-01f, -1.50414810e-01f, -1.16691507e-01f, 3.10561480e-03f, 2.00227946e-01f, 1.72313675e-01f,
  -1.05087385e-01f, -3.58491018e-02f, -5.34145012e-02f, 1.53726295e-01f, 2.69352645e-01f, 2.68452406e-01f, -1.02493010e-01f, 8.80561322e-02f, 4.43803295e-02f, 1.52778372e-01f,
  2.51764566e-01f, -2.67749339e-01f, 2.65355706e-01f, -1.97622031e-01f, -2.78142363e-01f, -1.73075125e-01f, -1.54181093e-01f, 4.40905616e-02f, -2.48075217e-01f, -6.24900125e-03f,
  -3.08374196e-01f, 1.16258644e-01f, 2.54335850e-01f, 1.47232441e-02f, -2.05360174e-01f, 1.40110165e-01f, 7.03688338e-02f, 1.06745018e-02f, 9.17407200e-02f, -1.72531322e-01f,
  -1.60458274e-02f, -2.17488661e-01f, 9.56209823e-02f, 7.95804784e-02f, 2.93391943e-01f, -8.73575658e-02f, -2.96569597e-02f, -9.39593092e-02f, 1.34362444e-01f, -9.00460556e-02f,
  1.40732661e-01f, 2.36753561e-02f, -3.46236899e-02f, 2.77595092e-02f, -4.78278585e-02f, -8.11392739e-02f, 5.17682284e-02f, -1.70567781e-01f, -1.17988594e-01f, -5.17390743e-02f,
  -1.22218676e-01f, 1.58715695e-01f, -6.24933690e-02f, -2.10599810e-01f, -2.21835449e-01f, -1.67327121e-01f, 3.53889391e-02f, 1.20655157e-01f, -1.07716367e-01f, -1.05697028e-01f,
  9.81047526e-02f, -1.36459421e-03f, 1.19514298e-02f, -2.26352632e-01f, -3.79204587e-03f, -1.63763121e-01f, 7.16039911e-02f, 1.79470405e-02f, -2.43868306e-02f, 1.43390387e-01f,
  -1.02378037e-02f, -6.96583167e-02f, 1.26173154e-01f, -1.61096543e-01f, -2.26831466e-01f, 1.28357038e-01f, 1.08995020e-01f, 2.44171575e-01f, 2.39171669e-01f, -2.71180600e-01f,
  -1.64838389e-01f, 1.66887134e-01f, 4.10683937e-02f, 2.79183775e-01f, -1.42529517e-01f, -7.04426020e-02f, 4.40927409e-02f, 1.84970498e-01f, -3.49585339e-02f, 4.59656864e-02f,
  -2.06223965e-01f, -3.53251174e-02f, 2.87183076e-01f, 3.12366635e-01f, 1.25655800e-01f, 1.70222193e-01f, 1.81656286e-01f, 4.05255295e-02f, -2.93141693e-01f, -1.61633030e-01f,
  -2.05371231e-01f, 1.82955980e-01f, -1.17403762e-02f, -1.39590353e-01f, -1.34950161e-01f, -1.90253276e-02f, -9.23919529e-02f, 2.85353303e-01f, 7.85076022e-02f, 1.71083061e-03f,
  -2.65683860e-01f, -4.45836075e-02f, -1.12957530e-01f, 1.97498221e-02f, 1.18393647e-02f, -1.16995819e-01f, 1.79137602e-01f, 3.60217430e-02f, 2.49044880e-01f, 6.88987300e-02f,
  1.50685638e-01f, -4.60142493e-02f, 6.56898916e-02f, 9.70003456e-02f, -4.96042669e-02f, -2.00576708e-01f, 9.15508196e-02f, 4.53851074e-02f, -1.22634143e-01f, 4.55857292e-02f,
  -3.42313461e-02f, 4.48808260e-02f, -2.03404725e-02f, 5.77243306e-02f, 4.17281426e-02f, -1.54043481e-01f, -2.96659768e-01f, 3.62339944e-01f, 3.96317989e-03f, -4.57714647e-02f,
  2.23969027e-01f, -2.94982582e-01f, -1.52465671e-01f, 1.51298037e-02f, 2.32327729e-01f, -4.94790338e-02f, 6.00891002e-02f, -2.34376788e-01f, -1.79245040e-01f, -1.34641558e-01f,
  -1.11697286e-01f, -1.98937982e-01f, -2.81166494e-01f, -1.99545503e-01f, 6.79704994e-02f, 6.14981391e-02f, -1.32559225e-01f, -2.12565601e-01f, 1.99847877e-01f, -1.17126904e-01f,
  -1.80351451e-01f, -3.77077945e-02f, 1.36629418e-01f, 1.36753500e-01f, -1.09019063e-01f, -1.54533193e-01f, -2.84160040e-02f, -3.59322242e-02f, 1.06261289e-02f, -3.54960300e-02f,
  -1.62149757e-01f, -2.55386382e-01f, -1.21223055e-01f, 4.18855459e-04f, -8.18156358e-03f, 1.74885634e-02f, -3.56705044e-03f, -2.54407544e-02f, -1.24842441e-02f, -1.55861601e-01f,
  1.22304894e-01f, 6.80091754e-02f, -1.26747727e-01f, 2.84846351e-02f, -1.11821517e-01f, 2.47720946e-02f, 9.83460993e-02f, -1.76440209e-01f, 5.26954122e-02f, -1.40540928e-01f,
  4.87444364e-02f, -5.13543226e-02f, 2.19385162e-01f, 5.07807173e-02f, -1.48480594e-01f, -4.89073470e-02f, -9.90509093e-02f, 8.03497154e-03f, 1.44484296e-01f, 2.21496865e-01f,
  6.33103922e-02f, -1.95461318e-01f, 1.14137530e-01f, 5.06853759e-02f, -4.52712253e-02f, 1.70944244e-01f, 1.07641928e-02f, -1.21887788e-01f, -2.26752739e-02f, -1.84593573e-01f,
  3.61360498e-02f, 2.57751197e-01f, -1.01936579e-01f, -1.69198155e-01f, 1.76901624e-01f, 1.62856597e-02f, -4.24821349e-03f, 7.90098608e-02f, -5.65463789e-02f, 8.75301585e-02f,
  2.72567421e-01f, 2.01393604e-01f, 1.80875316e-01f, 7.70583823e-02f, 1.88343257e-01f, -2.82749444e-01f, -2.07348719e-01f, 1.29330546e-01f, 1.78579330e-01f, 4.78428379e-02f,
  1.52436104e-02f, 1.06070988e-01f, -2.62522817e-01f, -1.77975968e-01f, 1.75833121e-01f, 2.03448847e-01f, 1.07858695e-01f, -3.62463016e-03f, 1.73756629e-01f, 1.52616417e-02f,
  -4.89940383e-02f, -6.00587241e-02f, -1.20119348e-01f, 2.35919654e-02f, -1.75610319e-01f, -2.78383624e-02f, 6.01585358e-02f, 6.15525059e-02f, -1.68165594e-01f, 4.69443910e-02f,
  -1.26296833e-01f, 1.50801033e-01f, -6.14203587e-02f, -6.72847405e-02f, 1.21564753e-01f, 4.67603952e-02f, -4.24465872e-02f, -4.30959975e-03f, 1.51852012e-01f, 1.95670594e-02f,
  -1.31763652e-01f, -5.91117628e-02f, -1.42087817e-01f, -1.52854547e-01f, 2.99702287e-01f, -5.52820712e-02f, 9.95271057e-02f, -1.16626911e-01f, -2.91830719e-01f, 1.64792895e-01f,
  1.04674026e-01f, 1.54676676e-01f, 6.95143193e-02f, -3.90806273e-02f, -1.15695409e-01f, -9.86713022e-02f, 2.30598032e-01f, 2.05339659e-02f, -5.74380308e-02f, 2.31930748e-01f,
  2.41252065e-01f, 9.83320922e-02f, 8.10575262e-02f, 4.81014028e-02f, -1.06105089e-01f, 8.49387348e-02f, -2.88395107e-01f, 3.51300649e-02f, 8.22791755e-02f, 1.27800822e-01f,
  2.52937049e-01f, -2.21405312e-01f, -1.84838682e-01f, 2.13206232e-01f, -3.13288718e-02f, -2.04378456e-01f, 1.73543170e-01f, 5.77990599e-02f, -2.13424638e-01f, -2.63121333e-02f,
  1.24761552e-01f, -4.08164673e-02f, 8.92775282e-02f, 2.56097615e-02f, 1.40002474e-01f, 7.46526346e-02f, 1.49489254e-01f, 9.30994190e-03f, 1.68191388e-01f, -5.71574681e-02f,
  -2.40930151e-02f, 7.10913688e-02f, -3.70854959e-02f, 1.87592193e-01f, 3.60426940e-02f, 1.13746941e-01f, 1.72412410e-01f, 1.18241943e-01f, -9.93305072e-02f, 1.31957963e-01f,
  1.20658822e-01f, -6.53056130e-02f, 7.97571316e-02f, 6.79620504e-02f, 1.71901509e-01f, -5.01551442e-02f, 2.36450750e-02f, 8.25241581e-02f, -2.04785630e-01f, -4.93763387e-02f,
  -2.23054081e-01f, 3.69980745e-02f, 2.74548501e-01f, -9.61586013e-02f, 1.39487714e-01f, -2.90763050e-01f, -1.32320821e-01f, 7.93453828e-02f, 1.63000464e-01f, 1.89585373e-01f,
  -2.17741549e-01f, 2.32850030e-01f, 1.74412653e-01f, 1.79322734e-01f, 2.29799021e-02f, 1.25236884e-01f, -2.97009110e-01f, 7.31643885e-02f, 1.38920903e-01f, -3.39011885e-02f,
  7.63740465e-02f, 1.38624027e-01f, 7.56922318e-03f, 1.61357641e-01f, -1.16591923e-01f, -6.85129911e-02f, -1.06688961e-02f, -1.38540074e-01f, -2.49547511e-02f, -4.89009842e-02f,
  3.63305271e-01f, -8.46954342e-03f, 3.18279475e-01f, 3.63188833e-01f, 1.14841267e-01f, -1.66277308e-02f, 6.10919259e-02f, 9.72658098e-02f, 7.30170980e-02f, 1.81650698e-01f,
  1.32316411e-01f, -6.96143359e-02f, 6.11308180e-02f, 2.77913501e-03f, 8.74402598e-02f, -1.48288729e-02f, 8.95319730e-02f, -5.13951406e-02f, 1.55207768e-01f, 9.44939554e-02f,
  1.55239478e-01f, -4.84846309e-02f, -7.92942345e-02f, 1.20910652e-01f, -1.18439898e-01f, -3.73694003e-02f, 2.63850633e-02f, 1.30921721e-01f, 3.20288427e-02f, -1.64862022e-01f,
  2.81247884e-01f, 1.99559137e-01f, -3.35629791e-01f, 3.73548456e-02f, -2.21912399e-01f, 2.88479507e-01f, 6.61692172e-02f, -2.51080189e-02f, 9.25530568e-02f, -1.69625476e-01f,
  -1.65481865e-01f, 2.14469433e-01f, 2.88914144e-01f, 1.70058474e-01f, 1.70276798e-02f, 1.10617161e-01f, -2.77057886e-01f, -1.49554253e-01f, -4.12621386e-02f, 1.05224326e-01f,
  -1.11114338e-01f, 1.29765555e-01f, -1.49463758e-01f, 3.85579281e-02f, 7.99663886e-02f, 2.12603584e-01f, -9.88092273e-02f, 2.55939811e-01f, -6.71533868e-02f, 5.56238219e-02f,
  -4.51081693e-02f, -2.10429803e-01f, 1.84551567e-01f, -7.11229921e-04f, 2.05509946e-01f, -1.31619036e-01f, 2.65701860e-01f, -2.31202058e-02f, 2.17847638e-02f, -6.79584518e-02f,
  -2.35984832e-01f, 9.81574804e-02f, 2.55337618e-02f, -1.38278157e-01f, 1.08097911e-01f, -5.94091564e-02f, 1.25120386e-01f, -8.12689587e-02f, 1.37141570e-01f, 1.22376136e-01f,
  -1.18149079e-01f, 6.65434450e-03f, 8.68714452e-02f, -1.14354357e-01f, 1.25903770e-01f, -1.98890284e-01f, 4.31579202e-02f, 5.22739179e-02f, -8.05366710e-02f, 1.08344041e-01f,
  -9.56325904e-02f, -1.27117395e-01f, -1.88388918e-02f, -2.64219373e-01f, 2.41215061e-02f, -1.94232196e-01f, -2.57316768e-01f, 2.63225138e-01f, -1.08904406e-01f, -1.31426856e-01f,
  1.93479769e-02f, -3.91060442e-01f, -9.62793157e-02f, -5.88760898e-02f, 2.62006432e-01f, 1.48498965e-02f, 1.16916493e-01f, -1.89498857e-01f, 4.45555197e-03f, 2.08533388e-02f,
  -2.10543752e-01f, -2.02609047e-01f, -2.50421733e-01f, -2.73664147e-01f, 1.67484097e-02f, -1.34793930e-02f, -2.07572598e-02f, -7.91136697e-02f, 3.60705741e-02f, -2.74272412e-01f,
  3.24450340e-03f, 9.20214280e-02f, 6.55786181e-03f, 2.74350643e-01f, -1.00541130e-01f, -2.65265197e-01f, -6.24360405e-02f, -6.44868687e-02f, 2.21612185e-01f, -7.09494948e-02f,
  -1.78695709e-01f, -2.36274585e-01f, -5.79968728e-02f, 1.71793014e-01f, 1.90004066e-01f, 5.00933565e-02f, 7.16868863e-02f, 1.73047453e-01f, -2.25861117e-01f, 2.03105405e-01f,
  -2.24714071e-01f, -1.49175813e-02f, -8.67904723e-02f, -1.18956538e-02f, -6.86069801e-02f, 2.60467619e-01f, -1.65319115e-01f, 8.64414275e-02f, 1.90009952e-01f, 7.47203603e-02f,
  1.71578582e-02f, -1.28035739e-01f, -3.31747271e-02f, -4.81590675e-03f, -2.40166746e-02f, -1.56287894e-01f, -4.86302562e-02f, -4.58071604e-02f, 1.63695857e-01f, -1.23114251e-01f,
  1.35229498e-01f, -3.73297423e-01f, -1.06801011e-01f, 8.41746107e-02f, -2.00569421e-01f, 7.24177510e-02f, 3.33258539e-01f, 1.98041975e-01f, -4.91318181e-02f, -2.41760444e-02f,
  3.64382230e-02f, 3.63922752e-02f, 4.97825593e-02f, -3.54533121e-02f, -2.11546868e-02f, 8.64208490e-02f, -1.16092071e-01f, 2.60136038e-01f, -4.10806760e-03f, -1.03129677e-01f,
  1.96690202e-01f, 1.65380970e-01f, 8.58612917e-03f, 1.39382809e-01f, 2.19332755e-01f, 8.79712850e-02f, -2.23414719e-01f, -4.34926748e-02f, 6.79741427e-02f, 2.09866658e-01f,
  -1.01672880e-01f, -1.52414903e-01f, -3.84712607e-01f, 9.90692228e-02f, 3.69089544e-02f, 3.46826643e-01f, 2.16391757e-01f, -3.43352854e-02f, 8.91180113e-02f, 1.09455489e-01f,
  3.40338163e-02f, -3.54221500e-02f, 1.08279876e-01f, -2.95110755e-02f, 2.39173308e-01f, 1.35589793e-01f, 6.97294548e-02f, 1.93383783e-01f, 8.66920948e-02f, 7.37033179e-03f,
  2.50317812e-01f, 2.52286382e-02f, 1.86834354e-02f, -6.70408159e-02f, 3.03952508e-02f, -3.72343436e-02f, 6.26881272e-02f, 9.26317126e-02f, 1.97904810e-01f, 1.20026134e-01f,
  2.02367976e-01f, 2.56673247e-01f, -1.83960721e-02f, -3.01932514e-01f, 9.49916393e-02f, 6.56321645e-02f, 2.58321375e-01f, 3.59765813e-03f, -3.74909863e-02f, 1.87845659e-02f,
  -6.12781160e-02f, 1.78628013e-01f, 1.60005480e-01f, -3.34228091e-02f, -5.29212020e-02f, -1.07570156e-01f, 2.88074285e-01f, 1.22693256e-01f, -1.91331550e-01f, -9.19000804e-02f,
  1.58594787e-01f, 1.71701312e-01f, 2.15641633e-01f, 8.77126120e-03f, -2.27911085e-01f, -5.85101023e-02f, -1.24611415e-01f, -7.61367902e-02f, -6.14465810e-02f, 2.36119330e-01f,
  9.58484486e-02f, -2.06406251e-01f, -1.39739767e-01f, 2.87962407e-01f, -2.98398316e-01f, -2.09492281e-01f, 3.71934436e-02f, 9.10848100e-03f, -5.12569137e-02f, -2.32621253e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.40195087e-01f, 8.92608091e-02f, 4.91182894e-01f, 3.29432249e-01f, 2.42025390e-01f, 2.58788139e-01f, 2.34475404e-01f, 8.20389483e-03f, 2.61758804e-01f, 7.98231959e-02f,
  2.80539483e-01f, 1.82894707e-01f, 3.24161738e-01f, 1.92446157e-01f, 2.76686579e-01f, 4.54419851e-02f, 2.08173752e-01f, 5.07674158e-01f, 1.64724916e-01f, 3.58830988e-01f,
  3.25039804e-01f, 1.49938375e-01f, 4.07777309e-01f, 3.06155384e-01f, -1.12921484e-01f, 4.48471487e-01f, -3.44667673e-01f, 3.15758526e-01f, 2.44296506e-01f, -4.30705845e-01f,
  4.78925526e-01f, -3.20258319e-01f, -1.67624280e-01f, 6.49808109e-01f, 3.97083759e-02f, 2.09967181e-01f, 1.17281504e-01f, -8.28211457e-02f, -4.67046976e-01f, 5.27097583e-01f,
  1.59366399e-01f, 3.47167194e-01f, 3.89408916e-02f, 2.95698375e-01f, 5.92255175e-01f, 2.21004874e-01f, 1.74005270e-01f, 5.70188284e-01f, 2.29073614e-01f, -8.49506482e-02f,
  -1.44134432e-01f, 2.17654988e-01f, -1.97855175e-01f, -4.39974591e-02f, 4.10855323e-01f, -2.81054229e-01f, -5.03673665e-02f, 5.25458157e-01f, 3.72067779e-01f, -1.10347550e-02f,
  -1.79543927e-01f, 2.56267078e-02f, 4.26466405e-01f, 1.96386173e-01f, -7.08862543e-02f, 2.77500600e-01f, 9.98125970e-02f, 2.77036220e-01f, 1.73577257e-02f, 1.11806378e-01f,
  1.14429137e-02f, 5.99330291e-02f, 1.03417799e-01f, 6.75530508e-02f, -2.28959635e-01f, 2.51202375e-01f, 1.72945112e-01f, 3.67043167e-02f, 1.12110518e-01f, 1.49832100e-01f,
  9.15687978e-02f, 4.37842160e-02f, 5.80590032e-02f, 1.46855852e-02f, -2.10950002e-01f, -1.30986303e-01f, 1.82631657e-01f, 2.15023637e-01f, 2.20229730e-01f, 3.64647597e-01f,
  3.87913764e-01f, 1.93636894e-01f, -2.41447482e-02f, -1.01902455e-01f, -2.98823744e-01f, 2.46418789e-01f, 4.38920528e-01f, 1.36746287e-01f, -3.28300416e-01f, -2.88383424e-01f,
  -3.74393284e-01f, 4.08164263e-01f, 2.82539338e-01f, 1.74888998e-01f, -5.78793347e-01f, 1.22722546e-02f, -1.49117827e-01f, -3.63819711e-02f, -5.43598354e-01f, 4.40599203e-01f,
  -3.03172082e-01f, 2.49732167e-01f, 1.02971807e-01f, 2.00907513e-01f, 4.04162914e-01f, 9.96314827e-03f, 1.91104546e-01f, 1.91343263e-01f, -6.62626922e-02f, 7.74575695e-02f,
  -4.00462270e-01f, 4.43299599e-02f, 4.18065697e-01f, -4.48280901e-01f, -3.72656994e-02f, -7.71718798e-03f, 5.33722453e-02f, 3.27420324e-01f, 1.48753703e-01f, 2.52002686e-01f,
  1.92609265e-01f, 1.22217372e-01f, 2.22488597e-01f, 3.50441724e-01f, -1.36676915e-02f, 3.14167231e-01f, 2.09765613e-01f, 2.23870426e-01f, 2.37448052e-01f, 5.73052987e-02f,
  2.99017072e-01f, 4.03470278e-01f, 1.71117261e-01f, 3.25469583e-01f, 2.49896586e-01f, 6.54977635e-02f, -4.39117365e-02f, 9.71849561e-02f, 2.30803147e-01f, 3.22491944e-01f,
  9.17366222e-02f, 5.54731973e-02f, 1.37593940e-01f, -3.03044885e-01f, 6.71708465e-01f, 3.99766713e-02f, 1.54095963e-01f, -2.28514373e-01f, -1.30103901e-01f, 6.60756350e-01f,
  1.68843232e-02f, 2.18874812e-01f, 2.59483576e-01f, -1.44260034e-01f, -2.31431112e-01f, -4.10408646e-01f, 4.99943286e-01f, 1.71838105e-01f, 5.22561818e-02f, 7.61813372e-02f,
  -1.99448422e-01f, -4.09853637e-01f, 9.75650251e-02f, 2.39385277e-01f, -4.98959273e-02f, -3.36760074e-01f, -1.89360961e-01f, 2.62728453e-01f, 4.45814818e-01f, 5.64432204e-01f,
  2.65855104e-01f, 9.32274573e-03f, -4.65992957e-01f, 4.42720026e-01f, 6.76106393e-01f, 2.81127512e-01f, -2.67604649e-01f, 6.32968903e-01f, -5.33876717e-01f, -6.71154484e-02f,
  4.74822372e-01f, 4.26917762e-01f, 4.15546983e-01f, 2.16152683e-01f, 2.88576961e-01f, 7.87234455e-02f, -1.31402472e-02f, 2.36851707e-01f, 2.15146437e-01f, 6.97347894e-02f,
  2.78087169e-01f, 8.51214007e-02f, 4.41349030e-01f, 3.69526953e-01f, 2.11791947e-01f, -1.45325452e-01f, 4.97380406e-01f, 1.63010523e-01f, 3.02032977e-01f, -2.96365079e-02f,
  2.74450541e-01f, 1.13939561e-01f, 4.59370583e-01f, 4.63606596e-01f, 1.16993114e-01f, 3.00996304e-01f, -4.47569154e-02f, -4.67002630e-01f, 8.01475253e-03f, 1.48800597e-01f,
  -4.17154700e-01f, -2.36176103e-02f, -3.51535201e-01f, 2.92416692e-01f, -1.14743307e-01f, 1.31136656e-01f, 4.75977436e-02f, 6.40769228e-02f, 3.86257946e-01f, 3.45962979e-02f,
  3.24998617e-01f, 2.78965056e-01f, 5.04502237e-01f, 1.25259236e-01f, -5.64648032e-01f, -5.41560590e-01f, 3.59416157e-01f, -1.59862801e-01f, 2.19372764e-01f, 4.23292994e-01f,
  -3.11943412e-01f, -2.67053694e-02f, 5.47583401e-01f, 2.52108723e-01f, -1.04217283e-01f, 2.43444920e-01f, -2.09669113e-01f, 2.46893749e-01f, 1.49221092e-01f, 1.31060421e-01f,
  8.89167637e-02f, 2.76212871e-01f, 7.67134607e-01f, -5.35847187e-01f, 9.33478549e-02f, -4.59379613e-01f, 2.17945173e-01f, 3.35039824e-01f, 1.39254853e-01f, 1.28222510e-01f,
  1.34726167e-01f, 2.12035522e-01f, 9.04895589e-02f, 4.91667330e-01f, 1.94113106e-01f, 2.95188725e-01f, 3.96203697e-01f, 2.57037699e-01f, 7.53975734e-02f, -3.34374122e-02f,
  3.28600585e-01f, 5.07894576e-01f, 3.68470579e-01f, 9.68156084e-02f, 2.81733841e-01f, 2.89110899e-01f, -8.08735266e-02f, 3.78374785e-01f, 2.45426223e-01f, 1.09111153e-01f,
  3.73431206e-01f, -3.24887604e-01f, 3.59101683e-01f, -4.00231570e-01f, -3.75993848e-01f, 5.64391352e-02f, -4.92001235e-01f, 6.02302313e-01f, -4.49768864e-02f, -2.36757442e-01f,
  3.83507729e-01f, 1.94575012e-01f, 1.64597526e-01f, 3.92550617e-01f, 5.62689245e-01f, -4.27776754e-01f, 2.40833908e-02f, 1.76064119e-01f, -5.26901066e-01f, -3.44959609e-02f,
  -1.67557001e-01f, 2.51135707e-01f, -1.91453010e-01f, 5.42099513e-02f, -4.84147072e-01f, -1.18666202e-01f, 6.86866641e-02f, 8.32963660e-02f, 8.06946456e-02f, 6.35261595e-01f,
  -4.05176543e-02f, 1.91554919e-01f, -3.03526133e-01f, 3.70300598e-02f, -2.29232654e-01f, -3.91850680e-01f, 4.81368035e-01f, 5.18725455e-01f, -3.02195072e-01f, -3.31927449e-01f,
  7.58783612e-03f, 6.00289963e-02f, 2.52651930e-01f, 2.00153321e-01f, -2.77470779e-02f, 1.64252594e-01f, 3.17202508e-01f, -1.14505306e-01f, 5.59603512e-01f, 3.90154600e-01f,
  1.13265142e-01f, 4.72732902e-01f, 4.93631251e-02f, 2.85937786e-02f, 2.27742389e-01f, 1.52972788e-01f, 2.11406082e-01f, 9.19005200e-02f, 4.59945798e-01f, 2.13144183e-01f,
  5.27682364e-01f, 2.58852661e-01f, -1.51957914e-01f, 2.15942696e-01f, 3.64646018e-01f, -1.80620134e-01f, 2.74915963e-01f, 3.80160272e-01f, 2.71190226e-01f, 3.67373466e-01f,
  4.11408216e-01f, -3.51946056e-01f, 3.10570210e-01f, -1.13035403e-02f, -6.01341605e-01f, 1.07984595e-01f, -6.75990582e-02f, -4.43620712e-01f, -1.27449140e-01f, 2.15746611e-02f,
  -3.76656234e-01f, -1.91599011e-01f, 2.91101009e-01f, -3.09636295e-01f, -2.89785117e-01f, -1.24766655e-01f, 2.28421360e-01f, 1.18915193e-01f, 3.42709333e-01f, -1.62770167e-01f,
  2.42777601e-01f, 3.16302150e-01f, 4.70129818e-01f, -2.55897313e-01f, 4.94454831e-01f, 3.63197327e-01f, 3.65571678e-01f, -1.95891336e-01f, 3.11732024e-01f, 4.38954711e-01f,
  1.34074716e-02f, -4.96867776e-01f, 3.75128478e-01f, -1.42908603e-01f, 1.34122491e-01f, 1.82757586e-01f, 1.42522275e-01f, 2.12794393e-01f, 5.18921092e-02f, 3.24732423e-01f,
  7.43814260e-02f, 2.85862207e-01f, -4.39238511e-02f, 1.21943168e-01f, -8.80861953e-02f, 7.43153393e-02f, 1.84335187e-01f, 2.50853956e-01f, 1.46580115e-01f, 2.24703833e-01f,
  9.42533761e-02f, 5.00041321e-02f, -7.22247288e-02f, 1.35925025e-01f, -5.83020560e-02f, 9.10686702e-02f, 1.25033975e-01f, 2.98504800e-01f, 1.19451426e-01f, 8.60804692e-02f,
  3.86067063e-01f, 8.92179236e-02f, 3.36265236e-01f, -2.99785197e-01f, 8.70169252e-02f, 4.85231400e-01f, 1.57854855e-01f, 4.43397909e-01f, -1.03172339e-01f, -1.41335368e-01f,
  -1.49196446e-01f, -1.94298290e-02f, 1.72666222e-01f, 4.41128850e-01f, -2.25330353e-01f, 9.15443674e-02f, -4.61487584e-02f, 6.12266697e-02f, 6.04490601e-02f, 5.39617419e-01f,
  -3.51072639e-01f, 3.00824463e-01f, 1.67975187e-01f, 4.82909977e-01f, 3.60741347e-01f, 6.58385098e-01f, 2.35526897e-02f, 2.49578238e-01f, -2.39878595e-01f, -2.54415832e-02f,
  -4.19609100e-02f, 3.70788723e-01f, -3.81251648e-02f, -1.00382470e-01f, -2.68700451e-01f, 6.19671792e-02f, 2.86503643e-01f, 5.23561120e-01f, 1.46676719e-01f, 2.54760444e-01f,
  -3.80375892e-01f, 3.88088733e-01f, 4.62640166e-01f, 2.28041172e-01f, 2.51231670e-01f, -1.22891456e-01f, 2.13104054e-01f, 2.93097407e-01f, 9.99404415e-02f, 1.24144234e-01f,
  3.38481933e-01f, 1.74454689e-01f, -1.72855854e-02f, -1.07325636e-01f, -1.56067893e-01f, 3.76839876e-01f, 4.87456284e-02f, 2.56882489e-01f, 1.36134028e-01f, 1.25730932e-01f,
  3.48119050e-01f, 1.56358525e-01f, 1.84261560e-01f, 3.45670015e-01f, -2.25272462e-01f, -1.20303132e-01f, -3.74824405e-01f, 3.31779271e-02f, 3.08321208e-01f, 7.99539983e-02f,
  1.18273444e-01f, -2.07702950e-01f, -4.26024616e-01f, -1.94305927e-01f, -5.87100461e-02f, -2.14561403e-01f, -4.90313442e-03f, -1.23123147e-01f, 6.55769035e-02f, 2.64466088e-02f,
  1.54303461e-01f, -3.14025611e-01f, -3.29278529e-01f, -1.94116026e-01f, 1.50049165e-01f, -6.09369762e-02f, -2.42329165e-01f, -3.99332762e-01f, 2.97165364e-01f, -4.49194610e-02f,
  -4.94447440e-01f, -4.07787681e-01f, 3.06700706e-01f, -1.22330368e-01f, 1.25121087e-01f, -1.39864519e-01f, 3.74972582e-01f, 1.54763594e-01f, -3.27491105e-01f, 4.85028505e-01f,
  3.35424423e-01f, 4.07224521e-02f, 3.34365517e-02f, 1.68809518e-01f, -2.70638883e-01f, 2.27175847e-01f, 6.17736995e-01f, 1.73568964e-01f, 1.98186636e-01f, 2.48985469e-01f,
  1.01628996e-01f, 1.25651091e-01f, 1.01229943e-01f, 1.87028274e-01f, 2.41110519e-01f, 1.36292100e-01f, -9.61352699e-03f, 3.17749530e-01f, -5.36492690e-02f, 3.05008143e-01f,
  1.18430793e-01f, 3.71254802e-01f, -1.99827746e-01f, 1.93186626e-01f, 3.26872319e-01f, 2.89550453e-01f, 5.47476113e-01f, 3.18304330e-01f, -2.29931399e-02f, 1.98042616e-01f,
  -7.85935760e-01f, 6.14203215e-02f, -2.43908569e-01f, 3.16126317e-01f, 4.15862322e-01f, -2.88315892e-01f, 6.08116016e-02f, -5.71657598e-01f, -6.28996551e-01f, 5.11704922e-01f,
  2.77702510e-01f, -3.50143313e-02f, -5.16562760e-01f, 4.59669262e-01f, 1.44890636e-01f, 1.88655686e-02f, -2.14461669e-01f, 1.02991872e-02f, -5.14139652e-01f, -2.29831070e-01f,
  -1.61887184e-01f, -5.08614779e-01f, 3.45463812e-01f, 1.36385605e-01f, -1.27269089e-01f, 5.32790661e-01f, -5.79422293e-03f, -9.23928246e-02f, 3.01644020e-02f, -3.69915992e-01f,
  3.91122371e-01f, 1.06440112e-01f, 3.09391588e-01f, 5.53610802e-01f, 6.09892607e-01f, 2.42757916e-01f, 5.88171110e-02f, -6.27504289e-02f, 1.82028353e-01f, 3.13663006e-01f,
  3.53000015e-01f, 3.25183541e-01f, 2.37429932e-01f, 2.20830888e-01f, 1.42146915e-01f, -4.08061035e-02f, 1.47157893e-01f, -2.95194015e-02f, 1.50399255e-02f, 2.28730485e-01f,
  1.41998321e-01f, 4.59018439e-01f, 8.60159323e-02f, 2.45419785e-01f, 2.64411531e-02f, 3.96422148e-01f, -2.15227425e-01f, 2.18976527e-01f, 1.70371711e-01f, 2.44915769e-01f,
  2.18210533e-01f, 1.58191532e-01f, -1.39362201e-01f, -7.13161007e-02f, -4.44858491e-01f, 3.33425939e-01f, -2.10068047e-01f, 3.42489481e-01f, 4.79499847e-01f, 6.60009682e-02f,
  2.83133686e-01f, -3.74731094e-01f, -4.10838783e-01f, 3.84166300e-01f, 8.25577378e-02f, 3.86072956e-02f, -1.30677968e-01f, 5.04731715e-01f, 2.49039903e-01f, 4.32859212e-01f,
  9.24396291e-02f, 1.38592020e-01f, -3.03343236e-01f, -4.28026110e-01f, -1.91597089e-01f, -2.90216804e-01f, -2.05126867e-01f, 3.98377031e-01f, -2.95137674e-01f, 4.94654030e-01f,
  2.65815765e-01f, -1.72463879e-01f, 2.33326957e-01f, -2.58688897e-01f, -2.47928455e-01f, 9.10134092e-02f, 4.01963383e-01f, 4.49343443e-01f, 2.84889042e-01f, 3.75880301e-01f,
  1.99495867e-01f, 1.89629897e-01f, 1.00405924e-01f, 1.26935631e-01f, 2.30359256e-01f, 1.86093658e-01f, 1.74674347e-01f, 4.41034347e-01f, -1.87501535e-01f, 9.00639519e-02f,
  2.65607834e-01f, 2.02481076e-02f, 7.76180029e-02f, 1.87669158e-01f, 2.55435139e-01f, 2.20793322e-01f, 3.99246931e-01f, 1.16518676e-01f, 1.82846382e-01f, 1.98378384e-01f,
  1.08150013e-01f, 2.82566160e-01f, 3.42396021e-01f, 2.41293937e-01f, 1.83282852e-01f, 8.52772221e-02f, -1.42838165e-01f, -1.12598211e-01f, 8.01440179e-02f, -4.58776146e-01f,
  -3.40094239e-01f, 2.47680694e-01f, -2.94398010e-01f, -3.23588736e-02f, 3.41963053e-01f, -8.44974071e-02f, 3.11681420e-01f, 2.82011718e-01f, 2.45797321e-01f, 1.26782194e-01f,
  1.57196477e-01f, -6.00639284e-02f, -2.96789974e-01f, 4.43565995e-01f, 1.80686906e-01f, 2.36415297e-01f, -3.28633577e-01f, 1.13953993e-01f, 2.38835618e-01f, 2.52304554e-01f,
  1.83592409e-01f, -1.12342626e-01f, 1.15328506e-01f, 4.91756767e-01f, -1.06188096e-01f, -5.10887504e-02f, -3.45684469e-01f, 5.37906647e-01f, 8.49708170e-02f, -4.07729357e-01f,
  4.64118481e-01f, 5.71966529e-01f, -2.68968731e-01f, 5.44162810e-01f, 8.06354359e-02f, 1.88993931e-01f, 3.71223688e-01f, -1.33558651e-02f, -8.38048533e-02f, 9.09759179e-02f,
  1.51476175e-01f, 3.76827680e-02f, 1.11317568e-01f, 1.67197138e-02f, -1.30774677e-01f, 2.00193390e-01f, 7.55824596e-02f, 1.17719933e-01f, 1.59024149e-01f, -3.89124341e-02f,
  3.53262216e-01f, 6.68986738e-02f, 3.63163859e-01f, -1.02078140e-01f, 4.24701512e-01f, 5.50483242e-02f, 1.18346363e-01f, 3.37183088e-01f, 1.37625948e-01f, -2.32550018e-02f,
  -3.97019312e-02f, 2.70527869e-01f, 4.68494356e-01f, -2.75825292e-01f, 9.46099684e-02f, -3.27133536e-01f, -1.97605357e-01f, 3.72918725e-01f, -6.76989630e-02f, -9.17265043e-02f,
  3.45360190e-01f, 1.49723098e-01f, -2.45538190e-01f, 3.43172580e-01f, -7.91784599e-02f, -3.18537027e-01f, 4.83788503e-03f, 1.89024672e-01f, -8.12459365e-02f, 7.70342276e-02f,
  -1.03006020e-01f, 4.97830242e-01f, 4.11112100e-01f, 5.06496072e-01f, 4.97222245e-01f, 1.66046456e-01f, 5.86275995e-01f, -1.28780387e-03f, 2.85068601e-01f, -4.12090309e-02f,
  -3.52507532e-01f, 6.03178859e-01f, 5.02364159e-01f, -3.59389037e-01f, 2.50862539e-01f, -4.16644722e-01f, -1.16194181e-01f, 5.58640897e-01f, 2.29530752e-01f, 2.45766924e-03f,
  3.58447164e-01f, 5.47241420e-02f, 6.93854736e-03f, 1.59497514e-01f, 2.66249120e-01f, 2.55936533e-01f, 1.58327952e-01f, 3.71654630e-01f, 2.00738832e-01f, 2.14399934e-01f,
  1.53951302e-01f, 2.55920161e-02f, -1.54991858e-02f, 3.39865625e-01f, -9.25934911e-02f, 2.95457274e-01f, 3.41578394e-01f, 1.84402302e-01f, 1.63480014e-01f, -7.97521882e-03f,
  3.31549734e-01f, 4.75806445e-01f, 1.47816807e-01f, -1.57605961e-01f, -3.46314698e-01f, -2.10713148e-01f, 2.71324545e-01f, 3.97214115e-01f, 1.91182807e-01f, -3.86665463e-01f,
  -4.72548246e-01f, -1.28675159e-02f, -5.53276204e-02f, 3.80195975e-01f, 9.74918809e-03f, -2.93498218e-01f, -3.89589310e-01f, -3.50790888e-01f, 2.82228529e-01f, -1.94514617e-01f,
  2.77000189e-01f, 1.15539894e-01f, 2.60296911e-01f, -2.56693453e-01f, 4.30027872e-01f, -2.01899648e-01f, -4.11295623e-01f, -1.81500718e-01f, -5.91848850e-01f, 2.70591024e-03f,
  4.41132724e-01f, 1.20758422e-01f, 6.22079194e-01f, 1.55220285e-01f, 2.06985593e-01f, 8.12579468e-02f, -5.25381379e-02f, 1.54264480e-01f, 6.31793857e-01f, 4.52611327e-01f,
  2.08016243e-02f, -3.45208049e-01f, 1.12313509e-01f, 3.64488631e-01f, -2.61119485e-01f, 3.20953161e-01f, 2.96069682e-01f, 5.44507317e-02f, -5.20241596e-02f, -1.37274489e-01f,
  2.64638096e-01f, 5.00879407e-01f, 2.16314405e-01f, 5.75157523e-01f, 4.10052210e-01f, -1.10896528e-01f, 4.89860997e-02f, -1.18233331e-01f, -2.65263058e-02f, 3.03823620e-01f,
  2.00507030e-01f, 2.23409265e-01f, 2.60306567e-01f, 3.61628562e-01f, 1.17121235e-01f, -3.56311649e-02f, 2.95643270e-01f, 1.88294083e-01f, 1.33608103e-01f, -1.63881183e-01f,
  1.12016305e-01f, 2.63909642e-02f, 3.55927199e-01f, -9.19899717e-02f, -2.60183483e-01f, -2.95912027e-01f, -3.63764346e-01f, 2.30146751e-01f, 6.14862405e-02f, -5.79681337e-01f,
  -2.10375190e-01f, -3.69878858e-01f, -2.10206658e-01f, -6.46412909e-01f, 1.65002942e-01f, -4.39805150e-01f, -2.83909380e-01f, -7.30013177e-02f, 6.07333422e-01f, -3.93485397e-01f,
  -2.58999795e-01f, -3.15644801e-01f, 3.85747820e-01f, -4.07557696e-01f, -1.59452688e-02f, -4.86166835e-01f, 3.95050675e-01f, 3.94253969e-01f, 6.43659353e-01f, 1.00321934e-01f,
  2.77092725e-01f, 5.26414573e-01f, -7.03914702e-01f, 3.41851473e-01f, 2.55165827e-02f, -3.34922254e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.57645303e-01f, 2.43102670e-01f, 2.28420213e-01f, 1.94890931e-01f, 3.33754450e-01f, 2.52355725e-01f, 1.49696067e-01f, 2.29263544e-01f, 2.83932567e-01f, 2.27262750e-01f,
  1.57690182e-01f, 2.98308104e-01f, 3.89436603e-01f, 4.46632326e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  5.79320416e-02f, 2.18621090e-01f, -4.77701873e-02f, -1.50641590e-01f, 1.63943127e-01f, 8.26185197e-02f, 6.52820468e-02f, -8.00000154e-04f, 1.28421905e-02f, 1.70525089e-01f,
  -2.45954588e-01f, 6.73761070e-02f, -1.25204593e-01f, -2.83239074e-02f, -1.23939261e-01f, 1.55627131e-01f, -1.82133749e-01f, -3.86537015e-01f, 6.58669993e-02f, -2.67902344e-01f,
  1.01240873e-01f, 5.45502789e-02f, -3.97168845e-02f, -3.11128050e-01f, 2.20468745e-01f, 2.75848627e-01f, -1.45995364e-01f, -1.40632158e-02f, 4.19398725e-01f, -3.04266840e-01f,
  1.65209666e-01f, -1.57199070e-01f, 6.56442568e-02f, 1.99584514e-01f, -2.67303228e-01f, 2.05893755e-01f, 2.36883864e-01f, 3.92744914e-02f, -4.69335109e-01f, 4.62719470e-01f,
  -4.27220225e-01f, 3.57099771e-01f, -2.16359068e-02f, 2.40237489e-01f, 1.99688956e-01f, 4.54555191e-02f, -5.05636990e-01f, -1.06105983e-01f, 3.59760001e-02f, 2.68946111e-01f,
  4.28644180e-01f, -3.10977221e-01f, -1.02635406e-01f, -3.59088182e-03f, -5.09289443e-01f, -6.04290366e-01f, 1.63266003e-01f, -4.71521497e-01f, -5.94024062e-01f, -2.24650860e-01f,
  3.75301689e-01f, 4.43122834e-01f, -1.83930069e-01f, -6.26437664e-01f, 2.49594852e-01f, 2.05582112e-01f, 1.81454554e-01f, 2.23017871e-01f, 2.36944675e-01f, -6.87866136e-02f,
  -1.38202891e-01f, 2.14448437e-01f, -6.71062013e-03f, 2.44058043e-01f, 1.77710757e-01f, -6.29701689e-02f, -1.71555862e-01f, 2.22846732e-01f, 1.22498661e-01f, 1.06167428e-01f,
  2.45122150e-01f, 1.64153159e-01f, 2.05131546e-01f, -3.12021166e-01f, 4.04938497e-02f, -1.92052603e-01f, -8.32580104e-02f, 2.85497844e-01f, -3.63477856e-01f, 1.30009621e-01f,
  -1.58257663e-01f, 4.65138823e-01f, 3.96002978e-01f, -3.67208540e-01f, -4.24584210e-01f, -2.65985012e-01f, 2.98074335e-01f, -4.37360734e-01f, -2.65081316e-01f, 3.71726066e-01f,
  5.34863651e-01f, 5.24556458e-01f, -3.84529889e-01f, -9.62668434e-02f, 4.05304462e-01f, -4.81028140e-01f, -3.89937609e-01f, -1.92778930e-01f, 2.10776225e-01f, -4.72424656e-01f,
  -1.30211756e-01f, -5.42971253e-01f, -3.75309698e-02f, -2.14354202e-01f, 3.16829681e-01f, -5.83330952e-02f, -5.02828956e-01f, -1.77406445e-01f, -5.58835328e-01f, -1.75305805e-03f,
  -3.17178905e-01f, -1.61358006e-02f, -2.90596664e-01f, -5.29219985e-01f, -1.11920260e-01f, 1.50646403e-01f, 3.14621091e-01f, 2.97216684e-01f, 1.99013472e-01f, 1.33648785e-02f,
  -1.89902633e-01f, 6.90334737e-02f, -1.20991550e-01f, 3.85510735e-02f, 2.42702410e-01f, 1.58682972e-01f, -1.41364112e-01f, -1.57401010e-01f, -1.96840718e-01f, -2.98581459e-02f,
  1.09930180e-01f, -2.10370928e-01f, 1.42152742e-01f, -1.13106981e-01f, -2.13824645e-01f, -2.20709041e-01f, -3.43874872e-01f, -2.53819358e-02f, 9.45308134e-02f, -3.87831144e-02f,
  1.84462279e-01f, -2.84427148e-03f, -6.54591471e-02f, 1.06306493e-01f, -2.92481810e-01f, -3.39228183e-01f, -3.52736235e-01f, -2.53644407e-01f, -2.65394688e-01f, 1.87351346e-01f,
  -1.68563589e-01f, -1.94145679e-01f, 4.62575257e-01f, 3.28711987e-01f, -3.85445058e-01f, 2.83335835e-01f, 3.28994989e-01f, -3.33304286e-01f, 9.68635902e-02f, 1.60998836e-01f,
  3.35635424e-01f, -2.55584657e-01f, 2.31936470e-01f, -1.57568946e-01f, -4.36189979e-01f, 3.31712991e-01f, -4.66879398e-01f, 3.06714624e-01f, -3.36293221e-01f, -2.72110879e-01f,
  -6.65278018e-01f, -6.72718167e-01f, -7.02056885e-02f, 4.24346849e-02f, -1.69398472e-01f, 3.75020027e-01f, 4.22066376e-02f, 2.17270106e-01f, -1.41679138e-01f, -5.64701855e-01f,
  4.24182385e-01f, 2.69138515e-01f, 1.07992634e-01f, -3.90960664e-01f, 6.56952560e-02f, -1.60616964e-01f, -3.68136913e-01f, -8.49155933e-02f, 2.11444423e-01f, -1.23103335e-01f,
  -3.19021612e-01f, 6.26870571e-03f, -7.69158602e-02f, -3.79076554e-03f, -1.57403380e-01f, -5.14158942e-02f, -3.20607930e-01f, -1.80154234e-01f, -6.53463602e-02f, -1.92769587e-01f,
  -3.56895208e-01f, 1.20584350e-02f, -2.43405953e-01f, -1.00702420e-01f, -1.89832836e-01f, 2.16556668e-01f, -7.89760053e-02f, -9.13465470e-02f, 1.23362243e-01f, 3.38458329e-01f,
  1.49554133e-01f, -8.49047154e-02f, -1.71957701e-01f, -3.03285956e-01f, -1.59384161e-01f, -1.31547526e-01f, 3.39681625e-01f, -8.18057656e-02f, 4.20259982e-02f, 2.52445459e-01f,
  1.11080930e-01f, 2.66918302e-01f, 1.83611065e-01f, 4.14103210e-01f, -2.68979341e-01f, 2.32162580e-01f, -3.56980622e-01f, -1.37013227e-01f, 7.67673552e-02f, -1.83406308e-01f,
  4.25912619e-01f, -3.75220269e-01f, -5.51574267e-02f, 4.05291587e-01f, 3.07104085e-03f, -5.82691908e-01f, -5.88332176e-01f, -9.38985422e-02f, 3.46354514e-01f, 1.23130329e-01f,
  2.61186302e-01f, 1.26638263e-01f, -3.62597741e-02f, 1.60284460e-01f, -6.07568920e-01f, -1.71468720e-01f, 2.17944048e-02f, 1.49480745e-01f, 1.58646833e-02f, 1.81099877e-01f,
  1.44805327e-01f, -1.46778122e-01f, -4.32502478e-02f, -3.21558028e-01f, 2.11799309e-01f, -1.40644714e-01f, -3.61035429e-02f, -1.40271366e-01f, 2.55651861e-01f, 1.76397532e-01f,
  2.73632497e-01f, 2.30428442e-01f, 1.06929831e-01f, 8.47467110e-02f, 2.59456057e-02f, 2.22430289e-01f, -3.23619008e-01f, -9.14904699e-02f, -7.18096551e-03f, -7.70723671e-02f,
  1.86077058e-01f, -1.56447887e-01f, -1.57384407e-02f, 3.27469647e-01f, 3.29339385e-01f, 3.31746668e-01f, 3.68219018e-01f, -2.69325584e-01f, 3.69554222e-01f, 5.12642205e-01f,
  -3.77455860e-01f, 1.35948673e-01f, 2.90196985e-01f, 1.27127528e-01f, 1.28024608e-01f, -4.91685897e-01f, -1.92367611e-03f, 4.05345470e-01f, -2.46723413e-01f, -2.65661836e-01f,
  -1.68202184e-02f, 7.31932893e-02f, -1.99529994e-02f, -3.91632527e-01f, 3.79783809e-01f, 1.88127384e-01f, -6.86423406e-02f, 2.11915970e-01f, 1.11784399e-01f, -2.97376335e-01f,
  3.24899018e-01f, -7.55954444e-01f, 2.12946385e-01f, -1.46612749e-01f, 2.73977160e-01f, 3.64756197e-01f, 2.75315821e-01f, -2.74420321e-01f, -3.39120120e-01f, -1.85157403e-01f,
  4.73200120e-02f, -2.22165912e-01f, -1.53038889e-01f, 5.28825745e-02f, 7.20582679e-02f, 1.44540668e-01f, 2.32780710e-01f, 2.53036022e-01f, 1.47917390e-01f, -2.09819511e-01f,
  1.46485984e-01f, -3.01871210e-01f, 1.12890303e-01f, 2.55825836e-02f, 1.58399910e-01f, -1.45613045e-01f, -1.16954548e-02f, 1.29266784e-01f, 5.87492995e-02f, 1.08085856e-01f,
  3.56769502e-01f, 2.61123359e-01f, 1.00592420e-01f, -4.82728183e-02f, -1.82324141e-01f, -1.73678815e-01f, 3.23453486e-01f, -3.51556540e-02f, -4.02427524e-01f, 3.68231386e-01f,
  -4.87308979e-01f, -3.41428757e-01f, -8.20715949e-02f, -4.81200039e-01f, -1.73029035e-01f, -4.57114905e-01f, 1.87877327e-01f, -5.45692444e-01f, 2.45089486e-01f, -3.67288589e-01f,
  -2.94335723e-01f, 3.38539705e-02f, -2.05074593e-01f, 1.17839381e-01f, 2.61100560e-01f, -5.65561131e-02f, 4.27811921e-01f, -2.97181398e-01f, 3.52463007e-01f, 2.42119461e-01f,
  6.50095269e-02f, -4.00211737e-02f, 3.65639627e-01f, 4.58022058e-01f, 1.11651279e-01f, 6.71452209e-02f, 3.32949728e-01f, -2.72355527e-01f, -8.55859637e-01f, -4.14440393e-01f,
  -1.71534847e-02f, 8.04079026e-02f, -7.77584016e-02f, -1.43130377e-01f, 1.62924469e-01f, -1.23843905e-02f, 1.33591756e-01f, -1.95639908e-01f, 8.69922489e-02f, 2.25755218e-02f,
  -7.40738064e-02f, -2.29693558e-02f, 2.05661729e-01f, 3.15119587e-02f, -8.53281468e-02f, 9.33556855e-02f, -1.81350961e-01f, 2.46036127e-01f, -3.96864442e-03f, 1.48393512e-01f,
  -1.26164213e-01f, 3.62660969e-03f, 2.21404031e-01f, 6.66313246e-02f, 3.13842386e-01f, 1.19777374e-01f, 6.24447949e-02f, 1.34070247e-01f, 2.22275198e-01f, 5.14675438e-01f,
  2.09557638e-01f, 8.69612247e-02f, -2.03286707e-01f, -4.14549798e-01f, -4.48236428e-02f, 4.24379677e-01f, -4.16586846e-01f, -2.48679116e-01f, -3.88634503e-01f, -5.62902451e-01f,
  -5.29357731e-01f, -3.90604109e-01f, 4.52884026e-02f, -3.15188497e-01f, -5.32789648e-01f, -2.17767179e-01f, 4.52177018e-01f, -3.72008175e-01f, -4.67216730e-01f, 5.86032048e-02f,
  3.08474481e-01f, 4.18026417e-01f, 1.49225846e-01f, 1.84062496e-01f, -6.40016913e-01f, -1.39943019e-01f, 2.88790435e-01f, 1.92999020e-01f, 1.67422161e-01f, -3.68490607e-01f,
  -4.83830363e-01f, 3.16690564e-01f, 3.70553881e-02f, -2.26848722e-01f, -2.47428231e-02f, -5.74474633e-01f, -2.39599720e-01f, 5.10187984e-01f, -2.91821044e-02f, -2.19162807e-01f,
  -1.98007282e-02f, 1.60981327e-01f, -3.62329446e-02f, -2.26515993e-01f, -1.81748480e-01f, 3.00633684e-02f, 1.69316530e-01f, 1.10947024e-02f, -1.37278810e-02f, 6.09568618e-02f,
  -8.52395073e-02f, 4.09790650e-02f, -3.52691785e-02f, -5.43993637e-02f, 1.00473106e-01f, 1.41330600e-01f, 2.22283136e-02f, -5.62849417e-02f, -9.59644169e-02f, -8.83654729e-02f,
  -8.95786285e-02f, 1.23324528e-01f, 2.01639403e-02f, -3.75128984e-02f, 8.01038668e-02f, -2.35631347e-01f, 3.04949790e-01f, 8.41953978e-02f, 3.04052662e-02f, 1.92675769e-01f,
  3.43172462e-03f, 2.12552711e-01f, 3.10025305e-01f, -3.36395264e-01f, -3.05004448e-01f, -3.79584163e-01f, 2.31915623e-01f, 2.72407800e-01f, 3.01200897e-01f, 2.94784337e-01f,
  2.21875459e-01f, 1.20543607e-01f, -2.88970768e-01f, -7.26123005e-02f, -1.26804635e-02f, 4.06568408e-01f, -4.00148600e-01f, -3.38623703e-01f, -6.99139714e-01f, 3.55399638e-01f,
  -4.62993830e-01f, 3.72267753e-01f, 9.82404053e-02f, 1.53849691e-01f, -8.70118961e-02f, -3.82425100e-01f, 1.58411264e-01f, -1.85796291e-01f, 1.14339665e-01f, 4.15198773e-01f,
  -3.06439251e-01f, -3.85837287e-01f, -4.12362851e-02f, -2.46133238e-01f, 8.81196707e-02f, 6.19539358e-02f, -8.76304880e-02f, -2.11652383e-01f, -2.38096882e-02f, -1.20983161e-01f,
  -6.25041872e-02f, 1.35803685e-01f, 9.14851204e-02f, 1.14914626e-01f, -9.13008302e-02f, 5.58926463e-02f, 7.79805034e-02f, -9.47947055e-02f, -8.91647935e-02f, 1.59754768e-01f,
  -2.11167373e-02f, 3.80630679e-02f, 1.02623574e-01f, 7.90248290e-02f, 1.61639377e-01f, 4.83697243e-02f, 2.73252670e-02f, 2.93856263e-01f, 2.04008207e-01f, -2.12633818e-01f,
  -2.08987892e-01f, 1.81266487e-01f, 2.87800968e-01f, -3.24104100e-01f, -3.45457762e-01f, 2.82864869e-01f, 2.48944446e-01f, -4.12183076e-01f, -3.51944715e-01f, -3.48953933e-01f,
  -2.56365955e-01f, 4.62845773e-01f, 2.62970179e-01f, -2.39218131e-01f, 1.21286690e-01f, 2.23667949e-01f, 5.94302490e-02f, -1.08305641e-01f, -2.51177311e-01f, 2.03656361e-01f,
  1.72919661e-01f, -2.36085340e-01f, -5.95349550e-01f, -2.20527723e-01f, 2.88108051e-01f, -3.30195546e-01f, -3.75945181e-01f, 4.87692982e-01f, -3.32656235e-01f, -4.46432322e-01f,
  -5.37675977e-01f, -3.32495391e-01f, -3.82910490e-01f, -1.01588026e-01f, 2.30779096e-01f, 4.52705443e-01f, -1.17622405e-01f, 1.40672863e-01f, -5.93403168e-02f, -6.49050921e-02f,
  7.29928985e-02f, 1.49411127e-01f, -2.74275571e-01f, 1.75163120e-01f, -9.52777267e-02f, -9.26060379e-02f, 2.24509493e-01f, 7.06954449e-02f, 8.30598548e-02f, 2.16037426e-02f,
  -1.17621891e-01f, 3.14455181e-02f, -1.24459527e-01f, 5.80226369e-02f, -3.37732315e-01f, -5.67656867e-02f, -2.40052998e-01f, -1.49754778e-01f, 2.17271484e-02f, 1.07693590e-01f,
  -9.69877467e-02f, -3.61974001e-01f, 7.21742138e-02f, -3.71274263e-01f, -2.86148876e-01f, -1.96139172e-01f, -6.26733750e-02f, 1.29190490e-01f, -3.89403284e-01f, -2.95088887e-01f,
  -1.78958997e-01f, 3.23518127e-01f, 1.74184859e-01f, -1.43797949e-01f, 2.39209443e-01f, -1.48430645e-01f, -4.17062156e-02f, -3.01600993e-01f, -5.66641763e-02f, -7.20954761e-02f,
  2.98726678e-01f, 2.16631606e-01f, 3.00195009e-01f, 2.87528545e-01f, -2.57833600e-01f, 4.89557013e-02f, -2.76555777e-01f, -2.66200334e-01f, -5.83773732e-01f, 3.21723253e-01f,
  4.04672742e-01f, -4.66758907e-01f, -4.95452017e-01f, -2.57741570e-01f, 1.68002278e-01f, 3.15286130e-01f, 2.36230850e-01f, -2.93048322e-01f, 2.59058088e-01f, -7.05621302e-01f,
  -4.21888411e-01f, 7.18371570e-02f, -9.55714956e-02f, 8.40438679e-02f, -2.49982059e-01f, 1.95812866e-01f, -1.22729443e-01f, -4.00945663e-01f, -1.08699732e-01f, -1.69850122e-02f,
  -5.59845194e-02f, 1.98373243e-01f, -3.18787068e-01f, -4.82852943e-02f, -1.31626287e-03f, -2.43522674e-01f, -2.68491749e-02f, 1.15250617e-01f, 3.03188954e-02f, 1.28477827e-01f,
  2.98019052e-02f, 1.64527640e-01f, 2.10307196e-01f, -1.79426685e-01f, 2.60318130e-01f, -2.57363379e-01f, 2.34863639e-01f, -3.92079949e-01f, 3.81736517e-01f, 3.71764690e-01f,
  2.82487065e-01f, 3.96448255e-01f, 2.85045832e-01f, 2.27128565e-01f, 4.02182221e-01f, 2.89034396e-01f, -2.44882658e-01f, 2.65882701e-01f, -2.51964759e-02f, 2.30765492e-01f,
  -1.23657687e-02f, -5.52899003e-01f, 2.47642368e-01f, 1.58140987e-01f, -3.31489027e-01f, 3.85780305e-01f, 1.81855172e-01f, -2.65815586e-01f, -4.45499957e-01f, -4.81113158e-02f,
  3.94702882e-01f, -2.78396364e-02f, -5.53143978e-01f, 1.19962774e-01f, -4.16859418e-01f, 2.04569817e-01f, -1.58523366e-01f, 3.00635904e-01f, 1.37123927e-01f, -1.38379931e-01f,
  -2.04525575e-01f, -1.07184887e-01f, -3.65832776e-01f, 2.63487607e-01f, 8.16882104e-02f, -3.09226364e-01f, 1.20816931e-01f, 3.61571857e-03f, -3.18810612e-01f, -1.60708770e-01f,
  -1.75615758e-01f, 1.86260343e-01f, -1.15179077e-01f, 7.66612217e-03f, -2.07854822e-01f, 7.42557570e-02f, 1.17513329e-01f, -2.99071729e-01f, 1.25296801e-01f, 1.59779176e-01f,
  1.18762620e-01f, -8.64833519e-02f, 2.94394195e-02f, -2.37901017e-01f, -3.40385020e-01f, -2.31361136e-01f, -8.05733819e-03f, 1.56501085e-01f, 1.37471333e-01f, 9.94005874e-02f,
  -1.49087071e-01f, -1.97028667e-02f, -3.48597765e-01f, 7.52489939e-02f, 2.27447569e-01f, -3.11228991e-01f, 2.64757484e-01f, 3.35460514e-01f, -2.90622771e-01f, -2.24567786e-01f,
  3.34240347e-01f, 1.66323528e-01f, 8.89465958e-02f, -1.76982582e-01f, -2.64244527e-01f, -1.88297272e-01f, -8.87852013e-02f, 3.27774942e-01f, -2.50951260e-01f, 5.93015552e-02f,
  1.67885110e-01f, -3.41966540e-01f, -2.74189830e-01f, -1.85455814e-01f, -1.02760241e-04f, -4.58447576e-01f, 4.68115211e-01f, 2.83612370e-01f, -4.43737537e-01f, 1.14889510e-01f,
  1.01026468e-01f, 7.12610111e-02f, 1.90377936e-01f, 3.14335108e-01f, -5.02832711e-01f, -6.66027844e-01f, -1.37927622e-01f, -1.36450693e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.31197062e-02f, 1.72700554e-01f, -1.10672459e-01f, -4.83567175e-03f, -1.22933120e-01f, -1.55558273e-01f, 1.07062459e-01f, -2.67237742e-02f, 2.91411523e-02f, -6.39554113e-02f,
  1.04409494e-01f, -1.67774230e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    