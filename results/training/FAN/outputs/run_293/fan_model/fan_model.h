/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.70327801e-01f, 6.56043291e-02f, -8.72013271e-02f, 2.93586344e-01f, 1.15328789e-01f, 8.35814551e-02f, -2.69934088e-02f, 7.67068043e-02f, 9.90496278e-02f, 8.59184861e-02f,
  2.68089306e-02f, 1.49457818e-02f, -3.46172571e-01f, 2.14037791e-01f, -1.11233003e-01f, -3.49668801e-01f, 2.69337028e-01f, 9.48326513e-02f, -5.95071763e-02f, 2.45420471e-01f,
  2.24414300e-02f, 1.97056904e-01f, -1.08482860e-01f, 1.16070561e-01f, 1.90955237e-01f, 9.94100869e-02f, -3.51042710e-02f, -2.38477841e-01f, 2.57475138e-01f, -1.20539907e-02f,
  6.02256730e-02f, 1.69303343e-02f, 5.84162138e-02f, -1.95183475e-02f, 1.58188380e-02f, 5.83190992e-02f, 4.12301607e-02f, -6.74072281e-02f, 9.16694058e-04f, 2.22450122e-02f,
  4.67150137e-02f, 3.69519740e-02f, 1.01347946e-01f, -7.23505244e-02f, 8.78166705e-02f, 2.87068989e-02f, 3.06686871e-02f, -5.33476286e-02f, -4.93128076e-02f, -4.54084426e-02f,
  -2.30207983e-02f, 7.48918345e-03f, 1.19288944e-01f, 5.07847704e-02f, -5.04059978e-02f, 1.73484422e-02f, 1.27497851e-03f, -2.73930691e-02f, 6.59356862e-02f, 5.88049553e-02f,
  3.73824537e-02f, 2.23443247e-02f, -5.50370105e-02f, -1.72059461e-02f, -1.81972496e-02f, 1.39008509e-02f, -6.04475103e-03f, -3.03989109e-02f, -1.36018423e-02f, -3.56403477e-02f,
  1.56531204e-02f, 3.51183563e-02f, 5.85237034e-02f, 4.36865464e-02f, 4.55209166e-02f, 3.77737246e-02f, -1.94078945e-02f, -1.22735938e-02f, 3.17331143e-02f, 3.84675972e-02f,
  -6.82471916e-02f, 3.61833721e-02f, -8.61569867e-03f, 1.21860681e-02f, -4.68318276e-02f, -4.87241894e-03f, 3.74250822e-02f, 2.59871036e-02f, -3.31990421e-02f, -2.40500947e-03f,
  -1.26572698e-02f, -3.29919420e-02f, -7.82504752e-02f, -4.10864241e-02f, -1.70289241e-02f, 1.94211416e-02f, 2.21174154e-02f, 1.21760722e-02f, -5.11281118e-02f, 3.70324124e-03f,
  4.28868718e-02f, 3.08391694e-02f, -2.56372504e-02f, 9.55411419e-03f, 1.02642700e-02f, -3.74303362e-03f, -2.06944416e-03f, 7.92590678e-02f, 1.14770040e-01f, 9.44020525e-02f,
  6.07790276e-02f, 1.51851159e-02f, -7.46198222e-02f, 9.89555474e-03f, 4.56624702e-02f, 3.19183394e-02f, 3.44718024e-02f, 3.34141478e-02f, -1.55526428e-02f, -4.86031407e-03f,
  1.74004927e-01f, -2.78697401e-01f, -5.98058701e-02f, 3.97340544e-02f, -1.66415691e-01f, 1.86370626e-01f, 1.63680539e-01f, -2.85932869e-01f, 3.97459231e-02f, -1.09137692e-01f,
  1.16711535e-01f, 1.01128668e-01f, -1.37430821e-02f, 1.81672141e-01f, 4.28717434e-01f, 2.24628642e-01f, 2.13381439e-01f, 1.92412093e-01f, -4.69412953e-02f, -7.54629448e-02f,
  -5.58994059e-03f, -4.25324067e-02f, 9.38147120e-03f, -3.94696176e-01f, -9.41665992e-02f, -2.75618345e-01f, -9.08964202e-02f, -1.58209488e-01f, -1.95953064e-02f, 6.29923418e-02f,
  7.40630850e-02f, -7.22701773e-02f, -3.34122702e-02f, -7.56406114e-02f, -3.85055169e-02f, 2.07527652e-02f, 5.75935468e-02f, 6.58128187e-02f, 1.22647621e-02f, -3.23826671e-02f,
  5.96931949e-02f, -4.90425751e-02f, 3.43278609e-02f, -1.92838553e-02f, -5.44726439e-02f, -7.47129470e-02f, 6.24352396e-02f, -5.43314824e-03f, -1.01375923e-01f, 7.07218722e-02f,
  1.50208436e-02f, 8.71482044e-02f, 2.06940472e-02f, 5.48800230e-02f, 8.92493688e-03f, -3.40053160e-03f, 4.54569645e-02f, 7.25216195e-02f, -7.53018539e-03f, -1.13392472e-02f,
  2.80544348e-02f, -4.18812893e-02f, -3.26649193e-03f, -5.31905890e-02f, 2.62000076e-02f, -3.30746621e-02f, -8.36705975e-03f, 5.58929984e-03f, 7.04462361e-03f, 7.45178107e-03f,
  -5.26555963e-02f, 2.75134910e-02f, 5.49451727e-03f, 2.65171155e-02f, 1.13291023e-02f, 4.94659832e-03f, 1.56304836e-02f, 5.87479323e-02f, -4.53011356e-02f, 2.01389138e-02f,
  1.52627723e-02f, -1.56180253e-02f, -2.17553489e-02f, -2.64429338e-02f, -3.33859888e-03f, -4.37088162e-02f, 1.12721175e-02f, -2.35863943e-02f, 3.51775847e-02f, -1.24135974e-03f,
  -1.55578122e-01f, -2.32830435e-01f, -6.59894496e-02f, 2.68362230e-03f, 4.64799255e-02f, -1.50461253e-02f, 4.17832695e-02f, 1.48998173e-02f, -1.31621554e-01f, 1.05869919e-02f,
  -4.81444784e-02f, 4.52301465e-02f, -8.35652053e-02f, 2.10978072e-02f, -6.71738340e-03f, -6.77656941e-03f, 1.66356955e-02f, -6.49761967e-03f, -3.55359204e-02f, 1.91482790e-02f,
  -1.84873622e-02f, -3.93875092e-02f, -1.72125883e-02f, -9.94154811e-02f, 1.14554875e-02f, 2.82165334e-02f, -1.11184167e-02f, -4.94416878e-02f, 1.55623145e-02f, -9.91085730e-03f,
  3.80527973e-01f, -5.47278635e-02f, 4.02705640e-01f, 1.67796671e-01f, -1.61014274e-01f, 2.57044911e-01f, 3.60421687e-01f, -2.69521773e-02f, 1.98171452e-01f, -1.59684703e-01f,
  -1.55051509e-02f, 6.96418285e-02f, 1.69645682e-01f, -2.15270557e-02f, 3.84957612e-01f, 1.70397863e-01f, 1.67676806e-01f, 1.29610926e-01f, -9.57319979e-03f, 9.73363966e-02f,
  5.68604097e-02f, -1.33300692e-01f, 1.45946413e-01f, -2.55779922e-01f, 7.69937038e-02f, -4.47037555e-02f, -1.91651002e-01f, -8.35625976e-02f, -8.43348280e-02f, -2.61573568e-02f,
  -3.75809669e-02f, -1.86745413e-02f, -2.05673248e-04f, 2.49499083e-02f, 1.12883031e-01f, -1.72397271e-02f, -1.09095797e-02f, -1.43273659e-02f, 5.40909823e-03f, 1.00964503e-02f,
  9.20943171e-03f, -3.57090533e-02f, 1.68551411e-02f, -7.18041956e-02f, 2.60777511e-02f, 1.10548101e-02f, 1.39905410e-02f, 3.04712486e-02f, -5.48291318e-02f, 6.13009743e-03f,
  8.19496438e-02f, -3.98498727e-03f, 8.40784237e-02f, -5.23018986e-02f, 2.90743690e-02f, -1.59184337e-02f, 1.82144493e-02f, 3.86074297e-02f, 2.13395413e-02f, 5.54672107e-02f,
  3.50965075e-02f, 7.03880787e-02f, 1.89613998e-02f, -1.42705080e-03f, -6.52499264e-03f, 2.13016775e-02f, -9.94645432e-03f, -4.77653928e-02f, 3.17907073e-02f, -2.20064651e-02f,
  -1.16416533e-03f, -5.01336791e-02f, -7.50845298e-02f, 5.17979776e-03f, 1.12168267e-02f, 7.04001810e-04f, 1.17755830e-02f, -5.75729050e-02f, 6.67393357e-02f, -3.61971511e-03f,
  -4.67547812e-02f, 4.13318351e-02f, -4.88673858e-02f, 1.06594916e-02f, -3.34640569e-03f, 3.56967337e-02f, 5.45853563e-03f, 5.07014766e-02f, 4.32873284e-03f, 1.69148576e-02f,
  4.76335995e-02f, -3.18796970e-02f, 5.53202480e-02f, -8.93777013e-02f, 3.05311382e-02f, 7.14697735e-03f, 5.75858504e-02f, 1.78178102e-02f, 6.32144650e-03f, 5.23620658e-02f,
  -3.94998528e-02f, 1.83376968e-02f, 5.29238908e-03f, -8.13989062e-03f, -1.94200577e-04f, 8.76890845e-04f, -1.98254958e-02f, -1.18790753e-02f, 5.43882046e-03f, -2.96455976e-02f,
  -1.27511052e-02f, -8.29599332e-03f, -5.80492616e-02f, 1.63778421e-02f, -6.46315962e-02f, 3.07522546e-02f, 4.93965410e-02f, -1.32486708e-02f, -4.46294025e-02f, 3.49997319e-02f,
  5.00829332e-02f, 1.19576104e-01f, 3.04624140e-01f, -1.60668224e-01f, -2.10047171e-01f, 6.11669421e-02f, -7.63563160e-03f, -9.32435319e-02f, 2.26523787e-01f, 1.26691759e-01f,
  -2.68315494e-01f, 2.77092934e-01f, 7.99439251e-02f, -5.45969382e-02f, -1.20178580e-01f, 8.23358744e-02f, -3.64873521e-02f, 4.38430905e-02f, 7.23084584e-02f, -1.30965069e-01f,
  -8.67371038e-02f, -4.62138444e-01f, -3.94361168e-02f, -1.59653634e-01f, -1.62346452e-01f, 1.93475876e-02f, -2.25446954e-01f, -4.51825634e-02f, -1.36453971e-01f, -3.83375678e-03f,
  2.06042752e-02f, -7.64733329e-02f, -3.29919159e-02f, 6.33732677e-02f, -5.59057556e-02f, 2.06307182e-03f, 2.31695548e-02f, -9.49218497e-03f, 1.72924753e-02f, -2.14204285e-02f,
  4.29979376e-02f, -5.61733590e-03f, 1.90127417e-02f, -8.07070755e-04f, 3.41829062e-02f, 5.21409884e-03f, 4.19756360e-02f, 1.33214612e-02f, 5.22908121e-02f, 7.22755045e-02f,
  9.36530977e-02f, 7.16749206e-02f, 1.05358385e-01f, 7.10357800e-02f, 5.34545630e-02f, 2.79798638e-02f, 7.78186694e-02f, 7.84045830e-02f, 2.07882170e-02f, 5.92519566e-02f,
  5.02005499e-03f, -2.48777140e-02f, -2.55211238e-02f, -3.92943770e-02f, -3.07034310e-02f, -2.16266774e-02f, -1.80223100e-02f, 7.74324778e-03f, -6.30512089e-03f, -1.91827025e-02f,
  -5.20560741e-02f, -3.72797549e-02f, 3.30591720e-04f, -1.59566198e-02f, -4.29068767e-02f, 2.10552085e-02f, -7.54482672e-03f, -2.32735407e-02f, 5.06256446e-02f, -3.93079072e-02f,
  -2.58255750e-02f, 3.02665550e-02f, -6.72185719e-02f, 2.39691208e-03f, -6.07734406e-03f, 4.83132899e-03f, -4.77814628e-03f, 5.87517284e-02f, 1.27705038e-02f, -7.83225894e-02f,
  -1.95479423e-01f, -9.46588144e-02f, -3.05310488e-02f, 1.06073869e-02f, -1.51611650e-02f, -3.88055928e-02f, -4.37377691e-02f, 3.63077968e-02f, -7.23825942e-04f, 5.21203466e-02f,
  -1.48952776e-03f, -5.46984265e-05f, -1.62184052e-02f, -1.84963103e-02f, -1.95795018e-02f, 1.60099175e-02f, -4.79385480e-02f, -3.17251794e-02f, -1.22399241e-01f, -9.58582610e-02f,
  -1.14986934e-01f, -3.70590836e-02f, 1.92730054e-02f, -5.07793427e-02f, -5.76627031e-02f, -2.19167266e-02f, -4.16365489e-02f, 1.01663340e-02f, -4.37959582e-02f, 1.41092595e-02f,
  -3.24350744e-01f, 2.74321109e-01f, -5.48846312e-02f, -5.29181957e-02f, -1.03926040e-01f, 2.90426701e-01f, 1.95047647e-01f, 4.23293449e-02f, -3.94234620e-02f, 2.98418224e-01f,
  6.69858828e-02f, 1.21970691e-01f, 1.56932682e-01f, 4.01161492e-01f, -1.35548003e-02f, 1.86725721e-01f, 1.98400080e-01f, 2.07570314e-01f, -2.98402999e-02f, -4.81171943e-02f,
  -8.96058828e-02f, 2.86012441e-01f, 5.51111922e-02f, 5.30758426e-02f, -5.84279560e-02f, -8.74390826e-02f, -1.04095362e-01f, -3.78904678e-02f, 1.38669193e-01f, 6.54940084e-02f,
  9.42564234e-02f, -9.13294591e-03f, -4.12751101e-02f, 1.96004771e-02f, -8.20434988e-02f, -5.11788055e-02f, -3.59372012e-02f, -3.01054846e-02f, -5.96365109e-02f, 1.08417450e-03f,
  -2.11268496e-02f, 5.82289125e-04f, 5.52824624e-02f, 3.04604638e-02f, -7.99684152e-02f, -6.45381883e-02f, 2.02630721e-02f, -3.11721470e-02f, 8.47907364e-02f, 4.53958893e-03f,
  2.67857453e-03f, 3.24026239e-03f, -2.53494307e-02f, 6.63490519e-02f, -6.47722781e-02f, 9.41217691e-03f, 3.82663719e-02f, -1.66382082e-02f, 1.89565830e-02f, 3.68173793e-03f,
  -2.20972244e-02f, 1.41622825e-02f, 3.29221995e-03f, 2.48478986e-02f, 2.51012873e-02f, -7.73231080e-03f, 3.61829773e-02f, 5.24609387e-02f, -4.22832407e-02f, 3.05003989e-02f,
  -6.53234450e-03f, -4.05347645e-02f, 2.61910949e-02f, -3.10259685e-02f, -1.43064326e-02f, 1.75037757e-02f, -5.50054871e-02f, 6.58970186e-03f, -3.01619153e-02f, -3.17415893e-02f,
  -1.78516824e-02f, 2.72143558e-02f, 1.43928444e-02f, 2.40267743e-03f, 3.67521681e-02f, -1.62101202e-02f, 1.76525395e-02f, 1.27810026e-02f, -1.05184643e-02f, -4.24095802e-02f,
  1.61760062e-01f, 5.95208965e-02f, 5.58654480e-02f, 5.31592369e-02f, 4.73814718e-02f, -4.13430333e-02f, 1.14408927e-02f, -7.01343734e-03f, 5.41299693e-02f, -6.10885583e-03f,
  -7.90765136e-02f, -4.94223274e-02f, -2.25434247e-02f, 1.00693628e-02f, 6.77402169e-02f, 5.84225245e-02f, -2.67970134e-02f, -3.48499604e-02f, -2.18963213e-02f, -1.67893674e-02f,
  -2.56781280e-02f, -3.11323367e-02f, -5.09908646e-02f, -3.81993018e-02f, 5.79768270e-02f, -2.05556173e-02f, -3.87831219e-02f, -7.36820102e-02f, 1.47476094e-02f, 2.14384031e-02f,
  1.86267033e-01f, -1.95885822e-01f, -1.22287171e-02f, 1.34338230e-01f, -3.38204890e-01f, -1.37557283e-01f, 2.31599748e-01f, -2.96189457e-01f, -2.27758363e-01f, 7.02537000e-02f,
  9.52208042e-02f, 3.58824767e-02f, 3.25906754e-01f, -4.08709310e-02f, 3.58218819e-01f, 1.92210674e-01f, -5.45149706e-02f, 4.26147841e-02f, -1.98212698e-01f, -5.41670099e-02f,
  -3.37702595e-02f, 8.21160451e-02f, 2.26221159e-01f, -1.92585126e-01f, -4.23764661e-02f, -9.77150202e-02f, 2.01427594e-01f, -2.18676515e-02f, -2.00125873e-02f, -1.43400030e-02f,
  1.99200604e-02f, -1.34985298e-01f, 5.32957502e-02f, -7.03113079e-02f, 2.68518552e-03f, 8.97846557e-03f, 5.78281730e-02f, 9.93368924e-02f, 2.59880181e-02f, -4.10580970e-02f,
  5.83114568e-03f, -2.66800541e-02f, -6.97605312e-02f, 3.12781706e-02f, -1.29298359e-01f, -2.04809587e-02f, -1.09913006e-01f, -2.96380259e-02f, -1.83064546e-02f, -7.89471194e-02f,
  -9.76212323e-03f, -7.52966553e-02f, -2.92538311e-02f, -4.93455231e-02f, -2.01775283e-02f, -5.53577244e-02f, -1.01327281e-02f, 3.42857018e-02f, -5.32837361e-02f, -1.03744462e-01f,
  -5.68870157e-02f, -9.00350511e-02f, -1.68067794e-02f, 2.37894878e-02f, -3.81321199e-02f, -1.62698627e-02f, -3.89708169e-02f, 7.34762400e-02f, -5.27247414e-02f, 2.03093179e-02f,
  1.47844171e-02f, -1.35470135e-02f, -7.71739557e-02f, -5.27762845e-02f, 5.46466261e-02f, -2.74344459e-02f, 9.76814143e-03f, -1.05082418e-03f, -4.58186641e-02f, 2.74155717e-02f,
  -1.66859049e-02f, -2.01416202e-02f, 7.14688897e-02f, -1.19896848e-02f, -2.90151015e-02f, 1.67055372e-02f, -7.14592636e-02f, -1.75893735e-02f, -5.53310961e-02f, 8.05982426e-02f,
  -9.84380394e-02f, -8.10278766e-03f, 3.04134004e-02f, -1.54269545e-03f, 5.47843017e-02f, -1.33412313e-02f, -2.17857044e-02f, -1.09433837e-01f, -8.28287564e-03f, 9.74216964e-03f,
  -1.32990126e-02f, 7.97978416e-03f, 2.34482307e-02f, -2.24893223e-02f, 2.07332112e-02f, -6.71679201e-03f, 1.06645457e-01f, -1.07407225e-02f, 3.29311565e-02f, -1.40483705e-02f,
  -3.62569876e-02f, -3.93213145e-02f, -1.68787278e-02f, -4.11415249e-02f, -2.87849475e-02f, 2.80076731e-02f, -7.45258778e-02f, -8.83295760e-02f, 3.63238971e-03f, 2.91189812e-02f,
  5.46404682e-02f, -1.98191509e-01f, 1.38416305e-01f, -3.78549658e-02f, 2.64881372e-01f, 9.41835940e-02f, -3.89603637e-02f, -1.35678509e-02f, -2.60404218e-02f, -1.45145297e-01f,
  -5.04952148e-02f, 1.88252446e-03f, -8.36106464e-02f, -2.30664015e-01f, -4.11395788e-01f, -3.06833327e-01f, -2.60921121e-01f, -1.50079742e-01f, -3.44513841e-02f, 2.88077183e-02f,
  -8.64657201e-03f, -8.02992433e-02f, -1.17416762e-01f, 1.46828488e-01f, 1.82948560e-01f, 2.32193783e-01f, -1.13830872e-01f, 2.26170048e-01f, 2.41297036e-02f, 3.49919684e-02f,
  -6.50049597e-02f, -8.57957751e-02f, 3.06173190e-02f, -3.37919183e-02f, -1.56079931e-02f, 6.20608181e-02f, 2.48863716e-02f, 3.62148359e-02f, 1.91011075e-02f, 5.95374368e-02f,
  3.87412426e-03f, 4.41028513e-02f, 3.18397284e-02f, -4.71341088e-02f, 4.03516665e-02f, 4.05855104e-02f, 5.41216657e-02f, 8.06943029e-02f, 1.22266784e-01f, 6.41246811e-02f,
  1.45299984e-02f, 2.79311500e-02f, 8.92989412e-02f, -6.38065021e-03f, 1.35405306e-02f, 2.91269813e-02f, 3.68086994e-02f, 6.02128869e-03f, -3.23133841e-02f, 4.02488150e-02f,
  -4.52791490e-02f, -5.51333241e-02f, 1.01606315e-02f, 8.12461250e-04f, -3.37572247e-02f, 6.32346496e-02f, -2.90514398e-02f, 4.73235548e-02f, 8.38245917e-03f, 2.35340334e-02f,
  7.58572528e-03f, 2.20404193e-02f, 2.39738654e-02f, 2.04342268e-02f, 1.12905707e-02f, 4.87751551e-02f, 1.63517427e-02f, 1.88856591e-02f, -1.12662278e-02f, 6.24270663e-02f,
  1.13525502e-02f, -2.05425695e-02f, 7.78969331e-03f, 6.14944324e-02f, -1.82539411e-02f, -1.25802960e-02f, 3.85696366e-02f, 5.53040169e-02f, -1.82151645e-02f, 5.59439976e-03f,
  -1.68088391e-01f, -2.81993717e-01f, 2.41289940e-02f, 6.51310086e-02f, -6.27282411e-02f, -5.99599816e-02f, -5.26367575e-02f, 4.31418093e-03f, -8.19319636e-02f, -3.30912843e-02f,
  4.34299186e-02f, 6.99206293e-02f, -3.78973670e-02f, 2.77498960e-02f, -2.57658176e-02f, -6.07967824e-02f, -2.13631094e-02f, -3.19933072e-02f, -4.69720736e-02f, -4.14801948e-02f,
  5.13813160e-02f, 1.93446211e-03f, -9.28521343e-03f, 5.99861965e-02f, 7.13951439e-02f, 5.49751036e-02f, 1.61334779e-02f, 1.18867168e-02f, 3.37268487e-02f, -3.93951386e-02f,
  -1.62456334e-01f, -2.69570142e-01f, 1.55056313e-01f, -1.55692130e-01f, 1.41816080e-01f, 1.97616652e-01f, 1.45579442e-01f, -1.13693282e-01f, 2.14542877e-02f, -3.14351171e-01f,
  -7.12543800e-02f, -1.60316437e-01f, 1.69823155e-01f, -1.16470024e-01f, 3.13699841e-01f, 2.27996469e-01f, -1.02523588e-01f, -1.05565973e-01f, 1.08305611e-01f, -1.39755175e-01f,
  2.35152785e-02f, -1.42165110e-01f, 1.63715735e-01f, -1.14575990e-01f, -1.23633742e-01f, -8.89231041e-02f, -1.17657579e-01f, 1.80774704e-01f, -1.15253605e-01f, 3.82709801e-02f,
  -9.89943296e-02f, -1.59929067e-01f, 3.76984477e-02f, 3.22947465e-02f, -4.12295572e-02f, -1.12773720e-02f, -1.32785039e-02f, 1.37367845e-01f, -7.03837443e-03f, -3.75972986e-02f,
  6.41544582e-03f, 6.72414340e-03f, -3.64027545e-02f, 5.47157936e-02f, 1.08956336e-03f, -1.20060099e-02f, -1.90337515e-03f, -3.86523246e-03f, -1.24309240e-02f, 8.88340846e-02f,
  4.06771936e-02f, -2.42876001e-02f, 3.84881012e-02f, -7.53464177e-02f, 5.23148067e-02f, -3.25077288e-02f, 6.82002008e-02f, -1.05096269e-02f, -8.49555135e-02f, 2.34864000e-02f,
  4.53256294e-02f, 2.46695112e-02f, 4.10124399e-02f, -3.07053048e-02f, 3.66892628e-02f, -5.19558303e-02f, 6.17086329e-03f, -8.75526667e-03f, -8.83898232e-03f, 1.34613976e-04f,
  1.10162795e-02f, -9.34626684e-02f, 2.48341858e-02f, 2.71042939e-02f, -8.55920464e-02f, -4.68408205e-02f, 2.73913108e-02f, -5.43846563e-02f, -1.37958080e-02f, 1.17513407e-02f,
  5.69501251e-04f, 2.30602399e-02f, -1.65195595e-02f, -6.87480643e-02f, 7.28460681e-03f, 4.56985608e-02f, -6.95969164e-02f, -1.54222816e-03f, -1.71872543e-03f, 6.73480630e-02f,
  -1.57030329e-01f, -2.84326077e-01f, 4.68946174e-02f, -1.09268390e-01f, -6.09722026e-02f, 1.44716166e-03f, 8.70323628e-02f, 9.26422328e-03f, 6.78375438e-02f, 3.95126990e-05f,
  -5.62202223e-02f, -6.69559166e-02f, -6.85691833e-02f, -3.22734490e-02f, 2.37506051e-02f, -1.75777841e-02f, -3.63764577e-02f, 1.67830661e-02f, 1.08018154e-02f, -5.16224504e-02f,
  -1.62912812e-02f, -2.41311546e-02f, 6.84420485e-03f, 3.40437144e-03f, -1.34387165e-02f, -1.86569651e-03f, -6.05845116e-02f, 7.53266141e-02f, 4.14078273e-02f, -7.79708009e-03f,
  4.10311788e-01f, 8.42994004e-02f, -1.57364726e-01f, -2.49814633e-02f, 3.31739962e-01f, 4.00162250e-01f, 1.23772450e-01f, 2.88333416e-01f, 2.01713249e-01f, -8.47719163e-02f,
  1.46812107e-02f, -1.25242501e-01f, -1.76970348e-01f, 1.11911379e-01f, 7.45710824e-03f, -1.35717183e-01f, 1.76431000e-01f, 5.91608733e-02f, 9.83912349e-02f, 1.40864402e-01f,
  1.06372714e-01f, 1.14742704e-01f, -1.60016030e-01f, 1.00428142e-01f, 1.85194910e-01f, -3.13393883e-02f, -2.08500862e-01f, -9.18739587e-02f, -3.73011716e-02f, 1.02905268e-02f,
  1.30988851e-01f, 4.01014350e-02f, -2.24407762e-02f, -2.50059031e-02f, 1.05064720e-01f, 1.11587187e-02f, -1.37257101e-02f, -7.29138777e-02f, -4.53540236e-02f, 2.19929293e-02f,
  -4.01502587e-02f, 5.40378364e-03f, -2.46498436e-02f, -1.03073176e-02f, 6.50456473e-02f, -3.79901938e-02f, 2.08037980e-02f, 7.03821331e-02f, -2.12515169e-03f, 2.66653541e-02f,
  8.52049794e-03f, 4.53092158e-02f, -4.20256555e-02f, -2.21468322e-02f, -9.72279441e-03f, -1.83311198e-02f, -5.92672303e-02f, 8.36806931e-03f, 2.84180306e-02f, 5.21893837e-02f,
  4.36999500e-02f, 6.19282760e-03f, -5.51843829e-02f, 3.91369831e-05f, 6.88432977e-02f, 3.42960097e-02f, -4.12452966e-02f, -5.32347299e-02f, -4.26041819e-02f, 3.10665369e-02f,
  2.55433340e-02f, 2.56800447e-02f, -2.52124132e-03f, 7.11223483e-03f, -1.07168276e-02f, 2.41456591e-02f, -4.61138710e-02f, 3.34245339e-02f, 5.81730530e-02f, -3.63483303e-03f,
  -2.97467839e-02f, 4.53228317e-02f, -2.36443542e-02f, -3.68238986e-02f, 4.17588316e-02f, -1.74768306e-02f, -9.11350828e-03f, 8.43240600e-03f, -2.20892299e-02f, 2.60527655e-02f,
  2.51552224e-01f, 6.39701188e-02f, -8.39205366e-03f, 9.39383805e-02f, -4.28371020e-02f, 1.31023163e-02f, -6.18956685e-02f, 6.14063181e-02f, 3.66430692e-02f, 7.48488083e-02f,
  4.55204770e-02f, -8.56191211e-04f, 6.98189288e-02f, 8.87679576e-04f, -5.42534469e-03f, 3.99348289e-02f, -3.96230072e-02f, 2.76884008e-02f, 6.84808195e-02f, -2.67766602e-02f,
  7.37913465e-03f, -7.62761198e-03f, -2.49695815e-02f, 3.57579812e-02f, -3.33497599e-02f, -3.29480171e-02f, 3.69613394e-02f, -2.38720402e-02f, -5.17406799e-02f, -1.65456329e-02f,
  -6.45895422e-01f, -4.31072228e-02f, -3.74749810e-01f, -4.33375090e-01f, -7.78831318e-02f, -2.57794708e-02f, -1.15468636e-01f, -7.29840398e-02f, -2.61391699e-01f, 2.61516958e-01f,
  1.50000095e-01f, -2.17098489e-01f, 2.40767360e-01f, -1.43057019e-01f, -3.46740782e-01f, 2.22270980e-01f, -2.27966100e-01f, 1.69459749e-02f, -2.63399705e-02f, -1.23270534e-01f,
  -1.77121952e-01f, 1.34753391e-01f, -1.63101047e-01f, 5.81962951e-02f, -1.65498063e-01f, -1.96362734e-01f, 4.99929376e-02f, 4.91861962e-02f, 1.63379721e-02f, 2.88543366e-02f,
  2.96540633e-02f, 5.72015122e-02f, -6.70727938e-02f, 8.14640149e-03f, -3.43655869e-02f, 3.02015021e-02f, -1.55350761e-02f, 4.72727865e-02f, -2.12593433e-02f, -3.93000228e-04f,
  -1.68339384e-03f, -5.02710678e-02f, -1.65362135e-02f, 2.69949939e-02f, -7.21915215e-02f, -7.91301280e-02f, 1.52387633e-03f, -1.49416586e-03f, 1.04668587e-02f, -3.98675166e-03f,
  -4.02313843e-02f, -1.22261792e-02f, -3.29056717e-02f, 4.30070981e-02f, -4.05667424e-02f, -4.66356464e-02f, -9.31114238e-03f, -1.26559623e-02f, 2.69645881e-02f, -6.46081269e-02f,
  9.00381431e-02f, 1.72517505e-02f, 5.41704381e-03f, -1.70231815e-02f, -8.76520667e-03f, 4.87587638e-02f, -1.93399638e-02f, 8.58715773e-02f, -7.15468749e-02f, 3.03222518e-02f,
  -5.88552170e-02f, -2.36875769e-02f, 4.51326966e-02f, -3.59635502e-02f, 1.93747785e-02f, -7.04273069e-03f, -2.55641211e-02f, 4.54683639e-02f, -4.47484888e-02f, -3.69531401e-02f,
  1.23543385e-03f, -3.11060809e-02f, -1.39283035e-02f, 3.30875032e-02f, -1.34324161e-02f, 7.22766714e-03f, -1.00644631e-02f, -2.03447323e-02f, -1.95680112e-02f, 1.71289966e-03f,
  8.85685235e-02f, 1.85757354e-02f, 4.36265720e-03f, -1.27485197e-03f, 1.50929606e-02f, -7.98250083e-03f, 3.51812254e-04f, -3.12475730e-02f, -3.16319987e-02f, 1.68299507e-02f,
  2.82912347e-02f, -4.62843617e-03f, 2.79507600e-02f, -6.57104142e-03f, 8.56672600e-03f, 3.78767215e-02f, 2.27704290e-02f, -1.88783705e-02f, -5.14673255e-02f, 2.35961769e-02f,
  1.03396596e-02f, 3.31047550e-02f, -2.18239538e-02f, 4.27666493e-03f, 1.82817578e-02f, 4.77381377e-03f, -5.12405159e-03f, -2.43798457e-02f, 3.98085676e-02f, 3.41048874e-02f,
  3.10062528e-01f, -3.36324662e-01f, -1.20197244e-01f, -7.55271092e-02f, 1.79833189e-01f, 2.56271601e-01f, 4.75950316e-02f, -6.79129064e-02f, -2.10471779e-01f, -2.10714772e-01f,
  7.18790069e-02f, -1.82092786e-02f, -1.35883942e-01f, 7.87614733e-02f, 5.44664860e-01f, -7.83683285e-02f, 1.65377796e-01f, 3.57622914e-02f, -4.95314896e-02f, 3.48863937e-02f,
  9.47924778e-02f, 1.77114516e-01f, 7.13300258e-02f, -4.46465276e-02f, 7.80204237e-02f, -1.58914536e-01f, 1.88464195e-01f, -1.31892115e-01f, 1.30164266e-01f, 1.60520777e-01f,
  7.06162825e-02f, -1.36150256e-01f, -9.76317897e-02f, -4.51955460e-02f, 6.76986575e-02f, 5.51359653e-02f, 5.77392727e-02f, 5.37774637e-02f, 1.67667214e-02f, -4.84518558e-02f,
  -3.32121663e-02f, 8.11710730e-02f, 6.96525490e-03f, -1.41673046e-03f, 1.23400623e-02f, -8.37284401e-02f, -1.77128799e-02f, 2.31269691e-02f, -4.24224511e-02f, 6.19145073e-02f,
  -4.18697819e-02f, 4.98321801e-02f, 2.16552317e-02f, 4.10042070e-02f, -1.61894578e-02f, -1.15909046e-04f, 1.86614029e-03f, 2.38016136e-02f, -3.69152538e-02f, 2.00023800e-02f,
  1.00905746e-01f, 1.08056124e-02f, -2.30478663e-02f, -3.50894481e-02f, 1.60031039e-02f, -3.78162004e-02f, 4.62040044e-02f, -9.16497037e-03f, -1.38702923e-02f, 3.63115151e-03f,
  2.63357181e-02f, -3.64749059e-02f, 1.86503008e-02f, 1.39467185e-02f, 4.69987430e-02f, -2.79088896e-02f, 3.96875553e-02f, -5.90937808e-02f, -3.36723998e-02f, 4.35773171e-02f,
  -5.49490228e-02f, 4.36463021e-02f, -2.44454704e-02f, -8.75452359e-04f, 7.75941974e-03f, -9.43099800e-03f, -9.21856333e-03f, -4.67775166e-02f, -4.27765353e-03f, 7.04589859e-02f,
  8.61846060e-02f, -6.90946802e-02f, -5.80223761e-02f, -4.26626168e-02f, -5.96110150e-02f, 3.57966684e-02f, -4.03880067e-02f, -4.40763794e-02f, -5.13050891e-02f, 3.71141881e-02f,
  8.28406960e-02f, -7.27903023e-02f, 3.01935039e-02f, 4.00625132e-02f, 2.37566736e-02f, 3.87312807e-02f, 7.19141401e-03f, 1.91107625e-03f, 6.19168542e-02f, 3.66097018e-02f,
  9.85699613e-03f, 2.64290348e-02f, 3.15755010e-02f, -9.58314072e-03f, 2.70866212e-02f, 9.41538066e-03f, 4.24320996e-02f, -2.17120908e-02f, 5.54931462e-02f, -2.31217295e-02f,
  4.39281017e-01f, -5.57041988e-02f, 2.99544811e-01f, 9.05715972e-02f, -6.90838229e-03f, -3.03960256e-02f, 1.58981174e-01f, -3.98938991e-02f, 2.83159822e-01f, -3.60933602e-01f,
  -2.40453437e-01f, 2.11172149e-01f, 5.41297905e-02f, -2.27333307e-01f, 2.84426719e-01f, 6.18427545e-02f, -1.56864151e-01f, -5.64171486e-02f, 1.01445630e-01f, -8.80619918e-04f,
  1.47079229e-01f, -3.02399755e-01f, 8.78193155e-02f, -2.39359424e-01f, -6.61861002e-02f, 9.53798369e-02f, -2.09274247e-01f, 4.76635024e-02f, -2.97724038e-01f, 7.58576579e-03f,
  -2.26597693e-02f, -2.67403387e-02f, 1.26486972e-01f, 3.54083516e-02f, 2.74508242e-02f, -3.01341452e-02f, -3.40451971e-02f, -4.02937969e-03f, 1.00868918e-01f, 3.54376696e-02f,
  -8.36574659e-03f, 1.07053854e-02f, -1.38982886e-03f, -2.17086542e-02f, 4.02199017e-04f, 3.75611745e-02f, 2.22932436e-02f, -3.75813507e-02f, 3.53648067e-02f, 1.85657442e-02f,
  8.20821375e-02f, -5.57170771e-02f, 2.25673150e-02f, -7.10876435e-02f, 7.76003301e-02f, 3.39355022e-02f, -3.03318026e-03f, 4.25902940e-02f, -4.04086336e-02f, -1.59566607e-02f,
  9.52140801e-03f, -1.22733787e-02f, -3.64426188e-02f, 2.47797705e-02f, 7.68999429e-03f, -7.82672409e-03f, -1.25961080e-02f, -1.16217993e-02f, 3.78834121e-02f, -7.71194184e-03f,
  2.66289655e-02f, 3.37707363e-02f, -3.80429775e-02f, 2.22774446e-02f, -1.99417491e-02f, 2.66888011e-02f, -1.00878337e-02f, -2.07064040e-02f, 5.26661053e-03f, 1.68150365e-02f,
  1.21857421e-02f, 1.23260105e-02f, -1.18964622e-02f, -3.06526497e-02f, -1.83590408e-02f, 5.63326851e-02f, -7.38523379e-02f, 4.41753380e-02f, 1.36805009e-02f, 4.15267199e-02f,
  -8.55965614e-02f, -3.74776833e-02f, -8.54102708e-03f, 7.93634448e-03f, -7.10309297e-02f, -7.86175653e-02f, -1.41410762e-02f, 3.51088084e-02f, -6.64410088e-03f, 6.52532512e-03f,
  -4.38258871e-02f, -6.79965829e-03f, -3.49607877e-02f, 6.87975995e-03f, -1.06983660e-02f, -4.92836386e-02f, -3.66487242e-02f, -3.08773778e-02f, -2.78769098e-02f, -6.34268373e-02f,
  -7.30817541e-02f, -2.16293251e-04f, 1.05860690e-02f, 2.45765056e-02f, -7.41209090e-02f, -2.37851869e-02f, 2.01415922e-02f, 1.35410056e-02f, -8.67964886e-03f, 2.23469660e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.30718398e-01f, -6.49747968e-01f, -2.89535373e-02f, 4.24550354e-01f, 3.17680895e-01f, 6.37871325e-02f, 9.81052220e-02f, 6.70048082e-03f, 1.72832713e-01f, -3.90876710e-01f,
  8.67236182e-02f, -1.80447474e-01f, -3.02327067e-01f, 1.59179747e-01f, 1.81500837e-01f, -1.80098101e-01f, 8.29956383e-02f, 4.91288155e-02f, 8.79358798e-02f, -5.09575494e-02f,
  2.66168296e-01f, 1.87086031e-01f, 4.23292490e-03f, -9.88605767e-02f, 7.97110572e-02f, -4.14082780e-02f, 1.11243846e-02f, -1.83498189e-01f, 5.68610765e-02f, -3.96643020e-02f,
  -1.10058608e-02f, 2.96993144e-02f, -4.59596775e-02f, -5.70900552e-02f, -5.14294133e-02f, 2.79954984e-03f, -5.43798655e-02f, -2.54794005e-02f, 1.08810283e-01f, 5.71942218e-02f,
  -9.59670916e-02f, 2.38093268e-02f, 6.63618147e-02f, 2.93186046e-02f, -3.13436496e-03f, -7.84817967e-04f, 8.16302299e-02f, 5.47945388e-02f, 8.24153274e-02f, 3.32654603e-02f,
  4.49254178e-02f, 2.41672173e-02f, 6.29685074e-02f, -8.88576880e-02f, 7.57852495e-02f, 1.70362704e-02f, -3.31534841e-03f, -6.12643138e-02f, -4.29308750e-02f, 5.83885796e-02f,
  -5.71928769e-02f, -1.01111121e-01f, -4.94499365e-03f, -4.71893139e-03f, 2.62491684e-02f, 1.35811388e-01f, -5.49634248e-02f, 1.03737433e-02f, -3.53227369e-02f, -6.19029365e-02f,
  -2.68665031e-02f, -1.59539301e-02f, -1.19888093e-04f, 5.46472985e-03f, 1.86622217e-02f, -5.42089110e-03f, -2.02373862e-02f, 5.13294525e-02f, -2.34148987e-02f, -7.87503435e-04f,
  -3.78379337e-02f, 1.26529103e-02f, -6.94248006e-02f, 2.71972567e-02f, -5.72892185e-03f, -3.01471744e-02f, -3.92558128e-02f, -1.89816430e-02f, -7.36188330e-03f, -7.28087649e-02f,
  -2.22072780e-01f, -3.24052751e-01f, -4.39639911e-02f, 2.49582790e-02f, -8.50987285e-02f, -8.33315179e-02f, -7.54848495e-02f, 2.30966657e-02f, -1.86824590e-01f, 9.64129250e-03f,
  9.06524714e-03f, 7.33957738e-02f, -4.67522144e-02f, -1.45162661e-02f, -4.07071151e-02f, 3.84543538e-02f, -3.10507752e-02f, -8.78494307e-02f, -7.36351013e-02f, -1.03881866e-01f,
  -2.34240815e-02f, -7.13891834e-02f, 2.82026362e-03f, 1.16588280e-01f, 5.72061650e-02f, -4.88071665e-02f, -5.57328500e-02f, -4.88909148e-02f, 7.20924931e-03f, -9.28284675e-02f,
  -1.55903801e-01f, -6.01690114e-02f, 6.29940480e-02f, -1.52522117e-01f, 6.20141700e-02f, 1.78574190e-01f, 1.20418288e-01f, -5.36953583e-02f, -2.43622825e-01f, -1.57748565e-01f,
  -5.67999377e-04f, -1.03239223e-01f, 4.44903318e-03f, -6.45144060e-02f, -1.34846643e-02f, -1.63906589e-02f, -1.86204150e-01f, 3.69457826e-02f, 5.21043083e-03f, -6.58747181e-02f,
  -6.85845241e-02f, -1.57720018e-02f, 7.17723295e-02f, 4.65841684e-03f, 1.13792561e-01f, -6.80246055e-02f, 3.56551148e-02f, 8.70348960e-02f, 2.97254398e-02f, 3.96844447e-02f,
  4.08157483e-02f, -1.62095115e-01f, 1.60997231e-02f, 3.34435329e-02f, 9.72308069e-02f, 8.47191066e-02f, -4.92874160e-03f, -9.06453375e-03f, -6.62885308e-02f, -6.96445908e-03f,
  4.81910184e-02f, 7.98376948e-02f, 2.16436591e-02f, 5.16505167e-02f, -5.59599586e-02f, 3.07916999e-02f, 4.57542650e-02f, 2.63848621e-03f, 3.19121927e-02f, 1.05830990e-01f,
  -4.57136380e-03f, -4.91536362e-03f, -8.19559768e-02f, -9.02673975e-02f, -5.09644859e-02f, -8.51361230e-02f, -9.87768322e-02f, 6.22113887e-03f, 4.30587046e-02f, -9.59087908e-02f,
  -2.59538498e-02f, -9.47472267e-03f, -8.18307176e-02f, 4.72564474e-02f, 1.20691424e-02f, 1.11807384e-01f, 8.72154012e-02f, 4.29502800e-02f, -6.02367856e-02f, 7.76851475e-02f,
  -1.23809576e-02f, -3.53974327e-02f, -6.40123934e-02f, 4.06768359e-02f, -4.41465862e-02f, 2.04315353e-02f, 8.48752856e-02f, 2.25530416e-02f, 5.35083860e-02f, -3.35424803e-02f,
  -5.19241719e-03f, -1.38533139e-03f, -6.27532154e-02f, -6.56880811e-03f, -1.46552362e-02f, -4.00237553e-02f, -5.87198921e-02f, -2.34732199e-02f, -5.37490472e-02f, 3.57119516e-02f,
  -4.07417072e-03f, -6.31064624e-02f, 5.70550896e-02f, 2.43971366e-02f, -3.91738079e-02f, -3.55446944e-03f, 4.22617281e-03f, 2.77625844e-02f, -1.05591521e-01f, -8.10869709e-02f,
  8.96305516e-02f, 5.52518517e-02f, 5.09086214e-02f, 1.81941781e-02f, 4.36189920e-02f, 4.31711711e-02f, -1.06813721e-01f, 5.67686781e-02f, 1.73850097e-02f, -7.99200125e-03f,
  -2.13052072e-02f, -5.98511174e-02f, 5.63760661e-02f, -5.10930791e-02f, -4.31405120e-02f, -8.63633752e-02f, 5.24160638e-02f, 5.39087616e-02f, 5.17584756e-02f, 4.21607606e-02f,
  -5.95410019e-02f, 4.20473695e-01f, -5.26702590e-02f, -1.17773399e-01f, -1.97436735e-01f, -3.91827106e-01f, -1.60607964e-01f, 1.10961877e-01f, 2.84457058e-01f, 1.76436827e-01f,
  1.35836434e-02f, 3.10771048e-01f, 2.48400152e-01f, -5.74324466e-02f, -4.83581692e-01f, 8.56517404e-02f, -2.98966736e-01f, -1.21265024e-01f, 1.12603061e-01f, -3.11921872e-02f,
  -1.73713669e-01f, -7.97483325e-02f, -1.94323331e-01f, -3.51412036e-02f, -1.66591778e-01f, -4.53799404e-03f, -2.22615927e-01f, -4.31734398e-02f, -2.36778677e-01f, -5.66326268e-02f,
  -8.79248679e-02f, 8.23714212e-02f, 9.90120173e-02f, 2.72010583e-02f, -1.73318252e-01f, -3.29898745e-02f, -1.33431274e-02f, 2.07720250e-02f, -2.29643676e-02f, -7.29129091e-03f,
  3.66376154e-02f, 4.30971310e-02f, 9.89040956e-02f, 3.83687019e-02f, 5.85904494e-02f, 2.72224601e-02f, 5.32526150e-02f, -3.19928974e-02f, 9.89417918e-03f, 4.10729274e-02f,
  -3.38700078e-02f, 4.54555005e-02f, -3.20015550e-02f, -9.79950204e-02f, -8.31382051e-02f, -1.59377288e-02f, -7.71206841e-02f, -1.91908572e-02f, -8.38733986e-02f, -3.30006592e-02f,
  5.62304407e-02f, -2.61725858e-02f, -6.57192916e-02f, -1.78089216e-02f, -2.78766938e-02f, 3.71517465e-02f, -1.41975367e-02f, -3.84105928e-02f, 1.21187195e-02f, -7.81934336e-02f,
  6.14333618e-03f, -4.88622580e-03f, -4.21573482e-02f, 7.11415708e-03f, -8.63422081e-02f, 1.65709964e-04f, 4.40728776e-02f, -1.64964236e-02f, -8.97146538e-02f, -1.46376034e-02f,
  9.86698866e-02f, 5.17063821e-03f, 8.96241963e-02f, -1.23678133e-01f, -1.83849931e-02f, 2.76522394e-02f, 4.72665243e-02f, 5.86062521e-02f, -5.77053688e-02f, -5.05845062e-02f,
  -2.99716145e-01f, -1.51235744e-01f, 3.84738967e-02f, 4.31918465e-02f, -1.24960514e-02f, -7.32201189e-02f, -7.69979209e-02f, -4.03663032e-02f, -1.29219353e-01f, -4.03330922e-02f,
  -3.32341343e-02f, -3.90486792e-02f, -1.48395568e-01f, -1.54800611e-02f, -3.03318333e-02f, -9.56365690e-02f, -7.88011849e-02f, -2.77501363e-02f, -1.06664114e-01f, -2.49875151e-03f,
  3.84990536e-02f, -5.88745624e-02f, -5.86406374e-03f, -4.74874768e-03f, -8.04899856e-02f, -3.27580608e-02f, 3.68122756e-02f, -1.38030387e-02f, -2.45607290e-02f, 1.93748884e-02f,
  -2.92003989e-01f, 1.45398989e-01f, 1.31058186e-01f, -3.06760579e-01f, 1.74908832e-01f, 4.35115471e-02f, -1.48128539e-01f, 5.08092307e-02f, -1.53485075e-01f, 5.83210997e-02f,
  7.48995095e-02f, -1.21125896e-02f, 1.84362009e-01f, -2.39459828e-01f, -3.69906515e-01f, -9.50003490e-02f, -2.57568777e-01f, -2.22113520e-01f, -7.91149363e-02f, -1.43604958e-02f,
  -1.71257704e-01f, -1.92708716e-01f, 5.89403473e-02f, 5.87850213e-02f, -2.95529570e-02f, 4.98301126e-02f, -1.02151915e-01f, 1.69155300e-01f, -8.92923921e-02f, 8.90744776e-02f,
  3.89707796e-02f, 3.18346620e-02f, 1.72123481e-02f, -5.52523397e-02f, 6.81169629e-02f, 6.21432364e-02f, -3.91121171e-02f, 5.80038838e-02f, 6.25889655e-03f, 3.86501011e-03f,
  8.17799661e-03f, 5.16978763e-02f, -9.00023878e-02f, 1.11648738e-01f, -4.77065668e-02f, -3.64492945e-02f, 7.29365796e-02f, 5.16169798e-03f, 5.55450357e-02f, -2.02819593e-02f,
  7.74598401e-03f, 4.11825143e-02f, -9.99575108e-02f, -6.04304075e-02f, 7.47396052e-02f, -5.46926782e-02f, -1.13794878e-02f, -8.33836272e-02f, 2.07218546e-02f, -3.15037221e-02f,
  -7.46639222e-02f, 3.70748132e-03f, 7.35013485e-02f, -4.89671007e-02f, 1.05679728e-01f, -6.42585605e-02f, 8.14339891e-02f, -4.41229828e-02f, -3.26143876e-02f, 3.27659771e-02f,
  -2.25450397e-02f, -3.70719582e-02f, -5.99031523e-02f, -7.80320540e-02f, -6.68662265e-02f, 3.72405015e-02f, -9.59988218e-03f, -1.71427932e-02f, -2.62221564e-02f, 5.34653142e-02f,
  -7.87037313e-02f, 3.22404355e-02f, -2.42031529e-03f, -8.58539417e-02f, 6.71966299e-02f, -9.84932296e-03f, 5.02538756e-02f, 3.55538540e-02f, 9.49855447e-02f, -1.05242088e-01f,
  -1.90938804e-02f, -1.06830411e-01f, 3.65074053e-02f, 6.29040077e-02f, -3.24056745e-02f, -3.98073941e-02f, -7.58694708e-02f, -2.11219192e-02f, -1.04729934e-02f, 7.97795057e-02f,
  -8.96330625e-02f, -7.42825568e-02f, -1.90946851e-02f, -7.02581927e-02f, -4.03257058e-04f, -9.43380967e-02f, 1.89189687e-02f, -2.54010670e-02f, 5.28327115e-02f, 3.13978083e-02f,
  5.90244196e-02f, -6.20490015e-02f, 5.41248024e-02f, -4.30253930e-02f, -5.29702492e-02f, -1.22854598e-02f, -2.47643739e-02f, 5.41276932e-02f, -6.10273331e-02f, -2.63615102e-02f,
  -3.40065837e-01f, 8.16374719e-02f, 1.41542912e-01f, -2.44964957e-01f, 1.81188703e-01f, 2.37182807e-03f, 3.56997140e-02f, 1.82196230e-01f, 5.21032251e-02f, 1.33578312e-02f,
  1.40954787e-02f, -2.33313292e-01f, 1.55597165e-01f, 4.41284440e-02f, -1.10517554e-01f, 1.53102189e-01f, -9.27020311e-02f, -1.78362936e-01f, 1.56915151e-02f, -1.41465247e-01f,
  -8.44551325e-02f, -4.64191288e-03f, 1.58729151e-01f, 1.83185756e-01f, -8.68883207e-02f, -1.81372575e-02f, -9.08344984e-02f, 4.26158980e-02f, -1.61374956e-01f, 2.56070271e-02f,
  -4.91057336e-02f, -8.49484801e-02f, 9.21115801e-02f, 4.39418480e-02f, 1.55494353e-02f, 9.47164278e-03f, -8.44284296e-02f, -5.71812354e-02f, -6.06329031e-02f, 7.34845325e-02f,
  -8.30118656e-02f, -7.26588629e-03f, -5.48998415e-02f, -7.02278549e-03f, -1.84243303e-02f, 1.04916133e-01f, 5.65771125e-02f, 2.12722197e-02f, 4.90641370e-02f, 1.45360343e-02f,
  -1.19850924e-02f, 2.42623501e-03f, -9.48814210e-03f, -1.54434275e-02f, -3.03293746e-02f, 3.75518650e-02f, -9.55982283e-02f, -5.95516339e-02f, 1.60136539e-02f, 4.31337133e-02f,
  6.65610805e-02f, -4.21940349e-02f, 9.80432332e-02f, -2.60301633e-03f, -5.46587147e-02f, -4.64013144e-02f, -4.98194285e-02f, -6.27971143e-02f, -4.59288023e-02f, -3.93238254e-02f,
  2.40063146e-02f, -4.79252115e-02f, 7.49630332e-02f, -8.39613285e-03f, 2.04345118e-02f, -6.35499358e-02f, -9.91960838e-02f, -1.21199256e-02f, -5.83761968e-02f, -1.57208219e-02f,
  -2.17913389e-02f, -1.92645006e-02f, 4.69769351e-02f, 5.53677678e-02f, -1.56619551e-03f, -4.51710224e-02f, 4.26579304e-02f, 5.24570309e-02f, -6.72446862e-02f, 2.89309043e-02f,
  -2.19806761e-01f, -1.90680727e-01f, 3.82944904e-02f, -5.98116219e-02f, 3.74801531e-02f, -6.13398142e-02f, -3.45351025e-02f, -5.57413176e-02f, -9.29370746e-02f, -8.63268878e-03f,
  1.98466983e-02f, -5.22687323e-02f, -1.49930403e-01f, 4.91644666e-02f, 2.77490970e-02f, -1.02790240e-02f, -1.24549128e-01f, -1.11380368e-01f, -3.54971960e-02f, 5.19776791e-02f,
  -4.03341576e-02f, -2.82107014e-03f, -4.90630381e-02f, -4.16471213e-02f, -2.56507508e-02f, 1.07321078e-02f, -1.23952217e-01f, 3.72071192e-02f, -9.10431817e-02f, -4.58994061e-02f,
  5.92073277e-02f, -9.16551973e-04f, -1.26366988e-01f, 9.68790147e-03f, -2.85911039e-02f, -1.72025621e-01f, -1.93463087e-01f, 3.12465075e-02f, 1.18687404e-02f, -1.60485208e-02f,
  -6.88489527e-02f, 1.09573327e-01f, -8.53953212e-02f, -5.24754450e-02f, 5.62276840e-02f, 3.13287005e-02f, -4.86385003e-02f, -2.53216866e-02f, -1.03391349e-01f, 7.05658793e-02f,
  6.42685890e-02f, -4.11621146e-02f, -1.07758343e-01f, 5.96497860e-03f, 2.75267754e-02f, 9.14256647e-03f, 4.56188321e-02f, 5.86781986e-02f, -1.17142443e-02f, 1.36138676e-02f,
  -1.66912898e-01f, 4.45669144e-02f, -3.93138640e-02f, -8.00818652e-02f, 2.28343178e-02f, 1.52638089e-02f, 2.68634930e-02f, 3.46203260e-02f, -5.97782247e-02f, 3.32671553e-02f,
  -5.41201904e-02f, -4.00300212e-02f, 5.22438483e-03f, -1.03602028e-02f, -3.80649567e-02f, -5.83057217e-02f, 1.89586412e-02f, -1.26035780e-01f, -6.28541410e-02f, -5.56776486e-02f,
  -8.75309780e-02f, -3.10268756e-02f, -4.81002294e-02f, 4.58145551e-02f, 6.35305122e-02f, -4.91319001e-02f, 4.18236963e-02f, -3.32612433e-02f, -2.67230012e-02f, -5.85240778e-03f,
  1.13581829e-02f, -7.89922196e-03f, -7.51651998e-04f, -1.09380409e-01f, -6.69811144e-02f, 6.59602061e-02f, 4.26454358e-02f, -7.70483688e-02f, 3.14476006e-02f, 2.51968075e-02f,
  8.88848770e-03f, 2.04300042e-02f, 6.69240355e-02f, 1.68038364e-02f, 8.35664719e-02f, -4.90461551e-02f, 2.08101850e-02f, 4.76361588e-02f, -8.98612216e-02f, -1.75367948e-02f,
  2.75855325e-02f, 1.44112865e-02f, 1.99001711e-02f, 7.72611648e-02f, 1.06148822e-02f, 3.73650566e-02f, -3.11697628e-02f, 3.17389406e-02f, -2.19395421e-02f, 6.35430589e-02f,
  5.99240437e-02f, 2.07668796e-01f, 2.14027818e-02f, 5.18717989e-02f, 3.37773710e-02f, 7.46180937e-02f, 2.79061459e-02f, 4.76970822e-02f, -6.88281842e-03f, 7.21340775e-02f,
  -2.70973854e-02f, 3.97133045e-02f, -2.75895279e-02f, 1.72838978e-02f, -3.01324315e-02f, 7.37668648e-02f, -2.73626670e-02f, 2.41685100e-02f, 3.33142914e-02f, 1.02352969e-01f,
  9.10014436e-02f, 6.01308979e-02f, 6.22595958e-02f, -3.60631719e-02f, -4.46042344e-02f, 9.86978784e-02f, -5.58387227e-02f, -1.83050837e-02f, 7.91459158e-02f, 3.21893096e-02f,
  -1.47837587e-02f, -6.18525222e-02f, -4.67191935e-02f, 6.99076988e-03f, 7.40218312e-02f, 2.16405727e-02f, -7.71133453e-02f, 4.28863019e-02f, -1.63696229e-01f, -1.33150190e-01f,
  -4.08303738e-02f, -9.96888131e-02f, -8.75824839e-02f, -6.48766232e-04f, 1.09179795e-01f, -6.42014816e-02f, 8.72421935e-02f, -3.71024050e-02f, -9.24095605e-03f, -1.09350391e-01f,
  -2.48385984e-02f, 1.04244247e-01f, 1.05703160e-01f, 5.27885966e-02f, 7.54171684e-02f, 9.81677845e-02f, 3.91810723e-02f, 4.46819030e-02f, 1.22828819e-01f, 1.57135755e-01f,
  1.02198854e-01f, -1.64831221e-01f, -8.80771428e-02f, -9.19984803e-02f, 2.63386890e-02f, -3.08544077e-02f, 7.91453868e-02f, 5.73767163e-03f, 5.68638779e-02f, 1.06678065e-02f,
  -1.17394470e-01f, 1.01833761e-01f, 3.63381505e-02f, 6.12815879e-02f, 2.29645474e-03f, 2.00305544e-02f, -7.70832077e-02f, -4.04752418e-02f, -3.76401059e-02f, -1.09437685e-02f,
  -5.84611334e-02f, -1.33429433e-03f, 6.57585934e-02f, 7.76630640e-02f, -3.58747989e-02f, 4.72864024e-02f, 2.57367399e-02f, -4.29867208e-03f, 9.14184526e-02f, 7.87138045e-02f,
  2.05916446e-02f, 2.79046744e-02f, -7.24789947e-02f, 5.12015249e-04f, 6.39229491e-02f, 2.55895220e-02f, -7.59495646e-02f, 8.45590532e-02f, -2.35807933e-02f, -7.45045096e-02f,
  -3.57672088e-02f, -6.75385594e-02f, 3.94990221e-02f, 5.28728068e-02f, -3.69523317e-02f, -9.60935578e-02f, 1.01499341e-01f, 5.69352880e-02f, -5.07436730e-02f, 3.76196727e-02f,
  5.84105290e-02f, -2.35217419e-02f, -7.15075731e-02f, 8.53459686e-02f, 9.44579914e-02f, -1.49313714e-02f, 3.65025401e-02f, -7.08787963e-02f, 5.18847108e-02f, 4.31713677e-04f,
  4.19970788e-02f, -8.74583498e-02f, 9.87501591e-02f, 7.04982132e-02f, 9.28944498e-02f, 1.08654313e-02f, -3.22435126e-02f, 5.18184453e-02f, -8.34686980e-02f, 4.83291736e-03f,
  -7.60635436e-02f, 3.35829407e-02f, 4.11253572e-02f, 8.39287937e-02f, 8.54377747e-02f, 4.01005298e-02f, -4.78109438e-03f, 3.90454121e-02f, 8.14605579e-02f, 2.12119687e-02f,
  -2.26917081e-02f, -1.41009465e-02f, -4.83377725e-02f, -6.90866411e-02f, -5.24944402e-02f, -9.10123885e-02f, -3.70396897e-02f, 4.60574180e-02f, 1.90079268e-02f, -8.50836113e-02f,
  1.86019782e-02f, -1.29739180e-01f, 3.69967800e-03f, 1.50963217e-01f, 7.25347325e-02f, -2.62628850e-02f, 6.55901954e-02f, -8.88805687e-02f, -1.91265315e-01f, -5.69367297e-02f,
  -1.75798006e-04f, 1.72644798e-02f, 4.71727587e-02f, 6.93143159e-02f, -3.76808178e-03f, -1.27188906e-01f, -9.25822109e-02f, 4.50483747e-02f, -9.29019675e-02f, 9.55355912e-02f,
  7.81883672e-02f, 1.30954757e-02f, 1.07884504e-01f, 2.19748053e-03f, 1.40352100e-01f, 6.38359040e-02f, 1.94414049e-01f, 5.98781556e-02f, 1.55541122e-01f, 4.68687490e-02f,
  -5.83036095e-02f, 4.20859642e-02f, 2.40672212e-02f, -1.10323958e-01f, 8.14545527e-03f, 4.86324094e-02f, 2.89594866e-02f, 9.87981558e-02f, -2.42737252e-02f, -4.01134640e-02f,
  1.03086181e-01f, -5.49913459e-02f, -7.84159079e-02f, -6.11188412e-02f, -1.00760870e-01f, -1.42297130e-02f, -2.28456827e-03f, -4.57103960e-02f, -3.98807824e-02f, -6.73183873e-02f,
  3.54867764e-02f, -4.44551110e-02f, 6.30346984e-02f, -1.67457145e-02f, 4.78652604e-02f, 4.68273573e-02f, 8.97504296e-03f, 2.61740852e-02f, -5.24255745e-02f, -1.21658053e-02f,
  7.13752285e-02f, -2.66848039e-02f, -5.81736751e-02f, -7.34770074e-02f, -9.12304968e-02f, -4.63691466e-02f, -4.88634594e-02f, 4.24251892e-03f, -2.05468740e-02f, 6.70355856e-02f,
  8.66590738e-02f, 1.59817580e-02f, 4.93602864e-02f, -6.61626607e-02f, 9.22166929e-03f, 4.95456010e-02f, 1.09822266e-01f, 7.13531598e-02f, -9.01370868e-02f, 8.03611949e-02f,
  -3.83767262e-02f, 3.64138447e-02f, -1.89460665e-02f, 8.59052688e-02f, -2.78481189e-02f, 8.85626897e-02f, -3.98169458e-02f, 4.79832897e-03f, 1.78395621e-02f, -4.50769663e-02f,
  -3.64892595e-02f, 7.16908872e-02f, 5.33321947e-02f, -9.33955088e-02f, 5.72790243e-02f, 8.72156993e-02f, -6.84759289e-04f, 6.93846047e-02f, -3.36106382e-02f, -2.67003868e-02f,
  -3.97550352e-02f, 7.02175573e-02f, -4.65698130e-02f, 8.65669027e-02f, 7.58478343e-02f, 1.28026363e-02f, -4.01721746e-02f, 2.86350660e-02f, 7.41965771e-02f, 1.03122741e-01f,
  -6.22935593e-02f, 6.78113997e-02f, -1.64601486e-03f, -7.96735361e-02f, 5.10449670e-02f, -4.10949476e-02f, 2.69736238e-02f, 2.24964358e-02f, -6.12037294e-02f, 4.50432785e-02f,
  -7.84458295e-02f, 2.92345304e-02f, -4.13256347e-01f, -1.51162416e-01f, 8.46848115e-02f, 1.33302763e-01f, 2.97790349e-01f, -6.32855147e-02f, 5.90756312e-02f, 4.18689370e-01f,
  2.94614077e-01f, -4.65544276e-02f, 1.57720476e-01f, 2.10342184e-01f, -1.23217866e-01f, 8.00135955e-02f, 2.86115766e-01f, 2.34071583e-01f, -1.26181558e-01f, 7.25496933e-02f,
  -1.27681494e-01f, 1.86968535e-01f, -1.84025556e-01f, 2.78798342e-02f, 1.13916226e-01f, -1.41969755e-01f, 1.35790974e-01f, -1.08464681e-01f, -2.34289560e-02f, -1.20771982e-01f,
  3.96786481e-02f, -6.51181415e-02f, -2.07645465e-02f, -1.24762498e-01f, 2.81890389e-02f, 1.21255256e-01f, -4.83754016e-02f, -9.84515250e-02f, -1.25565648e-01f, 4.25288966e-03f,
  -1.08822053e-02f, 2.72784010e-02f, 4.41087186e-02f, -3.72785442e-02f, 9.10488069e-02f, -4.15970013e-02f, -6.43357486e-02f, -8.00625309e-02f, 2.57561989e-02f, -3.60957347e-02f,
  -8.68825689e-02f, -1.33968070e-02f, 7.82335456e-03f, -4.06285897e-02f, -6.52317479e-02f, 2.98312511e-02f, -3.13887000e-02f, -1.26083404e-01f, -2.92686298e-02f, 3.12673897e-02f,
  3.34403776e-02f, 4.11122851e-02f, -1.39498925e-02f, -7.98858702e-03f, -2.94304248e-02f, 2.34819688e-02f, 1.04198055e-02f, -5.74377142e-02f, -7.02022482e-03f, 2.35043257e-03f,
  3.54821719e-02f, -9.12168697e-02f, 1.65108871e-02f, 7.43849054e-02f, 1.99168548e-02f, 5.90358265e-02f, 4.48007695e-02f, 1.95675232e-02f, 4.71234582e-02f, -9.54750031e-02f,
  5.01391478e-02f, 3.30694653e-02f, -4.43246812e-02f, 2.02161334e-02f, 4.63640317e-02f, -2.83515789e-02f, 6.02465728e-03f, 2.77709053e-03f, -4.99475859e-02f, 6.00841418e-02f,
  1.88383505e-01f, 1.65545195e-01f, -7.73706660e-02f, -5.45582734e-03f, -7.54300207e-02f, 4.75787446e-02f, 6.69885078e-04f, 1.14757363e-02f, -7.79060423e-02f, 8.27049613e-02f,
  8.75543877e-02f, -1.09355794e-02f, 3.39664593e-02f, 5.87407425e-02f, -5.00290329e-03f, 1.38207442e-05f, 7.10928440e-02f, 5.03626950e-02f, 6.27959147e-02f, -6.07147403e-02f,
  1.52211459e-02f, 1.06167525e-01f, -3.41383703e-02f, 9.16515738e-02f, 2.85828523e-02f, 8.99461433e-02f, 9.80675742e-02f, 7.23752379e-03f, 2.38535572e-02f, -7.38965571e-02f,
  -1.17190532e-01f, 2.67764121e-01f, -4.29075360e-02f, 1.12779461e-01f, 1.05816051e-01f, 2.37407997e-01f, 1.12257265e-01f, 7.47359693e-02f, 2.33254328e-01f, 1.14022240e-01f,
  9.80946794e-03f, -1.99456755e-02f, -8.42758194e-02f, -6.40878379e-02f, -4.83603217e-02f, 2.90268995e-02f, 1.51103973e-01f, 7.59197772e-02f, 1.33237138e-01f, -3.94641096e-03f,
  5.46355434e-02f, -1.33992657e-01f, -2.34361500e-01f, -1.32354230e-01f, -9.66068730e-02f, 3.71219963e-02f, -2.01066315e-01f, -4.97330055e-02f, 4.00183946e-02f, -1.23081803e-02f,
  -5.65565638e-02f, 3.27953696e-02f, -9.13831964e-02f, -2.75270101e-02f, 7.67103061e-02f, 6.24304302e-02f, 7.49230981e-02f, -7.59679079e-02f, -2.16596927e-02f, 4.06899340e-02f,
  8.04236233e-02f, -9.19391662e-02f, 1.50967734e-02f, -1.36786711e-03f, -4.85386811e-02f, 3.01213451e-02f, -1.26638068e-02f, 2.72032768e-02f, -1.72291063e-02f, 6.47888854e-02f,
  6.16713464e-02f, 1.16379395e-01f, 6.53270558e-02f, -2.73662712e-02f, -1.19509185e-02f, 8.28517452e-02f, 9.87443253e-02f, 7.18588233e-02f, -3.07961777e-02f, -2.75006518e-02f,
  5.64931482e-02f, 1.07629411e-01f, -2.80969106e-02f, -7.76932538e-02f, -5.65065332e-02f, 4.29087579e-02f, 5.78501746e-02f, -4.10410985e-02f, 5.96176982e-02f, 1.67956240e-02f,
  -4.16171700e-02f, 5.32240383e-02f, 3.51729356e-02f, 6.69641281e-03f, 8.36022422e-02f, -4.28209752e-02f, 2.40390617e-02f, 3.57446633e-02f, -4.92488965e-02f, -7.40468577e-02f,
  -8.31660032e-02f, 1.01016052e-02f, -4.78650108e-02f, -5.45475706e-02f, 3.86753082e-02f, -8.20561647e-02f, -3.47225219e-02f, -5.47594912e-02f, -9.51787457e-02f, -1.97230056e-02f,
  1.85128972e-01f, 3.11500043e-01f, 9.45228264e-02f, 8.97653401e-02f, 1.30623532e-02f, -2.69153621e-02f, 6.02260605e-02f, 5.45818470e-02f, 1.41686887e-01f, 9.40999910e-02f,
  4.41658013e-02f, -4.89764810e-02f, -5.73480465e-02f, 2.32218634e-02f, -4.54026237e-02f, -7.21983146e-03f, -1.16942488e-02f, 5.29124998e-02f, 1.02571465e-01f, 2.09374893e-02f,
  -5.43639343e-03f, -4.97602951e-03f, -4.52950150e-02f, 7.52172619e-02f, 6.51669279e-02f, -2.35528145e-02f, -1.06897326e-02f, -4.09604721e-02f, 6.19498864e-02f, 1.32404283e-01f,
  -8.28690901e-02f, -8.28588605e-02f, 1.19669577e-02f, 7.26014674e-02f, 4.22336496e-02f, -1.63574651e-01f, -8.46209154e-02f, -2.61612050e-02f, -5.41292131e-02f, -7.68856034e-02f,
  4.61388379e-02f, 1.06130630e-01f, -3.91770527e-02f, -1.88764406e-03f, -1.74345151e-01f, -7.40859210e-02f, -6.10055439e-02f, 1.02266110e-02f, -7.48912692e-02f, -3.17060091e-02f,
  -5.63119538e-03f, -6.14249520e-02f, -4.13126796e-02f, 4.88768332e-02f, -1.67592498e-03f, 1.37469769e-01f, -4.82747927e-02f, 1.67814240e-01f, 6.32672757e-02f, 4.93753776e-02f,
  2.08048653e-02f, -7.48496428e-02f, -1.14716096e-02f, 4.59815487e-02f, -8.57706144e-02f, 5.62481657e-02f, 3.65995467e-02f, -1.12630818e-02f, 7.60044530e-02f, -5.23399003e-02f,
  1.02957048e-01f, 2.20936146e-02f, -6.29680827e-02f, -2.09474899e-02f, 3.41177545e-03f, 4.17665094e-02f, 2.79633980e-02f, -6.28123879e-02f, 9.40145459e-03f, 6.75139949e-02f,
  6.77205771e-02f, 5.51650189e-02f, -8.45040157e-02f, 2.85338773e-03f, -4.21642885e-02f, 6.26155511e-02f, -9.75991860e-02f, -3.66053469e-02f, 5.94129004e-02f, 2.71358453e-02f,
  5.39571829e-02f, 3.80552225e-02f, -2.72931177e-02f, 7.81806856e-02f, 7.92680755e-02f, 7.12640584e-02f, 7.18266591e-02f, -3.74162979e-02f, -5.40996492e-02f, -2.75696963e-02f,
  4.20918949e-02f, 4.07339372e-02f, 7.49259070e-02f, -6.13931427e-03f, -5.07214479e-03f, -3.12647037e-02f, -4.97038811e-02f, 8.20908323e-02f, 7.82474652e-02f, -9.62444022e-02f,
  7.89619386e-02f, -2.41817837e-03f, 6.25949800e-02f, 5.90686649e-02f, -3.57403085e-02f, -2.35472042e-02f, -1.95012428e-02f, 4.81811576e-02f, -4.23432067e-02f, -3.56468298e-02f,
  -6.35466576e-02f, -1.48817286e-01f, -4.08150442e-03f, 1.10776782e-01f, 8.31127516e-04f, -7.72583783e-02f, 3.61893438e-02f, -3.05769537e-02f, -1.43006174e-02f, -9.71836522e-02f,
  -4.43784893e-02f, 6.12446852e-02f, 3.00771091e-02f, 1.30753824e-02f, 3.38095762e-02f, 4.20943238e-02f, -6.38425425e-02f, -5.17576896e-02f, -5.34164347e-02f, 7.11871237e-02f,
  -2.35852003e-02f, 8.71573687e-02f, -3.08167692e-02f, 8.42938274e-02f, -1.79301985e-02f, -3.32833901e-02f, 7.94596300e-02f, 9.71079022e-02f, -5.77404983e-02f, -3.79662253e-02f,
  -1.53769687e-01f, 8.99348035e-02f, -5.47309928e-02f, -2.45380402e-01f, 1.43461628e-02f, 1.63169093e-02f, -2.83594817e-01f, -2.65663508e-02f, -1.77643612e-01f, 5.74118271e-03f,
  -9.53051522e-02f, -6.86190799e-02f, -1.08910479e-01f, -1.06010757e-01f, -7.49194203e-03f, -6.47944510e-02f, -3.31706218e-02f, -5.62982857e-02f, -2.20637377e-02f, -8.80086496e-02f,
  1.07901683e-02f, 9.15049464e-02f, -6.85189618e-03f, 2.45399147e-01f, 2.07622591e-02f, 3.80068682e-02f, 3.11129168e-02f, 1.23078845e-01f, 1.12707354e-01f, 6.60732388e-02f,
  2.55657788e-02f, 6.47925213e-03f, 7.51905665e-02f, -4.78309542e-02f, -8.74414220e-02f, -4.32962440e-02f, 6.99224276e-03f, 5.30020520e-02f, 4.02472094e-02f, -1.13942893e-04f,
  4.71501909e-02f, -1.85839518e-03f, 5.32945469e-02f, 1.01253763e-01f, -3.58835459e-02f, -4.95802201e-02f, -4.81554493e-02f, 2.53886562e-02f, 3.47593762e-02f, 1.68774165e-02f,
  -1.93044171e-02f, 5.71645498e-02f, -9.12635028e-03f, -1.01113521e-01f, -2.69472692e-02f, 1.09951310e-02f, -8.01832154e-02f, -2.27482785e-02f, 7.65758157e-02f, -1.62841845e-03f,
  -2.40595732e-02f, 4.31361645e-02f, -2.83945799e-02f, 3.76606211e-02f, -4.69712019e-02f, 2.97461320e-02f, -6.10541813e-02f, 8.85199606e-02f, -9.86289349e-04f, 6.20203605e-03f,
  4.40125689e-02f, -6.36668354e-02f, -8.54082108e-02f, -4.58000936e-02f, -3.70878465e-02f, 5.54600433e-02f, 9.57319364e-02f, 1.03267975e-01f, 1.86595637e-02f, 7.52015710e-02f,
  -3.56589481e-02f, -2.50690244e-02f, 5.04039042e-02f, 5.47650009e-02f, -1.99422892e-02f, -1.89988241e-02f, -2.37275232e-02f, -5.66060729e-02f, -2.34514996e-02f, -7.12699629e-03f,
  -4.51136008e-02f, -8.73143822e-02f, 1.21497400e-02f, 6.76202774e-02f, 7.69802108e-02f, 8.91565010e-02f, 1.04165629e-01f, 1.17438252e-03f, -6.90541938e-02f, -2.90208794e-02f,
  5.04189916e-02f, -4.59832326e-03f, -4.54816408e-02f, -4.75474074e-02f, 5.79251610e-02f, 6.16774373e-02f, 5.22534177e-02f, 8.63010297e-04f, 1.48212246e-03f, 1.03711918e-01f,
  -5.81075214e-02f, -7.67972544e-02f, -1.32688627e-01f, 2.47356649e-02f, 3.83170769e-02f, 2.51044501e-02f, 5.67680448e-02f, -9.36583653e-02f, 7.77880475e-03f, 4.95244116e-02f,
  -9.03207883e-02f, 3.15982550e-01f, 6.01103082e-02f, 1.89925671e-01f, -2.79727846e-01f, -2.94829100e-01f, -7.92557821e-02f, 1.96216106e-01f, -1.15694948e-01f, 9.85596031e-02f,
  1.77632868e-01f, -1.57076627e-01f, 1.40603051e-01f, 3.11139882e-01f, 1.60139456e-01f, 2.58766770e-01f, 2.07839906e-01f, -1.16391554e-02f, 7.28318021e-02f, 3.32557291e-01f,
  2.32135966e-01f, 2.07677007e-01f, 4.07190293e-01f, 2.55331635e-01f, 9.37249884e-02f, 5.45413382e-02f, 2.15523720e-01f, 6.40915930e-02f, 9.07927603e-02f, 8.95327609e-03f,
  6.57778680e-02f, 9.71282795e-02f, 4.10091802e-02f, -1.52092725e-01f, 5.43157198e-02f, -1.26849264e-01f, -9.05012712e-02f, -1.79820340e-02f, 4.09999862e-02f, -2.98039485e-02f,
  -6.13979734e-02f, 1.59300398e-02f, 3.53932194e-02f, -3.59636918e-02f, -1.25702009e-01f, 6.37703240e-02f, 1.29377348e-02f, -8.82731453e-02f, -1.62573364e-02f, 1.07264742e-01f,
  2.16310341e-02f, -6.60434831e-03f, 5.88681456e-03f, -4.83965920e-03f, 7.30179548e-02f, -8.11613798e-02f, 6.15840685e-03f, 2.17693876e-02f, 1.43900989e-02f, 1.18954564e-02f,
  -2.40169037e-02f, -8.19204375e-02f, -5.34042716e-02f, -3.21359374e-02f, 4.52220477e-02f, -3.26610692e-02f, 9.27809253e-03f, 5.41130118e-02f, -3.38326395e-03f, -8.60049215e-04f,
  4.35081236e-02f, 5.92820458e-02f, -2.65685841e-02f, -4.26956564e-02f, 6.64889216e-02f, -6.25979751e-02f, -2.24143174e-02f, -4.63736840e-02f, 1.92217808e-02f, 2.75324099e-02f,
  -4.42555696e-02f, -7.06752390e-02f, -4.35923599e-02f, -5.28834276e-02f, -4.74185944e-02f, -5.92191145e-02f, 1.07197814e-01f, 5.63685223e-03f, 1.00253373e-01f, -5.79243861e-02f,
  1.16265774e-01f, 4.35242891e-01f, -2.52920762e-02f, -3.61391269e-02f, 4.94611785e-02f, -2.76543628e-02f, -4.88208886e-03f, 8.89662057e-02f, 3.72364372e-02f, 6.95303902e-02f,
  -4.41090390e-03f, -2.90538855e-02f, -1.30395091e-03f, -7.79750422e-02f, -5.62420487e-02f, 1.25563303e-02f, 1.27566010e-01f, -5.31131513e-02f, 2.58645080e-02f, 5.01586460e-02f,
  1.96682084e-02f, -5.60258776e-02f, 1.00277904e-02f, -4.55971695e-02f, 1.34378923e-02f, -2.77220714e-03f, 1.76444731e-03f, -2.12198514e-02f, 3.86107750e-02f, 4.46502604e-02f,
  1.62748799e-01f, -2.77347714e-01f, 9.15958136e-02f, 2.93926150e-01f, 2.08906621e-01f, 3.20206955e-02f, 2.11106643e-01f, 1.35354996e-01f, 1.56678304e-01f, -1.33933589e-01f,
  3.44577990e-02f, -2.33456239e-01f, -8.89234245e-02f, -2.51724906e-02f, -4.17705253e-02f, -1.27303481e-01f, 2.25043483e-02f, -4.70914356e-02f, 8.15954655e-02f, 1.37882590e-01f,
  1.75033197e-01f, 1.08977966e-02f, -9.18062776e-02f, -2.60015968e-02f, 1.43170446e-01f, 3.87019850e-02f, 4.36027274e-02f, 2.60747056e-02f, -1.70967028e-01f, -1.63422897e-01f,
  3.64403836e-02f, 2.42076423e-02f, 4.00155298e-02f, -2.53018290e-02f, 2.72457823e-02f, 8.29994157e-02f, -3.74934380e-03f, 3.97548899e-02f, 8.75927508e-02f, -6.27166927e-02f,
  -8.39224532e-02f, -5.12382723e-02f, 4.83863875e-02f, 5.06233200e-02f, 1.16896793e-01f, 1.11710522e-02f, 2.09892560e-02f, -7.61429640e-03f, -7.16063678e-02f, 4.59750276e-03f,
  3.32104340e-02f, -3.70775200e-02f, 8.44824873e-03f, -7.64515996e-02f, 2.59990990e-02f, -2.63410024e-02f, -1.44189652e-02f, -8.67944211e-02f, -2.46528629e-02f, 2.31388751e-02f,
  -4.55787219e-02f, -6.72222748e-02f, -1.17188869e-02f, 1.04664443e-02f, -6.50063902e-02f, 3.69135402e-02f, -3.27618942e-02f, 3.12437285e-02f, 4.57382239e-02f, 9.21225771e-02f,
  5.75863160e-02f, -2.33966820e-02f, 1.69231109e-02f, -5.64857163e-02f, 1.62912197e-02f, 5.40469121e-03f, -4.75987233e-02f, 2.33162835e-04f, 9.46536884e-02f, 3.67727899e-03f,
  -4.23680022e-02f, -4.17834595e-02f, -4.12230715e-02f, -7.24032074e-02f, -1.01069450e-01f, 6.43814206e-02f, -1.80210527e-02f, 2.16122642e-02f, 3.70837487e-02f, 4.27206047e-03f,
  7.35913888e-02f, -9.64640900e-02f, -4.39444184e-02f, -7.18134493e-02f, -2.38762423e-02f, -8.66917428e-03f, -3.25149000e-02f, -8.15071762e-02f, 4.24248427e-02f, -2.51574963e-02f,
  1.18335383e-02f, -1.10882437e-02f, 5.26520535e-02f, -7.24069849e-02f, -1.78952757e-02f, 5.48268575e-03f, -3.30727398e-02f, 3.75800729e-02f, 1.37300985e-02f, -6.79204762e-02f,
  -4.02611271e-02f, 5.50788604e-02f, -4.78391116e-03f, 1.01025708e-01f, -7.18656788e-03f, 6.16763122e-02f, 6.56116307e-02f, -7.09557161e-02f, -5.17422594e-02f, -7.70259351e-02f,
  -6.38380051e-01f, 6.51878864e-02f, -4.23599471e-04f, -2.03732356e-01f, -4.91638929e-02f, 2.08745673e-02f, 8.95310119e-02f, -1.10100128e-01f, -7.27106407e-02f, 3.00667472e-02f,
  1.37267753e-01f, -2.38976091e-01f, 3.74631166e-01f, 1.33233115e-01f, -1.04784258e-01f, 3.57200056e-01f, 6.58278540e-02f, -2.94547305e-02f, -2.30707228e-02f, -2.11961731e-01f,
  -8.91493633e-02f, -1.75650176e-02f, 1.78671345e-01f, 8.68847296e-02f, -1.37997076e-01f, -2.24560350e-01f, -1.65886506e-01f, 1.06425688e-01f, -1.16768204e-01f, -1.16249663e-03f,
  -2.06561640e-01f, -2.99472243e-01f, -8.75965953e-02f, -5.89143597e-02f, -1.07378483e-01f, -4.80370671e-02f, -4.25261781e-02f, 1.28548937e-02f, -1.13444462e-01f, -6.38368353e-02f,
  -1.17945448e-01f, -2.68754736e-02f, -4.09762748e-02f, -3.22435908e-02f, -6.76598847e-02f, -4.56411280e-02f, 5.23442440e-02f, 7.33032674e-02f, 2.48431284e-02f, -8.28951411e-03f,
  1.09374009e-01f, 2.53993161e-02f, 1.72661059e-02f, 3.65005769e-02f, 4.16782917e-03f, 5.36663085e-02f, 6.08687475e-02f, 2.66183342e-04f, -7.06382543e-02f, -9.97347534e-02f,
  -2.42718384e-02f, 6.78860694e-02f, -3.80583145e-02f, 6.02832213e-02f, -6.97125718e-02f, 1.33414760e-01f, 8.07341281e-03f, -4.08177003e-02f, 3.03439237e-02f, -1.91961732e-02f,
  -5.93458712e-02f, 1.60290003e-02f, -5.05643450e-02f, 5.20646051e-02f, -5.20047471e-02f, 2.55193617e-02f, 5.67669012e-02f, -1.11703882e-02f, 4.73069400e-02f, 4.15481031e-02f,
  3.49425003e-02f, -8.15029349e-03f, 1.24969194e-02f, 5.24446331e-02f, 4.84422110e-02f, 5.98938912e-02f, 9.01986659e-03f, 5.97772524e-02f, 6.71763951e-03f, -3.31657082e-02f,
  -4.00119245e-01f, -4.57467407e-01f, -8.24515149e-02f, -1.21785104e-01f, -3.94469276e-02f, -9.75882858e-02f, 2.00100429e-02f, 1.56301185e-02f, -9.37284976e-02f, -2.54173316e-02f,
  -6.78441599e-02f, -4.21501286e-02f, -5.24207912e-02f, 6.08464666e-02f, -4.23236564e-02f, -1.01518789e-02f, -7.25317001e-02f, -8.77301618e-02f, -4.91729304e-02f, -4.39149439e-02f,
  -2.06824802e-02f, 4.68721846e-03f, -1.42874885e-02f, -1.58406906e-02f, -5.75805362e-03f, -1.24744117e-01f, -1.27840310e-01f, 3.53590399e-02f, -7.09860250e-02f, 7.18516186e-02f,
  -2.28251159e-01f, 3.13963257e-02f, -1.62404165e-01f, -1.05999336e-01f, 4.13016789e-02f, -7.89473206e-02f, 4.25879322e-02f, 5.05549312e-02f, 9.91319586e-03f, 1.77198470e-01f,
  1.70969605e-01f, -1.59499153e-01f, 7.20173717e-02f, -1.24083363e-01f, -1.42776027e-01f, -8.70199203e-02f, -5.87833226e-02f, -1.12279639e-01f, -1.30748719e-01f, -3.93691920e-02f,
  -1.48276687e-01f, 8.06459114e-02f, -4.13755514e-02f, 1.62934497e-01f, -2.36422848e-03f, 9.31830239e-03f, 1.63425863e-01f, 1.78372756e-01f, 7.66396075e-02f, -7.21807107e-02f,
  -7.23105506e-04f, 1.06074087e-01f, -2.92371437e-02f, -1.04961224e-01f, 5.46838790e-02f, 7.37455906e-03f, -6.65115332e-03f, -8.18175375e-02f, -9.35402140e-03f, -3.97990495e-02f,
  -9.48675051e-02f, -3.48873460e-03f, 7.62077281e-03f, 8.67399424e-02f, 4.84277830e-02f, -1.21694943e-02f, 4.29568067e-03f, 1.00822531e-01f, -7.59748667e-02f, 4.36948389e-02f,
  1.86937433e-02f, 6.35973960e-02f, 6.02733009e-02f, -2.14847732e-05f, -4.24718261e-02f, -3.59243788e-02f, -6.96384460e-02f, 1.54342924e-04f, 3.72312516e-02f, 3.38651985e-02f,
  2.41035204e-02f, 4.60419469e-02f, 9.01333913e-02f, -2.37759817e-02f, 5.64320236e-02f, 6.06956817e-02f, 7.18435422e-02f, -4.47693057e-02f, 8.93685743e-02f, -7.25932494e-02f,
  8.22480489e-03f, 3.62792872e-02f, -7.01012388e-02f, -2.14372631e-02f, -5.71398996e-02f, -9.36613679e-02f, -3.09979822e-02f, 3.56154256e-02f, 7.32271979e-03f, 3.30183469e-02f,
  3.69850025e-02f, -9.81580019e-02f, -5.28163463e-02f, 1.76898818e-02f, 5.01166992e-02f, -2.90173688e-03f, 8.81751105e-02f, -8.99314955e-02f, 6.37064353e-02f, 6.96499124e-02f,
  1.53382160e-02f, -5.76634407e-02f, 5.94487041e-02f, 8.32183510e-02f, -8.25333819e-02f, 1.09256273e-02f, -7.72242919e-02f, 3.34821045e-02f, -6.66532516e-02f, 7.74584860e-02f,
  -2.75773499e-02f, 1.09948264e-02f, 3.48054394e-02f, -2.51731146e-02f, -1.69128515e-02f, 7.19754994e-02f, -3.10684033e-02f, -2.81764437e-02f, -4.44373339e-02f, 7.20922425e-02f,
  -6.69998536e-03f, 6.40052855e-02f, 1.93800963e-02f, 6.89071268e-02f, 4.33325954e-02f, 6.28966242e-02f, -4.15496193e-02f, 2.14981437e-02f, -1.58413164e-02f, 5.87489307e-02f,
  1.55786872e-01f, -3.04665864e-01f, -2.96594083e-01f, 8.78894422e-03f, 2.14638591e-01f, 2.36579910e-01f, 6.58445507e-02f, 3.71487513e-02f, -1.43511489e-01f, -1.27821758e-01f,
  1.53491080e-01f, -9.45801809e-02f, -2.91414350e-01f, 2.00896710e-01f, 2.59255111e-01f, -4.90026958e-02f, 1.77693233e-01f, 3.41357403e-02f, 5.88996410e-02f, -6.03477247e-02f,
  1.13821812e-01f, 3.32818568e-01f, -2.37076860e-02f, 1.75983623e-01f, 5.05117998e-02f, -6.28160089e-02f, 1.11047635e-02f, -1.34860426e-01f, 9.26105082e-02f, 1.95859656e-01f,
  9.64183956e-02f, -3.23878378e-02f, 1.07835289e-02f, 2.31863204e-02f, 4.94090430e-02f, 1.18423654e-02f, -7.88662210e-02f, 1.26191042e-02f, 1.22660808e-02f, -7.42093772e-02f,
  -1.04680859e-01f, -4.55071293e-02f, 1.49461195e-01f, 3.62285413e-03f, 1.27597023e-02f, 1.11883879e-01f, -2.49738107e-03f, 2.96211056e-03f, -1.17058687e-01f, 5.48964040e-03f,
  -8.93970430e-02f, -3.55020864e-03f, -1.01309426e-01f, 2.15391610e-02f, 8.03518388e-03f, 6.92601502e-02f, -3.16662639e-02f, -5.56313656e-02f, -7.24112466e-02f, 5.58723174e-02f,
  -4.57571149e-02f, 4.84462688e-03f, 4.83541489e-02f, 3.14694196e-02f, -3.03720273e-02f, 7.90224131e-03f, 2.19951067e-02f, 4.55564074e-02f, -5.09313028e-03f, 3.05734761e-03f,
  -1.77773684e-02f, -1.13527607e-02f, -5.27377278e-02f, -3.97789665e-02f, 7.53537044e-02f, -1.54912379e-02f, -2.23617870e-02f, -6.28924519e-02f, -2.54185442e-02f, 4.68069501e-02f,
  -2.04682592e-02f, 8.49296972e-02f, -7.80143663e-02f, 4.47855331e-02f, -3.76276895e-02f, -1.29815349e-02f, -2.48926338e-02f, -2.14239117e-02f, -1.69146080e-02f, 1.92734785e-02f,
  -7.86384009e-03f, -1.27619788e-01f, -7.76311681e-02f, 7.07713515e-02f, 2.38515381e-02f, 8.47439840e-02f, -7.79371010e-03f, 9.61018130e-02f, 2.72688847e-02f, 6.07958287e-02f,
  -6.82120100e-02f, 8.71585123e-03f, 6.36324733e-02f, 2.23814938e-02f, -1.47698252e-02f, -6.36455193e-02f, -2.24608835e-02f, -2.30151080e-02f, -6.77212253e-02f, -1.88512206e-02f,
  -9.62066874e-02f, 2.52847243e-02f, 6.07217886e-02f, 7.13759363e-02f, -6.18802831e-02f, -6.24862872e-02f, 1.96802840e-02f, -1.03454082e-03f, -7.69932121e-02f, -3.14797321e-03f,
  -5.55216409e-02f, -1.29533529e-01f, -1.82467148e-01f, 9.93783493e-03f, 4.28880379e-02f, 2.36211047e-01f, -2.46678200e-02f, 4.44016382e-02f, 2.95452233e-02f, 3.58143821e-02f,
  1.97778922e-02f, 2.56125280e-03f, -1.63296252e-01f, 3.80509533e-02f, 4.64790314e-02f, -7.56726488e-02f, 1.39291123e-01f, 1.29961163e-01f, 5.20092510e-02f, -6.00258932e-02f,
  5.00496961e-02f, 1.08411163e-01f, -1.37851506e-01f, 1.34968966e-01f, 1.00716360e-01f, 2.79460009e-02f, 5.47134094e-02f, -1.45916209e-01f, 1.10430554e-01f, 9.95094180e-02f,
  -7.49413818e-02f, -3.80720012e-02f, -3.62141766e-02f, -2.08107103e-02f, 4.73693646e-02f, -6.54907674e-02f, -6.01538792e-02f, 7.41676167e-02f, 8.13648850e-02f, 5.55430166e-02f,
  6.42133579e-02f, -7.91811664e-03f, 1.24508239e-01f, 3.70374648e-03f, -4.06322964e-02f, -6.49383813e-02f, -5.10940030e-02f, -1.06544286e-01f, -1.60131790e-02f, -9.93130654e-02f,
  -8.68530422e-02f, 1.28220972e-02f, -5.27185276e-02f, -1.31283253e-02f, 4.17205319e-02f, -5.48620187e-02f, 6.73478693e-02f, 6.96688220e-02f, 8.84742886e-02f, 6.99696317e-02f,
  -1.51087372e-02f, 7.69887539e-03f, -7.64281750e-02f, 4.94959280e-02f, -5.33542335e-02f, -2.84811128e-02f, -3.92423011e-02f, 7.63262510e-02f, -3.42242196e-02f, 5.94188645e-02f,
  5.03535867e-02f, -5.26789241e-02f, -2.04759166e-02f, 9.78421569e-02f, -4.69569005e-02f, 5.38183488e-02f, -8.49080160e-02f, -2.20672716e-03f, -8.37865025e-02f, 4.65590246e-02f,
  -1.04156256e-01f, 2.09830087e-02f, 7.47281462e-02f, -2.84512136e-02f, -3.39100584e-02f, -3.92127270e-03f, -2.34229062e-02f, -6.99126869e-02f, -6.17727451e-02f, -1.50410570e-02f,
  1.24731146e-01f, 3.47314551e-02f, -5.00371233e-02f, 8.44748393e-02f, 4.45231795e-02f, -3.25966552e-02f, 4.48158272e-02f, 8.67342949e-02f, -6.82476349e-03f, -5.60782216e-02f,
  -5.86831160e-02f, -3.58182788e-02f, -6.96101633e-04f, -7.46717229e-02f, 7.87860975e-02f, 8.70867446e-02f, 5.49878068e-02f, -2.13045944e-02f, 2.87453718e-02f, -6.84613734e-02f,
  -9.68817919e-02f, -4.80984524e-02f, -3.44958901e-02f, -1.60080940e-02f, 7.05951825e-02f, 3.47846150e-02f, 3.86313498e-02f, 6.11831173e-02f, 4.04429473e-02f, 6.73191920e-02f,
  1.16155230e-01f, -3.55869606e-02f, -7.89606348e-02f, 4.78313975e-02f, -2.16429487e-01f, 4.19606129e-03f, -5.26209176e-02f, -2.17980027e-01f, -4.67620448e-05f, 3.41476910e-02f,
  -1.40460402e-01f, 1.76700413e-01f, 1.00118145e-01f, -1.17841505e-01f, -1.48343444e-02f, 1.39605805e-01f, -9.91751030e-02f, 4.84267958e-02f, -6.32195771e-02f, -9.30455793e-03f,
  1.61791649e-02f, -8.51305053e-02f, -7.02591687e-02f, -2.78171152e-01f, -1.66706279e-01f, -1.38312578e-01f, 4.39764038e-02f, -5.05609578e-03f, -1.39973372e-01f, -8.95537809e-02f,
  2.76494846e-02f, -1.51336845e-02f, -4.91834134e-02f, -3.95465419e-02f, -2.19928585e-02f, 1.05816513e-01f, 4.56854887e-02f, 6.02435842e-02f, -6.37435541e-02f, -6.93950653e-02f,
  1.51397079e-01f, 2.08740346e-02f, 8.05450603e-02f, 9.38339606e-02f, -3.20031233e-02f, -2.92278603e-02f, -4.77348045e-02f, -6.04576543e-02f, 8.15673266e-03f, 7.55830035e-02f,
  2.71458691e-03f, 3.34889106e-02f, 2.10288074e-02f, 1.11037910e-01f, 5.51364720e-02f, -8.58764071e-03f, 1.20282620e-01f, 1.14625186e-01f, 4.50556763e-02f, -8.79129693e-02f,
  2.61447616e-02f, -6.33861450e-03f, 8.06476995e-02f, -9.93667394e-02f, -6.53480962e-02f, -4.06562872e-02f, 4.82254252e-02f, 6.33019488e-03f, -5.40790148e-02f, 3.71067449e-02f,
  -8.99603870e-03f, 3.98908518e-02f, -6.98909685e-02f, 7.71048144e-02f, 3.79285999e-02f, 6.57407641e-02f, 3.97528186e-02f, -5.60096279e-02f, 7.38227516e-02f, 2.14836635e-02f,
  2.81793252e-02f, -2.71124449e-02f, -9.51430388e-03f, 8.09861347e-02f, 4.55994904e-02f, 4.65399632e-03f, -6.68422356e-02f, -5.71835078e-02f, -1.43558998e-03f, -2.78065633e-03f,
  -4.63327952e-02f, 1.25560388e-02f, 4.59720902e-02f, -5.00846356e-02f, -4.53021862e-02f, -4.21561208e-03f, 8.51809885e-03f, -9.73196626e-02f, 2.32559852e-02f, 7.14728460e-02f,
  3.82067189e-02f, 1.55549584e-04f, -2.20712088e-02f, -3.71822119e-02f, 4.01572697e-02f, -2.85563841e-02f, 7.49176368e-02f, 5.93446530e-02f, 6.48524612e-02f, -4.52843644e-02f,
  -1.33420024e-02f, -2.20105033e-02f, 4.04769108e-02f, -4.68752049e-02f, 7.67842457e-02f, -7.61265755e-02f, -5.32102473e-02f, -2.41891295e-02f, 2.94231344e-02f, -2.65955627e-02f,
  2.52980828e-01f, 2.16883458e-02f, -2.27849886e-01f, -2.60534972e-01f, 5.92357805e-03f, 2.10478485e-01f, 4.67703380e-02f, -1.20814499e-02f, -2.73441374e-01f, 2.09704205e-01f,
  2.09054053e-01f, -6.51299953e-02f, -9.88013670e-02f, 2.63713077e-02f, -6.79591447e-02f, -1.17471576e-01f, 1.40653148e-01f, 5.88641539e-02f, -1.19935155e-01f, 9.81467888e-02f,
  4.62815650e-02f, 9.39876586e-02f, -1.53497890e-01f, 5.29740192e-02f, 1.74723268e-01f, 2.24868245e-02f, 1.40937999e-01f, -1.50391564e-01f, 9.75779295e-02f, 5.69522567e-02f,
  1.10890772e-02f, -4.67708968e-02f, -4.95760366e-02f, -1.14883468e-01f, 6.12278795e-03f, 2.02593133e-01f, 4.41984124e-02f, -8.18381757e-02f, -1.22112595e-03f, 2.34026741e-02f,
  -5.95882609e-02f, -1.34848118e-01f, -4.29753810e-02f, 2.72590239e-02f, 7.16442615e-02f, -5.00088260e-02f, -7.31787458e-02f, 2.71304362e-02f, -8.22617188e-02f, 4.56074066e-02f,
  -5.27853519e-02f, -2.88302806e-04f, 8.35407339e-03f, -1.10746428e-01f, -6.50017411e-02f, -6.90751672e-02f, -4.89057973e-02f, -5.57167567e-02f, 3.07223033e-02f, -1.81788765e-02f,
  1.53916791e-01f, 4.31878306e-02f, 9.81953964e-02f, -4.85027267e-04f, 7.30933696e-02f, 6.78978711e-02f, -2.04980373e-02f, 8.13866630e-02f, -7.76535794e-02f, 6.52957857e-02f,
  -1.41914804e-02f, 1.39642805e-02f, -3.76458094e-02f, 4.44916934e-02f, 5.50794825e-02f, -4.75958623e-02f, -2.27273181e-02f, 3.10025588e-02f, -2.84272470e-02f, -9.22276974e-02f,
  4.37517427e-02f, 5.50970882e-02f, 1.11916466e-02f, 1.61605980e-02f, -4.74992469e-02f, 1.67771336e-02f, 1.39853135e-01f, 4.02460843e-02f, -8.21657479e-02f, -1.10881254e-02f,
  1.21585563e-01f, 1.11857340e-01f, 3.33276093e-02f, -1.69969313e-02f, 4.50938679e-02f, 1.03183717e-01f, 5.49585633e-02f, -8.27312376e-03f, 3.09081213e-03f, -5.06409779e-02f,
  5.43139838e-02f, 1.61460675e-02f, 4.72490564e-02f, -7.98023716e-02f, -2.19990648e-02f, 1.28456682e-01f, -6.84652403e-02f, -1.16105057e-01f, 2.80103572e-02f, 7.18846321e-02f,
  -5.49940169e-02f, 1.15525937e-02f, -5.50270043e-02f, -6.09687008e-02f, 7.26706386e-02f, 5.61349317e-02f, 2.43663639e-02f, -9.82990116e-02f, 9.08773839e-02f, -5.61306626e-02f,
  5.40650412e-02f, 1.57246113e-01f, 1.08159289e-01f, 2.46119928e-02f, 2.54343431e-02f, 6.74479753e-02f, 7.84527063e-02f, -7.44888932e-02f, -7.64025748e-02f, -9.71781556e-03f,
  -3.65038887e-02f, 5.71078025e-02f, -3.89416656e-03f, 1.14765458e-01f, 2.33025141e-02f, 2.21796893e-02f, -4.89103161e-02f, 9.10617411e-02f, 3.45592350e-02f, -1.02941386e-01f,
  -5.15445061e-02f, -1.32339299e-01f, 1.20744415e-01f, -1.79406717e-01f, 3.98697928e-02f, 7.21237296e-03f, -1.56074896e-01f, -2.75107026e-02f, 2.29492579e-02f, -1.05086798e-02f,
  7.97746256e-02f, -8.61037895e-02f, -2.32780203e-02f, 7.91073292e-02f, 1.74326394e-02f, 9.75623354e-02f, -3.43609378e-02f, 9.32941362e-02f, -1.64630096e-02f, -5.54605648e-02f,
  -9.12752189e-03f, 7.02724047e-03f, -7.81489909e-02f, -1.13587767e-01f, 2.93573178e-02f, -7.37285390e-02f, -4.66413945e-02f, 1.06750652e-01f, 1.38826638e-01f, 7.19502196e-02f,
  9.55389962e-02f, 3.29672508e-02f, -6.05547614e-02f, 8.58550053e-03f, -3.54553387e-02f, -6.85381740e-02f, -1.22413076e-02f, 8.48167613e-02f, -5.81311621e-02f, 7.84236416e-02f,
  4.70695086e-02f, -4.29517515e-02f, 9.49652940e-02f, 9.82091529e-04f, -5.16069531e-02f, -6.38872311e-02f, 4.41449061e-02f, -1.08200889e-02f, -4.33001667e-02f, 5.75257931e-03f,
  -2.34111324e-02f, 1.01024797e-03f, 6.63097873e-02f, 5.88033386e-02f, -8.72244220e-03f, -2.13921815e-02f, -1.42439483e-02f, 7.72996321e-02f, -5.09147486e-03f, 6.84239566e-02f,
  -9.15321931e-02f, 2.62074266e-02f, -4.43799831e-02f, 1.31876813e-02f, -5.68602420e-02f, 3.13280672e-02f, -5.42265065e-02f, -2.81436834e-02f, -8.58780891e-02f, -8.90912488e-02f,
  -5.83762974e-02f, -1.39257267e-01f, -7.22966865e-02f, -3.64767574e-02f, -2.61453763e-02f, 6.11237250e-02f, -5.52658848e-02f, 7.27712288e-02f, 4.90981936e-02f, -5.92461904e-04f,
  -2.55575702e-02f, -6.77053481e-02f, 9.20919180e-02f, -9.11368728e-02f, -8.89836252e-02f, 6.12583719e-02f, -7.66495429e-03f, -1.85898133e-02f, 2.15971004e-02f, 7.63932690e-02f,
  1.04359975e-02f, -6.71302453e-02f, 7.91195855e-02f, 2.10105553e-02f, -2.22606529e-02f, 4.17727977e-02f, 1.26751140e-02f, -3.27572227e-02f, 1.12810163e-02f, 4.88783903e-02f,
  -1.27310768e-01f, -3.17507200e-02f, -9.49109197e-02f, -1.06689088e-01f, 1.39667131e-02f, 1.70375228e-01f, 7.93282464e-02f, -2.10034382e-02f, -1.43524453e-01f, 6.34966195e-02f,
  1.61101580e-01f, -9.96615142e-02f, 1.13265425e-01f, 7.42339296e-03f, -1.29612342e-01f, -7.63946772e-02f, 4.64422368e-02f, 4.79589887e-02f, -1.77161694e-01f, 2.03876868e-02f,
  -1.53983250e-01f, 7.62251839e-02f, -5.09434976e-02f, 2.03591455e-02f, -5.46061760e-03f, 4.04652730e-02f, 1.25894308e-01f, 1.21541530e-01f, 5.57109639e-02f, 4.84289527e-02f,
  -3.40488292e-02f, -1.44950286e-01f, -5.84807210e-02f, -9.12511663e-04f, 5.37804142e-02f, 1.40566066e-01f, 4.30143028e-02f, 9.75399166e-02f, -3.48591283e-02f, 2.13699434e-02f,
  2.74197347e-02f, 4.79781292e-02f, 2.78868806e-02f, -1.13509789e-01f, -1.04289472e-01f, -5.28714173e-02f, 5.96700870e-02f, -3.68832611e-02f, -9.58379805e-02f, -8.07055831e-02f,
  -2.85852831e-02f, 2.61796005e-02f, -1.58247957e-03f, 4.86160181e-02f, 4.38144989e-02f, -5.00007086e-02f, -3.02086547e-02f, 7.58440420e-02f, -7.27871284e-02f, -5.36327250e-02f,
  -4.70905975e-02f, -2.15727724e-02f, 8.44379663e-02f, 3.08247823e-02f, -3.48602086e-02f, 2.44418774e-02f, -1.92409307e-02f, 6.27627745e-02f, 4.89340052e-02f, 5.37699722e-02f,
  5.10059334e-02f, -3.78146805e-02f, -3.24551128e-02f, 3.50117758e-02f, 5.41729517e-02f, -6.72155395e-02f, -2.66435724e-02f, -7.32500702e-02f, 3.59412581e-02f, -1.06239144e-03f,
  5.38548976e-02f, -1.04052514e-01f, 7.83979371e-02f, 5.64157851e-02f, -3.61737721e-02f, 1.45301800e-02f, -4.70224097e-02f, 6.27515242e-02f, -6.83398545e-02f, -7.73118716e-03f,
  6.80596083e-02f, 5.77721968e-02f, 6.64884970e-02f, 6.35263696e-02f, 1.08105160e-01f, 2.66195484e-03f, 6.75827935e-02f, -5.38122170e-02f, -7.46976882e-02f, -7.15830624e-02f,
  8.34264085e-02f, -5.52921295e-02f, 1.53030492e-02f, -7.90694803e-02f, -4.43623252e-02f, 9.17000845e-02f, -4.23795097e-02f, 6.86685741e-02f, -2.60777008e-02f, 4.69149388e-02f,
  7.39093199e-02f, 1.14934333e-01f, 4.27807979e-02f, 3.24683972e-02f, -2.28465572e-02f, 3.84932309e-02f, 2.26342622e-02f, 8.64854604e-02f, -3.11419722e-02f, 5.80676794e-02f,
  -8.78355354e-02f, -1.54848665e-01f, -1.50139824e-01f, -2.77677551e-02f, -5.16798571e-02f, -2.97440857e-01f, -2.81987607e-01f, -7.93643296e-02f, -1.21835567e-01f, -1.95855454e-01f,
  -5.50916493e-02f, 5.44979088e-02f, -1.40560389e-01f, -1.67291448e-01f, 1.51153207e-01f, -2.66453400e-02f, -1.31167406e-02f, -8.31864774e-02f, 9.94647592e-02f, -3.70251946e-02f,
  6.36407360e-02f, 1.18840463e-01f, 1.56668961e-01f, 2.06195801e-01f, -1.39182031e-01f, 1.88173920e-01f, 2.61816919e-01f, 5.27243875e-02f, 1.49610266e-01f, 1.13661457e-02f,
  -5.06739430e-02f, -9.77536067e-02f, -1.18306018e-01f, 1.22453496e-02f, 3.83347794e-02f, 3.49246450e-02f, 2.55701691e-03f, 5.18946238e-02f, 8.17609485e-03f, -4.05755416e-02f,
  3.22101600e-02f, -3.74160893e-03f, 3.34176887e-03f, 7.95440227e-02f, -5.47868758e-02f, -7.75714405e-03f, 7.94748291e-02f, 8.92081764e-03f, -9.52730998e-02f, -3.98678519e-02f,
  1.06153321e-02f, 5.67162931e-02f, 5.46547547e-02f, 2.51887795e-02f, 1.00597180e-01f, -6.39114110e-03f, -2.35100016e-02f, 1.16939276e-01f, 5.46524674e-02f, 8.85264874e-02f,
  7.38687217e-02f, -8.59589968e-03f, -8.32322165e-02f, 2.20981217e-03f, -2.46381052e-02f, -1.98190901e-02f, 6.78922236e-02f, 4.33155186e-02f, 8.25717002e-02f, -3.40227224e-02f,
  1.02351028e-02f, 3.45839523e-02f, 1.73166599e-02f, -9.28589888e-03f, -3.46298739e-02f, 4.67082858e-02f, -3.72068137e-02f, -1.01513704e-02f, 4.23481129e-02f, 4.26380821e-02f,
  2.67168973e-02f, 2.27097739e-02f, 2.61812266e-02f, 2.85018943e-02f, -1.03454620e-01f, 6.65583983e-02f, 5.50665632e-02f, -6.69642584e-03f, 4.60496545e-02f, -4.21109758e-02f,
  -2.42891978e-03f, 2.28359982e-01f, 3.36256297e-03f, 6.69172965e-03f, -4.14739922e-02f, -7.20037222e-02f, -4.95140590e-02f, -6.30595386e-02f, -1.41207604e-02f, 2.85726879e-02f,
  4.40203659e-02f, -1.18234437e-02f, 9.60245670e-04f, 2.26988643e-02f, 9.59211141e-02f, -6.18514381e-02f, 8.85869414e-02f, 1.22139722e-01f, -7.80077185e-03f, 1.09548800e-01f,
  7.86153749e-02f, -3.54810022e-02f, 2.34541837e-02f, -4.48830612e-02f, 6.44584838e-03f, 2.81257723e-02f, 2.17415858e-02f, -3.72741707e-02f, 8.96392018e-02f, -5.47505952e-02f,
  7.88799003e-02f, 9.23339278e-02f, -2.25292012e-01f, -2.40969226e-01f, -6.67090341e-02f, -1.76260412e-01f, -3.13731313e-01f, -1.12855047e-01f, -5.28273508e-02f, -1.02154784e-01f,
  -4.22575623e-02f, 1.52421268e-02f, 2.11276431e-02f, -8.62977430e-02f, 1.67589158e-01f, 2.17406556e-01f, -1.24604076e-01f, -1.91413872e-02f, 1.38637036e-01f, -1.68824792e-01f,
  9.23811570e-02f, -7.27609619e-02f, 5.58057148e-03f, 2.86642220e-02f, -1.10225618e-01f, -1.72267377e-01f, -3.15352418e-02f, -1.75835848e-01f, -1.21643148e-01f, 3.78435664e-02f,
  -3.90997529e-02f, -9.62522067e-03f, -1.25710845e-01f, -8.95455778e-02f, 9.25937947e-03f, 1.46780023e-02f, -1.13521785e-01f, 1.27820047e-02f, -1.13316409e-01f, 4.52593416e-02f,
  4.10552360e-02f, 3.44498456e-02f, -4.90606092e-02f, 5.81305400e-02f, -7.21947849e-02f, -8.18533376e-02f, 7.17059970e-02f, -1.30942306e-02f, -1.09321505e-01f, 8.45762342e-02f,
  -3.51440050e-02f, -4.62276563e-02f, -1.23627454e-01f, -7.64562860e-02f, -7.86167383e-02f, -7.57249817e-02f, -8.12136605e-02f, 7.46099604e-03f, 4.74224016e-02f, 5.58735318e-02f,
  1.72392409e-02f, 5.92678040e-02f, 9.71708074e-02f, -2.95080636e-02f, 6.83664680e-02f, 1.61955878e-02f, 4.63889875e-02f, 6.63469138e-04f, 3.45941968e-02f, 8.25450122e-02f,
  -5.49414344e-02f, -6.48714304e-02f, 5.69101088e-02f, -1.01439497e-02f, -8.81077349e-03f, -2.35660728e-02f, -4.22684476e-02f, 3.74750271e-02f, -6.01246627e-03f, -2.21644659e-02f,
  -6.91908523e-02f, 7.12992474e-02f, 4.17500548e-02f, -1.47679234e-02f, -1.28865289e-02f, 2.00902298e-02f, 6.52951002e-02f, 4.30596694e-02f, -5.85314631e-02f, 1.86746977e-02f,
  7.55025148e-02f, 1.38193124e-03f, -3.91716231e-03f, -6.02723546e-02f, -6.14016205e-02f, 7.86320344e-02f, -6.42126203e-02f, 3.47478315e-02f, -6.50556087e-02f, 2.34237295e-02f,
  -8.46069530e-02f, -6.44823210e-03f, -1.57852918e-02f, 4.08873819e-02f, 3.58602665e-02f, 5.37323393e-02f, -1.01337306e-01f, 5.67712747e-02f, -7.78478011e-02f, -6.96221292e-02f,
  -3.51251289e-02f, -4.09928262e-02f, -2.14614961e-02f, 2.82412451e-02f, 7.30521679e-02f, -4.01306115e-02f, -6.20107725e-02f, -8.41105264e-03f, 3.07090618e-02f, 1.86233334e-02f,
  2.33528353e-02f, 1.90787595e-02f, -2.11122289e-01f, 1.64522722e-01f, -4.37508747e-02f, 3.13431948e-01f, 2.81692445e-01f, 6.09001890e-02f, 3.45256120e-01f, 1.91632494e-01f,
  1.68667167e-01f, -8.32586139e-02f, -2.59597544e-02f, 2.69041479e-01f, 1.18055798e-01f, 2.06798017e-01f, 3.08629990e-01f, 2.16780901e-01f, -1.57339331e-02f, 3.36327739e-02f,
  3.95320617e-02f, 1.61159322e-01f, -1.14490442e-01f, -3.58797051e-02f, -1.44357666e-01f, -1.68334991e-01f, -1.68093681e-01f, -2.27929875e-01f, -3.24409418e-02f, 1.28423478e-02f,
  1.47860840e-01f, 1.28349096e-01f, -2.98141576e-02f, -3.03461626e-02f, -5.12721725e-02f, -5.12987934e-02f, -1.17355391e-01f, -8.28282256e-03f, -5.00804968e-02f, -2.16202661e-02f,
  -7.41506144e-02f, -2.17577741e-02f, 7.80779570e-02f, -9.93029997e-02f, 3.45032895e-03f, -9.10715386e-02f, -5.63027076e-02f, 9.56186000e-03f, -3.95498984e-02f, -1.57308072e-01f,
  -2.49453299e-02f, -4.50164266e-02f, 3.31734167e-03f, 2.93832440e-02f, -7.80981332e-02f, -2.88087968e-03f, -3.59040126e-02f, -9.90465358e-02f, 1.73467360e-02f, -1.02199987e-02f,
  -4.72728759e-02f, -1.45750530e-02f, -2.77550779e-02f, 3.26592103e-02f, -4.82083149e-02f, -7.05979168e-02f, 6.45016087e-03f, 2.14713849e-02f, -8.12656619e-03f, 5.21275513e-02f,
  -8.34355131e-03f, 1.45956045e-02f, 4.91618104e-02f, 6.67245239e-02f, 7.20054135e-02f, 9.06141400e-02f, 2.60443166e-02f, 3.99304964e-02f, 6.44835532e-02f, 8.44672974e-03f,
  1.92148946e-02f, 4.68851104e-02f, 3.54056060e-02f, 6.73701018e-02f, 6.52636066e-02f, -1.56102050e-02f, 1.05732828e-02f, 6.29976857e-03f, 1.53587554e-02f, -5.43680340e-02f,
  1.93693787e-02f, -2.23751529e-03f, 3.87589596e-02f, -6.74776509e-02f, -2.36441996e-02f, 1.97383054e-02f, -1.12312175e-02f, -1.43518820e-02f, 8.99696201e-02f, 8.81299153e-02f,
  -3.20749842e-02f, 2.73319725e-02f, 3.57567966e-02f, 5.17995730e-02f, -4.16446775e-02f, 1.01420604e-01f, 7.39281476e-02f, -6.84445426e-02f, 4.85012233e-02f, -1.61945783e-02f,
  -8.63122866e-02f, 1.01235788e-02f, 7.91219622e-02f, -4.34441958e-03f, 9.13228840e-02f, -5.02649099e-02f, 4.54797372e-02f, -1.54822338e-02f, -3.16627547e-02f, 5.98250479e-02f,
  3.26729156e-02f, 6.24219538e-05f, 1.01947196e-01f, -1.11084715e-01f, -1.77915227e-02f, -6.57437444e-02f, -1.12956159e-01f, 1.09018251e-01f, 1.16891220e-01f, 8.65014791e-02f,
  6.47739321e-02f, -6.67045861e-02f, 1.79754402e-02f, -3.40529419e-02f, -1.36883870e-01f, -7.04827309e-02f, -1.54860675e-01f, -9.09717232e-02f, -7.43472874e-02f, 6.38514338e-03f,
  -9.03481692e-02f, 1.66759063e-02f, -1.60518996e-02f, 6.30686730e-02f, 7.26094618e-02f, 1.22286230e-01f, 1.79009195e-02f, 4.74969707e-02f, 3.17953788e-02f, 3.36718522e-02f,
  -5.90939214e-03f, 1.35183036e-01f, -1.82463918e-02f, 8.26358348e-02f, 1.07419632e-01f, -5.83443977e-02f, -5.33331782e-02f, 1.89011190e-02f, -9.24758017e-02f, 5.20869978e-02f,
  5.35615571e-02f, 6.74508065e-02f, 4.45057265e-02f, -1.04782106e-02f, 7.32101798e-02f, 8.83840844e-02f, 3.14870081e-03f, 4.71703559e-02f, -5.06392084e-02f, -4.78630252e-02f,
  1.11971021e-01f, 8.66134912e-02f, -1.03351043e-03f, 8.19768086e-02f, -8.09543654e-02f, 3.83795574e-02f, -7.56498501e-02f, 2.21486725e-02f, -6.42160559e-03f, -3.76414582e-02f,
  3.70195438e-03f, 6.99953660e-02f, -5.36760911e-02f, 7.26234987e-02f, 5.04132509e-02f, 8.93430784e-02f, -3.88829149e-02f, -2.10055392e-02f, 1.51632642e-02f, -2.54212562e-02f,
  3.75358351e-02f, 5.06943427e-02f, 2.50945520e-02f, -3.85057963e-02f, -5.15978374e-02f, -5.43160783e-03f, -7.96640106e-03f, -9.10341442e-02f, -4.13020402e-02f, 6.86781183e-02f,
  -2.90125478e-02f, 6.27732351e-02f, 3.31172124e-02f, -6.61408715e-03f, 9.61716920e-02f, -5.05792201e-02f, -6.30329847e-02f, -6.49254620e-02f, 7.82461837e-02f, -9.15847123e-02f,
  3.12355291e-02f, -7.26178363e-02f, 1.12341069e-01f, -5.74287400e-02f, -6.68435916e-02f, -1.00998534e-02f, -3.62936258e-02f, 5.95079549e-02f, 6.25169054e-02f, 3.90495290e-03f,
  -5.33317812e-02f, 4.38023964e-03f, 1.06720021e-02f, 2.77717002e-02f, -3.80746350e-02f, -2.92886999e-02f, -6.00157715e-02f, 3.99395339e-02f, -7.05181286e-02f, 3.61354537e-02f,
  -2.93878131e-02f, 2.89682746e-02f, 6.38967082e-02f, -2.58796606e-02f, -7.54698142e-02f, 4.57200669e-02f, -9.95802656e-02f, 8.03233758e-02f, -8.86724591e-02f, -3.43868323e-02f,
  2.35166699e-02f, -2.36534723e-03f, -1.63333975e-02f, -4.11832612e-03f, 3.90881626e-03f, 1.79520682e-01f, 2.43910983e-01f, -5.50717264e-02f, -9.56192389e-02f, 5.74337179e-03f,
  6.31094500e-02f, -1.11363761e-01f, 2.45289039e-02f, -6.48194849e-02f, 1.09063275e-01f, 1.00607358e-01f, 9.49401408e-02f, 7.02467635e-02f, -1.70100462e-02f, 7.39030680e-03f,
  -1.65671036e-02f, -4.92731296e-02f, 7.17819855e-02f, 1.10732149e-02f, 5.82964830e-02f, -7.41710067e-02f, -4.42406163e-02f, 6.61260709e-02f, -1.69134350e-04f, 2.21067462e-02f,
  8.26428756e-02f, -9.09239501e-02f, 6.09418191e-02f, -6.82542101e-02f, 1.33468360e-01f, -2.62952745e-02f, 5.40341176e-02f, -6.20992668e-02f, 6.03464246e-02f, -8.30197409e-02f,
  9.33623835e-02f, 3.39849032e-02f, -7.83061087e-02f, -1.81210437e-03f, -3.73082906e-02f, 3.40061523e-02f, 3.58925648e-02f, -9.25292447e-02f, 1.29319942e-02f, -5.57372719e-02f,
  4.23611440e-02f, -5.36773205e-02f, 2.41643246e-02f, 3.47786285e-02f, -2.44436674e-02f, -5.70447242e-04f, 2.96281017e-02f, 3.16337799e-03f, 4.16835546e-02f, -3.76050151e-03f,
  -4.92882319e-02f, 3.70263159e-02f, 8.29833373e-02f, 2.25043017e-02f, 6.31683925e-03f, -2.44662538e-02f, 8.73804316e-02f, -3.53910066e-02f, 1.07554439e-02f, -1.35192508e-02f,
  -3.31844054e-02f, 4.87541370e-02f, -4.31724032e-03f, -8.09928551e-02f, 4.49713580e-02f, -5.18084615e-02f, 3.53210941e-02f, -2.81438027e-02f, 8.18598494e-02f, -4.10895944e-02f,
  4.84196804e-02f, 4.61658575e-02f, 5.21178432e-02f, 5.70461750e-02f, -7.66990259e-02f, -5.25869317e-02f, -9.21060145e-02f, -9.28041805e-03f, 4.77209799e-02f, -2.39609312e-02f,
  8.75373483e-02f, 4.55430821e-02f, -3.54603119e-02f, 1.00584459e-02f, 4.21145111e-02f, -4.22200747e-02f, -1.21794641e-02f, -1.17994919e-02f, 7.14461952e-02f, 1.12947379e-03f,
  5.84843531e-02f, 7.68426955e-02f, 1.76912416e-02f, -6.04296625e-02f, -3.50377820e-02f, -8.02700408e-03f, 6.39666617e-03f, -6.63534030e-02f, 6.27935156e-02f, 8.53316393e-03f,
  -2.29862873e-02f, 6.23769462e-02f, -4.73327003e-02f, 5.78220412e-02f, 1.89388841e-02f, -2.69809961e-02f, -5.37137873e-02f, 1.16615202e-02f, -3.45847718e-02f, 2.19517108e-02f,
  9.02883802e-03f, -1.17292508e-01f, 4.45800573e-02f, 2.53820062e-01f, -2.28621773e-02f, -1.21588849e-01f, -2.19546661e-01f, -7.68267885e-02f, -2.42646802e-02f, -2.77889639e-01f,
  -1.32905602e-01f, -1.45950252e-02f, -3.63133937e-01f, 2.60060877e-01f, 2.71915346e-01f, 1.24334851e-02f, 2.29952782e-01f, -2.37366091e-02f, 3.63219008e-02f, 1.87707916e-02f,
  1.66773662e-01f, 2.58938521e-01f, 2.14534402e-01f, 1.90378875e-01f, -2.95822858e-03f, 2.57042706e-01f, 2.28806168e-01f, -1.04681673e-02f, 3.19696158e-01f, 1.70558885e-01f,
  1.78480595e-02f, 1.80072838e-03f, -5.20178229e-02f, 9.99037325e-02f, -6.89670071e-02f, -1.29135121e-02f, 1.67939849e-02f, -3.18154283e-02f, 3.01633589e-02f, -2.32490487e-02f,
  -6.35783523e-02f, 5.24057113e-02f, 1.40979616e-02f, 8.93663242e-02f, 8.67704973e-02f, 4.81312349e-02f, -2.97729205e-02f, -6.64243028e-02f, 6.97863474e-02f, -1.10778756e-01f,
  -3.61698084e-02f, 2.44157179e-03f, 2.03035157e-02f, -8.56846746e-04f, 1.88485254e-02f, -8.96981452e-03f, -1.34682171e-02f, -6.04610592e-02f, 2.58709583e-02f, 8.78885761e-02f,
  3.78971137e-02f, -3.07356473e-03f, -8.45450982e-02f, -3.30234803e-02f, -1.74240116e-02f, -2.19422556e-03f, 7.85535350e-02f, 4.17090841e-02f, -3.50732841e-02f, -6.69079944e-02f,
  6.55136257e-02f, 5.93440384e-02f, 5.39848655e-02f, -6.97045922e-02f, -2.26407056e-03f, -2.35421732e-02f, -2.62086261e-02f, 1.61680151e-02f, 5.96365817e-02f, 2.43399069e-02f,
  3.52416113e-02f, -3.29652950e-02f, 2.06088014e-02f, -4.46942598e-02f, 1.53631717e-03f, 1.77160185e-03f, 7.16109872e-02f, -6.16610460e-02f, -2.90373974e-02f, 2.79447739e-03f,
  7.31853247e-02f, 7.97734186e-02f, -6.31641084e-03f, 2.95564048e-02f, -7.46287871e-03f, -6.59619570e-02f, 1.13608250e-02f, 1.14282295e-01f, 1.41041398e-01f, 1.70508511e-02f,
  -3.89335416e-02f, 3.79071236e-02f, 2.94534955e-02f, 6.99067637e-02f, 2.33665686e-02f, -6.49469644e-02f, -3.30987386e-02f, -7.25234509e-04f, 5.51307946e-02f, 5.03552295e-02f,
  2.45703496e-02f, -3.40852439e-02f, 5.76399602e-02f, 7.76347294e-02f, 5.85820451e-02f, 2.97037028e-02f, -6.84791477e-03f, -2.73187761e-03f, -5.34578674e-02f, 8.70236158e-02f,
  9.65854749e-02f, -1.24174863e-01f, -1.52056798e-01f, 1.88704561e-02f, -1.20491832e-01f, -1.47895832e-02f, -2.70085149e-02f, -6.25661835e-02f, -5.60240522e-02f, -1.95560767e-03f,
  -1.00738674e-01f, -2.49181259e-02f, 1.29945606e-01f, -1.28727332e-01f, 9.07975137e-02f, 1.45304322e-01f, -6.61715269e-02f, -5.29220589e-02f, -5.17317429e-02f, 6.25198036e-02f,
  -2.92265192e-02f, 4.05691080e-02f, -1.60008401e-01f, -9.80389491e-02f, -1.97536260e-01f, -1.36327952e-01f, 9.85961109e-02f, -9.83295441e-02f, -1.91411108e-01f, 2.92162094e-02f,
  -1.06385313e-01f, -1.51183922e-02f, -9.88313556e-02f, 7.11941067e-03f, -3.58865522e-02f, 7.35029727e-02f, -1.12670166e-02f, -2.59163380e-02f, 5.46887480e-02f, 1.31679233e-02f,
  -3.25028449e-02f, -1.15702860e-02f, 2.49931514e-02f, -2.39898711e-02f, -5.97178638e-02f, -4.13699262e-03f, -4.09208573e-02f, -1.51759265e-02f, 2.65878178e-02f, -4.51939106e-02f,
  -6.79493770e-02f, 2.17863228e-02f, -6.42146245e-02f, 4.21231128e-02f, -4.50016223e-02f, 5.25893718e-02f, -6.06118925e-02f, -3.24523821e-02f, 4.37265560e-02f, 9.34101045e-02f,
  3.93144600e-02f, 1.26050279e-01f, 3.25680263e-02f, -8.85225907e-02f, 5.45316227e-02f, 3.01751643e-02f, -5.35634793e-02f, 6.07456416e-02f, -5.92100285e-02f, 6.18122704e-02f,
  -2.55301315e-02f, -3.92890200e-02f, -1.03340801e-02f, 7.17196092e-02f, -3.73604298e-02f, -4.00689505e-02f, 3.76732647e-02f, 2.08795518e-02f, 2.82549160e-03f, 2.62117106e-02f,
  4.06112708e-02f, 9.23387334e-02f, 4.90371399e-02f, -9.50711370e-02f, 5.55218160e-02f, -6.68642744e-02f, 3.67408358e-02f, -4.11713645e-02f, -3.16318981e-02f, -1.61262825e-02f,
  -5.58940731e-02f, 1.84379578e-01f, 1.59060974e-02f, 6.05819970e-02f, 5.94525374e-02f, 1.60081834e-02f, 1.62193608e-02f, -2.53615417e-02f, -4.14579846e-02f, 2.85537560e-02f,
  8.85607377e-02f, 4.04652208e-02f, 2.59561483e-02f, -8.28794837e-02f, 2.44637560e-02f, 2.60853134e-02f, 3.49878371e-02f, 1.52493520e-02f, 5.81184663e-02f, 5.24390228e-02f,
  2.22891360e-03f, 1.03988849e-01f, 1.72966775e-02f, -2.08372697e-02f, -5.55790253e-02f, 9.17570964e-02f, -3.91076226e-03f, 4.01051529e-02f, 8.89435485e-02f, 1.09269112e-01f,
  -1.17664430e-02f, 1.23786166e-01f, 4.65802103e-02f, -8.03552344e-02f, -1.43762559e-01f, 1.43567324e-01f, -7.93975666e-02f, 1.15937218e-01f, 4.35020447e-01f, -7.26241171e-02f,
  -2.03683004e-01f, -7.25875273e-02f, 1.04569182e-01f, -1.40340090e-01f, 1.87225476e-01f, 2.64342546e-01f, 1.73424352e-02f, -2.23380998e-02f, 1.14550032e-01f, -1.11135580e-01f,
  3.05838010e-04f, -2.44437754e-01f, -2.66214967e-01f, -2.19671473e-01f, -3.95131946e-01f, -1.91115677e-01f, -1.64659366e-01f, -1.79464892e-01f, -2.55307764e-01f, -5.09497933e-02f,
  1.06969595e-01f, -1.98336877e-02f, -4.84448969e-02f, 5.25470600e-02f, -5.37835732e-02f, -6.54721931e-02f, -4.92033437e-02f, -7.81262293e-02f, -3.44726294e-02f, 1.67484991e-02f,
  -2.22763773e-02f, 8.30809027e-02f, 8.98784474e-02f, -5.67033626e-02f, -5.81527650e-02f, -9.13748634e-04f, 6.97613973e-03f, 3.04462519e-02f, 3.73375304e-02f, -6.21465966e-02f,
  -6.72947466e-02f, 2.33585984e-02f, -8.97721201e-02f, 9.04077366e-02f, -8.59429501e-03f, -6.15819693e-02f, -5.26813231e-03f, -3.76668088e-02f, -1.24702873e-02f, 6.88535422e-02f,
  -1.01114795e-01f, 3.45424525e-02f, -3.50717455e-02f, 7.84855932e-02f, -3.63390781e-02f, -3.78269926e-02f, -3.26007791e-02f, -1.91260595e-02f, 9.93844494e-02f, -5.23635447e-02f,
  9.86860394e-02f, -6.19102046e-02f, -2.19589677e-02f, -8.07965249e-02f, 3.24246325e-02f, 6.21173829e-02f, -1.14024738e-02f, 6.17318824e-02f, 6.57171309e-02f, 3.88016589e-02f,
  4.00000885e-02f, 9.82436687e-02f, -8.57262611e-02f, -2.23175231e-02f, 1.78197417e-02f, 2.68348735e-02f, -2.31093052e-03f, 7.89986625e-02f, -3.24446447e-02f, -8.56225118e-02f,
  1.42137855e-01f, 1.52214080e-01f, 1.13564637e-02f, -1.57729693e-04f, 4.52908687e-02f, -5.22021018e-02f, 7.89175704e-02f, -1.69564690e-02f, 9.75108147e-02f, 6.06687516e-02f,
  -1.37083128e-03f, 1.36648724e-02f, 4.82630953e-02f, -9.64733586e-02f, 5.68602942e-02f, 3.61963063e-02f, 3.79703270e-04f, 1.02645576e-01f, -4.73070554e-02f, -5.42726461e-03f,
  -7.80204311e-02f, 6.76943585e-02f, 1.04943126e-01f, -1.75442304e-02f, 1.05486745e-02f, -5.27662188e-02f, 9.56351534e-02f, 4.36298214e-02f, -3.66803333e-02f, 6.40632436e-02f,
  -5.36021888e-02f, 1.66216910e-01f, 1.41248569e-01f, 6.10480458e-02f, -9.10808071e-02f, 3.84319350e-02f, 1.41400814e-01f, -1.48085609e-01f, -3.55464704e-02f, -1.73741989e-02f,
  2.91224215e-02f, 2.55864859e-01f, 1.12055294e-01f, 2.13771835e-01f, -2.83396952e-02f, -4.68945205e-02f, 1.36433840e-02f, 1.92459434e-01f, -5.34432940e-02f, -1.46159837e-02f,
  -1.12678753e-02f, -2.33357381e-02f, 2.58508157e-02f, -1.06267199e-01f, 2.40352154e-02f, -8.16581994e-02f, -9.42740068e-02f, -5.56860911e-03f, -8.17826670e-03f, -8.52642674e-03f,
  -3.79694030e-02f, 3.13283838e-02f, 1.60185043e-02f, 1.86244491e-02f, -3.01743206e-02f, -5.10455817e-02f, 7.14300200e-02f, -3.96665186e-03f, -3.35555933e-02f, 7.33346418e-02f,
  -3.64207700e-02f, -1.48628941e-02f, -7.89922550e-02f, -6.66344762e-02f, 3.14584114e-02f, -5.72066866e-02f, 3.92878354e-02f, 4.38573025e-02f, 5.12338057e-02f, -4.02494855e-02f,
  8.35758075e-03f, 1.15677305e-02f, 5.48007840e-04f, 6.97122440e-02f, 5.10578528e-02f, 5.93587756e-02f, -8.63561593e-03f, 8.30439031e-02f, -3.16843092e-02f, 2.81162411e-02f,
  -1.29618272e-02f, -6.87512234e-02f, 5.23120873e-02f, -7.27326125e-02f, -5.09683304e-02f, 5.30966595e-02f, 2.58147297e-03f, -3.35318111e-02f, 1.08070662e-02f, -6.53714463e-02f,
  -8.56228098e-02f, 5.36438823e-02f, -2.77275965e-03f, 2.74638515e-02f, -5.06880730e-02f, 6.09070696e-02f, -4.78643477e-02f, 6.23785108e-02f, 2.22665891e-02f, 6.96969107e-02f,
  5.15460894e-02f, -2.13008840e-03f, 7.48705268e-02f, 6.43869713e-02f, 4.73409146e-02f, 2.43000016e-02f, -5.27387857e-02f, -4.02122848e-02f, -9.74313840e-02f, 6.28420711e-02f,
  -4.87152077e-02f, -2.44614985e-02f, 2.86377557e-02f, 2.88176462e-02f, -4.99073565e-02f, 1.15816966e-02f, -1.65941101e-02f, -9.01559740e-02f, 1.86439473e-02f, 7.69248679e-02f,
  -8.97953063e-02f, -2.31718328e-02f, -8.04572999e-02f, 1.00536533e-01f, 7.57378787e-02f, -6.24655820e-02f, 6.41725287e-02f, -3.49975144e-03f, -5.91983758e-02f, -2.10077018e-02f,
  8.83149728e-02f, 1.80683676e-02f, -2.99549829e-02f, 5.51125966e-02f, 4.35787216e-02f, 7.36132711e-02f, 5.53376637e-02f, -3.43319140e-02f, 3.26773003e-02f, 7.73724727e-03f,
  3.03126961e-01f, -1.66615054e-01f, -1.53078124e-01f, 3.16095576e-02f, -1.50225619e-02f, 7.97806960e-03f, 2.13876739e-01f, -9.78799537e-02f, 2.01462093e-03f, -1.27944499e-01f,
  8.97018053e-03f, -7.95011595e-02f, 4.65839468e-02f, 1.08511120e-01f, 1.80793181e-01f, 1.52274007e-02f, 1.35744931e-02f, 6.49847537e-02f, 9.96049214e-03f, 1.27852848e-02f,
  -6.08274229e-02f, 3.07800490e-02f, -1.01986118e-01f, -2.09348455e-01f, 8.75735730e-02f, -1.42267108e-01f, -4.12246324e-02f, 2.12597344e-02f, -5.26520908e-02f, -4.34959121e-02f,
  1.09529309e-01f, 7.17794374e-02f, 1.89317446e-02f, -3.41250710e-02f, 1.10864295e-02f, 9.73549336e-02f, 2.79992614e-02f, 1.19507490e-02f, 6.63233176e-02f, -9.65574477e-03f,
  6.75537065e-02f, -1.72094945e-02f, -1.01037823e-01f, -4.66263257e-02f, -3.85556817e-02f, -1.05532311e-01f, 2.53462270e-02f, 1.90103538e-02f, -8.39345381e-02f, -3.29020023e-02f,
  4.57591936e-02f, -3.95022444e-02f, 3.29316817e-02f, -3.88036184e-02f, -5.04826894e-03f, -5.30438907e-02f, 2.61836182e-02f, 3.33836377e-02f, -1.05300851e-01f, -4.77340817e-02f,
  -1.17556332e-02f, 7.32326880e-02f, 8.09345543e-02f, 3.34477425e-02f, -1.57419010e-03f, -6.36227056e-02f, -2.59431824e-02f, -1.45150190e-02f, 1.02182804e-02f, 4.88506444e-02f,
  4.98599894e-02f, 4.44754437e-02f, 1.26087554e-02f, -6.75642341e-02f, -9.30747110e-03f, 6.08649738e-02f, -2.70495676e-02f, -4.39325534e-02f, 2.43792292e-02f, -4.21252660e-02f,
  -6.70847157e-03f, -5.60092460e-03f, 1.20164482e-02f, 4.84966673e-02f, -1.77939553e-02f, 6.99097663e-02f, -3.22506353e-02f, -2.74178050e-02f, 1.39227826e-02f, 7.06285164e-02f,
  -3.61731350e-02f, -5.48216179e-02f, -7.40757510e-02f, -4.57158089e-02f, -9.49913487e-02f, -5.48517890e-02f, -6.02492988e-02f, 5.22706509e-02f, 4.47962247e-02f, 8.67394283e-02f,
  -4.39463258e-02f, -1.42771415e-02f, -6.68764040e-02f, -2.02053040e-02f, 1.17461532e-02f, 2.77443379e-02f, -7.40481690e-02f, -1.04006127e-01f, 1.40821682e-02f, 2.67655402e-02f,
  -5.26786596e-02f, -2.06777528e-02f, 8.32372978e-02f, -5.77343367e-02f, -4.26351503e-02f, -4.63106632e-02f, -4.55652364e-02f, -8.00086334e-02f, 2.57564499e-03f, -2.24819081e-03f,
  1.32274851e-01f, 1.34563938e-01f, 1.53642654e-01f, 1.61276475e-01f, -1.69672951e-01f, -6.85637742e-02f, -4.50934395e-02f, -7.27614462e-02f, -1.61072165e-02f, 6.18577078e-02f,
  -7.39736110e-02f, 2.06047013e-01f, -3.70666608e-02f, 2.06242874e-01f, -4.03368771e-02f, -1.18531786e-01f, 2.00633615e-01f, 7.58441463e-02f, -5.26542552e-02f, 1.10354967e-01f,
  -2.18513664e-02f, 6.19312488e-02f, 4.37723398e-02f, -2.22199000e-02f, 1.28293470e-01f, 2.09620953e-01f, 1.20163858e-01f, 2.03696964e-03f, 2.61760086e-01f, -7.80326054e-02f,
  -1.51439698e-03f, 1.51456697e-02f, 7.95890093e-02f, -8.14168230e-02f, 4.67850082e-02f, 8.03538263e-02f, -5.76991588e-02f, -1.17516168e-03f, 7.67399147e-02f, 3.77500579e-02f,
  7.00307786e-02f, 3.90343219e-02f, 4.93420027e-02f, -9.73505676e-02f, -2.49285847e-02f, 6.97696209e-02f, 1.10822245e-01f, 2.91994251e-02f, -1.63817629e-02f, 8.98720324e-02f,
  1.14539780e-01f, 1.09110028e-01f, 6.90131783e-02f, 8.47256463e-03f, 3.12578641e-02f, -3.87815293e-03f, 1.41588803e-02f, -2.63079326e-03f, 7.02501982e-02f, 1.11948714e-01f,
  9.02036354e-02f, -5.65277673e-02f, -5.54444157e-02f, 1.58615094e-02f, -6.23505050e-03f, 5.95615096e-02f, -4.60296497e-02f, 2.24500778e-04f, 7.71604537e-04f, -2.83320434e-02f,
  -1.22133819e-02f, -3.87342088e-02f, -8.41489211e-02f, 5.32545075e-02f, 1.06876343e-02f, -6.97153732e-02f, -3.36600170e-02f, 3.98084335e-02f, -4.63168956e-02f, -5.07954843e-02f,
  -5.98421581e-02f, -3.96292936e-03f, -5.15152477e-02f, 6.43884242e-02f, -9.37326401e-02f, -7.99379423e-02f, -5.29846884e-02f, 1.03704169e-01f, -6.95210099e-02f, 2.15330198e-02f,
  7.80716687e-02f, 1.44918069e-01f, -3.05631459e-02f, -8.62667859e-02f, 5.28164878e-02f, 1.93705074e-02f, -2.29872912e-02f, -6.15065591e-03f, 7.30063468e-02f, -1.76140331e-02f,
  4.84060459e-02f, -1.70797780e-02f, 9.21273604e-02f, -5.99616021e-03f, 8.63238499e-02f, -6.22678697e-02f, 2.10854188e-02f, 4.13951054e-02f, -6.32700995e-02f, 7.12334961e-02f,
  5.64242192e-02f, 5.61040416e-02f, -2.15633754e-02f, 4.13554199e-02f, -9.68968554e-04f, 2.93251500e-02f, -1.55078452e-02f, 8.28337744e-02f, 3.64148058e-02f, -1.37992762e-02f,
  9.92524698e-02f, -1.53585643e-01f, -1.78052127e-01f, -4.29812856e-02f, -3.31016406e-02f, -2.14747757e-01f, -2.25755543e-01f, -2.96901129e-02f, 7.50595704e-02f, 1.03593282e-02f,
  -1.02298737e-01f, -9.59107280e-02f, -6.69505098e-04f, -1.36999711e-01f, -4.08276767e-02f, 1.90099612e-01f, -1.02348201e-01f, -5.13703004e-02f, 1.19798295e-02f, -1.43715978e-01f,
  2.39108875e-02f, -1.92953408e-01f, -1.21181861e-01f, -1.11143023e-01f, -2.44133607e-01f, -6.89279512e-02f, 7.51284361e-02f, -1.33220121e-01f, -2.24426761e-01f, -7.08254427e-02f,
  -1.05340250e-01f, -3.87949031e-03f, -7.44405538e-02f, -2.45369934e-02f, 5.00988886e-02f, -5.97934052e-02f, -5.29403985e-02f, -6.63507581e-02f, -7.38771260e-02f, 2.17093583e-02f,
  6.70340881e-02f, -4.32060137e-02f, -6.47465233e-04f, 1.03391156e-01f, -8.71257558e-02f, 4.50303480e-02f, -3.46188284e-02f, -2.71071848e-02f, -4.49164696e-02f, -6.11558594e-02f,
  -5.89923039e-02f, -4.77491543e-02f, -7.24266320e-02f, 6.77863359e-02f, 2.75827460e-02f, -5.19305170e-02f, 2.78631598e-02f, -7.15645999e-02f, -4.24809903e-02f, -5.81853613e-02f,
  2.61441264e-02f, -1.70980487e-02f, 1.45300571e-02f, -5.73131479e-02f, -3.29222134e-03f, -5.82546480e-02f, -6.23373268e-03f, -1.94719527e-02f, -4.56057154e-02f, 4.09348905e-02f,
  2.14512125e-02f, -6.37126192e-02f, 8.50080326e-02f, 2.16798540e-02f, -3.60991433e-02f, 2.47684810e-02f, 1.21538760e-02f, -3.19019072e-02f, 7.17077851e-02f, 4.50644903e-02f,
  3.74815129e-02f, -7.82253668e-02f, -8.16333592e-02f, 7.82435015e-02f, -4.88899387e-02f, 2.89294180e-02f, -8.95799771e-02f, 1.46890664e-02f, 5.26506566e-02f, -3.64956520e-02f,
  -8.01032558e-02f, -5.50615266e-02f, -4.73257788e-02f, 5.70988618e-02f, -4.00448106e-02f, 6.47836253e-02f, 4.21378240e-02f, -1.99145768e-02f, 4.15552296e-02f, 2.64875814e-02f,
  -8.72391984e-02f, -4.19186316e-02f, -6.58677071e-02f, -2.33220663e-02f, 4.93956879e-02f, 2.90150587e-02f, 5.14913574e-02f, -3.18365432e-02f, 3.42758447e-02f, 9.88326967e-04f,
  -8.59979987e-02f, -4.96731289e-02f, 3.74576157e-05f, 9.52613577e-02f, -8.33157673e-02f, 7.69558847e-02f, -2.13301629e-02f, 6.86296821e-03f, 2.25273129e-02f, 7.79114589e-02f,
  7.57373497e-02f, 3.39748442e-01f, 1.08633809e-01f, 1.46306008e-01f, -1.04731649e-01f, -2.88106292e-01f, -2.15925634e-01f, -1.04264490e-01f, 9.30482447e-02f, 1.69112489e-01f,
  -1.47868797e-01f, 3.43988657e-01f, -1.03009522e-01f, -3.41153555e-02f, -3.27547282e-01f, -1.48632690e-01f, -1.41179428e-01f, 7.97500834e-03f, -3.76523566e-03f, -7.04516247e-02f,
  -7.07593337e-02f, -1.74991995e-01f, -3.02982088e-02f, -6.11572228e-02f, 1.04299404e-01f, 1.15269296e-01f, -8.80764276e-02f, -7.08830431e-02f, 1.00444213e-01f, -1.05703823e-01f,
  1.52014764e-02f, 1.26715094e-01f, 7.56973848e-02f, 1.39568254e-01f, -4.17558663e-02f, 1.21996775e-01f, 8.69819745e-02f, -3.41941118e-02f, -5.01728989e-02f, -5.37782311e-02f,
  1.05791159e-01f, 4.13539074e-02f, 4.33913171e-02f, 6.43929765e-02f, 5.85302673e-02f, 9.68189240e-02f, 8.87591466e-02f, 1.47398368e-01f, 1.55825481e-01f, 9.33242291e-02f,
  1.80599973e-01f, 4.56209183e-02f, 9.69090220e-03f, 5.90643324e-02f, -3.35264727e-02f, -2.08834950e-02f, 4.06654254e-02f, 1.85929853e-02f, 5.68592995e-02f, 7.72022530e-02f,
  7.77625442e-02f, -7.50403255e-02f, -1.52809480e-02f, 5.06812148e-02f, 3.68456878e-02f, 4.21105586e-02f, -5.18462285e-02f, -7.05607561e-03f, 4.31121737e-02f, 1.72246955e-02f,
  2.77854446e-02f, 1.01562321e-01f, -5.85322417e-02f, -2.73457505e-02f, 8.69083405e-02f, 7.99092427e-02f, -6.06147386e-02f, 1.47627722e-02f, -2.89948322e-02f, 4.00161333e-02f,
  7.98391253e-02f, -8.57256502e-02f, 3.84734571e-02f, -1.00354087e-02f, -9.95645300e-02f, 9.47467424e-03f, 4.55092937e-02f, 1.37573713e-02f, -2.60970294e-02f, -6.90755099e-02f,
  -7.13283941e-02f, -3.81333455e-02f, 2.45980155e-02f, 2.41317712e-02f, 8.02226588e-02f, -9.13941562e-02f, 4.89382744e-02f, 7.61851808e-03f, -4.18270938e-02f, 1.20455157e-02f,
  -1.31922951e-02f, -5.09468913e-02f, 2.48867609e-02f, -3.61434817e-02f, 2.71711661e-03f, -7.85004944e-02f, -9.34743360e-02f, 4.84119654e-02f, 6.27736822e-02f, 5.09948842e-02f,
  3.25582102e-02f, 2.11827294e-03f, 2.38377806e-02f, -5.70456237e-02f, 8.84036571e-02f, 8.90971351e-05f, -7.59729967e-02f, 1.28853112e-01f, 3.66989300e-02f, -2.30546314e-02f,
  -2.91655689e-01f, -3.70738730e-02f, -1.89729974e-01f, -1.39509393e-02f, -4.67138141e-02f, 1.20067462e-01f, -1.86916273e-02f, -1.48908287e-01f, -1.93857759e-01f, 2.69748986e-01f,
  1.01161823e-01f, -2.49559119e-01f, -3.10271122e-02f, -6.02424257e-02f, -3.02241325e-01f, -1.96618229e-01f, 6.52103201e-02f, -3.51809114e-02f, -1.09717220e-01f, -1.05094865e-01f,
  -4.86187227e-02f, -1.30255437e-02f, -2.30134837e-02f, 1.72652274e-01f, -1.50724081e-03f, 1.36964634e-01f, 1.72747836e-01f, -1.81325176e-03f, 8.65779221e-02f, -7.05724396e-03f,
  -7.15010539e-02f, -1.48767650e-01f, -8.63757357e-03f, 3.77704725e-02f, 9.12722349e-02f, 1.35573998e-01f, 3.99012305e-02f, -3.26223783e-02f, 3.50682698e-02f, -1.21182524e-01f,
  -4.87347767e-02f, 2.74807587e-02f, -2.84008477e-02f, -4.15002182e-02f, 4.35282756e-03f, -2.32599098e-02f, 3.38205099e-02f, -1.57311391e-02f, -8.76594242e-03f, -6.88409358e-02f,
  -7.42919669e-02f, 6.78948388e-02f, -3.00383866e-02f, 2.48834374e-03f, -9.62951258e-02f, 9.45850182e-03f, -4.34877444e-03f, 3.26578431e-02f, -8.80104955e-03f, -5.32717220e-02f,
  -6.30728602e-02f, 5.63870519e-02f, -7.79848620e-02f, 3.42098027e-02f, -5.19003570e-02f, 8.15007985e-02f, 5.14618754e-02f, -4.74524219e-03f, -6.75756996e-03f, 7.53252059e-02f,
  -6.11158460e-02f, -7.50033930e-02f, -4.72062305e-02f, -2.40804758e-02f, 3.33267404e-03f, 5.01902252e-02f, 3.91654335e-02f, -9.12011892e-04f, 5.52807488e-02f, -9.24122520e-04f,
  -1.54141672e-02f, 2.71897111e-02f, 8.88213515e-02f, -7.69429433e-04f, -1.16334759e-01f, 7.65254050e-02f, -2.17573307e-02f, 3.46726105e-02f, 2.52636280e-02f, -2.45738029e-02f,
  -4.19389717e-02f, -1.34622991e-01f, -6.87351376e-02f, -3.46336067e-02f, -4.67687286e-02f, -2.25748215e-02f, -2.77822800e-02f, -5.27432263e-02f, -8.59524310e-02f, -3.93245704e-02f,
  1.28573462e-01f, -3.22040147e-03f, -4.44771387e-02f, 4.74342033e-02f, -7.84338545e-03f, -5.38202701e-03f, 5.61790392e-02f, 1.03797145e-01f, -4.03824542e-03f, -5.46107516e-02f,
  9.41508338e-02f, 6.59833848e-03f, 6.30687326e-02f, -4.43474874e-02f, 1.14403330e-01f, 6.54019713e-02f, -1.66468602e-02f, -1.64752062e-02f, -6.56034751e-03f, 3.07320710e-02f,
  4.83879633e-03f, -3.07885315e-02f, -1.59510411e-03f, 2.15851769e-01f, 1.27030089e-01f, 3.79520692e-02f, 1.67575747e-01f, 2.11413786e-01f, 3.24527800e-01f, -1.19317867e-01f,
  -9.02351439e-02f, -1.10822909e-01f, -4.14156057e-02f, -9.44220275e-02f, 6.50353357e-02f, 7.21826851e-02f, 9.95960459e-02f, -3.13202962e-02f, 2.03177035e-01f, 7.72420689e-02f,
  1.10427044e-01f, -2.99588460e-02f, -1.24077849e-01f, -1.71156511e-01f, 4.08027060e-02f, -9.44168493e-02f, -1.57878131e-01f, 5.03243916e-02f, -1.21537298e-01f, -4.65113856e-02f,
  2.20045615e-02f, 5.63666821e-02f, -7.75913149e-02f, -7.79054686e-02f, -1.73119083e-02f, 7.39376172e-02f, 3.22386883e-02f, -1.46792969e-02f, 1.78122614e-02f, 4.74549830e-02f,
  -9.72158760e-02f, -6.08722530e-02f, -2.51671262e-02f, 7.75556192e-02f, -2.15728506e-02f, 4.59385104e-02f, 5.76199368e-02f, 4.49470207e-02f, 2.88340803e-02f, -5.40178455e-02f,
  -9.72715113e-03f, -3.44580002e-02f, -1.38057331e-02f, -4.68291454e-02f, -2.59683803e-02f, 4.74697445e-03f, -6.65419474e-02f, -1.09236464e-01f, -1.64006967e-02f, -2.93254592e-02f,
  6.23588972e-02f, 1.04297414e-01f, -2.98050437e-02f, -5.82129806e-02f, -9.98084843e-02f, 6.77366182e-02f, -8.84786174e-02f, 9.72059928e-03f, -6.60508350e-02f, -1.00328781e-01f,
  -8.61877277e-02f, 2.73712687e-02f, -3.79642732e-02f, 3.55271436e-02f, 1.16328426e-01f, 4.54870798e-02f, -7.08161667e-02f, -9.89071429e-02f, -2.28547715e-02f, 8.85317400e-02f,
  6.87903613e-02f, -3.24853063e-02f, 4.74192612e-02f, 4.64487970e-02f, -8.05152208e-02f, -4.53437716e-02f, 9.27830338e-02f, -8.19827467e-02f, 8.07899311e-02f, 1.36141116e-02f,
  -5.73526844e-02f, 2.40353346e-02f, 2.38703713e-02f, -5.03296293e-02f, 4.66247760e-02f, -2.60158330e-02f, 9.40682963e-02f, -8.51468667e-02f, 7.15113431e-02f, 8.62164348e-02f,
  -7.58047402e-02f, 3.99272814e-02f, -3.64082493e-02f, -6.93128491e-03f, 7.18434229e-02f, -3.46104205e-02f, 2.28288211e-02f, -6.76554814e-02f, 9.40813124e-02f, 7.34790564e-02f,
  -6.07340187e-02f, 9.08991173e-02f, -6.90298229e-02f, 2.39610802e-02f, 5.21395681e-03f, -5.16821444e-02f, -7.43191764e-02f, -7.98783675e-02f, -1.15287691e-01f, -1.71467867e-02f,
  -1.22248501e-01f, -1.28206849e-01f, 2.65669912e-01f, -2.48904929e-01f, 4.68990989e-02f, 3.29984188e-01f, 2.04927355e-01f, -4.89661731e-02f, -4.83601779e-01f, -1.97200000e-01f,
  -9.90233049e-02f, -2.13181302e-02f, 1.39411062e-01f, -1.00177668e-01f, 1.62062779e-01f, -4.44567390e-03f, 2.63613053e-02f, 4.37954701e-02f, -2.75595412e-02f, -8.43129903e-02f,
  6.60883710e-02f, -7.00737834e-02f, 2.57936388e-01f, 7.46309832e-02f, -5.61612993e-02f, -1.24372825e-01f, -7.89637119e-02f, 1.54022798e-01f, 1.14727085e-02f, 3.72455306e-02f,
  -9.95963886e-02f, -1.28013328e-01f, 6.89096050e-03f, 3.52876410e-02f, 1.01147577e-01f, 6.47961572e-02f, 9.27891806e-02f, 3.56982201e-02f, 4.19376120e-02f, 4.73759398e-02f,
  -4.70018424e-02f, 8.44415501e-02f, -6.65057525e-02f, -1.69368871e-02f, 1.80648006e-02f, -2.01374311e-02f, 1.01422723e-02f, -2.41853334e-02f, 3.45604285e-03f, 7.02848136e-02f,
  5.23369014e-02f, 1.28996044e-01f, 3.93840261e-02f, 3.20020355e-02f, -1.39782159e-02f, -7.27731064e-02f, 2.87198815e-02f, 5.61719702e-04f, 4.91766930e-02f, -6.00959770e-02f,
  1.77253056e-02f, 2.36524250e-02f, -3.18436325e-03f, -5.74343801e-02f, -1.00762412e-01f, 1.07914796e-02f, -4.46248129e-02f, -5.79185225e-02f, 7.23133758e-02f, 2.37159356e-02f,
  -1.04507983e-01f, 1.77270472e-02f, -1.32444045e-02f, 2.88826749e-02f, 2.60242075e-02f, 2.15122513e-02f, 4.04427052e-02f, 1.51090389e-02f, 1.50082661e-02f, 2.95262076e-02f,
  2.01878510e-02f, 5.69974370e-02f, 4.09090444e-02f, 5.32036982e-02f, 5.57970314e-04f, 5.37016876e-02f, 4.02289890e-02f, 9.10033938e-03f, -6.38148114e-02f, 5.80069385e-02f,
  -2.10243184e-02f, -2.06458941e-01f, -1.14583440e-01f, -5.41028678e-02f, -5.12728021e-02f, -8.32199492e-03f, 1.92246679e-02f, 7.19060795e-03f, 1.00427736e-02f, -3.64018790e-02f,
  6.47202693e-03f, -1.31570371e-02f, 3.94041613e-02f, -6.45760968e-02f, 1.80953871e-02f, -3.61076072e-02f, -1.17166284e-02f, -1.02103375e-01f, 4.01118323e-02f, 7.68218189e-02f,
  -2.68272292e-02f, -5.35249487e-02f, -3.77208889e-02f, -2.57013720e-02f, -1.96231846e-02f, 3.25550027e-02f, -5.03835343e-02f, 4.78720441e-02f, 1.53637156e-02f, 6.19503148e-02f,
  -1.16733879e-01f, 6.45325854e-02f, 1.32487519e-02f, 1.20352723e-01f, -3.20515893e-02f, 2.62344986e-01f, 2.95824409e-01f, -3.55063491e-02f, 1.19424254e-01f, -6.67086162e-04f,
  3.43324356e-02f, -5.72365848e-03f, -2.08946057e-02f, 2.14713842e-01f, 2.13088363e-01f, 1.52696565e-01f, 2.98827142e-01f, 2.18199581e-01f, -1.18083358e-02f, -6.53384021e-03f,
  -5.88429831e-02f, 1.08820237e-01f, 9.66499746e-02f, -1.70546696e-02f, 1.45822885e-02f, -6.37900382e-02f, -6.45657033e-02f, -7.36744851e-02f, -7.92478621e-02f, -1.01406509e-02f,
  -1.07361361e-01f, 6.17526518e-03f, -3.97080928e-02f, -7.65905231e-02f, -5.52185737e-02f, -9.92357954e-02f, 3.52506153e-02f, 2.97261812e-02f, -6.06835671e-02f, 6.33890182e-02f,
  -1.07907020e-01f, -6.55454211e-03f, -5.49889691e-02f, 8.38397965e-02f, -2.07198467e-02f, -8.62369835e-02f, -9.18519348e-02f, 3.21335271e-02f, -5.18634953e-02f, -9.81611535e-02f,
  5.73575776e-03f, -4.91349846e-02f, 2.37197746e-02f, 4.20618244e-02f, 3.45237404e-02f, -1.44049367e-02f, -2.78053451e-02f, -2.41923146e-02f, -4.39763628e-02f, 1.69921410e-03f,
  -1.26771964e-02f, 3.42639536e-02f, -7.16086291e-03f, 6.52588084e-02f, 3.46178785e-02f, 3.90249901e-02f, 1.62557624e-02f, -8.91575739e-02f, -6.54120669e-02f, -6.87987311e-03f,
  5.55249043e-02f, -7.16666728e-02f, -2.17524134e-02f, 5.23514859e-02f, -5.38610406e-02f, 3.35404500e-02f, 5.33355139e-02f, 1.15407621e-02f, 4.01824526e-02f, 2.89771310e-03f,
  6.88830242e-02f, -3.44493077e-03f, -4.73983260e-03f, -1.50166769e-02f, -4.73358631e-02f, -7.78117403e-02f, 1.09051857e-02f, 2.47171503e-02f, 4.53094691e-02f, -7.33046979e-02f,
  3.13932560e-02f, -5.95748574e-02f, -7.17375949e-02f, 1.23047838e-02f, -2.86988504e-02f, 7.09856860e-03f, 4.95779887e-02f, 5.42836562e-02f, -6.27819970e-02f, 1.67909060e-02f,
  -1.18565492e-01f, 3.72265168e-02f, -8.22680667e-02f, 1.31184971e-02f, 5.88609055e-02f, -7.89038558e-03f, 2.84468215e-02f, 3.95499840e-02f, -5.90146780e-02f, -5.08801267e-02f,
  -8.15105364e-02f, -7.82150701e-02f, 8.32459182e-02f, 2.75156908e-02f, -1.60517227e-02f, -6.66969642e-02f, -8.52686316e-02f, 1.03984252e-02f, -3.91904861e-02f, 3.81166190e-02f,
  3.08230013e-01f, -1.34139434e-01f, 2.39187896e-01f, 1.45623460e-01f, 7.70761669e-02f, 2.14704461e-02f, 1.56839535e-01f, -6.09622337e-02f, -6.65157363e-02f, -1.22921281e-01f,
  -1.06837869e-01f, 2.89912611e-01f, -2.58751549e-02f, 5.78637002e-03f, 1.06173074e-02f, -7.54975528e-02f, -3.14804427e-02f, -7.62662245e-03f, -4.47624475e-02f, -2.73851678e-02f,
  -4.61857095e-02f, -2.37504318e-01f, 1.31729629e-03f, -3.05283040e-01f, -3.28708775e-02f, 5.00005968e-02f, -5.14288759e-03f, 1.15011483e-01f, -1.15615092e-01f, 8.36080592e-03f,
  -6.12952597e-02f, -5.77423573e-02f, 3.25016007e-02f, -2.05990504e-02f, -2.32577864e-02f, -2.94012669e-02f, 1.05275832e-01f, 5.08737937e-02f, 4.92984802e-02f, -1.76179148e-02f,
  1.51710689e-01f, -2.99098864e-02f, -4.85176109e-02f, 1.75496042e-02f, -4.40021865e-02f, 2.29419395e-03f, 5.48550580e-03f, 9.49992836e-02f, 3.36194150e-02f, 7.16495067e-02f,
  1.26769006e-01f, -2.51075085e-02f, 5.12585416e-02f, 1.56086879e-02f, -6.28437623e-02f, -8.99907276e-02f, 5.69684133e-02f, 1.33852676e-01f, 1.71547849e-02f, 5.50390296e-02f,
  -8.41404945e-02f, 5.71292412e-06f, 7.61797354e-02f, 4.79335338e-02f, -7.41120195e-03f, 1.20298713e-02f, 8.09737518e-02f, 4.47048098e-02f, -2.90577821e-02f, -5.72208054e-02f,
  -4.91309911e-03f, 8.58283117e-02f, 6.58246502e-02f, -8.23980495e-02f, -3.99532765e-02f, -3.44235860e-02f, -5.20157553e-02f, 1.34058623e-02f, 5.99620827e-02f, -8.05939212e-02f,
  -1.03431791e-01f, 5.74103892e-02f, -3.76784732e-03f, -1.06509484e-03f, -6.97887987e-02f, 7.00126067e-02f, 1.12142954e-02f, 2.31607240e-02f, 2.05943920e-02f, 6.38667047e-02f,
  -8.18645284e-02f, -5.33978865e-02f, -6.39818683e-02f, 4.34286818e-02f, 2.74736211e-02f, 2.78689489e-02f, -2.72439960e-02f, -1.38704283e-02f, 5.06116077e-02f, 1.11581376e-02f,
  -4.09483984e-02f, 6.34081140e-02f, 2.40553599e-02f, 1.05482727e-01f, -1.86924413e-02f, -7.72579089e-02f, 3.47948298e-02f, -3.82658355e-02f, -8.11103061e-02f, -8.70358869e-02f,
  -1.98684968e-02f, -1.08988658e-02f, 8.85625705e-02f, 1.74114071e-02f, -7.80499876e-02f, -1.25804218e-02f, -7.41332769e-02f, -5.35874292e-02f, -6.20163716e-02f, -6.88903928e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.82009533e-01f, 1.04618952e-01f, 2.80449331e-01f, 2.93958545e-01f, 9.23160985e-02f, 9.81349405e-03f, -7.06089288e-03f, 1.38317972e-01f, 2.10495889e-01f, 1.45306513e-01f,
  7.24386498e-02f, 2.03906134e-01f, 7.58303031e-02f, 2.19912261e-01f, 2.84369230e-01f, 6.80312365e-02f, 1.72575518e-01f, 1.26182273e-01f, 1.22744165e-01f, 1.50676787e-01f,
  5.71418437e-04f, 5.45655638e-02f, 1.61050126e-01f, 1.40323386e-01f, 2.49167174e-01f, -1.85134932e-02f, 5.21850474e-02f, 1.06322050e-01f, 7.98477083e-02f, 1.23257808e-01f,
  3.33802924e-02f, 6.68782145e-02f, 1.38389528e-01f, 9.63474885e-02f, 1.94579452e-01f, 2.02374488e-01f, 9.20480210e-03f, 2.54706919e-01f, 2.44120643e-01f, 1.18106812e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  4.71653901e-02f, -1.01068981e-01f, 1.39958337e-01f, 1.53886899e-01f, -6.01326346e-01f, -1.69177353e-01f, -2.49009177e-01f, 1.59383625e-01f, -3.02560236e-02f, -1.73243374e-01f,
  2.22666129e-01f, -2.33749658e-01f, -7.81282410e-02f, 3.29557002e-01f, -3.88609320e-02f, 1.61471829e-01f, 3.77112210e-01f, 4.08729941e-01f, -4.82074261e-01f, 4.18547308e-03f,
  -4.35200036e-01f, 5.63103855e-01f, -3.11200351e-01f, -6.06784523e-01f, -9.97850224e-02f, -4.16313633e-02f, 1.51368994e-02f, -1.74302787e-01f, 6.10605367e-02f, -2.44435981e-01f,
  -1.36975050e-01f, -4.02138941e-02f, 4.50217217e-01f, 2.46322863e-02f, -1.54934034e-01f, -1.99118495e-01f, 2.61805683e-01f, -1.81143075e-01f, 6.13288581e-01f, 1.13653742e-01f,
  -6.60312176e-02f, -4.16082777e-02f, 7.15245530e-02f, 4.88247015e-02f, 6.99016675e-02f, 2.16534898e-01f, -2.59867102e-01f, -6.51934445e-02f, 3.72078806e-01f, -3.86047736e-02f,
  1.88457072e-01f, -8.78822058e-02f, -4.93209846e-02f, -1.08023770e-01f, 1.93392366e-01f, 7.98464566e-02f, -2.10352801e-02f, -3.53243351e-02f, -6.72783405e-02f, 2.95543283e-01f,
  -8.33991468e-02f, 2.24706959e-02f, 3.59594256e-01f, -1.99624225e-01f, -9.38513428e-02f, 2.72581816e-01f, 2.82688379e-01f, 7.35889981e-03f, -4.23269600e-01f, -4.20440696e-02f,
  1.37900254e-02f, -1.05415940e-01f, -4.70331281e-01f, 5.23438215e-01f, -2.71452993e-01f, -5.77524975e-02f, 4.61603642e-01f, 2.27401957e-01f, 3.40282209e-02f, -5.61436832e-01f,
  4.30299461e-01f, -7.45478645e-02f, -4.69569385e-01f, -4.41368222e-01f, 6.74019873e-01f, 1.94758028e-01f, 5.73007941e-01f, -5.51494956e-01f, -8.54563862e-02f, -3.97311896e-02f,
  -3.06505531e-01f, -2.90189236e-01f, -2.43968695e-01f, 5.06758280e-02f, -9.11834165e-02f, 2.39753388e-02f, 5.36868751e-01f, 8.73041898e-02f, -2.34050781e-01f, -1.61455702e-02f,
  2.13127568e-01f, -1.08606517e-01f, -4.11969543e-01f, 2.53726617e-02f, 4.24166292e-01f, 2.17908621e-01f, -2.54737195e-02f, 6.18618429e-01f, 6.30417317e-02f, 6.80067688e-02f,
  -2.37005249e-01f, 1.99850515e-01f, 3.72535944e-01f, -5.76387867e-02f, 6.64255619e-02f, -1.75924242e-01f, 6.35399818e-02f, -3.28155905e-01f, 4.46741022e-02f, 3.12294483e-01f,
  6.76979721e-02f, -7.84942061e-02f, -2.35258773e-01f, -1.89067245e-01f, -6.03168532e-02f, 1.78094395e-02f, 2.04591453e-01f, -5.51467910e-02f, -3.53631943e-01f, 9.51152015e-03f,
  -5.50691299e-02f, -2.77135253e-01f, 5.65164685e-02f, 3.36768217e-02f, -3.33279371e-02f, 1.53756067e-01f, 6.60729930e-02f, -1.19964564e-02f, -5.14247060e-01f, 1.20171390e-01f,
  2.82664001e-01f, 1.68541446e-01f, -3.46387744e-01f, -2.40755275e-01f, 7.42150918e-02f, -9.02423412e-02f, 2.24825755e-01f, -2.59696669e-03f, -4.23893742e-02f, -5.18926442e-01f,
  2.25870490e-01f, -3.55741620e-01f, 5.49372554e-01f, 6.16341718e-02f, -1.93586469e-01f, -2.61597157e-01f, -1.08921036e-01f, 8.86501297e-02f, 3.19085956e-01f, 1.74404174e-01f,
  -2.02232376e-01f, -2.69406497e-01f, 1.22623906e-01f, 1.85160190e-01f, -2.24168152e-01f, -6.08236603e-02f, -7.25945607e-02f, -4.69374992e-02f, 5.62679291e-01f, 3.06409478e-01f,
  -2.33800977e-01f, -6.89270422e-02f, -1.01968631e-01f, -6.65579289e-02f, 1.99095622e-01f, -1.03866510e-01f, 2.50003971e-02f, -7.16113746e-02f, -4.55248952e-02f, 6.52347982e-01f,
  -6.26982674e-02f, -8.56635347e-02f, -9.68522877e-02f, -7.18443394e-02f, 3.43542174e-02f, -9.31947231e-02f, -1.92114830e-01f, 2.00269312e-01f, -1.28913149e-01f, 8.79056305e-02f,
  1.64939985e-01f, -1.47708267e-01f, 4.39058356e-02f, -3.60206068e-01f, -4.71957177e-01f, 1.61199316e-01f, 2.25048333e-01f, -3.15218754e-02f, -3.88800539e-02f, 1.39898330e-01f,
  -8.73568803e-02f, -4.31749135e-01f, -6.95686698e-01f, 1.04541391e-01f, -4.22602624e-01f, -3.24264109e-01f, -4.79509443e-01f, 2.49880645e-02f, 7.98228309e-02f, -2.38058254e-01f,
  3.14214170e-01f, -9.52322409e-03f, -2.38644943e-01f, 3.29338968e-01f, -3.83880705e-01f, -2.77932525e-01f, -1.01852171e-01f, 3.58839594e-02f, 7.21394837e-01f, 4.74119335e-01f,
  2.86939055e-01f, 1.42530173e-01f, -1.25022575e-01f, -3.39668691e-02f, 4.41554300e-02f, -4.59807776e-02f, 1.61718428e-01f, 1.87721178e-01f, 2.53571160e-02f, -1.88733011e-01f,
  3.58682990e-01f, 3.16910088e-01f, -1.32821813e-01f, -1.31738305e-01f, -2.00694427e-01f, -1.40785828e-01f, -1.66015550e-01f, -2.79807183e-03f, -6.11146726e-02f, 1.13409478e-02f,
  -2.32823849e-01f, 2.08207414e-01f, -2.12666631e-01f, -1.44027054e-01f, -9.99980941e-02f, -2.35092670e-01f, -5.33226654e-02f, -3.60052660e-02f, -2.63641685e-01f, 3.54344137e-02f,
  1.58916503e-01f, 7.29387105e-02f, 2.54165772e-02f, -3.29552174e-01f, -1.54143497e-01f, -1.46963641e-01f, 1.29238237e-02f, 6.49648726e-01f, 4.28345591e-01f, -2.08853126e-01f,
  2.24669695e-01f, 1.63158789e-01f, 3.81764233e-01f, -1.97562948e-01f, 2.07003310e-01f, 4.58528191e-01f, 2.53470242e-01f, 3.23919415e-01f, -6.08658731e-01f, -2.14204267e-01f,
  7.92321563e-03f, 3.41668785e-01f, 2.06327513e-01f, -4.06651109e-01f, 1.30163684e-01f, 5.79769313e-01f, 5.62168211e-02f, 2.97348797e-01f, -2.44765475e-01f, 2.35590354e-01f,
  -2.38438517e-01f, 2.93774813e-01f, -4.36755046e-02f, 3.56626272e-01f, 4.89325702e-01f, -1.75292194e-01f, 1.43076763e-01f, -1.57503054e-01f, -3.81226599e-01f, 7.69833475e-02f,
  -1.03468046e-01f, 2.24278748e-01f, 1.84673816e-01f, -1.85801759e-01f, 6.03221416e-01f, 3.03698219e-02f, -1.36131914e-02f, -1.32293731e-01f, -3.10244650e-01f, 5.60277738e-02f,
  1.71323165e-01f, 4.45796177e-02f, -2.78863870e-03f, 1.10178337e-01f, -2.44950861e-01f, 9.29827914e-02f, 1.10434219e-01f, -1.15892045e-01f, -1.80119798e-01f, 2.35811099e-01f,
  -1.26790524e-01f, -1.68897748e-01f, -2.82538503e-01f, -1.61004037e-01f, -2.09570035e-01f, -5.58806732e-02f, 6.52183266e-03f, 5.59303582e-01f, 6.18000887e-02f, -1.41963199e-01f,
  1.83298782e-01f, 2.79549152e-01f, -7.46399015e-02f, 2.42244974e-01f, 9.87367332e-02f, 9.99619737e-02f, 3.79106700e-02f, 2.46631578e-01f, -3.22090238e-02f, 2.43020236e-01f,
  4.85158294e-01f, 3.27051878e-01f, 9.70149189e-02f, 1.58226520e-01f, 4.63027745e-01f, 4.72702175e-01f, 5.38280070e-01f, -2.74904341e-01f, -6.25413775e-01f, 3.39662246e-02f,
  4.82324690e-01f, -2.87754923e-01f, -3.14633161e-01f, 4.25244689e-01f, -4.37574834e-01f, -2.83210874e-01f, 8.79704580e-02f, -3.33438993e-01f, -1.87714875e-01f, 1.06366605e-01f,
  -1.31546766e-01f, -1.87489212e-01f, 1.55333683e-01f, 5.85234880e-01f, -2.09868297e-01f, -2.27208704e-01f, -5.33507802e-02f, -1.43760696e-01f, -3.37940931e-01f, -2.87857711e-01f,
  -2.07606211e-01f, 1.97628126e-01f, 1.46914616e-01f, -1.38116822e-01f, 3.28773931e-02f, -1.29384905e-01f, -1.09925650e-01f, -5.69655299e-02f, 3.83131862e-01f, -2.23367468e-01f,
  1.32652387e-01f, 9.41710994e-02f, 2.46358126e-01f, 5.89174688e-01f, 7.09812120e-02f, -2.62182895e-02f, 6.87614381e-02f, 1.00973221e-02f, -1.42386213e-01f, -2.73105741e-01f,
  3.62218291e-01f, -1.93110779e-01f, 2.97084183e-01f, -8.30977340e-04f, 2.91430920e-01f, -1.34710208e-01f, -8.95692259e-02f, 4.02292982e-02f, 2.85811145e-02f, 2.14677319e-01f,
  -6.42291531e-02f, 1.20972237e-02f, -2.41298527e-01f, -4.77826148e-01f, 2.81911492e-01f, -2.47059271e-01f, 3.87788624e-01f, -2.28521541e-01f, 3.59529436e-01f, 1.95527375e-02f,
  -5.14480770e-01f, -2.32157052e-01f, 3.59761983e-01f, 2.97913611e-01f, 5.42106450e-01f, -4.24933374e-01f, 1.00824133e-01f, 5.54905832e-01f, 8.19314182e-01f, -1.12960145e-01f,
  -2.55666286e-01f, -1.78677052e-01f, 1.05887912e-01f, -1.13356486e-01f, -1.24394119e-01f, -5.77750690e-02f, -7.11649284e-02f, -2.23283609e-03f, -1.06077909e-01f, -2.66016483e-01f,
  -2.06738889e-01f, 5.82167029e-01f, -1.46609604e-01f, 3.42455469e-02f, 1.25980079e-01f, -1.30565733e-01f, -1.59972057e-01f, -8.33847299e-02f, -5.19776829e-02f, -2.55180985e-01f,
  -1.55955210e-01f, -1.14746056e-01f, 2.38658234e-01f, 9.51725394e-02f, 2.98831630e-02f, -6.95991069e-02f, -3.31575349e-02f, 1.45492107e-01f, -1.30807564e-01f, 2.66610533e-01f,
  -2.07487047e-01f, 8.82363841e-02f, -1.44523680e-01f, -1.67002782e-01f, 4.78598922e-01f, -2.82213360e-01f, 1.01611711e-01f, 1.10848635e-01f, -2.76276886e-01f, -8.45746994e-02f,
  -1.05571873e-01f, -2.54954636e-01f, -3.02053392e-01f, 7.58324414e-02f, -4.31236885e-02f, 3.09412889e-02f, -2.47813225e-01f, -2.28587478e-01f, 1.33615628e-01f, -1.56164423e-01f,
  -2.20705435e-01f, 1.33600131e-01f, -2.20979407e-01f, 2.63728470e-01f, -3.73890728e-01f, 2.25031957e-01f, -3.24657947e-01f, 6.07948713e-02f, -3.40255231e-01f, 2.90555179e-01f,
  -3.48650515e-02f, 2.98176557e-01f, -1.43027231e-01f, -6.85939863e-02f, 3.61687273e-01f, -1.54880052e-02f, 2.74003074e-02f, 2.07419172e-01f, -7.53592104e-02f, -3.49814706e-02f,
  -2.41957486e-01f, -6.08250313e-02f, -6.38589486e-02f, 8.20602328e-02f, -1.62802547e-01f, -2.98013002e-01f, 1.29835486e-01f, -1.04200520e-01f, -1.21011145e-01f, -5.18789887e-02f,
  3.03882539e-01f, -1.23960987e-01f, -2.38576699e-02f, -1.59312084e-01f, 3.86246234e-01f, 5.28407931e-01f, -8.05488303e-02f, -3.54016386e-02f, -1.87206060e-01f, 6.77881092e-02f,
  2.88489670e-01f, 4.97315884e-01f, -1.64453670e-01f, 3.41547132e-02f, -1.40573353e-01f, 5.65454781e-01f, 9.50239077e-02f, -7.90610313e-02f, -5.54264449e-02f, -1.20543972e-01f,
  -3.17260414e-01f, 6.67643920e-02f, -2.94809006e-02f, -1.73354656e-01f, -3.97105180e-02f, -2.53106773e-01f, -1.17406048e-01f, -7.39101917e-02f, -1.28492966e-01f, -6.08920455e-02f,
  1.22221515e-01f, -1.77192420e-01f, 1.60030410e-01f, -1.96560565e-02f, 2.51396060e-01f, -4.53810662e-01f, 1.52577609e-02f, -3.33742082e-01f, -1.16279610e-01f, 2.60358244e-01f,
  -2.54800856e-01f, -3.60557020e-01f, -3.13761830e-01f, -4.85765606e-01f, 4.88620847e-02f, -3.56749110e-02f, -2.18157232e-01f, -1.70183122e-01f, -1.66323200e-01f, -1.40068546e-01f,
  -1.23282075e-01f, 2.18538195e-01f, -4.77321222e-02f, 2.49644890e-01f, -2.61462301e-01f, 2.64582187e-02f, -6.74444214e-02f, 4.21149330e-03f, 9.33750272e-01f, -3.39472666e-02f,
  -1.47223651e-01f, -2.27458845e-03f, -2.60166943e-01f, -1.31792769e-01f, -8.64902437e-02f, -1.47342235e-01f, -6.44968227e-02f, -9.35207084e-02f, 3.73813689e-01f, -9.42743644e-02f,
  -2.74730980e-01f, 3.86383086e-02f, -4.63155285e-02f, 4.65267777e-01f, 7.94500262e-02f, -1.85697496e-01f, -2.18759608e-02f, -1.15794040e-01f, 3.71778756e-01f, -1.20610639e-01f,
  -9.86757502e-03f, -2.25993305e-01f, 4.17312272e-02f, -2.46517491e-02f, 3.48135866e-02f, -1.88219585e-02f, 1.94544137e-01f, -3.23216766e-01f, -1.88143864e-01f, 2.76110023e-01f,
  2.23230258e-01f, -2.93229848e-01f, 2.15322822e-01f, -3.89144719e-01f, 1.70065999e-01f, 2.21109644e-01f, -2.57251859e-02f, -1.98179096e-01f, -5.71421683e-01f, 6.11239970e-01f,
  4.64407116e-01f, 6.79275617e-02f, -1.66693091e-01f, 7.47536719e-01f, 2.05865428e-01f, 3.79626751e-01f, -3.05154800e-01f, -4.03378814e-01f, 5.85354209e-01f, 4.97230530e-01f,
  1.89341530e-01f, 2.41347328e-01f, -2.16937467e-01f, -9.09205060e-03f, -1.33841515e-01f, -2.09064409e-02f, -3.00536938e-02f, 2.66139328e-01f, -1.54046133e-01f, -2.33792499e-01f,
  4.68823202e-02f, -2.49174386e-01f, -2.48571441e-01f, 3.49504575e-02f, 1.96615741e-01f, -2.81268954e-02f, -2.84353085e-02f, -1.40843153e-01f, 1.96649939e-01f, -1.89226404e-01f,
  1.80359364e-01f, 1.51220754e-01f, -1.25132233e-01f, -1.71671197e-01f, -2.30986342e-01f, -1.77084669e-01f, 2.34665662e-01f, -1.84811607e-01f, 1.35006592e-01f, -2.21359208e-01f,
  1.72586188e-01f, 3.14991146e-01f, -1.22381538e-01f, -6.07563965e-02f, -2.42960662e-01f, -1.37046993e-01f, 3.00978534e-02f, 4.67965782e-01f, 1.78111553e-01f, 4.45338845e-01f,
  2.41792530e-01f, -1.82618394e-01f, -1.46022350e-01f, 1.85778782e-01f, 1.09351933e-01f, 6.29511848e-02f, -3.22553925e-02f, 1.66163400e-01f, 3.29561174e-01f, 6.27679229e-02f,
  3.34416628e-01f, -2.65992228e-02f, 2.01901734e-01f, -4.79660213e-01f, -4.19427872e-01f, -3.04648519e-01f, -4.29216594e-01f, -2.71706641e-01f, 5.48050761e-01f, -4.41729963e-01f,
  1.03526764e-01f, 6.70475483e-01f, -3.45402539e-01f, -5.81780970e-01f, -2.71355808e-01f, 1.93613574e-01f, -4.75705057e-01f, 2.74097741e-01f, -1.96941927e-01f, 1.22374907e-01f,
  3.19693573e-02f, 1.98980913e-01f, 3.10623765e-01f, 1.91270083e-01f, 4.39661145e-02f, 1.56185851e-01f, -2.47865900e-01f, 7.36871734e-02f, -3.22450131e-01f, 3.20783794e-01f,
  -1.45489722e-01f, 7.48471394e-02f, -1.56955291e-02f, 3.77166659e-01f, -1.92120448e-01f, 3.94087106e-01f, 1.78566769e-01f, -2.37122342e-01f, -2.65878409e-01f, 1.02440238e-01f,
  9.57665592e-02f, -3.14342737e-01f, 1.21980421e-01f, -2.54538745e-01f, -2.73432106e-01f, -9.71279293e-02f, -3.23864818e-02f, 3.86855751e-02f, -3.49564590e-02f, 4.94109899e-01f,
  -3.71063724e-02f, 9.29801539e-02f, -3.45672399e-01f, -7.53917545e-02f, 2.97498424e-02f, 1.83358163e-01f, 2.81852126e-01f, -1.67738393e-01f, 2.44360223e-01f, 2.58739013e-02f,
  4.02818844e-02f, -1.21029802e-02f, 1.87067330e-01f, 8.42238814e-02f, 1.88431772e-03f, 1.86300233e-01f, 3.90416771e-01f, -3.34337175e-01f, 1.36371151e-01f, 5.41949630e-01f,
  -7.21800476e-02f, -2.59826243e-01f, 4.54483300e-01f, -4.33572888e-01f, -4.06921729e-02f, -6.53999865e-01f, -6.30105913e-01f, 2.79695392e-01f, -1.31908998e-01f, 9.95991658e-03f,
  4.24651325e-01f, 6.39940351e-02f, -2.70479262e-01f, -3.25230658e-02f, -1.73108742e-01f, 7.99848288e-02f, -2.14371145e-01f, 1.18869267e-01f, 1.53563783e-01f, -1.99879799e-02f,
  -2.18143180e-01f, -1.70738831e-01f, -3.61331105e-01f, -1.70963600e-01f, -2.56715834e-01f, -9.27690119e-02f, 1.40199557e-01f, 9.41135082e-03f, 2.49627262e-01f, -7.24997222e-02f,
  -2.48009622e-01f, -2.02885106e-01f, -3.14468950e-01f, 9.25515369e-02f, -1.57253951e-01f, -1.46546125e-01f, -3.24255466e-01f, -1.83832616e-01f, 2.46735752e-01f, -6.44297823e-02f,
  3.10783654e-01f, -1.96089089e-01f, 7.36009419e-01f, -4.99183200e-02f, -1.42025933e-01f, -1.47985853e-02f, -1.42566144e-01f, 3.89180452e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.04778856e-01f, 8.66920725e-02f, -1.50371522e-01f, -1.27392650e-01f, 3.33634689e-02f, 1.74566597e-01f, 1.17239527e-01f, -1.02423228e-01f, -3.48922871e-02f, 1.53513789e-01f,
  1.86961778e-02f, 1.22695580e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    