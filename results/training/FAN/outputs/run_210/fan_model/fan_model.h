/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.55394590e-01f, -1.05804861e-01f, 3.51670235e-02f, -3.29379469e-01f, -9.75795090e-02f, -6.50520325e-02f, 3.73885743e-02f, -1.64713040e-01f, 4.56301682e-02f, -6.07981393e-03f,
  3.32547985e-02f, -6.61327988e-02f, 2.32195601e-01f, -6.75593913e-02f, 2.35068679e-01f, 3.59053075e-01f, -9.81076211e-02f, -6.43209070e-02f, 1.43945262e-01f, -2.60689437e-01f,
  -4.40960005e-02f, -9.55417287e-03f, 5.90061247e-02f, -6.37505576e-02f, -1.95726201e-01f, -1.66254431e-01f, -2.41852216e-02f, 5.75555163e-03f, -1.64578691e-01f, 7.77987167e-02f,
  8.15395266e-02f, -1.01924658e-01f, -4.41064984e-02f, 1.75249837e-02f, -7.22703338e-02f, -1.92883555e-02f, -1.02581866e-01f, 1.15776025e-01f, -5.63585991e-03f, -1.03087667e-02f,
  -1.59080848e-02f, -9.41299368e-03f, 1.68545195e-03f, 2.40124259e-02f, -3.03892195e-02f, 3.28302160e-02f, 6.19525881e-03f, 9.58184153e-03f, 1.69922858e-02f, 2.07745237e-03f,
  5.44160716e-02f, -3.01219933e-02f, -7.67812580e-02f, 2.18132157e-02f, 1.91811807e-02f, 2.00261474e-02f, 8.77525471e-03f, -3.48793641e-02f, -5.58895655e-02f, -7.51198530e-02f,
  6.64791837e-02f, 5.86768501e-02f, 6.16772473e-02f, 2.90109776e-02f, 4.30327393e-02f, -1.06793838e-02f, -5.54142240e-03f, 5.40039316e-02f, 1.31774263e-03f, -2.77818856e-03f,
  -5.71064427e-02f, -4.97824550e-02f, -2.99138408e-02f, 9.89753846e-03f, 3.52527667e-03f, -2.91955434e-02f, 2.33178716e-02f, -3.72180790e-02f, -7.51681207e-03f, 1.14337839e-02f,
  -3.56730260e-02f, -4.13417304e-03f, -3.29559785e-03f, -1.03658382e-02f, 1.35007752e-02f, 1.34636601e-02f, 1.09485732e-02f, -3.97771820e-02f, 1.93216261e-02f, -4.42644907e-03f,
  -2.78449446e-01f, -2.78051347e-01f, 7.05644265e-02f, 4.28919792e-02f, 5.26257753e-02f, 2.66800006e-03f, 4.26810756e-02f, -8.85191187e-02f, 6.69015422e-02f, 1.67317651e-02f,
  6.29545981e-03f, -7.27943778e-02f, -6.02545664e-02f, 7.38934241e-03f, 2.44196411e-02f, -3.74803459e-03f, -2.17148401e-02f, -1.18664093e-03f, -7.05324933e-02f, -2.79136449e-02f,
  -3.34004425e-02f, 2.12829951e-02f, 8.02849084e-02f, -4.60391715e-02f, -4.55098636e-02f, -4.28095274e-02f, -7.56615773e-02f, 5.83830364e-02f, 1.09979920e-02f, 5.23602962e-02f,
  1.22180566e-01f, -1.81288257e-01f, -2.55375654e-01f, -2.32672002e-02f, 3.81272227e-01f, 1.76556662e-01f, -1.32622600e-01f, 2.07243606e-01f, -8.73683095e-02f, 3.12171858e-02f,
  2.20377624e-01f, -4.14924085e-01f, -1.20522954e-01f, 1.01300940e-01f, -1.69469208e-01f, -1.37235910e-01f, 2.22604815e-02f, 4.48257709e-03f, 1.29572325e-03f, 8.99175480e-02f,
  1.29270917e-02f, 2.84623146e-01f, -3.74385193e-02f, 2.23630175e-01f, 1.53642505e-01f, 5.63107431e-02f, 2.23755121e-01f, -8.47337171e-02f, 1.11199662e-01f, -5.29595762e-02f,
  1.50945306e-01f, 4.11090888e-02f, -8.25444311e-02f, -2.04528067e-02f, 1.30111545e-01f, 4.24412079e-02f, -3.80064100e-02f, -5.37760332e-02f, 2.89054774e-02f, -3.19054201e-02f,
  -7.82242417e-02f, 1.99682526e-02f, 2.98246997e-03f, 8.98760464e-03f, 2.16021687e-02f, -1.21667571e-02f, -1.50484778e-02f, 1.19986549e-01f, -3.67072634e-02f, -1.33815175e-02f,
  -4.09382582e-02f, -2.07787729e-03f, -3.47710364e-02f, -2.87571978e-02f, 5.74023987e-04f, -1.71491168e-02f, -2.18188576e-02f, -4.98012416e-02f, -5.56165092e-02f, 4.14484441e-02f,
  -4.94461879e-03f, -1.14025557e-02f, -1.14382505e-02f, 1.24592585e-02f, 4.00874875e-02f, 4.34839986e-02f, -4.41478267e-02f, 2.18713414e-02f, -1.59674734e-02f, -1.47260400e-03f,
  5.98685816e-02f, -2.77983788e-02f, -4.26038988e-02f, -7.82639440e-03f, 2.14765165e-02f, -3.19510628e-03f, -1.92057434e-02f, -5.56633295e-03f, 5.00327870e-02f, 3.59522142e-02f,
  -2.70764660e-02f, -1.49870161e-02f, 3.39224264e-02f, 3.54566947e-02f, -3.96223664e-02f, -1.99323986e-02f, 1.13214040e-02f, -2.51799356e-02f, -7.25891488e-03f, 2.12979899e-03f,
  5.83449304e-02f, -1.64179370e-01f, 7.58182108e-02f, 3.75239812e-02f, -5.50187901e-02f, -2.89374590e-02f, -6.66102991e-02f, -2.86352858e-02f, -3.37580517e-02f, 2.66008731e-02f,
  7.75228143e-02f, -1.60342660e-02f, -4.56619784e-02f, 9.44024697e-03f, -1.24277370e-02f, 4.81577180e-02f, -1.95738021e-02f, 7.07521942e-03f, 2.82346047e-02f, 3.48212756e-02f,
  4.17174213e-02f, 4.13313555e-03f, 3.05257775e-02f, 1.15522586e-01f, 5.31705059e-02f, 4.43630293e-03f, 2.57703122e-02f, -1.01988744e-02f, -1.73952652e-03f, -5.17258011e-02f,
  -6.20948263e-02f, 2.24989519e-01f, -2.45550692e-01f, 7.40402266e-02f, -1.06392570e-01f, -7.29796439e-02f, 1.41433239e-01f, -3.18756327e-02f, -1.08530022e-01f, 3.54295403e-01f,
  6.01375103e-02f, 1.72238294e-02f, 1.82746783e-01f, 8.09237659e-02f, -3.18454295e-01f, 9.81536284e-02f, 1.15232140e-01f, 2.20780149e-01f, -8.65605474e-02f, 1.03942081e-01f,
  -1.67362437e-01f, 2.50228137e-01f, -1.56714112e-01f, 4.94149840e-03f, -9.16015133e-02f, -3.43914293e-02f, 1.08901411e-01f, -2.26120101e-04f, 6.45974651e-02f, -9.68256220e-03f,
  2.80574840e-02f, 1.19338343e-02f, -3.28698121e-02f, 1.52140073e-02f, -3.69589515e-02f, 1.26293488e-02f, 6.04910916e-03f, -8.54698196e-03f, -1.23074278e-01f, 8.27890858e-02f,
  5.66764399e-02f, -1.02023194e-02f, -2.25596484e-02f, 3.05362381e-02f, 5.29629886e-02f, -5.84034855e-03f, -7.18278289e-02f, -7.46798217e-02f, 1.63184050e-02f, -1.15589194e-01f,
  -5.07203974e-02f, -2.09241267e-02f, -6.76119979e-03f, 6.20216243e-02f, -9.49442759e-02f, -1.58856008e-02f, 8.35564267e-03f, -2.79620308e-02f, 4.96712737e-02f, -2.54756771e-02f,
  -2.08158046e-02f, 8.89325235e-03f, 1.31908506e-02f, 2.39837635e-02f, -7.03614729e-04f, 8.25855313e-05f, 5.97840287e-02f, 6.27384037e-02f, -1.06704067e-02f, 4.79215942e-02f,
  -2.89515033e-02f, 3.15796882e-02f, -1.29828770e-02f, 3.01132612e-02f, 5.49912900e-02f, 3.05076167e-02f, -4.73326450e-04f, 1.18043505e-01f, -3.43039520e-02f, -1.78204793e-02f,
  1.01984881e-01f, 3.32825556e-02f, 2.53241938e-02f, 3.65302525e-02f, 1.95634253e-02f, -4.77024820e-03f, 2.71742269e-02f, 3.18715423e-02f, 1.90774761e-02f, -2.42484398e-02f,
  4.10072267e-01f, 3.93858284e-01f, 3.36775258e-02f, 4.89308266e-03f, 7.45486543e-02f, -9.84620489e-03f, 4.11499888e-02f, -2.34454907e-02f, 9.75004658e-02f, -1.36505039e-02f,
  -3.62675600e-02f, 4.88131680e-02f, 1.99849866e-02f, 9.48241819e-03f, -4.78361063e-02f, 6.78751094e-04f, 1.09613478e-01f, 8.14614147e-02f, 3.28054801e-02f, 5.97963706e-02f,
  7.04933032e-02f, 6.79928511e-02f, -9.25813764e-02f, 5.24243398e-04f, 4.51208018e-02f, 1.54925631e-02f, -1.83823705e-02f, -1.61909778e-02f, 1.51121868e-02f, 2.37246156e-02f,
  -1.19654767e-01f, 1.70279652e-01f, -9.02371109e-02f, -1.47524729e-01f, 4.01215963e-02f, -2.48391375e-01f, -3.80182892e-01f, -1.18611157e-02f, 1.79460451e-01f, -2.99922787e-02f,
  -3.05408329e-01f, 3.55190486e-02f, -1.47307679e-01f, -2.53439635e-01f, -2.42046475e-01f, -1.89847834e-02f, -2.46078327e-01f, 2.31206436e-02f, 1.45024687e-01f, -5.16899601e-02f,
  1.04726385e-02f, -1.44718543e-01f, -2.32182994e-01f, 5.20323999e-02f, -7.51351342e-02f, 6.98359758e-02f, -1.20521024e-01f, -3.97033282e-02f, -3.99202034e-02f, -6.40857965e-02f,
  -1.22850507e-01f, 1.51094168e-01f, -1.21711232e-02f, 2.47057863e-02f, -8.17211717e-02f, -7.21279532e-02f, -2.50262432e-02f, -4.89918180e-02f, 5.93126053e-03f, -4.20416296e-02f,
  1.19942159e-03f, 2.28020661e-02f, 6.89835623e-02f, 4.38516214e-02f, 3.66687961e-02f, 2.65323557e-02f, 6.55045360e-02f, 1.13947671e-02f, -1.82301691e-03f, -1.84804890e-02f,
  -7.09388405e-02f, 2.05224361e-02f, -2.40927264e-02f, 1.01691531e-02f, 4.61986661e-03f, -4.37861383e-02f, -5.06539568e-02f, 1.71006366e-03f, 7.19399471e-03f, 3.71709242e-02f,
  6.33844584e-02f, 1.59042664e-02f, -4.60512703e-03f, -4.39736471e-02f, 4.89318138e-03f, -2.90389508e-02f, -1.14789745e-02f, 1.52755082e-02f, 6.14129230e-02f, -1.78379402e-03f,
  5.88340219e-03f, 2.97693107e-02f, -2.13385876e-02f, -1.09522240e-02f, 5.03729917e-02f, -2.75832210e-02f, 6.81310566e-03f, 5.87055553e-03f, 1.54474685e-02f, -4.67923693e-02f,
  -3.30104493e-02f, 4.06900458e-02f, 1.18730089e-03f, -2.46440410e-03f, -5.61457984e-02f, -2.71368008e-02f, -1.08742379e-02f, 2.58887671e-02f, -7.15530198e-03f, -7.40172192e-02f,
  5.66482060e-02f, 3.57297733e-02f, -5.09411171e-02f, 2.39011385e-02f, 1.99325234e-02f, 6.21145871e-03f, -1.45119596e-02f, 3.90327834e-02f, 3.25093083e-02f, -1.70309395e-02f,
  7.80348154e-03f, -4.84596677e-02f, 4.17463817e-02f, 9.30114929e-03f, -1.97253358e-02f, -6.19534291e-02f, -1.40698079e-03f, 3.10519245e-03f, -6.08825088e-02f, 1.98336504e-03f,
  1.80926844e-02f, 1.27060851e-02f, 1.16176084e-02f, 5.59830256e-02f, -1.95953622e-03f, -1.70421135e-02f, 5.21608330e-02f, 5.09775169e-02f, -3.05659026e-02f, 1.34977503e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.33997977e-01f, -1.88359290e-01f, -5.50162382e-02f, 1.87169865e-01f, 3.08240429e-02f, -1.90163091e-01f, -4.71162319e-01f, -3.10498644e-02f, -2.22616151e-01f, -3.78934711e-01f,
  -1.78529054e-01f, -1.31630823e-02f, -3.17390263e-01f, 2.32060224e-01f, 3.12033236e-01f, -5.23470528e-02f, 1.51086807e-01f, 2.56374162e-02f, 1.66084647e-01f, 1.16688404e-02f,
  2.57174402e-01f, 3.35661948e-01f, 3.46267581e-01f, 3.10813040e-01f, 8.71393085e-02f, 2.13185146e-01f, 2.28111729e-01f, 1.07226193e-01f, 3.00111234e-01f, 2.45701596e-01f,
  -1.03120171e-01f, -1.29224598e-01f, -6.96322173e-02f, 2.12922157e-03f, -6.61789924e-02f, -1.39105529e-01f, -6.80040345e-02f, 3.86369713e-02f, 8.61766636e-02f, 3.90576422e-02f,
  -5.48909344e-02f, 5.40345088e-02f, 1.35577604e-01f, 1.03334635e-01f, -4.09489200e-02f, 3.56095508e-02f, 3.20458114e-02f, -1.33344047e-02f, 4.51302752e-02f, -1.04209550e-01f,
  -1.64373945e-02f, 5.60991168e-02f, 3.82634066e-02f, -3.58144380e-02f, -2.57947054e-02f, -1.23682871e-01f, 1.86358299e-02f, -1.68972444e-02f, -1.85092185e-02f, -2.73244013e-03f,
  -7.43836537e-02f, -7.78875425e-02f, 3.12585086e-02f, 4.06778716e-02f, -4.54366431e-02f, -2.57580224e-02f, 8.40944052e-02f, -5.90582117e-02f, 8.51005130e-03f, -8.13311040e-02f,
  -3.82456519e-02f, 3.45210470e-02f, -1.69472247e-02f, -9.17810649e-02f, 7.46921683e-03f, -3.60900499e-02f, 1.02327660e-01f, 3.18476148e-02f, -3.88991199e-02f, -2.12132074e-02f,
  -8.52300376e-02f, 2.99663190e-02f, -2.59072911e-02f, 5.04522249e-02f, -4.22083661e-02f, -8.87606740e-02f, -3.18490341e-02f, -4.18160111e-02f, 3.55672725e-02f, 4.69624028e-02f,
  -1.68204024e-01f, -3.00877262e-02f, -1.09817134e-02f, -6.08753879e-03f, 1.47628237e-03f, 3.20155509e-02f, 4.27553430e-02f, -3.67383473e-02f, -1.09972004e-02f, 2.11507026e-02f,
  -3.37671749e-02f, 4.74457107e-02f, -1.18248612e-01f, 3.62114161e-02f, 5.15954383e-02f, -9.95484963e-02f, 6.35832027e-02f, 9.51984525e-03f, 5.47029227e-02f, 1.01359107e-01f,
  8.78121591e-06f, -6.23422712e-02f, 1.24408733e-02f, 1.01342291e-01f, -6.24863543e-02f, -1.65994447e-02f, 5.52746356e-02f, -4.12547104e-02f, 8.32653940e-02f, -7.18204724e-03f,
  6.56229258e-01f, 2.58365031e-02f, -1.80448055e-01f, 1.90301687e-01f, 7.52225071e-02f, 4.46825802e-01f, 2.83706188e-01f, 2.87354141e-01f, 5.13881266e-01f, 4.78305444e-02f,
  -3.42047550e-02f, 1.22667365e-01f, -1.94216266e-01f, 1.88421160e-01f, 2.37562001e-01f, 8.72000903e-02f, 3.50274235e-01f, 4.36363146e-02f, 2.76118457e-01f, 2.06276223e-01f,
  1.78967148e-01f, 2.03689948e-01f, -3.21730614e-01f, -8.58497471e-02f, 4.45213355e-02f, -2.97878794e-02f, -3.47440928e-01f, -2.79598832e-01f, -1.12681240e-01f, 4.42984998e-02f,
  7.78955547e-03f, 1.41924024e-01f, -1.00167520e-01f, -5.54752871e-02f, 4.53006756e-03f, -4.68947068e-02f, -7.57757276e-02f, -1.28263757e-01f, -3.06321103e-02f, 5.58301359e-02f,
  -1.90469231e-02f, -4.77226824e-03f, 1.33032158e-01f, -2.21126955e-02f, 9.05393437e-02f, 2.94443481e-02f, -2.20613610e-02f, -3.05040032e-02f, -4.42242846e-02f, 6.44786097e-03f,
  -2.67729554e-02f, -5.28657250e-02f, 1.82605758e-02f, -1.13590322e-02f, -9.48756263e-02f, 7.57402331e-02f, 6.18149266e-02f, -3.62927876e-02f, 7.38731259e-03f, 1.84735283e-01f,
  4.57149558e-02f, 1.16796136e-01f, 4.47252989e-02f, -1.06426859e-02f, 5.74080311e-02f, -1.79485921e-02f, -3.71110924e-02f, -4.97632623e-02f, 5.87815233e-02f, -2.93049496e-02f,
  3.72235873e-03f, -1.95370298e-02f, 6.40861019e-02f, 9.42580774e-03f, 3.78484502e-02f, 8.48032013e-02f, -6.17093267e-03f, -8.25364422e-03f, 3.08959875e-02f, 1.76367536e-02f,
  -4.35992032e-02f, 6.10160455e-02f, -9.61709768e-02f, -2.29889955e-02f, 2.30666846e-02f, -8.75507295e-02f, 4.23874619e-04f, -2.85717286e-02f, 4.04466689e-02f, -2.68386696e-02f,
  6.17271625e-02f, 2.02694654e-01f, 3.98409814e-02f, 7.17582032e-02f, -6.44898117e-02f, 3.23795900e-02f, 9.58851203e-02f, 1.24016367e-01f, 5.92924692e-02f, 1.10543542e-01f,
  -3.48374657e-02f, -6.04770053e-03f, 5.08870967e-02f, 2.37887865e-03f, -1.16942823e-02f, 8.77492800e-02f, 8.57937057e-03f, -2.32044607e-03f, 7.97365606e-02f, -6.59032911e-02f,
  -2.95085758e-02f, 1.15436338e-01f, 2.77863573e-02f, -9.33293428e-04f, 3.09322011e-02f, -4.61450294e-02f, 9.29263681e-02f, -8.88154656e-02f, -8.95116404e-02f, -1.94447022e-02f,
  4.65025038e-01f, 7.65994117e-02f, 1.50288954e-01f, 9.11806449e-02f, -3.28618407e-01f, -4.71398801e-01f, -4.70369011e-01f, -1.80431694e-01f, -7.65246451e-02f, -7.73464441e-02f,
  -3.39028150e-01f, 4.39714909e-01f, 6.75667077e-02f, -4.27475244e-01f, -1.01880468e-02f, -2.99394429e-02f, -2.18780994e-01f, -4.94720712e-02f, -1.30889013e-01f, 2.41335854e-03f,
  -5.50519023e-03f, -4.59952295e-01f, -3.10486052e-02f, -3.43802094e-01f, -1.56719267e-01f, 1.81884453e-01f, 4.05544527e-02f, -2.68195063e-01f, 4.99637239e-02f, -1.61618784e-01f,
  -2.18200788e-01f, -5.93410917e-02f, 1.20060988e-01f, 2.91070156e-02f, -9.61194113e-02f, 7.71365538e-02f, -3.23398598e-02f, -1.25735044e-01f, 6.00588396e-02f, 3.15656103e-02f,
  1.27937302e-01f, 6.11423291e-02f, -2.68880203e-02f, -2.13566385e-02f, -4.67892885e-02f, 7.54752681e-02f, 1.90241262e-02f, 9.93555263e-02f, 1.14338510e-01f, 9.53913480e-02f,
  1.13869779e-01f, 2.46012188e-03f, 5.20019513e-03f, 1.98360458e-02f, -8.93825945e-03f, -1.24725662e-01f, 4.25946601e-02f, 1.20003060e-01f, 3.67838815e-02f, 1.11223580e-02f,
  -4.74130698e-02f, -8.95520747e-02f, -1.39591033e-02f, 1.02325166e-02f, -6.86685145e-02f, -4.68793362e-02f, 3.14704180e-02f, 1.11868335e-02f, -1.58434939e-02f, -7.27181658e-02f,
  -4.78394441e-02f, 6.12242566e-03f, -1.07885273e-02f, 7.82715753e-02f, -4.68992516e-02f, 5.78027219e-02f, 3.20090689e-02f, 2.64828801e-02f, -5.40585108e-02f, -5.11591509e-03f,
  -1.40647581e-02f, -3.79476212e-02f, 4.54187505e-02f, -2.17519887e-02f, -6.50890991e-02f, 1.12841956e-01f, -1.87624060e-02f, 1.70163605e-02f, -4.96393517e-02f, 9.94230993e-03f,
  3.43294144e-02f, 8.56697634e-02f, 3.86222452e-02f, -3.97311971e-02f, 3.23635042e-02f, -1.87938754e-02f, -9.93760005e-02f, 4.27350514e-02f, 1.24123096e-02f, -6.74684122e-02f,
  -8.93928036e-02f, 8.67234136e-04f, 2.17157025e-02f, -1.05617316e-02f, 3.07308435e-02f, -1.22878747e-02f, 1.10680638e-02f, -3.36588435e-02f, -6.13877513e-02f, 5.30296862e-02f,
  6.74634948e-02f, 6.91372678e-02f, 1.26143306e-01f, 4.01017703e-02f, 3.84245403e-02f, 1.02129951e-02f, 1.11991845e-01f, 7.46584758e-02f, 7.62519687e-02f, -4.50942777e-02f,
  -6.74813509e-01f, 4.71708775e-02f, -3.91254544e-01f, -3.81616086e-01f, 1.91213682e-01f, -4.36548203e-01f, -3.82031828e-01f, 1.70142502e-02f, -3.51148918e-02f, 1.46668658e-01f,
  2.49921829e-02f, -6.46934286e-02f, 2.28689507e-01f, -3.94396812e-01f, -4.31026548e-01f, -1.08785115e-01f, -5.96317172e-01f, -3.01616460e-01f, 1.10280268e-01f, -5.62244542e-02f,
  -1.09554932e-01f, -9.52736810e-02f, -2.85213351e-01f, 3.81237298e-01f, -1.70891747e-01f, 1.04591079e-01f, 1.89025283e-01f, 3.59317839e-01f, -1.91906467e-01f, 5.63171208e-02f,
  -1.09314650e-01f, 2.22188711e-01f, -6.96168914e-02f, -3.10369749e-02f, -1.60340369e-01f, -4.78805080e-02f, -7.24627748e-02f, -3.07495631e-02f, 2.28348952e-02f, -9.14472403e-05f,
  -2.96391193e-02f, 3.72878388e-02f, -4.92162295e-02f, 9.76337492e-02f, 6.06044233e-02f, 3.91318724e-02f, -7.64824217e-03f, 1.20523944e-02f, -4.18741629e-02f, -8.39587525e-02f,
  -4.05611359e-02f, -1.14556819e-01f, -1.80966049e-01f, -1.03657626e-01f, -6.35919943e-02f, -4.47581373e-02f, -5.21182381e-02f, 2.64390116e-03f, -3.53419259e-02f, -3.12239770e-02f,
  -8.09236094e-02f, -4.96681891e-02f, 1.06289135e-02f, 5.85936904e-02f, -3.21229012e-03f, -9.76366550e-03f, -1.18924193e-02f, -1.35882283e-02f, 2.65555102e-02f, -3.52246314e-02f,
  -1.89635549e-02f, -2.53310800e-02f, 1.96832828e-02f, -7.87683949e-02f, -5.14386855e-02f, -3.86988483e-02f, -7.39341751e-02f, 8.53823721e-02f, -1.06667347e-01f, 5.61030358e-02f,
  6.52818829e-02f, -4.70785275e-02f, 4.30984311e-02f, 6.66717300e-03f, 3.32261659e-02f, -3.20107937e-02f, -8.45621713e-03f, -1.64243933e-02f, -5.05788950e-03f, -2.22715270e-02f,
  8.71322006e-02f, 2.30121277e-02f, 1.08673476e-01f, 1.08897127e-01f, 4.87967804e-02f, -2.55177654e-02f, -3.05325594e-02f, -4.18229997e-02f, -5.49400263e-02f, 4.89043305e-04f,
  -1.45041244e-02f, 2.42443457e-02f, -3.73813547e-02f, -3.83782350e-02f, -5.11542298e-02f, 1.48315039e-02f, -3.50796916e-02f, -4.93447892e-02f, -2.37049591e-02f, 5.15093356e-02f,
  -4.57085529e-03f, 8.17727447e-02f, 3.11391726e-02f, 6.80501834e-02f, -7.08479481e-03f, -5.62661178e-02f, 1.20723061e-02f, 1.14437677e-02f, 7.48713501e-03f, 6.47031423e-03f,
  -9.91086140e-02f, 1.58810645e-01f, 1.65925086e-01f, 1.72711566e-01f, -7.53828213e-02f, -3.91105205e-01f, -2.65393376e-01f, 2.24208921e-01f, -2.07203671e-01f, 4.51696999e-02f,
  1.87329620e-01f, -1.79136828e-01f, 1.50979847e-01f, -1.71044886e-01f, 2.13528015e-02f, -1.76174879e-01f, -1.10301726e-01f, -1.55547068e-01f, -1.88219681e-01f, 3.34645391e-01f,
  1.55489862e-01f, 9.18709412e-02f, 1.62002891e-01f, 1.16019323e-01f, 2.46654246e-02f, 2.83549309e-01f, 5.49133778e-01f, 1.42237589e-01f, 1.45471662e-01f, -8.32158700e-02f,
  -2.11170360e-01f, 8.05081651e-02f, -4.57689613e-02f, -1.16430372e-01f, 9.33322310e-02f, -1.54198089e-04f, -1.14073989e-03f, -7.01186135e-02f, 6.82021081e-02f, 4.28611785e-02f,
  4.31090966e-02f, 4.07843012e-03f, -6.82883784e-02f, -4.57208939e-02f, -3.61495540e-02f, -3.10513973e-02f, 3.47628482e-02f, -9.62947160e-02f, -4.94491085e-02f, -1.48860049e-02f,
  7.05009000e-03f, 1.50955347e-02f, 7.88342133e-02f, -7.72014782e-02f, 5.91236055e-02f, 9.79438331e-03f, 1.73483528e-02f, 1.39383320e-02f, -8.96995608e-03f, -2.75320858e-02f,
  6.09331429e-02f, 2.98264399e-02f, -1.79295064e-04f, -8.55368599e-02f, 2.51079891e-02f, -2.53535080e-04f, 1.68377045e-03f, 4.44963528e-03f, -1.74821708e-02f, -1.23033104e-02f,
  -2.02100892e-02f, 2.56148968e-02f, -5.30129261e-02f, 4.90195006e-02f, 4.77261171e-02f, -2.16755737e-02f, 3.43907177e-02f, 2.22354475e-02f, -9.78192687e-03f, -5.41621074e-02f,
  -7.95824006e-02f, 2.53297184e-02f, -4.70443740e-02f, -6.23329282e-02f, -8.85957927e-02f, 6.79479614e-02f, 7.43310302e-02f, 1.08565728e-03f, -9.24360100e-03f, 4.23504552e-03f,
  1.81540281e-01f, 3.86391610e-01f, -9.40023456e-03f, -1.29295513e-01f, -4.41978201e-02f, -3.76224183e-02f, -4.87582497e-02f, -2.74836682e-02f, 1.23052791e-01f, -8.04326236e-02f,
  1.25962764e-01f, -2.52646226e-02f, -1.15973027e-02f, 3.81855876e-04f, 3.68084870e-02f, 6.36858046e-02f, 1.33155525e-01f, 3.03046685e-02f, 7.12453052e-02f, 7.56031126e-02f,
  1.31048724e-01f, 1.71457678e-02f, -3.23373117e-02f, -1.07317567e-01f, 3.20330635e-02f, -3.35571356e-02f, -7.15286471e-03f, 1.07123509e-01f, 4.70046774e-02f, -1.29500655e-02f,
  5.81461675e-02f, 2.70832144e-02f, -2.96907425e-01f, -2.67476559e-01f, -2.89682359e-01f, -1.69230610e-01f, 5.84569611e-02f, -1.84021369e-01f, -4.64903116e-02f, 3.89365494e-01f,
  3.20026934e-01f, -1.39609892e-02f, 3.98646533e-01f, 3.01983148e-01f, -7.62647539e-02f, 4.63330895e-01f, 9.05909091e-02f, 1.63548887e-01f, -8.35295692e-02f, -5.04779490e-03f,
  -8.03951845e-02f, 2.65648752e-01f, -6.61913864e-03f, 1.19579351e-02f, -5.11373617e-02f, -1.78140029e-01f, -9.42411572e-02f, -8.68964791e-02f, -1.71790849e-02f, -1.08421244e-01f,
  5.71237653e-02f, 1.27345711e-01f, -6.69328570e-02f, -1.06214002e-01f, -4.11622673e-02f, -1.10574886e-01f, -1.41177461e-01f, -8.38459879e-02f, -6.25092164e-02f, -5.30263707e-02f,
  -4.67231236e-02f, 8.49103928e-03f, -2.83853598e-02f, 6.53833384e-03f, -1.03732482e-01f, -9.35984030e-02f, -7.87832513e-02f, -8.07481539e-03f, 3.06832250e-02f, 8.89001880e-03f,
  -2.93579213e-02f, -8.83981138e-02f, -2.30985116e-02f, 5.81815653e-02f, -1.72670826e-01f, -4.30100411e-02f, 1.60521409e-03f, 1.81366690e-02f, -6.66221008e-02f, -1.03532806e-01f,
  -1.04228497e-01f, -3.26365829e-02f, 2.42190585e-02f, 3.12391948e-02f, -8.67581293e-02f, 1.06222458e-01f, -1.96038075e-02f, -5.17671965e-02f, 7.47069791e-02f, 2.91585531e-02f,
  -4.59396373e-03f, -3.48165967e-02f, -2.45099533e-02f, 1.43737560e-02f, -6.97325766e-02f, 9.13937092e-02f, 5.27961589e-02f, 1.30334299e-03f, -4.67037596e-02f, -7.87860900e-02f,
  1.34618599e-02f, -3.30143943e-02f, 3.58875953e-02f, 5.72250746e-02f, -1.04133502e-01f, -4.18575071e-02f, -1.87196024e-02f, 5.83413197e-03f, 4.16192822e-02f, -6.17574304e-02f,
  -5.06251678e-02f, -8.38970020e-02f, -7.20190331e-02f, 4.64164317e-02f, -4.82119694e-02f, -5.12740240e-02f, 2.90248357e-02f, -1.01484165e-01f, -9.14888680e-02f, 9.86595638e-03f,
  -6.89859763e-02f, -4.16579172e-02f, -7.93210715e-02f, 5.21374159e-02f, 8.36723391e-03f, 2.08387170e-02f, 1.42863020e-02f, -9.05763358e-02f, -6.59410954e-02f, -3.83169279e-02f,
  5.94741553e-02f, 5.35052456e-02f, 2.69191153e-02f, 1.41872810e-02f, -5.56529919e-03f, 3.41743231e-02f, -1.33392606e-02f, -1.01485439e-01f, -1.19188577e-01f, 5.02627827e-02f,
  4.71136093e-01f, -6.47584379e-01f, 2.34272808e-01f, 3.92387271e-01f, 3.03999841e-01f, 2.46106371e-01f, 5.82452595e-01f, -3.21465999e-01f, 1.17200300e-01f, -4.59469885e-01f,
  -1.62385732e-01f, 4.29327153e-02f, -3.08075994e-02f, -1.10686533e-01f, 4.69689876e-01f, -3.99010256e-02f, 1.18573708e-02f, 3.82836759e-02f, -4.20434736e-02f, 8.22256133e-02f,
  1.08122230e-01f, -1.85812600e-02f, 1.35582626e-01f, -2.40416586e-01f, 1.97581336e-01f, 8.54796264e-03f, 8.00086185e-02f, 2.24605024e-01f, -1.64789528e-01f, 1.05507128e-01f,
  7.80936033e-02f, 1.75441559e-02f, -1.20827854e-01f, -1.42885730e-01f, -3.15338746e-02f, 1.25024549e-03f, 4.51051146e-02f, 2.16271967e-01f, 5.71418963e-02f, 2.95971818e-02f,
  8.96914750e-02f, 4.74875011e-02f, -3.46792862e-02f, 8.32269043e-02f, 8.53119045e-02f, -9.49088633e-02f, 7.08529502e-02f, -6.62980899e-02f, -4.62290943e-02f, -2.87525132e-02f,
  -3.46068554e-02f, -4.62473705e-02f, -4.41551656e-02f, -2.96688545e-02f, 3.86779197e-02f, -1.48709035e-02f, 1.36092128e-02f, 7.74505064e-02f, -8.62990841e-02f, -5.16023934e-02f,
  -1.31438464e-01f, -7.33755678e-02f, -2.22540554e-02f, -3.87680940e-02f, 2.01956909e-02f, -7.64203146e-02f, 5.18543599e-03f, -4.92981914e-03f, 3.09337247e-02f, -5.29418886e-02f,
  2.85255164e-02f, -1.89910848e-02f, -3.04379500e-02f, 4.04670238e-02f, 1.64462831e-02f, -2.16845628e-02f, 6.19558431e-02f, -2.65939515e-02f, -1.61735285e-02f, -3.42850648e-02f,
  6.59001842e-02f, 5.32336682e-02f, -5.95744401e-02f, 3.53647508e-02f, 2.28446461e-02f, 6.63722605e-02f, -6.26871139e-02f, 3.64669599e-02f, 3.47897643e-03f, 7.63187706e-02f,
  -1.62617832e-01f, -2.40659297e-01f, -9.80708152e-02f, 3.34722316e-03f, 1.27823129e-02f, -9.83723328e-02f, 4.78390791e-02f, -4.11868133e-02f, -4.31409432e-03f, -5.66726886e-02f,
  -7.12264702e-02f, 2.08715871e-02f, 1.34356441e-02f, 3.76025476e-02f, 1.24596746e-03f, -6.62299916e-02f, 9.60133672e-02f, -1.31531581e-02f, -3.90719995e-02f, -5.44042736e-02f,
  -5.78887686e-02f, 6.77834079e-02f, 9.09039676e-02f, 3.32970060e-02f, -4.31359150e-02f, 1.93337835e-02f, 2.37330571e-02f, -3.63265388e-02f, 2.18446851e-02f, -5.58446720e-02f,
  3.83759677e-01f, -2.10849360e-01f, -2.24387601e-01f, 1.37465388e-01f, -5.38666621e-02f, 2.39556152e-02f, -7.26895928e-02f, -9.00684744e-02f, -2.75140107e-01f, 1.32322535e-02f,
  1.42632619e-01f, 4.51233722e-02f, -2.47944087e-01f, 4.85891163e-01f, 5.42752624e-01f, -3.24201174e-02f, 4.05430228e-01f, 1.17959343e-01f, -1.03725366e-01f, 3.65374126e-02f,
  1.03781469e-01f, 4.79038060e-01f, 5.06786518e-02f, 1.72742531e-01f, 1.24871619e-01f, -1.01621360e-01f, 2.52353579e-01f, -1.78613693e-01f, 3.17803890e-01f, 2.60275453e-01f,
  1.79893449e-02f, -3.30791771e-02f, -3.69100422e-02f, 3.72756906e-02f, -2.35548727e-02f, 4.82392684e-02f, 5.32755919e-04f, 8.47254544e-02f, -8.14147219e-02f, -3.99669781e-02f,
  2.04159692e-02f, 2.81934068e-02f, 1.25766978e-01f, -1.51035341e-03f, 3.01921517e-02f, -7.66959488e-02f, -2.98974756e-02f, -7.37181678e-02f, -1.16901055e-01f, -3.91761027e-02f,
  -1.61114231e-01f, -4.83426899e-02f, -1.06497720e-01f, 2.38328567e-03f, -5.42160124e-02f, -1.17045138e-02f, -6.50746450e-02f, 2.74472870e-02f, 2.08284911e-02f, 9.95254330e-03f,
  1.63946897e-01f, -5.51386550e-02f, -4.48140204e-02f, 3.03053707e-02f, 6.55447170e-02f, -3.42614241e-02f, 7.46655688e-02f, -1.77247394e-02f, -3.58597636e-02f, 5.18311113e-02f,
  8.23702589e-02f, 2.35119350e-02f, 1.46665899e-02f, -2.18508821e-02f, 8.47001746e-03f, -5.28793484e-02f, -4.94136997e-02f, 1.16286450e-03f, -6.76789880e-02f, -6.66066408e-02f,
  1.49408197e-02f, 3.37880552e-02f, 1.45271290e-02f, 4.62044291e-02f, 1.59101607e-03f, -6.31760806e-02f, 1.13416947e-01f, 5.45393601e-02f, -7.41818100e-02f, 4.76830080e-02f,
  8.02934766e-02f, 1.67263791e-01f, -1.57522246e-01f, -2.50659995e-02f, 8.38371832e-03f, 9.50184315e-02f, 8.91327038e-02f, 5.02153262e-02f, 2.97315326e-02f, -7.78181152e-03f,
  -3.32337921e-03f, -4.94165951e-03f, 7.39603490e-02f, 1.03142537e-01f, 1.18770823e-02f, 1.46315005e-02f, 4.71557751e-02f, 1.88952778e-02f, 1.43738771e-02f, 1.80809069e-02f,
  -4.03480418e-02f, 1.57337717e-03f, 4.86077070e-02f, -4.97814752e-02f, 2.00422090e-02f, -4.15677689e-02f, 5.94919687e-03f, -6.89016655e-02f, 6.82138130e-02f, -1.07133528e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.64080212e-02f, 5.15711725e-01f, 5.34517169e-01f, 5.27493238e-01f, 8.04691985e-02f, 3.82684529e-01f, 5.01854122e-01f, 3.52564245e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -4.40854967e-01f, -3.10478330e-01f, -3.40274870e-01f, -4.15712953e-01f, -4.02096242e-01f, 6.42182946e-01f, -5.47274351e-01f, 2.27505818e-01f, 3.23884994e-01f, 4.08776440e-02f,
  7.89372250e-02f, 1.45316452e-01f, 3.03156257e-01f, -2.42782459e-01f, -3.00203860e-01f, 1.41157031e-01f, -3.02157015e-01f, 9.70475376e-03f, -2.43697524e-01f, -5.13772488e-01f,
  3.86664987e-01f, -2.91918874e-01f, -1.26833528e-01f, 1.28326833e-01f, 2.27898747e-01f, -6.06462896e-01f, 1.69379134e-02f, 2.66320139e-01f, 3.02467138e-01f, 1.09479547e-01f,
  -1.80630326e-01f, 8.94192606e-03f, -2.31602475e-01f, -1.74871892e-01f, 1.23499833e-01f, 2.66274393e-01f, -3.76286119e-01f, -3.46962392e-01f, -5.14882088e-01f, 1.13703325e-01f,
  2.87238858e-03f, 2.37470224e-01f, 7.42793232e-02f, 1.06692962e-01f, -4.15011913e-01f, -1.90417290e-01f, 4.07270432e-01f, -3.84761572e-01f, -1.44795072e-03f, 1.87837318e-01f,
  2.90654242e-01f, -1.22984573e-01f, 6.35948539e-01f, -8.81413162e-01f, 2.89402634e-01f, 1.23879693e-01f, -1.46884903e-01f, 1.91821922e-02f, 1.45601463e-02f, 2.94358820e-01f,
  3.80498357e-02f, 9.15361494e-02f, 2.13910908e-01f, -2.20410243e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.91297704e-01f, 2.01061264e-01f, 3.34915727e-01f, 2.63473272e-01f, -6.42235100e-01f, -2.71789074e-01f, -2.92761177e-01f, -3.93666476e-01f, 9.52944040e-01f, 1.58127159e-01f,
  2.72293091e-01f, -1.57263055e-01f, 5.66259980e-01f, -3.24898988e-01f, 3.16453516e-01f, 8.54265690e-01f, -3.30569446e-02f, 4.08375233e-01f, -1.74519658e-01f, 1.02990009e-01f,
  1.27274799e+00f, -8.09797794e-02f, -9.10497129e-01f, -4.69992906e-02f, 5.55697441e-01f, -2.92238712e-01f, 7.50957280e-02f, 7.67607749e-01f, -4.65641469e-01f, 6.96418643e-01f,
  6.87675238e-01f, 2.23245680e-01f, -1.76679366e-03f, 3.15272391e-01f, 6.84343815e-01f, 2.11154923e-01f, -4.33311723e-02f, -1.10528147e+00f, -5.96717954e-01f, 3.79916459e-01f,
  1.45991549e-01f, 2.27715060e-01f, 1.13545918e+00f, -1.45556092e-01f, -3.06388885e-01f, -9.74439681e-02f, 3.79085928e-01f, -2.22186267e-01f, 3.32828254e-01f, 5.82586899e-02f,
  1.57383438e-02f, 2.66287476e-01f, 3.51947516e-01f, 2.38259926e-01f, 5.92319429e-01f, -5.75462222e-01f, -2.61259347e-01f, 9.21689212e-01f, 1.26551297e-02f, -4.48396385e-01f,
  -4.27673638e-01f, 8.50779593e-01f, 4.51733649e-01f, 7.75597990e-01f, 1.84229184e-02f, 3.16270329e-02f, -1.37078345e-01f, -1.06032744e-01f, 2.77806997e-01f, 1.42712027e-01f,
  -2.66417265e-01f, 3.24670941e-01f, 5.92959411e-02f, -1.47238120e-01f, 2.27812096e-01f, 3.51032853e-01f, -2.50600457e-01f, -5.90389334e-02f, -1.64968818e-01f, 4.24321257e-02f,
  7.39911735e-01f, 1.55060783e-01f, 1.32944703e-01f, 7.76935637e-01f, -8.54982138e-02f, 6.30951524e-01f, 6.52696565e-02f, 4.15929139e-01f, -1.32856935e-01f, 7.89725602e-01f,
  -4.00384098e-01f, 1.23760319e+00f, 2.83358812e-01f, -2.62421459e-01f, 9.82546806e-02f, -3.60592514e-01f, 3.31693232e-01f, 2.63621006e-02f, -1.87476069e-01f, -1.28606400e-02f,
  -3.70793074e-01f, 6.11723363e-02f, -4.79281574e-01f, -5.00800729e-01f, -4.33694541e-01f, 1.18080445e-01f, 2.42586732e-01f, -9.52522978e-02f, 2.61161953e-01f, -3.43025327e-02f,
  1.15744483e+00f, -1.64284989e-01f, 2.40640029e-01f, 3.14709485e-01f, 3.94513309e-01f, -2.60488003e-01f, -8.58427584e-01f, -3.14640217e-02f, 9.03399587e-01f, 3.72547776e-01f,
  -2.58526593e-01f, 4.45298165e-01f, 8.25175941e-01f, 6.17574215e-01f, 7.48137116e-01f, 3.27236801e-01f, -2.93767065e-01f, 3.74727666e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.35508695e-01f, 3.00722182e-01f, 6.39102697e-01f, 1.92599356e-01f, -1.10048264e-01f, 3.29923064e-01f, 1.49203539e-01f, 4.48907018e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -4.79730457e-01f, 7.99549341e-01f, 1.44040495e-01f, 5.45307577e-01f, -5.43755054e-01f, -6.38663843e-02f, -6.29589736e-01f, 7.15676546e-01f, -6.49716020e-01f, 3.36018503e-01f,
  -7.46466637e-01f, 8.80183280e-01f, -3.02587360e-01f, -4.63345021e-01f, -4.47748512e-01f, -2.24387832e-02f, 3.96430552e-01f, -6.60206616e-01f, 1.00868279e-02f, 1.57188162e-01f,
  1.67702347e-01f, -3.53965461e-01f, -8.55059326e-01f, -8.33263218e-01f, 1.39776215e-01f, -4.28181440e-01f, -6.75097585e-01f, 9.06462669e-01f, 3.19287740e-02f, -2.08455577e-01f,
  -3.16219172e-03f, 4.06948715e-01f, 1.18385717e-01f, 1.49663016e-01f, 9.62660313e-02f, -4.67906535e-01f, 6.62356138e-01f, -2.52153844e-01f, 5.35026081e-02f, -7.77770221e-01f,
  1.04584408e+00f, 3.26625407e-01f, -3.13625842e-01f, 1.35473654e-01f, -3.96267958e-02f, -2.70689428e-01f, -2.13283941e-01f, -8.93392324e-01f, -2.36121304e-02f, -3.00764382e-01f,
  4.99324016e-02f, -7.24381924e-01f, -9.55292434e-02f, 4.80510712e-01f, -1.93706885e-01f, 5.25962114e-01f, -7.66559005e-01f, 5.43049157e-01f, -5.49736261e-01f, -6.91218793e-01f,
  3.26543212e-01f, 8.43241572e-01f, -1.38634473e-01f, 2.73956507e-01f, 5.66200614e-01f, 1.06529152e+00f, 7.04635441e-01f, 3.59846801e-01f, -4.36731964e-01f, -1.96397826e-01f,
  1.00003384e-01f, 2.83460796e-01f, -1.95122689e-01f, 1.00159919e+00f, 4.96829510e-01f, -4.22837496e-01f, 1.40084103e-01f, 4.36002642e-01f, -3.87581766e-01f, -9.41373110e-01f,
  -8.07542264e-01f, -8.78256917e-01f, 3.47562641e-01f, -1.64469898e-01f, -5.11842847e-01f, -6.42680526e-01f, 4.85164344e-01f, 8.65244329e-01f, -5.22773191e-02f, -6.71657383e-01f,
  3.81503761e-01f, 6.55163527e-01f, 8.01155642e-02f, 3.13115507e-01f, -1.44490391e-01f, 6.01120032e-02f, 4.38344836e-01f, -9.36428189e-01f, -6.07244015e-01f, 3.67443055e-01f,
  2.71700352e-01f, -3.25119227e-01f, 4.49064851e-01f, -5.12544096e-01f, -8.77837911e-02f, 1.82025850e-01f, -1.58002451e-01f, 1.81782216e-01f, -1.00387335e-01f, 7.07801759e-01f,
  9.99520123e-01f, -7.61904359e-01f, 4.80037332e-02f, -6.79033339e-01f, -1.00525893e-01f, -6.22476220e-01f, 7.98790336e-01f, 9.27053690e-01f, 2.76685238e-01f, 2.59187400e-01f,
  -3.69233608e-01f, 3.69115680e-01f, 8.62244427e-01f, -1.16024196e-01f, 4.52749074e-01f, -3.96042436e-01f, -4.48006928e-01f, 2.62248188e-01f, 3.48968282e-02f, -9.01848748e-02f,
  -6.37399554e-01f, 1.15414336e-02f, 5.54730475e-01f, 7.20020056e-01f, -6.35266364e-01f, -5.75960398e-01f, 9.58386421e-01f, -5.24740815e-01f, -1.46055758e-01f, -4.69644189e-01f,
  1.77402779e-01f, -3.50968003e-01f, 5.65340817e-02f, 5.47568798e-01f, -5.04688084e-01f, 1.65355727e-01f, -5.34571782e-02f, -1.89154014e-01f, -2.39091545e-01f, -3.97308767e-01f,
  1.82537198e-01f, 4.91783261e-01f, -3.89681309e-02f, 7.51475930e-01f, 3.69393170e-01f, 3.62827741e-02f, 1.05386272e-01f, -9.57597256e-01f, 9.97009337e-01f, -9.05024469e-01f,
  4.57456142e-01f, 3.26484442e-01f, 1.91933066e-01f, 4.65798944e-01f, 5.85340321e-01f, -1.35561168e-01f, -1.76508859e-01f, -7.21549615e-02f, -2.89303869e-01f, -9.48002756e-01f,
  -5.21692634e-01f, -6.11005843e-01f, -1.28060682e-02f, 1.00106108e+00f, 7.62680620e-02f, 6.55238509e-01f, 3.20116848e-01f, 1.93642989e-01f, -4.17044014e-02f, 2.80258745e-01f,
  -3.16472590e-01f, -3.88678074e-01f, 5.58100760e-01f, 1.49618864e-01f, 4.86986190e-02f, -8.81737232e-01f, 1.13693202e+00f, -6.61888838e-01f, -2.00197920e-01f, -4.47499484e-01f,
  1.41387343e-01f, 4.41205859e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.17533940e-01f, -2.34741703e-01f, -1.27537087e-01f, -5.36900386e-02f, 6.36631012e-01f, 3.38490456e-01f, 2.54985988e-01f, -1.19533382e-01f, -2.49106348e-01f, -3.44652355e-01f,
  -1.11323960e-01f, -3.08474805e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    