/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.89538801e-01f, 9.53586325e-02f, -7.43107200e-02f, -8.49760920e-02f, 1.58665087e-02f, 8.29649717e-02f, 2.33831167e-01f, 4.87141684e-02f, -1.01029225e-01f, -1.59474704e-02f,
  -1.85311493e-02f, -2.28288900e-02f, -1.15364883e-02f, -4.87025231e-02f, 5.28903604e-02f, 2.44659990e-01f, 8.33236873e-02f, 1.07106850e-01f, 2.83712745e-02f, 6.92031719e-03f,
  1.03497371e-01f, -5.76467700e-02f, -1.20572351e-01f, -1.76268727e-01f, -9.35109630e-02f, -9.87352505e-02f, -1.87369257e-01f, -1.48508161e-01f, 3.98385115e-02f, 2.57097720e-03f,
  -1.63497940e-01f, -1.64394870e-01f, 5.97545914e-02f, 2.53430009e-02f, -1.33277938e-01f, -7.05902325e-03f, -1.51025306e-04f, -5.32008037e-02f, -9.44035277e-02f, -6.07549846e-02f,
  2.19457429e-02f, -2.44685672e-02f, -9.05420408e-02f, -4.92570875e-03f, -4.66176728e-03f, 1.23026676e-03f, -7.13522881e-02f, -8.82752687e-02f, -3.12870778e-02f, -9.57835615e-02f,
  1.84595063e-02f, 1.01448059e-01f, 1.82270240e-02f, -8.56597722e-02f, -4.77872714e-02f, -2.43258826e-03f, 1.07217468e-02f, -1.42758459e-01f, -1.51276469e-01f, -8.69974345e-02f,
  3.00172511e-02f, -6.07954934e-02f, 2.69218143e-02f, -2.71811374e-02f, 5.39283268e-02f, 6.86313733e-02f, 1.02474086e-01f, 3.22380327e-02f, -2.24386957e-02f, 8.67512599e-02f,
  -6.85759857e-02f, -6.40963390e-02f, 8.08778405e-03f, -3.79755460e-02f, -6.62109302e-03f, 1.70393568e-02f, 6.67084679e-02f, 5.53639838e-03f, -1.38221486e-02f, 1.86301135e-02f,
  -1.92169230e-02f, 6.10362925e-02f, 2.76221484e-02f, -2.38048248e-02f, -1.50269261e-02f, 1.26394806e-02f, 2.43487991e-02f, -7.83125162e-02f, 1.52818877e-02f, 5.83382770e-02f,
  -2.30828896e-01f, 3.37968841e-02f, 8.08478594e-02f, 9.93780233e-03f, 2.05890052e-02f, -5.26364483e-02f, -3.21794138e-03f, 2.45133806e-02f, -1.06092185e-01f, -1.05959967e-01f,
  -3.62606980e-02f, -1.08558401e-01f, 1.18470965e-02f, -1.32430280e-02f, -2.26624794e-02f, -7.76157081e-02f, 7.86298662e-02f, -3.66035588e-02f, 4.14120555e-02f, -5.91308139e-02f,
  3.10417842e-02f, 1.23582043e-01f, 1.15416996e-01f, -2.12532356e-02f, -1.00837752e-01f, -6.47360273e-03f, -8.71313065e-02f, -9.25939009e-02f, 3.59503888e-02f, -2.80304160e-02f,
  6.41609311e-01f, 4.52955365e-01f, 2.50297397e-01f, 4.71416533e-01f, 1.98328629e-01f, -2.30688546e-02f, 2.72556216e-01f, 7.38918036e-02f, 1.99928924e-01f, 3.48777264e-01f,
  2.09669113e-01f, 7.45724887e-02f, 2.03168243e-01f, 4.34214808e-03f, -5.05970903e-02f, 2.99054652e-01f, 1.38731733e-01f, 8.11321810e-02f, -1.38402030e-01f, -6.51512370e-02f,
  1.16863951e-01f, 2.25470871e-01f, 1.47939920e-01f, 8.06440562e-02f, 2.37645194e-01f, 1.30000368e-01f, 2.70783931e-01f, 1.76888272e-01f, 1.53985769e-01f, 4.09228235e-01f,
  1.73602715e-01f, 3.26432079e-01f, -9.73139182e-02f, 1.54113322e-01f, 7.08596110e-02f, 1.49298891e-01f, 1.94357708e-01f, 5.10263406e-02f, 9.83330384e-02f, 1.65527642e-01f,
  1.14041366e-01f, 9.49279964e-02f, 2.16061875e-01f, 6.37551546e-02f, 1.75184697e-01f, 6.39921129e-02f, 5.05617224e-02f, 1.52748957e-01f, 4.02374333e-03f, 4.99789417e-02f,
  6.80692419e-02f, 2.84889936e-01f, 2.00780675e-01f, -3.34214717e-02f, 6.50760904e-02f, 5.78090549e-02f, 3.69012170e-02f, 6.81889132e-02f, 4.71110828e-02f, 1.62944198e-01f,
  -1.31637245e-01f, -4.78717275e-02f, -5.36937155e-02f, -9.91602764e-02f, -1.76819786e-02f, -1.27445012e-01f, -5.21429852e-02f, -6.66671470e-02f, -7.68258721e-02f, -1.31188542e-01f,
  -8.50342661e-02f, -1.14202708e-01f, -1.19989276e-01f, -9.21191126e-02f, -9.03418809e-02f, -4.65836339e-02f, -7.20353052e-02f, -1.49007007e-01f, -1.80565149e-01f, -8.08186308e-02f,
  -9.65398625e-02f, -5.84349930e-02f, -1.52206734e-01f, -1.77077025e-01f, -1.36721194e-01f, -3.62347476e-02f, -1.19456619e-01f, -1.63178429e-01f, -5.12702800e-02f, -1.72060188e-02f,
  4.82473262e-02f, -2.64918040e-02f, 1.40962526e-01f, 6.05321564e-02f, 1.24687046e-01f, 2.96272393e-02f, 1.06012501e-01f, 2.96656452e-02f, 1.45365581e-01f, 1.43899992e-01f,
  1.27183527e-01f, 1.26847371e-01f, 9.44172293e-02f, 1.85364150e-02f, 1.23474644e-02f, 3.72424945e-02f, 1.22229129e-01f, 1.41848713e-01f, 4.45168391e-02f, 1.57094181e-01f,
  1.34937987e-01f, 7.68930912e-02f, 1.78129941e-01f, 6.01416528e-02f, -1.49260629e-02f, 8.58524442e-02f, 1.08167380e-01f, 6.62379414e-02f, -2.18051914e-02f, 1.51670396e-01f,
  2.72424161e-01f, 1.16794139e-01f, -4.38853353e-01f, 1.41254291e-01f, -1.68448940e-01f, -1.77735671e-01f, -1.90507382e-01f, 3.79218049e-02f, 1.61066696e-01f, -3.04640010e-02f,
  9.79723334e-02f, 2.19361082e-01f, 9.91158560e-02f, -8.31457302e-02f, -1.68391585e-01f, -3.29192787e-01f, -3.68238032e-01f, -3.35181594e-01f, -2.42903277e-01f, -5.31905107e-02f,
  3.43770981e-02f, 2.78242435e-02f, 2.70204549e-03f, -1.90981086e-02f, 5.90137802e-02f, 6.35744408e-02f, -1.00597791e-01f, -6.64421842e-02f, -1.11154549e-01f, -1.16940446e-01f,
  -3.34784657e-01f, 1.16651066e-01f, -7.91018307e-02f, 1.34548336e-01f, 7.09853843e-02f, 3.95817794e-02f, -6.49226084e-02f, -6.12166189e-02f, 6.49003312e-02f, -2.79519893e-03f,
  -6.51587322e-02f, 6.99461251e-02f, 1.89382359e-02f, -5.35545945e-02f, 3.12052872e-02f, -4.25090045e-02f, 2.48343591e-03f, 2.81451419e-02f, -3.89244482e-02f, 6.12800475e-03f,
  1.81294978e-01f, -4.22153175e-02f, -7.38939717e-02f, -6.23219572e-02f, -9.73837972e-02f, -1.09697245e-01f, -1.75601395e-03f, -3.80207002e-02f, -1.21278092e-01f, 4.14568791e-03f,
  1.71082243e-02f, 8.73468369e-02f, 9.52353030e-02f, 1.55079827e-01f, 1.22327447e-01f, 1.08861364e-01f, 6.49369508e-03f, 2.05136053e-02f, 2.18731370e-02f, 2.45404150e-02f,
  8.03082138e-02f, 1.09404929e-01f, 9.87132266e-03f, 8.15285072e-02f, -8.66593211e-04f, -6.76672459e-02f, 2.71082036e-02f, 6.21044226e-02f, 4.67139520e-02f, 5.49642555e-02f,
  1.09472983e-01f, 2.06367709e-02f, 3.63661982e-02f, 7.82036558e-02f, 6.71496540e-02f, 3.87374312e-02f, 8.47111940e-02f, 1.15680374e-01f, 7.25244582e-02f, 1.14546761e-01f,
  1.80419073e-01f, -7.01047331e-02f, -4.86759394e-02f, -7.30638206e-02f, -1.05241917e-01f, -2.63435710e-02f, 5.21306545e-02f, 1.65741891e-02f, 4.33026301e-03f, -7.89211020e-02f,
  -6.61125481e-02f, -9.97093767e-02f, -1.76626816e-02f, -3.65183945e-03f, -3.74471806e-02f, -2.35697292e-02f, 9.95303243e-02f, -8.43797848e-02f, 2.64715515e-02f, -1.40207279e-02f,
  -1.32196350e-02f, -1.64624363e-01f, -1.68779537e-01f, -8.53028074e-02f, -5.58240972e-02f, -6.86255172e-02f, -1.81772992e-01f, -1.31130859e-01f, -2.72065222e-01f, -6.71054944e-02f,
  -2.74390280e-01f, -1.81234911e-01f, -3.07010055e-01f, -2.90699542e-01f, -1.91870153e-01f, -2.90717244e-01f, -1.40114605e-01f, -1.26170367e-01f, -1.05829343e-01f, -2.07823962e-01f,
  -1.75642639e-01f, 1.57018267e-02f, -1.59506187e-01f, -9.22018513e-02f, -6.45852610e-02f, -1.44829571e-01f, -1.18631460e-01f, -8.89732018e-02f, -2.61134505e-02f, -4.18612026e-02f,
  -1.71828464e-01f, -2.11386144e-01f, -1.05457297e-02f, -3.58739123e-02f, -9.91600901e-02f, -3.78735289e-02f, -2.05950707e-01f, -1.79790199e-01f, -8.21197480e-02f, -1.60311177e-01f,
  -2.25354299e-01f, -2.00620472e-01f, -6.32083938e-02f, -4.19209711e-02f, -9.37028304e-02f, 6.95603061e-03f, -1.10145599e-01f, -3.37244198e-02f, 4.25473275e-03f, -7.47174397e-02f,
  -7.73494095e-02f, -6.72353059e-02f, 2.53032260e-02f, -5.86808026e-02f, -8.70079547e-02f, 1.57706207e-03f, -2.48010969e-03f, -2.26063151e-02f, 4.31928225e-02f, 8.76509920e-02f,
  -3.72894816e-02f, -5.89990057e-02f, -1.37640284e-02f, 3.53158042e-02f, 9.15303603e-02f, -5.40665351e-03f, -4.03642580e-02f, -3.32027767e-03f, 3.88412029e-02f, 6.24290528e-03f,
  -4.73127421e-03f, 2.05049682e-02f, -6.60624681e-03f, 6.86455294e-02f, -3.94208841e-02f, -6.16066270e-02f, -1.78620126e-02f, 1.32607743e-02f, -4.53357622e-02f, 3.85097414e-02f,
  1.30076800e-03f, -4.92961407e-02f, 4.05645333e-02f, -3.14118005e-02f, -3.20895985e-02f, 1.61876436e-02f, -4.77376468e-02f, 2.83361804e-02f, 9.60014574e-03f, 2.81139147e-02f,
  4.15284000e-02f, -1.36135668e-02f, -4.36408557e-02f, 6.47752509e-02f, -3.01414006e-03f, -9.14109796e-02f, -8.74995533e-03f, -3.82340513e-02f, -1.16141975e-01f, -5.15537430e-03f,
  -1.61748946e-01f, 1.31320462e-01f, -3.05526350e-02f, 3.55949327e-02f, -1.91943403e-02f, 1.03291824e-01f, -4.67077903e-02f, 9.84676629e-02f, -2.47179214e-02f, -1.48437442e-02f,
  5.92258619e-03f, 3.40017825e-02f, -2.54984014e-02f, 5.98845854e-02f, -6.24233112e-02f, 9.52835474e-03f, 5.08111843e-04f, 1.54610099e-02f, 7.93102160e-02f, 7.48549327e-02f,
  2.56498717e-02f, 7.15152398e-02f, 5.33095002e-02f, 4.00218852e-02f, 5.49339391e-02f, 1.65908057e-02f, 4.23797294e-02f, 1.01844996e-01f, 7.43611678e-02f, 1.07212350e-01f,
  1.21094048e-01f, -2.58841634e-01f, 6.42422959e-03f, 4.12230901e-02f, 2.35549748e-01f, 6.39219135e-02f, -9.40620750e-02f, -2.80859116e-02f, 1.52622715e-01f, -1.25335842e-01f,
  8.72631446e-02f, 1.34142682e-01f, 1.40426368e-01f, 1.81878775e-01f, 1.60130084e-01f, -6.97176456e-02f, 9.35553163e-02f, 2.60870010e-01f, 3.18029881e-01f, 3.21069509e-01f,
  7.89592043e-02f, 1.70990407e-01f, 2.58739829e-01f, 9.06081498e-02f, 3.24610434e-02f, 1.12496227e-01f, -8.39923471e-02f, 1.74785927e-02f, 8.03675354e-02f, 5.53864799e-02f,
  -7.58094341e-02f, -8.29847679e-02f, 2.92199463e-01f, 1.57398984e-01f, 1.54301912e-01f, 1.84231639e-01f, 2.29572237e-01f, 9.92878303e-02f, 8.47572610e-02f, 6.59236610e-02f,
  1.26575008e-01f, 1.46093488e-01f, 1.25652462e-01f, 1.34665415e-01f, 1.95709452e-01f, 1.95787579e-01f, 4.76074480e-02f, 8.92613530e-02f, 2.11052448e-01f, 1.32482886e-01f,
  1.38046816e-01f, 1.86475739e-01f, 1.17767550e-01f, 2.01156169e-01f, 8.81614909e-02f, 3.47542703e-01f, 1.70378163e-01f, 1.04711026e-01f, 2.80525446e-01f, 1.32518128e-01f,
  6.24396699e-03f, -1.34508535e-01f, -1.23834081e-01f, -2.05814689e-01f, -1.62642553e-01f, -1.58668518e-01f, -2.31938735e-01f, -1.38671711e-01f, -1.65892035e-01f, -1.86356246e-01f,
  -1.56214342e-01f, -1.73771068e-01f, -1.84518263e-01f, -1.39400631e-01f, -8.98676142e-02f, -1.75575003e-01f, -1.98991776e-01f, -1.44564077e-01f, -1.55117109e-01f, -1.66719139e-01f,
  -1.41009063e-01f, -1.66478500e-01f, -2.00059727e-01f, -9.57184806e-02f, -1.57812431e-01f, -6.80143088e-02f, -7.20904917e-02f, -2.97262743e-02f, -6.79514632e-02f, -2.04370499e-01f,
  -1.67914852e-02f, 2.76142448e-01f, 9.28750113e-02f, 3.89410332e-02f, 9.45837945e-02f, 1.54391751e-01f, 9.67131704e-02f, 1.45401433e-01f, 2.13010713e-01f, 1.20526530e-01f,
  2.31710672e-01f, 1.39185965e-01f, 1.16346255e-01f, 1.46857589e-01f, 1.73704162e-01f, 1.03850342e-01f, 1.05543882e-01f, 9.98958871e-02f, 1.82189643e-01f, 1.60259977e-01f,
  1.10982582e-01f, 1.60601154e-01f, 1.37268484e-01f, 1.43955424e-01f, 1.00191996e-01f, 1.72962248e-01f, 1.83144838e-01f, 2.06495509e-01f, 1.63165361e-01f, 7.16920197e-02f,
  -3.55245411e-01f, 3.32473844e-01f, 1.53279096e-01f, -1.59337997e-01f, 2.64930557e-02f, 1.92799978e-02f, 6.92747310e-02f, -4.70296480e-02f, -2.19213992e-01f, 1.09368153e-01f,
  1.01109639e-01f, -1.63302839e-01f, -5.32627515e-02f, -3.18256617e-02f, -1.21279107e-02f, 2.21250281e-01f, 1.29720479e-01f, -6.38596714e-02f, -1.64163977e-01f, -5.03086224e-02f,
  3.48481685e-02f, -1.63658131e-02f, -4.81212474e-02f, -8.82977992e-02f, 9.09775719e-02f, -4.15631756e-03f, 1.84754387e-01f, 2.56935898e-02f, 9.66445357e-02f, 2.29474202e-01f,
  2.17203289e-01f, 7.77883381e-02f, 1.04114180e-02f, 1.13759816e-01f, 6.69044405e-02f, 2.14591827e-02f, 8.16720203e-02f, 1.17989309e-01f, 1.11141190e-01f, 7.23490939e-02f,
  7.91649595e-02f, 1.88158583e-02f, 3.65221687e-02f, 6.78302795e-02f, 1.20140955e-01f, 1.87532380e-02f, 1.48497507e-01f, -6.41351705e-03f, 1.18484907e-01f, 1.36151254e-01f,
  1.77071899e-01f, 1.09673761e-01f, -5.16567938e-03f, 4.63950485e-02f, -6.16962053e-02f, 3.45762782e-02f, 1.51718752e-02f, 1.96801987e-03f, 5.50138131e-02f, 2.80186255e-02f,
  4.54798713e-02f, -1.28162473e-01f, -1.55708700e-01f, -8.37661624e-02f, -8.59557390e-02f, -2.60935444e-02f, -2.28518397e-02f, -3.69424955e-03f, -1.15440033e-01f, -1.20561086e-02f,
  -1.00051358e-01f, -8.39412063e-02f, -8.59512910e-02f, -1.75392050e-02f, -1.27461955e-01f, -2.67580301e-02f, -2.97134500e-02f, 2.54461952e-02f, -3.79783958e-02f, 1.74131487e-02f,
  -4.75055911e-02f, -4.04499657e-02f, -2.43913904e-02f, -9.64172557e-03f, 3.38731445e-02f, -2.27971189e-02f, -8.40200931e-02f, -9.17185619e-02f, -6.60795718e-02f, -1.23682812e-01f,
  -2.26883054e-01f, -6.01882897e-02f, 5.30665107e-02f, -5.33549413e-02f, 1.23804778e-01f, 3.96093503e-02f, 1.18015587e-01f, -2.17092857e-02f, 8.46825689e-02f, -4.43262570e-02f,
  6.57678172e-02f, -3.98240946e-02f, 5.42168319e-02f, 1.02643907e-01f, -4.81301434e-02f, -3.57699730e-02f, 6.28726557e-02f, -8.36915430e-03f, -4.96569462e-02f, -1.21457002e-03f,
  9.56209525e-02f, -5.76080903e-02f, -1.27360508e-01f, -8.97781700e-02f, -1.25900954e-01f, -1.89943403e-01f, -8.30765963e-02f, -3.85296084e-02f, -1.80687234e-01f, -1.59386441e-01f,
  -2.08178341e-01f, -1.07305482e-01f, -1.52493967e-02f, 9.43385586e-02f, 2.44563684e-01f, -2.82203611e-02f, -1.93083942e-01f, -1.02124318e-01f, 6.85171783e-02f, 4.09632288e-02f,
  1.86402261e-01f, 4.30483192e-01f, 2.43869409e-01f, 2.63925105e-01f, 1.71582308e-02f, -1.32397205e-01f, -9.07902494e-02f, 1.05763808e-01f, 8.53537619e-02f, 1.27001718e-01f,
  2.04076231e-01f, 6.21727109e-02f, 1.25273820e-02f, 1.13135614e-01f, 1.11701876e-01f, 2.39080757e-01f, 3.99006270e-02f, 9.20368452e-03f, 6.57823384e-02f, 1.56226128e-01f,
  2.72851605e-02f, 1.10567369e-01f, 1.03711538e-01f, 3.02572846e-01f, 1.66755185e-01f, 8.57370496e-02f, 1.10105015e-01f, 1.20737143e-01f, 1.83000460e-01f, 8.62733200e-02f,
  2.26526961e-01f, 1.53912976e-01f, 1.34022579e-01f, 1.80970937e-01f, 1.50968447e-01f, 1.31085679e-01f, 3.91000696e-02f, 1.45708427e-01f, 3.72785814e-02f, 4.97048274e-02f,
  2.43918300e-01f, 1.44473553e-01f, 1.06003821e-01f, -9.14018229e-03f, 3.46569829e-02f, 1.92427173e-01f, -7.15545565e-03f, 4.18602377e-02f, 8.09139758e-02f, -1.02881879e-01f,
  -2.74568014e-02f, -1.51291266e-01f, -6.14938736e-02f, -2.07488537e-01f, -1.68124929e-01f, -1.56537920e-01f, -6.13511018e-02f, -1.12710662e-01f, -1.57709897e-01f, -2.14398533e-01f,
  -9.23002735e-02f, -1.76257849e-01f, -1.23709686e-01f, -1.09950446e-01f, -7.99398944e-02f, -1.88912034e-01f, -7.85690248e-02f, -1.07479863e-01f, -1.67540595e-01f, -9.63677093e-02f,
  -1.32271871e-01f, -1.72513261e-01f, -8.03110972e-02f, -1.02714583e-01f, -1.22114070e-01f, -1.02085143e-01f, -1.68992504e-01f, -1.21104963e-01f, -1.85669720e-01f, -1.75320700e-01f,
  1.06513284e-01f, 2.96476096e-01f, 6.68366253e-02f, 5.82426973e-02f, 1.85451522e-01f, 1.89113796e-01f, 1.24123149e-01f, 1.72485933e-01f, 2.07574964e-01f, 5.46849407e-02f,
  1.75517395e-01f, 1.34023950e-01f, 9.58430395e-02f, 7.47814924e-02f, 5.06637953e-02f, 1.03591450e-01f, 8.62520710e-02f, 1.31715283e-01f, 2.14155793e-01f, 1.18782170e-01f,
  6.67581335e-02f, 1.11616395e-01f, 9.84334201e-03f, 9.70311183e-03f, 8.21003392e-02f, 1.16003498e-01f, 2.38570161e-02f, 1.11365408e-01f, -2.24721171e-02f, -4.59301136e-02f,
  -2.93860465e-01f, 3.26799810e-01f, 2.76088178e-01f, -1.82116255e-02f, 1.12104967e-01f, -1.82610843e-02f, -2.95767095e-02f, -7.58905709e-02f, -3.64587232e-02f, 7.64732659e-02f,
  2.64155954e-01f, 2.01927871e-01f, 8.87905434e-02f, 1.30147070e-01f, 1.02440314e-02f, 1.39795095e-01f, 1.86177999e-01f, 9.42302197e-02f, -5.16182743e-02f, 1.48954813e-03f,
  1.09938644e-01f, -3.44909951e-02f, -5.93845621e-02f, 3.34933177e-02f, 7.65610039e-02f, 9.61434692e-02f, 1.75701529e-01f, 1.33375466e-01f, 1.43437147e-01f, 1.03025049e-01f,
  1.18371613e-01f, 7.81335831e-02f, 7.71581978e-02f, 1.70291573e-01f, 2.00805351e-01f, 1.74503863e-01f, 5.75489625e-02f, 1.41553193e-01f, 1.73526034e-01f, 1.44281939e-01f,
  9.23405439e-02f, 1.60919562e-01f, 1.18057795e-01f, 1.97194025e-01f, 3.22377980e-02f, 8.65335166e-02f, 2.30549853e-02f, 1.13534138e-01f, 1.21320106e-01f, 1.50815815e-01f,
  2.07938701e-01f, 1.44975945e-01f, -2.79916432e-02f, -3.98886949e-02f, 3.97989526e-02f, 2.61310209e-02f, -1.60655659e-02f, -8.05306211e-02f, -7.14580119e-02f, -1.33552179e-01f,
  -7.57810548e-02f, -1.34988472e-01f, -1.89906567e-01f, -1.48777798e-01f, -6.68720827e-02f, -1.46736681e-01f, -1.41216889e-01f, -1.31883904e-01f, -2.05095842e-01f, -1.84705675e-01f,
  -7.38404840e-02f, -2.17665434e-01f, -2.03745246e-01f, -1.43806756e-01f, -1.43802866e-01f, -1.84764311e-01f, -2.29048416e-01f, -2.40845352e-01f, -1.38924211e-01f, -2.19482571e-01f,
  -1.80350944e-01f, -2.24642709e-01f, -1.26126215e-01f, -1.49068892e-01f, -1.08648740e-01f, -1.58370405e-01f, -1.39784008e-01f, -2.75720924e-01f, -1.79884836e-01f, -1.96555987e-01f,
  -1.22867852e-01f, 1.80200830e-01f, 3.58916782e-02f, 1.49113804e-01f, 2.13036940e-01f, 1.24357931e-01f, 1.31162360e-01f, 1.49856970e-01f, 1.77892342e-01f, 8.56022835e-02f,
  1.54065967e-01f, 7.18772858e-02f, 1.59074217e-01f, 7.09951892e-02f, 1.44840226e-01f, -3.15811038e-02f, 1.08397208e-01f, 1.60649806e-01f, 2.76211314e-02f, 1.32508069e-01f,
  1.49064148e-02f, -9.09095258e-02f, -6.03562184e-02f, 1.75476987e-02f, -3.51277292e-02f, -7.43676722e-02f, -4.08776999e-02f, -7.75003731e-02f, -4.14394401e-03f, -1.69660114e-02f,
  -4.56425303e-04f, 2.23968804e-01f, -3.84120792e-01f, 1.93123370e-01f, -2.39519984e-01f, -2.75832176e-01f, -1.83664590e-01f, 1.13972619e-01f, 8.78024325e-02f, -3.58262248e-02f,
  1.12850092e-01f, 3.33757252e-01f, 3.45156789e-01f, 2.01038107e-01f, 6.97382987e-02f, -1.29744038e-01f, -1.90527633e-01f, -3.40211019e-02f, -1.32965699e-01f, -9.47332084e-02f,
  9.35017318e-02f, 3.97735275e-02f, 1.10379383e-01f, 1.11492813e-01f, 1.18779831e-01f, 9.95844528e-02f, -2.15930939e-02f, -3.83637846e-02f, -7.99590200e-02f, 5.86499013e-02f,
  -1.70310795e-01f, -6.73902631e-02f, 2.47107120e-03f, 1.20767184e-01f, -3.52753736e-02f, 4.68558632e-02f, 5.61763048e-02f, 1.62130520e-02f, 1.09737724e-01f, -6.95419386e-02f,
  -6.41260147e-02f, 2.18265038e-02f, 2.18771417e-02f, 9.79556423e-03f, 6.16442587e-04f, -1.09593749e-01f, 6.45731688e-02f, -2.19759028e-02f, -1.37109132e-02f, 3.19882110e-02f,
  1.14532702e-01f, -1.93249017e-01f, -1.72797218e-01f, 6.15194328e-02f, 3.09901852e-02f, 1.98950544e-02f, 2.60473834e-03f, -1.20156422e-01f, -7.35579655e-02f, -1.73647869e-02f,
  8.85087177e-02f, 2.27380022e-02f, -6.18116260e-02f, -2.23301053e-02f, 4.13950868e-02f, -2.49871910e-02f, 1.27249034e-02f, 4.78458293e-02f, 2.56616138e-02f, -3.57686169e-02f,
  -1.73828229e-02f, 2.63739713e-02f, -2.63738483e-02f, -6.55656122e-03f, 1.45540340e-02f, -4.72790077e-02f, -4.04960327e-02f, 9.32535976e-02f, 5.98214790e-02f, -3.32020521e-02f,
  -5.63266166e-02f, -2.74710432e-02f, -7.06553012e-02f, -7.59378029e-03f, -3.89961079e-02f, 6.25666827e-02f, 3.39800939e-02f, 5.66434264e-02f, -4.68101241e-02f, -4.67756763e-02f,
  2.86594272e-01f, -6.49419501e-02f, -2.25783419e-02f, 1.08148560e-01f, -9.09543335e-02f, 1.55566996e-02f, 5.54820895e-02f, -5.21685220e-02f, 5.80274016e-02f, 6.04964569e-02f,
  4.84709665e-02f, 1.84208304e-02f, 8.58892202e-02f, -7.26075843e-02f, -1.50110871e-01f, 1.19503587e-02f, 3.53461318e-02f, 1.01797961e-01f, 2.45039128e-02f, -1.07969798e-01f,
  1.00190351e-02f, 3.11287981e-03f, 5.52750826e-02f, 9.78550985e-02f, 3.08854319e-02f, 8.98706317e-02f, -6.27317354e-02f, 7.45555898e-03f, 5.17370589e-02f, 1.36809081e-01f,
  -2.03539878e-01f, 3.52579415e-01f, -2.29019105e-01f, 3.76957618e-02f, 1.54441357e-01f, 8.08195025e-02f, 1.81275278e-01f, 1.58214346e-02f, 7.64613450e-02f, 2.11836830e-01f,
  2.59615719e-01f, 3.00485194e-01f, 1.65929005e-01f, 1.39281377e-01f, -3.09020430e-02f, 9.26966444e-02f, -1.46358609e-01f, -2.74957329e-01f, -2.76138514e-01f, -2.45807040e-03f,
  1.59037009e-01f, 1.65405460e-02f, -1.34652615e-01f, -1.46945324e-02f, 2.22937405e-01f, 1.52706578e-01f, 5.95984049e-02f, 6.45603314e-02f, 4.37349267e-02f, 9.50100794e-02f,
  1.55082569e-01f, 1.53236464e-01f, -8.80029723e-02f, 1.04627855e-01f, 1.62998095e-01f, -3.50937434e-02f, 2.96252780e-02f, 3.64062749e-02f, 1.04225263e-01f, 1.23484209e-02f,
  9.82949361e-02f, 1.04068607e-01f, 1.49212196e-01f, 1.61140740e-01f, 1.69325259e-03f, -3.62159079e-03f, 2.66383067e-02f, -6.15534596e-02f, -6.86385557e-02f, 1.01760231e-01f,
  2.18854547e-01f, 1.82026550e-01f, 5.88061474e-03f, -3.91146988e-02f, 5.05093560e-02f, -2.30785552e-02f, 8.29735249e-02f, -3.16534936e-02f, 3.05795036e-02f, 1.14633501e-01f,
  -3.46799307e-02f, -9.20127407e-02f, -2.82223951e-02f, -6.51252270e-02f, -3.25850919e-02f, 1.72021259e-02f, 1.46520592e-03f, -2.13827612e-03f, -7.70338774e-02f, -9.01916549e-02f,
  -1.93787143e-02f, -1.43708989e-01f, -3.57528962e-02f, -6.35871962e-02f, 1.47457542e-02f, -6.67198524e-02f, -4.08497490e-02f, 2.11504120e-02f, -2.60867812e-02f, -1.11455068e-01f,
  -4.39700782e-02f, -6.05486371e-02f, -7.20474962e-03f, -1.44356251e-04f, -7.53157884e-02f, -8.00084844e-02f, -1.16124272e-01f, -8.57509077e-02f, -4.56770696e-02f, -1.04002632e-01f,
  1.04022779e-01f, -1.35301113e-01f, 1.18363157e-01f, 1.41113535e-01f, 8.61525442e-03f, 9.76392776e-02f, 1.35840923e-01f, 2.26178188e-02f, 1.12755135e-01f, 4.67014238e-02f,
  6.62186146e-02f, 5.03099971e-02f, 1.71043813e-01f, 3.94784808e-02f, 1.16169855e-01f, 1.18973270e-01f, 4.70826291e-02f, 2.45792232e-02f, -9.67224408e-03f, 1.02391988e-01f,
  1.12533256e-01f, 3.58505286e-02f, -3.73540968e-02f, 4.88828421e-02f, 1.10843606e-01f, -1.42494228e-03f, 1.08869068e-01f, 9.18113962e-02f, -4.41313200e-02f, 2.18262188e-02f,
  4.17095989e-01f, 2.58804619e-01f, -1.66581329e-02f, 5.70065200e-01f, 1.10589908e-02f, -1.06294692e-01f, -1.43037319e-01f, 1.39812693e-01f, 4.05645341e-01f, 1.16970964e-01f,
  1.88251957e-01f, 3.92334193e-01f, 4.06137049e-01f, 2.75908440e-01f, 2.50677884e-01f, 3.61698493e-02f, 2.81411678e-01f, 1.21507205e-01f, 1.97510570e-02f, -1.21771179e-01f,
  1.36244521e-01f, 1.90086201e-01f, 3.08688492e-01f, 2.21862331e-01f, 2.14743987e-01f, 1.33450493e-01f, 1.59671992e-01f, 1.55398816e-01f, 4.43830304e-02f, 3.56527388e-01f,
  -8.95427167e-02f, 1.69478640e-01f, 7.83798620e-02f, 3.09132755e-01f, 7.65863061e-02f, 1.30514920e-01f, 1.69564858e-01f, 2.37361118e-01f, 1.64161772e-01f, 1.77705109e-01f,
  2.52485842e-01f, 1.58068523e-01f, 1.15575738e-01f, 1.43874079e-01f, 1.13947555e-01f, 1.37869269e-01f, 2.51582623e-01f, 2.53401965e-01f, 2.91126966e-01f, 5.86375706e-02f,
  2.30381325e-01f, 1.37307569e-01f, 3.19575109e-02f, 1.63157716e-01f, 8.97349417e-02f, 1.53958753e-01f, 5.66341579e-02f, 1.47164896e-01f, 1.39443547e-01f, 2.73965597e-01f,
  -9.84163731e-02f, -1.70208558e-01f, -1.96834683e-01f, -1.36531204e-01f, -2.32354701e-01f, -1.44501880e-01f, -7.07329959e-02f, -1.43434420e-01f, -1.83990374e-01f, -2.68937141e-01f,
  -1.19287409e-01f, -1.48645580e-01f, -1.66754708e-01f, -1.09691851e-01f, -1.15095809e-01f, -1.28008172e-01f, -1.20649755e-01f, -1.46773666e-01f, -1.06623143e-01f, -1.36639655e-01f,
  -1.73564583e-01f, -1.80688158e-01f, -2.08056048e-01f, -1.23235464e-01f, -8.73366967e-02f, -1.65950254e-01f, -1.78335443e-01f, -1.63561538e-01f, -2.33537301e-01f, -2.15203092e-01f,
  3.18505496e-01f, 2.00346336e-01f, 2.27723286e-01f, 2.12999359e-01f, 1.63995922e-01f, 2.14175746e-01f, 1.69396117e-01f, 2.33470485e-01f, 2.29138061e-01f, 1.27891436e-01f,
  1.04236446e-01f, 1.23865180e-01f, 1.75374568e-01f, 1.55183077e-01f, 3.64644676e-02f, 1.68963432e-01f, 1.85837984e-01f, 2.75361151e-01f, 1.67558178e-01f, 1.31917372e-01f,
  1.62255824e-01f, 1.43033609e-01f, 1.76603913e-01f, 2.09857345e-01f, 1.70653298e-01f, 2.20765635e-01f, 1.17897294e-01f, 4.94988933e-02f, 8.90440792e-02f, 1.21547863e-01f,
  -4.70624119e-01f, 1.89601675e-01f, -3.77700552e-02f, -1.73316538e-01f, 1.25015020e-01f, 1.57117829e-01f, 7.28456378e-02f, 1.66104119e-02f, -1.56070724e-01f, -3.40394787e-02f,
  -3.20847631e-02f, -6.72196224e-02f, -6.60448298e-02f, 4.42908332e-02f, -1.25840877e-03f, 1.54906169e-01f, 6.18597865e-02f, -1.04676951e-02f, -4.53822240e-02f, -7.72043318e-02f,
  8.68554600e-03f, -5.79408742e-02f, -2.40068316e-01f, -5.90437241e-02f, -8.54478702e-02f, -7.61426613e-02f, -8.98152366e-02f, 7.08227456e-02f, 6.44536987e-02f, 1.53949946e-01f,
  -1.94784239e-01f, 4.91179042e-02f, -6.63001509e-03f, -8.95743221e-02f, -2.00843532e-02f, -3.23985405e-02f, -2.02717837e-02f, -2.74377633e-02f, 2.82704085e-02f, -6.73646852e-02f,
  1.91258714e-02f, -3.34564596e-02f, 4.35778871e-02f, 4.38822247e-03f, -1.42953306e-01f, -6.32426813e-02f, -1.27860382e-01f, -6.57025957e-03f, 1.93290208e-02f, -3.75547446e-02f,
  1.43201783e-01f, 8.58220309e-02f, 1.46105411e-02f, -1.61665604e-02f, -8.15120339e-02f, -1.03022166e-01f, -9.38758627e-02f, 1.32493284e-02f, -1.23156376e-01f, -2.38549620e-01f,
  -2.92410273e-02f, 5.88159002e-02f, 5.84189314e-03f, -3.97363789e-02f, -2.65820734e-02f, -4.99376357e-02f, 4.26541455e-02f, 1.10022081e-02f, 2.84135882e-02f, -1.00160865e-02f,
  9.23005864e-03f, 4.49070632e-02f, -2.74480842e-02f, -3.49044390e-02f, -4.73186783e-02f, 6.52182102e-02f, 2.62856912e-02f, 4.66019027e-02f, 3.33768688e-02f, -5.04451990e-03f,
  6.70501739e-02f, 2.68545933e-02f, -2.97247600e-02f, 4.47733700e-02f, 4.17403206e-02f, 7.95945376e-02f, 2.75059137e-02f, 3.32976840e-02f, 1.91922691e-02f, -1.10874244e-03f,
  -2.11651206e-01f, 5.51045649e-02f, -1.05814517e-01f, -3.31661776e-02f, -6.12565987e-02f, -8.34091827e-02f, -4.02528420e-02f, 2.18077749e-02f, -1.77186225e-02f, 3.32393288e-03f,
  -5.87540008e-02f, -1.14948288e-01f, -4.34474573e-02f, 1.64359361e-02f, -1.63354240e-02f, -5.69654629e-02f, 1.39482170e-02f, -6.73536025e-03f, -5.24639376e-02f, -1.00066751e-01f,
  -2.80208588e-02f, -6.50433153e-02f, -1.43652126e-01f, -7.82384817e-03f, -1.00988343e-01f, -1.14804208e-01f, -1.31906986e-01f, -1.08802617e-01f, -8.47872645e-02f, -2.64647722e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.77669215e-01f, -3.09268177e-01f, -3.61728698e-01f, 1.54644072e-01f, 3.16516101e-01f, -2.95031041e-01f, -6.79049551e-01f, -3.98172915e-01f, 1.83681682e-01f, -2.03075707e-01f,
  1.81597710e-01f, 3.77776414e-01f, -4.37881202e-02f, -6.46517798e-02f, -4.60951328e-01f, -3.94430608e-01f, -2.89369196e-01f, -3.33984464e-01f, -5.37565351e-02f, 1.98755428e-01f,
  2.97329873e-01f, 7.84406215e-02f, -4.66167517e-02f, -3.71219553e-02f, 3.05238008e-01f, 1.41788274e-01f, -6.33623004e-02f, 9.64762717e-02f, -1.24818027e-01f, 9.22201853e-03f,
  5.94772585e-02f, -1.02445260e-01f, 8.10650885e-02f, 3.08210701e-01f, 3.13329369e-01f, -2.34529853e-01f, -1.82984248e-01f, -1.18402652e-02f, -7.80189782e-02f, -1.94079742e-01f,
  2.33669907e-01f, 1.22862883e-01f, 1.13179304e-01f, -3.89951952e-02f, -5.91287203e-02f, -1.69061109e-01f, -1.45573005e-01f, -2.57930964e-01f, -2.74345875e-01f, -6.11481443e-03f,
  2.41677195e-01f, 2.18476623e-01f, -2.15559766e-01f, -2.42619142e-01f, -2.39818320e-01f, -9.51454416e-02f, -1.42116725e-01f, -6.88627362e-03f, -4.80162501e-01f, -3.11025053e-01f,
  7.99319670e-02f, 1.29309118e-01f, 9.85745639e-02f, -2.03927848e-02f, -9.18224826e-03f, 6.19075745e-02f, 4.34732251e-02f, 2.75540724e-02f, 7.08176941e-02f, 4.78247479e-02f,
  2.26929933e-02f, -1.00941800e-01f, 4.46514003e-02f, -8.98433849e-02f, 6.31681904e-02f, 7.49541819e-03f, 3.54743674e-02f, -1.21027336e-01f, -2.52350029e-02f, -7.69403949e-02f,
  -3.11051067e-02f, 2.22797468e-02f, 1.35503650e-01f, -1.22980000e-02f, -4.40421142e-02f, -1.39074668e-01f, 3.28150392e-02f, 7.83125162e-02f, 5.82095683e-02f, -1.78053826e-02f,
  7.47630969e-02f, -2.01643690e-01f, -1.08392581e-01f, -9.73020773e-03f, 7.87754580e-02f, 1.59426764e-01f, -1.05611168e-01f, -9.90642980e-02f, 2.73642391e-02f, -7.73869306e-02f,
  -4.24154140e-02f, -8.80285278e-02f, -6.76176101e-02f, -9.74615440e-02f, -7.41131157e-02f, -4.26730700e-02f, -1.12553246e-01f, -4.04814854e-02f, -1.68834120e-01f, 1.90490618e-01f,
  -1.83739245e-01f, -3.50154579e-01f, -3.07530463e-01f, -4.42178905e-01f, 3.57907917e-03f, -3.24075520e-01f, -3.01017970e-01f, -2.19380558e-01f, -5.73789120e-01f, -6.26051009e-01f,
  -2.49299601e-01f, 2.61322945e-01f, 9.23658311e-02f, -7.20210597e-02f, -9.59063917e-02f, -2.66827792e-01f, -1.41101047e-01f, -2.81043679e-01f, -1.53085545e-01f, 1.29719734e-01f,
  1.61389083e-01f, 9.77542475e-02f, -4.98339087e-02f, -1.69485703e-01f, -1.54018134e-01f, 2.80159321e-02f, -8.46431404e-02f, -1.83058694e-01f, -1.80924028e-01f, -1.82674695e-02f,
  8.11921060e-02f, 2.60306537e-01f, 5.38767092e-02f, -6.94991872e-02f, 2.51402885e-01f, 1.46869838e-01f, 1.74543098e-01f, 1.21435508e-01f, 7.49413371e-02f, 2.32511014e-01f,
  4.74913180e-01f, 1.69883352e-02f, -1.34896502e-01f, -1.34913519e-01f, 1.75389633e-01f, 1.44479677e-01f, 1.36691242e-01f, -1.85345544e-03f, 2.39888523e-02f, 1.74865842e-01f,
  1.32714808e-01f, 8.17335546e-02f, -4.38385643e-02f, 1.69114500e-01f, 7.05303475e-02f, 8.28339458e-02f, -3.25240642e-02f, -1.35368064e-01f, -1.49976268e-01f, 5.93448728e-02f,
  7.82760233e-02f, 7.94683769e-02f, -6.69776881e-03f, -2.20264509e-01f, -1.42730758e-01f, -1.67575002e-01f, -2.75029545e-03f, -4.14853431e-02f, -2.69846439e-01f, 2.58162059e-02f,
  -8.18401352e-02f, 8.63828659e-02f, -3.72310355e-02f, 1.81287050e-01f, 1.83450758e-01f, 1.56777412e-01f, 3.51365685e-01f, 2.88438976e-01f, 6.83382526e-02f, 4.62890491e-02f,
  9.99578014e-02f, 1.19843058e-01f, 3.34373921e-01f, 6.10523820e-02f, 5.11787757e-02f, 1.33808941e-01f, 2.65342534e-01f, 3.97795998e-02f, 1.90064803e-01f, 2.32182920e-01f,
  1.67805433e-01f, 1.11948336e-02f, 1.45820141e-01f, 1.07484080e-01f, 1.30891979e-01f, 5.07208556e-02f, 1.50864437e-01f, 1.99986279e-01f, 7.94025958e-02f, -2.38844659e-02f,
  4.15750474e-01f, -3.49850029e-01f, 1.85785815e-01f, -1.27795622e-01f, 1.33702949e-01f, -7.96076506e-02f, 7.67302960e-02f, 4.80167903e-02f, 1.23417810e-01f, 1.74857795e-01f,
  9.77963358e-02f, 7.91626498e-02f, 1.11116648e-01f, 1.01551466e-01f, 5.22791073e-02f, 4.64002416e-02f, 1.04620866e-01f, -7.14207441e-02f, -1.99436143e-01f, 1.49086475e-01f,
  -9.32896957e-02f, -1.86511636e-01f, -9.95465741e-02f, -1.95402443e-01f, -1.50661826e-01f, -1.57519773e-01f, 7.80583769e-02f, 2.89050583e-02f, -1.12794012e-01f, 1.63706943e-01f,
  -5.16400278e-01f, 1.35699272e-01f, 8.06028917e-02f, 1.39438882e-01f, 1.07364364e-01f, -3.43098909e-01f, -4.09370124e-01f, -2.80864894e-01f, -8.10193270e-03f, 2.22470924e-01f,
  1.66792706e-01f, 1.97270542e-01f, 1.67881489e-01f, -5.90542778e-02f, -3.92532825e-01f, -2.86701113e-01f, -3.21959257e-01f, -4.76592124e-01f, -4.98523921e-01f, -3.57415915e-01f,
  -1.44337550e-01f, -1.87879428e-01f, -3.67262065e-01f, -1.78140759e-01f, 2.65163779e-01f, 7.47233555e-02f, 1.90000877e-01f, -3.15476507e-02f, -1.10500075e-01f, 1.68819740e-01f,
  3.65431786e-01f, -2.86968440e-01f, -2.29628205e-01f, -1.45810828e-01f, -1.53170321e-02f, -1.25851616e-01f, -7.53659233e-02f, 5.05644381e-02f, -2.46968810e-02f, 5.70444278e-02f,
  -1.09003228e-03f, 7.93196112e-02f, -1.45464204e-02f, -1.25746131e-02f, 8.02515820e-02f, 3.00740320e-02f, 2.14363467e-02f, -1.29454862e-03f, -2.73864139e-02f, 8.53244588e-02f,
  7.65026510e-02f, -1.31296262e-01f, -2.35855356e-02f, -1.84879154e-01f, -1.68456137e-01f, -4.78163995e-02f, 1.76258665e-02f, -2.64730509e-02f, -8.48202705e-02f, 4.04795818e-02f,
  -1.22119188e-01f, -8.67043585e-02f, -9.67430416e-03f, 4.29143943e-03f, 3.04793324e-02f, 6.11749068e-02f, 3.14562693e-02f, -3.56699601e-02f, -5.82116842e-02f, 3.69965844e-02f,
  2.40738690e-01f, 7.74740195e-03f, -5.03934845e-02f, 1.03439108e-01f, -1.04452986e-02f, -7.92556554e-02f, -1.51740566e-01f, -7.38903955e-02f, -1.19819446e-03f, 5.12035638e-02f,
  3.53544555e-03f, -7.58066401e-02f, 1.30850673e-01f, 3.52602042e-02f, 1.28239226e-02f, -1.01980465e-02f, -3.87461297e-02f, -1.43942028e-01f, -3.44291516e-02f, 1.03582658e-01f,
  2.44996995e-01f, -1.96851298e-01f, 1.71412334e-01f, -6.69739693e-02f, 9.91460830e-02f, 9.30416062e-02f, 1.75997958e-01f, 9.54143330e-02f, 4.64401096e-02f, 2.28988770e-02f,
  -5.41337393e-02f, 2.53825486e-02f, 1.60680357e-02f, 1.57992229e-01f, 3.71922599e-03f, -2.52595972e-02f, -2.96912715e-02f, 2.14460656e-01f, 4.37271930e-02f, 2.01778516e-01f,
  1.17685959e-01f, -4.62944433e-02f, 4.63485122e-02f, 6.98675513e-02f, -4.85006981e-02f, -6.13884740e-02f, 2.18085364e-01f, 1.22856826e-01f, -6.39669225e-02f, 2.41637811e-01f,
  1.86510250e-01f, -5.87343216e-01f, 7.11603686e-02f, 4.18278784e-01f, 3.25895607e-01f, 2.14070246e-01f, 3.55195925e-02f, 1.28557300e-02f, 3.34998637e-01f, 3.71615253e-02f,
  3.50060724e-02f, 3.09525281e-01f, 2.74305552e-01f, 2.63089836e-01f, 8.81099775e-02f, 1.35553405e-01f, 2.09494874e-01f, 2.40390405e-01f, 3.52134258e-01f, 4.46397662e-02f,
  3.78938653e-02f, -3.25835049e-02f, -8.50125924e-02f, 3.70753370e-02f, -1.81512218e-02f, 2.88517326e-01f, -6.08902499e-02f, -5.24886437e-02f, -8.93488750e-02f, -2.57720184e-02f,
  -2.87331730e-01f, -1.52232111e-01f, 1.25126049e-01f, -1.12723291e-01f, -1.83520481e-01f, -1.19495295e-01f, 3.69767770e-02f, -1.49127558e-01f, -1.25220150e-01f, -9.34865326e-02f,
  -3.28252576e-02f, -9.97780263e-02f, -4.57466394e-02f, -1.34301051e-01f, -1.46472260e-01f, -8.98079202e-02f, -4.91013713e-02f, 5.64691378e-03f, -4.00702134e-02f, -1.76757518e-02f,
  -3.81790437e-02f, 1.58807993e-01f, 1.26983866e-01f, 7.66808987e-02f, 7.73740485e-02f, 9.36109051e-02f, -1.13118649e-01f, -8.44592154e-02f, 1.70453060e-02f, -2.28644516e-02f,
  2.61074215e-01f, 2.28236124e-01f, 2.04839483e-01f, 1.50460705e-01f, 1.55438811e-01f, 1.45844162e-01f, 1.38162777e-01f, 3.56973447e-02f, 1.63966849e-01f, 1.40179977e-01f,
  1.58869848e-02f, 1.26571223e-01f, 1.83704793e-01f, 2.63946969e-02f, 1.46309480e-01f, 1.55278742e-01f, 2.98617389e-02f, -5.74070998e-02f, 9.21777263e-02f, 1.24765523e-02f,
  1.55316561e-01f, -1.41495332e-01f, -1.54655471e-01f, -8.71981010e-02f, -9.33638960e-02f, 1.15976140e-01f, 4.13822681e-02f, 8.10807757e-03f, -5.78237176e-02f, -2.31025275e-02f,
  -2.09057137e-01f, 5.33742070e-01f, 2.47640193e-01f, 1.16627946e-01f, -8.96663144e-02f, -7.21587464e-02f, 1.62374616e-01f, -9.16693658e-02f, -3.18026155e-01f, -4.93396856e-02f,
  -1.00893050e-01f, -1.47810310e-01f, -3.54916863e-02f, -2.85300147e-02f, 1.13381995e-02f, -1.89301260e-02f, -3.08409967e-02f, 1.20099165e-01f, 8.16045776e-02f, -1.32626981e-01f,
  -3.14721242e-02f, 1.47147775e-01f, 3.16296846e-01f, 2.62779534e-01f, 2.06761345e-01f, 2.05288410e-01f, 9.15645882e-02f, 8.95577595e-02f, 1.55899286e-01f, 4.08463962e-02f,
  -9.77597117e-01f, 5.17953217e-01f, 4.51704115e-01f, -6.66129649e-01f, 7.84326792e-02f, 3.50028098e-01f, 5.40600121e-01f, 6.51538596e-02f, -2.80432791e-01f, 9.51083302e-02f,
  1.79911584e-01f, -1.31787762e-01f, 8.29165503e-02f, 6.49545640e-02f, 1.32395342e-01f, 4.07062739e-01f, 3.23025048e-01f, -2.08731830e-01f, -4.04176921e-01f, -2.07034826e-01f,
  -6.80512562e-02f, -4.90594268e-01f, -5.30127347e-01f, -2.60309815e-01f, -1.10177835e-02f, -9.21617672e-02f, 1.51246756e-01f, -5.82482740e-02f, 1.96527228e-01f, 4.61874008e-02f,
  2.72907674e-01f, -1.46371469e-01f, -2.36759752e-01f, -1.44348711e-01f, 1.13974296e-01f, -1.48200884e-01f, -1.59672752e-01f, -1.27157167e-01f, -3.13868187e-02f, -6.09427467e-02f,
  -4.62959558e-02f, -2.69060396e-02f, -2.89399922e-02f, 9.71471444e-02f, 7.14516686e-03f, -3.52413841e-02f, 1.06707759e-01f, -1.37065992e-01f, -2.16677710e-02f, 2.66990155e-01f,
  3.02730411e-01f, -7.68570453e-02f, -7.02661276e-02f, 1.48708194e-01f, 2.31514752e-01f, -1.40729263e-01f, 2.33075336e-01f, 1.26581537e-02f, -4.80150105e-03f, -2.31953397e-01f,
  -1.57364070e-01f, 1.34946955e-02f, 6.65540844e-02f, -7.66878724e-02f, -2.09756177e-02f, 6.54104128e-02f, -1.05860140e-02f, 2.76070368e-03f, -4.95018512e-02f, -1.11964168e-02f,
  -2.15340145e-02f, 3.43779996e-02f, -3.16971205e-02f, -4.46210988e-02f, -6.50839731e-02f, -8.25021863e-02f, -1.22713432e-01f, -3.94809321e-02f, 5.10775372e-02f, 1.74611318e-03f,
  -1.18298113e-01f, -9.12129432e-02f, -3.08548417e-02f, 6.45114556e-02f, 2.58121397e-02f, -6.73187431e-03f, -4.59083095e-02f, 3.59416716e-02f, -5.78050502e-02f, 1.35309085e-01f,
  -1.81787550e-01f, -1.06388167e-03f, -1.23036109e-01f, 7.37215206e-02f, 1.37403846e-01f, 1.42599732e-01f, -4.04039398e-02f, -1.21386051e-01f, -3.01130805e-02f, 3.43275927e-02f,
  1.37727773e-02f, -8.80361944e-02f, 5.23199476e-02f, 4.55392431e-03f, -1.48194060e-01f, 2.82969158e-02f, 1.08624712e-01f, -8.20928216e-02f, 1.13458142e-01f, 1.75957650e-01f,
  1.73585951e-01f, -1.06497690e-01f, -4.31884855e-01f, 5.75193902e-03f, 1.85347740e-02f, -3.53838205e-01f, 5.16287163e-02f, -9.98632014e-02f, 1.64689217e-02f, -1.35683864e-01f,
  5.10442257e-01f, 3.70050281e-01f, 1.60893738e-01f, 1.74677357e-01f, 1.33352444e-01f, 3.40380013e-01f, 6.19126260e-01f, 3.18542838e-01f, 2.30477639e-02f, 1.57279428e-02f,
  -4.15151954e-01f, -6.73137486e-01f, -4.95547503e-01f, -4.23675835e-01f, -1.64772850e-02f, 3.89115810e-01f, 2.51911432e-01f, 9.99878049e-02f, -5.12503497e-02f, -1.59178600e-02f,
  -3.76172885e-02f, 3.92795831e-01f, 2.89991736e-01f, 9.63488594e-02f, 3.28946337e-02f, -2.66180158e-01f, 1.45157233e-01f, 1.81137025e-01f, 7.06572309e-02f, 9.11687128e-03f,
  -4.35368031e-01f, 3.53957802e-01f, -3.48195821e-01f, -1.96103245e-01f, -2.54534006e-01f, -1.51498929e-01f, -1.06263414e-01f, -1.60745576e-01f, -2.31601968e-01f, 1.22067921e-01f,
  -4.81444709e-02f, -1.09521355e-02f, -1.82248682e-01f, 1.32919729e-01f, 2.45176882e-01f, -3.04122511e-02f, 2.87727088e-01f, 1.84026193e-02f, -1.43458873e-01f, -1.20588109e-01f,
  -2.66723722e-01f, 6.00631796e-02f, 1.38483822e-01f, 3.65831773e-03f, -5.40526658e-02f, -2.35754594e-01f, 6.90306798e-02f, 2.26833317e-02f, -8.95903409e-02f, 8.38703215e-02f,
  -3.30617666e-01f, 9.35227275e-02f, 1.87822312e-01f, 6.01390004e-02f, 1.41602442e-01f, -1.06598027e-02f, -5.79299219e-02f, -1.40596945e-02f, 9.71295163e-02f, 1.77192569e-01f,
  -9.77637023e-02f, -1.56224996e-01f, -1.48869336e-01f, -1.59165263e-01f, -2.76884377e-01f, 1.48871669e-03f, 1.32505536e-01f, 9.58904251e-02f, 5.52655309e-02f, 7.15573579e-02f,
  1.52748069e-02f, -2.64970958e-02f, -6.46651164e-02f, -6.64421022e-02f, -4.78407927e-02f, -1.33766666e-01f, -3.04380637e-02f, -1.24328338e-01f, -1.39153479e-02f, -1.58160619e-04f,
  -1.28978863e-01f, -2.53874868e-01f, -2.53871471e-01f, -1.08902631e-02f, 6.26325011e-02f, -1.74381003e-01f, -2.55813688e-01f, -1.20802596e-01f, 1.26269169e-03f, -1.01380587e-01f,
  7.34313726e-02f, -1.53983369e-01f, -1.69728473e-01f, 3.33990622e-03f, -1.33380488e-01f, 1.55428518e-02f, 6.50899261e-02f, 5.31126093e-03f, -4.06425744e-02f, -5.79523705e-02f,
  3.56665552e-02f, 1.05705306e-01f, 8.49335343e-02f, -4.69624102e-02f, -2.33422831e-01f, -2.56700695e-01f, 8.16407800e-02f, 6.50883690e-02f, 7.54163191e-02f, 3.77736419e-01f,
  -7.40686119e-01f, 1.16751164e-01f, -1.29678935e-01f, -2.39442289e-01f, -2.47393310e-01f, -2.11176932e-01f, -7.56182373e-02f, -9.89407450e-02f, -1.35484263e-01f, 8.44331284e-04f,
  1.08822450e-01f, 1.61212182e-03f, -1.17001064e-01f, -2.21442282e-01f, -2.94441462e-01f, -2.00279802e-01f, -3.40395868e-01f, -5.40447295e-01f, -4.94328320e-01f, -5.58278896e-02f,
  -1.04900546e-01f, -3.54288131e-01f, -4.04691219e-01f, -1.56377137e-01f, 1.63012415e-01f, -2.03085631e-01f, -1.85911357e-01f, -2.17882872e-01f, -2.47992173e-01f, -1.11050926e-01f,
  3.98074120e-01f, -5.79220848e-03f, -8.10653120e-02f, -1.63056388e-01f, 3.99817005e-02f, 6.36697793e-03f, -1.38626210e-02f, 3.82570550e-02f, 3.55569124e-02f, 1.69949025e-01f,
  -3.42588522e-03f, -3.52557451e-02f, -4.81243469e-02f, 2.05599785e-01f, 4.46612686e-02f, 1.19924486e-01f, 2.00730801e-01f, 8.71022269e-02f, 2.33327132e-02f, 2.81742245e-01f,
  1.15601487e-01f, -1.02109879e-01f, 1.59057863e-02f, 8.05114284e-02f, 3.75689454e-02f, -1.41526401e-01f, 2.23577872e-01f, 1.03905737e-01f, 1.17539624e-02f, 2.07677096e-01f,
  1.45266324e-01f, 1.71373799e-01f, 1.36884078e-01f, 1.03097595e-01f, 3.54677550e-02f, 6.80810437e-02f, 1.17644362e-01f, 5.82277924e-02f, -1.19147129e-01f, 2.44772770e-02f,
  1.66572213e-01f, 4.38073836e-03f, 7.85047561e-03f, -1.72549463e-03f, -2.47887131e-02f, 1.30168162e-02f, -3.72046605e-02f, 1.83567196e-01f, 5.27641401e-02f, -5.50233945e-02f,
  -1.75336134e-02f, 6.05918653e-03f, -9.23781916e-02f, 7.92402774e-02f, 1.15053602e-01f, 1.47859111e-01f, 9.04503018e-02f, -1.65735284e-04f, -8.65395814e-02f, -7.51516670e-02f,
  3.10719669e-01f, -4.51129436e-01f, 7.51129389e-02f, 2.18361095e-02f, -1.30020499e-01f, 9.48952958e-02f, 7.62031153e-02f, -2.85655782e-02f, 1.70149989e-02f, 1.48052752e-01f,
  -2.44780467e-03f, 5.58202993e-03f, 1.70092843e-02f, 1.95395112e-01f, -1.15474738e-01f, -2.10644528e-02f, 3.04179043e-02f, 8.02358333e-03f, -4.60517220e-02f, 3.16742152e-01f,
  6.82542548e-02f, -1.29881993e-01f, 1.30002135e-02f, 1.09360076e-01f, 3.13188657e-02f, -1.58130556e-01f, 4.09327634e-02f, 1.78242728e-01f, -1.18228577e-01f, 1.67120591e-01f,
  7.04910874e-01f, -2.26609722e-01f, -3.25312883e-01f, 1.26729324e-01f, -8.79214518e-03f, -3.09488356e-01f, -5.88503480e-01f, -2.90325671e-01f, 2.31794700e-01f, -1.74688548e-01f,
  1.63314566e-01f, 4.42627877e-01f, 2.50309557e-01f, -7.39191100e-02f, -4.74181503e-01f, -6.56807482e-01f, -6.48192644e-01f, -4.03239906e-01f, -3.45546365e-01f, -2.75587052e-01f,
  4.43594009e-02f, 8.25843122e-03f, -4.38504554e-02f, -1.79440185e-01f, 2.12894138e-02f, 1.64053917e-01f, -8.36357027e-02f, -3.09017021e-03f, -2.25530609e-01f, 3.05035673e-02f,
  -3.03778619e-01f, -1.34921640e-01f, -3.41773033e-02f, 1.51606277e-01f, 1.64357394e-01f, 1.70378536e-01f, 1.72495935e-02f, -4.15238831e-03f, 1.75246149e-01f, -1.30815834e-01f,
  1.23612188e-01f, -2.55096555e-02f, 1.04938015e-01f, -9.60567072e-02f, -2.36017928e-01f, -1.55220911e-01f, -1.87724888e-01f, -2.22894818e-01f, -7.53931552e-02f, -2.27985129e-01f,
  -5.28084710e-02f, 2.50210352e-02f, -1.04452595e-01f, -2.24172682e-01f, -3.49959940e-01f, 6.26529083e-02f, -2.98119932e-01f, -1.39530152e-01f, -2.88266599e-01f, -1.30375624e-01f,
  -2.71721333e-01f, -1.00032173e-01f, -5.61685339e-02f, 3.24533284e-02f, 1.41964838e-01f, 6.89589232e-03f, -1.19679654e-02f, -1.35779649e-01f, 4.41026762e-02f, -3.77821252e-02f,
  -7.82275870e-02f, 1.58018563e-02f, 4.04639468e-02f, -2.45621637e-01f, -1.46926984e-01f, -6.67992458e-02f, 5.03642969e-02f, -1.75699443e-01f, -1.13936931e-01f, 6.61275014e-02f,
  -2.05000304e-02f, -4.80238311e-02f, 1.60169825e-01f, 7.56524317e-03f, -1.26902968e-01f, -1.40292153e-01f, -4.13780585e-02f, -6.61362708e-02f, -1.53601691e-02f, -7.62256682e-02f,
  2.18448997e-01f, -7.76735181e-03f, 8.67017582e-02f, -1.71707377e-01f, -4.63854298e-02f, 5.68979755e-02f, 2.98169851e-01f, -5.78869916e-02f, 2.57381529e-01f, 2.58979350e-02f,
  -3.31653625e-01f, -1.59565687e-01f, -2.15233602e-02f, 1.21181875e-01f, -9.45568383e-02f, -6.48977309e-02f, -7.10009784e-02f, 7.68295303e-02f, -1.19707391e-01f, 4.45753299e-02f,
  -8.62071365e-02f, -1.18042402e-01f, 1.68430477e-01f, 7.62973074e-03f, -2.25736663e-01f, 1.50814086e-01f, -1.25798419e-01f, -4.73444276e-02f, -2.24424988e-01f, -2.19103515e-01f,
  -6.44204557e-01f, -4.09884658e-03f, -6.62951291e-01f, 1.72954917e-01f, 4.73046973e-02f, -1.35096014e-01f, 8.50263536e-02f, 1.46093264e-01f, 1.32049277e-01f, 3.52713354e-02f,
  -7.24168494e-02f, -2.09032707e-02f, -5.02945893e-02f, 9.19638872e-02f, -4.40435521e-02f, 1.14362620e-01f, 3.61301601e-01f, -1.65892556e-01f, -2.02482387e-01f, 5.10619916e-02f,
  3.57986033e-01f, 2.37668678e-01f, -5.15238196e-02f, 1.48622572e-01f, 1.91724360e-01f, 1.25388145e-01f, 1.03970557e-01f, 2.89287372e-03f, -6.39922451e-03f, 2.32743155e-02f,
  -7.28808939e-01f, -4.26945269e-01f, -3.17046233e-02f, -1.38919115e-01f, -1.75842628e-01f, -1.31324336e-01f, -1.13497593e-01f, -2.07588777e-01f, 8.21538866e-02f, 2.36908663e-02f,
  -5.69620840e-02f, -6.94967285e-02f, 7.34930485e-02f, 1.36741936e-01f, 5.40986881e-02f, -1.67395562e-01f, 1.01490341e-01f, -1.22813284e-01f, -1.99334055e-01f, -3.50231558e-01f,
  1.59942120e-01f, -3.35879207e-01f, -5.15575111e-01f, 5.36586642e-02f, -1.19443737e-01f, 2.92945486e-02f, -1.66195557e-01f, -2.18625113e-01f, -2.90539175e-01f, -3.00677866e-01f,
  -1.03215404e-01f, 6.20423965e-02f, 1.26867024e-02f, 6.00292385e-02f, 1.52409941e-01f, 1.99092813e-02f, 1.70033321e-01f, 1.09674282e-01f, 7.75906146e-02f, -7.48454556e-02f,
  -6.82851449e-02f, -1.64644286e-01f, -7.61047229e-02f, -1.11686476e-01f, 8.38811398e-02f, 2.81586107e-02f, -6.41349852e-02f, 8.53560641e-02f, -4.38992772e-03f, 6.35729432e-02f,
  -3.74380574e-02f, -1.02943137e-01f, 1.76335469e-01f, 9.57182199e-02f, -9.75623354e-02f, 1.86772589e-02f, -1.87836997e-02f, -1.10220186e-01f, -3.41701061e-02f, -7.73400962e-02f,
  2.93459952e-01f, 2.06455559e-01f, -1.93064958e-01f, 9.95713398e-02f, -1.28254995e-01f, 1.27624601e-01f, 1.04621157e-01f, 4.25492115e-02f, 6.61181659e-02f, 5.23956213e-03f,
  -7.31554553e-02f, 5.09107411e-02f, 2.72264063e-01f, 1.44845083e-01f, 5.46493083e-02f, -4.90193628e-02f, 2.05750912e-01f, -1.76062241e-01f, 1.67991504e-01f, -1.13509977e-02f,
  2.48285875e-01f, -5.74159510e-02f, -2.73310125e-01f, -1.30415782e-01f, -3.06187700e-02f, -4.13150527e-02f, -9.74058136e-02f, -1.14304371e-01f, -1.87809527e-01f, -6.79795668e-02f,
  -6.07972562e-01f, -2.54433155e-01f, -3.73249829e-01f, -1.85868919e-01f, -5.06326668e-02f, 3.77712362e-02f, 2.36272276e-03f, 4.46936451e-02f, -2.90355980e-01f, -3.50599468e-01f,
  -1.89731106e-01f, -8.60439464e-02f, -2.24534824e-01f, 8.45202804e-02f, 1.78169325e-01f, -7.17553124e-03f, 1.46433502e-01f, 1.60993859e-01f, 2.69921482e-01f, 4.42823678e-01f,
  1.98901743e-01f, -1.22786313e-02f, 6.22827895e-02f, 2.65677214e-01f, -5.20877875e-02f, -3.16720991e-03f, -1.69800714e-01f, -3.88198495e-02f, 1.26860380e-01f, 7.08702952e-02f,
  -4.52265799e-01f, -2.28770226e-01f, 7.57607520e-02f, 2.28140224e-02f, -1.36409089e-01f, -1.39610246e-01f, 3.21428701e-02f, -1.12382151e-01f, -2.44471096e-02f, -1.52347416e-01f,
  -4.79722768e-02f, -7.20067471e-02f, -1.85371473e-01f, 3.30682360e-02f, -1.45199999e-01f, -2.06599962e-02f, -2.11866833e-02f, 1.50493219e-01f, -1.10971816e-01f, -4.50264402e-02f,
  2.87314743e-01f, 1.09282851e-01f, -2.54495233e-01f, 4.61199023e-02f, -3.94740924e-02f, -7.72824660e-02f, 1.19326338e-02f, 6.07031211e-02f, -9.47562531e-02f, -2.28634641e-01f,
  8.07276648e-03f, -5.05488962e-02f, -1.34426713e-01f, -9.22591612e-02f, -8.09280109e-03f, -1.21510744e-01f, 1.36907697e-01f, -3.53860073e-02f, -4.67371903e-02f, -2.99174134e-02f,
  8.79464149e-02f, -5.06168045e-02f, 7.30191544e-02f, -7.64899142e-03f, 1.32313967e-01f, -7.65131414e-02f, 9.03154984e-02f, 6.05540164e-02f, 9.98516753e-02f, -1.40113356e-02f,
  3.58800255e-02f, -4.55016308e-02f, -1.01202905e-01f, 1.67269289e-01f, -4.57948670e-02f, 1.19442761e-01f, 1.25865145e-02f, -5.50692566e-02f, -9.74321887e-02f, -9.29758400e-02f,
  -4.27972853e-01f, 1.22497492e-01f, -4.12857682e-01f, 3.58371548e-02f, -1.99459493e-02f, 5.80150820e-02f, 1.65245291e-02f, 9.17861760e-02f, -1.82044879e-01f, 1.02550620e-02f,
  1.13168798e-01f, 1.93924271e-02f, -2.58472562e-01f, 2.23549418e-02f, -8.22357461e-02f, -1.35816708e-01f, -1.19353876e-01f, -1.28314525e-01f, -1.01914518e-01f, -5.31625077e-02f,
  -1.50744161e-02f, -5.24657853e-02f, -4.11650002e-01f, -3.42661768e-01f, -3.13782752e-01f, -2.41049632e-01f, -2.75168031e-01f, -2.16293126e-01f, -2.94320971e-01f, -3.64488363e-01f,
  5.13685465e-01f, 1.03658721e-01f, -1.89425305e-01f, 2.76954830e-01f, 8.63152146e-02f, -6.58694282e-02f, -2.15663940e-01f, -7.56298006e-02f, 1.13045759e-01f, 2.88909763e-01f,
  3.31685334e-01f, 4.67549503e-01f, 2.48597980e-01f, 2.50298470e-01f, 4.32420522e-02f, -1.07208565e-01f, -7.12674260e-02f, 9.43984315e-02f, 8.72608200e-02f, 2.01015726e-01f,
  3.54714334e-01f, 2.43188933e-01f, 1.29145414e-01f, 8.63564759e-02f, 2.49219999e-01f, 2.99622804e-01f, 4.09455933e-02f, 1.72608867e-01f, 2.70224601e-01f, 3.63808811e-01f,
  2.66212463e-01f, 2.93538384e-02f, -4.26040366e-02f, 4.82923761e-02f, -1.10757798e-01f, -9.80446935e-02f, -3.22058275e-02f, -1.49991333e-01f, -3.29664201e-02f, -1.58618391e-01f,
  4.61006612e-02f, -9.00382549e-02f, 6.00195043e-02f, -8.76391828e-02f, -3.63262035e-02f, -3.02771665e-03f, 1.94311272e-02f, -1.41041055e-01f, 5.38410209e-02f, 4.09387723e-02f,
  1.74591914e-01f, 3.46460678e-02f, -2.11140677e-01f, -4.29691337e-02f, 5.78405149e-02f, 9.71031785e-02f, -5.31786866e-02f, -4.64486470e-03f, -3.33798602e-02f, -1.76386423e-02f,
  1.98106453e-01f, 9.48399827e-02f, 2.09354654e-01f, 1.75103724e-01f, 2.25296825e-01f, 1.67036310e-01f, -8.80111456e-02f, -6.92375749e-03f, 5.71467765e-02f, -1.16396872e-02f,
  -9.62739065e-02f, 6.84031323e-02f, -2.18163617e-02f, -2.36449894e-02f, 1.52853593e-01f, -1.12117939e-02f, -1.31858230e-01f, -9.86056253e-02f, -9.86763984e-02f, -1.05785236e-01f,
  -1.59004927e-02f, -1.61189482e-01f, -1.18749030e-01f, -2.01281771e-01f, -1.22240037e-01f, -7.54359588e-02f, 1.72237381e-02f, -2.02910788e-03f, 1.35504484e-01f, 1.59760267e-02f,
  -2.37222046e-01f, -2.90853996e-02f, 1.66909531e-01f, -1.05304673e-01f, -8.35831687e-02f, -3.95957672e-04f, 1.63109079e-02f, -1.43881813e-01f, -1.53283570e-02f, -3.83762792e-02f,
  -9.23020393e-02f, -8.40687826e-02f, 2.28826888e-02f, -6.25446290e-02f, -4.88550663e-02f, -1.15252115e-01f, -6.97532222e-02f, -9.16656330e-02f, -1.33487219e-02f, -2.24977598e-01f,
  -1.32486328e-01f, -2.67143577e-01f, -2.13044569e-01f, -1.40080959e-01f, -7.60573670e-02f, -7.20643178e-02f, -3.54197249e-02f, -8.60479325e-02f, -9.98608470e-02f, -1.97199509e-01f,
  6.88113570e-02f, 3.58017862e-01f, -6.17739439e-01f, 4.62039024e-01f, -3.66446935e-02f, -4.84309822e-01f, -4.09256756e-01f, -2.77051151e-01f, 3.21185924e-02f, 1.55430138e-02f,
  -1.09664522e-01f, -1.16115607e-01f, -1.22033000e-01f, -8.66277441e-02f, -2.90132195e-01f, 1.27845660e-01f, 3.07689756e-01f, -1.11498281e-01f, -3.72280508e-01f, -7.55058005e-02f,
  4.05692369e-01f, 3.45254511e-01f, 2.04798102e-01f, 6.70331717e-02f, 4.17338997e-01f, 2.21123189e-01f, 1.60075977e-01f, 2.44293645e-01f, 5.43079060e-03f, 4.81323242e-01f,
  -1.77091420e-01f, -1.82685852e-01f, -1.88926309e-01f, 1.07250504e-01f, -4.89564873e-02f, -2.11289644e-01f, -1.82091877e-01f, -3.80091928e-02f, -1.86750352e-01f, -1.20087139e-01f,
  -6.57958463e-02f, -8.31134841e-02f, -8.20894837e-02f, 7.90103003e-02f, 4.69555752e-03f, -3.24567795e-01f, 2.79256105e-02f, -9.33594406e-02f, -1.90688491e-01f, -2.88325399e-01f,
  2.28306100e-01f, 4.02134918e-02f, -3.24984878e-01f, -2.34848052e-01f, -4.01403397e-01f, -1.79285929e-01f, -3.23845506e-01f, -1.99315026e-01f, -4.64850754e-01f, 1.32573366e-01f,
  -1.50932595e-01f, -6.65526465e-02f, 3.60119157e-02f, -7.13984594e-02f, 2.51124799e-02f, -8.49932656e-02f, 1.01288902e-02f, 7.18631446e-02f, -1.02657422e-01f, -5.75270243e-02f,
  -8.00995529e-02f, -6.18424602e-02f, -1.56509131e-01f, -1.24753460e-01f, 4.71162796e-03f, 1.15411784e-02f, 1.80258658e-02f, 2.13489488e-01f, -5.20773605e-02f, -1.02592841e-01f,
  4.69619669e-02f, -4.78866585e-02f, 1.11985877e-01f, 3.88083346e-02f, 5.42511679e-02f, -1.56366810e-01f, 1.56467289e-01f, -4.97397371e-02f, -2.47307029e-02f, 3.74563993e-03f,
  3.15759301e-01f, -3.10240984e-01f, 1.55648336e-01f, 5.51688708e-02f, 4.07351255e-02f, -2.38310814e-01f, -6.79901540e-02f, -1.40300840e-01f, -8.25605318e-02f, -1.80406108e-01f,
  -2.59037912e-01f, -2.73043275e-01f, 1.68001838e-02f, -9.25481617e-02f, -5.27967587e-02f, -8.48018453e-02f, 2.85906971e-01f, 3.27545851e-02f, 1.12701736e-01f, -8.91228840e-02f,
  3.26267242e-01f, -2.17027348e-02f, -2.14909054e-02f, -2.00378254e-01f, -1.15933716e-01f, -1.23080686e-01f, -1.62440181e-01f, -1.65602133e-01f, -3.38167906e-01f, 1.45841166e-01f,
  6.91414764e-03f, -1.47071421e-01f, 4.98616636e-01f, 1.24508075e-01f, -4.22753811e-01f, -4.16634887e-01f, -2.53225535e-01f, 7.03148469e-02f, -1.03109583e-01f, -2.40057543e-01f,
  -5.15225410e-01f, -4.09513444e-01f, 3.89448963e-02f, -5.21508008e-02f, 1.43241376e-01f, 7.84486011e-02f, 3.64043593e-01f, 3.61682028e-01f, 4.12695073e-02f, -5.75888634e-01f,
  -5.13290405e-01f, 1.80503100e-01f, 3.04035217e-01f, 2.38522336e-01f, 1.07427940e-01f, -9.63745117e-02f, 5.20716488e-01f, 8.00738931e-02f, -1.12479493e-01f, 1.91742554e-02f,
  -6.70464188e-02f, 2.42986158e-01f, -3.95038426e-02f, -1.61643907e-01f, 5.49636446e-02f, 3.89006920e-02f, 3.16404216e-02f, 3.80318761e-01f, -3.01625766e-02f, 5.04346862e-02f,
  -1.80146158e-01f, -2.05000609e-01f, -9.89520103e-02f, -1.22198705e-02f, -6.71078563e-02f, -1.24818012e-01f, 4.11992043e-01f, 3.84637445e-01f, 4.54529166e-01f, -1.38687521e-01f,
  -5.69420040e-01f, -3.43027830e-01f, 1.06951818e-01f, 1.29183531e-01f, 2.36665264e-01f, -8.98784995e-02f, 1.65591404e-01f, -1.44052148e-01f, 1.79335400e-01f, 2.78801210e-02f,
  -1.59601286e-01f, -9.75117236e-02f, 6.72183931e-02f, 8.92973021e-02f, -1.53867444e-02f, -3.82001214e-02f, -2.03932747e-02f, -5.78105673e-02f, 3.99286188e-02f, -1.10434294e-01f,
  -8.63335282e-02f, 1.55874128e-02f, 1.08193345e-01f, 5.25720976e-02f, -5.20001352e-02f, 1.23598568e-01f, -1.47706896e-01f, 8.53695199e-02f, 3.67868207e-02f, 8.62451717e-02f,
  3.66558060e-02f, 4.55194563e-02f, 8.42592344e-02f, 1.42658457e-01f, 4.60738540e-02f, 1.43073574e-01f, -1.95259098e-02f, -5.56009226e-02f, -3.28310616e-02f, -7.24736750e-02f,
  -2.46579777e-02f, 3.13230902e-01f, -1.60957612e-02f, 9.11088809e-02f, -4.66733649e-02f, 7.01142251e-02f, 4.29995693e-02f, -3.95764038e-02f, -3.22114443e-03f, -1.54049277e-01f,
  -1.13459453e-01f, -8.56737345e-02f, 1.83019623e-01f, -1.12165604e-02f, -1.59933701e-01f, -1.96939126e-01f, -2.70884156e-01f, -1.64272293e-01f, 1.48727344e-02f, -9.55106169e-02f,
  3.75839486e-03f, -3.01879138e-01f, -3.55265856e-01f, -9.14399475e-02f, -8.08379501e-02f, -2.42491201e-01f, -1.00826085e-01f, -2.54928708e-01f, -2.20289171e-01f, -3.30521286e-01f,
  -4.59689677e-01f, -3.82878661e-01f, -7.39761293e-01f, -7.45793402e-01f, -5.63915610e-01f, -6.52289540e-02f, 1.59192085e-01f, 4.48352247e-02f, -5.27942300e-01f, -4.40124929e-01f,
  1.61255877e-02f, 1.50844544e-01f, -1.85158193e-01f, 8.81015807e-02f, 1.44486248e-01f, -3.95266563e-01f, -5.26493192e-01f, -2.80450791e-01f, 2.81243473e-01f, 3.98374766e-01f,
  9.65475067e-02f, -1.52280971e-01f, -1.25226110e-01f, -8.49645287e-02f, -3.39246988e-01f, -2.22071409e-01f, -6.33437157e-01f, -4.17975217e-01f, -2.02755436e-01f, -5.64603925e-01f,
  1.47202954e-01f, -3.29966128e-01f, 3.20913084e-02f, -8.58416706e-02f, -2.89626330e-01f, -4.43272926e-02f, 1.01898007e-01f, -1.65311590e-01f, -9.63847190e-02f, -1.91632614e-01f,
  -2.57790685e-01f, 4.52828668e-02f, -5.98681420e-02f, 5.13496064e-02f, -8.02954510e-02f, 1.36735186e-01f, -2.64381200e-01f, -1.33374169e-01f, -2.45582581e-01f, -2.85512414e-02f,
  -1.13052644e-01f, -9.64103416e-02f, 3.72618325e-02f, 7.44125396e-02f, -1.24774277e-01f, -1.66288055e-02f, -3.50357033e-03f, -7.77616054e-02f, -5.64424954e-02f, -1.35298669e-01f,
  -1.27464116e-01f, -9.02554765e-02f, -9.28290188e-03f, 6.57070205e-02f, 1.56497076e-01f, -6.41623661e-02f, -7.82477856e-02f, 1.14063136e-02f, 4.54845764e-02f, -5.84407384e-03f,
  -2.51657199e-02f, -3.60790268e-02f, 1.26165943e-02f, -6.41407967e-02f, -2.34163404e-02f, -4.33424562e-02f, 7.56188901e-03f, -9.82950442e-03f, -4.19717059e-02f, -6.69527128e-02f,
  1.99497975e-02f, -7.73285702e-02f, -2.01891765e-01f, 1.58735260e-01f, -7.60560855e-02f, -7.55213052e-02f, -6.22991286e-02f, 9.11066234e-02f, -1.38791185e-02f, -8.26674998e-02f,
  3.68347794e-01f, 6.88339099e-02f, -8.49748217e-03f, 7.87665173e-02f, -1.35084406e-01f, -6.72010258e-02f, -1.26941234e-01f, -6.33067116e-02f, -1.90608427e-01f, 8.60219374e-02f,
  4.77082916e-02f, 1.08049683e-01f, -6.34546131e-02f, -2.26908587e-02f, 1.28144920e-01f, 7.56273270e-02f, 5.81444576e-02f, -2.83732712e-02f, 2.27345210e-02f, -1.40403762e-01f,
  -1.88339502e-01f, 1.11725107e-01f, 3.57465625e-01f, 1.00739300e-01f, 8.55809823e-02f, 1.29698649e-01f, 1.16562888e-01f, 1.48543194e-01f, 1.88011229e-01f, 1.35478631e-01f,
  -5.80000162e-01f, 6.21968389e-01f, 3.86788428e-01f, -5.46365976e-01f, 1.10928141e-01f, 4.55672979e-01f, 6.33949578e-01f, 1.31024808e-01f, -2.05616131e-01f, 5.69688268e-02f,
  2.49756455e-01f, -3.01156610e-01f, -8.94604549e-02f, 1.44612372e-01f, 2.84554780e-01f, 3.02422971e-01f, 1.72330484e-01f, -3.98045704e-02f, -1.59887478e-01f, -2.59048231e-02f,
  -1.31081015e-01f, -3.53436351e-01f, -2.74342418e-01f, -1.25404730e-01f, -2.11021185e-01f, -1.87409863e-01f, 9.55379456e-02f, 1.92944303e-01f, 2.87892848e-01f, -2.34790981e-01f,
  3.00667524e-01f, 3.37097883e-01f, -1.67373076e-01f, -8.09547529e-02f, 1.08756252e-01f, 9.32169612e-03f, 3.46446596e-02f, -7.81502947e-02f, 5.45491884e-03f, -1.80348493e-02f,
  -1.98433385e-03f, 9.62481424e-02f, 9.12649371e-03f, 8.99110734e-02f, 3.08393817e-02f, 1.29765555e-01f, 7.19413012e-02f, 4.93917093e-02f, 2.01814711e-01f, 2.85364270e-01f,
  1.59679428e-01f, 1.62970155e-01f, 1.67301223e-01f, 1.45646676e-01f, 2.63173729e-01f, 7.67247798e-03f, 2.76803702e-01f, 5.82517087e-02f, 2.22976968e-01f, -9.50840637e-02f,
  -8.61420482e-02f, -5.26122227e-02f, 6.19421043e-02f, -1.64314106e-01f, 1.08219534e-02f, 9.71752107e-02f, -8.78250748e-02f, -3.49473990e-02f, 1.25560844e-02f, -1.19784795e-01f,
  6.90881088e-02f, 1.45247445e-01f, 4.32345606e-02f, -1.15416370e-01f, -5.76492250e-02f, 8.95414650e-02f, 8.32790509e-02f, 1.43704787e-01f, 2.16248229e-01f, 1.67946428e-01f,
  1.34255998e-02f, 4.22327928e-02f, -2.13287715e-02f, 1.69582561e-01f, 1.34006247e-01f, -1.09881572e-02f, 3.62923369e-02f, 2.81240307e-02f, -6.74437955e-02f, 3.74949090e-02f,
  -2.04234362e-01f, 4.53055769e-01f, -2.23625973e-01f, -1.33819371e-01f, -7.12338611e-02f, -5.55768702e-03f, -5.10925129e-02f, -1.38263926e-01f, -1.24614574e-02f, -1.12183936e-01f,
  8.50639343e-02f, -1.04407892e-01f, -5.24617210e-02f, -8.13473240e-02f, -1.37275949e-01f, -5.97292185e-02f, -1.53921530e-01f, -1.43017024e-01f, 3.59085575e-02f, 2.20607165e-02f,
  5.19594774e-02f, -1.22633882e-01f, -2.16901883e-01f, -9.85747352e-02f, -6.81156963e-02f, -2.18624860e-01f, -3.81909981e-02f, -1.11633904e-01f, 1.17621072e-01f, -2.51670182e-01f,
  -7.78463110e-02f, 2.89277375e-01f, -6.06935978e-01f, -1.53396174e-01f, -4.26189899e-01f, -2.31082022e-01f, 2.88331032e-01f, 1.38246283e-01f, 8.10369104e-02f, 3.51451486e-01f,
  1.30523920e-01f, -3.82358760e-01f, -3.56940210e-01f, -2.10275665e-01f, 3.17942090e-02f, 1.81419924e-01f, -1.26633182e-01f, -4.36318219e-01f, -3.58453512e-01f, -1.29490718e-02f,
  -1.09618016e-01f, -9.58335623e-02f, -1.92200199e-01f, -1.63615093e-01f, -3.36125970e-01f, -4.87948805e-01f, -3.76114845e-01f, -3.51835221e-01f, -2.01827243e-01f, -4.62708324e-01f,
  -2.78837621e-01f, -2.82442033e-01f, -5.83417155e-02f, -7.09913597e-02f, -5.68098053e-02f, -1.85719207e-02f, -6.17306791e-02f, -7.66601861e-02f, 9.33910012e-02f, 9.85201001e-02f,
  -2.24253878e-01f, 1.21021427e-01f, -8.39831382e-02f, -1.28254056e-01f, -1.62916809e-01f, -1.02054633e-01f, -1.29189432e-01f, -2.09654912e-01f, -1.82533294e-01f, 1.23503767e-01f,
  3.17280591e-02f, -3.90894890e-01f, -4.41352367e-01f, 2.38542520e-02f, -1.17284387e-01f, -2.94085503e-01f, -1.45547315e-01f, -2.60115325e-01f, -2.09665030e-01f, -2.64720097e-02f,
  3.01246345e-01f, 2.28253696e-02f, 1.02953762e-02f, -2.00148579e-02f, 1.89008579e-01f, -1.58290379e-02f, -1.23890322e-02f, 2.73079369e-02f, 5.53435320e-03f, 7.46045113e-02f,
  1.56790629e-01f, 1.25124082e-01f, -6.32395968e-02f, -5.07631153e-02f, -1.71466291e-01f, -3.68119255e-02f, 1.43921718e-01f, 4.00319211e-02f, -7.88776278e-02f, -6.29181713e-02f,
  -1.47817478e-01f, -1.03735946e-01f, -1.27103969e-01f, -3.97311561e-02f, 4.38668691e-02f, 3.46111245e-02f, -3.48271020e-02f, -1.00788996e-02f, 1.53838773e-03f, -5.75425588e-02f,
  3.52523476e-02f, 9.24805850e-02f, -6.93966076e-02f, -1.04725204e-01f, 2.36604493e-02f, 4.38022427e-02f, 2.72280201e-02f, 1.99472636e-01f, -1.32362127e-01f, 8.99682194e-02f,
  -4.68189418e-02f, 1.58456400e-01f, -1.19200470e-02f, 5.93166845e-03f, -1.86283921e-03f, -1.01328172e-01f, 2.30647027e-01f, -2.61957914e-01f, -9.49285328e-02f, 4.10241857e-02f,
  2.48791531e-01f, 4.64148372e-02f, -9.00843218e-02f, 3.91202867e-02f, -4.20898832e-02f, -9.41182747e-02f, -1.09778360e-01f, -9.22569782e-02f, 1.01667240e-01f, 3.72320265e-01f,
  -4.42109048e-01f, 3.16835940e-01f, 1.52320713e-01f, -3.12730849e-01f, 1.89971328e-01f, 3.43319893e-01f, 5.39693177e-01f, 3.29336315e-01f, -4.53630425e-02f, 5.13486937e-03f,
  2.76471555e-01f, 4.78416383e-02f, -9.82702300e-02f, -2.93843052e-03f, 4.80017103e-02f, 4.53475397e-03f, -2.70549744e-01f, -2.03038871e-01f, 4.23597172e-02f, 1.55917868e-01f,
  4.78361733e-02f, -1.93273857e-01f, -3.36702615e-01f, -1.43181741e-01f, -3.46469939e-01f, -1.87359571e-01f, -2.09657848e-01f, -3.17007542e-01f, -5.04798405e-02f, -4.92391407e-01f,
  -3.23973060e-01f, 2.79962849e-02f, 5.15640387e-03f, -1.22500986e-01f, -9.87971202e-02f, -1.87851742e-01f, -1.02317430e-01f, -1.94579050e-01f, -7.51096234e-02f, -1.32637843e-01f,
  -2.39839423e-02f, -5.15433401e-02f, -9.78837237e-02f, -6.12334125e-02f, -1.26514742e-02f, 3.83967697e-03f, -1.43887579e-01f, -4.52606082e-02f, -2.09451914e-01f, 9.70219746e-02f,
  -2.21718654e-01f, -1.82367101e-01f, -1.56483546e-01f, 8.30758959e-02f, 7.10854903e-02f, -1.99415296e-01f, -8.86276811e-02f, -2.08122373e-01f, -1.46071464e-01f, -4.65108782e-01f,
  -8.49163383e-02f, -6.33456111e-02f, 1.07062601e-01f, 1.59840181e-01f, -7.69009069e-02f, -2.82923747e-02f, -9.50311497e-02f, -3.69259082e-02f, -9.82206687e-02f, -1.48513496e-01f,
  1.87485784e-01f, 1.66510358e-01f, 3.61073874e-02f, 4.10223380e-02f, -2.99534708e-01f, -5.74462116e-02f, -5.37864417e-02f, -1.27585039e-01f, -7.54109025e-02f, -9.75557789e-02f,
  -7.19091520e-02f, -2.08698306e-02f, -8.33717883e-02f, -5.62749580e-02f, 1.11632958e-01f, -4.64901477e-02f, -1.41255632e-01f, 4.59787138e-02f, -3.97126004e-02f, 2.88933627e-02f,
  -4.53657091e-01f, 8.71694982e-02f, -3.07740986e-01f, 4.95581999e-02f, -4.82630134e-02f, -9.61972624e-02f, -5.08416444e-02f, 1.21546246e-01f, 1.23857558e-02f, 1.56874597e-01f,
  1.40319481e-01f, -5.48473038e-02f, -6.42283112e-02f, 7.16048777e-02f, 1.80802941e-02f, -4.73859496e-02f, -1.26725212e-01f, 3.11674271e-03f, -2.31050944e-04f, -8.38123336e-02f,
  -2.57529765e-01f, -2.13233277e-01f, -2.86711752e-01f, -1.24489546e-01f, -2.01024413e-01f, -1.75868154e-01f, -2.97568023e-01f, -2.96823621e-01f, -2.91123509e-01f, -4.65369016e-01f,
  1.00612605e+00f, 5.59198201e-01f, -4.27150369e-01f, 6.23987734e-01f, -4.39829320e-01f, -4.86750454e-01f, -1.40701905e-01f, 1.95153520e-01f, 3.93884242e-01f, 2.83181697e-01f,
  -4.18594539e-01f, -4.03067380e-01f, -9.34249908e-02f, -3.03235739e-01f, -2.89525717e-01f, 1.07781485e-01f, 1.46702647e-01f, -3.08958024e-01f, -5.51476419e-01f, -4.48288471e-01f,
  -1.46775499e-01f, 1.40796289e-01f, 2.19712779e-01f, -6.08161204e-02f, 2.50364959e-01f, -2.07702249e-01f, 8.39295611e-03f, -4.23152745e-02f, -3.04147899e-01f, 2.26384237e-01f,
  -1.50482327e-01f, 3.43822241e-01f, -5.38235307e-01f, -4.08267975e-02f, -6.83507100e-02f, 2.15285882e-01f, -8.90173316e-02f, 6.43454567e-02f, -1.82158109e-02f, 1.49320677e-01f,
  -3.05367708e-01f, -7.15357363e-02f, -2.16825068e-01f, -1.78255051e-01f, -3.63301672e-02f, -2.73084432e-01f, 1.00318648e-01f, -1.53468177e-01f, 1.00772090e-01f, 2.58787982e-02f,
  -1.77076310e-01f, -3.28026414e-01f, -1.02089383e-01f, -1.38398290e-01f, -4.48634066e-02f, -2.29806602e-01f, -1.74686521e-01f, -7.74975717e-02f, -2.11831912e-01f, 6.58261538e-01f,
  2.47528747e-01f, 1.96030103e-02f, -1.47554338e-01f, -1.76160950e-02f, 1.12771951e-01f, -9.50318649e-02f, 5.75689506e-03f, -3.75077613e-02f, -5.40842563e-02f, 1.51458561e-01f,
  3.64573859e-02f, -1.54382428e-02f, 3.17386836e-02f, 1.68122545e-01f, -5.32589406e-02f, 5.39338328e-02f, -5.85065931e-02f, 1.28361896e-01f, 4.92397174e-02f, 7.54115283e-02f,
  -6.84638917e-02f, -3.44129577e-02f, -5.14996126e-02f, 7.10091218e-02f, -2.11639047e-01f, 1.36433374e-02f, 1.00080939e-02f, -3.16795856e-02f, 1.49743021e-01f, 4.13080715e-02f,
  1.04211211e-01f, -4.38978761e-01f, 2.21125335e-01f, -5.93707561e-02f, -2.92522646e-02f, -1.00498594e-01f, 6.04070611e-02f, -1.55476406e-02f, -4.50351872e-02f, -6.27820268e-02f,
  -1.92703336e-01f, 1.32878631e-01f, 8.85917693e-02f, -5.11801615e-02f, -1.58079937e-01f, -1.07734457e-01f, 2.11630110e-02f, -2.47611925e-01f, -9.18385088e-02f, 1.12099655e-01f,
  2.22987890e-01f, 9.43414941e-02f, 2.69172668e-01f, 9.83572602e-02f, 8.25951770e-02f, -4.38886434e-02f, -4.74114642e-02f, -1.27890229e-01f, -2.15595603e-01f, 5.82322538e-01f,
  4.85536814e-01f, -3.84946972e-01f, -5.40618598e-01f, -2.84936816e-01f, -3.79251331e-01f, -3.18263710e-01f, -3.01373035e-01f, -3.88876721e-02f, -3.31452452e-02f, -2.53815204e-01f,
  -5.19316457e-02f, 1.54292583e-01f, 4.39784862e-02f, 2.52128690e-02f, 2.70972922e-02f, -4.54220533e-01f, -5.09336889e-01f, -2.94739574e-01f, -1.19157098e-01f, -8.36167037e-02f,
  -6.33269325e-02f, -1.72374308e-01f, 1.61913820e-02f, -1.41039282e-01f, -3.82921636e-01f, -2.38051847e-01f, -4.06731129e-01f, -3.26346427e-01f, -3.73259664e-01f, -4.83750373e-01f,
  -2.92818010e-01f, 1.74459428e-01f, 1.10437572e-01f, 1.13782071e-01f, -4.45633642e-02f, 1.54807240e-01f, 6.43779933e-02f, 1.13334029e-03f, 9.33616459e-02f, 7.43468991e-03f,
  1.07617110e-01f, 9.77005363e-02f, 4.12859097e-02f, 1.14263773e-01f, -4.12940606e-02f, 1.15101039e-01f, 2.18500301e-01f, 9.58426669e-02f, -2.08611730e-02f, -5.31922355e-02f,
  -2.77272183e-02f, 1.40880048e-01f, 1.20066024e-01f, 1.23751692e-01f, 2.34433040e-01f, 2.28672981e-01f, 1.72936335e-01f, 1.76851317e-01f, 1.26570657e-01f, 1.17298290e-01f,
  -6.95580542e-02f, -5.26628282e-04f, 1.03557996e-01f, 1.54866338e-01f, 2.75522649e-01f, 9.81870517e-02f, 1.07649617e-01f, 8.72161090e-02f, 1.66166365e-01f, 6.31764680e-02f,
  -8.01366419e-02f, 3.53497341e-02f, 4.24091555e-02f, 7.37015251e-03f, -4.01138850e-02f, 3.81350750e-03f, -2.71004532e-02f, 6.37134239e-02f, 7.43791163e-02f, 7.78988376e-02f,
  1.42743066e-01f, -1.99486800e-02f, -1.13786690e-01f, -9.14994627e-02f, -6.75237784e-03f, 5.97495027e-02f, 5.15267551e-02f, 1.84338596e-02f, 6.17610253e-02f, -7.02075511e-02f,
  2.06894130e-01f, 8.21234286e-02f, 4.34586704e-02f, 1.29783630e-01f, -6.27191439e-02f, -1.29558116e-01f, -4.39952612e-02f, -2.97852103e-02f, 9.09498613e-03f, -6.36450946e-02f,
  4.72413264e-02f, -3.97153087e-02f, -1.94484256e-02f, -4.32240516e-02f, 9.21677127e-02f, 1.26397133e-01f, 2.32910842e-01f, 1.86780125e-01f, -7.22107291e-02f, -7.02015609e-02f,
  -1.47493798e-02f, 1.29398540e-01f, 2.64162809e-01f, 3.24706025e-02f, 1.60925761e-01f, 1.08043589e-01f, -4.90693413e-02f, -3.78798507e-02f, 5.22537529e-02f, 1.04561277e-01f,
  -5.22868633e-01f, 2.57300586e-01f, 1.00624971e-01f, -1.96822450e-01f, 3.80360126e-01f, 3.93802941e-01f, 6.84637964e-01f, 3.48462403e-01f, -1.05221860e-01f, 6.95617199e-02f,
  -6.49957880e-02f, -3.32095385e-01f, -3.39780599e-01f, -2.49144524e-01f, 1.13373630e-01f, 2.97308981e-01f, 2.43338749e-01f, -9.70629007e-02f, -1.24301359e-01f, 3.90155404e-03f,
  6.61589876e-02f, -1.74160581e-03f, -3.26354474e-01f, -1.58499032e-01f, -1.13414779e-01f, -2.72428036e-01f, 5.29508181e-02f, 9.04506519e-02f, 2.28136972e-01f, -1.93629727e-01f,
  -1.45721167e-01f, 9.06869769e-03f, -5.94881661e-02f, -2.22035944e-01f, -1.45661477e-02f, -1.00296475e-01f, 6.25208169e-02f, -6.97984844e-02f, -4.78565469e-02f, 3.93629484e-02f,
  -1.71789333e-01f, -9.58981458e-04f, -4.51552542e-03f, -7.94213042e-02f, 3.21574956e-02f, -9.41891894e-02f, -1.35660723e-01f, -7.79894590e-02f, -1.11040555e-01f, -1.00508176e-01f,
  -6.17002398e-02f, -2.60255747e-02f, 4.82080914e-02f, 2.40779184e-02f, 1.92484376e-03f, -1.86915934e-01f, 2.30762251e-02f, -1.49224460e-01f, -1.88751966e-02f, -1.91858023e-01f,
  4.40724604e-02f, 6.22892827e-02f, -1.81952920e-02f, -7.41658453e-03f, -3.84668298e-02f, -3.32963988e-02f, 6.13427050e-02f, 1.68456271e-01f, 8.91586691e-02f, 6.14433475e-02f,
  1.60255447e-01f, 3.19836617e-01f, 1.86654717e-01f, 2.03643709e-01f, -2.13536993e-03f, 6.10400923e-02f, 1.03978947e-01f, -1.41862710e-03f, 6.25863597e-02f, 6.05342202e-02f,
  1.13318369e-01f, 1.15885064e-01f, -8.52247253e-02f, 1.15240879e-01f, 1.08689137e-01f, 1.02792447e-02f, 2.00374201e-02f, 1.40124246e-01f, 5.89876585e-02f, 1.01929791e-01f,
  -1.87146384e-02f, 2.59333611e-01f, -5.22841960e-02f, -7.92179331e-02f, 2.73122098e-02f, -7.10753351e-02f, 5.31539582e-02f, 1.58311352e-01f, 1.58777744e-01f, 9.93149355e-02f,
  3.77025120e-02f, -7.55616128e-02f, 1.69401228e-01f, 1.99273169e-01f, -1.29981600e-02f, 5.41264229e-02f, 4.17624451e-02f, 8.88562854e-03f, -4.93285246e-02f, -6.76840320e-02f,
  3.34601998e-02f, 7.64402002e-02f, 1.14144936e-01f, 1.44314378e-01f, 9.35392603e-02f, -1.32560387e-01f, 4.70022671e-02f, 1.03510484e-01f, 1.45835220e-03f, 1.10263042e-01f,
  6.08983636e-01f, 4.96847391e-01f, 4.77155656e-01f, 3.50613862e-01f, 1.17792703e-01f, 3.69705886e-01f, 5.34741938e-01f, 4.87586319e-01f, 1.63177118e-01f, 2.03317434e-01f,
  6.24367818e-02f, 3.11201103e-02f, 3.19024995e-02f, 1.00636370e-01f, 1.98944479e-01f, 2.02062041e-01f, 2.26103157e-01f, 2.32502684e-01f, 1.60457641e-01f, 9.04596448e-02f,
  -1.28971506e-02f, 1.43181831e-01f, 1.73500493e-01f, 1.21477023e-02f, 5.72762117e-02f, -1.13384359e-01f, 3.68369222e-02f, 1.81350976e-01f, 1.14473201e-01f, 1.63528740e-01f,
  -5.64039573e-02f, 3.04555535e-01f, -2.37987444e-01f, -3.32261622e-01f, -4.98571172e-02f, 4.45667421e-03f, 6.75832778e-02f, -1.23621568e-01f, -2.64778323e-02f, -9.63042378e-02f,
  -1.20681614e-01f, 1.03019709e-02f, -1.80991851e-02f, 5.20610996e-02f, 5.72682992e-02f, -1.34042939e-02f, 5.95226139e-02f, 2.14659020e-01f, 1.96878597e-01f, 7.24734664e-02f,
  -8.82069096e-02f, -4.43128124e-02f, 6.67291656e-02f, 4.75817844e-02f, 2.17060763e-02f, -2.10908785e-01f, 5.39560476e-03f, 4.41053212e-02f, 3.81465331e-02f, 9.36547853e-03f,
  -7.57045895e-02f, -4.59106117e-02f, 1.41835973e-01f, 1.86049521e-01f, 1.21370941e-01f, 1.02298588e-01f, 7.61032104e-02f, -2.49843784e-02f, 1.38667032e-01f, 8.60759690e-02f,
  6.78305998e-02f, 9.54019204e-02f, 2.85036236e-01f, 9.20484737e-02f, -1.36472970e-01f, 7.03109577e-02f, 1.35250703e-01f, -3.96489687e-02f, -4.10903394e-02f, -3.63791212e-02f,
  8.36634561e-02f, -3.15782875e-02f, -2.70654876e-02f, 1.12462081e-01f, 1.06083113e-03f, 4.54393774e-02f, -1.00866556e-01f, -9.81384888e-02f, -1.37092039e-01f, -1.78156078e-01f,
  -1.66638121e-01f, 5.83664514e-02f, -1.20812342e-01f, -7.02551976e-02f, -4.72179204e-02f, -1.66721761e-01f, 1.21605702e-01f, -1.76438883e-01f, -1.10831037e-01f, -1.32688880e-01f,
  -9.01861303e-03f, 1.36353940e-01f, 1.30763173e-01f, 4.37951094e-04f, -1.62648484e-01f, -1.39454082e-01f, -6.62553906e-02f, 1.33325741e-01f, 3.37504745e-02f, -1.34194598e-01f,
  -5.72789498e-02f, -1.52535029e-02f, -1.39845148e-01f, -4.07811105e-02f, -1.43678740e-01f, -2.92066246e-01f, -1.81631804e-01f, -8.23442563e-02f, -9.96926278e-02f, -1.05190560e-01f,
  8.47151399e-01f, 4.19586837e-01f, 4.45123613e-01f, 4.18387018e-02f, -4.13778603e-01f, -3.15979183e-01f, -3.26525301e-01f, -2.99076945e-01f, -1.89370751e-01f, 7.40507850e-03f,
  -2.72404980e-02f, -1.30456612e-01f, 4.47470210e-02f, 1.79283530e-01f, 2.89192706e-01f, -8.30542445e-02f, -1.46536291e-01f, 3.76920491e-01f, 2.91071594e-01f, -9.56013426e-03f,
  -1.56017989e-01f, 2.38551989e-01f, 4.74463522e-01f, 2.95854092e-01f, 2.78174039e-02f, -1.44070983e-01f, 1.69048533e-02f, 5.21992333e-02f, -3.21865752e-02f, 7.74798691e-02f,
  4.27107699e-02f, 3.15406829e-01f, -1.51482403e-01f, -1.64401457e-02f, 1.90945789e-01f, 1.37682170e-01f, 3.28045376e-02f, 3.16955410e-02f, 5.39154327e-03f, -1.91486806e-01f,
  -2.38941889e-03f, 1.06943613e-02f, 5.04013598e-02f, -2.71343603e-03f, 2.62242742e-03f, -3.34306844e-02f, 5.84298139e-03f, 1.00921847e-01f, -1.01013593e-01f, -1.39075695e-02f,
  -1.08902529e-01f, -1.42330498e-01f, -1.84323013e-01f, -3.39886934e-01f, 1.37585346e-02f, -6.38224781e-02f, -3.15311849e-02f, -7.81397149e-02f, -5.97454347e-02f, -1.38336897e-01f,
  -2.25531995e-01f, 7.48009682e-02f, -4.37716544e-02f, -1.91229716e-01f, -1.17614552e-01f, -2.29681060e-01f, -2.27264181e-01f, -1.01125084e-01f, 4.54722904e-02f, 2.67850459e-02f,
  -1.19276419e-01f, -1.20302260e-01f, -1.68079093e-01f, -6.42091930e-02f, 2.57020406e-02f, -6.17632307e-02f, -1.32179230e-01f, -6.60030991e-02f, 1.03683844e-01f, 2.83428072e-03f,
  -3.81453000e-02f, -1.84926718e-01f, 2.94862818e-02f, -3.81344408e-02f, -1.59623370e-01f, -7.36365244e-02f, -1.17700346e-01f, -1.18030123e-01f, -4.53864969e-02f, -1.27875671e-01f,
  -3.47636729e-01f, 3.50056171e-01f, 2.37055384e-02f, 1.50333434e-01f, 1.51888937e-01f, 3.02446574e-01f, 1.12813003e-01f, 1.83588505e-01f, 6.44667000e-02f, -2.17388310e-02f,
  8.67470575e-04f, 2.17954800e-01f, 2.05015227e-01f, 1.04204498e-01f, 1.76760070e-02f, -3.56659815e-02f, 7.37501904e-02f, -5.69768324e-02f, -4.06960174e-02f, -8.28971248e-03f,
  -5.54300174e-02f, -2.57943213e-01f, -2.83517927e-01f, -1.15961052e-01f, -5.01987450e-02f, -1.19932242e-01f, -1.15092866e-01f, -2.29040548e-01f, -9.52304155e-02f, -1.96072772e-01f,
  -1.94608748e-01f, 4.08075333e-01f, 4.38638330e-01f, -2.32748672e-01f, 4.66686040e-01f, 3.60199630e-01f, 3.42028558e-01f, -2.67603189e-01f, -4.03467238e-01f, -5.05310111e-03f,
  3.40645015e-01f, -3.32137972e-01f, -3.21729302e-01f, -3.27931613e-01f, -3.01577330e-01f, -7.09266886e-02f, -2.93605514e-02f, -8.61379951e-02f, -1.75893933e-01f, 1.27320901e-01f,
  6.80724112e-03f, -1.26362801e-01f, -6.09956570e-02f, -1.84448630e-01f, -2.09080532e-01f, -2.46382356e-01f, 5.81452511e-02f, 1.58590764e-01f, 3.79531741e-01f, -7.58621767e-02f,
  5.45270406e-02f, 1.86623394e-01f, -1.84977189e-01f, 1.46684237e-03f, 2.06206262e-01f, -1.70599058e-01f, -4.36500944e-02f, -1.56717464e-01f, 4.66464227e-03f, -7.27826059e-02f,
  1.45017937e-01f, 3.77992839e-02f, 4.15207297e-02f, -2.31038183e-02f, 1.14150397e-01f, -7.67666250e-02f, -4.99642752e-02f, -1.01239368e-01f, -4.10307273e-02f, 1.96650997e-01f,
  2.32389420e-01f, 3.51759404e-01f, 3.71029049e-01f, -1.02948528e-04f, -8.79270434e-02f, 1.36335030e-01f, 7.07819462e-02f, -4.99586202e-02f, 9.51729864e-02f, -2.39030555e-01f,
  6.57355785e-02f, -2.36786064e-02f, 2.32129134e-02f, -6.01229593e-02f, -7.91154206e-02f, -4.54467647e-02f, -9.00031552e-02f, 5.32189049e-02f, -5.78242540e-02f, -7.86654279e-02f,
  2.54818629e-02f, 1.61264673e-01f, 8.64189789e-02f, 3.69498357e-02f, 1.54104698e-02f, 1.79611966e-01f, 1.65714130e-01f, 8.25512856e-02f, 6.33867979e-02f, 1.68507034e-03f,
  -3.29779685e-02f, -6.32416680e-02f, -5.00431098e-02f, -2.25738227e-01f, 2.47863665e-01f, 3.64916697e-02f, 5.78751229e-02f, 4.45476323e-02f, 4.36251871e-02f, 7.98071846e-02f,
  -3.80838603e-01f, 3.57975394e-01f, -1.51952416e-01f, -2.16955692e-01f, -7.91335627e-02f, -2.99303271e-02f, -2.77122576e-02f, -6.00879192e-02f, 4.51442562e-02f, -4.63854410e-02f,
  8.11138377e-02f, -9.50840041e-02f, 4.90936339e-02f, -7.30081052e-02f, -3.80435251e-02f, -3.57149467e-02f, 2.18218535e-01f, 7.89026096e-02f, 3.19160037e-02f, 1.11560501e-01f,
  2.38722656e-02f, -6.18026629e-02f, -1.32519484e-01f, -1.81973457e-01f, 9.36055928e-02f, -8.45859721e-02f, -9.05765444e-02f, -1.63575515e-01f, -9.82276350e-02f, -2.85582453e-01f,
  -7.69681573e-01f, 4.89343971e-01f, -2.31323659e-01f, -8.08521882e-02f, 2.61057075e-02f, -7.87918363e-03f, 3.20339024e-01f, -6.56198561e-02f, -4.79441956e-02f, 3.85727763e-01f,
  9.89644080e-02f, -3.22948769e-02f, 8.50667804e-03f, 1.61565691e-01f, 1.96981672e-02f, 5.41742563e-01f, 3.39658499e-01f, -2.12178349e-01f, -5.21461666e-01f, -2.13878244e-01f,
  2.79976249e-01f, -9.23593491e-02f, -4.34189260e-01f, -1.48337886e-01f, 1.66101858e-01f, 4.50532176e-02f, 2.02763855e-01f, -1.12378739e-01f, 2.01816753e-01f, 3.51739258e-01f,
  2.19645411e-01f, -3.11712295e-01f, -7.01210275e-02f, -1.56230599e-01f, -3.55761535e-02f, -1.36907667e-01f, 3.12891379e-02f, -3.17972720e-01f, -2.08594725e-01f, -1.61099136e-02f,
  -3.88854705e-02f, -8.04731026e-02f, -4.62321378e-02f, 2.85184477e-02f, -1.12741590e-01f, -2.19791844e-01f, -7.81671554e-02f, -2.74891466e-01f, -1.37369916e-01f, -8.08117390e-02f,
  2.34497502e-01f, -1.42086446e-01f, -2.12335885e-01f, -3.61510776e-02f, -2.06307054e-01f, -2.32106939e-01f, -9.09228548e-02f, -3.67549360e-01f, -3.22866499e-01f, 1.91937134e-01f,
  3.07859518e-02f, 1.16203226e-01f, 6.10248968e-02f, 6.83444291e-02f, 1.24950260e-01f, 6.10298757e-03f, -5.58891939e-03f, -1.65351629e-02f, -6.65746816e-03f, 8.12623575e-02f,
  -9.42124873e-02f, 9.94798541e-02f, 5.64560592e-02f, -1.71352029e-02f, 9.87181067e-02f, -5.44787645e-02f, 1.14840828e-01f, 1.21706098e-01f, -1.49210364e-01f, -6.82814568e-02f,
  -6.50888868e-03f, -5.58587946e-02f, -2.24795658e-02f, 1.06942758e-01f, -3.96613330e-02f, -4.14114930e-02f, 1.17410719e-01f, -2.36801319e-02f, -9.44178775e-02f, -3.98657430e-04f,
  3.52748066e-01f, -1.55840963e-01f, 2.05706716e-01f, -3.59983854e-02f, -1.03266574e-01f, -3.86141650e-02f, 8.33068117e-02f, -4.69980529e-03f, 2.57091932e-02f, -4.92840074e-02f,
  -4.27109972e-02f, -1.50311083e-01f, 1.61265641e-01f, 3.29524353e-02f, 1.11722918e-02f, -2.76144724e-02f, 2.25065514e-01f, 9.37964618e-02f, 1.50756910e-01f, 8.68834257e-02f,
  2.35692754e-01f, 1.23696968e-01f, 1.24649614e-01f, 1.92381933e-01f, 1.67201966e-01f, 7.81853721e-02f, 2.60319591e-01f, 1.09322317e-01f, -5.40633872e-02f, 4.93411511e-01f,
  -4.56053674e-01f, -1.07403743e+00f, 6.17201447e-01f, 6.02037124e-02f, 3.36142331e-01f, 2.46081591e-01f, -1.18438289e-01f, -1.56949162e-01f, 3.22071984e-02f, -2.31516838e-01f,
  -4.28165883e-01f, -4.77351487e-01f, -2.57652849e-01f, -3.26647848e-01f, -4.75581229e-01f, -1.31791666e-01f, 2.86650747e-01f, 3.90337735e-01f, 2.24902883e-01f, -7.62987956e-02f,
  -3.16181570e-01f, -1.94901332e-01f, -1.75603256e-01f, -6.04030453e-02f, -1.22245513e-02f, 1.56053126e-01f, 2.72732854e-01f, -2.49702334e-02f, -1.62468821e-01f, 1.09636113e-01f,
  3.72394830e-01f, -2.67631769e-01f, 2.33075365e-01f, -2.57865220e-01f, -4.13535014e-02f, -1.77735105e-01f, 2.04001144e-02f, -9.95147228e-03f, -1.28323555e-01f, -9.24739838e-02f,
  -1.68699041e-01f, -1.53019175e-01f, -3.06075951e-03f, -2.08933465e-03f, 2.08224412e-02f, 7.81049058e-02f, -1.83816165e-01f, -4.20778133e-02f, -8.14645812e-02f, -1.95988402e-01f,
  -3.41962278e-01f, -8.47785249e-02f, 2.10957527e-02f, 5.14813922e-02f, -5.61850183e-02f, 1.30150303e-01f, 2.46753935e-02f, 3.45766731e-02f, 7.87396133e-02f, 1.04208104e-01f,
  2.09977761e-01f, 4.78285253e-02f, -1.05541199e-01f, 2.85317842e-02f, -2.72825714e-02f, -2.91220862e-02f, 9.34543684e-02f, -9.54261199e-02f, -3.84013355e-02f, -4.39511053e-02f,
  -6.81397542e-02f, -1.73240472e-02f, -2.36082785e-02f, -8.30168873e-02f, -1.11057274e-02f, -1.46736950e-01f, -9.05725360e-02f, -1.43166333e-01f, 1.23750325e-02f, -1.12326525e-01f,
  -8.23776573e-02f, 2.71580741e-02f, 1.28465608e-01f, 2.15099100e-02f, -8.54626745e-02f, 6.45510629e-02f, -3.64058092e-02f, -1.12247281e-01f, 4.22924198e-03f, -1.47579044e-01f,
  -1.11645751e-01f, 1.63774118e-01f, 1.77296892e-01f, -1.15615770e-01f, 5.69987483e-02f, -3.96131054e-02f, -3.63127212e-04f, 1.64399520e-02f, 3.37670743e-02f, 8.29625502e-02f,
  -6.72297850e-02f, -3.47152315e-02f, -3.65148820e-02f, -7.72403702e-02f, 2.09368214e-01f, 1.68140218e-01f, -2.39493921e-01f, -4.69347425e-02f, 4.78719957e-02f, -1.02593601e-01f,
  -1.39689192e-01f, 1.62489504e-01f, 1.16794638e-01f, 8.23492408e-02f, 7.07730800e-02f, 2.43077531e-01f, 1.80668458e-01f, 2.26526320e-01f, 2.63988733e-01f, 1.38707101e-01f,
  7.70537496e-01f, -9.61709440e-01f, -2.66193628e-01f, 3.19160938e-01f, 2.90298551e-01f, -4.80957329e-02f, -5.76611698e-01f, -1.40056005e-02f, 2.59366870e-01f, -3.63479942e-01f,
  -3.12076062e-01f, 1.85352266e-01f, -1.60430461e-01f, 3.24372351e-02f, -1.35487080e-01f, -5.03387988e-01f, -1.19071923e-01f, 3.36774170e-01f, 7.50288844e-01f, 5.07138789e-01f,
  2.11032853e-01f, 3.37458104e-01f, 5.85694373e-01f, 2.05699116e-01f, -3.71566415e-01f, 2.47552693e-01f, -3.63839120e-01f, -1.49465710e-01f, -3.52617323e-01f, -3.97706091e-01f,
  -1.74626425e-01f, -5.59919834e-01f, 1.53422371e-01f, 2.13968381e-01f, 5.23401536e-02f, -1.31135225e-01f, -1.69093758e-01f, -1.15035169e-01f, -1.04734913e-01f, -1.71069294e-01f,
  2.42804773e-02f, 2.37142704e-02f, -1.37013376e-01f, -1.43440083e-01f, 1.86406896e-01f, 7.52519593e-02f, -1.30881205e-01f, -1.94842830e-01f, -1.75026119e-01f, -1.96365997e-01f,
  -2.33773172e-01f, 1.36211850e-02f, -1.92717388e-01f, -2.39109263e-01f, -4.34240371e-01f, 2.23163515e-01f, -3.89502883e-01f, -2.62804329e-01f, -1.12085119e-01f, -4.40556139e-01f,
  4.24646661e-02f, 6.34937808e-02f, -5.99830374e-02f, -1.13937281e-01f, -2.30521560e-02f, -1.38031825e-01f, -8.50779042e-02f, -1.07073493e-01f, 1.62491370e-02f, -2.09839060e-03f,
  -5.16500287e-02f, 1.38066486e-01f, 1.33532196e-01f, -3.90714966e-02f, -3.38314399e-02f, -1.50477797e-01f, 3.87226860e-03f, 2.99389120e-02f, -3.50598544e-02f, 1.19435206e-01f,
  7.63923377e-02f, -1.67677417e-01f, 1.48090050e-02f, -8.66676122e-03f, -1.55318286e-02f, 2.29538288e-02f, 4.67783585e-02f, 5.65129444e-02f, 1.37160540e-01f, -2.80093011e-02f,
  2.38653958e-01f, 1.79811224e-01f, -1.89929768e-01f, -4.97120135e-02f, -3.94583158e-02f, -6.54263347e-02f, -2.75459774e-02f, 2.83863135e-02f, -6.50191307e-02f, -5.83582073e-02f,
  -4.92480444e-03f, -1.32689610e-01f, -1.59131140e-01f, 7.85136595e-02f, 2.60359585e-01f, 1.18946247e-01f, -1.44783854e-01f, -6.21124357e-02f, 3.15628722e-02f, 1.05786286e-01f,
  -8.35843161e-02f, 1.72472805e-01f, 2.80820608e-01f, 5.55476807e-02f, 1.56998321e-01f, 4.00722384e-01f, 1.16628380e-02f, 6.62907809e-02f, 7.74551183e-02f, -8.62523615e-02f,
  -3.36759150e-01f, -2.28340164e-01f, 1.80147633e-01f, -6.69316769e-01f, -4.17846531e-01f, -2.74417013e-01f, -2.10663542e-01f, -3.34046185e-01f, -4.19781595e-01f, -3.30891371e-01f,
  9.76628065e-02f, 4.50369328e-01f, 3.20717216e-01f, 3.74577522e-01f, 5.47823429e-01f, -2.15143770e-01f, -2.68894613e-01f, 3.81542385e-01f, 5.89130521e-01f, 1.47216231e-01f,
  -1.30073518e-01f, -2.23151341e-01f, -7.21482784e-02f, -7.03148693e-02f, -5.29321432e-01f, 8.54490399e-02f, -3.95833433e-01f, -3.16325039e-01f, -6.13976792e-02f, -4.39585000e-01f,
  3.82656336e-01f, -2.42325887e-01f, 6.38208762e-02f, 2.93676816e-02f, -1.26054540e-01f, 6.68454096e-02f, 6.78992346e-02f, -7.17377439e-02f, -1.22669011e-01f, -1.42531633e-01f,
  -1.62526220e-01f, 6.15381226e-02f, 4.08248156e-02f, 6.29537702e-02f, -9.79552791e-02f, 3.99750508e-02f, -9.21905711e-02f, -1.71532463e-02f, -3.99806391e-04f, 8.97075385e-02f,
  6.49168938e-02f, -1.30798087e-01f, 1.16901942e-01f, -7.40914792e-02f, -9.41557344e-03f, 8.24145898e-02f, -1.29715558e-02f, -4.93289679e-02f, -3.73934172e-02f, -2.74648041e-01f,
  -5.15715256e-02f, -1.29051153e-02f, -1.13698706e-01f, 5.31220399e-02f, 5.58009185e-03f, -1.43287582e-02f, 2.48451047e-02f, 2.55287439e-02f, 9.56919566e-02f, 9.10984501e-02f,
  8.74024332e-02f, 9.97488666e-03f, 2.28348859e-02f, -1.00067444e-01f, -3.55905034e-02f, -2.24512946e-02f, -5.69671169e-02f, 2.38578189e-02f, -5.84171340e-02f, -1.65450439e-01f,
  2.53699552e-02f, -1.31489083e-01f, -1.75898802e-02f, 5.60506582e-02f, -4.64868881e-02f, -9.68514755e-03f, -1.04195356e-01f, 5.06755710e-02f, 9.02367979e-02f, -1.38589099e-01f,
  2.19552547e-01f, 2.11832494e-01f, -8.61156210e-02f, 1.67246446e-01f, -2.06170619e-01f, -1.45648241e-01f, -1.14095733e-01f, -1.13490030e-01f, -3.18383612e-02f, 4.74810302e-02f,
  -2.10754015e-02f, 8.04584920e-02f, 1.80664454e-02f, -9.74592008e-03f, -4.70084324e-02f, -7.94797018e-02f, -2.85737729e-03f, -3.06097269e-02f, -5.92454895e-02f, -6.11657128e-02f,
  -2.21209526e-01f, -1.28474534e-01f, 1.52131811e-01f, 3.00711505e-02f, -1.45873100e-01f, 1.78740725e-01f, 2.38641053e-01f, 1.59562945e-01f, 2.23601624e-01f, -8.20960179e-02f,
  7.46119976e-01f, 4.95424196e-02f, 2.56049961e-01f, 2.27607191e-01f, 2.22057432e-01f, 2.47355141e-02f, -5.58928214e-02f, -1.22062033e-02f, 6.27362030e-03f, 1.50489748e-01f,
  4.05753464e-01f, 3.72371286e-01f, 2.89340198e-01f, 1.06291339e-01f, 1.26300380e-01f, -1.08453222e-01f, -1.18775718e-01f, 1.04930229e-01f, 1.28001705e-01f, 6.60164207e-02f,
  6.11923113e-02f, 1.54715762e-01f, 1.48387164e-01f, 5.54019734e-02f, 1.33775175e-02f, 7.93652385e-02f, 4.71424079e-03f, 5.45046516e-02f, 1.75981030e-01f, 4.87098806e-02f,
  2.99470305e-01f, 3.21935117e-01f, -4.98530343e-02f, -3.64284241e-03f, -3.60414647e-02f, -9.96578112e-02f, -3.87790166e-02f, -4.71188780e-03f, -4.73225638e-02f, -1.71334401e-01f,
  3.98441032e-02f, -6.81779832e-02f, 4.41242345e-02f, 8.47599432e-02f, 1.47240385e-02f, 1.91319839e-03f, -4.85064127e-02f, -3.16153653e-02f, -1.32509887e-01f, -7.84343109e-02f,
  -8.32295865e-02f, 1.33786529e-01f, 8.53987038e-02f, -2.96522509e-02f, 6.80927932e-02f, 1.52288318e-01f, 6.03788812e-03f, 7.60329142e-02f, 9.72723067e-02f, -2.33841743e-02f,
  1.80654794e-01f, 1.04279868e-01f, 2.86505073e-01f, 3.09396774e-01f, 3.17484885e-01f, 1.03674561e-01f, 1.29846945e-01f, -4.11098897e-02f, 8.71849358e-02f, 6.30257055e-02f,
  7.99994171e-02f, 1.79548845e-01f, 2.50234958e-02f, 8.95231962e-02f, 1.26223490e-01f, 1.65722564e-01f, 2.95061823e-02f, -5.66804372e-02f, 2.07926646e-01f, 9.26652253e-02f,
  8.52966905e-02f, -7.04705343e-02f, 2.68664956e-01f, -2.17610672e-02f, 1.67498551e-02f, 1.93470821e-01f, 4.30650003e-02f, 8.88081416e-02f, 1.49801672e-01f, 1.73294500e-01f,
  -4.57950354e-01f, 3.63946944e-01f, 6.54843375e-02f, -5.64138219e-02f, 3.54660675e-02f, -3.77189892e-04f, 7.11759925e-02f, -1.30218700e-01f, -2.01420486e-01f, -1.92781776e-01f,
  2.80134976e-02f, -2.31190696e-02f, 9.81130451e-02f, -8.16746205e-02f, -6.34118840e-02f, -7.58364126e-02f, 9.51881856e-02f, 3.69913839e-02f, -5.12361974e-02f, -1.48127571e-01f,
  -1.64172098e-01f, -1.24292322e-01f, -4.29977477e-02f, -1.65996403e-01f, -1.06580988e-01f, 5.66247888e-02f, -8.87175500e-02f, -1.02789037e-01f, 9.13539343e-03f, -1.88159585e-01f,
  -2.01350272e-01f, -7.46455491e-02f, -7.48675883e-01f, -6.11901879e-01f, -5.12481809e-01f, -6.23702258e-02f, 2.25455359e-01f, 8.52840766e-02f, -2.12802649e-01f, -1.33890986e-01f,
  -3.62557508e-02f, -7.20735714e-02f, -2.86980957e-01f, 2.96621397e-02f, 2.80703038e-01f, 9.58457030e-03f, -1.20641686e-01f, -6.99902549e-02f, 7.68878087e-02f, 1.34457603e-01f,
  3.46517563e-02f, -2.51957804e-01f, -1.45013571e-01f, -2.01948598e-01f, -4.24256384e-01f, -2.95854062e-01f, -4.85915244e-01f, -3.89239222e-01f, -8.58705863e-03f, -4.55644459e-01f,
  -4.54608738e-01f, -2.93813467e-01f, 6.26704330e-03f, -4.97050546e-02f, -2.15546966e-01f, 5.05123623e-02f, 4.42170678e-03f, -2.72103429e-01f, 8.42924118e-02f, -9.01204869e-02f,
  -2.98411340e-01f, -7.73975104e-02f, -9.84986499e-02f, -1.56252056e-01f, -3.12097013e-01f, 7.41142780e-02f, -2.49481231e-01f, -3.27303447e-02f, -3.32335085e-02f, 4.13191132e-02f,
  1.90973774e-01f, -4.77524139e-02f, -6.06678016e-02f, 4.87002777e-03f, -3.50454040e-02f, -1.41992578e-02f, -1.77865610e-01f, 3.61906667e-03f, -6.39093965e-02f, -9.87843350e-02f,
  1.34434149e-01f, -4.44924161e-02f, -3.75833339e-03f, 2.80728340e-02f, 1.00480005e-01f, 7.79794231e-02f, -1.10961527e-01f, 5.30585647e-02f, 3.26230042e-02f, -2.34822631e-02f,
  -1.93135943e-02f, -4.40616831e-02f, -1.11486092e-01f, -1.88025576e-03f, -1.52751267e-01f, -7.00366199e-02f, 3.85423936e-02f, 3.90639417e-02f, -3.09964437e-02f, -2.79072057e-02f,
  1.75473332e-01f, 8.31020102e-02f, -1.09743485e-02f, 1.86956733e-01f, 1.53996333e-01f, 5.06374240e-02f, -2.13016203e-04f, 1.69675201e-01f, 1.69572644e-02f, 4.40343320e-02f,
  -2.66195506e-01f, 3.19402307e-01f, -1.06798545e-01f, 6.35326207e-02f, -9.17482674e-02f, -6.55149296e-02f, -6.78646341e-02f, 1.08531356e-01f, -2.45619610e-01f, -3.69143151e-02f,
  8.02171081e-02f, 3.25678736e-02f, -2.25902140e-01f, 6.38670102e-02f, -1.64059699e-02f, -8.88055563e-03f, 1.81177363e-01f, -5.55602014e-02f, 1.54419094e-01f, 2.17015315e-02f,
  2.10810900e-01f, 3.33794117e-01f, 2.24316493e-01f, 1.08662814e-01f, 1.40601218e-01f, 1.50865495e-01f, 4.61068824e-02f, 2.25229815e-01f, 3.70039731e-01f, 3.32836390e-01f,
  -3.53141636e-01f, -5.01755178e-01f, 5.34004450e-01f, -3.11098933e-01f, -4.30658132e-01f, -4.37836945e-01f, -7.49730349e-01f, -5.11728585e-01f, -3.30941170e-01f, -4.23829645e-01f,
  8.39989632e-02f, 5.70656002e-01f, 8.35656345e-01f, 5.26870310e-01f, 5.33850670e-01f, -2.00927734e-01f, 5.98761672e-03f, 6.07885778e-01f, 3.56723517e-01f, -5.57984889e-01f,
  -4.98229474e-01f, -2.80581951e-01f, 9.71386060e-02f, 2.24055145e-02f, -5.67977309e-01f, 3.51816490e-02f, 7.53110573e-02f, -1.64301902e-01f, -1.05185129e-01f, -1.48040652e-01f,
  2.18125641e-01f, -4.87134784e-01f, 2.28893563e-01f, 1.37963966e-01f, 2.77952198e-02f, 2.37592757e-02f, -4.15741540e-02f, -5.69009818e-02f, -5.72579317e-02f, -1.49504347e-02f,
  -4.13238518e-02f, 7.71214440e-02f, 1.33239478e-01f, 6.97367862e-02f, -1.60082832e-01f, -8.55420530e-02f, 2.47817244e-02f, -1.98659627e-03f, 7.61727169e-02f, -3.86133827e-02f,
  -9.73898023e-02f, -4.21018861e-02f, 2.05474168e-01f, -1.44852206e-01f, -2.16499537e-01f, 1.58075616e-01f, -1.46871716e-01f, -1.66757494e-01f, 1.62286922e-01f, -3.86772454e-01f,
  -6.60022944e-02f, 2.25293949e-01f, -3.94131653e-02f, -5.09795286e-02f, -7.72453174e-02f, 8.67236778e-02f, 5.97325619e-03f, -6.54917434e-02f, -4.19557020e-02f, 1.59369968e-02f,
  1.77499488e-01f, 9.47954357e-02f, -6.76679462e-02f, -9.88155752e-02f, -8.77577886e-02f, -2.30511725e-02f, 1.66855872e-01f, 6.04860559e-02f, -4.25518975e-02f, 1.05792116e-02f,
  7.22616389e-02f, 4.07538749e-02f, 2.75465343e-02f, -5.22429608e-02f, -1.00993467e-02f, 1.48942113e-01f, -1.22542791e-02f, 7.70488977e-02f, 7.82915950e-03f, -3.26120332e-02f,
  2.48865113e-01f, 6.02261066e-01f, 6.03906550e-02f, 6.54574931e-02f, -2.02254921e-01f, -2.40792260e-02f, -3.48188505e-02f, -4.58587110e-02f, -2.18912996e-02f, -2.60942187e-02f,
  -1.99701861e-02f, 1.24651320e-01f, 1.11234382e-01f, -2.73211394e-02f, -9.50194821e-02f, -9.47212204e-02f, -1.33618534e-01f, 2.16200784e-01f, 3.03289364e-03f, -2.57473648e-01f,
  -5.99604882e-02f, -1.89822301e-01f, 1.49839267e-01f, 1.78330630e-01f, -2.79081225e-01f, 1.75769031e-01f, 1.88171729e-01f, -7.62721598e-02f, 4.41372544e-01f, -1.58829644e-01f,
  6.96415067e-01f, 4.80427384e-01f, 2.77081072e-01f, 1.05477639e-01f, 5.96721992e-02f, -2.90847212e-01f, -3.27654034e-01f, -1.32163599e-01f, 2.28143454e-01f, 1.86609685e-01f,
  -1.01513537e-02f, -2.32079968e-01f, 1.02014557e-01f, -2.88238257e-01f, -3.50386441e-01f, -4.29465473e-02f, -1.07029490e-01f, -1.82988465e-01f, -5.45532942e-01f, -5.73411107e-01f,
  -3.96642447e-01f, 1.95826665e-02f, -3.01929656e-02f, -8.13626274e-02f, 4.49695170e-01f, 3.02945580e-02f, 4.56851065e-01f, 2.81621784e-01f, 1.37443185e-01f, 4.19289678e-01f,
  1.55251503e-01f, 5.52076280e-01f, -4.80592608e-01f, -3.01878378e-02f, 2.79077023e-01f, -8.31754804e-02f, -1.92735136e-01f, 2.18742222e-01f, 3.93426344e-02f, 7.97147863e-03f,
  8.77012685e-02f, -8.43830332e-02f, 1.77205667e-01f, -1.03019662e-01f, 5.98534569e-02f, -1.39671415e-01f, 7.95605928e-02f, -1.67701378e-01f, 6.34815684e-03f, 2.89847255e-02f,
  -3.05144161e-01f, 7.33808205e-02f, 1.49473399e-01f, -7.53954053e-02f, 1.02349930e-01f, 2.38254806e-03f, 1.36732489e-01f, 1.11510783e-01f, 6.51504695e-02f, 3.19319576e-01f,
  -2.55631536e-01f, 8.23836923e-02f, -3.44483107e-02f, -8.26123282e-02f, -2.65656143e-01f, 4.48885234e-03f, 3.93054076e-02f, -6.70397282e-02f, -1.63868591e-01f, -5.54334745e-02f,
  2.59578414e-02f, -8.04280341e-02f, 3.21827643e-02f, 2.50168238e-02f, 7.49712344e-03f, 1.26108065e-01f, 3.17255817e-02f, -6.95160255e-02f, 2.03945525e-02f, 9.05477908e-03f,
  -9.29516628e-02f, -1.39656179e-02f, 1.57089695e-01f, -4.88599800e-02f, 2.51996722e-02f, 2.36157272e-02f, -7.04792663e-02f, 6.78896233e-02f, -4.34996281e-03f, -1.11923292e-02f,
  -1.68179318e-01f, -3.73766452e-01f, 1.87577438e-02f, -1.51734069e-01f, 3.87849621e-02f, 3.68700437e-02f, -8.08390155e-02f, -2.20125709e-02f, 1.87228858e-01f, 1.35096103e-01f,
  4.37079705e-02f, 2.77662072e-02f, 2.27665856e-01f, -1.80159599e-01f, -3.04186285e-01f, 2.50653829e-02f, -2.41029233e-01f, -5.91837801e-02f, -2.46627167e-01f, 1.12068579e-01f,
  -5.80466874e-02f, -3.72000188e-01f, -3.54779392e-01f, -2.52545804e-01f, -6.25940487e-02f, -2.71323591e-01f, -9.28362533e-02f, -1.85278460e-01f, -4.41041648e-01f, -3.54172230e-01f,
  3.06906551e-01f, -3.82825546e-02f, 3.09462011e-01f, 1.75887018e-01f, -3.39098305e-01f, -4.65597123e-01f, -4.28203076e-01f, -3.72980505e-01f, -8.51018727e-02f, -8.75282586e-02f,
  -2.50620633e-01f, 2.22164486e-02f, 1.13879547e-01f, 2.79664844e-01f, 1.89269364e-01f, 2.27610216e-01f, 4.20066327e-01f, 5.65570116e-01f, 3.16468388e-01f, 2.05778807e-01f,
  1.80403024e-01f, 2.29800925e-01f, 2.83196658e-01f, 4.30830717e-01f, 4.46797401e-01f, 1.66701093e-01f, 1.22584589e-02f, 2.12479070e-01f, 1.69368804e-01f, 6.85356915e-01f,
  1.94160387e-01f, -1.67160854e-01f, -9.16653425e-02f, 5.00706248e-02f, 7.26735443e-02f, 1.25743374e-01f, 8.40832964e-02f, 3.96693982e-02f, -7.40650743e-02f, 9.08081681e-02f,
  -5.24522290e-02f, 3.53793278e-02f, 9.01639909e-02f, 6.58238083e-02f, -7.91574270e-02f, -1.33994117e-01f, 6.97719604e-02f, 2.10159183e-01f, 9.01443660e-02f, 9.55602229e-02f,
  2.59221703e-01f, -8.57633278e-02f, -2.65984058e-01f, -2.90940642e-01f, -2.51670983e-02f, 1.44350901e-01f, -2.89666504e-02f, 6.50780872e-02f, -2.41618708e-01f, 1.53319374e-01f,
  6.13966174e-02f, 3.07278298e-02f, 8.99119377e-02f, 2.91927848e-02f, 6.83657601e-02f, 2.79012807e-02f, 7.10990503e-02f, -3.43101397e-02f, 8.63326043e-02f, 1.19238645e-01f,
  1.59822002e-01f, 1.38890222e-01f, 1.43562868e-01f, -1.96714816e-03f, 7.04020485e-02f, 1.41275272e-01f, 1.08012363e-01f, 2.77844183e-02f, -9.62965935e-02f, -4.82667126e-02f,
  1.59261450e-02f, 7.89268389e-02f, 1.37550421e-02f, 1.70192853e-01f, 7.50402659e-02f, 5.29451109e-02f, 1.73650041e-01f, -2.15813927e-02f, -3.53508117e-03f, 7.32890423e-03f,
  -6.44589186e-01f, -4.57997948e-01f, 1.54245421e-01f, 7.25163072e-02f, -5.21064512e-02f, -1.75743923e-01f, 3.60622071e-02f, -6.05476499e-02f, -5.24705090e-02f, 7.72515312e-02f,
  -2.33393580e-01f, -1.78360920e-02f, -2.06148520e-01f, -1.98303331e-02f, 5.73107637e-02f, -2.23999858e-01f, -3.81351523e-02f, 2.01845706e-01f, -6.81186989e-02f, 2.08400842e-02f,
  1.85428392e-02f, -3.18878174e-01f, -3.33881110e-01f, -2.08485603e-01f, -1.02914371e-01f, -2.09500805e-01f, -2.77334362e-01f, -2.11650386e-01f, -3.91465694e-01f, -3.58418107e-01f,
  -3.22264731e-02f, -3.02312911e-01f, -1.21151075e-01f, -1.17576465e-01f, -2.72126377e-01f, -4.03682411e-01f, -5.63136518e-01f, -1.84690446e-01f, 1.03063352e-01f, -4.10117418e-01f,
  -2.19656900e-01f, 4.09556702e-02f, 1.52436020e-02f, -1.73904583e-01f, -3.15619260e-01f, -4.34045047e-01f, -2.24827915e-01f, -2.47089893e-01f, -3.24149966e-01f, -4.14752066e-01f,
  -4.28029299e-01f, -2.22353339e-01f, -1.62898600e-01f, -8.55061412e-02f, -4.06575911e-02f, 4.04841267e-02f, 4.42343578e-02f, -1.37238741e-01f, -2.19305873e-01f, -1.45484418e-01f,
  -3.60634089e-01f, 4.91335206e-02f, -1.26398191e-01f, 6.11064322e-02f, 4.63115871e-02f, -1.07765228e-01f, -1.12578243e-01f, 6.51129559e-02f, -1.63757498e-03f, -9.80771258e-02f,
  -1.78122073e-02f, -1.09495454e-01f, -6.08147345e-02f, -2.07890972e-01f, -1.47483528e-01f, -9.07702595e-02f, -3.93878706e-02f, -1.69286132e-02f, 8.33965167e-02f, -9.50291902e-02f,
  -2.00798407e-01f, -1.08528949e-01f, 7.58897439e-02f, 5.98575361e-02f, 5.25554977e-02f, -9.32541769e-03f, -7.72719011e-02f, 1.21691618e-02f, 3.40563841e-02f, -2.07260419e-02f,
  1.79638956e-02f, 7.60680065e-02f, 1.08899325e-02f, -1.56873148e-02f, 3.30245197e-02f, 1.65422440e-01f, 1.45634055e-01f, -1.11095451e-01f, 4.08750847e-02f, -7.60356057e-03f,
  -3.44907232e-02f, -4.60440032e-02f, 7.22065568e-02f, 4.71236892e-02f, 1.24269677e-02f, -4.53994311e-02f, 4.42930460e-02f, -5.57288490e-02f, 1.89053975e-02f, 8.50596651e-02f,
  -4.30594347e-02f, -3.83114107e-02f, 2.53261831e-02f, -6.03493536e-03f, -5.61468191e-02f, -1.65704675e-02f, -3.44042443e-02f, 6.51867362e-03f, -2.30633542e-02f, -3.24261002e-02f,
  1.22108042e-01f, 4.97182049e-02f, -4.33827974e-02f, -1.84126087e-02f, -2.26306543e-02f, 1.47374943e-01f, 1.22121669e-01f, -1.35052204e-02f, 6.44214675e-02f, -1.95291042e-01f,
  -1.06158972e-01f, -2.07747161e-01f, -5.64632975e-02f, -1.65574495e-02f, -1.15466826e-01f, 4.78250068e-03f, -1.50442570e-01f, -6.98222741e-02f, 2.60270736e-03f, 8.37988481e-02f,
  3.92130576e-02f, -1.86584681e-01f, -1.24667749e-01f, 7.72124669e-03f, 1.07484177e-01f, -1.66578684e-02f, -6.89615235e-02f, -1.07804194e-01f, 2.44069248e-02f, -2.04105839e-01f,
  -3.70443732e-01f, -3.39235663e-01f, -2.98672497e-01f, -8.27752650e-02f, 7.42637971e-03f, -3.61617357e-02f, -2.40189984e-01f, 2.02826589e-01f, 1.39957577e-01f, -3.89753163e-01f,
  -1.34945899e-01f, -6.34880811e-02f, -3.31219375e-01f, -1.77633479e-01f, -4.49330956e-01f, -5.61572790e-01f, -5.26662171e-01f, -5.06014466e-01f, -5.25476895e-02f, 2.46194318e-01f,
  -5.63950129e-02f, -1.67590871e-01f, -2.18594164e-01f, -3.90815437e-02f, 1.46650374e-01f, -3.13504338e-02f, -2.33641803e-01f, -2.14646459e-01f, -2.04309240e-01f, -3.85643154e-01f,
  2.99527571e-02f, 3.08372587e-01f, 6.07626140e-02f, 1.19444281e-02f, -5.36150970e-02f, 7.46224746e-02f, 7.35507682e-02f, -1.26594733e-02f, -2.86467802e-02f, -1.12988375e-01f,
  -1.51018212e-02f, 9.97334495e-02f, 4.92793657e-02f, -2.77920887e-02f, 5.35556674e-02f, 4.22080159e-02f, 3.92674096e-03f, -3.10980007e-02f, -1.42355815e-01f, 5.50538525e-02f,
  -1.54518738e-01f, -2.59977400e-01f, -1.73048571e-01f, -4.03628014e-02f, 1.55419856e-01f, -1.14943698e-01f, 2.06310630e-01f, 2.15583310e-01f, -2.31630858e-02f, -1.59309506e-01f,
  3.38065438e-02f, -5.81712686e-02f, 7.76547119e-02f, 1.43018454e-01f, -9.51988026e-02f, -5.81787676e-02f, 1.05366642e-02f, -8.40139538e-02f, 8.47271010e-02f, 4.09060195e-02f,
  7.76160359e-02f, 3.72886099e-02f, 8.98825452e-02f, 3.45098414e-02f, -1.37615893e-02f, -1.43267781e-01f, -1.19419791e-01f, -1.20810285e-01f, -4.44748811e-02f, -6.22089319e-02f,
  -9.20129195e-02f, -2.47711483e-02f, 1.62518267e-02f, -6.62381155e-03f, 2.23213639e-02f, -4.87583764e-02f, 1.07370332e-01f, 1.82538033e-01f, 7.37782419e-02f, 3.23646516e-02f,
  1.35590389e-01f, -4.68641669e-02f, -2.15535060e-01f, -3.49416770e-02f, -6.97517991e-02f, 1.21966675e-01f, -5.30677997e-02f, -6.68870881e-02f, -1.14316851e-01f, -4.67145704e-02f,
  1.35336906e-01f, 2.66364100e-03f, 2.75447033e-03f, 2.84678508e-02f, 6.11451641e-02f, 5.76752163e-02f, -1.44931123e-01f, -1.90983772e-01f, -1.73536986e-01f, 2.52705604e-01f,
  -1.14030741e-01f, -3.65374416e-01f, -3.99481654e-01f, -2.67988533e-01f, 6.56504929e-02f, -2.23690316e-01f, -1.17135145e-01f, 1.86624974e-02f, -2.52612382e-01f, -3.07657361e-01f,
  8.76957119e-01f, -1.65083647e-01f, -6.55311868e-02f, 3.64898443e-01f, 3.44657183e-01f, 4.50841486e-01f, 3.96586627e-01f, 4.54314351e-01f, 4.21434402e-01f, 2.65886754e-01f,
  7.40881041e-02f, 1.50002688e-01f, 6.76571056e-02f, -7.52651095e-02f, 8.11641514e-02f, 3.63338292e-02f, 8.53550285e-02f, -3.93887758e-02f, 2.36874640e-01f, 1.30860597e-01f,
  1.31239712e-01f, 1.26912981e-01f, 5.54924197e-02f, 9.53084081e-02f, -1.43646136e-01f, 6.41789241e-03f, -8.44123438e-02f, -5.89324869e-02f, -2.47328281e-01f, -2.84449071e-01f,
  -7.62125134e-01f, -1.57381684e-01f, 1.31060049e-01f, -9.13868546e-02f, -2.39805683e-01f, 4.29786891e-02f, 5.42744137e-02f, -2.41892822e-02f, 7.91579336e-02f, -1.61683615e-02f,
  -2.01830313e-01f, -4.44669798e-02f, -1.35174513e-01f, -3.18757668e-02f, 3.77360359e-02f, -2.91854646e-02f, 5.20248599e-02f, 1.09560611e-02f, -7.29396641e-02f, -1.86183661e-01f,
  -1.03934728e-01f, 4.43661325e-02f, 5.54718226e-02f, 4.28886153e-02f, -1.01763301e-01f, 3.03944219e-02f, -5.33843264e-02f, -1.21482238e-02f, 5.62088042e-02f, 1.04598060e-01f,
  6.29217550e-02f, 1.25291608e-02f, -2.03442812e-01f, 9.73634305e-04f, -1.20975964e-01f, 6.98362812e-02f, 1.79680325e-02f, -7.00433366e-03f, -7.03881085e-02f, -5.60631268e-02f,
  1.18402220e-01f, -2.12456167e-01f, -6.98981285e-02f, -7.05972761e-02f, -1.34673774e-01f, -7.93375149e-02f, -4.24181223e-02f, -1.48581669e-01f, -3.08176219e-01f, -1.86041206e-01f,
  -7.34025985e-02f, -5.59241287e-02f, -8.64102393e-02f, -1.87148958e-01f, -1.80656895e-01f, 4.62527871e-02f, 2.06498280e-02f, -2.45712847e-02f, 9.20718163e-02f, 1.92004874e-01f,
  -2.75568873e-01f, -2.24479988e-01f, -7.94899464e-02f, -5.61114848e-02f, -1.34999558e-01f, -1.34709403e-01f, -2.38227069e-01f, -9.57847014e-02f, -1.89940557e-01f, -3.75790633e-02f,
  -6.46748692e-02f, -1.12461997e-02f, -1.34006798e-01f, -3.87464352e-02f, 1.99797913e-01f, 9.71594006e-02f, -3.93873751e-02f, 1.42772973e-01f, -5.52302115e-02f, -6.11403622e-02f,
  -4.79859076e-02f, 1.71315745e-01f, 2.29233056e-01f, 1.49779454e-01f, -1.81553494e-02f, 1.44345313e-01f, 4.82897125e-02f, 7.07020834e-02f, 5.99618889e-02f, 3.07507783e-01f,
  -8.46465349e-01f, -1.20842345e-01f, -1.48636580e-01f, 3.51155805e-03f, 2.92245001e-01f, 1.24226801e-01f, 1.61944941e-01f, -2.86978930e-02f, -1.73616875e-02f, 5.63584045e-02f,
  9.51638296e-02f, 2.48038188e-01f, 3.01097304e-01f, 2.10972384e-01f, 2.32495844e-01f, 1.94164246e-01f, 2.26670831e-01f, 9.33266506e-02f, -1.09333992e-02f, 9.42342952e-02f,
  2.95775563e-01f, 1.66080981e-01f, -1.04311325e-01f, 6.49558082e-02f, 7.33597130e-02f, 2.19401613e-01f, 1.59102678e-01f, 2.08492026e-01f, 3.24281722e-01f, 2.24722773e-01f,
  2.05879450e-01f, -2.65406877e-01f, 1.31113268e-02f, -7.97732640e-03f, -5.20908870e-02f, -2.49283254e-01f, -1.66040391e-01f, -5.03265187e-02f, -2.67530177e-02f, 1.15266368e-01f,
  5.27243838e-02f, -8.01711231e-02f, -6.77440166e-02f, -5.02454117e-02f, -1.29773751e-01f, -9.16749984e-02f, -8.68532583e-02f, 6.54119104e-02f, 1.14419177e-01f, 1.92254875e-02f,
  6.26086593e-02f, -5.98112158e-02f, 1.04633227e-01f, 4.91630249e-02f, -2.02618334e-02f, 5.58964834e-02f, 3.89531553e-02f, -3.91100571e-02f, 2.90560480e-02f, -4.24927771e-02f,
  1.24621794e-01f, -1.29511341e-01f, -1.81929722e-01f, -2.17380002e-02f, -6.50264993e-02f, -7.11510256e-02f, 3.72954085e-02f, 9.25155357e-02f, -4.82803024e-02f, -1.52928159e-02f,
  4.67155017e-02f, 1.36080638e-01f, -1.30968750e-01f, 9.18290578e-03f, -4.90246639e-02f, -7.38553628e-02f, -1.88099027e-01f, 1.58322528e-02f, 2.02890094e-02f, -1.17247470e-01f,
  1.04380943e-01f, 9.73739251e-02f, -9.99598801e-02f, 9.81170759e-02f, 1.01906294e-02f, 2.00542924e-03f, 2.57132910e-02f, 1.00550033e-01f, 5.49629098e-03f, 3.77815105e-02f,
  5.51551104e-01f, 1.95870653e-01f, -6.31811470e-02f, -1.27624452e-01f, -1.74628440e-02f, -2.29897320e-01f, -1.17313556e-01f, -6.72441497e-02f, 1.02685146e-01f, -5.36266640e-02f,
  -4.82396130e-03f, -1.35944054e-01f, -2.16444600e-02f, 1.15349293e-02f, -1.43757761e-01f, -1.41983498e-02f, -7.71127343e-02f, 1.01240553e-01f, 1.13347098e-01f, -7.08956271e-02f,
  -2.45977137e-02f, 6.54599220e-02f, -3.92137468e-02f, 4.41676006e-02f, 6.79475442e-02f, 1.05793782e-01f, 4.08107862e-02f, -7.33471587e-02f, 5.56592606e-02f, 8.17300752e-02f,
  -3.19469050e-02f, 4.44604307e-01f, 4.45826083e-01f, -1.05941541e-01f, 4.44573849e-01f, 2.39128366e-01f, 1.31534144e-01f, -3.26488405e-01f, -1.02646336e-01f, 3.13424170e-01f,
  5.17215550e-01f, -1.13921084e-01f, -1.07372612e-01f, -3.42636019e-01f, -5.61362743e-01f, -2.23417580e-01f, -9.17072445e-02f, -4.09957290e-01f, -7.32359886e-01f, -4.56210226e-01f,
  -1.58461303e-01f, -1.33423597e-01f, -3.36126596e-01f, -2.06001773e-01f, 1.40735686e-01f, 1.70092769e-02f, 4.22027975e-01f, 2.67241478e-01f, 3.55596006e-01f, 1.75062954e-01f,
  7.76702836e-02f, 2.30366275e-01f, -3.45796436e-01f, -5.92247583e-02f, 2.86571175e-01f, -2.48520613e-01f, 6.71672672e-02f, -5.39027415e-02f, -1.10654630e-01f, -1.45156831e-01f,
  1.93360150e-01f, -2.99174208e-02f, 1.56317458e-01f, -3.76531594e-02f, -5.77836558e-02f, -1.43183887e-01f, -1.82527646e-01f, -3.76066387e-01f, -2.73777753e-01f, -3.15453224e-02f,
  2.44665280e-01f, 2.89254367e-01f, 2.04713494e-01f, -5.45651391e-02f, -1.88447371e-01f, -8.04464072e-02f, 9.89756361e-02f, -1.33970380e-01f, -6.12331182e-02f, -1.72444776e-01f,
  -1.34679034e-01f, 7.43982270e-02f, -7.89200887e-03f, -1.01966061e-01f, -9.04909000e-02f, -4.39379970e-03f, -3.01107671e-02f, -2.36698147e-02f, -7.08215758e-02f, -4.57078069e-02f,
  -1.14778550e-02f, 5.38465306e-02f, -1.62485152e-01f, 8.02507922e-02f, -3.17051932e-02f, 7.50783607e-02f, 1.56326860e-01f, -1.19879767e-01f, 1.04363756e-02f, -2.79277307e-03f,
  -1.36291921e-01f, 4.85312454e-02f, 1.46290869e-01f, -1.07179902e-01f, 5.27773425e-02f, 1.14909410e-01f, -5.25878146e-02f, -6.50810078e-02f, -7.66705498e-02f, 1.85857609e-01f,
  -3.11082125e-01f, 1.52789280e-01f, -2.16255739e-01f, -1.76248431e-01f, 1.87077001e-01f, 1.14194840e-01f, 2.31645808e-01f, 1.52904883e-01f, 2.62967318e-01f, -2.05022812e-01f,
  6.91703558e-02f, 8.53827130e-03f, 2.10538507e-01f, 9.33820382e-03f, -1.05632044e-01f, -2.45947987e-02f, 1.36662798e-03f, 6.98730946e-02f, -1.74299136e-01f, 9.41915140e-02f,
  -1.73906665e-02f, -3.89833391e-01f, -3.37655276e-01f, -1.06583767e-01f, -1.55105263e-01f, -2.93453693e-01f, -2.31741473e-01f, -8.56668204e-02f, -1.84546903e-01f, -4.18779463e-01f,
  1.67211697e-01f, 1.39722854e-01f, -7.68392608e-02f, -3.45647410e-02f, -2.75407225e-01f, -3.37987214e-01f, 4.06563431e-02f, -1.62843183e-01f, -9.74354818e-02f, 3.65677625e-01f,
  6.63881153e-02f, -1.85672060e-01f, 2.01630846e-01f, -1.35315523e-01f, -1.00726567e-01f, 3.26695651e-01f, 2.64015406e-01f, -2.01974824e-01f, -5.70580065e-01f, -6.16854727e-01f,
  -1.78257659e-01f, -6.43650517e-02f, -1.71191633e-01f, -1.40856937e-01f, -3.56051549e-02f, -3.13353352e-02f, 1.96931496e-01f, -5.53962812e-02f, -1.61485314e-01f, 6.48047626e-02f,
  2.79870272e-01f, -2.70342946e-01f, -1.36481777e-01f, -1.24382772e-01f, 1.48856491e-01f, 2.24174056e-02f, -9.54191461e-02f, -1.64695576e-01f, 7.85557646e-03f, -4.28139865e-02f,
  -8.48545358e-02f, -1.62480742e-01f, -2.45902881e-01f, -1.08301684e-01f, -5.60338087e-02f, -1.42575040e-01f, -9.16268975e-02f, -1.81121454e-01f, -5.17639657e-03f, -1.67636629e-02f,
  -9.62668732e-02f, -2.04160720e-01f, -9.80847552e-02f, -4.51612063e-02f, -2.14675710e-01f, -9.09579322e-02f, -1.23587124e-01f, -3.44293028e-01f, -1.65330455e-01f, 2.92021036e-01f,
  -2.23085731e-02f, 1.05849579e-01f, -5.85252233e-02f, -1.03544351e-02f, 9.80015621e-02f, 2.94950306e-02f, 2.17838697e-02f, 3.42447683e-02f, -7.20819160e-02f, 7.31324181e-02f,
  -5.53159788e-02f, 8.44876561e-03f, -3.04217394e-02f, 6.50861114e-02f, -1.89206488e-02f, -1.46192670e-01f, -1.34785790e-02f, 1.17981315e-01f, 6.71522170e-02f, -3.15062739e-02f,
  -1.33033440e-01f, -2.01500565e-01f, 2.75225155e-02f, -8.10113561e-04f, -1.02554141e-02f, -4.24843207e-02f, -2.69016027e-02f, -3.56069244e-02f, -5.47559373e-03f, -4.67362031e-02f,
  5.87408245e-01f, -1.92469954e-01f, 3.22197527e-01f, 4.96863248e-03f, 1.89800039e-02f, -9.55537409e-02f, 1.92160625e-02f, -5.15606403e-02f, -1.41256358e-02f, -7.15121776e-02f,
  -2.17003673e-01f, -1.27343193e-01f, 4.06547152e-02f, -5.16213998e-02f, -1.27326086e-01f, -6.26714453e-02f, 3.43248099e-02f, -2.98722298e-03f, -9.38830003e-02f, -1.51616871e-01f,
  -1.38571532e-02f, 9.33135003e-02f, 3.36106122e-01f, 3.14474881e-01f, -6.95125684e-02f, 1.44514859e-01f, 3.38713229e-01f, 5.62264249e-02f, 2.16642752e-01f, 6.42698169e-01f,
  -4.15383071e-01f, -8.69426038e-03f, 4.85395283e-01f, -3.42384338e-01f, -3.84833395e-01f, -3.74268919e-01f, -5.35752177e-01f, -3.53480548e-01f, -1.42538965e-01f, -2.27842815e-02f,
  -1.37818113e-01f, -1.30270034e-01f, 7.83448070e-02f, 7.49569619e-03f, -3.70887779e-02f, 1.86929628e-01f, 3.53940874e-01f, 2.21588448e-01f, -2.07795754e-01f, -4.56462741e-01f,
  -3.34327638e-01f, -1.44703716e-01f, 7.21190348e-02f, 1.83486894e-01f, 1.53905705e-01f, 7.39349006e-03f, 3.13725203e-01f, 7.63983130e-02f, 2.78892249e-01f, 6.03069186e-01f,
  3.43852311e-01f, 1.06886454e-01f, -8.64384994e-02f, 4.99873720e-02f, -2.40135156e-02f, 1.02707157e-02f, -6.84803948e-02f, 1.29199013e-01f, -5.45795485e-02f, 1.25619039e-01f,
  -9.44472924e-02f, -7.04066735e-03f, -2.53868788e-01f, 4.93944995e-02f, -2.60698140e-01f, -2.50417531e-01f, 2.93050930e-02f, 1.13823324e-01f, 1.12058394e-01f, 1.03954539e-01f,
  -1.52871981e-01f, -2.89107859e-01f, -1.11129880e-01f, -6.55679405e-03f, 2.86034960e-02f, 3.77645940e-02f, -3.90339307e-02f, 2.61212811e-02f, 2.89832545e-03f, 4.52679619e-02f,
  9.06103700e-02f, 1.13828681e-01f, -1.87098756e-02f, 1.01718567e-01f, -1.43788025e-01f, 1.07060157e-01f, 1.61540180e-01f, -7.81992152e-02f, 1.95689633e-01f, 2.45494042e-02f,
  -7.63663277e-02f, 3.26103568e-02f, -9.08846408e-03f, -7.27187023e-02f, 1.21167675e-01f, -4.88988273e-02f, -1.33353561e-01f, -2.06151176e-02f, 1.55862540e-01f, 1.85319912e-02f,
  -1.54565610e-02f, -2.61434466e-02f, 7.42141083e-02f, -3.07437573e-02f, 3.35881352e-01f, 1.29558414e-01f, 7.96357021e-02f, -1.26910165e-01f, -1.42795503e-01f, 3.48533057e-02f,
  -5.07615089e-01f, 1.28654554e-01f, -1.84345525e-02f, 1.01812510e-02f, -9.90664214e-02f, 4.76408750e-02f, 9.05032903e-02f, -4.78652641e-02f, -5.40713705e-02f, -6.83748629e-03f,
  -1.16415016e-01f, -6.50676563e-02f, -1.28278553e-01f, 6.71812743e-02f, -1.58444509e-01f, -9.15225744e-02f, -1.59425750e-01f, -2.09901422e-01f, -7.24951029e-02f, -1.31459936e-01f,
  -8.02070126e-02f, -4.52274650e-01f, -5.04392326e-01f, -4.40428883e-01f, -2.53162950e-01f, -4.66985047e-01f, -1.47579312e-01f, -2.68580049e-01f, -3.36333215e-01f, -5.82201421e-01f,
  -1.79872900e-01f, -4.21803482e-02f, -6.33402616e-02f, 4.01380450e-01f, 4.51467097e-01f, 2.89293796e-01f, 2.23274618e-01f, 1.64606720e-01f, 1.21393763e-01f, 1.76760837e-01f,
  7.36346021e-02f, 2.14693725e-01f, 2.67553061e-01f, 2.73628742e-01f, 5.52851222e-02f, 1.39027789e-01f, 1.35639384e-01f, -1.37717323e-02f, 5.37173040e-02f, 1.25210688e-01f,
  1.61532566e-01f, -1.10804327e-01f, -2.98957586e-01f, -2.58630477e-02f, -1.26105975e-02f, 1.91983730e-01f, 9.52827279e-03f, -6.27067983e-02f, 1.67706475e-01f, 9.79890898e-02f,
  3.07304785e-03f, -1.70521766e-01f, 3.12813342e-01f, -6.55314103e-02f, -3.73119265e-02f, -1.08628593e-01f, -1.94160312e-01f, -3.44933659e-01f, -8.79745558e-02f, -8.27974975e-02f,
  -2.01592162e-01f, -2.19806641e-01f, 1.74609050e-02f, -1.05548784e-01f, -1.78101555e-01f, -1.48406103e-01f, -2.16449007e-01f, -3.16343278e-01f, -2.15331033e-01f, -2.43384272e-01f,
  1.92485631e-01f, -1.93936437e-01f, -2.98494548e-01f, -2.37051696e-02f, -1.11795180e-01f, 3.49865342e-03f, -3.61895144e-01f, -2.27513090e-01f, -2.06790492e-01f, -3.95120710e-01f,
  -4.33840491e-02f, -8.55776072e-02f, -4.44343984e-02f, -2.46947497e-01f, 1.08297937e-01f, 1.07561965e-02f, 2.60762334e-01f, 2.34750479e-01f, 8.93781427e-03f, -7.68000931e-02f,
  1.24441661e-01f, 3.32529433e-02f, -1.28033310e-01f, -4.90386831e-03f, 8.88585374e-02f, -4.78727967e-02f, 3.62051390e-02f, 3.32687385e-02f, -5.58963418e-02f, -1.00508295e-01f,
  -3.56372669e-02f, -7.84093365e-02f, -2.02245697e-01f, -4.34908643e-02f, 5.38069308e-02f, 7.41781220e-02f, -7.48256370e-02f, -8.00080225e-03f, -2.39420515e-02f, -2.70251274e-01f,
  -3.54793556e-02f, -1.72174927e-02f, 3.60767283e-02f, -1.32700950e-01f, -4.97188307e-02f, 1.16558291e-01f, 2.21968815e-02f, 6.86207712e-02f, -5.81524102e-03f, 1.19365916e-01f,
  -1.54063299e-01f, 8.19391385e-02f, -7.51924068e-02f, -2.43627846e-01f, 8.60800669e-02f, -1.19779587e-01f, -4.60693799e-02f, 9.39517766e-02f, -1.55986711e-01f, -2.95080692e-01f,
  7.50631094e-02f, -1.21472515e-01f, -3.95938605e-02f, 9.79568735e-02f, -1.63614154e-01f, 1.56864017e-01f, -2.61892527e-01f, -2.41963804e-01f, -9.73518416e-02f, -1.30641833e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.34750471e-01f, 6.18985474e-01f, 4.75512385e-01f, 5.78049719e-01f, 7.29581237e-01f, 8.35043907e-01f, 3.43775749e-01f, 5.44021487e-01f, 5.68291008e-01f, 3.42532307e-01f,
  4.38012630e-01f, 5.92872560e-01f, 5.09110928e-01f, 3.51584464e-01f, 5.23343921e-01f, 4.50182587e-01f, 2.17223614e-01f, 7.26298511e-01f, 1.11045837e-01f, 6.84178352e-01f,
  3.99374425e-01f, 6.14424109e-01f, 6.15764976e-01f, 7.79912591e-01f, 7.40742326e-01f, 1.01642513e+00f, 6.38065219e-01f, 6.13759160e-01f, 3.04535329e-01f, 6.49806857e-01f,
  5.20668924e-01f, 2.60680705e-01f, 2.00259298e-01f, -1.97131149e-02f, 5.81272483e-01f, 3.56828123e-01f, 4.93311167e-01f, 5.50241232e-01f, 5.09257615e-01f, 9.48141217e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.32332101e-01f, -3.79050493e-01f, -3.79074901e-01f, -2.39264235e-01f, 2.06472613e-02f, -1.55041724e-01f, -2.43367851e-01f, 1.73626915e-01f, 2.03946140e-03f, 2.04529330e-01f,
  -1.35478377e-01f, 1.82952527e-02f, -8.97718072e-02f, -1.43234491e-01f, -8.11007544e-02f, 4.27105650e-03f, 2.75831163e-01f, -2.68737733e-01f, 1.35427311e-01f, 2.57020462e-02f,
  9.08749476e-02f, 1.20846301e-01f, -1.29107133e-01f, -1.52344570e-01f, 3.78903359e-01f, -4.95166421e-01f, -3.92910272e-01f, -2.50750393e-01f, -6.06095254e-01f, -3.66533220e-01f,
  1.54101536e-01f, 1.24393098e-01f, 1.31392986e-01f, 4.67942208e-01f, -6.36334643e-02f, -2.54023254e-01f, -4.49214041e-01f, 3.78369361e-01f, 4.02694345e-02f, 1.29770443e-01f,
  2.67113119e-01f, -5.17506123e-01f, 3.93067002e-01f, -3.81992906e-01f, -1.01421624e-01f, -1.56404585e-01f, -3.04060757e-01f, -8.20601225e-01f, -6.80631399e-01f, 5.12723804e-01f,
  1.30595267e-02f, -2.49801159e-01f, 2.14292362e-01f, -5.69333434e-01f, -7.39422798e-01f, -3.77592593e-02f, 1.18071213e-01f, 5.24717033e-01f, -1.48046389e-01f, -2.67953753e-01f,
  -5.85219026e-01f, -8.03016722e-01f, -4.99385864e-01f, -3.73892426e-01f, 1.19065106e-01f, 6.90362230e-02f, 2.72757024e-01f, -3.90903294e-01f, 6.22514114e-02f, -2.75736123e-01f,
  2.44195744e-01f, 5.14783598e-02f, -2.54712850e-01f, 1.08414494e-01f, 9.35033485e-02f, 2.82766134e-01f, -6.04444221e-02f, -1.32156285e-02f, 2.99270153e-01f, 7.32349604e-02f,
  6.72588423e-02f, -2.34310597e-01f, 1.01351082e-01f, -2.12856770e-01f, 4.80232120e-01f, -1.60508245e-01f, 4.14683104e-01f, -2.52319276e-01f, -7.55587757e-01f, -5.87636411e-01f,
  -4.22718227e-01f, 3.41844887e-01f, -5.84834456e-01f, -1.04635978e+00f, -4.27848876e-01f, 5.53924799e-01f, -7.68362761e-01f, -6.25321329e-01f, 2.81278670e-01f, -8.70684564e-01f,
  -3.92448902e-01f, 2.00662643e-01f, -3.54333162e-01f, -3.03908080e-01f, -1.41197965e-02f, -4.46924716e-01f, 3.09052527e-01f, -3.86538029e-01f, 1.47804692e-01f, 6.65255561e-02f,
  -2.03533381e-01f, -1.01102841e+00f, -4.60794449e-01f, 5.28242469e-01f, 5.35992444e-01f, 4.74264652e-01f, 3.96279007e-01f, 8.57691348e-01f, -5.04110098e-01f, -3.85843664e-02f,
  4.11026984e-01f, -5.34366727e-01f, 1.33514643e-01f, -1.11736163e-01f, -5.43918371e-01f, -3.35952006e-02f, -7.77388215e-01f, 5.09643912e-01f, 1.03784971e-01f, 1.00015424e-01f,
  1.13689110e-01f, 1.49520755e-01f, -8.66736844e-02f, 2.46072561e-01f, 1.31291971e-01f, -1.97871067e-02f, -7.38197938e-02f, -1.14995919e-01f, -2.06594132e-02f, 8.40481296e-02f,
  -8.32859576e-02f, -3.24657440e-01f, -2.01104343e-01f, 3.26736927e-01f, 3.22407693e-01f, -4.11451012e-02f, 5.28891906e-02f, 3.29705179e-01f, -5.29996753e-02f, -3.75899881e-01f,
  2.88783073e-01f, 6.32586703e-02f, 1.26222791e-02f, -1.83182240e-01f, -2.76671618e-01f, 1.67348549e-01f, -3.10780376e-01f, -3.75276715e-01f, -4.65824932e-01f, -2.46506020e-01f,
  2.66619623e-01f, 4.71489847e-01f, -3.51165444e-01f, -2.03384027e-01f, 9.26360905e-01f, -6.46119952e-01f, 2.96892792e-01f, -3.02109629e-01f, -1.30702838e-01f, -6.49096966e-01f,
  3.48171964e-02f, -3.82461160e-01f, -4.93059039e-01f, 2.68210024e-01f, -8.72660056e-02f, -3.80205661e-01f, 2.39754081e-01f, 6.59272611e-01f, 3.19153190e-01f, -1.56268016e-01f,
  -5.99395931e-01f, 8.23854506e-01f, -3.05137634e-01f, 1.91621155e-01f, -5.53859659e-02f, -4.37595785e-01f, -4.71696585e-01f, -2.59395450e-01f, -2.94590265e-01f, -4.46597129e-01f,
  5.89217722e-01f, -2.99773932e-01f, 1.06249325e-01f, -2.43483886e-01f, 3.15426111e-01f, -1.56547830e-01f, -1.01951361e-01f, -2.61361212e-01f, -1.15953423e-01f, -3.29721719e-01f,
  -2.55049706e-01f, 7.59681105e-04f, -2.89370149e-01f, -2.62490958e-01f, 2.10971594e-01f, -1.54691905e-01f, -3.85694057e-02f, 1.57247692e-01f, 5.25507033e-02f, 3.75227600e-01f,
  1.57727495e-01f, 1.22767515e-01f, -3.76533538e-01f, 1.49797101e-03f, -3.13508749e-01f, 3.12152475e-01f, -2.01000884e-01f, -6.04026794e-01f, -3.86510044e-01f, -3.21421772e-01f,
  7.47560263e-01f, -1.93222061e-01f, 1.41544677e-02f, -2.81273991e-01f, 3.05854203e-03f, 2.43258312e-01f, -2.77612805e-01f, -8.31337631e-01f, -2.87169456e-01f, 1.24414086e-01f,
  7.63701439e-01f, 3.51581097e-01f, 4.42292809e-01f, -1.14240611e+00f, -3.74762148e-01f, 4.43304002e-01f, -6.11787260e-01f, -5.12398005e-01f, 5.38748562e-01f, 3.70973408e-01f,
  -1.43584171e-02f, -9.75661874e-01f, 4.70119305e-02f, -5.47970355e-01f, 4.80277091e-01f, -2.27202639e-01f, -7.02803254e-01f, -3.17340851e-01f, -8.90950635e-02f, -6.38011657e-03f,
  -3.36010456e-01f, -2.45247990e-01f, 2.29264066e-01f, -1.81502268e-01f, 4.79174316e-01f, -4.71424609e-02f, -2.99354434e-01f, 6.61477298e-02f, -1.79191992e-01f, 3.93807590e-02f,
  -1.47735000e-01f, 1.21416613e-01f, -1.46822900e-01f, -1.96707845e-01f, 3.14305842e-01f, -1.53552234e-01f, 1.32877707e-01f, 2.67674378e-03f, -1.61157161e-01f, -2.10435525e-01f,
  1.60647929e-01f, 3.05367589e-01f, -2.06441209e-01f, 1.22336857e-01f, 1.18118137e-01f, 2.30162188e-01f, -3.97070646e-02f, 9.89510715e-02f, 6.26449138e-02f, 1.50422871e-01f,
  2.21234038e-01f, 7.66247585e-02f, 5.30750811e-01f, 1.04366414e-01f, 2.76117176e-01f, -3.07066530e-01f, 3.81833524e-01f, 1.80865794e-01f, -1.12974577e-01f, -5.13395190e-01f,
  -5.49309671e-01f, -1.40060574e-01f, 4.47129458e-01f, -4.67541367e-01f, -1.37853911e-02f, -1.13698788e-01f, 1.24394372e-02f, 2.74397463e-01f, -2.14523837e-01f, -4.70043659e-01f,
  1.96353376e-01f, -2.84241199e-01f, -2.44382575e-01f, -1.43961266e-01f, 5.62017821e-02f, -6.89332485e-01f, -5.97851872e-01f, -6.58091903e-02f, -4.59885091e-01f, 1.59164041e-01f,
  7.19545782e-01f, -7.75304258e-01f, 3.73115122e-01f, 2.30388090e-01f, 1.64301619e-01f, 1.04387969e-01f, 3.32946241e-01f, 1.11126199e-01f, 4.26066369e-01f, -4.22054470e-01f,
  2.72913218e-01f, 2.56412596e-01f, 9.71458703e-02f, 1.36017919e-01f, 2.12056160e-01f, 1.92564607e-01f, 2.29548797e-01f, 1.18967146e-01f, 1.23002633e-01f, 1.12346575e-01f,
  1.28866568e-01f, 1.12231702e-01f, 5.06635942e-02f, 2.13317484e-01f, 5.35258293e-01f, 2.31599689e-01f, -2.00393349e-01f, -3.07165831e-01f, -1.51430532e-01f, -2.81350583e-01f,
  3.38603765e-01f, 3.10391188e-01f, 2.34742135e-01f, -3.37356806e-01f, -3.03304374e-01f, 3.55876029e-01f, 1.35654643e-01f, -4.92530435e-01f, -8.82242322e-01f, 2.18011230e-01f,
  7.81883076e-02f, 3.42980735e-02f, 5.49487174e-01f, -5.10597289e-01f, 1.64909080e-01f, 6.26936316e-01f, -1.93100527e-01f, -1.33227892e-02f, -5.75338423e-01f, 6.81870282e-01f,
  -4.56668288e-01f, 8.84099960e-01f, 8.26166943e-02f, 1.55353785e-01f, -2.05551073e-01f, -1.42799065e-01f, -8.02793920e-01f, 4.02453691e-01f, -8.35297763e-01f, 1.16733231e-01f,
  -8.96645963e-01f, -2.56138653e-01f, 2.53647834e-01f, -7.54105985e-01f, -6.45365834e-01f, -6.81310475e-01f, -8.21510851e-02f, -3.09317917e-01f, 4.06761944e-01f, 1.27643883e-01f,
  -6.11074984e-01f, 6.72994137e-01f, -7.45695114e-01f, -2.77895313e-02f, 4.13105153e-02f, -3.08736563e-01f, 8.34375620e-02f, 7.39455968e-02f, -3.58308433e-03f, 3.66388895e-02f,
  2.75485069e-02f, 2.01502144e-01f, -3.24602164e-02f, -6.34998083e-03f, 8.22466165e-02f, 1.62420914e-01f, -7.80109987e-02f, 1.08966969e-01f, -1.06726572e-01f, -3.91976506e-01f,
  -1.76142439e-01f, 1.78606644e-01f, -1.70810282e-01f, 8.17235559e-02f, 7.03507140e-02f, -2.26389885e-01f, 2.50566989e-01f, -8.95951390e-02f, -8.54061663e-01f, 2.49492481e-01f,
  -5.51059306e-01f, -4.19852108e-01f, -2.74691463e-01f, 2.68315524e-01f, -5.13224602e-01f, -1.05401838e+00f, -6.11933470e-01f, 5.70017360e-02f, 5.37874550e-02f, 1.08960271e-01f,
  6.01233959e-01f, -1.24017030e-01f, -5.44277906e-01f, -3.06729406e-01f, -5.43321133e-01f, 7.04879105e-01f, -5.79746008e-01f, -6.51224911e-01f, 2.71444350e-01f, 5.87795198e-01f,
  -5.07107913e-01f, -3.27790439e-01f, -4.41098183e-01f, -6.25477016e-01f, -8.09905976e-02f, 3.11521739e-02f, -1.49878412e-01f, -6.67399108e-01f, 5.03102899e-01f, 5.57950616e-01f,
  -4.54648972e-01f, -2.79056728e-01f, -2.63095796e-01f, -5.57473421e-01f, -6.22142375e-01f, -1.06114112e-01f, 5.17579794e-01f, -5.12374461e-01f, -2.61374623e-01f, -5.73335364e-02f,
  -4.54808250e-02f, -3.54784206e-02f, -8.79801586e-02f, -3.40320587e-01f, 2.51620244e-02f, -1.74948424e-01f, -1.06180258e-01f, -1.09966889e-01f, -1.81052253e-01f, -4.14382249e-01f,
  2.15250239e-01f, 2.21282411e-02f, 7.37055019e-02f, -2.49002829e-01f, -1.29072666e-01f, 6.28173426e-02f, 9.91399214e-02f, 1.50875822e-01f, 3.03219557e-01f, 2.43911535e-01f,
  3.41144204e-01f, 1.36182889e-01f, -4.99972440e-02f, -3.78681272e-01f, -1.29343763e-01f, 1.97813854e-01f, 4.02549267e-01f, 2.57358346e-02f, -4.43260580e-01f, -3.09596896e-01f,
  7.04059482e-01f, 4.30281967e-01f, -3.95799503e-02f, 3.13655108e-01f, -9.05871540e-02f, -4.10569221e-01f, 6.95619658e-02f, -4.11637008e-01f, 1.94439843e-01f, 2.03400955e-01f,
  -3.57938379e-01f, 2.35308453e-01f, 4.24648896e-02f, -5.18813908e-01f, -2.80628532e-01f, 8.51300597e-01f, -1.21289372e-01f, -9.29897845e-01f, -3.16942215e-01f, -7.13491797e-01f,
  -5.64423442e-01f, -3.22403312e-01f, -8.00108686e-02f, 2.51582041e-02f, -1.40589029e-01f, -4.77271974e-02f, -1.52785346e-01f, 4.87600625e-01f, -1.12079987e-02f, -3.08961332e-01f,
  -2.25283757e-01f, 2.70062953e-01f, 1.14509918e-01f, 2.21317366e-01f, -1.06642455e-01f, 6.88183755e-02f, 7.89474994e-02f, -1.73204020e-02f, -1.29867457e-02f, -2.11283147e-01f,
  9.39061120e-02f, -2.09757656e-01f, 1.20767839e-01f, -7.81834405e-03f, 1.69544399e-01f, 1.26028314e-01f, -6.31287694e-01f, -2.09480137e-01f, 1.44641787e-01f, -3.23429048e-01f,
  -2.41613612e-01f, -1.72737509e-01f, -6.73923850e-01f, -3.85236651e-01f, -4.23979193e-01f, -3.38466652e-02f, -1.06514670e-01f, 6.04942478e-02f, -1.07433729e-01f, 1.59289718e-01f,
  -4.42615896e-01f, 7.67433286e-01f, -5.04190862e-01f, -5.37041306e-01f, -4.63244766e-01f, -2.87980467e-01f, -5.58676541e-01f, -6.94821775e-02f, -3.19683939e-01f, -1.48332119e-01f,
  -4.44879055e-01f, -6.64579570e-01f, -5.15280962e-01f, -1.02836519e-01f, -3.28880012e-01f, 5.38056076e-01f, 3.12917642e-02f, -4.67259914e-01f, -3.46472533e-03f, -2.73493864e-02f,
  1.05591941e+00f, 6.59275949e-01f, -2.79905558e-01f, -8.65236670e-03f, -2.07558855e-01f, -4.16668028e-01f, -5.39220452e-01f, -9.56524163e-02f, -3.47334027e-01f, -3.23536903e-01f,
  1.97109282e-01f, -2.04556242e-01f, -2.68201232e-01f, 7.03736469e-02f, -1.54157788e-01f, 3.44639644e-02f, -4.89819311e-02f, 3.57530303e-02f, -2.50093967e-01f, 4.96165119e-02f,
  -7.72215277e-02f, -1.08833693e-01f, -2.81261839e-03f, -1.92728281e-01f, -1.59648415e-02f, -6.48301169e-02f, -5.47115877e-02f, 3.73792574e-02f, -2.23311801e-02f, 3.63715380e-01f,
  1.78771079e-01f, -7.79528618e-02f, -1.58399958e-02f, 2.04582050e-01f, 3.20032716e-01f, 2.02582821e-01f, 1.19818650e-01f, 5.49015939e-01f, 2.97064986e-02f, 1.57844573e-01f,
  8.54620814e-01f, 3.43817919e-01f, 5.55298805e-01f, -1.88127831e-01f, -6.40809000e-01f, -7.02343524e-01f, -2.77273953e-01f, 7.00340211e-01f, -1.76575407e-01f, -1.21592339e-02f,
  3.60826313e-01f, 5.80740094e-01f, -1.01495349e+00f, -6.91741705e-01f, -6.92766905e-01f, -4.54207867e-01f, -6.68490171e-01f, -2.68953294e-01f, -3.11019301e-01f, -5.15862882e-01f,
  -4.55969363e-01f, 1.91567525e-01f, 4.13463205e-01f, -1.61259249e-01f, 5.18586710e-02f, 8.41327757e-02f, -3.78123134e-01f, 3.32012326e-01f, -2.87304699e-01f, -5.05232751e-01f,
  3.30151528e-01f, 3.21082294e-01f, -3.16036731e-01f, -2.66180426e-01f, -8.20844233e-01f, 2.39843071e-01f, 5.37254155e-01f, -3.15866172e-01f, 2.09787861e-01f, 5.80864176e-02f,
  4.16293889e-02f, -6.64452016e-02f, 1.21130101e-01f, 2.55342305e-01f, -3.21335439e-03f, 8.73539876e-03f, 3.07676941e-02f, 2.44283676e-01f, -9.41616669e-02f, 1.95024386e-01f,
  -7.14716539e-02f, -5.25115896e-03f, -1.13566658e-02f, -1.96899340e-01f, -2.16635376e-01f, 1.34410292e-01f, -1.43857896e-01f, -8.57628956e-02f, -1.99759096e-01f, -1.58119053e-01f,
  1.81680813e-01f, 2.39562139e-01f, -3.14575970e-01f, -1.16821148e-01f, -4.22435284e-01f, 1.67218342e-01f, 1.71505615e-01f, -6.46445453e-01f, 3.83537740e-01f, -3.01232845e-01f,
  1.19976707e-01f, -6.20981932e-01f, -3.38225275e-01f, -3.73912752e-01f, 5.76864630e-02f, -3.55599016e-01f, -3.01015705e-01f, 5.03132045e-01f, -2.31647551e-01f, -3.17779839e-01f,
  -4.27030832e-01f, -4.56761479e-01f, -5.91631353e-01f, 1.02088518e-01f, -2.17966482e-01f, -3.89498353e-01f, -4.79868114e-01f, 7.55766988e-01f, 2.13649482e-01f, -6.26149774e-01f,
  9.27495480e-01f, -1.72284663e-01f, -1.51734725e-01f, 4.82654303e-01f, -3.86377782e-01f, 3.04720178e-02f, -4.56908941e-01f, -3.15094262e-01f, -4.72863346e-01f, 4.26460594e-01f,
  -4.25667882e-01f, 4.97242779e-01f, -4.19166863e-01f, -1.53609142e-01f, 1.96086898e-01f, -1.67262733e-01f, 8.87978896e-02f, 8.57894123e-02f, -3.42084728e-02f, 2.17904523e-01f,
  7.66301230e-02f, -5.28902300e-02f, 6.52148724e-02f, 3.63030098e-02f, 8.44349042e-02f, -5.89394011e-02f, 1.60920843e-01f, 1.69390574e-01f, -1.75812140e-01f, -9.70034078e-02f,
  -1.90669745e-01f, 1.12057343e-01f, -6.60582557e-02f, 6.26270175e-02f, -2.77409762e-01f, 8.36619362e-02f, -2.20588937e-01f, 1.59344226e-01f, -3.89062852e-01f, -1.30014746e-02f,
  -4.58270639e-01f, -5.63584268e-01f, 4.00981992e-01f, 8.79745960e-01f, -3.29478264e-01f, -2.63603419e-01f, -4.53129768e-01f, -3.08827281e-01f, -1.16558030e-01f, -4.98949081e-01f,
  2.62428492e-01f, 1.14133600e-02f, 4.37310129e-01f, -3.72209758e-01f, 4.38740283e-01f, -7.38645121e-02f, -3.47285062e-01f, 4.21834946e-01f, 3.34690928e-01f, 8.05194759e-07f,
  6.22906864e-01f, -5.64372480e-01f, -6.32334590e-01f, -5.34604907e-01f, -1.05984814e-01f, 2.35321358e-01f, -4.04122978e-01f, -5.95373549e-02f, 4.83317435e-01f, -6.00117683e-01f,
  -2.79214531e-01f, -2.08124280e-01f, -2.23886967e-01f, -1.88157424e-01f, 6.94844604e-01f, -1.76677242e-01f, -4.50012267e-01f, -1.98308051e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.51389164e-02f, 4.94359918e-02f, 8.24047923e-02f, -1.76439911e-01f, -1.01793252e-01f, 1.78003892e-01f, -3.33171114e-02f, -8.22393224e-02f, 2.50732720e-01f, -6.05348200e-02f,
  -1.84693277e-01f, 6.48482936e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    