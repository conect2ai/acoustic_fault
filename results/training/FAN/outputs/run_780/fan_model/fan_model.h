/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.93862492e-02f, 4.02159803e-02f, 2.29772925e-01f, -9.62679908e-02f, -1.19889818e-01f, 1.88764110e-01f, 2.97210425e-01f, 2.74118245e-01f, -1.14223652e-01f, 9.64438822e-03f,
  -3.58601399e-02f, -1.90513194e-01f, 4.93653566e-02f, 1.76395588e-02f, 2.66614497e-01f, 1.84237748e-01f, 1.65725455e-01f, 2.47731209e-01f, 1.19594999e-01f, 2.47290377e-02f,
  -1.15473092e-01f, -1.06384665e-01f, -4.78841253e-02f, 7.59817138e-02f, -2.05773696e-01f, -2.25553334e-01f, -8.77461210e-02f, -1.81741014e-01f, -8.30824524e-02f, -4.02374774e-01f,
  2.13893354e-02f, 5.46540208e-02f, 7.87811726e-02f, -6.47838637e-02f, -1.08173527e-01f, 6.83258101e-02f, -2.68002898e-02f, 9.42394510e-03f, 3.93166654e-02f, -2.32885387e-02f,
  -1.26723573e-01f, -8.57895911e-02f, -8.79507959e-02f, -1.90073922e-02f, 2.29301155e-02f, 2.06133202e-02f, 2.99355239e-02f, 1.83924064e-01f, 7.35428333e-02f, 3.10997237e-02f,
  1.40660517e-02f, -2.41505336e-02f, 6.45350516e-02f, 1.03412233e-01f, 2.35412642e-01f, 1.43951019e-02f, 9.91137512e-03f, 5.59068769e-02f, 1.11802071e-01f, -1.56846344e-01f,
  -4.91078980e-02f, -2.50275359e-02f, -6.65082932e-02f, -1.26662357e-02f, -1.55248009e-02f, 4.66712750e-02f, -9.78802890e-02f, -6.55400530e-02f, -2.99586691e-02f, -2.97977682e-02f,
  8.57276171e-02f, 7.49545023e-02f, 3.68478857e-02f, 4.77589034e-02f, -2.74438169e-02f, -1.74612459e-02f, 4.13686857e-02f, -1.07615711e-02f, -4.25898992e-02f, 1.04131885e-02f,
  6.11895770e-02f, -2.30075903e-02f, -6.78476095e-02f, 3.35978940e-02f, 8.62090886e-02f, 7.17087090e-02f, -6.66183978e-02f, 2.51470562e-02f, 5.14245257e-02f, -8.29903185e-02f,
  -1.83364451e-02f, 7.18303397e-02f, -6.23180121e-02f, 6.34371564e-02f, -5.92982359e-02f, -5.92290005e-03f, -4.63333242e-02f, 4.83382419e-02f, -8.34744200e-02f, 2.33850963e-02f,
  5.47279697e-03f, 3.72433253e-02f, 2.73094140e-02f, -6.92019016e-02f, -7.29838684e-02f, -6.25558868e-02f, -6.84679598e-02f, 1.05539830e-02f, 8.72344002e-02f, -4.68190052e-02f,
  4.73031513e-02f, 1.18621111e-01f, 6.45527840e-02f, -2.85563730e-02f, -4.00224961e-02f, 2.71228496e-02f, -1.20942749e-01f, -5.57400249e-02f, 1.19463012e-01f, -1.12889141e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.91525859e-01f, -1.45931363e-01f, 5.67211695e-02f, -1.91939577e-01f, 1.80178881e-01f, 1.27829000e-01f, -6.49253428e-02f, -4.75221388e-02f, -1.29949406e-01f, -5.47343977e-02f,
  1.92281410e-01f, 5.51948585e-02f, 4.39310931e-02f, 2.13786084e-02f, 4.82287779e-02f, -7.89134353e-02f, -5.26243709e-02f, -6.07237034e-02f, 1.00094423e-01f, 1.71893671e-01f,
  1.62622392e-01f, 1.92597955e-02f, 2.43382510e-02f, -8.59454274e-03f, -2.54349951e-02f, -9.95015725e-02f, -7.68179744e-02f, -4.79513891e-02f, 8.10427740e-02f, -1.33576974e-01f,
  8.17800835e-02f, -8.31587613e-02f, 8.05225745e-02f, 9.40947458e-02f, 6.03968604e-03f, -1.25705793e-01f, -8.33040997e-02f, -1.62395241e-03f, 3.47633995e-02f, -1.97939649e-02f,
  -1.15693482e-02f, 7.39797130e-02f, 5.81929740e-03f, -5.55656888e-02f, -1.95083208e-02f, -4.38779965e-02f, -8.20151940e-02f, -8.56799632e-02f, 2.14239303e-02f, 2.21573710e-02f,
  -9.12239403e-03f, 8.73656198e-02f, 2.42465585e-02f, 2.84787472e-02f, 8.70440621e-03f, 3.84097770e-02f, 1.99127942e-03f, -1.87973510e-02f, -3.98957804e-02f, -3.20502341e-01f,
  4.62357700e-02f, 1.06176268e-03f, 2.73360703e-02f, 8.99043586e-03f, -4.69756089e-02f, 2.15669814e-02f, -4.19227369e-02f, -1.73224509e-02f, 9.77296159e-02f, -8.19713399e-02f,
  4.32941504e-02f, 4.68331110e-03f, -2.31650509e-02f, -3.52992713e-02f, 1.01466486e-02f, 2.20210617e-03f, 6.58315048e-02f, 2.51943320e-02f, 6.87738582e-02f, 6.59114867e-02f,
  1.99136846e-02f, 1.66704152e-02f, -9.44366492e-03f, -2.05011182e-02f, 1.16570964e-01f, 6.71740770e-02f, 1.67770218e-02f, 4.68232036e-02f, -6.34223297e-02f, 5.22993393e-02f,
  -3.05225849e-01f, 1.60093293e-01f, -1.93726763e-01f, -1.33074269e-01f, 5.64451888e-03f, 6.17125491e-03f, -9.81074292e-03f, 3.45164016e-02f, -3.61233875e-02f, -5.84647320e-02f,
  3.89533974e-02f, -1.46675006e-01f, -1.20776802e-01f, 1.02769077e-01f, -1.00423925e-01f, -3.80970389e-02f, -2.63190605e-02f, -8.60784799e-02f, 1.01242378e-01f, -4.62028123e-02f,
  2.54065040e-02f, -7.83769563e-02f, -2.39010587e-01f, -9.17460695e-02f, -9.77937356e-02f, -1.49554282e-01f, -1.01868860e-01f, -1.77199945e-01f, -2.76428580e-01f, -4.23244119e-01f,
  2.80179918e-01f, -4.56144392e-01f, -3.07804830e-02f, -1.44132346e-01f, -2.23420426e-01f, -1.03502184e-01f, -1.69181779e-01f, -1.68135211e-01f, -1.70433540e-02f, -2.59206682e-01f,
  6.66683465e-02f, 2.44413540e-01f, 1.69838652e-01f, 6.89318851e-02f, 1.71069041e-01f, -2.20036402e-01f, -2.00582519e-01f, 2.79351950e-01f, 3.42818111e-01f, 7.54505470e-02f,
  -9.38260034e-02f, -2.94146929e-02f, 1.25575930e-01f, 8.14637449e-03f, -1.73278645e-01f, 3.94183695e-02f, -2.30629876e-01f, -1.01078443e-01f, -2.04448774e-01f, -2.43484959e-01f,
  4.50934358e-02f, -1.64548885e-02f, 1.84131935e-01f, 5.61843067e-02f, -4.97472323e-02f, 1.28047034e-01f, 1.28029913e-01f, -6.41010515e-03f, 1.97942760e-02f, -9.90064293e-02f,
  5.26547804e-02f, 4.56485786e-02f, 1.80164978e-01f, -8.22789036e-03f, 2.26262361e-02f, -3.97234000e-02f, -9.56773385e-02f, 7.79635459e-02f, 4.20531109e-02f, -1.39048263e-01f,
  -1.95924267e-01f, -2.67074853e-02f, 5.28359078e-02f, 3.14576142e-02f, 1.88364401e-01f, 2.15180039e-01f, 5.85490465e-02f, -3.60169411e-02f, 9.15557072e-02f, -1.14859775e-01f,
  -5.60163893e-03f, -3.42212594e-03f, 1.49538079e-02f, 3.37573811e-02f, 2.56546140e-02f, 4.07694764e-02f, 5.62913604e-02f, -2.22779606e-02f, 3.19143459e-02f, 6.63148463e-02f,
  -9.00939927e-02f, -8.66032392e-02f, -4.69449274e-02f, -3.22828963e-02f, 1.90505907e-02f, -3.60293612e-02f, 2.84428820e-02f, -8.12299401e-02f, 6.62748218e-02f, -5.72486408e-02f,
  7.07734972e-02f, -2.64893789e-02f, 1.12535069e-02f, 2.38079745e-02f, -8.00091997e-02f, 7.42080389e-03f, 6.03478886e-02f, 2.11982932e-02f, -3.13354060e-02f, -3.94004658e-02f,
  4.70055826e-02f, 2.44661629e-01f, -4.72906157e-02f, 9.20118839e-02f, -5.92334494e-02f, -7.36546069e-02f, -5.58280526e-03f, -2.32249429e-03f, -5.37491776e-02f, -1.09032698e-01f,
  2.59275492e-02f, 9.19115841e-02f, -1.33793518e-01f, -1.09892882e-01f, 4.94725481e-02f, 9.21811610e-02f, -3.30989510e-02f, 1.99505230e-05f, -1.73687823e-02f, -1.84129670e-01f,
  -1.89797610e-01f, 9.05181095e-02f, 1.10618174e-01f, 7.23479390e-02f, 1.45624708e-02f, 1.97635800e-01f, 9.36122891e-03f, 4.15049233e-02f, 1.49942428e-01f, -1.30393237e-01f,
  1.76944330e-01f, -1.05957694e-01f, 2.84700599e-02f, 1.54093742e-01f, 3.85230146e-02f, -1.98298365e-01f, -2.47388393e-01f, -7.35501722e-02f, 1.12106346e-01f, 1.37615651e-01f,
  1.25118596e-02f, 1.99243903e-01f, 3.05638220e-02f, 1.57059997e-01f, -8.13215598e-02f, -5.36841266e-02f, 6.61963820e-02f, 1.13178596e-01f, 9.88616049e-02f, 1.09995529e-01f,
  1.62938610e-01f, 4.03130762e-02f, 1.89401001e-01f, 7.42526874e-02f, 2.10306257e-01f, 1.15554094e-01f, 7.83953257e-03f, 1.03935733e-01f, 1.51209280e-01f, 2.67418891e-01f,
  1.19238287e-01f, 2.78485734e-02f, 4.71986197e-02f, 3.25446501e-02f, -7.64055969e-03f, 1.19951546e-01f, -9.37103480e-03f, 5.11434413e-02f, 4.02863473e-02f, 4.36617061e-02f,
  9.22218785e-02f, -4.73022051e-02f, -7.00502843e-02f, -4.27336954e-02f, 3.39081287e-02f, 2.41644066e-02f, 2.64455117e-02f, 1.78123396e-02f, -5.74821569e-02f, 7.96645954e-02f,
  3.86155676e-03f, 4.42319773e-02f, -1.53763294e-01f, -3.99938673e-02f, -7.60447383e-02f, 9.85430479e-02f, 1.05455264e-01f, 1.11860491e-01f, 1.03601038e-01f, 1.65638879e-01f,
  -8.40697140e-02f, 4.59561199e-02f, -2.32900176e-02f, 7.46679679e-02f, 3.19805108e-02f, -1.87501479e-02f, -3.74177024e-02f, -1.78614892e-02f, -5.26527241e-02f, -4.91680503e-02f,
  -6.12221509e-02f, 1.09635508e-02f, 2.14515086e-02f, 4.73033562e-02f, -9.19599493e-04f, -4.26235758e-02f, -2.23791730e-02f, 8.09904784e-02f, -3.20854113e-02f, 6.73299804e-02f,
  -5.72829554e-03f, 7.81573877e-02f, -4.11390178e-02f, -2.97937449e-02f, -2.78414949e-03f, 5.77699877e-02f, 6.85056224e-02f, 4.02471349e-02f, -3.00676636e-02f, -1.32063376e-02f,
  1.21392608e-02f, -8.02940801e-02f, 1.63684756e-01f, 2.06733141e-02f, -8.35531652e-02f, -4.42765020e-02f, 1.08891569e-01f, -1.17670391e-02f, -5.51917255e-02f, 1.22241601e-01f,
  -2.01222859e-02f, -5.31454645e-02f, 4.66065714e-03f, 4.34362963e-02f, 1.93435233e-02f, 4.75680791e-02f, -2.50674188e-02f, -4.43799868e-02f, 2.10231263e-02f, 4.63909321e-02f,
  2.20666695e-02f, -6.07173741e-02f, -4.97788712e-02f, -4.97060716e-02f, -1.36805419e-02f, 4.37377729e-02f, -4.90371697e-02f, 7.70766735e-02f, 6.58482779e-03f, -4.73830402e-02f,
  -7.83297062e-01f, 1.55259952e-01f, -6.34731352e-02f, -8.10976177e-02f, 8.21685344e-02f, 2.41717696e-01f, 4.56611782e-01f, 1.87031507e-01f, -1.19603083e-01f, 6.96646497e-02f,
  -1.80819422e-01f, -7.57154301e-02f, 6.71239421e-02f, -1.33354440e-02f, 1.53639480e-01f, 2.92114377e-01f, 2.82673448e-01f, 2.20598765e-02f, -1.07629023e-01f, -1.52152240e-01f,
  8.37959945e-02f, -1.77009016e-01f, -4.34474647e-01f, -4.98892479e-02f, 1.11870661e-01f, -3.69998626e-02f, 4.31572599e-03f, -1.06066652e-01f, 8.33436176e-02f, 1.27243340e-01f,
  -1.64168954e-01f, -2.72954315e-01f, -3.14785689e-02f, -1.07974857e-02f, -1.63457632e-01f, -3.59168164e-02f, -7.59013146e-02f, -1.30276367e-01f, -7.85608888e-02f, -4.00357172e-02f,
  -4.39825393e-02f, -1.29506355e-02f, 1.21317580e-01f, 3.70649211e-02f, -3.12553346e-02f, 3.81109603e-02f, -5.19703850e-02f, -1.01534881e-01f, 2.58572283e-04f, -3.09460387e-02f,
  2.01528147e-01f, -9.64320824e-02f, -1.31933436e-01f, -1.29445037e-02f, 7.54527524e-02f, -8.22911859e-02f, -1.91492829e-02f, -2.34136637e-02f, -6.29778579e-02f, -8.30716453e-03f,
  3.17307375e-02f, -6.48630038e-02f, 3.04677640e-03f, 2.89535541e-02f, 1.25680091e-02f, -1.87874085e-03f, 3.63883041e-02f, 4.10470292e-02f, 7.61107206e-02f, -2.56246002e-03f,
  -7.98091851e-03f, -7.33100772e-02f, -2.06118822e-02f, -1.01248436e-02f, -5.20126987e-03f, 2.22284384e-02f, 9.99846235e-02f, 4.36086096e-02f, -6.05859198e-02f, -7.86352605e-02f,
  -6.10788949e-02f, -1.42712584e-02f, -3.43843587e-02f, 3.73759940e-02f, -6.33358955e-03f, 2.23262254e-02f, -6.65357113e-02f, 2.35556234e-02f, -1.10036112e-01f, -3.31401117e-02f,
  -1.14534259e-01f, -1.11175053e-01f, 3.32033378e-03f, -6.09372593e-02f, -2.93514486e-02f, -5.87479323e-02f, -3.57897766e-02f, -5.43879457e-02f, -5.74237183e-02f, 4.37092409e-03f,
  -1.18522093e-01f, -1.21276364e-01f, -3.95423993e-02f, 4.53753732e-02f, -2.26965379e-02f, -3.64746675e-02f, 6.68395460e-02f, 9.78217721e-02f, -1.62011050e-02f, -9.18113217e-02f,
  1.00897849e-01f, -2.47768424e-02f, -1.53364286e-01f, 4.73563112e-02f, -6.11847378e-02f, -2.24713996e-01f, -4.20125201e-02f, -1.58608913e-01f, -1.15389213e-01f, 2.54750755e-02f,
  9.38608870e-03f, 2.28439793e-01f, 4.22076434e-02f, 3.21474969e-01f, -4.02206853e-02f, -4.36101407e-01f, -4.36621934e-01f, -2.72171170e-01f, -6.49148747e-02f, 2.86399852e-03f,
  -1.25332043e-01f, 3.41296494e-02f, -1.16847754e-02f, 4.00749920e-03f, -2.75152057e-01f, 1.46320045e-01f, 4.48097914e-01f, 1.93131819e-01f, -3.65956336e-01f, -3.42066884e-01f,
  1.80663213e-01f, 1.93238989e-01f, 3.37904654e-02f, -9.76232886e-02f, 2.73636460e-01f, 4.52309251e-02f, 2.89843120e-02f, 1.72050163e-01f, 1.03882670e-01f, 8.11991453e-01f,
  -1.17648439e-02f, 1.36135101e-01f, -2.42151633e-01f, 1.28266841e-01f, -9.83380992e-03f, 5.42777590e-02f, -6.43359423e-02f, 4.91634011e-02f, 2.36813142e-03f, 5.46974353e-02f,
  6.30741417e-02f, 1.03213795e-01f, 7.48377442e-02f, -4.12732325e-02f, -8.55666101e-02f, -2.12709382e-01f, 9.33299866e-03f, 3.74942236e-02f, -7.12082237e-02f, -1.08672850e-01f,
  9.99918729e-02f, 8.65284726e-03f, -9.90489945e-02f, -1.48357108e-01f, -1.03126623e-01f, -7.85704516e-03f, -2.24419624e-01f, -9.43464562e-02f, -3.16699564e-01f, 9.09894779e-02f,
  -8.07086080e-02f, -8.53717793e-03f, 1.38204508e-02f, 2.56831180e-02f, 9.30811279e-03f, -6.68149150e-04f, 7.25908279e-02f, -8.41107741e-02f, -3.37418988e-02f, -2.78647896e-03f,
  -6.73489943e-02f, -6.67271912e-02f, 2.66190171e-02f, 1.45873921e-02f, -4.11443375e-02f, 2.78496016e-02f, -6.71585603e-03f, -2.86490172e-02f, -1.73909832e-02f, 5.03448360e-02f,
  7.39222988e-02f, 1.71083193e-02f, 5.61272949e-02f, -2.57789753e-02f, 5.17219566e-02f, 8.74366313e-02f, 4.25560586e-02f, -6.66786591e-03f, 7.15273023e-02f, 3.93225290e-02f,
  -1.99684203e-01f, -1.28411815e-01f, 4.54022139e-02f, 6.41066057e-04f, 4.80201691e-02f, 9.23125744e-02f, 7.59193376e-02f, -1.34522365e-02f, 5.11026382e-02f, -1.29461154e-01f,
  -1.08156890e-01f, -1.18514568e-01f, 5.45893796e-02f, -4.33521271e-02f, -1.84762150e-01f, -4.13504392e-02f, 3.95917632e-02f, -2.55908188e-03f, -9.58540812e-02f, -7.28182048e-02f,
  2.04853583e-02f, -2.05627412e-01f, -3.14947188e-01f, -2.53936291e-01f, -1.55058414e-01f, -2.12007463e-01f, -2.22000271e-01f, -2.47644022e-01f, -3.93638998e-01f, -4.03708756e-01f,
  -3.90884191e-01f, -2.96269748e-02f, -7.00450465e-02f, -1.34398654e-01f, 1.01684704e-01f, 2.07992435e-01f, -3.78286615e-02f, -3.09368763e-02f, -5.70201427e-02f, -5.07327616e-02f,
  1.44576967e-01f, -9.63539854e-02f, -2.28176028e-01f, -1.28633872e-01f, -3.21068376e-01f, -1.26263991e-01f, -3.16874593e-01f, -4.27664518e-01f, -3.24309468e-01f, -9.40677822e-02f,
  3.26385200e-02f, -2.86943644e-01f, -2.22070396e-01f, -8.00636187e-02f, 1.20474018e-01f, -4.56943177e-02f, -7.13342056e-02f, -4.86781746e-02f, 8.11110511e-02f, -1.29962772e-01f,
  2.23388728e-02f, 7.86117762e-02f, -1.15306545e-02f, -1.49321243e-01f, 1.12461835e-01f, -1.43010393e-02f, 1.06680788e-01f, 6.22214153e-02f, 3.36811766e-02f, -1.71202794e-02f,
  1.23109519e-01f, 8.52530673e-02f, -2.77842712e-02f, -1.47071285e-02f, -9.18637812e-02f, -7.21097365e-02f, -1.09505363e-01f, -1.48064733e-01f, -1.05609640e-01f, 1.02779008e-01f,
  1.39659373e-02f, -4.58904058e-02f, -1.19305365e-01f, -2.26244833e-02f, 1.51564172e-02f, -1.12167224e-01f, 7.04999566e-02f, -1.13887815e-02f, -1.88413523e-02f, -1.71626747e-01f,
  -6.87816814e-02f, 2.12645382e-02f, -1.08584370e-02f, 4.74166460e-02f, -3.29019595e-03f, 1.01680651e-01f, -3.29947099e-02f, -3.55991796e-02f, -6.99772388e-02f, -1.19242063e-02f,
  7.55656883e-02f, 1.01347983e-01f, 6.07330073e-03f, -2.42251102e-02f, 2.89543588e-02f, -9.00601000e-02f, -5.22097722e-02f, -6.00006022e-02f, -4.99636754e-02f, -6.80980161e-02f,
  -5.71350716e-02f, -3.71653661e-02f, -4.48205061e-02f, 8.38036742e-03f, -9.67570245e-02f, -8.20856243e-02f, -6.15149699e-02f, -2.00742017e-02f, -8.80745649e-02f, 2.78084744e-02f,
  -1.69562533e-01f, 6.87297955e-02f, -1.14848986e-01f, -4.61506136e-02f, -2.87296902e-02f, 5.54315373e-02f, 3.83127034e-02f, -8.56029987e-02f, 1.06995866e-01f, -3.68817337e-02f,
  2.43992321e-02f, -6.66570663e-02f, 1.46220569e-02f, 9.05095041e-02f, -3.85864708e-03f, -8.32140446e-03f, -7.10572377e-02f, -1.80050790e-01f, -1.75862834e-01f, 6.84131235e-02f,
  -1.42307386e-01f, -3.13629955e-01f, -3.83135021e-01f, -2.24359244e-01f, -2.51892582e-02f, -2.53526449e-01f, -1.78237483e-01f, -8.21762159e-02f, -2.25388750e-01f, -3.68104666e-01f,
  5.07827222e-01f, 6.38292372e-01f, 3.86518002e-01f, -1.07351309e-02f, -7.48946443e-02f, 2.48648345e-01f, 5.71617067e-01f, 2.01315656e-01f, -1.67685732e-01f, 3.83835323e-02f,
  -7.19170496e-02f, -4.26415265e-01f, -2.78664589e-01f, -1.16951182e-01f, 1.60940602e-01f, 2.69411832e-01f, -2.46875193e-02f, 3.75574566e-02f, -1.09003425e-01f, -4.38000448e-02f,
  -2.29074180e-01f, -5.08281291e-02f, 1.44304246e-01f, -4.53436486e-02f, 3.15803960e-02f, -2.86193162e-01f, 1.39643550e-01f, 4.28338535e-02f, 7.11811483e-02f, -3.89103517e-02f,
  -1.00939319e-01f, 5.99893928e-01f, -3.23419899e-01f, -2.57452548e-01f, -6.84989765e-02f, 7.49757746e-03f, 2.91020796e-02f, -3.29709835e-02f, -4.94810119e-02f, 8.21789280e-02f,
  -8.38843957e-02f, 4.63740481e-03f, 7.56724849e-02f, -6.77565485e-02f, 1.11074112e-01f, 5.30003421e-02f, 1.00601912e-01f, 2.02894673e-01f, 8.99306685e-02f, -3.20403539e-02f,
  -6.52829260e-02f, 4.34410535e-02f, 1.83128133e-01f, 1.54911757e-01f, 1.59320518e-01f, -1.68541655e-01f, 2.16946974e-01f, 4.25272668e-03f, 1.32068798e-01f, 1.53707042e-01f,
  -1.11744329e-01f, 4.62084301e-02f, 3.55998054e-02f, 4.39319760e-02f, 7.31994808e-02f, -9.10684913e-02f, 1.18035125e-03f, -2.04314739e-02f, 1.44492518e-02f, 2.15227567e-02f,
  -2.69244760e-02f, 1.87637601e-02f, 2.52062525e-03f, 6.81827813e-02f, -1.31415904e-01f, 7.77707174e-02f, -1.86478104e-02f, 3.15787457e-02f, -3.74173485e-02f, 5.01893163e-02f,
  3.94579284e-02f, 6.77010864e-02f, -4.33854572e-02f, 1.49628250e-02f, 3.55412140e-02f, 3.01044956e-02f, -5.12296474e-03f, 8.92321765e-03f, 1.06432857e-02f, 2.87161022e-02f,
  -3.49597573e-01f, 3.51794586e-02f, -8.72039795e-02f, 2.93246936e-02f, 1.50406267e-02f, -6.19262271e-02f, -3.33766155e-02f, -1.81600507e-02f, -5.80207147e-02f, -2.44892226e-03f,
  1.47027299e-02f, -5.49567603e-02f, 1.32782057e-01f, 9.92514566e-02f, -4.71571200e-02f, -2.93652620e-02f, -1.15708187e-01f, -9.57168266e-02f, -1.75798550e-01f, -5.93054406e-02f,
  -1.09319918e-01f, -1.46070436e-01f, -2.08764851e-01f, -1.06895491e-01f, -1.02042399e-01f, -2.82703102e-01f, -6.28133789e-02f, -1.03309117e-01f, -7.80350901e-03f, -1.27300829e-01f,
  -7.05091208e-02f, 2.20998347e-01f, -3.79324287e-01f, 2.08684150e-02f, -3.58661503e-01f, -3.90300065e-01f, -1.93153039e-01f, -1.85621250e-02f, 1.13277130e-01f, 5.09382561e-02f,
  4.20662463e-02f, 2.05684498e-01f, 1.09398670e-01f, -2.87103257e-03f, -1.05211750e-01f, -2.43638068e-01f, -3.69382709e-01f, -3.66998941e-01f, -2.29585484e-01f, -2.78089851e-01f,
  -6.98187128e-02f, -5.26284687e-02f, -1.54934585e-01f, -1.51072875e-01f, 2.19406456e-01f, 1.92438379e-01f, 9.38111618e-02f, -1.90485135e-01f, -1.23921335e-01f, -1.09555304e-01f,
  2.39678070e-01f, -1.20058760e-01f, -1.37077525e-01f, -1.30299613e-01f, -8.16324167e-03f, -1.96401682e-02f, -2.98896488e-02f, -2.95875911e-02f, -8.66040215e-02f, -4.76251580e-02f,
  -7.55616054e-02f, -7.39756003e-02f, -3.48381512e-03f, -7.86499586e-03f, -8.66473280e-03f, -1.03240885e-01f, -2.45838221e-02f, -1.26891002e-01f, -7.21356273e-02f, 5.25088757e-02f,
  -2.11158600e-02f, -1.90476775e-01f, -2.25626305e-02f, -6.84602633e-02f, -1.52282521e-01f, -1.28884807e-01f, 6.00949116e-02f, -2.06917509e-01f, -1.49456650e-01f, 2.38545522e-01f,
  -4.44067679e-02f, 7.85218552e-02f, -3.78212444e-02f, 9.06736851e-02f, 6.14668168e-02f, 2.79003121e-02f, 6.82974607e-02f, 8.79844874e-02f, 1.89841110e-02f, 4.23358306e-02f,
  -2.58063115e-02f, -6.42787069e-02f, 8.07730854e-02f, 1.09326258e-01f, -7.04538217e-03f, -6.49289414e-02f, -2.80131344e-02f, 6.20243251e-02f, -2.80807037e-02f, -7.51811638e-02f,
  1.75882522e-02f, -1.55843034e-01f, 3.56153995e-02f, 8.19215402e-02f, -1.22216001e-01f, -1.09060779e-02f, -1.04694115e-02f, -5.02988100e-02f, -2.40883939e-02f, -1.19676076e-01f,
  6.66126251e-01f, -4.07907754e-01f, 2.65832067e-01f, -1.51215028e-02f, 2.74975896e-02f, -4.48832102e-02f, 8.18909109e-02f, -9.52689536e-03f, 4.74021919e-02f, 5.05909398e-02f,
  -9.12540480e-02f, 5.12194857e-02f, 4.77249436e-02f, -1.12716891e-02f, -4.11948003e-02f, -1.27204591e-02f, 7.95437768e-03f, 5.91247641e-02f, -2.91093588e-02f, 6.65489137e-02f,
  5.53632826e-02f, 1.48578985e-02f, 1.97621360e-01f, 2.12949738e-01f, 7.06758723e-02f, -5.53022046e-03f, 2.87638545e-01f, 8.26267749e-02f, 2.42064167e-02f, 5.18072486e-01f,
  2.65387803e-01f, -4.07946795e-01f, 2.47236907e-01f, 1.14974365e-01f, 3.32319975e-01f, 2.78641701e-01f, 1.15105443e-01f, 1.62266567e-02f, 1.83100384e-02f, -3.84079516e-02f,
  -3.68950218e-01f, -2.49979064e-01f, -3.74750316e-01f, -2.91758567e-01f, -9.55937281e-02f, 8.47644210e-02f, 1.85388029e-01f, 1.37942493e-01f, 2.64718801e-01f, 1.25705808e-01f,
  -5.37627712e-02f, -3.05337477e-02f, -6.73577785e-02f, 1.54052174e-03f, -3.89002673e-02f, 2.82027163e-02f, -1.43009692e-01f, -4.04712893e-02f, -7.31220692e-02f, -1.20033383e-01f,
  1.30211720e-02f, -1.32044569e-01f, 9.94212627e-02f, -2.11633563e-01f, -1.15204588e-01f, 1.46616027e-02f, 5.69048338e-02f, 4.22051223e-03f, -2.06213724e-02f, 2.27041000e-05f,
  -4.04381081e-02f, -5.68998717e-02f, 1.96001008e-02f, -1.05358161e-01f, 1.05512813e-01f, 1.78666357e-02f, -4.27111313e-02f, -6.32083714e-02f, -1.33055583e-01f, -2.49430284e-01f,
  -2.44484127e-01f, -3.71243060e-02f, 1.44479960e-01f, -9.49016884e-02f, -7.99970403e-02f, -1.25482669e-02f, -1.57452017e-01f, -1.66023344e-01f, 2.74704210e-02f, -2.88520567e-02f,
  -3.00219003e-02f, 5.46229957e-03f, -2.59956196e-02f, 4.43554893e-02f, -1.51375784e-02f, 1.67651307e-02f, 1.02382908e-02f, -2.24892516e-02f, 4.11570184e-02f, 1.53522687e-02f,
  -1.48660515e-03f, 5.59026701e-03f, 4.25374135e-02f, 4.08672635e-03f, -6.57582730e-02f, 1.81950051e-02f, 8.44536275e-02f, -8.91902968e-02f, -1.66436797e-03f, 2.62496434e-02f,
  -7.71381101e-03f, 1.02616912e-02f, 3.43601555e-02f, -6.89224228e-02f, -4.62452956e-02f, -5.56309223e-02f, -3.17013562e-02f, -2.22753901e-02f, -8.49922448e-02f, 3.85018066e-02f,
  -1.96412541e-02f, -1.79516658e-01f, 5.73599972e-02f, -2.41415016e-02f, 7.65030831e-02f, -1.14671811e-01f, -4.56711762e-02f, -6.12330027e-02f, -2.65446957e-02f, 3.88063826e-02f,
  -8.23524222e-02f, -4.04280834e-02f, -1.21334694e-01f, 1.77107919e-02f, 2.44905040e-01f, 9.24165472e-02f, -6.37823492e-02f, 7.41963685e-02f, -1.08718954e-01f, 1.38634779e-02f,
  -1.22240663e-01f, 2.65144199e-01f, 3.40282589e-01f, 2.25179106e-01f, -5.66646792e-02f, 2.30387151e-01f, 1.85036287e-01f, 9.06934440e-02f, 2.28891090e-01f, 2.18670055e-01f,
  -4.40590158e-02f, -1.87509969e-01f, 1.87759265e-01f, -6.96541145e-02f, -3.34099591e-01f, -3.59229118e-01f, -5.75303137e-01f, -1.70992836e-01f, 2.92876270e-02f, -2.13972971e-01f,
  -3.21960956e-01f, -2.23326877e-01f, -6.22566715e-02f, -4.64578271e-02f, -1.20919012e-01f, -2.07731411e-01f, -6.68136925e-02f, 1.62851498e-01f, -2.97265742e-02f, -2.13311121e-01f,
  -2.31087983e-01f, -5.53494021e-02f, 1.75088465e-01f, 1.82415679e-01f, 8.64415765e-02f, 1.60210863e-01f, 1.61909208e-01f, 1.59519896e-01f, 3.40138599e-02f, 7.41632283e-02f,
  -2.26600349e-01f, 1.87990312e-02f, 6.91617429e-02f, -9.81898457e-02f, -1.42905302e-03f, 4.00459096e-02f, -9.73713920e-02f, 1.07514113e-01f, -6.10369118e-03f, 1.14797486e-03f,
  -1.23559356e-01f, -8.55850279e-02f, -6.17804863e-02f, -4.56253663e-02f, -8.16527605e-02f, -8.47482681e-02f, 1.69771180e-01f, 1.67357609e-01f, 1.00867019e-05f, -1.35844409e-01f,
  -7.17042461e-02f, -2.17290372e-01f, -2.17242777e-01f, 5.55763915e-02f, 8.28666687e-02f, 2.15798430e-02f, 3.47428136e-02f, 1.15971357e-01f, 2.21121863e-01f, 1.46016538e-01f,
  7.01100659e-03f, 2.61578895e-02f, 9.53771453e-03f, -5.98457158e-02f, -1.14416376e-01f, 2.61963606e-02f, 4.14181827e-03f, -1.21425064e-02f, 1.43967289e-02f, 1.02877403e-02f,
  -5.19577321e-03f, 3.30433175e-02f, -6.46833554e-02f, 3.52444053e-02f, 2.73012202e-02f, 4.78784963e-02f, -1.29540982e-02f, -4.11076248e-02f, 1.23903081e-02f, -3.90737765e-02f,
  3.63207832e-02f, 7.17455596e-02f, 5.81729934e-02f, -7.50826299e-03f, 1.07397377e-01f, 9.00620297e-02f, -1.53192030e-02f, 2.22775061e-02f, 3.96391861e-02f, 1.08285034e-02f,
  -1.32493913e-01f, 7.20623285e-02f, -1.61652222e-01f, -1.21508695e-01f, 1.61392782e-02f, 1.58108380e-02f, -8.11732337e-02f, 1.24800488e-01f, 1.99825671e-02f, -6.49002120e-02f,
  -1.49832144e-01f, -3.86722907e-02f, 2.49251425e-02f, -6.66987970e-02f, -1.11470567e-02f, -5.59102371e-02f, -1.28763422e-01f, 2.10039578e-02f, 1.31044155e-02f, -8.16341303e-03f,
  1.75261311e-02f, -1.40939951e-01f, -3.17013919e-01f, -3.86935240e-03f, -5.03537990e-02f, -1.99812844e-01f, -4.84413691e-02f, -9.13355052e-02f, -1.05042472e-01f, -2.16126218e-01f,
  5.35366774e-01f, -4.84077901e-01f, -4.74896371e-01f, 9.59619507e-02f, -2.01672241e-01f, -3.36717546e-01f, -5.00257850e-01f, 1.22633889e-01f, 2.57942677e-01f, -2.63319969e-01f,
  -1.17512375e-01f, 2.80460030e-01f, 1.25519097e-01f, 2.13418916e-01f, 2.09041163e-01f, -2.55979687e-01f, -2.53106743e-01f, 1.79754689e-01f, 3.87282223e-01f, 1.31686538e-01f,
  -3.65124419e-02f, 2.06665888e-01f, 4.06719565e-01f, 2.26963207e-01f, -2.02828363e-01f, 3.87101360e-02f, -2.18790635e-01f, -1.71654835e-01f, -2.67200708e-01f, -6.21710598e-01f,
  -4.73544866e-01f, -1.92622215e-01f, 3.60927656e-02f, 1.33830130e-01f, -1.92161500e-01f, 8.65223780e-02f, -7.03529119e-02f, -1.76844690e-02f, 3.58469635e-02f, -4.23253030e-02f,
  6.87489426e-03f, 1.25725167e-02f, -7.07951048e-03f, 3.70427384e-03f, -1.46037890e-02f, -9.79058146e-02f, -4.82450686e-02f, 3.08574643e-02f, 5.49007878e-02f, -9.80002508e-02f,
  -2.15943992e-01f, -2.77682453e-01f, -1.02308825e-01f, -7.36687854e-02f, -4.40633111e-02f, 5.72003350e-02f, -2.60255814e-01f, -1.01659402e-01f, -4.19282354e-02f, -2.65397072e-01f,
  -4.01686393e-02f, -8.72518867e-02f, 3.32072712e-02f, 2.97914557e-02f, 9.45760086e-02f, 1.29378987e-02f, -4.17245328e-02f, 5.11032296e-04f, 4.97846454e-02f, -8.87090992e-03f,
  -2.65746261e-03f, -3.23185921e-02f, 1.25978012e-02f, -3.48209008e-03f, -5.01631871e-02f, -5.28049283e-02f, -4.77318242e-02f, -3.71276587e-02f, -3.27025205e-02f, 7.88418129e-02f,
  3.83906700e-02f, -5.89137822e-02f, -2.13590413e-02f, 3.10159083e-02f, -1.16492905e-01f, -3.42385545e-02f, -3.21593112e-03f, 5.87527454e-02f, 4.05059494e-02f, -7.34504825e-03f,
  2.53241628e-01f, 7.27154091e-02f, -2.38467958e-02f, 1.35640785e-01f, 3.52926217e-02f, 5.90685580e-04f, -5.13555817e-02f, 3.80754881e-02f, 6.56562150e-02f, -6.98286062e-03f,
  -2.00713309e-03f, 6.38982877e-02f, -8.10215529e-03f, 7.53014069e-03f, 4.32682596e-02f, 5.37100732e-02f, 6.36647046e-02f, 2.48584035e-03f, 3.89634026e-03f, -6.61441237e-02f,
  9.67696160e-02f, 1.28550559e-01f, 1.15056030e-01f, 4.74887490e-02f, -7.43360147e-02f, 5.83322197e-02f, -7.41121098e-02f, -9.32080299e-02f, 9.06435698e-02f, 5.15277907e-02f,
  2.83457726e-01f, 7.42889419e-02f, 2.72945553e-01f, 1.42701909e-01f, 3.13678771e-01f, 3.41628969e-01f, 3.68082553e-01f, 2.33633414e-01f, 2.00241759e-01f, 1.79981381e-01f,
  1.62390932e-01f, -3.28155681e-02f, 1.13194227e-01f, -1.36707863e-03f, 1.17756516e-01f, 1.81463182e-01f, 1.27007738e-01f, 5.97650260e-02f, 8.74766409e-02f, 8.29095691e-02f,
  5.66958217e-03f, -2.20306494e-04f, -7.15826899e-02f, 8.04006755e-02f, 5.38685173e-03f, 8.01564008e-02f, -3.08379959e-02f, -1.18520789e-01f, -2.94631701e-02f, -1.58255994e-01f,
  -1.41408488e-01f, 1.24539845e-01f, 2.83255875e-02f, -5.43427728e-02f, -1.04998849e-01f, -7.07084090e-02f, 6.31427914e-02f, -1.78340942e-01f, -1.29144207e-01f, -6.66862354e-02f,
  -2.82884855e-02f, -1.34399518e-01f, -8.97566527e-02f, -1.63642138e-01f, -1.23735175e-01f, -1.35170678e-02f, -1.47155717e-01f, 5.86606488e-02f, -6.96643116e-03f, -1.09459497e-01f,
  -1.14807412e-01f, -5.58144972e-03f, 1.99046382e-03f, 1.15705676e-01f, 9.77234319e-02f, -2.67328322e-02f, 1.91489665e-03f, -1.03661316e-02f, -4.96547483e-02f, 5.15910797e-02f,
  1.39966398e-01f, 7.13586202e-03f, 4.85529006e-02f, 4.13286537e-02f, 4.82285991e-02f, 2.70025674e-02f, -3.10008749e-02f, -2.68638190e-02f, 7.64991269e-02f, 1.48325618e-02f,
  -4.34514415e-03f, 2.98188273e-02f, 5.41371778e-02f, 3.65650728e-02f, 1.08354405e-01f, -7.13711679e-02f, -5.10277599e-02f, 4.96770628e-02f, 3.64217088e-02f, -2.49136388e-02f,
  -1.68434046e-02f, 6.79264814e-02f, -2.34689750e-02f, 5.34393173e-03f, 6.45580888e-03f, 3.06517561e-03f, -8.72964710e-02f, -4.87182252e-02f, -2.69693155e-02f, -2.51754019e-02f,
  -1.65826216e-01f, 1.42625049e-01f, 5.48953339e-02f, -6.72649592e-02f, 1.75920650e-02f, -8.71928036e-02f, 1.29198939e-01f, -7.25835701e-03f, -1.23497628e-01f, 1.29153915e-02f,
  1.69808511e-02f, -1.03324853e-01f, -9.55305994e-03f, -1.23166116e-02f, 9.26979557e-02f, 1.52854975e-02f, -1.28549352e-01f, 1.11813210e-01f, 8.99492390e-03f, -4.57777977e-02f,
  -1.34286145e-02f, 9.46905762e-02f, 1.62190534e-02f, 1.14587180e-01f, 5.12884632e-02f, 1.51200555e-02f, -4.20341231e-02f, -1.18858563e-02f, 3.27606127e-02f, 3.62512320e-02f,
  -3.54396224e-01f, -5.44933602e-03f, -2.76721328e-01f, -3.49282980e-01f, -1.02484904e-01f, 3.58511917e-02f, 2.26397410e-01f, 1.09384224e-01f, -1.77796692e-01f, -9.26057547e-02f,
  -9.90878046e-02f, -1.76680252e-01f, -2.43372142e-01f, -1.20937424e-02f, -2.71425098e-02f, -1.35793969e-01f, -1.72227532e-01f, -1.90181106e-01f, -1.15407087e-01f, 4.89342250e-02f,
  -1.34434476e-02f, -1.85465083e-01f, -2.01505035e-01f, -1.57488555e-01f, -2.15358809e-01f, -2.20193863e-01f, -2.66192317e-01f, -1.89142942e-01f, -4.08262983e-02f, -1.92867026e-01f,
  -1.55535311e-01f, 2.72471085e-02f, -7.16468990e-02f, 1.21281436e-02f, -9.65080261e-02f, 1.90617908e-02f, -3.06928973e-03f, -6.05834089e-02f, -3.50083672e-02f, -7.91075919e-03f,
  -1.21966958e-01f, -9.49993823e-03f, -8.01150799e-02f, 3.10206437e-03f, 2.22675726e-02f, 3.82051617e-02f, 8.45053941e-02f, -3.61674167e-02f, -3.56852543e-03f, 2.07392573e-01f,
  8.76741782e-02f, 7.93977752e-02f, 1.14923909e-01f, 6.87408447e-02f, 8.59809369e-02f, -6.85634241e-02f, 1.30054757e-01f, 1.01038225e-01f, 1.43136814e-01f, -6.44666422e-03f,
  6.19439147e-02f, -1.21039869e-02f, 6.71340451e-02f, -3.04588303e-02f, 4.52380441e-02f, -6.41944679e-03f, -5.42896725e-02f, 4.91209701e-02f, 4.20256406e-02f, 1.56997386e-02f,
  -1.84620023e-02f, -4.32689898e-02f, -6.55804425e-02f, -4.41471450e-02f, 3.39567997e-02f, -2.49386225e-02f, 3.09868753e-02f, 7.43160993e-02f, 4.20945622e-02f, -6.71111792e-02f,
  4.37210463e-02f, 9.36667025e-02f, -7.88058266e-02f, -4.36263680e-02f, 1.29872104e-02f, -2.53171828e-02f, 5.16103767e-02f, 1.75395563e-01f, 3.48537564e-02f, 1.34170130e-02f,
  -3.10283422e-01f, 3.41014676e-02f, -4.43398468e-02f, -5.34555689e-02f, 1.49199059e-02f, -1.88159160e-02f, 3.29549350e-02f, -9.43790097e-03f, -2.69152261e-02f, 1.72474217e-02f,
  1.01272285e-01f, 3.36392000e-02f, -3.83971669e-02f, 2.68318839e-02f, -2.47559277e-03f, 5.63841723e-02f, 3.14661823e-02f, -8.56096521e-02f, 7.41286874e-02f, 6.93445280e-02f,
  9.70965102e-02f, 2.90088449e-02f, 7.26708677e-04f, 8.80904198e-02f, -2.00835038e-02f, -9.24351513e-02f, 8.42799321e-02f, 2.36709090e-03f, 8.35299939e-02f, -8.96498337e-02f,
  5.30198336e-01f, 6.24969825e-02f, -4.87261057e-01f, 2.79749304e-01f, -5.82898967e-02f, -7.31509775e-02f, -6.34690970e-02f, 2.32252046e-01f, 2.30868906e-01f, 1.09128445e-01f,
  -3.71976830e-02f, -7.78847709e-02f, -1.78686067e-01f, -2.21034765e-01f, -6.48046881e-02f, -1.57116577e-01f, -1.17995217e-01f, -2.37783641e-01f, -2.50907719e-01f, -4.41718437e-02f,
  1.12298846e-01f, 9.39621031e-02f, 1.57057896e-01f, -2.17660610e-02f, 6.97998032e-02f, -1.06859408e-01f, -2.94319708e-02f, -7.50862360e-02f, -2.37919867e-01f, -1.77039564e-01f,
  -4.55911070e-01f, -5.24803856e-03f, 3.33353935e-04f, 3.45030166e-02f, -9.51051638e-02f, 1.55005723e-01f, 5.93088642e-02f, 3.36400531e-02f, 1.05419390e-01f, 6.73799217e-03f,
  -8.35559592e-02f, 9.34673399e-02f, -4.40692604e-02f, 3.36025208e-02f, 2.87642539e-03f, 8.40530917e-02f, 1.10083140e-01f, 5.08888587e-02f, 1.45054385e-02f, -5.77725433e-02f,
  2.19118129e-02f, -4.78043631e-02f, -2.00744778e-01f, 4.46513556e-02f, -3.56897116e-02f, -2.06207469e-01f, -6.56554699e-02f, -1.18908659e-01f, -1.46567360e-01f, 2.34799564e-01f,
  1.35353506e-01f, -1.11675840e-02f, -9.15378481e-02f, 2.51977239e-02f, 1.28485739e-01f, 1.03763565e-02f, -2.41583902e-02f, -3.05135939e-02f, -2.66549867e-02f, 1.48122996e-01f,
  -2.24062949e-02f, -5.65262362e-02f, -4.81244102e-02f, 5.16436324e-02f, -2.47558132e-02f, -2.99315080e-02f, -5.18114455e-02f, 9.56580415e-02f, -4.58698496e-02f, 7.01876730e-02f,
  -2.79353689e-02f, -9.11717117e-02f, 3.21022496e-02f, -1.87123865e-02f, -1.35560036e-01f, -7.43617564e-02f, -4.54307348e-02f, -1.09523302e-02f, 7.41726160e-02f, 7.23303854e-02f,
  2.75058925e-01f, -2.70446360e-01f, 5.66896796e-02f, 9.95972380e-03f, -7.31870234e-02f, 3.13862413e-02f, -1.21151306e-01f, 4.34633978e-02f, -7.83494040e-02f, 1.77702550e-02f,
  -1.19911797e-01f, -2.80557331e-02f, -8.70636553e-02f, -2.64607742e-02f, 5.63255884e-02f, 8.86974111e-03f, -2.72612795e-02f, -5.11352494e-02f, -1.08367324e-01f, 3.16934064e-02f,
  1.09979019e-01f, 8.97107720e-02f, 1.32239193e-01f, -3.87649052e-02f, 1.66778732e-02f, -1.21803237e-02f, -1.37478650e-01f, 5.55387046e-03f, -1.03047818e-01f, 4.24985558e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.54262739e-01f, 2.48570815e-02f, 1.49934202e-01f, -1.74962170e-02f, 5.88157713e-01f, 5.22219241e-01f, 3.60506624e-01f, 7.51011729e-01f, 3.34619224e-01f, 5.60084105e-01f,
  6.07647121e-01f, 7.96239078e-02f, 2.10434511e-01f, 4.07749265e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.50274262e-01f, -1.47071034e-01f, 7.88358077e-02f, -1.96740013e-02f, 1.74794227e-01f, -5.92953324e-01f, -1.89884171e-01f, 2.33089373e-01f, -2.11958960e-01f, 3.18134338e-01f,
  -3.87297541e-01f, 1.94689915e-01f, 4.49869066e-01f, 1.92549944e-01f, 1.81276605e-01f, 3.65816019e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.20384055e-01f, -3.36580753e-01f, -2.18136519e-01f, -5.12686431e-01f, 4.59254026e-01f, -6.59017682e-01f, 6.95077181e-01f, 9.22237262e-02f, 9.13108662e-02f, 1.54123589e-01f,
  -2.11114958e-01f, 4.80204701e-01f, 3.15536916e-01f, -4.35841352e-01f, -2.63675392e-01f, 8.59091461e-01f, 2.06014082e-01f, 1.99060664e-01f, -7.26603121e-02f, 1.65324658e-01f,
  -2.14830503e-01f, -1.14166386e-01f, -1.30704612e-01f, 4.81958240e-02f, 3.24364930e-01f, 1.51163220e-01f, 1.02849305e+00f, -1.36761859e-01f, -1.75933182e-01f, 5.93752749e-02f,
  -2.31207043e-01f, -3.21265876e-01f, 8.54873732e-02f, 1.19511858e-01f, -3.11384410e-01f, -1.37446806e-01f, 5.03111333e-02f, 6.51415437e-02f, -3.11769575e-01f, 1.29821852e-01f,
  -2.89987046e-02f, 7.29464054e-01f, 7.37180412e-02f, -1.08997725e-01f, 6.83644831e-01f, 5.61260343e-01f, 1.10559732e-01f, 6.54882252e-01f, -7.23128468e-02f, -1.87660735e-02f,
  -3.84306721e-02f, -1.41126022e-01f, -1.55298263e-01f, -2.22129881e-01f, 1.75498717e-03f, 3.22168022e-01f, 5.84410310e-01f, 4.71576780e-01f, -1.05203256e-01f, 3.69109631e-01f,
  -3.81452978e-01f, -1.35409888e-02f, 8.51264969e-02f, 1.59186602e-01f, 9.69223082e-02f, 5.20218730e-01f, -1.87549181e-03f, -1.56243160e-01f, 1.81965038e-01f, 9.26461637e-01f,
  3.23345959e-01f, 2.27630109e-01f, 1.12649953e+00f, -2.70122737e-01f, -1.44177571e-01f, -9.57152024e-02f, -5.63421488e-01f, 4.66093123e-01f, 4.33824152e-01f, -2.87040979e-01f,
  1.82679668e-01f, 2.19033390e-01f, -2.12428212e-01f, 2.93789804e-01f, 1.12119213e-01f, -1.39827326e-01f, 6.78206189e-03f, -6.20824508e-02f, 4.55682516e-01f, -8.50142837e-02f,
  5.88599086e-01f, 3.38324904e-01f, 6.41331136e-01f, 4.56649184e-01f, -6.34363666e-02f, 1.79955304e-01f, -7.85702094e-03f, 1.12417012e-01f, 2.05367371e-01f, -9.93068591e-02f,
  -2.56615639e-01f, -2.07532495e-01f, -1.12174593e-01f, 6.49118796e-03f, 3.51804882e-01f, 1.30603775e-01f, -1.89653054e-01f, -7.30873346e-02f, 4.04180646e-01f, 3.91360652e-03f,
  -3.02774049e-02f, -3.36489268e-02f, 5.89700103e-01f, 1.04366988e-01f, 7.85395056e-02f, -3.76652569e-01f, -1.76558197e-01f, -2.85704046e-01f, -1.77778736e-01f, 1.34108692e-01f,
  5.38515568e-01f, -2.66520381e-01f, 3.82034391e-01f, 5.72649777e-01f, 5.24937630e-01f, 6.40191659e-02f, 3.11379492e-01f, 6.22265399e-01f, 4.45539206e-01f, -3.80041003e-02f,
  -2.94528633e-01f, 4.94932950e-01f, -2.89069653e-01f, 1.40226576e-02f, -3.42258424e-01f, -1.80439860e-01f, -2.64824480e-01f, 6.47732913e-01f, 2.41742626e-01f, 1.57211740e-02f,
  8.82690489e-01f, -9.46700796e-02f, 1.79352984e-01f, 2.21545622e-01f, 3.53109360e-01f, -3.24433386e-01f, -6.04204983e-02f, -3.45448196e-01f, 1.92165345e-01f, 3.40925276e-01f,
  1.45666945e+00f, 9.05856714e-02f, -1.94615111e-01f, -5.76134175e-02f, -2.82252252e-01f, 6.58590734e-01f, -1.88287035e-01f, -3.12242150e-01f, -2.36871257e-01f, -2.62116343e-01f,
  7.68997893e-02f, 3.15011330e-02f, 1.21440530e-01f, -3.53252530e-01f, -3.48330617e-01f, -2.13728443e-01f, 9.01158061e-03f, 6.57164037e-01f, 5.98430693e-01f, 8.47047150e-01f,
  -2.16543749e-01f, -1.27256945e-01f, -5.11689484e-01f, -4.73791808e-02f, 5.26024520e-01f, -1.35627940e-01f, -4.33953345e-01f, -3.40102792e-01f, 8.60244930e-01f, -1.92144379e-01f,
  2.84883678e-01f, 1.92490458e-01f, 4.16174740e-01f, 1.08331978e+00f, -5.93712032e-01f, -1.72631994e-01f, -1.21637680e-01f, 1.41505897e-01f, 8.22679326e-03f, -7.53323957e-02f,
  6.79749846e-01f, 5.70529513e-02f, 3.59081447e-01f, 4.04965460e-01f, 4.09190178e-01f, 5.66415071e-01f, -1.52139934e-02f, -2.22067479e-02f, -4.43426460e-01f, 5.23028195e-01f,
  -2.21854880e-01f, -3.53799239e-02f, -2.00094998e-01f, 8.95782530e-01f, 7.44772792e-01f, 1.48404375e-01f, 2.45443374e-01f, -5.25024593e-01f, 2.17230931e-01f, -3.48063231e-01f,
  -2.82485545e-01f, -5.09729624e-01f, 1.86766118e-01f, 1.68830171e-01f, 6.67738795e-01f, 1.99929073e-01f, -4.64653224e-01f, 1.04604268e+00f, 3.42823833e-01f, -1.05644397e-01f,
  -5.83097100e-01f, 1.65339485e-01f, -2.89638966e-01f, 2.10608661e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.50387895e-01f, 2.46201962e-01f, 1.95182562e-01f, -7.75259361e-02f, 2.45613188e-01f, 1.14504814e-01f, 2.32722759e-01f, 5.58738232e-01f, 2.06047416e-01f, 5.80638111e-01f,
  4.85955417e-01f, 1.48686245e-01f, 2.68297046e-01f, 5.87704360e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -5.29632092e-01f, -4.97201771e-01f, 2.32641891e-01f, -2.20240459e-01f, 2.85681814e-01f, 7.00130016e-02f, -4.27252531e-01f, -2.78301593e-02f, 9.55266804e-02f, 3.17721695e-01f,
  2.91686594e-01f, -7.17201829e-01f, -3.32664400e-01f, 7.21727073e-01f, 6.05979860e-01f, -7.00670898e-01f, -2.64798969e-01f, 4.77277547e-01f, -2.82925814e-01f, -2.62037724e-01f,
  4.93236214e-01f, -3.91759813e-01f, 5.01216412e-01f, 6.27870798e-01f, 6.49603084e-02f, -1.17818251e-01f, 9.02041614e-01f, -6.48098469e-01f, -5.45747459e-01f, -5.80409646e-01f,
  6.77985966e-01f, -7.25986123e-01f, 4.79751825e-01f, 4.91938114e-01f, 2.35026434e-01f, -1.71754390e-01f, -6.71476424e-01f, -9.54598561e-02f, -7.63552070e-01f, 2.05631301e-01f,
  1.89440250e-01f, 4.00163978e-01f, 2.15444546e-02f, 5.07340908e-01f, -4.71263587e-01f, -4.92779277e-02f, 8.77996325e-01f, -4.20993567e-01f, -1.99627265e-01f, 5.48216581e-01f,
  -6.80268466e-01f, -2.48027891e-02f, -4.25114393e-01f, -8.50790963e-02f, 3.93395633e-01f, -5.17804861e-01f, -2.43680224e-01f, 1.83360040e-01f, -2.91206360e-01f, -3.76506776e-01f,
  5.01932800e-01f, 9.13517475e-01f, 3.30626428e-01f, -3.14458609e-01f, -8.62754524e-01f, 8.02498832e-02f, 5.24408758e-01f, 2.56396867e-02f, -1.98257212e-02f, 6.67417467e-01f,
  -3.62164646e-01f, -2.66334206e-01f, -2.51095682e-01f, -5.55685349e-03f, -3.45478624e-01f, 7.71230236e-02f, 4.66744959e-01f, 3.44451964e-01f, 2.24941254e-01f, 2.38106877e-01f,
  -1.85856938e-01f, 3.97870243e-01f, 8.16719711e-01f, -4.82113928e-01f, 7.60733724e-01f, -5.95249236e-02f, -4.23897147e-01f, 3.97515371e-02f, 1.16600208e-01f, 6.29539847e-01f,
  3.54685485e-01f, -3.77822697e-01f, -7.07088271e-03f, -4.15399104e-01f, -4.82373953e-01f, 1.75013587e-01f, 5.53859711e-01f, -3.58750790e-01f, 8.07268202e-01f, -1.75145239e-01f,
  -3.93447310e-01f, 3.22840549e-02f, 1.26221657e-01f, 8.68182629e-02f, -1.72231212e-01f, 1.39194161e-01f, -3.21097940e-01f, 7.19196618e-01f, -4.18494582e-01f, -7.92283535e-01f,
  -6.18628502e-01f, 1.03547141e-01f, -8.38117421e-01f, -4.26185697e-01f, -6.82115555e-01f, -1.95458353e-01f, -3.75477038e-03f, -6.76394925e-02f, 7.58601844e-01f, -2.25759417e-01f,
  -7.99784902e-03f, -8.04725289e-01f, -3.59983981e-01f, 7.53530562e-01f, -3.77424002e-01f, 1.14698857e-02f, -1.09865934e-01f, 3.83338630e-01f, 4.93283570e-01f, -7.58291066e-01f,
  -2.96738386e-01f, 1.02552068e+00f, 1.52058870e-01f, -2.80634105e-01f, -2.54290193e-01f, 6.93268776e-01f, -3.70530635e-01f, 3.00789297e-01f, 2.01888680e-01f, -5.06820977e-01f,
  -6.78086579e-01f, -5.48023172e-02f, -1.97631970e-01f, 1.86715916e-01f, 1.54727146e-01f, 1.69590771e-01f, 5.04988372e-01f, -3.23681086e-02f, -4.43033129e-01f, -2.69659430e-01f,
  -7.80027449e-01f, -3.56738329e-01f, -2.30742440e-01f, -4.47684646e-01f, -3.03455204e-01f, 8.23029876e-01f, -9.56075788e-02f, 7.76237547e-01f, -6.91698909e-01f, 5.78372717e-01f,
  2.04092830e-01f, 4.25285310e-01f, -1.70126438e-01f, 2.78951049e-01f, 1.96181685e-01f, 1.22184299e-01f, -6.16747618e-01f, -4.04178292e-01f, -7.07296804e-02f, -7.25130916e-01f,
  4.13884491e-01f, -2.65254408e-01f, 5.35583258e-01f, -3.48749340e-01f, -2.61758536e-01f, 9.90064204e-01f, 5.74229777e-01f, -7.05611110e-01f, -3.04374069e-01f, 2.11067647e-01f,
  -3.65139633e-01f, 3.22788626e-01f, 6.44122839e-01f, 3.32370140e-02f, 2.50689864e-01f, 2.71815568e-01f, -4.28192407e-01f, -2.21964806e-01f, 5.62921822e-01f, -2.12031901e-01f,
  -2.40790114e-01f, -4.28559959e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.66488662e-01f, -6.63910359e-02f, 1.98270813e-01f, -1.77710623e-01f, -2.16563180e-01f, -8.49646851e-02f, -4.90163900e-02f, -3.08283325e-02f, 1.66016266e-01f, 2.80641038e-02f,
  1.21664546e-01f, 8.99416879e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    