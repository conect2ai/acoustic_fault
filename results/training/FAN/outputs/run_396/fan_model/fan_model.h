/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.35306773e-02f, -1.15590967e-01f, -2.80747831e-01f, -6.41874373e-02f, 4.07165289e-02f, 1.65542766e-01f, -2.73338873e-02f, -1.42832771e-01f, -1.09456263e-01f, 5.51828444e-02f,
  -7.22540123e-03f, -2.39860952e-01f, -7.72812814e-02f, 8.70479196e-02f, -8.82757381e-02f, 3.40418294e-02f, 1.28131464e-01f, 4.49576741e-03f, 1.80331729e-02f, 5.25250249e-02f,
  -1.18321352e-01f, 2.23159820e-01f, -2.06906244e-01f, -5.35222283e-03f, -4.03110497e-02f, -1.36856973e-01f, 1.99227184e-01f, -2.05950454e-01f, 2.51072258e-01f, -6.34403154e-02f,
  5.17499335e-02f, -1.60768315e-01f, -2.92201098e-02f, -3.57464813e-02f, 4.12798449e-02f, -1.14978611e-01f, -8.60751122e-02f, -1.27069443e-01f, 6.94624893e-03f, -7.41352439e-02f,
  -7.43730227e-04f, -8.62955824e-02f, 3.32625280e-03f, -9.80160758e-02f, -3.86639647e-02f, 6.51463121e-03f, -1.01380281e-01f, 3.00663318e-02f, -6.71463832e-02f, -2.17360090e-02f,
  -4.31795083e-02f, 1.13070162e-03f, 7.81942066e-03f, 1.87968276e-02f, -8.51333812e-02f, -7.55412728e-02f, -4.95532714e-02f, -2.71883085e-02f, 3.55386026e-02f, -4.35000435e-02f,
  -4.31062095e-02f, -6.36443868e-02f, 7.37426942e-03f, 1.41467769e-02f, 6.31748810e-02f, 2.80481149e-02f, 4.62840684e-03f, -3.47975205e-04f, 3.92964445e-02f, 4.74652909e-02f,
  6.73647970e-03f, -5.00589125e-02f, 1.56751450e-03f, -5.34392893e-02f, -1.25871701e-02f, -3.06947646e-03f, 1.22412674e-01f, 1.39599927e-02f, -2.86530741e-02f, -1.05009330e-02f,
  -7.08715022e-02f, 9.96506959e-03f, -2.88005378e-02f, 9.04981494e-02f, -5.56132123e-02f, -1.04424711e-02f, -3.76877859e-02f, 2.28077993e-02f, 5.14124669e-02f, -6.04445711e-02f,
  2.72702724e-01f, 1.11205354e-02f, 1.58701837e-02f, 4.17108759e-02f, 9.50013474e-02f, 7.88833201e-02f, -1.75430439e-02f, 4.28206734e-02f, 6.51228055e-02f, 4.29584868e-02f,
  -6.59130365e-02f, 1.43863454e-01f, 3.10096983e-02f, 6.66644722e-02f, 1.82500537e-02f, -2.22502239e-02f, 9.15311351e-02f, 8.85989051e-03f, 8.33350644e-02f, 3.48380879e-02f,
  1.74543390e-03f, 1.95799004e-02f, -7.34634697e-02f, -6.79419795e-03f, 3.32307778e-02f, 1.14424758e-01f, 2.30478514e-02f, -5.53124286e-02f, -3.78656015e-02f, 4.87296004e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.68058294e-01f, -2.95300465e-02f, -4.28642750e-01f, 5.16705886e-02f, 2.38440558e-01f, 2.31869414e-01f, -2.54992813e-01f, 1.03288397e-01f, -4.25897300e-01f, 5.25415540e-02f,
  3.49106580e-01f, -6.66057840e-02f, -4.41203475e-01f, 7.39087045e-01f, 3.73262078e-01f, -2.17437819e-01f, 6.10036254e-01f, 8.57286304e-02f, -3.02540094e-01f, 1.93824068e-01f,
  1.01079933e-01f, 7.65126348e-01f, 3.00332718e-02f, 2.60933399e-01f, 4.29999501e-01f, -2.75252938e-01f, 8.90913904e-02f, -2.95187294e-01f, 4.09543127e-01f, 1.62338406e-01f,
  9.14655328e-02f, 1.09113783e-01f, -1.22527070e-01f, -1.03313051e-01f, 5.74808493e-02f, 7.10145608e-02f, -1.61801904e-01f, -4.61156629e-02f, -1.37773067e-01f, -5.35209142e-02f,
  -4.89685573e-02f, 9.90994945e-02f, 1.32269382e-01f, 2.51887832e-02f, 1.53024882e-01f, -9.50315744e-02f, 1.12622427e-02f, -1.46407142e-01f, -1.71878859e-01f, 1.86347380e-01f,
  -3.70236859e-02f, -7.98939317e-02f, 2.76506552e-03f, -1.06269397e-01f, -2.23670085e-03f, 9.03424527e-03f, -1.65391386e-01f, -9.85753462e-02f, -5.59318103e-02f, 4.07749005e-02f,
  1.72870845e-01f, -2.46289503e-02f, 2.60010567e-02f, -5.34683354e-02f, -6.21958226e-02f, -4.43663187e-02f, 9.63474214e-02f, 2.92536616e-02f, -1.58577725e-01f, 7.26458281e-02f,
  3.74476425e-02f, 5.54885454e-02f, 4.45893221e-02f, 5.89506775e-02f, 9.08212811e-02f, -1.43677756e-01f, -1.19897410e-01f, 1.31923184e-01f, -1.43779302e-02f, -2.17023417e-02f,
  -1.31096393e-01f, -4.14454006e-02f, -4.97792214e-02f, -8.57865065e-02f, -2.71431394e-02f, 1.21156275e-02f, 1.71309769e-01f, 9.24493745e-02f, -1.03616618e-01f, -7.37020094e-03f,
  1.39022872e-01f, 2.27931961e-01f, -1.34285197e-01f, -4.56277952e-02f, -1.44237384e-01f, 1.44346863e-01f, -7.62458816e-02f, 1.72827095e-02f, -1.32747799e-01f, -1.58783682e-02f,
  1.29948735e-01f, -1.82019547e-01f, 6.54288679e-02f, 7.69835711e-02f, -1.93365216e-01f, -2.70222705e-02f, -2.96963518e-03f, -1.78518310e-01f, -7.40754008e-02f, 1.32478788e-01f,
  -1.69193558e-02f, 4.04388271e-03f, -3.61137167e-02f, -6.29780674e-03f, 4.78209555e-02f, 3.49964164e-02f, -4.33520675e-02f, -3.59234214e-02f, 1.32155955e-01f, -8.20559859e-02f,
  -2.79950142e-01f, 4.55181748e-01f, -1.73017398e-01f, 1.26122192e-01f, -2.60071218e-01f, 8.79250407e-01f, 8.31290007e-01f, -2.33438816e-02f, 7.80745670e-02f, 3.76569241e-01f,
  1.06830440e-01f, 1.31265342e-01f, 3.29355687e-01f, 4.58674461e-01f, 4.46260184e-01f, 5.11406660e-01f, 5.81231177e-01f, 4.15501922e-01f, -2.45069377e-02f, 1.48021460e-01f,
  -2.67790426e-02f, 4.88303214e-01f, 1.24199558e-02f, -9.88010019e-02f, -2.12225933e-02f, -3.03590924e-01f, -3.64545465e-01f, -1.70858234e-01f, -1.69484988e-01f, 1.76871955e-01f,
  7.95464814e-02f, -8.49941373e-02f, -1.65442139e-01f, 1.90662406e-02f, 8.21273178e-02f, -2.79870331e-02f, 8.68356973e-02f, 2.64294501e-02f, -1.22669630e-01f, 2.03219261e-02f,
  2.24014390e-02f, 6.15370497e-02f, 4.54829000e-02f, 2.47330107e-02f, -1.94276586e-01f, -1.14441022e-01f, -1.68954685e-01f, -1.92321673e-01f, -1.59705349e-03f, -8.49487707e-02f,
  -1.81502759e-01f, -1.04666516e-01f, -8.92458409e-02f, 1.80562466e-01f, -1.34297833e-01f, -1.44883078e-02f, 2.87737161e-01f, 4.50857952e-02f, 3.52922082e-02f, 1.20943159e-01f,
  4.79201078e-02f, 2.62183934e-01f, 3.69870290e-02f, -8.73304754e-02f, 7.08312076e-03f, -7.33574778e-02f, 3.40395304e-03f, -9.67401192e-02f, -1.97530612e-02f, 7.74626359e-02f,
  -7.73726031e-02f, -1.38106020e-02f, -1.28155956e-02f, 3.83816771e-02f, -2.84202378e-02f, 9.09635201e-02f, -3.19266394e-02f, -2.03554519e-02f, -8.89646709e-02f, -4.47411239e-02f,
  -4.44632629e-03f, 1.26986921e-01f, 5.66205382e-02f, 8.12973827e-02f, 9.76438373e-02f, -4.65995818e-02f, 9.86819640e-02f, -6.52185827e-02f, -7.33397305e-02f, 6.26703203e-02f,
  2.42771626e-01f, 5.49135566e-01f, 1.11912629e-02f, 1.53948916e-02f, -1.27240047e-01f, -1.60064995e-01f, 1.03771411e-01f, 6.03153817e-02f, 6.16026744e-02f, 8.33363533e-02f,
  2.50468473e-03f, -2.61493190e-03f, -2.15956625e-02f, -9.73505303e-02f, 2.04491392e-02f, 1.26425654e-01f, 1.82893336e-01f, -9.46361199e-02f, 5.53052276e-02f, -4.66640964e-02f,
  -1.25870466e-01f, 1.03159979e-01f, 1.10549137e-01f, 5.58297820e-02f, 3.05731897e-03f, 5.29050976e-02f, -9.09822285e-02f, -1.61541998e-01f, 3.44391651e-02f, 6.79459050e-02f,
  -8.30990791e-01f, 1.65203407e-01f, -2.04037800e-01f, -1.90339327e-01f, -4.53689098e-01f, -5.62727511e-01f, 1.10239856e-01f, -2.96275228e-01f, -7.17589259e-02f, 3.63794863e-01f,
  2.91292548e-01f, -3.99872899e-01f, 3.73104572e-01f, 2.02238739e-01f, -5.94649374e-01f, 4.64919686e-01f, -9.90447924e-02f, 1.81012496e-01f, -8.36715698e-02f, -3.67257774e-01f,
  -2.33965069e-01f, -9.64709669e-02f, 1.06703967e-01f, -2.38251895e-01f, -3.28617662e-01f, -1.55211434e-01f, 1.24822982e-01f, -6.03593625e-02f, -1.23492591e-01f, -1.09164894e-01f,
  -3.38600457e-01f, -2.35020041e-01f, 8.92608017e-02f, -8.00412372e-02f, -1.51572645e-01f, -1.37368031e-02f, -6.07992336e-02f, -8.58290959e-03f, -5.97192049e-02f, -4.14980240e-02f,
  -1.58978701e-02f, -1.66382492e-01f, -1.56648811e-02f, -6.69161677e-02f, -1.41622216e-01f, -2.45909696e-03f, -8.64129886e-02f, -2.82465816e-02f, 1.99376326e-02f, -2.70801205e-02f,
  1.12193432e-02f, 4.91374545e-02f, 1.21535128e-02f, 7.13817328e-02f, -1.36362985e-01f, 7.27320672e-04f, 1.19371004e-01f, 2.98924278e-02f, -1.50139704e-01f, -2.28247106e-01f,
  1.13090652e-03f, 8.61767009e-02f, 2.54367013e-03f, -2.78647542e-02f, -2.07182929e-01f, 6.28355145e-02f, -5.95139060e-03f, 1.22825451e-01f, 1.03907930e-02f, 2.69328076e-02f,
  -1.42571360e-01f, 2.59225070e-03f, -1.16942242e-01f, 4.25518900e-02f, -4.01645339e-05f, 3.13546136e-02f, -1.67640150e-02f, -1.40409563e-02f, 9.41083208e-02f, -4.24451083e-02f,
  4.13689949e-02f, 1.29151577e-02f, 7.34980926e-02f, 1.53137892e-01f, -4.05399874e-02f, -1.06399514e-01f, 1.47587201e-02f, 3.01265176e-02f, 8.18718523e-02f, -6.27008155e-02f,
  -7.04700470e-01f, -7.98028171e-01f, 5.24501652e-02f, -7.55186304e-02f, 1.46175141e-03f, -1.30265802e-01f, 3.50154191e-02f, -8.46642330e-02f, -1.49903700e-01f, -1.21500634e-01f,
  -1.06114887e-01f, 1.31717473e-01f, -1.80118561e-01f, 7.15789422e-02f, -5.84327392e-02f, -1.49074728e-02f, -3.39413732e-02f, -1.69709437e-02f, -9.72674415e-02f, -1.14374615e-01f,
  -3.27396840e-02f, -8.86253547e-03f, 2.68963967e-02f, 8.27815034e-04f, 7.87078366e-02f, 7.68427132e-03f, -2.32040435e-01f, 5.15013561e-02f, -1.49573788e-01f, 7.08567277e-02f,
  5.65875351e-01f, 4.70977187e-01f, 4.51602459e-01f, 4.89905894e-01f, -2.66187906e-01f, 1.79264173e-01f, 1.12987667e-01f, 1.38631344e-01f, 6.10161841e-01f, -6.49998859e-02f,
  -6.07650876e-01f, 5.69214582e-01f, -3.28097314e-01f, 2.23788574e-01f, -9.52754244e-02f, 4.35643829e-02f, 3.07303846e-01f, 1.02164939e-01f, 2.12436363e-01f, 1.41035080e-01f,
  1.41323909e-01f, -6.16681874e-01f, -1.61398202e-01f, -4.29673553e-01f, -1.22932419e-01f, 2.03874528e-01f, -5.80257773e-01f, -2.37712041e-01f, -3.17707449e-01f, -2.18575850e-01f,
  -1.83412526e-03f, 1.21786602e-01f, 7.27182329e-02f, 5.01345024e-02f, 4.40008603e-02f, -2.96044294e-02f, -1.39659867e-01f, -1.82108939e-01f, -3.74371707e-02f, 1.49107903e-01f,
  4.48064208e-02f, -3.36746573e-02f, 1.70987129e-01f, -4.67108563e-02f, 5.82867935e-02f, -9.81783681e-03f, 2.43005920e-02f, -1.60171126e-03f, 1.64674316e-02f, -1.34911807e-02f,
  8.00682381e-02f, 5.72053045e-02f, -2.87411362e-03f, -1.33852754e-02f, 8.65027383e-02f, 6.23583682e-02f, 1.56207131e-02f, -8.69057514e-03f, 7.36658275e-02f, 2.73244623e-02f,
  1.19822538e-02f, -8.51890966e-02f, -1.39830247e-01f, -1.67531520e-01f, -2.21891508e-01f, -1.70256376e-01f, -1.12733483e-01f, -8.13361406e-02f, 1.03793129e-01f, -1.29869819e-01f,
  9.82785970e-03f, -1.12523824e-01f, -5.60018048e-02f, 4.42191474e-02f, -1.56250317e-02f, 6.92851543e-02f, -8.99971798e-02f, 6.94581773e-03f, 1.66267976e-01f, -3.72859538e-02f,
  -1.17221415e-01f, -5.46661727e-02f, -8.56503248e-02f, -5.42820804e-02f, -9.03458968e-02f, -1.00612566e-01f, 7.64823556e-02f, 4.76389565e-03f, -5.05838916e-02f, -7.03349635e-02f,
  1.06738895e-01f, 9.13568139e-02f, 1.18498869e-01f, 1.43774794e-02f, 1.56622510e-02f, -6.82960823e-02f, -1.50751853e-02f, 1.28386855e-01f, 4.33115289e-02f, -9.41338390e-03f,
  1.01635501e-01f, -7.53937056e-03f, 2.02717334e-02f, -7.86610246e-02f, 2.00570337e-02f, -9.88281071e-02f, 3.87774035e-02f, 5.79717085e-02f, -1.21393353e-02f, -7.86594078e-02f,
  -8.86832401e-02f, -8.98380205e-02f, 9.73435715e-02f, -4.31810804e-02f, -5.71336299e-02f, -1.65321216e-01f, 8.92929584e-02f, 9.79851857e-02f, -2.14674160e-01f, 8.27104971e-02f,
  -6.88294530e-01f, 3.78179140e-02f, 4.02692586e-01f, 8.01812053e-01f, -3.46968144e-01f, -7.09720194e-01f, -7.05136120e-01f, 8.31015334e-02f, -9.26631689e-02f, -2.44042680e-01f,
  -6.62517101e-02f, -6.80225119e-02f, -2.44373307e-01f, 4.68537003e-01f, 2.98064917e-01f, 1.43289179e-01f, 3.04724604e-01f, -1.56943932e-01f, 1.46770179e-01f, 2.23757148e-01f,
  4.86914784e-01f, 3.08711588e-01f, 6.36240423e-01f, 3.18776995e-01f, 3.31138186e-02f, 3.55240405e-01f, 4.97688830e-01f, 1.51926875e-01f, 2.88467735e-01f, 4.52497602e-03f,
  -3.81831110e-01f, 1.93497851e-01f, 2.44413428e-02f, -4.72450741e-02f, 3.83715853e-02f, -1.53151050e-01f, -6.13893904e-02f, -1.03621088e-01f, 9.45696011e-02f, -3.38179953e-02f,
  -2.00673223e-01f, 5.90328164e-02f, 6.33369610e-02f, 7.09935054e-02f, -1.53424963e-01f, -1.68353438e-01f, -2.41704192e-02f, -1.10445805e-01f, -7.84071907e-02f, -2.42777783e-02f,
  5.64234750e-03f, -5.05591230e-03f, 6.20788597e-02f, 1.37765244e-01f, 4.35248315e-02f, 1.09144114e-01f, 1.67628154e-01f, 8.49235579e-02f, -1.66321807e-02f, 2.79992484e-02f,
  -1.24075655e-02f, 6.20030686e-02f, -3.76024051e-03f, -3.78048345e-02f, -1.36697637e-02f, 8.75618234e-02f, -9.98244155e-03f, 3.43495794e-02f, 4.02013101e-02f, -8.51146206e-02f,
  1.05979234e-01f, 9.05739069e-02f, -1.21060841e-01f, 6.54827338e-03f, -2.94274148e-02f, 3.72042172e-02f, 5.76877631e-02f, -3.55145545e-03f, 2.14662142e-02f, 1.27891321e-02f,
  9.37263817e-02f, 2.26355959e-02f, 3.25837247e-02f, -3.93932611e-02f, -8.81541818e-02f, 1.55134991e-01f, 1.55563265e-01f, 3.98219116e-02f, -1.78566668e-02f, -1.35937408e-01f,
  2.17029490e-02f, 5.38500965e-01f, -4.12297994e-02f, -1.99614391e-01f, 2.78911670e-04f, -4.57269326e-02f, 7.74869546e-02f, 6.65591210e-02f, -5.06486371e-02f, -9.92643908e-02f,
  -3.89468260e-02f, -1.02432139e-01f, 2.99189929e-02f, -1.06721587e-01f, 1.77080631e-01f, 2.20593307e-02f, 8.71653706e-02f, 1.14935957e-01f, 1.12862803e-01f, 6.74590841e-02f,
  -5.59710525e-03f, -1.02684461e-01f, 3.89171317e-02f, -1.43223941e-01f, 1.23895518e-02f, -1.56699806e-01f, -2.49155890e-02f, 5.04939025e-03f, 1.88430399e-01f, 2.02850655e-01f,
  -9.80006874e-01f, 1.74960405e-01f, 8.00472438e-01f, -5.41028619e-01f, -6.12993399e-03f, 7.95267224e-01f, 2.47193038e-01f, -9.69465449e-02f, -4.09943938e-01f, -1.56458467e-01f,
  -2.32634217e-01f, -2.76817888e-01f, 2.99473584e-01f, 1.67922691e-01f, 5.34352362e-01f, 3.78834099e-01f, 1.28057420e-01f, -3.82542028e-03f, 4.11083363e-02f, -2.60848671e-01f,
  -1.06936514e-01f, -3.19709748e-01f, 6.38062298e-01f, -9.12341475e-02f, -3.12051810e-02f, -1.82750449e-01f, -2.65948296e-01f, 2.94518709e-01f, -7.38549680e-02f, 4.57753427e-02f,
  2.51559429e-02f, -5.73888183e-01f, 1.27003938e-01f, 1.77778870e-01f, 2.41869278e-02f, -5.66706620e-02f, -2.54477281e-02f, 1.56598657e-01f, 1.01520745e-02f, -8.30176845e-02f,
  -1.24305144e-01f, 2.81215813e-02f, -1.98614463e-01f, 1.91792734e-02f, -1.29907876e-01f, 9.08859074e-02f, 2.00704753e-01f, 2.45011166e-01f, 8.13604519e-02f, 2.11508855e-01f,
  1.96247637e-01f, 1.84454441e-01f, 7.44282454e-02f, -2.62923632e-02f, 3.33301947e-02f, 1.04187109e-01f, 1.23275578e-01f, 4.55203839e-03f, 1.52383782e-02f, -1.00625819e-02f,
  -1.83752283e-01f, -8.62731263e-02f, 3.21474299e-02f, -5.27406596e-02f, -7.59971002e-03f, -1.42673612e-01f, -9.57999229e-02f, -4.24774736e-03f, -3.37023102e-02f, -5.87559789e-02f,
  -9.86272916e-02f, -1.08251981e-01f, -6.02389164e-02f, 1.06454551e-01f, -7.29107261e-02f, -1.74859196e-01f, 1.44214556e-01f, -7.70967975e-02f, -4.99086045e-02f, 6.05770096e-04f,
  -7.09982365e-02f, -3.30901556e-02f, -9.37791020e-02f, -6.09620288e-02f, 6.94705322e-02f, 8.52687657e-03f, -1.34019420e-01f, 1.75349385e-01f, -4.42094617e-02f, -5.12746423e-02f,
  -8.30979669e-04f, -3.86007279e-01f, -8.74194577e-02f, -9.97801125e-02f, -1.42183471e-02f, -5.53442612e-02f, 4.61862423e-02f, -6.76243007e-02f, -8.65324959e-02f, -6.85292631e-02f,
  1.97570138e-02f, -1.42452627e-01f, 5.79230674e-02f, 4.47714776e-02f, 2.54683066e-02f, 1.19209036e-01f, -9.54353511e-02f, -1.62332460e-01f, -1.23249255e-01f, -1.36241645e-01f,
  -2.73141582e-02f, -1.36073276e-01f, -7.09807500e-02f, -7.92127922e-02f, -4.93334271e-02f, -1.33341327e-01f, -2.11756244e-01f, 6.69470802e-02f, 8.62605348e-02f, 9.13843419e-03f,
  6.36251867e-02f, -5.70101619e-01f, -8.33884720e-03f, -1.51716843e-01f, -3.11887655e-02f, -1.24959663e-01f, 1.10927798e-01f, -5.08803904e-01f, -2.29749799e-01f, -4.54873085e-01f,
  -2.37684444e-01f, 2.58213252e-01f, 3.05628926e-01f, -4.48430508e-01f, 9.53466594e-01f, 1.93700016e-01f, -3.81410658e-01f, 1.46090938e-02f, 4.92914114e-03f, -3.28508586e-01f,
  -1.43448532e-01f, -4.63929296e-01f, 1.68437481e-01f, -3.60397547e-01f, -2.19859883e-01f, 6.48817688e-04f, 2.75680929e-01f, 2.38246530e-01f, -2.62932867e-01f, 2.00253621e-01f,
  -1.91472292e-01f, -5.36889553e-01f, 3.62291280e-03f, -9.31730568e-02f, -1.65788025e-01f, 4.94547933e-02f, 2.06568733e-01f, 4.00396943e-01f, 5.40819727e-02f, 2.32062805e-02f,
  2.14514852e-01f, -2.05431208e-02f, -1.36943892e-01f, 1.29913568e-01f, -7.60926530e-02f, -2.52216041e-01f, -5.05853444e-02f, -9.83856432e-03f, -9.00543109e-02f, 8.47290903e-02f,
  5.90943024e-02f, -5.29448539e-02f, -4.45190743e-02f, -3.11195739e-02f, 1.06227547e-02f, -4.52689379e-02f, 1.21669360e-01f, 2.59038776e-01f, -6.43176585e-02f, -1.01567313e-01f,
  -1.03522956e-01f, -5.64207546e-02f, -1.17927581e-01f, -1.23581350e-01f, -1.57118544e-01f, -1.47030428e-01f, -1.25070915e-01f, 5.90265989e-02f, 4.51742411e-02f, -3.35334279e-02f,
  -9.52719375e-02f, -1.05023801e-01f, -3.59676741e-02f, -1.00542389e-01f, 9.42756701e-03f, -8.52370486e-02f, 7.21268505e-02f, -7.45221833e-03f, 7.61370882e-02f, 4.72727679e-02f,
  -2.11242773e-02f, -2.41013523e-03f, -1.09349407e-01f, -6.99207745e-03f, -4.15734164e-02f, 2.34845102e-01f, -1.39367312e-01f, -3.19307707e-02f, -3.97963822e-02f, 2.06231967e-01f,
  -1.32534578e-01f, -4.75662708e-01f, -1.22600697e-01f, -7.13908672e-02f, 7.24614337e-02f, -8.78797919e-02f, -1.20443083e-01f, -1.30223036e-01f, -1.39053151e-01f, -1.43407211e-01f,
  -6.64498806e-02f, 1.82352276e-04f, -5.64698391e-02f, -4.30748910e-02f, 1.60683021e-01f, -9.89556238e-02f, 5.07774241e-02f, 3.80160660e-02f, 2.67708115e-02f, -8.60346183e-02f,
  -1.61287054e-01f, -8.32273066e-02f, 1.71454802e-01f, -1.16599284e-01f, -5.92856593e-02f, 6.09361455e-02f, -9.58082974e-02f, 2.16548610e-02f, 4.48386669e-02f, -3.59303579e-02f,
  9.08822715e-02f, -2.09115013e-01f, -2.36491561e-01f, -4.00748253e-01f, 2.62378067e-01f, 1.11176521e-01f, -7.29429498e-02f, 1.18125618e-01f, -3.87257189e-01f, 4.77905601e-01f,
  2.54541244e-02f, -3.42477292e-01f, -1.52272850e-01f, -5.76362193e-01f, -7.10003257e-01f, -5.38202643e-01f, -2.60274708e-01f, -1.28176719e-01f, -4.22458798e-01f, -3.45550627e-02f,
  -9.74459052e-02f, -2.26196274e-01f, -1.28364936e-01f, 3.80320579e-01f, 3.52664560e-01f, 4.64111507e-01f, 3.63669097e-01f, 2.33556882e-01f, 1.67340308e-01f, -2.43869007e-01f,
  -1.44900754e-01f, -2.61491299e-01f, 5.05541228e-02f, -1.08058728e-01f, 1.95210516e-01f, 3.25430840e-01f, 2.74926662e-01f, -9.60297808e-02f, -1.68455645e-01f, -1.96411103e-01f,
  -2.29024999e-02f, -8.90422687e-02f, -2.79310167e-01f, -4.94306646e-02f, 4.26241755e-02f, -9.45292041e-02f, -1.67528436e-01f, -6.44899011e-02f, -1.88188568e-01f, -3.80499996e-02f,
  -9.89808068e-02f, -6.67578131e-02f, 1.54308021e-01f, -1.28950700e-01f, -9.97508466e-02f, -8.94306004e-02f, 4.03056554e-02f, 9.55012739e-02f, 6.32208958e-02f, -6.56207576e-02f,
  4.95472811e-02f, 2.11071566e-01f, 9.20992792e-02f, 1.01965219e-02f, -7.76858479e-02f, 1.40670076e-01f, -9.62065533e-02f, -5.75174717e-03f, 3.63365039e-02f, 3.76286395e-02f,
  2.89706085e-02f, 3.16659845e-02f, -1.35637358e-01f, 1.40396073e-01f, 1.59407537e-02f, -8.78925323e-02f, 1.28110275e-01f, 4.13870625e-02f, -2.29731333e-02f, 1.65430158e-02f,
  -1.55374762e-02f, -3.79868560e-02f, 4.90656756e-02f, 6.72635883e-02f, -1.10905670e-01f, -9.09713970e-04f, 3.92971560e-03f, -6.01921305e-02f, 2.21065320e-02f, 2.97168009e-02f,
  1.06524108e-02f, 7.50697330e-02f, -9.23611298e-02f, -5.09218015e-02f, -5.94486669e-02f, 1.42171323e-01f, -8.62468705e-02f, -1.50717169e-01f, -1.66540042e-01f, -1.71602983e-02f,
  1.05190128e-01f, 2.18882158e-01f, 2.71845669e-01f, -1.19674481e-01f, -8.88772979e-02f, 5.82984053e-02f, 4.00413685e-02f, 7.78656453e-02f, 1.56641275e-01f, 1.03450790e-01f,
  1.71226710e-01f, 9.14798211e-03f, 2.02552998e-03f, 5.17085865e-02f, 2.93681454e-02f, -6.27201749e-03f, 1.18711866e-01f, 3.01070139e-02f, -6.29903227e-02f, -5.94362579e-02f,
  2.90443361e-01f, 5.35657465e-01f, 3.56891781e-01f, 4.11950648e-01f, -2.76984215e-01f, -6.16206527e-01f, -1.40891135e-01f, -1.37371374e-02f, 3.32112610e-02f, 2.82336503e-01f,
  -5.10644495e-01f, 9.54540730e-01f, -2.30183542e-01f, -3.99526544e-02f, -6.71494663e-01f, -5.01412034e-01f, -1.27480766e-02f, 2.00507805e-01f, -1.27437428e-01f, 3.34472150e-01f,
  -2.11701721e-01f, -3.32408935e-01f, -9.72040743e-02f, 5.81380799e-02f, 2.28259310e-01f, 4.89954323e-01f, -4.70800325e-02f, 3.46405432e-03f, 4.32889879e-01f, -1.94805562e-01f,
  -2.58859992e-01f, 1.10916167e-01f, 1.82274133e-01f, 2.97795217e-02f, -1.05519235e-01f, -4.36205491e-02f, 5.11082150e-02f, -6.03024215e-02f, -3.46642174e-02f, 9.41435695e-02f,
  3.99377942e-02f, 3.14093344e-02f, -1.23597868e-01f, 6.11523353e-02f, 4.33794037e-02f, 1.68631956e-01f, 1.70682535e-01f, 5.99360690e-02f, 2.27202818e-01f, 8.08759928e-02f,
  9.38809067e-02f, 5.51789664e-02f, 4.39343862e-02f, 6.05134256e-02f, -4.25858498e-02f, -1.06959179e-01f, -2.48911064e-02f, -4.38515805e-02f, 1.62551999e-01f, -1.07596749e-02f,
  -9.73096862e-02f, -2.63825599e-02f, 8.73301029e-02f, 7.71643594e-02f, 8.97866264e-02f, -3.13641205e-02f, 5.80779538e-02f, -1.13689870e-01f, 1.62325710e-01f, -4.38801153e-03f,
  -3.54383215e-02f, 5.45878001e-02f, -9.03375000e-02f, 1.33773997e-01f, -5.77536272e-03f, 1.50142070e-02f, 9.77532342e-02f, 9.82146263e-02f, -5.10089099e-02f, -4.25236970e-02f,
  -8.07348825e-03f, -3.01403310e-02f, 7.90228322e-02f, -4.70904671e-02f, -1.56190187e-01f, 5.63261695e-02f, -1.55586479e-02f, 2.01391369e-01f, -5.27095087e-02f, -1.08459383e-01f,
  6.35064114e-03f, 1.66259199e-01f, 7.24268109e-02f, 7.45868916e-03f, 7.12317303e-02f, -2.99460478e-02f, -8.99022967e-02f, 4.47398275e-02f, 4.02652398e-02f, -1.90991417e-01f,
  1.46154970e-01f, 8.58978108e-02f, 1.08606722e-02f, -4.70928624e-02f, -2.60910057e-02f, -7.84895420e-02f, -1.02424957e-02f, -8.99474788e-03f, 4.85266335e-02f, 4.12914008e-02f,
  9.50176418e-02f, 1.60449930e-02f, -1.01064518e-01f, -7.95938522e-02f, 1.91313736e-02f, -5.30273430e-02f, 2.00122222e-01f, 1.78979769e-01f, -3.91773917e-02f, 3.90985459e-02f,
  -9.94094849e-01f, 6.79814696e-01f, -1.01719975e-01f, -7.77345598e-01f, 2.31704682e-01f, -6.72065094e-02f, -2.91682154e-01f, 2.14464858e-01f, -2.26470605e-01f, 5.04009984e-02f,
  -2.91852385e-01f, -1.52174048e-02f, 3.29497129e-01f, -4.06573951e-01f, -4.87183750e-01f, 1.56900153e-01f, -5.38174927e-01f, -5.40268540e-01f, 3.96132559e-01f, -2.99682111e-01f,
  -2.87320048e-01f, -2.78589964e-01f, -1.08174495e-01f, 3.79795581e-01f, -2.13897720e-01f, 2.90269610e-02f, -2.28054360e-01f, 4.15678620e-01f, -1.36444300e-01f, 2.77669042e-01f,
  -3.39737862e-01f, -1.83582261e-01f, -1.72830656e-01f, -1.38851712e-02f, -2.18899220e-01f, -9.33245644e-02f, -1.74698934e-01f, 1.12866856e-01f, 3.64211202e-02f, 5.83244525e-02f,
  3.50301675e-02f, 3.27003859e-02f, -1.90205537e-02f, 8.49459320e-02f, -1.54909752e-02f, 6.13432713e-02f, 9.96779501e-02f, -1.86393082e-01f, 3.94735187e-02f, 4.52798493e-02f,
  5.23602106e-02f, -2.60339715e-02f, -1.96040452e-01f, -4.36578095e-02f, 1.49017237e-02f, 7.60045648e-02f, -6.53372630e-02f, -1.10002428e-01f, -8.42263699e-02f, -1.52833657e-02f,
  9.19777751e-02f, -1.47512734e-01f, -4.27052937e-02f, -2.84122266e-02f, 1.39840916e-01f, -1.32313743e-01f, 1.47737078e-02f, -5.76577932e-02f, 2.90660094e-02f, -1.20857889e-02f,
  -7.51103759e-02f, -1.02977380e-01f, 6.97189122e-02f, -1.01478480e-01f, -1.27839550e-01f, 1.74763147e-02f, -1.12610042e-01f, -1.20456010e-01f, -1.11527964e-01f, -5.28424978e-02f,
  -3.18708047e-02f, -1.77273396e-02f, 8.11421052e-02f, -7.59439766e-02f, -4.10658494e-03f, 9.97830257e-02f, -1.56489033e-02f, 9.01018735e-03f, -1.86527539e-02f, 5.52728446e-03f,
  -5.78701675e-01f, -2.96180844e-01f, 7.90565163e-02f, 1.36746168e-01f, -7.49883056e-02f, -8.39097053e-02f, -9.57691763e-03f, 5.27866594e-02f, 4.16586213e-02f, -8.62632785e-03f,
  -9.95694473e-02f, -6.95030689e-02f, -2.23288745e-01f, -2.70950645e-02f, -4.62405868e-02f, -1.47697747e-01f, -1.72214895e-01f, -2.25644615e-02f, -2.24641740e-01f, -4.92477268e-02f,
  -2.07749262e-01f, -9.32808220e-02f, -1.64786372e-02f, 1.00165494e-01f, -1.04835406e-01f, -7.24590197e-02f, -6.53770790e-02f, 2.61920840e-02f, 3.29815038e-02f, 1.76425893e-02f,
  4.08147603e-01f, -8.05156648e-01f, 2.03227833e-01f, 4.32068378e-01f, 4.97341305e-01f, 3.09627652e-01f, 5.51953495e-01f, -3.21672291e-01f, 1.46646038e-01f, -5.86997747e-01f,
  -1.85736611e-01f, -1.79497436e-01f, -3.93198341e-01f, -7.53635615e-02f, 5.97523153e-01f, -1.16286419e-01f, 1.57300308e-01f, -1.86659861e-02f, 6.52799755e-02f, 2.96327509e-02f,
  2.21228883e-01f, 2.50439718e-02f, 1.67932227e-01f, -3.80495697e-01f, -2.26566195e-03f, -1.38541698e-01f, -1.05202645e-01f, 1.80850923e-02f, -1.22173987e-01f, 1.78636089e-01f,
  5.72536699e-03f, -2.30611209e-02f, -5.78506701e-02f, -2.10018754e-01f, -7.59716779e-02f, 5.58023229e-02f, -7.31103402e-03f, 1.38249621e-01f, 2.52672970e-01f, -7.90402293e-02f,
  -8.46688449e-02f, 1.14201106e-01f, 5.81967756e-02f, 3.92605737e-03f, 6.20134808e-02f, 8.11467618e-02f, 1.00364983e-01f, -2.18788207e-01f, -8.44362453e-02f, 9.96626541e-02f,
  -6.02910332e-02f, -4.59176488e-02f, -8.81096348e-02f, -4.01376598e-02f, 8.80147815e-02f, 1.24400489e-01f, 1.80066749e-01f, 1.00960888e-01f, 7.48204738e-02f, 1.57990724e-01f,
  -7.66287372e-02f, -2.55630687e-02f, 5.84869608e-02f, -7.87102357e-02f, 6.16055802e-02f, 5.98406494e-02f, 6.13727830e-02f, -9.46234465e-02f, 5.25600389e-02f, -2.91147688e-03f,
  2.36222178e-01f, -5.58117442e-02f, 8.67175907e-02f, 4.22866307e-02f, -3.06881708e-03f, 1.60844587e-02f, 1.57033786e-01f, -3.70695032e-02f, -1.60589084e-01f, 8.84300023e-02f,
  8.31220672e-03f, 1.48152038e-01f, -1.16528429e-01f, 2.25460641e-02f, -9.06076878e-02f, 7.26980418e-02f, -1.44727603e-01f, 4.76463065e-02f, 2.80931443e-02f, -5.57944849e-02f,
  -4.59233105e-01f, -5.91865838e-01f, -1.44747987e-01f, -1.32939428e-01f, -1.14920288e-01f, -1.05235063e-01f, 1.55673742e-01f, -1.60391301e-01f, -7.86824375e-02f, -8.13042279e-03f,
  -1.28585905e-01f, 1.59464311e-02f, -6.07360192e-02f, 1.48902178e-01f, -1.68626219e-01f, -1.12752877e-01f, 6.77722320e-02f, -2.46148661e-01f, -1.21050656e-01f, -8.24822932e-02f,
  -8.33251998e-02f, 1.29956186e-01f, 1.03479410e-02f, -3.34386490e-02f, -4.67956904e-03f, -4.57856357e-02f, -4.87184115e-02f, -6.75803423e-03f, -1.11707160e-02f, -5.57144396e-02f,
  2.31800944e-01f, -5.19850910e-01f, 5.48105389e-02f, 3.19882661e-01f, 3.41083825e-01f, -7.30712116e-02f, -2.41711050e-01f, 1.15604378e-01f, 2.24542856e-01f, -4.55634922e-01f,
  -5.23380078e-02f, -3.71707886e-01f, -4.96677071e-01f, 1.54430255e-01f, 6.63527548e-02f, -1.69606313e-01f, 1.07079193e-01f, -1.30503982e-01f, 7.24754035e-02f, -4.56396565e-02f,
  1.96635410e-01f, 1.73846021e-01f, -9.56487283e-02f, 7.02258572e-02f, 1.76727608e-01f, -2.50687748e-02f, -7.89530799e-02f, -1.23581275e-01f, 9.95897800e-02f, 8.36476684e-03f,
  1.45200998e-01f, 1.32463813e-01f, -8.85120109e-02f, -7.39458427e-02f, 3.86329070e-02f, -6.61725849e-02f, -1.37407959e-01f, -1.15674615e-01f, 3.57955210e-02f, -4.54919087e-03f,
  -1.09176487e-01f, 1.11030437e-01f, 1.70790162e-02f, 8.96225199e-02f, -9.11405962e-03f, 1.26159295e-01f, 2.82363296e-02f, 2.55195261e-03f, 9.54410434e-02f, 5.47516719e-02f,
  4.95805815e-02f, 8.74095261e-02f, 8.11283439e-02f, -5.24129085e-02f, -7.34542385e-02f, 5.70385791e-02f, 1.25142246e-01f, -5.20592444e-02f, -1.54693844e-02f, 1.12501450e-01f,
  1.17115907e-01f, 9.98617113e-02f, 2.94547006e-02f, 1.17385641e-01f, -5.68263903e-02f, 1.32595986e-01f, -5.92764914e-02f, -3.85637656e-02f, -8.77330601e-02f, -3.63718607e-02f,
  9.37505662e-02f, 2.19881609e-02f, 6.43577948e-02f, 8.60908777e-02f, -5.08179180e-02f, 5.53373657e-02f, -1.83776692e-02f, 9.49514192e-03f, 3.56523022e-02f, 3.84068973e-02f,
  -6.32314160e-02f, 6.51629642e-02f, -7.53128007e-02f, 1.24297082e-01f, 3.61108296e-02f, -8.71374980e-02f, 6.44702241e-02f, 5.69806769e-02f, 6.95315525e-02f, -6.73449039e-02f,
  -8.14079642e-01f, -6.33278728e-01f, -2.05561683e-01f, 6.49203882e-02f, -1.25268519e-01f, -4.22311760e-02f, -2.69317962e-02f, 1.21200055e-01f, -2.61811644e-01f, 6.27008453e-02f,
  1.52335018e-02f, 3.92526239e-02f, -8.61251950e-02f, 1.40104279e-01f, -7.69179985e-02f, 4.87199202e-02f, -1.01438589e-01f, -1.93307981e-01f, -2.18338683e-01f, -9.10183117e-02f,
  -1.15433618e-01f, -3.10859308e-02f, 6.11984357e-02f, 2.08284676e-01f, 1.71640981e-02f, 3.28480192e-02f, 3.15540284e-02f, 3.72597948e-02f, 7.39732906e-02f, -6.11070469e-02f,
  2.79097557e-01f, -1.79308608e-01f, -2.44466826e-01f, -3.58839035e-01f, -2.38130555e-01f, -4.59539443e-01f, -4.97362345e-01f, -2.70326942e-01f, -4.84650210e-02f, -2.23483562e-01f,
  -4.48557198e-01f, -5.57483267e-03f, 1.44125089e-01f, -6.75397456e-01f, 4.93868560e-01f, 3.76866013e-01f, -6.56580091e-01f, -2.38251776e-01f, 2.28574593e-02f, -4.07396257e-01f,
  3.43326963e-02f, -5.79276860e-01f, -5.00198454e-04f, -2.45519608e-01f, -5.68765759e-01f, -2.99274772e-01f, 1.31365687e-01f, -3.42290252e-01f, -2.96851009e-01f, -1.70358390e-01f,
  -1.18829578e-01f, -3.64016667e-02f, -9.38276798e-02f, 1.36255935e-01f, -8.75775069e-02f, 5.41994832e-02f, -1.19829230e-01f, 8.34164023e-03f, 2.09040456e-02f, -2.50815209e-02f,
  -2.78667118e-02f, 2.66092449e-01f, -9.51682180e-02f, -4.90206406e-02f, -1.09561719e-01f, -1.12474831e-02f, 7.50419796e-02f, 7.44257402e-03f, 5.41844815e-02f, 1.05348721e-01f,
  -1.14833966e-01f, -1.78709291e-02f, -2.24009246e-01f, 1.09145947e-01f, -4.93252613e-02f, -1.28981024e-01f, 1.27727672e-01f, 3.30395103e-02f, 1.03406988e-01f, 8.41259360e-02f,
  -7.99412057e-02f, 1.44436032e-01f, 1.79247051e-01f, -4.07350771e-02f, 2.94014364e-02f, 1.69798061e-02f, -1.57627523e-01f, -2.84126420e-02f, -2.44131442e-02f, 4.12884541e-02f,
  -8.16916078e-02f, 3.88377649e-03f, 3.93193588e-02f, 1.29810562e-02f, 1.10843936e-02f, 1.39806401e-02f, -1.34732842e-01f, -8.08951184e-02f, -2.76060104e-01f, 3.75933051e-02f,
  8.92119184e-02f, 4.24558818e-02f, 1.11760207e-01f, -6.78298995e-02f, -1.04919985e-01f, 2.51521803e-02f, -1.06333025e-01f, 5.93051538e-02f, -1.27446175e-01f, -1.52778208e-01f,
  -2.00759158e-01f, -1.16634490e-02f, -4.49522473e-02f, 8.27373266e-02f, 1.95157528e-02f, 5.27033545e-02f, -7.68679827e-02f, -5.62902950e-02f, -1.44979075e-01f, 2.33013406e-02f,
  -5.36978357e-02f, 1.12950824e-01f, -7.61334002e-02f, -2.24435434e-01f, -1.58221751e-01f, -8.07060078e-02f, 9.13752150e-03f, 6.46886136e-03f, -1.93066239e-01f, -2.87606195e-02f,
  -1.99996382e-02f, -2.10818071e-02f, 1.56165138e-01f, -1.60830170e-01f, 2.75184568e-02f, -1.69676021e-01f, 8.10230209e-04f, 2.30133925e-02f, 8.79895166e-02f, 4.40359004e-02f,
  -1.96964368e-01f, -4.63565320e-01f, -5.29401064e-01f, -5.22199608e-02f, 1.38995320e-01f, 1.77556247e-01f, -5.17105579e-01f, 3.15583289e-01f, -3.10868382e-01f, -3.19821179e-01f,
  9.04187933e-02f, -2.36796588e-01f, -5.45187891e-01f, 7.42466077e-02f, 6.84410453e-01f, -5.68525076e-01f, 4.65910316e-01f, 3.44387174e-01f, 5.10115921e-02f, 2.36407816e-01f,
  4.21962917e-01f, 6.63686752e-01f, 4.66492563e-01f, 7.62061536e-01f, 3.95193994e-01f, 3.87398094e-01f, 5.74870944e-01f, 3.76222193e-01f, 6.77205622e-01f, 4.00517374e-01f,
  -1.03953026e-01f, -2.69362688e-01f, 1.60492826e-02f, 1.67882964e-02f, 2.40609068e-02f, -3.23101617e-02f, 7.14244023e-02f, 1.91930443e-01f, 2.65207663e-02f, -5.40308952e-02f,
  -7.11324364e-02f, 2.27078184e-01f, 1.16664795e-02f, 1.50716484e-01f, -5.17580891e-03f, 9.54544693e-02f, 1.40469940e-02f, 3.52733321e-02f, 8.24678913e-02f, -1.66399434e-01f,
  -1.26142591e-01f, 3.51258530e-03f, -2.98464075e-02f, -3.02761397e-03f, -1.04826503e-01f, 7.55105764e-02f, -7.26501346e-02f, 3.46649252e-02f, -1.34736538e-01f, 8.81889078e-04f,
  4.26129028e-02f, -1.08474456e-01f, -1.24556515e-02f, -1.73664600e-01f, -1.37324445e-02f, -7.71402121e-02f, 6.27669245e-02f, 4.21490194e-03f, 1.18976116e-01f, 5.36445081e-02f,
  2.83025913e-02f, -2.58809235e-02f, -8.69039744e-02f, 2.27765795e-02f, 1.29791930e-01f, 7.62593076e-02f, 1.14691176e-01f, 1.49937436e-01f, -6.03049956e-02f, -3.31048332e-02f,
  -1.05575316e-01f, 2.28351772e-01f, -9.47035179e-02f, 1.23335451e-01f, -6.78805485e-02f, -1.25362009e-01f, 4.65877987e-02f, -1.07245252e-01f, -2.43286923e-01f, 1.19418070e-01f,
  1.04452064e-03f, 1.24436051e-01f, -3.85415331e-02f, 1.91164389e-02f, -6.08901791e-02f, 7.69609809e-02f, 1.06836304e-01f, 1.27885863e-01f, 2.19554737e-01f, -3.91147006e-03f,
  2.15762630e-01f, 1.80199698e-01f, -1.17187381e-01f, -3.99164185e-02f, 3.20230603e-01f, 2.09074910e-03f, -3.40627879e-02f, 1.57375395e-01f, 2.37658918e-01f, 1.47494227e-02f,
  6.19162470e-02f, 3.88507210e-02f, 3.89157608e-02f, 1.78702548e-02f, -1.11097852e-02f, -2.82186806e-01f, 1.04187787e-01f, -4.56851348e-02f, 1.24307342e-01f, 1.42328233e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.51151180e-01f, 9.23452973e-01f, 8.69729295e-02f, 5.64465463e-01f, 3.87181818e-01f, 6.46907806e-01f, 9.37219784e-02f, 4.59116697e-01f, 6.64200127e-01f, 4.23935115e-01f,
  5.87582767e-01f, 3.52953523e-01f, -4.73908186e-02f, 7.97640800e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.75937819e-01f, -4.93388832e-01f, -4.18576986e-01f, 4.93469136e-03f, -2.13612050e-01f, 1.57821074e-01f, -3.52205127e-01f, -1.96434990e-01f, 2.15601757e-01f, -6.94421306e-02f,
  3.35697502e-01f, -3.08950484e-01f, 4.21370238e-01f, 1.28298208e-01f, -2.46134013e-01f, 1.40089124e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -4.26147103e-01f, -1.11097729e+00f, -1.70238599e-01f, 1.99494436e-01f, 6.79814637e-01f, -3.29657905e-02f, 3.18150431e-01f, 1.09809244e+00f, -2.12686017e-01f, -4.94175479e-02f,
  4.38177794e-01f, 5.96188247e-01f, -8.82957801e-02f, 3.01055849e-01f, 2.96569973e-01f, -2.26130188e-01f, 9.80913192e-02f, 1.49879888e-01f, 4.88044739e-01f, 9.82832730e-01f,
  6.18224323e-01f, 3.81558716e-01f, 8.05172861e-01f, 6.38667941e-01f, -8.24481189e-01f, -6.59661055e-01f, 1.85249820e-01f, 2.50384659e-01f, -4.59666073e-01f, -6.13429606e-01f,
  -1.92169636e-01f, 1.65150240e-01f, 6.58716410e-02f, -7.44255841e-01f, -2.13892341e-01f, 4.71935987e-01f, 2.90985256e-01f, 7.04570949e-01f, 6.89328372e-01f, 6.06367469e-01f,
  -1.02842666e-01f, -4.14440215e-01f, 6.97695017e-01f, 9.09829795e-01f, -4.53257382e-01f, -3.12601417e-01f, 5.97172439e-01f, -8.94109160e-02f, 5.17165810e-02f, 3.92745920e-02f,
  4.16903913e-01f, 3.17435339e-02f, 5.15915036e-01f, -7.41369545e-01f, 1.23285331e-01f, 6.86711848e-01f, 3.78290892e-01f, 3.68368775e-01f, -1.95060208e-01f, 1.00790739e+00f,
  -4.28647578e-01f, -5.13372235e-02f, 6.41202986e-01f, 9.08776559e-03f, 5.88483512e-01f, -5.02847135e-01f, 1.02093697e-01f, -7.43691802e-01f, 5.34746110e-01f, 5.30660972e-02f,
  6.24880373e-01f, -5.08755386e-01f, -7.15407133e-02f, -5.23998916e-01f, 1.91926211e-01f, 1.13757801e+00f, 1.54309675e-01f, 7.27275312e-01f, 4.26116318e-01f, 5.34454942e-01f,
  3.37554902e-01f, 6.28917813e-01f, 2.54454501e-02f, 1.08248198e+00f, -2.48308182e-01f, 2.26976573e-01f, -7.04626217e-02f, 8.95420551e-01f, 1.72321782e-01f, 4.49082434e-01f,
  -5.24788857e-01f, -1.44122243e-01f, 2.05314532e-01f, -2.12611377e-01f, 3.02218404e-02f, 6.74894810e-01f, 7.99620509e-01f, -8.62036586e-01f, -3.45263422e-01f, -2.25188032e-01f,
  -4.15554196e-01f, 2.06667930e-01f, -4.03788090e-01f, 6.64611638e-01f, 4.59859580e-01f, 7.62170017e-01f, -8.87158096e-01f, 4.51695323e-01f, 1.03186560e+00f, 6.77582443e-01f,
  -2.97159880e-01f, 6.31348431e-01f, 5.34477472e-01f, 4.83913779e-01f, -6.17304862e-01f, 3.39402765e-01f, 8.23792696e-01f, 1.24433033e-01f, 5.98653197e-01f, -1.06223412e-01f,
  -7.76325226e-01f, 6.64878130e-01f, 1.27235472e+00f, 4.20020878e-01f, -8.36351812e-02f, -3.79623979e-01f, -3.51613790e-01f, -8.81737545e-02f, 1.42001554e-01f, 1.25327900e-01f,
  -1.04437105e-01f, 9.93168354e-01f, 5.00593185e-01f, 1.84704810e-01f, 6.11119568e-01f, 4.75186199e-01f, 1.12791777e+00f, -8.58749568e-01f, -2.01415569e-01f, -3.74212503e-01f,
  6.87833846e-01f, -1.14580549e-01f, 5.71272552e-01f, 6.38011694e-01f, 4.46968794e-01f, 1.12376451e+00f, 5.78463733e-01f, 1.52932450e-01f, -6.25846744e-01f, -5.30908465e-01f,
  5.72639048e-01f, 3.91673595e-01f, -2.83057123e-01f, 4.06439155e-01f, 1.63120776e-01f, 2.42851257e-01f, -2.53850520e-01f, -6.09618332e-03f, 2.33952031e-01f, 1.07280171e+00f,
  3.22229832e-01f, 7.58328319e-01f, 8.08391094e-01f, 2.69016474e-01f, 3.88350606e-01f, -7.92199075e-01f, 6.21520817e-01f, -5.59441030e-01f, -2.77669393e-02f, 3.99656892e-01f,
  1.68689400e-01f, 5.05056083e-01f, -6.60407066e-01f, 5.65300621e-02f, -1.15357161e-01f, 5.32704294e-01f, 7.75297126e-03f, -7.93507218e-01f, -2.24994160e-02f, -5.96639931e-01f,
  1.46747176e-02f, 1.10554707e+00f, 3.62425923e-01f, 3.27967644e-01f, -5.98289430e-01f, 3.14771712e-01f, 5.21894038e-01f, 4.75120306e-01f, 6.24418437e-01f, 1.00733566e+00f,
  -4.36461061e-01f, 6.74706578e-01f, 8.86322200e-01f, 7.63095498e-01f, -2.45078221e-01f, 4.38579768e-01f, -6.38879657e-01f, 1.15296376e+00f, -3.59480470e-01f, -3.16449031e-02f,
  -6.40954077e-01f, 4.06845659e-01f, 7.27062047e-01f, 7.87841529e-02f, 2.22829580e-01f, 8.69785845e-02f, 3.44418943e-01f, 1.75864264e-01f, -4.37741488e-01f, 6.25646591e-01f,
  7.05703139e-01f, 7.77269721e-01f, 5.96687317e-01f, -5.90809643e-01f, -3.21637928e-01f, 7.77883053e-01f, 8.47685993e-01f, -2.11446747e-01f, -4.67406884e-02f, -3.59548002e-01f,
  1.61924168e-01f, -1.22172713e-01f, 8.92275333e-01f, 2.73788005e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  7.70749032e-01f, 4.98563468e-01f, 4.31379974e-02f, 7.89539337e-01f, 5.74096918e-01f, 7.81506777e-01f, 9.27467883e-01f, 1.60160884e-01f, 4.18660074e-01f, -1.75837815e-01f,
  5.46605945e-01f, 3.27431411e-01f, 4.70652670e-01f, 2.28588924e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -5.06569259e-03f, -4.81222630e-01f, 1.75156549e-01f, 5.40819049e-01f, -1.58037245e-01f, 4.80993651e-02f, -7.89258540e-01f, 1.54094845e-01f, -1.18108201e+00f, 5.07622540e-01f,
  3.80344063e-01f, -9.52792466e-01f, -1.04371430e-02f, -1.10752797e+00f, -1.29436278e+00f, 5.52846313e-01f, -3.79136264e-01f, -4.82636958e-01f, -1.40714121e+00f, 6.49161562e-02f,
  -7.62860119e-01f, 9.70863029e-02f, -3.12933147e-01f, 4.35723931e-01f, -7.78257728e-01f, -4.89397317e-01f, -1.54635489e-01f, 6.17187679e-01f, 3.42964500e-01f, -1.21475828e+00f,
  3.87057126e-01f, 6.71241283e-01f, 4.59800400e-02f, 4.26610231e-01f, -1.11149836e+00f, -6.55719459e-01f, -8.35223556e-01f, -5.25836051e-01f, 4.14948791e-01f, -3.89814959e-03f,
  8.35254490e-02f, -7.65334666e-01f, 4.89537083e-02f, 5.33038795e-01f, 2.31124118e-01f, 4.48520064e-01f, -8.10108840e-01f, 1.08444327e-02f, 2.30745539e-01f, -1.09374039e-02f,
  3.35609406e-01f, -2.13177085e-01f, 3.20674688e-01f, 4.58688438e-01f, 6.59551203e-01f, -1.22810924e+00f, -2.48256832e-01f, 4.93134826e-01f, -1.25082910e+00f, -3.41556489e-01f,
  2.81968892e-01f, -3.10657322e-01f, -3.96680772e-01f, -8.86607766e-01f, 1.71446830e-01f, -7.71359682e-01f, 6.61754072e-01f, 1.17560197e-03f, 2.59144157e-01f, 4.60632473e-01f,
  -9.06386152e-02f, 2.43757054e-01f, 3.04577589e-01f, -5.71140587e-01f, -5.57568967e-01f, 3.24242711e-02f, -7.95224488e-01f, 4.90307249e-02f, -3.66770387e-01f, -9.18393210e-02f,
  1.57532573e-01f, 3.31753582e-01f, -3.21343571e-01f, 2.79721051e-01f, 5.59969723e-01f, -9.50036705e-01f, -8.40414762e-01f, 4.88929391e-01f, -3.80848646e-01f, 1.56728834e-01f,
  3.78941804e-01f, -5.59035838e-01f, -1.16120052e+00f, -4.18378204e-01f, 6.15869045e-01f, -2.38602072e-01f, 1.91469431e-01f, 7.28631496e-01f, -2.03132648e-02f, -5.54218352e-01f,
  -3.47617924e-01f, -6.90847456e-01f, 3.91499043e-01f, -7.33668506e-02f, 8.15401912e-01f, -1.10435152e+00f, -2.55152613e-01f, -1.01804376e+00f, -6.41374886e-01f, 7.68732309e-01f,
  5.05288184e-01f, -1.01123941e+00f, -4.98533428e-01f, -2.39382252e-01f, 9.61687192e-02f, -8.77748668e-01f, 4.34444547e-01f, 4.48223710e-01f, 4.78408813e-01f, -7.87399471e-01f,
  -6.97804749e-01f, -7.81123102e-01f, 4.75999057e-01f, -3.72836709e-01f, -4.29778397e-01f, -8.85119975e-01f, -3.64384532e-01f, 3.46136779e-01f, -5.36271691e-01f, -2.90446907e-01f,
  -5.79656482e-01f, 6.38495266e-01f, -1.40551738e-02f, -6.11280918e-01f, 2.77552158e-01f, -4.81058538e-01f, -8.62322628e-01f, 1.02495342e-01f, 3.77539098e-02f, 3.96036357e-01f,
  2.87130833e-01f, 2.56821156e-01f, -3.34811866e-01f, -6.47772193e-01f, -2.65890330e-01f, 6.45522356e-01f, 8.83411542e-02f, -1.04323590e+00f, -3.83291572e-01f, -2.47871369e-01f,
  -6.03228569e-01f, 3.91766071e-01f, 4.62667108e-01f, -8.18579316e-01f, 6.78830981e-01f, -9.13485527e-01f, -7.81343579e-01f, -5.61796844e-01f, -9.10580635e-01f, 5.83150804e-01f,
  3.26212347e-01f, -4.28849459e-01f, -6.75281107e-01f, -8.02957237e-01f, -1.00505304e+00f, 1.54881790e-01f, -5.68712711e-01f, 4.11770999e-01f, 3.09712887e-01f, 8.90456736e-01f,
  -8.58065128e-01f, 3.55243176e-01f, 4.44518000e-01f, -4.12360132e-01f, 5.03408730e-01f, -9.80273962e-01f, -1.21509656e-01f, 4.56200778e-01f, 3.39487374e-01f, -3.93695116e-01f,
  3.49717528e-01f, -8.97581697e-01f, -2.70389259e-01f, -1.09930265e+00f, -7.70300865e-01f, 6.55208290e-01f, -8.58741581e-01f, -7.35636771e-01f, -9.42893505e-01f, 6.36236489e-01f,
  6.26810431e-01f, -6.27919078e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.67655042e-02f, 2.86380015e-02f, -1.80330172e-01f, 3.02160472e-01f, -9.68826115e-02f, 2.59297311e-01f, 4.47418600e-01f, 8.91398638e-03f, -1.95440024e-01f, 9.57419723e-02f,
  -1.12510994e-01f, -6.28817081e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    