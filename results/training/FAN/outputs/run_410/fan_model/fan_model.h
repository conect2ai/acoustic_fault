/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.64978400e-01f, 2.21349224e-01f, -8.36204514e-02f, -1.09802932e-02f, 4.09125328e-01f, -4.97371368e-02f, -2.97064871e-01f, 1.68211371e-01f, 8.43116269e-02f, -9.16102305e-02f,
  9.50800031e-02f, 1.10633329e-01f, -2.41457209e-01f, 1.41958222e-01f, -4.09464896e-01f, -3.67403358e-01f, 2.97021903e-02f, 1.98775139e-02f, 1.22421324e-01f, 1.55013993e-01f,
  1.04443364e-01f, 1.95583269e-01f, -2.75256395e-01f, 1.43668115e-01f, 5.58070540e-02f, 1.32297873e-01f, -1.77417755e-01f, 7.66038820e-02f, 9.83506907e-03f, 4.50014286e-02f,
  -7.83533752e-02f, 2.90821418e-02f, -1.04225185e-02f, -9.20630470e-02f, -1.98286958e-02f, 7.32132792e-03f, -4.70800400e-02f, -7.97422230e-02f, -6.21616058e-02f, -1.07917383e-01f,
  -1.02285981e-01f, -1.11634150e-01f, 6.12110086e-03f, 3.81393544e-02f, 6.94504678e-02f, -3.61973904e-02f, -2.30179299e-02f, 2.99732555e-02f, 9.99838337e-02f, 3.25964466e-02f,
  -2.97283866e-02f, -6.67463243e-02f, -3.19625810e-02f, -8.03038701e-02f, -3.77980694e-02f, 3.37267034e-02f, -1.42960725e-02f, 4.28287946e-02f, -8.55612233e-02f, 7.94930011e-02f,
  9.45708994e-03f, 1.08048730e-01f, -1.90853551e-02f, -4.50217947e-02f, 4.39715721e-02f, 5.53745739e-02f, -1.00355819e-01f, -2.18233350e-03f, -9.42685753e-02f, 3.96573581e-02f,
  -4.26570419e-03f, 3.10521275e-02f, -2.83784233e-02f, -6.16303906e-02f, -4.79042493e-02f, 6.08980916e-02f, 3.29509052e-03f, -4.06441763e-02f, 5.20567372e-02f, -8.32710564e-02f,
  -3.43241692e-02f, 9.46005508e-02f, -8.19643512e-02f, 6.92671388e-02f, 1.01649417e-02f, -2.46222727e-02f, 8.06712434e-02f, 9.49661899e-03f, 7.41300806e-02f, 5.07346317e-02f,
  -1.15495706e-02f, 9.65741873e-02f, -2.41502654e-02f, 2.03996338e-02f, -3.30501385e-02f, -1.17959723e-01f, 5.89615777e-02f, 3.70160192e-02f, -4.17800173e-02f, 2.03547552e-02f,
  5.25212996e-02f, 2.96365637e-02f, 2.72730850e-02f, -4.77634137e-03f, -6.84469938e-02f, -9.06489640e-02f, -2.74590068e-02f, -3.30663659e-02f, 1.62665527e-02f, -1.82842445e-02f,
  2.52158325e-02f, 1.02019380e-03f, 1.62595194e-02f, 1.10685199e-01f, 3.69936600e-02f, 5.38671426e-02f, 8.26945305e-02f, -2.17516976e-03f, -2.73664575e-02f, -6.13299571e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.07829547e-01f, 4.81009364e-01f, 2.07234189e-01f, -4.95795071e-01f, 2.61460751e-01f, 2.19078556e-01f, -1.26841918e-01f, 2.20530167e-01f, -1.41942441e-01f, 2.65622735e-01f,
  -3.63108888e-02f, -6.82122111e-02f, 1.33514568e-01f, -2.12685257e-01f, -7.11771548e-01f, -3.47705185e-01f, -3.62617850e-01f, -1.74793646e-01f, 8.48873556e-02f, 1.26171187e-02f,
  -2.38140956e-01f, -1.59367412e-01f, -1.01835206e-01f, 4.64509934e-01f, 2.17407852e-01f, 3.25657070e-01f, -2.69662708e-01f, 4.84201074e-01f, 3.41145210e-02f, -5.91535494e-02f,
  -6.21913075e-02f, 1.29432440e-01f, 1.64959073e-01f, 1.39181495e-01f, 9.77818221e-02f, 9.65334103e-02f, -1.51892137e-02f, -4.47821096e-02f, 3.75511460e-02f, 5.92194125e-02f,
  6.39371797e-02f, 6.43538162e-02f, -7.21997693e-02f, 5.21721579e-02f, 2.12858021e-01f, 1.00556351e-01f, 9.76672322e-02f, -1.47228837e-02f, 1.76356524e-01f, 4.48589996e-02f,
  5.10346144e-02f, 3.86595055e-02f, 7.52549386e-03f, -7.52241835e-02f, -9.25837532e-02f, 5.29754758e-02f, -1.26356587e-01f, -1.32594751e-02f, 1.53605133e-01f, 3.19771841e-02f,
  -2.66070571e-02f, -1.63715892e-02f, -6.16883226e-02f, 3.74476984e-03f, -2.29920242e-02f, 1.26124080e-02f, 8.17413069e-03f, -9.78961959e-02f, 1.00802764e-01f, -7.75510119e-03f,
  -9.07671601e-02f, -4.49340120e-02f, 4.22570556e-02f, -1.49699813e-02f, -1.79734849e-03f, -6.70979777e-03f, -1.11095592e-01f, 1.02793258e-02f, -1.36188388e-01f, -1.34094218e-02f,
  -4.50612865e-02f, -1.87323034e-01f, 7.71603510e-02f, 5.22983959e-03f, -3.43469419e-02f, 5.62376790e-02f, 6.94450513e-02f, 7.62866810e-02f, 5.08312183e-03f, -4.91919219e-02f,
  -1.31068513e-01f, -6.53732046e-02f, 5.25868572e-02f, 3.69066000e-02f, 1.06360307e-02f, -2.75788233e-02f, -1.26221836e-01f, 5.94333783e-02f, 7.43069313e-03f, -2.65979692e-02f,
  7.96836168e-02f, 3.52936015e-02f, -1.00091696e-02f, -8.13080072e-02f, 1.00378599e-02f, -2.18196791e-02f, -1.36103019e-01f, -3.45066041e-02f, 3.84267680e-02f, -5.73962927e-02f,
  7.12339953e-02f, 5.65363355e-02f, -4.49226834e-02f, 1.50357127e-01f, -7.23064970e-03f, -3.40653025e-02f, -3.67188603e-02f, 2.60905512e-02f, 5.73072471e-02f, 2.51413528e-02f,
  -2.57166892e-01f, -3.35487813e-01f, -4.24402744e-01f, -4.41277057e-01f, -3.28516155e-01f, -1.24884639e-02f, -6.26284629e-02f, -2.08248183e-01f, -7.86951408e-02f, 3.88390541e-01f,
  3.81855875e-01f, -3.86212111e-01f, 3.07302594e-01f, -1.25482336e-01f, -2.60089844e-01f, 1.54846653e-01f, -2.16586590e-02f, -4.72394079e-02f, -3.87869962e-02f, -3.87683585e-02f,
  -2.69976705e-01f, -8.63114819e-02f, -1.18728802e-01f, 4.59133238e-02f, -3.58972818e-01f, -7.37987980e-02f, 1.89305559e-01f, -2.01444272e-02f, -5.38007319e-02f, 2.28525363e-02f,
  5.60194179e-02f, 1.00522563e-01f, 7.58941397e-02f, -2.36047860e-02f, 1.49119705e-01f, 1.18406169e-01f, 7.30177155e-03f, 3.36900540e-02f, -1.02792956e-01f, 5.86107187e-03f,
  2.64311060e-02f, -1.65702388e-01f, 5.41153289e-02f, -1.54127479e-01f, -1.23289026e-01f, -5.19573800e-02f, -1.10437162e-01f, -4.50483188e-02f, 1.08357921e-01f, -3.32267471e-02f,
  5.13280183e-02f, -6.79020137e-02f, -1.60745636e-01f, 3.60565037e-02f, -1.21067092e-01f, 4.47591506e-02f, 1.00247217e-02f, -8.02089926e-03f, 1.05447397e-01f, -6.21661805e-02f,
  1.84824079e-01f, 7.40939677e-02f, 7.36972839e-02f, 1.03658952e-01f, -1.64994389e-01f, 2.66272783e-01f, 4.44669612e-02f, 6.94163665e-02f, -7.73644820e-02f, 8.58424138e-03f,
  -8.92215297e-02f, -1.10518217e-01f, 6.66708946e-02f, 3.60169299e-02f, -3.51087116e-02f, 1.83246225e-01f, 5.67436554e-02f, 3.38912047e-02f, -1.10773563e-01f, 9.41601470e-02f,
  9.60924923e-02f, 7.19748214e-02f, 4.11892608e-02f, 1.72238946e-01f, 7.65324682e-02f, -4.26782817e-02f, -5.52524403e-02f, -4.37771529e-02f, 8.48800987e-02f, -1.32165968e-01f,
  1.56495422e-02f, 5.83616011e-02f, 9.90350246e-02f, -1.33117782e-02f, 1.34921014e-01f, 1.18324198e-02f, -1.45549849e-02f, 1.90460198e-02f, -8.18642601e-02f, 8.19875896e-02f,
  -2.13028174e-02f, 9.99525934e-03f, -6.18800521e-02f, -1.05072232e-02f, -1.37283623e-01f, 7.52662271e-02f, 1.06689364e-01f, -3.97593789e-02f, 1.76343564e-02f, 2.51732264e-02f,
  7.74788577e-03f, 1.15376815e-01f, -1.11578733e-01f, -2.81889141e-02f, 1.94548909e-02f, 1.35888755e-01f, -2.38824748e-02f, 2.29924787e-02f, -7.61296377e-02f, -1.52636185e-01f,
  1.87390849e-01f, 1.25254199e-01f, 2.16181189e-01f, 4.39197600e-01f, -9.78659466e-02f, -3.83622289e-01f, -2.89991766e-01f, 2.63007373e-01f, -6.47687614e-02f, -2.24120170e-01f,
  -3.39015201e-02f, -5.17588332e-02f, -4.91250724e-01f, 3.27055871e-01f, -1.60070553e-01f, -4.67124403e-01f, 3.03827584e-01f, 5.25845401e-02f, -8.35939869e-02f, 1.98739320e-01f,
  1.03135452e-01f, 1.59983337e-01f, 4.31150526e-01f, 2.01197863e-01f, 1.55768156e-01f, 4.85342532e-01f, 3.15598339e-01f, 8.56249556e-02f, 5.17284811e-01f, 3.36247236e-02f,
  -1.60096198e-01f, -1.91624567e-01f, 1.12142026e-01f, -4.67530377e-02f, 8.79666656e-02f, 8.86580162e-03f, 3.54147740e-02f, -1.06744252e-01f, 1.54848229e-02f, 1.05770715e-01f,
  -1.04361996e-01f, 2.66326126e-02f, 2.57908851e-01f, -9.09780562e-02f, -4.47224714e-02f, 8.93081278e-02f, -6.07881434e-02f, 9.30485725e-02f, -2.14876719e-02f, -2.43491819e-03f,
  -4.94771041e-02f, 1.02517447e-02f, -1.56330112e-02f, 4.76487875e-02f, -5.17443828e-02f, 1.84286963e-02f, 2.19955415e-01f, 4.03986871e-03f, 7.73056969e-02f, 1.24648064e-02f,
  5.43800415e-03f, -1.37012303e-01f, -3.75750959e-02f, 4.12885435e-02f, 4.42024507e-02f, -1.16359014e-02f, -3.69178019e-02f, -6.62585646e-02f, -7.23997205e-02f, -9.44311321e-02f,
  8.77071321e-02f, -8.16961471e-03f, 6.86903074e-02f, 3.85761037e-02f, -7.28711784e-02f, -1.01809122e-01f, 1.09521434e-01f, -1.32624153e-02f, 1.40851717e-02f, 1.30472422e-01f,
  -1.57720730e-01f, -2.70443801e-02f, 7.07371458e-02f, -3.09034232e-02f, 3.63405570e-02f, -4.91240341e-03f, -1.60193533e-01f, -3.02390121e-02f, -4.84473025e-03f, -5.29062282e-03f,
  -2.28327274e-01f, 2.03663900e-01f, 1.41674094e-02f, -1.08551845e-01f, 6.74840584e-02f, 3.31258141e-02f, -1.03367344e-01f, 1.75289325e-02f, 1.18853442e-01f, -9.27832425e-02f,
  -3.37413214e-02f, 1.47495002e-01f, -3.76406498e-02f, 7.35095814e-02f, 5.88355809e-02f, -1.16388556e-02f, -1.40566140e-01f, 3.32883634e-02f, -4.44067977e-02f, 2.48730078e-01f,
  5.95438443e-02f, -3.89456861e-02f, 6.65228143e-02f, -5.46735823e-02f, 7.88733959e-02f, -1.13638736e-01f, 1.15793310e-01f, 2.74063200e-02f, -3.39325890e-02f, -8.74730349e-02f,
  1.22672021e-01f, -1.58514649e-01f, -5.29857039e-01f, -7.73677975e-02f, 2.17077553e-01f, 4.31627363e-01f, 2.14691795e-02f, 7.12241903e-02f, -6.00445569e-01f, 1.47643805e-01f,
  2.39380181e-01f, -3.33495229e-01f, -3.15235853e-01f, -1.32261738e-01f, -7.60735525e-03f, -4.01342392e-01f, 3.28651309e-01f, 1.90684628e-02f, -2.67968893e-01f, 4.32006180e-01f,
  9.91125554e-02f, 5.80892205e-01f, -2.70537496e-01f, 3.67098927e-01f, 2.90938735e-01f, 1.27350077e-01f, 5.45192599e-01f, 7.02060238e-02f, 4.39309537e-01f, 6.52625263e-02f,
  3.30254901e-03f, -4.02207598e-02f, -3.71388085e-02f, -1.52185246e-01f, 2.60791928e-01f, 2.65378416e-01f, 1.66134819e-01f, -1.71466935e-02f, -1.64957911e-01f, -5.88379167e-02f,
  4.30346020e-02f, -4.25287373e-02f, -1.35662511e-01f, -6.86858818e-02f, 6.49026707e-02f, -1.90208510e-01f, -1.09937884e-01f, -1.97072491e-01f, -1.87378138e-01f, -5.48172183e-02f,
  -6.03012703e-02f, -1.00104861e-01f, -6.61261566e-03f, -4.08390630e-03f, -7.72155225e-02f, 9.95451235e-04f, -2.02258881e-02f, 1.29343107e-01f, -1.04084149e-01f, 3.35833021e-02f,
  1.82694748e-01f, 9.03989822e-02f, 1.13774678e-02f, -1.92428410e-01f, -5.81727028e-02f, 2.33673141e-03f, 4.83325459e-02f, -6.88265860e-02f, -1.51111037e-01f, -1.71659943e-02f,
  5.44874221e-02f, 1.91372577e-02f, 3.32016796e-02f, 4.53770347e-02f, 2.27320150e-01f, -2.54553705e-02f, -6.42250702e-02f, 9.02293026e-02f, -6.07810654e-02f, -1.33433431e-01f,
  -2.04094663e-01f, 4.07259390e-02f, 4.97120023e-02f, -1.15051437e-02f, -1.64636821e-01f, 4.07972652e-03f, 1.12808019e-01f, -1.80501100e-02f, -1.07332155e-01f, 1.18745297e-01f,
  2.79886574e-01f, 3.02819133e-01f, -8.18908960e-02f, -1.04767412e-01f, -8.87495056e-02f, 1.42165005e-01f, -8.37289616e-02f, 4.86483835e-02f, 7.19139576e-02f, -6.46021217e-03f,
  2.71567345e-01f, 1.27889300e-02f, 1.01843499e-01f, -9.01973166e-04f, -1.69047013e-01f, 3.12267244e-01f, 7.93876722e-02f, -2.76568104e-02f, 1.52344197e-01f, 1.90835908e-01f,
  9.54512805e-02f, 1.68247983e-01f, 2.62180134e-03f, 3.49898003e-02f, 1.11824580e-01f, 2.37111747e-01f, 6.72526136e-02f, 1.20767690e-01f, 1.40882552e-01f, -8.55158195e-02f,
  -1.71160877e-01f, 4.58078496e-02f, 8.27815235e-02f, 5.68503179e-02f, 2.02240050e-02f, -7.20459223e-01f, -5.90587616e-01f, 1.61337882e-01f, -3.52675691e-02f, -8.78867880e-02f,
  -2.10360169e-01f, 2.75569141e-01f, 9.89955664e-02f, -1.70062985e-02f, -2.08857618e-02f, 7.95944929e-02f, -6.24752156e-02f, -6.88133016e-02f, 1.57288313e-01f, 2.38748327e-01f,
  1.24200158e-01f, -9.79455709e-02f, 3.00452739e-01f, -4.26401794e-02f, -5.63664958e-02f, 3.95699978e-01f, 4.86923963e-01f, -8.82020071e-02f, -1.57649312e-02f, 2.38378923e-02f,
  4.93211066e-03f, 3.06927711e-01f, 7.25729093e-02f, -1.18893370e-01f, 4.00226526e-02f, 2.65842341e-02f, -1.12838253e-01f, 9.36052725e-02f, 1.68031946e-01f, 2.05353320e-01f,
  -6.97989599e-04f, 1.12955347e-01f, -4.83048595e-02f, 9.68893617e-02f, -1.13229724e-02f, 2.62948684e-02f, 1.40563458e-01f, 7.25889727e-02f, 1.77565441e-01f, 6.68543056e-02f,
  2.64006890e-02f, 1.43692449e-01f, 7.56993294e-02f, -4.56695408e-02f, 9.13185701e-02f, -1.39354900e-01f, -4.91373390e-02f, 4.98433784e-02f, 1.19954579e-01f, 4.85135056e-02f,
  -2.07418110e-02f, -9.75037366e-02f, -6.15682229e-02f, -2.52983030e-02f, 5.98818734e-02f, 6.07305346e-03f, -1.07140131e-01f, -2.29117218e-02f, -2.53684931e-02f, -6.04093783e-02f,
  -5.20003513e-02f, 7.63624813e-03f, 1.22090103e-03f, -3.71165238e-02f, -3.67512815e-02f, 2.93426379e-03f, 3.57848778e-02f, 1.04213446e-01f, -6.50373846e-02f, 2.21409984e-02f,
  2.84782380e-01f, -8.15648213e-02f, -8.32004845e-02f, 3.07387114e-02f, -8.05014968e-02f, 3.72399278e-02f, 8.60027075e-02f, 8.72396305e-02f, 1.83521956e-01f, -3.99988778e-02f,
  1.42080233e-01f, 2.67554998e-01f, -4.64780405e-02f, -3.51426452e-02f, -4.04804461e-02f, -1.57193378e-01f, -7.52093270e-02f, -1.59457460e-01f, 1.68644398e-01f, -1.20083310e-01f,
  3.09014078e-02f, -7.62627274e-02f, 1.03289120e-01f, -1.20596625e-01f, 3.14837620e-02f, -7.23198280e-02f, 1.01489015e-01f, 3.79505791e-02f, 1.52373374e-01f, 6.48929253e-02f,
  1.62869662e-01f, -3.60457599e-02f, -5.65261580e-02f, -1.65172815e-01f, -1.23333283e-01f, 1.70340277e-02f, -3.12629491e-02f, -4.34702560e-02f, 3.76385301e-02f, 1.41775668e-01f,
  5.19538999e-01f, -7.52793014e-01f, 3.52892548e-01f, 3.24818224e-01f, 5.97240329e-01f, 2.07705274e-01f, 4.53391194e-01f, -1.76941767e-01f, 1.13681547e-01f, -6.00641787e-01f,
  -9.18934122e-02f, -2.27138206e-01f, -1.87789619e-01f, -2.11005151e-01f, 3.22288811e-01f, -2.12500900e-01f, 7.17928335e-02f, -8.91366303e-02f, -1.14916548e-01f, -9.90636274e-02f,
  2.77359247e-01f, 9.44797546e-02f, 5.00571094e-02f, -3.24090719e-01f, 2.00132951e-01f, 8.70378613e-02f, 7.27016851e-03f, 1.24717519e-01f, 1.20616425e-02f, 8.06358010e-02f,
  -3.53493392e-02f, 1.09796084e-01f, 5.85376471e-02f, -1.71862632e-01f, -3.14742625e-02f, 4.48594913e-02f, 2.56072059e-02f, -1.93229932e-02f, 5.54248244e-02f, -4.06094380e-02f,
  -7.36521408e-02f, -1.55270668e-02f, 1.92878749e-02f, 5.78126684e-02f, 1.50175035e-01f, -3.01637482e-02f, 5.32000586e-02f, -6.06657146e-03f, -1.24623440e-02f, 4.14079800e-02f,
  -3.16263847e-02f, -1.06346726e-01f, 1.17154978e-01f, -1.38879329e-01f, -2.73564588e-02f, 1.36250585e-01f, 1.43243164e-01f, 6.16663694e-02f, -9.00364593e-02f, 3.72819342e-02f,
  1.68072898e-02f, 5.22205308e-02f, -3.82384174e-02f, -8.28974247e-02f, -7.95666054e-02f, 1.36988044e-01f, 6.97271451e-02f, -1.24534788e-02f, -2.23782919e-02f, 4.08562347e-02f,
  2.14464758e-02f, -2.78725456e-02f, -4.18858491e-02f, -2.75463425e-02f, -2.18698289e-02f, -7.52737373e-02f, 4.59744893e-02f, 1.23393936e-02f, -6.22558445e-02f, -4.71039787e-02f,
  -5.94426095e-02f, 1.15586057e-01f, -1.43286481e-01f, 1.00713097e-01f, -2.43467167e-02f, 5.09736054e-02f, -9.30930078e-02f, -1.16955869e-01f, 5.99975623e-02f, 1.28457639e-02f,
  -4.40533400e-01f, -4.44700301e-01f, -1.22569479e-01f, -1.56182349e-01f, -3.21163312e-02f, -1.69609368e-01f, 5.22303246e-02f, -6.55636936e-02f, -1.00273937e-01f, -8.15274715e-02f,
  -9.76528798e-04f, -4.84842481e-03f, -7.59271383e-02f, 3.57145555e-02f, -2.16465473e-01f, -7.00438246e-02f, 3.02238222e-02f, -1.93397403e-01f, -5.76787814e-02f, -2.69450583e-02f,
  -8.35767686e-02f, 3.43628414e-02f, -6.85917139e-02f, 5.76982759e-02f, -9.97632518e-02f, 1.23268411e-01f, -2.73870435e-02f, -7.01029226e-02f, -4.23276648e-02f, -2.85924179e-03f,
  2.18327388e-01f, 4.36422884e-01f, 3.63068402e-01f, 3.95110101e-01f, -1.70629531e-01f, -6.52210474e-01f, -9.16946977e-02f, 1.66426554e-01f, 6.94322810e-02f, 2.98540503e-01f,
  -3.50767732e-01f, 4.97159511e-01f, -2.62113035e-01f, 1.00062259e-01f, -5.92648327e-01f, -5.49464524e-01f, -1.27327725e-01f, 2.28228271e-02f, -1.74679421e-02f, 1.58999935e-01f,
  -5.62402271e-02f, -3.10415983e-01f, 1.17649309e-01f, -1.46096632e-01f, 2.26821169e-01f, 3.98563027e-01f, 7.42033646e-02f, -1.18611187e-01f, 9.73333344e-02f, -1.08449370e-01f,
  -9.43688154e-02f, 2.55114287e-01f, 2.88136095e-01f, -2.96767429e-02f, -2.65535060e-02f, 1.08862564e-01f, 8.80115852e-03f, -1.11848921e-01f, -4.29252423e-02f, -1.20092258e-02f,
  -2.49993801e-02f, -1.43174618e-01f, -3.37272696e-02f, -1.59282625e-01f, 2.01581176e-02f, 2.36508697e-02f, 1.74744666e-01f, 7.94115216e-02f, 6.77624866e-02f, 5.02360202e-02f,
  1.42033041e-01f, 1.29362330e-01f, 1.73621818e-01f, 6.89659268e-02f, 6.74097091e-02f, 2.60792095e-02f, -8.65358710e-02f, 1.81241736e-01f, -5.17562926e-02f, -2.07734806e-03f,
  5.97845241e-02f, -1.17629938e-01f, -3.90749238e-02f, -3.27630416e-02f, -6.32085055e-02f, -7.39545226e-02f, -9.38890676e-04f, -4.22600731e-02f, -7.70185739e-02f, -9.70293954e-02f,
  5.47945360e-03f, 1.16632782e-01f, -1.20326169e-01f, 3.19187008e-02f, 5.60658686e-02f, 4.02545594e-02f, -2.21519824e-02f, -5.77627160e-02f, 6.33237809e-02f, 6.41933903e-02f,
  4.38524485e-02f, -7.11474791e-02f, 2.17474308e-02f, 3.87668833e-02f, -2.03292966e-01f, 3.92496511e-02f, 6.23841174e-02f, -6.75302073e-02f, -9.69028845e-02f, -4.17380556e-02f,
  1.89150814e-02f, 5.24040125e-02f, 6.30567819e-02f, 3.08238827e-02f, 1.14600919e-02f, -4.27023955e-02f, -7.09633008e-02f, 6.68680370e-02f, -1.63335636e-01f, -1.08750015e-01f,
  1.86745927e-01f, -6.43608272e-02f, -5.69450073e-02f, -2.97595095e-02f, -1.08873501e-01f, -1.78093668e-02f, 5.41193560e-02f, -5.14460802e-02f, 1.63953245e-01f, 3.20331044e-02f,
  1.93233900e-02f, -4.46564183e-02f, 2.39146948e-02f, -3.54196280e-02f, 5.41001149e-02f, 6.54298514e-02f, -1.58923998e-01f, 1.99134454e-01f, -4.87970039e-02f, -5.17164804e-02f,
  -3.71916264e-01f, -1.26990333e-01f, 4.21337038e-02f, 2.42003262e-01f, -1.83152646e-01f, 6.21436298e-01f, 7.87077308e-01f, 1.90980081e-03f, 6.26384437e-01f, 3.97151917e-01f,
  1.18134245e-01f, 1.79642588e-01f, 3.84329170e-01f, 2.26369113e-01f, 3.99174154e-01f, 3.62326682e-01f, 3.83182913e-01f, 2.26686060e-01f, -2.38322705e-01f, 3.58125083e-02f,
  -1.05464412e-02f, 7.86123425e-02f, -7.85189718e-02f, -3.46143782e-01f, -2.36991644e-01f, -4.52747673e-01f, -1.92259058e-01f, -1.51271015e-01f, -2.31491234e-02f, -2.01583616e-02f,
  -2.26102248e-01f, -3.11654866e-01f, -3.15551043e-01f, 4.17233109e-02f, -4.05521132e-02f, -1.35831237e-01f, 3.84434983e-02f, -6.41610026e-02f, -1.95474803e-01f, 1.45966299e-02f,
  1.75184697e-01f, -4.65363190e-02f, 5.45140430e-02f, -9.23246369e-02f, 9.08549130e-03f, -1.08081460e-01f, -1.28266782e-01f, -2.45587584e-02f, 2.36722082e-01f, -1.06979579e-01f,
  1.42084360e-02f, -3.84624600e-02f, 9.10202041e-02f, -2.41449196e-02f, -8.07978287e-02f, -1.66781060e-02f, 1.73066482e-01f, 1.24765635e-01f, -7.38192955e-03f, -1.10793617e-02f,
  -1.20765142e-01f, 6.15360476e-02f, -2.14479137e-02f, -4.71582524e-02f, 1.64892264e-02f, -1.47316873e-01f, 3.95223163e-02f, -8.28566309e-03f, 2.38208063e-02f, 8.45894292e-02f,
  -6.75826222e-02f, 9.05745476e-03f, -9.18196738e-02f, -3.98141593e-02f, 1.02205880e-01f, 1.09364375e-01f, 5.36348335e-02f, -1.61457449e-01f, 6.04312904e-02f, 1.27448086e-02f,
  7.85781667e-02f, 5.81957214e-02f, -1.67825237e-01f, -1.41252372e-02f, -2.32972130e-02f, 5.81287071e-02f, -2.30577681e-02f, 8.51883069e-02f, 1.28131844e-02f, -5.80166234e-03f,
  1.40262499e-01f, 1.39458239e-01f, -2.88539231e-02f, -9.28180441e-02f, 3.39242443e-03f, 1.32220555e-02f, -3.83749907e-03f, -1.05853230e-01f, 1.59420639e-01f, 1.16067596e-01f,
  -1.11404613e-01f, -1.06840618e-01f, -9.45884641e-03f, -6.50884956e-03f, 1.45618662e-01f, 1.76615760e-01f, 7.40496144e-02f, 1.09058484e-01f, 1.13743961e-01f, -1.48686856e-01f,
  -1.32690832e-01f, -1.49910832e-02f, 9.94066894e-02f, -6.83634803e-02f, -9.68126431e-02f, 1.40720055e-01f, -2.10933775e-01f, -3.45747889e-04f, -1.52214274e-01f, 9.46646556e-02f,
  -6.27776161e-02f, -1.73655767e-02f, -4.48758751e-01f, -3.06657732e-01f, 1.87039465e-01f, -3.60380113e-01f, -4.61622000e-01f, -1.45719185e-01f, 2.22275499e-03f, 9.72709134e-02f,
  -1.63061291e-01f, -2.01037809e-01f, 1.53309643e-01f, -6.42566979e-01f, -2.85945475e-01f, -6.22240715e-02f, -5.94669163e-01f, -4.53658164e-01f, -3.76746319e-02f, -1.99116886e-01f,
  -1.57809034e-01f, -2.31715515e-01f, -7.50491321e-01f, 9.59004685e-02f, -4.19112384e-01f, 3.06596868e-02f, 4.10473853e-01f, 9.34316441e-02f, -2.60437608e-01f, -1.57049745e-01f,
  -2.16431454e-01f, -1.34578809e-01f, -1.08104385e-02f, -1.42924041e-01f, -1.35091409e-01f, -3.05889081e-02f, -2.01649237e-02f, 8.71859267e-02f, -3.11267469e-02f, -9.59829688e-02f,
  9.55361128e-02f, 7.86244124e-02f, -1.22992270e-01f, 9.60197672e-03f, -1.58310495e-02f, -1.14754282e-01f, -1.67202175e-01f, -9.74005437e-04f, -1.31314993e-01f, -1.78216666e-01f,
  -3.34495544e-01f, -7.65291303e-02f, 8.27638581e-02f, -5.75086512e-02f, -1.10415891e-01f, -1.57651410e-01f, -2.88016070e-02f, 1.00058429e-01f, -6.56569153e-02f, 1.49837825e-02f,
  4.89143357e-02f, 2.73899287e-01f, 2.71655130e-03f, 4.00461257e-02f, -9.74011049e-02f, 1.16859697e-01f, -4.50736806e-02f, 1.23006552e-01f, 4.12347391e-02f, 1.02918816e-03f,
  -7.66814426e-02f, -6.87628612e-03f, -1.03843622e-01f, -7.85761699e-02f, -1.90345719e-01f, -1.33243889e-01f, 7.22907111e-02f, 3.02018747e-02f, -1.17170535e-01f, -1.01245210e-01f,
  -1.52098415e-02f, 1.46479875e-01f, -4.67638001e-02f, -6.45005777e-02f, 9.15058479e-02f, 8.38385373e-02f, 7.44750723e-03f, 1.88877527e-02f, 6.28703684e-02f, 8.49697366e-02f,
  1.13376109e-02f, 2.51424193e-01f, -2.11643968e-02f, -2.37588212e-02f, 6.92147836e-02f, -4.40105572e-02f, -2.70454083e-02f, -8.95333663e-02f, 5.40868603e-02f, 5.89042492e-02f,
  1.60958022e-01f, 4.47102822e-02f, 1.28142968e-01f, -8.60052854e-02f, -1.68663170e-02f, 6.32767007e-02f, 6.98742718e-02f, 1.36972100e-01f, 1.44665495e-01f, 6.01574071e-02f,
  1.19148023e-01f, -9.28156357e-03f, 7.94724226e-02f, -7.13034496e-02f, 7.64433295e-02f, 4.71942388e-02f, 1.17005073e-01f, -8.48183334e-02f, 2.24910546e-02f, -2.47660000e-02f,
  1.03570282e-01f, 2.77427554e-01f, 1.13860480e-01f, -9.57328081e-02f, 1.10169224e-01f, 5.87157249e-01f, 5.56619644e-01f, 6.76932782e-02f, 3.29854935e-01f, -1.20025724e-01f,
  -1.80259585e-01f, 4.83217835e-02f, 1.13999248e-01f, -7.06681237e-02f, 2.63621092e-01f, 2.57410944e-01f, 3.20885777e-01f, 8.38996321e-02f, 4.54911977e-01f, 9.54778772e-03f,
  6.43700063e-02f, -2.27033962e-02f, 7.90460967e-03f, -1.04148954e-01f, -8.06564614e-02f, -3.73484641e-02f, -5.00298023e-01f, 5.72248250e-02f, -5.61403394e-01f, 4.83810082e-02f,
  1.81414962e-01f, 1.61433578e-01f, 3.79073359e-02f, 5.48031218e-02f, 9.89536196e-02f, -9.39441696e-02f, -1.01920605e-01f, 1.19044170e-01f, 8.28822106e-02f, -3.14025655e-02f,
  -4.29847650e-02f, -1.38311028e-01f, 2.42259749e-03f, -5.23080602e-02f, -1.92261487e-02f, -1.08243465e-01f, -8.06999952e-02f, -1.61222480e-02f, -8.80591273e-02f, 7.08172545e-02f,
  8.29264075e-02f, 1.64938159e-02f, -9.89552066e-02f, -4.54414897e-02f, 9.72335115e-02f, -7.97682721e-03f, 2.11065158e-01f, -4.41222638e-02f, 5.11510558e-02f, 7.73530602e-02f,
  -5.63411787e-02f, 1.86210439e-01f, 8.26182868e-03f, -1.18264500e-02f, 4.96213920e-02f, -5.72070740e-02f, -1.60529658e-01f, -1.03859432e-01f, -3.41392402e-03f, -1.59600616e-01f,
  4.37577106e-02f, 1.78233068e-02f, 2.15194866e-01f, 4.67861518e-02f, 5.00623509e-02f, -8.60582478e-03f, -5.13089309e-03f, 6.28217161e-02f, 2.16729101e-02f, -8.69116187e-02f,
  -9.56735536e-02f, 5.53259030e-02f, 1.92761067e-02f, -1.48687571e-01f, 1.49888694e-01f, -2.56037252e-04f, -8.91996026e-02f, -9.77707002e-03f, -5.68991452e-02f, 3.82825583e-02f,
  8.74594003e-02f, 3.91169280e-01f, 5.62670976e-02f, -9.66146775e-03f, 8.46015438e-02f, 9.93659254e-03f, 1.16807170e-01f, 1.69744473e-02f, 9.11264420e-02f, 4.36430126e-02f,
  4.81062606e-02f, 1.21125013e-01f, -1.32266181e-02f, -9.20807943e-02f, -6.10418692e-02f, -2.44126190e-02f, 1.45978734e-01f, 9.96873230e-02f, 2.34572198e-02f, 2.61227917e-02f,
  -1.34785280e-01f, 8.22595507e-02f, 1.38768023e-02f, -4.09719013e-02f, 1.31353885e-02f, -1.52029127e-01f, 1.30636767e-01f, 7.93937445e-02f, 2.79631745e-03f, -4.14860584e-02f,
  8.43982100e-01f, -4.68519628e-01f, -3.12567413e-01f, 3.90886873e-01f, 2.37655118e-01f, 2.38751873e-01f, 1.13729641e-01f, 2.50693709e-01f, 5.06112039e-01f, -8.35221857e-02f,
  5.58199398e-02f, -2.07320064e-01f, -4.70493972e-01f, 3.10805172e-01f, 2.64578462e-01f, -6.87026009e-02f, 3.57523918e-01f, -1.11751128e-02f, 1.66333262e-02f, 1.17165059e-01f,
  2.73631275e-01f, 3.45229864e-01f, -3.56188059e-01f, 2.70563308e-02f, 1.04478277e-01f, -9.20686945e-02f, -2.81103980e-02f, -4.09743041e-01f, 1.92084953e-01f, -5.15005998e-02f,
  2.72370249e-01f, 5.22417352e-02f, 1.40130788e-01f, 5.95261436e-03f, 3.37506048e-02f, -2.29045115e-02f, -2.08150327e-01f, -9.73618552e-02f, 1.65273622e-01f, 5.70846768e-03f,
  -2.27669682e-02f, 1.42289117e-01f, 2.00709596e-01f, 5.92434499e-03f, 1.33234158e-01f, 1.50701776e-01f, 8.42426345e-02f, 7.22151101e-02f, 3.21546271e-02f, -1.35634214e-01f,
  4.61181998e-02f, 3.81474905e-02f, 1.02220669e-01f, -1.01052737e-02f, 8.75813290e-02f, 9.76197645e-02f, -1.25321954e-01f, -9.53091308e-02f, 2.27033906e-02f, 1.45407259e-01f,
  6.55656960e-03f, -1.26867011e-01f, -5.73977679e-02f, 1.40840054e-01f, -1.31365275e-02f, 8.32433552e-02f, 6.06709509e-04f, -1.12346791e-01f, 5.36472239e-02f, 5.23281284e-04f,
  -1.13327121e-02f, 5.17784655e-02f, -1.47694796e-02f, 4.75445315e-02f, -1.53391454e-02f, 4.63912562e-02f, -1.42321540e-02f, 4.14684750e-02f, -1.30446982e-02f, 1.51180401e-01f,
  3.24895233e-02f, 1.26165077e-01f, -1.37724116e-01f, -1.17589999e-02f, -1.70899760e-02f, -5.56585789e-02f, -5.21280095e-02f, 9.68232155e-02f, 2.96753962e-02f, -1.27770483e-01f,
  -2.55919039e-01f, -3.99371952e-01f, -7.24100857e-04f, -3.71431597e-02f, -1.78570762e-01f, 2.11375445e-01f, 4.53721583e-02f, 9.18613672e-02f, -6.04375117e-02f, 7.47145340e-02f,
  7.38326833e-02f, 3.73824649e-02f, 4.08781413e-03f, 1.13619700e-01f, 8.92053321e-02f, 8.15828592e-02f, -3.77446301e-02f, 6.02556951e-02f, 1.57282606e-01f, -4.03543226e-02f,
  -1.34305641e-01f, 3.47226597e-02f, 4.82855588e-02f, 1.22063197e-01f, -6.92739785e-02f, -1.09481670e-01f, 1.42659307e-01f, -1.21750697e-01f, -1.34777397e-01f, 1.91822853e-02f,
  4.76840556e-01f, -5.10415018e-01f, 4.57633764e-01f, 3.53874654e-01f, -4.20463718e-02f, -3.70446175e-01f, -1.49983510e-01f, -3.60608786e-01f, -4.25495237e-01f, -5.94402671e-01f,
  -1.35552183e-01f, 3.01516294e-01f, -2.09127545e-01f, 3.70404810e-01f, 5.95368803e-01f, -2.66500443e-01f, -5.92281930e-02f, 1.24146089e-01f, 3.05958670e-02f, -5.52379191e-02f,
  2.61467665e-01f, 1.80791140e-01f, 4.36371237e-01f, -1.09763797e-02f, 2.87450105e-01f, 1.29540563e-01f, 2.16508225e-01f, 1.97989881e-01f, 1.65838063e-01f, 3.35255176e-01f,
  8.52397829e-02f, 5.63464835e-02f, 1.49925590e-01f, 1.24172509e-01f, -1.59950124e-03f, 6.05451968e-03f, 2.36862317e-01f, 2.44996801e-01f, 1.42999321e-01f, -1.52176721e-02f,
  4.18377854e-03f, -8.68747476e-03f, 7.41622448e-02f, 7.36177433e-04f, 3.37992609e-02f, 7.23459795e-02f, -5.43450490e-02f, -6.62802234e-02f, -5.48065826e-02f, -3.37878130e-02f,
  -1.37628183e-01f, 6.70825467e-02f, -6.67679310e-02f, 9.84384194e-02f, 7.00709671e-02f, -2.72785444e-02f, 2.17639133e-02f, 7.47214034e-02f, -5.70876747e-02f, 1.31068043e-02f,
  -7.49485865e-02f, -3.80039178e-02f, 7.49521032e-02f, 1.38166666e-01f, 7.25583872e-03f, -1.70183266e-04f, 5.88632748e-03f, 3.10392119e-02f, 2.08996907e-02f, -1.35385022e-01f,
  6.99272454e-02f, 1.12817446e-02f, -1.86556636e-03f, -5.56107424e-02f, -4.45507541e-02f, -2.30858773e-02f, 2.10565671e-01f, 2.35364540e-03f, -3.62099670e-02f, -3.70198973e-02f,
  5.80403432e-02f, 4.28353325e-02f, 6.60764650e-02f, 4.96221855e-02f, 3.57723571e-02f, 1.54041843e-02f, -1.06239486e-02f, -8.81242938e-03f, -3.74058485e-02f, 5.62869161e-02f,
  -1.33300066e-01f, -1.83998510e-01f, -8.07392150e-02f, 1.40394583e-01f, 3.65971662e-02f, -2.12104414e-02f, 1.33968532e-01f, 3.71513180e-02f, -1.78561658e-02f, -5.84076904e-02f,
  1.59431651e-01f, 1.47539660e-01f, -1.60087049e-02f, 5.25359698e-02f, 2.21369967e-01f, -1.89580053e-01f, 4.84031923e-02f, 1.10124566e-01f, 9.31575522e-02f, -7.87378401e-02f,
  1.81758814e-02f, -1.83419019e-01f, 8.62569287e-02f, 5.80797866e-02f, 5.28458022e-02f, 3.06246914e-02f, 1.50352558e-02f, -6.75367378e-03f, 6.44413903e-02f, 6.75928444e-02f,
  -5.43728292e-01f, 4.14886326e-01f, -6.12191498e-01f, 2.56788820e-01f, -5.03478050e-02f, 4.64326590e-01f, 4.97947633e-01f, 2.20532045e-02f, 2.11975873e-01f, 4.51882988e-01f,
  3.15883398e-01f, -1.56177077e-02f, 4.91839461e-02f, 9.91937816e-01f, 2.06227213e-01f, 3.28242779e-01f, 5.97965896e-01f, 4.40225005e-01f, 3.83208389e-04f, -7.72113502e-02f,
  -1.38985524e-02f, 6.33262098e-01f, 6.73796833e-02f, 7.04781264e-02f, 7.09531531e-02f, -3.06075692e-01f, 4.93006185e-02f, -2.84253448e-01f, 3.02867413e-01f, 1.57034039e-01f,
  1.45930588e-01f, -1.31085396e-01f, -7.68485591e-02f, -9.87933278e-02f, -5.85612208e-02f, -8.34705755e-02f, -7.73748234e-02f, -1.12912677e-01f, -1.29794851e-01f, 1.92720313e-02f,
  -6.72059730e-02f, -1.13048494e-01f, 1.22768484e-01f, 8.01876336e-02f, -2.56631877e-02f, -9.42368060e-02f, -2.09797975e-02f, 1.78775825e-02f, 1.82963964e-02f, -4.09179144e-02f,
  -9.19469222e-02f, 2.87744068e-02f, -1.54731059e-02f, 1.32223085e-01f, -1.31458119e-01f, 4.26451378e-02f, 7.69002438e-02f, -1.58475742e-01f, 2.09321044e-02f, 8.19133818e-02f,
  6.62272722e-02f, -6.63724616e-02f, -3.39155979e-02f, 1.12994686e-01f, 9.29876566e-02f, 6.07774183e-02f, 3.77502777e-02f, -1.26541033e-01f, -1.17871873e-01f, 9.46250260e-02f,
  3.34923416e-02f, -1.52122211e-02f, 1.15321323e-01f, -1.42645615e-03f, -3.64811011e-02f, 8.57594481e-04f, -1.14651144e-01f, 5.21635152e-02f, -7.96654373e-02f, 7.28748785e-03f,
  5.66607043e-02f, -4.36431207e-02f, 5.05353920e-02f, 1.98026169e-02f, -1.88711770e-02f, -1.95626125e-01f, 6.64693490e-02f, -5.99725060e-02f, -1.09159127e-01f, -6.21523745e-02f,
  2.96779662e-01f, 1.52142555e-01f, 6.00999482e-02f, -2.20509600e-02f, 1.10444635e-01f, 9.62959137e-03f, 7.03329891e-02f, -4.95338887e-02f, -2.42565293e-02f, -1.14613734e-01f,
  -4.77536656e-02f, -5.13499370e-03f, -1.24414042e-02f, -4.98126000e-02f, 4.73844670e-02f, 1.31064784e-02f, 7.19846562e-02f, -5.34794247e-03f, 7.92836547e-02f, -2.50702780e-02f,
  1.95092317e-02f, 2.92331469e-03f, 3.50964651e-03f, -5.25999069e-02f, -2.30623502e-02f, -5.19322604e-02f, -3.44165345e-03f, -9.76797640e-02f, 3.41616906e-02f, 7.21703693e-02f,
  -8.56585622e-01f, 1.03098407e-01f, -8.74620378e-02f, -5.99906981e-01f, -6.70517460e-02f, -2.38389492e-01f, -5.61545640e-02f, -2.68260062e-01f, -1.20539442e-01f, 4.72535081e-02f,
  -2.67453864e-02f, -2.32120559e-01f, 4.23419744e-01f, -1.44114867e-01f, 5.43237329e-02f, 5.13985217e-01f, -1.47390604e-01f, -1.20830514e-01f, 1.72986433e-01f, -3.52778852e-01f,
  -8.91913101e-02f, -1.39474794e-01f, 1.40192052e-02f, 1.23321161e-01f, -3.28677863e-01f, -2.65794247e-01f, -1.90976769e-01f, 1.79576352e-01f, -2.11553767e-01f, 4.80843224e-02f,
  -7.28041768e-01f, -3.67490262e-01f, -2.04377994e-01f, -1.81612685e-01f, -3.18866253e-01f, -6.31524324e-02f, -1.05318680e-01f, 1.40904009e-01f, -1.16376229e-01f, -5.96436597e-02f,
  -7.24247470e-02f, -1.26962448e-02f, -1.11675784e-01f, 1.69311807e-01f, -9.32578593e-02f, -1.99456909e-03f, 9.41207539e-03f, -9.69256237e-02f, -1.02055125e-01f, 2.69297063e-02f,
  9.47042480e-02f, -6.53545260e-02f, -1.97213933e-01f, -1.18880365e-02f, -4.17682193e-02f, -1.63615681e-02f, 1.56834740e-02f, -1.04540791e-02f, -4.03752662e-02f, -2.20429927e-01f,
  1.88744411e-01f, 6.08382300e-02f, 4.69284728e-02f, -6.39249086e-02f, 1.25665769e-01f, -5.83317503e-02f, -3.21575776e-02f, 1.67221092e-02f, -1.51970256e-02f, -2.73308833e-03f,
  -8.01301524e-02f, -8.79164934e-02f, -1.23041477e-02f, -4.56695557e-02f, -2.15585139e-02f, -5.71855605e-02f, -6.83745369e-02f, -8.08198191e-03f, -7.56106386e-03f, 1.51631515e-02f,
  -1.30381733e-01f, 7.92917982e-02f, 1.16317734e-01f, -5.56421280e-02f, -3.15118954e-02f, 4.87251729e-02f, 2.21930724e-02f, 4.72016484e-02f, -3.75691168e-02f, 7.11056078e-03f,
  -8.92874897e-01f, -7.38560796e-01f, -1.27131179e-01f, -1.02386743e-01f, -4.89004925e-02f, -5.59982620e-02f, -2.09402163e-02f, -1.30132779e-01f, -1.26802221e-01f, 3.40407938e-02f,
  -1.60197526e-01f, -7.12638870e-02f, -1.07545055e-01f, 3.64103098e-03f, 1.49803296e-01f, -9.80460122e-02f, -8.36219266e-02f, -7.72769973e-02f, -1.32228643e-01f, 4.24626581e-02f,
  -7.67329633e-02f, 9.82239544e-02f, 1.09641589e-01f, 2.61681248e-02f, -1.53126195e-02f, -1.41171947e-01f, -9.09240022e-02f, -7.39617180e-03f, -1.05668724e-01f, 2.22425554e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.47460246e-01f, 1.27118573e-01f, 4.26459342e-01f, 3.25125962e-01f, 8.50890949e-02f, 5.06119490e-01f, 3.73606265e-01f, 6.44461334e-01f, 6.14012480e-01f, 6.28637731e-01f,
  5.23631811e-01f, 6.75340891e-01f, 2.19405636e-01f, 6.35377884e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  9.10111889e-02f, -2.01615226e-02f, 1.93138234e-02f, 6.33197427e-02f, -1.47143215e-01f, -3.27510685e-01f, -6.76580220e-02f, 2.01945439e-01f, 1.59535289e-01f, 9.62381512e-02f,
  2.56223708e-01f, 3.43469232e-01f, 1.80180788e-01f, -1.82803750e-01f, -4.68554258e-01f, 1.66704014e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.51600230e-01f, 1.58482730e-01f, 4.56791490e-01f, 1.14876196e-01f, 4.08704765e-02f, 6.73803315e-02f, -2.47532144e-01f, 2.71756619e-01f, -3.16046923e-01f, 5.83605647e-01f,
  2.43357867e-01f, 9.76876915e-01f, 9.95416790e-02f, -2.99070012e-02f, -7.35014398e-03f, 4.03450280e-01f, 2.59391934e-01f, 4.21891421e-01f, 3.61008197e-01f, -7.59232283e-01f,
  4.86670583e-01f, -4.03529048e-01f, -4.50529307e-01f, 6.59354270e-01f, 5.26532650e-01f, 2.33320549e-01f, -3.11982661e-01f, 3.99333388e-02f, 7.43213952e-01f, 4.58670110e-01f,
  -3.69438916e-01f, 1.57763630e-01f, 5.84296823e-01f, -5.88069141e-01f, 1.13911152e-01f, -7.12420419e-02f, 1.16617687e-01f, -7.43205547e-02f, 3.31937343e-01f, 1.07026207e+00f,
  5.72267890e-01f, 1.99794754e-01f, 2.81725883e-01f, 4.51133996e-01f, 5.32350659e-01f, 6.63547933e-01f, -6.42419577e-01f, 3.27613056e-01f, 8.82391751e-01f, 6.57645881e-01f,
  2.59646773e-01f, 7.88244978e-02f, 2.11807579e-01f, 8.28733683e-01f, -3.52973938e-01f, -4.06699836e-01f, -3.46306384e-01f, 4.68390197e-01f, 5.43714762e-01f, 2.47422710e-01f,
  5.75184882e-01f, 6.88722953e-02f, 8.26986790e-01f, -6.10552669e-01f, -1.59722418e-02f, -8.03240657e-01f, -6.10421836e-01f, 2.37038493e-01f, -1.09162517e-01f, 1.40713379e-01f,
  5.13263583e-01f, 2.83557802e-01f, -2.66966283e-01f, 2.36043651e-02f, 5.00782490e-01f, -1.12213811e-03f, -3.17550272e-01f, 6.62477732e-01f, -3.91663432e-01f, 1.80053771e-01f,
  3.48961174e-01f, -1.13226008e+00f, 2.33039349e-01f, -2.65405886e-02f, 1.65571839e-01f, -1.39908940e-01f, 3.08163464e-01f, 5.40997565e-01f, -1.28863171e-01f, 4.77038831e-01f,
  -7.11508393e-02f, 5.97105384e-01f, 9.30810906e-03f, 6.00654840e-01f, 9.99545231e-02f, 6.58597529e-01f, -2.20489092e-02f, -7.61907160e-01f, -6.66447341e-01f, 5.24844050e-01f,
  5.51870048e-01f, 2.93792874e-01f, 5.86789489e-01f, -1.38045147e-01f, -7.49787390e-02f, 5.16704381e-01f, 1.48879856e-01f, -2.61900812e-01f, -2.62398213e-01f, 5.14692366e-01f,
  9.60058212e-01f, 4.98089552e-01f, 4.13874462e-02f, 1.78572744e-01f, 3.30689043e-01f, 1.22508807e-02f, 3.01929176e-01f, 4.73285615e-01f, 7.03112602e-01f, -3.99798810e-01f,
  6.28161848e-01f, -2.89469779e-01f, 7.57610559e-01f, -4.43908900e-01f, -1.23091154e-02f, 3.95684093e-01f, -1.75045744e-01f, 1.65119499e-01f, 3.52526248e-01f, 4.85056221e-01f,
  -6.72761127e-02f, -2.72198230e-01f, 3.81092608e-01f, 1.88317388e-01f, 3.71009484e-02f, 6.08864725e-01f, 1.88221291e-01f, 6.21054232e-01f, -1.04577936e-01f, 6.02656305e-01f,
  6.89323366e-01f, 6.86233997e-01f, 5.03621876e-01f, -3.58856380e-01f, 2.83089072e-01f, 5.29560387e-01f, 6.23728096e-01f, 8.54819939e-02f, 5.44918895e-01f, -7.37017915e-02f,
  6.61114156e-01f, -3.86639982e-01f, 7.27384746e-01f, -2.82141507e-01f, 6.42931998e-01f, -2.64989644e-01f, -5.48424661e-01f, -5.47644123e-03f, -2.37215489e-01f, 5.40088475e-01f,
  1.13715440e-01f, 4.77599353e-01f, 2.81108528e-01f, -1.79434776e-01f, 8.87422383e-01f, 3.81313682e-01f, 1.31224841e-01f, 5.30744642e-02f, 4.88076359e-01f, -5.08825660e-01f,
  2.43711501e-01f, -3.55517656e-01f, 1.62564769e-01f, 2.82542467e-01f, -6.85019270e-02f, -3.48358482e-01f, 2.83900559e-01f, 1.76207066e-01f, 5.35477161e-01f, 6.10023320e-01f,
  -2.98643708e-01f, 3.22702259e-01f, 3.16496640e-01f, 9.98348966e-02f, -1.91626057e-01f, -6.21500492e-01f, 8.80436599e-01f, 1.23698510e-01f, 3.51290703e-01f, -2.60440439e-01f,
  -6.91468596e-01f, 6.57618582e-01f, 2.55716860e-01f, 2.37384975e-01f, 7.27994800e-01f, -1.76415205e-01f, -1.00636706e-01f, -9.10878837e-01f, 2.11437568e-01f, 6.05446696e-02f,
  6.41096473e-01f, -3.32499057e-01f, 3.46075505e-01f, -1.94407180e-02f, 2.36380342e-02f, 2.26980329e-01f, -4.26067084e-01f, 7.35304296e-01f, -8.38365853e-02f, -3.81661922e-01f,
  1.43853635e-01f, 6.02589428e-01f, -2.56868899e-01f, -2.96461672e-01f, 2.90205151e-01f, -7.20834434e-02f, -7.37248361e-02f, 5.67815483e-01f, 2.04054058e-01f, 3.33256930e-01f,
  -8.43191028e-01f, 3.07094157e-01f, 2.46647432e-01f, 8.75481904e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  7.30180264e-01f, 2.26412863e-01f, 7.16577172e-01f, 2.84832656e-01f, -3.02549034e-01f, 8.05237234e-01f, -6.85364157e-02f, 3.85749280e-01f, 6.53353095e-01f, 5.93785524e-01f,
  5.44908941e-01f, 2.36158654e-01f, 3.62911671e-01f, 3.04874539e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.08383694e-01f, -3.27273756e-01f, -4.90397364e-02f, -3.23776484e-01f, -1.27096191e-01f, 3.34576756e-01f, 2.05207482e-01f, -1.58580378e-01f, -1.43490583e-01f, -1.73758641e-02f,
  1.01079112e-02f, 3.73135388e-01f, 1.10986665e-01f, -2.20356546e-02f, 2.75224894e-01f, -2.80111432e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.53507200e-02f, 6.75089240e-01f, 6.05453193e-01f, -7.53463879e-02f, 1.32076725e-01f, 8.10375452e-01f, -3.77166420e-01f, -1.38461202e-01f, -5.60449898e-01f, 6.33755505e-01f,
  -9.18449983e-02f, 5.51491857e-01f, 2.77014017e-01f, 7.40459919e-01f, 2.25990504e-01f, -7.80337527e-02f, 5.18981293e-02f, -3.80808771e-01f, -3.74990582e-01f, 6.19432449e-01f,
  1.09440833e-01f, 6.03346601e-02f, -4.85778153e-01f, -3.55904480e-03f, -3.84336740e-01f, 3.25601131e-01f, 3.55229080e-01f, 4.34306413e-01f, 5.42537034e-01f, -2.37069011e-01f,
  -6.77444460e-03f, -9.34245944e-01f, 6.24852516e-02f, 2.70520803e-02f, 4.99967374e-02f, 7.40676701e-01f, 3.65890443e-01f, -5.97999096e-01f, -3.40174437e-01f, 3.49024892e-01f,
  3.14849764e-01f, 1.54217422e-01f, 3.12346041e-01f, -1.85225502e-01f, 4.03927594e-01f, -7.09704161e-01f, -6.18074477e-01f, 4.29957658e-01f, -2.66224414e-01f, -8.87858421e-02f,
  -1.82428390e-01f, 7.21795678e-01f, 2.29826674e-01f, -2.32080877e-01f, -4.51344371e-01f, -2.02930018e-01f, -3.20158273e-01f, 3.07023913e-01f, 4.62411225e-01f, 1.81725174e-01f,
  5.26023746e-01f, -6.64418042e-01f, 8.26995298e-02f, -5.41425705e-01f, 5.70839942e-01f, 5.40790975e-01f, 4.56128865e-01f, 2.44421601e-01f, 6.82602882e-01f, 7.78083652e-02f,
  4.92511600e-01f, 7.06222534e-01f, -2.48412415e-01f, -1.82484716e-01f, 2.83173561e-01f, -5.85597336e-01f, -5.01241744e-01f, 5.33524714e-02f, -2.06121758e-01f, 2.30694592e-01f,
  5.22372365e-01f, 1.59451157e-01f, 6.53386056e-01f, -1.86070904e-01f, -1.10353917e-01f, 7.39741743e-01f, -2.25479484e-01f, 4.65564340e-01f, 6.83025718e-01f, -5.96197206e-04f,
  6.60556972e-01f, -4.18104768e-01f, 1.55715093e-01f, -1.95061639e-01f, -3.96108091e-01f, 4.08243835e-01f, 2.57724226e-01f, -1.06652364e-01f, -1.94547534e-01f, -5.63146621e-02f,
  2.12915152e-01f, 2.72655010e-01f, -4.48600292e-01f, -4.19262975e-01f, -3.53932321e-01f, 3.92699659e-01f, -5.29902756e-01f, 8.51522148e-01f, 4.93184149e-01f, 5.46656966e-01f,
  6.69225931e-01f, -1.50094658e-01f, 6.47136271e-02f, -9.89977658e-01f, -2.98195064e-01f, -6.02467582e-02f, -1.44427391e-02f, 1.18869618e-01f, 6.80358708e-01f, 5.47607183e-01f,
  9.73412871e-01f, 4.06429619e-01f, -3.09060165e-03f, 6.33042976e-02f, 4.59311545e-01f, 9.53145847e-02f, 1.48863703e-01f, 1.52547717e-01f, -4.11451906e-02f, 3.01500499e-01f,
  3.42427373e-01f, 4.10790414e-01f, 7.34516084e-01f, -3.03126037e-01f, 2.03480989e-01f, 4.01222408e-01f, -4.01248693e-01f, -3.23141277e-01f, 4.62178230e-01f, -1.13508272e+00f,
  2.54065484e-01f, -4.08103317e-01f, -9.68219459e-01f, -2.17161179e-01f, 1.22995339e-01f, 6.60272062e-01f, 1.00048423e-01f, 5.30111253e-01f, 2.26895005e-01f, -4.47552018e-02f,
  -1.05763209e+00f, -7.64384419e-02f, -8.90981078e-01f, 8.10806546e-03f, 1.82383340e-02f, 1.65836796e-01f, 7.38552734e-02f, 5.04176497e-01f, 6.92229807e-01f, -1.22464709e-01f,
  -3.66765469e-01f, -4.55655068e-01f, 1.81025788e-02f, -1.03975106e-02f, 4.98925954e-01f, -7.83827007e-01f, 3.60242546e-01f, 4.61849481e-01f, 4.82483655e-01f, 3.84027660e-01f,
  -2.66056776e-01f, 6.10565305e-01f, -1.73345938e-01f, 2.36804590e-01f, 7.77846098e-01f, 4.74179476e-01f, 4.98569220e-01f, 9.67146218e-01f, 4.53871399e-01f, 9.35367942e-01f,
  5.43657780e-01f, -5.02809286e-01f, -1.13675332e+00f, 7.32341409e-01f, -6.94797635e-01f, -2.63765275e-01f, 3.03770065e-01f, 5.34301950e-03f, 2.10459456e-02f, 2.51562591e-03f,
  4.98505443e-01f, -1.89581528e-01f, -1.11406587e-01f, -7.90897012e-01f, -2.48144805e-01f, 4.15638566e-01f, 1.58604354e-01f, 9.23940599e-01f, -3.68205011e-01f, -2.68241674e-01f,
  8.33734572e-02f, 5.89396894e-01f, 6.17421269e-01f, 2.27287292e-01f, 7.04879045e-01f, 7.70817325e-02f, -5.39717197e-01f, -1.01791871e+00f, -4.77110684e-01f, 2.04208896e-01f,
  -6.07839487e-02f, 3.25803220e-01f, 5.51427603e-01f, -8.16638172e-01f, 4.88197982e-01f, 2.21858770e-01f, -2.56834090e-01f, 1.16285384e-01f, 4.11858767e-01f, -3.72427613e-01f,
  -2.81278491e-02f, 5.09757847e-02f, -2.57896483e-01f, -3.40103418e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.50633049e-01f, 9.10883099e-02f, 1.94072336e-01f, -2.12024793e-01f, 3.97552460e-01f, 6.13452911e-01f, -2.34254505e-02f, -1.04560778e-01f, 1.29080057e-01f, 3.26219350e-01f,
  1.36578694e-01f, 5.84958553e-01f, 5.99230714e-02f, -2.31883004e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.29792589e-01f, -5.40168703e-01f, -9.61228728e-01f, -1.91726878e-01f, 3.98411840e-01f, -3.49013746e-01f, 3.35005373e-02f, 6.49737418e-01f, 8.42816234e-02f, 5.28187037e-01f,
  -9.29558337e-01f, -2.77675003e-01f, -1.91191837e-01f, -6.68290377e-01f, -7.85762012e-01f, -1.82824314e-01f, 4.26566809e-01f, 5.10367215e-01f, -6.11041731e-04f, -3.99819821e-01f,
  -6.68646574e-01f, -5.47888517e-01f, 6.18913360e-02f, 5.06961226e-01f, -5.57050943e-01f, 1.37209341e-01f, -3.43466043e-01f, -1.51905343e-01f, -6.92267716e-01f, -6.65950894e-01f,
  6.37216747e-01f, -1.07933007e-01f, 4.92470339e-02f, 4.59905975e-02f, -6.72599554e-01f, 2.88829774e-01f, 4.02565718e-01f, 3.42544109e-01f, -2.70521283e-01f, -1.06267512e-01f,
  -3.40113282e-01f, 1.20794103e-01f, 3.46469998e-01f, -3.05535913e-01f, -8.39860618e-01f, 1.11634590e-01f, 3.98453891e-01f, 1.05323151e-01f, -2.33973086e-01f, 3.26781690e-01f,
  4.74549174e-01f, -6.66555345e-01f, -8.36461410e-02f, -5.84031045e-01f, -9.45914924e-01f, -7.62093306e-01f, 3.22169811e-01f, -3.11242640e-01f, -1.56647563e-01f, 2.19311893e-01f,
  3.57182145e-01f, 8.76428634e-02f, -7.99526632e-01f, 2.07015481e-02f, 5.58124721e-01f, -3.68848056e-01f, 1.35045096e-01f, -3.11493814e-01f, -4.04708654e-01f, -6.67847574e-01f,
  3.18000019e-01f, 9.71004441e-02f, -4.77177113e-01f, -1.55142359e-02f, -5.50060570e-01f, 3.67257476e-01f, 1.88796565e-01f, 7.49363840e-01f, -6.36868119e-01f, -8.37427080e-01f,
  2.14040488e-01f, -6.76662683e-01f, 5.23971543e-02f, -3.93284142e-01f, 2.39128128e-01f, -4.47986424e-01f, 3.90186548e-01f, 5.86171150e-01f, -4.58234161e-01f, -5.65359116e-01f,
  4.46248740e-01f, -9.03466463e-01f, -8.13460946e-01f, 3.14926863e-01f, -4.89747345e-01f, -9.61002588e-01f, -2.95132995e-01f, 2.92133261e-02f, -1.52372330e-01f, -9.57761258e-02f,
  2.23945171e-01f, 3.17252606e-01f, 1.72884613e-01f, -8.52752551e-02f, -4.37516034e-01f, -9.93921816e-01f, 1.89280480e-01f, 6.07702672e-01f, -5.49133062e-01f, 4.40130711e-01f,
  5.05875126e-02f, 3.85159642e-01f, 1.38744816e-01f, 2.04727218e-01f, -6.08080924e-02f, -2.75145739e-01f, -5.46646416e-01f, -2.26266190e-01f, -5.49748205e-02f, -4.48495924e-01f,
  1.56617507e-01f, 5.24246991e-01f, -6.68382086e-03f, -5.52063644e-01f, 5.47117412e-01f, -5.43282449e-01f, -6.13359869e-01f, 4.78130192e-01f, -3.66640501e-02f, 2.93669820e-01f,
  -3.13411444e-01f, 3.17076504e-01f, 3.35500658e-01f, 2.88200229e-01f, -8.60245109e-01f, -1.64683282e-01f, -4.48680781e-02f, 3.90413523e-01f, -6.38319433e-01f, -5.65428197e-01f,
  3.55515361e-01f, -8.17043543e-01f, 4.08644706e-01f, 1.90598398e-01f, -1.20074369e-01f, -2.31297731e-01f, -1.08961356e+00f, -7.41439879e-01f, 4.09191877e-01f, -2.77099401e-01f,
  3.44468981e-01f, -1.71109453e-01f, -3.44803095e-01f, -1.30920723e-01f, 5.40862679e-01f, -4.75896478e-01f, 3.20395268e-02f, 3.15180928e-01f, -7.64660299e-01f, 4.36496586e-01f,
  -9.30186436e-02f, 1.61948919e-01f, 4.99625027e-01f, 1.01980709e-01f, -7.35499024e-01f, -5.09181917e-01f, -4.44111824e-01f, -2.61437207e-01f, 4.97295141e-01f, -7.73913339e-02f,
  -1.58458352e-01f, 4.30107303e-02f, -4.50228393e-01f, -5.69816828e-01f, 4.95846182e-01f, 1.44971043e-01f, 4.23984565e-02f, 3.19561869e-01f, -2.77259111e-01f, 4.18805480e-01f,
  7.69103840e-02f, 3.76531214e-01f, -5.70819736e-01f, -5.35201252e-01f, 2.89180040e-01f, -1.19694225e-01f, -4.99148279e-01f, 4.44378316e-01f, 2.39298977e-02f, 4.67425704e-01f,
  5.16902730e-02f, 8.78836587e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.91675639e-02f, 1.44889429e-01f, 4.43342961e-02f, 9.16209742e-02f, 4.42290008e-01f, -1.82357337e-03f, -2.42564932e-01f, 8.40232987e-03f, -3.03507186e-02f, 1.95288375e-01f,
  2.58741885e-01f, 5.56260534e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    