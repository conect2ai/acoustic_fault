/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.59914541e-01f, -1.25542194e-01f, -7.51204342e-02f, 1.83516279e-01f, -6.82159364e-02f, 9.67984572e-02f, 1.67726547e-01f, -1.84362754e-01f, -7.47935614e-03f, -8.57174397e-02f,
  6.15055040e-02f, 6.18472695e-02f, 5.93932867e-02f, -1.79845802e-02f, 2.96879590e-01f, 1.04618363e-01f, 1.49869531e-01f, 1.05059519e-01f, 4.57373671e-02f, 2.72062421e-02f,
  5.47025874e-02f, 1.60501719e-01f, 6.25190958e-02f, -1.50473729e-01f, -7.66475424e-02f, 5.51657304e-02f, 7.81325474e-02f, -9.80755687e-02f, 1.06803983e-01f, -8.39499533e-02f,
  1.27726093e-01f, -5.94388917e-02f, -6.75143749e-02f, -1.16197824e-01f, 1.28589466e-01f, -2.54690051e-02f, -3.27904820e-02f, -4.14727405e-02f, -2.48275511e-02f, 5.88078462e-02f,
  -1.44199440e-02f, -4.31641266e-02f, -4.85708490e-02f, 2.27265409e-03f, -1.98957846e-02f, -1.74836129e-01f, -4.52014208e-02f, 3.43920640e-03f, -5.35583943e-02f, -2.38594152e-02f,
  -1.32507741e-01f, 7.84690455e-02f, -7.96897411e-02f, 4.42257524e-02f, 2.05909908e-02f, -1.06841855e-01f, 5.69694489e-02f, 5.25760371e-03f, 3.19263376e-02f, -3.50848003e-03f,
  -5.92449903e-02f, 2.78107002e-02f, 3.82951759e-02f, -2.28541773e-02f, 2.09442936e-02f, -8.55526421e-03f, -1.68677345e-02f, -4.66971062e-02f, -5.96590564e-02f, 6.63743764e-02f,
  2.58610100e-02f, 1.16662476e-02f, -1.22387327e-01f, -3.66133824e-02f, 4.84369434e-02f, -4.55442630e-02f, -3.01772393e-02f, -7.43893757e-02f, 5.13526760e-02f, 6.62828935e-03f,
  -4.84756269e-02f, -6.68404400e-02f, 1.08852163e-01f, 1.12001315e-01f, 1.12812007e-02f, -3.23015340e-02f, -3.31458002e-02f, -7.86913335e-02f, -3.00909709e-02f, 6.92388862e-02f,
  6.56034797e-02f, 1.15008108e-01f, 1.99525263e-02f, 4.52238508e-02f, 5.20974398e-02f, -6.02447391e-02f, 2.91901566e-02f, -1.68012809e-02f, 3.69072668e-02f, 2.41195736e-03f,
  -5.76892868e-02f, -3.11781326e-03f, 5.17717339e-02f, -1.30679710e-02f, 4.79629785e-02f, 8.41594301e-03f, 1.76462624e-02f, 1.37849838e-01f, 2.15411186e-02f, -6.61294023e-03f,
  3.55390981e-02f, 4.45015840e-02f, 5.02871387e-02f, -4.66492847e-02f, -2.63997633e-02f, -5.57435956e-03f, -2.62271031e-03f, -1.78341679e-02f, -3.26436907e-02f, 4.47379705e-03f,
  -2.96053976e-01f, -1.36391833e-01f, 9.23892334e-02f, -1.03838347e-01f, -1.13085628e-01f, 8.79414100e-03f, -1.62777510e-02f, -1.85008630e-01f, -1.63258657e-01f, 6.16532080e-02f,
  1.64837819e-02f, -1.61454514e-01f, 2.10774347e-01f, 5.63036138e-03f, -1.13570616e-01f, 2.80105714e-02f, -9.72028375e-02f, -7.81207085e-02f, -2.14112154e-03f, 1.42986956e-03f,
  -3.71507518e-02f, 2.22907681e-02f, 1.37840463e-02f, -7.60763586e-02f, -9.41611752e-02f, -5.67468302e-03f, 1.22155875e-01f, 1.57366872e-01f, -6.40236065e-02f, 9.21763107e-03f,
  8.67576227e-02f, 7.73190260e-02f, -3.00616529e-02f, 3.46258357e-02f, 5.21057248e-02f, 6.48847893e-02f, 3.39121670e-02f, 1.52836675e-02f, -3.00256200e-02f, 2.37887520e-02f,
  -7.78532922e-02f, -9.54556912e-02f, -6.53707907e-02f, 1.12179741e-01f, -7.35466834e-03f, 5.46258949e-02f, -1.78085186e-03f, -7.23799616e-02f, -8.66194442e-02f, -6.03952855e-02f,
  -6.42546341e-02f, -8.52526948e-02f, 3.96280438e-02f, -4.45383862e-02f, -8.72127116e-02f, 3.84302884e-02f, -1.98889468e-02f, 6.91890568e-02f, -9.15541779e-03f, 2.69892719e-02f,
  -7.75504932e-02f, 1.06132124e-02f, 4.53118756e-02f, -7.20885620e-02f, 5.41419275e-02f, -7.48927798e-03f, 6.45897090e-02f, 1.25764851e-02f, 7.88297355e-02f, -9.10987146e-03f,
  -4.69106957e-02f, -3.59493867e-02f, -2.83758063e-02f, -4.31498848e-02f, 2.52849180e-02f, 5.77227212e-03f, -2.90895696e-03f, -4.17946950e-02f, 1.76194927e-03f, -6.74921349e-02f,
  6.48360327e-02f, -4.29935306e-02f, 4.86721955e-02f, 2.45279614e-02f, 2.06903759e-02f, 3.16079967e-02f, -5.20217326e-03f, 3.50280888e-02f, 4.10449170e-02f, 1.15973642e-02f,
  2.40702592e-02f, 5.56139126e-02f, 1.58111621e-02f, -2.36140639e-02f, 1.36556789e-01f, 2.31845938e-02f, 1.07534053e-02f, -1.27666593e-02f, 1.79919899e-02f, -4.94245365e-02f,
  -1.19990714e-01f, -4.20968607e-03f, 6.57995716e-02f, -2.87413113e-02f, -2.51737144e-02f, 6.71858415e-02f, 2.70615257e-02f, -1.24048099e-01f, -1.22132143e-02f, -7.05354214e-02f,
  1.94725171e-02f, -1.82035584e-02f, 9.56193209e-02f, -1.47779416e-02f, 4.50561047e-02f, -7.21183643e-02f, -4.11108769e-02f, 2.74886377e-02f, -2.31153835e-02f, -3.61157097e-02f,
  -9.67848375e-02f, 1.51735753e-01f, 1.86655700e-01f, 2.78101712e-02f, -1.01295620e-01f, -1.40802220e-01f, 1.88934188e-02f, 8.01625922e-02f, 2.28507742e-01f, -7.65307173e-02f,
  -6.11778572e-02f, 6.91413954e-02f, 1.11128092e-01f, -1.74508542e-01f, -2.79226184e-01f, 1.75025478e-01f, -8.17453042e-02f, 2.27248222e-02f, 2.59008110e-01f, -1.05116978e-01f,
  1.06196832e-02f, -2.84626395e-01f, -1.15282061e-02f, -2.91243680e-02f, -1.09907404e-01f, 1.38094991e-01f, -1.66334242e-01f, 1.50134310e-01f, -1.36983246e-01f, -1.13679633e-01f,
  -1.70488041e-02f, -1.60109196e-02f, -2.10901964e-02f, 1.06150582e-02f, -5.02882758e-03f, -4.70061861e-02f, -1.36578809e-02f, -2.10145563e-02f, 1.09073274e-01f, 5.05890064e-02f,
  -5.83184697e-02f, -2.14542244e-02f, -5.45700900e-02f, 3.29073742e-02f, 4.81630024e-03f, 2.60514002e-02f, 4.71666791e-02f, 2.94087920e-02f, 5.00301607e-02f, -4.16584648e-02f,
  -7.59814307e-02f, 6.47683395e-03f, -1.22859608e-03f, 8.28816206e-04f, -3.17908404e-03f, 1.71943661e-02f, -2.05538385e-02f, 5.44577651e-02f, -1.67902485e-02f, -1.35474512e-02f,
  -7.13087022e-02f, 3.06233037e-02f, -1.10862672e-01f, -7.51991794e-02f, 4.06019576e-03f, 6.79378118e-03f, -8.58912393e-02f, -6.76570162e-02f, -5.52932732e-02f, -1.15287319e-01f,
  -3.44444439e-02f, 8.93936157e-02f, 2.79048793e-02f, -1.60916373e-02f, -8.15388560e-02f, -1.02125637e-01f, -6.69343024e-02f, 3.88486907e-02f, -4.48267274e-02f, 3.69045921e-02f,
  -2.44400650e-02f, -7.03536943e-02f, 1.48239704e-02f, 2.14471631e-02f, -3.98659259e-02f, 2.35259701e-02f, -7.66153708e-02f, -1.42499404e-02f, 6.99070096e-02f, 3.13482480e-03f,
  1.08157620e-02f, 3.72691453e-02f, -6.85782963e-03f, 1.73715651e-02f, 2.52454318e-02f, -1.13237008e-01f, -1.49075994e-02f, -1.47622786e-02f, 7.05214515e-02f, -1.63977444e-02f,
  -1.03198051e-01f, 1.92252491e-02f, -7.13436725e-03f, 2.26664142e-05f, -1.86671391e-02f, -4.25684592e-03f, -7.86146447e-02f, -4.20277342e-02f, -4.53528278e-02f, 1.88241955e-02f,
  2.18088832e-02f, -5.47776185e-02f, -1.22151755e-01f, -3.46719660e-02f, 2.00440157e-02f, -1.33622822e-03f, -9.83877480e-03f, -2.79955938e-03f, -5.00382669e-02f, 3.40976566e-02f,
  3.06998909e-01f, -1.14823163e-01f, 6.73195720e-02f, 1.94516167e-01f, -9.87395495e-02f, -2.60056049e-01f, -1.27335727e-01f, -2.96205236e-03f, -8.26457366e-02f, -1.70852795e-01f,
  -1.33695945e-01f, -1.51936129e-01f, -1.32299662e-01f, -7.90368319e-02f, 1.46279827e-01f, -8.85224864e-02f, -7.42042065e-02f, -1.41323850e-01f, 2.90784072e-02f, -3.64560112e-02f,
  9.97295678e-02f, -4.04486097e-02f, 9.93882567e-02f, 8.05578232e-02f, -1.32813649e-02f, 7.01523349e-02f, 1.18992351e-01f, -2.45298259e-03f, 1.06433578e-01f, 4.32196595e-02f,
  -1.09037437e-01f, 6.58479258e-02f, 3.10537759e-02f, -2.00948585e-02f, -3.64384404e-03f, 1.55047774e-02f, 3.21276188e-02f, 9.01880935e-02f, 3.15113589e-02f, -3.19246612e-02f,
  -4.32861373e-02f, -5.43351471e-02f, 6.17451034e-02f, 3.41107883e-02f, -5.22875264e-02f, 8.99730623e-02f, -6.27850965e-02f, -5.60722463e-02f, -9.73702315e-03f, -9.63471532e-02f,
  1.13355415e-02f, -3.54906917e-02f, -5.73005676e-02f, 1.78081822e-02f, -5.43658845e-02f, -2.99950950e-02f, -3.49719226e-02f, 4.37378101e-02f, 1.42631540e-02f, 7.95580447e-02f,
  5.53344004e-02f, -5.36576696e-02f, -4.79393080e-02f, 7.17061386e-03f, -4.81469557e-02f, 2.49890927e-02f, -2.13395935e-02f, -7.81069249e-02f, 1.15805129e-02f, 1.93513297e-02f,
  -4.49101217e-02f, 7.02959020e-03f, -4.43238794e-04f, -6.01346940e-02f, 4.02602591e-02f, -4.26089093e-02f, -9.90605541e-03f, 4.68496559e-03f, 3.40934135e-02f, -6.40919432e-02f,
  -3.09467502e-02f, 3.88833345e-03f, 1.37333469e-02f, 4.74296324e-02f, 1.55025572e-02f, 5.28785959e-02f, -2.68592834e-02f, 1.83097888e-02f, -2.39650253e-02f, -9.72427651e-02f,
  -2.31183738e-01f, -1.60244048e-01f, 5.04210144e-02f, 4.70586605e-02f, 1.54694198e-02f, 7.08241714e-03f, 1.64467599e-02f, -9.44515616e-02f, -9.04968604e-02f, -6.29387200e-02f,
  4.58313748e-02f, 9.44739114e-03f, -6.50150627e-02f, 3.04700229e-02f, -2.94171758e-02f, -7.60013983e-02f, 1.51368813e-03f, 5.81044517e-02f, -2.77248509e-02f, 6.38163164e-02f,
  -6.83828257e-04f, -6.01667948e-02f, 2.54826937e-02f, -3.68827544e-02f, -1.46249100e-03f, 4.41639461e-02f, 1.38281938e-02f, -5.25340438e-03f, -3.96360233e-02f, 4.70040337e-04f,
  -3.92375350e-01f, 1.90455783e-02f, 9.12085399e-02f, -1.11916102e-01f, -6.49994239e-02f, -1.68357134e-01f, -1.85850337e-01f, 4.21992503e-03f, -9.05084535e-02f, 2.12670881e-02f,
  -8.44835863e-02f, 4.50278353e-03f, 1.12468757e-01f, -1.24851950e-01f, -2.72037625e-01f, 1.77113473e-01f, -2.15462908e-01f, -5.23812212e-02f, 4.00680788e-02f, -6.52911440e-02f,
  1.83801893e-02f, -9.16384682e-02f, 5.95369190e-02f, 1.20879561e-02f, 1.07188327e-02f, 1.74308401e-02f, 3.49976383e-02f, 1.41847596e-01f, -7.51011148e-02f, 2.81989630e-02f,
  -9.30226669e-02f, 4.95095327e-02f, -6.08556457e-02f, 7.87823051e-02f, -6.38000444e-02f, -3.62286605e-02f, 3.54597531e-02f, 3.00501250e-02f, 1.83808692e-02f, 9.66068208e-02f,
  -8.43487121e-03f, -3.32819670e-02f, 3.67865786e-02f, 4.41258624e-02f, -1.76969506e-02f, 1.14208341e-01f, 1.01977289e-02f, 4.53311503e-02f, 1.17721736e-01f, -4.47945930e-02f,
  5.85192218e-02f, -4.43912894e-02f, 4.00177613e-02f, 1.02926441e-01f, 4.26083431e-02f, 1.40334756e-04f, -2.21156273e-02f, 3.42578441e-02f, 7.00554550e-02f, 5.02569228e-02f,
  -9.66188535e-02f, 7.46405125e-02f, 1.04660287e-01f, -7.22191250e-03f, -8.77281651e-03f, 1.61611065e-02f, -2.43178923e-02f, -5.40246554e-02f, -1.45738749e-02f, -3.06379255e-02f,
  7.10806996e-03f, 4.49440267e-04f, 2.40780171e-02f, -9.24873278e-02f, -6.45593777e-02f, -3.38809676e-02f, -2.05793213e-02f, -1.10521307e-02f, 2.10789358e-03f, -3.26628983e-02f,
  5.38639650e-02f, -5.23769632e-02f, -7.35983718e-03f, 4.50755470e-02f, 5.23966365e-02f, -4.30968851e-02f, 6.64108619e-02f, 7.30892643e-04f, 7.87477344e-02f, -1.22181419e-03f,
  -1.22050685e-03f, 5.94012216e-02f, 7.15931207e-02f, 3.08403634e-02f, 8.19721259e-03f, 1.83167122e-02f, 7.99943879e-02f, -2.87477616e-02f, -1.06480112e-02f, -3.12667452e-02f,
  1.07244123e-03f, -4.64404151e-02f, 8.91521648e-02f, 6.86439574e-02f, -2.63511371e-02f, 8.65797251e-02f, 8.62352774e-02f, -4.79886495e-02f, 5.67510761e-02f, 7.55250826e-02f,
  4.27195132e-02f, -4.10729200e-02f, -1.09477462e-02f, -5.89310154e-02f, -7.22779483e-02f, -1.11731282e-02f, -4.25319709e-02f, 3.60872969e-02f, 8.37780759e-02f, 1.98081564e-02f,
  -1.69945523e-01f, 7.87212700e-02f, -1.43838778e-01f, -3.81092099e-03f, 1.42984793e-01f, -7.16046337e-03f, -1.56441286e-01f, 8.90976489e-02f, -1.87092856e-01f, 1.69174880e-01f,
  -6.74666539e-02f, -1.46647736e-01f, -2.27065176e-01f, -1.17958328e-02f, -1.69891596e-01f, -2.59467095e-01f, -7.82964099e-03f, 6.11040555e-02f, -1.13563426e-01f, 1.72378749e-01f,
  -8.75058696e-02f, 1.62162453e-01f, -6.83752745e-02f, 2.65568793e-01f, 1.09587222e-01f, 9.70282941e-04f, 2.16137961e-01f, 6.28520325e-02f, 9.45151374e-02f, 5.21033183e-02f,
  -7.83339664e-02f, -4.96053435e-02f, -2.50564367e-02f, -1.01360515e-01f, -1.55421821e-02f, 7.47600421e-02f, -2.10187007e-02f, -8.34342651e-03f, -6.60459250e-02f, -8.77167359e-02f,
  -2.43856329e-02f, -7.81437606e-02f, -1.42893018e-02f, -3.27529758e-02f, 2.26450473e-04f, -9.30136070e-02f, -1.43813118e-02f, 2.30944008e-02f, -2.25509536e-02f, -9.20579955e-03f,
  -7.67078772e-02f, 1.35742500e-02f, 2.76266877e-02f, -8.57203379e-02f, -3.32702547e-02f, -7.88108632e-02f, -5.04511409e-02f, 2.36032065e-02f, -7.29025304e-02f, -2.64403000e-02f,
  -6.82214200e-02f, 5.68025745e-02f, 1.45174980e-01f, -3.48690897e-02f, -4.16194126e-02f, 7.29118362e-02f, -2.26396341e-02f, -9.34723823e-04f, -4.35646363e-02f, 6.26439154e-02f,
  7.75930807e-02f, -3.44885923e-02f, 5.60306013e-02f, 7.48701468e-02f, 2.43720952e-02f, 1.24466661e-02f, -1.29246693e-02f, -2.47336808e-03f, -7.22515164e-03f, -8.27956796e-02f,
  -4.07521762e-02f, 7.91282654e-02f, 1.76231042e-02f, -2.86416104e-03f, -2.66553741e-02f, 3.77039351e-02f, -2.35426077e-03f, 7.08077848e-02f, 4.40145954e-02f, 8.16655681e-02f,
  4.08933945e-02f, 3.48540246e-02f, -6.24389620e-03f, -4.78997864e-02f, -1.31408693e-02f, 1.45894125e-01f, -8.75414070e-03f, 1.11628108e-01f, 8.09213333e-03f, 5.33821471e-02f,
  9.00368113e-03f, 1.38154887e-02f, 1.23061627e-01f, 1.99979171e-03f, -1.70805806e-03f, 4.05286439e-02f, -4.31401506e-02f, 3.60124372e-02f, 3.23589966e-02f, -2.10971106e-02f,
  -8.75827949e-03f, 3.14767808e-02f, -6.50974968e-03f, -2.70419195e-02f, -4.98515256e-02f, -3.97451129e-03f, -6.93753585e-02f, 4.35966551e-02f, 2.46875212e-02f, -2.09029634e-02f,
  4.17509556e-01f, -2.97442794e-01f, 2.35481992e-01f, -1.85741410e-02f, -5.43501601e-02f, -2.70222723e-01f, -1.50002092e-01f, 1.87844001e-02f, 2.63011288e-02f, -9.14594829e-02f,
  1.96568407e-02f, 8.56778473e-02f, 1.66453406e-01f, -8.00311267e-02f, 2.29745135e-01f, 4.26261537e-02f, -7.53343329e-02f, -3.48285548e-02f, -4.91650961e-02f, -4.92637008e-02f,
  4.23856713e-02f, -1.25595540e-01f, 1.72487423e-01f, -9.00686979e-02f, -2.77066492e-02f, -2.82773748e-02f, 6.41685575e-02f, -2.96238344e-02f, -7.10240453e-02f, -4.15781252e-02f,
  3.79033224e-03f, 3.46476912e-01f, 8.55587572e-02f, 1.07217647e-01f, 6.00512996e-02f, 6.10561296e-02f, 9.98190325e-03f, 1.66881382e-02f, 2.70643774e-02f, -2.70717535e-02f,
  3.35393101e-03f, 5.36208861e-02f, 4.57365587e-02f, -5.09046242e-02f, -7.86095411e-02f, -1.89397540e-02f, -7.10235387e-02f, -1.05967909e-01f, -2.43512709e-02f, 6.19650073e-02f,
  5.21407202e-02f, 2.42288560e-02f, -7.72632845e-03f, 1.80286076e-02f, 4.47572060e-02f, -2.05085091e-02f, 6.33080453e-02f, -3.72062512e-02f, -1.32801263e-02f, 4.24916968e-02f,
  -4.84712422e-02f, 2.17102971e-02f, -4.38718572e-02f, -5.57828099e-02f, 5.53372391e-02f, -1.55716203e-02f, -4.82612438e-02f, 3.81683446e-02f, 6.57698512e-02f, -4.95672226e-02f,
  1.90115366e-02f, -4.72336672e-02f, 5.46129085e-02f, 1.38480458e-02f, 2.25041881e-02f, -6.25921460e-03f, 2.10140310e-02f, 4.37326245e-02f, -4.79569193e-03f, 1.97073445e-02f,
  5.57759441e-02f, -1.86195355e-02f, -5.36177456e-02f, 9.98537987e-03f, -6.31279254e-04f, -4.48588561e-03f, 3.79231758e-02f, 1.09049305e-02f, 3.87264639e-02f, 3.28142871e-03f,
  -9.21510607e-02f, 1.15495309e-01f, 8.43447447e-02f, 1.18275899e-02f, 2.57845572e-03f, -6.12654090e-02f, 6.58526048e-02f, 8.19287356e-03f, 2.50131451e-02f, 1.66917220e-03f,
  8.52628518e-03f, -2.62558870e-02f, 4.90923133e-03f, -2.80013047e-02f, -1.03191510e-01f, 5.88033497e-02f, 4.65897210e-02f, -3.28334533e-02f, 4.72160317e-02f, 1.85510598e-03f,
  -7.39569813e-02f, -1.58799421e-02f, -5.26977442e-02f, 1.08562782e-02f, 3.82805429e-02f, 2.48371740e-04f, -6.58626063e-03f, 1.74992606e-02f, 5.99802993e-02f, -9.62718129e-02f,
  1.81810632e-01f, 3.64956111e-02f, 3.07033002e-01f, 1.81876153e-01f, 2.18309648e-02f, -1.77031636e-01f, -5.32287844e-02f, 1.12915136e-01f, 2.58874655e-01f, -1.31660864e-01f,
  -2.32319951e-01f, 1.90471411e-01f, -6.22704811e-02f, 5.77979423e-02f, 8.41130838e-02f, 4.52362299e-02f, 1.73929632e-02f, -1.95136145e-02f, 1.48350865e-01f, -6.12946749e-02f,
  -3.22717801e-02f, -1.83396563e-01f, 6.09677881e-02f, -1.17491864e-01f, -6.52774349e-02f, 2.89627407e-02f, -2.81800538e-01f, 5.47646135e-02f, -1.75188228e-01f, 1.26722399e-02f,
  -1.04639627e-01f, 1.49486437e-01f, -3.06822453e-02f, -4.87618819e-02f, -1.02049664e-01f, -8.01227614e-02f, 2.55088583e-02f, 2.57820264e-02f, 2.18474003e-03f, -7.53919184e-02f,
  -1.28928619e-02f, 6.92260638e-03f, 2.48367079e-02f, -1.09879766e-02f, 9.95162949e-02f, 9.30684095e-04f, 9.97012258e-02f, -9.63307265e-03f, 3.76211992e-03f, 3.01107038e-02f,
  2.36568004e-02f, 1.84346773e-02f, -1.13471951e-02f, -4.27862778e-02f, -1.90050919e-02f, 3.82146123e-03f, 7.50701353e-02f, 2.36324519e-02f, -5.37434369e-02f, 2.75354441e-02f,
  1.10540971e-01f, 1.13161087e-01f, -4.67246324e-02f, 1.05476184e-02f, 2.21567531e-03f, -1.05010390e-01f, -2.88741905e-02f, -8.98874030e-02f, 2.66211908e-02f, -3.56551595e-02f,
  -5.53954616e-02f, -1.03995865e-02f, 3.25152762e-02f, 7.48836920e-02f, 3.98489498e-02f, 5.92080653e-02f, -2.72983219e-02f, -4.05654684e-02f, 7.14422837e-02f, 4.09554876e-02f,
  3.70567441e-02f, 5.91513030e-02f, 6.72507584e-02f, -7.67798442e-03f, -4.74936031e-02f, -6.04883805e-02f, 4.33451086e-02f, 2.29143258e-02f, -3.97778489e-02f, -7.62328878e-02f,
  -1.64363980e-01f, -9.99689251e-02f, -5.82996011e-02f, -1.35008931e-01f, -8.86557102e-02f, -4.72451327e-03f, -1.03836134e-02f, 3.56889144e-02f, -6.56889519e-04f, 1.18082166e-02f,
  -6.43987581e-02f, -1.12301074e-01f, -2.35796273e-02f, 2.81729195e-02f, -1.98849086e-02f, -9.13108736e-02f, -6.99979365e-02f, -3.62483808e-03f, -1.23298362e-01f, -4.97551002e-02f,
  -7.79248402e-02f, -9.90389287e-02f, 4.21172045e-02f, 8.20434745e-03f, -6.00796267e-02f, -1.21476427e-02f, -2.59918664e-02f, 3.77954617e-02f, -5.16528785e-02f, 1.97701473e-02f,
  -5.90537786e-02f, 1.24858739e-03f, -1.46164134e-01f, 1.39496207e-01f, -2.22654901e-02f, -3.45241070e-01f, -2.67125547e-01f, 1.67208627e-01f, -1.75873116e-01f, 1.88011497e-01f,
  -1.05442442e-01f, -8.53152573e-03f, -1.34529993e-01f, -9.19502228e-02f, -3.23197931e-01f, -2.05590755e-01f, -1.45421505e-01f, -7.82400370e-03f, -7.64283314e-02f, 1.69623680e-02f,
  -4.41280231e-02f, 3.23543102e-02f, 2.19853595e-02f, 1.62594989e-01f, 1.54412746e-01f, 2.26501048e-01f, 2.75964975e-01f, -6.55864850e-02f, 2.12235495e-01f, -2.24853884e-02f,
  -9.09176171e-02f, -3.13257463e-02f, 2.11657397e-02f, -5.96773699e-02f, -4.32605334e-02f, -3.72796841e-02f, 2.92236097e-02f, 1.95153374e-02f, -5.84602505e-02f, 6.93093464e-02f,
  6.47468567e-02f, 2.75507830e-02f, 1.41465329e-02f, -3.80893387e-02f, -3.85877490e-02f, -5.09861903e-03f, 4.27732356e-02f, 1.61519204e-03f, 6.73440844e-02f, -6.95069060e-02f,
  9.56787728e-03f, -2.95276325e-02f, 2.72326414e-02f, -7.18301255e-03f, -3.97326760e-02f, -1.93821695e-02f, -1.16945975e-01f, 1.30901989e-02f, 1.14697243e-04f, 3.91120985e-02f,
  9.15092155e-02f, -4.88825180e-02f, 4.38481271e-02f, 1.28625751e-01f, -2.40774788e-02f, 6.66583562e-03f, 1.80490632e-02f, -3.26527767e-02f, -1.02450565e-01f, -1.58582516e-02f,
  -8.14622417e-02f, 1.74583644e-02f, -5.84680066e-02f, 1.91967040e-02f, 8.46444368e-02f, 1.19308345e-01f, 2.12060101e-02f, -7.64215551e-03f, -2.03339420e-02f, -1.06442787e-01f,
  1.02218278e-01f, -3.84449437e-02f, 3.61419725e-03f, 1.15402445e-01f, 2.14955658e-02f, 1.05506517e-02f, 5.37639521e-02f, -2.77867783e-02f, 4.77428883e-02f, -3.16372551e-02f,
  -3.32833305e-02f, 8.36132094e-02f, 1.90104023e-02f, -3.22410353e-02f, 5.36860190e-02f, 3.49984244e-02f, -5.35582118e-02f, 7.14905635e-02f, 1.17699858e-02f, -7.95929413e-03f,
  -1.15654722e-03f, -7.58271962e-02f, 6.69200495e-02f, -4.31280583e-02f, 3.35323699e-02f, -6.38945401e-02f, -5.56520447e-02f, -3.91401276e-02f, 1.17161825e-01f, 8.50297660e-02f,
  1.59682147e-02f, 2.65644398e-02f, 6.81911856e-02f, 1.25275299e-01f, -8.36183969e-03f, 1.33650927e-02f, 1.39211398e-02f, -1.59713384e-02f, -5.01512736e-03f, 3.47665623e-02f,
  -3.23472679e-01f, -7.60908052e-02f, 3.43384966e-02f, -1.17996208e-01f, -1.91663742e-01f, -1.82397086e-02f, 1.28785640e-01f, -3.20955426e-01f, -1.07423544e-01f, 3.91119160e-02f,
  -1.00340210e-01f, 7.54450411e-02f, 2.73409218e-01f, 3.20401751e-02f, 1.73143581e-01f, 2.02981427e-01f, -9.33904126e-02f, 5.57482988e-03f, -4.15705368e-02f, -1.28804907e-01f,
  -8.00063387e-02f, -1.62246272e-01f, 1.47062987e-01f, -1.91164970e-01f, -7.73530379e-02f, -1.06316701e-01f, 1.07137278e-01f, 8.72550011e-02f, -3.94531786e-02f, 5.47897927e-02f,
  -1.16512641e-01f, -1.55063137e-01f, 5.84064517e-03f, 3.56288366e-02f, -1.20942727e-01f, 7.38396123e-02f, -7.54296174e-03f, 1.81372494e-01f, 9.49197728e-03f, -1.40786674e-02f,
  4.98883761e-02f, 2.41582511e-05f, -9.43280905e-02f, 8.51485059e-02f, -2.16939338e-02f, -3.56347822e-02f, 5.08815423e-02f, 8.79291631e-03f, -5.61633240e-03f, 1.00012077e-02f,
  4.41247113e-02f, -4.96915244e-02f, 8.62749070e-02f, 5.66060375e-03f, 1.80547144e-02f, -6.95175081e-02f, 6.13244697e-02f, 4.30752747e-02f, -3.77621315e-02f, -3.03271450e-02f,
  -3.08404006e-02f, -8.79434310e-03f, 9.91909429e-02f, -3.03689041e-03f, -6.54298067e-02f, 1.11194979e-03f, 5.08985743e-02f, 1.27562895e-01f, -4.12987918e-02f, -1.62013639e-02f,
  -6.23982251e-02f, 1.79704744e-02f, -5.92455221e-03f, 5.62850237e-02f, -8.51841457e-03f, 6.26934459e-03f, 6.86125038e-03f, 1.50748026e-02f, -2.32533328e-02f, -2.93126162e-02f,
  -3.10286358e-02f, -5.09798899e-02f, -3.33618410e-02f, -4.39857878e-02f, -2.45058760e-02f, 1.62450932e-02f, 2.51076315e-02f, -3.00198607e-02f, -1.18929464e-02f, 1.10143954e-02f,
  -1.22475468e-01f, -2.51655012e-01f, -1.53413946e-02f, 2.19616434e-03f, 4.02982756e-02f, 7.10797682e-02f, 6.60355911e-02f, -2.61543854e-03f, 8.68624263e-03f, -9.47628841e-02f,
  -6.24777265e-02f, 1.54898001e-03f, -1.37057826e-01f, 4.48622517e-02f, -1.45253874e-02f, -1.94856916e-02f, -2.94330232e-02f, -2.85752900e-02f, 1.30796097e-02f, -3.96297220e-03f,
  1.99656840e-02f, -2.65976936e-02f, 2.60823872e-02f, -5.43934703e-02f, -1.32333850e-02f, -4.53120358e-02f, -9.91009623e-02f, -7.76725775e-03f, 2.96737533e-02f, 1.17020614e-01f,
  -6.46083504e-02f, -2.58420736e-01f, 1.54978216e-01f, -1.46725371e-01f, 2.15548053e-01f, 1.29549325e-01f, -3.53530496e-02f, -3.53406742e-02f, -1.55385450e-01f, -4.09635961e-01f,
  -6.77122325e-02f, -1.63740553e-02f, -6.35500699e-02f, -5.76920249e-02f, 3.75780046e-01f, 1.90555081e-01f, 1.10665401e-02f, -1.18896298e-01f, 1.09112188e-01f, -9.72508341e-02f,
  1.14019595e-01f, -5.55801578e-02f, 2.80958503e-01f, 1.33292452e-01f, -6.79366365e-02f, -1.37399673e-01f, 3.02108843e-02f, 1.77396283e-01f, -1.96417677e-03f, 1.17126457e-01f,
  -3.58900800e-02f, -1.57858610e-01f, 9.89457872e-03f, 9.43040103e-02f, -2.59686150e-02f, 2.89050415e-02f, 8.35707188e-02f, -3.04559264e-02f, -1.34900270e-03f, -3.83420028e-02f,
  -2.96110138e-02f, -5.70695437e-02f, 7.58763626e-02f, 3.58574875e-02f, -8.70931745e-02f, -1.83526017e-02f, -7.00556859e-02f, 1.79173145e-02f, 9.01048109e-02f, 5.84436022e-02f,
  -7.26558790e-02f, -3.24986167e-02f, 2.25032140e-02f, 3.13244462e-02f, 1.36473715e-01f, -1.21710539e-01f, 6.27155155e-02f, 1.42345726e-01f, -8.42406154e-02f, -5.06532937e-02f,
  1.37840778e-01f, 7.84231499e-02f, 2.56021284e-02f, 2.73499321e-02f, -6.07667416e-02f, 3.07505950e-02f, -6.72315583e-02f, 6.07999451e-02f, -5.17378785e-02f, 1.56712737e-02f,
  -2.90436298e-03f, -7.32481033e-02f, 8.33741501e-02f, -7.07549751e-02f, -8.93537775e-02f, -4.21540998e-02f, 2.95487773e-02f, 9.27108433e-03f, -5.87051362e-02f, -1.44566754e-02f,
  -4.56718262e-03f, -2.08134800e-02f, -1.30481586e-01f, 2.89064497e-02f, -2.29648370e-02f, -3.49352248e-02f, -1.00621305e-01f, -4.04989719e-02f, 1.02601163e-01f, 6.26847446e-02f,
  -2.72226632e-01f, -1.10630654e-01f, -7.37105608e-02f, -4.84408475e-02f, 2.02279743e-02f, -3.22771445e-02f, 1.45833626e-01f, -3.55376378e-02f, 1.33913551e-02f, -2.89859576e-03f,
  2.71716341e-02f, -6.08343706e-02f, -2.03316733e-02f, -6.18663989e-03f, -1.72053017e-02f, -4.63461354e-02f, -4.46323380e-02f, 1.85240675e-02f, -5.75602874e-02f, 3.63182771e-04f,
  3.74701507e-02f, 1.32537205e-02f, -4.49307822e-02f, 5.91237377e-03f, 8.98459852e-02f, -3.10512874e-02f, 4.82564270e-02f, 4.69971709e-02f, 5.19985631e-02f, 1.36682196e-02f,
  4.32846695e-03f, 8.88577029e-02f, -1.72170117e-01f, 1.13055862e-01f, -1.54436231e-01f, 1.15660820e-02f, 7.64985830e-02f, 1.16385885e-01f, 1.43107176e-01f, 1.40354872e-01f,
  1.37763634e-01f, -9.69006047e-02f, 1.32925138e-02f, 1.75660521e-01f, 2.40976393e-01f, 1.52903304e-01f, 2.12614372e-01f, 1.27545863e-01f, -4.15869467e-02f, 8.88741910e-02f,
  1.16337620e-01f, 1.31752297e-01f, -1.56120807e-01f, -9.98283625e-02f, -8.99446309e-02f, -1.55922443e-01f, 9.00342017e-02f, -2.02593625e-01f, -1.04255892e-01f, -3.38057466e-02f,
  7.73520842e-02f, 8.70687589e-02f, -3.16575281e-02f, 3.35182971e-03f, 2.13802428e-04f, -1.10541340e-02f, 5.23435958e-02f, -8.01893547e-02f, 1.70139782e-02f, -1.26757219e-01f,
  2.00577192e-02f, -9.73552093e-02f, -2.43407814e-03f, -1.01925872e-01f, -3.09415851e-02f, -8.76587033e-02f, 2.41453084e-03f, -6.44892156e-02f, -7.24067464e-02f, -6.68567419e-02f,
  -1.05489388e-01f, -2.31922660e-02f, -1.17030600e-03f, -5.98811917e-03f, -1.68018267e-02f, 3.35200503e-02f, -2.26637051e-02f, -1.04442231e-01f, -2.63789669e-02f, -4.47537843e-03f,
  -2.54134238e-02f, 1.49967358e-01f, -8.18792805e-02f, -7.87340626e-02f, 1.10456301e-02f, 1.77240707e-02f, -1.18173368e-01f, 5.27999587e-02f, -8.38164538e-02f, -7.14459410e-03f,
  9.93120223e-02f, -8.97818133e-02f, 9.64657888e-02f, -7.01343343e-02f, -2.78786942e-02f, 5.63831851e-02f, 1.54399108e-02f, -2.01921239e-02f, 6.04386628e-02f, -3.03078108e-02f,
  8.73030871e-02f, 1.88698936e-02f, 4.63436991e-02f, -9.86890346e-02f, -4.47637551e-02f, -4.14397456e-02f, -3.77011322e-03f, -1.23330988e-01f, 1.43172331e-02f, -4.33148295e-02f,
  2.09831119e-01f, 3.41596693e-01f, 4.36870605e-02f, -8.17566589e-02f, 4.55694683e-02f, -9.24113952e-03f, -2.32880432e-02f, -5.22818323e-03f, 3.35001051e-02f, -5.79128899e-02f,
  9.84951481e-03f, -5.70897423e-02f, 9.62803364e-02f, -6.99779242e-02f, 6.45502880e-02f, 6.03609271e-02f, 1.16492994e-01f, 3.30116674e-02f, 7.92224929e-02f, 8.31652433e-03f,
  1.40861915e-02f, 4.14882414e-02f, -6.49313405e-02f, -2.52152849e-02f, -3.27155041e-03f, -2.17299536e-02f, -7.58262957e-03f, 6.52772840e-03f, -8.94830152e-02f, 1.00446634e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.29951933e-01f, -2.43386254e-01f, -4.44399454e-02f, 5.78317186e-03f, -7.25867748e-02f, -1.82828873e-01f, -2.56374508e-01f, -1.50394514e-01f, -1.30528063e-01f, -2.04594657e-01f,
  -7.07266331e-02f, 1.05143338e-01f, 1.39930055e-01f, -5.27231954e-02f, 1.26653224e-01f, 1.50068268e-01f, 4.14668992e-02f, 3.14243361e-02f, 1.17105208e-01f, -2.45960690e-02f,
  1.48124933e-01f, 1.36087254e-01f, 3.60843509e-01f, -1.98846241e-03f, -4.33294065e-02f, 2.15496704e-01f, 2.32629567e-01f, 5.73024675e-02f, 3.87934148e-02f, -3.25556919e-02f,
  -9.27162990e-02f, 2.23837495e-02f, 3.32728438e-02f, -1.34092541e-02f, -1.22376624e-03f, -8.26289356e-02f, 4.87946905e-02f, 5.83214499e-02f, 7.11753815e-02f, 1.20462231e-01f,
  -1.25544190e-01f, 1.31622609e-02f, -1.61267221e-02f, -5.33868186e-03f, -8.17530006e-02f, -1.58287922e-03f, 1.01934098e-01f, 6.12425432e-02f, 6.28268942e-02f, -1.18006989e-02f,
  -2.49471236e-02f, 5.03202118e-02f, -1.40085781e-03f, 4.92899865e-02f, 1.96316931e-02f, -1.54634148e-01f, -7.00278133e-02f, 7.46404845e-03f, -4.49207015e-02f, -1.72635317e-01f,
  -1.74997523e-01f, -1.82938576e-02f, 2.54857503e-02f, 1.72326267e-02f, 5.23673147e-02f, 1.35831244e-03f, -1.37932533e-02f, 1.80633236e-02f, -8.39713216e-03f, 4.87862229e-02f,
  2.92675328e-02f, 9.64036807e-02f, 3.67402844e-02f, -9.47489440e-02f, -4.60851118e-02f, 4.88036573e-02f, 1.69674128e-01f, -2.25058887e-02f, -7.75392279e-02f, 6.34072069e-03f,
  5.51663265e-02f, 4.97297272e-02f, -4.09658104e-02f, 1.68681983e-02f, -1.60786081e-02f, 8.24014544e-02f, 4.46227454e-02f, -3.77173610e-02f, 9.85135064e-02f, 2.21133064e-02f,
  -6.51291087e-02f, 7.18683079e-02f, -5.74282184e-02f, -2.18041651e-02f, 1.48924947e-01f, -3.87424529e-02f, 1.19351801e-02f, 5.81038371e-03f, 1.92088056e-02f, -6.45301938e-02f,
  5.89341111e-02f, -1.02411047e-01f, 2.82208081e-02f, -3.99617245e-03f, 1.16104908e-01f, -1.92101002e-02f, 2.29049008e-02f, 2.26083212e-02f, 7.53215402e-02f, -1.96009334e-02f,
  9.73307621e-03f, 7.13900924e-02f, 2.63390150e-02f, -5.73610980e-03f, -1.14990115e-01f, -1.79622713e-02f, -7.14751929e-02f, -7.86845982e-02f, 2.37570051e-02f, -1.39117151e-01f,
  -2.46854722e-01f, 1.11082174e-01f, -9.42019299e-02f, 1.01904958e-01f, -1.51496781e-02f, 3.02217543e-01f, 2.89358109e-01f, 2.18586493e-02f, 4.98542897e-02f, 1.75589740e-01f,
  2.18850225e-01f, 1.34769278e-02f, 1.61551446e-01f, 2.43214011e-01f, 2.17674166e-01f, 1.79453745e-01f, 1.83452025e-01f, 7.60076046e-02f, 6.28163964e-02f, -3.43680754e-02f,
  -6.50098398e-02f, 5.51635623e-02f, 2.82334294e-02f, -1.54349044e-01f, 1.79108127e-03f, -1.87923223e-01f, -7.95733482e-02f, -8.83292481e-02f, 1.27423480e-01f, 1.23691812e-01f,
  4.66026412e-03f, -1.54679835e-01f, -8.62904936e-02f, -6.24818821e-03f, -4.37816838e-03f, -9.36575085e-02f, -4.62282486e-02f, 2.98101548e-02f, -6.63331300e-02f, 5.01408502e-02f,
  -3.75311598e-02f, -5.17414510e-02f, 3.10915150e-02f, -1.52624659e-02f, 2.44164634e-02f, 8.19096044e-02f, 4.11771797e-02f, -9.17098299e-03f, -1.25695486e-02f, 3.38787548e-02f,
  5.20555340e-02f, -5.40324524e-02f, 6.53975084e-02f, 7.85893425e-02f, 9.14762095e-02f, 8.10608938e-02f, 2.11520325e-02f, 2.66616400e-02f, 8.34997520e-02f, 3.98324765e-02f,
  7.16921017e-02f, -6.47173077e-02f, -9.36238691e-02f, 4.96601593e-03f, -4.99820262e-02f, -5.08092865e-02f, -4.47619054e-03f, -4.67608161e-02f, 7.36526176e-02f, -9.20953155e-02f,
  -1.13488231e-02f, 2.55083330e-02f, 4.72289808e-02f, -4.11744841e-05f, 5.00994921e-02f, 1.06461704e-01f, 7.66106416e-04f, -3.67646702e-02f, -4.62332740e-02f, -6.86713308e-02f,
  -8.11439455e-02f, 6.96940441e-03f, -4.19533662e-02f, -5.18765338e-02f, 1.87421843e-04f, 4.76045310e-02f, -4.36999314e-02f, 7.87930191e-02f, -3.04155126e-02f, 6.48573563e-02f,
  1.63586318e-01f, -6.95669279e-02f, 7.88595602e-02f, 1.29607376e-02f, -3.71553488e-02f, -9.68246758e-02f, 1.32907629e-02f, 3.47216800e-02f, -1.89947356e-02f, -2.58272886e-02f,
  -1.15922056e-02f, 2.54942477e-02f, -2.43474338e-02f, 4.82083410e-02f, 8.93923715e-02f, 2.73392219e-02f, -2.17744778e-03f, 3.80805545e-02f, -1.41361477e-02f, -1.98717341e-02f,
  -2.85504712e-03f, 3.54058072e-02f, 8.89917612e-02f, -3.44994036e-03f, 7.30010271e-02f, -6.53308481e-02f, -5.23763336e-02f, -3.57044558e-03f, 6.39706329e-02f, 2.39052251e-02f,
  -3.23193930e-02f, 1.65747985e-01f, 1.40755922e-01f, -9.69711915e-02f, -4.96598072e-02f, -1.85670197e-01f, -6.16436899e-02f, -7.17559159e-02f, 1.60068393e-01f, -5.81813753e-02f,
  -2.05855757e-01f, 2.85638392e-01f, -2.42866818e-02f, -1.70607418e-01f, -4.21431400e-02f, 4.24123518e-02f, -1.94248363e-01f, -1.19850999e-02f, 1.34672478e-01f, -1.80438653e-01f,
  -4.35012765e-02f, -2.67132163e-01f, -1.36162683e-01f, -1.97981924e-01f, -1.51064873e-01f, -3.01680695e-02f, -8.78221095e-02f, 1.06548890e-02f, -7.42171928e-02f, 6.38693944e-02f,
  6.91855401e-02f, 1.27757981e-01f, 6.37653694e-02f, 3.26083302e-02f, -9.90664437e-02f, -1.26497656e-01f, -6.09449223e-02f, -2.70246025e-02f, 1.60674416e-02f, -7.60292336e-02f,
  -6.79009110e-02f, -1.25670254e-01f, 9.87533629e-02f, -3.33351060e-03f, 2.97331577e-03f, 9.26228762e-02f, 5.70087321e-02f, 3.86459269e-02f, -8.18805012e-04f, -6.61596879e-02f,
  6.50390461e-02f, -7.02733248e-02f, -8.17961767e-02f, -3.13273557e-02f, 3.24434135e-03f, 8.10008217e-03f, 1.69698913e-02f, -1.17690518e-01f, 4.81822006e-02f, 3.07351053e-02f,
  8.99316743e-02f, -2.93593388e-02f, 8.16130266e-03f, -1.26545593e-01f, -3.55160944e-02f, 8.76670256e-02f, -5.85416406e-02f, -7.64699792e-03f, 8.10903832e-02f, -2.58571319e-02f,
  -3.63925137e-02f, -2.74207331e-02f, -1.88518560e-03f, -1.62570253e-01f, 3.39229852e-02f, 9.01492983e-02f, 6.69469312e-02f, -6.74997717e-02f, 1.78831499e-02f, 3.86724956e-02f,
  1.03234440e-01f, 1.41246980e-02f, -1.43664882e-01f, -1.44257352e-01f, -5.67203648e-02f, -2.35139448e-02f, 1.16833849e-02f, 1.94611930e-04f, 1.25904949e-02f, -3.21428594e-03f,
  2.54968405e-02f, 2.30919160e-02f, 4.76617664e-02f, 3.00417445e-03f, -1.02587445e-02f, -2.05565859e-02f, -1.42732915e-02f, -1.16110638e-01f, 7.78808370e-02f, -6.08935840e-02f,
  -1.45887032e-01f, -7.98586830e-02f, 4.39198986e-02f, -7.76036307e-02f, -3.14897448e-02f, -1.15718609e-02f, -3.98425162e-02f, 6.61551580e-02f, 2.81573385e-02f, -2.87132040e-02f,
  -1.48313716e-01f, 4.78629172e-02f, 3.28709558e-02f, -8.67771059e-02f, -3.31928357e-02f, -3.08603456e-04f, 1.89895891e-02f, -5.81576638e-02f, -2.90134605e-02f, 1.94148812e-02f,
  -4.51035678e-01f, 1.72545183e-02f, -1.93320915e-01f, -1.43298000e-01f, -1.56825915e-01f, -9.51137692e-02f, -5.88769279e-02f, -1.29444748e-01f, 2.04465892e-02f, 1.49927124e-01f,
  -3.44402418e-02f, -1.65522516e-01f, 1.19090930e-01f, 1.20298304e-01f, -1.03767209e-01f, 2.51447022e-01f, -3.33574004e-02f, -3.29824686e-02f, 8.55699107e-02f, -7.60803372e-02f,
  1.28882118e-02f, 9.03215855e-02f, 1.55457020e-01f, 2.16885414e-02f, -1.13510378e-01f, -7.33774900e-02f, 2.52478477e-02f, -7.71566182e-02f, -5.29721454e-02f, -2.05778733e-01f,
  -1.49599314e-01f, -1.91591278e-01f, -1.80360377e-01f, -1.44016929e-04f, -1.56562477e-01f, -2.74721049e-02f, -8.17036331e-02f, -3.29888128e-02f, 4.63718170e-04f, -2.36161463e-02f,
  3.50097865e-02f, -2.25291420e-02f, -7.74557441e-02f, -2.00124793e-02f, -6.79076910e-02f, -9.67686921e-02f, -7.55252177e-03f, -3.95394862e-02f, 7.72799179e-02f, 2.87957629e-03f,
  -7.04614297e-02f, -5.98941594e-02f, -1.49303135e-02f, 4.27221730e-02f, 1.44472877e-02f, -2.81296261e-02f, 2.68257712e-03f, 3.47565971e-02f, -9.82206762e-02f, -7.60191306e-02f,
  4.28619049e-02f, 5.08426176e-03f, 1.77154634e-02f, 6.20299857e-03f, 7.36390846e-03f, -7.88851380e-02f, 4.31247763e-02f, 3.78651842e-02f, 2.59770900e-02f, 7.34533146e-02f,
  -4.36752848e-02f, -8.07674453e-02f, -2.67061647e-02f, 1.19168073e-01f, 3.21296081e-02f, 4.92325537e-02f, 5.56177348e-02f, -2.71324422e-02f, 1.24487564e-01f, -7.33139887e-02f,
  6.46871375e-03f, -9.36736315e-02f, 5.96121419e-03f, 4.58091870e-02f, -1.73543505e-02f, 2.06257659e-03f, -5.78180738e-02f, 4.41280630e-04f, -1.88628100e-02f, -5.52945882e-02f,
  -2.73454100e-01f, -3.34093690e-01f, -2.19014995e-02f, -8.99242833e-02f, -4.31975909e-02f, -9.49058309e-02f, 4.88879830e-02f, -6.03945414e-03f, -8.35963860e-02f, -1.29719198e-01f,
  -8.23329836e-02f, 2.72063655e-03f, -7.35772029e-03f, 6.96896389e-02f, -2.98788864e-02f, -4.46920842e-03f, -3.56323794e-02f, -4.16819996e-04f, 1.14010130e-04f, -8.14796090e-02f,
  -1.95175409e-02f, -6.08839616e-02f, 8.39425176e-02f, 3.21207531e-02f, 7.14796707e-02f, 9.29841958e-03f, -2.48323251e-02f, -3.59525648e-03f, -7.79326931e-02f, -4.41814102e-02f,
  1.50985733e-01f, -6.35515749e-02f, 8.68357867e-02f, 2.63295680e-01f, 2.45105345e-02f, -2.79332012e-01f, -1.72426149e-01f, 1.19940199e-01f, 6.47399426e-02f, -9.68299657e-02f,
  -1.83555763e-02f, 3.16708125e-02f, -7.30572045e-02f, 2.25684866e-01f, 1.05604462e-01f, -1.43767461e-01f, 1.03593595e-01f, 4.71472107e-02f, 9.70501918e-03f, 1.22621149e-01f,
  1.44462049e-01f, 4.86270823e-02f, 1.75756916e-01f, 6.12084791e-02f, 5.96086085e-02f, 1.65980086e-01f, 1.86543941e-01f, 1.46310348e-02f, 1.50488824e-01f, -1.93818361e-02f,
  -4.39086668e-02f, 4.21933644e-02f, -4.09345217e-02f, -9.93138775e-02f, -2.26455498e-02f, -5.04953265e-02f, -3.09318900e-02f, 2.54912004e-02f, 6.27713278e-03f, 1.98864657e-02f,
  1.32970512e-02f, 8.64397734e-02f, 4.23654877e-02f, 4.89470623e-02f, -1.21134135e-03f, 8.18434288e-04f, 8.01651329e-02f, 6.16506860e-02f, -1.55791827e-02f, 3.18443030e-02f,
  -4.45738574e-03f, 1.87108666e-01f, -1.14194211e-02f, -1.76394470e-02f, 1.07642055e-01f, 1.85211990e-02f, -6.73751161e-02f, 9.22266990e-02f, -9.29846242e-02f, -8.51833168e-03f,
  -9.08130482e-02f, -9.30963978e-02f, -6.28103390e-02f, 4.97074574e-02f, -1.20918676e-01f, -1.35965168e-01f, 1.24804027e-01f, -2.01773029e-02f, -2.00003870e-02f, -6.90485165e-02f,
  2.30770446e-02f, 1.86708476e-02f, -3.64475138e-02f, 1.84756320e-03f, -7.44725317e-02f, -3.91770490e-02f, 5.82648255e-03f, 2.60860715e-02f, -3.49090137e-02f, 4.58351411e-02f,
  -7.96180591e-02f, 7.17647225e-02f, 2.26661307e-03f, 8.39344133e-03f, -4.25846502e-03f, 1.11319900e-01f, 1.15424553e-02f, -7.13419542e-02f, -2.30716169e-02f, -9.14357603e-02f,
  -2.03157485e-01f, 8.43056887e-02f, 2.99043115e-02f, 2.51940265e-02f, -8.01333487e-02f, -7.13132694e-03f, -3.21925096e-02f, 2.13737357e-02f, -7.10741896e-03f, -7.06949160e-02f,
  4.45570908e-02f, -1.27311081e-01f, -6.73053935e-02f, 3.41629758e-02f, -3.86149921e-02f, 3.56802531e-02f, 1.14600332e-02f, -8.56521353e-02f, -8.27872485e-04f, 1.76955894e-01f,
  3.43347341e-03f, -1.10593908e-01f, 3.85035090e-02f, 1.00722238e-02f, 6.78686872e-02f, -1.54879997e-02f, 1.32159039e-01f, 1.04866505e-01f, 8.15626457e-02f, 1.89024839e-03f,
  1.85669154e-01f, -2.75521696e-01f, 1.75302610e-01f, 7.15872273e-02f, 2.50737906e-01f, 1.28599152e-01f, 1.84868097e-01f, 6.67434409e-02f, 5.03811613e-02f, -2.75918692e-01f,
  -1.11003868e-01f, -6.19394667e-02f, -2.38333438e-02f, -1.65326178e-01f, 9.74461511e-02f, 5.31910881e-02f, 3.19352299e-02f, -9.75421816e-02f, 3.60515639e-02f, -5.45480326e-02f,
  2.38036271e-02f, -1.25076413e-01f, 1.28167823e-01f, -1.13090552e-01f, 4.71410565e-02f, -3.98667157e-02f, -7.79853761e-02f, 7.81823918e-02f, -1.40979394e-01f, 8.07412565e-02f,
  -1.02526806e-01f, -2.17956491e-02f, -8.00934136e-02f, -5.01191877e-02f, -1.44911423e-01f, -3.01606692e-02f, -9.03725773e-02f, 1.10328473e-01f, -1.19967025e-03f, 3.99046987e-02f,
  -9.48622748e-02f, -2.78955195e-02f, 9.44200810e-03f, 1.55687667e-02f, -4.20700274e-02f, 1.26428707e-02f, 5.42179495e-02f, -2.05864646e-02f, -4.13323864e-02f, 7.47670978e-02f,
  4.03538682e-02f, -2.71613672e-02f, -1.47717357e-01f, -1.18893638e-01f, -4.67982925e-02f, 1.15533456e-01f, -5.79911545e-02f, 8.85941684e-02f, -3.52097265e-02f, -1.13987494e-02f,
  3.38950716e-02f, 3.14386263e-02f, 1.30084557e-02f, 5.30965553e-05f, 3.49618867e-02f, 1.65168308e-02f, -5.85187972e-02f, 5.37565798e-02f, -7.80812502e-02f, 6.40409961e-02f,
  -2.74809506e-02f, 3.65793668e-02f, 2.27955449e-02f, 4.54606898e-02f, 1.75370947e-02f, -2.67139431e-02f, -2.62649283e-02f, -6.53697550e-02f, 9.95131768e-03f, -3.99379060e-03f,
  -4.02611084e-02f, 3.99893485e-02f, 4.89878394e-02f, 1.46593288e-01f, -6.84561431e-02f, 5.02445959e-02f, -6.42850548e-02f, -2.79516522e-02f, -2.42311116e-02f, -9.83884372e-03f,
  -3.33761632e-01f, -1.15970403e-01f, -5.30186035e-02f, -1.03431292e-01f, -6.77221492e-02f, -2.80616432e-02f, -4.90509458e-02f, -3.85177061e-02f, -1.65670794e-02f, 6.58018067e-02f,
  -4.29957919e-02f, -1.70279872e-02f, -1.98969175e-03f, 5.46544828e-02f, -3.91471982e-02f, -6.69052824e-02f, -4.31331135e-02f, -8.27136561e-02f, -6.01431169e-02f, 2.96226460e-02f,
  -5.24952542e-03f, -9.69416648e-02f, -6.26177201e-03f, -1.26598738e-02f, -8.04636851e-02f, 9.84911025e-02f, 2.97505385e-03f, 3.01841050e-02f, 1.07589839e-02f, -3.13680395e-02f,
  9.19860825e-02f, -1.32068187e-01f, -1.84992954e-01f, 1.46116927e-01f, 2.88137253e-02f, 8.85110870e-02f, -7.14582950e-02f, 8.40487555e-02f, -7.50973374e-02f, 3.02493982e-02f,
  1.25420153e-01f, -4.18828577e-02f, -1.69628456e-01f, 2.31726408e-01f, 2.69976258e-01f, 1.44002866e-02f, 1.34557277e-01f, 6.96772635e-02f, 8.03483650e-02f, 4.34170179e-02f,
  1.22329354e-01f, 2.91037917e-01f, -6.30775094e-03f, 1.19975984e-01f, 5.51162958e-02f, -7.65477940e-02f, -2.87047420e-02f, -1.40004635e-01f, 2.23635063e-01f, 1.35376453e-01f,
  5.51640764e-02f, 3.99255343e-02f, -2.85797250e-02f, -2.05925759e-02f, -1.55771878e-02f, -3.37639973e-02f, -1.22994743e-01f, 2.72214934e-02f, 3.29134539e-02f, 5.27097359e-02f,
  -4.63027060e-02f, 1.84577424e-02f, 9.92945135e-02f, 1.42486049e-02f, 1.16016008e-02f, 2.99460720e-02f, 1.14133945e-02f, 3.16668749e-02f, -8.20442215e-02f, 2.80518569e-02f,
  4.66761878e-03f, 6.66859746e-02f, -3.43141556e-02f, -2.21627653e-02f, 1.00697838e-01f, 7.15290383e-02f, -9.34324116e-02f, -6.19620718e-02f, -1.16548203e-02f, -4.57350025e-03f,
  2.75792386e-02f, -2.47180536e-02f, -6.44852519e-02f, 2.56513786e-02f, -1.14428513e-02f, -1.48994359e-03f, 1.24166407e-01f, -3.03401556e-02f, -7.94049874e-02f, -8.80583674e-02f,
  1.79502480e-02f, 3.27278078e-02f, 4.83146794e-02f, 1.75902378e-02f, 6.01580441e-02f, 2.74461601e-02f, 2.00129189e-02f, 3.01847793e-02f, -5.49676269e-02f, -1.51556209e-01f,
  -7.62076443e-03f, 1.61903799e-02f, -4.72129695e-02f, -9.06697512e-02f, 4.82292920e-02f, -1.10366985e-01f, 8.44270438e-02f, -9.02878772e-03f, -3.24273519e-02f, -5.38205467e-02f,
  1.75767411e-02f, -6.27067639e-04f, -1.46786710e-02f, 2.29615457e-02f, -1.11985520e-01f, -1.08723780e-02f, -1.75549723e-02f, 1.12217307e-01f, -2.94701029e-02f, 2.43618041e-02f,
  8.49017277e-02f, -5.11681587e-02f, -3.46238054e-02f, 1.12083502e-01f, 8.73903930e-02f, 6.80935429e-03f, 8.52506980e-03f, 3.25147100e-02f, 1.25141405e-02f, 6.20321743e-02f,
  2.20993953e-03f, 1.32687008e-02f, -4.85152341e-02f, -2.54053976e-02f, 6.41318932e-02f, -4.49838378e-02f, -4.51401435e-03f, -2.50225309e-02f, 1.63583849e-02f, 6.04439266e-02f,
  4.83737588e-02f, -5.66094853e-02f, -1.86519146e-01f, 8.66519138e-02f, 4.21169735e-02f, 4.08617929e-02f, -2.45757457e-02f, -4.64627668e-02f, -1.13721341e-01f, 1.01723701e-01f,
  1.22164525e-01f, -8.09925422e-02f, -2.59371866e-02f, 2.02708676e-01f, 1.29106447e-01f, 1.42537768e-03f, 8.69048163e-02f, 7.55261555e-02f, -7.62261972e-02f, 9.40001979e-02f,
  6.66897558e-03f, 2.34781206e-01f, 4.42742966e-02f, 1.22157119e-01f, 1.33276861e-02f, -1.19940624e-01f, 2.47917175e-02f, -6.57882690e-02f, 4.64236774e-02f, 9.85124856e-02f,
  9.05988142e-02f, 1.64139513e-02f, -2.35522911e-02f, 3.05575002e-02f, 6.96111768e-02f, 4.32635956e-02f, 3.32113728e-02f, -1.57044485e-01f, -4.74850461e-02f, 2.20524557e-02f,
  -5.58613427e-02f, 2.75491849e-02f, -6.51604608e-02f, -7.96886813e-03f, -4.48701568e-02f, -7.62543753e-02f, -2.21191589e-02f, 5.86005338e-02f, -1.09351454e-02f, 7.27280155e-02f,
  -1.22960210e-01f, -2.43603364e-02f, -3.53154913e-02f, -8.40320960e-02f, -6.17434867e-02f, 3.80847380e-02f, -2.03114003e-02f, 6.56845123e-02f, -1.67621419e-01f, 5.67724113e-04f,
  -1.26731312e-02f, -2.10535713e-02f, -5.98958991e-02f, 5.91935329e-02f, -2.96569169e-02f, -5.60947433e-02f, 3.18831243e-02f, -7.56638348e-02f, -6.23515621e-02f, 1.24231748e-01f,
  -1.26225892e-02f, -1.00929283e-01f, -1.98176857e-02f, 4.30262201e-02f, 8.60275850e-02f, 9.12123099e-02f, -4.51675989e-02f, -2.32318789e-03f, -3.16288769e-02f, 3.44837154e-03f,
  1.03069032e-02f, -8.41925561e-04f, -6.00157715e-02f, 1.70797277e-02f, 3.53161208e-02f, -5.69559485e-02f, 7.45282248e-02f, 4.41898778e-02f, -9.31358561e-02f, -3.87017429e-02f,
  9.70420390e-02f, -2.38233674e-02f, -7.11377338e-02f, -4.25314605e-02f, -1.16020702e-01f, 1.16059752e-02f, 1.01390719e-01f, -4.36496623e-02f, -2.37688366e-02f, 9.06062052e-02f,
  1.71019044e-02f, 2.59678159e-02f, -3.27558033e-02f, -4.73040752e-02f, -7.50359520e-02f, -1.78051256e-02f, -4.62934189e-02f, 4.50951457e-02f, 2.12427564e-02f, 5.50339781e-02f,
  -6.49570599e-02f, -1.62410308e-02f, -5.19484095e-02f, 1.90984923e-02f, -7.37579167e-02f, 2.16234922e-02f, -6.26540259e-02f, 6.63758963e-02f, 2.08995119e-02f, -3.14702652e-02f,
  4.81618345e-02f, -1.26321316e-01f, -2.54459633e-03f, 3.46365049e-02f, 3.17780823e-02f, -7.43219927e-02f, 8.07525218e-02f, -3.74911726e-02f, -7.21836537e-02f, -2.47162968e-01f,
  1.87890362e-02f, 1.49235344e-02f, 2.50362873e-01f, -2.68926233e-01f, 3.96336108e-01f, 2.19559789e-01f, -1.12754166e-01f, -9.36978757e-02f, -1.74761917e-02f, -1.99047670e-01f,
  -8.71164873e-02f, -2.27218747e-01f, 8.91907066e-02f, -2.00709209e-01f, -1.25168651e-01f, -2.14496627e-01f, 6.32629404e-03f, -6.89279586e-02f, -1.51596799e-01f, 4.32608016e-02f,
  3.71857621e-02f, -2.11209711e-02f, 6.22172933e-03f, 6.73122182e-02f, 3.42649482e-02f, -5.56503274e-02f, -5.59629574e-02f, -2.48544309e-02f, 7.20440447e-02f, -5.20590805e-02f,
  -5.93035892e-02f, 1.02982581e-01f, -1.68043479e-01f, -4.18419670e-03f, -9.96615216e-02f, -3.89319770e-02f, 7.77240694e-02f, 9.43019241e-02f, -8.78242627e-02f, 3.55319977e-02f,
  -5.75513020e-02f, -1.41121224e-02f, 3.06328721e-02f, 2.34693736e-02f, 3.16354893e-02f, 7.51762763e-02f, -9.72991623e-03f, 5.14162183e-02f, 4.36883755e-02f, -1.21647278e-02f,
  -1.35825559e-01f, -1.45214461e-02f, 3.27881277e-02f, 3.55552025e-02f, -1.01570703e-01f, -1.66891771e-03f, -3.84729501e-04f, 4.43216064e-04f, -2.80612949e-02f, 9.70507786e-03f,
  5.05987145e-02f, -6.69326857e-02f, 6.46923929e-02f, 2.23676767e-02f, -7.70490468e-02f, 4.43475209e-02f, 3.31649594e-02f, 2.92868074e-03f, 1.64145622e-02f, 1.14076078e-01f,
  -4.76094820e-02f, -4.94834222e-02f, 6.97729811e-02f, 2.78502051e-02f, 8.60650241e-02f, 8.53493139e-02f, 2.60255020e-03f, -1.75389200e-02f, 2.71612816e-02f, 3.44787948e-02f,
  6.79790452e-02f, -1.56326562e-01f, -7.50027597e-02f, 1.06776804e-01f, 5.53266034e-02f, 1.52250836e-02f, -8.04467052e-02f, -5.76316155e-02f, -4.50859480e-02f, -7.04676434e-02f,
  -9.24782827e-02f, 1.40929580e-01f, -7.81137438e-04f, -2.49072518e-02f, -6.15015486e-03f, 2.03365404e-02f, 2.64067613e-02f, -3.42908986e-02f, 9.82321873e-02f, -5.29354550e-02f,
  1.04164276e-02f, 1.24110505e-01f, 4.37997021e-02f, -7.53954723e-02f, 2.67362073e-02f, 1.60294864e-02f, 1.01726025e-01f, -9.27702934e-02f, 8.50323681e-03f, -3.27235125e-02f,
  1.57857835e-01f, 2.48519376e-01f, 5.24578094e-02f, 3.09676770e-02f, -7.62913078e-02f, -2.12870315e-01f, -2.79104076e-02f, -8.51055309e-02f, -5.77625893e-02f, 9.21826288e-02f,
  -1.59491912e-01f, 3.28824401e-01f, -7.24186078e-02f, -6.57671541e-02f, -3.86854857e-01f, -2.08893076e-01f, -6.81362152e-02f, 2.04271954e-02f, -1.09778650e-01f, 1.06213167e-01f,
  -2.00516596e-01f, -2.39839256e-01f, -5.69970794e-02f, -4.14865427e-02f, 1.18285187e-01f, 2.04701111e-01f, -4.65807552e-03f, 2.88162418e-02f, 1.37546852e-01f, -1.66483015e-01f,
  -6.22246861e-02f, -3.40741612e-02f, 8.05914775e-02f, -1.91292055e-02f, -2.20161937e-02f, 7.38403797e-02f, 2.00187936e-02f, -6.53506815e-02f, 3.97898108e-02f, -2.24285685e-02f,
  7.88006186e-02f, 1.11132171e-02f, -3.84624414e-02f, -2.01028995e-02f, 8.75561405e-03f, 1.22321144e-01f, -3.68581638e-02f, 6.52396232e-02f, 6.78983256e-02f, 4.51515019e-02f,
  7.45071173e-02f, 3.01395915e-02f, 4.97609563e-02f, -1.59335658e-02f, 5.75231798e-02f, -3.08804102e-02f, -8.53936840e-03f, 4.14083600e-02f, 5.22441007e-02f, 3.10205519e-02f,
  3.13517042e-02f, 3.22521664e-02f, -4.33135964e-02f, 4.61636158e-03f, -3.35489139e-02f, -8.97161961e-02f, -4.27425429e-02f, -6.44041300e-02f, 8.76027942e-02f, -9.23287943e-02f,
  -1.24008292e-02f, 8.01496729e-02f, -1.11376740e-01f, 6.28802031e-02f, 1.79424006e-02f, -3.07973404e-03f, 1.04516326e-02f, -4.82106470e-02f, -8.79364237e-02f, -1.47583580e-03f,
  -4.54357378e-02f, 6.77947933e-03f, 3.15345675e-02f, -6.39706179e-02f, -1.01584755e-01f, 3.58450674e-02f, -1.26206491e-03f, 8.58361796e-02f, -4.92793657e-02f, -8.90566185e-02f,
  5.37606664e-02f, 3.07056978e-02f, 5.15972152e-02f, 3.33589315e-02f, -4.11165273e-03f, -3.67536061e-02f, -4.48803641e-02f, 5.97211234e-02f, -3.76511104e-02f, -5.16703203e-02f,
  9.32089314e-02f, 1.78830195e-02f, 7.23244436e-03f, -4.09270413e-02f, -5.61814643e-02f, -2.82213446e-02f, -2.47486751e-03f, 6.45905500e-03f, 5.22964485e-02f, -6.44598901e-02f,
  4.37123403e-02f, 2.72523779e-02f, -3.24121560e-03f, -7.85610005e-02f, 2.31733937e-02f, 5.53458408e-02f, 6.86642379e-02f, 1.31157339e-01f, 8.86535458e-03f, -5.46631664e-02f,
  7.74073154e-02f, -1.14184745e-01f, -1.61779031e-01f, 4.71607335e-02f, -1.58874784e-02f, 1.23755457e-02f, -1.93431079e-01f, -1.55749628e-02f, -3.06626946e-01f, 3.60699929e-02f,
  9.93715003e-02f, -1.23352751e-01f, -1.84466690e-02f, -4.40861322e-02f, -2.17682365e-02f, -1.95050046e-01f, 6.80889636e-02f, 6.13099858e-02f, -1.08510122e-01f, 2.27856904e-01f,
  7.26546943e-02f, 1.15236431e-01f, 3.78717147e-02f, 1.98649690e-01f, 8.79563242e-02f, 1.06082983e-01f, 3.04267526e-01f, 4.59966026e-02f, 1.28066748e-01f, -5.10757044e-02f,
  -4.17451002e-02f, 7.12051913e-02f, -3.10781188e-02f, -1.23656049e-01f, 1.39600515e-01f, -1.76899042e-02f, 1.12912968e-01f, -2.00461317e-02f, 5.79532459e-02f, -6.06911369e-02f,
  1.02334190e-02f, 4.78808843e-02f, -1.03795119e-01f, -2.42903363e-02f, -1.63709708e-02f, -3.18572782e-02f, 1.60231199e-02f, 6.13800623e-02f, -4.71904352e-02f, 6.27935901e-02f,
  -1.30047705e-02f, -6.75018877e-02f, -4.80472930e-02f, -3.30417138e-03f, -4.61098962e-02f, -7.05174059e-02f, 5.39131239e-02f, -1.40986536e-02f, 2.22491659e-02f, 7.25008100e-02f,
  1.05857607e-02f, 8.33291784e-02f, 5.41832559e-02f, -1.10283315e-01f, -3.31851505e-02f, -4.26951572e-02f, -6.22778200e-02f, -5.42920716e-02f, 3.72570078e-03f, 6.54839650e-02f,
  -3.77810723e-03f, -2.23021302e-02f, 3.61809656e-02f, 9.25711766e-02f, 1.88899755e-01f, 4.28762212e-02f, -4.64220010e-02f, -2.45526452e-02f, 4.85170912e-03f, -1.46668300e-01f,
  9.86628309e-02f, 4.76645641e-02f, -1.88104529e-02f, 4.93844878e-03f, 3.63730155e-02f, -6.34597540e-02f, -1.53936287e-02f, 1.01176746e-01f, -4.23177145e-02f, 1.32541487e-03f,
  9.99257565e-02f, 1.48511499e-01f, -1.38711751e-01f, -5.55027369e-03f, -5.68047240e-02f, 1.47859706e-02f, -1.90424465e-03f, -5.06133474e-02f, 4.74973954e-02f, -1.11298999e-02f,
  8.80302340e-02f, -2.29280703e-02f, 5.36396913e-02f, 7.40390969e-03f, -3.60335000e-02f, 5.95560297e-02f, -1.39989201e-02f, 5.52562252e-02f, -7.15271011e-02f, 8.34983736e-02f,
  9.57879126e-02f, -6.07031323e-02f, 9.03104246e-03f, -8.86663198e-02f, 6.21375293e-02f, 1.90281421e-02f, -5.09869754e-02f, 1.09587044e-01f, -5.59576601e-02f, 9.83036458e-02f,
  -6.52125895e-01f, 2.97840208e-01f, 1.44148216e-01f, -3.35050300e-02f, 2.08581774e-03f, 2.96071749e-02f, -1.23742864e-01f, 5.35638779e-02f, -6.65884614e-02f, 2.85213962e-02f,
  -1.30138263e-01f, 1.37820756e-02f, 4.89936434e-02f, 4.83895019e-02f, -2.13911012e-01f, 8.82999003e-02f, -4.76653688e-02f, -1.78816891e-03f, 2.52012778e-02f, -6.80693835e-02f,
  -3.24628055e-02f, 4.80160443e-03f, 2.15940233e-02f, 1.16169788e-01f, -1.05761513e-01f, -7.48124421e-02f, -1.26192868e-01f, 9.78778899e-02f, -8.33872408e-02f, -9.25551206e-02f,
  -1.80697724e-01f, -1.77824423e-01f, -1.33183494e-01f, -4.72800173e-02f, -1.58444732e-01f, -8.56520385e-02f, -7.68848881e-02f, -9.75477099e-02f, -6.05130047e-02f, -2.60171276e-02f,
  -5.22641428e-02f, 6.23114072e-02f, -1.20150335e-02f, 1.02766678e-02f, -2.42472496e-02f, -8.00161343e-03f, 4.64463495e-02f, 3.77920792e-02f, 5.62026240e-02f, 5.85179590e-02f,
  1.08733125e-01f, 9.70865786e-02f, -6.02628328e-02f, 8.05680919e-03f, -3.05708591e-02f, -3.44984792e-02f, 6.39298856e-02f, -9.80809256e-02f, -1.97690967e-02f, -8.17338526e-02f,
  -2.67536230e-02f, 5.49252108e-02f, 6.20447565e-03f, 2.39001829e-02f, 1.17224663e-01f, 1.50943259e-02f, -3.07954419e-02f, -3.04755289e-02f, 1.05408467e-01f, 2.08008084e-02f,
  -2.15077330e-03f, -5.45811802e-02f, -3.98502573e-02f, -5.04712015e-02f, 1.72034018e-02f, -2.80096103e-02f, -8.16695392e-02f, -5.71103655e-02f, 4.42623869e-02f, -2.76636574e-02f,
  5.07567339e-02f, -4.25470509e-02f, 1.57958292e-03f, 9.18778009e-04f, -4.88132946e-02f, -7.09729791e-02f, -2.85409950e-02f, -6.87067211e-02f, -1.34670511e-01f, -1.26110345e-01f,
  -2.85620332e-01f, -2.42973998e-01f, -1.05231412e-01f, -5.06869704e-02f, 4.45328057e-02f, -7.56032988e-02f, 3.45418565e-02f, -1.76965445e-02f, -4.24846858e-02f, -4.97045554e-02f,
  -4.47459519e-02f, -9.48399603e-02f, -2.55910438e-02f, 2.59895325e-02f, 7.29934731e-03f, 5.85694946e-02f, 1.39275203e-02f, -2.19897553e-02f, -9.99153256e-02f, 3.30187790e-02f,
  -2.83532869e-02f, -1.00751951e-01f, -2.02119965e-02f, -1.08984066e-02f, -5.46603203e-02f, -6.19630553e-02f, -3.05219926e-02f, 1.80760603e-02f, -1.65882185e-02f, -1.39831435e-02f,
  -2.36117765e-01f, -1.89639404e-02f, 2.39793226e-01f, -1.45457312e-01f, -5.15902154e-02f, 2.89460391e-01f, 2.44968981e-01f, -3.51055674e-02f, -1.87817112e-01f, -2.35005245e-01f,
  -1.37562200e-01f, -5.60979173e-02f, 1.97274297e-01f, -9.44237933e-02f, 2.43509263e-01f, 1.28094539e-01f, -1.17295207e-02f, -1.65393859e-01f, -5.07904440e-02f, -4.84116152e-02f,
  2.28634980e-02f, -1.35609493e-01f, 7.53032789e-02f, -7.25744218e-02f, -4.20480631e-02f, -1.48117945e-01f, -7.98857883e-02f, 1.03675835e-01f, -9.98353809e-02f, -9.33416095e-03f,
  5.81800099e-03f, -2.65310198e-01f, -3.50838900e-02f, -7.02083781e-02f, -7.60943070e-02f, -5.86109906e-02f, -1.22237466e-02f, 1.22129768e-02f, -7.76755661e-02f, -3.28661986e-02f,
  4.78019565e-02f, 1.00702420e-02f, -5.49387466e-03f, -5.63536130e-04f, 1.32101579e-02f, 1.02954765e-03f, -2.11761240e-02f, -3.14352140e-02f, 7.17529701e-03f, -2.20660325e-02f,
  5.99368475e-02f, -2.28976160e-02f, -8.29671603e-03f, -8.63465071e-02f, 6.10005017e-03f, -6.57866523e-02f, 7.39133582e-02f, -3.43381055e-02f, -4.23344504e-03f, -5.85614964e-02f,
  -2.24021804e-02f, 2.73769684e-02f, -8.32153931e-02f, -4.75820750e-02f, -5.34542799e-02f, 4.03141193e-02f, 2.83096032e-03f, -3.12480447e-03f, 5.98026328e-02f, 1.20807271e-02f,
  -4.06967886e-02f, -1.11943655e-01f, 3.13649960e-02f, 7.52308220e-02f, -5.29991351e-02f, -7.91626808e-04f, -1.21354267e-01f, 5.06866910e-02f, -5.76423071e-02f, 8.95655321e-05f,
  8.39580148e-02f, -7.59926764e-03f, -6.15385473e-02f, -6.29780954e-03f, 1.20120542e-02f, 2.42596529e-02f, -1.06549308e-01f, 3.00238263e-02f, -6.67758882e-02f, 1.34815164e-02f,
  3.05907819e-02f, -5.57846911e-02f, -1.12885177e-01f, -1.18872017e-01f, -7.10816234e-02f, -7.41172535e-03f, 3.10398266e-03f, 5.66591742e-03f, 3.66276503e-02f, -1.75413117e-03f,
  2.44401041e-02f, -5.61286435e-02f, 1.02244869e-01f, -6.99876482e-03f, 5.72923608e-02f, 7.00323805e-02f, 8.74635130e-02f, 1.72097515e-02f, -1.06201142e-01f, -1.33887716e-02f,
  1.32451385e-01f, -8.88396055e-03f, -1.52355721e-02f, -2.09416393e-02f, -7.56788403e-02f, -7.34338686e-02f, -5.37111014e-02f, -4.87866327e-02f, -5.28379716e-02f, -2.68073697e-02f,
  2.98164845e-01f, 2.21661851e-02f, 1.63699314e-01f, 3.16662431e-01f, 7.55827129e-02f, -2.13353187e-01f, 5.80608994e-02f, -5.31034991e-02f, 1.81593657e-01f, -1.46236181e-01f,
  1.16169184e-01f, 7.23225251e-02f, 5.87390400e-02f, -6.00369973e-03f, -6.54956140e-03f, -1.00530759e-01f, -7.78181059e-03f, -1.92367230e-02f, 8.27978700e-02f, -5.80430254e-02f,
  -4.78356890e-02f, -1.40955016e-01f, 4.62008081e-02f, -2.19932303e-01f, 1.29697502e-01f, 4.57326546e-02f, 9.46703628e-02f, 4.71088476e-02f, -7.47344345e-02f, -8.69720355e-02f,
  -4.24485318e-02f, 9.61281061e-02f, 8.26160833e-02f, -1.14692912e-01f, -8.33337847e-03f, 4.97369952e-02f, -1.48933232e-01f, -6.46939650e-02f, 4.46727276e-02f, -3.01585719e-02f,
  -7.93729052e-02f, -5.11428760e-03f, -4.51666862e-02f, 5.10270037e-02f, 6.58308715e-02f, 3.44874598e-02f, 6.79328591e-02f, 6.92325309e-02f, 9.30071324e-02f, 4.62675653e-02f,
  9.41455830e-03f, 6.51134700e-02f, -3.91188301e-02f, -1.04385810e-02f, -1.32042048e-02f, 9.57068875e-02f, -6.49526343e-02f, 1.58640519e-02f, 6.31783083e-02f, -2.31003761e-03f,
  -1.04348645e-01f, -1.06368698e-02f, 3.21263187e-02f, 9.21192858e-03f, -5.83153032e-02f, -3.22006904e-02f, -8.31704512e-02f, -1.06791377e-01f, 6.73581138e-02f, -2.66898278e-04f,
  3.76278814e-03f, -1.07054096e-02f, 3.40170227e-02f, 1.53898701e-01f, 8.95649418e-02f, -3.85718606e-02f, 9.90231871e-04f, -4.61870953e-02f, 4.06919420e-02f, 1.11239418e-01f,
  -3.51250619e-02f, -4.57908362e-02f, -2.25536525e-02f, 3.47411558e-02f, 3.43754441e-02f, 5.26692942e-02f, -1.18284184e-03f, -5.65463118e-03f, 8.49329494e-03f, 3.36769596e-02f,
  -2.78655797e-01f, -1.66986033e-01f, -7.44340867e-02f, -4.72851954e-02f, -4.67811935e-02f, 4.61069420e-02f, -1.05478816e-01f, -3.48781096e-03f, -1.11687938e-02f, -9.64595154e-02f,
  -1.71277840e-02f, 2.03213412e-02f, -5.69491200e-02f, 4.54393681e-03f, -1.28939852e-01f, -2.12113485e-02f, 1.15196751e-02f, 1.95247587e-02f, -3.81006710e-02f, -1.84921063e-02f,
  -4.93983291e-02f, -6.09618574e-02f, 2.69362219e-02f, -1.00725042e-02f, 1.13236497e-03f, 1.14493184e-01f, 9.14823322e-04f, 3.23980451e-02f, -1.06720954e-01f, -1.70081869e-01f,
  -8.79856870e-02f, -7.01582134e-02f, -1.53393984e-01f, 2.05785632e-01f, 9.80382860e-02f, -5.11574335e-02f, -6.94498196e-02f, 1.75906911e-01f, -3.31956521e-02f, 7.98421279e-02f,
  1.52773306e-01f, -5.01568057e-03f, -8.44765306e-02f, 1.70808300e-01f, 3.09886038e-01f, -1.24117211e-01f, 2.04634890e-01f, 1.76697429e-02f, 5.23695126e-02f, 7.39693940e-02f,
  3.70154940e-02f, 2.39774704e-01f, 2.58620866e-02f, 1.49585739e-01f, 8.25593248e-02f, 1.10498173e-02f, 1.53030977e-01f, -1.11185782e-01f, 2.29013309e-01f, 1.34100065e-01f,
  -2.72669345e-02f, -4.13741730e-02f, -2.07751989e-02f, -5.95579967e-02f, 8.98481086e-02f, 4.85949311e-03f, -4.36736904e-02f, 5.51581606e-02f, -1.60657633e-02f, -3.75097729e-02f,
  -8.53995606e-02f, -3.91328335e-03f, 8.76105279e-02f, -3.22525091e-02f, -9.15346965e-02f, 7.29929730e-02f, 7.10044876e-02f, 7.58908838e-02f, 4.49410491e-02f, 1.03042409e-01f,
  -1.20345363e-02f, 6.74210414e-02f, -8.98000598e-03f, -4.80765803e-03f, 6.47068350e-03f, 3.82664390e-02f, -4.07410339e-02f, 5.47056347e-02f, -5.66773023e-03f, 5.60312867e-02f,
  4.75582443e-02f, -1.19644701e-02f, -3.46682109e-02f, 7.30019510e-02f, -9.21690091e-03f, -2.59652548e-03f, 1.08359911e-01f, 7.90296346e-02f, 7.02780038e-02f, 3.98884043e-02f,
  1.28720244e-02f, 9.48967412e-03f, -8.06582917e-04f, -4.46590781e-02f, 2.03830302e-02f, 1.25243887e-03f, 6.18313700e-02f, 3.04343253e-02f, 4.67051454e-02f, -9.27013461e-04f,
  -5.77257574e-02f, -9.29728746e-02f, -2.17266344e-02f, -1.55121833e-02f, -6.78975414e-03f, 2.19814852e-03f, -2.67933998e-02f, -3.78775932e-02f, 4.20858264e-02f, -8.26843549e-03f,
  -8.43677446e-02f, 2.59485338e-02f, -2.53992947e-03f, -1.16338590e-02f, -1.51612917e-02f, 6.14585467e-02f, 1.50018288e-02f, 8.09103027e-02f, 1.19473320e-02f, -8.44240375e-03f,
  2.47076396e-02f, -4.19789217e-02f, -5.19503392e-02f, 7.07184821e-02f, 1.70457875e-03f, -2.24625133e-02f, 1.50808431e-02f, 3.29493167e-04f, 5.85144237e-02f, 8.46589208e-02f,
  1.10824704e-02f, 5.85560873e-02f, 6.68663457e-02f, 1.12774678e-01f, -1.68569274e-02f, 1.71255320e-02f, -7.78843313e-02f, 6.72489479e-02f, 2.09818836e-02f, 4.21683043e-02f,
  2.83734590e-01f, -4.57225204e-01f, -4.14428394e-03f, 2.16466412e-01f, 2.61399984e-01f, 1.40032053e-01f, 1.37877867e-01f, -7.71392584e-02f, -5.00280112e-02f, -2.51631528e-01f,
  7.11465925e-02f, -1.30303130e-02f, -8.30778480e-02f, -3.68915349e-02f, 2.08720848e-01f, -3.24036218e-02f, 3.56677547e-02f, 9.39065441e-02f, -5.25257252e-02f, -8.02564994e-02f,
  1.06517419e-01f, 1.69486180e-01f, 1.56855024e-02f, 1.36693828e-02f, 8.90753269e-02f, -1.25425145e-01f, -1.88439451e-02f, 8.78837556e-02f, -1.75796095e-02f, 1.82719618e-01f,
  -1.03278812e-02f, -5.95495142e-02f, 3.49075906e-02f, 8.00359175e-02f, -3.65236737e-02f, 2.98341643e-02f, 4.05042358e-02f, 1.39656305e-01f, 9.16634500e-02f, -5.45235500e-02f,
  -2.91547291e-02f, -1.65044051e-02f, 2.86403913e-02f, -1.06068905e-02f, 4.04087305e-02f, -9.15862024e-02f, 7.91725665e-02f, -5.19619361e-02f, -5.63072450e-02f, -8.28360096e-02f,
  4.14201850e-03f, -6.46683797e-02f, -1.17676705e-02f, -6.53938726e-02f, -5.33993430e-02f, -5.03814407e-03f, 2.12195497e-02f, 7.95937795e-03f, 1.47467023e-02f, -4.76353094e-02f,
  -8.56661052e-02f, -4.79367860e-02f, -4.16583382e-02f, 1.18703237e-02f, 6.05044216e-02f, -3.73030752e-02f, -1.81548074e-02f, -8.79308060e-02f, -6.21668175e-02f, 2.63002422e-02f,
  -1.05361762e-02f, 6.32530451e-02f, -7.41187297e-03f, -1.04639893e-02f, 2.90317480e-02f, -4.15946171e-02f, 4.07704897e-02f, 6.57372251e-02f, 1.96459331e-02f, 2.18713414e-02f,
  1.17623538e-01f, 7.68544972e-02f, 5.66915469e-03f, -5.53443618e-02f, 7.07003251e-02f, 7.39889219e-02f, -4.85119894e-02f, -3.39636207e-02f, -4.40641791e-02f, 4.12029363e-02f,
  -8.37871358e-02f, -3.18243027e-01f, -3.17592211e-02f, 6.92249388e-02f, -2.19710506e-02f, -1.20678984e-01f, -7.39752948e-02f, -1.00628305e-02f, -1.30606275e-02f, 1.11922855e-02f,
  -4.41544019e-02f, 4.34980951e-02f, -5.19060716e-03f, 6.03209324e-02f, 1.07343130e-01f, -8.68700966e-02f, -2.66544381e-03f, -2.43415367e-02f, 4.04767022e-02f, -9.67331678e-02f,
  9.87564959e-03f, -1.42565854e-02f, 3.97638269e-02f, 2.32926439e-02f, -1.08139262e-01f, 2.25966293e-02f, 2.80127637e-02f, -3.31867598e-02f, 1.62205286e-02f, -3.74103487e-02f,
  -3.59504908e-01f, 1.03790447e-01f, 1.58485681e-01f, -2.48393059e-01f, 3.82811278e-02f, 2.97709126e-02f, -7.27167353e-02f, 1.19098403e-01f, -1.03888884e-02f, -8.45926069e-03f,
  -8.77835136e-03f, -5.70172817e-02f, 1.88853815e-02f, -4.61247633e-04f, -1.08930804e-01f, -7.19589181e-03f, -1.36459827e-01f, -1.77524850e-01f, -8.76896456e-02f, -4.05340753e-02f,
  -1.73025072e-01f, -6.48995303e-03f, -1.28844818e-02f, 1.50205448e-01f, -1.54617736e-02f, -7.58481026e-02f, -5.63689955e-02f, 1.35419220e-01f, 2.51298933e-03f, 2.06229892e-02f,
  -1.58680156e-01f, -8.09662566e-02f, -5.49573591e-03f, 8.49068239e-02f, -2.22724359e-02f, -2.28446927e-02f, -7.56853446e-02f, -7.91657120e-02f, -1.66662350e-01f, -1.80972777e-02f,
  1.42686479e-02f, 8.78846869e-02f, -7.04727098e-02f, 3.98540497e-02f, 2.15108916e-02f, 1.11212105e-01f, 4.97980490e-02f, -8.26607868e-02f, -1.34258643e-01f, -2.28100340e-03f,
  -2.47079637e-02f, -1.15404977e-02f, 1.36221722e-02f, -3.33021441e-03f, 1.44880369e-01f, -5.79255000e-02f, 1.06870355e-02f, 7.98643474e-03f, -1.00021407e-01f, -1.05129264e-01f,
  8.00716579e-02f, -6.80394620e-02f, -9.89115313e-02f, 1.12060785e-01f, -2.32058242e-02f, 1.34470798e-02f, -2.10399050e-02f, 6.58422336e-02f, 4.53793386e-04f, -7.92070031e-02f,
  1.18893189e-02f, 5.39674200e-02f, -5.33761941e-02f, -8.35171267e-02f, -1.49640180e-02f, -1.13048693e-02f, -4.26541455e-02f, -3.04798055e-02f, -4.19448763e-02f, -4.07638215e-03f,
  -2.78102532e-02f, -5.41696586e-02f, -4.09487709e-02f, -2.60138651e-03f, 9.42418501e-02f, 8.42012465e-03f, 3.03924158e-02f, 6.02677241e-02f, -2.92792879e-02f, -9.29439217e-02f,
  -2.47738495e-01f, -1.29872575e-01f, -1.66104987e-01f, -4.56483923e-02f, 1.70867629e-02f, -9.09305364e-03f, -2.83178501e-02f, 3.32530960e-02f, -1.31184623e-01f, 3.30887586e-02f,
  -6.30208254e-02f, -4.84039262e-02f, -1.75394565e-02f, -5.59205785e-02f, 5.46268262e-02f, -6.68099374e-02f, -1.38269113e-02f, -1.66553646e-01f, -9.66727361e-02f, -1.82687622e-02f,
  -2.92171612e-02f, -8.69150534e-02f, 4.22334932e-02f, 2.29226723e-02f, 3.45100127e-02f, -8.56416896e-02f, -5.18675894e-02f, -5.24300449e-02f, -3.02207340e-02f, 3.84863839e-02f,
  3.15007716e-01f, -2.80611105e-02f, 2.62705773e-01f, 3.39374512e-01f, 2.52648089e-02f, -1.78649798e-01f, 9.03662853e-03f, 1.11865595e-01f, 3.18707794e-01f, 2.44917125e-02f,
  -4.58862409e-02f, 2.26617232e-01f, -4.78760451e-02f, 7.21293539e-02f, -1.74761593e-01f, -1.08892329e-01f, -5.23135178e-02f, 9.93285626e-02f, 7.78857395e-02f, 2.34112829e-01f,
  1.41652972e-01f, -3.48442979e-02f, -6.82159662e-02f, -1.25831008e-01f, -9.94157419e-03f, 1.59539983e-01f, -2.82535344e-01f, -1.86955005e-01f, -6.37106299e-02f, -1.81104541e-01f,
  -4.04435955e-02f, 6.29792213e-02f, 6.84182346e-02f, -1.19693160e-01f, 6.91415556e-03f, -8.08538720e-02f, -1.80825423e-02f, -6.61034286e-02f, -1.73980801e-03f, 3.90449949e-02f,
  1.23581134e-01f, -7.96336234e-02f, 5.26098050e-02f, 5.82988225e-02f, 3.47002521e-02f, 5.17628156e-02f, 7.95593932e-02f, 2.02845223e-02f, 8.24122429e-02f, 2.62604374e-02f,
  9.41295773e-02f, -6.94798911e-03f, 1.50511861e-02f, -8.98926854e-02f, 4.38983515e-02f, -3.75138633e-02f, 5.47295921e-02f, -2.25069821e-02f, 1.21394284e-02f, 5.42225316e-02f,
  -1.33246303e-01f, -3.65397558e-02f, -1.91961341e-02f, -3.11237015e-03f, 8.90001841e-03f, 9.21891928e-02f, -9.90565196e-02f, 3.35187130e-02f, -9.34963450e-02f, -1.28628826e-02f,
  6.69388624e-04f, 5.07792346e-02f, 5.13080694e-02f, 2.20675468e-02f, 1.09239351e-02f, 1.07643321e-01f, -6.28461987e-02f, 8.80739540e-02f, -3.99295660e-03f, -4.96919863e-02f,
  7.48041496e-02f, -3.34122032e-02f, -1.46592736e-01f, -8.03494230e-02f, -2.43877620e-03f, -1.14818884e-03f, 3.78915928e-02f, 1.10061891e-01f, 9.34026763e-03f, -2.52069421e-02f,
  -2.30648473e-01f, -1.88005611e-01f, -1.18299879e-01f, 1.26199767e-01f, 3.56531255e-02f, -2.83391890e-03f, 5.44790030e-02f, 7.58707598e-02f, -1.42684251e-01f, 3.44104022e-02f,
  6.21546879e-02f, 1.92094035e-02f, -7.70622194e-02f, 1.21549368e-02f, -1.07124269e-01f, 2.31974516e-02f, -2.13559736e-02f, -8.71875435e-02f, -7.52870217e-02f, -4.05167043e-02f,
  -1.32428715e-03f, 3.72934043e-02f, 2.40895245e-02f, 3.65565605e-02f, 2.60751671e-03f, -1.02905713e-01f, 9.42050815e-02f, -1.97377596e-02f, -5.96464910e-02f, -5.96849285e-02f,
  1.80249512e-01f, -2.42588162e-01f, -2.28586383e-02f, 2.04538748e-01f, 1.73395753e-01f, -1.31068425e-02f, 8.01013783e-02f, 1.20901745e-02f, 1.33715779e-01f, -2.22792685e-01f,
  -3.49136852e-02f, -7.29069859e-02f, -1.93743363e-01f, 4.11642045e-02f, 1.75066054e-01f, -7.54849315e-02f, 2.61398498e-02f, -1.03186287e-01f, -3.88415605e-02f, -1.12763137e-01f,
  9.32852700e-02f, -2.39745830e-03f, 9.78111625e-02f, 1.10462628e-01f, 7.93837160e-02f, 5.82557842e-02f, 7.45092556e-02f, -3.68579291e-02f, 1.37314454e-01f, 1.07400209e-01f,
  9.15543810e-02f, -8.29370841e-02f, 1.30576482e-02f, -9.89977345e-02f, -4.07440513e-02f, 7.28802085e-02f, -1.23112155e-02f, 1.90286972e-02f, -6.24725502e-03f, -4.83837835e-02f,
  -9.53657627e-02f, -8.48872960e-02f, 8.26737955e-02f, 4.05562520e-02f, 1.48881942e-01f, 1.10828772e-01f, -6.10280177e-03f, 1.86869968e-02f, 3.01236054e-03f, -1.81968927e-01f,
  -3.36471945e-02f, -3.11124455e-02f, 7.29274377e-02f, 9.38830723e-04f, -8.85299593e-02f, 1.27336144e-01f, -1.83595177e-02f, -7.41989464e-02f, -7.79070631e-02f, 2.12556142e-02f,
  -9.14339125e-02f, -6.51941076e-02f, -2.43700743e-02f, -3.73847224e-02f, -2.19402257e-02f, 1.18513033e-01f, 1.17200971e-01f, -1.97663717e-02f, 9.55061913e-02f, 3.04773264e-02f,
  4.58241254e-02f, 5.52094132e-02f, -3.95787507e-02f, -1.19740538e-01f, 8.21031572e-04f, -3.12232412e-02f, 2.05646660e-02f, -3.73222530e-02f, -3.65581140e-02f, 1.70042310e-02f,
  1.43083623e-02f, 1.14949092e-01f, -1.81833923e-01f, 4.51145656e-02f, 6.02657441e-03f, -2.97100097e-02f, -2.98945885e-02f, -7.25317933e-03f, -5.43777309e-02f, -6.93687797e-02f,
  -1.14701442e-01f, -2.66751885e-01f, 2.18133861e-03f, 6.88419938e-02f, -3.61778885e-02f, -7.75640383e-02f, 1.13224059e-01f, -8.41141939e-02f, -7.13673234e-02f, -1.53105244e-01f,
  -5.83560504e-02f, 8.32383260e-02f, 5.73328361e-02f, 6.55701896e-03f, 1.42524481e-01f, 1.94599200e-02f, -1.07699297e-01f, 1.15445070e-03f, 4.19073217e-02f, -6.89383894e-02f,
  -3.83710451e-02f, -5.46559803e-02f, 6.48716316e-02f, -5.42326551e-03f, 9.56072956e-02f, 5.48737794e-02f, -1.48295984e-02f, 2.97766477e-02f, -5.47652505e-02f, -3.69269550e-02f,
  2.11281359e-01f, -6.84803873e-02f, 1.23548314e-01f, -7.90319312e-03f, -6.40429743e-03f, -2.41368059e-02f, 4.31355312e-02f, -1.92978412e-01f, 9.69649106e-02f, -3.74912992e-02f,
  -7.30127394e-02f, 1.25069052e-01f, 3.30041945e-02f, -1.45827278e-01f, 2.23637536e-01f, 1.71370521e-01f, -8.59370977e-02f, -1.12548791e-01f, -3.18414420e-02f, -8.45005065e-02f,
  4.24174070e-02f, -1.65555447e-01f, -7.52644837e-02f, -2.44714826e-01f, -1.51070997e-01f, -1.20136112e-01f, -2.47541033e-02f, -2.45832708e-02f, -1.49900094e-01f, -9.73563176e-03f,
  -1.32623374e-01f, -7.09101111e-02f, 9.51620489e-02f, 4.23698984e-02f, -1.40489236e-01f, 1.39150443e-02f, 1.33904526e-02f, 6.18474446e-02f, 7.18342960e-02f, -9.04691769e-05f,
  4.45536859e-02f, -2.20365915e-02f, 2.94670090e-03f, 5.96853346e-02f, 7.78943971e-02f, 5.07852854e-03f, 3.07106003e-02f, -1.42265409e-01f, 7.01439977e-02f, -4.66603301e-02f,
  2.50524678e-03f, -4.57756774e-04f, -1.25083365e-02f, 6.24726154e-02f, 5.23456298e-02f, 1.25865236e-01f, 8.71796235e-02f, 4.23753746e-02f, 4.63705882e-02f, 8.94031897e-02f,
  -4.87916768e-02f, -9.14593711e-02f, -6.06679497e-03f, -1.41358390e-01f, -1.09414414e-01f, -6.68371469e-02f, -3.36770304e-02f, -2.59903725e-02f, 4.56497446e-02f, -8.45950022e-02f,
  2.13856250e-03f, 6.14601411e-02f, -1.00955956e-01f, -5.73723810e-03f, -5.51112965e-02f, 6.99036568e-02f, 9.49474573e-02f, 6.30989345e-03f, -7.15794936e-02f, -7.01294914e-02f,
  7.28617758e-02f, 1.07509509e-01f, -1.69000290e-02f, 5.07465238e-03f, -5.12753427e-03f, 2.98943538e-02f, -2.64777150e-02f, 9.74360034e-02f, 2.98595633e-02f, 4.09726426e-02f,
  -1.45175084e-01f, -3.53041999e-02f, -9.78618115e-03f, 6.14806227e-02f, -1.12905622e-01f, 1.30487857e-02f, 6.43029958e-02f, 9.65219289e-02f, 3.80670885e-03f, 5.19461967e-02f,
  -3.59013490e-02f, -1.05867885e-01f, 7.24989176e-02f, 2.08508242e-02f, -7.19802007e-02f, 9.11258459e-02f, 6.17591850e-02f, -3.62449698e-02f, 3.18430476e-02f, -9.17814225e-02f,
  -3.78147103e-02f, 1.02943614e-01f, 6.06003366e-02f, 3.72528434e-02f, -6.91361576e-02f, 9.15879756e-02f, 2.73720473e-02f, 1.08142540e-01f, -4.14764881e-02f, -1.60582904e-02f,
  -1.20917641e-01f, 2.52356958e-02f, -1.14579409e-01f, -1.20540321e-01f, 1.75359607e-01f, 1.37836281e-02f, -1.20622456e-01f, 8.54029804e-02f, -6.41261041e-02f, 1.42992705e-01f,
  -1.95309184e-02f, 2.48863343e-02f, -1.24103509e-01f, -1.93574280e-01f, -2.99096197e-01f, -2.58278072e-01f, -9.61023122e-02f, 1.85938515e-02f, -8.64177048e-02f, 8.50907862e-02f,
  -1.01443402e-01f, 7.12812617e-02f, -1.76200435e-01f, 1.62708219e-02f, 1.46645665e-01f, 1.94915965e-01f, 1.91692546e-01f, 1.86532941e-02f, 1.73189491e-01f, -2.87184231e-02f,
  -1.19181245e-03f, -6.10307418e-02f, 2.08917651e-02f, 2.46821325e-02f, -1.14892293e-02f, 7.87521899e-02f, -2.27712132e-02f, -3.30495946e-02f, -1.64742712e-02f, -5.44937234e-03f,
  2.98015680e-02f, 8.39874372e-02f, 1.93530116e-02f, -5.31857833e-02f, 2.59216242e-02f, 1.55356778e-02f, 9.36032832e-03f, 1.25162095e-01f, -7.47698322e-02f, -1.65645018e-01f,
  -2.62000114e-02f, 1.39277254e-03f, 7.11151659e-02f, -8.24211687e-02f, -1.52216805e-02f, 9.50350892e-03f, 1.00466721e-01f, -2.98052486e-02f, 7.73174763e-02f, -8.03144723e-02f,
  5.70218638e-02f, 9.27628055e-02f, -7.40794837e-02f, -2.24560536e-02f, -6.79732254e-03f, -3.18163484e-02f, -5.52595109e-02f, -4.46951725e-02f, -2.74674427e-02f, -2.71153748e-02f,
  3.90912332e-02f, 1.80084668e-02f, -3.05792633e-02f, -1.09049894e-01f, 5.36082909e-02f, -2.84350235e-02f, 1.44933537e-01f, 3.48543301e-02f, -2.64199078e-02f, 1.94365885e-02f,
  -4.53049429e-02f, -7.88741261e-02f, 2.08836291e-02f, 7.01267123e-02f, -4.96408530e-02f, 1.34884398e-02f, -6.93745911e-02f, 1.42480154e-02f, 3.09728403e-02f, 6.47191778e-02f,
  -2.73652226e-02f, -5.69900870e-02f, 2.41990220e-02f, 1.34989861e-02f, -1.34532943e-01f, -3.52385603e-02f, -8.49776715e-02f, -1.97195895e-02f, -3.80084477e-02f, -1.51269168e-01f,
  7.54218102e-02f, 2.96759848e-02f, 2.30143040e-01f, 6.67419732e-02f, -1.45660546e-02f, 1.16705326e-02f, 2.75309067e-02f, 7.63858631e-02f, 3.10797654e-02f, -6.04060218e-02f,
  9.88189355e-02f, 4.49033082e-02f, -1.07121550e-01f, -2.47395365e-03f, -1.15017723e-02f, 1.01506852e-01f, 1.37910992e-01f, 1.53797299e-01f, 1.15556955e-01f, -2.45360937e-02f,
  -8.19268525e-02f, 2.41124988e-01f, -2.89538112e-02f, 2.07590073e-01f, -8.63912553e-02f, -1.52710974e-01f, -1.71705708e-02f, 1.70060471e-02f, -1.88799590e-01f, 1.25431091e-01f,
  1.29709750e-01f, -8.79820138e-02f, 1.92242004e-02f, 1.92406550e-01f, 2.03271568e-01f, -3.98324877e-02f, 1.77799195e-01f, 1.79707434e-03f, -3.19640636e-02f, 1.80179209e-01f,
  1.54579822e-02f, 1.93017289e-01f, 1.11994438e-01f, 2.68211458e-02f, 5.05039245e-02f, -9.68698189e-02f, 2.19093516e-01f, -1.10709347e-01f, 1.18500434e-01f, -1.78516004e-02f,
  9.80663970e-02f, 9.63588804e-02f, -1.16409935e-01f, -1.40798107e-01f, 3.94280329e-02f, 6.90877959e-02f, -8.21197256e-02f, -3.10149323e-02f, 2.17289813e-02f, 6.70210272e-02f,
  -5.07855602e-02f, -3.09724379e-02f, -7.41194040e-02f, 3.18574309e-02f, 7.29743112e-03f, 1.05691910e-01f, 2.32341662e-02f, -1.34918010e-02f, -7.91785792e-02f, 1.10874079e-01f,
  -9.15415734e-02f, -6.91238344e-02f, 7.26877898e-02f, -2.52965558e-02f, 5.53747267e-02f, 8.33119228e-02f, 4.32055853e-02f, 3.61510552e-02f, -6.17396906e-02f, -3.26168686e-02f,
  5.73749132e-02f, -6.93907961e-02f, -1.96476188e-02f, -2.78575588e-02f, 4.52738144e-02f, -8.69595166e-03f, 1.12918094e-01f, -5.53039871e-02f, -1.42910630e-01f, 9.84897166e-02f,
  1.05782403e-02f, 6.73255548e-02f, 5.42657636e-02f, -6.39255531e-03f, -1.11209778e-02f, 5.75936399e-02f, -8.34392756e-03f, -2.52095256e-02f, -1.84957031e-02f, -5.27203493e-02f,
  -2.08266657e-02f, -1.78887363e-04f, -9.18893740e-02f, 2.36563161e-02f, 5.02437288e-05f, 3.16908471e-02f, 6.51590899e-02f, -8.79913289e-03f, -1.73543636e-02f, 5.48417866e-02f,
  2.01763406e-01f, 4.17954475e-02f, -7.99159259e-02f, 1.32851936e-02f, -9.61504877e-02f, 1.56308226e-02f, 1.12500275e-03f, -4.31189127e-02f, 6.05895258e-02f, 1.65383462e-02f,
  -2.89693102e-02f, 1.80092547e-02f, -5.34690656e-02f, -2.94995643e-02f, -2.85605583e-02f, 3.22718956e-02f, 1.02107301e-01f, -1.02834003e-02f, 1.62626803e-02f, 6.02306575e-02f,
  1.11130670e-01f, 9.13273916e-03f, 5.35025680e-03f, 3.47683653e-02f, 1.51309455e-02f, -1.90344476e-03f, -1.28978550e-01f, 2.25071050e-02f, 2.00011041e-02f, -6.27871752e-02f,
  4.39014770e-02f, 4.72999848e-02f, -1.40315607e-01f, -1.07155889e-02f, -3.26445669e-01f, -1.94679558e-01f, -9.22929402e-03f, 1.17222585e-01f, 2.46377811e-01f, 1.73563123e-01f,
  -4.55245450e-02f, 2.63413519e-01f, 8.88401493e-02f, -1.24865621e-01f, 6.52563274e-02f, 2.75427848e-01f, 1.60226654e-02f, 1.93658788e-02f, 4.46977094e-02f, -7.58704096e-02f,
  -3.01757501e-03f, -8.18898305e-02f, -1.30954802e-01f, -2.33908996e-01f, -2.72322685e-01f, -8.83060917e-02f, -8.47489238e-02f, -1.89464226e-01f, -1.59024939e-01f, -4.37215902e-02f,
  -7.76632205e-02f, 1.48200974e-01f, -9.57951397e-02f, 6.93010464e-02f, -2.98527605e-03f, -5.03886715e-02f, -7.97554106e-03f, -3.45052741e-02f, 3.80358808e-02f, -1.16074141e-02f,
  8.36301222e-02f, 7.39025921e-02f, 7.85175040e-02f, -1.11518363e-02f, -4.29485701e-02f, -1.11087225e-02f, 2.79363915e-02f, -1.62377730e-01f, 1.89538812e-03f, -6.61087334e-02f,
  5.90303354e-02f, 7.69179016e-02f, -9.05159768e-03f, 1.01776585e-01f, -9.97490436e-03f, 4.19592299e-02f, -4.59859241e-03f, -2.99411956e-02f, 5.16393073e-02f, -1.51219433e-02f,
  5.65598719e-03f, 3.71311046e-02f, -5.97437806e-02f, 2.24376880e-02f, -3.07817385e-03f, -7.80961569e-03f, 2.00149473e-02f, 6.15298096e-03f, -5.90137253e-03f, 6.38381718e-03f,
  4.34652455e-02f, 1.25701185e-02f, -3.70119661e-02f, -7.05992803e-02f, 9.87249333e-03f, 1.82364024e-02f, -1.45064602e-02f, 2.43575480e-02f, -1.07228942e-02f, -7.43112862e-02f,
  1.43147454e-01f, 1.80324037e-02f, 1.59078445e-02f, -1.24456473e-01f, 1.35018863e-02f, 9.92636848e-03f, -1.51114329e-03f, 2.32386738e-02f, -3.61034125e-02f, -2.84327450e-03f,
  5.58234490e-02f, 1.51930466e-01f, 2.50992086e-02f, 3.35659347e-02f, 3.13901007e-02f, -8.19033459e-02f, 1.60922650e-02f, -4.23135757e-02f, 6.32954761e-02f, 1.01083536e-02f,
  5.49023086e-03f, -1.01318713e-02f, 1.98913482e-03f, 2.61992100e-03f, 3.44506539e-02f, -5.94502129e-02f, 7.79667571e-02f, 3.80384587e-02f, 2.53896974e-02f, -5.44294566e-02f,
  -8.61457810e-02f, 4.20190506e-02f, 4.97468635e-02f, 1.21449353e-02f, 3.21328305e-02f, 5.65396808e-02f, 1.82832573e-02f, 9.89335706e-04f, 2.55719153e-03f, -4.56471220e-02f,
  2.63146073e-01f, -2.24999487e-01f, 1.69573501e-01f, 8.37514922e-02f, 1.56463042e-01f, 2.31470447e-02f, 2.25588992e-01f, 5.57144471e-02f, 9.93698314e-02f, -1.32646039e-01f,
  1.55924177e-02f, 4.33145612e-02f, -1.13900201e-02f, -8.76779929e-02f, 1.02969766e-01f, 8.37562457e-02f, 1.94130987e-02f, 5.08779399e-02f, 9.20948014e-02f, 5.49062528e-02f,
  3.23620364e-02f, -6.22653589e-02f, -1.02946483e-01f, -8.23562145e-02f, -5.64062893e-02f, 2.81224921e-02f, -9.16902274e-02f, 1.13544539e-01f, -1.57118544e-01f, 1.02280833e-01f,
  -1.74736627e-03f, -3.84105518e-02f, -1.93499401e-01f, -6.90580606e-02f, -7.36089349e-02f, -1.64699145e-02f, -1.46084860e-01f, 6.71576802e-03f, -2.45712474e-02f, -3.00715398e-02f,
  -5.07336222e-02f, -4.35901480e-03f, 9.02076587e-02f, 1.21504348e-02f, -1.18924856e-01f, -9.15179700e-02f, 5.80396391e-02f, -1.09640054e-01f, -5.09896036e-03f, 6.05836809e-02f,
  -6.58861995e-02f, -1.87029149e-02f, 7.21475435e-03f, 5.56989852e-03f, 1.37155116e-01f, -1.39825121e-02f, -1.24462461e-02f, 6.69742897e-02f, -1.86779294e-02f, -5.94686493e-02f,
  7.77229145e-02f, 4.87193055e-02f, -6.74165040e-02f, 6.13334812e-02f, 4.36035395e-02f, -5.66961244e-02f, 1.45412134e-02f, -9.42760799e-03f, -5.56630865e-02f, -6.00621998e-02f,
  -6.92382008e-02f, 1.47977695e-02f, 3.07331868e-02f, -2.97463443e-02f, -4.16849628e-02f, 5.54638244e-02f, 3.82212661e-02f, -1.35839935e-02f, -3.15351076e-02f, -7.59378774e-03f,
  -2.24434845e-02f, -3.75695042e-02f, 6.52129874e-02f, 9.40947160e-02f, 9.83837694e-02f, 6.21741936e-02f, 2.70793792e-02f, 1.38970511e-02f, -8.22778195e-02f, -3.84386256e-02f,
  -1.80839583e-01f, -1.40320599e-01f, -6.54980987e-02f, -1.38404593e-01f, 3.94238112e-03f, -3.45554538e-02f, -1.38186917e-01f, -5.82069457e-02f, -4.15676199e-02f, -2.02335231e-02f,
  3.28490064e-02f, 1.87482685e-02f, -6.80757314e-02f, 6.72532693e-02f, -2.92361192e-02f, -8.09672624e-02f, 5.80586269e-02f, 2.76397984e-03f, -7.67055973e-02f, 8.51109102e-02f,
  2.30683461e-02f, 2.75363773e-02f, 9.59892944e-02f, -9.37830284e-02f, 1.31349135e-02f, 1.90991350e-02f, 8.83605480e-02f, 1.13288620e-02f, 4.87284409e-03f, 7.47710839e-02f,
  3.60018402e-01f, -1.90556481e-01f, -1.12241887e-01f, 1.92105010e-01f, 1.84787378e-01f, 8.66857767e-02f, -1.35121820e-02f, 1.31967694e-01f, 1.73963562e-01f, -8.84364545e-02f,
  -4.16184263e-03f, -2.13895649e-01f, -1.91080391e-01f, 8.94048810e-03f, -1.08423769e-01f, -1.21682324e-01f, 6.92295209e-02f, 3.98490839e-02f, 1.46483106e-03f, -1.30082974e-02f,
  1.03450008e-01f, 1.16549097e-01f, -8.48086774e-02f, 2.72666328e-02f, 2.04877049e-01f, 1.73583910e-01f, -8.02787207e-03f, 7.57898912e-02f, -1.04141273e-02f, -8.84533226e-02f,
  5.92803322e-02f, -1.18110701e-01f, -6.61837831e-02f, -6.85685575e-02f, -2.90664751e-02f, 4.01425958e-02f, -6.02560975e-02f, -1.91611379e-01f, 4.31616381e-02f, -1.77715383e-02f,
  -1.13815419e-01f, 2.65992433e-02f, 3.49289109e-03f, 6.99135214e-02f, 9.46603343e-02f, -1.84422191e-02f, -2.10944396e-02f, 3.45945843e-02f, -3.41405123e-02f, -4.84628044e-02f,
  -1.26599014e-01f, -9.87455696e-02f, 9.75063816e-02f, 3.03134900e-02f, -4.01595458e-02f, -5.95491193e-02f, 2.41249092e-02f, -1.07196055e-01f, 5.92804253e-02f, -5.96373752e-02f,
  -2.19366383e-02f, 1.91960931e-02f, -4.59842943e-02f, 1.11006469e-01f, -2.83158775e-02f, 1.20258424e-02f, 2.18011513e-02f, -1.28623784e-01f, 8.10106844e-02f, -6.59568561e-03f,
  7.12632090e-02f, 1.24329880e-01f, -1.17958151e-02f, 3.50359604e-02f, -2.12183744e-02f, 5.70122525e-03f, -6.27173185e-02f, 3.12162861e-02f, 8.84241164e-02f, -7.01888502e-02f,
  2.92384978e-02f, -5.82242524e-03f, 4.34552208e-02f, -5.48868254e-02f, -2.91609261e-02f, -2.28992812e-02f, 5.05425148e-02f, -1.38098486e-02f, -8.51993635e-02f, -1.58828106e-02f,
  5.58303669e-02f, -1.24935932e-01f, -4.28158082e-02f, -7.85980076e-02f, -1.67474023e-03f, 2.53052581e-02f, 2.19267439e-02f, -3.87100317e-02f, 6.44349754e-02f, 9.63162109e-02f,
  8.28129891e-03f, 8.01946595e-03f, 7.56742731e-02f, 5.94393276e-02f, 3.73442359e-02f, 6.98952526e-02f, 3.23833786e-02f, -5.08354902e-02f, 1.71994716e-02f, -2.34505013e-02f,
  -5.65594733e-02f, -8.19052607e-02f, 2.41184700e-02f, 3.19476984e-02f, 1.04165124e-02f, -9.12297964e-02f, -5.95088787e-02f, 1.98656544e-02f, -1.05230603e-02f, -8.65998268e-02f,
  -3.12656134e-01f, -7.91779459e-02f, -2.17470050e-01f, 6.30199313e-02f, 4.28736918e-02f, 2.08846591e-02f, -1.59790754e-01f, 6.50984943e-02f, -1.63798913e-01f, 3.05298567e-02f,
  2.00118259e-01f, -9.65351015e-02f, -6.01846762e-02f, 9.00306404e-02f, 5.84358238e-02f, -8.43540579e-02f, 3.62398326e-02f, 3.48076150e-02f, -5.34240063e-03f, 1.03398301e-01f,
  8.30368549e-02f, 2.35056356e-01f, 9.80552360e-02f, 1.98229492e-01f, 1.13452226e-01f, 5.56826107e-02f, 2.28953168e-01f, 4.17579040e-02f, 2.22648174e-01f, 1.01445029e-02f,
  -1.24518581e-01f, -1.60342325e-02f, 2.90334690e-02f, -9.71082151e-02f, 6.55864254e-02f, 4.88926880e-02f, -3.37859057e-02f, -1.08106351e-02f, 1.33229280e-02f, 5.22448197e-02f,
  4.35873903e-02f, 1.73879880e-03f, -1.40180602e-03f, 4.90547754e-02f, 4.98839431e-02f, 4.69894446e-02f, 3.93751590e-03f, -1.71934608e-02f, -8.50312412e-02f, 6.05729111e-02f,
  -9.00377613e-03f, -3.18230353e-02f, 3.35249631e-03f, -2.47716885e-02f, 2.69684801e-03f, 4.35608812e-02f, 9.61008947e-04f, 1.31119445e-01f, -1.98212396e-02f, 2.62373406e-02f,
  -2.46648621e-02f, 3.85545120e-02f, -2.74706967e-02f, -5.84577303e-03f, -1.30187646e-02f, 1.34479757e-02f, -1.55161985e-03f, 4.64266352e-02f, -2.04642117e-02f, 1.64927002e-02f,
  2.61195637e-02f, 2.29689628e-02f, 3.11125182e-02f, 8.38326886e-02f, -4.19585444e-02f, -4.63174768e-02f, 3.62691060e-02f, 3.12049445e-02f, -5.86499833e-02f, 4.38245535e-02f,
  3.33770663e-02f, 5.19791171e-02f, -2.23343400e-03f, -3.80437337e-02f, 1.08098798e-01f, 8.54280218e-02f, 4.02913876e-02f, 1.08964443e-01f, 2.30489150e-02f, -1.14950396e-01f,
  1.25739425e-01f, 1.79120868e-01f, 4.64805998e-02f, -6.80637583e-02f, 2.92889252e-02f, 7.32866824e-02f, -4.40312326e-02f, 7.56216049e-02f, -4.90859896e-02f, 1.82573888e-02f,
  9.41096917e-02f, -3.89543138e-02f, 1.73225608e-02f, -3.20917740e-02f, 4.12363969e-02f, 1.22636527e-01f, 2.27655694e-02f, 8.59830156e-02f, 3.72641906e-03f, 1.33632123e-01f,
  -1.02198925e-02f, 2.39792168e-02f, -2.79086884e-02f, -8.62539858e-02f, -5.60699217e-02f, 1.22770943e-01f, -1.87138040e-02f, 4.72633680e-03f, 1.02051184e-01f, 1.00535549e-01f,
  -3.71085495e-01f, 1.73311979e-01f, -6.56816782e-03f, 1.64322704e-01f, -3.46310139e-02f, 2.52542347e-01f, 2.87645012e-01f, 5.44524565e-02f, 2.22021103e-01f, 2.11488798e-01f,
  7.47135580e-02f, -2.03024782e-02f, 6.52228370e-02f, 4.55382429e-02f, -5.54080419e-02f, 8.56582001e-02f, 2.21453980e-01f, 1.50847152e-01f, -4.92010950e-05f, -8.48967955e-02f,
  -1.28288686e-01f, 1.22375097e-02f, -1.32087454e-01f, -1.86222300e-01f, -6.88984916e-02f, -1.24231189e-01f, -9.04062390e-02f, -1.82675317e-01f, 1.27579439e-02f, 8.15412030e-02f,
  -2.65223859e-03f, 7.07074180e-02f, -4.17114682e-02f, -2.29221559e-03f, 3.69270071e-02f, 1.71509031e-02f, -4.36130533e-04f, -1.08569741e-01f, 1.43715099e-03f, 8.66021439e-02f,
  -7.44946599e-02f, -5.09731919e-02f, 1.06735252e-01f, 5.05797528e-02f, -3.94223034e-02f, 1.71804875e-02f, 2.31220969e-03f, -2.89081335e-02f, -3.16013135e-02f, 1.31900801e-04f,
  -6.51961118e-02f, 2.89780973e-03f, 6.13445528e-02f, 1.51533738e-01f, -1.15136402e-02f, 9.66735184e-03f, 7.53350481e-02f, 1.11169638e-02f, 4.96137664e-02f, 8.61466303e-02f,
  2.07976885e-02f, 1.52053321e-02f, 9.27543417e-02f, -1.95007888e-03f, -4.34297463e-03f, -2.82635726e-02f, -9.01482105e-02f, 3.27691599e-03f, -6.68941438e-02f, -9.86560285e-02f,
  6.42869771e-02f, 5.83544858e-02f, 3.34102325e-02f, -3.28075215e-02f, 6.78122789e-02f, 2.63588056e-02f, -1.28900949e-02f, 1.75103843e-02f, 3.09877098e-02f, -7.45992661e-02f,
  -4.11493378e-03f, 2.85881553e-02f, 1.10362045e-01f, 4.01193947e-02f, 2.26849131e-02f, -3.19123045e-02f, 1.35898991e-02f, -1.65920295e-02f, 5.95618859e-02f, -8.22085538e-04f,
  1.90172270e-01f, 1.60347328e-01f, 8.42385367e-02f, -9.10389610e-03f, -7.30586424e-02f, -2.11488307e-02f, 5.76656424e-02f, -1.82558186e-02f, 1.14849262e-01f, -2.07541371e-03f,
  3.33251641e-03f, 5.40489405e-02f, 5.21195941e-02f, -7.44412541e-02f, -7.02482276e-03f, 1.36929095e-01f, 8.31540748e-02f, 6.89189658e-02f, 5.21513373e-02f, -1.08059071e-01f,
  7.74066299e-02f, 9.13416892e-02f, -1.44028086e-02f, -2.55886074e-02f, 8.28502029e-02f, 5.30034080e-02f, 1.64258350e-02f, -2.07295064e-02f, -4.38820710e-03f, -2.15481129e-02f,
  1.49281383e-01f, -1.39955863e-01f, -3.80890933e-03f, 1.94329157e-01f, -1.14547648e-02f, -1.91145197e-01f, -8.07262883e-02f, 1.12913415e-01f, -2.57812571e-02f, -1.83212757e-01f,
  3.55430208e-02f, -8.50059763e-02f, -4.41511683e-02f, 1.69800967e-02f, 1.21819161e-01f, -1.74418241e-01f, 6.39032945e-02f, -4.22065593e-02f, -5.60425781e-02f, 9.14982110e-02f,
  6.83233589e-02f, 7.21600726e-02f, 2.22436771e-01f, 2.09867299e-01f, 1.40165627e-01f, 2.10346043e-01f, 2.47662783e-01f, 2.41470430e-02f, 1.37411237e-01f, 4.94098179e-02f,
  -7.97654986e-02f, 3.50283906e-02f, -2.53584441e-02f, 8.52570459e-02f, 7.37340227e-02f, -3.37517634e-02f, -4.63873297e-02f, -4.38535884e-02f, 9.47677717e-02f, 4.62467298e-02f,
  -3.96580994e-02f, -2.48043276e-02f, -1.15265390e-02f, 2.31355894e-02f, 1.79933440e-02f, 7.20433742e-02f, 9.44603533e-02f, 4.28610258e-02f, -1.39746098e-02f, 3.66812199e-02f,
  -5.46551868e-02f, -5.47792157e-03f, 4.21213135e-02f, 2.49863155e-02f, 3.74970143e-03f, -6.50099516e-02f, 2.64716428e-02f, 8.84857494e-03f, -6.30254820e-02f, -7.91795701e-02f,
  1.31300479e-01f, -7.64902383e-02f, 7.13697672e-02f, -4.39959951e-02f, 1.64638050e-02f, 3.04831960e-03f, 8.84985626e-02f, -1.00507112e-02f, 7.98808709e-02f, -1.07939854e-01f,
  -3.96812707e-03f, 2.24939846e-02f, 1.39739793e-02f, -1.05537608e-01f, -2.52170786e-02f, -1.01871073e-01f, -8.92546307e-03f, -5.04375016e-03f, -2.23769378e-02f, -5.44683263e-02f,
  -1.82597622e-01f, 1.44988135e-01f, -6.16718903e-02f, 1.07159950e-02f, -9.41561535e-02f, 3.42438631e-02f, 6.20958395e-02f, 5.62998187e-03f, 1.55312866e-02f, -9.52103548e-03f,
  -4.55455631e-02f, 1.09282024e-01f, -2.31668390e-02f, -5.22812381e-02f, 2.73783766e-02f, -5.46870530e-02f, -2.26615649e-02f, -1.80259459e-02f, 4.90399599e-02f, 9.86599773e-02f,
  -1.21238969e-01f, 1.82642939e-03f, 1.89896654e-02f, 8.41354504e-02f, 8.58577341e-02f, 6.85437918e-02f, -2.97720693e-02f, -1.19206205e-01f, 2.18187319e-03f, 5.23176715e-02f,
  -5.93461394e-02f, -1.08901948e-01f, -6.81965947e-02f, -6.63781837e-02f, 5.21403411e-03f, -2.52349535e-03f, -4.69758958e-02f, -5.43470494e-03f, 5.35518043e-02f, 2.88991537e-03f,
  -1.12490848e-01f, 2.43495673e-01f, 7.19340052e-04f, 3.68904620e-02f, 1.76182672e-01f, 3.56526598e-02f, -1.51297703e-01f, 1.24055579e-01f, 6.54989257e-02f, -1.21962307e-02f,
  -1.50017560e-01f, 1.56649575e-01f, -1.28359288e-01f, 2.57953145e-02f, -2.42264315e-01f, -1.04765855e-01f, 4.18245010e-02f, 4.75849537e-03f, 3.55116464e-02f, 1.08067304e-01f,
  -9.63137820e-02f, -6.93666339e-02f, -1.67251050e-01f, -1.22559406e-01f, -2.98151020e-02f, -1.00430325e-02f, -2.07511082e-01f, 2.67881583e-02f, -4.80112918e-02f, -4.91154715e-02f,
  -2.85001379e-02f, -9.54071805e-02f, -1.18081786e-01f, -5.06023280e-02f, 8.16946942e-03f, -4.99218293e-02f, 1.04765981e-01f, -1.17227165e-02f, 3.43030430e-02f, 8.37245733e-02f,
  7.51009062e-02f, -6.09289818e-02f, 2.82184295e-02f, 8.71035159e-02f, 4.19759266e-02f, 3.63676921e-02f, 5.83291575e-02f, 2.24727187e-02f, -9.41134524e-03f, 5.37776798e-02f,
  8.57943371e-02f, 7.72613958e-02f, 1.31420165e-01f, 7.45741557e-03f, 1.03109688e-01f, 8.95208120e-02f, -2.76045986e-02f, -3.81331854e-02f, 4.06820588e-02f, -4.22003493e-02f,
  8.11957791e-02f, -3.60111929e-02f, 1.00289797e-02f, 1.53431743e-02f, -1.05538152e-01f, -1.20500438e-02f, 7.64069930e-02f, -8.62182975e-02f, -5.23519255e-02f, -2.94676200e-02f,
  -1.21912109e-02f, 2.40221340e-03f, 3.30207571e-02f, 4.57701012e-02f, -4.75607701e-02f, 2.74738148e-02f, 5.73340431e-03f, 3.93681740e-03f, 9.87661779e-02f, 3.88742518e-03f,
  -7.21137896e-02f, -3.32679413e-02f, 1.44483848e-02f, 6.86603561e-02f, -8.09716433e-02f, -4.55945581e-02f, -5.02936728e-02f, -2.84738634e-02f, -2.43185535e-02f, 3.75235407e-03f,
  2.12617964e-02f, 1.03850245e-01f, -5.94535619e-02f, -4.05448787e-02f, -7.09385797e-02f, -1.24027111e-01f, -5.33831604e-02f, 1.02134235e-01f, -4.68046963e-02f, -2.03244481e-02f,
  4.59055565e-02f, 3.79980952e-02f, 1.93530813e-01f, -5.56319058e-02f, -2.94087604e-02f, -5.13668917e-02f, 1.46784598e-03f, 4.87667210e-02f, 1.70434862e-02f, -6.20262250e-02f,
  5.14237992e-02f, 4.81826439e-02f, 6.04024455e-02f, 4.80869599e-02f, -7.46085942e-02f, 2.89896242e-02f, 7.48744085e-02f, 1.04375951e-01f, -6.35451302e-02f, 1.94130244e-03f,
  -8.24788660e-02f, 1.16386034e-01f, -3.05153638e-01f, -2.43036076e-01f, 2.61694547e-02f, -3.21881860e-01f, -2.66889811e-01f, -4.60384339e-02f, 1.06870659e-01f, -9.43894498e-03f,
  -5.75029403e-02f, 2.97966506e-02f, 8.53689387e-02f, -2.01166555e-01f, -9.47662145e-02f, 1.69369638e-01f, -1.93705469e-01f, -1.53074712e-01f, 1.10905364e-01f, -1.40151918e-01f,
  -8.15776587e-02f, -6.27182126e-02f, -1.32431000e-01f, 3.78207080e-02f, -2.12638170e-01f, -7.14963749e-02f, 1.65233493e-01f, -1.59485132e-01f, -1.45102069e-01f, 9.34591964e-02f,
  -2.45357435e-02f, -3.64341475e-02f, -9.78217945e-02f, -4.91148457e-02f, -2.32702494e-01f, -5.68867810e-02f, -1.43548712e-01f, 4.35521128e-03f, -9.32422653e-02f, -6.63282275e-02f,
  7.02909157e-02f, 7.04656690e-02f, 6.02340065e-02f, 2.66135503e-02f, -1.95515249e-02f, -8.62401072e-03f, -5.06429449e-02f, 4.55696508e-02f, -8.74819532e-02f, 1.15646623e-01f,
  -3.28693017e-02f, 1.26490637e-03f, -5.08256108e-02f, 6.77303001e-02f, -6.54713344e-03f, -3.89163233e-02f, -2.56941076e-02f, 6.75750971e-02f, -9.95243266e-02f, 1.53370658e-02f,
  1.40563250e-01f, -4.67287289e-04f, -4.38985266e-02f, -1.03682075e-02f, 2.52585690e-02f, 4.91769426e-02f, -6.07671961e-02f, 6.52399659e-02f, -2.89878296e-03f, 1.72498226e-02f,
  4.34802324e-02f, -2.60766167e-02f, -8.06733593e-02f, -8.30160081e-02f, -1.43617019e-02f, 1.70742273e-02f, -3.73828933e-02f, -6.10808767e-02f, -5.48667368e-03f, -5.86016513e-02f,
  -1.11635730e-01f, -4.74137664e-02f, -3.96913057e-03f, 2.99727265e-02f, 5.04910126e-02f, 2.88285278e-02f, -3.33678350e-02f, 1.34007493e-02f, -3.72511223e-02f, -6.31128624e-02f,
  -2.68155694e-01f, -3.35801452e-01f, -2.18992457e-02f, -6.07092194e-02f, -5.98216336e-03f, -1.51776550e-02f, -4.74218167e-02f, 1.24444822e-02f, -4.24033329e-02f, -3.98596339e-02f,
  -1.93557199e-02f, -1.12060970e-02f, -7.26392819e-03f, -1.02529019e-01f, 1.03294201e-01f, -3.86618823e-02f, -7.80703723e-02f, -4.17779200e-02f, -1.93008780e-01f, 8.39745104e-02f,
  -1.00881971e-01f, -2.33954638e-02f, 6.75624609e-02f, 5.97428456e-02f, -6.03924729e-02f, -1.10053211e-01f, -3.10510155e-02f, 8.10794607e-02f, -2.74745375e-02f, 3.81578542e-02f,
  2.75701404e-01f, -1.20378565e-02f, 9.99039635e-02f, 1.55471116e-01f, 5.18035702e-02f, -1.67477980e-01f, -9.91422161e-02f, 2.68009603e-01f, 1.46515250e-01f, -1.08478397e-01f,
  -2.33633462e-02f, -7.05077033e-03f, -1.36314973e-01f, 1.41569227e-01f, 1.24867754e-02f, -1.05929695e-01f, 1.04461871e-01f, -1.02344044e-01f, 3.38107981e-02f, 7.56344125e-02f,
  1.84473708e-01f, 1.06687889e-01f, 1.47553802e-01f, 5.48342168e-02f, 9.16131679e-03f, 1.80209607e-01f, 8.59859884e-02f, -9.74913239e-02f, 8.00434873e-02f, -7.87073076e-02f,
  -8.46011117e-02f, 9.46694538e-02f, -6.06139712e-02f, 3.80183049e-02f, -7.74400085e-02f, -5.05189076e-02f, -9.81242880e-02f, -6.72740769e-03f, -1.13201179e-02f, -5.32666920e-03f,
  -8.02967418e-03f, -1.15462668e-01f, 9.10841078e-02f, 3.82059328e-02f, 2.62258365e-03f, 4.49401960e-02f, -2.30398290e-02f, 1.69658922e-02f, 2.92239003e-02f, 2.06435751e-03f,
  1.14593647e-01f, -8.33997130e-03f, 2.24942453e-02f, -7.73439556e-02f, 1.10243715e-01f, -2.58764047e-02f, 2.67902911e-02f, -5.43715507e-02f, -2.60748770e-02f, 2.45612115e-02f,
  7.91704506e-02f, -3.63643877e-02f, 1.82670318e-02f, 6.53718039e-02f, 7.51110911e-03f, 4.16003801e-02f, 7.22136796e-02f, 2.49953680e-02f, 4.39224839e-02f, -2.10009366e-02f,
  -6.40730485e-02f, -2.96569243e-02f, 2.63393428e-02f, -4.51527648e-02f, -4.59262952e-02f, 6.41905144e-02f, -1.38542634e-02f, -5.76706529e-02f, 8.11385363e-02f, -4.14100140e-02f,
  1.88333672e-02f, -5.14404960e-02f, -1.54173627e-01f, 8.09200332e-02f, 1.51588172e-02f, -2.20963676e-02f, -7.83635005e-02f, -6.64706752e-02f, 4.46301773e-02f, 9.91429910e-02f,
  -1.69759154e-01f, 4.10653725e-02f, 2.29302533e-02f, -1.37359379e-02f, 4.79345396e-02f, -5.57213835e-02f, 9.14564580e-02f, -5.43224141e-02f, -6.80701286e-02f, -8.57430845e-02f,
  5.90688102e-02f, -3.02936491e-02f, -8.57960060e-03f, -2.66881380e-02f, -8.28216784e-03f, 5.31215519e-02f, 1.72016416e-02f, -1.09503586e-02f, -4.86304015e-02f, 1.49275977e-02f,
  -2.53726356e-02f, -1.27787590e-02f, 7.57254735e-02f, -4.51624207e-02f, 6.38213456e-02f, -4.16713171e-02f, 3.84411891e-03f, 3.20312120e-02f, 6.53740764e-02f, 1.45126209e-01f,
  9.39238146e-02f, -8.03498924e-02f, -1.49068579e-01f, 3.12725268e-02f, -6.79591149e-02f, 7.37789571e-02f, 1.10751584e-01f, -1.33893669e-01f, -2.36672744e-01f, 1.11246966e-01f,
  1.16377607e-01f, -1.33352637e-01f, 8.80452096e-02f, 2.71834910e-01f, 2.02062204e-01f, 1.04030304e-01f, 1.49117485e-01f, 2.02979043e-01f, -7.87058473e-02f, -4.90185283e-02f,
  -5.98433167e-02f, 1.56486750e-01f, 5.23555428e-02f, 1.40144024e-02f, 7.91408271e-02f, -9.58793908e-02f, 4.99543035e-03f, -1.17543772e-01f, 8.00361484e-02f, 5.28486893e-02f,
  9.50684771e-02f, -9.12631229e-02f, -4.91283424e-02f, -5.12806214e-02f, 1.37082012e-02f, 1.41836196e-01f, 8.55156556e-02f, 6.32207990e-02f, -7.06270011e-03f, -4.80534583e-02f,
  -1.97395477e-02f, -6.71392633e-03f, -6.39593527e-02f, -5.29961437e-02f, -1.29963420e-02f, -4.24426273e-02f, -5.36218360e-02f, -6.53290972e-02f, -1.54519174e-02f, 1.23498542e-02f,
  -9.88236666e-02f, -9.46057588e-03f, -6.51779212e-03f, 1.12974588e-02f, -6.89444765e-02f, -3.00308317e-02f, -5.61813675e-02f, -6.77269623e-02f, -9.79752317e-02f, -4.49181767e-03f,
  7.06425011e-02f, 5.94058121e-03f, 8.03557187e-02f, 9.05733258e-02f, 7.60514587e-02f, 8.97178873e-02f, 1.35117713e-02f, 3.52817476e-02f, -2.96534020e-02f, 4.60254289e-02f,
  -1.56768486e-02f, -7.32672811e-02f, 5.16295666e-04f, 3.16161364e-02f, 1.51201442e-03f, -7.27571398e-02f, -1.41921621e-02f, 4.18284051e-02f, -7.81889260e-02f, 9.35515463e-02f,
  5.13659827e-02f, 1.16991838e-02f, 1.49206566e-02f, 1.11087494e-01f, 6.65306672e-02f, 7.31846094e-02f, 8.65242034e-02f, -1.00988194e-01f, -1.03965506e-01f, -4.08125296e-02f,
  -1.42633962e-02f, -9.25371647e-02f, -7.24170804e-02f, 6.70900121e-02f, 2.28630286e-02f, -2.82469168e-02f, -6.01451583e-02f, 1.95412524e-02f, -3.53454575e-02f, -1.50496839e-03f,
  -1.19899036e-02f, -7.56046697e-02f, -6.13143481e-02f, -1.01246960e-01f, 1.73998869e-03f, -7.64297694e-02f, 1.00051444e-02f, -4.54069078e-02f, -7.68399835e-02f, -5.67132048e-02f,
  9.10855643e-03f, 5.26412874e-02f, -9.98869818e-03f, -1.79650355e-02f, 5.09330183e-02f, 3.05157471e-02f, -1.32362144e-02f, -1.27359122e-01f, 2.60961545e-03f, 8.05126783e-03f,
  6.57528862e-02f, -9.86321419e-02f, -2.70256102e-01f, -1.03636511e-01f, -1.44223779e-01f, 1.82408869e-01f, 8.91043767e-02f, -1.57990307e-02f, -1.39790833e-01f, 2.02269182e-01f,
  1.59824878e-01f, -8.22292119e-02f, -1.55706117e-02f, 2.73598164e-01f, 1.03306815e-01f, 1.06858388e-01f, 1.87112510e-01f, 1.55509710e-01f, -1.04259901e-01f, 3.58808897e-02f,
  -2.68366691e-02f, 3.06847721e-01f, 2.93031707e-02f, 1.25987366e-01f, 1.06929272e-01f, -1.36413693e-01f, -2.92464327e-02f, -2.42904484e-01f, 3.31415720e-02f, -4.86932658e-02f,
  5.80896325e-02f, -1.33611143e-01f, -3.99086028e-02f, 4.44254326e-03f, -1.82265490e-02f, -1.52052594e-02f, -8.65691230e-02f, -1.54278176e-02f, -6.50516301e-02f, 1.50464298e-02f,
  2.65022041e-03f, -1.28852949e-02f, 1.77205056e-02f, -9.23559964e-02f, -8.51975381e-02f, -3.28192785e-02f, -1.71600915e-02f, -2.56061051e-02f, 1.51557252e-02f, 3.75040397e-02f,
  -7.44114742e-02f, -8.07354525e-02f, 3.13159078e-03f, 3.27211320e-02f, -5.83801121e-02f, -1.44547736e-03f, 7.91603029e-02f, -1.13532953e-01f, 4.46344987e-02f, 6.83155330e-03f,
  -1.47744641e-02f, -5.14253862e-02f, 4.42971550e-02f, 3.74644026e-02f, 8.70026927e-03f, 5.48323207e-02f, 3.92312417e-03f, -3.25445682e-02f, 8.26213654e-05f, 4.84936796e-02f,
  -9.97974277e-02f, 2.43339837e-02f, 8.97581205e-02f, 2.72919443e-02f, -1.99786872e-02f, -4.19439860e-02f, -6.24901280e-02f, 5.33655770e-02f, -7.22450688e-02f, 2.60577388e-02f,
  -9.41752363e-03f, -1.10337969e-04f, -6.95216209e-02f, 5.44833876e-02f, 4.52592038e-02f, -9.46321040e-02f, 3.67154665e-02f, -2.05194168e-02f, 2.59021353e-02f, 4.14263941e-02f,
  3.28547545e-02f, -9.31528211e-02f, -8.57856497e-03f, 1.06469495e-02f, -1.17115803e-01f, 3.25150117e-02f, -5.98980449e-02f, 4.77485582e-02f, -7.32263699e-02f, -5.31534143e-02f,
  -2.02511810e-02f, 2.84953453e-02f, 2.83120703e-02f, -1.91077255e-02f, -3.11058797e-02f, -2.94127632e-02f, 3.27638350e-02f, -1.17525235e-01f, -5.34828082e-02f, -1.76359303e-02f,
  -6.91742077e-02f, 5.70203289e-02f, 4.15437147e-02f, 7.21591106e-03f, 9.63141248e-02f, -1.20032113e-02f, -4.62508388e-02f, -1.20566025e-01f, -9.41739827e-02f, -7.88724143e-03f,
  -2.06141099e-01f, -1.71057004e-02f, -8.70078057e-02f, 2.71752328e-01f, -1.12718396e-01f, -2.09818140e-01f, -1.15397543e-01f, 3.38428915e-02f, -1.19047605e-01f, 1.18671507e-01f,
  2.29967892e-01f, -1.99362338e-02f, 6.49709329e-02f, 2.28086054e-01f, 9.38553289e-02f, 5.22915721e-02f, 8.81707966e-02f, 4.19564806e-02f, 2.32434254e-02f, 4.19176184e-02f,
  1.30909622e-01f, 1.65139824e-01f, 1.39634326e-01f, 2.94220708e-02f, 5.85737117e-02f, 1.97375700e-01f, 2.41378203e-01f, -1.50893003e-01f, 1.19646572e-01f, -6.81334659e-02f,
  -5.22854291e-02f, 1.51534835e-02f, -3.79102677e-02f, -7.58797526e-02f, 6.55978685e-03f, -6.84168264e-02f, 4.60043475e-02f, -2.73420550e-02f, -2.60716099e-02f, -5.29473126e-02f,
  -7.61572793e-02f, -1.25912242e-02f, -1.85879208e-02f, 5.77712141e-04f, -2.58178655e-02f, -1.88659970e-02f, -1.25418846e-02f, 1.64110623e-02f, -1.33358510e-02f, 2.53377315e-02f,
  -4.67374772e-02f, -2.46490315e-02f, 7.82167837e-02f, -3.61151621e-02f, 9.25416350e-02f, 1.70674338e-03f, 3.14632356e-02f, 6.47690669e-02f, -1.50138829e-02f, -9.61590633e-02f,
  6.01405576e-02f, -1.70795508e-02f, 5.47766425e-02f, 6.15123697e-02f, 3.76562290e-02f, 4.51022908e-02f, -9.34727676e-03f, -6.80187810e-03f, -8.68111663e-03f, 2.18369886e-02f,
  5.75039582e-03f, -5.02374619e-02f, -5.56730740e-02f, -3.29824141e-03f, -2.98686698e-02f, -2.38970760e-02f, -4.25074100e-02f, -5.05806282e-02f, -1.22665232e-02f, -6.38109446e-02f,
  -4.03905734e-02f, -8.91488045e-02f, -3.12692821e-02f, -1.66886784e-02f, 4.90406305e-02f, 1.91627275e-02f, 8.01364258e-02f, -9.31321308e-02f, 1.32272122e-02f, 6.69789761e-02f,
  -5.15072495e-02f, 1.41688243e-01f, -9.57956091e-02f, 1.43576022e-02f, -4.68733460e-02f, -1.10947981e-01f, 9.30755660e-02f, 7.76165277e-02f, -4.70937137e-03f, -5.10751866e-02f,
  -4.90105972e-02f, 1.21268956e-02f, 2.40009669e-02f, 2.84438003e-02f, -1.13811968e-02f, -2.32460201e-02f, 5.89765720e-02f, -4.01937217e-02f, -3.52431871e-02f, -2.33486090e-02f,
  6.90292418e-02f, -5.79221398e-02f, 9.32167768e-02f, 7.62832863e-03f, -4.36461531e-02f, 6.97162747e-02f, -5.77235855e-02f, -7.93554708e-02f, 1.00133300e-01f, -1.04515012e-02f,
  -3.90402530e-03f, 2.32772872e-01f, 2.93039352e-01f, 3.33957933e-02f, -1.60734519e-01f, 2.56762449e-02f, -4.24154215e-02f, 5.32254130e-02f, 2.46714011e-01f, 8.96186009e-02f,
  -1.41006947e-01f, 2.68640250e-01f, -9.31764469e-02f, 4.84695546e-02f, -1.46681920e-01f, -1.08940333e-01f, 6.41133711e-02f, 7.78911039e-02f, -3.11882515e-02f, 2.21160357e-03f,
  -1.78851988e-02f, -3.45908821e-01f, -2.88074259e-02f, -1.15704313e-01f, 3.83311440e-03f, 1.45179734e-01f, -2.37943470e-01f, -5.51468097e-02f, 7.55448192e-02f, -4.33854572e-02f,
  2.06203125e-02f, 6.55221641e-02f, 1.02503471e-01f, 1.59282699e-01f, -1.44457258e-02f, -4.40460891e-02f, -2.64383648e-02f, -5.96382236e-03f, 1.79349333e-02f, 1.18182581e-02f,
  -1.99352652e-02f, 8.11793953e-02f, -6.40017614e-02f, -3.84536269e-03f, 1.08604103e-01f, 9.02957618e-02f, 9.62646976e-02f, 9.77970939e-03f, 1.11710735e-01f, -4.51051742e-02f,
  1.09661885e-01f, 1.09701544e-01f, 9.55373049e-02f, 1.43328443e-01f, 1.06479526e-02f, 1.59506574e-02f, 1.53586864e-01f, 2.78186779e-02f, 1.52320847e-01f, 2.67613921e-02f,
  -5.45180328e-02f, -6.52368218e-02f, -4.30471683e-03f, 1.31820356e-02f, 2.80575994e-02f, 7.03521073e-02f, -2.71006413e-02f, -5.04622124e-02f, 1.58275738e-01f, 4.67544086e-02f,
  2.24313345e-02f, 9.24485400e-02f, -6.45369962e-02f, 7.52521530e-02f, -8.35629776e-02f, -2.99359523e-02f, -1.06857019e-02f, 9.21070203e-02f, -6.25613183e-02f, 7.11218128e-03f,
  -4.57271300e-02f, -4.52254824e-02f, -3.26788835e-02f, -1.95931899e-03f, 7.22354501e-02f, 3.64654772e-02f, -6.45063892e-02f, 1.82091564e-01f, -5.90461567e-02f, -7.99589604e-02f,
  1.96001283e-03f, 1.17596745e-01f, -1.15625244e-02f, 2.76764277e-02f, -1.16347745e-02f, -6.23765923e-02f, -6.10582484e-03f, 6.95963483e-03f, 7.94827491e-02f, -6.05462817e-03f,
  -1.67370699e-02f, 2.95682009e-02f, 1.60114206e-02f, -4.74641435e-02f, -2.02006102e-02f, -2.33665463e-02f, 8.18426162e-02f, 5.07559488e-03f, -3.05146053e-02f, -8.70184004e-02f,
  3.59421223e-02f, -5.84903359e-03f, 4.66007888e-02f, -2.94684581e-02f, 2.46460792e-02f, 3.50656658e-02f, 7.18290210e-02f, 4.54445072e-02f, -3.25636156e-02f, 3.41047038e-04f,
  6.83072209e-02f, 5.04626753e-03f, -1.95712805e-01f, -8.97418931e-02f, -2.86404043e-01f, -3.45647223e-02f, -6.68601990e-02f, -1.96291000e-01f, -1.25696242e-01f, 1.04960501e-01f,
  6.49982272e-03f, -6.60858974e-02f, 2.26968884e-01f, 6.74088160e-03f, -5.58386520e-02f, 2.26430804e-01f, 4.94182147e-02f, 4.09164578e-02f, -8.99613351e-02f, 1.82494167e-02f,
  7.33615607e-02f, 7.10587874e-02f, -1.48596354e-02f, -7.86561444e-02f, -1.30135402e-01f, -7.59753957e-02f, -6.62480071e-02f, -2.50773400e-01f, -9.78284031e-02f, -1.31971344e-01f,
  5.26540205e-02f, 9.65455621e-02f, -2.36077383e-02f, -2.88671069e-02f, -3.41785848e-02f, -9.96018015e-03f, 3.62464935e-02f, -4.83438820e-02f, -4.16360907e-02f, 7.31434971e-02f,
  2.35827155e-02f, -5.11739925e-02f, -2.93779243e-02f, -3.14137340e-02f, -4.14474122e-02f, -2.03266125e-02f, 2.69535407e-02f, -7.39822984e-02f, 1.13339082e-03f, -7.59831350e-03f,
  -5.28075686e-03f, 5.42980172e-02f, -8.36876780e-02f, 9.51817408e-02f, -6.87953457e-02f, -5.48114628e-02f, 1.70806970e-03f, 3.13772038e-02f, -1.92758143e-02f, 2.00332664e-02f,
  -5.98106533e-02f, 3.77829373e-02f, 4.51353900e-02f, -5.18163592e-02f, -6.79313987e-02f, 5.15985340e-02f, -1.31833190e-02f, 1.04227252e-01f, -1.13798305e-01f, 1.09803118e-01f,
  3.02902665e-02f, 1.89480837e-02f, 9.69403610e-03f, 2.05884036e-02f, 3.57387438e-02f, -2.50269193e-02f, -4.49230857e-02f, -2.18621921e-02f, -1.22309153e-04f, 3.58474394e-03f,
  1.43865170e-02f, 1.02472631e-02f, -5.51936589e-02f, -1.18166264e-02f, 7.96423554e-02f, -1.28887212e-02f, 3.04562766e-02f, -3.92652163e-03f, 1.05936378e-01f, -4.03759852e-02f,
  3.41560692e-02f, -8.59568492e-02f, -1.33710681e-02f, 6.63777590e-02f, -3.63262743e-02f, -2.28752214e-02f, -7.59890676e-02f, -1.24665186e-01f, -1.25284106e-01f, -1.81824807e-02f,
  4.25560400e-02f, 6.40997514e-02f, 3.09533086e-02f, -1.63056701e-02f, 4.19206917e-02f, -2.68196389e-02f, 5.44398613e-02f, -1.09652681e-02f, -2.81590875e-02f, 1.79758519e-02f,
  1.18532395e-02f, 6.81664422e-02f, 2.99857836e-02f, -3.03588510e-02f, -3.71967070e-02f, -3.90300192e-02f, -7.77012706e-02f, 5.98265603e-03f, 1.00796536e-01f, -1.97569318e-02f,
  -2.91145127e-03f, 8.90034065e-02f, 1.54588923e-01f, 1.25355288e-01f, -7.15744123e-02f, -3.11782449e-01f, -1.42140970e-01f, 1.64973840e-01f, -8.33489746e-02f, -7.47043714e-02f,
  -1.05363175e-01f, 1.01814859e-01f, -7.43600205e-02f, 1.06794402e-01f, 9.01965201e-02f, -2.03892246e-01f, 7.48254657e-02f, -6.94557503e-02f, -2.50162017e-02f, 8.76892433e-02f,
  1.47682801e-01f, 4.60405871e-02f, 3.92945856e-01f, 2.19805479e-01f, 7.03037763e-03f, 2.24094748e-01f, 1.91448823e-01f, 1.21397316e-01f, 1.89925492e-01f, 8.83610249e-02f,
  -1.94875762e-01f, 3.81875746e-02f, 1.66586190e-02f, 2.62834784e-02f, -2.89537609e-02f, -8.88106525e-02f, 4.60751988e-02f, 1.21370234e-01f, -3.32410410e-02f, -1.01090772e-02f,
  1.35101890e-03f, 4.29358371e-02f, 5.58830909e-02f, 8.56179278e-03f, -6.73410995e-03f, 3.86243016e-02f, 3.49874534e-02f, 5.17803393e-02f, -2.00738218e-02f, -7.76141956e-02f,
  5.87905645e-02f, -1.52751589e-02f, -5.99033386e-02f, 7.27993762e-03f, 5.58674932e-02f, -3.91410366e-02f, -6.77723531e-03f, 7.68332258e-02f, -1.16845489e-01f, 8.33252817e-02f,
  -6.29888102e-02f, -7.51713663e-02f, -5.23835309e-02f, 4.16474342e-02f, 9.78931878e-03f, -4.19113897e-02f, -1.32221822e-02f, -4.35984656e-02f, 1.00226335e-01f, -5.98847903e-02f,
  1.95176771e-03f, 7.82727897e-02f, -6.52889013e-02f, -1.00998744e-01f, 5.26834093e-02f, -8.48564878e-02f, 7.42050558e-02f, 6.56179711e-02f, 2.93347500e-02f, -8.34061950e-02f,
  -5.85598983e-02f, -2.14152299e-02f, -3.13111171e-02f, -4.29817624e-02f, 3.92558202e-02f, 5.11701442e-02f, 1.34459781e-02f, -3.37480716e-02f, 1.71990674e-02f, -6.87617883e-02f,
  -1.05058499e-01f, 1.60226449e-01f, 2.06558127e-02f, 8.05432722e-02f, 5.00519536e-02f, -1.03109382e-01f, 1.31953657e-01f, 1.26802390e-02f, -3.64356814e-03f, -4.32662182e-02f,
  4.97747473e-02f, -9.93156713e-03f, -1.22985989e-02f, 9.38344747e-02f, -1.50471479e-02f, 2.37676986e-02f, 4.55741026e-02f, 7.86404312e-03f, 7.00309426e-02f, 8.29053950e-03f,
  -2.94418037e-02f, -1.35769457e-01f, 5.45465052e-02f, 2.37041377e-02f, 3.48534845e-02f, -4.24986109e-02f, 3.37981991e-02f, -1.71234850e-02f, 1.39938183e-02f, -3.68672498e-02f,
  -4.55187798e-01f, 8.36236328e-02f, -1.44230813e-01f, -7.02773556e-02f, 1.04388729e-01f, -2.41443217e-01f, -9.52198207e-02f, 8.86419937e-02f, -1.12457506e-01f, 2.13962406e-01f,
  1.87535837e-01f, -2.06517383e-01f, 1.13197900e-01f, -2.20841110e-01f, -3.52764368e-01f, -6.39580116e-02f, -2.50927180e-01f, -1.99910879e-01f, -1.35469228e-01f, -5.84084168e-02f,
  -1.94027409e-01f, -3.28991711e-02f, -2.38500178e-01f, 2.65110768e-02f, -9.46426839e-02f, 8.02878290e-02f, 7.75003880e-02f, 2.30987594e-01f, -5.48428334e-02f, -6.26005884e-03f,
  -3.86910401e-02f, 1.60904124e-01f, 2.48271301e-02f, -9.73889977e-02f, 4.18277234e-02f, -4.90370914e-02f, 5.88369556e-02f, -5.11238500e-02f, 3.21343057e-02f, -5.21285534e-02f,
  -8.73252153e-02f, -8.33414271e-02f, 9.88036953e-03f, -1.87671762e-02f, -3.01264115e-02f, 3.61120030e-02f, -6.78824307e-03f, -8.29518214e-02f, 7.41383731e-02f, -8.29249322e-02f,
  -3.97026204e-02f, 3.05017270e-02f, -2.24266145e-02f, -5.46850227e-02f, -4.70400490e-02f, 9.83499140e-02f, -7.53551275e-02f, -1.03667416e-01f, -1.74096366e-03f, -1.23880409e-01f,
  -7.04584830e-03f, -3.63945924e-02f, -8.83688685e-04f, -3.15341204e-02f, -2.74468847e-02f, 1.26567319e-01f, -5.90523370e-02f, 6.59908354e-02f, 9.18677263e-03f, 9.32603776e-02f,
  -2.17560399e-02f, 3.03934999e-02f, 9.38264877e-02f, -7.54004493e-02f, -1.33515000e-01f, 2.71317624e-02f, 5.48506342e-02f, 1.11502074e-02f, -3.75264995e-02f, 7.21747288e-03f,
  9.06162336e-02f, -2.88780853e-02f, 5.16557656e-02f, 8.43652263e-02f, -1.43634900e-01f, 2.35722139e-02f, -3.55476737e-02f, -1.16704721e-02f, 9.48570967e-02f, -3.89139466e-02f,
  4.85925898e-02f, 1.70395628e-01f, 7.16209644e-03f, 2.48836298e-02f, 7.86597803e-02f, -7.36884214e-03f, -1.20276615e-01f, -1.47548661e-01f, -1.13177877e-02f, -1.17258681e-02f,
  2.91571431e-02f, -8.62365514e-02f, -7.23546520e-02f, 6.96408227e-02f, -1.07799850e-01f, -2.15585046e-02f, 1.28872052e-01f, -6.67601302e-02f, 5.46647012e-02f, 4.56839502e-02f,
  1.70588195e-01f, 9.19879600e-02f, -9.79442000e-02f, -4.04951572e-02f, 3.92972641e-02f, 5.36408201e-02f, 2.18192544e-02f, -3.56463231e-02f, -1.10561112e-02f, -2.48414353e-02f,
  -1.95140481e-01f, 1.79123264e-02f, 4.11386043e-01f, -1.97116449e-01f, -1.21097416e-02f, 2.15701759e-01f, 1.27870247e-01f, 4.32560146e-02f, -1.31008238e-01f, -6.03834726e-02f,
  1.17414899e-01f, 4.98526618e-02f, 1.31927356e-01f, -3.78020778e-02f, 5.20886779e-02f, 4.25771624e-02f, -9.15991813e-02f, -1.02683686e-01f, -9.60660130e-02f, -8.78320187e-02f,
  -5.02706878e-02f, -1.08646698e-01f, 1.24397680e-01f, -3.23242992e-02f, 2.71360055e-02f, -6.46815151e-02f, -8.27333406e-02f, 9.53545049e-02f, -2.31575537e-02f, 1.42807379e-01f,
  -7.24030584e-02f, -1.30775601e-01f, -8.02372247e-02f, 6.25029579e-02f, 9.82745551e-03f, 8.55941698e-02f, 5.83751462e-02f, 4.15629111e-02f, -5.66272289e-02f, -8.64591077e-02f,
  1.13371536e-02f, 1.26043171e-01f, -3.48340459e-02f, -9.14921425e-03f, -2.63744332e-02f, 1.69207398e-02f, 3.01481169e-02f, 7.28858113e-02f, -3.64108346e-02f, 3.03786844e-02f,
  9.16011725e-03f, -2.53709219e-02f, -4.36293185e-02f, 3.33330408e-02f, 6.38959557e-02f, -3.10579408e-02f, -1.16191380e-01f, 2.77070291e-02f, 2.85734851e-02f, -7.71874562e-02f,
  2.00584292e-01f, 8.69664475e-02f, -6.70947600e-03f, -1.57864438e-03f, 7.25173950e-02f, -4.20996696e-02f, -3.61574814e-02f, 1.99924354e-02f, -4.54012305e-02f, -1.21363200e-01f,
  -7.40524083e-02f, 8.96184444e-02f, -6.26743585e-02f, -1.39891431e-01f, -2.48375582e-03f, 3.35408226e-02f, -4.33793254e-02f, -1.00049838e-01f, 3.46349403e-02f, 1.13412431e-02f,
  -1.71127886e-01f, 8.48733112e-02f, 3.67312953e-02f, -3.52227688e-02f, 1.14622358e-02f, 1.78506947e-03f, -5.83138131e-02f, 3.10679730e-02f, -1.75564494e-02f, 6.92797871e-03f,
  -2.61848539e-01f, -1.68487370e-01f, 1.42328376e-02f, -1.21354364e-01f, -1.84217338e-02f, -1.97523274e-03f, 8.77175480e-03f, -4.41849530e-02f, -8.27561840e-02f, 3.68025564e-02f,
  -1.25332130e-02f, -7.37309754e-02f, 8.31147954e-02f, -7.14036748e-02f, 1.12311542e-02f, -8.79008025e-02f, -1.56123973e-02f, -8.36036056e-02f, -1.12060688e-01f, -9.64847952e-03f,
  4.85875048e-02f, -1.80689283e-02f, 3.11140646e-03f, -6.33863807e-02f, -2.13046204e-02f, -6.84120134e-02f, -1.31864831e-01f, -2.60249805e-02f, 4.87055108e-02f, 4.44021747e-02f,
  -1.32703304e-01f, 2.77995020e-01f, -9.84724015e-02f, 3.82186547e-02f, -1.51160276e-02f, 2.18736440e-01f, 1.84770167e-01f, 4.72123399e-02f, 1.89666092e-01f, 2.38643989e-01f,
  9.26702656e-03f, 9.36803967e-02f, -3.76446694e-02f, 1.98165670e-01f, 7.59267509e-02f, 2.21296132e-01f, 2.29506478e-01f, 1.70542523e-01f, -3.43898572e-02f, 4.58657816e-02f,
  -1.86513213e-03f, 4.06326689e-02f, -3.16128060e-02f, -1.64940879e-01f, -1.15292761e-02f, -2.30018094e-01f, -1.97219282e-01f, -1.46896645e-01f, 8.31355155e-03f, 4.13122363e-02f,
  9.56844538e-03f, -1.41208339e-02f, -1.48563147e-01f, -8.76104385e-02f, -6.07311167e-02f, -8.16043466e-02f, -1.34880506e-02f, -1.92408133e-02f, -3.95992249e-02f, -1.36039509e-02f,
  7.88703263e-02f, -4.55106795e-02f, -2.59280559e-02f, 1.18391747e-02f, -1.07537890e-02f, -3.89505699e-02f, 2.79178638e-02f, -2.30957232e-02f, 2.51843818e-02f, 5.53123653e-02f,
  -5.07749990e-02f, 2.59113556e-04f, -3.21553573e-02f, -3.29103991e-02f, 7.56381406e-03f, 4.61049080e-02f, 9.67062861e-02f, -5.66215515e-02f, -3.96907656e-03f, 9.12576988e-02f,
  -6.84071481e-02f, 4.05491516e-02f, -4.44335639e-02f, -5.14264591e-03f, -3.31571214e-02f, -8.71052966e-02f, 2.41863746e-02f, -2.03315057e-02f, -8.15067161e-03f, 7.41502345e-02f,
  -3.07545345e-02f, 1.64090488e-02f, 2.51521505e-02f, 4.12287144e-03f, 1.85462888e-02f, 3.29177491e-02f, -6.85099438e-02f, -1.87206734e-02f, 1.08266994e-02f, 2.12684404e-02f,
  5.45555085e-04f, 7.71674961e-02f, -2.75950599e-02f, 3.48925567e-03f, 5.39703779e-02f, -6.27120957e-02f, -1.88167207e-02f, 5.11957258e-02f, -7.02358857e-02f, 2.82988939e-02f,
  2.21889526e-01f, 1.32105649e-01f, 1.91871021e-02f, -4.34450358e-02f, -3.41087505e-02f, -3.09894066e-02f, -4.12538648e-02f, -3.77105847e-02f, -6.69581667e-02f, -1.75582133e-02f,
  -4.45240848e-02f, 9.42717679e-03f, 2.50745323e-02f, 2.18261350e-02f, -2.41468344e-02f, 1.66584607e-02f, 4.08786312e-02f, -4.70476178e-03f, 1.05460966e-02f, -6.92354739e-02f,
  -5.28002456e-02f, 2.07206956e-03f, 3.54874618e-02f, -7.11062271e-03f, -6.18087687e-02f, -2.41554808e-02f, 4.47075851e-02f, -1.05946831e-01f, -2.94430032e-02f, 8.46226364e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  5.73967360e-02f, 9.08913091e-02f, 3.62522416e-02f, -4.22365554e-02f, 4.23728712e-02f, 1.35997608e-01f, 3.03835440e-02f, -5.36128692e-02f, 4.79505323e-02f, 2.45910175e-02f,
  8.33081305e-02f, 1.54777080e-01f, 9.81691256e-02f, 7.98905343e-02f, 5.01823425e-02f, 6.29716888e-02f, 1.03308842e-01f, 1.42870501e-01f, -1.73279699e-02f, 5.71640916e-02f,
  8.00887048e-02f, -1.48621097e-03f, 9.98625606e-02f, 1.07738018e-01f, 1.43129006e-02f, 1.49819911e-01f, 7.62949139e-02f, -4.00926918e-02f, 1.36617586e-01f, -5.97382970e-02f,
  7.70391822e-02f, -7.54838064e-03f, 1.06972456e-02f, 6.55945912e-02f, 1.63446963e-01f, 4.26404960e-02f, -1.58007294e-02f, 1.27300709e-01f, -2.28989404e-02f, -1.02015566e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -7.28977248e-02f, -6.54364377e-02f, -2.16303244e-02f, -9.17327404e-02f, -4.97843612e-05f, -9.56598595e-02f, -7.60613233e-02f, -4.55609597e-02f, 6.38826564e-02f, -2.09838804e-02f,
  1.51765570e-01f, -7.90867372e-04f, -1.23657438e-03f, 4.96045165e-02f, -5.76152802e-02f, -9.79030952e-02f, -5.86472452e-03f, 8.80120322e-02f, -1.21150903e-01f, -1.25852272e-01f,
  5.96805739e-06f, -1.01636924e-01f, -2.23430231e-01f, 1.56643733e-01f, -1.41262293e-01f, 1.63860228e-02f, -1.01858035e-01f, 1.17290378e-01f, -9.74966884e-02f, -1.87423900e-01f,
  -1.85882896e-02f, -2.63959002e-02f, -1.96452975e-01f, 1.43111106e-02f, 1.56500712e-01f, -1.91579442e-02f, -3.28545943e-02f, -1.49147823e-01f, -5.00506833e-02f, -1.81927860e-01f,
  -8.93745199e-02f, -1.00912400e-01f, -1.16151914e-01f, -1.32353440e-01f, -3.14017967e-03f, 2.68651359e-02f, 1.23206889e-02f, -6.45078048e-02f, -1.26453498e-02f, 4.52130809e-02f,
  2.00828686e-01f, 1.46355219e-02f, 5.21312244e-02f, -1.55101093e-02f, -2.74650659e-02f, 4.51944070e-03f, 1.36828825e-01f, -5.62347174e-02f, -7.47984974e-03f, 3.59069668e-02f,
  -1.81733191e-01f, 6.82373047e-02f, -1.27590582e-01f, 1.36445060e-01f, -4.73135663e-03f, 3.61636654e-02f, 7.67850727e-02f, 8.48882124e-02f, 2.05842778e-03f, 6.38401583e-02f,
  -3.21533568e-02f, 5.60119264e-02f, -5.78193367e-02f, -6.06619492e-02f, 5.74820861e-02f, 1.33569236e-03f, 9.78042707e-02f, 6.98718661e-03f, 3.68192568e-02f, -1.60053983e-01f,
  1.32436387e-03f, -2.20192336e-02f, -2.31122315e-01f, -7.94109404e-02f, -2.20674157e-01f, 1.29842952e-01f, 1.05752580e-01f, 4.21888940e-02f, 1.89992064e-03f, 1.07435331e-01f,
  -1.18455760e-01f, 6.84006661e-02f, -1.26167014e-01f, -1.56100029e-02f, -8.84031728e-02f, 4.04519439e-02f, -9.85142067e-02f, -7.49655664e-02f, -1.76910702e-02f, 7.58237168e-02f,
  1.86263800e-01f, -2.21241802e-01f, 5.18624298e-03f, 6.67266771e-02f, 1.20371215e-01f, -2.70512998e-01f, -7.68944845e-02f, -2.60362023e-04f, -3.53754424e-02f, -6.07089661e-02f,
  -1.17650032e-01f, -2.82918736e-02f, -4.48001437e-02f, 8.02446157e-02f, 1.81939036e-01f, -1.61499485e-01f, -6.02688342e-02f, -1.80587932e-01f, -1.11446977e-01f, 7.20156059e-02f,
  1.94247112e-01f, 1.69981215e-02f, -3.58747952e-02f, 3.86359803e-02f, -1.17260486e-01f, -2.26847604e-02f, 1.76465839e-01f, 8.77161697e-02f, -2.92719454e-02f, 4.30759154e-02f,
  -7.47193694e-02f, 6.14915304e-02f, -1.08763836e-01f, -5.68558834e-02f, 5.08542620e-02f, -2.51946691e-02f, -1.18517689e-02f, 1.34288847e-01f, -7.85614774e-02f, -1.16217854e-02f,
  -1.37960523e-01f, -8.18424001e-02f, -1.92783494e-03f, 1.21148499e-02f, 2.16302592e-02f, 1.39485314e-01f, -1.23662472e-01f, -5.07247727e-03f, 1.93912491e-01f, -2.98515894e-03f,
  9.71942618e-02f, -2.28805900e-01f, 6.55322522e-02f, 4.75043990e-03f, -7.89825395e-02f, -1.50741279e-01f, 8.08568299e-02f, -5.06311394e-02f, 9.14898887e-02f, 5.41508570e-02f,
  -1.55218929e-01f, -4.79282765e-03f, 1.18905790e-01f, -1.52401514e-02f, -9.58897620e-02f, -4.99839820e-02f, 1.80372059e-01f, -4.46278490e-02f, 7.28451833e-02f, -7.63193741e-02f,
  9.96729508e-02f, -1.95432782e-01f, 1.22192271e-01f, -6.19335808e-02f, -1.00169048e-01f, -7.35619515e-02f, -5.71896248e-02f, 1.44275308e-01f, -1.45529941e-01f, -3.34554240e-02f,
  5.95875792e-02f, -5.46866804e-02f, 1.23379089e-01f, -5.24405986e-02f, 9.02342573e-02f, 4.80459854e-02f, -1.34077007e-02f, -2.15187624e-01f, 6.97527751e-02f, 2.03459233e-01f,
  1.51432864e-02f, -3.69666591e-02f, -8.68536904e-02f, -1.29475996e-01f, -7.32186213e-02f, 6.29994050e-02f, -5.60780428e-02f, -5.45810647e-02f, 5.70211709e-02f, -5.09786904e-02f,
  6.17988855e-02f, -5.76318428e-03f, -7.25003332e-03f, 1.11057144e-02f, -1.03315294e-01f, -2.93925237e-02f, 1.00559354e-01f, -7.88707808e-02f, 4.75544780e-02f, 8.35557953e-02f,
  -2.36943081e-01f, -1.26951531e-01f, 1.45328373e-01f, 1.30660906e-01f, -1.32747546e-01f, -1.61213711e-01f, -2.06625700e-01f, -1.40482083e-01f, -8.67228303e-03f, 3.28137949e-02f,
  -1.31267160e-01f, -9.71719101e-02f, -1.37981087e-01f, -1.80301160e-01f, -1.76307768e-01f, 1.19045459e-01f, -1.36435643e-01f, 1.26503766e-01f, -5.58763742e-02f, -7.98120201e-02f,
  -1.24514438e-01f, -2.40484700e-01f, 8.89436007e-02f, -6.72603548e-02f, -1.65570870e-01f, -1.10167816e-01f, 1.75800115e-01f, -1.23609617e-01f, -1.55882195e-01f, -1.12967998e-01f,
  -3.85635979e-02f, 2.88979281e-02f, 7.39214793e-02f, -2.57118434e-01f, 5.16514033e-02f, -4.77585522e-03f, -1.61903232e-01f, -1.09467581e-01f, -5.27090095e-02f, -8.20387378e-02f,
  7.34475330e-02f, -2.13743940e-01f, -1.80328041e-01f, 1.80819586e-01f, 7.68310344e-03f, -4.43690494e-02f, -1.44125549e-02f, 7.18558952e-02f, -4.43302244e-02f, -1.11307330e-01f,
  6.87673762e-02f, -3.08305100e-02f, -5.82206203e-03f, -4.89678094e-03f, 8.61631185e-02f, -5.68473861e-02f, 1.33776173e-01f, -4.45197299e-02f, 4.28449698e-02f, -4.09249701e-02f,
  -3.52342650e-02f, -1.07960321e-01f, -3.64497192e-02f, 4.79512215e-02f, -2.27079719e-01f, -2.17256114e-01f, -4.82429415e-02f, -2.40710881e-02f, -2.33198553e-01f, 1.60735905e-01f,
  -1.50934786e-01f, 1.78014562e-01f, -1.55452594e-01f, 1.04958378e-01f, -1.93501100e-01f, -1.00051597e-01f, -5.15653118e-02f, 7.14722127e-02f, -1.37671068e-01f, 2.64616124e-02f,
  4.73784544e-02f, -4.49190959e-02f, -1.31890818e-01f, -1.66099608e-01f, -4.25262675e-02f, -3.83651406e-02f, -1.10377848e-01f, -2.61176020e-01f, -2.54327506e-02f, -6.73367530e-02f,
  1.10284612e-01f, -7.36559555e-02f, -5.40199950e-02f, -5.16019799e-02f, 1.23052776e-01f, -3.67993005e-02f, 2.50227153e-01f, -1.62761524e-01f, -5.49624935e-02f, -1.52049854e-01f,
  -6.95336536e-02f, 2.13631481e-01f, 1.41237438e-01f, -1.00074388e-01f, -3.39333229e-02f, 1.40868068e-01f, -2.65658021e-01f, -8.17401856e-02f, -1.02611974e-01f, 1.33713245e-01f,
  4.00469117e-02f, 1.12588778e-01f, 9.40629542e-02f, -4.27816063e-02f, 5.69157489e-02f, 1.03948310e-01f, 1.47405893e-01f, -5.68149686e-02f, -2.28030309e-02f, 4.11350094e-03f,
  -3.55831981e-02f, -1.37655213e-02f, -1.72782806e-03f, -9.97015312e-02f, -8.56044441e-02f, 3.99649665e-02f, -1.54231384e-01f, 9.05462261e-03f, -1.32960200e-01f, 6.83433414e-02f,
  -9.53773037e-02f, -3.78043507e-03f, 1.14097171e-01f, -1.34687766e-01f, -1.53340235e-01f, 1.74035076e-02f, -1.22953519e-01f, -2.09266767e-01f, -7.38532320e-02f, 1.71474665e-01f,
  4.38834950e-02f, -3.10858302e-02f, 2.17422098e-03f, -3.05324867e-02f, -7.69203678e-02f, -6.82393163e-02f, 7.51786157e-02f, -2.04724781e-02f, -7.23661482e-02f, 2.61751562e-01f,
  -1.77023485e-02f, 3.64342369e-02f, 2.10014850e-01f, 2.35052761e-02f, 9.04603228e-02f, -1.70916453e-01f, -1.42107382e-01f, 9.97108519e-02f, 1.31914005e-01f, -9.42651853e-02f,
  -9.73097757e-02f, 6.21391535e-02f, 1.94733627e-02f, -2.27644399e-01f, -1.03135452e-01f, 7.58296624e-02f, 6.19299244e-03f, -1.60483286e-01f, 4.02341075e-02f, -1.69851542e-01f,
  6.66222274e-02f, -2.63148785e-01f, 1.24377847e-01f, -2.20345762e-02f, 7.98464864e-02f, 4.98686656e-02f, 8.09153467e-02f, -6.82988763e-02f, -2.97664143e-02f, 4.83716764e-02f,
  -1.19497947e-01f, 7.89949521e-02f, -7.70177767e-02f, -1.04857527e-01f, -6.45613819e-02f, 6.84744120e-02f, 1.40377209e-02f, 1.43550206e-02f, -8.93510580e-02f, 5.83654363e-03f,
  6.65119588e-02f, -1.12881973e-01f, -9.18584839e-02f, -7.12450892e-02f, -1.97909981e-01f, 2.79363602e-01f, 3.08698505e-01f, -1.69624552e-01f, 1.39224708e-01f, 8.21692869e-02f,
  -4.22491692e-02f, 9.15873647e-02f, -1.44680873e-01f, 1.08757302e-01f, -2.91374139e-02f, 6.22383170e-02f, 1.60926208e-01f, -2.04952046e-01f, -1.16795540e-01f, 1.10120572e-01f,
  1.44980907e-01f, -2.24983990e-01f, -4.99088019e-02f, 9.03478116e-02f, 6.28391281e-02f, -2.98814923e-01f, -3.66844162e-02f, 3.73749994e-02f, -6.27836213e-02f, -5.97194396e-02f,
  -1.83382794e-01f, 4.11971435e-02f, -1.43755659e-01f, -5.80217801e-02f, -1.09059982e-01f, -4.28275652e-02f, -1.37355119e-01f, 9.88539159e-02f, -2.33849615e-01f, 1.87950004e-02f,
  8.90978873e-02f, -4.77227904e-02f, -1.47767276e-01f, 7.02516292e-04f, -2.10319042e-01f, -5.78024052e-02f, 1.95208848e-01f, -1.67706415e-01f, -4.46939375e-03f, 5.15492968e-02f,
  5.23234205e-03f, 2.20836084e-02f, -8.44816491e-02f, -1.48232374e-02f, 2.24442454e-03f, -5.94545305e-02f, 6.52401373e-02f, 1.02167213e-02f, -6.94055185e-02f, 6.65221289e-02f,
  -9.82742384e-02f, -2.12153401e-02f, 4.15639253e-03f, -7.57516846e-02f, 4.15840559e-02f, 1.45560920e-01f, -3.46604317e-01f, -1.45513341e-01f, -2.78536957e-02f, 9.11790580e-02f,
  -6.13743486e-03f, -1.84799775e-01f, -1.02697693e-01f, -2.74205413e-02f, -4.62597422e-02f, 5.54286502e-02f, -1.45714760e-01f, -5.71074672e-02f, -5.61540574e-02f, -2.67268606e-02f,
  -5.18363900e-02f, -7.23491982e-02f, -4.28994484e-02f, 7.90528059e-02f, 2.11265180e-02f, -2.11477786e-01f, -4.69330475e-02f, -2.64825728e-02f, 1.52146593e-01f, -2.24863589e-01f,
  -2.26147976e-02f, -1.20881081e-01f, 1.70272410e-01f, -1.93508297e-01f, -2.39852428e-01f, -1.09801330e-02f, -1.61404982e-02f, 1.55974366e-02f, 5.15274182e-02f, -1.15855582e-01f,
  3.72862741e-02f, -1.02288358e-01f, -8.59238058e-02f, 1.86216626e-02f, 6.06737658e-02f, -1.73625067e-01f, -1.93801038e-02f, -1.70814499e-01f, -1.95330843e-01f, 1.62081018e-01f,
  1.01343684e-01f, -4.84167933e-02f, -3.47798516e-04f, -2.80621415e-03f, 6.62714988e-03f, -4.45454083e-02f, -8.05574190e-03f, 1.57074537e-02f, 1.08437732e-01f, 1.87809847e-03f,
  -2.91448161e-02f, -3.00204288e-02f, -1.09183602e-01f, -1.60060655e-02f, 9.70963091e-02f, -6.02687784e-02f, 2.36185730e-01f, 1.83245111e-02f, -9.67069790e-02f, -1.46338046e-01f,
  1.06834225e-01f, 2.38672763e-01f, -2.41325170e-01f, 2.50818823e-02f, 5.08915000e-02f, -3.81373763e-02f, -1.18844964e-01f, -1.54542979e-02f, 1.99580401e-01f, -8.03175196e-02f,
  -2.61228532e-02f, 2.51551688e-01f, -2.14760587e-01f, -2.06208721e-01f, 1.75970033e-01f, -5.07366247e-02f, -1.23106100e-01f, 9.28702299e-03f, 1.83351368e-01f, 1.69708103e-01f,
  -2.26850048e-01f, -1.14480957e-01f, 3.54725085e-02f, 2.16661140e-01f, -6.12203293e-02f, 2.62111932e-01f, -1.73772529e-01f, -1.40827507e-01f, 1.43336460e-01f, 1.86591402e-01f,
  -9.63521972e-02f, -2.65560389e-01f, -7.39141107e-02f, -4.39165942e-02f, -7.19422996e-02f, -3.66801023e-02f, 3.77718844e-02f, -2.21885890e-01f, -2.00700000e-01f, -1.49610683e-01f,
  2.13411286e-01f, -6.56606331e-02f, -5.10060154e-02f, -3.00934792e-01f, 1.76644921e-01f, -1.14236372e-02f, 4.56334241e-02f, 2.72417348e-02f, 4.89145331e-02f, 1.10924937e-01f,
  4.50956114e-02f, 5.73031642e-02f, -5.42106889e-02f, 1.36656821e-01f, 1.07021146e-01f, -5.15094288e-02f, 1.17809726e-02f, -4.84817922e-02f, -5.10476381e-02f, 1.08148940e-02f,
  9.82367769e-02f, -1.18532829e-01f, 1.05705179e-01f, -5.07823005e-02f, -1.55864051e-02f, 8.29942599e-02f, -7.19755366e-02f, 2.42086425e-01f, -7.58106634e-02f, 1.51545936e-02f,
  -6.25468930e-03f, -8.56049508e-02f, 1.53632253e-01f, 2.99366564e-01f, -4.65592556e-02f, 1.36651993e-02f, -8.08073506e-02f, -8.72870162e-02f, -2.90766824e-03f, 5.65717369e-03f,
  -1.69873029e-01f, 1.57059029e-01f, 5.55890426e-02f, -6.16934113e-02f, -1.10411428e-01f, -1.77505463e-01f, 5.98286390e-02f, -1.85235329e-02f, -1.97347011e-02f, -1.11298393e-02f,
  -5.72713725e-02f, -1.12116486e-01f, 1.62804201e-01f, -1.09332271e-01f, -1.38359010e-01f, -5.35315834e-02f, 2.17601229e-02f, -1.61730677e-01f, -3.52024660e-02f, 3.07844967e-01f,
  -1.30557179e-01f, -5.63870184e-02f, 3.53591703e-02f, -3.46272737e-02f, 1.49294347e-01f, 3.58071737e-02f, -1.24402478e-01f, 1.01065159e-01f, -2.02917848e-02f, -3.63746323e-02f,
  -1.05430588e-01f, -4.44055488e-03f, 4.76498436e-03f, 4.33090329e-02f, 7.12165534e-02f, 8.48613530e-02f, -1.21732332e-01f, 1.79317549e-01f, -5.37932999e-02f, -4.29481193e-02f,
  -1.54624030e-01f, 1.92406222e-01f, -1.49191722e-01f, 1.25106573e-01f, -7.57923117e-03f, -5.39111979e-02f, 1.59321234e-01f, -2.32522190e-02f, -1.55481935e-01f, -1.31339982e-01f,
  -1.80918574e-01f, 3.11237872e-01f, 1.62434712e-01f, -5.78552559e-02f, 1.30598977e-01f, 7.52982423e-02f, -2.41538733e-02f, 2.71283180e-01f, -1.88901871e-01f, 5.14654107e-02f,
  -2.20990777e-02f, -4.01299335e-02f, 5.78839332e-02f, -1.84303850e-01f, -1.98467463e-01f, 1.38018891e-01f, 8.35832804e-02f, -1.32318884e-01f, -4.74397391e-02f, -5.82876615e-02f,
  8.39043185e-02f, -2.68667072e-01f, -4.65703718e-02f, 7.42403492e-02f, -8.19830820e-02f, -1.37510791e-01f, -4.33300361e-02f, -3.93245108e-02f, -9.40868482e-02f, 6.59274310e-02f,
  1.53425587e-02f, -2.32763976e-01f, -5.33135831e-02f, 2.64417768e-01f, -2.32412472e-01f, -2.11189315e-03f, 1.73492860e-02f, 6.64286927e-06f, -6.09867573e-02f, 6.79213107e-02f,
  -2.16323033e-01f, 2.00383902e-01f, 1.93879921e-02f, -2.11513918e-02f, 1.05742507e-01f, 2.23116726e-02f, -2.49486566e-02f, 2.98122037e-02f, 7.39148632e-02f, 3.48914675e-02f,
  5.45481481e-02f, -8.84490237e-02f, -1.16885960e-01f, -1.20525368e-01f, 1.35704711e-01f, 9.21123177e-02f, 1.46403834e-01f, -1.22918777e-01f, -1.74960986e-01f, -5.27550653e-02f,
  -1.11061580e-01f, -8.25228542e-02f, -1.59516960e-01f, -1.70342341e-01f, -2.77027458e-01f, 1.87159365e-03f, -1.84231903e-02f, 2.80748885e-02f, -1.00649230e-01f, 2.26714760e-01f,
  -9.55547094e-02f, 1.84179042e-02f, -8.83157477e-02f, 8.53871182e-02f, 1.13093674e-01f, 9.12447274e-02f, -1.05598450e-01f, -5.43656684e-02f, -6.04548343e-02f, -2.61246525e-02f,
  1.09173127e-01f, -1.38591722e-01f, -4.23564613e-02f, 1.71936065e-01f, -5.13209440e-02f, -1.02154210e-01f, 1.71194524e-01f, -5.27927093e-03f, 3.11953278e-04f, 8.54480080e-03f,
  -1.09960891e-01f, -4.38608713e-02f, 1.90196484e-01f, -1.09533548e-01f, 1.30098969e-01f, -1.03573889e-01f, -1.06815519e-02f, -2.37740234e-01f, -6.40498474e-02f, 2.68927395e-01f,
  2.21689433e-01f, -4.36680354e-02f, 1.47774657e-02f, 2.93498561e-02f, -1.53126940e-01f, -6.16475232e-02f, 8.55279714e-02f, 2.05282673e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.69228428e-03f, 3.04802451e-02f, 1.06807739e-01f, -1.95224001e-03f, 1.54216075e-02f, 5.68408854e-02f, 9.73729696e-03f, 6.66827857e-02f, 8.52003992e-02f, -1.61173400e-02f,
  8.12065378e-02f, 7.36991912e-02f, 8.12437199e-03f, 6.16349578e-02f, -1.62448123e-01f, -6.44452125e-02f, 7.18329698e-02f, 6.07052296e-02f, -1.16289288e-01f, -1.64495707e-01f,
  4.20771316e-02f, 9.12849456e-02f, 3.70414034e-02f, 8.05411786e-02f, 2.50484288e-01f, 1.78343281e-01f, -1.32059142e-01f, 1.44088253e-01f, 7.46477991e-02f, -9.07267332e-02f,
  9.76833254e-02f, 1.05113626e-01f, -5.45422509e-02f, -8.64549540e-03f, 1.83344781e-01f, 8.79215822e-02f, 1.04253024e-01f, -1.23842508e-01f, 1.25177220e-01f, -1.80412624e-02f,
  -2.28195656e-02f, -2.80620456e-01f, -2.80559417e-02f, -1.15938656e-01f, 9.03756171e-02f, 2.15130880e-01f, -1.67203411e-01f, -7.45354071e-02f, -2.60507707e-02f, 2.55904078e-01f,
  -4.41491092e-03f, 2.01251402e-01f, 4.02783900e-02f, -1.26043465e-02f, 6.22101203e-02f, 1.73185050e-01f, 8.94072652e-02f, 1.96498141e-01f, -1.08636636e-02f, -9.15732235e-02f,
  1.33353069e-01f, 8.53734538e-02f, -1.82836689e-02f, 3.92308719e-02f, 4.55124713e-02f, 4.18279618e-02f, 1.68525308e-01f, 9.19520482e-02f, 1.06920637e-01f, 8.50292221e-02f,
  7.68410116e-02f, -6.62866607e-02f, 9.44412425e-02f, -2.29935572e-02f, 1.39796212e-01f, 1.43820629e-01f, 3.03137973e-02f, 8.26081410e-02f, 2.56490614e-02f, -5.69953993e-02f,
  8.51194784e-02f, -1.78066231e-02f, -2.82119244e-01f, -9.25337970e-02f, -1.22729145e-01f, 1.57492440e-02f, -9.24967304e-02f, 1.13105178e-01f, -1.21545168e-02f, 2.26811126e-01f,
  -1.27330989e-01f, 1.36314139e-01f, -1.69940531e-01f, -6.43166527e-02f, 4.19009887e-02f, -5.24101630e-02f, -1.18348733e-01f, -7.28033930e-02f, 1.44368529e-01f, 1.79947868e-01f,
  1.80415168e-01f, -2.17796862e-01f, 2.90499488e-03f, -6.56161308e-02f, 7.41557032e-02f, -2.12347448e-01f, -6.00706935e-02f, 2.73612272e-02f, 3.88531163e-02f, -2.73784883e-02f,
  -9.37903151e-02f, -2.30899407e-03f, -1.53367466e-03f, 8.64827186e-02f, 2.60675043e-01f, -4.88296039e-02f, 9.70713720e-02f, -9.95773301e-02f, -1.00411363e-01f, 1.29254684e-01f,
  2.09530100e-01f, -9.55042318e-02f, 1.19436100e-01f, 1.24074027e-01f, -7.13952184e-02f, 6.91331411e-03f, 1.19782470e-01f, 1.50402963e-01f, 1.73773423e-01f, 1.48135975e-01f,
  -7.87160397e-02f, 2.30375566e-02f, 7.92572871e-02f, -1.72191113e-02f, 1.33453816e-01f, -7.29330778e-02f, -4.84680720e-02f, 8.95471871e-02f, 7.71176517e-02f, 3.35898139e-02f,
  4.70863022e-02f, -1.57954961e-01f, 9.19744670e-02f, 8.28268304e-02f, -1.39098391e-01f, 1.36632817e-02f, 4.48089801e-02f, 1.02059580e-01f, 5.05622849e-02f, -2.05158308e-01f,
  -1.96310431e-01f, 4.42883596e-02f, -1.57810584e-01f, -3.64095122e-02f, 1.01129584e-01f, -1.02059193e-01f, -9.71179921e-03f, 8.53571743e-02f, 1.23155285e-02f, 3.07357684e-02f,
  -5.73432408e-02f, 1.89564198e-01f, -5.79841956e-02f, -8.72617066e-02f, -1.02150448e-01f, 1.25618801e-01f, 5.86093478e-02f, 7.56694237e-03f, -1.05973169e-01f, 2.28978679e-01f,
  1.42913476e-01f, 1.26398820e-02f, 3.64502445e-02f, -6.03277273e-02f, 4.31435443e-02f, 7.14699179e-02f, 1.97577745e-01f, 2.71455199e-02f, -4.16258769e-03f, -2.14573252e-03f,
  1.17717929e-01f, -1.71688929e-01f, 8.73633400e-02f, -2.80607305e-02f, 2.59738229e-02f, -9.18987542e-02f, 1.44367635e-01f, 4.12511677e-02f, 1.01250246e-01f, -1.22244492e-01f,
  -7.93883428e-02f, 4.51588929e-02f, -4.41609509e-02f, -2.20141876e-02f, 8.16052034e-02f, 1.94509804e-01f, 7.40157962e-02f, 8.80195349e-02f, 7.88746476e-02f, -2.53686961e-02f,
  1.54120892e-01f, 1.01887777e-01f, 5.79678938e-02f, 3.57592218e-02f, -1.57261744e-01f, 7.58126229e-02f, 1.60366908e-01f, -5.79239652e-02f, 9.59265679e-02f, 3.11992783e-02f,
  -1.13239050e-01f, -8.65034312e-02f, 1.37678027e-01f, -2.31428202e-02f, -1.36411160e-01f, -9.46141314e-03f, -5.50168902e-02f, -4.58594970e-02f, -2.17216252e-03f, 6.40727803e-02f,
  2.13959298e-04f, -9.67630446e-02f, -4.90368763e-03f, -3.20094451e-02f, -1.35703236e-01f, 1.97792232e-01f, 1.72244370e-01f, 3.50982882e-02f, 1.40579380e-02f, 3.78538631e-02f,
  -7.43572116e-02f, -1.80029213e-01f, 1.55225575e-01f, -5.93080744e-02f, -1.67249888e-01f, -4.93226275e-02f, 2.00772062e-01f, 1.07926637e-01f, 1.73687022e-02f, -1.47624398e-02f,
  -5.23191616e-02f, 1.00953326e-01f, 6.74700737e-02f, 1.18124112e-02f, 1.82613537e-01f, -1.50187872e-03f, 1.34251220e-02f, -3.94522995e-02f, 1.30197722e-02f, 6.51153028e-02f,
  1.49846539e-01f, 3.00138202e-02f, -9.02133957e-02f, 2.91872829e-01f, 4.99248318e-02f, 9.11907628e-02f, -1.53933624e-02f, 7.94698447e-02f, 1.50497230e-02f, 1.13986984e-01f,
  9.83508825e-02f, -3.98306809e-02f, 7.62628764e-02f, -8.07486400e-02f, 1.00728646e-01f, -1.36829931e-02f, 1.70801044e-01f, -2.15852037e-02f, 4.13897932e-02f, 4.72940840e-02f,
  -4.46850508e-02f, 4.07094136e-02f, 8.72652512e-03f, 4.64299954e-02f, 1.05798200e-01f, -5.36937006e-02f, 1.57610461e-01f, -9.76964384e-02f, -2.20460609e-01f, 1.06355354e-01f,
  1.16844904e-02f, -1.00489631e-02f, 1.08239967e-02f, -9.36039314e-02f, 1.31704196e-01f, -1.79672152e-01f, 8.37435499e-02f, 1.10589728e-01f, -1.12507164e-01f, 2.15260148e-01f,
  1.47996888e-01f, -1.01319000e-01f, -1.12661041e-01f, 1.59589965e-02f, 1.29884034e-01f, -2.44298042e-03f, -7.29439259e-02f, 1.19441494e-01f, -9.87548009e-02f, -2.79584415e-02f,
  1.29982024e-01f, 1.73323542e-01f, 2.99937814e-03f, -5.56177460e-02f, 5.80530949e-02f, 1.23104230e-02f, 2.77470108e-02f, 1.83263198e-01f, 1.80499062e-01f, -5.36868796e-02f,
  9.05863643e-02f, 8.68159346e-03f, 1.35974186e-02f, 6.64702207e-02f, 5.03007323e-02f, 2.82475501e-02f, 1.40840858e-01f, 9.67901871e-02f, -1.23836219e-01f, 1.47662789e-01f,
  2.78223753e-02f, 1.33119211e-01f, -8.75506252e-02f, 1.51454993e-02f, 8.67099613e-02f, -7.32942596e-02f, 9.12316144e-02f, -5.89792542e-02f, 1.27898350e-01f, 9.57781300e-02f,
  3.35939229e-02f, 9.97895822e-02f, -2.40570810e-02f, -5.68788499e-02f, -8.53124708e-02f, 3.49693522e-02f, -4.76642549e-02f, 9.27960053e-02f, -1.45188317e-01f, -2.17235401e-01f,
  1.54863000e-01f, -1.35242611e-01f, -1.74066141e-01f, 3.51013988e-02f, 8.14991221e-02f, 1.22320406e-01f, -9.92301106e-02f, -5.92785180e-02f, 2.83184387e-02f, -1.36777699e-01f,
  8.61666650e-02f, 6.81602284e-02f, -9.43656117e-02f, 8.93252939e-02f, 1.33037686e-01f, -3.85971554e-02f, -8.05761889e-02f, -1.21486142e-01f, 3.40408720e-02f, 2.76468508e-02f,
  -2.29645520e-02f, -1.33782707e-03f, -1.69392545e-02f, -1.04147948e-01f, 2.04505965e-01f, 1.23837404e-02f, -8.44300240e-02f, -6.29876927e-02f, 5.93861789e-02f, 9.63946655e-02f,
  -1.58375334e-02f, 4.39983979e-02f, 1.51708797e-02f, -3.82261612e-02f, 9.50831771e-02f, 1.51349500e-01f, 1.16023645e-01f, 4.58653755e-02f, -9.56945419e-02f, -4.12340648e-03f,
  8.27779472e-02f, 4.38540131e-02f, -1.11643314e-01f, 3.30921896e-02f, 2.79731750e-02f, 3.38123441e-02f, 1.41642034e-01f, 1.73315704e-02f, 6.34773960e-03f, 4.80775014e-02f,
  1.91409886e-02f, 4.85620610e-02f, -4.52842861e-02f, 8.18784523e-04f, -2.71914825e-02f, 1.30534455e-01f, -7.00439662e-02f, 2.54935808e-02f, -2.12272275e-02f, -6.47853389e-02f,
  1.27428817e-02f, -1.05068676e-01f, -8.73846337e-02f, 3.19396965e-02f, -1.77536577e-01f, 8.63844007e-02f, 2.46883467e-01f, -1.28860831e-01f, 4.83485721e-02f, 9.84263197e-02f,
  -1.51568176e-02f, -5.75826922e-03f, -9.02046412e-02f, 1.25591069e-01f, -4.33284463e-03f, -4.78126742e-02f, 1.52851924e-01f, -1.00857645e-01f, -2.66837589e-02f, 6.06541373e-02f,
  1.48854569e-01f, -1.12472422e-01f, -3.74956243e-02f, 1.29415274e-01f, 1.04671516e-01f, -1.33458138e-01f, 9.50863492e-03f, 4.19759285e-03f, -4.08626609e-02f, -9.28856507e-02f,
  -9.56526324e-02f, -4.29834314e-02f, -7.06836134e-02f, 1.19557418e-03f, 1.97294373e-02f, 1.17406156e-02f, 5.36524225e-03f, -1.07988432e-01f, -9.74133834e-02f, 1.96585953e-02f,
  3.90718039e-03f, -9.48916972e-02f, 4.10728864e-02f, 4.64186212e-03f, 1.46143846e-02f, -5.79185635e-02f, 2.36713916e-01f, 2.82948222e-02f, 1.42163977e-01f, 1.15031853e-01f,
  1.21155642e-01f, 1.81667472e-03f, -2.06417553e-02f, 5.35957664e-02f, 1.10866472e-01f, 2.21279953e-02f, 2.15003989e-03f, 1.14735350e-01f, -1.05774425e-01f, 7.02000281e-04f,
  8.95355642e-02f, 3.94891240e-02f, -5.92084080e-02f, 1.26294454e-03f, -9.63654146e-02f, 6.58924356e-02f, 5.14321364e-02f, 1.24637812e-01f, 8.16955492e-02f, 6.04243986e-02f,
  2.05117911e-01f, -1.44808441e-01f, 1.30261108e-01f, 4.03060485e-03f, -1.04706876e-01f, -1.47019550e-01f, 1.44861385e-01f, 1.89059108e-01f, 7.11481124e-02f, 1.03833934e-03f,
  1.64735273e-01f, 8.30211211e-03f, -3.84394452e-03f, 2.93891295e-03f, 1.64582077e-02f, 1.25132874e-01f, 1.06676526e-01f, 1.80973873e-01f, -3.90390232e-02f, 3.44547592e-02f,
  1.59622207e-01f, -7.16787800e-02f, 5.91747947e-02f, 3.92528363e-02f, -3.76607515e-02f, 4.98009846e-02f, 1.05900683e-01f, 8.24596733e-02f, -1.89292371e-01f, 8.71534869e-02f,
  -1.42029105e-02f, -7.89869726e-02f, 4.05288907e-03f, 1.66844111e-02f, -1.10247545e-01f, 5.07842079e-02f, -6.05410449e-02f, -6.15165681e-02f, 1.24746799e-01f, -8.70429203e-02f,
  4.48884815e-02f, -8.03033486e-02f, 7.74149820e-02f, 1.08938470e-01f, 8.65442678e-02f, -5.62001346e-03f, 9.55943912e-02f, 4.96914387e-02f, 1.05422005e-01f, 4.65820916e-02f,
  4.81241718e-02f, 1.41612478e-02f, 1.48417562e-01f, 6.53575361e-02f, 7.20791519e-02f, -6.96645211e-03f, 7.81515241e-02f, -1.38365123e-02f, -6.54523522e-02f, -1.68721288e-01f,
  1.59689132e-02f, 2.24224757e-03f, -1.55304879e-01f, 2.71991398e-02f, -1.18269853e-01f, 2.33552352e-01f, -6.47844225e-02f, 1.08177245e-01f, 5.47633134e-02f, 8.31016526e-02f,
  1.49773182e-02f, -2.09141453e-03f, -4.78201285e-02f, -2.53377762e-02f, -8.24839473e-02f, -1.18366221e-03f, -3.64602096e-02f, 1.22258954e-01f, 7.35934377e-02f, 1.84237976e-02f,
  -7.98434615e-02f, -4.62598428e-02f, -1.36917625e-02f, 7.63588771e-02f, -9.56934467e-02f, 1.91127539e-01f, -1.08679220e-01f, -1.40873659e-02f, 1.54198319e-01f, 8.17659032e-03f,
  2.79456396e-02f, -1.50178283e-01f, 1.52789399e-01f, 2.02776156e-02f, 1.03750844e-02f, 7.80045940e-03f, 7.27163209e-03f, -2.30731349e-02f, 8.29392299e-02f, 7.54276477e-03f,
  6.69746846e-02f, 1.01833180e-01f, -4.94159199e-02f, -1.59167305e-01f, 2.07273215e-02f, 2.18227580e-01f, 9.79052708e-02f, 2.71034855e-02f, -1.83563516e-03f, -6.38825893e-02f,
  1.16583616e-01f, 1.13948852e-01f, 1.95348427e-01f, 1.93993319e-02f, 6.69134024e-04f, 1.51666701e-01f, 2.84729470e-02f, -9.22806486e-02f, 8.78911912e-02f, -4.42891866e-02f,
  1.08719029e-01f, 4.42054681e-02f, -8.58275369e-02f, -1.45727322e-01f, -6.41221777e-02f, 2.04873547e-01f, -4.97416332e-02f, -2.24554226e-01f, -1.59380361e-01f, 8.39990601e-02f,
  -2.27130175e-01f, -7.48212333e-04f, 8.96696895e-02f, -4.56780754e-02f, -3.13678756e-02f, 2.19976440e-01f, 1.61188215e-01f, -6.78203627e-02f, 7.70771503e-02f, 2.72405357e-03f,
  -1.17343329e-01f, -8.56031775e-02f, -6.26805946e-02f, 9.69161168e-02f, -2.98940726e-02f, 6.65568933e-02f, -1.02349870e-01f, 3.13825369e-01f, 1.49817914e-01f, 1.40147194e-01f,
  4.60183360e-02f, -1.18892156e-01f, 1.18801713e-01f, 4.15277630e-02f, 2.64338136e-01f, -6.43130615e-02f, 6.59418479e-02f, -1.24866737e-03f, 4.30717506e-02f, -2.05602422e-01f,
  1.48176268e-01f, -4.41082343e-02f, 6.77979961e-02f, -1.16047606e-01f, 1.39685497e-01f, 1.04977407e-01f, -3.94165469e-03f, -3.12062383e-01f, -1.22990549e-01f, 1.62485078e-01f,
  1.54476628e-01f, 2.97418777e-02f, -6.15922138e-02f, 6.10889755e-02f, 1.23509586e-01f, 8.52080882e-02f, 1.30061209e-01f, -6.54995516e-02f, -5.34578003e-02f, 1.18782759e-01f,
  9.71417129e-02f, -1.00139186e-01f, -5.33159710e-02f, -9.85246524e-02f, 1.17289275e-01f, 4.23794538e-02f, -6.86018169e-02f, 1.17498770e-01f, 5.15943617e-02f, 1.84421510e-01f,
  2.43650615e-01f, -1.87766179e-01f, -9.92915407e-02f, -1.93164758e-02f, -4.68372516e-02f, -1.43164024e-01f, 1.44674972e-01f, -1.76117450e-01f, 1.43048793e-01f, 3.96980233e-02f,
  -2.51707435e-02f, -6.36071190e-02f, -6.35205656e-02f, 2.79808223e-01f, 7.31499940e-02f, -6.76439404e-02f, -1.72423154e-01f, 2.50011444e-01f, 7.97567666e-02f, -8.35782737e-02f,
  -1.41230673e-01f, 2.49789700e-01f, 3.14063728e-02f, 4.18772623e-02f, 1.43425420e-01f, -1.00391991e-02f, 6.35682642e-02f, 7.21435323e-02f, 1.66574746e-01f, -7.33889788e-02f,
  9.99099016e-03f, 6.35188520e-02f, 1.71844617e-01f, -1.17346816e-01f, 1.43324152e-01f, 2.47439127e-02f, -6.19194470e-04f, 9.69502404e-02f, 1.78832218e-01f, -9.28133577e-02f,
  1.68273002e-01f, -3.52356187e-03f, -7.97383189e-02f, -8.87367409e-03f, 9.75105818e-03f, 3.88600677e-02f, 9.47791338e-02f, 1.44161478e-01f, 1.45206198e-01f, 4.72866632e-02f,
  8.07714015e-02f, -5.33252172e-02f, 1.10046819e-01f, 1.64510399e-01f, 2.88595445e-02f, 2.65834015e-02f, -1.92433506e-01f, 3.39780003e-03f, 2.19832703e-01f, -9.44598541e-02f,
  1.31031439e-01f, 2.83473749e-02f, -1.65850833e-01f, -9.97851137e-03f, 5.15192412e-02f, 8.77066255e-02f, -3.38216918e-03f, -8.08131248e-02f, -6.40116557e-02f, -6.87377378e-02f,
  5.85529730e-02f, 2.14068547e-01f, -3.32847796e-02f, -4.42676619e-02f, -6.92090094e-02f, -2.44587604e-02f, -9.10230204e-02f, 1.65998206e-01f, -8.38655606e-02f, 2.79375315e-01f,
  4.73452657e-02f, -7.29089007e-02f, -6.93205297e-02f, -2.38988459e-01f, 1.85606599e-01f, -6.91143274e-02f, -8.05966556e-02f, -5.15804663e-02f, 1.03853218e-01f, -2.56907344e-02f,
  -7.20165372e-02f, -1.02361329e-01f, 2.26357970e-02f, 1.29745498e-01f, 1.24240711e-01f, -7.46744052e-02f, 1.64432615e-01f, 8.01776350e-02f, -5.63764349e-02f, -1.28442124e-01f,
  -5.95003506e-03f, 4.00124937e-02f, 1.07509524e-01f, -8.84816200e-02f, -4.30274522e-03f, 1.85327396e-01f, 1.36924878e-01f, -1.92710515e-02f, 1.23650664e-02f, -1.45101761e-02f,
  3.59380729e-02f, -9.35185887e-03f, -6.49957126e-03f, -3.09411101e-02f, -1.34401135e-02f, 9.12114158e-02f, 6.97202832e-02f, -1.06490768e-01f, 1.13503166e-01f, 8.67643356e-02f,
  1.10389449e-01f, 3.05106863e-02f, -1.26968071e-01f, 6.14521764e-02f, -2.11523604e-02f, -9.30025727e-02f, 7.35782906e-02f, -1.44596040e-01f, -4.85225320e-02f, 1.06861539e-01f,
  -1.12181157e-01f, 1.07805654e-01f, 5.32719828e-02f, 1.80562750e-01f, -3.27260979e-02f, 8.93634334e-02f, 1.09116890e-01f, -1.13571182e-01f, 5.47721013e-02f, 3.19156498e-02f,
  -1.37114786e-02f, -1.10127330e-01f, 1.51211068e-01f, -8.86431858e-02f, -7.74153918e-02f, 5.70227299e-03f, 1.01850510e-01f, -5.94169367e-03f, -1.03452891e-01f, -2.94166934e-02f,
  2.33390592e-02f, -2.00167876e-02f, -1.17039248e-01f, 2.28541106e-01f, 1.12868138e-02f, -7.86157027e-02f, -1.31373331e-01f, 8.48334655e-02f, 5.85147925e-02f, 8.36637095e-02f,
  -4.37619984e-02f, 1.00443460e-01f, -1.07329460e-02f, 1.09839857e-01f, 1.45016573e-02f, 1.62439287e-01f, -8.09785053e-02f, 8.24792907e-02f, 9.00140852e-02f, -1.13797113e-01f,
  -7.39022419e-02f, 8.41809809e-02f, 1.03539810e-01f, 1.41864240e-01f, -8.56240243e-02f, -5.03623635e-02f, -3.16100148e-03f, -1.14561361e-03f, 1.83087438e-01f, -8.52739438e-02f,
  9.74232033e-02f, 1.23143941e-01f, 7.98777044e-02f, -3.18981111e-02f, -3.79315689e-02f, -9.59249735e-02f, 2.43820203e-03f, 6.86625689e-02f, -5.40296882e-02f, 3.23803117e-03f,
  -9.08342525e-02f, -5.21446168e-02f, -5.37262559e-02f, -1.60141319e-01f, -2.76501000e-01f, 1.66040838e-01f, -1.24688767e-01f, 1.52719498e-01f, 8.86380300e-02f, -1.15207829e-01f,
  -1.71193369e-02f, -1.01493753e-01f, 1.16369225e-01f, 1.14271514e-01f, -2.21691161e-01f, 1.11331321e-01f, 1.35522028e-02f, 3.12636383e-02f, -1.22651897e-01f, -1.45027518e-01f,
  -3.28931287e-02f, -4.31342945e-02f, -1.77181400e-02f, 8.40165932e-03f, -1.04794279e-01f, 3.70364636e-02f, 1.05201177e-01f, 4.46156040e-02f, 1.22858778e-01f, 2.00836603e-02f,
  1.19702302e-01f, -2.88849045e-02f, 2.04143301e-01f, -3.86001691e-02f, 1.18444905e-01f, -1.75659284e-01f, 4.44869399e-02f, -7.41221756e-03f, 1.52919546e-01f, -3.51349600e-02f,
  8.35066587e-02f, 8.61135274e-02f, 1.88424112e-03f, -1.22389831e-01f, -1.26898572e-01f, 2.22041070e-01f, 7.21869320e-02f, 4.73973192e-02f, -6.15447275e-02f, -6.68906942e-02f,
  6.01301678e-02f, -1.80607382e-02f, 7.97268301e-02f, -6.27475008e-02f, 6.98614419e-02f, -9.65117440e-02f, 1.45783991e-01f, 3.15927565e-02f, 5.94959781e-02f, 3.68203074e-02f,
  -1.72564611e-02f, -3.54006588e-02f, -5.55125698e-02f, -1.46974683e-01f, -1.29033819e-01f, -3.57322246e-02f, -1.67951658e-01f, 7.08221048e-02f, -1.89554095e-01f, 2.39739671e-01f,
  -4.38804179e-02f, 1.94916263e-01f, -5.57979532e-02f, 8.18363801e-02f, -1.43239528e-01f, -9.61108431e-02f, 9.04539600e-02f, -2.40463763e-02f, -9.37589258e-02f, -8.57346430e-02f,
  2.74560414e-03f, 4.75882851e-02f, 2.36260239e-02f, -7.57422745e-02f, -7.70273879e-02f, -9.25147459e-02f, -6.51559755e-02f, -7.27324933e-02f, -6.49569556e-02f, 4.10229824e-02f,
  -2.07302704e-01f, 8.32915306e-02f, 2.37877257e-02f, -8.76248404e-02f, 4.60145175e-02f, -1.12539589e-01f, 2.72527099e-01f, -9.94595662e-02f, 6.76451102e-02f, -3.97762470e-02f,
  -1.11325849e-02f, 8.50081593e-02f, 1.77215666e-01f, -1.68842245e-02f, 1.23452824e-02f, 7.41625503e-02f, -1.18405074e-01f, -1.02115616e-01f, -8.08317289e-02f, 2.49099955e-01f,
  2.12903321e-02f, 2.51742117e-02f, 3.11633553e-02f, 6.86949538e-03f, 2.84598023e-03f, 9.23345890e-03f, -1.75927002e-02f, 9.18173864e-02f, 7.24276388e-03f, -1.08104058e-01f,
  1.29941314e-01f, 1.27983972e-01f, 1.76416695e-01f, 5.71953095e-02f, -4.05532606e-02f, 5.67792589e-03f, -1.92658082e-02f, -2.40033075e-01f, 2.43491068e-01f, -1.37653485e-01f,
  -2.00241834e-01f, 2.35885367e-01f, 3.99887487e-02f, 1.75938338e-01f, 7.83399269e-02f, 1.68667853e-01f, 6.75679520e-02f, 1.38895556e-01f, -3.62660736e-02f, -3.72924097e-03f,
  -7.04969987e-02f, -7.49485614e-03f, 2.06508830e-01f, -4.15771604e-02f, 6.46288786e-03f, -1.78122718e-03f, 1.14029653e-01f, 4.20178063e-02f, -3.03857066e-02f, 2.74776444e-02f,
  -7.56454170e-02f, -1.60519391e-01f, -7.64913410e-02f, 1.16788290e-01f, -2.37521186e-01f, 8.25789496e-02f, 2.45687276e-01f, 7.44351074e-02f, -2.19306648e-01f, -6.13634214e-02f,
  1.08485207e-01f, -7.08777681e-02f, -1.09542750e-01f, 1.65160641e-01f, -8.39281976e-02f, 1.53536558e-01f, 2.87574846e-02f, 1.33208811e-01f, -1.27541535e-02f, 1.96062610e-01f,
  -1.29100665e-01f, -6.46863282e-02f, 1.14667565e-01f, 4.88978028e-02f, -3.04920096e-02f, 1.07800439e-01f, 1.34240791e-01f, 1.44137621e-01f, 1.18006863e-01f, 5.72643355e-02f,
  -2.13444848e-02f, 9.49709415e-02f, 1.23543460e-02f, -3.28467297e-03f, -1.01766050e-01f, 8.94310102e-02f, -6.50611073e-02f, 1.04216069e-01f, 6.95581287e-02f, -6.07411712e-02f,
  4.85638119e-02f, -1.14995874e-01f, 2.00515807e-01f, 7.64308572e-02f, 5.07327095e-02f, 2.31890604e-01f, 1.26843452e-01f, -4.62107845e-02f, 9.65382382e-02f, -3.71615551e-02f,
  2.00999185e-01f, 2.08376110e-01f, 8.55479240e-02f, 7.59783760e-02f, -5.11205085e-02f, 4.66349833e-02f, 2.04034045e-01f, -4.65153418e-02f, -1.01949610e-01f, 1.49210826e-01f,
  1.46910056e-01f, 1.44349486e-01f, -4.67554480e-02f, 6.27062842e-02f, 1.48054570e-01f, -6.28960431e-02f, -6.07042238e-02f, 1.58276737e-01f, -6.10089526e-02f, 7.53749683e-02f,
  1.43412828e-01f, 7.57325962e-02f, -1.24790885e-01f, 8.12584758e-02f, 1.21551026e-02f, 6.11573597e-03f, -1.13950126e-01f, 2.71929502e-01f, -2.57346891e-02f, 5.20378500e-02f,
  -1.20940000e-01f, 9.38852876e-02f, -6.19115382e-02f, 1.27057046e-01f, 9.72636044e-02f, 1.91467077e-01f, 1.33226976e-01f, -1.43570378e-01f, 1.10160448e-01f, 7.64118806e-02f,
  -2.29314025e-02f, 2.35082265e-02f, -5.07468171e-03f, 7.07100332e-02f, -3.48355584e-02f, 1.32240728e-01f, 8.93023536e-02f, -6.03268333e-02f, 8.53396505e-02f, 1.33508161e-01f,
  1.59229428e-01f, 1.01660006e-02f, -2.50748880e-02f, -1.15283132e-01f, 1.95146650e-02f, -1.24929018e-01f, -9.04158652e-02f, -3.47374305e-02f, -2.98314899e-01f, 9.64595824e-02f,
  -1.26085028e-01f, 2.29586005e-01f, 9.67987329e-02f, 2.77853370e-01f, -1.30200118e-01f, 1.36011273e-01f, -1.58901110e-01f, -7.47862309e-02f, 2.84433831e-02f, 5.30162416e-02f,
  1.85272563e-02f, -1.52378485e-01f, 3.49489301e-02f, 1.20760109e-02f, 1.20602444e-01f, -1.82244614e-01f, 8.25897083e-02f, 1.57372244e-02f, -3.28003131e-02f, -1.44091219e-01f,
  -4.76385988e-02f, 3.36864963e-02f, -6.06403276e-02f, 1.59460187e-01f, 1.28931403e-01f, -1.60883367e-02f, 2.28507351e-02f, 3.21679413e-02f, 2.81550378e-01f, 4.36387435e-02f,
  2.49780118e-02f, -9.29792970e-02f, -1.95667110e-02f, 1.92766398e-01f, 2.19503894e-01f, 4.12847027e-02f, 8.35533589e-02f, 9.80802923e-02f, -7.71080256e-02f, -2.51688212e-02f,
  2.85461778e-03f, 2.41859958e-01f, 6.55161496e-03f, 1.32906392e-01f, 1.86802745e-01f, 1.17982700e-01f, 9.95897688e-03f, 1.47843391e-01f, 2.03982517e-02f, 1.47534907e-01f,
  1.47455141e-01f, 1.30730405e-01f, 1.56541727e-02f, 8.17960873e-02f, -8.28552321e-02f, 9.13688540e-02f, 1.84615001e-01f, -2.06756871e-02f, 1.93913773e-01f, -4.80503775e-02f,
  -3.46549414e-02f, 1.08491138e-01f, -1.31776975e-02f, 1.75976217e-01f, 1.09188773e-01f, -8.20906237e-02f, 1.37749642e-01f, 1.14944484e-03f, 1.47731662e-01f, 3.01888883e-01f,
  4.80070636e-02f, -4.38530296e-02f, -5.52521944e-02f, -6.29360527e-02f, 3.53907235e-02f, 9.31440070e-02f, -1.20958695e-02f, 3.46412241e-01f, 2.07520977e-01f, -6.47360086e-02f,
  -9.42957997e-02f, -1.52175665e-01f, 2.25707412e-01f, -1.43809274e-01f, -2.23848939e-01f, 1.27651751e-01f, 1.33364927e-02f, 2.25956291e-02f, 1.19169347e-01f, -1.10742688e-01f,
  -1.81605712e-01f, 1.88257262e-01f, 1.08632632e-01f, -6.06484935e-02f, 1.02214441e-01f, 1.80736274e-01f, 2.01393906e-02f, 2.67988164e-02f, -6.35474622e-02f, 7.93839470e-02f,
  2.33739600e-01f, 5.86484149e-02f, 1.16397478e-01f, 2.19870046e-01f, 1.46154076e-01f, 2.19337735e-02f, 8.63045678e-02f, 6.81278408e-02f, 5.92708290e-02f, 3.11903339e-02f,
  5.79230040e-02f, 1.24038972e-01f, 1.14613868e-01f, 4.44491692e-02f, -4.42079492e-02f, 1.46417543e-01f, -9.09076780e-02f, 9.77355391e-02f, 7.90337771e-02f, -1.68898087e-02f,
  3.74899781e-03f, -7.55315321e-03f, 3.47519526e-04f, -9.57686305e-02f, 5.47017083e-02f, 1.82020605e-01f, -1.92723975e-01f, 1.10048108e-01f, 3.15462828e-01f, -1.59202158e-01f,
  1.20062090e-01f, 8.48357826e-02f, 5.78728318e-02f, -7.46138319e-02f, 3.64208892e-02f, 2.52728611e-01f, -5.11487806e-03f, -2.21784208e-02f, 2.44353309e-01f, -2.81592291e-02f,
  1.41227175e-03f, 1.02864228e-01f, 2.32078895e-01f, 6.73894808e-02f, -1.97952986e-02f, 1.66741014e-01f, 6.30298853e-02f, 7.68519118e-02f, 1.10203691e-01f, 1.37490615e-01f,
  -1.06553733e-02f, -2.32161535e-03f, -6.35203943e-02f, 1.74382061e-01f, -5.28964847e-02f, -9.59924310e-02f, -1.09520838e-01f, 1.18588813e-01f, 3.72981676e-03f, -5.47346361e-02f,
  6.91658035e-02f, -5.50722852e-02f, -1.83433190e-01f, -6.86285868e-02f, 9.19164866e-02f, -2.61515900e-02f, 1.17233440e-01f, -1.69770673e-01f, 2.93102473e-01f, -2.52691773e-03f,
  9.15954635e-02f, -1.20971194e-02f, -4.26779203e-02f, 5.73017262e-02f, 5.68308979e-02f, -5.26845688e-03f, -1.95179656e-02f, -1.03155583e-01f, 4.87695597e-02f, 6.78730607e-02f,
  1.27488554e-01f, -1.18249003e-02f, 3.14883031e-02f, -4.79024425e-02f, -5.42212799e-02f, 3.79350409e-02f, -4.83159795e-02f, 2.81205531e-02f, 2.56664343e-02f, -1.34042040e-01f,
  1.18063919e-01f, -1.31621838e-01f, -1.44779980e-01f, 6.07583560e-02f, 3.68157737e-02f, -8.42321292e-03f, -6.64666146e-02f, -1.48517251e-01f, 7.54992887e-02f, -1.05078593e-01f,
  1.21793307e-01f, 5.70089966e-02f, -9.33190882e-02f, 1.72872338e-02f, 2.01049805e-01f, -1.87747702e-01f, -1.15689561e-01f, 1.94343831e-02f, 1.75336286e-01f, -1.84854877e-03f,
  -8.35626423e-02f, 3.60262836e-03f, 1.04135007e-01f, -1.16999939e-01f, 1.69311360e-01f, 1.74047813e-01f, -9.40177962e-03f, -6.72050267e-02f, 1.67328432e-01f, 1.18971422e-01f,
  -3.25246975e-02f, 1.66015580e-01f, 6.61906376e-02f, -1.63416833e-01f, 1.37509063e-01f, 8.94060731e-02f, 5.61857522e-02f, 3.84583361e-02f, -2.85231788e-02f, 2.97951438e-02f,
  4.91877533e-02f, 2.13826429e-02f, -1.66674182e-01f, 7.00347796e-02f, -4.90709059e-02f, 5.83009841e-03f, -1.49258777e-01f, -4.46451455e-02f, -7.62368813e-02f, -6.79781288e-02f,
  5.80899976e-02f, -1.97817124e-02f, -2.09133122e-02f, 4.32078205e-02f, -8.30091536e-02f, -2.35098624e-03f, -2.14256085e-02f, -6.58489689e-02f, -5.38606383e-02f, 7.08719641e-02f,
  -8.67113620e-02f, 2.98585463e-02f, -4.15255837e-02f, 2.04797005e-04f, -1.66786760e-02f, -1.15067407e-01f, 8.49212110e-02f, -4.51804176e-02f, 3.13673243e-02f, 3.14168930e-02f,
  -7.83422962e-02f, -1.09335080e-01f, 4.75925803e-02f, 6.92576244e-02f, 1.84287816e-01f, 1.12707250e-01f, -6.30107522e-02f, -1.36436716e-01f, 1.89921353e-02f, -1.02932461e-01f,
  -1.25989169e-01f, -5.19449525e-02f, 1.48121566e-01f, 9.64135900e-02f, -3.95512804e-02f, 4.74003851e-02f, 1.35255545e-01f, -7.28420913e-02f, 3.34071345e-03f, -5.53066283e-02f,
  -5.96959665e-02f, 6.11402374e-03f, 3.66904996e-02f, 1.13796294e-02f, -5.46016805e-02f, 9.11840722e-02f, -5.85381687e-02f, -5.32998666e-02f, 8.43808278e-02f, 1.18483827e-01f,
  1.21455446e-01f, 1.70531422e-02f, -9.36960056e-02f, -8.80236179e-02f, 5.66374809e-02f, -8.46407861e-02f, -8.89397115e-02f, 2.60288548e-02f, -5.68453856e-02f, 6.95108697e-02f,
  7.65002817e-02f, 9.69166532e-02f, 1.16399996e-01f, 1.97574822e-03f, 2.07848698e-02f, 3.73562425e-02f, 5.50429337e-02f, 1.02147855e-01f, 1.51581271e-03f, 3.76197845e-02f,
  -2.29386240e-01f, 6.68040961e-02f, 1.77887961e-01f, -1.27470940e-01f, 2.46092543e-01f, 1.66850626e-01f, -1.76978111e-01f, -4.93688211e-02f, 2.10355908e-01f, -3.17385942e-02f,
  -5.81250824e-02f, -1.16378799e-01f, -2.83140615e-02f, -1.03262067e-01f, 1.16616711e-01f, 1.29003376e-01f, -4.80446294e-02f, -9.12483037e-03f, -9.57800299e-02f, 2.26944517e-02f,
  -1.05160780e-01f, 7.87840858e-02f, 6.84130415e-02f, 1.83690846e-01f, 7.36432001e-02f, -4.60871309e-02f, -6.73508644e-02f, -1.59112006e-01f, 2.56297320e-01f, -8.28454867e-02f,
  -1.07406087e-01f, -1.36085302e-01f, 1.69189692e-01f, -6.86741853e-03f, -1.56321138e-01f, -9.49286148e-02f, -6.04707003e-02f, 1.62735462e-01f, -7.22141340e-02f, -2.09659357e-02f,
  8.44841525e-02f, 6.20477647e-02f, 4.46391180e-02f, -9.81001928e-03f, -2.52820738e-02f, 8.98341611e-02f, 9.44795236e-02f, -8.78269449e-02f, 7.71765336e-02f, 3.92979056e-01f,
  3.52498330e-02f, -3.21452320e-02f, 9.69644263e-02f, 6.36582673e-02f, 1.34479031e-01f, 8.68408307e-02f, 1.35555565e-02f, 9.77485701e-02f, -2.73165423e-02f, 1.60205200e-01f,
  -5.64531423e-02f, -1.74737088e-02f, 3.53444181e-02f, 2.41485983e-02f, 7.15086311e-02f, -1.95670743e-02f, 1.78603288e-02f, 7.63719082e-02f, -8.04418400e-02f, -5.28908931e-02f,
  2.28738040e-01f, 1.13517575e-01f, -6.66824356e-02f, 1.53116718e-01f, 2.51825780e-01f, -9.16602015e-02f, 9.85590965e-02f, -6.36259019e-02f, 1.51139051e-01f, 6.00286461e-02f,
  1.24022044e-01f, 2.23492250e-01f, -3.24440235e-03f, -9.96670499e-02f, 1.72870204e-01f, -5.15572540e-02f, -5.44174314e-02f, 5.13590313e-02f, 9.00640413e-02f, 8.41351151e-02f,
  5.07177673e-02f, 1.50212526e-01f, 6.27473593e-02f, 1.01673365e-01f, 1.27698541e-01f, 1.28072232e-01f, -7.05548823e-02f, 1.04581062e-02f, 3.54583599e-02f, 1.84305564e-01f,
  1.32881114e-02f, 1.82907917e-02f, -9.50162634e-02f, 6.43978789e-02f, -3.07453182e-02f, 2.40701690e-01f, 1.27796382e-01f, -3.77466939e-02f, -1.33843526e-01f, 9.42401811e-02f,
  1.16940681e-02f, -3.00981291e-02f, 7.13891760e-02f, -1.38167679e-01f, 1.13662139e-01f, -1.59433886e-01f, 1.06504634e-01f, 1.07855096e-01f, 1.40544251e-01f, 1.34741649e-01f,
  1.55919984e-01f, 1.33219302e-01f, 1.81127414e-01f, -4.23733406e-02f, -1.21502187e-02f, 1.90905184e-01f, -3.79135609e-02f, 7.21587334e-03f, -9.82488692e-02f, -8.26609656e-02f,
  1.34214655e-01f, -1.75769627e-02f, 2.42486354e-02f, -1.85073726e-03f, 1.09908227e-02f, 1.87466264e-01f, -4.33196314e-02f, -6.28644973e-02f, 5.95886202e-04f, -2.72930503e-01f,
  -1.06573910e-01f, 5.35521172e-02f, -4.66069952e-02f, -8.62898380e-02f, 6.24190923e-03f, 2.21340343e-01f, -9.60933417e-02f, -2.45603453e-02f, -2.36881059e-02f, 9.67962444e-02f,
  3.37122637e-03f, 6.62366152e-02f, 7.13840276e-02f, 1.32589668e-01f, -1.49843112e-01f, 1.40440032e-01f, 4.00943961e-03f, 1.88300297e-01f, 1.72923859e-02f, -1.35596544e-02f,
  1.65876523e-01f, -2.36327082e-01f, -1.29923120e-01f, 3.91805246e-02f, 1.90670744e-01f, -6.05452247e-02f, -3.91287953e-02f, 2.85628662e-02f, 1.41324416e-01f, -1.55641750e-01f,
  5.54872565e-02f, -1.14237696e-01f, -1.37870982e-01f, -1.77086636e-01f, 9.19160619e-02f, -1.08942904e-01f, -1.45360939e-02f, -1.95029408e-01f, 2.01454535e-01f, -7.98770785e-02f,
  -8.74701049e-03f, 1.19572720e-02f, 1.00003220e-01f, 1.60236973e-02f, 9.77955461e-02f, 1.39741600e-01f, 7.73124397e-02f, 8.55971798e-02f, -8.08921233e-02f, 5.15326895e-02f,
  -2.32077297e-02f, 1.52006835e-01f, 5.47686256e-02f, 5.58167733e-02f, -2.03510076e-02f, -9.27855447e-03f, -2.30687950e-02f, -9.18388292e-02f, 6.92824051e-02f, 4.86227637e-03f,
  -6.58718795e-02f, 1.26924247e-01f, 3.22085351e-01f, -2.40093797e-01f, 6.41109329e-03f, -1.19341966e-02f, -1.16730608e-01f, 1.44071842e-03f, -1.73153833e-03f, 2.45354190e-01f,
  9.45820361e-02f, -7.12368637e-02f, 1.11913748e-01f, -9.72254574e-02f, -1.62692107e-02f, 1.13470435e-01f, 1.69157773e-01f, 8.09439793e-02f, -3.35713588e-02f, 2.74517655e-01f,
  7.55165443e-02f, -1.08329557e-01f, 1.82846323e-01f, 9.14005190e-02f, 6.00083470e-02f, -2.06932232e-01f, -1.55721009e-01f, 1.00386433e-01f, -3.91836418e-03f, 2.96014734e-02f,
  -1.05099022e-01f, 8.22474509e-02f, -4.37989086e-02f, -6.90218434e-02f, -1.42641487e-02f, -5.55823483e-02f, -8.30676407e-02f, -3.74960043e-02f, -7.73564056e-02f, -1.12907179e-01f,
  2.78168749e-02f, -1.73077807e-01f, 1.95257887e-01f, 3.33947735e-03f, 4.72217612e-02f, 3.33550088e-02f, 1.26210853e-01f, 1.03964567e-01f, 1.68215886e-01f, 7.21842349e-02f,
  1.62697300e-01f, 8.02754015e-02f, -3.62066068e-02f, 6.05710670e-02f, 1.03835478e-01f, -5.41847991e-03f, -1.29849864e-02f, -9.06677023e-02f, 1.93972930e-01f, -3.42125408e-02f,
  -5.38078547e-02f, -1.99226990e-01f, -3.14149037e-02f, 1.63905516e-01f, -2.58583874e-01f, -1.82380795e-01f, -4.15518461e-03f, 1.32653981e-01f, -1.35329947e-01f, 1.32637531e-01f,
  1.05436735e-01f, -7.31239766e-02f, -1.52959796e-02f, 1.94239065e-01f, -1.19557649e-01f, -7.48474002e-02f, -8.18465278e-03f, -4.51429840e-03f, -2.00002611e-01f, 6.42263442e-02f,
  1.22022495e-01f, 9.64029506e-02f, -7.31358156e-02f, -1.20804146e-01f, -5.59501946e-02f, 2.82429963e-01f, -1.10334447e-02f, 2.40187138e-01f, 8.17545224e-03f, -4.62016650e-02f,
  2.42167518e-01f, 1.48634017e-01f, 7.79888183e-02f, -1.98375493e-01f, 1.70823693e-01f, 1.24638795e-03f, 1.50311440e-01f, -1.18960075e-01f, 9.74385142e-02f, -1.63704962e-01f,
  -5.67025952e-02f, -1.92990914e-01f, 2.44793996e-01f, 2.32784301e-02f, 1.49830684e-01f, -2.02557102e-01f, 8.04886743e-02f, 2.13401794e-01f, 1.38534203e-01f, 7.43374154e-02f,
  6.17008880e-02f, 5.54399490e-02f, 1.32981420e-01f, 1.14096977e-01f, 1.56751677e-01f, 6.38495758e-03f, 9.39913765e-02f, 4.36864719e-02f, 1.90175354e-01f, 5.68163022e-02f,
  1.51006654e-01f, -1.99730024e-02f, -1.17701575e-01f, -1.78866293e-02f, -6.87642470e-02f, -2.55455263e-02f, -2.07949549e-01f, -2.17033923e-01f, -2.05599025e-01f, 4.71449755e-02f,
  -6.82092272e-03f, 1.19261205e-01f, -5.01282215e-02f, 2.52316535e-01f, -1.27303824e-01f, 1.41128242e-01f, -1.24096125e-01f, 1.59899965e-02f, 1.66208714e-01f, 1.11086644e-01f,
  -5.97201139e-02f, -3.55736837e-02f, 1.53116539e-01f, -2.66300663e-02f, 5.28832562e-02f, -1.76705986e-01f, 4.21281718e-02f, 4.92025949e-02f, 2.55967584e-02f, -2.11626872e-01f,
  5.04525118e-02f, 2.64619291e-02f, -5.93454530e-03f, 1.10021062e-01f, 3.06027625e-02f, -1.40445977e-02f, -4.24720207e-03f, 2.61193775e-02f, 2.36030146e-01f, -1.64109059e-02f,
  -1.84511263e-02f, -1.56481400e-01f, -5.43039963e-02f, 5.74709363e-02f, 9.80944037e-02f, 4.72640246e-02f, 1.63322575e-02f, 3.81093323e-02f, -6.48141056e-02f, -6.83774203e-02f,
  2.50334442e-02f, 2.40198731e-01f, 1.56336986e-02f, 4.21606265e-02f, 8.45273510e-02f, 4.91806343e-02f, -9.41862352e-03f, 1.98303968e-01f, -5.68590313e-03f, 8.79841819e-02f,
  1.24483421e-01f, 1.42870605e-01f, 4.43706550e-02f, -2.24660132e-02f, -6.41203672e-02f, -8.64562392e-02f, 9.25157145e-02f, 9.01499484e-03f, -5.01847789e-02f, -7.90675804e-02f,
  3.07879895e-02f, 1.10083528e-01f, -4.08791602e-02f, 6.69129491e-02f, 8.24237056e-03f, -7.48224482e-02f, 5.43184206e-02f, -8.44661146e-02f, 2.08896548e-01f, 1.04165310e-02f,
  1.06269002e-01f, 6.81223869e-02f, -1.20138131e-01f, -1.03673413e-02f, 3.38580534e-02f, 1.30514428e-01f, -1.98217541e-01f, 1.54233828e-01f, 8.93409699e-02f, 1.75706938e-01f,
  -6.90667843e-03f, -5.86537942e-02f, 1.08386666e-01f, 2.96599627e-01f, -2.44844519e-02f, 1.38292313e-01f, 1.89519301e-02f, -8.15452114e-02f, 1.16018191e-01f, 9.28678215e-02f,
  -1.02375045e-01f, -1.46830827e-01f, -1.43549731e-02f, -1.24057651e-01f, 2.24184152e-02f, 1.45629019e-01f, 6.40012398e-02f, -6.78217113e-02f, -4.94581349e-02f, -5.03230244e-02f,
  1.99066445e-01f, 1.09962605e-01f, -2.00850964e-02f, -1.19031340e-01f, 1.06984563e-01f, -7.89469332e-02f, 5.02726249e-02f, 3.43632139e-02f, 1.73903406e-02f, 6.66101128e-02f,
  1.47414237e-01f, 3.64113115e-02f, -4.31807674e-02f, 4.59963381e-02f, 9.71769243e-02f, 7.20755458e-02f, 5.19371815e-02f, 7.27806911e-02f, -7.26214498e-02f, -2.96085924e-02f,
  1.31908119e-01f, -6.25431910e-02f, 1.20930299e-01f, 1.54608656e-02f, -1.08399443e-01f, 2.51666866e-02f, 1.42479418e-02f, 1.37041686e-02f, -1.13501325e-01f, -1.66146308e-02f,
  1.14479974e-01f, -1.87257901e-02f, 1.81992844e-01f, 2.38977417e-01f, 6.48590457e-03f, -9.81107429e-02f, 5.04532158e-02f, 7.15045407e-02f, -9.93574485e-02f, 4.71272692e-03f,
  2.92584393e-02f, 3.38669360e-01f, 6.11862652e-02f, -5.99001311e-02f, -3.94865721e-02f, -2.43385628e-01f, 1.18187703e-01f, -9.71888080e-02f, -1.69975400e-01f, 1.11300927e-02f,
  6.82243779e-02f, 4.68498021e-02f, 1.34232774e-01f, -7.88221210e-02f, -3.47720794e-02f, 1.02576539e-01f, 1.22320779e-01f, -7.65531138e-02f, 5.40343523e-02f, 1.80738449e-01f,
  3.27309743e-02f, -8.80149677e-02f, 1.12963401e-01f, 5.30818924e-02f, 1.36230350e-01f, -2.59594563e-02f, 1.17563615e-02f, 1.68619156e-01f, 2.73126271e-02f, 1.01083823e-01f,
  9.57810804e-02f, 3.62525657e-02f, -5.52082956e-02f, -4.42159362e-02f, 9.16376635e-02f, -3.56425084e-02f, 1.10250218e-02f, 7.96703622e-02f, 4.63232733e-02f, 2.97849271e-02f,
  1.51401445e-01f, 6.82181269e-02f, 5.36356904e-02f, 2.88241357e-02f, -1.13791339e-01f, 1.80711206e-02f, 4.25268598e-02f, 1.95025522e-02f, -5.38154505e-02f, -1.94233358e-01f,
  7.25132152e-02f, -2.49151494e-02f, 3.16526219e-02f, 1.10709198e-01f, 1.42486736e-01f, 1.91940457e-01f, -6.68249056e-02f, 1.14559419e-02f, 8.04293901e-02f, -1.50868088e-01f,
  2.18434915e-01f, 1.13734625e-01f, -4.13670316e-02f, -7.78321177e-02f, 1.88957393e-01f, -2.97837835e-02f, -4.43085469e-02f, -1.40624270e-01f, 1.35434806e-01f, 7.91727677e-02f,
  -4.43503670e-02f, -2.17013285e-01f, 4.99925017e-02f, -9.03817937e-02f, 7.58095607e-02f, 1.59865126e-01f, -9.33911204e-02f, -1.22917838e-01f, -3.04920375e-02f, 1.50905862e-01f,
  1.04906604e-01f, 1.30268097e-01f, 6.07969007e-03f, -1.26364958e-02f, -1.26194749e-02f, 1.27663746e-01f, 1.43293649e-01f, 5.52081354e-02f, -1.44970313e-01f, 4.30443250e-02f,
  1.46581456e-01f, 1.22877723e-02f, -9.71555188e-02f, 2.32332516e-02f, 1.96820617e-01f, 1.14869721e-01f, -3.16375084e-02f, -9.41271801e-03f, 6.71189725e-02f, 1.06915563e-01f,
  1.48937449e-01f, 4.19603772e-02f, 7.15463758e-02f, 1.99068710e-01f, 1.30132094e-01f, -7.74310809e-03f, 3.56129631e-02f, -6.73902631e-02f, 1.08326331e-01f, 8.43235105e-02f,
  -1.08716674e-01f, -2.41076350e-02f, -5.04428931e-02f, 2.67843157e-02f, -3.80736925e-02f, -1.41801730e-01f, -1.21788532e-02f, -3.81574072e-02f, -4.24488857e-02f, -4.23482694e-02f,
  5.98830767e-02f, -8.45387205e-02f, 1.31744459e-01f, 2.15092793e-01f, 7.56482184e-02f, 2.05217786e-02f, -6.11080043e-03f, 1.35977104e-01f, -4.63095941e-02f, -3.59193571e-02f,
  -6.62703365e-02f, 1.32213056e-01f, 4.33729663e-02f, 8.52303132e-02f, 8.30652192e-03f, 2.51635313e-01f, 1.23776101e-01f, 2.20329165e-02f, 6.37191683e-02f, -5.45700081e-02f,
  -6.62845373e-02f, 1.57550782e-01f, 1.18720055e-01f, 4.38177586e-02f, 4.91901254e-03f, -7.39783701e-03f, 1.39679193e-01f, -1.82025895e-01f, 1.60755366e-01f, -1.03523031e-01f,
  2.54820697e-02f, -7.43613541e-02f, 1.17582388e-01f, -1.40207306e-01f, 1.84484676e-01f, -1.79267019e-01f, -2.50591827e-03f, 6.93980381e-02f, 4.17113937e-02f, 8.72431621e-02f,
  3.68502587e-02f, -4.13309522e-02f, -5.19850291e-02f, -2.92373244e-02f, 1.66485962e-02f, 1.24163352e-01f, -1.45933300e-01f, -2.79153045e-02f, -6.63032457e-02f, 1.04522116e-01f,
  9.95168760e-02f, -2.27014869e-02f, -1.78229764e-01f, 9.21856463e-02f, -4.83294651e-02f, -4.63635325e-02f, 5.56479841e-02f, -3.48886549e-02f, -1.94681957e-02f, 4.36740667e-02f,
  2.34953791e-01f, -6.03620894e-02f, 1.75337438e-02f, 6.30638897e-02f, -1.49087489e-01f, -1.03173703e-01f, 9.30813849e-02f, 8.90489370e-02f, 1.55513719e-01f, -3.67657803e-02f,
  7.72229806e-02f, -1.52871728e-01f, 3.78962159e-02f, -1.20548204e-01f, 6.28942847e-02f, 3.92419770e-02f, 1.38472229e-01f, 3.23911846e-01f, -3.84495035e-02f, -1.90295931e-02f,
  1.88587144e-01f, 4.24684472e-02f, -4.10533026e-02f, -1.02793779e-02f, -1.05604239e-01f, 1.30347714e-01f, 7.42595643e-02f, 1.14892602e-01f, -1.64012447e-01f, 2.94401497e-02f,
  -8.69464129e-02f, -7.59887472e-02f, 1.17362015e-01f, 9.00037289e-02f, 1.79754049e-02f, 6.65062740e-02f, -1.18463807e-01f, -7.11599737e-02f, 5.98354004e-02f, -1.50983036e-01f,
  6.59570098e-02f, -9.36281383e-02f, 1.10680148e-01f, 1.15838826e-01f, 1.65012926e-02f, 1.05018085e-02f, 1.60903875e-02f, 8.71180668e-02f, 2.83661615e-02f, 1.13173336e-01f,
  -5.76400682e-02f, 9.06330645e-02f, -2.76429839e-02f, 8.43853801e-02f, 7.25355297e-02f, -5.45556366e-04f, -1.24715358e-01f, -1.74088813e-02f, -1.16384849e-01f, -3.08544803e-02f,
  4.95008752e-02f, 7.69207329e-02f, -4.63842899e-02f, -1.59378890e-02f, 1.88428536e-01f, -1.04630686e-01f, 4.90405736e-03f, 3.92346717e-02f, -6.63803443e-02f, -9.76624861e-02f,
  4.56240252e-02f, 1.68194771e-01f, 6.85169771e-02f, 5.30065782e-02f, 1.45557672e-01f, -1.74486116e-01f, 2.25346554e-02f, -1.61387250e-01f, 1.07944041e-01f, -3.93052250e-02f,
  2.00099349e-01f, 2.29965761e-01f, 7.16173649e-02f, -6.03419691e-02f, 2.88077265e-01f, 2.69084983e-02f, -1.41458176e-02f, -1.03351548e-01f, -8.37352350e-02f, 1.64556086e-01f,
  1.05492458e-01f, 3.32212774e-03f, -8.65041539e-02f, 2.68590096e-02f, 2.50070784e-02f, -2.10732907e-01f, 1.32270113e-01f, 1.32130921e-01f, 3.47478613e-02f, -2.05629226e-02f,
  -1.09269761e-01f, -1.87076628e-01f, 7.28396475e-02f, -8.71357545e-02f, 1.62296259e-04f, 7.52177536e-02f, -4.21441942e-02f, 1.08431876e-01f, 1.22640260e-01f, -1.01442272e-02f,
  7.43874609e-02f, 5.46153402e-04f, -9.58547965e-02f, 1.77466556e-01f, -5.66674843e-02f, -5.96263483e-02f, 4.42466028e-02f, 1.37768790e-01f, -2.61008099e-04f, 2.47251075e-02f,
  -3.50349993e-02f, 6.35258853e-02f, 1.97028313e-02f, -1.47320166e-01f, 3.53663325e-01f, 9.69663486e-02f, 1.10037655e-01f, 1.20437972e-01f, 1.29333735e-01f, 7.73295611e-02f,
  1.44609958e-01f, -5.89084774e-02f, 1.77541494e-01f, 1.35407522e-01f, 1.34624451e-01f, 1.21934623e-01f, 5.58046699e-02f, 3.54578309e-02f, 2.55964369e-01f, -2.92373430e-02f,
  3.25361155e-02f, -5.46541438e-02f, 5.72114550e-02f, 2.22637758e-01f, 1.16028763e-01f, 5.58432192e-02f, -5.42624593e-02f, 1.07914269e-01f, -9.74678174e-02f, 1.35458127e-01f,
  -1.58636644e-01f, 9.71843898e-02f, 1.84018254e-01f, 5.60403541e-02f, -1.50016084e-01f, -3.63335991e-03f, -9.29845423e-02f, 5.58226705e-02f, -1.02415025e-01f, 3.74217868e-01f,
  8.24829116e-02f, 3.56272645e-02f, -1.70957565e-01f, 2.40662619e-01f, -2.66774395e-03f, 9.24479682e-03f, 1.07153296e-01f, 1.33495659e-01f, 2.92850938e-03f, -1.22650720e-01f,
  1.17438650e-02f, 8.06988701e-02f, 1.03303730e-01f, 2.16345376e-04f, 6.17911257e-02f, 1.78744033e-01f, -5.51357772e-03f, 6.99610636e-02f, 9.73551944e-02f, 5.49635962e-02f,
  -9.26368758e-02f, -2.37081684e-02f, -2.97289118e-02f, -3.33023705e-02f, 1.41194031e-01f, -2.37225369e-02f, 6.11071363e-02f, -5.41161858e-02f, 4.83005755e-02f, 1.69847518e-01f,
  -1.35700896e-01f, 1.46575689e-01f, 1.52181745e-01f, -1.12508908e-01f, 8.43685120e-02f, -4.32706717e-03f, 1.86254948e-01f, 6.40214980e-02f, 9.58920121e-02f, 6.60594925e-02f,
  -4.14516814e-02f, -1.42191932e-01f, 1.20348603e-01f, 4.78135087e-02f, -4.95963097e-02f, 2.03752398e-01f, 1.80720165e-01f, 7.73065686e-02f, -1.89408530e-02f, -6.91237971e-02f,
  6.77944720e-02f, 4.68197167e-02f, -8.83687213e-02f, 1.34023830e-01f, -1.02221211e-02f, -5.58671989e-02f, 7.35605210e-02f, 7.03760684e-02f, -1.45986348e-01f, -4.66495100e-03f,
  7.50180110e-02f, 6.68407008e-02f, 2.48726960e-02f, 1.27849564e-01f, -6.60118461e-02f, -9.42317545e-02f, -1.67443797e-01f, -1.28349466e-02f, 1.43511504e-01f, 6.95593879e-02f,
  2.46816762e-02f, -3.25951949e-02f, 1.80339664e-01f, -5.91284931e-02f, 1.01670787e-01f, 1.03856221e-01f, -1.15844915e-02f, -1.94510221e-02f, -8.04307684e-02f, 8.13579572e-06f,
  1.00154757e-01f, 4.93109412e-02f, 4.45098995e-04f, 7.84818903e-02f, -4.08943519e-02f, -5.35641471e-03f, -1.27163753e-01f, -4.17897403e-02f, -4.84326817e-02f, 1.24733530e-01f,
  4.68425006e-02f, 1.35742053e-01f, 2.96011511e-02f, 8.09798688e-02f, 2.67171711e-01f, -8.27445462e-02f, -7.42015764e-02f, -1.02497146e-01f, 3.07333395e-02f, -9.88821685e-02f,
  -3.59786972e-02f, -1.55310854e-01f, 8.81295130e-02f, -1.15673929e-01f, 7.92693868e-02f, 6.54080510e-02f, -1.26811683e-01f, 1.34123296e-01f, 3.93681861e-02f, -7.08186440e-03f,
  -1.91731945e-01f, 8.56441259e-02f, 1.28238097e-01f, 4.81793135e-02f, 5.19721247e-02f, 1.13822140e-01f, 1.36384323e-01f, -9.59158763e-02f, 1.64800495e-01f, 6.92337006e-02f,
  -1.30003512e-01f, -1.82043836e-02f, 4.56376113e-02f, 1.42954066e-01f, -1.08127765e-01f, 1.60217643e-01f, 8.44304264e-02f, -1.81026086e-02f, 1.17103755e-01f, -7.03244358e-02f,
  3.38326097e-02f, 1.14316903e-01f, 3.25875841e-02f, -1.88053474e-01f, 2.11103469e-01f, 2.49525649e-03f, 2.81644473e-03f, -4.92225438e-02f, -5.23235276e-02f, -1.58393886e-02f,
  1.63856953e-01f, 1.07072525e-01f, 1.14393614e-01f, 7.16292560e-02f, -1.18141780e-02f, -1.58904977e-02f, 1.57217979e-01f, 1.04810499e-01f, -5.61312831e-04f, 1.80804729e-02f,
  -2.21493781e-01f, 7.28943525e-03f, 1.23735450e-01f, -3.30555327e-02f, 1.38149008e-01f, 6.90163672e-02f, -2.21911103e-01f, 1.33830085e-02f, 5.69129065e-02f, 3.70284282e-02f,
  -1.00745708e-01f, -7.06421882e-02f, -5.57405017e-02f, 3.65028530e-02f, 1.65770352e-01f, 1.83092579e-01f, 6.06397390e-02f, -4.47079428e-02f, -5.07506169e-02f, -1.62067842e-02f,
  -2.68793758e-02f, 6.94159567e-02f, 3.42359673e-03f, 3.28652263e-01f, 1.14815176e-01f, -2.42297519e-02f, -1.03723723e-02f, -2.51959503e-01f, 2.19621494e-01f, -4.52685766e-02f,
  -1.21218391e-01f, -1.22729258e-03f, 1.07670270e-01f, 4.44272868e-02f, -5.16578071e-02f, -7.42621645e-02f, -5.93336709e-02f, 1.21842511e-01f, 1.06492631e-01f, -1.35650203e-01f,
  1.46534637e-01f, 6.15296885e-02f, -5.44677638e-02f, -5.96903749e-02f, -2.73326449e-02f, 3.77996638e-02f, 1.84439763e-01f, 5.65546639e-02f, -3.12256943e-02f, 1.80267483e-01f,
  3.56379151e-02f, 2.98756845e-02f, -1.65842585e-02f, -1.11109531e-02f, -4.69842628e-02f, -4.77934293e-02f, -2.78011523e-02f, -3.16097364e-02f, 1.64099224e-02f, -5.07203527e-02f,
  1.43999085e-02f, -6.00870997e-02f, 4.97293510e-02f, 3.24269459e-02f, 4.75212820e-02f, -1.76904108e-02f, -1.70764551e-02f, -6.98804669e-03f, -1.76690947e-02f, 6.27705455e-03f,
  -4.14979719e-02f, -1.42868534e-01f, -1.39135672e-02f, -3.14268023e-02f, -1.47495210e-01f, 8.49384367e-02f, -6.58448339e-02f, 4.58295122e-02f, -8.95352662e-02f, -1.81647595e-02f,
  -1.07873060e-01f, -8.53737965e-02f, 2.54355893e-02f, 5.27422540e-02f, -7.52215907e-02f, -1.78303458e-02f, 9.03168917e-02f, -9.70630199e-02f, -7.51571730e-02f, -7.84329772e-02f,
  -8.50545336e-03f, 1.91191155e-02f, -7.11573213e-02f, -9.87020507e-02f, -1.66196637e-02f, -4.07558419e-02f, 5.76945953e-02f, -2.15869769e-03f, -7.04889596e-02f, -7.54896700e-02f,
  2.63706390e-02f, 6.82788715e-03f, 5.98086230e-02f, -2.50545852e-02f, -6.73985714e-03f, -6.60260394e-02f, -3.80677581e-02f, 6.93483502e-02f, 7.76246786e-02f, -5.25627658e-02f,
  -9.18778181e-02f, 1.98375769e-02f, -1.11817606e-01f, 7.35899201e-03f, -1.14526570e-01f, 4.70406897e-02f, 6.88990280e-02f, 9.40481499e-02f, 3.08681019e-02f, -6.63314313e-02f,
  4.26478386e-02f, -1.32735118e-01f, 2.37774570e-02f, -4.40538265e-02f, 3.95036712e-02f, 8.24189186e-02f, 2.40076222e-02f, 2.69870367e-02f, 4.30277847e-02f, 1.12869646e-02f,
  -1.17830254e-01f, 1.25010446e-01f, 4.48493026e-02f, 1.30885243e-01f, 5.51506877e-02f, -8.71708393e-02f, 1.80205300e-01f, -2.06500426e-01f, 1.69458259e-02f, 4.85224761e-02f,
  7.96169639e-02f, 2.73661017e-02f, -8.29951018e-02f, -1.96568236e-01f, 8.60168785e-02f, -1.40974015e-01f, 1.58603713e-01f, 1.04428157e-01f, -8.62237513e-02f, -2.53601186e-02f,
  1.41986117e-01f, -2.22121209e-01f, -1.15121908e-01f, -1.24271251e-01f, 1.97415397e-01f, 7.84711465e-02f, -2.53886413e-02f, -1.21296398e-01f, 5.70529252e-02f, -1.46311626e-01f,
  1.21483594e-01f, 4.05628867e-02f, -9.80491936e-02f, -7.51281232e-02f, 6.41451478e-02f, 2.14201257e-01f, -8.52818191e-02f, 1.66632563e-01f, 7.22080320e-02f, -1.47123829e-01f,
  9.97284874e-02f, 8.61621499e-02f, 4.85797152e-02f, 1.41139537e-01f, -4.37602624e-02f, -7.29256347e-02f, 1.29497021e-01f, 1.13936834e-01f, -6.98609874e-02f, -1.86369903e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.30949676e-01f, 2.27020285e-03f, 5.37766553e-02f, 1.69805270e-02f, 6.11012951e-02f, -3.84801882e-03f, -2.14851685e-02f, 7.19498545e-02f, 3.10703758e-02f, 1.58998102e-01f,
  -2.44555045e-02f, 1.39508605e-01f, 5.00749536e-02f, 5.26508577e-02f, -2.10155863e-02f, -1.56419314e-02f, 8.61948058e-02f, 3.07264030e-02f, 1.22075699e-01f, 1.62837297e-01f,
  5.59609197e-02f, 7.27102952e-03f, 6.43274467e-03f, 8.27464312e-02f, 1.35823861e-01f, -2.33902466e-02f, -1.22110369e-02f, 1.40605301e-01f, 6.17182143e-02f, 1.20288603e-01f,
  2.82712150e-02f, 1.46757826e-01f, -3.34387943e-02f, -3.80575769e-02f, 5.27921021e-02f, 4.19708565e-02f, 1.05729908e-01f, 7.93391541e-02f, 2.06113770e-03f, 2.83583347e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.21507486e-02f, -1.16397170e-02f, 6.01294339e-02f, -3.44435796e-02f, 7.52783716e-02f, 7.20780343e-02f, 7.10006431e-02f, 1.33265093e-01f, -2.42866874e-01f, -5.33725806e-02f,
  5.65199703e-02f, 7.13083223e-02f, 4.79635261e-02f, 1.75981835e-01f, 1.45172730e-01f, 5.04302345e-02f, 5.45345955e-02f, -3.75038870e-02f, 1.13609113e-01f, 1.69208825e-01f,
  -7.02918470e-02f, -5.56955077e-02f, 1.58014804e-01f, 7.98723325e-02f, 1.76353335e-01f, 1.45407066e-01f, -1.98826239e-01f, -6.23831563e-02f, 9.35727265e-03f, -4.28909622e-02f,
  1.61131367e-01f, 4.18744981e-02f, -1.00077331e-01f, -2.09086269e-01f, -1.83169812e-01f, 8.75843242e-02f, 2.50181612e-02f, -2.07190104e-02f, 2.26818622e-04f, -1.92154534e-02f,
  3.60020548e-02f, 2.55979486e-02f, 9.68257040e-02f, 8.96915328e-03f, 7.86326677e-02f, 8.88878480e-02f, 1.24557555e-01f, -3.89276557e-02f, -7.80553222e-02f, 7.68084228e-02f,
  -1.57672048e-01f, 1.47443444e-01f, -9.29955393e-02f, -5.95617527e-03f, 1.78222060e-01f, -2.37946305e-03f, 6.41135350e-02f, 9.26976576e-02f, -7.85023645e-02f, -9.13002789e-02f,
  7.56670758e-02f, 1.63787734e-02f, 4.55837958e-02f, 1.14777483e-01f, 2.20107101e-02f, 3.88787836e-02f, 1.62485074e-02f, -7.18629733e-02f, -1.76222157e-02f, -9.06851329e-03f,
  -1.36881899e-02f, -1.66021198e-01f, -1.16542123e-01f, -6.55031055e-02f, 1.53264590e-02f, -5.52772656e-02f, -5.66755459e-02f, -2.04010397e-01f, 4.23998982e-02f, 1.05982415e-01f,
  -5.05123846e-02f, 5.38464412e-02f, -2.36850858e-01f, 9.19693708e-02f, 4.23352830e-02f, -1.54472336e-01f, -2.69168377e-01f, -8.12209174e-02f, 7.57957995e-03f, -5.63516766e-02f,
  3.53290439e-02f, 3.28808930e-03f, 1.42008036e-01f, 6.20582178e-02f, -1.39275685e-01f, 5.34710847e-02f, -1.75971575e-02f, 4.46557961e-02f, 1.76560640e-01f, -1.34114861e-01f,
  1.52196158e-02f, 1.49963364e-01f, 2.17347257e-02f, -7.93032572e-02f, -1.56269461e-01f, -1.43027738e-01f, -1.73889741e-01f, -7.17164874e-02f, 1.65246993e-01f, 4.96007241e-02f,
  -7.26938322e-02f, -4.54239212e-02f, 5.12983501e-02f, -1.02110140e-01f, -4.07064445e-02f, 3.87821309e-02f, -4.21190001e-02f, -9.83580500e-02f, -2.73362417e-02f, 9.54483002e-02f,
  1.04261609e-02f, 1.42805487e-01f, 7.21251965e-03f, -7.00954348e-02f, 1.24235772e-01f, -5.96729591e-02f, 6.61626877e-03f, 1.24283515e-01f, 4.78476584e-02f, 4.12084535e-02f,
  1.02592163e-01f, 1.14266127e-01f, 9.74861458e-02f, 6.98525608e-02f, 1.22971162e-01f, 7.51123875e-02f, 4.14194725e-03f, 4.36908677e-02f, -1.25672389e-02f, -8.34552050e-02f,
  2.18530059e-01f, -5.24227740e-04f, -5.96059710e-02f, 6.92689344e-02f, 1.67422682e-01f, -4.36780117e-02f, -2.38809407e-01f, -7.12032095e-02f, -5.60984798e-02f, 5.30689433e-02f,
  -1.19653113e-01f, 6.45418167e-02f, -8.41331407e-02f, 1.06754310e-01f, 6.07050359e-02f, 1.13683291e-01f, 6.01389562e-04f, 2.21826639e-02f, -4.09351364e-02f, -1.62442490e-01f,
  1.25326142e-01f, 2.31351227e-01f, 6.00276403e-02f, 7.02974647e-02f, -3.66000533e-02f, 2.31329009e-01f, 1.30674273e-01f, -3.31800035e-03f, -1.66705728e-01f, 7.94780999e-02f,
  2.31869221e-02f, -1.86593056e-01f, 7.24078864e-02f, 3.15920003e-02f, -2.58749165e-02f, -5.56242540e-02f, 4.93915044e-02f, -1.09146893e-01f, 1.59458011e-01f, 1.60051957e-02f,
  2.43734270e-02f, 1.34140432e-01f, -4.13920032e-03f, -6.90182531e-03f, -1.21407151e-01f, -7.78177083e-02f, -1.89098880e-01f, -6.93701133e-02f, -4.10460867e-02f, 9.19055641e-02f,
  5.80850244e-02f, -8.73205289e-02f, 3.77756357e-02f, 5.29140308e-02f, 1.32984873e-02f, -1.33448571e-01f, -8.71599372e-03f, -4.60232086e-02f, -4.31698747e-02f, -3.63486484e-02f,
  7.89618790e-02f, -3.86273488e-02f, -8.63008946e-02f, 6.69438019e-02f, -9.06473100e-02f, -4.85072704e-03f, 6.90957755e-02f, 7.82717541e-02f, -1.60555527e-01f, 1.27870115e-02f,
  1.19369989e-02f, 7.27404878e-02f, 2.83407662e-02f, 5.93232624e-02f, 1.21942330e-02f, -1.55430838e-01f, -8.45895857e-02f, -1.70669243e-01f, -3.68111371e-03f, -9.80795082e-03f,
  4.31164429e-02f, -6.64668381e-02f, 3.83649543e-02f, 7.76822567e-02f, -1.42747089e-01f, -9.64561105e-02f, 4.91683632e-02f, -1.22275380e-02f, -1.11874320e-01f, -5.10955006e-02f,
  -1.75573558e-01f, -6.91446438e-02f, 5.75262471e-04f, -1.77196518e-01f, 8.34787115e-02f, 8.57322663e-02f, -1.06361762e-01f, -2.64317803e-02f, 1.29334718e-01f, 1.05723456e-01f,
  -7.89071769e-02f, 5.67211164e-03f, 2.68069487e-02f, -1.27072141e-01f, 6.56874403e-02f, -2.98269186e-02f, 2.37581432e-02f, -3.41544747e-02f, -4.40624394e-02f, 3.67264776e-03f,
  4.35947664e-02f, 7.01678321e-02f, 2.89686043e-02f, -2.69127768e-02f, -6.34278059e-02f, 7.30434954e-02f, 1.18913241e-01f, -1.23116709e-02f, -1.65167283e-02f, 2.81861029e-03f,
  -1.65574867e-02f, 6.17779559e-03f, -1.12240523e-01f, -1.14622287e-01f, 4.69233617e-02f, 2.87262294e-02f, -1.37966201e-01f, -9.06798169e-02f, 1.07807450e-01f, -3.94773670e-02f,
  -4.29628044e-02f, -1.33829853e-02f, 8.17412063e-02f, -1.50840089e-01f, -1.05845779e-01f, 1.42336804e-02f, -7.28163794e-02f, 1.23520065e-02f, -3.79564688e-02f, -1.33274004e-01f,
  1.21534124e-01f, 9.13329946e-04f, 1.99267529e-02f, 3.23867910e-02f, 1.48372233e-01f, 6.40674308e-02f, -8.77084509e-02f, -9.93604362e-02f, -2.63406746e-02f, 4.41271402e-02f,
  1.44203618e-01f, 1.07161760e-01f, -1.12285633e-02f, 1.55797631e-01f, 3.10808141e-02f, -8.16261917e-02f, -5.25824260e-03f, 2.53230724e-02f, 1.49687320e-01f, 7.17456080e-03f,
  5.97218238e-02f, -1.06760070e-01f, 1.61358770e-02f, -8.80623758e-02f, -1.10052250e-01f, -1.90780252e-01f, 1.03227183e-01f, -7.27236047e-02f, -2.58026104e-02f, 1.05308600e-01f,
  1.13724936e-02f, -6.47490695e-02f, -1.46124333e-01f, -1.01145208e-01f, -2.90942821e-03f, 7.24978596e-02f, 2.40133852e-02f, 1.55058220e-01f, 5.28976917e-02f, 9.17091221e-02f,
  -2.13045068e-03f, -4.13734987e-02f, -1.93388499e-02f, 1.66184664e-01f, -9.13097616e-03f, 4.36405167e-02f, 5.35058714e-02f, 5.80182858e-02f, -1.96183827e-02f, -1.91632342e-02f,
  -1.44429440e-02f, -7.33605772e-02f, 2.21640795e-01f, 1.58740550e-01f, -1.08746581e-01f, 5.16534597e-03f, 1.94979265e-01f, -9.32988673e-02f, -6.60885870e-03f, -1.70946363e-02f,
  -3.01018860e-02f, 8.59768242e-02f, 7.62574226e-02f, 4.29001451e-03f, 2.64107063e-03f, 1.65632263e-01f, -6.03829548e-02f, 2.06851326e-02f, 5.25462180e-02f, 1.15538277e-02f,
  5.19106351e-02f, -1.37551814e-01f, 9.49702188e-02f, 6.81580529e-02f, -3.13235037e-02f, 3.40817682e-02f, 4.31015715e-02f, 1.68627590e-01f, 1.45190701e-01f, -3.32521722e-02f,
  -6.49833605e-02f, 1.39522627e-01f, 7.27445036e-02f, -1.08204871e-01f, 5.64754046e-02f, -7.03353360e-02f, 5.26274443e-02f, -1.82708755e-01f, -1.16447434e-01f, -1.85058668e-01f,
  1.26583263e-01f, 9.40608308e-02f, -2.92308275e-02f, 1.13696098e-01f, -4.15968075e-02f, -9.68078300e-02f, -1.09997757e-01f, -1.03977904e-01f, -1.07207470e-01f, -6.39383942e-02f,
  -1.01446390e-01f, 1.63798898e-01f, 5.25452122e-02f, -9.25288796e-02f, -2.04837434e-02f, 2.16473117e-02f, 4.51505966e-02f, 1.47338212e-01f, -5.27526289e-02f, -1.76255091e-03f,
  8.66405740e-02f, 1.16386954e-02f, -1.68845415e-01f, 2.81889904e-02f, 3.64515145e-04f, -5.23697697e-02f, 1.04518004e-01f, 9.95376930e-02f, -6.27290308e-02f, 1.67654566e-02f,
  1.63559675e-01f, -3.81279271e-03f, -8.35313722e-02f, 1.25803351e-02f, -1.30316138e-01f, 3.58515158e-02f, 9.51202810e-02f, 6.99736699e-02f, 7.48023912e-02f, 1.88887462e-01f,
  -1.03250757e-01f, 6.51419312e-02f, -1.05608283e-02f, 9.34152082e-02f, -1.06312968e-01f, -8.42292607e-02f, 3.17654312e-02f, -4.77594957e-02f, -5.61912358e-02f, 2.28164177e-02f,
  6.69144467e-02f, 8.61276239e-02f, 4.60840538e-02f, -1.48929162e-02f, -5.80811761e-02f, 1.26646608e-01f, -3.20156403e-02f, -1.11936770e-01f, -6.81679649e-03f, 1.47042172e-02f,
  1.33257985e-01f, -5.94735220e-02f, -4.32594866e-02f, -5.03948480e-02f, -9.03690606e-02f, 1.71467200e-01f, -1.36859551e-01f, 2.72377282e-02f, 8.54770169e-02f, -1.41773857e-02f,
  -3.19123007e-02f, 1.43981855e-02f, -1.66015431e-01f, -5.52517436e-02f, -8.85477737e-02f, 1.39975101e-01f, 7.14830905e-02f, -4.98913862e-02f, -3.14327814e-02f, -2.23691645e-03f,
  8.93319845e-02f, 1.35822058e-01f, 2.24675424e-02f, 5.39598390e-02f, -4.81559075e-02f, 1.51513383e-01f, 1.08132064e-01f, 8.51831213e-02f, 2.65787430e-02f, 4.94055524e-02f,
  -3.45520093e-03f, 4.58917581e-03f, 6.76149204e-02f, 7.08763599e-02f, 1.54864155e-02f, 3.97569314e-03f, -1.43284127e-01f, 1.34071931e-01f, -1.68981627e-02f, 4.11658697e-02f,
  3.92559245e-02f, -1.00619726e-01f, 2.09700782e-02f, 2.78922711e-02f, 3.84871215e-02f, 9.90277231e-02f, -2.32611522e-02f, 5.11961207e-02f, 6.54785037e-02f, -7.95847327e-02f,
  4.95821312e-02f, -5.06546982e-02f, 1.26895770e-01f, 2.08116964e-01f, -1.05936833e-01f, 1.16732307e-01f, -5.69686219e-02f, -2.22603455e-01f, -4.28400375e-02f, -1.85517311e-01f,
  1.19014472e-01f, -7.49928728e-02f, -1.24125995e-01f, -4.66462709e-02f, 1.06165506e-01f, -5.82084805e-02f, 8.55750144e-02f, 3.77484262e-02f, 8.68777931e-02f, 3.94857004e-02f,
  7.16411788e-03f, 3.74364736e-03f, -9.34152305e-02f, 9.54373833e-03f, -1.39998496e-01f, -6.80379644e-02f, -1.52737930e-01f, -1.03417197e-02f, 1.42525434e-02f, 2.02600241e-01f,
  1.18454685e-02f, -1.33489966e-01f, 5.67530692e-02f, -7.76040601e-03f, 9.69667435e-02f, 1.61795113e-02f, -6.29072711e-02f, -1.45146223e-02f, -1.38361409e-01f, 1.67756192e-02f,
  -3.31298858e-02f, 2.19040848e-02f, -6.40064254e-02f, -1.76157039e-02f, 1.10316657e-01f, -7.99229071e-02f, 7.19233006e-02f, 8.34037364e-02f, 5.62274493e-02f, -1.82649363e-02f,
  -2.07093030e-01f, 1.07098877e-01f, -3.27171572e-02f, 3.08907107e-02f, -1.32832676e-01f, -1.70822412e-01f, -2.58084610e-02f, -4.93710525e-02f, 8.73665512e-02f, 1.00046352e-01f,
  1.79415479e-01f, 4.37512994e-03f, -4.06740382e-02f, -1.12454213e-01f, 1.00440960e-02f, -6.51026815e-02f, 1.33671716e-01f, -3.24847316e-03f, 2.64590159e-02f, 1.11152656e-01f,
  -8.93627629e-02f, -9.26903412e-02f, -3.84522378e-02f, -1.06594808e-01f, 2.91086603e-02f, -1.57645687e-01f, -1.83056835e-02f, -1.90669354e-02f, 1.15133576e-01f, -3.63586820e-03f,
  7.25193843e-02f, -1.32841513e-01f, -5.04559353e-02f, -1.51445419e-01f, 7.04756677e-02f, 2.54337266e-02f, -1.01995163e-01f, -4.04388309e-02f, -5.59123196e-02f, -1.07980683e-01f,
  3.28767896e-02f, -1.05109103e-01f, 1.10397212e-01f, 1.06748410e-01f, 2.80468073e-02f, -1.35454731e-02f, 5.70346974e-03f, 7.20185488e-02f, -4.60197441e-02f, -1.37684926e-01f,
  7.79731870e-02f, -1.24734141e-01f, 5.73924184e-02f, -1.63218379e-01f, 5.62300496e-02f, -9.91751850e-02f, -1.04798429e-01f, 3.86284068e-02f, -7.54531398e-02f, -1.76882431e-01f,
  1.32394969e-01f, 1.86990514e-01f, -1.54555321e-01f, 6.17159195e-02f, -4.30107377e-02f, 1.63239334e-02f, 8.44001696e-02f, -1.28551438e-01f, -1.18820630e-01f, -9.34727490e-02f,
  -1.25000343e-01f, -2.15920419e-01f, 9.91334245e-02f, 7.14284554e-03f, -6.43374324e-02f, -5.49793765e-02f, -8.71266946e-02f, 5.60597517e-02f, -1.94549896e-02f, 4.40022759e-02f,
  1.73907820e-02f, 2.39627939e-02f, -9.35777575e-02f, -1.05678469e-01f, -1.27369344e-01f, -1.30364835e-01f, 5.31716235e-02f, -2.22276360e-01f, -1.26566768e-01f, -1.19099408e-01f,
  6.84907958e-02f, 1.06483452e-01f, 1.49825692e-01f, 7.35848919e-02f, 7.99359828e-02f, -4.60070418e-03f, -2.30408255e-02f, -2.06218049e-01f, -3.67348567e-02f, -7.75646120e-02f,
  -1.01677753e-01f, 4.92555499e-02f, 8.76248330e-02f, 8.96521434e-02f, 1.28741816e-01f, -3.48765180e-02f, 1.52474716e-01f, -4.71308008e-02f, -7.51502737e-02f, 8.78882259e-02f,
  -4.01318893e-02f, 7.91102946e-02f, -3.07456236e-02f, -1.52188361e-01f, -8.33855197e-02f, -9.21411216e-02f, 9.21505969e-03f, -8.96819159e-02f, -1.86220840e-01f, -6.88777789e-02f,
  -2.86695305e-02f, -3.43042947e-02f, -7.24472106e-02f, -9.22442600e-02f, 6.18384108e-02f, 8.40466619e-02f, -4.74866070e-02f, 7.66214952e-02f, 4.78470139e-02f, 1.06674004e-02f,
  8.00428614e-02f, -4.27334234e-02f, -8.49381760e-02f, -1.70706734e-02f, -1.22999705e-01f, -1.24593846e-01f, 1.06355650e-02f, -1.55142918e-02f, -5.47055900e-02f, 2.47575529e-02f,
  -1.11340791e-01f, 1.25874564e-01f, 4.98863384e-02f, 6.28489554e-02f, 6.88800961e-02f, -1.20228976e-01f, 7.00065494e-02f, -5.64806126e-02f, -8.97173956e-02f, 1.23662688e-01f,
  1.27390862e-01f, 3.92529666e-02f, -1.56795368e-01f, 8.29776153e-02f, 8.70527178e-02f, -2.26193387e-02f, -1.33029461e-01f, -4.78341943e-04f, 3.85257602e-02f, 1.21705361e-01f,
  -1.40075535e-01f, 4.68700156e-02f, -1.00621618e-01f, -1.17922649e-01f, -3.77114154e-02f, -4.96022291e-02f, 1.36879310e-01f, 7.64908418e-02f, 1.29175365e-01f, -2.73017455e-02f,
  5.24759442e-02f, -1.69277117e-01f, -2.96846889e-02f, 9.37606841e-02f, -7.67131299e-02f, -3.70405242e-02f, 9.53201354e-02f, -1.11194022e-01f, -4.77280691e-02f, -1.18533663e-01f,
  -5.16523933e-03f, 4.48206253e-02f, -6.29941747e-02f, 1.17777744e-02f, 1.24358153e-02f, -5.15336916e-02f, -7.78593123e-02f, 8.49213079e-02f, 6.99305236e-02f, 9.24312230e-03f,
  -1.20460205e-01f, -9.11190137e-02f, 2.51408041e-01f, 1.47356912e-01f, -1.81576595e-01f, -1.67977624e-02f, 2.50586301e-01f, -4.39579524e-02f, 9.62869376e-02f, -1.02531891e-02f,
  -2.41779298e-01f, 1.43323075e-02f, -1.37179747e-01f, 2.20191688e-03f, 9.72396135e-02f, -8.10477287e-02f, -8.91662091e-02f, -2.46930778e-01f, -1.88634396e-01f, -9.30581766e-04f,
  1.23574641e-02f, -1.40606225e-01f, -4.76081064e-03f, 4.54577878e-02f, 1.14874862e-01f, 3.38715613e-02f, 1.03042303e-02f, 8.26271102e-02f, -5.06865159e-02f, -5.89265563e-02f,
  1.18276507e-01f, 1.18494630e-01f, -1.66700669e-02f, 2.94328164e-02f, -1.99057043e-01f, -4.13936265e-02f, 7.59852817e-03f, 1.08852997e-01f, 6.42438307e-02f, -1.64946795e-01f,
  1.06952451e-01f, 6.15242384e-02f, 1.85882032e-01f, 3.41984779e-02f, -2.97725257e-02f, 8.34666267e-02f, -1.81968734e-02f, 1.76610630e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  5.66506684e-02f, -3.85028981e-02f, 1.31666169e-01f, -7.35110343e-02f, -2.28414014e-02f, -1.15258172e-01f, 3.59246461e-03f, -7.95293972e-02f, 1.72266304e-01f, -1.10575572e-01f,
  -1.37132898e-01f, -1.01184644e-01f, -8.90336335e-02f, -7.36268982e-02f, -2.83282399e-02f, -4.44575846e-02f, -1.88016713e-01f, -9.81468335e-02f, 5.57013229e-02f, 2.23397817e-02f,
  1.93341151e-02f, 1.05559587e-01f, 1.93651870e-01f, -2.75049418e-01f, 6.53087422e-02f, -1.05344154e-01f, -7.12458417e-02f, 6.25675172e-02f, -3.52812670e-02f, 5.84679805e-02f,
  -4.38192151e-02f, -5.87376878e-02f, -3.03077344e-02f, -7.97222853e-02f, -4.36712466e-02f, 1.61765933e-01f, 7.86179528e-02f, 5.60251437e-02f, 4.88513894e-03f, 7.51207024e-02f,
  2.22974166e-01f, -3.37071680e-02f, 2.38288209e-01f, 5.63615561e-02f, -6.92313761e-02f, -4.39635217e-02f, 1.19789980e-01f, 1.74480259e-01f, -9.77437347e-02f, -2.26732772e-02f,
  -7.42409453e-02f, -2.87628025e-02f, 1.74554273e-01f, 2.38712937e-01f, 3.66881415e-02f, 5.84410550e-03f, -6.32968396e-02f, -1.15827464e-01f, 1.45687848e-01f, 1.77857041e-01f,
  6.70454130e-02f, 1.43029168e-01f, -3.74126844e-02f, -5.84982596e-02f, 4.13746163e-02f, -2.22868584e-02f, 7.06933215e-02f, 1.06789619e-01f, 6.05859347e-02f, 1.38925046e-01f,
  -1.08223587e-01f, -4.86297682e-02f, 1.20846443e-01f, 4.53672670e-02f, -3.64573821e-02f, 8.99241418e-02f, -7.24290386e-02f, -7.81822354e-02f, -2.95861345e-02f, -4.94556641e-03f,
  -9.20181423e-02f, -8.91668815e-03f, -1.02541812e-01f, -3.61198559e-02f, 1.37067661e-01f, 3.17147095e-03f, -1.25393048e-01f, -9.01049003e-02f, 9.19627864e-03f, 7.35880621e-03f,
  1.24187365e-01f, 1.21054322e-01f, 1.25685304e-01f, 2.70840358e-02f, -4.31248285e-02f, 6.72306120e-02f, 6.98093027e-02f, 1.06149375e-01f, 1.95004284e-01f, 7.31895044e-02f,
  -1.25064384e-02f, 8.92945230e-02f, -4.97518517e-02f, -1.27480239e-01f, -7.81378821e-02f, -8.79419968e-02f, 1.92749035e-02f, 1.24365076e-01f, -5.02818869e-03f, -4.04924490e-02f,
  6.13720752e-02f, -8.31690803e-03f, 1.51993632e-01f, -5.64864054e-02f, 1.85107723e-01f, -5.15781641e-02f, 1.33733928e-01f, 1.59451254e-02f, -7.40071312e-02f, 1.48710042e-01f,
  -1.07786976e-01f, -6.67997599e-02f, -8.45329557e-03f, 7.76590332e-02f, 1.13999158e-01f, 7.74431676e-02f, -4.12179604e-02f, 3.69540304e-02f, 6.66865483e-02f, 3.27644683e-03f,
  -4.66402397e-02f, -2.20681280e-02f, 1.03959963e-01f, -7.41798291e-03f, 1.27539381e-01f, 6.28944067e-03f, 1.44149110e-01f, -4.62878682e-03f, 5.96036315e-02f, 5.99147528e-02f,
  -3.24225612e-02f, -9.40070823e-02f, -1.12498114e-02f, -3.29661928e-02f, 4.00004052e-02f, 3.59012857e-02f, -1.64511532e-01f, -1.87269986e-01f, 1.62435085e-01f, -2.65217014e-02f,
  -1.58372402e-01f, 1.36843726e-01f, -1.91021323e-01f, -3.78426723e-02f, 1.88471168e-01f, -7.36366287e-02f, 3.71805504e-02f, 9.47403684e-02f, 5.96361645e-02f, 5.21643870e-02f,
  7.66924843e-02f, 2.32466757e-01f, 1.63388953e-01f, -5.69038279e-02f, -2.63469592e-02f, 1.17464885e-01f, 1.12950750e-01f, 2.66489796e-02f, -9.78105206e-08f, 3.56653631e-02f,
  -1.42559066e-01f, -3.84788699e-02f, 3.81505042e-02f, 1.32207438e-01f, -1.65336564e-01f, 4.33882773e-02f, 9.02605578e-02f, 1.59835722e-02f, 2.36977890e-01f, 2.06206348e-02f,
  1.00258321e-01f, -8.99364706e-03f, -2.84022484e-02f, 9.81825218e-02f, 3.62894312e-02f, 9.47644264e-02f, -4.15344089e-02f, -8.11183453e-03f, 4.15427610e-02f, 7.90895149e-03f,
  3.95179950e-02f, -5.12587875e-02f, 2.58620847e-02f, 7.42855370e-02f, -6.23465329e-03f, -7.19859600e-02f, -5.55388890e-02f, 6.81332424e-02f, 5.91160357e-02f, -2.98438501e-02f,
  -1.21966004e-01f, -1.12646502e-02f, 9.08967927e-02f, -1.75572874e-03f, -3.38390395e-02f, -1.03495792e-01f, 1.95036560e-01f, 3.07023991e-03f, -7.25730732e-02f, 2.75402032e-02f,
  -2.61015631e-02f, -2.42222324e-02f, -1.72120526e-01f, -1.33195996e-01f, -8.68271887e-02f, -4.09389799e-03f, 1.45525381e-01f, 1.58257354e-02f, 7.99548924e-02f, -6.43043518e-02f,
  5.13392389e-02f, 1.70031637e-01f, 3.62042058e-03f, 1.56255186e-01f, -1.64937973e-01f, -4.61925194e-02f, 3.24451784e-03f, -6.35362566e-02f, 5.43796532e-02f, 1.06994458e-01f,
  -5.17622605e-02f, -3.63931656e-02f, 1.81555692e-02f, 1.01852324e-02f, -2.76400466e-02f, 3.69637972e-03f, 1.86164036e-01f, 1.35170862e-01f, 4.48782369e-03f, -3.40993069e-02f,
  -2.65483335e-02f, -2.36801859e-02f, -1.17320925e-01f, 5.04208989e-02f, -1.25600845e-01f, -6.89210445e-02f, 1.36953682e-01f, 7.98062161e-02f, 1.28511816e-01f, 1.52463049e-01f,
  -1.29740434e-02f, -8.97000432e-02f, 1.81875974e-01f, -4.89174053e-02f, 2.55925618e-02f, 1.20304950e-01f, 9.35396627e-02f, 4.74090409e-03f, -4.35886309e-02f, 1.00296378e-01f,
  3.63912210e-02f, 9.63978097e-02f, 6.03344589e-02f, -2.78120600e-02f, 8.71091783e-02f, 1.48922987e-02f, -3.60481441e-03f, 9.53495204e-02f, 7.42357969e-03f, -8.75394121e-02f,
  -8.53993520e-02f, -6.43525645e-02f, 2.05802359e-02f, 5.14630899e-02f, -1.70105666e-01f, -9.28618684e-02f, 2.15071201e-01f, 7.74142966e-02f, -1.97090030e-01f, 5.68489991e-02f,
  -2.11572856e-01f, -3.56091373e-02f, 1.43208966e-01f, 8.56137648e-02f, 5.90171367e-02f, -2.11104937e-02f, -1.81931462e-02f, 4.47988398e-02f, 6.07894361e-02f, 2.16400295e-01f,
  1.00247063e-01f, 4.77759279e-02f, -1.05228499e-01f, 1.60664588e-01f, 7.01433271e-02f, -1.10443771e-01f, -9.62638482e-02f, 7.55895162e-03f, 4.88593243e-02f, 5.11334576e-02f,
  -2.30480693e-02f, -1.82878282e-02f, 5.38080418e-03f, -1.18624948e-01f, 4.55987900e-02f, -8.58887434e-02f, 2.06607983e-01f, 4.02923003e-02f, 1.51196986e-01f, -1.15652354e-02f,
  -1.60114288e-01f, 1.23113692e-01f, -1.09631218e-01f, -2.08173171e-02f, -3.00086290e-02f, 7.45865703e-03f, 6.20623603e-02f, 3.77851203e-02f, -3.26042157e-03f, -9.76623297e-02f,
  -4.61366959e-02f, 1.01203576e-01f, 2.12942716e-02f, 4.74430770e-02f, 9.08248127e-02f, 9.30748507e-02f, 1.29798010e-01f, 5.34881093e-02f, 3.82557064e-02f, 7.01765493e-02f,
  8.34673271e-02f, 1.14183933e-01f, -1.76319927e-02f, 9.70507413e-02f, -1.60356797e-02f, -5.33954464e-02f, -8.79500434e-03f, 1.00684121e-01f, -3.24606523e-03f, -4.31040789e-05f,
  1.94689751e-01f, 3.83129790e-02f, -2.04353244e-03f, 9.38309133e-02f, -3.97014581e-02f, 3.95544358e-02f, 5.52008301e-02f, -6.68310225e-02f, -9.65014175e-02f, -3.62802371e-02f,
  -2.91879140e-02f, -4.82198969e-02f, 1.27288342e-01f, 1.94409758e-01f, -8.27204436e-02f, 3.08654830e-02f, -8.69842693e-02f, 1.00368358e-01f, 4.51795124e-02f, -8.43087211e-02f,
  -6.68919981e-02f, 5.31798191e-02f, 4.64111157e-02f, 8.32135379e-02f, 2.19666362e-02f, 7.45736063e-03f, -6.67592809e-02f, -6.73289746e-02f, 1.55660242e-01f, 5.76594472e-02f,
  1.97443768e-01f, 1.06403366e-01f, 8.71246457e-02f, 3.59602869e-02f, 1.41474809e-02f, 3.54020521e-02f, 3.47105861e-02f, 1.05561286e-01f, -7.24076852e-02f, 8.57888833e-02f,
  2.65539140e-02f, -8.66638403e-03f, -1.49388751e-02f, 1.32630281e-02f, 6.32456839e-02f, -1.09468162e-01f, -5.34358881e-02f, -4.49208543e-02f, -4.50103246e-02f, -7.51015097e-02f,
  4.96651651e-03f, -4.13494185e-02f, 5.30480184e-02f, -1.46626070e-01f, -1.41308263e-01f, -1.12109515e-03f, 5.65094836e-02f, 4.39510196e-02f, -8.28547627e-02f, -7.30170235e-02f,
  4.56170738e-02f, -1.55705690e-01f, 6.35786876e-02f, -5.47887720e-02f, 5.95385619e-02f, 1.52822167e-01f, 8.67243409e-02f, -4.06905487e-02f, -1.23302210e-02f, 1.05274878e-01f,
  -5.95332570e-02f, 4.01163660e-02f, 2.39914358e-02f, 1.71448775e-02f, -4.20722403e-02f, -1.46411985e-01f, 1.81832045e-01f, 6.72151754e-03f, -7.98571557e-02f, 6.84573278e-02f,
  7.57823959e-02f, 1.23315357e-01f, 1.19666256e-01f, 2.19028756e-01f, 1.42322391e-01f, 2.25509882e-01f, 7.84225687e-02f, 3.56196687e-02f, -4.90563996e-02f, -3.79694626e-02f,
  2.48236749e-02f, -4.92991414e-04f, -1.70215055e-01f, -1.61157101e-01f, 1.46500915e-01f, 6.29725382e-02f, 3.75032909e-02f, 1.86027765e-01f, 9.48412493e-02f, -1.35694623e-01f,
  -1.15295663e-01f, -6.90535381e-02f, 1.52354673e-01f, 1.17879555e-01f, -7.32732788e-02f, 7.88298771e-02f, -1.90658018e-03f, -5.11726663e-02f, 4.57583501e-30f, -3.67378472e-30f,
  -2.93179106e-30f, 4.61443862e-30f, 2.96530581e-30f, 2.86579739e-31f, -1.40814885e-30f, 4.80232936e-32f, 2.52529176e-30f, -2.51185445e-30f, -4.02732076e-30f, -3.26816130e-30f,
  -2.10419813e-31f, 4.52380490e-31f, 1.10076582e-30f, -2.06642291e-31f, 2.81909933e-30f, -3.81768140e-30f, -3.74682749e-30f, 1.57058035e-30f, -3.27018315e-30f, -9.92766481e-31f,
  -7.93091110e-32f, 4.99998520e-32f, -1.69161572e-27f, 2.25924901e-32f, 1.61435097e-30f, 1.24681791e-32f, 1.42409120e-34f, 4.92598449e-40f, 5.71286455e-30f, -7.25980271e-30f,
  -3.20843792e-30f, 4.57315451e-31f, -1.85776557e-30f, -1.12449869e-32f, -1.20022993e-31f, -8.80462178e-28f, 9.17368740e-34f, 1.00371065e-29f, -1.90172943e-30f, -2.14851685e-30f,
  -3.57074634e-30f, -3.30644857e-30f, -4.56721828e-29f, 7.07630672e-31f, -9.52876292e-33f, -1.23431654e-29f, 1.23094345e-29f, -5.60530814e-31f, -2.85917259e-30f, -3.07237736e-30f,
  -3.34285805e-30f, -7.38462816e-33f, -8.08733423e-37f, -8.38820732e-30f, -1.79068076e-30f, -1.88396085e-30f, 1.54527004e-29f, 5.44189148e-30f, -8.12765447e-33f, -7.11100687e-33f,
  -5.98184887e-40f, -4.94557464e-40f, 5.25952131e-02f, 5.22620976e-02f, 3.94598767e-02f, 2.00191252e-02f, 4.76446236e-03f, -2.87614595e-02f, 1.08882785e-01f, 5.28962351e-02f,
  2.78724190e-02f, 2.91172080e-02f, 3.42846885e-02f, -1.26656696e-01f, 1.61540985e-01f, 4.92766984e-02f, -1.87662363e-01f, -1.58264741e-01f, 2.59609997e-01f, -3.49976122e-02f,
  -1.03726998e-01f, -1.01265304e-01f, 2.77744811e-02f, -3.30415219e-02f, -8.91225114e-02f, 1.80600107e-01f, 1.01705298e-01f, 1.11346006e-01f, 1.35953594e-02f, 2.77367799e-04f,
  5.50887845e-02f, 3.06169931e-02f, 9.84605774e-02f, -1.47926077e-01f, 1.84925824e-01f, 2.32028693e-01f, -6.43467903e-02f, -7.73747936e-02f, 1.22882165e-01f, 9.02402401e-02f,
  2.96191365e-01f, 1.95426702e-01f, -1.74675286e-01f, 2.62595624e-01f, 2.14420110e-02f, -9.73939747e-02f, -3.46051231e-02f, 6.63315207e-02f, -2.08844841e-01f, -1.00404032e-01f,
  -1.20048635e-01f, -1.53444007e-01f, 2.09826604e-01f, 2.01390743e-01f, -6.55576885e-02f, 4.61158194e-02f, 2.98821945e-02f, -1.15019875e-02f, -8.73347372e-02f, 7.32463449e-02f,
  -9.16627049e-02f, -6.62869737e-02f, -1.37738854e-01f, -7.24787116e-02f, 7.71916956e-02f, 9.38713457e-03f, 6.19405620e-02f, -7.30232289e-03f, 2.76841200e-03f, -1.83153730e-02f,
  -1.79479327e-02f, 1.52338639e-01f, 5.24063669e-02f, -1.12056741e-02f, -7.68485591e-02f, 6.17027581e-02f, 9.78438482e-02f, 7.71154836e-02f, -6.74580708e-02f, -7.28769675e-02f,
  1.18874684e-01f, 2.85280012e-02f, -2.00187564e-02f, 9.10005998e-03f, -1.01792268e-01f, 6.08461909e-03f, -2.94167567e-02f, -1.27920732e-01f, -1.29324377e-01f, 7.42977485e-02f,
  8.53005201e-02f, 5.11993058e-02f, 1.49201348e-01f, 2.35150312e-03f, 1.46576419e-01f, 1.16837464e-01f, 1.13475859e-01f, 9.13067386e-02f, 5.33496551e-02f, 6.20036907e-02f,
  1.82457268e-01f, -3.87943983e-02f, 3.82191911e-02f, 1.41213760e-01f, 5.93267195e-02f, -2.88881902e-02f, -5.07850274e-02f, 9.30696949e-02f, -1.03985228e-01f, 3.15443426e-02f,
  1.19775750e-01f, 1.16620719e-01f, -4.50677983e-02f, -6.36104448e-03f, 1.42698497e-01f, -4.86953836e-03f, 2.86631268e-02f, 9.36589614e-02f, -3.57000642e-02f, 1.86074506e-02f,
  1.40997469e-01f, 1.11156106e-01f, 5.11688143e-02f, 3.22306268e-02f, -1.01094795e-02f, -1.94145665e-02f, 1.29038751e-01f, -3.62804532e-02f, 2.00794917e-02f, 1.95851535e-01f,
  -1.26291560e-02f, -2.28788350e-02f, 4.07534689e-02f, 1.11125924e-01f, 5.92407696e-02f, 2.74095610e-02f, 7.33929221e-03f, 1.33958310e-01f, 1.94042489e-01f, 1.30852595e-01f,
  3.04318685e-02f, 1.45975351e-01f, -1.33087173e-01f, 2.31190547e-01f, -1.98820725e-01f, -2.10337922e-01f, -1.24840006e-01f, 8.00071359e-02f, 1.77977383e-01f, -3.72768231e-02f,
  2.23919988e-01f, 2.19354153e-01f, 1.86821163e-01f, 8.90768170e-02f, 9.24055278e-02f, 1.80341810e-01f, -9.98036712e-02f, -1.24206915e-01f, -1.31312147e-01f, -1.21906810e-01f,
  6.38684928e-02f, 2.87077725e-02f, 1.06918626e-01f, 5.74625470e-02f, -1.21557236e-01f, -8.62711109e-03f, 3.23466328e-03f, -9.69890784e-03f, 7.68643096e-02f, 2.00581670e-01f,
  6.26583695e-02f, 1.01842351e-01f, 2.49458447e-01f, 2.42665038e-01f, -1.32562384e-01f, -9.87107754e-02f, 3.43543477e-02f, 9.59626436e-02f, 1.34311140e-01f, 1.20035410e-01f,
  2.83705771e-01f, 1.12446770e-01f, 6.96612522e-02f, 7.67178908e-02f, -2.52496894e-03f, 4.62430157e-02f, -4.10061842e-03f, 1.35268092e-01f, 1.02919556e-01f, 2.05959529e-01f,
  -1.75642565e-01f, -5.62291499e-03f, -4.06155139e-02f, -1.74363956e-01f, 1.34020999e-01f, -3.04833595e-02f, 6.16569631e-02f, 1.12133250e-01f, 3.50016099e-03f, 9.66817662e-02f,
  3.85354981e-02f, 6.52040467e-02f, 9.97301470e-03f, 3.09890136e-02f, -2.18164939e-02f, -4.65115570e-02f, 1.41222522e-01f, 2.22821441e-02f, -1.06425345e-01f, -3.25749116e-03f,
  1.58210129e-01f, -1.99771896e-01f, -1.81461170e-01f, -2.29740851e-02f, -1.11702554e-01f, 5.07861450e-02f, 1.18132956e-01f, 6.99246675e-03f, 8.88692811e-02f, 1.69212118e-01f,
  1.14122070e-02f, 1.23931281e-01f, 1.79553479e-01f, 1.64080307e-01f, -1.14974426e-02f, -3.96069586e-02f, 2.02171132e-01f, 2.45807413e-02f, -4.08109426e-02f, 1.73123971e-01f,
  1.31210104e-01f, 1.98403254e-01f, 1.87634736e-01f, 8.99405330e-02f, 1.01440743e-01f, 1.65091798e-01f, 2.26410717e-01f, -1.48567244e-01f, 7.55179524e-02f, -6.39001057e-02f,
  1.47942245e-01f, -1.35717437e-01f, -2.27943081e-02f, -8.78163129e-02f, 2.88197771e-02f, 9.13897976e-02f, 4.24219370e-02f, 1.57221273e-01f, 1.30057916e-01f, -7.32754171e-02f,
  -1.77909121e-01f, -1.26847178e-01f, -1.23531565e-01f, -6.34184778e-02f, -2.53987908e-02f, 2.12449595e-01f, 6.14968762e-02f, -4.76394817e-02f, 7.45929917e-03f, -4.46296707e-02f,
  -6.89773262e-02f, -1.81762815e-01f, -6.88028410e-02f, 5.66034056e-02f, 6.61665052e-02f, -2.50840187e-02f, -9.31503475e-02f, -7.01422840e-02f, 2.87773144e-02f, -1.00071460e-01f,
  -1.28339827e-01f, -1.00308649e-01f, 3.52260172e-02f, -1.81687754e-02f, -1.55399472e-01f, 7.14801103e-02f, 2.04960275e-02f, -8.35568756e-02f, -6.13560602e-02f, -1.69588447e-01f,
  -1.62543319e-02f, 9.03181359e-02f, 1.04275450e-01f, -1.49382025e-01f, 5.55536011e-03f, -2.05999419e-01f, 6.25984520e-02f, 9.21891853e-02f, 5.81017835e-03f, 5.04534990e-02f,
  8.88287723e-02f, 1.08007379e-01f, 3.14739384e-02f, -1.45345837e-01f, 1.71999812e-01f, 1.14270197e-02f, -5.98878153e-02f, -3.62889096e-02f, -3.74971554e-02f, 8.69997684e-03f,
  -2.30655566e-01f, 3.40851862e-03f, 4.10955027e-02f, 8.65842700e-02f, -1.84187293e-01f, 6.10402003e-02f, -1.31479755e-01f, 7.68213570e-02f, -4.33504470e-02f, 8.99331272e-02f,
  -5.35066351e-02f, -1.55864313e-01f, 1.77397504e-01f, 9.20971930e-02f, 2.22741649e-01f, 1.62141994e-01f, 1.09454930e-01f, -7.80100375e-02f, 1.44192651e-01f, -1.68634564e-01f,
  2.59657297e-03f, 1.79893449e-01f, -4.19166349e-02f, 7.20594451e-02f, 1.31418630e-02f, 6.46030605e-02f, 1.05242997e-01f, -1.40092929e-03f, -1.26231387e-01f, 1.19609006e-01f,
  1.17328182e-01f, -3.93372262e-04f, 6.98202327e-02f, 5.76428510e-02f, -1.63583517e-01f, 8.98398608e-02f, -1.29630119e-01f, -6.08137585e-02f, -1.71898767e-01f, -7.58820772e-02f,
  1.45067856e-01f, -5.60755916e-02f, 9.03658867e-02f, 1.73236221e-01f, 1.15023695e-01f, -1.98484585e-01f, -6.03350587e-02f, -8.50185677e-02f, -2.10193824e-02f, -3.99703421e-02f,
  -8.68730620e-02f, -8.00115019e-02f, 9.36530754e-02f, 1.45120159e-01f, 1.53738752e-01f, -2.55741440e-02f, -7.38055781e-02f, 5.86585701e-02f, 5.28440662e-02f, -1.41806170e-01f,
  -1.03098996e-01f, 1.18612349e-01f, 2.48567343e-01f, -1.23271383e-01f, 1.64463013e-01f, 1.73667222e-01f, -1.52596667e-01f, -8.29172507e-02f, 6.47734329e-02f, 2.30019495e-01f,
  6.70257211e-02f, 1.83682457e-01f, 2.14680359e-02f, -5.39722666e-02f, 2.50940979e-01f, 1.14380814e-01f, -2.18712594e-02f, 3.99826206e-02f, 9.81959030e-02f, 9.23222222e-04f,
  1.59204781e-01f, 1.66436210e-01f, 3.82726416e-02f, 1.72620386e-01f, -6.47686198e-02f, -1.64514974e-01f, 8.88286717e-03f, -5.07162176e-02f, -1.41483042e-02f, 4.38114963e-02f,
  -1.95347760e-02f, 8.04873928e-02f, 9.03294012e-02f, 7.38137364e-02f, -1.16255611e-01f, 3.70431952e-02f, 4.30671945e-02f, -2.64508929e-02f, 7.57676512e-02f, 1.52325720e-01f,
  -1.00028552e-01f, -8.97081196e-02f, 1.45317420e-01f, 1.88678037e-02f, 8.08801278e-02f, -1.02297785e-02f, -2.59194672e-02f, 2.76072174e-02f, 7.95515329e-02f, 1.84821799e-01f,
  1.64860636e-01f, 1.98732942e-01f, -3.13124992e-02f, 2.39165202e-02f, -1.26771452e-02f, 8.09051245e-02f, 1.08245932e-01f, -2.28418950e-02f, 1.12635046e-01f, 3.59617248e-02f,
  -1.42263234e-01f, 4.45726365e-02f, 9.25320461e-02f, 6.65132776e-02f, 2.31170505e-01f, 1.51369885e-01f, -6.51356671e-03f, 2.05211505e-01f, 5.11110313e-02f, 3.99069041e-02f,
  2.73179598e-02f, 9.83572006e-03f, -2.19804347e-02f, -4.10197340e-02f, -7.65972808e-02f, 6.64504692e-02f, 1.09450236e-01f, 2.02568278e-01f, -1.10070467e-01f, 3.72521691e-02f,
  1.59390733e-01f, -8.26022215e-03f, 2.49017999e-02f, 8.07023495e-02f, -1.33107394e-01f, -3.82984504e-02f, -8.15353766e-02f, 4.45754677e-02f, 6.13191240e-02f, 3.81632149e-02f,
  -1.16046350e-02f, 3.87645550e-02f, -4.78854543e-03f, -6.93515763e-02f, 9.10193846e-02f, 7.19946921e-02f, 1.44459248e-01f, -3.37446555e-02f, 1.67425022e-01f, 4.79753651e-02f,
  8.84473622e-02f, 1.28801446e-02f, -9.57178250e-02f, -1.48686826e-01f, -9.09875482e-02f, -3.58246937e-02f, 5.91657832e-02f, 7.87634924e-02f, -2.16980293e-01f, -1.85742080e-01f,
  2.07215279e-01f, 6.05360158e-02f, -2.07795560e-01f, 9.65707526e-02f, -1.09320283e-01f, 2.68743932e-02f, 1.99588254e-01f, -1.19852483e-01f, 1.27403466e-02f, -4.49558422e-02f,
  1.37945330e-02f, -1.77233219e-02f, 5.39228208e-02f, 2.78723657e-01f, 1.68196917e-01f, -8.59676450e-02f, -2.74932049e-02f, 1.42306402e-01f, 1.02888547e-01f, 4.61511090e-02f,
  2.91388482e-02f, -3.69782597e-02f, -1.56817392e-01f, -9.27551184e-03f, 1.84165128e-02f, 7.38022523e-03f, -1.73003092e-01f, 1.00775778e-01f, 1.69884175e-01f, -3.46763358e-02f,
  1.78882197e-01f, 5.80062345e-02f, 1.20870017e-01f, -9.85376164e-02f, -1.55909613e-01f, 1.38916522e-01f, -1.93298366e-02f, 1.17153496e-01f, 6.43546134e-02f, -4.26676497e-02f,
  7.72515237e-02f, -4.04577218e-02f, -1.86026487e-02f, -1.01156384e-02f, 1.68631941e-01f, 7.14342073e-02f, 9.93424430e-02f, 1.71706080e-01f, 1.44510284e-01f, 2.13617101e-01f,
  3.74474749e-02f, 2.06546277e-01f, -4.75437641e-02f, 2.12193243e-02f, 1.61035717e-01f, 1.63115606e-01f, 7.00470656e-02f, 8.21964592e-02f, -1.67970862e-02f, -9.01011564e-03f,
  1.84317470e-01f, -1.14287205e-01f, -2.21729711e-01f, 5.37397638e-02f, -6.40204996e-02f, 1.38477787e-01f, -4.47894968e-02f, 2.47812551e-02f, 3.81264091e-02f, 2.15563297e-01f,
  1.29120290e-01f, 2.23785773e-01f, 3.11516467e-02f, 1.01234771e-01f, 6.37619011e-03f, -1.72594748e-02f, -5.60890464e-03f, 5.60839921e-02f, 3.09643727e-02f, 2.42621019e-01f,
  -9.15523022e-02f, 1.38700917e-01f, 1.23730540e-01f, -9.85271409e-02f, -1.24251887e-01f, 4.59624492e-02f, 1.17203541e-01f, -4.14474197e-02f, 9.30362493e-02f, -4.97386642e-02f,
  1.46563455e-01f, -1.96584925e-01f, 3.87051180e-02f, -8.06819052e-02f, 1.73882574e-01f, 1.51980311e-01f, 4.36554626e-02f, 2.58245707e-01f, 1.29049867e-01f, 1.49030939e-01f,
  -1.64607018e-01f, -1.29351933e-02f, -2.88295090e-01f, 3.60585935e-02f, 1.03161603e-01f, 2.00339824e-01f, 4.67803888e-02f, 2.16600150e-02f, 7.99181238e-02f, 3.10582817e-02f,
  1.42801836e-01f, 6.31748661e-02f, -9.37434752e-03f, -1.50779029e-02f, -1.14818029e-01f, -6.68969378e-02f, 5.43800592e-02f, 9.52960104e-02f, -6.59154356e-02f, 1.51198521e-01f,
  -1.51591837e-01f, -1.28910229e-01f, 1.33352563e-01f, 5.64357191e-02f, -1.64260149e-01f, 3.75764370e-02f, -1.25636312e-03f, 2.35572201e-03f, 7.89702609e-02f, -3.04686148e-02f,
  -7.42019862e-02f, -1.91122398e-01f, 5.83771951e-02f, -7.62737244e-02f, 5.69605418e-02f, 5.17314747e-02f, 1.73391804e-01f, 6.62031323e-02f, 8.17806944e-02f, 4.85513508e-02f,
  3.47162671e-02f, -2.91003962e-03f, 2.05354735e-01f, 1.34923488e-01f, 6.50776608e-04f, -4.41673882e-02f, -1.62733942e-01f, -1.24123283e-01f, 1.44343212e-01f, -2.14196607e-01f,
  1.65499419e-01f, 1.64206937e-01f, 2.97513213e-02f, -7.74638504e-02f, 5.31938113e-02f, 6.40434399e-02f, 1.32047623e-01f, 8.69775284e-03f, 1.68512594e-02f, -1.71022788e-01f,
  1.14308096e-01f, -1.02112358e-02f, -9.13789198e-02f, 1.67834237e-01f, -2.94725429e-02f, 4.83331736e-04f, 1.26290530e-01f, 1.47182673e-01f, 1.30000666e-01f, 6.36570379e-02f,
  -5.19327559e-02f, -9.56192426e-03f, 6.93235025e-02f, 1.18326440e-01f, 1.30257621e-01f, 1.02655910e-01f, 1.52598724e-01f, 1.40001133e-01f, -1.10250019e-01f, 2.85719205e-02f,
  2.01323926e-01f, 1.25028864e-01f, 7.75623992e-02f, 6.23925738e-02f, -9.81772542e-02f, -9.16737336e-05f, -1.67047270e-02f, -1.76037084e-02f, -1.25747859e-01f, -6.74111098e-02f,
  -6.56087250e-02f, 6.06389605e-02f, 1.41342804e-01f, 1.15393199e-01f, -2.37771217e-03f, -1.48421049e-01f, -7.94394314e-02f, 5.11114821e-02f, 9.77572724e-02f, 2.03114182e-01f,
  3.05975825e-02f, -8.96630585e-02f, 1.43106580e-01f, 1.15359448e-01f, 4.81815524e-02f, 1.37409732e-01f, 1.80784076e-01f, 1.30817488e-01f, -1.77090228e-01f, 8.73922780e-02f,
  -8.85902718e-02f, -1.14185654e-01f, 1.68678358e-01f, -1.69148400e-01f, 2.54848301e-01f, 1.90923810e-01f, -8.64626467e-02f, -1.03112005e-01f, 1.66495979e-01f, 9.53104720e-02f,
  2.02123329e-01f, 3.07135098e-02f, 2.31139854e-01f, -2.19726842e-02f, 2.45080993e-01f, 1.32613048e-01f, -1.70983762e-01f, 3.34054045e-02f, -1.03435554e-01f, 1.95876244e-04f,
  8.63166377e-02f, 1.42054111e-01f, 7.89199620e-02f, 2.00815052e-01f, -4.39090952e-02f, -1.12556621e-01f, 3.99500728e-02f, 1.30037546e-01f, -3.49799879e-02f, -1.19231660e-02f,
  2.12251455e-01f, 3.59724425e-02f, 1.94129217e-02f, 1.94599610e-02f, 2.29624167e-01f, 4.40167859e-02f, 1.31426364e-01f, 1.63900286e-01f, -1.53046489e-01f, 7.53639862e-02f,
  -1.40561372e-01f, -1.00187972e-01f, -6.26751557e-02f, 1.00218490e-01f, 1.03030046e-02f, -1.37009129e-01f, 3.12175751e-01f, 1.04357608e-01f, -9.05969888e-02f, 1.09385915e-01f,
  -6.34365007e-02f, -6.54571950e-02f, 1.40130460e-01f, -1.17932968e-01f, -5.90915009e-02f, -1.24731064e-01f, 6.26396090e-02f, 1.11305386e-01f, 1.64283335e-01f, 1.59337476e-01f,
  -3.38444561e-02f, -9.67181474e-02f, -4.26545739e-02f, 6.23590546e-03f, -5.36039844e-03f, 1.06349982e-01f, 8.52598548e-02f, 2.52775736e-02f, 5.88999689e-02f, 2.09097311e-01f,
  -4.85785492e-02f, -4.66983020e-02f, -1.39243364e-01f, 2.07564965e-01f, 2.53985465e-01f, 1.75288692e-01f, 2.50300407e-01f, 8.60229284e-02f, 1.01091050e-01f, -9.72268209e-02f,
  -9.48520601e-02f, 2.09711254e-01f, 8.73547718e-02f, 1.78365394e-01f, 1.68327447e-02f, 6.74782395e-02f, -8.73925239e-02f, -5.42283766e-02f, -6.67033345e-02f, -1.43695265e-01f,
  3.61015275e-03f, -1.81218702e-02f, 4.89628362e-03f, -1.64668076e-02f, -8.42505395e-02f, 3.17171402e-02f, -1.69822592e-02f, 6.90959115e-03f, -2.35191360e-01f, 1.08703517e-03f,
  2.39374544e-02f, -6.91101477e-02f, 5.90679757e-02f, -2.74209101e-02f, 1.39526755e-01f, 5.70295826e-02f, 9.16979238e-02f, 1.79287065e-02f, -4.29974720e-02f, 8.70047733e-02f,
  -2.54103810e-01f, -1.61756635e-01f, -6.99126199e-02f, 6.97474228e-03f, 2.24393025e-01f, 5.26245162e-02f, 9.40679014e-03f, 7.26996958e-02f, 1.66271314e-01f, 1.98614046e-01f,
  2.52582207e-02f, 4.56965007e-02f, -8.53166506e-02f, -1.06833696e-01f, 3.47881727e-02f, -4.62724315e-03f, 1.08994618e-01f, 7.79575109e-02f, 3.09950691e-02f, -3.48836333e-02f,
  -1.28052175e-01f, 6.07044771e-02f, -1.16539903e-01f, -1.49445876e-01f, 2.08325133e-01f, 8.53917897e-02f, 5.46231009e-02f, -1.28936544e-01f, -8.82278159e-02f, -4.77166325e-02f,
  -2.34409645e-01f, 1.33946091e-01f, -2.25589082e-01f, -4.90882397e-02f, 2.25413784e-01f, 1.37343304e-03f, 7.04065785e-02f, 5.16622327e-02f, -9.15358663e-02f, -1.72339618e-01f,
  1.53092250e-01f, -3.49392556e-02f, 8.77813771e-02f, 2.59504139e-01f, 1.12276159e-01f, 1.20540157e-01f, 1.48909941e-01f, 2.02736273e-01f, 8.96775499e-02f, 2.69573152e-01f,
  1.03340127e-01f, 2.38540143e-01f, 7.09017739e-03f, 1.91796631e-01f, 1.49791569e-01f, 5.15159406e-02f, 8.76705647e-02f, 2.36728087e-01f, 7.18899071e-03f, -3.39357704e-02f,
  1.66669071e-01f, -2.64131613e-02f, 5.02525382e-02f, 2.21258909e-01f, -4.78293672e-02f, 1.17071144e-01f, 1.71715125e-01f, 9.80337709e-02f, 1.35932460e-01f, 2.47791767e-01f,
  -1.00042783e-01f, 1.47085696e-01f, -7.74965659e-02f, 1.42585889e-01f, 1.43081367e-01f, 7.93909281e-03f, -2.48331632e-02f, -1.16704918e-01f, -7.95865506e-02f, 2.34274939e-01f,
  -1.07241355e-01f, 1.32708445e-01f, 7.53860995e-02f, -1.39679253e-01f, -6.09389208e-02f, 1.39876291e-01f, 8.45142305e-02f, 5.95630184e-02f, -7.92182609e-02f, -8.96175504e-02f,
  2.23617867e-01f, -4.06715013e-02f, 1.86265558e-01f, 1.08257666e-01f, 1.14552723e-03f, 1.97961003e-01f, 3.33449501e-03f, 1.26668081e-01f, 3.23663764e-02f, -4.32703421e-02f,
  -4.63395678e-02f, -2.99073048e-02f, -2.08674654e-01f, 6.27053231e-02f, -7.32835159e-02f, 2.71978974e-01f, 5.15353233e-02f, 4.04131077e-02f, 3.93785909e-02f, -6.61057159e-02f,
  -4.49401736e-02f, -9.45775807e-02f, -1.18489169e-01f, -1.91861331e-01f, -8.89411718e-02f, -2.02792987e-01f, 8.10705870e-03f, -1.27676591e-01f, -1.46370322e-01f, -1.50065064e-01f,
  7.21352324e-02f, -8.72036368e-02f, -1.74363449e-01f, -8.76471996e-02f, 2.62294915e-02f, -1.93965912e-01f, 6.54039485e-03f, -8.16157088e-02f, 2.37184297e-03f, 2.23896161e-04f,
  3.94437611e-02f, -9.54510570e-02f, 7.30595142e-02f, -1.79653242e-02f, -1.75482500e-02f, -5.48727475e-02f, 1.10433169e-01f, -6.69049993e-02f, 5.87775111e-02f, -5.31333201e-02f,
  1.82144329e-01f, -5.92531934e-02f, 4.65214252e-02f, -3.05076921e-03f, 1.74830109e-01f, 1.19109847e-01f, 1.92177057e-01f, 1.25234663e-01f, 1.38187930e-01f, 1.19170032e-01f,
  1.72788709e-01f, -8.32079127e-02f, 8.60013440e-02f, -3.05996127e-02f, -8.88878703e-02f, 1.16501264e-02f, -2.72199303e-01f, -2.09066793e-01f, 9.09727141e-02f, 1.61762714e-01f,
  3.51600498e-02f, 1.38139158e-01f, 1.55323192e-01f, -6.65696710e-02f, -7.26649538e-02f, -7.52146021e-02f, 2.07218513e-01f, 9.11212787e-02f, -1.07022367e-01f, 5.59812449e-02f,
  6.59765163e-03f, -2.65325364e-02f, -8.30737501e-02f, -2.93640569e-02f, 5.67205809e-02f, 2.80745551e-02f, -1.13037685e-02f, 6.58859387e-02f, -3.70304994e-02f, -2.25487887e-03f,
  -3.35614979e-02f, 6.27644956e-02f, 1.01925693e-01f, 7.08572865e-02f, -1.74962163e-01f, -1.21726148e-01f, 1.61765367e-01f, -7.39560043e-03f, -1.51349783e-01f, 8.64316300e-02f,
  -7.93824792e-02f, 2.72897445e-02f, 7.42195547e-02f, -1.54731750e-01f, -1.31580114e-01f, 8.35546181e-02f, 4.50633913e-02f, -1.29787937e-01f, 4.90174554e-02f, -7.77507424e-02f,
  1.69149652e-01f, 1.28537312e-01f, 2.43030749e-02f, 1.28132373e-01f, -7.21970648e-02f, 1.31267831e-01f, 1.42301932e-01f, -5.95529303e-02f, -2.28269398e-02f, 1.56686589e-01f,
  -1.16199546e-01f, -1.65598560e-02f, -7.19334558e-02f, -8.55095312e-02f, -1.31689847e-01f, 1.68212682e-01f, 1.92173570e-01f, 1.86145976e-01f, 4.85723764e-02f, 1.46594912e-01f,
  4.94828597e-02f, 1.04118586e-01f, -3.38641293e-02f, -2.83132214e-02f, 5.01912497e-02f, -1.06235735e-01f, 1.42305478e-01f, 1.29772395e-01f, 5.81489429e-02f, 1.49387538e-01f,
  -1.17794443e-02f, -9.09867361e-02f, 2.10960358e-01f, 2.19657030e-02f, -1.60854030e-02f, 1.54185519e-01f, -7.42889429e-03f, 1.07373416e-01f, -6.08054288e-02f, 2.49137357e-02f,
  1.90770894e-01f, 4.80401665e-02f, 5.09864762e-02f, -8.13458301e-03f, 7.60357305e-02f, 8.29335600e-02f, 6.13887906e-02f, 8.24894980e-02f, -1.36802569e-01f, 5.56481220e-02f,
  -9.74694416e-02f, -2.10792407e-01f, -1.69130087e-01f, 1.76273733e-01f, 2.17603594e-01f, -6.14595041e-02f, 3.40401113e-01f, -1.72618758e-02f, 5.87074086e-02f, 1.49760962e-01f,
  -9.43017602e-02f, 8.66341591e-02f, 5.73080368e-02f, -1.62700862e-01f, -1.68098152e-01f, -1.35996073e-01f, 2.00200543e-01f, 2.30919853e-01f, 2.49801222e-02f, 1.31508216e-01f,
  -2.56955046e-02f, -8.01007003e-02f, -3.80981229e-02f, 1.53471055e-02f, -1.40380599e-02f, 1.73310444e-01f, 1.51817039e-01f, 4.79771383e-03f, 5.06297313e-02f, 3.06723595e-01f,
  -3.11889965e-02f, 7.37659633e-02f, -1.86059117e-01f, 2.07513317e-01f, 2.50987083e-01f, 2.66235650e-01f, 2.50931084e-01f, 4.63652276e-02f, 1.77250907e-01f, 1.14618533e-03f,
  -1.17120326e-01f, 7.03694448e-02f, 1.17634647e-01f, 2.33099118e-01f, 1.45353943e-01f, 2.42499113e-01f, -3.92766707e-02f, -2.41359472e-02f, -6.96123987e-02f, -9.96822193e-02f,
  5.16050495e-03f, 2.49205418e-02f, 1.42292917e-01f, 8.11374336e-02f, -4.25584614e-02f, 3.78331915e-02f, -1.74433395e-01f, 2.36194767e-02f, -1.21168271e-01f, 1.00360503e-02f,
  -6.27747104e-02f, 5.74094243e-02f, -6.37122765e-02f, -6.28108531e-02f, 1.72978386e-01f, 1.66753188e-01f, -1.94386512e-01f, -1.13005251e-01f, 1.01985876e-02f, 2.25845292e-01f,
  -1.44351423e-01f, 3.99648882e-02f, 9.73933339e-02f, -2.94251591e-01f, 1.33091211e-01f, -3.59017812e-02f, -9.25608817e-03f, 2.31384292e-01f, 1.03216775e-01f, 7.41143376e-02f,
  3.40750255e-02f, 8.87582675e-02f, -1.09950632e-01f, -1.68092147e-01f, 1.31768987e-01f, 2.23749459e-01f, -2.97819506e-02f, -7.92303681e-02f, -2.11826771e-01f, -1.13295846e-01f,
  1.64950266e-01f, -1.74306691e-01f, 1.91742212e-01f, 4.27938774e-02f, 3.56116891e-02f, -5.01266085e-02f, 3.27575266e-01f, 5.68616726e-02f, 7.17008337e-02f, 2.12671906e-02f,
  -1.42591357e-01f, -1.26236767e-01f, 9.43320617e-02f, 1.40593812e-01f, -6.74170628e-03f, 7.23204939e-05f, -8.94606858e-03f, -3.09235770e-02f, 1.11800231e-01f, 1.19651638e-01f,
  1.63512528e-01f, 2.11397126e-01f, -3.25360037e-02f, 9.11462605e-02f, 5.31352460e-02f, 1.26898617e-01f, 1.55821647e-02f, 5.90997152e-02f, 2.51247466e-01f, 1.09940618e-01f,
  1.27320752e-01f, 1.19959325e-01f, 1.55980065e-01f, 5.21658957e-02f, 1.51216239e-01f, 1.47637576e-01f, -1.14770815e-01f, 8.13824385e-02f, -8.09943974e-02f, -8.90117362e-02f,
  -5.82541674e-02f, 2.35342845e-01f, -1.47203812e-02f, 4.52977456e-02f, 2.01288342e-01f, 6.29562959e-02f, -6.71833828e-02f, 1.66991293e-01f, -1.27557009e-01f, 5.99978678e-02f,
  1.82774276e-01f, -1.28084749e-01f, -7.00118095e-02f, 7.97495060e-03f, 1.72724992e-01f, 4.35797609e-02f, 1.30063042e-01f, 2.61167258e-01f, 1.21304020e-01f, 9.87851992e-02f,
  -1.81854963e-01f, -1.11884624e-02f, -9.31238532e-02f, -1.99210241e-01f, -9.40377042e-02f, 2.41170134e-02f, -4.01406810e-02f, 2.23779619e-01f, -4.85442765e-02f, 2.04332750e-02f,
  -3.31233591e-02f, 9.07361954e-02f, 2.73530900e-01f, 2.14058310e-01f, 2.14500025e-01f, -6.73334599e-02f, -2.93952674e-02f, -4.00417261e-02f, -1.70384526e-01f, 1.72669262e-01f,
  3.78628448e-02f, 1.81862697e-01f, -1.90563679e-01f, 8.77407342e-02f, -3.50700803e-02f, 1.17493970e-02f, -5.29704429e-02f, -2.05043256e-02f, -4.51943129e-02f, 3.36043648e-02f,
  2.78558414e-02f, 9.47931707e-02f, 1.46091595e-01f, 1.30284399e-01f, 4.02681082e-02f, 2.35189162e-02f, 1.07436655e-02f, 5.63412979e-02f, 1.28980130e-01f, 1.26861125e-01f,
  -9.21330601e-02f, -5.91095090e-02f, 1.12549148e-01f, 2.58033369e-02f, -7.47312326e-04f, 1.24323703e-01f, 1.22076739e-02f, -1.36627955e-02f, 6.52297810e-02f, -1.14994116e-01f,
  -1.08099267e-01f, 3.57732996e-02f, 3.07289921e-02f, -1.02181798e-02f, 1.81174323e-01f, 2.86745951e-02f, 9.64876488e-02f, 1.67439848e-01f, 5.81562705e-02f, 1.79035038e-01f,
  -7.17213303e-02f, 1.26529679e-01f, 2.19443753e-01f, -6.73935935e-02f, -3.17217261e-02f, 4.54626791e-02f, 3.04952054e-03f, 1.47952670e-02f, -1.36518292e-02f, -1.26116768e-01f,
  -6.09160401e-02f, 9.79813710e-02f, 9.24440250e-02f, 1.85663640e-01f, -1.97401773e-02f, 6.55598417e-02f, 1.80319473e-01f, 1.09947704e-01f, 4.74640401e-03f, 4.73115295e-02f,
  -8.34432244e-03f, -3.22510824e-02f, 8.52341205e-02f, 2.21033990e-01f, 1.56832322e-01f, 1.27607644e-01f, -2.74829157e-02f, 5.79378121e-02f, 2.53526598e-01f, -4.63280119e-02f,
  1.60947605e-03f, 1.65280789e-01f, -1.61670335e-02f, 7.05297012e-03f, 1.81275249e-01f, 8.44833627e-02f, -3.92180011e-02f, -1.70444623e-02f, -9.42495465e-02f, 5.79849184e-02f,
  -6.49728701e-02f, -1.05465157e-03f, -6.71500117e-02f, 1.09524447e-02f, -6.44007996e-02f, -1.19966222e-02f, 1.14854209e-01f, 1.50212064e-01f, -1.78124189e-01f, -1.21795766e-01f,
  7.52440169e-02f, 2.31380910e-01f, -1.33035645e-01f, 8.30800384e-02f, 2.07318619e-01f, -2.82950521e-01f, 9.11095813e-02f, -1.54205249e-03f, -1.03944823e-01f, 1.71510413e-01f,
  6.13059737e-02f, 6.17186651e-02f, 4.77320217e-02f, 1.59371942e-02f, -3.85640301e-02f, -1.81833595e-01f, 6.86646402e-02f, 1.71599954e-01f, 5.33719780e-03f, -8.87181684e-02f,
  -1.29513159e-01f, -3.35544012e-02f, 1.72955602e-01f, -8.64005312e-02f, 2.09218919e-01f, 1.95853561e-02f, -6.59662392e-03f, -1.06742568e-01f, 2.99501240e-01f, 7.50646293e-02f,
  4.26172540e-02f, 4.50322181e-02f, -1.20577171e-01f, -1.14870965e-01f, 1.12671793e-01f, 1.42775893e-01f, 9.29154083e-03f, -6.48260936e-02f, -3.19093354e-02f, -2.70802844e-02f,
  1.14726640e-01f, 1.00617163e-01f, 9.52314511e-02f, 2.13368386e-01f, -2.60590333e-02f, 2.23065522e-02f, -5.62082827e-02f, 5.83556248e-03f, -5.22058792e-02f, -9.46503133e-02f,
  -1.78842694e-02f, -7.82954767e-02f, -4.78335135e-02f, -1.25160694e-01f, -4.91945185e-02f, -7.83539265e-02f, 3.48571725e-02f, 1.30022904e-02f, -1.67997465e-01f, -1.16435541e-02f,
  6.94748899e-03f, -7.17854947e-02f, -1.19505383e-01f, 8.50578323e-02f, 1.49199784e-01f, 1.70718078e-02f, -5.49228117e-02f, -1.65014297e-01f, -5.05271591e-02f, 9.95071903e-02f,
  1.05697840e-01f, -6.17779493e-02f, 1.52127715e-02f, -9.12305042e-02f, 1.55312428e-02f, 9.31077227e-02f, 1.59060404e-01f, 2.03086600e-01f, 8.95893201e-02f, -3.50730158e-02f,
  6.62179217e-02f, -8.31628665e-02f, 5.88942580e-02f, -2.62549445e-02f, -6.07519448e-02f, 1.33502305e-01f, 7.22336173e-02f, 5.67293435e-04f, -3.90961803e-02f, 8.26218128e-02f,
  8.96299183e-02f, 6.76231384e-02f, -1.02232106e-01f, 1.62277311e-01f, -6.24666661e-02f, 1.18233874e-01f, -1.41268507e-01f, 6.80021718e-02f, -3.44081074e-02f, -1.57297373e-01f,
  9.17762071e-02f, -2.09642984e-02f, 1.89501002e-01f, 1.58710495e-01f, 1.26499861e-01f, -1.92113314e-02f, 1.12604916e-01f, -1.25560910e-01f, -2.81018540e-02f, 1.89693153e-01f,
  -4.44567613e-02f, -2.14494895e-02f, -1.76852196e-02f, 1.18572302e-02f, 6.20481297e-02f, 2.15760060e-02f, -1.48871420e-02f, 7.88672864e-02f, 3.62790376e-02f, 4.05980349e-02f,
  1.52695561e-02f, 1.05354242e-01f, -9.99783725e-02f, 1.62058100e-01f, -2.76948474e-02f, -9.75887403e-02f, -8.92962739e-02f, 4.43041548e-02f, 2.68547028e-01f, 4.48311754e-02f,
  7.89641365e-02f, 5.25897518e-02f, 1.68316185e-01f, 1.11570641e-01f, 7.54822642e-02f, 1.08578712e-01f, -1.59228295e-01f, -7.71330819e-02f, -1.39396727e-01f, -7.42141977e-02f,
  1.93286955e-01f, 4.80710156e-02f, 2.63733733e-02f, -1.20772570e-01f, -1.86832502e-01f, -3.45562177e-04f, 8.48356076e-03f, -1.08776301e-01f, -1.92971691e-03f, 1.14997841e-01f,
  1.13205388e-01f, 9.11058486e-02f, 1.06787637e-01f, 2.14870751e-01f, -9.62552279e-02f, -5.09346612e-02f, -1.43631957e-02f, 1.32662997e-01f, 2.84446273e-02f, 1.88119873e-01f,
  9.46744345e-03f, 8.60630199e-02f, 1.27505008e-02f, -4.16770624e-03f, 2.29011476e-02f, -4.36016805e-02f, 6.82036653e-02f, 9.96428430e-02f, 3.72500718e-02f, 1.07601516e-01f,
  -9.82738435e-02f, 6.86402060e-03f, -4.23147604e-02f, -5.08546717e-02f, 5.82462586e-02f, 5.82717322e-02f, -7.22834282e-03f, 2.43782420e-02f, 4.10055853e-02f, 6.86421245e-02f,
  1.99636202e-02f, -5.04139252e-02f, 3.23228054e-02f, 2.86547225e-02f, 5.78801446e-02f, 6.39125183e-02f, 3.63860279e-02f, -1.06102571e-01f, -1.20112044e-03f, 7.06675649e-03f,
  9.72586423e-02f, 2.46626940e-02f, -1.98319048e-01f, -1.00439653e-01f, 8.29711109e-02f, -4.47307788e-02f, -2.39893511e-01f, 1.74901132e-02f, -6.30793571e-02f, -1.27200810e-02f,
  1.70182049e-01f, 7.61389360e-02f, 1.82259828e-01f, 1.07474752e-01f, -5.50931282e-02f, 2.52029859e-02f, 6.95517436e-02f, 2.25814521e-01f, 2.35445589e-01f, -4.18342231e-03f,
  -8.05718452e-03f, 1.76605836e-01f, 3.97030078e-02f, -3.96703146e-02f, -6.64746016e-02f, 3.25533450e-02f, -8.49672779e-02f, -5.31604439e-02f, 1.54223546e-01f, 5.72920851e-02f,
  -3.43857845e-03f, -3.52670550e-02f, 1.05082251e-01f, -9.89009216e-02f, 1.54637381e-01f, 3.08655072e-02f, 6.38949051e-02f, 1.98977739e-02f, 1.65484119e-02f, 1.31611452e-01f,
  -8.02056938e-02f, 1.94797013e-02f, -4.33543185e-03f, 3.67727429e-02f, 1.20120585e-01f, -2.13935021e-02f, 2.31038406e-02f, 5.04192635e-02f, 8.61730874e-02f, -5.52380569e-02f,
  -5.15748896e-02f, -1.42163932e-01f, -2.14392245e-01f, -3.23681444e-01f, -8.18900317e-02f, -1.90008655e-01f, -7.64263328e-03f, -1.60159126e-01f, -2.26405978e-01f, -1.89788297e-01f,
  6.70567453e-02f, -1.57757103e-01f, -3.35625708e-02f, 4.66844738e-02f, -3.49438377e-02f, -2.19733000e-01f, -6.60462454e-02f, -5.52976616e-02f, -1.49766266e-01f, 2.47787107e-02f,
  5.25737889e-02f, -2.37721741e-01f, 1.26195297e-01f, -7.81598687e-02f, -5.88776991e-02f, 8.08588415e-02f, 1.32806122e-01f, 3.50525640e-02f, -9.17645469e-02f, -7.99787119e-02f,
  7.07692429e-02f, -1.07059836e-01f, 2.05363054e-02f, -1.34043628e-02f, 1.47637516e-01f, -1.14131812e-02f, 5.33281080e-02f, 1.49603516e-01f, 1.52837530e-01f, 2.37381607e-02f,
  1.16233043e-01f, -1.24827489e-01f, 5.37179597e-02f, -4.65937853e-02f, 7.48266727e-02f, 1.08690470e-01f, -2.85660446e-01f, -2.19417840e-01f, -5.70947155e-02f, -7.91473240e-02f,
  3.35910693e-02f, 8.81390646e-02f, 7.82325566e-02f, -1.80847779e-01f, -5.59476055e-02f, -1.57174617e-01f, 2.71658331e-01f, 7.18740970e-02f, 1.99720617e-02f, 4.63565774e-02f,
  -5.47384471e-03f, -1.93474162e-02f, 6.91759959e-02f, 2.50173826e-03f, -8.09239894e-02f, -1.01779215e-01f, 8.86343420e-02f, 9.31535959e-02f, 1.47187620e-01f, -2.75840815e-02f,
  -1.05986051e-01f, -7.01723099e-02f, 8.94175023e-02f, -4.06378657e-02f, -2.36952268e-02f, 7.39501044e-02f, -3.04655395e-02f, -1.91660356e-02f, 7.78975384e-03f, 9.74431261e-02f,
  1.30522782e-02f, -1.99624547e-03f, -4.35436033e-02f, -9.70479026e-02f, -3.85247469e-02f, 1.60621151e-01f, 4.84340377e-02f, 1.47209063e-01f, 5.98470829e-02f, -9.61191952e-02f,
  6.81037977e-02f, 1.02998957e-01f, 2.21337095e-01f, 1.90228611e-01f, 8.83184671e-02f, 2.64145378e-02f, -2.21114531e-02f, -1.89278051e-01f, 1.27253726e-01f, 4.70650122e-02f,
  9.61849317e-02f, 7.36274719e-02f, 4.70984913e-02f, 1.48018658e-01f, -1.68295428e-01f, 1.77044421e-01f, 7.40528153e-03f, 1.32259503e-01f, -8.03281963e-02f, 5.63638285e-02f,
  -2.15924345e-02f, 1.86121121e-01f, 3.45318802e-02f, 2.52664149e-01f, -1.92686692e-01f, -9.08001661e-02f, 1.24645017e-01f, 4.09289859e-02f, 2.45121375e-01f, 2.36178234e-01f,
  -3.66049958e-03f, -7.38607198e-02f, 3.34145688e-02f, -1.50578953e-02f, 2.35836264e-02f, 1.85454175e-01f, 1.20768595e-11f, 1.42377438e-11f, -7.56496393e-11f, -1.24035010e-11f,
  1.00183604e-10f, -1.04988344e-10f, -9.16498683e-11f, 9.59883908e-12f, 6.36066200e-11f, -2.11085524e-11f, -4.56870132e-11f, -1.07463457e-11f, 2.31549567e-12f, 2.52052251e-15f,
  3.17730783e-15f, 2.50671513e-16f, -1.86679391e-15f, 5.55490509e-14f, -4.84796089e-14f, 1.27637506e-12f, -1.70417811e-13f, -4.32043935e-15f, -1.03784338e-14f, 2.10811034e-14f,
  -3.50251273e-12f, -6.41721572e-12f, -1.17814406e-14f, -3.07741706e-13f, -2.44820847e-14f, -3.81998273e-14f, -1.14575479e-15f, 2.37325588e-14f, 8.17319845e-14f, -1.62134134e-15f,
  7.41275209e-15f, -1.22319758e-11f, -3.33354351e-11f, -1.89424434e-14f, 5.01444352e-14f, 8.30802864e-15f, -1.89405281e-13f, -2.60653281e-14f, -1.07187557e-10f, -1.10847850e-11f,
  -2.31175287e-11f, -4.93166129e-14f, -1.45388421e-12f, -3.23951560e-11f, 9.81208726e-14f, 2.27413388e-14f, -2.31437352e-12f, -1.30238173e-11f, 7.62966960e-15f, -1.86331246e-11f,
  -3.61015227e-13f, -3.01072817e-12f, -7.53359099e-14f, 1.07356744e-13f, 8.84458793e-14f, -1.08904093e-14f, 8.17400211e-14f, -3.66031511e-12f, -1.20864868e-14f, -4.59102056e-14f,
  3.35890502e-02f, -1.49915693e-02f, -4.65936922e-02f, -1.28488332e-01f, -1.99095104e-02f, -1.16146587e-01f, -5.07774577e-02f, -1.80169374e-01f, 1.67435274e-01f, -2.03096792e-02f,
  -6.74351603e-02f, -1.53998546e-02f, -6.36825413e-02f, -1.82827175e-01f, -9.12284479e-02f, -5.35183512e-02f, -7.98466280e-02f, -6.12290949e-02f, -1.09702669e-01f, -1.50202975e-01f,
  1.59447685e-01f, -2.54243370e-02f, -1.43781722e-01f, -7.99986720e-02f, -1.15416400e-01f, -1.65373862e-01f, 1.43827274e-01f, -2.21915506e-02f, 1.41154423e-01f, -4.19820100e-02f,
  -8.60495642e-02f, 4.04771417e-02f, 1.28712639e-01f, 1.70522571e-01f, 1.91014245e-01f, -1.05247132e-01f, 6.72500730e-02f, 8.49950835e-02f, 1.66004077e-02f, 1.29063442e-01f,
  9.38653871e-02f, -2.25092229e-02f, 8.31461977e-03f, 2.59126984e-02f, 5.42304628e-02f, -3.70655507e-02f, -1.21070072e-01f, 1.47066414e-01f, -6.41084928e-03f, -9.62735489e-02f,
  1.85843468e-01f, -7.49782100e-02f, 1.52967080e-01f, -1.81598752e-03f, -6.09790534e-02f, 1.07200868e-01f, -3.92822437e-02f, -2.27654427e-02f, 2.82198608e-01f, 8.36003274e-02f,
  5.99621050e-02f, -7.96600282e-02f, -6.46992251e-02f, -2.46027838e-02f, 3.03618051e-02f, -2.00446825e-02f, 5.83308004e-02f, -8.80749226e-02f, -9.74674225e-02f, 1.10548355e-01f,
  1.07422978e-01f, -1.84147619e-02f, -1.13370351e-01f, 2.80062109e-02f, -2.82155629e-02f, 5.56344166e-02f, 7.42672682e-02f, -2.15268303e-02f, 5.19443005e-02f, -3.97259668e-02f,
  5.74963912e-02f, -3.83347236e-02f, -1.20982900e-01f, -6.52421862e-02f, -1.40429467e-01f, -2.00517848e-01f, -1.70700356e-01f, 1.09136850e-01f, 2.40416124e-01f, -2.70711016e-02f,
  5.93270212e-02f, 5.76094650e-02f, 2.03935876e-01f, 2.11472586e-01f, 6.79893419e-02f, 1.27287388e-01f, -2.73923706e-02f, 8.78278390e-02f, 4.24418226e-02f, -6.42497987e-02f,
  1.31169394e-01f, 1.56299964e-01f, 9.84605551e-02f, 4.62574661e-02f, -1.20749362e-01f, 2.02886522e-01f, 1.61003806e-02f, -8.97743329e-02f, 2.09620669e-01f, 1.11659162e-01f,
  2.20922679e-02f, -4.06395681e-02f, -1.25497475e-01f, 8.07671621e-03f, -2.90029515e-02f, 5.40610887e-02f, -2.12847590e-01f, -4.88948151e-02f, 2.32909277e-01f, 6.81306869e-02f,
  1.73383236e-01f, 2.08417073e-01f, -7.46138906e-03f, -3.82316038e-02f, 2.26957321e-01f, -8.19904879e-02f, 6.64775744e-02f, 2.88534582e-01f, -5.54576442e-02f, -3.85709107e-02f,
  -7.61392191e-02f, -7.89359063e-02f, -2.23460086e-02f, -4.15095314e-02f, 2.26694867e-02f, -3.96622792e-02f, 4.28475030e-02f, 3.39243468e-03f, -1.60996225e-02f, -1.70353893e-02f,
  -5.59458174e-02f, -1.14256041e-02f, -6.83497917e-03f, -2.95063779e-02f, -3.60324904e-02f, 9.23852343e-03f, 3.75644565e-02f, -2.42347792e-02f, 6.66821450e-02f, 1.31458445e-02f,
  1.73654053e-02f, -1.71738223e-03f, -8.31784233e-02f, -6.93566352e-02f, -5.67278527e-02f, -7.72052333e-02f, -8.26776400e-02f, -7.74451494e-02f, 2.08933675e-03f, -7.72103528e-03f,
  -4.03059423e-02f, -3.52869295e-02f, -6.23340346e-02f, -8.59019160e-02f, -2.54056379e-02f, -6.80586472e-02f, -4.73303907e-02f, 4.50259261e-03f, -1.25133470e-02f, -4.98330295e-02f,
  -4.96749356e-02f, -3.03305709e-03f, -6.41982108e-02f, -2.87334137e-02f, -1.42353013e-01f, 5.02243778e-03f, -5.36587425e-02f, 5.06300991e-03f, -4.61017303e-02f, -4.68141660e-02f,
  -2.47117486e-02f, -6.96214214e-02f, -6.84827492e-02f, -6.21319339e-02f, 1.23781729e-02f, 5.82142326e-04f, 1.15537569e-02f, -2.33871322e-02f, -8.63879248e-02f, -7.44484812e-02f,
  -6.51031286e-02f, -7.25410730e-02f, -4.16276082e-02f, 4.82148752e-02f, -5.27024195e-02f, 9.21194814e-03f, 6.20447360e-02f, -1.55953810e-01f, 5.93665503e-02f, 1.01556644e-01f,
  4.30522710e-02f, 6.56170398e-03f, -1.05428003e-01f, 7.31253028e-02f, -1.35273308e-01f, 1.33183569e-01f, -1.88546553e-01f, -2.11434141e-01f, -1.83204174e-01f, -1.01113692e-01f,
  2.52532929e-01f, -4.75505292e-02f, 1.27020940e-01f, 1.65679306e-01f, 2.67137527e-01f, 2.17992868e-02f, 1.23236522e-01f, 1.16907306e-01f, -1.56219274e-01f, -3.80358398e-02f,
  -6.76676910e-03f, -1.03469707e-01f, 2.20265165e-01f, 1.32947573e-02f, 9.12889540e-02f, -1.04769111e-01f, -9.49812979e-02f, 3.13877612e-02f, 1.96751878e-02f, -1.78613663e-01f,
  8.92872289e-02f, 3.45856160e-01f, 2.80092478e-01f, 2.04575852e-01f, 2.57098019e-01f, 2.49039099e-01f, -5.89008741e-02f, -1.62570685e-01f, -7.20026866e-02f, 2.64102668e-01f,
  -7.43619353e-02f, 1.69723526e-01f, -5.13227610e-03f, 1.72337040e-01f, 7.88578242e-02f, 1.15205832e-01f, 4.85786013e-02f, -6.60312995e-02f, 3.25468043e-03f, 1.17455237e-01f,
  3.05447310e-01f, 1.81273535e-01f, -1.01651594e-01f, 5.08035980e-02f, -3.94898690e-02f, -4.18950133e-02f, 1.43033922e-01f, -2.46187858e-02f, 5.34155853e-02f, 1.07490383e-01f,
  -1.16017282e-01f, 3.30750234e-02f, -2.24258211e-02f, -2.21833866e-02f, -8.81473497e-02f, 1.04416236e-01f, -4.16513011e-02f, 3.09982710e-02f, 1.49686500e-01f, -3.16134803e-02f,
  3.63886058e-02f, 1.97339654e-02f, 4.89091501e-02f, -1.62780821e-01f, -3.51458155e-02f, -6.94152247e-03f, -1.35816142e-01f, 6.01119436e-02f, 1.27001166e-01f, -1.11179218e-01f,
  2.13379055e-01f, 2.15636685e-01f, 5.44143133e-02f, 2.45486408e-01f, 1.63977131e-01f, 5.15309647e-02f, 1.35110036e-01f, -2.58015078e-02f, 1.75625056e-01f, -1.08560726e-01f,
  1.05290949e-01f, 2.44007215e-01f, 1.36633366e-01f, 1.13821598e-02f, 1.04202613e-01f, -6.78494945e-02f, 7.96241090e-02f, 1.97762713e-01f, 2.13838160e-01f, -1.13877088e-01f,
  1.75368220e-01f, -7.60475621e-02f, 1.82190120e-01f, -4.67769243e-02f, -6.33021519e-02f, -5.54015636e-02f, -7.95868263e-02f, 1.40486509e-01f, -6.37708306e-02f, 1.50358856e-01f,
  9.00814608e-02f, 7.32599571e-02f, -5.67769408e-02f, -1.28662109e-01f, 5.42129241e-02f, 8.26501325e-02f, 7.30431750e-02f, 1.68961897e-01f, 6.33435100e-02f, 1.44535154e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -2.03081761e-02f, -1.03433989e-03f, 2.88656205e-02f, 9.11518186e-03f, -2.83067003e-02f, 4.60357927e-02f, 5.39614744e-02f, -4.74399728e-30f, -7.54150301e-02f, 4.15932238e-02f,
  3.37317809e-02f, 8.71969014e-02f, -2.28049010e-02f, 5.15744053e-02f, 2.06071306e-02f, 5.36365807e-02f, 5.19192666e-02f, 5.26432879e-02f, 6.49374276e-02f, 5.37004843e-02f,
  2.89349607e-03f, 1.05253123e-01f, -6.13198802e-02f, -3.86797749e-02f, 1.08891159e-01f, 3.82723026e-02f, 6.21874863e-03f, -2.27696672e-02f, 9.19587612e-02f, -2.26955730e-02f,
  -3.28681758e-03f, 2.42322925e-02f, 2.91690584e-02f, 3.88584249e-02f, -1.93018324e-10f, 2.36710981e-02f, 5.33170402e-02f, -6.22177310e-02f, 7.74879660e-03f, 1.45908237e-01f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -3.92973982e-02f, 2.70452612e-04f, 8.16818476e-02f, 1.29774734e-01f, -7.72889555e-02f, 1.57730952e-02f, 9.47490036e-02f, -3.02799582e-03f, -1.09131187e-01f, 5.06371399e-03f,
  2.00563911e-02f, -2.34679803e-02f, -1.64300963e-01f, 2.13041641e-02f, -1.50193036e-01f, 1.18223466e-02f, -2.29316384e-01f, -1.72683477e-01f, -1.44707054e-01f, -5.70954271e-02f,
  -7.26827681e-02f, 3.20697017e-02f, 1.37799010e-01f, -9.09650624e-02f, -7.43838772e-02f, 5.71738854e-02f, 1.79084484e-02f, -3.31144594e-02f, -6.11123629e-02f, 2.10326854e-02f,
  -1.16565980e-01f, 1.89795468e-30f, -1.52737126e-01f, 1.52142933e-02f, -6.18146881e-02f, -2.17932031e-01f, 6.21255152e-02f, 1.09820060e-01f, -8.23669434e-02f, 8.25309306e-02f,
  -3.32092084e-02f, 7.88421705e-02f, -8.84047076e-02f, 1.71944365e-01f, -9.06172395e-02f, -1.75937891e-01f, -3.20823528e-02f, 1.61721423e-01f, 1.46709830e-01f, -8.56854990e-02f,
  7.75265768e-02f, 1.13908142e-01f, -5.01351543e-02f, 7.50606731e-02f, -2.18473263e-02f, 5.11728339e-02f, -5.46002537e-02f, -1.64368935e-02f, 3.15735326e-14f, 6.26812354e-02f,
  -8.76223221e-02f, 8.24530646e-02f, -6.13041297e-02f, -1.47766843e-01f, 9.50903222e-02f, 7.83355683e-02f, -5.70416078e-02f, 3.82591449e-02f, -4.21505468e-03f, -3.21476683e-02f,
  -8.55768546e-02f, 3.48752588e-02f, 1.17502935e-01f, 1.93606377e-01f, 1.07288852e-01f, 1.09603174e-01f, -1.54713839e-01f, -1.97839230e-01f, 3.94948870e-02f, 9.29185897e-02f,
  2.71930657e-02f, -5.67186847e-02f, -1.98298469e-01f, -8.22294578e-02f, 1.34047223e-02f, 3.25076655e-02f, -2.07975581e-02f, 3.65908258e-02f, 9.68533158e-02f, 5.16627878e-02f,
  1.33329988e-01f, 2.76278313e-02f, 8.60574171e-02f, 9.27119032e-02f, 5.36410399e-02f, 9.06561744e-31f, 1.19207472e-01f, 3.97057347e-02f, 8.98869988e-03f, 8.76284298e-03f,
  -2.20772978e-02f, 1.89801142e-01f, 7.05838799e-02f, 1.99339747e-01f, -4.65325713e-02f, 1.40325844e-01f, -4.00590189e-02f, 1.40594199e-01f, -3.73023748e-02f, -8.12287629e-02f,
  1.05307877e-01f, -5.55950077e-03f, 1.26104191e-01f, 2.87778256e-03f, 1.44273311e-01f, 7.27502480e-02f, -1.75315309e-02f, 6.80111498e-02f, 6.77529499e-02f, 7.49489143e-02f,
  8.76614675e-02f, -5.00878226e-03f, -3.99033122e-14f, 1.77441031e-01f, 1.05013875e-02f, -2.17405017e-02f, 1.22842729e-01f, -1.39961392e-02f, 6.49458990e-02f, 5.81317097e-02f,
  6.92260265e-02f, 3.70154493e-02f, -1.39493942e-01f, -7.01653073e-03f, 4.25034203e-03f, -6.91248998e-02f, -1.30636588e-01f, 7.62747303e-02f, -4.63356189e-02f, 9.78565589e-02f,
  9.54712033e-02f, -2.02414207e-03f, -3.90643952e-03f, -8.29720870e-02f, -1.49236366e-01f, -9.70042124e-02f, 8.03105161e-02f, 8.46172869e-03f, 1.41192839e-01f, -8.02771151e-02f,
  7.13470206e-02f, 3.09814755e-02f, -8.48916098e-02f, 1.19248684e-02f, -3.14182416e-03f, 5.70580848e-02f, -4.37182859e-02f, -4.00650539e-02f, -9.90221351e-02f, -2.65612423e-31f,
  -1.37304127e-01f, 1.06657706e-01f, -1.13758989e-01f, 3.03523820e-02f, 1.79767776e-02f, 3.19936574e-02f, 1.76061131e-03f, 5.85120246e-02f, 1.86135748e-03f, 9.87803042e-02f,
  6.14244081e-02f, 1.86201297e-02f, 3.08422185e-02f, 3.27692158e-03f, -1.50314420e-01f, 9.58243683e-02f, -1.53555525e-02f, 9.51927453e-02f, 1.88582223e-02f, 1.61786944e-01f,
  1.03485592e-01f, 8.30018818e-02f, -5.12971766e-02f, 4.06353287e-02f, 3.99660356e-02f, -2.51440089e-02f, 1.14119351e-14f, 4.72263340e-03f, -6.70312950e-03f, 6.00168132e-04f,
  -1.26805127e-01f, -1.06739946e-01f, -2.59304717e-02f, -8.26508403e-02f, 1.17942598e-02f, 5.32806888e-02f, 6.33276552e-02f, 5.61568029e-02f, 1.86809171e-02f, 8.10906515e-02f,
  1.62424803e-01f, -8.59749392e-02f, 4.24130298e-02f, 2.50495765e-02f, 1.07694291e-01f, -1.40656367e-01f, 8.99718106e-02f, -7.69343367e-03f, 4.54517901e-02f, 3.87954200e-03f,
  5.68002462e-02f, 7.66286105e-02f, -8.87822956e-02f, 4.85378783e-03f, -1.11629970e-01f, 1.36875600e-01f, 2.08515629e-01f, 5.58238290e-02f, 6.15805574e-03f, -3.87984812e-02f,
  9.37860906e-02f, 6.50058240e-02f, 2.14152843e-01f, 8.12095821e-31f, -4.55956347e-02f, 3.74648795e-02f, 2.45093673e-01f, 4.75864038e-02f, -4.45053689e-02f, 1.30421817e-01f,
  3.33453938e-02f, 1.40532991e-02f, 5.02216853e-02f, 1.58571839e-01f, 1.37452751e-01f, 4.08814475e-02f, -4.08162214e-02f, 1.26688689e-01f, 7.19106197e-02f, 8.90392065e-02f,
  2.49007806e-01f, 1.17318176e-01f, 2.24619791e-01f, 6.29867241e-02f, 1.71854541e-01f, 4.85120192e-02f, 1.60353035e-01f, 5.84889650e-02f, 9.52569023e-02f, -1.90907698e-02f,
  5.87449706e-15f, 6.35273606e-02f, -8.13787058e-03f, -4.88277385e-03f, 2.51121998e-01f, 6.81742877e-02f, 1.31204411e-01f, -3.99870612e-02f, 6.79787323e-02f, 8.59658793e-02f,
  -1.79947615e-02f, -5.54454029e-02f, -1.40486713e-02f, -1.81424525e-02f, 3.25198323e-02f, 1.37020469e-01f, -1.04892319e-02f, 4.17674184e-02f, -3.40009667e-02f, -1.39002129e-02f,
  -1.87401876e-01f, -6.63226517e-03f, -3.84096839e-02f, -9.08460543e-02f, -6.72186092e-02f, -1.49178520e-01f, -1.67622760e-01f, -4.99756001e-02f, 7.93811977e-02f, 1.44210696e-01f,
  4.78746332e-02f, 6.06231093e-02f, -8.22476372e-02f, 5.29899960e-03f, -2.88683418e-02f, 3.24657001e-02f, 8.45821574e-02f, -1.04116944e-31f, -3.59228142e-02f, -8.05549324e-02f,
  1.75223112e-01f, -7.20495433e-02f, 1.35383427e-01f, 2.19776019e-01f, 2.62032282e-02f, -2.63477731e-02f, -8.94456357e-02f, 6.40749261e-02f, -5.92986867e-03f, 3.39145027e-02f,
  -1.60154086e-02f, -5.64443916e-02f, 1.83647163e-02f, 1.30324990e-01f, 2.10192084e-01f, 1.00603148e-01f, 2.08107568e-02f, 1.05155237e-01f, 9.21625048e-02f, 1.99011236e-01f,
  1.58255950e-01f, -6.87432215e-02f, 6.30144998e-02f, -2.18521282e-02f, 2.85074766e-14f, 1.14682280e-01f, -3.07205897e-02f, 1.34525290e-02f, 2.72557646e-01f, 8.03556368e-02f,
  -1.15530705e-02f, -1.77513018e-01f, 8.86824280e-02f, -9.94605850e-03f, -1.10116918e-02f, 1.04947789e-02f, -8.04412961e-02f, 1.09835379e-01f, 1.12489104e-01f, -7.63438717e-02f,
  -2.10619569e-02f, 5.98268118e-03f, -7.63560608e-02f, 5.97224478e-03f, -1.09401375e-01f, 1.68004528e-01f, -5.13240173e-02f, 3.76782170e-03f, -1.73619509e-01f, -1.00269996e-01f,
  -1.31296515e-01f, -3.08528375e-02f, -5.94013780e-02f, 2.71764010e-01f, 6.23003170e-02f, -7.59744644e-03f, 6.85447827e-03f, 1.01363778e-01f, 2.95900386e-02f, 1.31134257e-01f,
  9.02910754e-02f, 1.27154653e-30f, -2.87385043e-02f, 6.45230561e-02f, 1.68355584e-01f, -9.93440598e-02f, 9.89037603e-02f, 1.05711520e-01f, 3.66847194e-03f, -8.57367441e-02f,
  -8.63699391e-02f, 8.43732581e-02f, 5.70385344e-02f, 1.73984207e-02f, 2.30524261e-02f, -5.82507290e-02f, 6.87767565e-02f, -4.48274761e-02f, 1.87017485e-01f, 7.81530142e-02f,
  7.67977387e-02f, 8.16775188e-02f, 1.53272480e-01f, 1.22816898e-01f, 1.70739248e-01f, 1.46215698e-02f, 7.41219297e-02f, 5.43986671e-02f, 1.15988194e-14f, 8.75196084e-02f,
  8.59461576e-02f, 6.95911273e-02f, 2.48038858e-01f, 4.16869391e-03f, 8.35314691e-02f, -6.36640489e-02f, -6.89384108e-03f, 1.92318767e-01f, -1.13161874e-03f, 6.96414784e-02f,
  2.27487192e-01f, 1.56499520e-02f, 4.61469889e-02f, -9.64945331e-02f, 6.36283532e-02f, 7.00152889e-02f, 8.43519792e-02f, -1.69253483e-01f, -1.00634441e-01f, -7.80596584e-02f,
  -9.19561088e-02f, 1.01853885e-01f, 8.53141621e-02f, -8.01672228e-03f, -1.64977923e-01f, -1.70494556e-01f, -1.64937302e-02f, 1.24237519e-02f, 6.77392446e-03f, -5.81765585e-02f,
  -6.30360097e-02f, 3.29701267e-02f, -7.24354684e-02f, -1.03264619e-02f, 9.18211490e-02f, -2.30969406e-31f, -3.27508785e-02f, 1.86843313e-02f, 1.90050885e-01f, -1.35124968e-02f,
  -2.43496820e-02f, -1.71467829e-02f, 8.13599378e-02f, -1.00306720e-01f, -3.34786475e-02f, -1.05130658e-01f, 5.61922556e-03f, 8.66314396e-02f, -1.96403414e-02f, -1.12364693e-02f,
  -3.58424783e-02f, 5.28353713e-02f, 1.59461007e-01f, -3.45667452e-02f, 1.81625426e-01f, 1.04004703e-01f, -3.79122719e-02f, 1.64715517e-02f, 5.77433035e-02f, -7.66373128e-02f,
  -1.46656588e-01f, 1.12253889e-01f, -2.25105291e-14f, -3.68211530e-02f, -4.19136360e-02f, 4.09004018e-02f, -3.88624445e-02f, -5.60057163e-02f, -1.48405194e-01f, 3.18498164e-02f,
  -6.83757961e-02f, -8.32935348e-02f, -3.91573831e-02f, -1.39388191e-02f, -8.37695152e-02f, -1.15934007e-01f, -1.42738879e-01f, -4.66334634e-02f, -1.93409398e-01f, -6.74104095e-02f,
  -7.23295212e-02f, 1.84863299e-01f, -1.11238156e-02f, 4.74881828e-02f, -3.74587663e-02f, -3.33957523e-02f, 9.09827743e-03f, 1.14331611e-01f, -1.34791331e-02f, 1.16785370e-01f,
  4.60659266e-02f, -8.97923484e-02f, -8.75266269e-02f, -1.68953642e-01f, 5.09095751e-02f, 3.53084505e-02f, 4.04989533e-03f, -1.96105260e-02f, -5.88470548e-02f, 2.14254064e-31f,
  -7.25354776e-02f, 2.57465541e-02f, -2.02623844e-01f, -9.96446535e-02f, 5.80830760e-02f, -1.84787750e-01f, -1.59063637e-02f, 6.33176938e-02f, -1.09195113e-01f, -1.61381081e-01f,
  -7.51556084e-02f, -7.92601854e-02f, -5.24493232e-02f, -1.83473691e-01f, -1.05737135e-01f, 5.39095998e-02f, -2.74300463e-02f, -1.42049640e-01f, 8.07247534e-02f, -9.79461148e-02f,
  -1.25545442e-01f, -1.82023160e-02f, -1.13041878e-01f, -1.38246402e-01f, -1.35882914e-01f, -1.10266939e-01f, 4.65857110e-15f, -4.10063341e-02f, -1.62294656e-01f, 4.96982671e-02f,
  -2.97265530e-01f, -2.29011014e-01f, 9.92334262e-02f, 4.88264337e-02f, 4.00005542e-02f, 7.38644674e-02f, -3.13213468e-02f, 1.03132263e-01f, 8.61680433e-02f, 8.49778280e-02f,
  1.27317116e-01f, 3.15741003e-02f, 6.71918457e-03f, 1.14634804e-01f, -1.65389404e-01f, 1.98341250e-01f, -1.99668407e-02f, 1.00875966e-01f, -4.01889123e-02f, -8.82344618e-02f,
  -8.03166330e-02f, 7.88848177e-02f, -1.19382001e-01f, -1.49891227e-01f, 1.05593883e-01f, -1.39507607e-01f, -5.07968962e-02f, 1.95748836e-01f, 1.52050927e-01f, -5.47178425e-02f,
  2.07776561e-01f, 6.84327930e-02f, -7.91549683e-02f, 1.79101329e-30f, 3.11698020e-02f, 1.45630583e-01f, 6.94062188e-02f, -7.77242854e-02f, 5.84840961e-02f, 1.13180690e-01f,
  -2.82909311e-02f, 2.08661005e-01f, -4.62117568e-02f, 1.42023072e-01f, 5.08136936e-02f, 2.48945057e-01f, -1.51282735e-02f, 5.73948361e-02f, 6.57720640e-02f, 1.83794618e-01f,
  8.55960324e-02f, -2.47890987e-02f, 6.93810582e-02f, 1.78478107e-01f, -3.32451984e-02f, 1.55031502e-01f, 4.28527594e-02f, 9.93591100e-02f, -6.91799074e-02f, 1.93271965e-01f,
  -3.79061610e-14f, 2.22111359e-01f, -7.62992352e-02f, 5.19870445e-02f, -4.91273068e-02f, -9.19334665e-02f, -1.56199887e-01f, -8.93609822e-02f, 1.27966896e-01f, -4.94895177e-03f,
  5.50751202e-02f, 1.93904396e-02f, 1.08513191e-01f, -1.01189546e-01f, -1.38654914e-02f, -3.48472558e-02f, -1.36486560e-01f, -9.43256542e-02f, -1.10316100e-02f, -7.25039765e-02f,
  -1.44178018e-01f, 2.05032341e-02f, -2.05483790e-02f, -2.62431838e-02f, -1.14378333e-01f, -7.95142651e-02f, 2.92443000e-02f, 2.17726827e-02f, 1.13233635e-02f, 2.07211673e-01f,
  1.23410121e-01f, -2.97386460e-02f, -7.87708014e-02f, 5.96223101e-02f, -1.93405747e-02f, -1.04919121e-01f, 6.43357635e-03f, 1.42502660e-30f, -1.57812878e-01f, 2.77141593e-02f,
  9.62719917e-02f, -1.14621200e-01f, 1.08365305e-01f, 1.40665978e-01f, 1.74186882e-02f, 6.28211536e-04f, -2.19269376e-02f, 7.93729424e-02f, -6.04817010e-02f, 4.23811823e-02f,
  -3.71396765e-02f, -8.61816183e-02f, 4.49263789e-02f, 2.01372840e-02f, -2.74403077e-02f, 6.42285794e-02f, -4.30429429e-02f, 6.02994673e-02f, 1.32350445e-01f, 4.30437438e-02f,
  3.57737727e-02f, -8.59197751e-02f, 5.50870113e-02f, 2.90156454e-02f, -4.80964048e-16f, 3.17272507e-02f, -2.23160023e-03f, 2.07215697e-02f, 5.10901436e-02f, -8.25127736e-02f,
  -1.44097045e-01f, -1.37160957e-01f, 4.24438007e-02f, -5.45579419e-02f, -1.35024026e-01f, -8.80718157e-02f, -1.31935880e-01f, -1.68523211e-02f, -7.88662434e-02f, 1.25834301e-01f,
  -1.21129006e-01f, -9.90658253e-02f, -1.22447021e-01f, 1.84126705e-01f, -1.55167595e-01f, 6.05109520e-02f, -6.68481141e-02f, -2.27674201e-01f, -1.02181830e-01f, -1.02753364e-01f,
  1.16074637e-01f, 2.05475673e-01f, 1.75272509e-01f, -4.21275347e-02f, 7.49940053e-02f, -3.42849903e-02f, 3.96826118e-02f, -1.30998704e-03f, -8.49892572e-02f, -8.74745920e-02f,
  3.53690833e-02f, -1.87993473e-31f, -1.26668632e-01f, -2.29571536e-02f, -1.97737396e-01f, -9.55419540e-02f, 2.01909076e-02f, -5.16533898e-03f, -9.93005782e-02f, 8.31857100e-02f,
  -1.77477941e-01f, 9.32712257e-02f, 4.37134020e-02f, -3.60660367e-02f, -7.05188885e-03f, -1.53638586e-01f, 6.64043128e-02f, 8.46975818e-02f, -4.88128960e-02f, -1.55080052e-03f,
  -8.46153721e-02f, -1.66582279e-02f, -1.85680911e-02f, 1.37171848e-02f, -5.20041659e-02f, -4.37626913e-02f, 1.58205733e-01f, 1.56281050e-02f, 4.64375141e-14f, 5.50223365e-02f,
  -3.88069381e-03f, 3.53587396e-03f, -7.97767714e-02f, -4.44896221e-02f, 2.16550753e-02f, -6.74966052e-02f, -6.60256147e-02f, 2.47254949e-02f, 3.44221704e-02f, -1.06060341e-01f,
  -5.85139915e-02f, -4.46690358e-02f, 1.91615388e-01f, 6.90997317e-02f, 2.97073624e-03f, 3.88880372e-02f, 1.40363723e-01f, 1.15122356e-01f, -1.48948669e-01f, 1.24058425e-01f,
  1.82159021e-01f, -2.95406263e-02f, -1.42246555e-03f, 1.19887486e-01f, -1.11715738e-02f, -3.91955429e-04f, 4.65983488e-02f, 8.26445520e-02f, 2.90648919e-02f, 1.06428586e-01f,
  4.02069204e-02f, 1.37265667e-01f, 1.77106690e-02f, 1.82195511e-02f, -2.06954614e-03f, 7.10520742e-32f, -9.40930564e-04f, 1.15731671e-01f, 3.67509760e-02f, -1.32566439e-02f,
  3.80320363e-02f, 2.85490490e-02f, 2.80012414e-02f, -4.44453806e-02f, -2.12549996e-02f, 1.41370624e-01f, 8.83446485e-02f, -7.21664205e-02f, 8.17226917e-02f, 8.95964131e-02f,
  5.71974590e-02f, 1.10976703e-01f, 1.37083173e-01f, 8.43410790e-02f, -5.84471039e-02f, 1.02969654e-01f, 1.36293039e-01f, 1.67161003e-01f, 6.39773458e-02f, 3.11094336e-02f,
  1.18705817e-01f, 1.07091621e-01f, 1.67511540e-14f, 1.01788849e-01f, -1.86597789e-03f, 8.72888863e-02f, 1.52207017e-01f, 1.79287985e-01f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.52947004e-02f, 5.13051227e-02f, -4.27037776e-02f, 3.54439914e-02f, -7.41702095e-02f, -1.42877191e-01f, 1.86156004e-03f, 4.10672948e-02f, -1.44566491e-01f, -8.47877115e-02f,
  -1.13739952e-01f, 7.97167420e-02f, -6.40401766e-02f, -1.76019524e-03f, -6.07667156e-02f, -1.15341872e-01f, -1.55889720e-01f, -9.73566342e-03f, 2.84703132e-02f, -1.83102358e-02f,
  -8.40251446e-02f, 5.86282276e-02f, 2.80807596e-02f, -1.20454393e-01f, -1.95216045e-01f, -5.25213964e-02f, 1.86780885e-01f, 8.52336511e-02f, 3.73946801e-02f, 1.18977092e-01f,
  -1.94082204e-02f, -5.84149834e-31f, 1.51332781e-01f, 1.29923671e-01f, 3.10401041e-02f, -9.69256088e-02f, 1.91662416e-01f, -1.30645670e-02f, 1.10293791e-01f, 1.84259191e-01f,
  -4.78110835e-02f, -1.00080788e-01f, -4.93022650e-02f, 1.57522574e-01f, 4.01728414e-02f, -1.12161435e-01f, -2.68595386e-02f, 1.32814065e-01f, 1.61827564e-01f, -2.80346364e-01f,
  1.51301071e-01f, 1.38918698e-01f, -2.81727105e-01f, 8.35639313e-02f, 2.71841064e-02f, 6.80882558e-02f, -2.27520853e-01f, 1.99170500e-01f, 2.46082099e-13f, 1.79810338e-02f,
  9.24651325e-02f, 7.98094571e-02f, 2.88094431e-02f, -1.16490111e-01f, 9.68247354e-02f, -7.41447583e-02f, -8.95139277e-02f, 2.02863105e-02f, -6.72581047e-02f, -3.10729519e-02f,
  3.92910512e-03f, -4.20497581e-02f, -1.28352538e-01f, 1.10542187e-02f, 4.81632091e-02f, 3.42361368e-02f, 9.56561491e-02f, -2.00681999e-01f, -1.82465371e-02f, -3.07032857e-02f,
  -8.58670026e-02f, -3.66026424e-02f, -5.67640848e-02f, -1.55279189e-01f, -5.67542054e-02f, -9.83437300e-02f, 1.64610207e-01f, 1.99107096e-01f, 1.54041812e-01f, -4.31349315e-03f,
  -6.48275614e-02f, -3.11401393e-02f, -1.70006067e-01f, 5.13314120e-02f, 1.54497623e-01f, -5.34352235e-30f, 8.30823705e-02f, -5.54598235e-02f, 1.28989041e-01f, 8.38896558e-02f,
  3.13385502e-02f, 1.23893745e-01f, 1.09717242e-01f, -3.85103375e-02f, 2.37242170e-02f, 8.22464079e-02f, 9.62047651e-02f, 1.01005867e-01f, -3.17212269e-02f, 9.19574425e-02f,
  1.52647480e-01f, -2.43534129e-02f, 1.16978064e-01f, 9.51767191e-02f, 6.35742098e-02f, 3.84201040e-03f, 1.25536084e-01f, 1.30786508e-01f, 1.40124992e-01f, -2.48023719e-01f,
  2.45394960e-01f, 1.10157140e-01f, 3.61051622e-14f, 5.60796522e-02f, 3.88511224e-03f, 5.03611254e-40f, 1.50174603e-01f, 1.08833350e-01f, 1.22244917e-01f, -6.07886761e-02f,
  1.06732890e-01f, 5.80014028e-02f, 2.90216319e-02f, 1.18133344e-01f, 1.41087174e-01f, 1.03934705e-01f, 8.79104882e-02f, -6.40564947e-04f, 3.53441127e-02f, -9.68582649e-03f,
  -7.98097327e-02f, -7.94752985e-02f, 8.74340758e-02f, 1.16571099e-01f, 1.27455473e-01f, 8.26238990e-02f, -4.66574170e-02f, 7.12721795e-02f, -6.35242239e-02f, -2.09314764e-01f,
  -1.54476300e-01f, -2.58307019e-03f, 2.11031899e-01f, 1.54524565e-01f, -2.95998361e-02f, -1.48791820e-01f, 7.44159669e-02f, 5.08074984e-02f, 1.92186952e-01f, -3.61820006e-31f,
  -1.45443574e-01f, 4.04014960e-02f, 1.55862570e-01f, 4.76974212e-02f, -1.35832459e-01f, 1.85214162e-01f, 2.24763178e-03f, -3.60925607e-02f, 6.58708662e-02f, 1.54281706e-01f,
  3.12917948e-01f, 8.71542245e-02f, -1.63863927e-01f, 2.00011618e-02f, 6.35877773e-02f, 6.76466525e-02f, 2.05902249e-01f, 1.61407337e-01f, 4.22550701e-02f, -3.21395434e-02f,
  1.31236956e-01f, -4.96291779e-02f, 5.62465191e-02f, 8.09579939e-02f, 8.50136429e-02f, -1.35531396e-01f, -3.52627507e-14f, 1.25414640e-01f, -7.42368028e-02f, -1.53932814e-03f,
  6.90150261e-02f, 2.99820267e-02f, 7.65512791e-03f, -6.35387823e-02f, -5.99497044e-03f, 5.24601042e-02f, 6.17681332e-02f, -8.69750604e-02f, 1.39143750e-01f, 1.01121068e-01f,
  -1.25203311e-01f, -1.15612723e-01f, -9.53750312e-02f, -4.36465815e-02f, 6.44870326e-02f, -3.89763080e-02f, -3.36785875e-02f, -8.48087296e-02f, -1.11298181e-01f, -4.58193608e-02f,
  -8.32014624e-03f, 7.88068175e-02f, -1.96730480e-01f, -6.63184598e-02f, -7.31733292e-02f, 6.89336285e-02f, -2.65429877e-02f, -7.37924501e-02f, 5.61363846e-02f, 2.34203343e-03f,
  5.17827049e-02f, 1.43789083e-01f, 1.33894905e-01f, -3.76578620e-31f, 1.62230581e-01f, 3.75682637e-02f, 2.07979605e-01f, 1.05273768e-01f, 2.30263546e-02f, -3.09827849e-02f,
  1.83446392e-01f, 7.48789310e-02f, 9.31737125e-02f, -1.84478894e-01f, -4.01014555e-03f, 9.32540447e-02f, -2.51901671e-02f, 1.68441489e-01f, 5.66832572e-02f, -2.28759758e-02f,
  1.59064084e-01f, -2.09629372e-01f, 1.47577509e-01f, -7.93184992e-03f, -1.14453718e-01f, 6.22687675e-02f, 1.60893679e-01f, -9.23961960e-03f, -1.32863760e-01f, 1.00887023e-01f,
  1.54606993e-14f, -9.56082195e-02f, 4.05583717e-02f, 2.04819944e-02f, 1.72006115e-01f, -3.01037394e-02f, 9.44829136e-02f, 1.45888617e-02f, 1.12445615e-02f, 1.67648971e-01f,
  7.58599341e-02f, 3.62701267e-02f, 2.35483214e-01f, 7.68232867e-02f, 1.86934453e-02f, 6.55092765e-03f, -7.79599398e-02f, -9.38975811e-03f, 3.48883972e-04f, -1.07306480e-01f,
  6.65288568e-02f, 4.66310047e-02f, 7.08257481e-02f, 2.57477257e-02f, 4.93049212e-02f, 1.88087851e-01f, 5.87928072e-02f, -1.14965029e-01f, -1.93938464e-01f, -8.13097600e-03f,
  3.39910276e-02f, 2.80592710e-01f, 7.67814070e-02f, -1.16990097e-01f, 1.75104424e-01f, 9.51202586e-02f, 1.04690883e-02f, 1.07238774e-31f, -2.36131266e-01f, 6.16895407e-02f,
  2.63506752e-02f, -5.71074821e-02f, -1.28611758e-01f, 1.29547507e-01f, -8.30088779e-02f, 1.79884471e-02f, 2.04153329e-01f, 1.83952376e-01f, 2.59654045e-01f, 4.03266177e-02f,
  -1.68936446e-01f, 1.20610617e-01f, -7.44827166e-02f, 1.34203807e-01f, 6.64405450e-02f, 1.68410107e-01f, 2.63877451e-01f, -1.00506032e-02f, 1.03617005e-01f, -7.78865069e-02f,
  1.96168926e-02f, 1.17201589e-01f, -1.16064712e-01f, -1.27301916e-01f, -3.95116475e-15f, 3.08448002e-02f, -3.01263481e-02f, -2.45644655e-02f, -7.29086697e-02f, 1.10893724e-02f,
  -4.47305515e-02f, -6.27247095e-02f, 3.21493819e-02f, -1.08610755e-02f, 6.15071654e-02f, 5.22925006e-03f, -1.34589558e-03f, 9.59088281e-03f, 1.16223916e-01f, -2.59665269e-02f,
  2.39839628e-02f, -2.93282289e-02f, 1.36553049e-01f, 4.94444296e-02f, 3.13307927e-03f, 5.14259264e-02f, 7.32844099e-02f, -3.20558697e-02f, -1.04622822e-02f, 1.00659719e-02f,
  -3.28492485e-02f, -2.38350090e-02f, 2.03982405e-02f, 1.31106615e-01f, 1.26501486e-01f, -2.90165022e-02f, -1.65372804e-01f, 4.41804640e-02f, -9.76708084e-02f, -6.06644563e-02f,
  9.12886038e-02f, -1.42586278e-31f, -2.92493217e-02f, -2.50445474e-02f, 3.29996645e-02f, 1.14097551e-01f, -5.60605945e-03f, 5.00675365e-02f, 6.52698874e-02f, -1.87296242e-01f,
  4.24648710e-02f, 1.13013769e-02f, 9.48480796e-04f, -1.10481612e-01f, 9.71951038e-02f, 8.99433866e-02f, 8.82800221e-02f, -5.46363182e-02f, -6.44015372e-02f, 1.51381597e-01f,
  -1.06676444e-01f, -7.27864578e-02f, 1.66185632e-01f, 1.04246708e-03f, 5.75853176e-02f, -7.27703571e-02f, 1.14329867e-01f, -7.86011200e-03f, 9.00441695e-14f, -7.46534020e-02f,
  2.91332193e-02f, -5.25350571e-02f, 1.06571518e-01f, 1.52831182e-01f, -2.71929335e-03f, -6.45308115e-04f, -5.09069115e-03f, 4.62262658e-03f, 9.84609011e-04f, -2.04305653e-03f,
  2.72545661e-03f, 1.86638685e-03f, -2.30743154e-03f, -1.35772501e-03f, -5.10426937e-04f, 4.28879540e-03f, -7.89460202e-04f, -5.13205712e-04f, -4.64109844e-03f, 8.25305295e-04f,
  -1.64889507e-02f, -3.99902090e-03f, -4.18183953e-03f, -7.62347272e-03f, -5.15453867e-04f, -5.03919320e-04f, 1.16779003e-02f, -6.09479088e-04f, -5.31317294e-03f, -1.42429266e-02f,
  3.76786618e-03f, 4.47451277e-03f, -1.59951672e-02f, -5.25006931e-03f, -7.87455775e-03f, -1.10246159e-31f, -1.03148492e-02f, 1.08834589e-03f, 1.48139268e-04f, -1.45426197e-02f,
  1.45300152e-02f, 6.30133832e-03f, -4.51225741e-03f, 7.23820599e-03f, -1.26725016e-02f, -2.28387769e-03f, -4.84804576e-03f, 9.31298453e-03f, 1.45125797e-03f, -9.12551768e-03f,
  -8.31227936e-03f, 1.59409903e-02f, 1.53718246e-02f, -1.69970300e-02f, 1.37724937e-03f, 9.94289946e-03f, -1.27266003e-02f, 2.39913110e-02f, 1.29264295e-02f, -6.35169493e-03f,
  -6.42714743e-03f, 1.26095163e-02f, 4.86809793e-16f, 9.94759891e-03f, 3.00822360e-03f, -5.66662678e-40f, 8.79666489e-03f, -1.41020771e-02f, 3.25161219e-02f, -4.36469465e-02f,
  1.00485444e-01f, 6.90838173e-02f, 1.42631829e-01f, 1.59881301e-02f, 8.84625614e-02f, 1.31858230e-01f, 5.20517156e-02f, -1.42846078e-01f, -6.90806145e-03f, 1.30087407e-02f,
  1.30799234e-01f, 3.17612886e-02f, -1.34983018e-01f, -2.29483508e-02f, 3.11098294e-03f, 5.58296852e-02f, 6.18421212e-02f, -3.59497219e-02f, -2.09466457e-01f, -1.00444324e-01f,
  1.77852605e-02f, 3.14102508e-02f, 2.39816587e-02f, -3.85504365e-02f, -3.92796062e-02f, 1.97436854e-01f, -6.46870360e-02f, 5.46690598e-02f, 7.78035149e-02f, 3.25793949e-31f,
  7.52396733e-02f, 9.92050320e-02f, 6.62965104e-02f, -7.00066388e-02f, 1.89438581e-01f, -3.59109268e-02f, 1.06748536e-01f, -6.17888458e-02f, 3.52561101e-02f, -2.78996374e-03f,
  -2.48420462e-02f, -1.45759890e-02f, 1.18194103e-01f, 2.98849903e-02f, 4.20386642e-02f, 9.81449410e-02f, 5.52137978e-02f, -1.13461418e-02f, 2.38277540e-02f, 8.21496099e-02f,
  -1.93887390e-02f, 1.42991915e-01f, 1.69923723e-01f, 2.51584966e-02f, -6.82245344e-02f, 1.91442549e-01f, -8.79701721e-14f, -4.76234481e-02f, 1.72011435e-01f, -9.84009821e-03f,
  1.31129578e-01f, 3.31863277e-02f, 5.65401576e-02f, 2.60048192e-02f, -2.98923738e-02f, -2.33912654e-03f, 5.06778397e-02f, -2.06171870e-02f, -3.39911855e-03f, 4.34767921e-03f,
  6.61201309e-03f, -2.14514527e-02f, -2.87564825e-02f, -1.26852207e-02f, 1.94398873e-02f, 3.49165089e-02f, -4.23575155e-02f, -4.80791740e-02f, -2.25304943e-02f, 3.90727520e-02f,
  3.65455188e-02f, -1.42475655e-02f, -4.50306684e-02f, 3.50300260e-02f, 3.47620137e-02f, -1.18230224e-01f, -9.05307680e-02f, -2.37770891e-03f, 8.07855725e-02f, 1.24523193e-01f,
  6.29388774e-03f, 8.27154368e-02f, -5.56763895e-02f, -1.21889953e-30f, 4.52791378e-02f, 1.70326233e-01f, -8.02398697e-02f, -4.40324806e-02f, 1.20559908e-01f, -1.59458853e-02f,
  -6.02221908e-03f, 7.33371079e-02f, 4.00492325e-02f, -2.19086595e-02f, -5.29202372e-02f, 4.43677604e-02f, 1.09812424e-01f, -2.75578462e-02f, 3.33564617e-02f, 1.20194964e-01f,
  2.95343101e-02f, -5.93755990e-02f, 3.60279903e-02f, 1.26725063e-01f, -8.85649696e-02f, 1.15630195e-01f, -7.96608999e-03f, 1.39501661e-01f, -9.37591568e-02f, 1.84204310e-01f,
  -8.54211924e-14f, -1.64819453e-02f, 1.48809537e-01f, 3.18757929e-02f, -9.54724848e-02f, -3.05889901e-02f, 5.64518422e-02f, -1.06235504e-01f, -4.68483800e-03f, 2.98931245e-02f,
  2.91099865e-02f, 5.42850345e-02f, -7.78473914e-03f, 1.38842344e-01f, -6.07602745e-02f, -7.62383193e-02f, 7.31614381e-02f, 5.24809584e-03f, -1.33687571e-01f, -6.50907233e-02f,
  -1.22498728e-01f, 4.01721783e-02f, -1.06172405e-01f, -8.91161710e-02f, -1.48956999e-01f, -1.54175714e-01f, -8.96409824e-02f, -1.40298203e-01f, 7.53210261e-02f, -3.21107246e-02f,
  1.80306256e-01f, -2.05348395e-02f, 3.12747471e-02f, -2.33468622e-01f, 6.23525605e-02f, 1.09089002e-01f, 1.99849397e-01f, 4.58872040e-31f, 7.16407970e-02f, -1.24016525e-02f,
  3.00214350e-01f, -4.40463349e-02f, -8.73634443e-02f, 2.49437422e-01f, 5.77157363e-02f, 7.48479888e-02f, -7.74919987e-02f, 6.95456266e-02f, 1.67485908e-01f, 2.20402569e-01f,
  -2.34240770e-01f, 3.08409445e-02f, 1.35619149e-01f, -4.08575311e-02f, 3.00548881e-01f, -8.23060051e-02f, 7.80270249e-02f, -1.12011954e-01f, -3.54905948e-02f, 3.90053801e-02f,
  1.30514145e-01f, -2.21720915e-02f, 7.36738071e-02f, -2.61709862e-03f, 3.07928020e-14f, 1.13954745e-01f, -1.74811631e-01f, 8.12848508e-02f, 2.82518178e-01f, -4.50891778e-02f,
  -4.40468745e-40f, -4.93524707e-40f, 1.36285104e-39f, -4.91827735e-40f, -4.95553788e-40f, 4.91115875e-40f, 4.93080496e-40f, -9.52742826e-42f, -4.94232363e-40f, 4.94875559e-40f,
  -4.95321172e-40f, 4.90584783e-40f, -4.98298931e-40f, 4.91682000e-40f, 5.03188062e-40f, 4.92725967e-40f, -4.97971027e-40f, -4.97680959e-40f, -4.90808991e-40f, 4.96275456e-40f,
  4.95668694e-40f, -4.93195402e-40f, 4.91094856e-40f, 4.93866624e-40f, 4.92699343e-40f, -4.97137255e-40f, -5.51224573e-40f, 2.71466817e-35f, 4.93847006e-40f, -4.94742436e-40f,
  -4.95342192e-40f, -5.40747064e-40f, 4.90572172e-40f, -1.33952695e-31f, -6.25389696e-40f, 4.92598449e-40f, 6.38477857e-37f, 4.91171927e-40f, -4.93090305e-40f, -4.95329580e-40f,
  -5.68295786e-35f, -4.95780798e-40f, -4.63224767e-28f, -3.75247615e-35f, -5.53215818e-40f, -4.95322573e-40f, -4.95591623e-40f, -4.99510539e-27f, -4.30224989e-30f, 4.93632607e-40f,
  6.75697313e-36f, 6.29436634e-37f, -4.90860839e-40f, 2.37057937e-35f, 5.85574602e-40f, 3.33051791e-39f, -5.10738258e-40f, -2.74851145e-25f, 5.48686821e-40f, -4.93800763e-40f,
  -8.11563583e-26f, -5.48920838e-40f, 4.92252328e-40f, 4.94897980e-40f, 2.25170003e-03f, 7.47471154e-02f, -5.39016165e-02f, -5.02673164e-02f, 6.66940436e-02f, -2.75280774e-02f,
  -1.22884654e-01f, -4.89643626e-02f, 5.83687015e-02f, 6.15942590e-02f, 3.48750949e-02f, 1.29645392e-02f, -4.62966375e-02f, 1.22243933e-01f, 1.44073620e-01f, -4.23504673e-02f,
  8.62063840e-02f, 1.64394770e-02f, 2.61825342e-02f, 7.24122971e-02f, 6.33488894e-02f, 1.38590306e-01f, -1.36245470e-02f, -1.80737570e-01f, -8.75684917e-02f, 1.52259871e-01f,
  6.03827015e-02f, 4.79323491e-02f, 1.28937572e-01f, 4.54266109e-02f, -3.17200571e-02f, 4.74226049e-33f, 8.17788094e-02f, 1.01903714e-01f, -1.24564022e-01f, 4.49098274e-02f,
  2.94569414e-02f, -1.74429774e-01f, 1.33504979e-02f, 8.36101100e-02f, 1.05592772e-01f, 4.91952300e-02f, 1.22940121e-02f, -6.74499050e-02f, 9.89701897e-02f, -2.79938877e-02f,
  2.07002349e-02f, 7.29233846e-02f, -9.90263671e-02f, -9.96714458e-03f, -3.35544981e-02f, 7.01131225e-02f, -6.65375963e-02f, -2.75964529e-04f, -1.33395478e-01f, 1.50845915e-01f,
  1.39426244e-02f, 1.12547893e-02f, -5.39685111e-14f, 7.01699555e-02f, 1.07785404e-01f, 7.80007197e-03f, -1.86769262e-01f, 8.01586211e-02f, 5.85267916e-02f, 6.52189180e-02f,
  -2.46556737e-02f, -1.71320047e-02f, 4.69242930e-02f, 8.02353993e-02f, -6.82574362e-02f, 5.73564135e-02f, 1.50155714e-02f, -1.04936518e-01f, 1.59531072e-01f, 3.10132746e-02f,
  1.14546753e-01f, -4.94756773e-02f, 3.79678942e-02f, -5.76851591e-02f, -3.81925255e-02f, -4.61034663e-02f, 4.06498127e-02f, 2.98678111e-02f, -3.04793231e-02f, -3.86831686e-02f,
  8.31049755e-02f, 3.89005356e-02f, -1.76513150e-01f, 5.03897108e-03f, -7.32840970e-02f, -9.24680531e-02f, 2.82639284e-02f, 1.03908636e-01f, 1.63152553e-02f, 1.57774419e-30f,
  1.51611447e-01f, 5.37103973e-02f, 1.29532233e-01f, 8.78177658e-02f, -7.96997473e-02f, -3.67217921e-02f, 1.80554882e-01f, -2.85683852e-02f, 9.34964046e-02f, -5.04804961e-03f,
  6.72780722e-02f, 1.10820092e-01f, 6.09253235e-02f, 2.66612738e-01f, -1.03080660e-01f, 2.78968941e-02f, 8.72532353e-02f, -8.36462677e-02f, 1.77370682e-01f, -5.57349175e-02f,
  -8.80028158e-02f, 6.34579882e-02f, 1.11155137e-01f, 2.89095175e-02f, -2.10544944e-01f, 1.34304374e-01f, -4.47401426e-16f, -1.37810528e-01f, 1.32738762e-02f, 5.45427725e-02f,
  2.65824404e-02f, 4.81082201e-02f, -2.80839801e-02f, -5.74779138e-02f, 3.81584540e-02f, 6.00262433e-02f, -3.20723243e-02f, 1.35537744e-01f, 1.06959827e-01f, 4.08107787e-02f,
  -6.62836537e-04f, 7.17450827e-02f, -2.82740220e-02f, 1.94359906e-02f, 1.28247872e-01f, -1.62497580e-01f, 9.92721245e-02f, 4.65736724e-02f, 5.57402298e-02f, 8.74852836e-02f,
  -3.61085087e-02f, 1.13439851e-01f, 8.20883512e-02f, -2.69770801e-01f, -1.83460385e-01f, 1.75625235e-01f, 2.59469539e-01f, 3.80585678e-02f, -4.11794893e-02f, -1.88844845e-01f,
  9.14508651e-04f, 3.50187086e-02f, 8.08887258e-02f, 4.09302205e-30f, -6.78478107e-02f, -5.37586175e-02f, 8.86141285e-02f, 2.39926174e-01f, -2.18169659e-01f, 2.16285944e-01f,
  7.40121678e-02f, -8.89108181e-02f, 1.49818420e-01f, 1.00252755e-01f, 1.04670994e-01f, 1.16499618e-01f, -1.24474600e-01f, 2.62979835e-01f, 1.16869636e-01f, -6.00044839e-02f,
  -1.67303756e-02f, 1.47094533e-01f, 1.08832881e-01f, -1.30635500e-01f, 2.25391328e-01f, -2.07311809e-02f, 8.15382525e-02f, -4.53860499e-02f, 2.91943662e-02f, -1.56575069e-01f,
  -2.14578907e-14f, -8.03487822e-02f, -1.93337262e-01f, -2.49598268e-03f, 9.78626162e-02f, 5.05357422e-02f, 7.58755282e-02f, 5.02659678e-02f, 7.75415972e-02f, 9.06557888e-02f,
  1.42560273e-01f, 1.01959527e-01f, 3.57294008e-02f, 1.17560007e-01f, -2.98438668e-02f, -3.12051661e-02f, 4.67094220e-02f, -2.59153489e-02f, 1.85049213e-02f, -1.20865919e-01f,
  -8.04167390e-02f, 5.79487868e-02f, -8.92584324e-02f, -7.86261410e-02f, -7.64151439e-02f, -3.04421410e-02f, -5.84503114e-02f, -2.26462737e-01f, 6.52183965e-02f, 8.13997984e-02f,
  1.84926521e-02f, 1.53737450e-02f, -6.14644587e-02f, -1.22174025e-01f, 1.23817073e-02f, 4.07411531e-02f, 2.46309601e-02f, 2.26265717e-30f, -9.74112600e-02f, -7.57459737e-03f,
  2.63756961e-01f, 3.07677798e-02f, -1.91990197e-01f, 1.60063609e-01f, 3.02671399e-02f, 3.37047502e-02f, -2.33828668e-02f, 7.35228658e-02f, 1.74319327e-01f, 2.18251809e-01f,
  -1.61546230e-01f, 1.56552061e-01f, 3.63475606e-02f, -4.57736328e-02f, 2.59331256e-01f, 3.10456497e-03f, 2.33963639e-01f, -6.88209906e-02f, 6.42736852e-02f, -3.98652181e-02f,
  1.49219036e-01f, 1.65156350e-02f, -3.32439542e-02f, 2.68364046e-02f, 3.63235510e-14f, 3.24087421e-04f, -1.44158989e-01f, 6.88054636e-02f, 3.48693997e-01f, -6.20406820e-03f,
  3.80155928e-02f, 1.49647385e-01f, 2.83381902e-02f, 1.97762940e-02f, 1.22183807e-01f, 6.30453974e-02f, 1.67530924e-02f, 1.20396867e-01f, 4.11168821e-02f, -2.35554606e-01f,
  1.23952832e-02f, -6.40072525e-02f, -2.82697767e-01f, 2.75677800e-01f, 2.21041650e-01f, -1.10167153e-01f, 1.06318132e-03f, 1.61299139e-01f, 1.18166260e-01f, -1.66397600e-03f,
  -1.79632679e-01f, 1.05201535e-01f, -3.44337821e-02f, -3.93592149e-01f, -1.89218625e-01f, 1.94399416e-01f, 3.86764348e-01f, 6.11918652e-03f, 3.84972960e-01f, 1.98495463e-01f,
  6.07475033e-03f, -1.43990041e-31f, 3.08483988e-01f, 1.71048477e-01f, -1.01063676e-01f, 9.51465592e-02f, 4.30338457e-02f, -1.94105342e-01f, 1.05749490e-02f, 4.17417169e-01f,
  2.28045389e-01f, -3.17548886e-02f, 5.94902784e-02f, 1.57901838e-01f, -1.36509687e-01f, -8.97102356e-02f, -4.37506102e-03f, 1.21043541e-01f, 2.76106084e-03f, -3.31960380e-01f,
  2.68629223e-01f, 1.51785508e-01f, -3.61606061e-01f, -9.38665196e-02f, -2.27076918e-01f, 3.38546246e-01f, -1.38156652e-01f, 3.01857200e-02f, 9.57029798e-14f, 2.13824317e-01f,
  1.14961423e-01f, -2.18256144e-04f, -3.08211118e-01f, -1.04396157e-01f, 5.29655702e-02f, -1.33041907e-02f, -4.03467529e-02f, -4.82201241e-02f, 4.97362204e-02f, -3.22706029e-02f,
  -3.53333429e-02f, 1.05172887e-01f, 4.44525741e-02f, -1.50528640e-01f, 2.60844305e-02f, 6.86553717e-02f, 1.54872090e-01f, 2.63191462e-02f, -5.17728273e-03f, -9.72684845e-02f,
  5.01464196e-02f, 7.15964809e-02f, 5.71319498e-02f, -3.92897241e-02f, -1.32920712e-01f, -5.59607446e-02f, 4.65726182e-02f, -2.53764410e-02f, -1.08794734e-01f, -6.57324819e-03f,
  -9.46241245e-02f, 5.29930070e-02f, -6.48324043e-02f, 6.17001690e-02f, 1.65677235e-01f, -7.09596863e-33f, 2.02367052e-01f, 5.78383245e-02f, 8.45261142e-02f, 1.07929282e-01f,
  3.58281247e-02f, -2.69077811e-02f, 2.03941718e-01f, -7.48177171e-02f, 1.10026740e-01f, -1.11518875e-01f, -7.17463419e-02f, 4.47239523e-04f, 1.21767513e-01f, 6.15018420e-02f,
  1.86980873e-01f, -2.65696808e-03f, -5.59666045e-02f, -1.21572383e-01f, -5.48444502e-02f, -2.68943477e-02f, -1.19156964e-01f, 5.96603192e-02f, 6.56394213e-02f, 4.82579917e-02f,
  -1.33969903e-03f, 1.51958749e-01f, 6.26754575e-15f, -3.80017012e-02f, 1.38313070e-01f, -1.63941868e-02f, 7.47862831e-02f, 1.68291569e-01f, 1.37494802e-02f, -4.68087532e-02f,
  5.33817708e-02f, -7.28631690e-02f, -5.27323373e-02f, -2.26782616e-02f, -3.57113369e-02f, -4.97599170e-02f, -7.82118663e-02f, 1.09805457e-01f, 1.88841242e-02f, -5.54709397e-02f,
  -1.06748544e-01f, -2.07961634e-01f, -2.47191936e-02f, 3.97569761e-02f, -8.49620439e-03f, 1.01253428e-02f, -4.35487404e-02f, -8.16332996e-02f, 1.14091106e-01f, 5.02720624e-02f,
  5.40902256e-04f, 8.20542648e-02f, 2.63420433e-01f, -7.79109374e-02f, 1.50513127e-02f, -1.91591933e-01f, -1.04686543e-01f, -2.14483991e-01f, 9.53523070e-02f, 2.41791641e-31f,
  -1.88623928e-02f, -2.27447167e-01f, -1.24550000e-01f, 6.95574507e-02f, -8.54355190e-03f, 1.18147574e-01f, -1.71313435e-01f, 3.30363475e-02f, -1.07317202e-01f, 5.64119630e-02f,
  7.79077634e-02f, -1.83878437e-01f, -2.00063094e-01f, -1.22102149e-01f, 1.15048371e-01f, -2.15214521e-01f, -2.06516623e-01f, 1.95419639e-01f, -2.90935367e-01f, -2.79347807e-01f,
  2.13800728e-01f, -1.30460247e-01f, -1.25897452e-01f, -1.11915901e-01f, 3.01297933e-01f, -2.50022709e-01f, -2.12548857e-14f, 1.03619993e-01f, -2.37162232e-01f, 8.83610826e-03f,
  2.00025979e-02f, 6.00826181e-02f, -2.51080059e-02f, 4.46146578e-02f, -2.27041240e-03f, 3.16550806e-02f, 3.57822925e-02f, 1.31850019e-02f, -6.18708991e-02f, 4.81781438e-02f,
  1.37689963e-01f, 2.92404238e-02f, 1.85890216e-02f, 6.22731559e-02f, 1.67845964e-01f, 9.27090719e-02f, 5.07920980e-02f, -1.23214558e-01f, 8.95523503e-02f, 4.46890928e-02f,
  1.03240065e-01f, 8.41195583e-02f, -3.77807133e-02f, -2.27551386e-02f, -8.52438435e-02f, -8.37551281e-02f, -1.65564895e-01f, 6.02324083e-02f, -1.28453404e-01f, 2.21872985e-01f,
  -8.51097051e-04f, -3.42159159e-02f, 9.41570625e-02f, 4.93809171e-40f, 1.41041040e-01f, 2.17462376e-01f, -1.66169852e-01f, 2.44166195e-01f, 1.28080279e-01f, -2.32710749e-01f,
  2.05986917e-01f, -1.41247973e-01f, 2.51166701e-01f, -2.97219194e-02f, -5.08850515e-02f, -1.97836861e-01f, 3.06639969e-01f, 3.52318250e-02f, 1.94619924e-01f, 1.92707896e-01f,
  -1.60548747e-01f, 5.57929883e-03f, -1.62671015e-01f, 1.26038596e-01f, -6.30382821e-02f, 9.17327255e-02f, -3.92367132e-02f, 7.06663579e-02f, -2.20001247e-02f, 1.58630326e-01f,
  -1.53401665e-14f, -6.05538562e-02f, 2.63215572e-01f, -3.15738935e-03f, -9.69366543e-03f, 1.84451714e-01f, -5.80499433e-02f, 1.41729033e-02f, 5.41314781e-02f, 1.20154113e-01f,
  -9.27805901e-03f, -2.73861326e-02f, 1.28861144e-01f, 2.94137206e-02f, 6.34788126e-02f, -1.01003945e-01f, -8.66030529e-02f, 5.03107347e-02f, 1.35529041e-01f, 3.58280838e-02f,
  -1.22941315e-01f, -1.06063122e-02f, -6.83424398e-02f, -9.45546180e-02f, 5.70658371e-02f, 1.45270675e-01f, -6.23834617e-02f, -2.04371884e-02f, 2.14965846e-02f, 6.82849288e-02f,
  -9.34855267e-02f, 1.38061019e-02f, 2.79697198e-02f, 1.67624250e-01f, -2.05260757e-02f, 1.44745573e-01f, -1.74260631e-01f, 5.68444441e-32f, -1.71106100e-01f, 1.27830401e-01f,
  4.99556251e-02f, -1.69532020e-02f, 7.02410638e-02f, 1.39619485e-01f, 5.39460704e-02f, -2.11280794e-03f, 1.63092047e-01f, 7.48235062e-02f, 5.13021462e-02f, 1.38657227e-01f,
  7.83023685e-02f, 7.46659515e-03f, -2.39157379e-01f, 2.77858496e-01f, 2.61330634e-01f, 6.59150854e-02f, 2.49213457e-01f, 2.94020891e-01f, -1.10196490e-02f, 2.64840990e-01f,
  1.33463502e-01f, 3.50072123e-02f, -2.23875508e-01f, 2.13735297e-01f, -3.67807184e-14f, -8.54526982e-02f, 7.78619573e-02f, 6.21404201e-02f, -4.85578179e-02f, -1.32401437e-01f,
  3.25226188e-02f, -7.06268772e-02f, -4.96219248e-02f, -1.23986997e-01f, -8.58649015e-02f, -3.69422510e-02f, 2.90863886e-02f, -4.45942059e-02f, -1.34071186e-01f, 3.78202796e-02f,
  -5.30846752e-02f, -4.60233400e-03f, 2.72272736e-01f, -2.16578513e-01f, -2.64312387e-01f, -2.51225661e-02f, -9.02932584e-02f, -2.39114240e-02f, -2.16857269e-02f, -4.27075177e-02f,
  -1.59523636e-02f, -1.18492983e-01f, 1.89270955e-02f, 2.68472433e-01f, 8.05951506e-02f, -1.01855479e-01f, -1.67079553e-01f, 1.49975881e-01f, -2.52958536e-01f, -1.97959342e-03f,
  7.03467354e-02f, 5.21148744e-30f, -3.09962500e-02f, -3.33281867e-02f, 1.77828837e-02f, -2.15485860e-02f, 1.21712342e-01f, 1.00726806e-01f, 1.00766733e-01f, -2.21070126e-01f,
  -5.80462404e-02f, -5.93380220e-02f, 3.59563939e-02f, -2.96389870e-02f, 1.16900578e-01f, 1.17708258e-01f, 8.27928632e-02f, 3.58148254e-02f, 6.36727586e-02f, 4.96700630e-02f,
  -1.45579085e-01f, -1.84794553e-02f, 6.57270998e-02f, 1.55290112e-01f, 1.74540341e-01f, -1.56171396e-01f, -6.56335652e-02f, 1.63346127e-01f, -8.95927162e-15f, -1.42290294e-01f,
  8.37302655e-02f, -1.25295352e-02f, 2.24854663e-01f, -1.18680270e-02f, 1.97186992e-02f, -2.51717772e-03f, 5.86609617e-02f, -1.53254848e-02f, 8.25559124e-02f, 2.81955563e-02f,
  -1.56333367e-03f, 1.27407491e-01f, 2.51193531e-03f, -9.49738994e-02f, 2.55819838e-02f, 1.62720494e-02f, 1.64924264e-01f, -1.09241819e-02f, 1.02512412e-01f, -1.33408988e-02f,
  -7.25463917e-03f, 7.84958452e-02f, 7.22695589e-02f, 8.42203721e-02f, -1.01654939e-01f, -6.65090531e-02f, -3.91146317e-02f, 9.45408717e-02f, 5.98601252e-02f, -5.40253147e-02f,
  -9.34808552e-02f, -1.36937751e-02f, -2.37078313e-02f, 5.31970859e-02f, 1.14681870e-01f, 6.95422458e-33f, 1.53815255e-01f, -5.34160808e-03f, 7.38968775e-02f, 1.22408338e-01f,
  -4.18798588e-02f, -2.74037430e-03f, 2.01813757e-01f, -1.03978343e-01f, 2.00764567e-01f, -6.62801638e-02f, -3.80489114e-03f, -5.69526441e-02f, 8.23504180e-02f, 2.69924134e-01f,
  8.64628032e-02f, -3.69363315e-02f, -4.83426750e-02f, -2.15749424e-02f, -1.84088908e-02f, -1.05244443e-01f, 5.72601929e-02f, -1.13169923e-01f, 5.98705076e-02f, -7.24853575e-03f,
  -4.22680527e-02f, -6.04129443e-03f, -3.20942613e-14f, -1.42753080e-01f, 2.27919780e-02f, -2.51969732e-02f, 3.27569246e-02f, 1.58091322e-01f, 1.85907446e-02f, -2.36657690e-02f,
  4.40052710e-02f, 9.57359746e-02f, 9.13832635e-02f, 1.53105199e-01f, 1.93879604e-01f, -1.04267657e-01f, 1.32326514e-01f, 1.17527455e-01f, 1.08626984e-01f, 1.39076468e-02f,
  1.00289304e-02f, 1.31079897e-01f, 5.87882586e-02f, 1.16295025e-01f, 2.74231404e-01f, 7.58669078e-02f, 7.60692209e-02f, 2.41123199e-01f, 1.82884157e-01f, -8.11849087e-02f,
  -1.55044943e-01f, -1.36374012e-01f, 1.08287565e-01f, 2.53368735e-01f, -1.29597917e-01f, 7.58401975e-02f, 2.08214939e-01f, -7.68706426e-02f, 1.68342702e-02f, 3.40282545e-32f,
  -2.53566116e-01f, 1.29284859e-01f, -1.23210020e-01f, 3.33688036e-02f, -7.92204216e-02f, 1.10894196e-01f, -1.61067963e-01f, -4.80742343e-02f, 2.43752599e-01f, 3.18129748e-01f,
  2.69293189e-01f, -9.26541314e-02f, 7.51839131e-02f, 4.37090620e-02f, 6.98550977e-03f, 1.04840733e-01f, -1.44512951e-01f, 3.85767728e-01f, -2.78936606e-02f, 9.12681222e-02f,
  2.70451427e-01f, 8.98794979e-02f, -1.29361629e-01f, 1.45931602e-01f, -1.97128188e-02f, -1.03525959e-01f, 9.85246769e-14f, 4.75562215e-02f, 6.40909821e-02f, -4.25068736e-02f,
  -2.17710704e-01f, 2.77117521e-01f, -6.37623817e-02f, -1.12448074e-01f, -2.06429809e-02f, 6.26548156e-02f, -1.05991855e-01f, -8.53966698e-02f, 1.82027575e-02f, -1.88658640e-01f,
  -9.29605737e-02f, 1.60344824e-01f, -1.43395200e-01f, -7.01507628e-02f, -7.46632293e-02f, 8.63707531e-03f, -2.52774447e-01f, 1.23541266e-01f, -1.12395734e-01f, -2.57137418e-01f,
  -1.70746475e-01f, -2.13402361e-02f, 4.96584736e-02f, 5.34603298e-02f, 7.31450319e-02f, 6.14844486e-02f, 9.83685907e-03f, 8.09900165e-02f, 1.00135423e-01f, 6.16084710e-02f,
  9.16410796e-03f, 4.29788195e-02f, -1.41881287e-01f, -1.60318057e-30f, -2.95555681e-01f, 7.35218301e-02f, 6.93083256e-02f, -3.42259347e-01f, 1.66644931e-01f, 1.87912405e-01f,
  -2.00314105e-01f, 1.20244645e-01f, -2.34750152e-01f, 2.02008173e-01f, 1.41282871e-01f, 2.40313768e-01f, -5.49703464e-02f, -2.33210951e-01f, -1.27023414e-01f, 2.34056443e-01f,
  3.00476283e-01f, 6.30938485e-02f, 2.03703523e-01f, 2.07300976e-01f, 2.07492020e-02f, 2.06441090e-01f, 7.64880031e-02f, 6.33998439e-02f, -1.78398564e-02f, 1.10549062e-01f,
  4.92235681e-14f, 1.59830928e-01f, 2.73645343e-03f, 5.11661507e-02f, 6.50646687e-02f, -2.13153943e-01f, 9.72791016e-02f, 5.34089468e-02f, -1.16515853e-01f, -1.30372450e-01f,
  -8.11540186e-02f, -9.03596804e-02f, -1.66397631e-01f, 8.28550532e-02f, 5.81578119e-03f, 1.05501160e-01f, 6.35163188e-02f, 1.09958172e-01f, -1.22894824e-01f, -4.09035683e-02f,
  -3.92206013e-02f, -6.56093284e-02f, 9.02573671e-03f, -1.51530728e-01f, -1.07285537e-01f, -2.29341850e-01f, 1.52446758e-02f, 1.10790208e-01f, 1.22814775e-01f, -3.69863845e-02f,
  4.67004851e-02f, -1.12086914e-01f, 1.10319346e-01f, 7.88283162e-03f, -4.79644798e-02f, -9.18750535e-04f, 2.63381004e-01f, -7.31941494e-31f, 3.26230675e-01f, 9.11636502e-02f,
  1.02778696e-01f, 1.11041546e-01f, 1.43251479e-01f, 1.30000971e-02f, 1.86149746e-01f, 1.78816780e-01f, -1.79840326e-01f, -1.05191290e-01f, -1.59949169e-01f, 1.25227168e-01f,
  8.64714682e-02f, -2.68518418e-01f, 4.28959280e-01f, -1.48639781e-02f, 1.03084907e-01f, -2.38583177e-01f, -1.65438369e-01f, -3.47508676e-02f, -1.70762718e-01f, 1.28715247e-01f,
  4.92925420e-02f, 6.42234683e-02f, 3.60478520e-01f, 1.90741315e-01f, -1.04912349e-13f, 3.22328120e-01f, 2.04488263e-01f, 2.32235175e-02f, 2.22807214e-01f, 7.96149746e-02f,
  -1.16723508e-01f, 1.48335263e-01f, -6.32245392e-02f, -5.05010709e-02f, 9.87484381e-02f, 5.19434316e-03f, -1.80457607e-01f, -7.26754442e-02f, -3.34692118e-03f, 3.11932359e-02f,
  5.51876575e-02f, 1.29341885e-01f, 2.12058902e-01f, 7.41200671e-02f, 4.89941314e-02f, -1.01083547e-01f, -5.98246930e-03f, -1.89020913e-02f, 7.60968328e-02f, 2.04645619e-02f,
  5.55798635e-02f, 1.26765937e-01f, 1.05430469e-01f, 6.33634068e-03f, -1.06541008e-01f, -4.02684473e-02f, -4.89770137e-02f, 7.34021440e-02f, -1.22707181e-01f, -4.55902442e-02f,
  3.46377268e-02f, 5.05134465e-40f, 6.26855716e-02f, 1.39986947e-01f, -1.62484512e-01f, 1.23291560e-01f, 1.31189391e-01f, -8.34423378e-02f, 1.72063798e-01f, -6.65374547e-02f,
  1.72091335e-01f, -1.74215570e-01f, -1.94750622e-01f, -1.40634343e-01f, 3.44864190e-01f, 1.46702498e-01f, -3.29135451e-03f, 1.12694956e-01f, -2.13642027e-02f, -3.99743691e-02f,
  -1.23108141e-01f, 1.23230778e-02f, -2.20692642e-02f, 1.20406926e-01f, -1.26714632e-02f, 1.24682404e-01f, -1.35956816e-02f, 7.81158432e-02f, 9.39175309e-15f, -1.29117846e-01f,
  1.77263439e-01f, -1.42804515e-02f, -1.53401103e-02f, 1.86919644e-01f, -5.09446960e-16f, 3.78133970e-17f, -1.11114131e-15f, -1.27539212e-15f, -1.20081394e-15f, -1.26370158e-15f,
  -1.28752936e-15f, -1.15628161e-15f, -5.71723258e-16f, -1.16499224e-17f, -7.73203385e-16f, -2.54840027e-16f, -1.10553194e-15f, 9.35942608e-16f, 3.79166781e-16f, 2.04158710e-16f,
  1.65520898e-18f, -3.85447160e-16f, -1.95453488e-16f, 5.19103414e-17f, -7.21719055e-17f, 7.76068421e-16f, 9.28408250e-16f, -1.25616426e-15f, 1.06182547e-15f, -1.61284089e-17f,
  2.57670797e-17f, -1.00624430e-16f, -1.26663934e-17f, 9.56922873e-16f, 5.27537414e-16f, 5.03207680e-40f, 2.50205327e-16f, -3.10318144e-16f, -3.20498993e-15f, -1.97778657e-15f,
  -2.36957583e-17f, -2.57350696e-15f, 7.86847127e-16f, -5.09978354e-17f, -1.11644427e-15f, -7.22471776e-16f, -2.29012700e-15f, -1.02996358e-15f, 2.22756404e-16f, -7.96681021e-16f,
  9.77308864e-17f, -5.13434050e-16f, -2.48817601e-15f, 1.73876573e-15f, -4.43055274e-16f, -3.93032790e-16f, 2.77598150e-15f, -2.30198779e-16f, 3.20656731e-15f, -6.65827123e-17f,
  5.22052776e-17f, -5.90615851e-16f, -4.53710657e-35f, -1.29338887e-16f, -2.92514649e-16f, -5.29665596e-40f, -4.12337248e-15f, -2.12455345e-15f, 1.74605101e-01f, 1.06044389e-01f,
  -5.68849929e-02f, 3.95209901e-02f, 2.13923329e-03f, 3.15362518e-03f, 6.43430501e-02f, 6.91274107e-02f, -2.74047013e-02f, 9.03467610e-02f, 3.26335058e-02f, 1.20992288e-01f,
  1.61031574e-01f, -7.08287209e-02f, -7.93341845e-02f, -9.14344117e-02f, 6.66055232e-02f, 5.13758510e-02f, 1.38649091e-01f, 6.23351373e-02f, 2.27042753e-02f, -1.07024945e-01f,
  1.83374304e-02f, 9.90913156e-03f, -1.41977772e-01f, -2.44953427e-02f, -1.17295377e-01f, 4.09906879e-02f, -5.16989008e-02f, 1.28532806e-02f, -6.53455779e-02f, -1.16977157e-30f,
  -9.05097499e-02f, 1.13975808e-01f, 6.52744174e-02f, -3.29519324e-02f, -4.31655087e-02f, -3.59571986e-02f, 2.96781268e-02f, -5.44331595e-02f, 1.95693672e-02f, 3.48099247e-02f,
  1.95734948e-02f, 4.62908112e-03f, 1.33259356e-01f, 2.09024735e-02f, -5.95836602e-02f, -9.95813496e-03f, -2.02806778e-02f, 6.18672855e-02f, 4.03789850e-03f, 3.33613791e-02f,
  2.98749916e-02f, 8.42735767e-02f, 4.81790863e-02f, 5.37874252e-02f, -1.54894209e-02f, 7.83596486e-02f, -2.21434252e-16f, -5.20552173e-02f, 1.49396688e-01f, 3.81226577e-02f,
  7.20784860e-03f, 9.38835219e-02f, -3.76561321e-02f, 7.93832019e-02f, -5.55659495e-02f, 1.22758649e-01f, 8.45775381e-02f, -4.09497656e-02f, 3.03000361e-02f, 5.37004732e-02f,
  8.92852060e-03f, -1.69411063e-01f, -2.99477000e-02f, -9.45443735e-02f, -1.61623403e-01f, 9.56372768e-02f, 1.82768390e-01f, -3.39795067e-03f, -1.35102689e-01f, 5.59106050e-03f,
  3.34507488e-02f, 9.47510600e-02f, -1.63765907e-01f, 4.93025444e-02f, -4.29079384e-02f, -2.60891676e-01f, -5.41404746e-02f, 1.62311122e-01f, 2.43533567e-01f, 2.48724427e-02f,
  2.75952071e-01f, 2.50815064e-01f, -2.50879098e-02f, 1.26491082e-30f, 6.93088621e-02f, 1.04740076e-01f, 8.82408246e-02f, 2.76364069e-02f, -1.81993954e-02f, -2.85869557e-02f,
  2.18951572e-02f, 2.70082742e-01f, 2.23558158e-01f, 1.38442952e-03f, 1.19207948e-01f, 1.93040103e-01f, -8.69716704e-02f, 6.83776662e-02f, -7.81432018e-02f, 3.41335125e-02f,
  2.32151166e-01f, -1.05532706e-01f, 3.20431799e-01f, 2.00580373e-01f, -1.20841600e-01f, -1.06386848e-01f, 9.05190594e-03f, 1.33219227e-01f, -1.82043821e-01f, 8.15955848e-02f,
  3.56396668e-14f, 3.02326325e-02f, 6.73821792e-02f, 1.48518803e-02f, -2.21014693e-02f, -6.06909469e-02f, -3.25101428e-02f, 1.52671367e-01f, 3.21752205e-02f, 6.32954836e-02f,
  -1.77941192e-02f, 8.42438638e-02f, 4.46375518e-04f, -1.23251967e-01f, -7.84202814e-02f, 1.38619438e-01f, 1.99982859e-02f, 4.22739834e-02f, 1.08783267e-01f, 2.08926275e-02f,
  6.38824403e-02f, -1.81588177e-02f, 7.81635419e-02f, 1.53949797e-01f, 1.88828528e-01f, 1.62755013e-01f, 1.68731213e-01f, 5.58150858e-02f, -1.06993914e-01f, -6.17712028e-02f,
  -1.23628564e-02f, -8.92491341e-02f, 4.77057993e-02f, 1.23465374e-01f, 2.46583968e-02f, -1.02490438e-02f, -8.43582768e-03f, -4.93811974e-40f, 7.65584856e-02f, 9.88948271e-02f,
  -2.62947589e-01f, -3.68503928e-02f, 4.40556556e-03f, 5.21308221e-02f, 8.00799020e-03f, 1.29875522e-02f, 1.10131323e-01f, 1.01464475e-02f, -2.21183803e-02f, -1.91601411e-01f,
  2.68598914e-01f, 1.88291892e-01f, -1.39155939e-01f, 1.44840330e-01f, -7.22522810e-02f, 1.53391317e-01f, 8.66938457e-02f, 3.53910364e-02f, 1.54557794e-01f, 8.45909938e-02f,
  -9.69670489e-02f, 1.17280692e-01f, -5.07710204e-02f, 6.57611713e-02f, -7.05775024e-14f, -1.08600505e-01f, 8.06369483e-02f, -9.43136029e-03f, -1.88849241e-01f, -1.36134690e-02f,
  1.38607517e-01f, 1.19018694e-02f, 3.36073786e-02f, 1.13002598e-01f, 3.82337458e-02f, 1.00867860e-02f, 6.29919246e-02f, 1.25610739e-01f, 3.91693525e-02f, -4.76808436e-02f,
  6.91463351e-02f, 1.42701775e-01f, 1.04912326e-01f, 6.31866530e-02f, -6.18336983e-02f, -1.10276811e-01f, 7.44992867e-02f, -9.25631896e-02f, 1.25375345e-01f, 4.23444882e-02f,
  -1.03727892e-01f, -1.00281194e-01f, 1.91989783e-02f, -4.03458029e-02f, -9.53714699e-02f, -5.22464095e-03f, -6.20603114e-02f, 2.73368768e-02f, -4.09184061e-02f, -3.38627328e-03f,
  -3.15171406e-02f, 2.08163196e-32f, 1.47719771e-01f, 8.53009075e-02f, 1.04050368e-01f, 2.73418408e-02f, -1.84811987e-02f, -1.14832342e-01f, 1.23436116e-01f, -2.52761459e-03f,
  1.75013170e-01f, 4.47222069e-02f, -9.39796269e-02f, 8.54647160e-02f, 6.79194480e-02f, 6.16247673e-03f, 1.19768560e-01f, 5.17770536e-02f, 2.50451751e-02f, -2.50044409e-02f,
  7.27059320e-02f, 3.01244799e-02f, -7.66665787e-02f, 6.67794570e-02f, 4.14425842e-02f, 3.60061787e-02f, -2.05205400e-02f, 1.23181693e-01f, -6.60958105e-15f, -2.12925170e-02f,
  1.40671119e-01f, 8.46697669e-03f, 1.09741883e-02f, 9.75823496e-03f, 3.30396555e-02f, -4.69673350e-02f, -3.22712809e-02f, -3.42063382e-02f, 9.75571126e-02f, -3.55602987e-03f,
  2.75570806e-02f, 1.29851997e-01f, 1.42137306e-02f, -1.04197010e-01f, 1.97736267e-02f, -7.48249814e-02f, 4.55382690e-02f, -8.67034793e-02f, 7.73831795e-04f, -2.13990323e-02f,
  8.08719918e-03f, 4.72097062e-02f, -5.26831336e-02f, 2.18946813e-03f, -1.20427556e-01f, -8.59322324e-02f, -6.00936115e-02f, 1.34198517e-01f, 1.38791263e-01f, -1.35068074e-01f,
  -7.14275837e-02f, -8.91872942e-02f, -5.60822822e-02f, 8.25954154e-02f, 1.74871668e-01f, -3.69501622e-30f, 1.62902325e-01f, -5.59419803e-02f, 1.93487704e-01f, 1.08767778e-01f,
  -1.00389034e-01f, 6.90690354e-02f, 1.88981891e-01f, -8.83432552e-02f, 1.06473029e-01f, -1.17751084e-01f, -1.75644411e-04f, 4.99451943e-02f, -6.75417781e-02f, 1.29222065e-01f,
  1.75271630e-01f, -1.91174030e-01f, 1.04717530e-01f, -1.19665876e-01f, -4.47306931e-02f, -1.52413353e-01f, 3.56869400e-02f, -4.34163511e-02f, 1.37930423e-01f, -7.11754337e-02f,
  7.08567724e-02f, 2.46795081e-02f, 6.91868031e-15f, -6.21500649e-02f, -1.85411293e-02f, 2.80688126e-02f, 2.08442643e-01f, 9.61283669e-02f, -8.63397866e-02f, 1.14223830e-01f,
  -1.37844101e-01f, 8.58904123e-02f, -1.44877732e-01f, 3.41373729e-03f, -1.13784438e-02f, -1.94305554e-01f, 5.35208918e-02f, 1.67997181e-01f, -1.24400526e-01f, 1.90938115e-02f,
  -1.34043425e-01f, 1.28683463e-01f, 2.22242158e-02f, 2.34294054e-03f, 1.37070324e-02f, -1.54885083e-01f, -7.25090057e-02f, 9.63578522e-02f, 1.40955657e-01f, 8.04860815e-02f,
  4.97223511e-02f, -1.86180040e-01f, -1.25259787e-01f, 1.62345693e-01f, 1.46724686e-01f, 4.47882749e-02f, 5.35509810e-02f, -4.61858213e-02f, -2.83333175e-02f, -2.05203848e-30f,
  -1.70419633e-01f, 2.18984604e-01f, -5.17102778e-02f, -1.03054293e-01f, 2.14882597e-01f, -4.39559296e-02f, -1.10247672e-01f, 1.17640041e-01f, -5.92616051e-02f, 2.35000029e-01f,
  5.49451150e-02f, -3.52077633e-02f, 1.17750965e-01f, -1.16486162e-01f, -1.31720692e-01f, 2.66276091e-01f, -4.76917513e-02f, 5.67727089e-02f, 1.51969030e-01f, 2.62102067e-01f,
  -2.67368183e-02f, 1.83561698e-01f, -1.00198857e-01f, 1.92840517e-01f, -5.87972514e-02f, 7.07083568e-02f, -7.44846998e-16f, 7.36660063e-02f, 2.01289669e-01f, 1.02961799e-02f,
  -1.95488632e-01f, -7.69070834e-02f, 2.27745455e-02f, 1.28854230e-01f, 5.96794784e-02f, -6.81565478e-02f, 7.07857758e-02f, 1.62418619e-01f, -6.57841414e-02f, -3.19551937e-02f,
  4.68967147e-02f, 4.04933393e-02f, 1.69190884e-01f, -9.85503080e-04f, 7.53279924e-02f, -6.85047507e-02f, 1.97207674e-01f, -7.30457576e-03f, 1.63088933e-01f, 1.35750234e-01f,
  1.61798224e-02f, 1.45645276e-01f, 2.08456203e-01f, -5.83003536e-02f, -3.52164470e-02f, 2.95726601e-02f, 1.99937597e-01f, 1.30645066e-01f, -4.84553874e-02f, -5.36673069e-02f,
  4.71696965e-02f, 1.53892664e-02f, 2.12843604e-02f, -3.61148364e-32f, -6.25592563e-03f, 7.63367489e-02f, 1.13360975e-02f, 2.80558974e-01f, -1.34278849e-01f, 1.40515104e-01f,
  1.26032168e-02f, -1.15481287e-01f, 2.54038304e-01f, 9.11176279e-02f, 1.94843322e-01f, -1.61828965e-01f, 1.07379816e-01f, 1.84247389e-01f, 3.60894538e-02f, -4.20345515e-02f,
  -1.29146636e-01f, 2.91138530e-01f, -8.32386315e-02f, 5.27882203e-02f, 2.67363489e-01f, -3.85540351e-02f, -4.43029180e-02f, 1.13151252e-01f, 1.75614372e-01f, -5.14666326e-02f,
  -5.25562903e-14f, 2.44602235e-03f, -4.79673371e-02f, -2.94778794e-02f, -9.14288759e-02f, 2.93937802e-01f, -2.25966088e-02f, -9.84860305e-03f, -5.96301071e-02f, -7.80497938e-02f,
  6.58552721e-02f, -1.09042168e-01f, 1.36160403e-02f, 4.36677150e-02f, 9.70242545e-02f, -6.76834509e-02f, 3.93095873e-02f, -3.26444991e-02f, 1.10005260e-01f, 1.55316489e-02f,
  -1.92858391e-02f, 2.61465888e-02f, -1.26599614e-02f, -6.54075816e-02f, -1.07885353e-01f, -8.78855661e-02f, -1.18473992e-01f, 6.01219423e-02f, 7.74994269e-02f, 1.04640320e-01f,
  3.96720320e-02f, -3.14793666e-03f, -7.86119998e-02f, 6.36847913e-02f, -9.56638604e-02f, -7.84804695e-04f, 3.81680131e-02f, -1.91962654e-33f, 1.18152462e-01f, 8.70045722e-02f,
  2.57294923e-02f, 7.57737532e-02f, 1.23131908e-01f, -7.55146891e-02f, 1.23720296e-01f, -2.87800692e-02f, -4.48104180e-02f, -1.00725442e-01f, -1.77163035e-01f, -9.45755243e-02f,
  1.73992440e-01f, -6.17890283e-02f, 2.10861608e-01f, 1.69125106e-02f, -9.52137336e-02f, -3.04265618e-02f, -7.36165121e-02f, -1.93477385e-02f, -2.81478707e-02f, 5.79502061e-02f,
  6.04880936e-02f, -9.13825352e-03f, 6.47113398e-02f, 9.60350260e-02f, 9.36206120e-15f, -2.78129037e-02f, 2.25604281e-01f, -4.11943085e-02f, 7.91667849e-02f, 1.69671446e-01f,
  -4.63641584e-02f, -3.39335129e-02f, 1.21916644e-02f, 2.59587280e-02f, 8.53166804e-02f, -1.97211225e-02f, -2.59665065e-02f, 2.26971619e-02f, 4.93943058e-02f, -1.29469275e-01f,
  1.19526656e-02f, -7.42615461e-02f, -4.57301512e-02f, 2.85326131e-02f, -6.17638081e-02f, 5.67547884e-03f, -4.27223109e-02f, 4.08500582e-02f, 2.17653438e-03f, -1.04222102e-02f,
  -1.40123636e-01f, -7.03724381e-03f, 3.10795405e-03f, -6.06760718e-02f, 2.18284987e-02f, 8.17818642e-02f, 1.20163016e-01f, 3.16743031e-02f, 8.81926045e-02f, 1.41863391e-01f,
  3.76124657e-03f, 7.57483199e-31f, 9.06455051e-03f, 1.02569431e-01f, 1.47815555e-01f, -4.59482335e-02f, 4.63518351e-02f, 8.36584643e-02f, 1.88818469e-03f, 1.60419658e-01f,
  1.56392325e-02f, 4.80155721e-02f, 1.17055446e-01f, 2.65312761e-01f, -4.71016355e-02f, -4.91309501e-02f, -2.90170927e-02f, 1.27703130e-01f, 2.44170800e-01f, -6.51625916e-02f,
  1.77215651e-01f, 1.01373307e-01f, -6.13543056e-02f, 1.17542163e-01f, 9.19473097e-02f, 7.67839625e-02f, -8.38429406e-02f, 1.36834875e-01f, 1.66113461e-14f, 4.45979610e-02f,
  5.46353683e-02f, 8.42220057e-03f, 4.48072888e-02f, -8.68781209e-02f, 1.83745418e-02f, 5.00547653e-03f, 4.36486444e-03f, -4.75390926e-02f, -3.96177284e-02f, 7.45189711e-02f,
  -9.60996822e-02f, -1.38770009e-03f, 7.90733919e-02f, 1.28390595e-01f, 3.80107425e-02f, -9.45139602e-02f, -2.17550278e-01f, 4.46435437e-02f, -6.96419254e-02f, 9.74701867e-02f,
  1.20153531e-01f, -3.84942479e-02f, -1.27686799e-01f, -2.17445523e-01f, 1.44887373e-01f, 1.23174563e-01f, 1.88888144e-02f, 6.24169968e-03f, 2.49783844e-01f, 1.12849578e-01f,
  9.49035138e-02f, 2.86548841e-03f, 3.86942923e-02f, -1.49948046e-01f, 1.40702993e-01f, -8.13332723e-31f, 8.60164780e-03f, -1.59234647e-02f, -9.17720273e-02f, 1.00763187e-01f,
  5.88753633e-02f, 1.25581101e-01f, -2.42527410e-01f, 1.49831489e-01f, -2.94549055e-02f, 1.29054099e-01f, 7.85817057e-02f, -8.35706964e-02f, -5.25611639e-02f, -2.74610847e-01f,
  2.22872019e-01f, 6.59480989e-02f, -2.82091163e-02f, 2.09723860e-01f, -2.06576139e-01f, -5.46795912e-02f, 1.72586679e-01f, 7.82573298e-02f, -1.80747345e-01f, 8.69528949e-02f,
  3.83487463e-01f, -1.85491472e-01f, 2.20590080e-13f, 3.56388569e-01f, -6.74831793e-02f, -2.07821466e-02f, 1.18950635e-01f, -2.72951229e-03f, -3.92095409e-02f, -1.02586932e-01f,
  1.44226760e-01f, -1.84714254e-02f, 1.39575694e-02f, -1.42785888e-02f, 1.01165526e-01f, -1.39167551e-02f, 1.13527350e-01f, 1.05652548e-01f, -7.95715302e-02f, -2.07506027e-02f,
  2.58928448e-01f, 3.43050761e-03f, -1.03381649e-01f, 1.24759771e-01f, 1.08490199e-01f, -4.96967249e-02f, -1.52180921e-02f, 6.91057593e-02f, 4.39748242e-02f, -7.81779215e-02f,
  5.45570860e-04f, 2.94614792e-01f, 1.15862913e-01f, 2.30059363e-02f, -2.39263892e-01f, 1.07403114e-01f, -1.63456738e-01f, -8.91048759e-02f, 5.32770231e-02f, 2.19787939e-31f,
  -7.87119195e-02f, 1.04229689e-01f, 2.61846674e-03f, 1.02267131e-01f, 1.17941335e-01f, 1.83220282e-02f, 8.74977559e-02f, -2.33870059e-01f, 1.49576580e-02f, 9.86779854e-02f,
  1.71149354e-02f, -1.46819279e-01f, 2.45932326e-01f, 1.10457622e-01f, 3.25752087e-02f, -2.41119857e-03f, -9.72129032e-02f, 2.85343200e-01f, -6.31504506e-02f, 5.05180955e-02f,
  3.09825361e-01f, 3.99417513e-06f, 4.68555503e-02f, -5.04859239e-02f, 1.34727910e-01f, 4.06903327e-02f, 1.06004018e-13f, -1.00933075e-01f, 1.60834655e-01f, -7.47024789e-02f,
  9.48773846e-02f, 2.47493476e-01f, -1.08646611e-02f, -7.96232074e-02f, -4.78978679e-02f, -7.72971474e-03f, -1.29097020e-02f, -7.16898665e-02f, -6.66783229e-02f, 9.90832373e-02f,
  3.78003791e-02f, 5.57940789e-02f, -1.08529322e-01f, -5.58177382e-02f, -1.51597559e-01f, 1.41714856e-01f, -1.77068681e-01f, 3.34783942e-02f, 3.57366279e-02f, -1.72590971e-01f,
  -1.07498810e-01f, -1.32559165e-01f, 3.14206607e-03f, 1.83549359e-01f, 2.21589133e-01f, -4.12293226e-02f, 1.17709421e-01f, -6.96820393e-02f, 2.43517514e-02f, 9.13360715e-02f,
  -3.93123552e-02f, -9.45815817e-02f, 6.40700161e-02f, 2.64529769e-31f, -6.84648603e-02f, 1.15742698e-01f, -1.35386273e-01f, -9.08459350e-02f, 1.56051576e-01f, 2.26761457e-02f,
  -2.78184954e-02f, 7.43653551e-02f, -3.05748075e-01f, 3.11707351e-02f, -6.08734079e-02f, 8.11245665e-02f, 2.85189394e-02f, -4.47455972e-01f, 2.36563101e-01f, 1.17553212e-01f,
  1.07031189e-01f, -3.35418060e-02f, -8.22121724e-02f, -4.86806855e-02f, -8.39527510e-03f, 1.88214406e-01f, -2.14787591e-02f, 7.43499249e-02f, 2.98473835e-01f, 1.87184542e-01f,
  6.60348580e-14f, 2.10334152e-01f, 1.90000474e-01f, 2.89922282e-02f, 1.15756698e-01f, -7.03632310e-02f, 6.20778203e-02f, 1.42483488e-02f, -2.13851556e-02f, 9.20169502e-02f,
  5.95525466e-02f, 1.31378502e-01f, 9.36403126e-02f, 9.80388224e-02f, 7.13581070e-02f, 3.65902521e-02f, 6.01881407e-02f, -2.62469705e-02f, -2.53609680e-02f, -7.07189888e-02f,
  1.46566465e-01f, -1.26093224e-01f, 1.17862813e-01f, 1.28814489e-01f, -3.69725603e-04f, 1.36973962e-01f, 9.76232514e-02f, -1.68155208e-01f, -1.43629506e-01f, -6.43518865e-02f,
  1.15332387e-01f, 5.42887896e-02f, 8.50746259e-02f, -1.20159619e-01f, 7.48140514e-02f, -6.09938130e-02f, 2.18021393e-01f, -2.99102727e-31f, 1.05460674e-01f, 2.62526367e-02f,
  1.02409132e-01f, 3.44526500e-01f, -1.54772550e-01f, 1.44842908e-01f, 1.71942994e-01f, -2.06294432e-02f, 2.68785298e-01f, -1.09540028e-02f, 1.26279473e-01f, -8.20105746e-02f,
  -3.11170355e-03f, 5.69435880e-02f, 1.51558340e-01f, -1.10784434e-01f, -1.21429108e-01f, 7.04682544e-02f, -7.49560744e-02f, 3.76420990e-02f, 8.55251551e-02f, -6.91725314e-02f,
  -5.06913178e-02f, 1.38207629e-01f, 2.29358360e-01f, -1.22468293e-01f, -1.30911774e-13f, 4.89431135e-02f, 4.30762954e-02f, -5.25220446e-02f, 1.49582252e-02f, 2.70584553e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -2.62178201e-02f, 8.34449828e-02f, 1.09335139e-01f, -2.82347668e-02f, -1.54951699e-02f, 6.10025181e-03f, 3.61476006e-04f, 1.21211959e-02f, 4.96015837e-03f, -2.28186101e-02f,
  -1.18324269e-38f, 3.32673602e-02f, 5.60752377e-02f, 4.80860211e-02f, 4.81582545e-02f, 9.37405415e-03f, -4.46387678e-02f, 3.43805901e-03f, 6.70780167e-02f, 6.87481761e-02f,
  2.47179512e-02f, 3.22742760e-02f, -2.86494549e-02f, -2.29396652e-02f, 1.82523374e-02f, -5.91183789e-02f, -1.15189832e-15f, 1.68665592e-02f, 7.64160752e-02f, 9.87348706e-02f,
  -5.37484838e-03f, -6.66306447e-03f, 4.44215834e-02f, 1.48543403e-01f, 2.85142418e-02f, 8.39329325e-03f, 1.71464700e-02f, 6.14306070e-02f, 3.29953320e-02f, 5.39604276e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.02210239e-01f, 1.45177105e-02f, -1.02889016e-01f, -2.09391173e-02f, -9.18800458e-02f, -7.34863505e-02f, 3.20853256e-02f, 4.98312339e-03f, 6.08194396e-02f, 2.55289879e-02f,
  8.03976133e-02f, -3.04495990e-02f, -2.16346681e-01f, -8.59179944e-02f, -3.63698825e-02f, -2.22409844e-01f, 5.67055419e-02f, -4.35039923e-02f, -1.17163599e-01f, -1.07280843e-01f,
  -2.44763106e-01f, -9.66796055e-02f, -2.27270395e-01f, -1.73875526e-01f, -2.47028813e-01f, 1.32881254e-01f, -1.39699116e-01f, 7.47350603e-02f, -2.77584285e-01f, 2.04970971e-01f,
  1.13814678e-02f, -1.30328909e-01f, -2.27999136e-01f, -4.51919623e-02f, -1.01901496e-17f, -1.71033721e-02f, 6.36436343e-02f, 1.59389451e-01f, -3.14384028e-02f, -4.66685772e-01f,
  7.46854022e-02f, 2.54330207e-02f, 1.07113928e-01f, -3.84437174e-01f, 4.74711694e-02f, 9.64964405e-02f, -2.51075685e-01f, -3.34010065e-01f, 2.84126461e-01f, 1.15433969e-01f,
  6.94153082e-16f, -9.70573723e-02f, -2.16054723e-01f, -2.04317808e-01f, 1.74491834e-02f, 1.80833668e-01f, -3.25446635e-01f, 9.60984901e-02f, 1.68895513e-01f, -2.13987455e-01f,
  -1.60663024e-01f, 1.00448437e-01f, -1.27103269e-01f, 1.84690610e-01f, 1.57238856e-01f, 7.01058889e-03f, 1.95854548e-02f, -8.72549936e-02f, 9.03157368e-02f, 2.29104818e-03f,
  2.68464182e-02f, 3.71720344e-02f, 1.30771557e-02f, -4.08482179e-02f, -5.41024096e-02f, 1.31553620e-01f, -1.25798017e-01f, 1.57313257e-01f, -2.98294365e-01f, 7.01292753e-02f,
  -1.50894374e-01f, 6.60238266e-02f, -3.75075527e-02f, 1.95551470e-01f, 2.88573354e-01f, -1.93331897e-01f, -1.20893031e-01f, -1.78040266e-02f, 4.94015664e-02f, -4.25088257e-02f,
  -3.63873124e-01f, -2.30140332e-02f, -3.91371101e-01f, -1.81792378e-02f, -7.21164607e-03f, 7.29146376e-02f, 1.03898555e-01f, -2.86444515e-01f, -2.38616805e-15f, 9.90711972e-02f,
  1.04008771e-01f, -1.54495761e-01f, -2.21945196e-01f, 3.45191270e-01f, 1.67515337e-01f, 3.08181178e-02f, 1.92443833e-01f, -7.45232627e-02f, 3.57228965e-02f, 5.37897348e-02f,
  -1.53135523e-01f, -6.19296432e-01f, 1.40631869e-01f, 2.30017662e-01f, -1.19477452e-16f, 3.83546092e-02f, -7.12664938e-03f, 1.38604999e-01f, 6.45877868e-02f, 5.69941849e-02f,
  -5.31761386e-02f, 5.78431487e-02f, 1.48688018e-01f, -2.67726313e-02f, -1.63599551e-02f, -9.36615020e-02f, -5.10970056e-02f, -3.95708159e-02f, -1.25511706e-01f, -2.00822622e-01f,
  -4.84689213e-02f, 1.20542161e-01f, -6.39466420e-02f, -2.35915691e-01f, -1.27682194e-01f, -1.75562486e-01f, 1.85957141e-02f, 8.19052197e-03f, 1.29224434e-01f, 8.19030926e-02f,
  1.90481376e-02f, 5.46017699e-02f, 6.57620281e-02f, -3.12261283e-02f, 1.73688620e-01f, -3.79089639e-02f, 6.81726262e-02f, 2.68462867e-01f, -9.81518347e-03f, 1.98152304e-01f,
  6.83893487e-02f, 2.20102042e-01f, 2.22321242e-01f, -6.31377473e-02f, -3.64323229e-01f, -4.69620252e-04f, -1.22623280e-01f, -1.91926688e-01f, 1.26207564e-02f, 1.31014198e-01f,
  1.47652030e-01f, -2.83807516e-01f, 6.08418224e-18f, 1.57952905e-02f, -1.25719801e-01f, -1.80783942e-01f, -2.70581126e-01f, -5.93047924e-02f, 5.75003261e-03f, -2.45858405e-06f,
  6.26252443e-02f, 1.88643649e-01f, 1.77736446e-01f, -2.70917237e-01f, -7.54477233e-02f, 3.34464163e-01f, 9.02957655e-03f, 1.94597878e-02f, 8.36951766e-18f, 1.19686097e-01f,
  -4.35055643e-02f, 1.76787496e-01f, 3.54646184e-02f, -1.30896211e-01f, 2.15879291e-01f, -4.17474300e-01f, 4.71220687e-02f, 5.15906736e-02f, -4.14374292e-01f, -5.32677434e-02f,
  9.54900607e-02f, -5.04878342e-01f, 5.82701042e-02f, 1.11107185e-01f, 1.18281223e-01f, 1.94086865e-01f, -5.44059575e-02f, 4.21244465e-02f, 5.02311811e-03f, -1.18263185e-01f,
  7.48256315e-03f, -8.27175304e-02f, 1.72561318e-01f, 5.59349498e-03f, -1.38117880e-01f, -1.29841357e-01f, 1.91454172e-01f, 1.93005696e-01f, -1.63640574e-01f, -1.22772157e-01f,
  -2.23729640e-01f, -1.76996171e-01f, -2.78104365e-01f, 1.38350293e-01f, -1.08911298e-01f, -6.78402707e-02f, -8.82935943e-04f, 8.00535679e-02f, 9.30263475e-02f, -3.23353499e-01f,
  1.43769637e-01f, 7.40378425e-02f, -8.64163885e-05f, -3.41349214e-01f, -3.09647888e-01f, -1.10472575e-01f, 4.07343890e-26f, -2.08640829e-01f, -2.77634472e-01f, 2.44140208e-01f,
  -6.19726293e-02f, -1.68578029e-01f, -2.03215852e-01f, 5.65431952e-01f, -1.97506621e-01f, -3.75453264e-01f, 2.75565870e-02f, 4.35682833e-02f, 6.44414797e-02f, -3.26391518e-01f,
  -3.58154744e-01f, -2.92009652e-01f, -2.38553235e-15f, -1.09097697e-01f, -4.22680318e-01f, 9.95478183e-02f, -2.82838047e-01f, -3.29922922e-02f, -3.44020396e-01f, 2.19497502e-01f,
  -1.30767658e-01f, -4.37057436e-01f, 1.54724807e-01f, 7.86276609e-02f, -2.62581825e-01f, 1.69256449e-01f, 1.36851519e-01f, -1.23091273e-01f, 9.58149359e-02f, -1.40474796e-01f,
  2.50064284e-01f, 2.20723420e-01f, -1.56049550e-01f, -3.81366722e-02f, 4.87523526e-02f, -1.30911898e-02f, -5.16936071e-02f, 1.21579975e-01f, -2.41425950e-02f, 3.82451899e-02f,
  -1.75136894e-01f, 1.13919057e-01f, 1.17180664e-02f, 1.95694968e-01f, 2.62564182e-01f, -6.55687079e-02f, -1.26145273e-01f, 1.70047283e-01f, -1.03136599e-01f, -4.92810877e-03f,
  -3.00640017e-01f, -9.82038826e-02f, 1.92242563e-01f, 3.22691456e-04f, 2.01310068e-01f, 1.51828825e-01f, -2.48894934e-02f, 1.16973236e-01f, -1.08144969e-01f, 8.69388580e-02f,
  3.04843499e-14f, -1.98094293e-01f, 2.64360029e-02f, 2.16858923e-01f, 2.10320503e-01f, -5.93290091e-01f, -2.15026382e-02f, -5.15336514e-01f, -1.28641531e-01f, 7.23387673e-02f,
  1.20312050e-01f, 2.91253421e-02f, 2.14551035e-02f, 9.07414034e-03f, -4.63358521e-01f, -1.71504229e-01f, 2.06631146e-15f, 2.60882750e-02f, -1.69440843e-02f, -1.88662991e-01f,
  3.17159928e-02f, 8.87404904e-02f, -2.10812911e-01f, -2.85356455e-02f, 2.37679463e-02f, 2.09928714e-02f, -2.26753160e-01f, 1.12877257e-01f, -1.54779255e-01f, -6.86192513e-03f,
  9.71533507e-02f, 4.26089950e-02f, -6.58433735e-02f, 1.96543783e-01f, 9.46533531e-02f, -1.03199482e-01f, -1.14238493e-01f, 2.55090237e-01f, 5.86838052e-02f, -2.10278258e-01f,
  5.46532869e-02f, -2.44798556e-01f, 8.55243206e-02f, -1.68215498e-01f, -1.16575271e-01f, 2.81426515e-02f, -1.41154930e-01f, -8.33179280e-02f, 6.88011572e-02f, -4.80142497e-02f,
  4.67418805e-02f, -2.23391384e-01f, -1.42620310e-01f, -1.80089287e-02f, 5.90239353e-02f, -4.92819510e-02f, 6.92506060e-02f, 1.25730768e-01f, 9.25615951e-02f, -1.55948579e-01f,
  -5.67762600e-03f, 2.75473180e-03f, 1.20089399e-02f, 5.63065335e-02f, 4.19979942e-13f, 1.08123720e-02f, 1.21516339e-03f, 9.75968465e-02f, -1.79304183e-02f, 5.34625590e-01f,
  1.14316754e-01f, -6.41150624e-02f, -5.40310191e-03f, -1.06004000e-01f, -8.02954361e-02f, -1.56302582e-02f, -8.46454948e-02f, -3.10364157e-01f, 6.88379034e-02f, -2.23798379e-01f,
  -6.25268763e-16f, 6.75696060e-02f, 1.98085368e-01f, -1.34596199e-01f, 1.13886558e-01f, 3.34612615e-02f, -1.47726595e-01f, -1.19803704e-01f, -9.61191729e-02f, -1.61719148e-03f,
  -1.45786539e-01f, -4.26496148e-01f, -1.19772024e-01f, 1.67572618e-01f, 7.97309130e-02f, 1.64460137e-01f, -7.47503936e-02f, -7.39545599e-02f, 2.21363902e-01f, 8.83126333e-02f,
  -7.25337416e-02f, -1.74090475e-01f, 4.12337556e-02f, 9.17913765e-02f, -1.13241635e-01f, 9.36489329e-02f, 2.51900032e-02f, -8.52685869e-02f, 8.43491256e-02f, 1.78976282e-01f,
  1.10073999e-01f, 8.00719634e-02f, 1.21894158e-01f, 1.60884127e-01f, -1.62242174e-01f, -8.18445757e-02f, 6.48439750e-02f, -1.22507833e-01f, 1.38099894e-01f, -1.35086417e-01f,
  -6.73865825e-02f, -5.62148057e-02f, -9.07500216e-04f, -4.92407382e-02f, 1.92599781e-02f, -2.30713580e-02f, 7.01173618e-02f, -1.72638446e-02f, -2.63843721e-12f, 4.76576127e-02f,
  -2.59957779e-02f, -2.53338128e-01f, 1.48354545e-02f, 6.20694697e-01f, -1.89124674e-01f, -9.54877687e-05f, -3.57217789e-01f, 9.63175744e-02f, -3.37425768e-01f, -3.23478699e-01f,
  -1.97426468e-01f, 2.24416569e-01f, -1.86847094e-02f, -3.51204962e-01f, 6.69043929e-17f, -6.68051019e-02f, 2.02304840e-01f, -4.64486368e-02f, 2.49407440e-02f, -3.08871567e-01f,
  1.44119814e-01f, -4.09327626e-01f, -3.07528257e-01f, 7.90696517e-02f, -9.57868844e-02f, -3.16797376e-01f, 1.62350446e-01f, -2.83632070e-01f, -3.71038285e-03f, 1.57939121e-01f,
  6.51171356e-02f, -6.57814071e-02f, -1.00713760e-01f, -6.09960184e-02f, 1.43990517e-01f, -1.26725122e-01f, 3.63544561e-02f, -1.98170558e-01f, -2.73524667e-03f, 6.38601109e-02f,
  8.26477781e-02f, 2.08202302e-01f, -2.26320341e-01f, 2.99747586e-02f, 1.20802537e-01f, 1.78316817e-01f, -9.89027023e-02f, -8.43538418e-02f, -6.95982724e-02f, 1.70606207e-02f,
  2.95143336e-01f, -1.19770467e-01f, -1.98006123e-01f, 1.67948738e-01f, 1.50306642e-01f, -3.49836916e-01f, -1.59949854e-01f, 2.74887793e-02f, -3.24153970e-03f, -1.77536741e-01f,
  -1.76266968e-01f, 1.53450221e-01f, -4.91998693e-40f, -1.44095063e-01f, -4.13223058e-01f, 1.22035101e-01f, 1.05026513e-01f, -1.66853800e-01f, -1.63511381e-01f, 3.22862625e-01f,
  -3.22251648e-01f, -2.95794904e-01f, 1.08156297e-02f, -2.39850894e-01f, -1.78780332e-01f, 9.07192603e-02f, 4.58358824e-01f, -8.13102052e-02f, -7.72211192e-16f, -2.25278482e-01f,
  -2.46543780e-01f, -2.55602777e-01f, -1.68215409e-01f, 2.67247409e-02f, -1.21531583e-01f, -3.60934399e-02f, -7.31756762e-02f, -1.00335948e-01f, 2.96102464e-01f, -1.59231827e-01f,
  2.22219318e-01f, 7.20055699e-02f, 1.43507160e-02f, -5.41915596e-02f, 1.11704636e-02f, 3.55854034e-02f, 1.76944043e-02f, 5.18974923e-02f, 1.04317285e-01f, 1.02306329e-01f,
  -1.59051478e-01f, 3.83723676e-02f, 4.90073413e-02f, -8.79683867e-02f, 4.15321775e-02f, -6.08144104e-02f, -7.47469589e-02f, -1.32524416e-01f, 1.55012712e-01f, 4.76778820e-02f,
  -6.83364421e-02f, -8.55021328e-02f, -1.23567112e-01f, 2.14251399e-01f, 3.16346943e-01f, -6.55669346e-02f, -1.67183891e-01f, -5.72606847e-02f, -4.77123857e-02f, -3.91792178e-01f,
  -1.53815979e-02f, 7.47217461e-02f, -1.78602431e-03f, 3.33417207e-02f, 3.32851149e-02f, -1.20712318e-01f, 4.93795158e-40f, 1.09069146e-01f, -1.99639663e-01f, -2.21242517e-01f,
  -2.56495893e-01f, -3.26499104e-01f, 4.52439263e-02f, -7.68739730e-02f, 1.04011081e-01f, -2.93749776e-02f, 5.58487810e-02f, -2.34438643e-01f, 2.37777904e-01f, 9.54107270e-02f,
  2.87991256e-01f, -8.31414089e-02f, 9.22127183e-17f, 1.40360191e-01f, -3.13204765e-01f, -9.29204002e-02f, 8.73366892e-02f, -1.47863835e-01f, 1.15150027e-01f, -2.15013288e-02f,
  1.15799256e-01f, -7.14138299e-02f, 3.89061540e-01f, 1.66977018e-01f, 2.35808939e-01f, -9.38343406e-02f, -2.20728070e-01f, 1.87186480e-01f, -1.09505102e-01f, -1.33118212e-01f,
  -1.82830945e-01f, -1.56137973e-01f, -6.50710985e-02f, 1.24975793e-01f, 3.36071290e-02f, 1.25715569e-01f, -5.16850464e-02f, 1.03055716e-01f, -1.23132959e-01f, 7.87012354e-02f,
  7.59693608e-02f, 7.65047073e-02f, 2.73654312e-01f, 2.08255500e-01f, -1.07847467e-01f, -1.18288539e-01f, 2.87453294e-01f, 2.34590068e-01f, 1.13196962e-01f, -1.63829580e-01f,
  7.67698064e-02f, 1.17541596e-01f, -4.28962847e-03f, -3.36334631e-02f, -3.16403508e-02f, -3.14544767e-01f, 3.38292979e-02f, -5.53401262e-02f, -2.41054147e-02f, 1.96229815e-01f,
  1.86293214e-13f, -3.36982340e-01f, 1.37842000e-01f, 6.40125945e-02f, 1.88486546e-01f, -5.69616079e-01f, -2.49693394e-02f, -1.59733921e-01f, -2.94027418e-01f, 9.24860239e-02f,
  1.42012894e-01f, -2.87559003e-01f, -3.97256374e-01f, 3.15100729e-01f, 2.27811784e-01f, -1.83335900e-01f, -1.76452064e-16f, 9.69938040e-02f, 1.83152035e-02f, -2.45321035e-01f,
  4.04176190e-02f, -1.25835566e-02f, -1.15596242e-02f, -3.37164760e-01f, -1.77975804e-01f, 3.26674730e-02f, -2.51548707e-01f, -3.81492615e-01f, -2.16052830e-02f, -2.04898313e-01f,
  2.56333803e-03f, 4.25175560e-04f, -6.80829734e-02f, 9.45879743e-02f, 4.97986116e-02f, 5.16814813e-02f, 1.92197368e-01f, 2.00787410e-02f, 2.01413766e-01f, 6.95157563e-03f,
  -8.21344480e-02f, -3.79565358e-02f, -1.85236230e-01f, -6.97793625e-03f, 2.59095281e-01f, -1.11482672e-01f, -1.58488646e-01f, -2.21890911e-01f, -1.59856364e-01f, -4.65788059e-02f,
  1.13274254e-01f, -2.17809632e-01f, -1.04092121e-01f, 2.12281197e-01f, -3.59979451e-01f, -7.54097179e-02f, -1.96227022e-02f, -2.91341394e-01f, 4.14174609e-02f, 6.19135648e-02f,
  -1.14951876e-03f, -7.38043338e-02f, -1.90730169e-02f, -3.41486663e-01f, 4.92941767e-40f, 9.81531888e-02f, 6.17399551e-02f, 9.63350385e-02f, -4.05328944e-02f, -2.28697971e-01f,
  -2.00274307e-02f, -2.86341906e-01f, 1.86625972e-01f, 2.83603314e-02f, -7.14322850e-02f, 2.12999806e-03f, 2.31536806e-01f, -3.51175755e-01f, -7.01516092e-01f, 1.26712203e-01f,
  2.03866156e-15f, 2.61705279e-01f, -1.08574912e-01f, 3.49542141e-01f, 1.23115517e-01f, -2.31713757e-01f, 4.00760695e-02f, 2.28241190e-01f, -1.57200992e-01f, -2.18733832e-01f,
  -2.29818046e-01f, 8.05335566e-02f, -3.45003963e-01f, 7.22386315e-02f, -8.52046087e-02f, 7.82311261e-02f, -9.75401700e-02f, -7.64370710e-02f, -4.79211919e-02f, -1.79989487e-02f,
  1.45921543e-01f, -3.59719396e-02f, 4.14711162e-02f, -4.40063683e-04f, 5.95152155e-02f, 1.43471345e-01f, 1.25046358e-01f, -5.39355986e-02f, 5.37204668e-02f, 9.65051353e-02f,
  -9.60901082e-02f, -2.03433380e-01f, 1.32632907e-02f, -2.60453988e-02f, 5.72098531e-02f, -1.23626791e-01f, 4.30930257e-02f, -1.28492400e-01f, -2.07654983e-01f, -8.91732424e-02f,
  8.48378763e-02f, -2.33735576e-01f, 1.74983740e-01f, -1.62556142e-01f, -1.41249634e-02f, -3.05140644e-01f, -3.19398604e-02f, -7.00132623e-02f, 3.18429290e-27f, 9.80800018e-02f,
  -2.14549284e-02f, 1.66669697e-01f, -2.17881855e-02f, 2.28360444e-01f, -2.65588015e-01f, -9.00985599e-02f, -8.28686357e-02f, 3.22680995e-02f, -1.62561998e-01f, -2.86688417e-01f,
  2.33526126e-01f, 1.55414954e-01f, -5.38196027e-01f, -2.18889087e-01f, 7.00038982e-17f, -1.16060331e-01f, 1.88806638e-01f, -3.67751606e-02f, -1.19736083e-01f, -2.94142693e-01f,
  1.98802516e-01f, 9.13000554e-02f, -1.84764683e-01f, 7.47925565e-02f, 9.87240002e-02f, -3.07598770e-01f, -2.59116501e-01f, 6.52793199e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.75612960e-02f, 6.31743893e-02f, -7.18571693e-02f, 9.56529602e-02f, 1.16152816e-01f, -1.27541646e-02f, -8.01142454e-02f, -1.44780368e-01f, 2.27666497e-02f, 5.29975034e-02f,
  8.81204456e-02f, -5.01669794e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    