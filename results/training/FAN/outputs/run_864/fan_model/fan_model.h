/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.16412798e-01f, 1.80276170e-01f, 5.55331290e-01f, 3.60145159e-02f, 1.56943083e-01f, 1.29898593e-01f, 3.22513551e-01f, 1.12349808e-01f, -9.01352018e-02f, -2.20363354e-03f,
  -1.64075106e-01f, -1.34048387e-01f, 5.04371300e-02f, 7.85492882e-02f, 2.47736156e-01f, 4.76200044e-01f, 4.50150192e-01f, 3.29157740e-01f, 2.34148890e-01f, 8.45442177e-04f,
  -3.37421484e-02f, 6.95428923e-02f, 1.89984798e-01f, 9.98382792e-02f, -1.19850568e-01f, -9.40816943e-03f, 1.00881934e-01f, 2.88755540e-02f, -7.94454217e-02f, 7.79124424e-02f,
  2.27071777e-01f, 2.09739223e-01f, -6.20474555e-02f, -6.40508682e-02f, -7.29908235e-03f, -2.13580430e-02f, 5.75139299e-02f, 2.61491034e-02f, -1.34554788e-01f, -3.86352278e-02f,
  -1.43430149e-02f, -5.90185709e-02f, -1.03134394e-03f, -8.03615898e-02f, 8.57811794e-02f, 6.09502196e-02f, -6.58455193e-02f, 1.23957947e-01f, 1.06893025e-01f, 3.73628512e-02f,
  -2.42077336e-02f, -4.51802835e-02f, 3.02426219e-02f, -3.47226858e-02f, 7.40806013e-02f, 2.04006732e-02f, 5.42350188e-02f, -3.21575478e-02f, -2.94010080e-02f, 2.45297644e-02f,
  1.97174530e-02f, 5.20711653e-02f, 1.05774812e-02f, -1.11057691e-01f, -1.74146984e-02f, -9.55297276e-02f, 2.36779843e-02f, -2.88963243e-02f, 4.60858122e-02f, -3.94274220e-02f,
  -3.04905605e-02f, -1.09120850e-02f, 1.32757174e-02f, 5.79878837e-02f, 1.65646784e-02f, 1.80275552e-02f, -2.99157742e-02f, 6.37848973e-02f, -4.29336950e-02f, 1.13604907e-02f,
  -2.40377001e-02f, -9.66932178e-02f, -2.41803341e-02f, 1.12514170e-02f, 3.48159438e-03f, 2.59074047e-02f, 1.64057855e-02f, -2.09893752e-02f, 2.30844934e-02f, 2.52979975e-02f,
  -2.72201985e-01f, 4.15135771e-02f, 8.08704346e-02f, 1.73840299e-02f, 1.23910001e-02f, -8.12355056e-02f, -8.94332156e-02f, -3.85100804e-02f, -7.00978488e-02f, -6.87346444e-04f,
  -4.21217689e-03f, 2.36440692e-02f, 4.48796004e-02f, 8.34157597e-03f, -1.12165296e-02f, -4.16896045e-02f, -5.60177043e-02f, -5.78998923e-02f, -9.29680467e-02f, -8.66790414e-02f,
  -4.03091796e-02f, 5.00411494e-03f, -2.48797070e-02f, 3.78996739e-03f, -1.09270737e-01f, -5.39273657e-02f, -5.23653142e-02f, -5.86861596e-02f, 1.13764420e-01f, -5.87048531e-02f,
  2.73203760e-01f, 1.67871684e-01f, 3.83909903e-02f, 5.27727865e-02f, 4.15845364e-02f, -2.54004728e-02f, -7.98577536e-03f, -1.45355761e-01f, -1.42660737e-01f, 2.13716533e-02f,
  1.46467341e-02f, -5.14756292e-02f, -3.12699899e-02f, 3.07325907e-02f, -3.05258837e-02f, -5.41006252e-02f, 1.49083706e-02f, 7.54795149e-02f, -8.13448802e-02f, 8.60627089e-03f,
  6.09152876e-02f, 7.52598941e-02f, 1.30076155e-01f, -1.29870251e-02f, 8.67834538e-02f, 5.28131276e-02f, -6.97533786e-02f, 1.60380080e-01f, 1.04450494e-01f, 1.70884565e-01f,
  3.67816389e-02f, 2.58589387e-01f, -1.03118733e-01f, 5.70188537e-02f, -5.06436527e-02f, -5.42461239e-02f, 2.61868220e-02f, -1.44955395e-02f, 6.17195070e-02f, -5.89959174e-02f,
  5.58303259e-02f, 3.21008004e-02f, 4.63637486e-02f, -7.55508756e-03f, 4.53040760e-04f, 4.37317742e-03f, 7.76123032e-02f, -1.30095733e-02f, 1.70399565e-02f, 1.29461810e-01f,
  1.68208852e-01f, 8.48264918e-02f, 9.59844589e-02f, 6.10799529e-02f, 1.85139440e-02f, -1.90428533e-02f, 1.25841990e-01f, 1.33749738e-01f, 7.08176717e-02f, 9.92255807e-02f,
  -2.36174967e-02f, -3.93804088e-02f, 3.27406041e-02f, -4.30575572e-02f, 4.05394807e-02f, 5.22611178e-02f, 6.99609965e-02f, 4.53855395e-02f, 4.95057330e-02f, -5.33072799e-02f,
  -5.16588315e-02f, -1.74987372e-02f, 4.02943604e-02f, 3.34499702e-02f, -3.56273353e-02f, -3.68472934e-02f, 9.00838599e-02f, -3.57947461e-02f, -2.30672080e-02f, 4.65764105e-02f,
  7.81268580e-04f, 9.77152810e-02f, 4.14685626e-03f, 7.61021525e-02f, -3.37173454e-02f, -3.29012349e-02f, 2.45016348e-02f, -1.24620669e-01f, -5.32245710e-02f, -7.75708035e-02f,
  -2.25391626e-01f, 1.56533776e-03f, 4.30320129e-02f, 3.77256535e-02f, 4.46966477e-03f, -6.90636737e-03f, 7.61989923e-03f, 3.60149369e-02f, -1.12259332e-02f, 4.21362743e-02f,
  -1.95343886e-02f, -5.80265857e-02f, 5.07825911e-02f, -1.19549688e-02f, -6.90572411e-02f, 6.32724306e-03f, -7.24609643e-02f, -4.65404317e-02f, -6.09890670e-02f, 3.81114595e-02f,
  -1.01567544e-01f, -5.64085171e-02f, -7.96616748e-02f, -1.01073414e-01f, 9.17751342e-02f, -4.96489257e-02f, -1.39679372e-01f, -6.97216168e-02f, -7.12632015e-02f, -2.90130585e-01f,
  -3.17914575e-01f, -1.93242535e-01f, -9.08020362e-02f, -1.07838824e-01f, 1.67143047e-02f, -1.11842185e-01f, -1.86070696e-01f, -7.33219013e-02f, -6.10370710e-02f, -9.22366977e-02f,
  1.43570587e-01f, 3.04945230e-01f, 6.83492571e-02f, 4.86517623e-02f, -6.27818555e-02f, -2.85455048e-01f, -3.01513940e-01f, -1.77243039e-01f, -8.48111231e-03f, 1.31495357e-01f,
  -3.53851542e-02f, -7.65510872e-02f, -2.90573202e-02f, -7.93940723e-02f, -9.05819088e-02f, 1.13841332e-01f, -4.81559597e-02f, 3.23916855e-03f, -6.55729249e-02f, -5.46199791e-02f,
  2.28194911e-02f, 1.61189616e-01f, -3.49913277e-02f, 2.37424504e-02f, 6.72335401e-02f, -2.86459289e-02f, 1.79967773e-03f, 6.82260767e-02f, 1.05243348e-01f, -4.63612787e-02f,
  1.38077915e-01f, 1.04433306e-01f, -4.68336828e-02f, -1.87980421e-02f, 5.34089953e-02f, 5.85706010e-02f, -2.89683770e-02f, 3.75660360e-02f, -6.41006380e-02f, 6.77258298e-02f,
  5.67793995e-02f, 9.48958937e-03f, -8.53253826e-02f, 8.21646377e-02f, 9.45583638e-03f, -5.60325868e-02f, 1.06232084e-01f, 2.25033425e-02f, 2.47238837e-02f, -2.26967931e-01f,
  1.58084240e-02f, -9.68155824e-03f, 8.13071355e-02f, 4.89238417e-03f, -2.78130379e-02f, -1.29203778e-02f, 2.93602571e-02f, 8.25873052e-04f, -1.18580889e-02f, -3.94580849e-02f,
  8.17868188e-02f, 4.46321368e-02f, 1.03945797e-02f, -2.62673777e-02f, -1.08425021e-02f, -1.18737062e-02f, -6.74608648e-02f, -8.11743811e-02f, -4.29687947e-02f, -8.02138913e-03f,
  5.49299419e-02f, 5.18491818e-03f, 7.57313818e-02f, -4.23065536e-02f, -1.74518432e-02f, -1.64397582e-02f, -4.93867099e-02f, 1.48553699e-01f, -7.05140829e-02f, 2.06585005e-02f,
  -7.04155192e-02f, 1.02867909e-01f, -1.48934424e-01f, -2.58547254e-02f, -4.06719521e-02f, -4.47998717e-02f, -2.17332505e-02f, 1.62445977e-02f, 4.48536011e-04f, -6.62377151e-03f,
  -9.00012348e-03f, -9.91454720e-02f, -9.60587636e-02f, 5.81928641e-02f, -5.57616018e-02f, 4.74590585e-02f, -9.44001153e-02f, -5.06242849e-02f, 3.58853079e-02f, -8.01946372e-02f,
  -9.88051575e-03f, -1.68405861e-01f, -6.31922781e-02f, -1.31554589e-01f, -8.23700614e-03f, -1.49813041e-01f, -6.06194809e-02f, -1.05044402e-01f, -1.30640537e-01f, -4.28906530e-01f,
  1.47488371e-01f, -1.46633476e-01f, -4.37602177e-02f, -8.08288679e-02f, -6.22183345e-02f, 1.44835845e-01f, 1.99502468e-01f, 2.29090869e-01f, 2.32445467e-02f, 8.13134685e-02f,
  -5.02976589e-02f, -7.46730417e-02f, -5.64942285e-02f, -8.11316296e-02f, 4.35891524e-02f, -6.59976602e-02f, -1.71895906e-01f, -4.02055271e-02f, 2.03062713e-01f, 1.65601969e-01f,
  -3.75357792e-02f, -1.37353480e-01f, -1.02223679e-01f, -8.54122862e-02f, -2.15971172e-01f, -1.32389218e-01f, -1.73980594e-01f, -1.20973438e-01f, -3.94560657e-02f, -4.72984225e-01f,
  -1.24886734e-02f, -1.59284603e-02f, 8.89906064e-02f, 1.81584433e-02f, 4.01808731e-02f, -5.46799181e-03f, 3.20104510e-02f, -3.04816626e-02f, -2.28356794e-02f, -5.15942881e-03f,
  -1.20764710e-01f, 5.40765598e-02f, -1.10365718e-03f, -1.48658883e-02f, -2.36510318e-02f, 3.25616747e-02f, 2.87036579e-02f, -1.14600800e-01f, 1.92387868e-02f, -7.03269467e-02f,
  -7.89330006e-02f, -1.09607272e-01f, 2.42454819e-02f, 6.23521954e-02f, -3.57703753e-02f, 1.12541821e-02f, 1.07691167e-02f, 1.09205861e-02f, 2.57002600e-02f, 1.99323166e-02f,
  5.05090579e-02f, -2.90778819e-02f, -2.59996336e-02f, -2.17921399e-02f, 1.47577720e-02f, -2.60377172e-02f, -2.95802038e-02f, -6.05662027e-03f, 1.31564997e-02f, -1.75802205e-02f,
  2.09688712e-02f, -5.17257601e-02f, 2.36624107e-02f, -6.92050532e-02f, 1.29952021e-02f, -1.67183729e-03f, -3.88762616e-02f, 7.69457128e-03f, -6.50184276e-03f, -4.58396832e-03f,
  -1.38145126e-03f, 2.62891650e-02f, 2.87051946e-02f, -5.28661534e-02f, 4.99150828e-02f, -3.65088880e-02f, 2.57472936e-02f, -1.93995405e-02f, -5.02835810e-02f, -5.53038828e-02f,
  1.25430837e-01f, 1.54628828e-01f, -7.42108971e-02f, 4.41847071e-02f, -1.52884806e-02f, 2.75141243e-02f, -7.45827034e-02f, 3.41857783e-02f, -7.27349743e-02f, 6.68060929e-02f,
  7.07375407e-02f, -2.34212205e-02f, -2.28975527e-02f, -4.97644618e-02f, 9.28981528e-02f, 2.81216595e-02f, 2.06804890e-02f, -4.21488807e-02f, 4.86807860e-02f, 2.39662826e-02f,
  8.24336857e-02f, 1.05997913e-01f, 2.10748866e-01f, 1.22918695e-01f, 1.55486818e-02f, 1.01540394e-01f, 1.13720849e-01f, 9.08007547e-02f, 2.67666131e-01f, 2.56810039e-01f,
  2.52830446e-01f, -1.76215265e-02f, -1.74768224e-01f, 1.52448133e-01f, -9.10451338e-02f, -2.63751805e-01f, -4.80051756e-01f, -2.42140248e-01f, 1.31566048e-01f, 1.32064313e-01f,
  1.33855343e-01f, 3.29200238e-01f, 2.37708181e-01f, 5.26522249e-02f, -1.16810858e-01f, -1.77000299e-01f, -1.74948916e-01f, -8.24480131e-02f, -1.15637623e-01f, -1.13983467e-01f,
  4.46168799e-03f, 5.20844897e-03f, 3.86987254e-02f, -3.33515145e-02f, 1.11108519e-01f, 1.76609308e-01f, 3.16273645e-02f, 3.04449145e-02f, -4.00978476e-02f, 2.18663231e-01f,
  2.86015242e-01f, -9.79899615e-02f, -5.94105236e-02f, 1.71734646e-01f, 3.87388542e-02f, 2.47841198e-02f, 8.81413594e-02f, 1.67766921e-02f, 1.36485100e-01f, -1.31820021e-02f,
  1.05099812e-01f, 1.48701789e-02f, 8.78939126e-03f, -7.69452155e-02f, -1.54740727e-02f, -1.28985131e-02f, -9.53053869e-03f, 8.68841191e-04f, -7.49037266e-02f, 4.35232520e-02f,
  -1.68725960e-02f, -1.63455568e-02f, -9.31528397e-03f, -8.25987235e-02f, -1.12022348e-02f, 1.30554279e-02f, -2.57394724e-02f, -7.63506964e-02f, -1.62123829e-01f, 1.43650755e-01f,
  -1.46399820e-02f, 4.60449643e-02f, -2.90967673e-02f, -4.56201695e-02f, 8.12285170e-02f, 7.29747582e-03f, 8.15688726e-03f, 2.11582910e-02f, 9.47175641e-03f, -4.01998423e-02f,
  -4.71752789e-03f, -4.37986180e-02f, -3.83353001e-03f, 2.90773753e-02f, 1.23369083e-01f, -3.93926213e-03f, -3.15264016e-02f, 2.65649166e-02f, 2.96110306e-02f, -4.20580171e-02f,
  6.67883009e-02f, -1.16944723e-02f, 1.49819383e-03f, 2.17770208e-02f, -3.47781321e-03f, 1.18445568e-02f, 2.82066260e-02f, -3.94544005e-02f, 4.60269451e-02f, -2.99066994e-02f,
  3.44806880e-01f, -1.55963033e-01f, 1.97504401e-01f, -3.42398919e-02f, -8.88486207e-03f, 4.16520536e-02f, 9.59691778e-02f, -2.28795805e-03f, -1.98902730e-02f, 5.85562252e-02f,
  -3.96045111e-02f, 4.01634462e-02f, 5.23037352e-02f, 2.88352296e-02f, -7.91064426e-02f, -6.50524497e-02f, -6.65107667e-02f, -1.28110610e-02f, -5.03263762e-03f, 4.44603637e-02f,
  -5.44299791e-03f, -5.01575209e-02f, 1.21893875e-01f, 3.12695913e-02f, -5.89313097e-02f, 1.41862631e-01f, -3.78889106e-02f, 8.95060040e-03f, -8.33833069e-02f, 1.02683231e-01f,
  -3.06589812e-01f, 1.15289815e-01f, -3.70321721e-02f, -5.30419610e-02f, 5.85885206e-03f, -1.77843362e-01f, -1.46335103e-02f, -1.37954652e-01f, -1.58096641e-01f, -7.58459908e-04f,
  5.20181619e-02f, -1.59549583e-02f, -5.43867163e-02f, -3.11381649e-02f, -8.86852518e-02f, 9.53735337e-02f, -2.06370335e-02f, -6.93391636e-03f, -1.33914143e-01f, -5.99904545e-02f,
  1.25243768e-01f, 1.62784022e-03f, -5.51890470e-02f, 1.36399060e-01f, 3.46813947e-01f, 2.21111357e-01f, 1.28852233e-01f, 1.59972399e-01f, 1.81838050e-01f, 4.91967380e-01f,
  2.11685419e-01f, -7.02984333e-02f, -6.09671548e-02f, -7.22293183e-02f, 7.18200803e-02f, -1.38963079e-02f, -9.14808363e-04f, 8.12513083e-02f, -4.26135622e-02f, 2.76891198e-02f,
  3.12179774e-02f, -1.11177228e-02f, 3.08892094e-02f, 1.17718413e-01f, 6.45872504e-02f, -6.44442067e-02f, 4.22482789e-02f, -4.33335416e-02f, -8.94070491e-02f, -3.86553667e-02f,
  8.19278583e-02f, 1.47095591e-01f, -3.89048941e-02f, -5.70986420e-02f, -2.25880966e-02f, -4.35752608e-02f, 1.54187068e-01f, 1.01148427e-01f, -1.12474971e-02f, 2.97037572e-01f,
  9.52034071e-02f, 1.30233644e-02f, -6.41053468e-02f, 7.22810701e-02f, 2.47476511e-02f, -2.55860463e-02f, 5.88844009e-02f, -4.39325385e-02f, -2.57528713e-03f, 7.76982531e-02f,
  -5.20716533e-02f, -7.16987923e-02f, 2.18126993e-03f, -2.65821107e-02f, 6.07356019e-02f, -3.51294945e-03f, 2.91786646e-03f, -1.04036164e-02f, 2.10961998e-02f, -9.63559449e-02f,
  -3.56688872e-02f, 1.25558851e-02f, 3.92271541e-02f, 3.20212916e-02f, -6.95630088e-02f, 4.59834412e-02f, 4.85965908e-02f, 1.95458718e-03f, 3.34402695e-02f, -9.73145068e-02f,
  9.30341110e-02f, -3.86213481e-01f, 9.03605372e-02f, 3.28423940e-02f, 5.68512827e-02f, -1.93871818e-02f, 7.74354907e-03f, -4.71638478e-02f, -6.40264675e-02f, 5.50778694e-02f,
  -8.01711008e-02f, -4.95145805e-02f, -3.37814838e-02f, 6.92490861e-02f, 8.74480885e-03f, -3.16935740e-02f, -6.44777156e-03f, -2.17461376e-03f, -1.56147918e-02f, -3.24034542e-02f,
  5.01208603e-02f, -9.91207585e-02f, -6.65578693e-02f, 1.17500164e-02f, 5.96650206e-02f, -1.68183237e-01f, 4.83010113e-02f, 1.09517738e-01f, -1.87458277e-01f, 1.08050868e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.26710367e-03f, -2.14814305e-01f, 3.96066815e-01f, 1.47507057e-01f, 2.69337147e-01f, 4.29570645e-01f, 3.56922776e-01f, 5.30646145e-02f, -7.29070157e-02f, 6.69332072e-02f,
  -9.63124111e-02f, -1.63145557e-01f, -1.79731727e-01f, -1.36253819e-01f, -1.50240228e-01f, 6.87951520e-02f, 1.06145307e-01f, 2.74250880e-02f, 8.16033036e-02f, 2.10151896e-01f,
  -3.94528955e-02f, 4.25621606e-02f, 3.17605399e-02f, 1.68748684e-02f, 2.90283617e-02f, -3.77422497e-02f, 1.43040895e-01f, 1.10131226e-01f, -9.32846591e-03f, 1.00836083e-02f,
  1.49719983e-01f, -1.72365515e-03f, -5.11447936e-02f, -2.06598341e-01f, -2.70455400e-03f, -9.49790925e-02f, -3.71643417e-02f, -8.18077102e-02f, -6.55732080e-02f, 3.38046923e-02f,
  -6.38947915e-03f, 6.41582825e-04f, 1.44351143e-02f, 3.87378335e-02f, 9.54502299e-02f, 7.78647363e-02f, -7.53776431e-02f, -2.67493934e-03f, -1.77101523e-01f, -8.14356804e-02f,
  -1.35761052e-01f, 6.75065517e-02f, 2.17823833e-01f, 2.36600600e-02f, -9.97202396e-02f, -8.81356522e-02f, -3.06859240e-02f, 1.88424420e-02f, 2.80637406e-02f, 3.06287240e-02f,
  -1.93227623e-02f, -9.29417927e-03f, 3.26606371e-02f, 3.25649269e-02f, -5.02091348e-02f, 5.42578660e-02f, 6.93360344e-02f, 6.16399385e-02f, 3.89980450e-02f, 5.66078313e-02f,
  4.94506732e-02f, -2.08649486e-02f, 4.10727672e-02f, 4.48515825e-02f, -4.88516539e-02f, 7.10890675e-03f, 7.36577436e-02f, -5.05082756e-02f, 4.97678332e-02f, 2.09535044e-02f,
  3.65001708e-02f, 8.58960375e-02f, -3.85927409e-02f, 1.77093316e-02f, 6.40150625e-03f, -1.13710172e-01f, -4.72033285e-02f, -4.65299413e-02f, -6.21696189e-03f, -4.23651375e-02f,
  -6.18483312e-02f, 1.49414949e-02f, -9.24005657e-02f, -6.31467849e-02f, 1.10395603e-01f, -5.00716604e-02f, -5.73591478e-02f, -4.15987968e-02f, 1.32552832e-02f, 1.49190929e-02f,
  6.07160553e-02f, -1.00399435e-01f, -3.22285667e-02f, -3.30703543e-03f, 1.61690980e-01f, 8.25878903e-02f, 3.15996376e-03f, 1.89857706e-02f, -1.16313897e-01f, -8.63282010e-02f,
  -8.31069201e-02f, 1.79231644e-01f, 1.78319275e-01f, 2.27172207e-02f, 1.66266467e-02f, 4.02903231e-03f, 1.48910865e-01f, 1.35517299e-01f, 1.61308929e-01f, 9.31231305e-02f,
  1.72948390e-01f, 3.14760119e-01f, 4.44245525e-02f, 8.97999704e-02f, 3.42966169e-02f, 8.99069756e-02f, 1.63035378e-01f, -1.76417623e-02f, -1.61703840e-01f, 1.25786558e-01f,
  1.58271596e-01f, -8.79175588e-02f, -1.46533065e-02f, -1.26858786e-01f, -1.25463335e-02f, 2.03050077e-02f, -5.32429777e-02f, -1.01533629e-01f, -8.62088427e-02f, 3.39363962e-02f,
  3.19005386e-03f, -2.10125335e-02f, 8.55990797e-02f, -1.92636102e-02f, 2.58904472e-02f, -6.22689500e-02f, -8.56942087e-02f, 6.95311502e-02f, 1.33903369e-01f, 4.14139219e-02f,
  6.22314923e-02f, 2.60950536e-01f, -8.16788971e-02f, -4.25047353e-02f, 1.26471177e-01f, -7.40508214e-02f, 2.54935455e-02f, -7.73351789e-02f, -5.10616452e-02f, -9.77855846e-02f,
  1.16572350e-01f, -5.75995855e-02f, 7.94970170e-02f, 7.03669935e-02f, 3.47727537e-02f, 6.49221474e-03f, 6.19862638e-02f, 2.52469741e-02f, -5.20678936e-03f, 9.99871939e-02f,
  7.28257224e-02f, 1.12357348e-01f, 1.47024035e-01f, -5.10252342e-02f, 1.73910018e-02f, -1.52475364e-03f, 5.46608195e-02f, -8.92476365e-03f, 3.49167138e-02f, -3.84644642e-02f,
  -8.40294883e-02f, -4.62685190e-02f, 4.98015666e-03f, 8.72994810e-02f, -9.88587514e-02f, -6.76386431e-02f, -6.14644028e-02f, 1.60116311e-02f, -4.50933650e-02f, 5.31752482e-02f,
  3.74908075e-02f, 5.38097247e-02f, 3.48500274e-02f, -2.38507036e-02f, -7.16434121e-02f, 1.82597432e-02f, 1.11247189e-01f, -6.69493899e-02f, -6.08296916e-02f, 3.93294841e-02f,
  8.33695531e-02f, 1.61604956e-02f, -5.67421094e-02f, -7.47059733e-02f, 2.61007342e-02f, 6.05417676e-02f, -9.94866341e-02f, 6.12549819e-02f, -8.79807323e-02f, -5.91650195e-02f,
  -2.53160242e-02f, 3.15917959e-03f, -1.88275632e-02f, 5.85020811e-04f, 2.34677214e-02f, 8.35264847e-02f, 1.14708722e-01f, 6.37616962e-02f, -3.00998986e-02f, 5.59034608e-02f,
  1.13543449e-02f, 1.08506037e-02f, 6.72523528e-02f, 2.00792905e-02f, -1.87082645e-02f, 2.26416737e-02f, 5.62332990e-03f, 3.57662030e-02f, -6.95485547e-02f, -9.04387757e-02f,
  -1.07923664e-01f, -1.10842139e-01f, -1.19098127e-01f, -1.27826765e-01f, -1.24437618e-03f, -3.10367011e-02f, -2.18552916e-04f, -1.22615427e-01f, -9.30160657e-02f, -2.25669518e-01f,
  -8.27996060e-02f, -7.90123567e-02f, 4.85720336e-02f, 2.18170825e-02f, 1.38971791e-01f, 1.61883399e-01f, 6.89248145e-02f, -7.90105984e-02f, -1.18828997e-01f, -4.25132457e-03f,
  -5.10859862e-02f, 8.99673626e-03f, -1.23146072e-01f, -1.44129889e-02f, -1.29598603e-01f, -1.34415507e-01f, -2.68040374e-02f, 2.57611386e-02f, -6.43322691e-02f, 8.10104087e-02f,
  -2.44609304e-02f, -1.14113510e-01f, -8.86776969e-02f, -2.96093337e-02f, -3.00103868e-03f, 4.25618850e-02f, -5.82893305e-02f, -9.07267183e-02f, -6.88555390e-02f, 1.80704624e-03f,
  -9.50495675e-02f, 1.05827913e-01f, 2.71703247e-02f, -3.95285711e-02f, -4.03178260e-02f, -1.17834695e-02f, 4.26810607e-02f, -7.79208615e-02f, 3.20155546e-02f, 5.07294163e-02f,
  2.55287942e-02f, 8.02050605e-02f, -1.49254370e-02f, -6.49688989e-02f, -1.86611328e-03f, -5.63127175e-02f, 9.29408590e-04f, 2.05364600e-02f, 1.91925205e-02f, -1.98066924e-02f,
  -6.56541511e-02f, -3.32958400e-02f, -4.23595496e-02f, -7.27514550e-02f, 1.32601447e-02f, 5.76402619e-02f, 9.21578147e-04f, 6.20531291e-02f, -2.71835625e-02f, -4.16367911e-02f,
  -1.41541008e-02f, 3.87662128e-02f, 2.76503582e-02f, -2.70450898e-02f, -8.09157640e-02f, -7.65742660e-02f, -9.43002701e-02f, 8.39741342e-03f, 5.39999381e-02f, -1.53434118e-02f,
  6.89522251e-02f, 5.29297628e-02f, 3.76027785e-02f, 2.71550603e-02f, -3.75095084e-02f, 1.57710221e-02f, -4.03321758e-02f, -1.26453459e-01f, 1.46546429e-02f, -4.06715609e-02f,
  -3.87085006e-02f, 1.29457004e-03f, -8.44904110e-02f, 7.72573799e-02f, -7.88622361e-04f, -1.01514861e-01f, -6.08423799e-02f, 1.75592303e-02f, -1.07238881e-01f, -5.97382635e-02f,
  -1.05106324e-01f, 3.20745334e-02f, 5.87072186e-02f, 1.39598167e-02f, 1.14688367e-01f, -3.22445221e-02f, -6.60900176e-02f, 5.30005246e-02f, 9.55016613e-02f, 2.40319651e-02f,
  5.55292405e-02f, -7.73934051e-02f, -2.56732143e-02f, 7.32250884e-02f, 7.54133314e-02f, 8.88302475e-02f, -5.97761832e-02f, -3.62252332e-02f, 3.59580331e-02f, 3.62152793e-02f,
  -2.33536065e-02f, -1.12572834e-01f, -4.99136038e-02f, -4.73622866e-02f, -2.98159681e-02f, -1.13749802e-01f, -9.11359414e-02f, 4.98518497e-02f, -5.99534996e-02f, -7.72198141e-02f,
  6.90827072e-02f, 1.07439533e-01f, 1.71423182e-01f, -5.99536039e-02f, -1.47725135e-01f, -1.03816152e-01f, -1.10456191e-01f, -4.54562642e-02f, -5.70556931e-02f, 2.85074506e-02f,
  -5.97530864e-02f, 2.78773513e-02f, -9.15484726e-02f, 9.92489681e-02f, 9.84568149e-02f, -9.79253370e-03f, 8.47972780e-02f, 7.27438480e-02f, 5.49343834e-03f, 7.53477449e-03f,
  -2.54307650e-02f, 7.70355463e-02f, 1.96198523e-01f, 2.89703254e-02f, 9.88686085e-02f, 6.90842271e-02f, 1.56668544e-01f, 1.12587616e-01f, 8.21279641e-03f, 2.18906641e-01f,
  4.70953286e-02f, 1.03147171e-01f, 4.37254459e-02f, 2.52758488e-02f, 8.98652896e-03f, 1.11474469e-01f, 5.30666895e-02f, 1.66909188e-01f, 2.38212813e-02f, 1.30838677e-01f,
  8.11448172e-02f, 6.72192350e-02f, 8.48493129e-02f, 5.41890338e-02f, 9.83527303e-02f, 2.10416131e-02f, 5.06549031e-02f, 5.11650778e-02f, 1.21942677e-01f, -2.25809366e-02f,
  -7.31796622e-02f, -3.27173136e-02f, -7.30744153e-02f, -2.63702944e-02f, 3.00174020e-02f, -1.08984821e-01f, 6.39767200e-02f, 1.58980519e-01f, 2.10725162e-02f, 6.92537501e-02f,
  -9.23366025e-02f, 2.51451880e-02f, 1.93639901e-02f, -6.89086244e-02f, -7.24836662e-02f, 5.18171564e-02f, -5.29078534e-03f, -3.10131744e-03f, -3.99347618e-02f, 1.03307413e-02f,
  -2.50979252e-02f, -6.99447915e-02f, -8.19308907e-02f, -3.73996049e-03f, -8.98755565e-02f, 7.60843828e-02f, -6.67673955e-03f, -4.50335965e-02f, -1.87245943e-02f, -5.37418053e-02f,
  3.79554927e-02f, 6.20696582e-02f, 2.92618535e-02f, -6.40444309e-02f, 6.46943077e-02f, 4.99887019e-02f, 6.52432814e-02f, -1.66156534e-02f, 5.93792535e-02f, -3.00108306e-02f,
  -7.43773654e-02f, -1.06220596e-01f, 1.23149538e-02f, 3.62065434e-02f, 8.03946238e-03f, 9.56433117e-02f, -1.06869020e-01f, 1.14620559e-01f, -5.56447990e-02f, 7.05221593e-02f,
  5.71713783e-02f, 8.65597874e-02f, -7.46821240e-03f, 1.08500220e-01f, 7.37461299e-02f, -6.16871901e-02f, 7.13559985e-02f, -1.67420078e-02f, -1.12045659e-02f, 5.45500331e-02f,
  9.60336402e-02f, -4.56041582e-02f, 4.30847034e-02f, 9.62408842e-04f, -4.08510789e-02f, -1.44759208e-01f, -7.09066093e-02f, -2.34453920e-02f, 7.06109181e-02f, -6.50532246e-02f,
  8.31824839e-02f, 9.37548354e-02f, -6.37596250e-02f, 8.74655694e-02f, 1.12249434e-01f, 5.06231412e-02f, 1.33660257e-01f, 1.50220454e-01f, 8.14481005e-02f, 1.65586546e-01f,
  1.02590837e-01f, 2.21979603e-01f, 2.28247464e-01f, 1.02451235e-01f, 1.14438105e-02f, -1.48429200e-02f, 3.84860113e-02f, -9.96554419e-02f, 7.76501819e-02f, 3.81900482e-02f,
  8.37499425e-02f, -1.74774006e-02f, 6.26297370e-02f, 5.11646830e-02f, -3.09746917e-02f, 1.60910875e-01f, -1.70095991e-02f, 6.64088055e-02f, 2.79949997e-02f, 2.88657937e-02f,
  -9.91437584e-02f, -9.97483060e-02f, 7.48778805e-02f, 6.38639256e-02f, -5.35481870e-02f, -4.02203016e-02f, 3.22941062e-03f, -9.51473117e-02f, 8.09509773e-03f, 1.73620228e-02f,
  -6.45404905e-02f, 6.22571968e-02f, -7.30662420e-02f, -1.50018074e-02f, 2.05814429e-02f, 2.84753088e-02f, -2.47991979e-02f, 7.49041066e-02f, 6.88138455e-02f, 6.16747364e-02f,
  1.02670714e-01f, -8.91648456e-02f, -5.12967221e-02f, -2.66048349e-02f, 2.32210010e-02f, 9.09250304e-02f, 4.17158641e-02f, -9.74926632e-03f, 3.00342608e-02f, -4.62665409e-02f,
  -7.17240572e-02f, 1.34974299e-03f, -1.93926506e-02f, 2.18956321e-02f, 9.07090232e-02f, -5.66129684e-02f, -3.59299555e-02f, -3.60761657e-02f, 8.49628374e-02f, -8.26785713e-02f,
  3.50360163e-02f, -3.86432819e-02f, -3.80930901e-02f, 8.64029303e-02f, -5.18932119e-02f, -5.48949949e-02f, -8.73587877e-02f, -4.49058553e-03f, -6.27161041e-02f, 5.80849387e-02f,
  -6.66301996e-02f, 3.28231938e-02f, -1.21904664e-01f, -6.32631704e-02f, -3.48935127e-02f, 4.47662398e-02f, 1.93970554e-04f, -1.01789674e-02f, -4.49964032e-02f, -2.17900914e-03f,
  1.76057473e-01f, 6.75961971e-02f, -4.41872552e-02f, 2.23661121e-02f, -6.88599870e-02f, 3.09924060e-03f, 7.59436935e-02f, -3.35903540e-02f, -6.71855807e-02f, 8.05274993e-02f,
  7.82215595e-03f, -9.25652385e-02f, 6.47655427e-02f, 2.70769671e-02f, -8.84370729e-02f, -5.78129888e-02f, -2.79172324e-02f, 7.43665472e-02f, -2.13894527e-02f, -8.71135592e-02f,
  2.24351697e-02f, -3.34847420e-02f, -9.34335124e-03f, -3.82657722e-02f, 4.91945483e-02f, 4.29459363e-02f, -6.39193580e-02f, -3.19524184e-02f, -5.70320524e-02f, 1.18162252e-01f,
  2.59293437e-01f, 1.80991188e-01f, -1.22752391e-01f, 1.09378994e-01f, 4.86788480e-03f, -1.59072250e-01f, -7.48313963e-02f, -8.60232934e-02f, 2.54193973e-02f, 6.70865178e-02f,
  1.36210099e-01f, -1.66035667e-02f, 6.34671524e-02f, -1.71111956e-01f, -2.60417223e-01f, -1.42951146e-01f, -1.01269625e-01f, -1.03796884e-01f, -2.82676309e-01f, -7.38310888e-02f,
  3.56668457e-02f, 2.95146424e-02f, -4.47033942e-02f, 4.80114892e-02f, 1.42188102e-01f, 1.58999905e-01f, 7.14655221e-02f, 4.88510951e-02f, 7.64916930e-03f, 2.00282976e-01f,
  4.53053974e-02f, 4.80237640e-02f, -3.16685252e-02f, 1.83036670e-01f, 1.26528427e-01f, -6.23209141e-02f, -2.86529679e-02f, -1.97415706e-02f, -3.49551588e-02f, -2.09154803e-02f,
  9.13887843e-02f, -3.57799456e-02f, 4.50734422e-02f, -2.11374722e-02f, -4.57745455e-02f, 1.78966951e-02f, -4.99749593e-02f, -2.11114421e-01f, -4.88181040e-02f, -8.33909884e-02f,
  1.31839082e-01f, 8.90333578e-02f, 2.75052786e-02f, -3.55295427e-02f, -6.54363036e-02f, 8.18971428e-04f, -1.90545470e-02f, 3.47783864e-02f, -1.86899990e-01f, -2.63848174e-02f,
  1.72165945e-01f, 8.99892524e-02f, 5.50742559e-02f, 3.91845033e-02f, 6.01042993e-02f, 1.10702857e-01f, 1.05392136e-01f, 1.27752826e-01f, -4.32460085e-02f, -2.38116495e-02f,
  -6.54020309e-02f, 1.61558818e-02f, -2.86949277e-02f, 7.17393532e-02f, 6.84060752e-02f, 9.25772414e-02f, 5.39617017e-02f, 8.96244794e-02f, -3.30163389e-02f, 2.15078723e-02f,
  7.73256496e-02f, 3.75876129e-02f, 1.01867542e-01f, 3.15481871e-02f, 2.99884994e-02f, 4.89295051e-02f, 5.21295033e-02f, 9.41791087e-02f, 9.97954756e-02f, 1.38011590e-01f,
  2.87569556e-02f, -4.74701524e-02f, 9.53126848e-02f, -7.30223656e-02f, 1.29716158e-01f, -6.81988969e-02f, 3.88137214e-02f, 2.12298948e-02f, 5.22299111e-03f, -5.79401068e-02f,
  5.65561764e-02f, -1.96694564e-02f, -4.35960963e-02f, -1.02372624e-01f, -7.27150738e-02f, 3.59850675e-02f, -1.12709729e-02f, -3.32102366e-02f, -1.48883000e-01f, 6.56761676e-02f,
  -1.26920156e-02f, -3.29137594e-02f, -8.32152143e-02f, -1.57734379e-01f, 2.28191800e-02f, 2.80596241e-02f, 6.34280173e-03f, 1.08119119e-02f, -4.68831956e-02f, -1.42910052e-02f,
  2.48706102e-01f, 2.26306319e-02f, -2.64944732e-01f, 2.93650329e-01f, 2.22196858e-02f, -1.83143109e-01f, -2.45268151e-01f, -6.03691787e-02f, 5.17034866e-02f, -1.68292653e-02f,
  2.81002279e-02f, 6.10339828e-03f, -9.51095372e-02f, -1.70751393e-01f, -1.77251354e-01f, -2.62355924e-01f, -1.55334473e-01f, -2.73259550e-01f, -1.36669591e-01f, 1.65719390e-02f,
  7.15318024e-02f, 1.22836500e-01f, 1.50410905e-01f, 3.98331545e-02f, 2.08976403e-01f, 1.67829469e-02f, 8.84384513e-02f, -3.15149650e-02f, -4.55010571e-02f, -4.62747999e-02f,
  -2.09914550e-01f, -4.29625250e-02f, -1.45269543e-01f, -3.33756097e-02f, -3.14855576e-02f, -2.76619252e-02f, -4.53801975e-02f, -7.57587031e-02f, -1.05253547e-01f, -6.14747331e-02f,
  4.51009385e-02f, -9.89382342e-02f, -4.47630370e-03f, 6.80983961e-02f, -4.25954089e-02f, -8.01120847e-02f, -4.86915447e-02f, -1.55397311e-01f, -1.14195861e-01f, -5.39477393e-02f,
  -5.19827455e-02f, -8.46511051e-02f, -1.30106986e-01f, -9.38760638e-02f, -1.27554327e-01f, -1.18233114e-01f, -1.60837144e-01f, -9.69943255e-02f, -8.14953893e-02f, 6.15962334e-02f,
  -3.47288251e-02f, 8.62977395e-05f, -4.14021239e-02f, -4.18911390e-02f, -2.75933240e-02f, -4.66966070e-02f, 3.62543911e-02f, 5.13206013e-02f, 2.16992311e-02f, -4.71659489e-02f,
  -1.04265269e-02f, -7.51541182e-02f, -5.86746633e-02f, 7.23948255e-02f, 9.21258330e-03f, 1.35891000e-03f, 1.01240752e-02f, -3.10255750e-03f, 2.55786404e-02f, 8.75336975e-02f,
  -6.00949936e-02f, -8.65190402e-02f, 5.37180565e-02f, 5.97131141e-02f, -4.39089872e-02f, -7.73484036e-02f, 2.38568038e-02f, 3.01367994e-02f, -1.02653885e-02f, 4.36881110e-02f,
  2.90783316e-01f, -1.70792818e-01f, -1.81105118e-02f, 5.15114479e-02f, 2.26818398e-02f, -6.20976090e-02f, -1.49730518e-02f, -1.96194127e-02f, -1.07402746e-02f, -3.51413526e-02f,
  -1.35801956e-01f, -1.05664439e-01f, 6.33265898e-02f, -1.01546824e-01f, -2.11798232e-02f, -1.73076708e-02f, 1.48086355e-03f, -4.36946489e-02f, -9.85048488e-02f, 1.10099927e-01f,
  7.91207924e-02f, -1.56753715e-02f, -4.70836684e-02f, 1.87342018e-02f, -4.50465903e-02f, -9.80330855e-02f, -1.99320853e-01f, -5.57155162e-02f, -9.39922035e-02f, -3.41833159e-02f,
  2.89342970e-01f, -1.38296306e-01f, 9.13913622e-02f, 1.57577336e-01f, 1.69400081e-01f, 3.51571441e-02f, -1.54303178e-01f, -9.51685905e-02f, 6.39973134e-02f, -4.93547767e-02f,
  -8.88238177e-02f, 7.00907968e-03f, 2.80138571e-02f, 7.61041567e-02f, -2.49066092e-02f, 3.45856696e-02f, -5.30192368e-02f, 2.70505194e-02f, 1.68956503e-01f, 7.52877742e-02f,
  1.37265056e-01f, 7.63866752e-02f, 2.66507976e-02f, 4.35308963e-02f, 1.44005790e-01f, 5.49526587e-02f, 7.41475523e-02f, 2.83117779e-02f, 4.76775914e-02f, 9.31176245e-02f,
  1.42871775e-02f, -2.91406899e-03f, 6.73304349e-02f, 2.38754526e-02f, 1.86111517e-02f, -6.58544973e-02f, -4.44114208e-02f, -6.88309595e-02f, 6.18402027e-02f, -9.69785303e-02f,
  -8.05436969e-02f, 9.06983018e-02f, -1.77686363e-02f, -3.93818803e-02f, -6.15428872e-02f, 5.61986417e-02f, 2.17174217e-02f, -4.97228727e-02f, -7.14876503e-02f, 4.37481552e-02f,
  -4.63818721e-02f, 2.19168197e-02f, -2.68830955e-02f, -2.39284169e-02f, -5.99717386e-02f, 8.79343003e-02f, -9.31501687e-02f, 5.19593582e-02f, -3.03856730e-02f, 6.50312081e-02f,
  3.43868472e-02f, 4.65977788e-02f, 2.74602603e-02f, 8.82895961e-02f, -3.70305292e-02f, -1.46723902e-02f, -4.66832109e-02f, -1.47196874e-02f, -5.48825152e-02f, -3.60886082e-02f,
  -4.29975279e-02f, -4.04602429e-03f, 4.08853702e-02f, -2.39228434e-03f, -8.36118270e-05f, 5.57805672e-02f, 7.11108232e-03f, 1.21256532e-02f, 8.42552781e-02f, 4.21332605e-02f,
  -2.76093837e-02f, 6.48156623e-04f, 7.96590075e-02f, -6.83442801e-02f, 2.52683330e-02f, 8.59379694e-02f, 4.22213711e-02f, -5.06082699e-02f, -2.59967502e-02f, -1.13105234e-02f,
  -1.05731636e-01f, -1.21849500e-01f, 1.01489417e-01f, -6.12502247e-02f, -1.77248102e-02f, 4.55022380e-02f, -4.49672043e-02f, -8.44905376e-02f, 2.59858323e-03f, -3.07365581e-02f,
  5.50784655e-02f, -2.80708205e-02f, 3.27695012e-02f, -9.87523124e-02f, 9.80801955e-02f, 2.82654283e-03f, -9.73811373e-02f, 8.88872743e-02f, -1.08174793e-01f, 2.23878399e-02f,
  -5.19522990e-04f, 2.03531981e-02f, 8.20028558e-02f, 2.59596985e-02f, 8.55942890e-02f, 9.93031189e-02f, 7.95003623e-02f, -3.76679488e-02f, 5.97379021e-02f, -6.64559528e-02f,
  -1.91966906e-01f, -3.10115255e-02f, 5.89709803e-02f, 3.16618867e-02f, 2.44189680e-01f, 2.45767906e-01f, 1.73450693e-01f, 1.12344354e-01f, 6.30513430e-02f, -1.34510845e-02f,
  -4.82409969e-02f, -1.47266567e-01f, 3.20444698e-03f, 5.63162602e-02f, 9.78920162e-02f, 2.17225820e-01f, 2.15400144e-01f, 1.13042310e-01f, 3.52935083e-02f, 2.60841362e-02f,
  6.00156672e-02f, -1.07178474e-02f, -7.41099045e-02f, -3.40816043e-02f, 9.60692167e-02f, 6.58316258e-03f, 4.38936576e-02f, -7.89993852e-02f, 1.75611097e-02f, 4.97748144e-02f,
  -1.80176407e-01f, -1.48796096e-01f, 4.94425260e-02f, 4.55365377e-03f, -1.33174807e-01f, 3.99320796e-02f, -1.68562550e-02f, -1.23707512e-02f, 3.09689455e-02f, -5.44531532e-02f,
  -2.75050011e-02f, -1.17149927e-01f, 1.01953400e-02f, 5.37686199e-02f, -3.09294555e-02f, -4.37313467e-02f, -6.30540103e-02f, 1.04163494e-02f, 7.94702582e-03f, -4.56969664e-02f,
  -7.99581632e-02f, -1.17257252e-01f, -6.99524879e-02f, 6.39366955e-02f, 1.11549506e-02f, 5.78930452e-02f, -9.44096409e-03f, -3.83989476e-02f, -7.61616454e-02f, -6.01572543e-02f,
  -4.76708785e-02f, 3.35921794e-02f, -7.92747661e-02f, 2.24627014e-02f, -6.36710003e-02f, -4.21980675e-03f, 1.14270553e-01f, -5.05490154e-02f, -3.90792005e-02f, 8.44178125e-02f,
  9.01814997e-02f, 6.18699417e-02f, -3.90835619e-03f, 4.61442620e-02f, -2.72279121e-02f, 7.61380866e-02f, 3.82352769e-02f, 1.31496573e-02f, -1.39554618e-02f, -5.56000043e-03f,
  1.82944890e-02f, 1.08998254e-01f, -7.32766511e-03f, 9.81149524e-02f, -1.93844736e-02f, 3.35174352e-02f, 1.46155134e-02f, 4.32624109e-02f, 9.26038064e-03f, 3.72303203e-02f,
  -2.01129705e-01f, -8.83341059e-02f, 8.17519985e-03f, 9.47787799e-03f, -4.76732440e-02f, -6.34372234e-02f, 2.26546568e-03f, -9.55771282e-02f, -5.74284233e-02f, -5.26676811e-02f,
  -1.34970620e-01f, -1.01474494e-01f, -6.48809448e-02f, -5.89633025e-02f, 8.29105973e-02f, 8.00673366e-02f, -9.44700465e-02f, 3.70260168e-05f, -8.40388890e-03f, -1.02670856e-01f,
  1.04775161e-01f, 1.08172975e-01f, 6.38211519e-02f, -1.62209745e-03f, -1.66401397e-02f, 1.31352395e-01f, 7.36908466e-02f, -3.25251482e-02f, 4.26783115e-02f, 1.17568607e-02f,
  -1.15655854e-01f, 1.01631895e-01f, 2.21553475e-01f, -1.25671234e-02f, 2.57556401e-02f, 9.86052770e-03f, -6.26045316e-02f, -1.18669540e-01f, 3.15521657e-02f, 1.24020673e-01f,
  6.34178668e-02f, -3.15335244e-02f, -6.97221234e-02f, -1.30557209e-01f, -1.32894143e-01f, 8.37377179e-03f, -1.52314767e-01f, -2.27929756e-01f, -2.14069068e-01f, -1.09200008e-01f,
  -1.89170226e-01f, -6.41957298e-02f, -1.61612555e-01f, -9.51213017e-02f, 9.18674693e-02f, 9.46189463e-02f, 3.65957655e-02f, 1.25350744e-01f, -7.18102790e-03f, 1.01937786e-01f,
  2.45145619e-01f, 1.60860077e-01f, -1.50501266e-01f, -1.15771666e-01f, 1.24167584e-01f, 4.95685749e-02f, -6.86011463e-02f, -5.01417853e-02f, 4.90496978e-02f, -5.41802421e-02f,
  9.00365785e-02f, -2.94701401e-02f, -7.70893227e-03f, -6.27677813e-02f, -5.09788953e-02f, -9.84404981e-02f, -3.01455446e-02f, -7.11782500e-02f, -1.15751266e-01f, -3.77952568e-02f,
  -6.03860579e-02f, -3.94703373e-02f, -8.49248916e-02f, -4.12942916e-02f, 3.88859734e-02f, -2.05469355e-02f, 8.23352411e-02f, -3.35771067e-04f, 3.29995640e-02f, -9.18262377e-02f,
  -4.54447552e-04f, 2.52490826e-02f, 2.71278881e-02f, -7.06680268e-02f, -1.17453240e-01f, 8.71276483e-02f, -5.45297265e-02f, -3.64300497e-02f, -7.17574507e-02f, 3.53291780e-02f,
  6.75249621e-02f, 2.78275518e-04f, -8.54478180e-02f, -9.30949375e-02f, 6.02907082e-03f, 5.06811030e-02f, 5.28226160e-02f, -7.26296380e-02f, 2.69410871e-02f, -8.60095695e-02f,
  -6.87460005e-02f, -5.83552159e-02f, 6.60574064e-02f, 4.08985019e-02f, -1.88110806e-02f, -9.35949311e-02f, 6.73220456e-02f, 2.77669169e-02f, 6.87489957e-02f, -4.53558117e-02f,
  -1.10301584e-01f, -5.30100204e-02f, 4.81581613e-02f, -1.34225488e-01f, 2.54491512e-02f, -6.58927932e-02f, 1.12233706e-01f, -4.51860018e-02f, 1.28631055e-01f, 2.48465855e-02f,
  2.60767378e-02f, 1.03804749e-02f, -4.28202795e-03f, 4.45031747e-02f, -1.38022959e-01f, -4.02832329e-02f, -9.64777470e-02f, -1.14135653e-01f, -6.35871515e-02f, 1.12864012e-02f,
  -7.12663755e-02f, -1.11258052e-01f, -1.36451572e-01f, -4.88953106e-03f, -1.46574989e-01f, -5.89653775e-02f, -8.94332491e-03f, -9.72816646e-02f, -1.73471823e-01f, -2.26942271e-01f,
  -1.56876996e-01f, 4.09633480e-02f, -6.20460212e-02f, -1.57487944e-01f, -4.05065194e-02f, -4.78961654e-02f, 7.89389852e-03f, -1.32606715e-01f, -1.61407948e-01f, 2.18098108e-02f,
  -3.07788607e-02f, 4.73706201e-02f, 1.18944481e-01f, -6.32866323e-02f, 3.60534713e-02f, 3.52692455e-02f, -2.02839612e-03f, -1.08060919e-01f, -3.15850042e-02f, -1.41788632e-01f,
  4.14546626e-03f, 1.86742544e-02f, 1.32351583e-02f, -8.52455348e-02f, -9.09450352e-02f, 5.41785546e-02f, 4.14118394e-02f, 1.06929848e-02f, -1.09681357e-02f, 3.70280892e-02f,
  3.52861881e-01f, -1.78906038e-01f, -8.33486691e-02f, -8.04916583e-03f, -3.69747020e-02f, 2.42524557e-02f, -6.76011015e-03f, -5.91138490e-02f, -6.39778897e-02f, -6.55308813e-02f,
  -6.76380121e-04f, -1.13151381e-02f, -1.08351856e-01f, -8.30904320e-02f, -3.43623720e-02f, -3.90479863e-02f, -2.84383260e-02f, -1.06103159e-01f, -1.12454578e-01f, -3.50679979e-02f,
  8.77751969e-03f, -1.85548767e-01f, 4.17985059e-02f, -4.83508164e-04f, -2.79769879e-02f, -5.40586114e-02f, 5.35906740e-02f, -7.84081966e-02f, -5.78581505e-02f, 3.10081765e-02f,
  -1.10520691e-01f, -1.96554475e-02f, -9.71338600e-02f, -5.19814901e-02f, -5.75561300e-02f, -1.80296749e-02f, -3.10337674e-02f, 7.15518463e-03f, 3.01582962e-02f, 6.42848462e-02f,
  6.07521646e-02f, -5.31493463e-02f, 1.10702060e-01f, 3.33613530e-02f, -3.64478044e-02f, -8.51411074e-02f, -4.78823371e-02f, 4.85453680e-02f, -1.78472314e-03f, -4.85077724e-02f,
  -6.77029341e-02f, -8.56129229e-02f, -4.45288531e-02f, 7.03416485e-03f, -8.79151821e-02f, -5.78864031e-02f, -6.58692494e-02f, 3.64959911e-02f, -5.58231808e-02f, -2.19085068e-02f,
  2.09430084e-01f, -1.79037407e-01f, 2.24132929e-02f, -3.41369025e-02f, -9.17153805e-02f, -7.91359618e-02f, 2.63889693e-02f, -6.27990961e-02f, -6.78454386e-03f, 5.76538332e-02f,
  -7.77077302e-02f, -1.08342348e-02f, 2.68344227e-02f, 2.39462927e-02f, -8.10967460e-02f, 4.22851630e-02f, -3.11900955e-02f, 9.29498076e-02f, -2.95193084e-02f, -3.05632930e-02f,
  5.34655415e-02f, 3.93122844e-02f, 1.15938626e-01f, 1.48280323e-01f, 5.74624613e-02f, -7.10515976e-02f, 1.92692891e-01f, 7.72230402e-02f, 8.98007565e-05f, 1.71662122e-01f,
  -1.08158387e-01f, -2.49858782e-01f, -4.87823665e-01f, -2.72179127e-01f, -1.15057088e-01f, 7.02936202e-02f, 3.89791615e-02f, 1.45673990e-01f, -1.43762946e-01f, -1.74823299e-01f,
  6.43906323e-03f, 1.24143481e-01f, -7.79609233e-02f, 1.36821359e-01f, 1.23676136e-02f, -1.28139436e-01f, -2.81768888e-01f, -1.22689441e-01f, 1.16243221e-01f, 2.47083038e-01f,
  1.38646308e-02f, -1.07221074e-01f, 3.11908573e-02f, -1.69006328e-03f, -2.17950806e-01f, -4.78404947e-02f, -2.32599318e-01f, -5.97530305e-02f, -7.21414313e-02f, -2.40162939e-01f,
  -1.51672632e-01f, -8.11113641e-02f, 2.10205670e-02f, 1.29736930e-01f, -1.56551167e-01f, 3.96556258e-02f, -7.87238106e-02f, -3.74870673e-02f, 2.24568634e-04f, -1.24806516e-01f,
  -2.64182333e-02f, 2.45717131e-02f, 5.24669420e-03f, 8.38266984e-02f, 1.68139674e-02f, 3.70778888e-02f, -3.68441790e-02f, 5.51600801e-03f, -9.06407237e-02f, 3.19181941e-02f,
  4.86500002e-02f, 1.89331137e-02f, -6.32474571e-02f, 4.89552058e-02f, 4.70361970e-02f, -2.42907200e-02f, -1.64133068e-02f, 7.86651894e-02f, -9.66148637e-03f, -8.23599845e-02f,
  9.35224965e-02f, 6.74132782e-04f, 1.47871654e-02f, 2.90497076e-02f, 3.65133286e-02f, 2.44452208e-02f, -6.32574260e-02f, 1.04405254e-01f, -2.50820331e-02f, -8.14910792e-03f,
  5.81303611e-03f, 2.98811123e-02f, 5.16443700e-02f, 4.94292304e-02f, -1.46168983e-02f, -3.33878808e-02f, 8.35058242e-02f, -6.37581870e-02f, 5.08125871e-02f, -4.00357656e-02f,
  -3.17327976e-02f, 3.53765450e-02f, -8.52594227e-02f, 2.72507444e-02f, -5.01928777e-02f, -1.41737405e-02f, 1.08384741e-02f, 7.62365088e-02f, 2.39750259e-02f, -1.34065077e-02f,
  -2.23650597e-02f, 2.59537064e-02f, 1.99756213e-02f, 5.09958044e-02f, -1.69671342e-01f, -5.39838150e-02f, -6.46618828e-02f, -4.21459787e-02f, -1.27511546e-01f, 5.17733991e-02f,
  1.49583325e-01f, -7.54785836e-02f, -9.94542167e-02f, 3.01184803e-02f, 4.01630886e-02f, 1.41466737e-01f, -1.92921679e-03f, -6.57595173e-02f, 5.12923785e-02f, -5.23431189e-02f,
  -2.88648475e-02f, 1.52929164e-02f, 3.29346359e-02f, 1.00319080e-01f, 9.98450518e-02f, 9.16833058e-02f, 5.12225330e-02f, -8.05049296e-03f, 8.20340589e-02f, -5.72567470e-02f,
  -5.44665568e-02f, -7.19445944e-02f, -3.42981547e-01f, -6.76436424e-02f, 6.52995408e-02f, -2.18817368e-02f, -9.72797815e-03f, 1.44668937e-01f, 3.61135341e-02f, -1.22506274e-02f,
  -4.12501097e-02f, 1.26758954e-02f, -8.56522173e-02f, 4.30923626e-02f, -8.46339464e-02f, -2.73736846e-02f, -5.49950227e-02f, -9.17348340e-02f, -7.45917251e-03f, 2.14191023e-02f,
  4.31330455e-03f, 5.68613186e-02f, -9.93512571e-02f, -7.19018579e-02f, 9.11288112e-02f, -1.18267141e-01f, -1.23055995e-01f, -7.29789361e-02f, -6.93233609e-02f, -9.34239030e-02f,
  -1.31048769e-01f, -1.30010605e-01f, -1.88723821e-02f, -1.94637384e-02f, -1.47734173e-02f, 4.65356298e-02f, -1.50755076e-02f, -1.11958072e-01f, 3.00942343e-02f, -1.41001251e-02f,
  -5.34601975e-03f, 6.08044937e-02f, -8.36021453e-02f, 4.73397598e-02f, -4.68136221e-02f, 3.57526205e-02f, -8.09695423e-02f, -4.15972993e-02f, -2.55293157e-02f, -6.78894073e-02f,
  2.71298345e-02f, 4.91297916e-02f, -3.15614156e-02f, -6.31407648e-02f, -7.76057839e-02f, -7.25205615e-02f, -1.40048221e-01f, 2.65113898e-02f, -5.52282035e-02f, 2.90056542e-02f,
  7.28786960e-02f, 7.92221129e-02f, 2.48878077e-02f, -2.31562443e-02f, 4.20536622e-02f, -4.29821685e-02f, -4.98938560e-02f, 8.95103905e-03f, 6.72498271e-02f, -8.57597962e-03f,
  -6.86210319e-02f, -2.77104210e-02f, 8.66439864e-02f, 7.48885497e-02f, 5.37860282e-02f, 3.79090640e-03f, 7.72488639e-02f, 1.49302986e-02f, -5.15224412e-02f, 4.98800166e-02f,
  -7.12982342e-02f, -1.51840365e-02f, -3.17117572e-02f, -5.68290837e-02f, -3.72384712e-02f, 8.28203186e-03f, -5.74251078e-02f, 2.77463514e-02f, 6.15816079e-02f, 4.95302901e-02f,
  -7.45871961e-02f, -1.29175231e-01f, -7.33227059e-02f, 9.92546380e-02f, -1.73726901e-02f, -6.53033778e-02f, 3.33298035e-02f, 1.98016465e-02f, -5.88036254e-02f, 3.78045179e-02f,
  -4.83639129e-02f, 2.93949693e-02f, -2.98878681e-02f, -3.13241854e-02f, 1.39782978e-02f, -4.10132930e-02f, 3.95888425e-02f, -4.57777828e-02f, -1.89554715e-03f, 1.01800062e-01f,
  3.61429825e-02f, -6.65274486e-02f, -1.14409022e-01f, -1.22256577e-01f, 7.24687874e-02f, -8.95687751e-03f, -1.42910868e-01f, -5.36403060e-02f, -1.74551278e-01f, -5.80303278e-03f,
  2.39514962e-01f, -3.43750305e-02f, -2.62490660e-03f, 1.04220726e-01f, 3.58548015e-02f, -5.75276986e-02f, -4.80631888e-02f, -4.70645912e-02f, 6.82069212e-02f, 3.94006632e-02f,
  4.00319286e-02f, 1.01043500e-01f, 2.61078421e-02f, 1.27768815e-02f, 6.88462853e-02f, 4.35939915e-02f, -6.94783852e-02f, 1.43524423e-01f, 3.14777009e-02f, 1.22518584e-01f,
  -2.62097735e-02f, -2.23329775e-02f, 1.08285829e-01f, -3.02549452e-02f, 3.67855001e-03f, 3.85155454e-02f, -7.76640475e-02f, 5.02235070e-02f, 1.91503018e-03f, -9.64978710e-02f,
  -7.01256022e-02f, -9.72355902e-02f, 1.06594011e-01f, -5.13087772e-02f, 4.29777652e-02f, -9.78025347e-02f, -2.49391105e-02f, 3.77230309e-02f, -4.20661978e-02f, 3.86519730e-02f,
  2.55280826e-02f, 2.30726451e-02f, -3.95867042e-02f, 3.24531645e-02f, -6.62011355e-02f, 1.46554578e-02f, -2.74353083e-02f, -2.56731380e-02f, 6.65497333e-02f, -3.46156545e-02f,
  -1.02833457e-01f, -5.05461693e-02f, 4.95914072e-02f, 2.14920845e-02f, 1.72110461e-02f, 9.58663002e-02f, -1.15483448e-01f, -4.23430428e-02f, 2.71661236e-04f, -2.08307654e-02f,
  3.04424632e-02f, 4.03844677e-02f, -6.05180785e-02f, 4.98301983e-02f, 6.66224305e-03f, 5.73753379e-02f, 6.25317991e-02f, 2.51135621e-02f, -6.12398870e-02f, 8.01861435e-02f,
  6.90307170e-02f, 1.61172878e-02f, 3.97945642e-02f, 6.28121570e-02f, 3.10671926e-02f, -5.25542349e-02f, 9.50925704e-03f, 6.69478625e-03f, 7.10389158e-03f, 5.81062632e-03f,
  -6.47342429e-02f, -2.67404281e-02f, 5.76046109e-02f, 1.65444557e-02f, 3.80786918e-02f, 4.78888601e-02f, 5.14193140e-02f, 7.85173103e-02f, 2.88581774e-02f, 5.06905664e-04f,
  2.60100104e-02f, 6.77613541e-04f, 6.06170371e-02f, 1.66825689e-02f, -5.06206527e-02f, 1.07379127e-02f, 4.69953567e-02f, -2.46884059e-02f, -4.54719961e-02f, -1.28613099e-01f,
  4.56676595e-02f, -2.90192254e-02f, -6.06124364e-02f, -7.57613257e-02f, 4.53309678e-02f, 4.07919921e-02f, -1.06615666e-02f, -3.96859124e-02f, 3.76289338e-02f, -2.34546643e-02f,
  -5.21438606e-02f, 6.68894779e-03f, 3.95774245e-02f, 3.16930469e-03f, -7.50494897e-02f, 6.73622414e-02f, 9.22890380e-02f, -4.69706096e-02f, 4.11922745e-02f, 6.11248240e-02f,
  -9.98247713e-02f, 5.26465522e-03f, 8.98142755e-02f, -9.38150659e-02f, -5.91585971e-02f, -6.34080824e-03f, 2.49970108e-02f, -8.12214538e-02f, -5.58958314e-02f, 1.89644303e-02f,
  2.51310859e-02f, 1.76802743e-02f, 1.93574596e-02f, -4.05681990e-02f, -9.26713943e-02f, 3.56354527e-02f, 1.29340878e-02f, -1.55656529e-03f, -8.91347416e-03f, -1.13058649e-01f,
  -1.09957859e-01f, -1.89141911e-02f, -5.58790900e-02f, -5.51380739e-02f, 2.18657274e-02f, 5.86334206e-02f, 4.35934030e-02f, -2.69990545e-02f, -9.11550894e-02f, -6.06873892e-02f,
  3.10619503e-01f, -2.79159099e-01f, -1.47353625e-02f, -1.55250281e-01f, -7.72458389e-02f, -8.97008702e-02f, -1.93323903e-02f, 1.29673388e-02f, 9.25747957e-03f, -8.94634798e-03f,
  -1.50422484e-01f, -5.24676293e-02f, -5.99303767e-02f, -9.68946069e-02f, 6.35152310e-02f, -8.45712274e-02f, -1.05029657e-01f, -1.85307935e-02f, 2.50970153e-03f, -4.91803735e-02f,
  -1.88499853e-01f, -1.49516270e-01f, -4.40254323e-02f, -4.49719727e-02f, -5.56804687e-02f, -1.16018660e-01f, -7.79415071e-02f, -8.72948021e-02f, -1.08310983e-01f, 1.04052342e-01f,
  8.34525004e-02f, 3.32090370e-02f, 1.34687424e-02f, -1.73020177e-02f, 1.10693304e-02f, 5.48343249e-02f, 6.19754381e-02f, 1.02444910e-01f, 1.04732625e-01f, 1.31924003e-01f,
  -5.76562434e-02f, 1.97860301e-02f, -1.37740914e-02f, 7.04125762e-02f, 6.17517531e-02f, 1.55377593e-02f, 6.82026893e-02f, -3.90462540e-02f, 9.95089114e-02f, -3.45041528e-02f,
  -7.77547900e-03f, 6.20739236e-02f, -6.43544197e-02f, 3.40889543e-02f, -1.14084423e-01f, 1.25714168e-02f, -3.53047065e-02f, 1.84800643e-02f, -1.44557990e-02f, -5.04091568e-02f,
  3.83316755e-01f, -1.25533849e-01f, 1.80660903e-01f, -8.56919214e-02f, -6.37404546e-02f, -5.33158779e-02f, 1.92554388e-02f, -3.18533406e-02f, -5.03040776e-02f, 9.60910469e-02f,
  -1.14595359e-02f, 3.20345797e-02f, 4.53394391e-02f, 1.64800882e-02f, 5.38688824e-02f, -4.16135415e-02f, -1.25779379e-02f, -2.66188402e-02f, -7.05884099e-02f, -3.22009251e-02f,
  -2.85883974e-02f, -9.42832883e-03f, 2.37968937e-01f, 8.74463767e-02f, -5.02272556e-03f, 9.03559476e-02f, 2.56324291e-01f, 9.65673104e-02f, 1.77358821e-01f, 3.02859902e-01f,
  1.90517083e-01f, -4.66159247e-02f, -4.97339591e-02f, 1.58231109e-01f, -3.03196739e-02f, 2.71615759e-02f, -2.25009248e-01f, -6.80882260e-02f, 1.17880069e-01f, -6.48910999e-02f,
  2.54294220e-02f, -7.74847493e-02f, -1.08449064e-01f, -1.80183515e-01f, -1.71362385e-01f, -2.08242223e-01f, -7.47674927e-02f, -2.40315139e-01f, -1.65462658e-01f, -1.05721459e-01f,
  -1.56476781e-01f, -7.56240711e-02f, 2.99543682e-02f, -5.71674146e-02f, 1.38818532e-01f, -3.07496060e-02f, 1.25531480e-02f, 1.18982024e-01f, 1.91982985e-02f, 7.94294402e-02f,
  -6.26326948e-02f, 2.39233971e-01f, -1.11492909e-01f, 5.89097962e-02f, 1.66412592e-02f, 6.49131164e-02f, -8.60402361e-02f, 9.87311155e-02f, -2.42031012e-02f, -5.74653270e-03f,
  2.13942211e-02f, -6.88057840e-02f, 1.13978945e-01f, 6.05372600e-02f, 6.49351701e-02f, -7.95887113e-02f, -1.58310577e-05f, -9.79838669e-02f, -2.47869827e-02f, -9.07631516e-02f,
  -5.99759370e-02f, 8.81431028e-02f, 3.08772437e-02f, -8.49077329e-02f, -5.91668859e-02f, -1.95354559e-02f, -1.82824284e-02f, 1.12217918e-01f, 9.16665867e-02f, 2.80822031e-02f,
  -2.74720825e-02f, -2.14066077e-02f, -4.27231453e-02f, 7.59881139e-02f, 3.80011201e-02f, 1.16549088e-02f, 2.22283471e-02f, -5.02998047e-02f, -1.31205404e-02f, 2.64096688e-02f,
  2.36734003e-02f, -7.88389072e-02f, 3.37042473e-02f, 5.14823431e-03f, -1.40448911e-02f, -7.80515894e-02f, 1.28197642e-02f, -1.08984418e-01f, -7.07339197e-02f, 5.50666973e-02f,
  -2.49153078e-02f, -3.35638709e-02f, -2.44939718e-02f, 1.77110685e-03f, -2.02030316e-02f, -7.99618140e-02f, 5.38425557e-02f, 8.69906470e-02f, -1.85898431e-02f, 8.06432217e-02f,
  6.89138323e-02f, -1.16059132e-01f, -4.62100143e-03f, 1.37646934e-02f, 3.52200028e-03f, -5.40134124e-02f, -2.98914704e-02f, 3.99647653e-03f, 2.80742943e-02f, 3.21613513e-02f,
  -3.03623471e-02f, 7.11589633e-03f, -5.66000231e-02f, -8.01478550e-02f, -1.14504613e-01f, 3.50106098e-02f, -5.64362668e-02f, 1.63438302e-02f, -3.46152708e-02f, 2.57901922e-02f,
  -1.65295541e-01f, -1.60526097e-01f, -4.92182234e-03f, -5.63669130e-02f, -9.13066760e-05f, 3.24186198e-02f, -1.26753792e-01f, -2.22097784e-02f, -8.08066800e-02f, -6.39811456e-02f,
  -2.29920875e-02f, 2.71965414e-02f, 2.39357352e-02f, 3.38534936e-02f, -8.36281031e-02f, -1.23556934e-01f, -1.00111954e-01f, -8.21867883e-02f, -4.98600490e-02f, 3.88967469e-02f,
  -1.18066398e-02f, 5.68370521e-02f, 9.61126667e-03f, -1.64365053e-01f, -1.86626494e-01f, -7.63222501e-02f, -7.62861641e-03f, -9.40687805e-02f, -1.92456171e-01f, -7.16103539e-02f,
  -2.48432495e-02f, -6.48756698e-02f, -2.09727306e-02f, 2.22939514e-02f, 1.74598326e-03f, -1.99991092e-02f, 1.39328241e-01f, 8.98907706e-02f, 5.99751920e-02f, 8.89401510e-02f,
  1.03237905e-01f, 1.35689780e-01f, -8.30785483e-02f, -3.39848325e-02f, -1.29359271e-02f, -2.92590423e-03f, 1.26356706e-02f, -7.28281513e-02f, -4.87576537e-02f, -1.70744788e-02f,
  5.03081232e-02f, -4.11217138e-02f, 6.74064010e-02f, -3.56569402e-02f, -7.41575360e-02f, -9.56999436e-02f, -6.51082769e-02f, -6.87408894e-02f, -4.64114547e-02f, -3.45285758e-02f,
  2.25349758e-02f, -7.50062913e-02f, -9.44511667e-02f, -1.11509964e-01f, 6.28239661e-02f, -7.50716701e-02f, 5.61558567e-02f, 4.39208979e-03f, -5.88184409e-03f, 1.08298868e-01f,
  5.85214701e-03f, -5.03022335e-02f, 8.78652930e-03f, -6.87810853e-02f, 5.42765744e-02f, 1.32377753e-02f, -5.69702461e-02f, -6.46621510e-02f, -4.83365655e-02f, -6.23053089e-02f,
  6.16646074e-02f, 4.19010520e-02f, -1.89079735e-02f, -9.29606408e-02f, 7.76254162e-02f, -9.36506093e-02f, -3.38454954e-02f, -3.80742028e-02f, -8.79154652e-02f, -2.66226027e-02f,
  4.65913601e-02f, 1.12343384e-02f, -2.37297025e-02f, -9.34287608e-02f, 4.56613787e-02f, 5.66168614e-02f, 8.29941481e-02f, -2.53244918e-02f, 7.21356943e-02f, 5.53974546e-02f,
  -3.22071649e-02f, -3.12851183e-02f, -8.16056207e-02f, -8.68390873e-02f, 3.05425711e-02f, -3.83898690e-02f, 7.10771978e-02f, -7.25352913e-02f, 5.84920775e-03f, -5.54873012e-02f,
  1.71037354e-02f, -9.89484638e-02f, 3.47746387e-02f, 2.78511401e-02f, 1.23194000e-02f, -1.08747847e-01f, -7.36827916e-03f, -2.34831963e-02f, -3.55049558e-02f, 6.76076114e-02f,
  4.09480706e-02f, -1.20071001e-01f, -1.18846253e-01f, -3.31845097e-02f, 2.14946046e-02f, -7.73119330e-02f, 2.15523560e-02f, 3.78448963e-02f, -5.69732115e-03f, 3.30217299e-05f,
  1.91868693e-02f, -5.36364503e-02f, 2.55958200e-01f, 3.23212780e-02f, -1.47711605e-01f, -1.91829965e-01f, -3.37456912e-01f, -8.37019831e-02f, -4.27394360e-02f, -1.41393408e-01f,
  -1.66763186e-01f, -4.31598350e-02f, 1.47956431e-01f, 1.37369454e-01f, 2.83890143e-02f, 7.23543763e-02f, 7.55587146e-02f, 1.94484964e-01f, 1.33289807e-02f, -9.27006751e-02f,
  -8.67317468e-02f, -8.30251947e-02f, 9.08599347e-02f, -9.16273333e-03f, 5.71127376e-03f, -6.71563447e-02f, 1.42328665e-01f, -4.23461981e-02f, -3.17164026e-02f, -5.82123995e-02f,
  1.21101812e-01f, -1.28024206e-01f, -3.77348810e-02f, -2.19570962e-03f, 6.25211373e-02f, 1.94372199e-02f, 3.79774789e-03f, 1.12675704e-01f, -5.19516356e-02f, 2.85261627e-02f,
  3.43429632e-02f, 1.19080935e-02f, -9.29539278e-02f, -8.14174488e-02f, -1.30063444e-02f, -1.01616539e-01f, 1.19291238e-01f, 8.46227333e-02f, 3.79154831e-02f, -4.42627445e-02f,
  -9.03870538e-02f, -1.04573801e-01f, -5.77096753e-02f, 1.25043895e-02f, 5.08851148e-02f, -1.75046232e-02f, -7.81527236e-02f, -4.24277484e-02f, -9.80704837e-03f, -1.03891611e-01f,
  4.84292470e-02f, 1.08190989e-02f, 6.10340275e-02f, -5.12412786e-02f, -4.11492549e-02f, 4.38262038e-02f, -5.29901264e-03f, 3.72376293e-02f, -5.40855266e-02f, 2.88053919e-02f,
  2.40659807e-04f, -6.13957085e-02f, 5.92909493e-02f, 7.64999986e-02f, 4.53647524e-02f, -2.35065129e-02f, 3.73155102e-02f, 1.35620534e-02f, 3.32176611e-02f, 1.21598728e-02f,
  -4.71115597e-02f, 6.75535724e-02f, 8.63143504e-02f, 1.64841656e-02f, -1.36000775e-02f, 1.14485994e-01f, -6.14360906e-02f, -4.67974655e-02f, -2.30885725e-02f, 1.03703029e-02f,
  -2.16227267e-02f, 1.63920656e-01f, -7.66479596e-02f, 5.40732108e-02f, 4.95917676e-03f, -5.78348478e-03f, -6.69784024e-02f, 6.44030399e-04f, -8.99184681e-03f, -5.36211487e-03f,
  -1.25312954e-01f, -1.01136491e-01f, 6.60154969e-02f, -4.30184454e-02f, -1.06981173e-01f, -7.12318420e-02f, -8.99429247e-02f, 2.31878348e-02f, 4.02885899e-02f, -6.67862818e-02f,
  -1.02366060e-02f, -1.34236932e-01f, -4.38864343e-03f, 3.20074297e-02f, -1.54379681e-02f, -3.66523191e-02f, -3.08251772e-02f, -1.09555855e-01f, -6.11634329e-02f, -1.12540483e-01f,
  4.53239501e-01f, 3.14139873e-01f, 1.30843267e-01f, 7.56479278e-02f, 5.50057143e-02f, 2.00018898e-01f, 2.81144261e-01f, 7.99686462e-02f, -2.54078824e-02f, 3.67377028e-02f,
  -8.97254497e-02f, -2.22007841e-01f, -2.31468365e-01f, -1.23143747e-01f, 2.49427985e-02f, -8.77444074e-03f, -9.97236185e-03f, 4.68216687e-02f, -3.51542011e-02f, -2.38003973e-02f,
  -4.60437275e-02f, 1.25623360e-01f, 2.45332554e-01f, -1.69849605e-03f, 1.02275768e-02f, -1.31369010e-01f, -1.82132125e-02f, 1.06121965e-01f, 1.02453649e-01f, -7.57331494e-03f,
  -4.68797311e-02f, 3.13797802e-01f, -1.13572657e-01f, -4.62978110e-02f, -2.75243800e-02f, -1.00229308e-01f, -5.51472651e-03f, -2.94727534e-02f, -1.68135259e-02f, 1.35025289e-02f,
  -1.39613286e-01f, 3.34612578e-02f, -3.85184139e-02f, -4.04665321e-02f, -3.50300968e-02f, 8.54613334e-02f, -4.81909066e-02f, 6.82943538e-02f, -9.65018049e-02f, -9.17681530e-02f,
  -1.94408417e-01f, 2.97748912e-02f, 1.62345484e-01f, -1.57842655e-02f, -5.78778088e-02f, -7.26565644e-02f, 1.05354048e-01f, -4.97070737e-02f, -4.87328544e-02f, 4.72130030e-02f,
  -9.62393954e-02f, -8.05524364e-02f, 2.96202842e-02f, -2.59250514e-02f, -6.28811354e-03f, 2.46194638e-02f, -1.15614995e-01f, 1.85098778e-02f, 1.37558486e-03f, 9.82540846e-02f,
  1.85768083e-02f, -5.54481670e-02f, 1.03295746e-03f, 1.32246884e-02f, -1.39368013e-01f, 6.08275831e-03f, -4.86159995e-02f, 5.27061149e-02f, 1.03831433e-01f, -3.62603776e-02f,
  -1.37168122e-02f, 2.28915494e-02f, -3.28995436e-02f, -4.07190323e-02f, -8.86608660e-02f, 3.85339186e-02f, 1.39552243e-02f, -2.45109648e-02f, -8.80057085e-03f, 9.40591097e-02f,
  2.43528821e-02f, -1.30058914e-01f, -5.19690476e-02f, -4.84601036e-03f, 4.73927781e-02f, -1.16788313e-01f, -2.91972142e-02f, -7.67346546e-02f, -9.21169072e-02f, 3.99954654e-02f,
  -6.67352155e-02f, -2.68332083e-02f, -4.42927368e-02f, 8.54527764e-03f, 8.07790235e-02f, 1.10928835e-02f, 7.32536539e-02f, -9.30763409e-02f, 1.07165482e-02f, 3.37794498e-02f,
  -2.14049462e-02f, -4.24483418e-03f, 3.27044241e-02f, -2.75005810e-02f, 1.68346930e-02f, -5.66783175e-02f, 4.13653888e-02f, 1.61432922e-02f, -1.89449284e-02f, 1.02285221e-01f,
  -6.80670321e-01f, 1.86063468e-01f, 1.24787964e-01f, -2.04770938e-01f, 9.94039625e-02f, 2.39182130e-01f, 3.03142339e-01f, -1.15706604e-02f, -1.51812613e-01f, -5.19360323e-03f,
  5.46339974e-02f, -1.51650473e-01f, -8.94735008e-02f, 1.05701044e-01f, 5.18380664e-02f, 2.63621300e-01f, 2.48453557e-01f, -7.53892912e-03f, -1.36244774e-01f, 2.25903466e-02f,
  1.52689461e-02f, -1.71425745e-01f, -3.24631363e-01f, -2.77013816e-02f, 6.19722754e-02f, 2.05420330e-02f, 5.89984171e-02f, -5.15968204e-02f, 1.09924339e-01f, 2.31882468e-01f,
  -6.16492182e-02f, -1.94421694e-01f, -7.09150033e-03f, -5.62311374e-02f, 3.14670019e-02f, -8.95832032e-02f, -1.50909368e-02f, -8.82224664e-02f, -3.51449735e-02f, -2.52544391e-03f,
  1.13973124e-02f, 4.19669226e-02f, -7.41836876e-02f, 3.26137356e-02f, -1.25353739e-01f, -4.61871400e-02f, -1.40022546e-01f, -9.25548896e-02f, -1.29858539e-01f, -7.79538453e-02f,
  1.20168544e-01f, -3.56210060e-02f, -1.55256495e-01f, -2.50994582e-02f, -1.75045699e-01f, -1.47947699e-01f, -1.25053957e-01f, -4.85728867e-02f, -3.89277339e-02f, -2.61926770e-01f,
  4.29392941e-02f, 2.43185498e-02f, 4.12315205e-02f, -4.70342226e-02f, 9.12747812e-03f, -3.47208381e-02f, 1.25337437e-01f, 1.06965251e-01f, -5.73388627e-03f, -1.29554663e-02f,
  -3.81705984e-02f, 8.30076635e-03f, -7.02844635e-02f, -3.08888201e-02f, -2.34989095e-02f, -6.53915433e-03f, 8.38742312e-03f, 5.84056117e-02f, 1.01920096e-02f, -1.63195021e-02f,
  -7.77887329e-02f, -7.76285827e-02f, -5.33796474e-02f, 1.72318127e-02f, 8.50382820e-02f, 2.39722915e-02f, -4.03901227e-02f, -8.55447128e-02f, -7.12352097e-02f, -2.22960161e-03f,
  -3.77745688e-01f, 1.75690770e-01f, -1.48898199e-01f, -1.14830397e-01f, 8.75566155e-02f, -3.13979238e-02f, 5.51367644e-04f, -4.49756794e-02f, -1.45847574e-02f, -7.68414959e-02f,
  -2.69957781e-02f, -9.37413648e-02f, -5.33499382e-02f, -1.12676576e-01f, -1.86736792e-01f, -9.25040469e-02f, 9.14927514e-04f, -7.48679265e-02f, -6.38872311e-02f, -2.01972406e-02f,
  -2.81102862e-02f, -2.12923303e-01f, -3.10972482e-01f, -6.85577020e-02f, -1.18469812e-01f, -1.81192026e-01f, -1.27107605e-01f, -1.43670976e-01f, -2.23826572e-01f, -2.77044833e-01f,
  1.07301511e-01f, -6.13895357e-02f, 2.26223692e-01f, -9.81366914e-03f, -1.71811432e-01f, -2.49574989e-01f, -1.91796824e-01f, -8.55790898e-02f, -1.21550918e-01f, -5.80819249e-02f,
  -1.00867592e-01f, -1.74817035e-03f, 7.93047308e-04f, 6.57849908e-02f, 2.26832420e-01f, -1.95696540e-02f, 1.16502039e-01f, 2.61317492e-01f, 9.05530229e-02f, 5.24956509e-02f,
  -1.10703193e-01f, 2.23800782e-02f, 2.48826861e-01f, 1.83456510e-01f, 7.46498024e-03f, 6.69010878e-02f, 8.11609477e-02f, 6.15569428e-02f, 7.68654272e-02f, 8.07427317e-02f,
  -3.51409544e-03f, 8.72935876e-02f, -9.55280140e-02f, -1.09190926e-01f, -7.87001774e-02f, 1.06075741e-01f, 4.08715084e-02f, 8.64189789e-02f, 2.77983211e-02f, 3.05946153e-02f,
  -7.56922439e-02f, 2.64415517e-02f, 1.09549360e-02f, -8.40292871e-02f, -3.74537520e-03f, 4.89146076e-02f, 3.80870439e-02f, 2.47028157e-01f, 1.74184114e-01f, 8.76412913e-02f,
  -1.19760528e-01f, -2.00606272e-01f, -5.77032417e-02f, -4.67938781e-02f, 1.15363680e-01f, -5.05847484e-02f, 1.66497584e-02f, -4.72822860e-02f, -7.00414507e-03f, 8.10668468e-02f,
  9.75664146e-03f, 5.72630316e-02f, -3.77267040e-02f, 2.68435087e-02f, 5.80851249e-02f, 1.61884760e-03f, -5.94143383e-03f, 2.69634873e-02f, -2.28913091e-02f, -1.09467767e-02f,
  9.73367542e-02f, 3.03883497e-02f, -5.06828306e-03f, 7.24175051e-02f, 3.42378840e-02f, 5.34176342e-02f, 2.76155528e-02f, 7.32074529e-02f, 2.39235964e-02f, -4.87090386e-02f,
  4.30211388e-02f, -1.17678689e-02f, 1.20979501e-02f, 8.49607065e-02f, 5.90180755e-02f, -2.58923937e-02f, -8.87713283e-02f, -3.59025784e-02f, -4.30298112e-02f, 8.24943744e-03f,
  -1.14384137e-01f, 9.90843326e-02f, -5.81064820e-02f, -6.98631406e-02f, 8.21611471e-03f, -2.42556725e-02f, -6.54182658e-02f, 6.01319149e-02f, -3.08567807e-02f, 8.16209067e-04f,
  -8.70790854e-02f, -7.33103082e-02f, -9.99825895e-02f, -3.61089758e-03f, -4.01240736e-02f, -5.17927781e-02f, -1.60750404e-01f, 5.55473827e-02f, 1.28104258e-02f, 1.22463778e-02f,
  -1.38329379e-02f, -1.16137356e-01f, -5.63093871e-02f, -1.19201504e-01f, -3.54270563e-02f, -1.40069321e-01f, -7.47964606e-02f, -5.51144518e-02f, 1.15670580e-02f, -2.51239222e-02f,
  1.34872749e-01f, -3.48887563e-01f, 7.49810636e-02f, -2.26321686e-02f, -8.66092145e-02f, -9.13825557e-02f, -2.73770154e-01f, -5.45432456e-02f, -1.06902681e-01f, -2.52860755e-01f,
  -1.88021943e-01f, 1.60545319e-01f, 9.85211357e-02f, 3.78065109e-02f, 1.31546259e-01f, -1.68895453e-01f, 4.63411883e-02f, 3.35466623e-01f, 3.76773953e-01f, 6.16889857e-02f,
  -1.27836401e-02f, 3.81684303e-03f, 1.02340676e-01f, 9.12566409e-02f, -2.33532235e-01f, -3.35596949e-02f, -7.78761432e-02f, -9.60702822e-02f, -8.32741931e-02f, -2.19973445e-01f,
  -6.06503077e-02f, -5.28179146e-02f, 1.38069421e-01f, 1.34175763e-01f, -3.40060852e-02f, 7.14449808e-02f, -4.94165404e-04f, 1.99968606e-04f, 2.42750589e-02f, -1.37787640e-01f,
  -5.84808514e-02f, 6.02714941e-02f, 3.45830694e-02f, -9.38916430e-02f, -1.22677805e-02f, 3.54661196e-02f, -4.89530005e-02f, 1.37221217e-01f, 8.32533091e-02f, -1.48827946e-02f,
  -1.32956937e-01f, -8.78708884e-02f, 8.90009701e-02f, 3.92708965e-02f, 9.16907042e-02f, 1.67802066e-01f, 7.09751174e-02f, 8.42646137e-02f, 6.26918450e-02f, -1.49710625e-01f,
  3.18599902e-02f, 5.13182841e-02f, 7.89301470e-02f, 1.08066816e-02f, -2.20423993e-02f, 4.26007025e-02f, 9.97551437e-03f, -2.31065173e-02f, 3.01412698e-02f, 4.60465662e-02f,
  -9.45281424e-03f, 4.33351938e-03f, 1.84686761e-02f, -3.53386713e-04f, 5.52509092e-02f, -3.86653468e-03f, 2.02682391e-02f, -1.08624652e-01f, 7.13735595e-02f, 2.70731132e-02f,
  5.49717136e-02f, 1.33690806e-02f, -2.31083799e-02f, -7.15983361e-02f, -2.79504284e-02f, -4.04684991e-02f, -1.80733241e-02f, 1.78357717e-02f, 3.58663984e-02f, 1.11440234e-02f,
  -1.56384617e-01f, 3.39455098e-01f, -2.31631789e-02f, 2.59681661e-02f, 2.85698548e-02f, 6.28865734e-02f, 1.79566089e-02f, -2.41775699e-02f, -8.49018916e-02f, -2.78307833e-02f,
  -2.75884010e-02f, 3.69803309e-02f, 3.65516581e-02f, -8.04615300e-03f, -1.00993458e-02f, -1.15193585e-02f, 2.79090703e-02f, 2.01671384e-02f, 2.14405935e-02f, -1.57672390e-01f,
  3.67335044e-03f, -7.76519999e-02f, 5.21563627e-02f, -6.59822375e-02f, -2.15137713e-02f, 2.20279515e-01f, -6.03581518e-02f, 5.39163388e-02f, 1.24889351e-01f, -8.41683298e-02f,
  6.01023659e-02f, 1.69724852e-01f, 1.54885560e-01f, 1.01829402e-01f, 2.66160727e-01f, 2.06712157e-01f, 3.08312654e-01f, -5.06003993e-03f, 5.89232631e-02f, -3.32765579e-02f,
  1.45277986e-03f, -1.40809789e-01f, -1.17355026e-02f, -2.37431228e-02f, -2.39072349e-02f, -4.44236211e-02f, 6.78390339e-02f, 1.97242219e-02f, -2.52318624e-02f, -2.64357179e-02f,
  -2.76947469e-02f, -3.14245261e-02f, 5.49609959e-02f, -8.20990130e-02f, -6.37290105e-02f, -9.19841975e-02f, 8.61828551e-02f, 1.21539067e-02f, 1.05805360e-01f, -8.11363850e-03f,
  -1.13657666e-02f, 2.33201042e-01f, -9.38038677e-02f, -5.25924489e-02f, -1.06647247e-02f, -6.66491464e-02f, 8.11397750e-03f, -3.71729545e-02f, 5.61282896e-02f, 2.75411680e-02f,
  -4.29092981e-02f, 6.03063032e-03f, 1.10593569e-02f, -2.70491689e-02f, -6.30107149e-03f, -1.07148841e-01f, -3.40158939e-02f, -1.43785983e-01f, 2.77866926e-02f, 3.78133878e-02f,
  7.17571797e-03f, 3.61462161e-02f, 2.03057840e-01f, -2.69507058e-02f, -5.76673597e-02f, -4.28901613e-02f, 3.41962948e-02f, 5.69814369e-02f, -4.45053130e-02f, -9.28293616e-02f,
  -8.61327276e-02f, 7.81350583e-02f, 1.91158301e-03f, 3.00272815e-02f, -8.22419971e-02f, 4.50497493e-02f, 4.04568575e-02f, -3.85154188e-02f, 9.29452758e-03f, -5.11864014e-02f,
  -4.96746935e-02f, 3.12340949e-02f, 3.31274159e-02f, 1.87122636e-02f, -3.56313512e-02f, 4.16560881e-02f, -3.15996073e-02f, 2.18828185e-03f, -3.21699195e-02f, -4.45778593e-02f,
  -7.71523267e-02f, 1.01322956e-01f, -2.30961316e-03f, -3.53800878e-02f, 4.16443683e-02f, -3.77099477e-02f, -1.13172002e-01f, -7.32099712e-02f, -3.63317654e-02f, -1.51431505e-02f,
  -2.34338433e-01f, 3.36505622e-02f, -7.64505789e-02f, -1.39600411e-01f, 8.58228132e-02f, 1.17275212e-02f, -6.65430650e-02f, -3.05172335e-02f, -2.16467306e-02f, -2.96315234e-02f,
  1.12251252e-01f, 1.81892160e-02f, -1.18071614e-02f, -8.63300636e-02f, -8.67161825e-02f, -7.69044161e-02f, -9.86296386e-02f, -1.36537086e-02f, 5.00560589e-02f, 7.27354432e-04f,
  -1.87163539e-02f, 8.41715746e-03f, 2.87333038e-03f, -8.76554623e-02f, -7.51623437e-02f, 4.45768144e-03f, 7.71322623e-02f, -6.97239488e-02f, 4.54700701e-02f, -5.47695383e-02f,
  1.44192502e-01f, -2.32433215e-01f, 6.59806356e-02f, -6.75248951e-02f, -2.00311854e-01f, -3.47639859e-01f, -3.51012647e-01f, -1.83843061e-01f, -4.11970802e-02f, -2.13956982e-01f,
  -6.97114989e-02f, -2.48163883e-02f, -2.25860905e-02f, 7.15645030e-02f, 5.60720228e-02f, -2.09597468e-01f, -1.18239276e-01f, 3.11585605e-01f, 2.61745185e-01f, 1.21534288e-01f,
  6.11327775e-02f, 1.20619990e-01f, 3.71929079e-01f, 1.06598094e-01f, 4.88806330e-02f, 4.89438884e-03f, 3.16300057e-02f, 1.36734813e-01f, -9.08406600e-02f, -4.19609323e-02f,
  -1.24429524e-01f, -1.85804889e-02f, 7.11255074e-02f, 5.90327941e-02f, -8.50187093e-02f, -8.44336301e-03f, -1.16100170e-01f, 5.27453311e-02f, 2.62255426e-02f, -8.30771551e-02f,
  -8.42459872e-02f, 2.55747717e-02f, -7.00500309e-02f, 3.84607762e-02f, -7.12403432e-02f, -7.47770518e-02f, 9.90481004e-02f, 6.37918934e-02f, 1.17943980e-01f, -6.70642592e-04f,
  -8.84792432e-02f, -8.92404243e-02f, -7.46061057e-02f, -8.82050470e-02f, -4.30227593e-02f, 1.24995276e-01f, -1.19633395e-02f, 7.86486641e-03f, -7.34636709e-02f, -5.13782799e-02f,
  -2.76502892e-02f, -6.91938587e-03f, 1.02120042e-02f, -2.53895912e-02f, -3.57995294e-02f, -5.20870984e-02f, -1.97664928e-02f, 4.32584882e-02f, 4.31776643e-02f, -6.68218210e-02f,
  4.19749059e-02f, -1.01297209e-02f, 7.11253285e-02f, -3.27207111e-02f, 1.09740913e-01f, -4.15396579e-02f, 1.26206176e-02f, 2.14940496e-02f, 6.77037090e-02f, -1.44137423e-02f,
  3.42419855e-02f, -4.62082773e-02f, 2.00253050e-03f, 1.22208754e-03f, 3.27695510e-03f, 9.24094170e-02f, 3.91862802e-02f, -2.51043309e-02f, -2.05810536e-02f, -3.13276164e-02f,
  -9.19846701e-04f, 8.26363564e-02f, -1.33796394e-01f, 4.19265404e-02f, -1.13415699e-02f, 4.01265882e-02f, -1.04764193e-01f, 7.72947026e-03f, -3.00338473e-02f, -2.67039030e-03f,
  5.33221401e-02f, 3.63534205e-02f, -1.46206170e-01f, 2.57059056e-02f, -3.83096747e-02f, -3.67893539e-02f, -3.73048112e-02f, 2.32642349e-02f, 1.46650132e-02f, -7.97547475e-02f,
  -3.75611186e-02f, -1.19704641e-01f, -1.59074798e-01f, -1.22572884e-01f, -1.44277081e-01f, -1.58272251e-01f, -1.83280826e-01f, -1.91606984e-01f, -8.22068378e-02f, -1.22062072e-01f,
  -1.84971720e-01f, -9.52071324e-02f, 4.41425703e-02f, 3.36581208e-02f, 8.65962207e-02f, -1.81495726e-01f, -3.64714175e-01f, -2.65362978e-01f, -3.41177806e-02f, -7.29340538e-02f,
  3.81183513e-02f, -1.09574683e-02f, 1.08911663e-01f, 1.40362578e-02f, -9.52653363e-02f, -1.16737753e-01f, 1.23101011e-01f, 1.19082794e-01f, -2.59667020e-02f, -1.15360111e-01f,
  5.19143827e-02f, 9.04989988e-02f, 1.92881990e-02f, 1.08740456e-01f, 2.75110248e-02f, 8.54089856e-02f, 1.27618089e-01f, 6.72041103e-02f, 1.09506547e-01f, 1.35429472e-01f,
  -3.49166878e-02f, -1.19460933e-01f, -4.18841019e-02f, 1.20542012e-01f, 8.85435268e-02f, -8.24470967e-02f, -9.38626304e-02f, -4.62700464e-02f, 8.17515403e-02f, -7.72809982e-02f,
  8.53720307e-02f, 4.69902009e-02f, -5.61676770e-02f, 3.32695059e-02f, -3.55102564e-03f, -1.54036045e-01f, -2.31579710e-02f, 2.81220786e-02f, -3.96765955e-02f, -1.46006286e-01f,
  -2.13016644e-02f, -7.95025676e-02f, -1.70414314e-01f, -9.63318497e-02f, -1.63521439e-01f, -4.69265394e-02f, -1.21123128e-01f, -1.34240091e-01f, -3.50759029e-02f, -2.30268106e-01f,
  3.91805060e-02f, 8.08611438e-02f, 9.74283461e-03f, -2.56326143e-02f, -6.65234625e-02f, 5.69152683e-02f, -6.81924149e-02f, -1.26362918e-02f, 6.13752566e-03f, 5.12472726e-02f,
  -2.00775824e-02f, -1.82448514e-02f, 5.89018539e-02f, -8.82820506e-03f, -3.69930640e-02f, -7.07591418e-03f, -6.09917054e-03f, -8.57400894e-02f, 4.87938263e-02f, -5.80253862e-02f,
  4.23330441e-02f, -5.48796877e-02f, 2.55519766e-02f, -6.78650439e-02f, 6.52046548e-03f, -1.69892721e-02f, -7.32044429e-02f, 4.99839485e-02f, -6.02739342e-02f, 3.76387760e-02f,
  1.10189646e-01f, 9.30060521e-02f, -5.07028122e-03f, -7.43202642e-02f, 5.42872120e-03f, 6.15012534e-02f, 2.53072493e-02f, 1.70965809e-02f, 6.00355212e-03f, -1.49294198e-01f,
  -4.48285304e-02f, -8.07239413e-02f, 4.19479236e-02f, -3.53072435e-02f, 1.42453406e-02f, -3.43182050e-02f, -6.61672046e-03f, -7.92049095e-02f, 2.88203880e-02f, -1.27205357e-01f,
  1.55101987e-02f, -2.07195953e-01f, -1.93547651e-01f, -9.42652225e-02f, -6.77268803e-02f, -9.31436755e-03f, -6.13240860e-02f, -7.11869150e-02f, -1.88279733e-01f, -1.70033485e-01f,
  -3.13301653e-01f, 1.59255624e-01f, 2.50925049e-02f, -2.00763538e-01f, -1.11709900e-01f, -8.02830458e-02f, 6.05578683e-02f, -1.37838393e-01f, -2.33374879e-01f, 5.02892099e-02f,
  1.57323852e-02f, -4.42565195e-02f, 1.06924996e-02f, -9.88424756e-03f, 7.38196773e-03f, 8.16792250e-02f, -8.84231459e-03f, -3.43853515e-03f, -1.99908718e-01f, -1.67198613e-01f,
  -8.21904242e-02f, -2.05961704e-01f, -2.54373461e-01f, -2.01909363e-01f, -3.75215970e-02f, -9.28402469e-02f, -8.01417604e-02f, -9.53203440e-02f, 3.53718661e-02f, -5.86931072e-02f,
  9.82141420e-02f, -4.98925112e-02f, -1.53031982e-02f, 7.21784830e-02f, -5.38416505e-02f, -4.23433110e-02f, -3.36305723e-02f, -2.02480331e-02f, -1.21731140e-01f, -3.47548500e-02f,
  -5.29230051e-02f, -2.08810177e-02f, -1.16024919e-01f, 3.13126743e-02f, -1.56156188e-02f, -8.37658197e-02f, -8.15612674e-02f, 6.69764075e-03f, 8.31248180e-04f, -3.54244094e-03f,
  1.02195330e-01f, -5.34915663e-02f, 1.12400807e-01f, -4.50592004e-02f, 9.38918144e-02f, -4.34824079e-02f, 9.47649777e-02f, 2.63664518e-02f, 6.25596642e-02f, 1.80884711e-02f,
  2.19004527e-02f, 5.35018258e-02f, -4.81048971e-02f, -2.13079471e-02f, -7.32157528e-02f, 3.40970047e-02f, 3.68307554e-03f, -1.96448062e-02f, 4.64624316e-02f, 7.94120692e-03f,
  5.47810793e-02f, -1.30225066e-02f, -4.71481606e-02f, 9.90506448e-03f, 5.39196879e-02f, -6.00031354e-02f, 7.45013133e-02f, 1.04706042e-01f, 6.76405877e-02f, 6.60050139e-02f,
  7.23597854e-02f, -1.08726388e-02f, -8.58224090e-03f, 3.66140753e-02f, 6.64849579e-02f, 1.31769357e-02f, -7.03479350e-02f, 1.01895064e-01f, -5.82766496e-02f, -3.41886245e-02f,
  -5.77173717e-02f, 4.76508997e-02f, 4.16056961e-02f, 6.82001859e-02f, -1.04791842e-01f, 3.25297974e-02f, 4.01019678e-02f, -7.20032491e-04f, -9.81798768e-02f, -4.50038053e-02f,
  9.76349488e-02f, -5.97324297e-02f, -3.45892385e-02f, 5.49379783e-03f, 1.53036676e-02f, -2.16457341e-02f, 9.45221707e-02f, -2.61167437e-02f, 1.27597585e-01f, -1.17310823e-03f,
  8.84820744e-02f, 7.95349479e-02f, 1.12700261e-01f, 1.62637278e-01f, -3.87316979e-02f, 7.64338002e-02f, 7.86724091e-02f, 2.02870071e-02f, 3.05154864e-02f, 1.23604275e-01f,
  -4.04751211e-01f, -7.48134851e-02f, -1.45623484e-03f, 2.19464973e-02f, -4.74983081e-02f, -4.00454290e-02f, -1.50696680e-01f, 6.25518244e-03f, 4.17218395e-02f, -1.34172767e-01f,
  -1.09615155e-01f, 8.34263414e-02f, 8.90757889e-02f, 1.47651941e-01f, 3.04421061e-03f, -2.21291967e-02f, 1.56714201e-01f, 5.21888956e-02f, -1.26147661e-02f, 4.32487950e-03f,
  1.44553348e-01f, 5.42852916e-02f, 1.03490390e-01f, 5.27160913e-02f, 9.31979567e-02f, 1.52517483e-01f, -5.14347199e-03f, 4.21836749e-02f, 7.29280561e-02f, -2.29652748e-02f,
  3.38836610e-02f, -1.56995490e-01f, 1.36678308e-01f, 1.22711748e-01f, 7.89437816e-03f, -1.20930873e-01f, -1.89726371e-02f, 5.76870516e-02f, 2.18466949e-02f, 5.95643260e-02f,
  9.58339032e-03f, -1.34220521e-03f, 9.23158303e-02f, -7.54169933e-03f, -6.69097155e-02f, 3.13272774e-02f, 3.44721824e-02f, 1.03475752e-04f, 5.96089195e-03f, 3.49660106e-02f,
  1.23856030e-01f, -6.37456626e-02f, 5.56768440e-02f, 6.08290322e-02f, -1.93783976e-02f, 1.44493565e-01f, 4.40549105e-02f, 6.45531714e-02f, -4.95803803e-02f, -6.12971038e-02f,
  3.23320664e-02f, 1.70518560e-05f, 3.70748751e-02f, 8.35999399e-02f, -4.77045067e-02f, -4.61983718e-02f, 5.64936660e-02f, 5.21030016e-02f, 5.48693165e-03f, -4.63518128e-02f,
  -3.37343477e-02f, -2.28622649e-02f, 6.90771639e-02f, -8.95396248e-02f, -2.43042000e-02f, -3.18086632e-02f, -2.39672959e-02f, 5.18705659e-02f, 4.98911254e-02f, -4.32094224e-02f,
  -9.10282582e-02f, -2.86026057e-02f, 2.40839832e-02f, 7.53473341e-02f, 2.15048362e-02f, -1.61517933e-02f, 1.93643235e-02f, -6.05931766e-02f, -7.89099336e-02f, -1.58438329e-02f,
  3.80778313e-02f, 8.21778625e-02f, -9.31438506e-02f, -3.13868076e-02f, 6.17181472e-02f, -4.09208797e-02f, 4.16673757e-02f, -3.38955708e-02f, -2.62853839e-02f, -2.89565716e-02f,
  1.56163396e-02f, 4.04784828e-02f, 3.13761346e-02f, 8.08286294e-03f, 9.05521438e-02f, 3.79433706e-02f, -2.89387419e-03f, 9.36918259e-02f, -1.22770136e-02f, 5.99559732e-02f,
  4.57789702e-03f, -8.26138034e-02f, -9.63530540e-02f, 1.68742370e-02f, 7.08649755e-02f, 1.48852225e-02f, -3.13248858e-02f, -1.50321191e-02f, -6.53085206e-03f, -1.47172272e-01f,
  3.59705508e-01f, 3.02684665e-01f, 2.24993840e-01f, 1.12054974e-01f, 1.29801169e-01f, 1.06233329e-01f, 2.76311994e-01f, 1.93388090e-01f, 6.72248900e-02f, 5.56016974e-02f,
  1.96926624e-01f, 7.79280066e-02f, 3.61305512e-02f, 4.81335856e-02f, 1.45201385e-01f, 1.14947736e-01f, -8.77511799e-02f, 2.27246433e-02f, -6.03769943e-02f, -5.90619184e-02f,
  -5.70076071e-02f, -2.61211675e-02f, 9.41265002e-02f, -8.00816193e-02f, -7.39249289e-02f, -1.56750917e-01f, 2.73422655e-02f, 1.19801104e-01f, 2.16506124e-02f, -6.86709285e-02f,
  -9.07336995e-02f, 3.38392317e-01f, -2.36265019e-01f, -7.45659769e-02f, 3.44902836e-02f, -1.19109474e-01f, 3.51194665e-02f, -6.85984343e-02f, 4.06201854e-02f, -1.47714745e-02f,
  -5.88953309e-02f, -4.33029197e-02f, -2.71531846e-02f, -5.34431599e-02f, 1.01389647e-01f, 7.62011558e-02f, 1.78422481e-02f, 1.27913579e-01f, -3.85577753e-02f, 5.23721464e-02f,
  6.23508468e-02f, 1.11462764e-01f, 1.64395109e-01f, -1.61421187e-02f, 5.89038245e-02f, 2.96551883e-02f, 1.17043242e-01f, -1.49123557e-03f, 1.09181732e-01f, 2.23825928e-02f,
  2.84933858e-03f, 4.73415386e-03f, 4.68152128e-02f, 9.64357778e-02f, -2.73486432e-02f, -4.27090526e-02f, -2.27555837e-02f, -1.85629614e-02f, 1.67244840e-02f, 2.91128270e-02f,
  -3.00520975e-02f, 7.60160461e-02f, -3.33732814e-02f, 3.41298468e-02f, -1.00422844e-01f, 6.61485419e-02f, 2.93971170e-02f, 2.47160532e-03f, 3.68075483e-02f, -2.18991730e-02f,
  -2.27193236e-02f, 7.26450235e-02f, 7.95311779e-02f, -2.06334004e-03f, 5.77166006e-02f, 6.57278299e-02f, 4.33587283e-02f, -5.80668971e-02f, 6.86351210e-02f, 7.20782503e-02f,
  -1.28135100e-01f, 1.59789503e-01f, -1.63029015e-01f, -1.14093468e-01f, 5.04578128e-02f, -9.09752250e-02f, -3.88992466e-02f, 2.09301915e-02f, 2.52927355e-02f, -4.90583181e-02f,
  7.57671893e-02f, 3.53059210e-02f, 1.47934586e-01f, -8.39217678e-02f, -7.41909891e-02f, -7.51919076e-02f, -7.56370276e-02f, -1.76561512e-02f, 2.09121555e-02f, -1.92061104e-02f,
  -2.27546063e-03f, -7.17950240e-02f, -1.48416653e-01f, -7.26365969e-02f, -4.69431020e-02f, -1.55366614e-01f, -1.21183343e-01f, -9.78962407e-02f, -2.80341189e-02f, -1.31396130e-01f,
  4.05041575e-01f, -1.74836889e-01f, -3.79018575e-01f, -7.12185353e-02f, -2.56513059e-01f, -3.30211848e-01f, -4.11380917e-01f, -1.02736749e-01f, 5.97560368e-02f, -2.44686723e-01f,
  -4.50016037e-02f, 1.68401107e-01f, 1.27205446e-01f, -9.82011389e-03f, 5.15644103e-02f, -3.07375163e-01f, -2.51006514e-01f, -9.00720730e-02f, -1.89436171e-02f, -1.32637158e-01f,
  -1.93840176e-01f, -1.03178285e-01f, -2.01394688e-02f, 6.12805337e-02f, -9.46662351e-02f, -9.80262086e-02f, -1.69540569e-01f, -8.79134387e-02f, -2.37788513e-01f, -1.01178788e-01f,
  -2.13792205e-01f, 8.96662176e-02f, 5.51949367e-02f, 8.29554647e-02f, -5.49541451e-02f, 1.48010822e-02f, -1.66640785e-02f, 1.18169069e-01f, 6.15909807e-02f, -1.94631424e-02f,
  2.42636576e-02f, 1.08424067e-01f, 1.48977369e-01f, -4.34452221e-02f, 3.80951613e-02f, -8.84104297e-02f, 1.00433633e-01f, 7.72686154e-02f, 2.06282139e-02f, -9.59681869e-02f,
  -1.28735662e-01f, -5.79973646e-02f, 5.83661050e-02f, 5.66065311e-02f, 6.92531615e-02f, 8.19467679e-02f, 9.01340041e-03f, 2.37623174e-02f, 8.52017775e-02f, -5.35177328e-02f,
  -7.73016512e-02f, -2.68779770e-02f, -4.19237316e-02f, 1.14112208e-02f, -1.76946428e-02f, 2.21050158e-02f, -1.09205097e-02f, 3.15083861e-02f, 3.69288102e-02f, -2.47120131e-02f,
  -5.13022617e-02f, 6.25327826e-02f, -6.58166111e-02f, 2.28702165e-02f, -4.55923080e-02f, -2.14554630e-02f, 7.09833354e-02f, -5.33408485e-02f, -4.30869088e-02f, 7.55520985e-02f,
  2.04148293e-02f, 8.25704914e-03f, 3.78029980e-02f, -4.70349379e-02f, -6.01024963e-02f, -7.37580582e-02f, 2.93809697e-02f, 9.71658714e-03f, 3.84409092e-02f, -2.00770935e-03f,
  1.20895661e-01f, -1.25596179e-02f, 1.98054388e-02f, 1.99875653e-01f, 1.00999400e-02f, -5.09233437e-02f, -5.62198348e-02f, 6.75212964e-02f, 1.33702621e-01f, -7.37619549e-02f,
  -3.27481478e-02f, 6.82199970e-02f, -4.84351302e-03f, -7.37036392e-02f, -6.55468851e-02f, 2.77604759e-02f, -6.88276067e-02f, 6.02917969e-02f, 1.33874798e-02f, -1.65584445e-01f,
  -5.46489097e-02f, 2.24363375e-02f, 1.60680294e-01f, -4.11137706e-03f, 1.11913560e-02f, 1.17911272e-01f, -5.56554906e-02f, -6.37846515e-02f, 8.91928971e-02f, -7.37446323e-02f,
  -3.51223558e-01f, -3.41551900e-01f, -2.70092785e-01f, -2.36129925e-01f, -1.99990362e-01f, -8.94094706e-02f, -3.28295794e-03f, -6.87965890e-03f, -1.80431649e-01f, -2.19422013e-01f,
  2.02705041e-02f, 8.27815533e-02f, 9.10583287e-02f, 4.04033028e-02f, 1.40742719e-01f, -2.46281222e-01f, -2.52824336e-01f, 1.97998900e-03f, 1.82815820e-01f, 2.77244538e-01f,
  4.08772789e-02f, -3.56428251e-02f, -3.22822668e-02f, -3.71020511e-02f, -1.24232121e-01f, -7.73814321e-02f, -2.68743396e-01f, -1.08644180e-01f, -1.04074441e-01f, -3.45529705e-01f,
  2.80368298e-01f, -1.54182792e-01f, 8.60366225e-02f, 1.82705093e-02f, -8.79202485e-02f, -5.64856082e-02f, -1.47401926e-03f, -1.07375488e-01f, -3.83719429e-02f, -9.72075388e-02f,
  7.82488845e-03f, -5.71282953e-02f, 6.53082356e-02f, -2.50765663e-02f, -5.99143952e-02f, -4.27518263e-02f, -9.90130082e-02f, -1.13579199e-01f, -2.82356376e-03f, 6.62490055e-02f,
  2.23251395e-02f, -7.01241493e-02f, -5.46899438e-02f, 3.35539542e-02f, 7.66196921e-02f, 4.94287573e-02f, -4.40749377e-02f, 6.55282363e-02f, 1.06872134e-02f, -7.73406997e-02f,
  -2.70672161e-02f, 3.56778665e-03f, -1.00931720e-04f, -3.65029424e-02f, 2.61493418e-02f, -7.17157265e-03f, -2.01712456e-03f, 5.05378395e-02f, 9.92257614e-03f, 1.03680370e-02f,
  -1.77494735e-02f, -3.71795855e-02f, 1.59279245e-03f, -7.82745183e-02f, -2.60023437e-02f, -9.25375968e-02f, 1.95311215e-02f, 2.13799421e-02f, -2.76195817e-03f, 3.64129036e-03f,
  5.28998785e-02f, -3.09188645e-02f, -1.27360329e-01f, 8.63243565e-02f, -9.37598497e-02f, -2.73227599e-02f, -7.00060651e-03f, 7.11889565e-02f, 6.94350004e-02f, -5.06725674e-03f,
  1.46727681e-01f, -3.64415534e-02f, 2.16144994e-02f, -1.91789155e-03f, -3.66372876e-02f, 4.69126832e-03f, -1.08500622e-01f, -6.26241192e-02f, -1.17270984e-02f, 3.09454296e-02f,
  1.57760065e-02f, 9.32990685e-02f, -2.16740370e-02f, 3.33261304e-02f, 9.21622142e-02f, 2.67914571e-02f, -1.43163368e-01f, -9.10645127e-02f, 8.13386366e-02f, 2.56638248e-02f,
  -6.16686791e-02f, 3.94586697e-02f, 9.93797183e-02f, -1.42511660e-02f, 3.70587930e-02f, -1.64969917e-02f, 1.71959862e-01f, 6.28728494e-02f, 1.23919263e-01f, -8.63476917e-02f,
  -3.15841913e-01f, -1.30538076e-01f, -1.54244244e-01f, -2.57615030e-01f, 9.59004909e-02f, 7.08131120e-02f, 1.09695189e-01f, -4.05248502e-05f, 8.46218690e-03f, 4.66325097e-02f,
  -1.04306284e-02f, -2.64704823e-02f, -1.09663643e-01f, 7.68118948e-02f, 1.32987693e-01f, -1.12490612e-03f, -5.18164486e-02f, 2.88157389e-02f, -8.63614434e-04f, 1.73684806e-01f,
  1.20985629e-02f, -1.29985839e-01f, -1.72399685e-01f, -1.16252720e-01f, -1.58698171e-01f, -1.38730690e-01f, -6.26860708e-02f, -5.75719699e-02f, 2.08029859e-02f, -6.18330836e-02f,
  -1.91948012e-01f, -1.49973750e-01f, 4.39814366e-02f, -5.22986054e-02f, -8.37302357e-02f, -1.08148567e-01f, -2.83134878e-02f, -1.44462343e-02f, 5.93995750e-02f, -7.31228217e-02f,
  -9.65989456e-02f, -1.38629368e-02f, -5.44341560e-03f, 5.29375933e-02f, -8.08628052e-02f, 6.42489716e-02f, -2.71064118e-02f, -4.84429821e-02f, -7.65220225e-02f, 1.08190745e-01f,
  2.67143194e-02f, -4.73010242e-02f, -1.04357570e-01f, 4.48638275e-02f, -6.23824559e-02f, -2.70914827e-02f, -9.93253887e-02f, -5.24888039e-02f, -1.34980036e-02f, -1.42854795e-01f,
  5.80683947e-02f, 5.69959059e-02f, -2.27770843e-02f, -1.73111428e-02f, 1.80737264e-02f, 5.63901216e-02f, -3.60501036e-02f, -1.08903209e-02f, 9.56211090e-02f, -1.10354135e-02f,
  2.81118900e-02f, -3.79069336e-02f, -2.65134312e-02f, -7.10579455e-02f, 2.21196059e-02f, -3.59722134e-03f, -7.76378904e-03f, 2.18665041e-02f, 1.12216054e-02f, 2.00303122e-02f,
  -2.88930498e-02f, 9.98002943e-03f, -8.55557472e-02f, -4.08537015e-02f, -3.88429910e-02f, -3.99529748e-02f, -2.48197950e-02f, 9.06634852e-02f, 3.73013355e-02f, -5.96053153e-02f,
  -2.35308826e-01f, 1.23702072e-01f, -1.12378731e-01f, -2.55757719e-02f, -4.42141183e-02f, 9.47121624e-03f, 3.94572644e-03f, 7.17409348e-05f, 2.67726686e-02f, 1.49876047e-02f,
  5.92828654e-02f, -1.63245331e-02f, -4.53610942e-02f, -2.52913740e-02f, 2.59725954e-02f, -5.58155589e-02f, -3.72282863e-02f, -1.28960805e-02f, -5.26109077e-02f, -8.44119340e-02f,
  -1.04427375e-01f, -1.17498800e-01f, -1.61714822e-01f, -1.30103201e-01f, -1.21063903e-01f, -1.05612390e-01f, -1.63935632e-01f, -7.17240199e-02f, -2.75380840e-03f, -1.82358801e-01f,
  6.22402132e-02f, -1.50520071e-01f, -1.27293557e-01f, -3.47672552e-02f, -9.45488662e-02f, -3.62650566e-02f, -2.67895639e-01f, -1.06234014e-01f, 3.43904682e-02f, -2.41850227e-01f,
  -7.47243762e-02f, -9.10986587e-02f, -3.25525156e-03f, 3.95747572e-02f, -1.07991703e-01f, -1.88451082e-01f, -1.99521184e-01f, -6.46530390e-02f, 1.10457666e-01f, 6.08991608e-02f,
  4.40265657e-03f, -9.79371183e-03f, 6.55736700e-02f, -3.92263234e-02f, -8.63631070e-02f, -9.28052068e-02f, -1.13183156e-01f, -1.00790665e-01f, -7.74584860e-02f, -2.23914251e-01f,
  -2.76794970e-01f, -9.46561471e-02f, 8.19221735e-02f, 1.48263201e-02f, -4.69259396e-02f, -7.68327937e-02f, 1.12907263e-03f, -3.60501930e-02f, 8.01950097e-02f, -1.13898963e-01f,
  -8.21504369e-02f, -4.80744578e-02f, -4.94911000e-02f, 2.58334931e-02f, 9.00854841e-02f, -9.67068411e-03f, 4.67087626e-02f, 1.07343256e-01f, 1.91566851e-02f, 5.88640161e-02f,
  -1.11468192e-02f, -1.17668070e-01f, -3.58930118e-02f, -6.82352036e-02f, -5.53567819e-02f, -3.77633497e-02f, 2.59575987e-04f, 4.31377068e-02f, -1.12151308e-02f, -7.99953267e-02f,
  -6.88706562e-02f, -3.51324417e-02f, 6.23424463e-02f, 7.53328577e-02f, 8.34424198e-02f, 2.47516739e-03f, -8.17490462e-03f, -3.67544591e-02f, 6.38048649e-02f, -4.32798117e-02f,
  1.65088959e-02f, -1.52009437e-02f, 6.38554757e-03f, -3.32522504e-02f, 2.31426843e-02f, -5.24679646e-02f, -1.08778462e-01f, 8.46594479e-03f, -1.49373813e-02f, 4.71122637e-02f,
  -4.14067619e-02f, -2.19575129e-02f, 6.33260533e-02f, -4.91052978e-02f, 7.46508092e-02f, -2.91315634e-02f, 8.52295607e-02f, -2.98292339e-02f, 2.89321821e-02f, -6.19068779e-02f,
  6.59098625e-02f, 8.72194767e-02f, -1.63845308e-02f, -5.21040894e-02f, -8.22961181e-02f, 4.21461090e-02f, -5.34998253e-02f, -2.57555619e-02f, -6.22878969e-02f, -1.05968803e-01f,
  3.02543566e-02f, 2.79771350e-03f, -6.54885173e-02f, -7.59793669e-02f, -5.74464314e-02f, -8.60407129e-02f, -7.75490403e-02f, 1.40505265e-02f, 2.57747266e-02f, -4.41785678e-02f,
  -7.53435493e-02f, -4.95050736e-02f, -6.23758771e-02f, 4.90617752e-02f, 5.47297560e-02f, -9.50448141e-02f, -5.59742656e-03f, -6.95735738e-02f, -1.60515606e-02f, -1.45070150e-01f,
  -2.66994000e-03f, 1.02142006e-01f, 7.43662491e-02f, -1.61662161e-01f, 1.34462908e-01f, 1.06435552e-01f, 1.58198744e-01f, 9.16695297e-02f, -1.01323307e-01f, 3.87621559e-02f,
  1.05668046e-01f, -6.82513565e-02f, -8.83118436e-02f, -1.98548380e-02f, -1.00477301e-01f, 1.28714606e-01f, 8.59591216e-02f, 4.44289632e-02f, -1.06352732e-01f, -6.57580048e-02f,
  -6.56256303e-02f, -1.67045817e-01f, -6.51293844e-02f, -8.20924789e-02f, -1.37941599e-01f, -5.05425744e-02f, -5.22938557e-02f, 5.12988605e-02f, 6.60837814e-02f, -1.38090655e-01f,
  4.82609272e-02f, 5.63342310e-02f, 1.39293317e-02f, -1.20156907e-01f, 2.79758275e-02f, -7.36098886e-02f, 6.47501424e-02f, 3.10273524e-02f, 6.69104829e-02f, -3.31184827e-02f,
  -7.12913275e-02f, 1.46377068e-02f, -8.85106549e-02f, 1.37081230e-02f, 7.63811171e-03f, 2.70918645e-02f, -1.91903673e-02f, -1.83963850e-02f, 8.22057575e-02f, 4.44774628e-02f,
  6.64649829e-02f, 5.72472736e-02f, 1.32627785e-01f, -4.08901386e-02f, 1.25049636e-01f, -8.48250184e-03f, 3.28585729e-02f, 8.58454965e-03f, 1.41719714e-01f, -2.59255152e-02f,
  5.20895943e-02f, -4.27221209e-02f, 7.58214295e-02f, -2.66299527e-02f, 6.74093738e-02f, 7.99998362e-03f, 6.98075071e-02f, -2.79636197e-02f, 1.06396107e-02f, -9.39998478e-02f,
  -4.84732203e-02f, -3.86535041e-02f, 3.90287042e-02f, 9.02455673e-02f, 8.32691863e-02f, 3.21928188e-02f, -2.84329969e-02f, -7.70671712e-03f, 7.53895119e-02f, 3.82459946e-02f,
  1.59954019e-02f, -1.25931818e-02f, 3.66772562e-02f, 4.07450320e-03f, 9.47715342e-02f, 1.13769293e-01f, 8.24557692e-02f, 7.25990161e-02f, -1.93013791e-02f, 3.36616710e-02f,
  -2.65086144e-01f, 1.14801273e-01f, -2.77568866e-02f, -1.50372952e-01f, -2.61916220e-02f, -4.17715311e-02f, -7.55232349e-02f, -9.02826935e-02f, 1.21711725e-02f, 2.57159844e-02f,
  6.51723593e-02f, -5.68435341e-02f, 2.28303391e-02f, -2.94088181e-02f, 6.29238263e-02f, 4.72531728e-02f, -1.56341698e-02f, 3.57761122e-02f, 7.80064613e-02f, -2.19140444e-02f,
  -3.08786687e-02f, 5.97229972e-02f, 9.84227061e-02f, 4.63086851e-02f, 7.53098950e-02f, 4.31550555e-02f, -4.00381302e-03f, -8.28216821e-02f, 6.77105412e-03f, -1.29070714e-01f,
  -1.11143090e-01f, 1.00413926e-01f, 1.28555864e-01f, 4.81637977e-02f, 2.69603074e-01f, 2.08726048e-01f, 2.26994485e-01f, 5.37011139e-02f, 7.92228356e-02f, 1.14710815e-01f,
  -9.05418992e-02f, 4.49217372e-02f, -1.96114406e-02f, 1.52077293e-02f, 8.51728693e-02f, 3.06299701e-02f, 1.66040391e-01f, 7.81385079e-02f, 1.98451262e-02f, -3.07503040e-03f,
  1.03525259e-02f, 1.84016768e-03f, -8.46695602e-02f, 4.99409139e-02f, 1.21174650e-02f, -1.31624239e-02f, -1.69467144e-02f, 6.61948472e-02f, 3.74702886e-02f, 3.12028285e-02f,
  -1.00802705e-01f, -2.30104197e-02f, 3.14246789e-02f, -1.50144279e-01f, -6.33260161e-02f, -3.71966809e-02f, 5.48412986e-02f, -2.53464580e-02f, -8.78180712e-02f, -9.41395387e-02f,
  -9.65041295e-02f, -1.27645424e-02f, 7.86151513e-02f, -1.20593712e-01f, -3.42625193e-02f, -3.20377424e-02f, -1.16635248e-01f, 2.65920386e-02f, 8.71472284e-02f, -6.27362123e-03f,
  2.23970804e-02f, -4.39101420e-02f, -4.69809137e-02f, -4.74129505e-02f, 9.62742120e-02f, -9.46122259e-02f, -8.43165442e-02f, 4.31253463e-02f, -5.41008003e-02f, -1.31824195e-01f,
  -6.78382767e-03f, -2.39250418e-02f, -3.57472152e-02f, 4.95502241e-02f, 2.58223042e-02f, 2.02271491e-02f, 6.08890727e-02f, 3.84405777e-02f, -1.24766789e-02f, -2.19236016e-02f,
  -5.53919040e-02f, 5.71630932e-02f, -1.82041377e-02f, 4.60317172e-03f, -6.67236149e-02f, 6.04896769e-02f, -6.71160221e-02f, -2.15002336e-02f, 6.54759035e-02f, -5.58213554e-02f,
  7.86358565e-02f, 7.38589913e-02f, -1.04498910e-03f, -2.24435758e-02f, -6.39047176e-02f, -8.15556943e-02f, -1.98062602e-02f, -7.42632300e-02f, -1.80966128e-02f, -7.11422190e-02f,
  -1.00066856e-01f, 6.18372597e-02f, 4.52700034e-02f, 2.63348129e-02f, 3.09385303e-02f, 1.16687398e-02f, 4.02915102e-05f, -7.03987107e-02f, -6.24612384e-02f, -6.30154014e-02f,
  6.26696497e-02f, -7.99334347e-02f, 5.09164408e-02f, 6.97351396e-02f, 5.33647323e-03f, -1.82749901e-03f, -8.24363064e-03f, 2.54004691e-02f, -3.07055358e-02f, -7.15861022e-02f,
  6.23276411e-03f, 4.25962619e-02f, 7.42233358e-03f, 6.10943176e-02f, 9.59280804e-02f, -7.90491253e-02f, -1.32529507e-03f, 7.48979971e-02f, -1.83249880e-02f, 1.37619907e-02f,
  2.99853832e-01f, -4.27614450e-01f, 1.01171605e-01f, 4.83078398e-02f, 6.70101121e-02f, 1.21397808e-01f, -6.53388351e-02f, -8.68245512e-02f, 2.61917990e-02f, -1.34325862e-01f,
  -2.04707950e-01f, -4.75780331e-02f, -1.89870174e-04f, 6.23220485e-03f, -3.54021378e-02f, -8.25448111e-02f, 1.54377446e-02f, 1.97061330e-01f, 1.55231968e-01f, 5.55716269e-03f,
  -1.26164153e-01f, -6.46759868e-02f, 3.09055466e-02f, -5.40905818e-02f, -1.97240248e-01f, 4.88342941e-02f, -7.39732012e-02f, -1.52191669e-01f, -1.12514526e-01f, -2.11098850e-01f,
  -1.04153253e-01f, -4.31233048e-02f, 9.50443447e-02f, -8.38076547e-02f, -3.88112880e-04f, -2.39350498e-02f, -2.48361211e-02f, -4.63243686e-02f, 1.46206534e-02f, -6.77217394e-02f,
  -1.11432046e-01f, 3.15256342e-02f, 1.06296747e-03f, 8.53861030e-03f, -4.72087897e-02f, -9.86057147e-03f, -1.10342965e-01f, 1.09224459e-02f, -3.32870381e-03f, -2.00951397e-01f,
  -1.25109062e-01f, 3.50160599e-02f, 1.03442185e-01f, 6.75952509e-02f, 3.83174494e-02f, 1.63568094e-01f, -1.53010294e-01f, -7.03515261e-02f, -2.12942362e-02f, 1.25804618e-02f,
  -7.10275844e-02f, -2.45535225e-02f, 3.02422475e-02f, -2.99523622e-02f, 1.17097057e-01f, 1.11383945e-02f, 1.41896978e-01f, -3.32375988e-02f, -7.26173595e-02f, -3.36980610e-03f,
  -7.43485391e-02f, -1.10029718e-02f, -7.07614347e-02f, 7.16167614e-02f, -7.39133060e-02f, 1.36358021e-02f, -4.03959230e-02f, -3.52498963e-02f, -6.14734329e-02f, -1.02404959e-01f,
  -5.35710827e-02f, 2.28131730e-02f, -1.05855495e-01f, -9.73377079e-02f, -5.81868067e-02f, 9.66537464e-03f, 1.64045598e-02f, -3.53785381e-02f, -5.84449321e-02f, 4.09392007e-02f,
  -7.77455792e-02f, 1.19646102e-01f, -1.23737594e-02f, 2.89834924e-02f, 7.56728426e-02f, -1.09366477e-01f, 4.19468954e-02f, 7.48685226e-02f, -5.39352894e-02f, 4.57265740e-03f,
  -8.12716931e-02f, -9.56660509e-02f, -1.53518543e-01f, -1.25426129e-01f, 1.52978271e-01f, 2.00383514e-02f, -7.05773979e-02f, 7.07906857e-02f, -3.98938963e-03f, -5.46541326e-02f,
  -2.22174928e-01f, 2.48405069e-01f, 2.67282307e-01f, 1.99522465e-01f, 3.33941937e-03f, 3.09267104e-01f, 3.11178677e-02f, 1.55528978e-01f, 2.92673409e-01f, 1.56054989e-01f,
  3.69909167e-01f, -4.87695336e-02f, 6.08014017e-02f, 8.13782960e-02f, -2.66769141e-01f, -1.83265105e-01f, -1.81464896e-01f, 5.97002059e-02f, 8.34320709e-02f, -4.79973527e-03f,
  -8.34424719e-02f, -3.24966423e-02f, 9.43791941e-02f, 2.23351598e-01f, 2.25149646e-01f, 8.91090333e-02f, 1.31291807e-01f, 2.37726256e-01f, 2.27387637e-01f, 2.20759716e-02f,
  1.23300971e-02f, -4.52321284e-02f, 1.23879597e-01f, 1.04942352e-01f, 5.91512136e-02f, 7.71851689e-02f, 7.53516927e-02f, -2.12484654e-02f, -3.83645482e-02f, 2.09004641e-01f,
  1.07950913e-02f, 1.13017507e-01f, 1.75498948e-02f, -3.77733521e-02f, -1.78259954e-01f, 1.09693013e-01f, -5.29097728e-02f, 8.11175480e-02f, -4.69078049e-02f, 5.85778467e-02f,
  -1.45808712e-01f, -2.74299644e-02f, 1.26035213e-02f, 4.46662828e-02f, 1.19204167e-03f, -3.54277156e-02f, 1.06562167e-01f, 7.80971646e-02f, 9.02879909e-02f, 3.52707431e-02f,
  -1.39808923e-01f, -1.93023369e-01f, 3.49118039e-02f, -7.32337162e-02f, 7.21560344e-02f, 4.00848500e-02f, -7.39813829e-03f, -8.17733165e-03f, 1.31204687e-02f, 5.40185124e-02f,
  4.60528545e-02f, 5.28266886e-03f, 9.06123593e-02f, 7.93233588e-02f, 2.91314963e-02f, -2.52177473e-02f, -8.21942184e-03f, 3.44456770e-02f, -1.38808433e-02f, -5.14006941e-03f,
  5.73901236e-02f, -9.80231166e-03f, 6.38375133e-02f, 1.55933611e-02f, 3.27191390e-02f, -6.66914731e-02f, -1.31143136e-02f, -6.77704215e-02f, 3.62346787e-03f, 3.05454358e-02f,
  3.24900150e-02f, 4.29139547e-02f, -2.78341863e-03f, 7.96103999e-02f, -4.59310375e-02f, 5.55077903e-02f, 2.06437837e-02f, 2.60066651e-02f, -2.80688573e-02f, -5.05132899e-02f,
  -1.94486484e-01f, -1.02351800e-01f, 1.85930535e-01f, 7.21243769e-02f, -2.17608120e-02f, -5.84880747e-02f, 1.54199880e-02f, -6.57386854e-02f, -8.56340677e-02f, -6.74869772e-03f,
  -8.04906711e-02f, 1.09750694e-02f, -1.05073266e-01f, -1.47520034e-02f, 2.48610810e-03f, -6.05545528e-02f, -3.72570232e-02f, 8.55256766e-02f, 7.47971609e-02f, -3.28740887e-02f,
  -1.07779458e-01f, -9.03619453e-02f, -4.44534235e-02f, -1.05972402e-01f, -1.04605243e-01f, 4.93867733e-02f, -2.44137216e-02f, -5.18254414e-02f, -8.64267200e-02f, -1.00282021e-01f,
  6.55936301e-02f, 2.09023014e-01f, -9.10960734e-02f, 8.24530125e-02f, 2.23775278e-03f, 3.94476838e-02f, -1.88399535e-02f, 4.64379005e-02f, -1.50498971e-02f, 4.98788245e-03f,
  9.41814780e-02f, -1.01651147e-01f, 5.27013466e-02f, -2.37841550e-02f, -7.54403770e-02f, -5.30784801e-02f, -1.55591834e-02f, -3.43527831e-02f, -1.02692366e-01f, -1.09477289e-01f,
  -7.09297881e-02f, 7.14978725e-02f, -8.38930905e-03f, 9.09867063e-02f, -5.10140806e-02f, -1.12369590e-01f, 6.09735101e-02f, 4.23655957e-02f, 6.16455413e-02f, -4.95839380e-02f,
  -6.67382255e-02f, -5.14421128e-02f, -4.85896319e-02f, 2.18440872e-02f, 5.21888658e-02f, 1.24069834e-02f, -5.81610296e-03f, 3.38642262e-02f, 1.24096535e-01f, 6.81235790e-02f,
  3.15576382e-02f, 2.09414251e-02f, -1.33627858e-02f, -3.41041870e-02f, 6.59380853e-02f, -6.24237908e-03f, -6.75773900e-03f, -3.31986621e-02f, -6.31600767e-02f, 5.71202189e-02f,
  8.27689767e-02f, -3.82424481e-02f, 8.72258842e-03f, -4.88234870e-02f, -1.36530101e-01f, -4.08923663e-02f, -1.09587185e-01f, -1.03981219e-01f, -5.52661531e-03f, 3.43963839e-02f,
  3.09096426e-02f, -3.22004035e-02f, 3.53791118e-02f, -1.79469883e-02f, -1.15797305e-02f, -1.43798860e-02f, -5.58783412e-02f, -6.93533476e-03f, 1.75921023e-02f, 9.35898572e-02f,
  1.02334410e-01f, -4.43883054e-02f, -2.24132352e-02f, 8.68101791e-02f, 6.36478439e-02f, -5.06939739e-02f, -8.84731784e-02f, 2.17447225e-02f, -7.13205412e-02f, 8.38446096e-02f,
  -5.06235734e-02f, -8.00175071e-02f, 8.25356413e-03f, -3.64139713e-02f, 1.35271922e-02f, -7.02465326e-02f, -6.16820455e-02f, -8.40373784e-02f, -8.82151769e-04f, -2.95521133e-02f,
  -7.90331140e-02f, -4.36889417e-02f, -9.03913565e-03f, 3.98347341e-02f, -1.52807701e-02f, 6.44374713e-02f, -3.14996056e-02f, 1.05668217e-01f, -1.50911352e-02f, -6.16428442e-02f,
  -7.20508546e-02f, -3.64079028e-02f, 6.96199015e-02f, -1.39008313e-02f, -3.69550996e-02f, -7.14616701e-02f, 4.51532975e-02f, -7.94647112e-02f, -3.39285610e-03f, 5.12475334e-02f,
  3.73041928e-02f, 3.58269028e-02f, -1.38583658e-02f, 7.21504092e-02f, 9.11491271e-03f, -7.18805240e-03f, 3.42126079e-02f, -6.63904939e-05f, 4.76949848e-02f, 7.70086935e-03f,
  9.68375877e-02f, -1.27088442e-01f, -1.12110913e-01f, 1.07116299e-02f, 6.64842082e-03f, -6.11235462e-02f, -8.34915563e-02f, -1.68029964e-01f, -4.17739786e-02f, 4.10950854e-02f,
  3.35798748e-02f, -5.10294996e-02f, 9.15427804e-02f, -8.09872244e-03f, -4.27686386e-02f, 2.57422142e-02f, -9.20859650e-02f, -1.16308127e-02f, 9.49970931e-02f, -2.32414976e-02f,
  8.69077295e-02f, 1.12919062e-01f, 4.41070879e-03f, -2.78009083e-02f, 1.08629391e-02f, 3.36173968e-03f, -5.13117388e-02f, -8.90459167e-04f, -3.42298970e-02f, -2.70337164e-02f,
  -2.56407931e-02f, -1.98284648e-02f, 7.38747269e-02f, 8.04269835e-02f, 7.58785158e-02f, -4.25552353e-02f, 2.72802096e-02f, -5.83781977e-04f, 9.57978889e-03f, -3.28844227e-02f,
  9.76344943e-03f, 7.33714178e-02f, -6.45003468e-02f, 6.00884780e-02f, 5.13385907e-02f, 1.79340094e-02f, -2.93357279e-02f, -1.11226641e-01f, -9.63311270e-02f, -8.05648193e-02f,
  1.94648225e-02f, 2.93275211e-02f, -8.05334523e-02f, -1.38656810e-01f, -1.44122332e-01f, 8.92234780e-03f, -6.90620393e-02f, -4.78376113e-02f, -7.12460503e-02f, 2.53544897e-02f,
  -9.58970413e-02f, -6.39346614e-02f, -5.52311204e-02f, -8.03784281e-02f, 5.26394807e-02f, -2.27868669e-02f, -6.53024539e-02f, -6.36613816e-02f, 5.27600311e-02f, 6.78247139e-02f,
  2.73079630e-02f, 7.47333989e-02f, -6.24378361e-02f, -1.13439456e-01f, -7.03384504e-02f, -1.03682898e-01f, -2.99882833e-02f, 2.31045950e-02f, 8.02337527e-02f, 4.95689847e-02f,
  -3.57189775e-03f, -4.23862040e-02f, -4.25282605e-02f, -8.97632018e-02f, 4.73530851e-02f, -1.10761598e-01f, 1.88581534e-02f, 3.42769921e-02f, -3.55573036e-02f, -3.06661353e-02f,
  -9.99476463e-02f, 4.82604615e-02f, -3.50349993e-02f, -1.05918758e-01f, -1.39815118e-02f, 7.42635354e-02f, -4.64600958e-02f, 5.20009138e-02f, -3.36464271e-02f, -8.61051902e-02f,
  6.87905401e-02f, -8.36173296e-02f, -8.28061327e-02f, -4.00402471e-02f, -1.10879131e-02f, 4.49712016e-02f, 2.69928556e-02f, 4.96948287e-02f, -2.68227663e-02f, -8.09841696e-03f,
  4.57455963e-02f, -9.88202319e-02f, 3.73648740e-02f, -1.06652550e-01f, -1.17028467e-01f, 2.58116443e-02f, -2.07775589e-02f, -9.18089971e-02f, -1.41881138e-01f, -1.10840179e-01f,
  -5.82191460e-02f, 9.96843725e-02f, -4.89609614e-02f, -1.58425495e-01f, -1.75865758e-02f, -4.71042395e-02f, 1.14362024e-01f, -4.51083481e-02f, -1.68967079e-02f, 7.46098086e-02f,
  -5.70237488e-02f, -1.63815424e-01f, -5.12173958e-02f, -1.46406934e-01f, -1.16485730e-01f, -1.64485723e-02f, -1.07686214e-01f, -7.23222643e-02f, -2.22571939e-01f, -1.83117926e-01f,
  -1.38059765e-01f, -1.44077227e-01f, -7.81338438e-02f, -1.07466199e-01f, -3.59453000e-02f, -1.92105565e-02f, -4.44163233e-02f, -6.16894178e-02f, -2.75058835e-03f, -7.37675801e-02f,
  9.92479771e-02f, 1.22395515e-01f, -1.64380163e-01f, -1.89536028e-02f, -1.78130567e-02f, 4.98033576e-02f, 1.63452979e-02f, -7.53090009e-02f, 6.17141128e-02f, 3.63692418e-02f,
  -1.76839326e-02f, 5.62897995e-02f, -1.97171140e-02f, 5.10292426e-02f, -4.99602780e-03f, -7.48159289e-02f, -1.24392226e-01f, -1.48164546e-02f, 4.92147952e-02f, -2.73373295e-02f,
  -3.62592712e-02f, 6.08442724e-02f, -5.62033989e-02f, 1.06571361e-01f, -1.34640178e-02f, 2.64576748e-02f, 9.45235863e-02f, -3.24463695e-02f, 9.95658636e-02f, -5.21845557e-02f,
  1.17537137e-02f, 2.62644812e-02f, 6.87427968e-02f, 5.93190491e-02f, -6.86925724e-02f, 8.24224651e-02f, -2.59261392e-02f, 5.10235801e-02f, -7.46252611e-02f, -7.04704300e-02f,
  -7.50901625e-02f, 1.06520541e-01f, 3.23942699e-03f, 2.66850796e-02f, 5.32435700e-02f, 1.40899299e-02f, 8.79775435e-02f, 2.96914466e-02f, 7.32401311e-02f, 5.41044027e-02f,
  -8.97234157e-02f, 7.24948123e-02f, -6.88945502e-02f, -6.34516925e-02f, 5.55660538e-02f, 3.69587317e-02f, 3.24834920e-02f, -8.06576293e-03f, -4.32420187e-02f, -2.97553763e-02f,
  -3.19805108e-02f, -6.98820502e-02f, 2.67044902e-02f, -4.69900668e-02f, -1.70535836e-02f, -2.34957021e-02f, -1.73027627e-02f, 5.62432371e-02f, -5.63500524e-02f, -4.03146893e-02f,
  7.66859353e-02f, 7.88129121e-03f, -2.57591065e-02f, -9.46243405e-02f, -7.91159719e-02f, -3.46489474e-02f, -7.42104948e-02f, -8.82713273e-02f, 2.74018478e-02f, -2.35703457e-02f,
  -3.85261215e-02f, 1.37970103e-02f, -9.80295688e-02f, 5.22208549e-02f, -3.61022279e-02f, -1.36390433e-01f, 4.92484272e-02f, 2.36222651e-02f, -3.06316596e-02f, -9.01950710e-03f,
  4.27566737e-01f, 4.15750504e-01f, 4.77983914e-02f, 4.37663980e-02f, 3.90325822e-02f, -1.54919967e-01f, 2.69532260e-02f, -1.34697765e-01f, -2.63980050e-02f, 1.06786519e-01f,
  1.61279574e-01f, -5.31124063e-02f, -3.10792252e-02f, -1.13683999e-01f, -8.68029296e-02f, 5.98845594e-02f, -1.07719816e-01f, 8.64768028e-02f, -6.71379641e-03f, 3.83692868e-02f,
  -1.63343940e-02f, 1.49429068e-01f, 2.32110903e-01f, -2.73023620e-02f, 8.11246559e-02f, -3.93488258e-02f, -3.53697836e-02f, 1.39920160e-01f, 1.29933476e-01f, 2.38216087e-01f,
  2.30549887e-01f, 2.28310287e-01f, -2.68975794e-01f, -1.09995995e-02f, 3.59886372e-03f, -1.79780833e-02f, -3.13854218e-02f, 3.17559205e-02f, 9.18491557e-02f, 9.24250484e-02f,
  1.01461671e-01f, 1.13147937e-01f, 1.17762585e-03f, -1.79824419e-02f, 5.25864772e-02f, -5.76530695e-02f, -1.04255509e-02f, 5.45274056e-02f, -6.31616265e-02f, 1.76633075e-02f,
  6.44036084e-02f, 1.39036670e-01f, 1.39590260e-02f, -1.57795116e-01f, -1.07063629e-01f, -1.02433302e-01f, 2.39049410e-03f, 4.04369049e-02f, 1.05367927e-02f, 8.55986848e-02f,
  1.64109096e-02f, 6.74045905e-02f, 8.62016380e-02f, -2.47736741e-02f, 7.08969831e-02f, 1.14668496e-02f, -1.61487162e-02f, 2.56215278e-02f, -3.40918005e-02f, -2.89157778e-03f,
  -3.79016586e-02f, -3.01178247e-02f, 4.53866832e-02f, -1.78832263e-02f, -2.54094321e-02f, 7.43829608e-02f, 2.35824920e-02f, 5.49733341e-02f, -2.52771284e-02f, 4.03923877e-02f,
  -2.87489109e-02f, -7.97629878e-02f, -6.76831454e-02f, -3.09047569e-02f, -2.36849245e-02f, -4.80395965e-02f, 5.66763468e-02f, -3.17460112e-02f, -1.42207863e-02f, 5.74139468e-02f,
  -1.21023580e-01f, -1.56007096e-01f, -9.09859166e-02f, 5.19781895e-02f, -1.03278328e-02f, 6.54947683e-02f, -2.03466043e-02f, 7.75233377e-03f, -1.65575109e-02f, 6.83534816e-02f,
  6.40264750e-02f, -5.04579060e-02f, -2.42385585e-02f, 2.48848274e-03f, -7.40194619e-02f, -5.56628853e-02f, -4.46714424e-02f, -5.58390543e-02f, -1.39389887e-01f, 4.51792143e-02f,
  -1.12930588e-01f, -1.00916184e-01f, -1.09292269e-01f, -1.76007181e-01f, -9.72503573e-02f, -1.26127079e-01f, -1.37259170e-01f, -1.83419026e-02f, -1.67433009e-01f, -1.84923157e-01f,
  -1.73184518e-02f, -2.18770966e-01f, -2.58980375e-02f, 5.59115224e-02f, -3.09369410e-03f, -1.21266410e-01f, -1.84073225e-01f, -1.27009705e-01f, 1.56677291e-02f, -7.97539279e-02f,
  6.13459665e-03f, -2.90972665e-02f, 2.80105993e-02f, -1.25200659e-01f, -2.13734984e-01f, -1.43554315e-01f, -1.68795213e-01f, -1.54079780e-01f, -1.13834411e-01f, -5.81828393e-02f,
  -4.85522561e-02f, 5.41584939e-02f, -3.71078439e-02f, 6.49613738e-02f, 3.12953778e-02f, 1.56706106e-02f, 1.89546905e-02f, -4.84159589e-03f, 5.42584918e-02f, 8.35395306e-02f,
  -1.44893094e-03f, 1.43198580e-01f, -4.88158055e-02f, -3.50529701e-02f, 4.88732196e-02f, -5.62185980e-02f, -5.86813316e-02f, 6.62268400e-02f, 5.36139868e-02f, -3.72839533e-02f,
  -3.63901071e-02f, -3.10138650e-02f, -3.97968525e-03f, 4.34122570e-02f, -3.09804846e-02f, 9.28435847e-03f, -8.06777254e-02f, -6.70273751e-02f, 2.86233798e-02f, 7.95067549e-02f,
  -1.38077699e-02f, -3.06767188e-02f, -1.66799977e-01f, -3.88857499e-02f, -5.45545332e-02f, -5.76253608e-02f, 4.47109193e-02f, 1.39729865e-02f, -8.35252404e-02f, -5.90697005e-02f,
  -4.54255044e-02f, -4.92713600e-02f, -2.99890283e-02f, 3.37339118e-02f, -6.90216199e-02f, 7.50387982e-02f, -6.66616336e-02f, 4.19825278e-02f, -5.74267618e-02f, 2.79763322e-02f,
  -4.19031382e-02f, -6.30978420e-02f, 4.65100743e-02f, 6.66576549e-02f, -8.36093538e-03f, -2.88099260e-03f, -3.68078575e-02f, 7.54026929e-03f, 5.02279550e-02f, -2.68085487e-03f,
  4.82535437e-02f, 1.01617826e-02f, -3.55615616e-02f, 6.27096668e-02f, 3.82592641e-02f, 2.32000183e-02f, -5.56900576e-02f, -6.20220751e-02f, 6.68174699e-02f, 8.91529620e-02f,
  -1.24253690e-01f, -1.25441372e-01f, -3.14981863e-02f, 4.22375984e-02f, -1.04301888e-03f, 1.07550375e-01f, 6.50714636e-02f, 3.30554545e-02f, 4.13410887e-02f, -1.58267226e-02f,
  -4.03165631e-02f, 1.19314808e-02f, -6.17809892e-02f, -5.26964255e-02f, -6.44612387e-02f, -9.03453305e-02f, -1.33095741e-01f, -1.18106499e-01f, -7.44171739e-02f, -3.33956331e-02f,
  -2.64481679e-02f, -2.54284173e-01f, -1.47529170e-01f, -2.19352961e-01f, 2.58609513e-03f, -1.63540453e-01f, -1.02061898e-01f, -1.22956648e-01f, -2.92268693e-01f, -1.79636583e-01f,
  1.25407547e-01f, 3.87349282e-04f, -1.21221036e-01f, -4.60294224e-02f, 1.98742133e-02f, 1.43941984e-01f, 1.32499188e-01f, 1.24865934e-01f, -1.05084993e-01f, -5.28472960e-02f,
  -3.79194692e-02f, 4.57529761e-02f, -1.13387398e-01f, -1.25441089e-01f, -7.99758136e-02f, -1.08231213e-02f, 1.00452071e-02f, -1.24487326e-01f, 1.60548147e-02f, 1.16353109e-01f,
  7.47396871e-02f, -3.00593320e-02f, -4.95865270e-02f, 7.08479062e-02f, -7.38771483e-02f, -3.89806144e-02f, -6.64038360e-02f, -3.25260013e-02f, 2.83494629e-02f, -7.60723352e-02f,
  9.70522175e-04f, -4.04855274e-02f, -6.00010119e-02f, -4.30826731e-02f, -6.75863102e-02f, -3.56372148e-02f, -4.77316529e-02f, -1.57187004e-02f, -8.53411481e-03f, -3.68381813e-02f,
  5.15754670e-02f, 3.17836814e-02f, 4.66048904e-02f, -3.24281491e-02f, -4.90086190e-02f, -7.57321566e-02f, -9.75446254e-02f, -7.81206712e-02f, -7.90641084e-02f, -8.84332880e-03f,
  1.13943564e-02f, -4.25575487e-02f, -2.44698655e-02f, -4.01376607e-03f, -7.28399083e-02f, -1.48681402e-01f, 6.30784184e-02f, -2.83768289e-02f, -5.73466271e-02f, 6.42549470e-02f,
  2.25617141e-02f, -1.08461186e-01f, 2.51015909e-02f, 9.44589451e-03f, 9.45700333e-02f, -3.39210965e-02f, -3.09613422e-02f, 9.94143337e-02f, -3.21351434e-03f, -5.03925830e-02f,
  -1.43710217e-02f, -6.48075715e-02f, -3.40817422e-02f, -4.50076573e-02f, -1.14089623e-02f, -4.47850935e-02f, 9.84918624e-02f, 8.44075605e-02f, -5.83408177e-02f, -8.78932774e-02f,
  3.24249901e-02f, -7.25763217e-02f, 3.84036899e-02f, 8.06501508e-02f, 3.30974050e-02f, 5.69503568e-02f, 4.38969524e-04f, 5.96205890e-02f, 3.95545736e-02f, 7.13662729e-02f,
  -3.66197005e-02f, 3.75036523e-02f, -9.20497775e-02f, 5.38352430e-02f, -7.61351362e-03f, 1.87488610e-03f, -5.31785041e-02f, 5.70703186e-02f, -1.06159300e-01f, 7.79685006e-02f,
  -2.60404069e-02f, 1.78112034e-02f, -5.08018285e-02f, 8.44639614e-02f, -6.03329651e-02f, -4.28560041e-02f, 2.92508919e-02f, -1.12345457e-01f, -4.04830761e-02f, 5.96310943e-02f,
  6.04188368e-02f, -3.94755341e-02f, -1.32601487e-03f, -1.13910101e-01f, -9.24837813e-02f, -3.71865667e-02f, -8.92588794e-02f, 4.69370466e-03f, 1.92332026e-02f, 9.39904079e-02f,
  6.04617000e-01f, 2.75927424e-01f, -2.87229091e-01f, 2.15888456e-01f, -2.67888427e-01f, -2.28318408e-01f, 8.45265051e-04f, 2.21119583e-01f, 1.54051021e-01f, 1.18237875e-01f,
  -1.77446693e-01f, -9.55326632e-02f, -2.01030076e-01f, -8.85544568e-02f, 1.93885174e-02f, 1.25489324e-01f, -5.42543549e-03f, -4.71269451e-02f, -2.37103164e-01f, -4.73169126e-02f,
  1.15216218e-01f, 1.55328542e-01f, 1.41001806e-01f, 1.40013963e-01f, -5.55826277e-02f, -1.55090094e-01f, 8.89357645e-03f, -2.82004941e-02f, -1.34834796e-01f, -5.38816713e-02f,
  -3.35234672e-01f, 7.75091797e-02f, -8.51274729e-02f, -2.38653775e-02f, -7.77439550e-02f, 1.33013979e-01f, -3.72289978e-02f, 4.68445383e-02f, 9.05222148e-02f, 6.48658574e-02f,
  -9.81513783e-02f, 5.74678779e-02f, -1.35179400e-01f, -4.51921299e-02f, 1.58721320e-02f, -7.31107732e-03f, 1.00158125e-01f, 7.53850862e-02f, -7.42545575e-02f, -1.19964331e-01f,
  -9.61432680e-02f, -1.27523169e-01f, -3.47030237e-02f, -8.08850601e-02f, 1.75467841e-02f, -1.26832843e-01f, -1.03288278e-01f, -1.23578599e-02f, -1.31722063e-01f, 1.92368776e-01f,
  2.18371022e-02f, 2.75300890e-02f, -4.50216420e-02f, 2.96900701e-02f, 8.52290392e-02f, 2.04587206e-02f, 9.00062174e-03f, -5.14516886e-03f, 3.44411395e-02f, 3.29137892e-02f,
  2.74048019e-02f, -4.66055721e-02f, 2.66876630e-02f, 4.76912558e-02f, -2.18990147e-02f, -1.01754688e-01f, -1.09145492e-02f, 6.68153018e-02f, -4.34769969e-03f, 4.13665473e-02f,
  -4.74605300e-02f, 5.02576539e-03f, -5.08886240e-02f, -3.69609669e-02f, -4.33663167e-02f, 4.27097231e-02f, -1.00877313e-02f, -9.87517312e-02f, -4.88001220e-02f, 1.84252970e-02f,
  1.78813353e-01f, -3.31839263e-01f, 9.92827639e-02f, 3.86213958e-02f, -7.26248100e-02f, 6.11880235e-02f, -5.42758964e-02f, -6.23426773e-03f, -3.20949294e-02f, 1.85167324e-03f,
  -9.75211635e-02f, 1.77065376e-02f, 3.74171175e-02f, 4.00109403e-02f, 4.76283655e-02f, 3.05231921e-02f, 1.94516540e-01f, -1.19993212e-02f, 2.16090549e-02f, -1.46401767e-02f,
  1.68416947e-01f, 1.00596339e-01f, 7.70154297e-02f, 1.15031771e-01f, -7.02236742e-02f, -1.22419745e-01f, 5.83049357e-02f, -1.79034211e-02f, -8.74429867e-02f, 5.45123339e-01f,
  -2.75785446e-01f, 1.83210559e-02f, -1.01943359e-01f, 2.45080069e-01f, 3.22615683e-01f, 1.42752245e-01f, 4.33746427e-02f, 9.59453210e-02f, 2.33704478e-01f, 2.40975946e-01f,
  2.54134804e-01f, 3.50783557e-01f, 2.35325694e-01f, 1.69220343e-01f, 5.42895459e-02f, 7.97052011e-02f, 1.58886060e-01f, 1.10084089e-02f, -3.43077816e-02f, 6.18219115e-02f,
  1.88130870e-01f, 7.95050487e-02f, -1.24929063e-01f, 7.64268264e-02f, 2.78960377e-01f, 2.06198558e-01f, 1.06241792e-01f, 1.69238120e-01f, 1.85219556e-01f, 2.03466892e-01f,
  -7.92699531e-02f, -1.67581573e-01f, 1.07352830e-01f, 9.38042253e-02f, 8.80183559e-03f, -1.35757208e-01f, -4.63409424e-02f, -1.83541983e-01f, -1.18618719e-01f, -1.08538695e-01f,
  5.05870357e-02f, 4.22147512e-02f, -3.62708769e-03f, 2.04454232e-02f, -1.49220318e-01f, -1.54401183e-01f, -3.04801874e-02f, -1.34821013e-01f, 1.32442284e-02f, 4.28459719e-02f,
  7.50888139e-02f, 1.30243823e-01f, -1.42308950e-01f, -7.39180669e-02f, 2.48359069e-02f, 7.66503960e-02f, -1.53833792e-01f, -2.98214275e-02f, -8.69957656e-02f, -1.40426576e-01f,
  5.71325496e-02f, -3.75568820e-03f, -3.15989070e-02f, 5.28279617e-02f, 3.01578231e-02f, 5.23145683e-02f, 3.85762155e-02f, 1.10040031e-01f, -1.19967926e-02f, -5.16480654e-02f,
  1.16122149e-01f, 3.08349635e-02f, 8.82935673e-02f, 1.07392473e-02f, 1.27422169e-01f, 6.12578318e-02f, -1.52710099e-02f, -5.40896431e-02f, 6.02044053e-02f, -6.54372051e-02f,
  9.70784854e-03f, -4.28930931e-02f, 1.15880882e-02f, -6.51744381e-02f, -3.05005461e-02f, 4.12152335e-02f, -3.61666046e-02f, -2.18999665e-02f, -4.27152626e-02f, -9.92528163e-03f,
  1.61019742e-01f, -9.63612348e-02f, 3.38355005e-02f, 1.92289371e-02f, 4.94948439e-02f, -7.45250732e-02f, 5.60448803e-02f, -5.20386733e-03f, -4.85992245e-02f, 6.19183965e-02f,
  3.88559629e-03f, -5.85648045e-02f, -1.24740982e-02f, -4.28326465e-02f, -5.63000292e-02f, 4.47039753e-02f, 1.09494977e-01f, 9.05281156e-02f, 9.26281810e-02f, 1.28343962e-02f,
  3.30420546e-02f, 1.00252626e-03f, 4.10431176e-02f, -7.49940574e-02f, 9.16716736e-03f, -3.87814129e-03f, -1.25907678e-02f, -3.61740291e-02f, -1.80643260e-01f, -2.29248218e-03f,
  -2.52643228e-01f, -9.39674005e-02f, 2.44694754e-01f, -1.18351661e-01f, -8.41591582e-02f, 1.40221104e-01f, 6.75395355e-02f, 4.72691283e-02f, -8.25215206e-02f, -2.37527732e-02f,
  1.00553352e-02f, -4.34939824e-02f, -7.01319650e-02f, -2.72234865e-02f, -9.71475691e-02f, 1.53039709e-01f, -2.93518901e-02f, 7.30104446e-02f, 7.03381083e-04f, 5.28686978e-02f,
  -1.05744891e-01f, -6.20318614e-02f, -1.41495600e-01f, -3.91921923e-02f, -4.56244983e-02f, 9.77742374e-02f, 8.57646689e-02f, -9.65496823e-02f, 3.88618633e-02f, -2.60279570e-02f,
  3.21736366e-01f, -1.99677408e-01f, 3.25189084e-02f, -1.89801306e-01f, -3.97102535e-02f, -1.08621120e-01f, -1.28458394e-02f, 7.44335577e-02f, 2.44400986e-02f, -2.26763990e-02f,
  -1.16878189e-01f, -1.07252389e-01f, -4.41353805e-02f, 5.89556039e-05f, -4.42511812e-02f, -5.25602363e-02f, -8.66541464e-04f, -1.32081896e-01f, -1.20425243e-02f, 1.21535826e-02f,
  -4.94486764e-02f, -1.39256716e-01f, 9.98489782e-02f, -3.31784934e-02f, -7.17552900e-02f, -8.27997401e-02f, 1.01759076e-01f, -7.57013485e-02f, -8.92299339e-02f, 1.67849306e-02f,
  -1.45469895e-02f, 8.56600404e-02f, -6.86397180e-02f, 4.56056185e-02f, -5.17755002e-02f, -6.21143952e-02f, 3.72660160e-02f, 8.89386088e-02f, -2.85272785e-02f, -1.78827513e-02f,
  -2.43412945e-02f, 7.68700801e-03f, 8.87142569e-02f, -2.65037417e-02f, 4.60647941e-02f, -9.34579521e-02f, 8.54836870e-03f, -5.16561046e-02f, -3.83709148e-02f, 3.02343331e-02f,
  -2.69379001e-02f, -7.91270733e-02f, 1.25699565e-02f, 6.17037416e-02f, -1.05274171e-01f, -3.41826603e-02f, -7.97756948e-03f, -6.98473118e-03f, 2.72274073e-02f, 1.14935664e-02f,
  1.86566070e-01f, 2.08198489e-03f, 8.01349208e-02f, -9.21367109e-03f, -4.05744314e-02f, -1.31259188e-01f, 2.43361592e-02f, -1.10756487e-01f, -7.00243860e-02f, -5.96571621e-03f,
  -7.97784626e-02f, 2.03950014e-02f, 1.75057035e-02f, 3.83655950e-02f, 2.13182019e-03f, 6.06071576e-02f, -1.21477291e-01f, 6.08966500e-02f, -5.49222492e-02f, 4.24379595e-02f,
  -9.91646666e-03f, 6.05342351e-02f, 1.25976473e-01f, 1.62579432e-01f, -5.48703857e-02f, 9.10685211e-02f, 2.45092183e-01f, 1.06992409e-01f, 1.57361075e-01f, 1.70124114e-01f,
  2.94175357e-01f, 1.94269270e-01f, 1.11207373e-01f, 4.95583527e-02f, -1.44392299e-02f, -2.22009301e-01f, -1.30764961e-01f, -1.34126276e-01f, -1.26558572e-01f, -3.28269899e-02f,
  -6.22985289e-02f, -2.09669229e-02f, -9.22960714e-02f, 2.19312240e-03f, -8.98803398e-02f, -7.43571296e-02f, 9.90804955e-02f, 1.35216400e-01f, 6.24187402e-02f, 1.55357778e-01f,
  1.72842920e-01f, 2.00182050e-01f, 2.76052713e-01f, 2.54975185e-02f, 8.12805444e-02f, 2.89327442e-03f, -6.01013377e-03f, 4.45586853e-02f, 1.39159530e-01f, 3.52526009e-01f,
  3.37368757e-01f, 1.46763325e-01f, -1.13724396e-01f, -3.37557644e-02f, 5.86972870e-02f, -2.75777932e-02f, 5.17910011e-02f, 2.80544646e-02f, -1.14520546e-02f, -7.30748177e-02f,
  -5.60120530e-02f, 4.14799340e-02f, -1.00825489e-01f, -2.19299011e-02f, -1.00075684e-01f, -3.84910367e-02f, -3.52706052e-02f, 6.66950196e-02f, -3.14558521e-02f, -8.29059035e-02f,
  5.22030182e-02f, 1.31079912e-01f, -6.60191625e-02f, -8.00329149e-02f, -2.59493645e-02f, -1.03463612e-01f, -1.27096266e-01f, 2.09796578e-02f, -8.26164335e-02f, 5.90595566e-02f,
  -1.78506132e-02f, 8.38347748e-02f, -8.64569619e-02f, -3.20188887e-02f, -3.84262539e-02f, -1.00807741e-01f, 2.34717168e-02f, -4.24876250e-02f, -5.68363704e-02f, -7.41321146e-02f,
  -1.18086580e-03f, -5.70282340e-02f, -3.20836306e-02f, 4.03954834e-02f, -5.85600324e-02f, -3.63454595e-02f, -3.42796370e-02f, -7.76573345e-02f, -2.51141712e-02f, -7.05620050e-02f,
  2.04026420e-02f, -1.67263467e-02f, 8.69067758e-02f, -4.99899387e-02f, 2.53260527e-02f, -1.15893006e-01f, -6.01881780e-02f, -1.02733085e-02f, -6.03282638e-02f, 9.43012163e-02f,
  -7.40232691e-02f, -2.47091457e-01f, 5.81942238e-02f, 6.50882125e-02f, 1.20614029e-01f, 5.05651124e-02f, 8.36647153e-02f, 4.06601932e-03f, 7.80956298e-02f, 9.52059031e-02f,
  -3.54747213e-02f, 1.13937967e-01f, -3.29087079e-02f, -5.08493371e-02f, 7.73952901e-02f, 4.26431745e-02f, 1.96424611e-02f, 6.68933764e-02f, -1.16450284e-02f, 8.66578743e-02f,
  2.73791002e-03f, -7.44534060e-02f, -5.20475507e-02f, -1.31620079e-01f, -1.28182754e-01f, -1.26877591e-01f, -3.11827566e-02f, 7.45230448e-03f, -1.27018124e-01f, -1.09338246e-01f,
  5.32515645e-01f, -2.08609998e-01f, -1.18247755e-01f, 1.36217505e-01f, -4.14071372e-03f, 8.91231745e-02f, 7.13737682e-03f, 7.44973868e-02f, 1.12932228e-01f, -2.58512069e-02f,
  1.29329383e-01f, 2.39116028e-01f, 1.49743751e-01f, 1.26293376e-01f, 1.09863676e-01f, -1.35736614e-01f, -9.90199521e-02f, 1.05368033e-01f, 2.37143531e-01f, 1.25301495e-01f,
  -8.38781744e-02f, -1.77099428e-03f, 1.14341125e-01f, -2.82708574e-02f, -1.91125542e-01f, 5.27559742e-02f, -1.75701812e-01f, -8.96911994e-02f, -1.24926545e-01f, -1.96482480e-01f,
  1.95730627e-02f, 1.25630349e-01f, 4.90054637e-02f, 8.70697871e-02f, 1.68977433e-03f, -8.25085118e-02f, 1.00044228e-01f, -1.55309364e-01f, 1.30133899e-02f, -3.76743972e-02f,
  -8.78934041e-02f, -7.56223649e-02f, -3.36408801e-02f, -7.26641864e-02f, -9.95258242e-03f, -1.97097659e-02f, -1.10479362e-01f, -2.11967696e-02f, -4.59559970e-02f, -1.32594109e-01f,
  -1.06386483e-01f, -9.24656354e-03f, 8.18520337e-02f, -1.34587586e-02f, 5.50388061e-02f, 3.74778099e-02f, -7.03390390e-02f, 1.19112413e-02f, -1.48389442e-03f, -5.44640422e-02f,
  2.54446943e-03f, 9.02352855e-02f, 4.44400981e-02f, -2.17339844e-02f, -4.17195037e-02f, -3.28432280e-03f, -7.25915609e-03f, -3.93141173e-02f, 5.32908551e-02f, 4.19798307e-02f,
  6.11285567e-02f, -4.44132742e-03f, 5.88699989e-02f, 1.27708316e-02f, -1.76910963e-03f, -7.99395889e-02f, -3.13724950e-02f, 5.08036604e-03f, 7.53951669e-02f, 4.57790457e-02f,
  3.19148637e-02f, 1.43364845e-02f, 7.95228686e-03f, -1.07843116e-01f, 4.12660018e-02f, 4.79402160e-03f, 1.07870959e-02f, 5.25472946e-02f, 4.90920618e-02f, -8.01936761e-02f,
  -3.28422599e-02f, 1.59372732e-01f, 9.26644504e-02f, 3.16578560e-02f, 3.36948298e-02f, -1.01579763e-01f, 1.05208106e-01f, -3.35793160e-02f, -2.40313765e-02f, -1.49023071e-01f,
  2.60410067e-02f, 9.20348912e-02f, -8.14485252e-02f, -2.89246062e-04f, 6.54764026e-02f, 5.58116883e-02f, 1.94560401e-02f, 1.07696466e-02f, -6.68245628e-02f, -1.69142112e-01f,
  -8.80249962e-02f, 1.07629225e-01f, 2.03037262e-01f, 2.30731666e-02f, -6.18816055e-02f, 2.23143801e-01f, -3.56504731e-02f, -3.16927508e-02f, 2.01792046e-01f, 7.55305067e-02f,
  -1.17827579e-01f, 7.30694970e-03f, -7.77058527e-02f, -7.88594484e-02f, -2.02621557e-02f, 1.04896963e-01f, 2.43508622e-01f, 1.04659483e-01f, -2.47202832e-02f, 1.36448098e-02f,
  3.06155477e-02f, -1.53969556e-01f, -1.84678771e-02f, 1.65549237e-02f, 4.57864106e-02f, 4.87864390e-02f, 8.07696804e-02f, -1.14921331e-01f, -1.35175928e-01f, -1.59312878e-02f,
  6.49059787e-02f, 4.66949604e-02f, -1.09559834e-01f, -1.04952827e-01f, -8.85593072e-02f, -1.07066460e-01f, -1.20024174e-01f, -8.69989172e-02f, 9.99130756e-02f, -1.53720109e-02f,
  -1.71900555e-01f, -5.98164126e-02f, -6.85400749e-03f, 4.11931612e-02f, -1.03528567e-01f, -3.50351930e-02f, -7.89985806e-02f, -2.94194892e-02f, -4.10077944e-02f, -5.87570332e-02f,
  -5.79247586e-02f, -1.21409690e-03f, -1.23578116e-01f, -1.90344453e-02f, -4.39583622e-02f, -3.50371785e-02f, 4.18556109e-02f, -1.12857819e-01f, -1.88326221e-02f, 3.11298873e-02f,
  4.47619818e-02f, 1.71485692e-02f, -2.58528013e-02f, -1.35516971e-02f, 5.87098338e-02f, -1.15065515e-01f, -3.78907751e-03f, -1.13386856e-02f, -1.04170768e-02f, -8.40583891e-02f,
  8.65624622e-02f, 4.57112677e-02f, -4.92834486e-02f, 5.26847085e-03f, -3.78040187e-02f, -7.46163214e-03f, -9.08623077e-03f, 6.04422018e-02f, 6.28721640e-02f, 1.33772679e-02f,
  3.99091206e-02f, -1.75865684e-02f, -4.42128778e-02f, -7.72173405e-02f, -1.07777854e-02f, -3.20739895e-02f, -2.54493356e-02f, 1.68516077e-02f, 1.29595893e-02f, -3.35936286e-02f,
  5.53890839e-02f, 6.07129708e-02f, 5.92392981e-02f, -2.80437730e-02f, 4.76247296e-02f, 6.26058504e-02f, -6.54005110e-02f, -3.62740420e-02f, 2.90090647e-02f, 3.07068061e-02f,
  -7.67458081e-02f, -5.95219284e-02f, 2.55145114e-02f, -7.65606016e-02f, -7.75375068e-02f, -7.43463710e-02f, -8.27292502e-02f, 6.78315759e-02f, -1.03062734e-01f, -5.58159575e-02f,
  -7.00912848e-02f, -2.62847207e-02f, -1.06405430e-01f, -3.06252018e-02f, -8.08584318e-02f, -5.83407171e-02f, 1.39642119e-01f, 5.80694666e-03f, 1.23846531e-02f, -6.98135048e-02f,
  3.07731014e-02f, 8.78696069e-02f, 1.20149232e-01f, 1.13174923e-01f, 1.22114280e-02f, -8.79670456e-02f, -9.08113047e-02f, 7.95393959e-02f, -3.82097391e-03f, 1.41276479e-01f,
  -4.19549435e-01f, 1.67555287e-01f, 1.05364963e-01f, -2.54076421e-01f, -9.95833334e-03f, 2.50395983e-02f, 2.45069265e-02f, -6.74363822e-02f, -5.32572605e-02f, 1.37129202e-01f,
  -2.31918283e-02f, -1.57750845e-01f, -1.38085619e-01f, -1.43458977e-01f, -1.53919354e-01f, 2.20235903e-02f, -1.54617473e-01f, -3.03868324e-01f, -3.07015836e-01f, -2.51298964e-01f,
  -1.18726984e-01f, -1.82827547e-01f, -2.66321331e-01f, -1.67615429e-01f, 4.36168164e-02f, -1.58301163e-02f, -5.11074625e-02f, -1.24257468e-01f, -2.49849111e-02f, -4.34435084e-02f,
  3.29844356e-01f, -1.36052400e-01f, -5.74786365e-02f, -1.28555015e-01f, 8.38968828e-02f, -3.85022722e-02f, -5.00550382e-02f, -6.70372099e-02f, -3.12293172e-02f, 9.94167551e-02f,
  -1.27838507e-01f, -7.66649768e-02f, 4.81889993e-02f, 4.55254577e-02f, -3.21417861e-02f, 3.42745110e-02f, 3.02829575e-02f, -4.33017388e-02f, -2.16347966e-02f, 5.76752871e-02f,
  1.58180252e-01f, -9.17903855e-02f, -2.03300733e-02f, 9.18312296e-02f, 1.34344576e-02f, -1.55226141e-01f, 1.53225169e-01f, 1.01685680e-01f, 1.07252888e-01f, 1.46761402e-01f,
  -2.14299560e-03f, 7.75499418e-02f, 2.06787568e-02f, -9.31630668e-04f, 2.48452518e-02f, 5.89775592e-02f, -2.43305955e-02f, 5.67939468e-02f, -9.22133848e-02f, 4.07870002e-02f,
  5.98828495e-02f, 5.34980670e-02f, 8.11150819e-02f, 5.16166352e-02f, -4.47520949e-02f, -9.15420335e-03f, -3.89265530e-02f, 5.59019335e-02f, -2.69275513e-02f, -8.56305361e-02f,
  -4.07453924e-02f, -9.96751245e-03f, 3.85346562e-02f, -3.58767062e-02f, -2.61163488e-02f, 6.35332689e-02f, -1.17745074e-02f, -6.66130707e-02f, 7.93801546e-02f, -1.00212820e-01f,
  1.99132562e-01f, -1.73516795e-01f, -7.46513996e-03f, -8.42936486e-02f, -2.07806211e-02f, 1.29114449e-01f, 9.29346308e-02f, 5.80595136e-02f, -4.93382923e-02f, -2.74615232e-02f,
  8.81188270e-03f, -2.74545308e-02f, 8.32962524e-03f, 4.37267795e-02f, -3.24087553e-02f, 1.46631300e-02f, 1.55674545e-02f, 1.79802366e-02f, 4.45063822e-02f, 9.78020206e-02f,
  3.80948409e-02f, 6.46612197e-02f, 1.16529744e-02f, 9.07619298e-03f, -5.33402804e-03f, -7.75790289e-02f, 1.19738534e-01f, 7.94156641e-02f, -6.89772069e-02f, 2.59884089e-01f,
  -5.70197292e-02f, 6.38020709e-02f, -6.85527027e-02f, -5.69787398e-02f, 8.44656602e-02f, -1.06003344e-01f, -1.54425740e-01f, 9.27580521e-03f, -3.73201445e-03f, 4.09331731e-02f,
  5.19030653e-02f, -1.34576768e-01f, -5.77826500e-02f, -2.26178184e-01f, -1.49155557e-01f, -6.09260835e-02f, -1.64038911e-01f, -2.40427494e-01f, -2.90987074e-01f, -2.45451108e-01f,
  -2.00338393e-01f, -1.72295734e-01f, -2.11927772e-01f, -1.41210556e-01f, 9.67955391e-04f, -8.39225352e-02f, 8.56834725e-02f, -1.97294354e-02f, -9.83638912e-02f, 6.07641488e-02f,
  -6.24959916e-02f, 8.79642069e-02f, -3.71189602e-02f, -3.80031317e-02f, 5.83721846e-02f, -3.34823504e-02f, -4.60183620e-02f, 4.94078547e-02f, 5.41085303e-02f, -5.25250658e-02f,
  1.61801409e-02f, -7.65314400e-02f, -1.04959518e-01f, 6.19270504e-02f, -7.76745901e-02f, -2.22000331e-02f, -3.21151838e-02f, -1.41096443e-01f, -5.97009286e-02f, 1.12201363e-01f,
  3.49914841e-02f, -6.96656760e-03f, 3.80712003e-02f, 5.74208461e-02f, 5.52947074e-02f, 2.90834475e-02f, 7.13367090e-02f, -4.59114742e-03f, -1.03408337e-01f, 1.05296284e-01f,
  -3.37447338e-02f, -5.29556386e-02f, 2.92291660e-02f, 7.40366131e-02f, 7.84313586e-03f, 8.31847340e-02f, 1.56670921e-02f, -8.19682181e-02f, 3.28385569e-02f, -4.03299704e-02f,
  -6.68405294e-02f, 5.40853404e-02f, 2.15038806e-02f, -4.21095751e-02f, -2.74652634e-02f, -5.77671453e-03f, -1.90050360e-02f, -5.69975078e-02f, -1.60106774e-02f, 2.50216685e-02f,
  -3.85971814e-02f, 7.59722069e-02f, 4.49756049e-02f, -4.79109399e-02f, -4.52485085e-02f, 2.00215206e-02f, -4.82861931e-03f, -4.51605991e-02f, -7.18384460e-02f, -6.25364333e-02f,
  -9.46300775e-02f, -6.48937896e-02f, -9.36405957e-02f, -6.32244349e-02f, -9.39070014e-04f, -5.37906168e-03f, 9.31976065e-02f, -6.33605048e-02f, -6.34456798e-02f, -7.28226230e-02f,
  1.52868023e-02f, -7.93273672e-02f, 1.34350918e-02f, -2.26341039e-02f, 5.79945073e-02f, 4.53567877e-02f, -3.16803157e-03f, 1.43905450e-03f, -5.88434264e-02f, -2.33265720e-02f,
  6.26292601e-02f, -1.70003325e-01f, -1.04334317e-01f, -1.35508969e-01f, 7.06053972e-02f, -5.02437092e-02f, -1.74282849e-01f, -1.36761412e-01f, -2.05684900e-01f, -4.46598828e-02f,
  1.46621540e-01f, 1.32145286e-01f, -1.10552020e-01f, 9.41150337e-02f, -5.87653294e-02f, 1.16586387e-01f, 1.25250012e-01f, 2.04816729e-01f, 7.59894550e-02f, 1.79233372e-01f,
  8.01457912e-02f, 1.85582504e-01f, 2.32725337e-01f, 1.24195620e-01f, 1.74000889e-01f, 2.99822483e-02f, 7.16382861e-02f, -3.21019441e-02f, -2.85749091e-03f, 4.69699875e-02f,
  1.46397531e-01f, 2.28257407e-03f, 6.27836864e-03f, 2.64493041e-02f, 4.92035449e-02f, 7.76224658e-02f, -1.68469679e-02f, -1.14024751e-01f, -5.00490479e-02f, -8.64731148e-02f,
  -1.70845419e-01f, -3.08513194e-02f, 5.62426932e-02f, 1.10862195e-01f, -8.39178264e-02f, 6.40114862e-03f, -9.29732155e-03f, -1.10348940e-01f, -6.63148239e-02f, -5.69690466e-02f,
  2.96378545e-02f, -1.22914299e-01f, -1.03896642e-02f, -7.51801357e-02f, -1.12216964e-01f, -1.12447040e-02f, -4.51079644e-02f, 1.94529872e-02f, 5.07875569e-02f, -1.82242896e-02f,
  -5.46030840e-03f, -8.66074190e-02f, -1.48558453e-01f, 9.52676758e-02f, 5.63574247e-02f, -8.45474098e-03f, -1.21921888e-02f, 3.64012755e-02f, 2.56159413e-03f, 5.65937273e-02f,
  -6.76357374e-02f, -2.12014597e-02f, -8.00608620e-02f, 1.12471636e-02f, 1.00591235e-01f, 1.91708375e-02f, -7.76806623e-02f, -4.15309286e-03f, 1.17373183e-01f, -6.04347959e-02f,
  -5.05900308e-02f, -4.79605831e-02f, -2.06074491e-03f, 8.61883238e-02f, -4.54292260e-02f, -8.61332715e-02f, -1.00229699e-02f, -5.36471121e-02f, -5.54967076e-02f, -2.52816789e-02f,
  -1.61293466e-02f, -1.22134380e-01f, -3.87498438e-02f, -4.03801091e-02f, -1.05156228e-02f, -5.88414408e-02f, 6.13659853e-04f, 7.42790848e-03f, 8.94638374e-02f, -5.04575146e-04f,
  7.80794024e-02f, 1.27525017e-01f, 8.85902345e-02f, 2.36073527e-02f, -2.79429611e-02f, 3.29877399e-02f, 9.41222459e-02f, -7.37736151e-02f, -1.24636091e-01f, -7.46602342e-02f,
  -1.06189258e-01f, -1.12778842e-01f, -1.98940318e-02f, 6.35580048e-02f, 1.26222521e-02f, 6.56302869e-02f, 4.01180051e-02f, -5.53539619e-02f, 2.48737913e-02f, -1.13772929e-01f,
  -3.29919457e-02f, 5.12820110e-02f, 4.77164686e-02f, -2.78250054e-02f, -4.90210280e-02f, 8.58163610e-02f, 1.59263741e-02f, 5.22140898e-02f, -5.88986203e-02f, 7.40605742e-02f,
  3.50163616e-02f, -5.18638380e-02f, 2.30565257e-02f, 9.05387476e-02f, -1.06280081e-01f, -2.15796605e-01f, -9.68728140e-02f, -1.66489586e-01f, -3.58235613e-02f, 2.64961608e-02f,
  -4.32337038e-02f, 8.22779238e-02f, 3.25062759e-02f, -4.50789183e-02f, -2.27219220e-02f, 5.88943847e-02f, 1.46129742e-01f, 5.36172800e-02f, 1.50959283e-01f, 1.19104691e-01f,
  3.29700038e-02f, 1.73120052e-01f, 4.56053950e-02f, 1.09925559e-02f, 1.29834414e-01f, -1.03487605e-02f, 5.89115247e-02f, 9.22897160e-02f, 2.98559833e-02f, 1.70202911e-01f,
  1.34234186e-02f, -4.84072678e-02f, -4.59731445e-02f, 5.41247800e-02f, 1.46951973e-02f, -3.72690968e-02f, -4.77390690e-03f, -6.50215298e-02f, -4.23553213e-02f, -3.24708559e-02f,
  -8.74862075e-02f, -4.04237956e-02f, 2.07511019e-02f, 5.75658903e-02f, -5.93370460e-02f, -7.74246873e-03f, -7.92905763e-02f, 5.01380721e-03f, 5.92242070e-02f, -6.49429858e-02f,
  1.60055712e-03f, -3.67524251e-02f, 3.18707116e-02f, -1.60242319e-01f, 2.37306748e-02f, 6.02136999e-02f, -4.24323641e-02f, 6.04818426e-02f, -1.12322792e-01f, 2.84166224e-02f,
  -6.54346421e-02f, -6.82547539e-02f, -3.54834311e-02f, -5.88894542e-03f, -3.38847935e-02f, 3.25326137e-02f, 5.36943972e-02f, 2.44703274e-02f, 6.88656792e-03f, 1.50651410e-02f,
  3.10092419e-02f, -2.89895805e-03f, -6.85849041e-02f, -5.05358726e-02f, 6.77158982e-02f, -6.06179377e-03f, 5.40745743e-02f, 8.83971900e-02f, 2.74108462e-02f, 6.20259121e-02f,
  3.60809565e-02f, -1.44280884e-02f, 2.41842158e-02f, 3.13637964e-02f, 5.47321066e-02f, 8.12087581e-02f, 4.28350978e-02f, -8.90085101e-03f, -7.10586235e-02f, -1.20740021e-02f,
  -5.26124276e-02f, -1.19214267e-01f, -1.77885182e-02f, -4.68722023e-02f, 5.55561297e-02f, -4.84626740e-02f, -9.11431294e-03f, -4.16841824e-03f, -3.85689596e-03f, -1.59713551e-02f,
  -9.28037316e-02f, -1.15293097e-02f, 1.46312695e-02f, -6.85496926e-02f, 7.68790469e-02f, 4.28665541e-02f, 7.26724640e-02f, 2.84211356e-02f, 2.39514597e-02f, -4.51502204e-02f,
  -3.10089458e-02f, -1.16376668e-01f, 1.81534532e-02f, -1.05870806e-01f, -9.70522314e-02f, -1.55424783e-02f, -8.90085287e-03f, 2.93126553e-02f, -1.20399199e-01f, -3.49004529e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.21608281e-01f, 9.12640244e-02f, -2.40100292e-03f, -2.56208493e-03f, 8.00513700e-02f, 9.36552510e-02f, 2.11887628e-01f, 4.47077155e-02f, 5.06728217e-02f, 7.54124522e-02f,
  7.74340630e-02f, 3.70013379e-02f, 1.24770932e-01f, 4.44944426e-02f, 2.15600520e-01f, 1.29853651e-01f, 4.86173630e-02f, 1.98578835e-01f, 2.63764858e-01f, 2.33628958e-01f,
  1.63718864e-01f, 3.46696913e-01f, 1.88831717e-01f, 3.46327454e-01f, 2.43631288e-01f, 1.96540996e-01f, 1.97271228e-01f, 9.63250473e-02f, 1.07836097e-01f, 1.52902052e-01f,
  7.02504069e-02f, 5.12354560e-02f, 1.84900925e-01f, 3.08306031e-02f, 2.70816594e-01f, 1.16056085e-01f, 8.35984573e-02f, 5.33655509e-02f, 1.52926996e-01f, 2.08570525e-01f,
  1.66056320e-01f, 1.48760870e-01f, 4.94231343e-01f, 7.35041052e-02f, 2.32449502e-01f, 2.01974332e-01f, 2.91999638e-01f, 1.30478844e-01f, 3.49909455e-01f, 8.88902545e-02f,
  8.09421390e-02f, 1.08271375e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -4.56110299e-01f, -1.05696224e-01f, -5.55935025e-01f, -1.60435960e-01f, -1.59430783e-02f, -3.99439305e-01f, 2.17125148e-01f, -4.85238060e-02f, 1.03652738e-01f, 1.52090490e-01f,
  -1.28909320e-01f, 5.78123657e-03f, -9.33441594e-02f, 3.53230760e-02f, 1.79648191e-01f, 2.21808851e-01f, -6.34963736e-02f, -2.16663957e-01f, 3.19738179e-01f, -5.57241812e-02f,
  -1.21789366e-01f, -1.32523641e-01f, -2.50372112e-01f, 7.26571739e-01f, 3.56213212e-01f, 1.94513258e-02f, -2.61989236e-01f, 1.53103575e-01f, -1.28062814e-01f, -2.75324434e-01f,
  -6.55820295e-02f, -3.64278883e-01f, -2.34090574e-02f, 1.72097594e-01f, -1.76304311e-01f, 2.99400121e-01f, -6.61188886e-02f, -2.44344577e-01f, 1.70865625e-01f, -1.12537079e-01f,
  3.67531270e-01f, 6.78407967e-01f, 3.19796681e-01f, 4.72104728e-01f, -2.19170883e-01f, 3.80465239e-02f, -1.77104287e-02f, -7.93938059e-03f, -1.30481273e-01f, 8.27816054e-02f,
  -1.59389134e-02f, -1.40485868e-01f, 2.94673890e-01f, 1.92979112e-01f, 9.05300770e-03f, -1.29989147e-01f, -2.98793674e-01f, -1.25313953e-01f, 4.89984192e-02f, -1.10677145e-02f,
  -1.11631580e-01f, 5.69648482e-02f, -1.77415222e-01f, -1.31890863e-01f, -2.38696247e-01f, -1.73401472e-03f, 3.64636660e-01f, 7.80945122e-02f, 1.51601836e-01f, -3.22588265e-01f,
  -2.84261912e-01f, -7.17013031e-02f, 1.08441589e-02f, 2.46233538e-01f, 4.50172842e-01f, -5.10146558e-01f, -3.00285399e-01f, 3.28201763e-02f, -1.24299653e-01f, -1.43496588e-01f,
  2.54026741e-01f, -1.12333260e-01f, -2.34016776e-01f, 1.15371525e-01f, 1.18541248e-01f, -1.44121289e-01f, -5.07893674e-02f, 2.23260522e-01f, -2.13817567e-01f, 2.53463387e-01f,
  8.40218796e-04f, 2.95779593e-02f, -1.49646640e-01f, 7.34796003e-02f, -2.27900192e-01f, -4.08670634e-01f, 9.85222682e-02f, 6.04955673e-01f, 1.44775240e-02f, -1.57277565e-03f,
  -1.90333977e-01f, 1.22257374e-01f, -2.00629264e-01f, 2.97388643e-01f, 8.88535678e-01f, 2.23060519e-01f, -1.66553989e-01f, 1.42112926e-01f, 1.20400451e-01f, 1.64743036e-01f,
  5.90099096e-01f, 4.18774962e-01f, -8.35798085e-02f, 6.09334894e-02f, 3.99770103e-02f, -1.62046090e-01f, -2.55377173e-01f, -1.36225179e-01f, -9.97997671e-02f, 2.55619437e-01f,
  -1.05900332e-01f, -2.23215997e-01f, 8.45656753e-01f, -1.70738921e-01f, -4.66620386e-01f, -2.01364905e-01f, 4.07511175e-01f, -1.67295218e-01f, 6.64978027e-01f, 2.77744383e-01f,
  2.32320115e-01f, 3.49299610e-01f, 1.54834896e-01f, 1.57193244e-01f, 1.72288537e-01f, -1.45836202e-02f, 3.24905127e-01f, -3.97387862e-01f, -4.60173376e-02f, -1.58285588e-01f,
  -2.07605645e-01f, -2.71683872e-01f, 4.29045297e-02f, 2.00874999e-01f, -2.09386662e-01f, -2.90238738e-01f, -4.89133503e-03f, -1.18653417e-01f, -3.34430300e-03f, -1.42154828e-01f,
  -1.65377736e-01f, -2.50034302e-01f, -1.92841396e-01f, 1.08323559e-01f, -1.21468149e-01f, -2.20085368e-01f, -2.44519524e-02f, 5.31713367e-01f, -2.95805484e-01f, 1.13506198e-01f,
  4.76393461e-01f, 6.05828285e-01f, -1.34507403e-01f, 7.43548393e-01f, 5.28568447e-01f, -1.46374226e-01f, 3.16465497e-01f, -1.04325764e-01f, 4.50874195e-02f, -1.86496511e-01f,
  -6.74765510e-03f, 2.11378500e-01f, -7.65973330e-02f, -6.20593317e-02f, -3.39236669e-02f, 1.29102111e-01f, -4.85187210e-03f, 9.26259533e-02f, -2.18183339e-01f, -3.40360433e-01f,
  5.96110076e-02f, -1.87090859e-01f, -2.41383016e-01f, -3.57519656e-01f, -1.31123334e-01f, -1.12929851e-01f, -5.86866029e-02f, -1.37915909e-01f, -2.33568907e-01f, -1.96048841e-01f,
  -1.56662121e-01f, 1.23833336e-01f, 5.80280423e-02f, 6.31576255e-02f, -9.05748457e-02f, 3.74444760e-02f, -4.36396785e-02f, -1.53249323e-01f, -5.49174666e-01f, -1.93353549e-01f,
  2.12921500e-01f, 1.61689147e-01f, -7.27646351e-01f, -2.22045153e-01f, -7.99577683e-02f, 6.28821105e-02f, 1.91642106e-01f, -1.74958423e-01f, -1.15430221e-01f, -1.89681500e-01f,
  -4.52451527e-01f, 1.15593961e-02f, 1.38240874e-01f, 2.29366496e-01f, -9.68404263e-02f, 2.32376352e-01f, 2.24592350e-02f, -6.37350827e-02f, -2.31371015e-01f, -3.51561308e-01f,
  1.65305082e-02f, -1.47854656e-01f, -2.61348546e-01f, 9.07977045e-01f, -1.53835118e-01f, -2.76441257e-02f, -3.75407040e-02f, -3.44431579e-01f, -1.41529990e-02f, 5.74379742e-01f,
  -6.30808473e-02f, -1.90961868e-01f, -4.36940849e-01f, 1.62983611e-01f, 5.24205685e-01f, -1.26697883e-01f, 4.02716786e-01f, -1.23188854e-03f, -5.05146421e-02f, -8.27023536e-02f,
  -4.51933183e-02f, 9.64589603e-03f, 2.95662731e-01f, -2.17773303e-01f, -5.01543051e-03f, 1.46498576e-01f, -3.69516551e-01f, -3.00475180e-01f, 8.63625109e-02f, -4.48787445e-03f,
  -1.60543948e-01f, 2.65037924e-01f, 4.65504885e-01f, 1.43466845e-01f, -7.31403306e-02f, -1.59102827e-01f, -5.14835536e-01f, 6.68341443e-02f, -3.36843044e-01f, 4.36123073e-01f,
  -5.35606360e-03f, 1.64870713e-02f, -5.15774667e-01f, -1.69921473e-01f, 4.05629247e-01f, -2.79430360e-01f, 3.86996746e-01f, -1.47794396e-01f, -9.93028749e-03f, -6.29276633e-02f,
  4.56141569e-02f, 2.70450354e-01f, 5.93001880e-02f, 2.90035397e-01f, 3.41507792e-01f, -2.78655924e-02f, -1.36082157e-01f, 5.50916374e-01f, 6.84153056e-03f, -4.96891350e-01f,
  -6.79617897e-02f, -1.34374827e-01f, 1.94955338e-02f, 4.34588730e-01f, 3.50388348e-01f, 1.46771014e-01f, -1.01258807e-01f, -8.63210708e-02f, -2.84969565e-02f, -3.30792636e-01f,
  -1.50409460e-01f, -2.29804367e-01f, 2.79161870e-01f, 4.31159958e-02f, -1.77089847e-03f, 1.53553963e-01f, 1.53329104e-01f, -3.06599468e-01f, -1.22407794e-01f, 1.08978739e-02f,
  1.61220487e-02f, -1.76533118e-01f, -1.91585943e-01f, -1.23794377e-01f, 6.30103573e-02f, -6.92285895e-02f, 3.21917117e-01f, -7.91383535e-02f, 4.65169668e-01f, -1.92790225e-01f,
  -9.12393704e-02f, 2.33726948e-01f, -7.64562562e-03f, -1.86889216e-01f, -1.87864959e-01f, -1.91433743e-01f, 5.57468355e-01f, 5.39144695e-01f, -9.65096727e-02f, -1.42341256e-01f,
  7.10998848e-03f, 8.56092200e-02f, 5.17430961e-01f, 2.22364917e-01f, 1.60655007e-01f, 4.98343855e-01f, -5.02180755e-01f, -3.86379778e-01f, -5.24800062e-01f, 3.98003727e-01f,
  2.94308633e-01f, -3.01792055e-01f, -2.24133372e-01f, -1.70002446e-01f, -2.42775679e-01f, 9.99456085e-03f, 2.65033543e-01f, 2.60393888e-01f, 5.56031048e-01f, -1.56945467e-01f,
  -6.88435212e-02f, -3.51446599e-01f, 1.23565443e-01f, -2.28318833e-02f, 1.69672385e-01f, 1.29460633e-01f, 2.47790277e-01f, -8.27845559e-02f, -1.37002142e-02f, -1.24754846e-01f,
  2.35477224e-01f, -3.96556228e-01f, -1.69817358e-01f, -3.62563640e-01f, -2.05080077e-01f, -8.58957320e-02f, 4.95438017e-02f, 1.06816933e-01f, -2.09602535e-01f, 3.25316936e-03f,
  2.40775079e-01f, -2.78827310e-01f, -1.11805171e-01f, 5.11979535e-02f, -1.47629037e-01f, -6.66957125e-02f, -4.84869704e-02f, -1.43974990e-01f, 2.56079555e-01f, 1.36991665e-02f,
  1.23747505e-01f, -4.39576805e-02f, -1.64856404e-01f, 1.97384715e-01f, 1.15126181e+00f, 1.03956759e-01f, -1.14666589e-01f, -9.48184803e-02f, 7.21562430e-02f, 2.21437469e-01f,
  2.30076820e-01f, 1.00235097e-01f, 4.09347028e-01f, -1.46684842e-02f, -4.10032004e-01f, -1.53788850e-01f, 1.38181478e-01f, -1.68581054e-01f, 7.54871145e-02f, -6.44792840e-02f,
  6.55305326e-01f, 4.29650396e-01f, -3.37206721e-01f, -3.34371328e-01f, 7.04983622e-02f, 4.86237735e-01f, -2.35416472e-01f, 8.80435258e-02f, -1.35819092e-01f, 3.83566320e-01f,
  -2.32836202e-01f, -1.51013777e-01f, 7.22021982e-03f, 3.38681191e-02f, -6.42166808e-02f, -3.33358273e-02f, -1.09239995e-01f, -4.90176678e-02f, -1.31861478e-01f, -2.11020559e-02f,
  -1.35343269e-01f, 4.69507277e-02f, -8.43007397e-03f, 1.22339346e-01f, 2.79394358e-01f, -2.17219159e-01f, 5.34408152e-01f, -8.14932734e-02f, -1.21130623e-01f, 3.11209112e-01f,
  -2.74581224e-01f, -1.74512655e-01f, -2.32278407e-01f, 8.97698104e-02f, -7.16559887e-02f, -2.29782820e-01f, -2.93923616e-01f, -2.30952382e-01f, -7.20856115e-02f, -9.71706435e-02f,
  -3.48122150e-01f, 6.27773762e-01f, 2.91027650e-02f, -1.46244153e-01f, -1.95824704e-03f, 5.56765437e-01f, 4.23030406e-02f, 6.97339550e-02f, 3.72074604e-01f, -3.89691621e-01f,
  -3.61102782e-02f, 6.21402383e-01f, -2.33048618e-01f, -1.01242714e-01f, -2.63898134e-01f, -2.40160435e-01f, -9.86343026e-02f, 1.71241164e-01f, -2.92400360e-01f, -2.93261167e-02f,
  -5.15386015e-02f, -5.06227314e-01f, -1.88506186e-01f, -9.78407562e-02f, 3.19559693e-01f, 3.26906629e-02f, -8.75130296e-02f, -3.43410492e-01f, -1.43190071e-01f, 3.38758349e-01f,
  -7.67218918e-02f, -1.00942403e-01f, 8.04423541e-02f, -8.29666778e-02f, 9.32972431e-02f, -1.39486715e-01f, 9.79721695e-02f, -2.24135101e-01f, 4.91900176e-01f, -2.51302961e-02f,
  -1.04947530e-01f, -3.21868272e-03f, 1.12747356e-01f, -2.11730257e-01f, -4.32734489e-02f, -7.16430694e-02f, -1.36772886e-01f, -7.16673583e-02f, -1.99133605e-01f, 8.06231797e-01f,
  -1.65691987e-01f, 6.42664125e-03f, 6.00706227e-02f, -3.09879392e-01f, 4.05074991e-02f, -7.46171921e-02f, 3.00304055e-01f, -4.34359573e-02f, -4.63855006e-02f, -2.28926152e-01f,
  1.38165191e-01f, -1.21753983e-01f, -6.46434054e-02f, 3.64379585e-01f, -1.36451676e-01f, -1.14626728e-01f, 1.73898228e-02f, -1.09153777e-01f, -2.08858997e-01f, -2.03978613e-01f,
  -1.12213649e-01f, 7.18076080e-02f, -1.13461167e-01f, 6.25590801e-01f, -1.05859473e-01f, -3.11514229e-01f, -3.32100123e-01f, 1.68126628e-01f, -1.46086857e-01f, -1.53850332e-01f,
  1.96811318e-01f, -1.99807808e-02f, 1.41744539e-01f, 6.45670369e-02f, -2.66305357e-01f, -3.55444988e-03f, 1.44749194e-01f, 5.67016192e-02f, 6.14673674e-01f, -1.40507326e-01f,
  -4.94087458e-01f, 3.63057643e-01f, -3.54651541e-01f, -1.69399664e-01f, 8.29511702e-01f, -2.45169282e-01f, 1.31746113e-01f, -9.23838168e-02f, -1.79461822e-01f, -1.25051007e-01f,
  -5.18671647e-02f, 2.55315334e-01f, 4.17159200e-01f, -1.51107088e-01f, -1.12139612e-01f, -2.55322754e-01f, -3.95273641e-02f, 1.51302308e-01f, 2.28045583e-01f, -1.92840807e-02f,
  -1.56590164e-01f, -1.86275050e-01f, 2.70681709e-01f, -2.63040721e-01f, -1.26723737e-01f, 2.29375228e-01f, 2.03675732e-01f, -2.18395770e-01f, -1.06863871e-01f, -2.95765817e-01f,
  -1.66379020e-01f, -1.33521155e-01f, -2.76564687e-01f, -2.37877667e-01f, -2.09109396e-01f, -1.52914748e-01f, 1.63969070e-01f, 2.72370964e-01f, 7.59776175e-01f, -2.22165063e-02f,
  -1.03384815e-01f, -5.23646735e-03f, -2.21480966e-01f, -2.77895510e-01f, -2.65910149e-01f, 5.47139049e-02f, 6.23441599e-02f, -4.85918298e-02f, 3.14550400e-01f, 4.28134315e-02f,
  2.59808987e-01f, 2.62216609e-02f, -1.40978217e-01f, -2.76547074e-01f, -1.12713978e-01f, -3.15577071e-03f, 5.95905781e-01f, -3.30478735e-02f, 2.20163390e-01f, -2.85209566e-01f,
  -2.90420115e-01f, -1.32631168e-01f, -3.99586052e-01f, 4.54956561e-01f, 3.85744721e-01f, -3.92182857e-01f, 6.46825492e-01f, 6.22713327e-01f, -8.90832618e-02f, 1.60915360e-01f,
  1.04601428e-01f, -2.70968620e-02f, -9.64053795e-02f, 5.32178640e-01f, 4.12433594e-01f, 1.94869533e-01f, -2.01546490e-01f, 2.67909944e-01f, -7.68898949e-02f, -1.38076171e-01f,
  3.10416855e-02f, 7.38346204e-02f, -2.33431727e-01f, 1.61661774e-01f, 2.17392296e-01f, -1.33192703e-01f, -2.67733604e-01f, 1.58310547e-01f, -1.85783237e-01f, -2.15785235e-01f,
  -1.00721888e-01f, 1.71398222e-01f, 4.36996311e-01f, -8.26203972e-02f, 6.19260967e-02f, -2.40346685e-01f, -2.21173819e-02f, -3.09970021e-01f, -1.82263449e-01f, -1.66543618e-01f,
  -1.24641873e-01f, -1.55571997e-01f, -1.78660244e-01f, -9.15519819e-02f, 8.10145438e-02f, 3.11062396e-01f, -9.20740217e-02f, 4.32083338e-01f, 3.39146286e-01f, 4.74017970e-02f,
  -3.35911334e-01f, 3.95326316e-01f, -2.36882523e-01f, 5.43846250e-01f, -2.85942536e-02f, -1.60664231e-01f, -1.50479227e-01f, 1.12548023e-01f, -1.55325621e-01f, 2.66855538e-01f,
  1.66795433e-01f, -2.47726128e-01f, 2.57688850e-01f, 2.17383560e-02f, -1.67709842e-01f, -7.05594122e-02f, -1.68149620e-01f, -1.71297953e-01f, -1.66830849e-02f, 1.37235954e-01f,
  3.77654374e-01f, 3.98095399e-01f, 7.45123103e-02f, -5.20315394e-02f, -1.24938257e-01f, -1.56540871e-01f, -4.28924188e-02f, -1.47714272e-01f, -2.43150070e-01f, -2.44728342e-01f,
  -7.99883679e-02f, 6.49605542e-02f, 5.38251102e-01f, -2.34459597e-03f, -2.50548005e-01f, 8.29195324e-03f, 7.34608710e-01f, -2.98380047e-01f, -1.39540024e-02f, 3.76332668e-03f,
  -6.32795766e-02f, -1.83084711e-01f, -2.44051013e-02f, -1.43567830e-01f, -1.84773937e-01f, -1.44079208e-01f, -1.62711367e-01f, 2.27925718e-01f, 1.14715926e-01f, -8.72103125e-02f,
  -1.88721448e-01f, 4.88549203e-01f, -2.70304739e-01f, -3.12287390e-01f, -1.74311996e-01f, 3.42356488e-02f, -3.89753468e-02f, -1.09352089e-01f, -8.53185058e-02f, -1.95963696e-01f,
  7.38147944e-02f, -1.26810983e-01f, -2.38842264e-01f, -1.38395187e-02f, -3.61369729e-01f, -4.54976894e-02f, 6.69142604e-01f, 4.54845391e-02f, -1.58307076e-01f, -1.40776828e-01f,
  4.94194388e-01f, -2.76170850e-01f, 7.04363286e-02f, -5.06577231e-02f, -2.32292429e-01f, -5.58912344e-02f, 1.40494481e-01f, 3.33352596e-01f, -8.88170227e-02f, 2.54496448e-02f,
  3.61917645e-01f, 4.26658690e-01f, -2.87399767e-03f, 5.42853784e-04f, -5.04377425e-01f, -2.27822050e-01f, 3.44817847e-01f, 5.52828968e-01f, 1.20621830e-01f, -1.14385244e-02f,
  -1.81966662e-01f, 4.97382805e-02f, 1.48962131e-02f, -2.25462958e-01f, -1.01677887e-01f, 2.25676641e-01f, -1.29047409e-01f, -2.05521181e-01f, -1.27315685e-01f, -3.91715653e-02f,
  -1.95420891e-01f, 1.41112372e-01f, 4.17352095e-02f, -2.09762365e-01f, 5.78695357e-01f, 5.64158149e-02f, -7.77709931e-02f, -2.94673909e-02f, 5.33585668e-01f, -1.97298273e-01f,
  -2.66334951e-01f, -1.24850221e-01f, -2.10330531e-01f, 8.06049228e-01f, -1.92188606e-01f, -2.09154978e-01f, -7.29643181e-02f, -8.43028259e-03f, 3.33386540e-01f, 1.69673964e-01f,
  -3.26784909e-01f, -3.84310693e-01f, 1.69868901e-01f, -8.38022232e-02f, 1.57416224e-01f, 4.30103481e-01f, -1.42442301e-01f, 1.83833808e-01f, -6.97105704e-03f, -3.07473511e-01f,
  4.36921697e-03f, 8.90848711e-02f, 4.76569422e-02f, -5.25982976e-02f, -4.84748818e-02f, 2.14245915e-02f, -7.83304945e-02f, -2.76430368e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.85222173e-01f, 1.01775099e-02f, 1.82660982e-01f, 8.87594447e-02f, -3.16586420e-02f, 2.21854866e-01f, -3.20547298e-02f, -9.93229225e-02f, 1.31732404e-01f, -2.16112146e-03f,
  5.85228484e-03f, 9.93812755e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    