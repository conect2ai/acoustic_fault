/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.54660577e-01f, 1.02195144e-01f, -1.60993934e-01f, 6.75174221e-03f, -2.58215845e-01f, -2.45011717e-01f, -1.47413611e-01f, -9.72020999e-02f, 5.09369140e-03f, 4.43608202e-02f,
  -1.36893764e-01f, -2.77380031e-02f, 8.22892487e-02f, 2.31942553e-02f, -1.50149092e-01f, 2.02711180e-01f, -1.14972159e-01f, -5.07436171e-02f, 2.00439140e-01f, -6.24647997e-02f,
  1.20268345e-01f, -8.44708271e-03f, 1.90182030e-02f, 3.12661156e-02f, -1.34812415e-01f, -2.41319370e-02f, -1.78515509e-01f, -9.37477592e-03f, -2.21901417e-01f, -1.36579975e-01f,
  -9.74965841e-02f, -7.99124166e-02f, -3.70669812e-02f, -1.55221745e-02f, -2.04114333e-01f, -7.29630142e-02f, -3.92287299e-02f, 3.10714915e-02f, -1.70190562e-03f, -4.77072224e-02f,
  3.40737216e-02f, -7.69788697e-02f, 3.29389377e-03f, 1.63402632e-01f, 2.25260761e-02f, -9.61443260e-02f, 3.80688906e-02f, -4.36216071e-02f, 6.47874102e-02f, -1.30931169e-01f,
  -5.61016472e-03f, -6.92892075e-02f, 1.21569401e-02f, 6.55838381e-03f, -4.91691902e-02f, -6.05081916e-02f, -7.43058845e-02f, -3.55705284e-02f, -3.80589515e-02f, -6.48259148e-02f,
  -3.26687098e-02f, 1.14634998e-01f, 8.63674581e-02f, 5.41771725e-02f, 1.99451968e-02f, -7.25904256e-02f, -1.57780908e-02f, 1.99568272e-02f, 1.00398913e-01f, 4.59910519e-02f,
  -1.73825622e-02f, 1.34854149e-02f, -3.71717848e-02f, 1.85894947e-02f, -6.53583463e-03f, -6.06857166e-02f, -2.22431999e-02f, -4.36556600e-02f, -8.99091084e-03f, 2.05901321e-02f,
  -6.59072679e-03f, -4.84827682e-02f, -3.17155495e-02f, -3.46483439e-02f, -2.09655147e-02f, 2.57166382e-02f, -8.70022643e-03f, -3.79510522e-02f, -4.24284264e-02f, -3.03408746e-02f,
  -2.14281872e-01f, -1.32253692e-01f, 4.12471853e-02f, -9.24727991e-02f, -4.30818833e-02f, 1.34317894e-02f, 1.46561310e-01f, 3.00280079e-02f, -5.01350276e-02f, -6.81977198e-02f,
  7.29856826e-03f, 4.86555807e-02f, -2.83213779e-02f, 1.25207812e-01f, -1.15978085e-02f, -6.20228685e-02f, -2.61072684e-02f, -4.87661026e-02f, -7.67749175e-02f, -8.73681158e-02f,
  1.85942855e-02f, 3.82721014e-02f, 8.16965029e-02f, -7.93690905e-02f, -4.36053276e-02f, -4.44989204e-02f, -3.13813873e-02f, 1.24692015e-01f, -7.68953487e-02f, -1.20713182e-01f,
  -8.48560184e-02f, 1.67604282e-01f, 1.64455976e-02f, -4.83788848e-02f, 1.82573926e-02f, -2.68170714e-01f, -2.44803786e-01f, 3.39911617e-02f, -6.58689514e-02f, 3.33367251e-02f,
  -1.41082481e-01f, 3.93636897e-02f, -1.13719508e-01f, -3.30646306e-01f, -3.99352014e-01f, -1.98385835e-01f, -3.75796199e-01f, -1.30572483e-01f, -6.68688789e-02f, -9.01447460e-02f,
  -7.94175789e-02f, -1.56327769e-01f, -1.12063713e-01f, 8.02267790e-02f, -7.27257952e-02f, 7.59028196e-02f, 1.54122025e-01f, 5.76547720e-02f, 4.77899276e-02f, -9.06310081e-02f,
  -7.39102885e-02f, -2.78408406e-04f, 4.95796688e-02f, 5.02154939e-02f, -5.84002696e-02f, 3.70533578e-03f, -2.56126141e-03f, 2.09865738e-02f, -1.53632741e-02f, -9.86671150e-02f,
  1.19371317e-01f, 1.19592873e-02f, -8.07989296e-03f, 6.15939312e-02f, 3.87597047e-02f, -5.87689839e-02f, 2.04873830e-02f, -7.53854588e-02f, -4.85224798e-02f, -4.85362532e-03f,
  -4.78612520e-02f, 7.30266050e-02f, -6.13896400e-02f, 3.98753062e-02f, 5.37537709e-02f, -3.77944224e-02f, 4.89371456e-02f, 5.27728945e-02f, -9.51385275e-02f, 4.02475968e-02f,
  5.46527579e-02f, 1.45234801e-02f, -6.43879473e-02f, -9.77817550e-02f, -4.13123611e-03f, -9.51948762e-03f, -8.76867026e-02f, 1.97473243e-02f, 4.42756116e-02f, 3.43150534e-02f,
  2.96977405e-02f, 5.48286103e-02f, 2.17590500e-02f, 5.74079864e-02f, -2.86072604e-02f, 5.10961972e-02f, 3.51873157e-03f, -8.98091495e-02f, 3.28147337e-02f, -7.60848597e-02f,
  3.66130173e-02f, 7.28189480e-03f, -1.40265767e-02f, -5.56633901e-03f, -5.39981015e-02f, 3.10133994e-02f, 7.50030205e-02f, 4.86215577e-02f, -5.57708181e-03f, -1.37749650e-02f,
  -7.25281518e-03f, 1.07289806e-01f, 2.30916906e-02f, 1.62328631e-02f, 2.14042794e-02f, -2.79731322e-02f, 4.84808907e-02f, 8.96542668e-02f, -4.07386571e-02f, -2.43124366e-02f,
  1.55547615e-02f, -2.06112601e-02f, 1.04329243e-01f, 1.02228299e-02f, -9.86912772e-02f, 1.54272029e-02f, -6.69984799e-03f, 9.24942344e-02f, 9.15286168e-02f, 1.53801208e-02f,
  9.51614603e-02f, 1.07056974e-02f, -4.87126820e-02f, -5.01687862e-02f, 3.54797952e-03f, 2.65553780e-02f, 3.87886949e-02f, 1.94253195e-02f, 1.98514555e-02f, 1.16452910e-02f,
  -3.41604263e-01f, 6.86396509e-02f, 3.18882354e-02f, -1.55379683e-01f, -1.16188146e-01f, -1.43800855e-01f, -2.17295170e-01f, 6.56085536e-02f, -2.00006112e-01f, 4.65259664e-02f,
  1.59786679e-02f, 3.29273455e-02f, 9.31493118e-02f, -5.13639711e-02f, -3.17484707e-01f, 7.67453536e-02f, -1.76786453e-01f, -3.80060934e-02f, -1.56189743e-02f, -1.61172897e-01f,
  -1.21057875e-01f, -2.29799777e-01f, -8.10599774e-02f, 3.79510522e-02f, -5.12465462e-02f, 7.09699467e-02f, -4.72050123e-02f, 6.68710694e-02f, -3.12484745e-02f, -8.23654085e-02f,
  7.97806904e-02f, -2.26446521e-02f, 3.73528041e-02f, -1.92556866e-02f, 8.97596553e-02f, -4.54175510e-02f, -3.09176669e-02f, -5.40432008e-03f, -5.42915426e-04f, -2.92312223e-02f,
  -9.43730585e-04f, -3.37908641e-02f, -1.93189383e-02f, -2.34925412e-02f, -4.16330881e-02f, -5.79666831e-02f, 5.51664233e-02f, 5.77096120e-02f, 2.68138461e-02f, -2.00567627e-03f,
  1.50669307e-01f, 1.08185351e-01f, 1.47278793e-02f, 8.74925032e-02f, 1.71083584e-02f, -2.44211238e-02f, 1.20779974e-02f, 9.73290429e-02f, 1.48559168e-01f, 1.11927323e-01f,
  -3.38624269e-02f, -9.08452179e-03f, 1.21768452e-02f, -2.52950322e-02f, -3.30813341e-02f, -3.88757773e-02f, -5.39000221e-02f, -6.11640774e-02f, 1.65256001e-02f, -3.95574160e-02f,
  -2.12500561e-02f, 1.75671503e-02f, -1.15518151e-02f, 3.72294299e-02f, 2.92060245e-02f, 3.00790020e-03f, 1.50312614e-02f, 7.31685236e-02f, 4.76761386e-02f, 2.28666756e-02f,
  -1.76089808e-01f, -9.01277661e-02f, 5.73584661e-02f, 6.51930198e-02f, -1.44089395e-02f, -3.26055922e-02f, 7.93568417e-02f, 8.75804126e-02f, -3.78531478e-02f, -1.87042840e-02f,
  -1.31335864e-02f, 7.26103690e-03f, 2.87386980e-02f, -5.54843917e-02f, 1.22316934e-01f, 3.95448431e-02f, -9.27376151e-02f, -3.92652526e-02f, -2.04268564e-02f, -6.67054281e-02f,
  6.06706031e-02f, 3.93304154e-02f, 1.23308310e-02f, 5.02733104e-02f, 2.85761952e-02f, -5.43370657e-02f, 1.97065417e-02f, -6.30492568e-02f, -5.86599410e-02f, 9.95821729e-02f,
  2.26474460e-02f, -2.87010819e-02f, 5.60059659e-02f, 1.02259472e-01f, 3.26377451e-02f, 5.36698960e-02f, -1.45397382e-02f, 5.85137568e-02f, 2.13933960e-02f, -3.26517299e-02f,
  2.77460307e-01f, 1.58443078e-01f, 2.00770989e-01f, 2.20715433e-01f, -2.01135757e-03f, 3.07113901e-02f, -8.55804160e-02f, 7.38971978e-02f, 3.08763474e-01f, 3.28429192e-02f,
  -1.62171736e-01f, 1.58267781e-01f, -1.59580261e-01f, 9.92357209e-02f, -1.91796750e-01f, -1.66049853e-01f, 1.54922707e-02f, 7.32485354e-02f, 5.59756309e-02f, 6.74388558e-02f,
  -4.27276939e-02f, -2.95020610e-01f, -1.27465665e-01f, -3.22603108e-03f, 1.39723316e-01f, 9.47687924e-02f, -1.95926845e-01f, -5.65829538e-02f, -3.12383324e-02f, -1.40805736e-01f,
  1.95110310e-02f, 7.37743303e-02f, 8.15555528e-02f, 8.71842355e-03f, 7.37555176e-02f, -6.88774809e-02f, 7.14714527e-02f, -9.46034864e-02f, 4.20237072e-02f, -5.51030273e-04f,
  -7.81778432e-03f, -1.28422022e-01f, -7.74173811e-02f, -1.89768579e-02f, 4.20758426e-02f, 3.22979130e-02f, -1.70824733e-02f, 7.33716637e-02f, 5.29256947e-02f, -2.50791777e-02f,
  2.40081605e-02f, 9.50464606e-02f, 4.01029661e-02f, -5.45215048e-02f, -1.02423262e-02f, -3.47633436e-02f, 1.10132052e-02f, -1.13592148e-01f, 5.76631986e-02f, 5.91880679e-02f,
  -4.44674753e-02f, -6.79622516e-02f, -6.54972494e-02f, -6.38537705e-02f, -9.64853540e-03f, -2.37925965e-02f, -1.48757696e-02f, -9.35430005e-02f, 1.08953632e-01f, -6.58407211e-02f,
  4.26541567e-02f, 5.24976244e-03f, -4.24713915e-04f, 1.23663601e-02f, 3.00331246e-02f, 7.33364075e-02f, -3.77441719e-02f, 7.27860481e-02f, 3.87068428e-02f, 1.67519189e-02f,
  -4.60162312e-02f, -2.04614792e-02f, 5.92313483e-02f, 8.82355124e-03f, -6.22473611e-03f, -5.85997440e-02f, -9.90463654e-04f, 7.50858858e-02f, -5.94257265e-02f, -3.99674997e-02f,
  -2.71744616e-02f, -6.82184994e-02f, 5.24759013e-03f, -9.70719606e-02f, 2.56956555e-02f, -5.99912480e-02f, -9.01586413e-02f, 2.91264709e-02f, 1.99369714e-01f, -1.51662491e-02f,
  -5.85998967e-02f, -4.48173992e-02f, -4.89965966e-03f, 3.12817097e-02f, -1.12913782e-02f, -1.07178599e-01f, -7.43728727e-02f, 2.01565353e-03f, 9.55316145e-03f, 1.22988448e-02f,
  -1.17378915e-03f, 4.18095030e-02f, 1.92939769e-02f, 1.11594554e-02f, 6.17953166e-02f, -7.47660408e-03f, -4.76412755e-03f, 3.52161974e-02f, -8.91893171e-03f, 3.33559960e-02f,
  1.75350666e-01f, 5.17402887e-02f, -1.46679536e-01f, -1.83353379e-01f, 6.72693131e-03f, 9.19420854e-04f, 1.80759784e-02f, -1.97598320e-02f, 1.24208659e-01f, -1.31770730e-01f,
  2.35610344e-02f, 9.31157470e-02f, 2.00852349e-01f, -1.86035901e-01f, 3.46520126e-01f, 8.95479321e-02f, -9.43475589e-03f, 1.14746047e-02f, 3.01413368e-02f, 6.10219054e-02f,
  1.00702168e-02f, -1.12787135e-01f, -7.82520175e-02f, -6.48273230e-02f, -1.39288530e-01f, -2.12082699e-01f, -6.78592622e-02f, -1.13782197e-01f, -2.55202264e-01f, 4.89897616e-02f,
  -5.17510176e-02f, -1.50471916e-02f, -6.83533261e-03f, -1.62031222e-02f, -2.00798530e-02f, -3.09124440e-02f, -1.36429697e-01f, 7.79424310e-02f, 5.27252704e-02f, -7.48824235e-03f,
  1.26456752e-01f, 4.77311574e-02f, -4.51336429e-02f, -2.03053616e-02f, -1.08397165e-02f, 8.46865326e-02f, 8.75269324e-02f, -8.19292814e-02f, -4.43036743e-02f, 1.01473086e-01f,
  1.44171165e-02f, 4.70996499e-02f, -6.51458651e-03f, 8.14863592e-02f, -7.25868866e-02f, -1.69112650e-03f, 1.14305578e-01f, -1.42548829e-02f, -2.95840064e-03f, 1.51070133e-01f,
  4.02190015e-02f, -4.95850248e-03f, -7.89213553e-03f, -1.13665469e-01f, 5.52035719e-02f, -1.20425604e-01f, 3.97158191e-02f, 1.84836648e-02f, -8.91775414e-02f, -7.17916638e-02f,
  -4.40694951e-02f, 3.33589613e-02f, 4.15504770e-03f, -1.09122723e-01f, -1.60293013e-03f, 8.57385769e-02f, 7.05344826e-02f, -5.64506650e-02f, -9.09982547e-02f, -5.07452600e-02f,
  -5.10822004e-03f, 6.11495525e-02f, -5.11643179e-02f, -5.18027432e-02f, 3.24083604e-02f, -4.22996134e-02f, -7.16146007e-02f, -6.51704520e-02f, -1.18045948e-01f, 6.73578903e-02f,
  1.43711716e-01f, 9.09649953e-02f, -4.05376852e-02f, -1.18603826e-01f, -4.20007780e-02f, 6.48018867e-02f, 2.20205281e-02f, -1.52443899e-02f, 5.05971648e-02f, -2.02250690e-03f,
  -1.06639229e-02f, -2.88488902e-02f, -2.82528587e-02f, -1.18272498e-01f, -1.04310699e-01f, -5.17392345e-03f, 6.18695095e-02f, 3.63295004e-02f, -8.29931274e-02f, 6.09374493e-02f,
  6.67800941e-03f, 2.33318061e-02f, 2.92134043e-02f, -4.85815518e-02f, -6.07995130e-02f, 1.42588085e-02f, 2.64502373e-02f, -1.94617566e-02f, 1.14646345e-01f, 7.76142254e-02f,
  2.35811070e-01f, 3.89079452e-02f, 2.87309676e-01f, -1.77507736e-02f, 5.09759746e-02f, 9.17237252e-02f, 6.48025349e-02f, 2.29631402e-02f, 3.06140274e-01f, -2.33193114e-01f,
  -1.97794542e-01f, 2.26096988e-01f, 1.53319180e-01f, -2.73791581e-01f, 1.21799007e-01f, 1.03406943e-01f, -2.19002113e-01f, -5.31263240e-02f, 1.30219117e-01f, -1.35620967e-01f,
  7.84229115e-02f, -3.59574914e-01f, -1.41438106e-02f, -2.71225393e-01f, -1.53952288e-02f, 6.13974668e-02f, -3.55328023e-01f, 1.59949124e-01f, -2.70833343e-01f, -6.73589483e-02f,
  -2.40284558e-02f, 4.87489514e-02f, 4.61909957e-02f, 6.56867251e-02f, 3.91927967e-03f, -6.10891357e-02f, 1.83436908e-02f, -2.73013301e-02f, 1.30281448e-02f, 6.07574992e-02f,
  -1.78701486e-02f, -3.78233120e-02f, -3.96781527e-02f, -4.19000611e-02f, -7.16702489e-04f, 2.34258492e-02f, 3.63609754e-02f, -1.08472938e-02f, 5.47827184e-02f, 1.92897338e-02f,
  1.18841231e-01f, 9.16730519e-03f, -6.34177923e-02f, -8.99080595e-04f, 7.42061362e-02f, 6.55391589e-02f, -4.87389229e-02f, -1.38731636e-02f, 7.08219130e-03f, -2.94638034e-02f,
  -2.25527585e-02f, -4.98265736e-02f, -2.32322458e-02f, -3.00564542e-02f, 6.98848516e-02f, 1.62321739e-02f, 6.49199188e-02f, -3.45694013e-02f, -4.61640861e-03f, -6.90564737e-02f,
  9.19039920e-02f, -5.49072661e-02f, -6.38737183e-05f, -2.52203289e-02f, -9.04706270e-02f, 7.76459128e-02f, -1.13578178e-02f, -1.96710732e-02f, 8.02335739e-02f, 5.57407886e-02f,
  -5.29445196e-03f, 5.36969416e-02f, 2.44776737e-02f, -6.63589165e-02f, 1.93970483e-02f, 3.90684903e-02f, -3.56397443e-02f, 6.27328604e-02f, 5.61808757e-02f, -7.41549358e-02f,
  -1.41050994e-01f, -1.04756139e-01f, -5.60485311e-02f, 7.45259877e-03f, 1.46500971e-02f, -1.83718745e-02f, -3.31028365e-02f, -5.78257814e-02f, 1.15253560e-01f, 9.89593640e-02f,
  -5.48473857e-02f, -5.85084371e-02f, -5.68553656e-02f, -5.28457947e-03f, -1.71370935e-02f, 4.35157567e-02f, -7.71441087e-02f, -2.02290211e-02f, -7.13602826e-02f, 1.10197440e-03f,
  -1.10075526e-01f, 4.92089018e-02f, 4.50622737e-02f, 2.91006826e-02f, -8.26093182e-02f, 4.66304366e-03f, -2.35732794e-02f, 8.85089338e-02f, -1.24556631e-01f, -8.73821496e-04f,
  -1.47548184e-01f, 4.24500883e-01f, -4.16015685e-02f, 1.39633432e-01f, -1.58445805e-01f, 3.11799586e-01f, 1.83675110e-01f, -3.84151749e-02f, 1.34553090e-01f, 2.73002714e-01f,
  -8.06256011e-03f, 1.38627812e-01f, 3.23704607e-03f, 2.56663382e-01f, -2.51364350e-01f, 7.10658729e-02f, 9.23281014e-02f, 2.03186706e-01f, -3.61450091e-02f, -2.46964227e-02f,
  -7.07252845e-02f, 4.83732261e-02f, -1.76914036e-01f, -9.45229307e-02f, 3.15355025e-02f, -1.10874906e-01f, -1.75298557e-01f, -5.51975481e-02f, 7.12532625e-02f, 3.19821318e-03f,
  1.12313656e-02f, 4.54683788e-02f, 2.64820009e-02f, -6.80718804e-03f, -3.93348746e-02f, -6.97968993e-03f, -1.47836196e-04f, 6.44529331e-03f, -3.32396068e-02f, 4.74620610e-03f,
  5.53872101e-02f, 1.03496257e-02f, 6.29572645e-02f, -7.98226669e-02f, 6.33434877e-02f, -3.73233343e-03f, -7.40870684e-02f, 5.01058325e-02f, 5.23373596e-02f, 2.74296254e-02f,
  -5.24675883e-02f, 1.07669517e-01f, 1.35291507e-03f, 4.82158065e-02f, -8.09191540e-02f, 6.07861206e-02f, 9.60565209e-02f, -2.59742588e-02f, 5.58158047e-02f, -3.87739111e-03f,
  -4.93120495e-03f, 1.57723650e-02f, -8.39034691e-02f, -1.22983027e-02f, -7.93624111e-03f, 2.49660984e-02f, 1.85820963e-02f, 3.63668017e-02f, -2.42348686e-02f, 1.84002314e-02f,
  1.38252228e-02f, 1.00814581e-01f, -6.36647940e-02f, 1.48281297e-02f, -3.00846994e-02f, -9.64027457e-03f, -1.39355538e-02f, -7.90756370e-04f, 6.71336204e-02f, -1.06651142e-01f,
  -7.54469037e-02f, -3.47200246e-03f, -5.04522696e-02f, 3.59631982e-03f, 7.00837895e-02f, -1.98243707e-02f, -1.99020915e-02f, 4.95562963e-02f, -1.19954534e-01f, -4.86088544e-02f,
  1.97486281e-01f, 9.14843529e-02f, -2.21071336e-02f, -5.71470596e-02f, -6.70697242e-02f, 7.44373305e-03f, -9.01259109e-02f, 5.73485605e-02f, 8.54441598e-02f, 7.01786159e-03f,
  -2.93737985e-02f, -8.85571446e-03f, 4.66356659e-03f, 3.59096676e-02f, -3.25563643e-03f, -7.75707595e-05f, 7.72975618e-03f, -2.55003478e-02f, -7.71457925e-02f, 7.08434614e-04f,
  -1.92359798e-02f, -5.00519425e-02f, 3.25642750e-02f, 2.03089751e-02f, 8.68055448e-02f, 6.43237978e-02f, 6.96717156e-03f, 1.25365406e-01f, -7.06255659e-02f, 1.89480791e-03f,
  -9.90310386e-02f, 4.42638583e-02f, 2.72175610e-01f, -5.63836619e-02f, 1.85157105e-01f, -1.17837049e-01f, -7.76424110e-02f, 8.74287561e-02f, -3.36845890e-02f, -2.35327572e-01f,
  -2.00382456e-01f, -1.04294620e-01f, -2.65524805e-01f, -1.37012199e-01f, -1.50109783e-01f, -2.33452633e-01f, -1.37465671e-02f, -1.10899359e-01f, 1.26542673e-01f, 5.70750125e-02f,
  1.56950593e-01f, -6.68974593e-02f, 5.40685989e-02f, 8.83344784e-02f, 1.27879351e-01f, 4.44618911e-02f, -4.48549464e-02f, 1.34291157e-01f, 1.54080186e-02f, 6.83100969e-02f,
  -2.67030336e-02f, -1.32735431e-01f, 1.33255124e-01f, 5.63765429e-02f, -2.98440140e-02f, 7.76134208e-02f, 2.85445638e-02f, 1.82570014e-02f, -6.79581761e-02f, -4.05090898e-02f,
  -2.14226339e-02f, 2.16099084e-03f, -6.06280342e-02f, 1.13717569e-02f, 6.64517730e-02f, 3.96473259e-02f, 8.72309953e-02f, 1.79935396e-01f, 7.92350993e-02f, 1.16519913e-01f,
  1.09805293e-01f, 8.89161825e-02f, 2.58126613e-02f, -4.42441367e-02f, 2.90950704e-02f, 1.37727529e-01f, -6.31073341e-02f, 5.07743806e-02f, 1.24421328e-01f, 1.33189529e-01f,
  -4.87651676e-03f, 2.79813819e-03f, -2.77999379e-02f, -8.67874026e-02f, -9.29381624e-02f, -7.22877122e-03f, 2.88618617e-02f, 2.19530379e-03f, 2.82938834e-02f, 3.61598246e-02f,
  -8.09179991e-02f, 2.94460170e-03f, 2.97045056e-02f, 5.66053763e-03f, 3.50167751e-02f, -1.64988533e-01f, -1.38800040e-01f, 4.72708642e-02f, 4.66441512e-02f, 1.17346473e-01f,
  -3.16668749e-02f, 1.81734543e-02f, -1.17939621e-01f, -2.97958180e-02f, -3.74853984e-02f, -4.00068946e-02f, 1.28341438e-02f, 3.53658088e-02f, 9.09427926e-02f, 1.32610546e-02f,
  -1.14893116e-01f, -2.39933550e-01f, -2.96044983e-02f, -2.11944822e-02f, -1.17403612e-01f, 1.98720675e-03f, 5.16957529e-02f, 1.47796735e-01f, -4.92656827e-02f, -4.98980433e-02f,
  1.38400540e-01f, -4.47470322e-02f, -4.84431386e-02f, -4.85908985e-02f, 2.69647576e-02f, -2.51442585e-02f, -8.19695741e-02f, 1.18917814e-02f, 3.47508974e-02f, 1.17429636e-01f,
  2.02495102e-02f, 3.39650586e-02f, -4.85403873e-02f, -1.64683908e-02f, 4.41746004e-02f, 1.42396828e-02f, 4.56239022e-02f, 1.97756272e-02f, 5.79346083e-02f, 5.40571753e-03f,
  4.16456461e-01f, -2.19370931e-01f, -4.90864255e-02f, 1.55203536e-01f, 1.04004040e-01f, -6.91482723e-02f, -2.07648724e-02f, 1.11676849e-01f, 2.60213930e-02f, -2.23798782e-01f,
  1.10195301e-01f, 5.23820110e-02f, -1.77505568e-01f, 1.45723484e-02f, 2.55027443e-01f, -2.01836139e-01f, 9.60104316e-02f, -1.16089906e-03f, -5.60450517e-02f, -3.67595442e-02f,
  1.35439977e-01f, 8.64290148e-02f, 8.62973917e-04f, 3.16815078e-02f, -4.00347114e-02f, 6.85198903e-02f, 1.10424452e-01f, -8.45334083e-02f, 8.21036026e-02f, 6.87795058e-02f,
  -2.91062333e-02f, -5.80911487e-02f, -2.04055179e-02f, -7.27058426e-02f, -6.49748519e-02f, -4.57429178e-02f, -9.77391154e-02f, -8.84797201e-02f, 8.79698321e-02f, -1.04793698e-01f,
  -1.39965666e-02f, 7.32438415e-02f, 3.46797220e-02f, 5.23892976e-02f, 3.82160954e-02f, 2.01613866e-02f, 7.74195942e-04f, -1.14772119e-01f, -7.38897249e-02f, -6.16024844e-02f,
  -6.67313710e-02f, -2.08028667e-02f, -3.39409560e-02f, 6.28590863e-03f, -2.53296774e-02f, 6.48454279e-02f, -6.26391207e-04f, 2.76334304e-02f, -2.84359995e-02f, -9.90923215e-03f,
  6.16929606e-02f, -2.76868138e-02f, 5.90757700e-03f, 1.00450944e-02f, -2.15682648e-02f, -5.24289645e-02f, -9.72800329e-03f, -4.56110341e-03f, 1.32560972e-02f, -7.22819120e-02f,
  -3.28864977e-02f, -1.67414341e-02f, -2.02251561e-02f, 8.15236792e-02f, 5.99681996e-02f, 4.30033251e-04f, -4.07580137e-02f, 5.22071943e-02f, -3.05708181e-02f, -3.68358046e-02f,
  -2.52805976e-03f, 9.76927113e-04f, -1.51304342e-02f, -2.17062030e-02f, 2.90084686e-02f, 3.05263456e-02f, -3.63442861e-02f, 5.21663716e-03f, 1.93964280e-02f, -6.83652610e-03f,
  4.12048725e-03f, -1.42097920e-01f, -2.00660545e-02f, 3.07226162e-02f, -2.63648760e-02f, -3.42102945e-02f, 1.37408990e-02f, 3.37207429e-02f, -5.54377399e-02f, -5.33092767e-02f,
  3.85310017e-02f, 9.19281915e-02f, -9.28815752e-02f, 3.39064136e-04f, -2.82975230e-02f, -5.20395674e-02f, -7.57012963e-02f, 7.42580891e-02f, 1.43699022e-03f, -1.74341314e-02f,
  -4.40412248e-03f, -7.84960203e-03f, 8.84791557e-03f, -3.81876901e-02f, -1.99804716e-02f, -5.21942675e-02f, 4.43889126e-02f, 8.08732063e-02f, -4.83572148e-02f, -1.01670817e-01f,
  3.02930087e-01f, -2.28546798e-01f, 1.57877818e-01f, 2.27880359e-01f, 1.41505778e-01f, 1.54607177e-01f, 1.63733974e-01f, -6.61160648e-02f, 4.04214039e-02f, -1.08763166e-02f,
  -2.78564710e-02f, 7.33037218e-02f, -3.72873768e-02f, 1.12650163e-01f, 1.49162933e-01f, -9.32849720e-02f, 5.78277521e-02f, 1.03683829e-01f, -2.37299293e-01f, 2.40342766e-02f,
  3.44596244e-02f, -8.50997269e-02f, 8.15550238e-02f, -1.45204216e-01f, 2.00012058e-01f, 2.00543925e-03f, 1.12897530e-01f, -2.56035535e-04f, 1.29077300e-01f, 2.60861963e-02f,
  2.60807667e-02f, 1.45069942e-01f, 1.83523335e-02f, 4.40727733e-02f, 3.75365429e-02f, 3.53288092e-02f, 3.13211419e-02f, 8.52261335e-02f, 1.40757477e-02f, -6.49918243e-03f,
  -4.42822985e-02f, 9.42483842e-02f, -4.06983960e-03f, -3.48472781e-02f, 7.38088712e-02f, 1.01896226e-02f, 7.18206819e-03f, 1.73411183e-02f, 6.51376173e-02f, 4.43966314e-02f,
  -1.00424848e-01f, 3.37129645e-02f, 1.35512337e-01f, 7.71037489e-02f, 1.92583069e-01f, 1.45296633e-01f, 2.05106977e-02f, 4.69124950e-02f, 9.06655472e-03f, 5.80715109e-03f,
  3.45993005e-02f, 1.29663246e-02f, -8.63418356e-02f, -5.58134541e-02f, 3.41519266e-02f, -1.28167570e-01f, -4.80534509e-02f, 1.76309105e-02f, 2.75538769e-02f, 2.29194295e-02f,
  3.23901288e-02f, 4.82567772e-02f, -3.52981151e-03f, 4.59599160e-02f, 5.28152753e-03f, 3.99839506e-03f, -9.37854219e-03f, -4.83776629e-02f, -1.73657592e-02f, -1.40188923e-02f,
  -8.23931172e-02f, 1.86574832e-02f, 2.76078824e-02f, -3.53487767e-02f, -7.63250962e-02f, -5.13416994e-03f, -3.69364731e-02f, 1.08194826e-02f, -5.63084334e-02f, 5.03372811e-02f,
  -1.04751438e-02f, 1.99461251e-01f, -4.33301032e-02f, 7.44528025e-02f, -4.03922573e-02f, 4.52293791e-02f, 1.97231490e-02f, -4.50983346e-02f, 2.78959330e-02f, -3.18001769e-02f,
  -1.03656389e-02f, 3.73549573e-02f, 4.72470671e-02f, 2.91946195e-02f, -5.79999983e-02f, -8.62017274e-02f, -5.66331074e-02f, -8.21757391e-02f, 1.28687963e-01f, -8.20251629e-02f,
  4.70971726e-02f, 2.75736358e-02f, -1.29144806e-02f, 1.03562521e-02f, 5.48230596e-02f, 1.02539092e-01f, 4.66410480e-02f, 5.40726595e-02f, 6.97121695e-02f, 4.25215662e-02f,
  2.79514343e-01f, 7.94298723e-02f, 4.81457071e-04f, 1.67308003e-01f, 9.68085229e-02f, -1.14425123e-02f, -9.06689540e-02f, 1.68960765e-01f, 2.34187230e-01f, 4.41867411e-02f,
  -9.48497429e-02f, -2.32934998e-03f, -2.89985895e-01f, -4.83522601e-02f, -1.97462648e-01f, -3.15838605e-01f, 5.27946651e-02f, -4.31054942e-02f, -3.83283012e-03f, 1.78113937e-01f,
  4.35687378e-02f, 2.72030085e-02f, -1.23306997e-01f, 1.13735713e-01f, 1.92462727e-01f, 1.87931240e-01f, -2.74851117e-02f, -6.45338222e-02f, -2.91366689e-02f, -3.24029438e-02f,
  -2.80663632e-02f, 3.90692391e-02f, 5.06230257e-02f, 5.05745895e-02f, 6.27379790e-02f, 8.40883255e-02f, 1.41340680e-02f, -1.66655958e-01f, -1.50662102e-02f, 7.71468356e-02f,
  -9.90484841e-04f, 1.91325452e-02f, -3.52561139e-02f, 3.57513838e-02f, 9.80654210e-02f, 3.39985825e-02f, 2.78839748e-02f, 3.97960320e-02f, 2.47338600e-02f, -5.60168289e-02f,
  -2.29074750e-02f, -3.38884220e-02f, 5.98054416e-02f, -1.74919516e-02f, 9.52777192e-02f, 6.15923218e-02f, -6.42606467e-02f, -5.74996248e-02f, -5.27574029e-03f, -3.43889669e-02f,
  1.68956444e-02f, 5.04777655e-02f, -6.91871857e-03f, 4.44306899e-03f, -9.75324064e-02f, -1.03869021e-01f, -6.01812080e-03f, -1.04123773e-02f, -4.29719761e-02f, -1.87036360e-03f,
  1.32372277e-02f, 5.34499437e-02f, 7.17895031e-02f, -1.05069354e-01f, 3.12732980e-02f, 1.62497647e-02f, 1.77044272e-02f, 3.84029076e-02f, 3.30050439e-02f, 4.04106043e-02f,
  -5.03145307e-02f, -3.76462098e-03f, -7.59387156e-03f, -5.39436564e-02f, 1.40477084e-02f, -3.73236500e-02f, 2.44260374e-02f, 2.03753337e-02f, -9.04203951e-02f, -3.52952220e-02f,
  2.42340285e-02f, 8.78965706e-02f, 1.29551971e-02f, -4.51646978e-03f, 3.66086103e-02f, 6.65853033e-03f, 2.59023402e-02f, 9.17403251e-02f, -2.09937487e-02f, -1.60164833e-02f,
  -1.59731023e-02f, -2.74443459e-02f, 5.44517227e-02f, 5.80149740e-02f, -2.94899959e-02f, 9.91802383e-03f, -7.06831291e-02f, 3.45263965e-02f, -1.49445317e-03f, -5.24788769e-03f,
  -7.22871199e-02f, 7.71215977e-03f, -6.16488010e-02f, -1.69088766e-02f, -5.11520403e-03f, -5.00978492e-02f, 5.66572277e-03f, -4.10170853e-02f, -4.87149358e-02f, 1.85042676e-02f,
  3.57240349e-01f, -4.71765772e-02f, -1.60191096e-02f, 2.02232957e-01f, -9.47910640e-03f, -2.02229261e-01f, -2.07917914e-01f, -2.98611224e-02f, 1.11600928e-01f, -1.29241869e-01f,
  2.79032788e-03f, -2.54886020e-02f, -3.28897476e-01f, 2.24458039e-01f, -2.73842961e-01f, -1.15845844e-01f, 5.13441570e-04f, 3.34324054e-02f, -6.18018061e-02f, 1.31166339e-01f,
  8.61140788e-02f, 2.79293470e-02f, -7.36145228e-02f, 5.99326566e-04f, 8.44448805e-02f, 1.53626695e-01f, 3.64674404e-02f, -1.79427683e-01f, 6.14889748e-02f, -5.08570895e-02f,
  5.76828718e-02f, 2.44377315e-01f, 1.11040287e-01f, -3.66729163e-02f, 2.70042103e-02f, 1.73821896e-02f, 4.06784844e-03f, -8.87045935e-02f, -1.75906047e-02f, -2.01871712e-02f,
  -5.78947999e-02f, -4.47768206e-03f, 1.96282379e-02f, -4.61699069e-02f, 3.83056176e-04f, 2.59383209e-02f, -4.32096422e-02f, 4.77786809e-02f, 1.99667439e-02f, -1.04114085e-01f,
  -8.83761570e-02f, 7.98746869e-02f, 6.23851120e-02f, 8.36520456e-03f, -4.46813144e-02f, -1.15192011e-02f, 3.54109891e-02f, -1.07210524e-01f, -2.22153459e-02f, 6.89499779e-03f,
  5.36211170e-02f, 5.27222035e-03f, -4.88948002e-02f, 6.33894876e-02f, 3.42038311e-02f, 2.11446024e-02f, -5.30238897e-02f, -2.17486382e-03f, -7.73561895e-02f, 7.09550455e-02f,
  1.21223025e-01f, 8.27078149e-03f, 2.32790206e-02f, -6.53273389e-02f, -1.48497103e-03f, 7.00881779e-02f, -7.38521852e-03f, 6.98527768e-02f, 4.13898602e-02f, 7.77323321e-02f,
  1.68381762e-02f, -5.97929694e-02f, 2.78585348e-02f, -5.35660945e-02f, 3.40486355e-02f, -1.32434694e-02f, 1.41000906e-02f, -2.95400918e-02f, -3.54006626e-02f, -8.92419592e-02f,
  -1.18586570e-01f, -1.50164636e-02f, 5.53810485e-02f, -2.67598708e-03f, 5.97708821e-02f, -4.00274321e-02f, 3.67809989e-04f, 5.41213974e-02f, -9.20858756e-02f, -3.28201577e-02f,
  -5.01944385e-02f, -9.94940847e-02f, -3.32912169e-02f, 4.68174033e-02f, -7.07267448e-02f, -8.68833587e-02f, 4.14973982e-02f, -2.69500744e-02f, 2.34024394e-02f, -1.18120275e-01f,
  1.03926351e-02f, -8.47627819e-02f, 1.62528362e-04f, 4.71440740e-02f, 1.64305456e-02f, 4.39689755e-02f, 1.08347967e-01f, 1.40449880e-02f, -7.33298510e-02f, -2.34575123e-02f,
  -2.83302516e-01f, 1.81518838e-01f, -1.82559669e-01f, 1.10040717e-01f, -2.08713561e-02f, 2.73346364e-01f, 2.22813919e-01f, -7.97642171e-02f, 1.61936402e-01f, 2.48280942e-01f,
  1.43826589e-01f, -1.34908762e-02f, 7.08220527e-02f, 1.50082320e-01f, 4.29340787e-02f, 2.73875207e-01f, 1.43558085e-01f, 6.69914633e-02f, -6.13006353e-02f, -1.11826316e-01f,
  -1.28664941e-01f, 1.03321381e-01f, -1.03714643e-02f, -1.01425692e-01f, -6.65215701e-02f, -1.74680606e-01f, 8.27231929e-02f, -7.39398673e-02f, 4.07690257e-02f, -7.12966770e-02f,
  -1.11596681e-01f, -1.98286295e-01f, 4.48714057e-03f, -2.09239386e-02f, -2.41656089e-03f, -9.59055573e-02f, -7.75480457e-03f, -3.36673334e-02f, -9.86638889e-02f, -6.71343282e-02f,
  -1.44899320e-02f, -1.43924087e-01f, -2.80703511e-02f, 7.12691322e-02f, 5.74966185e-02f, 2.04916708e-02f, 1.24762151e-02f, 6.20707050e-02f, -1.97095498e-02f, -3.62459105e-03f,
  3.85256745e-02f, 5.01242606e-03f, 5.50888330e-02f, -1.67576708e-02f, -2.00168435e-02f, -3.87290083e-02f, -1.30080767e-02f, -2.00020019e-02f, -1.21597797e-02f, 3.84191307e-03f,
  -2.52314936e-02f, 1.49795860e-02f, 2.65367106e-02f, -1.56847760e-02f, 8.86181649e-03f, -5.22887670e-02f, 3.31599973e-02f, -4.33080383e-02f, 3.20088156e-02f, 2.69865748e-02f,
  4.18069512e-02f, -8.78606923e-03f, -4.97009903e-02f, 7.76062384e-02f, 1.32861007e-02f, -7.81080648e-02f, -5.25114983e-02f, 1.31971501e-02f, 1.74032394e-02f, -2.07824167e-03f,
  1.28930388e-02f, 3.21436883e-03f, 6.53956011e-02f, 5.64419255e-02f, 1.39975818e-02f, -2.76688915e-02f, 3.27516459e-02f, 1.39821926e-02f, -1.43410526e-02f, -6.83538765e-02f,
  1.04938038e-01f, -6.04101596e-03f, -6.74074963e-02f, -7.69461095e-02f, 1.42270103e-02f, 2.76033916e-02f, 4.88703251e-02f, -6.56306371e-02f, 1.94507372e-02f, 2.38931421e-02f,
  -1.10856406e-01f, -6.45711785e-03f, -3.88397537e-02f, -2.36076093e-03f, 3.46632153e-02f, 8.06704909e-02f, -2.59759389e-02f, 8.74037594e-02f, 3.15516330e-02f, -3.91119299e-03f,
  1.45813394e-02f, 1.53681505e-02f, -1.10915609e-01f, -5.19674644e-02f, -1.71384886e-02f, 1.64644755e-02f, -2.59930640e-02f, -1.65394843e-02f, 2.17838790e-02f, 4.56949063e-02f,
  -2.83780217e-01f, -2.61572212e-01f, -2.16452824e-03f, -1.39674574e-01f, -7.49940202e-02f, 1.11651421e-01f, -4.40245116e-04f, -8.91545787e-02f, -2.28084311e-01f, -1.56326637e-01f,
  1.43985553e-02f, -7.51221031e-02f, -1.67220905e-02f, -2.06701070e-01f, -1.00261711e-01f, 9.28202644e-03f, -1.92943394e-01f, 1.97656397e-02f, -6.98784366e-02f, -1.48920819e-01f,
  -2.62370761e-02f, -1.09345347e-01f, -7.39157125e-02f, -3.80305834e-02f, -9.21469852e-02f, 1.42245129e-01f, -6.17424920e-02f, 1.45489633e-01f, 5.60596921e-02f, 6.67658225e-02f,
  -1.28347829e-01f, -7.57021233e-02f, 5.81633300e-02f, -5.00379987e-02f, -6.60695368e-03f, 7.42648691e-02f, 1.15492791e-01f, 9.69265699e-02f, 5.35731995e-03f, -6.21380517e-04f,
  5.21374382e-02f, -1.94978993e-02f, 2.13701222e-02f, 1.65557340e-02f, -6.88865483e-02f, -1.07085451e-01f, -1.13223977e-01f, 5.11780567e-02f, -1.78943276e-02f, -5.29408790e-02f,
  2.80638225e-02f, 2.12400500e-02f, 2.79347077e-02f, 2.38150312e-03f, 7.26671517e-02f, -9.95734241e-03f, 5.45527861e-02f, 1.33478299e-01f, 6.54714927e-02f, 8.25802144e-03f,
  9.04708058e-02f, -6.39111549e-02f, -6.69833347e-02f, 2.31223777e-02f, -5.42868953e-03f, -1.29771054e-01f, -1.71680674e-02f, 6.14311732e-03f, -2.88211890e-02f, -5.14056794e-02f,
  -4.03160043e-02f, -7.90352896e-02f, 1.32681057e-03f, 1.64182130e-02f, 6.04758672e-02f, 3.39392163e-02f, 2.11777985e-02f, -7.75048658e-02f, -2.56163138e-03f, 1.28266737e-01f,
  3.37971970e-02f, 3.28563899e-02f, 2.27266885e-02f, -4.28633466e-02f, -1.51296081e-02f, -1.14429777e-03f, 1.56318315e-03f, -4.64529358e-03f, 2.60580629e-02f, 6.88441843e-02f,
  -2.12619379e-01f, -2.32383594e-01f, -7.70476758e-02f, -3.51950303e-02f, -6.81125522e-02f, -3.31065170e-02f, -5.55351041e-02f, 3.02009881e-02f, -7.25713223e-02f, -5.94322570e-02f,
  2.98514478e-02f, -3.96374576e-02f, 9.23020951e-03f, -2.31472440e-02f, 1.15964552e-02f, -8.42214823e-02f, -2.86289696e-02f, -3.78327519e-02f, 9.97525454e-02f, -5.33311255e-02f,
  5.02140075e-03f, -6.69933297e-03f, 6.25222996e-02f, -2.83987466e-02f, 3.02910656e-02f, 1.22122258e-01f, 2.10960265e-02f, 6.51107132e-02f, 8.55652019e-02f, -2.21953588e-03f,
  2.42777675e-01f, 3.80240232e-02f, -1.09785367e-02f, 1.29948452e-01f, 1.50769040e-01f, 1.25534579e-01f, 1.47664756e-01f, 9.63830724e-02f, 1.85887609e-02f, -1.96336374e-01f,
  -5.79032935e-02f, -7.44838640e-02f, -1.95370942e-01f, 2.54950430e-02f, 7.72571489e-02f, -1.70312822e-01f, 2.02022567e-01f, 1.35223642e-01f, -3.10591348e-02f, 8.96234289e-02f,
  6.49169600e-03f, 6.69182092e-02f, -1.97891727e-01f, 4.52358089e-03f, 1.56954348e-01f, 8.00246447e-02f, -2.02423576e-02f, -8.36008191e-02f, -1.02213249e-02f, 5.82458340e-02f,
  -4.92871180e-02f, 1.96843483e-02f, 6.24378547e-02f, -2.41245609e-02f, 1.77071571e-01f, 5.80265969e-02f, 2.71418467e-02f, 4.69424352e-02f, -5.97981997e-02f, 8.41549318e-03f,
  4.36468683e-02f, -3.42314132e-02f, 3.36618610e-02f, 3.52569632e-02f, 4.52561006e-02f, -9.17779431e-02f, -2.94107739e-02f, 3.43188494e-02f, -3.83380353e-02f, -1.59702934e-02f,
  -5.25242835e-02f, 2.83067878e-02f, 8.34635049e-02f, 8.83287191e-02f, 1.05551295e-01f, 3.06231789e-02f, -1.10758603e-01f, 1.57807600e-02f, 4.29857783e-02f, -8.74026958e-03f,
  6.99725449e-02f, -1.33894205e-01f, -2.70786844e-02f, -1.02578215e-01f, -1.04933068e-01f, -1.94888550e-03f, -7.17688873e-02f, -8.14705864e-02f, -2.73202788e-02f, -6.66107461e-02f,
  3.20949405e-02f, -3.99847738e-02f, 5.30472808e-02f, 8.68024863e-03f, 3.48508917e-02f, 4.03701030e-02f, -2.35329606e-02f, -7.03045875e-02f, 1.07640058e-01f, 5.30352592e-02f,
  -4.65408452e-02f, -2.89997850e-02f, 4.24584374e-02f, 2.81503145e-02f, -1.45818489e-02f, 1.10930735e-02f, 4.91348058e-02f, 8.66579823e-03f, -9.10637621e-03f, 3.64583060e-02f,
  -6.47766665e-02f, -8.76043458e-03f, -8.15759078e-02f, 1.17116578e-01f, 4.72451523e-02f, -2.58033257e-02f, 3.01298406e-02f, 1.17231756e-01f, 3.27070095e-02f, -4.81607132e-02f,
  1.25443591e-02f, -6.17054179e-02f, 8.97500589e-02f, 1.28597459e-02f, -4.45158221e-03f, 1.35782082e-02f, -5.64968362e-02f, 8.88425261e-02f, -8.70720483e-03f, -1.81040373e-02f,
  5.55703742e-03f, 1.25655208e-06f, 2.93371622e-02f, -3.11880466e-02f, 8.16156939e-02f, -7.30712414e-02f, 4.06292416e-02f, -4.17098217e-02f, 1.03005402e-01f, -1.45495953e-02f,
  -1.53122142e-01f, 3.22586447e-01f, -7.22573027e-02f, -1.10869311e-01f, -1.90667480e-01f, -7.13319555e-02f, -1.46693826e-01f, -2.06356514e-02f, -2.61804730e-01f, 3.47784996e-01f,
  9.68715623e-02f, 1.36025757e-01f, -8.32436383e-02f, 1.93025142e-01f, -2.99775988e-01f, -1.90595180e-01f, -5.15948609e-02f, -4.78695408e-02f, -1.46413058e-01f, 3.00992746e-02f,
  -2.80817654e-02f, 5.08464873e-02f, 1.18224591e-01f, 1.61346316e-01f, 9.25110951e-02f, 1.27068430e-01f, 1.97837487e-01f, -7.82237276e-02f, 4.00596529e-01f, -1.24192744e-01f,
  7.14235753e-02f, -8.69601518e-02f, 9.76288542e-02f, 4.70720008e-02f, 2.84497887e-02f, -1.27093382e-02f, -2.84152608e-02f, -7.37858415e-02f, -1.94898117e-02f, 4.06219177e-02f,
  1.15310103e-01f, -3.59285437e-02f, 2.89222598e-02f, -9.60552767e-02f, 3.05927848e-03f, 5.45537397e-02f, 1.45828594e-02f, -3.22793461e-02f, 1.04164956e-02f, 8.32670461e-03f,
  7.98530579e-02f, 2.16726735e-02f, 4.21485491e-02f, 5.62298447e-02f, 1.25483489e-02f, -5.17822281e-02f, -2.48921737e-02f, 3.17168236e-02f, 1.36466578e-01f, 1.68804079e-02f,
  -2.75759473e-02f, -8.75387490e-02f, -5.09437248e-02f, 6.80705952e-03f, 8.07819813e-02f, 1.28701240e-01f, 7.11531565e-02f, 3.07480153e-03f, 9.96724740e-02f, 2.44114120e-02f,
  5.95388226e-02f, 2.94385627e-02f, -1.75265223e-02f, 5.73095940e-02f, -3.38836014e-02f, 8.11207816e-02f, 5.59392385e-03f, 1.44733218e-02f, -7.50225112e-02f, 4.02438454e-02f,
  -3.75684164e-02f, -2.57150386e-03f, -3.05416761e-03f, -6.16968162e-02f, -1.13206673e-02f, 2.92430129e-02f, -3.36991921e-02f, -1.49749413e-01f, -1.56140793e-02f, 4.00529709e-03f,
  -4.06466424e-02f, -2.84775626e-02f, 4.09274399e-02f, 1.08625539e-01f, 5.95588051e-02f, 9.75820348e-02f, -4.76454645e-02f, -5.72591312e-02f, -8.67758971e-03f, 1.39114046e-02f,
  1.31579451e-02f, 1.23868912e-01f, -1.33132897e-02f, -6.16032332e-02f, 4.33116555e-02f, -3.10305487e-02f, 2.22267415e-02f, 9.99808460e-02f, 5.73016927e-02f, 6.61977008e-02f,
  1.07802115e-02f, -5.23388619e-03f, 9.84231383e-02f, 9.84978825e-02f, 1.34418026e-01f, 3.20682526e-02f, -1.29124208e-03f, 9.06481128e-03f, 2.34327670e-02f, 3.70927602e-02f,
  4.92636651e-01f, 5.46456911e-02f, 1.06330670e-01f, 3.01182717e-01f, 8.11009854e-02f, 4.44804393e-02f, 1.17769703e-01f, 5.27845286e-02f, 1.69043019e-01f, -5.03751151e-02f,
  -6.92282096e-02f, 1.56548843e-01f, -1.20151393e-01f, 1.01701124e-02f, 7.78286904e-02f, -1.52798429e-01f, 2.41374671e-02f, -1.85799934e-02f, 7.10409740e-03f, 5.81378452e-02f,
  3.54005098e-02f, -1.87053517e-01f, 8.48684693e-04f, -1.44004151e-01f, 1.63697183e-01f, 5.83615527e-02f, -5.53517602e-02f, -4.07008566e-02f, 7.06200525e-02f, 4.96051572e-02f,
  2.87252162e-02f, 9.97991115e-02f, -3.07332575e-02f, -1.32859647e-02f, -3.69730890e-02f, 4.27296385e-02f, -1.73396710e-02f, -3.20969522e-02f, 1.56870503e-02f, 6.28591627e-02f,
  5.64375818e-02f, -7.80410543e-02f, 2.75526792e-02f, -6.10701665e-02f, 8.02593678e-03f, 5.76803535e-02f, 9.09781605e-02f, 2.67140544e-03f, 2.39618383e-02f, 6.99770004e-02f,
  1.08959064e-01f, -1.76323578e-02f, -4.40004207e-02f, 9.49528739e-02f, 2.16189865e-02f, -3.64505760e-02f, 3.88946384e-02f, 6.53007925e-02f, 1.12022348e-01f, 7.76037499e-02f,
  2.85611842e-02f, -4.73618172e-02f, -4.04146239e-02f, 1.48401819e-02f, 9.41744149e-02f, -3.08399834e-02f, -2.97513232e-02f, -6.72972389e-03f, 7.44838193e-02f, -6.48771003e-02f,
  9.98630002e-02f, -2.42733047e-03f, 8.78490787e-03f, 4.52721007e-02f, -3.52147184e-02f, 9.52147990e-02f, 1.79865642e-03f, 7.28887171e-02f, 3.44120972e-02f, 4.76744175e-02f,
  2.97741070e-02f, 1.29040293e-02f, -1.54180275e-02f, 2.64246222e-02f, 1.29076382e-02f, -5.49730547e-02f, -4.42967303e-02f, 4.95148897e-02f, 5.78753166e-02f, -9.18269996e-03f,
  8.30664635e-02f, 1.07603692e-01f, -5.85589968e-02f, 8.45195204e-02f, -7.88126439e-02f, 4.73388210e-02f, 5.05942665e-03f, -3.13285440e-02f, 4.77279238e-02f, 8.18922669e-02f,
  3.39453407e-02f, -3.61242630e-02f, 1.82994623e-02f, 6.61789579e-03f, -4.87347171e-02f, -3.97736542e-02f, 7.79342726e-02f, 3.63804214e-02f, 5.06989844e-02f, -2.57979501e-02f,
  3.42971012e-02f, -5.49815558e-02f, 7.40409363e-03f, -5.86395040e-02f, -1.89004131e-02f, 6.79079965e-02f, 5.77223599e-02f, 8.85985643e-02f, 5.00291251e-02f, 6.69143302e-03f,
  1.93836495e-01f, -2.23991379e-01f, 1.62460119e-01f, 3.79724912e-02f, 1.86606824e-01f, 1.74578160e-01f, 1.21831976e-01f, 9.81916022e-03f, -9.10312533e-02f, -1.68595836e-01f,
  1.87067673e-01f, -5.64678498e-02f, -5.27547486e-03f, -5.42965308e-02f, 2.33058646e-01f, -1.70221448e-01f, 2.12821811e-02f, 1.64265573e-01f, -1.03582412e-01f, 1.78920478e-01f,
  7.05546364e-02f, 1.11363240e-01f, 1.19305566e-01f, 2.24477705e-02f, 1.29425108e-01f, 1.99767482e-02f, 6.73541129e-02f, 1.04772195e-01f, 9.82668698e-02f, 9.60340202e-02f,
  -2.23198738e-02f, -6.49908260e-02f, 6.47080615e-02f, 7.45426044e-02f, 9.62916687e-02f, 2.04250573e-05f, 1.41269956e-02f, -5.46535999e-02f, 2.40526851e-02f, 4.93678227e-02f,
  5.45076020e-02f, 7.06470907e-02f, 2.01176689e-03f, -2.73283701e-02f, 1.79847970e-03f, -2.83965487e-02f, 3.55983130e-03f, -2.88669709e-02f, -1.34188272e-02f, 1.82352625e-02f,
  -8.13429058e-02f, -2.74570077e-03f, 1.04538180e-01f, 3.31667997e-02f, 7.54286870e-02f, -2.86683720e-02f, -3.44265178e-02f, 6.55046701e-02f, -1.93207469e-02f, 2.29894277e-03f,
  -1.88269243e-02f, 3.88410613e-02f, 3.75583991e-02f, -4.06872816e-02f, -6.81449950e-04f, 2.20116172e-02f, 9.00568382e-04f, -3.42667997e-02f, -3.96080129e-02f, -1.78079586e-02f,
  2.06113514e-02f, -2.48355400e-02f, 1.88471861e-02f, 3.27132381e-02f, -3.36224288e-02f, 9.04372241e-03f, 8.62490907e-02f, 3.55961919e-02f, -5.12644229e-03f, 4.07712208e-03f,
  -8.34148899e-02f, 1.90276727e-02f, 7.85254389e-02f, 4.10107523e-02f, 5.38665392e-02f, 2.89125871e-02f, 2.47599166e-02f, 3.93262282e-02f, 6.07466809e-02f, -2.15609241e-02f,
  9.49725416e-03f, 7.25587979e-02f, -8.33803937e-02f, -5.70712127e-02f, -6.65300637e-02f, 9.15513560e-02f, -1.14624035e-02f, 3.79305379e-03f, 1.75947957e-02f, 1.42365918e-01f,
  9.29411054e-02f, 1.89913828e-02f, 3.47540230e-02f, -6.05329126e-03f, 1.75517630e-02f, -5.77301066e-03f, 1.01264581e-01f, 4.55758534e-03f, 8.48595053e-02f, 6.83573307e-03f,
  -7.24405376e-03f, 3.86269242e-02f, -3.25962044e-02f, 7.86299407e-02f, -1.94315538e-02f, 2.46017482e-02f, 8.21694266e-03f, -7.42665231e-02f, 4.12718318e-02f, 6.10835999e-02f,
  2.41262615e-02f, -6.05063438e-02f, -3.02932709e-01f, -1.19021371e-01f, -8.74001831e-02f, 2.29466394e-01f, 2.99905449e-01f, -6.22972474e-02f, -1.45993292e-01f, 1.07698612e-01f,
  2.11804599e-01f, -2.51749665e-01f, -5.75852953e-02f, 2.56649941e-01f, 1.71125710e-01f, 1.52385667e-01f, 2.23730579e-01f, 1.32274523e-01f, -1.18476562e-01f, -1.21885657e-01f,
  -2.96235960e-02f, 2.66981781e-01f, -1.44736310e-02f, -4.91663627e-02f, -7.60204121e-02f, -1.79810673e-01f, -2.98549216e-02f, -1.28651261e-01f, 9.60732922e-02f, 1.68166995e-01f,
  1.11900494e-01f, -4.04564179e-02f, -2.17692554e-02f, -1.11821862e-02f, -1.09556735e-01f, 3.76462960e-03f, -4.37682383e-02f, 2.33026817e-02f, -8.27742592e-02f, 1.12054748e-02f,
  -3.89900617e-02f, 4.90185134e-02f, -4.16050702e-02f, -1.49394227e-02f, -1.85893569e-02f, -1.19118504e-02f, 6.43416587e-03f, 1.48621444e-02f, -1.90620553e-02f, -3.62913613e-03f,
  -1.77926645e-01f, -8.54755100e-03f, -8.65732953e-02f, 6.03522137e-02f, -8.70724469e-02f, -2.48893872e-02f, 1.39328744e-02f, 2.08992884e-02f, 2.32397504e-02f, -2.02937592e-02f,
  9.41680372e-02f, 7.89758749e-03f, 1.99284405e-02f, 6.39500841e-02f, -1.11699225e-02f, 4.48669940e-02f, 6.29942715e-02f, 5.62269166e-02f, -4.58025634e-02f, 9.98148844e-02f,
  -3.24672684e-02f, 1.42269820e-01f, -3.25422548e-03f, -6.06268533e-02f, -4.67307791e-02f, 4.51078042e-02f, -5.54968007e-02f, 9.42182764e-02f, 2.43445244e-02f, 3.54092312e-03f,
  -5.58575690e-02f, 4.48053405e-02f, -5.76599203e-02f, -1.65832043e-02f, 1.07284471e-01f, -4.72304635e-02f, 8.89303908e-02f, -7.04636499e-02f, -6.21526986e-02f, -1.25041336e-01f,
  -1.59994327e-02f, -2.07909703e-01f, -7.80470669e-02f, 1.79407950e-02f, -3.29959132e-02f, 1.19735233e-01f, 5.14429733e-02f, -4.55475338e-02f, -1.25256315e-01f, 6.21605441e-02f,
  4.12366539e-02f, -1.18867129e-01f, 6.40152767e-02f, 8.22195783e-02f, -8.66548121e-02f, 3.40724103e-02f, 2.79091224e-02f, -1.80685483e-02f, -2.04351265e-02f, -4.46335264e-02f,
  -6.23244308e-02f, -6.50569201e-02f, 5.14094420e-02f, -1.89985801e-02f, 6.64436594e-02f, 7.72425719e-03f, -9.68421996e-03f, 3.26574198e-03f, -2.95635127e-02f, -2.80184541e-02f,
  1.36374727e-01f, 2.76481181e-01f, -1.59638286e-01f, 8.23081881e-02f, 4.34266264e-03f, 2.70488679e-01f, 3.73634920e-02f, 1.37825638e-01f, 9.14760455e-02f, 2.76053011e-01f,
  1.62257016e-01f, 6.01203181e-03f, -3.96233313e-02f, 2.06812024e-01f, -3.47927719e-01f, -5.57616316e-02f, 3.73577811e-02f, 2.35891435e-02f, -6.41020760e-02f, 8.66087675e-02f,
  -5.43647148e-02f, 9.96338874e-02f, -2.14459047e-01f, 1.65732652e-01f, 1.59975827e-01f, -1.10354247e-02f, -7.50276744e-02f, -3.97386402e-02f, 8.80233198e-02f, 2.40590256e-02f,
  5.91921583e-02f, -1.35948146e-02f, -9.32352990e-03f, 1.40621671e-02f, 2.42868625e-02f, -3.34925056e-02f, 2.35008565e-03f, -9.35613438e-02f, -1.74704432e-01f, -9.21166968e-03f,
  4.09481376e-02f, 4.18639556e-02f, 3.04437131e-02f, 1.43003352e-02f, -2.32224464e-02f, -3.44423726e-02f, 2.00710930e-02f, 9.02850404e-02f, 6.34776056e-02f, 3.88228558e-02f,
  2.97446176e-02f, 2.02665548e-03f, 6.09245792e-04f, -7.84743354e-02f, -4.73257862e-02f, 7.09642172e-02f, -8.02535191e-02f, -9.34708640e-02f, -3.21390405e-02f, -6.51732385e-02f,
  1.23790465e-02f, 3.57479416e-03f, 1.07211322e-01f, 1.08343437e-01f, 2.14851275e-02f, 3.68130133e-02f, -7.93161988e-02f, -2.28907727e-02f, -5.92751708e-03f, 7.91317597e-02f,
  8.26255307e-02f, 5.57597689e-02f, -1.87267940e-02f, 2.20508184e-02f, -6.03398075e-03f, 1.40668303e-02f, 2.02013236e-02f, -4.43292782e-02f, -1.11697540e-02f, -2.38491129e-02f,
  2.24912167e-02f, -1.82255898e-02f, 1.73000824e-02f, -4.47125435e-02f, -1.34944553e-02f, 1.23397284e-03f, -2.13935599e-02f, -2.51499191e-02f, -1.04270183e-01f, -1.62861962e-02f,
  -7.88448378e-03f, -9.42192897e-02f, -7.74521455e-02f, 7.35776052e-02f, -2.44733728e-02f, 7.76217580e-02f, -6.88618701e-03f, 9.11637843e-02f, -1.41735181e-01f, 3.91960070e-02f,
  -3.60925775e-03f, -4.25640307e-02f, 3.68002839e-02f, -4.86369170e-02f, -1.11719564e-01f, -3.49889472e-02f, -4.34451178e-02f, -6.29869923e-02f, 3.27437259e-02f, -4.12991010e-02f,
  4.46747337e-03f, 7.99693391e-02f, -1.37353197e-01f, -4.36354056e-02f, 7.22959265e-02f, -6.74983189e-02f, -3.76603566e-02f, 3.92790139e-02f, -8.27023014e-02f, -4.89619449e-02f,
  1.84568092e-01f, -1.27793550e-01f, 1.29044533e-01f, -1.73053574e-02f, 4.56345864e-02f, 3.23347062e-01f, 4.07010198e-01f, -9.15995240e-02f, 3.04616150e-02f, -1.25031307e-01f,
  -2.54676882e-02f, -9.37173329e-03f, 1.15490638e-01f, -4.80902232e-02f, 2.10800827e-01f, 8.16384181e-02f, 6.71519637e-02f, 2.25545540e-02f, -3.78611460e-02f, 5.29993267e-04f,
  -5.70964105e-02f, -1.07408471e-01f, -1.05500603e-02f, -1.52562186e-01f, 6.14866316e-02f, -2.23209962e-01f, -2.76510388e-01f, 6.18379889e-03f, -2.17399344e-01f, -3.67162228e-02f,
  1.16335712e-01f, -2.54539051e-03f, 8.18879679e-02f, 2.80374251e-02f, -7.32549652e-02f, -3.25084701e-02f, 2.41606180e-02f, 9.39081758e-02f, -8.24868772e-03f, 3.91072370e-02f,
  -8.71777534e-03f, -4.40901965e-02f, -2.57683527e-02f, 5.98603971e-02f, -2.69947350e-02f, -1.85689852e-02f, 2.26135906e-02f, -2.22067870e-02f, -4.14835587e-02f, -2.51223426e-03f,
  4.50400934e-02f, -2.04361174e-02f, 1.01168022e-01f, -5.32130748e-02f, -4.73976657e-02f, 9.84886885e-02f, 3.10529917e-02f, 1.89839397e-02f, 3.92884389e-03f, -7.04022795e-02f,
  7.80391647e-03f, -3.23266722e-02f, -3.09847295e-02f, -8.67458154e-03f, 2.67659742e-02f, 2.83233840e-02f, 7.61302933e-02f, -1.05958045e-01f, -2.94147562e-02f, -3.97742279e-02f,
  7.00140893e-02f, 3.88684426e-03f, 2.86980420e-02f, 6.27756212e-03f, -2.93891039e-02f, 4.09014449e-02f, 6.03587329e-02f, -1.42840724e-02f, 3.44575718e-02f, 1.47412531e-04f,
  -1.45969843e-03f, -2.72981320e-02f, -6.75309449e-02f, 6.58647269e-02f, 4.40374948e-02f, 1.02409143e-02f, -1.29481375e-01f, 1.55843073e-03f, -9.94907413e-03f, 3.25990580e-02f,
  6.42262548e-02f, -2.61464030e-01f, 4.25237510e-03f, -1.16977105e-02f, -2.56249458e-02f, -4.61950265e-02f, 4.42880839e-02f, -7.80177042e-02f, 4.97400872e-02f, -3.83786410e-02f,
  -1.23662855e-02f, 9.39938333e-03f, -3.30773718e-03f, 3.66948312e-03f, 7.20041543e-02f, -2.74337623e-02f, -5.19932769e-02f, -3.77542190e-02f, 1.94064546e-02f, -1.17535613e-01f,
  -9.22409594e-02f, -6.40326440e-02f, 6.75830012e-03f, 2.73122434e-02f, -4.25422899e-02f, 3.84418629e-02f, -7.35817775e-02f, 4.30322289e-02f, -4.82318625e-02f, 6.43625855e-02f,
  -2.95652986e-01f, -2.01960281e-01f, -1.22695103e-01f, -2.32220769e-01f, 2.03238409e-02f, 2.48778448e-01f, 1.63005397e-01f, -1.71985954e-01f, -4.06534076e-01f, 4.28389572e-02f,
  9.27787274e-02f, -1.68354183e-01f, -1.01679780e-01f, 1.34150475e-01f, -1.15914546e-01f, -6.02940544e-02f, -2.13984144e-03f, 5.43206893e-02f, -1.44755185e-01f, -3.98825295e-02f,
  -1.53138518e-01f, 1.05462864e-01f, -3.39512154e-02f, 1.19376503e-01f, 5.86905070e-02f, 4.90203016e-02f, -1.34556383e-01f, -3.50309466e-03f, 1.94009289e-01f, 5.43299392e-02f,
  1.11056685e-01f, -1.80195458e-02f, 1.24316774e-01f, 2.35743187e-02f, -5.87016158e-02f, 9.94393304e-02f, 8.18940029e-02f, 8.69616270e-02f, -9.55936499e-03f, -1.91047899e-02f,
  -3.26825604e-02f, -4.88419086e-02f, -1.98814198e-02f, -6.79630339e-02f, 7.85992742e-02f, -2.90900227e-02f, -6.20946102e-02f, 8.50150660e-02f, -1.47508970e-02f, -2.79051587e-02f,
  -1.34086870e-02f, -7.33597651e-02f, 1.67847294e-02f, -1.08685326e-02f, 3.06152310e-02f, -4.26289402e-02f, 4.78461059e-03f, -1.63006142e-03f, -2.30363309e-02f, -1.02722086e-01f,
  1.54803144e-02f, -1.19768478e-01f, -9.49884132e-02f, -1.52424937e-02f, -3.64825577e-02f, 3.01932245e-02f, -1.81007627e-02f, 1.60413254e-02f, -8.10657442e-02f, 6.42613992e-02f,
  2.55410536e-03f, 2.06161197e-02f, -3.94419692e-02f, 4.93702516e-02f, -1.77228481e-01f, -2.67866952e-03f, -2.73470264e-02f, 3.91095467e-02f, -1.39456866e-02f, -6.31790683e-02f,
  4.62477840e-02f, 2.17838194e-02f, -3.44690084e-02f, 4.34670448e-02f, 6.78811595e-03f, -1.73472852e-01f, -1.70806441e-02f, -2.77214237e-02f, -1.25005487e-02f, -1.83723550e-02f,
  -1.36879710e-02f, -2.99438417e-01f, 2.81233899e-02f, 4.20639961e-04f, -3.02677471e-02f, -9.42732021e-02f, -3.97106074e-02f, -4.50342186e-02f, -1.00280993e-01f, -7.00147972e-02f,
  3.91634554e-02f, -3.28442194e-02f, -4.10915650e-02f, 2.40167025e-02f, 2.32741702e-02f, 1.92798842e-02f, -3.35158594e-02f, -2.40766834e-02f, -7.27670938e-02f, 3.40343490e-02f,
  5.14267795e-02f, 2.68885661e-02f, 5.26086502e-02f, 2.22131424e-02f, -3.88067798e-03f, 7.39670247e-02f, 1.84823424e-02f, 3.45885009e-02f, 9.58170649e-03f, -1.14441536e-01f,
  -4.89356905e-01f, 8.35110769e-02f, -8.17500651e-02f, -2.24003449e-01f, -3.21954750e-02f, 1.39584109e-01f, 2.55414955e-02f, -4.25385237e-02f, -1.51574463e-01f, 1.64362013e-01f,
  6.16935305e-02f, -2.49953225e-01f, 2.23806128e-01f, -2.72601783e-01f, -2.51067311e-01f, 1.45880625e-01f, -1.34799346e-01f, 1.33849038e-02f, -8.77188817e-02f, -3.41118239e-02f,
  -1.11124553e-01f, -1.67674124e-02f, -7.13276491e-02f, 7.45282397e-02f, -1.45461127e-01f, 5.87143786e-02f, 1.49510249e-01f, 1.74957365e-01f, -7.60590881e-02f, -1.43924445e-01f,
  -1.08260885e-02f, 3.64379538e-03f, -5.07916883e-02f, -7.05220774e-02f, 1.40261995e-02f, 1.77957118e-02f, 6.19582878e-03f, -3.65508720e-02f, -6.68047881e-03f, -2.11850908e-02f,
  -7.23417029e-02f, -6.31997958e-02f, -2.80219670e-02f, -3.20377387e-02f, -1.46208242e-01f, 1.28874416e-02f, 2.77981441e-02f, -5.20744361e-02f, -5.31849219e-03f, 2.53026150e-02f,
  4.15171124e-02f, -5.52669838e-02f, -2.84637008e-02f, 3.56142037e-02f, 6.54015839e-02f, -6.03568414e-03f, -1.74346138e-02f, 3.23104486e-02f, -3.88142513e-03f, -3.42539027e-02f,
  -1.36831468e-02f, 1.90933626e-02f, 6.61256313e-02f, -2.80978028e-02f, -4.29264456e-02f, 7.35714883e-02f, 1.85562647e-04f, -5.10441177e-02f, -7.65487738e-03f, 7.24932104e-02f,
  2.26274207e-02f, 1.75390597e-02f, -7.48983771e-02f, 3.10902763e-02f, -3.48378420e-02f, -2.80944631e-02f, -6.38379976e-02f, 5.77549674e-02f, 2.07559858e-02f, 3.17529705e-03f,
  -9.78029519e-03f, -7.99750090e-02f, 6.59466684e-02f, 1.40553918e-02f, 4.01636958e-03f, 6.92672953e-02f, -4.21932861e-02f, 8.45613889e-03f, 6.60998970e-02f, -3.67643014e-02f,
  4.18415368e-02f, 7.95934200e-02f, 2.28316672e-02f, -2.96507571e-02f, 8.25423747e-02f, -3.62791233e-02f, -6.09493963e-02f, -6.78448081e-02f, 6.37146458e-02f, 2.97573544e-02f,
  4.18509729e-02f, -1.11892633e-02f, -3.17995101e-02f, -2.04056595e-03f, -6.79643676e-02f, 1.51389271e-01f, 6.20893687e-02f, 6.31908774e-02f, -5.68930507e-02f, 8.02177489e-02f,
  1.18787698e-02f, 1.27713397e-01f, -4.42297608e-02f, 1.02900267e-01f, 4.38439772e-02f, 2.87166107e-02f, -2.54394803e-02f, 1.15453796e-02f, -5.42986989e-02f, 6.41515339e-03f,
  -1.25774533e-01f, 4.53150928e-01f, -1.09522998e-01f, 1.82031229e-01f, -5.11161834e-02f, 1.19620301e-01f, -4.65344191e-02f, 1.36270478e-01f, 3.91020514e-02f, 2.82911628e-01f,
  8.15053806e-02f, 6.41672909e-02f, 4.03217152e-02f, 2.57550865e-01f, -2.52315402e-01f, 1.97799876e-01f, 3.11397880e-01f, 2.08301619e-01f, -3.52051333e-02f, 1.80295616e-01f,
  8.69130567e-02f, 1.15602404e-01f, 8.18564221e-02f, 7.02072158e-02f, 1.12683281e-01f, -6.25694543e-03f, -1.00334793e-01f, -5.46049625e-02f, 1.33483812e-01f, -1.05207436e-01f,
  1.91672407e-02f, -4.44579870e-02f, -8.57891589e-02f, -3.97052392e-02f, 6.67524263e-02f, 2.14673728e-02f, 2.99459174e-02f, -1.32778138e-01f, -2.50422135e-02f, -9.41387489e-02f,
  -5.74592734e-03f, -8.84057879e-02f, -1.31261889e-02f, -1.07936613e-01f, 1.59075130e-02f, -1.45601472e-02f, -2.25802930e-03f, 7.80387521e-02f, 2.35000793e-02f, -5.26738875e-02f,
  -1.61782876e-02f, 1.12577245e-01f, 7.55625591e-02f, 7.81933367e-02f, -6.65694177e-02f, 6.52416870e-02f, 9.43002924e-02f, -4.78174612e-02f, 1.41603127e-01f, 6.37288392e-02f,
  -1.48178369e-03f, 3.05922469e-03f, -4.57248315e-02f, -1.62987579e-02f, 8.41416270e-02f, 1.06852893e-02f, 1.75981168e-02f, -2.06059013e-02f, 1.95379853e-02f, -1.47984074e-02f,
  -4.20348234e-02f, 7.91785493e-02f, 1.98813919e-02f, 5.94601128e-03f, 7.10070282e-02f, 4.22349237e-02f, -6.87715635e-02f, -5.24722273e-03f, 2.81772353e-02f, -3.17750722e-02f,
  2.89786630e-03f, 3.55733670e-02f, 1.01287495e-02f, 1.54494336e-02f, -2.07386184e-02f, -3.42641138e-02f, 9.94857550e-02f, 2.61053219e-02f, -1.16546370e-01f, 4.72865514e-02f,
  2.25808382e-01f, 3.28752130e-01f, -8.63343328e-02f, -1.44941151e-01f, 5.61637841e-02f, -1.02861179e-02f, -6.71375915e-02f, 3.19514237e-02f, 9.53175575e-02f, -1.14621567e-02f,
  6.39716014e-02f, -6.31665513e-02f, -6.22271141e-03f, -6.02860674e-02f, 4.62407805e-02f, 1.09401502e-01f, 4.96748015e-02f, 2.67895386e-02f, -1.29070447e-03f, 1.35657743e-01f,
  -1.09902229e-02f, 7.79970214e-02f, 3.79085317e-02f, 2.42346805e-02f, 9.07339975e-02f, 2.78474744e-02f, -1.60522629e-02f, 4.50745560e-02f, -3.82664986e-02f, 4.50950768e-03f,
  3.75922859e-01f, -4.70133811e-01f, -1.41975328e-01f, 9.59560350e-02f, 2.16695368e-01f, 1.87283400e-02f, 7.01397434e-02f, -5.00770845e-02f, 8.53069592e-03f, -1.75819412e-01f,
  2.11592004e-01f, -1.08224012e-01f, -3.42021622e-02f, 3.68755236e-02f, 3.72423887e-01f, -1.83683522e-02f, -5.58110625e-02f, -7.51613528e-02f, 1.72621980e-02f, -6.14535548e-02f,
  1.56738535e-01f, 1.44978985e-01f, -3.50550450e-02f, 2.20755883e-03f, -4.80692238e-02f, -8.79257768e-02f, 6.81720972e-02f, -7.16849193e-02f, 4.03355770e-02f, 4.90658060e-02f,
  -2.02358849e-02f, -8.28922689e-02f, -2.96517275e-03f, -7.63022602e-02f, -4.89411727e-02f, -4.71662097e-02f, -6.77082688e-02f, 7.48972073e-02f, 7.02339262e-02f, 2.01242808e-02f,
  -6.51343912e-02f, -4.38033976e-02f, 3.29862498e-02f, 5.74195534e-02f, -1.48388902e-02f, -1.01525793e-02f, 8.40423256e-03f, 4.46723551e-02f, -3.20620425e-02f, -5.45258559e-02f,
  -5.54950312e-02f, 7.87474867e-03f, 4.72320579e-02f, 6.62915185e-02f, 8.68001580e-02f, 3.56436372e-02f, -6.53078407e-02f, 1.48713589e-02f, -4.21276465e-02f, 1.71159077e-02f,
  5.60306869e-02f, -3.67114022e-02f, 1.80621482e-02f, -1.97059155e-04f, -1.75632127e-02f, 6.07918315e-02f, 3.98545340e-02f, 1.96611695e-02f, -2.38007624e-02f, 5.18274382e-02f,
  2.88519487e-02f, -1.54459504e-02f, 1.27600878e-02f, 5.75703904e-02f, 3.37992087e-02f, -1.32638784e-02f, -4.32646535e-02f, -2.57066265e-02f, 2.37925313e-02f, 7.24868178e-02f,
  3.88675034e-02f, 1.11805573e-02f, -9.45886318e-03f, 1.47924735e-03f, 3.75111774e-02f, 3.29244919e-02f, 5.42770512e-02f, -3.37763056e-02f, -5.60872108e-02f, -3.52328457e-02f,
  -2.25167722e-02f, -1.24662213e-01f, -8.30178428e-03f, 9.20392349e-02f, -7.98740834e-02f, -1.23776514e-02f, -4.58571762e-02f, -6.55121878e-02f, -8.52723941e-02f, 4.44814898e-02f,
  -2.11669151e-02f, -2.98501402e-02f, 3.54095660e-02f, 1.42827705e-02f, 8.62227082e-02f, 1.66428275e-02f, -3.89332063e-02f, -2.49723028e-02f, -1.91301554e-02f, -2.17103362e-02f,
  -3.24125728e-03f, -2.17515882e-02f, 1.23782102e-02f, -5.36881909e-02f, -1.72948502e-02f, -4.42966586e-03f, 2.06479598e-02f, -9.10743605e-03f, 5.39452629e-03f, -3.92369404e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.64539838e-01f, -2.44806081e-01f, -4.75525945e-01f, -2.82416195e-01f, 1.74804971e-01f, 5.51171489e-02f, -9.47860405e-02f, 4.40845974e-02f, -2.16504052e-01f, 2.10446641e-01f,
  1.63763851e-01f, -2.89949834e-01f, -1.55184895e-01f, -2.43075173e-02f, -2.07142219e-01f, -2.98772871e-01f, -8.63496121e-03f, 1.89228039e-02f, -2.31662109e-01f, 1.10111766e-01f,
  -1.05189197e-01f, 2.06997290e-01f, -2.48350337e-01f, 1.73078164e-01f, 1.28299490e-01f, 6.06399402e-03f, 3.52235645e-01f, -5.51398471e-02f, 1.94586664e-01f, 4.96179089e-02f,
  1.08462572e-01f, -2.55118851e-02f, 3.20889102e-03f, -5.08903712e-02f, 9.98830497e-02f, 1.44173056e-01f, 6.93648122e-03f, -1.23842910e-01f, -5.09576574e-02f, -1.58699870e-01f,
  -3.68532389e-02f, -3.63360457e-02f, 2.76091769e-02f, -2.20526103e-02f, -6.03447296e-03f, -1.01758754e-02f, -1.15985289e-01f, -8.31214711e-02f, -1.68279737e-01f, -1.07476614e-01f,
  -1.53602451e-01f, -5.93134128e-02f, -1.19880680e-02f, -2.33363956e-02f, -3.72985713e-02f, -5.43642379e-02f, 2.90415194e-02f, -2.03699060e-03f, 2.65060682e-02f, -5.64100295e-02f,
  7.95665607e-02f, 8.31015110e-02f, 2.88124029e-02f, -8.46945215e-03f, -1.01303644e-01f, 2.55191512e-02f, -5.72572835e-02f, -9.29782465e-02f, -1.20895326e-01f, 4.73959111e-02f,
  -2.29151193e-02f, 5.03226072e-02f, 1.04306079e-02f, 1.11471005e-01f, -6.38582325e-03f, 5.05806617e-02f, -2.51810737e-02f, -1.34684111e-03f, -8.70735198e-02f, 2.09348220e-02f,
  5.20643480e-02f, -8.16595182e-02f, 4.78805825e-02f, 2.40489058e-02f, 1.62498802e-02f, -3.91676603e-03f, -2.15870421e-02f, 6.28503785e-02f, -6.68260604e-02f, 8.84249434e-02f,
  2.12966517e-01f, 1.53079525e-01f, -8.86411667e-02f, 8.09064731e-02f, -1.72983797e-03f, 7.25117400e-02f, -7.56190717e-02f, 6.32712841e-02f, 1.66798159e-02f, 3.57925706e-02f,
  1.70537144e-01f, 1.21060861e-02f, 1.84713587e-01f, 6.04274720e-02f, -1.44873895e-02f, 1.18384123e-01f, -3.48037109e-03f, -1.03346162e-01f, 4.25275825e-02f, 7.68350288e-02f,
  3.88422981e-02f, -2.36429479e-02f, -9.26481485e-02f, 1.60298347e-02f, 5.39764538e-02f, 3.65556143e-02f, 6.97898492e-02f, 3.31557244e-02f, 3.20340246e-02f, -6.58095106e-02f,
  -2.53856897e-01f, 2.19020188e-01f, 3.61037180e-02f, -2.09189191e-01f, 4.11863141e-02f, -1.59561157e-01f, -2.54947424e-01f, 2.13617906e-01f, 1.11574486e-01f, 9.35305431e-02f,
  -7.77756004e-03f, 1.69490099e-01f, 6.45169541e-02f, -1.11581244e-01f, -2.80507296e-01f, -2.39531592e-01f, -2.09394068e-01f, -1.78032015e-02f, 4.96583842e-02f, -1.29678562e-01f,
  -1.57659769e-01f, -2.02865660e-01f, -8.99549276e-02f, 4.22888622e-02f, 7.33425319e-02f, 4.16610539e-02f, -6.37632608e-02f, 1.34312496e-01f, 1.79988537e-02f, 1.30970374e-01f,
  4.64773178e-02f, 9.26733464e-02f, 6.47028089e-02f, 1.33022681e-01f, -4.74483855e-02f, 3.16459425e-02f, -4.83358838e-02f, 8.70864168e-02f, -1.22151701e-02f, 4.59641628e-02f,
  5.15989922e-02f, 3.50425728e-02f, -6.03794903e-02f, -8.13783891e-03f, 1.29808456e-01f, 3.99202965e-02f, 1.38689220e-01f, -3.81871574e-02f, 5.49433939e-02f, 8.32130574e-03f,
  4.25879732e-02f, -6.76225033e-03f, 5.12119569e-03f, -1.14366315e-01f, 4.74417806e-02f, 5.48447855e-02f, -6.80855811e-02f, -1.37725258e-02f, -2.19668690e-02f, -1.38820596e-02f,
  -2.84651611e-02f, -1.67260021e-01f, 2.92926980e-03f, 8.19524974e-02f, -5.00908606e-02f, 8.41535628e-02f, -4.81497683e-02f, -5.82033172e-02f, -2.12582052e-02f, -1.36676701e-02f,
  -4.24792990e-02f, 4.32720371e-02f, 1.21604919e-01f, -4.62276563e-02f, -1.06023379e-01f, 8.06056410e-02f, -4.89594452e-02f, 5.43438643e-02f, -1.44571960e-01f, -1.92409605e-02f,
  -3.96301001e-02f, 6.95786104e-02f, -4.94928379e-03f, -4.26810645e-02f, 7.05935508e-02f, 1.74551811e-02f, 1.00436183e-02f, 1.18667908e-01f, 4.56684530e-02f, -9.40477327e-02f,
  3.53341177e-03f, -4.11472358e-02f, -4.24564555e-02f, 8.86371508e-02f, 5.47822006e-02f, 7.52618983e-02f, -3.67126577e-02f, 1.98607221e-02f, 2.29893364e-02f, 5.87414950e-02f,
  1.68803521e-02f, -2.11771447e-02f, -2.53938269e-02f, -7.23061189e-02f, 1.71915442e-02f, -7.12554380e-02f, -1.25753246e-02f, -4.54360209e-02f, 1.48484418e-02f, 7.67044574e-02f,
  1.90559160e-02f, -5.98901547e-02f, -6.37165532e-02f, -4.10647914e-02f, -1.22243501e-02f, 7.18727708e-02f, -7.11522922e-02f, 1.14307627e-01f, -5.75481951e-02f, -2.64481660e-02f,
  -5.29469132e-01f, 4.59021665e-02f, 1.25399172e-01f, -1.97901055e-01f, -7.95187578e-02f, -6.65062815e-02f, -8.23516548e-02f, -2.25121845e-02f, 1.39401341e-03f, 1.18099891e-01f,
  -1.31116778e-01f, -1.14036821e-01f, 1.33910090e-01f, 7.73221776e-02f, -3.40729281e-02f, 1.14273056e-01f, -1.95530392e-02f, -5.38576394e-02f, 7.80117232e-04f, -7.32906535e-02f,
  -1.06275693e-01f, -3.94818150e-02f, 9.03897658e-02f, 6.31091148e-02f, -3.84485498e-02f, -8.26908052e-02f, -1.02073506e-01f, 3.58833298e-02f, -3.05543412e-02f, -1.10418648e-01f,
  -3.26454461e-01f, -7.78250396e-02f, -7.86233023e-02f, 1.20992186e-02f, -1.59808882e-02f, 3.06013320e-02f, -1.94881391e-02f, -2.51952354e-02f, -8.79274979e-02f, 7.60347247e-02f,
  -5.96035877e-03f, 5.20701930e-02f, -4.45380546e-02f, 6.80528060e-02f, -1.51436469e-02f, -5.97795285e-02f, -6.23658784e-02f, -2.50370894e-02f, -1.55245848e-02f, 2.70982622e-03f,
  1.13699980e-01f, -7.82064945e-02f, -9.63717401e-02f, 4.47084866e-02f, -6.76333159e-02f, -8.83341953e-02f, -1.82854012e-02f, -8.84795934e-02f, 3.51236612e-02f, -3.94861251e-02f,
  5.85533157e-02f, -5.49414977e-02f, 2.90958099e-02f, -1.78227015e-02f, 2.25142017e-02f, -3.82949784e-02f, 3.98407206e-02f, 5.82655258e-02f, -3.53078321e-02f, -8.87144729e-02f,
  -1.29468799e-01f, -4.91126478e-02f, -6.81036785e-02f, -6.36056811e-02f, -5.38637936e-02f, 2.67333612e-02f, -5.10053709e-02f, -4.66391034e-02f, 3.72473686e-03f, -1.37289777e-01f,
  -1.50414765e-01f, -7.07775950e-02f, 7.56459981e-02f, -3.17158550e-02f, -8.29010308e-02f, 3.70948426e-02f, -4.67104698e-03f, 6.19187579e-02f, -6.45348728e-02f, 3.66615318e-02f,
  -3.74753505e-01f, -2.06524551e-01f, -1.53601632e-01f, -6.85541108e-02f, -6.97823316e-02f, -6.43910200e-04f, 3.65075804e-02f, -1.45034879e-01f, -4.56996039e-02f, 2.65871957e-02f,
  -2.51226816e-02f, -1.57475881e-02f, -2.45692041e-02f, 5.31060137e-02f, 6.33780509e-02f, -6.19396642e-02f, -6.74746707e-02f, -4.41040918e-02f, -7.01112077e-02f, 8.55423789e-03f,
  -9.07564685e-02f, -2.26443950e-02f, 2.34398618e-02f, -6.41852897e-03f, -6.67973282e-03f, -4.69142199e-02f, 1.63733009e-02f, -1.46015007e-02f, 2.98378281e-02f, -2.63382122e-02f,
  -1.05095342e-01f, 4.49775606e-02f, -6.27816692e-02f, -2.98761010e-01f, -2.40076631e-02f, -1.68809325e-01f, -1.31531775e-01f, -5.70357293e-02f, 2.07186732e-02f, -9.87049565e-02f,
  -5.02761044e-02f, 1.24623023e-01f, 1.37803465e-01f, -2.20818445e-01f, 2.49818951e-01f, 1.68278649e-01f, -3.24168772e-01f, -1.64435789e-01f, 7.08772708e-03f, -1.61454856e-01f,
  -8.30997303e-02f, -1.45906985e-01f, 1.01017244e-02f, -1.05099522e-01f, -2.19790801e-01f, -1.28473669e-01f, 6.95538707e-03f, -5.49120188e-04f, -1.15218252e-01f, 9.26234648e-02f,
  -1.66241452e-01f, -2.84151912e-01f, -9.39171910e-02f, 2.09790114e-02f, -1.20403834e-01f, -5.37360609e-02f, 1.09254860e-03f, 1.02044120e-01f, -6.26713503e-03f, -4.04576771e-02f,
  3.69780581e-03f, 4.93479893e-02f, 9.74798501e-02f, 9.16520692e-03f, -2.93201804e-02f, -6.69461340e-02f, 3.06373462e-02f, -1.12467490e-01f, -1.89242489e-03f, 8.04763734e-02f,
  8.18412080e-02f, 6.06744224e-03f, -5.71030304e-02f, -3.70230116e-02f, -1.33028198e-02f, -5.92906959e-02f, 2.55474309e-03f, -2.11221050e-03f, -5.21613248e-02f, -1.08204456e-02f,
  1.91569384e-02f, 8.31884053e-03f, 2.00786889e-02f, 1.19395629e-01f, -7.35961786e-03f, 1.02585115e-01f, -6.52033910e-02f, 2.97177583e-02f, -5.46832047e-02f, -4.90526818e-02f,
  -2.24889386e-02f, -4.29976881e-02f, 5.70509881e-02f, 2.02444680e-02f, -4.58174124e-02f, -1.92325618e-02f, 2.33977959e-02f, -9.43618870e-05f, -2.21209247e-02f, -8.64128396e-02f,
  -1.49704665e-02f, 1.29111065e-02f, 6.56161085e-02f, 4.85192388e-02f, -2.46869922e-02f, 1.29811512e-02f, -4.37011011e-02f, 1.34015575e-01f, -5.27793765e-02f, -2.60456838e-02f,
  -1.62394613e-01f, -2.61517256e-01f, 4.06468064e-02f, -8.46002847e-02f, 1.28174931e-01f, -3.06794140e-02f, 5.37285209e-02f, -5.02772965e-02f, -7.83096403e-02f, -5.98771349e-02f,
  -8.49336535e-02f, -4.23162952e-02f, -8.84412825e-02f, -5.15420586e-02f, 1.11087456e-01f, 1.15238142e-03f, -6.91442052e-03f, -4.28234637e-02f, -1.48977051e-02f, -8.45560730e-02f,
  4.31365632e-02f, 6.23827055e-02f, 8.43867958e-02f, -3.42187695e-02f, 9.11179464e-03f, -2.03189682e-02f, -2.60964278e-02f, 1.13966512e-02f, -6.44776374e-02f, 3.37076373e-02f,
  -1.53566957e-01f, 1.21587805e-01f, 3.96434888e-02f, 4.96619567e-02f, -3.08709383e-01f, 1.67954341e-01f, 1.19847916e-01f, 2.51458343e-02f, 9.45549682e-02f, 2.66036421e-01f,
  -3.25482748e-02f, 5.82967363e-02f, 1.31397665e-01f, 9.30406749e-02f, -3.92315574e-02f, 1.71708122e-01f, 1.19369790e-01f, 2.78741382e-02f, -8.85825232e-02f, -2.90012155e-02f,
  -8.98927525e-02f, -2.83137020e-02f, -2.88759060e-02f, -2.24799141e-02f, -1.45023078e-01f, -1.30221412e-01f, -1.10586822e-01f, -1.04386143e-01f, -1.05349242e-03f, -8.27707499e-02f,
  -1.52623743e-01f, 3.68782878e-02f, -2.24186629e-02f, 2.22886682e-01f, -5.08887656e-02f, 2.17027329e-02f, 6.61654472e-02f, 6.33216575e-02f, 5.06177135e-02f, 6.36556000e-02f,
  -5.52025735e-02f, -5.20731620e-02f, -1.14313001e-02f, -7.61634856e-03f, 1.97376031e-02f, -6.67598248e-02f, -1.69298798e-02f, 8.12485814e-03f, 1.30213901e-01f, -7.30704442e-02f,
  -1.83373615e-02f, -6.44106194e-02f, -5.49344867e-02f, 5.41718528e-02f, -2.54381285e-03f, -3.08810584e-02f, 2.55604759e-02f, -1.22249871e-01f, -1.04513422e-01f, 4.94713336e-02f,
  6.00934885e-02f, 7.51611032e-03f, 2.73859482e-02f, 6.51066527e-02f, -7.64561966e-02f, -1.48518294e-01f, 1.75002273e-02f, 4.42340001e-02f, 6.82366197e-04f, -1.09134406e-01f,
  -1.81504413e-02f, -5.63645996e-02f, -1.18725739e-01f, -5.00564091e-02f, 2.00227704e-02f, -5.22796810e-02f, -2.64555961e-02f, -8.07517096e-02f, 8.89559910e-02f, 1.60145890e-02f,
  7.41090849e-02f, 8.34311731e-03f, 1.63270943e-02f, -3.01820375e-02f, 1.42273363e-02f, -9.31319147e-02f, -4.81355563e-02f, -2.56250389e-02f, 1.97549388e-02f, -2.81341672e-02f,
  7.19277486e-02f, 1.21193729e-01f, 2.29791924e-02f, 5.02171218e-02f, 7.81043395e-02f, 1.42106656e-02f, 1.64533183e-01f, -8.27745348e-02f, -2.83858124e-02f, 4.56532277e-02f,
  3.94151895e-04f, 3.83030847e-02f, -1.88010391e-02f, -1.63303893e-02f, -1.29002389e-02f, -3.05004232e-02f, -1.06990613e-01f, -5.66264242e-02f, 1.24412365e-01f, -4.23897021e-02f,
  6.16370849e-02f, 6.93299621e-03f, -8.20861198e-03f, 1.75362621e-02f, -4.32944559e-02f, 4.76838313e-02f, 4.67635840e-02f, 1.07668601e-01f, -1.15490407e-01f, -2.63679978e-02f,
  -1.64818317e-01f, 2.56976873e-01f, -9.96776074e-02f, 1.33601278e-01f, -1.81587324e-01f, 3.03154081e-01f, 2.20977828e-01f, -1.41545251e-01f, 1.23429976e-01f, 1.61926076e-01f,
  -1.34803042e-01f, -6.36001602e-02f, 9.68903229e-02f, -1.14246104e-02f, 1.34393185e-01f, 2.89443672e-01f, 1.41016930e-01f, 2.37671565e-02f, 9.04170051e-02f, 7.94854108e-03f,
  -1.53910574e-02f, 1.09807529e-01f, 7.49789411e-03f, 1.88484658e-02f, -1.10559911e-01f, -5.93742095e-02f, -1.56553179e-01f, -7.52492100e-02f, -7.85104185e-02f, -1.21538341e-02f,
  -1.05633549e-01f, -4.26361710e-02f, -5.44307828e-02f, -1.32629434e-02f, -5.69428666e-04f, -5.48309460e-02f, 7.27964789e-02f, 2.09170301e-02f, -2.53994390e-02f, -1.62559412e-02f,
  6.88607320e-02f, -3.94107439e-02f, 7.31930882e-02f, 8.46482664e-02f, 2.49663834e-02f, -1.08518474e-01f, -6.53805658e-02f, 2.05291137e-02f, -5.41760437e-02f, -9.21905339e-02f,
  -1.29408628e-01f, 8.12055022e-02f, -1.00104459e-01f, 4.66780253e-02f, -1.10964403e-02f, 1.30222663e-02f, 7.22712353e-02f, -9.94424745e-02f, 1.11183792e-01f, 2.19210610e-02f,
  2.58309487e-02f, 4.89524752e-02f, 1.41437292e-01f, 1.14947958e-02f, 3.87649089e-02f, -8.67781937e-02f, -9.79674906e-02f, -5.95811941e-03f, 1.68888681e-02f, -9.12669487e-03f,
  3.72265652e-02f, -1.30300328e-01f, -7.63123529e-03f, 3.96283865e-02f, 1.22075330e-03f, -6.11171834e-02f, -1.02611929e-01f, -8.50526914e-02f, -6.92903949e-03f, 1.75661668e-02f,
  -6.91645816e-02f, -2.55814306e-02f, 7.07238493e-03f, 3.64226177e-02f, -5.38071170e-02f, 2.00418849e-02f, 1.35607775e-02f, -8.03681742e-03f, -9.39515755e-02f, 2.30231490e-02f,
  1.79234520e-01f, 2.29814947e-01f, 7.91528299e-02f, 3.44145782e-02f, 9.90801305e-02f, 3.26503925e-02f, 1.42839670e-01f, -3.58085074e-02f, 8.08332339e-02f, -6.20424263e-02f,
  3.21575850e-02f, 3.96760069e-02f, 8.36771876e-02f, 2.93931202e-03f, -3.03786602e-02f, 6.39452040e-02f, -1.07369952e-01f, -5.17896786e-02f, -5.66025074e-06f, -6.04372993e-02f,
  -6.43789619e-02f, 8.39673504e-02f, -8.80693197e-02f, -2.72413176e-02f, -7.27949780e-04f, -5.67462295e-02f, -2.37081423e-02f, -1.27469506e-02f, 2.57332176e-02f, 5.00033163e-02f,
  5.10009602e-02f, 3.92332720e-03f, -8.24326426e-02f, -6.57615587e-02f, -2.04656854e-01f, -7.26555362e-02f, -1.08253613e-01f, -3.77039723e-02f, 1.41906559e-01f, 1.57446176e-01f,
  -1.07651539e-01f, 1.35099709e-01f, 1.71669438e-01f, -1.66433036e-01f, 1.02648184e-01f, 1.49228632e-01f, -1.38231829e-01f, 5.43926726e-04f, -4.41451222e-02f, -1.68580800e-01f,
  -1.40536919e-01f, -1.01237133e-01f, -8.56579095e-02f, -7.16489106e-02f, -2.69204289e-01f, -3.53991352e-02f, -9.51082632e-02f, -1.96672931e-01f, -1.33092448e-01f, -6.21625828e-03f,
  -7.55218789e-03f, 1.36810720e-01f, -8.62245411e-02f, 9.45592970e-02f, -5.38431592e-02f, -6.14665300e-02f, -1.05284736e-01f, 1.09664001e-01f, 8.33728835e-02f, 4.16624546e-03f,
  9.39811394e-02f, 6.35071620e-02f, 5.47536649e-02f, -4.50580977e-02f, -9.50222835e-02f, 6.64936528e-02f, -1.39536066e-02f, -6.14505224e-02f, 6.63766935e-02f, -3.67180305e-03f,
  -8.20641071e-02f, -9.99954790e-02f, -7.66307861e-02f, 2.74370313e-02f, -5.03597260e-02f, -2.06302945e-02f, 1.76160168e-02f, 6.01451509e-02f, -8.95199552e-02f, 3.55446674e-02f,
  -1.60979815e-02f, -1.40646251e-03f, -1.03444317e-02f, -4.03857194e-02f, 3.92755587e-03f, 5.53557873e-02f, -8.65038186e-02f, 1.36506220e-04f, 5.44277536e-05f, -1.08782865e-01f,
  5.58248945e-02f, 4.64871898e-02f, 8.88669789e-02f, 7.69661516e-02f, -6.19222224e-02f, 7.49614686e-02f, 8.24340526e-03f, 6.44194370e-04f, -7.21496418e-02f, -1.00459747e-01f,
  -1.28153386e-02f, 7.83382878e-02f, 6.05407059e-02f, -2.68698446e-02f, -1.14609674e-01f, -3.91241275e-02f, -7.22354352e-02f, 7.31940418e-02f, 8.64119753e-02f, -7.43905976e-02f,
  -1.97605286e-02f, 1.11341313e-01f, 5.56053855e-02f, -4.08240668e-02f, 6.02627918e-02f, -2.07527019e-02f, -4.09517437e-02f, -1.48037113e-02f, 3.29931453e-02f, 1.69711299e-02f,
  -6.40342906e-02f, -1.43961962e-02f, -2.73690820e-02f, -5.68138286e-02f, -1.04140250e-04f, 3.42709497e-02f, 3.20644304e-02f, -1.47859752e-02f, -1.06964642e-02f, -3.71784568e-02f,
  -8.55569541e-02f, 3.70131135e-02f, 7.88258463e-02f, 2.17323527e-02f, 1.19454833e-02f, 3.78410816e-02f, 7.42854401e-02f, -1.58421919e-02f, -6.52760640e-02f, 3.04361861e-02f,
  2.32636988e-01f, 1.45580294e-02f, -1.80645823e-01f, -1.34792641e-01f, -1.13164596e-01f, -2.01693282e-01f, -2.94758528e-01f, -2.11711720e-01f, -1.91758662e-01f, -1.80288732e-01f,
  -1.22789107e-01f, -1.09081464e-02f, 1.65331095e-01f, -2.65091926e-01f, 1.14772119e-01f, 1.96542859e-01f, -7.53124654e-02f, -8.33337009e-02f, 9.64595973e-02f, 3.09620053e-02f,
  3.17729712e-02f, -2.24950947e-02f, 1.48431510e-01f, -7.63619915e-02f, -1.85736954e-01f, -3.09829637e-02f, -2.51966957e-02f, -5.37892729e-02f, -2.24662706e-01f, -8.06982890e-02f,
  7.77099654e-02f, 5.77946119e-02f, 1.61862094e-02f, -1.91584509e-02f, 3.13416570e-02f, -3.80675569e-02f, -9.62398201e-02f, 7.74161741e-02f, -2.60842824e-03f, -2.13455390e-02f,
  -2.23188624e-02f, -3.05524897e-02f, -3.07926815e-02f, -1.51324226e-02f, -1.97073724e-02f, -1.06100954e-01f, -3.14105079e-02f, 7.11560482e-03f, -3.88178416e-02f, 4.73896116e-02f,
  -1.09122619e-01f, -7.49520063e-02f, -1.95389494e-01f, -3.35849635e-02f, -9.14564282e-02f, -1.30843416e-01f, 8.04316252e-02f, 9.19500440e-02f, 1.46864308e-02f, -3.72620113e-02f,
  -1.94081739e-02f, -2.21858136e-02f, 6.71794564e-02f, 1.10278623e-02f, 2.10292321e-02f, 5.03192097e-02f, -2.33283434e-02f, 3.36409174e-02f, 2.09840033e-02f, -4.36366387e-02f,
  -5.01613170e-02f, 3.36141884e-02f, 5.80648445e-02f, 1.40706161e-02f, -1.93331074e-02f, 3.79709266e-02f, -1.31788114e-02f, -4.39434871e-02f, -9.50228050e-02f, -4.17524464e-02f,
  -1.51455626e-02f, -5.21845035e-02f, -5.81613481e-02f, 2.08423473e-02f, -2.67742258e-02f, -1.30218593e-02f, -4.18560617e-02f, 9.91073772e-02f, 7.62547553e-02f, 3.01173553e-02f,
  7.77931064e-02f, 1.41899824e-01f, -3.03680240e-03f, 1.46357436e-02f, 1.09722584e-01f, 5.25890514e-02f, 3.48237529e-02f, 3.39223184e-02f, -6.24759533e-02f, 1.30741432e-01f,
  -5.24156690e-02f, 1.63133349e-02f, 1.93864107e-02f, -7.49489665e-02f, -1.29100636e-01f, -8.20528269e-02f, -3.05244252e-02f, 1.68390404e-02f, -2.28544082e-02f, -1.85315404e-02f,
  -8.35300535e-02f, 6.52431026e-02f, -9.35787633e-02f, -4.23572622e-02f, -2.49225218e-02f, 1.07038328e-02f, 7.03473613e-02f, -3.25119644e-02f, 6.56758668e-03f, -1.06289499e-01f,
  2.59768426e-01f, 5.45778424e-02f, -2.19454244e-02f, 9.99026373e-02f, -2.21854284e-01f, -2.67819971e-01f, -2.82642573e-01f, 2.01120414e-02f, -2.42713585e-01f, -3.36513780e-02f,
  1.36534765e-01f, -1.01456203e-01f, 9.98822525e-02f, 1.11911722e-01f, 1.27303883e-01f, -1.10457670e-02f, 1.81105629e-01f, -3.42445038e-02f, 1.13649983e-02f, 2.39053726e-01f,
  2.09211811e-01f, 2.38637403e-01f, 1.92558676e-01f, 1.13191552e-01f, 1.18955843e-01f, 2.88785875e-01f, 2.43210286e-01f, 4.56864759e-02f, 1.72890812e-01f, -7.33285770e-02f,
  2.78765988e-02f, 1.05217971e-01f, 5.97122461e-02f, -6.56429753e-02f, -2.05252925e-03f, 3.01581435e-02f, 2.25166269e-02f, -4.56851907e-02f, -1.26126841e-01f, -4.59737144e-02f,
  -1.93049125e-02f, 1.76365022e-02f, -7.38600791e-02f, -2.90189963e-02f, -1.20253852e-02f, -6.43923804e-02f, -1.07324630e-01f, -4.19811085e-02f, -5.44044301e-02f, 7.71093816e-02f,
  -8.39124247e-02f, -4.97331508e-02f, 6.37345314e-02f, -4.18065451e-02f, -7.21587613e-02f, -3.64273302e-02f, -7.93873426e-03f, 1.69994812e-02f, -1.00840501e-01f, -7.51055479e-02f,
  9.18299034e-02f, 1.54556171e-03f, 5.32275327e-02f, -3.11979316e-02f, 4.51118350e-02f, 2.15065759e-02f, -4.57838587e-02f, 8.20179656e-02f, 2.89604384e-02f, 7.56964982e-02f,
  4.90542443e-04f, 2.02431362e-02f, -3.88958082e-02f, -6.07309025e-03f, 4.53842953e-02f, -1.21330269e-01f, 1.93714052e-02f, -2.19196007e-02f, 1.80411059e-02f, -1.82688441e-02f,
  -2.71672271e-02f, 1.07653759e-01f, 6.45290092e-02f, -7.37772360e-02f, 1.66686382e-02f, 3.82055044e-02f, 6.62031844e-02f, 4.50490490e-02f, -1.17862709e-01f, 8.00275877e-02f,
  9.66129154e-02f, 2.10566819e-01f, 1.89076667e-03f, -8.15171450e-02f, 2.95371562e-03f, 1.10794768e-01f, 3.11426283e-03f, 3.78666557e-02f, 8.92510340e-02f, 1.22222319e-01f,
  4.62030210e-02f, 1.83976125e-02f, 4.34020422e-02f, 6.98636323e-02f, -5.57792038e-02f, 6.03981577e-02f, 1.50089869e-02f, 2.07272023e-02f, -7.37516955e-02f, 2.58523915e-02f,
  1.81710161e-02f, -9.03252605e-03f, 3.90645340e-02f, -1.64884329e-01f, -4.33055572e-02f, 4.33678413e-03f, 3.00067221e-03f, 8.19566622e-02f, 8.34523439e-02f, -2.71093510e-02f,
  -5.58336228e-02f, -1.92210346e-01f, 2.75135320e-02f, -1.51369898e-02f, -9.24141426e-03f, 1.92274034e-01f, 3.64911377e-01f, -1.54075339e-01f, -1.62117347e-01f, 1.02050379e-01f,
  1.92804798e-01f, 1.12801902e-01f, 3.40564817e-01f, 4.92201857e-02f, 3.28835160e-01f, 1.68372586e-01f, -5.40220961e-02f, 6.90463036e-02f, -1.46566227e-01f, -7.68537000e-02f,
  -1.21569023e-01f, 7.85755515e-02f, 1.47617206e-01f, -2.21213549e-01f, 2.56885141e-02f, -1.18438192e-01f, 5.19481441e-03f, 1.28266528e-01f, -2.40408015e-02f, 1.24000728e-01f,
  -1.40340878e-02f, -5.98035567e-02f, 5.36735989e-02f, 2.61623133e-03f, 4.90827635e-02f, 3.79280187e-02f, 2.40605827e-02f, 1.91938534e-01f, -3.83106470e-02f, -4.29196330e-03f,
  -1.37438243e-02f, -2.18965020e-02f, -8.19495097e-02f, 1.74725074e-02f, -9.85303819e-02f, -6.80787787e-02f, -2.77633592e-02f, -7.22492393e-03f, -5.20275049e-02f, 8.43411870e-03f,
  1.08158745e-01f, -3.55450660e-02f, -5.16624413e-02f, 5.95915541e-02f, -7.23548979e-02f, -4.08622622e-02f, 1.03162238e-02f, 8.42988268e-02f, -1.32851815e-02f, 1.47886178e-03f,
  5.55851460e-02f, -5.79084195e-02f, 8.52831081e-02f, 2.47476567e-02f, -2.36137770e-02f, -6.22554570e-02f, -3.36501226e-02f, 9.86223519e-02f, 2.00526509e-02f, -1.59926973e-02f,
  3.12221851e-02f, -9.12886951e-03f, -1.78780183e-01f, -1.04210362e-01f, -7.22775236e-02f, -4.74596508e-02f, 2.28619576e-02f, -7.99719691e-02f, 3.74867320e-02f, 5.31172082e-02f,
  8.52342043e-03f, -2.69187931e-02f, 1.01391897e-02f, 8.56977627e-02f, -4.41441797e-02f, 8.07273090e-02f, -1.07282689e-02f, -1.11763604e-01f, 2.42530350e-02f, 1.95595976e-02f,
  3.75635028e-02f, -1.64455160e-01f, 4.34704907e-02f, -9.51798446e-03f, 7.32214823e-02f, -5.21322004e-02f, 5.58819287e-02f, -3.18119414e-02f, -1.34560853e-01f, -6.21696003e-02f,
  -9.95937809e-02f, -1.89909358e-02f, -3.86422426e-02f, 7.62629285e-02f, 1.49415084e-03f, -6.49468228e-02f, -5.87382820e-03f, -2.27792952e-02f, 3.23233679e-02f, -6.28608465e-02f,
  -3.69393229e-02f, 5.31822955e-03f, -4.93954495e-02f, -6.88147619e-02f, -1.05482660e-01f, 8.98745582e-02f, -1.21602356e-01f, -4.01913049e-03f, -4.59081233e-02f, 3.03731579e-02f,
  -1.39044374e-01f, 1.27969190e-01f, -2.51131088e-01f, 4.57932912e-02f, -1.28164008e-01f, -9.55624729e-02f, -8.33200365e-02f, -3.07844975e-03f, 1.40524544e-02f, 2.90052444e-01f,
  2.05515206e-01f, 7.73830432e-03f, 9.53602195e-02f, 9.12359655e-02f, -1.93381146e-01f, 2.25733042e-01f, -1.43083408e-02f, 8.25076029e-02f, 6.11561537e-02f, -1.18582413e-01f,
  -1.12728149e-01f, 1.82916954e-01f, -2.90613174e-02f, -3.73585969e-02f, -1.55103713e-01f, -5.69692254e-02f, -6.37680292e-02f, 4.65999910e-05f, -3.10225822e-02f, 1.80773009e-02f,
  -2.22447757e-02f, 1.80305570e-01f, -3.05488473e-03f, 7.65584484e-02f, -1.20593891e-01f, -8.26760754e-02f, -6.25078306e-02f, -6.48643896e-02f, -4.57433499e-02f, -4.23246548e-02f,
  -3.36389318e-02f, 3.77722941e-02f, 5.51076084e-02f, -1.06691634e-02f, -1.38794467e-01f, 1.78854037e-02f, 9.04708914e-03f, -5.77971078e-02f, -6.21056221e-02f, -1.10581003e-01f,
  -7.77230263e-02f, -1.13075778e-01f, -4.82284985e-02f, 7.27184191e-02f, -2.82716695e-02f, 9.02633667e-02f, 2.51563638e-02f, 1.54459849e-02f, -2.79710032e-02f, 9.42704920e-03f,
  -8.90640393e-02f, 4.06655222e-02f, 1.35319801e-02f, 3.57883722e-02f, -1.70524884e-02f, -2.16559339e-02f, -3.34202200e-02f, 4.53873463e-02f, 5.99523857e-02f, -5.47277331e-02f,
  5.91261014e-02f, 2.03151163e-02f, 1.72748452e-03f, -1.57592818e-02f, -3.31327459e-03f, -1.19721377e-02f, 1.74963996e-02f, 4.75246906e-02f, -6.09608069e-02f, -7.88348392e-02f,
  8.98220763e-02f, 2.16830522e-02f, 2.90605724e-02f, -1.25792669e-03f, 3.13347913e-02f, -5.44874184e-02f, 1.62299946e-02f, 1.04172528e-01f, -4.22822833e-02f, -2.03064173e-01f,
  1.00803696e-01f, 1.60974547e-01f, 2.21384112e-02f, 3.02710087e-05f, -6.06456399e-03f, -1.53150618e-01f, -6.23235218e-02f, -2.87380498e-02f, 2.14844830e-02f, -2.60631125e-02f,
  -1.98308751e-02f, 1.09548494e-01f, -9.55999717e-02f, -5.24557345e-02f, -1.56645253e-01f, -1.94864608e-02f, -1.55244768e-02f, 1.47441644e-02f, 1.33095607e-02f, -9.34191048e-02f,
  -9.50632989e-03f, 5.30713648e-02f, 4.35024947e-02f, -1.31194014e-02f, -1.99788753e-02f, 3.81986983e-03f, -1.77209631e-01f, 1.06804427e-02f, -1.03820153e-01f, 1.44243184e-02f,
  1.91045940e-01f, -1.53212063e-02f, -6.04853071e-02f, 2.26626709e-01f, -7.82307331e-03f, -2.51386613e-01f, -2.58804798e-01f, 1.70567498e-01f, -8.22111517e-02f, -1.23435006e-01f,
  8.13193023e-02f, -7.07440749e-02f, -1.46262392e-01f, 2.74941117e-01f, 2.33264938e-01f, -1.19638771e-01f, 2.22031757e-01f, 6.13778271e-03f, -4.12498862e-02f, 4.56336103e-02f,
  1.88487977e-01f, 2.74234295e-01f, 1.91258565e-01f, 2.56399095e-01f, 9.64737386e-02f, 1.92338228e-01f, 2.24060550e-01f, -1.31827071e-01f, 3.12595904e-01f, 1.12683780e-01f,
  -4.86059599e-02f, 3.60868336e-03f, 6.57416880e-02f, -2.17117481e-02f, 6.21965602e-02f, -4.58983518e-02f, -4.39110361e-02f, 9.02835466e-03f, 2.84105055e-02f, -7.94262439e-02f,
  -2.62631308e-02f, 8.54153708e-02f, 8.50978121e-02f, 2.51616016e-02f, -7.30092749e-02f, 8.72184783e-02f, 1.26022324e-02f, 5.21275550e-02f, -7.30414176e-03f, 5.93714193e-02f,
  2.75519453e-02f, 8.16306565e-03f, -7.17681497e-02f, 7.57933185e-02f, -3.63128469e-03f, -1.79834710e-03f, -1.54945375e-02f, 9.30941999e-02f, 2.50700414e-02f, 5.23212962e-02f,
  4.53567095e-02f, -1.19063087e-01f, -2.80224662e-02f, -4.18842994e-02f, 2.01560208e-03f, -4.05037515e-02f, 2.03868281e-02f, -1.16870331e-04f, -2.36338675e-02f, 4.12384607e-02f,
  -4.18300666e-02f, 2.85892133e-02f, -4.28995453e-02f, 4.28571599e-03f, -1.05609139e-02f, -1.07960820e-01f, -1.60421524e-02f, 1.63108073e-02f, 2.23546326e-02f, 3.84124443e-02f,
  1.81848966e-02f, 5.56429923e-02f, -2.57063638e-02f, -2.05428004e-02f, -3.03271729e-02f, -4.41670325e-03f, 4.88160402e-02f, 1.87708028e-02f, 5.48759662e-03f, 4.60551381e-02f,
  -6.43572882e-02f, 1.70305178e-01f, -8.65956172e-02f, 9.27476287e-02f, -6.46537393e-02f, 6.68712705e-03f, -3.97774316e-02f, 1.39831126e-01f, 3.12407594e-02f, -2.72850264e-02f,
  6.24856502e-02f, -5.12734242e-02f, -1.16838872e-01f, 1.12192586e-01f, 4.07579243e-02f, -2.24806461e-02f, 4.31435555e-02f, -2.41166586e-03f, 6.21151179e-02f, 9.06399265e-02f,
  -5.94211370e-03f, -4.61926833e-02f, 1.47001818e-02f, -5.56164272e-02f, 1.12283938e-01f, -8.29306897e-04f, 2.69429237e-02f, -3.28165777e-02f, 3.92740639e-03f, 9.81434900e-03f,
  -2.34858319e-01f, -1.62250083e-02f, -2.80912817e-01f, -1.35781765e-01f, 1.15576409e-01f, -2.86931098e-01f, -2.39779174e-01f, 2.39877850e-02f, 5.62348180e-02f, 2.05678955e-01f,
  3.75371948e-02f, -1.16296738e-01f, 1.24235034e-01f, -2.42107406e-01f, -3.22616667e-01f, -1.36153564e-01f, -3.01623970e-01f, -1.27788931e-01f, -1.14563026e-01f, -1.01840705e-01f,
  -1.84312120e-01f, -2.40771919e-02f, -2.83841342e-01f, -4.97632846e-02f, -6.11411482e-02f, -3.28470729e-02f, 1.17275201e-01f, 9.91496518e-02f, -7.23452568e-02f, 6.38495684e-02f,
  -2.56297030e-02f, 1.82886571e-01f, -6.17711805e-03f, -8.10432509e-02f, -8.83878171e-02f, 5.02778552e-02f, -6.69829100e-02f, 4.64738570e-02f, 4.63462695e-02f, -9.66271162e-02f,
  -5.46842627e-03f, -2.92414967e-02f, 2.44380590e-02f, -2.57089939e-02f, -3.15761799e-03f, 5.76320440e-02f, 3.80586609e-02f, -3.44857685e-02f, 3.33435796e-02f, -1.23422287e-01f,
  -1.12697966e-01f, 3.62285860e-02f, 2.13044677e-02f, 3.73838320e-02f, -1.12669460e-01f, 7.01119751e-02f, -1.06477514e-01f, 4.63059545e-02f, 4.45716381e-02f, -9.96615738e-03f,
  7.61526451e-02f, -4.86790985e-02f, -1.71292707e-01f, -6.30631521e-02f, -2.02288814e-02f, 2.45764460e-02f, 9.16275661e-03f, 3.87504622e-02f, -5.08585833e-02f, -6.88691065e-02f,
  -1.40862297e-02f, 1.41335987e-02f, -4.62739803e-02f, -6.35711774e-02f, -1.42479375e-01f, 6.88894689e-02f, -1.29916919e-02f, -2.44195722e-02f, -8.21333155e-02f, -1.05875514e-01f,
  -2.41086856e-02f, 2.12949868e-02f, 2.52319202e-02f, 4.38729711e-02f, -6.43726531e-03f, -4.37730812e-02f, -3.13137621e-02f, 1.15002068e-02f, -5.99326901e-02f, -2.91231219e-02f,
  3.41588855e-02f, 9.55117345e-02f, -2.12428290e-02f, 1.12081952e-01f, -3.21735144e-02f, -6.17649369e-02f, -8.57984647e-02f, -1.24221975e-02f, 3.95809114e-02f, -4.57525924e-02f,
  3.12523767e-02f, -6.84430748e-02f, -2.12188028e-02f, -3.02732866e-02f, 2.39090957e-02f, -3.97924632e-02f, 3.27277966e-02f, 4.06374931e-02f, -1.47927483e-03f, 6.57328814e-02f,
  -2.26477329e-02f, 1.61017687e-03f, -5.35359359e-05f, 3.97027619e-02f, 1.51060401e-02f, 7.39041418e-02f, 2.98044235e-02f, -7.28344992e-02f, 7.27636591e-02f, 1.78280175e-01f,
  2.80425660e-02f, 1.16193496e-01f, -1.89678937e-01f, 8.64923373e-03f, -2.96974331e-01f, 1.56779975e-01f, 1.59815643e-02f, -1.16073161e-01f, 1.10942513e-01f, 2.41527393e-01f,
  7.86599964e-02f, 3.40059102e-02f, 1.20884687e-01f, 1.87970232e-02f, 3.20115089e-02f, 2.72046030e-01f, 9.44712311e-02f, 2.48726420e-02f, -1.87047443e-03f, -7.21504539e-02f,
  -3.95423621e-02f, 7.41225407e-02f, -3.45399929e-03f, -1.17331214e-01f, -6.51769042e-02f, -7.87709747e-03f, -1.04459494e-01f, -9.19886306e-02f, -9.27163512e-02f, -8.54440853e-02f,
  1.70882195e-02f, 1.51626065e-01f, 2.31357235e-02f, 1.81354377e-02f, -1.08706774e-02f, -1.63130283e-01f, -4.87415865e-02f, 2.21562590e-02f, -8.30684751e-02f, 4.04505469e-02f,
  6.40289038e-02f, -4.51455750e-02f, 7.42199123e-02f, -4.87849563e-02f, -6.47275299e-02f, -2.74633709e-02f, 2.31190640e-02f, 1.17820166e-02f, 3.36458907e-02f, -1.00599956e-02f,
  -2.58740094e-02f, -3.11514605e-02f, 1.51890358e-02f, 2.65908092e-02f, -2.37556291e-04f, 1.62291806e-02f, 5.78042679e-02f, 8.30734521e-02f, 9.48166475e-02f, 6.43655881e-02f,
  5.86719550e-02f, -2.88929883e-02f, 3.02229222e-04f, -5.79638965e-02f, -9.14887805e-03f, -9.45166918e-04f, -1.14800734e-02f, -1.72149334e-02f, 1.10369608e-01f, -9.27237868e-02f,
  -9.33238678e-03f, 2.60454952e-03f, 3.86424102e-02f, 6.92873672e-02f, 2.19697710e-02f, -1.81662254e-02f, -3.71764693e-03f, -7.57160112e-02f, 3.46869379e-02f, 6.96582580e-03f,
  -5.94594441e-02f, 3.29040363e-02f, 1.59364974e-03f, 1.00165997e-02f, -2.46307757e-02f, -5.66087775e-02f, 8.98519754e-02f, 1.08837694e-01f, -1.31589025e-02f, 2.03647707e-02f,
  1.44992754e-01f, 2.37830922e-01f, 1.33191794e-01f, -5.06363139e-02f, 1.05575241e-01f, -7.69714406e-03f, 7.66004995e-02f, 6.17919415e-02f, 5.19967265e-02f, 5.78372180e-02f,
  4.83449996e-02f, -8.67230911e-03f, -1.88257787e-02f, -7.04414397e-02f, 3.02454922e-02f, 9.15784389e-02f, -3.62850167e-02f, -1.56813301e-02f, 8.21838155e-02f, 9.23265293e-02f,
  -9.93815437e-02f, 9.30714905e-02f, 1.07093848e-01f, 1.22724168e-01f, 2.96307821e-02f, 8.61782208e-02f, -1.72307435e-03f, -1.35658402e-02f, -5.48627786e-02f, 5.19589484e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.45630002e-01f, 1.19235888e-01f, 1.34555921e-01f, 7.25451037e-02f, 6.25499263e-02f, 9.75656137e-02f, 2.41064709e-02f, 2.35532876e-03f, 8.03495273e-02f, 1.10663295e-01f,
  9.94212553e-02f, -9.88580566e-03f, 7.02346861e-02f, 1.26350746e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.53306946e-01f, 2.46945629e-03f, 7.53022134e-02f, 9.25844759e-02f, 4.32414282e-03f, -4.35193889e-02f, 1.00515746e-02f, 7.74879903e-02f, -8.94201845e-02f, -3.74352559e-02f,
  -7.21597895e-02f, 7.20618442e-02f, -1.49442956e-01f, 1.37917504e-01f, -3.41433845e-02f, 4.16836068e-02f, -7.27894763e-03f, -6.72060996e-02f, 3.83324223e-03f, 3.05427704e-02f,
  1.11052180e-02f, 1.78713594e-02f, -1.42905489e-01f, 5.25724702e-02f, 3.21930945e-02f, 2.50498205e-01f, 9.19254944e-02f, 2.77680427e-01f, -1.31484464e-01f, -3.65153998e-02f,
  -1.64807662e-01f, -1.77412301e-01f, 4.59005237e-02f, -1.69548258e-01f, -1.74569800e-01f, -2.31720477e-01f, -1.86086819e-01f, -1.47915296e-02f, 2.33225167e-01f, -1.47558793e-01f,
  1.29071862e-01f, -2.51753926e-01f, -9.19287726e-02f, -9.97504145e-02f, -1.75871044e-01f, -1.62170246e-01f, 1.63592815e-01f, 3.85355771e-01f, 6.75609782e-02f, -7.18235448e-02f,
  1.39703110e-01f, 6.69024661e-02f, 2.08630443e-01f, 2.09762871e-01f, 3.66539508e-02f, -4.31957841e-03f, -2.78416313e-02f, 6.48779124e-02f, -4.10824232e-02f, -2.63216090e-03f,
  9.19642895e-02f, -2.36644745e-01f, 7.32522607e-02f, 5.66455759e-02f, -1.50650457e-01f, -9.43981707e-02f, -1.13353558e-01f, 1.41002266e-02f, -4.41321209e-02f, -1.11414738e-01f,
  2.69326139e-02f, -8.34929720e-02f, -1.60399228e-01f, -4.64831479e-02f, -4.97383028e-02f, -3.74779701e-02f, -2.07438812e-01f, -8.79994710e-04f, -1.29887775e-01f, 6.80223852e-02f,
  -7.56107084e-03f, -1.50951359e-03f, -2.11043134e-01f, -8.50104392e-02f, 3.32833529e-02f, 2.30553672e-02f, -5.33293486e-02f, -7.18711838e-02f, -1.42479822e-01f, 2.56614536e-01f,
  -9.81252873e-04f, 1.85498357e-01f, -5.83806820e-02f, -1.74330492e-02f, -1.39360279e-01f, -2.21814699e-02f, -1.96712296e-02f, -2.48735789e-02f, -6.88809752e-02f, -1.21396907e-01f,
  6.34411350e-02f, 3.90721150e-02f, 9.24075544e-02f, -1.03090063e-01f, 9.50815231e-02f, -1.63669899e-01f, -1.68366820e-01f, 8.40746984e-02f, 1.73431858e-02f, -6.56447858e-02f,
  2.11206138e-01f, 2.22805768e-01f, -1.17113963e-01f, 5.32627441e-02f, 1.61628067e-01f, 7.19325617e-02f, 2.05201671e-01f, 1.99855998e-01f, 2.44018566e-02f, -9.87173468e-02f,
  3.79069261e-02f, 8.02999884e-02f, 3.30637097e-02f, 6.88048592e-03f, -8.12671729e-04f, -9.99671221e-02f, 1.07675113e-01f, 9.81016830e-02f, -5.41775115e-03f, 4.32849079e-02f,
  -1.76730212e-02f, -5.46820499e-02f, 1.34565964e-01f, 4.27527912e-02f, 2.83629447e-02f, 4.41886187e-02f, 1.40620768e-01f, -6.85400050e-03f, 1.18629903e-01f, 8.32432359e-02f,
  8.08074847e-02f, 5.35609722e-02f, -3.45830321e-02f, 1.62196785e-01f, -5.33248074e-02f, 6.57243356e-02f, 7.67638236e-02f, 1.18552908e-01f, 5.44702448e-02f, -9.40778702e-02f,
  -8.13111141e-02f, -1.85644291e-02f, -4.19410272e-03f, 1.06800705e-01f, 2.29328647e-01f, 1.30140066e-01f, 7.98800215e-02f, 1.15824703e-04f, -5.41959517e-03f, -1.03955418e-02f,
  2.73674130e-02f, -2.59061068e-01f, -2.32321098e-01f, 8.40494186e-02f, 2.70276889e-02f, -4.22722474e-02f, 2.42125262e-02f, -2.23654099e-02f, -1.80205074e-03f, -1.72389880e-01f,
  -8.09273347e-02f, -2.79446483e-01f, -1.10392153e-01f, -1.70701399e-01f, -1.21631540e-01f, 1.56741306e-01f, 1.70629770e-01f, -2.46969089e-01f, 5.58939092e-02f, 1.22440755e-01f,
  4.29652222e-02f, 3.84365804e-02f, 3.42124030e-02f, 1.50511667e-01f, -2.05853507e-02f, 6.49621636e-02f, 1.91164181e-01f, -1.14188083e-01f, 7.07514063e-02f, -1.46489143e-02f,
  1.88706309e-01f, 3.31973433e-02f, -1.43808918e-02f, -4.03586365e-02f, -2.64115520e-02f, -4.04740125e-02f, 7.99543336e-02f, 3.75126787e-02f, 9.76314116e-03f, -9.86593664e-02f,
  -2.65077110e-02f, 8.13742429e-02f, -8.43268260e-02f, -1.54908448e-02f, -1.38279825e-01f, 9.61041749e-02f, -1.26053896e-02f, -1.06176928e-01f, -5.36688380e-02f, 1.12664245e-01f,
  -1.18776560e-01f, 8.32529142e-02f, 2.09365919e-01f, 6.32822737e-02f, -3.39357443e-02f, -4.33271565e-02f, -9.15516093e-02f, -8.15842450e-02f, -1.44978687e-01f, -1.48244098e-01f,
  3.14711370e-02f, -7.44831264e-02f, -8.86811614e-02f, 1.77625820e-01f, -9.53063220e-02f, -8.03853348e-02f, 3.91509980e-02f, 9.14109051e-02f, 1.80795062e-02f, 1.75197229e-01f,
  -2.08584324e-01f, 1.29533380e-01f, 9.26520303e-02f, -8.83808360e-03f, 1.05261924e-02f, 1.74576446e-01f, 3.10536861e-01f, 1.32678002e-01f, 5.24942875e-02f, -7.94341117e-02f,
  2.68552393e-01f, -1.25733182e-01f, 1.00224102e-02f, -1.47171855e-01f, 9.51093854e-04f, -2.13199049e-01f, 1.44518167e-01f, 4.54948470e-02f, -5.12138009e-02f, 5.45861945e-02f,
  1.10032773e-02f, -1.73083581e-02f, 1.10611662e-01f, -1.48842350e-01f, -2.93628156e-01f, 1.22569595e-02f, -2.17597336e-01f, 5.22040874e-02f, -1.39290299e-02f, 6.81882650e-02f,
  1.12302275e-02f, 1.54787246e-02f, -1.83969140e-01f, -1.16356850e-01f, 1.34687707e-01f, 2.75814701e-02f, 4.17948514e-02f, 7.36964718e-02f, -2.22754195e-01f, 7.23603042e-03f,
  -1.02468334e-01f, -3.71933505e-02f, -1.70641448e-02f, -2.37580650e-02f, -1.78175956e-01f, -1.46366451e-02f, 8.96210149e-02f, -4.64828126e-02f, 1.66750371e-01f, -1.93030328e-01f,
  1.62807778e-01f, 8.80972110e-03f, -8.69845226e-02f, -4.51144502e-02f, -8.71705264e-02f, 6.94400296e-02f, -2.38836870e-01f, 2.42209956e-01f, -2.25480720e-01f, 2.23056767e-02f,
  -1.87482629e-02f, 2.94245929e-02f, -1.04687558e-02f, 1.43636301e-01f, -2.82747477e-01f, -1.60998870e-02f, 5.07759675e-02f, 4.99307439e-02f, -4.16106880e-02f, 5.93556911e-02f,
  1.52399167e-01f, -6.00151494e-02f, -1.58686697e-01f, 2.80523617e-02f, 3.43675554e-01f, 6.49882033e-02f, -1.00979261e-01f, -1.28998280e-01f, -9.62940231e-02f, -1.11440003e-01f,
  9.25770327e-02f, 2.52189577e-01f, 4.09636609e-02f, 2.44277164e-01f, 1.40523881e-01f, 3.53951678e-02f, 1.77433446e-01f, 2.57590022e-02f, -7.96637163e-02f, 1.75344616e-01f,
  1.41208172e-01f, -7.14538693e-02f, -1.54492361e-02f, 1.44756055e-02f, -9.30886017e-04f, 1.12602478e-02f, -1.10293645e-02f, 6.93176538e-02f, 2.28825938e-02f, -5.38230687e-02f,
  1.06885247e-01f, 5.09856790e-02f, 1.03027709e-01f, -5.82499579e-02f, 1.62969097e-01f, -2.65259703e-04f, -4.93228249e-02f, -4.71427739e-02f, -4.45351489e-02f, 3.68916579e-02f,
  -1.47920921e-01f, 8.62419829e-02f, 8.93864688e-03f, 1.44195661e-01f, -2.33288086e-03f, 7.06689106e-03f, 1.42547756e-01f, 1.79877564e-01f, 1.70655102e-01f, -1.46823257e-01f,
  1.20995335e-01f, -1.40928105e-01f, 1.00636624e-01f, 5.19751608e-02f, 4.59753387e-02f, -1.52506633e-02f, 1.20845571e-01f, -1.97321236e-01f, -5.34980325e-03f, -8.11752975e-02f,
  1.95554152e-01f, 4.84375283e-03f, -4.41350117e-02f, -1.66422486e-01f, -7.88113102e-02f, -2.88213611e-01f, -1.31438211e-01f, -1.58780426e-01f, -2.02774704e-02f, -6.53584823e-02f,
  -5.27770817e-02f, 1.50743946e-01f, -4.09956537e-02f, -7.60318488e-02f, -2.06872880e-01f, -1.15484424e-01f, -1.49935395e-01f, 4.08439189e-02f, 2.84280121e-01f, -2.58338034e-01f,
  -2.20485687e-01f, 1.68234572e-01f, 1.84387520e-01f, -2.09726557e-01f, -2.17981398e-01f, 9.91585180e-02f, 7.40656070e-03f, 1.23561174e-01f, 8.48714337e-02f, 4.01884615e-02f,
  -5.97269945e-02f, -3.99582535e-02f, 1.14053056e-01f, -8.82313401e-02f, 6.35667816e-02f, 6.81425724e-03f, -3.16176331e-03f, -3.32606360e-02f, -8.14055279e-02f, 5.65891266e-02f,
  9.55495536e-02f, -8.12814683e-02f, -3.60138435e-03f, -1.36455998e-01f, 1.67302102e-01f, -8.08389038e-02f, 1.21968947e-01f, -1.93101555e-01f, 1.60806060e-01f, 5.70713915e-02f,
  -2.61048853e-01f, -1.40015274e-01f, -1.34031221e-01f, 1.12664223e-01f, -1.25671059e-01f, 1.82082042e-01f, -5.75388521e-02f, -1.50809079e-01f, -1.16287425e-01f, -1.58610687e-01f,
  -3.13409507e-01f, 2.28637397e-01f, -1.02085248e-01f, -9.71242115e-02f, -1.60629988e-01f, -1.46267846e-01f, -4.42096815e-02f, 2.15436086e-01f, 9.59058944e-03f, 1.13796629e-01f,
  7.28374794e-02f, 1.80539675e-02f, 6.59882128e-02f, -7.52103105e-02f, 1.82156451e-02f, 1.81216970e-02f, 1.05853446e-01f, 1.29010022e-01f, 1.03281274e-01f, 2.28612393e-01f,
  5.26468232e-02f, 9.87841636e-02f, -5.77281136e-03f, 1.72761559e-01f, 1.34244397e-01f, -7.95040578e-02f, -8.99559781e-02f, 5.63158169e-02f, -3.41828875e-02f, -4.43477882e-03f,
  6.37332872e-02f, 8.11644346e-02f, -5.03143556e-02f, 6.81777894e-02f, 9.38464478e-02f, -1.03983562e-02f, -6.31377846e-02f, -3.61993723e-02f, -3.27502973e-02f, 7.28033781e-02f,
  1.03074998e-01f, -1.21583994e-02f, -8.22407752e-03f, 6.87942430e-02f, 1.74236059e-01f, -1.11256331e-01f, 1.06541246e-01f, -1.11204796e-01f, -1.65377721e-01f, 1.30200451e-02f,
  -7.93701559e-02f, 3.61063853e-02f, -1.30879385e-02f, -9.85384807e-02f, 1.86936393e-01f, -3.48926075e-02f, -1.84604108e-01f, 7.77735934e-02f, -6.72710612e-02f, -1.12777866e-01f,
  -6.43581599e-02f, 6.67087436e-02f, -1.03691913e-01f, -1.49678260e-01f, -2.24674597e-01f, -1.30719602e-01f, 3.09364479e-02f, -9.70346294e-03f, -4.98501323e-02f, -1.77449193e-02f,
  9.68253762e-02f, 3.94914597e-02f, -6.23924769e-02f, -1.86993942e-01f, 8.22157636e-02f, -6.26283363e-02f, -2.09582657e-01f, 2.59094328e-01f, 3.16909462e-01f, -6.79574087e-02f,
  -1.15047628e-02f, 1.79974750e-01f, -1.94008186e-01f, -7.05002546e-02f, 5.51813692e-02f, 1.32644773e-01f, 5.98701648e-03f, 5.33705056e-02f, -1.24361552e-01f, -5.68369925e-02f,
  2.83670843e-01f, -1.65157944e-01f, -1.04084343e-01f, -5.02827503e-02f, 1.09059334e-01f, -2.05243640e-02f, 1.83930248e-01f, 1.19143635e-01f, 9.28097665e-02f, 1.07246339e-01f,
  2.64798962e-02f, 2.66416054e-02f, -5.97377047e-02f, -1.35426130e-03f, -5.93982125e-03f, 1.48681596e-01f, 6.10872209e-02f, 2.23377906e-02f, 1.07866423e-02f, 4.19623926e-02f,
  5.35999238e-02f, 1.67062253e-01f, 1.46184161e-01f, 1.37994178e-02f, 3.27974483e-02f, 8.73100311e-02f, 1.14960177e-02f, -6.31573275e-02f, -6.83732852e-02f, 2.06481397e-01f,
  -1.13494825e-02f, -8.94804075e-02f, 2.71129999e-02f, 1.47142321e-01f, 1.89897522e-01f, -1.77958131e-01f, 4.07804176e-02f, 2.45942995e-02f, -3.76060754e-02f, -3.45639586e-02f,
  1.44695535e-01f, 1.57057848e-02f, 1.28510490e-01f, -4.50778455e-02f, -8.58208090e-02f, 6.43004011e-03f, -1.00828819e-02f, 2.11722419e-01f, 9.19150561e-02f, 2.13141814e-01f,
  1.23114288e-01f, -1.98559880e-01f, -1.02527123e-02f, 2.10120514e-01f, 1.34455934e-01f, -1.52133435e-01f, -1.09111508e-02f, 5.02919778e-03f, -2.24687010e-01f, -2.41971165e-01f,
  -2.85181195e-01f, 9.21776369e-02f, 5.01794107e-02f, -1.27846897e-01f, -6.32605404e-02f, -8.38855579e-02f, 6.46284893e-02f, 1.74971089e-01f, -1.01650640e-01f, -1.22083478e-01f,
  5.33421040e-02f, 2.29237497e-01f, -8.33798498e-02f, -1.20510280e-01f, 5.45356609e-02f, 1.96524002e-02f, 8.58090222e-02f, -5.03712110e-02f, 1.44742772e-01f, 7.03679994e-02f,
  -4.69595157e-02f, -1.60448223e-01f, -1.30475432e-01f, 7.78723583e-02f, 1.93493858e-01f, 9.77830514e-02f, 6.22575358e-02f, -6.22922629e-02f, 1.47001132e-01f, 5.32191768e-02f,
  1.00176349e-01f, 1.47004962e-01f, -2.12789867e-02f, 1.43783510e-01f, 2.03862622e-01f, 3.36489379e-02f, 3.55149925e-01f, 1.22510046e-01f, 1.11141637e-01f, -7.42604584e-03f,
  7.12084547e-02f, 8.72399509e-02f, 1.16546102e-01f, -2.96957325e-03f, 5.40875047e-02f, 7.57599175e-02f, -1.70373425e-01f, 6.68139085e-02f, -3.62365879e-02f, 1.64628830e-02f,
  -5.85162044e-02f, 2.58145869e-01f, -2.08185222e-02f, -1.72285676e-01f, -2.46258304e-02f, -1.09118015e-01f, -4.10061538e-01f, 1.38770491e-01f, 1.94330424e-01f, 2.40346021e-03f,
  1.62647709e-01f, 6.79363087e-02f, 1.04175918e-01f, -1.67201564e-01f, -2.76261985e-01f, -6.64144903e-02f, -2.09990665e-01f, -1.71341673e-01f, -2.21009523e-01f, -1.02850758e-01f,
  -4.35245335e-02f, 2.95013726e-01f, 7.61756226e-02f, 1.28174752e-01f, -1.09360188e-01f, -4.70262095e-02f, -1.25063211e-01f, -7.20394105e-02f, -1.32399872e-02f, 3.61094922e-02f,
  5.09800911e-02f, 1.88627304e-03f, 1.14578724e-01f, -1.19104572e-01f, 2.09111162e-02f, -6.15167106e-03f, 1.23230927e-01f, -7.08801523e-02f, 1.13502026e-01f, -7.70760402e-02f,
  -1.40755385e-01f, -1.40731066e-01f, 1.14745587e-01f, -2.45211720e-01f, 3.80245969e-02f, -4.73894440e-02f, 2.34605912e-02f, -5.74255511e-02f, 3.27097112e-03f, 2.09831342e-01f,
  1.88316733e-01f, -1.04189426e-01f, -6.61431402e-02f, 7.48975202e-02f, 4.33209017e-02f, -7.43187964e-02f, -1.95924744e-01f, -3.02154906e-02f, -7.56787285e-02f, -7.43113682e-02f,
  -2.71148980e-01f, 1.34112641e-01f, 1.62959978e-01f, -5.90841584e-02f, -1.96490094e-01f, -8.06032792e-02f, -9.43509042e-02f, -1.89762592e-01f, -1.28900811e-01f, 8.77857581e-02f,
  -1.45980179e-01f, -2.17472717e-01f, -1.09385334e-01f, 9.83145759e-02f, -3.80385891e-02f, 5.05963974e-02f, 7.98774511e-02f, 2.29447410e-01f, 1.78294152e-01f, 3.51063572e-02f,
  -1.07792877e-01f, 6.90682307e-02f, -1.05662756e-01f, 9.72229987e-02f, 1.32934883e-01f, -7.55029870e-03f, -4.93332818e-02f, 1.56641558e-01f, -1.70062065e-01f, -1.12766363e-01f,
  -4.01741937e-02f, 6.46746308e-02f, -7.58497193e-02f, 7.29250312e-02f, 5.44131286e-02f, 1.27961263e-01f, 9.96564329e-02f, -1.28077671e-01f, -1.14337467e-02f, -9.12963040e-03f,
  1.40480369e-01f, 5.51387062e-03f, 3.49344797e-02f, 2.32765935e-02f, -1.81977198e-01f, -4.08894978e-02f, -2.71734018e-02f, -1.36682745e-02f, 2.45822910e-02f, -2.39493340e-01f,
  -9.95390415e-02f, -2.94384807e-01f, -6.50747865e-02f, 1.70513764e-01f, 8.28799456e-02f, -7.73648396e-02f, -1.32058263e-01f, 2.10790813e-01f, 1.89210817e-01f, -9.21906065e-03f,
  -3.03657036e-02f, 1.33306738e-02f, -1.93929717e-01f, 1.30836070e-01f, -1.44283354e-01f, 2.47516513e-01f, 1.51689321e-01f, 1.56108618e-01f, 4.30802116e-03f, 4.54572365e-02f,
  -1.79823324e-01f, -3.04743201e-01f, -2.38669179e-02f, 2.46672854e-01f, -6.30775765e-02f, -1.61895797e-01f, -2.19877005e-01f, 3.74543108e-02f, -1.04188405e-01f, 3.40893818e-03f,
  -1.08446710e-01f, 3.31845023e-02f, 1.12079792e-01f, -8.88859574e-03f, 3.65523621e-03f, 2.01824635e-01f, -6.73928261e-02f, -4.13724892e-02f, 1.18211001e-01f, 1.30486339e-02f,
  -7.06247166e-02f, -5.73660694e-02f, -6.03104383e-02f, -8.79598632e-02f, 5.64219207e-02f, 1.41572222e-01f, -8.20143819e-02f, -3.87107655e-02f, 1.38764894e-02f, -2.65156408e-03f,
  2.07930043e-01f, -4.86944616e-03f, 9.84713510e-02f, -7.25899413e-02f, -8.34491849e-02f, -2.38454565e-02f, -5.54174930e-02f, -1.11237597e-02f, -1.09866850e-01f, -9.26339030e-02f,
  -1.87486604e-01f, 1.56507596e-01f, -1.39719859e-01f, 5.24336211e-02f, 2.92611837e-01f, 1.54645398e-01f, 1.73319295e-01f, -1.23076625e-01f, -5.55612473e-03f, -7.98890181e-03f,
  3.82738411e-02f, 1.49196833e-01f, 2.46229451e-02f, 1.02173202e-01f, 1.80837378e-01f, -2.13493824e-01f, -8.92162621e-02f, 5.72868250e-02f, 1.30265340e-01f, 2.52350550e-02f,
  1.70233604e-02f, -2.56412476e-01f, -7.44835958e-02f, -2.96989202e-01f, -1.19011305e-01f, 5.64556569e-03f, 1.52699677e-02f, -3.71909849e-02f, -1.94596108e-02f, 2.43852306e-02f,
  -1.67581126e-01f, -6.85217455e-02f, -8.71467218e-02f, -1.64965808e-01f, -6.40395358e-02f, -1.72707424e-01f, 5.19868173e-02f, -2.63462424e-01f, 1.15170917e-02f, 1.49625361e-01f,
  2.80970544e-01f, -5.95990233e-02f, 2.17053443e-02f, -1.13912724e-01f, -1.24858968e-01f, -5.87829985e-02f, -1.45767495e-01f, -8.90515745e-02f, 9.31063592e-02f, 3.00716329e-02f,
  -1.60000741e-01f, -3.97769064e-02f, -8.63012597e-02f, -1.51582360e-01f, 4.07074858e-03f, -1.10139370e-01f, -5.38064092e-02f, -1.53033346e-01f, 9.99598578e-02f, -7.36373439e-02f,
  1.23193607e-01f, -5.17279916e-02f, -1.25438347e-01f, -1.99885461e-02f, -7.62269869e-02f, 5.78527115e-02f, -2.13707164e-01f, -5.24365492e-02f, -7.32321218e-02f, -1.99986342e-02f,
  -2.10976601e-02f, -4.07901742e-02f, 1.87186882e-01f, -2.41981626e-01f, -3.87461074e-02f, 1.54680789e-01f, 1.44200251e-01f, -9.89808608e-03f, 8.43452066e-02f, -1.44905537e-01f,
  1.16880730e-01f, 8.91435742e-02f, -1.23102799e-01f, 3.61191742e-02f, 9.30374786e-02f, 1.52633339e-02f, 1.63789690e-02f, 1.31331131e-01f, 1.10691264e-01f, -8.51182118e-02f,
  -4.09863114e-01f, 1.85916096e-01f, -1.30322039e-01f, -2.15618089e-01f, -7.04875588e-02f, 7.84743503e-02f, -5.08756042e-02f, -2.19504625e-01f, -1.56152084e-01f, -2.73918390e-01f,
  -2.70682782e-01f, 1.73020780e-01f, -1.52534187e-01f, -1.47761824e-03f, -2.00513244e-01f, -2.94083536e-01f, -1.27109304e-01f, -1.36937857e-01f, -8.99574384e-02f, 3.03681884e-02f,
  -1.39201820e-01f, 9.51321945e-02f, -1.05736576e-01f, 2.88020261e-02f, -1.20568901e-01f, -1.50436893e-01f, 5.24532050e-02f, -1.41588181e-01f, 2.72850934e-02f, 8.95985588e-02f,
  5.32163819e-03f, 8.23657438e-02f, -4.36368994e-02f, -6.48101717e-02f, 6.67450279e-02f, -1.70090690e-01f, 3.34128998e-02f, 3.77313010e-02f, -2.17407539e-01f, -6.64867014e-02f,
  -1.78871870e-01f, 1.97308242e-01f, 1.79660186e-01f, -8.28944519e-03f, 7.38786708e-04f, 1.12489276e-01f, 1.46923929e-01f, -1.90723807e-01f, 2.17780657e-02f, 3.09078228e-02f,
  -2.40224048e-01f, 3.61363441e-02f, 7.08184913e-02f, -1.55595481e-01f, 9.48187485e-02f, -6.74019009e-02f, -4.04459983e-02f, -1.36819318e-01f, -2.25418478e-01f, -9.17051136e-02f,
  -9.60580911e-03f, -1.64071992e-01f, -2.51108836e-02f, -4.55843052e-03f, -2.90361494e-01f, 6.33250400e-02f, -1.03631020e-01f, 1.50293842e-01f, 5.59709705e-02f, 1.91116646e-01f,
  -9.37265158e-02f, -1.79026827e-01f, 1.84770286e-01f, 1.40175313e-01f, -1.09314121e-01f, -4.84353974e-02f, 1.15059622e-01f, -1.62428841e-01f, 2.20342085e-01f, -1.41195267e-01f,
  1.16670825e-01f, -1.37579804e-02f, -3.69625445e-03f, -3.70678306e-02f, -2.02143401e-01f, 2.29557324e-02f, -6.84662024e-03f, 1.31084612e-02f, -5.78955524e-02f, 1.50471125e-02f,
  -8.32429454e-02f, -6.88529909e-02f, 1.51894957e-01f, -1.75324455e-01f, 5.62724844e-02f, -7.81080648e-02f, 8.88987333e-02f, -1.26965806e-01f, 1.63185030e-01f, -9.81491655e-02f,
  -3.00584406e-01f, -1.49424672e-01f, -5.44362590e-02f, -1.36805385e-01f, 2.27757189e-02f, -2.69205645e-02f, 1.25157461e-01f, 4.67997454e-02f, -1.14391536e-01f, -6.47836775e-02f,
  1.67488530e-01f, -3.11881453e-01f, 1.56720039e-02f, 1.26716122e-01f, 9.03076977e-02f, -1.06365554e-01f, 1.07290395e-01f, -1.44915476e-01f, 1.15037732e-01f, -6.24330379e-02f,
  -1.31394953e-01f, 7.13510141e-02f, 9.03646350e-02f, -2.43156046e-01f, -3.46147209e-01f, -1.04885250e-01f, -7.70839006e-02f, -1.48405686e-01f, -3.33679557e-01f, 2.64551222e-01f,
  -1.47130206e-01f, -1.87505707e-01f, -1.08137662e-02f, 1.53824612e-01f, -1.11779697e-01f, -2.33020559e-01f, -1.60227902e-02f, 1.25259772e-01f, 6.96818903e-02f, 6.13002554e-02f,
  -1.44212872e-01f, 1.63468421e-01f, -8.80494155e-03f, -1.11610927e-01f, 1.65394425e-01f, -2.03782450e-02f, -2.07902631e-04f, -3.52508388e-02f, 5.91144823e-02f, -1.19326524e-01f,
  7.42164329e-02f, 1.36003852e-01f, 8.25291499e-02f, 2.13645145e-01f, 8.11775178e-02f, -4.96211685e-02f, 1.29129563e-03f, -4.30653654e-02f, 1.15332596e-01f, -3.96501161e-02f,
  1.08226210e-01f, -2.22367924e-02f, -8.54935348e-02f, 1.20242164e-02f, -9.93291661e-02f, -5.99061288e-02f, -9.71865505e-02f, 1.09196501e-02f, 4.18999866e-02f, -2.11674839e-01f,
  1.25195354e-01f, 2.71983002e-03f, 1.67027861e-01f, 2.57266895e-03f, -4.20462675e-02f, -7.46857524e-02f, 1.27324864e-01f, 1.31983742e-01f, 1.29425660e-01f, 1.47332400e-01f,
  1.23403296e-01f, -8.48908350e-02f, -2.95092501e-02f, 7.33769685e-02f, 2.48290256e-01f, 1.53898597e-01f, 7.80317858e-02f, -3.77079621e-02f, 8.57410505e-02f, -1.23531997e-01f,
  -1.67773455e-01f, -1.29897758e-01f, 1.62916213e-01f, 8.96373540e-02f, 1.52685508e-01f, -7.89786577e-02f, -2.13914916e-01f, -2.94025511e-01f, -1.18015386e-01f, -4.73698154e-02f,
  -1.67590640e-02f, -7.42968619e-02f, 1.86217546e-01f, -2.46336207e-01f, -9.35848728e-02f, 2.10210308e-01f, -8.38749781e-02f, 7.49228969e-02f, -1.09616540e-01f, -3.14844251e-02f,
  2.94301398e-02f, -9.06049758e-02f, 1.54596463e-01f, 5.92512935e-02f, -2.66690496e-02f, -5.50874248e-02f, -8.81513208e-03f, 2.43832693e-02f, 1.12777472e-01f, -4.49323729e-02f,
  6.10268395e-03f, 1.55670136e-01f, -2.50178594e-02f, -6.93978444e-02f, -1.92924395e-01f, 2.08603553e-02f, -9.56948921e-02f, 5.82310259e-02f, 1.77754819e-01f, 1.92987230e-02f,
  -4.35283408e-02f, 9.82014462e-02f, -1.27026886e-01f, 1.38436735e-01f, 3.72191146e-02f, 1.33025423e-01f, 8.08346868e-02f, -1.67660173e-02f, -1.39831202e-02f, 1.52834401e-01f,
  3.27697061e-02f, -3.00040040e-02f, -1.53796384e-02f, 6.94477186e-02f, 2.15723768e-01f, 2.43548341e-02f, 5.27543686e-02f, 6.16807826e-02f, 1.03944987e-01f, -5.23272902e-02f,
  -1.86808154e-01f, 1.97182503e-02f, 4.48291861e-02f, 3.33886147e-02f, 5.25080748e-02f, 1.09745651e-01f, 8.91716406e-02f, -1.60652056e-01f, -5.34428805e-02f, 1.58783078e-01f,
  1.60858035e-01f, -5.31198643e-02f, 3.78970467e-02f, -7.84524009e-02f, 3.66445072e-02f, -1.57445028e-01f, -2.37890109e-01f, -2.65023932e-02f, 6.29476979e-02f, -7.40115196e-02f,
  4.81595211e-02f, 6.43023923e-02f, 1.00517660e-01f, -7.94498771e-02f, -1.61698505e-01f, 3.52616571e-02f, -1.21604584e-01f, -9.89983156e-02f, 5.16354702e-02f, 4.54599736e-03f,
  -2.52646059e-01f, -1.69833615e-01f, -1.66487947e-01f, -1.30596489e-01f, 6.70313537e-02f, 1.59065947e-02f, -4.93985415e-02f, -1.10007390e-01f, 6.52453005e-02f, -6.45350367e-02f,
  1.71501294e-01f, -1.22921243e-01f, -4.70737740e-02f, 4.57776152e-02f, -1.19543068e-01f, 9.20055360e-02f, -9.81853828e-02f, 4.01972942e-02f, 6.71120957e-02f, -1.12292664e-02f,
  -1.01570264e-02f, -3.78169343e-02f, 1.55337453e-01f, -3.08379620e-01f, 1.29150867e-01f, 2.63378024e-02f, -3.67041007e-02f, -2.85102520e-02f, -1.14085868e-01f, -1.33551881e-01f,
  2.85047621e-01f, 6.69843778e-02f, -1.71689615e-01f, -9.95427370e-02f, 5.52018583e-02f, -3.81247066e-02f, -1.42250657e-01f, 1.77638784e-01f, 2.22399294e-01f, 2.16028076e-02f,
  -3.64570230e-01f, 2.25580752e-01f, 9.75538604e-03f, -8.38821679e-02f, 1.10059224e-01f, 1.60471395e-01f, -2.11101145e-01f, -2.25645453e-01f, -9.11558121e-02f, -5.36727253e-03f,
  -3.71016532e-01f, 5.52060008e-02f, -2.50292897e-01f, -1.34034216e-01f, 6.16163500e-02f, -2.63921291e-01f, 6.10934012e-03f, -8.67588297e-02f, 1.97621714e-02f, 1.39725536e-01f,
  -8.98335278e-02f, -1.03914879e-01f, -3.20007801e-02f, -6.88736048e-03f, 5.56863397e-02f, 8.43777657e-02f, -6.40680119e-02f, 2.08734512e-01f, -1.20462522e-01f, -3.95647325e-02f,
  -6.96928576e-02f, 1.52619615e-01f, 1.33625567e-01f, -2.60406341e-02f, -1.29872113e-01f, -6.03164546e-02f, -2.87794042e-02f, -3.58457007e-02f, 1.16998680e-01f, -1.76443070e-01f,
  -3.70052122e-02f, -3.43784690e-02f, -2.07660258e-01f, -2.23085597e-01f, -1.70505404e-01f, -7.99554661e-02f, -2.02331379e-01f, 7.96059892e-02f, -1.89778641e-01f, 1.63735777e-01f,
  2.01258987e-01f, -2.49232933e-01f, 4.85352837e-02f, 1.18260525e-01f, -1.53839812e-01f, 2.12944011e-04f, -4.37525064e-02f, 1.02073073e-01f, -3.72969471e-02f, 2.70232379e-01f,
  -1.39203414e-01f, 1.02802664e-01f, 9.46076959e-03f, -1.56297579e-01f, 1.04832195e-01f, 3.30355793e-01f, -1.84208930e-01f, -1.67287752e-01f, 3.60807229e-04f, 1.63454525e-02f,
  1.47320643e-01f, 1.87961847e-01f, 9.76107866e-02f, 8.84370820e-04f, 1.62616923e-01f, 2.61294365e-01f, 3.57906893e-02f, 2.24566311e-01f, -1.38282597e-01f, 1.50523171e-01f,
  9.45881940e-03f, 1.56008884e-01f, 7.11121410e-03f, 8.11572894e-02f, 8.81575197e-02f, 6.34673014e-02f, 1.20857559e-01f, 2.52083992e-03f, 1.30355254e-01f, 1.74187850e-02f,
  -7.77517036e-02f, -1.04461014e-01f, 2.04732314e-01f, 1.25054702e-01f, 3.41235958e-02f, -3.72302644e-02f, 1.56631529e-01f, 9.63032842e-02f, 1.62939489e-01f, 1.19040012e-01f,
  2.26501320e-02f, 4.00673077e-02f, 1.34329259e-01f, -1.50402298e-03f, 1.59109294e-01f, -3.10734771e-02f, -1.08103976e-01f, -7.52977878e-02f, 1.17281703e-02f, 2.70262033e-01f,
  3.39442760e-01f, -2.03352273e-01f, 1.18787356e-01f, -6.33867979e-02f, -1.30710071e-02f, 2.92779552e-03f, -1.22766629e-01f, 8.64043646e-03f, 4.43640575e-02f, -6.37408718e-02f,
  -4.17141527e-01f, 5.83436377e-02f, 1.51773348e-01f, -4.19138186e-02f, -1.73518762e-01f, 2.92904556e-01f, -7.18292445e-02f, -1.88221056e-02f, -1.98593020e-01f, 8.62121433e-02f,
  -1.18295208e-01f, -9.27460864e-02f, 1.27598166e-01f, 1.81822985e-01f, -3.35873924e-02f, 9.68884081e-02f, 6.00652136e-02f, 1.79963231e-01f, -1.26298442e-01f, 1.90017611e-01f,
  -2.40912199e-01f, -2.28561088e-01f, -4.99154069e-02f, 8.39702860e-02f, 9.45888609e-02f, 8.41083750e-02f, 3.41103971e-03f, 9.21588540e-02f, -7.46033043e-02f, 9.43587534e-03f,
  -6.60087764e-02f, -6.70937970e-02f, 6.99176034e-03f, 5.76451421e-04f, -4.40256521e-02f, -3.16929817e-02f, 1.17242783e-01f, -2.08765373e-01f, -3.21947411e-02f, -1.12817384e-01f,
  1.22642785e-01f, 3.49968858e-02f, -1.22962641e-02f, -1.04393460e-01f, -1.35343775e-01f, -5.24208397e-02f, 4.77368757e-02f, -6.55793846e-02f, -3.15608941e-02f, -1.51948333e-01f,
  -7.11029489e-03f, -1.63670540e-01f, 4.24192138e-02f, 3.13035920e-02f, 9.05785635e-02f, -2.27456480e-01f, -7.55656809e-02f, 2.47641966e-01f, 9.72269326e-02f, -5.68600446e-02f,
  -1.24042861e-01f, -5.61418161e-02f, 1.68166461e-03f, -3.11347912e-03f, -7.87465125e-02f, 1.40784070e-01f, 1.69926867e-01f, -1.20354272e-01f, -1.84939697e-01f, -1.31245643e-01f,
  -1.40752569e-01f, -1.95018634e-01f, -2.01824546e-01f, 2.14129612e-01f, -2.88188979e-02f, -1.67260215e-01f, -1.12342343e-01f, 3.47402543e-02f, -1.58063602e-02f, -4.75417674e-02f,
  4.82048504e-02f, 5.09731025e-02f, 4.89337705e-02f, 1.52346522e-01f, -1.04060583e-01f, 9.54466313e-02f, -5.43388873e-02f, -7.46542290e-02f, -9.43542793e-02f, -9.13602486e-02f,
  -7.71842748e-02f, 3.30220126e-02f, -1.04915500e-01f, -7.57902190e-02f, -1.29773002e-02f, 1.90841500e-02f, -1.31751284e-01f, 1.34370387e-01f, -7.95926005e-02f, 8.73676315e-02f,
  -1.87726781e-01f, -7.11564422e-02f, 9.27725434e-03f, 1.73433408e-01f, -1.94607507e-02f, -3.66423242e-02f, -2.64327586e-01f, -3.21633145e-02f, 1.41452536e-01f, -2.03344272e-03f,
  -1.96760118e-01f, -2.76235975e-02f, -8.98526907e-02f, -2.16070071e-01f, 4.52436917e-02f, 8.63896757e-02f, -9.94566306e-02f, -9.15645659e-02f, -3.90173793e-01f, 1.37620032e-01f,
  -6.09343946e-02f, -2.27819029e-02f, -2.02410743e-02f, -6.67603314e-02f, 5.12767397e-03f, 1.22385724e-02f, -1.02253623e-01f, 2.27220263e-02f, 4.11775112e-01f, -2.35175565e-02f,
  7.61870891e-02f, 1.80862367e-01f, 1.23974010e-01f, -1.41622752e-01f, 2.10295454e-01f, 1.13161691e-01f, 3.20680618e-01f, -3.64873745e-02f, 3.82489711e-01f, -1.77610904e-01f,
  -1.82473451e-01f, -1.18301287e-01f, -1.67285919e-01f, -2.99004167e-02f, -1.01904817e-01f, -3.10975406e-02f, 1.62612885e-01f, -6.14827573e-02f, 4.28261887e-03f, 1.38903350e-01f,
  9.36852768e-03f, 1.07986119e-03f, 1.20979501e-02f, 6.06773375e-03f, -8.28422680e-02f, -6.07107952e-02f, -1.42554104e-01f, 6.95066005e-02f, -2.83760224e-02f, -4.65633757e-02f,
  -5.99166453e-02f, 3.26909833e-02f, -3.73845398e-02f, -3.61727104e-02f, 7.65880048e-02f, -5.27622662e-02f, -1.18627697e-01f, -1.54381663e-01f, 7.04623908e-02f, 9.32531059e-02f,
  8.67373198e-02f, -3.19134258e-02f, -1.31739706e-01f, -1.19594060e-01f, 1.16666131e-01f, -1.53401881e-01f, 1.50076628e-01f, 2.09035594e-02f, -6.14957400e-02f, -1.51555598e-01f,
  2.11238548e-01f, 1.78541169e-01f, 1.89132780e-01f, -3.38788927e-02f, -5.64515702e-02f, 5.91019168e-02f, 2.11991053e-02f, 1.20786026e-01f, 5.15159182e-02f, -7.80024752e-02f,
  -1.70327753e-01f, 4.12886590e-02f, -2.20018268e-01f, 1.76089063e-01f, 9.11172405e-02f, -1.39781669e-01f, 6.25404119e-02f, -3.89940068e-02f, -3.14504325e-01f, -1.39890403e-01f,
  2.53902320e-02f, -6.97063878e-02f, -1.41911179e-01f, -5.31673990e-02f, -2.56043434e-01f, -6.31913841e-02f, 6.18600957e-02f, 8.64915773e-02f, 3.69536653e-02f, 1.69628993e-01f,
  1.26233920e-01f, -9.13181007e-02f, 4.85692434e-02f, 4.26915735e-02f, -1.04622796e-01f, 7.85429925e-02f, 1.39409930e-01f, 5.46498448e-02f, 5.53266369e-02f, -1.41086072e-01f,
  -3.58607769e-02f, -1.29978806e-01f, -3.05762626e-02f, 1.28973961e-01f, 3.80942598e-03f, 9.54561830e-02f, 6.06334358e-02f, -2.47017853e-02f, 1.59198437e-02f, -1.42035708e-01f,
  1.66246980e-01f, -1.38638750e-01f, 2.75244415e-02f, 1.39606610e-01f, 1.26629397e-01f, 7.99116045e-02f, 4.07542996e-02f, -9.53416377e-02f, -6.98450441e-03f, 1.00212894e-01f,
  1.09738214e-02f, 4.00568023e-02f, 1.89025176e-03f, 1.88718475e-02f, 2.30406538e-01f, -7.10121691e-02f, 9.35635045e-02f, -2.92623462e-03f, 1.78791046e-01f, 2.14243997e-02f,
  9.61126015e-02f, -7.37973605e-04f, 2.37054348e-01f, -1.02230228e-01f, -7.68072084e-02f, 6.08788840e-02f, 6.67624325e-02f, 1.36307210e-01f, 7.30616003e-02f, -1.45196810e-01f,
  -1.05796807e-01f, -2.97662783e-02f, -1.28148526e-01f, -1.07677907e-01f, 2.20221039e-02f, -8.62133130e-02f, -7.33153298e-02f, 4.39738557e-02f, -9.47921649e-02f, -1.35991931e-01f,
  5.53874858e-02f, -5.01307659e-02f, -1.10362686e-01f, -1.16635747e-01f, 3.08857393e-02f, -1.76171347e-01f, -3.70949097e-02f, 1.35191813e-01f, -1.20580025e-01f, 5.95794339e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.70962620e-02f, 3.42798270e-02f, 3.97096127e-02f, 8.16747323e-02f, -9.52247754e-02f, 4.79450375e-02f, -4.87704650e-02f, 4.38929424e-02f, 1.48112755e-02f, -1.54453561e-01f,
  8.25907364e-02f, 1.49430474e-02f, 6.03319407e-02f, 5.62868733e-03f, -7.84627870e-02f, -3.82592790e-02f, 1.11722983e-01f, -1.00546600e-02f, 1.09635003e-01f, -9.47894529e-02f,
  -8.36559907e-02f, 1.22404145e-02f, 1.95001904e-02f, -9.52527896e-02f, 4.07679603e-02f, 2.60873705e-01f, 3.05718690e-01f, 1.14412241e-01f, -2.10009553e-02f, 8.40073824e-02f,
  4.99534309e-02f, -1.48161277e-01f, -3.93314026e-02f, 2.13981979e-02f, -1.39256552e-01f, 3.15488651e-02f, 3.53306346e-02f, -9.60958898e-02f, -1.18297311e-02f, -1.39863491e-01f,
  -1.41341379e-02f, 3.52765061e-02f, -1.67748779e-01f, -1.64829597e-01f, -7.51141533e-02f, -2.19949335e-01f, -2.14509681e-01f, 2.75059119e-02f, -1.67255968e-01f, 1.56528205e-02f,
  -3.04474365e-02f, 1.27267212e-01f, -1.44117456e-02f, 2.82653779e-01f, 2.06453186e-02f, 2.29371525e-02f, 1.68335482e-01f, 6.95978254e-02f, -4.93498147e-02f, -1.37584880e-01f,
  2.47425795e-01f, 1.92929983e-01f, 2.92982966e-01f, 1.35142639e-01f, 2.92704813e-02f, 1.42425433e-01f, 7.13994801e-02f, 1.60623819e-01f, 6.19906746e-02f, 1.20462529e-01f,
  7.84299299e-02f, -7.90767223e-02f, 5.16263768e-02f, -8.21283981e-02f, -4.64384519e-02f, -1.24517810e-02f, 9.09476727e-03f, 4.47918475e-02f, 6.07631430e-02f, 1.08774453e-01f,
  1.58478096e-01f, -6.79653045e-03f, 1.05279833e-01f, -3.24942321e-02f, 4.62554879e-02f, 7.56612420e-02f, 1.26556516e-01f, -7.29372725e-02f, 9.13436636e-02f, -1.86250340e-02f,
  -9.14245322e-02f, 1.83664821e-02f, -1.25090897e-01f, 4.78481129e-02f, 1.11883983e-01f, -1.42646298e-01f, 1.45401061e-02f, -1.66004032e-01f, -7.37796491e-03f, -1.50824457e-01f,
  -2.33525455e-01f, 7.28356242e-02f, 1.35641843e-01f, -9.38930064e-02f, -1.60102606e-01f, -1.88993737e-01f, 7.34118968e-02f, 1.21557526e-01f, -2.92762369e-02f, 2.00168848e-01f,
  1.85677677e-01f, 1.00903668e-01f, -1.73915550e-01f, -6.51002750e-02f, -8.65950994e-03f, 1.12678334e-01f, 1.66941524e-01f, 1.08340003e-01f, -5.57078868e-02f, 7.76709169e-02f,
  5.26119061e-02f, 1.75795451e-01f, 4.46203947e-02f, 2.74213672e-01f, -4.69618756e-03f, -1.19920887e-01f, -1.17370136e-01f, -1.16794370e-01f, -7.50519633e-02f, 5.42275645e-02f,
  5.68420906e-03f, 1.25028044e-01f, -5.48390597e-02f, 7.43043423e-02f, -9.62499380e-02f, 5.98528748e-03f, 7.32419863e-02f, -1.21677041e-01f, 1.22720227e-01f, 2.66726371e-02f,
  2.55925618e-02f, 9.49570239e-02f, -1.00698352e-01f, 6.70236200e-02f, 5.47289513e-02f, -2.93372828e-03f, 8.49742442e-02f, -7.83462077e-02f, -5.99222665e-04f, -6.29701838e-02f,
  -2.32597850e-02f, -8.55546296e-02f, 4.45988663e-02f, 2.25781217e-01f, 1.82088628e-01f, 8.68886113e-02f, -4.60804664e-02f, 1.52406925e-02f, 1.18536698e-02f, -6.90713823e-02f,
  -1.01763763e-01f, 2.23594867e-02f, -6.56200275e-02f, -2.13473774e-02f, 1.04902558e-01f, -1.39798373e-01f, 1.78143829e-02f, -1.34058505e-01f, -6.34971866e-03f, -7.24190921e-02f,
  -1.88613459e-01f, -1.93084717e-01f, -2.46887840e-02f, -1.41823456e-01f, -1.42418146e-01f, -3.61677515e-03f, -1.86647758e-01f, 8.92546028e-02f, -2.00801507e-01f, 1.87206462e-01f,
  4.31300588e-02f, 2.10599542e-01f, 6.30624518e-02f, 1.60843376e-02f, 2.38227472e-01f, 1.76107436e-02f, -6.36709780e-02f, -3.36306021e-02f, 2.49935150e-01f, 1.17081314e-01f,
  2.03558847e-01f, 9.51585546e-02f, 1.51018770e-02f, 1.08042069e-01f, 1.55069143e-01f, -3.72572592e-03f, 3.82558927e-02f, 1.36592105e-01f, 1.31722679e-02f, -5.97397685e-02f,
  1.14166066e-01f, -1.09635234e-01f, 5.04207686e-02f, -2.98948791e-02f, -8.16333145e-02f, 1.61536187e-01f, 7.96243846e-02f, 8.50184541e-03f, 1.08916081e-01f, 1.28171980e-01f,
  1.78171203e-01f, 3.26861888e-02f, 1.67330965e-01f, -3.91204022e-02f, 4.27430756e-02f, -1.00551257e-02f, 1.25166103e-01f, 1.84424400e-01f, -1.05685726e-01f, 1.47338882e-01f,
  -9.46346074e-02f, 1.87485255e-02f, 9.91076380e-02f, -1.38386592e-01f, 3.84557508e-02f, -9.70296040e-02f, -9.99450684e-02f, -9.39058736e-02f, -2.35113844e-01f, 6.67761564e-02f,
  1.34485960e-01f, -1.47887573e-01f, -1.89879239e-01f, -2.26578042e-01f, -7.26068318e-02f, 7.00699687e-02f, -5.90019599e-02f, -6.61658682e-03f, 8.38658866e-03f, 1.90509558e-01f,
  -5.67298196e-02f, -1.39540657e-01f, -3.51806618e-02f, 1.01596490e-01f, 2.39986271e-01f, 1.55055836e-01f, 1.07488900e-01f, 1.39793977e-01f, 9.02817398e-02f, 1.76892847e-01f,
  6.54315650e-02f, -2.12632176e-02f, 1.06258884e-01f, -1.94431201e-01f, -8.50430951e-02f, -9.21971817e-03f, -4.54572886e-02f, -1.03613205e-01f, 2.14426103e-03f, -1.50327629e-03f,
  2.36440822e-01f, 1.01269804e-01f, 1.93635851e-01f, 2.91002393e-02f, 4.22386117e-02f, 7.43394941e-02f, 8.49059224e-02f, -2.42011156e-02f, -5.12480587e-02f, 2.06905603e-01f,
  1.72291368e-01f, 1.90771505e-01f, -6.35960326e-02f, 3.00321784e-02f, -7.44038373e-02f, 1.08090527e-01f, 1.04661532e-01f, 1.63891703e-01f, -1.42485052e-02f, 1.90100774e-01f,
  -3.75463255e-03f, 1.70461729e-01f, 1.17953986e-01f, 1.23423345e-01f, 1.66603830e-02f, -2.51810491e-01f, -1.85471639e-01f, 1.01995379e-01f, 1.29626364e-01f, -2.18554959e-01f,
  -8.59139860e-02f, -1.72925331e-02f, 4.87838872e-02f, -2.40751263e-02f, 1.76764041e-01f, -8.86825994e-02f, 2.58165777e-01f, -1.63662180e-01f, -1.51660174e-01f, 1.31302625e-02f,
  9.93595347e-02f, -6.37136325e-02f, 2.71392375e-01f, 2.53138244e-01f, 6.66424558e-02f, -1.69275105e-01f, 2.40976781e-01f, 2.43863672e-01f, 1.88929304e-01f, 5.43222092e-02f,
  -6.26761699e-03f, -9.60024893e-02f, -5.90742007e-02f, -4.21330556e-02f, -1.64284147e-02f, -6.46886006e-02f, 1.48712248e-02f, -1.08553953e-01f, 1.87782869e-01f, -7.53907263e-02f,
  8.03208947e-02f, -3.88168544e-02f, 6.15438223e-02f, -1.88805014e-02f, 5.96780814e-02f, -1.34532019e-01f, 8.71780887e-02f, 1.72892883e-01f, -2.98602297e-03f, 2.32114762e-01f,
  1.50253922e-01f, 1.30468085e-01f, 4.00682129e-02f, 9.52223167e-02f, 7.52440318e-02f, -4.93911514e-03f, 8.97104070e-02f, 1.26067117e-01f, 1.19471103e-02f, 1.31858826e-01f,
  2.21132055e-01f, 6.02285936e-02f, 5.10363393e-02f, 3.38380523e-02f, -9.49804187e-02f, -1.48990288e-01f, 4.89648096e-02f, -1.17740035e-02f, 1.05007999e-01f, -1.01187907e-01f,
  -2.08430991e-01f, 1.68540701e-01f, -1.22652631e-02f, 1.40242070e-01f, 1.41213372e-01f, 1.34675905e-01f, 6.40253648e-02f, 1.34630818e-02f, -1.49682790e-01f, 1.84341401e-01f,
  2.23897621e-01f, 1.00752063e-01f, 8.38457868e-02f, 1.55475512e-01f, 2.00833589e-01f, -1.27756625e-01f, 6.73059225e-02f, -1.45583361e-01f, 1.57457337e-01f, 3.73818092e-02f,
  2.14320555e-01f, 4.46282625e-02f, -2.75004029e-01f, -1.66707337e-01f, 1.76985953e-02f, 1.93742123e-02f, -4.72585969e-02f, 1.41701037e-02f, 1.10392280e-01f, -7.55334496e-02f,
  -8.71686637e-02f, 2.42789164e-01f, 9.43764076e-02f, 6.09356016e-02f, 1.02064639e-01f, -5.81032448e-02f, 4.69510332e-02f, 7.98698573e-04f, 7.12743476e-02f, -1.25104651e-01f,
  1.17618747e-01f, 1.19105995e-01f, -4.74860370e-02f, 2.16157302e-01f, 9.97744352e-02f, 5.39880767e-02f, 7.64344707e-02f, 1.08859345e-01f, 1.68415949e-01f, -1.09256059e-01f,
  2.35302541e-02f, 1.67987525e-01f, 5.12706861e-02f, 7.09743053e-02f, 1.26256391e-01f, 1.40905023e-01f, -8.12048987e-02f, 2.29754224e-01f, -7.52846748e-02f, -1.31520525e-01f,
  -1.26445871e-02f, -7.54764825e-02f, 1.91387445e-01f, 6.21375851e-02f, 6.50257543e-02f, -4.69539352e-02f, 1.33746833e-01f, 1.91546604e-01f, 3.45348492e-02f, 1.37980103e-01f,
  2.23454982e-01f, -1.09663859e-01f, -4.23459001e-02f, 2.17744276e-01f, 2.50760727e-02f, 1.02234587e-01f, 4.86118942e-02f, 6.80237934e-02f, 1.21331282e-01f, 6.38703033e-02f,
  -5.95754646e-02f, -1.95595324e-01f, -8.73495191e-02f, 1.53661609e-01f, 3.70319188e-02f, -5.60678430e-02f, -9.08544585e-02f, -7.63576180e-02f, -9.05205607e-02f, -1.77191515e-02f,
  -9.20694380e-04f, -1.14212297e-01f, -1.70840293e-01f, -8.42079744e-02f, -6.33332655e-02f, 1.34830375e-03f, -1.24330856e-01f, -3.80709209e-02f, 1.10476308e-01f, 1.34050399e-01f,
  5.85884750e-02f, 1.10194556e-01f, -6.73432499e-02f, -8.52889344e-02f, 1.76835805e-01f, 1.29300714e-01f, 1.42289028e-01f, 2.20171884e-01f, 9.74772125e-02f, 5.98994829e-02f,
  1.36749566e-01f, 3.22900340e-02f, 3.90898250e-02f, 5.67104928e-02f, 2.09126979e-01f, 6.23422861e-02f, 3.35911885e-02f, 9.58816186e-02f, 6.92219799e-03f, 1.11364171e-01f,
  2.06241813e-02f, 4.51311991e-02f, 6.19784705e-02f, -2.87116051e-01f, -1.50722608e-01f, -2.86510706e-01f, 1.57227293e-02f, 3.79595943e-02f, -3.69560788e-03f, -3.75679918e-02f,
  -6.25209063e-02f, 2.24369422e-01f, 1.60736606e-01f, -1.29845804e-02f, -8.88096914e-03f, 8.57304484e-02f, -1.46521449e-01f, 1.18267789e-01f, -6.72419518e-02f, 1.26554832e-01f,
  1.82156369e-01f, 1.33761704e-01f, -6.86961273e-03f, -7.82676339e-02f, 6.32208027e-03f, -2.63872564e-01f, 2.98088342e-02f, 2.88143069e-01f, 1.97870523e-01f, -1.91324756e-01f,
  -2.57422000e-01f, -8.88111442e-02f, -5.29955588e-02f, -2.88153123e-02f, -1.04468465e-02f, 5.08961752e-02f, 8.62340331e-02f, 3.10094585e-03f, -1.05107620e-01f, 3.10506195e-01f,
  9.28468034e-02f, -4.09865752e-02f, -6.27088100e-02f, 5.18775731e-02f, 2.77427845e-02f, 1.01093881e-01f, 8.13370943e-02f, 9.40667763e-02f, 9.62978452e-02f, 1.73350886e-01f,
  5.14452420e-02f, -9.70479697e-02f, 7.50075728e-02f, 4.30225953e-02f, 6.62272982e-03f, 1.79619659e-02f, 1.37394769e-02f, 1.40876293e-01f, 1.63715780e-01f, -3.21782678e-02f,
  9.23935026e-02f, 5.29345125e-03f, -7.20154941e-02f, 2.51481985e-03f, 5.65500334e-02f, 3.76562029e-02f, 1.49219632e-01f, 1.36260465e-01f, 1.91919684e-01f, 1.35793477e-01f,
  -1.15468957e-01f, 4.66300026e-02f, -5.61072454e-02f, -2.51425564e-01f, 1.05022803e-01f, -1.13351867e-01f, -1.14556774e-01f, -1.22437008e-01f, -1.70166716e-01f, -8.48356932e-02f,
  1.85947835e-01f, -1.24376312e-01f, -3.69686745e-02f, -8.61843750e-02f, 6.38744757e-02f, -1.36150584e-01f, -9.62435901e-02f, -5.83262667e-02f, 4.15340774e-02f, 1.85627639e-01f,
  -1.61303908e-01f, -1.00470684e-01f, 8.34205076e-02f, 1.39195085e-01f, 1.81814879e-01f, 1.78305328e-01f, 7.02153658e-03f, 5.41989021e-02f, 1.11021355e-01f, 1.31117865e-01f,
  5.98212844e-03f, -2.39520054e-02f, 7.35004246e-02f, 6.57480732e-02f, 2.42264003e-01f, 1.58650912e-02f, 6.66185617e-02f, -2.92355369e-04f, 1.19988821e-01f, 6.57949522e-02f,
  1.67074606e-01f, 1.42212078e-01f, 2.13678882e-01f, 5.84380925e-02f, -2.03032177e-02f, 1.18354954e-01f, 1.09744385e-01f, 1.14028260e-01f, 2.15220228e-02f, 3.67961749e-02f,
  2.05280900e-01f, 1.45611659e-01f, 1.74950764e-01f, -4.81363609e-02f, 8.78173336e-02f, 8.39103162e-02f, 4.08276916e-02f, 1.21105164e-01f, -1.14417709e-01f, 1.85572520e-01f,
  1.42684660e-03f, -1.57545313e-01f, 2.01426428e-02f, 9.53873247e-02f, -1.47375196e-01f, -7.55033689e-03f, -7.77821476e-03f, -2.19200224e-01f, 1.53087541e-01f, -4.79249582e-02f,
  -7.69857466e-02f, -4.99770977e-02f, -2.40123346e-01f, 2.71633919e-02f, 2.74346113e-01f, 3.30428258e-02f, 7.58929625e-02f, -1.47437602e-01f, 1.36110798e-01f, 1.29080996e-01f,
  -5.14100827e-02f, 1.71792544e-02f, 1.85803369e-01f, 1.63889632e-01f, -1.08694494e-01f, 8.11852515e-02f, 4.42457378e-01f, 2.33259574e-02f, 6.75157234e-02f, 5.54351807e-02f,
  -5.33064753e-02f, -1.60613537e-01f, -1.00962117e-01f, -3.30837280e-03f, -4.36846986e-02f, 7.59099200e-02f, -7.54868686e-02f, -1.38075769e-01f, 1.02349222e-01f, -1.18484549e-01f,
  -5.28275780e-02f, 4.82044481e-02f, 1.08101606e-01f, 9.21870098e-02f, 6.69220909e-02f, -2.83571538e-02f, -7.90954605e-02f, 9.91758425e-03f, 8.88104215e-02f, 4.98232320e-02f,
  -1.05401240e-02f, 5.69710843e-02f, -1.32411674e-01f, 6.16898835e-02f, -4.77863066e-02f, 6.51030755e-03f, 6.05066903e-02f, 2.89045703e-02f, 2.51403153e-02f, 4.83626388e-02f,
  9.25763771e-02f, -8.84789787e-03f, 1.10187300e-01f, -9.15732980e-03f, 1.49713561e-01f, -7.10217059e-02f, -2.56083220e-01f, -1.33804262e-01f, -7.77924061e-02f, 4.94424775e-02f,
  -1.81434005e-01f, 1.39252394e-01f, -1.42542019e-01f, -8.48245695e-02f, 1.65836215e-02f, -9.07418877e-02f, -1.74535975e-01f, 2.32004538e-01f, -1.35289147e-01f, 4.95727025e-02f,
  -2.09116507e-02f, -6.09046966e-02f, 4.99556214e-02f, 1.60389781e-01f, 1.91934764e-01f, 6.22406304e-02f, 2.54705288e-02f, 8.26109052e-02f, 1.83227390e-01f, -1.29316419e-01f,
  4.22456600e-02f, -6.75653592e-02f, 1.03282854e-02f, -3.22037302e-02f, 1.70655012e-01f, 1.27680689e-01f, 3.95258665e-02f, 1.22373275e-01f, 6.15969338e-02f, 1.69292375e-01f,
  1.56823903e-01f, -1.11147374e-01f, -2.10831255e-01f, 1.92598607e-02f, 1.40854880e-01f, 2.17132941e-01f, -2.98192818e-02f, -9.13374498e-02f, 1.66693494e-01f, 2.37227008e-01f,
  -8.12145770e-02f, -4.86872755e-02f, 1.53211966e-01f, -1.04769245e-01f, 8.82022381e-02f, 6.82548359e-02f, 1.11032888e-01f, 2.47825593e-01f, 4.19056453e-02f, -8.27421844e-02f,
  -5.12600951e-02f, 1.40335128e-01f, 2.45350733e-01f, 4.95683178e-02f, 1.63804159e-01f, 1.25981942e-02f, 1.47946551e-01f, 1.80149779e-01f, 1.84200719e-01f, 1.07062712e-01f,
  5.60801104e-02f, 1.62591878e-02f, 2.64343798e-01f, 6.58619702e-02f, 2.76135057e-01f, 9.35168490e-02f, 2.74864793e-01f, 4.24049161e-02f, 4.99814190e-02f, 2.58218437e-01f,
  9.74367186e-02f, 2.38136598e-03f, -9.39505324e-02f, 7.32814595e-02f, -1.81939468e-01f, 3.83760929e-02f, -1.55960292e-01f, -2.61181295e-01f, -2.31142025e-02f, 1.49690449e-01f,
  -2.49807864e-01f, -7.80386701e-02f, 3.55557129e-02f, -3.10816437e-01f, -3.46348137e-01f, 2.29823634e-01f, 1.99340940e-01f, 1.57402366e-01f, 1.78701892e-01f, 1.98495731e-01f,
  1.89734861e-01f, 1.82680581e-02f, -1.00190848e-01f, -2.36496150e-01f, -1.42755825e-02f, -1.15607336e-01f, -1.37584746e-01f, 1.71173424e-01f, -9.00080502e-02f, 1.79703429e-01f,
  1.40083045e-01f, 4.84665371e-02f, 9.50446278e-02f, 7.35519454e-02f, -6.19401634e-02f, 1.20006362e-02f, 4.77478318e-02f, 1.15276471e-01f, -1.04527110e-02f, 9.79474187e-02f,
  -8.34839270e-02f, 8.09164122e-02f, -1.06491905e-03f, -7.82509893e-02f, 5.50110787e-02f, -3.96245363e-04f, 6.53054267e-02f, 5.56926541e-02f, 1.69584662e-01f, 1.43274039e-01f,
  2.12547407e-01f, -1.10053375e-01f, 1.39281666e-02f, -2.06796959e-01f, -2.38638416e-01f, -1.62429586e-01f, -1.20326700e-02f, 1.94656268e-01f, -1.80176888e-02f, 2.95299798e-01f,
  -2.41801083e-01f, 2.99710035e-02f, 1.66751631e-02f, -2.87925415e-02f, -1.47599906e-01f, 2.08654955e-01f, -2.10612699e-01f, 1.03850532e-02f, 3.99117880e-02f, 4.53340709e-02f,
  -4.75536138e-02f, 2.86300957e-01f, 3.15408558e-01f, 1.47595629e-01f, 8.04124326e-02f, -1.20346740e-01f, 2.22199738e-01f, 3.04211164e-03f, -1.44941062e-02f, -1.12898067e-01f,
  -1.43329576e-01f, -4.99549285e-02f, 1.10512085e-01f, 1.01250008e-01f, 1.10953838e-01f, 1.34111330e-01f, 1.28203079e-01f, 8.93439725e-02f, 1.27574980e-01f, -1.51367247e-01f,
  -1.70334890e-01f, 1.72630057e-01f, 1.53875828e-01f, 2.14329183e-01f, 8.48643761e-03f, 6.68821260e-02f, 6.03207015e-02f, 7.35044330e-02f, 7.66271800e-02f, 5.64751886e-02f,
  1.73283800e-01f, -3.12584266e-02f, 1.89429522e-02f, -2.29410268e-03f, 3.20183337e-02f, 1.19188223e-02f, 3.57380025e-02f, -2.38944944e-02f, 3.68337333e-02f, 8.61196145e-02f,
  1.92670375e-01f, 4.02198769e-02f, 6.18720949e-02f, 1.73981469e-02f, 2.15751350e-01f, -6.78718910e-02f, 1.04556039e-01f, -1.43448994e-01f, -1.96165234e-01f, -1.72125578e-01f,
  -5.27925091e-03f, 1.72755972e-01f, 1.85029179e-01f, -5.67958057e-02f, 7.02846870e-02f, 3.96694168e-02f, 3.89382318e-02f, -2.56269909e-02f, -2.09960863e-01f, 9.75011066e-02f,
  -1.23132378e-01f, 8.53996910e-03f, -3.49275827e-01f, 1.16062835e-02f, 2.06052065e-02f, -9.91344973e-02f, -4.77459580e-02f, 1.32950157e-01f, -1.83751598e-01f, 1.44359199e-02f,
  -1.62759811e-01f, -8.38130340e-03f, -1.59409136e-01f, -1.29553005e-01f, -3.62939239e-02f, 9.56921056e-02f, 1.05298340e-01f, 7.85589889e-02f, 5.80919348e-02f, 1.14943616e-01f,
  7.92902038e-02f, 4.58091013e-02f, -2.43441015e-02f, -4.01766673e-02f, -1.72239527e-01f, 1.07160918e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  7.18500977e-03f, 5.61124086e-03f, 6.95656519e-03f, 1.14205410e-03f, 1.35787234e-01f, 1.49328917e-01f, 1.47562340e-01f, 1.47954062e-01f, 1.11757286e-01f, 1.36014894e-01f,
  -1.56159056e-02f, 1.92374304e-01f, -1.18097886e-02f, 1.51109636e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.09568758e-02f, 9.14630145e-02f, -2.14792769e-02f, -5.53143211e-03f, 3.72153074e-02f, 2.86278632e-02f, -6.49190098e-02f, -7.09148720e-02f, -1.04303006e-03f, -5.69656938e-02f,
  3.01244091e-02f, -3.83452363e-02f, 1.11484416e-02f, -4.10846360e-02f, 8.14009681e-02f, -1.07280150e-01f, -4.33934573e-03f, 1.25774354e-01f, 5.15857413e-02f, -4.87821661e-02f,
  4.72781286e-02f, -1.70775224e-02f, -4.50835265e-02f, -1.63753405e-02f, 5.36562018e-02f, 2.27787510e-01f, 1.71608642e-01f, 2.16094375e-01f, 1.00065134e-01f, 9.65440050e-02f,
  3.95729840e-02f, 8.21658969e-02f, -3.00742947e-02f, 1.81479320e-01f, 1.90550715e-01f, -2.29771987e-01f, -2.93825299e-01f, 4.13705185e-02f, -1.47008553e-01f, 7.46692643e-02f,
  -2.99526125e-01f, -2.40253527e-02f, 1.89013734e-01f, -1.97429687e-01f, -2.42304042e-01f, 1.85712557e-02f, -2.31679276e-01f, -5.19562177e-02f, -1.17129572e-01f, -9.88559648e-02f,
  -1.50877098e-02f, 6.21706806e-03f, 2.60652266e-02f, 1.51361063e-01f, 1.35793924e-01f, 7.15335980e-02f, 2.69570202e-02f, -2.31887922e-01f, 2.63115112e-02f, 6.12263102e-03f,
  -2.88636563e-03f, 1.34778380e-01f, 2.70677265e-02f, -9.96001884e-02f, -7.76296202e-03f, 2.65903417e-02f, 1.57332048e-01f, -3.44208889e-02f, -1.02051005e-01f, -4.78910282e-03f,
  -1.32400304e-01f, 9.96667817e-02f, 1.63456257e-02f, -1.73582435e-02f, 9.16040130e-03f, -4.07188460e-02f, 8.51717591e-02f, -2.32729707e-02f, -5.92212677e-02f, -3.81457992e-02f,
  -3.91933583e-02f, -2.97133029e-02f, -1.07457675e-01f, 2.76449416e-02f, -7.72769284e-03f, 3.98057587e-02f, 2.12649927e-02f, -4.38634939e-02f, -7.61850402e-02f, -2.53086150e-01f,
  8.46140180e-03f, -1.07661895e-01f, 1.75066352e-01f, 8.54599550e-02f, -5.38384877e-02f, -1.92252576e-01f, -1.89040780e-01f, 5.50849549e-02f, 2.16525212e-01f, -1.32776052e-01f,
  6.51258742e-03f, 2.61052832e-04f, 1.14318959e-01f, -3.63901369e-02f, -1.10765614e-01f, 3.52036245e-02f, 1.54622406e-01f, 4.08259500e-03f, 1.50168642e-01f, -2.07277760e-02f,
  -3.22347954e-02f, -1.26734674e-01f, 1.66210428e-01f, 1.03090182e-01f, -1.16149150e-01f, -1.54741719e-01f, 1.08635770e-02f, -4.97219563e-02f, -1.23624541e-01f, 1.14615835e-01f,
  1.41118795e-01f, 4.29606065e-02f, -2.24746272e-01f, -2.35459521e-01f, 3.92549224e-02f, 1.30868733e-01f, 3.89084704e-02f, 5.80633469e-02f, 1.55346189e-02f, 8.78188759e-03f,
  7.91015774e-02f, -2.45937612e-03f, -1.62357464e-01f, -8.65568817e-02f, -6.64212480e-02f, 4.00197320e-02f, 2.25293264e-02f, -5.23611866e-02f, 1.17004886e-02f, 2.15586852e-02f,
  6.68135136e-02f, 8.71273037e-03f, -2.18779203e-02f, -1.61574725e-02f, -3.06254532e-02f, 1.55396145e-02f, -1.29257515e-01f, 4.12059054e-02f, 1.18520625e-01f, 3.53122987e-02f,
  -4.37921211e-02f, -2.25435831e-02f, 3.59064043e-02f, -2.79733628e-01f, -4.52067181e-02f, 4.99764383e-02f, 1.16769224e-01f, 2.67145168e-02f, 9.01409760e-02f, -1.11103758e-01f,
  -1.56514943e-01f, -1.14609050e-02f, 2.47524343e-02f, -1.42850503e-01f, 1.80895761e-01f, 1.37292266e-01f, -9.03198775e-03f, -7.18173608e-02f, -1.10457063e-01f, 1.92173660e-01f,
  9.70656872e-02f, 2.40009488e-03f, 6.27781004e-02f, -4.66270298e-02f, 2.32434515e-02f, 8.34043548e-02f, 1.02870397e-01f, 6.55367449e-02f, -3.74475494e-02f, -1.21780209e-01f,
  -7.74919465e-02f, -2.06871673e-01f, 9.90524702e-03f, 9.98011753e-02f, 9.70889442e-03f, 5.88982180e-02f, -1.18680790e-01f, -5.76178320e-02f, 8.74788314e-02f, 6.22714981e-02f,
  9.42455903e-02f, 1.04725370e-02f, -6.59425333e-02f, -3.84099949e-05f, 9.61348489e-02f, 4.80394950e-03f, 3.51377539e-02f, 5.49773090e-02f, -5.38481437e-02f, 4.72743809e-02f,
  -4.23443578e-02f, -6.28444776e-02f, 7.80019462e-02f, -6.91240504e-02f, 1.78666003e-02f, -8.08336362e-02f, -3.63843776e-02f, -5.15054129e-02f, 8.19489360e-02f, -1.99057236e-02f,
  -1.21403791e-01f, -1.22314468e-01f, 1.16074987e-01f, -5.07079884e-02f, 5.78825735e-02f, 1.46072684e-02f, 7.22793043e-02f, 8.50821957e-02f, 8.87394622e-02f, 1.82690732e-02f,
  1.99221626e-01f, 5.49303256e-02f, 5.43344244e-02f, 3.75564247e-02f, -5.71583286e-02f, 1.10079937e-01f, 1.90375566e-01f, -2.23990634e-01f, -1.69285014e-01f, -8.42663348e-02f,
  -1.48760214e-01f, -4.05543670e-02f, -3.04305077e-01f, -5.42660728e-02f, 1.93843082e-01f, -7.79668838e-02f, -1.00136153e-01f, 5.83209358e-02f, -2.00258836e-01f, 1.56786628e-02f,
  -6.79425523e-02f, -1.34051546e-01f, -1.45266905e-01f, -5.38693815e-02f, -9.64689776e-02f, 6.94063157e-02f, 2.68305629e-01f, 1.10391445e-01f, 1.83830112e-02f, -1.00806102e-01f,
  -7.82196596e-03f, 3.59837599e-02f, 7.48128369e-02f, 1.84826215e-03f, 4.10197414e-02f, -1.05790257e-01f, -7.30024353e-02f, -1.43698221e-02f, -8.27019513e-02f, 9.83735896e-04f,
  -5.78016639e-02f, -1.22789651e-01f, -6.55000806e-02f, -1.15786940e-01f, -3.88362557e-02f, 2.93078050e-02f, -9.82517302e-02f, -9.01429206e-02f, 5.00319302e-02f, 4.31696102e-02f,
  -1.78750947e-01f, -3.94385122e-03f, 4.33592908e-02f, -9.21864063e-02f, 8.76988024e-02f, -9.77311507e-02f, 1.59459740e-01f, 1.78089051e-03f, 3.83745576e-03f, -4.39850017e-02f,
  -9.94723812e-02f, 4.16721888e-02f, 1.10142224e-01f, -2.94519924e-02f, -7.70651549e-02f, 8.27709958e-02f, 1.92591488e-01f, -3.66635472e-02f, 1.07379749e-01f, -1.93421930e-01f,
  -1.19314440e-01f, -5.67037053e-02f, 1.90065410e-02f, 1.46478876e-01f, 5.02833687e-02f, 1.58800691e-01f, 6.85118809e-02f, 7.74021372e-02f, 5.43551967e-02f, 2.98614684e-03f,
  -7.88079724e-02f, -6.73634410e-02f, -1.77547801e-02f, -8.86694901e-03f, 5.01372479e-02f, -1.13480814e-01f, 2.16995463e-01f, -1.12875223e-01f, 1.11558311e-01f, -2.14706156e-02f,
  5.01982607e-02f, 4.78545902e-03f, -8.15775245e-02f, -3.84578481e-02f, 6.88730320e-03f, -9.29279998e-02f, -1.29055351e-01f, 7.33884098e-03f, 2.11699139e-02f, -2.10019782e-01f,
  -8.10317546e-02f, -1.34699658e-01f, -3.12836803e-02f, 6.40368015e-02f, 8.17830414e-02f, 1.26340361e-02f, 4.33857776e-02f, 2.04329677e-02f, 9.55479294e-02f, -1.01904213e-01f,
  1.68079749e-01f, 4.30036187e-02f, 1.07637204e-01f, 1.64569601e-01f, -1.29847929e-01f, 1.91177532e-01f, -7.48933777e-02f, 9.68047678e-02f, 6.40746728e-02f, 1.73248008e-01f,
  -3.06539983e-02f, 1.60780504e-01f, 9.47042331e-02f, -9.87991691e-02f, -3.49838287e-02f, -2.97694802e-02f, -2.01981843e-01f, 2.84939818e-02f, -1.21196374e-01f, 3.16171087e-02f,
  1.14599122e-02f, -1.00270569e-01f, -1.44555300e-01f, -1.86261117e-01f, 5.55799343e-02f, 1.32909462e-01f, -1.03211850e-01f, 1.70253798e-01f, -1.38981342e-01f, 4.72771376e-03f,
  -4.60697562e-02f, 5.23201823e-02f, 3.89084071e-02f, -7.86770359e-02f, -6.66083768e-02f, 9.41194445e-02f, -1.60454288e-02f, -2.18399450e-01f, 1.81209803e-01f, 2.09338233e-01f,
  2.25978255e-01f, -1.20270520e-01f, 6.58186078e-02f, 6.16730675e-02f, -8.52366984e-02f, -5.11915721e-02f, 2.48264167e-02f, -5.07046916e-02f, 1.22104213e-01f, -1.37803078e-01f,
  -6.39501587e-02f, 3.28403443e-01f, -1.45539254e-01f, 8.28323662e-02f, -5.23401797e-02f, 3.87639776e-02f, 1.37461051e-01f, -2.60638408e-02f, 5.78526072e-02f, 7.13137537e-03f,
  -9.80597511e-02f, -2.25860905e-02f, 7.42952973e-02f, -4.44104001e-02f, 1.51314139e-01f, -2.06853356e-02f, 5.96656045e-03f, 7.85370320e-02f, 7.45009854e-02f, 4.81050946e-02f,
  3.45417000e-02f, 1.10485792e-01f, 2.77263336e-02f, 1.04666343e-02f, -8.33003074e-02f, 1.40776664e-01f, -4.16419879e-02f, 6.58526942e-02f, 7.00482503e-02f, 1.55951595e-02f,
  -4.27262112e-02f, 4.00309041e-02f, 1.79724753e-01f, -1.42015349e-02f, 5.53248376e-02f, 4.59944271e-02f, -8.93414468e-02f, 1.45509914e-01f, 2.48340905e-01f, -9.31646749e-02f,
  -2.07353711e-01f, -1.11758046e-01f, -8.62113908e-02f, -8.69666412e-02f, -2.69215792e-01f, 5.03628887e-02f, 1.42547920e-01f, -1.69915736e-01f, -2.03151375e-01f, 1.24611974e-01f,
  -1.42971054e-01f, -1.47778243e-01f, -4.36034724e-02f, 4.55164351e-03f, -1.85063854e-01f, 3.57632004e-02f, -1.63406342e-01f, 4.25720587e-02f, 1.85724627e-02f, 1.15176896e-02f,
  1.28430963e-01f, 5.18728467e-03f, -1.69232205e-01f, 2.10885871e-02f, 2.48226412e-02f, 1.40983120e-01f, 1.28741011e-01f, 1.03158832e-01f, -5.09734713e-02f, 8.61280262e-02f,
  5.89371175e-02f, 3.81102934e-02f, 1.67516410e-01f, 4.21252102e-02f, 3.97158712e-02f, 6.79374412e-02f, 1.56683728e-01f, 5.45104556e-02f, 1.17099375e-01f, -1.00711256e-01f,
  7.03253448e-02f, 2.15577111e-01f, 1.37703940e-01f, 1.38549253e-01f, -1.49732428e-02f, 1.77607372e-01f, 3.01261634e-01f, 2.79906429e-02f, 3.98028307e-02f, 1.83847845e-02f,
  1.40691455e-02f, 3.25723737e-02f, -2.29916479e-02f, 1.37902079e-02f, -1.82503853e-02f, -6.18847981e-02f, -6.39458224e-02f, -2.60369152e-01f, 8.52820948e-02f, -2.24597976e-01f,
  -8.82569999e-02f, 7.61101469e-02f, 3.40629444e-02f, -2.03027442e-01f, -1.43293932e-01f, 5.83598688e-02f, 6.60323054e-02f, -5.72213084e-02f, 3.01014818e-02f, 1.10896409e-01f,
  1.15924262e-01f, 7.28882290e-03f, -1.59007266e-01f, -1.59302773e-03f, -3.17563228e-02f, -1.09231845e-03f, -2.01811776e-01f, 9.20384303e-02f, -8.25245380e-02f, -6.27851933e-02f,
  -6.35970309e-02f, -1.16894871e-01f, 3.13564041e-03f, 8.80628973e-02f, 2.28286311e-01f, 8.72733966e-02f, -7.16279298e-02f, 1.18695587e-01f, -1.28093794e-01f, -5.94127225e-03f,
  -1.47127002e-01f, -1.28015980e-01f, 6.84725568e-02f, -7.02530742e-02f, -1.74296767e-01f, -6.16718270e-02f, -1.51563883e-01f, -1.85993418e-01f, -1.19138911e-01f, -3.47421765e-02f,
  -6.14591949e-02f, -2.39768121e-02f, -1.21866554e-01f, 1.90637574e-01f, -1.57137275e-01f, -1.41499057e-01f, -2.10712850e-01f, -1.65323615e-01f, -4.32492755e-02f, 1.40164113e-02f,
  -3.18296671e-01f, 1.22554591e-02f, -5.98970875e-02f, 6.51324317e-02f, 6.74652457e-02f, -4.53903712e-02f, -1.29298493e-01f, 4.34699887e-03f, 1.78865176e-02f, 1.16533190e-01f,
  1.23411819e-01f, 2.54068971e-01f, -1.22505866e-01f, 1.64675906e-01f, -7.13078976e-02f, -1.67377114e-01f, -1.21974587e-01f, 1.22953400e-01f, 4.18900140e-02f, -1.31471939e-02f,
  -4.80774976e-02f, 5.55799715e-02f, -1.81069635e-02f, 8.28512653e-04f, -8.10470879e-02f, 4.68353182e-02f, 1.63248092e-01f, -6.52479529e-02f, 2.72911973e-02f, 4.14361022e-02f,
  1.97164699e-01f, -1.19438738e-01f, 7.15556145e-02f, -5.49558960e-02f, 9.40838363e-03f, 1.44210622e-01f, -8.19355473e-02f, 6.22208230e-02f, -2.08622590e-01f, 7.71495327e-02f,
  7.37257898e-02f, -1.58604205e-01f, 2.25070477e-01f, 2.94823013e-02f, 1.85519561e-01f, 1.49799976e-02f, 3.53876092e-02f, -5.36861494e-02f, 1.21254630e-01f, 6.61973283e-02f,
  -9.90576223e-02f, -5.60309365e-02f, -7.92380348e-02f, 8.24793577e-02f, 7.42358807e-03f, -6.34952486e-02f, 5.64864650e-02f, -3.81436236e-02f, 1.68768261e-02f, 9.18446016e-03f,
  -7.60955969e-03f, -1.83244981e-02f, 6.97639817e-03f, -8.20295885e-02f, -1.47469580e-01f, -2.59805154e-02f, 6.23336993e-02f, 6.33145198e-02f, -8.04109965e-03f, 4.82229777e-02f,
  -6.36883005e-02f, -3.15065593e-01f, -1.11851357e-01f, 7.57187884e-03f, 8.88907909e-02f, 1.43263996e-01f, -3.30074467e-02f, -7.75643736e-02f, -1.02416828e-01f, -6.60008267e-02f,
  8.39634240e-02f, -3.94223519e-02f, 1.91726074e-01f, 1.09642282e-01f, -8.84301588e-02f, -6.78670928e-02f, -1.04374193e-01f, 1.32562682e-01f, 1.04698889e-01f, -6.46243766e-02f,
  1.90284476e-01f, -5.40423952e-02f, 6.55285195e-02f, -8.49346742e-02f, 1.57051474e-01f, 1.45728573e-01f, -4.90993634e-02f, -1.27157390e-01f, -3.00807580e-02f, -1.64708078e-01f,
  -9.16747153e-02f, 1.43835068e-01f, 7.03596175e-02f, 7.25567415e-02f, -1.42524913e-01f, -2.01786876e-01f, 2.50845365e-02f, 1.66686773e-01f, 8.07374716e-02f, -7.98467472e-02f,
  -5.87584861e-02f, 4.83522154e-02f, 5.56229241e-02f, -3.84525792e-03f, 6.20878488e-02f, 3.13255489e-02f, 2.41698064e-02f, 6.54785894e-03f, -3.61432508e-02f, 9.66099426e-02f,
  -1.81628596e-02f, -2.68196333e-02f, 1.44618275e-02f, 6.45853952e-02f, -6.64465725e-02f, -1.19485661e-01f, 8.49885121e-02f, -3.70671973e-02f, 6.24320656e-02f, 1.73887499e-02f,
  -1.78063035e-01f, -1.08586684e-01f, -3.84507068e-02f, -4.22097556e-03f, 8.88612196e-02f, 1.35484055e-01f, 1.15413435e-01f, -9.34284255e-02f, -3.16182077e-02f, -1.35384416e-02f,
  -1.19038085e-02f, 2.02395439e-01f, 1.62391901e-01f, 1.34003237e-01f, 1.83083147e-01f, -8.95626564e-03f, -6.60742074e-02f, -1.60353497e-01f, -1.16286101e-02f, 1.81171060e-01f,
  -5.40487207e-02f, -2.13502392e-01f, -1.06663201e-02f, 7.01652020e-02f, -3.85974608e-02f, 7.72036845e-03f, -7.87754804e-02f, -1.73423320e-01f, -3.40539701e-02f, -1.29422352e-01f,
  1.29647344e-01f, 1.42299190e-01f, 1.16038285e-01f, 1.12054966e-01f, 6.83271736e-02f, -7.84809589e-02f, -8.73587802e-02f, -1.54897511e-01f, 1.09606877e-01f, 8.72536451e-02f,
  -1.81282330e-02f, 8.91582817e-02f, 1.08948223e-01f, 1.06969513e-01f, 8.94000567e-03f, -2.93996483e-02f, -1.57727405e-01f, 5.19392416e-02f, 3.59415151e-02f, -1.13871828e-01f,
  9.70003307e-02f, 1.24077573e-02f, -8.80694482e-03f, -1.70014307e-01f, 4.17453162e-02f, 1.35098532e-01f, 1.21793240e-01f, 5.32426648e-02f, 6.13196343e-02f, 1.29221737e-01f,
  4.76420373e-02f, 1.34453392e-02f, -4.14061174e-02f, 5.84610552e-02f, 1.18061639e-01f, 1.53814763e-01f, 8.13205764e-02f, -7.25229159e-02f, -6.90924674e-02f, -7.74538964e-02f,
  -1.59445837e-01f, 8.08167756e-02f, 2.87528280e-02f, -4.05792333e-02f, 1.83222860e-01f, -1.62541419e-01f, -4.98689078e-02f, 2.20647873e-03f, -9.09015164e-03f, 3.44892517e-02f,
  8.69556144e-02f, 1.85320437e-01f, 8.16345066e-02f, -9.30443183e-02f, 9.92809311e-02f, 3.20295215e-01f, -6.94874823e-02f, 1.81616507e-02f, -1.43586516e-01f, 1.11275939e-02f,
  5.71249947e-02f, 1.11170270e-01f, 1.03767395e-01f, 1.61891147e-01f, -5.22385025e-03f, -1.68254495e-01f, -1.03577562e-01f, -1.28144950e-01f, -5.09276614e-02f, 1.68610260e-01f,
  1.59356520e-02f, 9.62536484e-02f, -4.00002412e-02f, -5.16052693e-02f, -1.22170942e-02f, 7.91718513e-02f, -1.31169021e-01f, -5.66230938e-02f, -1.53751709e-02f, -3.23886126e-02f,
  4.46462445e-02f, -2.02461351e-02f, -8.82942304e-02f, -6.40654787e-02f, 5.80491731e-03f, -4.37546894e-03f, -8.24753419e-02f, -1.24134533e-01f, -1.10783666e-01f, 2.67514363e-02f,
  -1.68545768e-01f, -2.07251180e-02f, 8.10950845e-02f, -6.63263872e-02f, -1.71565171e-02f, 1.81932766e-02f, -3.51843163e-02f, -1.09614104e-01f, 6.79148510e-02f, -5.93548268e-02f,
  6.44467399e-02f, 5.22326026e-03f, -9.52540785e-02f, 2.03251868e-01f, 1.12728938e-01f, 1.38030469e-01f, 6.37234282e-03f, -1.85067117e-01f, 1.02755181e-01f, -5.00641912e-02f,
  -1.39120324e-02f, 2.53336936e-01f, 1.82465196e-01f, -2.33860984e-01f, -2.88347930e-01f, 1.15057282e-01f, -9.46970433e-02f, 1.91287115e-01f, -2.10981265e-01f, -1.25044242e-01f,
  2.14365274e-01f, 2.23212200e-03f, -2.89898217e-01f, -1.45813495e-01f, -2.29384571e-01f, 1.28043285e-02f, -2.07550541e-01f, 1.00992806e-02f, -1.66890174e-01f, 2.20898837e-02f,
  -2.68387720e-02f, -6.88034818e-02f, 2.37571582e-01f, 1.89574324e-02f, -9.93469283e-02f, -2.93022662e-01f, -5.55450842e-02f, 6.13857470e-02f, -5.01048416e-02f, 2.97306739e-02f,
  9.15227644e-03f, -2.49823391e-01f, 1.97661258e-02f, -8.99800584e-02f, 5.19329756e-02f, -1.16494775e-01f, 6.11062944e-02f, -1.18499637e-01f, -1.53111247e-02f, -4.56786752e-02f,
  3.67982350e-02f, -1.12202205e-02f, -5.49464077e-02f, 2.32788194e-02f, -5.07971570e-02f, 7.15440586e-02f, -2.64002591e-01f, -1.49885699e-01f, -9.66662019e-02f, -5.20824566e-02f,
  -1.26817390e-01f, -4.16137278e-03f, 7.50894919e-02f, -4.71017696e-02f, 1.15152843e-01f, -7.22281188e-02f, -2.86808684e-02f, 6.25829101e-02f, -1.10154133e-02f, 1.26608778e-02f,
  -1.11035638e-01f, 1.23684041e-01f, -5.96304461e-02f, -3.01786251e-02f, -1.89314961e-01f, -1.86745018e-01f, 5.67242391e-02f, 9.25554931e-02f, -4.81635332e-02f, 1.76824480e-01f,
  -1.22862212e-01f, 4.09248993e-02f, -1.75698027e-02f, -1.86615869e-01f, 1.70808092e-01f, -1.23445995e-01f, 1.32216781e-01f, -1.07767329e-01f, -4.08538245e-02f, -1.30892649e-01f,
  1.06805399e-01f, 7.36394823e-02f, 1.01755835e-01f, -6.21546805e-02f, 1.41354412e-01f, -8.43899995e-02f, 7.71297216e-02f, -5.81948012e-02f, -5.85776269e-02f, -1.07840195e-01f,
  7.83274546e-02f, -2.25894988e-01f, -1.32741868e-01f, 1.03628829e-01f, -1.50428683e-01f, -1.00971907e-01f, 1.02316840e-02f, 2.59369891e-02f, -7.07360879e-02f, 5.78967407e-02f,
  1.03394769e-01f, 1.20920874e-01f, -3.81902629e-03f, 9.07340869e-02f, -9.75230243e-03f, 2.07251608e-01f, 6.83619315e-03f, 8.70762952e-03f, -7.86018446e-02f, -2.51135044e-02f,
  -4.46046330e-02f, 1.40716452e-02f, -1.57561284e-02f, 1.04708269e-01f, 8.87703151e-02f, 4.40933593e-02f, -1.70182064e-01f, -1.06622107e-01f, 1.75854519e-01f, 8.02448485e-04f,
  7.20255915e-03f, 1.33893624e-01f, -1.04492828e-01f, 3.43174785e-02f, -2.49849126e-01f, -1.12019025e-01f, -1.29301965e-01f, 4.31742519e-02f, -8.18439759e-03f, -1.09093837e-01f,
  -1.78266165e-03f, 1.47462338e-01f, -1.34189948e-01f, -5.61216548e-02f, 9.57452655e-02f, 7.00099440e-03f, 2.06016675e-01f, -2.78710902e-01f, -5.95153123e-02f, 1.21065006e-01f,
  -1.41030312e-01f, 3.32389921e-02f, 8.77987891e-02f, -1.68838874e-01f, -1.25299186e-01f, 2.51835436e-02f, 7.99391866e-02f, 1.38530597e-01f, 8.34014416e-02f, 4.92961109e-02f,
  -1.15016755e-02f, -1.62318185e-01f, 1.23984674e-02f, -1.71696842e-01f, 9.30681527e-02f, 4.67947833e-02f, -4.60891575e-02f, 1.00346850e-02f, -1.64872766e-01f, 1.25855193e-01f,
  -4.63064481e-03f, 1.05101295e-01f, 2.25161705e-02f, 2.18901876e-02f, -1.66245267e-01f, -1.62232935e-01f, -6.03287891e-02f, 5.35824262e-02f, -6.41611358e-03f, -2.92986240e-02f,
  -6.43417165e-02f, -4.05829847e-02f, -2.71822587e-02f, -1.59540266e-01f, -7.15609789e-02f, -6.78918958e-02f, -5.13861477e-02f, -2.19445601e-02f, -1.13215394e-01f, -2.90954143e-01f,
  3.41949463e-01f, -5.86365175e-04f, 3.90678719e-02f, 1.13707911e-02f, 4.20567580e-03f, -7.72408471e-02f, 3.59901525e-02f, 2.65217051e-02f, 1.34527117e-01f, 2.07947344e-02f,
  8.36838111e-02f, -2.03074906e-02f, -2.64018942e-02f, 2.08444931e-02f, -2.58572280e-01f, -2.10698560e-01f, 1.69581268e-02f, 2.29926139e-01f, -1.43452376e-01f, 3.55782025e-02f,
  -1.44876882e-01f, 1.04521610e-01f, 1.60149291e-01f, -8.26158375e-02f, 5.11311144e-02f, -1.07376926e-01f, -1.56019211e-01f, 3.23830217e-01f, -1.46036029e-01f, 2.65250858e-02f,
  -3.67381610e-02f, -1.37783542e-01f, -1.17596826e-02f, -1.65037036e-01f, 2.05218032e-01f, 1.34078249e-01f, -1.50719089e-02f, 6.87571913e-02f, 1.80124082e-02f, 1.22848898e-01f,
  4.98535968e-02f, -1.42769992e-01f, -2.15764325e-02f, -1.26430482e-01f, 1.06527819e-03f, -1.57205332e-02f, -2.62404680e-02f, -2.40950081e-02f, -2.21417863e-02f, -8.70499685e-02f,
  1.02958335e-02f, -3.56836990e-02f, -3.80309336e-02f, -5.14014848e-02f, -9.65942815e-02f, 4.43643928e-02f, 1.79104730e-02f, 3.51914465e-02f, -9.45988670e-02f, -5.93430037e-03f,
  -8.22325796e-02f, -1.23694502e-01f, -8.04012176e-03f, -5.33042699e-02f, 2.81072170e-01f, 7.62707144e-02f, 9.98627394e-02f, 3.84224323e-03f, -5.63381091e-02f, 6.78745583e-02f,
  -4.97706607e-02f, 2.18778616e-03f, -3.28722931e-02f, -1.57717373e-02f, 8.67084190e-02f, -1.58156723e-01f, -2.25618891e-02f, -7.22250268e-02f, -3.17929626e-01f, -9.22589004e-02f,
  4.68079001e-02f, 2.14311004e-01f, -1.04973808e-01f, -1.89284503e-03f, 5.07617407e-02f, 1.11933857e-01f, 6.05237074e-02f, -4.08861116e-02f, -5.97624704e-02f, -4.12297733e-02f,
  -2.14124285e-03f, 3.06022793e-01f, -4.01654392e-02f, 2.24722903e-02f, 1.01456776e-01f, -2.13715702e-01f, 7.20377713e-02f, -8.52524638e-02f, 4.11186293e-02f, 9.55614224e-02f,
  -2.22881977e-03f, -4.72386107e-02f, 2.60391925e-03f, -2.15990599e-02f, -1.33387715e-01f, -1.62010536e-01f, -9.39583697e-04f, -2.34987050e-01f, -3.95864621e-02f, 1.33355513e-01f,
  3.55917178e-02f, 2.56354157e-02f, -1.15834363e-01f, -7.43925869e-02f, -9.02992487e-02f, -4.09555295e-03f, -3.75946276e-02f, 2.67328117e-02f, -8.52930993e-02f, -1.13020889e-01f,
  -3.75480577e-02f, -1.45850286e-01f, -3.67419142e-03f, -2.47754920e-02f, 5.68716750e-02f, -6.15190901e-02f, -1.10484771e-02f, -2.74183929e-01f, 2.95855582e-01f, -6.22002631e-02f,
  -1.09912105e-01f, 4.34829667e-02f, -2.81283781e-02f, -6.68459907e-02f, 1.25332683e-01f, -7.82969221e-02f, 2.29335055e-01f, 1.13552576e-03f, 1.39719561e-01f, -7.46061131e-02f,
  5.91096282e-02f, 5.59924655e-02f, -2.01496258e-01f, -2.55971432e-01f, 8.04237574e-02f, -2.30796225e-02f, 3.10364440e-02f, 5.90889305e-02f, -1.11103602e-01f, 2.61349946e-01f,
  1.20402254e-01f, -7.24560693e-02f, -1.96535233e-02f, 1.88706666e-02f, -6.28520176e-02f, 3.85724843e-01f, -1.58959359e-01f, -4.99395840e-02f, -9.67572331e-02f, 1.34395044e-02f,
  -6.38336316e-02f, -4.24891822e-02f, 1.46652967e-01f, 1.93684042e-01f, 1.13371409e-01f, 2.72584800e-02f, -4.42960821e-02f, 6.56267405e-02f, 8.13112184e-02f, -1.59230381e-01f,
  -7.48083228e-03f, -2.02060074e-01f, -4.87431921e-02f, 5.55389524e-02f, 1.75723150e-01f, -2.55264435e-02f, -8.68734717e-02f, 1.07951716e-01f, -1.08350538e-01f, -2.11477280e-02f,
  -7.53247440e-02f, -1.28399432e-01f, 1.46817371e-01f, -3.84471146e-03f, 4.65690158e-02f, -3.07808071e-02f, 8.82149935e-02f, -5.07694334e-02f, -5.84442727e-03f, 1.02835298e-01f,
  -1.04872763e-01f, 5.00069372e-02f, -7.90376142e-02f, 7.35209417e-03f, -1.21010609e-01f, -2.82986183e-02f, 6.66601434e-02f, -1.78031057e-01f, 1.12960711e-01f, 4.07964326e-02f,
  2.43368208e-01f, 3.53367515e-02f, -4.81392257e-02f, -5.34989126e-02f, -1.32565901e-01f, 7.37507492e-02f, 3.48647326e-01f, -1.41592085e-01f, -9.42197889e-02f, -2.15238914e-01f,
  -1.50985979e-02f, -3.72559801e-02f, -2.39521205e-01f, 8.91934410e-02f, 2.27617890e-01f, -1.28269494e-01f, -2.80638058e-02f, 1.44350037e-01f, -1.86998576e-01f, -2.63353348e-01f,
  6.76549599e-02f, 2.73968428e-02f, -5.40084355e-02f, -9.54609737e-02f, -9.80568379e-02f, -3.82120050e-02f, -9.77374241e-02f, 4.48363507e-03f, 1.64499030e-01f, -6.75935522e-02f,
  -1.84893072e-01f, -1.37521610e-01f, 9.98301655e-02f, 2.67529815e-01f, 2.58529514e-01f, 2.99334768e-02f, 1.32977605e-01f, 3.69065441e-02f, 2.11260140e-01f, 7.14132711e-02f,
  -1.19164854e-01f, -1.45459965e-01f, -3.36799724e-03f, 2.37528179e-02f, 5.23001552e-02f, -3.07073910e-02f, 5.65581676e-03f, 1.16491579e-01f, -6.05804510e-02f, 7.64488280e-02f,
  -4.68517765e-02f, -5.68528846e-02f, -1.05647355e-01f, -6.00974113e-02f, -2.14501143e-01f, -1.06292567e-03f, 1.07178099e-01f, 3.22920643e-02f, 2.24038493e-03f, -4.81419545e-03f,
  -2.42183004e-02f, -1.60612300e-01f, 2.34819725e-02f, 1.67844947e-02f, 1.91577092e-01f, 1.55295312e-01f, -9.74411666e-02f, -5.21679223e-02f, -2.37230033e-01f, 1.03184180e-02f,
  1.20879069e-01f, -1.55362338e-01f, 8.54285061e-03f, 2.00446555e-03f, -1.33393869e-01f, -1.78666010e-01f, -1.21723399e-01f, 9.91677120e-02f, 1.53084710e-01f, -1.65680721e-01f,
  1.35010421e-01f, -1.55543908e-01f, -2.47619096e-02f, 8.47725421e-02f, 8.80693868e-02f, 8.35862011e-02f, -1.64693013e-01f, 5.38882520e-03f, -6.69477209e-02f, -1.13619089e-01f,
  -4.06712964e-02f, 2.29327291e-01f, 8.16707164e-02f, 1.63407564e-01f, -9.67342630e-02f, -1.38513923e-01f, 7.80008882e-02f, -2.06037126e-02f, 2.04179481e-01f, 5.46463355e-02f,
  -6.51424825e-02f, -1.60965770e-01f, -4.51978594e-02f, -8.06745142e-02f, -4.87742573e-03f, -2.11397663e-01f, 3.62516567e-02f, 8.00891593e-02f, -2.96459962e-02f, 7.39638880e-02f,
  -8.13388005e-02f, -8.02702904e-02f, -3.15891020e-02f, -7.26519302e-02f, -2.35257402e-01f, -1.45264834e-01f, -1.05673205e-02f, -1.06837012e-01f, -7.77211785e-02f, -3.75602096e-02f,
  5.14971018e-02f, -1.68771207e-01f, 1.40699625e-01f, 3.36114727e-02f, -8.34498182e-02f, 1.33173138e-01f, 4.17236798e-02f, 4.74653244e-02f, -1.10607892e-01f, -1.47564209e-03f,
  -3.62043232e-02f, -9.67728496e-02f, 1.75898075e-02f, -2.29308635e-01f, -1.92920402e-01f, 3.38329151e-02f, 4.65665422e-02f, 2.15679094e-01f, 2.13243216e-02f, 3.00977565e-02f,
  2.63027042e-01f, -1.24819912e-01f, -6.06172578e-03f, 1.08483419e-01f, -2.57832017e-02f, -1.34306863e-01f, 1.04154512e-01f, -6.25290573e-02f, 4.66217361e-02f, 4.27094800e-03f,
  9.98791531e-02f, -1.30753264e-01f, 9.11899209e-02f, -4.05129418e-02f, 1.01853041e-02f, -1.50216714e-01f, -9.52568799e-02f, -7.35991448e-02f, 4.03093696e-02f, -1.01901509e-01f,
  -1.03187367e-01f, -5.26311956e-02f, -1.18598253e-01f, -2.00677533e-02f, 5.03818952e-02f, -6.39323294e-02f, -1.12352721e-01f, -1.31500512e-01f, -7.88515881e-02f, -1.80400267e-01f,
  -1.42390653e-01f, -3.89705040e-02f, 2.73653981e-03f, 3.56736332e-02f, -3.01566683e-02f, 1.90761223e-01f, -1.76898167e-01f, -2.04705715e-01f, -1.17259175e-01f, -1.34253711e-01f,
  -2.87161153e-02f, -1.41167408e-02f, -2.29273587e-01f, -6.54412955e-02f, -5.42040132e-02f, -3.57985832e-02f, -4.58671823e-02f, -2.72874814e-02f, -2.80177835e-02f, -2.65653580e-02f,
  7.17566460e-02f, -1.58668950e-03f, 1.08992949e-01f, 2.74387449e-01f, -1.53314829e-01f, 1.87926441e-01f, -9.75309610e-02f, -1.40442580e-01f, -1.02445163e-01f, 1.69462726e-01f,
  1.25203013e-01f, -2.18348056e-02f, -4.58612107e-02f, -6.23419024e-02f, 1.03545308e-01f, -1.00990288e-01f, -7.76450410e-02f, -1.83205809e-02f, 9.46491584e-02f, -2.10788436e-02f,
  1.13379866e-01f, 6.15683869e-02f, 5.35336174e-02f, -1.15007594e-01f, 2.07844637e-02f, -9.83665790e-03f, -1.76156014e-02f, 7.58118778e-02f, -1.19898215e-01f, 1.64506286e-02f,
  -1.29650101e-01f, 5.10922484e-02f, 5.86560294e-02f, -2.84684114e-02f, 2.60869861e-01f, -8.04414451e-02f, 2.18910977e-01f, 1.69452310e-01f, -2.18896661e-02f, 5.13662063e-02f,
  -3.46112240e-04f, 3.04116518e-03f, 5.61615676e-02f, 9.72333848e-02f, 4.36142348e-02f, -8.48500803e-02f, 8.53898153e-02f, 6.04345016e-02f, -8.70606601e-02f, -7.71945948e-03f,
  -1.18120082e-01f, -3.17630060e-02f, 4.92508523e-02f, -7.34173730e-02f, 6.01001531e-02f, 9.48651601e-03f, 7.87938014e-02f, -1.16958074e-01f, 1.04879357e-01f, -8.08863044e-02f,
  -1.31767243e-01f, 2.11536195e-02f, 3.76136526e-02f, 1.53772876e-01f, 7.98942074e-02f, -9.09907445e-02f, -1.29912168e-01f, -1.03929855e-01f, -1.68004539e-04f, 1.39735058e-01f,
  2.43852809e-01f, 5.29581197e-02f, -1.40933514e-01f, -6.67560250e-02f, -3.50145139e-02f, -9.42489132e-02f, -2.15574056e-02f, 6.76141456e-02f, 8.12816396e-02f, -7.75289387e-02f,
  -8.93588290e-02f, 5.08147525e-03f, -1.40685709e-02f, -7.70416297e-03f, -1.29040424e-02f, 2.44571507e-01f, -2.13688418e-01f, -1.37407467e-01f, -7.06304833e-02f, 2.21804380e-01f,
  -7.64295086e-02f, 9.37321112e-02f, 1.62342507e-02f, 6.91947192e-02f, -5.49265891e-02f, 5.84121607e-02f, 1.84049472e-01f, 1.37211531e-01f, 8.04238170e-02f, -2.85165966e-01f,
  3.37190740e-02f, 3.90618034e-02f, 1.16567751e-02f, 2.60355067e-03f, 4.73588891e-03f, 5.13953157e-02f, -6.91509992e-02f, -1.24396086e-01f, 2.75798421e-02f, -1.75745841e-02f,
  -1.10856881e-02f, -8.42147544e-02f, 1.46850869e-01f, 4.38358858e-02f, 6.46143481e-02f, -3.46341245e-02f, 1.04222707e-01f, 1.06118165e-01f, -3.45593095e-02f, -1.97748933e-03f,
  -9.53176692e-02f, 8.58022496e-02f, 2.44968787e-01f, 1.32564232e-01f, -5.19609600e-02f, -7.17530027e-02f, 2.26005670e-02f, -1.42591462e-01f, -1.06201723e-01f, 1.42289490e-01f,
  1.05516262e-01f, 5.82193621e-02f, 7.66656771e-02f, -8.83517638e-02f, -1.46824375e-01f, -1.08436838e-01f, -2.07047865e-01f, -7.17438199e-03f, 4.67996150e-02f, 1.62780002e-01f,
  6.26886310e-03f, -1.05572917e-01f, -1.21735722e-01f, 3.04783136e-01f, 6.64381683e-02f, -1.42054185e-01f, 2.72379760e-02f, -2.58337259e-02f, 1.63192879e-02f, 2.84564644e-01f,
  4.12874073e-02f, 1.09490655e-01f, -2.63638273e-02f, -6.87226653e-02f, -1.10139042e-01f, -1.76537007e-01f, 1.55462446e-02f, 1.69884220e-01f, 1.17647357e-01f, 1.54228792e-01f,
  -2.47294102e-02f, -4.61682267e-02f, -9.19744447e-02f, 1.07225534e-02f, 9.42993388e-02f, 1.77971423e-02f, 4.69980314e-02f, 1.31090302e-02f, 2.03818128e-01f, 5.89353358e-03f,
  -4.02737372e-02f, 1.39829770e-01f, -9.83864591e-02f, -4.75319624e-02f, 3.26469913e-02f, 1.35873565e-02f, 9.71371308e-03f, 8.34996775e-02f, -6.90137371e-02f, 9.86763015e-02f,
  1.03144206e-01f, -6.35213330e-02f, 7.57649615e-02f, 6.14213049e-02f, 1.55809700e-01f, -1.03222758e-01f, -1.22927688e-01f, -1.84808224e-02f, -1.01501368e-01f, 1.03133217e-01f,
  1.24776632e-01f, -5.75606339e-02f, 3.36508043e-02f, -1.68012261e-01f, 1.04358114e-01f, -1.00131929e-01f, -7.34413341e-02f, -1.86726861e-02f, -1.17997406e-02f, 1.46389842e-01f,
  2.11210400e-01f, -6.54927567e-02f, -2.17328928e-02f, -2.86811680e-01f, 1.49565518e-01f, -1.59682885e-01f, -1.29245311e-01f, -7.62004852e-02f, 1.06679544e-01f, 4.11534011e-02f,
  4.74584429e-03f, 4.28783298e-02f, -2.46073417e-02f, 4.24485933e-03f, -1.53790608e-01f, -1.11158483e-01f, -2.97732055e-01f, 1.80143818e-01f, -2.26339594e-01f, 2.92563979e-02f,
  3.93613838e-02f, -7.33230822e-03f, 8.85995775e-02f, -1.00521438e-01f, -1.87406436e-01f, 1.15834258e-01f, 1.09156892e-01f, -9.01310220e-02f, 1.86880529e-01f, 6.06818497e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.16764836e-02f, 7.48906732e-02f, 1.33142114e-01f, -9.86643583e-02f, -1.77956358e-01f, -1.46775886e-01f, -5.59576675e-02f, 8.47307667e-02f, -3.70916799e-02f, -1.29520390e-02f,
  4.69955392e-02f, 6.11560382e-02f, 8.64511579e-02f, -1.59740970e-01f, -2.88223028e-01f, -2.40934491e-01f, 1.19614182e-02f, 3.21610607e-02f, -3.54299724e-01f, -1.28997147e-01f,
  2.54216611e-01f, 7.69982263e-02f, -1.26492769e-01f, 3.71266268e-02f, -9.60241072e-03f, -3.03377174e-02f, 1.73965722e-01f, 1.23972915e-01f, 2.85723269e-01f, 3.99607480e-01f,
  -1.22645892e-01f, 2.51020461e-01f, -1.86517965e-02f, -2.23455466e-02f, -1.01841912e-01f, -8.47565681e-02f, 1.76171303e-01f, -1.37701944e-01f, -3.52830201e-01f, -8.84993821e-02f,
  -3.11066676e-02f, -3.63386050e-02f, -6.00134656e-02f, -1.62178695e-01f, 3.14617753e-01f, -1.62375048e-02f, -1.03328072e-01f, 2.55015045e-01f, 1.27120227e-01f, -1.30781308e-01f,
  1.32067621e-01f, 4.94742543e-02f, 1.51948825e-01f, 1.12591922e-01f, -1.08901951e-02f, 1.31582886e-01f, -5.62684163e-02f, 9.36204419e-02f, 2.88486406e-02f, -6.95203692e-02f,
  3.56080890e-01f, -7.38493428e-02f, 3.49058747e-01f, 8.75824019e-02f, -1.63409079e-03f, -8.46291184e-02f, 1.50115237e-01f, -3.19960192e-02f, 1.04565755e-01f, 5.20953685e-02f,
  -5.19509427e-02f, 2.94205919e-03f, -4.35442384e-03f, -9.05184522e-02f, 1.52316749e-01f, 6.06128983e-02f, 1.20347075e-01f, 5.10674715e-02f, -2.30756421e-02f, 8.57281461e-02f,
  -1.03083901e-01f, 1.96750283e-01f, -1.13293722e-01f, 2.35665917e-01f, 2.85491142e-02f, 9.30523798e-02f, 1.13095716e-01f, -8.04984011e-03f, 7.13461190e-02f, -8.59728903e-02f,
  -7.64402822e-02f, 2.31217444e-01f, -1.87974405e-02f, 2.07459524e-01f, -7.22570270e-02f, 2.14110147e-02f, -3.22707415e-01f, -1.17207266e-01f, 3.36813390e-01f, 9.85710323e-02f,
  -1.48670852e-01f, 1.09557815e-01f, -3.63351226e-01f, -4.81917188e-02f, -2.40438312e-01f, -1.16096579e-01f, 1.13900669e-01f, -2.24497795e-01f, -7.42366016e-02f, 3.11898924e-02f,
  -1.09874591e-01f, -3.87304902e-01f, 2.78094858e-01f, 2.30752170e-01f, 2.19882295e-01f, -8.78864676e-02f, 2.32905179e-01f, 1.85294539e-01f, -4.18207645e-02f, 1.29082352e-01f,
  5.58866672e-02f, -1.13491647e-01f, 1.41519055e-01f, -9.06150490e-02f, 6.38253242e-02f, 5.26008546e-01f, 1.07810088e-01f, 2.06947654e-01f, -5.45787066e-02f, 8.34345073e-02f,
  -1.44529253e-01f, 9.60819572e-02f, 1.49995714e-01f, 1.99715681e-02f, 7.44724721e-02f, 6.78241998e-02f, -6.72399625e-03f, -1.29365036e-02f, 9.76269469e-02f, 7.29584247e-02f,
  -1.03898626e-02f, 5.53608267e-03f, 1.82603627e-01f, 1.80102974e-01f, 1.42574571e-02f, 1.27793372e-01f, 1.35266855e-01f, -4.77237590e-02f, 2.43493002e-02f, 4.13450338e-02f,
  6.71264231e-02f, 1.09604083e-01f, 3.95777598e-02f, 3.74504477e-01f, 1.42294616e-02f, 2.18019694e-01f, -1.07057378e-01f, -1.69338375e-01f, 2.35612124e-01f, -8.94427821e-02f,
  1.04391664e-01f, 1.50451466e-01f, 7.30744675e-02f, -1.95121109e-01f, -3.93510520e-01f, 2.99211107e-02f, -1.16532110e-01f, 1.29078612e-01f, -2.20038772e-01f, -7.69757014e-03f,
  1.55416831e-01f, -1.24564618e-01f, -4.67966825e-01f, 1.16805762e-01f, -2.08135232e-01f, 5.12752421e-02f, -1.84649378e-01f, 3.19329537e-02f, 1.43087864e-01f, 6.11654557e-02f,
  2.11765803e-02f, 1.95766956e-01f, 3.72087270e-01f, 1.21628851e-01f, 8.11815485e-02f, -1.57202616e-01f, 3.07708740e-01f, 2.87304014e-01f, -1.23822950e-01f, 4.96059693e-02f,
  -1.55925229e-01f, 5.74915612e-04f, 1.72389299e-01f, 1.06822930e-01f, 6.27654940e-02f, 5.48306713e-03f, -7.40121379e-02f, -2.49406807e-02f, 5.45902736e-02f, 1.72001407e-01f,
  1.20423332e-01f, 1.05837835e-02f, 6.49860175e-03f, 1.17140003e-01f, 8.13687816e-02f, 3.97513993e-02f, 3.99032421e-02f, 1.81083975e-03f, -6.14100276e-03f, -1.72674283e-02f,
  -4.68079858e-02f, 1.02302387e-01f, 6.03076816e-02f, 2.87345685e-02f, -1.07637374e-02f, 7.29915276e-02f, 3.41835991e-02f, -3.38506550e-01f, -1.65693492e-01f, -9.30844247e-02f,
  6.64068162e-02f, 1.01755060e-01f, -2.83963718e-02f, 4.71581668e-02f, -5.77645116e-02f, -7.22391978e-02f, -1.36498129e-02f, 9.98119041e-02f, 3.74174386e-01f, -8.48951712e-02f,
  -5.08961193e-02f, -1.14079684e-01f, 1.00424640e-01f, 1.66852817e-01f, -5.53616211e-02f, -4.83878367e-02f, 2.74753362e-01f, 9.68941376e-02f, 4.16646153e-02f, 7.27990493e-02f,
  2.27117091e-01f, 1.61951464e-02f, -5.39906472e-02f, 9.90814529e-03f, -1.11218924e-02f, -1.06103785e-01f, -2.63442874e-01f, 2.06912369e-01f, 1.48653075e-01f, 3.23945016e-01f,
  -1.74862519e-01f, -1.06514268e-01f, -5.08693559e-03f, -9.05680412e-04f, 2.20018879e-01f, 1.78178251e-01f, 1.33244768e-01f, 1.01834007e-01f, -4.49927486e-02f, 1.92279637e-01f,
  1.23510294e-01f, 5.37433149e-03f, 5.95402382e-02f, 1.35091737e-01f, 1.38605580e-01f, -2.37870980e-02f, 2.05396954e-02f, 6.62856847e-02f, 5.12182303e-02f, 7.30954260e-02f,
  1.04988083e-01f, 1.77055851e-01f, -5.21233156e-02f, 1.14890132e-02f, 1.53343767e-01f, 8.17508101e-02f, 1.78241432e-01f, 1.62005275e-01f, 4.29048575e-02f, 9.56719220e-02f,
  5.28093837e-02f, -1.64693877e-01f, -1.00874946e-01f, 2.66250633e-02f, -7.69074857e-02f, -2.11490482e-01f, 2.31785014e-01f, -2.28642091e-01f, -2.72895955e-02f, -2.91456841e-02f,
  -2.29503408e-01f, 5.81179047e-03f, 3.72359343e-02f, 2.09909916e-01f, 1.65997297e-01f, -9.85809937e-02f, 1.20705672e-01f, 2.19184384e-01f, -9.90958363e-02f, 4.64231707e-02f,
  -2.52870899e-02f, -9.59813669e-02f, 1.52959555e-01f, 2.30116248e-01f, -1.50688030e-02f, 1.91603571e-01f, -3.18125486e-02f, -3.07806376e-02f, -1.23083442e-01f, -1.49252430e-01f,
  1.11618727e-01f, 1.46021008e-01f, 2.37806931e-01f, 2.03649640e-01f, 9.07001719e-02f, 1.01651855e-01f, -9.38831568e-02f, -1.33129984e-01f, -1.17623225e-01f, 6.34370446e-02f,
  -3.71839106e-02f, 5.40907569e-02f, 1.01707511e-01f, 4.82137315e-02f, 2.34505907e-02f, 5.84676908e-03f, 1.25929760e-02f, -3.20837162e-02f, -9.27816778e-02f, -1.24432072e-02f,
  1.61616523e-02f, 7.68764243e-02f, -6.84331032e-03f, -9.56900492e-02f, 1.18904009e-01f, 8.65353644e-02f, 6.52240729e-03f, 7.42459670e-02f, -9.66608245e-03f, 1.03381835e-01f,
  -1.75530195e-01f, -8.02547322e-04f, 4.09139954e-02f, 6.90587312e-02f, 9.61874947e-02f, 2.11927652e-01f, 1.26871198e-01f, 1.94362268e-01f, 1.15839675e-01f, -2.14401055e-02f,
  6.70081936e-03f, 2.01108903e-01f, -2.05624271e-02f, 2.16565236e-01f, 2.21449852e-01f, 3.57546955e-02f, -2.30911776e-01f, -2.28814200e-01f, -1.47927985e-01f, -3.63659896e-02f,
  -2.11503625e-01f, -1.47618636e-01f, -8.65531620e-04f, -6.54267296e-02f, -2.22967446e-01f, 1.45131677e-01f, -4.39510569e-02f, -2.45173718e-03f, -4.12673242e-02f, -8.77209008e-02f,
  -1.95150584e-01f, 2.49764174e-01f, -1.53606474e-01f, 2.68595278e-01f, 1.96770206e-01f, -2.83764564e-02f, -9.45965648e-02f, 4.23533022e-02f, 1.33584082e-01f, 1.99167266e-01f,
  1.33268461e-01f, 9.99264270e-02f, 1.25380978e-01f, 7.88165256e-02f, 6.84293881e-02f, 8.82888511e-02f, 4.81769629e-02f, 8.95531625e-02f, 4.24811244e-02f, 1.06925987e-01f,
  5.07779494e-02f, 7.76131302e-02f, 1.42897278e-01f, 1.87227339e-01f, 2.99165882e-02f, 2.38834731e-02f, 9.33488011e-02f, 1.22819804e-01f, 2.88142096e-02f, 1.11137614e-01f,
  2.66561955e-02f, 1.31892145e-01f, 2.38548547e-01f, 1.03023872e-02f, 2.52069272e-02f, 3.84999961e-02f, -7.46349245e-02f, 6.64406642e-02f, 9.43817720e-02f, -2.32988194e-01f,
  -1.62742779e-01f, -2.22551003e-01f, 1.13392426e-02f, -4.33726124e-02f, 9.65976715e-02f, -6.09965697e-02f, 1.80098057e-01f, -1.44828362e-02f, -2.09701717e-01f, 5.79946227e-02f,
  3.05913359e-01f, -7.03821331e-02f, 2.63331294e-01f, -8.68892521e-02f, 2.32258216e-01f, 1.09634243e-01f, -1.84009984e-01f, 1.82483375e-01f, 1.90392137e-01f, 1.74991209e-02f,
  1.76598474e-01f, 1.86869353e-01f, 2.10073274e-02f, -7.13012740e-03f, 1.09165303e-01f, 5.03024412e-03f, 3.89538221e-02f, -5.00435382e-02f, -1.45423383e-01f, 2.13547081e-01f,
  1.83131739e-01f, 2.65270263e-01f, 9.69070047e-02f, 1.60875410e-01f, -5.07926941e-02f, -1.74750268e-01f, 6.76113367e-02f, 1.73350856e-01f, 6.74848929e-02f, 1.36935562e-02f,
  1.45981953e-01f, 5.73199168e-02f, 1.17529213e-01f, 2.81146049e-01f, -4.56767268e-02f, 7.26685449e-02f, 1.44762963e-01f, -1.25686256e-02f, 1.10070623e-01f, 1.16172247e-01f,
  1.98644072e-01f, 1.57763138e-01f, 1.63895041e-01f, 7.55228773e-02f, 1.91763401e-01f, 1.38415352e-01f, 2.32889801e-01f, 2.26092041e-01f, -3.58573258e-01f, 1.50133431e-01f,
  -1.06833875e-01f, 8.92274529e-02f, 8.60055089e-02f, -2.56922334e-01f, -1.46689519e-01f, -1.12349108e-01f, 5.41763753e-02f, -9.01019350e-02f, -1.18819967e-01f, 1.43070534e-01f,
  1.39202937e-01f, 1.66387692e-01f, 3.59745741e-01f, 1.99030295e-01f, 1.15885921e-01f, -3.18616360e-01f, 2.17630208e-01f, -6.27188683e-02f, 3.13428380e-02f, 1.13967573e-02f,
  -2.15378717e-01f, 1.35287806e-01f, 9.25768390e-02f, 2.89845765e-01f, 6.52739257e-02f, -3.03920299e-01f, 7.53348842e-02f, -2.03121621e-02f, 1.01989442e-02f, 2.04525560e-01f,
  -1.79516934e-02f, 1.99379191e-01f, -2.42582992e-01f, -1.27916127e-01f, 1.81689098e-01f, 2.54132003e-01f, 3.17808725e-02f, 6.15138263e-02f, 2.02475917e-02f, 1.09203488e-01f,
  1.44895568e-01f, 2.58294582e-01f, 5.27107939e-02f, 1.44530281e-01f, -1.71927828e-02f, 8.32365081e-02f, 5.44304438e-02f, 7.07120225e-02f, -1.44090811e-02f, 1.06608160e-01f,
  7.02209249e-02f, -9.35445130e-02f, 1.24465108e-01f, 3.80349644e-02f, 1.56787202e-01f, 1.30998924e-01f, 1.39958784e-01f, 1.55551016e-01f, 9.63107497e-02f, 2.08199341e-02f,
  9.81952697e-02f, -1.99703742e-02f, 1.28267214e-01f, 1.38979435e-01f, 2.12141238e-02f, 1.01124249e-01f, -5.93585260e-02f, -1.93730235e-01f, -2.07853392e-01f, 4.69389632e-02f,
  1.01004191e-01f, -1.85715646e-01f, 1.30438417e-01f, -2.75244623e-01f, -9.61865112e-02f, 4.13503870e-02f, 3.76313142e-02f, -1.90387696e-01f, 1.04435049e-02f, 1.75222605e-01f,
  -2.35293545e-02f, -1.25835449e-01f, -8.18656087e-02f, 2.82736927e-01f, 1.61205932e-01f, -9.55251977e-02f, -2.30313733e-01f, 1.66722968e-01f, -1.01239525e-01f, 1.04643166e-01f,
  -9.06061605e-02f, 2.01044291e-01f, 2.56021768e-02f, -1.67617410e-01f, -7.58916661e-02f, -8.38752836e-02f, 1.40396759e-01f, 2.71287084e-01f, 2.01857194e-01f, 2.46499348e-02f,
  -1.25250190e-01f, 9.94456708e-02f, -8.07340816e-03f, 2.51522124e-01f, 5.61398827e-02f, -7.64225051e-02f, -5.56083545e-02f, -4.25638556e-02f, -4.57709692e-02f, -4.44187522e-02f,
  5.45494743e-02f, 6.58646040e-03f, 1.38274997e-01f, 8.89704973e-02f, 5.02922051e-02f, 1.51925027e-01f, -1.10364966e-01f, -8.13027546e-02f, 1.14362486e-01f, 3.20507959e-02f,
  -2.12217450e-01f, -3.23449783e-02f, 2.34028343e-02f, -9.15016308e-02f, 2.81291176e-02f, -1.09433018e-01f, 1.43768296e-01f, -3.15484218e-02f, 2.07381099e-01f, -7.67941326e-02f,
  -3.89918461e-02f, 3.46425138e-02f, 1.09210238e-01f, 9.74109303e-03f, -2.06423327e-01f, 5.70951924e-02f, 8.87966305e-02f, 7.55904987e-02f, 1.62539646e-01f, -1.32273376e-01f,
  -7.23455846e-02f, -1.19328974e-02f, 1.29303202e-01f, 1.61469206e-01f, -5.08283302e-02f, 3.14774752e-01f, 1.08612418e-01f, -1.29758805e-01f, 7.45511949e-02f, -7.09873661e-02f,
  2.93244310e-02f, -9.28204432e-02f, 9.58415121e-03f, -1.65386528e-01f, 7.29255527e-02f, -6.61969185e-02f, 4.57927823e-01f, -5.45221269e-02f, 4.59788829e-01f, 4.86189686e-03f,
  1.88365325e-01f, 1.09221209e-02f, -7.38284290e-02f, -3.06735206e-02f, 1.61262348e-01f, -4.94740382e-02f, -9.85133350e-02f, 5.75844161e-02f, -7.38197267e-02f, -9.09363180e-02f,
  2.25724161e-01f, 1.96842983e-01f, 1.10680759e-02f, 8.89772847e-02f, -1.08039044e-02f, 1.30047454e-02f, 1.01507947e-01f, 1.16630457e-01f, 1.30701333e-01f, 1.24200121e-01f,
  -1.83191411e-02f, 1.23307846e-01f, -4.49572727e-02f, 1.31488815e-01f, 1.08716831e-01f, 2.14507952e-02f, 5.14390739e-03f, 5.33220731e-03f, 1.11435696e-01f, -1.32310733e-01f,
  1.44976676e-01f, 1.25887468e-02f, -7.65742660e-02f, 7.39716291e-02f, 1.34326413e-01f, -9.26518738e-02f, -1.62778422e-01f, -8.63134116e-02f, -1.23316266e-01f, -1.63268909e-01f,
  7.78172612e-02f, -1.40603155e-01f, 2.35525921e-01f, 1.14988927e-02f, -4.15252447e-01f, 6.55143037e-02f, 2.59997368e-01f, 8.84373933e-02f, 7.21650347e-02f, -6.45165816e-02f,
  1.97566897e-01f, 1.89567536e-01f, -2.64293998e-01f, 5.84967025e-02f, 1.82550713e-01f, -1.16440542e-01f, 2.39347398e-01f, 3.95496190e-01f, -8.22954625e-03f, -2.35657170e-02f,
  -3.73359583e-02f, 1.44962639e-01f, -9.76855010e-02f, -1.52293622e-01f, -1.42540727e-02f, 2.77773619e-01f, 2.03939267e-02f, 3.48117471e-01f, 1.02079600e-01f, 2.17616811e-01f,
  -8.15268233e-02f, -4.25062716e-01f, 3.60444933e-02f, 9.81436297e-02f, 3.67164649e-02f, -5.28871790e-02f, 4.64261398e-02f, -5.85641675e-02f, 1.54271036e-01f, 6.32086843e-02f,
  1.95321254e-02f, -1.04073040e-01f, -1.18616018e-02f, 5.76848462e-02f, -1.19657407e-03f, 6.29627407e-02f, 1.34132430e-01f, 3.80865112e-02f, -8.80735889e-02f, -6.46513104e-02f,
  1.13764025e-01f, 1.15436926e-01f, -4.90261279e-02f, 1.70346409e-01f, -1.50782332e-01f, 9.21902135e-02f, -1.02472641e-01f, 1.30931363e-01f, 5.58350496e-02f, 5.37082925e-02f,
  3.77822630e-02f, 1.17371917e-01f, 2.76696705e-03f, 1.77256346e-01f, -1.31974086e-01f, 2.06264675e-01f, 4.09312136e-02f, -8.00521895e-02f, 2.10326985e-01f, 2.66495436e-01f,
  5.64237237e-02f, -2.42409721e-01f, -2.25686088e-01f, 1.40767777e-02f, -1.54588828e-02f, -1.15696274e-01f, -1.10285990e-01f, -1.42285347e-01f, 1.48869947e-01f, 1.60797775e-01f,
  1.93118174e-02f, -1.98468283e-01f, 1.51737496e-01f, -5.34470230e-02f, 1.84980810e-01f, 1.47562951e-01f, 1.96694151e-01f, 1.44005686e-01f, -1.37349188e-01f, -7.67601281e-02f,
  1.05635552e-02f, -1.14817801e-03f, 1.24362782e-01f, -1.10314481e-01f, 1.38415143e-01f, 2.54996806e-01f, 1.00343309e-01f, 2.31265441e-01f, 7.50339851e-02f, -2.30668392e-02f,
  1.46348074e-01f, 5.80324382e-02f, 8.76725093e-02f, 7.42580816e-02f, -7.65888318e-02f, 7.35131204e-02f, 5.81484325e-02f, -4.90560494e-02f, 1.11942105e-01f, 5.82963228e-02f,
  -6.24293927e-03f, 5.02806231e-02f, 5.54765016e-02f, -5.35801314e-02f, 6.55522645e-02f, 1.26364619e-01f, -1.58737257e-01f, 4.93168607e-02f, -1.30762205e-01f, 7.14267865e-02f,
  -4.50975001e-02f, 7.62088895e-02f, 1.17018029e-01f, -1.36966437e-01f, -2.71726996e-02f, 1.53643386e-02f, 8.22543800e-02f, 1.42090365e-01f, -1.81438953e-01f, 1.33603066e-01f,
  -1.59208938e-01f, 1.12813406e-01f, 3.23701382e-01f, 2.44388892e-03f, -1.22910000e-01f, -1.58759326e-01f, -1.39416397e-01f, -1.49700224e-01f, -2.51629442e-01f, -1.39928192e-01f,
  1.25818059e-01f, -6.92136660e-02f, 8.63086209e-02f, 6.74424469e-02f, -1.06148168e-01f, -2.70528704e-01f, 7.79819861e-02f, 4.09948034e-03f, -1.76073864e-01f, 1.59083799e-01f,
  -1.28442362e-01f, 3.66402976e-02f, -2.88012740e-03f, -6.80484576e-03f, 2.06871033e-01f, -3.70472968e-02f, -7.68700391e-02f, -8.88262615e-02f, 7.46968761e-02f, 2.89739639e-01f,
  1.78510398e-01f, 2.38857627e-01f, -2.81473752e-02f, 2.01301515e-01f, -1.16119474e-01f, 9.46391746e-02f, 7.45492578e-02f, 6.82029352e-02f, 1.15327507e-01f, -4.58603445e-03f,
  4.40282859e-02f, 6.14070741e-04f, -3.78911979e-02f, -1.00272827e-01f, 2.27014478e-02f, 2.15376187e-02f, 5.18589057e-02f, 7.29424730e-02f, 6.74218312e-02f, 1.35055985e-02f,
  1.24413475e-01f, -1.52839333e-01f, 1.21521547e-01f, 7.59218261e-03f, 4.29969169e-02f, 4.88209203e-02f, 1.30651176e-01f, 2.34680414e-01f, 9.42403674e-02f, 6.28315210e-02f,
  -1.54583961e-01f, -1.45925388e-01f, 1.21999756e-01f, 1.26060799e-01f, 3.08185190e-01f, 1.79301485e-01f, -1.75729051e-01f, -1.66935712e-01f, -1.81772858e-01f, 4.86326553e-02f,
  -9.15798396e-02f, 1.45509347e-01f, -8.22004825e-02f, -8.62632394e-02f, -4.13653255e-02f, -8.89310390e-02f, -2.27872282e-01f, -5.07499874e-02f, -1.62976921e-01f, 2.05035612e-01f,
  -2.90232331e-01f, -1.35052517e-01f, -5.65430755e-03f, 2.16920212e-01f, -2.70066466e-02f, 1.77653328e-01f, 2.35534191e-01f, 1.21778041e-01f, 1.22491494e-01f, 1.31559432e-01f,
  2.10339561e-01f, 2.85070896e-01f, 4.94389012e-02f, -5.33691570e-02f, -7.56736994e-02f, -4.15200815e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.85691014e-02f, 1.60363019e-01f, 8.99454504e-02f, 1.56519935e-01f, 2.43143011e-02f, 9.51001793e-02f, 9.63999629e-02f, 1.51758706e-02f, 5.89396656e-02f, 2.29111873e-02f,
  9.21325311e-02f, 8.05306062e-02f, 9.94396508e-02f, 5.98560646e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.24493083e-02f, -4.62269373e-02f, -6.88242610e-04f, -1.19506031e-01f, 2.22387221e-02f, -8.40051249e-02f, 6.21203668e-02f, 5.27434126e-02f, 1.67905793e-01f, -2.61099264e-02f,
  -1.80533007e-02f, 1.34217776e-02f, 9.47781950e-02f, 3.35932150e-02f, -1.03596948e-01f, -5.43535426e-02f, 1.35548506e-02f, -2.00365037e-02f, 5.30081205e-02f, -1.32558912e-01f,
  1.35167977e-02f, -1.37881069e-02f, -3.46810706e-02f, -1.69384610e-02f, -5.93779348e-02f, 1.25627950e-01f, -4.53342423e-02f, 1.69984847e-02f, 1.93731248e-01f, 6.01700358e-02f,
  -1.71762183e-01f, -7.91338086e-02f, -6.27297387e-02f, 1.01267010e-01f, -3.08214873e-02f, -7.85998162e-03f, -1.25484886e-02f, 1.31541178e-01f, 8.20714682e-02f, 1.01294778e-02f,
  1.63806662e-01f, 2.99986545e-02f, 1.31857067e-01f, 1.05350889e-01f, 4.32678964e-03f, 1.28158718e-01f, 1.16465278e-01f, 4.90925610e-02f, -1.14289382e-02f, 2.99220663e-02f,
  1.59108832e-01f, -6.90651871e-03f, 3.59357451e-03f, -2.12766528e-02f, -1.58111006e-01f, 1.17572360e-01f, -1.78127423e-01f, -1.24864988e-01f, -1.42081538e-02f, 9.05562565e-02f,
  -1.41570389e-01f, -5.67678083e-03f, 2.01969482e-02f, 1.21448070e-01f, 2.12464314e-02f, -3.74151580e-02f, 1.86770801e-02f, -2.89664492e-02f, -2.03715404e-03f, -5.94163202e-02f,
  4.09615226e-03f, 1.25402987e-01f, 9.42225531e-02f, 3.16683576e-02f, 2.40259953e-02f, 4.29481734e-03f, 2.74482407e-02f, -6.60543442e-02f, -1.58737525e-01f, -1.02713540e-01f,
  -2.37154532e-02f, -4.75944728e-02f, 1.40184045e-01f, -1.15544997e-01f, -8.84056911e-02f, 7.63209909e-02f, -4.32169959e-02f, -6.47628903e-02f, 9.53498557e-02f, 9.23795924e-02f,
  -1.04868852e-01f, -1.14646077e-01f, 1.11974180e-01f, 3.93941998e-02f, -2.68544793e-01f, -9.92293842e-03f, 3.98214906e-03f, -1.01976849e-01f, -8.67640153e-02f, 2.80059613e-02f,
  -3.05247232e-02f, 1.08151548e-01f, 7.84859620e-03f, 4.98916134e-02f, 3.38145643e-02f, 3.08350138e-02f, 1.56073436e-01f, -3.88783924e-02f, -1.17469527e-01f, 3.56886862e-03f,
  3.41578089e-02f, 1.88470080e-01f, -8.13074708e-02f, 3.88847776e-02f, 1.48400724e-01f, -1.04267657e-01f, 7.35101402e-02f, -1.63636446e-01f, -1.20718732e-01f, 8.58673528e-02f,
  -1.11850426e-01f, -4.67477627e-02f, -1.43292740e-01f, 9.61552262e-02f, -8.03773627e-02f, 1.51023408e-02f, -8.95798057e-02f, 2.02133492e-01f, -7.42030740e-02f, -3.17693762e-02f,
  1.02419749e-01f, 2.84495801e-02f, 9.32746977e-02f, 5.76582327e-02f, 1.62141137e-02f, 1.58261061e-02f, 1.03430547e-01f, 3.77217382e-02f, 8.38601403e-03f, -4.74277511e-03f,
  1.35759220e-01f, -1.34267226e-01f, -3.77858579e-02f, 4.12218794e-02f, 2.21203119e-02f, 4.63481955e-02f, 6.12572581e-02f, 1.58595681e-01f, 3.06868646e-03f, 1.38111770e-01f,
  -2.69871149e-02f, 7.83149991e-03f, 1.09312013e-01f, 6.74562901e-02f, -1.60091057e-01f, -2.23070588e-02f, 1.02496229e-01f, -1.71555549e-01f, -1.63199797e-01f, 2.46538315e-02f,
  1.09580703e-01f, -2.30735168e-01f, -1.39696836e-01f, 1.76728554e-02f, -8.91387165e-02f, 1.86850756e-01f, -1.21326230e-01f, 1.49276733e-01f, -1.38310734e-02f, -7.29902983e-02f,
  5.90592064e-02f, -7.07171410e-02f, -1.55843738e-02f, -1.82180181e-01f, -2.56743170e-02f, 1.92740783e-01f, -8.87262896e-02f, 1.49027392e-01f, -8.07311833e-02f, -8.11115950e-02f,
  1.86110839e-01f, -1.92153081e-01f, 4.91883159e-02f, 2.20814720e-01f, -4.43273485e-02f, 1.39723718e-01f, -7.23041743e-02f, -1.43933669e-01f, 5.01592569e-02f, -3.80055271e-02f,
  -4.15653177e-03f, 1.35779053e-01f, -8.53872895e-02f, -4.40710671e-02f, 8.43332335e-02f, 3.31716915e-03f, -4.81026024e-02f, -5.43100238e-02f, 6.23443425e-02f, 3.40867154e-02f,
  1.65251464e-01f, 1.86678227e-02f, -1.47781551e-01f, -8.01272392e-02f, -4.96494696e-02f, 6.18114918e-02f, 3.11513189e-02f, -6.33391365e-02f, -6.10829629e-02f, -3.63250561e-02f,
  8.71689618e-02f, -7.32461864e-04f, 1.19342051e-01f, 8.51168782e-02f, -4.60627005e-02f, 3.92005630e-02f, -2.13999674e-01f, 5.68459928e-02f, -7.92256817e-02f, -9.41946432e-02f,
  -1.53704137e-01f, 1.43106014e-01f, 1.01186614e-02f, -9.53016654e-02f, -1.12479907e-02f, 8.69040564e-02f, -8.68857726e-02f, 6.95913285e-02f, -3.65930758e-02f, 6.45735040e-02f,
  1.12293340e-01f, -8.57755262e-03f, -3.96867320e-02f, 1.68212932e-02f, -5.53885028e-02f, -2.37860397e-01f, -1.69895478e-02f, 1.44992501e-01f, 6.29863888e-02f, 7.15955123e-02f,
  -1.51145473e-01f, -6.77654892e-02f, -2.66080275e-02f, -7.48592392e-02f, -8.35461635e-03f, -6.46147355e-02f, -1.11953691e-01f, 3.13880444e-02f, -1.21105708e-01f, -1.91578299e-01f,
  -2.12225288e-01f, 7.20041990e-02f, -2.15847846e-02f, 1.11344233e-02f, -6.10816218e-02f, 7.52011985e-02f, -2.40595266e-02f, -8.08411762e-02f, -1.19478693e-02f, -5.69278002e-03f,
  2.90145930e-02f, 7.33417645e-02f, 4.17533144e-02f, 3.04380152e-02f, 8.03869143e-02f, -8.69223922e-02f, -1.56979024e-01f, 5.40692024e-02f, 6.28845319e-02f, -6.52536154e-02f,
  1.38737202e-01f, 1.56802572e-02f, -7.08620250e-02f, 5.43625094e-02f, -9.25697088e-02f, 7.17801154e-02f, -1.13819670e-02f, 1.84686407e-01f, 7.99602736e-03f, 6.16379529e-02f,
  6.56159669e-02f, 9.94120166e-02f, -1.84395209e-01f, -1.33114770e-01f, 1.59591567e-02f, 9.62059796e-02f, -1.52752111e-02f, -1.20266052e-02f, 9.10414085e-02f, -1.66097417e-01f,
  -1.32737145e-01f, -8.65020901e-02f, 3.75928218e-03f, 6.83143288e-02f, 2.45020799e-02f, 2.20033508e-02f, 6.86227530e-02f, 1.25209764e-01f, 4.19488586e-02f, -3.39139611e-01f,
  -1.12913050e-01f, 9.59249511e-02f, -5.85010573e-02f, 1.07580326e-01f, -1.27110288e-01f, -9.39374864e-02f, -1.31447420e-01f, -5.13545908e-02f, 6.39431030e-02f, -1.87092781e-01f,
  4.26607579e-02f, 1.43854588e-01f, -2.53451075e-02f, -1.50801331e-01f, 5.63386194e-02f, 1.01531856e-01f, -4.65651229e-02f, 2.64874566e-02f, -1.03612304e-01f, 1.68089375e-01f,
  5.71376383e-02f, 3.05120610e-02f, -5.14451154e-02f, 1.80856287e-01f, 5.10097556e-02f, 4.33774665e-02f, 7.44054466e-02f, -1.25526339e-01f, -1.41168069e-02f, -1.25818839e-02f,
  8.35194960e-02f, 1.46245211e-01f, -8.14692751e-02f, -5.66974841e-02f, 2.98706852e-02f, 4.50125374e-02f, 1.24020971e-01f, 7.40202367e-02f, -5.05863130e-02f, -2.35331841e-02f,
  -5.20358533e-02f, -4.98105139e-02f, 2.52605900e-02f, 9.08529088e-02f, -1.03825584e-01f, -1.34007648e-01f, 6.15823343e-02f, 5.56924567e-02f, -1.06489874e-01f, -4.80572134e-03f,
  1.76011562e-01f, 1.17611671e-02f, -1.31618589e-01f, 1.90744609e-01f, 1.11946531e-01f, -1.78069826e-02f, 1.19154461e-01f, -2.52678573e-01f, 3.96867469e-02f, -1.28786340e-01f,
  -6.95972741e-02f, -9.89386067e-03f, -4.90473546e-02f, -4.07673046e-03f, 2.11857241e-02f, 1.09762594e-01f, 7.57996142e-02f, -1.10742435e-01f, 1.69549406e-01f, -1.17739089e-01f,
  1.57631095e-02f, 1.12952136e-01f, -1.11254290e-01f, 1.22515313e-01f, 1.02563582e-01f, -2.36809835e-01f, 1.54087827e-01f, 6.36412948e-02f, -2.42258608e-02f, 1.08356506e-01f,
  7.12355226e-02f, 1.04949921e-01f, -1.18804328e-01f, -5.03372401e-02f, -1.56784356e-01f, -8.98573399e-02f, 4.75350441e-03f, -8.88818502e-03f, -5.54360747e-02f, 1.22952349e-01f,
  8.48725531e-03f, 7.42254853e-02f, 1.27530002e-04f, -1.29562095e-02f, -7.67339319e-02f, -6.20038919e-02f, -2.19249576e-02f, 6.39625415e-02f, 4.36114632e-02f, -5.81365190e-02f,
  1.99909136e-02f, 4.82010618e-02f, -2.30177585e-02f, 7.69806802e-02f, 3.44881080e-02f, 3.79009470e-02f, -3.34552489e-02f, -1.31401852e-01f, -2.41059944e-01f, -8.58401805e-02f,
  -1.45184919e-01f, -1.36138752e-01f, -1.20401762e-01f, 1.18101440e-01f, 2.89825653e-03f, -2.48354599e-01f, 4.84131016e-02f, -2.47525182e-02f, -1.19515043e-02f, -5.00800200e-02f,
  2.72224471e-02f, 1.52485788e-01f, 9.87677053e-02f, 7.87303224e-02f, 8.99250805e-02f, 7.19306841e-02f, 2.65634246e-03f, -2.47365132e-01f, -8.45758244e-02f, 9.51354206e-02f,
  4.97087054e-02f, 8.60696733e-02f, -1.72964990e-01f, 1.17031066e-02f, -1.64687380e-01f, -1.45327643e-01f, 9.89982337e-02f, -7.46015534e-02f, 5.14714159e-02f, -6.09550178e-02f,
  -1.42420819e-02f, -1.81230247e-01f, -1.99160911e-02f, 9.79999006e-02f, 1.53481707e-01f, -3.70244160e-02f, -1.14241242e-01f, 1.38729783e-02f, -3.01030446e-02f, 1.93807278e-02f,
  -9.89166126e-02f, -1.15360536e-01f, -1.04003385e-01f, -1.86726227e-01f, -4.21486013e-02f, 6.14887886e-02f, 1.44816950e-01f, 8.02765042e-03f, 5.88615388e-02f, -2.79582925e-02f,
  4.35307771e-02f, 5.67581356e-02f, -1.55669972e-01f, -1.58436760e-01f, -4.44864705e-02f, -8.49632081e-03f, 8.43477771e-02f, -1.21300265e-01f, 4.66880985e-02f, -4.60273251e-02f,
  -1.10993758e-01f, 1.08902575e-02f, -5.98674379e-02f, 1.65253133e-01f, -8.67954567e-02f, -1.05738744e-01f, 8.93046055e-03f, 8.76918510e-02f, -7.06125647e-02f, -3.76676880e-02f,
  2.55998652e-02f, 2.45911838e-03f, -6.05814904e-02f, -6.92654541e-03f, -2.07124557e-02f, 7.13751465e-02f, 4.74756546e-02f, 1.38218805e-01f, 9.58963670e-03f, 9.86518338e-03f,
  1.22852452e-01f, 7.26268142e-02f, -2.97089536e-02f, 1.68487042e-01f, 7.03710243e-02f, 7.50737861e-02f, -5.66405952e-02f, 4.16548224e-03f, 5.41663021e-02f, -7.25941285e-02f,
  1.23483516e-01f, -1.60850644e-01f, -1.76206917e-01f, 2.57060174e-02f, -6.63417131e-02f, -1.84962541e-01f, -5.36136180e-02f, 4.39360403e-02f, -1.67534471e-01f, -5.39125465e-02f,
  5.56179434e-02f, 1.61267202e-02f, -8.45826194e-02f, -8.43243003e-02f, 4.32330966e-02f, 3.52936685e-02f, 1.07620684e-02f, 4.27374393e-02f, 1.82906706e-02f, -1.78707503e-02f,
  -1.13473132e-01f, -1.52901009e-01f, -5.39086945e-02f, -2.41629984e-02f, -3.90431248e-02f, -1.09677233e-01f, 1.08694702e-01f, -6.35663932e-03f, 9.00128507e-04f, 5.73652945e-02f,
  -7.91342184e-02f, 3.02315652e-02f, 1.17210187e-01f, 4.70363684e-02f, 5.00258245e-02f, -8.34110826e-02f, 3.08071990e-02f, -2.15658784e-01f, -3.00509483e-02f, -2.51138937e-02f,
  -1.64940983e-01f, -8.35956261e-03f, 1.72583293e-02f, -2.37779636e-02f, 5.39709404e-02f, -1.64411694e-01f, -5.69822788e-02f, -1.79776341e-01f, 2.13531051e-02f, 1.54935628e-01f,
  -1.15197769e-03f, 8.21704715e-02f, 8.46393928e-02f, 9.52858925e-02f, 4.09982912e-02f, -2.04145133e-01f, -1.91764962e-02f, -1.56226419e-02f, -9.66103002e-02f, 3.42263989e-02f,
  -7.96627626e-02f, 8.20477456e-02f, -2.38962680e-01f, -1.33793026e-01f, 7.37271309e-02f, -4.59997403e-03f, -2.99608428e-02f, -6.95505440e-02f, 1.13870449e-01f, 8.11304152e-03f,
  -7.52914548e-02f, 7.47805610e-02f, 1.22195445e-01f, -1.60458073e-01f, -7.53363520e-02f, 3.00204046e-02f, -2.25311518e-02f, -8.49676225e-03f, -8.34047198e-02f, -4.13622856e-02f,
  -5.40956631e-02f, -6.11070469e-02f, 2.62488425e-02f, -7.99580440e-02f, 2.21157111e-02f, 2.49037966e-02f, 6.02497719e-02f, -6.17795736e-02f, -2.41528470e-02f, -1.56495228e-01f,
  -5.36849955e-03f, -2.73368154e-02f, -6.83264360e-02f, -3.60424779e-02f, 3.82451452e-02f, -7.34805763e-02f, -9.19511095e-02f, 4.85309511e-02f, 7.86774680e-02f, 9.90485623e-02f,
  4.18730639e-02f, 8.17305129e-03f, 2.05668047e-01f, -3.18662822e-02f, 1.12253115e-01f, -1.17571525e-01f, -3.78204361e-02f, 1.46290094e-01f, 1.85859520e-02f, -5.37208803e-02f,
  1.37806544e-02f, -1.33539978e-02f, 5.85025223e-03f, -1.17268845e-01f, -7.49209821e-02f, -1.28981974e-02f, -8.81948322e-02f, -1.06952496e-01f, -8.38339552e-02f, 1.18373282e-01f,
  4.37336303e-02f, 1.05403876e-02f, 6.01209402e-02f, -3.95262428e-02f, 8.35461728e-03f, 1.34545803e-01f, -5.32478765e-02f, 1.20178133e-01f, -9.18603912e-02f, -6.18786775e-02f,
  6.03294047e-03f, 6.69073761e-02f, -8.21494497e-03f, 9.53558236e-02f, -4.90719937e-02f, -1.22487292e-01f, -1.69195861e-01f, 9.17449296e-02f, 2.71232892e-02f, -6.06822111e-02f,
  -4.58977595e-02f, -4.07708772e-02f, -1.21562287e-01f, -6.63322285e-02f, -1.06145397e-01f, -1.43360831e-02f, -6.70929030e-02f, -2.94057606e-03f, -2.41246987e-02f, -6.42722147e-03f,
  -5.62797114e-02f, -1.12721525e-01f, -2.84948554e-02f, 2.22600475e-02f, -8.30370486e-02f, 4.13819067e-02f, -1.15176670e-01f, -7.21975118e-02f, -7.27806985e-02f, -7.24653155e-03f,
  -8.79492462e-02f, -4.30774428e-02f, 8.17682967e-02f, -6.06000014e-02f, -2.55708098e-01f, -8.14719498e-03f, 7.51461014e-02f, -1.01001494e-01f, -6.12582713e-02f, 1.56048127e-02f,
  4.21185829e-02f, -1.06741518e-01f, -4.36836705e-02f, 1.37360737e-01f, 2.93982010e-02f, 4.28268202e-02f, -3.10542602e-02f, -1.36036798e-01f, 2.54547689e-02f, 8.23295340e-02f,
  -5.53584434e-02f, 8.25455487e-02f, -1.30824462e-01f, -1.79198235e-01f, -7.15391263e-02f, 1.29089609e-01f, 1.62722901e-01f, -2.20257360e-02f, -2.02362332e-02f, 4.04856168e-02f,
  -5.22531383e-02f, 1.00906976e-01f, -1.94745794e-01f, -2.78311223e-02f, -1.39878290e-02f, -1.29629984e-01f, -6.10213205e-02f, 2.34347358e-02f, -1.56006485e-01f, -1.29332811e-01f,
  6.08062595e-02f, -2.21590102e-02f, 3.47279571e-02f, -1.60567015e-01f, 1.12607323e-01f, 3.89694907e-02f, -1.14835113e-01f, 6.51534274e-02f, 5.45595996e-02f, -4.49259393e-02f,
  -1.27618656e-01f, -1.79140747e-01f, 3.65726948e-02f, -4.93865535e-02f, 1.05018869e-01f, 7.25040287e-02f, -6.58945274e-03f, -1.68398291e-01f, -1.83855191e-01f, 1.12842582e-01f,
  1.01612583e-02f, -1.64443463e-01f, -1.13011420e-01f, -1.29837811e-01f, -1.90490603e-01f, 1.83472019e-02f, 1.32913413e-02f, 1.05939768e-02f, 2.13451952e-01f, 9.24794376e-02f,
  1.95008069e-01f, 2.37562805e-02f, 1.09676443e-01f, -5.55808097e-02f, -2.92394627e-02f, 4.16270234e-02f, -7.70535022e-02f, 4.23995731e-03f, 9.14042592e-02f, -4.09627855e-02f,
  8.72108340e-02f, -6.78356513e-02f, -7.24824741e-02f, -9.43411216e-02f, -1.94764525e-01f, -1.03610702e-01f, 1.31627228e-02f, 8.78364593e-02f, -3.34163569e-02f, 1.53578380e-02f,
  -5.66416793e-02f, -1.34904623e-01f, 2.69058589e-02f, -2.11711098e-02f, 9.41590518e-02f, 1.09782793e-01f, -7.57860905e-03f, 5.03511690e-02f, -3.09054721e-02f, 3.02915238e-02f,
  1.75359740e-03f, 1.55432612e-01f, 1.43399648e-03f, -2.41519827e-02f, -1.65926799e-01f, 3.40908878e-02f, 6.35889173e-02f, -9.18173939e-02f, -2.83360202e-02f, 2.86727808e-02f,
  4.10800911e-02f, -2.36739125e-02f, -4.86009605e-02f, -2.55067479e-02f, -6.69594761e-03f, 1.69262573e-01f, 8.76768604e-02f, -8.03579483e-03f, 1.47148478e-03f, -4.36162539e-02f,
  -9.15675834e-02f, 4.99559194e-02f, -1.15457848e-02f, -9.94670764e-02f, -7.91583359e-02f, -4.67127971e-02f, 3.62358205e-02f, -1.00923404e-02f, -4.00383286e-02f, -2.66036857e-02f,
  -4.15054522e-02f, 5.60597442e-02f, -1.66705269e-02f, 1.30027577e-01f, 4.70366590e-02f, -1.06968768e-01f, 7.23260567e-02f, -1.87657345e-02f, -1.36846378e-01f, 8.07949379e-02f,
  -5.02699874e-02f, 3.04625053e-02f, 3.72228548e-02f, 5.92488609e-02f, -1.55389160e-01f, -1.49713963e-01f, 1.37828290e-01f, 7.65533447e-02f, -3.50849032e-02f, -1.01537563e-01f,
  8.16640444e-03f, 1.49652557e-02f, -1.06275424e-01f, -2.11481117e-02f, 9.32175815e-02f, 1.64591253e-01f, -1.16423346e-01f, 4.15532030e-02f, 2.41522208e-01f, 5.16784787e-02f,
  -1.29101783e-01f, 7.73047581e-02f, -9.88825411e-02f, 8.91644433e-02f, -1.34954840e-01f, 8.27163458e-02f, -1.58916220e-01f, 9.41920355e-02f, -7.59775713e-02f, 1.59641460e-01f,
  1.37163594e-01f, 1.16091995e-02f, -7.35687464e-02f, 1.01228617e-01f, -6.07511401e-02f, 6.65048212e-02f, -7.97665343e-02f, 6.55248463e-02f, 1.90348327e-02f, -1.49035782e-01f,
  6.51023835e-02f, 4.91362251e-02f, 1.97334010e-02f, -1.62894670e-02f, -1.11950167e-01f, -1.02362849e-01f, 9.70179364e-02f, 7.53545836e-02f, -7.42263049e-02f, -2.96177883e-02f,
  3.48756500e-02f, 7.91314319e-02f, 8.64692032e-03f, 1.13310395e-02f, -1.54973206e-03f, -2.78015416e-02f, 5.95168509e-02f, -2.75077522e-01f, 1.31021529e-01f, -6.93243295e-02f,
  -2.20149443e-01f, -9.86799411e-03f, 1.17815033e-01f, 4.51264121e-02f, 3.80013846e-02f, -2.07664132e-01f, 4.78736125e-02f, -1.30529245e-02f, 8.79918560e-02f, 1.18066363e-01f,
  -7.40114320e-03f, 7.65737966e-02f, -1.04560658e-01f, -1.26709223e-01f, 1.05904753e-03f, 7.81039074e-02f, 5.92412055e-02f, -6.37321733e-03f, -7.99315721e-02f, -2.09733158e-01f,
  -1.14514850e-01f, 1.42550930e-01f, -2.17199504e-01f, -1.42709449e-01f, -1.13810800e-01f, -4.84293401e-02f, 6.61473498e-02f, -4.95026633e-02f, 9.15442705e-02f, 1.42901093e-01f,
  1.36397049e-01f, -1.92345828e-02f, -9.94678810e-02f, -5.52080758e-02f, 9.40649584e-02f, -1.47802383e-01f, 7.70070627e-02f, 7.57544395e-03f, -4.31135595e-02f, -1.53666153e-03f,
  1.11929864e-01f, -4.05011175e-04f, -9.35264006e-02f, -8.21217597e-02f, -6.96761012e-02f, 3.07306051e-02f, 5.48407584e-02f, 1.07276671e-01f, -2.32446995e-02f, 5.28863072e-02f,
  -1.74756125e-01f, 5.04744388e-02f, -3.43730561e-02f, -1.98329985e-01f, -5.74726053e-02f, -3.80029753e-02f, -1.35072857e-01f, -1.21818691e-01f, -1.11262664e-01f, -2.53651533e-02f,
  1.64063275e-01f, 1.08692251e-01f, 5.04865199e-02f, 5.08682504e-02f, 1.06602088e-01f, -1.26205340e-01f, -1.22914501e-01f, 5.11877686e-02f, -4.43785712e-02f, -6.05364479e-02f,
  5.17424457e-02f, -8.81652813e-03f, 2.34181751e-02f, -9.22602267e-05f, -7.76921883e-02f, -8.75431076e-02f, 3.54149379e-02f, 2.09274013e-02f, 4.35657464e-02f, 9.06435922e-02f,
  1.74815487e-02f, -1.13624357e-01f, -2.82484870e-02f, 1.88441332e-02f, 1.48041368e-01f, 3.88807915e-02f, 1.32674977e-01f, 9.46453810e-02f, -8.99577960e-02f, 1.14761837e-01f,
  -2.92923916e-02f, -9.07643810e-02f, 4.17176448e-03f, -1.55284517e-02f, 1.45974874e-01f, -1.77650556e-01f, 1.33467972e-01f, 1.54132634e-01f, 1.20672345e-01f, 1.33425193e-02f,
  -6.90766573e-02f, -7.57260695e-02f, -1.03831319e-02f, -6.66629225e-02f, -2.90733594e-02f, 7.90012106e-02f, -1.68611839e-01f, -1.95208862e-02f, -5.98827330e-03f, -1.11446315e-02f,
  3.60204391e-02f, 2.07466539e-02f, -1.06896564e-01f, 6.41720071e-02f, 6.61224872e-02f, 6.99953884e-02f, -1.23267904e-01f, 1.34366930e-01f, -3.59152108e-02f, -1.03843408e-02f,
  -2.91539058e-02f, -1.05488144e-01f, 6.46920800e-02f, -6.57435432e-02f, -9.33188498e-02f, -8.13403428e-02f, 1.85186803e-01f, 6.47183582e-02f, 5.42658530e-02f, -6.65798783e-02f,
  2.82420933e-01f, -7.42172226e-02f, 2.40289643e-02f, 2.81602480e-02f, 1.88584656e-01f, -1.55738473e-01f, 1.80815518e-01f, 6.37142509e-02f, -3.18865143e-02f, -6.98617548e-02f,
  -2.83580497e-02f, 1.11758895e-01f, -1.82565540e-01f, 1.01769522e-01f, 5.44356368e-02f, -4.37338501e-02f, -8.32271017e-03f, -3.15413982e-01f, 6.08133674e-02f, -1.47037460e-02f,
  -1.76951498e-01f, 1.51257426e-01f, -2.51476243e-02f, -9.32820421e-03f, -3.44454013e-02f, -6.59065917e-02f, -8.71523842e-02f, 1.83521584e-02f, 1.16803326e-01f, -8.90986174e-02f,
  -1.47900969e-01f, 1.65936793e-03f, 4.41771261e-02f, -1.67573735e-01f, -7.79706761e-02f, 1.71607770e-02f, 9.30697285e-03f, 5.36759757e-02f, 3.20260413e-02f, 1.02099374e-01f,
  9.43533704e-02f, 3.46782821e-04f, -7.22011402e-02f, 4.74810116e-02f, 2.96487939e-02f, 9.64476988e-02f, -4.84483652e-02f, -2.03612894e-02f, 4.73196199e-03f, 1.74238943e-02f,
  -2.62142457e-02f, -2.78287828e-02f, 5.28774895e-02f, 5.23433834e-02f, 3.66871394e-02f, -4.26829197e-02f, -7.59797841e-02f, -1.11479737e-01f, -7.16885775e-02f, -3.95850614e-02f,
  -1.89764500e-01f, -4.06687595e-02f, -8.98422748e-02f, 5.90857118e-02f, 6.90221563e-02f, -7.79210404e-02f, 6.95268735e-02f, -1.06633872e-01f, -1.05119817e-01f, 8.58946145e-03f,
  5.82258254e-02f, 1.83288291e-01f, -1.31079368e-02f, 3.28984261e-02f, 1.06169701e-01f, 9.10425335e-02f, 5.57315871e-02f, -2.58135766e-01f, -8.21122229e-02f, -2.27929819e-02f,
  -4.72978167e-02f, 4.05977890e-02f, 1.17129264e-02f, -1.37009740e-01f, -1.19878106e-01f, -8.02895948e-02f, 5.51635809e-02f, -9.76291969e-02f, 1.40157372e-01f, -1.06308468e-01f,
  7.26657221e-03f, -1.29949242e-01f, 1.23875318e-02f, 2.82113217e-02f, 1.76002041e-01f, -2.65486408e-02f, -2.19061747e-02f, 1.37004480e-01f, 5.79071455e-02f, -3.82728316e-02f,
  5.94738759e-02f, 1.01377279e-01f, 4.02732715e-02f, -8.67794640e-03f, 1.62784576e-01f, -5.67072630e-02f, -1.23796344e-01f, -2.60072481e-03f, 3.41376662e-02f, 1.01292558e-01f,
  8.24754685e-03f, -7.00270087e-02f, 5.77344112e-02f, 1.55089060e-02f, 3.95068973e-02f, -1.31041715e-02f, 9.31737125e-02f, 1.03999056e-01f, 6.11886643e-02f, -4.20811120e-03f,
  -3.28715928e-02f, 2.65609734e-02f, 6.10047430e-02f, -1.04279794e-01f, -1.34091213e-01f, -7.55512044e-02f, -1.19750470e-01f, -6.51697218e-02f, -7.66546875e-02f, -6.67325640e-03f,
  -2.28309967e-02f, 1.67723596e-02f, -1.32369578e-01f, 1.17620967e-01f, -6.86585158e-02f, -1.69375584e-01f, -5.49125224e-02f, -6.59837096e-04f, -5.63706877e-03f, 1.55581636e-02f,
  3.50479409e-02f, -2.04909071e-01f, -4.21590451e-03f, -8.96054208e-02f, 4.28743660e-02f, 1.49788171e-01f, 5.71212023e-02f, -1.24111742e-01f, 3.93308029e-02f, -9.34614167e-02f,
  4.93980339e-03f, 1.38636902e-01f, 1.56676412e-01f, -4.34638225e-02f, 2.57000774e-01f, -5.13667203e-02f, -2.56711803e-03f, -5.15254252e-02f, 2.38328993e-01f, -2.03297623e-02f,
  -1.24336801e-01f, -5.22442944e-02f, 1.44812971e-01f, 8.72101858e-02f, 6.36626454e-03f, -7.81231672e-02f, -5.30109368e-02f, -1.26402289e-01f, 9.02332217e-02f, 1.36225164e-01f,
  9.04805809e-02f, 4.94865365e-02f, -1.87303033e-02f, 3.65962349e-02f, 4.72282916e-02f, -9.88147780e-03f, -7.81816542e-02f, -1.10181361e-01f, 2.39709187e-02f, 8.48607123e-02f,
  1.52242273e-01f, 7.68197998e-02f, 1.61548719e-01f, -1.25384986e-01f, -7.54179247e-03f, 1.12446398e-01f, -9.85091776e-02f, -1.49911910e-01f, -5.62679246e-02f, 4.58315350e-02f,
  -4.44355374e-03f, -1.25657633e-01f, -2.66816288e-01f, -9.97330714e-03f, -5.65140229e-03f, 9.41209868e-02f, -7.24744098e-03f, 1.13337226e-01f, -9.33495685e-02f, -1.93115115e-01f,
  -1.32608831e-01f, 1.87994316e-02f, 1.03934966e-01f, -6.55646399e-02f, 8.88060182e-02f, 1.97989583e-01f, 7.84439221e-02f, 4.16154321e-03f, 1.43069133e-01f, 1.74854413e-01f,
  -6.89099133e-02f, 9.59619731e-02f, 1.06322996e-01f, -9.21397433e-02f, -2.08984837e-01f, 8.51909146e-02f, 4.54723015e-02f, 9.92094576e-02f, -5.86330034e-02f, 9.68164206e-03f,
  -1.64964229e-01f, -3.18160020e-02f, 8.09355546e-03f, 6.52934089e-02f, 7.89183378e-02f, 5.01590371e-02f, 1.27269238e-01f, 4.29767966e-02f, 7.44021535e-02f, 6.58063740e-02f,
  2.40718722e-02f, 4.67297547e-02f, 5.51166907e-02f, -2.28917062e-01f, -1.60354674e-01f, 1.02694370e-01f, 9.20280218e-02f, 5.93138933e-02f, 2.93831504e-03f, -1.59369290e-01f,
  -7.25484395e-04f, 4.62843217e-02f, 1.08340839e-02f, 1.61414687e-02f, -1.11131743e-02f, -1.35177502e-03f, -1.13870949e-01f, -3.94734368e-02f, 5.75328059e-02f, 6.48642853e-02f,
  2.10470796e-01f, -8.89493898e-02f, 7.13325739e-02f, 1.17290474e-01f, 3.25237475e-02f, -1.05879962e-01f, -1.70597866e-01f, 1.29802063e-01f, -2.03890592e-01f, 9.28399619e-03f,
  8.71638060e-02f, 1.41700000e-01f, -1.84604898e-02f, -2.12645352e-01f, -1.40627354e-01f, -1.31676435e-01f, -9.69691500e-02f, -1.64549962e-01f, 6.07145391e-02f, 1.71394378e-01f,
  1.45437106e-01f, -1.76075533e-01f, 8.22772756e-02f, 7.08209425e-02f, 1.14723787e-01f, 1.23412982e-01f, 1.12653397e-01f, -6.90772338e-03f, -8.04367959e-02f, 1.08450800e-01f,
  9.77666453e-02f, 5.91854453e-02f, 1.51850343e-01f, 2.74791062e-01f, 1.05761319e-01f, -1.20283075e-01f, 5.89492032e-04f, 1.40102774e-01f, 1.48986191e-01f, -9.01749283e-02f,
  8.80487114e-02f, -2.17938237e-02f, -3.43509726e-02f, 8.74814913e-02f, -8.17959085e-02f, -5.93232401e-02f, 9.43526775e-02f, 1.82180032e-01f, 4.12716977e-02f, 7.39516690e-02f,
  2.66380161e-02f, 2.98827868e-02f, -1.19711474e-01f, 1.38231711e-02f, -2.52983067e-02f, -9.44647416e-02f, 6.05221801e-02f, -4.03978862e-02f, 3.00362743e-02f, 6.67250296e-03f,
  6.40690103e-02f, -8.99220407e-02f, 2.07517091e-02f, 8.35563689e-02f, -1.46152839e-01f, -7.15207905e-02f, -2.86334585e-02f, -8.34736079e-02f, -4.70697954e-02f, 5.29520679e-03f,
  6.43562973e-02f, -1.06593668e-01f, -1.50804386e-01f, 1.65241629e-01f, -5.55893360e-03f, 4.41525765e-02f, -1.82404518e-02f, -3.16848576e-01f, 5.54438271e-02f, 6.08170740e-02f,
  -3.63082290e-02f, -1.45441350e-02f, -1.39811575e-01f, -1.55103549e-01f, -1.12452082e-01f, 1.06611639e-01f, 7.71752819e-02f, 2.63476092e-02f, -2.09189877e-02f, -1.01042993e-01f,
  1.26163274e-01f, 9.13806036e-02f, -2.45760784e-01f, 9.08817425e-02f, -2.71866564e-02f, -4.34047990e-02f, 8.32906831e-03f, 5.13057299e-02f, -1.55107304e-01f, 5.60492016e-02f,
  9.82429236e-02f, 1.57125250e-01f, -1.17185860e-04f, -1.81076184e-01f, -2.46342793e-02f, 4.72501628e-02f, 1.10207975e-01f, -1.08577192e-01f, -2.30125431e-02f, 2.65393183e-02f,
  -3.40799093e-02f, 6.51390105e-02f, -3.52142304e-02f, 1.33598059e-01f, 1.06767245e-01f, 8.66148546e-02f, 6.87859654e-02f, -9.38312078e-05f, 3.97749729e-02f, 1.94445923e-02f,
  7.07564726e-02f, -1.53757486e-04f, 6.45216703e-02f, -6.94776252e-02f, -5.61362728e-02f, -8.13896805e-02f, -3.58154029e-02f, 7.47039840e-02f, 1.39418587e-01f, 1.00950100e-01f,
  5.43745160e-02f, 1.00033805e-01f, 2.54807025e-01f, -3.98434922e-02f, -1.22836813e-01f, 1.86275542e-01f, 6.15083054e-02f, -1.15435220e-01f, 4.96099889e-02f, 1.06875837e-01f,
  -3.71813029e-02f, 2.23799311e-02f, -9.70960781e-02f, -1.09299324e-01f, 9.93923321e-02f, -1.69376388e-01f, 1.96396068e-01f, 2.45751485e-01f, 1.20227672e-01f, -6.98372647e-02f,
  -1.36791810e-01f, -4.88463007e-02f, 2.82757189e-02f, 8.11383128e-02f, 1.02046028e-01f, 1.78220477e-02f, 8.32897723e-02f, -2.55123843e-02f, -1.11614943e-01f, 1.11183114e-01f,
  -8.41997787e-02f, -8.74497518e-02f, 1.24437049e-01f, 5.81886992e-02f, -7.15499818e-02f, 1.85963716e-02f, 1.95981145e-01f, 7.52275884e-02f, 1.35062961e-04f, 4.60532196e-02f,
  -3.28679048e-02f, 1.06043816e-01f, 2.57855142e-03f, 6.61022495e-03f, 7.23862946e-02f, -1.31142035e-01f, -1.84525475e-01f, 5.14996387e-02f, 7.15186819e-03f, 8.36690292e-02f,
  -4.88160737e-02f, -4.20684814e-02f, -1.54080037e-02f, -2.95161009e-02f, -3.55493352e-02f, -1.60176065e-02f, -5.40320203e-02f, 2.71694325e-02f, 2.56001111e-03f, -1.67198732e-01f,
  3.92045416e-02f, 2.32504457e-02f, -9.94014367e-02f, -1.28336087e-01f, 3.86679135e-02f, 2.89948843e-02f, -7.35562444e-02f, 9.09356177e-02f, 1.40835764e-02f, -4.42465693e-02f,
  2.36112736e-02f, 5.78087121e-02f, 8.34550932e-02f, -1.29028345e-02f, 1.02379009e-01f, -3.32627334e-02f, -9.00947303e-02f, -9.76913199e-02f, 1.00456268e-01f, 6.44245297e-02f,
  1.39719576e-01f, -4.17355709e-02f, 3.65948607e-03f, -1.75853204e-02f, -8.21520686e-02f, 3.02243307e-02f, 1.44380093e-01f, -6.06152713e-02f, 5.23045249e-02f, -1.17649689e-01f,
  -7.59425089e-02f, 1.47810429e-01f, 1.62274852e-01f, -1.59435436e-01f, 1.03999592e-01f, -3.54120880e-02f, 1.84845738e-02f, 1.66743211e-02f, 1.78301439e-01f, -1.53087020e-01f,
  -1.37493595e-01f, 1.90070178e-02f, 1.93049744e-01f, 2.84787323e-02f, -5.69158234e-03f, 1.16769381e-01f, -1.47058694e-02f, -2.26698499e-02f, -3.32206711e-02f, -2.36828178e-02f,
  -2.50767153e-02f, -9.55949537e-03f, 5.69306463e-02f, -1.40582304e-03f, -1.04477115e-01f, -4.82607931e-02f, -5.62047921e-02f, 1.10688172e-02f, 1.05676413e-01f, 8.12398419e-02f,
  -1.01783015e-01f, -6.66852742e-02f, 1.49202673e-02f, -1.15765698e-01f, -4.72465828e-02f, 2.27715522e-02f, -5.63317463e-02f, -5.30597158e-02f, -1.58369087e-03f, 8.04418623e-02f,
  -3.62534784e-02f, 1.12336110e-02f, 2.49342397e-01f, -1.01777390e-01f, -6.78778961e-02f, 1.88740388e-01f, 9.25536677e-02f, -1.19285695e-01f, 7.63013288e-02f, -2.56083697e-01f,
  1.18618660e-01f, -4.25231345e-02f, -4.80336472e-02f, 1.78106520e-02f, -1.76796287e-01f, 1.13616303e-01f, 2.84880586e-03f, 1.44766018e-01f, 5.51165156e-02f, -1.58017293e-01f,
  1.74908102e-01f, -1.35645032e-01f, 1.04234092e-01f, 1.51115611e-01f, -4.11037728e-02f, 1.29495010e-01f, 6.09694161e-02f, -1.46145046e-01f, -5.10117896e-02f, 2.16377173e-02f,
  1.32703379e-01f, -3.53623647e-03f, -7.78631568e-02f, 1.11477301e-01f, 7.73786306e-02f, -1.71483189e-01f, 1.44662606e-02f, 5.78545406e-02f, -1.84847172e-02f, -1.07699009e-02f,
  -8.57492462e-02f, 6.42645508e-02f, 8.59145746e-02f, 1.25755191e-01f, 5.50557896e-02f, -8.32533985e-02f, -1.08576372e-01f, -4.56334762e-02f, -7.61919469e-02f, 8.70212018e-02f,
  -2.93015577e-02f, 6.72300681e-02f, -1.29837498e-01f, 3.27530294e-03f, -9.49093401e-02f, -4.77737281e-03f, -3.16211097e-02f, 5.74158244e-02f, 7.33696222e-02f, 5.94231859e-02f,
  -3.85519266e-02f, -3.09974812e-02f, 6.28037527e-02f, 4.40883003e-02f, -3.19076367e-02f, 8.93910825e-02f, 7.42939040e-02f, -1.24773597e-02f, -5.25637344e-02f, 8.40705112e-02f,
  7.79104680e-02f, -3.39794867e-02f, -1.37330025e-01f, -1.87319428e-01f, 8.71497765e-02f, 6.59844931e-03f, -9.44329053e-02f, 4.07068245e-02f, -7.64594600e-02f, -2.21763536e-01f,
  -3.86865549e-02f, 6.54089898e-02f, 4.54173796e-02f, 6.95493519e-02f, -6.65056258e-02f, -4.83888462e-02f, -7.06387684e-03f, 3.56555171e-02f, -1.90682769e-01f, 1.60877705e-01f,
  6.01588599e-02f, -8.79161879e-02f, 9.88533944e-02f, 1.43324286e-01f, -3.83516923e-02f, 3.00493129e-02f, 6.39384761e-02f, 1.71109185e-01f, 3.73066105e-02f, -3.76949906e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -5.20755257e-03f, 1.82582915e-01f, 1.30877569e-01f, 1.32639199e-01f, -5.00161462e-02f, 1.43376261e-01f, -5.14450669e-02f, 9.09728110e-02f, 8.14500824e-02f, -5.31061087e-03f,
  -7.94131011e-02f, -5.07996418e-02f, 3.20026502e-02f, -5.44139259e-02f, 1.26530021e-01f, 5.30952923e-02f, -2.51105666e-01f, 1.40533984e-01f, 9.09309834e-02f, 2.06984639e-01f,
  -2.61678286e-02f, 3.41519594e-01f, 2.97504395e-01f, 1.98301286e-01f, 1.29340202e-01f, -6.15831278e-02f, 1.41233668e-01f, -5.57924695e-02f, -8.39092806e-02f, -1.20931901e-01f,
  2.77088314e-01f, 1.22055508e-01f, 1.05456807e-01f, -1.94625348e-01f, -1.19529180e-01f, 8.25185254e-02f, 1.90964881e-02f, -1.32722735e-01f, -7.68512040e-02f, 2.67349869e-01f,
  -4.51065004e-01f, -1.33167356e-01f, -4.74719942e-01f, 8.46214071e-02f, -6.72969176e-03f, -2.21941620e-01f, 9.43593085e-02f, -9.01436657e-02f, -2.01851740e-01f, 1.95397347e-01f,
  -1.93229854e-01f, 3.34161252e-01f, 1.60629153e-02f, 5.41697666e-02f, 6.71193302e-02f, 2.95009822e-01f, 1.07736073e-01f, 5.53751528e-01f, -3.15542445e-02f, -2.19501778e-01f,
  -1.71589300e-01f, 4.39747989e-01f, 3.69780242e-01f, -5.45215085e-02f, 1.13669792e-02f, 1.21491581e-01f, 1.79428115e-01f, -3.27232433e-03f, 6.70034736e-02f, -7.99186379e-02f,
  2.67667085e-01f, 3.29416804e-02f, -2.84720375e-03f, 1.12186432e-01f, 1.46862909e-01f, 5.22285281e-03f, 6.58236491e-03f, -1.62440851e-01f, 5.46758845e-02f, -2.40015730e-01f,
  4.04583514e-02f, -1.67774916e-01f, 1.84330344e-01f, 7.92604983e-02f, 9.57223177e-02f, -5.97024709e-02f, -1.46569699e-01f, 1.14788406e-01f, 4.10915650e-02f, -2.13023856e-01f,
  -4.00310755e-02f, 2.55557559e-02f, -7.62827173e-02f, -7.03833252e-02f, -4.27978933e-01f, 2.35288858e-01f, -5.45272268e-02f, 4.22991812e-02f, -1.44271240e-01f, 1.34253487e-01f,
  -5.73067628e-02f, -1.04417004e-01f, -2.15461597e-01f, -4.25900184e-02f, 1.00925937e-01f, -1.79412499e-01f, 2.60514855e-01f, 2.02168196e-01f, 6.42928705e-02f, -2.46665254e-01f,
  7.66598061e-02f, 3.03124934e-01f, 6.24811165e-02f, 1.87262893e-01f, 2.55935401e-01f, -2.87527025e-01f, -6.49052188e-02f, 1.66822925e-01f, 1.57703653e-01f, -6.09741220e-03f,
  3.31517667e-01f, 1.15248829e-01f, 7.07220137e-02f, -1.69172421e-01f, 3.33064914e-01f, -1.31597281e-01f, 4.92860824e-02f, 1.47270471e-01f, -1.33808613e-01f, 1.57273054e-01f,
  1.19459666e-01f, -3.70496027e-02f, 1.15451127e-01f, -4.09594700e-02f, 7.97677040e-03f, 2.34779030e-01f, 1.86889768e-01f, 6.48257956e-02f, 7.83655141e-03f, -1.28803343e-01f,
  -4.85361367e-02f, 3.53527188e-01f, 2.35512167e-01f, 1.10738941e-01f, 2.70615935e-01f, 4.75104228e-02f, -2.35124484e-01f, -2.80102283e-01f, 2.53355950e-01f, -4.65525463e-02f,
  1.13867551e-01f, 1.30566014e-02f, -3.95492285e-01f, 1.67089894e-01f, 1.22094341e-01f, 2.07016245e-01f, -1.14807300e-01f, 2.54445393e-02f, 1.13029100e-01f, -1.93878099e-01f,
  -7.24663138e-02f, 4.53093886e-01f, 1.38731271e-01f, 3.90199721e-02f, 5.83030097e-02f, -1.06014505e-01f, 1.15319543e-01f, -2.07803011e-01f, 3.31316918e-01f, 5.90383820e-02f,
  9.27453041e-02f, -1.92138121e-01f, 3.31958413e-01f, 1.31662041e-01f, 4.52206254e-01f, 9.49408188e-02f, 3.77576947e-02f, -1.36420801e-01f, 5.20111620e-01f, 4.11648184e-01f,
  3.34203169e-02f, 2.44345471e-01f, 1.48012817e-01f, -1.31940186e-01f, 6.54400811e-02f, -2.80636609e-01f, 1.13996556e-02f, 4.60637957e-01f, 1.11617155e-01f, 1.59429535e-01f,
  4.71352339e-02f, 7.14787170e-02f, -3.12685668e-01f, -6.03535287e-02f, 1.18945599e-01f, -6.69712722e-02f, 1.30794257e-01f, 1.10988438e-01f, -7.16359466e-02f, -7.47230798e-02f,
  -1.95595697e-01f, 6.00461438e-02f, -8.76452103e-02f, -1.40289739e-01f, 6.05298243e-02f, 1.68377489e-01f, 2.68099993e-01f, 1.67187721e-01f, 1.60396248e-01f, 2.58350879e-01f,
  -4.29491736e-02f, -3.93223995e-03f, 1.63162261e-01f, -6.32982105e-02f, 2.89887451e-02f, -2.51121633e-02f, -1.03469834e-01f, -2.84147616e-02f, -3.34989727e-02f, 4.57662940e-02f,
  -5.91559000e-02f, -6.04854431e-03f, 2.28564098e-01f, -3.86835672e-02f, 8.18277299e-02f, -2.41620570e-01f, -5.36953006e-03f, -2.08638176e-01f, 2.40427434e-01f, 3.36977720e-01f,
  4.49966788e-02f, -6.84113875e-02f, 2.40391225e-01f, 9.53969732e-02f, 1.46508738e-01f, -2.33882293e-01f, 1.57931924e-01f, -4.38547134e-02f, -1.79501817e-01f, -1.52754962e-01f,
  8.64708349e-02f, -7.82424808e-02f, -1.97641745e-01f, 1.16981529e-01f, 4.46190804e-01f, 1.72842015e-02f, 3.84868324e-01f, -2.56721321e-02f, 2.82271653e-02f, -2.33480558e-01f,
  3.31016511e-01f, 1.93006381e-01f, 7.35313743e-02f, -2.74529040e-01f, -5.97616062e-02f, 3.74719709e-01f, 3.97106633e-02f, -9.22010988e-02f, 5.40469028e-02f, 1.13518208e-01f,
  -2.29538754e-02f, 1.34203047e-01f, 2.52155155e-01f, -1.13002047e-01f, -4.32459675e-02f, 6.91963658e-02f, -7.61083961e-02f, 1.89788431e-01f, -6.39245510e-02f, -2.98173279e-01f,
  -1.53972566e-01f, -1.36818439e-01f, -2.11733691e-02f, -3.26428503e-01f, 8.85258615e-02f, 7.38192126e-02f, -1.01182498e-01f, 1.15819156e-01f, -9.45374891e-02f, -4.72167321e-02f,
  2.22413376e-01f, -5.46427406e-02f, -2.30247736e-01f, -1.22011185e-01f, -1.52877904e-03f, 5.10412604e-02f, -3.30479175e-01f, 1.47835031e-01f, 1.93659253e-02f, -2.63998896e-01f,
  -2.54383951e-01f, 9.68482271e-02f, -2.17745513e-01f, 1.17826954e-01f, -1.68874651e-01f, 4.28225622e-02f, 1.03598006e-01f, 1.25781670e-02f, 2.26517469e-01f, -3.61759454e-01f,
  -1.88419014e-01f, -2.21092701e-01f, -1.58228606e-01f, 4.87706125e-01f, -5.15123904e-02f, 3.90828662e-02f, -1.06053948e-01f, -4.40424234e-01f, 2.22815841e-01f, 1.01572141e-01f,
  2.24537492e-01f, 1.22232884e-01f, 3.70680302e-01f, 1.42165989e-01f, 7.01111928e-02f, 3.25745670e-03f, 4.83604580e-01f, 4.73142602e-02f, -8.58163312e-02f, 5.05457759e-01f,
  -3.48503813e-02f, 5.48143275e-02f, -2.04783324e-02f, -7.37129822e-02f, 1.71429217e-01f, 2.40119435e-02f, -2.34464601e-01f, -9.21581313e-02f, -7.85455666e-03f, 2.67254710e-02f,
  1.88530669e-01f, 4.73214202e-02f, 2.59623349e-01f, 5.35352230e-02f, -4.73590866e-02f, 3.93992215e-02f, 7.24565312e-02f, -1.43722352e-02f, -8.66975784e-02f, -9.58049819e-02f,
  -1.61795169e-01f, -7.03621730e-02f, -8.00431147e-02f, 8.06581080e-02f, 2.13127285e-01f, 3.90852094e-01f, 1.94331631e-01f, 2.04433143e-01f, 3.40059340e-01f, -2.52249449e-01f,
  -9.44584683e-02f, 2.04164952e-01f, 4.37293872e-02f, 2.50431933e-02f, 1.46815971e-01f, 1.01092376e-01f, 9.25267339e-02f, 2.50458926e-01f, -1.32449090e-01f, -2.87692845e-01f,
  1.03437468e-01f, -3.91862206e-02f, 1.26604781e-01f, 2.54864573e-01f, 1.36477932e-01f, -1.51162505e-01f, -6.32018223e-02f, -1.17292270e-01f, 1.63742512e-01f, 1.66314691e-01f,
  2.94687897e-01f, 3.58625948e-01f, 2.89264798e-01f, 5.28245866e-02f, 4.69094180e-02f, 3.83823693e-01f, -2.62556970e-01f, -4.22698781e-02f, 3.34814399e-01f, -4.28891778e-01f,
  -1.88460335e-01f, 1.14435241e-01f, 3.02295297e-01f, 5.16344942e-02f, 1.06603734e-01f, -1.36663586e-01f, 1.76513791e-02f, 1.01705149e-01f, 1.76294858e-03f, 1.24180652e-01f,
  4.22174595e-02f, 1.14875965e-01f, 8.58865753e-02f, -3.91786695e-02f, -8.96275491e-02f, 4.22557481e-02f, -1.10614210e-01f, -7.55615383e-02f, -7.62300938e-02f, -1.58586919e-01f,
  -1.86808303e-01f, -7.87865222e-02f, 1.43254086e-01f, 6.70027584e-02f, 5.09626381e-02f, 1.67273670e-01f, 5.15352339e-02f, 2.21608132e-02f, 7.14161545e-02f, 5.57399839e-02f,
  -1.26596376e-01f, -1.14663944e-01f, -1.32688768e-02f, 9.07047316e-02f, 2.42595106e-01f, -5.94261587e-02f, 9.05596688e-02f, -7.68671110e-02f, -2.01765358e-01f, 2.66790087e-03f,
  -7.52767324e-02f, -1.72089264e-01f, -3.22460756e-02f, 2.87012100e-01f, -3.56940031e-01f, -1.70284677e-02f, -3.68073493e-01f, -1.57805383e-01f, -3.59327823e-01f, 7.81565979e-02f,
  -9.04361829e-02f, 7.54521564e-02f, -1.57539457e-01f, -1.03714049e-01f, -8.00294280e-02f, 1.95942074e-01f, 2.46773124e-01f, 3.61667760e-02f, -8.29222575e-02f, 9.24612358e-02f,
  1.08687527e-01f, 2.95455903e-01f, -1.40413284e-01f, 1.36694849e-01f, 2.42175087e-02f, 3.43889356e-01f, 6.68961778e-02f, 1.63274080e-01f, 5.96597500e-04f, -4.23716977e-02f,
  2.44953334e-02f, -1.06428534e-01f, -7.80306682e-02f, 1.04921181e-02f, 1.50053957e-02f, 1.25492558e-01f, 1.53265651e-02f, -9.95150506e-02f, -1.98880155e-02f, -5.32200700e-03f,
  6.33895844e-02f, -7.69836158e-02f, -3.82645801e-02f, -9.45604295e-02f, -9.25581157e-02f, 2.81212423e-02f, 1.34080082e-01f, 1.32797495e-01f, 4.81974930e-02f, 6.79828525e-02f,
  -2.47040689e-02f, 5.21254539e-02f, -7.98507687e-03f, -8.07271972e-02f, -4.92916778e-02f, -3.20061627e-05f, 9.15263146e-02f, -1.46334216e-01f, -1.59478277e-01f, 1.99504763e-01f,
  8.16441849e-02f, -1.23266853e-01f, -1.42870814e-01f, 4.77065193e-03f, -5.40435947e-02f, 6.33090660e-02f, -1.17865562e-01f, 7.39369988e-02f, -2.46592704e-02f, -1.08918414e-01f,
  -4.82649691e-02f, 1.85777083e-01f, -1.96392715e-01f, -1.46651015e-01f, -1.32954985e-01f, 1.55301005e-01f, -6.72168136e-02f, 1.07971564e-01f, 1.10492855e-01f, -9.40944925e-02f,
  1.78068608e-01f, -6.81040734e-02f, -1.08549416e-01f, 3.08556765e-01f, -8.61052796e-02f, 1.31990872e-02f, -3.30746844e-02f, -1.78236067e-01f, 9.54497382e-02f, -8.72178152e-02f,
  -1.72111988e-02f, 1.90439597e-01f, 1.10595517e-01f, -1.30987868e-01f, -3.53498347e-02f, 1.42579809e-01f, 1.61872149e-01f, 1.18997514e-01f, 3.63603346e-02f, -3.05767179e-01f,
  -1.81008756e-01f, -3.30068953e-02f, 1.69778720e-01f, 7.50659257e-02f, 1.16577238e-01f, -2.19917670e-01f, 2.17792597e-02f, 1.10261545e-01f, 3.83527689e-02f, -7.02427179e-02f,
  1.12264119e-02f, 1.45358875e-01f, -1.37231886e-01f, -6.79222643e-02f, -9.34149548e-02f, 1.61942840e-02f, 2.48457849e-01f, 3.11372634e-02f, -3.04674618e-02f, 4.35021259e-02f,
  1.07707962e-01f, -2.10371330e-01f, 9.54058468e-02f, 1.05062179e-01f, -5.43829016e-02f, -1.21157736e-01f, 1.84730012e-02f, -3.56725901e-02f, 1.31575048e-01f, 1.99895222e-02f,
  -2.37280652e-01f, -1.48677766e-01f, -1.55336082e-01f, -7.14034811e-02f, -7.85706472e-03f, 2.61258543e-01f, -8.07135999e-02f, -1.08813114e-01f, -3.85175824e-01f, -1.22776315e-01f,
  1.85506955e-01f, -8.57564956e-02f, -8.82671922e-02f, -3.82643379e-02f, 2.06663504e-01f, 1.41077653e-01f, 2.64210433e-01f, 1.45752415e-01f, 1.25930026e-01f, 1.70226112e-01f,
  2.25170195e-01f, -3.35673273e-01f, 2.30129600e-01f, -7.92765431e-03f, -3.22309956e-02f, 1.83390886e-01f, 4.05603983e-02f, -1.17925242e-01f, -7.17330202e-02f, 1.03776909e-01f,
  -4.27947799e-03f, -4.09473777e-02f, 6.49978593e-02f, 7.20070582e-03f, -9.92878340e-03f, -8.48001912e-02f, -1.42043620e-01f, 9.74668786e-02f, -9.79935229e-02f, 1.54727977e-03f,
  -8.48601386e-02f, 5.79009131e-02f, 6.23771176e-02f, 6.38933405e-02f, -3.78712974e-02f, -1.10044532e-01f, -4.94146533e-03f, 2.74066087e-02f, 1.94215756e-02f, -1.04230754e-02f,
  -1.70829128e-02f, 7.85309263e-03f, -1.33565992e-01f, -1.59808844e-01f, -6.52766079e-02f, 2.07335696e-01f, 1.69250175e-01f, -1.69363603e-01f, -3.71050462e-02f, 1.93467662e-02f,
  -6.93167746e-02f, -2.95808390e-02f, -1.37595385e-01f, -1.53347701e-01f, 1.96506202e-01f, 1.94802612e-01f, -1.08251520e-01f, -5.24114445e-02f, -1.07656591e-01f, -1.64513305e-01f,
  -1.38108417e-01f, 2.20468283e-01f, -4.04678583e-02f, 7.06718164e-03f, -1.46862730e-01f, -1.31245911e-01f, -9.51036985e-04f, 3.05157542e-01f, 2.62434363e-01f, -2.25851983e-02f,
  -1.33554399e-01f, 1.40336752e-02f, 3.53431376e-03f, 8.37617815e-02f, -8.06890577e-02f, 4.50587273e-01f, -2.32263669e-01f, 2.86414295e-01f, -1.20326780e-01f, 1.16728425e-01f,
  1.93125084e-02f, 9.43326950e-02f, 5.14722280e-02f, -1.68245375e-01f, -9.29906890e-02f, 1.94825307e-02f, -4.40695286e-02f, 2.93042183e-01f, 2.65777677e-01f, 2.08110650e-04f,
  -2.12288499e-01f, -4.73239757e-02f, 3.09768729e-02f, 5.23809604e-02f, -1.90628424e-01f, 7.24926889e-02f, -7.43306279e-02f, -5.39744906e-02f, 3.48006189e-02f, -1.78528026e-01f,
  6.39647320e-02f, 7.83468634e-02f, -5.45474030e-02f, 4.27372381e-02f, 3.60375382e-02f, 8.47522691e-02f, -1.43478513e-01f, -8.17045942e-02f, 1.64896309e-01f, -5.53801991e-02f,
  -2.64481485e-01f, 3.81451026e-02f, -3.15399617e-02f, -3.57907228e-02f, -6.52946830e-02f, 6.28691837e-02f, -2.44524673e-01f, -1.33608282e-01f, 1.87890567e-02f, 1.49662569e-01f,
  6.65085465e-02f, -8.28976184e-02f, 4.13420498e-02f, -3.65792997e-02f, -1.46385223e-01f, -1.05498265e-02f, 1.37933522e-01f, 2.17938945e-01f, -1.53963313e-01f, 1.54546380e-01f,
  4.44247514e-01f, 2.75741100e-01f, 5.03885224e-02f, 1.11651354e-01f, -2.35789314e-01f, 1.89944774e-01f, -3.32394317e-02f, 1.42228916e-01f, -1.30001903e-01f, 1.11756578e-01f,
  -2.45272461e-02f, 3.42890978e-01f, 1.78068206e-01f, 2.48141423e-01f, 1.59783244e-01f, 1.00810781e-01f, -1.05911337e-01f, 1.79988325e-01f, -1.41463175e-01f, 2.47283559e-02f,
  -7.39685670e-02f, 6.81381077e-02f, 3.40418667e-02f, 7.52098411e-02f, 1.26975864e-01f, 1.03278868e-01f, -2.16865689e-01f, -2.18878221e-02f, -1.28911555e-01f, 1.32705763e-01f,
  5.04344031e-02f, 4.65328060e-02f, -4.49100621e-02f, -1.50298432e-01f, -6.54958710e-02f, -1.26594454e-01f, 1.16287954e-01f, -1.18315458e-01f, -1.39524927e-02f, -2.78000414e-01f,
  1.21527612e-01f, 1.95976585e-01f, -1.06751900e-02f, -1.01966850e-01f, 5.46486676e-02f, 4.45157364e-02f, 6.80717975e-02f, 1.82481840e-01f, 3.51053625e-01f, -1.96589418e-02f,
  1.63557790e-02f, -3.65775287e-01f, -8.73698071e-02f, -1.41033635e-01f, -8.60488191e-02f, -1.93018466e-02f, -1.18503012e-01f, 1.88286323e-02f, 3.94049063e-02f, -2.91213319e-02f,
  1.04109615e-01f, 7.62182055e-03f, 1.71476126e-01f, -2.31996551e-02f, 2.28948221e-01f, 7.47501329e-02f, -4.40476537e-01f, 4.59074289e-01f, 1.85855329e-01f, -7.49734342e-02f,
  4.18761939e-01f, 2.04182252e-01f, 1.93673700e-01f, -1.16294280e-01f, 2.56647527e-01f, 7.71032050e-02f, 2.60828793e-01f, -8.95187408e-02f, 8.69476721e-02f, 1.16186462e-01f,
  -6.99163135e-03f, 4.72757593e-02f, -1.41840037e-02f, 6.16324171e-02f, 7.98440203e-02f, -1.76537648e-01f, -1.56076968e-01f, 1.74774796e-01f, 1.77461773e-01f, 7.89457783e-02f,
  -9.68121663e-02f, -3.22391763e-02f, 1.52648121e-01f, -1.28589541e-01f, 5.03708026e-04f, -2.78356601e-03f, 1.93790328e-02f, 1.15664192e-01f, 5.99951781e-02f, -1.10808974e-02f,
  3.48728299e-02f, 2.64137201e-02f, 7.42307231e-02f, -1.82210341e-01f, 6.16241731e-02f, 1.15743585e-01f, -1.52601972e-01f, -1.47057503e-01f, 6.92045614e-02f, 1.44137546e-01f,
  2.29013730e-02f, -8.04841295e-02f, 6.08574413e-02f, 5.11471294e-02f, 1.97052300e-01f, 2.58553810e-02f, -1.74273372e-01f, -9.90830585e-02f, 2.11781845e-03f, 5.49163446e-02f,
  2.20182654e-03f, 9.96405929e-02f, 8.80507603e-02f, -1.72731593e-01f, -1.07506447e-01f, -1.12624496e-01f, 1.80089056e-01f, 1.20420530e-02f, -2.08931729e-01f, -1.08470529e-01f,
  5.10428473e-02f, 2.51866698e-01f, 2.58408546e-01f, -1.62575588e-01f, 3.18922490e-01f, 1.49177447e-01f, 2.31617004e-01f, -1.28563121e-01f, 3.96868914e-01f, -1.69459805e-01f,
  -9.85819176e-02f, 1.10423982e-01f, -1.12630576e-01f, 1.21597387e-02f, 1.19280279e-01f, 3.08382586e-02f, -6.44369572e-02f, 1.68086752e-01f, -1.78687975e-01f, -1.01385698e-01f,
  -1.09828133e-02f, 6.34615421e-02f, 1.07626244e-01f, 5.31274453e-02f, -3.83117911e-03f, -9.75190103e-03f, 2.10180312e-01f, 8.28434080e-02f, -4.22525741e-02f, 1.87858880e-01f,
  -1.37588724e-01f, -1.15869958e-02f, -2.06449907e-02f, 2.17640977e-02f, 1.20422825e-01f, 1.09173521e-01f, 2.00196132e-01f, 1.47113621e-01f, 2.25833207e-01f, 1.68761700e-01f,
  3.16290826e-01f, -2.42835507e-02f, 3.27286720e-01f, 2.13100120e-01f, 1.19219162e-01f, -2.54987150e-01f, 1.23988248e-01f, 1.89790521e-02f, 1.25334710e-01f, 2.20594704e-01f,
  -5.09641580e-02f, -9.41588879e-02f, -3.20025906e-02f, -1.17996998e-01f, -5.29717915e-02f, 1.55943021e-01f, 1.32617839e-02f, -6.93501160e-02f, -2.74888068e-01f, -2.94792235e-01f,
  9.84384045e-02f, 2.34998558e-02f, -2.65639931e-01f, 3.24717462e-01f, 4.38690603e-01f, 3.16790976e-02f, 5.97693808e-02f, 1.21681191e-01f, -8.01303238e-02f, 5.86444065e-02f,
  3.73192251e-01f, 1.88622810e-02f, -3.10032576e-01f, -8.61958638e-02f, 1.89310297e-01f, 2.15245679e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.48112506e-01f, 1.81936547e-01f, 2.19870642e-01f, 1.72945142e-01f, -6.05131453e-03f, 2.02058610e-02f, 2.82914145e-03f, 1.21065218e-03f, -1.67998835e-03f, 5.61398119e-02f,
  1.24604501e-01f, 1.23670302e-01f, 2.84915082e-02f, 7.70491585e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -7.94072971e-02f, 3.86028029e-02f, -4.49642576e-02f, 1.42461687e-01f, 3.17182988e-02f, -3.04070383e-01f, -2.88637895e-02f, 9.65442583e-02f, 4.00475487e-02f, -9.99920070e-03f,
  -1.20666334e-02f, 1.36515722e-01f, -1.18877158e-01f, 4.53129411e-03f, 1.62387341e-01f, -2.01472357e-01f, -7.48144314e-02f, 4.99153882e-02f, -2.43312553e-01f, 1.13432318e-01f,
  1.63234919e-01f, -1.92794815e-01f, -7.13446876e-03f, 4.97890189e-02f, 2.16449481e-02f, 1.62340328e-01f, 2.00634763e-01f, 2.98414707e-01f, 7.11728111e-02f, -3.15509260e-01f,
  -2.62491941e-01f, -2.93451607e-01f, 3.48686993e-01f, -3.45688522e-01f, 2.21862257e-01f, -2.63695925e-01f, 1.60256386e-01f, 2.33985931e-01f, -3.00775588e-01f, 1.87057316e-01f,
  -2.25328341e-01f, -2.71725595e-01f, -1.97609231e-01f, 2.72816569e-01f, -7.92745128e-03f, -3.94449115e-01f, 2.70474106e-01f, -2.71211863e-01f, -2.86735356e-01f, -3.62402856e-01f,
  -8.23885128e-02f, 1.95838213e-01f, 2.94128776e-01f, -1.26698390e-01f, -3.13982844e-01f, 1.73227504e-01f, -2.71599263e-01f, 1.41602069e-01f, -4.39256251e-01f, -3.31718713e-01f,
  1.72880396e-01f, -2.83091396e-01f, -2.57506639e-01f, -1.35401711e-01f, 2.60962486e-01f, 2.36981362e-01f, 1.47982612e-01f, -1.82468519e-01f, -1.53127149e-01f, 2.11647063e-01f,
  -1.24358043e-01f, 8.30848292e-02f, 8.01547915e-02f, 1.39636323e-01f, 1.40890628e-01f, -1.36017755e-01f, -1.56194091e-01f, 5.93630448e-02f, -2.37484708e-01f, -2.99438685e-02f,
  5.65834045e-02f, 1.85666457e-02f, -1.75013930e-01f, 1.33460373e-01f, -5.32481149e-02f, 3.01964022e-02f, -9.68096629e-02f, 3.44078988e-02f, 1.37444407e-01f, -4.73034345e-02f,
  -1.76824212e-01f, -2.20592037e-01f, 5.68737229e-03f, 7.66072050e-02f, 1.63941741e-01f, -5.52768521e-02f, -3.22638601e-01f, -1.51398271e-01f, 1.79764286e-01f, -1.60991669e-01f,
  3.42474431e-01f, 7.88689926e-02f, -3.05708736e-01f, -2.15163723e-01f, -2.32246742e-01f, -2.50421375e-01f, 9.61801708e-02f, 1.48478046e-01f, 1.76102653e-01f, 2.86721271e-02f,
  1.55380249e-01f, 2.08597481e-01f, 2.81101316e-01f, 2.04988852e-01f, -4.18478221e-01f, 2.17832401e-01f, 3.86954620e-02f, -4.87775058e-01f, 5.45089990e-02f, 4.99215908e-03f,
  -1.27962396e-01f, 4.11744341e-02f, 6.57084659e-02f, -2.54458319e-02f, 1.16552129e-01f, 2.98577964e-01f, 4.74309213e-02f, -4.03825313e-01f, -2.81638891e-01f, -1.07870482e-01f,
  1.02329321e-01f, -2.09187627e-01f, 7.91047588e-02f, 5.24327494e-02f, 1.49235517e-01f, 8.01063254e-02f, -2.72851676e-01f, 6.84587583e-02f, 4.23933156e-02f, 1.78162456e-01f,
  -1.37784347e-01f, 3.79651003e-02f, -1.56292632e-01f, -2.68431590e-03f, -1.28613546e-01f, 1.64394919e-02f, 7.05289617e-02f, -1.99325472e-01f, 1.69727877e-01f, -5.01590148e-02f,
  -1.29410520e-01f, 1.24625176e-01f, -3.59017029e-02f, 1.64458379e-01f, -3.80199067e-02f, -1.55891124e-02f, -1.84350479e-02f, 5.04333414e-02f, 1.92667872e-01f, 5.14571406e-02f,
  1.63265690e-01f, 1.64383993e-01f, -1.85861856e-01f, -1.83569968e-01f, -2.91386098e-02f, 1.06341615e-02f, 3.66124660e-01f, -8.28582570e-02f, -1.15418546e-02f, 1.34568304e-01f,
  -1.94405496e-01f, -1.43118590e-01f, 2.03769982e-01f, -1.98701084e-01f, -1.41587600e-01f, 6.30117022e-03f, -8.41918737e-02f, 1.50779486e-01f, -3.80860239e-01f, 8.90780389e-02f,
  -1.18515708e-01f, 1.36213243e-01f, 4.13745612e-01f, -3.40620428e-01f, -3.01512569e-01f, -2.34554559e-01f, 1.71717554e-01f, 8.24799985e-02f, -2.96949923e-01f, 2.96026357e-02f,
  2.21999243e-01f, -3.21561337e-01f, -1.74145043e-01f, -9.60810333e-02f, 8.27401951e-02f, -3.26208659e-02f, -1.89751223e-01f, -4.02210355e-02f, -2.12848768e-01f, -1.35926411e-01f,
  -2.00711995e-01f, -7.16711730e-02f, -1.41580522e-01f, -2.85409186e-02f, 1.88409492e-01f, 5.76818474e-02f, -2.49901161e-01f, -6.82519749e-02f, -1.38963945e-02f, -8.46526176e-02f,
  6.37134016e-02f, -2.75269955e-01f, -5.31963855e-02f, -1.22518493e-02f, 1.61116213e-01f, -1.42963573e-01f, 9.02456343e-02f, 1.39730498e-01f, 4.69034575e-02f, 2.31948465e-01f,
  2.30690196e-01f, 5.56251518e-02f, -1.05287276e-01f, 1.98649272e-01f, 1.51810899e-01f, 1.26935527e-01f, -2.70296454e-01f, 1.79757345e-02f, -2.49717861e-01f, 1.63755476e-01f,
  -5.45056574e-02f, -2.32223645e-01f, -1.09146401e-01f, 3.38331640e-01f, -2.00400978e-01f, -2.34202474e-01f, 6.98423088e-02f, -2.20846444e-01f, 1.82891831e-01f, -1.86168253e-01f,
  -1.79123461e-01f, -1.61841929e-01f, -3.91945809e-01f, -4.78639483e-01f, 7.98800141e-02f, 2.41746798e-01f, 8.47738683e-02f, -3.52664709e-01f, 3.84531468e-02f, 3.15717384e-02f,
  -4.14762765e-01f, 2.55188882e-01f, 3.93561013e-02f, -1.22224867e-01f, -3.85407358e-01f, 2.44640991e-01f, 1.40244246e-01f, 5.17480150e-02f, -3.18749338e-01f, 1.25217572e-01f,
  1.28544629e-01f, -1.25172362e-01f, 2.03019977e-01f, 2.37613358e-02f, -4.37221117e-02f, -2.17068717e-02f, -1.34494066e-01f, 2.37203278e-02f, 1.04768828e-01f, 7.74099305e-02f,
  1.99212343e-01f, 5.68623468e-02f, 1.95692912e-01f, -9.57675427e-02f, 1.06255502e-01f, 2.46188000e-01f, -8.27313885e-02f, 6.24586456e-02f, -1.73500016e-01f, -1.75288189e-02f,
  6.22080937e-02f, 6.85923547e-02f, 1.52390942e-01f, -9.12306756e-02f, -1.14373296e-01f, 3.84430736e-01f, 5.89890517e-02f, -1.66312128e-01f, 3.35528031e-02f, 2.00569645e-01f,
  2.08572462e-01f, -1.50269553e-01f, 1.89333513e-01f, 1.80255860e-01f, -1.47707358e-01f, -1.01526994e-02f, 1.17561087e-01f, -1.99562028e-01f, 4.32387777e-02f, -6.76828474e-02f,
  -9.11677442e-03f, -1.77502126e-01f, 5.53368218e-03f, 9.55940858e-02f, -2.39970356e-01f, -2.10040316e-01f, 2.38265663e-01f, -2.85340756e-01f, -5.68471432e-01f, 6.75252685e-03f,
  -4.70944680e-02f, 7.33149424e-02f, 2.34278888e-01f, 2.99100935e-01f, 1.25597119e-01f, 2.60520726e-02f, 1.69554725e-01f, -4.44907844e-01f, -3.72469664e-01f, 1.74723700e-01f,
  1.15295067e-01f, -4.22293469e-02f, 1.91965461e-01f, -1.18263155e-01f, -1.94129169e-01f, 1.21563546e-01f, -8.28003511e-02f, -5.28169572e-02f, -9.24225524e-02f, -1.34311453e-01f,
  -8.06562752e-02f, -1.69853255e-01f, 2.28594313e-03f, 4.95019145e-02f, -1.15544215e-01f, 1.10404067e-01f, -3.91920246e-02f, -8.90243649e-02f, 1.99818119e-01f, -3.64207983e-01f,
  1.55908272e-01f, 7.14283762e-03f, -2.40287129e-02f, -8.42114910e-02f, -1.16811760e-01f, -8.83648992e-02f, -1.73799112e-01f, -1.47924244e-01f, -1.04448520e-01f, -4.39260677e-02f,
  -4.55468073e-02f, 7.45398924e-02f, -1.97429851e-01f, -1.66840732e-01f, -8.15474689e-02f, 1.75671712e-01f, -2.13169917e-01f, 8.61212537e-02f, -7.26760039e-03f, 9.96120926e-03f,
  1.94470137e-01f, 6.47812486e-02f, -2.27383927e-01f, 1.48793058e-02f, 3.05797327e-02f, 1.30316168e-01f, 2.26448596e-01f, -1.70382246e-01f, 2.43114486e-01f, 1.87732443e-01f,
  2.84028441e-01f, -2.61445969e-01f, 1.50317296e-01f, -4.73380268e-01f, -4.82834160e-01f, 1.28101274e-01f, 8.06074962e-02f, -1.19426198e-01f, -1.81413844e-01f, -5.77024594e-02f,
  1.21946789e-01f, 1.46985978e-01f, -1.40599057e-01f, 1.63334146e-01f, -2.11902887e-01f, -7.56847784e-02f, 1.45427153e-01f, -1.45864815e-01f, -1.53253123e-01f, -2.01665491e-01f,
  -2.20837697e-01f, -1.49622262e-01f, 2.18704455e-02f, -1.49142742e-01f, 1.32598907e-01f, -1.46622986e-01f, 1.17280073e-01f, -2.07384765e-01f, 8.17410424e-02f, 1.21603578e-01f,
  7.03463927e-02f, 1.82121843e-01f, 5.65617867e-02f, -1.35920554e-01f, 6.85349256e-02f, 1.13854244e-01f, 5.29253297e-03f, -3.52517404e-02f, 8.71711075e-02f, 9.97081175e-02f,
  7.40694553e-02f, -2.60154605e-01f, 3.35521139e-02f, 1.07597530e-01f, 2.71081299e-01f, -1.05501182e-01f, 3.09040491e-02f, 1.18411869e-01f, 1.59076527e-01f, -7.24793673e-02f,
  3.11810553e-01f, -1.79114953e-01f, 2.12095007e-01f, 1.72782525e-01f, 3.45608652e-01f, -3.20208371e-01f, 2.27691472e-01f, 2.01339442e-02f, -2.06260368e-01f, -3.57558355e-02f,
  1.93201378e-02f, 2.99439520e-01f, 2.52020299e-01f, 1.54635549e-01f, 2.13808328e-01f, 1.14939176e-01f, -2.77937889e-01f, -8.97341818e-02f, -3.03573698e-01f, -1.00997642e-01f,
  -8.07959680e-03f, 2.64773332e-02f, 2.27582872e-01f, -2.12467670e-01f, -3.86507243e-01f, 7.46273920e-02f, 2.92627692e-01f, 2.12423623e-01f, 4.10348885e-02f, 3.68200317e-02f,
  1.85031950e-01f, -9.35386866e-02f, 1.63235918e-01f, 3.45029794e-02f, 2.84770057e-02f, -6.34259731e-02f, 5.55549078e-02f, 8.94357711e-02f, 1.03308767e-01f, 4.91179265e-02f,
  -2.69702747e-02f, -1.32988077e-02f, 7.05146044e-02f, -1.30934060e-01f, 7.67140761e-02f, 4.76490073e-02f, 8.88019726e-02f, 7.99751431e-02f, -1.22886688e-01f, -5.38854785e-02f,
  -5.88897094e-02f, 3.13882008e-02f, 2.99748983e-02f, 1.28105760e-01f, 1.59992009e-01f, -2.14841574e-01f, 1.68626502e-01f, 4.04353105e-02f, 2.42148474e-01f, 8.54311660e-02f,
  2.03460753e-01f, -3.93050238e-02f, 3.25243510e-02f, 1.47064179e-01f, 1.73023701e-01f, 7.31136948e-02f, -5.77192195e-02f, -4.27594073e-02f, -2.07774211e-02f, -1.19712271e-01f,
  -1.60553783e-01f, -1.71096057e-01f, -8.65092874e-02f, 2.15302020e-01f, -1.90876529e-01f, -1.35182485e-01f, 2.05577672e-01f, 1.33379713e-01f, 2.43515633e-02f, -2.39116132e-01f,
  3.39912206e-01f, -3.85810524e-01f, -9.67123508e-02f, -4.67196286e-01f, 3.03819358e-01f, -2.49279201e-01f, -2.01987043e-01f, 4.22919154e-01f, 1.62580013e-01f, -2.36812532e-01f,
  -1.04287699e-01f, -5.13146996e-01f, -2.98769437e-02f, -1.72037125e-01f, -1.63551793e-01f, 2.88834631e-01f, -8.75642300e-02f, -9.42296907e-02f, -2.43770089e-02f, -1.42877700e-03f,
  1.81686521e-01f, -2.90075243e-02f, 1.84588566e-01f, -1.61332607e-01f, 2.23862901e-01f, 8.04029554e-02f, 1.11526713e-01f, 1.76388562e-01f, 9.50857326e-02f, -1.47523552e-01f,
  1.67781398e-01f, 3.08760524e-01f, -1.25075459e-01f, -1.12944499e-01f, -1.52389005e-01f, -1.62879422e-01f, 7.38859922e-02f, -1.62531763e-01f, 1.14666328e-01f, -3.00494842e-02f,
  -1.82889774e-01f, -5.92365526e-02f, 8.62828493e-02f, 2.66706526e-01f, -2.04392299e-01f, 1.28057286e-01f, -2.18379796e-01f, 1.58087522e-01f, -3.05484772e-01f, -1.58012256e-01f,
  -1.98998109e-01f, 1.71709761e-01f, 1.17900848e-01f, 2.95073897e-01f, 1.96772978e-01f, 1.60628930e-02f, -5.34320697e-02f, 2.94544756e-01f, -2.65304565e-01f, 1.35984883e-01f,
  1.43277019e-01f, 6.23702519e-02f, -3.28053594e-01f, -1.24837562e-01f, 5.13020098e-01f, 2.59315163e-01f, -3.89667302e-01f, -2.59495199e-01f, -1.42859131e-01f, -2.17073530e-01f,
  -1.21866696e-01f, 2.94427131e-03f, -2.21654549e-01f, 1.63549945e-01f, 1.14108756e-01f, -2.16757119e-01f, -1.74419835e-01f, 1.89832523e-01f, -1.24962613e-01f, 1.52012452e-01f,
  8.04324895e-02f, 1.83354378e-01f, 1.03009880e-01f, -1.42529830e-01f, -1.10407636e-01f, 6.85736910e-02f, 1.32110924e-01f, 1.68598518e-01f, 1.79628097e-02f, 4.00642790e-02f,
  2.00351298e-01f, 2.25085439e-03f, 1.01902239e-01f, -4.33223881e-02f, -9.50503442e-03f, -1.62239105e-01f, -7.90699795e-02f, -6.20651990e-02f, 5.09324297e-02f, -8.50839242e-02f,
  -1.67452246e-01f, -1.99671373e-01f, -1.13393538e-01f, 2.27803051e-01f, -8.42554867e-02f, -1.66705459e-01f, -9.39899683e-02f, 3.60083655e-02f, -2.41095975e-01f, 1.79896906e-01f,
  1.39628366e-01f, 6.89775124e-02f, -1.22055886e-02f, 2.26953775e-01f, 3.28898221e-01f, 9.40068886e-02f, -1.69894025e-01f, -1.88675872e-03f, 7.29520023e-02f, 1.60410792e-01f,
  8.29106495e-02f, 2.27875099e-01f, -2.58837849e-01f, -7.18089864e-02f, -2.12353349e-01f, 6.14068173e-02f, 2.92477965e-01f, 1.10335357e-01f, -4.24107254e-01f, -4.14488703e-01f,
  3.01113129e-01f, -5.38244426e-01f, 1.91777751e-01f, 1.83962747e-01f, -2.14671791e-01f, -1.76843822e-01f, 1.00520097e-01f, -3.69573496e-02f, 5.43803945e-02f, -3.66726905e-01f,
  8.17463323e-02f, 1.89310297e-01f, -2.09955990e-01f, 1.12182945e-01f, -1.58875838e-01f, -2.47166101e-02f, 5.45864552e-02f, 1.71058133e-01f, -6.11437671e-02f, -2.59360997e-03f,
  -1.37908831e-01f, 1.12476923e-01f, -5.81543446e-02f, 2.55894288e-02f, -7.11875930e-02f, 4.04066034e-03f, -2.21094280e-01f, -1.42123606e-02f, -9.35180485e-02f, -1.03223935e-01f,
  -4.60556820e-02f, -2.34083962e-02f, -4.01374511e-02f, -1.39673114e-01f, -1.88555866e-01f, -1.60640419e-01f, 1.31878138e-01f, 1.22179613e-01f, -2.18398929e-01f, 2.03302860e-01f,
  -2.36283466e-01f, 1.19335026e-01f, -6.72815740e-02f, 1.75847128e-01f, -2.57613152e-01f, 3.72006707e-02f, -1.29388705e-01f, -2.30174974e-01f, -1.28349826e-01f, 7.91769400e-02f,
  -1.45707756e-01f, 6.58486933e-02f, 2.42926434e-01f, -1.65698137e-02f, -3.15326273e-01f, 6.23750575e-02f, 5.92725128e-02f, 2.66335279e-01f, 6.08251023e-04f, -1.44498184e-01f,
  -4.85908031e-01f, 5.48622757e-02f, -2.35388368e-01f, 1.40026972e-01f, 3.50517750e-01f, 1.15716405e-01f, -1.87392496e-02f, 1.19343564e-01f, 2.37223536e-01f, -2.71205842e-01f,
  -2.68248081e-01f, -5.15259147e-01f, 1.41802698e-01f, 1.17650561e-01f, 1.74900338e-01f, -2.20052361e-01f, 1.37387156e-01f, -2.35457227e-01f, 2.43843436e-01f, 2.18524486e-01f,
  4.43850942e-02f, 8.72733593e-02f, 6.24324717e-02f, 3.32061574e-02f, -1.02969378e-01f, -8.72845277e-02f, -7.97320455e-02f, 3.01304515e-02f, -1.34452179e-01f, -7.16106221e-02f,
  1.03910603e-01f, -4.52814624e-02f, -8.81347731e-02f, 2.94967089e-02f, -2.40677372e-01f, -1.86927170e-01f, 7.15039372e-02f, 9.96377319e-02f, -1.01715617e-01f, -2.08574623e-01f,
  -2.66718090e-01f, 1.30032450e-02f, 6.07566014e-02f, -2.02703476e-01f, -1.86333358e-01f, -2.01161221e-01f, -2.51771003e-01f, -1.17845640e-01f, 1.06072873e-01f, -8.26673657e-02f,
  2.45447174e-01f, -1.64731741e-01f, 2.24501848e-01f, 1.68742053e-03f, 2.86309659e-01f, 5.59930019e-02f, -3.19964290e-01f, -1.21331364e-01f, 1.57306612e-01f, -1.21749759e-01f,
  1.51041240e-01f, 3.92094217e-02f, 2.17838719e-01f, -2.61981964e-01f, -1.58592314e-01f, -4.75381911e-01f, -5.27029373e-02f, 3.36320192e-01f, -4.51529294e-01f, 3.67746234e-01f,
  -3.97217244e-01f, -1.82379290e-01f, 1.19362414e-01f, -1.84673846e-01f, -2.58163661e-01f, -2.39845604e-01f, 7.76664093e-02f, 4.23836559e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.70046873e-02f, 6.37759194e-02f, -1.47753417e-01f, -8.72239769e-02f, -1.45700648e-01f, 1.68673333e-03f, -5.47773428e-02f, 1.22932193e-03f, -3.00134942e-02f, -1.21787013e-02f,
  -5.26832342e-02f, -3.33155617e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    