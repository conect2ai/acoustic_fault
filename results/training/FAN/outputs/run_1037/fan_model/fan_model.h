/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.94538009e-01f, 1.71568125e-01f, -9.64095220e-02f, 9.87204760e-02f, -3.70472707e-02f, 9.47652534e-02f, 1.59991592e-01f, 6.75168559e-02f, -5.92357144e-02f, -1.12264398e-02f,
  -8.67155269e-02f, -1.23762995e-01f, -4.64669019e-02f, -8.14343169e-02f, 1.18776627e-01f, 1.60968497e-01f, 1.55146688e-01f, 9.45678651e-02f, 9.90179107e-02f, 8.33501294e-02f,
  5.56300730e-02f, 3.90429534e-02f, 1.85829386e-01f, 7.80008063e-02f, 2.74567108e-04f, -3.07437554e-02f, -3.71369496e-02f, -9.12862923e-03f, -3.81100550e-02f, 7.72152841e-02f,
  -3.71097535e-01f, 5.03213815e-02f, -1.06819212e-01f, 1.03861287e-01f, -6.64300397e-02f, -5.23836538e-02f, -5.40427379e-02f, 4.15111892e-02f, 2.15219110e-02f, -6.48706853e-02f,
  7.20168948e-02f, 7.05733448e-02f, -2.87025962e-02f, -6.59249946e-02f, 7.61802793e-02f, 4.85394821e-02f, 4.30419529e-03f, -2.23192703e-02f, -5.15140109e-02f, -6.17758632e-02f,
  9.92052928e-02f, 8.92534330e-02f, 2.24141479e-02f, -2.19385084e-02f, -7.39661381e-02f, 4.66842949e-02f, -5.65717816e-02f, -8.24944898e-02f, 7.46212378e-02f, -2.81800590e-02f,
  9.66617391e-02f, 1.02263428e-01f, 1.40103605e-02f, 3.88298668e-02f, 2.14128364e-02f, -4.09658998e-02f, 4.83242981e-03f, 3.00905984e-02f, 2.16363501e-02f, 4.30920944e-02f,
  -5.35567887e-02f, -3.56023051e-02f, -3.83761600e-02f, -3.61972302e-02f, -4.29521091e-02f, 5.53392880e-02f, -1.07801119e-02f, -1.59991719e-02f, 2.83610653e-02f, -1.21327654e-01f,
  6.08265325e-02f, -7.33992308e-02f, -4.31029946e-02f, 5.75449206e-02f, 5.55212200e-02f, 4.92102429e-02f, -6.15919940e-02f, 2.74904240e-02f, 4.60723937e-02f, 5.62035805e-03f,
  -3.03768218e-01f, -1.63339563e-02f, -6.08496182e-02f, 3.57497670e-02f, 9.42538306e-02f, 8.08202922e-02f, 9.11383554e-02f, 8.41939300e-02f, 4.55915183e-02f, 3.64737697e-02f,
  -2.37433910e-02f, 8.28861743e-02f, 2.09033154e-02f, -5.92726655e-02f, 9.26737487e-02f, 6.06210157e-02f, 1.18601613e-01f, 5.93979619e-02f, -4.25978862e-02f, -7.42199970e-03f,
  2.70902999e-02f, -4.15581837e-02f, -6.46687998e-03f, 2.92477794e-02f, -3.36515694e-03f, 1.35466233e-02f, -6.64983988e-02f, -8.68578032e-02f, -1.01149864e-02f, -4.16539870e-02f,
  5.90228066e-02f, -2.25803286e-01f, -8.17015916e-02f, -2.88642216e-02f, 3.28356624e-02f, 9.27622393e-02f, -7.37333018e-03f, 2.38532182e-02f, 1.99835675e-04f, -9.21441317e-02f,
  9.99294519e-02f, 1.83954120e-01f, 2.26339459e-01f, 1.83296815e-01f, 2.48163477e-01f, -3.44154239e-02f, -9.81983840e-02f, 1.11740254e-01f, 2.83203989e-01f, 2.25085586e-01f,
  7.53771067e-02f, -1.85943156e-01f, -1.55236106e-02f, 1.24488898e-01f, -2.16666505e-01f, 1.10437140e-01f, -1.70034632e-01f, -2.93302476e-01f, -1.09171443e-01f, -4.05678898e-01f,
  -2.38107294e-01f, -1.83266312e-01f, 2.47430176e-01f, 1.62411347e-01f, -2.09815335e-02f, 7.54727796e-02f, 1.55853495e-01f, -4.51581404e-02f, 1.47596002e-01f, -1.49553344e-02f,
  1.29836779e-02f, 3.55893150e-02f, 8.17116871e-02f, 1.92275494e-02f, -1.04424335e-01f, -1.21597257e-02f, 6.11881763e-02f, 1.16717163e-03f, 5.23801371e-02f, -6.43073441e-03f,
  4.41431031e-02f, 7.47567602e-03f, -6.23744428e-02f, 3.21482606e-02f, 1.12513661e-01f, 1.46571800e-01f, -2.73014954e-03f, -2.65206359e-02f, -2.39841919e-02f, -2.57059187e-01f,
  -4.07761410e-02f, -5.42863971e-03f, -4.90447246e-02f, -2.42969133e-02f, -6.09795786e-02f, 1.70489550e-02f, -2.67194305e-03f, -6.86518550e-02f, -2.44011381e-03f, -4.30440605e-02f,
  4.03137617e-02f, 1.82097200e-02f, -8.87333304e-02f, 2.02944353e-02f, -2.67916881e-02f, -1.87770370e-02f, -9.81431920e-03f, -1.13587838e-03f, 2.02489737e-02f, 4.73662699e-03f,
  -1.67108458e-02f, -2.61295848e-02f, -7.45900795e-02f, -4.33546305e-02f, 3.27929147e-02f, 6.07950203e-02f, 7.01459358e-03f, 1.06031492e-01f, 5.76781370e-02f, -7.93296006e-03f,
  -6.38291761e-02f, 3.04504335e-01f, 6.84669614e-02f, 3.56578864e-02f, 1.42266033e-02f, 1.64694188e-03f, 1.95726603e-02f, 1.04321375e-01f, 8.38767365e-02f, -3.19065563e-02f,
  4.74483818e-02f, 2.08202992e-02f, 3.90854627e-02f, -1.50411418e-02f, 6.98188767e-02f, -2.76861805e-03f, -3.69053371e-02f, 4.38725539e-02f, 4.37364019e-02f, -2.40776036e-02f,
  -3.73889180e-03f, 8.26836750e-02f, -1.81049816e-02f, -6.07682578e-03f, -6.62311837e-02f, 1.65332630e-01f, 6.31625950e-02f, -9.62965377e-03f, 1.96571916e-01f, -9.33665335e-02f,
  5.18445075e-01f, 7.03908801e-02f, -2.64488012e-02f, 2.04874933e-01f, -2.40850255e-01f, -4.05560166e-01f, -3.39142978e-01f, -1.31039366e-01f, 4.03615423e-02f, -8.73160139e-02f,
  -1.67670175e-01f, -4.73066121e-02f, -1.32634327e-01f, -1.52405590e-01f, -1.42122462e-01f, -2.41505101e-01f, 2.22522728e-02f, 1.11103460e-01f, -2.04072282e-01f, -2.18665719e-01f,
  -1.08414352e-01f, 2.66499221e-01f, 2.36612737e-01f, 7.95412734e-02f, -6.61150143e-02f, -1.47323191e-01f, -5.76714464e-02f, 2.65458617e-02f, -1.68352157e-01f, 3.82414833e-02f,
  -1.74167842e-01f, -3.28849666e-02f, -1.40884504e-01f, -5.89721650e-02f, -4.22460511e-02f, -7.16599301e-02f, -1.22531250e-01f, 3.43098119e-02f, -4.12286744e-02f, -5.65736108e-02f,
  -1.05909549e-01f, -4.48066089e-03f, -1.70713842e-01f, 6.28029881e-03f, -1.11045361e-01f, -9.19547454e-02f, -1.64107084e-02f, -4.62811366e-02f, -6.89377189e-02f, -1.57558605e-01f,
  -6.76695555e-02f, -1.12449557e-01f, -3.00185867e-02f, -1.61650196e-01f, -2.30581656e-01f, 4.22972478e-02f, -1.32168487e-01f, -1.51589707e-01f, -1.68795288e-01f, 1.37109393e-02f,
  1.42850697e-01f, 6.11025020e-02f, -8.63769650e-02f, -4.12945002e-02f, 5.49006015e-02f, -3.48445624e-02f, 1.74592864e-02f, -1.25927657e-01f, -1.33157540e-02f, 4.34898678e-03f,
  -1.09117597e-01f, -3.03907949e-03f, 5.85634038e-02f, 1.06382603e-02f, -7.25500733e-02f, -6.63640499e-02f, -6.49600998e-02f, -8.65463912e-03f, -9.65766013e-02f, -6.38152426e-03f,
  -2.52290908e-02f, -4.61246294e-04f, 5.75484522e-02f, -3.92116532e-02f, 2.57994533e-02f, 2.98291910e-03f, -3.68267372e-02f, -4.15056571e-02f, 5.46547659e-02f, 2.30544689e-03f,
  5.85134216e-02f, -2.20353991e-01f, -6.37179092e-02f, -1.86798736e-01f, -1.25602424e-01f, -2.81232670e-02f, -4.34555747e-02f, -9.49095339e-02f, -4.65149507e-02f, -1.00401632e-01f,
  -1.89815059e-01f, -1.55462354e-01f, -3.53012122e-02f, -1.17302820e-01f, -1.42427877e-01f, -1.00520417e-01f, -1.31778672e-01f, -3.96665484e-02f, -1.37201741e-01f, -6.07660972e-02f,
  -5.43266349e-02f, -5.44821210e-02f, -2.06649125e-01f, -1.48229986e-01f, -1.39110431e-01f, -1.32410139e-01f, -2.23870561e-01f, -1.34681255e-01f, -3.00823241e-01f, -1.02598881e-02f,
  2.57848680e-01f, -2.57653207e-01f, -1.63445696e-01f, -7.70900473e-02f, -2.74628282e-01f, -1.79264620e-01f, -3.90187770e-01f, 1.95615124e-02f, 1.21863559e-01f, -9.59784985e-02f,
  3.38289961e-02f, 3.08281839e-01f, 3.57638597e-01f, 2.59376824e-01f, 2.60344237e-01f, -2.93324202e-01f, -1.64144903e-01f, 9.12766606e-02f, 2.15579093e-01f, 4.27669361e-02f,
  -9.34125409e-02f, -5.02478704e-02f, 1.75155818e-01f, 1.23174705e-01f, -1.53829828e-01f, 1.55047327e-01f, -7.80914277e-02f, -1.48196310e-01f, -6.79609627e-02f, -1.54856473e-01f,
  1.19506113e-01f, -2.71673948e-02f, 1.47885635e-01f, 9.85434651e-02f, 4.07413691e-02f, 7.43082017e-02f, 5.78750484e-02f, 3.01301572e-02f, -7.75528140e-03f, 6.21273071e-02f,
  -1.14263094e-03f, 8.02022889e-02f, 7.17410073e-02f, -1.01257907e-02f, -9.67496186e-02f, 8.48282222e-03f, 1.22437924e-01f, 9.98761803e-02f, 2.80875955e-02f, -3.94211337e-03f,
  -5.62035143e-02f, -5.83846718e-02f, 1.96086206e-02f, -2.60878936e-03f, 1.59484386e-01f, 1.63102433e-01f, 4.29983437e-02f, 3.49699892e-03f, 1.88262329e-01f, -6.81175068e-02f,
  1.78910815e-03f, -2.51228623e-02f, 8.78255218e-02f, -9.28740352e-02f, -1.03976652e-02f, 4.68611121e-02f, -2.09739786e-02f, -1.90133427e-03f, -9.84712783e-03f, -1.49893733e-02f,
  3.33012305e-02f, 2.22415980e-02f, -5.02871983e-02f, -6.07028380e-02f, -4.08166759e-02f, -8.57367441e-02f, -4.66169976e-02f, 5.51617518e-03f, 8.01403448e-02f, -2.76318155e-02f,
  2.42986856e-03f, -2.74422839e-02f, -1.99837461e-02f, 3.10742445e-02f, -6.41793162e-02f, -1.76508178e-03f, -6.18473776e-02f, 2.27034669e-02f, -2.47923695e-02f, -1.62809640e-01f,
  1.18971929e-01f, 2.44653761e-01f, -3.44458898e-03f, 6.09562881e-02f, 5.82586974e-02f, 2.22577527e-02f, 1.10477157e-01f, 8.32034089e-03f, -3.43977697e-02f, 1.56278759e-02f,
  8.82806927e-02f, 7.58699551e-02f, 7.92253688e-02f, 5.25295027e-02f, -2.48043258e-02f, -6.11760318e-02f, 6.22265832e-03f, -2.47342642e-02f, 8.27672780e-02f, -2.30035223e-02f,
  1.04533665e-01f, -1.82208873e-03f, 1.02804117e-01f, 5.76139241e-02f, -7.99159147e-03f, 8.45522583e-02f, -3.45566534e-02f, 3.97071205e-02f, 1.07408278e-01f, -7.85695016e-02f,
  -6.66764140e-01f, -1.87553823e-01f, 1.91202343e-01f, -9.92158204e-02f, 4.93019074e-02f, 1.43086314e-01f, 5.54128364e-02f, 7.79960677e-02f, 3.34388576e-02f, -5.94201759e-02f,
  -3.66121754e-02f, 4.97313328e-02f, 1.60788491e-01f, 1.20400883e-01f, 2.00137332e-01f, 1.14684394e-02f, 1.39918150e-02f, 1.82264805e-01f, 3.14787209e-01f, 1.86218962e-01f,
  7.88825005e-02f, -1.44400373e-01f, -5.91515042e-02f, -5.35056330e-02f, -4.58399542e-02f, 2.08690077e-01f, -7.30762184e-02f, -1.72499821e-01f, 3.07401363e-02f, -2.21201032e-01f,
  2.35145763e-01f, -3.59761387e-01f, 1.19002387e-01f, -8.93596783e-02f, 3.56673114e-02f, 4.54014316e-02f, 1.32662868e-02f, -3.42469178e-02f, -8.81293882e-03f, -4.36088108e-02f,
  2.38098614e-02f, -2.18649358e-02f, -5.78325056e-02f, 2.15964355e-02f, -1.63972508e-02f, -2.89386418e-02f, -4.51030098e-02f, -7.17803184e-03f, 3.01481914e-02f, 1.03090163e-02f,
  -4.12603952e-02f, -1.34599343e-01f, -8.97673965e-02f, 3.27536277e-02f, 5.41222468e-02f, 7.26607591e-02f, -2.60685361e-03f, 2.93384045e-02f, 5.20756133e-02f, 1.78955533e-02f,
  1.79830059e-01f, -3.18810642e-02f, -2.19680965e-02f, 2.56207343e-02f, 4.72638011e-03f, 5.91267459e-03f, -8.09952558e-04f, 1.15501527e-02f, -2.52827294e-02f, -1.03289476e-02f,
  -3.05839237e-02f, 6.22428535e-03f, -1.54601047e-02f, -1.19425528e-01f, -1.25448536e-02f, -7.76053220e-02f, 7.06666708e-02f, -5.48555367e-02f, -1.03175707e-01f, -1.22270823e-01f,
  -6.00486121e-04f, -4.65223044e-02f, -1.37881720e-02f, 1.46347452e-02f, -8.27681869e-02f, -1.45842358e-02f, -1.83201768e-02f, -8.92855600e-02f, -6.29457086e-03f, -1.16473876e-01f,
  2.24522978e-01f, -1.07263796e-01f, -1.75731257e-02f, 7.96147808e-02f, -6.38447702e-02f, -2.73534544e-02f, 6.55990914e-02f, 1.12498563e-03f, -1.45072164e-02f, -7.55426986e-03f,
  -5.66971377e-02f, 1.93687063e-02f, -2.33699474e-02f, 4.96904887e-02f, 3.24157849e-02f, 5.32182865e-02f, -8.28947797e-02f, 1.10046811e-01f, 1.96823291e-02f, -4.15763482e-02f,
  -4.67492677e-02f, 1.14449807e-01f, 1.26144618e-01f, 3.03252880e-02f, 1.16719298e-01f, 2.32368514e-01f, 1.84871629e-01f, 1.56250268e-01f, 2.71533936e-01f, 1.64942592e-01f,
  -7.04631329e-01f, 1.43537745e-01f, -2.16094583e-01f, 2.52111610e-02f, 1.19949512e-01f, 3.82244550e-02f, 3.77562158e-02f, -5.23000620e-02f, -9.00006294e-03f, 1.40149251e-01f,
  1.07934803e-01f, -2.18413360e-02f, -1.01753650e-02f, -4.80789132e-02f, -2.22820908e-01f, 6.31379262e-02f, 1.33141190e-01f, -3.33250612e-01f, -3.74482155e-01f, -1.32182583e-01f,
  2.50646263e-01f, -1.02918774e-01f, -3.43110293e-01f, -2.02885374e-01f, 9.70116034e-02f, 4.91222665e-02f, 4.58899774e-02f, 8.84788111e-02f, 4.97422032e-02f, 1.63643330e-01f,
  -9.03356168e-03f, -2.59786159e-01f, 2.31436286e-02f, 2.21271906e-03f, 7.97967017e-02f, 5.27953021e-02f, -4.69984896e-02f, -1.24137308e-02f, -4.50604297e-02f, -2.52433270e-02f,
  -1.93229120e-03f, -3.92281264e-02f, 5.07590324e-02f, 1.21889636e-02f, -3.01239174e-02f, 5.60714975e-02f, -2.57879980e-02f, -5.27082719e-02f, -6.15248010e-02f, 1.02748916e-01f,
  1.92675546e-01f, 5.24858274e-02f, -6.57386556e-02f, -6.45696148e-02f, -8.07129871e-03f, -2.28743926e-02f, 6.06701337e-02f, 1.51929939e-02f, -1.27687037e-01f, 8.98972601e-02f,
  1.17458291e-01f, -5.21854609e-02f, -2.68985145e-02f, 3.19154374e-02f, 8.08784068e-02f, 2.86603570e-02f, -7.20748901e-02f, -2.10107807e-02f, -3.44959944e-02f, -7.92086963e-03f,
  -1.84437109e-03f, 4.35913987e-02f, 2.91960407e-02f, -5.09697571e-02f, 5.70576042e-02f, -1.16374008e-01f, -7.76353553e-02f, -5.49716130e-02f, -6.50659576e-03f, -5.00224233e-02f,
  -1.08759729e-02f, -5.10704257e-02f, -1.13952300e-02f, 3.90878245e-02f, -2.08091550e-02f, -1.78942960e-02f, -3.52309681e-02f, 8.42937157e-02f, 8.21224079e-02f, -3.60402955e-05f,
  1.60891056e-01f, 3.69553305e-02f, 1.72294602e-02f, -4.46313694e-02f, -1.42585747e-02f, -1.69368833e-02f, 2.22187955e-02f, 2.94604083e-03f, -7.57716654e-04f, -2.97865644e-02f,
  -6.69592395e-02f, -1.02074437e-01f, -1.73757374e-02f, 1.04362018e-01f, 2.16789208e-02f, 3.35732400e-02f, 9.50851813e-02f, 1.85289141e-02f, -4.20760959e-02f, 1.50450869e-02f,
  8.65552723e-02f, 2.26275306e-02f, -1.41348109e-01f, -1.01178931e-02f, -3.05033308e-02f, -1.67423505e-02f, -2.90563004e-03f, 3.66775319e-02f, -1.42734237e-02f, 4.48662229e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.07282627e-01f, -8.53702873e-02f, -4.34601247e-01f, 4.08660732e-02f, -1.42753363e-01f, 9.16470960e-02f, -1.17842937e-02f, 1.94059368e-02f, 2.31890231e-01f, 2.74937246e-02f,
  2.50381604e-02f, 2.18332186e-01f, 2.53888983e-02f, -7.75871873e-02f, 2.68229544e-01f, -1.41355693e-01f, -1.80924371e-01f, -7.71164745e-02f, 2.09574491e-01f, 1.79826513e-01f,
  3.45689543e-02f, 5.04250489e-02f, 2.41154358e-01f, 2.28499323e-02f, -2.11954609e-01f, 1.40368128e-02f, -3.19631279e-01f, -2.33252168e-01f, -2.20391333e-01f, -5.27495444e-01f,
  -2.09354445e-01f, -2.24504530e-01f, -2.72083208e-02f, 1.30505934e-01f, -3.42444748e-01f, 9.65130627e-02f, -5.97262122e-02f, -2.56229877e-01f, -4.12538052e-02f, -8.97670761e-02f,
  -1.88964859e-01f, -8.22215062e-03f, -2.13209003e-01f, -1.66816503e-01f, -3.51618119e-02f, 3.69529091e-02f, -1.14597984e-01f, 3.32440622e-02f, -4.48866077e-02f, -1.07136250e-01f,
  -2.35803097e-01f, -1.09883584e-01f, -2.89763629e-01f, -1.91647291e-01f, -1.84143975e-01f, -1.30503759e-01f, -3.09631914e-01f, -2.55162984e-01f, -1.11909874e-01f, -2.15601772e-01f,
  5.05074225e-02f, -6.99022040e-02f, -6.42830282e-02f, -1.56531736e-04f, 3.82025540e-02f, -1.41934961e-01f, -3.03831752e-02f, -8.02860186e-02f, 1.10603194e-03f, 5.96849173e-02f,
  -5.72365038e-02f, -3.76469567e-02f, 8.96331519e-02f, 7.10487831e-03f, -3.41367349e-02f, -3.18885557e-02f, -5.20180492e-03f, 9.92492884e-02f, 8.93821269e-02f, 7.77229816e-02f,
  1.89354375e-01f, 9.59312767e-02f, 1.85853153e-01f, -1.80867612e-02f, 9.89091322e-02f, -1.00649707e-02f, 1.26858190e-01f, 1.40170166e-02f, -8.12260900e-03f, 2.32545942e-01f,
  4.13984835e-01f, 2.97774505e-02f, 9.32757109e-02f, 3.96523289e-02f, 2.69887801e-02f, -6.00162782e-02f, 5.46502061e-02f, -7.27336332e-02f, 6.81283548e-02f, 1.57151803e-01f,
  4.14869189e-03f, 2.62676476e-04f, -7.90547058e-02f, -1.49922082e-02f, -7.43310945e-03f, -3.47939357e-02f, 1.43003330e-01f, 1.60598636e-01f, 1.89547107e-01f, 1.16513029e-01f,
  6.56490251e-02f, 3.80513340e-01f, 2.92253941e-01f, -8.97530932e-03f, -7.86463991e-02f, 3.02284628e-01f, 7.39477668e-03f, 3.93768288e-02f, 3.28113347e-01f, 3.58653337e-01f,
  -3.38223100e-01f, -2.11099282e-01f, -4.28202413e-02f, 3.28638554e-01f, 1.01899073e-01f, -2.71384180e-01f, -3.92566919e-01f, -2.61254728e-01f, 1.06148519e-01f, -4.40066867e-02f,
  -1.62014470e-01f, 8.27421919e-02f, 6.14093952e-02f, 1.24906994e-01f, 1.45112991e-03f, 4.17645201e-02f, 3.29644799e-01f, 3.04620147e-01f, 1.23752177e-01f, -2.20186003e-02f,
  1.90634400e-01f, 1.76349849e-01f, 1.64751768e-01f, 1.72395691e-01f, 2.04413116e-01f, 2.11553231e-01f, 2.56424099e-01f, 7.84550756e-02f, -1.08170817e-02f, 4.65095639e-01f,
  -3.49537969e-01f, -2.30810314e-01f, 2.05530077e-01f, 1.00170806e-01f, 3.00733782e-02f, -2.34437324e-02f, -8.09342600e-03f, 6.50064871e-02f, -1.49058308e-02f, 1.14145182e-01f,
  1.72764678e-02f, -6.24086447e-02f, -1.06870113e-02f, 5.50807454e-02f, 1.91260353e-02f, -7.19131855e-03f, 1.40608132e-01f, 8.88461024e-02f, 5.94333513e-03f, -2.66551580e-02f,
  1.05884418e-01f, -7.89128169e-02f, -3.00095707e-01f, -1.82392567e-01f, -1.33322358e-01f, 1.38548896e-01f, -1.68539628e-01f, -8.64098072e-02f, -2.07029268e-01f, 2.95842085e-02f,
  1.59027517e-01f, 7.59053975e-02f, -3.04437317e-02f, 2.37093084e-02f, 4.60677408e-02f, -1.08610317e-01f, 6.54249638e-02f, 9.83841568e-02f, 1.34605631e-01f, 1.31361291e-01f,
  1.62372235e-02f, 1.58117265e-02f, -5.30510880e-02f, -2.07805093e-02f, 6.14185221e-02f, -4.52463925e-02f, 8.32597762e-02f, 1.83513626e-01f, 8.93587768e-02f, 1.84016360e-03f,
  6.51444793e-02f, -9.28828400e-03f, 6.20752610e-02f, 2.70389374e-02f, 7.65814781e-02f, 1.66708156e-01f, 1.24423698e-01f, 5.40108383e-02f, -2.53387894e-02f, -5.74567355e-02f,
  -3.42150107e-02f, 8.00273791e-02f, 5.30702844e-02f, -6.10928871e-02f, 1.79005954e-02f, -9.44228917e-02f, 8.24890882e-02f, 5.22785001e-02f, -1.18477829e-01f, 4.08336781e-02f,
  -1.23650081e-01f, -1.38093472e-01f, -1.20817631e-01f, 6.70828149e-02f, 2.87357755e-02f, -2.88866926e-02f, 8.19909051e-02f, 2.44644247e-02f, 5.06907515e-02f, 2.09437534e-02f,
  1.09857127e-01f, -1.35940462e-01f, -3.48320544e-01f, -2.36580476e-01f, -2.15637043e-01f, -7.20432103e-02f, -5.70579916e-02f, -1.05204351e-01f, -2.67550439e-01f, -3.08271796e-01f,
  2.93254316e-01f, -1.38411373e-01f, 8.17452967e-02f, 3.68547469e-01f, -2.01532349e-01f, -4.26951051e-01f, -8.66974175e-01f, -1.53426483e-01f, 2.13971972e-01f, -3.48432600e-01f,
  -4.25326228e-01f, 5.57892211e-02f, 2.42463320e-01f, -1.98253449e-02f, -3.39698404e-01f, -5.57417512e-01f, -2.48197392e-01f, -1.16055414e-01f, -2.32888609e-01f, -4.66878414e-01f,
  -2.76151210e-01f, 9.38120559e-02f, 2.15195477e-01f, -1.58993620e-02f, 1.23680800e-01f, 2.21712738e-01f, 3.03568542e-01f, 2.10682333e-01f, -1.45239547e-01f, 1.28542259e-01f,
  -2.06954852e-02f, -1.12847596e-01f, -4.67531234e-02f, -6.60453662e-02f, -8.15343868e-04f, 6.88279718e-02f, -2.00549886e-01f, 1.03251234e-01f, -1.49095163e-03f, 9.16761681e-02f,
  -4.05325554e-02f, -4.08239782e-01f, 1.13425530e-01f, -1.36429608e-01f, -2.31426850e-01f, -7.18073696e-02f, -1.18798427e-02f, -1.57106042e-01f, 8.08124840e-02f, -2.12397054e-01f,
  -2.80510813e-01f, -1.95145488e-01f, -1.44215245e-02f, -1.01636700e-01f, 8.47608894e-02f, 1.55225009e-01f, 8.57491270e-02f, 3.74175087e-02f, 7.61624575e-02f, 7.49992281e-02f,
  -7.29714260e-02f, 2.22017001e-02f, -3.69392671e-02f, -1.24379098e-01f, -1.50168911e-01f, -1.17211547e-02f, 7.29918256e-02f, -1.45663023e-01f, 5.46064228e-02f, 1.67985018e-02f,
  4.60536666e-02f, -3.28836069e-02f, 9.05360747e-03f, 4.83114794e-02f, 7.29606003e-02f, -7.45226666e-02f, -1.06117979e-01f, 5.33481464e-02f, -9.80975199e-03f, -3.25620957e-02f,
  -1.48608327e-01f, 4.72443923e-02f, 7.98230097e-02f, -2.95817778e-02f, -8.28584060e-02f, -8.35209712e-02f, 3.53248343e-02f, 7.83266872e-02f, 2.75658146e-02f, -1.27152264e-01f,
  2.26050571e-01f, -2.69741099e-03f, 6.38299733e-02f, -5.86745627e-02f, -7.47546628e-02f, 7.31820837e-02f, 1.04661733e-01f, -2.82040369e-02f, 6.01038374e-02f, -2.41757244e-01f,
  -7.94186816e-02f, 1.06010260e-02f, 1.48847431e-01f, -1.04662560e-01f, -2.24709004e-01f, 3.80241573e-02f, -1.67290837e-01f, -1.18499927e-01f, -1.46705791e-01f, 1.70538239e-02f,
  1.16317794e-01f, -2.70913929e-01f, 5.80660477e-02f, 5.42131029e-02f, 1.71025902e-01f, -1.48352617e-02f, 1.24802180e-01f, 9.75621864e-02f, -9.17244628e-02f, -9.61999744e-02f,
  1.82966501e-01f, -5.45459330e-01f, -3.02722037e-01f, 1.51349843e-01f, 9.52556804e-02f, -2.39822611e-01f, -8.99447024e-01f, -1.64308444e-01f, 2.77154356e-01f, -3.79934728e-01f,
  -6.43311143e-02f, 4.88231122e-01f, 1.57699510e-01f, -1.07021466e-01f, -4.43313420e-01f, -8.20589542e-01f, -3.18484098e-01f, -1.80256888e-02f, 2.24026904e-01f, 8.21986124e-02f,
  6.00949153e-02f, 1.92053661e-01f, 3.64066392e-01f, 2.28192300e-01f, 6.90226257e-02f, 2.00087443e-01f, -1.15895115e-01f, 1.21397458e-01f, -2.75960177e-01f, -2.62580514e-01f,
  -2.72449881e-01f, -1.88466281e-01f, 1.57752037e-01f, 2.16899469e-01f, -4.04851185e-03f, -1.37743756e-01f, -1.37652919e-01f, 8.73940438e-02f, -2.97586303e-02f, -9.18479264e-02f,
  1.73660070e-01f, 5.50104603e-02f, 1.04358092e-01f, 5.34190238e-02f, 1.15135640e-01f, 1.22756414e-01f, 2.26413414e-01f, 7.09210038e-02f, -6.22156411e-02f, -7.75954574e-02f,
  -7.61549473e-02f, 6.27640039e-02f, 2.43944004e-02f, -1.74210846e-01f, 5.19102290e-02f, 6.78113475e-02f, -1.08783387e-01f, 1.20488321e-02f, -1.35909721e-01f, -3.24706048e-01f,
  1.68139726e-01f, -8.51573274e-02f, 1.36869311e-01f, 6.18628077e-02f, -1.62692126e-02f, 8.80077407e-02f, 4.11965623e-02f, -9.92688611e-02f, 4.63847555e-02f, 1.85622182e-03f,
  1.40884236e-01f, -7.48700649e-02f, -5.34191839e-02f, -6.13078400e-02f, 1.89594880e-01f, 2.34271232e-02f, -6.97517842e-02f, -9.85189006e-02f, 8.89824107e-02f, 3.09857521e-02f,
  2.24070922e-02f, -1.84987839e-02f, 1.57124802e-01f, 4.05956134e-02f, -1.18937291e-01f, 5.76512329e-02f, 7.33431578e-02f, -1.14136729e-02f, 2.02884629e-01f, 9.31838378e-02f,
  1.69845760e-01f, -1.03625774e-01f, -1.81989580e-01f, 5.39583415e-02f, -3.78639363e-02f, -4.74870279e-02f, -1.14013217e-01f, 1.01713017e-01f, -4.60324474e-02f, -2.80515403e-01f,
  -1.78624466e-01f, -1.53284848e-01f, -9.70083028e-02f, -1.05330892e-01f, 3.72724198e-02f, 9.13798958e-02f, -1.44429117e-01f, 1.42493483e-03f, -8.99711251e-02f, 2.85822209e-02f,
  1.80806301e-03f, -1.69309556e-01f, -1.25044882e-01f, -2.61329532e-01f, -1.76271759e-02f, -1.15269450e-02f, -9.79670733e-02f, -1.94487885e-01f, -3.34184736e-01f, -6.40247583e-01f,
  7.38620281e-01f, -5.22514760e-01f, -3.02737623e-01f, -8.43673125e-02f, -1.28553500e-02f, 1.16319463e-01f, -1.33623809e-01f, 1.14703380e-01f, 1.46170119e-02f, -2.84269750e-01f,
  -1.37769967e-01f, 3.64355221e-02f, -2.08817363e-01f, -2.18252763e-02f, -1.98287964e-02f, -2.81670302e-01f, -1.65252447e-01f, -2.16468088e-02f, 3.45828563e-01f, 2.65851140e-01f,
  -5.43106608e-02f, -5.73787279e-02f, 1.74164414e-01f, -1.00526497e-01f, -3.66558462e-01f, -9.17435065e-03f, -3.70269418e-01f, -2.92791307e-01f, -2.38806352e-01f, -5.50288856e-01f,
  -4.31868315e-01f, 2.89812759e-02f, 1.32829845e-01f, 1.27482846e-01f, -5.73688745e-02f, 1.14748068e-02f, 1.48364037e-01f, -7.37906694e-02f, 9.79514867e-02f, 9.91924107e-03f,
  4.18571308e-02f, 3.75110433e-02f, 3.75759928e-03f, -5.21312049e-03f, -9.97055974e-03f, -3.75516750e-02f, 1.42265335e-01f, -1.50291994e-02f, -1.73095912e-01f, -4.24173251e-02f,
  -2.46905666e-02f, 2.01646671e-01f, 7.48145133e-02f, 1.05109945e-01f, 1.93398625e-01f, 1.68931678e-01f, 8.12338740e-02f, 1.55727491e-01f, 1.58731759e-01f, 9.86868814e-02f,
  -7.27885813e-02f, -3.52948196e-02f, 1.71323895e-01f, 1.20273709e-01f, 2.16387510e-01f, 2.88013607e-01f, 2.24099923e-02f, 3.27367708e-02f, 8.92319456e-02f, -1.73234213e-02f,
  -1.38295338e-01f, -3.90558690e-02f, 6.12984598e-02f, 2.23454069e-02f, 3.45347193e-03f, -6.95978254e-02f, 2.76650600e-02f, -2.48761587e-02f, -9.81650427e-02f, 1.38797760e-02f,
  -2.18347386e-02f, -1.56057877e-02f, -1.20723426e-01f, 1.14131514e-02f, -1.78113058e-01f, 8.42872337e-02f, -8.87246206e-02f, -5.05771451e-02f, -1.29204663e-02f, -1.39890462e-01f,
  -7.88033456e-02f, 9.00038928e-02f, -7.44147748e-02f, 7.82263372e-03f, -6.17593043e-02f, -4.43183631e-02f, -6.36852384e-02f, -1.10143453e-01f, -2.89614797e-02f, -1.03226572e-01f,
  -8.98283347e-02f, 3.30538518e-04f, -1.46625742e-01f, -8.84499848e-02f, 6.94686845e-02f, 1.93502441e-01f, 7.65613019e-02f, 1.17777750e-01f, -9.59308669e-02f, -1.50753587e-01f,
  -7.10152015e-02f, 1.96456701e-01f, 8.97748917e-02f, 1.26752421e-01f, 2.01596335e-01f, 1.73265964e-01f, 3.98110040e-02f, 1.01368919e-01f, 5.08889817e-02f, 1.45755857e-01f,
  -5.29704094e-02f, 5.08810692e-02f, 9.91142318e-02f, -1.29943773e-01f, 4.35451865e-01f, 2.14350283e-01f, -1.50415525e-01f, -1.93361104e-01f, 4.92644943e-02f, 2.24500611e-01f,
  4.38465774e-01f, 1.88098341e-01f, 5.13926931e-02f, 7.34033138e-02f, -3.13615829e-01f, -1.24020189e-01f, -7.20411018e-02f, -2.16849685e-01f, -3.46780032e-01f, -8.97606835e-03f,
  1.07890971e-01f, -1.26035273e-01f, -1.60868287e-01f, -8.58196989e-02f, 5.29367523e-03f, -1.51232541e-01f, 1.50256068e-01f, 1.56792223e-01f, 2.00019658e-01f, 4.93519865e-02f,
  2.77391315e-01f, 4.20257658e-01f, -1.09038599e-01f, -1.45893116e-02f, 1.60522044e-01f, -2.71304697e-01f, -8.87537077e-02f, 6.38471693e-02f, 1.02600455e-01f, -5.16537912e-02f,
  7.41754919e-02f, 2.35995755e-01f, -2.81412061e-02f, -5.91915958e-02f, -9.41361487e-03f, -9.66907367e-02f, -1.36681825e-01f, -2.42515221e-01f, -3.73521358e-01f, -1.25919953e-01f,
  1.61625929e-02f, 2.13743031e-01f, 6.81869453e-03f, -1.01608038e-01f, -2.38373369e-01f, -1.88202202e-01f, -1.23520687e-01f, -9.29474458e-02f, -8.05058032e-02f, -4.71549690e-01f,
  1.84210718e-01f, 2.32662559e-01f, 2.10602522e-01f, 6.48316741e-02f, -5.82872666e-02f, 1.65221281e-02f, 1.86747566e-01f, 5.35982326e-02f, 5.01611307e-02f, -9.40329209e-03f,
  4.43773009e-02f, 9.30755362e-02f, 1.67145708e-03f, -6.29060566e-02f, 5.28382957e-02f, 1.83230806e-02f, -1.69537254e-02f, -2.58987784e-01f, -1.01890877e-01f, -1.78621262e-02f,
  -8.20667744e-02f, 2.58045457e-02f, -4.44201268e-02f, -2.36751899e-01f, 9.26754698e-02f, -1.44935185e-02f, -6.56754002e-02f, 1.04727065e-02f, -1.32201612e-01f, 7.42762014e-02f,
  -2.09757343e-01f, 3.46462727e-01f, 4.52852398e-02f, -2.69352227e-01f, 9.49022695e-02f, 2.09188730e-01f, 1.05789468e-01f, 5.33444360e-02f, 1.20638914e-01f, -1.71078399e-01f,
  -8.44692588e-02f, 1.73113111e-03f, 3.11217606e-02f, -1.83241621e-01f, 3.41331773e-02f, -1.20727994e-01f, -1.92823678e-01f, -8.31567124e-02f, -3.72807197e-02f, 2.72884760e-02f,
  -3.63545120e-01f, -3.14679146e-01f, -2.52874821e-01f, -2.43908718e-01f, -5.45219071e-02f, -3.30838114e-01f, -2.16033757e-01f, -3.24249923e-01f, -1.72457442e-01f, -6.59578323e-01f,
  -9.94918346e-02f, 3.95552069e-02f, -1.53832212e-01f, 1.50052696e-01f, 7.64941275e-02f, -1.81369901e-01f, -1.91412702e-01f, -2.39221960e-01f, -1.97847728e-02f, -3.85167487e-02f,
  -5.21719120e-02f, 1.14672100e-02f, 2.00518847e-01f, 1.49017442e-02f, -1.14330225e-01f, 2.30897710e-01f, 3.57297301e-01f, 9.97826457e-02f, -1.82814702e-01f, -6.21372461e-02f,
  1.76591337e-01f, 1.14683896e-01f, -8.00906196e-02f, -1.04568131e-01f, 2.15497762e-01f, -3.57611999e-02f, -2.76525915e-02f, 1.50660798e-01f, 5.55587700e-03f, 5.18180966e-01f,
  9.20321345e-02f, 1.38397487e-02f, -6.94842935e-02f, 1.67072743e-01f, 1.33920684e-01f, -7.65138119e-02f, -5.84519701e-03f, 9.03197452e-02f, 6.36879588e-03f, 1.56172141e-01f,
  9.30150524e-02f, 3.81006710e-02f, 2.45655507e-01f, 2.86827255e-02f, 9.21377167e-03f, -1.71876818e-01f, -3.88579480e-02f, -1.25815317e-01f, -2.80095786e-01f, -2.43189588e-01f,
  2.96294957e-01f, 1.58086382e-02f, -1.48869321e-01f, -1.82413206e-01f, -7.65767694e-02f, 4.45999354e-02f, -2.40884200e-01f, -8.00487995e-02f, -2.74313539e-01f, -1.06653869e-01f,
  5.33766150e-02f, -4.08532657e-02f, 4.96778339e-02f, -6.36184663e-02f, -4.13504839e-02f, 1.19408168e-01f, 1.09608419e-01f, 4.06456646e-03f, 1.57724708e-01f, -3.32801566e-02f,
  1.08241178e-01f, -4.53084782e-02f, 5.93714267e-02f, -5.03137335e-02f, 2.87327953e-02f, 9.39811300e-03f, -3.23229507e-02f, -4.05371711e-02f, 4.17264784e-03f, -7.41088912e-02f,
  5.34871854e-02f, -1.51449284e-02f, 9.86771137e-02f, 8.39651842e-03f, -1.71551391e-01f, 3.37379239e-02f, -1.00428620e-02f, -1.93581685e-01f, -2.00587651e-03f, 9.35527980e-02f,
  -1.37464032e-01f, -3.32383416e-03f, 1.72448426e-01f, 1.35534391e-01f, 3.05247176e-02f, 4.86950353e-02f, 1.81658313e-01f, 1.57753050e-01f, -1.02337440e-02f, -2.59261280e-01f,
  -2.19932303e-01f, 2.86195111e-02f, 5.47222868e-02f, 8.97051673e-03f, -3.44147794e-02f, -5.49112074e-03f, 5.71953505e-02f, -1.13704361e-01f, -4.83175293e-02f, 6.55901805e-02f,
  5.84990904e-02f, -2.42082417e-01f, -9.93532315e-02f, -2.58902013e-01f, -1.14112878e-02f, -1.25097066e-01f, -1.45031065e-01f, -6.52740672e-02f, -4.57877874e-01f, -4.87177342e-01f,
  -7.70131126e-02f, -1.34795040e-01f, 2.64229178e-01f, 4.14495945e-01f, 3.69035751e-01f, 4.46751922e-01f, 3.98404419e-01f, 2.12419033e-01f, 2.45586023e-01f, 2.46437535e-01f,
  1.38603505e-02f, -2.76100077e-03f, 1.28879040e-01f, 1.82383686e-01f, 7.61842802e-02f, 3.31187338e-01f, 2.60863930e-01f, 2.31144339e-01f, 1.92667112e-01f, 2.34328747e-01f,
  1.03779525e-01f, 7.68917575e-02f, -7.04271644e-02f, -3.39317322e-02f, 1.86668411e-01f, 5.70998453e-02f, 1.11381799e-01f, 9.30064619e-02f, 1.23623379e-01f, 1.25803441e-01f,
  3.51855569e-02f, -4.25335243e-02f, -5.60515618e-04f, -1.72032893e-01f, -1.50517449e-01f, -1.69170558e-01f, 3.52710076e-02f, -8.37013423e-02f, -1.69813067e-01f, -6.32188395e-02f,
  -7.71615952e-02f, -7.67015293e-02f, -8.29916671e-02f, -2.06054337e-02f, -8.56328830e-02f, -1.87073082e-01f, -1.53142482e-01f, 1.19877361e-01f, 1.07193746e-01f, 1.00117959e-01f,
  -1.28471106e-02f, 5.06104529e-02f, 1.91338763e-01f, 1.50384873e-01f, 7.98922703e-02f, 3.72777097e-02f, 5.87008186e-02f, -4.23093699e-02f, -4.81132083e-02f, 3.09394933e-02f,
  2.89616883e-01f, 7.19723627e-02f, 1.16263703e-01f, 1.65471658e-01f, -7.97845714e-04f, -6.99558994e-03f, -5.82467706e-04f, -3.68981771e-02f, 1.91218302e-01f, -4.90199104e-02f,
  -5.75891174e-02f, 2.45771840e-01f, 2.06952438e-01f, 2.47789007e-02f, 1.08020172e-01f, 1.83592081e-01f, -1.39536172e-01f, -1.25218019e-01f, -1.22468531e-01f, 4.14713025e-02f,
  -5.89369833e-02f, 8.54649544e-02f, -4.81106788e-02f, -2.25206632e-02f, 7.35602453e-02f, 4.85944375e-02f, 8.77700448e-02f, -1.24345561e-02f, -1.23328090e-01f, -6.80541694e-02f,
  1.43901303e-01f, 2.11749807e-01f, 1.66559190e-01f, 3.34081822e-03f, -7.55146295e-02f, -2.49830782e-01f, 9.10038650e-02f, -1.26917586e-01f, -1.39854267e-01f, -9.23024118e-03f,
  -1.78078935e-01f, -1.68465555e-01f, -4.76988070e-02f, -1.62889302e-01f, -1.77633911e-01f, -1.98617548e-01f, -6.86594769e-02f, 1.20636396e-01f, 1.33471206e-01f, -8.66489857e-02f,
  -2.49773301e-02f, 1.51649579e-01f, 1.36208147e-01f, 5.23561873e-02f, 5.57026267e-02f, 1.01817116e-01f, -2.20361166e-02f, -6.94869086e-02f, -3.88627350e-02f, -1.51810959e-01f,
  4.75363106e-01f, -1.88446999e-01f, 5.81177533e-01f, 1.59784809e-01f, 2.57131726e-01f, 4.25549597e-01f, 3.14476341e-01f, 1.74994886e-01f, 4.28581610e-02f, 4.50979806e-02f,
  -1.17796086e-01f, -1.03748344e-01f, -1.15706012e-01f, -1.14509314e-01f, 2.55597308e-02f, 1.19447842e-01f, 5.65949306e-02f, 2.37185791e-01f, 2.39306912e-01f, 1.90990165e-01f,
  -8.94750357e-02f, -1.14969797e-01f, -7.09338021e-03f, -6.11137934e-02f, -7.75621161e-02f, -1.38946518e-01f, -7.23445117e-02f, -5.52786328e-02f, -1.73124447e-01f, -2.99831837e-01f,
  1.00364052e-01f, -9.03122686e-03f, -1.17230508e-02f, -3.00144196e-01f, -1.13546014e-01f, -7.37788081e-02f, 1.00597948e-01f, -9.01962668e-02f, -1.35956705e-01f, -1.63532019e-01f,
  -9.23260525e-02f, -3.94167192e-02f, 7.45159388e-02f, -2.32262388e-02f, 6.06233552e-02f, 6.82659447e-02f, -9.56285521e-02f, 3.37965880e-03f, -3.58535605e-03f, -1.01756647e-01f,
  -1.60042152e-01f, 4.61838245e-02f, 1.27363712e-01f, 6.70108050e-02f, 9.93885472e-02f, -5.41975535e-02f, 3.54483910e-02f, -7.40375835e-03f, 2.10381914e-02f, -5.72883263e-02f,
  -1.48928851e-01f, 1.53144628e-01f, 2.53525805e-02f, 9.78356600e-02f, 5.89169674e-02f, 1.54566523e-02f, 1.13694057e-01f, -3.17222476e-02f, 3.21371369e-02f, 6.91738278e-02f,
  -5.71138151e-02f, 1.92894377e-02f, 1.04798734e-01f, 1.22199081e-01f, -4.92002554e-02f, 2.40584351e-02f, 9.88914818e-02f, 1.93292629e-02f, -4.25861776e-02f, 8.71259123e-02f,
  1.19777262e-01f, 4.04876061e-02f, 1.03683472e-01f, 1.95857901e-02f, -4.75123851e-03f, 6.51567504e-02f, 5.52652031e-02f, 6.15058653e-02f, -6.56717196e-02f, -1.07170157e-01f,
  -2.48890460e-01f, 1.29989162e-01f, -7.10661188e-02f, -1.35565236e-01f, -5.62268831e-02f, -1.43766791e-01f, 7.77301565e-02f, 3.25593166e-02f, -1.40573218e-01f, -1.70916408e-01f,
  -7.63996318e-02f, 8.18322692e-03f, 9.45516974e-02f, 1.87639054e-02f, 6.00096360e-02f, 1.24312183e-02f, -5.39714135e-02f, 1.84667572e-01f, -8.66910070e-02f, -5.09662740e-02f,
  -8.12689140e-02f, 1.72882210e-02f, 2.23935172e-01f, 2.06847727e-01f, 4.31114919e-02f, 1.56684905e-01f, 1.13008721e-02f, 1.39817044e-01f, 4.17491943e-02f, 1.49203762e-01f,
  -9.72611725e-01f, -7.78198615e-02f, -5.23427278e-02f, -4.28294361e-01f, -4.13396433e-02f, 2.30368465e-01f, -6.21739402e-02f, 1.65829748e-01f, 1.85740039e-01f, 1.69919640e-01f,
  7.91650265e-02f, -1.75814420e-01f, -1.58163458e-01f, -2.01016739e-02f, -1.47290289e-01f, 5.20775653e-02f, -2.99622472e-02f, -3.51138741e-01f, -3.00227076e-01f, 8.18054527e-02f,
  6.03557453e-02f, -3.97043824e-01f, -4.28158581e-01f, 7.80137926e-02f, 2.97712237e-02f, -2.01012567e-02f, 5.77972122e-02f, -1.79989532e-01f, 1.57016575e-01f, -5.94934002e-02f,
  -2.92257279e-01f, -3.12444180e-01f, 1.05445676e-01f, -6.67797774e-02f, 1.91839673e-02f, -5.55591285e-02f, -1.13588899e-01f, -1.34504169e-01f, 1.11563392e-01f, 1.46293446e-01f,
  4.84469812e-03f, 1.05205312e-01f, -1.85311854e-01f, 8.53996649e-02f, -1.76926956e-01f, 6.15240587e-03f, 1.48793831e-01f, -1.71576500e-01f, 9.20970067e-02f, 2.37559691e-01f,
  1.98903754e-01f, -6.43896637e-03f, -1.79877967e-01f, 2.61754632e-01f, 2.41127059e-01f, -7.61132911e-02f, 3.88029777e-02f, 1.37460083e-01f, 2.08253384e-01f, 9.09547359e-02f,
  1.21540532e-01f, 5.41568510e-02f, -2.08110735e-02f, -8.24935511e-02f, -5.99092804e-02f, -3.95498332e-03f, -1.34310097e-01f, 1.15436809e-02f, -4.30226289e-02f, -7.25313649e-02f,
  9.70526710e-02f, 1.42952297e-02f, 8.49352330e-02f, -4.85483035e-02f, -1.20660216e-02f, 5.22719510e-02f, -4.03768793e-02f, 1.64866826e-04f, 1.05055675e-01f, -8.71367846e-03f,
  -1.41321227e-01f, 1.48424327e-01f, -8.96900445e-02f, -3.30267027e-02f, 3.10217007e-03f, -9.47876871e-02f, 1.03531696e-01f, 6.09660819e-02f, -1.38440222e-01f, -1.41959349e-02f,
  -4.57155079e-01f, -1.46650359e-01f, -2.25629508e-01f, -1.14520945e-01f, 4.52354997e-02f, 2.08175585e-01f, -3.34339701e-02f, -4.06915471e-02f, -7.52942711e-02f, -2.23093051e-02f,
  1.30543232e-01f, -1.59857869e-02f, -6.92713484e-02f, 1.18776210e-01f, -8.10554773e-02f, 3.38556170e-02f, 4.45274599e-02f, -1.15074858e-01f, 1.21454179e-01f, 1.30982265e-01f,
  6.87522665e-02f, -5.05326735e-03f, -2.92366296e-01f, -1.21030509e-02f, 1.49553446e-02f, -1.89705610e-01f, -1.39052048e-01f, 3.79430167e-02f, -1.09423129e-02f, -2.76649863e-01f,
  -3.58559400e-01f, -2.22479016e-01f, 6.29988685e-02f, 6.88589877e-03f, -1.36466235e-01f, -2.72517093e-03f, -4.90301959e-02f, 6.55157343e-02f, 1.42385095e-01f, 9.10490286e-04f,
  2.06914321e-01f, 2.48347804e-01f, 2.07709327e-01f, 2.60407865e-01f, 2.19587013e-01f, 1.02806747e-01f, 1.03588089e-01f, 1.84889212e-01f, 9.78082269e-02f, 1.30657047e-01f,
  -2.06509493e-02f, -1.88614219e-01f, -9.38505977e-02f, 8.02873820e-02f, 1.28974274e-01f, 9.27980840e-02f, -9.01857689e-02f, -1.71065673e-01f, 4.64060082e-04f, 1.52897656e-01f,
  4.93807793e-01f, -2.88348407e-01f, 1.23275906e-01f, 1.07698634e-01f, -1.71314254e-01f, 1.09686516e-02f, 4.14230227e-02f, -1.31623879e-01f, -5.95669262e-02f, -1.45098697e-02f,
  5.65839633e-02f, -1.48393720e-01f, -1.13528356e-01f, -2.51898199e-01f, -1.82455227e-01f, -5.77350408e-02f, -7.00855404e-02f, -7.88482577e-02f, 1.40289471e-01f, 1.02206081e-01f,
  1.59797356e-01f, -8.56904760e-02f, 1.45846933e-01f, 9.81701016e-02f, 1.20858893e-01f, 1.35384485e-01f, -5.39086061e-03f, -2.32838634e-02f, 5.59433140e-02f, 3.36833745e-02f,
  2.07111150e-01f, 1.56552643e-01f, -4.14912961e-03f, -5.69253638e-02f, -1.87582185e-03f, -1.55231664e-02f, -7.71332160e-02f, -8.96799099e-03f, 5.46288714e-02f, -5.39664999e-02f,
  -1.20675944e-01f, -2.18982138e-02f, 2.94382945e-02f, 5.70621751e-02f, 5.43007739e-02f, -1.30543280e-02f, -1.06449880e-01f, 1.33718729e-01f, -6.97420090e-02f, -1.46513432e-01f,
  -1.23964176e-01f, 3.58686596e-02f, -3.99739482e-03f, -7.89626464e-02f, -2.17213612e-02f, 8.31777826e-02f, 1.08940855e-01f, 5.72236143e-02f, 5.63951395e-02f, 1.92700028e-02f,
  2.49614134e-01f, 2.09078733e-02f, 1.12243153e-01f, 7.70395324e-02f, -6.58812076e-02f, -4.80991937e-02f, 1.14142358e-01f, -9.65279713e-02f, -3.32643650e-02f, 8.07052404e-02f,
  5.98027632e-02f, 5.16924262e-02f, -1.27099976e-01f, -1.74554728e-03f, 6.86546601e-03f, 4.58013155e-02f, -1.32177789e-02f, 6.88995644e-02f, 1.66509837e-01f, 1.55227005e-01f,
  1.85149997e-01f, 1.79483742e-01f, 3.07319909e-01f, 2.35105291e-01f, 2.08715528e-01f, 2.51212507e-01f, 5.69533929e-02f, 1.35340735e-01f, 1.75504088e-01f, -6.62955791e-02f,
  1.68972105e-01f, -2.17370912e-01f, 5.24325132e-01f, 5.36139905e-02f, -4.63416934e-01f, -3.67572337e-01f, -4.13253695e-01f, -8.23313519e-02f, -7.63716623e-02f, -3.93472128e-02f,
  -3.39482456e-01f, -1.19409859e-01f, 8.04296359e-02f, 2.90978193e-01f, 2.25510314e-01f, 2.22208098e-01f, 4.26724583e-01f, 6.05211377e-01f, 2.85978556e-01f, -1.60732701e-01f,
  -1.83058336e-01f, 1.30948141e-01f, 3.92067581e-01f, 1.98630705e-01f, 5.61781190e-02f, -5.45615740e-02f, 6.21900707e-02f, -3.58767132e-03f, -6.66127130e-02f, 3.57758552e-01f,
  1.78230107e-01f, 1.34938717e-01f, -1.52834868e-02f, -1.08509779e-01f, 5.28391041e-02f, -1.73025001e-02f, -1.87411550e-02f, 1.54955655e-01f, -1.38213858e-01f, 9.60126668e-02f,
  -7.53898546e-02f, 1.74171831e-02f, -3.00066154e-02f, -2.92954538e-02f, -5.18338755e-02f, -7.52620921e-02f, 2.15819463e-01f, 3.09150517e-01f, 3.09673339e-01f, -5.28260134e-02f,
  -9.23725218e-02f, -3.75817031e-01f, -1.19675219e-01f, -6.44872263e-02f, 3.90698984e-02f, 3.65084819e-02f, -1.57744870e-01f, 2.07431346e-01f, 4.31803837e-02f, 2.86313266e-01f,
  1.12076111e-01f, 7.85053298e-02f, 1.13376444e-02f, 4.97852415e-02f, -3.42844613e-02f, -5.88035036e-04f, 8.84593930e-03f, -1.05398551e-01f, 5.47515824e-02f, 9.15577635e-03f,
  5.06453309e-03f, 6.44399151e-02f, 8.23234171e-02f, -3.97738554e-02f, 2.52433699e-02f, 7.97405317e-02f, -1.16312884e-01f, 1.02691695e-01f, -5.11541292e-02f, 3.25999483e-02f,
  4.31732424e-02f, -3.94912511e-02f, -5.80363497e-02f, 1.40614599e-01f, 6.73446665e-03f, 4.96870913e-02f, 4.93344031e-02f, -9.16778520e-02f, 6.78616017e-02f, 6.55273125e-02f,
  -2.23355651e-01f, 4.02002037e-02f, 1.34729207e-01f, 5.63172437e-02f, -3.26855928e-02f, -5.19546606e-02f, -5.04691266e-02f, -3.98054272e-02f, -9.25894678e-02f, -1.57394886e-01f,
  -2.44814351e-01f, -1.60354115e-02f, -4.37009819e-02f, 1.04391556e-02f, -2.77604237e-02f, -1.25967041e-01f, -1.65690128e-02f, -1.62204169e-02f, 6.18436597e-02f, -2.01088428e-01f,
  5.15080383e-03f, -1.66105673e-01f, -1.93398714e-01f, -2.28473812e-01f, -1.56654239e-01f, -2.45186105e-01f, -1.82274476e-01f, -2.72178769e-01f, -2.45993629e-01f, -2.61032552e-01f,
  1.03967285e+00f, 3.31307590e-01f, 2.97828496e-01f, 2.62685180e-01f, -2.88754404e-02f, 5.29104955e-02f, 1.57469168e-01f, 2.26834029e-01f, 1.01273336e-01f, 1.52202204e-01f,
  1.41261801e-01f, 5.66048101e-02f, 6.21344429e-03f, 1.14747122e-01f, 2.01279119e-01f, 1.46999717e-01f, 6.85143992e-02f, 1.47238418e-01f, 2.07370937e-01f, 2.82157689e-01f,
  1.03571989e-01f, 2.24579230e-01f, 3.21536392e-01f, 1.42415762e-01f, 1.41982719e-01f, -1.53519614e-02f, 2.75167972e-02f, 1.28760606e-01f, 1.18158862e-01f, 1.29543439e-01f,
  2.55999109e-03f, 4.26191330e-01f, -2.34778732e-01f, 6.55698329e-02f, 4.08530831e-02f, -5.09029701e-02f, 2.58844579e-04f, 3.98188420e-02f, 1.14379264e-02f, -1.38416886e-01f,
  -9.91090164e-02f, 1.50783993e-02f, 1.40374139e-01f, -2.58740447e-02f, -1.90522578e-02f, -9.58705023e-02f, 9.85465050e-02f, 9.81844142e-02f, -4.14771726e-03f, -9.32254642e-02f,
  -2.97202468e-02f, 3.39716598e-02f, -7.03205764e-02f, -6.31032288e-02f, 1.13671057e-01f, -7.79634193e-02f, 6.44692546e-03f, 9.12700519e-02f, -5.53212985e-02f, 2.32775599e-01f,
  1.01408295e-01f, 8.15267935e-02f, 1.14976212e-01f, 1.34318128e-01f, 1.57771438e-01f, 1.40365623e-02f, -4.32331003e-02f, -1.89566035e-02f, 8.63992646e-02f, 1.65282354e-01f,
  -6.32502809e-02f, -1.76665355e-02f, 3.44452076e-02f, 9.07157548e-04f, -7.92156532e-02f, -5.47411628e-02f, -2.94707604e-02f, 3.72684351e-03f, 6.99294060e-02f, -1.31806374e-01f,
  9.17383656e-02f, -6.66972995e-02f, 7.83646628e-02f, 8.17406923e-02f, -4.53737564e-02f, 6.85824081e-02f, 1.32884964e-01f, 8.74898434e-02f, 1.76824123e-01f, -3.89024615e-02f,
  -6.63759410e-01f, -7.67986923e-02f, 3.42732705e-02f, 6.39935657e-02f, 1.66312885e-02f, 1.27893299e-01f, -2.04442050e-02f, -1.39082447e-01f, -1.86185926e-01f, -2.30031103e-01f,
  -6.41513243e-02f, -6.15082607e-02f, 7.11176952e-04f, 4.97519337e-02f, -3.17665488e-02f, -1.32693544e-01f, 3.86776440e-02f, -2.12985441e-01f, -1.16527878e-01f, -1.12969555e-01f,
  -1.02423571e-01f, -1.06096588e-01f, -2.40671664e-01f, -1.25756636e-01f, -1.55891001e-01f, -1.12231672e-01f, -1.31037995e-01f, -3.21962498e-02f, -1.01995416e-01f, -4.74355780e-02f,
  -5.48944652e-01f, -1.55762926e-01f, -2.92572439e-01f, 2.00560197e-01f, 7.73435012e-02f, 1.31941959e-01f, 1.02011956e-01f, 6.47019744e-02f, 1.06544234e-01f, -3.09394076e-02f,
  -4.96777296e-02f, 9.19531435e-02f, 2.40784973e-01f, 2.34161809e-01f, 1.41762108e-01f, 1.72302485e-01f, 3.18929434e-01f, 8.59159306e-02f, 5.46777397e-02f, -1.09444503e-02f,
  2.72177517e-01f, -7.92692825e-02f, -1.68776751e-01f, 2.03239080e-02f, -4.07323912e-02f, 2.39331737e-01f, -2.55997237e-02f, -8.66262764e-02f, 1.07036814e-01f, 1.90581605e-01f,
  -2.32146546e-01f, -4.52016771e-01f, 1.99253947e-01f, 6.57416210e-02f, -1.20370068e-01f, -2.00243264e-01f, -1.38230935e-01f, -2.02765882e-01f, -1.97110742e-01f, -1.16989754e-01f,
  -1.51465476e-01f, 5.11128753e-02f, 5.34778610e-02f, 9.80585143e-02f, -6.13419786e-02f, -1.14787303e-01f, -5.21849059e-02f, -9.38675180e-02f, -1.55345812e-01f, -2.35386714e-01f,
  3.15163493e-01f, -1.03551209e-01f, -4.31395680e-01f, -4.43033688e-02f, -2.32887976e-02f, -8.92339498e-02f, -2.70370185e-01f, -2.28692412e-01f, -2.63521552e-01f, -4.75496948e-01f,
  6.13513812e-02f, -4.67146598e-02f, 7.45771080e-02f, -1.60714895e-01f, 4.61414605e-02f, 1.14063337e-01f, 2.08798677e-01f, 1.09100066e-01f, 4.76044081e-02f, -2.01042667e-01f,
  2.70711780e-02f, 1.69117436e-01f, -5.13533242e-02f, -9.74820554e-03f, 6.40732795e-03f, -8.85574743e-02f, 1.22606801e-02f, 1.22567646e-01f, -1.13445610e-01f, 1.77881978e-02f,
  -4.54224981e-02f, -7.89880529e-02f, -1.00317970e-01f, 9.11294296e-02f, 8.37687626e-02f, 1.40903771e-01f, -3.92264873e-03f, -4.22898866e-02f, -1.53243482e-01f, -2.15465143e-01f,
  -1.77454248e-01f, 1.88595071e-01f, -1.30644873e-01f, -3.22666876e-02f, 1.65844262e-02f, -7.94147477e-02f, -9.79561452e-03f, -3.05163953e-02f, -1.21093735e-01f, 3.17457085e-03f,
  -1.68244720e-01f, -1.66958064e-01f, 4.33865003e-02f, 7.71189947e-03f, 4.01188731e-02f, -6.28610328e-02f, 9.30957124e-03f, 1.11391045e-01f, -1.75851863e-02f, -1.50746867e-01f,
  -3.07367034e-02f, -4.50908355e-02f, -1.98826537e-01f, 8.74546915e-02f, -6.57354593e-02f, -7.73684010e-02f, -1.54030710e-01f, -1.45180911e-01f, -1.72366619e-01f, -3.02354008e-01f,
  -1.56691462e-01f, 4.68992501e-01f, -3.26006889e-01f, 2.31243402e-01f, 4.42716599e-01f, -1.04623511e-01f, 3.81977968e-02f, -3.23043287e-01f, 5.78727107e-03f, 2.64937162e-01f,
  1.48036405e-01f, -3.69536318e-02f, 3.79037783e-02f, -1.12858161e-01f, -4.23225522e-01f, 1.73543245e-01f, 2.24663973e-01f, -3.46909434e-01f, -6.06732965e-01f, -3.11567008e-01f,
  3.02499175e-01f, 2.64858872e-01f, -1.14065535e-01f, -2.11024396e-02f, 2.45949835e-01f, -1.62165519e-03f, 1.82413474e-01f, 2.14953348e-01f, 1.38242796e-01f, 3.42351228e-01f,
  -2.03517675e-01f, -1.94411203e-01f, -1.51998222e-01f, 2.21492574e-01f, -2.90778652e-02f, -2.50250548e-01f, -7.50008523e-02f, -2.72615910e-01f, -1.16710678e-01f, 1.99460378e-03f,
  1.93784699e-01f, -1.40196592e-01f, -1.46816904e-02f, -1.28280088e-01f, -1.91416755e-01f, -1.26683176e-01f, -4.75519896e-02f, -3.03591222e-01f, -3.54580909e-01f, -4.55749571e-01f,
  2.47133747e-01f, 1.31929412e-01f, -2.11054370e-01f, -2.79344201e-01f, -3.65865558e-01f, -1.01408795e-01f, -2.99284101e-01f, -2.75638014e-01f, -4.19775635e-01f, -1.88411493e-02f,
  -9.02800113e-02f, -5.57910614e-02f, -5.40332450e-03f, 1.47834122e-01f, -1.47129432e-03f, 1.56319868e-02f, -3.20655182e-02f, -7.91501254e-02f, 7.29003400e-02f, 1.34872764e-01f,
  -1.43420249e-01f, 1.09099569e-02f, -9.51384306e-02f, 1.51460841e-02f, -5.52412076e-03f, -4.11330834e-02f, -6.63427338e-02f, 3.16113532e-02f, -1.68262571e-01f, -8.05585533e-02f,
  -6.73545226e-02f, -1.01455592e-01f, 5.67084216e-02f, -1.00311510e-01f, 1.95162177e-01f, -1.29253697e-02f, 7.35048577e-02f, -5.54436669e-02f, -1.06071487e-01f, 1.22463837e-01f,
  1.44443706e-01f, -2.05818042e-02f, 3.72458994e-02f, 4.34967456e-03f, -1.74729507e-02f, 2.62664687e-02f, 8.11649710e-02f, -4.96866629e-02f, 1.08279735e-01f, -2.10149497e-01f,
  -1.31496459e-01f, -1.67068899e-01f, 1.31568730e-01f, -4.16226080e-03f, -1.66880473e-01f, -8.33746453e-04f, 2.49298811e-01f, 1.23142101e-01f, 1.04303986e-01f, 1.50000498e-01f,
  1.26186758e-01f, 1.02344655e-01f, -7.65438974e-02f, 1.39955044e-01f, 1.29371852e-01f, -6.43276125e-02f, -1.73458382e-01f, 1.94950178e-02f, -2.31093988e-01f, 1.22059129e-01f,
  -6.85530961e-01f, 1.77128658e-01f, -4.09106314e-01f, -4.76978570e-01f, -5.72513342e-01f, -3.03664446e-01f, 3.21193635e-01f, -4.57762070e-02f, -3.55010241e-01f, 1.29489213e-01f,
  1.04128323e-01f, -1.83120370e-02f, 5.92365377e-02f, 1.81822762e-01f, 1.39544129e-01f, 1.58859998e-01f, -3.75929385e-01f, -3.46011788e-01f, -2.63773918e-01f, -1.61507070e-01f,
  -2.22652927e-02f, -2.88538095e-02f, -2.92031139e-01f, -2.65363038e-01f, -3.15505490e-02f, 4.80021909e-03f, -5.80693521e-02f, -3.02215695e-01f, -2.96409559e-02f, -3.24371494e-02f,
  3.86899203e-01f, -3.88855249e-01f, -1.53454214e-01f, -1.67406052e-01f, -9.03073773e-02f, -1.41502604e-01f, -3.51145864e-02f, -7.27670565e-02f, -1.21782914e-01f, -8.63632709e-02f,
  -1.99186206e-01f, -1.23161256e-01f, -1.67761281e-01f, 1.67724653e-03f, -1.27899498e-01f, 1.39946574e-02f, 4.43962924e-02f, -4.92995009e-02f, 4.26823981e-02f, 1.45270377e-01f,
  -1.73252709e-02f, -2.29664057e-01f, -1.26185566e-01f, 5.15542701e-02f, 3.06974258e-03f, -1.01410322e-01f, 2.79921312e-02f, -1.38023093e-01f, -2.93384250e-02f, 3.64089549e-01f,
  1.48909584e-01f, 1.81689039e-01f, -2.11424176e-02f, 1.42360196e-01f, 9.94067118e-02f, 1.16778098e-01f, 3.41730355e-03f, 5.94853796e-02f, 1.67504661e-02f, 1.33572817e-01f,
  -2.00914126e-02f, 6.99021965e-02f, 2.29157936e-02f, 8.63398984e-02f, 7.61622097e-03f, -1.87429726e-01f, -8.41584615e-03f, 1.39680132e-01f, -1.32956980e-02f, -7.56313354e-02f,
  -1.18040636e-01f, -1.15917869e-01f, -6.91446587e-02f, 4.15739641e-02f, -1.28345773e-01f, 2.09125108e-03f, -1.02459304e-01f, 7.98875988e-02f, -9.88042541e-03f, -1.94628447e-01f,
  4.02215660e-01f, -2.44942576e-01f, 9.34008583e-02f, 1.71620566e-02f, -7.97205716e-02f, -5.50732873e-02f, -1.15536213e-01f, -1.12159558e-01f, -2.03349233e-01f, 4.49156761e-02f,
  -2.30498984e-01f, -1.17388349e-02f, 2.95409765e-02f, 5.99852540e-02f, 8.93355533e-03f, 6.24126792e-02f, 7.40966666e-03f, 2.97085531e-02f, -4.24168073e-03f, 4.53857258e-02f,
  2.89134961e-02f, 4.84866016e-02f, 2.75999188e-01f, 1.73937201e-01f, 8.48558769e-02f, 3.97367328e-02f, 2.55678922e-01f, 8.21259469e-02f, 8.75957683e-02f, 6.78886414e-01f,
  -3.92012089e-01f, -4.08089072e-01f, -3.12318534e-01f, -4.75385606e-01f, -4.08140153e-01f, 7.95184374e-02f, -1.01107724e-01f, -1.17480800e-01f, -2.43602380e-01f, -2.65238822e-01f,
  1.00275174e-01f, 1.40944242e-01f, -1.53472334e-01f, 6.73720986e-02f, 2.23257959e-01f, -3.04246813e-01f, -3.50823253e-01f, -6.92326948e-02f, 3.89257520e-01f, 2.71986306e-01f,
  3.82231884e-02f, -1.69559121e-01f, -8.66086408e-03f, 3.65466662e-02f, -3.56154740e-01f, -2.27179199e-01f, -3.51277620e-01f, -3.31952631e-01f, -1.32886916e-01f, -6.32563353e-01f,
  -2.40471721e-01f, 9.97958109e-02f, 2.11017892e-01f, 2.19202876e-01f, -9.62982923e-02f, 1.02569737e-01f, -1.60123296e-02f, -9.57888365e-02f, 7.85080492e-02f, -8.33833888e-02f,
  -1.04154032e-02f, 2.43560851e-01f, 8.76954645e-02f, 1.59661397e-01f, -7.20167533e-02f, -2.09976621e-02f, -6.62297085e-02f, -2.31433325e-02f, 2.66882926e-02f, -2.74683461e-02f,
  -4.23352495e-02f, -1.22367226e-01f, 3.10954377e-02f, 1.20786540e-01f, 7.61084352e-03f, -1.10223647e-02f, 2.91934628e-02f, 8.25466681e-03f, -2.38313414e-02f, -5.91740429e-01f,
  -1.52085811e-01f, -1.07702449e-01f, 9.14540421e-03f, 8.38198364e-02f, 4.98021394e-02f, -1.45478323e-01f, -1.34547250e-02f, 2.00687535e-02f, 7.37984106e-02f, 6.48792386e-02f,
  5.88537864e-02f, -4.70662937e-02f, 1.39458895e-01f, -8.60510767e-02f, -5.46616688e-02f, -1.56691730e-01f, -7.36714080e-02f, -6.20556772e-02f, 2.80399043e-02f, -1.18487224e-01f,
  8.46952870e-02f, -3.44457962e-02f, -1.48914009e-01f, 4.03354205e-02f, 2.68522333e-02f, -1.69757426e-01f, -1.02801574e-02f, 9.70382392e-02f, -1.08524196e-01f, 6.11320473e-02f,
  -1.98672086e-01f, 1.74042583e-01f, -2.23765284e-01f, 1.19435772e-01f, -1.99031174e-01f, -1.86230361e-01f, -1.77375585e-01f, 1.75266303e-02f, 3.39205824e-02f, -1.07693739e-01f,
  1.69420149e-02f, -1.12420946e-01f, 1.27128162e-03f, 8.68629366e-02f, 6.93662092e-02f, -9.44799930e-03f, -3.16743478e-02f, -8.15925747e-02f, 1.92076251e-01f, -1.37451425e-01f,
  3.79428305e-02f, 1.03873856e-01f, 5.98930172e-04f, -3.12208943e-02f, -1.04708828e-01f, -7.92372152e-02f, -1.89790249e-01f, -7.31683820e-02f, -6.54609781e-03f, -4.92257416e-01f,
  2.14935362e-01f, -5.71506560e-01f, -8.48618057e-03f, 2.56192609e-04f, 2.31995463e-01f, 2.96735972e-01f, 3.38082225e-03f, 6.55843839e-02f, 9.49164480e-02f, -2.34794870e-01f,
  -4.76356298e-01f, -3.68651658e-01f, -3.86980563e-01f, -2.52600044e-01f, 2.71081850e-02f, -1.35072351e-01f, 2.33811326e-02f, 2.36562550e-01f, 4.12812412e-01f, 3.59253556e-01f,
  1.12858102e-01f, 8.37482139e-02f, 1.59358054e-01f, 2.02621609e-01f, -1.50323719e-01f, -1.30565897e-01f, -2.96452463e-01f, -3.09542287e-02f, -6.67568222e-02f, -3.55877787e-01f,
  -3.81797224e-01f, -2.13319123e-01f, 2.22638384e-01f, 9.46954712e-02f, -2.38982216e-01f, 3.21613401e-02f, 1.82952341e-02f, 2.53072707e-03f, -9.97577533e-02f, 4.03239764e-03f,
  -3.07486486e-02f, -4.44424264e-02f, -7.66446441e-02f, -6.05431385e-02f, 4.00847644e-02f, 8.11933726e-02f, -1.49240136e-01f, -1.07074007e-01f, -2.07099438e-01f, -1.06859073e-01f,
  -1.81706637e-01f, 6.75899759e-02f, 1.01200528e-01f, -2.20892020e-02f, -9.88707319e-02f, 1.23853110e-01f, -2.19404519e-01f, -1.05663473e-02f, 3.94224338e-02f, -1.77263096e-01f,
  1.68827102e-01f, -8.89527984e-03f, -8.80231932e-02f, 6.55087829e-02f, -1.77007899e-01f, 1.16089294e-02f, -8.26206505e-02f, -7.02666417e-02f, 6.45307824e-02f, 7.99935590e-03f,
  -3.34365703e-02f, 2.51167752e-02f, -3.10244057e-02f, -5.06041534e-02f, -1.73792928e-01f, -8.18883777e-02f, 8.98458585e-02f, -1.42877072e-01f, -3.69566754e-02f, -1.18219247e-02f,
  -5.16164601e-02f, 1.67111831e-03f, 4.66096140e-02f, 1.33671355e-03f, -1.22248391e-02f, -2.89535075e-02f, 1.70568854e-03f, 5.89444228e-02f, 4.40503582e-02f, 1.13136485e-01f,
  -2.42447898e-01f, 8.06628689e-02f, -9.59889516e-02f, -5.84894754e-02f, 1.46283153e-02f, -4.33859266e-02f, -1.16603181e-01f, 6.54397607e-02f, -5.67908771e-02f, 6.30970597e-02f,
  -1.76779963e-02f, 2.88541652e-02f, -8.34011436e-02f, 1.58895869e-02f, 1.35380685e-01f, 1.15654834e-01f, -1.30155385e-01f, -1.07020214e-01f, -1.56661812e-02f, 7.62049481e-02f,
  -4.06384021e-02f, 1.74853161e-01f, 1.84569761e-01f, 1.22426920e-01f, 4.08299938e-02f, 2.86969304e-01f, 6.88241124e-02f, 2.11151585e-01f, 2.41303295e-01f, 2.48089090e-01f,
  -3.93570095e-01f, 3.36753666e-01f, 4.10893470e-01f, -1.02364466e-01f, 2.75688767e-01f, 3.40176940e-01f, 1.72071815e-01f, 5.81404986e-03f, -1.61232099e-01f, 7.66733363e-02f,
  2.01081142e-01f, -3.86669874e-01f, -1.98359877e-01f, -3.61878276e-01f, -4.42993850e-01f, -2.49926582e-01f, -2.40328118e-01f, -4.23860490e-01f, -4.90974605e-01f, -3.30645084e-01f,
  -2.85837948e-01f, -3.88860255e-01f, -4.55394924e-01f, -3.40071648e-01f, 1.11135669e-01f, -1.66727602e-01f, -1.40403789e-02f, 4.66623306e-02f, 1.60813957e-01f, 1.35170028e-01f,
  1.58429325e-01f, 5.00186265e-01f, -7.85641894e-02f, -1.09800801e-01f, 4.81462926e-02f, -2.91955825e-02f, -5.85187860e-02f, 8.94310102e-02f, -5.21671725e-04f, -1.06367674e-02f,
  -1.58936065e-02f, -5.26461527e-02f, 2.17121816e-03f, 4.85622250e-02f, -2.60419343e-02f, 6.68696612e-02f, 7.23041445e-02f, -5.47699034e-02f, 2.71659642e-02f, 9.36726555e-02f,
  1.91289008e-01f, 2.52975076e-01f, 4.45369557e-02f, 4.90284860e-02f, 1.68048486e-01f, 9.11570061e-03f, 2.44416445e-01f, 2.06401944e-01f, 1.01195283e-01f, 8.77772570e-02f,
  -8.77917185e-03f, -1.30295157e-01f, 9.05178934e-02f, 4.37076688e-02f, -1.38004851e-02f, -1.19768381e-02f, 5.14128171e-02f, -1.45160824e-01f, -1.35290802e-01f, -1.12493031e-01f,
  1.05580218e-01f, 3.79718319e-02f, -8.74417052e-02f, 6.24158867e-02f, 1.05111748e-02f, 4.49166037e-02f, 6.67179376e-02f, -6.26355596e-03f, 8.71700794e-02f, 8.30837786e-02f,
  5.45250997e-02f, 1.22961305e-01f, 1.13493256e-01f, -1.36419944e-02f, 2.34800845e-01f, 1.90359131e-01f, 5.77634759e-02f, 1.19934641e-02f, -9.51921493e-02f, 9.72358789e-03f,
  -1.55346856e-01f, 1.41770303e-01f, -2.10844800e-01f, -1.45552814e-01f, -5.21125123e-02f, 1.35711387e-01f, 1.55073911e-01f, 4.18174788e-02f, 9.45229605e-02f, 5.08912019e-02f,
  3.31614316e-02f, -4.88348082e-02f, 6.10319562e-02f, 4.40578423e-02f, -8.48234147e-02f, 8.95600393e-02f, 1.07733488e-01f, 8.17260817e-02f, 4.33076881e-02f, 1.05984896e-01f,
  1.17161646e-02f, -7.94277564e-02f, -1.73654005e-01f, 9.46961809e-03f, -4.10011746e-02f, -2.55563706e-01f, -4.40749014e-03f, 1.11430585e-01f, -2.99705565e-02f, -2.33712763e-01f,
  2.14410111e-01f, 8.29085037e-02f, -7.96422005e-01f, 1.61954085e-03f, -1.34022251e-01f, -4.77387041e-01f, -4.41542506e-01f, 5.19320816e-02f, 2.64250875e-01f, 9.05970559e-02f,
  2.69811839e-01f, 4.23412144e-01f, 3.17846537e-01f, 1.95331983e-02f, -2.80456036e-01f, -5.49528658e-01f, -5.90822637e-01f, -5.79473853e-01f, -4.43833590e-01f, -5.30260354e-02f,
  -1.40720963e-01f, -1.75980464e-01f, -1.67149708e-01f, -3.80305760e-02f, 1.50216252e-01f, 1.00536406e-01f, -3.48484397e-01f, -1.76663846e-01f, -3.01750988e-01f, -1.88907847e-01f,
  -3.96994948e-01f, -3.06544721e-01f, -1.39666542e-01f, 1.13460407e-01f, -1.47821158e-01f, 1.84062105e-02f, 6.23734146e-02f, -2.47596335e-02f, 1.77878514e-01f, 6.98072985e-02f,
  4.71290834e-02f, 1.05695844e-01f, 1.04812555e-01f, 1.61544502e-01f, 4.35265750e-02f, 3.57557982e-02f, 2.93815732e-02f, -1.40244007e-01f, -1.02998763e-01f, 1.13444656e-01f,
  5.68076484e-02f, -1.42654717e-01f, -8.10336694e-02f, -1.72192305e-01f, -2.49951750e-01f, -1.78202111e-02f, -1.13560505e-01f, -1.12139791e-01f, -2.10805446e-01f, -1.00175878e-02f,
  -1.32382482e-01f, 1.11788131e-01f, -4.22007926e-02f, 5.31072728e-02f, 7.81014413e-02f, 9.01098475e-02f, -2.65766401e-02f, 1.94227919e-01f, 5.57867996e-02f, 7.32425675e-02f,
  1.77880347e-01f, -8.99970680e-02f, -7.83488601e-02f, -1.22646168e-02f, -4.35632803e-02f, -9.92084816e-02f, -2.59812754e-02f, -1.28390223e-01f, -8.89995396e-02f, 5.35663404e-02f,
  1.62614956e-01f, -8.53769258e-02f, -2.31941137e-02f, -9.28128138e-02f, -1.51396170e-01f, -1.67789638e-01f, 4.22132127e-02f, 1.22179821e-01f, 8.79703090e-02f, 7.47957006e-02f,
  3.39475840e-01f, -4.59681034e-01f, 1.88426062e-01f, 1.25406891e-01f, -3.62274982e-02f, 1.23056546e-01f, 4.55732234e-02f, 2.63525043e-02f, 9.20953527e-02f, 1.16595075e-01f,
  -2.00712271e-02f, -1.07889958e-02f, 5.14763035e-02f, 1.14003904e-01f, 9.13804770e-02f, -2.21806057e-02f, 1.31252035e-01f, 3.15731727e-02f, -3.79714109e-02f, 1.54037222e-01f,
  1.54505566e-01f, 2.41295770e-02f, 2.07435012e-01f, 6.83522671e-02f, 1.19813476e-02f, -4.28284109e-02f, 4.24426831e-02f, 1.28895059e-01f, -1.29591256e-01f, 1.15760334e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.33585072e-01f, 4.49431062e-01f, 3.56979489e-01f, 4.63410616e-01f, 1.41185060e-01f, 2.30774716e-01f, 8.53927061e-02f, 3.82030994e-01f, 4.21551079e-01f, 2.31259078e-01f,
  3.69740347e-03f, 1.51373327e-01f, 4.78412598e-01f, 4.07164454e-01f, 4.50073808e-01f, 5.35660446e-01f, 1.53531164e-01f, 4.41647738e-01f, 3.89695317e-01f, 6.16676509e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.46482769e-02f, -1.28549244e-02f, -1.96083579e-02f, -1.75693389e-02f, 5.33520840e-02f, -1.16587877e-01f, 1.30469352e-02f, -2.86360353e-01f, -7.23707378e-02f, -3.96325812e-02f,
  -9.66830477e-02f, 2.78553125e-02f, -2.91487098e-01f, 3.81264240e-01f, 2.02485882e-02f, 1.50757832e-02f, -2.96092760e-02f, -2.19204664e-01f, 3.28803897e-01f, -1.77175805e-01f,
  -3.11440118e-02f, -1.96200252e-01f, -1.91572737e-02f, 4.05038029e-01f, -5.69393523e-02f, 1.32337540e-01f, -1.18838660e-01f, -2.87593901e-01f, -1.96298957e-01f, 4.57293600e-01f,
  -2.22987264e-01f, -1.07631989e-01f, -1.15091532e-01f, -7.42328539e-02f, -1.84482515e-01f, 1.36203423e-01f, -1.16232134e-01f, 8.36107209e-02f, -2.97651310e-02f, -3.63168605e-02f,
  -1.64125189e-02f, 6.88309073e-02f, -1.04524881e-01f, 2.30711266e-01f, -1.88321829e-01f, -1.69139087e-01f, 6.49233833e-02f, 2.75504470e-01f, 1.42282285e-02f, -1.75640564e-02f,
  -2.57305503e-01f, -7.90408552e-02f, -1.43943965e-01f, 1.31280184e-01f, -1.16542384e-01f, -4.02530909e-01f, 2.43332416e-01f, -3.44306052e-01f, 1.08514167e-01f, 1.47028342e-01f,
  -7.89639503e-02f, 1.13831729e-01f, 1.90877199e-01f, 3.40210855e-01f, 1.60679638e-01f, 8.55074171e-03f, -7.81171620e-02f, -6.05601668e-02f, 2.39528790e-01f, -1.47169996e-02f,
  -5.61744124e-02f, 8.15695245e-03f, 3.52170795e-01f, 1.02971338e-01f, 3.89422029e-02f, -2.81330168e-01f, 3.07910532e-01f, -7.98447896e-03f, 1.21270768e-01f, 5.09501398e-02f,
  2.33841851e-01f, -1.02367006e-01f, -1.40993521e-01f, 1.12868987e-01f, -1.27508538e-02f, -1.12453066e-01f, -2.02214584e-01f, 3.35171700e-01f, 9.38297510e-02f, -2.02693358e-01f,
  -2.73841202e-01f, -2.66781718e-01f, 2.51233820e-02f, 1.96516305e-01f, -1.92075357e-01f, -6.19730465e-02f, 1.16940010e-02f, -2.51082256e-02f, -1.02611884e-01f, 9.97084081e-02f,
  7.58312345e-02f, -3.33676599e-02f, -4.74435627e-04f, -1.62534624e-01f, 1.88387915e-01f, 7.26087764e-02f, -1.28102601e-01f, 7.05765262e-02f, -2.12124437e-01f, 4.84670922e-02f,
  3.12510967e-01f, 1.97509602e-01f, -5.83018325e-02f, 1.18532721e-02f, 2.03258514e-01f, -1.41105935e-01f, -1.16125911e-01f, -4.85855006e-02f, 1.86050177e-01f, 4.76395071e-01f,
  1.06002472e-01f, -3.82752448e-01f, -1.07926048e-01f, -2.66132534e-01f, -1.44454390e-01f, -1.79192692e-01f, 1.42286763e-01f, 4.26740348e-02f, 6.55613020e-02f, -5.59460260e-02f,
  1.89420953e-01f, 6.56149685e-02f, -6.14870265e-02f, 1.57062694e-01f, -1.02296539e-01f, 1.17914580e-01f, -6.70049116e-02f, 1.27978683e-01f, 2.08121181e-01f, 5.42136580e-02f,
  1.87274199e-02f, 7.62436315e-02f, 1.85104057e-01f, 1.06605150e-01f, -1.37008533e-01f, 2.25174874e-02f, -5.86050609e-03f, -1.72927871e-01f, 4.98111844e-02f, 1.64625406e-01f,
  -2.04208866e-02f, 2.21619055e-01f, -1.24776363e-01f, -7.39738569e-02f, -2.13837549e-01f, 3.59769821e-01f, 1.54789090e-01f, 2.87902236e-01f, 1.28849223e-01f, 2.47733459e-01f,
  8.04342255e-02f, -1.08183540e-01f, 1.08202651e-01f, -6.66637719e-02f, 3.24003845e-01f, 4.59801145e-02f, -3.64395902e-02f, 2.63333529e-01f, -1.81165919e-01f, 2.58187711e-01f,
  1.69787690e-01f, 7.51454979e-02f, 1.54302537e-01f, 2.25792766e-01f, -4.50497940e-02f, -2.24606901e-01f, -1.63857132e-01f, 7.81006739e-02f, 1.06018901e-01f, -1.46275878e-01f,
  -1.05051212e-01f, 4.09362406e-01f, -1.02206983e-01f, 7.03426749e-02f, -1.20881461e-01f, 3.28109562e-01f, -1.32491753e-01f, 4.97273505e-02f, 1.91637784e-01f, -1.96744800e-01f,
  1.08964019e-01f, 3.09691653e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.38971657e-01f, 1.87854066e-01f, 1.57575369e-01f, 3.31824154e-01f, 8.89699906e-02f, 9.53221470e-02f, 2.93958306e-01f, -7.67468572e-01f, 3.87802720e-01f, -1.06049143e-01f,
  -5.05577624e-01f, -3.69916916e-01f, -2.02491537e-01f, -2.98865000e-03f, 4.41796333e-01f, 2.31547356e-02f, -2.68293824e-02f, 3.70462239e-01f, 1.93403274e-01f, -2.01602817e-01f,
  6.27152026e-02f, -1.35800689e-01f, -3.12491983e-01f, 3.97811234e-01f, 3.56519818e-01f, -3.51729482e-01f, 6.39611930e-02f, -1.83958545e-01f, -2.99249142e-01f, -1.62426665e-01f,
  5.74363112e-01f, 7.87362307e-02f, 1.94524258e-01f, 3.27624679e-01f, 1.96282163e-01f, 2.17964172e-01f, 2.62571394e-01f, 2.50868231e-01f, 1.07983097e-01f, 8.79508108e-02f,
  1.38492078e-01f, -3.64353687e-01f, 2.95808818e-02f, 1.17348179e-01f, 3.43982458e-01f, 8.81238654e-02f, -7.20194697e-01f, -6.28008842e-01f, 2.24689916e-01f, -3.21541697e-01f,
  -1.22303270e-01f, 3.90012026e-01f, 5.20262420e-01f, 3.19728702e-01f, 1.45450905e-01f, -2.71402895e-01f, -8.64326395e-03f, 9.08246636e-03f, 5.31272531e-01f, -1.06669419e-01f,
  -3.44623804e-01f, 5.88173270e-01f, -6.14818573e-01f, 2.65376627e-01f, 9.16485637e-02f, 1.23454973e-01f, 5.60739450e-02f, 1.60701111e-01f, 2.47102112e-01f, 2.01945558e-01f,
  1.80936858e-01f, -6.10100441e-02f, 5.89835867e-02f, -2.54964471e-01f, 6.18183203e-02f, 1.23672724e-01f, -1.84503943e-01f, 3.59407932e-01f, 3.30204427e-01f, 2.74367854e-02f,
  5.04387356e-02f, 1.78474367e-01f, 2.83519536e-01f, 5.37579618e-02f, -2.71762967e-01f, 2.21055210e-01f, 2.00116649e-01f, 1.71238512e-01f, -3.95818472e-01f, 3.75472724e-01f,
  5.03867686e-01f, -3.45494524e-02f, -3.45310837e-01f, -2.20272452e-01f, -7.85851032e-02f, 2.82324910e-01f, 5.48909843e-01f, -1.80619340e-02f, 2.27892369e-01f, 2.90224671e-01f,
  5.06736994e-01f, 2.65788466e-01f, 2.76785307e-02f, -1.83103964e-01f, 6.16742492e-01f, 7.57339373e-02f, -1.80742934e-01f, 3.46217364e-01f, 3.31876129e-01f, 2.09153175e-01f,
  -2.91229010e-01f, 5.38930818e-02f, 4.16854173e-01f, 3.25883150e-01f, 1.68553188e-01f, -1.56057149e-01f, -5.79981744e-01f, -6.73526302e-02f, -3.14849317e-01f, -3.51834834e-01f,
  -9.56771225e-02f, -7.57539347e-02f, 4.80233908e-01f, -1.08160106e-02f, -3.15610290e-01f, -4.71823588e-02f, 2.86237627e-01f, 6.03944361e-01f, 1.28353432e-01f, -5.80271184e-02f,
  1.60383001e-01f, 1.58851504e-01f, 4.12568629e-01f, 1.09263666e-01f, 1.01976506e-01f, 2.37495959e-01f, -4.61648516e-02f, 8.45582336e-02f, 1.87519968e-01f, 1.89279858e-02f,
  2.96362191e-01f, 2.18648419e-01f, -9.55506116e-02f, 3.65779549e-01f, 3.95030916e-01f, 2.03697369e-01f, 3.15449312e-02f, 9.18283127e-03f, 3.37156728e-02f, 2.52703071e-01f,
  6.51871637e-02f, -6.79572225e-02f, -4.58326750e-03f, 8.75125378e-02f, -6.16601482e-02f, -1.85346410e-01f, 3.47245187e-01f, 1.61752075e-01f, 4.99161333e-02f, -4.14616503e-02f,
  -6.74564391e-02f, 9.67686027e-02f, 1.75739795e-01f, 1.99118108e-01f, -5.09410910e-03f, 1.72456011e-01f, -3.61271389e-02f, -2.01195985e-01f, 5.81660792e-02f, -1.87002555e-01f,
  -2.18029946e-01f, -1.85167387e-01f, 1.24489345e-01f, 2.04265922e-01f, -2.96104878e-01f, -4.85506117e-01f, -2.17887629e-02f, 8.90867636e-02f, 3.63657087e-01f, 3.04961920e-01f,
  3.37488838e-02f, -4.36007649e-01f, 2.07880558e-03f, 1.59516737e-01f, 4.78486568e-01f, 4.52629596e-01f, 1.55432314e-01f, -5.85060716e-01f, -2.74595499e-01f, -9.02463078e-01f,
  5.46334684e-02f, -1.02489017e-01f, 3.14972520e-01f, 2.73088753e-01f, -3.55016664e-02f, 5.02630293e-01f, 1.98631823e-01f, 2.64984131e-01f, 1.29332498e-01f, -1.37319237e-01f,
  6.05409086e-01f, 2.16850385e-01f, -1.41114637e-01f, 1.65077761e-01f, 2.33177647e-01f, 3.92876238e-01f, 4.94378090e-01f, 2.08833277e-01f, -2.44341418e-01f, -3.80500443e-02f,
  1.80280581e-01f, -2.55456090e-01f, -3.94652635e-01f, -2.07334876e-01f, 1.70869648e-01f, 4.35760647e-01f, 4.40210029e-02f, 7.12978467e-02f, 2.74413526e-01f, 3.31853002e-01f,
  -3.86306852e-01f, -1.66566059e-01f, -1.24166004e-01f, 2.58657604e-01f, 2.84182411e-02f, 5.22108264e-02f, 3.69441897e-01f, 4.72350493e-02f, 5.41411899e-03f, 1.56048089e-01f,
  8.54298100e-02f, 3.37161459e-02f, 3.93099934e-02f, 2.03803152e-01f, 1.81832522e-01f, -1.08113632e-01f, -4.65038687e-01f, 3.96025956e-01f, 2.44139940e-01f, 3.12091559e-01f,
  -3.75358880e-01f, -1.43509999e-01f, 2.55743563e-01f, 1.97158933e-01f, -8.24813470e-02f, 9.36993659e-02f, 2.85853922e-01f, 2.61011481e-01f, -1.00391574e-01f, 3.87228757e-01f,
  1.32519037e-01f, -5.07262588e-01f, -4.15306389e-02f, -2.80490220e-01f, -1.07855357e-01f, 1.76095754e-01f, 1.18448203e-02f, 3.75346318e-02f, 1.37147367e-01f, -2.37740129e-02f,
  2.54794389e-01f, 1.08742723e-02f, -1.62981734e-01f, 1.81221381e-01f, -3.21980342e-02f, -1.08431138e-01f, -1.80920243e-01f, -1.06977724e-01f, -5.19669615e-02f, -2.55608205e-02f,
  6.76740110e-01f, 6.53597355e-01f, 1.87621936e-01f, 3.95859212e-01f, -2.01292604e-01f, -1.55350091e-02f, 1.08736664e-01f, 2.95166135e-01f, 4.93481494e-02f, -3.77219692e-02f,
  2.42345065e-01f, 7.16547295e-02f, -2.88585961e-01f, -9.35641304e-02f, 4.91094053e-01f, 8.39961395e-02f, 5.00356793e-01f, 4.42290679e-02f, 3.00190806e-01f, 1.92641169e-01f,
  5.06283529e-02f, 1.96850356e-02f, 2.52727479e-01f, 2.81566381e-01f, 8.68765116e-02f, 1.99674040e-01f, 3.98267090e-01f, 2.51641184e-01f, 1.63950205e-01f, -3.37728828e-01f,
  6.79402173e-01f, 3.90365720e-01f, 2.91774750e-01f, 4.10741568e-01f, 5.81814408e-01f, -1.61917731e-01f, -2.13486757e-02f, -1.98680609e-01f, -4.30430882e-02f, -7.58323744e-02f,
  4.38112989e-02f, 6.22745693e-01f, 2.21224986e-02f, 2.23609045e-01f, -3.09889942e-01f, -2.27193683e-01f, 2.37131894e-01f, 5.33504665e-01f, -3.41878563e-01f, -9.50165987e-02f,
  -1.66077629e-01f, 1.10923991e-01f, -7.94762745e-02f, -5.61012775e-02f, -2.86374390e-01f, 4.45094258e-02f, -2.88838744e-01f, -1.32616773e-01f, 1.16590299e-02f, 1.36395261e-01f,
  -1.76220294e-02f, 1.65554322e-02f, 3.23398590e-01f, -1.64758414e-01f, 2.96763271e-01f, 3.57981205e-01f, 2.97728270e-01f, -1.45222947e-01f, -1.37394667e-02f, 2.24259213e-01f,
  7.84566626e-02f, -1.49168417e-01f, 1.09396450e-01f, -4.83099103e-01f, -6.56995550e-02f, -1.08061142e-01f, -5.21606207e-01f, 2.32211247e-01f, 2.19275892e-01f, -1.33804500e-01f,
  -1.37763485e-01f, 2.63754517e-01f, 1.00019306e-01f, 3.00860256e-01f, 1.14562511e-01f, 3.57634127e-01f, -1.01231493e-01f, 2.15302661e-01f, -6.44529685e-02f, -9.88285169e-02f,
  2.78076619e-01f, -6.72590286e-02f, -1.03466153e-01f, -1.40732676e-01f, 5.98078609e-01f, -1.23593107e-01f, -1.73144609e-01f, -1.36037827e-01f, 3.33426863e-01f, -2.36686960e-01f,
  -2.32764050e-01f, 1.04247488e-01f, -1.51390666e-02f, -4.85972852e-01f, -2.95925140e-01f, -2.26377070e-01f, 5.09111941e-01f, -1.24012597e-01f, 4.52178150e-01f, 5.31437635e-01f,
  -1.09529547e-01f, 3.49546850e-01f, -1.02985874e-01f, 4.10721183e-01f, 1.31992787e-01f, 2.79662073e-01f, 4.82814550e-01f, 3.23011786e-01f, 2.25267887e-01f, 2.13132948e-01f,
  -5.49034923e-02f, -2.16992602e-01f, -2.66992420e-01f, -3.34476799e-01f, -9.36448947e-02f, -3.31091791e-01f, 6.71125427e-02f, -1.55651197e-01f, -5.01237273e-01f, -3.82002801e-01f,
  1.86971441e-01f, 4.80938077e-01f, 2.52051018e-02f, 7.04880357e-02f, 2.63663709e-01f, 7.72830173e-02f, -3.26038003e-01f, -2.35292614e-01f, 1.81494698e-01f, -9.41464677e-02f,
  2.43498564e-01f, 9.88359600e-02f, 1.60596609e-01f, 3.94015491e-01f, 4.41068053e-01f, -5.39793551e-01f, 3.42231750e-01f, 2.00721219e-01f, 1.46669745e-01f, -1.05288729e-01f,
  4.95112598e-01f, 9.44917500e-02f, -1.34616286e-01f, 2.70844758e-01f, 8.28366950e-02f, 1.71426013e-01f, 2.79112875e-01f, -2.69744128e-01f, 2.77339727e-01f, -8.22226629e-02f,
  -8.43035728e-02f, 3.52822214e-01f, 4.21226203e-01f, 2.66608372e-02f, -7.65533820e-02f, 1.98882565e-01f, 2.52993047e-01f, -9.54410583e-02f, -1.23516709e-01f, 1.40635058e-01f,
  3.71136725e-01f, 8.97017568e-02f, -3.49140197e-01f, -1.59488589e-01f, 5.40606856e-01f, 1.64470494e-01f, -1.85467694e-02f, -7.27764592e-02f, 2.34157145e-01f, 4.53416288e-01f,
  -1.98187511e-02f, 2.90438294e-01f, 3.17392081e-01f, 1.28149226e-01f, 2.70245541e-02f, 1.33306861e-01f, -8.87486860e-02f, -7.00838983e-01f, 2.47546598e-01f, 4.29141879e-01f,
  6.72096312e-02f, 3.72741401e-01f, -5.75635850e-01f, -1.20867193e-01f, 2.34705791e-01f, 1.30721658e-01f, 2.52922505e-01f, 5.56211472e-02f, -3.63379368e-04f, 5.20196557e-01f,
  -2.22855225e-01f, -2.36751303e-01f, -2.89505899e-01f, 3.35935861e-01f, 4.74201292e-01f, 2.11101070e-01f, 5.16632795e-02f, 8.10701787e-01f, 1.49957001e-01f, -2.47144729e-01f,
  3.23020965e-01f, 1.79625884e-01f, 5.15409335e-02f, 2.01780468e-01f, 2.37673387e-01f, 4.05761898e-02f, -1.68500751e-01f, 1.29884509e-02f, -2.51962878e-02f, -2.44624376e-01f,
  6.10840730e-02f, 3.89770985e-01f, -3.48484874e-01f, 2.31964305e-01f, -4.21207212e-03f, 3.05084586e-01f, -1.48825675e-01f, 4.18379724e-01f, 2.88340807e-01f, -2.12159470e-01f,
  -2.55819380e-01f, 3.40653330e-01f, -6.83484524e-02f, -3.21814895e-01f, 1.71523049e-01f, 3.25162977e-01f, 5.25160193e-01f, -1.13184437e-01f, 1.19227327e-01f, -1.77496783e-02f,
  4.60284561e-01f, 3.83590460e-01f, 4.50688779e-01f, 1.42857373e-01f, 2.41676256e-01f, 2.17130482e-02f, 6.46090031e-01f, 3.14756274e-01f, -2.51542509e-01f, 4.44382817e-01f,
  3.95953327e-01f, 5.40267467e-01f, -1.45087224e-02f, 6.95616985e-03f, 5.87188363e-01f, 1.06634371e-01f, 3.76345545e-01f, 2.87478924e-01f, -1.98246259e-02f, 1.57538533e-01f,
  -1.94688752e-01f, 2.21767928e-03f, -2.38855109e-01f, 2.31015429e-01f, -4.17633653e-01f, -5.10787740e-02f, -7.14238733e-02f, 2.06816047e-01f, 2.36042634e-01f, 2.73946494e-01f,
  8.15163478e-02f, -3.41399983e-02f, -3.89776677e-02f, 4.80857641e-01f, 1.08978853e-01f, 1.71037003e-01f, 9.39492285e-02f, 2.15258956e-01f, -5.41092455e-02f, 1.49624690e-01f,
  -1.95518762e-01f, 1.05139419e-01f, -4.53626849e-02f, 3.98577228e-02f, 1.37566760e-01f, 2.26410627e-01f, 7.14293838e-01f, -2.76310533e-01f, -6.03371160e-03f, -3.72516900e-01f,
  2.82106280e-01f, -4.67854887e-01f, -4.81658489e-01f, -1.02445357e-01f, 1.82038024e-01f, -3.62439245e-01f, 5.95381483e-02f, -4.17336255e-01f, 1.17093697e-01f, -9.12732407e-02f,
  9.52158347e-02f, 5.64350367e-01f, 1.53180677e-03f, 2.11739779e-01f, -6.12195551e-01f, 2.70958662e-01f, 5.37912995e-02f, 1.79352179e-01f, 3.06986570e-01f, 3.23106736e-01f,
  2.57579625e-01f, 1.14242420e-01f, -2.07162499e-01f, 1.82095259e-01f, -1.66263998e-01f, 1.03171572e-01f, 1.64505780e-01f, 2.61125237e-01f, -2.45383874e-01f, 4.25535114e-03f,
  7.95288384e-02f, 1.19884722e-01f, -4.57535923e-01f, 3.21236342e-01f, 1.92528576e-01f, 4.08471286e-01f, 1.40870530e-02f, 5.99016726e-01f, -1.18306912e-02f, -1.89805046e-01f,
  -1.27263203e-01f, 3.31492007e-01f, 5.24713516e-01f, 4.98841971e-01f, 9.02743936e-02f, -1.17390834e-01f, 3.48079801e-01f, 5.89095503e-02f, 2.23818973e-01f, 3.36804420e-01f,
  9.39388126e-02f, 4.43258226e-01f, 3.69779617e-01f, 4.33817625e-01f, -5.97335659e-02f, -2.94309556e-01f, 3.02759051e-01f, -1.30391359e-01f, -5.46323806e-02f, 7.92211816e-02f,
  -8.15649927e-02f, 6.06860161e-01f, 5.15661180e-01f, 3.34683210e-01f, -9.96626681e-04f, 1.79156974e-01f, 4.22466516e-01f, 5.16844057e-02f, -8.61538947e-02f, 2.08218157e-01f,
  -3.63208681e-01f, 8.43994543e-02f, 6.54956251e-02f, 5.19049494e-03f, 6.53858662e-01f, -1.68913260e-01f, -5.16266935e-02f, -3.35224601e-03f, 1.45569921e-01f, 1.83557183e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.31877977e-01f, 1.26223937e-01f, 2.58540511e-01f, 3.58909637e-01f, 1.15688425e-02f, 5.15018582e-01f, 3.89792591e-01f, 3.67420286e-01f, 1.01430379e-01f, 2.13340193e-01f,
  -1.26312718e-01f, 6.28492177e-01f, 4.87972140e-01f, 1.21614359e-01f, 1.54753432e-01f, 7.01842532e-02f, -3.75648998e-02f, 3.85757238e-01f, 2.47614756e-01f, 4.44968820e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.96334600e-01f, 2.62429882e-02f, 2.46834114e-01f, 3.85122538e-01f, 3.59823555e-02f, -1.93629339e-01f, 1.03255622e-01f, -8.49293694e-02f, -1.03424430e-01f, -3.51533234e-01f,
  -8.11566263e-02f, -7.65813515e-02f, -2.32074276e-01f, 2.24665970e-01f, -1.70822859e-01f, 4.86208834e-02f, 2.64062006e-02f, -3.40390299e-03f, -2.66067177e-01f, 2.34998390e-02f,
  -4.43244213e-03f, 1.28801137e-01f, 1.63128823e-01f, 9.95560065e-02f, 2.53221631e-01f, 7.73298964e-02f, 2.60142922e-01f, -9.44163427e-02f, -8.85921158e-03f, 1.06960714e-01f,
  -7.90776610e-02f, 6.15463741e-02f, 7.14340881e-02f, 9.85533968e-02f, -2.56884813e-01f, -1.46964684e-01f, -4.08819169e-01f, -2.48076677e-01f, 5.65882847e-02f, 4.09186959e-01f,
  4.96284217e-01f, -3.25182021e-01f, 5.39300382e-01f, 2.56238461e-01f, -1.48827434e-01f, 2.74357945e-02f, 1.20246083e-01f, -6.61978200e-02f, 2.77179480e-01f, -1.26968756e-01f,
  -1.44388393e-01f, -1.12654522e-01f, -5.55447489e-02f, 1.97929934e-01f, 1.85021818e-01f, -3.34826082e-01f, -1.98421806e-01f, 1.57324716e-01f, 1.32131830e-01f, -1.40644491e-01f,
  1.64818838e-01f, 1.13227479e-01f, -1.03539579e-01f, -1.54956877e-01f, -1.84164569e-01f, -1.72896296e-01f, -9.35543403e-02f, -9.25255045e-02f, -9.56670716e-02f, 3.17492515e-01f,
  2.34129906e-01f, 1.66263208e-01f, -4.81117904e-01f, 1.51862919e-01f, 1.67656168e-01f, -1.53730482e-01f, 1.71102881e-01f, 5.45617752e-02f, 1.31527260e-01f, -1.33207560e-01f,
  -1.00713737e-01f, 1.97508648e-01f, 8.88425261e-02f, 2.86414742e-01f, -2.18378454e-01f, -4.58965212e-01f, 1.69070840e-01f, 4.21893001e-02f, -3.07258397e-01f, -7.98452646e-02f,
  -9.17738900e-02f, 2.05637485e-01f, -1.36451036e-01f, 1.22301906e-01f, 5.42151034e-02f, -1.74794570e-01f, -1.10264383e-01f, 1.45915344e-01f, -1.39583066e-01f, -2.17560276e-01f,
  7.76017159e-02f, 5.48646264e-02f, 4.16536927e-02f, 1.96237415e-01f, -3.46766859e-01f, 4.85474735e-01f, -1.07776441e-01f, -1.31037861e-01f, 1.76950291e-01f, -3.43391784e-02f,
  6.42403811e-02f, 2.03291014e-01f, -1.85992807e-01f, 1.34158626e-01f, 2.20296517e-01f, 2.61351794e-01f, -1.32136151e-01f, -7.80612901e-02f, -1.61194667e-01f, 2.34843224e-01f,
  -1.03211835e-01f, -1.63676322e-01f, -8.49092826e-02f, 7.50811473e-02f, -5.55346310e-02f, -2.27999032e-01f, -1.11537561e-01f, -9.81612429e-02f, 3.05627882e-01f, 3.70850116e-01f,
  2.75240242e-01f, 2.55422354e-01f, 1.24035969e-01f, -2.15393767e-01f, -1.14955753e-01f, 3.32309484e-01f, 2.82690525e-01f, 2.80201912e-01f, 9.92743969e-02f, 1.36396121e-02f,
  1.11051746e-01f, -1.78488925e-01f, 9.72878188e-02f, 3.00014466e-01f, 9.64794680e-02f, -2.70198047e-01f, -4.07543182e-02f, -1.24377996e-01f, 2.01103747e-01f, 4.09967750e-02f,
  4.91607115e-02f, 4.78640497e-02f, 3.99937667e-02f, 8.78021717e-02f, 2.75140822e-01f, -1.07156090e-01f, 3.58437002e-02f, -1.64089009e-01f, -7.28543848e-02f, 9.85211954e-02f,
  -1.22439861e-01f, 7.85577223e-02f, -2.00525954e-01f, -2.97076136e-01f, 2.71546364e-01f, -3.41370031e-02f, 2.55890548e-01f, 9.06679183e-02f, 2.47182418e-02f, 3.94059867e-01f,
  -1.62205622e-01f, -4.97325867e-01f, 2.42303729e-01f, -9.76415575e-02f, -2.91097045e-01f, -1.50931001e-01f, -1.40122458e-01f, 6.82052523e-02f, -3.64779867e-02f, -1.72713041e-01f,
  -7.14098960e-02f, 8.81791636e-02f, -1.77006125e-01f, 1.84289113e-01f, 2.20665172e-01f, 1.11090735e-01f, 1.05333544e-01f, 1.64319530e-01f, -2.31663108e-01f, -1.25025650e-02f,
  -1.93302035e-01f, 9.77021754e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  4.49281842e-01f, -2.52107918e-01f, 5.71847618e-01f, 1.31148770e-01f, 1.43092126e-01f, -1.22010238e-01f, -1.67045578e-01f, -2.59413928e-01f, 7.29626358e-01f, -4.78340924e-01f,
  -6.70363665e-01f, -6.52670041e-02f, -5.31221032e-01f, 2.98174679e-01f, 1.65919051e-01f, 1.84751704e-01f, 1.59259424e-01f, 1.91139117e-01f, -9.96211916e-02f, 2.03431353e-01f,
  -2.12836340e-01f, 2.36489996e-01f, 1.48823127e-01f, 4.43001628e-01f, -1.00532629e-01f, 1.66273549e-01f, 2.80624926e-01f, -7.30367303e-02f, 1.68324769e-01f, -2.64947359e-02f,
  -4.11317870e-02f, -3.70193017e-03f, -2.15562582e-01f, -2.97842652e-01f, 1.01652756e-01f, 4.53918338e-01f, -1.11989670e-01f, 2.46917307e-01f, -2.30185822e-01f, -1.62063792e-01f,
  -7.50596046e-01f, 1.28596529e-01f, -2.90817171e-01f, 3.53384286e-01f, 6.23949230e-01f, 1.01434685e-01f, 1.04609676e-01f, 1.54525535e-02f, -5.32786027e-02f, 4.01275724e-01f,
  -1.29273698e-01f, 9.62638035e-02f, 1.28928483e-01f, -3.92291635e-01f, 6.41049221e-02f, 6.20759949e-02f, 4.83776391e-01f, -7.46537596e-02f, 4.55202833e-02f, -5.28527834e-02f,
  -1.84588820e-01f, -3.66455764e-01f, 2.39171535e-01f, 3.32331955e-01f, 3.41271847e-01f, 2.48067990e-01f, -7.50801489e-02f, 3.31776254e-02f, -5.18126376e-02f, -5.09897172e-01f,
  -6.34849221e-02f, -1.04120962e-01f, 4.59733307e-01f, -3.73393774e-01f, 2.91265160e-01f, -1.61873192e-01f, -4.12782639e-01f, 2.19547689e-01f, -1.00953601e-01f, 4.00450602e-02f,
  2.85413444e-01f, -8.19838494e-02f, -6.71126008e-01f, -1.81478728e-02f, 2.96302795e-01f, 2.34680638e-01f, -8.28072056e-02f, -1.50744587e-01f, 3.08945507e-01f, 4.84953165e-01f,
  3.32876265e-01f, 2.03507349e-01f, 3.51960123e-01f, 1.50328735e-02f, 4.01605129e-01f, -2.79969256e-02f, -1.63788244e-01f, 1.64502561e-01f, 2.30739847e-01f, -1.07869461e-01f,
  -3.18414830e-02f, 4.78314549e-01f, 6.47186562e-02f, -3.79078567e-01f, 5.85677586e-02f, 6.84181079e-02f, -3.64865571e-01f, 2.49530151e-01f, 3.65054280e-01f, -4.11835283e-01f,
  -9.93952677e-02f, -7.14055449e-02f, 2.44381294e-01f, 2.96386868e-01f, -2.56178468e-01f, -1.43469870e-02f, 3.52178007e-01f, 2.54884273e-01f, 2.82129169e-01f, 1.01911806e-01f,
  1.67563558e-01f, 3.77893776e-01f, -3.83840621e-01f, 1.03891946e-01f, -6.16154373e-02f, -1.61057249e-01f, -2.45601088e-01f, 2.53031671e-01f, -3.34713578e-01f, 1.23542503e-01f,
  -1.20064288e-01f, 1.79475442e-01f, -3.26706767e-01f, 6.89484000e-01f, -5.88958681e-01f, 5.14044881e-01f, 3.35508622e-02f, -7.12758303e-01f, 2.49077812e-01f, 8.19177646e-03f,
  -6.18177652e-01f, -9.84059051e-02f, -7.35856444e-02f, 2.58118808e-02f, -1.69048503e-01f, -2.16579020e-01f, 6.38694882e-01f, -5.88081405e-02f, -1.24729797e-01f, -6.09147809e-02f,
  4.15461391e-01f, 4.62378234e-01f, -1.30355060e-01f, -1.53503060e-01f, -3.68347913e-01f, -4.63420421e-01f, 4.85014677e-01f, 4.72241849e-01f, -1.84606705e-02f, -7.88499534e-01f,
  -4.38311309e-01f, -6.50524735e-01f, -1.82165757e-01f, 1.71844453e-01f, -6.86990499e-01f, 3.58285069e-01f, -2.45757475e-01f, 2.56279737e-01f, -4.29837525e-01f, 5.86526215e-01f,
  -9.11157131e-02f, 2.50321895e-01f, 2.51601338e-01f, 3.99244696e-01f, 4.46267933e-01f, -3.33605707e-02f, -2.01039806e-01f, 2.39007071e-01f, 2.29586691e-01f, 1.67678282e-01f,
  1.23719700e-01f, -6.35792732e-01f, 1.31819338e-01f, -7.11604580e-02f, 2.20859032e-02f, -1.59493938e-01f, -1.18598290e-01f, 1.65637791e-01f, -1.74261481e-01f, -3.08120567e-02f,
  3.69688243e-01f, 2.25622617e-02f, 4.26179737e-01f, -1.74824357e-01f, -1.20606937e-01f, 9.87093002e-02f, -1.11775640e-02f, -2.25165173e-01f, 4.15741533e-01f, 1.78981572e-01f,
  7.99218416e-02f, -6.05683327e-01f, 3.48903164e-02f, -4.77316082e-01f, -3.40408087e-01f, 1.94579929e-01f, 1.55204847e-01f, -9.78134200e-02f, -1.53328776e-02f, 8.73638391e-02f,
  -2.11150065e-01f, 2.71840155e-01f, -2.29269877e-01f, -5.96379451e-02f, -5.98649047e-02f, -1.08180761e-01f, 5.11185169e-01f, -1.41733633e-02f, 4.98972595e-01f, 2.24480391e-01f,
  -1.18594110e-01f, -1.07158549e-01f, 4.37888920e-01f, 4.38742191e-02f, -3.19128394e-01f, -3.09289664e-01f, -6.37314562e-03f, -2.54381984e-01f, -1.60597846e-01f, -1.62597314e-01f,
  1.10880323e-01f, 3.79337296e-02f, -5.40131330e-01f, 2.18967155e-01f, 9.95778143e-02f, 6.63824022e-01f, -8.05442333e-02f, 2.36639455e-01f, 2.08195016e-01f, 1.66983068e-01f,
  7.87186846e-02f, -1.09278731e-01f, 4.60455716e-01f, 1.42935798e-01f, 1.74177289e-01f, 2.79591855e-04f, 1.53841630e-01f, -1.10966899e-01f, -9.92065147e-02f, -8.76388624e-02f,
  2.65686452e-01f, 3.32473487e-01f, 2.99118817e-01f, -1.22404188e-01f, 1.62217662e-01f, 2.92772025e-01f, 1.41019717e-01f, 4.00458187e-01f, 2.37866625e-01f, -8.32015574e-02f,
  6.91304028e-01f, 3.52985829e-01f, 4.32648450e-01f, -3.72174382e-01f, 1.05387293e-01f, 6.73787236e-01f, 1.80149421e-01f, -5.07865965e-01f, 1.85286358e-01f, -2.71330446e-01f,
  1.30034491e-01f, -1.23812988e-01f, -1.95983186e-01f, 1.80059448e-01f, 4.87221390e-01f, 4.35589135e-01f, -1.94244683e-01f, 4.50595140e-01f, -3.22439700e-01f, -3.90487820e-01f,
  -1.07236713e-01f, 1.28059670e-01f, -1.34640440e-01f, 1.13723733e-01f, -4.80868399e-01f, -4.15407002e-01f, 1.21805534e-01f, 4.07563418e-01f, 1.48797080e-01f, 3.68460953e-01f,
  5.48296034e-01f, 6.02000296e-01f, -3.93706411e-02f, -1.99124277e-01f, -4.41153854e-01f, 1.07400882e+00f, -1.22459680e-01f, 9.69334692e-02f, 1.96984947e-01f, 3.22235554e-01f,
  1.22124672e-01f, -1.09675236e-01f, 1.25588924e-01f, 6.46433830e-01f, 1.51285052e-01f, -8.14524963e-02f, 1.92015871e-01f, -2.70766944e-01f, -3.00204876e-04f, -5.15161872e-01f,
  -2.74837554e-01f, 2.47953564e-01f, 3.52733642e-01f, 1.99285913e-02f, 2.35524565e-01f, 4.98447686e-01f, 4.66007948e-01f, 3.43978181e-02f, 4.92106110e-01f, 1.59105599e-01f,
  3.91776830e-01f, 7.29762495e-01f, 8.30062926e-01f, 5.63829362e-01f, 6.03815496e-01f, 2.97966510e-01f, -3.06438357e-01f, 2.89907962e-01f, 2.15072870e-01f, 5.12724221e-01f,
  -5.02947628e-01f, -4.67661679e-01f, 3.89436692e-01f, 4.98729050e-02f, -1.76436499e-01f, 5.60144663e-01f, -2.29703069e-01f, 3.16653013e-01f, 2.26644695e-01f, -3.04477699e-02f,
  -1.98174998e-01f, -5.51158376e-03f, -1.89612880e-01f, 4.92385298e-01f, 4.90462065e-01f, 2.70248264e-01f, -5.25254488e-01f, 1.12930633e-01f, 2.84244474e-02f, -3.58416280e-03f,
  -2.39282683e-01f, -7.26903453e-02f, 2.17503048e-02f, 1.10578522e-01f, 1.07344486e-01f, -2.72552133e-01f, 7.09876478e-01f, -9.83758122e-02f, 5.92051268e-01f, -2.01035246e-01f,
  1.80009231e-01f, 7.94093788e-01f, 3.04772496e-01f, -6.14059865e-02f, 3.79063100e-01f, 2.98038423e-01f, 2.59491861e-01f, 1.93972483e-01f, 1.05330303e-01f, 1.14857353e-01f,
  6.79876268e-01f, 4.56909209e-01f, -1.21404842e-01f, 4.90382195e-01f, -2.12838233e-01f, -1.52244195e-01f, -4.04145032e-01f, -2.36070435e-02f, 9.33314674e-03f, 6.34638965e-02f,
  1.01174891e-01f, 1.28652424e-01f, -1.91831917e-01f, 5.20957470e-01f, -1.12726809e-02f, 3.36699545e-01f, 3.04213673e-01f, 4.54310745e-01f, -3.48980069e-01f, -1.05779529e-01f,
  -6.25116885e-01f, 1.69376522e-01f, 3.36359352e-01f, -5.15231311e-01f, 1.35523006e-01f, -1.59837857e-01f, -5.17592907e-01f, 1.05708778e-01f, -7.39208460e-02f, 1.72223508e-01f,
  1.38322785e-01f, 2.33391926e-01f, -9.39294137e-03f, -4.87762801e-02f, -1.99905351e-01f, 3.34776759e-01f, 1.16522975e-01f, 7.47684002e-01f, 1.58772886e-01f, 3.21735680e-01f,
  2.16776803e-01f, -1.90084770e-01f, 2.07693204e-01f, 4.14804935e-01f, 2.17323881e-02f, -2.33023405e-01f, 1.55374780e-01f, 4.08035338e-01f, 4.14299190e-01f, 4.88433652e-02f,
  8.26497674e-01f, -1.76716059e-01f, 6.08736396e-01f, -4.29427475e-01f, 5.30265987e-01f, 2.87024349e-01f, -7.17781624e-03f, -6.53595507e-01f, 4.72737223e-01f, 1.17543995e-01f,
  1.78383186e-01f, -1.34803027e-01f, -5.95662966e-02f, -2.28579164e-01f, 2.80771941e-01f, 3.43662687e-03f, -3.87992114e-01f, 3.73597622e-01f, -2.01139882e-01f, 3.90217543e-01f,
  4.50675845e-01f, -5.53576685e-02f, 1.52226359e-01f, -2.07421526e-01f, -2.21741542e-01f, 1.06057681e-01f, -4.33208972e-01f, 2.68184602e-01f, 2.23483890e-01f, 3.75075370e-01f,
  9.38214734e-02f, 1.58987910e-01f, 2.20294967e-01f, 1.84780568e-01f, -5.74625671e-01f, 3.58220667e-01f, -4.07934994e-01f, 1.15906924e-01f, -4.27208357e-02f, 3.46865237e-01f,
  1.19779706e-01f, -2.37392262e-01f, 5.38051501e-02f, 5.28307319e-01f, 3.34357351e-01f, -1.58189684e-01f, -1.10606551e-01f, -9.07101110e-02f, 4.33916807e-01f, 7.97659531e-02f,
  -7.47260451e-02f, -6.41051158e-02f, 3.17179292e-01f, 2.22515568e-01f, -7.99383298e-02f, 4.22136277e-01f, 5.27602375e-01f, -1.69985071e-01f, 2.38841012e-01f, 1.99178278e-01f,
  2.55287081e-01f, 1.70657083e-01f, 2.92574223e-02f, 1.85882956e-01f, -2.59518892e-01f, -4.03265744e-01f, -1.61146998e-01f, -4.83538002e-01f, 3.24386120e-01f, -1.86550751e-01f,
  3.64354737e-02f, 8.02780315e-02f, -2.26352006e-01f, 1.67456552e-01f, -1.72998413e-01f, 2.02466324e-01f, 1.80208027e-01f, 1.13658965e-01f, -4.43658054e-01f, -2.82227576e-01f,
  4.95814085e-01f, 3.62231791e-01f, -1.80321019e-02f, -1.43805549e-01f, 5.20117939e-01f, 5.02974033e-01f, 2.22582281e-01f, 1.49308413e-01f, 4.10422176e-01f, 4.81196120e-03f,
  1.64470643e-01f, 2.59989463e-02f, 2.77234137e-01f, 3.39655489e-01f, 3.54093760e-01f, 1.69751406e-01f, 2.98317432e-01f, 4.94837612e-01f, -1.49326935e-01f, 7.20728874e-01f,
  -2.63038546e-01f, -1.47437394e-01f, -3.20864357e-02f, -5.87683618e-01f, 4.58053529e-01f, 2.04653349e-02f, 1.59647107e-01f, 2.40524158e-01f, -1.66149497e-01f, 1.56995077e-02f,
  1.90705642e-01f, -3.29957366e-01f, -1.90086395e-01f, -3.95746201e-01f, -1.55264616e-01f, 4.80565727e-01f, 6.53311491e-01f, -3.79690707e-01f, 5.47455966e-01f, 4.26780641e-01f,
  -1.83396518e-01f, 3.93749088e-01f, 2.24801317e-01f, 3.10683757e-01f, -3.07719469e-01f, -1.42822757e-01f, 1.95768639e-01f, 1.73259839e-01f, -4.99403030e-02f, 3.97881716e-01f,
  -2.27479443e-01f, -4.30875838e-01f, 3.85364413e-01f, 3.36856216e-01f, -5.33527732e-02f, 7.83160627e-01f, 1.39885589e-01f, -2.08449975e-01f, 2.65678823e-01f, 4.07045297e-02f,
  1.69544071e-01f, 1.76946700e-01f, 6.76075816e-01f, -4.85307090e-02f, 2.16083854e-01f, 7.24730670e-01f, 1.75888687e-01f, 2.06604481e-01f, -4.51215714e-01f, 1.87650785e-01f,
  -4.40707713e-01f, -2.09359705e-01f, 4.66800809e-01f, 1.27656981e-01f, -2.44633675e-01f, 1.28936753e-01f, -1.45269647e-01f, -2.09556639e-01f, 1.01616226e-01f, -1.38828576e-01f,
  1.98665932e-01f, -1.68093890e-01f, 4.60810244e-01f, -1.87870368e-01f, -5.13177276e-01f, 9.95839015e-02f, -1.18748136e-01f, 5.14587620e-03f, -2.02010348e-01f, -2.49372348e-01f,
  2.02378988e-01f, 5.47138266e-02f, 2.33590543e-01f, 7.62347654e-02f, -1.88250512e-01f, 1.10789098e-01f, 3.44496407e-02f, 1.51466191e-01f, 9.51872244e-02f, -1.92050800e-01f,
  -2.64551908e-01f, 4.45078202e-02f, 5.27978361e-01f, 5.34972310e-01f, 1.08322874e-01f, -4.11605924e-01f, 2.99491644e-01f, 4.86034453e-01f, 7.88019001e-02f, 1.47259355e-01f,
  6.34810507e-01f, 5.85534930e-01f, 3.85573655e-01f, 4.21912968e-02f, -2.21779332e-01f, -5.21660030e-01f, -2.20170721e-01f, 1.66877702e-01f, -4.78596658e-01f, 5.30558303e-02f,
  3.11145008e-01f, 7.81119335e-03f, 3.57232541e-01f, 7.94403479e-02f, -5.22282608e-02f, 2.93442279e-01f, 1.36442795e-01f, 3.08254451e-01f, -2.55121291e-01f, -8.70763436e-02f,
  -1.39910132e-01f, -1.58076614e-01f, 2.94762433e-01f, 1.04976028e-01f, 7.33972266e-02f, 6.95999563e-02f, -2.26431847e-01f, -2.98267573e-01f, 3.73132765e-01f, -9.82436538e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.06823854e-01f, 2.73422860e-02f, -3.44328731e-02f, 1.70349568e-01f, 3.96324277e-01f, 1.50452524e-01f, -1.35314822e-01f, -6.27218634e-02f, 2.68993646e-01f, 6.82762265e-02f,
  2.22764954e-01f, 2.50993639e-01f, 2.72923291e-01f, 3.66760582e-01f, 2.50267178e-01f, 1.46751761e-01f, 1.84742481e-01f, 3.74944478e-01f, 3.71324793e-02f, 1.75738961e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.77837431e-02f, 1.49836689e-01f, -3.09347540e-01f, -3.51136178e-01f, 6.94073886e-02f, -1.74424663e-01f, 1.61315054e-01f, -2.34023616e-01f, -1.19522668e-01f, 3.10064197e-01f,
  -1.57492131e-01f, 3.81312281e-01f, 1.15445353e-01f, -2.02906668e-01f, 1.23098671e-01f, 3.67917687e-01f, -3.97680372e-01f, -7.47514367e-01f, -3.97570252e-01f, 1.77168489e-01f,
  -1.51598260e-01f, 5.17642610e-02f, -2.37612665e-01f, -2.70938575e-01f, -6.92262128e-02f, -7.14067340e-01f, 9.57862958e-02f, 2.26618960e-01f, -4.35782611e-01f, 1.58482417e-01f,
  3.11093420e-01f, -6.66771770e-01f, -3.92574906e-01f, 7.74292499e-02f, -1.76300079e-01f, -1.88912839e-01f, -2.59933829e-01f, 1.02820203e-01f, 3.72266889e-01f, -3.07161450e-01f,
  2.17834994e-01f, -1.59075171e-01f, -2.69345760e-01f, -3.08082402e-01f, 1.98735252e-01f, -4.22301143e-03f, 7.48043656e-02f, 1.47803426e-01f, 2.88397342e-01f, 1.33289039e-01f,
  -5.33300862e-02f, -3.66197526e-01f, -4.67791222e-02f, -3.03228468e-01f, 1.79791301e-01f, -1.69891417e-01f, 3.10229629e-01f, -4.91634011e-01f, -1.69011801e-02f, 2.01305345e-01f,
  -8.47557902e-01f, 3.89915287e-01f, -5.18344998e-01f, 3.12766582e-01f, 2.79456347e-01f, 3.30144912e-01f, 4.56451625e-02f, 2.05364183e-01f, 7.97667429e-02f, 3.77766907e-01f,
  -2.14707792e-01f, 3.08185130e-01f, -2.82905519e-01f, 3.05627733e-01f, 1.25735164e-01f, -3.70413452e-01f, -3.08990091e-01f, -5.56055307e-01f, 1.83935699e-05f, -4.19670418e-02f,
  -4.90862221e-01f, -4.79341626e-01f, -8.54600012e-01f, 8.32944512e-02f, 3.72532964e-01f, -4.35545802e-01f, -9.07648802e-01f, 3.55834961e-01f, -1.31353647e-01f, 2.07554311e-01f,
  5.39496280e-02f, 6.37559071e-02f, -9.38436627e-01f, 3.90426278e-01f, 2.39421986e-02f, -1.89479202e-01f, 1.70945808e-01f, -3.15497220e-01f, -2.77657896e-01f, -2.33160362e-01f,
  -3.75094086e-01f, -1.39338702e-01f, 2.88971245e-01f, 2.09480837e-01f, -1.49780914e-01f, -3.07734281e-01f, 1.85597584e-01f, -4.65776175e-01f, -4.21255499e-01f, -2.11319271e-02f,
  3.81465584e-01f, -3.87201518e-01f, -3.71908814e-01f, -1.76561996e-01f, 4.12786543e-01f, -2.03333627e-02f, -3.59578639e-01f, 2.56132394e-01f, -6.89030945e-01f, -4.15942520e-01f,
  -9.43712071e-02f, -1.91379428e-01f, 1.04165763e-01f, 3.11422259e-01f, 1.69426166e-02f, -7.45801210e-01f, 2.01428402e-02f, 4.40435717e-03f, -1.65073067e-01f, 2.41828665e-01f,
  -1.61709353e-01f, 2.35507727e-01f, -2.57239133e-01f, -2.18688399e-01f, -5.36560535e-01f, 4.50826466e-01f, -3.53065044e-01f, -6.77372282e-03f, 3.46539140e-01f, 2.92405128e-01f,
  -3.37630391e-01f, 3.12577665e-01f, -9.67701972e-02f, -1.22507431e-01f, -4.11134660e-01f, 4.66162056e-01f, -3.31175566e-01f, 3.60849798e-01f, -7.87219346e-01f, 1.94223925e-01f,
  -3.90896380e-01f, 1.19642265e-01f, -3.81899714e-01f, -4.41683978e-01f, 3.30725759e-02f, -5.75861819e-02f, -1.01436660e-01f, 1.56825721e-01f, 1.01596182e-02f, -1.11579530e-01f,
  -2.29817983e-02f, -4.15094614e-01f, 3.56641531e-01f, 4.48794067e-01f, -2.01691568e-01f, -9.48673412e-02f, 4.41334456e-01f, 1.98867321e-01f, -3.64294261e-01f, -2.80290395e-01f,
  3.91584605e-01f, 2.25201190e-01f, 2.95114249e-01f, -5.63085496e-01f, -1.82782456e-01f, -5.89616239e-01f, -1.29095493e-02f, -2.09268183e-01f, -1.73563763e-01f, 1.63389355e-01f,
  -4.87754196e-01f, 3.07324737e-01f, 3.67981911e-01f, 1.47027448e-01f, 1.94557637e-01f, 1.07569598e-01f, -1.48905426e-01f, -2.04153091e-01f, 3.09389949e-01f, 1.32345721e-01f,
  -2.69482583e-01f, -1.47264749e-01f, 1.85425192e-01f, -3.57597582e-02f, 5.01361154e-02f, -1.57307163e-02f, 3.10283691e-01f, -2.83457935e-01f, -1.21428862e-01f, -1.73608765e-01f,
  5.43103516e-01f, 3.01050514e-01f, -3.21254015e-01f, -5.89381345e-02f, -6.22429773e-02f, -7.07791150e-02f, -1.60268664e-01f, 2.39171326e-01f, 1.07651189e-01f, -9.87295732e-02f,
  -1.86165303e-01f, -2.67628700e-01f, 3.50528628e-01f, -9.64943707e-01f, 3.11055958e-01f, 3.04372132e-01f, -5.42614639e-01f, 5.03326058e-01f, -7.68430293e-01f, -7.06195951e-01f,
  -7.16711581e-02f, 2.41061836e-01f, -3.50430399e-01f, 2.26382613e-01f, -4.72651124e-02f, -2.01061055e-01f, -3.24431151e-01f, -1.56631410e-01f, -2.06584781e-01f, 5.39985634e-02f,
  -3.50921266e-02f, -2.16855526e-01f, 2.47213379e-01f, 2.79748410e-01f, -4.20569390e-01f, -2.83636749e-01f, 1.36537656e-01f, 2.29016200e-01f, -2.22767353e-01f, -2.88441211e-01f,
  -1.89775586e-01f, 3.15807194e-01f, 3.84979278e-01f, 8.45258236e-02f, 8.30912888e-02f, -6.70846403e-02f, -6.05595946e-01f, -6.40080646e-02f, -2.43367508e-01f, -5.42209506e-01f,
  -2.89791912e-01f, -4.41180974e-01f, 2.09648624e-01f, -7.21209168e-01f, 3.46566409e-01f, 2.67073214e-01f, -1.09208949e-01f, -3.69181670e-02f, -1.79265991e-01f, -3.39206219e-01f,
  2.36426219e-01f, 1.77099943e-01f, -4.16179597e-01f, 4.25184250e-01f, -1.70392111e-01f, -2.11319476e-01f, 4.52259108e-02f, 6.14994466e-01f, 2.25661919e-01f, -2.54537523e-01f,
  3.19903493e-01f, -2.49411002e-01f, 1.55937094e-02f, 2.32534837e-02f, 4.92227256e-01f, -2.39651904e-01f, -4.95836996e-02f, -7.30722964e-01f, -2.34496191e-01f, 8.03684629e-03f,
  1.83302373e-01f, 6.09247208e-01f, -6.89816117e-01f, 2.41213605e-01f, 1.93680078e-01f, -5.83675981e-01f, -6.09308444e-02f, -1.42233491e-01f, 1.81412816e-01f, -2.61348009e-01f,
  8.02577063e-02f, -4.00566198e-02f, 4.82143424e-02f, 3.39921057e-01f, -7.37608254e-01f, -4.06114817e-01f, 4.73694175e-01f, 2.91380435e-01f, 1.93180546e-01f, 5.06311178e-01f,
  -2.82302737e-01f, -1.52478874e-01f, -7.19924927e-01f, 2.53387000e-02f, -4.21991616e-01f, -1.33374361e-02f, 1.63109135e-02f, -8.07559192e-02f, 2.98547775e-01f, 1.19019270e-01f,
  9.45446342e-02f, 2.27951571e-01f, -4.20038223e-01f, -1.48012578e-01f, 2.98627943e-01f, -6.26103938e-01f, 1.57240435e-01f, -1.37239456e-01f, 1.79451048e-01f, 7.76120052e-02f,
  1.95837483e-01f, 4.02120352e-01f, -1.10588856e-01f, 4.80227917e-01f, 3.24293345e-01f, -2.76148856e-01f, 6.83150962e-02f, 4.04764593e-01f, 7.09897041e-01f, -3.35701883e-01f,
  -5.43609321e-01f, -5.78088760e-01f, -2.94739902e-01f, -2.47056663e-01f, -3.69810700e-01f, -6.13261521e-01f, 7.14221418e-01f, 3.40738297e-01f, 8.10904801e-02f, -3.88169661e-03f,
  -3.75430971e-01f, 1.87670887e-01f, -6.84275627e-01f, -1.06622171e+00f, 3.87825042e-01f, -5.60007453e-01f, -1.08748615e-01f, -4.54331368e-01f, 3.92812043e-01f, -7.40118185e-03f,
  -5.19212008e-01f, -2.43920878e-01f, 1.04413163e-02f, -4.11406666e-01f, 7.60891363e-02f, 2.98484594e-01f, 2.38105357e-02f, -2.12290704e-01f, 4.11158562e-01f, 1.56854745e-02f,
  -3.05943370e-01f, 1.85557172e-01f, 2.53489107e-01f, 2.78727025e-01f, -3.08110714e-01f, 3.62507015e-01f, -1.73377842e-01f, 2.85202116e-01f, -3.76309872e-01f, 2.03864854e-02f,
  -1.44487932e-01f, -7.03340292e-01f, -5.12058586e-02f, 6.19797967e-02f, 4.31412518e-01f, -5.84346294e-01f, -1.42142788e-01f, 2.33006001e-01f, 2.57984340e-01f, 6.83944067e-03f,
  4.40762371e-01f, -5.22252142e-01f, -5.49547434e-01f, 7.11863488e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.56771439e-01f, -1.16931811e-01f, 4.59534749e-02f, 5.60034029e-02f, -1.79936752e-01f, -1.74827635e-01f, 1.37034580e-01f, -9.05303955e-02f, -2.35114142e-01f, 4.03812937e-02f,
  3.76967967e-01f, -1.02940150e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    