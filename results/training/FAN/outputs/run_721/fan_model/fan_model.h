/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.00913960e-01f, 2.24180773e-01f, 3.09648037e-01f, 1.99531376e-01f, 1.43959254e-01f, -4.05778503e-03f, -6.35901988e-02f, -6.33644834e-02f, 1.16220526e-01f, 9.52822268e-02f,
  1.16937712e-01f, 7.91249983e-03f, 1.03432074e-01f, 6.29518330e-02f, -5.67776076e-02f, 1.32779658e-01f, 2.90274382e-01f, 2.25153536e-01f, -3.01601854e-03f, -2.76685283e-02f,
  3.55691388e-02f, 1.99164614e-01f, 3.21031839e-01f, 2.80583769e-01f, 2.59615749e-01f, 2.79285967e-01f, 2.58785367e-01f, 3.27088386e-01f, 1.48439527e-01f, 3.45837295e-01f,
  5.31091681e-03f, 2.52809078e-01f, 1.05672613e-01f, 2.05755234e-01f, 2.28373066e-01f, 1.99557811e-01f, 1.09687753e-01f, 2.08929628e-01f, 1.07085340e-01f, 2.04719067e-01f,
  1.52063310e-01f, 2.05856115e-01f, 2.08226740e-01f, 1.49636313e-01f, 2.50982821e-01f, 1.37884319e-01f, 1.64866179e-01f, 3.01693767e-01f, 1.68520570e-01f, 2.42992371e-01f,
  1.01447143e-01f, 2.02228472e-01f, 1.44677565e-01f, 1.11533053e-01f, 1.34308919e-01f, 1.59070283e-01f, 1.55315995e-01f, 1.37812197e-01f, 1.30794913e-01f, 9.50452089e-02f,
  -1.86029702e-01f, -2.06760406e-01f, -1.08052716e-01f, -2.15844899e-01f, -9.05598551e-02f, -1.21206395e-01f, -1.42664388e-01f, -1.61676884e-01f, -1.22930676e-01f, -1.32408187e-01f,
  -1.80017769e-01f, -1.44260272e-01f, -1.59673586e-01f, -2.05369979e-01f, -2.05230877e-01f, -6.77443370e-02f, -2.02027202e-01f, -1.42599925e-01f, -1.84121981e-01f, -9.05801505e-02f,
  -1.38425022e-01f, -1.55835539e-01f, -4.08806540e-02f, -1.93039194e-01f, -1.58483177e-01f, -1.27509579e-01f, -1.93747550e-01f, -1.24521658e-01f, -1.68972552e-01f, -1.48833513e-01f,
  1.44609004e-01f, 1.65097296e-01f, 1.26993150e-01f, 1.18636176e-01f, 2.15889826e-01f, 1.97105050e-01f, 1.22704767e-01f, 2.44411781e-01f, 1.87580884e-01f, 3.80583405e-02f,
  2.12193727e-01f, 1.32970616e-01f, 1.80851623e-01f, 2.28781939e-01f, 9.13963169e-02f, 6.69438541e-02f, 2.26895183e-01f, 1.59417003e-01f, 8.33214745e-02f, 1.06720150e-01f,
  9.09124613e-02f, 1.00936182e-01f, 1.12685949e-01f, 6.41960800e-02f, 9.90795866e-02f, 1.06455781e-01f, 1.70108795e-01f, 9.26778391e-02f, 5.24976961e-02f, -8.23637843e-03f,
  7.32956305e-02f, -1.85594261e-01f, -2.05552652e-01f, 5.37380762e-02f, -2.38511682e-01f, -1.69825152e-01f, -1.64722383e-01f, 1.18086897e-01f, 7.10354000e-02f, -1.27315193e-01f,
  -1.43815339e-01f, 5.38739190e-02f, 1.84042275e-01f, 1.24903210e-01f, 2.18966529e-01f, 6.78083673e-02f, -6.22069426e-02f, 1.28631741e-01f, 1.79380015e-01f, -2.12060229e-04f,
  -8.94502476e-02f, -2.49372739e-02f, 9.12029669e-03f, 1.23152070e-01f, 4.20041829e-02f, 2.95191016e-02f, -1.05954632e-01f, -1.75819457e-01f, -1.70181572e-01f, -1.42982677e-01f,
  -1.03277132e-01f, -1.50073975e-01f, -2.09904704e-02f, -3.42582986e-02f, -4.57610264e-02f, -8.44422653e-02f, -8.68589878e-02f, 1.93699971e-02f, -3.32201645e-02f, -5.42617105e-02f,
  -6.74496442e-02f, -1.03888825e-01f, 4.75343354e-02f, -6.47842363e-02f, -3.13213542e-02f, -1.25567883e-01f, -2.53611337e-03f, -3.10185552e-02f, 5.27809262e-02f, -1.98559985e-01f,
  -7.66589269e-02f, -2.34944135e-01f, -1.39863476e-01f, -4.59684506e-02f, 1.59103908e-02f, -3.48239988e-02f, -1.02333389e-01f, -1.37852266e-01f, -1.32963151e-01f, -1.80222038e-02f,
  1.77298129e-01f, 1.05452463e-01f, 5.62907569e-02f, 1.03850298e-01f, 1.03790686e-01f, 1.01656802e-01f, 1.07388817e-01f, 6.59691393e-02f, 1.41693309e-01f, 4.56055664e-02f,
  5.35688363e-02f, 1.30385354e-01f, 1.31706774e-01f, 5.52778095e-02f, 2.09607370e-02f, 9.78055876e-03f, 9.38741788e-02f, 1.34635463e-01f, 4.88318056e-02f, 5.53989932e-02f,
  3.89545262e-02f, 2.16195583e-02f, 6.95009679e-02f, 4.81927916e-02f, -2.59214584e-02f, 1.04190446e-01f, 8.46651942e-02f, 5.07116178e-03f, 1.02365874e-01f, -2.97856256e-02f,
  1.03935122e-01f, -1.38104394e-01f, 4.31907587e-02f, 2.51172744e-02f, -1.51233807e-01f, -1.08940877e-01f, -4.85522710e-02f, -1.15534931e-01f, -9.69491750e-02f, -6.80942759e-02f,
  -5.02842851e-02f, -4.53098565e-02f, -2.94086821e-02f, -1.02099944e-02f, -1.32835060e-01f, -6.26929896e-03f, -1.35785297e-01f, 1.36910817e-02f, -8.65016878e-02f, -7.09457472e-02f,
  -5.26813194e-02f, -1.12133352e-02f, 3.90304551e-02f, 8.25650170e-02f, -1.03742763e-01f, 4.66456041e-02f, -3.66804898e-02f, -2.86751855e-02f, 5.69669977e-02f, 3.19603831e-02f,
  -1.15320206e-01f, 9.64296982e-02f, -2.31292043e-02f, -1.63145401e-02f, -1.45703126e-02f, 1.24869362e-01f, 8.43349844e-02f, 1.44166872e-01f, 3.72930877e-02f, 3.12998332e-03f,
  -7.17028305e-02f, -2.54470021e-01f, -9.84609649e-02f, -8.69573653e-02f, -7.20895007e-02f, 6.20198809e-02f, 2.14071259e-01f, -5.49276322e-02f, 2.43672333e-03f, 4.97188307e-02f,
  8.98350477e-02f, 3.32757570e-02f, -5.46679134e-03f, 2.73512751e-02f, 3.80481221e-02f, 2.89423577e-02f, 1.28141046e-01f, 1.03043139e-01f, -2.40401831e-02f, 1.96326032e-01f,
  -5.90522140e-02f, -7.21514523e-02f, -9.41847563e-02f, -1.72540411e-01f, -2.22773012e-02f, 7.04176426e-02f, -8.74503329e-02f, 4.50646840e-02f, -7.47989789e-02f, 1.09145150e-01f,
  -7.14904815e-02f, 4.01500724e-02f, -5.20764887e-02f, 5.19615114e-02f, 5.20061255e-02f, -6.65718317e-02f, -1.43802082e-02f, 1.08244911e-01f, -5.15621640e-02f, -1.69090107e-02f,
  -4.25551124e-02f, -6.67008013e-02f, -6.42138273e-02f, -1.51811847e-02f, -4.28868793e-02f, -1.02220185e-01f, 4.10294160e-02f, 1.26877770e-01f, -9.72545706e-03f, 1.56589627e-01f,
  1.54464945e-01f, 1.04918055e-01f, 8.07968006e-02f, 4.51884195e-02f, -1.58580728e-02f, 1.23968236e-02f, 6.87271059e-02f, 1.96889024e-02f, 1.93906575e-02f, 6.81917071e-02f,
  2.11421568e-02f, -8.35597143e-02f, -2.88289436e-03f, 3.80199924e-02f, -6.13487214e-02f, -5.78891821e-02f, 2.16491185e-02f, -2.66010072e-02f, -4.58501056e-02f, -7.20573887e-02f,
  -1.01768680e-01f, -7.00100660e-02f, 1.91479307e-02f, -2.88908388e-02f, 3.36279534e-02f, 3.00657786e-02f, 2.90933922e-02f, -1.81516875e-02f, 3.52982730e-02f, 7.40650743e-02f,
  -1.78057432e-01f, -2.41708592e-01f, -1.27155736e-01f, -6.84628934e-02f, 3.85336354e-02f, -6.04822747e-02f, 1.37341619e-02f, -5.89256883e-02f, -7.12670088e-02f, 3.58901396e-02f,
  -7.08898827e-02f, -2.22653989e-02f, -5.02522551e-02f, 5.40807210e-02f, 1.93162858e-02f, -4.92997468e-02f, 3.61371823e-02f, 3.50830555e-02f, -1.04485169e-01f, -6.12316765e-02f,
  -9.53688473e-03f, -2.86922082e-02f, -1.30947426e-01f, 7.22313151e-02f, 6.91742897e-02f, -1.58376515e-01f, 1.50009468e-02f, -2.52073854e-02f, -7.72665218e-02f, 1.81464672e-01f,
  -3.24845463e-02f, -2.91044712e-01f, -3.09909403e-01f, -9.24556106e-02f, 8.39501098e-02f, -1.96624920e-01f, -3.10479730e-01f, -1.96056679e-01f, 6.26330376e-02f, -8.17613453e-02f,
  4.82467003e-02f, 1.42999291e-01f, 9.33025330e-02f, 6.73678890e-02f, -9.66073349e-02f, -2.58292168e-01f, -1.70556813e-01f, -1.65342107e-01f, -1.03422724e-01f, 6.33967742e-02f,
  1.21548451e-01f, -2.92730238e-02f, -2.71820987e-04f, -5.35502918e-02f, -5.81540316e-02f, 5.27428323e-03f, -6.61133602e-02f, -1.20684519e-01f, -1.09291837e-01f, -1.64712846e-01f,
  -1.27190545e-01f, -1.55684069e-01f, 4.47444357e-02f, 1.49316147e-01f, 3.42168659e-02f, 1.63771678e-02f, -1.01151086e-01f, 1.78054720e-03f, -2.60892045e-02f, -1.00757495e-01f,
  -2.18858495e-02f, 6.71625435e-02f, -1.09787891e-02f, -3.14818288e-04f, -4.51469757e-02f, -6.23041987e-02f, -2.83853579e-02f, -1.92276806e-01f, -8.00841823e-02f, -4.80066612e-02f,
  -2.77179088e-02f, -9.63250920e-02f, -5.42682037e-02f, -8.96578133e-02f, -1.60574183e-01f, -5.86778335e-02f, -1.10060737e-01f, -4.20108363e-02f, -5.93769476e-02f, -1.52120024e-01f,
  9.91336331e-02f, 3.70059684e-02f, -4.70339432e-02f, -8.22128505e-02f, 3.38378064e-02f, -4.22916841e-03f, -5.73578104e-02f, 1.56545006e-02f, 3.22121754e-02f, -9.79787335e-02f,
  4.08640914e-02f, -8.33490212e-03f, -1.19359344e-02f, -7.41549879e-02f, 2.26257704e-02f, -1.03764281e-01f, -3.74752134e-02f, -3.27099636e-02f, 6.45585954e-02f, -2.42730360e-02f,
  -9.59135890e-02f, 1.93502270e-02f, 1.95701215e-02f, -1.10516362e-01f, -1.12793475e-01f, -8.45253002e-03f, -1.03919953e-01f, 4.88359295e-02f, -3.88934538e-02f, 2.40387507e-02f,
  3.89063507e-02f, 1.04930170e-01f, -6.31576404e-02f, 1.46326078e-02f, 3.77116376e-03f, 3.65472026e-02f, 4.00722288e-02f, 2.06870027e-02f, -2.09016465e-02f, -1.03513487e-01f,
  -3.58248428e-02f, 3.51953437e-03f, -2.13920269e-02f, -1.00171082e-01f, -6.87244684e-02f, 3.03959101e-03f, -5.25903739e-02f, -1.50996167e-02f, -1.00060947e-01f, -6.80486709e-02f,
  -1.09230570e-01f, -1.70237049e-01f, 4.34222585e-03f, -1.41361803e-01f, -4.66546565e-02f, -4.03447375e-02f, -7.49204755e-02f, -3.62062380e-02f, -9.73604061e-03f, -1.49577230e-01f,
  3.76467198e-01f, -2.84918770e-02f, -1.91987246e-01f, 1.70108065e-01f, -1.62597626e-01f, -2.35171229e-01f, -8.68006870e-02f, 5.77954017e-03f, 5.61143868e-02f, 4.68508974e-02f,
  6.32556826e-02f, 2.92252582e-02f, 9.47167054e-02f, 1.46521911e-01f, 9.54883620e-02f, -4.98024598e-02f, -9.38600004e-02f, 1.35620357e-02f, 1.49519786e-01f, 1.15049824e-01f,
  1.18883982e-01f, 1.79439306e-01f, 3.21703792e-01f, 8.93245041e-02f, 2.79237982e-02f, -6.44388273e-02f, -1.41814826e-02f, -4.64542024e-02f, 1.84434056e-02f, -1.96345355e-02f,
  -1.21770173e-01f, 2.47243747e-01f, 1.98359881e-02f, 6.97319657e-02f, -6.09819777e-02f, 9.87937450e-02f, 7.12164119e-02f, 1.08914509e-01f, 1.10894762e-01f, 1.03371255e-01f,
  7.39938987e-04f, 1.17562853e-01f, 1.17237024e-01f, 7.58636370e-02f, 1.26936257e-01f, 4.79462072e-02f, 1.30609736e-01f, 1.66801065e-01f, -4.55907993e-02f, -4.21858355e-02f,
  -2.38519851e-02f, -1.99305452e-02f, -4.43232292e-03f, -6.25895485e-02f, 5.65110184e-02f, -4.25841212e-02f, -4.84323092e-02f, 2.77265608e-02f, 1.03161961e-01f, 1.28111690e-01f,
  1.54613256e-01f, 2.67438963e-02f, 9.71412584e-02f, -2.02904129e-03f, 1.03423387e-01f, 2.63133906e-02f, -1.06391251e-01f, -4.19433452e-02f, 6.02678284e-02f, -3.48131196e-03f,
  8.05171430e-02f, 2.17354409e-02f, 4.97287698e-02f, -1.71304983e-03f, -3.06864344e-02f, -4.90698703e-02f, -1.85392853e-02f, 4.36788052e-02f, 1.16777336e-02f, 2.28959527e-02f,
  3.75878438e-02f, -6.94269389e-02f, -3.54866274e-02f, 4.65468038e-03f, -1.15691192e-01f, 1.80094186e-02f, -7.10717142e-02f, 3.20957452e-02f, 6.14077458e-03f, -4.95475978e-02f,
  3.68007794e-02f, 1.19474113e-01f, 1.48592629e-02f, 1.48063749e-01f, -6.20050244e-02f, 1.04693085e-01f, 5.51187806e-02f, -4.20059524e-02f, 4.98835221e-02f, 9.16177966e-03f,
  8.18226300e-03f, 3.05328816e-02f, -5.74852154e-03f, -1.80196539e-02f, 3.07108741e-02f, -6.20332323e-02f, 5.97710237e-02f, -3.23421042e-03f, 3.74725983e-02f, 6.21607266e-02f,
  -5.87886311e-02f, -6.49070814e-02f, 3.74723636e-02f, 6.68312097e-03f, -2.81153657e-02f, 4.01413552e-02f, -7.97697306e-02f, -5.65211512e-02f, 9.68700424e-02f, -6.98854029e-02f,
  1.32295370e-01f, 1.53810401e-02f, 2.20638305e-01f, 1.58337593e-01f, 2.31471926e-01f, 2.40509540e-01f, 1.51383787e-01f, -7.07647130e-02f, 1.08495757e-01f, 1.32645845e-01f,
  4.92869690e-03f, 8.03204179e-02f, 1.76706374e-01f, 1.00302160e-01f, 1.54610006e-02f, 1.35403931e-01f, 1.71741381e-01f, 1.07885852e-01f, 1.99885443e-01f, 1.51828691e-01f,
  1.80088937e-01f, 2.15325311e-01f, 2.14980215e-01f, 1.86053708e-01f, 2.38863945e-01f, 6.82063550e-02f, 2.31320918e-01f, 2.28038147e-01f, 2.10771009e-01f, 1.53174967e-01f,
  1.61137953e-01f, -4.53300253e-02f, 1.40702566e-02f, 8.34631100e-02f, 1.01249129e-01f, -1.72228068e-02f, 7.21481591e-02f, 3.29121798e-02f, -4.65159677e-02f, -3.78752523e-03f,
  2.46140808e-02f, 8.16155896e-02f, 8.38403404e-02f, -2.79135518e-02f, -2.32319217e-02f, -4.70607281e-02f, 6.57243356e-02f, 3.85293458e-03f, 7.69036263e-02f, -6.51852265e-02f,
  1.42114803e-01f, 1.68553546e-01f, 8.94475263e-03f, -3.74621935e-02f, -2.52714735e-02f, 9.59831197e-03f, -5.17459475e-02f, 3.38727571e-02f, -3.86792831e-02f, 5.34555782e-03f,
  5.62324040e-02f, -1.31197140e-01f, -6.72779232e-02f, -1.35469526e-01f, -8.83537680e-02f, -5.88375479e-02f, -1.28433198e-01f, -6.55499995e-02f, -1.16315879e-01f, -1.54224023e-01f,
  -1.38274610e-01f, -1.29035562e-01f, -1.10213766e-02f, -1.04625680e-01f, -1.24611422e-01f, -9.41574923e-04f, -1.04001381e-01f, -5.03527038e-02f, 9.66746520e-05f, -1.20342985e-01f,
  -1.21122733e-01f, -5.30635491e-02f, -9.72252786e-02f, -8.43503252e-02f, -1.05479822e-01f, -8.57882202e-02f, -9.09993351e-02f, -1.23512641e-01f, -1.28160100e-02f, -8.29582661e-02f,
  -4.80539575e-02f, 7.33093694e-02f, 2.97415555e-02f, 4.06812243e-02f, -3.01883295e-02f, -3.64093632e-02f, -3.79364751e-02f, -6.29541352e-02f, -6.54911324e-02f, -1.16983028e-02f,
  8.22316781e-02f, 1.43895634e-02f, -2.74070762e-02f, -6.48599723e-03f, 1.72528122e-02f, 1.90515462e-02f, 5.08120982e-04f, 1.44311860e-01f, 5.65106049e-02f, 2.76499391e-02f,
  -1.04896668e-02f, 7.77597073e-03f, 2.41520768e-03f, -7.65725672e-02f, -5.77583238e-02f, 6.39282688e-02f, 6.68111145e-02f, 1.91038344e-02f, -1.71157364e-02f, -7.19411224e-02f,
  2.39432067e-01f, 1.64257169e-01f, -1.52390897e-01f, -2.55147181e-02f, -3.03492188e-01f, -2.44044662e-01f, -2.04461459e-02f, -1.31306723e-01f, -1.28728911e-01f, 2.55169533e-02f,
  6.69453219e-02f, -4.53365501e-03f, -1.34561080e-02f, -3.97266559e-02f, 4.09327075e-03f, -2.96339896e-02f, -2.20612153e-01f, -1.00351550e-01f, -2.27440655e-01f, -1.42046168e-01f,
  -1.47000894e-01f, -9.86839309e-02f, -1.33920193e-01f, -1.78499505e-01f, -1.81906834e-01f, -4.52857837e-02f, -1.68394044e-01f, -2.51250952e-01f, -2.08574846e-01f, -7.04056174e-02f,
  5.94625324e-02f, -1.98744759e-01f, -1.89269260e-01f, -5.33724762e-02f, -1.10616498e-01f, -1.63783971e-02f, -1.06722511e-01f, -2.15165079e-01f, -9.57826972e-02f, -3.42897438e-02f,
  -2.37776533e-01f, -1.24556489e-01f, -1.05573721e-01f, -1.49290934e-01f, -2.30883092e-01f, -1.57654136e-01f, -1.57348350e-01f, -2.21302047e-01f, -9.39165205e-02f, -1.77452669e-01f,
  -1.43180892e-01f, -2.32085168e-01f, -1.55736163e-01f, -1.35360152e-01f, -1.95331722e-01f, -1.63397029e-01f, -1.54536366e-01f, -1.74365401e-01f, -8.81772488e-02f, -6.44768476e-02f,
  5.65932095e-02f, 1.17053844e-01f, 1.67010445e-02f, 1.08770661e-01f, 8.84570107e-02f, 8.36234018e-02f, 3.79895084e-02f, 1.19203046e-01f, 6.22821897e-02f, 9.60689560e-02f,
  1.09023280e-01f, 5.40152788e-02f, -8.11718125e-03f, 1.62534922e-01f, 6.63473606e-02f, 8.08130875e-02f, 5.97188026e-02f, 1.43301353e-01f, 9.63424221e-02f, 1.11486383e-01f,
  1.38812661e-01f, 6.16444647e-02f, 3.40485312e-02f, 1.61001116e-01f, 2.78084222e-02f, 1.28775403e-01f, 1.52537525e-01f, 4.18838225e-02f, 1.18453555e-01f, 9.12152827e-02f,
  1.03112489e-01f, -2.58277804e-01f, 3.86226214e-02f, -1.81143448e-01f, -2.02179775e-01f, -1.73381165e-01f, -9.61448699e-02f, -1.05092101e-01f, -1.63088992e-01f, -2.91859768e-02f,
  -1.75346270e-01f, -5.37619777e-02f, -1.36558264e-01f, -1.75658822e-01f, -5.92195541e-02f, -1.71724007e-01f, -9.38172340e-02f, -5.97367957e-02f, -7.58954734e-02f, -2.03258991e-01f,
  -1.10942788e-01f, -1.28191695e-01f, -1.46036083e-02f, -1.02480000e-03f, -1.32520437e-01f, -1.49869144e-01f, -6.82389587e-02f, -7.02247173e-02f, -2.97006071e-02f, 5.29081076e-02f,
  -2.05323055e-01f, 1.30071836e-02f, -1.74809974e-02f, -2.03004777e-01f, 5.36667742e-03f, -8.20626840e-02f, 2.69495826e-02f, -2.56972853e-02f, -1.25431404e-01f, -7.45867044e-02f,
  -8.17631558e-02f, 1.92596037e-02f, -5.41174784e-03f, 1.04929604e-01f, 1.14674188e-01f, -3.93798761e-02f, 1.62153393e-01f, 3.28001305e-02f, 2.07245760e-02f, 1.29741073e-01f,
  1.39642090e-01f, -5.81064448e-02f, -3.87252606e-02f, 9.47603770e-03f, 1.20386697e-01f, 4.90491055e-02f, -2.21810397e-02f, 4.97284019e-03f, 3.26722525e-02f, 1.73544243e-01f,
  -8.45354572e-02f, 2.06203368e-02f, -4.85206135e-02f, -9.23502445e-02f, 1.24017696e-03f, -6.29836172e-02f, -1.02431796e-01f, -4.28471006e-02f, -2.06081755e-02f, -1.72396731e-02f,
  -7.59531511e-03f, 4.74286033e-03f, -2.90343668e-02f, -4.78145741e-02f, -1.08757541e-01f, -1.11202084e-01f, -8.40908289e-02f, -7.99460150e-03f, -3.15720998e-02f, 5.20188734e-03f,
  -5.51389111e-03f, -1.50449604e-01f, -1.86487466e-01f, -1.35759085e-01f, -1.23705797e-01f, -4.00061011e-02f, -1.43555552e-01f, 1.87558420e-02f, -1.20252445e-01f, -1.02455661e-01f,
  1.89179797e-02f, -6.42231153e-03f, -5.78101575e-02f, 3.43025513e-02f, -5.67612180e-04f, 1.82359312e-02f, 9.41333696e-02f, -3.33457403e-02f, 4.25063297e-02f, 1.44020040e-02f,
  -8.82015228e-02f, -6.35438189e-02f, 3.55607159e-02f, 7.80377239e-02f, 6.25497699e-02f, -3.75460498e-02f, 6.54565841e-02f, 4.36196886e-02f, 5.17659970e-02f, 2.17243023e-02f,
  -7.14625046e-02f, 4.84267995e-02f, 3.70685272e-02f, 7.32602105e-02f, -7.49742240e-02f, -5.97127639e-02f, -6.38988167e-02f, -1.03869744e-01f, -1.02808081e-01f, -1.04148455e-01f,
  -1.49827152e-01f, 3.52413021e-02f, -7.03103840e-02f, -1.74711999e-02f, -2.28048600e-02f, -1.82959642e-02f, -4.68333140e-02f, 6.33318201e-02f, -6.50746152e-02f, 3.60989310e-02f,
  -4.45093736e-02f, -2.74640042e-02f, 1.07506895e-02f, 1.18169952e-02f, -6.25474285e-03f, -2.69217864e-02f, -7.67430887e-02f, -7.54689127e-02f, -8.59909579e-02f, -5.45068234e-02f,
  -4.11493890e-02f, -2.08049357e-01f, -2.38190562e-01f, -9.30043012e-02f, -9.76356678e-03f, -8.13129842e-02f, -1.71221346e-02f, -1.21837541e-01f, -6.93025291e-02f, -1.56887144e-01f,
  -2.01347277e-01f, -7.99503252e-02f, 9.87042561e-02f, -4.51778471e-02f, 7.35687464e-02f, 9.72663835e-02f, 4.39372212e-02f, 3.67119014e-02f, -3.41134183e-02f, -2.24415003e-03f,
  -1.87590852e-01f, -1.79722190e-01f, -9.87715423e-02f, -6.40277052e-03f, -8.11644420e-02f, 4.24272716e-02f, -5.46664707e-02f, 4.83357236e-02f, 1.35011980e-02f, 7.68784732e-02f,
  -6.32454604e-02f, -1.81623191e-01f, -2.32418343e-01f, -4.11172807e-02f, -5.84062934e-02f, -4.65209819e-02f, -7.84614533e-02f, -1.14603050e-01f, 1.12836752e-02f, -1.02152497e-01f,
  1.61779821e-01f, -1.65564254e-01f, -2.08694354e-01f, -2.57295221e-01f, -4.35724743e-02f, -2.30524793e-01f, -1.58176348e-01f, -1.96788341e-01f, -1.74292088e-01f, -1.81878924e-01f,
  -2.15490505e-01f, -2.31637478e-01f, -1.74050376e-01f, -1.89451739e-01f, -7.71791488e-02f, -8.32336247e-02f, -1.49624243e-01f, -1.07821248e-01f, -5.89095280e-02f, -5.99280931e-02f,
  -2.03850418e-01f, -1.69345111e-01f, -1.17823444e-01f, -1.36027828e-01f, -1.64182544e-01f, -1.26250073e-01f, -1.04646601e-01f, -5.38366996e-02f, -1.60931498e-01f, -1.52323186e-01f,
  1.57292299e-02f, 9.42781940e-02f, 9.18116346e-02f, 1.07813843e-01f, 5.75491749e-02f, 1.65796431e-03f, 1.00285411e-01f, 4.96831909e-02f, 1.80991203e-01f, -9.39159095e-03f,
  1.20097280e-01f, 1.65063336e-01f, 1.27349898e-01f, 3.62404957e-02f, 1.62792608e-01f, 2.27888245e-02f, 4.54451479e-02f, 4.19981331e-02f, 3.40210460e-02f, 2.15418283e-02f,
  9.32552740e-02f, 2.26494335e-02f, 4.86402139e-02f, 1.00966096e-01f, 1.16926789e-01f, 1.74415082e-01f, 1.45573661e-01f, 9.18184742e-02f, 1.09783053e-01f, 5.70701696e-02f,
  -1.02895554e-02f, -1.00438446e-01f, -1.26348063e-01f, -1.83986798e-01f, -1.89246029e-01f, -1.54176176e-01f, -1.20629437e-01f, -1.57004476e-01f, -1.24493323e-01f, -3.66703011e-02f,
  -7.11094365e-02f, -2.20586106e-01f, -6.83407038e-02f, -9.65815932e-02f, -1.55605331e-01f, -1.66742936e-01f, -1.31288424e-01f, -1.85692787e-01f, -2.27646559e-01f, -1.77090049e-01f,
  -2.33162448e-01f, -1.41087577e-01f, -1.21151358e-01f, -1.18789665e-01f, -9.49977338e-02f, -1.54777169e-01f, 1.00685551e-03f, -1.48395956e-01f, -1.31885737e-01f, -5.30496351e-02f,
  -2.21642330e-02f, 2.13235378e-01f, 1.85315683e-01f, -7.42272437e-02f, 1.44725457e-01f, 1.30323201e-01f, 2.61357665e-01f, 8.98081064e-02f, 3.00640240e-02f, 5.59661873e-02f,
  3.19057591e-02f, 4.87091243e-02f, 1.19208261e-01f, 7.09770992e-02f, 1.54463440e-01f, 2.68231541e-01f, 2.19101220e-01f, 1.61251098e-01f, 6.75832108e-02f, -4.82478626e-02f,
  -1.93052031e-02f, -2.23062739e-01f, -1.39767706e-01f, -1.41180649e-01f, 6.86800256e-02f, 8.47682357e-02f, 7.43129998e-02f, 5.76418117e-02f, 1.72623873e-01f, 1.27135158e-01f,
  2.29128584e-01f, 7.10660890e-02f, -6.79518357e-02f, -2.44931858e-02f, -4.50948142e-02f, -9.71597582e-02f, 2.99065397e-03f, -1.02866605e-01f, -1.09502107e-01f, -9.86683816e-02f,
  -9.55665037e-02f, -9.24561694e-02f, -1.00782551e-01f, -3.55941132e-02f, 2.27798205e-02f, 1.18575068e-02f, -1.18956417e-01f, -5.30510806e-02f, -4.29649986e-02f, 6.43310547e-02f,
  -3.49379703e-02f, -7.10662603e-02f, 9.12702307e-02f, 6.57282919e-02f, -8.05421174e-02f, -2.86812782e-02f, -3.25671881e-02f, 7.12426007e-02f, 8.93503055e-02f, -6.24343343e-02f,
  7.74507271e-03f, -1.21704070e-02f, 3.08286157e-02f, 6.55579865e-02f, -5.53870797e-02f, 1.91385038e-02f, -1.79208200e-02f, -7.50619173e-02f, -3.17016765e-02f, -5.03078364e-02f,
  6.22740993e-03f, 3.94623727e-02f, 4.41629514e-02f, -5.10087758e-02f, -3.88846695e-02f, 6.44289404e-02f, -6.31776676e-02f, -8.76042768e-02f, -2.71237176e-02f, 1.46133257e-02f,
  3.56365964e-02f, -7.92383030e-02f, -2.60174349e-02f, 2.75783706e-02f, -7.72280097e-02f, -4.38492745e-02f, -2.03137775e-03f, -5.05215861e-02f, -2.16547363e-02f, -3.49985026e-02f,
  -9.45573971e-02f, -4.27703746e-03f, 3.06142010e-02f, 1.84683762e-02f, -3.40670496e-02f, -5.81909381e-02f, -4.12223376e-02f, 3.18904617e-03f, -4.25497489e-03f, 1.30684348e-03f,
  3.88749652e-02f, -4.33308035e-02f, 7.13139623e-02f, 4.61924486e-02f, -3.29916291e-02f, 2.97972579e-02f, -3.35719027e-02f, -2.47813947e-03f, 7.63465986e-02f, 3.10736336e-02f,
  -1.66681539e-02f, 1.10350713e-01f, 1.54881656e-01f, 1.15753405e-01f, -4.19650264e-02f, 1.74003601e-01f, 1.48915082e-01f, -3.65325063e-02f, 1.34404320e-02f, -4.90704365e-02f,
  -2.16615215e-01f, -1.42758200e-02f, 1.78840667e-01f, -1.62259698e-01f, 1.37724623e-01f, 1.78167462e-01f, 2.18312278e-01f, 1.57167882e-01f, 3.30293216e-02f, 5.45445383e-02f,
  -1.75371006e-01f, 3.77294119e-03f, -7.10242102e-03f, 1.26392931e-01f, 2.08295375e-01f, 2.38715261e-01f, 2.87473708e-01f, 2.88132757e-01f, 1.80013195e-01f, 1.39015928e-01f,
  7.28584900e-02f, -1.28533661e-01f, -6.08003736e-02f, -4.36780800e-04f, 4.34507057e-03f, -9.06756446e-02f, -7.09006861e-02f, 7.38311261e-02f, 9.27860383e-03f, 3.79404463e-02f,
  -1.12604111e-01f, -1.11580275e-01f, 8.72228667e-03f, -1.66349888e-01f, -1.42263666e-01f, -7.48925805e-02f, -5.05361855e-02f, -9.98323560e-02f, -7.54877925e-02f, -3.26990783e-02f,
  -1.32670239e-01f, -1.07837014e-01f, -2.70596128e-02f, -6.06627613e-02f, -4.66508716e-02f, 8.63002497e-04f, 3.43113951e-02f, -3.97369415e-02f, -7.71293417e-02f, -5.52835874e-02f,
  -1.61614064e-02f, -5.18075116e-02f, -5.67600019e-02f, 4.18849140e-02f, 5.63554764e-02f, -1.14143156e-01f, 2.66127083e-02f, -9.80788767e-02f, 3.66432145e-02f, -1.60446852e-01f,
  2.97872797e-02f, 2.07117908e-02f, 1.44765034e-01f, -5.49813099e-02f, -2.51117945e-02f, -4.37242575e-02f, 1.45170510e-01f, 2.50790864e-02f, 4.40650340e-03f, -4.69107963e-02f,
  1.32163763e-01f, 4.85459901e-02f, -3.83308195e-02f, 4.01259847e-02f, 8.81531090e-02f, -2.58099809e-02f, 1.06265746e-01f, 5.11239059e-02f, 4.49436046e-02f, -5.50453225e-03f,
  7.49596432e-02f, 5.65464385e-02f, -9.84904394e-02f, 1.28252003e-02f, 1.29005983e-01f, 1.20834775e-01f, 7.54745165e-03f, -2.57275496e-02f, -8.27506557e-03f, -3.36688347e-02f,
  -2.73452997e-01f, -2.43322439e-02f, 5.36380010e-03f, 4.28732149e-02f, -1.16742589e-01f, -1.88806541e-02f, -5.86561635e-02f, -4.98265363e-02f, -9.19765607e-02f, -4.13997844e-02f,
  -9.01361108e-02f, -2.23567393e-02f, -7.58317411e-02f, 3.44247594e-02f, -5.88201880e-02f, -7.51510262e-02f, -9.86564532e-02f, 1.17417350e-02f, 1.33046545e-02f, -6.21626005e-02f,
  -7.38554448e-02f, 3.91993485e-03f, 4.40850221e-02f, 3.15343514e-02f, -9.02099628e-03f, -5.15579134e-02f, -1.32323846e-01f, -1.44793503e-02f, -2.94880066e-02f, -1.53058857e-01f,
  3.29413295e-01f, 4.26994592e-01f, 3.06076050e-01f, 5.18896841e-02f, 6.77700639e-02f, 2.19254777e-01f, 4.30167228e-01f, 2.12461323e-01f, 9.07820538e-02f, 1.53711364e-01f,
  -8.47775117e-02f, -1.39757261e-01f, -1.18782520e-01f, 1.10416831e-02f, 1.21199518e-01f, 3.76553446e-01f, 1.55991167e-01f, 1.31687224e-01f, -5.35330772e-02f, 8.57461244e-02f,
  4.29789349e-02f, 2.19767774e-03f, 6.60500824e-02f, 2.81708650e-02f, 8.76684263e-02f, -1.27771720e-01f, 1.07902460e-01f, 7.92731643e-02f, 8.62759203e-02f, 1.99031144e-01f,
  4.69234288e-02f, 4.46157515e-01f, 8.83797333e-02f, 1.02335215e-01f, 7.22835287e-02f, 2.00175181e-01f, 1.71433046e-01f, 2.33225897e-01f, 1.69767722e-01f, 2.09554225e-01f,
  4.33503129e-02f, 1.53767839e-01f, 6.68056980e-02f, 8.65356103e-02f, 1.82428941e-01f, 1.67607054e-01f, 1.57897070e-01f, 1.48469612e-01f, 1.57803714e-01f, 2.47087538e-01f,
  -1.71118882e-02f, 1.23725921e-01f, 1.47652015e-01f, 2.82616705e-01f, 1.99518174e-01f, 6.48311973e-02f, 2.84604907e-01f, 1.19196661e-01f, 2.42723599e-01f, 2.85297304e-01f,
  3.93724702e-02f, 1.50704218e-05f, -8.03155303e-02f, 1.94990616e-02f, 1.03541296e-02f, -2.39089169e-02f, -3.50003317e-02f, -1.04640678e-01f, 4.92564887e-02f, -4.44126315e-02f,
  -1.79599319e-02f, -6.91705197e-02f, -4.03397046e-02f, -6.01288565e-02f, -2.58599371e-02f, 2.01340895e-02f, -5.83921559e-02f, -6.29578382e-02f, -2.10567378e-02f, 2.91287266e-02f,
  -5.59261963e-02f, 4.71958704e-02f, -1.05608843e-01f, 5.99389896e-02f, 3.49720865e-02f, -4.56835739e-02f, -3.67589407e-02f, -3.63601893e-02f, -7.37748742e-02f, -4.55064476e-02f,
  -1.09143317e-01f, 1.66830212e-01f, 1.01107299e-01f, 1.93449631e-01f, 1.63627073e-01f, 8.86881799e-02f, 1.03796390e-03f, 1.18258141e-01f, 5.33300973e-02f, 2.45917127e-01f,
  5.59007488e-02f, 2.06145436e-01f, 1.53043792e-01f, 1.07538477e-01f, 1.79655597e-01f, 6.95738345e-02f, 1.34466708e-01f, 1.33163244e-01f, 7.73568824e-02f, 1.78582713e-01f,
  1.99178010e-01f, 1.39967486e-01f, 1.89212441e-01f, 1.52567506e-01f, 2.16126472e-01f, 2.56311838e-02f, 6.54135793e-02f, 8.67879316e-02f, 1.08885206e-01f, 1.77653790e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.15112543e-01f, 1.82966173e-01f, 2.74632633e-01f, 3.03916801e-02f, 5.25009297e-02f, 7.22093657e-02f, 1.20066598e-01f, 4.62011844e-02f, -1.13288447e-01f, 1.09759420e-01f,
  -9.69905965e-03f, -1.24488510e-02f, -1.03930652e-01f, -9.88033563e-02f, 3.64560913e-03f, 2.92428918e-02f, 5.01014758e-03f, 1.35049403e-01f, 2.13629335e-01f, 2.34386951e-01f,
  9.86725539e-02f, 6.24978021e-02f, 1.97164193e-01f, 8.62013921e-02f, 4.10728268e-02f, -3.05953380e-02f, 8.86969790e-02f, 7.22339898e-02f, 1.78969339e-01f, 1.38442263e-01f,
  2.85347313e-01f, 3.02879900e-01f, -6.77553415e-02f, -5.72594032e-02f, 9.29176062e-02f, 4.48519588e-02f, -3.50007862e-02f, -8.20227414e-02f, -3.68295722e-02f, -4.64004241e-02f,
  1.76638756e-02f, 7.72966370e-02f, 7.76623487e-02f, -2.30299793e-02f, 2.43178234e-02f, 1.09696396e-01f, 9.82299000e-02f, 1.10948376e-01f, -5.17230071e-02f, -1.81940608e-02f,
  3.93250547e-02f, 9.95602384e-02f, 5.48861660e-02f, -1.04415834e-01f, -8.64471868e-03f, 3.43297236e-02f, -7.22742379e-02f, 1.32801875e-01f, -8.56233835e-02f, 1.70714572e-01f,
  4.05384339e-02f, 1.92961231e-01f, 2.82946527e-01f, 2.62038916e-01f, 2.62490213e-01f, 3.50108743e-02f, 3.69174741e-02f, 2.60202456e-02f, 1.56278461e-01f, 1.61579400e-01f,
  1.11132637e-01f, 2.23233268e-01f, 2.00016126e-01f, 1.22565985e-01f, 4.55528982e-02f, 1.78504393e-01f, 2.13082835e-01f, 3.79376523e-02f, 6.91384375e-02f, 2.73996759e-02f,
  1.96675360e-01f, -1.45069268e-02f, 2.68376376e-02f, 9.44627151e-02f, 5.08504659e-02f, 1.83288276e-01f, 2.20123574e-01f, 6.85218871e-02f, 6.03103749e-02f, 1.76158309e-01f,
  -3.83049875e-01f, -1.09564349e-01f, 7.32380599e-02f, -6.22472689e-02f, -5.27117848e-02f, -1.16517402e-01f, -2.76017822e-02f, -4.68559451e-02f, -1.41079605e-01f, -8.38696063e-02f,
  -6.97703511e-02f, -2.12365272e-03f, 5.86043596e-02f, 8.15061778e-02f, -1.60488468e-02f, -1.22984760e-01f, 3.32235335e-03f, -1.42029181e-01f, -2.25018054e-01f, -1.75592199e-01f,
  -4.11311612e-02f, -3.41026187e-02f, -1.54729530e-01f, -7.50086904e-02f, -4.19508182e-02f, -1.34493500e-01f, -8.39885548e-02f, -8.46000537e-02f, -1.16175294e-01f, -8.40218142e-02f,
  -2.46307358e-01f, -5.35985306e-02f, -1.90892577e-01f, 1.01161823e-01f, 9.91069004e-02f, -8.02620351e-02f, -3.68226543e-02f, 5.49694709e-02f, -2.17996282e-03f, -1.54849425e-01f,
  -1.15143858e-01f, -3.13618109e-02f, -2.68689021e-02f, -8.31151940e-03f, -3.18780774e-03f, -6.34956285e-02f, 2.26613022e-02f, 4.82217297e-02f, 1.52576268e-01f, 1.67178139e-01f,
  1.82220235e-01f, 1.57319382e-01f, 3.50899585e-02f, 1.66994214e-01f, 1.17392957e-01f, 3.20270360e-02f, -3.00899055e-02f, 7.73144048e-03f, -1.02269277e-01f, 5.51610403e-02f,
  -3.55934203e-01f, -3.31888236e-02f, 8.84689167e-02f, 5.94807044e-02f, -7.57692903e-02f, -1.02539547e-01f, -9.47556943e-02f, 4.94044907e-02f, -4.21099365e-03f, -1.54993325e-01f,
  -8.44644234e-02f, 3.74378599e-02f, -3.94683555e-02f, -3.09538911e-03f, 1.05770202e-02f, -6.23772293e-02f, 1.96263120e-01f, 7.90245235e-02f, -1.86375812e-01f, -8.49594995e-02f,
  1.64678514e-01f, -8.34592432e-02f, -1.02908775e-01f, 6.33973554e-02f, 4.97113317e-02f, -1.04845524e-01f, -8.59418958e-02f, 1.06401153e-01f, -2.10118398e-01f, -1.37357816e-01f,
  -1.21881498e-03f, -2.16133636e-03f, 1.23076819e-01f, 3.82438004e-02f, -3.81045267e-02f, -1.37809709e-01f, 1.38934657e-01f, 6.17875680e-02f, -5.59605099e-02f, 2.56944206e-02f,
  1.12850107e-01f, -1.59562692e-01f, 4.25145403e-02f, -8.06751028e-02f, 5.32614440e-02f, 5.03109284e-02f, 5.70363738e-02f, -2.31937245e-02f, -6.46948591e-02f, 2.71657738e-03f,
  1.00555472e-01f, 9.26474929e-02f, 8.08986276e-02f, 1.64095834e-01f, -6.44543692e-02f, 1.09171756e-01f, 7.49932230e-02f, 1.04986764e-01f, 1.08037308e-01f, -6.92104101e-02f,
  -1.30814970e-01f, -4.89080809e-02f, -2.93047249e-01f, 1.22801632e-01f, -4.77792434e-02f, -2.80585829e-02f, -8.44791010e-02f, 2.15839539e-02f, -1.75062066e-03f, -7.30645284e-02f,
  -1.04259394e-01f, -8.78466070e-02f, -6.48828968e-02f, 8.80835876e-02f, -1.52834564e-01f, -1.45753607e-01f, -4.97556217e-02f, -1.20800018e-01f, -5.82410097e-02f, -5.77904619e-02f,
  1.83743969e-01f, -1.93516940e-01f, -2.97050089e-01f, -7.33917877e-02f, -1.98765788e-02f, -2.96286732e-01f, -2.04848528e-01f, -1.56286895e-01f, -3.11636418e-01f, -4.90283936e-01f,
  1.99118748e-01f, 8.43926296e-02f, -2.01313552e-02f, 9.91973728e-02f, 3.11867833e-01f, 2.45123833e-01f, 3.24918330e-01f, 1.63323745e-01f, 1.04995683e-01f, 1.48371151e-02f,
  -1.14360772e-01f, -1.44205451e-01f, -2.22942591e-01f, -2.17103839e-01f, 8.29867087e-03f, 1.28803819e-01f, 1.88283414e-01f, 8.40855390e-03f, 9.47695132e-03f, 3.28134932e-02f,
  1.56871546e-02f, 9.37837437e-02f, 8.55661705e-02f, -5.89163601e-02f, -4.67900299e-02f, 4.46474887e-02f, 8.18107873e-02f, 1.29383191e-01f, -9.20399185e-03f, -1.65546358e-01f,
  -3.68877202e-01f, -1.84210166e-02f, 3.10252868e-02f, -1.55553028e-01f, 7.48552615e-03f, -8.33933800e-02f, -2.34696101e-02f, -7.62215033e-02f, 1.20573916e-01f, 6.20217174e-02f,
  -7.87508022e-03f, 3.16806249e-02f, -5.88225536e-02f, 7.87192434e-02f, 9.46909096e-03f, -2.36051045e-02f, -7.61748329e-02f, -7.44994078e-03f, -1.00243881e-01f, -1.82868779e-01f,
  -9.62530002e-02f, 2.40721088e-02f, 1.49476871e-01f, 1.20411487e-02f, -1.15645453e-01f, -6.58573210e-02f, -1.08907990e-01f, -1.14765257e-01f, 1.93411093e-02f, -1.76930036e-02f,
  -8.30659047e-02f, -9.51466858e-02f, -5.38157150e-02f, -1.61210269e-01f, -2.60934588e-02f, 9.38005596e-02f, -3.78786884e-02f, -1.60876978e-02f, -8.17263424e-02f, 7.79539347e-02f,
  4.65679243e-02f, -8.82746726e-02f, -7.96381012e-02f, -1.99815650e-02f, -1.41062364e-01f, -1.87299512e-02f, -8.11622813e-02f, -1.13241568e-01f, -7.90518895e-02f, -3.35472636e-02f,
  -1.46320626e-01f, 7.08302483e-02f, -1.32746268e-02f, -6.60022274e-02f, -1.36114344e-01f, -6.57566041e-02f, -9.01900232e-02f, -1.57172829e-01f, 6.87115192e-02f, -3.66397463e-02f,
  -9.65369418e-02f, -1.01026118e-01f, -1.64610490e-01f, -5.89744747e-02f, -5.72906286e-02f, -6.18417487e-02f, -2.18387604e-01f, -4.25734706e-02f, -1.39496261e-02f, 7.32058585e-02f,
  -2.99902726e-02f, -8.42948619e-04f, -1.02359749e-01f, -3.12600583e-02f, 1.16016336e-01f, 5.60869500e-02f, -6.08310523e-03f, -4.59534191e-02f, 3.67746246e-03f, -2.30180845e-02f,
  3.91192362e-02f, 6.60928488e-02f, 1.12048738e-01f, -5.30091207e-03f, -3.15871462e-02f, 5.50806671e-02f, 6.31111264e-02f, 1.19455792e-01f, 8.54040310e-02f, 2.20941499e-01f,
  2.86118507e-01f, 6.64520562e-02f, -4.69937652e-01f, 3.24434519e-01f, -2.46886030e-01f, -3.63539994e-01f, -4.34745133e-01f, -2.42430747e-01f, 1.65500998e-01f, 4.26079929e-02f,
  -5.66487797e-02f, 4.95971963e-02f, -2.33847201e-02f, -5.17866164e-02f, -1.89808324e-01f, -1.62513196e-01f, -8.84357020e-02f, -1.73484415e-01f, -2.63325781e-01f, -1.40628442e-02f,
  1.12464994e-01f, 2.26704225e-01f, 1.55350894e-01f, 9.69687179e-02f, 2.75143027e-01f, 3.72771472e-02f, -4.23011035e-02f, -2.02790815e-02f, -1.07178926e-01f, 2.12258205e-01f,
  -1.09721035e-01f, -6.18999861e-02f, -2.14789778e-01f, 1.86703920e-01f, 8.34969953e-02f, 1.54397801e-01f, 2.13112440e-02f, 5.56922369e-02f, 2.06444245e-02f, 1.21959932e-01f,
  7.97177032e-02f, 1.38624180e-02f, -1.43559733e-02f, 1.60881877e-01f, 1.42890006e-01f, -4.26831469e-02f, -3.21438466e-03f, -5.52709363e-02f, 9.99017358e-02f, 4.14782912e-02f,
  8.15244168e-02f, -5.56643493e-02f, -3.05509180e-01f, -1.32140547e-01f, -4.35092226e-02f, -1.60627589e-01f, -1.97011277e-01f, -6.36090338e-02f, -2.96106756e-01f, 1.62470594e-01f,
  1.26350641e-01f, 1.17391370e-01f, 3.98995094e-02f, 3.56821157e-03f, 9.68328342e-02f, 5.42753525e-02f, 1.39014378e-01f, 1.62729979e-01f, 7.60711506e-02f, 9.12764966e-02f,
  -9.11023691e-02f, 5.91184832e-02f, 4.77030613e-02f, -4.16407883e-02f, 1.25798836e-01f, 1.58266515e-01f, 5.50233759e-02f, 5.22093363e-02f, 6.17237799e-02f, 1.72327533e-01f,
  5.00703715e-02f, 2.63843164e-02f, 1.75892971e-02f, 1.26603052e-01f, 1.72730889e-02f, 1.03199489e-01f, 8.14568326e-02f, -3.83142754e-02f, 1.39353260e-01f, 3.30682099e-03f,
  1.87439337e-01f, -3.17500561e-01f, 8.64498317e-02f, 4.45009619e-02f, 2.55632997e-02f, -3.38176936e-02f, 1.24515831e-01f, 1.31657377e-01f, 1.52313992e-01f, 7.75673911e-02f,
  -1.91828206e-01f, -6.07957691e-02f, -1.08174719e-02f, -2.93960087e-02f, -1.79006942e-02f, -1.11348882e-01f, 4.86178696e-02f, -6.03933297e-02f, -8.56068283e-02f, 7.42729455e-02f,
  1.14731025e-02f, -2.14056134e-01f, -1.89436331e-01f, -2.52121300e-01f, -1.82793639e-03f, -1.59735158e-01f, -1.28336146e-01f, -1.21048100e-01f, -3.46412867e-01f, -5.48275299e-02f,
  -1.91178709e-01f, 1.42809302e-01f, -6.75247386e-02f, 5.00527360e-02f, 2.40457475e-01f, -9.40951519e-03f, -1.60640225e-01f, -1.95160866e-01f, 8.48995522e-02f, 1.59879718e-02f,
  2.25752905e-01f, 8.22582021e-02f, -1.12643190e-01f, -1.16665795e-01f, -3.41957748e-01f, -1.82895437e-01f, -1.95623502e-01f, -3.83170962e-01f, -3.08034241e-01f, -1.86638273e-02f,
  1.34883896e-01f, -4.52982225e-02f, -2.31452987e-01f, -1.52266935e-01f, 8.08360949e-02f, -5.61073702e-03f, -2.99481377e-02f, 4.07653414e-02f, 4.62147733e-03f, 8.87940917e-03f,
  -1.24775276e-01f, -7.18108192e-02f, 9.91739929e-02f, 9.03823376e-02f, 5.61572611e-02f, -1.76723167e-01f, -1.86299812e-02f, -5.49975261e-02f, 5.71991429e-02f, -2.20862450e-03f,
  1.64411217e-01f, -2.24510413e-02f, 9.31074992e-02f, -1.13999462e-02f, -4.46126936e-03f, -1.08191125e-01f, -8.33743811e-02f, -1.56334892e-01f, -1.48179114e-01f, -9.46633145e-02f,
  2.04775348e-01f, 1.58833519e-01f, -1.32844165e-01f, -1.11046143e-01f, -2.21336275e-01f, -8.87757912e-02f, -1.20910749e-01f, -1.55655012e-01f, -2.98633426e-01f, -2.47606531e-01f,
  3.78832929e-02f, 6.35680109e-02f, 1.25324115e-01f, 2.66298335e-02f, 6.13551363e-02f, 8.92354771e-02f, -5.17467149e-02f, 2.32416000e-02f, 2.17593908e-02f, -1.44345323e-02f,
  6.55761361e-02f, -7.67425343e-04f, -6.14911094e-02f, -4.64397334e-02f, -1.54791564e-01f, 5.98745160e-02f, -1.33280866e-02f, -8.34307820e-02f, -1.33961499e-01f, -4.99957018e-02f,
  -7.86385313e-02f, -5.89423515e-02f, 9.61805657e-02f, -4.27363031e-02f, -2.72137746e-02f, -9.95734334e-02f, 2.70999316e-02f, -1.30588245e-02f, -2.64081974e-02f, -2.17102822e-02f,
  2.23588515e-02f, -5.29708527e-02f, -3.27010043e-02f, -7.35420361e-02f, 7.72030503e-02f, 1.04289204e-01f, 1.02427728e-01f, -1.02344327e-01f, 5.00331409e-02f, -8.28266665e-02f,
  -1.09124929e-01f, -5.69702648e-02f, 4.95366789e-02f, 1.19937472e-02f, -5.29906675e-02f, -1.44498914e-01f, -6.83598444e-02f, -3.44447754e-02f, 1.04518775e-02f, 1.16332896e-01f,
  1.10922381e-02f, -7.32024834e-02f, -1.71307221e-01f, -9.94310156e-02f, -9.33253169e-02f, -2.39877924e-01f, -2.04551384e-01f, -2.24312216e-01f, -3.51709485e-01f, -3.70986342e-01f,
  -2.12871537e-01f, 5.41797765e-02f, 1.06731340e-01f, 1.32143915e-01f, 4.55235243e-01f, 1.77581459e-02f, -3.00996959e-01f, -3.57999265e-01f, -7.11434111e-02f, 3.15841138e-02f,
  2.61201680e-01f, 2.16216356e-01f, 9.58318710e-02f, -3.98477120e-03f, -2.07700461e-01f, -1.56865254e-01f, 3.53618115e-02f, -1.34599850e-01f, -1.52442351e-01f, 4.22829092e-02f,
  2.16340199e-01f, 6.30453005e-02f, -6.20241463e-02f, -7.34248757e-02f, 1.23929620e-01f, 1.61337972e-01f, 6.92385659e-02f, 2.05540508e-01f, 1.20678984e-01f, 6.78773001e-02f,
  5.41853756e-02f, -1.59260318e-01f, -5.34030423e-02f, 1.20605007e-01f, 2.86742270e-01f, -2.12037191e-01f, -1.50500700e-01f, -1.32551432e-01f, -1.20167509e-01f, -1.38650775e-01f,
  2.20464557e-01f, 1.12315118e-02f, 7.59725645e-02f, -5.87114468e-02f, -1.60319451e-02f, -1.11388743e-01f, -9.41839144e-02f, -2.38953561e-01f, -2.10697606e-01f, -1.19672887e-01f,
  1.47849396e-01f, 2.37127095e-01f, 6.92706183e-02f, -1.10634431e-01f, -1.79023564e-01f, 1.35364935e-01f, -3.98566425e-02f, -1.15683004e-01f, -2.40112901e-01f, -1.99062958e-01f,
  1.03473991e-01f, 1.15977041e-01f, 2.32879221e-02f, 2.82909647e-02f, -3.25048156e-02f, 4.13586348e-02f, 1.07115857e-01f, 5.12197576e-02f, 5.45281582e-02f, -8.37777741e-03f,
  2.05447432e-02f, 2.84589659e-02f, 2.79740859e-02f, -4.29416373e-02f, 7.15948790e-02f, 1.13913873e-02f, -3.27335633e-02f, -8.23502988e-02f, 4.28284332e-02f, 4.52753669e-03f,
  7.48321563e-02f, -2.53546913e-03f, 1.03634402e-01f, -6.86269328e-02f, 6.93471804e-02f, 3.93917523e-02f, 5.14847822e-02f, 6.11969307e-02f, 1.02308795e-01f, 7.74633586e-02f,
  -6.57213628e-02f, -2.03912631e-02f, -8.29473957e-02f, -7.59739578e-02f, 5.67224659e-02f, 4.28076088e-02f, -5.47954924e-02f, -6.47915453e-02f, 7.55944150e-03f, -1.06423415e-01f,
  -6.79225475e-02f, -9.72616598e-02f, 1.15765752e-02f, -7.31650144e-02f, -1.00428008e-01f, -2.66641900e-02f, 1.19049914e-01f, 4.62648310e-02f, -9.22017843e-02f, -4.26070485e-03f,
  6.31678011e-03f, -1.20029725e-01f, -5.27049340e-02f, -1.07743151e-01f, 1.11700818e-02f, 8.60648416e-03f, -8.22236612e-02f, -1.66332871e-01f, -2.01997086e-01f, -2.40600809e-01f,
  -2.73788571e-01f, -2.67239541e-01f, 2.38629803e-02f, 1.32207230e-01f, 5.95636703e-02f, 4.11846042e-02f, -3.65415290e-02f, 6.41519651e-02f, 1.25653729e-01f, -8.43309909e-02f,
  -2.07240075e-01f, -6.59030452e-02f, -1.73951089e-01f, -1.32353127e-01f, -4.69295029e-03f, 1.75408185e-01f, 1.32649198e-01f, 1.27856970e-01f, 6.71911472e-03f, 4.13782801e-03f,
  4.71037328e-02f, -6.04051761e-02f, 4.41823527e-02f, -7.42010623e-02f, -7.70802721e-02f, -6.29282817e-02f, 8.93304870e-02f, 3.68426926e-02f, -1.63408518e-02f, 6.94481134e-02f,
  6.83424762e-03f, -6.61192164e-02f, 6.49191439e-02f, -1.42670795e-01f, -8.10934082e-02f, -1.28759846e-01f, -1.81437116e-02f, 4.03781496e-02f, 5.57986163e-02f, 6.19267486e-02f,
  9.20207202e-02f, 1.47198914e-02f, 2.48693265e-02f, -9.27165225e-02f, -5.64082898e-02f, -1.04261860e-01f, -9.91550460e-03f, 1.35810748e-02f, 1.12697825e-01f, -6.51212931e-02f,
  6.48085168e-03f, -1.01103581e-01f, 1.28460050e-01f, -9.32859182e-02f, -2.47815456e-02f, -5.56743816e-02f, -1.51296556e-01f, -7.63651207e-02f, -3.40961143e-02f, -1.24484442e-01f,
  -5.50486855e-02f, 8.34542289e-02f, -6.05691560e-02f, -2.87437383e-02f, 3.16616893e-02f, 7.37157613e-02f, 5.23106866e-02f, -1.89512670e-02f, -3.26473676e-02f, 2.22306140e-02f,
  6.46178052e-02f, 5.11970706e-02f, 6.38440326e-02f, -1.92369483e-02f, 7.94472769e-02f, 8.66634324e-02f, 7.91238844e-02f, -2.86616217e-02f, 9.23435166e-02f, 5.15499301e-02f,
  1.69416051e-02f, 6.87952489e-02f, -2.56078877e-03f, 1.00091368e-01f, -7.80447125e-02f, 1.21309226e-04f, 3.68554704e-02f, -1.28234783e-02f, -2.10651830e-02f, 2.48470940e-02f,
  9.86982509e-02f, -2.90259663e-02f, -1.37686124e-02f, 8.08884054e-02f, -6.54244870e-02f, -5.91970906e-02f, 3.77456658e-02f, -5.34808487e-02f, -5.40555315e-03f, 1.23510912e-01f,
  2.79011056e-02f, 1.49224950e-02f, 1.41628250e-03f, -9.42132920e-02f, -3.54735740e-02f, -1.06100678e-01f, -9.38334540e-02f, -1.71870850e-02f, 3.08256298e-02f, 2.01856531e-03f,
  6.42039999e-02f, 8.27829540e-03f, -4.25130688e-02f, -3.80520597e-02f, -3.94926034e-02f, -6.93557933e-02f, -3.48941572e-02f, 2.27627512e-02f, -6.11039288e-02f, -1.36000440e-01f,
  3.74291539e-01f, -2.22161785e-01f, -4.82498169e-01f, 2.43813127e-01f, -1.70034721e-01f, -1.38902500e-01f, -3.91547568e-02f, 2.83399820e-01f, 2.24615395e-01f, 1.31511539e-02f,
  -1.99922815e-01f, -5.75183854e-02f, -1.19446486e-01f, -1.37255415e-01f, -2.12195539e-03f, -1.27340838e-01f, -1.06654294e-01f, -1.26062766e-01f, -4.96480428e-02f, 3.13627049e-02f,
  -1.98139809e-02f, 1.86066955e-01f, 1.51301697e-01f, 1.22308947e-01f, 2.58230940e-02f, -4.85310555e-02f, -1.21930115e-01f, -3.99065390e-02f, -2.14485824e-01f, -2.04983816e-01f,
  -1.48005830e-02f, 3.91119672e-03f, -5.43381609e-02f, 2.55998527e-03f, -7.59173334e-02f, 5.26521988e-02f, -4.88954447e-02f, -5.17310463e-02f, -1.06259577e-01f, -1.08314157e-01f,
  -2.92685300e-01f, -1.25807419e-01f, -7.91618824e-02f, -8.83150622e-02f, 1.89086683e-02f, -1.96391754e-02f, -9.98716503e-02f, -1.87221855e-01f, -6.37991428e-02f, -1.35740682e-01f,
  -2.70351797e-01f, -3.01112413e-01f, -1.39933065e-01f, -7.55398944e-02f, -7.90838245e-03f, -2.01701790e-01f, -1.58262387e-01f, -1.01567946e-01f, -2.46810876e-02f, 1.16862088e-01f,
  1.37722909e-01f, 7.68055394e-02f, -5.63528799e-02f, 5.36305085e-02f, 7.59041309e-02f, -8.58540367e-03f, 1.37366638e-01f, 4.62093800e-02f, 2.06663869e-02f, -4.75582145e-02f,
  -9.87946708e-03f, 2.32845545e-02f, 5.29332124e-02f, 5.60304103e-03f, -6.63686171e-02f, 3.59289385e-02f, -8.14387649e-02f, 2.81995907e-02f, -8.58060829e-03f, 7.35090971e-02f,
  -9.87462979e-03f, -1.30356727e-02f, -4.82759178e-02f, -2.37104297e-02f, -1.14861719e-01f, -5.74637763e-02f, -5.11952564e-02f, 2.78055258e-02f, 3.76460887e-02f, -2.60184202e-02f,
  3.27741325e-01f, -2.16249004e-01f, 1.30486161e-01f, 4.70131338e-02f, 3.60958241e-02f, -7.12625757e-02f, -2.36292221e-02f, 6.10631220e-02f, -5.36819026e-02f, -9.34190452e-02f,
  -1.40631482e-01f, -2.01035328e-02f, -5.29610626e-02f, -3.17618288e-02f, 1.40030924e-02f, -7.63177574e-02f, 1.88013241e-02f, -1.29567683e-01f, -1.23039493e-02f, 3.12815495e-02f,
  9.24699977e-02f, 8.38407800e-02f, 2.01390654e-01f, -8.45994130e-02f, 1.12767138e-01f, 1.68535605e-01f, -1.02024879e-02f, 1.35186538e-01f, 1.58022508e-01f, 2.86515981e-01f,
  -5.07101677e-02f, -1.35301603e-02f, -1.31158769e-01f, 9.34371278e-02f, 1.77495256e-01f, -1.90600350e-01f, -2.15030596e-01f, -2.48731703e-01f, 1.36412156e-03f, 3.25095952e-02f,
  1.83943033e-01f, 2.52778381e-01f, 1.23640396e-01f, 1.48335978e-01f, -6.13372102e-02f, -1.04107171e-01f, 6.25451058e-02f, 9.09305513e-02f, 5.74559011e-02f, 2.13042200e-01f,
  3.34679425e-01f, 2.17200235e-01f, 6.36494905e-02f, 6.44246787e-02f, 2.54563510e-01f, 2.09204257e-01f, 7.23674670e-02f, 1.03093088e-01f, 1.16094247e-01f, 3.40196431e-01f,
  2.26340130e-01f, -1.31977335e-01f, -3.73644121e-02f, -1.57429103e-03f, 8.19622576e-02f, -9.98813435e-02f, -1.99153665e-02f, -8.56520385e-02f, -2.04012655e-02f, -8.89264345e-02f,
  8.56853127e-02f, -7.29780272e-02f, 6.78122938e-02f, -8.70816559e-02f, -3.39974798e-02f, -8.99949297e-02f, -4.44093607e-02f, -8.96133482e-02f, -1.44281685e-01f, 4.84235497e-04f,
  2.70437092e-01f, 1.29511207e-01f, -1.81214940e-02f, -1.63921744e-01f, -6.50193542e-02f, 1.39136374e-01f, -1.09571606e-01f, -9.39066112e-02f, -1.36077672e-01f, 1.43501014e-02f,
  -7.08397757e-03f, -5.68978041e-02f, 5.24726987e-04f, 2.76831072e-02f, 4.48338985e-02f, 4.16968092e-02f, 2.68000420e-02f, 1.10818155e-01f, -2.48181541e-02f, 6.21759668e-02f,
  1.18662834e-01f, 2.66353600e-02f, 7.57363364e-02f, 5.61045893e-02f, 1.99132804e-02f, 2.95889750e-02f, 1.29901782e-01f, 4.62406175e-03f, 8.24937597e-02f, -5.89141622e-02f,
  1.23814102e-02f, -1.26068434e-02f, 1.66461002e-02f, 5.85685251e-03f, 4.85099852e-02f, 1.89395081e-02f, 7.44966418e-02f, 5.66086434e-02f, 5.62713817e-02f, 5.75940534e-02f,
  -1.23645857e-01f, -2.07733467e-01f, -3.52271926e-03f, -5.42714335e-02f, 7.35755451e-03f, -1.03903469e-02f, 4.94205505e-02f, -4.78122234e-02f, 2.49404386e-02f, -6.20382428e-02f,
  -6.58152103e-02f, -4.81796339e-02f, -1.30536094e-01f, -7.85886049e-02f, 3.39617692e-02f, -9.89384502e-02f, 1.79846063e-02f, -2.90271677e-02f, -7.72084445e-02f, -8.17954764e-02f,
  -8.03350061e-02f, -6.62397593e-02f, 1.22070229e-02f, -7.82666802e-02f, -7.49941841e-02f, -3.20409946e-02f, 3.86048444e-02f, -7.27074593e-03f, -1.02103941e-01f, -1.03989214e-01f,
  5.37921190e-01f, -2.71717370e-01f, -5.52512348e-01f, 1.14756353e-01f, -2.11962715e-01f, -3.39302272e-01f, -3.92251670e-01f, -9.82939601e-02f, 5.30001074e-02f, -3.09548885e-01f,
  -1.33639380e-01f, 9.40263122e-02f, -7.95689747e-02f, -4.60929014e-02f, 4.08891886e-02f, -3.70460689e-01f, -3.43371898e-01f, -2.65931990e-02f, 1.22389220e-01f, 8.47065896e-02f,
  2.76983604e-02f, 1.90797761e-01f, 2.66533345e-01f, 2.08350495e-02f, -1.09186456e-01f, -4.73303124e-02f, -3.37029219e-01f, -1.08043492e-01f, -1.96143106e-01f, -2.58621633e-01f,
  -2.17869818e-01f, -1.25709429e-01f, -8.16523135e-02f, 1.38636485e-01f, -7.24040270e-02f, 4.45601158e-02f, -6.55429959e-02f, 2.70127319e-02f, 6.97337687e-02f, -1.45077378e-01f,
  -3.44485007e-02f, 1.76009778e-02f, 1.08485343e-03f, -5.20974398e-02f, -6.61066622e-02f, 5.18564992e-02f, 5.37619442e-02f, -1.72105022e-02f, -1.13329358e-01f, -4.04702388e-02f,
  -3.57319340e-02f, -1.84306335e-02f, -8.18912312e-02f, -1.03335358e-01f, -5.08843809e-02f, -3.12924013e-02f, -7.75864273e-02f, -8.89976230e-03f, -6.79368600e-02f, -7.73168802e-02f,
  -1.85796276e-01f, -1.59679756e-01f, -7.18513206e-02f, 5.78388385e-02f, 3.34060900e-02f, -7.85286278e-02f, -9.68795922e-03f, -4.80254218e-02f, -4.71291505e-02f, 1.76376104e-02f,
  -2.85412185e-03f, -3.67409289e-02f, 5.01419650e-03f, -4.02551144e-02f, 3.31950299e-02f, -1.56359766e-02f, -4.36635725e-02f, -3.69354971e-02f, -1.35425348e-02f, 8.47506225e-02f,
  4.31062616e-02f, 1.85296417e-03f, -2.28687655e-02f, 1.79130584e-02f, -9.94338468e-02f, -1.13614537e-01f, -5.74900508e-02f, -1.86047778e-02f, 3.07821110e-03f, -5.38776740e-02f,
  7.14361742e-02f, -1.55782178e-01f, -8.89574736e-02f, -2.39580008e-03f, -1.45225823e-01f, -1.02485843e-01f, -1.38270199e-01f, 6.28173724e-02f, 1.07325222e-02f, -9.13342237e-02f,
  -1.27019078e-01f, 2.74569690e-02f, -1.20197207e-01f, 5.25838174e-02f, -5.16762547e-02f, 3.39348279e-02f, 1.02800645e-01f, -6.80528358e-02f, -3.02439518e-02f, -3.13821249e-03f,
  6.94571435e-02f, 8.54960680e-02f, 2.12752506e-01f, 5.83102629e-02f, 6.19914941e-02f, 6.81155026e-02f, -9.07274783e-02f, -5.29651493e-02f, 1.01425191e-02f, 4.92885001e-02f,
  -3.64266425e-01f, -5.24504995e-03f, -6.18405938e-01f, -1.10227158e-02f, 1.95151865e-01f, 5.63665517e-02f, 1.84301361e-01f, 3.31687182e-02f, 9.23809633e-02f, 1.12857588e-03f,
  1.06845126e-02f, 7.07358494e-02f, -3.59044410e-02f, 5.38095608e-02f, 3.62715125e-03f, 3.33449692e-02f, 7.50499889e-02f, -1.50014177e-01f, 1.33982962e-02f, 3.48802179e-01f,
  3.96589130e-01f, 6.39505982e-02f, -1.28149316e-01f, 3.57244052e-02f, 8.94811377e-02f, 8.71603787e-02f, -1.66087463e-01f, 3.95688713e-02f, 1.04344413e-01f, 3.13785374e-02f,
  -4.00918543e-01f, -3.15520406e-01f, -1.88059397e-02f, 8.49263817e-02f, -1.04620516e-01f, -1.40948176e-01f, -3.65164354e-02f, -1.89168558e-01f, -2.89479159e-02f, -2.58550551e-02f,
  -7.60050640e-02f, -1.23306200e-01f, 8.43224525e-02f, 4.31948788e-02f, 6.55642450e-02f, -6.20624050e-02f, -6.91215619e-02f, -1.66573897e-01f, -3.12915713e-01f, -2.70606875e-01f,
  2.86010832e-01f, -4.57562245e-02f, -3.34996969e-01f, -8.29233825e-02f, -2.04964831e-01f, -1.15557693e-01f, -2.22717896e-01f, -9.94018465e-02f, -3.15772682e-01f, -2.19857275e-01f,
  1.27070146e-02f, 4.17820401e-02f, -1.71539132e-02f, -6.24647066e-02f, 1.65617213e-01f, 1.60748027e-02f, 5.03985137e-02f, 9.74717215e-02f, 2.63497811e-02f, -6.57740906e-02f,
  -1.50991818e-02f, -1.97091065e-02f, -6.01429902e-02f, -1.46144658e-01f, 9.68117490e-02f, -1.17418692e-01f, -1.20711541e-02f, 5.83953261e-02f, -2.81715039e-02f, -2.81301793e-02f,
  8.21030438e-02f, -4.73014861e-02f, -9.87515785e-03f, 3.08770854e-02f, 6.09052740e-02f, -9.50904191e-02f, 2.62090079e-02f, 4.23052572e-02f, 4.94820401e-02f, -2.88773086e-02f,
  6.99203014e-02f, -4.43283282e-02f, -8.16204622e-02f, 4.98610064e-02f, -3.67492326e-02f, -1.99024081e-02f, 5.47813764e-03f, 2.46236660e-02f, -7.09698200e-02f, -1.49299875e-02f,
  3.51172350e-02f, 4.69626114e-02f, 1.43137693e-01f, 5.90502098e-02f, -2.53635761e-03f, 1.04735708e-02f, 1.16044551e-01f, -2.44745184e-02f, 2.93651465e-02f, -7.19509795e-02f,
  4.19645868e-02f, 8.79490525e-02f, -1.20514132e-01f, -4.91868705e-02f, -6.55155769e-03f, 2.68446617e-02f, -1.46922871e-01f, 2.71654539e-02f, -1.80993125e-01f, -8.08486640e-02f,
  3.19566756e-01f, -1.28701240e-01f, 1.82658769e-02f, 1.07496649e-01f, 2.40106985e-01f, 1.79734185e-01f, 3.42520028e-02f, -3.31633650e-02f, 8.48048925e-02f, 9.77958590e-02f,
  2.16130376e-01f, 1.88731477e-01f, 6.48583025e-02f, 1.22592822e-01f, -9.26245097e-03f, -5.94057627e-02f, -2.94633415e-02f, 3.81642245e-02f, 5.08594736e-02f, -1.39864190e-02f,
  9.38973669e-03f, 1.06492136e-02f, 1.58343874e-02f, 8.25267807e-02f, 8.54031816e-02f, 1.55051470e-01f, 9.04996917e-02f, 5.25494330e-02f, -4.40139174e-02f, -8.78087431e-02f,
  -1.75892442e-01f, 1.13781942e-02f, 1.34429693e-01f, 7.41122365e-02f, -2.49135923e-02f, -3.44336927e-02f, -2.85029467e-02f, -8.01700205e-02f, -8.25554132e-02f, -1.81170821e-01f,
  3.56038264e-03f, 2.62336805e-02f, 3.75303440e-02f, -4.24751341e-02f, 2.52964702e-02f, 9.69580486e-02f, 1.72551870e-02f, 3.01510911e-04f, -1.60829112e-01f, -5.33054695e-02f,
  -6.92469701e-02f, 7.75554031e-02f, 4.59651016e-02f, -5.29939367e-04f, 8.59874263e-02f, -8.70658201e-04f, -2.54285745e-02f, -1.24843707e-02f, 2.40051523e-02f, 3.20797190e-02f,
  1.70307338e-01f, 2.84100443e-01f, 1.78763524e-01f, 7.71018639e-02f, 1.38071507e-01f, 1.95680130e-02f, 5.24239317e-02f, 1.41397327e-01f, 2.09085166e-01f, 1.34212166e-01f,
  1.26174301e-01f, 1.51600957e-01f, 6.89074993e-02f, 1.45374149e-01f, 9.62865874e-02f, 7.61563554e-02f, 8.10511038e-02f, 6.17852025e-02f, 1.79080665e-01f, 1.30309230e-02f,
  1.03209592e-01f, 1.21112704e-01f, 1.44315273e-01f, -3.50068323e-03f, -4.79696542e-02f, 1.03014335e-01f, 1.78422108e-01f, 1.81899920e-01f, 1.91098273e-01f, 2.01001287e-01f,
  -1.47950709e-01f, 1.84083790e-01f, -3.31712514e-02f, -2.45356672e-02f, -1.64788906e-02f, -7.43474290e-02f, 5.84746040e-02f, -1.56175032e-01f, -8.83344337e-02f, -2.02353776e-01f,
  -5.97240403e-02f, 4.60288525e-02f, 6.15308769e-02f, -4.22551408e-02f, 1.05447493e-01f, -5.33363447e-02f, 8.78171325e-02f, 3.49811167e-02f, -4.99385409e-02f, -1.26569718e-01f,
  -5.72637357e-02f, 6.38314635e-02f, 7.52557442e-02f, -5.89909293e-02f, 9.01803523e-02f, 1.75022006e-01f, 2.27830503e-02f, -6.22017011e-02f, -7.02911150e-03f, 2.55673425e-03f,
  2.03371167e-01f, 3.83264333e-01f, -5.90421893e-02f, -1.05575375e-01f, -1.50912032e-01f, -3.15330029e-02f, 3.11493993e-01f, 1.64831996e-01f, -2.43528366e-01f, 8.24469235e-03f,
  -1.64098479e-02f, -2.83692598e-01f, -2.93542713e-01f, -1.32262066e-01f, 9.58250239e-02f, 5.70758060e-02f, 8.01349524e-03f, 1.06035667e-02f, -1.09886982e-01f, -2.15734672e-02f,
  -6.60009682e-02f, 1.72988966e-01f, 2.71595180e-01f, 9.47690159e-02f, -1.78040788e-01f, -1.80587322e-01f, -3.54698091e-03f, 1.16375029e-01f, 5.49785607e-02f, -2.06294298e-01f,
  5.36978990e-02f, 1.95229337e-01f, -7.22462758e-02f, -8.38747323e-02f, 8.90820026e-02f, 1.56431735e-01f, 1.50644584e-02f, 5.29270396e-02f, 3.48419398e-02f, 1.10954382e-01f,
  4.51002605e-02f, 1.01598218e-01f, 1.00940332e-01f, 7.84286559e-02f, 1.49108157e-01f, -2.25851368e-02f, -5.14498167e-02f, 3.13014165e-02f, -3.60231125e-03f, -1.76843852e-02f,
  -2.02385336e-01f, -4.16472778e-02f, -1.19718328e-01f, 1.83819961e-02f, -1.09373428e-01f, -1.71886519e-01f, -8.20817798e-02f, -7.52999410e-02f, -2.31041927e-02f, -1.12833947e-01f,
  -4.20587845e-02f, 5.53886890e-02f, 6.45804103e-04f, 6.89251870e-02f, 1.66353717e-01f, 5.83976880e-02f, 1.30291849e-01f, 1.39066279e-01f, 1.10559523e-01f, 1.89975604e-01f,
  8.21904615e-02f, 2.39603579e-01f, 2.72970796e-01f, 1.73614085e-01f, -1.23279709e-02f, 8.83149356e-02f, 8.62583220e-02f, 6.73532113e-02f, 6.17159978e-02f, 1.88491479e-01f,
  9.82399955e-02f, 1.05412463e-02f, 1.42759398e-01f, 2.29527846e-01f, -6.24946272e-03f, -2.66831610e-02f, 8.27616975e-02f, 1.25014082e-01f, 3.45829241e-02f, -6.94809994e-03f,
  1.91747814e-01f, -2.89102569e-02f, -6.59739822e-02f, -1.55965254e-01f, -8.19888338e-02f, -5.20950668e-02f, -1.99944954e-02f, -5.35240732e-02f, 1.03201576e-01f, 7.40782693e-02f,
  4.48789634e-02f, 8.42750669e-02f, 1.93162128e-01f, 1.10883899e-01f, -3.08413338e-02f, -5.19430190e-02f, -5.58049828e-02f, -2.19023824e-01f, -1.88641652e-01f, -9.37409699e-02f,
  -2.64444593e-02f, -4.27549258e-02f, -2.60971546e-01f, -1.75351903e-01f, -1.32231221e-01f, -2.79820293e-01f, 1.17414875e-03f, -1.53720140e-01f, -8.31460208e-02f, 9.58708152e-02f,
  5.02797008e-01f, -5.26464246e-02f, 6.60526827e-02f, 5.38281947e-02f, -1.28056586e-01f, -2.11718887e-01f, -4.49643940e-01f, -1.72047973e-01f, -2.37939134e-02f, -2.46050939e-01f,
  3.70762567e-03f, 3.34985763e-01f, 3.01253974e-01f, 7.01507032e-02f, 2.02437341e-02f, -3.50560814e-01f, -3.59772623e-01f, 1.97039694e-02f, -1.25265270e-01f, -3.40085864e-01f,
  -2.36062825e-01f, -2.12537333e-01f, -8.60002935e-02f, -1.07262805e-01f, -2.86249101e-01f, 5.27054444e-02f, -1.57024398e-01f, -1.20345131e-01f, -1.52797371e-01f, -1.38466164e-01f,
  -8.68590027e-02f, -1.98990759e-02f, -8.23924989e-02f, -5.21621257e-02f, -1.01521745e-01f, 5.53335622e-02f, 4.33831401e-02f, -8.73801038e-02f, 3.48182358e-02f, -4.12873849e-02f,
  7.06793740e-02f, 2.94025596e-02f, 9.25355405e-02f, 1.33669907e-02f, -1.62817016e-01f, -7.94105977e-02f, -1.70058519e-01f, -1.12743013e-01f, 9.36403405e-03f, -2.14754820e-01f,
  -1.20265268e-01f, -6.52657868e-03f, 1.20608248e-01f, -8.14478323e-02f, -1.71958171e-02f, 1.76170349e-01f, -1.10863283e-01f, -9.16555617e-03f, 4.35723327e-02f, -1.11700058e-01f,
  -1.56213582e-01f, 4.93850820e-02f, -1.21705651e-01f, -1.26211539e-01f, -6.12933524e-02f, -3.48782949e-02f, 3.58349867e-02f, -7.09503815e-02f, -6.25571981e-02f, -4.16020080e-02f,
  -1.11303362e-03f, -3.69974896e-02f, -8.49776864e-02f, -1.86036248e-02f, -2.44391710e-02f, 4.43351269e-02f, 2.64499430e-02f, -1.21979348e-01f, -1.17616300e-02f, 6.56534135e-02f,
  1.27645219e-02f, -2.60116090e-03f, 3.50142568e-02f, -6.33508340e-02f, -4.92011718e-02f, -4.76116501e-03f, 6.25954792e-02f, -1.91266276e-02f, 3.54318246e-02f, -1.29182469e-02f,
  2.07338154e-01f, 1.70795813e-01f, 1.31062919e-03f, -7.46659040e-02f, -2.29358897e-02f, -3.66540849e-02f, 8.75107124e-02f, -1.00783534e-01f, 7.81106502e-02f, 8.76736268e-02f,
  -1.67947203e-01f, 4.94219363e-02f, 1.32609755e-01f, 7.43458141e-03f, -1.50036320e-01f, -1.29455820e-01f, -1.41062424e-01f, -3.57184783e-02f, -4.13078740e-02f, -1.51989460e-01f,
  -1.84342682e-01f, -1.24320865e-01f, 1.91356346e-01f, 9.18549895e-02f, -3.92610729e-02f, 1.25070363e-01f, -5.02789244e-02f, -3.90168354e-02f, 2.05604419e-01f, -1.46652460e-01f,
  3.77939999e-01f, 2.94729531e-01f, -2.20558465e-01f, 2.82994863e-02f, -2.41043083e-02f, 3.17661986e-02f, 4.21533406e-01f, 2.93745160e-01f, 5.58951981e-02f, 7.78865740e-02f,
  -6.02826774e-02f, -3.07369769e-01f, -2.52362937e-01f, -3.19171607e-01f, -9.08950120e-02f, -1.20622814e-02f, -8.10062066e-02f, -3.38151008e-01f, -2.39295438e-01f, 5.05529009e-02f,
  9.04922187e-02f, 2.99989849e-01f, 2.31391951e-01f, 6.76569417e-02f, 2.26761773e-02f, -1.81595609e-01f, 1.50317103e-01f, 4.79130298e-02f, -1.27007395e-01f, -4.17728364e-01f,
  -2.03232720e-01f, 2.63142824e-01f, -1.63856313e-01f, 1.60116971e-01f, -7.05030654e-03f, -2.61198189e-02f, 4.53448370e-02f, -2.75150053e-02f, 3.74853164e-02f, -3.53124142e-02f,
  1.10160507e-01f, -2.02620798e-03f, -3.37603986e-02f, 1.88163370e-02f, 1.75014123e-01f, -4.05807830e-02f, 2.42181927e-01f, -8.34573656e-02f, -1.03111550e-01f, 2.84261499e-02f,
  -1.39381751e-01f, 9.40887108e-02f, 1.79339722e-01f, -1.60276908e-02f, -1.73279136e-01f, -1.92650318e-01f, 9.08965915e-02f, -1.32456884e-01f, -1.47955388e-01f, 5.01071103e-02f,
  -1.21354677e-01f, -1.60602987e-01f, 8.01603347e-02f, 6.70955479e-02f, 7.65532330e-02f, -1.42759144e-01f, -1.54750898e-01f, -1.31384015e-01f, -4.62247506e-02f, 1.97346807e-01f,
  -1.50849476e-01f, -2.50793397e-01f, -2.13618830e-01f, 7.10561266e-03f, -1.56904638e-01f, -6.05716296e-02f, -2.72017960e-02f, -8.66876841e-02f, -5.82370646e-02f, 1.01700671e-01f,
  -1.10899378e-02f, -2.14907713e-02f, -9.74830240e-03f, 1.58959460e-02f, 1.21126547e-02f, -3.77538651e-02f, -9.30180550e-02f, -2.97709480e-02f, 9.01753176e-03f, 1.90040663e-01f,
  7.64408112e-02f, -1.04457894e-02f, -3.06807943e-02f, 1.38594583e-02f, -8.66004899e-02f, -5.11798449e-02f, -2.22395033e-01f, -7.47943521e-02f, -1.08104840e-01f, -6.53074086e-02f,
  -2.53573880e-02f, -1.60617024e-01f, -4.24328670e-02f, -5.93031421e-02f, -3.91623862e-02f, -9.54270214e-02f, 1.06689576e-02f, -1.08774215e-01f, -1.62408620e-01f, -4.39695790e-02f,
  -3.06779519e-02f, 1.47559986e-01f, 4.87501435e-02f, -9.36416090e-02f, -1.28014281e-01f, 1.03697749e-02f, -2.81362366e-02f, 7.48530701e-02f, 6.58567622e-02f, 2.37723142e-01f,
  5.79109132e-01f, 3.82588059e-01f, 3.43151450e-01f, 2.95559794e-01f, 2.21600868e-02f, -1.79954879e-02f, 7.50167444e-02f, 5.08485436e-02f, 5.43528162e-02f, 1.86700851e-01f,
  9.27670822e-02f, -2.79299077e-03f, 7.34493881e-02f, 5.29277101e-02f, -3.09105907e-02f, -1.38613926e-02f, -7.74988383e-02f, 1.35337219e-01f, 4.35898043e-02f, 7.03502074e-02f,
  1.12175293e-01f, 9.22293290e-02f, 1.11360595e-01f, 1.70889601e-01f, 1.94436476e-01f, 1.07385768e-02f, 5.67137599e-02f, 1.13780707e-01f, 1.12823643e-01f, 2.12065607e-01f,
  1.80033874e-02f, 3.29895318e-01f, -2.50398457e-01f, -4.53041270e-02f, -4.35445532e-02f, -5.14424918e-03f, -1.77387353e-02f, -3.57611291e-02f, -7.37964362e-02f, -4.22613285e-02f,
  2.81867888e-02f, 5.81876300e-02f, 6.14886656e-02f, 1.14169139e-02f, 2.09189411e-02f, -7.49827130e-03f, -5.98338321e-02f, 1.04897402e-01f, -2.51520947e-02f, 1.44075239e-02f,
  6.96174130e-02f, 1.46654323e-01f, 1.51275331e-02f, -9.04375240e-02f, 1.49585709e-01f, 3.49531472e-02f, 8.38557705e-02f, 1.55770540e-01f, 1.10237397e-01f, 1.32068336e-01f,
  1.45736828e-01f, 2.64131129e-01f, 1.39741942e-01f, 9.48936865e-02f, 2.93046497e-02f, 2.83403546e-02f, 3.20705362e-02f, -1.78827737e-02f, 2.37410190e-03f, 6.02011867e-02f,
  6.35332465e-02f, 1.19515918e-01f, -9.60686151e-03f, 7.90469907e-03f, -6.07312694e-02f, 6.74155280e-02f, 3.75319049e-02f, 6.17017522e-02f, -2.02929471e-02f, -2.58874949e-02f,
  5.00994511e-02f, -1.04765236e-01f, -6.30660653e-02f, 1.39314765e-02f, -7.65619576e-02f, 9.15090442e-02f, -4.39284258e-02f, 5.66599406e-02f, 1.03725374e-01f, -7.79556930e-02f,
  -6.12249255e-01f, -2.16626719e-01f, -3.27726230e-02f, -1.32792488e-01f, 1.17368430e-01f, -8.62924103e-03f, 7.56619796e-02f, 1.12779280e-02f, -1.55455008e-01f, -1.73790485e-01f,
  -4.23516072e-02f, -1.46685326e-02f, 5.20249549e-03f, -1.95291732e-02f, -2.02465132e-01f, -2.13833496e-01f, -3.19251418e-02f, -1.27477944e-01f, -3.94010767e-02f, -9.39773917e-02f,
  -1.08506210e-01f, -1.33118957e-01f, -1.97117969e-01f, -1.77864388e-01f, -5.92398942e-02f, -6.84259459e-02f, -5.03770076e-02f, -5.42865396e-02f, -8.57497975e-02f, -2.42400300e-02f,
  -8.21125269e-01f, 1.01976156e-01f, 6.87285736e-02f, -3.31697434e-01f, -7.76400343e-02f, -1.98431760e-01f, -7.90670589e-02f, -6.41559735e-02f, 2.92796530e-02f, 1.99311912e-01f,
  6.28557056e-02f, -2.02873170e-01f, -1.58620432e-01f, -2.13771686e-01f, -3.02947700e-01f, 8.70768726e-02f, -1.00695506e-01f, -4.75198358e-01f, -6.98743045e-01f, -4.86477196e-01f,
  -3.76709461e-01f, -5.57767689e-01f, -6.11073852e-01f, -3.61720324e-01f, 5.93336485e-03f, -2.13172421e-01f, -4.21672799e-02f, -2.10689053e-01f, -1.63175672e-01f, -8.81825611e-02f,
  2.06356823e-01f, -1.32355899e-01f, -1.16433501e-01f, 1.91509537e-03f, 6.01878539e-02f, 4.89645302e-02f, -5.11042848e-02f, 1.01205707e-01f, -9.89741646e-03f, 6.44124597e-02f,
  4.10774611e-02f, 7.41664395e-02f, -3.13476510e-02f, -3.41438018e-02f, -1.13997415e-01f, -3.26796994e-02f, 1.69937372e-01f, -6.75670877e-02f, 5.87754250e-02f, 1.86671019e-01f,
  2.13781521e-01f, 8.04062635e-02f, 3.53822373e-02f, 1.87696442e-01f, 7.40986019e-02f, -1.73926111e-02f, 1.48198441e-01f, 2.61563323e-02f, -8.33899528e-03f, 4.11125422e-02f,
  -5.68427518e-02f, 2.06737146e-01f, 4.21953108e-03f, -1.35736138e-01f, 6.85823634e-02f, 1.30404428e-01f, -1.56882741e-02f, 1.33004695e-01f, -2.40791403e-02f, 1.11249149e-01f,
  1.14744321e-01f, 4.06385846e-02f, -1.25732645e-01f, -4.27010581e-02f, -7.67641664e-02f, 4.52170409e-02f, -1.08008951e-01f, 6.26220256e-02f, 9.16286334e-02f, 8.32221955e-02f,
  -8.14381316e-02f, 7.71705806e-02f, 6.59922361e-02f, 4.46439013e-02f, 1.42495260e-02f, 7.37714022e-02f, -7.22757578e-02f, -2.76630484e-02f, -4.28062044e-02f, 5.18172048e-02f,
  -9.56675112e-02f, -3.15133154e-01f, 8.41917172e-02f, -3.95613387e-02f, 4.90874350e-02f, 1.33312359e-01f, -1.03886826e-02f, -3.59711722e-02f, -1.05924957e-01f, -3.92481275e-02f,
  -5.28596938e-02f, 2.66639628e-02f, -4.64758836e-03f, 1.35904253e-01f, -4.01883312e-02f, -4.89283279e-02f, 1.61955580e-01f, 6.85814992e-02f, 1.08099200e-01f, 3.26045096e-01f,
  2.29977265e-01f, 5.09938821e-02f, 1.07829444e-01f, 2.45679274e-01f, 1.35291040e-01f, -1.82497516e-01f, 9.17902216e-02f, 9.95041430e-03f, 3.29447947e-02f, 2.85451710e-02f,
  -4.48136598e-01f, -5.40383607e-02f, -1.16051652e-01f, -2.55615532e-01f, -2.61586346e-02f, 1.61728695e-01f, 1.12937130e-01f, 1.16977267e-01f, -3.82025689e-02f, -5.43565415e-02f,
  -1.38438810e-02f, -1.54973045e-01f, -2.28820220e-01f, -9.33395848e-02f, -1.06018811e-01f, -1.18478395e-01f, -2.72387266e-01f, -2.40825653e-01f, 8.85551982e-03f, 1.78932279e-01f,
  3.06874077e-04f, -2.23500013e-01f, -2.02652812e-01f, -1.32042959e-01f, -1.81519479e-01f, -1.86209932e-01f, -2.16160104e-01f, -1.28305137e-01f, -4.90921251e-02f, -3.22246850e-01f,
  -1.03664719e-01f, -2.57596187e-02f, 1.11653075e-01f, -8.22642259e-03f, -2.89507239e-04f, 5.94467819e-02f, 3.03836651e-02f, -3.50143462e-02f, 3.68626043e-02f, 1.17764790e-02f,
  -5.96504919e-02f, 1.16971888e-01f, -7.58702978e-02f, 2.66097486e-02f, -8.91452730e-02f, -1.36672361e-02f, 5.76147530e-03f, 4.80271056e-02f, -4.14126143e-02f, 2.18154415e-01f,
  8.36545080e-02f, -1.19656026e-01f, -4.22854759e-02f, 1.00425027e-01f, 1.37204453e-01f, -4.69870418e-02f, 6.24802709e-02f, 1.71266675e-01f, 4.90973406e-02f, -1.58781976e-01f,
  6.55039698e-02f, -1.09352842e-02f, 1.13411911e-01f, 5.93088865e-02f, -3.67742740e-02f, -2.87436601e-02f, -7.65124261e-02f, -6.71997145e-02f, -4.49407734e-02f, -2.12775618e-02f,
  2.11786442e-02f, 2.05508694e-02f, -1.47270849e-02f, -8.87169763e-02f, -4.37527075e-02f, -6.31049052e-02f, -8.19638222e-02f, -7.74096623e-02f, -8.58609006e-02f, -1.73541643e-02f,
  -1.21903447e-02f, -9.65335071e-02f, -1.93707272e-02f, -4.85980622e-02f, 8.35581422e-02f, -2.60967016e-02f, 4.55153883e-02f, 3.57318483e-02f, 4.34347391e-02f, 4.85861190e-02f,
  -2.00356528e-01f, -2.05984153e-03f, -2.00094938e-01f, 3.38791460e-02f, 1.47397462e-02f, 1.23781554e-01f, -9.62629244e-02f, 1.39918774e-01f, -5.21142222e-03f, 5.29026017e-02f,
  1.53523698e-01f, 3.67040485e-02f, -8.07751790e-02f, 2.32537743e-02f, 6.53489828e-02f, 5.07848039e-02f, -5.80057576e-02f, -1.88313141e-01f, 3.35523635e-02f, 7.80736804e-02f,
  4.20494303e-02f, -1.12816393e-01f, -3.01736057e-01f, -1.94278777e-01f, 2.63902210e-02f, -2.54442692e-01f, -1.72398254e-01f, 2.20161956e-03f, -1.23113491e-01f, -2.41675735e-01f,
  6.44015312e-01f, 5.35765104e-03f, 1.78097785e-01f, 8.62189010e-02f, -2.08048671e-01f, -1.46446139e-01f, -3.21089715e-01f, -9.47920382e-02f, -2.40945052e-02f, -9.76500101e-03f,
  5.11285402e-02f, 1.55355200e-01f, 1.45888194e-01f, 1.72814503e-01f, 8.41783062e-02f, -4.05999385e-02f, -6.19988330e-02f, 2.00316325e-01f, 2.31909439e-01f, 6.66826069e-02f,
  -1.95008144e-02f, -2.70996289e-03f, 1.46235138e-01f, 1.42044634e-01f, 3.97783332e-02f, -1.00853131e-03f, 7.57135376e-02f, 4.12633643e-02f, 6.68724673e-03f, 3.84528339e-02f,
  1.89346984e-01f, 2.55829215e-01f, 1.34440944e-01f, 1.61432952e-01f, 4.29969691e-02f, -1.34956259e-02f, -1.58932805e-02f, -1.30046876e-02f, 5.42164594e-02f, -1.18467256e-01f,
  -8.61302540e-02f, 1.30580172e-01f, 3.66267450e-02f, 3.99032980e-02f, 5.39389364e-02f, 5.67462854e-02f, 8.96337815e-03f, 1.77102074e-01f, 2.70414464e-02f, -2.58732606e-02f,
  1.52154136e-02f, 3.40598561e-02f, -3.47798392e-02f, -3.24842520e-02f, 4.03014384e-02f, -3.91157530e-03f, 9.63100977e-03f, 1.24714427e-01f, 1.10089108e-01f, 1.33858860e-01f,
  1.53550923e-01f, 1.82189286e-01f, 1.47059068e-01f, 9.87938643e-02f, 1.57441616e-01f, 1.94481406e-02f, -3.33132260e-02f, -1.08828925e-01f, 6.91290051e-02f, 1.08089238e-01f,
  8.25519115e-02f, 2.95748748e-03f, -2.40577664e-02f, 1.80803388e-02f, 8.42112303e-02f, -2.41461322e-02f, -1.55327497e-02f, -1.27645791e-01f, 8.84508565e-02f, -7.80380443e-02f,
  1.56952813e-01f, 1.12152062e-01f, 1.49749532e-01f, 8.45883861e-02f, 8.50315019e-03f, 8.23365375e-02f, 4.22259793e-02f, -1.14138983e-01f, 1.96244735e-02f, -5.80593990e-03f,
  -4.21731353e-01f, 1.71316609e-01f, 5.61053604e-02f, 8.47079828e-02f, -1.00411117e-01f, -5.47579937e-02f, -5.01704551e-02f, -1.33545488e-01f, -2.01516554e-01f, -2.48605698e-01f,
  -1.20193318e-01f, 2.79255845e-02f, -6.86921477e-02f, 5.24261035e-02f, 5.59843816e-02f, -1.07600898e-01f, -3.71716470e-02f, -5.54627627e-02f, -6.89432099e-02f, 9.35478974e-03f,
  -5.78467734e-02f, -1.44763365e-01f, -1.65309399e-01f, -2.01073229e-01f, -6.89841807e-02f, 1.65343974e-02f, -1.53719783e-01f, -3.22785303e-02f, -2.67063566e-02f, -1.24177486e-01f,
  2.31376946e-01f, 2.21133739e-01f, -5.46957850e-02f, -6.35637566e-02f, 3.35321635e-01f, 3.34868073e-01f, 4.33960408e-01f, 3.32829535e-01f, 1.01672217e-01f, 1.07483551e-01f,
  4.51320559e-02f, -3.45351517e-01f, -3.78696471e-01f, -3.58553350e-01f, -1.63919419e-01f, 3.97792235e-02f, 1.53960109e-01f, -1.62898794e-01f, -2.52667814e-01f, 8.80913809e-03f,
  -5.04332408e-02f, 1.61747798e-01f, 5.10540940e-02f, -9.47603360e-02f, 3.95622514e-02f, -1.56589955e-01f, 1.26288176e-01f, 1.57284752e-01f, -2.40939409e-02f, -3.33497584e-01f,
  -1.95258379e-01f, 1.50927246e-01f, -1.68741181e-01f, 3.77632305e-02f, 2.70336475e-02f, -9.63290930e-02f, -2.87193377e-02f, -9.68367606e-02f, -2.29344144e-02f, -1.81297120e-02f,
  -4.04045433e-02f, 1.51947383e-02f, -8.36429521e-02f, 9.37721319e-03f, 1.69778720e-01f, 1.51741374e-02f, 1.11218497e-01f, -9.97614115e-02f, -2.16965303e-01f, -1.53230175e-01f,
  -7.73954690e-02f, 1.21686101e-01f, 1.71848834e-01f, 2.48006508e-02f, -6.75225109e-02f, -1.25874445e-01f, 3.82950380e-02f, -7.26651400e-03f, 3.76438210e-03f, 6.53470904e-02f,
  -6.24075085e-02f, 2.05053091e-02f, -2.61503924e-02f, 2.58951876e-02f, 5.69501705e-03f, -6.32182648e-03f, -9.31128338e-02f, 2.97738332e-02f, -2.91436203e-02f, 1.13453180e-01f,
  -1.20485358e-01f, -7.79411718e-02f, -2.18221605e-01f, -5.06648272e-02f, -1.57893240e-01f, -9.57275257e-02f, -4.68648300e-02f, -5.68788201e-02f, 2.08204612e-02f, 8.70895907e-02f,
  -4.73332182e-02f, 9.04219747e-02f, 8.01186562e-02f, -4.89512086e-02f, -4.17586649e-03f, -1.07425831e-01f, -1.31829798e-01f, -3.75670530e-02f, 3.53368707e-02f, 1.08805321e-01f,
  -1.83793195e-02f, 5.11537716e-02f, -1.00711450e-01f, -4.13320027e-02f, 7.11536407e-02f, 3.44143696e-02f, -1.35566801e-01f, -7.71011412e-02f, 6.52178749e-02f, -1.53229222e-01f,
  -2.32047960e-02f, -2.11875990e-01f, -8.95324945e-02f, 3.99860963e-02f, 4.77326335e-03f, 9.98575706e-04f, 4.15379182e-03f, -6.45921938e-03f, -1.32009879e-01f, 4.29282337e-02f,
  1.56625938e-02f, -3.27738305e-03f, 1.37399390e-01f, -7.65338391e-02f, -1.53896749e-01f, -4.17446047e-02f, 1.07668810e-01f, 1.38205692e-01f, 7.83027709e-02f, 2.98186094e-01f,
  2.47037143e-01f, -1.75002456e-01f, 5.21541685e-02f, 2.21283495e-01f, 6.50245026e-02f, -4.61422354e-02f, -7.47600943e-02f, 7.31853768e-02f, 1.28710717e-01f, 1.47785813e-01f,
  3.18041407e-02f, 6.05383627e-02f, 9.11696851e-02f, 1.31785840e-01f, 7.93401673e-02f, 3.23462114e-02f, 7.59678259e-02f, 8.97629187e-02f, 1.23405971e-01f, 1.51089728e-01f,
  4.44307923e-02f, -1.68027412e-02f, 1.70268398e-02f, 1.07515790e-01f, 1.15629978e-01f, 7.74818212e-02f, -2.00883336e-02f, -3.50374579e-02f, -7.02162273e-03f, 1.49203613e-01f,
  1.02681994e-01f, -1.12453878e-01f, -4.13842872e-02f, -1.42287493e-01f, -4.66991290e-02f, -2.29749996e-02f, -1.16913475e-01f, -2.08974570e-01f, -3.80600244e-02f, -4.97884713e-02f,
  -1.34782612e-01f, 3.51455547e-02f, -8.36673602e-02f, -7.05955997e-02f, 2.25711875e-02f, -1.27544343e-01f, -6.74772076e-03f, -7.75917098e-02f, -8.26633796e-02f, 2.59208903e-02f,
  -7.62990639e-02f, 2.87935939e-02f, -1.15977809e-01f, -1.12128526e-01f, -6.02558441e-02f, 4.14244644e-02f, -1.37462437e-01f, -7.83713162e-03f, -4.96561117e-02f, 9.68088135e-02f,
  1.79499432e-01f, 3.37115824e-02f, 7.77667090e-02f, 6.15834743e-02f, 1.65771812e-01f, 2.22781263e-02f, 4.68976572e-02f, 1.48010056e-03f, 1.00754285e-02f, 6.30514929e-03f,
  1.00037627e-01f, 1.71391517e-01f, -6.87770322e-02f, 8.19506124e-02f, 9.87154543e-02f, -1.42702842e-02f, -3.66081893e-02f, -6.98283166e-02f, -3.81267965e-02f, -1.34915426e-01f,
  -3.35037056e-03f, 8.07373375e-02f, 1.97171643e-02f, 7.95346200e-02f, 2.28132308e-02f, -3.04590613e-02f, 9.55615491e-02f, -3.37278284e-02f, -4.60637873e-03f, -6.56030253e-02f,
  -3.14863503e-01f, -2.15520650e-01f, 1.32443801e-01f, -9.05040726e-02f, -4.75003049e-02f, -9.40803140e-02f, -3.28718610e-02f, -2.09477782e-01f, -2.74109334e-01f, -1.11759253e-01f,
  -5.29519133e-02f, 5.28564677e-02f, -9.83735919e-02f, -1.37991965e-01f, -2.81733535e-02f, -9.76957083e-02f, -8.95681605e-03f, 5.20099886e-03f, -1.11843899e-01f, -4.42157350e-02f,
  -1.28873646e-01f, -4.09028307e-02f, -5.12201302e-02f, -6.65336922e-02f, -1.07876346e-01f, -1.29740536e-01f, -1.55048475e-01f, -1.01330794e-01f, -9.28186104e-02f, -9.29186270e-02f,
  7.71102756e-02f, -1.54571921e-01f, -3.80011573e-02f, 2.79605150e-01f, 2.83854097e-01f, 2.72027344e-01f, 2.20096216e-01f, 1.06799342e-01f, 1.91211909e-01f, 1.48949459e-01f,
  1.28343090e-01f, 6.97056055e-02f, 1.35003954e-01f, -5.06785093e-03f, 1.04419272e-02f, 3.65071446e-02f, -2.64692702e-03f, -5.84246889e-02f, -1.04677938e-02f, 1.49309769e-01f,
  1.59885019e-01f, 8.26490149e-02f, -3.86018530e-02f, -1.60634313e-02f, 2.27363426e-02f, 6.52698502e-02f, 9.36723500e-02f, -1.64623298e-02f, -3.79905961e-02f, -5.34965470e-03f,
  -1.65989816e-01f, -1.93628624e-01f, -3.35548334e-02f, 4.72262269e-03f, 1.22158993e-02f, -2.43188236e-02f, 3.43903117e-02f, -5.17101288e-02f, 2.83716377e-02f, -5.43358885e-02f,
  2.26373523e-02f, -1.64288461e-01f, 2.75310595e-02f, -5.15637062e-02f, -7.42624477e-02f, -5.83178923e-03f, -1.21259660e-01f, -9.23070088e-02f, -6.37722621e-03f, -7.28373528e-02f,
  -7.45289773e-02f, -3.55948061e-02f, -5.66161377e-03f, 2.49007139e-02f, -9.34943035e-02f, -8.70622993e-02f, -1.78796962e-01f, -1.07490748e-01f, -5.51839545e-02f, -1.22747183e-01f,
  2.37473696e-02f, -3.59954797e-02f, -7.20849261e-02f, -8.46149214e-03f, 6.22781627e-02f, -1.07497856e-01f, -8.07524025e-02f, -4.74982262e-02f, -2.63054911e-02f, -1.68541372e-02f,
  -2.96906265e-03f, 3.90736684e-02f, -3.64964758e-03f, 1.19207390e-02f, 4.89359051e-02f, -1.86333153e-02f, -3.13742235e-02f, 1.49112539e-02f, -7.92825073e-02f, -5.78374043e-02f,
  -7.18603702e-03f, -5.75265475e-02f, -1.15169957e-01f, -4.39963490e-02f, -3.19680646e-02f, -4.79821377e-02f, 2.17512082e-02f, -1.06516676e-02f, 1.34499632e-02f, 6.01117574e-02f,
  8.92503709e-02f, 1.11412302e-01f, 6.93378821e-02f, -1.56482816e-01f, -1.20442770e-01f, -6.89510554e-02f, 9.21613723e-02f, 1.31317610e-02f, -8.33790191e-03f, -1.36911720e-01f,
  -1.03449404e-01f, -1.20193819e-02f, 6.68080943e-03f, -4.70620282e-02f, -1.04445189e-01f, 5.91354631e-03f, -9.95871648e-02f, -4.76365797e-02f, -1.07433438e-01f, -1.23307183e-01f,
  2.47964934e-02f, 6.01562373e-02f, -1.21325413e-02f, 4.51649651e-02f, 4.48034443e-02f, 7.41904452e-02f, -8.95758346e-02f, -9.89290550e-02f, -3.89504358e-02f, 1.72390211e-02f,
  -4.99666840e-01f, -7.41348565e-02f, -5.61331883e-02f, 2.30596691e-01f, 3.46249849e-01f, 3.05941522e-01f, 2.48272032e-01f, 1.72784939e-01f, 3.31910759e-01f, 2.43590012e-01f,
  1.69584557e-01f, 2.42747054e-01f, 2.14248657e-01f, 2.39874542e-01f, 1.58560067e-01f, 3.08768392e-01f, 3.37826222e-01f, 1.84493810e-01f, 7.99622983e-02f, 9.43861082e-02f,
  1.72386870e-01f, 9.23072770e-02f, -5.73523864e-02f, 2.15775251e-01f, 2.36214250e-01f, 2.43825182e-01f, 3.39046180e-01f, 1.29489541e-01f, 2.51030296e-01f, 2.76966631e-01f,
  -1.55237406e-01f, -3.34935218e-01f, 6.32479265e-02f, 1.65596958e-02f, -9.51804966e-02f, -1.51009291e-01f, -7.59689584e-02f, -1.04655847e-01f, 1.91629082e-02f, 9.92161781e-02f,
  7.45847821e-02f, -1.91243857e-01f, -1.53036445e-01f, -3.72120552e-02f, -2.86099445e-02f, -1.09864295e-01f, -4.39002673e-04f, 4.22576368e-02f, 1.57426044e-01f, 1.74747445e-02f,
  3.00056804e-02f, 5.18929660e-02f, -2.29164609e-03f, 9.29075107e-02f, 2.78126169e-02f, 5.00919707e-02f, -1.51607856e-01f, 1.49383675e-02f, -2.43650861e-02f, 2.86275595e-02f,
  1.97529480e-01f, 3.09554115e-02f, 3.05582099e-02f, 7.85021409e-02f, -1.08025439e-01f, 8.36058259e-02f, 1.35989897e-02f, 6.00749478e-02f, 1.11065917e-01f, -5.05772159e-02f,
  1.39077529e-01f, 6.40840977e-02f, 1.97787397e-02f, -1.22251455e-02f, 3.31239887e-02f, 7.63959512e-02f, 2.93208603e-02f, -8.89258087e-02f, -1.14225775e-01f, 4.91216481e-02f,
  -6.08118996e-02f, -3.93950455e-02f, -1.32174462e-01f, -3.49332541e-02f, 9.17664543e-02f, 6.64429814e-02f, 1.21981025e-01f, 8.32388625e-02f, -2.98811700e-02f, 4.57446463e-02f,
  4.58720714e-01f, 3.04685556e-03f, -1.31978646e-01f, -4.93449681e-02f, -7.25512803e-02f, -1.78590253e-01f, -5.36896549e-02f, -1.18378825e-01f, -1.01878442e-01f, -4.10854518e-02f,
  -7.40855783e-02f, -9.72141698e-02f, -1.04451731e-01f, -1.00369900e-02f, -5.61125251e-03f, -1.01201050e-01f, -6.05557077e-02f, 1.01189725e-01f, 5.96666187e-02f, 1.02399819e-01f,
  3.00711542e-02f, 1.34630755e-01f, 1.51374400e-01f, 6.98754713e-02f, -1.76616833e-02f, 1.33245140e-01f, -5.06250486e-02f, -5.81273586e-02f, 8.59760621e-04f, -2.71465518e-02f,
  1.17495365e-01f, 1.19579017e-01f, -2.39100665e-01f, 1.82057053e-01f, 1.64919775e-02f, -1.26253992e-01f, -1.26841469e-02f, 1.47840217e-01f, 1.90539449e-01f, 1.18265755e-01f,
  -1.72509998e-02f, -1.49529934e-01f, -1.71116129e-01f, -1.74073428e-01f, -3.02042603e-01f, -1.43148765e-01f, -1.36725813e-01f, -3.28093976e-01f, -2.75027186e-01f, -8.82096440e-02f,
  -4.20652665e-02f, -5.32714725e-02f, -1.09558873e-01f, -4.31351773e-02f, 8.03547353e-02f, -1.52055472e-01f, -1.94893479e-02f, -6.73862100e-02f, -2.60416478e-01f, -1.39319360e-01f,
  -1.65811002e-01f, 3.14791277e-02f, -3.35778226e-03f, -1.83734335e-02f, -1.74832512e-02f, -3.36646363e-02f, -2.30929479e-02f, 1.34587158e-02f, -3.93312871e-02f, -3.75332907e-02f,
  -3.09938733e-02f, 5.15517816e-02f, 3.31835845e-03f, -5.95270842e-02f, 3.31130512e-02f, -8.78787227e-03f, -3.12348753e-02f, -8.68657529e-02f, -6.95378706e-02f, 2.11849958e-02f,
  -1.84428524e-02f, -9.73688737e-02f, -9.19694677e-02f, 6.22007903e-03f, 8.77540279e-03f, -9.70255584e-02f, -2.28128023e-02f, -3.12159471e-02f, -1.52929485e-01f, 4.52515744e-02f,
  6.07724003e-02f, 4.94763479e-02f, 7.49923587e-02f, 7.54998848e-02f, 1.73779659e-03f, 1.96635798e-02f, 4.56670187e-02f, -1.25257848e-02f, 9.32891201e-03f, 5.34729427e-03f,
  5.97156659e-02f, 4.55464460e-02f, 2.69468855e-02f, 1.65628176e-02f, -1.13949887e-01f, 3.61773768e-03f, -2.23391037e-02f, 8.21098778e-03f, -6.83332980e-03f, -1.60322949e-01f,
  -7.56596476e-02f, -1.38959736e-02f, -4.68773283e-02f, -2.22258419e-02f, -4.03218344e-02f, 2.67431121e-02f, 4.91182581e-02f, 8.56160931e-03f, 6.21271171e-02f, 2.58760713e-03f,
  2.16706004e-02f, -1.27907753e-01f, 3.35194543e-02f, -8.73648599e-02f, -6.34329766e-02f, 1.47360507e-02f, 3.46121714e-02f, 5.29100746e-02f, 3.43622919e-03f, -5.35703497e-03f,
  -8.28465354e-03f, 1.03994401e-03f, -5.76400897e-03f, -2.41020247e-02f, -1.41715594e-02f, 2.13736780e-02f, -1.16109126e-03f, -9.24254507e-02f, -6.85233325e-02f, 8.46209601e-02f,
  3.97448204e-02f, -1.28321335e-01f, -7.51383230e-02f, -3.83268967e-02f, -2.47635096e-02f, -1.72509819e-01f, -1.31048679e-01f, -1.83258834e-03f, -2.02111199e-01f, 6.27378747e-03f,
  7.21953511e-02f, 8.99788141e-02f, 2.35803947e-01f, 3.17738391e-02f, -2.08904877e-01f, -2.86756247e-01f, -3.27027649e-01f, -8.00747797e-02f, 1.20931910e-02f, -1.06285112e-02f,
  -2.12029293e-01f, -2.15009034e-01f, 1.12027779e-01f, -3.63356322e-02f, -6.99538812e-02f, 1.50107428e-01f, 3.09354186e-01f, 1.74992457e-01f, -2.58013129e-01f, -4.45490986e-01f,
  -2.59456784e-01f, 3.36071178e-02f, 1.12681635e-01f, 9.87327322e-02f, 2.02346727e-01f, 1.21346064e-01f, 3.94756138e-01f, 1.74634695e-01f, 6.75820932e-02f, 4.17159230e-01f,
  1.51740670e-01f, 1.12338006e-01f, -1.22240029e-01f, -6.60737455e-02f, 3.05212364e-02f, 3.09255440e-02f, -1.08087167e-01f, 2.53370672e-01f, -1.43268168e-01f, -6.25522994e-03f,
  -2.02360451e-01f, -1.20217375e-01f, -7.80841261e-02f, -1.18985310e-01f, -1.37272924e-01f, -1.56979948e-01f, 7.02824146e-02f, 6.33548126e-02f, 1.09112412e-01f, -6.25856146e-02f,
  -3.10648888e-01f, -1.13862045e-01f, -4.41397950e-02f, 5.65263517e-02f, 6.29142597e-02f, -9.03798863e-02f, -4.96281423e-02f, -1.21296141e-02f, 1.60125524e-01f, 1.74290821e-01f,
  -7.98430219e-02f, -3.64326127e-02f, -1.25449188e-02f, 5.37419245e-02f, -6.75972849e-02f, 2.66385600e-02f, 3.76126319e-02f, -4.27676998e-02f, 1.44580966e-02f, -6.05063923e-02f,
  -1.27800843e-02f, 3.72535214e-02f, 1.35011394e-02f, 2.60010883e-02f, -1.22731641e-01f, 5.67372404e-02f, -1.08090006e-01f, 6.15760833e-02f, -1.45959789e-02f, 7.67592266e-02f,
  -3.36080859e-03f, -2.25942908e-03f, 1.10144638e-01f, 1.11478660e-03f, 3.87439542e-02f, 5.20773977e-02f, 6.37518615e-02f, -1.19413352e-02f, 8.23961347e-02f, -1.51699437e-02f,
  -1.50490534e-02f, -5.40449992e-02f, 9.33216792e-03f, -7.49303922e-02f, -6.94523286e-03f, -3.51295955e-02f, 9.04022753e-02f, -3.56747955e-02f, -2.81328727e-02f, -1.01700373e-01f,
  -2.17104107e-01f, -7.91439340e-02f, 1.31486475e-01f, -1.08892307e-01f, -1.77177668e-01f, -3.30764018e-02f, -9.02779177e-02f, -2.02695623e-01f, -1.52003214e-01f, -1.30988881e-01f,
  -1.05666086e-01f, -1.89360395e-01f, -1.79542720e-01f, -1.75096601e-01f, -6.04585707e-02f, -3.07716519e-01f, -1.04330495e-01f, -8.36138874e-02f, -1.20917313e-01f, -1.95074350e-01f,
  2.78921068e-01f, -2.10523665e-01f, -5.46009660e-01f, -3.71309817e-01f, -2.95783162e-01f, -4.09702249e-02f, 1.91590898e-02f, 2.94180661e-02f, -2.17123047e-01f, -2.34185636e-01f,
  9.91292391e-03f, 1.61540553e-01f, 6.97302818e-02f, 7.46359378e-02f, 1.77058458e-01f, -2.32513756e-01f, -2.95971662e-01f, -1.26452342e-01f, 1.33517504e-01f, 1.25066727e-01f,
  5.71041033e-02f, -1.80054218e-01f, 1.35226632e-02f, -9.32451263e-02f, -3.92207116e-01f, -1.37152165e-01f, -3.36697280e-01f, -2.21528977e-01f, -1.21614367e-01f, -3.99250150e-01f,
  -2.76412636e-01f, -6.07109927e-02f, 5.21434881e-02f, 4.67940606e-02f, -6.54188916e-02f, 1.15167037e-01f, 1.12482104e-02f, -1.51117593e-01f, -1.32637080e-02f, -1.50484055e-01f,
  -2.17859708e-02f, -1.71260815e-02f, -4.42136712e-02f, -4.35916223e-02f, -9.22388434e-02f, 2.96876207e-02f, -6.97508007e-02f, -3.82372402e-02f, -4.63508219e-02f, 6.48831576e-02f,
  1.14815503e-01f, 8.19601193e-02f, 3.95449288e-02f, 1.05567962e-01f, 8.39312896e-02f, 1.03545792e-01f, -4.34892289e-02f, 1.08696863e-01f, 2.60326657e-02f, 2.18049102e-02f,
  -1.32410014e-02f, 6.90409914e-02f, 1.31261617e-01f, 1.10047370e-01f, 1.89012453e-01f, 8.35186318e-02f, 5.10796160e-02f, 8.95398334e-02f, 1.37410387e-01f, 6.16067909e-02f,
  -6.11843988e-02f, 1.13349751e-01f, 2.02069953e-02f, -3.77195925e-02f, -9.43593830e-02f, -2.06480678e-02f, 1.15371525e-01f, 1.15001462e-02f, 1.68189872e-03f, 7.63116404e-02f,
  5.66176744e-03f, 4.87089977e-02f, -5.03552631e-02f, 2.02318523e-02f, 8.00532773e-02f, -5.56633957e-02f, 6.73220232e-02f, 2.92867795e-02f, 5.94608784e-02f, 5.61592951e-02f,
  2.90383585e-02f, 1.98398009e-01f, 3.69397774e-02f, 1.55164436e-01f, -1.20153971e-01f, -1.39126927e-01f, -8.62114131e-02f, -8.87633786e-02f, -1.75696164e-01f, -1.01593584e-01f,
  -7.84989893e-02f, 9.47026089e-02f, -7.92911723e-02f, 2.04951447e-02f, -2.07685549e-02f, 4.47727405e-02f, 1.28394365e-01f, 9.41440091e-02f, 3.20540257e-02f, -1.19003117e-01f,
  2.65264753e-02f, 1.21115275e-01f, 1.90522954e-01f, 9.43626985e-02f, 7.31262267e-02f, 1.29168034e-01f, 7.66797177e-03f, 3.74638699e-02f, 4.89481464e-02f, 4.17236090e-02f,
  -3.43288839e-01f, 2.01269686e-01f, 2.37901583e-01f, -3.03335309e-01f, 1.54153362e-01f, 2.91863263e-01f, 4.01238173e-01f, 6.91887215e-02f, -2.11566672e-01f, 1.61911666e-01f,
  5.01281507e-02f, -1.42383382e-01f, -6.83986545e-02f, -3.02048195e-02f, 1.01198226e-01f, 2.83444464e-01f, 1.83325008e-01f, -2.16547363e-02f, -7.81371146e-02f, 8.36428776e-02f,
  5.31200245e-02f, -1.39531866e-01f, -1.70629680e-01f, -7.48197287e-02f, -8.73303860e-02f, -8.62641856e-02f, 1.74516886e-02f, 1.29164301e-03f, 2.36014977e-01f, 7.61456415e-02f,
  4.76619089e-03f, -4.56857448e-03f, -3.19905989e-02f, -9.93983746e-02f, 4.27623838e-02f, -2.87284516e-02f, 1.79378688e-02f, -1.52749181e-01f, 1.09181926e-02f, -3.51316594e-02f,
  -4.01851796e-02f, 1.94000266e-02f, 1.16051706e-02f, 4.11868356e-02f, -1.48351835e-02f, -6.20756950e-03f, -1.45693555e-01f, -3.54246274e-02f, -2.43872553e-02f, -2.84580756e-02f,
  1.08690552e-01f, -3.29814516e-02f, -1.01166278e-01f, 7.15857893e-02f, -1.79958122e-03f, -1.79054245e-01f, -7.22010210e-02f, -1.25067785e-01f, -5.26556484e-02f, -1.67497560e-01f,
  3.09960116e-02f, 7.66249970e-02f, 9.24467072e-02f, -4.50441651e-02f, -2.77992897e-02f, 1.13281962e-02f, -3.04788258e-02f, 7.67738149e-02f, 7.75072351e-02f, 6.47277711e-03f,
  -3.09901033e-02f, -9.83514916e-03f, -9.17808488e-02f, -7.08421916e-02f, -6.81816041e-02f, 1.59780402e-02f, 4.39482592e-02f, 6.18110038e-03f, -2.65425560e-03f, 3.78944655e-03f,
  -5.84070608e-02f, 5.23579381e-02f, -2.16629237e-01f, -1.89125515e-03f, 3.57972570e-02f, 2.77132504e-02f, -8.20464566e-02f, -7.03528582e-04f, -4.91485111e-02f, 7.41651207e-02f,
  -2.52267897e-01f, 3.15736532e-01f, -1.66891217e-01f, 3.52505818e-02f, 4.17017527e-02f, 1.24695592e-01f, 2.13215780e-02f, 5.66095933e-02f, 4.08596322e-02f, 1.97129752e-02f,
  2.80324910e-02f, -2.01625843e-02f, 4.54668235e-03f, 3.29490826e-02f, -2.06378791e-02f, -5.41786589e-02f, 1.41270936e-01f, 8.09479132e-02f, 1.75947901e-02f, -1.39433712e-01f,
  -6.15644567e-02f, -1.02087282e-01f, -2.20415920e-01f, -3.11340904e-03f, -8.39825645e-02f, -1.66607529e-01f, -1.41679049e-01f, -1.69791609e-01f, 2.34853923e-02f, -1.05813079e-01f,
  4.79848944e-02f, -2.85509437e-01f, 1.27256781e-01f, 7.24184066e-02f, -2.70488411e-01f, -2.94591844e-01f, -4.67709124e-01f, -1.24996863e-01f, 4.09511179e-02f, -1.31916687e-01f,
  -2.24583358e-01f, -3.77069153e-02f, 2.84868423e-02f, -4.03302200e-02f, -1.11681618e-01f, -1.46535441e-01f, 3.80070135e-02f, 1.25019670e-01f, 8.26253071e-02f, -1.20479472e-01f,
  -1.00853883e-01f, 1.20509028e-01f, 3.47662866e-01f, 2.52739638e-01f, 2.03524411e-01f, 1.03462748e-01f, 2.24614680e-01f, 8.79372284e-02f, -6.72411323e-02f, 1.18270673e-01f,
  2.33840700e-02f, 1.37829170e-01f, -2.14669784e-03f, 1.05659254e-01f, -3.47064622e-02f, 3.69698964e-02f, -9.63868275e-02f, 1.01199254e-01f, -5.20983562e-02f, -5.08921333e-02f,
  -1.41598001e-01f, -6.04126342e-02f, -1.07989013e-01f, 1.66204013e-02f, 1.85677726e-02f, -8.49427506e-02f, 9.18887928e-02f, 1.10680491e-01f, 8.09598938e-02f, -1.34971002e-02f,
  -1.66396737e-01f, -1.02044053e-01f, -4.50168103e-02f, 2.32874695e-02f, 6.44082427e-02f, -1.86612308e-02f, 4.41890508e-02f, 1.05280332e-01f, 7.76360035e-02f, 6.83348775e-02f,
  7.41448402e-02f, 3.96767370e-02f, -5.00393100e-02f, -6.57024682e-02f, -1.27571240e-01f, -1.87203307e-02f, 4.40702885e-02f, -3.42023931e-02f, -5.93307475e-03f, -7.48858154e-02f,
  -8.41117501e-02f, -4.67515178e-02f, 1.90997252e-03f, 2.48007029e-02f, 1.12890350e-02f, 9.89242196e-02f, -1.04099058e-01f, 4.39806730e-02f, 1.13815762e-01f, 5.71423769e-02f,
  -1.16986837e-02f, -5.76942898e-02f, 2.53751725e-02f, -2.92331167e-03f, -3.57132219e-02f, 1.04119502e-01f, 2.78655272e-02f, -1.43631985e-02f, 5.23902625e-02f, -2.66293902e-03f,
  1.31340213e-02f, 4.46020551e-02f, -1.14228114e-01f, 4.15737219e-02f, -6.16347194e-02f, 6.62015378e-02f, -2.15311013e-02f, -6.30500168e-02f, -3.64359841e-02f, -7.39538670e-02f,
  -1.25951156e-01f, -1.02595128e-01f, -9.94758215e-03f, 3.59773519e-03f, -2.68122256e-02f, -2.80103832e-02f, -1.21898755e-01f, -1.05722629e-01f, -9.57756341e-02f, -8.02249238e-02f,
  -1.10364534e-01f, -1.95777699e-01f, -2.70465136e-01f, -2.31803581e-01f, -7.53602386e-02f, -2.15313688e-01f, -7.41130933e-02f, -8.20150822e-02f, -1.96819767e-01f, -2.97435790e-01f,
  3.18226248e-01f, 1.37170348e-02f, 7.25627318e-02f, 9.34640095e-02f, -4.32496816e-02f, -8.43315199e-02f, -2.54554868e-01f, -1.82668298e-01f, 8.40019211e-02f, 1.75334457e-02f,
  2.26373598e-01f, 1.83233470e-01f, 1.91024393e-01f, 7.19002783e-02f, -1.25024691e-01f, -1.47837192e-01f, -1.21712178e-01f, 2.44760793e-02f, 6.00320920e-02f, -5.31853698e-02f,
  -1.54089957e-01f, -2.80080661e-02f, 4.47763279e-02f, 6.33419231e-02f, 4.11599576e-02f, 9.10175517e-02f, 1.47125185e-01f, -4.33160812e-02f, -1.47642389e-01f, -1.21703535e-01f,
  4.90951166e-02f, 8.03095102e-02f, 4.63332161e-02f, 8.22952390e-02f, 2.18189836e-01f, 1.89093232e-01f, 2.10927039e-01f, 4.25678827e-02f, -3.68367583e-02f, 4.49079610e-02f,
  3.89336459e-02f, 1.32043391e-01f, 2.03985929e-01f, 1.23449184e-01f, -9.19118524e-03f, 8.35458487e-02f, 1.51060387e-01f, -3.96855967e-03f, -3.13131101e-02f, 1.44192755e-01f,
  1.25403389e-01f, 6.29659742e-02f, -7.69480020e-02f, 1.66180488e-02f, -6.33044168e-02f, 1.45177573e-01f, 9.99190658e-02f, 1.39046103e-01f, -1.08101573e-02f, 3.92502323e-02f,
  -2.40567327e-02f, 6.95574507e-02f, 2.21924230e-01f, 2.81608924e-02f, 7.36610293e-02f, 1.19890459e-01f, 1.08977988e-01f, -4.73887697e-02f, 8.82621109e-02f, 8.05003643e-02f,
  8.64643380e-02f, -1.84056953e-01f, -6.74097985e-03f, 9.41275284e-02f, 4.16468531e-01f, 2.38680139e-01f, 5.28881922e-02f, 8.20861608e-02f, 1.39764398e-01f, 3.83966416e-02f,
  1.45398840e-01f, 9.06191915e-02f, 2.90445954e-01f, 1.12253860e-01f, -4.83877100e-02f, 1.58628330e-01f, 9.93025899e-02f, 3.67951468e-02f, 2.65498102e-01f, 1.41430572e-01f,
  2.14463715e-02f, 6.05689622e-02f, -1.32779688e-01f, -1.31905302e-01f, -6.05973303e-02f, 1.50546595e-01f, 3.84413230e-04f, 2.83460207e-02f, -3.08080949e-02f, -8.62978995e-02f,
  -1.48291498e-01f, 4.70521562e-02f, 9.29743145e-03f, -3.05424407e-02f, 1.19546786e-01f, -6.08055703e-02f, -3.66023593e-02f, -1.31197095e-01f, -1.45572752e-01f, 8.57704207e-02f,
  -1.78717952e-02f, -6.92617446e-02f, -8.01142976e-02f, -1.34366572e-01f, -7.90504217e-02f, -1.16954534e-03f, -8.01640600e-02f, -8.13302547e-02f, -8.51333365e-02f, 1.73394252e-02f,
  2.83639342e-01f, 1.06615178e-01f, 2.02389091e-01f, 1.41016066e-01f, -1.57490477e-01f, -3.03445280e-01f, -3.42238635e-01f, -4.92956862e-02f, 1.75738335e-02f, 5.66267222e-02f,
  -9.18133780e-02f, -7.25634396e-03f, 9.88166183e-02f, 1.82924308e-02f, -8.52964073e-02f, 1.35405902e-02f, 1.90434173e-01f, 1.53677687e-01f, -1.16587751e-01f, -2.48966038e-01f,
  -1.08351290e-01f, 1.18333066e-03f, 1.32906318e-01f, 6.85067549e-02f, 1.53980568e-01f, -2.84861866e-02f, 1.44112840e-01f, 7.02434108e-02f, -2.54072528e-02f, 3.30565721e-01f,
  2.12674901e-01f, 1.44793868e-01f, -3.28101546e-01f, -6.15019761e-02f, 5.82137518e-02f, 6.90718070e-02f, -4.56873029e-02f, 1.50084928e-01f, 2.23778300e-02f, 4.83018495e-02f,
  6.90927356e-02f, 5.07548898e-02f, 2.76675280e-02f, 5.98219745e-02f, -6.72522932e-03f, -1.36789203e-01f, 1.33774564e-01f, 6.09683171e-02f, 1.40159622e-01f, 4.94922809e-02f,
  -1.04169182e-01f, -6.01895675e-02f, -8.98660999e-03f, -1.04051478e-01f, 3.68812308e-02f, -3.95933688e-02f, -6.43331409e-02f, 2.60317698e-02f, -9.75746810e-02f, 1.90855175e-01f,
  -9.85731333e-02f, 4.73698974e-02f, 6.21837936e-02f, 4.92131785e-02f, -2.76579298e-02f, 4.62395065e-02f, 9.56256762e-02f, -5.89734353e-02f, -3.35507914e-02f, 4.84828912e-02f,
  -4.74600531e-02f, -1.60951361e-01f, 4.18881103e-02f, -1.18840523e-02f, -1.71046872e-02f, 1.35195348e-02f, -4.07179184e-02f, -2.27864813e-02f, -5.62136667e-03f, 7.42133111e-02f,
  -1.40004943e-03f, 2.53723338e-02f, 8.89088288e-02f, 6.66248659e-03f, -3.15898992e-02f, -1.74183473e-02f, -7.35082105e-02f, -3.64148952e-02f, 2.59955525e-02f, -3.45218624e-03f,
  -1.24290325e-01f, -2.84540564e-01f, -4.37815376e-02f, -5.67629235e-03f, -1.37290591e-02f, -2.68138163e-02f, 2.90718004e-02f, -6.89257234e-02f, -4.02534986e-03f, 1.48122814e-02f,
  -2.76041739e-02f, -1.14599010e-02f, 1.18775062e-01f, 1.19020580e-03f, -7.13039115e-02f, -7.69204870e-02f, -9.61182714e-02f, -5.10859676e-02f, -3.95705365e-02f, 1.72150563e-02f,
  -8.27889219e-02f, -2.67213434e-01f, -2.24961460e-01f, -5.97039275e-02f, -2.58593876e-02f, -2.88160324e-01f, -1.52809277e-01f, -1.75563931e-01f, -3.07596594e-01f, -1.90361947e-01f,
  3.87429222e-02f, 3.50188166e-01f, -1.97760180e-01f, -3.24745804e-01f, -1.98210955e-01f, 9.01868418e-02f, 3.32069069e-01f, 1.62289649e-01f, -2.83300191e-01f, 1.33822829e-01f,
  2.04895511e-01f, -2.00253904e-01f, -1.56659484e-01f, -1.22112960e-01f, 2.26019517e-01f, 1.89308435e-01f, -1.25906333e-01f, -2.04393312e-01f, -2.04852030e-01f, 6.13062419e-02f,
  -6.04377240e-02f, -8.34443569e-02f, -6.50409088e-02f, -1.05072334e-01f, -3.58251959e-01f, -3.66463363e-01f, -2.28275746e-01f, -6.76941574e-02f, -1.01762908e-02f, -1.92184895e-01f,
  -2.54187554e-01f, 4.99443598e-02f, -1.19856626e-01f, -1.51629135e-01f, -1.93752721e-02f, -1.48223817e-01f, -6.01542443e-02f, -2.63822734e-01f, -1.17461525e-01f, -1.26341477e-01f,
  -7.52673224e-02f, -8.60831290e-02f, -1.98437512e-01f, -2.11240992e-01f, -1.52413473e-01f, -1.06737934e-01f, -1.64815024e-01f, -8.92822295e-02f, 5.10033732e-03f, 7.24388808e-02f,
  2.23736554e-01f, 1.33212209e-01f, 2.39632931e-02f, 1.17732152e-01f, 1.04571842e-01f, -1.08117014e-01f, 7.67722130e-02f, -4.85086963e-02f, 2.92431545e-02f, -1.47064226e-02f,
  1.97603270e-01f, 5.46670929e-02f, -5.35172373e-02f, -2.11820146e-03f, 6.37739673e-02f, 7.95847699e-02f, -5.90064451e-02f, 7.24560767e-02f, 1.59207247e-02f, 2.11845711e-02f,
  4.94928993e-02f, 7.13603497e-02f, 1.00101352e-01f, 3.00010620e-03f, -1.27634063e-01f, 4.84355763e-02f, 8.07557628e-02f, 1.17442012e-01f, -2.16245688e-02f, 2.31337082e-03f,
  3.21288481e-02f, 5.91902360e-02f, -6.95436969e-02f, -6.34425506e-02f, -4.69821924e-03f, -3.74070089e-03f, -4.88310196e-02f, 4.30016965e-02f, 8.09058174e-02f, 4.92021330e-02f,
  -4.15408850e-01f, 1.76994547e-01f, -1.85780644e-01f, -1.74946025e-01f, -7.58931786e-02f, -5.87072112e-02f, 1.24190487e-02f, 2.77441405e-02f, -9.91287678e-02f, -5.08244112e-02f,
  1.17811419e-01f, 1.76908318e-02f, 7.35471100e-02f, -2.08993386e-02f, 3.16999257e-02f, 6.80886628e-03f, 7.30015114e-02f, -1.03740998e-01f, 8.04305151e-02f, 6.73516020e-02f,
  5.14187552e-02f, 1.83695495e-01f, -2.36769803e-02f, -4.27530780e-02f, 2.86001284e-02f, -4.51402552e-02f, -1.20156676e-01f, -1.35836557e-01f, 6.48745745e-02f, 7.74301514e-02f,
  2.38146245e-01f, 1.77415907e-01f, -3.09790596e-02f, 6.11878857e-02f, -5.49834594e-02f, -8.22646990e-02f, 2.12427899e-01f, -6.98159495e-03f, -1.97043732e-01f, 8.54503885e-02f,
  -2.71279644e-02f, -4.15233284e-01f, -3.29165608e-01f, -1.97161660e-01f, 3.45471129e-02f, 2.37792522e-01f, 1.76105797e-01f, 1.39874026e-01f, -5.61972819e-02f, 7.81807676e-02f,
  1.02393970e-01f, 1.42309964e-01f, 2.41146192e-01f, 7.50466660e-02f, -6.15348965e-02f, -2.06787571e-01f, 2.64656283e-02f, 6.02236241e-02f, 1.11693731e-02f, 2.95864977e-03f,
  -1.27669826e-01f, 4.54057455e-02f, -1.76576152e-01f, -6.18005879e-02f, 4.46512066e-02f, -3.09645925e-02f, -4.36136611e-02f, -3.74000520e-02f, 1.65323036e-05f, 4.35164012e-02f,
  -1.53235584e-01f, -9.28326696e-02f, -2.47543514e-01f, -5.33489436e-02f, -1.42359123e-01f, -1.45919025e-01f, 1.18347406e-01f, 5.76488823e-02f, -8.06649029e-02f, -3.78679708e-02f,
  5.11658099e-03f, -3.33406851e-02f, 5.73164187e-02f, 9.06652659e-02f, -3.44409943e-02f, -8.72633532e-02f, -5.75741045e-02f, -1.13704674e-01f, -9.91545897e-03f, 1.01057157e-01f,
  1.36985660e-01f, 2.37805191e-02f, -3.64812985e-02f, 3.53089571e-02f, 7.34289885e-02f, 3.00240424e-02f, -4.52498868e-02f, -1.32645555e-02f, -5.30949142e-03f, -9.79324058e-02f,
  -2.23365333e-02f, 1.70453086e-01f, -7.49498606e-02f, -2.35398412e-02f, -7.48844445e-02f, -1.41401082e-01f, 7.11983219e-02f, 1.15781963e-01f, 7.07333535e-02f, 1.32528678e-01f,
  -9.86353233e-02f, -5.06835878e-02f, -1.06451198e-01f, -5.22972904e-02f, -5.17068766e-02f, 1.84012316e-02f, -1.61534458e-01f, 1.94257998e-03f, 8.44632313e-02f, 1.13490552e-01f,
  -1.07487582e-01f, 9.22455564e-02f, -1.75969735e-01f, -3.42778713e-02f, 3.78885306e-02f, -1.40829995e-01f, -1.55654177e-01f, 1.73270069e-02f, -5.35092317e-02f, -3.52339633e-02f,
  -1.10203862e-01f, 6.94148475e-03f, -2.09538326e-01f, -5.01749329e-02f, -2.42403641e-01f, -2.39050433e-01f, 1.03645094e-01f, -1.03162073e-01f, -8.76956955e-02f, -3.61770466e-02f,
  1.54071003e-01f, 1.12179257e-01f, 1.15854293e-01f, -5.01921959e-02f, -9.34840441e-02f, 5.53657748e-02f, 3.61861312e-03f, -3.20980735e-02f, 9.43263397e-02f, 3.81386787e-01f,
  2.93320805e-01f, 2.15964988e-01f, 2.78473943e-01f, 7.65140876e-02f, 9.08330157e-02f, 6.44172579e-02f, 1.60818994e-01f, 5.20321429e-02f, -5.36089577e-02f, -9.26149711e-02f,
  1.82735603e-02f, -2.15044081e-01f, 4.67957510e-03f, -2.01267023e-02f, 1.02283157e-01f, 9.18305740e-02f, 6.48738295e-02f, 1.73453763e-01f, 1.10180669e-01f, -8.22673179e-03f,
  -5.73645942e-02f, 2.20518962e-01f, 2.71147847e-01f, 1.42646298e-01f, -1.73739061e-01f, -1.77052438e-01f, 1.91263065e-01f, 1.53600767e-01f, 1.93016808e-02f, -2.57586777e-01f,
  9.38927457e-02f, 1.58571646e-01f, -2.58159727e-01f, -7.07068965e-02f, 2.10079297e-01f, -8.61056373e-02f, -3.37857530e-02f, 5.28601259e-02f, -1.47035541e-02f, -7.32895508e-02f,
  2.82095447e-02f, 1.03038466e-02f, 1.23277247e-01f, 1.15969934e-01f, 1.66287974e-01f, 2.85866279e-02f, 4.99826521e-02f, 1.79196801e-02f, 1.13953322e-01f, 2.27196477e-02f,
  -3.96102993e-03f, 1.93504163e-03f, 2.04559788e-01f, 1.63427755e-01f, 1.49044871e-01f, -7.57310167e-02f, 1.34166479e-01f, 3.48584279e-02f, 1.06278367e-01f, -1.76888973e-01f,
  -1.63348496e-01f, 1.02260243e-02f, 1.07815549e-01f, 3.00587267e-02f, -1.60189532e-02f, 1.59596745e-02f, 2.40035411e-02f, 8.04874748e-02f, 4.07005772e-02f, 4.14354540e-02f,
  -4.88861986e-02f, 4.14403938e-02f, 1.05970241e-01f, 6.67358935e-02f, -6.64644912e-02f, 1.50049582e-01f, 1.06383659e-01f, 3.46637890e-02f, 1.50207877e-01f, 7.33945221e-02f,
  -1.91477407e-02f, 8.33928809e-02f, 8.55492577e-02f, 1.08491488e-01f, -5.59766665e-02f, -1.42736537e-02f, 1.10836690e-02f, 1.05284266e-02f, -4.92154919e-02f, 2.50026621e-02f,
  -2.54420321e-02f, 2.93207347e-01f, -3.01862448e-01f, -1.18234202e-01f, 1.66538116e-02f, 2.11234484e-02f, 3.21806483e-02f, -7.60966167e-02f, 3.32983583e-03f, -8.15955698e-02f,
  6.78163618e-02f, -4.22452129e-02f, 1.92146957e-01f, 5.66507652e-02f, -6.41498640e-02f, -7.16419667e-02f, -1.35694640e-02f, -4.18836623e-02f, 3.41281034e-02f, -1.14096127e-01f,
  1.71940830e-02f, -1.87923849e-01f, -1.86858296e-01f, -2.01243192e-01f, -1.88316151e-01f, -2.92367041e-01f, -8.53667110e-02f, -2.12345365e-02f, -9.01264772e-02f, -1.64617524e-01f,
  -2.08605900e-02f, -9.74926502e-02f, -1.87888399e-01f, 2.51851417e-02f, 1.66483745e-01f, -7.23812729e-02f, -2.30512679e-01f, -2.04639688e-01f, 7.32756332e-02f, -1.48720238e-02f,
  8.90576169e-02f, 1.34581283e-01f, -7.61777014e-02f, -1.27654165e-01f, -4.22370732e-01f, -4.23647463e-01f, -3.63069564e-01f, -4.06846404e-01f, -2.02095866e-01f, 7.23836049e-02f,
  1.21495724e-01f, -1.63410734e-02f, -1.09201081e-01f, -1.03883266e-01f, 2.15331644e-01f, 1.03428021e-01f, -2.19601635e-02f, 5.33329323e-02f, -3.27911675e-02f, 8.55426714e-02f,
  6.55562505e-02f, -1.28143479e-03f, -2.15296410e-02f, 2.40616631e-02f, 7.18215480e-02f, -9.59856901e-03f, -1.83154456e-02f, -5.37394695e-02f, 2.10817978e-02f, -3.65141360e-03f,
  7.83434734e-02f, 5.17399423e-02f, 1.91081986e-02f, 2.59617325e-02f, -7.44587462e-03f, -5.96908517e-02f, -1.38733685e-01f, -1.67236537e-01f, -1.99081957e-01f, -3.55936959e-02f,
  1.02617539e-01f, 3.05582490e-02f, -1.68413565e-01f, -1.37813285e-01f, -8.54365528e-02f, -1.03317415e-02f, 1.26255210e-02f, 7.56353363e-02f, -1.73398882e-01f, -2.28504017e-02f,
  4.32863459e-02f, -2.29491498e-02f, 1.96047425e-02f, 4.35840897e-02f, -1.97108854e-02f, 8.49175379e-02f, -3.16752084e-02f, -7.18210414e-02f, 6.55004308e-02f, 4.36277203e-02f,
  -4.12607454e-02f, 2.17311587e-02f, 2.30882522e-02f, -1.09838825e-02f, -5.45533262e-02f, -4.00178134e-02f, -5.16227726e-03f, -6.19972050e-02f, -9.96178295e-03f, -4.11060601e-02f,
  6.54834835e-03f, 2.55696177e-02f, 9.52743739e-02f, -5.69187589e-02f, 1.60984974e-02f, -1.00348564e-03f, 4.58416529e-02f, 4.83099930e-02f, 4.00928222e-02f, 4.85672206e-02f,
  9.68771055e-02f, -1.45273671e-01f, 5.81778996e-02f, -1.29269063e-01f, -4.90495339e-02f, 1.20670393e-01f, 4.81313765e-02f, -4.73601334e-02f, 5.02552986e-02f, 1.74392685e-02f,
  -4.97226417e-02f, -9.55920294e-02f, -5.19036734e-03f, 6.66332021e-02f, 3.24362591e-02f, -8.64599738e-03f, -1.50383249e-01f, 1.18082818e-02f, -7.39961490e-02f, 1.55252352e-01f,
  -9.32058170e-02f, -1.98215052e-01f, -2.41027907e-01f, -1.82321906e-01f, -6.53394163e-02f, -1.20216906e-01f, -1.28692865e-01f, 1.10697327e-03f, -2.65461028e-01f, -2.10100368e-01f,
  -2.20920563e-01f, -6.58089340e-01f, 3.61380875e-01f, 5.15023246e-02f, 3.20187420e-01f, 1.22682936e-01f, -1.76304772e-01f, -2.86034346e-01f, -1.61948934e-01f, -2.51487672e-01f,
  -3.82903963e-01f, -2.90208936e-01f, -2.89861709e-01f, -2.35559404e-01f, -2.19298676e-01f, -2.83133030e-01f, 7.48668164e-02f, 2.42754772e-01f, 4.00026649e-01f, 1.35007113e-01f,
  -2.12314278e-02f, 8.35194513e-02f, 1.47932515e-01f, 3.17933299e-02f, -1.36243373e-01f, -4.38778512e-02f, 4.01895158e-02f, 1.17712237e-01f, -1.01551414e-01f, -1.68163002e-01f,
  -1.02255801e-02f, -1.62109256e-01f, 1.49890378e-01f, -1.16154499e-01f, -2.88260765e-02f, -1.18886672e-01f, -3.73334922e-02f, 6.84345141e-02f, -1.27588183e-01f, -5.69058098e-02f,
  -7.11953416e-02f, -4.13189083e-02f, -5.46094179e-02f, -1.27406433e-01f, -2.07638852e-02f, 8.00315589e-02f, -9.80488807e-02f, -1.20575555e-01f, -1.11596905e-01f, -8.21549296e-02f,
  -8.00858811e-02f, 9.63611677e-02f, -7.92017281e-02f, -1.76617488e-01f, -6.86508790e-02f, -4.52745706e-02f, -1.20850168e-01f, -1.33186474e-01f, 6.09034952e-03f, -2.09133342e-01f,
  1.98195592e-01f, -1.11580953e-01f, 2.94111967e-02f, 1.76802687e-02f, -3.23023945e-02f, -9.59172547e-02f, 2.83076987e-03f, -1.01801008e-01f, -7.97468238e-03f, -1.07683204e-02f,
  -5.10419942e-02f, -5.06741665e-02f, -7.95857087e-02f, -4.05231304e-02f, -7.71882460e-02f, -8.85771587e-03f, -1.26688480e-01f, -2.94444524e-02f, 1.09979808e-01f, -7.96024799e-02f,
  -1.43717155e-01f, -1.33284628e-01f, 6.68438375e-02f, 4.47561033e-02f, -6.06511235e-02f, -1.58938225e-02f, -9.12196189e-02f, -1.36487018e-02f, -9.98925269e-02f, -1.06653877e-01f,
  -1.62507221e-01f, 3.04040402e-01f, 3.47326547e-02f, -8.61871764e-02f, 2.98541342e-03f, 2.07718294e-02f, 5.61613478e-02f, 6.58518821e-02f, 1.03452906e-01f, 3.46690156e-02f,
  4.35987785e-02f, -2.79087704e-02f, -4.83617634e-02f, 1.44066019e-02f, 2.45422170e-01f, 3.41354683e-02f, -2.53797602e-02f, -2.27376148e-02f, 6.77257329e-02f, -6.15119711e-02f,
  -5.41390441e-02f, 1.30021825e-01f, 1.18646778e-01f, 8.01346824e-02f, 1.35661671e-02f, 1.04952164e-01f, 1.80180043e-01f, 2.03619868e-01f, 1.84229210e-01f, 1.14186659e-01f,
  -2.34440967e-01f, -1.84462547e-01f, 7.46438578e-02f, 1.39770612e-01f, -1.33194283e-01f, -2.33203411e-01f, -3.80116522e-01f, -3.16520214e-01f, -1.67718962e-01f, 6.08991692e-03f,
  6.31180108e-02f, 1.02025464e-01f, 1.79350898e-01f, 1.41834512e-01f, 1.55033022e-01f, -4.71980369e-04f, 1.04697160e-01f, 2.34189734e-01f, 4.79146652e-02f, -1.74431458e-01f,
  7.04485476e-02f, 4.86908555e-02f, 1.42128825e-01f, 7.04056323e-02f, 1.48301408e-01f, 1.43939584e-01f, 1.43736480e-02f, 7.08726328e-03f, 2.79648900e-02f, 3.29713523e-01f,
  4.26790386e-01f, 1.32731602e-01f, 1.63011327e-01f, 9.18244272e-02f, 4.73504998e-02f, -7.62199610e-02f, 5.28136417e-02f, -1.01732742e-02f, -1.19576678e-01f, -5.18313274e-02f,
  -7.94964656e-03f, 3.64523660e-03f, 6.62502572e-02f, -1.21012941e-01f, -8.00164640e-02f, 7.36721884e-03f, -3.83016584e-03f, -3.34314853e-02f, -1.19887115e-02f, 1.37416378e-01f,
  1.31343871e-01f, -9.14221108e-02f, -7.18010068e-02f, -4.48336639e-02f, 3.35927531e-02f, 7.48423263e-02f, -3.47404331e-02f, -8.93678367e-02f, -2.30299253e-02f, -1.80543900e-01f,
  3.88142355e-02f, -7.00731501e-02f, 1.06005028e-01f, 6.34694621e-02f, -7.67872185e-02f, -1.90219611e-01f, -3.06041893e-02f, -1.28322423e-01f, -1.50330346e-02f, -6.62193820e-02f,
  -2.84711123e-02f, 7.04597756e-02f, -5.50329126e-02f, 3.63832302e-02f, 1.58174798e-01f, 9.66529772e-02f, -9.97450352e-02f, 6.22798316e-02f, 1.45641044e-01f, 8.38791206e-02f,
  4.94687259e-02f, 1.60686951e-02f, -7.07008988e-02f, 1.27273783e-01f, -9.00326967e-02f, -1.86780281e-02f, 4.83099408e-02f, -4.26882273e-03f, -1.14261337e-01f, -8.80866274e-02f,
  1.87721178e-01f, 3.29731345e-01f, 1.38716564e-01f, 1.20462723e-01f, 1.44618088e-02f, 8.52607414e-02f, 2.23662972e-01f, 1.55236632e-01f, 4.59840819e-02f, 5.06720357e-02f,
  -4.61926311e-02f, 3.78009044e-02f, -4.28965427e-02f, -6.22015446e-02f, -8.92113447e-02f, 1.09467888e-02f, -2.06295811e-02f, 2.66941078e-02f, 6.32946640e-02f, 1.52803838e-01f,
  4.48096879e-02f, -7.89714828e-02f, -1.55503405e-02f, -2.96446197e-02f, -6.50411397e-02f, -9.76398736e-02f, -1.13599703e-01f, -7.22385570e-02f, -4.34836186e-02f, -1.53098732e-01f,
  3.18166822e-01f, 1.10860258e-01f, -3.31701040e-01f, 4.73304046e-03f, -9.65192094e-02f, -2.23722503e-01f, -1.57924622e-01f, -1.67819247e-01f, 4.62076860e-03f, 1.41930848e-01f,
  1.23447977e-01f, 3.73949036e-02f, -3.85280475e-02f, -1.66957736e-01f, -2.08502367e-01f, -5.04468717e-02f, -7.82345682e-02f, -2.53210366e-01f, -3.91637504e-01f, -1.83512390e-01f,
  4.12418135e-02f, -1.84554514e-02f, -9.94138047e-02f, -1.56852469e-01f, -6.85785562e-02f, -1.37266070e-01f, -1.18782952e-01f, -6.11316301e-02f, -8.21678489e-02f, 9.92205068e-02f,
  -1.59541503e-01f, -7.88512006e-02f, -1.08545311e-01f, 1.96082983e-02f, 4.54264544e-02f, 1.88513584e-02f, -4.34462354e-03f, -1.17511600e-02f, 8.15073475e-02f, -7.47688264e-02f,
  8.25011730e-03f, -2.39978544e-02f, -1.50172440e-02f, -3.39075476e-02f, -1.03936516e-01f, -1.19638778e-01f, -9.08115953e-02f, -1.44013152e-01f, 5.04735997e-03f, -8.18093270e-02f,
  6.66729584e-02f, -3.25179799e-03f, -1.47268891e-01f, -1.06529452e-01f, -2.27637112e-01f, -5.70537522e-02f, -1.84170797e-01f, -2.13425875e-01f, -1.53770581e-01f, 1.36731984e-02f,
  8.70716125e-02f, -7.04278238e-03f, 3.08630858e-02f, 2.29377914e-02f, 7.01509118e-02f, 7.10299313e-02f, -2.55302973e-02f, -5.74938431e-02f, 3.78124900e-02f, -3.50674465e-02f,
  -7.81027898e-02f, 9.44072530e-02f, -3.31243463e-02f, -3.92500907e-02f, -9.45354775e-02f, -2.61269528e-02f, 1.59065887e-01f, 2.55874209e-02f, -3.17046009e-02f, -8.09491239e-03f,
  -4.01647799e-02f, -7.56738111e-02f, 1.15954429e-02f, 3.95251028e-02f, 6.42020628e-02f, 1.59740704e-03f, 1.23716495e-03f, -3.11109126e-02f, -5.92109635e-02f, 1.60261039e-02f,
  5.88593036e-02f, -2.17007492e-02f, 1.17533572e-01f, -4.99884039e-02f, -4.21313904e-02f, 1.47268567e-02f, 1.60866246e-01f, 1.24778658e-01f, 7.20831901e-02f, -9.80118290e-03f,
  -1.15571722e-01f, 2.42406898e-03f, -1.84988547e-02f, 5.81054352e-02f, -4.39758785e-02f, -7.71084353e-02f, 2.01816987e-02f, 6.68600276e-02f, 7.99397081e-02f, 8.54674354e-02f,
  1.96385980e-02f, 2.31820438e-02f, 8.78329650e-02f, 5.70858158e-02f, -7.96292797e-02f, -4.45341982e-04f, -5.06447703e-02f, -2.99840793e-02f, -1.63783729e-02f, 1.81142107e-01f,
  2.60666400e-01f, 1.17211580e-01f, 5.84601276e-02f, 3.00068974e-01f, 9.80573073e-02f, -2.11148694e-01f, -3.95740807e-01f, -1.74170867e-01f, 1.54223546e-01f, 2.58153006e-02f,
  1.82335570e-01f, -4.07468192e-02f, -4.77152131e-02f, -2.86075056e-01f, -4.41945434e-01f, -3.35093856e-01f, -2.95490652e-01f, -2.77087718e-01f, -3.19819838e-01f, -2.28783280e-01f,
  -1.07085682e-01f, 1.05433270e-01f, -5.34055717e-02f, 3.85384858e-02f, 2.79835075e-01f, 1.57687306e-01f, 1.94348574e-01f, 1.58263728e-01f, 7.17344582e-02f, 1.51982069e-01f,
  1.11672200e-01f, 3.54602814e-01f, -1.91618577e-01f, 1.17654512e-02f, 1.50965050e-01f, -4.39973474e-02f, -9.89151672e-02f, 9.67361256e-02f, -1.33692324e-01f, -3.68556194e-02f,
  7.00396821e-02f, 6.56887516e-02f, -6.38766661e-02f, -1.06559113e-01f, -8.70622287e-04f, -9.68792066e-02f, -9.41982344e-02f, -2.22549170e-01f, -9.93334949e-02f, -1.11847930e-02f,
  -2.02223986e-01f, -1.68416146e-02f, 1.25060022e-01f, -1.39928177e-01f, 1.61229596e-02f, -1.02251470e-01f, 1.27147153e-01f, 1.40588000e-01f, -4.44792323e-02f, 2.13591740e-01f,
  1.88740846e-02f, 5.44379130e-02f, 5.81784509e-02f, 9.60639417e-02f, -7.68997148e-02f, 8.51741619e-03f, 9.06564519e-02f, 1.09879710e-01f, 1.34415552e-02f, -3.14582624e-02f,
  -6.02870509e-02f, -1.40994461e-02f, 5.04798368e-02f, -1.93896033e-02f, -5.83912171e-02f, 1.77088246e-01f, -5.90773448e-02f, -3.89397182e-02f, -6.12093881e-02f, 5.44523858e-02f,
  -3.06209680e-02f, 8.82090330e-02f, 1.27281696e-01f, -1.53144803e-02f, 8.12246650e-02f, -9.91778821e-02f, 6.33222535e-02f, 1.17054716e-01f, 1.60570860e-01f, 1.32681727e-01f,
  1.11706570e-01f, -2.95155823e-01f, -1.42889516e-02f, -8.46433118e-02f, 9.97521877e-02f, 2.73068454e-02f, 8.02432373e-02f, -8.50357562e-02f, 1.26989111e-01f, -3.22691649e-02f,
  4.76201773e-02f, -7.24945441e-02f, 5.43247052e-02f, -7.48455897e-02f, -1.81508407e-01f, -3.15997377e-02f, -2.51655132e-01f, -5.85151091e-02f, -1.40414417e-01f, 6.40599504e-02f,
  -3.27043571e-02f, -2.09707171e-01f, -1.84428602e-01f, -2.30890825e-01f, 7.67512918e-02f, -2.50843436e-01f, -1.44898146e-01f, -4.70618950e-03f, -1.90047354e-01f, -2.77269602e-01f,
  -2.53978968e-01f, -3.97902846e-01f, -6.86512142e-02f, -2.61982828e-01f, -2.41701141e-01f, -1.17124610e-01f, -3.87569010e-01f, -1.21198326e-01f, -7.52748176e-02f, -3.92723769e-01f,
  -1.42118081e-01f, 1.08062193e-01f, 1.04757296e-02f, 9.26603973e-02f, 1.00368463e-01f, -3.96914154e-01f, -2.58178145e-01f, 1.00511469e-01f, 3.51013124e-01f, -2.70617288e-02f,
  -1.84540570e-01f, -4.23210263e-02f, 2.01099157e-01f, 7.39259347e-02f, -2.90153593e-01f, 8.10245201e-02f, -9.74763855e-02f, -1.08332567e-01f, -1.22643150e-01f, -3.52591217e-01f,
  -1.74269512e-01f, -5.31467050e-02f, 1.71105534e-01f, 1.01892307e-01f, -3.82159352e-02f, -4.62956727e-03f, -6.25926107e-02f, 1.15353316e-01f, 9.69894528e-02f, -1.21084176e-01f,
  4.77340072e-03f, 5.40168732e-02f, -8.96244217e-03f, 6.21950440e-02f, -6.66270107e-02f, -9.12676472e-03f, 2.85104550e-02f, 5.74568696e-02f, -2.30308995e-02f, -1.25584796e-01f,
  -2.09563941e-01f, -1.05086334e-01f, -2.59856433e-02f, -1.82594303e-02f, 8.99736807e-02f, 1.05673417e-01f, 1.53987873e-02f, 1.20521590e-01f, 9.24874917e-02f, -2.43092850e-01f,
  -1.50045389e-02f, 2.50642505e-02f, -4.82647642e-02f, 7.79681280e-02f, 4.39951047e-02f, -7.04924315e-02f, 4.77576116e-03f, -2.55762022e-02f, 5.87358698e-02f, 4.73770872e-02f,
  1.25294633e-03f, -1.11173457e-02f, 6.18966967e-02f, -9.92585123e-02f, 2.24326067e-02f, -3.94829065e-02f, -9.78608206e-02f, -4.83914558e-03f, -5.75386584e-02f, 4.62426059e-03f,
  4.89061363e-02f, 1.79302152e-02f, -2.29152776e-02f, 7.80241564e-02f, 2.61897147e-02f, 3.70433107e-02f, -1.04639485e-01f, 3.93266529e-02f, 2.10403092e-02f, -9.28988829e-02f,
  -1.94620956e-02f, 1.93739340e-01f, -1.55104533e-01f, 1.22926570e-01f, -6.78397790e-02f, 5.90627529e-02f, 1.17266327e-02f, 1.07192330e-01f, 1.07496185e-02f, -9.88343284e-02f,
  8.57012495e-02f, -3.28425989e-02f, -1.19336955e-01f, 4.25560772e-02f, 8.56449306e-02f, -1.55621557e-03f, -1.39941707e-01f, -8.61062706e-02f, 7.40295351e-02f, -1.29190192e-01f,
  -1.18538305e-01f, -9.12671611e-02f, -1.76660657e-01f, -9.60906148e-02f, -4.10280749e-02f, 6.74134493e-02f, -8.66937041e-02f, -2.86654644e-02f, 1.63939986e-02f, -3.16123098e-01f,
  -1.22577101e-01f, -4.30052489e-01f, -7.62503520e-02f, -8.13202038e-02f, -2.45441496e-01f, -1.74878508e-01f, -3.38220626e-01f, -7.49765784e-02f, -6.36065453e-02f, -3.38611633e-01f,
  -1.50790140e-01f, 3.12684923e-02f, -1.84299592e-02f, -4.65630367e-03f, 9.37007144e-02f, -2.05628365e-01f, -1.14935167e-01f, 1.11703843e-01f, 1.76071554e-01f, -1.12382777e-01f,
  -1.97470546e-01f, -2.23064944e-02f, 1.42377436e-01f, 5.47103658e-02f, -2.67401516e-01f, -4.99405935e-02f, -1.58769190e-01f, -1.38015762e-01f, -1.21116117e-01f, -3.05872619e-01f,
  -1.89000726e-01f, -1.22765251e-01f, 1.13933511e-01f, 2.18438022e-02f, -7.06000254e-02f, 5.96254021e-02f, -3.61600220e-02f, 4.43090796e-02f, 1.19011821e-02f, -5.98519593e-02f,
  -5.23059769e-03f, -1.33530879e-02f, 1.43875815e-02f, -1.55934086e-02f, -5.08167520e-02f, -4.33540605e-02f, 6.72023818e-02f, 3.62054110e-02f, 3.45333591e-02f, -8.91360044e-02f,
  -1.37940377e-01f, -1.10842727e-01f, -2.93725170e-02f, -2.07722802e-02f, 5.97443581e-02f, 9.32757705e-02f, -4.29285169e-02f, -2.93364991e-02f, 4.46776710e-02f, -2.28609309e-01f,
  -7.41741210e-02f, -3.24367126e-03f, 3.21801156e-02f, 2.33607292e-02f, 8.77668187e-02f, -3.03245187e-02f, 1.60527565e-02f, -3.80667038e-02f, 3.68147455e-02f, -6.92424104e-02f,
  -5.18121831e-02f, 9.81741119e-03f, 8.14379472e-03f, -9.62585062e-02f, -4.73621376e-02f, 1.28211407e-02f, -2.08173711e-02f, 1.71453767e-02f, 1.18335579e-02f, 2.22622901e-02f,
  -2.35352237e-02f, -3.06362156e-02f, 4.23367508e-03f, 2.13728324e-02f, -6.40003458e-02f, -6.13973476e-03f, -1.84021275e-02f, -1.61114000e-02f, -2.20279396e-02f, -9.12437662e-02f,
  5.30156121e-02f, 1.49752602e-01f, -1.27116948e-01f, 3.74446660e-02f, -3.98882590e-02f, -5.67434872e-05f, -4.56300750e-02f, 9.97974947e-02f, 1.95452454e-03f, -1.06391385e-01f,
  -2.69155353e-02f, -2.50280928e-02f, -5.05391732e-02f, 1.65914204e-02f, -2.14591087e-03f, -7.42712542e-02f, -9.12248809e-03f, -1.27507299e-01f, 5.72027080e-02f, -9.42075998e-03f,
  -3.11314058e-03f, -5.03064245e-02f, -4.68246713e-02f, -4.11633924e-02f, -6.86670765e-02f, 4.67062481e-02f, -9.92347598e-02f, -1.20647445e-01f, 5.42236082e-02f, -1.83094949e-01f,
  -1.33558273e-01f, 2.28272945e-01f, 5.43318614e-02f, 2.10928723e-01f, -1.20073324e-02f, -3.33075106e-01f, -2.08541408e-01f, -2.71122515e-01f, 1.10026293e-01f, 2.95552820e-01f,
  1.93902358e-01f, -9.95808169e-02f, -4.35249098e-02f, -2.36097530e-01f, -4.82359707e-01f, -1.45134211e-01f, -5.68436608e-02f, -3.57301146e-01f, -5.81794322e-01f, -4.19004202e-01f,
  -7.17175305e-02f, -2.05233153e-02f, -1.41374573e-01f, -4.47088853e-02f, 1.87431350e-01f, -3.63829583e-02f, 1.14461496e-01f, -2.96927094e-02f, -7.15690851e-02f, 2.08986893e-01f,
  1.45374224e-01f, -3.44395600e-02f, -1.95373222e-01f, -3.91323380e-02f, 1.57386720e-01f, -4.29603159e-02f, -6.96419971e-03f, 7.45080337e-02f, 8.03577080e-02f, 1.26311153e-01f,
  6.74363747e-02f, 6.74910992e-02f, -1.41945565e-02f, 3.90092246e-02f, -2.96719298e-02f, -6.90193400e-02f, 4.49470570e-03f, -1.13648169e-01f, -4.56595533e-02f, 9.71811339e-02f,
  1.02837989e-02f, 1.96747873e-02f, -1.05910666e-01f, -4.90098260e-02f, -1.45694584e-01f, -1.32357582e-01f, -1.60504114e-02f, -9.81415734e-02f, -8.61279741e-02f, 1.70535266e-01f,
  -1.36194140e-01f, -1.42829102e-02f, 6.58602268e-02f, 1.29815385e-01f, 1.57109410e-01f, 5.91711514e-02f, 1.29933029e-01f, 1.11910611e-01f, -7.75018781e-02f, 8.19539875e-02f,
  4.92607057e-02f, 1.01218767e-01f, 8.23120251e-02f, 1.27329275e-01f, 1.33427128e-01f, -1.35348206e-02f, 2.81585176e-02f, 1.19559653e-01f, 3.58646475e-02f, 1.91261902e-01f,
  1.00867651e-01f, 1.19268812e-01f, 7.81077892e-02f, 6.08920269e-02f, 2.38738898e-02f, 1.58813730e-01f, 7.42302760e-02f, 1.08558170e-01f, -4.79083732e-02f, 1.26774237e-01f,
  2.15860188e-01f, -1.70842901e-01f, 1.76955670e-01f, -4.52378504e-02f, 5.30514168e-04f, 2.37939898e-02f, 1.40098482e-01f, 1.75819546e-01f, 1.50409684e-01f, 1.32930323e-01f,
  -1.47914598e-02f, 4.28132601e-02f, 1.11122377e-01f, -2.46906336e-02f, -8.12297538e-02f, 5.46628460e-02f, 1.28602043e-01f, 4.80288900e-02f, -8.37543085e-02f, 1.98313594e-01f,
  1.07586600e-01f, -8.65992159e-02f, -2.96123177e-02f, 4.22229320e-02f, -5.57307228e-02f, -1.21332534e-01f, 6.09345622e-02f, -7.83019513e-03f, -8.16973150e-02f, 1.80350438e-01f,
  -5.08710742e-01f, 8.45091268e-02f, 2.93014348e-01f, -3.60583544e-01f, 1.85289547e-01f, 1.85451075e-01f, 3.20066363e-01f, 3.14815976e-02f, -7.74662346e-02f, 1.30686179e-01f,
  2.73776241e-02f, -1.36205748e-01f, -3.79591323e-02f, -1.22829854e-01f, -2.13753238e-01f, 2.42848366e-01f, 2.40456671e-01f, -2.27900445e-01f, -3.42916459e-01f, -2.12483883e-01f,
  -1.54911280e-01f, -3.22158009e-01f, -3.65197301e-01f, -2.71855623e-01f, 3.23088169e-02f, -2.91246325e-02f, 9.19470042e-02f, 1.16747627e-02f, 3.02082039e-02f, 1.30844101e-01f,
  1.44566461e-01f, -7.46548772e-02f, -2.80719027e-02f, -1.72622919e-01f, -1.75280981e-02f, -8.46978724e-02f, -1.07769802e-01f, -1.46121025e-01f, -1.71676964e-01f, 3.85393994e-03f,
  -7.62910619e-02f, -5.65488487e-02f, -1.09216131e-01f, 3.88960466e-02f, -7.48909190e-02f, -2.23503113e-01f, -1.22723185e-01f, -2.32630223e-01f, -4.11910862e-02f, -2.50298455e-02f,
  1.23720327e-02f, -1.24704801e-01f, -1.23226643e-02f, -3.18737924e-02f, -2.63800174e-02f, -2.86123548e-02f, 9.00071189e-02f, -8.71243849e-02f, -7.76818395e-02f, -6.12124288e-03f,
  -5.49928434e-02f, -6.25880659e-02f, -1.32371202e-01f, 8.29021633e-03f, -7.74295926e-02f, -8.78825113e-02f, -3.66761088e-02f, -5.14118932e-03f, -1.98071990e-02f, -6.65450562e-03f,
  -4.29426357e-02f, 2.27691382e-02f, -4.50928928e-03f, -4.18905728e-02f, -8.86218324e-02f, -7.49972090e-02f, -3.73437069e-02f, -4.23831232e-02f, 4.24626246e-02f, -1.04576349e-02f,
  9.17560793e-03f, 1.11291841e-01f, 5.86991608e-02f, -2.47356035e-02f, 3.02334148e-02f, -1.17250763e-01f, -7.56342430e-03f, 4.11744863e-02f, 2.48569604e-02f, 6.62417859e-02f,
  4.55652364e-02f, -8.39001387e-02f, 1.00973561e-01f, -8.45623910e-02f, 5.75642996e-02f, 4.37489785e-02f, -9.65880044e-03f, -5.97468205e-02f, -2.77494099e-02f, -8.48737136e-02f,
  -1.03699766e-01f, -3.98650505e-02f, 8.00484568e-02f, 7.62644410e-02f, -1.86981857e-01f, -4.46135364e-02f, -1.15676284e-01f, 6.49830550e-02f, 2.07163040e-02f, 1.09190606e-01f,
  9.73149836e-02f, 1.30634876e-02f, -5.46029992e-02f, 1.44397259e-01f, 8.17309767e-02f, -6.77595362e-02f, 4.45252061e-02f, 1.05514288e-01f, -8.12580884e-02f, -2.75453962e-02f,
  4.33480591e-02f, 2.41932362e-01f, -1.53122380e-01f, -7.11058173e-03f, 1.41905472e-02f, -1.32190716e-02f, -2.52711885e-02f, 1.06635980e-01f, 1.08655952e-01f, 8.91247839e-02f,
  2.30538458e-01f, 2.88657695e-01f, 1.50319546e-01f, 1.77403256e-01f, 1.08275220e-01f, -6.58650249e-02f, -6.76784590e-02f, -1.80295296e-02f, -5.57647273e-02f, -3.37812901e-02f,
  1.09674685e-01f, -1.03820032e-02f, 5.82561502e-03f, 3.35233733e-02f, -8.42156187e-02f, 7.87513703e-02f, 5.36597706e-02f, -4.96180356e-02f, -7.93304518e-02f, -5.28095588e-02f,
  -1.02752186e-01f, -2.62281656e-01f, 7.37272277e-02f, -3.45340967e-02f, -1.18344016e-01f, 3.71958204e-02f, -3.25318985e-02f, -7.55115151e-02f, -3.89333554e-02f, -1.02431364e-01f,
  -5.79440258e-02f, -2.22499352e-02f, -1.38955459e-01f, -6.92084357e-02f, -1.13677941e-01f, -6.35242611e-02f, 1.21812373e-02f, 5.49273901e-02f, -1.09215476e-01f, -9.79414955e-02f,
  -1.40739694e-01f, -6.96271136e-02f, -4.78915423e-02f, -9.56043378e-02f, -1.06410503e-01f, -9.07473192e-02f, -7.00193830e-03f, -1.33675411e-01f, -7.37150311e-02f, 6.63315412e-03f,
  -1.47119239e-01f, 7.21415319e-03f, -1.36935785e-01f, -2.56721620e-02f, 8.45146775e-02f, -1.18535338e-03f, -1.39565654e-02f, 3.04969903e-02f, 2.54283044e-02f, 3.36244404e-02f,
  9.15575176e-02f, -8.62653553e-02f, -3.16920690e-02f, 8.96452516e-02f, 1.40374705e-01f, -8.69393945e-02f, -2.27069929e-02f, 6.70601102e-03f, -1.14038788e-01f, -1.47682995e-01f,
  -2.34497283e-02f, -5.53063005e-02f, 3.33399069e-03f, -9.15271137e-03f, -8.48549157e-02f, -8.22937191e-02f, -1.41130341e-02f, -5.17423381e-04f, 1.66971667e-03f, 3.46300602e-02f,
  2.45307684e-01f, -1.65458351e-01f, -5.41080013e-02f, -1.06568970e-01f, -1.87590256e-01f, -8.82105008e-02f, -1.42063737e-01f, -1.24025397e-01f, -7.11747408e-02f, -1.92248970e-02f,
  -4.58195433e-02f, -1.53607413e-01f, 3.97663154e-02f, 4.70470153e-02f, 1.86601151e-02f, -2.31838785e-02f, -2.22654140e-04f, -6.04948737e-02f, 1.61255244e-02f, 4.24535796e-02f,
  7.26234168e-02f, -2.70554405e-02f, 4.23747227e-02f, 7.73724094e-02f, 1.12280145e-01f, 7.50786141e-02f, 2.33462565e-02f, -3.79008129e-02f, -4.96763252e-02f, 1.01488538e-01f,
  3.95171285e-01f, 5.18774509e-01f, 2.52453983e-01f, -5.86367883e-02f, -2.58568347e-01f, 3.27491201e-02f, 3.06451857e-01f, 2.79220819e-01f, 1.76706478e-01f, 1.10772304e-01f,
  7.80022070e-02f, 1.02254935e-01f, 1.53441906e-01f, 9.98593494e-02f, 2.69918978e-01f, 1.70074403e-01f, 1.22493282e-01f, 2.18522534e-01f, 8.71091336e-02f, 6.15560152e-02f,
  -5.68680977e-03f, -1.29232658e-02f, 9.43500698e-02f, 5.45995533e-02f, 9.25605893e-02f, 1.10265538e-02f, 3.86683233e-02f, -1.21049345e-01f, -4.41581123e-02f, 1.24389850e-01f,
  -9.67343673e-02f, 5.09613845e-03f, -6.06231913e-02f, -5.20050712e-02f, -9.33357328e-03f, 1.38897255e-01f, -4.67651188e-02f, 1.59089845e-02f, -6.93572238e-02f, 2.30823569e-02f,
  -8.61506760e-02f, 1.61829405e-02f, -3.38651091e-02f, -2.97010746e-02f, -9.62811559e-02f, -4.08262946e-02f, 1.00612603e-01f, 5.64282052e-02f, 1.06078222e-01f, 3.66455950e-02f,
  4.96642254e-02f, -1.82561338e-01f, -4.98054698e-02f, 4.32031043e-02f, 3.57063450e-02f, 5.10667218e-03f, -5.37695959e-02f, 6.05919138e-02f, -3.34617160e-02f, 7.64211565e-02f,
  9.41115916e-02f, 2.09250137e-01f, -1.67466048e-02f, -6.58905357e-02f, 3.71470749e-02f, -6.50422201e-02f, -8.20564404e-02f, -7.69319609e-02f, 2.41544936e-02f, -1.02252088e-01f,
  -2.06693694e-01f, -9.06159803e-02f, -4.17919978e-02f, -1.78520143e-01f, -2.59073470e-02f, 4.41555455e-02f, -3.61821726e-02f, -2.11096741e-02f, -1.97013408e-01f, -4.14785706e-02f,
  -1.20964274e-01f, -4.01053801e-02f, -5.86719289e-02f, -9.64449942e-02f, -7.69074187e-02f, 3.48684815e-04f, -7.03554153e-02f, -4.78342324e-02f, 4.22455147e-02f, 9.41684619e-02f,
  -1.28988937e-01f, -2.84760118e-01f, 5.55577949e-02f, 1.95143297e-01f, -3.99111360e-02f, 1.03933454e-01f, 2.31736526e-02f, -1.09489799e-01f, -5.89865148e-02f, -1.34690270e-01f,
  -3.53123955e-02f, 1.01869859e-01f, -3.60277295e-02f, -1.40066389e-02f, -2.35153958e-01f, -1.46009937e-01f, -1.00637684e-02f, 7.25193620e-02f, 6.90633580e-02f, 5.12700640e-02f,
  9.39362645e-02f, -1.00990467e-01f, 1.33523028e-02f, -1.13984041e-01f, -1.35376081e-02f, -1.26624733e-01f, -6.03578314e-02f, -8.45624134e-02f, -1.00118198e-01f, -9.27269906e-02f,
  -3.39992911e-01f, -2.73587048e-01f, 6.38471767e-02f, -4.07290369e-01f, -1.25998363e-01f, -3.26439850e-02f, -2.48091936e-01f, -1.82019293e-01f, -1.81515262e-01f, -3.45837384e-01f,
  -1.42796472e-01f, 2.36906093e-02f, -1.06282301e-01f, -3.82334143e-02f, -6.86302632e-02f, -3.22639078e-01f, -2.34269127e-01f, 2.26087663e-02f, 1.29907265e-01f, 7.33022578e-03f,
  -8.74233469e-02f, -7.23031387e-02f, 9.46854334e-03f, -3.24837901e-02f, -2.51709908e-01f, 2.85114371e-03f, -1.17005572e-01f, -6.54760599e-02f, -6.33196832e-05f, -2.75306910e-01f,
  -2.32527211e-01f, -2.68252809e-02f, 8.57339278e-02f, 3.04002501e-02f, -3.39704975e-02f, -2.17381567e-02f, -8.43108445e-02f, 2.04914417e-02f, 4.39592451e-02f, -3.63615416e-02f,
  -2.74283923e-02f, 4.33182679e-02f, -4.04637754e-02f, -4.62269001e-02f, -7.61642680e-02f, -5.92112429e-02f, -3.55802961e-02f, 5.93882613e-02f, -3.44551057e-02f, 1.67543758e-02f,
  -6.96590096e-02f, -3.01775672e-02f, -1.18067134e-02f, 2.51481924e-02f, -5.10137081e-02f, 9.96769220e-02f, 8.88878703e-02f, 1.23635262e-01f, 9.17480588e-02f, -2.34643981e-01f,
  -6.66369423e-02f, 3.15150656e-02f, -1.95128769e-02f, 6.10221885e-02f, 1.54906120e-02f, 8.58743861e-02f, -9.47787315e-02f, -8.29648077e-02f, 1.26402646e-01f, 5.76448813e-03f,
  -2.13961191e-02f, 1.32420138e-02f, 2.63600200e-02f, -7.30129555e-02f, 2.66319737e-02f, -5.09237424e-02f, -1.79060251e-02f, -3.69603299e-02f, -5.33068972e-03f, -7.81016750e-03f,
  5.13649471e-02f, -3.10939439e-02f, -3.30971414e-03f, -1.96037255e-02f, 3.04833036e-02f, -8.15312192e-02f, -2.99999435e-02f, 7.72428587e-02f, 4.42857668e-02f, 6.89560547e-02f,
  -2.05022305e-01f, 2.09220886e-01f, -2.38797456e-01f, 1.87827107e-02f, -2.96866409e-02f, 2.06546821e-02f, 1.06623657e-02f, -1.62163138e-04f, 2.92334729e-03f, -5.69023229e-02f,
  5.92615120e-02f, -9.06364396e-02f, -9.25350338e-02f, 8.07273164e-02f, -3.84330470e-03f, 5.74992485e-02f, -1.23636961e-01f, -1.45792708e-01f, 3.07807513e-02f, 1.79753266e-02f,
  -7.02041611e-02f, -1.14715524e-01f, -2.14324251e-01f, -2.01747447e-01f, -1.10251278e-01f, -2.64661503e-04f, -4.56727892e-02f, 1.38962688e-02f, -2.04842873e-02f, -3.38510484e-01f,
  -7.89702311e-02f, -3.04653019e-01f, 4.03886199e-01f, -2.75107741e-01f, -7.64951780e-02f, -2.02913443e-03f, -9.51221511e-02f, -2.92670965e-01f, -2.83580691e-01f, -2.21440986e-01f,
  -1.34532481e-01f, -3.58423330e-02f, 5.70802391e-02f, 5.99200428e-02f, 2.06427231e-01f, -2.64247209e-02f, 1.34264722e-01f, 3.83391321e-01f, 4.47456956e-01f, 9.43281048e-04f,
  -1.91970319e-01f, -8.70635733e-02f, -1.23637449e-02f, -1.07832804e-01f, -2.79998600e-01f, 4.87977080e-02f, -1.00037135e-01f, -1.32798657e-01f, -3.54394838e-02f, -2.71044731e-01f,
  5.21912500e-02f, -3.84432912e-01f, 3.34729697e-03f, -1.04655653e-01f, -6.50397986e-02f, 7.69427791e-02f, -3.20165344e-02f, -1.96229488e-01f, -9.91592035e-02f, -1.39712647e-01f,
  -8.82017314e-02f, -3.25227194e-02f, -7.37240389e-02f, -1.00335285e-01f, -7.23064840e-02f, -1.04206920e-01f, -1.19219996e-01f, -8.29397067e-02f, 3.68030332e-02f, -3.52275111e-02f,
  -1.68530807e-01f, -6.98699579e-02f, 3.99828590e-02f, -2.91205626e-02f, -1.29648358e-01f, 1.50969699e-01f, -1.18710905e-01f, -1.00967273e-01f, 5.36064245e-02f, -1.21582963e-01f,
  -5.32800481e-02f, 1.38161257e-01f, -6.57843649e-02f, 7.43651688e-02f, 1.39304977e-02f, 1.37178794e-01f, 7.42368847e-02f, 7.81292617e-02f, 4.98530194e-02f, 5.99274412e-02f,
  1.36131361e-01f, 2.81251818e-02f, 4.64796871e-02f, -1.12094181e-02f, 4.98224841e-03f, 3.40251327e-02f, 1.04648754e-01f, -8.50850493e-02f, -1.30198315e-01f, 6.53939471e-02f,
  -2.57498957e-02f, 2.39007026e-02f, 4.48848195e-02f, -4.08806987e-02f, 5.80760129e-02f, 1.63327947e-01f, 3.27799618e-02f, 8.71898085e-02f, 3.40721682e-02f, -2.58967560e-02f,
  4.77788225e-02f, 1.71346545e-01f, -1.57790124e-01f, -6.32703304e-02f, -1.06068097e-01f, -8.94717351e-02f, -1.55063048e-01f, -2.06518546e-01f, -9.42474827e-02f, 6.94032852e-03f,
  -1.10600092e-01f, -3.50177661e-02f, 6.30192161e-02f, -1.76811800e-03f, 5.95964640e-02f, -1.71472579e-02f, -8.10624808e-02f, 8.53970498e-02f, 1.13127194e-02f, 5.63673154e-02f,
  -7.09407255e-02f, 2.44444590e-02f, 2.61400044e-01f, 1.12175800e-01f, -1.24960572e-01f, 2.25843325e-01f, 3.41103859e-02f, 1.14025511e-01f, 2.40106210e-01f, -6.94299536e-03f,
  5.29023230e-01f, 1.10377170e-01f, -2.54529655e-01f, 3.51616055e-01f, -2.00096771e-01f, -4.83170211e-01f, -4.14647818e-01f, 7.11380765e-02f, 2.78603435e-01f, 8.85933936e-02f,
  -2.30311647e-01f, -2.02176824e-01f, -4.24670056e-03f, -1.97043136e-01f, -2.45238706e-01f, -7.66029656e-02f, -1.22029632e-02f, -1.70485705e-01f, -3.24952275e-01f, -3.64412665e-01f,
  -1.74414858e-01f, 7.22062076e-03f, 1.16425686e-01f, 5.51482057e-03f, 2.65799224e-01f, -4.22481000e-02f, 1.63085848e-01f, 1.43614635e-02f, -2.01747030e-01f, 2.16113865e-01f,
  -7.80412136e-03f, 2.81387448e-01f, -3.07616532e-01f, -7.37278759e-02f, -3.54630649e-02f, -7.16760242e-03f, -1.43115237e-01f, 5.13359606e-02f, -8.71596858e-02f, 3.01846340e-02f,
  -1.77508965e-01f, -1.00972705e-01f, -2.87285503e-02f, -1.06254831e-01f, -2.34484691e-02f, 1.81956105e-02f, 8.45831931e-02f, -4.46612351e-02f, 6.84129074e-03f, -8.52605477e-02f,
  -1.79640234e-01f, -1.32654130e-01f, -9.67100263e-02f, 5.42980153e-03f, 2.24137697e-02f, -1.12326883e-01f, -5.09943627e-03f, -2.16578525e-02f, -7.60575384e-02f, 3.31843078e-01f,
  1.32345045e-02f, -8.82649124e-02f, -1.95918027e-02f, 8.54447857e-02f, 4.24484126e-02f, 3.83801088e-02f, 6.37954772e-02f, -1.33937867e-02f, -3.04622669e-02f, -5.90627128e-03f,
  1.08241655e-01f, 9.75516066e-02f, -2.17746813e-02f, 5.46535179e-02f, 3.61672137e-03f, -3.91932353e-02f, -5.77786304e-02f, 4.00551297e-02f, -2.30421405e-02f, 3.97439860e-02f,
  -5.14616147e-02f, -5.06041348e-02f, -5.98367415e-02f, 4.97152805e-02f, -1.75816659e-02f, 9.22293309e-03f, -1.65918712e-02f, -6.03151247e-02f, -5.05392812e-02f, -2.48944983e-02f,
  5.84611893e-02f, -3.68786871e-01f, 1.06448226e-01f, -7.43746683e-02f, 5.03232963e-02f, 7.15180533e-04f, -9.00972486e-02f, -6.03523627e-02f, 8.88452828e-02f, -3.17508429e-02f,
  -2.12603644e-01f, -3.84298116e-02f, 1.19079612e-01f, -4.86136600e-02f, -6.92157447e-02f, 3.45831271e-04f, -7.57198632e-02f, -6.92254528e-02f, -1.54953569e-01f, -7.05162287e-02f,
  8.73615667e-02f, -4.11683023e-02f, -1.84221100e-02f, 7.51151294e-02f, 9.67430975e-03f, -1.40722975e-01f, -7.71269668e-03f, -8.63155723e-02f, -1.73441797e-01f, 2.34002113e-01f,
  5.23537993e-01f, 4.19097960e-01f, 2.34742537e-01f, 1.08353302e-01f, 1.30058557e-01f, -1.16513930e-01f, -2.67045379e-01f, -5.08255437e-02f, -1.29499242e-01f, 1.49233034e-02f,
  7.94730633e-02f, 5.80641301e-03f, -1.34797975e-01f, -2.25268766e-01f, -1.28417671e-01f, -2.55535871e-01f, -2.11958915e-01f, -5.23320287e-02f, -2.36080643e-02f, 1.26325609e-02f,
  1.78861544e-02f, 1.70193434e-01f, 1.28967226e-01f, 3.43154632e-02f, 2.45539546e-01f, -1.38029912e-02f, 2.47854814e-02f, 2.17549518e-01f, 4.62007225e-02f, 1.87337413e-01f,
  2.22302839e-01f, 4.09846008e-01f, -5.39889395e-01f, -5.54548055e-02f, 5.86601794e-02f, -1.05375499e-01f, -1.70861691e-01f, 2.30997875e-02f, -1.03225157e-01f, -4.07422893e-02f,
  4.12709340e-02f, 8.10303167e-02f, 1.00385509e-01f, -1.63927019e-01f, 3.89217921e-02f, -7.24237785e-02f, 1.03792153e-01f, 1.75070460e-03f, -2.00763553e-01f, 1.73976600e-01f,
  -1.31658316e-01f, 1.85672656e-01f, 2.43147939e-01f, -1.11147813e-01f, 1.74282175e-02f, -1.39142379e-01f, 8.39200765e-02f, 1.91011623e-01f, -1.75162315e-01f, 1.47080570e-01f,
  -8.47572237e-02f, 9.96927023e-02f, -5.30579761e-02f, 1.11385785e-01f, -1.98190898e-01f, -8.87043700e-02f, -6.85711205e-02f, 8.34163204e-02f, -4.73328382e-02f, 6.74676374e-02f,
  -8.71482044e-02f, -9.51143652e-02f, 7.25670829e-02f, -7.61861950e-02f, -1.30784750e-01f, -2.52429452e-02f, -3.35999131e-02f, -2.20049351e-01f, -8.20520222e-02f, 3.41162123e-02f,
  -2.58928332e-02f, -5.29817641e-02f, 5.44225276e-02f, -9.49193016e-02f, -9.89986137e-02f, -2.01137830e-02f, -1.11520603e-01f, 4.75305840e-02f, 1.56606197e-01f, 9.49671194e-02f,
  -9.59116593e-02f, -3.14614207e-01f, -6.25210255e-02f, -8.06416571e-03f, 1.07902557e-01f, -8.52639079e-02f, -8.98072943e-02f, -7.57291242e-02f, 6.69471994e-02f, 8.10800269e-02f,
  7.08185211e-02f, -6.05575740e-02f, -4.33820114e-03f, -2.06865266e-01f, -1.13366134e-01f, -1.48570370e-02f, -1.45154387e-01f, -1.27798066e-01f, -1.84533954e-01f, 2.53843695e-01f,
  -8.85977894e-02f, -7.27873892e-02f, -9.92621034e-02f, -2.88265258e-01f, -1.29271910e-01f, -3.60193074e-01f, -3.13002616e-01f, -1.81283161e-01f, -3.64024550e-01f, -2.58866966e-01f,
  -2.90067434e-01f, -2.33042520e-02f, -4.11264926e-01f, -4.34024096e-01f, -2.92489171e-01f, -5.85115775e-02f, 3.89539488e-02f, -4.36214916e-02f, -2.32992053e-01f, -1.82056993e-01f,
  -6.21991865e-02f, 5.05823493e-02f, -4.29197624e-02f, 1.39153197e-01f, 2.35089868e-01f, -1.15051784e-01f, -3.19499373e-01f, -6.01691864e-02f, 2.59763092e-01f, 3.00737590e-01f,
  1.75038695e-01f, 3.70043367e-02f, 2.19620522e-02f, -2.23758910e-02f, -1.94322437e-01f, -2.87434608e-02f, -3.23157638e-01f, -2.69466579e-01f, 2.24240310e-03f, -3.83102596e-01f,
  1.37420610e-01f, -3.40075999e-01f, 5.58556467e-02f, -6.01468794e-03f, -1.27629042e-01f, -1.50245912e-02f, -1.15924545e-01f, -4.51451913e-02f, -1.49346948e-01f, -1.94236919e-01f,
  -1.84276402e-01f, 5.62879480e-02f, -5.94264232e-02f, 2.67275255e-02f, -1.60751373e-01f, -1.35762438e-01f, -7.73738278e-03f, -1.21613115e-01f, -1.34680852e-01f, -2.42791958e-02f,
  5.07143028e-02f, -1.36162847e-01f, -1.54041648e-01f, -5.39406091e-02f, -6.62813848e-03f, -1.48346961e-01f, 1.97787974e-02f, -8.91809314e-02f, -2.47258302e-02f, -4.87765223e-02f,
  4.23810892e-02f, -4.00866419e-02f, 5.40629663e-02f, 4.88696694e-02f, 7.08541051e-02f, -1.29758287e-02f, -6.86826929e-02f, 5.40586635e-02f, 1.24401757e-02f, 1.21304333e-01f,
  2.14914232e-02f, 1.63545124e-02f, -2.88984738e-02f, -2.71040555e-02f, -8.52037892e-02f, 4.34375107e-02f, 2.99837478e-02f, 5.32934889e-02f, 4.93736044e-02f, -4.06026319e-02f,
  7.45109692e-02f, 7.27539435e-02f, -9.85868573e-02f, 9.80264917e-02f, -1.86779276e-02f, -1.61596294e-02f, 2.85474472e-02f, 1.48316070e-01f, -4.30613533e-02f, -6.03155047e-03f,
  1.89518914e-01f, 1.45806186e-02f, -1.86326906e-01f, 3.54399555e-03f, -1.36249244e-01f, -6.65494725e-02f, -9.94938165e-02f, 1.60955284e-02f, -1.57566220e-01f, -1.23360858e-03f,
  6.22226186e-02f, 1.56334564e-01f, -1.04768267e-02f, 1.23219565e-01f, 1.06323563e-01f, -1.22713409e-02f, 1.51211038e-01f, -7.13647231e-02f, -1.68351308e-02f, -3.50048579e-02f,
  9.99534205e-02f, 9.10356864e-02f, 1.57899216e-01f, -2.86872257e-02f, -1.47512378e-02f, 6.51919469e-02f, 4.84069660e-02f, 2.85818409e-02f, 1.42764539e-01f, 2.09376290e-01f,
  -3.31513345e-01f, -1.98820047e-02f, 4.84416574e-01f, -1.31186977e-01f, -1.65075690e-01f, -1.43836662e-01f, -2.01432973e-01f, -5.71956811e-03f, -1.30460327e-02f, -6.80969059e-02f,
  -1.28984258e-01f, -2.03656152e-01f, 1.49051294e-01f, 2.86907703e-02f, 4.66386043e-02f, 1.48185655e-01f, 2.78759301e-01f, 2.59437829e-01f, -5.63657433e-02f, -3.83076251e-01f,
  -3.60946655e-01f, -1.33497760e-01f, -2.12902501e-02f, 4.65993360e-02f, -6.36799559e-02f, -9.23893750e-02f, 2.65848577e-01f, -1.30877137e-01f, -6.66294396e-02f, 9.68650100e-04f,
  -6.07154667e-02f, 8.23565796e-02f, 3.79621275e-02f, -8.93467590e-02f, 4.51803952e-03f, 2.26330999e-02f, -2.75981519e-02f, 8.60791579e-02f, -1.41140958e-03f, 1.69315740e-01f,
  -7.02449977e-02f, -3.89292799e-02f, -1.19714975e-01f, 7.18016224e-03f, -1.26836449e-01f, -9.50854644e-02f, 1.11018807e-01f, 1.70208246e-01f, 1.03334941e-01f, -1.18252207e-02f,
  -2.46126264e-01f, -2.53907472e-01f, -3.59296426e-02f, 7.70537704e-02f, 1.05096065e-01f, 2.21421346e-02f, 2.56725438e-02f, -6.36855736e-02f, 3.36885192e-02f, -8.75819176e-02f,
  2.48885658e-02f, -1.94987655e-02f, -2.26994567e-02f, 6.96049035e-02f, 1.67262759e-02f, 6.37360513e-02f, 1.92276780e-02f, -1.03836365e-01f, -8.25678743e-03f, -1.15465477e-01f,
  -3.03532500e-02f, -5.48363961e-02f, 7.23479912e-02f, 3.94887105e-02f, -1.80070493e-02f, 1.45301956e-03f, -1.13353111e-01f, -6.50123181e-03f, 6.88548982e-02f, -4.32808436e-02f,
  -7.77726844e-02f, 5.02571324e-03f, 2.78206374e-02f, -4.43544984e-02f, 1.05557032e-01f, 6.03220947e-02f, -6.23812601e-02f, -2.88858935e-02f, -9.67783779e-02f, -3.58263776e-02f,
  -1.30704477e-01f, 1.78704679e-01f, -9.60984752e-02f, 4.16134372e-02f, -6.61450475e-02f, -1.03554800e-02f, 4.55431677e-02f, 2.98632234e-02f, 6.63243607e-02f, -1.29629914e-02f,
  3.48573700e-02f, -6.49171844e-02f, 3.78082134e-02f, 9.61919781e-03f, -1.37181982e-01f, -5.20043895e-02f, -2.26289421e-01f, -1.17334098e-01f, -2.93125473e-02f, -6.63209781e-02f,
  -2.02208813e-02f, -2.41429910e-01f, -3.32061648e-01f, -1.97966412e-01f, -1.64500222e-01f, -1.64519981e-01f, -5.95964827e-02f, -1.56153664e-01f, -1.65917262e-01f, -2.57131159e-01f,
  -5.05698085e-01f, 4.07175034e-01f, 1.97798654e-01f, -1.79150149e-01f, 2.39245176e-01f, 2.40528941e-01f, 2.25860178e-01f, 4.48954254e-02f, -2.64282655e-02f, 1.48185879e-01f,
  7.68643245e-02f, -1.20747156e-01f, 6.24077246e-02f, -2.73976065e-02f, -1.41670197e-01f, 2.67015457e-01f, 2.78257340e-01f, -2.00700358e-01f, -3.53868663e-01f, -3.04188490e-01f,
  -6.86382353e-02f, -2.06351802e-01f, -3.54716718e-01f, -1.74384594e-01f, 2.16104060e-01f, -2.99557634e-02f, 2.26598471e-01f, 2.19724141e-02f, 1.84910670e-01f, 2.43608192e-01f,
  -2.17769295e-02f, 3.10173929e-02f, -1.08033963e-01f, -1.16700046e-01f, 6.75449148e-02f, -1.30423665e-01f, 2.87207477e-02f, 4.38349834e-03f, -2.49777026e-02f, -4.99049388e-02f,
  2.93207401e-03f, 1.05854785e-02f, 8.61797184e-02f, -3.89958248e-02f, -1.04177184e-01f, -9.73807722e-02f, -1.59138650e-01f, -1.78124979e-01f, -1.10430986e-01f, -3.79808843e-02f,
  4.68678176e-02f, -7.19830021e-02f, -5.39773591e-02f, 4.24333550e-02f, 4.34999578e-02f, -1.50558338e-01f, -3.86633426e-02f, -8.28539953e-02f, -8.99033621e-02f, -1.11976027e-01f,
  -5.42005189e-02f, -2.67122295e-02f, 7.57092834e-02f, 5.40612489e-02f, -8.04799497e-02f, 9.70773101e-02f, 1.15771167e-01f, 6.31416366e-02f, 3.18247080e-02f, -2.62490343e-02f,
  9.50199589e-02f, -6.54541925e-02f, -3.13320570e-02f, 8.07816237e-02f, 1.83325093e-02f, 4.24881512e-03f, -2.18544286e-02f, 1.11698695e-02f, 4.09423783e-02f, -4.40159328e-02f,
  -1.01707846e-01f, 2.04145946e-02f, 7.15998420e-03f, -5.26321530e-02f, 1.41819075e-01f, 3.34662572e-02f, 2.46496480e-02f, -2.38353442e-02f, 1.64002739e-03f, 6.65280819e-02f,
  -1.95705086e-01f, -6.66169822e-02f, -1.20293446e-01f, -9.59033240e-03f, 1.07920870e-01f, -1.21144028e-02f, 6.33274689e-02f, 1.22514516e-02f, 4.29254510e-02f, -1.01631790e-01f,
  -3.04615740e-02f, -4.13859338e-02f, 1.26697570e-01f, -5.86070046e-02f, -1.25277638e-01f, -2.95328703e-02f, -5.13357073e-02f, -8.33904669e-02f, -3.26189362e-02f, 4.63612899e-02f,
  2.72573568e-02f, -2.64643967e-01f, -2.52862304e-01f, -1.76659098e-03f, -4.74845544e-02f, -2.60592997e-01f, -7.28792250e-02f, -1.24448471e-01f, -1.03535168e-01f, -2.17216089e-01f,
  -2.24465162e-01f, 1.82548948e-02f, -1.12593397e-01f, 1.50613993e-01f, 6.83837831e-02f, -1.40702158e-01f, -3.00567687e-01f, -2.33596981e-01f, -6.88356757e-02f, -1.43074155e-01f,
  -1.30607352e-01f, -3.48576084e-02f, 1.76208857e-02f, 9.65438224e-03f, -6.08214326e-02f, 8.81316215e-02f, 2.69767940e-01f, 2.24488437e-01f, 7.86331445e-02f, 2.07158253e-02f,
  2.59754568e-01f, 2.34652817e-01f, 1.41941205e-01f, 1.86089352e-01f, 2.78294057e-01f, 1.40294597e-01f, 2.09431741e-02f, 1.22249506e-01f, 1.19620800e-01f, 4.75024909e-01f,
  -1.53082460e-01f, -1.64844438e-01f, -1.29419178e-01f, 9.08628181e-02f, -1.13241132e-02f, -1.59082282e-02f, -7.01043159e-02f, 2.69858502e-02f, -1.04708187e-02f, 4.24144268e-02f,
  1.05878457e-01f, 1.44847147e-02f, -9.56923794e-03f, 1.19454712e-01f, -5.36386808e-03f, -9.34810564e-02f, 1.25779316e-01f, -2.62144804e-02f, -1.14437781e-01f, -9.56384242e-02f,
  2.07202762e-01f, 1.24830902e-01f, -1.63305506e-01f, -1.32647142e-01f, -2.09598288e-01f, -3.59346531e-02f, -1.33133441e-01f, -9.18600187e-02f, -3.16957146e-01f, 2.24595380e-04f,
  -9.26993042e-02f, 7.32752308e-02f, 3.89352604e-03f, 6.34415224e-02f, 2.29689740e-02f, 2.64679492e-02f, 9.34438184e-02f, 3.94280590e-02f, 5.18043265e-02f, 6.08923882e-02f,
  -5.71413971e-02f, -5.77968657e-02f, -6.90069273e-02f, -9.70976055e-02f, 2.72734929e-02f, -5.60443662e-02f, 9.93102565e-02f, -3.10593117e-02f, -4.99412715e-02f, -1.11508422e-01f,
  -3.14012282e-02f, 1.26202237e-02f, 2.08666660e-02f, 3.13935131e-02f, -4.77366559e-02f, -8.04453045e-02f, 5.99860447e-03f, 8.18807539e-03f, 9.54207964e-03f, -5.84660396e-02f,
  -2.24582970e-01f, -9.40793455e-02f, -5.81936166e-02f, 3.85341570e-02f, -5.39401434e-02f, -7.49812797e-02f, -4.99227718e-02f, -8.29643533e-02f, -4.82946895e-02f, -6.44439086e-03f,
  -8.99075270e-02f, -8.55543762e-02f, -9.17527080e-02f, -3.05033731e-03f, 1.07340598e-02f, -1.16456643e-01f, 1.07134372e-01f, 8.84000883e-02f, -4.99635004e-02f, -3.18377353e-02f,
  8.61423016e-02f, -4.36167605e-02f, -8.57119858e-02f, -1.37427062e-01f, -1.05098046e-01f, -1.72843039e-01f, -9.32870135e-02f, -8.96405727e-02f, -3.15882385e-01f, -2.26097941e-01f,
  3.02860856e-01f, 1.64550141e-01f, -2.41006598e-01f, 2.54942656e-01f, 2.94714391e-01f, 2.68783510e-01f, 1.73231840e-01f, 1.47540212e-01f, 1.91036791e-01f, 2.80989945e-01f,
  3.94804060e-01f, 3.50610793e-01f, 3.35853487e-01f, 9.11242217e-02f, 1.40705407e-01f, -2.31934376e-02f, 1.58851501e-02f, -2.54601836e-01f, -7.97862932e-02f, 6.11227602e-02f,
  2.46649459e-01f, 1.77024215e-01f, 5.23913428e-02f, -5.49535826e-02f, 5.31257316e-02f, 2.54873782e-01f, 6.98827952e-02f, 1.53419062e-01f, 1.50933452e-02f, -1.34687662e-01f,
  -7.88446069e-02f, 8.02435428e-02f, -1.14452451e-01f, 4.91861440e-02f, -5.78738339e-02f, -2.40292758e-01f, -9.85838696e-02f, -1.57525122e-01f, -1.52624659e-02f, -9.62032750e-02f,
  -1.28829166e-01f, -1.22312725e-01f, 3.27911451e-02f, -1.23779565e-01f, -1.41956374e-01f, -1.36318237e-01f, -1.13353044e-01f, -2.65749902e-01f, -1.80112243e-01f, -3.72057706e-02f,
  3.61800082e-02f, -5.64383045e-02f, -1.75286457e-01f, -1.61823200e-03f, -8.41381773e-02f, -1.47278579e-02f, -1.53025702e-01f, -7.52471983e-02f, -1.79837823e-01f, -1.61171094e-01f,
  -1.01697810e-01f, -2.08583787e-01f, -1.23464264e-01f, -1.11533277e-01f, -4.11102436e-02f, -6.72666207e-02f, -9.60798711e-02f, 8.90274812e-03f, -4.10661548e-02f, -3.33851613e-02f,
  -7.19167367e-02f, 2.17545195e-03f, -6.34362474e-02f, -7.28914291e-02f, -1.52081940e-02f, -1.55826956e-02f, -8.81672278e-02f, -1.23441167e-01f, -6.25615120e-02f, 5.58173060e-02f,
  6.57385662e-02f, -9.42625850e-02f, -8.48812088e-02f, -1.57281011e-01f, -1.06833629e-01f, -5.50420657e-02f, -8.98040310e-02f, -4.46301028e-02f, 7.26629198e-02f, 7.44720995e-02f,
  3.07435691e-01f, 3.24629307e-01f, -1.80284008e-02f, -9.01585445e-02f, -1.26421988e-01f, 1.99104939e-02f, 3.91213968e-02f, 2.14511752e-02f, 9.86026507e-03f, -5.21030836e-02f,
  -1.28133781e-02f, -1.18706927e-01f, 8.63292590e-02f, -2.89999153e-02f, -9.23418999e-02f, -9.09699425e-02f, 6.29673526e-03f, -3.66150551e-02f, -1.09169791e-02f, -1.45083919e-01f,
  -2.68646851e-02f, -9.12914947e-02f, -1.44304231e-01f, 2.44824383e-02f, -1.14907019e-01f, 8.41744244e-02f, 1.41236903e-02f, -1.09442219e-01f, -1.23453856e-01f, 8.49062353e-02f,
  -4.51752067e-01f, 1.55806720e-01f, 1.90184996e-01f, -1.91079512e-01f, 3.71104628e-01f, 2.98124790e-01f, 2.87257671e-01f, -1.71161547e-01f, -2.31024861e-01f, 1.17137209e-01f,
  1.43570736e-01f, -1.94820426e-02f, -1.20661505e-01f, -2.91983522e-02f, 5.78074995e-03f, 2.42833093e-01f, 1.48500621e-01f, -7.59519683e-03f, -9.13195610e-02f, 1.91165544e-02f,
  2.02515751e-01f, -7.13547245e-02f, -2.35872775e-01f, -8.07099938e-02f, 3.19846421e-02f, -9.03220996e-02f, 6.26187250e-02f, 4.55217212e-02f, 2.45882809e-01f, 1.71827286e-01f,
  -1.40517011e-01f, -2.33477399e-01f, 8.87901112e-02f, 7.43400529e-02f, 9.92347226e-02f, -1.26384169e-01f, -1.45406440e-01f, -8.37494060e-02f, 2.41947267e-02f, -2.85213273e-02f,
  1.25236884e-01f, 7.07605109e-02f, 4.07563075e-02f, -4.52958383e-02f, -1.77963704e-01f, -1.09631971e-01f, -1.03242315e-01f, -1.95072293e-01f, -2.67949790e-01f, -2.99106799e-02f,
  2.96688735e-01f, 1.99519053e-01f, -2.68225633e-02f, -6.99139237e-02f, -2.58667052e-01f, -1.77003801e-01f, -1.65669769e-01f, -1.73759714e-01f, -2.14080080e-01f, -2.18333989e-01f,
  -2.72563798e-03f, 1.24845304e-01f, 6.84300885e-02f, 7.66834663e-03f, 4.18853089e-02f, 1.20007545e-02f, 6.41302988e-02f, 7.17565641e-02f, -3.22537720e-02f, 2.84608803e-03f,
  -6.80226758e-02f, -7.73642361e-02f, -5.23387641e-02f, -9.91379842e-02f, 6.76721474e-03f, -4.62730043e-02f, 1.33612659e-03f, -6.88044503e-02f, 6.75721541e-02f, 4.91548367e-02f,
  -6.57731071e-02f, -5.17847538e-02f, -6.01882264e-02f, -7.68733397e-02f, 6.32051751e-02f, 1.05109833e-01f, -5.60575463e-02f, -6.11417368e-02f, -9.06605050e-02f, 4.94834594e-03f,
  -3.72767359e-01f, 2.85750836e-01f, -1.34253696e-01f, -9.76886675e-02f, 9.71693099e-02f, 1.13889510e-02f, -5.65492809e-02f, 5.30314520e-02f, -4.52651270e-03f, -7.85880908e-02f,
  4.63156123e-03f, -7.73159638e-02f, -7.77264088e-02f, -3.99645790e-02f, -4.59108874e-02f, -9.85906199e-02f, 2.01394871e-01f, -3.99911515e-02f, -6.08487278e-02f, -1.30212950e-02f,
  5.41078337e-02f, 1.76670235e-02f, -1.73901334e-01f, -1.24069653e-01f, -1.04678586e-01f, -2.21010521e-01f, -1.45185098e-01f, -9.84863937e-02f, -1.27334267e-01f, -2.11716875e-01f,
  4.47234154e-01f, 1.97692618e-01f, 2.96094984e-01f, 1.55044990e-02f, -3.40330929e-01f, -3.55143428e-01f, -1.86156601e-01f, -1.29973024e-01f, -2.62065679e-02f, -2.96726171e-02f,
  -6.75441399e-02f, -1.44733423e-02f, 1.01920597e-01f, -1.22794760e-02f, 2.18933355e-02f, -4.74000201e-02f, 1.03807906e-02f, 3.35841686e-01f, 1.59448311e-01f, 2.45153084e-02f,
  -6.15376271e-02f, 1.36835024e-01f, 2.73247123e-01f, 2.38511845e-01f, 1.35256618e-01f, -4.36713174e-02f, -3.91002418e-03f, 6.18775981e-03f, 7.34189898e-02f, 2.65814781e-01f,
  2.49501601e-01f, 1.17156394e-01f, -4.31967713e-03f, 7.84512013e-02f, 4.58362438e-02f, 8.67810398e-02f, 1.08324289e-01f, 6.91083670e-02f, -9.17148888e-02f, -3.76112722e-02f,
  2.57119238e-02f, 2.27206275e-02f, 2.14260840e-03f, -1.32826045e-01f, -9.12712589e-02f, -9.03909560e-04f, -1.37325928e-01f, -3.08457445e-02f, -1.72775418e-01f, -7.74486363e-02f,
  -1.11236051e-01f, -1.81807205e-01f, -1.59871787e-01f, -1.50668845e-01f, -2.76862495e-02f, -1.72132447e-01f, -1.11894809e-01f, 4.95060696e-04f, -1.09184511e-01f, -6.37824833e-02f,
  7.91948065e-02f, 5.48371375e-02f, -1.10796988e-01f, -2.32003435e-01f, -1.99113801e-01f, -2.12875485e-01f, -2.26615787e-01f, -9.39656347e-02f, 1.21478802e-02f, -9.61068273e-02f,
  -2.04912573e-01f, -5.88803552e-02f, -1.56590566e-01f, 6.20892756e-02f, 1.86217085e-01f, -1.86494645e-02f, -8.37052613e-02f, -8.58263895e-02f, -3.70074138e-02f, -5.27935028e-02f,
  -6.51178509e-02f, -1.04503043e-01f, -1.58848409e-02f, -1.37415543e-01f, -1.75343901e-01f, -1.66004911e-01f, -1.29469767e-01f, -4.16380651e-02f, -3.12507488e-02f, -2.02340004e-03f,
  -1.48918688e-01f, 6.39019758e-02f, 1.80688262e-01f, 2.00735867e-01f, -3.27691883e-02f, 1.48165300e-01f, 1.05953068e-01f, 9.66762751e-02f, 3.80706526e-02f, -4.60150056e-02f,
  1.15444735e-01f, 1.73762739e-01f, 1.68573223e-02f, -2.25491021e-02f, -8.65858346e-02f, -1.80400331e-02f, 3.93519327e-02f, -7.18496293e-02f, -6.48712069e-02f, 5.99740166e-03f,
  -7.88637623e-03f, -1.54202506e-01f, -1.31265178e-01f, -8.46658647e-02f, -8.73240158e-02f, -2.42736191e-02f, 1.14954207e-02f, -8.65076184e-02f, -1.17639430e-01f, -1.24510480e-02f,
  -1.95523620e-01f, -5.01730204e-01f, 2.31589258e-01f, 1.21706791e-01f, 2.73580819e-01f, 2.36521453e-01f, 1.58955127e-01f, 6.06918558e-02f, 9.46488697e-03f, 6.69445246e-02f,
  -2.22893849e-01f, -2.87515551e-01f, -1.61596045e-01f, -2.90755853e-02f, -1.13310078e-02f, 3.16575915e-01f, 3.75872463e-01f, 2.48403922e-01f, 1.58086792e-01f, 3.58594581e-02f,
  -6.35944977e-02f, -1.77776143e-01f, -1.97193578e-01f, -1.14733353e-01f, -1.46408290e-01f, -5.79908257e-03f, -3.73206399e-02f, -5.11346310e-02f, -1.37020543e-01f, -3.97483706e-02f,
  1.16424240e-01f, -1.37230814e-01f, 7.94472620e-02f, -2.10676163e-01f, -1.15176141e-01f, -1.57184020e-01f, 3.88249978e-02f, -7.33951554e-02f, -1.76082999e-01f, -9.36773866e-02f,
  -8.29987749e-02f, -1.33874044e-01f, -1.28742829e-01f, -1.39602005e-01f, 1.29584540e-02f, -1.65270478e-01f, -1.32144406e-01f, -1.47963896e-01f, -1.64978176e-01f, -8.94911960e-02f,
  -9.92404670e-02f, -8.91683847e-02f, 3.60166319e-02f, -3.09058260e-02f, -4.10399884e-02f, -9.07533020e-02f, -5.53953610e-02f, -3.35631557e-02f, -1.33986920e-01f, 6.29675537e-02f,
  -3.66482022e-03f, 6.91011921e-02f, -3.62659246e-02f, -9.92418006e-02f, -2.00952385e-02f, 1.85939416e-01f, 1.01434942e-02f, 4.26578568e-03f, -3.03210355e-02f, -1.83955375e-02f,
  -2.33062804e-02f, 2.71075666e-02f, 8.71462971e-02f, -6.77597150e-02f, -1.42702281e-01f, -4.11065146e-02f, -4.18948978e-02f, -1.02580450e-01f, -2.82167438e-02f, 3.50351185e-02f,
  -5.76536991e-02f, 1.14664217e-04f, -4.11435217e-02f, 3.97333689e-02f, -1.29700348e-01f, -3.16048637e-02f, -7.87152201e-02f, -1.38541862e-01f, 6.53470382e-02f, -6.45024478e-02f,
  1.84359714e-01f, -6.65249676e-02f, 2.13354528e-01f, -7.94768631e-02f, -1.00279234e-01f, -6.15909547e-02f, -2.20214259e-02f, 5.38661033e-02f, 2.46828757e-02f, -6.16814569e-02f,
  -6.13991581e-02f, -1.46353347e-02f, 1.87372267e-02f, -8.31465870e-02f, 1.34207949e-01f, -1.32830478e-02f, -1.45278499e-01f, 9.08120275e-02f, 7.80711323e-02f, -8.21700040e-03f,
  6.98032370e-03f, 1.73013330e-01f, 2.30940118e-01f, 2.32640356e-01f, 3.63925360e-02f, 2.01179981e-01f, 1.81608304e-01f, 1.89837575e-01f, 1.77301168e-01f, 1.84153900e-01f,
  -5.68653584e-01f, -2.28037626e-01f, 1.24790289e-01f, 1.00177780e-01f, 3.11474830e-01f, 2.60402024e-01f, 4.99586053e-02f, 2.66019534e-02f, 2.44416773e-01f, 1.31588960e-02f,
  -4.62658145e-02f, 3.06406599e-02f, -4.57725376e-02f, 4.05677482e-02f, 5.47265895e-02f, 1.95063204e-01f, 3.63592327e-01f, 1.10689782e-01f, 1.43794194e-01f, 2.63557993e-02f,
  1.96689874e-01f, 5.53693511e-02f, -6.49255142e-02f, 6.29007295e-02f, 1.35593206e-01f, 2.27384165e-01f, 1.99411303e-01f, 1.34757549e-01f, 8.20650831e-02f, 2.74753839e-01f,
  1.26778215e-01f, -2.29272693e-01f, 2.11026687e-02f, -3.78259122e-02f, -2.17347100e-01f, -1.84021950e-01f, 3.46763358e-02f, -1.17108636e-01f, -5.35848588e-02f, 8.56301934e-02f,
  -4.31837747e-03f, -1.49053857e-01f, -6.44550323e-02f, 3.23027261e-02f, -7.15736672e-03f, -2.44391188e-02f, -1.74455956e-01f, 2.86124554e-03f, 1.10265121e-01f, -4.17826176e-02f,
  -1.28310444e-02f, 4.20884974e-02f, 1.47289991e-01f, 8.54163319e-02f, 1.13361720e-02f, -3.31006870e-02f, -1.66797802e-01f, -4.44697142e-02f, -3.23418975e-02f, -2.56235749e-02f,
  1.06422231e-01f, 6.66818246e-02f, -3.62266190e-02f, 4.76206206e-02f, -5.76041304e-02f, 5.60259409e-02f, 8.82114470e-02f, 6.17101006e-02f, 1.47526503e-01f, -5.02283350e-02f,
  7.15211406e-02f, 2.06155717e-01f, 2.77952738e-02f, 3.37847807e-02f, -3.35475132e-02f, 9.51364711e-02f, 9.59800705e-02f, 5.32287955e-02f, 2.39149760e-02f, 4.91489209e-02f,
  1.09428458e-01f, 4.57084998e-02f, 4.13593762e-02f, -3.75116765e-02f, -1.16420258e-03f, 7.02277943e-02f, 1.47528797e-01f, 3.04428302e-03f, 1.21616544e-02f, 3.07791624e-02f,
  3.39406371e-01f, -1.46049291e-01f, 5.01755737e-02f, -5.15458249e-02f, 6.04045857e-03f, -1.63413212e-01f, -5.31772599e-02f, 6.81278706e-02f, -4.01452882e-03f, 8.68528858e-02f,
  3.29994410e-02f, -1.01262741e-02f, -5.59353195e-02f, -5.88721707e-02f, -3.03424336e-02f, 9.62709710e-02f, -1.20376825e-01f, -9.80417337e-03f, 4.07073088e-02f, -1.89503431e-02f,
  4.59962117e-04f, 1.65001035e-01f, 2.20873654e-01f, 1.74063459e-01f, -1.17504951e-02f, 1.29657626e-01f, 1.11013196e-01f, -3.50095667e-02f, 3.54996398e-02f, 1.16850108e-01f,
  -4.07485617e-03f, 3.43578368e-01f, 2.29469165e-01f, 9.03334841e-03f, 1.61428861e-02f, 3.19368653e-02f, 8.34770203e-02f, -3.35161164e-02f, -1.19478755e-01f, 1.45764917e-01f,
  1.48994222e-01f, -1.70411900e-01f, 4.38259505e-02f, -1.51521102e-01f, -1.40475824e-01f, 1.64950728e-01f, -1.93939023e-02f, -2.07891881e-01f, -2.47824475e-01f, -1.31867394e-01f,
  -9.03258175e-02f, -1.76270768e-01f, -3.42107117e-02f, -1.78569853e-01f, 1.55496716e-01f, 4.52343486e-02f, 1.73440859e-01f, 1.57139197e-01f, 3.04237783e-01f, 2.31921971e-01f,
  1.55098289e-01f, 2.67928421e-01f, -1.94910571e-01f, -4.67677414e-02f, 1.09316194e-02f, -3.42284851e-02f, -1.09678768e-01f, -1.08981393e-01f, 2.49150582e-03f, -1.74425170e-01f,
  1.51178241e-02f, 2.96019809e-03f, 3.39830220e-02f, -4.60387953e-02f, -1.47894263e-01f, -8.14821869e-02f, -4.56451811e-02f, -9.76308584e-02f, -1.19960003e-01f, 4.10089940e-02f,
  7.38504007e-02f, 8.20794851e-02f, -6.53280914e-02f, -3.33865881e-02f, -4.07715291e-02f, -1.52463034e-01f, 5.56797646e-02f, -8.10294747e-02f, 1.31588653e-02f, 1.75063275e-02f,
  -2.97278047e-01f, -1.64458975e-01f, -6.22765943e-02f, -1.94716409e-01f, -1.54570773e-01f, -2.22538784e-01f, -1.64989121e-02f, -8.02614689e-02f, -6.93609938e-02f, -1.24152057e-01f,
  -1.65041149e-01f, 2.90699005e-02f, -1.13658905e-01f, -1.39358312e-01f, -1.25004575e-01f, -3.03128324e-02f, -3.86585109e-02f, -6.86898455e-02f, 4.78401519e-02f, -2.55870335e-02f,
  -8.19528662e-03f, -6.05090261e-02f, -2.58945697e-03f, -1.27692476e-01f, -3.06782071e-02f, -1.76692814e-01f, -1.73783287e-01f, -1.55040756e-01f, -1.82859793e-01f, 3.92321534e-02f,
  -1.72104940e-01f, 1.54872864e-01f, -1.73999146e-02f, 1.86862946e-01f, 1.53713524e-01f, 1.43097118e-01f, 2.47837558e-01f, 1.66520029e-01f, 1.14026420e-01f, 1.50806047e-02f,
  6.86105639e-02f, 7.52762565e-03f, 4.13324907e-02f, 5.06624021e-02f, -5.63023090e-02f, -5.53696379e-02f, 2.60200794e-03f, 3.19772288e-02f, 6.33667856e-02f, -5.52682653e-02f,
  4.21840250e-02f, -1.76904932e-01f, -1.48692757e-01f, -1.14522062e-01f, -1.74338296e-01f, -1.56086221e-01f, -1.50474355e-01f, -8.80369619e-02f, -3.77032831e-02f, -2.07006976e-01f,
  3.37967962e-01f, -1.41642420e-02f, -3.00831407e-01f, 3.63321370e-03f, -1.60664424e-01f, -2.30345160e-01f, -2.16668442e-01f, -1.10875137e-01f, 2.30356418e-02f, -1.03787169e-01f,
  -3.01251560e-02f, 7.71567822e-02f, 4.25575003e-02f, -5.18950000e-02f, -7.81631768e-02f, -1.90967381e-01f, -2.46971220e-01f, -1.56330124e-01f, -1.81111231e-01f, -1.70979172e-01f,
  -7.48633444e-02f, -8.20317194e-02f, -6.95018843e-02f, -6.22316524e-02f, -8.17059278e-02f, -7.42079616e-02f, -1.83671087e-01f, -1.20941550e-01f, -1.52578399e-01f, -5.88401780e-02f,
  -1.23453058e-01f, -7.17340177e-03f, -6.96435422e-02f, 2.74101943e-02f, -4.50045653e-02f, 1.87186785e-02f, -1.17028262e-02f, -8.84256791e-03f, 4.46701683e-02f, -4.06516604e-02f,
  7.40961498e-03f, -1.86438579e-02f, -4.88050655e-03f, -3.12942006e-02f, -9.97282565e-02f, -3.29480879e-02f, -8.42508897e-02f, -6.70312569e-02f, -1.97622236e-02f, -8.15877542e-02f,
  -1.00510670e-02f, -2.56149732e-02f, 1.14451908e-03f, -5.78045920e-02f, -6.06999658e-02f, -3.59244570e-02f, -6.82913885e-02f, -4.97970879e-02f, -3.99699062e-02f, 4.04508412e-02f,
  7.44930655e-03f, 6.05470594e-03f, -8.22997168e-02f, -1.61834788e-02f, 5.28594777e-02f, 8.24434962e-03f, 3.88006978e-02f, 6.46687299e-03f, 3.27933580e-02f, -3.15751582e-02f,
  -4.44382839e-02f, -5.80849089e-02f, -7.96239916e-03f, 7.12847058e-03f, -5.84957562e-02f, -1.62564814e-02f, -1.66937229e-04f, -2.68496815e-02f, 3.66376117e-02f, 5.66414036e-02f,
  -3.66162695e-02f, -7.72062242e-02f, 2.05689762e-03f, 1.10933539e-02f, -2.92776804e-02f, -3.52664739e-02f, 4.12361743e-03f, 2.54896302e-02f, 1.77398827e-02f, -2.27367412e-02f,
  1.45339653e-01f, -4.58674692e-02f, 9.40810293e-02f, -6.55595809e-02f, -4.00015302e-02f, -4.92153168e-02f, 1.37674119e-02f, 2.60797748e-03f, 1.08942345e-01f, 3.73248793e-02f,
  -1.79895125e-02f, 1.16612809e-02f, 6.28895545e-03f, 1.81823540e-02f, -1.02178901e-01f, -2.15020776e-02f, -2.50175308e-05f, 2.65533454e-03f, -9.21075791e-03f, -5.94108813e-02f,
  -6.71534836e-02f, 7.56362872e-03f, 1.70827016e-01f, 6.05276972e-02f, 8.57866555e-03f, 5.75992130e-02f, -2.78163957e-03f, -3.08093838e-02f, 8.01877826e-02f, 1.30664751e-01f,
  -2.55119860e-01f, 3.04149747e-01f, -1.45562505e-02f, -2.32841849e-01f, -3.41306031e-01f, -4.02125239e-01f, -4.92703617e-02f, -1.08739175e-01f, -1.22207917e-01f, 2.40641773e-01f,
  1.13294862e-01f, -1.26045033e-01f, 1.68186069e-01f, -7.24690035e-02f, -1.02393432e-02f, 3.15640539e-01f, 3.21447663e-02f, -2.15364724e-01f, -4.26969796e-01f, -4.55142319e-01f,
  -2.49756977e-01f, -1.39512673e-01f, -2.76727289e-01f, -1.79180980e-01f, -4.23647743e-03f, -9.76920575e-02f, 1.70848131e-01f, -1.70498088e-01f, -1.19020723e-01f, 6.40749335e-02f,
  2.70439178e-01f, -1.74572021e-01f, -1.70835316e-01f, -9.48143229e-02f, -4.11406672e-03f, -5.05657345e-02f, -5.95902056e-02f, -5.48080690e-02f, 1.63256843e-02f, 1.00578345e-01f,
  -1.24546364e-01f, -1.85090154e-01f, -6.19383380e-02f, 1.73020847e-02f, -7.51052201e-02f, -9.26531404e-02f, -2.42557265e-02f, -1.25779405e-01f, 3.22652073e-03f, -3.88019234e-02f,
  8.42807721e-03f, -1.88200206e-01f, -9.88464803e-02f, 1.65578350e-02f, -5.93135431e-02f, -2.15111911e-01f, 2.40138620e-02f, -9.24968123e-02f, -6.99523538e-02f, 2.02611610e-01f,
  6.01816624e-02f, 2.29895487e-01f, -1.52943041e-02f, 2.85956506e-02f, 3.08263265e-02f, -8.99008941e-03f, 5.72841205e-02f, 9.08031687e-03f, -1.37176458e-02f, 1.88996002e-01f,
  8.63219239e-03f, 4.96985996e-03f, 2.64696404e-02f, 1.08401895e-01f, 8.15663394e-03f, 6.73604105e-03f, 8.04246366e-02f, 3.37580666e-02f, -3.43558751e-02f, -1.00789309e-01f,
  -1.85957223e-01f, -1.01443805e-01f, -6.54630736e-02f, 9.33194440e-03f, 6.25294913e-03f, -7.77803212e-02f, 8.68506543e-03f, -6.60014078e-02f, -3.01976595e-02f, -1.78285778e-01f,
  2.70270020e-01f, -3.48571062e-01f, 1.47768319e-01f, 4.27066498e-02f, -2.62377616e-02f, -8.54890421e-03f, 9.92105063e-03f, -7.02302530e-02f, -7.32393041e-02f, 5.85776046e-02f,
  -1.38682768e-01f, 9.79961827e-03f, 5.56436032e-02f, 9.24228802e-02f, -1.13840543e-01f, -7.30457380e-02f, 9.02273804e-02f, -8.23878795e-02f, -1.25167981e-01f, 2.39103381e-02f,
  1.08694479e-01f, 5.98861687e-02f, 1.64949432e-01f, 1.34044647e-01f, -1.45747820e-02f, -6.84132650e-02f, 1.00718796e-01f, 6.76185116e-02f, 7.00354651e-02f, 2.92517215e-01f,
  9.40125212e-02f, -2.07788885e-01f, 1.60971656e-01f, 1.60418063e-01f, -8.67337957e-02f, -2.20981658e-01f, -3.56228918e-01f, -1.41564012e-01f, 8.10833555e-03f, -7.84870237e-02f,
  -1.87098786e-01f, 1.71342775e-01f, 2.13841572e-01f, 2.12334156e-01f, 1.59176052e-01f, 1.95797365e-02f, 3.29288185e-01f, 3.43845814e-01f, 2.82023847e-01f, 3.75748426e-02f,
  1.10073552e-01f, 1.66738018e-01f, 2.73970276e-01f, 1.61069646e-01f, 4.36153114e-02f, 1.86793640e-01f, 1.84304744e-01f, 7.65705034e-02f, -8.26931000e-03f, 4.05011296e-01f,
  -1.31667271e-01f, -1.78152025e-01f, 3.57696265e-02f, 4.80345488e-02f, -4.44984920e-02f, 1.05606556e-01f, -4.30563949e-02f, 1.03493802e-01f, -2.74396446e-02f, 5.02111018e-02f,
  -2.61825398e-02f, 2.27918942e-02f, -3.75522189e-02f, 9.67225991e-03f, -9.38568711e-02f, -1.91925019e-01f, 1.38548851e-01f, 7.52443746e-02f, 1.15937486e-01f, -7.88417459e-02f,
  1.79011956e-01f, -1.30993336e-01f, -1.67315215e-01f, -5.94230965e-02f, -9.31372717e-02f, 1.89674646e-01f, -1.05856456e-01f, -7.70596489e-02f, -1.27962708e-01f, 3.95069048e-02f,
  -9.45420265e-02f, 6.11002184e-03f, -3.31120118e-02f, -2.99630985e-02f, 9.30214450e-02f, -1.17379781e-02f, 8.79675299e-02f, 1.19336974e-03f, -5.54315222e-04f, 6.00532182e-02f,
  6.07375130e-02f, 5.71127012e-02f, -6.29182830e-02f, 3.98173369e-02f, -5.77795831e-03f, -5.86676188e-02f, -1.02884416e-02f, 2.20470466e-02f, -3.36574670e-03f, 6.10194057e-02f,
  4.81990054e-02f, 7.92676955e-02f, 2.81241443e-02f, 1.47437990e-01f, 1.41635656e-01f, 1.69071287e-01f, 6.71707913e-02f, 1.10418521e-01f, 5.87228276e-02f, -1.18270526e-02f,
  -1.67686746e-01f, 5.75346267e-03f, -9.93846804e-02f, -6.87743574e-02f, -9.21907872e-02f, -1.82700772e-02f, -3.86259495e-03f, -5.73577136e-02f, -7.03845546e-02f, 1.52719552e-02f,
  -9.60358530e-02f, -1.40694007e-01f, -3.64349484e-02f, 8.92679170e-02f, 2.50757132e-02f, -2.09393367e-01f, -6.94290211e-04f, 1.14004858e-01f, 1.48722231e-02f, -3.35433446e-02f,
  4.81046848e-02f, -1.90773785e-01f, -2.16836572e-01f, -1.43606737e-01f, -1.59776285e-01f, -4.17621210e-02f, -1.37426376e-01f, -1.09194331e-01f, -2.76495218e-01f, -2.14074031e-01f,
  -6.63866401e-01f, 2.42925063e-02f, 3.20533484e-01f, -3.29859227e-01f, -7.97048435e-02f, 2.70280153e-01f, 3.26104075e-01f, -3.26025598e-02f, -3.10220778e-01f, -2.02614069e-02f,
  9.75892320e-02f, -1.09532960e-01f, -1.23817876e-01f, -2.34762044e-03f, 6.87847659e-02f, 5.78591749e-02f, -5.79024963e-02f, -1.98122352e-01f, -9.45987031e-02f, 5.53870276e-02f,
  -1.71481401e-01f, -2.30502084e-01f, -4.09532964e-01f, -2.86196053e-01f, -1.82315677e-01f, -2.37192065e-01f, -9.52511579e-02f, -9.51519832e-02f, -1.89798046e-02f, -1.49733663e-01f,
  5.88348150e-01f, 5.70819825e-02f, 1.22847380e-02f, -1.62825603e-02f, -2.88823955e-02f, -6.70282841e-02f, 5.04549779e-02f, -2.18652319e-02f, -1.04717426e-01f, 1.15065470e-01f,
  1.14200171e-02f, 1.02175839e-01f, -2.69355103e-02f, 2.08938032e-01f, 1.11509666e-01f, 1.10248253e-01f, 2.51829177e-02f, 8.80695041e-03f, 1.88532442e-01f, 2.12605610e-01f,
  2.65507758e-01f, 4.11256636e-03f, 5.83142266e-02f, 8.05756152e-02f, 6.72705173e-02f, 3.14520262e-02f, 1.65255070e-01f, 1.28836244e-01f, 1.46910518e-01f, -4.10595210e-03f,
  9.40269083e-02f, -1.50251120e-01f, 3.33732925e-02f, 6.62814379e-02f, 7.22858608e-02f, 5.27788363e-02f, -9.43859443e-02f, -5.12724183e-02f, -1.42432109e-01f, -1.74636245e-01f,
  -3.51635329e-02f, 2.19018564e-01f, 1.16052702e-02f, -9.46975872e-02f, -1.71713587e-02f, 2.44037658e-02f, -1.49187678e-03f, 6.33782372e-02f, 7.04984069e-02f, -5.55671901e-02f,
  1.27841728e-02f, -6.73440248e-02f, -5.66181839e-02f, 4.23572436e-02f, 1.05446994e-01f, 3.17849331e-02f, 8.72208402e-02f, 1.09463401e-01f, 5.07509196e-03f, -3.51087004e-02f,
  2.68254608e-01f, 1.31905377e-01f, -9.92600173e-02f, -8.77448320e-02f, -4.38600443e-02f, -4.86591235e-02f, 1.10207096e-04f, -7.69608049e-03f, -5.03663644e-02f, 1.66979358e-01f,
  1.44347221e-01f, -9.10294130e-02f, 3.85545380e-02f, 9.51432437e-02f, -1.08795904e-01f, -1.97583362e-02f, -7.26882659e-04f, -1.57487273e-01f, 3.68756279e-02f, 1.16514221e-01f,
  5.52843288e-02f, -4.05821651e-02f, -1.19395077e-01f, 2.89055426e-02f, -9.18247178e-02f, -1.92583039e-01f, 2.59432266e-03f, -3.49136852e-02f, 4.56550233e-02f, -1.41038522e-01f,
  1.11058876e-01f, -4.36354309e-01f, -2.58683443e-01f, -2.54295975e-01f, -1.88962206e-01f, 9.86609757e-02f, -3.38449106e-02f, 1.06773786e-01f, -8.29011574e-02f, -2.60281175e-01f,
  5.16546965e-02f, 3.97006154e-01f, 2.06345290e-01f, 3.03349644e-01f, 2.33561531e-01f, -3.44896048e-01f, -3.38204056e-01f, 3.96424271e-02f, 5.09412408e-01f, 3.11909586e-01f,
  -2.53149495e-02f, -1.05280116e-01f, 4.07141149e-02f, -1.23278506e-01f, -3.82858157e-01f, 4.54765297e-02f, -4.55023259e-01f, -2.77351707e-01f, -2.28193402e-01f, -4.19340312e-01f,
  2.78033406e-01f, -8.61298740e-02f, 8.77476856e-02f, -4.41491902e-02f, -4.09410596e-02f, 4.47873697e-02f, 6.50434345e-02f, -5.38406298e-02f, -3.60746831e-02f, -7.22991973e-02f,
  -2.97059063e-02f, 1.97995417e-02f, 5.43724336e-02f, -7.89466873e-02f, -3.82596850e-02f, 1.07775584e-01f, -1.22378550e-01f, -5.49304187e-02f, -9.35524609e-03f, -2.28993353e-02f,
  -1.51535884e-01f, -1.18132584e-01f, 4.07453999e-02f, 5.02970964e-02f, 2.49664765e-02f, 6.99579492e-02f, 3.86074856e-02f, 6.69296607e-02f, 1.17261587e-02f, -1.36694640e-01f,
  -3.94877493e-02f, -3.00115235e-02f, -3.94939482e-02f, -1.04476847e-02f, 1.36645615e-01f, -4.27767597e-02f, 4.31828797e-02f, -6.67085797e-02f, 6.34166151e-02f, -5.77031337e-02f,
  1.90766826e-02f, -6.35005981e-02f, 6.36292845e-02f, -1.06352240e-01f, -1.02104940e-01f, -1.17392242e-01f, -6.38932809e-02f, -1.74321942e-02f, -4.71985154e-02f, -5.62171778e-03f,
  -2.00659819e-02f, -4.07923535e-02f, -1.42840855e-02f, 2.37278175e-02f, -1.50681987e-01f, 3.03487782e-03f, -1.07126698e-01f, -3.25772464e-02f, 6.17596693e-02f, -9.56657231e-02f,
  1.91019893e-01f, -5.01696095e-02f, 6.75029540e-03f, 1.03739135e-01f, -8.22472870e-02f, -9.78504941e-02f, -3.43345180e-02f, -1.59083251e-02f, -6.21394068e-02f, 4.96163554e-02f,
  1.08823488e-02f, 9.10321176e-02f, 1.73629411e-02f, -9.67097282e-02f, 7.51471892e-02f, 3.38686667e-02f, -1.19475506e-01f, -1.39597580e-02f, -8.66131783e-02f, 3.05721108e-02f,
  -1.87384233e-01f, -4.41227891e-02f, 1.79064319e-01f, 1.30553797e-01f, -2.59338412e-02f, 2.18063831e-01f, 1.66133136e-01f, 1.15682513e-01f, 1.30212620e-01f, 4.23788056e-02f,
  4.37394343e-02f, -1.48222804e-01f, 1.04810119e-01f, -4.08154763e-02f, -2.31394783e-01f, -2.68161029e-01f, -3.77862185e-01f, -1.25353515e-01f, -7.09018623e-03f, -2.00796828e-01f,
  -1.12750731e-01f, 1.24150291e-01f, 3.02657664e-01f, 8.73414576e-02f, -1.29363731e-01f, -2.06089482e-01f, -2.13367000e-01f, -1.32874683e-01f, -2.24721476e-01f, -3.22748125e-01f,
  -3.47741246e-01f, -9.34320912e-02f, -1.31747961e-01f, -1.93015076e-02f, 3.60677019e-02f, 3.35301794e-02f, -9.56683245e-04f, -5.72887957e-02f, -1.17650211e-01f, 1.83022139e-03f,
  2.97047317e-01f, -2.86414083e-02f, 1.11713074e-02f, -1.35343969e-01f, 2.60301935e-03f, 4.65289094e-02f, -4.71849255e-02f, 2.90626418e-02f, 1.01619754e-02f, 6.20743409e-02f,
  -3.59903425e-02f, -4.92798574e-02f, 5.75347692e-02f, -9.50968191e-02f, -3.29255834e-02f, -1.15937032e-01f, -6.45495132e-02f, -3.32594216e-02f, -5.20353690e-02f, -1.02786712e-01f,
  -9.95001346e-02f, -8.06603432e-02f, 1.30893216e-01f, -5.44887446e-02f, 5.40006496e-02f, 1.29915047e-02f, 5.97976707e-02f, -2.65047047e-02f, -6.27775723e-03f, -4.69892174e-02f,
  -1.16067126e-01f, 9.87542272e-02f, -5.25903292e-02f, 5.22888266e-02f, 5.88240195e-03f, 4.55629677e-02f, -3.43879685e-02f, -3.18567045e-02f, 4.59489645e-03f, 6.32751957e-02f,
  4.43783067e-02f, -5.20503558e-02f, 8.61858875e-02f, 8.41357920e-04f, 7.47346506e-02f, -5.13007231e-02f, 2.01466754e-02f, 2.19062027e-02f, -2.56310906e-02f, -6.34134188e-02f,
  -5.86112328e-02f, -1.04372818e-02f, -7.66496314e-03f, -1.83458198e-02f, -1.77422717e-01f, 2.80792806e-02f, -7.33452812e-02f, -1.09435208e-02f, -6.07287213e-02f, -7.04724863e-02f,
  3.44454139e-01f, 3.72590497e-02f, 1.12545758e-01f, -1.91092119e-02f, -6.20640703e-02f, -1.12079373e-02f, 5.36391810e-02f, -3.66126448e-02f, 4.58969101e-02f, -3.59065346e-02f,
  -3.53461616e-02f, 5.74434511e-02f, 4.95904312e-03f, -2.82495748e-02f, -1.49729595e-01f, -1.11148454e-01f, -2.54319876e-01f, -3.76133336e-04f, -2.57585850e-02f, -5.02473749e-02f,
  -1.17207527e-01f, -1.32735804e-01f, 1.30219340e-01f, 1.19247921e-01f, 1.06766131e-02f, 1.11825176e-01f, 1.35561809e-01f, 7.40845650e-02f, 1.09584287e-01f, 1.97357163e-04f,
  -1.00900270e-01f, -1.82682022e-01f, -2.66130716e-01f, -2.71421373e-01f, -9.87128019e-02f, 8.18966702e-03f, -4.66724038e-02f, -4.57417034e-02f, -7.29157776e-02f, -1.97936758e-01f,
  -2.82055289e-02f, -2.76640579e-02f, -2.26155326e-01f, -9.18595493e-02f, -7.57230446e-02f, -2.75458485e-01f, -2.37776801e-01f, -1.94332719e-01f, 4.91531752e-02f, 1.84218869e-01f,
  4.24476005e-02f, -6.19723648e-02f, -2.66699269e-02f, -2.24523768e-02f, -1.33631825e-01f, -6.31150752e-02f, -2.60380030e-01f, -1.43736944e-01f, -2.37087766e-03f, -2.41820663e-01f,
  -1.91543370e-01f, -5.94233125e-02f, -8.46500974e-03f, 2.65853517e-02f, -4.67417724e-02f, 5.56742735e-02f, 9.75783635e-03f, -3.17615941e-02f, 5.92528023e-02f, -3.36972214e-02f,
  -2.32789125e-02f, 7.56290630e-02f, -3.80878337e-02f, -5.38145844e-03f, -3.49930301e-02f, 5.15771769e-02f, -4.93585169e-02f, -1.47328740e-02f, -9.29041356e-02f, 1.68058146e-02f,
  3.03124506e-02f, -5.15908934e-02f, -1.50860891e-01f, -1.18851904e-02f, -3.05578467e-02f, -6.38736710e-02f, -1.37776230e-02f, 1.04280964e-01f, -5.35809286e-02f, -1.29493743e-01f,
  -2.50225957e-03f, -6.08642362e-02f, -8.01163390e-02f, 2.04926934e-02f, -3.63787025e-04f, -6.19800128e-02f, -3.75021994e-02f, -2.05544177e-02f, 8.28016996e-02f, 1.92211883e-03f,
  -8.76206383e-02f, -1.12587083e-02f, -1.83178531e-03f, -1.63578354e-02f, 1.66297592e-02f, -9.22821686e-02f, -2.66076606e-02f, -5.85963577e-02f, 1.25307404e-02f, 8.86084884e-03f,
  -2.11193692e-02f, -2.84907576e-02f, -6.61624074e-02f, -7.31826946e-03f, 4.70641553e-02f, -2.95476615e-02f, 7.99084455e-03f, 2.41431072e-02f, -7.78711885e-02f, 4.29410972e-02f,
  -1.56408310e-01f, -4.46045734e-02f, -1.58084214e-01f, 1.21094356e-03f, -5.86431101e-02f, 6.53640414e-03f, -6.86362535e-02f, 7.21864179e-02f, -4.07785401e-02f, -3.93632017e-02f,
  -1.21782010e-03f, -7.08087534e-02f, -1.24063522e-01f, 3.38935219e-02f, 1.37103396e-02f, -4.99233254e-04f, -3.20862681e-02f, -1.22064441e-01f, -3.06483041e-02f, 6.01746514e-02f,
  -2.31237262e-02f, -6.13798052e-02f, -1.51407346e-01f, -1.43396482e-01f, 5.68788406e-03f, -7.37930685e-02f, -8.76097605e-02f, 1.36603015e-02f, -7.88726285e-02f, -1.60710335e-01f,
  -7.30134010e-01f, -2.66143680e-01f, 1.86714336e-01f, -6.38639256e-02f, 3.16621326e-02f, 2.08236560e-01f, 5.17635681e-02f, -6.79091215e-02f, -5.75006641e-02f, -9.21723992e-02f,
  -2.19277099e-01f, -1.53691739e-01f, -1.96460053e-01f, -4.33488376e-02f, -1.57193672e-02f, 4.04534377e-02f, 1.06611215e-01f, 1.04955621e-02f, 1.35795489e-01f, 9.26279128e-02f,
  4.54616621e-02f, -3.84398997e-02f, -2.43702859e-01f, -1.28891855e-01f, 4.01230790e-02f, -5.51415309e-02f, 6.13857955e-02f, -6.42743856e-02f, 6.38096333e-02f, 1.19138032e-01f,
  4.72687781e-01f, -1.42151520e-01f, 7.12692887e-02f, -8.99100900e-02f, -7.80853406e-02f, -1.78728506e-01f, -7.20587000e-02f, -4.64861915e-02f, 6.78250846e-03f, 1.04750648e-01f,
  8.84339586e-02f, -1.71348099e-02f, 6.19743913e-02f, 5.13363704e-02f, 1.42589137e-01f, 5.02624437e-02f, 4.22425196e-02f, 6.29212335e-02f, 8.85915011e-02f, -1.39786974e-02f,
  5.97813241e-02f, 2.13343184e-02f, 9.43832472e-02f, 1.13364853e-01f, -6.20866306e-02f, -2.14877836e-02f, 5.26081212e-02f, 1.06750183e-01f, 9.53115802e-03f, 4.53677513e-02f,
  5.25322219e-04f, -1.96492106e-01f, 6.08118959e-02f, -7.98516795e-02f, -1.22213952e-01f, 4.24741246e-02f, 3.67422290e-02f, -1.95797645e-02f, -9.93826985e-02f, -3.07549182e-02f,
  9.18502212e-02f, 1.96042165e-01f, 8.94644670e-03f, 3.70318964e-02f, -2.38145553e-02f, 4.05121259e-02f, 3.82062271e-02f, 5.80483600e-02f, -4.78370290e-04f, 8.01930502e-02f,
  1.96594894e-02f, 6.00410486e-03f, -3.60880792e-02f, 2.11358711e-01f, 2.03324154e-01f, 5.45580983e-02f, 1.13044642e-01f, 5.58277071e-02f, 5.77825047e-02f, -1.17190897e-01f,
  4.28829044e-01f, -4.80792485e-02f, -5.70698753e-02f, -1.81683749e-02f, -7.31591892e-04f, -1.44611269e-01f, 4.61649001e-02f, 8.79587680e-02f, 9.91339758e-02f, 1.37507081e-01f,
  1.81858102e-03f, -4.37101498e-02f, -1.28283759e-03f, -5.69041334e-02f, 8.83675814e-02f, -8.49452335e-03f, -1.33647159e-01f, 3.57077830e-02f, 7.63337389e-02f, 1.26145080e-01f,
  -8.24850872e-02f, 1.01522312e-01f, 5.97035550e-02f, 1.37777701e-01f, 9.29314457e-03f, -1.36660393e-02f, 1.58972576e-01f, 6.03427701e-02f, 1.60215244e-01f, -2.13359594e-02f,
  1.49126813e-01f, 4.71043065e-02f, 2.63034981e-02f, 2.21675545e-01f, 1.94858447e-01f, 2.51145601e-01f, 3.48467022e-01f, 2.11739644e-01f, 1.73338175e-01f, -2.73166923e-03f,
  7.20310658e-02f, -1.30570143e-01f, 7.82308169e-03f, -1.62620991e-01f, -7.85081908e-02f, 8.82564709e-02f, 9.58202183e-02f, 1.93424169e-02f, 1.61187705e-02f, 3.96798775e-02f,
  -2.62828767e-02f, 9.86167789e-02f, -6.64136261e-02f, -7.93353692e-02f, -4.59101610e-02f, -9.74821001e-02f, 7.50974705e-03f, 1.04217539e-02f, 4.57337275e-02f, -1.31302491e-01f,
  -1.85139984e-01f, -2.04191450e-02f, -2.49280799e-02f, -1.88415572e-01f, -1.12871274e-01f, -5.77353165e-02f, -4.81376797e-02f, -5.24498001e-02f, -9.37349349e-02f, -4.78178561e-02f,
  -1.01921037e-01f, -4.77448367e-02f, -6.12032041e-02f, -1.05788276e-01f, 2.98624951e-02f, -4.67448533e-02f, -9.73293781e-02f, -1.30228132e-01f, -7.51463622e-02f, -7.93327168e-02f,
  -1.18605427e-01f, 8.46417900e-03f, 1.00444980e-01f, -2.44696736e-02f, -8.06489959e-02f, -1.29730180e-01f, -9.95053500e-02f, -9.22227576e-02f, -5.74096069e-02f, -1.05362020e-01f,
  4.36958484e-02f, 2.68598236e-02f, 6.01105802e-02f, -3.28620337e-02f, -8.17286372e-02f, -1.26466900e-01f, -4.94024828e-02f, 1.82436015e-02f, 5.27867265e-02f, 6.71279728e-02f,
  2.12935172e-02f, -7.09485495e-03f, 2.62704436e-02f, 1.41838476e-01f, -3.30667607e-02f, 7.16034845e-02f, 1.33554727e-01f, 3.69245112e-02f, 2.71476805e-02f, 9.53381285e-02f,
  1.09975420e-01f, 2.25674361e-03f, 6.95904717e-02f, -2.68243812e-03f, -3.07930037e-02f, -3.49445976e-02f, 4.93686125e-02f, 2.51284074e-02f, -4.04734388e-02f, 1.10007338e-01f,
  4.01659943e-02f, 1.24922425e-01f, -3.56828352e-03f, -3.16141844e-02f, 3.51658873e-02f, -1.97572373e-02f, -4.87474278e-02f, -6.33228049e-02f, -1.14661507e-01f, -3.97837386e-02f,
  1.48569569e-02f, -8.94523114e-02f, -3.16281654e-02f, 4.16605268e-03f, 5.99126294e-02f, 5.69471791e-02f, -1.37587070e-01f, -6.27871156e-02f, -1.07977904e-01f, -6.76322207e-02f,
  -7.49441534e-02f, 1.08290434e-01f, 8.31252933e-02f, 9.02032852e-02f, 8.22329298e-02f, -1.83258560e-02f, -6.88315602e-03f, 7.82570317e-02f, 1.29062787e-01f, 1.00309946e-01f,
  2.11436093e-01f, -3.98403764e-01f, -9.26782042e-02f, -1.42888213e-02f, 2.49977987e-02f, -4.41283956e-02f, -9.49713886e-02f, -9.92310047e-02f, 1.07337601e-01f, -5.09199016e-02f,
  4.08990942e-02f, 2.19729114e-02f, 9.10012648e-02f, -2.37176456e-02f, 5.58310449e-02f, -8.77000093e-02f, -9.49160010e-02f, -7.22044241e-03f, 1.30173802e-01f, -1.18989244e-01f,
  -2.38477159e-02f, -1.44705713e-01f, -2.20294688e-02f, -8.52367058e-02f, -1.19693846e-01f, -2.36132871e-02f, -3.99911366e-02f, -1.80184826e-01f, -1.18131459e-01f, -1.17823213e-01f,
  -1.05603531e-01f, 1.70078576e-01f, 1.40367940e-01f, 5.12472764e-02f, -6.73010200e-02f, 3.65464240e-02f, 1.31345332e-01f, -9.36810821e-02f, -8.36010128e-02f, -3.72134224e-02f,
  2.50611398e-02f, -1.10906124e-01f, 9.08365026e-02f, -4.47458141e-02f, 3.11564393e-02f, -2.54315045e-02f, 4.92563806e-02f, -1.69691406e-02f, 3.51832695e-02f, -4.79829125e-03f,
  1.82587765e-02f, 2.74420753e-02f, 8.81857276e-02f, 1.57269061e-01f, 1.50298104e-01f, 1.69685379e-01f, 7.57043511e-02f, 1.38735816e-01f, 2.07183689e-01f, 1.67280063e-01f,
  3.08680125e-02f, 2.02528592e-02f, 1.25537947e-01f, 1.26452744e-01f, 1.82120353e-01f, 6.00084849e-02f, -7.20439926e-02f, 1.21305173e-04f, 1.63399175e-01f, -6.92277700e-02f,
  -3.02412584e-02f, 1.39092565e-01f, 1.39931574e-01f, 1.40664391e-02f, 2.51164436e-02f, -2.75167860e-02f, -8.82363617e-02f, 3.50120142e-02f, 2.05782712e-01f, -3.89662827e-03f,
  1.56599879e-01f, -1.66146055e-01f, -1.69519141e-01f, -1.24144308e-01f, -1.12675525e-01f, 1.14282757e-01f, -2.69059371e-02f, 5.35773933e-02f, -7.93906897e-02f, -7.10060745e-02f,
  -3.50253344e-01f, 5.01052499e-01f, 1.45133704e-01f, 3.28442338e-03f, -1.31377624e-02f, -1.49794146e-01f, 1.51810229e-01f, -9.92124230e-02f, -1.78704083e-01f, -4.77584079e-02f,
  -4.32765409e-02f, -1.01151772e-01f, -4.84166779e-02f, 2.45495234e-02f, 9.84042063e-02f, 1.00155830e-01f, -1.89274363e-02f, 4.63215960e-03f, -1.09298624e-01f, -1.43896088e-01f,
  -8.46884549e-02f, 4.99753319e-02f, 7.72452950e-02f, 1.47200748e-01f, 1.32110432e-01f, 1.00097932e-01f, 3.09325842e-04f, 5.49317002e-02f, 1.51765123e-01f, 6.86275810e-02f,
  1.44697949e-01f, -5.29410020e-02f, 1.23818643e-01f, 1.15921319e-01f, -2.41760775e-01f, -1.72035247e-01f, -1.61601394e-01f, -9.91692543e-02f, 6.39576539e-02f, 9.75481942e-02f,
  8.71790573e-02f, 2.47581348e-01f, 3.36338133e-01f, 2.45739490e-01f, 1.73836350e-01f, 8.65886360e-02f, 1.19633324e-01f, 1.75374135e-01f, 3.80648635e-02f, -7.37169310e-02f,
  -5.61858602e-02f, 3.58623266e-02f, 1.49972811e-01f, -2.49605235e-02f, 2.14479920e-02f, 1.58129752e-01f, 1.14800952e-01f, 3.95930093e-03f, 7.32232332e-02f, 3.20741311e-02f,
  2.30810076e-01f, -1.54347822e-01f, 1.76230326e-01f, -1.13896290e-02f, -1.35559272e-02f, -2.42873840e-02f, -1.77057888e-02f, -4.71315719e-02f, -7.52217025e-02f, -3.85970362e-02f,
  -5.92102529e-03f, -7.65199810e-02f, -1.89176351e-02f, -9.50058326e-02f, -5.04259057e-02f, -1.30089922e-02f, 7.62098506e-02f, 5.82040660e-02f, 9.48894303e-03f, -1.09802820e-02f,
  -6.12316020e-02f, -1.09604038e-01f, -7.11291954e-02f, 2.88166720e-02f, 6.59474283e-02f, 1.52967900e-01f, -5.41261919e-02f, -7.73899853e-02f, -2.49667298e-02f, 1.00865617e-01f,
  -4.45078015e-02f, 1.00414626e-01f, 1.07709959e-01f, 1.30247340e-01f, 1.12434924e-01f, 5.75888567e-02f, -7.18903542e-02f, -6.73902184e-02f, 1.02168664e-01f, 7.91441202e-02f,
  3.30385529e-02f, 9.78072360e-02f, 1.23670828e-02f, -2.95203570e-02f, 1.59930393e-01f, 4.45955135e-02f, 8.87375977e-03f, 4.74236682e-02f, 1.04040869e-01f, 7.24577308e-02f,
  8.23258460e-02f, 1.20262727e-02f, 5.82372509e-02f, 1.01375826e-01f, -1.22531783e-02f, 2.80928351e-02f, 1.38439739e-03f, 3.68547067e-02f, -3.32380719e-02f, -8.53105336e-02f,
  1.52662203e-01f, -1.67362932e-02f, 1.38345852e-01f, 5.83840460e-02f, -1.50406972e-01f, -1.37589201e-01f, 7.60304704e-02f, -3.41547914e-02f, 2.82728206e-02f, -5.57775907e-02f,
  -1.18023217e-01f, 1.04633063e-01f, -9.88422148e-03f, -6.42528459e-02f, 2.39512920e-02f, -8.48622844e-02f, 7.27871954e-02f, -3.90743315e-02f, 1.86191294e-02f, -9.32150409e-02f,
  4.05771472e-02f, -1.12406565e-02f, 6.11037239e-02f, 1.17438592e-01f, 5.48025779e-02f, 1.31627560e-01f, 1.47289233e-02f, 3.72857675e-02f, 4.80970517e-02f, 5.16998209e-03f,
  -4.25585836e-01f, -1.99917965e-02f, -9.37765930e-03f, -8.90247449e-02f, 1.32047638e-01f, -2.12338418e-01f, -2.14846715e-01f, -3.15146625e-01f, -2.37604573e-01f, -2.64415145e-02f,
  1.84770927e-01f, 3.19669545e-01f, 1.89997926e-01f, 7.83428773e-02f, -1.21849261e-01f, -1.96542948e-01f, -1.67866692e-01f, -7.52566457e-02f, 1.05961554e-01f, 2.47919336e-01f,
  1.90414280e-01f, 2.28430815e-02f, -9.47912708e-02f, -1.57476701e-02f, 2.23298818e-01f, 1.54776543e-01f, -1.12911239e-02f, 8.81461278e-02f, 4.21835221e-02f, 2.42813319e-01f,
  4.36464161e-01f, -2.41861016e-01f, -1.19845673e-01f, 2.96495017e-02f, 9.56834257e-02f, -9.95603502e-02f, -6.48036599e-02f, -9.21740904e-02f, -1.58373028e-01f, -1.19625814e-01f,
  9.29323733e-02f, -4.20372859e-02f, 2.83349454e-02f, 5.09284697e-02f, -5.90053573e-02f, -3.52892652e-02f, -1.12542048e-01f, -2.16547653e-01f, -1.95172966e-01f, 2.14495547e-02f,
  1.52205452e-01f, 1.52683511e-01f, -1.28042027e-02f, -1.48810804e-01f, -9.58246142e-02f, 1.06704170e-02f, 5.16602993e-02f, -8.44724253e-02f, -2.21678033e-01f, -8.42979830e-03f,
  -7.79575575e-03f, 1.77555028e-02f, 3.42570730e-02f, -1.28009403e-02f, 2.19986867e-03f, -3.72353643e-02f, -3.20460498e-02f, 1.09259777e-01f, -4.31768671e-02f, 2.58913580e-02f,
  4.18239227e-03f, -1.27324574e-02f, 7.54695833e-02f, -1.53733492e-01f, 1.04787359e-02f, -1.54075790e-02f, 5.98894171e-02f, 4.73104119e-02f, -1.45978369e-02f, -5.10946885e-02f,
  -2.66185682e-02f, -6.51476234e-02f, -3.33728790e-02f, 7.33693456e-03f, -4.07644510e-02f, -3.71268317e-02f, -8.42392631e-03f, 6.38340861e-02f, 1.20256701e-02f, -3.69615555e-02f,
  1.99238390e-01f, -2.60092199e-01f, 3.52940857e-02f, -5.41485772e-02f, 2.08870713e-02f, -9.88333747e-02f, 2.57030614e-02f, -8.71541575e-02f, -7.11791776e-03f, -1.14867771e-02f,
  1.26107791e-02f, -7.65878335e-02f, -3.92564945e-02f, 3.38800289e-02f, 7.34423697e-02f, 4.69438955e-02f, 1.43660069e-01f, 9.86111462e-02f, -1.12035893e-01f, 8.21655318e-02f,
  -1.29023731e-01f, -7.49266297e-02f, 1.14976510e-01f, 7.68042356e-02f, 5.19685335e-02f, 1.01556621e-01f, 6.79519102e-02f, 1.30353108e-01f, -7.98246115e-02f, -1.92662017e-04f,
  -3.10589001e-02f, -1.66224405e-01f, 3.46819758e-01f, 9.08935368e-02f, 2.01321781e-01f, -1.29783198e-01f, -4.63774174e-01f, -3.60173911e-01f, 1.34497220e-02f, 7.11739659e-02f,
  2.23208472e-01f, 8.95347521e-02f, 1.21435769e-01f, -9.13203582e-02f, -2.46937171e-01f, -9.67540741e-02f, 7.47045651e-02f, 3.48560810e-02f, -1.30045578e-01f, -1.26726493e-01f,
  -1.19651549e-01f, -1.30243227e-02f, 4.98233512e-02f, -7.98893794e-02f, 6.63205162e-02f, -3.75274867e-02f, 1.41979635e-01f, 1.52775869e-01f, 9.69024524e-02f, 1.24160334e-01f,
  3.12639266e-01f, -3.55523825e-02f, 2.14974433e-02f, 1.53563082e-01f, 2.35747024e-01f, -2.15692624e-01f, -1.40360638e-01f, 1.30611569e-01f, -1.15861170e-01f, 4.39084247e-02f,
  2.99594432e-01f, 5.36621921e-02f, 1.07730545e-01f, -8.69773924e-02f, 5.17839193e-03f, -2.27030739e-01f, -4.25461233e-02f, -1.74434006e-01f, -1.08404405e-01f, -9.36324149e-02f,
  -7.40522966e-02f, 1.82139531e-01f, 1.89788014e-01f, -5.39763458e-02f, -1.29857898e-01f, 1.22931443e-01f, -6.97886795e-02f, -1.17233038e-01f, -7.47419149e-02f, -1.58882782e-01f,
  9.64880809e-02f, 1.57849312e-01f, 5.02945855e-02f, 8.24691057e-02f, -6.68652654e-02f, 5.28177135e-02f, 7.67284930e-02f, -5.46054691e-02f, 1.32740755e-03f, -3.49257588e-02f,
  -2.64465045e-02f, 7.41323307e-02f, -1.00222252e-01f, -7.15246573e-02f, 6.23283871e-02f, 1.75992176e-02f, -7.29812169e-03f, -6.52460605e-02f, 1.16986237e-01f, -1.09549137e-02f,
  -2.77108848e-02f, -3.98020968e-02f, 1.54335931e-01f, -2.00917795e-01f, 9.53920633e-02f, 9.53722224e-02f, 4.73625511e-02f, -5.56278564e-02f, 5.79103380e-02f, 1.19602650e-01f,
  5.98190352e-02f, 1.45018280e-01f, 4.73072566e-02f, -1.57574996e-01f, 1.15395829e-01f, 5.49154822e-03f, -1.10837631e-02f, -9.52219032e-03f, 5.00013046e-02f, -5.35663702e-02f,
  -8.37083813e-03f, 4.69260626e-02f, 1.25882775e-01f, -3.60513143e-02f, -9.49040651e-02f, 1.36443479e-02f, 1.33458868e-01f, 9.91199315e-02f, -6.29406646e-02f, -1.30502740e-02f,
  -9.26976874e-02f, -1.13470338e-01f, 1.47697907e-02f, -1.43083423e-01f, 1.11649390e-02f, 5.39958067e-02f, -7.86664262e-02f, -1.99212894e-01f, -1.44149944e-01f, -3.69256973e-01f,
  -5.52773714e-01f, 2.88182795e-01f, 3.89790863e-01f, -4.05703127e-01f, 5.53942285e-02f, 2.31375322e-01f, 3.17224473e-01f, 1.39261305e-01f, -1.67928070e-01f, -1.08648621e-01f,
  8.81838612e-03f, -2.48396501e-01f, -8.09935778e-02f, -8.67444649e-02f, 4.95854579e-02f, 5.73319569e-02f, 1.12925069e-02f, 2.16579088e-03f, 5.96570931e-02f, -6.54258020e-03f,
  -1.21434510e-01f, -1.81265086e-01f, -1.91361740e-01f, -1.45349102e-02f, -1.53833896e-01f, -2.09563017e-01f, 6.46028072e-02f, -9.60075036e-02f, 3.29090282e-02f, -2.88400948e-01f,
  -3.36585909e-01f, 9.08916593e-02f, -5.29961055e-03f, -9.19931605e-02f, -8.26684237e-02f, -2.07347319e-01f, 3.18561979e-02f, 1.78076085e-02f, -1.34399340e-01f, -1.28821069e-02f,
  9.72473063e-03f, 2.75654010e-02f, -4.31559123e-02f, -1.35332033e-01f, -2.21908577e-02f, 5.02366796e-02f, 5.65392338e-02f, 1.82750840e-02f, -6.03046976e-02f, 9.71246064e-02f,
  -1.95918873e-01f, -8.95004645e-02f, 1.16636083e-01f, 2.01807857e-01f, 4.12913412e-02f, -6.02604896e-02f, 8.28889832e-02f, 1.66496299e-02f, 1.08417019e-01f, -3.00628185e-01f,
  -4.78042066e-02f, -5.81077524e-02f, 5.70831075e-02f, -3.11502311e-02f, -1.40410468e-01f, -1.83831137e-02f, -4.87476476e-02f, -8.84360075e-02f, -7.25950450e-02f, -6.98244795e-02f,
  1.79490283e-01f, 1.08902253e-01f, 5.75328954e-02f, 8.38737637e-02f, -1.62881419e-01f, -6.99223299e-03f, 5.93852159e-03f, 1.26641095e-01f, -9.18136016e-02f, -9.65945143e-03f,
  -4.05601561e-02f, -1.62472725e-02f, 2.75148172e-02f, -4.63530757e-02f, 6.38964474e-02f, 3.31933126e-02f, 1.78136490e-02f, -4.65867855e-03f, 2.95804590e-02f, 2.36024916e-01f,
  -3.76888603e-01f, 8.71329457e-02f, -3.18102092e-01f, -5.85792698e-02f, -1.56033769e-01f, -1.11464830e-02f, 3.25519382e-03f, 8.65805000e-02f, 3.42924409e-02f, -3.46626416e-02f,
  2.45633900e-01f, 2.29429509e-02f, 2.59950384e-02f, -2.74991011e-03f, -1.34426817e-01f, 7.92035554e-03f, -2.16907308e-01f, -1.00143269e-01f, -9.07975584e-02f, -7.95565844e-02f,
  -2.07627043e-01f, -2.47696862e-01f, -3.80808324e-01f, -1.66314334e-01f, -2.52055854e-01f, -2.80045599e-01f, -2.47203335e-01f, -2.04034731e-01f, -1.15978874e-01f, -4.89927202e-01f,
  -2.19073921e-01f, 7.64651299e-02f, -3.08129452e-02f, -9.13982540e-02f, 1.20527491e-01f, -6.25962764e-02f, -1.80901766e-01f, -3.33729297e-01f, -4.92870696e-02f, 6.99992180e-02f,
  1.63030088e-01f, 8.26798677e-02f, 3.16790603e-02f, -8.49596709e-02f, -3.87699246e-01f, -2.49098316e-01f, -2.54835874e-01f, -2.66811192e-01f, -2.77498960e-01f, -1.54591888e-01f,
  8.21523443e-02f, -8.77812505e-02f, -1.82119042e-01f, -1.42613590e-01f, 2.13615701e-01f, 1.82276562e-01f, 1.86833620e-01f, 8.88076946e-02f, 1.73461094e-01f, 2.73558170e-01f,
  2.21809402e-01f, -1.13604754e-01f, -9.61171463e-02f, -3.87321152e-02f, 1.20858602e-01f, 2.85792314e-02f, -6.08005114e-02f, -5.76712564e-02f, -9.07315835e-02f, -3.88743803e-02f,
  8.69968757e-02f, -2.50177421e-02f, -6.50275946e-02f, 3.49479355e-02f, -2.74336040e-02f, -9.82980505e-02f, -1.63475052e-01f, -2.04574019e-01f, -1.66519523e-01f, -2.67181210e-02f,
  4.93818112e-02f, 3.07482276e-02f, -5.66193908e-02f, -9.93282050e-02f, -1.35297194e-01f, 1.48450844e-02f, -6.88660366e-05f, 2.32196022e-02f, -7.91144744e-02f, 9.38230827e-02f,
  4.32950817e-02f, -1.14938430e-02f, -1.84645113e-02f, 7.68357366e-02f, 2.05286946e-02f, 1.11475170e-01f, 3.05223744e-02f, -2.03337837e-02f, -5.54032177e-02f, 3.14353555e-02f,
  -4.22748514e-02f, 3.74092720e-02f, 1.62291154e-02f, -5.14859892e-02f, -3.34690847e-02f, -6.27360940e-02f, -2.80219018e-02f, -2.10159179e-02f, -7.73338228e-02f, 4.57285438e-03f,
  -6.91851452e-02f, -6.07356336e-03f, 7.51559362e-02f, -7.39317983e-02f, 2.16281265e-02f, -5.67270331e-02f, -1.00638960e-02f, -4.38156240e-02f, -2.79777944e-02f, -7.60379806e-02f,
  1.39177740e-01f, -1.19094402e-01f, 5.29269576e-02f, -1.62894592e-01f, -1.26289867e-03f, 1.28063202e-01f, 7.93805420e-02f, -2.46900469e-02f, 6.03169315e-02f, -2.83071101e-02f,
  -1.25469461e-01f, -9.31059476e-03f, 6.77904487e-02f, 7.04535618e-02f, -3.34282927e-02f, -7.68907880e-03f, 7.86472484e-03f, 4.46415432e-02f, -4.85093407e-02f, 1.07710443e-01f,
  -1.14246637e-01f, -9.50339511e-02f, -1.42159045e-01f, -2.22030487e-02f, -6.60192072e-02f, -1.77208818e-02f, 7.90890157e-02f, 8.89511257e-02f, -8.91280994e-02f, 1.89450141e-02f,
  2.07140129e-02f, -1.76916197e-01f, -4.27335232e-01f, 8.82418379e-02f, -6.84294775e-02f, -7.54426047e-02f, -8.57869536e-03f, 1.74962372e-01f, 1.21514827e-01f, -1.24107510e-01f,
  -9.98420864e-02f, 6.26591593e-02f, -6.47953749e-02f, 7.24619906e-03f, 6.81871623e-02f, -1.38653651e-01f, -1.64203793e-01f, -1.15240656e-01f, 1.61907688e-01f, 2.78372139e-01f,
  1.70374095e-01f, 2.60703921e-01f, 1.75552145e-01f, 9.23230276e-02f, -1.13494597e-01f, -8.06109793e-03f, -1.40740991e-01f, -1.10529281e-01f, -1.20212309e-01f, -2.42829621e-01f,
  -3.71260971e-01f, -2.36028597e-01f, 4.95840088e-02f, 7.23402798e-02f, -5.13625890e-02f, -4.67506945e-02f, -2.10063960e-02f, -7.07525313e-02f, -9.20181721e-02f, -6.63859546e-02f,
  -1.26512766e-01f, -2.37879548e-02f, -1.01022065e-01f, -4.24995348e-02f, 2.01161411e-02f, -4.58997227e-02f, -5.14662452e-03f, -2.51877774e-02f, -3.02165765e-02f, -5.98342828e-02f,
  1.59192551e-02f, -1.34411424e-01f, -2.59338349e-01f, -5.11259809e-02f, -5.82807623e-02f, -1.95593238e-02f, -7.58428648e-02f, -5.12111224e-02f, -5.82314506e-02f, -1.88161030e-01f,
  9.52204317e-02f, 1.39804687e-02f, -4.14252952e-02f, 1.37776195e-03f, 1.29505396e-01f, -1.12939619e-01f, -6.98304474e-02f, 2.56809201e-02f, -2.99458280e-02f, 1.13578858e-02f,
  3.75265367e-02f, -2.08045244e-02f, 6.43689781e-02f, -2.39319094e-02f, -5.03232740e-02f, -3.57273258e-02f, -3.01598869e-02f, 3.56204957e-02f, -5.14340028e-03f, -1.53313614e-02f,
  3.99630256e-02f, -9.35744718e-02f, -4.47850488e-03f, 1.14589497e-01f, -7.55049512e-02f, 7.86343589e-03f, 4.89931256e-02f, 3.15830223e-02f, 1.76656991e-02f, -2.65774899e-03f,
  2.36975640e-01f, 2.56988574e-02f, -4.92748842e-02f, 3.99852283e-02f, -4.23627310e-02f, 5.10446392e-02f, -4.93633300e-02f, -1.99368894e-02f, -1.77015588e-01f, -2.15190668e-02f,
  -6.26912192e-02f, 2.26133540e-02f, -1.30045503e-01f, 7.66325891e-02f, 1.21769365e-02f, -4.33525704e-02f, -3.46090342e-03f, -1.30544424e-01f, 3.27484570e-02f, -4.91270982e-03f,
  9.40015260e-03f, 4.04064059e-02f, -3.17256935e-02f, -4.70003970e-02f, -2.15101112e-02f, 5.29814996e-02f, -9.22913179e-02f, 3.17983031e-02f, -3.89877968e-02f, -1.72237959e-02f,
  4.71688837e-01f, -1.40160993e-01f, -1.69070005e-01f, 2.31087148e-01f, -1.42785627e-02f, -7.62259737e-02f, -5.15436828e-02f, 3.30864266e-02f, 2.01961800e-01f, 3.98659296e-02f,
  -1.47885678e-03f, 1.55117512e-01f, 1.70154482e-01f, 8.74145329e-03f, 8.17763992e-03f, -5.27039990e-02f, -8.25834423e-02f, 5.85014820e-02f, -1.84168154e-03f, -7.81402458e-03f,
  3.67701203e-02f, 1.04855597e-01f, 1.28886327e-01f, -5.01826741e-02f, -1.13940500e-01f, 7.98493475e-02f, -1.38568074e-01f, -1.74202658e-02f, -1.25665098e-01f, -7.89085105e-02f,
  -3.56284417e-02f, -2.49852911e-01f, -2.21364130e-03f, 2.06752284e-03f, -2.09982358e-02f, 8.33027512e-02f, -5.87563254e-02f, -1.06984288e-01f, 4.71947305e-02f, -8.02610964e-02f,
  -5.87145016e-02f, -1.90300923e-02f, -5.57214282e-02f, -2.12792885e-02f, -1.14033520e-01f, -8.09936002e-02f, -1.17185220e-01f, 1.87646709e-02f, -5.99880107e-02f, -3.98038812e-02f,
  -1.23935277e-02f, -1.26370385e-01f, -3.83023769e-02f, -3.29501852e-02f, 2.96719316e-02f, 9.59793758e-03f, -4.23442237e-02f, -5.92477545e-02f, -1.37742803e-01f, 3.77945527e-02f,
  5.70461676e-02f, 1.41650647e-01f, 8.81146081e-03f, 3.11841792e-03f, 1.03819095e-01f, 6.81026801e-02f, 1.35932416e-01f, -3.01765967e-02f, 9.70258785e-04f, 8.73436332e-02f,
  1.66633315e-02f, 8.83133486e-02f, -1.75218191e-02f, -5.08666374e-02f, 1.21502327e-02f, 7.76492245e-03f, 3.90250422e-02f, 3.03832218e-02f, -7.36874193e-02f, 6.77248389e-02f,
  1.03216149e-01f, 1.07567376e-02f, 3.94261479e-02f, -4.00578864e-02f, -8.37518722e-02f, -1.14330137e-02f, 1.01003788e-01f, -1.02576064e-02f, 7.59206712e-02f, 4.96584140e-02f,
  1.88855737e-01f, -1.05448090e-01f, 2.29913101e-01f, -1.27067405e-03f, 3.61857191e-02f, 2.53486894e-02f, 1.03693098e-01f, -2.79763881e-02f, -1.00158468e-01f, 6.31210208e-02f,
  -4.84071486e-02f, 9.62700248e-02f, 4.35911398e-03f, -6.77088648e-02f, -5.32489596e-03f, 4.74125296e-02f, 3.04584019e-02f, 1.29804686e-01f, -2.01010182e-02f, 3.47648785e-02f,
  3.25214006e-02f, 9.81592834e-02f, 1.95198566e-01f, 1.59463912e-01f, -7.85283465e-03f, 8.71745348e-02f, 1.83579341e-01f, 9.99170393e-02f, 1.69817090e-01f, 3.24252367e-01f,
  2.37947866e-01f, -4.49255146e-02f, -7.20680505e-03f, 1.70302927e-01f, 6.53886944e-02f, 4.18417118e-02f, -1.11487933e-01f, -5.85588068e-03f, 1.08509623e-01f, 9.18812528e-02f,
  -1.93177730e-01f, -2.19137385e-01f, -1.51270255e-01f, -2.13915214e-01f, -1.77661523e-01f, 9.66151133e-02f, 2.20416710e-01f, 1.01468526e-01f, 2.72548646e-02f, 1.49827600e-01f,
  1.15273118e-01f, 1.71123460e-01f, 1.80420965e-01f, 1.28176481e-01f, 8.51432085e-02f, 4.34392095e-02f, 8.08818638e-02f, -4.38956264e-03f, -1.62682123e-02f, 2.54593432e-01f,
  -4.72876728e-02f, -2.18505323e-01f, 1.02365583e-01f, 1.56020289e-02f, -4.76416200e-02f, -5.54729141e-02f, 5.36459545e-03f, 4.47267257e-02f, -7.44326860e-02f, 1.61874592e-02f,
  1.96349192e-02f, -5.75833097e-02f, -6.86427802e-02f, -8.38721991e-02f, -6.03410043e-02f, -1.29380831e-02f, -2.35445444e-02f, -1.35749042e-01f, -5.84753975e-02f, -8.97868872e-02f,
  -7.67893419e-02f, -1.17662072e-01f, -1.92267492e-01f, -1.63174927e-01f, -2.09472388e-01f, -3.47467884e-02f, -9.10776407e-02f, -1.72088146e-01f, -1.37342677e-01f, -4.32901047e-02f,
  -3.04153204e-01f, -9.90969166e-02f, -2.24167839e-01f, -2.40200117e-01f, -1.62021041e-01f, -9.46501121e-02f, -8.59750621e-03f, -1.32702455e-01f, -1.69320866e-01f, -1.04130328e-01f,
  -1.13396579e-02f, -1.54235199e-01f, -1.74647003e-01f, 5.48127219e-02f, 1.15919504e-02f, -4.76983562e-02f, -8.77882838e-02f, -1.34816542e-01f, -1.96673527e-01f, -1.66025296e-01f,
  -1.04354903e-01f, 6.13457616e-03f, 1.71204463e-01f, 3.63729261e-02f, 3.63410637e-02f, -1.95220020e-02f, 2.07268838e-02f, -1.62168846e-01f, 1.34102139e-03f, 7.70578906e-02f,
  -6.76035360e-02f, -2.98882067e-01f, 1.87914655e-01f, 7.79410005e-02f, -4.04166132e-02f, 8.82615447e-02f, -5.14096208e-02f, 3.11886449e-03f, 3.88746858e-02f, -3.89888361e-02f,
  -8.82337019e-02f, 7.83521309e-02f, -1.04309060e-01f, 2.76852259e-03f, 1.03955001e-01f, -1.64378621e-02f, -1.05395176e-01f, 7.11166784e-02f, 4.80226874e-02f, 1.05804078e-01f,
  6.31794184e-02f, 8.05621445e-02f, 8.66922662e-02f, -5.75476559e-03f, -5.73344864e-02f, 1.44737050e-01f, 6.12324364e-02f, 5.97789176e-02f, -2.86913419e-04f, 2.00337976e-01f,
  3.85766000e-01f, 1.75362736e-01f, -5.05494922e-02f, 1.58831596e-01f, -3.82084012e-01f, -3.28866094e-01f, -3.31855655e-01f, -2.69219637e-01f, 2.36542728e-02f, 1.18618727e-01f,
  -2.16185614e-01f, -4.87807207e-02f, -6.83840318e-03f, 7.81361014e-02f, -2.25986503e-02f, 8.25603902e-02f, 1.69443920e-01f, 2.29639679e-01f, 1.24605775e-01f, 2.44213548e-02f,
  1.86848342e-01f, 1.80572897e-01f, 2.69995213e-01f, 2.05983102e-01f, 1.86608464e-01f, 1.12539314e-01f, 4.05792668e-02f, 9.13981423e-02f, 1.04195930e-01f, 4.38201070e-01f,
  1.71159700e-01f, -1.78019226e-01f, -2.01035097e-01f, -7.04226503e-03f, -7.57832304e-02f, 2.29576364e-01f, 1.34408876e-01f, 6.66688532e-02f, -5.38759828e-02f, 2.53891051e-01f,
  -3.19031766e-03f, 1.01253755e-01f, 5.13863079e-02f, 1.14957564e-01f, 1.01560965e-01f, -9.65386555e-02f, 6.96808770e-02f, 7.98475221e-02f, 5.25947623e-02f, -3.54268663e-02f,
  4.48293611e-02f, -1.68573186e-02f, -2.28347585e-01f, -2.72128820e-01f, -9.52883437e-02f, -1.76072924e-03f, -2.47666985e-01f, 3.36905546e-03f, -1.64773166e-01f, 2.70578593e-01f,
  -1.98272914e-01f, -9.81649533e-02f, 2.28445642e-02f, 9.91747230e-02f, 1.12761840e-01f, -1.07093379e-02f, 1.90528948e-02f, 6.80945115e-03f, 9.81482267e-02f, 1.25907391e-01f,
  -8.02414566e-02f, -1.59840360e-02f, -5.10929488e-02f, -5.06549738e-02f, -1.81139633e-02f, -1.53836280e-01f, -7.83953629e-03f, 1.48041416e-02f, -4.57751639e-02f, -5.32990620e-02f,
  6.35269359e-02f, -1.34848822e-02f, 3.97655480e-02f, -3.76007636e-03f, 3.14360647e-03f, -8.37620124e-02f, 5.66462725e-02f, 3.56114581e-02f, -8.02294239e-02f, -5.57084307e-02f,
  3.32304873e-02f, -3.46951753e-01f, 5.34540042e-02f, 4.42524217e-02f, 1.42082162e-02f, -5.16499579e-02f, -4.03249040e-02f, -1.07918652e-02f, -7.63844773e-02f, 7.82286376e-02f,
  7.55862007e-03f, 6.97407722e-02f, 6.23506540e-03f, 3.30236042e-03f, 1.02335483e-01f, -6.89361468e-02f, 5.18557280e-02f, -7.16097802e-02f, 5.25802188e-03f, -4.43999022e-02f,
  6.64570183e-02f, -4.66433242e-02f, -1.02597497e-01f, -3.48004729e-01f, -1.27918392e-01f, -8.52352828e-02f, -1.80947796e-01f, -3.97708900e-02f, -2.14552820e-01f, -2.05661487e-02f,
  4.00721699e-01f, -3.36268663e-01f, -2.31113464e-01f, 9.20998976e-02f, 1.90187544e-01f, 2.49834448e-01f, 4.35982198e-02f, 1.98289752e-01f, 1.46826163e-01f, -1.27197027e-01f,
  -1.97495684e-01f, -1.78906366e-01f, -2.18968913e-01f, -2.06705943e-01f, -1.52271524e-01f, -2.22053692e-01f, -1.95375994e-01f, -1.26871258e-01f, 3.44064087e-01f, 4.08658534e-01f,
  -1.01157157e-02f, 8.57076198e-02f, -1.79968439e-02f, -9.58528072e-02f, -1.77174360e-01f, -6.54346198e-02f, -2.73052841e-01f, -2.33029261e-01f, -2.23681882e-01f, -3.48248124e-01f,
  -2.75203675e-01f, -9.20695886e-02f, 1.12597644e-01f, -1.32228568e-01f, -1.54605106e-01f, -2.85447319e-03f, -2.52346545e-02f, -6.02125414e-02f, -4.24589776e-03f, 6.89147562e-02f,
  -8.99244398e-02f, 6.45880625e-02f, -6.72108084e-02f, -2.25783810e-02f, 1.02009391e-02f, 8.31539258e-02f, 2.57645771e-02f, -1.01520568e-01f, -2.28761099e-02f, -1.19909883e-01f,
  -9.00169536e-02f, 5.91603853e-02f, -2.77691577e-02f, 6.39609322e-02f, -2.76209805e-02f, -9.66603635e-04f, -2.05736663e-02f, -3.99656454e-03f, 6.86696470e-02f, 5.87714724e-02f,
  -9.62064117e-02f, 6.86440617e-02f, 2.95476355e-02f, 9.66075957e-02f, 9.56215858e-02f, 1.17158115e-01f, 1.15704335e-01f, -1.33565720e-02f, -6.46796227e-02f, 1.17193977e-03f,
  6.24847077e-02f, -1.26342073e-01f, -2.59687193e-02f, -1.13076292e-01f, -4.68879826e-02f, 4.07333411e-02f, 5.36046065e-02f, -1.42688781e-01f, -1.40498325e-01f, 2.98488531e-02f,
  2.81989519e-02f, 2.21822993e-03f, -2.04088856e-02f, -3.05406954e-02f, -1.08681880e-01f, -3.99103910e-02f, 3.80720496e-02f, -2.16998700e-02f, 3.69170196e-02f, 2.66640037e-02f,
  -4.45240960e-02f, -1.93410113e-01f, -6.63123950e-02f, -3.41411754e-02f, -4.29111719e-02f, -5.10352850e-02f, -1.07396342e-01f, 7.38870203e-02f, -5.82175422e-03f, 5.71386330e-02f,
  -1.25526667e-01f, -1.71952751e-02f, -1.91961646e-01f, 4.18439172e-02f, 1.30237490e-01f, 4.85102683e-02f, -1.49425849e-01f, -8.46504141e-03f, -4.81347591e-02f, -5.82834668e-02f,
  -1.67486697e-01f, 5.10913394e-02f, 6.53717741e-02f, 8.59371871e-02f, 1.05583958e-01f, 1.09092049e-01f, 7.91831017e-02f, 8.34983736e-02f, 1.28379315e-01f, 8.82424936e-02f,
  4.96082485e-01f, -3.71244662e-02f, 5.19016534e-02f, 2.65859365e-01f, 4.97645177e-02f, 1.37550253e-02f, 1.66978180e-01f, 2.19486147e-01f, 1.04529671e-01f, 9.54966545e-02f,
  -3.03327858e-01f, -4.37551141e-01f, -3.76624733e-01f, -2.92996705e-01f, -1.78447962e-01f, 2.45594367e-01f, 2.50299990e-01f, 1.08464167e-01f, -3.84865282e-03f, 1.74959376e-02f,
  -2.86138449e-02f, 2.62235284e-01f, 2.56369263e-01f, 9.20935199e-02f, 1.14398599e-01f, -7.45846778e-02f, 2.07090620e-02f, -2.78730281e-02f, -1.68177053e-01f, 6.30932897e-02f,
  -1.54482216e-01f, -3.47356834e-02f, 4.24373038e-02f, -5.16079515e-02f, -1.49131805e-01f, 5.61135486e-02f, 9.50523317e-02f, 3.82596627e-02f, -1.35248259e-01f, 1.19664900e-01f,
  -5.23530692e-02f, -6.82200640e-02f, -2.04975650e-01f, -4.10591774e-02f, -4.04737405e-02f, -1.09546930e-01f, 8.18434805e-02f, 9.50581767e-03f, -4.17618901e-02f, -3.37530710e-02f,
  -1.79298759e-01f, -1.01565905e-01f, -1.05986698e-02f, -4.47082669e-02f, -1.30979493e-01f, -8.15465078e-02f, -7.51411617e-02f, -6.25339299e-02f, -8.67370814e-02f, 1.45810306e-01f,
  4.11633309e-03f, -5.36906384e-02f, -4.13128957e-02f, 1.04846269e-01f, 5.03302254e-02f, -5.74858077e-02f, -5.85195087e-02f, -5.36311418e-02f, 3.39442417e-02f, 1.20890513e-01f,
  3.40195708e-02f, 1.72857307e-02f, -7.32858777e-02f, 4.63937223e-02f, -7.84163997e-02f, -1.24456614e-01f, 8.92017316e-03f, 1.15722477e-01f, 6.71887351e-03f, -1.45710558e-02f,
  -4.85195518e-02f, 3.66773494e-02f, 1.55229298e-02f, 8.35035369e-03f, -1.67139471e-02f, -5.72299324e-02f, 8.72523114e-02f, -1.28510162e-01f, -3.17931958e-02f, 9.26854908e-02f,
  1.54701576e-01f, -2.73145527e-01f, 3.67970988e-02f, -6.63151732e-03f, -9.80966166e-03f, -1.13279052e-01f, -1.36451751e-01f, -6.32044673e-02f, -9.70411524e-02f, -1.43826514e-01f,
  3.15615274e-02f, -6.01083003e-02f, -1.58301815e-01f, -1.06619574e-01f, 1.03258349e-01f, -8.40783641e-02f, 6.59126695e-03f, 3.01017310e-03f, -2.63652932e-02f, -5.45088500e-02f,
  3.00463140e-02f, 2.17845142e-01f, 2.19779849e-01f, 8.33568051e-02f, -9.35363770e-02f, 1.29971951e-01f, 1.05527803e-01f, 9.34235081e-02f, -1.84159670e-02f, 3.93813461e-01f,
  -2.52894908e-01f, -8.83339196e-02f, -3.93618703e-01f, -2.65064072e-02f, -6.97528943e-02f, -4.50293645e-02f, 7.47920722e-02f, 2.08879068e-01f, 1.82313278e-01f, 4.52685915e-02f,
  2.17508934e-02f, -5.49903847e-02f, -2.06936374e-01f, -7.58294091e-02f, -5.48604727e-02f, -6.12558760e-02f, -1.33078963e-01f, -2.17663482e-01f, -7.08738668e-03f, 2.42257118e-01f,
  1.69261143e-01f, 4.91048433e-02f, 4.14741822e-02f, 8.74878392e-02f, 3.45844217e-02f, -1.08184330e-02f, -8.05763453e-02f, -1.37409046e-01f, -6.84395730e-02f, -2.89396137e-01f,
  -2.63559908e-01f, -1.39721900e-01f, 1.21996164e-01f, 1.15772383e-02f, -2.97275800e-02f, -4.07965034e-02f, -3.16731222e-02f, -3.60109136e-02f, -9.14752334e-02f, 2.83745816e-03f,
  -1.22342095e-01f, -2.14364212e-02f, -1.23320006e-01f, -6.02279194e-02f, -3.84581322e-03f, 5.37397154e-02f, -1.47198001e-02f, -5.66872768e-02f, -1.08539522e-01f, -4.51118872e-02f,
  -1.52725801e-02f, -7.90669918e-02f, -2.82510936e-01f, -7.27851912e-02f, -2.81802416e-02f, -2.92776227e-02f, -7.78718293e-02f, -1.26551269e-02f, -6.53487295e-02f, -1.69548661e-01f,
  3.00990250e-02f, -8.18042755e-02f, 6.79248478e-03f, -2.69341320e-02f, 5.77809848e-02f, -7.59734735e-02f, -1.47770969e-02f, 4.52768840e-02f, 4.97427443e-03f, -9.48245749e-02f,
  -1.29558071e-01f, -4.43531461e-02f, 7.87424222e-02f, 1.16899595e-01f, 2.13276991e-03f, 9.00892764e-02f, 5.90077229e-02f, 1.14409544e-01f, 9.04914550e-03f, -7.28779435e-02f,
  6.68494403e-02f, 3.59615274e-02f, 9.67845842e-02f, 7.12812841e-02f, 3.75662930e-02f, 1.27000719e-01f, 1.36802375e-01f, 8.34465995e-02f, -5.56782596e-02f, 5.47301657e-02f,
  1.04271695e-01f, 1.63742200e-01f, -2.12551579e-02f, -4.35269671e-03f, -4.64923382e-02f, 4.57726382e-02f, -3.69956382e-02f, 6.83059096e-02f, -1.34216696e-01f, -3.74782123e-02f,
  -5.39718056e-03f, -8.53236113e-03f, -8.83370116e-02f, 1.46289542e-03f, -6.53133988e-02f, 1.81224607e-02f, -1.09655643e-02f, -2.09256396e-01f, -4.83197868e-02f, -1.05028898e-02f,
  -6.78756237e-02f, 3.33068371e-02f, -2.41093636e-01f, -2.47111648e-01f, -7.24565908e-02f, -4.17559668e-02f, -1.47253394e-01f, 1.01206593e-01f, -8.76231566e-02f, -6.65630549e-02f,
  6.26583546e-02f, -2.23252565e-01f, -3.82817507e-01f, -3.14866215e-01f, -2.62924939e-01f, -2.24839732e-01f, -1.53073296e-01f, -1.11757956e-01f, -8.72524902e-02f, -2.06929475e-01f,
  1.61234345e-02f, 5.58203273e-02f, 5.24975061e-02f, -9.89941731e-02f, 6.60607498e-03f, -1.85051605e-01f, -1.39957502e-01f, -2.91716993e-01f, -2.54281044e-01f, -2.29670525e-01f,
  -1.58988342e-01f, -3.36878181e-01f, -2.11370692e-01f, -2.26394311e-01f, -2.28876710e-01f, -1.93464771e-01f, -2.42187545e-01f, -2.29282632e-01f, -1.56903073e-01f, -2.14219227e-01f,
  -3.48686367e-01f, -3.15874889e-02f, -1.13724895e-01f, 1.12208426e-01f, -1.28745809e-01f, 3.87429483e-02f, -1.15627900e-01f, -2.71032862e-02f, 2.76037026e-02f, -1.25048801e-01f,
  -8.57240055e-03f, 7.31821582e-02f, -1.36530355e-01f, -1.15561619e-01f, -1.82766259e-01f, 2.15519052e-02f, -1.64423995e-02f, -5.67928739e-02f, 9.09709185e-02f, 1.62336916e-01f,
  1.32654592e-01f, 1.68721974e-01f, 7.23472685e-02f, 1.07468992e-01f, 1.35980740e-01f, 4.26541641e-02f, -8.68273005e-02f, 4.34060767e-02f, 1.13984577e-01f, -3.29570100e-02f,
  -3.46605387e-03f, 3.94261256e-02f, 1.08302243e-01f, 2.34017707e-02f, 2.00496688e-02f, 1.65843800e-01f, -2.16235891e-02f, -6.90501481e-02f, 1.60798226e-02f, -1.70513224e-02f,
  2.61578709e-02f, -8.53928458e-03f, -4.82393894e-03f, 2.69135721e-02f, 3.34459431e-02f, 5.85795045e-02f, 7.22211823e-02f, 1.54853798e-03f, 6.68205023e-02f, 8.18406045e-02f,
  5.44580668e-02f, 1.67619899e-01f, 1.16059639e-01f, 8.79530534e-02f, 4.31225896e-02f, 1.38851507e-02f, 1.29593397e-02f, 1.09049767e-01f, 6.77808821e-02f, 4.00083065e-02f,
  -4.11819577e-01f, 1.35866553e-01f, 7.96164274e-02f, 8.77720118e-02f, 2.18708441e-02f, -1.16428975e-02f, -2.37139538e-02f, 9.23910458e-03f, -4.08685580e-02f, -3.86255942e-02f,
  1.13999575e-01f, -4.40618880e-02f, -4.11308706e-02f, -1.58743393e-02f, -6.55151233e-02f, 6.84548542e-02f, 4.03724872e-02f, 3.75742130e-02f, 1.10418521e-01f, 1.50741160e-01f,
  1.92995727e-01f, 1.66203082e-01f, 1.06325515e-01f, 7.53208101e-02f, 6.88880756e-02f, 1.26302108e-01f, -5.00775836e-02f, 1.53023958e-01f, 1.20995343e-01f, 6.55519078e-03f,
  5.11755288e-01f, 9.50422734e-02f, 2.54683057e-03f, 1.10963821e-01f, 2.75537431e-01f, 2.59577900e-01f, 3.91302079e-01f, 2.78960317e-01f, 2.32057706e-01f, 1.04819953e-01f,
  1.03512369e-01f, -1.24640353e-01f, -1.31835267e-01f, -1.26409933e-01f, 7.89971203e-02f, 1.72368094e-01f, 9.67518166e-02f, -1.28637729e-02f, -2.95035876e-02f, 6.77390173e-02f,
  5.25243655e-02f, 9.46089029e-02f, 9.84910652e-02f, -4.48107235e-02f, -5.91747463e-02f, -2.72474010e-02f, -2.25970969e-02f, 6.33533746e-02f, 2.72895787e-02f, -1.70647055e-01f,
  -4.49713618e-01f, 4.17665914e-02f, -2.10165735e-02f, -1.54664600e-02f, -8.59255567e-02f, -1.07548669e-01f, -3.40115093e-02f, -1.64978370e-01f, 4.55225110e-02f, 6.34046569e-02f,
  -8.13540965e-02f, -6.09722175e-02f, -4.55960818e-02f, -1.15864731e-01f, -6.46321177e-02f, -1.43369392e-01f, 1.32048246e-03f, -7.42955878e-02f, -1.44158036e-01f, -5.88432178e-02f,
  -9.88881290e-02f, 5.92006668e-02f, 1.48533478e-01f, 8.23635608e-02f, -2.99958941e-02f, -7.80382613e-03f, -7.31170475e-02f, 3.73092555e-02f, 6.23618178e-02f, 4.04192992e-02f,
  -1.86940581e-01f, 4.43433635e-02f, -1.56019539e-01f, -1.03981815e-01f, 3.16874720e-02f, -3.83639336e-02f, -4.80495691e-02f, 1.42294765e-01f, 9.57581177e-02f, 1.53391644e-01f,
  3.00386641e-02f, 1.29147675e-02f, -1.20689295e-01f, 7.68805668e-02f, -6.17136583e-02f, -1.73506305e-01f, -5.05375229e-02f, -1.01208217e-01f, -1.16887175e-01f, -1.13170438e-01f,
  7.93242007e-02f, -5.08286469e-02f, -7.60925263e-02f, -1.20509766e-01f, -4.36020419e-02f, -1.77088790e-02f, -8.28625709e-02f, -8.45300965e-03f, 7.94570595e-02f, 1.43910632e-01f,
  -3.05063009e-01f, -9.32121575e-02f, -9.67469290e-02f, -1.40869081e-01f, -1.08346075e-01f, -1.51024476e-01f, -2.36733891e-02f, -2.05913514e-01f, -7.89242610e-02f, 5.40536596e-03f,
  -2.30441205e-02f, -5.72655909e-02f, -5.26119359e-02f, 5.33501506e-02f, 1.37228489e-01f, 4.03467827e-02f, 2.89998669e-02f, -8.95463582e-03f, -3.11905276e-02f, -6.65436089e-02f,
  8.80876333e-02f, 2.29031235e-01f, 9.73851830e-02f, 1.86711341e-01f, 1.83556706e-01f, 1.18541151e-01f, -2.04395968e-02f, -1.18285818e-02f, 1.16994031e-01f, 1.30391955e-01f,
  -4.16028529e-01f, 3.70414674e-01f, 3.18103880e-01f, -5.32033563e-01f, 6.67536631e-02f, 3.02589148e-01f, 3.29242319e-01f, 9.59910750e-02f, -2.38088220e-01f, 9.08844993e-02f,
  2.01822206e-01f, -3.66496623e-01f, -2.50377357e-01f, -2.77855515e-01f, -1.25582725e-01f, 1.40409544e-01f, -1.08436830e-01f, -3.53698403e-01f, -2.27901906e-01f, -1.30936399e-01f,
  -3.11328143e-01f, -3.52839768e-01f, -2.62921244e-01f, -3.08119386e-01f, -2.51536429e-01f, -3.83080035e-01f, 3.40920240e-02f, -5.16070798e-02f, 1.74845666e-01f, -2.07936287e-01f,
  2.79009670e-01f, 2.77442575e-01f, -1.82655111e-01f, -2.84860581e-01f, 4.63658432e-03f, -1.46378189e-01f, 1.42898038e-02f, 1.63084641e-02f, -1.27457187e-03f, 1.22260928e-01f,
  2.00847276e-02f, 1.90239977e-02f, 2.67854631e-02f, 1.08386084e-01f, 2.83740181e-03f, 8.49431846e-03f, -2.12565158e-02f, -3.15953395e-04f, 7.25402161e-02f, 2.65569478e-01f,
  9.66199860e-02f, 2.16015577e-01f, 2.08190680e-01f, 7.09912106e-02f, 5.74581400e-02f, -1.60547778e-01f, 2.15608165e-01f, 6.32093102e-02f, 1.91305265e-01f, -1.29881978e-01f,
  -7.27707446e-02f, -4.78906110e-02f, 2.73598526e-02f, 6.39237389e-02f, 2.44873278e-02f, 6.53625727e-02f, 2.52813697e-02f, 6.98952423e-03f, 1.69501454e-02f, 3.12068854e-02f,
  1.05106317e-01f, 2.77859092e-01f, 8.04438293e-02f, 5.68678156e-02f, 7.74372071e-02f, 8.32192600e-02f, 1.65715292e-01f, 5.70615567e-02f, 1.52850047e-01f, 1.50126055e-01f,
  5.91958798e-02f, 1.02677815e-01f, 8.06469694e-02f, 1.35773152e-01f, 2.56533265e-01f, 1.39082819e-01f, 1.30993515e-01f, 1.22770078e-01f, 9.36736912e-02f, 1.66244403e-01f,
  -1.60888821e-01f, 1.56984508e-01f, -2.19999224e-01f, -1.40326589e-01f, -7.43714198e-02f, -7.02930568e-03f, -3.08102015e-02f, -2.51562032e-03f, -3.35188471e-02f, 1.71205737e-02f,
  1.80098519e-01f, -9.03539658e-02f, 6.06337935e-02f, -1.55519256e-02f, 4.50197654e-03f, -1.12041440e-02f, -3.23958397e-02f, -1.49018437e-01f, -7.03966767e-02f, -5.31342067e-03f,
  -2.91402135e-02f, -9.39768106e-02f, -1.50967374e-01f, -1.72935888e-01f, 1.71767361e-02f, -2.20746443e-01f, -9.16907340e-02f, -6.71049282e-02f, -5.87375872e-02f, -3.02200645e-01f,
  2.86288589e-01f, -2.37302884e-01f, 3.46498400e-01f, 1.75101712e-01f, 7.11362436e-02f, 2.68729985e-01f, 1.43607989e-01f, 1.98440909e-01f, 8.37415978e-02f, -2.06319746e-02f,
  -1.47500440e-01f, -2.24408865e-01f, -1.38700426e-01f, -1.09974965e-01f, 4.66846526e-02f, 1.03274040e-01f, 1.22349672e-01f, 1.73208192e-01f, 1.81367993e-01f, 8.55208468e-03f,
  -6.37592375e-02f, 1.17163705e-02f, 1.62770540e-01f, 1.47143438e-01f, 6.37141839e-02f, 3.83292362e-02f, -4.10332419e-02f, -3.88882756e-02f, -3.11745498e-02f, 6.71357736e-02f,
  -6.51822314e-02f, -6.36131391e-02f, -1.63613454e-01f, -2.51057446e-01f, -1.10011153e-01f, -1.03842877e-01f, -2.54110135e-02f, -1.68745331e-02f, 2.31860913e-02f, -8.39808807e-02f,
  -1.05022468e-01f, -1.30785808e-01f, -4.57381755e-02f, 5.66212051e-02f, 4.63741533e-02f, -1.20128058e-02f, 1.47307022e-02f, 1.22734770e-01f, 4.18267027e-02f, -6.28498942e-02f,
  -5.42136915e-02f, 9.01918684e-04f, 1.78279340e-01f, 5.60944118e-02f, 6.87546581e-02f, 3.33849783e-03f, -1.98520739e-02f, 4.63206619e-02f, -2.59749126e-02f, -5.69126718e-02f,
  -1.19557150e-01f, -3.51816267e-02f, -4.10596095e-02f, 1.07452273e-01f, -1.35071436e-03f, 1.07657574e-01f, 8.20334256e-02f, 4.89209965e-02f, 2.09696472e-01f, 2.32708365e-01f,
  1.52002066e-01f, 1.29199460e-01f, 1.63911715e-01f, 3.89728788e-03f, 2.79627219e-02f, 3.48848365e-02f, 1.16713665e-01f, 6.86122552e-02f, 8.31639990e-02f, 9.79239121e-02f,
  1.41218707e-01f, 1.12739861e-01f, 5.25384881e-02f, 1.15954787e-01f, -1.52158095e-02f, 7.95207545e-02f, 1.63367867e-01f, -2.58436184e-02f, 6.41233176e-02f, 1.22284763e-01f,
  -2.71394521e-01f, 1.78473536e-03f, -2.29250304e-02f, -1.06188834e-01f, -2.63489373e-02f, 3.07136979e-02f, -3.55404714e-04f, -1.79323897e-01f, -1.37162447e-01f, 5.02087325e-02f,
  -8.65577534e-02f, 8.11968744e-03f, 9.52310041e-02f, 1.43597856e-01f, 1.21868737e-01f, 1.20748907e-01f, -4.81051467e-02f, -2.26591527e-02f, 1.24057161e-03f, -1.51897501e-02f,
  -1.26962051e-01f, 1.24013565e-01f, 8.37203413e-02f, 9.70955044e-02f, -5.45401052e-02f, -2.84988359e-02f, 9.76149291e-02f, 5.72432540e-02f, -1.65901799e-02f, 6.98786527e-02f,
  -5.46230018e-01f, 3.08030635e-01f, 1.50107279e-01f, -7.73597717e-01f, -3.10112059e-01f, 3.93433757e-02f, 3.80592465e-01f, -1.26714513e-01f, -4.85340953e-01f, 8.09723958e-02f,
  1.69471234e-01f, -9.78441238e-02f, -1.06583849e-01f, 1.08185008e-01f, 3.67118269e-01f, 3.80997270e-01f, 9.98640358e-02f, -9.80446208e-03f, 1.10268049e-01f, 2.33271401e-02f,
  1.28884912e-01f, -3.07039946e-01f, -2.14959934e-01f, -1.96914971e-01f, -2.88631380e-01f, -1.25032410e-01f, -5.35949506e-02f, -1.04607284e-01f, 2.66465843e-01f, -1.30555883e-01f,
  4.57428783e-01f, -2.41101518e-01f, -5.44331735e-03f, -1.66422740e-01f, -7.60503709e-02f, -6.47215173e-02f, -8.65682494e-03f, -2.31010571e-01f, 4.14161710e-03f, -2.42545009e-02f,
  -2.71267533e-01f, -1.29592046e-01f, -2.08333001e-01f, -4.63795429e-03f, -2.17632100e-01f, -4.06714566e-02f, -9.02187154e-02f, -8.45011473e-02f, -2.20744628e-02f, 1.81756422e-01f,
  1.68658152e-01f, 1.49927270e-02f, 5.96810021e-02f, 1.93191499e-01f, 9.45297629e-02f, -4.79097851e-02f, 2.03247815e-01f, -4.39098738e-02f, 7.02593327e-02f, 1.13219181e-02f,
  2.81989761e-02f, 5.12856580e-02f, -4.35077958e-02f, -5.90451546e-02f, 1.91857032e-02f, -9.93346572e-02f, -1.39593899e-01f, 8.68528560e-02f, -1.41526163e-02f, 2.34140735e-02f,
  -8.34217891e-02f, 8.65803212e-02f, 1.36077944e-02f, -6.71370849e-02f, -1.34306746e-02f, -7.19595328e-02f, 8.37722793e-02f, 4.27511372e-02f, 2.62707788e-02f, -5.57116531e-02f,
  -5.99892698e-02f, -1.19487517e-01f, -1.11133061e-01f, 7.22612590e-02f, 2.10705295e-01f, -2.08148416e-02f, -6.89836144e-02f, 1.67282537e-01f, -8.04049149e-02f, 3.80640514e-02f,
  -2.00475097e-01f, 2.40265682e-01f, 2.01327559e-02f, -4.47279587e-02f, -1.34238049e-01f, -1.04590049e-02f, -1.09962732e-01f, -2.14406699e-02f, -1.42000079e-01f, 3.58587801e-02f,
  1.26846060e-02f, 2.64296718e-02f, -1.66629963e-02f, -3.41540873e-02f, 2.12167315e-02f, -1.34457991e-01f, 7.36996010e-02f, -1.71867274e-02f, 5.49707338e-02f, 3.83323357e-02f,
  -8.17680173e-03f, 1.52780116e-02f, 1.11217879e-01f, 4.52047810e-02f, -2.13167854e-02f, -5.83952852e-02f, 1.89942673e-01f, 1.49693698e-01f, 1.81564108e-01f, 6.18548431e-02f,
  4.94907171e-01f, -6.59425080e-01f, -9.48797241e-02f, -1.19101211e-01f, 8.98416340e-02f, 5.49302064e-02f, -3.03186536e-01f, 4.25557373e-03f, 1.28763914e-01f, -2.27870598e-01f,
  -7.13602751e-02f, 2.30914235e-01f, 2.39032626e-01f, 1.37852624e-01f, 1.08783714e-01f, -4.00231957e-01f, -1.63213000e-01f, 3.98751885e-01f, 5.93306899e-01f, 2.36504257e-01f,
  -1.65627082e-03f, -2.91905850e-02f, 1.74374476e-01f, 1.53586427e-02f, -2.31684789e-01f, 6.79110736e-02f, -3.07445407e-01f, -1.41987979e-01f, -1.40501469e-01f, -3.32393050e-01f,
  -4.85845879e-02f, -1.39280349e-01f, 1.35184005e-01f, 4.45605954e-04f, -4.94419076e-02f, -2.29296535e-02f, -2.56134123e-02f, -4.29299362e-02f, -2.06314810e-02f, -1.58121705e-01f,
  1.16899842e-02f, -1.09419310e-02f, 5.60260676e-02f, -5.10323308e-02f, -1.72306538e-01f, -2.56921742e-02f, -2.51530856e-02f, 5.86717725e-02f, -5.58118410e-02f, -9.71172303e-02f,
  -1.04957685e-01f, -2.65553202e-02f, -1.21497184e-01f, -2.56820954e-02f, -4.74877730e-02f, 2.62556314e-01f, -1.14257960e-02f, -3.86626571e-02f, -2.62074806e-02f, -2.67335624e-01f,
  1.41891055e-02f, 1.14265103e-02f, 7.73363709e-02f, 1.68460399e-01f, 5.58738187e-02f, 6.34020567e-02f, 5.81906624e-02f, 2.80740466e-02f, 1.46795049e-01f, 1.35374749e-02f,
  -5.34853041e-02f, -1.71427764e-02f, 4.80122380e-02f, -7.12273717e-02f, 2.17780489e-02f, 2.54553724e-02f, -6.38766065e-02f, -6.49868399e-02f, 9.27409232e-02f, 1.17844000e-01f,
  1.08624853e-01f, 1.01282440e-01f, 7.37932771e-02f, 1.03986941e-01f, -3.19570526e-02f, 1.27032071e-01f, 1.03383407e-01f, 1.78926103e-02f, 2.81514730e-02f, 4.63921484e-03f,
  -2.57164419e-01f, 3.81062359e-01f, -6.18520603e-02f, 4.78538796e-02f, -8.93196166e-02f, -3.83756012e-02f, 1.11456700e-01f, 5.54034039e-02f, 8.56995061e-02f, 4.95525859e-02f,
  -4.55209501e-02f, 2.69769356e-02f, -3.56975086e-02f, -5.65428771e-02f, 4.57851924e-02f, 2.12580524e-02f, 3.02473325e-02f, 1.26766518e-01f, 9.70494524e-02f, -4.82876152e-02f,
  -1.56891227e-01f, -8.55811872e-03f, 8.79807249e-02f, -1.10819824e-02f, -4.94179223e-03f, 3.21388662e-01f, 1.11858854e-02f, 3.25382389e-02f, 1.64793372e-01f, -1.87771499e-01f,
  6.45225763e-01f, 3.57966781e-01f, 3.50981414e-01f, 2.94989824e-01f, 1.74749404e-01f, 2.34356821e-01f, 2.96697587e-01f, 1.25213876e-01f, 1.30563602e-01f, 1.76769853e-01f,
  7.79431686e-02f, -2.22038236e-02f, 2.60338951e-02f, 3.89699377e-02f, 6.00010380e-02f, 1.94211543e-01f, 6.22231252e-02f, 1.11046350e-02f, -1.41131394e-02f, 1.63001880e-01f,
  1.72204934e-02f, 9.83404666e-02f, 1.85927991e-02f, -6.00258522e-02f, 2.84919441e-02f, -1.09158672e-01f, 4.51969057e-02f, 9.81226489e-02f, 2.05364361e-01f, 2.47251950e-02f,
  2.92093810e-02f, 2.82932907e-01f, -1.38229713e-01f, -1.22147046e-01f, -3.11510656e-02f, -1.85207948e-02f, -7.32898191e-02f, -1.79106459e-01f, -7.17516392e-02f, -3.77862006e-02f,
  -9.18064266e-02f, -2.73288880e-02f, -5.04179969e-02f, -1.02564275e-01f, -7.47966468e-02f, -6.72102794e-02f, -1.13579944e-01f, -1.09971926e-01f, -1.54368401e-01f, 1.60990302e-02f,
  -9.44284201e-02f, 9.71446708e-02f, 5.28513230e-02f, -9.19546187e-02f, 2.63140704e-02f, -1.56967729e-01f, -8.46848171e-03f, -7.78954774e-02f, -9.36749503e-02f, 1.68715356e-04f,
  -2.42632240e-01f, 1.19638415e-02f, 3.58432829e-02f, 3.60141248e-02f, 8.26684535e-02f, -9.85580403e-03f, -5.87233901e-02f, -2.13016644e-02f, 6.19085692e-02f, -1.21794142e-01f,
  -1.28153890e-01f, -5.73083349e-02f, 3.40676941e-02f, -3.76251638e-02f, -2.14953423e-02f, 5.89789525e-02f, 4.67063673e-02f, -4.97427508e-02f, -7.42633492e-02f, -4.25560772e-02f,
  -3.88501532e-04f, -1.21998779e-01f, -1.75737783e-01f, -1.54951036e-01f, -2.10799843e-01f, -5.21878116e-02f, 1.34407301e-02f, -1.70432672e-01f, -1.88430533e-01f, -1.60173550e-01f,
  -2.75564134e-01f, 4.90106195e-02f, -5.11690825e-02f, -1.47547305e-01f, 1.79034576e-03f, -1.04909688e-01f, 1.46219237e-02f, -2.89400686e-02f, -3.43438145e-03f, 4.67954297e-03f,
  4.09396552e-02f, 7.15459734e-02f, -4.57931496e-02f, -8.29533264e-02f, -1.23477139e-01f, -6.54172897e-02f, -1.85767170e-02f, -1.14464648e-01f, -7.32758045e-02f, -1.59165695e-01f,
  -1.49864584e-01f, -7.47469142e-02f, 7.83516541e-02f, -3.54889892e-02f, 2.52720378e-02f, -1.30368069e-01f, -5.68780825e-02f, -1.37978926e-01f, 1.62548348e-02f, -1.43579617e-02f,
  6.15043879e-01f, -4.89346206e-01f, -1.49507448e-01f, 3.26017626e-02f, -1.98721707e-01f, -1.95347592e-01f, -4.75014478e-01f, -5.51238060e-02f, 1.65411770e-01f, -2.41323590e-01f,
  2.33215228e-01f, 6.41941667e-01f, 4.16398674e-01f, 3.26391429e-01f, 3.81586134e-01f, -3.17377388e-01f, -2.63612479e-01f, 1.87532395e-01f, 3.26847166e-01f, 6.09648302e-02f,
  -1.15485713e-01f, -1.03368320e-01f, 2.00503930e-01f, 3.16768773e-02f, -4.80375588e-01f, -2.87975825e-04f, -3.97415727e-01f, -2.41852745e-01f, -1.86728761e-01f, -4.75734890e-01f,
  -1.48618110e-02f, -7.09196255e-02f, 1.34994239e-01f, 2.03888059e-01f, -4.18095142e-02f, -1.06008109e-02f, -1.22434095e-01f, -1.64650470e-01f, -5.72448932e-02f, -1.43167824e-01f,
  -3.81263671e-03f, 2.60379333e-02f, -7.18499999e-03f, -1.27792209e-01f, -2.39586458e-01f, 1.64927728e-02f, -1.61651179e-01f, -1.55021355e-03f, 1.69599503e-02f, -1.45545378e-01f,
  -2.36093938e-01f, -1.32071123e-01f, -9.73921344e-02f, -2.45222732e-01f, -1.79609686e-01f, 1.09235644e-01f, -3.62939209e-01f, -2.33186170e-01f, -1.03339225e-01f, -5.04620850e-01f,
  -3.95431407e-02f, 7.24257380e-02f, 3.29315127e-03f, -1.35222390e-01f, -4.66675982e-02f, 5.77103384e-02f, -3.03956103e-02f, -1.96216926e-02f, 4.70529124e-02f, -9.57636908e-02f,
  5.12320735e-02f, 1.07562512e-01f, 7.49034956e-02f, -7.97784775e-02f, -4.61901538e-02f, -9.61635783e-02f, -5.28117530e-02f, 1.63797773e-02f, 5.71165467e-03f, 3.26784290e-02f,
  6.75398558e-02f, -7.39366561e-02f, 2.50365641e-02f, 3.07814553e-02f, 1.04549371e-01f, 9.72186625e-02f, 9.14284028e-03f, 7.21546412e-02f, 1.68056451e-02f, -8.01861584e-02f,
  1.38239786e-01f, 2.90295660e-01f, -5.84733998e-03f, 8.96773934e-02f, 1.37019884e-02f, 4.52812165e-02f, 2.60294862e-02f, -3.75589617e-02f, 4.51461561e-02f, 1.84350125e-02f,
  -3.78703699e-02f, 7.84037858e-02f, -7.08579570e-02f, -5.63153736e-02f, -1.15615549e-02f, 2.60887458e-03f, 4.43226285e-02f, 1.13955021e-01f, -1.20990798e-02f, -2.02288345e-01f,
  -1.51509821e-01f, 4.84225452e-02f, 3.91981751e-02f, -7.68158659e-02f, -1.11426823e-01f, 1.49376109e-01f, -1.79844618e-01f, -1.75196782e-01f, 1.59236506e-01f, -3.88169914e-01f,
  -1.69703975e-01f, -3.93907160e-01f, 4.01441425e-01f, -2.46355489e-01f, -2.12722301e-01f, -6.67669848e-02f, -2.71909893e-01f, -2.55437672e-01f, -1.47002339e-01f, -2.01391280e-01f,
  -3.00996035e-01f, -1.26220554e-01f, -8.29791874e-02f, 4.99787070e-02f, -7.54895806e-02f, 9.12537798e-02f, 9.32451338e-02f, 1.88562289e-01f, 2.64369845e-01f, -1.41165122e-01f,
  -5.47152162e-02f, -4.08360772e-02f, -1.79158300e-02f, -3.76717479e-04f, -2.10831791e-01f, -1.38534129e-01f, 2.03855131e-02f, -1.46785863e-02f, -1.48613870e-01f, -1.64389193e-01f,
  9.42795500e-02f, -3.32081765e-01f, -3.13555077e-02f, -1.25689775e-01f, -1.90388840e-02f, -9.69313160e-02f, -5.77833690e-02f, 5.81065379e-02f, -1.68810427e-01f, 4.35435139e-02f,
  -2.24423688e-02f, -2.85926703e-02f, -3.16701569e-02f, 2.76361573e-02f, 2.60824338e-02f, -3.26426560e-03f, -3.79149616e-02f, -1.83554858e-01f, -1.54008495e-03f, -5.84928654e-02f,
  -1.12933926e-01f, -7.81354010e-02f, -9.83505100e-02f, -7.15677366e-02f, -1.58157408e-01f, -3.67392600e-02f, -4.15055193e-02f, -5.85092828e-02f, -3.14700529e-02f, -5.91182224e-02f,
  2.67192245e-01f, -1.44176011e-03f, -3.41106462e-03f, -5.61894290e-02f, -3.01885121e-02f, -9.78721902e-02f, -2.77986564e-02f, -1.42143434e-03f, -1.05203576e-02f, -6.69817701e-02f,
  -1.34017304e-01f, -1.16959989e-01f, -1.02720059e-01f, -1.97653193e-02f, -9.36554670e-02f, -1.14118559e-02f, -7.93488994e-02f, -4.33704816e-02f, 6.22635931e-02f, -1.16910674e-01f,
  -1.80941179e-01f, -5.83567880e-02f, -3.62568535e-02f, -9.75141972e-02f, -6.20536953e-02f, -6.12860508e-02f, 1.02777332e-02f, -4.29185778e-02f, 3.96725629e-03f, -1.74277857e-01f,
  -8.97001326e-02f, 8.65234211e-02f, -4.71313484e-02f, -9.04349834e-02f, 2.93127038e-02f, 6.81403354e-02f, -1.16928387e-02f, 1.29695430e-01f, -5.14383912e-02f, 6.64237738e-02f,
  -2.05934085e-02f, 1.21930353e-01f, 1.54903889e-01f, 1.63746474e-03f, -3.49354930e-03f, 9.42004323e-02f, -1.02207117e-01f, -9.48656648e-02f, 4.58906665e-02f, -6.45897985e-02f,
  8.26403275e-02f, 5.14945053e-02f, 2.35922530e-01f, 1.08575068e-01f, -2.70158593e-02f, 2.43839309e-01f, 1.08208612e-01f, 1.44894607e-02f, 2.05778062e-01f, 8.48758891e-02f,
  1.54196650e-01f, -1.22018777e-01f, 9.80527923e-02f, 1.10271767e-01f, 3.91554646e-02f, 6.11933060e-02f, 1.88121110e-01f, -1.18598705e-02f, 5.78775033e-02f, 8.97328481e-02f,
  -6.27645329e-02f, -1.31266311e-01f, -2.14631617e-01f, -1.10566042e-01f, -7.53519386e-02f, 2.16417134e-01f, 1.59190819e-01f, 6.21946566e-02f, 2.14908030e-02f, -7.72771612e-02f,
  9.19594523e-03f, -1.38956858e-02f, -4.84821163e-02f, -1.33748874e-01f, -4.43089157e-02f, 2.60164868e-03f, 3.90540175e-02f, -5.37809357e-02f, -7.65563920e-02f, 7.75615275e-02f,
  1.74948648e-01f, -1.58960387e-01f, -2.08767373e-02f, -2.69643277e-01f, -1.68768018e-02f, 2.53771599e-02f, 6.13500215e-02f, -6.09050542e-02f, 1.94578953e-02f, 1.01099931e-01f,
  -2.60173832e-03f, -1.98256038e-02f, -2.11216789e-03f, -7.01152720e-03f, -2.47414913e-02f, -2.37292144e-02f, -1.76723868e-01f, -6.30835742e-02f, -1.37570620e-01f, -1.10472724e-01f,
  -1.37888134e-01f, -1.37582319e-02f, 4.92526740e-02f, -6.20249324e-02f, -5.94407655e-02f, -9.95816812e-02f, 2.47157626e-02f, -1.13723002e-01f, -9.46765766e-02f, 1.33313432e-01f,
  4.07091342e-02f, 1.66751910e-02f, 3.83601896e-02f, 1.31499290e-01f, 1.54103702e-02f, 2.85151489e-02f, 1.43930510e-01f, 1.06304169e-01f, 1.87203869e-01f, 1.66061983e-01f,
  1.48875013e-01f, 1.57858193e-01f, 1.97855219e-01f, 3.27164084e-01f, 3.17646898e-02f, 1.64112538e-01f, 1.55333921e-01f, 1.95625097e-01f, 2.91340034e-02f, 1.07539870e-01f,
  1.43760964e-01f, 1.72720775e-02f, 1.56648517e-01f, 4.82030325e-02f, 3.51682156e-02f, 1.46595791e-01f, 2.48878255e-01f, 1.14992917e-01f, 1.21324137e-01f, 1.36440888e-01f,
  2.05932856e-01f, -1.66876361e-01f, 1.59769520e-01f, -7.05244690e-02f, 1.06996737e-01f, -7.75686800e-02f, -2.99337003e-02f, -4.20454182e-02f, 1.73214320e-02f, 6.16140179e-02f,
  5.78027144e-02f, 6.18429184e-02f, 6.67585433e-02f, 4.17198725e-02f, 1.95745245e-01f, 1.58635378e-01f, -8.87500960e-03f, -2.61243545e-02f, -1.55193329e-01f, -1.26116918e-02f,
  -4.96043600e-02f, 3.79095264e-02f, 2.27856234e-01f, 7.33749568e-02f, -4.09141257e-02f, 1.08865373e-01f, 5.29673025e-02f, -1.18212507e-03f, 1.43853873e-01f, 3.12591553e-01f,
  -5.80574751e-01f, -1.51276216e-01f, 1.77766964e-01f, -9.69125554e-02f, 1.65451348e-01f, -4.29024063e-02f, -2.14019194e-01f, -1.11208044e-01f, 1.03701480e-01f, -3.10920905e-02f,
  -3.38182636e-02f, 9.61600021e-02f, 1.96186244e-01f, 5.29665016e-02f, -9.21069831e-02f, 1.38693511e-01f, 3.16622376e-01f, 7.82758668e-02f, -1.06087066e-01f, -2.28622794e-01f,
  6.73299655e-03f, -1.40765473e-01f, -2.27926329e-01f, 1.50801800e-02f, 4.91821393e-02f, 8.08221698e-02f, 2.03976318e-01f, 3.99013609e-02f, 8.26753750e-02f, 2.32962579e-01f,
  -2.16115996e-01f, -2.33974874e-01f, 6.77115023e-02f, 3.14624384e-02f, 1.38081431e-01f, -5.83371520e-02f, -1.43702462e-01f, -9.80445147e-02f, 1.71065573e-02f, -3.16568241e-02f,
  -4.28039171e-02f, -1.17795803e-02f, 1.00493059e-01f, -2.89213122e-03f, -6.70114830e-02f, -1.24279760e-01f, -1.46444878e-02f, -7.17960224e-02f, -4.98965494e-02f, -6.35830760e-02f,
  2.37314060e-01f, -3.25372964e-02f, -7.56122023e-02f, 1.42384721e-02f, -5.88828549e-02f, 2.26028841e-02f, -1.26587465e-01f, -1.09577700e-01f, -1.94506869e-01f, -2.29133114e-01f,
  6.52426705e-02f, 1.02573037e-02f, -2.85630077e-02f, -6.92090532e-03f, 1.28340766e-01f, 5.80010898e-02f, 7.21396059e-02f, 4.97883512e-03f, 6.15608096e-02f, -1.74944457e-02f,
  3.50662954e-02f, -9.07437131e-03f, 1.06391739e-02f, -6.78673312e-02f, -1.87772736e-02f, -8.62280577e-02f, -6.44003078e-02f, -2.48419251e-02f, 5.78850359e-02f, -3.74163911e-02f,
  -3.50626558e-02f, 6.53206883e-03f, 3.98483835e-02f, 2.09351517e-02f, -1.49828102e-02f, -1.49742588e-02f, -1.29934642e-02f, -1.09456547e-01f, -1.10080607e-01f, -1.27829731e-01f,
  -1.29124597e-01f, 1.65680960e-01f, -1.57241583e-01f, 1.47803649e-02f, 4.00377810e-02f, 1.76106721e-01f, -3.90078947e-02f, 2.05916986e-02f, 1.95279401e-02f, -9.24607739e-02f,
  -1.88413158e-01f, -2.18930677e-01f, -4.51584980e-02f, 3.81476395e-02f, -4.16347943e-02f, -6.07252270e-02f, -7.77362892e-03f, -4.15321775e-02f, -1.26140304e-02f, 1.19235925e-03f,
  1.81288779e-01f, -1.99581698e-01f, -2.87932098e-01f, -1.43284857e-01f, -8.86993632e-02f, -2.84043700e-01f, -1.96623549e-01f, -1.02244429e-01f, -2.79868126e-01f, -3.93415481e-01f,
  6.18907094e-01f, 3.00099760e-01f, 5.75229004e-02f, 1.76910266e-01f, 2.98380405e-01f, 1.57683238e-01f, 9.94194075e-02f, 3.40521224e-02f, 7.87793323e-02f, 1.37444615e-01f,
  2.61732548e-01f, 2.23932296e-01f, 1.56214505e-01f, -6.40056953e-02f, -4.56922278e-02f, -1.23157375e-01f, -1.31243572e-01f, -1.50159538e-01f, -1.13367885e-01f, 4.72517163e-02f,
  -1.35667231e-02f, 7.71682039e-02f, 1.76065359e-02f, -4.47715484e-02f, -6.11724369e-02f, 3.36272120e-02f, 1.21507728e-02f, 1.12237155e-01f, 7.90750980e-02f, -1.35265812e-01f,
  -1.48186553e-02f, 1.68264464e-01f, -1.08677052e-01f, 4.04831283e-02f, 5.38341440e-02f, -7.76533410e-02f, -7.23888800e-02f, -4.71023507e-02f, -2.98362151e-02f, -1.16850272e-01f,
  -1.28442943e-01f, -5.42353578e-02f, -4.00390103e-02f, -5.80557510e-02f, -5.32702953e-02f, -1.84683412e-01f, -1.49217322e-01f, -1.27367154e-01f, -3.92862074e-02f, 1.21387495e-02f,
  3.47792730e-02f, 4.38610464e-02f, -4.99659143e-02f, -5.07602356e-02f, -7.51106665e-02f, -1.09057799e-02f, 3.72686908e-02f, 3.96258757e-02f, -7.18545839e-02f, -7.10888878e-02f,
  1.15630835e-01f, 1.55560747e-01f, 2.06273749e-01f, 4.88625243e-02f, 1.42547801e-01f, 5.94788045e-02f, 6.42411411e-02f, 9.19640660e-02f, -4.73983958e-02f, -3.34304683e-02f,
  -7.84379244e-02f, -3.26776244e-02f, 7.51045421e-02f, 9.66084525e-02f, 9.97606963e-02f, 1.66784734e-01f, -4.45354059e-02f, 1.64207723e-02f, 7.56879756e-03f, -4.75872401e-03f,
  -2.25318223e-02f, -1.20479174e-01f, 1.02166375e-02f, -5.42895682e-02f, 1.47658056e-02f, -1.76444575e-02f, 2.81402357e-02f, -2.72535942e-02f, 1.39909819e-01f, -6.62054196e-02f,
  -3.90192628e-01f, 1.38424501e-01f, -1.36227444e-01f, -2.07452536e-01f, -1.88845191e-02f, -4.88827489e-02f, 1.12784952e-01f, -2.24103630e-02f, -1.13240503e-01f, -7.08504617e-02f,
  -9.94266123e-02f, -1.57150719e-02f, 5.83507977e-02f, -3.02531254e-02f, -2.00032651e-01f, -1.05977014e-01f, -1.13480128e-02f, -1.39439449e-01f, -5.41761816e-02f, -1.44313633e-01f,
  -1.45218045e-01f, -1.26746550e-01f, -9.58897993e-02f, -1.09904204e-02f, -6.24227785e-02f, -1.09723590e-01f, -1.65138826e-01f, -1.45029992e-01f, 1.71734579e-02f, -4.57714610e-02f,
  2.82150656e-01f, 3.01734656e-01f, -7.28236794e-01f, 2.68348962e-01f, -1.56185180e-01f, -3.27998042e-01f, -7.80065134e-02f, -6.53639343e-03f, 1.73248202e-01f, 1.56068087e-01f,
  -4.79417257e-02f, -1.12267490e-03f, 4.63281125e-02f, -8.25174376e-02f, -1.34175897e-01f, -1.12797812e-01f, -2.12235212e-01f, -4.22922939e-01f, -2.56897300e-01f, 2.31061298e-02f,
  2.88670868e-01f, 3.63244891e-01f, 1.70032829e-01f, 4.53757234e-02f, 1.23643465e-01f, 2.31101587e-02f, -8.37683082e-02f, -3.81734557e-02f, -1.40992820e-01f, -1.67805105e-01f,
  -1.11386836e-01f, -2.91525602e-01f, -2.06390768e-01f, -1.22288233e-02f, -7.83681497e-02f, 4.32651676e-03f, -5.84238991e-02f, -1.04124852e-01f, -1.82594471e-02f, -2.39351001e-02f,
  5.98201947e-03f, -7.69671947e-02f, -3.79773900e-02f, 8.50957334e-02f, 1.07197680e-01f, -1.44703602e-02f, -3.30183543e-02f, -2.32041195e-01f, -1.42477840e-01f, -1.02572404e-01f,
  6.58452734e-02f, -2.61072040e-01f, -3.34559828e-01f, -2.02527210e-01f, -2.65913218e-01f, -2.12956011e-01f, -9.58928317e-02f, -2.24550888e-01f, -3.12716842e-01f, 8.31367821e-02f,
  6.73184125e-03f, 1.74418967e-02f, 7.17643797e-02f, 7.58271590e-02f, 1.20086208e-01f, -2.03682706e-02f, -1.92817505e-02f, 3.08489464e-02f, 7.83855245e-02f, 4.09115776e-02f,
  -6.28524348e-02f, 5.73097654e-02f, -3.28165591e-02f, -7.52772465e-02f, 8.48559737e-02f, -8.52072611e-02f, -1.03189804e-01f, 1.53389469e-01f, -7.07913935e-02f, 3.93723845e-02f,
  1.43566690e-02f, -4.40193117e-02f, 8.11220482e-02f, 5.80428652e-02f, -1.50667295e-01f, -3.85722220e-02f, 5.86272478e-02f, 4.13241647e-02f, 4.39813621e-02f, -1.98409632e-02f,
  5.42985916e-01f, -1.79995745e-01f, 1.45995200e-01f, -7.19979703e-02f, -7.45390356e-02f, -6.81722760e-02f, 6.52169883e-02f, -5.60657494e-02f, 9.89439245e-03f, 5.97654916e-02f,
  -8.31843838e-02f, 3.00090648e-02f, 9.28634331e-02f, 1.01657182e-01f, -6.41941419e-03f, 4.41532061e-02f, 6.78437203e-02f, -3.32406089e-02f, 3.18880752e-02f, 4.30110730e-02f,
  1.50677443e-01f, -1.20313289e-02f, 8.71571824e-02f, 8.78797546e-02f, 2.23184545e-02f, 4.38255705e-02f, 1.51032269e-01f, 5.16213626e-02f, -1.08706176e-01f, 4.85946715e-01f,
  5.83909035e-01f, 4.35027659e-01f, 2.36405283e-01f, 4.48857434e-02f, -1.13613382e-01f, 2.23096330e-02f, 2.31814876e-01f, 1.69660971e-01f, 8.28326643e-02f, 2.06165195e-01f,
  9.45568085e-02f, 4.16657934e-03f, 9.63965729e-02f, 3.62232551e-02f, 2.03184560e-01f, 1.20280571e-01f, 3.42031717e-02f, 2.16198072e-01f, 2.84427367e-02f, 1.29093334e-01f,
  -4.43736278e-02f, 4.20950092e-02f, 1.37374327e-01f, 9.05370638e-02f, 9.99750104e-03f, 2.14444604e-02f, 1.02802269e-01f, 8.57136697e-02f, 1.11146197e-01f, 9.93653387e-02f,
  -7.74036497e-02f, 1.94206342e-01f, -9.61293578e-02f, -7.15563968e-02f, -1.62025467e-01f, 3.84177417e-02f, 6.71890704e-03f, 1.73348468e-02f, 1.65876877e-02f, -5.24131581e-02f,
  -7.08934963e-02f, -7.15305507e-02f, -3.21739316e-02f, -2.69949790e-02f, -1.03737065e-03f, -7.52626583e-02f, 5.46945445e-02f, 1.35214508e-01f, -4.54885550e-02f, -4.04743738e-02f,
  -8.92295018e-02f, -6.17426783e-02f, -3.37264836e-02f, -4.82714400e-02f, 1.22657903e-01f, -7.87498727e-02f, 5.69412224e-02f, -8.70441739e-03f, 9.17916298e-02f, 1.81070715e-01f,
  1.41633889e-02f, 4.98633198e-02f, 1.14224404e-01f, 2.07253858e-01f, 8.42402428e-02f, 6.35658205e-02f, 7.60122687e-02f, 7.07467124e-02f, 4.55540344e-02f, 5.83535619e-02f,
  4.15045256e-03f, 8.93152729e-02f, 8.84849951e-02f, 1.09158652e-02f, -9.05471737e-04f, 4.47886847e-02f, -4.09439811e-03f, 2.18119193e-02f, 4.50231247e-02f, 2.58918740e-02f,
  9.85151040e-04f, -6.36897460e-02f, -4.16707844e-02f, 3.64797302e-02f, -2.13481556e-03f, 1.07908770e-01f, 6.79038912e-02f, 8.88244063e-02f, -6.64148992e-03f, 7.33358264e-02f,
  -4.00447369e-01f, -1.30647317e-01f, -7.15416968e-02f, 3.06483079e-02f, -1.21398233e-01f, -7.59005621e-02f, -7.33822808e-02f, 1.36691090e-02f, -1.24454312e-01f, 3.41774954e-04f,
  -4.88771051e-02f, -3.03027220e-02f, -8.13532621e-03f, 4.04279269e-02f, -1.32425010e-01f, -5.84344268e-02f, -7.17458427e-02f, -1.22755989e-01f, -2.90671512e-02f, -6.67984337e-02f,
  -1.84826046e-01f, -1.61862046e-01f, -1.92032486e-01f, -1.26934778e-02f, -1.04005806e-01f, -1.69261038e-01f, -1.08259834e-01f, -7.37787038e-02f, -3.17280173e-05f, -9.34570357e-02f,
  3.19612145e-01f, 3.12420636e-01f, 1.76095113e-01f, 2.91569233e-01f, 1.67142034e-01f, 2.65275747e-01f, 2.62876153e-01f, 2.88077980e-01f, 1.14190690e-01f, 2.07353145e-01f,
  2.52258599e-01f, 2.34119609e-01f, 1.78621784e-01f, 2.01529980e-01f, 2.65097976e-01f, 1.93693772e-01f, 8.56727734e-02f, 9.20012146e-02f, 1.46557689e-01f, -3.17865573e-02f,
  1.26323700e-02f, -1.69763993e-02f, 8.13065395e-02f, 4.42127809e-02f, 1.08930543e-01f, 7.71973064e-05f, 8.14893171e-02f, 6.22147694e-02f, -4.00244212e-03f, -3.31126899e-02f,
  -7.76865259e-02f, 1.03195265e-01f, 3.65268905e-03f, -1.00177050e-01f, -7.73559837e-03f, -1.86510645e-02f, -6.90827221e-02f, -1.97361410e-02f, -1.74622029e-01f, -9.13317576e-02f,
  -1.00533858e-01f, 7.20598474e-02f, -5.37501164e-02f, -1.20730557e-01f, -1.45890951e-01f, -1.58954427e-01f, 3.15732993e-02f, -2.48414464e-02f, 7.58892521e-02f, 2.78801266e-02f,
  -1.87488296e-03f, 7.22965524e-02f, -9.20644924e-02f, -3.75320725e-02f, 1.90972891e-02f, -5.51138110e-02f, -3.13047729e-02f, -1.37241799e-02f, 5.60473576e-02f, -3.73521857e-02f,
  2.23696351e-01f, 1.88127160e-01f, 1.87124863e-01f, 2.40208566e-01f, 1.21751487e-01f, 7.95145482e-02f, -9.22732502e-02f, 9.65578035e-02f, 6.27563819e-02f, -8.25436041e-03f,
  -1.11880235e-01f, 3.10314782e-02f, 1.33175209e-01f, -8.22891667e-02f, -5.47226612e-03f, 5.51521890e-02f, 8.47515166e-02f, 7.11938515e-02f, -1.37588754e-01f, -2.37064939e-02f,
  -2.88161682e-04f, -9.20345262e-02f, -6.06961101e-02f, -5.05941659e-02f, -3.08695529e-02f, -1.03649221e-01f, 9.29096341e-03f, -8.01893920e-02f, 4.75178510e-02f, -7.20566735e-02f,
  8.02054927e-02f, 2.26603836e-01f, 1.09574959e-01f, 1.12091601e-01f, 1.66300461e-02f, -1.29515484e-01f, 2.06079409e-02f, -7.88982436e-02f, -1.35583624e-01f, -3.96453813e-02f,
  -9.77454856e-02f, 8.31847712e-02f, -6.12422340e-02f, -1.25805303e-01f, -8.80351886e-02f, -1.70672536e-01f, 8.32635909e-02f, 2.01785728e-01f, 1.43760115e-01f, 3.18194851e-02f,
  8.23179781e-02f, 5.67244254e-02f, -5.35468832e-02f, -2.86159646e-02f, -4.25842740e-02f, 1.03954665e-01f, -4.59933430e-02f, -4.60066693e-03f, -1.22289628e-01f, -1.21142417e-01f,
  -4.23541069e-01f, 2.85417497e-01f, -4.12281863e-02f, 1.79099172e-01f, -1.26378223e-01f, -1.08167820e-01f, 3.86929549e-02f, 8.72331932e-02f, 1.91835016e-01f, 2.43306234e-01f,
  -1.77986212e-02f, -1.61146477e-01f, 1.59812614e-01f, -1.36592044e-02f, -2.95552481e-02f, 3.35587233e-01f, 3.83360624e-01f, -2.79039294e-01f, -6.23348951e-01f, -5.24343252e-01f,
  -9.59981233e-02f, -1.01962961e-01f, -2.02339381e-01f, -1.17723107e-01f, 2.57287651e-01f, 9.93834659e-02f, 3.81448090e-01f, 2.06345189e-02f, -1.14027321e-01f, 2.31869519e-01f,
  -1.24594338e-01f, -2.00511292e-01f, -2.20757335e-01f, -2.45651141e-01f, 1.45985819e-02f, -1.80756241e-01f, -1.50857940e-01f, -2.73608007e-02f, -1.20390005e-01f, -1.28080517e-01f,
  -1.63952872e-01f, -1.64192528e-01f, -1.05792940e-01f, -1.50024518e-02f, -9.87774804e-02f, -1.09112553e-01f, 9.47940797e-02f, -1.05355002e-01f, -1.38236523e-01f, -1.68983236e-01f,
  4.95528020e-02f, -4.00116593e-01f, -2.90085435e-01f, -9.87273920e-03f, -1.34131551e-01f, -2.53766924e-01f, -8.97653550e-02f, -2.57859677e-01f, -2.33535886e-01f, 2.33201191e-01f,
  -8.37332606e-02f, 7.95723349e-02f, 5.75917624e-02f, 2.22601324e-01f, 4.41596769e-02f, -1.75827369e-02f, 8.00522193e-02f, 1.25169381e-02f, -7.68059343e-02f, -4.41479459e-02f,
  -5.47614843e-02f, -2.06163395e-02f, -9.98821631e-02f, -4.81852330e-02f, 1.74258947e-02f, -6.92743808e-02f, -7.23642260e-02f, 1.18344605e-01f, 2.80124079e-02f, 2.79167145e-02f,
  -4.09747176e-02f, 2.06983015e-02f, -1.82744674e-02f, 3.66019197e-02f, 7.11600929e-02f, 8.34961459e-02f, 1.41055845e-02f, -7.35924691e-02f, 6.02712622e-03f, -1.08186603e-01f,
  2.92245597e-01f, -1.01499543e-01f, 2.12759867e-01f, 9.63467360e-02f, 2.37397086e-02f, -6.19344600e-02f, 1.39605597e-01f, -6.39702305e-02f, 4.30780128e-02f, -1.78574547e-01f,
  -9.78802741e-02f, -1.06195256e-01f, 1.90519750e-01f, 1.19487695e-01f, -1.04567908e-01f, 4.61574905e-02f, 1.09933957e-01f, 8.91532190e-03f, 4.57766131e-02f, -4.61733751e-02f,
  2.98989862e-01f, -5.26588634e-02f, -7.03430083e-03f, 1.55452535e-01f, 1.18384734e-01f, -1.87995195e-01f, 8.47796574e-02f, 4.43751141e-02f, -9.39914584e-02f, 5.05738318e-01f,
  6.19531393e-01f, 1.12196896e-02f, -4.31936592e-01f, -9.05217007e-02f, -2.57629871e-01f, -2.11824223e-01f, -1.39052555e-01f, -1.56688169e-01f, -2.72048227e-02f, -6.72688186e-02f,
  4.95905580e-04f, 1.00331970e-01f, -2.33578961e-03f, -6.06487356e-02f, -1.05673037e-02f, -3.00680518e-01f, -2.38002017e-01f, -2.05889523e-01f, -3.96036170e-02f, -1.45403162e-01f,
  -2.14187019e-02f, -1.29420698e-01f, 6.77703694e-02f, 2.94126440e-02f, -2.19491139e-01f, -2.10856706e-01f, -2.44987711e-01f, -2.26143941e-01f, -2.31013179e-01f, -2.79022396e-01f,
  -5.44696450e-01f, -1.14814341e-02f, 1.03265472e-01f, 1.98416680e-01f, 7.84145147e-02f, 2.34629050e-01f, 1.45534575e-01f, 1.22009963e-01f, 1.19598694e-01f, 3.51068303e-02f,
  -4.43206877e-02f, 5.01673184e-02f, 6.41139224e-02f, -3.09080407e-02f, 3.67488526e-02f, 8.34397078e-02f, 1.81998521e-01f, -4.24766354e-02f, -5.64682530e-03f, -7.16863386e-03f,
  3.74834542e-03f, -7.65223429e-02f, 3.72040132e-03f, 1.06856100e-01f, 1.49184376e-01f, 1.10870674e-02f, 5.85540533e-02f, -6.74819723e-02f, -2.57622842e-02f, 1.98947161e-01f,
  4.91812676e-02f, 4.63132709e-02f, -3.09297629e-02f, 5.52163869e-02f, 1.01053387e-01f, -5.36894007e-03f, -6.20511658e-02f, 5.85498102e-03f, -2.08571535e-02f, 1.34674385e-01f,
  -1.00457249e-02f, -1.20925479e-01f, -1.05755389e-01f, -1.29636610e-02f, -1.01383805e-01f, -1.39936432e-01f, -1.36960298e-01f, -1.47101916e-02f, -1.25942960e-01f, -1.85224578e-01f,
  3.17814201e-02f, -1.41199455e-01f, -1.43851653e-01f, -2.57214624e-02f, -1.89126894e-01f, -2.75931116e-02f, -1.64267316e-01f, -1.25332987e-02f, -1.52090071e-02f, -7.04053119e-02f,
  -2.62076855e-01f, -4.57430333e-02f, -3.99336927e-02f, -2.43438827e-03f, 3.54496716e-03f, -2.84591829e-03f, 4.81030978e-02f, -5.82471713e-02f, -1.42830774e-01f, -4.60750796e-02f,
  -9.95987505e-02f, 3.64158154e-02f, 2.75940020e-02f, -4.13685255e-02f, 1.20052874e-01f, -2.75326390e-02f, 1.84569061e-01f, 8.85785595e-02f, -3.42231169e-02f, -4.07109633e-02f,
  2.74807047e-02f, 9.80029330e-02f, 8.54109973e-02f, 1.58797503e-01f, 6.96559921e-02f, 7.53448531e-02f, 1.43630221e-01f, 5.05287610e-02f, 1.43711828e-03f, 3.36729944e-01f,
  3.28427225e-01f, 6.15277290e-01f, 9.85037535e-04f, 8.77428651e-02f, -9.88667086e-02f, 5.93145238e-03f, 1.46540016e-01f, 2.23031580e-01f, 9.20562632e-03f, 1.19452193e-01f,
  2.55399907e-04f, -5.20383343e-02f, -2.46551074e-02f, -1.52762607e-01f, -4.03897464e-02f, 4.67088036e-02f, -3.40713300e-02f, -1.41648099e-01f, -1.17552884e-01f, -2.39962135e-02f,
  -6.27138689e-02f, 9.87236798e-02f, 9.81255695e-02f, 4.98913713e-02f, -4.72402666e-03f, -1.31380782e-01f, -1.90035552e-02f, 7.07567185e-02f, -3.18113118e-02f, -3.63322310e-02f,
  -1.30011648e-01f, 1.83640614e-01f, -2.19966933e-01f, 8.00952911e-02f, 8.64192396e-02f, 1.25435680e-01f, 4.27429117e-02f, 7.11508021e-02f, 1.82567909e-01f, 1.18239738e-01f,
  -2.34786281e-03f, -9.61108971e-03f, 1.52768083e-02f, 1.13336497e-03f, 8.63596424e-02f, 9.46029276e-02f, 2.23890051e-01f, 1.05605312e-01f, 1.08779639e-01f, 5.00982068e-02f,
  -3.12852301e-02f, -2.51080561e-02f, 1.49525106e-01f, -1.05548970e-01f, -1.35093138e-01f, -8.67331922e-02f, -3.45156230e-02f, 6.06092252e-03f, -1.35720119e-01f, -1.61869470e-02f,
  3.32769263e-03f, 9.53739211e-02f, -1.40691981e-01f, -2.27226675e-01f, -1.03362970e-01f, 3.79287940e-03f, 5.50895594e-02f, -5.88623248e-02f, -1.31953165e-01f, -5.15301302e-02f,
  2.17444487e-02f, -2.18791455e-01f, -4.59552705e-02f, -5.56449518e-02f, -6.50557280e-02f, 7.94748291e-02f, -6.34270441e-03f, 9.26823635e-03f, -1.56989485e-01f, 1.98419522e-02f,
  -1.05327591e-01f, 1.16114743e-01f, 1.90590233e-01f, 5.96299022e-02f, 1.39154419e-01f, 5.59089966e-02f, -7.83142895e-02f, -4.49254923e-02f, 1.70655102e-02f, 5.62013499e-02f,
  -1.89582165e-02f, -5.84424615e-01f, -1.54047057e-01f, -3.45208794e-02f, 5.22012124e-04f, 2.18541816e-01f, -8.54769349e-02f, 6.38156831e-02f, 8.72970521e-02f, 1.04831502e-01f,
  9.95746925e-02f, 5.29994406e-02f, 5.50729483e-02f, 2.61946861e-02f, -1.32776901e-01f, -9.26565453e-02f, 5.30576222e-02f, 6.32198304e-02f, 9.21823010e-02f, 9.70297977e-02f,
  1.77186653e-01f, 9.54244693e-04f, 6.87518716e-02f, -8.02172422e-02f, -8.83853883e-02f, -1.68450475e-01f, -1.00259408e-01f, 4.91542881e-03f, -3.30188684e-02f, -6.86192811e-02f,
  2.32378751e-01f, -2.10774139e-01f, 1.64670318e-01f, -4.09346372e-02f, -5.46725877e-02f, 3.73986922e-02f, 8.51375014e-02f, 5.39850676e-03f, -1.20757446e-01f, -2.47509703e-02f,
  5.57978302e-02f, 2.05917001e-01f, 2.11439013e-01f, 4.08148803e-02f, 1.27424255e-01f, -1.21575586e-01f, -1.94565475e-01f, 1.09979287e-01f, 1.98993132e-01f, -8.01729113e-02f,
  -6.79182932e-02f, -1.16832137e-01f, -4.17152718e-02f, -1.16412051e-01f, -1.56512320e-01f, -2.48266086e-02f, -7.25920200e-02f, -1.59695536e-01f, -1.02557644e-01f, -1.61509067e-01f,
  1.56046003e-01f, -1.66653857e-01f, 3.61013897e-02f, -1.27112523e-01f, -2.61229053e-02f, 8.01120885e-03f, 5.93824275e-02f, -1.04888968e-01f, -1.81574319e-02f, -1.11172363e-01f,
  -5.08072972e-02f, -7.42936134e-02f, -2.57512573e-02f, -6.62874430e-02f, -7.81988446e-03f, -3.23371068e-02f, -9.47682410e-02f, -4.39476036e-02f, -1.18123941e-01f, -8.94915015e-02f,
  -1.48574769e-01f, -1.61050837e-02f, 1.31031170e-01f, -7.10547715e-02f, 3.87798250e-02f, -3.59106716e-03f, -8.95604342e-02f, -1.06671369e-02f, -6.40535057e-02f, -8.07022452e-02f,
  -6.56938776e-02f, 5.59466146e-03f, 8.15138686e-03f, -6.86852681e-03f, 1.10518135e-01f, 5.41384071e-02f, 2.24262550e-02f, 2.10290551e-02f, -4.97357473e-02f, 1.94673034e-04f,
  -6.17128238e-02f, 6.55126795e-02f, 3.52419280e-02f, -6.29237145e-02f, 4.75891255e-04f, 4.25829552e-03f, 4.65290733e-02f, -1.46081680e-02f, 2.89506875e-02f, 5.19511327e-02f,
  3.98123525e-02f, -2.54844110e-02f, -4.55767699e-02f, 5.71554415e-02f, -9.78174731e-02f, 2.86643486e-02f, 1.61936563e-02f, -6.32351090e-04f, 1.12254294e-02f, -3.20082307e-02f,
  2.00419933e-01f, 1.11355884e-02f, 1.26051694e-01f, -7.02707842e-03f, -9.28247198e-02f, -1.64600506e-01f, -4.63693738e-02f, -1.31602600e-01f, -5.89392856e-02f, 4.55694459e-02f,
  -3.79677452e-02f, 9.26428288e-02f, 1.42146330e-02f, -1.25600532e-01f, -1.42180519e-02f, 3.34515865e-03f, -8.72245952e-02f, 5.38868979e-02f, -6.50932938e-02f, -7.09055588e-02f,
  -1.08498342e-01f, 3.77358273e-02f, 2.33470023e-01f, 1.22179426e-01f, -1.85122772e-03f, 1.94710821e-01f, 1.10113256e-01f, 1.37927979e-01f, 1.11101829e-01f, 1.00730084e-01f,
  1.54866740e-01f, -3.01630408e-01f, -5.83106130e-02f, -4.64871377e-02f, 1.28999159e-01f, 1.67085439e-01f, 2.83911616e-01f, 1.26953900e-01f, -3.11158900e-03f, -5.19859754e-02f,
  -1.84535012e-01f, -8.39491114e-02f, -1.56215876e-01f, -2.15758383e-01f, -2.74939723e-02f, 2.63817087e-02f, 1.19525485e-01f, 3.39630693e-02f, 1.75290078e-01f, 2.16652974e-01f,
  8.45050439e-02f, 4.50912975e-02f, -6.21627271e-02f, -4.87384573e-02f, -1.99290946e-01f, -9.75824893e-02f, -1.10562339e-01f, -5.66842817e-02f, -1.90822199e-01f, -3.04563850e-01f,
  1.50614947e-01f, -3.24948102e-01f, 3.23375463e-02f, -1.88897982e-01f, -1.59429982e-01f, -1.30905792e-01f, 4.89542969e-02f, -1.81988060e-01f, -9.66458544e-02f, 3.15464363e-02f,
  -8.55668187e-02f, -1.64173111e-01f, -9.18552354e-02f, 2.41733668e-03f, -2.66933348e-02f, 3.96997556e-02f, -7.27179199e-02f, -2.03523710e-01f, -1.04687944e-01f, -2.88228840e-02f,
  -5.94091974e-02f, -6.37474731e-02f, -3.17954011e-02f, 1.10832392e-03f, -7.67792994e-03f, 7.85325766e-02f, -6.17948472e-02f, -1.01722525e-02f, -6.20905012e-02f, -2.75992770e-02f,
  -8.48241150e-03f, 1.64883226e-01f, 1.83276702e-02f, -4.94848490e-02f, 5.88374734e-02f, 9.38181058e-02f, -1.81786343e-02f, 1.04812920e-01f, -2.02478487e-02f, 5.57518713e-02f,
  -1.46901691e-02f, -1.52111530e-01f, 3.78465978e-03f, -5.44002801e-02f, -3.34192514e-02f, -3.42498580e-03f, 7.35350624e-02f, -5.58407269e-02f, 1.46517809e-02f, 2.06787363e-02f,
  -4.67895642e-02f, 6.36314824e-02f, -8.41611475e-02f, -1.14200957e-01f, -3.38707212e-03f, -5.14173284e-02f, -2.05066125e-03f, 4.00480442e-03f, -6.33518770e-02f, 5.53681739e-02f,
  1.20725343e-02f, -8.99755210e-02f, 3.10321264e-02f, -1.36562198e-01f, 2.99664959e-02f, -8.06341395e-02f, -1.85334399e-01f, -1.01902477e-01f, -4.45226356e-02f, 9.24471393e-02f,
  -1.93727333e-02f, -7.48548135e-02f, -7.31422473e-03f, 1.38042662e-02f, 2.01958835e-01f, 1.25318930e-01f, -1.07302815e-01f, -4.40963916e-03f, 3.42730200e-04f, 1.68168545e-02f,
  -1.02963924e-01f, 1.54860318e-01f, 1.90185457e-01f, 9.65554193e-02f, 1.38520906e-02f, 1.59622252e-01f, 1.86049402e-01f, 5.56051731e-02f, 1.23592570e-01f, 2.82084972e-01f,
  -1.43683162e-02f, -3.98486219e-02f, -4.68816832e-02f, 1.88121185e-01f, 1.14123799e-01f, 8.07777196e-02f, 6.08263724e-02f, 1.18259713e-01f, 1.56116292e-01f, 1.08222157e-01f,
  1.11038335e-01f, 1.33847386e-01f, 7.45183975e-02f, 1.25278383e-01f, 9.41245183e-02f, 4.00989316e-03f, -2.55315322e-02f, 6.80936947e-02f, -2.44532917e-02f, 3.82604152e-02f,
  1.09043099e-01f, -2.06214022e-02f, -4.11361791e-02f, 4.32976149e-03f, 6.55363034e-03f, 4.86913919e-02f, 1.06549375e-02f, -1.44382399e-02f, 7.48953894e-02f, 3.55164483e-02f,
  -9.15366411e-02f, -4.67427708e-02f, -3.33259404e-02f, -3.54666039e-02f, -7.32489442e-03f, -1.10288106e-01f, -7.36885071e-02f, -1.45190954e-01f, -6.36622170e-03f, -9.48302820e-02f,
  5.63537562e-03f, -6.14774898e-02f, -2.62048934e-02f, -9.60622057e-02f, -1.00412659e-01f, -2.40898095e-02f, -6.49546087e-02f, 1.49603595e-03f, 3.10868304e-02f, 1.23638315e-02f,
  6.69676531e-03f, -6.75773174e-02f, -1.43163919e-01f, -4.59870771e-02f, -3.56353298e-02f, 4.46944572e-02f, 2.35157572e-02f, 1.17339082e-02f, -3.53103206e-02f, -3.21692936e-02f,
  9.45364013e-02f, -5.91542348e-02f, -2.57633533e-02f, 3.65994051e-02f, 4.04492542e-02f, 6.41986355e-03f, -3.65058705e-02f, -1.19070970e-02f, -4.32276800e-02f, -1.10822581e-01f,
  -4.07609232e-02f, 7.25523457e-02f, -7.30294287e-02f, 3.79086062e-02f, 2.98078433e-02f, -6.45742938e-02f, -9.84937772e-02f, -3.75237018e-02f, 2.20300863e-03f, -1.04711149e-02f,
  8.51851143e-03f, 4.46595578e-03f, 2.74160225e-02f, -4.85034622e-02f, -5.13568930e-02f, -7.19677731e-02f, 5.03178826e-03f, 5.13724191e-03f, -7.66111016e-02f, 1.06649874e-02f,
  -1.04462795e-01f, 3.90946716e-02f, 3.83786559e-02f, -1.99269932e-02f, -9.26376209e-02f, 1.92554928e-02f, -2.70554610e-02f, -1.37867061e-02f, -7.78369680e-02f, -5.83659261e-02f,
  -1.03536598e-01f, -4.42760214e-02f, -2.16502827e-02f, -9.27898474e-03f, -8.17696899e-02f, -9.68953315e-03f, 4.48403694e-02f, -5.19146398e-03f, -8.24056119e-02f, -1.35959029e-01f,
  -1.19502926e-02f, -1.19704515e-01f, -9.43333730e-02f, -4.39922661e-02f, 6.77804928e-03f, 7.91117549e-03f, -6.59283176e-02f, -4.04717624e-02f, -9.27240029e-02f, -1.02264695e-01f,
  -4.20008212e-01f, 3.49574327e-01f, -3.14868391e-01f, -1.51509896e-01f, -1.34850875e-01f, 5.80612719e-02f, 4.13160741e-01f, 2.27169961e-01f, 1.10154100e-01f, 1.78131491e-01f,
  5.26954383e-02f, -1.65142193e-01f, -5.89467622e-02f, -6.17699586e-02f, 3.89511287e-02f, 3.01451325e-01f, 1.60775617e-01f, -2.54191637e-01f, -2.68223733e-01f, -5.79608232e-02f,
  1.52646542e-01f, -6.83845580e-02f, -2.81337023e-01f, -1.38900250e-01f, -3.85611616e-02f, -1.61512062e-01f, -1.24315778e-02f, -1.44548714e-01f, 2.20537446e-02f, -9.69347432e-02f,
  -1.67566240e-01f, -2.24105090e-01f, -1.76650926e-01f, -3.32446873e-01f, -1.48370966e-01f, -4.34233062e-02f, 5.01718279e-03f, -1.28885657e-01f, -5.07488884e-02f, 1.54346356e-03f,
  -2.40880147e-01f, -3.54174562e-02f, -1.65404677e-01f, -1.21342339e-01f, -1.00521378e-01f, -6.83269501e-02f, -1.16128139e-01f, -1.58068746e-01f, -1.03833154e-01f, -5.75438887e-02f,
  8.12197626e-02f, -9.00610089e-02f, -3.04515034e-01f, 1.95798706e-02f, 2.66052354e-02f, -6.33404553e-02f, -1.49663389e-01f, -1.03079654e-01f, -8.47699121e-02f, -1.54223233e-01f,
  1.80258602e-01f, -1.34263746e-02f, -6.52847961e-02f, -2.13592183e-02f, -1.43046454e-02f, 7.31558129e-02f, 5.50906435e-02f, 1.65144447e-02f, -4.78584878e-02f, -2.60963924e-02f,
  4.13890220e-02f, -1.36912311e-03f, -1.82067789e-02f, 9.31429490e-02f, 5.76052964e-02f, 1.31284464e-02f, 9.56236571e-03f, 8.00931156e-02f, 4.91884630e-03f, 1.54113667e-02f,
  -1.46408956e-02f, -6.55311644e-02f, -8.90035927e-02f, -1.55654107e-03f, 4.65070382e-02f, 6.75965920e-02f, 2.27180552e-02f, -6.67668656e-02f, -5.66077605e-02f, -9.59786121e-03f,
  -2.99241245e-02f, 6.61652312e-02f, -6.86790869e-02f, -3.46125476e-02f, -6.06172420e-02f, -5.73581597e-03f, 3.15404199e-02f, 4.44287024e-02f, -2.52381973e-02f, -5.83438389e-02f,
  -5.09255566e-02f, 3.88827063e-02f, 6.56166160e-03f, -2.19461136e-02f, -1.25272751e-01f, 6.35492802e-02f, 1.30773142e-01f, -1.79478779e-01f, -1.13047101e-03f, -7.37031102e-02f,
  3.62582281e-02f, 1.09894484e-01f, -2.16449901e-01f, -7.48562440e-02f, 1.09973820e-02f, -7.31204003e-02f, -2.16544598e-01f, -1.76823940e-02f, 3.67268547e-02f, 8.91464576e-02f,
  2.47478560e-01f, 3.50973070e-01f, 1.46222502e-01f, -7.59991407e-02f, 6.23140931e-02f, 1.98515207e-01f, 2.27628395e-01f, 9.64774787e-02f, -7.61187449e-02f, 7.95126259e-02f,
  5.78697473e-02f, -5.25413156e-02f, -1.30736768e-01f, -3.64362076e-02f, 4.21903059e-02f, -2.92428508e-02f, -1.28113879e-02f, -9.79995653e-02f, -8.81639197e-02f, -4.46866686e-03f,
  -3.49888653e-02f, 8.69815797e-02f, -9.23557952e-02f, -7.53963739e-02f, 3.39124203e-02f, -1.20067939e-01f, -2.78699258e-03f, 1.17466882e-01f, 2.11407766e-01f, 9.11968872e-02f,
  1.51762828e-01f, 3.19042951e-01f, -4.04083669e-01f, 7.08206603e-03f, 8.95198807e-02f, -8.03812370e-02f, -1.20200202e-01f, -8.02150443e-02f, -4.70835268e-02f, -8.64509121e-02f,
  1.61006935e-02f, 7.20714331e-02f, 5.77614419e-02f, 4.15978692e-02f, 5.78182191e-02f, 4.25589085e-03f, 3.37659232e-02f, -5.69951758e-02f, -1.22256696e-01f, 6.98678643e-02f,
  2.75530145e-02f, 1.36976153e-01f, 1.00165114e-01f, -1.00799546e-01f, -3.19557488e-02f, -1.06889561e-01f, 3.40989605e-02f, 2.14475151e-02f, -1.47347435e-01f, -6.78018183e-02f,
  -2.87594825e-01f, 3.17319445e-02f, 6.32590503e-02f, 1.60954408e-02f, -1.85735635e-02f, -2.32912321e-02f, 9.19387862e-02f, 2.26268657e-02f, 4.62180115e-02f, 6.83565810e-02f,
  -1.11572199e-01f, -1.32719517e-01f, -2.05733459e-02f, -1.98718123e-02f, -1.36781380e-01f, 2.43761819e-02f, 9.51585993e-02f, -9.90852192e-02f, -7.92813487e-03f, 2.69207964e-03f,
  6.78392798e-02f, -3.09084114e-02f, -7.54993036e-02f, 4.74395417e-02f, -6.93246722e-02f, -7.27272034e-02f, -1.30938500e-01f, -1.24754533e-01f, -7.00702369e-02f, -3.23962271e-02f,
  -1.51973054e-01f, -8.31265897e-02f, -1.86102703e-01f, 8.05943310e-02f, 1.75398961e-01f, 1.18087400e-02f, 1.78816002e-02f, 8.08186978e-02f, 1.07618079e-01f, 4.49644495e-03f,
  6.55736821e-03f, -7.10753212e-03f, 7.35537335e-02f, 1.84462145e-02f, -9.29944292e-02f, 1.30544072e-02f, 9.77041125e-02f, 2.23708935e-02f, -7.08816797e-02f, 1.70718960e-03f,
  -8.08398798e-02f, -1.44209132e-01f, -1.19659066e-01f, -1.81650892e-01f, -1.19924992e-01f, -3.20749462e-01f, -1.29288942e-01f, -3.32242288e-02f, -1.27817884e-01f, -2.44393066e-01f,
  -5.36232173e-01f, 2.86851898e-02f, -2.19039544e-01f, -3.00102800e-01f, -2.98501141e-02f, -8.32665488e-02f, 5.95912710e-02f, -6.49568290e-02f, -9.16181281e-02f, -7.06490129e-02f,
  9.68600810e-02f, 1.13702767e-01f, 3.77172418e-02f, -5.10808378e-02f, -2.76884437e-01f, -9.19731483e-02f, -1.32614091e-01f, -3.09270084e-01f, -2.57240534e-01f, 1.19470857e-01f,
  1.69809252e-01f, -1.22046843e-01f, -2.84144729e-01f, -1.26467124e-01f, 2.08910137e-01f, 4.77360189e-02f, -8.51556808e-02f, -1.69152886e-01f, -7.39470497e-02f, 6.10620901e-02f,
  2.09314495e-01f, -1.36159271e-01f, -1.13596968e-01f, -1.37713104e-01f, -6.28655702e-02f, -3.19664441e-02f, -1.06887687e-02f, -1.54737130e-01f, -9.01236013e-02f, -6.40686378e-02f,
  -1.78533290e-02f, 3.27478312e-02f, 2.08341572e-02f, 1.21664613e-01f, -2.42743362e-02f, -1.48614436e-01f, -1.47022486e-01f, -1.03207439e-01f, -1.54643804e-01f, 1.25800386e-01f,
  1.99493393e-01f, -1.20147966e-01f, -9.72150937e-02f, 3.62941548e-02f, 2.10552453e-03f, -1.34476542e-01f, 6.77699372e-02f, -1.77680850e-02f, -1.93269238e-01f, -2.26175897e-02f,
  2.24003531e-02f, 4.43378696e-03f, -1.15036145e-01f, -1.62717998e-02f, 7.04531074e-02f, -3.24442126e-02f, -5.68703674e-02f, -7.22611276e-03f, -3.30989957e-02f, -6.25848398e-02f,
  1.02088906e-01f, 4.94747683e-02f, -1.24300374e-02f, -4.88776825e-02f, 8.55754390e-02f, -1.12547338e-01f, -1.73067838e-01f, 4.55038548e-02f, 3.59098613e-02f, 1.91958938e-02f,
  -7.80543387e-02f, -2.11792886e-02f, -2.35076044e-02f, 6.74672471e-03f, -3.78782786e-02f, -1.32294953e-01f, -3.74768376e-02f, 4.52539138e-02f, 2.16064565e-02f, 3.83382104e-02f,
  1.64978936e-01f, -2.76125163e-01f, -7.91355669e-02f, 8.41520540e-03f, -7.40549788e-02f, 9.37046930e-02f, 5.33705465e-02f, -1.43133849e-01f, -3.46016213e-02f, -1.29114483e-02f,
  7.24287936e-03f, -6.79660738e-02f, 5.51034324e-02f, 1.48168951e-01f, 2.18502749e-02f, 1.91160999e-02f, -7.89174512e-02f, -1.39482290e-01f, 2.17769966e-02f, 1.44279674e-01f,
  -4.16617058e-02f, -1.90894619e-01f, -2.08677158e-01f, -6.75805612e-03f, 2.33376138e-02f, -1.29197568e-01f, 7.89106339e-02f, 9.30365920e-02f, -6.58662692e-02f, -6.30345792e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  3.45875323e-01f, 2.75609702e-01f, 2.75695324e-01f, 4.15006220e-01f, 2.47744605e-01f, 1.01949640e-01f, -5.03850169e-03f, 3.70269239e-01f, 1.02716021e-01f, 1.70012593e-01f,
  2.78075039e-01f, 1.74517140e-01f, 4.13524628e-01f, 1.28610700e-01f, 4.38881308e-01f, 2.36349210e-01f, 3.37157249e-01f, -2.44835000e-02f, 4.30870235e-01f, 4.54689115e-01f,
  6.62513375e-02f, 1.85351282e-01f, 6.50072843e-02f, 1.64329290e-01f, 4.97549176e-01f, 7.45256096e-02f, 1.74072891e-01f, 3.16638201e-01f, 1.12292305e-01f, 2.82274812e-01f,
  3.11990768e-01f, 4.83205825e-01f, 4.28540796e-01f, 8.43971223e-02f, 5.16480088e-01f, 3.11495811e-01f, 4.17310923e-01f, 2.42078707e-01f, 2.43615761e-01f, 1.89660758e-01f,
  2.97578007e-01f, 5.05958915e-01f, 1.74249619e-01f, 3.61688174e-02f, 2.50828803e-01f, 4.15934950e-01f, 3.81933242e-01f, 3.29859138e-01f, 2.12025270e-01f, 2.82317162e-01f,
  1.93392113e-01f, 2.32523724e-01f, 2.30588153e-01f, 2.20457047e-01f, 1.61013782e-01f, 4.88805205e-01f, 1.58277243e-01f, 3.51729274e-01f, 2.49348864e-01f, 3.25890571e-01f,
  3.31493437e-01f, 1.66444704e-01f, 2.22457096e-01f, 8.70753452e-02f, 1.48731560e-01f, 1.27102271e-01f, 2.64937639e-01f, 1.59460366e-01f, 3.86495411e-01f, 1.90775856e-01f,
  1.79008573e-01f, 4.52382505e-01f, 2.30361477e-01f, 1.65700346e-01f, 3.52962315e-01f, 3.10856402e-01f, 1.73980176e-01f, 3.04216385e-01f, 4.29210693e-01f, 1.32512137e-01f,
  1.49109781e-01f, 3.70939553e-01f, 4.02667344e-01f, 3.14936906e-01f, 3.05125862e-01f, 4.91020590e-01f, 3.09363395e-01f, 4.02918935e-01f, 3.73613626e-01f, 2.91981131e-01f,
  3.09070736e-01f, 2.25891739e-01f, 4.30835992e-01f, 9.51117054e-02f, 2.20417291e-01f, 4.50869143e-01f, 1.49210185e-01f, 1.28493980e-01f, 2.28462681e-01f, 3.96703959e-01f,
  -4.70037423e-02f, 2.83602238e-01f, 2.76609272e-01f, 4.18531716e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -8.88842344e-02f, -9.61996093e-02f, -6.73661157e-02f, -2.40441278e-01f, 4.70301472e-02f, 2.29092576e-02f, -2.21672766e-02f, -1.56606853e-01f, -8.57127607e-02f, -2.46832937e-01f,
  -1.49254024e-01f, -1.30572706e-01f, -3.04187499e-02f, 3.75675820e-02f, -1.64031744e-01f, 8.69346783e-03f, 2.82123059e-01f, 8.71227756e-02f, -6.17385209e-02f, 8.04105178e-02f,
  -6.74723238e-02f, -2.10976988e-01f, -4.09477800e-02f, -8.89654681e-02f, -1.07391454e-01f, 3.25497836e-01f, -2.43170992e-01f, 2.36134175e-02f, 1.13945432e-01f, -1.42368063e-01f,
  1.94081254e-02f, 2.03389317e-01f, 1.15100212e-01f, 3.62285942e-01f, 4.22716767e-01f, -2.35004187e-01f, -5.16974740e-02f, -6.60924092e-02f, -6.20362349e-02f, -6.47378415e-02f,
  -1.05374672e-01f, 3.74194801e-01f, -1.84193462e-01f, -1.71469718e-01f, -8.72168690e-03f, -1.08243428e-01f, -3.97206128e-01f, 1.80650860e-01f, -6.36575222e-01f, 2.03557819e-01f,
  -4.10993010e-01f, 9.81579572e-02f, -2.48041943e-01f, -4.68072563e-01f, 2.35390402e-02f, -2.70947397e-01f, -1.47011653e-01f, 2.25434199e-01f, -7.37860948e-02f, 4.62349504e-02f,
  -1.30083531e-01f, -1.18135959e-02f, 3.38946670e-01f, 2.36231372e-01f, -2.69560009e-01f, -3.36480945e-01f, -1.98604539e-01f, -1.13632036e-02f, 2.92864621e-01f, -3.33275050e-01f,
  -1.93633541e-01f, 1.91066545e-02f, 3.56668711e-01f, -3.27895731e-01f, -4.85714853e-01f, -1.97667312e-02f, -3.20178330e-01f, -2.84143090e-01f, -1.97659537e-01f, -4.58844244e-01f,
  -1.48715556e-01f, -5.06789863e-01f, 8.37441459e-02f, -4.64774936e-01f, -5.87961636e-03f, 1.14300065e-01f, 2.76954800e-01f, -1.60151318e-01f, 3.72006506e-01f, 1.34895846e-01f,
  -6.19584322e-03f, 1.72301009e-01f, -4.44236040e-01f, 7.64214918e-02f, -4.41845685e-01f, 1.16998419e-01f, -1.15709804e-01f, 4.63720113e-01f, -7.40322098e-02f, -3.71964961e-01f,
  -1.69968322e-01f, 1.88048795e-01f, -2.80821353e-01f, 3.47587705e-01f, 2.08491515e-02f, -2.82942832e-01f, -7.95386881e-02f, -1.81566417e-01f, -3.51383746e-01f, 3.01372588e-01f,
  -7.72999376e-02f, 2.25958139e-01f, -3.53258938e-01f, -5.06865323e-01f, -1.67543218e-01f, -1.08355954e-01f, 3.55627052e-02f, -9.37445983e-02f, -3.36302727e-01f, -8.08822751e-01f,
  1.75064042e-01f, 1.17137909e-01f, -1.08898945e-01f, -1.61574036e-02f, -1.74024943e-02f, -5.65843135e-02f, -2.25997686e-01f, 1.47699058e-01f, -3.80786508e-02f, -6.78110719e-02f,
  -2.17265636e-01f, -2.64260992e-02f, 4.52399291e-02f, -1.34294614e-01f, -7.92249590e-02f, 1.36812637e-03f, -1.27720937e-01f, 9.66675207e-02f, 4.19898257e-02f, 1.03938453e-01f,
  -1.36928692e-01f, 2.14358732e-01f, -3.05853695e-01f, 1.45060956e-01f, 2.77978808e-01f, -1.22123905e-01f, 2.09650397e-01f, -2.44921133e-01f, -1.02410866e-02f, 2.65336260e-02f,
  -7.19726533e-02f, -2.58486629e-01f, 1.42308787e-01f, -4.90567029e-01f, -1.90639310e-02f, -3.19032133e-01f, -4.94494349e-01f, -2.81369001e-01f, -4.62980149e-03f, 1.16190933e-01f,
  -1.33947767e-02f, 4.35921192e-01f, -3.18788707e-01f, 1.33269131e-01f, -2.59052604e-01f, 7.02006817e-01f, -2.27261454e-01f, 2.24237680e-01f, -3.94584209e-01f, -4.32105720e-01f,
  2.58691519e-01f, -4.03874159e-01f, 2.13812634e-01f, 1.82587013e-01f, 3.54094454e-03f, -4.22755152e-01f, -6.64380431e-01f, 2.19300166e-01f, -6.25900105e-02f, -4.42811161e-01f,
  7.57433921e-02f, -2.66471118e-01f, 1.85469519e-02f, -3.24394584e-01f, -2.89867949e-02f, -3.15981388e-01f, -2.01593250e-01f, 6.67930767e-03f, 1.24765329e-01f, -4.51757759e-01f,
  3.80667746e-01f, 4.11820382e-01f, -4.93332237e-01f, -4.28274721e-01f, 4.02888209e-02f, 4.43360209e-02f, 2.08312780e-01f, 2.15093851e-01f, -2.31711224e-01f, -3.54419261e-01f,
  1.84787422e-01f, -2.11631015e-01f, -4.23532218e-01f, -4.45480525e-01f, 2.00824782e-01f, -3.45687866e-01f, 2.19071638e-02f, -3.38881426e-02f, -6.67796656e-03f, -2.98338067e-02f,
  3.66249382e-01f, -1.49235621e-01f, -7.38808792e-03f, -2.49366984e-01f, 3.60775352e-01f, 2.64370561e-01f, 1.08988121e-01f, -2.17808723e-01f, 7.20845237e-02f, 1.69841751e-01f,
  1.76142171e-01f, -2.36357540e-01f, -1.34218946e-01f, -6.49075568e-01f, -4.00453448e-01f, 1.11878347e-02f, 2.46728748e-01f, -1.38277531e-01f, -2.55776405e-01f, -7.74686225e-03f,
  -3.49224359e-01f, -4.90807623e-01f, 3.19745362e-01f, 1.63517088e-01f, -4.08193976e-01f, 5.08700535e-02f, -1.12458333e-01f, 4.63459462e-01f, 2.25678846e-01f, 8.57739091e-01f,
  -9.29294303e-02f, -1.11102499e-01f, -3.54968965e-01f, 2.31717482e-01f, -2.07448527e-01f, 1.54049918e-01f, 9.17665362e-02f, -7.70565093e-01f, 2.15403110e-01f, -1.39863700e-01f,
  1.55816272e-01f, -7.66016394e-02f, 1.45204231e-01f, -7.40354717e-01f, -1.11628532e-01f, -4.63346004e-01f, -1.08618522e-02f, -1.62433609e-02f, -5.05506992e-02f, 6.13402426e-02f,
  6.70898184e-02f, 1.18518591e-01f, 4.70274985e-02f, 2.44515866e-01f, 2.59449303e-01f, -2.96752304e-02f, 1.15345351e-01f, 6.05326258e-02f, 2.69700903e-02f, 2.00664878e-01f,
  -1.37863144e-01f, 2.39140213e-01f, 7.40013644e-02f, 1.91583663e-01f, -2.81054556e-01f, 1.70101583e-01f, -2.89284829e-02f, -3.01779918e-02f, 2.64766723e-01f, -2.31068328e-01f,
  -3.59160513e-01f, 2.15512767e-01f, -1.53789461e-01f, -4.49701473e-02f, -2.41990700e-01f, 5.02619073e-02f, -2.00113864e-03f, -2.48408005e-01f, -7.16556907e-02f, 6.84694126e-02f,
  -1.95983186e-01f, 4.08552997e-02f, 4.15716432e-02f, -3.40388007e-02f, -2.81768233e-01f, -3.40601921e-01f, -4.50285137e-01f, -1.64058045e-01f, 2.45662034e-01f, -2.66672641e-01f,
  -1.46271288e-01f, -1.26095816e-01f, -2.34447330e-01f, -3.40515882e-01f, 3.42804730e-01f, -1.77972645e-01f, 8.05074908e-03f, 4.36035246e-01f, 4.20677841e-01f, 1.20389290e-01f,
  -1.50496244e-01f, 1.41293734e-01f, 1.13180704e-01f, -3.42126042e-01f, 3.35299551e-01f, 1.64026380e-01f, -4.08865690e-01f, -2.64513493e-01f, 5.03476560e-01f, 4.14437741e-01f,
  -2.27461219e-01f, -2.21632451e-01f, -1.76729679e-01f, -7.76842460e-02f, 3.54766071e-01f, 5.46817958e-01f, -1.59749269e-01f, -1.91600248e-01f, -4.77256440e-02f, 5.14394820e-01f,
  -2.57451683e-01f, 2.01540902e-01f, -2.65190154e-01f, 5.04871458e-02f, 1.03096344e-01f, -1.39088482e-01f, -1.87302396e-01f, -2.29677781e-01f, -3.59269291e-01f, -1.76979035e-01f,
  5.30711770e-01f, -5.78281283e-03f, -1.19384833e-01f, -1.51943937e-01f, -1.13297693e-01f, 2.36838069e-02f, -2.14170501e-01f, 1.07291982e-01f, 1.92663863e-01f, -2.18974456e-01f,
  2.54089266e-01f, 2.78827965e-01f, -2.73444682e-01f, 1.03850633e-01f, -6.15065135e-02f, -3.14491093e-02f, 3.20885107e-02f, -1.76377580e-01f, -7.24000186e-02f, -8.79872218e-02f,
  -4.17564273e-01f, -2.32290104e-01f, -2.96445429e-01f, -1.20192207e-02f, -2.76539251e-02f, 4.01789218e-01f, -3.55899602e-01f, 3.78907263e-01f, 3.14389944e-01f, -2.53321171e-01f,
  4.16540682e-01f, -2.82714218e-01f, -4.13561195e-01f, -2.65777498e-01f, -2.79410839e-01f, -2.21087574e-03f, 6.84245750e-02f, -4.95625548e-02f, -1.25468150e-01f, -2.32558660e-02f,
  -3.21803018e-02f, -1.50108635e-01f, -2.31853426e-01f, -3.74285966e-01f, -6.88221082e-02f, -6.97040707e-02f, 1.32966926e-02f, 3.49474438e-02f, -1.28230140e-01f, 7.15385377e-02f,
  3.92442271e-02f, -8.84199142e-02f, 4.57975417e-02f, 7.77549446e-02f, -1.40919373e-03f, 1.43776760e-02f, -1.91182926e-01f, -2.23815724e-01f, 2.96242088e-02f, 3.98932025e-02f,
  -1.86840251e-01f, -6.86843991e-02f, -5.84650785e-02f, 1.88412637e-01f, 3.55014987e-02f, 1.94507226e-01f, 4.32005376e-01f, 2.57286012e-01f, -1.47056893e-01f, -1.04334667e-01f,
  -1.88732222e-01f, -5.30402839e-01f, 8.67535025e-02f, -1.65780097e-01f, -2.03960449e-01f, -4.10723478e-01f, -1.77710012e-01f, -6.69303894e-01f, 9.92304683e-02f, -1.24498665e-01f,
  3.12776864e-02f, -2.79094845e-01f, -2.85176605e-01f, -1.15276910e-01f, 2.97790378e-01f, 3.39934766e-01f, -2.51707613e-01f, 2.70521194e-02f, -2.16271475e-01f, -1.74458385e-01f,
  -2.59436965e-01f, -1.14298768e-01f, -1.26024976e-01f, 5.82776777e-02f, 5.29527664e-01f, -2.97557086e-01f, -3.75230014e-01f, -4.72136170e-01f, 4.89231229e-01f, 2.16003940e-01f,
  -2.55202353e-01f, -8.58399719e-02f, -8.04635882e-02f, -4.76113439e-01f, 7.33909532e-02f, -4.46475834e-01f, -6.56828843e-03f, -3.17606889e-02f, -1.91181585e-01f, 3.44156355e-01f,
  -3.26754242e-01f, -1.25127152e-01f, 2.08091855e-01f, 8.10979605e-02f, -7.44220793e-01f, -5.69094896e-01f, 1.74811527e-01f, 2.54105449e-01f, 3.88285875e-01f, -1.67422384e-01f,
  -1.46062195e-01f, 5.07270396e-01f, -1.66599870e-01f, 1.25365891e-03f, -9.05252546e-02f, 1.84541374e-01f, -1.50783896e-01f, 4.43568788e-02f, -2.21123531e-01f, 2.75866926e-01f,
  -2.68548369e-01f, -4.25902277e-01f, 1.37757465e-01f, 8.10468197e-02f, -1.98723450e-02f, 1.00154458e-02f, -3.49941105e-01f, -3.70442003e-01f, -1.26556188e-01f, 4.13388193e-01f,
  7.22089410e-02f, -1.82170421e-01f, -2.73694724e-01f, -1.91337183e-01f, -1.31580383e-01f, -2.35703483e-01f, -1.54519379e-01f, 1.41021758e-01f, 1.67787954e-01f, 1.47892460e-01f,
  3.65318388e-01f, -6.28686473e-02f, 7.24433541e-01f, -2.58788437e-01f, -1.03155207e-02f, -1.28990263e-01f, -8.27763975e-02f, -8.89609829e-02f, 1.99972197e-01f, -1.15771726e-01f,
  -6.87623739e-01f, -4.80601825e-02f, -2.33433560e-01f, -1.90052763e-02f, -2.53903925e-01f, -5.64982712e-01f, -3.94705027e-01f, -3.95807177e-02f, -9.61984992e-02f, 4.12493616e-01f,
  1.07640326e-02f, 1.39587134e-01f, 9.43357870e-02f, -6.19390868e-02f, 1.90790500e-02f, -6.38485327e-02f, -6.74353912e-02f, -1.00207247e-01f, 1.30973950e-01f, -1.82867628e-02f,
  6.22383952e-02f, -9.34853703e-02f, 2.10998990e-02f, 3.68242413e-02f, 1.20407991e-01f, -7.30679482e-02f, -3.78623530e-02f, 2.49183506e-01f, -1.48193419e-01f, -3.76229405e-01f,
  1.53954193e-01f, 2.21829355e-01f, 8.63445327e-02f, 7.03189895e-02f, -1.86385036e-01f, 1.47392333e-01f, -3.39613557e-01f, -4.51360531e-02f, -2.67392434e-02f, -6.23408612e-03f,
  1.69129103e-01f, 2.42830236e-02f, 1.36179728e-02f, -1.00861089e-02f, -3.46697271e-01f, -3.19856346e-01f, -3.93559396e-01f, -1.48891881e-02f, -3.02992970e-01f, 1.09995216e-01f,
  -5.07430099e-02f, -4.89786193e-02f, 4.47882205e-01f, -8.10189079e-03f, -1.36145279e-01f, 5.22272065e-02f, -9.08367485e-02f, -1.45012528e-01f, 1.67323723e-01f, 2.14151382e-01f,
  4.83596057e-01f, -2.57667214e-01f, -3.84510130e-01f, 2.53592879e-01f, 8.79933238e-02f, 2.30001211e-01f, -2.36636728e-01f, -3.14938933e-01f, -1.81231782e-01f, 2.20808372e-01f,
  -2.09613279e-01f, 1.56442262e-02f, 7.29707330e-02f, 5.05490899e-01f, -5.25432862e-02f, -1.05984397e-02f, 3.91162157e-01f, 1.44654125e-01f, 1.45507976e-02f, 1.07259959e-01f,
  1.56947058e-02f, -3.75499636e-01f, 4.82000649e-01f, 7.58957416e-02f, -4.58717346e-01f, 3.63896698e-01f, 3.04306895e-01f, -3.98564905e-01f, -2.26371735e-01f, -3.40963185e-01f,
  -9.82210413e-02f, -3.14381659e-01f, 3.95583920e-02f, 1.05846129e-01f, 1.01641580e-01f, 1.89689502e-01f, -4.21647877e-01f, -4.16514277e-03f, -4.22115386e-01f, 2.95517832e-01f,
  -1.02282196e-01f, -6.15977570e-02f, -1.33997053e-01f, -6.01269864e-02f, -4.95416261e-02f, -6.35123551e-02f, 3.35143715e-01f, 6.80092797e-02f, 2.84378111e-01f, -2.43665799e-01f,
  -5.82161434e-02f, -2.00088069e-01f, -4.07607675e-01f, -1.95216879e-01f, -3.37155133e-01f, -5.20855822e-02f, 1.09409921e-01f, -1.19730113e-02f, 1.17159180e-01f, -1.45039484e-01f,
  -5.23171723e-01f, -4.63498384e-01f, -1.47517309e-01f, -9.17864218e-02f, -7.54574463e-02f, -1.75272614e-01f, 2.65476614e-01f, -3.77134862e-03f, -2.10867330e-01f, -2.31841300e-02f,
  1.41136527e-01f, 4.43964452e-01f, -1.03855290e-01f, 1.54837370e-01f, -1.87534526e-01f, -3.56635302e-01f, -1.40070990e-01f, -4.46812846e-02f, -4.28737439e-02f, 1.44598678e-01f,
  -7.96234384e-02f, 1.53534606e-01f, 1.87447116e-01f, 1.44301087e-01f, 2.59836540e-02f, -5.33842444e-02f, -6.78730235e-02f, 3.29915702e-01f, 1.16043650e-01f, 1.05773605e-01f,
  4.34624292e-02f, -1.34329200e-01f, 8.60274881e-02f, 7.69049302e-02f, 2.20854953e-02f, 5.29785566e-02f, 1.24511637e-01f, -1.71357617e-01f, 1.08409688e-01f, -1.46543443e-01f,
  -2.97651947e-01f, -2.63699532e-01f, -2.14221507e-01f, 1.78152055e-01f, -1.42411932e-01f, -1.91645890e-01f, 1.07268460e-01f, 3.05781305e-01f, -6.62049204e-02f, -2.08649516e-01f,
  -3.96025255e-02f, 4.54157203e-01f, -7.68290088e-02f, 2.46052608e-01f, 3.08569431e-01f, -1.17685989e-01f, 3.82145435e-01f, -2.22254589e-01f, 5.01478255e-01f, -4.52362955e-01f,
  1.20250888e-01f, -2.37110734e-01f, -3.83023441e-01f, 2.31232181e-01f, -2.59414405e-01f, 1.68018267e-01f, 4.35230741e-03f, 2.47027174e-01f, 2.53492203e-02f, 3.88506912e-02f,
  -1.31568357e-01f, -9.32021514e-02f, -6.81245923e-02f, -2.47661471e-01f, 2.85265446e-01f, 4.88384604e-01f, -9.67913195e-02f, -1.22667886e-01f, -3.57807547e-01f, -1.07358351e-01f,
  4.34599251e-01f, -1.95002615e-01f, -4.69233006e-01f, -2.17795614e-02f, 2.38156319e-01f, -2.85420686e-01f, 1.23863541e-01f, 1.01727873e-01f, -5.69469869e-01f, -3.84226441e-01f,
  4.92169827e-01f, -5.82742870e-01f, 1.07596941e-01f, -4.59992945e-01f, -4.80561078e-01f, -1.70588732e-01f, 3.24930340e-01f, -4.22476679e-01f, -3.38292383e-02f, -8.90801027e-02f,
  -8.26966241e-02f, -3.40140522e-01f, 1.76752880e-01f, 2.36474395e-01f, -7.37146959e-02f, -3.75038654e-01f, -2.57758528e-01f, -1.43270522e-01f, -1.71649873e-01f, -1.67057469e-01f,
  1.34623080e-01f, -1.26019210e-01f, 4.65420783e-02f, -3.51651013e-01f, -4.98795986e-01f, -7.43152261e-01f, -1.55881457e-02f, 3.03425193e-01f, 1.84630007e-01f, 1.46276325e-01f,
  1.90255687e-01f, 6.24473393e-02f, 3.86273950e-01f, 2.56651163e-01f, 4.83460585e-03f, 1.92802086e-01f, -5.15768111e-01f, -2.88071454e-01f, -1.45709559e-01f, -3.50028753e-01f,
  -1.12504885e-01f, -2.21258804e-01f, -2.04130232e-01f, 2.03931585e-01f, -4.87317830e-01f, -6.50115609e-02f, 8.09881568e-01f, 1.19966213e-02f, -9.45085660e-02f, 5.30498266e-01f,
  2.15346858e-01f, 2.22864226e-01f, -1.59399524e-01f, -1.74924452e-03f, 3.27117406e-02f, 3.28934699e-01f, -3.70229453e-01f, -1.20876729e-01f, 2.23562587e-02f, 1.01461940e-01f,
  -9.26628038e-02f, -1.31484807e-01f, -7.34608322e-02f, 3.85085978e-02f, 1.51210904e-01f, 1.31857932e-01f, 1.24594402e-02f, 2.08264887e-01f, 2.11610705e-01f, 7.80646726e-02f,
  1.22622691e-01f, 1.35845523e-02f, 2.56628186e-01f, -3.56099784e-01f, 2.71597147e-01f, 1.78092375e-01f, 1.63715765e-01f, 3.93275395e-02f, 1.04927689e-01f, -2.69516539e-02f,
  1.65025279e-01f, 3.33133698e-01f, 2.90653557e-01f, 1.64205115e-02f, -3.10579330e-01f, 2.49199122e-01f, -7.15107799e-01f, -6.10796869e-01f, 1.87079087e-02f, 6.40280470e-02f,
  -2.98948567e-02f, -2.51208935e-02f, -5.87595940e-01f, -4.47456539e-01f, 2.29645446e-01f, -3.37058246e-01f, -3.71204019e-02f, 2.10877195e-01f, -4.87865925e-01f, -9.70548093e-02f,
  2.02805847e-01f, -5.58268845e-01f, 1.87012240e-01f, -3.46174568e-01f, -3.65186960e-01f, -2.02392161e-01f, 4.47910219e-01f, -1.88599989e-01f, -1.40829995e-01f, 3.11046869e-01f,
  -2.90931255e-01f, 4.73906040e-01f, -3.30017805e-01f, 2.30893731e-01f, 4.20805365e-02f, -4.86710042e-01f, -3.89912635e-01f, 1.25805944e-01f, -4.14282113e-01f, 1.00500911e-01f,
  -2.96822309e-01f, -2.63700068e-01f, -1.81269959e-01f, -1.94982737e-01f, -6.53791800e-02f, 1.74340799e-01f, -3.57856154e-01f, -2.53489226e-01f, 4.20587540e-01f, 4.01143759e-01f,
  -8.21550861e-02f, 1.76885054e-01f, -2.84141272e-01f, 1.31699592e-01f, -3.92189562e-01f, -5.25892973e-01f, 3.71853054e-01f, -1.85181066e-01f, -2.71649152e-01f, 1.10246241e-01f,
  -1.54786825e-01f, 3.02037224e-02f, 2.32818648e-01f, -4.10371870e-01f, -7.62863383e-02f, -1.44366667e-01f, -2.43308753e-01f, -2.89762288e-01f, -2.91474521e-01f, -1.78597242e-01f,
  3.43705043e-02f, -3.28712881e-01f, -2.95795649e-01f, -1.33686423e-01f, -5.73318124e-01f, -3.18992823e-01f, -3.38749327e-02f, 1.94054291e-01f, 5.54554164e-01f, -3.93343747e-01f,
  4.14873719e-01f, -2.06053600e-01f, -2.18215451e-01f, -2.19052643e-01f, -3.00278276e-01f, 2.08004206e-01f, 3.13054994e-02f, -3.72626156e-01f, -2.71146670e-02f, -3.40036243e-01f,
  -2.22552419e-02f, -2.81759240e-02f, -3.46506268e-01f, -1.58884943e-01f, -3.53437066e-01f, 3.27429324e-01f, 2.01052334e-02f, -6.08014204e-02f, -1.08873345e-01f, 2.29715869e-01f,
  -4.74039428e-02f, -1.79658443e-01f, -1.46429464e-01f, -4.72945236e-02f, 1.02738447e-01f, -2.67757446e-01f, 1.47716269e-01f, -1.54299289e-01f, -2.94470936e-01f, -2.17707697e-02f,
  2.64098030e-02f, -2.06341907e-01f, -1.63545102e-01f, -1.49581462e-01f, -1.43231377e-01f, 1.12304837e-01f, -1.73760608e-01f, -9.85273570e-02f, -8.66509527e-02f, 1.29655479e-02f,
  1.42366052e-01f, -2.30429411e-01f, -1.51938096e-01f, 1.67209134e-01f, -2.60429114e-01f, -1.13708721e-02f, -8.61677155e-02f, -6.88202456e-02f, 1.68479923e-02f, -3.34049277e-02f,
  -3.19198340e-01f, 3.95191520e-01f, -1.11429375e-02f, 4.42348793e-02f, 2.33838409e-01f, 3.77889350e-02f, 8.63600969e-02f, -2.92027444e-01f, -8.40240624e-03f, -8.68067890e-02f,
  4.66803759e-01f, -2.67087054e-02f, -1.52413413e-01f, -5.89733012e-02f, -2.51228601e-01f, -1.44170448e-01f, -9.42050964e-02f, -1.43009141e-01f, -1.82609662e-01f, -1.41464576e-01f,
  -3.00265271e-02f, 7.75814354e-02f, 2.93428779e-01f, -8.82515907e-02f, -7.68042281e-02f, -1.44071281e-01f, 2.16422245e-01f, -4.30346608e-01f, -2.80632287e-01f, -5.56987226e-02f,
  -1.98370129e-01f, -1.27533168e-01f, -1.30872250e-01f, -1.23185255e-01f, -1.49969190e-01f, 1.08383030e-01f, -1.51435837e-01f, -2.08405241e-01f, -1.61036998e-01f, -1.37325302e-01f,
  -1.12429082e-01f, 2.32876882e-01f, 2.45380085e-02f, 4.41838652e-02f, -1.26856506e-01f, -2.66565830e-01f, -4.63625379e-02f, -3.22822750e-01f, -2.48410180e-01f, 1.96153149e-02f,
  4.19998556e-01f, 2.66060859e-01f, 3.38415764e-02f, 3.22207004e-01f, -3.99671406e-01f, 2.91335553e-01f, 2.49892414e-01f, 1.20767839e-01f, -1.09884813e-01f, -1.68106422e-01f,
  6.15887977e-02f, 8.49930570e-02f, -1.18762508e-01f, -6.58421144e-02f, -2.20283926e-01f, 1.39421999e-01f, -9.39891022e-03f, 5.08730821e-02f, -9.81721058e-02f, -7.21506923e-02f,
  -3.77448678e-01f, 1.70579463e-01f, -1.54077753e-01f, -3.10578924e-02f, -1.60673872e-01f, -1.17807768e-01f, -7.31680393e-02f, -2.94862658e-01f, -1.42391145e-01f, -2.66322866e-02f,
  -1.25124142e-01f, -5.13462117e-04f, -3.44065905e-01f, -3.84664163e-02f, -2.62497246e-01f, -3.56565326e-01f, -1.97117329e-01f, -7.63421237e-01f, -9.69587639e-02f, -1.84008732e-01f,
  3.93466324e-01f, -1.28462464e-01f, 4.36037220e-02f, -5.74434809e-02f, 7.41581470e-02f, 6.56934083e-01f, -3.58233303e-01f, -9.50739458e-02f, -7.73883387e-02f, -8.98264274e-02f,
  6.07603751e-02f, 3.81147206e-01f, -3.85870524e-02f, 9.80360806e-02f, 5.46732210e-02f, 8.96459818e-02f, 1.22580372e-01f, 1.04683623e-01f, 4.16312367e-02f, -7.63881207e-02f,
  8.57410952e-02f, -8.77075456e-03f, 5.69955260e-02f, 4.84759845e-02f, 1.13214158e-01f, 1.69715613e-01f, -1.02492221e-01f, -8.85955698e-04f, 1.74774408e-01f, -2.86162406e-01f,
  -1.01452239e-01f, 5.20021245e-02f, -1.64912969e-01f, -1.90858200e-01f, 1.62202790e-01f, 2.24877104e-01f, 1.91723153e-01f, 2.83015817e-01f, 1.21825665e-01f, -2.44819403e-01f,
  3.85027260e-01f, -3.34811896e-01f, -1.25830263e-01f, -5.19735813e-02f, 9.74999666e-02f, 2.73076832e-01f, -8.21045414e-02f, -6.69226348e-02f, -1.12258635e-01f, 1.30403012e-01f,
  -2.01605167e-02f, -4.27263409e-01f, 1.85163572e-01f, -1.64143413e-01f, -4.83143806e-01f, -5.83894104e-02f, -7.01980591e-02f, 3.98379624e-01f, 9.67165828e-02f, 2.51869977e-01f,
  -3.25951762e-02f, -1.43077418e-01f, -9.54618603e-02f, -1.87045634e-01f, -3.38166319e-02f, -1.17205463e-01f, -3.89569812e-02f, -2.37962142e-01f, -3.94259125e-01f, 2.69814312e-01f,
  -1.50904551e-01f, 5.60051948e-03f, 5.10824382e-01f, -2.23186806e-01f, -3.42094928e-01f, -2.41717637e-01f, -1.28266290e-01f, -1.53725445e-01f, -2.10334197e-01f, 6.85317591e-02f,
  -2.52744138e-01f, -2.63376594e-01f, -1.04048990e-01f, 2.76251942e-01f, -1.73113585e-01f, -2.81461805e-01f, -2.55318373e-01f, -1.37319505e-01f, -1.81355551e-01f, 4.80729342e-02f,
  -2.68402994e-01f, 1.49051815e-01f, -7.50603974e-02f, 5.53552389e-01f, 1.87568113e-01f, -1.67361394e-01f, -4.31545496e-01f, -3.56152266e-01f, -7.55250826e-02f, -3.00550640e-01f,
  1.97788164e-01f, -2.42798343e-01f, -1.07117712e-01f, 9.97447297e-02f, 2.27838293e-01f, -2.04577227e-03f, -9.35057476e-02f, -1.06435649e-01f, -1.44744748e-02f, -1.37475550e-01f,
  -2.66703010e-01f, -2.95633167e-01f, 1.67186663e-01f, 2.77529269e-01f, -1.76291522e-02f, 4.54364628e-01f, 6.48770988e-01f, -7.73146451e-02f, -3.99178922e-01f, 1.58172354e-01f,
  -2.90589064e-01f, 2.84799188e-01f, -3.46840560e-01f, 1.93381667e-01f, 1.23238787e-01f, -5.96445918e-01f, 2.95142651e-01f, 3.04305375e-01f, -1.49199665e-01f, -2.29192138e-01f,
  -4.53206271e-01f, -1.59335583e-01f, -2.40073740e-01f, -2.31422141e-01f, -2.17897028e-01f, -2.16614053e-01f, 9.98840034e-02f, 4.55207109e-01f, -9.58954319e-02f, -2.35770658e-01f,
  -3.51165473e-01f, -2.35328302e-01f, -1.27403066e-01f, 6.57400116e-02f, 1.88175097e-01f, 2.91275959e-02f, 4.12581563e-02f, -6.83014691e-02f, 1.69762876e-02f, -1.54112980e-01f,
  -6.40909746e-02f, 7.20281452e-02f, -4.87940274e-02f, -4.59117740e-02f, 1.61300078e-01f, -2.05740303e-01f, -2.50435211e-02f, 2.27335751e-01f, -4.16453443e-02f, 5.16905673e-02f,
  2.55065528e-03f, 1.30965337e-01f, -1.46540940e-01f, -1.40533820e-01f, -3.29554707e-01f, -3.01942468e-01f, 9.57040116e-02f, 6.64113089e-02f, -3.10482889e-01f, 3.24278921e-01f,
  4.46722209e-01f, 5.98348081e-01f, -1.03533365e-01f, -4.16509300e-01f, 4.54092413e-01f, 1.35558918e-01f, 1.70467451e-01f, 1.02618165e-01f, -3.20240438e-01f, 1.83536232e-01f,
  -2.58293539e-01f, 7.24010989e-02f, -5.21758139e-01f, -2.75211751e-01f, 9.23571642e-03f, -2.97826111e-01f, 1.15726992e-01f, 1.44064026e-02f, -2.62676150e-01f, 6.23118989e-02f,
  -7.08572716e-02f, -3.02985519e-01f, -7.12977126e-02f, -2.70975847e-02f, 7.30120540e-02f, 1.11754149e-01f, -1.11084819e-01f, -2.29705393e-01f, -1.89825773e-01f, 5.75911224e-01f,
  2.23045692e-01f, 3.17561299e-01f, 4.91188586e-01f, 3.55759382e-01f, -5.63046157e-01f, -5.31234801e-01f, 3.52363795e-01f, -1.70511097e-01f, -1.23098204e-02f, -4.56200510e-01f,
  -1.96737632e-01f, -3.42323184e-01f, -1.41220270e-02f, 2.87412137e-01f, -3.40343177e-01f, -6.07644379e-01f, -6.68455139e-02f, 3.64980906e-01f, 9.02588591e-02f, 3.33772868e-01f,
  1.67899057e-01f, -2.25027829e-01f, 1.21931732e-02f, 2.67159820e-01f, 1.64794132e-01f, -4.16390270e-01f, 1.44512355e-01f, -2.41348371e-01f, -5.08604705e-01f, -2.06236944e-01f,
  8.16065818e-02f, 6.46258220e-02f, -2.46061653e-01f, -3.30987014e-02f, 2.24777274e-02f, 5.40159702e-01f, 5.06773651e-01f, -6.18496418e-01f, 5.08766830e-01f, -2.26554036e-01f,
  -8.54375772e-03f, 2.75911421e-01f, 2.09483758e-01f, -1.56407639e-01f, -3.41519356e-01f, -2.87615776e-01f, -8.61723498e-02f, -3.78319204e-01f, -1.95994616e-01f, -3.87028009e-01f,
  -2.16532797e-01f, -9.57946926e-02f, -1.27599806e-01f, 1.35850711e-02f, -1.14965819e-01f, 3.35503146e-02f, 1.80312142e-01f, 1.23553365e-01f, 9.85900313e-02f, -2.43690819e-01f,
  -2.22404778e-01f, -4.78172332e-01f, -4.78836484e-02f, -1.59038842e-01f, -1.68420628e-01f, -2.34242737e-01f, -1.45611388e-03f, -4.19888496e-01f, 1.55821284e-02f, 5.96240833e-02f,
  -6.09205998e-02f, 9.88241062e-02f, 6.53861314e-02f, 8.37473869e-02f, -5.60664125e-02f, -3.57590802e-02f, -1.36984557e-01f, 9.36721265e-02f, 6.12408184e-02f, 1.45582072e-02f,
  2.58099269e-02f, 1.06342830e-01f, -2.14717612e-01f, 2.01274619e-01f, -1.20774351e-01f, -6.11923970e-02f, -2.01802582e-01f, -1.33575976e-01f, 2.06785500e-01f, -1.33057281e-01f,
  2.04057500e-01f, 2.58852839e-01f, -3.03601604e-02f, -1.67195812e-01f, 3.22039425e-03f, -1.02721944e-01f, -9.27241221e-02f, -1.45750269e-01f, -4.60184634e-01f, -7.53006339e-02f,
  -2.09460542e-01f, -3.08661652e-03f, 1.63372472e-01f, -4.40543652e-01f, -5.87204099e-02f, -1.16248161e-01f, -2.70569399e-02f, -1.63082480e-01f, -2.05067307e-01f, -9.38036740e-02f,
  8.66129696e-02f, -2.44811967e-01f, -1.52155682e-01f, -1.73419937e-01f, -4.75566387e-02f, -5.82924709e-02f, -2.98520178e-01f, -3.74211133e-01f, -2.30872422e-01f, 4.76597901e-03f,
  -5.68604767e-02f, -2.77885050e-01f, -1.67240694e-01f, -1.22689225e-01f, -3.46884012e-01f, -3.64367485e-01f, -2.11916029e-01f, -1.31139442e-01f, 3.23662930e-03f, -9.98556539e-02f,
  -2.22318098e-01f, -1.92915127e-01f, -1.27512738e-01f, -2.82280773e-01f, 1.04244277e-01f, 2.88522214e-01f, 2.12440699e-01f, 4.56805378e-02f, -2.81950921e-01f, 3.31692070e-01f,
  -3.98199737e-01f, -5.00429571e-02f, 3.79541904e-01f, -3.04001331e-01f, -8.59043300e-02f, -5.57072349e-02f, 3.02627254e-02f, -1.77517340e-01f, 1.28789842e-01f, 2.13042200e-01f,
  2.76089944e-02f, -2.09754229e-01f, -7.22229630e-02f, 3.84910792e-01f, -8.58898759e-02f, 2.14510292e-01f, 3.86444360e-01f, 2.65628368e-01f, -3.43728036e-01f, 1.45761162e-01f,
  -1.14508875e-01f, -3.37720811e-01f, 2.56725460e-01f, 6.21501267e-01f, -2.37491593e-01f, -1.71382010e-01f, 1.74504116e-01f, -1.54333383e-01f, 6.19720444e-02f, -1.37333378e-01f,
  -6.51065111e-02f, -2.17376113e-01f, -1.50117755e-01f, -2.59187847e-01f, -4.32989985e-01f, -3.42855662e-01f, 6.32146280e-03f, -2.96025425e-01f, 5.80195844e-01f, -1.53044850e-01f,
  -1.14423260e-01f, -3.13054591e-01f, 3.40707868e-01f, 9.86700356e-02f, -3.32483649e-01f, -1.11566819e-01f, 2.26650447e-01f, -6.66311532e-02f, -1.77781135e-01f, 3.42267364e-01f,
  -1.97588727e-01f, -4.82411683e-01f, 3.20053667e-01f, 1.57635018e-01f, -6.69671819e-02f, -1.78980857e-01f, -1.05334111e-01f, 3.96509171e-01f, 1.24632582e-01f, -1.21871203e-01f,
  6.49870606e-03f, -1.06479868e-01f, -3.13882008e-02f, 8.37341622e-02f, -3.18419561e-02f, -3.01082227e-02f, 4.35667671e-03f, -3.60143464e-03f, 4.65440266e-02f, -1.75221309e-01f,
  6.43574968e-02f, -1.94273084e-01f, 1.11579783e-01f, -1.62926301e-01f, 3.29983123e-02f, 3.17179714e-04f, -1.90966800e-02f, -1.32839024e-01f, 2.63128560e-02f, 1.60809830e-01f,
  -2.82805301e-02f, 1.34396389e-01f, 2.17516676e-01f, -1.34604305e-01f, 1.96919516e-01f, -4.14932936e-01f, 4.69132178e-02f, 1.41978249e-01f, -4.49866988e-02f, -2.95020968e-01f,
  -2.16569692e-01f, -1.60583019e-01f, -3.48225653e-01f, 6.16746731e-02f, 4.21480030e-01f, -1.41317710e-01f, 4.91572946e-01f, 1.61903992e-01f, -2.85514802e-01f, -1.68368101e-01f,
  -4.40911874e-02f, 5.04643500e-01f, -1.89931363e-01f, -8.39629471e-02f, -3.96834195e-01f, -4.64985184e-02f, -1.95470944e-01f, -3.18110571e-03f, 2.19826788e-01f, -3.42585593e-01f,
  -5.17899543e-02f, -7.56796896e-02f, 3.35507363e-01f, 2.37315625e-01f, 4.72070903e-01f, -2.52263069e-01f, -1.33316666e-01f, -1.98408291e-01f, -1.94693729e-01f, 1.28891394e-01f,
  -1.45731688e-01f, -9.05837715e-02f, -1.06834337e-01f, 5.74203357e-02f, -1.85140282e-01f, -4.18122485e-02f, -1.74658690e-02f, -1.59714684e-01f, -2.44079590e-01f, 3.56494308e-01f,
  -9.43888873e-02f, -1.08025879e-01f, 1.03363156e-01f, -4.07730162e-01f, 1.42852843e-01f, 1.10512465e-01f, -1.37273848e-01f, -4.08718556e-01f, -3.92084271e-01f, 2.99415320e-01f,
  -1.57303378e-01f, -1.79591253e-01f, -4.11254555e-01f, 1.46414191e-01f, -1.79978013e-01f, -3.85181308e-02f, -1.61065608e-01f, -1.45836741e-01f, 2.71969706e-01f, -2.66092718e-01f,
  -2.20896155e-01f, 1.84457079e-02f, 1.57455593e-01f, 4.66958940e-01f, -1.57009020e-01f, -2.24417657e-01f, -2.66126037e-01f, -3.16685766e-01f, -3.87067646e-01f, -1.93021536e-01f,
  -5.41602001e-02f, -2.97551006e-01f, -2.88601220e-01f, 1.58558339e-01f, 5.43105185e-01f, 1.29111707e-01f, 7.83803985e-02f, -3.50306451e-01f, 2.93232828e-01f, -1.77192733e-01f,
  -2.10377961e-01f, -4.78703417e-02f, -4.34571296e-01f, 2.26105347e-01f, -2.80962765e-01f, 1.37706473e-01f, -4.64697331e-02f, -3.79538566e-01f, -3.95226091e-01f, 1.57964468e-01f,
  4.18163426e-02f, -2.81722490e-02f, -1.01137355e-01f, -1.09173566e-01f, 4.65840936e-01f, -2.53289998e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.73199207e-01f, 1.34204045e-01f, 1.49836630e-01f, -1.35181202e-02f, -1.80631429e-01f, 5.62011562e-02f, -6.45103678e-02f, -1.95793062e-02f, 5.08317817e-03f, -2.26776786e-02f,
  7.87727162e-02f, 6.56368732e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    