/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.10683048e-01f, -1.83988959e-01f, 2.68936008e-01f, -2.18730941e-02f, -7.36132488e-02f, 1.19788513e-01f, 8.31123888e-02f, 6.06012456e-02f, -6.79808855e-02f, 2.08774842e-02f,
  -1.72377691e-01f, -1.81464329e-01f, -1.07161026e-03f, -8.46591964e-02f, 8.46376494e-02f, 2.80828159e-02f, 1.70742571e-01f, 1.51303574e-01f, 2.32279465e-01f, 6.19510945e-04f,
  -2.62444951e-02f, 7.34690726e-02f, 1.40161291e-01f, -3.45269442e-02f, 5.75087443e-02f, -8.29897299e-02f, 2.80721523e-02f, -8.42374563e-03f, -1.16964281e-01f, 4.52635735e-02f,
  6.78418428e-02f, 2.26122104e-02f, 2.94502415e-02f, -7.05706999e-02f, -2.16709971e-02f, 7.90642276e-02f, -2.51684990e-03f, 9.68669802e-02f, 4.02523726e-02f, -2.42212545e-02f,
  -5.92002347e-02f, -9.46034417e-02f, -2.79842746e-02f, 2.28467807e-02f, -2.23886222e-03f, 6.56134859e-02f, -1.85866226e-02f, 8.61487538e-02f, 1.14826433e-01f, -6.35477528e-02f,
  -1.29766196e-01f, -7.42793679e-02f, 1.10480018e-01f, 8.93035978e-02f, 1.65827610e-02f, -4.30467911e-02f, -4.94398475e-02f, 1.78043190e-02f, 7.09903091e-02f, 4.38741520e-02f,
  -2.49293484e-02f, 4.20130603e-02f, 4.25378978e-02f, 9.95349884e-03f, -4.29433100e-02f, -2.11526435e-02f, -7.71715026e-03f, -1.78736970e-02f, -7.88031444e-02f, -6.99172392e-02f,
  9.46740620e-03f, 9.12103355e-02f, -2.83444580e-02f, 4.86290492e-02f, 4.81435936e-03f, 4.10870686e-02f, -5.16861118e-02f, -4.92316671e-02f, 1.03034917e-02f, 4.35770154e-02f,
  4.20311429e-02f, 6.97782412e-02f, -2.05507092e-02f, 2.96309832e-02f, -2.83076689e-02f, 2.73477249e-02f, 2.40659788e-02f, -8.82152542e-02f, 3.06363450e-03f, 8.32851417e-03f,
  -6.07455820e-02f, 2.14161053e-02f, 2.14891136e-03f, -2.30550300e-02f, 2.06177514e-02f, -2.99420673e-02f, -7.48130530e-02f, -6.42927215e-02f, -5.74159697e-02f, -7.72059709e-02f,
  3.56039852e-02f, -1.73948414e-03f, -2.60886867e-02f, 9.81935635e-02f, 4.56679277e-02f, 9.28054899e-02f, -1.32815033e-01f, -3.47970016e-02f, -3.53279635e-02f, -2.02202927e-02f,
  -1.97555758e-02f, -5.79732470e-02f, -4.85531017e-02f, 3.64817269e-02f, -4.46213558e-02f, -7.14924335e-02f, 5.39476573e-02f, 3.88138724e-04f, -2.29907800e-02f, 6.65650293e-02f,
  -1.41331209e-02f, -1.60396338e-01f, -2.17465281e-01f, 9.33289379e-02f, -9.02513694e-03f, -5.37611619e-02f, 2.24233810e-02f, -4.37808447e-02f, 1.43154472e-01f, 5.48273697e-02f,
  3.77807841e-02f, 1.53875098e-01f, 9.18658674e-02f, 2.55285706e-02f, -7.67670944e-02f, -2.00378075e-02f, -4.53202687e-02f, 3.34367678e-02f, -5.31446412e-02f, 2.13748030e-02f,
  1.63284525e-01f, 7.25029185e-02f, 3.06671355e-02f, 1.29724983e-02f, 1.01825364e-01f, 8.81758034e-02f, 3.37506586e-04f, 3.02997064e-02f, 6.16330132e-02f, 1.87146831e-02f,
  -1.23101011e-01f, -7.25550056e-02f, -3.10619269e-02f, 6.35564625e-02f, -6.18656985e-02f, -4.89112176e-02f, 6.29974082e-02f, -8.97257403e-02f, 9.18470770e-02f, -1.17950402e-02f,
  -7.88175873e-03f, -2.91688717e-03f, 4.76715639e-02f, 6.04507178e-02f, -2.10468210e-02f, -6.38868064e-02f, -1.13976374e-02f, 4.35180999e-02f, -7.72839040e-02f, -6.66966885e-02f,
  8.17752555e-02f, 6.50622919e-02f, -4.89893034e-02f, 2.50471365e-02f, 7.30747450e-03f, 9.65295956e-02f, 6.95627695e-03f, -8.84829015e-02f, -3.71770635e-02f, -5.51048443e-02f,
  4.01202701e-02f, -3.86463245e-03f, 9.40888561e-03f, -4.64813188e-02f, 1.87912472e-02f, -8.08867719e-03f, 2.01315302e-02f, 2.84700766e-02f, -6.98948205e-02f, 7.30676278e-02f,
  -1.85312107e-02f, -8.33196193e-02f, 6.40684217e-02f, -8.54315311e-02f, -1.98008604e-02f, 5.78400530e-02f, 2.95860339e-02f, -3.69469114e-02f, 3.32320742e-02f, 9.46953744e-02f,
  1.07279524e-01f, -9.71534252e-02f, 2.18503699e-02f, -5.79431504e-02f, 1.28226839e-02f, -4.77098301e-02f, -5.76069355e-02f, -3.72278467e-02f, -4.01149616e-02f, 1.16133355e-02f,
  1.33128390e-01f, -5.20414934e-02f, 1.70016568e-02f, 6.65344223e-02f, 1.25239313e-01f, 4.83547114e-02f, -2.72101630e-02f, -7.16727898e-02f, 2.96941511e-02f, -7.24272430e-02f,
  -3.58152762e-02f, 3.75119075e-02f, -7.73523077e-02f, -4.53003347e-02f, -7.32324868e-02f, -6.09529801e-02f, 6.77438267e-03f, 5.57131357e-02f, 3.07619330e-02f, -7.26040304e-02f,
  1.00890897e-01f, -4.21266705e-02f, 1.05276160e-01f, -1.60899907e-02f, 3.36086843e-03f, 8.46260563e-02f, 3.19481990e-03f, -3.13326418e-02f, 9.15160626e-02f, -2.56131347e-02f,
  1.42704874e-01f, -4.82455269e-02f, 1.83588013e-01f, 8.94166604e-02f, 2.40408525e-01f, 9.68275592e-02f, 1.80336744e-01f, -2.92238384e-03f, 3.26950327e-02f, 6.00348897e-02f,
  -1.43430158e-02f, -8.43737945e-02f, -3.23862247e-02f, -8.88486505e-02f, 1.21376235e-02f, 1.01595230e-01f, 2.15526685e-01f, 1.29685372e-01f, 1.85896248e-01f, 3.29925381e-02f,
  1.08355120e-01f, 2.09449098e-01f, 1.30517200e-01f, 8.99088904e-02f, 1.05848588e-01f, 2.71838661e-02f, 1.23740174e-01f, 2.78086774e-02f, 8.77605230e-02f, 1.38198510e-01f,
  8.96483064e-02f, 1.60096794e-01f, -5.17796427e-02f, -5.31789809e-02f, -2.91442610e-02f, 1.59694757e-02f, 4.73948941e-03f, -3.20195556e-02f, -5.13931662e-02f, -8.96021351e-03f,
  -3.03406417e-02f, 2.67016292e-02f, 9.56997871e-02f, 2.03796737e-02f, 9.63184088e-02f, 5.00587448e-02f, 8.72989185e-03f, -2.40512304e-02f, 7.28353206e-03f, -8.88882875e-02f,
  -8.29069316e-02f, 3.63931991e-02f, 5.77489138e-02f, -5.01504838e-02f, 7.44361877e-02f, 3.93513665e-02f, -4.46798541e-02f, -5.81701696e-02f, -5.51916286e-03f, -1.37701377e-01f,
  3.12530026e-02f, 4.51950543e-02f, -2.57236119e-02f, -1.27822146e-01f, -9.94164962e-03f, -2.12232750e-02f, -3.99458259e-02f, -2.10775156e-02f, 3.70491296e-02f, -4.33721505e-02f,
  -9.73392129e-02f, 2.50425935e-02f, -4.53943945e-02f, 1.78513974e-02f, -5.41938236e-03f, 4.61890996e-02f, -8.82604420e-02f, -5.30984849e-02f, -2.68045068e-02f, -5.60717210e-02f,
  6.45426139e-02f, -6.35280982e-02f, 4.91992161e-02f, -5.71708009e-02f, -5.32811657e-02f, 5.44204339e-02f, 1.40368305e-02f, -3.17271391e-04f, 8.92762989e-02f, -2.80372035e-02f,
  9.83180702e-02f, -1.56799182e-02f, -3.37802689e-03f, -2.22559064e-03f, 2.53002923e-02f, -5.03799357e-02f, -6.98753260e-03f, -8.49427946e-04f, 3.93307917e-02f, -1.19694117e-02f,
  -4.61981818e-02f, 1.84463225e-02f, -3.14676501e-02f, 1.49193211e-02f, -5.84869124e-02f, 1.60223376e-02f, -7.28762522e-02f, 1.16432402e-02f, -8.47864300e-02f, -9.33888480e-02f,
  8.48189276e-03f, -4.91414331e-02f, -2.57847104e-02f, -1.20340330e-04f, -9.22752321e-02f, 4.36042845e-02f, -2.10426170e-02f, -6.14986382e-02f, -1.15410276e-02f, -1.08148962e-01f,
  1.89809889e-01f, -1.13992088e-01f, -1.61102846e-01f, 4.06033210e-02f, -1.93282470e-01f, -1.54651836e-01f, -2.11620390e-01f, -4.68349695e-04f, 1.12132423e-01f, 3.13676223e-02f,
  -6.36578202e-02f, 6.62805811e-02f, 5.47228381e-02f, 1.45010307e-01f, 1.25820071e-01f, -4.12172191e-02f, 8.20421427e-02f, 5.21372743e-02f, 2.35417068e-01f, 3.12711373e-02f,
  1.11976869e-01f, 1.52497426e-01f, 1.63966641e-01f, 1.22297451e-01f, -9.52427462e-02f, 5.29440306e-02f, -4.91676666e-02f, -1.49515033e-01f, -5.65712377e-02f, -3.25232372e-02f,
  -6.60950243e-02f, -1.79636538e-01f, 5.04926257e-02f, 1.20532198e-03f, -5.12424409e-02f, 3.92265292e-03f, 4.40942161e-02f, -6.25878107e-04f, -2.15742029e-02f, 1.19583413e-01f,
  -2.68322621e-02f, 6.71906620e-02f, 5.17832488e-02f, -2.02286504e-02f, -4.40064296e-02f, 4.13940698e-02f, -1.17131183e-02f, 2.31308565e-02f, -1.31176156e-03f, 3.66350566e-03f,
  7.06681376e-03f, -2.05907539e-01f, -1.46909982e-01f, -4.82092761e-02f, -4.55350243e-02f, 1.17882963e-04f, -7.27283210e-02f, -8.46407469e-03f, -1.27888843e-01f, 1.34035908e-02f,
  -1.65091176e-02f, 7.05174431e-02f, -7.23032206e-02f, 7.36690639e-03f, -2.96711642e-03f, -6.92536216e-03f, -2.23974772e-02f, 2.50687748e-02f, -1.73910260e-02f, -2.17780080e-02f,
  -6.97209612e-02f, -3.21802869e-02f, 4.41874489e-02f, -5.88977104e-03f, 3.51646319e-02f, -1.03603102e-01f, -5.68570271e-02f, -3.38389054e-02f, 3.93875614e-02f, -8.82856622e-02f,
  1.05013198e-03f, 4.45644520e-02f, -1.49817253e-02f, 6.26888126e-02f, -1.00250803e-01f, -5.73616549e-02f, -6.87422231e-02f, 1.17972344e-02f, 8.35497212e-03f, 1.05669387e-02f,
  2.42021784e-01f, -7.75771439e-02f, 1.49732962e-01f, 2.79722344e-02f, 3.99163105e-02f, -1.54286167e-02f, -4.85277250e-02f, 2.45111287e-02f, 1.95235815e-02f, 6.53152168e-02f,
  6.35823831e-02f, 2.40676850e-02f, -3.29946093e-02f, -2.60637072e-03f, 1.01838727e-02f, 2.75098067e-02f, -2.92010177e-02f, -7.65591338e-02f, -2.37967670e-02f, 3.76069583e-02f,
  1.16010778e-01f, 9.36914980e-02f, 1.11740164e-01f, 1.06083341e-01f, 6.67582750e-02f, 1.79825369e-02f, 7.17747584e-02f, 2.39173025e-02f, 1.05791651e-01f, 2.18594015e-01f,
  6.23470023e-02f, -8.38811323e-02f, 1.24093644e-01f, -4.17041034e-03f, -2.66029257e-02f, 1.08172059e-01f, 1.97428297e-02f, 3.26927602e-02f, -6.90149143e-02f, 2.60586217e-02f,
  1.44034661e-02f, -9.58581343e-02f, -5.49967922e-02f, 4.45828820e-03f, 1.09532513e-01f, 9.57462471e-03f, -5.83773740e-02f, 1.23321712e-01f, 1.12879917e-01f, 1.23077936e-01f,
  3.88186835e-02f, 9.53872781e-03f, 1.44911200e-01f, 5.04384823e-02f, 4.55260044e-03f, -8.01796168e-02f, -3.66364978e-02f, 7.55282491e-02f, 9.93707702e-02f, -6.27420545e-02f,
  -2.53094025e-02f, 1.26211077e-01f, 8.40886235e-02f, -9.85455513e-02f, 5.17070107e-02f, -8.97463504e-03f, -2.86506359e-02f, 5.67427203e-02f, 3.77288647e-02f, -4.46260609e-02f,
  -2.87418049e-02f, -4.18769307e-02f, -2.38107909e-02f, 2.40392145e-03f, -4.06106822e-02f, 9.71744070e-04f, 6.41629398e-02f, 7.50581175e-02f, 1.07966132e-01f, 7.50886574e-02f,
  -1.25685064e-02f, 2.45691724e-02f, 7.33069256e-02f, 1.15519352e-01f, 7.62351230e-03f, 1.60478856e-02f, 1.45651489e-01f, 1.20320722e-01f, 7.02224448e-02f, -1.10192671e-01f,
  -5.40502220e-02f, 2.66903322e-02f, 2.69328561e-02f, 4.05790992e-02f, -6.32137656e-02f, -6.58834279e-02f, -3.46940346e-02f, 4.96620387e-02f, -4.20014821e-02f, 1.34195490e-02f,
  2.57080588e-02f, -2.96267718e-02f, 1.49754283e-03f, -3.48882303e-02f, -3.90266366e-02f, -2.68586446e-02f, -2.45797671e-02f, -4.51592132e-02f, -4.19206396e-02f, -5.71281873e-02f,
  2.70888209e-02f, 6.03932999e-02f, -2.93567199e-02f, -2.54781153e-02f, 3.72070707e-02f, 4.60545011e-02f, 2.99103931e-02f, 2.46677287e-02f, 5.65221719e-02f, 8.63086358e-02f,
  -2.14168921e-01f, 1.34185657e-01f, -5.99030592e-02f, -8.30890704e-03f, -1.68424230e-02f, -5.78906052e-02f, -4.14608605e-02f, 4.45601391e-03f, 1.51976219e-05f, 7.64189567e-03f,
  4.09629457e-02f, -6.41287342e-02f, -3.64664709e-03f, -3.40124778e-02f, 6.69614747e-02f, -1.18471555e-01f, -1.01154476e-01f, 5.17947078e-02f, 5.18493392e-02f, 3.38921323e-02f,
  -5.92042804e-02f, -6.27605543e-02f, -7.31927380e-02f, -4.73034494e-02f, -3.20642665e-02f, -5.80195412e-02f, -1.04353026e-01f, -7.32902288e-02f, 5.05777672e-02f, -2.81925559e-01f,
  1.99170321e-01f, -1.26910672e-01f, -2.02219859e-02f, 2.05449209e-01f, -9.87477154e-02f, -8.03468972e-02f, -2.60300100e-01f, 1.27227217e-01f, 1.34823561e-01f, -1.84612587e-01f,
  -4.17515188e-02f, 1.63507257e-02f, 1.33537918e-01f, 1.49204940e-01f, 9.49716866e-02f, -1.31853223e-01f, -1.19385906e-01f, 9.41260979e-02f, 1.23385265e-01f, 4.30571996e-02f,
  -1.82520337e-02f, 2.15376262e-02f, 2.17343837e-01f, 1.79406092e-01f, -1.00490957e-01f, 2.45567560e-02f, -7.49800056e-02f, -1.43248618e-01f, -1.50819212e-01f, -2.46021956e-01f,
  -1.62236989e-01f, 2.98462529e-02f, 1.05821058e-01f, 9.97884870e-02f, -9.86330733e-02f, 4.65020351e-02f, 2.98986118e-02f, -8.12818334e-02f, 5.14946952e-02f, 2.33990848e-02f,
  -7.77252913e-02f, 4.45183320e-03f, 6.29065931e-02f, -9.59396213e-02f, 1.25956777e-02f, -9.27806571e-02f, 1.01067242e-03f, 2.96123885e-02f, -1.87683087e-02f, -5.37882112e-02f,
  -1.44136762e-02f, -1.11605532e-01f, -7.21986890e-02f, -8.64005759e-02f, 4.27711196e-02f, 2.26216670e-02f, -1.22330695e-01f, -8.66564661e-02f, 6.90212920e-02f, -1.21076889e-01f,
  2.83348672e-02f, -3.17410864e-02f, -9.20728687e-03f, -3.39309126e-02f, 5.80080003e-02f, -5.66081470e-03f, -5.46473078e-02f, 2.02322030e-03f, -2.30686348e-02f, 5.30243181e-02f,
  3.36876288e-02f, -7.91340508e-03f, -8.77475250e-04f, -2.94759497e-02f, 6.40623420e-02f, 1.55188600e-02f, -5.72602004e-02f, 8.46788585e-02f, -7.38876015e-02f, 8.37148726e-02f,
  9.37534273e-02f, -8.93667042e-02f, 2.04636604e-02f, -3.96330804e-02f, -8.36852267e-02f, 4.08388823e-02f, 5.73560819e-02f, -9.03868116e-03f, -1.77801810e-02f, 2.52360329e-02f,
  8.51368159e-02f, 1.13901541e-01f, 6.09802408e-03f, -2.45995577e-02f, -5.86513579e-02f, -2.91051324e-02f, -4.94019315e-02f, 5.47282882e-02f, -8.50438420e-03f, 4.16732542e-02f,
  -3.12814899e-02f, 1.72386710e-02f, -5.05313650e-02f, -4.48026881e-03f, -1.39631676e-02f, 1.92556658e-03f, -3.45795974e-02f, 3.27927209e-02f, 1.29255220e-01f, 6.21046573e-02f,
  2.02603359e-02f, 1.13164391e-02f, 2.52627190e-02f, -5.88667020e-02f, -8.17899033e-02f, 4.15648781e-02f, -1.39923632e-01f, -6.91774348e-03f, 1.08008727e-01f, 6.95319027e-02f,
  -2.38995880e-01f, 9.28652734e-02f, 2.09075555e-01f, -8.38594884e-02f, 2.00927824e-01f, 1.86158374e-01f, 3.71892422e-01f, 2.41464097e-02f, -1.86792821e-01f, 5.21333106e-02f,
  -2.78895777e-02f, -2.33431593e-01f, -1.23401672e-01f, -4.44855839e-02f, -2.91647352e-02f, 2.17584506e-01f, 2.03002498e-01f, -4.58319709e-02f, -1.49718970e-01f, 1.70343164e-02f,
  5.95986135e-02f, -1.44604862e-01f, -1.09296300e-01f, -1.84045538e-01f, -2.12718528e-02f, -9.65210050e-02f, 9.00294036e-02f, -5.89284464e-04f, 9.50021818e-02f, 1.73045069e-01f,
  5.14041185e-02f, 2.65927501e-02f, -1.57600839e-03f, -1.25893936e-01f, -8.42142850e-02f, -4.65617813e-02f, 5.69808781e-02f, -5.33978902e-02f, -4.46446659e-03f, 3.78388241e-02f,
  -4.17283624e-02f, 2.98552141e-02f, 5.44203119e-03f, -2.51672845e-02f, 6.98906332e-02f, 3.26965973e-02f, 1.60241425e-02f, 1.99471917e-02f, 8.34823865e-03f, 9.83974710e-02f,
  -1.83135476e-02f, 4.25826237e-02f, 6.94779083e-02f, -1.46662490e-02f, -7.45710954e-02f, -1.58962309e-02f, 4.21159267e-02f, 1.06218725e-03f, -2.46616919e-02f, 1.92068366e-03f,
  -2.57820785e-02f, -2.48817727e-03f, 6.21882966e-03f, -2.03411058e-02f, -1.05501130e-01f, 1.86784267e-02f, 2.44999267e-02f, 8.00828449e-03f, -4.33567539e-02f, 7.55662844e-02f,
  -2.85587944e-02f, 3.85686532e-02f, -3.39745097e-02f, 4.42204066e-02f, 1.08345272e-03f, 2.06678510e-02f, -2.52029765e-02f, -3.85085400e-03f, 1.92593120e-03f, -1.33140041e-02f,
  -8.48391280e-02f, 3.04794014e-02f, 2.43320893e-02f, 1.23283239e-02f, -4.56946902e-02f, 3.12969945e-02f, -4.29155789e-02f, -2.90471483e-02f, 1.65394861e-02f, -1.52585208e-02f,
  -1.82036117e-01f, 1.39508061e-02f, 4.28734533e-02f, -4.25054356e-02f, 2.30194684e-02f, -2.63642203e-02f, -6.79492280e-02f, -5.21115810e-02f, 8.63528252e-02f, 5.48221841e-02f,
  1.43153395e-03f, -1.28105711e-02f, 7.57566234e-03f, 5.76613545e-02f, -2.61177067e-02f, -6.01758175e-02f, 1.47410864e-02f, -5.32292798e-02f, 4.21966538e-02f, -4.57194820e-02f,
  1.09006695e-01f, -8.13198984e-02f, -7.93958083e-02f, -3.59133035e-02f, -4.41979989e-02f, -1.44050077e-01f, -1.27082346e-02f, 2.93446444e-02f, -8.67429152e-02f, 3.75764109e-02f,
  -3.78358543e-01f, -7.27807432e-02f, 7.78210759e-02f, -8.91557261e-02f, 1.03381217e-01f, 2.44693130e-01f, 1.40116990e-01f, 5.27322777e-02f, 6.35849871e-03f, -2.27731541e-02f,
  -2.74804272e-02f, 1.37238558e-02f, 1.11253038e-01f, -5.15337149e-03f, 4.84316051e-02f, 7.59716006e-03f, 8.02160054e-02f, -7.65703665e-03f, 9.40448344e-02f, -9.70246270e-03f,
  -7.73160718e-03f, -1.41100824e-01f, -6.17170557e-02f, -1.14978038e-01f, -4.09691036e-02f, -9.20233577e-02f, 3.88135500e-02f, -6.31783754e-02f, 4.87939790e-02f, -1.30219489e-01f,
  -4.34360206e-02f, 4.08472493e-02f, 1.33092836e-01f, -1.00024059e-01f, 1.50004085e-02f, -9.61783435e-03f, -5.83098382e-02f, -5.06215030e-03f, -9.43711400e-02f, -1.19007062e-02f,
  5.47613986e-02f, 4.71136607e-02f, 6.08887225e-02f, 8.43980610e-02f, 2.33794712e-02f, 3.38693224e-02f, -2.97435485e-02f, -2.71516275e-02f, -8.60238448e-02f, -4.56224829e-02f,
  7.55667128e-03f, -2.34018196e-03f, 1.37517542e-01f, 9.20755416e-02f, 8.39158222e-02f, -8.19096994e-03f, 1.50115833e-01f, 2.30261628e-02f, 5.46402819e-02f, -1.31515235e-01f,
  5.15111126e-02f, 4.05904129e-02f, 2.90770177e-02f, -5.77533804e-02f, 4.65148091e-02f, 1.83393545e-02f, 1.07288837e-01f, 3.47986110e-02f, -3.88865694e-02f, 6.59059733e-03f,
  5.27653135e-02f, -4.47354205e-02f, 9.52010974e-02f, -1.88882314e-02f, 1.97955612e-02f, -2.52180062e-02f, 1.02047637e-01f, 6.53176336e-03f, 9.84888524e-02f, -7.37576038e-02f,
  -8.00489914e-03f, 5.37492819e-02f, -1.15276001e-01f, -1.49278576e-02f, -5.44438735e-02f, 2.84107942e-02f, 1.32184681e-02f, 6.33940846e-02f, -8.12337101e-02f, -9.63916555e-02f,
  1.13964323e-02f, 2.15244278e-01f, -8.06135014e-02f, -4.40947302e-02f, -3.24952155e-02f, 5.29333367e-04f, -7.00098202e-02f, 3.32383486e-03f, -4.37567458e-02f, -1.48317004e-02f,
  8.19297209e-02f, -6.12604152e-03f, -4.51694801e-02f, -2.81401649e-02f, 4.84957136e-02f, -5.70556447e-02f, 2.32185921e-04f, -3.90135427e-03f, 1.60693638e-02f, -3.41429412e-02f,
  -7.62411505e-02f, -5.36272377e-02f, -2.89283488e-02f, -3.01697124e-02f, 8.56224969e-02f, 1.65867165e-01f, 3.48215289e-02f, 7.80910626e-02f, 1.65867493e-01f, -6.82749227e-02f,
  6.53825775e-02f, 5.50089311e-03f, 2.81804532e-01f, 1.81432273e-02f, -5.29626980e-02f, -1.26843244e-01f, -2.81484157e-01f, -1.50595114e-01f, -1.31967634e-01f, -4.46169898e-02f,
  -4.34544981e-02f, -1.81964532e-01f, -8.61184597e-02f, 1.97931961e-03f, -2.32024044e-02f, -3.30231003e-02f, 1.43636495e-01f, 2.18523294e-01f, -5.70475496e-02f, -1.64181381e-01f,
  -1.40747309e-01f, 6.48746490e-02f, 2.76308000e-01f, 1.19300246e-01f, -3.60200703e-02f, -8.85434225e-02f, 4.95292097e-02f, 1.06699325e-01f, 7.24780606e-03f, 9.06918719e-02f,
  2.67719310e-02f, 1.93726018e-01f, -1.42296618e-02f, -1.88871622e-02f, 9.39209461e-02f, -8.07681605e-02f, -6.71309233e-02f, 6.30557090e-02f, 2.31329165e-02f, 1.23286629e-02f,
  6.61919042e-02f, -2.92850193e-02f, 2.49070227e-02f, 7.93415606e-02f, -5.57575971e-02f, -2.13083886e-02f, 1.63047567e-01f, 1.95288032e-01f, 1.21961191e-01f, 4.12981249e-02f,
  1.28601156e-02f, -5.10257808e-03f, 9.68924239e-02f, 5.84999584e-02f, 1.02750994e-01f, -7.40403980e-02f, 2.89646275e-02f, 1.16583351e-02f, 5.54648750e-02f, -2.04884307e-03f,
  -4.30973954e-02f, 4.40166593e-02f, 6.86432645e-02f, -6.65613487e-02f, 4.31046002e-02f, 2.94399895e-02f, 1.30739123e-01f, -3.78007367e-02f, -1.25383183e-01f, 2.73595843e-03f,
  3.56441177e-02f, -3.03041264e-02f, 4.14751805e-02f, -1.78917348e-02f, -1.24026816e-02f, -7.46582542e-03f, -1.14092804e-01f, 8.72871373e-03f, 1.31122634e-01f, 1.42729818e-03f,
  -2.10318321e-04f, -7.33361207e-03f, 4.87177409e-02f, -6.49050635e-04f, 2.27471460e-02f, 1.14185296e-01f, -3.35708372e-02f, -3.33464183e-02f, -5.09260669e-02f, -4.55215079e-04f,
  -3.13199222e-01f, -1.73847489e-02f, -6.18155338e-02f, -1.16169728e-01f, -4.01479565e-03f, -2.51786262e-02f, -4.23287153e-02f, 9.25991312e-02f, -4.70488332e-03f, -9.29590091e-02f,
  -4.97867949e-02f, -1.59627721e-02f, -7.18031004e-02f, -2.65445490e-03f, -3.42424214e-02f, -8.71899128e-02f, -2.76624635e-02f, -1.07053339e-01f, 6.91798925e-02f, 2.27997378e-02f,
  -1.92737859e-02f, -1.62125215e-01f, -1.78962097e-01f, -1.25698850e-01f, -8.38205889e-02f, -1.98935658e-01f, -1.89010158e-01f, -1.70086071e-01f, -2.27333322e-01f, -2.90664673e-01f,
  1.55045703e-01f, -1.12670317e-01f, -1.61490161e-02f, 1.88911945e-01f, 3.51080559e-02f, -6.72751069e-02f, -1.41735226e-01f, -9.61256772e-02f, 1.38605610e-01f, -1.03700630e-01f,
  -6.97508082e-02f, -1.06314542e-02f, 3.27488333e-02f, -3.25639322e-02f, -1.23970665e-01f, -5.99557906e-02f, -9.48941335e-02f, -5.05738370e-02f, -9.96625274e-02f, -7.96702728e-02f,
  -8.74482542e-02f, 1.47034466e-01f, 1.62833095e-01f, 1.71160642e-02f, 7.33247995e-02f, 2.90728118e-02f, 7.99723342e-02f, -6.18319400e-03f, 5.55784702e-02f, -3.02103311e-02f,
  -1.18181810e-01f, -1.14258444e-02f, 2.57197246e-02f, 6.92023039e-02f, 5.75840622e-02f, 3.28161977e-02f, -6.79973364e-02f, 5.05369566e-02f, 4.45836447e-02f, -5.24047948e-02f,
  -1.12588694e-02f, 1.67382360e-02f, -1.70670613e-03f, -7.59812072e-02f, 1.29941590e-02f, -4.80603576e-02f, -1.47167910e-02f, 7.84741566e-02f, 2.08612420e-02f, -6.55713677e-02f,
  -8.26214328e-02f, 2.84327529e-02f, -5.01298271e-02f, -8.35464057e-03f, 4.76742312e-02f, -2.42240448e-02f, 2.64697466e-02f, 6.46977592e-03f, -8.20206851e-03f, -3.08336169e-02f,
  1.20981157e-01f, -4.82828207e-02f, 1.44929765e-02f, 2.20240168e-02f, -1.98964477e-02f, 5.23067899e-02f, 2.97318846e-02f, 1.29082296e-02f, -4.16832343e-02f, 1.21302687e-01f,
  2.42371820e-02f, 7.97273184e-04f, 6.86660991e-04f, 1.11245431e-01f, -4.51121619e-03f, -2.46379580e-02f, 6.20326996e-02f, 6.98974654e-02f, -7.93886706e-02f, -2.85154600e-02f,
  5.70672564e-02f, -2.50173155e-02f, 3.14004309e-02f, -7.92986378e-02f, 2.73201335e-02f, -4.64104488e-02f, 2.81416476e-02f, 1.68356970e-02f, 5.60710505e-02f, 1.04617644e-02f,
  2.97952034e-02f, -2.32569892e-02f, 6.82758763e-02f, -1.32296115e-01f, 6.37076944e-02f, 1.45894000e-02f, -9.80654545e-03f, 5.31152599e-02f, 3.56520223e-03f, 1.42790349e-02f,
  -1.78143401e-02f, -3.68252508e-02f, 4.35249731e-02f, -1.98655035e-02f, 6.14707768e-02f, 4.47382499e-03f, 5.35180606e-02f, 5.96328825e-02f, -5.00543751e-02f, -4.77599017e-02f,
  3.65397483e-02f, -4.87303585e-02f, 4.47030962e-02f, -6.18488677e-02f, -2.09163614e-02f, 2.11195759e-02f, -5.24447039e-02f, -4.22139652e-02f, -4.84673865e-03f, 3.51432338e-02f,
  1.15009576e-01f, 1.28950164e-01f, 7.61187449e-02f, -4.77744974e-02f, -4.74855257e-03f, 3.04957908e-02f, 2.44346619e-01f, -3.52946445e-02f, -6.53954744e-02f, 2.71313526e-02f,
  -2.00900614e-01f, -1.91948950e-01f, -2.24636242e-01f, -1.33304954e-01f, -4.29111011e-02f, 1.39908761e-01f, 1.03523813e-01f, -6.00819364e-02f, -8.99862945e-02f, -1.56975195e-01f,
  -1.21813737e-01f, -6.78675398e-02f, 5.87135274e-03f, -2.18794635e-03f, 5.23371100e-02f, 4.57243323e-02f, 3.13957967e-02f, 7.12087303e-02f, 1.04694381e-01f, 2.89620519e-01f,
  -8.41555521e-02f, 1.38450623e-01f, -5.82564995e-03f, 3.75623032e-02f, 6.10564090e-02f, 4.48925197e-02f, 3.44490079e-04f, 5.36819808e-02f, -2.89738122e-02f, 1.74551383e-02f,
  -6.08623475e-02f, -2.19207555e-02f, -8.35921466e-02f, -4.41071428e-02f, -2.09152121e-02f, 6.91277236e-02f, 6.71220347e-02f, -8.32621828e-02f, -5.92996879e-03f, 3.65121216e-02f,
  4.14674096e-02f, -7.34683080e-03f, -8.23156908e-02f, 7.04548368e-03f, 1.18987530e-01f, -2.70912871e-02f, 5.68995029e-02f, 1.11757942e-01f, 1.40622541e-01f, 2.94622988e-01f,
  3.72392945e-02f, -3.91537733e-02f, 2.53361892e-02f, -2.76691671e-02f, 5.13286982e-03f, -1.35658984e-03f, -3.48443985e-02f, -2.84545366e-02f, 3.23501416e-02f, 4.24414128e-02f,
  9.79990233e-03f, 1.18434457e-02f, 4.46376111e-03f, -3.39657106e-02f, -4.00529951e-02f, -2.02876283e-03f, 9.16546732e-02f, 3.87857109e-02f, -6.39960915e-02f, -6.78358739e-03f,
  7.10558593e-02f, 2.83189323e-02f, 2.70960815e-02f, -2.68429071e-02f, 3.95316295e-02f, 1.42690372e-02f, 4.89168167e-02f, -8.43958482e-02f, -7.06759887e-03f, -5.90629578e-02f,
  -5.38271107e-02f, -1.83803812e-02f, -7.94555843e-02f, 6.58950163e-03f, -6.52247071e-02f, -1.64395687e-03f, 2.96282526e-02f, 3.16879824e-02f, -8.34907740e-02f, -5.46376519e-02f,
  7.40405694e-02f, -1.97960660e-02f, 4.67951503e-03f, 5.96851557e-02f, -3.05580180e-02f, -9.25730094e-02f, 2.61529293e-02f, -1.42907882e-02f, 2.49997023e-02f, 4.74843383e-02f,
  1.40217096e-02f, 5.72336167e-02f, -3.04929866e-03f, -2.03836430e-03f, -8.79989285e-03f, -1.21833704e-01f, 5.41699044e-02f, 1.05847359e-01f, 8.41396675e-02f, 2.35731453e-01f,
  1.76130176e-01f, 8.92625675e-02f, 1.99700877e-01f, 2.98552420e-02f, -4.10231128e-02f, -1.40610635e-01f, -7.55611509e-02f, -1.17300183e-01f, -7.54154846e-02f, 1.20477550e-01f,
  -9.84265432e-02f, -1.33486316e-01f, -7.55623356e-02f, -1.13357037e-01f, -1.66270912e-01f, -4.44108341e-03f, 7.49138296e-02f, 6.05253726e-02f, -5.18761110e-03f, -1.14270248e-01f,
  -6.81364685e-02f, 7.71299899e-02f, 1.20436653e-01f, -3.71840820e-02f, 1.55523820e-02f, -1.53457969e-01f, -7.89212901e-03f, 7.39936605e-02f, -1.23721592e-01f, 2.06518948e-01f,
  9.91203859e-02f, 9.47688799e-03f, -9.08087790e-02f, -4.10101302e-02f, 5.73910736e-02f, 4.05819826e-02f, 3.72177549e-02f, 1.40709817e-01f, 1.57515705e-02f, 4.31616791e-02f,
  3.30399424e-02f, 1.98984873e-02f, 3.09371464e-02f, 3.94060872e-02f, 8.69937241e-02f, 1.68618523e-02f, -4.83502336e-02f, 2.19105184e-02f, 1.04677714e-01f, 4.90884259e-02f,
  2.12262608e-02f, -6.09759875e-02f, 3.76655832e-02f, 8.08520429e-03f, 2.98798475e-02f, -5.32098599e-02f, 1.13058006e-02f, 7.54356058e-03f, 4.02207337e-02f, 1.23750836e-01f,
  3.28610092e-02f, -7.62485759e-03f, 4.25336249e-02f, 6.84014475e-03f, 5.59617206e-02f, -1.49721056e-02f, -7.59098828e-02f, 3.41066159e-02f, -4.64149751e-02f, 5.17800972e-02f,
  -4.09780703e-02f, 2.75284946e-02f, 4.77806143e-02f, -3.70809063e-02f, -3.98307256e-02f, -5.16671650e-02f, 2.81025115e-02f, -9.65682045e-03f, 6.11148551e-02f, 2.99950559e-02f,
  4.86819781e-02f, -4.31215093e-02f, 6.82358071e-02f, 5.21408161e-03f, -4.84628044e-02f, 1.70713570e-02f, -3.82891931e-02f, -1.45223998e-02f, -5.93661815e-02f, -4.47391393e-03f,
  1.04477070e-01f, 3.29757505e-03f, 8.40280876e-02f, -5.03245555e-02f, -1.27172079e-02f, 5.15072942e-02f, -9.00104865e-02f, 1.11142145e-02f, 1.02697928e-02f, 6.61529303e-02f,
  -9.31471214e-02f, -1.94085240e-02f, 1.11513920e-01f, -3.65347974e-03f, 7.08603635e-02f, 3.17920670e-02f, 2.95579061e-02f, -8.33068800e-04f, -8.28603879e-02f, 6.28682002e-02f,
  -4.15361412e-02f, 6.82326853e-02f, 7.20729083e-02f, -2.66687088e-02f, -1.07175186e-01f, 3.80864181e-03f, -1.70600004e-02f, 3.38405930e-02f, -3.56266573e-02f, 6.87260181e-02f,
  3.20982844e-01f, -2.14519426e-01f, -1.01957344e-01f, 1.02123849e-01f, -1.01850085e-01f, -1.66776478e-01f, -2.16923401e-01f, -6.79901093e-02f, 1.59942836e-01f, -1.14049219e-01f,
  -2.71546781e-01f, 1.00989640e-03f, -6.21806160e-02f, -9.00514796e-02f, 4.34749722e-02f, -4.26234789e-02f, 7.74108618e-02f, 1.13382384e-01f, 1.27552569e-01f, 4.40659327e-03f,
  -8.12657326e-02f, 1.67726114e-01f, 1.41459152e-01f, 1.43197045e-01f, 3.69007997e-02f, 5.31189702e-02f, -1.43682845e-02f, 3.13708819e-02f, -1.45694301e-01f, 1.28251538e-01f,
  -6.17175661e-02f, -5.48463464e-02f, -4.62788343e-02f, 5.44442609e-02f, -4.13389206e-02f, 1.61399662e-01f, 4.06183489e-02f, 6.71996623e-02f, -5.21754548e-02f, -2.29788522e-04f,
  -3.93484831e-02f, 7.52612799e-02f, -6.02579713e-02f, -1.89326182e-02f, 5.64466976e-02f, -1.01505965e-02f, 9.03159976e-02f, 9.82375070e-02f, 8.88608247e-02f, 1.08297670e-03f,
  -1.32777944e-01f, -2.83590541e-03f, -5.32426275e-02f, -6.02163039e-02f, -9.63052064e-02f, 1.60496105e-02f, -4.53410074e-02f, -2.63093214e-04f, -5.39508797e-02f, 5.34048826e-02f,
  3.93342935e-02f, 3.41309644e-02f, 4.94654290e-03f, 1.11519121e-01f, -2.47773398e-02f, -3.25346664e-02f, 1.88986249e-02f, -5.85586131e-02f, 2.84557994e-02f, 2.82144379e-02f,
  1.12309530e-02f, -9.73292515e-02f, 2.29421165e-03f, 6.33491129e-02f, -3.17628197e-02f, -2.80910209e-02f, 1.40611716e-02f, 5.53665608e-02f, -7.35843331e-02f, 4.45632897e-02f,
  -1.61668509e-02f, -6.02027327e-02f, -2.18548104e-02f, -6.29879534e-02f, 4.43144366e-02f, 2.77424138e-02f, 5.52599579e-02f, 1.94574369e-03f, 4.14379686e-02f, 2.94747315e-02f,
  9.60569158e-02f, -2.13994130e-01f, 1.34225592e-01f, 1.36122787e-02f, -4.62785847e-02f, -4.21311222e-02f, -1.59250032e-02f, -3.36815268e-02f, -7.08243102e-02f, 2.10738946e-02f,
  -4.31791656e-02f, -3.72751802e-02f, 2.20267568e-02f, 4.61306423e-03f, 4.24678214e-02f, 6.81576729e-02f, -2.06971355e-02f, 3.61652635e-02f, -8.79154354e-02f, 1.51198832e-02f,
  -3.64209488e-02f, 9.06986818e-02f, 2.04291195e-02f, 1.38405021e-02f, -4.36652452e-02f, 1.78778768e-02f, -2.15408672e-03f, 8.02859664e-02f, 7.79593596e-03f, 2.45870888e-01f,
  -1.49562299e-01f, 1.40067235e-01f, -2.73023024e-02f, -5.48143424e-02f, 1.09910384e-01f, -2.48938408e-02f, 1.52764082e-01f, 3.20835039e-02f, -3.08445990e-02f, 8.54796842e-02f,
  -1.13457143e-02f, 6.17694343e-04f, 6.32394180e-02f, -5.23646846e-02f, -1.37947068e-01f, 7.40405470e-02f, 4.34062928e-02f, -1.91106852e-02f, -1.95585340e-01f, -8.57693404e-02f,
  -3.35245812e-03f, 1.83231346e-02f, -1.97929829e-01f, -7.47074187e-02f, 2.22636852e-02f, 4.70477305e-02f, 1.05379254e-01f, -5.27020395e-02f, 1.21259689e-01f, 1.45161241e-01f,
  8.11032653e-02f, 1.06737092e-02f, -3.68404426e-02f, 1.75183006e-02f, 3.12919579e-02f, -1.75002087e-02f, -7.10768402e-02f, 4.03299928e-02f, -5.52879013e-02f, -2.29853019e-02f,
  1.14847668e-01f, -1.09993834e-02f, 3.69260646e-02f, -5.45520931e-02f, 2.76173875e-02f, -9.35198218e-02f, 5.32206744e-02f, -1.36318684e-01f, -5.72192445e-02f, 2.46567056e-02f,
  1.83597486e-02f, 1.64288227e-02f, -1.04377300e-01f, -7.15640932e-02f, -6.85892627e-02f, -1.96408108e-02f, -8.42802674e-02f, -4.51415367e-02f, -1.48827165e-01f, 5.39866723e-02f,
  4.92731929e-02f, -5.03063388e-02f, 5.83658516e-02f, -1.49878806e-05f, -5.38940988e-02f, 7.95887858e-02f, -2.77704243e-02f, 1.01384614e-03f, -6.49390891e-02f, 7.85620213e-02f,
  -6.15516193e-02f, 2.78141573e-02f, -2.38471199e-03f, -8.56319517e-02f, -3.32991686e-03f, -5.32141477e-02f, -8.06556717e-02f, -1.04905097e-02f, -1.11631632e-01f, -1.29483705e-02f,
  7.34665170e-02f, -3.45340781e-02f, -1.70343053e-02f, -3.02359834e-02f, -5.02146631e-02f, 1.33974958e-04f, -7.91373849e-03f, 3.15911919e-02f, 1.63359921e-02f, -4.36331220e-02f,
  6.53982759e-02f, -1.49513707e-01f, 3.68176736e-02f, 5.17984554e-02f, 7.75646269e-02f, 3.69735574e-03f, 7.62150297e-03f, -5.28382026e-02f, 7.19997194e-03f, 4.19811495e-02f,
  7.28033707e-02f, -6.57396317e-02f, -6.46852478e-02f, -1.30588850e-02f, 8.40547122e-03f, -4.49957065e-02f, -1.14697097e-02f, 4.34608869e-02f, -2.15802877e-03f, 9.97747667e-03f,
  -1.45532275e-02f, 3.30606177e-02f, 4.22502272e-02f, 5.24688475e-02f, -6.03481242e-03f, -1.39150536e-02f, -5.09348623e-02f, 3.45859714e-02f, -6.42766878e-02f, 1.14957191e-01f,
  -1.97982490e-01f, 2.25754023e-01f, 3.53712104e-02f, -1.30607218e-01f, -1.83575928e-01f, -2.30686814e-01f, -1.90438867e-01f, -1.69356480e-01f, -1.50004640e-01f, 7.64485449e-02f,
  9.53239799e-02f, -3.79022770e-02f, 3.11922897e-02f, 9.80037004e-02f, 2.84512918e-02f, 5.81141151e-02f, -1.99495684e-02f, 4.27259468e-02f, -5.20939566e-02f, -5.76361194e-02f,
  -5.47454692e-02f, -1.42547942e-03f, 8.25194344e-02f, 2.66127493e-02f, 1.43070951e-01f, -1.35643899e-01f, 8.83134454e-02f, 2.08707467e-01f, 7.30300471e-02f, 1.31375745e-01f,
  3.18468690e-01f, 2.09786639e-01f, -3.54142003e-02f, 5.18252440e-02f, 3.19355987e-02f, 5.95843978e-02f, -3.39233363e-03f, 3.27445567e-02f, 1.02910809e-02f, -2.34848503e-02f,
  4.60985266e-02f, 7.99414366e-02f, 3.62554081e-02f, 1.56977605e-02f, -1.26537739e-03f, 7.99677670e-02f, 1.05517574e-01f, 7.59985521e-02f, 1.01556160e-01f, 6.75956383e-02f,
  6.02427796e-02f, 1.11268714e-01f, -4.19990160e-02f, -6.15258999e-02f, -1.84413251e-02f, -1.33577306e-02f, 6.61248050e-04f, 6.77977502e-02f, 2.91737616e-02f, 9.58810151e-02f,
  -2.00575329e-02f, 1.23860380e-02f, -6.87066317e-02f, 2.04264261e-02f, -3.94394062e-02f, -5.98386228e-02f, -1.58270542e-02f, 4.59428802e-02f, -1.03342114e-02f, 3.15977745e-02f,
  -9.35702294e-04f, -8.10967106e-03f, -1.38589451e-02f, 3.53493504e-02f, -1.00779012e-02f, 5.07733375e-02f, -4.70191799e-02f, 2.26600040e-02f, -2.05861609e-02f, -4.92180511e-02f,
  1.60421175e-03f, 3.11784707e-02f, -2.35253330e-02f, -1.63812228e-02f, 1.20804124e-02f, 1.81042049e-02f, 1.10447500e-02f, 7.62644485e-02f, -7.18389377e-02f, 6.26464561e-02f,
  -1.38912708e-01f, -1.33360876e-02f, 1.70813557e-02f, 1.47931660e-02f, -5.08890599e-02f, 7.69030303e-02f, 2.08931621e-02f, -6.89265132e-03f, -5.18666469e-02f, 4.30493653e-02f,
  2.50751269e-03f, 2.04565972e-02f, 6.48859516e-02f, 5.76893352e-02f, -5.75173683e-02f, -8.39762762e-02f, 9.54575613e-02f, -6.47526830e-02f, 2.55007651e-02f, -2.02756524e-02f,
  -6.22214749e-02f, -1.61618471e-01f, -1.61293462e-01f, -1.39383107e-01f, -5.81424646e-02f, -1.31714076e-01f, -6.85148686e-02f, -9.90781039e-02f, -1.01895049e-01f, -2.07306206e-01f,
  5.53140461e-01f, 1.64965570e-01f, 1.74217775e-01f, 2.71401018e-01f, 1.93744212e-01f, 7.74790272e-02f, 2.15054944e-01f, 1.30488157e-01f, 9.22273099e-02f, 4.74791266e-02f,
  8.28302205e-02f, 3.46236415e-02f, 6.22522905e-02f, 3.75147373e-03f, -1.46778685e-03f, 1.04057774e-01f, 2.00303778e-01f, 9.10938904e-02f, 1.04761302e-01f, 1.04709134e-01f,
  2.64925361e-02f, 1.10573247e-01f, 1.61731988e-01f, -1.83255579e-02f, 8.68766159e-02f, -1.29131392e-01f, 1.18581927e-03f, 2.11278144e-02f, -1.38239950e-01f, -3.90487053e-02f,
  -8.08096230e-02f, 1.60201445e-01f, -1.13088325e-01f, 4.15846743e-02f, 3.15966643e-02f, -1.88858341e-02f, 1.23291008e-01f, -1.25512835e-02f, -3.21461372e-02f, -2.72219609e-02f,
  4.27372530e-02f, -3.99053954e-02f, 4.90177795e-02f, 7.87721539e-04f, 8.42701197e-02f, 5.05565181e-02f, 2.69384664e-02f, -2.59497352e-02f, -1.03841886e-01f, -5.95596582e-02f,
  -8.39044079e-02f, 7.19022602e-02f, 3.05886939e-03f, -3.83930132e-02f, -6.16964810e-02f, -6.10013232e-02f, 3.11840158e-02f, -2.67449599e-02f, 2.15916838e-02f, 2.45604813e-02f,
  1.69400289e-03f, -3.03885154e-03f, 3.50038707e-02f, 2.75782514e-02f, 8.78346041e-02f, -2.78976858e-02f, -3.25106382e-02f, -8.46055802e-03f, 3.79236378e-02f, -4.44980152e-02f,
  1.77428238e-02f, -1.29427772e-03f, 3.84126306e-02f, 8.42739567e-02f, -7.49613866e-02f, 2.93289609e-02f, -2.54590996e-02f, 5.28389812e-02f, -7.62383044e-02f, 2.46709548e-02f,
  -9.65645537e-03f, 4.45713149e-03f, -6.31111115e-02f, 5.41614788e-03f, -8.66063684e-02f, 7.60876909e-02f, -6.90288469e-02f, 2.56049819e-02f, 4.43204828e-02f, -5.74539602e-02f,
  -2.22951304e-02f, -1.74009148e-02f, -6.88466057e-02f, -3.65741439e-02f, 4.73606251e-02f, -7.95806125e-02f, -1.16183413e-02f, -7.38193989e-02f, 6.55176025e-03f, -1.19517855e-02f,
  -2.61217486e-02f, 6.46009892e-02f, 6.66421056e-02f, -1.16728030e-01f, 5.18100299e-02f, -5.98287955e-02f, -4.50032130e-02f, 1.47625273e-02f, -6.42704451e-03f, -8.34798515e-02f,
  4.00247499e-02f, 3.40456851e-02f, 5.20927832e-02f, -5.17715923e-02f, 1.57310441e-02f, 6.44920617e-02f, -9.40826088e-02f, -1.06144205e-01f, 4.77852067e-03f, 6.82816356e-02f,
  6.13605119e-02f, -1.26091808e-01f, 3.60186212e-03f, 6.12131739e-03f, -1.45566221e-02f, 2.54181683e-01f, 1.69860333e-01f, 1.54600680e-01f, 6.22522756e-02f, -9.19046551e-02f,
  8.12132955e-02f, 6.55961037e-02f, -7.48682469e-02f, 1.69605867e-03f, 8.71000960e-02f, -1.30980715e-01f, -1.30642310e-01f, -1.05093811e-02f, 1.19842343e-01f, 4.08225842e-02f,
  -1.26648173e-01f, -2.70249378e-02f, -6.89577535e-02f, 7.19411299e-02f, -5.53579964e-02f, -1.21247731e-01f, -7.94026535e-03f, -8.78509879e-02f, -3.96374017e-02f, -2.31372103e-01f,
  -1.35335192e-01f, 2.10594207e-01f, 5.13883494e-02f, -4.80549000e-02f, 8.90269503e-02f, 6.02777265e-02f, 2.02996042e-02f, 8.85445508e-04f, -1.67978387e-02f, -5.03524393e-03f,
  -3.03109623e-02f, 1.00934118e-01f, 1.09885640e-01f, -9.74857658e-02f, 6.41719699e-02f, 9.28899646e-02f, 8.04669857e-02f, -2.67235190e-02f, 8.66328329e-02f, -1.37650315e-02f,
  5.09327352e-02f, 1.27791882e-01f, 6.33613318e-02f, 1.09301008e-01f, 1.53124958e-01f, -1.53172121e-03f, 8.34331289e-02f, 1.16951041e-01f, 1.29316568e-01f, -1.04663029e-01f,
  -4.08067368e-03f, 6.50140867e-02f, 1.14975981e-02f, 2.64872648e-02f, -7.85235083e-04f, -7.71535560e-02f, -4.32740012e-03f, -7.09768981e-02f, -5.81314713e-02f, 2.00582948e-02f,
  4.87217680e-03f, -8.31906796e-02f, 2.09467746e-02f, 9.08089522e-03f, -5.98634668e-02f, -7.48217944e-03f, 2.38489583e-02f, 3.66588235e-02f, -9.66905896e-03f, 2.15591881e-02f,
  2.50941683e-02f, 3.13771516e-02f, 3.23940255e-02f, 5.41565716e-02f, 5.82854785e-02f, -4.06925268e-02f, 1.66421104e-02f, -3.73590104e-02f, 1.34138186e-02f, -5.26247472e-02f,
  -1.74967274e-01f, 1.05265230e-01f, -2.86153741e-02f, 2.73477342e-02f, 4.70074527e-02f, 1.44424811e-02f, 2.09845603e-02f, 7.23632574e-02f, 2.71801576e-02f, -2.27592140e-02f,
  2.17840951e-02f, -4.64022644e-02f, -6.72248900e-02f, -4.58204970e-02f, 8.12749118e-02f, 4.01504040e-02f, -9.14876163e-02f, -5.44075929e-02f, -4.20845672e-02f, -1.15530873e-02f,
  -4.86833677e-02f, -5.70685044e-02f, -4.21727374e-02f, -4.85999184e-03f, -8.44990313e-02f, 3.44223529e-02f, -2.16528457e-02f, 7.35016132e-04f, 9.50605273e-02f, -1.42935589e-01f,
  -1.90744668e-01f, 1.52574657e-02f, 1.33275688e-01f, -1.15111470e-01f, 4.88467924e-02f, 5.85664995e-02f, -1.30611146e-02f, -3.53630520e-02f, 2.52589751e-02f, -2.25929115e-02f,
  1.80895120e-01f, -9.62850302e-02f, -1.48359209e-01f, -2.84170769e-02f, -8.89138728e-02f, -1.27405703e-01f, -1.43283844e-01f, -1.82456866e-01f, -2.01835930e-01f, 2.00913437e-02f,
  2.37932652e-02f, -7.23909587e-02f, -8.35383907e-02f, 6.88625500e-02f, -7.62847364e-02f, -2.49154083e-02f, -1.94175374e-02f, 9.39232260e-02f, 6.03530332e-02f, -2.27432579e-01f,
  -1.90161347e-01f, 1.22391969e-01f, -7.29693845e-02f, -1.65196061e-02f, 1.11136146e-01f, -4.78952713e-02f, 2.95567326e-02f, 6.63269386e-02f, 6.86098682e-03f, 1.08015491e-02f,
  1.78907681e-02f, -7.29125692e-03f, -2.79292627e-03f, 5.46943061e-02f, 4.21210341e-02f, 3.98683511e-02f, -3.51435989e-02f, -2.61461437e-02f, 3.61801982e-02f, -2.88270190e-02f,
  1.27600739e-02f, 5.91467805e-02f, -3.95586491e-02f, 4.12371308e-02f, -4.46331203e-02f, -3.02199963e-02f, 1.87298626e-01f, 1.05500266e-01f, 1.51253402e-01f, 4.20416370e-02f,
  6.28948137e-02f, 2.80889459e-02f, 6.94532245e-02f, 1.00148600e-02f, -4.79785651e-02f, -1.75195690e-02f, -8.47803056e-02f, -4.61842455e-02f, -4.47996855e-02f, 6.95676878e-02f,
  1.07323648e-02f, 2.07286980e-02f, 2.50107050e-02f, -1.93175655e-02f, -4.23001349e-02f, -1.19450623e-02f, -1.52045470e-02f, -1.87540019e-03f, 4.09230813e-02f, -1.41032552e-02f,
  -2.16604806e-02f, 3.92470136e-02f, -6.58808127e-02f, 3.33462097e-02f, 9.06226970e-03f, 1.00844905e-01f, -6.16432279e-02f, -1.07335495e-02f, -2.30114441e-02f, -3.99364270e-02f,
  -1.30782947e-01f, 2.83160955e-01f, -1.32855326e-01f, -1.65500283e-01f, 6.64832518e-02f, -2.36812271e-02f, 4.65555005e-02f, -2.98862848e-02f, 4.47736960e-03f, -4.46154922e-02f,
  3.10435351e-02f, -3.84804569e-02f, 5.94602190e-02f, 8.33398104e-02f, -3.87848951e-02f, -3.59971970e-02f, -7.22289607e-02f, -8.21690857e-02f, -3.67879085e-02f, 1.41582444e-01f,
  -1.66160483e-02f, -1.07300177e-01f, -1.16433822e-01f, 1.53936613e-02f, -5.64348251e-02f, -1.47395954e-01f, 2.04357486e-02f, -7.32471868e-02f, 9.29394551e-03f, -9.92465317e-02f,
  1.32101476e-01f, 1.57729797e-02f, -5.37668653e-02f, 9.05878246e-02f, 7.67411813e-02f, -8.56613554e-03f, 6.58719614e-02f, -8.49812329e-02f, -9.86581445e-02f, 9.36825052e-02f,
  1.81351975e-02f, -9.80748888e-03f, -2.39530690e-02f, 1.02141220e-02f, -3.93075533e-02f, -2.73825396e-02f, 8.20862949e-02f, -7.43172988e-02f, -7.86254462e-03f, -1.60867516e-02f,
  1.31099075e-01f, 6.05232865e-02f, 7.17861801e-02f, 3.15499157e-02f, 8.30700919e-02f, -3.27256359e-02f, 3.11425384e-02f, -2.54969466e-02f, 2.77985670e-02f, 1.14210561e-01f,
  -2.23731652e-01f, 2.49999743e-02f, -7.69585148e-02f, 1.71374083e-01f, -6.94587454e-02f, 2.68893261e-02f, 1.28121348e-02f, -9.68949646e-02f, 1.53370993e-02f, 7.95071200e-03f,
  -6.84261415e-03f, 7.01265708e-02f, 6.41069859e-02f, -8.73525254e-03f, 5.01320958e-02f, -3.86346541e-02f, -3.80869061e-02f, -3.55659463e-02f, -4.00821902e-02f, -6.79264665e-02f,
  8.07216093e-02f, 1.45905996e-02f, 3.71797569e-02f, 1.32155456e-02f, -2.21005548e-02f, 5.48709705e-02f, 4.69090790e-02f, 3.96276526e-02f, -5.97050637e-02f, -8.09748694e-02f,
  -1.43273659e-02f, -1.17537286e-02f, -2.58531421e-02f, -2.55315248e-02f, 3.57850567e-02f, -1.03462767e-02f, -2.92495750e-02f, 3.25656869e-02f, 1.76732875e-02f, -4.43736427e-02f,
  -3.82117555e-02f, -2.59000566e-02f, -5.31073250e-02f, -7.60674998e-02f, -4.72975262e-02f, -4.94216122e-02f, -3.72439921e-02f, -9.42197535e-03f, 4.47538160e-02f, -5.65582002e-03f,
  5.35478331e-02f, 2.62054633e-02f, 3.22500058e-02f, -5.14288470e-02f, 7.49265924e-02f, 3.61420261e-03f, 5.51755615e-02f, 4.19494212e-02f, -4.72691506e-02f, 3.24237198e-02f,
  -3.08881819e-01f, 1.39259785e-01f, -8.43988582e-02f, 3.82855423e-02f, -7.96680376e-02f, -4.60593216e-02f, -2.01232769e-02f, 9.20128077e-03f, -9.17681307e-02f, 6.44449657e-03f,
  6.98346049e-02f, -2.04378739e-02f, -2.99080405e-02f, -6.80667832e-02f, -5.92197850e-02f, 5.87877408e-02f, 3.32076810e-02f, 8.71454738e-03f, 8.83941576e-02f, -7.91548565e-02f,
  1.23175327e-02f, -2.88554910e-03f, -2.60510948e-02f, -4.09214664e-03f, 2.66055521e-02f, 5.73962964e-02f, -1.42099172e-01f, -9.68962908e-02f, -1.16797440e-01f, -1.95111871e-01f,
  -6.21138513e-01f, 4.03390527e-02f, -1.89927682e-01f, -8.09762925e-02f, 2.03056678e-01f, 9.90288630e-02f, 1.85232610e-01f, 6.74899518e-02f, -1.99714792e-03f, 1.17357329e-01f,
  1.58921480e-02f, 6.43344149e-02f, -5.87779656e-02f, 6.76561445e-02f, -1.08769834e-01f, 1.17333159e-01f, -1.00420509e-02f, -7.99716562e-02f, -7.37963542e-02f, 1.12535839e-03f,
  2.03679994e-01f, -1.84378531e-02f, -2.48926401e-01f, -1.18613489e-01f, 1.27710938e-01f, 5.72990291e-02f, -3.14662829e-02f, -2.07103696e-02f, 1.25589833e-01f, 7.09169507e-02f,
  -1.46502852e-01f, -2.07918644e-01f, 6.33161291e-02f, 5.23312353e-02f, 1.97220827e-03f, -8.74833018e-02f, -7.02041388e-02f, -1.07547203e-02f, -6.20938279e-02f, -1.36724524e-02f,
  -5.94136380e-02f, -1.17107108e-02f, -4.55532260e-02f, -1.74643546e-02f, -4.62609865e-02f, -5.91818057e-02f, -1.19856745e-02f, -3.54619138e-02f, -5.24902670e-03f, -6.20098300e-02f,
  1.24406807e-01f, 2.38138717e-02f, -6.44034445e-02f, 5.93669266e-02f, -2.93246645e-04f, -9.10402089e-02f, 2.61011329e-02f, -1.34350881e-01f, -1.35760143e-01f, -1.10637099e-01f,
  5.59749920e-03f, 4.10033539e-02f, 5.23915589e-02f, 2.68162247e-02f, -6.89749327e-03f, 4.79951985e-02f, 1.11087784e-02f, 3.04721333e-02f, 4.64068428e-02f, -8.08697790e-02f,
  5.65649532e-02f, -1.19724050e-02f, 6.72338391e-03f, 1.52473394e-02f, 1.44051518e-02f, 3.05698402e-02f, -9.79134962e-02f, 3.77805196e-02f, -5.29148765e-02f, 2.90475525e-02f,
  -2.19932590e-02f, -2.33242586e-02f, -6.06710054e-02f, 3.29220071e-02f, 2.36549973e-02f, 2.50482559e-02f, -8.77402201e-02f, 2.38182601e-02f, -3.07366624e-02f, 1.04114842e-02f,
  -7.44310766e-02f, -7.49008432e-02f, -1.54302306e-02f, -1.47527298e-02f, -4.65858243e-02f, -4.49596196e-02f, -5.72717190e-02f, 6.33885413e-02f, -8.60765502e-02f, 2.16785679e-03f,
  -7.22959340e-02f, -5.21103777e-02f, 2.81347837e-02f, -1.82917807e-02f, 8.85074064e-02f, 3.84474806e-02f, 4.27083373e-02f, -7.30075687e-02f, 4.13513519e-02f, 6.06864244e-02f,
  9.32175964e-02f, -1.00383990e-01f, -1.47633001e-01f, 1.46495774e-02f, -3.00526805e-02f, -8.48029107e-02f, -6.91981912e-02f, -8.33356827e-02f, -1.49263591e-01f, -1.24522500e-01f,
  -4.24660772e-01f, -1.26403375e-02f, -1.40843093e-02f, -1.75888568e-01f, -3.29697244e-02f, 1.90311670e-02f, 1.41535851e-03f, -7.00803995e-02f, -8.28116685e-02f, -5.50766811e-02f,
  1.48099303e-01f, 3.21303681e-02f, -3.03876977e-02f, 7.38496333e-02f, -9.14117694e-02f, -4.89360802e-02f, -1.83569133e-01f, -1.66286349e-01f, -8.64471719e-02f, 1.32547540e-03f,
  1.40230596e-01f, -1.17890365e-01f, -2.80566439e-02f, -1.88076049e-02f, 1.29717752e-01f, 1.28790423e-01f, -5.72825298e-02f, -4.62864973e-02f, 1.21954598e-01f, -3.11916489e-02f,
  1.02088854e-01f, -5.27848192e-02f, -2.98317280e-02f, 1.16884001e-02f, -1.32271629e-02f, 2.60172179e-04f, -1.66462082e-02f, -4.99161445e-02f, 9.54226702e-02f, -3.39719281e-02f,
  1.00296445e-01f, 1.59369987e-02f, 5.12355231e-02f, -4.77516055e-02f, 2.83675771e-02f, -1.51177775e-02f, -6.37528896e-02f, -1.02737106e-01f, -3.54052186e-02f, 9.80316550e-02f,
  5.60835600e-02f, 1.06215157e-01f, -4.24533635e-02f, -4.49521393e-02f, -2.36582980e-02f, 1.57282520e-02f, 1.10681646e-01f, 2.93251825e-03f, 2.01884974e-02f, 3.09492089e-02f,
  -4.78288867e-02f, 1.15038699e-03f, -8.41060188e-03f, 5.23336008e-02f, 2.75735985e-02f, 7.45511502e-02f, 1.71143468e-02f, -2.13066172e-02f, -3.53766680e-02f, 1.83676858e-03f,
  -2.13073716e-02f, 1.55443791e-02f, -2.71544941e-02f, -1.07967898e-01f, 3.54865901e-02f, -8.64225626e-02f, 3.54894921e-02f, 2.24510580e-03f, -4.16963324e-02f, -7.71897798e-03f,
  2.79665664e-02f, 5.42112701e-02f, 4.05655541e-02f, 1.62043683e-02f, -2.02952214e-02f, -1.80751476e-02f, 1.68103483e-02f, 1.63039025e-02f, -8.29679891e-03f, -7.59141566e-03f,
  1.21910140e-01f, -1.37981502e-02f, -9.72630233e-02f, 4.30081673e-02f, -5.30239828e-02f, 2.32950132e-02f, 1.12600736e-02f, -2.45356411e-02f, 3.75270620e-02f, 5.27626313e-02f,
  3.66080813e-02f, -9.99944210e-02f, 2.66879611e-02f, 2.70245317e-02f, 1.43432394e-02f, 4.87345420e-02f, -2.99309380e-02f, -8.54388848e-02f, 5.15042841e-02f, -1.96100473e-02f,
  -1.96839832e-02f, -2.89799105e-02f, -9.09797773e-02f, -4.06836420e-02f, 1.44407935e-02f, 4.73715626e-02f, 9.38068181e-02f, -4.47815731e-02f, 1.62025429e-02f, -4.99459170e-02f,
  -2.74480373e-01f, 6.94995075e-02f, -1.26540869e-01f, -1.79906577e-01f, 6.88696280e-02f, 1.21884063e-01f, 1.86873645e-01f, 7.83557072e-02f, 3.56670767e-02f, 7.27612525e-02f,
  9.45441052e-02f, -1.99614819e-02f, 1.34625658e-03f, -6.21665418e-02f, 9.59297195e-02f, -1.33006005e-02f, -1.27288084e-02f, -1.82821333e-01f, -1.31524950e-01f, 1.13597170e-01f,
  9.94749516e-02f, -8.34323615e-02f, -2.00427726e-01f, -5.32426983e-02f, -4.24078479e-02f, 4.03704643e-02f, -8.16465989e-02f, -1.13988407e-01f, 2.26703975e-02f, -2.02149767e-02f,
  -1.39587715e-01f, -1.24950767e-01f, 5.55123799e-02f, -6.74148509e-03f, 6.05671182e-02f, 6.71370840e-03f, 3.46664414e-02f, -1.20988876e-01f, -4.11941744e-02f, -6.07372960e-03f,
  -4.49456275e-02f, 6.16770051e-02f, -6.40683547e-02f, 2.27791145e-02f, -3.30235213e-02f, -7.73850679e-02f, -3.37979198e-02f, -8.42860341e-02f, -3.22972760e-02f, -9.48196948e-02f,
  1.04277566e-01f, 4.95369025e-02f, -7.74652138e-02f, -8.67654942e-03f, 4.65211533e-02f, -9.41611305e-02f, 1.46216131e-03f, -1.11196786e-01f, 4.70817424e-02f, -1.13612629e-01f,
  6.68768659e-02f, -1.21400179e-02f, 3.66454124e-02f, -1.16042066e-02f, 1.11603644e-02f, -2.43129432e-02f, 2.69237105e-02f, 2.63810512e-02f, 8.93938914e-03f, -7.04769865e-02f,
  1.47386799e-02f, -2.89858915e-02f, -6.47797212e-02f, 2.05494883e-03f, 1.03257094e-02f, -3.42129134e-02f, 1.26026403e-02f, 1.01190239e-01f, -8.80840793e-02f, 9.86678805e-03f,
  5.24471179e-02f, 4.69279587e-02f, -1.02654107e-01f, -5.73984608e-02f, -6.37278631e-02f, -2.45023239e-03f, -8.24468210e-02f, -7.05446536e-03f, 1.92593653e-02f, 3.37591432e-02f,
  2.45050471e-02f, -1.13789188e-02f, 7.54567087e-02f, -1.03033921e-02f, -1.29737686e-02f, 1.73710231e-02f, -2.54676007e-02f, -1.23527162e-02f, 3.98667343e-02f, 1.03971697e-02f,
  -8.06295052e-02f, -4.60882410e-02f, 4.40133661e-02f, -6.19846396e-02f, -3.23044434e-02f, 5.87246157e-02f, 6.66002259e-02f, 8.85995775e-02f, 3.24739255e-02f, -7.36663416e-02f,
  6.43427297e-02f, 5.58828786e-02f, 1.16983227e-01f, 1.05547374e-02f, -5.37366644e-02f, -8.01572017e-03f, 2.63022594e-02f, 6.03689700e-02f, 9.03685093e-02f, 1.40810624e-01f,
  -1.14679448e-02f, 1.92180738e-01f, -1.25940070e-01f, 1.30441755e-01f, 1.79030597e-01f, -8.55900124e-02f, -1.00264572e-01f, -1.35225356e-01f, 7.08657503e-02f, 1.19531289e-01f,
  9.51516703e-02f, -3.49679589e-02f, 3.30118462e-02f, -2.95850728e-02f, -1.73426315e-01f, -4.10571881e-02f, 8.37751627e-02f, -5.17431870e-02f, -2.28973374e-01f, -1.52790383e-01f,
  3.30469832e-02f, 1.00881599e-01f, 3.38980146e-02f, -1.02782361e-02f, 1.21452525e-01f, -1.05304427e-01f, 1.42801236e-02f, 1.44215092e-01f, 1.65890947e-01f, 2.79058427e-01f,
  -7.79354051e-02f, 2.52537966e-01f, -8.95251408e-02f, -3.44333537e-02f, 2.13194937e-02f, -1.42735280e-02f, 1.14600472e-02f, 1.11292236e-01f, 1.14380773e-02f, 5.18919975e-02f,
  -5.64082852e-03f, 1.33394584e-01f, -2.25052610e-02f, 8.32024142e-02f, 5.90443844e-03f, -6.59350976e-02f, -1.19819921e-02f, 1.99317150e-02f, -7.29299635e-02f, -8.36343169e-02f,
  6.80548176e-02f, 9.27245542e-02f, 2.57609691e-02f, 2.23006643e-02f, -6.96092006e-03f, -1.11892987e-02f, 1.89997964e-02f, -2.07242207e-03f, 8.39771554e-02f, 2.54061501e-02f,
  -4.28359434e-02f, 1.38358831e-01f, -6.30502179e-02f, 1.16189584e-01f, -1.09784760e-01f, 2.09718030e-02f, 5.08219413e-02f, 2.57946234e-02f, 2.42369398e-02f, -1.77462380e-02f,
  2.10951231e-02f, -1.41477853e-01f, 3.22815925e-02f, 9.12418589e-03f, 2.57755835e-02f, 4.12962027e-02f, -3.23532596e-02f, -2.32989361e-04f, -5.88604771e-02f, 1.49973799e-02f,
  5.56560941e-02f, -1.30197480e-02f, -3.67679670e-02f, -3.92350070e-02f, 5.13342656e-02f, 2.31419690e-02f, 2.82734539e-02f, -7.78385671e-03f, 1.74038690e-02f, 2.92403828e-02f,
  -1.59202352e-01f, -9.51165054e-03f, 3.25784534e-02f, -2.15829872e-02f, -6.60915207e-03f, 9.91966296e-03f, 9.59203765e-03f, -6.04231982e-03f, 1.20295674e-01f, -7.32227787e-02f,
  1.47069162e-02f, -1.00229196e-01f, 2.54976265e-02f, -7.90196359e-02f, -1.29354656e-01f, 1.72895659e-02f, -6.80538341e-02f, -1.14691302e-01f, -2.55869180e-02f, -2.78157983e-02f,
  -1.18749760e-01f, -2.17145085e-01f, -2.00308740e-01f, -1.05557077e-01f, -7.24468008e-02f, -2.20380679e-01f, -7.80599788e-02f, -7.71341175e-02f, -1.44519210e-01f, -3.64266604e-01f,
  -9.69688147e-02f, 5.58119826e-02f, 9.59921479e-02f, 1.99253038e-02f, 8.68710577e-02f, 1.04690262e-03f, 1.15621902e-01f, -1.09399535e-01f, -5.32850325e-02f, 7.83910137e-03f,
  5.71635850e-02f, 1.98773686e-02f, -4.13336977e-02f, 7.76064699e-04f, -5.42253405e-02f, 8.14731196e-02f, 1.37851670e-01f, 1.52801052e-02f, -1.90202281e-01f, -2.07986701e-02f,
  1.16019048e-01f, 1.29194677e-01f, -8.82401466e-02f, -1.32934943e-01f, 1.67989716e-01f, -1.13686815e-01f, -2.08986718e-02f, 1.38796240e-01f, 9.06741694e-02f, 2.82534510e-01f,
  1.93385370e-02f, 4.28374223e-02f, -6.39731660e-02f, 3.38460840e-02f, 8.50413591e-02f, -8.18897933e-02f, -4.60984260e-02f, -5.61241731e-02f, -1.85954794e-02f, -4.10300791e-02f,
  1.34793371e-01f, -5.15109822e-02f, 6.80450648e-02f, -6.41060099e-02f, 3.00898012e-02f, -5.62679619e-02f, -7.71616772e-02f, 4.38193977e-02f, -6.76633343e-02f, -4.53340411e-02f,
  4.94437553e-02f, 1.33602411e-01f, 5.65959290e-02f, 1.57225579e-02f, -7.67519278e-03f, 1.22572826e-02f, 1.72617976e-02f, -7.14965612e-02f, 1.68237388e-02f, -9.24776681e-03f,
  -7.21204877e-02f, -9.77853127e-03f, -4.95657288e-02f, 7.33857453e-02f, 5.60085289e-02f, -7.15546906e-02f, 3.66421975e-02f, -4.39812094e-02f, -6.32706434e-02f, -1.53416302e-02f,
  -1.72845717e-03f, 1.97523162e-02f, -8.49112943e-02f, 6.53833002e-02f, 6.81352019e-02f, 3.69599368e-03f, 5.99615350e-02f, 5.49721755e-02f, 3.47128548e-02f, 4.12551314e-02f,
  -3.35370749e-02f, -2.67978646e-02f, 3.70829292e-02f, 3.78574096e-02f, 3.03759631e-02f, -9.62592214e-02f, 6.70745596e-02f, -6.84010163e-02f, -2.91700084e-02f, 6.28020242e-02f,
  -7.27611110e-02f, -1.38221651e-01f, -3.94097380e-02f, -4.32410324e-03f, -2.55374722e-02f, -3.33519578e-02f, 4.72830579e-04f, 1.15419552e-02f, 6.45488426e-02f, -1.82679109e-02f,
  -8.64594802e-02f, 3.24200615e-02f, -1.90111902e-02f, -1.21730873e-02f, 8.12447164e-03f, 6.79412931e-02f, 1.06980607e-01f, 7.16806874e-02f, 2.86956541e-02f, 9.85184684e-02f,
  -4.03737985e-02f, 9.40221623e-02f, 2.05282737e-02f, -4.65767458e-02f, 1.21936686e-02f, -7.49168918e-02f, -2.74432544e-02f, 7.02559054e-02f, -2.75699571e-02f, -8.33775941e-03f,
  -1.72867119e-01f, 4.05159220e-02f, 1.97288662e-01f, -2.83634961e-01f, -7.96628147e-02f, 8.91633183e-02f, 2.95038462e-01f, 6.76035322e-03f, -1.65331766e-01f, 8.44928771e-02f,
  -1.33704320e-01f, -9.13067013e-02f, -1.83306132e-02f, -9.27164778e-03f, 1.06289171e-01f, 1.78002730e-01f, 2.14152634e-01f, 1.90540224e-01f, 5.63770384e-02f, -2.26571923e-03f,
  1.46336267e-02f, -1.07969642e-01f, -1.14096917e-01f, -8.50672126e-02f, -5.06437458e-02f, 2.98803532e-03f, -3.60898450e-02f, -1.43037528e-01f, 4.09587063e-02f, -4.56535909e-03f,
  2.08460316e-01f, -2.38217618e-02f, 1.37724429e-01f, -1.10823810e-01f, 8.89050215e-03f, -5.73274679e-02f, -1.81297716e-02f, 2.43890993e-02f, -4.11406113e-03f, -1.48376764e-03f,
  -9.59988590e-03f, -6.07407615e-02f, 2.48892661e-02f, -5.77353612e-02f, -5.54597192e-02f, -4.39163903e-03f, -5.34512550e-02f, -3.05769891e-02f, -1.64423864e-02f, 3.13185528e-02f,
  -2.11633705e-02f, -1.11470364e-01f, -6.70028701e-02f, -3.80805098e-02f, 1.27708921e-02f, -7.34689459e-02f, -8.02141428e-02f, -6.89278543e-02f, 1.30856866e-02f, -2.12490335e-02f,
  -6.75770193e-02f, -1.26936929e-02f, 6.12077117e-02f, 2.77402382e-02f, -2.62954943e-02f, 6.16203919e-02f, -4.81087938e-02f, 9.54138786e-02f, 3.25486035e-04f, 6.62763491e-02f,
  -4.14905623e-02f, 1.45783303e-02f, 3.69962119e-02f, -5.31028919e-02f, 1.70570202e-02f, 1.30219869e-02f, 1.03484085e-02f, 2.32848208e-02f, -7.11163878e-02f, -4.02746070e-03f,
  -8.10590014e-02f, -2.81160343e-02f, -6.42273277e-02f, 3.55430357e-02f, 7.02146590e-02f, 3.53219802e-03f, -1.07633946e-02f, 3.82975340e-02f, -7.86813721e-02f, 1.31205609e-02f,
  -1.68085605e-01f, 6.34885654e-02f, 6.10644817e-02f, 7.78701752e-02f, 6.31558057e-03f, -9.95762199e-02f, 4.75816652e-02f, -8.14874936e-03f, -1.16076265e-02f, -1.91297736e-02f,
  3.31809036e-02f, 3.02730594e-02f, 7.89971128e-02f, -4.26119678e-02f, 5.24448138e-03f, -9.77285113e-03f, -6.37734011e-02f, 5.57560176e-02f, 1.34946713e-02f, -3.37929092e-02f,
  -6.88641146e-02f, 2.84773875e-02f, 6.74566701e-02f, 7.46574253e-02f, -6.62524924e-02f, 1.19657621e-01f, 1.41026780e-01f, -7.48180039e-03f, 1.36067390e-01f, -8.94441605e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.68638030e-02f, -7.69866332e-02f, -1.46658406e-01f, -9.02807340e-02f, -1.98064018e-02f, -1.09332524e-01f, -4.57930518e-03f, -7.72304237e-02f, 2.44506225e-02f, -1.34279821e-02f,
  -1.20339356e-01f, -4.22090515e-02f, 1.86866857e-02f, -7.44815636e-03f, -7.67141804e-02f, -1.32794380e-01f, -1.78379580e-01f, -2.78358515e-02f, -8.73457342e-02f, -1.37580764e-02f,
  5.74023575e-02f, 5.27178384e-02f, 8.56260210e-02f, 4.76252753e-03f, -1.07791342e-01f, 2.48224102e-02f, -1.41109928e-01f, -1.62059646e-02f, 3.41181494e-02f, -4.66116779e-02f,
  -1.75382569e-01f, 5.72620556e-02f, 4.18155566e-02f, 5.03119174e-03f, -6.84203282e-02f, 1.04462858e-02f, 2.69804727e-02f, -2.98822187e-02f, 5.37497252e-02f, -9.38275605e-02f,
  3.65094356e-02f, -8.86982400e-03f, 3.20410319e-02f, -5.17262258e-02f, 1.05132805e-02f, -3.20156501e-03f, 7.00432360e-02f, 3.16124340e-03f, 9.34379101e-02f, 5.51234260e-02f,
  5.00808051e-03f, -5.22108227e-02f, 5.33446632e-02f, 1.12443301e-03f, -4.83921394e-02f, 2.88601983e-02f, 2.33490299e-02f, -2.05266755e-02f, -6.03533015e-02f, -5.99252693e-02f,
  -4.49611247e-02f, -1.43039692e-02f, 7.75817260e-02f, 6.10049441e-02f, -6.63393037e-03f, -1.51392678e-03f, 2.03567240e-02f, 1.47255687e-02f, -3.40940170e-02f, -1.93544906e-02f,
  1.75877158e-02f, -4.69463356e-02f, 5.35359904e-02f, -5.13600782e-02f, -1.21041894e-01f, 1.04863560e-02f, -5.56511171e-02f, -7.45729962e-03f, 4.14076149e-02f, 2.07925541e-03f,
  5.63445166e-02f, -7.42374361e-03f, 6.96455920e-03f, 1.43719865e-02f, 2.12357234e-04f, 1.95640400e-02f, -1.23070050e-02f, -7.92222172e-02f, -8.35631192e-02f, -5.88980876e-02f,
  -3.51038501e-02f, -7.34208524e-02f, -1.45424362e-02f, 5.84190153e-02f, -1.47413695e-02f, 3.80677246e-02f, -6.97766766e-02f, 7.06580356e-02f, -1.80523060e-02f, 7.12057203e-02f,
  -2.41276231e-02f, 7.91589990e-02f, 3.83887696e-03f, -2.05969773e-02f, 3.92859355e-02f, -6.69799000e-02f, 5.19497916e-02f, 5.49240895e-02f, 2.60652471e-02f, 7.93700740e-02f,
  -7.43586347e-02f, 8.04050788e-02f, 5.89160398e-02f, -6.85951784e-02f, 5.34590557e-02f, -4.00986746e-02f, -9.06395391e-02f, 6.53898120e-02f, 4.53659967e-02f, 1.01771590e-03f,
  2.00177520e-03f, -5.82922287e-02f, -6.31027147e-02f, -1.20402001e-01f, 4.05587107e-02f, -8.05312544e-02f, 2.73195258e-03f, -7.99611136e-02f, 3.59790809e-02f, 5.36474362e-02f,
  8.04887787e-02f, 1.40026242e-01f, 9.08060446e-02f, 2.73924172e-02f, 7.54770115e-02f, 4.14027236e-02f, -1.21874183e-01f, 9.41491053e-02f, 1.52193204e-01f, 2.82333642e-02f,
  1.97713245e-02f, -4.37754057e-02f, 2.71462724e-02f, -2.59253047e-02f, -1.05201885e-01f, 1.02720104e-01f, -4.41594282e-03f, -1.36832163e-01f, -2.63234451e-02f, -1.50555715e-01f,
  3.17178607e-01f, -2.43857466e-02f, 1.15357265e-02f, 2.88171694e-02f, -9.27942246e-02f, 2.62467470e-02f, -5.91714382e-02f, 4.82386425e-02f, 4.34807129e-02f, -1.72024388e-02f,
  -8.39424208e-02f, -1.34063056e-02f, -3.91869918e-02f, 3.79711576e-02f, -5.16231246e-02f, 5.04252538e-02f, -3.81012671e-02f, -2.86022853e-02f, 6.41354695e-02f, 7.46083586e-03f,
  7.31585696e-02f, 6.95372000e-02f, 7.82957450e-02f, -1.34281591e-02f, 8.83276612e-02f, 6.73183799e-02f, 4.92487028e-02f, 1.70127861e-02f, 3.13585363e-02f, -5.32554202e-02f,
  -4.41896322e-04f, -6.42960472e-03f, -2.57291719e-02f, 9.05541629e-02f, -2.08757296e-02f, 9.12077539e-03f, -7.48991594e-03f, 1.03730060e-01f, 6.66561648e-02f, -8.71292576e-02f,
  3.53988260e-02f, 8.26823190e-02f, 6.76966757e-02f, 6.23459145e-02f, -4.24501300e-02f, -6.88855201e-02f, 1.06763495e-02f, -4.05493705e-03f, 7.02456087e-02f, -2.82225683e-02f,
  6.02575280e-02f, -9.22904983e-02f, 4.22943607e-02f, -7.47113079e-02f, 1.95720196e-02f, -5.69057502e-02f, -6.40548915e-02f, 5.19982092e-02f, -2.82419734e-02f, -2.35031061e-02f,
  1.61810875e-01f, 1.10338435e-01f, 1.06263109e-01f, -1.79650392e-02f, -1.04830392e-01f, -5.79315126e-02f, 8.10583681e-02f, -4.41743359e-02f, 8.40166584e-03f, 1.84028950e-02f,
  2.77093053e-02f, 6.23586886e-02f, -6.60638092e-03f, -8.75917748e-02f, -3.58994603e-02f, 8.08423609e-02f, -6.84048906e-02f, 1.00652255e-01f, 9.96412523e-03f, 2.25324444e-02f,
  -8.22913870e-02f, 6.73158914e-02f, 1.25129357e-01f, 1.19534403e-01f, 2.14853184e-03f, 1.11162178e-01f, 3.13249673e-03f, 6.50564581e-02f, 2.05452479e-02f, 8.68673250e-02f,
  6.03486598e-02f, 5.24844825e-02f, -1.04336157e-01f, 1.27918750e-01f, 1.04860216e-01f, -1.57899469e-01f, -2.77445346e-01f, -1.77624673e-01f, -1.22498218e-02f, 2.39917208e-02f,
  7.75191933e-02f, 6.66686445e-02f, -8.34494159e-02f, -2.92510223e-02f, -2.30903402e-01f, -4.90575060e-02f, 4.18182313e-02f, -3.08087729e-02f, -7.27360398e-02f, 2.76086014e-02f,
  8.10441747e-02f, 9.95048210e-02f, -4.24833186e-02f, -9.51083452e-02f, 1.33379340e-01f, 1.57119155e-01f, 2.32181996e-02f, 1.00696526e-01f, 6.21393062e-02f, 1.43227547e-01f,
  8.50458220e-02f, 3.80049758e-02f, 7.57700428e-02f, 1.61358848e-01f, 1.28240198e-01f, -7.49589726e-02f, -6.67593069e-03f, -6.32532611e-02f, -6.72373474e-02f, -2.84492392e-02f,
  7.55456686e-02f, -3.16724777e-02f, 3.51784547e-04f, 2.88858861e-02f, -9.27996039e-02f, 4.06895764e-02f, 2.19970327e-02f, -9.30197090e-02f, -8.92452076e-02f, -2.49196775e-03f,
  7.43710473e-02f, 9.75866686e-04f, -2.89838761e-02f, -1.19778320e-01f, -7.06242723e-03f, -1.53580755e-02f, 5.46120144e-02f, 7.28804916e-02f, -1.02821141e-01f, 6.43607229e-02f,
  2.95514781e-02f, 2.21468206e-03f, 2.34462712e-02f, 1.37322098e-02f, 3.76694016e-02f, -4.17851061e-02f, -1.63273700e-02f, 9.22720134e-02f, -8.34649727e-02f, -3.46142016e-02f,
  -8.93830582e-02f, -8.94002467e-02f, -2.74597891e-02f, -1.91253237e-02f, -1.43937580e-02f, 1.08815767e-02f, 5.95760010e-02f, -5.70106413e-03f, -1.16514564e-02f, 5.20224012e-02f,
  -6.58373209e-03f, -1.97908375e-02f, 6.91261515e-02f, -1.90925132e-02f, 4.42889296e-02f, 3.39274779e-02f, 1.03634298e-01f, -6.66724741e-02f, 3.39833871e-02f, 7.19684213e-02f,
  7.62426406e-02f, -7.36905038e-02f, 1.39892906e-01f, 8.24303180e-02f, 1.42583940e-02f, 3.39690074e-02f, 7.92033076e-02f, 4.10257429e-02f, -1.40200406e-02f, -6.42742217e-02f,
  -3.42716202e-02f, -2.44007446e-02f, -1.02720764e-02f, -8.65604449e-03f, 5.11637442e-02f, -8.42398107e-02f, -7.84261599e-02f, -4.07162309e-02f, -1.13905154e-01f, 1.12095824e-03f,
  -4.21376154e-02f, -5.85257523e-02f, -1.05235383e-01f, -1.56909004e-01f, -6.63777441e-02f, -1.31456961e-03f, -1.21107876e-01f, 4.75896969e-02f, -4.52593528e-02f, -1.19895943e-01f,
  -6.35822117e-02f, -1.73458472e-01f, -1.10197902e-01f, 1.31585374e-01f, 1.16841518e-03f, -2.84131635e-02f, -1.10186160e-01f, 5.39946556e-02f, 4.27562147e-02f, -5.27080446e-02f,
  -3.48498225e-02f, 1.40386328e-01f, -2.23721024e-02f, 3.90440784e-02f, -1.11020841e-01f, -1.56638458e-01f, -1.71972111e-01f, -2.35857610e-02f, 4.16461788e-02f, 1.52154803e-01f,
  2.90219095e-02f, -4.50640079e-03f, 4.61720563e-02f, 8.21521953e-02f, -3.27939726e-02f, -5.24205342e-02f, -2.07761619e-02f, -6.94266185e-02f, 1.49894245e-02f, -1.62851572e-01f,
  4.35537659e-02f, 3.98696512e-02f, -7.00454088e-03f, 2.81290989e-02f, -2.85995957e-02f, 5.31588979e-02f, -9.44895612e-04f, 1.23872580e-02f, -1.06767369e-02f, -5.14655523e-02f,
  5.80346249e-02f, 1.40176062e-02f, -7.95734525e-02f, 8.96244943e-02f, 8.17498714e-02f, -4.80410568e-02f, -1.02638550e-01f, -5.20505346e-02f, -4.80333269e-02f, 3.88186350e-02f,
  -5.89771532e-02f, -4.11670394e-02f, -8.67543742e-02f, -1.33948043e-01f, -4.99568582e-02f, -7.78976232e-02f, -1.38686150e-01f, -9.09283236e-02f, -1.49442360e-01f, -3.45732458e-02f,
  -1.55116711e-02f, -3.28010283e-02f, 6.78338408e-02f, -7.95707256e-02f, 1.17584374e-02f, -1.96067318e-02f, -5.45258112e-02f, 1.52730318e-02f, 2.07026973e-02f, -8.90030991e-03f,
  -1.05457753e-02f, 7.40191787e-02f, 3.87402512e-02f, 7.86509085e-03f, -1.07095361e-01f, 1.67222414e-02f, -5.48558123e-02f, -6.75578928e-03f, -1.09509386e-01f, -1.43347597e-02f,
  1.89078134e-02f, -1.24573149e-01f, 2.38648187e-02f, 4.27093245e-02f, -1.02321520e-01f, 6.45779371e-02f, 1.65631399e-02f, 6.63206428e-02f, 1.12082232e-02f, 2.49032192e-02f,
  6.40517101e-02f, -1.46930814e-01f, -4.83980477e-02f, 5.75567130e-03f, -3.14698182e-03f, -4.13620546e-02f, -3.91812902e-03f, -2.37266757e-02f, 1.23346001e-02f, -7.25940987e-02f,
  2.91889682e-02f, -4.46525961e-02f, -1.05994046e-02f, -6.05708957e-02f, -2.40616989e-03f, -6.18932210e-02f, -3.39075513e-02f, -6.90370873e-02f, -3.54363881e-02f, -4.98997085e-02f,
  2.46422943e-02f, 3.44677828e-02f, -8.51143673e-02f, -1.09232500e-01f, -8.27609450e-02f, -8.21616426e-02f, -1.19143829e-01f, -7.17170769e-03f, -1.28304943e-01f, -1.31475687e-01f,
  3.73972170e-02f, -3.40884440e-02f, 1.17699336e-02f, 9.16983709e-02f, 7.85585269e-02f, 8.26617703e-02f, 1.24650314e-01f, -5.14772460e-02f, -1.56659186e-02f, -3.67136858e-02f,
  5.10627823e-03f, 3.10685788e-03f, 7.00282753e-02f, -1.99363530e-02f, 1.02811679e-02f, 8.53727981e-02f, 8.77105689e-04f, 8.17483664e-02f, -4.64957133e-02f, 9.27189365e-02f,
  1.12921603e-01f, 9.45706666e-02f, -5.95473610e-02f, -7.53295496e-02f, 2.94108759e-03f, -7.74319051e-03f, 8.02231878e-02f, 1.17500871e-01f, -6.66780919e-02f, 7.70263895e-02f,
  -3.50819193e-02f, 1.03134833e-01f, -7.67217651e-02f, -3.67673598e-02f, 1.41640322e-03f, -6.93132579e-02f, 3.38925198e-02f, 5.30607887e-02f, -3.49582322e-02f, -8.32105801e-02f,
  9.31321532e-02f, -7.74693042e-02f, 9.38761085e-02f, -3.94439250e-02f, 8.15224722e-02f, 3.15592811e-02f, 9.59655493e-02f, 6.38859496e-02f, 7.23695680e-02f, -4.11538295e-02f,
  -1.44530684e-02f, -2.16890648e-02f, 8.46746713e-02f, -1.08987028e-02f, 8.75289738e-02f, 5.75088384e-03f, -3.37806679e-02f, 7.63234496e-02f, 5.36996536e-02f, -2.50573941e-02f,
  -1.51193840e-02f, 6.46626353e-02f, 6.97193667e-02f, 7.10549057e-02f, 7.98975825e-02f, -7.48118311e-02f, -6.18588030e-02f, -5.78053109e-03f, 4.10119705e-02f, -3.79334018e-02f,
  7.57879913e-02f, 1.30724506e-02f, 8.64358544e-02f, -4.37295549e-02f, -3.57887037e-02f, 8.98473114e-02f, -1.02866571e-02f, -5.46714067e-02f, -1.86540540e-02f, 2.89417189e-02f,
  -2.09416077e-02f, 5.00016809e-02f, -6.01025186e-02f, 3.34545448e-02f, 8.18769857e-02f, 1.53198177e-02f, -2.04431694e-02f, 6.28620910e-04f, -2.22446006e-02f, -3.60190216e-03f,
  -4.33766376e-03f, -5.36832996e-02f, -3.82717177e-02f, 8.59561637e-02f, 2.14049849e-03f, 4.78794686e-02f, -3.79954316e-02f, 8.82479772e-02f, 8.08299631e-02f, 6.92270920e-02f,
  8.13914184e-03f, -1.06505856e-01f, 4.56831306e-02f, -2.67567020e-02f, -2.81027071e-02f, 7.09497258e-02f, -6.09754473e-02f, 9.91097540e-02f, -5.19807227e-02f, -1.95219964e-02f,
  6.40432537e-02f, 1.99512057e-02f, 1.07578961e-02f, -6.90481141e-02f, 4.80436049e-02f, 8.42044801e-02f, 6.20765984e-02f, 4.68038060e-02f, 4.01672907e-03f, -1.44322368e-03f,
  4.28922754e-03f, -1.06355429e-01f, -5.90369804e-03f, 7.26446211e-02f, 6.61264285e-02f, 5.65529466e-02f, -1.09226979e-01f, 6.97777187e-03f, -2.04276089e-02f, 5.33490553e-02f,
  2.49159727e-02f, -3.38791423e-02f, 1.23631902e-01f, 7.74851292e-02f, 3.99355404e-02f, -3.47696804e-02f, -3.28571647e-02f, 1.03997178e-01f, 1.78895295e-02f, 1.13236018e-01f,
  -1.27134388e-02f, -5.49792759e-02f, 9.97276008e-02f, 1.06734283e-01f, 1.97124332e-02f, 4.67911959e-02f, -2.97261775e-02f, -3.08117922e-02f, 2.85032019e-03f, 6.41883165e-02f,
  3.49633512e-03f, -3.87043841e-02f, 1.16450332e-01f, 6.81002736e-02f, 1.08135026e-02f, 3.54551673e-02f, -3.04448847e-02f, 9.25999656e-02f, 5.54297864e-02f, -3.63703147e-02f,
  -7.20134601e-02f, 1.45655898e-02f, -4.13101763e-02f, 8.94461498e-02f, -3.67721799e-03f, -5.13676256e-02f, 5.45583144e-02f, -3.95253263e-02f, 2.78170127e-02f, 1.26536004e-02f,
  3.24683562e-02f, 5.59625216e-02f, 2.60035414e-02f, -3.97376940e-02f, -2.82031316e-02f, 8.65872353e-02f, 2.24524029e-02f, -5.11499532e-02f, 7.04730898e-02f, 1.06334671e-01f,
  -5.10757491e-02f, 6.14339625e-03f, -2.72709914e-02f, 3.94491805e-03f, -5.06595746e-02f, -4.94720489e-02f, -2.23315135e-02f, -5.78217255e-03f, -2.95164324e-02f, -5.99600896e-02f,
  3.23636420e-02f, 1.07106548e-02f, 7.39075243e-02f, 4.40390632e-02f, -2.05077697e-02f, -2.23679431e-02f, 6.01614229e-02f, -6.05978407e-02f, -4.54330407e-02f, 3.10492180e-02f,
  -7.07963780e-02f, -6.08602129e-02f, 8.59817713e-02f, 3.99069972e-02f, 1.04944013e-01f, 6.40592910e-03f, 3.29842907e-03f, 2.99883839e-02f, -1.57230739e-02f, 3.15144584e-02f,
  5.34345321e-02f, -7.26240501e-02f, -3.18498202e-02f, -1.12446044e-02f, -2.96562836e-02f, -4.82672788e-02f, -3.65179824e-03f, 9.07523185e-02f, 1.80013082e-03f, 9.37621575e-03f,
  -6.52950555e-02f, 5.53745544e-03f, -3.15795913e-02f, -9.13515687e-02f, -3.90558988e-02f, -1.46529591e-02f, -8.51906687e-02f, 4.67635226e-03f, -2.44017388e-03f, 4.26728139e-03f,
  5.57737499e-02f, -4.37665284e-02f, -1.06013538e-02f, 6.82878569e-02f, -3.08182952e-03f, -5.02636097e-02f, 5.51366545e-02f, 7.46267438e-02f, -8.39889348e-02f, 3.62292975e-02f,
  1.05378278e-01f, -2.48726010e-02f, -1.49830189e-02f, 1.19670361e-01f, -1.07297394e-02f, 4.73156013e-02f, -6.10057153e-02f, 1.06924802e-01f, -3.50271091e-02f, 3.85926501e-03f,
  -5.82314171e-02f, 6.63693175e-02f, -1.77854262e-02f, 1.53110996e-02f, 4.13119458e-02f, 1.39904484e-01f, 1.05436735e-01f, 1.25592396e-01f, 1.35048211e-01f, 6.21319301e-02f,
  -4.92030978e-02f, 5.03909178e-02f, -3.02431472e-02f, -4.37982380e-03f, 3.19979066e-04f, 1.83328260e-02f, 2.60757096e-02f, -2.12179087e-02f, 2.47321464e-02f, 1.03573054e-01f,
  6.66447356e-02f, 1.47074228e-02f, 1.17640540e-01f, 7.10683390e-02f, -6.29331246e-02f, 1.26306061e-02f, 3.66519764e-02f, -2.06884183e-02f, -5.38109988e-02f, -6.13644719e-02f,
  -1.95355248e-02f, -1.33029725e-02f, -3.22420672e-02f, 4.65450659e-02f, -9.13452432e-02f, 4.87923436e-02f, -9.39897150e-02f, 3.58468890e-02f, 1.38971865e-01f, -6.13823645e-02f,
  3.50981355e-02f, 2.46940292e-02f, -2.23755650e-03f, -4.71591838e-02f, -7.80315232e-03f, 1.14596352e-01f, -1.57354847e-02f, 9.08777863e-02f, 4.71362881e-02f, 6.63157925e-02f,
  -4.64305095e-02f, -5.40860891e-02f, -9.01086081e-04f, 3.53736132e-02f, 1.61116328e-02f, -3.45601290e-02f, -3.36448178e-02f, -9.03890748e-03f, 8.42891112e-02f, -3.70723009e-02f,
  -3.94158401e-02f, 4.75539155e-02f, 1.78068541e-02f, 8.37343112e-02f, -6.74933344e-02f, 5.74108511e-02f, -2.60931123e-02f, -1.36819845e-02f, 1.42960567e-02f, 1.57138109e-02f,
  5.02373427e-02f, 7.16491416e-02f, -8.62396285e-02f, 8.22714996e-03f, 1.23068234e-02f, 8.77281725e-02f, -5.72193824e-02f, 8.07223469e-02f, 6.18823022e-02f, 4.64136899e-02f,
  5.37714772e-02f, -1.76806599e-02f, -2.52084229e-02f, -7.46109569e-03f, -3.64573002e-02f, 2.65281405e-02f, 1.65408775e-02f, -5.38588576e-02f, 3.95360328e-02f, 5.28194755e-02f,
  -3.23420763e-02f, 3.51312943e-02f, -7.42674544e-02f, 4.64882590e-02f, -5.52361347e-02f, -2.15315577e-02f, 7.49139115e-02f, 4.71596187e-03f, 6.96277618e-02f, 1.47489160e-02f,
  5.50683448e-03f, 1.94295477e-02f, 6.25035912e-02f, -6.00581914e-02f, 5.91579415e-02f, 1.19157039e-01f, -7.59088770e-02f, -7.18436539e-02f, 4.74449154e-03f, -1.02959856e-01f,
  2.59318531e-01f, -8.90397429e-02f, -1.38061211e-01f, -1.44724831e-01f, -3.06835994e-02f, -7.99931586e-02f, -1.37328938e-01f, 7.18291551e-02f, -5.42173162e-02f, -1.91013083e-01f,
  -2.35720687e-02f, 1.01363376e-01f, 1.16666451e-01f, 7.19974115e-02f, 5.52632362e-02f, -1.86998725e-01f, -1.54581487e-01f, 1.79031305e-02f, 1.27832517e-01f, 7.15893358e-02f,
  -5.13213351e-02f, -5.93985915e-02f, 1.22467734e-01f, -2.96643320e-02f, -1.78758010e-01f, 3.08228354e-03f, -2.08122343e-01f, -1.07980810e-01f, -7.81445876e-02f, -2.15331033e-01f,
  -1.04434915e-01f, 1.88384667e-01f, -7.01162219e-02f, 1.15830399e-01f, -1.00896999e-01f, 1.80049310e-03f, -1.60161033e-02f, 5.27801886e-02f, 5.66453449e-02f, -9.62670073e-02f,
  3.68665569e-02f, -1.43868160e-02f, 6.74020080e-03f, 1.07073203e-01f, -7.88739324e-03f, 3.19115818e-03f, -5.53110763e-02f, -1.96168236e-02f, 5.40879613e-04f, -1.50111588e-02f,
  -7.99925774e-02f, 1.59009807e-02f, 4.79405038e-02f, -8.55595991e-02f, 5.01568094e-02f, 6.95509762e-02f, -5.74702732e-02f, -5.60658276e-02f, 1.13663241e-01f, -6.88920170e-02f,
  -2.44840961e-02f, -4.45552878e-02f, -5.47285716e-04f, 9.60402340e-02f, -2.67098341e-02f, 3.66920158e-02f, 2.30164770e-02f, -6.23335887e-04f, 4.80346344e-02f, 1.73128303e-02f,
  2.62185819e-02f, -1.02255642e-01f, -2.97612213e-02f, -4.73232865e-02f, -7.89920166e-02f, -3.91085371e-02f, 7.58162560e-03f, -1.99929718e-02f, -1.53876534e-02f, 4.35687825e-02f,
  -2.18499135e-02f, 3.00767738e-02f, -6.17293492e-02f, 9.45429653e-02f, -8.68235156e-02f, -1.65475737e-02f, 6.26069903e-02f, -1.49903875e-02f, -5.02502872e-03f, 1.29407853e-01f,
  -4.53285724e-02f, 3.96663025e-02f, 2.17197910e-02f, 9.03556570e-02f, -1.23449126e-02f, 5.95629914e-03f, -7.66078904e-02f, -5.52348308e-02f, 5.97407818e-02f, -5.49676307e-02f,
  3.30056883e-02f, 1.82530805e-02f, 3.30496505e-02f, 2.08262466e-02f, 9.56434160e-02f, -4.80498467e-03f, -4.68746051e-02f, 2.03269236e-02f, 5.44503331e-03f, -2.74853073e-02f,
  -1.35751262e-01f, 6.95299730e-02f, 1.43002450e-01f, 6.96157590e-02f, -6.46079257e-02f, 7.04285726e-02f, -1.58052891e-02f, -1.38109652e-02f, 1.16208784e-01f, -6.96265921e-02f,
  -3.98514234e-02f, -5.73922060e-02f, -6.79371208e-02f, 1.84871212e-01f, 8.15832093e-02f, 8.32439139e-02f, 7.46836066e-02f, 1.00450054e-01f, 1.62362486e-01f, 1.63539052e-01f,
  1.40036449e-01f, 6.39995039e-02f, 1.77570850e-01f, 1.70059890e-01f, 1.48549996e-04f, 5.70535511e-02f, 1.93681970e-01f, 5.03095128e-02f, 8.66956711e-02f, 1.02166354e-03f,
  1.32818639e-01f, 6.69889823e-02f, 2.20152475e-02f, 2.43954342e-02f, 2.20630810e-01f, 1.81186214e-01f, 3.84155437e-02f, -2.17041634e-02f, 4.81282435e-02f, 1.63760856e-01f,
  -2.39884872e-02f, -1.57146275e-01f, -2.43242998e-02f, 4.42495123e-02f, -9.58412711e-04f, -3.94595489e-02f, -4.79936861e-02f, -1.60695650e-02f, -4.26969193e-02f, -3.83845344e-02f,
  7.42942318e-02f, -1.12302462e-02f, 2.72964798e-02f, -1.00527428e-01f, -3.42676998e-03f, -6.13275915e-02f, -3.54422517e-02f, -1.02201313e-01f, -2.89140455e-03f, 3.56327556e-02f,
  1.09216139e-01f, -3.09112724e-02f, -1.00823097e-01f, -1.40046505e-02f, -4.93541546e-02f, 7.75064230e-02f, 1.99403614e-02f, -7.30228052e-03f, 3.47985141e-02f, -4.63703461e-02f,
  2.30046492e-02f, -1.72025040e-02f, -3.25470939e-02f, -4.66164108e-03f, 3.11272424e-02f, 5.55007122e-02f, -5.92332659e-03f, 5.48071638e-02f, -3.05156875e-02f, 1.31042628e-02f,
  1.31837819e-02f, 8.91811848e-02f, -4.20438722e-02f, -1.07187685e-02f, -2.33448260e-02f, -3.93411592e-02f, -2.02214401e-02f, -6.07527755e-02f, 2.68238038e-03f, 3.07082366e-02f,
  -4.75432500e-02f, 3.99237350e-02f, -6.45416230e-02f, 1.05580412e-01f, 4.09617126e-02f, 3.78097664e-03f, 1.29555468e-03f, 5.50140962e-02f, -7.13576898e-02f, -1.18607871e-01f,
  -6.06735833e-02f, -4.06776220e-02f, 1.31268770e-01f, 1.77433435e-03f, -3.79060395e-02f, -1.03135884e-01f, 5.21585643e-02f, -6.02435581e-02f, 1.20272879e-02f, -1.43032253e-03f,
  -4.10466678e-02f, -1.04940131e-01f, -2.05698702e-02f, 3.90128940e-02f, -3.82534079e-02f, -3.87670100e-02f, 6.92249089e-02f, 8.32374468e-02f, 1.39633808e-02f, 6.56835437e-02f,
  4.72457781e-02f, -8.47779885e-02f, -7.41184056e-02f, -6.70406967e-02f, 1.91903859e-02f, 5.57276160e-02f, -7.58690536e-02f, -8.66730437e-02f, -1.02708623e-01f, 2.07700022e-02f,
  -1.70586612e-02f, -1.44534454e-01f, 6.99974820e-02f, -3.06604039e-02f, 6.84757605e-02f, -2.46497113e-02f, -3.18989763e-03f, -2.10256539e-02f, -2.91557517e-02f, -6.98436871e-02f,
  -6.77981740e-03f, -6.83413893e-02f, 3.87982577e-02f, 7.82983676e-02f, -9.17837676e-03f, -3.01293861e-02f, -3.79186608e-02f, -2.69361641e-02f, 1.52102038e-01f, 4.54862118e-02f,
  -5.06021157e-02f, 7.35001713e-02f, -4.63857427e-02f, 1.27434330e-02f, -8.55350792e-02f, 8.13426226e-02f, -5.51123321e-02f, -6.55198051e-03f, -4.84556593e-02f, -1.15638711e-01f,
  5.09420736e-03f, 1.19963149e-02f, 1.03351817e-01f, -6.60714731e-02f, -8.14746395e-02f, 4.13311198e-02f, 7.47111812e-02f, -6.88553089e-03f, 7.52215832e-03f, -2.34940872e-02f,
  -5.24884015e-02f, 3.80471647e-02f, -6.75696656e-02f, -3.85788567e-02f, -7.46217221e-02f, 2.70568253e-03f, -9.45112631e-02f, -2.09597163e-02f, 6.61147833e-02f, -9.31529999e-02f,
  6.61764219e-02f, 9.77684110e-02f, 1.84165016e-02f, -2.56908312e-02f, -3.68870050e-02f, -1.89946534e-03f, 2.57279985e-02f, -1.29574556e-02f, 8.91158283e-02f, -1.01275593e-01f,
  3.36775486e-03f, 2.70032454e-02f, -5.80440536e-02f, 2.93423645e-02f, 2.57471635e-04f, 3.66752744e-02f, 1.00101009e-01f, 3.94482128e-02f, 1.17182909e-02f, -1.06750935e-01f,
  -2.34918017e-03f, 4.77788039e-02f, 2.20427494e-02f, -1.29573606e-03f, -2.88449582e-02f, -3.67380045e-02f, 2.71696579e-02f, -6.34306893e-02f, -8.94367136e-03f, 6.97231293e-02f,
  2.72982810e-02f, -7.61635154e-02f, -1.96683835e-02f, -5.50011732e-02f, 3.30358334e-02f, -6.33429065e-02f, -1.22842100e-02f, -3.51547264e-02f, 3.98573056e-02f, 3.17497849e-02f,
  7.63011500e-02f, 3.24358717e-02f, -8.85262247e-03f, 2.08519455e-02f, 6.94580153e-02f, 3.84303518e-02f, -6.98006451e-02f, -6.00830093e-02f, 1.04443923e-01f, 6.59265816e-02f,
  7.57113025e-02f, 2.61593121e-03f, 4.16366234e-02f, 3.19419266e-03f, 2.66529527e-02f, -8.46833140e-02f, -2.73540132e-02f, 1.04758114e-01f, 9.84592959e-02f, 1.21041322e-02f,
  -9.74626616e-02f, 1.20907918e-01f, 1.52246840e-02f, 2.31483523e-02f, 9.07596722e-02f, 1.02922777e-02f, -1.79249253e-02f, -5.12874797e-02f, 1.04904346e-01f, 7.00421482e-02f,
  -9.89255831e-02f, 1.04174301e-01f, -1.00114383e-01f, -1.38423681e-01f, -1.08937629e-01f, -7.46070370e-02f, 1.05109081e-01f, 5.75286858e-02f, -7.17227347e-03f, -9.89281456e-04f,
  -1.25714522e-02f, 2.60300487e-02f, -1.74529050e-02f, -2.05577142e-03f, 6.43334398e-03f, -2.01929305e-02f, -1.15639970e-01f, -3.99743691e-02f, -8.13146904e-02f, -7.01245293e-02f,
  1.15669295e-02f, -6.17675111e-02f, 2.12669419e-03f, -5.15076704e-02f, -9.50727686e-02f, 4.65259664e-02f, -3.89112867e-02f, 2.29017027e-02f, -1.01048395e-01f, 3.78807038e-02f,
  6.47373050e-02f, -5.78468665e-02f, -1.05641276e-01f, -5.70340417e-02f, -6.25607818e-02f, 3.41040082e-02f, 2.93499185e-03f, -6.03668354e-02f, 2.65270825e-02f, 2.11141314e-02f,
  4.04035412e-02f, -7.88426176e-02f, -1.07878242e-02f, -6.72263652e-02f, -3.32356729e-02f, -3.83289568e-02f, 3.86614539e-02f, 1.51394494e-02f, 5.83613329e-02f, 4.77373600e-02f,
  -6.21285066e-02f, 8.97837281e-02f, 5.02209365e-02f, 3.45717743e-02f, 7.46641457e-02f, -1.17099965e-02f, 6.25343397e-02f, -3.75115015e-02f, -5.87559342e-02f, 1.29874244e-01f,
  6.88605607e-02f, 7.95445666e-02f, -1.67394243e-02f, -2.83371322e-02f, -4.96716537e-02f, -4.34744358e-03f, 6.79979697e-02f, 1.96213033e-02f, 9.70587730e-02f, -9.48974583e-03f,
  8.09083730e-02f, 8.51817057e-03f, 4.95335981e-02f, 3.16638243e-03f, 5.58925532e-02f, -3.03045521e-03f, -3.24943177e-02f, 1.54259021e-03f, 3.18141170e-02f, -2.82909218e-02f,
  6.33459315e-02f, -1.37863476e-02f, 4.29690741e-02f, -2.45161522e-02f, -2.54986472e-02f, -8.51700082e-02f, 7.36127887e-03f, 8.31560567e-02f, 6.94803521e-02f, 4.53422479e-02f,
  2.12522801e-02f, -7.31825009e-02f, 5.62619530e-02f, 1.54747814e-02f, -1.73666701e-02f, 7.67477155e-02f, -3.95105546e-03f, 8.44936892e-02f, -1.00499289e-02f, -7.16831684e-02f,
  -3.19423829e-03f, 6.03385083e-03f, -3.53305377e-02f, 3.89624685e-02f, 2.33845320e-02f, -5.85441217e-02f, -3.48147377e-02f, 6.53478131e-02f, 2.65458301e-02f, -4.72517833e-02f,
  4.74401712e-02f, -3.26569043e-02f, -3.77688557e-02f, 1.69870220e-02f, 5.24928495e-02f, 9.23437402e-02f, -2.44792923e-02f, 1.16564937e-01f, 1.07371934e-01f, 6.51278123e-02f,
  9.06431898e-02f, -1.52673379e-01f, -1.70181140e-01f, 7.71755725e-02f, 1.05756549e-02f, -1.67275131e-01f, -1.90320671e-01f, 2.39914339e-02f, 5.92726283e-03f, -1.35166496e-01f,
  -1.52008161e-01f, -1.59823410e-02f, 5.78028373e-02f, 2.77819391e-02f, -1.04425415e-01f, -2.16723919e-01f, -1.62200496e-01f, 6.20544143e-02f, 1.65106758e-01f, -3.24204117e-02f,
  -1.36472899e-02f, 2.29193084e-02f, 1.29289821e-01f, 6.58915713e-02f, 1.38470554e-04f, -2.68851314e-02f, -1.39501572e-01f, -3.54825929e-02f, -1.62217870e-01f, -2.51592338e-01f,
  -2.19014674e-01f, -1.09456554e-01f, 3.94985341e-02f, 2.19833422e-02f, -6.06822371e-02f, -5.46772406e-02f, -4.33824807e-02f, 2.14279885e-03f, -3.15682380e-03f, 7.08006322e-02f,
  8.04847032e-02f, -1.72603950e-02f, 7.87879154e-02f, 8.30603242e-02f, -9.79779661e-03f, 1.08827263e-01f, 8.78726467e-02f, 9.65189785e-02f, -6.53042644e-02f, -3.33061591e-02f,
  -1.00806929e-01f, -4.86028977e-02f, -3.21456790e-02f, 6.80611208e-02f, 2.89517269e-02f, -2.07985807e-02f, -3.84909883e-02f, 2.71430667e-02f, -1.92380380e-02f, 2.24781036e-02f,
  -1.41123250e-01f, -1.98884141e-02f, -5.78142703e-02f, -5.28663844e-02f, -1.86246410e-02f, -2.30623316e-02f, 4.87687774e-02f, -8.07978436e-02f, 8.39101598e-02f, -8.33930671e-02f,
  4.98983683e-03f, 5.14312126e-02f, -2.72226036e-02f, 4.83316258e-02f, 9.21345875e-02f, 4.84737158e-02f, 5.57947941e-02f, -2.25095656e-02f, 3.63965817e-02f, 2.15308126e-02f,
  3.32734026e-02f, -9.07137431e-03f, -5.67252226e-02f, 8.44538659e-02f, -9.52122826e-03f, -8.70991498e-02f, -6.49453402e-02f, -1.14302598e-02f, 7.45730996e-02f, 4.24307846e-02f,
  4.47113067e-02f, -6.97346479e-02f, -4.50766012e-02f, 5.05540185e-02f, 9.00340974e-02f, 4.08917340e-03f, -4.00742665e-02f, -3.02115548e-02f, -4.76921760e-02f, -3.26724574e-02f,
  3.57753523e-02f, 4.95434254e-02f, 5.94556294e-02f, -8.65572318e-03f, 7.30910525e-02f, 6.76170886e-02f, 5.48940338e-02f, -1.96670797e-02f, -3.77238505e-02f, -7.03342399e-03f,
  -5.86257242e-02f, -7.01709092e-02f, -3.43473591e-02f, -2.61101518e-02f, -5.58593459e-02f, -8.39304179e-02f, 2.19566338e-02f, -7.04196692e-02f, -4.61385474e-02f, -8.92310515e-02f,
  1.80410817e-01f, 1.92297343e-02f, 1.88477784e-01f, 1.10573694e-01f, 6.50965646e-02f, 1.34776935e-01f, 1.56945035e-01f, 8.53709355e-02f, 1.18022837e-01f, 2.52847951e-02f,
  6.81987125e-03f, 6.04829825e-02f, 1.33758485e-02f, 3.43436822e-02f, -2.38347631e-02f, -1.73248965e-02f, -1.84536316e-02f, 1.00154161e-01f, 2.13402450e-01f, 1.69765607e-01f,
  -1.00198738e-01f, -7.13291094e-02f, 4.01486531e-02f, -3.54102813e-03f, 2.04725936e-02f, 7.26891309e-02f, -6.58780243e-03f, 6.00635484e-02f, 3.88382860e-02f, -3.22602578e-02f,
  1.41049236e-01f, 2.94486154e-02f, 3.07727922e-02f, 1.00117475e-02f, 1.45682348e-02f, -1.43463956e-02f, 9.38291755e-03f, -2.64846021e-04f, 1.21877519e-02f, 1.03532054e-01f,
  5.24982698e-02f, -6.77354587e-03f, -4.33428362e-02f, -5.43834344e-02f, 3.82348448e-02f, -4.35910970e-02f, 6.30678013e-02f, 9.39032137e-02f, 1.29416194e-02f, 5.40078897e-03f,
  -7.22648459e-04f, -8.19969457e-04f, 4.77781445e-02f, -2.56490167e-02f, -4.90044653e-02f, -6.94745407e-02f, 4.66852710e-02f, -6.48956820e-02f, 6.74834549e-02f, 5.31765670e-02f,
  8.63111019e-02f, -2.80564055e-02f, 5.59144877e-02f, 1.70581695e-02f, -4.84650992e-02f, -5.14578409e-02f, -9.59282219e-02f, -7.09443167e-02f, 2.60889195e-02f, -6.61042333e-02f,
  2.27733664e-02f, -4.04996462e-02f, -5.70280887e-02f, 9.30173248e-02f, 5.33465445e-02f, 5.04220165e-02f, 2.72732298e-03f, 2.43274458e-02f, -5.60540706e-02f, -9.41157434e-03f,
  5.32539980e-03f, 9.74124968e-02f, -6.03243299e-02f, -7.18080178e-02f, -6.71620518e-02f, -4.26820777e-02f, -3.43579762e-02f, 4.26702611e-02f, -4.42367345e-02f, -1.40377441e-02f,
  -6.25281483e-02f, 3.52763869e-02f, 6.03014529e-02f, -5.37054911e-02f, 2.13400312e-02f, 6.66732434e-03f, -1.00173861e-01f, -7.04027787e-02f, -6.74257725e-02f, -6.90143928e-03f,
  -2.66885012e-03f, 7.05779344e-02f, -5.62967323e-02f, -8.65195133e-03f, 1.14757948e-01f, -1.93458125e-02f, -1.85033809e-02f, 1.22512326e-01f, -2.83770431e-02f, 3.20874006e-02f,
  -5.19697778e-02f, 5.19322120e-02f, 5.68722039e-02f, 1.12324275e-01f, 1.11547913e-02f, 1.10165156e-01f, -7.52807502e-03f, 8.83588269e-02f, 5.98055348e-02f, -3.68004739e-02f,
  1.16730891e-01f, -2.76050400e-02f, -6.33266345e-02f, -3.60502712e-02f, 1.95355136e-02f, -1.14546962e-01f, -2.29472741e-02f, 4.56559509e-02f, 5.85767552e-02f, 7.29760388e-03f,
  6.21771552e-02f, 6.88858181e-02f, -7.24661574e-02f, -5.47864325e-02f, -9.03960764e-02f, -7.22872987e-02f, 1.27683021e-02f, -6.31890222e-02f, -5.93487732e-02f, 2.92248745e-02f,
  -6.45696092e-03f, -3.03262975e-02f, 5.05043343e-02f, -5.05557321e-02f, -3.54347974e-02f, -8.24339911e-02f, 5.47218025e-02f, 2.47116536e-02f, -5.62716313e-02f, -3.25456969e-02f,
  -1.02376342e-01f, -1.77717563e-02f, -5.97143620e-02f, -3.14325467e-03f, -7.74325952e-02f, 9.54818502e-02f, -6.43661320e-02f, -7.31354505e-02f, -4.81407680e-02f, 7.84449056e-02f,
  2.45555732e-02f, -4.02482376e-02f, 8.07990059e-02f, -6.06664084e-02f, 7.00967982e-02f, -8.26182589e-02f, 5.93214035e-02f, -4.22758907e-02f, 6.05225039e-04f, -7.66657665e-03f,
  -5.12838475e-02f, -8.41519386e-02f, -9.73446667e-02f, 8.28642026e-03f, -6.68434352e-02f, 6.16594627e-02f, -8.53839964e-02f, 6.87318146e-02f, 4.78399359e-02f, 9.11950171e-02f,
  5.60952090e-02f, -9.51407999e-02f, -8.88539255e-02f, 7.29055330e-02f, -5.21115176e-02f, 7.17564970e-02f, -1.48274126e-02f, 1.79615861e-03f, -1.03814825e-01f, 4.87079360e-02f,
  3.05456519e-02f, -6.77591637e-02f, -7.77617916e-02f, 4.25905995e-02f, 5.11950739e-02f, -1.09988607e-01f, -9.77315232e-02f, 3.87233868e-02f, -7.41051883e-02f, -7.27861524e-02f,
  -3.69560942e-02f, -2.35237144e-02f, -5.06457426e-02f, -1.01498231e-01f, -3.70782204e-02f, -4.82715927e-02f, -3.41507830e-02f, 7.02858865e-02f, 8.35191384e-02f, -9.98575054e-03f,
  2.81781312e-02f, 1.75244287e-02f, 8.27775449e-02f, -5.67579754e-02f, -6.82177246e-02f, 2.98654716e-02f, 7.00216135e-03f, -8.28791037e-02f, 4.67992201e-02f, 4.86961305e-02f,
  7.32010007e-02f, -1.20592061e-02f, -6.27440810e-02f, -4.11574095e-02f, 4.19588163e-02f, -5.82050644e-02f, -3.03129610e-02f, 8.17329288e-02f, 4.45015989e-02f, 3.67812812e-02f,
  9.87964123e-02f, 8.75362083e-02f, 8.93189311e-02f, -3.79465939e-03f, 8.30430258e-03f, 2.38925274e-02f, -2.94212531e-03f, 3.61771844e-02f, -1.02032818e-01f, 1.97292883e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.05558185e-03f, -5.34726214e-03f, 2.74310540e-02f, 1.75514873e-02f, 5.78111212e-04f, 3.14235948e-02f, 1.62319012e-03f, -4.19219770e-03f, 1.39278963e-01f, 3.71807218e-02f,
  -1.77285299e-02f, 3.31899524e-02f, 1.26499003e-02f, -1.39715048e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -8.14316273e-02f, 8.99460912e-02f, -6.11344948e-02f, -4.50801514e-02f, 1.22463197e-01f, 5.15986793e-02f, 9.84691009e-02f, -4.55635227e-02f, -2.22445689e-02f, -7.72000998e-02f,
  -5.36347963e-02f, 9.84484851e-02f, -3.02035362e-02f, 1.10355064e-01f, 3.09014879e-03f, 1.05966695e-01f, 4.09374153e-03f, -9.22003239e-02f, -4.96729426e-02f, 2.35040128e-01f,
  -5.75513951e-02f, 9.34516937e-02f, -1.28700808e-01f, 7.89537579e-02f, 4.58758250e-02f, 3.67159583e-02f, -4.89094928e-02f, -6.19851835e-02f, 1.84919611e-02f, -8.20354149e-02f,
  -6.11539222e-02f, -1.25918120e-01f, -1.10061772e-01f, 1.49986386e-01f, 1.67731851e-01f, 9.67172254e-03f, 1.15354262e-01f, 1.64487258e-01f, -5.03311306e-02f, 2.23277688e-01f,
  -4.87756580e-02f, -1.24194119e-02f, -6.87578693e-02f, -1.55574991e-03f, 6.72550574e-02f, 5.33528104e-02f, -9.52886045e-02f, 1.83798134e-01f, 2.29657851e-02f, -9.91146266e-02f,
  -8.97038057e-02f, 7.89472274e-03f, 1.26827821e-01f, -3.94848250e-02f, 2.27195583e-03f, 2.29114536e-02f, 2.43973918e-02f, 3.83501872e-02f, -2.76984330e-02f, 8.70663226e-02f,
  -6.78768903e-02f, 1.28938742e-02f, 8.66769776e-02f, 7.26388991e-02f, -3.54881696e-02f, 1.30036296e-02f, 1.04341256e-02f, -2.59530675e-02f, -1.19804498e-02f, -1.10579334e-01f,
  -9.23398882e-02f, 1.40635595e-01f, 6.89986795e-02f, 1.98873915e-02f, -4.56079356e-02f, 1.08745627e-01f, 3.77037935e-02f, 1.22996390e-01f, 1.86297610e-01f, -7.74248689e-02f,
  4.03939635e-02f, -8.16562325e-02f, -2.96099354e-02f, 9.18441564e-02f, 8.66964087e-02f, 4.64729294e-02f, -1.70184597e-01f, -6.48196638e-02f, 1.12285145e-01f, -1.58082873e-01f,
  -2.13609394e-02f, -2.02763572e-01f, -1.01755597e-01f, -7.16873705e-02f, -1.97187185e-01f, 1.10079080e-01f, 7.10691214e-02f, -2.88250521e-02f, -1.44135743e-01f, -1.23205908e-01f,
  -1.65879622e-01f, -6.15780987e-02f, 1.72333214e-02f, 1.06711045e-01f, -1.76290810e-01f, -2.13077813e-02f, 9.16890800e-02f, -1.22488409e-01f, 1.11790061e-01f, 2.12497070e-01f,
  5.87753169e-02f, -7.71214887e-02f, -8.60825763e-04f, -3.58410850e-02f, 3.49471788e-03f, 6.88692927e-02f, 4.06361520e-02f, 1.36085242e-01f, -7.62458295e-02f, -6.31677061e-02f,
  -8.79676342e-02f, -6.08901270e-02f, -8.08331072e-02f, -5.49098253e-02f, 1.79435089e-01f, 4.08525690e-02f, -8.45148563e-02f, -6.16623461e-02f, 4.95960936e-02f, -6.39993474e-02f,
  -1.09814808e-01f, 1.20324209e-01f, -5.00482991e-02f, -2.58538104e-03f, 2.23257661e-01f, -1.20771602e-01f, -1.07271872e-01f, 6.68327957e-02f, -1.36910170e-01f, -7.62115419e-03f,
  -9.19729413e-04f, 7.91980699e-02f, 4.76428531e-02f, 7.09961951e-02f, -2.54947897e-02f, 1.06480047e-01f, -2.27380320e-02f, 1.77342340e-01f, -7.30115697e-02f, 2.76922304e-02f,
  -4.84706461e-02f, 8.34034532e-02f, -3.95654142e-02f, -1.50000453e-01f, -3.15942690e-02f, -2.22393215e-01f, 8.55737031e-02f, -3.64891291e-02f, 1.38055399e-01f, -4.92779128e-02f,
  -2.25993916e-01f, 1.43961787e-01f, 1.54654697e-01f, 1.50228545e-01f, 7.47986659e-02f, 1.85239747e-01f, 1.30241111e-01f, 7.33461007e-02f, 9.59380418e-02f, -8.75139758e-02f,
  6.35819286e-02f, -8.62256214e-02f, 1.19328998e-01f, -1.41473208e-02f, -2.07170124e-05f, 1.91366017e-01f, -1.24387465e-01f, -3.53424072e-01f, 1.04040302e-01f, -2.41146713e-01f,
  1.59093782e-01f, 2.29817837e-01f, -3.73243131e-02f, 1.03833331e-02f, -1.86054837e-02f, -1.19395852e-01f, 3.30285616e-02f, -5.84398024e-02f, 1.25177339e-01f, 9.39981192e-02f,
  -2.12432444e-01f, 1.30459383e-01f, -1.15176648e-01f, 9.94793102e-02f, -1.36129498e-01f, 5.47539294e-02f, 7.66814966e-03f, -4.79655750e-02f, -9.51680988e-02f, -2.77008507e-02f,
  6.01863228e-02f, 1.21384189e-01f, 2.25885529e-02f, 3.02413404e-02f, 1.21188439e-01f, 5.23311347e-02f, 9.46156830e-02f, 4.22936268e-02f, 7.23871514e-02f, -4.34431806e-02f,
  -5.42897806e-02f, -6.06297590e-02f, -8.92860368e-02f, -7.01056123e-02f, -8.67784023e-02f, -1.10033490e-01f, 5.59669584e-02f, 9.20526683e-02f, 8.80772993e-02f, 6.12968616e-02f,
  1.99486747e-01f, -6.37485012e-02f, 9.11568701e-02f, -1.36508122e-01f, -9.60564613e-03f, -2.80353457e-01f, -9.65475142e-02f, -3.30448966e-03f, -6.47731721e-02f, 1.18076034e-01f,
  -7.38146231e-02f, -2.46507749e-01f, 4.73475382e-02f, -5.24675846e-03f, -3.03215422e-02f, -1.12498172e-01f, 1.54755861e-01f, 1.77258521e-01f, 4.67841402e-02f, -2.64998525e-01f,
  -2.06155598e-01f, 2.17291996e-01f, 5.62708378e-02f, 2.15148553e-01f, -1.22847751e-01f, 1.63135514e-01f, -1.24255560e-01f, 1.15079172e-01f, 6.56510219e-02f, 2.12247998e-01f,
  1.02807224e-01f, -4.31258138e-03f, 3.30587812e-02f, 5.65290377e-02f, 2.43339557e-02f, -1.28266975e-01f, 3.54472883e-02f, -2.34029684e-02f, 7.92066082e-02f, 3.98852602e-02f,
  1.56722423e-02f, -1.16113849e-01f, -7.88726136e-02f, 1.23918347e-01f, 9.12484825e-02f, 8.04482326e-02f, -7.89282545e-02f, -4.88080457e-02f, 9.67762768e-02f, 5.32667488e-02f,
  1.01299509e-01f, -6.82759956e-02f, 4.11305092e-02f, -1.24396225e-02f, -7.86509588e-02f, 3.96648459e-02f, -4.30420265e-02f, 1.52150631e-01f, 4.17721942e-02f, -1.09304972e-02f,
  4.15161736e-02f, -1.98536053e-01f, 6.50461018e-02f, -1.27307385e-01f, 1.93453096e-02f, -1.78728595e-01f, 8.69832784e-02f, -1.82460010e-01f, 2.11518873e-02f, -1.02554210e-01f,
  8.14995915e-02f, -3.18699747e-01f, -2.00315177e-01f, 1.32164154e-02f, 3.30974087e-02f, -6.39974475e-02f, -2.06958547e-01f, 5.18737361e-02f, 1.20806143e-01f, -1.06065623e-01f,
  3.91659662e-02f, 1.91108704e-01f, 6.06311820e-02f, -1.33432850e-01f, 4.05102149e-02f, -1.85072497e-01f, 7.19554350e-02f, 5.77161983e-02f, 5.34758568e-02f, 7.65498877e-02f,
  -1.08048141e-01f, -4.18863334e-02f, -1.16760492e-01f, 1.10642344e-01f, 1.45080358e-01f, 1.22442089e-01f, 5.79881389e-03f, 1.25093773e-01f, -2.09966302e-01f, 8.47004652e-02f,
  7.48872682e-02f, -1.80018395e-01f, -7.87793100e-02f, -7.65060559e-02f, 9.43945721e-02f, -6.13456368e-02f, -1.29188433e-01f, 3.29472236e-02f, 1.47791132e-01f, 8.47482458e-02f,
  -5.27564473e-02f, -1.32836282e-01f, 4.45881858e-02f, -4.80454639e-02f, 1.95103943e-01f, -1.66427270e-01f, -7.96578750e-02f, -4.84003639e-03f, -3.55232917e-02f, -1.87700480e-01f,
  -6.98629096e-02f, 2.97669414e-02f, -1.34801164e-01f, -9.01137516e-02f, -1.39316991e-01f, -1.77391112e-01f, 1.71434924e-01f, -1.19110152e-01f, -6.38423637e-02f, -9.18328464e-02f,
  -6.96782917e-02f, -6.67339787e-02f, 7.16521814e-02f, -9.33271721e-02f, 7.96556547e-02f, -1.91653445e-01f, -8.57839286e-02f, -1.33901536e-01f, 1.16619475e-01f, -7.84659907e-02f,
  -4.66880687e-02f, 1.33156911e-01f, 2.23588750e-01f, 1.99899167e-01f, 7.18873963e-02f, 4.43086661e-02f, 1.62841648e-01f, 1.44652694e-01f, 1.46674365e-01f, -2.40418449e-01f,
  4.65026498e-02f, 6.74982965e-02f, 7.21400157e-02f, 1.62648946e-01f, 1.08956166e-01f, 5.69437221e-02f, 4.62588444e-02f, 1.42685428e-01f, 2.23631173e-01f, 7.17090592e-02f,
  2.74485238e-02f, 1.65988281e-01f, -4.04317193e-02f, -2.02544825e-03f, -8.41808021e-02f, -3.22628841e-02f, -5.43543138e-02f, 1.49288133e-01f, -8.36684480e-02f, 8.86621550e-02f,
  1.22945510e-01f, -1.28466055e-01f, -5.17430948e-03f, -5.89774251e-02f, 8.28573555e-02f, -3.66310067e-02f, 9.95158702e-02f, -9.19810906e-02f, -1.56772926e-01f, 1.66472107e-01f,
  6.06558360e-02f, 1.39487058e-01f, -1.24378338e-01f, 1.23645142e-01f, 8.94727707e-02f, -1.46793187e-01f, -1.07006244e-01f, -3.49693969e-02f, -4.63246554e-02f, -7.66273681e-03f,
  9.14441720e-02f, 5.29889651e-02f, 2.11605072e-01f, -1.73933089e-01f, 7.14647621e-02f, -1.80141896e-01f, -9.50996503e-02f, -1.08579740e-01f, 1.02042630e-01f, 5.89498989e-02f,
  1.06663637e-01f, 2.87709087e-01f, 9.61239338e-02f, -7.06074759e-02f, 2.77584773e-02f, -2.20755190e-01f, -4.43678424e-02f, 9.97296814e-03f, -6.96638823e-02f, -1.34856328e-01f,
  6.51771575e-02f, -1.70804724e-01f, 3.11715482e-03f, -9.44056921e-03f, -1.14948731e-02f, 1.41591176e-01f, -5.65259382e-02f, -9.65111181e-02f, -1.10955022e-01f, 1.62494078e-01f,
  1.04860105e-01f, -2.94433590e-02f, -6.58313558e-02f, -7.84512144e-03f, 1.29033357e-01f, -7.97581598e-02f, 8.35839286e-02f, -8.04798752e-02f, -3.03646475e-02f, -7.91263133e-02f,
  -5.56919985e-02f, 1.50716743e-02f, -1.12971053e-01f, 1.25383101e-02f, 8.64859074e-02f, -9.59339887e-02f, 1.25019969e-02f, -3.36104073e-02f, -5.52734956e-02f, -1.15312068e-02f,
  3.99443470e-02f, 4.76812050e-02f, -1.06497407e-01f, 4.92644086e-02f, -1.16957858e-01f, -4.47947979e-02f, -1.58144310e-02f, 1.93659261e-01f, 4.45852354e-02f, -2.77647213e-03f,
  -1.90610029e-02f, 7.26864338e-02f, -5.65045401e-02f, -1.89599648e-01f, -6.76077008e-02f, -2.61723608e-01f, 7.75324553e-02f, -1.27266347e-01f, -2.17570458e-02f, 7.01994598e-02f,
  -6.89458922e-02f, -2.94581689e-02f, -3.77942473e-02f, -1.11902401e-01f, -1.70087650e-01f, 7.38667175e-02f, -3.52279544e-02f, 1.17672727e-01f, -2.18743443e-01f, 2.88815014e-02f,
  1.05790205e-01f, -7.06051067e-02f, 9.58843082e-02f, 9.01269838e-02f, 2.87825763e-02f, 1.34306312e-01f, 5.87883368e-02f, -2.36429915e-01f, -3.30014341e-02f, -6.00056909e-02f,
  -7.11728781e-02f, 6.80018067e-02f, -1.10025197e-01f, -9.18722302e-02f, -6.40146881e-02f, -8.12194049e-02f, -1.73173398e-01f, -3.07708513e-02f, 1.38313249e-01f, 1.83772087e-01f,
  1.64338779e-02f, 9.76962149e-02f, -2.48104110e-02f, -2.02207845e-02f, -5.41150868e-02f, 6.57698289e-02f, -3.49107273e-02f, -2.43010297e-02f, -1.85668781e-01f, 4.36580442e-02f,
  2.05252364e-01f, 2.68160868e-02f, -2.07711473e-01f, -1.41443998e-01f, 1.84344444e-02f, -1.47871882e-01f, -4.18587923e-02f, -2.77509540e-03f, -2.45664478e-03f, -7.50802085e-02f,
  9.91812870e-02f, -2.95042843e-01f, 9.00754333e-02f, 9.51480120e-02f, -1.17019556e-01f, -7.16781244e-02f, -9.27439928e-02f, -1.64305449e-01f, 1.53745636e-01f, -9.07658339e-02f,
  1.15378439e-01f, -5.02193682e-02f, 3.20857950e-03f, -1.32027850e-01f, 9.10898671e-03f, -1.00255430e-01f, -3.87009024e-03f, -1.57386646e-01f, -1.24480575e-01f, -8.15474316e-02f,
  -5.00133783e-02f, -1.48095921e-01f, 8.76109079e-02f, 1.34570241e-01f, 6.31898046e-02f, 7.46768713e-02f, 5.52157760e-02f, 1.83312491e-01f, 5.50513230e-02f, -4.00438197e-02f,
  -1.41208813e-01f, -1.35820493e-01f, 2.17815805e-02f, -3.92980985e-02f, -5.87430261e-02f, 1.47613674e-01f, 8.81861150e-02f, 9.07119885e-02f, 7.82410875e-02f, 1.34987324e-01f,
  1.98526248e-01f, 8.86285603e-02f, -8.07686970e-02f, 1.04781665e-01f, -1.27493933e-01f, 8.65679681e-02f, -1.11960899e-03f, 1.08732879e-01f, 1.49218500e-01f, -1.03945732e-02f,
  -6.53839409e-02f, -1.09254241e-01f, 1.34985417e-01f, -2.17610300e-02f, -1.21055536e-01f, 1.40702520e-02f, 5.67504019e-02f, 1.28897717e-02f, 1.69901326e-01f, 6.88338652e-02f,
  -1.12751745e-01f, 1.63297966e-01f, -1.05484851e-01f, -6.97507262e-02f, 5.95449023e-02f, 2.47512594e-01f, 4.51269746e-02f, 9.81466006e-03f, 2.11105362e-01f, 1.49267852e-01f,
  -1.24190018e-01f, -1.30328074e-01f, 7.23657534e-02f, -3.76575217e-02f, 1.23456225e-01f, -5.24311177e-02f, 2.48944148e-01f, -2.37753600e-01f, -1.73621014e-01f, 2.47638911e-01f,
  1.67036429e-01f, 1.48708057e-02f, 6.24137651e-03f, 2.17421174e-01f, 6.67947717e-03f, -5.70591576e-02f, -7.83036500e-02f, -1.55942798e-01f, -4.45610192e-03f, 2.87927091e-02f,
  7.35793412e-02f, -1.53073519e-02f, -1.57718092e-01f, 1.72945365e-01f, -4.22842018e-02f, -2.48721436e-01f, 3.60140148e-05f, -3.70882675e-02f, 2.75148358e-02f, 1.43936262e-01f,
  5.05623147e-02f, 2.38080174e-02f, -5.49147241e-02f, -2.35155206e-02f, -6.24754988e-02f, -9.60650966e-02f, -1.25226155e-01f, 1.10914677e-01f, 2.13196855e-02f, 1.40651673e-01f,
  1.27484202e-01f, -1.37501270e-01f, -1.09136896e-02f, -6.24828972e-02f, -8.40015057e-03f, -6.82904944e-02f, -1.01460017e-01f, 1.27377912e-01f, 1.16289668e-01f, 1.01205625e-01f,
  -9.26512107e-02f, -7.52123520e-02f, 7.19455257e-02f, -1.12931982e-01f, 8.83466452e-02f, -8.70386064e-02f, -6.37952313e-02f, 6.19238019e-02f, -1.00250896e-02f, -2.50362828e-02f,
  -7.28789419e-02f, 8.93051457e-03f, -2.13482920e-02f, -1.25628427e-01f, 7.24442452e-02f, -2.52785712e-01f, 1.32152960e-01f, -2.40488481e-02f, 6.84971036e-03f, 1.08521700e-01f,
  -1.33479074e-01f, -2.23030825e-03f, 1.23676948e-01f, -2.46028434e-02f, -5.74099161e-02f, -8.43002461e-03f, -2.11695358e-01f, -1.46184368e-02f, -5.55300713e-02f, 5.08037545e-02f,
  1.05574511e-01f, 1.81520417e-01f, 2.19594091e-01f, 1.62332952e-01f, 1.23931438e-01f, 2.13388368e-01f, 1.98408082e-01f, 2.00252324e-01f, 2.14467905e-02f, -1.02346256e-01f,
  1.30453646e-01f, -1.36155576e-01f, 4.31771856e-03f, 1.69283986e-01f, -6.00994751e-02f, -2.02857666e-02f, -1.20092191e-01f, 4.62257341e-02f, 6.77180141e-02f, -8.47145319e-02f,
  1.29222721e-01f, 1.59632951e-01f, -1.27834544e-01f, -8.57093185e-02f, -1.29219666e-01f, -2.44569164e-02f, 3.14545333e-02f, 1.08920105e-01f, -1.29731745e-01f, 3.19843255e-02f,
  -9.42908041e-03f, 3.23963612e-02f, -8.77496824e-02f, 8.78460407e-02f, -8.29909462e-03f, -1.05209179e-01f, 1.27147794e-01f, 1.37856394e-01f, -1.30043015e-01f, 1.79861516e-01f,
  5.21751978e-02f, 6.75540715e-02f, 2.39679292e-02f, -1.15278065e-01f, -1.09950431e-01f, 1.09318398e-01f, -3.88318636e-02f, 1.12300143e-01f, -3.63322869e-02f, 8.45815316e-02f,
  -1.24987112e-02f, 3.03966738e-02f, 2.23690018e-01f, -2.43116498e-01f, -4.96880859e-02f, 2.55519841e-02f, -6.95425943e-02f, -2.62261957e-01f, -3.19632180e-02f, 2.64175117e-01f,
  9.01839510e-02f, 2.43471995e-01f, 1.11985676e-01f, -2.84643263e-01f, 2.44897362e-02f, -1.43547311e-01f, -2.03352258e-01f, 1.83387063e-02f, -1.20649293e-01f, -1.57782547e-02f,
  2.05634251e-01f, -1.95070103e-01f, -7.19108731e-02f, 1.58905208e-01f, -2.55789347e-02f, -1.88731421e-02f, -1.40563101e-01f, -1.94854259e-01f, -6.09561168e-02f, -1.32615715e-01f,
  -4.17527035e-02f, 1.62354842e-01f, 1.85716510e-01f, 5.89355230e-02f, 1.14053033e-01f, -1.87340617e-01f, -2.23477464e-03f, 1.60843087e-03f, -9.09013376e-02f, -3.21982317e-02f,
  2.49524396e-02f, 1.92490011e-03f, 2.60042101e-02f, -1.89553604e-01f, -7.93778598e-02f, 4.65942062e-02f, 3.73125523e-02f, -9.10190046e-02f, -2.45399833e-01f, 3.30118947e-02f,
  1.12807840e-01f, -1.97865977e-03f, -2.56376285e-02f, -6.65489882e-02f, -1.29844084e-01f, -1.38925537e-01f, 1.32966563e-01f, 1.66812632e-02f, -4.07308526e-02f, 1.05978914e-01f,
  1.27462924e-01f, -1.56762898e-01f, -9.04487446e-02f, -1.33935019e-01f, -6.79836422e-02f, -1.34962305e-01f, 5.52261099e-02f, 4.69476692e-02f, 1.37015492e-01f, -1.05418451e-01f,
  -1.04785413e-01f, -9.53835435e-03f, -7.35560723e-04f, -7.09605813e-02f, -5.38493916e-02f, 8.55576340e-03f, -1.71032771e-01f, 9.37379226e-02f, -2.04520941e-01f, 1.03276931e-01f,
  2.66057104e-01f, 8.83213058e-02f, 2.97967903e-02f, 7.52250329e-02f, -1.30481601e-01f, -2.85372678e-02f, -6.66306689e-02f, -2.91326731e-01f, 1.41215354e-01f, 1.18390217e-01f,
  1.39213011e-01f, 7.93473199e-02f, -1.17735572e-01f, 2.60352809e-02f, 9.34179872e-03f, 1.54692039e-01f, -2.79780123e-02f, -4.69894893e-02f, -2.93251220e-02f, 4.93287146e-02f,
  1.55644879e-01f, 1.30536582e-03f, 1.13780737e-01f, 1.15354493e-01f, -8.01984072e-02f, 2.41638534e-02f, 2.15603169e-02f, -8.99317265e-02f, 4.32990268e-02f, 2.28891820e-02f,
  8.40985626e-02f, -1.02852002e-01f, -1.06467761e-01f, 7.91056827e-03f, 7.92615637e-02f, 9.24771950e-02f, 1.15446355e-02f, 1.03870027e-01f, 1.10718675e-01f, 2.40411274e-02f,
  -7.81161040e-02f, 5.88986054e-02f, 1.84164871e-03f, 1.11517362e-01f, 2.14956589e-02f, -7.69531801e-02f, -6.42328232e-04f, -1.66600689e-01f, 7.58631453e-02f, -9.70636830e-02f,
  4.63742064e-03f, -2.15698928e-01f, -5.71550205e-02f, -4.51741442e-02f, -8.80528823e-04f, -1.66101649e-01f, 5.98463044e-02f, -1.11341074e-01f, 4.64137308e-02f, 2.52299830e-02f,
  7.58405179e-02f, -4.23485268e-04f, -1.08953714e-01f, -1.64186597e-01f, 2.36019436e-02f, -8.93859640e-02f, -3.08639426e-02f, 1.54476702e-01f, 1.75622284e-01f, -2.46721525e-02f,
  4.35170680e-02f, -1.38040587e-01f, 1.52986377e-01f, -1.81946643e-02f, 1.38795704e-01f, 1.64733022e-01f, -8.66598412e-02f, 1.29083693e-01f, -1.27228364e-01f, -5.75683191e-02f,
  -4.96213138e-02f, -1.12470828e-01f, -2.70650461e-02f, 1.36138335e-01f, -1.64307043e-01f, 2.76761129e-02f, -1.43410951e-01f, -4.01135087e-02f, -1.35062650e-01f, -6.72540292e-02f,
  -3.97105590e-02f, -1.58602178e-01f, -2.25532637e-03f, 8.46448317e-02f, 3.05016879e-02f, 5.12498170e-02f, -1.78885162e-01f, 4.03048098e-02f, 1.38531417e-01f, -3.55588980e-02f,
  1.14153482e-01f, 6.96009817e-03f, 7.58878961e-02f, -7.31129274e-02f, 8.91466513e-02f, 1.11437917e-01f, 7.61161384e-04f, 1.11761391e-01f, -6.72562793e-03f, -1.48248643e-01f,
  7.89346769e-02f, -6.47798106e-02f, 1.21759949e-03f, -4.15896066e-02f, 1.48418635e-01f, 1.07804738e-01f, 2.19774216e-01f, -2.45927781e-01f, -2.29719914e-02f, -1.74703747e-01f,
  1.70105457e-01f, -3.13939065e-01f, -3.58839706e-02f, -8.34204033e-02f, -2.03019381e-01f, -2.87930351e-02f, -1.21378988e-01f, 2.11307351e-02f, 1.95056871e-01f, -6.23338930e-02f,
  3.55335474e-02f, -5.09570539e-02f, -1.88371018e-01f, -2.07397923e-01f, -2.41837889e-01f, -5.88436835e-02f, 1.82957090e-02f, 9.36961845e-02f, -1.04110166e-01f, 4.40039486e-02f,
  -1.13461025e-01f, 3.95798571e-02f, 3.85396667e-02f, 1.21187225e-01f, 2.25240178e-02f, 7.70534799e-02f, -2.12176014e-02f, 1.68348521e-01f, 1.86689988e-01f, -1.77155398e-02f,
  -9.92910415e-02f, 7.84250572e-02f, 2.07134318e-02f, 1.73927575e-01f, -8.47717933e-03f, 1.36673450e-01f, 9.87281725e-02f, 5.37326299e-02f, -4.10272889e-02f, 8.58171284e-02f,
  -3.99907976e-02f, -4.61689606e-02f, 1.47408828e-01f, 1.50647927e-02f, -9.34781954e-02f, 2.43938327e-01f, 2.12922767e-02f, 1.03739277e-01f, 8.22180957e-02f, 6.76172823e-02f,
  8.31312239e-02f, 1.84983462e-02f, 1.77200451e-01f, 6.58962205e-02f, 2.58190315e-02f, -3.21499445e-02f, 1.77078843e-01f, -2.40072832e-02f, 2.51131773e-01f, -1.71982169e-01f,
  1.48183346e-01f, -1.72478244e-01f, -1.13275900e-01f, 1.33572966e-01f, 1.20972015e-01f, 7.30950609e-02f, 6.18661121e-02f, 2.57660657e-01f, -1.14011385e-01f, -6.35137260e-02f,
  -4.64280993e-02f, -2.28627607e-01f, -1.89717308e-01f, -2.25604232e-02f, 1.00120254e-01f, -9.42166778e-04f, -1.43540636e-01f, -1.48160383e-02f, -5.86297214e-02f, -9.55340415e-02f,
  1.05359614e-01f, -6.19327314e-02f, 5.92285059e-02f, 5.20278327e-02f, -4.01492156e-02f, 1.35987595e-01f, -5.30872568e-02f, -1.29774764e-01f, 8.71431679e-02f, -1.66012555e-01f,
  -1.28273800e-01f, 1.37800768e-01f, -4.10123877e-02f, 1.29368454e-01f, -3.36016230e-02f, -7.52159432e-02f, 2.07569394e-02f, -6.95374757e-02f, 2.25630365e-02f, -8.75570551e-02f,
  -1.41465560e-01f, 1.60401799e-02f, 1.44874871e-01f, 1.28297970e-01f, -9.78833530e-03f, -6.81828558e-02f, 2.55430210e-02f, 1.34384975e-01f, -1.38150588e-01f, 4.60517891e-02f,
  1.53353121e-02f, -1.07334189e-01f, 1.93977747e-02f, -5.90409478e-03f, -1.27013819e-02f, 2.17759646e-02f, -1.21496238e-01f, 1.69134736e-02f, -2.77118646e-02f, 2.04481348e-01f,
  -4.62904163e-02f, 1.95112824e-01f, -1.07119896e-01f, 4.67556566e-02f, -1.44668877e-01f, 1.42060474e-01f, 1.10152379e-01f, -4.68891822e-02f, 7.55219460e-02f, -1.21442964e-02f,
  7.13001611e-03f, 7.71873146e-02f, 4.23824415e-03f, -1.24092110e-01f, 1.58275008e-01f, 1.94607362e-01f, 4.09395248e-02f, 6.37999251e-02f, -7.58516416e-02f, 3.98476794e-02f,
  1.03937961e-01f, -7.61983544e-02f, 5.12722060e-02f, 6.84786662e-02f, -6.24834001e-02f, -6.30261898e-02f, -1.31096125e-01f, -1.05811441e-02f, -2.22387281e-03f, -1.17321014e-01f,
  -2.41844673e-02f, 1.55919343e-01f, -1.22081839e-01f, 1.00018889e-01f, 3.36186513e-02f, 3.30381952e-02f, 4.46178243e-02f, -3.83601822e-02f, -6.10652789e-02f, 9.41243395e-02f,
  3.24133341e-03f, 8.19067806e-02f, -7.24811107e-02f, -9.68092084e-02f, -1.15024731e-01f, 8.38281810e-02f, -2.34522626e-01f, 3.84933129e-02f, 1.38251156e-01f, -3.10344286e-02f,
  1.47085994e-01f, -7.49929994e-02f, -1.63845912e-01f, 1.83869228e-01f, -2.70343274e-02f, 1.44914910e-01f, 5.11963032e-02f, 2.29060024e-01f, -2.85618682e-03f, -8.36322829e-02f,
  3.01663317e-02f, -1.03934608e-01f, -1.08845308e-01f, 1.92592114e-01f, -6.80824146e-02f, -3.18675973e-02f, 3.05138379e-01f, -5.27853295e-02f, 1.51436523e-01f, -6.76243529e-02f,
  -1.88936457e-01f, -3.81453745e-02f, 9.41156819e-02f, 2.36553565e-01f, -4.07543518e-02f, 3.95945549e-01f, -1.47082061e-01f, -8.68939981e-02f, 1.28562823e-01f, -4.96192090e-02f,
  -1.90086335e-01f, -1.35961339e-01f, -2.42308706e-01f, -1.02290429e-01f, -1.20652609e-01f, -3.05162102e-01f, -2.35188603e-01f, 1.11874573e-01f, -2.76320148e-02f, 1.32328030e-02f,
  -1.45238906e-01f, -3.96640338e-02f, -1.29491538e-01f, 9.32616293e-02f, -7.11045787e-02f, -2.78292801e-02f, 5.11065722e-02f, 8.82505700e-02f, -5.65785654e-02f, 7.48985335e-02f,
  1.30186141e-01f, -4.44099046e-02f, 2.91752350e-02f, 2.81283688e-02f, -7.94096068e-02f, -1.42091721e-01f, 8.55880082e-02f, 9.97299701e-03f, -3.31300609e-02f, 9.21877548e-02f,
  -2.11866479e-02f, 2.53844354e-02f, -7.05686212e-02f, 1.25170603e-01f, -1.64935868e-02f, -4.24613385e-03f, 1.42656177e-01f, 5.76839857e-02f, -3.95109579e-02f, -1.17850721e-01f,
  8.15000907e-02f, 1.47226229e-01f, 8.76947194e-02f, 1.00732669e-01f, -9.77618247e-02f, -1.08526908e-01f, 6.47054091e-02f, -1.33734256e-01f, 1.38186291e-01f, 8.77247453e-02f,
  -1.72765568e-01f, 6.79676682e-02f, 3.55623593e-03f, -1.21626928e-01f, 3.28401029e-02f, 5.75035671e-03f, -6.43474457e-04f, -1.56278074e-01f, -2.38300618e-02f, -9.02481750e-02f,
  2.54636593e-02f, 8.70546997e-02f, -1.96895003e-01f, 1.43373072e-01f, 9.34727862e-02f, 8.96539353e-03f, 9.17588919e-02f, 8.10470805e-02f, -1.84622481e-01f, 1.51027143e-01f,
  -4.82389778e-02f, -2.01241687e-01f, -1.53640434e-02f, 3.35826576e-02f, -1.50036048e-02f, 1.55408412e-01f, 8.20807442e-02f, 7.30698928e-02f, 1.82123140e-01f, -4.10137735e-02f,
  -7.23839179e-02f, -6.42911047e-02f, -1.29525274e-01f, 1.90838985e-02f, 8.56612623e-02f, 9.33951363e-02f, -7.65997246e-02f, 7.96592310e-02f, -5.44523774e-03f, 1.19935513e-01f,
  3.46782766e-02f, 1.58710591e-02f, 3.11683845e-02f, -3.56154442e-02f, 6.82751760e-02f, -8.18386953e-03f, 1.16777562e-01f, -9.17799175e-02f, 9.87999514e-02f, -1.85495429e-02f,
  4.18491550e-02f, 1.19910628e-01f, -3.47183160e-02f, 4.03962843e-02f, 1.67828351e-01f, 1.12981729e-01f, -3.31543647e-02f, 4.69803885e-02f, -1.61967392e-03f, -5.00044003e-02f,
  6.46869391e-02f, -5.06786164e-03f, -1.29821124e-02f, -1.16512269e-01f, 1.06461115e-01f, -7.44302571e-02f, -9.67145413e-02f, -1.09220006e-01f, -6.23635612e-02f, -7.78965792e-03f,
  3.21571529e-02f, 1.17689289e-01f, -3.17604691e-02f, 8.34570825e-02f, 8.24070871e-02f, 1.38221100e-01f, 1.45300880e-01f, -7.65391141e-02f, 1.31484106e-01f, 2.01713685e-02f,
  1.77183226e-01f, -1.38983643e-02f, 1.12029769e-01f, 1.85990795e-01f, 9.80680212e-02f, -1.65868387e-01f, -1.69885010e-02f, -2.71078944e-01f, 5.23375198e-02f, -2.95067094e-02f,
  -3.61368284e-02f, 1.20501993e-02f, 3.39484215e-02f, -1.28135994e-01f, 1.34254813e-01f, -1.51643798e-01f, 1.07134894e-01f, -1.40875941e-02f, -1.46543130e-01f, 1.08499549e-01f,
  5.38657680e-02f, 1.15573175e-01f, 3.74689326e-02f, -1.49766445e-01f, 1.26504004e-01f, 5.87140135e-02f, -4.31243517e-02f, 8.34009722e-02f, 1.85425580e-01f, -9.26537905e-03f,
  -1.32914037e-01f, -3.35765257e-02f, 8.45860466e-02f, 4.15885635e-03f, 4.97978851e-02f, 1.49103075e-01f, -9.92648005e-02f, -2.45410968e-02f, 1.17536440e-01f, -4.42804508e-02f,
  6.52008653e-02f, 1.67092055e-01f, 2.69830018e-01f, 1.07470173e-02f, 1.11441612e-02f, -2.18145385e-01f, 2.84285117e-02f, -3.01695794e-01f, 2.68609021e-02f, 3.02156899e-03f,
  2.58663088e-01f, -2.55154133e-01f, 3.75023931e-02f, 1.20965481e-01f, 9.98302177e-02f, -1.92261368e-01f, -3.20418514e-02f, 8.46794283e-04f, -1.77531332e-01f, 1.00431412e-01f,
  -2.43772462e-01f, 7.33727589e-02f, 2.52028108e-01f, 8.63312334e-02f, -1.10611282e-01f, -5.93951829e-02f, 8.67962837e-02f, -2.80846078e-02f, -1.40224174e-01f, -2.37585038e-01f,
  1.54336929e-01f, -1.20068826e-01f, 1.43899456e-01f, -6.69361418e-03f, -2.69716792e-03f, -1.17050014e-01f, 3.56364064e-02f, 2.42328450e-01f, -5.91207743e-02f, -1.02577224e-01f,
  1.40169740e-01f, 2.43765429e-01f, -1.26972541e-01f, 1.54369950e-01f, -7.42278546e-02f, -1.07276537e-01f, -2.79669818e-02f, -2.18946394e-02f, -6.86857058e-03f, -1.73121709e-02f,
  -1.36601374e-01f, 6.87533244e-02f, 6.59065321e-02f, -2.34188680e-02f, 4.64402959e-02f, -1.09665751e-01f, 3.18718026e-03f, -6.53335676e-02f, -5.65633178e-02f, -9.32467282e-02f,
  1.62079334e-01f, -3.65841053e-02f, 1.05197258e-01f, -7.21003190e-02f, 2.20221803e-02f, -4.09742333e-02f, 1.78184465e-01f, -7.84229785e-02f, 1.60323516e-01f, 2.16352474e-02f,
  3.26573215e-02f, 8.26400667e-02f, -3.03615611e-02f, 1.14837386e-01f, 1.01349093e-01f, 1.18241355e-01f, 1.69360295e-01f, 5.01634972e-03f, -6.45004632e-03f, 6.88952357e-02f,
  -1.35140836e-01f, 4.26924787e-02f, -7.12158829e-02f, -1.46577239e-01f, 1.52385011e-01f, 1.39609069e-01f, 4.73258905e-02f, 1.45284742e-01f, 6.05157167e-02f, -1.29429996e-01f,
  1.77518539e-02f, -1.09550178e-01f, -7.51153603e-02f, 9.33444053e-02f, 1.69841498e-02f, 6.66674972e-02f, 4.80732210e-02f, -4.14940454e-02f, 2.23786607e-02f, -1.07459947e-01f,
  3.91984805e-02f, 1.41488835e-01f, -1.31674362e-02f, 8.10685530e-02f, -3.86731289e-02f, 1.59580056e-02f, -8.05614144e-02f, -1.08874431e-02f, 8.37455019e-02f, -6.11717366e-02f,
  -1.24630637e-01f, -4.81894910e-02f, 1.25533551e-01f, -1.19094923e-01f, -2.11663082e-01f, 7.33495399e-04f, 8.26168582e-02f, 7.27066305e-03f, 7.27645606e-02f, 2.96938289e-02f,
  4.32915762e-02f, -1.14775011e-02f, 1.07033357e-01f, -1.30767867e-01f, -4.50978316e-02f, 6.52485490e-02f, -1.01618998e-01f, -3.11154723e-01f, -2.78173275e-02f, 7.96255395e-02f,
  -2.01106668e-01f, -6.06724024e-02f, -1.51238456e-01f, -1.81848079e-01f, -3.07257753e-02f, -4.13622037e-02f, 1.54273793e-01f, -1.59841716e-01f, -1.76055178e-01f, -8.21841732e-02f,
  1.74654618e-01f, -3.04090798e-01f, -2.06789583e-01f, -2.26859868e-01f, -2.60569841e-01f, -1.37837276e-01f, 8.36442411e-02f, 3.97479720e-03f, -1.58138976e-01f, -1.54247478e-01f,
  -1.26519710e-01f, -1.74574181e-01f, 1.17435068e-01f, 2.98018783e-01f, 1.16501346e-01f, -2.48693419e-03f, 9.54953060e-02f, 2.20898613e-02f, -1.06071100e-01f, 7.96896368e-02f,
  -1.72397681e-02f, 1.62599355e-01f, -3.67881358e-02f, -5.45507222e-02f, -1.72344357e-01f, 2.03623295e-01f, -1.82900135e-03f, -3.99842076e-02f, -5.23698926e-02f, -2.87145451e-02f,
  -2.10685715e-01f, 3.62909702e-03f, 7.52342939e-02f, -4.15385254e-02f, 7.29246512e-02f, 1.58166271e-02f, -5.48886061e-02f, -4.05211896e-02f, -1.18088387e-01f, 4.73758541e-02f,
  1.26091838e-01f, 8.91107023e-02f, 5.21394052e-02f, 7.11545050e-02f, 2.66262852e-02f, -3.34344283e-02f, 4.60207611e-02f, 7.25386292e-02f, 9.76770744e-02f, -4.91237827e-02f,
  -6.09724559e-02f, -2.23784223e-01f, 1.51025310e-01f, 2.72727273e-02f, 1.72043100e-01f, -2.65960954e-03f, -2.81403307e-02f, 5.11705764e-02f, 9.24033113e-03f, -1.03542559e-01f,
  -7.31413513e-02f, 1.53750377e-02f, 1.63661376e-01f, 7.29665579e-03f, -1.28440503e-02f, 3.06881219e-03f, -1.01460822e-01f, -1.17082328e-01f, -1.54668972e-01f, -5.91727495e-02f,
  -5.45161180e-02f, -3.90906855e-02f, 2.61677429e-02f, 3.75880627e-03f, 7.03786612e-02f, 1.41210109e-01f, -1.08801752e-01f, 2.53700092e-02f, 1.09639861e-01f, -8.91198292e-02f,
  5.99987395e-02f, 1.48074582e-01f, 1.16921544e-01f, 1.37709305e-01f, -9.96787697e-02f, -4.02668491e-02f, -8.60333145e-02f, -8.42602775e-02f, 1.42951712e-01f, 1.11986129e-02f,
  1.24587931e-01f, 4.21275906e-02f, -1.04696922e-01f, -3.15523706e-03f, -1.40202463e-01f, 3.05991173e-02f, 2.87728775e-02f, 9.37248021e-02f, -7.32768327e-02f, -7.44949058e-02f,
  -1.03127226e-01f, -7.28675500e-02f, -8.83889198e-02f, 1.12437345e-01f, -3.66948023e-02f, -8.79728142e-03f, -1.41468957e-01f, -1.41091317e-01f, 5.42282909e-02f, -7.49852136e-02f,
  1.33980766e-01f, -1.29231900e-01f, -1.26236305e-01f, 9.89324152e-02f, 1.41707107e-01f, 8.14947635e-02f, -1.19112328e-01f, 1.52164832e-01f, -3.45820338e-02f, -1.90779679e-02f,
  -8.57307091e-02f, 3.98501121e-02f, 1.00599088e-01f, -1.23630211e-01f, 2.90821254e-01f, -3.79705727e-02f, 3.06025445e-01f, -2.99882978e-01f, -7.39085674e-02f, -4.63790745e-02f,
  8.35134089e-02f, -2.49089599e-01f, -8.18265826e-02f, 1.94594860e-01f, 1.17191449e-02f, -1.89775884e-01f, -1.63021252e-01f, -5.98454326e-02f, 4.44240943e-02f, -1.61715716e-01f,
  -4.76718647e-03f, -5.33592999e-02f, -1.76227570e-01f, -2.53301561e-01f, -9.90951359e-02f, -1.83233395e-01f, 1.61020875e-01f, 1.08982675e-01f, 3.89211923e-02f, 1.24412812e-01f,
  -4.58558388e-02f, 2.70741861e-02f, -1.22620106e-01f, 1.89937100e-01f, -1.05775297e-01f, -1.81095768e-02f, 5.32162711e-02f, 1.82131097e-01f, 1.03766927e-02f, -6.86122850e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.14903541e-02f, 8.89935419e-02f, -9.66218039e-02f, 9.96155888e-02f, -2.66612284e-02f, -7.39404336e-02f, -8.65958557e-02f, -1.15180030e-01f, -6.26379624e-02f, -2.93247849e-02f,
  -3.58647183e-02f, -4.44210209e-02f, -1.19969342e-02f, -8.80911853e-03f, -7.16109127e-02f, 5.21765314e-02f, -3.18903029e-02f, -4.75278609e-02f, -4.95307520e-02f, -2.29274910e-02f,
  -1.11365512e-01f, -7.15087280e-02f, -4.02717702e-02f, -1.29527837e-01f, 1.05340622e-01f, -6.47226498e-02f, -6.71652481e-02f, 3.47731896e-02f, -3.95133719e-02f, -1.07396752e-01f,
  4.34771813e-02f, 3.76284905e-02f, 3.79448347e-02f, 9.34136212e-02f, 1.13915496e-01f, 1.73329748e-02f, 1.17217645e-01f, 1.98770389e-02f, -1.91373974e-02f, 3.45844030e-02f,
  -1.48965390e-02f, -1.03014462e-01f, -1.49497828e-02f, 6.17559180e-02f, -5.31123094e-02f, -7.18341246e-02f, -3.11242472e-02f, -3.89813520e-02f, -6.42823726e-02f, 7.68700317e-02f,
  -1.63611937e-02f, -1.29906729e-01f, -6.18822798e-02f, -5.79475947e-02f, 4.09152918e-03f, -2.34686807e-02f, 6.68037459e-02f, 2.36409809e-02f, 5.30075729e-02f, 6.46562725e-02f,
  1.50612905e-03f, -7.50338379e-03f, -1.17648900e-01f, 2.12951861e-02f, -1.64831169e-02f, 7.71979317e-02f, 6.33720309e-02f, 7.00770840e-02f, 9.61750522e-02f, -5.34830205e-02f,
  -1.01200536e-01f, 1.24794155e-01f, 9.83163193e-02f, 1.77980840e-01f, -5.84082194e-02f, -4.52024899e-02f, 5.32749221e-02f, 1.07847847e-01f, 1.03020176e-01f, -9.80576426e-02f,
  -6.28137961e-03f, 5.39715774e-02f, 6.51367605e-02f, -1.89272508e-01f, -8.56433585e-02f, 9.51647237e-02f, 9.23119336e-02f, -2.54674330e-02f, 9.14469361e-02f, 1.14960760e-01f,
  -1.10472158e-01f, 8.70494917e-02f, 7.91745782e-02f, 9.61651281e-02f, 1.95072603e-03f, 5.63655198e-02f, -2.81739198e-02f, 8.85687023e-02f, 2.72690486e-02f, 6.95285723e-02f,
  -9.01016518e-02f, -9.12663899e-03f, -9.84016582e-02f, -2.01873496e-01f, 1.80222869e-01f, 6.01947457e-02f, -1.45158082e-01f, 1.46691933e-01f, 1.22032918e-01f, -1.31701425e-01f,
  -1.04574539e-01f, 3.75532024e-02f, -4.63164411e-02f, 1.47703523e-02f, 7.99632743e-02f, 1.61108673e-01f, -1.22183554e-01f, 9.13211405e-02f, 3.68605927e-02f, 5.02400883e-02f,
  1.65135235e-01f, 8.92748833e-02f, 1.82758555e-01f, 4.10742238e-02f, 6.80073127e-02f, -8.52007233e-03f, 1.58432469e-01f, 1.23793138e-02f, -4.89116125e-02f, -2.19771545e-02f,
  -7.60109797e-02f, -2.13486049e-02f, 3.02912947e-02f, 1.40381843e-01f, 1.58791915e-01f, 4.93657663e-02f, 1.16788425e-01f, 1.48747116e-01f, 1.40836641e-01f, 2.32239310e-02f,
  6.79254010e-02f, 2.90872399e-02f, 6.88947439e-02f, 1.31038114e-01f, 5.58918826e-02f, -2.03058962e-02f, -9.19816643e-02f, 1.68740854e-01f, 1.01695277e-01f, -6.96231276e-02f,
  -5.28679555e-03f, 3.83410342e-02f, 1.19934939e-01f, 8.00322555e-03f, 5.95481135e-02f, -1.63956434e-01f, 1.66533485e-01f, -1.83969900e-01f, -9.67634916e-02f, 8.03058743e-02f,
  -1.75378814e-01f, -8.66793394e-02f, 9.92974341e-02f, 3.11147273e-02f, 1.42681196e-01f, 1.75169006e-01f, 1.07920609e-01f, 1.02497801e-01f, 4.71715117e-03f, -8.36505070e-02f,
  2.12071408e-02f, 4.80161468e-03f, 4.33923043e-02f, -1.07977413e-01f, -4.58361097e-02f, 8.86793882e-02f, 5.30377440e-02f, -1.69084802e-01f, 3.85537334e-02f, 5.51657677e-02f,
  1.90086618e-01f, -8.31797272e-02f, -1.22599185e-01f, -8.44921097e-02f, 2.14659125e-02f, -2.43605720e-03f, 1.14524275e-01f, 2.83563323e-02f, -5.77680916e-02f, 2.97796372e-02f,
  -3.62127833e-02f, 2.50448547e-02f, 1.59146696e-01f, 5.92188314e-02f, 2.85070073e-02f, -6.67256713e-02f, -3.42924967e-02f, -1.28844250e-02f, 7.07474202e-02f, 1.61760241e-01f,
  -7.82630742e-02f, 9.43926498e-02f, -1.67748854e-02f, -7.37938657e-02f, -1.77380145e-02f, -7.81802684e-02f, 1.18463852e-01f, 1.31630465e-01f, -9.26331580e-02f, -1.54145947e-02f,
  4.62149158e-02f, 8.24832544e-02f, -4.56546284e-02f, 6.86985329e-02f, 1.65800095e-01f, 7.19445478e-03f, 7.79503956e-02f, 1.46127388e-01f, -8.60714167e-02f, 7.00079799e-02f,
  1.07639737e-01f, 1.45240381e-01f, 2.05140579e-02f, -3.25038135e-02f, 3.58864293e-02f, 1.84425756e-01f, 1.21073760e-01f, -4.98760007e-02f, -1.08150072e-01f, -8.87891576e-02f,
  -1.49003983e-01f, 4.49645668e-02f, -6.05881214e-02f, -8.46242905e-02f, 2.42394675e-02f, -4.80692871e-02f, -8.27361643e-02f, -1.85455289e-02f, -1.32114574e-01f, -5.32854348e-02f,
  6.75241351e-02f, 2.77941935e-02f, 6.35099364e-03f, 6.43081544e-03f, -9.94528159e-02f, -1.01204745e-01f, -3.13459188e-02f, -2.64637563e-02f, -3.99480984e-02f, -4.37085591e-02f,
  -4.92158383e-02f, 2.02487432e-03f, -6.56194910e-02f, -9.01214033e-02f, -2.29442455e-02f, -6.45781457e-02f, 9.39695388e-02f, 1.13322482e-01f, -8.94048288e-02f, 2.41063386e-02f,
  1.14028379e-01f, 1.14929944e-01f, 9.25955176e-02f, -3.97812063e-03f, 1.04061641e-01f, 1.18868701e-01f, -4.02669571e-02f, -5.61905690e-02f, -6.49690181e-02f, -1.17840618e-01f,
  1.28726363e-01f, 3.64544466e-02f, 2.70029679e-02f, -8.04046690e-02f, -4.91413623e-02f, -1.84515920e-02f, -9.50585157e-02f, -9.35135260e-02f, 4.52430337e-04f, 9.43546519e-02f,
  1.00600362e-01f, 4.29234542e-02f, 1.36792123e-01f, -9.81346369e-02f, -6.54167086e-02f, -5.69293723e-02f, 5.36405928e-02f, 6.69252351e-02f, 4.32846434e-02f, -4.41806354e-02f,
  -6.27028942e-02f, -2.10490465e-01f, -7.21021816e-02f, -1.69365808e-01f, 1.06791914e-01f, -3.32378112e-02f, -5.57393394e-02f, -5.96327782e-02f, -5.27548939e-02f, 1.21672101e-01f,
  -1.99607778e-02f, -2.22678278e-02f, 1.28092207e-02f, -1.54448021e-02f, -9.60658938e-02f, 8.91815424e-02f, 5.77634908e-02f, 1.71747804e-01f, 1.20505735e-01f, -3.44816633e-02f,
  7.63319358e-02f, -3.86004895e-02f, 1.93088669e-02f, -3.44681703e-02f, 2.07012475e-01f, -8.48437473e-02f, -8.82412866e-02f, 1.48981987e-02f, -5.45257740e-02f, -5.85080534e-02f,
  1.07479908e-01f, 4.23646495e-02f, -1.01041339e-01f, 2.11153805e-01f, 1.50523573e-01f, 3.13009843e-02f, -5.24133779e-02f, 1.84586152e-01f, 1.67222694e-02f, 3.82018462e-02f,
  -1.15805715e-02f, -1.14179403e-02f, 8.23814422e-02f, 7.73943812e-02f, 3.52213369e-03f, 2.15171427e-02f, 1.76448420e-01f, 8.77208337e-02f, 1.54793575e-01f, -7.64676705e-02f,
  -2.24558711e-02f, 8.37880969e-02f, 1.09680496e-01f, 3.81483436e-02f, 1.38886020e-01f, 1.60455644e-01f, 1.18083358e-01f, 4.44571823e-02f, 1.88762128e-01f, 1.60597622e-01f,
  3.15181613e-01f, -2.47280806e-01f, -7.73052499e-02f, -1.76088005e-01f, 1.48968399e-01f, -1.04698082e-02f, -1.26253828e-01f, 2.42882848e-01f, -2.69671500e-01f, -3.14078599e-01f,
  2.48295441e-02f, 1.32783100e-01f, -3.29294838e-02f, 4.17784564e-02f, -1.79023389e-02f, -1.50830850e-01f, -2.83746514e-02f, -1.55577138e-01f, -2.76181489e-01f, -2.00178772e-01f,
  1.88551079e-02f, 9.58001465e-02f, -1.61834821e-01f, 1.56332031e-01f, -5.69412783e-02f, -2.14212164e-02f, -2.05651782e-02f, 2.88185894e-01f, -1.04965359e-01f, 1.27987206e-01f,
  -1.02519080e-01f, 3.13845485e-01f, 4.70965169e-03f, 8.74201059e-02f, -9.52866673e-02f, 1.76108852e-01f, -6.71205819e-02f, 2.62748376e-02f, 2.16268122e-01f, 3.62606831e-02f,
  9.16192755e-02f, -6.57789130e-03f, -4.13277782e-02f, 1.55236199e-01f, 1.02798223e-01f, 1.52108371e-01f, -6.84935823e-02f, 3.63418683e-02f, -1.03202239e-01f, 5.69401421e-02f,
  1.78798959e-01f, -1.10841192e-01f, 1.35505013e-03f, -1.22953936e-01f, -2.53440943e-02f, -3.11982166e-02f, 1.57409329e-02f, 6.74853027e-02f, 1.10930115e-01f, 8.02193955e-02f,
  1.08049698e-01f, 1.76642150e-01f, -5.02198935e-02f, -9.09581780e-02f, 3.72255631e-02f, 4.35601436e-02f, 7.59097934e-02f, -1.13656797e-01f, 8.31432864e-02f, -1.72440968e-02f,
  9.19669420e-02f, 1.14281982e-01f, -1.56049386e-01f, -1.50836840e-01f, 7.16310591e-02f, 8.82536620e-02f, -9.40133035e-02f, -6.79754987e-02f, -5.68595417e-02f, -1.64594844e-01f,
  -6.63785934e-02f, -1.80352479e-01f, -8.15530401e-03f, 3.82358618e-02f, 1.23418190e-01f, -8.83940309e-02f, 6.45960122e-02f, -1.13207735e-01f, 3.18159275e-02f, 1.14791848e-01f,
  5.82773648e-02f, 1.89151257e-01f, 2.58711755e-01f, -2.52785999e-02f, -7.17430264e-02f, 1.35702327e-01f, 7.59069100e-02f, 1.20577656e-01f, -7.46986130e-03f, 8.25406834e-02f,
  1.32704616e-01f, 1.24254353e-01f, -3.56670581e-02f, 4.80515920e-02f, 4.96137291e-02f, 1.54443711e-01f, -9.66172814e-02f, 1.90670900e-02f, 1.09418660e-01f, 1.41456842e-01f,
  1.26189470e-01f, 6.97154924e-02f, 5.72935566e-02f, 2.04928607e-01f, -1.73841640e-02f, 1.51451930e-01f, -1.91963911e-02f, 2.98345149e-01f, 1.88193873e-01f, 1.20376639e-01f,
  -1.12197272e-01f, 4.38139960e-02f, 1.17794432e-01f, 1.24277748e-01f, -4.76845726e-02f, 2.02854589e-01f, -1.92477945e-02f, 6.20134175e-02f, -9.07159001e-02f, 6.33668453e-02f,
  7.76613737e-03f, 3.80479425e-01f, 5.50634451e-02f, -2.52043456e-02f, 2.52483398e-01f, 1.31168470e-01f, 4.79658879e-03f, 1.95865527e-01f, 7.47542754e-02f, -7.93106854e-03f,
  1.19584493e-01f, 1.15234733e-01f, -9.88078639e-02f, -1.41937837e-01f, -2.78959692e-01f, 3.13908130e-01f, 2.13218391e-01f, -2.24406064e-01f, -8.13872218e-02f, -1.14802301e-01f,
  1.80729210e-01f, -1.15608566e-01f, 3.67199816e-02f, 9.22051966e-02f, 1.91174950e-02f, -5.09737208e-02f, -2.70681102e-02f, 2.63055861e-02f, -1.02001451e-01f, -9.41300299e-03f,
  1.04321120e-02f, 4.15377095e-02f, 1.22062147e-01f, 1.53497487e-01f, -3.35050784e-02f, -9.71794948e-02f, 4.50227149e-02f, -1.03530101e-01f, 2.23520063e-02f, 2.81703383e-01f,
  7.47658685e-02f, 7.34093115e-02f, -4.55704108e-02f, 1.13660231e-01f, 1.37663335e-01f, 9.13458765e-02f, 2.91403592e-01f, -1.53940201e-01f, 5.19054197e-02f, 3.41884270e-02f,
  1.52506575e-01f, 8.30503181e-02f, -1.32729402e-02f, 6.12412840e-02f, 1.91951454e-01f, 1.21359222e-01f, 2.27276504e-01f, -1.44827738e-01f, -1.92407280e-01f, -5.18666841e-02f,
  2.65865913e-03f, 1.69376537e-01f, 1.28376335e-01f, -5.17705418e-02f, 1.30548283e-01f, 1.46827683e-01f, -8.36800933e-02f, -1.94489464e-01f, -1.32131562e-01f, -7.01724589e-02f,
  -1.64755091e-01f, -6.36845902e-02f, -7.26325214e-02f, 2.49936044e-01f, 3.04273754e-01f, -3.40499766e-02f, -4.35329974e-02f, 1.43434346e-01f, -1.38680795e-02f, -1.00801542e-01f,
  -6.95662051e-02f, -5.98144941e-02f, -5.95804229e-02f, -3.01158801e-02f, -1.98462978e-01f, 1.46071479e-01f, -8.28689039e-02f, -9.50594842e-02f, -1.29982948e-01f, 2.63865218e-02f,
  -2.82984655e-02f, -8.09019431e-02f, -1.17577113e-01f, 1.97881356e-01f, 1.74096879e-02f, -1.10790469e-01f, 1.84193403e-01f, 8.78229737e-02f, 1.55965924e-01f, 6.25677332e-02f,
  6.85315207e-02f, 1.92084849e-01f, 1.81675285e-01f, 1.49114519e-01f, -1.10829598e-03f, -3.78010124e-02f, 8.38300511e-02f, 7.12819323e-02f, 1.13964684e-01f, -1.65570602e-02f,
  1.31616399e-01f, -2.38501374e-02f, -3.57418926e-03f, 1.09965988e-01f, -6.46219775e-02f, 1.81725472e-01f, 7.66514614e-02f, 2.14104488e-01f, 4.28947173e-02f, 1.47594452e-01f,
  9.68099013e-02f, -3.59401964e-02f, 6.35059923e-02f, -2.44801521e-01f, 8.08061752e-03f, -1.01050489e-01f, -1.07367545e-01f, -5.05229495e-02f, 4.38509434e-02f, -4.16131243e-02f,
  1.18525140e-01f, -2.45859399e-01f, 5.51601835e-02f, -8.01380947e-02f, 1.21303290e-01f, 2.31705353e-01f, -2.74395376e-01f, -1.19614467e-01f, 2.24812299e-01f, -2.26866931e-01f,
  1.76620483e-01f, 3.17462415e-01f, -7.41260126e-02f, 1.27511799e-01f, -6.30561039e-02f, -2.07649148e-03f, -1.42702028e-01f, 2.04336926e-01f, 1.91947997e-01f, 1.03142969e-01f,
  1.88042149e-02f, 1.09061003e-01f, -1.59832947e-02f, -1.94772869e-01f, -1.41728282e-01f, 8.19225386e-02f, 1.65523857e-01f, -4.60877158e-02f, 4.74324524e-02f, 2.87589543e-02f,
  9.96302888e-02f, 2.57397499e-02f, -1.02237500e-01f, 1.24440618e-01f, 2.47751310e-01f, -1.30589213e-02f, -5.86764589e-02f, -1.87932644e-02f, 5.92082366e-02f, 1.91223204e-01f,
  2.01701686e-01f, 9.97829959e-02f, 1.07826158e-01f, 7.53075257e-02f, -1.12044565e-01f, 1.87974036e-01f, 1.30455215e-02f, -4.99111190e-02f, 1.34800330e-01f, -1.75638460e-02f,
  1.66491568e-01f, 4.15815301e-02f, 4.41142954e-02f, 1.39829457e-01f, 6.52947947e-02f, -3.63126099e-02f, 1.41536564e-01f, 8.13144445e-02f, 1.83700845e-01f, -3.96157568e-03f,
  2.09602639e-01f, -3.42927463e-02f, -7.19857216e-02f, -8.56024995e-02f, 1.50480762e-01f, 2.91933659e-02f, -1.68855652e-01f, 1.73901066e-01f, 7.30110854e-02f, -2.69832343e-01f,
  1.26844451e-01f, 1.50291249e-01f, -1.68826610e-01f, -5.46468683e-02f, -1.34626105e-01f, -1.78865150e-01f, -5.74734099e-02f, -2.00890377e-01f, 5.00240512e-02f, -5.46247512e-02f,
  1.45072475e-01f, -9.11569372e-02f, 1.09030910e-01f, 6.53369501e-02f, -8.09981376e-02f, -7.75314271e-02f, -2.44908333e-02f, 2.20489725e-01f, 8.07507560e-02f, 1.11046121e-01f,
  2.83816680e-02f, 3.18719856e-02f, -3.85651216e-02f, -6.55775741e-02f, 8.77513736e-02f, 1.02775827e-01f, 5.43663427e-02f, -8.30814764e-02f, 1.42831028e-01f, -8.42022803e-03f,
  1.00305006e-02f, 1.00320593e-01f, 2.58243568e-02f, 1.14809655e-01f, -7.18972087e-02f, 1.13140814e-01f, -8.33163559e-02f, 9.42090824e-02f, 1.19274922e-01f, -1.29493073e-01f,
  -1.83508079e-02f, 1.04348674e-01f, 2.13880911e-01f, -2.41029020e-02f, -2.05015354e-02f, 1.01692304e-01f, 1.44089997e-01f, -8.55871588e-02f, 1.75355121e-01f, -3.49704474e-02f,
  -1.30161867e-01f, 5.00142351e-02f, 4.70231250e-02f, 1.30457878e-01f, 1.01561390e-01f, -7.17132315e-02f, 1.27406240e-01f, 3.28700244e-02f, 1.64893549e-02f, -5.59150577e-02f,
  -1.45019144e-01f, -1.80817813e-01f, -1.26681939e-01f, 8.79643764e-03f, -1.61424592e-01f, 2.29336768e-01f, 9.60603356e-02f, 4.58566286e-02f, 5.88740669e-02f, 1.83809977e-02f,
  1.07452758e-01f, 6.40946552e-02f, -1.89801127e-01f, -4.83011007e-02f, 1.64278615e-02f, -1.16273344e-01f, -5.74117862e-02f, -5.86824678e-02f, -1.16630793e-01f, 6.95233122e-02f,
  7.38749728e-02f, 8.70092064e-02f, -8.48659351e-02f, 1.17596112e-01f, 6.56411201e-02f, 2.51338948e-02f, -1.02486648e-01f, 7.46399388e-02f, 2.30029508e-01f, 1.71417251e-01f,
  -1.05071940e-01f, 1.40743673e-01f, 1.87642410e-01f, 1.61517978e-01f, 1.08308770e-01f, -1.02324910e-01f, 2.16713458e-01f, 5.25985435e-02f, 1.80289105e-01f, -9.05401707e-02f,
  1.03293456e-01f, -1.93840661e-03f, 6.08930439e-02f, 1.87659845e-01f, 1.30109012e-01f, 1.14549741e-01f, -7.15156365e-03f, -1.88450634e-01f, 5.25592864e-02f, 1.45147890e-01f,
  -1.84215769e-01f, -7.46526122e-02f, 1.83030054e-01f, -2.07904324e-01f, 2.01659665e-01f, 1.65212870e-01f, -1.60875082e-01f, 3.98688763e-02f, -1.46943226e-01f, 8.27540383e-02f,
  -1.43240437e-01f, 8.35193023e-02f, 5.57803875e-03f, 1.89826153e-02f, -7.25447312e-02f, -1.11360438e-01f, 1.97467163e-01f, 2.22448066e-01f, 1.04683630e-01f, -1.41387045e-01f,
  -1.66555703e-01f, 1.21154815e-01f, 1.61086112e-01f, 6.30739378e-03f, 6.82997005e-03f, 2.81226039e-01f, 2.70901769e-01f, 8.39328542e-02f, -8.04280862e-03f, 2.99052745e-02f,
  2.77113318e-01f, 1.82524137e-02f, 8.09783936e-02f, -6.55255318e-02f, 5.84397800e-02f, -9.04941708e-02f, 2.86152869e-01f, -4.80393171e-02f, -2.99939122e-02f, -1.21656477e-01f,
  -4.63148765e-02f, -7.69554749e-02f, 1.18986629e-01f, 3.03217918e-02f, -5.65292966e-03f, -2.62864511e-02f, 8.38208124e-02f, -1.53389443e-02f, 1.02590494e-01f, -1.93747189e-02f,
  3.86322364e-02f, -4.80257571e-02f, -4.75554764e-02f, 2.51396038e-02f, -1.84440706e-02f, -5.01080975e-02f, -2.25547235e-02f, 5.72644956e-02f, -1.11453538e-03f, 1.47636309e-01f,
  9.60051566e-02f, 1.74607784e-01f, 1.34890869e-01f, 1.64009601e-01f, 8.74499008e-02f, 1.52867615e-01f, 1.12142473e-01f, -5.05765155e-02f, -2.19239965e-02f, 3.37905586e-02f,
  -8.37286711e-02f, 2.14500865e-03f, -1.00113668e-01f, -1.07804164e-01f, 8.56347531e-02f, 2.16044515e-01f, -3.60030569e-02f, -1.33274004e-01f, 3.51019241e-02f, 2.04540286e-02f,
  -7.29970261e-02f, 1.32593170e-01f, -1.48469361e-03f, -4.36497107e-02f, 1.35041904e-02f, 1.28582969e-01f, 5.52054755e-02f, 1.02015838e-01f, -1.77583188e-01f, 2.31924385e-01f,
  -2.75489539e-02f, -1.02946885e-01f, -7.65045360e-02f, -1.02178872e-01f, 2.11371720e-01f, 6.46966472e-02f, 3.83556681e-03f, -2.78154970e-03f, 6.60796091e-02f, -1.45269647e-01f,
  3.70614007e-02f, 8.14531967e-02f, -1.09773204e-01f, 1.65782854e-01f, -7.49539435e-02f, -6.10916875e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.15959868e-01f, 9.97775123e-02f, -5.09393774e-02f, -8.14241841e-02f, 5.75266033e-02f, 1.20885372e-01f, 5.79710975e-02f, 2.01397780e-02f, 1.74722001e-01f, 1.06239609e-01f,
  5.68308355e-03f, 1.40110284e-01f, 4.70561236e-02f, 7.69780157e-03f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.36744887e-01f, 6.13308884e-02f, 2.01507553e-01f, 2.91954651e-02f, 1.09861769e-01f, -2.83563081e-02f, 2.74368771e-03f, 9.60000530e-02f, 6.14187419e-02f, -1.26036024e-02f,
  1.05335101e-01f, 1.04165755e-01f, 1.19044915e-01f, 1.90135539e-02f, 9.60813388e-02f, 1.54567420e-01f, -6.52865693e-02f, -1.42979026e-01f, -3.53931226e-02f, 7.56536052e-02f,
  8.46512094e-02f, 7.78269768e-02f, -7.99155515e-03f, -7.89638236e-02f, 1.77284613e-01f, -1.80339143e-02f, 1.21797867e-01f, -1.23245060e-01f, -1.71257138e-01f, 4.32512052e-02f,
  3.41756567e-02f, -1.54333785e-01f, 7.73642808e-02f, -1.87334999e-01f, -2.11262122e-01f, 2.00402550e-02f, 1.00682462e-02f, -9.16348621e-02f, -1.55062210e-02f, 2.14304607e-02f,
  -1.27183020e-01f, 7.81976730e-02f, -2.09773090e-02f, 1.34203508e-01f, -5.93544217e-03f, 1.01482622e-01f, 1.26049584e-02f, 1.18376896e-01f, -5.88564994e-03f, -8.90407711e-02f,
  -3.51285860e-02f, -5.55273108e-02f, -1.56984687e-01f, 6.92536607e-02f, -1.38959158e-02f, -1.83338836e-01f, -1.88074842e-01f, -1.52189538e-01f, 1.61707997e-01f, 1.19080849e-01f,
  -2.25434586e-01f, 1.94145158e-01f, -1.32505551e-01f, -1.14554204e-01f, -5.51096797e-02f, -8.40177462e-02f, -8.69087279e-02f, -1.33617306e-02f, -5.86148165e-02f, 3.16796564e-02f,
  9.82675329e-02f, -1.34922359e-02f, 3.84039246e-02f, 1.60249710e-01f, 5.86593114e-02f, 1.13420293e-01f, 1.79262176e-01f, -1.13723814e-01f, -9.33370292e-02f, 1.45369902e-01f,
  2.71210074e-02f, 9.07458663e-02f, 5.06969541e-02f, 1.10838346e-01f, 2.99823866e-03f, -4.35267724e-02f, 1.01905808e-01f, 3.84735353e-02f, -1.16395494e-02f, 1.06961869e-01f,
  1.98208943e-01f, 1.20234424e-02f, -7.89016560e-02f, -6.88778460e-02f, 3.26484740e-02f, -1.31176382e-01f, 1.71736792e-01f, 3.29204276e-02f, 7.71595761e-02f, 1.90684810e-01f,
  -1.76369101e-01f, 2.18237266e-01f, 1.85191594e-02f, 1.88129410e-01f, -1.06529534e-01f, 1.22861192e-02f, -2.02898398e-01f, 1.75056353e-01f, -6.10564128e-02f, 8.43834728e-02f,
  -1.19005360e-01f, -3.22548412e-02f, -1.75277721e-02f, -7.30436519e-02f, 3.03198975e-02f, -1.62918970e-01f, 1.24529205e-01f, -2.46597305e-02f, 1.62476785e-02f, -1.52591452e-01f,
  -1.87379763e-01f, 1.53979883e-01f, 2.14367121e-01f, 2.59327561e-01f, -2.41794229e-01f, 2.70979423e-02f, 7.01634735e-02f, 1.40096739e-01f, -5.94218075e-02f, -6.20899387e-02f,
  2.01292168e-02f, -6.91439807e-02f, -1.05298020e-01f, 8.21676105e-02f, -6.46309629e-02f, -4.05227877e-02f, -3.82128283e-02f, 1.82405666e-01f, -6.16815453e-03f, 5.34195118e-02f,
  1.01277895e-01f, 5.35314679e-02f, 1.55534729e-01f, 1.63527995e-01f, -1.55571532e-02f, 9.76314172e-02f, 1.30213782e-01f, -2.89015919e-02f, 1.75664723e-01f, 7.07899183e-02f,
  7.14301094e-02f, 3.48342024e-02f, 8.09648335e-02f, 6.31263852e-02f, 1.58556059e-01f, 1.56222135e-01f, 2.59619188e-02f, -7.59718120e-02f, -1.34045752e-02f, 1.02234423e-01f,
  1.49960980e-01f, -1.20574243e-01f, -1.83147430e-01f, 5.40392883e-02f, 6.32915422e-02f, -1.36496142e-01f, 2.10383143e-02f, -6.36785254e-02f, -1.36113703e-01f, -5.46924770e-02f,
  4.33269888e-02f, -1.15655422e-01f, 5.27127832e-02f, -3.45786624e-02f, -1.70064166e-01f, 2.46083543e-01f, 2.53218152e-02f, 4.10845764e-02f, -3.15719768e-02f, -1.59563735e-01f,
  -7.75135309e-02f, -1.24218106e-01f, -3.52028795e-02f, -2.70774066e-01f, -5.32515272e-02f, -7.06564561e-02f, -9.74537730e-02f, 7.81970993e-02f, -2.14305416e-01f, -1.54164091e-01f,
  1.73763763e-02f, -1.24696024e-01f, -1.34739771e-01f, -2.38155816e-02f, 1.77725349e-02f, 9.56083983e-02f, 8.20185691e-02f, -3.37662548e-02f, 1.10586137e-01f, 1.71148270e-01f,
  -4.60218713e-02f, -9.91399139e-02f, -8.78651906e-03f, -3.52755897e-02f, 9.66591481e-03f, -1.98235363e-02f, 8.21538568e-02f, -2.52567887e-01f, -1.87249497e-01f, 1.25189079e-03f,
  -1.38275638e-01f, 3.19933519e-02f, 2.25117281e-01f, -1.64476901e-01f, -4.10304144e-02f, -6.78242045e-03f, 2.35742986e-01f, 3.23839448e-02f, -1.28288805e-01f, 4.37398553e-02f,
  -1.70108423e-01f, 7.16951787e-02f, -3.12736154e-01f, 5.39309233e-02f, 4.86302897e-02f, -3.26074094e-01f, 6.72454089e-02f, -1.70692042e-01f, -4.41151112e-02f, -2.20304906e-01f,
  1.16006419e-01f, -5.07440530e-02f, 9.55942795e-02f, -3.38717885e-02f, 2.11062700e-01f, -1.76812425e-01f, -7.52441809e-02f, 1.02532143e-02f, -1.67859271e-02f, -1.41329631e-01f,
  -4.75012027e-02f, 4.77155447e-02f, 4.26483573e-03f, -2.26031616e-01f, 1.53094262e-01f, 1.73951179e-01f, -1.09934144e-01f, -1.83549285e-01f, -6.65361062e-02f, 3.02847952e-01f,
  -1.82032108e-01f, 1.72158942e-01f, -9.78770480e-02f, -1.01092078e-01f, -7.08451271e-02f, 2.56544203e-02f, 1.48502856e-01f, -1.00696884e-01f, 1.22794710e-01f, -1.36723882e-02f,
  4.93028834e-02f, -3.36710922e-03f, 5.33596203e-02f, -4.93376702e-02f, -3.37370560e-02f, 1.55344099e-01f, 1.33976163e-02f, -7.85400346e-02f, 8.80411081e-03f, -4.32838835e-02f,
  1.32054120e-01f, 1.84831500e-01f, 3.99329439e-02f, 3.80246639e-02f, 1.06686295e-03f, 6.96125254e-02f, 2.76518390e-02f, 6.45865947e-02f, 8.60467404e-02f, 1.42783105e-01f,
  6.39688363e-03f, -3.64536345e-02f, 1.71984896e-01f, -4.51166630e-02f, 1.05300667e-02f, 1.49193361e-01f, -8.36504921e-02f, 9.52530876e-02f, 1.92320421e-01f, 1.76849570e-02f,
  3.13434340e-02f, -3.79219688e-02f, 1.30233780e-01f, 1.13842227e-01f, 1.68352336e-01f, 6.56439215e-02f, -1.00372933e-01f, -6.11706357e-03f, 9.17855371e-03f, -6.28793091e-02f,
  -3.64652765e-03f, -4.05506976e-02f, -1.88752159e-01f, 2.81212926e-01f, -2.69771530e-03f, 1.43092155e-01f, 9.87769365e-02f, -1.68928638e-01f, -1.83915999e-02f, -1.19900323e-01f,
  4.45767902e-02f, -1.40155450e-01f, -1.88623354e-01f, -1.99720606e-01f, 1.51259392e-01f, 2.35513166e-01f, -1.51068196e-01f, -2.97680292e-02f, -2.12543264e-01f, -9.96941477e-02f,
  1.00658193e-01f, -1.33723021e-01f, -8.12426060e-02f, 1.02820165e-01f, 8.67130011e-02f, 1.35140300e-01f, 1.98134668e-02f, -1.59363504e-02f, 6.24344312e-02f, -4.75878119e-02f,
  1.11230135e-01f, -5.29937707e-02f, -8.07972346e-03f, -1.01120397e-01f, 9.70075652e-02f, 9.38098952e-02f, 9.23809856e-02f, -1.43596724e-01f, -1.04497038e-01f, -1.19794548e-01f,
  1.98066141e-02f, 7.42924511e-02f, 1.64615646e-01f, 3.89898978e-02f, 1.22904696e-01f, -1.44330366e-02f, 8.09094831e-02f, 1.93355426e-01f, 1.68804973e-02f, 2.02948391e-01f,
  2.00938761e-01f, -1.69583131e-02f, 1.60137892e-01f, -7.94902146e-02f, 5.15714325e-02f, 2.06925511e-01f, -2.86072969e-01f, 2.04299450e-01f, 2.19814721e-02f, 1.69610545e-01f,
  -1.25354707e-01f, -1.49457917e-01f, -2.05497831e-01f, -1.14708953e-03f, 2.99592800e-02f, 1.80135682e-01f, -3.34019810e-02f, 3.11835185e-02f, -1.01946279e-01f, 5.27956150e-03f,
  -1.18318036e-01f, -7.02263117e-02f, 8.71509165e-02f, 4.10516746e-02f, -1.09875351e-02f, -1.84491292e-01f, -1.58504024e-02f, 3.39997411e-02f, 2.21359074e-01f, 2.58501559e-01f,
  -1.48829147e-01f, -5.90638034e-02f, 8.19102824e-02f, 1.75746292e-01f, 1.42431751e-01f, 1.48096457e-01f, 9.89162251e-02f, 6.22723252e-02f, 1.67094231e-01f, -6.03800267e-02f,
  6.10048138e-03f, 1.84529610e-02f, -2.48797145e-02f, -4.90735471e-02f, 1.10630587e-01f, 1.64699137e-01f, 7.45132864e-02f, -1.72017254e-02f, 1.21506505e-01f, -5.03464341e-02f,
  -4.56993431e-02f, 5.80255836e-02f, 1.43054992e-01f, -2.05125008e-02f, 2.02940181e-01f, 1.75884992e-01f, -1.16160773e-02f, 1.21009555e-02f, -1.19603181e-03f, -2.33239569e-02f,
  -8.94428343e-02f, -1.39801636e-01f, 7.26298541e-02f, -1.71859711e-01f, -1.60628706e-01f, 1.60083011e-01f, -1.81939259e-01f, -2.61120796e-01f, -1.54080287e-01f, -2.58722663e-01f,
  1.34784594e-01f, -2.32329562e-01f, -1.83635965e-01f, 4.28878404e-02f, -1.22691087e-01f, 6.88429251e-02f, 1.23539925e-01f, -1.27681091e-01f, -1.11482762e-01f, -1.73658147e-01f,
  -4.08301353e-02f, -7.48361647e-02f, 1.34224296e-01f, -5.15045412e-02f, -2.54446100e-02f, 1.06223539e-01f, 7.10647702e-02f, 6.11623377e-02f, -4.71364856e-02f, -5.03941104e-02f,
  -2.51599811e-02f, 4.39449549e-02f, 3.15579958e-02f, 5.01914844e-02f, 1.14183770e-02f, 2.67410595e-02f, 5.89932948e-02f, -1.10092632e-01f, -1.84443891e-01f, 6.33645952e-02f,
  -9.36078504e-02f, 1.06142655e-01f, 1.88588798e-01f, -8.77632052e-02f, -6.99233487e-02f, -1.15457706e-01f, -4.85063270e-02f, -1.11450858e-01f, -1.08297504e-01f, -7.31266662e-02f,
  -1.42063990e-01f, -4.92427796e-02f, -3.34054045e-02f, 5.92519417e-02f, 8.22991729e-02f, -4.79125371e-03f, 1.25550896e-01f, -2.79640667e-02f, 8.66402611e-02f, -2.80158408e-02f,
  6.60071988e-03f, 7.21242651e-03f, 2.14851215e-01f, -5.29056676e-02f, -1.83243960e-01f, -1.79070100e-01f, -1.01574913e-01f, -2.60212809e-01f, 5.27694412e-02f, 2.49472596e-02f,
  5.68655552e-03f, -2.02525519e-02f, -1.33926466e-01f, -1.16372436e-01f, -1.52666003e-01f, -1.02314660e-02f, -2.41173863e-01f, -2.29167119e-01f, 8.35864767e-02f, -7.62865245e-02f,
  -1.25079840e-01f, -7.19322488e-02f, 1.24107204e-01f, -5.43501973e-02f, 1.32221490e-01f, -4.40420136e-02f, -8.51792395e-02f, -1.34676173e-01f, 2.94273552e-02f, 1.67278647e-01f,
  -6.75364882e-02f, 1.65952072e-02f, 3.11570801e-02f, -2.55080700e-01f, 2.63249036e-02f, 2.08969831e-01f, -1.09060414e-01f, -1.46478191e-01f, -1.11684069e-01f, -2.35423714e-01f,
  4.03327078e-01f, 1.14337064e-01f, -1.11836568e-01f, 2.00215187e-02f, -3.28084715e-02f, -1.49380844e-02f, -1.18433185e-01f, -9.20104533e-02f, -7.56568015e-02f, -7.16203749e-02f,
  -1.13922097e-01f, 6.92335293e-02f, -4.17718142e-02f, -8.65461156e-02f, 1.28098905e-01f, 3.84613150e-03f, -5.27246743e-02f, -2.64851153e-02f, -1.19964465e-01f, -6.20149355e-03f,
  -7.65524879e-02f, 6.03735121e-03f, -7.08799139e-02f, -4.37340816e-04f, -1.13719568e-01f, 8.91285576e-03f, 1.38836995e-01f, -6.22802451e-02f, 6.24590069e-02f, 1.68512344e-01f,
  -1.89009473e-01f, 1.55638695e-01f, -6.59389794e-02f, -2.56033719e-01f, 2.35595778e-01f, 3.46416198e-02f, 3.65934186e-02f, 1.37929916e-01f, -3.15391451e-01f, 2.35833049e-01f,
  -1.02487773e-01f, 2.09971771e-01f, -1.54846525e-02f, -1.21179290e-01f, -1.49202317e-01f, 1.55558228e-01f, -5.45557216e-02f, 1.72816470e-01f, 3.88448359e-03f, -1.32735252e-01f,
  -3.85635830e-02f, 1.83230966e-01f, 9.57718790e-02f, 1.44321218e-01f, -7.43956789e-02f, 1.42520249e-01f, 6.71876147e-02f, 3.76501195e-02f, 6.11598417e-02f, -1.09489644e-02f,
  3.26819897e-01f, 6.69516921e-02f, -1.59041062e-01f, 1.69395611e-01f, -2.67482460e-01f, -2.45203711e-02f, -4.81223352e-02f, 1.38299108e-01f, 9.56581831e-02f, 1.31994337e-01f,
  -1.11316174e-01f, -9.57945883e-02f, 4.45981212e-02f, 1.44421667e-01f, -1.30071551e-01f, -6.40031770e-02f, 3.77923511e-02f, -2.48677265e-02f, 2.40034293e-02f, -9.21800509e-02f,
  1.75990667e-02f, 2.23726109e-02f, 1.10577673e-01f, 4.89421822e-02f, -1.06231973e-01f, -5.01527004e-02f, -2.70510856e-02f, 1.06178597e-01f, -1.14136815e-01f, 6.45138382e-04f,
  5.59402145e-02f, 9.75633487e-02f, -2.32139304e-02f, 2.38154516e-01f, -1.77319810e-01f, -1.22446381e-01f, 1.03487141e-01f, -2.69864291e-01f, -5.61789796e-02f, -9.41891745e-02f,
  1.74616903e-01f, 5.69217466e-02f, -3.71712089e-01f, 1.35510638e-01f, 4.53881584e-02f, 7.43789896e-02f, -1.03678182e-01f, -8.95851478e-02f, -8.21396708e-02f, 5.88576272e-02f,
  1.89719573e-01f, 2.55790085e-01f, 4.75870408e-02f, -2.96231180e-01f, -7.52835423e-02f, -1.50090363e-02f, 5.11943698e-02f, -2.73891091e-02f, -7.70081058e-02f, 3.78214195e-02f,
  -1.25028223e-01f, 2.34438218e-02f, -1.22432560e-01f, 2.44560763e-01f, 2.50563830e-01f, -1.19862638e-01f, -8.09451044e-02f, 1.17486343e-01f, -3.42429243e-03f, -8.16870481e-03f,
  -3.65458727e-02f, 1.12285828e-02f, -1.07472185e-02f, 1.04073592e-01f, 6.54579476e-02f, -6.63453015e-03f, 2.86000036e-02f, -1.25782853e-02f, -2.38792878e-02f, 9.28268582e-03f,
  1.03777938e-01f, 1.17526121e-01f, 1.04741447e-01f, 1.45356312e-01f, 6.80662543e-02f, -7.41119534e-02f, 3.45082358e-02f, -1.55816793e-01f, -7.95125812e-02f, 6.74362248e-03f,
  2.85071302e-02f, -7.52987787e-02f, 1.00113459e-01f, 3.74945477e-02f, 1.62023976e-01f, 1.28167778e-01f, -8.16433225e-03f, 5.24029657e-02f, -2.75710344e-01f, -1.27044871e-01f,
  1.05739541e-01f, -1.41799465e-01f, 3.39138857e-03f, -8.77296552e-02f, 1.41092818e-02f, -5.60905412e-02f, -2.66481608e-01f, -1.06564216e-01f, -1.34450654e-02f, -2.63960302e-01f,
  -3.24329324e-02f, -1.06337987e-01f, -2.55611748e-01f, -2.04901267e-02f, 5.56050651e-02f, -5.02397865e-02f, -6.51650876e-02f, -9.46564972e-02f, -9.00389068e-03f, -1.16225980e-01f,
  1.55292107e-02f, -2.34028939e-02f, 1.27536386e-01f, -9.27515402e-02f, 1.32188857e-01f, -2.56223917e-01f, 6.48804307e-02f, 7.14982599e-02f, -1.99000239e-01f, 7.50185028e-02f,
  -4.73923534e-02f, -1.24846622e-01f, 3.11042100e-01f, 1.35720253e-01f, -1.67642936e-01f, 1.72063510e-03f, -2.33356699e-01f, 1.78899546e-03f, -1.21524677e-01f, -6.23677000e-02f,
  5.09877428e-02f, -1.55141279e-01f, -1.20067149e-01f, 2.18553208e-02f, -6.69536367e-02f, 8.52070153e-02f, 5.81424646e-02f, -1.27432838e-01f, -1.34898052e-01f, -2.18969285e-01f,
  -2.26130504e-02f, 6.76301792e-02f, -1.36616766e-01f, -2.05809623e-01f, -1.27799707e-02f, -5.66283017e-02f, -5.80370147e-03f, -5.28937504e-02f, -1.89660955e-02f, 8.82462338e-02f,
  6.20219223e-02f, 2.07889587e-01f, -1.17730424e-01f, 1.94462866e-01f, 2.26572007e-01f, -7.82629848e-03f, 2.57758498e-01f, 9.33170617e-02f, 2.18765303e-01f, 1.04386099e-01f,
  -2.84099858e-02f, 3.27326506e-01f, 6.53974712e-02f, 2.52434880e-01f, 1.70374006e-01f, -1.37145430e-01f, 7.74514675e-02f, 1.98888153e-01f, 9.86158699e-02f, 2.25639224e-01f,
  3.69428732e-02f, -1.74243838e-01f, 5.05441688e-02f, 2.48922765e-01f, 1.18007980e-01f, 1.06047906e-01f, 1.47796750e-01f, -7.54178613e-02f, 5.06248809e-02f, 1.77138031e-01f,
  3.84213515e-02f, -5.21202981e-02f, 9.43197832e-02f, 5.04832305e-02f, -2.11390220e-02f, 9.67983007e-02f, -8.85070637e-02f, -7.27522001e-02f, 7.07415640e-02f, -9.06984434e-02f,
  9.18117017e-02f, 2.85404064e-02f, -1.31966516e-01f, -5.30767515e-02f, 1.45717278e-01f, 1.71822850e-02f, -5.51694594e-02f, 8.37649852e-02f, -5.19415550e-02f, -1.26303181e-01f,
  -8.71434510e-02f, -1.54755697e-01f, -2.12693900e-01f, 9.43922326e-02f, 2.29173843e-02f, 9.27171856e-02f, -4.17255610e-02f, 2.30077654e-02f, 5.28796948e-02f, -3.16545516e-02f,
  4.05160189e-02f, 1.14357669e-03f, 2.76049823e-02f, -7.05679134e-03f, 1.55831259e-02f, -1.76311489e-02f, 3.21489304e-01f, 2.43509218e-01f, 2.35570483e-02f, 9.03810486e-02f,
  3.69665958e-02f, 2.25969285e-01f, 2.05074474e-01f, -1.07726892e-02f, 2.31732130e-01f, 1.88781977e-01f, 1.38279930e-01f, 2.78775424e-01f, 1.10609658e-01f, -1.41893119e-01f,
  1.37668431e-01f, 2.03646254e-02f, -1.67147309e-01f, 5.75191006e-02f, -7.76980966e-02f, 2.95822084e-01f, -9.53537673e-02f, 2.80057609e-01f, -1.17702089e-01f, 3.16500291e-02f,
  8.17424431e-02f, -5.62373735e-02f, -3.74954264e-03f, 3.04854274e-01f, 5.47959842e-02f, -1.81135610e-01f, 6.44602850e-02f, 2.58950982e-02f, 1.70047566e-01f, 7.89289996e-02f,
  -1.31895557e-01f, -1.34419560e-01f, -1.99755915e-02f, 1.12791754e-01f, -5.76018468e-02f, 1.83388203e-01f, -4.24828194e-02f, 8.38523582e-02f, 1.44335488e-02f, 1.98523290e-02f,
  -3.44284042e-03f, 5.06019853e-02f, 1.24701828e-01f, -1.18494608e-01f, 5.67926047e-03f, -8.90281200e-02f, 1.17631294e-01f, -6.09038286e-02f, -9.60078612e-02f, 9.30967703e-02f,
  -8.52728635e-02f, -5.77303674e-03f, 2.04894379e-01f, -7.30943307e-02f, -8.15626830e-02f, 9.19961184e-02f, 2.42514685e-01f, 2.02066317e-01f, -7.90500827e-03f, 1.42257139e-01f,
  -1.76955938e-01f, -1.96381837e-01f, -2.65032142e-01f, 7.53230751e-02f, -2.92315036e-02f, -2.30929106e-01f, 1.30549192e-01f, -2.05002964e-01f, 1.74428651e-03f, 2.03343555e-02f,
  -4.00137790e-02f, -1.52646482e-01f, -2.23066867e-03f, 8.53018016e-02f, 5.54431155e-02f, -9.80788916e-02f, -4.34055477e-02f, -1.47439867e-01f, -1.60680920e-01f, -1.03443570e-01f,
  -1.26734927e-01f, -8.39223713e-02f, -6.26798868e-02f, -9.58849713e-02f, 5.11585623e-02f, -6.91706035e-03f, -1.14911094e-01f, -7.70013779e-02f, -8.33556876e-02f, 2.58905292e-01f,
  -2.02170759e-01f, 1.23018071e-01f, 6.52754009e-02f, -3.82452533e-02f, -6.44383803e-02f, 1.63975596e-01f, 1.44653529e-01f, -8.82663131e-02f, -1.32094612e-02f, 8.94940048e-02f,
  -1.58413440e-01f, 1.12798929e-01f, -4.31018136e-02f, -1.22669116e-01f, -9.11892802e-02f, 5.16254567e-02f, -8.33630040e-02f, 9.70177650e-02f, -5.84323183e-02f, -1.17170652e-02f,
  -5.31662926e-02f, 1.44608349e-01f, 1.51306376e-01f, 9.85892373e-04f, 1.11750944e-03f, 8.63876194e-02f, 1.40472623e-02f, 5.30719943e-02f, 1.29737347e-01f, 3.08608245e-02f,
  1.77617744e-02f, 1.75362658e-02f, 7.85710961e-02f, -1.32431269e-01f, -1.92325801e-01f, 1.88440904e-01f, 6.67201802e-02f, -2.55319476e-01f, 1.33266091e-01f, 4.67982255e-02f,
  -7.10363090e-02f, 1.21529289e-01f, -2.56521940e-01f, 5.99042587e-02f, -4.24012430e-02f, 1.82335079e-01f, -1.78272337e-01f, 2.41658241e-02f, -1.43809423e-01f, 2.01665014e-01f,
  -5.13928272e-02f, 2.38180697e-01f, 1.78855821e-01f, 8.37111622e-02f, -5.66523299e-02f, -6.07813783e-02f, 1.05519667e-01f, 1.00299977e-01f, -9.30478200e-02f, 2.41505504e-02f,
  1.19100437e-01f, -3.56961004e-02f, -1.04955740e-01f, -1.02553159e-01f, 2.89920807e-01f, 7.93788806e-02f, -1.68749541e-01f, 1.52609810e-01f, -1.73631847e-01f, 2.46846620e-02f,
  -1.35899112e-01f, -1.68095231e-01f, 9.04899836e-03f, -2.01194629e-01f, -1.11618273e-01f, -2.50279129e-01f, -2.67955121e-02f, -2.51013786e-01f, 1.73634775e-02f, 1.24394387e-01f,
  -1.54477060e-01f, -5.56347966e-02f, -9.31907445e-02f, -6.43199533e-02f, -1.88026756e-01f, 2.07732785e-02f, -3.61936204e-02f, -3.85695621e-02f, 1.09490842e-01f, -3.13455984e-02f,
  -1.73008051e-02f, -2.78152805e-02f, -1.71002433e-01f, -1.94176883e-01f, -8.64112005e-02f, -1.41388148e-01f, -1.00272737e-01f, -2.26017296e-01f, 6.38091713e-02f, -1.76501304e-01f,
  1.91521585e-01f, -1.04597554e-01f, -1.60893515e-01f, 2.08173648e-01f, -2.07904339e-01f, -5.32483589e-03f, 8.60886723e-02f, -1.61961496e-01f, -9.94406864e-02f, -1.82603627e-01f,
  -1.52760655e-01f, 1.74564078e-01f, -1.07725747e-01f, 1.23531176e-02f, -1.74326614e-01f, -2.84923673e-01f, 5.08964211e-02f, 2.48812109e-01f, 9.55401361e-02f, -1.50516585e-01f,
  9.93996486e-03f, 4.08733673e-02f, 5.20726107e-02f, -3.48133668e-02f, 1.35989591e-01f, -1.18817547e-02f, 1.94476202e-01f, -1.11129217e-01f, 5.84837124e-02f, -2.86924541e-01f,
  2.10283007e-02f, -2.49568801e-02f, 8.72653276e-02f, 2.06960458e-02f, 1.21397479e-02f, -5.10054640e-02f, -1.32960286e-02f, 2.27747127e-01f, 2.58055985e-01f, -6.19405434e-02f,
  -1.40571922e-01f, 2.12418940e-02f, 4.61782403e-02f, -1.88425872e-02f, 9.70749632e-02f, -1.28624231e-01f, -8.86252970e-02f, 4.08631787e-02f, 7.76826516e-02f, -9.67116058e-02f,
  5.56050763e-02f, -1.31135788e-02f, -3.14819664e-02f, 1.58724673e-02f, -1.85228977e-02f, -4.53625731e-02f, 1.25576675e-01f, -5.87800983e-03f, 9.64971632e-02f, 1.59543175e-02f,
  -3.02363839e-02f, 1.73870206e-01f, -1.53999716e-01f, -7.28811398e-02f, 1.18940845e-02f, 1.59392297e-01f, 2.23761201e-02f, 8.07558075e-02f, 1.07107058e-01f, 1.31190121e-01f,
  8.84580687e-02f, -1.33470997e-01f, 1.62080839e-01f, -1.39611766e-01f, 8.33262876e-02f, -8.62400159e-02f, -1.24558285e-01f, -7.24426880e-02f, 2.17381001e-01f, -2.10094564e-02f,
  2.36339774e-02f, 3.12992781e-02f, -8.73356462e-02f, -1.82056874e-01f, 1.18188396e-01f, -1.15356565e-01f, 2.20175266e-01f, -1.76041290e-01f, 4.68421839e-02f, -1.31773189e-01f,
  -6.39522895e-02f, 1.19533546e-01f, -2.52660960e-01f, -8.69659856e-02f, 8.88246894e-02f, -4.03652415e-02f, 2.75247008e-01f, -4.66343351e-02f, -6.58573434e-02f, 6.39194995e-02f,
  -1.15542702e-01f, -6.40932024e-02f, -9.21923965e-02f, -5.79761667e-03f, -4.99743633e-02f, -8.26740041e-02f, 3.49948443e-02f, -9.45359319e-02f, 8.33442435e-02f, -4.11400087e-02f,
  -1.36896847e-02f, -1.29846960e-01f, -1.31103974e-02f, -5.67633584e-02f, -1.11035988e-01f, 1.09667055e-01f, -1.07535206e-01f, -1.64130539e-01f, 4.08134796e-03f, -1.06780425e-01f,
  7.57936239e-02f, 8.39435458e-02f, 9.87832025e-02f, 1.98439360e-02f, -1.38258478e-02f, 3.60763259e-02f, 3.20054730e-03f, 6.75621256e-02f, 2.52136409e-01f, -2.15097629e-02f,
  4.31005983e-03f, 4.94972877e-02f, 1.89606696e-01f, 1.30986184e-01f, -1.80412129e-01f, 1.77212894e-01f, 1.13995433e-01f, 6.73752353e-02f, 1.45819867e-02f, -1.74413890e-01f,
  -2.36396939e-01f, 1.72627896e-01f, -1.00419164e-01f, 2.86653340e-02f, -1.75443202e-01f, 1.45041151e-02f, 3.79716009e-02f, 2.51300454e-01f, -1.12425186e-01f, -9.73798409e-02f,
  1.09393671e-01f, 1.17941000e-01f, -2.15456379e-03f, -8.65283534e-02f, -8.71019810e-02f, 1.01548724e-01f, -7.74585158e-02f, 2.66395032e-01f, -1.43277630e-01f, -4.10459489e-02f,
  1.15331538e-01f, 1.83019623e-01f, 7.16485083e-02f, -6.23327941e-02f, -4.26592752e-02f, 1.52066618e-01f, -1.00029439e-01f, 1.18934706e-01f, 3.83272283e-02f, -7.79323876e-02f,
  8.78788456e-02f, 7.30866119e-02f, 9.44066569e-02f, 3.17191444e-02f, -4.24371697e-02f, -5.76803572e-02f, -1.18457871e-02f, -6.28393814e-02f, -9.02735516e-02f, -1.03730597e-01f,
  -8.28508809e-02f, -3.96694019e-02f, -9.39823985e-02f, -8.21244717e-02f, 9.52653438e-02f, -1.05518803e-01f, 1.61225104e-03f, -1.24671839e-01f, 5.81705458e-02f, 1.45798386e-03f,
  8.95031020e-02f, 2.13488236e-01f, 1.56035200e-01f, 1.30915623e-02f, 8.15581381e-02f, 1.13197885e-01f, 1.66427940e-01f, 2.07488552e-01f, -7.84015283e-02f, 1.79239810e-01f,
  4.29388434e-02f, 9.37381685e-02f, 5.75535335e-02f, 7.34659880e-02f, -1.52308673e-01f, -5.91894463e-02f, 9.02968273e-02f, 3.05429220e-01f, -5.87860160e-02f, -7.96084031e-02f,
  1.44255400e-01f, 8.90345052e-02f, -1.17302254e-01f, -1.65591657e-01f, -8.62110034e-02f, -1.22717451e-02f, 6.74755424e-02f, 2.24389970e-01f, -1.95199996e-02f, -1.53824985e-01f,
  2.19527304e-01f, 2.74261106e-02f, 1.28836468e-01f, 1.95263550e-01f, -1.45448238e-01f, 1.12766147e-01f, -1.57622308e-01f, -1.05208360e-01f, -1.98763788e-01f, -3.94884311e-02f,
  -1.73687756e-01f, -1.57139137e-01f, 9.73446891e-02f, 9.16394219e-02f, 4.91452776e-02f, 1.52326198e-02f, -1.46991725e-03f, 5.04336767e-02f, -3.04338709e-02f, 7.04481676e-02f,
  -1.37228385e-01f, -1.88139692e-01f, -3.17641459e-02f, 6.17253147e-02f, -3.54014686e-03f, -8.41351002e-02f, -2.05683351e-01f, -7.75648355e-02f, -5.95371351e-02f, -1.12366170e-01f,
  -6.98705614e-02f, 1.94727719e-01f, -1.11374229e-01f, 1.11140348e-01f, 1.00351438e-01f, 3.93625274e-02f, -1.71352118e-01f, 2.08767802e-01f, 7.78962076e-02f, -4.33769487e-02f,
  1.23693213e-01f, -2.16025829e-01f, -4.66352962e-02f, 4.47045974e-02f, -1.94755271e-02f, 1.55636668e-01f, 2.41510257e-01f, -1.04510427e-01f, 2.10478827e-01f, 6.05149679e-02f,
  1.19103558e-01f, -1.84295175e-03f, 1.01316758e-01f, -2.70285219e-01f, -1.14876479e-01f, 1.69439450e-01f, 2.80436706e-02f, -7.91071653e-02f, 1.10441662e-01f, -1.01557642e-01f,
  -2.17928439e-02f, 2.85170227e-01f, 1.54343560e-01f, 2.83637736e-02f, -1.07672200e-01f, -1.80239707e-01f, 1.49986550e-01f, -5.71215004e-02f, -4.80106175e-02f, 6.96978569e-02f,
  -4.61726449e-02f, -1.07299648e-01f, 1.69425741e-01f, 5.64653706e-03f, 1.29529059e-01f, -1.18760780e-01f, 6.63191453e-02f, 1.32814527e-01f, -6.58301776e-03f, 1.29851997e-01f,
  5.56364283e-02f, -3.93059254e-02f, -2.67266370e-02f, 8.24005157e-02f, 1.83149710e-01f, 7.05347285e-02f, 9.91995707e-02f, 8.43169317e-02f, -2.35048737e-02f, 1.11271240e-01f,
  1.39161736e-01f, 9.43691805e-02f, 9.06233042e-02f, 1.43908888e-01f, 1.00550070e-01f, -4.76202108e-02f, -2.00850088e-02f, -1.32980049e-01f, 1.79555088e-01f, 1.77589431e-02f,
  -2.34740436e-01f, 1.51834011e-01f, -1.94527823e-02f, -1.50413394e-01f, -1.40716106e-01f, -8.69708136e-02f, 1.92006797e-01f, -1.48973987e-01f, -9.56574902e-02f, -7.67614096e-02f,
  2.70744134e-02f, 9.86048207e-02f, 2.40189880e-01f, -9.04758647e-02f, -1.05763763e-01f, -3.64348218e-02f, 1.00151643e-01f, -5.25367633e-02f, 4.05083522e-02f, -2.75990907e-02f,
  1.20337546e-01f, -3.78867313e-02f, 9.95185599e-02f, -7.64126033e-02f, 2.74278745e-02f, 5.13015278e-02f, 1.36549532e-01f, -1.00261331e-01f, -1.09256662e-01f, -2.32357550e-02f,
  5.55996336e-02f, -9.75363106e-02f, 7.85306394e-02f, -1.43145293e-01f, -6.58589378e-02f, -2.94733047e-02f, -1.66776683e-02f, 8.17472264e-02f, 4.66417195e-03f, 3.80915366e-02f,
  -8.82918667e-03f, 1.08402967e-01f, 1.30644262e-01f, 1.64669499e-01f, 9.03024226e-02f, -1.47371635e-01f, 5.05676866e-02f, 1.40545502e-01f, 1.71809062e-01f, -7.99634233e-02f,
  8.22841525e-02f, -1.71105936e-01f, -8.72146860e-02f, -9.99516174e-02f, 1.38329059e-01f, -9.39979125e-03f, 3.27839963e-02f, 8.01734999e-02f, 2.22059965e-01f, 1.51194796e-01f,
  1.74945965e-01f, 1.10622749e-01f, -2.28394315e-01f, -5.03491201e-02f, -1.19984590e-01f, -1.30333394e-01f, 4.78349254e-02f, -1.27574876e-01f, -1.13973744e-01f, 9.09027159e-02f,
  -2.16069981e-01f, -9.20368582e-02f, 3.67201380e-02f, -2.11345404e-01f, -1.91681176e-01f, 5.09495921e-02f, -9.05546322e-02f, 6.62064180e-02f, 1.47485122e-01f, 2.09212422e-01f,
  -1.25769392e-01f, -9.98336300e-02f, -8.20681974e-02f, -1.84319213e-01f, -5.13599999e-02f, -1.04521491e-01f, 1.53099507e-01f, -7.60550648e-02f, -2.46691313e-02f, -3.46965283e-01f,
  -1.75003439e-01f, 1.25544891e-01f, -5.99472597e-02f, 2.92921990e-01f, -2.36317068e-01f, 6.58085197e-02f, -7.22727273e-03f, 1.87563643e-01f, 1.40390128e-01f, -6.64535686e-02f,
  1.11853756e-01f, -1.16265714e-01f, -8.37627277e-02f, -2.61028260e-02f, -6.03688769e-02f, -1.92115143e-01f, -1.17249310e-01f, 3.56845348e-03f, -6.69903457e-02f, 1.10535517e-01f,
  2.57779695e-02f, -4.35011759e-02f, -4.12119105e-02f, 8.51033553e-02f, 1.54372141e-01f, -1.73830688e-01f, -3.96324182e-03f, 7.31340125e-02f, -1.23281620e-01f, -3.20642181e-02f,
  1.01622678e-01f, -9.82426479e-02f, -1.33961424e-01f, -3.83469239e-02f, 1.35456964e-01f, -1.56305090e-01f, 5.67647442e-02f, 2.10053995e-01f, 1.87936753e-01f, -2.33308986e-01f,
  9.23723802e-02f, 1.70148030e-01f, -1.95722003e-02f, 1.20933481e-01f, -2.37596467e-01f, 1.99391976e-01f, -6.41851872e-02f, 1.63614407e-01f, -1.47123471e-01f, 1.62283203e-03f,
  -2.15940788e-01f, 7.65366852e-02f, -1.13697853e-02f, 2.46259898e-01f, 1.73287034e-01f, 7.13520348e-02f, 2.02561960e-01f, 8.10850039e-02f, 7.00416788e-02f, 1.12908728e-01f,
  -1.67084709e-01f, -7.25990627e-04f, 1.76220194e-01f, -1.72562152e-02f, -7.88490251e-02f, -2.17994243e-01f, 2.47857973e-01f, -3.14439572e-02f, -7.59988576e-02f, 1.80501610e-01f,
  -1.43369315e-02f, -3.34177203e-02f, 7.36907199e-02f, 1.13065071e-01f, -2.13736594e-01f, 7.67657012e-02f, -5.94101623e-02f, 1.57110959e-01f, 1.26007572e-01f, 1.38555557e-01f,
  5.86486571e-02f, -1.96543023e-01f, 6.52270168e-02f, -2.16946900e-02f, 1.99738562e-01f, -7.05267414e-02f, 1.62282735e-01f, -1.24492854e-01f, -1.17579577e-02f, 1.96253911e-01f,
  9.33819544e-03f, 7.09478855e-02f, -6.54326156e-02f, -8.54520947e-02f, -9.59011391e-02f, 5.66834286e-02f, 2.26290450e-01f, 1.68158501e-01f, 2.55353451e-02f, 1.86754018e-01f,
  -5.45631200e-02f, 4.73599657e-02f, 3.15999128e-02f, 1.67066783e-01f, 1.41314164e-01f, -1.18924841e-01f, 2.95794159e-01f, -2.18657792e-01f, -4.38958267e-03f, -2.37137061e-02f,
  -4.09842320e-02f, 1.99644506e-01f, 1.85172051e-01f, -2.36336231e-01f, -9.96150598e-02f, 4.82641049e-02f, 1.54924363e-01f, 3.08894724e-01f, -2.63449907e-01f, -2.52103031e-01f,
  1.07939048e-02f, 1.74681455e-01f, -1.53022688e-02f, -1.19871482e-01f, 1.67593911e-01f, 1.02934904e-01f, 7.62909502e-02f, -1.20363943e-01f, -1.33569688e-01f, 1.90314755e-01f,
  4.36287820e-02f, 1.40092328e-01f, -1.25021249e-01f, -1.87481880e-01f, 5.34762144e-02f, 7.56055191e-02f, 8.66497532e-02f, 4.88527492e-02f, -3.05620600e-02f, -8.82528815e-03f,
  6.28628880e-02f, -5.86251579e-02f, -1.69831980e-02f, -4.80942875e-02f, -3.02202143e-02f, -4.28073332e-02f, -9.91843268e-02f, 8.82822201e-02f, 4.30949479e-02f, -4.58095223e-02f,
  6.03218712e-02f, -1.26439884e-01f, -9.44937617e-02f, 3.12267728e-02f, 9.78974029e-02f, 1.46531299e-01f, 1.04291059e-01f, 1.15673661e-01f, -2.10598364e-01f, 7.25169778e-02f,
  2.85827797e-02f, -5.77190258e-02f, -5.72199747e-02f, 1.52928770e-01f, 2.02388823e-01f, -5.67155480e-02f, -3.58378559e-01f, 2.20328763e-01f, 8.03219080e-02f, -2.75999248e-01f,
  1.91194907e-01f, -2.69422889e-01f, 2.02215806e-01f, -1.73190564e-01f, 1.26626119e-02f, 2.01436117e-01f, 2.20178083e-01f, 2.99736615e-02f, 3.63022685e-01f, -2.14152396e-01f,
  9.80684459e-02f, -7.02109560e-02f, -2.03342631e-01f, 1.54765537e-02f, 1.96355482e-04f, 1.35814369e-01f, 4.30451259e-02f, -5.92758134e-02f, 1.19255655e-01f, 3.24720517e-02f,
  -5.69615588e-02f, 1.36218995e-01f, 9.81939510e-02f, -1.64029881e-01f, 6.21676333e-02f, -2.23988593e-02f, -1.21947490e-01f, -1.23385593e-01f, -3.11759830e-01f, -1.08934581e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.35974750e-01f, 1.12997621e-01f, 1.25254905e-02f, 2.27463171e-02f, -4.80359383e-02f, 1.30841667e-02f, -4.78093550e-02f, -2.27999985e-02f, -5.57867736e-02f, 1.31803527e-01f,
  1.41700171e-03f, -8.70004073e-02f, 9.90033820e-02f, 2.08670616e-01f, -9.50867757e-02f, -3.65258679e-02f, 7.07238764e-02f, 6.20054007e-02f, 3.23455855e-02f, 2.10518718e-01f,
  -8.81250873e-02f, -4.43192050e-02f, -4.50441614e-02f, -6.24337047e-03f, -7.80080110e-02f, 1.06318794e-01f, -5.08921370e-02f, -2.24256571e-02f, 1.72859207e-01f, -7.42590278e-02f,
  -1.91923946e-01f, -1.98331103e-02f, -1.06755674e-01f, 7.15848655e-02f, 1.55657515e-01f, -1.94348529e-01f, -6.51053265e-02f, -2.65204944e-02f, 6.58918265e-03f, 1.04802027e-01f,
  -1.49602126e-02f, 1.51316851e-01f, 2.37248957e-01f, -7.61077479e-02f, -7.08956495e-02f, 2.28135809e-02f, 1.13605484e-01f, -1.72840014e-01f, 4.88907769e-02f, 7.96443373e-02f,
  -1.21519879e-01f, 1.06580637e-01f, -8.68122503e-02f, 4.15477306e-02f, 2.25358587e-02f, 2.94810921e-01f, 1.92747250e-01f, 1.93957970e-01f, 1.48170501e-01f, -2.31184587e-02f,
  1.54135838e-01f, -1.45122819e-02f, -1.51462164e-02f, 5.99384494e-03f, 9.79604125e-02f, 6.47560209e-02f, 1.22224443e-01f, 1.48615092e-01f, -8.55529979e-02f, -1.15098804e-01f,
  5.86647131e-02f, 7.77118355e-02f, 2.96173710e-02f, 4.76638339e-02f, -1.12367071e-01f, -7.41101354e-02f, -1.42777547e-01f, 1.39273852e-01f, 8.36143941e-02f, 1.16435133e-01f,
  1.18938573e-01f, -4.68813442e-02f, 1.09363180e-02f, 1.27706910e-02f, 5.19219562e-02f, -5.19948676e-02f, -6.66609704e-02f, 9.79595631e-03f, -4.75243963e-02f, -4.26894650e-02f,
  -4.72042710e-02f, 4.08685915e-02f, 1.09121665e-01f, 1.33257940e-01f, 1.14640035e-01f, -2.59462129e-02f, -4.82772812e-02f, -5.07991202e-02f, 4.83029298e-02f, 1.34601757e-01f,
  9.80750695e-02f, -7.68640265e-03f, 1.14225328e-01f, 1.35154828e-01f, -4.74047288e-03f, 5.67090362e-02f, 2.16711201e-02f, -4.18231972e-02f, 5.03355451e-02f, -2.51497515e-02f,
  -1.00950236e-02f, -1.92262903e-02f, 1.52014643e-01f, 1.46706223e-01f, -4.74480912e-02f, 1.51345447e-01f, -9.59095731e-02f, -2.78421100e-02f, -2.93608778e-03f, 2.77847975e-01f,
  5.11131063e-02f, -7.25301122e-03f, 1.41792774e-01f, -3.71540673e-02f, 2.52308965e-01f, 1.45392390e-02f, -7.27248341e-02f, 1.16348751e-01f, 3.26268608e-03f, -3.52266990e-02f,
  8.36829469e-02f, 7.71897808e-02f, -2.43563224e-02f, 8.58805329e-03f, 9.52499360e-02f, -1.21640721e-02f, -9.06647667e-02f, 5.31079732e-02f, 2.80989204e-02f, -7.86979422e-02f,
  4.04999144e-02f, -5.76990582e-02f, 1.50050055e-02f, 1.46669090e-01f, -1.91674624e-02f, 1.11232407e-01f, 1.20469788e-02f, 5.63280582e-02f, 8.95593539e-02f, -4.78961878e-02f,
  -2.91895270e-02f, 1.13969155e-01f, -5.98822311e-02f, 3.61140221e-02f, 9.40835550e-02f, -6.52615055e-02f, 1.37952879e-01f, 6.71495423e-02f, 1.24898488e-02f, 4.07146215e-02f,
  3.16730142e-02f, -4.15160023e-02f, -2.57667918e-02f, 1.07692741e-01f, -6.07995130e-02f, -4.89516556e-02f, 1.44276872e-01f, 1.01033278e-01f, 2.20744256e-02f, 8.36887360e-02f,
  -9.87056196e-02f, 1.44480392e-01f, 6.57121614e-02f, -3.37043703e-02f, -1.14356391e-01f, 2.17972517e-01f, -4.53755260e-02f, 3.44854817e-02f, 3.44035067e-02f, -3.09262164e-02f,
  -1.09057680e-01f, -6.28054664e-02f, -3.24091054e-02f, 1.82607636e-01f, -8.57288390e-02f, -1.58290163e-01f, 1.29836529e-01f, 5.85584231e-02f, 7.92734027e-02f, 1.59983113e-01f,
  -9.19172317e-02f, -6.87699020e-02f, -3.85261700e-02f, 1.10316396e-01f, 6.58302307e-02f, 7.92946368e-02f, 1.57765836e-01f, 2.77703237e-02f, 6.01422153e-02f, 9.55426041e-03f,
  1.53098563e-02f, 5.56122102e-02f, -1.56713296e-02f, 1.10071249e-01f, -2.22786283e-03f, 1.55917600e-01f, 7.03362226e-02f, 2.06987038e-01f, 1.69512555e-01f, 2.03607008e-02f,
  9.55657102e-03f, 1.74879789e-01f, 1.59317628e-01f, -8.75273347e-02f, 1.23030044e-01f, 1.61107302e-01f, 1.29986331e-01f, 1.79938927e-01f, 2.12648958e-01f, -8.65941271e-02f,
  -9.72317159e-02f, 1.37527511e-01f, 2.55536251e-02f, -1.19449712e-01f, -5.74712791e-02f, -1.32617563e-01f, -4.56411839e-02f, -5.61640076e-02f, -2.29916915e-01f, -1.69196934e-01f,
  8.99825804e-03f, 4.01988216e-02f, 1.11512810e-01f, -1.40660793e-01f, -2.37731665e-01f, 1.91369772e-01f, 8.96520838e-02f, -1.42794400e-01f, -1.20388016e-01f, 6.62665367e-02f,
  -1.46728218e-01f, -3.94250117e-02f, -1.21105880e-01f, -9.74106193e-02f, 8.93562380e-03f, 1.02710247e-01f, -1.41246868e-02f, -2.13937595e-01f, -3.22402380e-02f, 2.16665477e-01f,
  -9.77160931e-02f, 2.38662258e-01f, -1.51918769e-01f, -1.44334540e-01f, 3.49348187e-01f, 2.31165916e-01f, 1.54948831e-01f, -8.10020715e-02f, -1.06204875e-01f, 8.10559615e-02f,
  -1.39006197e-01f, 1.01941638e-01f, 1.54511645e-01f, 4.27864380e-02f, 5.25151677e-02f, 1.23117976e-01f, 3.29392068e-02f, -9.11042988e-02f, -1.12332813e-01f, 5.74672706e-02f,
  9.79745090e-02f, -8.01492184e-02f, 1.41258031e-01f, 2.25466192e-01f, 1.51443943e-01f, 1.51394308e-01f, -8.89471248e-02f, 1.68417677e-01f, 1.45913407e-01f, 1.21785544e-01f,
  -1.97929554e-02f, 8.31525847e-02f, -3.54783721e-02f, 1.61455706e-01f, 1.27220541e-01f, 7.39928484e-02f, -1.94489017e-01f, 7.05397576e-02f, 4.82261442e-02f, 5.69262132e-02f,
  1.41841605e-01f, -1.42949313e-01f, 2.56490916e-01f, -2.65212562e-02f, 2.00967446e-01f, 2.17219636e-01f, 1.83879852e-01f, 4.89537306e-02f, 2.23685890e-01f, 8.63700882e-02f,
  -9.95224807e-03f, -1.89815998e-01f, -5.15407622e-02f, 1.78638965e-01f, -1.70815110e-01f, 2.43633941e-01f, -3.33011374e-02f, 1.55420735e-01f, 1.32391393e-01f, -1.91852469e-02f,
  -9.63925570e-02f, 2.97499895e-01f, 1.29446328e-01f, -1.55419305e-01f, 4.38069664e-02f, 1.19263463e-01f, 1.71133861e-01f, -2.76715402e-02f, -2.36455470e-01f, -1.13906927e-01f,
  3.90595347e-02f, -8.11670572e-02f, 1.23487495e-01f, -1.71652898e-01f, 9.37403366e-02f, 1.45175979e-01f, 1.17553160e-01f, 4.73823585e-02f, -5.88904507e-02f, 1.52722597e-01f,
  2.79719234e-02f, 6.60998821e-02f, 1.42840251e-01f, -7.82386516e-04f, 7.66936094e-02f, 1.69962734e-01f, 8.84197950e-02f, -6.34195954e-02f, 1.52130589e-01f, 1.24150425e-01f,
  1.60384566e-01f, 1.00616112e-01f, 4.33571301e-02f, -5.66721186e-02f, 1.08891942e-01f, -1.98910106e-02f, 1.30620906e-02f, -2.41668954e-01f, 2.45239541e-01f, -5.81731834e-02f,
  -1.88872561e-01f, 9.00899991e-02f, -7.33049363e-02f, 6.50438964e-02f, -1.00051381e-01f, -9.67852101e-02f, 7.05036968e-02f, 4.31950241e-02f, 4.04970050e-02f, 1.47559077e-01f,
  9.69554260e-02f, -9.71897468e-02f, 2.23667294e-01f, -3.98471877e-02f, -1.95050955e-01f, -1.33442149e-01f, -8.02368149e-02f, 7.79035389e-02f, 3.37992497e-02f, -7.43090510e-02f,
  -7.39506632e-02f, 6.33050548e-03f, -5.70752136e-02f, -6.49389327e-02f, 1.55827716e-01f, -2.41691675e-02f, 2.07371950e-01f, -1.80769354e-01f, 1.88387204e-02f, 1.19002596e-01f,
  4.27328870e-02f, 8.12697932e-02f, 9.55270380e-02f, -1.37098834e-01f, 8.15191343e-02f, 2.18779128e-02f, -7.04186561e-04f, 2.31012600e-04f, 1.29934356e-01f, 1.30229563e-01f,
  3.71850766e-02f, 5.74807823e-02f, 1.23514466e-01f, 4.16702637e-03f, 9.25946385e-02f, -3.24091502e-02f, 1.81595296e-01f, -1.38457566e-01f, 1.69393480e-01f, -6.59264550e-02f,
  7.06970990e-02f, -5.06254993e-02f, -2.06136536e-02f, -3.48941237e-02f, -6.09846935e-02f, 1.33151218e-01f, 2.65435934e-01f, 9.85119045e-02f, 1.68068200e-01f, 1.29502654e-01f,
  6.76048547e-02f, 2.85845786e-01f, 1.54867517e-02f, 3.36927146e-01f, 1.86546832e-01f, -2.53880452e-02f, 2.13559315e-01f, 5.03438711e-02f, 1.93161055e-01f, -2.36024545e-03f,
  -1.45549506e-01f, 2.43239552e-01f, 2.84599960e-01f, 2.14709580e-01f, 2.50971049e-01f, -2.63407916e-01f, -1.96704090e-01f, 1.54708415e-01f, 9.25352499e-02f, 4.21884090e-01f,
  -9.02222544e-02f, -3.20524909e-02f, -1.58473998e-02f, 2.84186065e-01f, -7.64607918e-03f, -9.45831090e-02f, 3.89050581e-02f, 1.13900080e-02f, 4.31393422e-02f, 6.55643120e-02f,
  -1.79666072e-01f, -1.13231488e-01f, -2.08019582e-03f, 4.18446720e-01f, 9.50679276e-03f, 1.03529692e-01f, 4.81782928e-02f, 1.46293491e-01f, -1.15763329e-01f, 1.12128459e-01f,
  4.94111620e-04f, 9.35106128e-02f, 1.39331684e-01f, 4.84511442e-02f, 1.27536103e-01f, -1.23396054e-01f, -2.17123982e-02f, 1.26132414e-01f, -5.85799143e-02f, 5.48027009e-02f,
  7.55196586e-02f, 1.27236769e-01f, 7.16607347e-02f, -4.55171317e-02f, 6.23029545e-02f, -3.93426791e-02f, -1.05920933e-01f, -8.14976320e-02f, -8.61304328e-02f, -2.71351729e-02f,
  8.25753585e-02f, -8.57702121e-02f, -1.31430596e-01f, 2.94339750e-02f, 4.60859239e-02f, -9.35530476e-03f, -6.78886473e-02f, 1.28569856e-01f, 1.71672001e-01f, -1.03063069e-01f,
  6.62913024e-02f, 8.77024904e-02f, 5.68177477e-02f, -3.12106870e-02f, 1.06658470e-02f, 5.45977615e-02f, -3.03288847e-02f, 2.67873686e-02f, -4.98602204e-02f, 5.92874810e-02f,
  -1.36885241e-01f, -4.61396500e-02f, -1.01824701e-01f, -7.38660479e-03f, -7.86169395e-02f, -6.32788241e-02f, 9.19796377e-02f, -1.81584153e-02f, 3.00822733e-03f, 3.41352783e-02f,
  8.50742683e-03f, 7.36181214e-02f, 1.37471348e-01f, 4.84273508e-02f, 1.31802127e-01f, -4.34005260e-03f, -6.95183724e-02f, 7.13987201e-02f, 9.68135893e-02f, -1.88584160e-02f,
  3.31614524e-01f, -7.57070482e-02f, 7.93544427e-02f, -4.47018333e-02f, 1.42636642e-01f, 9.58248228e-02f, 3.11554857e-02f, 2.13956714e-01f, 9.16618407e-02f, 7.48838484e-02f,
  1.58771321e-01f, 1.78801924e-01f, 2.10685223e-01f, 5.98259531e-02f, 5.54074757e-02f, 5.73765859e-02f, -5.40499240e-02f, -1.86657123e-02f, -9.34236031e-03f, 2.88422797e-02f,
  1.41716868e-01f, -7.50495344e-02f, 1.51900083e-01f, -2.42827088e-02f, 1.90045267e-01f, 5.40491194e-02f, 1.19885895e-02f, -1.66746408e-01f, 1.90502450e-01f, 4.83633988e-02f,
  1.79897383e-01f, 3.18869263e-01f, 1.06332414e-02f, 1.23839326e-01f, 1.67027920e-01f, -1.62783917e-02f, -1.34344518e-01f, -2.79691648e-02f, 1.70499429e-01f, -1.72656894e-01f,
  2.42124021e-01f, -1.13476895e-01f, 7.17183426e-02f, -2.27573782e-01f, -3.47875431e-02f, -8.16593319e-02f, 1.05110094e-01f, 9.87067968e-02f, 6.34578662e-03f, 3.63350332e-01f,
  8.75921473e-02f, -5.24130464e-03f, 7.10349232e-02f, 1.15032479e-01f, 1.32432923e-01f, -9.46474746e-02f, 1.85094669e-01f, -1.58997089e-01f, 8.62917602e-02f, -3.13031256e-01f,
  -2.18842831e-02f, 9.37157273e-02f, 7.71456063e-02f, -7.65378624e-02f, 3.62186968e-01f, -1.23602927e-01f, -5.36369830e-02f, 5.50231189e-02f, -5.20168198e-03f, -6.50788397e-02f,
  -1.35806175e-02f, -4.57511768e-02f, -8.28388631e-02f, 8.39190036e-02f, -2.08769180e-02f, 6.52353764e-02f, -3.44234258e-02f, -1.31162837e-01f, -4.75422405e-02f, -4.97157918e-03f,
  -9.73621085e-02f, 1.31163314e-01f, 2.72552166e-02f, -1.09358445e-01f, -4.18173932e-02f, 1.21929750e-01f, 1.31312013e-01f, 1.67107824e-02f, 6.26276210e-02f, 8.09339806e-03f,
  1.34439677e-01f, 9.84908417e-02f, 9.03220773e-02f, 6.19291933e-03f, -4.65692207e-02f, -8.40428621e-02f, 7.61599615e-02f, -1.02480948e-01f, -1.19739585e-01f, 5.76631725e-02f,
  -1.90530606e-02f, -2.44425312e-02f, 8.30843896e-02f, -3.76390703e-02f, -9.84740481e-02f, -2.19174605e-02f, -7.73144439e-02f, 6.80941641e-02f, -9.06366482e-03f, -1.29326820e-01f,
  -1.14721477e-01f, 7.87003487e-02f, 1.16878860e-02f, 8.79142508e-02f, -1.22139998e-01f, 2.76062395e-02f, -1.92749947e-02f, -1.02850102e-01f, 4.41653132e-02f, 1.44327730e-02f,
  -1.15082018e-01f, 1.08397715e-01f, -1.59031823e-02f, -1.15195803e-01f, 5.61959995e-03f, 1.17675208e-01f, -6.80577978e-02f, 4.26815674e-02f, -1.09958887e-01f, 5.29734567e-02f,
  -1.01318426e-01f, 1.63749814e-01f, -1.15469478e-01f, 1.13101058e-01f, 8.31110328e-02f, 2.18859479e-01f, -1.71133894e-02f, 5.75364642e-02f, 8.97795409e-02f, -1.01020634e-02f,
  8.85096043e-02f, 1.28483027e-01f, 1.87581316e-01f, -6.12851558e-03f, 6.28627092e-03f, 9.10283476e-02f, -5.13903536e-02f, -3.85894207e-03f, -5.37903123e-02f, -4.08092067e-02f,
  -4.06448469e-02f, 5.59894480e-02f, 1.36999130e-01f, 5.20544238e-02f, 7.84439780e-03f, 2.09094197e-01f, 2.03881487e-01f, 2.30588049e-01f, 5.75542357e-03f, 2.32853711e-01f,
  1.53294215e-02f, 1.38200685e-01f, 8.41430798e-02f, 9.32933390e-03f, 1.71664372e-01f, 2.97299344e-02f, -1.44496150e-02f, 9.97320563e-02f, 2.47294664e-01f, 1.17825307e-01f,
  2.44454086e-01f, -1.68312505e-01f, -1.80759728e-02f, -4.96628648e-03f, 7.32225552e-02f, 1.79069772e-01f, -2.22967193e-01f, 2.85343230e-02f, -5.76457717e-02f, 1.09152131e-01f,
  -2.84720969e-04f, -8.90342742e-02f, 7.64227808e-02f, 2.41108947e-02f, 1.22753941e-01f, -8.91530141e-02f, -1.33876130e-01f, 2.01787869e-03f, -5.99639714e-02f, 2.68945962e-01f,
  -1.32697457e-02f, -1.71022445e-01f, -1.00694364e-02f, -2.98811477e-02f, 1.26453444e-01f, -1.14461325e-01f, -5.49605154e-02f, 3.87849286e-02f, -2.36120615e-02f, 1.40563445e-02f,
  -1.01012453e-01f, 5.50167821e-02f, -7.80612007e-02f, 8.02622959e-02f, 1.28647769e-02f, 6.24935701e-02f, -2.39687376e-02f, 7.47209936e-02f, -7.18550086e-02f, 3.04197390e-02f,
  -2.80537903e-02f, -6.87807798e-02f, -2.65266169e-02f, -5.97403385e-02f, -9.42539349e-02f, -2.42852941e-02f, -1.17100857e-01f, 1.90258417e-02f, -5.86717799e-02f, 1.24877259e-01f,
  4.63672690e-02f, -3.26233469e-02f, 6.22874685e-02f, -8.12811926e-02f, -1.25470564e-01f, -1.25710353e-01f, 3.46583016e-02f, -1.04551628e-01f, 1.14643678e-01f, -4.77715954e-02f,
  -1.63178761e-02f, 8.29240754e-02f, -1.20261513e-01f, -2.29226761e-02f, -3.76673639e-02f, -4.46813777e-02f, 5.00421561e-02f, -5.24180569e-02f, 5.03323115e-02f, -9.01829675e-02f,
  4.10974436e-02f, 5.64461984e-02f, -7.92794749e-02f, -1.88002344e-02f, 8.05656090e-02f, 5.92517257e-02f, -1.57011822e-02f, -1.19383283e-01f, -1.14303589e-01f, 1.21560901e-01f,
  1.24399669e-01f, 1.18403755e-01f, -1.51295457e-02f, -6.50005117e-02f, -2.97138188e-02f, -3.54794674e-02f, 1.08693741e-01f, -1.02507897e-01f, -9.85740423e-02f, -1.86996553e-02f,
  3.34070101e-02f, 2.60528866e-02f, 1.72906872e-02f, -2.22111605e-02f, -3.71982269e-02f, -7.07665905e-02f, -1.23498723e-01f, -7.94780180e-02f, -1.05035231e-01f, 4.39121239e-02f,
  3.80452094e-03f, -9.11984686e-03f, -1.24029256e-01f, 1.73713751e-02f, 4.69544046e-02f, 6.95973858e-02f, -1.21851459e-01f, 2.81689707e-02f, -3.28090861e-02f, 1.35809556e-01f,
  -1.35140717e-01f, -4.72278446e-02f, -2.18337285e-03f, 3.85821499e-02f, 8.12004656e-02f, 8.10194686e-02f, -3.16911452e-02f, 5.26327789e-02f, -6.34387136e-02f, 3.61343995e-02f,
  -1.05529755e-01f, -3.21172215e-02f, 2.61164326e-02f, -1.16394125e-02f, -4.93755303e-02f, 3.04936580e-02f, -9.47281271e-02f, -3.94389555e-02f, 1.30874708e-01f, -5.00680208e-02f,
  2.58089509e-02f, -6.12272136e-03f, 1.37455370e-02f, -3.31412558e-03f, 9.42887217e-02f, -9.21267569e-02f, -8.77160653e-02f, 1.92594901e-02f, -4.23974730e-03f, -1.37486113e-02f,
  6.61774501e-02f, 3.48195247e-02f, -9.15585682e-02f, 1.64387599e-01f, -8.63862708e-02f, 8.45330432e-02f, 1.76850066e-01f, 1.00734062e-01f, 9.96311754e-02f, 1.50564551e-01f,
  -8.30789655e-02f, 1.45079002e-01f, 1.29557505e-01f, -2.67155282e-03f, -4.43456508e-02f, -1.32036045e-01f, -1.03717156e-01f, -3.74084748e-02f, 1.04617663e-01f, 1.06342740e-01f,
  6.74086139e-02f, 2.04964444e-01f, -6.87994361e-02f, -2.76419334e-02f, -1.18976511e-01f, 8.68579149e-02f, -8.56957808e-02f, 2.56011069e-01f, 1.16815850e-01f, 7.97372535e-02f,
  1.52174085e-01f, 2.40706224e-02f, 1.18761323e-01f, 1.88454036e-02f, -5.38945124e-02f, -4.29811981e-03f, -1.73137471e-01f, 1.08438432e-01f, 2.59317309e-01f, -2.06105277e-01f,
  1.85115542e-02f, 8.27672407e-02f, 1.36028022e-01f, 3.61100510e-02f, -4.61482294e-02f, -1.69808120e-02f, -1.63044527e-01f, 7.24212602e-02f, -6.68742182e-03f, -1.32179437e-02f,
  6.72278702e-02f, 8.96103978e-02f, 1.05647936e-01f, -4.36566323e-02f, -1.12021208e-01f, -1.66406985e-02f, -1.49588719e-01f, -2.20523611e-01f, -7.74159953e-02f, 3.47502679e-01f,
  1.25762016e-01f, 6.37125373e-02f, 7.74255022e-02f, -9.74177122e-02f, -1.63062036e-01f, 4.07495908e-02f, 4.82709706e-02f, 1.27198771e-01f, -4.08345275e-02f, -1.13775032e-02f,
  1.84976339e-01f, 2.51505941e-01f, 1.38696656e-02f, 5.72436228e-02f, 3.46489549e-02f, -1.75206084e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  9.93667990e-02f, 8.80298689e-02f, -5.60001843e-02f, 4.18081842e-02f, 6.19409010e-02f, -5.72287403e-02f, 1.34030327e-01f, 2.23069657e-02f, 1.06055915e-01f, -8.94498453e-02f,
  1.81222737e-01f, 1.42204329e-01f, -6.97701350e-02f, 9.89700258e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.34995356e-01f, -2.12814271e-01f, -5.12245223e-02f, -3.37390006e-01f, -2.42064055e-02f, -1.59104854e-01f, -2.04855517e-01f, -1.14569992e-01f, -3.67821783e-01f, -7.01992214e-02f,
  -1.17521018e-01f, -2.48939767e-01f, -4.30497319e-01f, -1.08113490e-01f, -4.00320053e-01f, 3.71237285e-02f, -7.19258711e-02f, -1.22865900e-01f, -2.68982440e-01f, 1.95874542e-01f,
  -5.74505292e-02f, 1.69542223e-01f, -1.78810671e-01f, 1.34719640e-01f, -5.95287159e-02f, -1.29015535e-01f, 2.15566739e-01f, -1.26000643e-01f, -3.96503247e-02f, 1.41189605e-01f,
  5.67151383e-02f, -4.82847661e-01f, 2.32986156e-02f, 1.62146762e-01f, 3.19097877e-01f, -4.11003828e-01f, 1.71660647e-01f, 8.26354548e-02f, -3.86204422e-01f, 2.49786496e-01f,
  -2.65366733e-01f, -2.70050496e-01f, 1.59761369e-01f, 2.06467360e-01f, 1.47056997e-01f, -1.56748697e-01f, -3.41149420e-01f, 2.82676637e-01f, 1.12680286e-01f, -1.00084759e-01f,
  -9.81618837e-03f, 2.51742810e-01f, 2.71335214e-01f, -2.26122454e-01f, 2.79952109e-01f, -3.47093701e-01f, 2.06174597e-01f, -1.13762766e-01f, -2.96654105e-01f, -5.25980070e-02f,
  5.43957837e-02f, 3.21457610e-02f, 1.66036740e-01f, 2.51760215e-01f, 2.70803440e-02f, 2.37509474e-01f, -2.15793818e-01f, -2.63053596e-01f, 2.05046888e-02f, 3.40883076e-01f,
  7.06070215e-02f, -1.43167019e-01f, 3.06542158e-01f, 1.22492209e-01f, -1.93731368e-01f, 2.70315796e-01f, -2.15333894e-01f, 5.35545126e-03f, 2.66950905e-01f, 9.61329639e-02f,
  -6.74551353e-02f, 8.37411880e-02f, -1.82236984e-01f, 6.36109933e-02f, 2.89386529e-02f, -6.61310554e-01f, 3.88504088e-01f, 3.87547106e-01f, 3.28117877e-01f, -1.08343981e-01f,
  -1.73665255e-01f, -2.12268591e-01f, -5.27930796e-01f, -4.39415015e-02f, -3.51056963e-01f, 8.52480829e-02f, 3.05218190e-01f, 5.74082881e-02f, -3.36053491e-01f, -2.29483977e-01f,
  3.09614390e-01f, -2.05036551e-02f, -4.59475458e-01f, 1.25896484e-01f, 4.13920917e-02f, -4.71193075e-01f, -2.89515316e-01f, -1.05341952e-02f, 3.57839882e-01f, 2.62854099e-01f,
  -3.23411524e-01f, 1.75458193e-01f, 1.57187015e-01f, 3.23357403e-01f, 2.50378758e-01f, 1.32901743e-01f, 6.65660277e-02f, -3.21886033e-01f, 2.34971076e-01f, 3.74949127e-01f,
  -1.73367724e-01f, 3.30902934e-02f, 8.58605802e-02f, -9.73081216e-02f, -6.40550256e-02f, 8.04049969e-02f, -3.78287135e-04f, 7.72048384e-02f, 1.87413871e-01f, 1.73112929e-01f,
  -2.21342698e-01f, 8.13265219e-02f, 2.91397244e-01f, 3.95134371e-03f, 4.32993285e-02f, 4.05882984e-01f, 2.45949011e-02f, -2.02676401e-01f, 3.80854636e-01f, 2.12315232e-01f,
  5.64093232e-01f, -3.50790620e-02f, 3.20961684e-01f, -1.44472510e-01f, 2.24838212e-01f, 4.20737779e-03f, 1.68676734e-01f, 7.18620121e-02f, 1.22008413e-01f, 2.83949494e-01f,
  2.42025703e-01f, -5.08186102e-01f, 2.70263344e-01f, 1.25369802e-01f, 1.32535785e-01f, -1.50721937e-01f, 4.64248687e-01f, -2.28651747e-01f, 3.10079396e-01f, 2.67171204e-01f,
  -4.02044237e-01f, 4.28154558e-01f, 1.10459618e-01f, 1.83011115e-01f, 1.16874620e-01f, 3.87037285e-02f, 1.65454760e-01f, 1.17448553e-01f, 2.39934191e-01f, -1.11103289e-01f,
  2.16002941e-01f, 3.21238935e-01f, 1.72805175e-01f, 9.29829292e-03f, 2.36455262e-01f, -2.87569344e-01f, 6.51338547e-02f, 3.73327941e-01f, 1.93322003e-01f, 1.21083826e-01f,
  -1.08209528e-01f, -4.33184812e-03f, -6.66915178e-02f, -1.77572668e-01f, 2.91449070e-01f, -1.48726761e-01f, -3.74733984e-01f, -4.25760485e-02f, 8.76839682e-02f, -9.00666788e-02f,
  2.10913688e-01f, -2.25893289e-01f, -4.82775658e-01f, -1.56950966e-01f, 7.72772133e-02f, -1.10442363e-01f, -1.29346121e-02f, -2.94489056e-01f, 2.09370971e-01f, 2.26054564e-01f,
  -3.81657258e-02f, 6.92223907e-02f, 1.42478824e-01f, 3.17874312e-01f, 2.28758335e-01f, -6.97698817e-03f, -4.93754894e-01f, -3.49714682e-02f, 2.00358331e-01f, 1.58362448e-01f,
  -4.88220528e-02f, -4.01093066e-01f, 2.87263185e-01f, -1.41999871e-01f, -1.10810809e-01f, 4.53495622e-01f, -1.06648743e-01f, 2.97115207e-01f, 2.18103662e-01f, 8.40826780e-02f,
  -2.39237055e-01f, 3.91819447e-01f, 1.09724276e-01f, -1.27800301e-01f, -1.82132587e-01f, 1.73391238e-01f, -4.70574340e-03f, 2.39016637e-01f, -2.06846207e-01f, -1.15781769e-01f,
  -2.71607220e-01f, 2.65159965e-01f, -4.31161791e-01f, 7.27780014e-02f, -4.55140062e-02f, 4.27577823e-01f, -1.11671984e-01f, 1.06812358e-01f, 2.98291415e-01f, 3.76365721e-01f,
  5.84579557e-02f, -3.88004512e-01f, -2.11023048e-01f, -1.80105940e-02f, 1.13720939e-01f, 2.01103911e-02f, -3.54556412e-01f, 1.25506505e-01f, 2.04816237e-01f, -7.56237879e-02f,
  3.51032317e-01f, 5.80447391e-02f, -5.43877147e-02f, -1.27177343e-01f, -6.95596039e-02f, 7.34376013e-02f, 6.34525064e-03f, -1.84545606e-01f, 1.39538810e-01f, 1.52594015e-01f,
  -1.28907606e-01f, -3.07437539e-01f, 1.08994447e-01f, 8.32944512e-02f, -3.22188586e-01f, -6.75052106e-02f, 2.64628548e-02f, 3.38372737e-02f, 8.16030130e-02f, 2.37940162e-01f,
  -2.93898523e-01f, -2.71229476e-01f, 5.73642738e-02f, -3.07882905e-01f, -4.28210422e-02f, 1.82475224e-01f, 9.44858491e-02f, 4.46860958e-03f, 1.59452617e-01f, -4.64378893e-01f,
  5.88016286e-02f, 2.55666822e-01f, -2.50220895e-01f, -3.53760570e-02f, -2.24555567e-01f, 2.56856471e-01f, -3.02363306e-01f, -4.73859429e-01f, -1.82541862e-01f, 1.20586194e-01f,
  1.37998357e-01f, 1.83544010e-01f, 4.27266270e-01f, 3.34997833e-01f, -2.81676482e-02f, 2.53081858e-01f, 2.29630351e-01f, -1.13626830e-01f, 2.72581309e-01f, 1.36322990e-01f,
  -2.77448714e-01f, -2.52233505e-01f, 3.60354483e-01f, 5.22395313e-01f, 1.59641325e-01f, -2.23171607e-01f, -2.70535976e-01f, -1.22495264e-01f, -4.88656908e-02f, 2.28751421e-01f,
  -6.68360433e-03f, -1.92656577e-01f, 4.43541199e-01f, -3.43805552e-03f, -1.21200196e-01f, -4.75489534e-03f, 4.50139940e-01f, 8.59942287e-02f, -8.78058895e-02f, -2.10217405e-02f,
  2.10084300e-02f, 6.37360141e-02f, 2.76230186e-01f, 3.78518343e-01f, 2.31672406e-01f, 5.82029037e-02f, 1.59522876e-01f, -2.52733231e-01f, 7.33162388e-02f, 4.60875958e-01f,
  1.68252781e-01f, 1.87344015e-01f, -1.70166984e-01f, 2.59016305e-01f, 6.82944134e-02f, -3.60028923e-01f, 2.37032384e-01f, 1.29849687e-02f, -2.94849556e-02f, 5.76657951e-02f,
  -9.92547162e-03f, 1.72913104e-01f, 2.21899435e-01f, -3.01450014e-01f, -2.42636576e-01f, -7.45426863e-02f, -1.97082222e-01f, -2.09558800e-01f, -3.47952358e-02f, 2.30845794e-01f,
  1.12275630e-01f, 1.18633077e-01f, -3.73335540e-01f, -1.05192214e-02f, -5.54336682e-02f, -3.00047129e-01f, 3.24621320e-01f, 5.39624810e-01f, -2.93939691e-02f, -1.69335395e-01f,
  2.47971371e-01f, 2.29215905e-01f, -1.83092654e-01f, 3.36935103e-01f, 1.97793335e-01f, 2.25732863e-01f, -3.96539658e-01f, -3.09912860e-01f, 3.10087711e-01f, 1.97636113e-01f,
  -1.31228536e-01f, 1.14877142e-01f, -9.92724970e-02f, -4.63511050e-01f, 4.05803621e-01f, -1.28090888e-01f, 3.00712764e-01f, -1.40268236e-01f, 2.84671277e-01f, -8.10284764e-02f,
  2.21162543e-01f, 6.67307004e-02f, -8.36282521e-02f, -4.03256267e-01f, -1.80263892e-02f, 2.98667371e-01f, 1.58444688e-01f, 2.57815570e-02f, -1.64713383e-01f, 1.41275227e-01f,
  -1.64124399e-01f, -1.05922684e-01f, -2.61904188e-02f, 1.50548115e-01f, -2.04222113e-01f, 1.41708087e-02f, -9.47765037e-02f, -4.89595085e-01f, 2.89603695e-03f, 1.36847049e-01f,
  -8.65128338e-02f, 1.78885892e-01f, -2.81096041e-01f, 1.12360783e-01f, -6.39407663e-03f, 2.48047516e-01f, -5.40199995e-01f, -1.48396373e-01f, 3.83392721e-01f, -3.14141154e-01f,
  -8.02559499e-03f, -2.74459403e-02f, 3.17872077e-01f, -1.88934952e-01f, -1.94780231e-01f, 2.48738572e-01f, 3.99368286e-01f, -1.26009151e-01f, 3.40983897e-01f, 2.79082656e-01f,
  -1.55537963e-01f, -4.91420299e-01f, 2.34961376e-01f, -5.00964880e-01f, -3.34525526e-01f, 2.60012925e-01f, -1.77098349e-01f, -4.48008329e-01f, 2.92329609e-01f, 2.19320148e-01f,
  3.73063445e-01f, -4.13136259e-02f, 2.66666353e-01f, 3.05664927e-01f, 3.17831561e-02f, -1.46475464e-01f, -1.58287287e-01f, 9.72510204e-02f, -2.82730162e-02f, -3.46713625e-02f,
  -4.71970499e-01f, -1.68741226e-01f, -1.87813446e-01f, 1.59975898e-03f, -1.45471960e-01f, 7.72033706e-02f, 6.15297742e-02f, -2.06016600e-01f, 1.23799648e-02f, 2.10479975e-01f,
  1.11220963e-01f, -2.17213526e-01f, -7.27430508e-02f, 1.01172358e-01f, 5.32855727e-02f, -3.60360533e-01f, -2.36658081e-01f, 2.39222005e-01f, -3.14473629e-01f, -2.95021385e-01f,
  -1.10683188e-01f, 2.61255279e-02f, 2.63530821e-01f, 1.41505808e-01f, -1.95534244e-01f, 1.72422692e-01f, 4.20808047e-02f, -2.32545197e-01f, 8.50847587e-02f, 2.34042898e-01f,
  1.95668891e-01f, 2.48051271e-01f, -2.68319845e-01f, -8.52436125e-02f, -1.79062471e-01f, -7.06468374e-02f, -2.14342356e-01f, -1.96422249e-01f, -3.83434184e-02f, 1.09670520e-01f,
  2.43425146e-01f, -3.76069307e-01f, -2.73073375e-01f, 2.60841906e-01f, -2.77361006e-01f, -2.09514141e-01f, -4.15707797e-01f, -6.29978403e-02f, 7.75996387e-01f, 5.05405925e-02f,
  -3.47057544e-02f, -7.86379874e-02f, -2.48823881e-01f, 1.04411200e-01f, -1.18009768e-01f, 1.42990902e-01f, -5.48680842e-01f, -3.07357520e-01f, -2.17182308e-01f, 1.25506714e-01f,
  7.61565045e-02f, 1.70043588e-01f, -2.27882788e-01f, -4.01844606e-02f, -3.97398651e-01f, 2.37729222e-01f, 3.79299432e-01f, 1.32287070e-02f, -1.64868385e-01f, -1.12539470e-01f,
  -1.41526172e-02f, 1.36798382e-01f, 1.31554171e-01f, -2.16039598e-01f, -3.63304513e-03f, 1.81766391e-01f, 1.76369861e-01f, -6.37226105e-02f, -1.31907180e-01f, 1.21381350e-01f,
  -2.54668951e-01f, 4.98219207e-03f, 1.06023267e-01f, -3.39041233e-01f, 1.80841982e-01f, -1.10919774e-01f, -8.43347311e-02f, 3.02562594e-01f, -4.42665955e-03f, -3.32262546e-01f,
  -1.54903177e-02f, 9.65676755e-02f, -3.85502875e-01f, 6.19435497e-02f, -2.89572060e-01f, 2.53483772e-01f, -3.24641652e-02f, -1.69740632e-01f, -4.81148273e-01f, -1.85219169e-01f,
  6.09093942e-02f, -8.92233178e-02f, -3.73379529e-01f, -2.44617946e-02f, -3.79981659e-02f, -1.91696689e-01f, -3.11768204e-01f, -4.82757986e-02f, -2.49969661e-01f, 1.96588665e-01f,
  3.07002842e-01f, -2.09730938e-01f, -7.95099661e-02f, 9.88110714e-03f, -2.81266898e-01f, -4.31496739e-01f, 1.89427018e-01f, 1.40282465e-02f, -3.41064274e-01f, -2.40788937e-01f,
  -2.49117047e-01f, 2.35291213e-01f, 2.75835752e-01f, 1.91656038e-01f, 7.86738936e-03f, -8.38924572e-02f, 3.31065625e-01f, 2.78836012e-01f, -5.09669244e-01f, -1.04058504e-01f,
  -1.78584695e-01f, 1.06120273e-01f, -3.72350246e-01f, 1.19273394e-01f, -1.21471621e-01f, -1.22700840e-01f, 5.57557829e-02f, -3.83710489e-02f, 5.67128100e-02f, 3.24933492e-02f,
  -9.39125195e-02f, -1.63651139e-01f, 1.77922398e-01f, 1.61925688e-01f, 1.29135787e-01f, 1.05695032e-01f, -2.86846489e-01f, 2.49327391e-01f, 1.08085655e-01f, -2.39531830e-01f,
  1.06445692e-01f, -6.76871687e-02f, -4.66543853e-01f, -2.00491875e-01f, 1.06034547e-01f, 7.34173208e-02f, 6.03384189e-02f, -2.00899407e-01f, -3.04606944e-01f, -2.23320544e-01f,
  2.11394532e-03f, -2.50387549e-01f, 2.75923401e-01f, -1.01698637e-01f, 1.51456341e-01f, -2.22885847e-01f, 2.68539518e-01f, -6.76041543e-02f, 3.00612718e-01f, -2.10618928e-01f,
  -1.74624305e-02f, 3.00950259e-02f, 1.10173598e-01f, -3.82107913e-01f, 2.22203121e-01f, -2.50491887e-01f, 2.07731761e-02f, 2.44649723e-01f, 3.98718089e-01f, -1.08908787e-01f,
  3.04518882e-02f, -5.02297655e-02f, 2.00994730e-01f, -3.62494111e-01f, -1.14617832e-01f, -4.50955808e-01f, -2.86475807e-01f, -1.98967785e-01f, -1.87594160e-01f, 3.72315198e-01f,
  -4.07076061e-01f, -5.23581803e-02f, 3.60644996e-01f, 1.25413507e-01f, 1.48109689e-01f, -1.87168811e-02f, 3.02965999e-01f, -1.55760929e-01f, -7.56935850e-02f, -1.72925279e-01f,
  -1.96867548e-02f, 9.40225422e-02f, -6.37487024e-02f, 7.18933120e-02f, -4.99155909e-01f, 6.43984452e-02f, -5.81101775e-02f, -7.59014711e-02f, -8.20734054e-02f, -1.07095018e-01f,
  9.83063951e-02f, 6.22148216e-02f, -1.67968586e-01f, -1.05713166e-01f, 1.83315635e-01f, -1.55396715e-01f, 8.60685185e-02f, -9.46662109e-03f, 1.15615726e-01f, -3.61144841e-02f,
  -1.70338422e-01f, 1.55845031e-01f, 9.60235074e-02f, -7.13835880e-02f, -1.63607076e-01f, 2.80486584e-01f, 2.88435929e-02f, 5.48929811e-01f, 2.18493432e-01f, 4.74701107e-01f,
  -1.10784816e-02f, 1.48331895e-01f, -4.20924485e-01f, -2.19187960e-01f, -4.91605699e-01f, -2.26152152e-01f, -2.85889059e-01f, 3.91327381e-01f, 1.49427215e-02f, -5.06102145e-02f,
  -9.12266001e-02f, -2.45890453e-01f, 3.91768254e-02f, -2.09051818e-01f, -2.03076541e-01f, 1.73634246e-01f, 6.49311766e-02f, -2.24553585e-01f, -2.32812297e-02f, 2.91183561e-01f,
  -2.65863985e-01f, -1.39175445e-01f, 1.95654109e-01f, 1.79644614e-01f, 2.34238952e-01f, 2.62632221e-01f, -1.06310546e-01f, -1.96668774e-01f, 3.82568270e-01f, 5.61296642e-02f,
  1.92136541e-01f, -3.72730605e-02f, 7.75965769e-03f, 4.16780353e-01f, 4.86741923e-02f, -1.24417670e-01f, 2.21869200e-01f, 2.59593070e-01f, 1.46010388e-02f, -7.99307004e-02f,
  -9.66260582e-02f, 1.43186510e-01f, 3.61215621e-01f, -1.82498902e-01f, -1.43622309e-01f, -1.41722500e-01f, -3.14442515e-01f, 8.79863799e-02f, 2.95498341e-01f, 4.40527469e-01f,
  1.68293908e-01f, 1.52341634e-01f, 1.50765136e-01f, -2.85531312e-01f, 1.94244727e-01f, -8.35721791e-02f, 2.93642849e-01f, 3.60334486e-01f, -1.19823635e-01f, 4.03837919e-01f,
  2.46903360e-01f, -3.03535946e-02f, -7.08403885e-02f, -1.67845786e-01f, 1.11594178e-01f, 2.70877779e-01f, 3.49849373e-01f, -1.91112161e-02f, 2.70685166e-01f, 3.61757219e-01f,
  -3.64887327e-01f, -2.48974070e-01f, 3.03176194e-01f, 3.69550794e-01f, -2.11366415e-01f, -1.56770798e-03f, -1.09957717e-01f, -2.82251328e-01f, -4.38786983e-01f, 3.39166969e-02f,
  4.00615871e-01f, -1.86370298e-01f, 6.85197935e-02f, -3.63657683e-01f, -4.12923992e-02f, -1.06091946e-02f, -9.24881399e-02f, 3.57864559e-01f, -2.55485147e-01f, -7.69147277e-02f,
  -3.37692261e-01f, -7.15551749e-02f, -3.44198823e-01f, -1.13090269e-01f, -2.70134419e-01f, 4.47017886e-02f, -1.05800532e-01f, 2.89397081e-03f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.60063580e-02f, -3.39324027e-02f, -1.05780520e-01f, 2.69465465e-02f, -1.12916892e-02f, 1.18457697e-01f, -3.43907326e-02f, 1.21477604e-01f, 6.77649379e-02f, -1.55533746e-01f,
  -1.19890273e-01f, 2.19542041e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    