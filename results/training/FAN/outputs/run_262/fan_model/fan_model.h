/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.30061853e-01f, 2.47481450e-01f, 1.30344018e-01f, 2.38587428e-03f, -4.20229277e-03f, 2.28140146e-01f, 6.63752109e-02f, 1.78365856e-01f, 2.67814666e-01f, 1.79871470e-01f,
  8.74941498e-02f, -1.20783672e-01f, 8.02688003e-02f, 8.63661617e-02f, -1.82749167e-01f, 1.87185124e-01f, 6.26377687e-02f, 3.31421904e-02f, 1.01072833e-01f, -7.76897818e-02f,
  -3.42148170e-02f, 9.34495591e-03f, -1.11486629e-01f, 1.93601206e-01f, -1.52190566e-01f, -7.65780732e-02f, -3.09719175e-01f, 1.30718183e-02f, -8.37391987e-02f, 5.03810644e-02f,
  -7.90554471e-03f, -5.56436107e-02f, -4.37953919e-02f, 8.37316290e-02f, -3.11857946e-02f, 2.80389171e-02f, -9.59809348e-02f, 2.28271410e-02f, 8.29066057e-03f, 6.93525299e-02f,
  -1.25409523e-02f, 3.31622735e-02f, 1.09656803e-01f, 8.61459449e-02f, 6.58020973e-02f, 5.68719208e-02f, 3.22060436e-02f, -2.27501560e-02f, -4.08205204e-02f, -2.36202171e-03f,
  6.16799369e-02f, -4.82948720e-02f, -2.42690295e-02f, -5.01350034e-03f, -4.22735214e-02f, 2.92168874e-02f, -5.83305536e-03f, -8.63203332e-02f, -3.73662487e-02f, 6.34297505e-02f,
  1.60743240e-02f, 3.53206322e-03f, 6.27259351e-03f, 9.12486855e-03f, 3.62911262e-02f, 1.82387559e-03f, -4.53568846e-02f, 3.31779779e-03f, 1.12034113e-03f, -1.83246080e-02f,
  1.24240736e-03f, 2.26602014e-02f, 1.18982540e-02f, 1.55014908e-02f, -2.03295657e-03f, -1.30459350e-02f, -3.51128951e-02f, -2.15457268e-02f, 5.40828742e-02f, -2.69931052e-02f,
  3.56477909e-02f, -1.26636038e-02f, 2.30326653e-02f, -1.89534277e-02f, 2.28138361e-02f, -2.18348652e-02f, 6.51871320e-03f, 5.53295156e-03f, 2.50766221e-02f, -5.82018681e-02f,
  -1.67754441e-01f, -1.89988300e-01f, 7.10840970e-02f, -6.36062399e-02f, 1.46409366e-02f, 5.51618682e-03f, -1.57923084e-02f, 3.88829666e-03f, 1.22089749e-02f, -3.23811024e-02f,
  -3.78118120e-02f, -2.57515945e-02f, -1.03183426e-01f, -9.23507567e-03f, -2.00172402e-02f, 2.53231190e-02f, -9.73165929e-02f, 1.38549106e-02f, -6.54530376e-02f, -5.53315133e-02f,
  -8.86400044e-02f, 9.72158276e-04f, 7.75112631e-03f, -2.60713790e-02f, 1.55929886e-02f, -5.53399138e-02f, -5.70419505e-02f, 6.24022596e-02f, -1.27262445e-02f, -3.93722430e-02f,
  1.67755067e-01f, 1.41139597e-01f, 2.33521927e-02f, 3.96940708e-01f, -4.35659811e-02f, -2.86984281e-03f, 8.88948888e-02f, 2.45544478e-01f, 2.27631666e-02f, 1.64562523e-01f,
  3.61519977e-02f, -1.95675250e-02f, -2.13431008e-02f, 2.23005921e-01f, -2.29725137e-01f, -9.46363062e-02f, 2.04437450e-01f, 8.10601637e-02f, -4.73117307e-02f, 1.56617358e-01f,
  -2.14886125e-02f, 7.11961463e-02f, 4.77424338e-02f, 1.09779470e-01f, 1.02267891e-01f, 5.39446212e-02f, 2.73106731e-02f, -5.75022958e-02f, 7.70860836e-02f, -3.57978344e-02f,
  -7.59570450e-02f, 2.37232774e-01f, 6.92003444e-02f, -1.43002709e-02f, 3.54849286e-02f, 3.78111824e-02f, -4.56641689e-02f, -1.17492735e-01f, 2.77398387e-03f, 5.14815077e-02f,
  -8.23909864e-02f, 4.73570358e-03f, 2.76846290e-02f, -4.82280478e-02f, -2.33725570e-02f, 3.69657688e-02f, 1.08979773e-02f, 5.30113420e-03f, 1.67327076e-02f, 4.84657893e-03f,
  -3.36353071e-02f, 6.46860823e-02f, 1.49027538e-02f, -7.76757067e-03f, 9.00479779e-03f, 4.31871042e-02f, -4.42096256e-02f, -6.82271123e-02f, 1.07013602e-02f, 4.80143949e-02f,
  1.43080251e-02f, -1.59307905e-02f, -2.70976145e-02f, 2.12753899e-02f, -6.19747071e-03f, 2.28157192e-02f, -9.53674037e-03f, -3.59984115e-02f, 1.61775108e-02f, 5.06942719e-03f,
  8.35812017e-02f, -4.68614995e-02f, 3.08554545e-02f, -1.34325901e-03f, 2.62756832e-02f, 3.38985994e-02f, -4.35185991e-02f, 4.17780913e-02f, -2.32023783e-02f, 7.98767060e-03f,
  3.77400443e-02f, -4.70012054e-02f, 3.92630883e-03f, 5.01399674e-03f, 6.57116808e-03f, -2.51910035e-02f, 1.78739266e-03f, -2.93862503e-02f, 1.66069102e-02f, -1.07097290e-02f,
  9.08933654e-02f, 3.58417332e-01f, 1.57490149e-02f, -1.37642482e-02f, -1.15970448e-02f, -1.91189889e-02f, -5.35046682e-03f, -3.24053057e-02f, -7.00697117e-03f, 6.24087676e-02f,
  4.14450578e-02f, -4.29966301e-02f, -3.94251756e-02f, -2.39642290e-03f, -5.22282440e-03f, -4.26267385e-02f, 6.25362108e-03f, -1.77328009e-02f, 5.24511039e-02f, -7.81185627e-02f,
  6.46964982e-02f, -4.39855922e-03f, -1.97074693e-02f, 5.12517430e-02f, 2.86153741e-02f, -1.00321788e-02f, 3.09681613e-02f, 1.31319668e-02f, 3.46833318e-02f, -5.62551850e-03f,
  9.13421437e-02f, 6.11613542e-02f, 1.73099101e-01f, 1.83272779e-01f, -1.81933999e-01f, -3.39676142e-02f, -2.98820678e-02f, -6.34265617e-02f, -4.04397398e-02f, -7.29075745e-02f,
  -1.09234387e-02f, 1.48120478e-01f, 1.33031517e-01f, -2.26632524e-02f, 3.55142742e-01f, 8.75771269e-02f, 2.70562395e-02f, -5.12898639e-02f, -1.20872706e-02f, -1.84288807e-02f,
  -2.68054381e-02f, -1.20728113e-01f, 1.55547038e-01f, -1.66579679e-01f, -7.10338056e-02f, -6.20354898e-02f, 4.12078388e-02f, -1.70465969e-02f, 2.78952178e-02f, -5.57987578e-02f,
  -2.86148190e-02f, -2.17263810e-02f, -1.50309149e-02f, 1.77508965e-02f, -4.39652801e-02f, -1.07054338e-02f, 4.72176969e-02f, 1.01076970e-02f, 1.16130970e-01f, 2.45423783e-02f,
  -8.29991847e-02f, 6.85693920e-02f, -5.16130105e-02f, -1.59456916e-02f, -6.26928359e-02f, 3.14877764e-03f, -9.01900697e-03f, -1.13529880e-02f, 1.73932165e-02f, 3.89533751e-02f,
  3.82442549e-02f, -4.80109081e-03f, -5.80421612e-02f, -6.61402242e-03f, 3.50232758e-02f, 3.28241549e-02f, 3.07176933e-02f, 2.23356206e-02f, -5.97483963e-02f, -4.31170352e-02f,
  -3.76656018e-02f, -1.42889074e-03f, 4.32033502e-02f, 6.79412065e-03f, 1.57216862e-02f, 3.52840386e-02f, 3.33114490e-02f, -1.17530040e-02f, -3.15682404e-03f, -3.58213298e-03f,
  5.51862717e-02f, 4.36966866e-02f, -2.87122559e-02f, 2.55595427e-02f, -6.93363138e-04f, -2.22144295e-02f, 1.98831465e-02f, -2.50186324e-02f, 1.36564802e-02f, 3.26925516e-02f,
  2.28062877e-03f, 3.61504592e-02f, 4.05659936e-02f, -3.40827717e-03f, 2.01654509e-02f, -7.89961591e-03f, 6.29948499e-03f, 1.32682472e-02f, 3.18664983e-02f, 4.74424334e-03f,
  -7.25953579e-02f, -8.58764499e-02f, 6.85226247e-02f, -4.53468449e-02f, -1.86486933e-02f, 5.28932512e-02f, -6.46881238e-02f, 1.54206762e-03f, -4.94215414e-02f, -1.32711530e-02f,
  -6.16085576e-03f, -3.26596834e-02f, -1.02845863e-01f, 2.84347627e-02f, 3.78147438e-02f, -2.62274630e-02f, 4.84973751e-02f, 1.99066345e-02f, 2.06180819e-04f, 6.53365254e-03f,
  4.23039086e-02f, -1.72212441e-03f, 3.83322611e-02f, -4.19292264e-02f, -7.96756241e-03f, 6.82298094e-03f, -5.27344681e-02f, -1.18214516e-02f, -2.37702131e-02f, -1.98007859e-02f,
  9.43609998e-02f, -1.54859439e-01f, -4.11485791e-01f, 2.60904934e-02f, 1.78997204e-01f, -1.56910151e-01f, -2.01481402e-01f, 1.78698882e-01f, -1.09254858e-02f, 1.04638077e-01f,
  5.82116432e-02f, -2.61619538e-01f, -9.63712260e-02f, -1.15272149e-01f, -2.36260891e-01f, -2.40920186e-01f, -6.02693371e-02f, -8.22364986e-02f, -8.31081569e-02f, 6.27520457e-02f,
  -2.58885864e-02f, 1.18576273e-01f, -1.62311643e-01f, 1.61830544e-01f, 4.39894460e-02f, 6.33739755e-02f, 1.80216774e-01f, -6.22335225e-02f, 1.30249232e-01f, -1.11475468e-01f,
  2.71279290e-02f, 2.55028363e-02f, -3.62924449e-02f, -5.99007942e-02f, 4.26167585e-02f, 1.59945916e-02f, 1.93374455e-02f, -8.02703276e-02f, 5.05704246e-02f, 1.09631736e-04f,
  -6.28109872e-02f, -1.11153815e-02f, 3.32157165e-02f, -3.57848331e-02f, -1.09919747e-02f, -3.85434330e-02f, -1.94729436e-02f, -3.76187526e-02f, -3.54426168e-02f, -6.38935640e-02f,
  -3.97438109e-02f, -7.59955719e-02f, -9.03115645e-02f, -3.14241126e-02f, -8.17137305e-03f, -1.47645585e-02f, -1.34853879e-02f, -7.24255443e-02f, 6.13443665e-02f, -1.23495981e-02f,
  -1.07651728e-03f, -2.52883956e-02f, -2.76285633e-02f, 6.95401132e-02f, -3.22766490e-02f, 1.02502793e-01f, -7.03936517e-02f, 4.72584553e-02f, 2.60344297e-02f, 2.84271110e-02f,
  5.26242293e-02f, 1.83486845e-02f, 5.17858379e-02f, 2.77916677e-02f, 2.75117494e-02f, 2.46703960e-02f, -1.83930136e-02f, 1.79632660e-02f, 1.86661053e-02f, 8.40974078e-02f,
  -2.04843618e-02f, 4.98432294e-02f, -4.06340286e-02f, 3.27091441e-02f, -1.14386277e-02f, -1.85837783e-02f, 1.38372239e-02f, -8.33296329e-02f, 8.32914934e-03f, -1.46397538e-02f,
  8.69107023e-02f, 1.68775886e-01f, 6.77899420e-02f, 1.42879291e-02f, 3.42937000e-02f, 4.18768525e-02f, -8.37682411e-02f, 4.93274294e-02f, -9.33126267e-03f, 1.84051525e-02f,
  4.23906483e-02f, 4.08440195e-02f, 6.56158701e-02f, -1.51222544e-02f, -3.03404536e-02f, 8.07649642e-03f, 2.79500969e-02f, 5.14273010e-02f, 8.20846558e-02f, 4.89074960e-02f,
  6.67534992e-02f, 3.19104530e-02f, -8.22762260e-04f, 4.66966666e-02f, 6.06665425e-02f, -2.55887918e-02f, 5.50479768e-03f, -3.46078887e-04f, 6.12608902e-02f, -9.82053112e-03f,
  1.28233254e-01f, -5.75520359e-02f, 2.38677859e-01f, -1.11034391e-02f, 2.57308818e-02f, -8.97133797e-02f, -5.94629981e-02f, -1.19643053e-02f, 2.33716622e-01f, -2.51145184e-01f,
  -2.15438813e-01f, 2.06154183e-01f, -6.50371388e-02f, -3.04064631e-01f, 2.75210142e-01f, 9.93369520e-02f, -1.86229855e-01f, -8.58212709e-02f, 4.81003635e-02f, -8.48095492e-02f,
  8.74637216e-02f, -2.93749452e-01f, 3.83464694e-02f, -6.58701956e-02f, -8.63991007e-02f, 2.28948481e-02f, -1.50673047e-01f, 3.10801454e-02f, -2.15084925e-01f, -3.19813075e-03f,
  -1.82390168e-01f, 1.59775894e-02f, 5.09282500e-02f, 1.19471792e-02f, -3.68282124e-02f, -8.98891035e-03f, -9.68700275e-02f, -3.07323989e-02f, 4.89849113e-02f, 6.21438306e-03f,
  -2.06355727e-03f, -1.03753256e-02f, 3.48066129e-02f, 3.05509400e-02f, -3.51798162e-02f, 1.99209023e-02f, 8.00417960e-02f, -2.53723469e-02f, 2.61848699e-02f, 7.13547468e-02f,
  7.48389959e-02f, 3.56006473e-02f, -3.20980474e-02f, -6.31388277e-04f, 7.91819617e-02f, 1.74768013e-03f, 6.90176894e-05f, 9.24006104e-03f, -2.73902435e-02f, 2.43388172e-02f,
  1.42278984e-01f, 2.34780125e-02f, -6.72424510e-02f, -3.13642956e-02f, -2.64939684e-02f, -6.97616301e-03f, -6.74317479e-02f, -1.46910036e-02f, -4.14907038e-02f, -3.50535437e-02f,
  -5.22644781e-02f, -1.97911449e-02f, -2.14045681e-03f, 3.14924531e-02f, 2.48526270e-03f, -1.70566998e-02f, -1.70116983e-02f, -5.01989610e-02f, 2.47971863e-02f, 6.78648129e-02f,
  -3.25184129e-02f, -1.11762639e-02f, -2.52409279e-02f, -5.05902506e-02f, -4.96330252e-03f, 3.04881744e-02f, -4.31787521e-02f, 1.48171140e-02f, -7.37548992e-03f, 7.87372701e-03f,
  -2.45406911e-01f, -4.91137095e-02f, 3.46996618e-04f, -2.23083477e-02f, 2.52676453e-03f, -1.01106837e-02f, 1.38190184e-02f, 6.14723898e-02f, 1.19004212e-03f, 3.26655954e-02f,
  -1.90498009e-02f, -2.68218238e-02f, -5.62754385e-02f, -2.65790932e-02f, 1.65109690e-02f, -1.82451420e-02f, -1.07384726e-01f, -5.55730518e-03f, -2.39684768e-02f, -8.34865794e-02f,
  -9.17564407e-02f, -4.04633395e-02f, 6.32070526e-02f, 1.32687632e-02f, -2.09894460e-02f, -2.15626191e-02f, 6.28619269e-02f, 6.17650934e-02f, 3.03268358e-02f, 6.19126111e-02f,
  1.10686772e-01f, 5.28272808e-01f, -3.00116301e-01f, 1.00686014e-01f, -3.02450478e-01f, 1.20275058e-02f, 1.12336306e-02f, 1.09666623e-02f, 1.29480772e-02f, 2.64317334e-01f,
  6.17159270e-02f, 6.52652904e-02f, 1.22848034e-01f, 1.95542857e-01f, -3.94037478e-02f, 2.06377834e-01f, 1.05409369e-01f, 1.01725578e-01f, -3.09860869e-03f, 2.41424912e-03f,
  -8.89411420e-02f, 1.91556945e-01f, -1.82174996e-01f, -1.15045079e-03f, -1.80875644e-01f, -1.15268260e-01f, -7.94394594e-03f, -9.50956196e-02f, -4.34572995e-02f, 9.04245395e-03f,
  -1.05632968e-01f, 7.43660554e-02f, -3.51808146e-02f, 3.23902145e-02f, -6.22033775e-02f, -4.93394956e-02f, 1.76588586e-03f, -4.46025766e-02f, -4.08334844e-02f, 2.41434220e-02f,
  4.33224887e-02f, -4.36788052e-02f, 6.35467768e-02f, -3.83931175e-02f, -9.26117506e-03f, -5.43030500e-02f, -7.57568032e-02f, -8.08283016e-02f, -7.62296319e-02f, -8.67538080e-02f,
  -1.10756062e-01f, -8.33226144e-02f, -1.45259388e-02f, 2.21161265e-02f, -8.89337957e-02f, -2.73381416e-02f, -4.04186174e-02f, -2.44286116e-02f, -2.53468356e-03f, -5.45274913e-02f,
  1.37548849e-01f, -2.19250768e-02f, 1.71540957e-02f, -2.91995015e-02f, -6.00604247e-03f, -7.74499476e-02f, 1.39699075e-02f, 1.18815619e-02f, 8.90976575e-04f, 1.55635541e-02f,
  -5.24173258e-03f, 1.46797895e-02f, 1.52265336e-02f, 1.85309432e-03f, -3.36593576e-03f, 1.42015172e-02f, -1.59655083e-02f, 2.55919714e-02f, -2.24048104e-02f, -2.52208654e-02f,
  4.13432159e-02f, 3.64921615e-02f, 1.72969922e-02f, -9.23886150e-02f, 2.08090802e-04f, -3.32763721e-03f, 1.72571167e-02f, -1.85080133e-02f, -5.28371185e-02f, -1.48713337e-02f,
  2.38836318e-01f, 3.79468352e-01f, 5.59140444e-02f, -1.33993281e-02f, 4.15111780e-02f, 1.81225948e-02f, 5.41519374e-02f, 4.29581366e-02f, 1.16120964e-01f, -6.17337832e-03f,
  -4.95705381e-02f, -4.91358992e-03f, -1.47091560e-02f, 1.26991142e-03f, 7.12549835e-02f, 3.39701287e-02f, 1.72762806e-03f, 1.10050872e-01f, 8.26447755e-02f, -9.36492905e-03f,
  -2.47849748e-02f, 2.31465343e-02f, -1.96057055e-02f, -6.32767305e-02f, 2.13476233e-02f, -6.31189346e-02f, 2.18704324e-02f, -1.76644307e-02f, -5.68771735e-02f, 5.80763221e-02f,
  7.98753649e-02f, -3.45079064e-01f, -5.72318025e-02f, -4.88771610e-02f, 3.93932834e-02f, 4.04868513e-01f, 1.11143969e-01f, 2.46451795e-03f, 1.47192553e-01f, -1.92320436e-01f,
  5.02328575e-02f, -1.89270198e-01f, 1.70417931e-02f, 1.95128042e-02f, 4.06152010e-01f, 1.97701946e-01f, 1.25293553e-01f, -3.26672383e-02f, 8.54680911e-02f, -1.27033845e-01f,
  5.88869154e-02f, -4.46378812e-03f, 4.76069236e-03f, -1.20101959e-01f, -7.60380700e-02f, -1.30532622e-01f, -1.27636462e-01f, -8.27357545e-02f, -1.99187309e-01f, 3.44350189e-02f,
  1.06107287e-01f, -3.08713689e-02f, -1.31411299e-01f, -6.87002391e-02f, 8.39415565e-03f, -2.11962853e-02f, -2.88132746e-02f, 4.54457626e-02f, 4.12190631e-02f, -3.05056851e-03f,
  7.92145822e-03f, 2.01602839e-02f, 3.72919552e-02f, 9.04985517e-03f, -1.39464904e-02f, -4.00469862e-02f, -5.68802655e-03f, 3.06856781e-02f, -5.98264001e-02f, -1.20363981e-02f,
  -2.62315627e-02f, -4.21959069e-03f, -2.59141028e-02f, -9.87604610e-04f, 1.22760748e-02f, -1.00232447e-02f, 4.43248153e-02f, 2.25926028e-03f, -5.05015999e-02f, 7.14524463e-02f,
  5.60896322e-02f, -5.97777404e-03f, -3.30217704e-02f, -3.60716246e-02f, -1.99627932e-02f, 1.73450522e-02f, -5.13502397e-02f, 1.71953440e-02f, 1.63263716e-02f, -9.70316119e-03f,
  -5.71658183e-03f, -3.23366225e-02f, 2.47834492e-02f, 6.52348436e-03f, 1.72436740e-02f, -2.41950061e-02f, 6.05365168e-03f, -4.88313958e-02f, 1.83808822e-02f, 5.95181296e-03f,
  -2.32411791e-02f, -8.28047190e-03f, -5.16859964e-02f, 3.36527936e-02f, -7.09821284e-03f, -3.55331664e-04f, 3.94230359e-04f, -9.92046110e-03f, -2.00792328e-02f, 1.49944080e-02f,
  9.63049680e-02f, -8.00358597e-03f, -5.74821271e-02f, -9.68609750e-03f, 2.56065708e-02f, 2.74020294e-03f, 7.06705078e-02f, 3.04437019e-02f, -4.37614694e-02f, 3.88148390e-02f,
  -6.41068593e-02f, -4.69329096e-02f, 2.87290439e-02f, -1.51389530e-02f, 1.38134109e-02f, -1.31374281e-02f, -5.06874174e-02f, -3.83007787e-02f, -3.47859663e-04f, -2.28031110e-02f,
  -1.41445911e-02f, -8.60687625e-03f, 5.98144196e-02f, -3.27949189e-02f, 8.82595312e-03f, 2.56709545e-03f, -4.88258302e-02f, 1.76391359e-02f, 9.89485830e-02f, -9.28679202e-03f,
  -3.14064324e-01f, -3.07423323e-02f, -1.14010789e-01f, -1.73408806e-01f, -2.78244674e-01f, -6.33304492e-02f, -1.21766806e-01f, -8.99998397e-02f, -2.89425254e-01f, 1.28781423e-01f,
  8.48013982e-02f, -8.26252252e-02f, 2.58433163e-01f, 6.10204339e-02f, 4.73314710e-02f, 2.44646028e-01f, -1.14721626e-01f, -4.29972373e-02f, -9.04588103e-02f, -5.60774952e-02f,
  -4.20051776e-02f, 7.95473158e-02f, 1.62397578e-01f, 9.42925960e-02f, -9.31963995e-02f, -1.18489571e-01f, 6.39412031e-02f, 2.52349749e-02f, 4.51506004e-02f, 1.31631941e-02f,
  1.18577974e-02f, 6.08869549e-03f, -2.45973859e-02f, 1.14003355e-02f, -1.05574261e-02f, -3.29110213e-02f, -2.93556484e-03f, 3.19594592e-02f, -7.24416552e-03f, -9.32923891e-03f,
  -3.03594079e-02f, 3.95542793e-02f, 3.56084369e-02f, -2.85773613e-02f, -9.08903405e-02f, -3.91517617e-02f, -9.50320624e-03f, -5.11971079e-02f, 1.67745091e-02f, 3.97535749e-02f,
  -3.72254774e-02f, 1.42199919e-02f, -5.13960347e-02f, -2.50432249e-02f, -1.15026608e-02f, -2.66747158e-02f, 3.05933558e-04f, -4.74754274e-02f, -5.38633466e-02f, -5.12501672e-02f,
  1.67319998e-02f, -2.35845260e-02f, -4.57893033e-03f, 3.21463905e-02f, -1.60144120e-02f, 1.25433169e-02f, 3.20499912e-02f, 5.86894192e-02f, -4.80458215e-02f, 2.45076983e-04f,
  -3.72162610e-02f, -3.72599140e-02f, 1.99806597e-03f, -4.28563021e-02f, 2.10622675e-03f, -2.02261303e-02f, 6.42290898e-03f, 1.68426447e-02f, -7.18514249e-02f, 2.29631849e-02f,
  -8.03814456e-03f, -2.35802587e-02f, 3.52950394e-02f, 1.74940825e-02f, 8.47122725e-03f, -5.05327759e-03f, -1.33822728e-02f, -9.28123575e-03f, 2.56520556e-03f, -7.78224273e-03f,
  1.51381539e-02f, -5.37365749e-02f, 8.78019910e-03f, -3.58020030e-02f, 6.14748895e-03f, -1.97145343e-02f, 2.05721296e-02f, -9.41513106e-02f, 2.46751448e-03f, -1.57336798e-02f,
  -2.69470308e-02f, -5.86120524e-02f, -5.32880388e-02f, 4.50859293e-02f, -2.21430440e-03f, 4.00231518e-02f, 4.18797247e-02f, -6.01962693e-02f, -1.19349910e-02f, -8.16193875e-03f,
  3.29205468e-02f, -3.74383815e-02f, -1.91059764e-02f, -2.56389678e-02f, 7.54465000e-04f, 2.84549128e-02f, -7.20782652e-02f, -2.16471609e-02f, 5.95917255e-02f, 1.20107224e-02f,
  -2.58725346e-03f, -3.30621839e-01f, -1.35156559e-02f, -2.41248548e-01f, -1.33100441e-02f, 5.06914547e-03f, -1.11019693e-01f, -1.36870816e-01f, -1.71768337e-01f, -1.72657326e-01f,
  2.56221183e-02f, -1.86618082e-02f, -2.77285408e-02f, -1.18728556e-01f, 3.87753963e-01f, -7.08975047e-02f, -2.89717000e-02f, -4.71785963e-02f, -8.20135102e-02f, -1.28811225e-01f,
  -4.25146110e-02f, -1.38398275e-01f, 3.79480682e-02f, -1.86831318e-02f, -1.49665043e-01f, -1.37020871e-01f, 9.15136337e-02f, 4.87711467e-02f, 4.71049827e-03f, 1.13685995e-01f,
  -2.79514417e-02f, -1.47432223e-01f, -6.29560137e-03f, 4.47103903e-02f, 3.10688559e-02f, 3.76528017e-02f, 3.49175483e-02f, 5.63506261e-02f, -1.37506966e-02f, -3.51438932e-02f,
  1.66377053e-02f, -2.60935016e-02f, 1.49739897e-02f, -3.56845781e-02f, -6.48588389e-02f, 1.41949553e-04f, 4.87738401e-02f, -4.08816934e-02f, -8.32818225e-02f, -1.16166696e-02f,
  2.00875029e-02f, 4.41741087e-02f, -6.38579205e-02f, -1.36930440e-02f, -1.91396456e-02f, -1.06375245e-02f, -1.12154819e-01f, -3.33588477e-03f, 3.44552653e-04f, -6.09589331e-02f,
  2.65399646e-02f, -2.48965137e-02f, 5.78414230e-03f, 2.78289616e-02f, -3.79257165e-02f, -1.16125392e-02f, -5.40557764e-02f, 9.54129733e-03f, -2.16900036e-02f, -3.28953331e-03f,
  -9.10974946e-03f, -1.62549168e-02f, -5.09055443e-02f, -3.04411072e-02f, -4.13566716e-02f, -3.70529927e-02f, 4.97099198e-02f, -1.44618573e-02f, -1.01451660e-02f, -3.33299078e-02f,
  -4.77172434e-04f, -2.91107856e-02f, -1.09387347e-02f, -3.73114310e-02f, 2.83877235e-02f, -2.14052368e-02f, -2.35466845e-02f, -2.11665407e-02f, 2.49140691e-02f, -2.32628491e-02f,
  -1.10355113e-02f, 6.72200620e-02f, 6.98815053e-03f, -4.14428711e-02f, 3.35197076e-02f, 4.38525081e-02f, 3.71278934e-02f, -1.36620523e-02f, 5.90933934e-02f, 6.43376037e-02f,
  5.17029082e-03f, -2.69811209e-02f, -2.49059275e-02f, 9.64081287e-03f, 4.23019603e-02f, 1.39244525e-02f, -7.22459108e-02f, 3.31531130e-02f, 5.23959957e-02f, 1.78173408e-02f,
  -4.10984121e-02f, -4.52962425e-03f, 2.63159499e-02f, -4.97360714e-02f, -3.72679415e-03f, 3.32377441e-02f, -1.43214706e-02f, -2.11022864e-03f, 8.26109201e-02f, 4.82806154e-02f,
  2.62842089e-01f, -1.71932474e-01f, 3.05339843e-01f, -1.46510988e-01f, 1.47851557e-02f, -4.49869841e-01f, -2.07750008e-01f, 8.27608258e-02f, 3.26916091e-02f, -1.81733847e-01f,
  1.38070231e-04f, 8.54758322e-02f, 8.44485238e-02f, -3.21559697e-01f, -6.16199598e-02f, -2.28540286e-01f, -3.18512082e-01f, -9.32419226e-02f, -5.42330928e-02f, 5.00248075e-02f,
  -6.72671720e-02f, -1.51347607e-01f, -7.45574161e-02f, -5.90614304e-02f, -1.02739101e-02f, 1.12741984e-01f, 9.29734632e-02f, 1.36392042e-01f, -6.85166270e-02f, -2.24738736e-02f,
  -4.67227679e-03f, 2.63749212e-01f, 4.12479267e-02f, 4.36114408e-02f, 6.03619888e-02f, 2.30216961e-02f, -3.65446173e-02f, 5.91173582e-02f, 3.75168771e-02f, -2.77140690e-03f,
  2.03526225e-02f, 3.32819019e-03f, 2.95221284e-02f, -1.31060295e-02f, 8.50087218e-03f, 7.08684698e-02f, 1.88615033e-03f, -7.17084259e-02f, -5.62999723e-03f, -3.22509743e-02f,
  -4.72302102e-02f, -8.30550343e-02f, -3.95637425e-03f, -1.50100626e-02f, 4.27300557e-02f, -5.25990836e-02f, -3.47841568e-02f, 1.59833729e-02f, -2.13200301e-02f, -5.56732230e-02f,
  4.44681244e-03f, 7.05144629e-02f, -3.94001883e-03f, -1.12167411e-02f, 5.77284619e-02f, 5.16510792e-02f, -4.59371917e-02f, 4.37651463e-02f, 8.45206454e-02f, -3.69659662e-02f,
  -4.41755392e-02f, 5.22470614e-03f, 3.93949188e-02f, -4.28856984e-02f, -1.33911818e-02f, -2.07553115e-02f, 6.42311620e-03f, -1.32233778e-03f, -4.37203310e-02f, -2.05295533e-02f,
  -9.05687455e-03f, -1.54609261e-02f, 2.31727250e-02f, -6.36858344e-02f, 1.93663165e-02f, 1.16150430e-03f, -2.12023733e-03f, 1.78286980e-03f, 3.42558660e-02f, 1.46237900e-02f,
  -1.05878171e-02f, 2.07631290e-01f, 3.24454680e-02f, -1.44563746e-02f, -1.83791090e-02f, -8.46529379e-02f, -1.13830324e-02f, -6.50737062e-03f, -3.59383551e-03f, 1.91121525e-03f,
  -4.19064574e-02f, 2.37533357e-02f, 4.36868407e-02f, 3.74171659e-02f, -3.82062257e-03f, -6.58340603e-02f, -1.36967376e-02f, -1.71055254e-02f, -8.80217645e-03f, 2.17719097e-02f,
  2.00333148e-02f, 2.29078606e-02f, -2.64450777e-02f, -1.42842010e-02f, -2.76653236e-03f, 8.18026159e-03f, 4.78027724e-02f, -5.48506416e-02f, 4.80252616e-02f, -1.68291759e-02f,
  -4.00560796e-01f, 5.23483306e-02f, -7.47123957e-02f, -1.77788213e-01f, -1.19777054e-01f, -2.51503766e-01f, -2.22977996e-01f, -1.04069859e-01f, -1.27238557e-01f, 7.45733008e-02f,
  -3.60230682e-03f, -5.47530763e-02f, 3.54623571e-02f, -1.79259136e-01f, -2.02596232e-01f, 5.23247048e-02f, -5.58391251e-02f, 3.41685936e-02f, -5.92088476e-02f, -1.24035344e-01f,
  -9.89624336e-02f, -1.56191081e-01f, -7.12384507e-02f, 8.19612145e-02f, -1.42000824e-01f, 7.93532580e-02f, 2.13949591e-01f, 1.20285936e-02f, 1.17140532e-01f, -8.72560441e-02f,
  -8.11601728e-02f, -6.53444789e-03f, -7.70796835e-02f, -3.44509855e-02f, -9.25280992e-03f, 2.26862039e-02f, -4.20348272e-02f, -4.06038612e-02f, -3.90268192e-02f, -3.76400426e-02f,
  -5.46499752e-02f, -2.76313331e-02f, -5.24083748e-02f, -6.55146390e-02f, -6.32006228e-02f, -9.25937016e-03f, -1.06233791e-01f, 3.20226364e-02f, 4.89235716e-03f, -1.12626217e-01f,
  -7.66399652e-02f, 2.74647996e-02f, 1.84588917e-02f, 5.57565354e-02f, 4.95000593e-02f, -3.62170376e-02f, 4.13538739e-02f, 5.29001690e-02f, -3.04915365e-02f, 5.41474074e-02f,
  5.92368431e-02f, 3.76554802e-02f, 1.64934359e-02f, -4.59687710e-02f, -2.53402181e-02f, -8.59600119e-03f, 1.35323629e-02f, -4.59963363e-03f, -1.04718162e-02f, 2.01732647e-02f,
  -2.63490714e-02f, -3.95962335e-02f, -4.79051732e-02f, -4.46446538e-02f, 3.65793006e-03f, 4.25180013e-04f, 4.13217358e-02f, -1.58011727e-02f, 3.20471413e-02f, -3.87206674e-02f,
  1.55675253e-02f, -1.33575946e-02f, 1.74158551e-02f, 8.47838372e-02f, 1.07923718e-02f, -1.33435577e-02f, 1.12874173e-02f, 1.25182588e-02f, 4.49779890e-02f, 2.21919473e-02f,
  6.04761019e-02f, 1.76760271e-01f, 2.63524465e-02f, -6.42169639e-02f, 1.02788039e-01f, 5.44295385e-02f, 2.44966801e-02f, 2.66097970e-02f, 2.35379674e-02f, 5.08595258e-03f,
  4.13221903e-02f, 2.76017878e-02f, 4.25113775e-02f, 1.10570388e-02f, 5.58650959e-03f, -2.91129481e-02f, 5.39548695e-02f, 1.24903815e-02f, -9.40595195e-03f, 5.80450594e-02f,
  5.20474426e-02f, 6.61817659e-03f, -3.60657424e-02f, 2.73377728e-02f, 1.55780762e-02f, 5.96669354e-02f, -4.07967195e-02f, 3.49527448e-02f, 5.29161766e-02f, 1.42954234e-02f,
  -5.36194265e-01f, -3.45314145e-02f, 3.65509391e-02f, -2.85275728e-01f, 5.32204621e-02f, -7.03412220e-02f, -2.87040889e-01f, 1.04263134e-01f, -3.02263677e-01f, 4.60863374e-02f,
  -6.40794858e-02f, 1.14078531e-02f, 1.25483489e-02f, -1.57417968e-01f, -1.82215720e-01f, -2.16734111e-02f, -3.21164310e-01f, -7.70139471e-02f, -3.85857150e-02f, -1.35435984e-01f,
  -1.26125077e-02f, -1.49770051e-01f, 1.74711317e-01f, 1.38111472e-01f, -5.59004880e-02f, 6.00652285e-02f, 9.31059495e-02f, 1.61378235e-01f, -1.75073110e-02f, -1.43785644e-02f,
  -5.44509478e-02f, -4.98845130e-02f, 5.70939109e-02f, 1.96502209e-02f, -6.69608116e-02f, -9.98643460e-04f, 1.06077269e-03f, 5.54523664e-03f, -1.71701163e-02f, -1.91149116e-02f,
  3.31309512e-02f, 2.52714586e-02f, -7.69299939e-02f, 2.99994443e-02f, 4.15155664e-02f, 2.93882843e-02f, 5.50967082e-02f, 2.48345174e-02f, 3.16389017e-02f, 7.52277896e-02f,
  3.58681120e-02f, 5.58386743e-02f, 2.58709919e-02f, 1.42156407e-02f, 2.27657147e-02f, -1.20382477e-02f, 4.29990441e-02f, 3.63594517e-02f, -8.35922509e-02f, -1.97486524e-02f,
  -2.47626621e-02f, -2.76233330e-02f, 5.16193584e-02f, 7.45690241e-03f, -5.09511121e-02f, 1.75377838e-02f, -2.38449760e-02f, -6.62807422e-03f, -3.73664722e-02f, 1.34087047e-02f,
  -1.77077968e-02f, 3.80529463e-02f, 8.05650558e-03f, 6.05460722e-04f, -1.74655672e-02f, -4.16352004e-02f, -1.32715330e-02f, 1.56676937e-02f, -3.14846598e-02f, -6.64902665e-03f,
  6.00557600e-04f, -3.16200964e-02f, 7.96763413e-03f, -1.68771707e-02f, -3.47131044e-02f, 4.10204157e-02f, 3.62458527e-02f, 5.38319871e-02f, -6.08686544e-02f, -1.22148739e-02f,
  -1.62497297e-01f, -8.65461826e-02f, -2.93497816e-02f, 4.90111895e-02f, -5.39489351e-02f, 1.87780317e-02f, -8.78536887e-03f, 1.18547948e-02f, -5.73446639e-02f, -3.67825516e-02f,
  4.01089899e-03f, 6.43861946e-03f, -1.77844167e-02f, -4.56938073e-02f, -6.04744814e-03f, -3.91762108e-02f, -4.88405675e-02f, -2.37208474e-02f, -3.18912826e-02f, -1.49522144e-02f,
  2.40794756e-02f, -4.52735014e-02f, 1.90359037e-02f, -3.13806813e-03f, -2.80972086e-02f, 2.36211028e-02f, -6.06237166e-02f, -3.67753953e-02f, 2.61838622e-02f, -3.26379039e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.29918149e-02f, -1.08945459e-01f, 1.73413023e-01f, -8.66123289e-02f, -2.73418371e-02f, 9.08203889e-03f, 1.73066616e-01f, -1.70254871e-01f, -2.51265377e-01f, -8.32272172e-02f,
  1.31362826e-01f, 2.16373622e-01f, 9.67367440e-02f, -1.10846303e-01f, -2.29849488e-01f, -2.26687178e-01f, -1.75182357e-01f, -4.80191633e-02f, -8.02101195e-02f, 1.78463645e-02f,
  -8.58240947e-02f, -1.76229894e-01f, 3.13869491e-02f, -1.46506697e-01f, 1.47152215e-01f, 1.11358739e-01f, -2.67528906e-03f, 2.14462385e-01f, 8.77820477e-02f, 1.01803660e-01f,
  -5.32717481e-02f, -1.09363953e-02f, 5.07894643e-02f, -4.21659574e-02f, 6.69945106e-02f, 1.50233805e-01f, 1.01968184e-01f, 1.35161415e-01f, 1.02007143e-01f, 4.52207215e-02f,
  7.09762424e-02f, 2.78656296e-02f, -4.73498963e-02f, 6.29009008e-02f, -4.05990332e-02f, -4.89362478e-02f, -9.53734294e-03f, 5.93175776e-02f, 4.13992144e-02f, -1.68999657e-02f,
  -5.25156595e-02f, 3.04620191e-02f, 2.15162057e-02f, -2.80119814e-02f, 8.88153631e-03f, -4.18649381e-03f, 5.75778112e-02f, 3.36003453e-02f, 4.95065711e-02f, -3.49472207e-03f,
  5.32501340e-02f, -4.64814194e-02f, -5.50016053e-02f, -8.50242674e-02f, -3.27419341e-02f, -6.33500963e-02f, -3.15792672e-02f, 3.09194773e-02f, 5.61369993e-02f, 1.69158503e-02f,
  -3.29213291e-02f, -4.67283055e-02f, 2.67875139e-02f, -1.19582517e-02f, 1.35559437e-03f, 5.91629464e-03f, -9.08212271e-03f, 1.14793971e-01f, -4.18564118e-02f, 3.76731865e-02f,
  1.26763945e-02f, -2.90218908e-02f, 9.23719704e-02f, 2.50759609e-02f, -2.94210166e-02f, 5.18584289e-02f, -2.25521456e-02f, -4.26568203e-02f, 5.54820262e-02f, 5.64052053e-02f,
  -8.97962302e-02f, -2.86106840e-02f, -2.74414252e-02f, -2.01437957e-04f, 9.76161938e-03f, -4.63391729e-02f, -6.95454702e-02f, -9.73819643e-02f, -4.29517254e-02f, -4.57452238e-02f,
  1.20447755e-01f, 1.79354232e-02f, 3.73824988e-03f, -3.57916616e-02f, -1.19389128e-02f, -7.78022083e-03f, -1.25848297e-02f, -4.08731997e-02f, 3.23490016e-02f, -1.46475956e-02f,
  1.22171402e-01f, 1.95323899e-02f, -2.48047505e-02f, -1.57626010e-02f, 3.11801862e-02f, 3.16673443e-02f, -2.82410942e-02f, 7.27338344e-02f, 2.15643048e-02f, 3.79051678e-02f,
  3.07598189e-02f, 1.04369357e-01f, 9.73535585e-04f, 5.24800308e-02f, 1.12071529e-01f, 6.18889257e-02f, 1.11278720e-01f, 1.90933570e-02f, 1.20104961e-01f, 5.32267131e-02f,
  1.90427341e-02f, 8.66399258e-02f, -1.85291674e-02f, 6.36431947e-02f, 1.51477143e-01f, 7.45079815e-02f, 2.29012012e-01f, 1.18578374e-01f, -8.34195409e-03f, 1.22013658e-01f,
  5.00409752e-02f, 5.69488406e-02f, -1.09438866e-01f, 4.73302184e-03f, -1.51159748e-01f, -9.29945782e-02f, -7.15573505e-03f, -9.54790413e-02f, 1.35519067e-02f, 6.02050535e-02f,
  -1.26565751e-02f, 3.93600352e-02f, -1.06136136e-01f, 2.28193235e-02f, 3.15618478e-02f, 3.83885065e-03f, -9.28808451e-02f, -2.05202820e-03f, -6.03674613e-02f, -1.08353021e-02f,
  1.57413296e-02f, 6.40131207e-03f, 1.44867562e-02f, 1.93786342e-03f, 1.00052454e-01f, 3.57717685e-02f, -4.10754606e-02f, -5.38433939e-02f, -7.09532797e-02f, 4.42739762e-03f,
  -4.69595976e-02f, 7.70846158e-02f, 2.00324655e-02f, 7.36044347e-02f, 5.28183253e-03f, -5.42722037e-03f, 7.26774782e-02f, 1.55008491e-03f, -7.77348354e-02f, 4.34852317e-02f,
  -2.96070240e-03f, 8.65722448e-02f, -3.94811220e-02f, -3.42865400e-02f, -3.99797410e-02f, -6.32116422e-02f, -1.10915406e-02f, 3.36740799e-02f, -6.70552924e-02f, 2.44106632e-02f,
  5.37016764e-02f, -2.91912016e-02f, -5.65469153e-02f, -4.51284871e-02f, 5.34409657e-02f, -3.39504592e-02f, 5.24648689e-02f, -6.80464730e-02f, -4.86994535e-02f, 7.26465434e-02f,
  -3.16532627e-02f, 6.22470565e-02f, -2.08715163e-02f, 9.97373275e-03f, 4.52481434e-02f, 1.03861494e-02f, -3.45797837e-02f, -1.86513700e-02f, -9.90571454e-03f, 3.49628218e-02f,
  3.81609425e-02f, 1.73980832e-01f, 5.05267717e-02f, -2.57501546e-02f, 1.42310848e-02f, -3.02360132e-02f, 6.18392453e-02f, -1.91919617e-02f, -1.37232142e-02f, -3.28195398e-03f,
  2.48470083e-02f, 1.29003162e-02f, 8.83773062e-03f, -3.71367782e-02f, 4.92772199e-02f, -8.96026939e-02f, 5.53109199e-02f, 3.79978456e-02f, 5.74117191e-02f, 8.17672759e-02f,
  4.84164916e-02f, -2.09061299e-02f, 6.88382313e-02f, -1.28662435e-03f, 6.39399588e-02f, 2.12957151e-02f, -3.21979560e-02f, -7.28924945e-02f, 4.47720587e-02f, 3.90139073e-02f,
  4.19729859e-01f, 4.16806728e-01f, 2.84371316e-01f, 4.24193859e-01f, -5.45594692e-02f, -1.45451158e-01f, -1.83932967e-02f, 1.00044265e-01f, 2.09673539e-01f, 1.61492713e-02f,
  -1.31437108e-01f, 3.66798341e-01f, -1.23870462e-01f, 8.47548395e-02f, -1.01767015e-02f, -1.78707018e-01f, 2.01671824e-01f, 6.63652495e-02f, 2.74521392e-02f, 1.69407070e-01f,
  1.87090695e-01f, -1.45303652e-01f, 1.30193934e-01f, -1.50483176e-01f, 2.25254491e-01f, 2.71681339e-01f, -1.60422951e-01f, -1.82665005e-01f, 1.30068064e-01f, -8.01464319e-02f,
  2.72843391e-02f, 1.06396616e-01f, 7.86032453e-02f, 1.21699078e-02f, 3.67753096e-02f, 9.84120928e-03f, 6.59837499e-02f, -2.76511777e-02f, -5.28373793e-02f, 4.52245586e-03f,
  8.02464709e-02f, -3.60806845e-02f, -1.89144840e-03f, -1.04423771e-02f, 3.48694995e-02f, 5.84381185e-02f, 2.12070372e-04f, 2.89980527e-02f, 3.03970110e-02f, 5.61110340e-02f,
  1.28023088e-01f, 9.68933105e-02f, 7.96043128e-02f, -4.51841466e-02f, -1.90225826e-03f, 6.79028174e-03f, -1.80784948e-02f, -5.47831366e-03f, 2.82407738e-02f, 9.80612412e-02f,
  5.15981577e-02f, 1.30342720e-02f, 3.93405855e-02f, -2.98836478e-03f, 3.99968140e-02f, -5.72969280e-02f, 4.45011519e-02f, -5.43693230e-02f, 3.46454047e-02f, -7.82086477e-02f,
  -5.61759323e-02f, 3.60416360e-02f, -6.63584024e-02f, 3.54912765e-02f, 1.99673697e-02f, 1.55292870e-02f, -3.67474258e-02f, 1.68175213e-02f, 3.24906744e-02f, 3.78625281e-02f,
  -2.50005070e-02f, -5.49493879e-02f, 1.22364378e-02f, -3.26152481e-02f, 1.27910394e-02f, -6.86688125e-02f, -3.37903295e-03f, 6.28194362e-02f, -6.35487586e-02f, -4.83395047e-02f,
  8.57055262e-02f, 1.39927194e-01f, 2.74875946e-02f, -3.45950131e-04f, -4.73451391e-02f, 1.57882590e-02f, 1.21266330e-02f, 2.30092034e-02f, 6.90733120e-02f, 1.58590805e-02f,
  2.66799964e-02f, 1.13247791e-02f, -1.68501027e-02f, -5.09841479e-02f, -3.22075412e-02f, 7.52496347e-02f, 4.18015523e-03f, -9.03202221e-03f, 3.70917981e-03f, 4.27134745e-02f,
  2.07209936e-03f, -2.95841955e-02f, -1.54986568e-02f, 3.85949872e-02f, 3.75759006e-02f, 1.82517972e-02f, 4.60252203e-02f, 7.52867386e-02f, 2.42778827e-02f, 2.18991656e-02f,
  1.73643067e-01f, -3.95545721e-01f, -3.50194305e-01f, 2.77289320e-02f, 3.28462064e-01f, 1.24591388e-01f, -2.53207386e-02f, 7.08394647e-02f, -2.65874386e-01f, -8.71390775e-02f,
  1.54201210e-01f, -1.62101865e-01f, -3.90045583e-01f, -4.83644120e-02f, 1.15308121e-01f, -4.08340663e-01f, 1.83476403e-01f, 5.66173717e-02f, -1.83739275e-01f, 9.05192271e-02f,
  4.40619215e-02f, 2.36342326e-01f, -1.28648862e-01f, 3.21073890e-01f, 1.93437725e-01f, 8.67486447e-02f, 2.52300471e-01f, -9.45182294e-02f, 2.63086557e-01f, 1.47286236e-01f,
  -5.53918369e-02f, -1.37639210e-01f, 3.13778850e-03f, -4.91679907e-02f, 5.25874756e-02f, 1.13389038e-01f, 4.10254896e-02f, 1.39885889e-02f, -6.45597130e-02f, -1.02076560e-01f,
  -3.01514100e-03f, 7.05835819e-02f, -1.11145815e-02f, 5.81096634e-02f, 7.93639570e-02f, 3.80470678e-02f, -6.29511699e-02f, -1.70097537e-02f, -1.06965147e-01f, -1.01916753e-01f,
  -1.38568938e-01f, -1.03422711e-02f, 8.07127431e-02f, -5.75064402e-03f, -4.29394878e-02f, 2.88642552e-02f, -1.96727235e-02f, -4.69452143e-02f, -4.00783382e-02f, 2.91840974e-02f,
  7.08618835e-02f, 9.43359584e-02f, 8.32598805e-02f, 1.60667710e-02f, 2.16238871e-02f, -2.75312643e-02f, 6.09742552e-02f, -6.45282194e-02f, -1.39679306e-03f, -5.10920491e-03f,
  -8.70394986e-03f, 4.19779196e-02f, -5.02225608e-02f, 3.41542996e-02f, 5.33507541e-02f, -2.44133491e-02f, 3.82416770e-02f, -1.28410021e-02f, 1.77218094e-02f, -3.60605270e-02f,
  -3.52741070e-02f, -4.23182733e-02f, 3.13095637e-02f, -3.68600129e-04f, -3.35998125e-02f, 7.29843974e-03f, -3.45212966e-02f, -5.93943223e-02f, 4.36551273e-02f, 8.13229233e-02f,
  1.17686681e-01f, -3.29196383e-03f, -5.14609218e-02f, 5.06846458e-02f, -7.52585605e-02f, 3.85469422e-02f, -6.58285245e-02f, 5.50069027e-02f, -6.07448677e-03f, -2.47251727e-02f,
  1.24313563e-01f, 4.19259332e-02f, 3.57237533e-02f, 5.38300797e-02f, 5.12355864e-02f, 2.66804975e-02f, -4.15958017e-02f, 4.06553075e-02f, 4.99380492e-02f, -3.91620882e-02f,
  1.04700476e-01f, 1.45596089e-02f, 1.45436882e-03f, 4.95305918e-02f, 4.97275479e-02f, 4.92338315e-02f, 9.91114825e-02f, 4.78317402e-02f, -3.63313928e-02f, -6.81519732e-02f,
  1.43595114e-01f, -5.51400110e-02f, -2.73142070e-01f, 2.09824502e-01f, 6.67785034e-02f, -1.78892985e-02f, -2.77232975e-01f, 8.92571583e-02f, -2.38306910e-01f, 1.66299697e-02f,
  2.57697284e-01f, -1.96654983e-02f, -7.46832415e-02f, 3.34014446e-01f, 3.31692219e-01f, -1.37333333e-01f, 2.82876968e-01f, 1.41548350e-01f, -6.86232150e-02f, 1.67139530e-01f,
  2.55803227e-01f, 4.26143020e-01f, 1.50757521e-01f, 2.73866445e-01f, 1.16257697e-01f, 1.34976983e-01f, 2.59989411e-01f, -4.39012162e-02f, 4.65285182e-01f, 1.28913909e-01f,
  -7.59031102e-02f, -7.01102242e-02f, -2.98915915e-02f, -1.48381546e-01f, 5.34428880e-02f, -2.08283253e-02f, -2.36131176e-02f, 5.91626354e-02f, -7.28572085e-02f, 1.24093415e-02f,
  -2.65430976e-02f, 2.09542108e-03f, 6.19701892e-02f, 5.45954856e-04f, 1.44505221e-03f, -1.91984549e-02f, 2.13467330e-03f, -6.80091530e-02f, -6.59051836e-02f, 6.42496049e-02f,
  -1.00645900e-01f, -4.61990274e-02f, -3.30542736e-02f, -1.07217757e-02f, -2.83958912e-02f, 6.73477654e-04f, -3.50095145e-02f, 5.84225580e-02f, -2.60814074e-02f, -2.13591680e-02f,
  6.00351356e-02f, -4.16919217e-02f, -2.62436159e-02f, 1.05775511e-02f, 5.84418401e-02f, -3.47389537e-03f, 1.99319702e-02f, 3.73460241e-02f, -3.73023488e-02f, 3.85666415e-02f,
  3.83618176e-02f, 7.88198337e-02f, 5.76208197e-02f, -4.38101310e-03f, 5.32027557e-02f, -8.42776895e-02f, -4.28634882e-02f, 3.53082754e-02f, -1.26471985e-02f, 2.29909476e-02f,
  -3.94091010e-02f, 1.09911812e-02f, 2.58254856e-02f, -2.03306507e-02f, 2.78887488e-02f, 7.52883125e-03f, 1.30815163e-01f, 3.34193669e-02f, -1.45090893e-01f, -6.77480772e-02f,
  1.44086376e-01f, 2.45976999e-01f, -2.74078064e-02f, 4.82629016e-02f, -3.51071209e-02f, 1.10205762e-01f, -7.26362364e-03f, 4.98034135e-02f, 3.75150293e-02f, 1.42529225e-02f,
  -2.24874206e-02f, -2.52777264e-02f, -3.18667032e-02f, 3.59911434e-02f, -7.91329332e-03f, 5.59874773e-02f, -2.87312758e-03f, -1.49338506e-03f, 5.52800298e-02f, 1.29210606e-01f,
  -1.98551677e-02f, -4.68214564e-02f, -3.85341793e-02f, -3.75318192e-02f, 1.43190995e-02f, -5.23562022e-02f, 3.34497616e-02f, -5.44633791e-02f, 8.00312683e-02f, 1.49961663e-02f,
  5.11278622e-02f, 1.39509439e-01f, 3.46271753e-01f, 1.94400012e-01f, -5.17093055e-02f, -2.17324451e-01f, -6.36242749e-03f, 1.45874128e-01f, 6.70505688e-02f, -7.26841837e-02f,
  -4.51947264e-02f, 6.07410818e-02f, 2.25815773e-02f, 1.22405358e-01f, 5.25919758e-02f, 2.96116117e-02f, 1.78595800e-02f, 4.76008207e-02f, 9.84131619e-02f, 4.41969819e-02f,
  1.98746234e-01f, -6.24948926e-02f, 1.49356812e-01f, 4.21311222e-02f, 1.33186236e-01f, 2.12365672e-01f, -4.84941825e-02f, 1.54028744e-01f, 1.06041834e-01f, -1.67044215e-02f,
  -2.39918269e-02f, -5.35530001e-02f, 1.97325069e-02f, -7.88655877e-03f, 2.70621087e-02f, 3.44682834e-03f, -7.29893986e-03f, -6.27210736e-02f, 1.67975016e-02f, -6.52847290e-02f,
  5.05074859e-02f, -3.14990059e-02f, 1.08057380e-01f, -4.29176539e-02f, -2.04037651e-02f, -1.36940670e-03f, 1.28343239e-01f, 6.97968379e-02f, 5.98695315e-02f, 3.52741294e-02f,
  9.57292840e-02f, -9.61110368e-03f, 1.86650753e-02f, 7.10242018e-02f, 2.02290229e-02f, -2.96122078e-02f, -5.93037978e-02f, -5.30912192e-04f, 5.12854494e-02f, 5.32849021e-02f,
  -7.41076171e-02f, -2.21880097e-02f, -7.79660493e-02f, 8.20308253e-02f, -2.42848638e-02f, -5.69610484e-02f, 2.54714284e-02f, 3.95583548e-02f, -9.69263539e-03f, -3.31314132e-02f,
  -4.30858918e-02f, 6.42736927e-02f, -1.28646074e-02f, 4.37088776e-03f, 4.96222563e-02f, 4.93830815e-02f, 5.76917008e-02f, -8.93322304e-02f, 9.23548266e-02f, -1.52661502e-02f,
  -6.26055077e-02f, 1.21364491e-02f, 1.88324135e-02f, 1.92946326e-02f, -2.44327802e-02f, 4.32850234e-02f, 7.50408396e-02f, 4.71179597e-02f, -1.28011359e-02f, 6.63457215e-02f,
  5.86744994e-02f, 2.20345318e-01f, 4.54776734e-03f, -8.04154724e-02f, 8.18331093e-02f, -9.63983219e-03f, 3.31347138e-02f, 9.33637917e-02f, 3.69138531e-02f, 2.79057119e-03f,
  3.38675529e-02f, 6.80065081e-02f, 2.12797755e-03f, 6.82957545e-02f, 7.25538954e-02f, -2.87926812e-02f, -1.20916842e-02f, 1.62555799e-02f, -3.72442454e-02f, 6.08201399e-02f,
  -3.74911865e-03f, -7.84794707e-03f, 2.05892548e-02f, -4.91292961e-02f, -2.94551682e-02f, -5.32667711e-02f, 2.89250612e-02f, 7.97804520e-02f, 2.40691192e-02f, 7.60024562e-02f,
  3.27655748e-02f, -3.84235591e-01f, -8.18553288e-03f, 4.85082380e-02f, 2.26256475e-01f, 1.37398504e-02f, 1.07413242e-02f, 7.62443021e-02f, 8.16444755e-02f, -1.64735109e-01f,
  -1.07726038e-01f, -1.45284280e-01f, -1.93874493e-01f, 8.57245550e-02f, 2.82444861e-02f, -1.25088006e-01f, 1.59469113e-01f, -5.00120297e-02f, 6.14306368e-02f, 3.64957601e-02f,
  1.42584458e-01f, 7.66214281e-02f, 3.62433158e-02f, 5.35675324e-02f, 1.52293548e-01f, 1.15052193e-01f, -3.68404426e-02f, -2.26812642e-02f, -2.39764471e-02f, 3.39035653e-02f,
  -3.76016162e-02f, -1.01324320e-01f, -8.22300836e-02f, 7.73594109e-03f, -1.14478851e-02f, 1.22292386e-02f, -1.08005792e-01f, -3.18689868e-02f, 8.26184824e-02f, 7.69263729e-02f,
  -4.12664078e-02f, -2.60723718e-02f, 1.02823332e-01f, 1.36816474e-02f, 2.13377457e-02f, 4.38488498e-02f, 1.38404258e-02f, 1.63048115e-02f, 6.27561361e-02f, 6.51282258e-03f,
  -5.00870384e-02f, 1.14069106e-02f, 6.12065643e-02f, -4.01802137e-02f, 8.37636739e-02f, -2.67824419e-02f, 2.93630753e-02f, -8.85020643e-02f, -1.12046646e-02f, 7.17393830e-02f,
  2.58761086e-02f, -6.58448562e-02f, 2.64455862e-02f, 4.67414930e-02f, 1.69329289e-02f, -6.25265762e-03f, 8.67495313e-02f, 7.66690746e-02f, 2.75211222e-03f, -1.94259174e-02f,
  2.32105944e-02f, -4.49878629e-03f, 8.09827000e-02f, -9.98025835e-02f, -4.89297211e-02f, 6.82107592e-03f, -4.82487381e-02f, 7.89090320e-02f, -5.89636434e-03f, -4.64744354e-03f,
  9.19120312e-02f, -8.62790551e-03f, -5.98130822e-02f, -3.37360278e-02f, -5.98660335e-02f, -1.61862522e-02f, 5.30004539e-02f, 4.86489311e-02f, -1.83025803e-02f, 4.72812168e-02f,
  -1.30558670e-01f, -1.87319934e-01f, 3.31802145e-02f, 5.31910062e-02f, -4.54606079e-02f, -9.54368636e-02f, 8.34371373e-02f, -1.44790085e-02f, -8.13709199e-03f, -6.86150119e-02f,
  -1.37974955e-02f, 4.65092212e-02f, -7.58863389e-02f, -7.51587702e-03f, -4.25618514e-02f, 4.87894267e-02f, -1.05753774e-02f, 7.44854799e-04f, -3.97851057e-02f, -6.06475063e-02f,
  -1.89737231e-02f, -6.87441677e-02f, 6.87719062e-02f, 9.72172711e-03f, -3.18985097e-02f, -8.14958513e-02f, -7.25777494e-03f, -9.68503766e-03f, 5.38646765e-02f, -4.67859283e-02f,
  -1.02930322e-01f, -1.40648529e-01f, 1.55132008e-03f, 1.56394571e-01f, -4.77466807e-02f, -3.91360283e-01f, -4.25195366e-01f, -9.55282673e-02f, -8.72848928e-02f, -1.34483904e-01f,
  -1.96357191e-01f, 1.34546638e-01f, -1.53206453e-01f, 9.19911191e-02f, 1.34480968e-01f, 1.03803664e-01f, 1.65876783e-02f, -1.43344738e-02f, 1.84577361e-01f, -4.18018810e-02f,
  1.09093450e-01f, 5.26125766e-02f, 2.04109862e-01f, 4.81188260e-02f, 4.36931942e-03f, 2.23687783e-01f, 3.71487588e-01f, -6.31660670e-02f, 1.67347461e-01f, 1.74719721e-01f,
  2.24642996e-02f, -5.59085496e-02f, -1.01883866e-01f, 4.65772152e-02f, 1.90427713e-02f, -7.14087486e-02f, -1.57338381e-02f, -3.32004875e-02f, 4.84116673e-02f, 1.03169447e-02f,
  2.64391012e-04f, 5.53384200e-02f, 3.84675190e-02f, 6.92992434e-02f, 1.48710553e-02f, 3.00566647e-02f, 7.75359944e-02f, -1.81097537e-02f, 1.86885353e-02f, -3.85852531e-02f,
  -5.12099378e-02f, -2.66838446e-02f, -4.37696651e-02f, -3.97366397e-02f, 1.66233014e-02f, -7.35033527e-02f, 3.06536108e-02f, -3.38721089e-02f, 6.05459735e-02f, 3.59391384e-02f,
  -1.04559422e-01f, 3.63424793e-02f, -6.46383911e-02f, 1.09175416e-02f, -5.23974635e-02f, -4.11400311e-02f, 2.87675560e-02f, 7.12193199e-04f, -9.78336763e-03f, -8.99433643e-02f,
  6.21707961e-02f, -1.62044857e-02f, 3.01845670e-02f, -3.99346054e-02f, -3.30914743e-02f, -3.98774520e-02f, 8.53677765e-02f, -1.11724557e-02f, -7.54268169e-02f, 1.27054350e-02f,
  3.88660766e-02f, 3.61666605e-02f, 1.00704469e-03f, -5.88804819e-02f, -1.14218593e-01f, -1.58082340e-02f, 6.64351583e-02f, -5.40582240e-02f, 9.33237746e-02f, 4.82600043e-03f,
  -8.98682252e-02f, 1.19519658e-01f, 1.51553573e-02f, -6.87089637e-02f, -2.36152229e-03f, -3.60967629e-02f, -4.35758345e-02f, 3.07969172e-02f, 6.74042776e-02f, -5.88462837e-02f,
  1.05613405e-02f, 1.39412722e-02f, -3.64501849e-02f, -4.04236615e-02f, 6.75126687e-02f, -2.89597991e-03f, 2.17104200e-02f, 6.34108558e-02f, -9.43868328e-03f, 7.48705342e-02f,
  -1.60960965e-02f, 2.78269243e-03f, 5.52650951e-02f, -4.10584966e-03f, -3.08526703e-03f, 1.85413659e-03f, 3.14634964e-02f, 6.69345036e-02f, -2.49369182e-02f, -1.09862173e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.24371359e-01f, -1.83610246e-02f, 2.92021334e-01f, 3.19914341e-01f, 1.14250548e-01f, 1.82523936e-01f, 1.26705676e-01f, 1.69938251e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.55739450e-01f, 2.82374471e-01f, -1.51452169e-01f, -1.94646940e-01f, 9.64167714e-02f, -3.02954949e-02f, 4.21326123e-02f, 8.97102151e-03f, 4.60116118e-02f, 3.30940396e-01f,
  2.54982021e-02f, -2.36856956e-02f, -4.14869219e-01f, -2.22278796e-02f, 1.76418766e-01f, -1.01802677e-01f, 3.14141154e-01f, -3.84131938e-01f, 4.10240978e-01f, -2.33861879e-01f,
  1.89905912e-01f, -3.16137731e-01f, -3.85661721e-01f, -2.98782855e-01f, 1.08073220e-01f, 1.82980020e-02f, 5.58992587e-02f, 3.18318069e-01f, -9.19908052e-04f, 1.17843471e-01f,
  2.25119919e-01f, -9.62513238e-02f, 4.31462005e-02f, -4.02677268e-01f, -8.45872983e-03f, 1.48149982e-01f, -1.29060417e-01f, 1.22367963e-01f, -2.59791553e-01f, 3.67714055e-02f,
  3.67664918e-02f, -5.93071952e-02f, 2.97633000e-03f, 1.83766544e-01f, -2.24987194e-02f, -3.64000529e-01f, -9.83794108e-02f, 4.43391837e-02f, 4.78570759e-02f, -1.38396313e-02f,
  -8.83768946e-02f, 3.60773355e-01f, 2.89828330e-01f, 2.90848464e-01f, 3.52322370e-01f, 5.07587552e-01f, 2.85813242e-01f, -2.63700098e-01f, -1.69367060e-01f, -3.42473924e-01f,
  -3.12001735e-01f, -1.06261492e-01f, -1.10178366e-01f, 7.78740942e-02f, 1.77541580e-02f, 4.16090131e-01f, 2.49740288e-01f, -8.98832604e-02f, 3.42729002e-01f, 1.40338466e-01f,
  -1.08418003e-01f, -3.57669443e-02f, 1.07238077e-01f, 1.82553187e-01f, 1.32995650e-01f, 6.37435690e-02f, 2.43697137e-01f, -1.97057754e-01f, -1.78685382e-01f, -5.57773821e-02f,
  8.36643055e-02f, -4.21073467e-01f, -5.01774430e-01f, -3.75855789e-02f, -2.25046262e-01f, 4.89574410e-02f, 2.18181819e-01f, 5.92757225e-01f, 3.40324938e-01f, -2.10111573e-01f,
  -5.95129654e-02f, -2.84799397e-01f, -3.49343538e-01f, 1.70890957e-01f, 1.14219673e-01f, -2.44796529e-01f, 1.93558801e-02f, -1.95657641e-01f, -1.92207232e-01f, -1.10401608e-01f,
  -3.44504938e-02f, -1.39220864e-01f, -2.66827017e-01f, -9.31865126e-02f, -3.90322000e-01f, 1.14312164e-01f, -4.21463788e-01f, 1.93885222e-01f, -6.17409050e-01f, 2.09993318e-01f,
  4.75276411e-01f, 3.74663204e-01f, 1.90555960e-01f, -5.15751958e-01f, 1.21094219e-01f, -3.58507484e-01f, 3.50920707e-01f, 2.25323290e-01f, -1.55653030e-01f, -1.31594151e-01f,
  2.71692090e-02f, 3.03006805e-02f, -1.51493028e-01f, 2.49158606e-01f, 1.78632945e-01f, 1.37493476e-01f, 1.87962502e-01f, 1.62699550e-01f, 9.07349512e-02f, -3.17711323e-01f,
  -1.25730470e-01f, -2.89532304e-01f, -1.98958799e-01f, 1.87183097e-01f, 4.16028686e-02f, 2.66048551e-01f, 5.94467185e-02f, -1.67715594e-01f, -1.13191776e-01f, 2.31444001e-01f,
  -3.96695703e-01f, 4.97548841e-02f, 2.12155972e-02f, 1.38563052e-01f, -4.54452604e-01f, 2.67165482e-01f, -9.08123255e-02f, 6.77642077e-02f, 1.66454524e-01f, 4.25044030e-01f,
  2.02741444e-01f, 2.86445897e-02f, 1.73802450e-01f, -7.75254518e-02f, -2.12682843e-01f, 1.09533332e-01f, 2.56423682e-01f, -1.77060679e-01f, -1.93222702e-01f, -7.51428604e-02f,
  -1.33193746e-01f, -2.87042767e-01f, 3.17349075e-03f, -1.08815506e-01f, -1.77694410e-01f, 1.64846435e-01f, 2.49955833e-01f, 1.17673621e-01f, 4.78318036e-02f, -1.44823631e-02f,
  1.29816011e-01f, -1.21931747e-01f, 7.31646270e-02f, -6.33028597e-02f, -5.00704311e-02f, -8.90923068e-02f, -2.58647025e-01f, 2.98137277e-01f, -1.90467816e-02f, 3.76662463e-01f,
  1.15641527e-01f, 2.18130469e-01f, 4.43781137e-01f, 3.45458180e-01f, 1.91937108e-02f, -1.10597655e-01f, -2.16714203e-01f, -1.83537200e-01f, 1.02520272e-01f, 1.18851900e-01f,
  -2.69876003e-01f, 1.00221135e-01f, 2.16028675e-01f, 1.92800120e-01f, -2.46808063e-02f, -3.48360568e-01f, 1.21460088e-01f, -1.22814626e-01f, -1.70153156e-01f, 8.47437754e-02f,
  -5.14534339e-02f, 8.67827535e-02f, -1.82014760e-02f, 1.76810727e-01f, -4.67811465e-01f, 2.15747461e-01f, 7.84618482e-02f, 4.15748268e-01f, -3.30519468e-01f, -2.80612558e-01f,
  -2.18433529e-01f, -1.33190036e-01f, -1.29869878e-01f, 2.82377541e-01f, -9.23282132e-02f, -2.39279214e-02f, 1.21246375e-01f, -1.77604854e-01f, 1.16493903e-01f, 3.56933266e-01f,
  2.38276124e-01f, -1.75381690e-01f, -4.00906280e-02f, 1.04136271e-02f, 7.24496916e-02f, 2.02916205e-01f, 3.73537093e-02f, -5.19176014e-02f, -1.31308138e-01f, -6.58357739e-02f,
  1.08519413e-01f, -3.28510672e-01f, 6.67926595e-02f, -3.66370946e-01f, 1.54630393e-01f, -3.24748635e-01f, 3.49566102e-01f, 2.48109803e-01f, -2.14446917e-01f, 1.04697861e-01f,
  -4.06772733e-01f, 4.56162155e-01f, 3.59435426e-03f, 2.22729653e-01f, -2.37280414e-01f, -4.80862230e-01f, -7.85340592e-02f, -5.08276224e-02f, -3.16258311e-01f, -3.19467150e-02f,
  -1.11704096e-01f, -1.41481077e-03f, 1.99541807e-01f, -1.32847562e-01f, -1.22041985e-01f, -2.15773538e-01f, 4.77201715e-02f, -8.85304511e-02f, 1.59226209e-01f, 1.38569444e-01f,
  -2.14785054e-01f, 1.91682920e-01f, 1.11494213e-01f, 4.09185775e-02f, 5.22426143e-02f, -8.37371591e-03f, -1.39218882e-01f, 1.17130904e-02f, -5.85557614e-03f, -2.47747615e-01f,
  -1.14988968e-01f, 2.75420576e-01f, 2.17382252e-01f, -3.56860101e-01f, 5.35535775e-02f, 4.56383312e-03f, 1.60161778e-01f, 1.84830770e-01f, 6.78888187e-02f, 4.42269593e-01f,
  -1.67019904e-01f, -2.37887949e-01f, -2.40799680e-01f, 1.93148986e-01f, -1.86245576e-01f, -8.45052749e-02f, 3.41954708e-01f, 2.16029078e-01f, 1.81010514e-01f, 2.53220767e-01f,
  -5.62596656e-02f, -3.70380640e-01f, 2.10052669e-01f, -1.42770037e-01f, 6.20896965e-02f, 2.85185158e-01f, 1.19789965e-01f, 3.76413256e-01f, -8.38250741e-02f, -5.88965788e-02f,
  -4.64508682e-01f, -5.13534993e-02f, -1.30756050e-01f, 2.33275712e-01f, 1.32463232e-01f, -2.90180355e-01f, 3.11925471e-01f, -3.98583293e-01f, 2.69058466e-01f, 6.54857531e-02f,
  -2.75979489e-01f, -4.08910722e-01f, -1.45094162e-02f, 7.27077276e-02f, -3.23092937e-01f, 2.76011735e-01f, -9.92160961e-02f, -3.40302922e-02f, 2.67515272e-01f, -1.12742566e-01f,
  -5.50226644e-02f, -2.85503179e-01f, -2.47177463e-02f, -1.84264295e-02f, -1.21889003e-01f, -9.99255944e-03f, -3.91083539e-01f, -9.62550566e-02f, -7.77410865e-02f, -5.30645736e-02f,
  3.47052068e-02f, 8.47679898e-02f, -8.80628675e-02f, 2.42533147e-01f, 2.06180543e-01f, -1.03129454e-01f, 7.94299990e-02f, 2.08650962e-01f, -2.66411453e-01f, 9.14622098e-02f,
  -1.33310556e-01f, 1.59732461e-01f, 9.60795060e-02f, -2.85774887e-01f, -1.66743070e-01f, -8.30965415e-02f, 4.03011590e-01f, -2.52335787e-01f, -8.43996778e-02f, 2.03589976e-01f,
  7.29159126e-03f, 9.43397582e-02f, -9.44123566e-02f, -8.96705762e-02f, -1.34934366e-01f, 1.03597403e-01f, 2.21689537e-01f, -7.66353831e-02f, -2.92783648e-01f, -1.76496971e-02f,
  1.38758153e-01f, -1.28239498e-01f, 1.74134538e-01f, -5.00219353e-02f, -2.45877746e-02f, 3.16175163e-01f, 4.39568087e-02f, -2.15548933e-01f, -2.26223230e-01f, 4.09191012e-01f,
  -2.98165679e-01f, 3.47773661e-03f, -2.72581607e-01f, 1.69298649e-02f, 2.97203809e-02f, -3.39365751e-01f, 2.08965078e-01f, 9.67163742e-02f, 3.23428512e-01f, -2.94427574e-01f,
  -1.07251897e-01f, 2.16029599e-01f, -1.51203141e-01f, -2.56750709e-03f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.22088711e-02f, -1.54826686e-01f, 1.01693477e-02f, -1.20761789e-01f, 1.13605727e-02f, 2.43789643e-01f, 2.58775502e-01f, 5.75252116e-01f, 6.31259405e-04f, 2.46175021e-01f,
  3.65236133e-01f, 4.26354915e-01f, -3.99611354e-01f, -5.07835388e-01f, 4.17962044e-01f, -5.23748696e-01f, 2.05811620e-01f, -4.71983016e-01f, 3.64525020e-01f, 3.51872385e-01f,
  7.52035856e-01f, 3.37355845e-02f, -5.71118407e-02f, 4.62637246e-01f, 2.82603949e-01f, -1.39606610e-01f, -4.07922894e-01f, 3.85764278e-02f, 2.95632541e-01f, 1.74261406e-01f,
  -3.36658433e-02f, 5.29522121e-01f, 1.63443029e-01f, -3.23052295e-02f, 2.71459639e-01f, -2.70851012e-02f, -3.66130844e-02f, -9.30373073e-02f, 1.29762590e-01f, -2.37608757e-02f,
  2.11447015e-01f, 2.28674531e-01f, -1.27772182e-01f, 7.96167329e-02f, -1.73421875e-01f, 4.91262740e-03f, 2.71324396e-01f, -9.99785662e-02f, 1.12994269e-01f, -2.30389819e-01f,
  4.42690194e-01f, -9.36469063e-02f, 3.07730809e-02f, -8.71094018e-02f, -3.34860504e-01f, -4.89869416e-01f, 3.97912301e-02f, 6.92937002e-02f, -7.11424351e-02f, 3.48439902e-01f,
  1.52799651e-01f, -1.31539747e-01f, 1.61239520e-01f, -1.04148120e-01f, -1.45603776e-01f, -1.26961038e-01f, 1.17122836e-01f, 1.62852213e-01f, 4.07760963e-02f, 2.75293708e-01f,
  -8.30026902e-03f, 1.18299648e-01f, -4.58824039e-02f, 2.37168357e-01f, 5.96755892e-02f, -2.25079894e-01f, 2.82702744e-01f, -2.89270002e-02f, 6.91617653e-02f, -1.08404253e-02f,
  1.51492029e-01f, 6.88975528e-02f, 4.08822112e-03f, 1.66204035e-01f, 2.00214952e-01f, 4.75113429e-02f, -3.21710370e-02f, 3.29955995e-01f, -1.06381379e-01f, -4.78129797e-02f,
  7.61065558e-02f, -1.28827527e-01f, 8.59174207e-02f, -1.09161906e-01f, 1.59294248e-01f, 6.23215130e-03f, 3.08083355e-01f, 3.52710098e-01f, 6.77290782e-02f, 5.60049489e-02f,
  2.39124924e-01f, 2.15579718e-01f, -3.50095689e-01f, 3.12651306e-01f, 3.37897062e-01f, 3.55275869e-01f, 3.98645103e-02f, 2.45619327e-01f, -3.18589061e-02f, 3.34618092e-01f,
  3.44747417e-02f, 2.53326207e-01f, 2.72796363e-01f, 4.21047285e-02f, -5.15747786e-01f, -4.39562589e-01f, -4.03904229e-01f, 5.07353067e-01f, 8.10516998e-02f, 1.48428857e-01f,
  2.11577758e-01f, -8.15346017e-02f, 7.22286403e-01f, -7.62798041e-02f, -7.25423768e-02f, 4.03012931e-01f, -9.23072472e-02f, 2.38341123e-01f, -9.71959531e-02f, -4.15315963e-02f,
  -3.87175791e-02f, -4.25398722e-02f, -5.82831204e-02f, 1.38442263e-01f, 1.42584816e-01f, 3.81108560e-02f, -6.20046966e-02f, -3.82515222e-01f, 5.11126146e-02f, -4.47451510e-02f,
  -2.09921360e-01f, 1.20528124e-01f, 8.99060145e-02f, 4.41013485e-01f, -5.12825251e-01f, 2.26220325e-01f, 1.74782146e-02f, 3.05316567e-01f, 1.48079187e-01f, -8.41082484e-02f,
  9.74051505e-02f, -1.38608456e-01f, -3.41711682e-03f, 1.67075545e-01f, 1.12354591e-01f, 7.12739766e-01f, 8.78989637e-01f, 9.66610014e-02f, 1.72311261e-01f, 2.41671324e-01f,
  8.66027474e-02f, 3.34839821e-02f, 1.41732916e-01f, -1.77860767e-01f, -7.84969609e-03f, 2.45144784e-01f, 4.60509621e-02f, 1.35752127e-01f, 2.18533054e-01f, 2.39260644e-01f,
  1.52642280e-01f, -3.24922919e-01f, -5.37373349e-02f, -1.35394126e-01f, -4.33319837e-01f, 6.71279788e-01f, -2.13733599e-01f, -1.10865913e-01f, -4.07275558e-01f, 1.44074395e-01f,
  9.48835537e-02f, 3.45777988e-01f, 5.31520247e-01f, 5.74803233e-01f, 3.40387672e-01f, 1.15266535e-03f, -3.57348084e-01f, 3.84984434e-01f, 1.06720716e-01f, -3.04685086e-01f,
  7.53608048e-02f, 1.02703832e-01f, -1.83612052e-02f, -2.07642063e-01f, 5.99541329e-02f, 1.68822950e-03f, -1.50555015e-01f, -9.15386081e-02f, 1.45906910e-01f, -4.67926376e-02f,
  -6.45112321e-02f, 1.37916327e-01f, 9.13611799e-02f, 2.09017932e-01f, -1.70373973e-02f, -2.48107791e-01f, 2.26901025e-02f, 6.72765151e-02f, 9.88946185e-02f, -1.38675004e-01f,
  2.65603542e-01f, 1.44471690e-01f, 3.14059705e-01f, 3.04174006e-01f, -1.06253110e-01f, -1.95935890e-01f, 1.16356269e-01f, -9.64300260e-02f, -1.21706687e-01f, -1.09212510e-01f,
  -1.82899043e-01f, -1.20805852e-01f, -2.01609209e-02f, 2.33972982e-01f, -2.87730604e-01f, -3.03101033e-01f, 3.17704469e-01f, 3.76581281e-01f, -7.33396271e-03f, -1.49621619e-02f,
  2.69637793e-01f, -4.92945500e-02f, 2.48257473e-01f, -1.71073824e-01f, 2.09937587e-01f, 6.01873808e-02f, -6.64521530e-02f, -3.23971850e-04f, 4.27607298e-01f, -1.58655673e-01f,
  -1.56695738e-01f, 5.25016069e-01f, 1.80565119e-01f, 4.40026075e-01f, 2.22571611e-01f, 1.62222341e-01f, 2.16057643e-01f, 3.24195735e-02f, -2.67873675e-01f, 1.92865416e-01f,
  1.14378661e-01f, -2.31366381e-02f, 4.83990967e-01f, 2.73071021e-01f, 8.67317095e-02f, 4.79851276e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  8.62453505e-02f, 1.63624793e-01f, 7.44122118e-02f, 1.25313818e-01f, 1.01449154e-01f, 7.80828446e-02f, 2.54352272e-01f, 1.45896718e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  6.20839000e-03f, 4.21080202e-01f, 5.49722433e-01f, -7.48109758e-01f, 4.13621366e-01f, 4.53597277e-01f, 4.26800460e-01f, -2.68407792e-01f, 1.46366209e-01f, -1.04584768e-01f,
  2.93164313e-01f, 5.77180013e-02f, -6.27684712e-01f, -2.14328572e-01f, 7.46611655e-02f, -2.38018468e-01f, 6.79049566e-02f, 3.50504011e-01f, -4.42592114e-01f, 8.84041369e-01f,
  -6.24716759e-01f, -7.99135864e-01f, 2.01008450e-02f, 2.87423670e-01f, -3.56528908e-01f, -8.49608779e-02f, -2.54199684e-01f, -5.18014967e-01f, 1.11110076e-01f, -4.31515217e-01f,
  9.02071521e-02f, 5.94291270e-01f, 1.96889177e-01f, -4.92566168e-01f, -3.93235713e-01f, 4.79619473e-01f, 2.31173158e-01f, 1.41991705e-01f, -3.69343348e-02f, -4.80654269e-01f,
  -5.66915907e-02f, 3.13610077e-01f, 1.39071643e-01f, 2.76558667e-01f, 4.55662668e-01f, -7.92308003e-02f, -6.17751598e-01f, -4.50492352e-01f, 4.77045834e-01f, -9.67564285e-02f,
  4.52517301e-01f, 7.96792686e-01f, -2.63404876e-01f, 1.53665960e-01f, -2.32705414e-01f, 6.88327185e-04f, -5.36689460e-01f, 1.76490471e-01f, 7.49823824e-02f, -4.90053892e-01f,
  8.53634417e-01f, -1.66133046e-01f, 6.24102391e-02f, 6.71286806e-02f, -4.49798465e-01f, -3.52281511e-01f, -1.71959311e-01f, -4.11738068e-01f, 2.57783793e-02f, -2.49729782e-01f,
  -4.10502374e-01f, 1.61431402e-01f, -2.80962884e-01f, -5.49519837e-01f, -2.72388637e-01f, -2.93398559e-01f, 1.06490739e-01f, 1.33804590e-01f, -5.75959802e-01f, 5.81678867e-01f,
  -4.23735417e-02f, -3.41134518e-01f, 1.14374064e-01f, -1.44607514e-01f, 1.83402017e-01f, 2.50290990e-01f, -1.37142822e-01f, -2.86530077e-01f, 3.68024588e-01f, 2.23393053e-01f,
  5.44764400e-02f, -3.14667106e-01f, 5.58884263e-01f, 2.30712473e-01f, -2.54227489e-01f, 1.13531239e-01f, -1.63471609e-01f, 3.01818289e-02f, -7.07530618e-01f, -5.45206726e-01f,
  2.45725900e-01f, 1.57097235e-01f, 4.58213806e-01f, 4.47560161e-01f, 1.46014825e-01f, 8.52245167e-02f, 7.30494410e-02f, -5.01903370e-02f, -8.67605746e-01f, 6.81460500e-01f,
  4.58343536e-01f, -4.01206076e-01f, -3.51742208e-02f, 3.53013217e-01f, 6.68132901e-02f, -3.42593119e-02f, 2.19798684e-01f, -3.76418650e-01f, -1.09798059e-01f, 5.09943552e-02f,
  -6.06830180e-01f, -1.59847736e-01f, 2.30913207e-01f, 3.65499884e-01f, -3.89496058e-01f, 7.68067420e-01f, 2.19522882e-02f, -1.53700396e-01f, 4.80715007e-01f, 6.77391171e-01f,
  -3.71639341e-01f, -2.64003366e-01f, 1.88479833e-02f, 4.03303981e-01f, 7.07949772e-02f, 4.17181104e-01f, 1.05732672e-01f, 4.32268828e-01f, -1.17469147e-01f, 5.23272157e-02f,
  4.15386975e-01f, 1.34641305e-01f, 8.30191374e-01f, -4.72185642e-01f, -5.98868430e-01f, 1.74472108e-01f, -5.16409218e-01f, -2.16252714e-01f, 3.29325825e-01f, -1.62729517e-01f,
  -5.75941384e-01f, -5.10786593e-01f, 7.29291916e-01f, -2.06407666e-01f, 3.21124464e-01f, -3.24411541e-01f, -2.63892293e-01f, -2.62033612e-01f, -1.31733920e-02f, 2.20476370e-02f,
  1.27841830e-01f, -4.29341853e-01f, 6.64232850e-01f, -1.54619232e-01f, -9.23531577e-02f, 2.88181484e-01f, 2.93423206e-01f, 7.26539612e-01f, -1.36821002e-01f, 4.33562577e-01f,
  3.23553056e-01f, -6.06661139e-04f, 4.42613810e-01f, -5.23907006e-01f, -4.36946839e-01f, -5.90926230e-01f, -4.45063949e-01f, -5.58353722e-01f, -5.44839740e-01f, 2.59672552e-01f,
  -8.20515096e-01f, 4.01641786e-01f, 8.92828628e-02f, 4.71062720e-01f, -3.43455821e-01f, 1.94598690e-01f, -2.19187923e-02f, 2.49256641e-01f, -5.02987027e-01f, -3.27866912e-01f,
  4.57263365e-02f, 1.94227606e-01f, -4.93941128e-01f, -4.27403420e-01f, 4.59590673e-01f, 5.01213968e-01f, -3.20594817e-01f, -7.41304934e-01f, 2.31662214e-01f, 2.64018983e-01f,
  1.57920539e-01f, -4.30658221e-01f, 3.10829371e-01f, 3.60054165e-01f, 3.54075700e-01f, -5.43793023e-01f, 7.55745396e-02f, 7.62512088e-01f, -3.79427969e-01f, -4.41908360e-01f,
  1.97300598e-01f, -4.44490343e-01f, 2.00352326e-01f, 6.88962340e-01f, -2.00859800e-01f, -4.62468922e-01f, -7.05364347e-01f, 5.39764225e-01f, 9.08892378e-02f, 3.01249117e-01f,
  -2.26376653e-01f, -2.46108457e-01f, 1.04624942e-01f, -3.98345917e-01f, 4.89311405e-02f, -3.39526534e-01f, 2.08871141e-01f, 2.45814115e-01f, -1.33947730e-02f, -1.31049067e-01f,
  -1.33389113e-02f, -1.86142057e-01f, -3.01918983e-01f, 1.28158867e-01f, 1.95057258e-01f, -1.49441436e-01f, -4.05259073e-01f, 7.30753720e-01f, -4.58329558e-01f, 1.08049050e-01f,
  2.45947942e-01f, 5.98158360e-01f, -4.22430545e-01f, -3.72819483e-01f, 5.23257613e-01f, -4.79302824e-01f, 1.97360262e-01f, -3.16929907e-01f, 5.88834405e-01f, -1.94862649e-01f,
  2.54525810e-01f, -4.39236104e-01f, -1.36538848e-01f, -2.93180812e-02f, 4.94131535e-01f, 6.07923090e-01f, 1.10656820e-01f, -5.72955888e-03f, -3.85206416e-02f, 9.25697237e-02f,
  -3.14346552e-01f, -6.51103035e-02f, -4.71930414e-01f, -1.66428030e-01f, -2.47936428e-01f, -1.64700016e-01f, -1.69159606e-01f, -2.86835194e-01f, -1.47944495e-01f, -1.25437647e-01f,
  -2.63514698e-01f, 6.51102364e-01f, 3.60812366e-01f, 2.10750118e-01f, 2.73540884e-01f, -1.34008378e-01f, -2.48607561e-01f, -3.20204169e-01f, 5.51810384e-01f, 4.47955847e-01f,
  1.63090155e-02f, -3.03660005e-01f, -2.42813099e-02f, 3.96220833e-01f, 4.89707112e-01f, -2.98040688e-01f, -1.21679187e-01f, 6.36180401e-01f, -3.20556730e-01f, 5.43627143e-01f,
  3.08282763e-01f, 2.85753071e-01f, 3.44648242e-01f, 4.93311323e-02f, 1.48123592e-01f, -6.51850522e-01f, 1.02212541e-01f, -4.43773180e-01f, -8.34887102e-02f, -5.71232587e-02f,
  2.47767940e-01f, 1.66735053e-01f, 2.48609588e-01f, 5.13190746e-01f, 1.10249288e-01f, -2.22378865e-01f, 1.90389141e-01f, -4.75317568e-01f, -1.05539851e-01f, 4.99126941e-01f,
  -1.78610310e-01f, -1.63222477e-01f, 9.98907208e-01f, 4.49526399e-01f, -2.17665315e-01f, -2.68652886e-01f, -4.25176710e-01f, -4.28195715e-01f, 4.23591405e-01f, -3.65367532e-01f,
  4.46747124e-01f, 3.80141854e-01f, -1.07630320e-01f, 3.93256605e-01f, -4.45231974e-01f, 1.15675189e-01f, -8.00386369e-01f, -5.85737899e-02f, 4.39386480e-02f, -9.93502736e-02f,
  -2.28604544e-02f, 1.01201481e-03f, 4.21198756e-02f, -5.11186272e-02f, 3.95867914e-01f, 2.45121241e-01f, 5.62276840e-01f, 1.67685583e-01f, 4.56532627e-01f, -1.80741921e-01f,
  1.75723672e-01f, 5.50146937e-01f, -3.77255142e-01f, -2.30482414e-01f, -9.70199779e-02f, -2.81755567e-01f, -1.24833293e-01f, 3.28964382e-01f, 1.07965149e-01f, 8.87527108e-01f,
  -1.99795991e-01f, -4.68418121e-01f, 2.65545547e-01f, 7.42393732e-02f, -3.68221581e-01f, 3.96358728e-01f, 8.40927809e-02f, 1.25452774e-02f, 7.62415305e-02f, -8.43452290e-02f,
  -2.01422926e-02f, 1.77390084e-01f, -7.56491274e-02f, -3.05252850e-01f, 5.13113178e-02f, -3.83688398e-02f, 5.67821562e-01f, -1.97440475e-01f, -1.45634159e-01f, -5.06769359e-01f,
  5.40596187e-01f, -5.29188752e-01f, -2.62237102e-01f, -5.01645505e-01f, 4.18575555e-01f, 4.24750835e-01f, -3.10755610e-01f, -3.62620562e-01f, -1.29153743e-01f, 1.02980995e+00f,
  -3.83366048e-01f, -3.88031363e-01f, 7.61282146e-02f, -4.90871608e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.11987460e-02f, 7.11506754e-02f, -2.26621911e-01f, -9.39855278e-02f, 2.24535286e-01f, 1.51899815e-01f, 2.60717601e-01f, -3.42247710e-02f, -3.96945924e-01f, -1.45742461e-01f,
  9.22623836e-03f, -7.35103637e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    