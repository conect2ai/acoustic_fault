/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.33451658e-01f, 8.10179859e-02f, -5.30119874e-02f, -4.43044513e-01f, -5.82380332e-02f, 9.88156870e-02f, 1.57182708e-01f, 6.99925646e-02f, 2.71832105e-02f, 1.71165466e-01f,
  -5.64775988e-02f, -5.18711358e-02f, 6.70665428e-02f, 1.06114775e-01f, 4.20926459e-04f, 1.37102321e-01f, -1.46373389e-02f, -2.25665942e-01f, -7.50395581e-02f, -3.12947668e-02f,
  -2.28433292e-02f, -3.95888269e-01f, -4.83317584e-01f, -1.44786969e-01f, 3.87945101e-02f, 1.37580678e-01f, -5.85808360e-04f, -1.92970783e-01f, 1.53377801e-02f, -3.86435032e-01f,
  4.59392294e-02f, -4.29070778e-02f, 3.71850096e-02f, -1.90730244e-02f, -5.91642298e-02f, 9.46262479e-02f, -1.65630057e-02f, -9.20205265e-02f, 2.21604798e-02f, -4.79398817e-02f,
  -4.91766445e-02f, -4.88480926e-02f, -1.03593819e-01f, -1.48723237e-02f, -7.62577057e-02f, 4.58212048e-02f, 6.05785027e-02f, -6.96902797e-02f, 8.74435604e-02f, 1.04551643e-01f,
  -1.21974595e-01f, -1.11168660e-01f, -7.30107054e-02f, 1.07726261e-01f, 1.18341275e-01f, -1.34726793e-01f, 1.19870253e-01f, 1.11768030e-01f, 1.04909115e-01f, 6.59883171e-02f,
  -2.57509910e-02f, 1.53753264e-02f, 2.28145011e-02f, -2.01540180e-02f, -1.00653023e-02f, 5.03562950e-02f, -4.15648110e-02f, -3.98224443e-02f, 2.50355955e-02f, -3.70494761e-02f,
  2.27515586e-02f, 4.40138765e-02f, 2.76826899e-02f, -8.76368284e-02f, 8.00174847e-03f, -1.33861341e-02f, 7.16101611e-03f, -8.22691433e-03f, -1.94592196e-02f, 1.31595582e-02f,
  7.97111727e-03f, 7.94156641e-03f, -1.21672126e-02f, 1.43719800e-02f, -1.93593707e-02f, -3.70095409e-02f, -6.64289948e-03f, 3.97116989e-02f, 4.94442992e-02f, -6.19474016e-02f,
  7.27483258e-02f, 1.22764297e-02f, -2.44265664e-02f, 6.33955225e-02f, 4.89737503e-02f, 2.16645468e-02f, -8.28066990e-02f, 1.45317063e-01f, -3.57213914e-02f, 2.21180543e-02f,
  -4.39869752e-03f, -3.77536081e-02f, 6.25267532e-03f, 1.96790025e-02f, 8.65312293e-02f, -1.45967584e-02f, -1.60951111e-02f, 6.57916907e-03f, 2.55330559e-02f, 3.61457132e-02f,
  1.93218514e-02f, 1.62852317e-01f, 1.02054432e-01f, 1.09410457e-01f, 6.48579597e-02f, -4.02964726e-02f, 5.55891134e-02f, 3.11534666e-02f, 1.08013988e-01f, 2.16041744e-01f,
  3.38913530e-01f, 5.45145869e-02f, -1.33974478e-01f, 1.67967528e-01f, -1.34249657e-01f, -3.50522622e-02f, 1.55714720e-01f, 1.29967406e-01f, 5.85953193e-03f, 7.47398734e-02f,
  -4.67071496e-02f, -2.43433807e-02f, -4.86861840e-02f, -1.52970348e-02f, 1.56274170e-01f, -2.98730773e-03f, 2.63934955e-02f, 6.91805333e-02f, 5.12116998e-02f, -1.82483569e-01f,
  3.97213409e-03f, 8.33338127e-02f, 2.55992979e-01f, 7.91589692e-02f, -1.31946534e-01f, 2.29088679e-01f, 1.06757529e-01f, 3.86183783e-02f, -4.60781790e-02f, -2.07150266e-01f,
  -7.87806064e-02f, -1.73794538e-01f, 9.40427370e-03f, 1.18259996e-01f, -5.12166023e-02f, 1.17085166e-02f, 6.86803237e-02f, -6.74098134e-02f, 7.53208343e-03f, -6.41990006e-02f,
  -9.90583897e-02f, -6.87712282e-02f, -3.81182246e-02f, 1.24635976e-02f, 2.59511527e-02f, -5.33988886e-03f, -4.95186858e-02f, -2.87960228e-02f, -1.39358100e-02f, -1.63230464e-01f,
  -4.07946631e-02f, -1.98659450e-01f, -3.62062529e-02f, 4.55168970e-02f, -6.06861934e-02f, -6.99825287e-02f, -6.54294156e-03f, 1.47592435e-02f, 2.98600886e-02f, 1.08852781e-01f,
  4.47511636e-02f, 1.45732220e-02f, 6.38476899e-03f, -5.42788161e-03f, 5.99855408e-02f, 2.26066168e-02f, -8.20241049e-02f, 9.23448876e-02f, -1.86127499e-02f, 7.11086243e-02f,
  -1.95201021e-02f, -4.36813459e-02f, 4.67543676e-03f, -8.36686976e-03f, 2.18451787e-02f, -2.58995499e-02f, -4.01238399e-03f, 4.90484498e-02f, -1.02107674e-02f, -1.50946351e-02f,
  4.11805101e-02f, 4.89762658e-03f, -3.39239202e-02f, -7.88006634e-02f, -4.28736359e-02f, 3.87526187e-03f, -4.98353913e-02f, 5.87359220e-02f, -2.35886630e-02f, 6.84480667e-02f,
  2.76831686e-01f, 1.05287626e-01f, -5.00215180e-02f, -4.59581427e-02f, 3.03490832e-02f, -7.19261691e-02f, -1.60727482e-02f, -1.82518624e-02f, -7.27226287e-02f, 8.64267200e-02f,
  -8.32864753e-05f, 2.83751125e-03f, 5.09784818e-02f, -4.30346318e-02f, 3.88120078e-02f, 7.55583793e-02f, 3.05154715e-02f, 7.93301836e-02f, -5.02312370e-02f, -3.04190833e-02f,
  7.10170642e-02f, 1.65400013e-01f, 2.53151923e-01f, 2.19308417e-02f, 1.80267845e-03f, 1.82955623e-01f, 1.20859399e-01f, 5.67423366e-02f, 1.90880626e-01f, 5.33030748e-01f,
  -4.67165679e-01f, -2.16007847e-02f, 5.80022745e-02f, 5.23055643e-02f, 1.42431393e-01f, 1.43745854e-01f, 5.69286011e-02f, -1.61195382e-01f, 2.43325904e-02f, -2.96708550e-02f,
  8.59484896e-02f, 1.23665251e-01f, 7.99374059e-02f, -5.12635522e-02f, -4.32875231e-02f, -1.84101705e-03f, -6.36728853e-02f, -8.49709883e-02f, 6.73964322e-02f, -1.19568817e-01f,
  4.75656427e-02f, -4.72494140e-02f, -3.95768955e-02f, -3.97601947e-02f, -4.49370965e-02f, 1.61496028e-01f, 7.07052648e-02f, -1.42895088e-01f, -7.26939738e-02f, -3.85720700e-01f,
  -1.46413282e-01f, -2.11287946e-01f, 9.20579061e-02f, -1.72673091e-02f, -5.68982624e-02f, -3.90951298e-02f, -8.45453516e-02f, -4.22197953e-02f, -2.58671138e-02f, 1.19460560e-02f,
  -3.33747417e-02f, -4.27915901e-02f, 5.63313626e-02f, -5.04275113e-02f, 2.16282392e-03f, -8.68387818e-02f, -2.74156965e-02f, -9.25125405e-02f, -1.20726237e-02f, -2.77770758e-02f,
  8.03786591e-02f, 3.82585749e-02f, 5.61146326e-02f, 4.62522507e-02f, 5.07702716e-02f, 1.10133514e-02f, -7.73268640e-02f, -2.38182157e-01f, -1.55850440e-01f, -3.28943700e-01f,
  1.88464136e-03f, -5.75308539e-02f, -2.75940876e-02f, 1.48226339e-02f, -1.53810373e-02f, 1.50174899e-02f, -1.55724809e-02f, 8.55817944e-02f, 2.44816057e-02f, -4.05311398e-02f,
  5.88774420e-02f, -4.83057424e-02f, 1.20192468e-02f, 1.28462398e-02f, 1.23544484e-02f, -1.15423445e-02f, 2.39362568e-02f, -3.58582884e-02f, 8.74418989e-02f, -8.37361217e-02f,
  1.14568546e-02f, 1.71196628e-02f, 5.42336814e-02f, -7.49058090e-04f, -4.51155789e-02f, -2.92402171e-02f, -2.59872731e-02f, -2.66725160e-02f, 3.16281291e-03f, -1.99939366e-02f,
  1.34439111e-01f, 2.09509164e-01f, -2.58648433e-02f, -8.27730671e-02f, 1.88657418e-02f, 9.11546964e-03f, 7.71087334e-02f, -1.40816551e-02f, 2.31942907e-02f, -1.72247346e-02f,
  -5.06770890e-03f, 5.78816496e-02f, -1.42426919e-02f, 1.08739082e-03f, -1.49778780e-02f, 8.51819571e-03f, -5.33778854e-02f, 4.12679650e-02f, 9.22574252e-02f, -5.33093661e-02f,
  -2.90350672e-02f, 2.52440721e-02f, 3.11230868e-02f, -5.78054190e-02f, -3.63739878e-02f, 2.90983245e-02f, 6.10630438e-02f, -1.12598157e-02f, 1.06216110e-01f, 8.73976201e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.58207464e-01f, -5.04036129e-01f, 2.85464704e-01f, 4.36051667e-01f, 4.37940508e-01f, 4.60168511e-01f, 2.04888806e-01f, -9.42624453e-03f, 1.46550283e-01f, -6.62046298e-02f,
  -2.78216582e-02f, -4.84887697e-02f, -5.53590693e-02f, -6.44989461e-02f, -4.51240167e-02f, 9.75788459e-02f, 1.04207389e-01f, 5.10154963e-02f, 1.67991906e-01f, 2.22377285e-01f,
  1.01581581e-01f, -1.11390082e-02f, 2.16445271e-02f, -5.97385392e-02f, -3.10154893e-02f, 1.34767771e-01f, 4.36051562e-03f, -4.27041091e-02f, -4.73821796e-02f, -1.22027904e-01f,
  -1.37778401e-01f, 1.49003696e-02f, 2.24473998e-01f, 3.27589773e-02f, 1.17438314e-02f, -1.29130557e-01f, -6.22939616e-02f, -2.02973690e-02f, -6.71950132e-02f, -6.43991679e-02f,
  -8.28774720e-02f, -3.90981771e-02f, -2.39953417e-02f, 6.96735308e-02f, 2.54732706e-02f, 3.49346176e-02f, -1.09250411e-01f, -1.29387602e-01f, 5.53753823e-02f, 1.78517848e-02f,
  -1.21522091e-01f, 5.97669967e-02f, 1.07889464e-02f, 9.41067562e-02f, -2.76102871e-02f, 1.04892537e-01f, -1.44358173e-01f, -5.12783639e-02f, 5.19811809e-02f, -9.92898569e-02f,
  -8.72768182e-03f, 5.87570900e-03f, -5.22786155e-02f, 2.28521693e-02f, -1.72214191e-02f, -4.35114540e-02f, -3.43714166e-03f, 7.87781850e-02f, 5.31304330e-02f, -4.82149655e-03f,
  1.43696712e-02f, 2.86390930e-02f, -9.95097756e-02f, 4.43379544e-02f, 1.28101483e-02f, -5.43660894e-02f, -4.58919518e-02f, -1.29206209e-02f, -8.45458433e-02f, 1.05967410e-02f,
  6.11675940e-02f, -3.40077356e-02f, -7.17487112e-02f, 2.84602912e-03f, -8.99063423e-03f, -1.75018180e-02f, 1.78563952e-01f, -5.21257147e-02f, -1.44862384e-02f, 7.56925941e-02f,
  -1.53979346e-01f, 9.97293647e-03f, -2.45197676e-02f, -1.71954855e-01f, -3.47030126e-02f, -3.44075300e-02f, 4.22788560e-02f, -4.06050831e-02f, -6.89701438e-02f, -3.35033573e-02f,
  2.69377902e-02f, -1.44063234e-01f, -5.29613951e-03f, -6.68309927e-02f, 1.07076399e-01f, -5.23356125e-02f, -6.40409580e-03f, 1.02287397e-01f, -1.28437996e-01f, -5.28683327e-02f,
  7.20935985e-02f, 2.69832574e-02f, 1.28967585e-02f, -7.37108365e-02f, 1.15254156e-01f, 1.64790545e-02f, -5.09699173e-02f, 1.15857730e-02f, -1.48526775e-02f, 1.14114054e-01f,
  1.11579344e-01f, -3.12165413e-02f, -2.58310914e-01f, 2.30976745e-01f, -1.39931053e-01f, 9.65768006e-03f, 4.00044024e-02f, 1.21778585e-01f, 1.90445200e-01f, -4.91214730e-02f,
  4.79480391e-03f, 1.09413952e-01f, 9.67643484e-02f, 3.80112492e-02f, 8.40973035e-02f, -8.77899490e-03f, -1.13899603e-01f, 2.46211495e-02f, -1.36056570e-02f, 4.49602539e-03f,
  1.28241330e-01f, 1.18123785e-01f, 7.96462521e-02f, 7.41663799e-02f, -1.15580127e-01f, -3.48132327e-02f, -2.27777451e-01f, -1.19906962e-01f, -1.83034152e-01f, -2.42761970e-01f,
  -2.03810677e-01f, -1.77321404e-01f, -3.46998349e-02f, 5.54459430e-02f, -1.82462543e-01f, -3.50853205e-02f, -4.47438620e-02f, -9.69517305e-02f, 1.17435560e-01f, 5.17503498e-03f,
  -3.74909267e-02f, 7.65715688e-02f, 5.56179918e-02f, -3.03875525e-02f, -1.28086448e-01f, 3.97000946e-02f, 1.53230634e-02f, -1.66713521e-02f, 7.05507845e-02f, -8.32711533e-02f,
  2.13085823e-02f, -5.93348891e-02f, -1.59301534e-01f, -2.55704150e-02f, -5.87509526e-03f, 5.07891066e-02f, -4.74578477e-02f, -1.54025108e-01f, -1.70803741e-01f, -2.13557199e-01f,
  1.72902644e-02f, -4.45597582e-02f, -5.43972179e-02f, -4.80321087e-02f, 2.68506203e-02f, 6.66047782e-02f, -8.07146803e-02f, -6.33659586e-03f, 1.08198379e-03f, 1.19293304e-02f,
  -1.77729614e-02f, 2.17910074e-02f, 1.55122019e-02f, 1.70639493e-02f, 4.28770781e-02f, -3.02108936e-02f, 2.17093863e-02f, 3.73754986e-02f, -3.90866362e-02f, 5.37095638e-03f,
  -9.83981136e-03f, -7.53768208e-03f, -4.89870347e-02f, 1.36668645e-02f, 3.43014649e-03f, 8.02232767e-04f, 1.81288868e-02f, -2.61588618e-02f, 4.07467559e-02f, -1.03954840e-02f,
  2.18852535e-01f, 1.18069572e-03f, -2.90884096e-02f, 6.43509403e-02f, -3.66181023e-02f, -9.70855542e-03f, 4.14994247e-02f, -1.17751416e-02f, -4.21505012e-02f, -1.65869091e-02f,
  1.20468671e-02f, 7.61641935e-03f, -5.29986918e-02f, -9.17949975e-02f, -9.18642431e-03f, 8.09999630e-02f, -8.16869661e-02f, 8.14773366e-02f, -1.96375549e-02f, 4.47748639e-02f,
  2.35122144e-02f, 2.92875376e-02f, 8.90230909e-02f, -3.21961800e-03f, 4.41250727e-02f, 1.50175169e-01f, -2.32563657e-03f, -4.30511013e-02f, 8.22098032e-02f, -6.13205917e-02f,
  2.20490411e-01f, 2.17768833e-01f, 1.57884523e-01f, -1.33314401e-01f, 1.30871609e-01f, 2.83866487e-02f, 1.30653679e-01f, 5.55664022e-03f, -8.87564868e-02f, 1.57240912e-01f,
  7.32062012e-02f, -2.81850457e-01f, -1.67869359e-01f, -1.24474756e-01f, -2.24827319e-01f, 8.08794871e-02f, -1.26958027e-01f, -1.01148933e-01f, -2.49607071e-01f, -2.28090771e-02f,
  -1.33315831e-01f, -8.64387527e-02f, -8.60300753e-03f, -5.37034348e-02f, 2.84277704e-02f, -3.09552014e-01f, 6.98785782e-02f, -4.04070616e-02f, -5.60332574e-02f, 4.21910919e-02f,
  -1.22634426e-03f, 2.02230215e-01f, -1.83538012e-02f, -1.76154952e-02f, -1.11238353e-01f, 6.08945675e-02f, -9.74751357e-03f, 3.02098151e-02f, 1.15236500e-02f, 6.03922419e-02f,
  6.27427921e-02f, 5.88287041e-02f, 6.31936416e-02f, 3.39391343e-02f, -9.67874452e-02f, 7.86640588e-03f, 5.31407669e-02f, -4.94723059e-02f, -9.86784548e-02f, -2.36298181e-02f,
  -3.21226828e-02f, -4.34171818e-02f, -1.91949476e-02f, -2.85133626e-02f, -2.68118619e-03f, -1.35118946e-01f, 4.08176668e-02f, -2.46546939e-02f, -2.28514499e-03f, 4.23016362e-02f,
  5.46838716e-03f, -4.83639985e-02f, 2.80299075e-02f, 1.33838933e-02f, -9.80503901e-05f, 2.16454454e-02f, -5.18327244e-02f, -5.36882579e-02f, -3.09974491e-03f, -5.07071652e-02f,
  2.24716752e-03f, -3.53206918e-02f, 1.77682061e-02f, 1.33892938e-01f, -5.61104305e-02f, 7.47754995e-04f, 2.09856480e-02f, -1.25887543e-02f, -3.68114747e-02f, 9.52502713e-04f,
  -5.97598888e-02f, 1.59558859e-02f, -2.55019069e-02f, -1.51279205e-02f, 4.71228510e-02f, -3.77976187e-02f, 9.45563391e-02f, 2.93601048e-03f, 4.71134484e-02f, -2.47377213e-02f,
  4.69166925e-03f, -1.09709233e-01f, 5.93075044e-02f, 6.77121282e-02f, -3.02981809e-02f, -6.59122914e-02f, 1.09454012e-02f, 6.51816726e-02f, 6.84643909e-02f, -2.60807481e-03f,
  2.49335486e-02f, -1.44649157e-02f, 2.76957708e-03f, -3.58577780e-02f, -8.75516385e-02f, 1.16884466e-02f, -8.83085802e-02f, 4.99682836e-02f, -3.63099650e-02f, -1.41869429e-02f,
  -5.56673761e-03f, 3.30383964e-02f, -1.07124755e-02f, -3.06898113e-02f, 1.46201821e-02f, -9.52965841e-02f, -5.72114810e-02f, -1.31220400e-01f, -6.23774379e-02f, -3.93153727e-02f,
  3.24443489e-01f, -3.95950347e-01f, 2.30388299e-01f, -2.24889785e-01f, 3.50436196e-02f, 3.28292847e-01f, 1.77538648e-01f, -1.07836369e-02f, 1.98484864e-02f, -1.47747725e-01f,
  -1.51474923e-01f, -4.87430468e-02f, 4.77008447e-02f, -6.60812780e-02f, 7.51155615e-02f, 1.29431754e-01f, 1.06449630e-02f, 1.33790836e-01f, 3.39099914e-01f, 1.66700229e-01f,
  -2.02468827e-01f, -2.58442312e-01f, -2.43188381e-01f, -9.84374434e-02f, 6.11598091e-03f, 2.28784814e-01f, -2.28668679e-03f, -1.47808075e-01f, 1.10346302e-02f, 6.42176867e-02f,
  2.25289047e-01f, -2.05906425e-02f, 2.48623386e-01f, -8.47059041e-02f, -4.77910191e-02f, 7.51350299e-02f, 1.28506064e-01f, 2.14845426e-02f, -2.07178108e-02f, -5.08463793e-02f,
  2.74100881e-02f, -5.37461825e-02f, 7.52023607e-02f, -1.01700358e-01f, 4.86063622e-02f, 4.22462411e-02f, -1.03104495e-01f, -1.32362908e-02f, 1.22576524e-02f, 1.59059577e-02f,
  -1.33226693e-01f, -2.41040234e-02f, 1.33075878e-01f, -4.15882133e-02f, 2.42067017e-02f, -5.92780933e-02f, -7.27931932e-02f, 3.37596051e-02f, 9.03422758e-02f, 1.31093264e-01f,
  -2.13546976e-02f, -2.35078018e-03f, 4.76702265e-02f, -8.30504522e-02f, -1.44512514e-02f, 6.67422265e-02f, -1.06684286e-02f, 8.82307887e-02f, -1.36450768e-01f, -1.59018654e-02f,
  -5.32203838e-02f, -9.85273942e-02f, 2.65181400e-02f, 2.78468430e-02f, -5.04852086e-02f, -7.28190551e-03f, 1.36754811e-01f, -6.39440790e-02f, -9.49362218e-02f, 1.98198445e-02f,
  3.92149389e-02f, 6.20052628e-02f, 6.73763677e-02f, -5.60214184e-03f, -1.10625751e-01f, -5.49823530e-02f, -6.52585700e-02f, -2.60024588e-03f, 4.38188668e-03f, -1.07231177e-01f,
  2.14408278e-01f, 3.43554914e-02f, 4.19187397e-02f, 4.08281907e-02f, 1.19161293e-01f, 4.56922501e-02f, -5.80470338e-02f, 8.83939639e-02f, -2.80991215e-02f, 1.89946722e-02f,
  9.05181170e-02f, -1.37927467e-02f, 3.23183946e-02f, -7.95302261e-03f, 4.73888591e-03f, 2.42642779e-02f, -1.33549765e-01f, 1.40241340e-01f, -2.58803535e-02f, 5.58295846e-02f,
  -1.57909006e-01f, 1.43596590e-01f, 2.79610634e-01f, 2.19596475e-01f, 5.27048036e-02f, 2.52599627e-01f, 1.89391360e-01f, 8.97853300e-02f, 2.33359113e-01f, 1.12662181e-01f,
  -7.03991771e-01f, 2.52313584e-01f, -2.87454754e-01f, -7.29265739e-04f, 5.57186343e-02f, 9.01299790e-02f, 1.82706699e-01f, 9.03288350e-02f, 7.08471239e-02f, -1.01087049e-01f,
  -3.62279564e-02f, -8.03962424e-02f, 7.14662224e-02f, 9.27343220e-02f, 1.23085789e-01f, 2.36927439e-02f, 3.02759826e-01f, -4.65631522e-02f, -4.06061672e-02f, 6.46481961e-02f,
  1.69334218e-01f, -1.03188939e-02f, -1.30917385e-01f, -8.63887742e-02f, 1.09554566e-02f, -1.65732175e-01f, 8.68719295e-02f, -1.02588713e-01f, -1.38960212e-01f, 2.11305782e-01f,
  -4.58287030e-01f, -1.45293847e-01f, 7.14830384e-02f, -6.75417632e-02f, 1.99772287e-02f, -7.53987134e-02f, -1.37177866e-03f, -1.12308087e-02f, 5.56810498e-02f, -1.01919495e-01f,
  9.09364969e-02f, -2.66468357e-02f, 6.91276342e-02f, -3.75664383e-02f, -4.56171595e-02f, -2.57068407e-02f, -3.41063254e-02f, -7.33646005e-02f, -8.78903735e-03f, 3.48371565e-02f,
  1.78646013e-01f, -3.62002291e-02f, -7.32274130e-02f, 4.24817950e-02f, -1.66557524e-02f, -2.35427767e-02f, 5.49571961e-02f, -7.34623969e-02f, 7.17174681e-03f, 3.16787176e-02f,
  3.97172235e-02f, 7.28065707e-03f, -3.94462086e-02f, -2.59209331e-02f, 3.18653844e-02f, -4.27924730e-02f, 1.99136920e-02f, 7.02180117e-02f, 3.34801078e-02f, -1.13468859e-02f,
  1.07569704e-02f, 8.90597049e-03f, -5.59430942e-02f, -2.92169396e-02f, -2.26764251e-02f, 8.17098171e-02f, 2.68292632e-02f, -9.03207902e-03f, -7.03742821e-03f, 2.56570484e-02f,
  2.79957391e-02f, 6.43072352e-02f, -4.02211910e-03f, -1.81006491e-02f, 7.43549084e-03f, 4.15416583e-02f, -3.33784916e-03f, -5.10763824e-02f, -3.90396863e-02f, -7.13101923e-02f,
  -5.72884753e-02f, -1.55721884e-02f, -2.40214709e-02f, 3.63574475e-02f, 2.59485971e-02f, 1.65710002e-02f, 4.26031053e-02f, -1.24798514e-01f, -1.77434944e-02f, -1.75355021e-02f,
  1.34329516e-02f, 2.14540195e-02f, -2.93935649e-02f, -5.01810275e-02f, 4.91258316e-03f, -4.39943862e-04f, 1.04098231e-01f, 3.92241254e-02f, 8.51925761e-02f, -4.48282659e-02f,
  6.92719743e-02f, 9.64565501e-02f, 6.71903789e-03f, 1.54885978e-01f, 4.36271541e-02f, 3.45635377e-02f, -1.05278932e-01f, -7.24651590e-02f, -4.47451696e-02f, -4.11406271e-02f,
  6.93953261e-02f, 5.37419260e-01f, 1.22748762e-01f, 2.51515299e-01f, 1.81659862e-01f, 1.55824363e-01f, 4.17565018e-01f, 3.11824381e-01f, -2.47265771e-01f, 1.41541213e-01f,
  1.35857150e-01f, -1.58597082e-01f, -6.96940199e-02f, -2.93037333e-02f, 2.06669867e-01f, 2.77273148e-01f, 1.89944819e-01f, 1.41309664e-01f, -8.09397921e-02f, -8.15827549e-02f,
  3.38398069e-02f, 2.11786315e-01f, -4.54068911e-04f, 3.90503630e-02f, 1.27900555e-03f, -2.39382133e-01f, 1.02297060e-01f, 1.67774975e-01f, 2.97337081e-02f, -1.34511692e-02f,
  -1.62420630e-01f, 3.37590218e-01f, -1.04132712e-01f, -1.52986646e-02f, 3.44916172e-02f, 2.91634593e-02f, 3.95694152e-02f, 4.31459807e-02f, -2.45507304e-02f, 2.05443054e-02f,
  -1.32426834e-02f, -5.62473834e-02f, 1.65696945e-02f, -8.74743331e-03f, 1.56488553e-01f, 9.51224938e-02f, 1.21137397e-02f, 1.60498515e-01f, -3.76101360e-02f, -1.38088256e-01f,
  6.89476654e-02f, -4.27759252e-02f, 1.49530917e-01f, 1.37501031e-01f, 9.58347619e-02f, -2.89105382e-02f, 9.25577581e-02f, -8.37982893e-02f, 9.85259935e-02f, 4.54406515e-02f,
  -5.03027812e-02f, 4.32232991e-02f, -1.14114294e-02f, 6.66112453e-02f, -1.16974032e-02f, -8.78277197e-02f, 3.43003869e-02f, 3.60024790e-03f, 8.22760910e-03f, 6.89562485e-02f,
  -4.39484641e-02f, -3.24532911e-02f, -1.62855927e-02f, 7.49631599e-02f, -6.73323572e-02f, 7.86406267e-03f, 1.53808314e-02f, 7.24063143e-02f, -3.66849080e-02f, -3.71053070e-02f,
  7.04291686e-02f, -5.02534248e-02f, 8.76098685e-03f, 6.25706092e-02f, -4.47788835e-02f, 3.36720943e-02f, -3.16697359e-02f, 2.02845298e-02f, 3.99545878e-02f, -1.77027006e-02f,
  -4.12248746e-02f, 9.51669272e-03f, -1.04449272e-01f, -2.10513119e-02f, -3.75843234e-02f, -1.17036186e-01f, 2.40110289e-02f, -6.40049428e-02f, -2.30094232e-02f, 3.49019021e-02f,
  1.26543464e-02f, 3.17887291e-02f, -4.93422616e-03f, -3.18848006e-02f, -7.46788234e-02f, 3.46675180e-02f, -5.95218316e-02f, 1.82642471e-02f, -1.76657643e-02f, -3.76733877e-02f,
  -1.46406679e-03f, -8.58787447e-02f, -1.26130506e-01f, -5.69858998e-02f, -6.68124063e-03f, 2.21530907e-02f, 6.97678328e-02f, -5.58395945e-02f, 1.39183542e-02f, -7.72364363e-02f,
  3.87229711e-01f, -2.91789733e-02f, -5.20268619e-01f, 2.26984084e-01f, -2.54745454e-01f, -1.14749990e-01f, -1.16869278e-01f, 8.86974707e-02f, 1.22092195e-01f, -1.00998335e-01f,
  -3.45714651e-02f, -1.68505535e-02f, -8.54271129e-02f, -5.79649024e-02f, -6.18303828e-02f, -1.83388978e-01f, -2.04393953e-01f, -2.73482442e-01f, -5.31285666e-02f, -1.29209071e-01f,
  -1.19094595e-01f, -1.44682648e-02f, 9.53942016e-02f, 1.08669199e-01f, -1.60020739e-01f, -8.66840482e-02f, -1.73279956e-01f, -3.15401629e-02f, -1.26332760e-01f, -1.98724613e-01f,
  -3.68613333e-01f, 1.37604505e-01f, 7.67880753e-02f, -8.13460560e-04f, -6.40614033e-02f, 1.48956642e-01f, 1.79088619e-02f, 5.71040399e-02f, -8.43964890e-03f, -4.29578982e-02f,
  3.96255478e-02f, -1.11479439e-01f, -1.75220110e-02f, 1.67927425e-02f, 4.92768474e-02f, -3.43721211e-02f, 1.12356082e-01f, -7.48880357e-02f, -8.27358291e-02f, -3.38909030e-02f,
  -9.66089442e-02f, -7.78515190e-02f, 8.31370614e-03f, 4.86454479e-02f, -3.85497883e-02f, -1.27606660e-01f, 3.11056804e-02f, 4.44795229e-02f, 6.93815276e-02f, 1.80273339e-01f,
  -2.51091998e-02f, -3.39960903e-02f, 2.07494348e-02f, 6.15083128e-02f, 4.80543729e-03f, 1.05400775e-02f, -1.61296315e-02f, -1.00584490e-04f, 1.73348710e-02f, -7.74693638e-02f,
  3.56308781e-02f, -2.68323142e-02f, -5.55998739e-03f, 7.41666332e-02f, -6.67503551e-02f, 5.57921128e-04f, 4.14865874e-02f, -7.01869056e-02f, 5.23759797e-02f, -4.55715897e-04f,
  -8.95536097e-04f, 2.02789251e-02f, 3.13712433e-02f, 2.68852357e-02f, -7.50509501e-02f, -5.58020510e-02f, 2.59975065e-02f, 3.41467299e-02f, 5.35530671e-02f, -9.90996137e-02f,
  1.68791741e-01f, 5.69794187e-03f, 2.29476709e-02f, 1.70691703e-02f, 5.81297837e-02f, -8.92343819e-02f, -3.14352699e-02f, 8.47797766e-02f, 5.07379770e-02f, 4.19667214e-02f,
  6.88653765e-03f, 2.10238434e-02f, -9.13136266e-03f, 3.26397903e-02f, -7.61307264e-03f, -5.72685041e-02f, -3.98716889e-02f, 6.34540012e-03f, 4.22068201e-02f, -5.21984696e-02f,
  -3.12051661e-02f, 1.43914461e-01f, 1.18728973e-01f, 1.05972871e-01f, 7.66431317e-02f, -6.39971718e-02f, 6.73552323e-03f, -3.96623686e-02f, -1.70056242e-02f, 2.06814334e-01f,
  4.27120626e-01f, -1.79285243e-01f, 3.39372195e-02f, -3.07028964e-02f, -4.79697548e-02f, 1.34454025e-02f, 4.96701635e-02f, -2.20187418e-02f, 9.45266783e-02f, -1.51869595e-01f,
  -1.44656599e-01f, 3.64332721e-02f, -8.27220976e-02f, -8.13185349e-02f, 3.31242569e-02f, 1.50835693e-01f, 6.65509924e-02f, 1.29310593e-01f, 1.24854639e-01f, -3.69470902e-02f,
  -8.60029459e-02f, -7.37684593e-02f, 5.44365272e-02f, 4.70691845e-02f, -1.16374798e-01f, 5.90528920e-02f, -1.57183915e-01f, -7.92113543e-02f, -3.37141529e-02f, -6.04094788e-02f,
  -2.04822406e-01f, -1.05233729e-01f, -7.05188289e-02f, -1.11324146e-01f, -1.35823742e-01f, 7.18809664e-02f, 1.06816953e-02f, -3.57345864e-02f, 7.68509209e-02f, -1.43491453e-03f,
  6.68219626e-02f, -1.94657296e-02f, 2.05381513e-02f, -7.23483711e-02f, -1.79654136e-02f, -2.04726867e-02f, 7.86777884e-02f, -1.44197224e-02f, -3.33498083e-02f, -1.91241458e-01f,
  -1.08399810e-02f, -3.82135995e-02f, 2.59153191e-02f, -6.87818602e-02f, 3.58621962e-02f, -2.24789158e-02f, -7.68943503e-02f, -7.66177252e-02f, 5.24668582e-03f, -4.99212034e-02f,
  8.59421492e-03f, 2.08269432e-02f, 2.47303043e-02f, 3.43963690e-02f, 4.91633564e-02f, -6.05065823e-02f, -2.33523138e-02f, -9.24663693e-02f, 6.96732849e-02f, 3.29299755e-02f,
  1.73844583e-02f, -2.09112037e-02f, 1.49029410e-02f, 8.94417614e-02f, -1.40608057e-01f, 1.87177472e-02f, 2.78666504e-02f, 2.17609536e-02f, -1.33706592e-02f, 5.67541830e-02f,
  1.54284639e-02f, 3.49487066e-02f, -4.01189625e-02f, -3.49768214e-02f, -1.31230317e-02f, 2.40917001e-02f, 3.96661200e-02f, -3.00689247e-02f, -2.88068485e-02f, 5.81341721e-02f,
  -8.85303691e-02f, 4.05588076e-02f, 4.43494059e-02f, 1.16342999e-01f, -2.27972269e-02f, -3.59781794e-02f, -6.12030178e-02f, -7.25080818e-02f, 5.02520651e-02f, -2.12574136e-02f,
  -2.22368985e-02f, 3.23040634e-02f, -3.12749273e-03f, -2.03208756e-02f, -3.07258237e-02f, 8.78725946e-02f, -2.05496382e-02f, 8.50918069e-02f, -3.61685129e-03f, -2.76179947e-02f,
  3.28487791e-02f, 1.24558046e-01f, 1.72904417e-01f, 8.61209854e-02f, -2.66480595e-02f, 8.77723470e-02f, -3.02090142e-02f, 2.93217022e-02f, 2.23176777e-01f, 1.80881470e-01f,
  2.70770669e-01f, 3.04404676e-01f, -4.33917763e-03f, 2.65301883e-01f, 1.95207343e-01f, -6.53252974e-02f, 2.11995438e-01f, 1.67235062e-02f, -1.15714874e-02f, 4.03082073e-02f,
  -7.70757860e-03f, -2.55043842e-02f, 4.35086191e-02f, -1.19894773e-01f, 6.77324831e-02f, 7.92210847e-02f, 6.52680919e-02f, 9.10925642e-02f, -1.14968963e-01f, 5.64471781e-02f,
  -2.38138419e-02f, 1.76546738e-01f, 3.40557918e-02f, 9.21347514e-02f, 1.73171774e-01f, -1.40260831e-01f, -5.14376126e-02f, 7.01145083e-02f, -7.09373578e-02f, 1.18684925e-01f,
  1.18951602e-02f, 9.15467516e-02f, -8.02768096e-02f, -1.25884444e-01f, -1.04172282e-01f, -9.44245681e-02f, -7.89518952e-02f, -8.91321599e-02f, -5.41600585e-02f, -7.30123296e-02f,
  -3.84350345e-02f, -1.10303983e-01f, 1.77020766e-02f, -6.37964457e-02f, 2.52057109e-02f, -1.29741669e-01f, 3.33817154e-02f, -1.86035149e-02f, -8.66346732e-02f, 2.99192616e-03f,
  5.28783798e-02f, 1.48780107e-01f, 1.29037619e-01f, -2.13802587e-02f, -3.80452313e-02f, 7.12881982e-02f, -7.87800830e-03f, -1.55559868e-01f, -1.04105264e-01f, 6.38418421e-02f,
  -2.71247197e-02f, -2.39136051e-02f, -5.34670018e-02f, -3.21925175e-03f, -1.26639055e-02f, 7.69148162e-03f, 7.74400383e-02f, 1.68780554e-02f, 6.34614900e-02f, -1.88995730e-02f,
  -5.11711575e-02f, 4.04543132e-02f, -6.47550523e-02f, 2.18171580e-03f, 1.60719361e-02f, 8.16316344e-03f, 3.83423753e-02f, 4.53350358e-02f, -6.68449849e-02f, -4.47567878e-03f,
  4.68113981e-02f, 5.38154170e-02f, -4.08513620e-02f, 3.97951230e-02f, 1.07952133e-02f, -8.79175309e-03f, -3.45205776e-02f, -8.78324732e-02f, -2.18660086e-02f, -1.08996443e-02f,
  -3.32382917e-02f, -5.86564317e-02f, 1.10498562e-01f, -2.03337464e-02f, -2.78935279e-03f, 3.27621959e-02f, 4.28691246e-02f, -1.06549166e-01f, 3.82728688e-02f, 2.03222930e-02f,
  -1.02310412e-01f, -9.34380200e-03f, 2.41656452e-02f, 3.26260924e-02f, 3.44414189e-02f, -1.03307448e-01f, -5.51639497e-02f, -2.34351819e-03f, 7.88626149e-02f, -3.65637280e-02f,
  3.16862646e-03f, 7.03941360e-02f, 2.27283016e-02f, -2.38560513e-02f, -2.81837657e-02f, 5.09759709e-02f, -3.97545509e-02f, -6.51475713e-02f, -3.37833390e-02f, -1.13494530e-01f,
  2.85192221e-01f, 1.11123420e-01f, 9.79825184e-02f, 2.23914925e-02f, -5.23148812e-02f, 5.71684958e-03f, -1.87638462e-01f, -3.76934893e-02f, -6.19245991e-02f, 2.29427163e-02f,
  -1.16889132e-02f, 6.21551313e-02f, -6.38994500e-02f, 1.94343254e-02f, 7.94442371e-02f, -1.05787441e-01f, -3.75112519e-02f, 1.22368395e-01f, -3.31156515e-02f, -1.94573682e-02f,
  -1.43240001e-02f, 5.16616479e-02f, 8.41127783e-02f, -3.41798998e-02f, 7.34705776e-02f, 4.96351719e-02f, -1.86266340e-02f, 3.23796459e-02f, -5.88884950e-02f, -4.17103386e-03f,
  1.07052967e-01f, 2.46510152e-02f, -1.80647094e-02f, -2.71535665e-02f, 4.12867703e-02f, 5.39944172e-02f, -2.45639007e-03f, 1.10941075e-01f, -8.25654194e-02f, -3.78445573e-02f,
  -6.25464767e-02f, -1.13762571e-02f, 3.76445241e-02f, -1.58412557e-03f, 7.75581691e-03f, 6.42079636e-02f, 1.06964996e-02f, -4.06829827e-02f, 6.63197860e-02f, -4.22290638e-02f,
  -7.18056113e-02f, 2.40899194e-02f, -6.53790962e-03f, -1.26345575e-01f, 9.97042865e-04f, -1.82630066e-02f, 1.68802310e-02f, -7.48020634e-02f, 4.64154333e-02f, -6.18774854e-02f,
  -1.08139075e-01f, 4.63525467e-02f, -4.47480679e-02f, 3.00911837e-03f, 5.18612638e-02f, -1.00852899e-01f, -2.51880959e-02f, 1.67648103e-02f, 5.22996001e-02f, 1.77374016e-02f,
  5.41609526e-02f, 1.15195084e-02f, 7.14019388e-02f, -1.20010069e-02f, 1.34508335e-03f, -2.33794898e-02f, 5.40909432e-02f, -3.95517386e-02f, 4.60079648e-02f, -5.86097687e-02f,
  5.29822521e-02f, -7.50420755e-03f, -4.32712100e-02f, -3.53205912e-02f, -4.74282987e-02f, 5.67006916e-02f, -5.39813861e-02f, -1.93139277e-02f, -4.98532355e-02f, -9.00282897e-03f,
  -6.63725799e-03f, 1.78163815e-02f, -7.19177574e-02f, -4.53629717e-02f, -1.23616522e-02f, 1.35621941e-02f, 3.31516787e-02f, 7.78151304e-02f, 2.97778361e-02f, -1.09717557e-02f,
  -5.36488220e-02f, -1.26261506e-02f, 4.74616326e-03f, -9.44511220e-02f, 2.23730039e-03f, -6.49909005e-02f, -9.95118544e-03f, 4.64613400e-02f, -5.27321710e-04f, -6.94374368e-02f,
  -3.29132229e-02f, -1.35195270e-01f, -1.14225231e-01f, -1.02171369e-01f, 2.05102321e-02f, -2.71283146e-02f, -6.31190836e-02f, -2.12307218e-02f, -6.13467731e-02f, -5.93359768e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -2.70260781e-01f, 2.04302013e-01f, 1.92837238e-01f, 5.83412088e-02f, -9.83919948e-02f, 4.57271785e-02f, 6.86653852e-02f, -1.11345366e-01f, 3.38330716e-01f, 2.28407130e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.52084660e-02f, -8.96800682e-02f, -2.08992839e-01f, 4.93274480e-02f, -1.10982008e-01f, -3.11934590e-01f, -3.12023342e-01f, -1.88295305e-01f, 2.47227505e-01f, -3.42591673e-01f,
  -6.87829033e-02f, 2.02766076e-01f, -1.06205963e-01f, 1.89289615e-01f, 3.71609628e-02f, 2.37283409e-01f, 1.44911140e-01f, -2.43019193e-01f, -2.38927603e-01f, -3.36217642e-01f,
  -3.47241580e-01f, 8.80995095e-02f, -4.39720422e-01f, -2.68388599e-01f, -7.24552795e-02f, -2.70266026e-01f, 3.68305832e-01f, 1.30214021e-01f, 1.28800437e-01f, 9.29985046e-02f,
  3.96882325e-01f, 1.59831643e-01f, -1.46444246e-01f, -3.24733704e-01f, -1.70675144e-01f, 2.78461933e-01f, 2.00382888e-01f, -3.52469049e-02f, -1.89826805e-02f, 4.61616693e-03f,
  -5.84455021e-02f, 2.33927310e-01f, -1.69537082e-01f, -4.98383999e-01f, 3.32872510e-01f, 3.46282631e-01f, 1.75685622e-02f, 3.21665227e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.24804033e-02f, 4.98611212e-01f, 3.62191856e-01f, -3.41833159e-02f, -2.67270077e-02f, -8.81361365e-02f, 1.31176144e-01f, -1.78934202e-01f, -2.21951842e-01f, 1.72242463e-01f,
  -3.59159380e-01f, -3.16338450e-01f, -1.33982420e-01f, 3.51892859e-01f, 6.87831119e-02f, 1.29881248e-01f, -9.50641930e-02f, -2.33747456e-02f, -9.51163843e-02f, -1.39717042e-01f,
  1.18977033e-01f, -5.60973734e-02f, 1.72941700e-01f, 5.41635118e-02f, -1.92579553e-02f, 1.32446662e-01f, 1.72625184e-01f, -2.37463161e-01f, 9.41524804e-02f, 2.09141802e-02f,
  -9.91136730e-02f, -1.53721154e-01f, 3.93590555e-02f, 2.22250894e-01f, -3.01556918e-03f, -2.39516404e-02f, 1.29314318e-01f, 2.19094560e-01f, 3.22642505e-01f, 1.34905308e-01f,
  -2.33850539e-01f, 4.74859923e-01f, -3.14030826e-01f, 3.53565812e-01f, 1.10200055e-01f, 3.21183085e-01f, -1.76185101e-01f, -2.10593045e-01f, 6.05383039e-01f, -1.02769017e-01f,
  5.17900467e-01f, -1.91235051e-01f, 2.09257990e-01f, 2.64691830e-01f, 1.19169183e-01f, 5.56437790e-01f, -1.84056565e-01f, -3.83608282e-01f, 6.06283665e-01f, 3.59562516e-01f,
  5.53379834e-01f, -4.64207344e-02f, 9.97672305e-02f, -7.69564062e-02f, 2.28838816e-01f, 6.26321614e-01f, -1.48188069e-01f, -7.84744978e-01f, 2.61101931e-01f, -2.76087195e-01f,
  -1.50755063e-01f, -2.37792090e-01f, 5.58416285e-02f, -2.20399126e-01f, 3.56836319e-01f, 1.66218191e-01f, -2.87340969e-01f, 1.70948371e-01f, 5.26001096e-01f, 3.89255255e-01f,
  7.71635249e-02f, -2.11424485e-01f, -1.69796079e-01f, 1.96452029e-02f, -2.57720172e-01f, 1.57364711e-01f, 2.25663800e-02f, 1.64495960e-01f, 2.54785597e-01f, 3.86238694e-01f,
  -2.26340536e-03f, -1.76076919e-01f, -1.16017051e-01f, 9.70333070e-02f, -7.94497430e-02f, -7.23424479e-02f, -3.44026178e-01f, -5.73378578e-02f, 2.79970080e-01f, -9.94836241e-02f,
  9.35641453e-02f, 9.05806944e-02f, -2.74294674e-01f, 7.54759982e-02f, -1.39517859e-01f, -2.35788882e-01f, -2.16160759e-01f, -1.04004540e-01f, -2.98736483e-01f, -1.49412736e-01f,
  1.45063043e-01f, 2.80522015e-02f, 6.31517410e-01f, 1.54559776e-01f, 6.32188678e-01f, -1.87996705e-03f, 4.42621142e-01f, 2.11869702e-01f, 8.99997175e-01f, 4.42805588e-01f,
  -3.50434899e-01f, -7.14055449e-02f, -2.59830624e-01f, -1.89507753e-01f, 5.39599657e-01f, 5.36813140e-01f, 1.50081083e-01f, 2.70827472e-01f, 3.64404976e-01f, 5.20382226e-01f,
  2.83955216e-01f, -4.83173966e-01f, 1.04503192e-01f, -2.06542701e-01f, -1.91732422e-01f, 1.79129526e-01f, 4.53254521e-01f, -6.72634542e-01f, 4.49312538e-01f, 6.96189761e-01f,
  -5.93268722e-02f, -2.66601115e-01f, 5.15746236e-01f, 1.23887649e-03f, 2.57686436e-01f, -1.23878479e-01f, -1.02037797e-02f, 1.14037812e-01f, -2.14216337e-01f, -1.83495432e-01f,
  -1.09796546e-01f, 1.99020669e-01f, 4.20184940e-01f, -5.25240637e-02f, -1.57588080e-01f, -1.42235458e-01f, 6.27965450e-01f, 1.10594593e-01f, -7.98532814e-02f, 2.58309823e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.38458389e-01f, -1.37619689e-01f, 1.63937956e-01f, -4.37729433e-02f, 3.44019145e-01f, 1.62986785e-01f, 2.57019371e-01f, 3.36126119e-01f, 1.33946866e-01f, 1.72892287e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.87062466e-01f, -1.76982973e-02f, -2.95903027e-01f, 1.71996862e-01f, 4.32805330e-01f, 1.68135494e-01f, -5.06021559e-01f, 6.92407414e-02f, -4.43953931e-01f, 2.13526651e-01f,
  1.58040002e-01f, -1.78163543e-01f, -3.05891603e-01f, -4.12432879e-01f, 5.36120057e-01f, 1.84558719e-01f, -2.11140537e-03f, 1.64828464e-01f, -4.09297734e-01f, -7.25558400e-02f,
  7.75647387e-02f, -3.59818518e-01f, -4.34895098e-01f, 1.25321835e-01f, -1.82922840e-01f, 3.57511103e-01f, 1.57417461e-01f, -3.58797684e-02f, -4.31086808e-01f, -6.46791816e-01f,
  5.13565540e-01f, 1.47213712e-01f, 5.08332439e-02f, 2.59049207e-01f, 2.27826476e-01f, -2.02550799e-01f, -3.98842394e-01f, 1.06284730e-01f, 4.45658565e-01f, -1.49399266e-01f,
  3.66644233e-01f, -2.36766085e-01f, -2.21330032e-01f, 1.19242027e-01f, 2.00786695e-01f, 5.00413775e-01f, -2.50725478e-01f, -2.47247905e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.86428219e-01f, -7.30893239e-02f, -2.19765469e-01f, 6.36064410e-02f, 6.84499741e-02f, -9.71973538e-02f, -2.17977405e-01f, -8.20242986e-02f, -2.09258288e-01f, 4.74170417e-01f,
  3.39188516e-01f, -2.06456885e-01f, 5.47326542e-02f, 8.04562941e-02f, 2.67256498e-01f, -2.10492879e-01f, 5.47655940e-01f, 6.91521883e-01f, 1.78854167e-01f, 2.96988457e-01f,
  5.93963623e-01f, -4.97882515e-01f, 4.43659604e-01f, 1.89721212e-01f, -1.47579059e-01f, -3.01353008e-01f, 1.18360603e+00f, -2.33381703e-01f, 4.81004901e-02f, -1.85112551e-01f,
  9.27433252e-01f, -2.06414074e-01f, -1.87129602e-01f, 2.25967571e-01f, -1.15550332e-01f, 2.18410775e-01f, -2.43980326e-02f, -1.23920269e-01f, -2.17556298e-01f, -6.89887032e-02f,
  -2.93163694e-02f, 4.17328021e-03f, -1.90539420e-01f, -7.69762471e-02f, 2.24743471e-01f, -2.07429036e-01f, 3.43706131e-01f, -4.64235991e-02f, -2.32889235e-01f, 3.61594260e-02f,
  -3.32900792e-01f, -2.80275457e-02f, 2.95255650e-02f, -2.72087604e-01f, 1.58017650e-01f, -1.96226418e-01f, 8.98937210e-02f, 1.13369085e-01f, 4.16247100e-01f, 8.22423622e-02f,
  -1.08684719e-01f, 8.95777643e-02f, 2.82916456e-01f, -1.33585408e-02f, -2.81770736e-01f, 8.14022869e-03f, -9.28434059e-02f, 2.38438338e-01f, 2.47969002e-01f, 9.33307856e-02f,
  -2.03619003e-01f, 2.36781523e-01f, 4.66864467e-01f, -7.62654245e-02f, 1.77488327e-02f, 1.71627849e-01f, -2.13290062e-02f, -1.05528302e-01f, 4.89195548e-02f, -1.56438440e-01f,
  -3.87594141e-02f, -1.77511275e-01f, -2.32829720e-01f, -8.95116106e-02f, 9.67242271e-02f, -1.15896277e-01f, 3.79816554e-02f, 7.04591721e-02f, -2.15110183e-01f, 2.54258454e-01f,
  -2.12080732e-01f, 1.00673854e-01f, -1.65844724e-01f, -1.75282612e-01f, -1.20931074e-01f, 5.55558614e-02f, 4.02974755e-01f, 5.47909290e-02f, -1.40448049e-01f, -4.55461532e-01f,
  -6.36072978e-02f, 1.27107486e-01f, -1.22106887e-01f, -1.74734801e-01f, -1.50932014e-01f, 1.03770137e+00f, -1.58262938e-01f, -3.69962722e-01f, 1.56434804e-01f, 1.06821740e+00f,
  1.29883930e-01f, 6.72887444e-01f, -5.22279777e-02f, -2.98447281e-01f, -2.64607131e-01f, -2.65771318e-02f, -8.40942487e-02f, -1.66166812e-01f, 1.53678507e-01f, 9.05022398e-02f,
  3.58263463e-01f, 4.54271227e-01f, -8.37131217e-02f, -2.79938132e-01f, -3.28390300e-01f, 8.26527357e-01f, 3.51787776e-01f, -1.46336034e-01f, -1.60996228e-01f, -5.14646843e-02f,
  -4.52872738e-02f, 1.70016646e-01f, -1.83348745e-01f, -1.97728500e-01f, -2.27982372e-01f, 9.57642421e-02f, 2.20885277e-01f, -9.57945585e-02f, 2.47098431e-02f, -6.62708580e-02f,
  5.32734245e-02f, -1.30663648e-01f, -1.93740129e-01f, -7.38306120e-02f, 8.16674829e-02f, 1.11125685e-01f, -3.25736851e-02f, -2.23040491e-01f, 8.50455388e-02f, -2.09330127e-01f,
  -5.50578069e-03f, 2.37260342e-01f, 2.42901355e-01f, 1.62634090e-01f, 4.39745605e-01f, -2.98890203e-01f, 6.39760494e-02f, 2.49691039e-01f, 6.70103669e-01f, -3.13204348e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -7.49266371e-02f, 6.33991122e-01f, -4.09353115e-02f, -3.33779156e-02f, -1.58796925e-02f, 1.72688931e-01f, 3.59368980e-01f, -2.89835840e-01f, 3.12046817e-04f, -1.37962893e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -5.97384036e-01f, -1.51363105e-01f, -5.76018035e-01f, -4.27317113e-01f, -3.96526277e-01f, 4.28798735e-01f, 4.91765514e-02f, -4.05742228e-01f, -2.81105250e-01f, -1.58490762e-01f,
  1.94948334e-02f, -5.66714890e-02f, 3.29821020e-01f, 4.78628576e-02f, -1.75011791e-02f, 9.63639319e-02f, 3.92807508e-03f, 5.16111255e-01f, 2.20768943e-01f, -6.84745491e-01f,
  -4.72716570e-01f, 5.88898838e-01f, -1.57057658e-01f, -1.94654390e-01f, -4.68581133e-02f, -1.94799706e-01f, -2.76275992e-01f, 9.41247120e-02f, 4.54740882e-01f, -2.65565455e-01f,
  -9.94655713e-02f, -7.82685950e-02f, -1.35112107e-01f, -2.82536507e-01f, -5.14003992e-01f, -2.03047395e-01f, -3.97662580e-01f, 9.07919370e-03f, 2.28210360e-01f, -5.34811497e-01f,
  1.25095561e-01f, 2.02216446e-01f, 1.14959501e-01f, 1.49101660e-01f, 3.75258535e-01f, 2.35425070e-01f, -2.04261690e-01f, -1.56219810e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.92737007e-01f, -1.03221260e-01f, -1.89613655e-01f, -2.94764042e-02f, -9.28742588e-02f, -2.41663441e-01f, 8.74168426e-02f, 6.74831793e-02f, -8.51821899e-03f, 2.43372902e-01f,
  9.10749510e-02f, 1.86388671e-01f, -1.80817634e-01f, -2.93098167e-02f, -5.89406639e-02f, 1.25305891e-01f, 5.95242262e-01f, 5.20099342e-01f, 3.10796589e-01f, -1.43208340e-01f,
  2.69943267e-01f, -1.66047096e-01f, -2.23590016e-01f, 9.45410728e-01f, -1.38991028e-01f, -4.15248051e-02f, -2.39197034e-02f, -1.66483343e-01f, -1.13546260e-01f, -3.93315524e-01f,
  -2.04471573e-01f, 1.38433948e-02f, -7.54352450e-01f, -9.62548852e-01f, -8.33561540e-01f, 2.08589524e-01f, -2.71585882e-01f, 4.41300869e-02f, 3.66388589e-01f, 4.02527869e-01f,
  6.86411411e-02f, 2.31071159e-01f, -4.35906261e-01f, 1.99116081e-01f, 1.06042528e+00f, 1.03528595e+00f, 1.20311882e-02f, 5.40182829e-01f, 1.53707266e+00f, 1.19807875e+00f,
  1.08744204e+00f, -6.06964946e-01f, -5.06414652e-01f, 9.59102690e-01f, -3.07495475e-01f, 1.09631643e-01f, 1.09546192e-01f, -3.80475223e-01f, 3.30716640e-01f, -1.17273524e-01f,
  9.58876133e-01f, -3.03129673e-01f, 2.16090217e-01f, -1.58813745e-01f, -3.47303927e-01f, -7.37088770e-02f, -2.02718183e-01f, -6.45728886e-01f, -8.38837326e-01f, 7.60746241e-01f,
  -1.27511516e-01f, -1.96209088e-01f, -1.24813810e-01f, 1.00668363e-01f, 1.48585439e-02f, -1.15254194e-01f, 3.14507931e-01f, 5.24094999e-02f, 1.62495106e-01f, 1.09162576e-01f,
  3.42699856e-01f, 3.34482759e-01f, 2.54565984e-01f, 2.68596232e-01f, 1.59592599e-01f, -1.50213167e-01f, -2.25613892e-01f, 7.09432840e-01f, -1.99235499e-01f, 1.78828448e-01f,
  1.18373886e-01f, 2.02955261e-01f, -6.36059046e-01f, -3.12577039e-01f, -1.55415982e-01f, 2.86120772e-01f, 1.54822826e-01f, -5.93663342e-02f, 3.44859332e-01f, 5.45309961e-01f,
  4.63052958e-01f, -5.56812286e-01f, 1.59365520e-01f, 1.52860320e+00f, 1.35412455e-01f, 3.96243125e-01f, 5.57332821e-02f, 1.56594604e-01f, -5.16998470e-01f, -9.75253955e-02f,
  1.66521952e-01f, 6.22213364e-01f, 6.44757152e-02f, 8.72875229e-02f, -2.61615574e-01f, -7.57273100e-03f, 5.37739135e-02f, -1.66502789e-01f, 3.74347240e-01f, -1.59981474e-01f,
  -8.79198611e-02f, 2.68124789e-01f, 9.16489884e-02f, 1.23813033e-01f, -2.06140921e-01f, 1.06430613e-01f, -1.64961487e-01f, 4.23969984e-01f, -2.25535706e-01f, -9.95180830e-02f,
  -1.84125304e-01f, 1.55911133e-01f, 1.24831693e-02f, -1.91670120e-01f, 3.33441570e-02f, 4.10062820e-01f, -1.35257930e-01f, 4.70021516e-02f, 1.34613113e-02f, -2.49509111e-01f,
  -2.36607864e-01f, -9.31022465e-02f, -9.52804536e-02f, 5.65832108e-03f, -1.91955820e-01f, -1.23372033e-01f, -6.06127689e-03f, 7.74811059e-02f, -2.78639078e-01f, -1.17035106e-01f,
  2.35651463e-01f, 9.14314315e-02f, -8.52670893e-02f, -2.28930831e-01f, 1.67449310e-01f, -1.84137821e-01f, -2.31160261e-02f, -1.92433491e-01f, 9.77681503e-02f, -5.18634059e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  -2.45885804e-01f, 1.19321093e-01f, -3.46243083e-02f, 9.21340764e-01f, 4.97156829e-02f, -4.82112058e-02f, 2.60550499e-01f, -6.66338876e-02f, 1.74032211e-01f, -2.43076757e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.18624282e-01f, -7.31053576e-02f, -2.35008433e-01f, 9.37201083e-01f, -3.09346437e-01f, 9.64743435e-01f, 2.16803014e-01f, -5.90842664e-01f, -3.53700668e-01f, 1.26548052e+00f,
  1.09336153e-01f, -5.02265871e-01f, -6.60439193e-01f, 1.76754013e-01f, 1.85674548e-01f, 2.42101416e-01f, 6.92594200e-02f, -3.64602059e-01f, 2.03516781e-01f, -1.08357199e-01f,
  4.46055353e-01f, -3.27128261e-01f, 4.76242714e-02f, -4.91652697e-01f, 9.08478320e-01f, -6.52321994e-01f, 3.79590571e-01f, -1.15807988e-01f, -2.06225365e-01f, 2.53374636e-01f,
  -2.39809424e-01f, 1.81025460e-01f, 3.27816546e-01f, 3.54221106e-01f, -1.42755672e-01f, -6.79288149e-01f, 2.70874709e-01f, -8.90965104e-01f, 1.91845253e-01f, 5.91049135e-01f,
  -6.31190017e-02f, 4.02793914e-01f, -7.26335719e-02f, 2.11440518e-01f, 2.23368973e-01f, -1.47071406e-01f, 1.60629265e-02f, 2.03002959e-01f, 9.67066407e-01f, 4.57870871e-01f,
  7.63612807e-01f, -7.31598914e-01f, 7.00463831e-01f, -9.18010056e-01f, -6.13231473e-02f, 5.47938824e-01f, -1.14066422e+00f, 1.14389491e+00f, -5.15568554e-01f, -1.26813680e-01f,
  -1.23168357e-01f, -2.29581654e-01f, 3.27283591e-02f, 1.88118890e-01f, 1.07070124e+00f, -6.50028046e-03f, 1.26386631e+00f, 6.48252666e-02f, 6.58392608e-01f, 5.46346307e-01f,
  2.00844958e-01f, 1.89713418e-01f, -6.86423361e-01f, 1.40496612e+00f, 1.86873302e-02f, -3.96144986e-01f, -1.05184400e+00f, -2.73249522e-02f, 1.87355518e-01f, 2.34709695e-01f,
  -2.20176503e-01f, -1.48557693e-01f, -5.10013580e-01f, 1.75329357e-01f, -1.86381266e-01f, -5.14618419e-02f, 8.73639882e-02f, -2.57444531e-01f, 3.72301012e-01f, 4.91256475e-01f,
  3.53811949e-01f, -5.29605523e-02f, -2.95097113e-01f, 2.40877286e-01f, -2.67862678e-01f, -7.46021513e-03f, -3.99022490e-01f, -4.89393532e-01f, -2.29555443e-01f, 1.59547091e-01f,
  -5.00561059e-01f, 4.02922899e-01f, 1.04321040e-01f, 3.87283683e-01f, -4.42984611e-01f, -1.02874219e+00f, 2.20231295e-01f, 6.44272506e-01f, 7.85811782e-01f, -7.77525678e-02f,
  3.15254211e-01f, 9.47117656e-02f, 3.78072292e-01f, -4.66542095e-01f, 6.17364347e-01f, -7.53802240e-01f, -7.94289172e-01f, -1.00903235e-01f, -3.24708894e-02f, -2.50373960e-01f,
  7.35429585e-01f, -8.69544566e-01f, -2.43389666e-01f, -3.60992074e-01f, 3.34109604e-01f, 1.91999272e-01f, 1.12752974e-01f, 6.92094909e-03f, 2.17389129e-02f, 6.81402922e-01f,
  -3.03419739e-01f, 6.28011107e-01f, -5.56036413e-01f, 2.04698533e-01f, -2.71653950e-01f, 3.20539474e-02f, 1.12704849e+00f, -8.75944912e-01f, -8.05385768e-01f, -2.25481972e-01f,
  -5.23490787e-01f, -3.46405327e-01f, 1.96761742e-01f, 2.02830464e-01f, -6.51262343e-01f, 7.77278960e-01f, -5.94809353e-01f, -2.35847980e-01f, -9.80767310e-01f, 3.76347546e-03f,
  -3.75196427e-01f, 6.05600357e-01f, -4.83794808e-01f, 2.10537091e-02f, -1.55255526e-01f, 5.74455142e-01f, 6.38895214e-01f, -3.05444121e-01f, 1.10438570e-01f, 2.20898315e-01f,
  -8.50974619e-01f, 1.03303760e-01f, -3.15464228e-01f, 9.84108508e-01f, 1.20498538e+00f, 1.17457485e+00f, -9.71917342e-03f, -2.39626959e-01f, 3.90996605e-01f, -2.52210259e-01f,
  8.65565062e-01f, -3.88031512e-01f, -7.61580408e-01f, -3.21919501e-01f, 2.10632421e-02f, 1.33121340e-02f, -4.35415357e-01f, -3.55827838e-01f, -5.83481610e-01f, -3.40876013e-01f,
  -1.72787204e-01f, -7.37282276e-01f, 2.68132448e-01f, -2.13225096e-01f, 3.09130222e-01f, -5.63733578e-01f, -1.76605195e-01f, 7.17347637e-02f, 7.44129658e-01f, -1.98405504e-01f,
  3.70790869e-01f, 1.98821604e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  5.32123856e-02f, -2.99261242e-01f, 1.68896645e-01f, 6.17958307e-01f, 1.58603013e-01f, -1.80468127e-01f, -6.99194297e-02f, -3.29336196e-01f, -3.31400573e-04f, -2.28870556e-01f,
  5.06536245e-01f, -2.37362772e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    