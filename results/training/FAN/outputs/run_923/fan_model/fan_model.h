/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.26874550e-02f, -1.54503092e-01f, 3.83016139e-01f, -5.76391406e-02f, -4.74924333e-02f, -6.06675074e-02f, -2.16266707e-01f, -1.99188113e-01f, -3.89264375e-02f, -9.51056704e-02f,
  -9.09425542e-02f, 8.09557270e-03f, 1.36376917e-01f, 1.40491679e-01f, 6.33779839e-02f, -8.67194310e-02f, 2.04361863e-02f, 2.39840031e-01f, 2.11657181e-01f, -6.85829967e-02f,
  -1.60648987e-01f, -1.30135804e-01f, 9.88632441e-02f, -8.29845481e-03f, -2.09615566e-02f, 1.25152320e-01f, 5.20426407e-02f, 1.89103708e-02f, 3.60374823e-02f, 2.50847861e-02f,
  4.20681566e-01f, -4.87257577e-02f, 3.92527618e-02f, -1.23601459e-01f, -4.49410789e-02f, 8.55699182e-02f, 3.42378467e-02f, 5.63404933e-02f, -3.23165692e-02f, 7.55786058e-03f,
  2.09572911e-02f, -1.00078404e-01f, -3.18646394e-02f, -1.75860170e-02f, -5.05618043e-02f, -4.92128357e-02f, -4.74102087e-02f, 1.32983387e-01f, 4.92039211e-02f, 4.00640480e-02f,
  -1.64436534e-01f, -1.02047861e-01f, 3.63260806e-02f, -7.55010694e-02f, 8.23186412e-02f, 5.66216931e-02f, -4.06450368e-02f, 8.88405889e-02f, 1.36819869e-01f, -6.18573511e-03f,
  -5.29692285e-02f, 5.19937426e-02f, 1.04346881e-02f, -6.87783435e-02f, -2.43471819e-03f, -5.35986461e-02f, 2.85445973e-02f, 2.72746328e-02f, -5.35632670e-02f, -2.71852519e-02f,
  3.18674520e-02f, 1.72307789e-02f, -8.93649086e-03f, -7.93691259e-03f, 5.10668159e-02f, -1.89760197e-02f, -3.88115905e-02f, 1.94913149e-02f, 4.05927375e-02f, -1.87782794e-02f,
  -8.93367827e-03f, 4.47472110e-02f, 3.01242322e-02f, -4.28590998e-02f, 2.61511710e-02f, 7.05431625e-02f, 4.41647246e-02f, -1.58457868e-02f, -6.74539655e-02f, -2.93313656e-02f,
  -4.74977233e-02f, 2.42683701e-02f, 2.12721676e-02f, -6.93298504e-02f, 6.18565716e-02f, -3.54323350e-02f, 1.13365874e-02f, 5.51124522e-03f, 5.06461374e-02f, 2.67957188e-02f,
  6.20598719e-02f, 5.71127310e-02f, -3.81150842e-02f, -3.13535891e-03f, -3.08027603e-02f, 8.01936816e-03f, -1.42575487e-01f, 2.24006586e-02f, -7.41742477e-02f, -6.73739985e-02f,
  -5.23321219e-02f, -3.40076163e-02f, 8.54997039e-02f, 9.51152518e-02f, 3.93744111e-02f, 1.47603124e-01f, 1.41127184e-01f, 3.76846269e-02f, 1.04273453e-01f, -1.06047817e-01f,
  2.69082844e-01f, 2.20135629e-01f, 1.95219055e-01f, 2.43537977e-01f, -6.74821883e-02f, -5.18690310e-02f, -7.11408332e-02f, -9.30803269e-02f, -4.92533995e-03f, 5.30828275e-02f,
  -2.19217464e-02f, -8.43679234e-02f, 5.38656451e-02f, 6.87626898e-02f, 2.75416486e-02f, 1.22934900e-01f, 6.65684119e-02f, 1.79544926e-01f, 7.30035175e-03f, -8.47209841e-02f,
  -1.36896446e-01f, 6.73645828e-03f, 1.38134584e-01f, -4.10085022e-02f, 5.19086346e-02f, -4.55192439e-02f, 1.67395726e-01f, 8.56899321e-02f, 4.24078107e-02f, 1.89536199e-01f,
  2.10730240e-01f, 1.45528302e-01f, -3.12538035e-02f, -1.08581088e-01f, 3.55778188e-02f, -5.06258421e-02f, -3.25482595e-03f, 3.79455350e-02f, -6.92332312e-02f, 1.10373057e-01f,
  6.11042939e-02f, -7.55574182e-02f, 5.23194596e-02f, -2.01253816e-02f, 5.94882146e-02f, 5.66434413e-02f, 2.82069780e-02f, 1.41443416e-01f, 3.59881893e-02f, 4.74478751e-02f,
  4.34907638e-02f, 6.99882135e-02f, 4.72967699e-02f, -1.05906405e-01f, -6.67392984e-02f, -6.19233400e-02f, -4.57121097e-02f, 5.37155718e-02f, 5.70193306e-02f, 1.57072827e-01f,
  -6.30017295e-02f, -2.05362197e-02f, -4.05179039e-02f, 5.00179529e-02f, -3.06875203e-02f, 1.27704758e-02f, 6.92986697e-02f, -4.79890853e-02f, 3.39926593e-02f, -7.09779635e-02f,
  -2.83854338e-03f, 2.29236148e-02f, 3.54863219e-02f, 2.47752350e-02f, -4.89204796e-03f, 3.77714485e-02f, -3.55187021e-02f, 1.91050011e-03f, -5.88350110e-02f, -9.95687544e-02f,
  6.80982172e-02f, -3.55610922e-02f, -1.98819776e-04f, 2.77376045e-02f, 7.58022293e-02f, 4.05999832e-02f, -6.54040575e-02f, -6.12962693e-02f, 5.58991358e-02f, 4.65875417e-02f,
  -4.36723568e-02f, -5.98730445e-02f, -1.20241269e-02f, 2.47934777e-02f, 9.57321450e-02f, 4.25283350e-02f, 6.40722886e-02f, -6.24232702e-02f, -4.58095688e-03f, 6.59018522e-03f,
  1.00394581e-02f, -3.86354066e-02f, 1.11928033e-02f, 2.38632597e-02f, 8.11622944e-04f, -2.06513144e-02f, -7.95495883e-02f, 3.39007266e-02f, -5.68637662e-02f, -2.03796979e-02f,
  -2.33033970e-02f, -3.94077636e-02f, -7.99921826e-02f, -9.33393613e-02f, -2.61539258e-02f, -1.29936472e-01f, -6.97269663e-02f, -1.15281099e-03f, -1.46777809e-01f, -4.98637185e-02f,
  1.25356987e-01f, -2.36132517e-01f, 9.97442827e-02f, 1.13166429e-01f, -8.69883373e-02f, -2.57826984e-01f, -3.07209611e-01f, -1.35874212e-01f, -1.36488192e-02f, -1.67619765e-01f,
  -1.82275295e-01f, -8.69304612e-02f, -6.59037977e-02f, 1.21045433e-01f, 7.42522329e-02f, 6.39240816e-02f, 1.45634428e-01f, 3.43590200e-01f, 1.95170403e-01f, 2.38810945e-02f,
  6.46634325e-02f, 1.60582870e-01f, 2.15093881e-01f, 2.06385434e-01f, 3.33196968e-02f, 1.03899986e-01f, 4.09869142e-02f, 1.28178775e-01f, -2.52684578e-02f, 2.59286642e-01f,
  -1.74263790e-01f, -5.91221340e-02f, 3.17376154e-03f, 6.14952929e-02f, -7.36260712e-02f, 7.00803939e-03f, -1.07782343e-02f, 6.16183169e-02f, -6.83157071e-02f, 8.35984871e-02f,
  -3.41768749e-02f, 6.31040037e-02f, -1.62377767e-02f, 1.94605403e-02f, -8.99079442e-02f, 1.65195875e-02f, 8.93828720e-02f, 1.68018594e-01f, -2.28530029e-03f, -9.59545821e-02f,
  -6.39926419e-02f, -1.02262728e-01f, -1.48519233e-01f, -3.79266664e-02f, -1.99307129e-02f, 1.26533927e-02f, -1.15717277e-01f, 1.67086208e-03f, -7.79339299e-02f, -7.32355788e-02f,
  -3.54191586e-02f, 3.55813429e-02f, -6.35211840e-02f, -3.94554771e-02f, 9.05559864e-03f, 3.33240889e-02f, 5.01542836e-02f, -3.77371013e-02f, 2.74172220e-02f, -2.11338736e-02f,
  2.07795184e-02f, 2.97368900e-03f, 2.42734384e-02f, 5.68132773e-02f, 7.71660311e-03f, -5.34917880e-03f, 8.29427838e-02f, 8.77267588e-03f, -1.86927300e-02f, -6.91175181e-03f,
  -3.52988057e-02f, -4.79828194e-02f, -4.16357666e-02f, 9.25345272e-02f, -3.55703644e-02f, 2.00290978e-02f, 9.73047242e-02f, 2.65422706e-02f, -4.17409576e-02f, 2.02691313e-02f,
  -1.87655702e-01f, 1.97148230e-03f, 5.23746274e-02f, 6.31122664e-02f, 5.14574833e-02f, -6.33018604e-03f, -2.17268337e-03f, 1.14913424e-02f, -2.20197439e-02f, 1.70213524e-02f,
  -7.55218267e-02f, -3.40018701e-03f, 1.07758204e-02f, 2.68281475e-02f, -3.42101278e-03f, -8.07889104e-02f, -7.64334649e-02f, 9.20289475e-03f, 7.35094026e-02f, 2.71463785e-02f,
  -3.38634811e-02f, 1.42040923e-02f, -4.85959835e-02f, -6.21654876e-02f, -2.00480167e-02f, -7.77949095e-02f, -9.69653428e-02f, -6.51336908e-02f, -3.02482955e-02f, -2.25245152e-02f,
  -9.71705914e-02f, -1.31583706e-01f, -7.82037620e-03f, 5.36359400e-02f, -2.48742715e-01f, -1.29970670e-01f, -3.28001827e-01f, -9.69788656e-02f, 1.01846375e-01f, -2.32764296e-02f,
  -6.87180683e-02f, 9.97722521e-02f, 1.66889027e-01f, 1.07905053e-01f, 8.09119940e-02f, 3.72432098e-02f, 5.34637608e-02f, 2.41788968e-01f, 1.76153108e-01f, -1.30070418e-01f,
  -8.43582153e-02f, -9.82519090e-02f, -5.74266887e-04f, 9.85952541e-02f, -7.98628386e-03f, 1.29387826e-01f, 7.66305253e-03f, -2.54924651e-02f, -6.87278062e-02f, -5.71238212e-02f,
  -8.44810158e-03f, -1.14709780e-01f, 1.07215889e-01f, -5.75579237e-03f, 1.73627548e-02f, 4.62573813e-03f, -2.13492718e-02f, 6.43381849e-02f, 7.44506419e-02f, -1.37496681e-03f,
  -3.69829498e-02f, 7.21365958e-02f, -4.15948927e-02f, -4.05969955e-02f, -5.48923574e-02f, 7.89638758e-02f, 3.75546627e-02f, 4.66387123e-02f, 1.48479596e-01f, -6.72449544e-02f,
  -1.17891505e-01f, -1.48480445e-01f, -5.94072118e-02f, 6.08268082e-02f, 9.18165445e-02f, 1.21189378e-01f, -7.46448487e-02f, 2.93345191e-02f, 1.31838322e-01f, -2.06766538e-02f,
  2.68128049e-02f, 2.42784042e-02f, 1.49931479e-02f, -1.99568700e-02f, 2.77364794e-02f, 6.10314608e-02f, 4.99577038e-02f, 1.69262756e-02f, -8.05021226e-02f, 2.40767654e-02f,
  -1.32257473e-02f, -5.04263528e-02f, 4.28062230e-02f, 6.04620092e-02f, 5.46357818e-02f, -4.25582333e-03f, -6.82325917e-04f, 3.10794134e-02f, -1.46345822e-02f, 4.26491089e-02f,
  5.51010855e-02f, 3.00557399e-03f, 2.35202592e-02f, 6.78538978e-02f, 5.61686307e-02f, 8.78735930e-02f, -2.85395253e-02f, -3.60327326e-02f, 4.06900570e-02f, -1.35178238e-01f,
  9.34414119e-02f, 9.11965668e-02f, 9.20638964e-02f, 1.03996739e-01f, 2.70410739e-02f, -2.61595026e-02f, -3.44176032e-02f, 5.72080277e-02f, 2.04240363e-02f, 1.14361800e-01f,
  -3.93139012e-02f, 2.03400422e-02f, -1.40373530e-02f, -1.12154649e-03f, -1.06830336e-03f, -7.41079673e-02f, 9.48970392e-03f, -1.15453023e-02f, 2.89988220e-02f, -3.15182917e-02f,
  -7.56274462e-02f, 8.21334030e-03f, -3.27015743e-02f, -2.46247854e-02f, -7.93437734e-02f, 1.68688726e-02f, 1.66969672e-02f, 2.16089599e-02f, 4.65947352e-02f, -9.99493524e-02f,
  1.07322961e-01f, -7.86241423e-03f, 9.26000178e-02f, 1.40695972e-02f, -4.43628766e-02f, 2.27547094e-01f, 2.22012430e-01f, 1.37906060e-01f, 5.54665327e-02f, 8.54014009e-02f,
  -1.49985984e-01f, -2.22937182e-01f, -1.09133296e-01f, 3.21569704e-02f, 1.09091580e-01f, 7.11831525e-02f, 1.81901857e-01f, 1.41482085e-01f, 5.54882362e-03f, 5.33320084e-02f,
  5.42148501e-02f, 2.50749700e-02f, 9.59275588e-02f, -4.97065037e-02f, -6.52869567e-02f, -6.12415150e-02f, -7.60326013e-02f, -4.69845422e-02f, 4.57610153e-02f, -5.46770431e-02f,
  -8.34859759e-02f, -1.61122773e-02f, 5.81346937e-02f, -9.57134068e-02f, 1.12304566e-02f, -2.63483785e-02f, 3.29980664e-02f, 7.36272708e-02f, -7.87884966e-02f, -4.98940162e-02f,
  -1.49680495e-01f, -7.62219355e-02f, 6.02997793e-03f, -2.60763820e-02f, -2.66705118e-02f, 2.82103233e-02f, 8.66270885e-02f, 2.67758369e-02f, 6.23684153e-02f, -8.22620280e-03f,
  -1.82134081e-02f, -5.71831167e-02f, 8.40003267e-02f, 8.63292813e-02f, 1.77604798e-02f, 4.04571816e-02f, -7.73475990e-02f, -6.75514690e-04f, 1.17348328e-01f, -1.46656334e-02f,
  4.65858206e-02f, 7.75923394e-03f, -6.43385276e-02f, -5.71988411e-02f, 4.16126437e-02f, -1.88226942e-02f, -3.47917601e-02f, 4.22952287e-02f, 7.55313486e-02f, -8.61971900e-02f,
  3.42603959e-02f, -2.97982413e-02f, 4.05814759e-02f, 5.04243784e-02f, 3.55387777e-02f, -8.51401836e-02f, 5.96628413e-02f, 1.34702204e-02f, 5.72545044e-02f, -8.77066180e-02f,
  -4.35415888e-03f, 2.69913394e-02f, -8.76197442e-02f, -5.35079576e-02f, -1.48676150e-02f, -6.29482269e-02f, 4.73617949e-02f, 1.00537832e-03f, 3.23689543e-02f, -7.07307085e-03f,
  -1.95360392e-01f, -3.77902156e-03f, 6.31001145e-02f, 3.06248609e-02f, -6.32132217e-02f, 3.82104926e-02f, -6.15098849e-02f, 9.71034914e-03f, -4.15591244e-03f, 1.25994347e-02f,
  3.16478335e-03f, -3.82008329e-02f, 9.33821022e-04f, 6.81558922e-02f, -1.93915947e-03f, 5.09644672e-03f, -3.52460407e-02f, -6.59554973e-02f, -7.60954991e-02f, -6.44016936e-02f,
  6.67053983e-02f, 1.08008273e-01f, 7.23832473e-02f, -3.10208518e-02f, -7.08179995e-02f, 2.47992985e-02f, -5.07165603e-02f, -4.78208587e-02f, 1.03467237e-02f, 1.10459931e-01f,
  -4.04288583e-02f, 2.82368530e-02f, -2.08943292e-01f, -2.32567012e-01f, -2.48588324e-01f, -7.79609606e-02f, 2.27248576e-02f, 1.04308324e-02f, 1.79760233e-02f, -6.06480837e-02f,
  -7.66670704e-02f, -8.08120668e-02f, -4.52058874e-02f, -6.77394727e-03f, 1.06851935e-01f, -9.98227596e-02f, -1.06670901e-01f, -7.23764021e-03f, -4.74155731e-02f, 4.86871563e-02f,
  -1.72929019e-02f, 1.77683104e-02f, -7.36531243e-02f, -2.64410023e-02f, -1.13501832e-01f, -6.46741986e-02f, -1.35901615e-01f, -1.86342478e-01f, -7.79298693e-02f, -2.52629537e-02f,
  -7.91823864e-02f, -9.65865180e-02f, 7.68849207e-03f, 7.65484124e-02f, -1.31710097e-01f, 1.19207665e-01f, -3.47296707e-03f, 1.09883144e-01f, 7.20719472e-02f, 2.62718741e-02f,
  -5.13592251e-02f, -3.49539928e-02f, 5.88769466e-02f, -4.55411710e-03f, -5.21936752e-02f, 5.54726124e-02f, 9.90857780e-02f, -1.90326422e-02f, 5.88757321e-02f, -9.42671672e-02f,
  -4.14998597e-03f, -1.45087704e-01f, 6.95471391e-02f, -2.42245588e-02f, 5.18859178e-03f, 1.14082778e-02f, -1.26943532e-02f, -6.82158321e-02f, 1.04268296e-02f, 3.62630412e-02f,
  6.90681413e-02f, 2.00569220e-02f, 4.30404246e-02f, 6.96091214e-03f, 2.41554063e-02f, 6.76150694e-02f, 7.49202296e-02f, 1.37113817e-02f, 6.28255084e-02f, 1.20788785e-02f,
  8.37467331e-03f, 4.94685359e-02f, -6.90969676e-02f, 5.36122993e-02f, -2.25974713e-02f, -7.02517033e-02f, 5.23488037e-03f, 8.66561756e-03f, 1.39667206e-02f, 2.44000144e-02f,
  -4.56300899e-02f, 1.28618591e-02f, -3.53750214e-02f, 6.95768893e-02f, -5.63974865e-02f, 1.04294047e-02f, -3.62608843e-02f, -1.56258848e-02f, -5.31894229e-02f, -2.97536813e-02f,
  1.43196434e-01f, -1.59896761e-01f, 6.43456578e-02f, 9.36025754e-02f, -7.77747706e-02f, -7.05214515e-02f, -5.63368686e-02f, -6.92786947e-02f, -7.73226023e-02f, -3.36477943e-02f,
  9.84161347e-03f, 9.71454158e-02f, 3.95751819e-02f, -6.17697723e-02f, 1.79924874e-03f, 9.56321359e-02f, 3.58931087e-02f, 5.63842878e-02f, -2.69734450e-02f, -9.20042023e-02f,
  6.61244541e-02f, 1.34893060e-01f, 1.14964940e-01f, 1.69240907e-01f, 3.77308577e-02f, 5.04704937e-02f, 1.07807331e-01f, 2.72095408e-02f, 1.20830514e-01f, 2.82133758e-01f,
  2.54180491e-01f, -1.63162917e-01f, 5.43742664e-02f, 8.69494826e-02f, 9.13205296e-02f, -5.35203144e-02f, -1.19290590e-01f, -4.39574346e-02f, -2.53172126e-02f, -8.36494416e-02f,
  -9.67245549e-02f, 9.84860817e-04f, -4.51818593e-02f, -1.10521518e-01f, -1.33659039e-02f, -8.36154222e-02f, -1.49494559e-02f, 1.61312789e-01f, 5.35223298e-02f, 1.12294190e-01f,
  8.42770785e-02f, 4.81803082e-02f, 1.74765423e-01f, 7.80571550e-02f, 5.90921156e-02f, 5.85088059e-02f, 8.38237181e-02f, 1.22792631e-01f, 5.42404652e-02f, -2.48928880e-03f,
  -1.33997947e-01f, -9.86252502e-02f, -5.32658026e-02f, 3.58612426e-02f, 3.21752466e-02f, -7.70400390e-02f, -3.67418826e-02f, 3.04031987e-02f, -5.80436289e-02f, -8.17107782e-02f,
  7.56769106e-02f, 8.78478289e-02f, 7.02898204e-02f, 4.84227985e-02f, 4.06611860e-02f, 6.65935129e-02f, -8.14162940e-03f, 2.85240486e-02f, 6.70263916e-02f, -1.19619936e-01f,
  7.23276809e-02f, -6.32364079e-02f, 7.01530948e-02f, -1.38332784e-01f, -3.22569869e-02f, 4.20980994e-03f, -7.21021146e-02f, 4.83509153e-02f, -9.23962519e-02f, -8.40900913e-02f,
  5.15715126e-03f, -1.54900830e-02f, -7.14938343e-02f, 9.16348863e-03f, -8.21008608e-02f, 5.38362712e-02f, 7.71310255e-02f, -2.12929137e-02f, 2.47633420e-02f, 2.55966466e-03f,
  1.10164220e-02f, -8.97808298e-02f, 1.25620821e-02f, 1.30905211e-03f, -5.76173179e-02f, 8.44464973e-02f, -5.26171504e-03f, 3.77133600e-02f, -4.79188487e-02f, 9.84346494e-02f,
  -2.83139516e-02f, -4.44797948e-02f, 4.53254804e-02f, -5.48458323e-02f, -7.80410096e-02f, 6.83538988e-02f, -3.83224376e-02f, -1.74914452e-03f, 5.94555065e-02f, -6.62384275e-03f,
  -6.81342259e-02f, 6.85751587e-02f, 3.12964916e-02f, 3.92449610e-02f, -5.80322407e-02f, 3.59135754e-02f, -6.29574284e-02f, -5.17456271e-02f, -6.51840568e-02f, -9.85879004e-02f,
  -1.14035025e-01f, -7.18342364e-02f, -6.56871051e-02f, -1.01693803e-02f, 5.95745146e-02f, 2.20382344e-02f, 2.07824912e-02f, 4.75850254e-02f, -8.57909694e-02f, 1.44086415e-02f,
  -4.46265899e-02f, 4.99988422e-02f, 3.18171317e-03f, -6.37547374e-02f, -5.23620732e-02f, 1.03921331e-01f, -2.46932637e-02f, -6.56520203e-02f, -5.73297264e-03f, -1.35875354e-02f,
  -3.43062133e-01f, 9.66515206e-03f, -2.83166976e-03f, -2.08068982e-01f, -1.08582459e-01f, 1.26877472e-01f, 2.50587642e-01f, 2.65521556e-02f, -1.25689089e-01f, -7.87133276e-02f,
  1.96511634e-02f, 9.76101309e-02f, 8.00508037e-02f, 1.79807037e-01f, 1.88086003e-01f, 1.40944183e-01f, 8.19030032e-02f, 1.20252401e-01f, 2.08730966e-01f, 7.99005404e-02f,
  -1.27917416e-02f, -9.09472182e-02f, -4.58475463e-02f, -5.18382750e-02f, -2.27715462e-01f, -6.63135946e-02f, -1.16684303e-01f, -7.99424797e-02f, -2.88974848e-02f, -8.26867074e-02f,
  2.54629478e-02f, -2.28303313e-01f, 6.45166337e-02f, -5.74539648e-03f, -1.47657916e-01f, -9.41723585e-03f, -5.11747263e-02f, -1.33719787e-01f, -5.11795804e-02f, 4.28709015e-02f,
  -6.70370758e-02f, -1.08535774e-01f, -7.12153241e-02f, -9.33045670e-02f, 1.30989337e-02f, -5.61198741e-02f, -5.75821009e-03f, -8.29698294e-02f, 3.60178873e-02f, 5.69912158e-02f,
  4.15488333e-02f, 1.20399799e-02f, -9.75179449e-02f, 9.04874057e-02f, 7.06889704e-02f, 5.81166968e-02f, -1.13125362e-01f, -4.19689436e-03f, 7.16745406e-02f, -1.11761577e-02f,
  1.79999284e-02f, -3.37862372e-02f, -2.57068803e-03f, 5.90855293e-02f, -1.88173261e-02f, -3.93310599e-02f, -1.85764302e-03f, -3.89952771e-02f, 7.36156702e-02f, -8.09900463e-03f,
  -1.82460342e-02f, 3.69428508e-02f, -4.28503715e-02f, -1.89889763e-02f, 2.51375008e-02f, -2.85101831e-02f, 2.13743430e-02f, 5.88534586e-02f, 8.43715593e-02f, -6.90593421e-02f,
  -5.27492315e-02f, 1.27143376e-02f, -9.63931754e-02f, 5.15097640e-02f, 8.41806829e-02f, 2.91850250e-02f, -4.17329818e-02f, 1.04527874e-02f, -7.28861690e-02f, -2.87014470e-02f,
  -1.22195981e-01f, 1.80130258e-01f, -2.65088920e-02f, 7.28175938e-02f, -8.47878307e-02f, 3.04582324e-02f, 1.84988528e-02f, -9.95336194e-03f, -6.01612516e-02f, -2.13003568e-02f,
  1.88696068e-02f, 1.30848410e-02f, -3.39725204e-02f, 4.22695205e-02f, -2.41068415e-02f, -5.95995085e-03f, 2.21986324e-02f, 1.79489236e-02f, 4.66452725e-02f, -4.23041321e-02f,
  3.71251837e-03f, 5.34686483e-02f, 9.22110863e-03f, 6.50846511e-02f, 3.05234324e-02f, 1.05616666e-01f, 1.03700489e-01f, -3.32025327e-02f, 7.74777075e-03f, 9.00538713e-02f,
  4.94983345e-02f, -1.38522774e-01f, 2.07551166e-01f, 8.52950886e-02f, 6.12765402e-02f, 1.09882176e-01f, 8.91577974e-02f, -5.90091832e-02f, -5.39302565e-02f, -1.27184177e-02f,
  -1.68854654e-01f, -1.30843192e-01f, -4.37367186e-02f, -7.40564317e-02f, -1.06649250e-01f, 8.87566358e-02f, 8.92828405e-02f, 1.23517282e-01f, 1.67863324e-01f, -7.03687361e-03f,
  -1.62877649e-01f, 1.68638624e-04f, 7.88510367e-02f, 9.42549761e-03f, 4.11947519e-02f, -2.51283310e-02f, 6.44690767e-02f, 4.95857000e-02f, -3.15537080e-02f, -3.46390232e-02f,
  4.37066844e-03f, 6.70110136e-02f, 9.55868233e-03f, -6.69174939e-02f, 4.65596952e-02f, 6.17316291e-02f, -4.43725958e-02f, 7.97571391e-02f, -4.11328971e-02f, 4.83312132e-03f,
  1.20013673e-02f, 3.40077914e-02f, 7.37172663e-02f, -5.68166897e-02f, 7.74893835e-02f, 4.80029806e-02f, 6.12104237e-02f, -5.28084859e-02f, 1.16047420e-01f, -3.87318502e-03f,
  -2.02798042e-02f, 1.16280757e-01f, 1.76693633e-01f, 8.11122730e-02f, -3.53561640e-02f, 1.12271354e-01f, 1.38002038e-02f, 1.49775162e-01f, 8.72800499e-02f, 4.39265296e-02f,
  -7.49785975e-02f, 3.18412557e-02f, 2.99071297e-02f, 8.01531039e-03f, -2.78800521e-02f, 5.89586683e-02f, 7.30601102e-02f, -5.27854189e-02f, -1.66659541e-02f, 2.10890658e-02f,
  3.91410850e-02f, 3.62870395e-02f, 1.78851280e-02f, 3.31411920e-02f, -4.41749506e-02f, 5.48465475e-02f, 5.62486462e-02f, -5.32018356e-02f, 6.27917796e-02f, 7.46182874e-02f,
  1.73191950e-02f, 3.07133421e-02f, -8.51928955e-04f, -1.49101801e-02f, -1.66478828e-02f, 2.33592670e-02f, 1.69543177e-02f, 7.42101744e-02f, 2.33201608e-02f, -7.76639730e-02f,
  -5.73211312e-02f, 3.87291871e-02f, 3.57685350e-02f, 5.74893318e-02f, 2.50877868e-02f, -2.00174078e-02f, 2.77020019e-02f, 4.59351540e-02f, -7.27429241e-02f, 4.87028994e-02f,
  5.44751249e-03f, -1.29914572e-02f, -2.69078650e-02f, -7.49682263e-02f, -4.91509289e-02f, -5.17605841e-02f, -1.79143418e-02f, 9.15531768e-04f, 3.17326151e-02f, -2.59907581e-02f,
  -6.17646612e-02f, 2.03206614e-01f, 1.52263686e-01f, 5.15938215e-02f, 4.69873585e-02f, 9.23323110e-02f, 4.36652415e-02f, 1.35092810e-01f, 8.90271813e-02f, 1.24807291e-01f,
  -3.33830863e-01f, 1.93085507e-01f, 1.39171138e-01f, -2.22132862e-01f, -1.33031771e-01f, -1.13147065e-01f, 6.39701411e-02f, -9.55283493e-02f, -4.62775081e-02f, 1.33308154e-02f,
  -5.92501014e-02f, -4.48412895e-02f, -1.63279697e-02f, 9.16903242e-02f, 8.77249837e-02f, 1.72847256e-01f, 1.69250164e-02f, 1.15685046e-01f, -1.15583323e-01f, -3.07458285e-02f,
  -1.35975838e-01f, -5.00976406e-02f, -8.28965008e-02f, 6.81220815e-02f, 4.22000233e-03f, -2.80774590e-02f, 9.69269406e-03f, -3.26481499e-02f, 1.07967883e-01f, 1.04165494e-01f,
  5.43605201e-02f, 7.72896260e-02f, -1.39743432e-01f, -7.43440092e-02f, -3.53875048e-02f, 1.04979284e-01f, -8.18367526e-02f, 1.06568135e-01f, 4.79596443e-02f, -5.29669262e-02f,
  -7.79472888e-02f, -5.90883195e-02f, -3.20079438e-02f, 3.26924138e-02f, -5.56785874e-02f, 5.48647605e-02f, 1.46362409e-01f, 1.08101673e-01f, 6.16179816e-02f, 5.22853807e-02f,
  2.77570076e-02f, 9.79466084e-03f, 4.42741476e-02f, 1.02972249e-02f, 4.97597903e-02f, -8.46862122e-02f, 1.31103575e-01f, 9.32932571e-02f, 9.31081548e-02f, 5.07333465e-02f,
  -4.09649126e-02f, -1.42119201e-02f, 6.45273477e-02f, -5.54808229e-02f, -6.11247495e-03f, -1.21461535e-02f, 5.46496026e-02f, -6.80051595e-02f, 6.19495008e-03f, 8.11677501e-02f,
  -2.82918904e-02f, 6.90499470e-02f, -1.03108762e-02f, -8.23423490e-02f, -4.89029475e-02f, 1.60536300e-02f, -9.08973999e-03f, 4.14684676e-02f, -2.24264674e-02f, 3.94129157e-02f,
  -2.28938158e-03f, 4.78969282e-03f, -1.69913359e-02f, 2.22930368e-02f, -3.08045279e-02f, 4.40433957e-02f, -2.23268084e-02f, 2.08340790e-02f, -2.64098793e-02f, -5.02167121e-02f,
  -1.63786545e-01f, 7.63210561e-03f, -7.37008378e-02f, 4.54953052e-02f, -2.87853684e-02f, -1.80189461e-02f, -6.57994822e-02f, 3.92660797e-02f, -8.57489854e-02f, -1.76609755e-02f,
  5.55792525e-02f, 5.04530966e-02f, 7.59667456e-02f, -5.92555339e-03f, 1.05264764e-02f, 6.91685220e-03f, -6.60533756e-02f, 4.14695218e-02f, 4.00049835e-02f, -2.99320277e-02f,
  8.69357139e-02f, -1.84982240e-01f, -2.04993889e-01f, -1.08375572e-01f, 1.36317415e-02f, -2.75399417e-01f, -9.77268219e-02f, -1.17308132e-01f, -4.54984829e-02f, -2.24736050e-01f,
  -3.40892524e-01f, -7.53708482e-02f, -6.62623346e-02f, -6.23327196e-02f, -3.38975899e-02f, -2.46229917e-01f, -2.55338728e-01f, -2.00520366e-01f, -2.19977517e-02f, 6.11887313e-02f,
  -1.26302512e-02f, 1.93691641e-01f, 4.49062064e-02f, 1.19043350e-01f, -1.55062601e-01f, -8.56608823e-02f, 1.09373974e-02f, -6.67350143e-02f, 6.79016188e-02f, 2.48387689e-04f,
  1.43394992e-01f, 5.32489903e-02f, -6.23804331e-02f, -5.41993156e-02f, 9.72448662e-02f, 1.58439592e-01f, 4.73617809e-03f, 1.09838277e-01f, 1.45850509e-01f, 1.81210384e-01f,
  3.57238382e-01f, -1.76899105e-01f, 6.44433126e-02f, 7.41803050e-02f, 3.40637602e-02f, -2.34616548e-03f, -1.39033506e-02f, -4.79735946e-03f, 4.27238755e-02f, -9.61990654e-03f,
  3.43277864e-02f, 8.27147067e-02f, 4.19762135e-02f, 4.02086861e-02f, 3.78727801e-02f, 1.25410706e-02f, -7.07677752e-02f, -1.59896016e-02f, -4.70691696e-02f, -3.41944732e-02f,
  1.06683411e-01f, 6.03963621e-02f, -1.77279487e-02f, 7.92214740e-03f, 2.06728727e-02f, -7.44836181e-02f, -3.83916274e-02f, 8.66333842e-02f, -9.66564566e-02f, -4.50770892e-02f,
  -6.44519553e-02f, 3.19177024e-02f, 1.82471517e-02f, 1.79704949e-02f, -1.69044808e-02f, -7.71855414e-02f, 1.63962711e-02f, 9.17286500e-02f, 2.72848755e-02f, 1.94203276e-02f,
  -7.98957571e-02f, 3.58075090e-02f, 7.18792379e-02f, -3.19706202e-02f, 1.01314252e-02f, 6.65675923e-02f, -6.20998889e-02f, 5.14531843e-02f, 3.88475321e-02f, -7.38515705e-02f,
  -5.18300869e-02f, 3.17749754e-02f, 4.90371250e-02f, -2.04259856e-03f, -4.41136211e-03f, -2.74550300e-02f, -2.58784816e-02f, -8.13288148e-03f, 2.23454032e-02f, -2.69854418e-03f,
  1.49005830e-01f, -2.03124240e-01f, 1.20777965e-01f, 4.36421447e-02f, 2.76884995e-02f, 8.47985223e-03f, 7.43853971e-02f, 7.86141958e-03f, -2.35966798e-02f, 5.84259406e-02f,
  7.35090449e-02f, -6.99140057e-02f, 5.88231571e-02f, -2.01487616e-02f, -6.17145225e-02f, 2.48111114e-02f, 1.61251742e-02f, 2.80689877e-02f, 5.55313565e-02f, 1.18541688e-01f,
  -3.97587344e-02f, -6.67350963e-02f, -9.54330936e-02f, -7.79796764e-02f, -4.53979261e-02f, -7.58113265e-02f, 5.46348132e-02f, 3.53869498e-02f, -9.78295058e-02f, -1.38792098e-01f,
  -1.97915882e-01f, -1.52847990e-01f, -6.74339235e-02f, 2.76472010e-02f, 1.90498129e-01f, 1.21771000e-01f, -1.71609707e-02f, -5.47798537e-02f, -7.83029944e-02f, -4.51017469e-02f,
  1.62467994e-02f, 1.04527362e-01f, -4.16451283e-02f, 1.34090343e-02f, -1.32595990e-02f, 1.49428835e-02f, -1.27533935e-02f, 2.72629764e-02f, 5.66301215e-03f, 1.17120437e-01f,
  -3.74384969e-02f, -4.35373895e-02f, -4.37832065e-02f, 7.48960748e-02f, 3.27672921e-02f, 7.23599941e-02f, -7.75816888e-02f, 1.13448650e-01f, 1.66682769e-02f, 7.00470954e-02f,
  -1.52730554e-01f, 1.04632480e-02f, 4.35959026e-02f, 7.52680302e-02f, 7.53246099e-02f, 2.75099035e-02f, 1.07340209e-01f, 5.72018363e-02f, -3.96187492e-02f, -6.99110702e-02f,
  1.44692078e-01f, 1.13566287e-01f, 5.77864125e-02f, 2.77011842e-02f, -5.47280535e-02f, 6.76063448e-02f, 2.58727241e-02f, -9.16596353e-02f, -7.52972290e-02f, 3.86311598e-02f,
  -1.96818798e-03f, 1.94349326e-02f, -4.28413264e-02f, 1.98776647e-02f, -6.89846277e-02f, 1.03868738e-01f, -5.12967072e-02f, -2.66365632e-02f, -7.69267231e-02f, -1.60646200e-01f,
  -5.49944751e-02f, -6.91087022e-02f, 5.82683533e-02f, -7.19692186e-03f, -5.72942607e-02f, -1.90355182e-02f, -7.07825273e-02f, 7.40680331e-03f, 2.22060941e-02f, 4.14807312e-02f,
  6.04816759e-03f, 4.51942012e-02f, -3.83602269e-02f, 6.39352575e-02f, 2.03878228e-02f, -3.54034901e-02f, -2.81605031e-03f, -3.22714038e-02f, 2.93354224e-02f, 9.66624022e-02f,
  7.35581443e-06f, 3.39001343e-02f, 8.41758326e-02f, 2.36315373e-02f, -2.40319055e-02f, 1.47313660e-03f, -2.84155179e-02f, -4.01500762e-02f, 4.99665178e-02f, 1.63707621e-02f,
  -6.85589090e-02f, 2.11900219e-01f, -9.49245542e-02f, -2.31197551e-02f, -2.58739330e-02f, 8.30424353e-02f, 2.40753666e-02f, -5.98804131e-02f, 8.65786821e-02f, 7.53065869e-02f,
  1.05821975e-01f, -3.10397130e-02f, 3.30623724e-02f, -4.35378822e-03f, -3.50178480e-02f, 6.12714961e-02f, -5.12712859e-02f, -9.77744237e-02f, 9.82423685e-03f, -6.51188567e-02f,
  4.99792136e-02f, -4.71822545e-02f, 1.00905774e-02f, -7.17189685e-02f, -3.52048092e-02f, 6.19480433e-03f, -8.96078944e-02f, 2.75122132e-02f, -3.16627733e-02f, -1.40278056e-01f,
  -1.29281387e-01f, -1.66782476e-02f, 1.80731416e-01f, 9.00974870e-02f, 1.39981747e-01f, 1.08513914e-01f, 2.25170374e-01f, 7.39362389e-02f, -3.39310318e-02f, 7.40580037e-02f,
  1.07875668e-01f, -1.18124031e-03f, 8.16275328e-02f, -7.00022951e-02f, -4.79639806e-02f, -1.07423319e-02f, 4.21692394e-02f, 2.55197436e-02f, 5.02467379e-02f, 1.90316424e-01f,
  6.54329732e-02f, -9.19821300e-03f, -8.19820315e-02f, 5.80566488e-02f, 2.01324709e-02f, 7.30489641e-02f, -4.24517803e-02f, 4.40275706e-02f, 7.12441206e-02f, 1.31789654e-01f,
  1.96885303e-01f, 7.55423531e-02f, -3.07760052e-02f, 2.56031174e-02f, 1.06138952e-01f, -7.21986890e-02f, 3.06868777e-02f, 7.32976338e-03f, 7.78324902e-03f, 1.16150349e-01f,
  4.46280167e-02f, 3.80986966e-02f, -1.09971464e-02f, 3.70595008e-02f, 4.72542346e-02f, 5.42441942e-02f, -1.92204863e-01f, -3.02353296e-02f, -7.88618028e-02f, 3.93375084e-02f,
  1.21889532e-01f, 2.01256424e-01f, 1.11187436e-01f, -3.91593874e-02f, -1.38642555e-02f, -1.20207975e-02f, -4.60578352e-02f, -4.94165234e-02f, -3.80707253e-03f, -3.13722268e-02f,
  6.62421584e-02f, 8.00381750e-02f, -8.26442093e-02f, 2.29145661e-02f, -6.64146675e-04f, -6.07243292e-02f, 5.48489057e-02f, -1.70805845e-02f, 6.77778721e-02f, -5.70100918e-02f,
  5.34731224e-02f, -3.50071415e-02f, -6.62308186e-02f, 3.16705704e-02f, -2.14244220e-02f, 4.16726694e-02f, 7.16929138e-02f, -8.10033306e-02f, -9.81779099e-02f, -9.79966670e-03f,
  3.38015035e-02f, -1.34988474e-02f, 3.42439092e-03f, -8.98555294e-02f, 3.72267328e-02f, -8.27715397e-02f, -1.68715063e-02f, 1.96447186e-02f, -3.61399353e-02f, 7.75329769e-02f,
  -1.23745456e-01f, 5.04638581e-03f, 3.74359079e-02f, -7.35831484e-02f, -4.25162502e-02f, -1.22841567e-01f, -3.82990614e-02f, -1.28693329e-02f, -1.35436114e-02f, -3.88159044e-03f,
  8.92103836e-02f, -2.61299387e-02f, -2.39980761e-02f, 1.98456980e-02f, 3.93100977e-02f, 8.50059688e-02f, 3.95871093e-03f, -2.53035408e-02f, -9.92925763e-02f, 1.20098777e-02f,
  -4.62940261e-02f, -3.88570465e-02f, 3.78822051e-02f, -5.19400239e-02f, 1.33546190e-02f, 9.85819772e-02f, -2.17604395e-02f, 1.22074626e-01f, -1.25113325e-02f, -1.62180558e-01f,
  4.23088968e-01f, -6.00293092e-02f, 2.72130191e-01f, -7.98987821e-02f, -1.98783278e-01f, 5.97410612e-02f, 8.25346559e-02f, -7.29331467e-03f, -1.41538605e-01f, -1.98880937e-02f,
  -1.13462329e-01f, -3.95482779e-02f, -8.31987709e-03f, 1.50751574e-02f, 2.40734830e-01f, 9.25048888e-02f, 3.62159796e-02f, 2.55454451e-01f, 2.87868291e-01f, 1.97271649e-02f,
  -1.31328374e-01f, 2.05412917e-02f, 1.76001579e-01f, -2.51293438e-03f, -1.11174650e-01f, -1.62832886e-01f, -3.15286219e-02f, 5.55336140e-02f, 6.69606868e-03f, -5.51066846e-02f,
  -3.53175476e-02f, 1.07896492e-01f, 1.35420680e-01f, -1.22905597e-01f, -7.46637732e-02f, 1.10467225e-01f, 6.96256906e-02f, 1.93806849e-02f, 6.01841435e-02f, -4.87304218e-02f,
  -8.01543221e-02f, 2.80198250e-02f, -7.74273872e-02f, -5.07004596e-02f, 4.23482619e-02f, 2.48043463e-02f, -6.39190078e-02f, 2.09268942e-01f, 1.07609518e-01f, -5.96883036e-02f,
  -2.04537645e-01f, 1.36492057e-02f, 1.78928584e-01f, 5.38247488e-02f, 9.50739533e-02f, 1.19959965e-01f, 1.22723006e-01f, 6.07027411e-02f, 1.47861138e-01f, 8.26291218e-02f,
  -8.15649927e-02f, -3.91528271e-02f, -3.10733877e-02f, 8.26570988e-02f, -2.53480878e-02f, -2.68665701e-02f, 1.40544930e-02f, -1.41759096e-02f, 5.95236607e-02f, 1.72021135e-03f,
  -3.24055785e-03f, 4.01928686e-02f, 3.77228204e-03f, 6.25007227e-02f, -7.57720619e-02f, -6.33809716e-03f, 1.46002024e-02f, -3.19844522e-02f, 1.94786657e-02f, -7.04371417e-03f,
  6.39399514e-02f, 5.85241169e-02f, -2.81089190e-02f, -2.26062201e-02f, -2.68557314e-02f, 1.10863000e-01f, 6.82136118e-02f, 6.29793927e-02f, -4.09923308e-02f, 1.02778591e-01f,
  -1.44900560e-01f, 1.75306037e-01f, -4.65172790e-02f, 8.98026302e-02f, -5.73536940e-02f, -7.92351365e-02f, -5.65187037e-02f, 5.74585497e-02f, -1.38802147e-02f, 4.60890867e-02f,
  1.28579559e-03f, 7.24600703e-02f, 4.00005579e-02f, -6.44205213e-02f, 8.86272043e-02f, -3.56422625e-02f, -6.08425029e-02f, 1.11504132e-02f, -6.23525307e-02f, -7.57265240e-02f,
  -1.18868187e-01f, 2.90155262e-02f, 5.54715544e-02f, -1.42943589e-02f, -2.89107002e-02f, 1.42424911e-01f, 1.89689815e-01f, -1.60168409e-02f, 2.25568771e-01f, 8.66272673e-02f,
  -1.46638565e-02f, -1.11635603e-01f, 2.49040984e-02f, 8.16785693e-02f, 4.71322834e-02f, 2.39584759e-01f, 2.57271290e-01f, 1.95802152e-01f, 1.77332237e-02f, 2.07088981e-02f,
  -1.35018751e-01f, -6.09164499e-02f, -1.08403437e-01f, -6.23867773e-02f, -8.94042756e-03f, 6.61927834e-02f, 8.03558230e-02f, 1.54918000e-01f, 2.29691476e-01f, 1.57953203e-01f,
  1.14593869e-02f, 4.42611799e-02f, 7.64219090e-02f, -1.06206909e-01f, -1.12783201e-01f, -8.42254385e-02f, -7.90984835e-03f, -6.72711208e-02f, -1.14662051e-01f, -1.91353068e-01f,
  -6.64230138e-02f, 5.87109141e-02f, 1.51834026e-01f, -4.84432094e-02f, -4.66098636e-02f, 3.00265681e-02f, 2.65878215e-02f, -9.86924246e-02f, -8.63452926e-02f, -1.01643071e-01f,
  -2.53751781e-02f, -2.79955119e-02f, -7.36908689e-02f, -9.44425240e-02f, 8.07839558e-02f, 6.94323629e-02f, 6.66329917e-03f, -2.76515521e-02f, -5.80310300e-02f, -1.25554740e-01f,
  -1.35301948e-01f, 1.74979977e-02f, 1.66478381e-02f, -6.21660352e-02f, -6.12288415e-02f, 1.47767393e-02f, 5.40623739e-02f, -4.32769619e-02f, 4.74896505e-02f, -5.20037338e-02f,
  -5.03079630e-02f, 9.25785210e-03f, 5.64586520e-02f, -7.09887668e-02f, 5.15412427e-02f, 2.94213486e-03f, -7.17358198e-03f, 4.97454952e-04f, 6.17540814e-02f, 7.25154579e-02f,
  -1.06321471e-02f, -9.62206628e-03f, 5.32054119e-02f, 1.16059789e-02f, -6.30677715e-02f, -2.80934814e-02f, -2.73922794e-02f, -2.99216248e-02f, -3.28642279e-02f, 2.81308722e-02f,
  3.79418693e-02f, -3.43721621e-02f, -4.66760024e-02f, 5.13055883e-02f, -7.71456733e-02f, -5.80314696e-02f, -4.29913364e-02f, -6.58616498e-02f, 4.51279841e-02f, -1.19910445e-02f,
  -6.86823130e-02f, 8.50921124e-02f, 1.72547475e-02f, 2.32102051e-02f, 5.10132052e-02f, -6.66665286e-02f, 1.97170321e-02f, 5.03967963e-02f, 5.33924624e-02f, 5.30747473e-02f,
  -6.86410069e-02f, -1.20919468e-02f, 4.84997369e-02f, -7.61771873e-02f, 8.49420726e-02f, 5.85785648e-03f, -5.35118990e-02f, 7.51768146e-03f, 6.35086745e-02f, -1.19070716e-01f,
  -8.72095674e-03f, 1.65296838e-01f, 1.28396958e-01f, 6.04957901e-03f, -6.02367967e-02f, 7.83165246e-02f, 1.19323887e-01f, 5.98638989e-02f, 1.37512237e-01f, 6.82338327e-02f,
  2.80947208e-01f, 1.33252829e-01f, -8.20990577e-02f, -3.51830311e-02f, -9.89370868e-02f, -2.14614540e-01f, -9.50866565e-02f, -1.20212406e-01f, -9.32652205e-02f, -7.63069466e-02f,
  1.84584498e-01f, 1.13558426e-01f, 5.93398176e-02f, 4.44164723e-02f, -8.07961076e-02f, -1.44241929e-01f, -2.14359537e-01f, -1.31678268e-01f, -1.09581731e-01f, -9.04754549e-03f,
  -1.05232723e-01f, -1.05995685e-01f, 1.00318059e-01f, -8.92231837e-02f, -3.86679522e-03f, -9.15455222e-02f, -1.29761294e-01f, -5.37402788e-03f, -6.47106245e-02f, 3.12297251e-02f,
  8.13255101e-05f, 3.41122061e-01f, -4.83250692e-02f, 6.63681552e-02f, 4.79712859e-02f, 9.59113687e-02f, -4.53687981e-02f, -5.38036507e-03f, -1.06225284e-02f, -5.60317002e-02f,
  -2.57070046e-02f, 7.12187439e-02f, -7.32667893e-02f, 4.04183082e-02f, 5.17717935e-02f, 3.84366303e-03f, 6.09990284e-02f, 2.24914476e-02f, 3.52003984e-03f, 1.24228291e-01f,
  -9.52433329e-03f, -5.70932552e-02f, 3.41993980e-02f, 1.65718887e-02f, 2.48708157e-03f, -6.89278021e-02f, -2.27015354e-02f, -3.85297500e-02f, 6.01640530e-03f, 9.07352951e-05f,
  -2.70873364e-02f, -4.26480807e-02f, 3.21741290e-02f, 6.23875409e-02f, 1.57958176e-02f, 3.86308804e-02f, -5.71442135e-02f, 1.68803651e-02f, 3.45271416e-02f, -3.75643186e-02f,
  -1.78783275e-02f, 5.41100428e-02f, -5.89823127e-02f, 4.87914011e-02f, 7.04685301e-02f, -4.77013178e-02f, 6.17762506e-02f, 1.37109458e-02f, 5.83765209e-02f, 3.19141187e-02f,
  -2.79317088e-02f, -6.75204545e-02f, 4.99539040e-02f, -7.10811988e-02f, 2.88230572e-02f, -5.39672151e-02f, -5.20649664e-02f, 4.37802374e-02f, 8.72870442e-03f, 4.72214036e-02f,
  -1.41412526e-01f, 4.90237121e-03f, -4.45533581e-02f, -7.39113912e-02f, -9.59388614e-02f, -6.54611960e-02f, -3.89255434e-02f, 3.70128429e-03f, 6.29626820e-03f, 1.34177122e-03f,
  -3.82889286e-02f, 5.85604273e-02f, -3.15825567e-02f, -7.56838247e-02f, -4.99967160e-03f, 1.87963787e-02f, -3.54140699e-02f, -1.32159814e-01f, -6.15361631e-02f, 4.15213667e-02f,
  -3.29908952e-02f, -4.90812548e-02f, -1.25607699e-01f, -1.61525503e-01f, -2.45256051e-02f, -7.04818889e-02f, -1.14733167e-01f, -9.26678255e-02f, -2.08101004e-01f, -1.01183787e-01f,
  -2.93413103e-01f, -2.76794583e-01f, 5.50412498e-02f, 5.78570142e-02f, -6.27091751e-02f, -3.98238078e-02f, -2.91653365e-01f, -2.23601714e-01f, -5.30575961e-02f, -1.87447295e-02f,
  -8.68769139e-02f, 1.45751506e-01f, 1.18270375e-01f, 8.51754099e-03f, -5.16015477e-02f, -2.30096793e-03f, 7.77198374e-02f, 1.55116618e-01f, 7.26452991e-02f, 2.47299802e-02f,
  1.02738030e-01f, 8.05538818e-02f, 7.71186873e-03f, 3.06904260e-02f, 1.36743754e-01f, 1.62222788e-01f, 4.89759147e-02f, 6.90227747e-02f, 2.65149567e-02f, 1.32774562e-01f,
  8.06360915e-02f, -2.50419915e-01f, 1.47959605e-01f, 5.15964292e-02f, 3.58506255e-02f, -6.71061501e-02f, 3.96750644e-02f, 7.27531919e-03f, 3.84503938e-02f, -3.21819149e-02f,
  9.04709846e-02f, -3.49688083e-02f, 5.68994693e-02f, 1.05870860e-02f, -7.95300677e-02f, -5.95737761e-03f, -2.24527884e-02f, -2.16761939e-02f, -4.87422720e-02f, -6.19650371e-02f,
  2.68642325e-02f, 1.61140934e-02f, -4.17636037e-02f, -9.91682895e-03f, -4.98700654e-03f, 1.26621097e-01f, -6.40652627e-02f, -6.51634187e-02f, -6.79102018e-02f, -1.46494001e-01f,
  1.37033965e-02f, -1.72842257e-02f, 8.63901619e-03f, -4.44569364e-02f, -7.21412338e-03f, 9.66747254e-02f, 3.11156940e-02f, -3.56786419e-03f, 7.89212734e-02f, 4.50876467e-02f,
  -1.76596977e-02f, -6.05046079e-02f, 2.82645877e-02f, 3.79885994e-02f, 5.06745726e-02f, -3.54725644e-02f, 8.34172145e-02f, -1.02882767e-02f, -4.24363911e-02f, -2.95697134e-02f,
  3.85407172e-02f, -9.21992585e-04f, 2.90992092e-02f, -5.10405749e-03f, -7.67212212e-02f, 2.75310427e-02f, 2.33712345e-02f, 3.51105630e-02f, 4.95685562e-02f, -3.22802141e-02f,
  -8.70063454e-02f, -3.77536044e-02f, 9.79460031e-02f, 1.94187984e-02f, 6.89211395e-03f, 3.96899041e-03f, -8.41331575e-03f, 4.35954571e-04f, -3.43171880e-02f, -4.71164510e-02f,
  5.07036038e-02f, 1.04910526e-02f, -4.06343304e-02f, 7.78989727e-03f, -9.78512038e-03f, -8.06050655e-03f, -8.88227522e-02f, 1.96152106e-02f, -3.13626863e-02f, -6.24745227e-02f,
  -7.44454116e-02f, -8.35795626e-02f, -6.20858930e-02f, -8.32667574e-04f, 4.04212885e-02f, 1.16388276e-01f, -6.10550083e-02f, -2.60579344e-02f, -1.05414763e-01f, -1.02328390e-01f,
  2.51695123e-02f, -1.30762190e-01f, -5.95814846e-02f, 1.61370382e-01f, -3.26944739e-02f, -2.71089613e-01f, -2.68630743e-01f, -7.02240467e-02f, 1.26985252e-01f, -4.94073657e-03f,
  -1.35577306e-01f, -8.49328786e-02f, 3.42293270e-02f, -5.01204580e-02f, -2.42353305e-01f, -1.04611307e-01f, -2.76321098e-02f, -1.19432531e-01f, -6.20579496e-02f, 1.01112537e-02f,
  1.52904049e-01f, 3.84363383e-02f, 5.18400446e-02f, 2.94456147e-02f, 2.07411900e-01f, 1.39333725e-01f, 1.54033571e-01f, 8.76307786e-02f, 3.62741053e-02f, 1.68381408e-01f,
  3.27762701e-02f, -1.04703560e-01f, -6.30679578e-02f, 5.96536025e-02f, 9.95126590e-02f, 8.27979371e-02f, 2.38986090e-02f, -1.36924069e-02f, -2.92722546e-02f, 3.93191865e-03f,
  8.33590329e-02f, -3.60771492e-02f, -4.13187481e-02f, -6.42047904e-04f, -4.41033673e-03f, 5.00865467e-02f, 2.11971365e-02f, -4.45529185e-02f, 2.02724524e-02f, 9.42453444e-02f,
  3.29338834e-02f, -1.00379683e-01f, -1.16523720e-01f, -1.06882557e-01f, 5.04947603e-02f, -8.05604458e-02f, -6.50565773e-02f, -3.18813659e-02f, -8.47435892e-02f, 1.46169215e-01f,
  -6.44576922e-03f, 6.98822588e-02f, -7.73308054e-02f, 6.35315478e-02f, 6.38806969e-02f, -3.05172447e-02f, 4.42464883e-03f, -9.22355242e-03f, 5.61205335e-02f, 5.34312129e-02f,
  -1.97503027e-02f, 1.94704346e-02f, -5.63461818e-02f, -2.50233654e-02f, 5.78861218e-03f, -7.28340400e-03f, -1.54965976e-02f, -5.42684309e-02f, 4.81334627e-02f, 3.50804366e-02f,
  4.63639339e-03f, -1.48777151e-02f, -3.97454528e-03f, 1.58384871e-02f, -3.34937125e-02f, 2.19162460e-03f, 6.33555055e-02f, 5.25532998e-02f, 2.42724344e-02f, -1.39559265e-02f,
  1.73652783e-01f, -2.79586524e-01f, 3.58766541e-02f, -3.02206911e-02f, 2.60505732e-02f, 9.77801345e-03f, 2.59944587e-03f, 8.50965008e-02f, -2.45428048e-02f, 1.34557504e-02f,
  -8.55384246e-02f, -6.43808320e-02f, -3.85474637e-02f, 2.97369473e-02f, -5.07826312e-03f, 7.50195608e-02f, 1.10947967e-01f, -2.39987355e-02f, -9.74474400e-02f, 5.64527735e-02f,
  1.42270338e-03f, -5.07292338e-02f, -2.59963814e-02f, -1.14581645e-01f, -1.50966295e-03f, -1.36209382e-02f, -4.49078642e-02f, 4.00168188e-02f, -1.55742615e-01f, 1.49441153e-01f,
  2.77081162e-01f, 6.91792965e-02f, 9.33191329e-02f, 2.32607469e-01f, 9.69114900e-02f, -1.04911052e-01f, -5.19629680e-02f, -2.70529836e-02f, 3.80057171e-02f, -9.09542141e-04f,
  -1.50600374e-01f, -2.35901102e-02f, -1.37305960e-01f, -5.73382936e-02f, -8.42607915e-02f, 1.28826285e-02f, 2.81051118e-02f, 7.90371001e-02f, 2.07181722e-02f, 1.23508871e-02f,
  -7.65628666e-02f, 1.63551554e-01f, 3.58162597e-02f, 6.21195734e-02f, 1.17236584e-01f, 1.36223465e-01f, 1.12784356e-01f, 6.72075972e-02f, -3.11820786e-02f, 8.69875923e-02f,
  3.12159234e-03f, -3.06856297e-02f, -1.28314979e-02f, -1.14576459e-01f, -4.11167257e-02f, 4.45249826e-02f, 7.94032812e-02f, 6.23997487e-02f, -3.35026272e-02f, 8.32184702e-02f,
  2.85087004e-02f, -6.77760690e-02f, -6.82455078e-02f, 3.75495963e-02f, 5.34255393e-02f, -7.71982372e-02f, 2.98834015e-02f, 4.72412817e-02f, -3.70123461e-02f, -7.30420649e-02f,
  3.60269137e-02f, 4.21925262e-02f, 7.10817128e-02f, -7.82589465e-02f, -1.03146747e-01f, -6.85198531e-02f, -3.05574238e-02f, 8.77966825e-03f, 7.88261145e-02f, 1.19667612e-01f,
  1.46815702e-02f, -4.20855731e-02f, 2.79935300e-02f, 6.86718449e-02f, -4.84302826e-02f, 2.33467552e-03f, 7.24568963e-02f, -4.56702746e-02f, -3.13236415e-02f, -9.18427855e-03f,
  4.43774685e-02f, -5.91222532e-02f, -4.43823375e-02f, -1.78752225e-02f, -8.44199024e-03f, 1.03911888e-02f, 1.58266500e-02f, 1.26613528e-02f, 2.51763482e-02f, -2.69596488e-03f,
  7.38212094e-02f, 5.54846041e-02f, -5.30447289e-02f, -1.58284027e-02f, -4.17225249e-02f, 5.89410998e-02f, -4.03600521e-02f, 1.51831657e-02f, -1.13464408e-02f, 6.53781816e-02f,
  1.49449334e-01f, -1.92623854e-01f, 8.17695782e-02f, 3.45710628e-02f, 6.20940961e-02f, -8.90377387e-02f, -5.55067472e-02f, 1.74213219e-02f, -2.94751097e-02f, 2.55929101e-02f,
  2.22520740e-03f, -4.18835282e-02f, -7.31508583e-02f, -9.13061449e-05f, 1.31157786e-02f, 3.55647430e-02f, -1.06653191e-01f, 7.50910789e-02f, -8.69644880e-02f, 1.78563073e-02f,
  -9.59425140e-03f, 1.46455929e-01f, 7.26845255e-03f, 1.00157633e-01f, 4.08535451e-02f, -2.20684404e-03f, 1.00006469e-01f, 1.02545306e-01f, 8.30886886e-02f, 2.68906713e-01f,
  -4.44180757e-01f, -2.37216011e-01f, -3.96374762e-01f, -1.51525587e-01f, -9.37616378e-02f, 6.01500720e-02f, -9.65089127e-02f, 1.21507607e-01f, -3.02041089e-03f, -9.32619423e-02f,
  3.08224559e-02f, 1.63400412e-01f, 3.50042805e-03f, -2.60750856e-02f, 5.23519181e-02f, -1.91297442e-01f, -2.13942185e-01f, -1.99143261e-01f, -9.96464118e-02f, -1.83966942e-02f,
  -2.36367285e-02f, -9.87868980e-02f, -4.57337834e-02f, -6.58795461e-02f, -9.91491303e-02f, -2.85157803e-02f, -1.65063031e-02f, -1.43476963e-01f, -1.13890238e-01f, -2.11748600e-01f,
  -2.36983523e-01f, -2.12610886e-01f, -1.71277635e-02f, 7.23982304e-02f, 4.53859419e-02f, -5.63021377e-03f, 4.51039672e-02f, -2.36696098e-02f, 2.50959012e-04f, 6.05947152e-02f,
  -4.22623605e-02f, 2.35201828e-02f, 2.18513869e-02f, 2.57063899e-02f, -6.81098327e-02f, 4.41589616e-02f, 4.82017547e-03f, -3.88341881e-02f, -3.36776935e-02f, -4.57530580e-02f,
  7.84723386e-02f, -8.13774467e-02f, -2.73605902e-03f, -1.60862356e-02f, 3.98347490e-02f, -2.89948843e-02f, 3.97967728e-04f, -1.35194845e-02f, 9.22523364e-02f, -2.76662074e-02f,
  -3.29707749e-02f, -6.75405748e-03f, 1.02612786e-02f, -1.70370210e-02f, 7.78990164e-02f, 2.38855332e-02f, -3.77515294e-02f, -9.57588945e-03f, -3.34395748e-03f, 2.83826776e-02f,
  2.00888328e-02f, -5.41831180e-02f, -2.99036428e-02f, -3.54740098e-02f, -5.52018464e-04f, -4.58693504e-02f, -1.58840755e-03f, 1.67603455e-02f, 2.17922386e-02f, -1.74369980e-02f,
  1.87252145e-02f, 3.94431800e-02f, -3.26186279e-03f, 1.48978271e-02f, -1.00694232e-01f, -6.67223334e-02f, 9.56518482e-03f, 7.78237283e-02f, 3.62322368e-02f, 5.32639287e-02f,
  1.96568668e-01f, 3.98091823e-02f, -9.12952870e-02f, -8.87270551e-03f, -5.18483259e-02f, 2.85834335e-02f, -7.18326196e-02f, -5.98496245e-03f, 5.11152111e-02f, -5.61158657e-02f,
  9.46183130e-02f, -5.21341749e-02f, -8.53231177e-02f, 7.41648749e-02f, 4.01493683e-02f, 8.41408968e-02f, 5.57809174e-02f, -6.47112355e-02f, -5.54651162e-03f, 7.37749040e-02f,
  5.80745228e-02f, -4.30225246e-02f, 2.10806131e-02f, 9.22260154e-03f, 6.82729343e-03f, -4.00269926e-02f, 3.47563252e-03f, 1.64747722e-02f, 8.43449980e-02f, 1.63380846e-01f,
  3.88568587e-04f, -6.94639906e-02f, 6.73886240e-02f, 1.70432657e-01f, -1.60712097e-02f, -1.36165293e-02f, -1.62901580e-01f, -1.78919584e-01f, 1.29782692e-01f, 1.31889343e-01f,
  8.65520090e-02f, 1.21495940e-01f, 1.59227103e-01f, 8.81247316e-03f, -1.69881865e-01f, -5.02341725e-02f, 1.19899899e-01f, 6.11579455e-02f, -3.77428830e-02f, 1.21617652e-01f,
  7.48927370e-02f, 1.83665738e-01f, -7.33776996e-03f, 8.82270783e-02f, 1.36290610e-01f, 1.76088840e-01f, 7.52427205e-02f, 4.64094803e-02f, -1.70254912e-02f, 3.24549615e-01f,
  2.51723528e-01f, -1.39006644e-01f, -7.69515056e-03f, 6.09988309e-02f, -4.99742664e-02f, 8.44189245e-03f, -1.14109758e-02f, -4.29177433e-02f, -6.87808245e-02f, 6.11127578e-02f,
  2.73042894e-03f, 5.06631173e-02f, 9.06421840e-02f, 5.02979420e-02f, -5.82242906e-02f, 6.26715422e-02f, -5.97030409e-02f, -6.38987198e-02f, -1.33597423e-04f, -5.89213036e-02f,
  9.51557308e-02f, 6.50062114e-02f, -1.12733886e-01f, -1.71440557e-01f, -1.47845864e-01f, -3.51755843e-02f, 1.18296845e-02f, -9.93993878e-02f, -6.64299503e-02f, 1.41544975e-02f,
  -3.37934792e-02f, -2.64194943e-02f, -2.91344654e-02f, 4.23910692e-02f, 5.86845959e-03f, 6.60516415e-03f, 1.94447767e-02f, -2.45200358e-02f, 1.92016214e-02f, 6.04431480e-02f,
  -3.56603786e-02f, -6.19657896e-02f, 3.63115082e-03f, 6.26395550e-03f, 9.69058871e-02f, -2.87333447e-02f, -6.58699311e-03f, -6.99764267e-02f, -2.15662308e-02f, 2.75343703e-03f,
  2.13875081e-02f, -1.25044277e-02f, -1.25704426e-02f, -1.37244863e-02f, 2.56041382e-02f, 5.13290055e-02f, 2.06225365e-02f, 3.75534892e-02f, -2.99538150e-02f, -1.34225907e-02f,
  1.25232622e-01f, -2.05838159e-01f, 1.16608247e-01f, -3.86626720e-02f, -4.24697734e-02f, 1.61767527e-02f, 8.68684798e-02f, -2.65130145e-03f, 2.94878054e-02f, -2.70526158e-03f,
  -6.89308792e-02f, 4.72999252e-02f, 2.85993945e-02f, -1.38514200e-02f, 1.22000342e-02f, 6.60722554e-02f, -6.68993890e-02f, 9.12035182e-02f, 1.41743645e-02f, -5.76218329e-02f,
  -2.88607925e-02f, 2.88157351e-02f, -5.40957153e-02f, -5.26717538e-03f, -1.15081307e-03f, 1.15712695e-01f, -1.44543899e-02f, 3.77578773e-02f, -7.08123818e-02f, -2.20705234e-02f,
  -2.16439024e-01f, -2.15338431e-02f, -3.64707448e-02f, -8.41457918e-02f, -2.24813133e-01f, -2.78147578e-01f, -3.58577251e-01f, -1.85165957e-01f, -1.64697528e-01f, -1.64274558e-01f,
  4.40353528e-02f, 8.94948393e-02f, -1.82098113e-02f, -3.39718312e-02f, -4.84463526e-03f, -1.78385273e-01f, -2.35238999e-01f, -2.60514468e-02f, -1.64945170e-01f, -1.34444281e-01f,
  -1.55555472e-01f, -1.27304360e-01f, -7.26672634e-02f, -9.95950308e-03f, -7.49737993e-02f, 8.78372937e-02f, -4.97936495e-02f, 1.93594173e-02f, 6.53871596e-02f, -1.12545311e-01f,
  1.46434903e-01f, -1.94738284e-02f, 5.78335598e-02f, -7.85070658e-02f, -4.69761491e-02f, 9.31819826e-02f, 8.41612462e-03f, 3.01321130e-02f, -7.34519493e-03f, 2.55167633e-02f,
  1.36693623e-02f, -1.88976415e-02f, -5.64361066e-02f, 9.43632647e-02f, -3.31231542e-02f, 2.93603372e-02f, -8.72073546e-02f, 8.65333527e-03f, 2.10184772e-02f, 5.63954897e-02f,
  7.12245842e-03f, -3.65234129e-02f, -5.20532317e-02f, 5.56230433e-02f, 8.41078833e-02f, 5.23075182e-03f, 3.18936184e-02f, 3.64808515e-02f, 1.34080991e-01f, -4.39395905e-02f,
  -4.47193794e-02f, 4.95940968e-02f, -1.37016084e-02f, 1.50890583e-02f, -4.88145724e-02f, 3.42299640e-02f, -6.45799413e-02f, 2.57007144e-02f, -1.16003737e-01f, 5.45259975e-02f,
  5.72965946e-03f, -2.26098392e-02f, -3.91634665e-02f, 3.18000726e-02f, 1.29334617e-03f, -7.18469471e-02f, 4.14656028e-02f, -2.64783651e-02f, -1.69009541e-03f, 6.59175888e-02f,
  -7.18140677e-02f, 1.47599159e-02f, 4.01462242e-02f, 4.19484265e-02f, 7.57175535e-02f, -8.13419595e-02f, -5.68521582e-02f, 1.91338509e-02f, 7.56200254e-02f, -4.91068996e-02f,
  9.88444239e-02f, 1.03191342e-02f, -3.69554497e-02f, -7.63045950e-03f, -2.20876317e-02f, 6.02947474e-02f, 9.89798680e-02f, -3.67367454e-02f, 5.66913262e-02f, -4.45290394e-02f,
  -4.80933674e-03f, -2.45388094e-02f, 2.73664277e-02f, -2.32811663e-02f, -4.08672579e-02f, -9.51264519e-03f, -6.80646300e-02f, -5.92755191e-02f, 5.75352386e-02f, 3.51180658e-02f,
  1.78328175e-02f, -6.32168502e-02f, -8.25793073e-02f, 3.10918018e-02f, -3.94115262e-02f, -2.73034126e-02f, 2.86390074e-02f, -4.75257868e-03f, 4.69220877e-02f, -8.36137533e-02f,
  -9.35645625e-02f, -1.46180272e-01f, 4.03133720e-01f, -6.96739275e-03f, 4.01826948e-03f, 6.69056177e-02f, -7.03261867e-02f, -5.24069294e-02f, -1.02011539e-01f, -7.16130137e-02f,
  -6.18200190e-02f, -7.75815621e-02f, -7.09769875e-02f, -2.33722255e-02f, -4.39572744e-02f, -1.16032884e-02f, -9.02787969e-02f, 5.16868979e-02f, 2.22912326e-01f, -1.08424835e-01f,
  -2.28349149e-01f, -1.07194908e-01f, 8.66128877e-02f, -1.36637138e-02f, -8.83270726e-02f, -1.24476552e-01f, 1.26275510e-01f, -1.24138612e-02f, -7.97302872e-02f, -2.55010784e-01f,
  9.98314992e-02f, 1.04560092e-01f, 1.30130127e-01f, -1.41234666e-01f, 1.33842500e-02f, -4.03675549e-02f, 5.29867746e-02f, 2.38364469e-02f, -3.07218991e-02f, 8.47149361e-03f,
  3.44376862e-02f, 1.97089761e-02f, -4.47894186e-02f, -7.00069824e-03f, 1.60627030e-02f, 1.90155080e-03f, -1.95104331e-02f, 1.65662870e-01f, 1.07745498e-01f, 4.23303386e-03f,
  -9.42586288e-02f, -5.74046522e-02f, 7.30101317e-02f, 1.61196128e-01f, 5.92275187e-02f, 1.44362718e-01f, 1.32289097e-01f, 1.48673505e-01f, 1.62390530e-01f, -1.21853873e-01f,
  2.16865800e-02f, -2.49017142e-02f, 4.63915281e-02f, 1.60104111e-02f, -2.99393069e-02f, 2.64875945e-02f, -3.63154076e-02f, 3.46211381e-02f, 9.14813951e-02f, -6.62557483e-02f,
  -1.67816766e-02f, 5.54706827e-02f, -5.15272841e-02f, -3.71297896e-02f, 4.38564718e-02f, 7.74513111e-02f, -9.61886719e-03f, -1.73612721e-02f, 2.86980029e-02f, 1.93273146e-02f,
  1.01472400e-02f, 5.47342598e-02f, -1.94414239e-02f, 2.47822572e-02f, 2.38750526e-03f, 1.71072800e-02f, -9.25534442e-02f, -2.28627250e-02f, 4.34504226e-02f, -1.97247005e-06f,
  7.69911483e-02f, 2.10229203e-01f, -6.86667114e-02f, 3.25447246e-02f, 5.70022538e-02f, 8.47537443e-02f, -8.62441212e-02f, 2.60926019e-02f, -3.51319127e-02f, -8.33115168e-03f,
  -4.82982174e-02f, -3.02268919e-02f, 4.57423776e-02f, -1.88518539e-02f, 9.28248540e-02f, 3.42219435e-02f, -5.63401058e-02f, 4.96817753e-02f, 4.59582508e-02f, 7.69110071e-03f,
  -1.00211024e-01f, -6.87400475e-02f, 1.06905997e-01f, 8.76848400e-02f, -8.89378879e-03f, -8.86893366e-03f, 4.36504968e-02f, 6.66420767e-03f, 1.67387038e-01f, -1.38420016e-01f,
  -4.49201435e-01f, 2.72376418e-01f, 1.32996500e-01f, -6.07401095e-02f, 7.27974623e-03f, -5.84387071e-02f, 1.28795132e-02f, -1.38944596e-01f, -7.13368729e-02f, 9.91000086e-02f,
  1.75808355e-01f, -6.84288740e-02f, -4.57085930e-02f, -1.38054108e-02f, -3.43655273e-02f, 5.17137460e-02f, -1.76187232e-02f, -1.37557939e-01f, -3.03466082e-01f, -1.24876358e-01f,
  -1.81267932e-02f, -1.73431158e-01f, -1.22270636e-01f, -1.36085376e-02f, 7.88279921e-02f, 3.20131108e-02f, 2.24928334e-01f, 1.29998803e-01f, 1.99188888e-01f, 1.47759065e-01f,
  1.17433123e-01f, 5.20630414e-03f, -1.04391053e-01f, 1.80507712e-02f, 1.70856223e-01f, -6.14236481e-02f, -5.64069934e-02f, 1.05252035e-01f, 6.88022673e-02f, 1.90870035e-02f,
  5.34077622e-02f, -1.27685508e-02f, 7.48602673e-02f, 6.74635097e-02f, -6.40491992e-02f, -1.37480065e-01f, -7.18053505e-02f, -9.57736745e-02f, 4.26487625e-02f, 1.36977481e-03f,
  1.52265549e-01f, 4.82646376e-02f, -5.71051314e-02f, -4.75334711e-02f, 7.58948401e-02f, -1.89942867e-02f, 5.94653487e-02f, 3.93735394e-02f, 1.37862088e-02f, 1.06395222e-02f,
  -6.76700249e-02f, 6.05242625e-02f, -4.50668670e-02f, 8.15910846e-02f, -8.17993134e-02f, 4.00536954e-02f, 5.53668365e-02f, 5.56890445e-04f, 2.25659483e-03f, 1.17724920e-02f,
  3.62465493e-02f, -5.76330498e-02f, 1.53085319e-02f, 1.24266520e-02f, 2.18008272e-02f, 2.35326905e-02f, -4.16346069e-04f, 1.98274758e-02f, -3.50915976e-02f, -1.19121894e-02f,
  -6.21068142e-02f, -8.63847614e-04f, 8.20571110e-02f, 2.15245574e-03f, 3.52737866e-02f, -1.93162803e-02f, -4.42882860e-03f, -2.03743801e-02f, -1.51201375e-02f, -3.63633595e-02f,
  -6.81162030e-02f, 6.74491078e-02f, -1.14678420e-01f, -9.45177525e-02f, -2.77914368e-02f, 3.99239361e-02f, 5.47594577e-02f, -1.43079069e-02f, 5.10716848e-02f, -9.60158333e-02f,
  5.76226274e-03f, -5.57377823e-02f, 7.47581124e-02f, -9.76241892e-04f, -1.52404264e-01f, -3.14457789e-02f, 3.05782612e-02f, -7.37238601e-02f, -7.51284957e-02f, -5.77449873e-02f,
  -6.46973252e-02f, -1.56358764e-01f, -2.34025791e-01f, -1.45671964e-01f, -8.56925845e-02f, -1.16865091e-01f, -4.15714197e-02f, -1.16661139e-01f, -1.92009211e-01f, -2.30218410e-01f,
  -1.43428996e-01f, -2.75755748e-02f, -1.41840085e-01f, -8.77288803e-02f, 3.32491733e-02f, 2.04795137e-01f, 2.26410568e-01f, 1.31443650e-01f, -6.30745441e-02f, 6.28544390e-02f,
  -6.36346126e-03f, 7.54589960e-02f, 4.23819683e-02f, 9.16996449e-02f, 5.89774735e-02f, 1.77391022e-02f, 7.17209429e-02f, -1.33370340e-01f, -8.91899168e-02f, -9.58200544e-02f,
  7.30403587e-02f, -7.35275596e-02f, -1.65885791e-01f, -1.03264362e-01f, -1.37992874e-01f, -5.93221635e-02f, -7.65376911e-02f, -9.96816531e-02f, 7.68854097e-02f, -7.51026794e-02f,
  -9.95527282e-02f, -6.22640587e-02f, 7.16618821e-02f, 5.79895824e-02f, 6.60182089e-02f, -2.44072755e-03f, 9.29891244e-02f, 2.13813665e-03f, 8.08655396e-02f, 3.52005921e-02f,
  8.12947899e-02f, -7.00832680e-02f, -4.40341467e-03f, -6.40691072e-02f, -9.90174487e-02f, 1.22320978e-02f, -1.23863779e-01f, -8.34923163e-02f, 4.56789657e-02f, -9.40314457e-02f,
  -3.42484973e-02f, 3.63466144e-02f, -1.20467633e-01f, -4.19672802e-02f, -9.30907801e-02f, -3.24965976e-02f, 3.67189050e-02f, -6.88871145e-02f, 7.58597068e-03f, -1.83252916e-02f,
  2.87978072e-03f, -1.09201502e-02f, -1.90669596e-02f, 2.47341357e-02f, -1.97522193e-02f, -3.94064486e-02f, 2.36570444e-02f, 5.62478080e-02f, 4.99360003e-02f, -2.85682594e-03f,
  -7.54732937e-02f, 3.19329090e-02f, -4.17816713e-02f, 7.29447510e-03f, -6.70327470e-02f, 2.66012326e-02f, 3.81839126e-02f, 6.10268582e-03f, -5.07677123e-02f, -1.49264783e-02f,
  -2.10634135e-02f, -1.63695700e-02f, -1.23505272e-01f, 3.81342019e-03f, -5.71302995e-02f, 8.49949494e-02f, -6.52487064e-03f, 7.34386295e-02f, 7.06016123e-02f, 4.33417922e-03f,
  -1.59692336e-02f, 1.11024089e-01f, -1.00600384e-01f, 1.97599623e-02f, -5.72538525e-02f, 3.04337521e-03f, -6.38313070e-02f, -9.51902382e-03f, 3.45063047e-03f, -4.81618494e-02f,
  -1.83996856e-02f, -8.84288922e-02f, -9.48203634e-03f, -7.88621977e-03f, 3.36392820e-02f, 5.84499128e-02f, -8.19283426e-02f, -1.06870636e-01f, 2.66861673e-02f, -9.52335373e-02f,
  7.10810572e-02f, 3.09199393e-02f, -4.33192998e-02f, -4.02663127e-02f, -8.32372308e-02f, -2.49716174e-02f, -6.40560240e-02f, 2.83610076e-02f, 1.33770406e-02f, -1.38892174e-01f,
  9.90701243e-02f, -2.46795475e-01f, -1.03652803e-02f, -6.67160898e-02f, -3.11169531e-02f, 5.02300784e-02f, -9.64567736e-02f, 5.82556911e-02f, -4.52314317e-02f, -1.57155797e-01f,
  5.89312539e-02f, -4.37857732e-02f, -1.23191942e-02f, 3.23653631e-02f, 1.18838832e-01f, -8.70537460e-02f, -1.09474018e-01f, 1.71984017e-01f, 2.41576955e-01f, 8.18950012e-02f,
  -2.30289921e-02f, 3.92443947e-02f, 1.42388254e-01f, 6.48249984e-02f, -1.60860240e-01f, 9.00416821e-03f, -4.25179489e-03f, -6.25084639e-02f, 8.91292188e-03f, -2.12876275e-01f,
  -1.42657802e-01f, 1.40788257e-01f, 1.26315549e-01f, 1.27146423e-01f, 3.43421213e-02f, 1.02278233e-01f, 1.00539088e-01f, 4.75137793e-02f, 5.91978319e-02f, -8.81999955e-02f,
  1.09829113e-01f, 1.31468490e-01f, 1.84734408e-02f, -2.94685084e-02f, 8.89572054e-02f, 7.82022327e-02f, 9.56170931e-02f, 1.36825740e-01f, 6.43624291e-02f, -2.36327923e-03f,
  -1.03480250e-01f, -2.94700242e-03f, -4.63486789e-03f, -1.25624221e-02f, 9.40397605e-02f, 2.45622918e-02f, 5.12670688e-02f, 4.49379981e-02f, 1.32472351e-01f, -1.97893813e-01f,
  -3.24668400e-02f, 4.71149664e-03f, 3.37147191e-02f, 2.30711307e-02f, -2.80741565e-02f, -4.16768305e-02f, 4.79560420e-02f, -2.50921790e-02f, 1.20850028e-02f, 5.40696830e-02f,
  -3.39215323e-02f, 6.93610031e-03f, 3.26361619e-02f, -5.76121360e-02f, -5.83320223e-02f, 9.32268240e-03f, -2.46722400e-02f, -7.61313587e-02f, 8.66557378e-03f, 2.53358167e-02f,
  6.44907057e-02f, -1.79773159e-02f, 9.30341184e-02f, -5.61541095e-02f, 1.57648261e-04f, 5.61188944e-02f, -4.69138138e-02f, -3.70136723e-02f, -3.29369493e-02f, 5.51933870e-02f,
  -1.92550242e-01f, 1.83449551e-01f, -1.59600183e-01f, -3.57981063e-02f, -1.79337971e-02f, -6.09130487e-02f, -6.11180738e-02f, 1.00188091e-01f, -2.60146521e-02f, 4.23908904e-02f,
  -2.33700499e-03f, -1.29236383e-02f, -9.64071602e-02f, -5.67202047e-02f, -3.14972699e-02f, 4.00251104e-03f, -1.51938766e-01f, -8.44789445e-02f, -3.76042239e-02f, -9.17799696e-02f,
  -1.09010682e-01f, -8.16484019e-02f, -1.37977004e-01f, -4.85622212e-02f, -9.88769680e-02f, 3.14481109e-02f, -1.02082573e-01f, -1.15830489e-01f, 4.11682576e-02f, -2.57267326e-01f,
  -1.32378235e-01f, -1.21530682e-01f, -3.15218568e-01f, -9.24879909e-02f, -6.84789568e-02f, -2.20003370e-02f, -4.55886424e-02f, 4.77250889e-02f, 9.36498865e-02f, 2.08097175e-02f,
  5.83661161e-02f, 5.35170198e-04f, -1.07401237e-01f, -2.98383627e-02f, -1.10137671e-01f, -9.81836915e-02f, -1.59078822e-01f, -7.68467784e-02f, -1.61930129e-01f, 1.02125987e-01f,
  -3.02105676e-02f, -1.37196690e-01f, -5.09737525e-03f, -1.08461462e-01f, 8.47985595e-02f, 2.96784472e-02f, -1.52719557e-01f, -9.54498425e-02f, -9.41864178e-02f, -3.41723748e-02f,
  -1.17391117e-01f, -1.06893584e-01f, 3.30190845e-02f, 2.45794877e-02f, -4.30243351e-02f, 1.15141403e-02f, 2.92891487e-02f, -8.55663568e-02f, -6.35012016e-02f, -4.95796949e-02f,
  -2.49765888e-02f, 2.01880615e-02f, -1.05542250e-01f, -3.06092408e-02f, 7.02143386e-02f, 3.35813646e-04f, -8.82876739e-02f, 4.64929081e-02f, -1.05872363e-01f, -8.53047241e-04f,
  -7.83783442e-04f, -3.61640155e-02f, -1.44497901e-02f, 2.83572474e-03f, 8.82746801e-02f, -1.37511626e-01f, -1.76834483e-02f, 1.24182925e-01f, -5.79053499e-02f, 2.39700694e-02f,
  1.42498855e-02f, 1.44693125e-02f, -1.80693157e-02f, 7.99886510e-02f, 2.32485570e-02f, -4.25442010e-02f, -2.40314216e-03f, 1.11455647e-02f, 8.12028274e-02f, -3.06246802e-02f,
  -6.86241128e-03f, 2.17376128e-02f, 4.28532157e-03f, 3.63296606e-02f, 3.56058357e-03f, 1.96380094e-02f, -5.04027074e-03f, 3.50859575e-03f, -3.28295901e-02f, 7.46342018e-02f,
  3.24833617e-02f, -4.37083887e-03f, -1.60640832e-02f, 1.30162071e-02f, 6.01480575e-03f, 4.50370647e-02f, 6.41108826e-02f, 4.90438230e-02f, 5.97404279e-02f, -1.17678652e-02f,
  -3.45947146e-02f, -2.07028717e-01f, 7.69515783e-02f, 3.16210203e-02f, -5.53095043e-02f, -3.52673233e-02f, -5.16825244e-02f, -2.05308641e-03f, 5.29487506e-02f, 1.03226500e-02f,
  -5.71847260e-02f, 8.01798850e-02f, -2.87737660e-02f, 1.66239515e-02f, 8.76972973e-02f, -4.58145328e-02f, 7.31278807e-02f, -4.95913588e-02f, 1.46495607e-02f, -2.72332486e-02f,
  -3.49779539e-02f, 1.06144167e-01f, 8.65780339e-02f, 9.59378947e-03f, 8.24475065e-02f, 3.54933776e-02f, -2.48728599e-02f, 1.99654866e-02f, -5.84147312e-02f, 1.03572384e-01f,
  -3.05757046e-01f, -1.50109217e-01f, -7.89410844e-02f, 1.50757492e-01f, 2.86918312e-01f, 1.67352930e-01f, -3.72821800e-02f, -3.57614756e-02f, 1.01564296e-01f, 6.20095022e-02f,
  1.03715025e-01f, -7.31475949e-02f, -1.32918149e-01f, -1.68542862e-01f, -2.73732990e-01f, -1.56887710e-01f, -9.10880417e-02f, -8.93472135e-02f, -1.34867564e-01f, -2.34575057e-03f,
  1.53452590e-01f, 1.26730710e-01f, -3.27698737e-02f, 5.11716790e-02f, 2.60900147e-02f, 7.80381262e-02f, 7.54365772e-02f, 1.62868835e-02f, -3.13448347e-02f, -7.58116096e-02f,
  -1.77616850e-01f, -7.86475614e-02f, 1.99644230e-04f, 3.34190913e-02f, 1.41892776e-01f, -1.13198817e-01f, 4.86856466e-03f, 7.62317004e-03f, 2.96351779e-02f, -8.10077637e-02f,
  3.15311477e-02f, -1.02352217e-01f, -1.23037444e-02f, -7.68171176e-02f, 2.23482493e-02f, -1.65386721e-02f, -3.78642255e-03f, -1.84503168e-01f, -1.47436365e-01f, 4.10520062e-02f,
  1.62108809e-01f, 1.55325059e-03f, -7.67301098e-02f, -1.09164774e-01f, -6.06461130e-02f, -7.96692297e-02f, -1.14717364e-01f, -7.06234500e-02f, -9.46853086e-02f, -1.54335707e-01f,
  3.34131569e-02f, -5.53742656e-03f, 9.88149736e-03f, -8.53189453e-02f, 9.27684270e-03f, -3.48462677e-03f, -3.65263224e-02f, 1.96947418e-02f, -1.77578498e-02f, 4.53133471e-02f,
  -9.70531069e-03f, 2.26538442e-02f, 7.63524789e-03f, -8.29365402e-02f, 6.34723529e-02f, 5.12362756e-02f, -3.45150270e-02f, 6.29644748e-03f, 3.57332304e-02f, -3.96602899e-02f,
  -3.82243209e-02f, 1.76600013e-02f, -1.95646496e-03f, -1.73137225e-02f, 3.11865788e-02f, 2.08972357e-02f, -3.50658549e-03f, 3.60482596e-02f, -6.34502247e-02f, -4.54886742e-02f,
  2.41065715e-02f, 5.56483455e-02f, -4.68579009e-02f, -9.89317819e-02f, 5.36405817e-02f, 4.40100990e-02f, 4.28971350e-02f, 3.68628930e-03f, -4.10400182e-02f, -5.85823841e-02f,
  4.50111032e-02f, -6.90923259e-02f, 2.27037277e-02f, 4.57569733e-02f, 7.08737783e-03f, -2.50463691e-02f, 7.54797906e-02f, 1.82551295e-02f, -4.51419950e-02f, 3.22691142e-03f,
  7.82364905e-02f, 4.71888948e-03f, -3.58299427e-02f, 4.50431788e-03f, -2.55777072e-02f, 2.11696737e-02f, 3.29094380e-02f, 2.44008731e-02f, -3.56274620e-02f, -6.61610290e-02f,
  -4.22040135e-01f, -1.18034430e-01f, -1.79602116e-01f, -3.17010015e-01f, -5.64191602e-02f, -5.74104153e-02f, 5.33363596e-03f, -1.49323851e-01f, 7.82747753e-03f, -1.17612176e-01f,
  8.58623534e-02f, 2.07216412e-01f, 7.65214339e-02f, 2.14484379e-01f, 2.58982796e-02f, 1.28528674e-03f, -1.59181148e-01f, -6.60650898e-03f, -4.00935747e-02f, 4.08193953e-02f,
  -4.62348275e-02f, -8.80301967e-02f, -7.80714601e-02f, -3.69463079e-02f, -6.90766796e-02f, 1.59884542e-02f, -4.89390194e-02f, -2.72571929e-02f, -3.09085138e-02f, -7.54841194e-02f,
  1.05318330e-01f, -5.50943613e-02f, 1.02973744e-01f, 2.23988947e-03f, 5.10293245e-02f, -2.20550206e-02f, 5.74922413e-02f, -9.25750062e-02f, 4.02703285e-02f, -1.21966098e-02f,
  8.51292163e-02f, 3.15761194e-03f, -6.12696726e-03f, -6.25699526e-03f, 1.74887981e-02f, -4.53001112e-02f, 1.13399560e-02f, 5.36897629e-02f, 4.04396048e-03f, 5.69222644e-02f,
  8.51009390e-04f, -3.35677601e-02f, -1.01581082e-01f, 1.58720408e-02f, 7.13555887e-02f, 6.47996366e-02f, -1.48101719e-02f, 5.18035144e-02f, -8.06494355e-02f, -2.00343668e-01f,
  2.65166610e-02f, 8.75768661e-02f, -4.77521643e-02f, 1.37083894e-02f, 4.89783697e-02f, 6.03751726e-02f, 2.30959896e-02f, -1.87482238e-02f, -4.94314879e-02f, -6.84327707e-02f,
  3.31069231e-02f, 6.66292151e-03f, 5.97387403e-02f, -1.01624943e-01f, -3.85289863e-02f, 1.94193551e-03f, -5.10687642e-02f, -2.57531479e-02f, 4.29760218e-02f, -6.27434924e-02f,
  2.26964019e-02f, 1.51431672e-02f, -9.01810974e-02f, -3.06850169e-02f, -3.02843265e-02f, 2.72934139e-02f, 2.96637807e-02f, 3.84105593e-02f, -5.79895750e-02f, 2.28287652e-02f,
  3.06084473e-02f, 4.76510189e-02f, -9.26585775e-03f, 3.35422978e-02f, -2.14840155e-02f, -6.21583909e-02f, 5.91654330e-02f, -3.63989398e-02f, -7.09353536e-02f, -7.56195709e-02f,
  -2.11440232e-02f, -2.58848462e-02f, 2.13962309e-02f, 1.59534849e-02f, 1.12410206e-02f, 2.32160455e-05f, -1.06979094e-01f, 3.75410579e-02f, 2.75335182e-02f, -5.87271489e-02f,
  -1.13840289e-01f, -4.07492071e-02f, 1.55969746e-02f, -2.95019918e-03f, -9.56519917e-02f, -5.89826889e-02f, -6.82300106e-02f, 6.14574440e-02f, 3.97169217e-02f, -9.21572372e-02f,
  3.19811732e-01f, -1.33211939e-02f, 4.57176790e-02f, -1.96474437e-02f, -1.95680484e-01f, -2.92712122e-01f, -2.82206863e-01f, -4.01968583e-02f, -2.09969021e-02f, 5.86534990e-03f,
  -7.94904977e-02f, -6.42070100e-02f, 1.65175591e-02f, 9.13216919e-02f, 1.36802513e-02f, -1.66186810e-01f, 2.81762797e-03f, 4.77796793e-02f, -6.17409907e-02f, -1.03618018e-01f,
  -5.36325760e-02f, 8.45669731e-02f, 1.97518528e-01f, 6.53084368e-02f, -4.34502661e-02f, 1.93020869e-02f, 5.46368025e-02f, 9.28658769e-02f, -5.52577041e-02f, -2.61217002e-02f,
  -7.50901476e-02f, 2.13386461e-01f, -1.16702244e-01f, 8.65987018e-02f, 1.34159587e-02f, 1.35304164e-02f, 4.93839234e-02f, 9.33821499e-02f, -1.10483179e-02f, -7.79278055e-02f,
  4.11295071e-02f, 7.64525458e-02f, -1.79739837e-02f, -5.27307875e-02f, 5.42707220e-02f, -3.36664659e-03f, 1.50861114e-01f, 1.22277141e-01f, 8.08638781e-02f, -4.67768759e-02f,
  -3.99378836e-02f, 1.06197163e-01f, 7.99614340e-02f, -9.28910449e-02f, 6.63775057e-02f, -2.36677695e-02f, -5.68936169e-02f, 6.67756870e-02f, 1.02512538e-01f, -4.96306233e-02f,
  -1.39197288e-02f, 4.74969782e-02f, 3.85820456e-02f, 4.38404344e-02f, -8.08209628e-02f, -6.94435537e-02f, -7.12717175e-02f, -7.21883327e-02f, 3.13208112e-03f, -1.34156104e-02f,
  5.82905822e-02f, -3.16697359e-02f, 3.70586440e-02f, -6.64981306e-02f, -2.22212169e-02f, 6.61073625e-02f, -3.72106656e-02f, 1.58880949e-02f, 3.53700109e-02f, 6.86991140e-02f,
  -7.78582355e-04f, -3.01362807e-03f, 3.11190053e-03f, -4.37127240e-02f, 8.31888895e-03f, 5.37192076e-03f, 6.36077002e-02f, 5.86515553e-02f, 8.00883025e-02f, -4.36209925e-02f,
  -1.39523312e-01f, -1.56833641e-02f, -3.65772992e-02f, 5.99439330e-02f, -2.83599040e-03f, 1.41372494e-02f, -8.75262618e-02f, 7.32042268e-02f, 5.18492088e-02f, 1.35183372e-02f,
  8.35910738e-02f, -6.13118634e-02f, -1.13020279e-02f, 3.48150656e-02f, -4.92843501e-02f, -1.13369636e-01f, 4.35133204e-02f, -2.54074819e-02f, -6.03852095e-03f, 4.99218591e-02f,
  -2.39118170e-02f, -1.38851419e-01f, -3.24960500e-02f, -1.15744248e-01f, -2.92456988e-02f, -1.56372339e-01f, -1.81209937e-01f, -4.76927422e-02f, -5.63831925e-02f, -2.36273751e-01f,
  3.51316899e-01f, -2.03286752e-01f, 2.00691551e-01f, 2.43852437e-02f, -8.11747611e-02f, -9.11565870e-02f, -2.34812647e-01f, -8.05432871e-02f, 1.77824404e-04f, -1.14786111e-01f,
  -1.09464057e-01f, -8.63993168e-03f, -5.36036491e-03f, 3.72818038e-02f, 1.36777729e-01f, -4.08888087e-02f, 5.22483326e-02f, 2.68902540e-01f, 2.18218222e-01f, -6.15995191e-02f,
  7.25377351e-03f, -1.48916915e-02f, 1.27947524e-01f, 1.17653139e-01f, -7.10747689e-02f, -4.88883853e-02f, -6.09050505e-02f, -3.49607281e-02f, -4.87212278e-02f, 5.99260703e-02f,
  -6.82919621e-02f, 1.05380230e-01f, 1.19432798e-02f, 9.30766240e-02f, -4.74578589e-02f, 6.18715174e-02f, -1.81546845e-02f, 2.63821650e-02f, 2.19771732e-02f, -5.33749461e-02f,
  -3.79403643e-02f, -7.04783723e-02f, 3.49736735e-02f, -8.64532813e-02f, -7.99015760e-02f, -3.12057026e-02f, 3.44917923e-02f, 1.21747822e-01f, 9.98955891e-02f, -5.23066930e-02f,
  -1.26931546e-02f, 2.47785170e-03f, -9.02096629e-02f, -9.47218463e-02f, -5.67582361e-02f, -1.34637291e-02f, -2.88244206e-02f, 3.39885801e-02f, -2.20256462e-03f, -1.12739559e-02f,
  2.20001768e-02f, 2.20636800e-02f, -4.06730501e-03f, 4.27414803e-03f, 4.19503823e-02f, 6.71042595e-03f, -7.44341463e-02f, 3.04530212e-03f, -7.03784302e-02f, 6.54569194e-02f,
  -5.40683977e-02f, 4.83945496e-02f, -2.84424126e-02f, -1.91127963e-03f, 4.56888378e-02f, 3.72459330e-02f, -6.59730881e-02f, 1.90345664e-02f, 1.93044264e-02f, -6.45811856e-02f,
  -1.44035248e-02f, -6.11920692e-02f, 8.94496068e-02f, -7.63526857e-02f, -3.28648984e-02f, 4.03849520e-02f, 4.20443453e-02f, -5.18047139e-02f, -5.79817547e-03f, -7.06975013e-02f,
  -9.94680896e-02f, -4.73166443e-02f, -5.53519055e-02f, 1.73996724e-02f, 2.29909513e-02f, 1.81919187e-02f, -3.39815579e-02f, 5.49678504e-02f, 4.75971363e-02f, -7.35993460e-02f,
  -1.43559445e-02f, 5.27032092e-02f, -7.50354379e-02f, -6.45505264e-02f, -1.30437256e-04f, 2.67119296e-02f, 2.62709707e-02f, 6.22355826e-02f, 3.17010246e-02f, 1.83193199e-03f,
  -5.48995882e-02f, 8.63548741e-02f, -4.68829572e-02f, -3.27497572e-02f, 5.66480272e-02f, 9.78965908e-02f, 3.24267969e-02f, -6.02385961e-02f, 2.24815924e-02f, -6.41390905e-02f,
  -2.35481694e-01f, -1.85754642e-01f, -2.21973255e-01f, 3.76307443e-02f, 1.12826139e-01f, 1.16820291e-01f, 1.33771569e-01f, 1.87297672e-01f, 6.77604377e-02f, -1.98011585e-02f,
  -1.01386361e-01f, -4.82523777e-02f, -2.42757034e-02f, -6.83587343e-02f, 2.77254805e-02f, 7.91872758e-03f, 1.23282038e-01f, -1.45642310e-02f, 1.78326935e-01f, 2.17444330e-01f,
  1.41071051e-01f, 7.35904053e-02f, -4.75606136e-02f, 1.57877640e-03f, -1.48748001e-02f, -3.86690348e-02f, -1.68944702e-01f, -7.17019588e-02f, -1.01213045e-01f, -1.19754769e-01f,
  -2.79623389e-01f, -3.18163991e-01f, 1.75674662e-01f, -3.28857712e-02f, -3.98571640e-02f, 6.88192435e-03f, -4.18832004e-02f, -1.30311549e-01f, -6.40295446e-02f, 3.28153372e-03f,
  -7.49050602e-02f, 4.00869995e-02f, 3.60974409e-02f, -1.56633593e-02f, 5.06776497e-02f, -2.03833338e-02f, -6.83111325e-02f, -5.54184057e-02f, -2.79352795e-02f, -3.47095430e-02f,
  8.22319686e-02f, 2.14697774e-02f, -8.32919106e-02f, -2.52749305e-02f, -1.01105131e-01f, 3.93304378e-02f, -1.06114052e-01f, -7.90400505e-02f, 1.38134668e-02f, -4.37883846e-02f,
  4.16136831e-02f, -7.38182515e-02f, 2.72915661e-02f, 5.62393181e-02f, 5.34974746e-02f, -4.35693078e-02f, 4.65062708e-02f, 8.11958984e-02f, -3.21224742e-02f, -4.03790735e-02f,
  2.85116751e-02f, -7.20637143e-02f, 1.59031362e-04f, 1.45141929e-02f, -4.94038267e-03f, 1.08244941e-02f, 6.00605085e-03f, 3.97897661e-02f, -3.63114141e-02f, -2.04371121e-02f,
  -4.61085588e-02f, -3.59621681e-02f, -7.73313344e-02f, 4.69047800e-02f, 1.90951675e-02f, -4.55082022e-02f, 1.88793130e-02f, 8.99847001e-02f, -8.04531500e-02f, 3.12841274e-02f,
  1.67708576e-03f, -4.64149192e-03f, -1.94793846e-02f, 1.62407178e-02f, -6.40101880e-02f, 4.07207124e-02f, 2.57522035e-02f, 3.77548561e-02f, -3.64554040e-02f, 6.86619729e-02f,
  4.50982340e-02f, 4.91487272e-02f, -9.07798335e-02f, 2.94181537e-02f, 6.07650541e-02f, 5.05169146e-02f, 1.20987736e-01f, 1.02040619e-01f, 4.03496902e-03f, 6.63805678e-02f,
  1.16180614e-01f, 1.77677795e-01f, 1.38675079e-01f, 1.24447830e-01f, 1.15538919e-02f, 1.39145195e-01f, 3.39776874e-02f, 1.57294627e-02f, 1.14273630e-01f, 9.68527421e-02f,
  -2.15659350e-01f, -1.35394577e-02f, -1.89345077e-01f, 7.37849576e-03f, 4.68428433e-02f, -6.89935908e-02f, -1.80020839e-01f, -8.43382105e-02f, 2.14853603e-02f, -3.80750932e-02f,
  9.30785239e-02f, 6.33230358e-02f, -2.12852843e-03f, 4.50794920e-02f, -3.75500657e-02f, -8.29373300e-02f, -1.06429897e-01f, -1.81754857e-01f, -1.10373184e-01f, -2.70043332e-02f,
  5.14034107e-02f, -1.10096382e-02f, -4.13234010e-02f, -2.50952449e-02f, 9.36935991e-02f, -4.59156632e-02f, 6.52486682e-02f, 6.21264167e-02f, -4.22958694e-02f, 2.44815759e-02f,
  -1.42404839e-01f, 9.51748267e-02f, -7.50356019e-02f, 9.29040387e-02f, 1.04637161e-01f, -6.56707138e-02f, 3.59056182e-02f, 6.15341701e-02f, 4.39640917e-02f, -2.80866921e-02f,
  4.73099798e-02f, 1.54102528e-02f, -6.02483973e-02f, -4.57309261e-02f, -8.57753083e-02f, -6.10162839e-02f, -1.22673951e-01f, -1.52505890e-01f, 4.14105803e-02f, -7.57006928e-02f,
  1.37898833e-01f, -8.90683383e-03f, -1.73320666e-01f, 1.05172358e-02f, -4.66304682e-02f, 1.19003495e-02f, -8.02347213e-02f, 8.05114061e-02f, -1.09259121e-01f, -5.51053099e-02f,
  -1.60427333e-03f, -3.36478539e-02f, 6.62401766e-02f, -3.16784829e-02f, -7.11352099e-03f, 5.94214350e-02f, -2.02349722e-02f, -5.56325493e-03f, -1.09315431e-03f, -9.50517729e-02f,
  -4.10322137e-02f, 3.07921264e-02f, 4.32001874e-02f, -1.87917557e-02f, 4.21142355e-02f, -9.70138703e-03f, -7.20837293e-03f, 5.57395034e-02f, 3.88734788e-02f, 5.13253808e-02f,
  6.10102005e-02f, -4.05053124e-02f, 3.17108221e-02f, 8.56717452e-02f, 5.80119826e-02f, 2.22262414e-03f, -4.49748375e-02f, 6.19158987e-03f, -4.56671752e-02f, -5.78142367e-02f,
  -1.49941623e-01f, 2.02897996e-01f, -8.45527872e-02f, -6.30870555e-03f, 4.08752337e-02f, 7.16211051e-02f, 2.92343013e-02f, 7.64515027e-02f, 4.62535955e-02f, 9.41810606e-04f,
  4.07827757e-02f, -4.10971642e-02f, -1.67359803e-02f, -1.01132050e-01f, -6.63293973e-02f, -9.77873057e-02f, -1.18612371e-01f, 2.66442494e-03f, 4.04367298e-02f, -5.60778081e-02f,
  3.42675601e-03f, -1.24338955e-01f, -2.37610504e-01f, -8.27994570e-02f, 8.39991728e-04f, -1.08448312e-01f, -4.96178716e-02f, -8.41041729e-02f, -1.88298702e-01f, -2.40357965e-01f,
  -4.01637733e-01f, 1.15458272e-01f, 3.06241274e-01f, -6.32334352e-02f, 2.73199052e-01f, 2.18038425e-01f, 3.13236028e-01f, -7.88812786e-02f, -1.01664111e-01f, -2.05751564e-02f,
  -6.40259609e-02f, -3.27770233e-01f, -2.63457507e-01f, -2.21145093e-01f, -1.49332926e-01f, 1.61772951e-01f, 2.41118699e-01f, -5.81961237e-02f, -3.32564935e-02f, -2.63485257e-02f,
  2.77070552e-02f, -1.20055526e-01f, -2.83866469e-02f, -7.49412552e-02f, 2.53709331e-02f, -1.07732929e-01f, 1.35250539e-01f, 1.25763848e-01f, 1.84322953e-01f, 8.06057528e-02f,
  7.87512735e-02f, 7.72579238e-02f, -2.53356341e-02f, -1.13628425e-01f, 7.42480904e-02f, 1.79564897e-02f, -2.33870745e-02f, -3.35024521e-02f, -6.03142269e-02f, 8.01661052e-03f,
  4.92213592e-02f, -3.19366455e-02f, -6.23672493e-02f, 9.30398107e-02f, 7.90123045e-02f, -2.73857173e-02f, 6.35519996e-02f, -5.77335386e-03f, 4.37707752e-02f, 7.00536445e-02f,
  1.06479928e-01f, 6.22588955e-02f, 1.16464756e-02f, 1.23329058e-01f, -2.31037065e-02f, -6.35651723e-02f, 5.54707982e-02f, 6.88655898e-02f, -1.00764558e-02f, -8.17346275e-02f,
  8.81902501e-03f, -1.16278906e-03f, 8.38708729e-02f, -3.27508263e-02f, -4.09797812e-03f, -1.14002479e-02f, 6.37060627e-02f, 1.61130447e-02f, -4.37548645e-02f, 2.29841582e-02f,
  -1.66514015e-03f, 5.29217049e-02f, -5.70820570e-02f, 2.48075444e-02f, -1.52604431e-02f, 5.98801151e-02f, 6.61436170e-02f, 1.48033630e-02f, 1.64874662e-02f, 4.58143055e-02f,
  -6.14607371e-02f, 3.31909843e-02f, 1.02720279e-02f, 3.26647125e-02f, 6.63378388e-02f, 3.95398736e-02f, -5.94777912e-02f, -1.86026059e-02f, -5.51623758e-03f, 4.98310477e-02f,
  -3.36878240e-01f, 5.01835579e-03f, -1.40316546e-01f, -1.37943745e-01f, 4.11739014e-02f, -6.45836964e-02f, -4.28483114e-02f, -7.60484934e-02f, 4.78042774e-02f, 6.89397193e-03f,
  -1.88214164e-02f, -8.01023096e-02f, 2.17382684e-02f, -3.16018946e-02f, 1.35383718e-02f, -6.09530099e-02f, -3.00989728e-02f, -1.26162097e-02f, -2.24061254e-02f, -3.42832915e-02f,
  -8.12893827e-03f, 4.92996387e-02f, -1.90431580e-01f, -8.17905515e-02f, 1.89876892e-02f, -8.91084820e-02f, -2.83367857e-02f, -2.41726693e-02f, -1.40079901e-01f, -1.23972580e-01f,
  4.74831387e-02f, 2.32379034e-01f, 3.00201267e-01f, -2.50213891e-01f, -1.16388001e-01f, 9.83654261e-02f, 1.41028851e-01f, 7.44582862e-02f, -1.39502838e-01f, 3.88652533e-02f,
  1.66229725e-01f, -1.04679741e-01f, -2.43578982e-02f, -6.50580972e-02f, -3.23447119e-03f, 1.51132345e-01f, -1.29435450e-01f, -1.36740312e-01f, 6.80400105e-03f, -4.18501869e-02f,
  -1.35610238e-01f, -2.10316584e-01f, -1.75946161e-01f, -1.06287152e-01f, -1.01376966e-01f, -3.92412245e-02f, 5.28302863e-02f, 3.39911617e-02f, 1.73897725e-02f, -1.09849244e-01f,
  4.00924534e-01f, 1.94959253e-01f, -4.45819236e-02f, -9.12391543e-02f, 6.64060414e-02f, 6.16734428e-03f, 8.40280056e-02f, 2.97808554e-02f, -5.50050847e-02f, -4.71084118e-02f,
  1.91425066e-02f, 4.16650390e-03f, -4.07327488e-02f, 6.06273450e-02f, -4.40297462e-02f, 1.13162220e-01f, 4.63945717e-02f, 3.22646648e-02f, -1.42045915e-02f, 1.23511359e-01f,
  -1.12467878e-01f, -5.40452590e-03f, 9.38617140e-02f, 7.21566472e-03f, -1.35683920e-02f, -9.12567973e-02f, 1.56208232e-01f, 1.06548853e-01f, -3.08252815e-02f, 1.19162709e-01f,
  -1.67132672e-02f, 2.63164882e-02f, 2.37903111e-02f, -2.59781051e-02f, -5.69293983e-02f, 5.15410230e-02f, -4.80128918e-03f, -2.56355796e-02f, -6.92360252e-02f, 3.62585261e-02f,
  -3.42930704e-02f, -9.23478976e-03f, 4.61669341e-02f, -7.38237277e-02f, 4.64782901e-02f, 3.44382897e-02f, -4.49296273e-02f, -3.56674753e-03f, 4.31625023e-02f, -4.32819612e-02f,
  6.02425262e-02f, -3.19424346e-02f, -2.01584771e-02f, 1.54652065e-02f, 5.87219819e-02f, -3.37228291e-02f, -2.78532021e-02f, 6.25866354e-02f, 6.63337708e-02f, 2.29332503e-02f,
  4.53929380e-02f, -1.03940815e-01f, 1.57845356e-02f, -1.21052740e-02f, -1.48819415e-02f, 1.32412566e-02f, 4.05074805e-02f, -6.70376271e-02f, -7.70739466e-02f, 4.93970588e-02f,
  8.94105136e-02f, -5.76812178e-02f, -1.70841590e-02f, -5.30950085e-04f, -5.97807318e-02f, -1.27315242e-02f, -6.20227978e-02f, -1.21035539e-01f, -7.47794062e-02f, -4.32166271e-02f,
  5.30084483e-02f, -5.22982888e-02f, 2.04084199e-02f, -1.45466905e-02f, -7.32698664e-02f, -1.00172572e-01f, 6.94605634e-02f, 1.18175648e-01f, 8.37835893e-02f, 5.13899922e-02f,
  1.98882475e-01f, 2.20731795e-01f, -5.32405302e-02f, 1.70323551e-01f, 6.52503734e-03f, 7.50488322e-03f, -8.63105431e-02f, 1.13635911e-02f, -1.68215055e-02f, 9.22297016e-02f,
  -1.57988630e-02f, -1.32630214e-01f, -8.37682113e-02f, -1.03059813e-01f, -1.36810383e-02f, -6.70701191e-02f, -9.93802026e-03f, -5.03293760e-02f, -2.22209275e-01f, -5.36787584e-02f,
  -2.58037895e-02f, 6.41076416e-02f, 1.25710562e-01f, -5.82414605e-02f, 7.39600807e-02f, -8.04822445e-02f, 1.45278797e-01f, 1.41856849e-01f, -7.15805069e-02f, 4.81677242e-02f,
  -4.98474985e-02f, 2.79159248e-01f, -7.22426698e-02f, -1.99831352e-02f, -2.47830153e-03f, -1.20271882e-02f, -2.30899062e-02f, 1.28296778e-01f, 6.55692145e-02f, 5.42068891e-02f,
  1.83254399e-03f, 5.35899177e-02f, 6.88168705e-02f, -4.68124188e-02f, 1.50488585e-01f, 1.26895651e-01f, 6.83698207e-02f, -2.45982707e-02f, -9.55316331e-03f, 5.84666766e-02f,
  -3.08704395e-02f, 5.23486175e-02f, 5.92084005e-02f, -2.22326200e-02f, 1.18595824e-01f, -9.63825881e-02f, -1.85445566e-02f, 1.84752997e-02f, -7.14177489e-02f, 1.30484998e-01f,
  -4.98236641e-02f, -5.68940938e-02f, 5.28627336e-02f, 2.40961812e-03f, -3.58183272e-02f, -6.83818832e-02f, -5.94826341e-02f, -2.28850525e-02f, -5.45485644e-03f, 4.33049314e-02f,
  5.15184030e-02f, -6.76304400e-02f, 2.25957111e-02f, -2.46604104e-02f, -2.00365987e-02f, -3.39001156e-02f, -1.29932212e-02f, 2.45148869e-04f, 3.03064529e-02f, 1.22858826e-02f,
  -3.83088998e-02f, -3.46042924e-02f, 1.03815421e-01f, -3.22856046e-02f, -2.94132420e-04f, 3.34347188e-02f, 7.01170936e-02f, 6.93396926e-02f, 3.13741751e-02f, -8.78500007e-03f,
  4.60706055e-02f, -2.15170354e-01f, -9.01527479e-02f, 4.85105142e-02f, 2.03155912e-02f, 4.17019054e-02f, -5.21244248e-03f, -1.20759988e-03f, 8.15782025e-02f, -3.56506146e-02f,
  -8.57909396e-03f, 6.29681200e-02f, -5.38330860e-02f, -2.36358810e-02f, -5.12478203e-02f, -9.04505998e-02f, 9.65899676e-02f, -5.50307706e-02f, -2.95224171e-02f, 7.13542327e-02f,
  3.14112194e-02f, -8.75129253e-02f, -1.01417214e-01f, -1.72778107e-02f, 2.83156168e-02f, -2.14452162e-01f, -5.11831492e-02f, -8.02265387e-03f, -1.55174389e-01f, -9.89375934e-02f,
  7.01556325e-01f, -7.02666072e-03f, -2.94084936e-01f, 2.80052900e-01f, -1.53470665e-01f, -4.21368837e-01f, -3.62372547e-01f, -1.35212429e-02f, 1.03278540e-01f, 5.85409477e-02f,
  -8.90435204e-02f, 2.20149860e-01f, 1.36173844e-01f, -2.85983328e-02f, -1.02437355e-01f, -1.72184095e-01f, -2.40665674e-02f, 2.43795794e-02f, -5.57465628e-02f, -1.09485082e-01f,
  -4.66219410e-02f, 2.03501165e-01f, 2.24381074e-01f, 1.46582872e-01f, 9.06926244e-02f, 1.15280218e-01f, -7.86742568e-02f, 4.87660356e-02f, -2.16259986e-01f, 1.56380996e-01f,
  1.58469900e-02f, 6.95444942e-02f, -4.23730016e-02f, 1.25355139e-01f, -1.74084157e-02f, 1.11132078e-01f, 2.63024820e-03f, 5.01450449e-02f, 6.47334978e-02f, -9.02841147e-03f,
  5.28313443e-02f, -2.85716914e-02f, 6.03053309e-02f, 3.26375291e-02f, 2.94772559e-03f, -2.74834167e-02f, 2.28118729e-02f, 9.55305248e-02f, -5.22864163e-02f, -1.04915246e-01f,
  -4.76698801e-02f, -2.84037441e-02f, -1.33912235e-01f, -1.57284945e-01f, -7.11560324e-02f, 3.28349583e-02f, -5.99594042e-02f, -1.08179143e-02f, -1.36228427e-01f, 1.84866160e-01f,
  2.30971519e-02f, 1.62298605e-02f, -5.97423948e-02f, 2.29572356e-02f, -6.66756695e-03f, 1.52589567e-02f, -3.51174362e-02f, 1.69557109e-02f, -6.45389631e-02f, 2.59371456e-02f,
  -3.22389565e-02f, -2.19823923e-02f, 6.49122661e-03f, 7.21597299e-03f, 2.58491617e-02f, -4.55526635e-02f, 1.01763038e-02f, 2.31850166e-02f, -1.75388027e-02f, 3.79230529e-02f,
  2.55012847e-02f, -1.03798369e-02f, 2.46250387e-02f, -6.36372250e-03f, -1.40143083e-02f, 3.98054048e-02f, 1.80415660e-02f, -3.31513397e-02f, 1.19926967e-02f, 1.98606197e-02f,
  1.24971725e-01f, -1.63375318e-01f, 9.23002735e-02f, 6.78906068e-02f, -2.17815991e-02f, 4.96577621e-02f, 1.74810793e-02f, -2.11316887e-02f, -2.21773069e-02f, 4.63765748e-02f,
  -6.65038601e-02f, 8.16605333e-03f, 1.46106016e-02f, -7.38274455e-02f, 3.47870775e-02f, -5.26341274e-02f, 4.16424833e-02f, -2.33240929e-02f, 4.22607325e-02f, 1.88678578e-02f,
  5.60404733e-02f, -6.45351689e-03f, 9.70729440e-02f, -5.15445247e-02f, 3.28281634e-02f, 6.55332729e-02f, -1.18849009e-01f, 2.67145392e-02f, -9.20113921e-02f, 2.91701336e-03f,
  9.04580131e-02f, -2.24638835e-01f, -1.83769330e-01f, 4.60115820e-02f, -1.49755441e-02f, -8.09790418e-02f, -1.33396775e-01f, -1.73239395e-01f, 4.08531763e-02f, 6.19466938e-02f,
  2.93539539e-02f, 1.35444239e-01f, 1.42687455e-01f, 1.87303759e-02f, -2.11644638e-02f, -1.10838860e-01f, -1.18630327e-01f, -8.92208293e-02f, 1.48487883e-02f, 3.00778239e-03f,
  7.31578171e-02f, 1.18628956e-01f, 2.07760707e-02f, -1.93716474e-02f, 2.68175872e-03f, 4.79949042e-02f, -8.43728632e-02f, -2.05453243e-02f, 4.70546260e-02f, 6.90208822e-02f,
  2.24740654e-01f, -1.48522794e-01f, 1.17890425e-01f, 1.48759276e-01f, -5.21837175e-02f, -1.89360529e-02f, 3.12262345e-02f, -8.30428209e-03f, 3.95930000e-02f, -5.50867319e-02f,
  5.13989404e-02f, -3.57904099e-02f, 4.86640893e-02f, -3.36763524e-02f, -6.30415380e-02f, -8.04659724e-02f, -8.81858021e-02f, -1.23956330e-01f, -4.18543480e-02f, -2.50985399e-02f,
  -6.84860796e-02f, 3.22725065e-02f, -1.08499207e-01f, -1.13976084e-01f, -1.15079761e-01f, 1.05661280e-01f, -6.17423914e-02f, -2.04969868e-02f, -1.44359395e-01f, -6.35960028e-02f,
  6.54133111e-02f, 2.83831637e-02f, 4.56168801e-02f, -1.71970148e-02f, -2.10505212e-03f, 4.11911309e-02f, 5.56787923e-02f, 4.46991995e-02f, 4.23359051e-02f, 5.03268875e-02f,
  -4.69324030e-02f, -7.97719788e-03f, -1.04875993e-02f, -7.40985898e-03f, 8.96565020e-02f, -1.69510338e-02f, 1.61780491e-02f, -2.06890795e-03f, 2.78839562e-02f, -2.46600807e-02f,
  2.25956179e-02f, -4.10952941e-02f, 2.18620989e-02f, 6.71871519e-03f, -5.57282753e-02f, -7.26585835e-02f, 5.62652983e-02f, -2.03641336e-02f, -7.90204108e-03f, -6.79071108e-03f,
  3.23058695e-01f, -8.81753117e-02f, 1.25892863e-01f, -5.83400810e-03f, 3.17017995e-02f, -3.13008465e-02f, 8.83624610e-03f, 1.09333964e-02f, 4.42319959e-02f, 2.47847810e-02f,
  -5.62575199e-02f, -3.97196896e-02f, -8.54985043e-02f, -6.31053075e-02f, 8.92333016e-02f, 3.24900933e-02f, 4.51980494e-02f, 9.26960781e-02f, 1.04073733e-02f, -6.79689720e-02f,
  -8.12658593e-02f, 7.67408013e-02f, 1.77698433e-01f, 5.45042045e-02f, -2.95318291e-02f, 5.33532016e-02f, 1.46505937e-01f, 1.04042709e-01f, 1.90889202e-02f, 2.04789609e-01f,
  3.73869389e-02f, -4.93442893e-01f, -1.92258626e-01f, 3.50944698e-02f, 1.39269873e-01f, 1.09673226e-02f, -1.39862180e-01f, 4.55641896e-02f, 1.53519228e-01f, -1.54204711e-01f,
  -5.13826944e-02f, 1.84907258e-01f, 1.88523769e-01f, 6.49342388e-02f, 5.16135693e-02f, -2.09994152e-01f, -1.61501259e-01f, -4.26463969e-02f, 1.90979525e-01f, 1.67101562e-01f,
  8.33824500e-02f, 3.82103398e-02f, 6.58729002e-02f, 5.05408980e-02f, -1.66334480e-01f, 8.79721418e-02f, -1.25196487e-01f, -1.67675763e-01f, -1.73292458e-01f, -3.43669683e-01f,
  -1.64130214e-03f, -1.42113224e-01f, 2.26350114e-01f, -8.94975942e-03f, -8.98340344e-02f, -3.91725861e-02f, 8.39750171e-02f, -5.13766669e-02f, -1.60902590e-02f, -9.67068002e-02f,
  2.50756219e-02f, 2.82208342e-02f, -3.80444638e-02f, -1.83546189e-02f, 5.50150350e-02f, 3.49043831e-02f, -7.12409541e-02f, -7.33062327e-02f, 8.68567601e-02f, -4.14869748e-02f,
  -5.07913157e-02f, -4.21763361e-02f, 1.20598683e-02f, 9.27276164e-03f, 5.23241423e-02f, 9.87119377e-02f, -3.58533524e-02f, 3.46195251e-02f, 3.77468988e-02f, -1.28223643e-01f,
  -2.48863804e-03f, -5.29575795e-02f, -5.83831361e-03f, -9.01874993e-03f, 1.47017194e-02f, -3.45453992e-02f, -3.64675932e-02f, 3.35109942e-02f, -1.00545436e-02f, -6.18034936e-02f,
  3.89455408e-02f, 4.25302722e-02f, 1.50818173e-02f, -5.26327193e-02f, -2.43101560e-04f, -8.93364474e-02f, 6.48397580e-02f, -1.77954677e-02f, 8.28365982e-02f, -2.20446158e-02f,
  -3.65339802e-05f, -1.14263315e-02f, -7.95933679e-02f, 1.20611526e-02f, -1.72351375e-02f, -1.89428292e-02f, 6.84132352e-02f, 2.77176313e-02f, 4.03490923e-02f, 4.47550556e-03f,
  1.47199199e-01f, 1.01143181e-01f, -1.63444062e-03f, 1.12746306e-01f, 3.79111432e-02f, -5.73133565e-02f, -2.04218477e-02f, 2.33131405e-02f, -4.39947210e-02f, -2.64009256e-02f,
  3.23346406e-02f, -3.33776837e-03f, 5.54448515e-02f, 2.44154073e-02f, 7.45886639e-02f, 1.08010978e-01f, 5.24569023e-03f, 1.31542549e-01f, 1.39119923e-02f, 4.06624749e-03f,
  -7.62692243e-02f, 8.95096511e-02f, 2.09167451e-01f, 1.21938944e-01f, 8.81986246e-02f, 1.72118947e-01f, 1.03936374e-01f, 3.06765456e-02f, 1.12461582e-01f, -4.65040766e-02f,
  -3.41829062e-02f, -1.34256616e-01f, -1.89275607e-01f, -2.68164754e-01f, -3.12384903e-01f, -2.05991015e-01f, -3.07870150e-01f, -1.05365425e-01f, -1.92338288e-01f, -1.91678077e-01f,
  -7.93897584e-02f, -1.23734094e-01f, -4.04800177e-02f, -4.56868634e-02f, -5.10479957e-02f, -1.33389875e-01f, -1.39945269e-01f, 8.05730745e-02f, -3.33491787e-02f, -1.25813589e-01f,
  -5.20532243e-02f, -8.62880982e-03f, 6.84721172e-02f, 3.63668762e-02f, -7.54134580e-02f, -6.83432892e-02f, -3.22918892e-02f, -1.17164105e-01f, 5.73309287e-02f, 8.29884261e-02f,
  -2.12178692e-01f, -1.79918054e-02f, 5.57107590e-02f, 1.05132438e-01f, 2.12754728e-03f, -2.37114858e-02f, -6.53790683e-02f, 1.12295836e-01f, 4.81183790e-02f, -8.44863802e-02f,
  -8.89031887e-02f, -3.71294059e-02f, -6.69775978e-02f, 5.95062636e-02f, -2.16160472e-02f, -6.63065538e-02f, 4.29665186e-02f, 1.03129782e-01f, 4.61501293e-02f, 5.92223257e-02f,
  3.10282595e-02f, -6.45017773e-02f, 4.38606218e-02f, -3.20765600e-02f, 1.10873565e-01f, 1.23232923e-01f, 3.16120982e-02f, 1.25367805e-01f, -1.54336290e-02f, 1.22524351e-01f,
  2.30269674e-02f, -2.52624787e-02f, -1.25175277e-02f, -4.59431950e-03f, 1.04409605e-02f, 6.59159943e-02f, 7.95676708e-02f, -6.58309227e-03f, -2.66387444e-02f, 3.89187895e-02f,
  -4.03111689e-02f, -4.20729071e-02f, 1.87131166e-02f, -5.71514256e-02f, -2.74499860e-02f, 5.35554327e-02f, -8.10932368e-03f, -1.84652221e-03f, 5.59910312e-02f, 1.77988298e-02f,
  9.27907228e-02f, 2.81442516e-02f, -4.52263141e-03f, -2.42359214e-03f, 6.09175973e-02f, -1.81310484e-03f, -6.34140074e-02f, 1.61027387e-02f, -5.20055927e-02f, 4.01114114e-02f,
  -1.13431603e-01f, 3.23626213e-02f, 3.78307514e-02f, 9.57496017e-02f, 4.16000327e-03f, 7.01838359e-02f, -6.46269172e-02f, 7.28400201e-02f, -1.28177004e-02f, -2.55710781e-02f,
  -1.62634365e-02f, 5.26950620e-02f, -1.45156160e-02f, -5.01376502e-02f, -4.92025167e-02f, -3.97062637e-02f, -7.64072910e-02f, 2.39507612e-02f, 4.55512607e-04f, -7.10158795e-03f,
  5.18797562e-02f, 4.21483815e-02f, 1.16253264e-01f, 9.43978205e-02f, -3.40078250e-02f, 3.97827923e-02f, 3.47824134e-02f, 6.55782372e-02f, 4.52532433e-02f, -7.01597184e-02f,
  4.22305055e-02f, 3.68354231e-01f, 7.49722570e-02f, -4.93851677e-02f, 6.20461674e-03f, 2.18578979e-01f, 3.95739973e-01f, 1.64478511e-01f, -9.34490860e-02f, 7.85082504e-02f,
  -9.62379202e-02f, -1.75199121e-01f, -7.75358379e-02f, -1.47385463e-01f, -2.35869493e-02f, 1.62258402e-01f, 6.00224175e-02f, 1.51052075e-02f, -1.93710208e-01f, -8.90770555e-02f,
  1.14211708e-03f, 6.35507479e-02f, -5.85517772e-02f, -4.70301844e-02f, 4.66394760e-02f, -2.88323443e-02f, 1.12785578e-01f, 9.60854515e-02f, 1.59686446e-01f, 2.11793855e-01f,
  5.98181225e-02f, 2.47031059e-02f, -1.05692126e-01f, -1.42183751e-01f, -9.27490890e-02f, -2.36393027e-02f, 2.73251534e-02f, 4.16602194e-03f, 1.31522082e-02f, -2.37902664e-02f,
  -9.98593941e-02f, 1.68354101e-02f, -8.65800008e-02f, -1.02426179e-01f, -3.47934812e-02f, -5.98063990e-02f, 1.10815698e-02f, 1.95980333e-02f, -5.73930964e-02f, -6.08225390e-02f,
  -7.35823438e-02f, 5.98262437e-02f, 9.78745893e-02f, 1.23543419e-01f, 2.47899238e-02f, -9.70472470e-02f, 2.45648306e-02f, 1.11454353e-01f, 2.03356855e-02f, 1.40091911e-01f,
  3.33079370e-03f, 3.99218537e-02f, -9.45637375e-02f, 8.18787441e-02f, 8.12952314e-03f, -2.67230831e-02f, -6.05541021e-02f, -3.86706144e-02f, 1.61745660e-02f, 2.89670769e-02f,
  -6.50613829e-02f, -5.36225270e-03f, 6.24701567e-03f, 6.95082620e-02f, -5.12232408e-02f, 3.97724994e-02f, 4.69395472e-03f, 3.76658104e-02f, 4.41870652e-02f, -8.39890316e-02f,
  -1.15907807e-02f, -8.05665702e-02f, 3.37698683e-02f, -1.78339034e-02f, -5.87975383e-02f, 8.08169097e-02f, 1.02529293e-02f, -2.12634057e-02f, -5.13355099e-02f, -5.48001677e-02f,
  2.07028259e-02f, -1.63041696e-01f, -1.38138719e-02f, -4.88425530e-02f, 6.18880801e-02f, -7.47373924e-02f, 1.98462438e-02f, 5.38863428e-03f, -1.50373187e-02f, 7.94256032e-02f,
  -8.37760791e-03f, -7.00246170e-02f, 6.48799017e-02f, 7.98409209e-02f, 7.83150829e-03f, 6.54393584e-02f, 5.19008636e-02f, 2.59691160e-02f, 2.21033581e-02f, 7.68624097e-02f,
  7.92801008e-03f, 1.34066746e-01f, -6.59586105e-04f, 2.59692892e-02f, 6.98324814e-02f, -3.99097055e-02f, 2.10481241e-01f, 1.78465709e-01f, 9.88810584e-02f, 2.74213701e-01f,
  2.35971391e-01f, 1.09076902e-01f, -1.18075371e-01f, 9.44255739e-02f, -1.77915245e-01f, -1.52621537e-01f, -2.50765346e-02f, 1.49718612e-01f, 1.14920564e-01f, 4.35035974e-02f,
  9.57257487e-03f, -2.59959511e-02f, 3.83332148e-02f, -8.71617571e-02f, -9.71036553e-02f, 9.49352048e-03f, -1.19840667e-01f, -2.22218186e-01f, -1.10669471e-01f, -8.15257356e-02f,
  -1.59170896e-01f, 2.48911884e-03f, -6.78188950e-02f, -3.77505496e-02f, 1.63115896e-02f, -3.76245454e-02f, -3.59210186e-02f, 3.27496044e-02f, -1.87504753e-01f, -1.55981435e-02f,
  -7.70692080e-02f, 2.62939464e-02f, -1.40692964e-01f, -3.19459313e-03f, -1.19855732e-01f, 3.20304558e-02f, -1.02761589e-01f, 5.77461161e-02f, 4.60592657e-02f, 3.16451639e-02f,
  -8.75789225e-02f, -8.76980424e-02f, 2.00035069e-02f, 6.08274378e-02f, 3.32485251e-02f, -3.56600247e-02f, 1.06540389e-01f, 7.51485005e-02f, 1.51355918e-02f, 3.83902341e-02f,
  -1.34202585e-01f, -5.84660172e-02f, 4.85915691e-03f, 5.04633971e-02f, -2.65467875e-02f, -2.01859072e-01f, 7.63298571e-02f, -3.85127626e-02f, -9.27798152e-02f, 1.82610989e-01f,
  -8.83046817e-03f, -9.40254480e-02f, 5.16031682e-03f, 5.56752682e-02f, 8.87346566e-02f, 2.04444509e-02f, 3.27203982e-02f, -1.08088471e-03f, 3.58002223e-02f, -1.71308033e-02f,
  5.73025122e-02f, 5.66947646e-03f, 6.85025901e-02f, 9.05281529e-02f, 4.50709946e-02f, -2.03399416e-02f, 4.65776771e-02f, 7.67600583e-03f, -1.58965513e-02f, -3.21862870e-03f,
  1.51118450e-02f, -1.79664325e-02f, 6.98143325e-04f, 5.47794625e-02f, 2.83872671e-02f, -2.43344400e-02f, -4.84394990e-02f, -7.36668259e-02f, 3.46477665e-02f, 9.45141725e-03f,
  2.39851415e-01f, -1.36953086e-01f, -3.35709751e-02f, 5.94244488e-02f, 5.05706444e-02f, 6.17000759e-02f, 9.51938257e-02f, 4.00508679e-02f, -7.85812512e-02f, 4.15357873e-02f,
  -3.20153683e-02f, 1.10276490e-01f, 1.20813176e-01f, 6.78529814e-02f, 4.21683304e-02f, 4.20975983e-02f, 1.22010224e-01f, -1.68465935e-02f, -6.57917410e-02f, -1.99691928e-03f,
  7.90594444e-02f, -4.77039330e-02f, -7.61730131e-03f, -1.79411694e-02f, -1.25096589e-02f, -1.28090367e-01f, -6.00950606e-02f, 5.95393032e-02f, -7.36299604e-02f, 1.62558213e-01f,
  -1.48728654e-01f, -9.93363038e-02f, -7.36779645e-02f, 5.36089242e-02f, -1.20383762e-01f, -9.76995751e-02f, 2.70259213e-02f, -2.85359146e-03f, 1.15112528e-01f, -2.08986718e-02f,
  -1.68591276e-01f, 7.80167524e-04f, 6.04514144e-02f, 1.10847861e-01f, 8.37176368e-02f, 1.32427767e-01f, 2.14529827e-01f, 1.80551708e-01f, 1.79112047e-01f, -3.20371729e-03f,
  1.24638058e-01f, 1.41892746e-01f, 4.16281112e-02f, 1.42091736e-01f, 1.29096031e-01f, 1.97540317e-02f, -6.59966692e-02f, -2.40114778e-02f, -1.02176286e-01f, 1.43105537e-01f,
  -1.11376427e-01f, -1.47596091e-01f, 1.49943724e-01f, -1.04247592e-01f, -2.01160200e-02f, -2.90265195e-02f, -3.53133678e-02f, -4.40176614e-02f, -1.69453688e-03f, -1.98831018e-02f,
  -6.25014082e-02f, -7.37236515e-02f, -4.32367586e-02f, 7.92657360e-02f, 6.55450001e-02f, -7.42978007e-02f, 1.62205603e-02f, 4.06808704e-02f, 5.27347028e-02f, -8.59533995e-02f,
  -5.68877272e-02f, -1.33487061e-01f, -8.65301937e-02f, -3.04860082e-02f, 4.23489511e-03f, -3.40478239e-03f, -1.16640283e-02f, 2.83044707e-02f, -1.14703573e-01f, 1.81067288e-02f,
  9.76044033e-03f, -8.54707323e-03f, -5.28174117e-02f, 4.23614718e-02f, -7.44861066e-02f, -7.62278512e-02f, 2.63281520e-02f, -5.97494058e-02f, 7.64147341e-02f, 1.37931611e-02f,
  2.26449352e-02f, 3.79142202e-02f, -1.16435084e-02f, -1.59654405e-03f, 6.10418804e-02f, -5.81695873e-04f, -2.58646365e-02f, 6.98876530e-02f, -8.09903666e-02f, -3.39477174e-02f,
  -5.77799007e-02f, -2.79397536e-02f, 1.49867311e-02f, 1.78203899e-02f, 2.29004771e-02f, 5.01105897e-02f, 3.66603397e-02f, -3.62822600e-02f, -1.12910144e-01f, -2.38751210e-02f,
  7.50476718e-02f, -9.55828503e-02f, -2.75437701e-02f, 6.58744201e-02f, 3.05120666e-02f, -2.36274041e-02f, -1.23318322e-01f, 3.27072442e-02f, -6.41083643e-02f, 1.70167014e-02f,
  -7.40736872e-02f, -4.67214398e-02f, -1.25281289e-02f, 2.74695829e-02f, 6.36582598e-02f, -1.86605528e-02f, 6.49446622e-02f, 8.12746435e-02f, 1.00402050e-02f, 7.21841911e-03f,
  -2.23169830e-02f, -1.19028892e-02f, -2.97733787e-02f, -2.64992584e-02f, 3.92574519e-02f, -6.34347722e-02f, -6.69299960e-02f, 2.68828720e-02f, -4.36983677e-03f, 1.02813207e-01f,
  3.14277083e-01f, -1.30956411e-01f, -1.02715679e-01f, -3.68680283e-02f, -1.47533655e-01f, -4.94968668e-02f, 4.43455763e-02f, 4.73578461e-02f, 8.29148963e-02f, -4.60017025e-02f,
  -1.71231344e-01f, 8.34665075e-03f, -5.58541752e-02f, 5.63314408e-02f, 7.53809214e-02f, -2.27923170e-02f, -1.56361237e-01f, 2.64433771e-02f, 1.06599808e-01f, 1.57621428e-01f,
  -5.30881882e-02f, -1.98886264e-02f, 1.23589098e-01f, 1.15044855e-01f, -1.89847365e-01f, -1.34609148e-01f, -6.94392249e-02f, -3.16373222e-02f, -7.50780031e-02f, -2.11380720e-01f,
  -1.63947031e-01f, 7.21405745e-02f, -1.11241054e-04f, -6.23766631e-02f, -6.54510260e-02f, 1.12833977e-01f, -1.85799152e-02f, 7.54561694e-03f, -7.80451111e-03f, 5.89282848e-02f,
  -7.17452839e-02f, 6.64400309e-02f, 4.38235141e-03f, 1.16202310e-02f, -3.94324474e-02f, 4.26692329e-02f, 4.36902866e-02f, -1.77345099e-03f, -4.59316224e-02f, -1.41694434e-02f,
  -9.41866040e-02f, -7.66562074e-02f, 6.52833953e-02f, 3.91830578e-02f, -4.38960083e-02f, 2.25760583e-02f, -7.25917295e-02f, 6.65061846e-02f, 3.50389630e-02f, 4.69484320e-03f,
  -3.75545844e-02f, -4.71517183e-02f, 1.24271931e-02f, 4.42190319e-02f, 5.39578088e-02f, -3.28229740e-02f, -1.75777059e-02f, -9.56356749e-02f, 9.14433300e-02f, -3.09231635e-02f,
  2.10315865e-02f, -3.08621842e-02f, -2.80065853e-02f, 8.74965172e-03f, -5.70570156e-02f, -6.38185516e-02f, 6.78220838e-02f, 4.37078960e-02f, 3.86606576e-03f, 4.49970290e-02f,
  -1.10900383e-02f, 2.63445508e-02f, 2.55218577e-02f, 1.78157433e-03f, 5.92745319e-02f, -4.08050753e-02f, -6.83703870e-02f, -5.66342399e-02f, 7.53354952e-02f, -2.79410090e-02f,
  6.17636815e-02f, 5.75057268e-02f, -4.31001931e-02f, -9.55335889e-03f, -8.28066766e-02f, 2.61560455e-02f, -5.53500392e-02f, -5.13219573e-02f, -1.10848829e-01f, -4.17414792e-02f,
  -5.39351441e-03f, 7.91702941e-02f, 8.89278110e-03f, -2.37553101e-02f, 1.71598382e-02f, 5.47368824e-03f, 4.24504615e-02f, 3.29048894e-02f, 3.12329158e-02f, -9.33719426e-03f,
  -8.10893178e-02f, 1.51819080e-01f, 9.67893898e-02f, 1.05537698e-02f, 7.77463019e-02f, 1.48248905e-02f, -6.22323640e-02f, 7.70980939e-02f, 9.42296460e-02f, 1.00114033e-01f,
  1.49687022e-01f, 1.51639311e-02f, -9.00929794e-03f, 1.27529994e-01f, 2.01657906e-01f, 2.03616127e-01f, 2.07412913e-01f, 2.36869287e-02f, -6.75311685e-02f, 3.71344686e-02f,
  2.99040005e-02f, 6.67483360e-02f, 7.12490305e-02f, -5.13873249e-02f, 6.23045266e-02f, 9.05287713e-02f, -3.49999554e-02f, 6.13073036e-02f, 1.56123415e-01f, 1.40163869e-01f,
  9.02469456e-03f, 3.80107947e-02f, -3.44476141e-02f, -9.18598697e-02f, 5.98656712e-03f, -7.04589486e-02f, -1.55407730e-02f, -7.68974349e-02f, 3.57281156e-02f, -1.00086711e-01f,
  4.17634211e-02f, 3.70362662e-02f, 8.20618868e-02f, 4.71183211e-02f, 3.99395972e-02f, -7.68773854e-02f, 5.07826209e-02f, -1.12103596e-01f, 1.91213302e-02f, -1.06558248e-01f,
  -2.15345360e-02f, 1.79790463e-02f, -3.96603160e-02f, -7.52013400e-02f, -3.26704532e-02f, 5.57767926e-03f, -2.29576443e-04f, -9.05985013e-02f, -1.06810905e-01f, -8.67504105e-02f,
  -1.96069963e-02f, 6.93260431e-02f, 9.59556177e-03f, -4.03248854e-02f, -8.31626803e-02f, 9.54847932e-02f, 5.73086105e-02f, -3.47187407e-02f, -3.47816274e-02f, -9.10881683e-02f,
  5.44902496e-02f, 6.89074993e-02f, 8.47979076e-03f, 8.32458213e-02f, 2.43778713e-02f, -4.02710550e-02f, -4.86185811e-02f, 7.26628527e-02f, -3.29081677e-02f, -1.98266897e-02f,
  5.33680916e-02f, 8.49789754e-03f, 2.38279323e-03f, 8.16583708e-02f, -8.13125670e-02f, 4.80243154e-02f, 5.10296561e-02f, -5.36321215e-02f, 2.37196703e-02f, 5.52021787e-02f,
  3.66749568e-03f, -7.74004608e-02f, -1.29118906e-02f, -3.52005735e-02f, -8.94913897e-02f, 5.08609414e-02f, 4.30204310e-02f, -3.20867747e-02f, -2.84917490e-03f, -8.74763802e-02f,
  2.78676078e-02f, 7.14563206e-02f, -5.72294183e-02f, 2.07187086e-02f, 7.69704655e-02f, -9.60100293e-02f, -9.56802070e-03f, 1.14455018e-02f, -4.18988541e-02f, 4.00979668e-02f,
  -3.94133925e-02f, 6.57985359e-02f, -2.77242307e-02f, -8.28690380e-02f, 1.14350356e-01f, 2.50875745e-02f, 1.90189369e-02f, -3.91902402e-02f, -5.40511347e-02f, -7.13863745e-02f,
  -7.68050179e-02f, 7.95895979e-02f, 1.81018099e-01f, 4.73068208e-02f, -4.60523479e-02f, 2.00328939e-02f, 2.81530488e-02f, -1.07825845e-02f, 1.36633918e-01f, 7.78543279e-02f,
  -7.25091323e-02f, -3.13937247e-01f, 5.43323830e-02f, -1.55140400e-01f, -7.50482157e-02f, 5.91973662e-02f, -1.40212744e-01f, 4.64859717e-02f, 1.85013786e-02f, -9.57220346e-02f,
  4.40628864e-02f, 1.07506961e-01f, 5.74980937e-02f, 6.42361119e-02f, 3.24849449e-02f, -1.53329268e-01f, -7.12515935e-02f, 1.69510067e-01f, 1.90738603e-01f, 3.65823433e-02f,
  -2.76808515e-02f, -1.02237426e-01f, 8.16055462e-02f, -5.26048616e-03f, -2.95379370e-01f, -2.13269088e-02f, -1.43587008e-01f, -1.57917634e-01f, -1.36284992e-01f, -3.16503584e-01f,
  -5.12055084e-02f, -1.67602018e-01f, 1.67537600e-01f, 7.77582731e-03f, 1.00396290e-01f, -6.01441786e-02f, -5.53497998e-03f, -2.95297429e-02f, 2.78533753e-02f, -9.80476066e-02f,
  -1.67987554e-03f, 4.50035706e-02f, -2.89989579e-02f, -6.66963384e-02f, -5.66798411e-02f, -3.94972824e-02f, 4.31687683e-02f, 1.03544826e-02f, 5.70821874e-02f, -1.23775452e-01f,
  -8.39637816e-02f, -8.15653875e-02f, 6.71487898e-02f, -1.87430643e-02f, -2.03793962e-03f, 1.26811504e-01f, -5.61934747e-02f, -4.95360121e-02f, -2.52724085e-02f, -2.42200494e-01f,
  -5.02243079e-02f, 3.94690819e-02f, 4.99580130e-02f, -9.27249566e-02f, 4.21014689e-02f, -2.25812737e-02f, -2.00424213e-02f, -1.55036319e-02f, 2.94464771e-02f, 1.43833994e-03f,
  5.85083254e-02f, 6.54403567e-02f, -3.67474817e-02f, -6.25771657e-02f, 1.05937272e-02f, 3.43531035e-02f, 2.03808714e-02f, -3.68924290e-02f, -1.69810150e-02f, -5.88387325e-02f,
  -1.70308948e-02f, 3.39453667e-02f, -3.81832160e-02f, 4.70336452e-02f, 7.72320181e-02f, -3.33401188e-02f, 1.79823637e-02f, 5.26296571e-02f, 5.08855516e-03f, 7.73743093e-02f,
  -7.06016878e-03f, 3.39547306e-01f, -1.53206110e-01f, -6.82505295e-02f, -2.83270087e-02f, 4.71548885e-02f, -4.43164259e-02f, -5.85723184e-02f, -8.67865533e-02f, -5.24384156e-02f,
  -3.51346470e-02f, -1.17661525e-02f, 2.32635122e-02f, 2.94044409e-02f, 9.32732373e-02f, -1.15537485e-02f, 4.77315672e-02f, -9.24479042e-04f, 9.07019377e-02f, -7.19420090e-02f,
  -1.36950696e-02f, 8.35164338e-02f, 9.82179791e-02f, -2.32797470e-02f, 4.19690125e-02f, 1.81912586e-01f, 3.67019475e-02f, 1.02807887e-01f, 9.53143388e-02f, -1.40682518e-01f,
  -4.29332256e-02f, -1.68211415e-01f, -5.52495010e-02f, 1.63410932e-01f, 8.56763199e-02f, -2.33048081e-01f, -3.04871559e-01f, -1.07439272e-01f, -1.20061738e-02f, -4.37421650e-02f,
  2.11235415e-02f, 7.64981136e-02f, -1.07851550e-02f, -1.04359508e-01f, -1.09934285e-01f, -9.06790048e-02f, -1.12434886e-02f, 1.26166185e-02f, 6.27863640e-03f, 7.21333027e-02f,
  7.56595731e-02f, 8.50438550e-02f, 9.01685283e-02f, 4.68517728e-02f, 1.93329379e-01f, 1.99057255e-02f, 1.25413030e-01f, -2.97040697e-02f, -7.49962032e-02f, 2.48566300e-01f,
  2.66848534e-01f, 3.18926051e-02f, -9.23449099e-02f, -4.95047122e-02f, 8.14309791e-02f, 7.15585873e-02f, 5.03599569e-02f, -5.73491259e-03f, -2.95050703e-02f, -5.06178383e-03f,
  1.01897949e-02f, 1.28892079e-01f, 8.25117305e-02f, 7.51397982e-02f, 6.71601621e-03f, 5.90919703e-02f, -2.72530727e-02f, -4.42614406e-02f, -7.24171624e-02f, 2.42284779e-02f,
  -5.33305155e-03f, -7.90163316e-03f, 4.24017534e-02f, -7.40838200e-02f, -1.32873744e-01f, 9.64370072e-02f, -2.03100909e-02f, -5.76843247e-02f, 1.05589796e-02f, -6.20146655e-03f,
  3.59519795e-02f, 6.29380997e-03f, 6.65671984e-03f, -3.87355573e-02f, 4.73735407e-02f, -6.59659207e-02f, 8.04980546e-02f, -5.63154481e-02f, -3.08693144e-02f, -5.34615554e-02f,
  2.31395178e-02f, -2.61644050e-02f, 3.94164324e-02f, 4.38968390e-02f, -2.54837740e-02f, -1.46516217e-02f, 5.78632355e-02f, -8.27307552e-02f, -1.09739359e-02f, -5.45793213e-02f,
  -2.04908345e-02f, -4.36904840e-02f, 6.31660670e-02f, 2.67457291e-02f, 1.76365487e-02f, -7.78288022e-02f, 9.38646346e-02f, -6.82395771e-02f, 2.40514986e-02f, 6.64370358e-02f,
  -2.91485917e-02f, -1.80939049e-01f, 1.21641554e-01f, 7.49647468e-02f, 1.17948968e-02f, 7.42472112e-02f, 6.82495721e-03f, -2.35875882e-02f, 1.08471058e-01f, -2.87795160e-02f,
  8.74581486e-02f, -2.20140815e-02f, -5.73364459e-02f, -7.61781633e-02f, 4.90455851e-02f, -7.95937479e-02f, -4.80387397e-02f, 1.11548759e-01f, -1.12124108e-01f, -6.31789071e-03f,
  1.46951443e-02f, -3.80820148e-02f, 1.73191130e-02f, -6.53791577e-02f, -1.61539335e-02f, 5.91848083e-02f, 2.11662762e-02f, 5.50240166e-02f, -1.03580736e-01f, -9.98456925e-02f,
  -1.90525681e-01f, 2.22887084e-01f, -7.10894242e-02f, 3.30300815e-02f, 1.55492485e-01f, 6.90307915e-02f, 1.99368104e-01f, 8.00078437e-02f, 2.44942261e-03f, 1.96149305e-01f,
  1.45150796e-01f, 8.44508410e-02f, -1.03897840e-01f, -1.25008732e-01f, -1.39783755e-01f, 1.81731582e-01f, 1.37287065e-01f, -2.24884227e-01f, -2.81480253e-01f, -5.64532466e-02f,
  8.03159829e-03f, -4.49397117e-02f, -2.47983843e-01f, -6.84633926e-02f, 1.54668212e-01f, 1.01853259e-01f, -2.80413474e-03f, 5.56015000e-02f, 2.45948453e-02f, 2.82186270e-01f,
  1.35575280e-01f, -7.45997131e-02f, -7.18570873e-02f, 6.59964085e-02f, 8.83982629e-02f, -2.80506779e-02f, 4.33421843e-02f, -9.95180197e-03f, 3.34957498e-04f, 2.79544946e-02f,
  -2.10695732e-02f, 4.50216234e-02f, -4.65941876e-02f, 7.63079524e-02f, 3.64819018e-04f, -7.55929798e-02f, 3.90426459e-04f, -1.08597092e-01f, -5.10697737e-02f, 6.25242218e-02f,
  1.75064519e-01f, 5.22997379e-02f, 1.59954336e-02f, -9.61289331e-02f, 6.90259086e-03f, -7.04203546e-02f, 7.28807524e-02f, 2.68749055e-03f, -1.64641562e-04f, 8.85673091e-02f,
  3.30086946e-02f, 7.08852410e-02f, -7.91296549e-03f, -2.46163979e-02f, -3.63767594e-02f, 6.03668839e-02f, 1.62786115e-02f, 5.49607538e-02f, 1.17761027e-02f, -5.31432293e-02f,
  -2.00879574e-02f, 2.77832039e-02f, -4.99584973e-02f, 1.41942911e-02f, 3.64244245e-02f, 4.69964871e-04f, -6.08711690e-02f, -2.36158762e-02f, 5.05059119e-03f, -1.70565303e-02f,
  1.29415905e-02f, -4.75033820e-02f, 4.83277440e-02f, -4.43108417e-02f, -2.73081828e-02f, 2.46741921e-02f, 3.82002629e-02f, -3.05676851e-02f, 4.52871574e-03f, -5.35067823e-03f,
  -2.58548204e-02f, -1.84651822e-01f, 1.66697696e-01f, -9.84424800e-02f, 5.33592217e-02f, 3.75013575e-02f, 9.46606249e-02f, -9.37320516e-02f, -2.58969590e-02f, -1.67403538e-02f,
  -1.08927056e-01f, 4.67967242e-02f, 7.89044518e-03f, -9.72078294e-02f, 2.03567017e-02f, 4.37228009e-02f, 4.80189957e-02f, -3.27269100e-02f, 5.11365421e-02f, -1.97455510e-02f,
  2.87970509e-02f, 3.58245783e-02f, -3.89204994e-02f, 6.95995539e-02f, -3.64926830e-02f, -6.22975901e-02f, 7.27181286e-02f, 6.79526106e-02f, 3.31653617e-02f, 1.12017989e-01f,
  1.95496455e-01f, -3.94489169e-02f, -2.56303281e-01f, -2.14594491e-02f, 4.36236523e-02f, 1.94608700e-02f, 4.59754653e-02f, 4.18543369e-02f, 6.38252795e-02f, -7.52821378e-03f,
  -7.80728236e-02f, -1.58329792e-02f, -5.11920489e-02f, -1.03016511e-01f, -1.80679366e-01f, -3.00456546e-02f, -1.92997366e-01f, -2.67322451e-01f, -1.48074105e-01f, -8.43182653e-02f,
  -8.83265883e-02f, -8.88120830e-02f, -2.98560299e-02f, 6.94788992e-02f, 1.10288970e-01f, -3.28994803e-02f, -1.99410152e-02f, -9.58378017e-02f, -3.79825197e-02f, 4.76841256e-02f,
  -1.77552477e-01f, 2.17352733e-01f, 1.00881513e-02f, 4.77202944e-02f, -1.10726811e-01f, 1.18180536e-01f, 8.35092440e-02f, -5.12054302e-02f, -3.08526051e-03f, -6.05076272e-03f,
  6.68333378e-03f, 1.07285939e-01f, 2.81933248e-02f, 4.07650545e-02f, -1.57757513e-02f, 4.08370979e-02f, 1.75385792e-02f, -1.50503824e-02f, -7.51172006e-02f, -1.28068272e-02f,
  5.33998609e-02f, -7.48542836e-03f, -8.02020058e-02f, 7.00888559e-02f, -8.48136842e-03f, -5.95737575e-03f, -2.67041177e-02f, 1.10227831e-01f, 2.85668690e-02f, 4.36121821e-02f,
  -8.76428559e-02f, -8.25814456e-02f, -6.17632531e-02f, 1.88649464e-02f, -4.67296466e-02f, -4.60644476e-02f, -5.05424216e-02f, -3.30877043e-02f, 4.35882248e-02f, 5.33178262e-02f,
  4.68695387e-02f, -5.47015434e-03f, -1.77971553e-02f, 4.24819887e-02f, -3.50255594e-02f, -6.33436590e-02f, 1.27531141e-02f, -1.61170755e-02f, -2.75403261e-02f, -2.33516321e-02f,
  -7.85990618e-03f, -1.94551982e-02f, 3.94464917e-02f, -2.84358636e-02f, 6.19655177e-02f, 4.06636409e-02f, -7.47337192e-02f, 1.26530239e-02f, 6.05584159e-02f, 4.69564497e-02f,
  -8.63204896e-02f, -1.94039524e-01f, 6.63137585e-02f, -3.61468121e-02f, 7.36595392e-02f, -2.81516723e-02f, 3.94811779e-02f, -1.34157557e-02f, 6.52780244e-03f, 4.74466570e-02f,
  1.08475452e-02f, -4.22970466e-02f, -5.55570051e-02f, 1.25069814e-02f, -3.38910446e-02f, -9.30218492e-03f, -6.31699637e-02f, -8.76153335e-02f, -6.27563968e-02f, 1.44278318e-01f,
  -5.97416759e-02f, 4.09551114e-02f, -3.36284339e-02f, -7.38522187e-02f, 6.41677901e-03f, -6.87867701e-02f, 5.55359339e-03f, 2.17468850e-02f, -7.21353590e-02f, -8.29524696e-02f,
  7.31351823e-02f, 1.91713542e-01f, 8.18528533e-02f, 1.20005086e-01f, 1.15969457e-01f, 9.00454596e-02f, 1.99516505e-01f, 9.44200009e-02f, -1.70845222e-02f, 2.24513337e-01f,
  2.79222298e-02f, 7.27587268e-02f, 9.98577625e-02f, -6.30586147e-02f, 8.65127295e-02f, 1.14764899e-01f, 1.87906042e-01f, 1.17995720e-02f, -1.23248056e-01f, -7.70372376e-02f,
  1.37585491e-01f, 1.21861376e-01f, 7.03773648e-02f, -7.55530223e-02f, 9.26824957e-02f, -3.37673090e-02f, 9.91666541e-02f, 4.96422797e-02f, 3.86072695e-02f, 2.04503745e-01f,
  1.01341359e-01f, -4.79015075e-02f, -1.21661052e-01f, -6.95943311e-02f, 8.35333094e-02f, -7.96263888e-02f, 1.00458719e-01f, -1.33329192e-02f, -1.02634825e-01f, -9.62830707e-02f,
  5.71641736e-02f, -2.59559751e-02f, -8.18331689e-02f, -1.03567973e-01f, 4.13486362e-02f, -1.15258448e-01f, 8.92343465e-03f, 2.01523602e-02f, 4.94313426e-02f, 9.71461907e-02f,
  4.99232411e-02f, -1.77832339e-02f, 6.31590001e-03f, -4.29504961e-02f, -2.12930162e-02f, 3.10650263e-02f, 1.82500817e-02f, -2.96373330e-02f, -9.65358466e-02f, -3.35526802e-02f,
  -1.30127044e-02f, -4.87803183e-02f, 3.00492793e-02f, 3.91291594e-03f, -5.30204028e-02f, 4.37833928e-02f, -4.39596921e-02f, 3.37887742e-02f, 3.86222452e-02f, 3.10556144e-02f,
  -5.44141978e-02f, 7.03047737e-02f, 8.23267177e-02f, -3.28164995e-02f, -4.96230051e-02f, 5.84569387e-02f, 6.22318238e-02f, 7.41927922e-02f, 6.29015714e-02f, 1.37548074e-02f,
  -3.43843363e-02f, -2.31694826e-03f, -2.14547161e-02f, -3.96624580e-02f, -5.16907237e-02f, 4.69630770e-02f, 5.83417341e-03f, -2.29303222e-02f, 5.83521947e-02f, 1.72783304e-02f,
  -1.49344206e-01f, -2.58930642e-02f, 5.57206608e-02f, -6.25363588e-02f, 3.41733471e-02f, -3.44767906e-02f, 1.15321325e-02f, -1.16484709e-01f, 1.85140700e-03f, 6.59181625e-02f,
  4.95218001e-02f, 2.60707438e-02f, 6.06837682e-02f, 5.41485436e-02f, -1.97374206e-02f, -4.35471423e-02f, 1.10749118e-01f, -3.97380553e-02f, -3.93756665e-02f, 1.36724943e-02f,
  1.22742504e-02f, -2.48781200e-02f, -9.19575337e-03f, 7.65680568e-03f, 6.19785162e-03f, -1.64276604e-02f, -2.95218360e-02f, -8.88049304e-02f, -5.69195375e-02f, -1.04891146e-02f,
  1.09472968e-01f, -1.30495369e-01f, -2.16793809e-02f, 5.15807457e-02f, -1.17751181e-01f, -1.66810676e-01f, -8.74694809e-02f, -3.74516770e-02f, -5.05242124e-02f, -8.74943733e-02f,
  -7.13843554e-02f, 1.67776287e-01f, 1.80366516e-01f, 1.15310643e-02f, 5.73460497e-02f, -1.94573477e-01f, -1.49321005e-01f, -2.43339576e-02f, 1.61964789e-01f, -4.35171165e-02f,
  -9.03241560e-02f, -3.65623385e-02f, 8.33369046e-02f, 4.09040898e-02f, -4.88763191e-02f, 6.70394897e-02f, -9.00369734e-02f, -2.83438843e-02f, -1.43259197e-01f, -2.39914551e-01f,
  9.38638151e-02f, -3.43865231e-02f, 9.44532230e-02f, 5.80060743e-02f, 7.40963742e-02f, 2.72092558e-02f, 7.70049393e-02f, 1.01820506e-01f, -5.54280654e-02f, -1.24929035e-02f,
  -7.40527920e-03f, 4.47945483e-02f, -3.48840258e-03f, 3.91584763e-05f, -4.56871577e-02f, 8.64049327e-03f, 1.16786771e-02f, 8.68816897e-02f, 9.04267356e-02f, 2.63834856e-02f,
  -7.79654756e-02f, -1.21564731e-01f, 7.17263520e-02f, -1.19320536e-02f, -3.47447954e-02f, 2.01610569e-02f, 6.77937409e-03f, -2.60905214e-02f, 5.08894920e-02f, -3.22903655e-02f,
  3.11041120e-02f, 1.50840608e-02f, -5.68825305e-02f, 6.44473508e-02f, -3.56861427e-02f, 9.25643928e-03f, -6.12430423e-02f, 2.92489417e-02f, -6.84002936e-02f, 7.40776584e-02f,
  -3.44564579e-02f, 1.35159846e-02f, -1.57238487e-02f, 8.87394771e-02f, -3.10976785e-02f, -2.70477100e-03f, -7.50403553e-02f, -5.35077006e-02f, -1.41464863e-02f, 4.13094200e-02f,
  8.95632803e-02f, 5.73946387e-02f, -5.03971018e-02f, 1.14077441e-02f, -8.44991282e-02f, -7.91335106e-02f, -5.85924610e-02f, 1.54336803e-02f, 6.41397908e-02f, -6.03162870e-02f,
  3.09629768e-01f, 3.12292743e-02f, 4.66476306e-02f, -2.24113483e-02f, -7.67359603e-03f, -1.02567766e-02f, 5.57348914e-02f, -5.41527383e-02f, 5.88786229e-02f, 1.34367868e-02f,
  -4.30109724e-02f, 9.37938541e-02f, -2.56043556e-03f, 1.19342301e-02f, 3.56458277e-02f, -4.99488600e-02f, -3.29880267e-02f, -3.01184375e-02f, -3.57136130e-02f, 5.13008237e-02f,
  3.36094499e-02f, -7.48638660e-02f, 1.48929909e-01f, 9.36272293e-02f, -7.06399186e-03f, 1.37571886e-01f, 1.23180658e-01f, 1.20250108e-02f, 1.41773270e-02f, 4.05247882e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.45918250e-02f, -1.21782362e-01f, -3.25546384e-01f, -9.48643163e-02f, -1.51655003e-01f, 7.15109659e-03f, 1.66668873e-02f, 4.88441549e-02f, 7.62744388e-03f, -1.41844571e-01f,
  -7.28770299e-03f, 1.43790208e-02f, 8.74646101e-03f, -8.76914039e-02f, 2.62975674e-02f, -1.03064910e-01f, -2.42845818e-01f, -1.77968517e-01f, 1.37386620e-02f, 2.08948217e-02f,
  -6.34907261e-02f, 3.56636569e-03f, -9.94479805e-02f, 1.80033091e-02f, -4.21302021e-02f, -8.26197118e-02f, -2.06081793e-01f, -1.38451504e-02f, -4.91588609e-03f, -1.46701857e-01f,
  -1.14378735e-01f, -2.16237083e-02f, -6.13738000e-02f, 5.86409904e-02f, -6.86261207e-02f, -3.32818590e-02f, 1.19778970e-02f, -1.21068284e-02f, 8.71859863e-02f, 5.20438477e-02f,
  -2.85837632e-02f, 6.10725470e-02f, 2.17935238e-02f, 8.03171173e-02f, 3.56335640e-02f, 4.85350043e-02f, -4.27312776e-02f, -3.38253267e-02f, -3.45135964e-02f, 4.49032113e-02f,
  7.48582035e-02f, -1.51605979e-02f, -1.23402001e-02f, -7.52327964e-02f, -5.02596684e-02f, -6.96526989e-02f, 6.94635808e-02f, 4.33500707e-02f, 1.90109927e-02f, -7.23972097e-02f,
  -7.66584426e-02f, 3.72686721e-02f, 3.01289242e-02f, 9.87709016e-02f, 2.85338587e-03f, 1.27094053e-02f, 3.98256816e-02f, 8.32356215e-02f, -2.40401980e-02f, 3.83015238e-02f,
  -5.59682176e-02f, -4.18091659e-03f, 7.12381024e-03f, 2.66028065e-02f, 4.30171518e-03f, -2.00193580e-02f, -5.97471595e-02f, 1.63660441e-02f, -2.42398586e-02f, -7.53671825e-02f,
  -6.74902834e-03f, 8.07469338e-03f, -6.26419261e-02f, -4.97788899e-02f, -9.11583006e-02f, -3.58227938e-02f, -2.12696996e-02f, 2.26265993e-02f, -7.94752389e-02f, -2.49633472e-03f,
  3.56305321e-03f, 3.99492681e-03f, -6.41027614e-02f, 3.30052264e-02f, -2.41562258e-02f, 4.38652039e-02f, 5.97119555e-02f, 7.54496679e-02f, 2.46593300e-02f, 4.27398458e-02f,
  -4.77859983e-03f, 8.59604478e-02f, -6.46124855e-02f, 2.71791853e-02f, -5.22051379e-02f, -1.93334557e-02f, -9.73456725e-02f, -6.35423884e-02f, -5.41335344e-02f, 1.76306143e-02f,
  5.19240014e-02f, -1.29292589e-02f, -7.90459290e-02f, -9.56844985e-02f, -3.84067707e-02f, 2.39232350e-02f, -2.09270082e-02f, -1.63487662e-02f, -1.05574995e-01f, -2.51690149e-02f,
  -2.00924009e-01f, 4.68117967e-02f, -1.00925758e-01f, -1.91649050e-03f, -2.63995267e-02f, 4.36154641e-02f, 2.08868831e-02f, -4.54450138e-02f, 6.75412565e-02f, -7.57487724e-03f,
  -2.54994407e-02f, -2.66324747e-02f, 8.16503447e-03f, 3.80602591e-02f, -4.27636057e-02f, 4.47067991e-02f, -1.93245392e-02f, -7.94198141e-02f, -1.32580787e-01f, -2.28401311e-02f,
  7.94197097e-02f, 8.76126662e-02f, -2.37751603e-02f, -7.32320249e-02f, 2.10187491e-02f, 3.64427939e-02f, 7.42856711e-02f, -7.72609860e-02f, 3.42409238e-02f, 2.84863021e-02f,
  -6.50895163e-02f, -9.13021117e-02f, 5.15264310e-02f, 4.43334430e-02f, -2.64870990e-02f, 3.91498990e-02f, 2.32535172e-02f, -1.68479662e-02f, -9.91286561e-02f, -5.30133434e-02f,
  3.84210870e-02f, -4.53288071e-02f, 1.31291198e-02f, -3.41468975e-02f, -4.55644093e-02f, 4.90996540e-02f, -1.61877275e-02f, 2.96558775e-02f, -4.62408587e-02f, -3.63492072e-02f,
  -6.38166219e-02f, 4.65869009e-02f, -6.17195405e-02f, 6.86100870e-02f, -6.93548471e-02f, -3.45471390e-02f, -9.08020660e-02f, -4.31706347e-02f, -3.54894474e-02f, -1.30074965e-02f,
  -2.83005815e-02f, 2.14642063e-02f, -4.00881954e-02f, 8.89563467e-03f, 6.71547800e-02f, -7.74523020e-02f, 7.69808665e-02f, 8.98791477e-02f, 3.65515538e-02f, -1.32328626e-02f,
  -7.95874596e-02f, -9.12266821e-02f, 4.26834747e-02f, 4.15279204e-03f, -9.93571617e-03f, -3.76645029e-02f, -5.28600477e-02f, -2.15882901e-02f, 1.20487614e-02f, 1.53031554e-02f,
  -8.76790285e-02f, -5.77887148e-03f, 8.82913172e-02f, 4.24801111e-02f, 2.77495570e-02f, 8.21874887e-02f, -3.87180746e-02f, -8.07475597e-02f, 4.18820754e-02f, -8.15107226e-02f,
  9.24237296e-02f, -3.78662013e-02f, -1.16152026e-01f, 6.43858239e-02f, 3.85825001e-02f, -8.53995159e-02f, -6.86245337e-02f, -8.72111246e-02f, -1.60664059e-02f, -9.32754669e-03f,
  -6.40812293e-02f, -9.59094241e-02f, 4.48023826e-02f, -3.90692502e-02f, 1.68256939e-03f, -2.07694117e-02f, -1.65109579e-02f, 2.80223619e-02f, -4.55017462e-02f, -5.73118962e-02f,
  -6.22715801e-03f, -7.19863251e-02f, -1.04670055e-01f, -5.04011326e-02f, 7.78268948e-02f, -5.36535643e-02f, -2.53419811e-03f, -9.62392241e-03f, -9.83242840e-02f, -7.73866177e-02f,
  1.22238219e-01f, -2.66276971e-02f, 2.58717090e-02f, -8.08812864e-03f, -2.80996598e-02f, -5.52793033e-02f, -4.19468544e-02f, 4.25965041e-02f, 2.35249829e-02f, -1.16298757e-02f,
  1.35881066e-01f, 1.48154169e-01f, 9.27177966e-02f, 1.52375847e-01f, 1.42936021e-01f, -7.65608177e-02f, 2.65668426e-02f, 4.13677888e-03f, 9.23395008e-02f, -6.63393587e-02f,
  -7.51006454e-02f, 7.08928183e-02f, 1.16692863e-01f, 7.84432665e-02f, -7.91590381e-03f, 5.84828071e-02f, -1.54870041e-02f, -8.45034048e-02f, 3.07394341e-02f, -2.84066070e-02f,
  -5.23733608e-02f, 1.49255902e-01f, 5.60186803e-02f, 9.83207747e-02f, -1.12451902e-02f, 8.49662349e-03f, -5.25112897e-02f, 1.33505967e-02f, -4.08059731e-02f, 3.64931673e-02f,
  -3.17253135e-02f, 4.71200943e-02f, 1.26618911e-02f, -7.77399912e-02f, -5.09428233e-02f, -7.75835291e-02f, 5.88741563e-02f, 8.43957812e-02f, 6.86949044e-02f, 1.11497166e-02f,
  4.95804437e-02f, 7.74010718e-02f, -3.41304913e-02f, -3.00312210e-02f, 1.21467039e-01f, 1.12796880e-01f, 6.97807744e-02f, 5.33347651e-02f, 9.59347636e-02f, 1.58426389e-02f,
  4.42466728e-04f, 9.34415832e-02f, -6.84067048e-03f, 8.42220411e-02f, 8.10968876e-02f, -3.22180316e-02f, -6.95516914e-02f, -3.81088555e-02f, -4.76429723e-02f, 6.42026914e-03f,
  4.42617945e-03f, 7.86291361e-02f, -4.36095148e-02f, -7.95550346e-02f, 7.43792653e-02f, -2.88752206e-02f, -3.03139035e-02f, 2.04608627e-02f, 8.43429491e-02f, -4.37000796e-04f,
  -1.10507738e-02f, 3.84269394e-02f, -6.84328079e-02f, -7.10346028e-02f, -6.88877031e-02f, 2.13621967e-02f, -4.34374772e-02f, -5.84348291e-02f, 7.26616243e-03f, 7.55302086e-02f,
  -6.39411733e-02f, 4.89737093e-02f, 1.31079838e-01f, 4.47224528e-02f, -7.31869936e-02f, 6.41382933e-02f, -5.63051105e-02f, 3.28285433e-02f, 6.71463385e-02f, -5.49666397e-03f,
  6.85015544e-02f, 1.39559619e-02f, -5.97754195e-02f, 7.10483044e-02f, -3.10464650e-02f, 3.76897566e-02f, -1.40706732e-04f, 1.58428494e-02f, -1.55446120e-02f, 2.15087291e-02f,
  -1.21420417e-02f, -3.53298858e-02f, 6.09062202e-02f, -8.62103924e-02f, -9.38934758e-02f, 4.93231826e-02f, -1.19331777e-01f, -1.06177390e-01f, -6.16786256e-02f, -1.33608177e-01f,
  -2.86770821e-01f, -3.76305804e-02f, -4.74866992e-03f, -7.01480061e-02f, 3.81377339e-03f, -3.47979106e-02f, -2.38831583e-02f, 3.90921347e-02f, 6.17984720e-02f, -4.21153158e-02f,
  -3.97877917e-02f, 5.80244772e-02f, 1.16511174e-01f, 1.34494185e-01f, 8.49586278e-02f, 5.39717339e-02f, 3.44627686e-02f, 3.91777866e-02f, -1.79185960e-02f, -6.60959482e-02f,
  -5.87526560e-02f, 6.27922127e-03f, -1.21427424e-01f, -3.58100757e-02f, 3.42237875e-02f, 7.62519538e-02f, -2.16180813e-02f, 3.65183577e-02f, 2.74124667e-02f, 6.07426204e-02f,
  1.12563096e-01f, -8.04292783e-02f, 5.12612350e-02f, -8.13537538e-02f, -3.91444489e-02f, -4.97684069e-02f, 3.13432105e-02f, -3.61933820e-02f, 2.11851764e-02f, 5.10961041e-02f,
  -9.56003964e-02f, -5.49279824e-02f, -7.07211904e-03f, 7.97787681e-03f, 6.17383234e-02f, -7.31214806e-02f, -4.01763022e-02f, -6.05086274e-02f, 9.05102491e-02f, 1.68211721e-02f,
  2.52237357e-02f, -1.03260331e-01f, 1.71990402e-03f, 4.90886383e-02f, -3.13267596e-02f, -1.04966938e-01f, 3.04836649e-02f, 1.37932356e-02f, 2.23443173e-02f, 1.68409280e-03f,
  1.00363838e-02f, 3.90489176e-02f, -6.78842664e-02f, 2.80298982e-02f, 1.33284023e-02f, 6.59272969e-02f, 4.63214852e-02f, 7.69657269e-02f, -3.04603595e-02f, 4.20504622e-02f,
  9.40985084e-02f, -9.57883894e-02f, 2.91375238e-02f, -5.57372496e-02f, -3.30332890e-02f, -6.54329136e-02f, -4.75159436e-02f, 1.93995573e-02f, -2.05849558e-02f, -1.57668125e-02f,
  -5.20478236e-04f, 7.66321793e-02f, 6.92972764e-02f, 6.42978922e-02f, -3.50079425e-02f, 1.90883521e-02f, -5.73706999e-02f, 6.50886074e-02f, -9.85732526e-02f, 2.84869671e-02f,
  1.07170694e-01f, -1.21784657e-01f, -4.20543663e-02f, -6.64433241e-02f, -3.51032970e-04f, -3.98278981e-02f, -9.53038707e-02f, -7.05693290e-02f, -5.91001026e-02f, 1.96134523e-02f,
  -1.71778575e-02f, -2.82599777e-02f, -5.01769893e-02f, -2.25393847e-02f, -3.94560769e-03f, -8.50813240e-02f, -1.75161567e-03f, 1.72131155e-02f, -6.77995384e-02f, 1.78359076e-02f,
  8.29304084e-02f, 5.34035638e-02f, 4.64979187e-02f, 1.04002647e-01f, -2.84369402e-02f, -1.95651315e-02f, 6.41250238e-02f, 1.37442863e-02f, -5.58153838e-02f, -1.38290389e-03f,
  1.05483048e-01f, 1.59966007e-01f, 7.24055618e-02f, -2.52436362e-02f, -6.23804741e-02f, 5.63970618e-02f, 1.42806515e-01f, 7.74978027e-02f, -1.19719014e-01f, 2.81416439e-03f,
  -2.07907078e-03f, -6.97685555e-02f, 5.36937779e-03f, -1.34549394e-01f, -8.34148377e-02f, -4.01695706e-02f, 3.14064883e-02f, -8.69677309e-03f, 9.16796401e-02f, 8.83922428e-02f,
  5.53590022e-02f, 8.11566338e-02f, 6.49121031e-02f, 2.19226778e-02f, -2.04759482e-02f, -1.07959747e-01f, -6.76473379e-02f, 6.90296218e-02f, 1.72365631e-04f, 9.97439250e-02f,
  8.54028836e-02f, 1.72405213e-01f, -1.40689343e-01f, 1.95531882e-02f, -5.23811392e-03f, -1.97714865e-02f, 1.66847762e-02f, 2.21555978e-02f, -7.06231743e-02f, 5.24893589e-02f,
  4.94849123e-02f, 3.29266302e-02f, -1.35574862e-02f, 3.90421711e-02f, 4.65493686e-02f, -6.44538179e-02f, -4.04297262e-02f, -4.34558801e-02f, -6.67346343e-02f, 6.02247529e-02f,
  1.94746405e-02f, 3.01396139e-02f, 5.31219617e-02f, 6.29089773e-02f, -1.73466525e-03f, -1.06664412e-01f, 7.34485388e-02f, 2.65779048e-02f, 6.70121387e-02f, -7.04526678e-02f,
  -6.74514771e-02f, -1.21004954e-02f, -2.94774137e-02f, -5.04058301e-02f, 5.28561585e-02f, -5.11761708e-03f, -2.14623213e-02f, -5.09679578e-02f, 8.83659627e-03f, 7.26308078e-02f,
  -5.22008575e-02f, 6.02838621e-02f, 9.41022560e-02f, -3.36109451e-03f, -7.39494041e-02f, 4.46243882e-02f, 8.22100788e-02f, -1.59573350e-02f, -6.24631383e-02f, 4.96403463e-02f,
  3.83983813e-02f, 1.04005858e-01f, -5.83732277e-02f, 1.00492537e-01f, -8.08986202e-02f, 1.48320794e-02f, -9.81856952e-04f, 7.81122297e-02f, 8.16479102e-02f, 3.75580117e-02f,
  -9.99771990e-03f, -1.31316315e-02f, 3.41690741e-02f, -9.05301273e-02f, -2.17690156e-03f, 8.21588282e-03f, -3.67284678e-02f, -2.99689304e-02f, 2.70304382e-02f, -4.28881869e-02f,
  5.97267561e-02f, -2.81407852e-02f, 4.54504788e-02f, -7.84301385e-02f, 3.88021208e-03f, 2.95622889e-02f, -6.74167201e-02f, -7.21089169e-02f, 3.34247239e-02f, 2.65347194e-02f,
  -3.31954099e-02f, -1.00852866e-02f, -8.54456127e-02f, -5.50741367e-02f, 5.43242060e-02f, -1.04832575e-01f, 8.32321718e-02f, -3.10231168e-02f, -1.20394491e-02f, -4.94236797e-02f,
  2.71328926e-01f, -1.63206443e-01f, -4.12567556e-01f, 5.00634946e-02f, -1.37008056e-01f, -1.91574797e-01f, -1.55558780e-01f, 1.10125601e-01f, 1.53443158e-01f, -1.58354759e-01f,
  -9.20124166e-03f, 1.15761563e-01f, -1.13825239e-01f, -1.28612071e-01f, -1.12203471e-01f, -3.16555619e-01f, -3.24569106e-01f, -8.91528204e-02f, 1.29187331e-01f, 1.44102126e-01f,
  5.07977605e-02f, 2.29437798e-02f, 1.93438753e-01f, 3.13675888e-02f, -3.49245556e-02f, -1.98570429e-03f, -2.04974443e-01f, -3.10853254e-02f, -2.11685881e-01f, -2.80834615e-01f,
  -2.41341487e-01f, 8.09723139e-02f, -1.35920048e-02f, 5.21702766e-02f, 1.08186919e-02f, 5.23605105e-03f, -5.36233112e-02f, -5.52376956e-02f, 6.93562403e-02f, 2.07338613e-02f,
  -1.61542080e-03f, 3.26621234e-02f, -4.10319865e-02f, -1.44254894e-03f, 1.60100069e-02f, 2.25355886e-02f, 2.08604522e-02f, -3.39024663e-02f, -4.44131047e-02f, -7.70620704e-02f,
  -5.71916029e-02f, -1.24992773e-01f, 2.14412413e-03f, 7.11341426e-02f, -2.81745419e-02f, 7.94719066e-03f, -4.73701209e-02f, -4.30953987e-02f, -1.04965575e-01f, -1.03982888e-01f,
  -1.04212083e-01f, -5.39444678e-04f, 3.18100452e-02f, -7.84533005e-03f, 2.67539788e-02f, 2.74418145e-02f, 1.19338767e-03f, 4.88722771e-02f, 8.43566805e-02f, 1.39007522e-02f,
  -2.37432308e-02f, -7.72146955e-02f, -5.60271293e-02f, 4.96210270e-02f, -1.00498796e-02f, -4.39755572e-03f, -7.36273453e-02f, -1.10258870e-02f, -8.56851507e-03f, -8.57122391e-02f,
  3.42225321e-02f, 1.67425200e-02f, -4.43710061e-03f, 7.48943761e-02f, -2.35269852e-02f, -4.88808081e-02f, 4.75300401e-02f, 9.91054997e-03f, -1.54466704e-02f, 6.79981560e-02f,
  2.07936764e-01f, -1.48691744e-01f, -1.13262057e-01f, 1.34210244e-01f, 4.44650091e-03f, -8.21616128e-02f, 7.33164093e-03f, -9.22677666e-02f, -2.10664165e-03f, -3.81221287e-02f,
  5.49189150e-02f, 4.62366082e-02f, 3.52686713e-03f, -4.59893495e-02f, 7.19765648e-02f, 8.52642674e-03f, -5.46410009e-02f, -1.12079959e-02f, -4.47749570e-02f, 7.89813548e-02f,
  -7.46025369e-02f, -1.83067508e-02f, -7.86480978e-02f, 2.05072723e-02f, 1.31901205e-02f, -7.45814294e-02f, -9.37685221e-02f, 3.10366508e-02f, -1.29376188e-01f, -1.16704792e-01f,
  -1.36441097e-01f, -1.35551110e-01f, -2.65914518e-02f, -1.06773190e-02f, 9.80393589e-02f, -7.10121617e-02f, -3.79142873e-02f, -8.14336240e-02f, 6.18512370e-02f, 1.67337265e-02f,
  1.62823945e-02f, 3.04915104e-02f, -1.59364820e-01f, -1.44944608e-01f, -2.16661051e-01f, -3.54281627e-02f, -3.88725437e-02f, -2.07585514e-01f, -1.40086278e-01f, -1.30529210e-01f,
  -1.37283742e-01f, -1.17273398e-01f, -1.66049466e-01f, -9.91248339e-02f, -8.30184147e-02f, -1.04172572e-01f, 1.83530070e-03f, 3.97394076e-02f, 5.79927973e-02f, -5.76502504e-03f,
  -9.89880189e-02f, 1.57262996e-01f, -7.42770219e-03f, 3.59205552e-03f, -1.11713391e-02f, 7.17172325e-02f, -5.82370311e-02f, 4.63213623e-02f, -4.70389985e-02f, 6.97883293e-02f,
  -4.99870218e-02f, -3.30361351e-02f, -2.35268287e-02f, -1.07473666e-02f, -4.56784293e-02f, -1.67286824e-02f, 3.47926393e-02f, -6.97255135e-02f, -9.89355613e-03f, -5.11885285e-02f,
  -5.17927371e-02f, -7.38352165e-02f, -1.11232758e-01f, -9.36515406e-02f, -6.54716790e-02f, 1.57282036e-02f, 8.96620527e-02f, 3.44809517e-02f, 5.51297776e-02f, -5.12093306e-02f,
  5.15281446e-02f, 1.17613142e-02f, -3.17324884e-02f, -4.33085347e-03f, -1.85377449e-02f, 2.46904958e-02f, -4.04606313e-02f, -4.01867703e-02f, -3.44050452e-02f, 2.07935087e-03f,
  -5.54666445e-02f, 5.42465374e-02f, 6.49177358e-02f, 7.75345787e-02f, -3.41022597e-03f, -3.88263017e-02f, 2.70296950e-02f, 6.67863293e-03f, -1.16412593e-02f, 5.24413213e-02f,
  -7.90247247e-02f, -1.91062260e-02f, -2.99949870e-02f, 1.05219800e-02f, 1.55142294e-02f, 5.34415245e-02f, 6.87640756e-02f, -2.91400938e-03f, 6.93229912e-03f, 9.08299983e-02f,
  -1.24804787e-02f, 2.73669492e-02f, -2.84102466e-03f, -1.10302549e-02f, 5.42786084e-02f, -1.51049346e-03f, 3.63133587e-02f, -9.83725651e-04f, 8.47539306e-03f, -6.59493059e-02f,
  -7.97285438e-02f, 5.08274585e-02f, -5.85218780e-02f, -9.17933285e-02f, 3.62015888e-02f, 5.42919375e-02f, -1.22023247e-01f, -3.75637077e-02f, -1.06813483e-01f, -4.34220172e-02f,
  -8.44893157e-02f, -1.25911206e-01f, -1.74455956e-01f, -8.63091871e-02f, -6.46432787e-02f, -1.42783210e-01f, -1.15738273e-01f, -1.14692606e-01f, -7.81172514e-02f, -9.51320380e-02f,
  -1.03263920e-02f, 1.22930303e-01f, 6.31003231e-02f, 2.04683729e-02f, -1.59116257e-02f, 1.36434704e-01f, 1.56049535e-01f, 2.28902742e-01f, 2.23922759e-01f, 3.13871726e-02f,
  2.22106632e-02f, 1.43043444e-01f, 2.23465800e-01f, 1.93967700e-01f, 1.14792064e-01f, 1.67944476e-01f, 7.45202303e-02f, -3.36648375e-02f, 1.26008898e-01f, 6.13420196e-02f,
  1.54850736e-01f, 1.12336107e-01f, 3.63946334e-02f, 8.89613107e-02f, -3.29845138e-02f, 5.23025170e-02f, 9.53511149e-02f, 7.80007094e-02f, 4.21893261e-02f, 4.14475240e-02f,
  -2.26267338e-01f, -7.83642679e-02f, 5.85998185e-02f, 4.31432091e-02f, -1.46626338e-01f, 7.04903379e-02f, -1.68193839e-02f, -6.41535297e-02f, -6.96963668e-02f, 6.33363277e-02f,
  3.52612324e-02f, 3.99727859e-02f, 7.64069147e-03f, -3.12602222e-02f, -5.10023236e-02f, -8.52089003e-02f, 2.25732215e-02f, -1.29507296e-02f, 6.41627386e-02f, -8.24560672e-02f,
  3.55754271e-02f, -3.73094268e-02f, -9.62023437e-02f, 8.37336108e-02f, 3.79302576e-02f, -6.79213181e-02f, 6.61562569e-03f, -3.30695137e-02f, 7.13515207e-02f, -9.52396989e-02f,
  6.12965822e-02f, 6.16958253e-02f, -3.58165912e-02f, 4.67535071e-02f, 1.17983017e-02f, 9.27159861e-02f, -7.04243705e-02f, 4.23984304e-02f, 6.40409440e-02f, 3.84983756e-02f,
  -4.75486517e-02f, -7.41751119e-02f, -2.36310274e-03f, 1.16774021e-02f, -4.63889539e-02f, -6.63448274e-02f, -9.20909867e-02f, 2.35995036e-02f, -1.30314361e-02f, -7.05058724e-02f,
  -5.05257547e-02f, 2.58415099e-02f, -1.00711383e-01f, -1.99859031e-02f, -4.78292108e-02f, -4.16675285e-02f, -2.77664028e-02f, 4.48120199e-02f, 6.34826161e-03f, 1.10197044e-03f,
  3.53240073e-02f, 1.91261861e-02f, 9.95491147e-02f, 8.97700116e-02f, -1.00988530e-01f, -5.99396043e-02f, 7.15977326e-02f, -2.36337241e-02f, -8.84547085e-02f, 4.40525636e-02f,
  -1.18809447e-01f, -8.63838419e-02f, -1.99084040e-02f, -3.43747288e-02f, -6.14871159e-02f, -2.92499885e-02f, -4.98268194e-02f, 5.01920655e-02f, 4.12975103e-02f, 3.53400335e-02f,
  3.75555195e-02f, -6.00713156e-02f, -5.32210581e-02f, 5.24808057e-02f, -4.25707847e-02f, 3.20208035e-02f, 5.95855489e-02f, -9.52231213e-02f, -5.73358685e-02f, 8.44974220e-02f,
  1.11381933e-01f, -1.16944522e-01f, -6.86640292e-02f, 1.28163651e-01f, 1.16415910e-01f, 2.11782511e-02f, 7.76970908e-02f, 1.13927223e-01f, 6.69475496e-02f, -8.97238404e-02f,
  -9.51107219e-02f, -1.16327055e-01f, -1.43305600e-01f, -2.47471947e-02f, -2.33491883e-02f, -1.72439590e-02f, 6.88145757e-02f, -1.83993690e-02f, 1.55199632e-01f, 1.16880000e-01f,
  7.17107058e-02f, 2.88542602e-02f, 8.78563002e-02f, 8.32571387e-02f, -9.81398895e-02f, -7.78089687e-02f, -3.23259719e-02f, -1.07483968e-01f, -3.14557850e-02f, -4.87294197e-02f,
  -1.19851470e-01f, 5.41394465e-02f, 6.21810816e-02f, -1.09007414e-02f, -1.13884648e-02f, 3.27960700e-02f, 5.37016802e-02f, -3.02074943e-02f, -4.40279096e-02f, 1.64907221e-02f,
  4.01515476e-02f, -1.20032225e-02f, 3.86099741e-02f, 2.26490330e-02f, -9.61173512e-03f, -3.80564854e-02f, 5.23373112e-03f, 7.99040869e-02f, -3.28227170e-02f, -1.17769115e-01f,
  -1.54213935e-01f, 1.41880289e-03f, 7.73931220e-02f, -3.18246298e-02f, -1.32529316e-02f, -7.47253597e-02f, -7.58403838e-02f, 8.53004456e-02f, 1.06600136e-01f, 3.09740212e-02f,
  -2.08956376e-02f, 5.04245497e-02f, 8.67880806e-02f, -8.79376978e-02f, 7.72405416e-02f, 5.75804748e-02f, -1.51951648e-02f, 4.21901345e-02f, -6.49175420e-02f, 3.40937376e-02f,
  2.02471334e-02f, -7.76290670e-02f, 9.64931324e-02f, 5.53813800e-02f, -7.69389868e-02f, 5.50936423e-02f, -8.30533206e-02f, -6.56110886e-03f, -8.36279541e-02f, -2.10218504e-02f,
  -7.65323788e-02f, -1.15893297e-02f, 9.44469199e-02f, -6.48846924e-02f, -7.09001347e-02f, 6.24754056e-02f, 4.39664721e-02f, 2.74327546e-02f, -5.88609688e-02f, -6.48629665e-02f,
  -8.28277841e-02f, -6.39161421e-03f, 1.11794397e-01f, -5.82187390e-03f, -5.27840629e-02f, -6.04516305e-02f, 3.56081165e-02f, -8.87734443e-02f, 4.38897386e-02f, 6.67338893e-02f,
  7.67211840e-02f, -6.77994490e-02f, -1.07331112e-01f, 6.90796971e-02f, 1.29923746e-01f, 1.27882317e-01f, 2.27664039e-03f, -6.49921522e-02f, 2.28102040e-02f, -7.40447715e-02f,
  -2.50635277e-02f, 5.55743650e-02f, 4.90818638e-03f, 4.91172001e-02f, 1.10470533e-01f, 6.47013262e-02f, 9.82949287e-02f, 8.08251724e-02f, 4.61032204e-02f, 1.41644016e-01f,
  1.99033860e-02f, -1.04783215e-01f, -1.21328153e-01f, -2.28941906e-02f, 1.94802340e-02f, 8.01541097e-03f, 1.99450590e-02f, 1.02616940e-02f, 9.62735415e-02f, -3.68920504e-03f,
  -2.79947463e-02f, 7.68792480e-02f, 1.24228552e-01f, 3.25292423e-02f, -3.89542878e-02f, -8.28367770e-02f, -7.71543607e-02f, -7.75347427e-02f, -2.62970775e-02f, -2.79501313e-03f,
  -2.80746352e-02f, -2.56590021e-04f, 6.11242093e-02f, -4.58298139e-02f, 9.85612571e-02f, 7.83010200e-02f, -1.27753273e-01f, -5.44770136e-02f, 2.87832832e-03f, -3.04038487e-02f,
  -1.41002014e-01f, -7.90209845e-02f, 3.89362089e-02f, 7.91521966e-02f, -8.35953653e-02f, -4.86731306e-02f, -7.33743086e-02f, -4.72031645e-02f, 4.43082117e-02f, -1.08629003e-01f,
  -5.75971603e-02f, 3.98393050e-02f, 3.02217156e-02f, -1.39069790e-02f, 1.86809935e-02f, -3.41740437e-02f, -2.89260391e-02f, -2.63488069e-02f, -1.02821469e-01f, -2.68579666e-02f,
  8.56823027e-02f, -2.63362867e-03f, 4.64361571e-02f, -3.15252207e-02f, -6.50348887e-02f, 9.78784040e-02f, -8.35647732e-02f, 1.59514602e-02f, -1.94597915e-02f, 3.96911837e-02f,
  -6.85824677e-02f, -3.08137499e-02f, 2.66954061e-02f, 8.79311860e-02f, 7.71103948e-02f, 1.91680323e-02f, 1.33526856e-02f, 3.25207673e-02f, -2.25799787e-03f, 7.96564147e-02f,
  -1.61603745e-02f, -3.31393182e-02f, 7.32844844e-02f, -2.62732580e-02f, -5.12829572e-02f, 6.65795654e-02f, 3.22917243e-03f, -3.19510959e-02f, 2.62788613e-03f, 7.25156022e-03f,
  6.65489957e-02f, -2.04196014e-02f, 4.97942194e-02f, -5.48643023e-02f, 5.71620688e-02f, 2.26655304e-02f, -3.06868907e-02f, -4.13733944e-02f, 9.66608450e-02f, 2.33838744e-02f,
  -3.46756056e-02f, -4.80630696e-02f, 9.57241058e-02f, 6.74333470e-03f, -1.05467811e-02f, -5.10509685e-02f, 7.87260532e-02f, 3.31785306e-02f, 4.02686745e-02f, -9.28907767e-02f,
  8.55044201e-02f, 3.54956612e-02f, 6.54738173e-02f, -6.80633038e-02f, -5.25235087e-02f, 1.02278955e-01f, -2.57743951e-02f, -1.79098230e-02f, 6.77842945e-02f, -8.55743885e-03f,
  -5.74851111e-02f, 2.37336308e-02f, -3.32354791e-02f, 3.12271621e-02f, -3.92276831e-02f, -5.78976348e-02f, 6.46991804e-02f, -9.78319347e-02f, -1.16398185e-02f, -4.99976985e-02f,
  -8.57826993e-02f, -4.70899343e-02f, 7.81662986e-02f, 7.37080676e-03f, 1.40078038e-01f, 3.38653065e-02f, 2.67792344e-02f, 8.12292621e-02f, -7.44127706e-02f, 3.35506089e-02f,
  -1.62224248e-02f, 9.50043462e-03f, -7.04066828e-02f, 2.95420811e-02f, -4.10935208e-02f, 3.85614596e-02f, 3.33467871e-02f, 3.57332570e-03f, 7.16588050e-02f, 3.66731058e-03f,
  -6.54455693e-03f, -3.22882235e-02f, -7.51617998e-02f, -2.95850392e-02f, 5.37854843e-02f, -7.48839509e-03f, 5.22147194e-02f, 5.98429469e-03f, 5.73338568e-02f, 4.86635230e-02f,
  9.97492000e-02f, -4.66175638e-02f, 1.48293367e-02f, 3.87811996e-02f, 3.59580405e-02f, -3.39220054e-02f, -6.38632849e-03f, -5.68420365e-02f, -8.65777060e-02f, -9.03236642e-02f,
  -6.11886494e-02f, 4.29059975e-02f, 6.32455721e-02f, -3.58511768e-02f, -2.43662298e-02f, 4.11386788e-02f, 1.34073636e-02f, 4.83015589e-02f, -2.87698470e-02f, 3.62170953e-03f,
  1.53577456e-03f, 9.23084840e-02f, 4.78525497e-02f, -1.90510005e-02f, -2.13537440e-02f, 9.22248662e-02f, 6.48201406e-02f, -8.12272262e-03f, -5.03774956e-02f, 2.79012453e-02f,
  -7.80171975e-02f, 4.64938395e-03f, 1.02395602e-01f, 4.43104878e-02f, -2.73804739e-02f, 8.39104876e-02f, -1.45133762e-02f, -5.73562197e-02f, -8.87884721e-02f, -5.95384911e-02f,
  7.43334368e-02f, 1.05122298e-01f, 4.59206291e-02f, 2.40113884e-02f, 5.30083477e-02f, 7.79741257e-02f, -6.13282323e-02f, -5.79853095e-02f, 7.13242441e-02f, -7.10173929e-03f,
  9.21016634e-02f, 1.99691392e-02f, -5.24174199e-02f, 8.94100219e-02f, -2.74588391e-02f, 5.96392229e-02f, 9.72038209e-02f, 1.45216156e-02f, -4.44341823e-02f, 9.53393653e-02f,
  1.41898561e-02f, 2.12124772e-02f, -3.12751569e-02f, -1.07040331e-01f, 8.62825140e-02f, 6.60127774e-02f, -1.88347809e-02f, -1.17395855e-02f, 7.15408996e-02f, -3.10875941e-03f,
  2.24346854e-02f, 7.28755072e-02f, 5.84427221e-03f, -9.58513170e-02f, 4.39601392e-02f, -8.15064460e-02f, -1.85050238e-02f, -7.61992903e-03f, 7.08875284e-02f, 1.89215764e-02f,
  6.41240329e-02f, -4.42760624e-02f, 1.21308081e-01f, 2.86391396e-02f, -3.51521969e-02f, 2.06509084e-02f, -5.13565131e-02f, 6.24954179e-02f, 1.19981527e-01f, -2.91043259e-02f,
  1.61317810e-02f, -1.87889546e-01f, -5.67235127e-02f, -6.55895099e-02f, -1.66408848e-02f, 1.52453594e-02f, 2.91407332e-02f, -1.19613662e-01f, 5.17469272e-03f, -4.77561839e-02f,
  -3.38286795e-02f, 5.67841232e-02f, 3.65712568e-02f, -2.41368879e-02f, -7.86438659e-02f, -8.21744427e-02f, -4.69964482e-02f, -2.67201755e-02f, 4.72505875e-02f, -1.13930516e-02f,
  -4.89312559e-02f, -8.18545669e-02f, -4.91746552e-02f, -8.03714022e-02f, 4.34018895e-02f, 1.05529569e-01f, -8.03659558e-02f, 4.50685695e-02f, 2.24347357e-02f, -3.03531624e-02f,
  1.41325012e-01f, -1.14245629e-02f, -4.89348080e-03f, 5.97012341e-02f, -6.12212159e-02f, -6.95589483e-02f, 7.14661404e-02f, 1.02696335e-02f, 6.85080811e-02f, -3.08275297e-02f,
  -6.00324646e-02f, -9.12625343e-03f, 6.48412574e-03f, 5.51710241e-02f, -5.01472093e-02f, -5.28750718e-02f, -4.13705148e-02f, -1.12209834e-01f, -1.06412970e-01f, 2.50493344e-02f,
  -4.85733487e-02f, 3.95123214e-02f, 6.61147684e-02f, -4.25201282e-02f, -8.89926106e-02f, 9.69431549e-02f, -3.36099528e-02f, -3.08194216e-02f, -1.45583441e-02f, -5.33361360e-02f,
  9.69337393e-03f, -2.61849295e-02f, 9.75905173e-03f, 1.07896663e-02f, -1.71648227e-02f, 6.90669939e-02f, 3.93046113e-03f, -6.47931080e-03f, 7.85287768e-02f, -6.54269308e-02f,
  -5.76131530e-02f, -2.16812361e-02f, 7.28362575e-02f, 8.48698337e-03f, -8.16492587e-02f, -5.97045161e-02f, -4.35901955e-02f, -4.50302893e-03f, -6.34364039e-02f, 3.24395522e-02f,
  -8.88345856e-03f, 7.87840933e-02f, 1.22619234e-03f, -7.06932768e-02f, 1.19301351e-03f, -2.99036056e-02f, 1.89246126e-02f, -5.59460334e-02f, 3.63213941e-02f, -5.07342294e-02f,
  1.20891757e-01f, 3.85353714e-02f, 3.20220329e-02f, 1.02846198e-01f, -6.80209771e-02f, 2.05492880e-02f, -3.35180797e-02f, 6.95196539e-02f, 7.35003203e-02f, 9.40439999e-02f,
  -2.24562990e-03f, 9.71438456e-03f, -8.04708600e-02f, 8.96631777e-02f, 4.31185141e-02f, -3.52351852e-02f, 3.03129386e-02f, -8.52823816e-03f, -4.92058769e-02f, -1.62081365e-02f,
  -1.30305097e-01f, 9.27505642e-02f, 1.07967675e-01f, -2.40662713e-02f, 2.19362173e-02f, 7.54129812e-02f, -7.98987970e-03f, 6.89277351e-02f, 6.51110709e-02f, -1.00675724e-01f,
  9.39681306e-02f, 8.43499452e-02f, -2.48697530e-02f, 1.25561967e-01f, 5.98605201e-02f, 5.78677468e-02f, 1.28100395e-01f, 1.34006694e-01f, -3.51495370e-02f, 2.83492845e-03f,
  4.24920917e-02f, -5.45748509e-02f, 6.39507025e-02f, -1.93939507e-02f, -1.00472935e-01f, 3.00131785e-03f, -8.37900043e-02f, -2.80599725e-02f, 4.56758700e-02f, -4.43141423e-02f,
  -6.99185804e-02f, 4.78237942e-02f, -6.35373220e-02f, -6.85449988e-02f, 4.61398698e-02f, -5.92716895e-02f, -5.34230508e-02f, 6.38477691e-03f, -8.11769292e-02f, -7.04932734e-02f,
  -4.50302772e-02f, 4.84302193e-02f, -6.93295076e-02f, -3.93504985e-02f, 5.43331094e-02f, 3.94215472e-02f, -8.73894542e-02f, 8.76572058e-02f, -6.50003329e-02f, -5.44290915e-02f,
  3.00346501e-02f, 4.76567820e-02f, -6.27958179e-02f, 3.27806058e-03f, 7.47253597e-02f, 9.88189802e-02f, -8.16182643e-02f, 7.32335746e-02f, -9.16894749e-02f, -5.41992709e-02f,
  -8.81589297e-03f, 1.07983863e-02f, 9.22261253e-02f, -2.91653955e-03f, 2.58755032e-02f, -3.56567316e-02f, -3.73087153e-02f, 6.72260125e-04f, -5.52425943e-02f, 6.28780872e-02f,
  -1.24409683e-02f, 2.86400001e-02f, -9.67772305e-02f, -2.77506746e-02f, 4.75749075e-02f, -8.66051316e-02f, 8.65575001e-02f, 6.24369010e-02f, -5.47059663e-02f, -3.35445181e-02f,
  1.67011935e-03f, 6.49827197e-02f, -5.38144074e-02f, -2.03231610e-02f, -3.31814252e-02f, 1.48447147e-02f, 6.60788715e-02f, -5.42898197e-03f, 3.18842046e-02f, 4.61768284e-02f,
  -7.79910013e-02f, 9.25577283e-02f, -2.35291999e-02f, 5.07444404e-02f, 3.06417495e-02f, -4.04977240e-03f, 6.87377304e-02f, -7.29709491e-02f, -2.20105629e-02f, 2.07636226e-02f,
  1.13962978e-01f, -5.43219596e-02f, 6.94922507e-02f, -2.68462747e-02f, -7.22766444e-02f, -4.82944138e-02f, -9.69306156e-02f, 3.74795645e-02f, -3.66301574e-02f, 5.40606305e-03f,
  -1.45186549e-02f, 3.88963670e-02f, 2.41740290e-02f, -1.74014792e-02f, 8.96093398e-02f, -6.46265149e-02f, -5.74461147e-02f, 8.80294666e-02f, -6.90622926e-02f, -3.16271372e-02f,
  1.26783166e-03f, 1.09021224e-01f, 1.33187309e-01f, 2.17987224e-02f, -3.22358161e-02f, -8.24358966e-03f, 6.82603791e-02f, 9.22477841e-02f, -1.93129461e-02f, 7.74534494e-02f,
  2.94454098e-01f, 3.63648981e-02f, 1.05873927e-01f, 1.41241491e-01f, 4.95130569e-02f, 8.36875383e-03f, 1.83368355e-01f, 1.03756972e-01f, 1.28382653e-01f, 2.49040369e-02f,
  3.10463691e-03f, 1.13620155e-01f, 3.00125908e-02f, 1.38045967e-01f, 1.23514794e-01f, -5.04074879e-02f, -4.43479866e-02f, 3.58844735e-02f, 1.46789756e-02f, -8.95483233e-03f,
  3.53409611e-02f, -2.68123671e-02f, 7.79595450e-02f, 7.85952583e-02f, -4.73610274e-02f, -8.43149573e-02f, 6.16262807e-03f, 5.94088249e-03f, 4.24216948e-02f, -4.25366201e-02f,
  -5.20152785e-02f, 1.37726173e-01f, 5.09819053e-02f, -6.01582862e-02f, -2.57481746e-02f, -1.05597630e-01f, -1.24643242e-03f, 1.95232201e-02f, -1.79822301e-03f, 5.44151738e-02f,
  -5.04267737e-02f, -9.34235752e-03f, -2.02012528e-02f, 4.10926566e-02f, 3.72973108e-03f, 6.28931373e-02f, 3.23207118e-02f, -9.09565948e-03f, -3.65777425e-02f, -1.07030153e-01f,
  4.54412550e-02f, 1.58072002e-02f, -4.69121113e-02f, 1.91388447e-02f, 1.81986636e-03f, 5.08283079e-02f, 2.53366912e-03f, -2.44289078e-02f, -2.88675423e-04f, -1.00891754e-01f,
  -7.89688528e-03f, -1.64779350e-02f, -3.66716199e-02f, 6.46457747e-02f, 5.56495637e-02f, 6.60747066e-02f, 7.09767044e-02f, 7.86388814e-02f, -4.99050599e-03f, 1.01120539e-01f,
  9.69979241e-02f, -3.92848568e-04f, -6.92209154e-02f, 1.13018602e-01f, 9.10732374e-02f, 7.76231587e-02f, 4.32605743e-02f, -1.29087847e-02f, 5.85804880e-02f, 3.53809632e-02f,
  -2.64200363e-02f, 1.40229333e-02f, 5.92877269e-02f, 8.45079590e-03f, 8.47374499e-02f, 6.24729171e-02f, 2.20564548e-02f, 2.78854482e-02f, -4.91710901e-02f, 9.28451493e-02f,
  -9.92900953e-02f, 9.90621820e-02f, 8.59120339e-02f, -1.16049806e-02f, 5.12396134e-02f, 6.75530210e-02f, -1.69974044e-02f, -1.18063956e-01f, 8.50314926e-03f, 2.40628584e-03f,
  3.99486087e-02f, 1.52292633e-02f, 6.88025961e-03f, 3.00165229e-02f, -2.95759104e-02f, -7.25339055e-02f, 5.27467616e-02f, -4.24442813e-02f, -7.55446926e-02f, 2.29826625e-02f,
  -1.22034311e-01f, 5.75375929e-03f, 9.26909968e-02f, 3.88925746e-02f, 7.57248104e-02f, -1.50510119e-02f, 2.45799348e-02f, 2.49257348e-02f, 9.32865739e-02f, 7.93799013e-02f,
  4.85696681e-02f, 1.41979326e-02f, -8.81108865e-02f, 1.09534025e-01f, 5.95083497e-02f, -6.03898652e-02f, 1.09026041e-02f, 4.68121022e-02f, 4.27436605e-02f, 9.12278444e-02f,
  3.54123153e-02f, -3.62089723e-02f, 4.93774675e-02f, 1.02431469e-01f, -9.08684731e-03f, -1.01931402e-02f, 1.11780472e-01f, -6.87978342e-02f, 6.16700575e-02f, 1.50878215e-02f,
  -2.76227053e-02f, -3.56887765e-02f, 2.52764504e-02f, -1.21694210e-03f, -5.87188266e-02f, -6.41523749e-02f, -7.11649507e-02f, 8.81661996e-02f, -2.31457036e-02f, 2.64201220e-02f,
  -9.32440236e-02f, -5.10041527e-02f, -1.95618086e-02f, 5.36567047e-02f, -4.39129062e-02f, -7.83306062e-02f, -7.68514425e-02f, 5.09433337e-02f, -3.39658000e-02f, 6.59471527e-02f,
  -7.93989226e-02f, 2.37923861e-02f, 5.11485972e-02f, -6.17851876e-02f, -4.74783890e-02f, 6.97786212e-02f, 3.19721028e-02f, 2.34338585e-02f, 7.16521516e-02f, -4.60911542e-02f,
  -7.67546520e-02f, 3.98855135e-02f, -4.55516670e-03f, 7.19502717e-02f, 6.61963150e-02f, 6.97261617e-02f, 1.53293507e-02f, -6.82760105e-02f, -8.50218758e-02f, -3.57843116e-02f,
  7.46379122e-02f, 9.42221135e-02f, -8.38098377e-02f, 3.32277827e-02f, 6.84240609e-02f, -3.52339894e-02f, 4.63423580e-02f, -1.84312183e-02f, 1.84024721e-02f, 1.49040828e-02f,
  3.55941243e-02f, 4.33451980e-02f, 3.82264331e-02f, 8.71325806e-02f, -1.75525271e-03f, 1.55803584e-03f, 4.48616147e-02f, 1.90627221e-02f, -2.67837141e-02f, 6.43546656e-02f,
  9.03496146e-02f, 4.88641188e-02f, 7.47389719e-02f, 3.21760103e-02f, -1.85341891e-02f, -8.40960667e-02f, 8.12880769e-02f, 3.02851945e-02f, 8.62097442e-02f, 2.75651962e-02f,
  1.64119841e-03f, 6.45973980e-02f, -2.31000017e-02f, -7.26205623e-03f, -4.82216552e-02f, 2.94886846e-02f, 7.47182071e-02f, 7.11101517e-02f, -5.89279532e-02f, 5.41381352e-02f,
  -2.54781991e-02f, -3.31726633e-02f, -3.87112647e-02f, 7.47756660e-02f, -6.51155710e-02f, 2.56601581e-03f, -7.04110339e-02f, 4.54972088e-02f, 5.07361293e-02f, 5.66785038e-02f,
  6.55418262e-03f, -6.96157888e-02f, -4.39193361e-02f, -7.99468979e-02f, -6.05025515e-02f, -3.05068437e-02f, 5.83840162e-02f, -4.33876701e-02f, -1.31527651e-02f, 1.74221341e-02f,
  -2.16364577e-01f, -3.26919742e-02f, 4.61507663e-02f, -5.38140275e-02f, -3.42116170e-02f, 8.26297551e-02f, -4.67587411e-02f, 1.06925555e-01f, 7.54429167e-03f, 1.68499332e-02f,
  -4.88620512e-02f, 1.01997722e-02f, -6.81433007e-02f, 3.77531908e-02f, 1.95135418e-02f, -9.84738488e-03f, -4.73221131e-02f, -1.47146813e-03f, -1.31196618e-01f, 2.62818523e-02f,
  -7.10546076e-02f, -1.40809894e-01f, -1.55991614e-01f, -1.17045874e-02f, 9.17329267e-02f, 4.34490032e-02f, 8.74330997e-02f, -9.60545391e-02f, 8.23409930e-02f, 4.61117737e-02f,
  -1.14569068e-01f, -9.48382467e-02f, 8.56371596e-03f, -9.43558961e-02f, -9.61945057e-02f, -5.50056100e-02f, 7.17626214e-02f, -7.53786881e-05f, -8.48385133e-03f, -8.81529078e-02f,
  1.78910606e-02f, 3.47445495e-02f, -5.80639988e-02f, 5.06662875e-02f, 4.63139862e-02f, 4.57819588e-02f, 6.17428683e-02f, -1.64239779e-02f, -3.27296555e-02f, -7.04564676e-02f,
  -2.29272116e-02f, 4.36217636e-02f, -1.26430895e-02f, 6.42689466e-02f, 1.06315531e-01f, 4.47794124e-02f, 6.35135919e-02f, 3.72313336e-02f, -3.27448696e-02f, -3.04292012e-02f,
  6.73930198e-02f, -2.53743362e-02f, 4.18519862e-02f, -9.35041830e-02f, -5.40367104e-02f, 5.56526333e-03f, 8.73263553e-02f, -3.09021249e-02f, -4.57250625e-02f, 3.09742447e-02f,
  -8.01312551e-02f, -3.32394466e-02f, -9.32902545e-02f, 1.75621100e-02f, -4.50432412e-02f, 1.64799765e-02f, 7.60552734e-02f, -5.26569895e-02f, -1.92088075e-02f, -8.87950649e-04f,
  -2.56241136e-03f, 3.79538871e-02f, 7.18670264e-02f, 3.96183468e-02f, -4.12468910e-02f, 8.83035436e-02f, 3.12531963e-02f, 8.11640248e-02f, -2.54809335e-02f, 7.92453960e-02f,
  -7.97239840e-02f, -9.01131704e-02f, 4.25323471e-02f, 2.95985732e-02f, -5.72553650e-02f, -5.20577133e-02f, -6.82072528e-03f, 3.96842100e-02f, -3.29427496e-02f, -8.78444910e-02f,
  4.97300103e-02f, -7.16692209e-02f, -6.04592226e-02f, -1.32195679e-02f, -8.10749009e-02f, -1.41690318e-02f, -4.39450778e-02f, 5.77721000e-02f, 6.89650103e-02f, 3.23305503e-02f,
  -1.20839393e-02f, -1.97693240e-02f, 2.61719506e-02f, -6.38230667e-02f, -3.19465660e-02f, 4.57598157e-02f, 1.23045244e-03f, -3.41918096e-02f, -4.01666015e-02f, 5.47422608e-03f,
  -6.49242662e-03f, 3.25092417e-03f, -1.17106712e-04f, -5.14140725e-02f, -5.21413200e-02f, -7.34446272e-02f, 6.98393509e-02f, 8.47656354e-02f, 2.51535070e-03f, -7.59068690e-03f,
  -7.19286688e-03f, -8.29089805e-02f, 7.85801187e-02f, 7.82891288e-02f, -5.63403890e-02f, 8.91833752e-02f, 1.78624061e-03f, 4.91285510e-02f, 6.38786182e-02f, 6.56379461e-02f,
  1.50780259e-02f, -8.46692827e-03f, 4.41562869e-02f, -7.79594928e-02f, -7.72761041e-03f, 1.62745975e-02f, 6.57086680e-03f, -8.75371173e-02f, -5.91568612e-02f, -7.10911900e-02f,
  1.15396090e-01f, -2.75523346e-02f, -5.79268718e-03f, -4.43153009e-02f, 4.39027324e-02f, 3.80340070e-02f, 1.69537142e-02f, -4.38643210e-02f, 3.80921289e-02f, -2.62048692e-02f,
  -4.34177183e-02f, -9.53054801e-02f, -5.95688447e-02f, 7.05164447e-02f, 8.37434456e-02f, -8.33868831e-02f, -5.24148718e-02f, 7.36824470e-04f, -4.47692722e-02f, -1.94508471e-02f,
  -1.13529705e-01f, -8.83959457e-02f, -2.05948148e-02f, 9.84881818e-03f, 6.10005297e-02f, -7.28531554e-02f, 8.98897648e-03f, 2.05822065e-02f, 6.62492141e-02f, 8.28827694e-02f,
  -6.64284006e-02f, 4.75445203e-02f, -7.84725547e-02f, 7.52587020e-02f, -3.20229158e-02f, -7.36279711e-02f, 2.39857044e-02f, 5.29536456e-02f, 6.29208162e-02f, -5.56538366e-02f,
  -3.32949795e-02f, 6.36208197e-03f, 7.51634687e-02f, -6.29649237e-02f, 1.27234766e-02f, 1.53518450e-02f, 2.57824510e-02f, 5.29526621e-02f, -2.75431760e-02f, -1.79760053e-03f,
  -3.17198671e-02f, -1.49177015e-02f, 2.96984911e-02f, 8.21389705e-02f, -6.60643354e-02f, -2.18946207e-02f, -1.82680991e-02f, -5.96740618e-02f, 7.13098794e-02f, 5.48344813e-02f,
  1.36989579e-01f, -5.76156937e-03f, -4.87570825e-04f, 6.64877295e-02f, -4.16649766e-02f, 7.83533510e-03f, -4.82009947e-02f, 4.36096080e-02f, -6.64242879e-02f, -5.57973236e-02f,
  8.14465284e-02f, 8.85889232e-02f, -4.72948477e-02f, 4.82416116e-02f, 8.53084102e-02f, -5.19395843e-02f, -8.35486278e-02f, 3.68984193e-02f, -9.12917554e-02f, -1.63626336e-02f,
  1.57129541e-02f, 8.81813541e-02f, 1.75577775e-02f, -4.54637296e-02f, -8.20192546e-02f, 1.02452010e-01f, 1.05122127e-01f, 1.04268175e-02f, -5.51027581e-02f, 4.13158424e-02f,
  1.72479264e-03f, 1.16946027e-02f, 1.77796017e-02f, 3.34014744e-02f, -6.18460064e-04f, -5.40868342e-02f, -9.16421488e-02f, -7.33230561e-02f, 3.76913287e-02f, 2.90124211e-02f,
  -1.04376050e-02f, -2.70313025e-02f, -1.15543716e-02f, -9.94923562e-02f, -1.20420374e-01f, -3.68575566e-02f, 5.23516797e-02f, -1.37969106e-01f, -5.81750832e-02f, -1.33214593e-01f,
  -4.21344899e-02f, 2.80508865e-02f, -1.19874708e-01f, -4.76121493e-02f, 3.44802141e-02f, -1.15686646e-02f, -5.86847849e-02f, -1.11018375e-01f, -2.01522484e-02f, -7.99064934e-02f,
  1.96260676e-01f, -4.83829603e-02f, -1.95424818e-02f, 1.89544484e-02f, -3.88305139e-04f, -1.99428927e-02f, -3.07166632e-02f, -6.55681118e-02f, -4.28354181e-02f, -3.55686955e-02f,
  -2.60644555e-02f, 5.10739721e-02f, -4.63174582e-02f, -6.56017065e-02f, -5.01336232e-02f, 2.27898024e-02f, -3.26059647e-02f, -1.14389203e-01f, -1.03787342e-02f, -1.35066342e-02f,
  -1.20955080e-01f, -8.38057399e-02f, 7.04027526e-03f, 4.66758832e-02f, 1.71231311e-02f, -1.11622646e-01f, 4.81593572e-02f, 1.07801035e-02f, -3.31550427e-02f, 1.43342122e-01f,
  -5.31919450e-02f, -6.60013482e-02f, -5.07083982e-02f, 2.38968688e-03f, -4.25181463e-02f, -1.70723535e-02f, -1.97490156e-02f, 5.58066070e-02f, 5.70997782e-02f, 8.83647874e-02f,
  3.43845934e-02f, 2.97434144e-02f, 5.10107614e-02f, 6.34730980e-02f, 6.05179854e-02f, 6.48160726e-02f, 4.90147136e-02f, 1.71984814e-03f, 5.82876839e-02f, -1.49013121e-02f,
  -5.70365302e-02f, 1.04443729e-02f, 1.00134745e-01f, -1.26987388e-02f, 2.66662128e-02f, -7.57146105e-02f, 6.02195933e-02f, -2.00403724e-02f, 4.99658957e-02f, 3.44111472e-02f,
  2.13300198e-01f, -1.52934462e-01f, 1.14329569e-01f, -7.03560561e-02f, -8.80137160e-02f, -7.16728047e-02f, -1.25043187e-02f, 3.71328741e-02f, -7.09870383e-02f, 8.60710889e-02f,
  -6.08986877e-02f, -3.51668857e-02f, 1.28694130e-02f, 1.43925869e-03f, -6.47177473e-02f, -8.18687025e-03f, 1.49624459e-02f, -7.95466304e-02f, -6.95471615e-02f, 6.92562060e-03f,
  -2.26177368e-02f, -2.90273037e-02f, -2.81603802e-02f, 1.02475569e-01f, -2.54067685e-03f, 7.57294297e-02f, 9.70695317e-02f, -4.00772206e-02f, 1.05190977e-01f, 1.46440849e-01f,
  -2.33931452e-01f, -9.83226001e-02f, -2.20232055e-01f, -2.55788982e-01f, 4.78492714e-02f, 1.09122813e-01f, 1.55217079e-02f, 8.82210061e-02f, -3.36718350e-03f, -1.67444140e-01f,
  -8.03946108e-02f, -1.31308511e-01f, -1.39753252e-01f, 6.63492233e-02f, 1.09092087e-01f, -1.64632946e-02f, -1.73869990e-02f, -7.80471563e-02f, 1.27350792e-01f, 8.11526254e-02f,
  -8.71289149e-03f, -1.52721763e-01f, -3.86975929e-02f, 1.37011232e-02f, -5.03401868e-02f, -1.05167642e-01f, -2.09006578e-01f, -7.56827071e-02f, -1.04878053e-01f, -9.72052962e-02f,
  -1.08128212e-01f, -7.36780688e-02f, 2.44586691e-02f, 9.47384685e-02f, -1.08540161e-02f, 7.75297880e-02f, -1.47197852e-02f, -9.93294343e-02f, -1.17088996e-01f, -1.10159069e-01f,
  -1.45488244e-03f, 5.94973303e-02f, -5.14098033e-02f, -4.97744326e-03f, 6.96846396e-02f, 9.41159129e-02f, -1.03934584e-02f, -8.93619359e-02f, 2.35827779e-03f, -2.52782125e-02f,
  -1.78880431e-03f, 2.77156923e-02f, -9.95939523e-02f, 7.38682747e-02f, -5.81660084e-02f, -1.20794866e-02f, 5.97828627e-03f, 4.54784483e-02f, -1.62294367e-03f, -1.37339860e-01f,
  1.38695225e-01f, -7.46905953e-02f, 6.66077659e-02f, 2.15017907e-02f, -7.76889175e-02f, -7.32869506e-02f, 4.23011146e-02f, -4.85092849e-02f, 5.27786743e-03f, -2.02751420e-02f,
  2.72439364e-02f, -3.92013006e-02f, 6.23045787e-02f, -1.29650754e-03f, -2.35538185e-02f, 5.40916137e-02f, -4.21432406e-02f, -4.00255881e-02f, 7.83900321e-02f, -2.79268436e-02f,
  -3.40512991e-02f, 1.82121564e-02f, 5.44477254e-02f, -1.46173723e-02f, 7.86888376e-02f, -5.79682216e-02f, 6.61667809e-02f, 1.03237353e-01f, 6.08312301e-02f, 5.54150939e-02f,
  -9.52434540e-02f, 1.16341025e-01f, 3.86186206e-04f, 2.65026353e-02f, -1.00303806e-01f, 4.07306030e-02f, -3.99554111e-02f, -9.42192227e-03f, 1.82346199e-02f, 9.54690874e-02f,
  9.91349816e-02f, -2.59934794e-02f, -1.21676825e-01f, 9.09416527e-02f, -2.89597083e-03f, 7.24750455e-04f, 2.67850887e-02f, -5.92589602e-02f, 2.22923756e-02f, -3.17267291e-02f,
  -5.29858805e-02f, 6.08626753e-02f, -6.09334856e-02f, -8.71204436e-02f, -2.31671818e-02f, -2.25306991e-02f, 6.36676028e-02f, 1.37525676e-02f, 6.99886493e-03f, -7.49873146e-02f,
  -1.12414725e-01f, 4.29300331e-02f, 4.33078827e-03f, 5.53154014e-02f, -5.49426340e-02f, 6.50230125e-02f, 7.99506009e-02f, -1.32965436e-02f, -9.98833552e-02f, 5.50857857e-02f,
  5.39520010e-02f, -6.76916614e-02f, -3.29210274e-02f, -6.56160489e-02f, -6.59486651e-02f, -2.70601977e-02f, -5.67299053e-02f, -1.48459539e-01f, -1.32757396e-01f, 5.86434864e-02f,
  -2.93797068e-03f, -7.18717128e-02f, -2.38756817e-02f, -5.60789779e-02f, -7.34454533e-03f, -6.33236989e-02f, 6.68118745e-02f, -8.91663320e-03f, -1.27857691e-02f, 5.35396859e-02f,
  6.89327568e-02f, -7.50754625e-02f, -9.62710902e-02f, 3.27077112e-03f, 7.29237571e-02f, -8.34290124e-03f, -2.52372175e-02f, -6.41337335e-02f, -3.10615003e-02f, -3.30941118e-02f,
  3.39290984e-02f, -7.60587603e-02f, -6.20506331e-02f, -2.64580846e-02f, -1.97131280e-02f, -4.24902029e-02f, -2.40483340e-02f, 8.92201625e-03f, 1.56796500e-02f, -9.22445282e-02f,
  6.09659702e-02f, -4.74255197e-02f, 7.39170909e-02f, 3.37826125e-02f, -6.27579540e-02f, -4.13102731e-02f, -4.73085977e-02f, -6.00979105e-02f, -1.59485936e-02f, -2.51403600e-02f,
  4.59030010e-02f, 8.77000615e-02f, 3.39074396e-02f, -1.29186595e-02f, 4.12244387e-02f, 8.33008140e-02f, 3.10189594e-02f, -2.72026900e-02f, 4.39096689e-02f, 9.92615148e-02f,
  7.68391117e-02f, 5.55381365e-03f, 5.82725219e-02f, 8.80330727e-02f, -5.27340211e-02f, -9.25841853e-02f, 3.15303318e-02f, -1.88378303e-03f, -5.48526645e-02f, -7.88067747e-03f,
  -9.26890448e-02f, -3.66131142e-02f, 5.99770471e-02f, -2.65717991e-02f, 8.78888741e-02f, 4.48504230e-03f, -6.56854659e-02f, -7.27008805e-02f, -7.90554211e-02f, -1.80389974e-02f,
  6.11142963e-02f, -1.04668615e-02f, 6.56435862e-02f, -4.75640409e-02f, -7.85610545e-03f, -2.87868530e-02f, 6.54431060e-02f, -9.68808681e-03f, -3.40987854e-02f, -7.21548423e-02f,
  6.08462654e-02f, 6.12985119e-02f, 8.37199986e-02f, -8.65387022e-02f, 1.50997015e-02f, -1.65926162e-02f, 1.59665402e-02f, -9.98517275e-02f, 6.38023466e-02f, -2.77938154e-02f,
  9.43271369e-02f, 4.28659357e-02f, 5.80810830e-02f, -3.29765826e-02f, 2.66723596e-02f, -1.64777264e-02f, -3.43887806e-02f, -1.35341706e-02f, -9.12870616e-02f, 6.98348060e-02f,
  -1.51786730e-01f, -4.15907875e-02f, -2.62731370e-02f, -2.73378771e-02f, -3.88012975e-02f, -4.04094867e-02f, -6.52809963e-02f, -9.55834985e-02f, 2.47074245e-03f, 4.70344201e-02f,
  4.14477568e-03f, -3.70449759e-02f, 5.44047989e-02f, -4.31327559e-02f, -4.35583927e-02f, -8.62778574e-02f, -1.97043438e-02f, 3.60015817e-02f, 3.17358822e-02f, 2.32481342e-02f,
  -7.15445653e-02f, 1.00407898e-02f, -3.44244689e-02f, -6.96637258e-02f, -4.19139042e-02f, -2.94900779e-03f, -2.43494511e-02f, -5.34303337e-02f, 2.18505263e-02f, 6.19267896e-02f,
  4.70902771e-02f, -1.76449195e-01f, -9.27955005e-03f, -3.89312729e-02f, 4.14631050e-03f, -4.49466780e-02f, 5.34448512e-02f, -8.61160904e-02f, 1.40154827e-02f, -3.80435474e-02f,
  -2.19783280e-02f, -4.16396894e-02f, 5.12856394e-02f, -5.64552769e-02f, 9.54262018e-02f, 1.91213395e-02f, 2.19439883e-02f, -5.50138839e-02f, 5.49649186e-02f, -5.02932221e-02f,
  -3.43390889e-02f, 2.00170279e-02f, -2.30874624e-02f, 2.52005178e-02f, -1.23596229e-01f, -1.46802301e-02f, 4.44907062e-02f, -6.09420389e-02f, 5.75406849e-03f, 1.00667119e-01f,
  -3.03434990e-02f, -4.84024212e-02f, 7.26719052e-02f, -3.84252481e-02f, -7.85173178e-02f, -2.83402577e-02f, -8.01595524e-02f, 6.32822812e-02f, -4.17524800e-02f, 3.98017652e-02f,
  -4.05204445e-02f, 2.08851881e-02f, -7.06530362e-02f, -5.47429956e-02f, -1.37618454e-02f, 3.43441665e-02f, -6.87321201e-02f, -2.08741184e-02f, 5.49102910e-02f, -9.15412605e-02f,
  -1.90063212e-02f, -6.84429407e-02f, -5.06217442e-02f, -6.02516718e-02f, -1.03022322e-01f, -5.17621860e-02f, -1.02106504e-01f, 4.88853864e-02f, -1.82120055e-02f, 8.28525145e-03f,
  2.15763390e-01f, -6.25824779e-02f, -7.27221593e-02f, -1.16051205e-01f, -8.61651227e-02f, 6.26506507e-02f, 1.57502666e-02f, 6.34335652e-02f, 1.14858011e-02f, -8.63988698e-02f,
  4.71388437e-02f, 8.33948627e-02f, 7.63472095e-02f, 6.76437542e-02f, 1.13436636e-02f, 2.32561901e-02f, 2.74226330e-02f, -2.69828290e-02f, 2.31196843e-02f, -7.43711665e-02f,
  -1.94059070e-02f, -2.85609043e-03f, 6.26266375e-02f, 3.15515585e-02f, -8.51011276e-02f, 1.04608573e-01f, 3.18562537e-02f, 7.15939254e-02f, 3.44428644e-02f, 1.44744024e-01f,
  -5.37035987e-02f, -8.17211252e-03f, -7.15311803e-03f, 6.70291558e-02f, 6.14388771e-02f, 9.09912512e-02f, 9.07542855e-02f, -8.04063827e-02f, 3.30456346e-02f, -5.87473959e-02f,
  -3.21796201e-02f, 4.94206175e-02f, -4.21473309e-02f, 7.63266608e-02f, -2.35014712e-03f, 2.60841679e-02f, -4.57995348e-02f, -6.71567321e-02f, -7.95939788e-02f, 1.74976047e-02f,
  8.34706426e-02f, -4.84949686e-02f, 3.57130840e-02f, 5.83349019e-02f, 4.97737229e-02f, 3.06101944e-02f, -1.36848562e-03f, 2.19653128e-03f, -1.18347378e-02f, -6.54522330e-02f,
  -6.40826076e-02f, -1.46415278e-01f, -1.06057175e-03f, 2.07067411e-02f, -6.35824874e-02f, -2.73597743e-02f, 1.02906791e-03f, 5.98122030e-02f, 4.15184833e-02f, -1.02658197e-01f,
  9.20978095e-03f, 5.66083603e-02f, 6.06110785e-03f, -5.59895672e-02f, -6.47770464e-02f, 5.38125448e-02f, -5.19390143e-02f, -8.53274390e-02f, 7.04710111e-02f, -9.58538428e-02f,
  1.00263387e-01f, -5.02961800e-02f, -5.69323264e-02f, 8.19530524e-03f, -3.02517749e-02f, 5.33871651e-02f, 3.95505130e-02f, 2.04576459e-02f, -2.78118178e-02f, -1.28773168e-01f,
  2.59120464e-02f, 5.73763549e-02f, -5.47585525e-02f, 3.55641767e-02f, 2.34932005e-02f, 3.86977829e-02f, 5.76633215e-02f, -1.35754216e-02f, 3.47517505e-02f, -1.83720402e-02f,
  6.78183660e-02f, -9.47705563e-03f, 1.71955954e-02f, -9.05677900e-02f, 6.62200674e-02f, 8.80849585e-02f, 7.39785954e-02f, 4.92947325e-02f, -3.43124457e-02f, -4.02872153e-02f,
  -7.12098554e-02f, 1.27147920e-02f, 1.81546379e-02f, 1.73331071e-02f, 5.39726689e-02f, -3.35228182e-02f, 4.46374491e-02f, 1.73712280e-02f, 8.43359083e-02f, 1.08780973e-02f,
  6.77070394e-02f, 8.88460129e-02f, -6.86127767e-02f, -1.00538343e-01f, 4.33031991e-02f, -1.70268733e-02f, -6.53394461e-02f, -4.82891425e-02f, -8.76884311e-02f, -1.16487988e-03f,
  2.23973952e-03f, -8.87612924e-02f, 4.01075045e-03f, 1.23926541e-02f, 3.22767794e-02f, -9.20779556e-02f, -3.83829251e-02f, -3.04760244e-02f, -5.22945896e-02f, 7.36806020e-02f,
  -9.66592878e-03f, -9.54885501e-03f, -6.85661808e-02f, -5.45831472e-02f, -5.74401952e-03f, -2.89494395e-02f, -1.95928980e-02f, -4.30402020e-03f, 3.09703667e-02f, -1.24744073e-01f,
  -1.43220022e-01f, 8.10783803e-02f, -4.20010313e-02f, -1.21177405e-01f, 6.70785531e-02f, 6.95675611e-02f, 1.29932836e-01f, 2.38341317e-02f, 1.34951132e-03f, -5.37916012e-02f,
  6.98328167e-02f, -4.22321213e-03f, -4.09710594e-02f, 2.73182383e-03f, 3.64470258e-02f, -3.28961905e-04f, -2.28342414e-02f, -1.43643960e-01f, -4.07557227e-02f, -1.11022115e-01f,
  -1.57227591e-02f, -8.79680924e-03f, -1.53494656e-01f, -7.55378231e-02f, 5.41299768e-02f, -5.80796413e-02f, 2.74494942e-02f, -5.36571824e-05f, -8.37289020e-02f, -9.69466195e-02f,
  8.34724084e-02f, 8.29674825e-02f, 1.18094943e-02f, 3.41281518e-02f, -8.04549828e-02f, -1.80936065e-02f, -6.59408122e-02f, 4.69751135e-02f, -7.03142583e-02f, 1.56900603e-02f,
  -5.71448468e-02f, 4.10640612e-02f, 7.03462213e-02f, 7.35374168e-02f, -8.94807801e-02f, -4.74652871e-02f, -2.14426108e-02f, 5.03077395e-02f, 6.57663569e-02f, 7.36202449e-02f,
  -3.81067134e-02f, 6.74393177e-02f, 9.58587322e-03f, -5.92955761e-02f, 6.01840839e-02f, 2.71798857e-02f, 4.93586920e-02f, -7.86521414e-04f, 8.62593483e-03f, -8.30375105e-02f,
  -8.62954259e-02f, -7.43490690e-03f, -6.50049327e-03f, -2.22509112e-02f, -3.00949775e-02f, 7.84121305e-02f, 3.84691693e-02f, 3.22353058e-02f, -3.13908048e-02f, 3.33885998e-02f,
  2.69788709e-02f, -7.24825487e-02f, 1.84018407e-02f, 5.54381981e-02f, 2.50415094e-02f, 9.20247287e-02f, -3.64402793e-02f, 5.96042797e-02f, 1.01746157e-01f, -5.27746454e-02f,
  3.81721631e-02f, -1.26713477e-02f, -1.21891806e-02f, 5.69298342e-02f, -6.31324723e-02f, -4.87600863e-02f, -3.34905870e-02f, 1.70679204e-02f, -3.95159200e-02f, -4.71733660e-02f,
  -2.50963941e-02f, -6.39266819e-02f, 4.69549522e-02f, -1.83301549e-02f, 2.76069064e-02f, 1.93630308e-02f, 1.58560649e-02f, 7.43957330e-03f, -1.05384238e-01f, 1.71048846e-02f,
  4.63614836e-02f, -1.00874990e-01f, -1.97307002e-02f, 7.56343156e-02f, -2.35646707e-03f, -2.02471912e-02f, -1.63343679e-02f, 3.80056351e-02f, 6.80589825e-02f, 2.78801490e-02f,
  -5.27001172e-02f, -2.91034337e-02f, -2.47853789e-02f, -3.65203395e-02f, 3.69027480e-02f, 5.44787198e-03f, 6.68888390e-02f, 6.48287088e-02f, -9.40150395e-02f, 6.43038377e-02f,
  -1.80730462e-01f, 1.17160240e-02f, 1.00819856e-01f, -1.00129329e-01f, 2.02882271e-02f, 1.20867062e-02f, -1.46923989e-01f, 5.11792228e-02f, 5.88624254e-02f, -8.73831287e-02f,
  -8.74822885e-02f, -5.39635681e-02f, -9.83417779e-02f, -7.80841485e-02f, -1.44754529e-01f, -9.70480889e-02f, -1.27980158e-01f, -1.33630214e-02f, -9.73335952e-02f, -1.31766036e-01f,
  -1.31226227e-01f, -1.07246898e-01f, -1.78506270e-01f, -6.49692044e-02f, -1.01206809e-01f, -1.37876108e-01f, 6.18960857e-02f, -3.97623144e-02f, -3.48290950e-02f, -1.58769190e-01f,
  9.01270881e-02f, 1.14518277e-01f, -1.51855475e-03f, -4.94697168e-02f, 3.27279903e-02f, 7.93384165e-02f, -8.77244920e-02f, 1.05152652e-01f, -3.58303450e-02f, -7.38956928e-02f,
  -7.68411905e-02f, -1.05537504e-01f, -3.56526338e-02f, -4.47759591e-02f, -5.98392449e-02f, 4.96842386e-03f, -7.40431175e-02f, -5.78661971e-02f, -1.11571839e-02f, 1.74848549e-02f,
  -2.76288576e-03f, 3.13406624e-03f, -9.45129246e-02f, 7.71652907e-02f, -4.08275314e-02f, -4.15480435e-02f, 8.99207145e-02f, 5.38823158e-02f, -7.46060982e-02f, -2.96357777e-02f,
  -4.12370125e-03f, 5.34361303e-02f, -8.18510354e-02f, 7.27104396e-02f, -1.24949189e-02f, 1.87429115e-02f, 3.22664864e-02f, -1.03225015e-01f, 1.66408475e-02f, -1.01811394e-01f,
  -1.17903939e-02f, -4.77635581e-03f, 6.92307428e-02f, 1.53738009e-02f, -7.35424161e-02f, -4.24257405e-02f, -5.31676225e-02f, -2.01600883e-03f, -1.37699796e-02f, -4.73879799e-02f,
  -1.08924583e-01f, 1.88053474e-02f, -4.05039592e-03f, -2.78027691e-02f, 3.02536972e-02f, 4.88845482e-02f, 6.99670911e-02f, 4.10853811e-02f, -5.31445742e-02f, 7.00089186e-02f,
  -1.05804339e-01f, 5.57314157e-02f, -1.18857503e-01f, -7.16045126e-02f, 2.07167566e-02f, -6.92787245e-02f, 5.59465960e-02f, -4.46127430e-02f, 4.75518145e-02f, -8.42809305e-03f,
  -3.10535952e-02f, 3.06973755e-02f, 3.43025848e-02f, 1.24415727e-02f, -1.15315914e-01f, -5.55873476e-02f, -1.06125057e-01f, -5.09159043e-02f, 3.69319655e-02f, 4.76700813e-02f,
  -9.62246656e-02f, -1.28561020e-01f, -7.64699131e-02f, -1.15679450e-01f, -2.30324306e-02f, -1.00671761e-01f, 3.44016291e-02f, -1.05661809e-01f, -1.53159380e-01f, -2.06989944e-01f,
  -3.00127149e-01f, -8.11367258e-02f, -2.95127574e-02f, -9.52860415e-02f, -1.11361116e-01f, 3.24079283e-02f, 1.67834095e-03f, -7.42864534e-02f, 4.07230202e-03f, -1.53154507e-01f,
  -2.02848725e-02f, 3.64969485e-02f, -1.12133279e-01f, -1.17370980e-02f, -2.37608273e-02f, -8.68057460e-02f, -6.42798096e-02f, -5.61327226e-02f, -5.36673330e-02f, -5.11295423e-02f,
  -5.27042784e-02f, -6.55649975e-02f, -3.30325253e-02f, -3.07578277e-02f, -1.07365012e-01f, 9.87105072e-03f, 2.19114800e-03f, -8.05166140e-02f, -8.60791430e-02f, -1.41459271e-01f,
  1.44514605e-01f, 2.82117054e-02f, 7.69381821e-02f, 3.73887382e-02f, 6.89524785e-02f, -6.23447448e-02f, 4.19375636e-02f, -3.92024070e-02f, -6.52668774e-02f, 1.19039603e-02f,
  -6.51386380e-02f, -3.84743437e-02f, 4.20593433e-02f, -8.57587531e-03f, 1.22339632e-02f, -1.10746771e-02f, 3.28572304e-03f, -1.99858453e-02f, 1.61354765e-02f, 6.23667575e-02f,
  2.76747812e-02f, 3.89579572e-02f, -2.72778384e-02f, -4.23552915e-02f, 1.08390003e-01f, 6.48594126e-02f, 1.15131745e-02f, 4.00252007e-02f, -8.88990611e-03f, 6.62318543e-02f,
  3.47482972e-02f, -1.58723947e-02f, 3.71849574e-02f, 2.88130268e-02f, -4.18317169e-02f, 7.36227408e-02f, -5.39127225e-03f, 4.33536693e-02f, 4.59106304e-02f, 4.91944999e-02f,
  4.66064401e-02f, 4.13469821e-02f, -9.60663483e-02f, -3.15766782e-02f, -6.26199692e-02f, 6.79008663e-02f, -5.13960309e-02f, 8.36273097e-03f, 5.54330759e-02f, -1.35521535e-02f,
  8.82900581e-02f, 1.44321145e-02f, 1.12048746e-03f, 1.00307718e-01f, 6.43806756e-02f, -2.81022023e-02f, 3.84155922e-02f, -2.84811482e-02f, -3.34946103e-02f, 2.48952806e-02f,
  2.89505254e-02f, 9.75911319e-02f, -2.13759579e-02f, 4.13722694e-02f, -6.87866732e-02f, 4.28055935e-02f, 1.45450430e-02f, -3.69379446e-02f, 3.91301028e-02f, -4.70441952e-03f,
  1.03220358e-01f, 3.72542515e-02f, 1.16728274e-02f, 9.57179293e-02f, 9.13819373e-02f, 9.35446322e-02f, -5.53909540e-02f, -8.41728151e-02f, 9.38291401e-02f, 9.15690288e-02f,
  1.92892123e-02f, 6.49368763e-02f, -8.43444467e-02f, 5.35950921e-02f, -6.35402948e-02f, -1.15103265e-02f, 1.11234576e-01f, 8.41474906e-02f, -3.63314264e-02f, 3.57554071e-02f,
  2.16641668e-02f, -2.45808110e-01f, -8.27983767e-02f, -1.06407352e-01f, 7.43851252e-03f, -3.44514288e-02f, -1.00550681e-01f, 2.36530732e-02f, -2.25185566e-02f, -1.17837384e-01f,
  -4.07205708e-02f, 9.52656195e-02f, -6.36664182e-02f, -7.85403252e-02f, -1.53981224e-01f, -1.83497474e-01f, -1.91476509e-01f, -1.67183399e-01f, 1.14168316e-01f, 1.38308525e-01f,
  -7.86983073e-02f, 3.69065069e-02f, -3.62078846e-02f, -4.73407395e-02f, -8.27877969e-02f, -1.09918348e-01f, -1.08879067e-01f, -1.28960162e-01f, -1.03006683e-01f, -6.08182810e-02f,
  -7.42357820e-02f, 1.91137586e-02f, 1.10963015e-02f, 1.74202286e-02f, -5.27792983e-02f, 7.91896135e-02f, -2.07193680e-02f, 1.58267580e-02f, 4.42786179e-02f, 3.84300053e-02f,
  5.57940044e-02f, 5.09746820e-02f, -5.59605099e-02f, 3.11016198e-02f, -7.78608024e-02f, 2.41465978e-02f, -9.03595015e-02f, -2.63945032e-02f, 6.54154792e-02f, 3.14776078e-02f,
  -1.51303886e-02f, -2.32682060e-02f, -9.34038311e-02f, -8.11296999e-02f, 1.11302212e-01f, 5.77027723e-03f, -6.92741573e-02f, 3.05298828e-02f, 5.64961210e-02f, -2.60826349e-02f,
  -8.52120817e-02f, -6.10885210e-03f, -6.67276978e-02f, -3.34639028e-02f, -7.70037342e-03f, 1.39836650e-02f, -9.97818112e-02f, 1.84782147e-02f, 2.20232662e-02f, 3.64259817e-02f,
  -4.15493129e-03f, -5.32817803e-02f, -4.49702516e-02f, -1.13745451e-01f, -7.72188008e-02f, 1.19582191e-02f, 8.55510607e-02f, -6.51524216e-02f, -5.07022766e-03f, 3.20903510e-02f,
  4.01523039e-02f, 3.95289250e-03f, 4.98430431e-02f, 6.69529103e-03f, -2.69401893e-02f, 3.63021381e-02f, 6.16989098e-02f, 8.14884380e-02f, 4.93388176e-02f, -5.34803271e-02f,
  -2.00871546e-02f, 6.88656569e-02f, -1.31493852e-01f, -8.16993490e-02f, -8.31927732e-02f, -8.54719430e-02f, -8.67799520e-02f, -3.44232358e-02f, 9.02343839e-02f, -6.89808056e-02f,
  7.80741824e-03f, -5.18521015e-03f, -4.76690605e-02f, 5.31506166e-02f, 9.04355943e-03f, -5.12273982e-02f, -3.40519585e-02f, -4.46711332e-02f, 7.43280053e-02f, -5.15060946e-02f,
  -2.24944539e-02f, -3.34036052e-02f, -6.53943270e-02f, -9.31671634e-02f, 4.07272577e-02f, -9.47639868e-02f, -2.97145136e-02f, -4.44431417e-02f, -1.70235068e-01f, -2.22491652e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.33560210e-01f, 1.91185009e-02f, -3.89585458e-03f, 1.20101273e-01f, 2.06538104e-02f, 1.46554962e-01f, -2.57875826e-02f, -1.11493897e-02f, 1.31940186e-01f, 7.87079558e-02f,
  1.09577350e-01f, -4.66125691e-03f, 3.73862162e-02f, 5.48301227e-02f, -7.51546174e-02f, 9.80683714e-02f, 2.60889735e-02f, 8.80027413e-02f, 2.14192569e-02f, -2.33164690e-02f,
  1.30684313e-03f, -3.10750492e-02f, -3.42199616e-02f, 4.76754233e-02f, 7.81298578e-02f, 1.24327496e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.22841135e-01f, -2.96048075e-01f, -1.18313983e-01f, -1.91019308e-02f, -5.21241948e-02f, -1.07715793e-01f, -1.03400378e-02f, 5.02743423e-02f, -1.26514956e-01f, 1.25308139e-02f,
  -5.63743487e-02f, 1.23065934e-02f, -1.44620975e-02f, -2.09720507e-02f, 2.66117528e-02f, -1.63241386e-01f, -3.71149704e-02f, 5.74998483e-02f, -9.42992568e-02f, -3.30624759e-01f,
  -1.25389904e-01f, -1.23413876e-02f, -4.46626917e-02f, 2.68702120e-01f, -9.54447538e-02f, -8.76254514e-02f, -3.13049138e-01f, -7.72988275e-02f, -5.21274172e-02f, -3.42533365e-02f,
  1.06614418e-01f, 5.33284731e-02f, -1.11738198e-01f, -5.73052987e-02f, -7.12023973e-02f, -3.50502953e-02f, 2.83904094e-02f, 2.42931917e-02f, -2.64838308e-01f, -4.25033756e-02f,
  -3.56814086e-01f, -2.16851719e-02f, -1.61863621e-02f, -3.78712267e-02f, 6.58914447e-02f, -1.30791441e-01f, -9.62159038e-02f, -1.35255471e-01f, -2.40084171e-01f, -2.84662515e-01f,
  -6.40168637e-02f, -2.48708129e-01f, -1.74215838e-01f, -4.89180302e-03f, -4.16737087e-02f, -8.43180194e-02f, 1.05686620e-01f, 3.60147394e-02f, -5.73634729e-02f, -3.30449045e-02f,
  -9.91033614e-02f, 1.08766831e-01f, 1.31196395e-01f, -3.84575054e-02f, -1.27248496e-01f, 4.82535698e-02f, 7.59823844e-02f, -4.07191254e-02f, 1.27439618e-01f, -1.65597185e-01f,
  -1.24716416e-01f, -1.82263926e-01f, 1.42453387e-01f, -6.21618554e-02f, -2.23348096e-01f, 4.29306366e-03f, 3.66236359e-01f, 1.84489638e-01f, 1.74067155e-01f, 2.50342220e-01f,
  5.62626235e-02f, -6.31049648e-02f, 2.55591244e-01f, 1.56468362e-01f, -3.76003355e-01f, -2.00854927e-01f, 6.69322312e-02f, 6.24076501e-02f, 1.36266291e-01f, 5.07722676e-01f,
  2.39826545e-01f, -2.15586782e-01f, 1.05004556e-01f, 8.94198343e-02f, 2.83485085e-01f, -9.69495326e-02f, 1.75374746e-01f, 1.25075253e-02f, -3.38757366e-01f, 2.17256963e-01f,
  -6.74445853e-02f, 1.65911078e-01f, 4.01619673e-01f, 7.61238784e-02f, 4.94840592e-02f, -6.13653846e-02f, 2.46434323e-02f, 7.82557309e-01f, 1.09068111e-01f, -8.99874270e-02f,
  2.08060980e-01f, 1.31320670e-01f, -1.26030713e-01f, 1.00097738e-01f, 5.96653931e-02f, -6.89364150e-02f, -7.84213841e-02f, 7.29327742e-03f, 4.17037169e-03f, -1.21354900e-01f,
  3.27780306e-01f, -7.67971426e-02f, -4.94050831e-02f, 2.35684533e-02f, 3.01877372e-02f, 8.05649087e-02f, 1.62557676e-01f, 4.98667181e-01f, 1.29141837e-01f, -1.38205886e-01f,
  3.48866284e-01f, 1.30704910e-01f, -3.72481942e-02f, -2.39692792e-01f, 1.47683010e-01f, 1.44619420e-01f, 1.15875237e-01f, -5.16892634e-02f, 2.04953015e-01f, 1.67154372e-01f,
  -5.21872900e-02f, 5.38951419e-02f, 1.61306038e-01f, 7.63267800e-02f, 2.31854618e-01f, 1.77351478e-02f, 1.55997887e-01f, -8.01587626e-02f, -1.72826648e-01f, -1.18690014e-01f,
  8.13298225e-02f, -1.12089507e-01f, 6.92764446e-02f, 2.01980889e-01f, 4.99733984e-02f, -6.48499429e-02f, 4.23970520e-02f, 6.22692518e-02f, 1.29332274e-01f, 2.77285222e-02f,
  2.24773794e-01f, -4.17093247e-01f, 1.43900201e-01f, 1.25448674e-01f, 4.80413921e-02f, -4.62406389e-02f, -2.12629721e-01f, -4.92902160e-01f, 1.59134522e-01f, 2.10511148e-01f,
  4.88454476e-02f, -1.52899683e-01f, -1.32485598e-01f, -3.95573795e-01f, 9.97366458e-02f, -1.64069712e-01f, 1.88082587e-02f, -2.79660046e-01f, -6.20524399e-02f, 3.10691565e-01f,
  1.30061349e-02f, -4.67202589e-02f, 3.93244833e-01f, -8.72441102e-03f, 6.64942339e-02f, 1.89675726e-02f, 2.18675449e-01f, 1.11430302e-01f, -4.18230236e-01f, -3.75470072e-01f,
  -6.83089048e-02f, -1.00473590e-01f, 4.15371329e-01f, 1.96589023e-01f, 7.53159598e-02f, -1.81818753e-02f, -3.94810289e-01f, -1.16625063e-01f, 1.23317949e-01f, -6.23835735e-02f,
  9.81324464e-02f, 1.57257199e-01f, -4.99389887e-01f, 5.19873425e-02f, 2.38705292e-01f, -1.48185240e-02f, -3.04274678e-01f, 1.76056609e-01f, 1.56859607e-02f, 3.38239521e-01f,
  6.29986450e-02f, -1.01672672e-01f, -5.49101353e-01f, -4.86668870e-02f, -3.50072533e-01f, 4.15494770e-01f, 2.26825282e-01f, 4.69408602e-01f, -1.12596095e-01f, -3.83630157e-01f,
  -6.13145754e-02f, -1.37488112e-01f, 2.02818349e-01f, 1.50166243e-01f, 3.17238629e-01f, -1.36991367e-01f, -2.34376937e-01f, -5.79662272e-04f, -3.84806236e-03f, 2.13206515e-01f,
  1.14105538e-01f, -2.05754548e-01f, 2.18045160e-01f, -1.28993332e-01f, -1.68855965e-01f, 1.40986070e-01f, -1.67289943e-01f, 3.04213017e-01f, 2.15417221e-02f, 1.48318917e-01f,
  -4.16641384e-02f, 1.66686893e-01f, 2.42395297e-04f, 3.37719530e-01f, 3.61875743e-02f, -9.62048844e-02f, 4.13953178e-02f, -7.51800612e-02f, -3.38313170e-02f, -1.83299452e-01f,
  -9.28974599e-02f, -5.39319366e-02f, -8.36206228e-02f, -1.42898843e-01f, -7.99515098e-02f, 5.08210622e-02f, -1.32524688e-02f, 2.19302222e-01f, -2.19469726e-01f, -1.42622933e-01f,
  -6.65607825e-02f, 1.56364515e-01f, -1.11134477e-01f, 1.27521688e-02f, -1.09759988e-02f, 4.45756391e-02f, 9.15063769e-02f, 1.69179309e-02f, 1.10801712e-01f, 1.66819796e-01f,
  8.81135464e-02f, 1.53624341e-01f, -1.56832665e-01f, -1.84670854e-02f, 3.70046757e-02f, 4.64762837e-01f, 7.70778731e-02f, 5.05716205e-02f, 1.58352226e-01f, 1.39223665e-01f,
  -3.61585356e-02f, -1.79065689e-01f, 1.12296350e-01f, 8.59203786e-02f, 1.33573756e-01f, -1.60867851e-02f, -7.33943284e-02f, 1.29738092e-01f, 4.93758395e-02f, 1.92557693e-01f,
  -1.62368212e-02f, 3.10987253e-02f, 8.54426026e-02f, 4.18397337e-02f, 6.41372427e-02f, 1.66428626e-01f, -1.13394827e-01f, -1.23779856e-01f, -3.65067367e-03f, 8.59905109e-02f,
  -3.75257544e-02f, 1.55265272e-01f, -7.48100877e-02f, -2.44360581e-01f, -1.78114437e-02f, 1.72380254e-01f, 2.04015985e-01f, 3.44838500e-01f, 6.54252693e-02f, 5.00187576e-01f,
  3.63701880e-01f, 1.94023624e-02f, -2.61572123e-01f, 1.82606816e-01f, 1.06687292e-01f, 5.16937301e-02f, 2.39084810e-01f, 2.05178913e-02f, 1.19517095e-01f, -2.20648706e-01f,
  3.03923219e-01f, -1.03943527e-01f, -1.58847068e-02f, 2.34280884e-01f, 1.77331846e-02f, -1.39048621e-01f, -4.21090536e-02f, -5.50994053e-02f, 2.49263883e-01f, 4.06010181e-01f,
  1.73660576e-01f, -1.26378044e-01f, 3.23040694e-01f, -3.26440126e-01f, 1.43199470e-02f, 1.51668176e-01f, 3.37868303e-01f, 2.91656911e-01f, -3.53633165e-02f, 1.74551994e-01f,
  5.71230538e-02f, -2.88353622e-01f, -1.49372622e-01f, -1.92043353e-02f, -1.14076488e-01f, 4.08390304e-03f, 2.72057027e-01f, -3.67392927e-01f, -1.32750407e-01f, 2.17285961e-01f,
  -7.47635320e-04f, -1.40789911e-01f, 4.87430573e-01f, -1.41235655e-02f, -4.66007769e-01f, -3.66085768e-01f, -1.80849537e-01f, 1.48694471e-01f, -2.10838079e-01f, -8.70155077e-03f,
  1.04723044e-01f, 2.88199931e-02f, -1.46729112e-01f, -6.60715327e-02f, -5.03749475e-02f, -5.46707883e-02f, -1.50299100e-02f, -1.11985907e-01f, -1.87112708e-02f, -7.01203719e-02f,
  -1.76832259e-01f, -9.36192572e-02f, 9.70979594e-03f, -3.85010019e-02f, -1.10775437e-02f, -1.48359269e-01f, 3.15412739e-03f, -9.07192528e-02f, 6.56232238e-02f, 9.34684649e-02f,
  -9.76976529e-02f, 4.90477011e-02f, 7.15053529e-02f, 1.28142014e-02f, -1.70077980e-02f, -7.54694641e-02f, -7.12198466e-02f, 6.12141974e-02f, 6.58330321e-02f, 1.00977965e-01f,
  -6.22697957e-02f, -1.54990330e-01f, -1.49843454e-01f, -6.62221611e-02f, 1.00379825e-01f, -4.89599407e-02f, 1.57263815e-01f, -1.85154304e-02f, 9.80121344e-02f, 3.88453789e-02f,
  1.16891049e-01f, 8.90561193e-02f, -3.09533000e-01f, -1.66905299e-01f, -2.36874700e-01f, 9.93027687e-02f, 4.93877828e-02f, -2.14617863e-01f, -2.61294663e-01f, -5.17570637e-02f,
  -2.44796928e-02f, 7.22986683e-02f, -2.04503536e-01f, 1.53556541e-01f, 2.48292871e-02f, 6.24030270e-02f, -1.25889033e-01f, -1.78798825e-01f, -1.19744748e-01f, 1.20415300e-01f,
  -4.72825676e-01f, 1.19628988e-01f, 1.39171243e-01f, 2.12526396e-02f, 4.44704778e-02f, 8.87332931e-02f, 2.79144645e-02f, 5.12344576e-02f, 7.51709566e-02f, -8.36563781e-02f,
  3.89699750e-02f, 1.31120533e-01f, 1.22736625e-01f, 1.57491177e-01f, 1.47600994e-01f, -1.51110396e-01f, -3.28466833e-01f, -2.65209705e-01f, -1.68244049e-01f, 1.40390307e-01f,
  9.41876397e-02f, -3.34444404e-01f, 5.22225559e-01f, -1.69507504e-01f, 2.93207020e-01f, -5.89783154e-02f, 5.42888232e-02f, -3.68010141e-02f, -2.04338536e-01f, -7.98217654e-02f,
  1.27062902e-01f, -1.95834652e-01f, -3.04894745e-01f, -2.52049506e-01f, 3.04850131e-01f, -2.69428790e-01f, 1.94448441e-01f, 4.73181233e-02f, 1.83266506e-01f, 2.23257661e-01f,
  -1.59668049e-03f, 1.08900204e-01f, 5.10814823e-02f, 2.02364206e-01f, -1.93727329e-01f, -2.41972148e-01f, 1.03791915e-01f, 1.68018013e-01f, 4.77354705e-01f, 3.02493215e-01f,
  -2.65382081e-01f, -6.93916976e-01f, -2.64424145e-01f, -1.92724720e-01f, 7.34931529e-02f, -3.68776433e-02f, -2.54509121e-01f, -2.15173364e-01f, -5.10850064e-02f, -1.50336951e-01f,
  1.85699970e-01f, -3.11713636e-01f, 2.42046744e-01f, 1.34117529e-01f, -1.18003689e-01f, -2.77468890e-01f, 4.78228182e-02f, 5.28289191e-02f, -2.97983307e-02f, 6.27176720e-04f,
  2.68261470e-02f, -4.29842055e-01f, 2.24343866e-01f, -8.14519823e-02f, -1.60448417e-01f, -5.88925853e-02f, 6.90005869e-02f, -6.39179870e-02f, -1.34426713e-01f, -1.60428986e-01f,
  -8.21568891e-02f, 1.75072357e-01f, -5.27193770e-02f, -8.72914791e-02f, 3.66227925e-01f, 1.09013908e-01f, -7.60733932e-02f, 6.33484423e-02f, 1.31652325e-01f, 2.28273243e-01f,
  2.35484585e-01f, 8.35680738e-02f, -2.44480390e-02f, 2.83740878e-01f, 1.63850486e-01f, 6.95504108e-03f, -7.17742071e-02f, 2.97974497e-01f, -4.30259034e-02f, -5.05234599e-02f,
  -6.79736137e-02f, 3.77612412e-02f, -1.42785996e-01f, 7.98946843e-02f, -1.18107954e-02f, -3.31454128e-01f, -1.51089773e-01f, -1.73631713e-01f, -5.78811280e-02f, 4.12472636e-02f,
  1.36047127e-02f, -7.91651085e-02f, 7.70675689e-02f, -3.00291240e-01f, 8.68363380e-02f, -2.41454199e-01f, 2.63969749e-02f, 1.72147378e-01f, 1.48250088e-02f, -6.93405941e-02f,
  1.15363859e-01f, 6.24742135e-02f, 9.21867937e-02f, -2.19834656e-01f, -1.65116817e-01f, 1.39554471e-01f, 8.64495561e-02f, -3.14947218e-02f, 3.55803698e-01f, -5.04556186e-02f,
  -1.85186137e-03f, 1.96095426e-02f, -1.49953887e-01f, -3.17280553e-02f, -2.73135083e-04f, 1.73754930e-01f, -1.85993940e-01f, 1.06712662e-01f, 3.12370379e-02f, -2.75487434e-02f,
  -1.45067081e-01f, 3.84105034e-02f, -1.31550450e-02f, 1.10258184e-01f, -6.38537705e-02f, -2.92623699e-01f, 9.90763530e-02f, -2.76640981e-01f, 1.06306598e-01f, -1.99942201e-01f,
  -4.59954411e-01f, 1.98303517e-02f, 1.48867995e-01f, 1.24713652e-01f, -6.18414059e-02f, -1.91945583e-01f, -2.56947726e-01f, -2.98447669e-01f, 1.24122486e-01f, -1.14337243e-02f,
  3.35280657e-01f, -5.16165160e-02f, 4.74793911e-01f, -8.82566199e-02f, 2.37568453e-01f, 1.64939672e-01f, 4.14367318e-01f, -2.46009268e-02f, -1.79186225e-01f, 2.24709421e-01f,
  1.34961471e-01f, 9.26937610e-02f, 1.03213809e-01f, -1.24916174e-01f, -4.25359815e-01f, 2.95746505e-01f, 2.19167992e-02f, 3.52152616e-01f, 3.45514446e-01f, 8.06044042e-02f,
  -1.11206155e-02f, -2.04019129e-01f, 4.96263467e-02f, -1.72124624e-01f, 3.27509791e-01f, -2.73908615e-01f, -1.69082344e-01f, -2.68772006e-01f, -1.26541957e-01f, 2.03478113e-01f,
  2.33248830e-01f, 2.62286037e-01f, -2.68552542e-01f, 6.01516478e-02f, 5.35705825e-04f, 8.64185691e-02f, 7.29550933e-03f, -2.72644181e-02f, -7.72408620e-02f, 5.08723296e-02f,
  3.97751123e-01f, -3.15497443e-02f, -5.13708368e-02f, -6.91794753e-02f, 7.64000192e-02f, -1.23655349e-02f, 4.19678502e-02f, 5.64019829e-02f, -8.47375169e-02f, 1.29452646e-01f,
  -2.04512868e-02f, 1.54305294e-01f, -3.18686932e-01f, 4.30354550e-02f, 3.95656265e-02f, -6.38105208e-03f, 8.85968655e-02f, 3.92339826e-01f, 6.34253025e-02f, 8.65108743e-02f,
  9.53769311e-02f, 7.68546835e-02f, 2.09295318e-01f, 8.85922834e-02f, 1.26804747e-02f, -2.87059695e-01f, 6.22119717e-02f, 1.46449301e-02f, 1.79746211e-01f, -6.71034586e-03f,
  3.21545601e-02f, -1.46831021e-01f, -2.39405587e-01f, 8.85075182e-02f, 1.84609860e-01f, 1.49447203e-01f, -2.73276363e-02f, -5.70386462e-03f, -1.64186619e-02f, 6.51124492e-02f,
  -9.43956822e-02f, 1.48288190e-01f, 6.23290688e-02f, 2.08328456e-01f, -2.08465122e-02f, 3.18235122e-02f, -1.90658331e-01f, 7.69285336e-02f, 5.71677685e-02f, 8.50206688e-02f,
  -8.48692562e-03f, 4.23430689e-02f, 2.07219154e-01f, -7.01721106e-03f, 1.96514726e-01f, 1.31785631e-01f, 3.64358425e-02f, 8.00371841e-02f, 3.98041040e-01f, -2.57670153e-02f,
  2.54730344e-01f, -2.83533543e-01f, 1.01504795e-01f, 7.86459520e-02f, 1.10375240e-01f, 2.52965569e-01f, 3.39803621e-02f, 1.77072197e-01f, 5.18904366e-02f, 4.80376370e-02f,
  1.90309852e-01f, -5.98325491e-01f, -1.70358703e-01f, -1.82840675e-01f, -1.52840585e-01f, 5.63623533e-02f, 3.38071287e-01f, -3.82774509e-02f, -1.22829624e-01f, -1.63459748e-01f,
  -3.46257448e-01f, -2.42545336e-01f, -2.00009048e-01f, -3.31504613e-01f, -2.26230755e-01f, -4.44762297e-02f, 5.88753372e-02f, -3.76300454e-01f, 2.85948366e-01f, 2.10807994e-01f,
  3.53667408e-01f, -2.15960801e-01f, -1.80949837e-01f, -4.38997567e-01f, -3.36302459e-01f, -1.24083075e-03f, -4.11405176e-01f, 1.16815902e-01f, 1.28112599e-01f, -2.68787444e-01f,
  -8.68117511e-02f, -8.25090483e-02f, 1.90094799e-01f, -9.20242071e-02f, -5.75412154e-01f, -4.48402688e-02f, 1.70864180e-01f, 5.04972160e-01f, 3.04481238e-01f, 1.20457821e-01f,
  1.60268456e-01f, 1.80330068e-01f, 4.39060777e-01f, 3.59384306e-02f, 2.84933448e-01f, 3.67590524e-02f, -1.19859271e-01f, -1.63952962e-01f, 1.39158785e-01f, 1.77855715e-01f,
  3.09972409e-02f, 1.22440837e-01f, 6.87208176e-02f, 9.30965170e-02f, -1.10580966e-01f, -9.64893550e-02f, -7.09038898e-02f, 1.62385657e-01f, -7.04266950e-02f, 2.00687468e-01f,
  7.74958655e-02f, 2.26922724e-02f, -1.84419557e-01f, -1.57848492e-01f, 1.32570520e-01f, 9.99333058e-03f, 2.63485499e-02f, -5.48744202e-02f, 6.80933967e-02f, 2.34338462e-01f,
  -4.31362865e-03f, 1.46235481e-01f, 1.25229955e-01f, -3.05170263e-03f, -1.81543790e-02f, -1.89076081e-01f, -1.14253543e-01f, -1.96340710e-01f, -1.12746321e-02f, -4.17215019e-01f,
  -3.59797597e-01f, 6.57427981e-02f, 1.27133414e-01f, 1.43280551e-01f, -3.60030234e-02f, -7.20827132e-02f, 7.70676658e-02f, -6.52238354e-02f, 1.00882359e-01f, -7.27959275e-02f,
  1.70253649e-01f, 9.74446684e-02f, 3.41302194e-02f, 8.79312083e-02f, 8.24842975e-02f, 7.95364976e-02f, -3.10067926e-02f, -4.40656126e-01f, 7.29544042e-03f, 2.27567524e-01f,
  9.09975842e-02f, 1.96421489e-01f, -1.43161044e-01f, 5.78297637e-02f, -8.69355276e-02f, -1.31256133e-01f, 2.57304013e-02f, -1.41497076e-01f, -6.88090548e-02f, -1.44926339e-01f,
  1.65266022e-01f, -1.14175417e-02f, 6.10611662e-02f, -1.17557377e-01f, -2.81547189e-01f, -6.05193377e-02f, -2.99905270e-01f, 3.25049400e-01f, 6.81259483e-02f, 9.24620107e-02f,
  9.62844715e-02f, 7.84553438e-02f, 4.55525443e-02f, -2.43262678e-01f, 6.93089589e-02f, 2.97454465e-02f, 2.41084937e-02f, 1.55055458e-02f, -4.88233082e-02f, 2.11159989e-01f,
  3.62600058e-01f, 3.94459814e-01f, 1.49401665e-01f, 2.18448251e-01f, -2.06233874e-01f, 1.24776298e-02f, -1.28391862e-01f, 3.43883969e-02f, 2.79241860e-01f, 4.20770533e-02f,
  -2.75616676e-01f, 4.51524854e-02f, 4.95015264e-01f, -1.88541383e-01f, 2.42750227e-01f, -4.64559793e-02f, 1.77741081e-01f, 2.41362005e-01f, -4.09516275e-01f, 2.85126269e-01f,
  -2.19788119e-01f, -2.07667053e-01f, -1.41643649e-02f, -2.77703375e-01f, 7.65244989e-03f, -1.38660446e-01f, -6.64508402e-01f, -3.53285849e-01f, 3.12704563e-01f, 3.32821548e-01f,
  -2.26905197e-01f, -1.82102427e-01f, -2.52616480e-02f, 1.18404537e-01f, 2.98403233e-01f, 4.28268343e-01f, -2.33940169e-01f, -3.06567699e-01f, -5.32235065e-03f, 2.29062662e-01f,
  1.65149853e-01f, 2.95533478e-01f, 6.17174841e-02f, -2.05954388e-01f, -4.35768276e-01f, 1.87047377e-01f, -8.10333416e-02f, 7.63719380e-02f, 1.15928054e-01f, -1.18640184e-01f,
  -9.69840661e-02f, -1.55483752e-01f, 1.25249282e-01f, -1.98027771e-02f, 1.35415316e-01f, -7.55193308e-02f, -1.13128014e-01f, 3.96917164e-02f, 1.27295153e-02f, -1.12665072e-01f,
  -1.77672908e-01f, -1.86815590e-01f, -3.36994343e-02f, -4.73734513e-02f, -4.42844555e-02f, -1.01488538e-01f, 1.74061544e-02f, -5.48788719e-03f, -7.38444775e-02f, -1.42880484e-01f,
  -1.58847541e-01f, -1.78502172e-01f, -8.51744264e-02f, -1.45193219e-01f, -2.27106869e-01f, -1.81103006e-01f, -1.15229450e-01f, 1.73645809e-01f, -6.02300167e-02f, -1.25878416e-02f,
  6.97716102e-02f, -2.37898827e-02f, 9.95206460e-02f, -2.42398791e-02f, 1.21793717e-04f, 4.31903303e-02f, -3.50148305e-02f, -1.17364436e-01f, 1.28774326e-02f, -1.25424966e-01f,
  2.19853241e-02f, -1.84873372e-01f, -1.52722150e-01f, 5.45992143e-02f, -5.03618233e-02f, 5.35739809e-02f, -1.03293903e-01f, -2.89326459e-01f, -2.51890033e-01f, -4.08904813e-02f,
  -7.36175403e-02f, 4.98937108e-02f, 1.07097819e-01f, -3.50379688e-03f, 1.15224667e-01f, -1.28457949e-01f, 1.30019449e-02f, -1.15444615e-01f, 7.42242560e-02f, -1.32244378e-01f,
  -2.73476899e-01f, 1.18605621e-01f, -6.64579347e-02f, -6.24898705e-04f, -1.58530906e-01f, -5.78634441e-02f, -5.50363697e-02f, -8.77854787e-03f, -2.60677665e-01f, -8.53432417e-02f,
  6.17858507e-02f, -1.10347375e-01f, -2.60735899e-02f, -7.89148211e-02f, -2.41982359e-02f, -8.49605724e-02f, -3.32737297e-01f, -3.81730467e-01f, -5.42365992e-03f, 9.71539095e-02f,
  -3.53473462e-02f, 1.21302582e-01f, -2.02547073e-01f, -4.96247821e-02f, 2.06745073e-01f, -1.80826008e-01f, 1.33016542e-01f, 7.52561819e-03f, 9.39624980e-02f, 2.03588918e-01f,
  -2.64679193e-01f, 8.25138316e-02f, -3.72527480e-01f, 2.46018410e-01f, -4.45990376e-02f, -1.16267152e-01f, -4.04604636e-02f, 1.69140428e-01f, -2.05711871e-01f, -2.18780264e-01f,
  2.97852725e-01f, 2.53961772e-01f, -2.32376888e-01f, -1.02740854e-01f, 2.13678539e-01f, 1.40094385e-01f, -2.86740243e-01f, -2.14777634e-01f, 4.53260928e-01f, 1.99251086e-01f,
  3.29868525e-01f, -3.49290371e-01f, -2.75098234e-02f, -2.99605489e-01f, -2.46509328e-01f, -1.65121809e-01f, -2.81610578e-01f, 1.43226638e-01f, -3.94542143e-02f, 3.49557996e-01f,
  -3.40344846e-01f, 9.50067267e-02f, -2.54683077e-01f, -8.83046165e-02f, 2.59486079e-01f, 2.20023040e-02f, 2.32130468e-01f, -2.58244067e-01f, -9.08756629e-02f, 1.57605067e-01f,
  -6.21014610e-02f, 1.94395185e-01f, -1.65701449e-01f, -1.73155740e-01f, -2.83273719e-02f, 4.23034966e-01f, -7.67823383e-02f, 1.08595446e-01f, 2.89662573e-02f, -3.60446237e-02f,
  4.68826573e-03f, -2.12570862e-03f, 2.72083301e-02f, 1.69157475e-01f, 6.41289493e-03f, -1.51691437e-01f, 4.19223756e-02f, 8.75041783e-02f, -1.17242880e-01f, 1.67302117e-01f,
  2.56109834e-02f, -1.47222772e-01f, -1.16747260e-01f, -8.88519585e-02f, 2.74955481e-02f, 1.80430487e-01f, 1.10738106e-01f, -1.74856081e-03f, -4.43535224e-02f, 2.18802541e-01f,
  1.65568218e-02f, 4.76365983e-02f, -2.66359717e-01f, -2.31365845e-01f, -6.03257641e-02f, -1.45752747e-02f, -7.56082544e-03f, -7.82701373e-02f, -3.17908794e-01f, -2.19360411e-01f,
  3.50775011e-02f, 5.24444655e-02f, -1.79267541e-01f, 1.95504695e-01f, 6.34468943e-02f, -8.47036317e-02f, -1.52025349e-03f, -2.75852531e-01f, 1.51180848e-01f, 5.42036481e-02f,
  1.47197962e-01f, 7.96729028e-02f, -4.64808941e-02f, -6.52286336e-02f, 1.90900285e-02f, -1.67053759e-01f, -1.68142289e-01f, 1.51450843e-01f, 6.19670562e-03f, -7.46883405e-03f,
  1.60207808e-01f, 1.27851963e-01f, -4.89313193e-02f, 1.26584426e-01f, -1.29682094e-01f, 7.48798400e-02f, -3.62369567e-02f, -3.63902226e-02f, -9.92680043e-02f, 1.54463470e-01f,
  8.26751664e-02f, 1.43163577e-01f, 1.15247943e-01f, 2.27216855e-02f, 9.81420130e-02f, 1.71185419e-01f, -6.15842007e-02f, 1.05052456e-01f, -1.38479128e-01f, 3.27247560e-01f,
  1.12600803e-01f, 2.35774249e-01f, -2.12456081e-02f, 4.68652666e-01f, -3.38616431e-01f, -3.08923841e-01f, -4.37428243e-02f, 1.83362022e-01f, 2.08813563e-01f, 2.97663689e-01f,
  -4.81154919e-01f, 1.20186852e-02f, 2.20143087e-02f, 3.47991765e-01f, -2.44416460e-01f, 6.24351054e-02f, -4.55110252e-01f, 1.86926916e-01f, -3.87672096e-01f, -1.28442824e-01f,
  -1.72964688e-02f, -8.80781934e-02f, 1.83913052e-01f, -3.41875702e-01f, -3.52767736e-01f, 1.76856831e-01f, 2.89167255e-01f, -3.37338567e-01f, 2.56013453e-01f, -5.62692285e-02f,
  -1.22742005e-01f, -1.91828042e-01f, 1.23803340e-01f, 2.03297108e-01f, -1.15949385e-01f, 2.49449953e-01f, -2.61889368e-01f, 1.21048555e-01f, 1.44910440e-01f, 2.75894761e-01f,
  1.14405215e-01f, 7.31592625e-02f, 6.03180379e-02f, -7.54514337e-02f, -4.26919274e-02f, -5.57850637e-02f, -1.84436098e-01f, -7.30592310e-02f, -2.95256168e-01f, -1.07488744e-01f,
  5.08264601e-02f, -1.97783485e-01f, -1.07699288e-02f, -1.43957943e-01f, 3.82307172e-01f, -6.58498853e-02f, 1.20493308e-01f, 1.04278363e-01f, 1.82725012e-01f, 9.36772525e-02f,
  -5.39177172e-02f, 2.00696588e-02f, 5.52506074e-02f, 4.73153666e-02f, 3.86801176e-02f, 1.65035352e-02f, 7.03624124e-03f, -7.33783022e-02f, -7.41890222e-02f, -1.53285205e-01f,
  -7.39186853e-02f, -3.48685086e-02f, -1.79817318e-03f, -1.27607863e-02f, -6.13445183e-03f, 6.40316680e-02f, -6.14985600e-02f, -9.60964113e-02f, -6.31500110e-02f, -6.52268454e-02f,
  -6.51601627e-02f, 1.73472896e-01f, -1.12209745e-01f, 1.12287574e-01f, 9.57433041e-03f, -6.55891327e-03f, -4.49545756e-02f, 3.86983007e-02f, -1.85460135e-01f, -1.62442446e-01f,
  8.65020081e-02f, 1.02339633e-01f, -3.17061692e-01f, 2.03842372e-01f, -1.87813446e-01f, -6.87909052e-02f, 7.41397664e-02f, 1.41914606e-01f, 8.79334733e-02f, 4.80171712e-03f,
  -1.48435244e-02f, 1.17730610e-01f, 1.36743143e-01f, 4.00418043e-02f, -1.99244861e-02f, 1.78195089e-01f, 5.13585936e-03f, 2.19095927e-02f, -1.72819331e-01f, 8.09099227e-02f,
  1.69657707e-01f, 1.19104579e-01f, 1.26757905e-01f, -5.62186614e-02f, 1.26512796e-01f, -1.30575567e-01f, -6.54033646e-02f, 1.00539796e-01f, -1.67673901e-01f, 1.36472344e-01f,
  -8.86157751e-02f, 7.55727515e-02f, 6.57892600e-02f, -9.15981233e-02f, 1.71429425e-01f, 1.51888460e-01f, -1.66046932e-01f, -2.89529800e-01f, -2.33923748e-01f, 1.83502376e-01f,
  -3.62747550e-01f, -2.51019001e-01f, -1.89934969e-01f, 5.14971793e-01f, 1.81520000e-01f, 2.69330531e-01f, -4.11556065e-01f, -3.74518365e-01f, 2.47931302e-01f, 3.81931394e-01f,
  3.20697784e-01f, 7.23451301e-02f, -2.52837658e-01f, 4.53884542e-01f, 1.29163384e-01f, -3.98873389e-01f, 3.04107010e-01f, -1.72311574e-01f, -8.92705023e-02f, -6.34760857e-02f,
  2.27674708e-01f, 2.19965465e-02f, 2.24444613e-01f, 3.48998681e-02f, -2.13145629e-01f, 3.45575452e-01f, 2.86086202e-02f, -2.55778998e-01f, 9.81631503e-02f, 4.70349073e-01f,
  3.69142234e-01f, -2.68266857e-01f, 1.70202425e-03f, -3.07510555e-01f, -1.65085316e-01f, -1.69871554e-01f, -3.39412063e-01f, 3.54946516e-02f, -4.37285691e-01f, 5.22806704e-01f,
  2.40832224e-01f, 5.75857013e-02f, 1.62407398e-01f, -1.55830830e-01f, 2.56744698e-02f, 2.47700214e-02f, 6.15815446e-02f, -1.39863074e-01f, 2.10581720e-03f, 3.40005532e-02f,
  7.46665522e-02f, -2.27369562e-01f, -2.00930849e-01f, 9.72792432e-02f, 4.28239889e-02f, 6.04774803e-02f, -1.27145320e-01f, -6.15077838e-02f, 1.18562225e-02f, -1.04861610e-01f,
  -1.30868182e-01f, -2.91344244e-02f, -1.59784749e-01f, 8.58606249e-02f, -7.69154401e-03f, 1.87408086e-02f, -1.34173110e-01f, -1.08957201e-01f, -1.25074714e-01f, 6.99448213e-02f,
  -1.41508162e-01f, -4.40973230e-03f, -7.72221386e-02f, 1.66322440e-02f, 2.00809073e-02f, -1.17995813e-01f, -1.26924708e-01f, -1.94876827e-02f, 1.32946640e-01f, 4.49526720e-02f,
  -1.55112699e-01f, 3.38411219e-02f, 1.11663967e-01f, 2.10850775e-01f, 7.91752189e-02f, 1.43190306e-02f, -9.34243295e-03f, 1.05196185e-01f, 1.63237497e-01f, 3.51290852e-02f,
  1.26756430e-01f, -3.82968225e-02f, 5.32308258e-02f, 2.38227531e-01f, 3.90930474e-03f, -1.19738631e-01f, 2.72269454e-02f, 8.50934982e-02f, -1.00084558e-01f, -2.42439538e-01f,
  -5.62423915e-02f, 9.13838670e-02f, 1.60417613e-02f, -3.83486263e-02f, -2.63648659e-01f, -8.25810432e-03f, -4.34366288e-03f, -2.11079374e-01f, 2.74919104e-02f, 1.48961529e-01f,
  6.05082288e-02f, 1.15018904e-01f, 1.11511193e-01f, -3.28264236e-02f, 9.26500466e-03f, 1.33962825e-01f, 2.34040394e-02f, -4.01182622e-02f, 7.13986829e-02f, -3.76280695e-02f,
  -8.06252211e-02f, 3.70635539e-01f, -1.18159994e-01f, -3.37206632e-01f, 3.93494032e-02f, -2.32733443e-01f, 2.51116514e-01f, -2.44951934e-01f, 2.43100852e-01f, 5.47005832e-02f,
  -3.96128418e-03f, 3.98625165e-01f, -1.97128236e-01f, 8.14315304e-02f, -1.17171951e-01f, -1.63965467e-02f, -2.96192497e-01f, 1.42793089e-01f, 1.46981422e-02f, 3.90692651e-02f,
  2.01028645e-01f, 1.89154327e-01f, 3.40178818e-01f, 1.82809383e-01f, 4.88447323e-02f, -4.89263125e-02f, -2.76232392e-01f, -1.80236567e-02f, -7.86541328e-02f, 2.90027440e-01f,
  -4.61672604e-01f, -2.47736216e-01f, -5.16816825e-02f, -3.09090376e-01f, -2.64808267e-01f, 3.91278505e-01f, -2.16759473e-01f, -3.75881374e-01f, 3.37160319e-01f, 1.80226833e-01f,
  -4.49013151e-02f, 1.73884079e-01f, 5.60790673e-02f, 4.07132991e-02f, -9.94302109e-02f, 6.38949871e-02f, 6.49850592e-02f, 1.23755082e-01f, 1.66515455e-01f, -3.11482310e-01f,
  -7.20321313e-02f, 3.01453173e-01f, -6.43394366e-02f, 3.50753106e-02f, -2.27861151e-01f, 2.42691547e-01f, 2.71502044e-02f, -1.88850015e-01f, -1.95238724e-01f, -9.17838365e-02f,
  -1.36074945e-01f, -9.21395570e-02f, 2.85909208e-03f, 1.73068643e-01f, 7.96609372e-02f, -1.34940997e-01f, -1.58805162e-01f, -5.62899113e-02f, 1.95597142e-01f, 2.83360362e-01f,
  -5.93567789e-02f, 9.48023945e-02f, 2.50310987e-01f, 2.33401340e-02f, 1.31776169e-01f, -4.49368469e-02f, 1.78439766e-01f, -1.68365583e-01f, 1.21359251e-01f, -9.00102127e-03f,
  1.79942891e-01f, -2.06030086e-01f, 7.33848512e-02f, -1.90587252e-01f, 8.45929831e-02f, 4.46660332e-02f, 4.41859253e-02f, 1.35709986e-01f, -1.17190778e-01f, -6.09242730e-02f,
  3.69811021e-02f, 2.20680814e-02f, 2.44833753e-02f, 1.72445253e-02f, -5.40342778e-02f, -3.13283950e-02f, 1.76796854e-01f, -1.30663201e-01f, 1.49061576e-01f, -4.99852188e-02f,
  -9.81331803e-03f, 7.10406750e-02f, 6.79746941e-02f, 6.24005720e-02f, -1.64473131e-01f, 3.02347280e-02f, -9.99003742e-03f, 1.79073930e-01f, 1.98211428e-02f, 2.08411459e-02f,
  1.40054032e-01f, -1.15858220e-01f, 1.56431552e-02f, -1.53886646e-01f, 1.14297070e-01f, -1.48205891e-01f, -1.04819410e-01f, -3.57702821e-02f, -1.37860700e-01f, 1.37987249e-02f,
  1.57565892e-01f, 1.19124293e-01f, -4.99928482e-02f, -2.20387708e-02f, 3.39735039e-02f, 1.14858203e-01f, 7.49967899e-03f, 1.64821856e-02f, 3.17587219e-02f, -1.32887840e-01f,
  2.16249108e-01f, -3.62851232e-01f, -3.89271468e-01f, 1.15765937e-01f, -2.18791112e-01f, -7.50293806e-02f, -2.31827900e-01f, 1.44961461e-01f, 1.57168955e-01f, -3.50146890e-01f,
  2.89690159e-02f, 2.74592727e-01f, 3.85420710e-01f, 1.13190144e-01f, 1.53815746e-01f, -4.85380411e-01f, -4.79291141e-01f, -4.62710820e-02f, -2.69432664e-01f, -3.29984993e-01f,
  -1.18569925e-01f, 1.01423658e-01f, 1.20783567e-01f, -8.26258864e-03f, 1.80523366e-01f, -2.87251770e-01f, -2.16382183e-02f, -2.32310951e-01f, 1.18301615e-01f, -1.55158415e-01f,
  -2.77754933e-01f, -5.23470938e-02f, 4.27716821e-01f, 3.40921462e-01f, 3.25669050e-01f, -3.34480405e-01f, -4.54519749e-01f, -3.62769067e-01f, -2.95135826e-01f, 3.17075759e-01f,
  8.87911618e-02f, -3.54441524e-01f, -9.80656594e-03f, 2.20408306e-01f, -1.33089155e-01f, -2.39526346e-01f, -1.03531023e-02f, 5.23333289e-02f, 2.51248479e-01f, -2.28425473e-01f,
  -7.40346834e-02f, -8.10252875e-02f, -3.65516953e-02f, -1.69942126e-01f, 2.80251056e-01f, -1.78515688e-02f, 1.75042115e-02f, -5.12136556e-02f, -8.22715312e-02f, -1.15645133e-01f,
  -5.58704184e-03f, -1.33031741e-01f, 1.21892698e-01f, 2.14752197e-01f, -1.24423681e-02f, -1.06017135e-01f, 2.70810537e-02f, -8.34586620e-02f, -7.37478957e-02f, 5.89712113e-02f,
  -1.38649046e-01f, 1.84980351e-02f, 1.02381982e-01f, 9.14876461e-02f, -9.09611881e-02f, -4.52761054e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.39317569e-02f, 4.13968228e-02f, 3.99549678e-02f, -3.39700771e-03f, 6.61007836e-02f, 4.77536693e-02f, -1.20579571e-01f, 7.36506581e-02f, 3.25099416e-02f, 9.98748690e-02f,
  -6.18636720e-02f, 1.24962861e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    