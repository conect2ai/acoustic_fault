/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.71173707e-01f, -3.08970988e-01f, -3.61242384e-01f, -3.10188949e-01f, -3.29131857e-02f, -2.89316773e-02f, -2.11548805e-01f, -1.51251405e-01f, -1.40752578e-02f, -7.29699880e-02f,
  4.36847955e-02f, 4.05188017e-02f, -2.50956953e-01f, -1.71375245e-01f, -4.93728220e-01f, -5.18350184e-01f, -4.39351827e-01f, -4.37891781e-01f, -2.94336528e-01f, -2.40345150e-02f,
  -4.08883654e-02f, -1.19452000e-01f, -2.34526917e-01f, -1.55699164e-01f, -1.38282523e-01f, -6.91875396e-03f, -1.11371443e-01f, -7.39308372e-02f, 1.60907477e-01f, -8.60808790e-02f,
  -3.29914957e-01f, -1.91127107e-01f, -4.11828235e-03f, -1.12667590e-01f, -9.86104906e-02f, -1.12535581e-01f, -1.48410067e-01f, -5.95369041e-02f, 2.68405620e-02f, -2.08954796e-01f,
  -2.07394898e-01f, -1.69036850e-01f, -5.63881211e-02f, -1.69735521e-01f, -1.51598036e-01f, -2.37882927e-01f, -2.34767124e-01f, -3.11848819e-01f, -3.05666268e-01f, -1.00694619e-01f,
  -3.26033197e-02f, 7.12370500e-02f, -1.29590288e-01f, -1.09523721e-01f, -2.26166323e-01f, -1.03577726e-01f, -1.68732759e-02f, -1.32174864e-01f, -1.46866024e-01f, -8.86954814e-02f,
  -4.85397689e-02f, 7.78470561e-02f, 4.67780493e-02f, 3.72722596e-02f, 1.02586681e-02f, 1.29042953e-01f, -8.71831700e-02f, -9.55595262e-03f, 7.53997192e-02f, 8.54770020e-02f,
  1.13901449e-02f, 1.19748071e-01f, -1.15976119e-02f, 5.97231984e-02f, 7.15082213e-02f, 3.38304564e-02f, 1.48390263e-01f, 2.97350716e-03f, 1.49862617e-01f, 1.59413263e-01f,
  6.82079941e-02f, 6.36708736e-02f, 1.10595539e-01f, 8.59533176e-02f, 8.61598104e-02f, 8.50401074e-02f, -3.03125121e-02f, 2.35049024e-01f, 2.24031787e-02f, 1.03940770e-01f,
  -5.20421006e-02f, -4.89661247e-02f, -4.42846268e-02f, -1.98436722e-01f, -3.21343653e-02f, -2.30960846e-02f, 6.59403726e-02f, 4.46030051e-02f, 5.22906482e-02f, -8.59793723e-02f,
  -4.39583547e-02f, -2.02268958e-02f, 1.68909337e-02f, -1.65714864e-02f, -6.93136901e-02f, -6.64224699e-02f, 1.71859004e-02f, -6.79023042e-02f, -5.08721024e-02f, -7.49122873e-02f,
  -1.32385250e-02f, -4.46749711e-03f, 8.40482563e-02f, 1.27386823e-01f, -1.20192049e-02f, 7.96755180e-02f, 1.35514757e-03f, -2.03227215e-02f, -7.76272267e-02f, -1.17976896e-01f,
  9.55948591e-01f, -3.10603052e-01f, -6.71603531e-02f, 1.22021042e-01f, -2.77697772e-01f, 1.74296647e-02f, -6.75294772e-02f, -4.43827920e-03f, 1.53172061e-01f, -2.02972561e-01f,
  7.81812053e-03f, 1.01519145e-01f, 9.36230049e-02f, 1.23887658e-01f, 2.48915851e-01f, -2.47364849e-01f, -3.25276822e-01f, 9.09650624e-02f, 3.76551837e-01f, 1.98162124e-01f,
  -6.96472675e-02f, -8.66336077e-02f, 2.66090661e-01f, 6.17069900e-02f, -1.58651412e-01f, 5.85057959e-03f, -1.37259156e-01f, -9.58203748e-02f, -2.09349528e-01f, -4.84029949e-01f,
  6.89337635e-03f, 1.68959284e-03f, 1.14189334e-01f, -6.63451198e-03f, -4.39776219e-02f, 1.15282841e-01f, 9.68435779e-02f, 8.09126347e-02f, 1.03626363e-02f, -9.78529733e-03f,
  -1.36841416e-01f, -1.62728096e-03f, 6.95008831e-03f, -2.23044585e-02f, -1.63415633e-02f, 4.06066363e-04f, -2.31355638e-03f, 1.03270724e-01f, 8.57961178e-02f, -4.95695882e-02f,
  -9.64295119e-02f, -1.94719329e-01f, -4.38910089e-02f, 1.38641736e-02f, 1.52018771e-01f, 9.50535201e-03f, -5.49042150e-02f, -5.33378683e-02f, 9.42276195e-02f, -7.80516816e-03f,
  5.71075454e-02f, 2.75694486e-02f, -6.14923351e-02f, -4.08120900e-02f, -2.18379050e-02f, 5.14718611e-03f, -4.79834788e-02f, 2.11401489e-02f, 3.37214507e-02f, -6.41674176e-02f,
  -4.21104282e-02f, -1.38140172e-01f, 4.94273454e-02f, 3.67525704e-02f, -2.07720064e-02f, -7.83995613e-02f, -4.97088395e-02f, 3.81996520e-02f, 3.05112656e-02f, -5.79855330e-02f,
  -1.21125029e-02f, -2.32362095e-02f, -4.24814261e-02f, -7.72711262e-02f, -1.02876909e-01f, 5.39418962e-03f, -4.02552895e-02f, -3.77296135e-02f, -4.86409292e-02f, -1.02662601e-01f,
  1.48419619e-01f, 4.23861817e-02f, 7.43493140e-02f, 7.11126998e-02f, 7.05476105e-02f, -3.47901089e-03f, 7.11835921e-02f, 4.04232852e-02f, -5.67533411e-02f, 1.54301599e-02f,
  6.70754835e-02f, 9.35889855e-02f, 6.65895641e-02f, -3.11043635e-02f, 5.29797561e-02f, -3.19150575e-02f, 1.41278503e-03f, -5.67286275e-02f, -7.41890296e-02f, -2.09150761e-02f,
  -7.26038171e-03f, 3.00880186e-02f, 8.99492949e-02f, 3.34608294e-02f, 3.79563719e-02f, 6.00885041e-02f, 3.64065394e-02f, 3.89859155e-02f, 1.73382521e-01f, 1.48285881e-01f,
  5.48516691e-01f, 1.57738328e-01f, -3.00101787e-01f, 4.91136938e-01f, 1.42254427e-01f, -1.32589459e-01f, -1.97932273e-01f, 3.79959531e-02f, 2.88213849e-01f, 1.76619470e-01f,
  -4.98843007e-02f, 5.07975519e-02f, -3.07662655e-02f, -7.43768960e-02f, -2.91065961e-01f, -3.06008290e-02f, 9.33742449e-02f, -6.37289733e-02f, -2.05641523e-01f, 6.31764382e-02f,
  2.71091938e-01f, 2.92552054e-01f, 1.04844272e-01f, 2.77052764e-02f, 1.93757713e-01f, -6.44558966e-02f, -1.91770315e-01f, -1.41878277e-01f, -1.85968280e-01f, 1.45684958e-01f,
  -1.90404877e-01f, 9.36911702e-02f, -1.05237454e-01f, 5.58808818e-02f, 1.52849313e-02f, -6.77240193e-02f, -3.19301337e-02f, -9.19258967e-03f, -4.13959939e-03f, 3.86613011e-02f,
  4.76568602e-02f, -3.59854288e-02f, 8.92733485e-02f, 9.07651708e-02f, 4.67511900e-02f, 6.21295534e-02f, 3.57304700e-02f, -2.15216912e-02f, -5.79558499e-02f, 1.69103295e-02f,
  2.03731488e-02f, 5.01110554e-02f, 2.69398140e-03f, -6.27172366e-02f, -8.92102495e-02f, -2.44992413e-02f, -8.70888233e-02f, -2.35230885e-02f, -8.07652771e-02f, 1.05664119e-01f,
  -4.31222934e-03f, -1.19915567e-01f, -8.26217011e-02f, 7.60967880e-02f, 4.83112894e-02f, -7.98356235e-02f, 1.28219416e-02f, -1.17088240e-02f, 6.38678446e-02f, -4.14981917e-02f,
  1.93319637e-02f, 6.21708259e-02f, 9.17837694e-02f, 5.78698143e-02f, -6.72172429e-03f, 3.16200592e-02f, -1.11881737e-02f, 7.27727916e-03f, 5.84260486e-02f, -7.61274423e-04f,
  9.90297496e-02f, 7.13553280e-03f, 4.46789376e-02f, 3.70201515e-03f, -3.90437506e-02f, -8.18994269e-02f, -2.24486515e-02f, -9.64697376e-02f, -1.35121783e-02f, 7.58837909e-02f,
  9.17273238e-02f, -1.56466469e-01f, 1.47677168e-01f, 8.91301706e-02f, 7.56640136e-02f, -5.33773415e-02f, 1.50349652e-02f, -1.71951856e-02f, 6.25014156e-02f, 3.47629264e-02f,
  -2.72003710e-02f, -7.76855126e-02f, -2.33486872e-02f, -7.34630898e-02f, 1.74528640e-02f, 6.44742250e-02f, -3.85085978e-02f, 8.87027830e-02f, -8.18574522e-03f, 1.06120994e-02f,
  1.33885657e-02f, 1.08812220e-01f, 3.67711671e-02f, 1.16290256e-01f, 6.40975013e-02f, 3.11818905e-02f, -1.72212228e-01f, -6.94994107e-02f, -1.09143622e-01f, 1.54506370e-01f,
  -7.35587060e-01f, 4.22192097e-01f, 2.58024067e-01f, -1.11138128e-01f, 4.15158331e-01f, 4.27350730e-01f, 7.16724277e-01f, 4.29139771e-02f, -2.13108703e-01f, 2.52769232e-01f,
  5.44206500e-02f, -1.81808531e-01f, -3.63259912e-02f, -5.05434014e-02f, -9.46296677e-02f, 2.75898308e-01f, 1.53437778e-01f, -2.24718764e-01f, -1.30366653e-01f, 8.64999369e-02f,
  2.16279984e-01f, -4.27391231e-02f, -3.02778870e-01f, -1.56390458e-01f, 6.62137493e-02f, -3.54825296e-02f, 1.84629753e-01f, 5.49194729e-03f, 1.45534605e-01f, -1.26640433e-02f,
  -1.12895660e-01f, -9.72610191e-02f, 1.00839362e-01f, -5.12912385e-02f, 6.72463775e-02f, -2.91123707e-02f, 7.73352981e-02f, -4.31652814e-02f, 8.09367970e-02f, 3.84410843e-02f,
  -1.58608682e-03f, -8.99094436e-03f, 2.03147111e-03f, 6.43455461e-02f, 6.44979300e-03f, 1.27073219e-02f, -3.93549353e-02f, -1.19008206e-01f, 6.84492290e-02f, 7.11228773e-02f,
  2.12542713e-01f, 8.19485113e-02f, 1.00319900e-01f, 1.78363055e-01f, -1.60566010e-02f, -1.37668848e-01f, 5.02300225e-02f, -1.07285753e-01f, -4.66216467e-02f, -7.10372627e-02f,
  -4.07966636e-02f, -2.64587123e-02f, 3.44717875e-02f, -5.56207746e-02f, -2.43842117e-02f, -5.26281148e-02f, -8.67519751e-02f, 3.94539088e-02f, -3.24098170e-02f, -6.17070310e-02f,
  -1.90866478e-02f, -6.64469525e-02f, -9.10491496e-03f, 6.77197799e-02f, 2.97947861e-02f, 2.69997050e-03f, -1.62318218e-02f, 2.27135960e-02f, -9.17935669e-02f, -2.79525556e-02f,
  -3.56522650e-02f, -1.34482354e-01f, -4.16741446e-02f, -1.11452103e-01f, -5.47093228e-02f, -1.19036280e-01f, -4.82171774e-02f, -1.80899799e-02f, 8.39430559e-03f, -6.68027848e-02f,
  5.21993358e-03f, 1.11573577e-01f, -8.20600369e-04f, -8.08302034e-03f, 5.82008772e-02f, 3.22481804e-02f, 6.33662865e-02f, 4.68468629e-02f, -5.91818523e-03f, 3.71738225e-02f,
  -1.88976284e-02f, -1.04902433e-02f, 8.95689949e-02f, -1.76736433e-03f, 6.28573494e-03f, 3.36870179e-03f, 1.05812086e-03f, 4.55134287e-02f, 3.57599035e-02f, 1.47534127e-03f,
  9.64978114e-02f, 2.09652826e-01f, 8.58575180e-02f, 6.42913952e-02f, 8.95282701e-02f, 9.18965861e-02f, 1.97714046e-01f, 2.65607964e-02f, 1.83028296e-01f, 2.94635981e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.33043671e-01f, -5.88883698e-01f, -3.47646773e-02f, -1.69890121e-01f, -3.64485711e-01f, -2.18608111e-01f, -6.68537378e-01f, 3.23522538e-01f, 2.59630114e-01f, -6.72445536e-01f,
  -2.74168521e-01f, -5.51555976e-02f, -2.92645752e-01f, 4.42510210e-02f, 1.58158168e-01f, -5.50806761e-01f, -1.79016113e-01f, 2.46205226e-01f, 5.93668282e-01f, 3.02928418e-01f,
  -2.72472918e-01f, 1.80995524e-01f, 4.47045922e-01f, 5.18888354e-01f, -3.08014274e-01f, 5.59951253e-02f, -1.34856209e-01f, -4.20202464e-02f, -5.18637180e-01f, -8.83920312e-01f,
  -5.80051482e-01f, -1.67152122e-01f, 1.36196688e-01f, -2.21679315e-01f, -1.31678939e-01f, -1.13722607e-01f, 1.05934933e-01f, -5.40731736e-02f, -8.24358910e-02f, 1.24854155e-01f,
  -1.80260658e-01f, 2.34958515e-01f, -9.04010832e-02f, -3.73265110e-02f, -1.83194666e-03f, 1.14428131e-02f, 2.21653715e-01f, 1.86963111e-01f, 2.77013686e-02f, -4.60328497e-02f,
  -4.68537867e-01f, -2.25371212e-01f, -5.79109192e-02f, 1.47287801e-01f, 3.21821958e-01f, 2.06941247e-01f, 2.12148815e-01f, 2.56484151e-01f, 2.41013482e-01f, -3.78194630e-01f,
  4.29820176e-03f, 1.48328673e-02f, -8.15164447e-02f, 5.70131689e-02f, 1.70690864e-02f, -1.10240400e-01f, -2.25079916e-02f, -6.24519549e-02f, -4.34719101e-02f, -2.25661546e-02f,
  1.97677210e-01f, 1.31413378e-02f, 2.46387976e-03f, -8.69202465e-02f, -1.22905128e-01f, -5.58628701e-02f, -4.41192213e-04f, -4.94627841e-02f, 6.12454489e-02f, 3.07063647e-02f,
  -8.63911025e-03f, 5.60834557e-02f, 3.17987427e-02f, 2.13665858e-01f, -8.36656839e-02f, 3.96184586e-02f, -1.62044346e-01f, 8.91303346e-02f, 9.42358896e-02f, -2.53283054e-01f,
  -1.73205078e-01f, 2.82490551e-01f, -4.32551861e-01f, 9.01311170e-03f, -1.52982294e-03f, 3.53980139e-02f, -3.81124586e-01f, 1.06398210e-01f, 3.73067968e-02f, -1.30880818e-01f,
  -1.40218046e-02f, -6.82001635e-02f, -1.46407681e-02f, -1.53307185e-01f, 9.50330421e-02f, 6.96745440e-02f, -3.42740625e-01f, -1.63962349e-01f, 1.63434729e-01f, -8.54078010e-02f,
  1.05466068e-01f, -2.21342802e-01f, -2.17705697e-01f, -3.00382912e-01f, -2.12690324e-01f, -1.98491544e-01f, -6.59810752e-02f, -1.81845203e-01f, -9.40965787e-02f, -6.96402609e-01f,
  1.24235623e-01f, 1.97568864e-01f, 2.61369020e-01f, -4.69101518e-01f, 4.92772073e-01f, 6.45596206e-01f, 9.64019954e-01f, 1.58701330e-01f, -2.61207819e-01f, 4.85493839e-02f,
  5.01793146e-01f, -9.96223092e-02f, -1.00063406e-01f, 3.54705080e-02f, 3.30078155e-01f, 1.75799131e-01f, -2.68207133e-01f, 4.41729352e-02f, 2.26695433e-01f, 9.74675044e-02f,
  -2.60090441e-01f, -3.74274701e-01f, -2.16125533e-01f, -2.37049788e-01f, -5.99139333e-01f, -2.90028483e-01f, -1.03040792e-01f, -4.94849496e-03f, 3.93473446e-01f, -6.94124103e-01f,
  -3.13767418e-02f, 5.56305200e-02f, -3.15959938e-02f, 4.83987555e-02f, -1.17670046e-02f, -1.97898343e-01f, -1.24021314e-01f, -3.52679193e-01f, -2.73389742e-02f, -2.47196853e-01f,
  5.95175698e-02f, -5.42033799e-02f, -5.30475983e-03f, 1.80503353e-02f, 1.33516237e-01f, 5.35802469e-02f, -1.26328886e-01f, -1.73032984e-01f, -2.81961858e-02f, 8.13942254e-02f,
  -1.75148517e-01f, 2.66812205e-01f, 3.31065804e-01f, 1.13615163e-01f, 1.48199663e-01f, 9.05112624e-02f, 2.92509407e-01f, 4.93247760e-03f, 3.41400594e-01f, -5.34978271e-01f,
  1.18054701e-02f, -1.41560950e-03f, 1.68614805e-01f, -1.62110180e-01f, 4.80705239e-02f, -2.49222573e-02f, -4.69879108e-03f, 1.01302586e-01f, 1.10299699e-01f, -1.02903239e-01f,
  3.31927538e-02f, -1.67292613e-03f, -6.60807937e-02f, -6.32858649e-02f, -3.64231467e-02f, 6.65102974e-02f, 4.07106280e-02f, -5.01152538e-02f, 1.03234738e-01f, 4.10352051e-02f,
  2.44069733e-02f, 8.62208530e-02f, 6.97384309e-03f, -3.84504814e-03f, -2.63574477e-02f, 9.51076858e-03f, -1.29478574e-01f, 3.26045118e-02f, -1.17073536e-01f, -1.94087196e-02f,
  -4.20498520e-01f, 5.13040066e-01f, -2.77665824e-01f, 5.42461034e-03f, -3.27506997e-02f, -9.34706554e-02f, 3.91388237e-02f, -4.71434258e-02f, 4.41038124e-02f, -1.12051919e-01f,
  1.15947872e-01f, -4.11426648e-02f, 3.53079066e-02f, 4.28302996e-02f, -2.91381534e-02f, -8.23939145e-02f, 6.43614605e-02f, 9.79533717e-02f, 6.46762270e-03f, -9.29729417e-02f,
  -3.19644697e-02f, -1.18228607e-01f, -1.07937744e-02f, 4.70952466e-02f, -3.27835709e-01f, -7.03783929e-02f, -2.86206473e-02f, -1.99855596e-01f, 4.47615325e-01f, -3.83184016e-01f,
  7.82219648e-01f, 5.03516972e-01f, 5.88075936e-01f, 3.51607472e-01f, -4.33184905e-03f, 3.32079679e-01f, 7.41684079e-01f, 2.79618919e-01f, 9.41444188e-02f, -2.99228337e-02f,
  -3.63723665e-01f, -4.31845635e-01f, -1.20979875e-01f, -5.57845868e-02f, 3.36453170e-01f, 6.51791036e-01f, 4.71021414e-01f, 4.28982854e-01f, 6.15261979e-02f, 1.17127271e-02f,
  -9.14008096e-02f, -1.42256126e-01f, -9.00850296e-02f, 7.65717849e-02f, 5.34501337e-02f, -1.11460641e-01f, -2.25494686e-03f, 7.94440508e-03f, -9.46411118e-02f, 2.10617229e-01f,
  -7.29303211e-02f, 3.38594168e-01f, 5.99707849e-02f, -2.32653528e-01f, -2.09818065e-01f, 1.32190036e-02f, 4.60056476e-02f, -1.03273027e-01f, -2.08138615e-01f, 1.48225250e-02f,
  -1.56747863e-01f, -2.76975065e-01f, 2.73676049e-02f, -1.27063747e-02f, -7.88393468e-02f, 1.31218592e-02f, 8.48473758e-02f, 1.42151311e-01f, 1.18119538e-01f, 6.10648505e-02f,
  -7.48968311e-03f, -7.75556415e-02f, 4.00732718e-02f, 1.38217494e-01f, 2.84743428e-01f, 4.87088319e-03f, 3.09473276e-02f, 1.35730743e-01f, 1.01382241e-01f, 2.64997721e-01f,
  -1.52390644e-01f, 3.43960486e-02f, 2.41232198e-02f, 1.06872894e-01f, -4.85277101e-02f, -3.91866378e-02f, 1.08336255e-01f, 7.34416069e-03f, 1.29230395e-01f, -2.10314151e-02f,
  -4.47607264e-02f, 4.45972616e-03f, 6.16249163e-03f, 5.04242629e-02f, -1.33069560e-01f, 7.62272477e-02f, 1.66411012e-01f, -3.34703475e-02f, -1.34842545e-01f, -5.10232709e-02f,
  -4.82556485e-02f, 4.17398065e-02f, -8.91602039e-02f, 5.21225780e-02f, -4.06604595e-02f, 9.56755951e-02f, 2.63210088e-02f, -1.98839590e-01f, 4.26165713e-03f, 2.61059981e-02f,
  -3.29699427e-01f, -8.13934132e-02f, 7.93076828e-02f, 7.14655146e-02f, -8.50487873e-02f, -1.10973097e-01f, 3.40583026e-02f, -6.31630123e-02f, -1.61341667e-01f, 1.91890955e-01f,
  3.19019258e-02f, -7.57650360e-02f, -1.12096630e-02f, -2.10738066e-03f, -9.64464843e-02f, -1.38040334e-01f, -9.53984708e-02f, 1.25889838e-01f, 1.12162009e-02f, -5.36257029e-02f,
  -3.20355855e-02f, 6.95654005e-02f, -5.05559891e-02f, 1.59725145e-01f, 1.15786001e-01f, -1.48283660e-01f, -6.86828643e-02f, -3.21373995e-03f, -9.60066542e-03f, 5.70814796e-02f,
  1.27216804e+00f, -7.58915901e-01f, -7.72025764e-01f, 5.00484824e-01f, -1.00131109e-01f, 2.65257835e-01f, -5.20445518e-02f, 1.97133526e-01f, 3.65028113e-01f, -7.85853639e-02f,
  -1.94689378e-01f, 4.31646593e-02f, -4.14794423e-02f, -3.49035487e-02f, 3.49612683e-01f, -2.52703995e-01f, -2.23532185e-01f, -4.04679179e-02f, 4.57226932e-01f, 3.70711595e-01f,
  -1.07422188e-01f, 1.12179972e-01f, 3.86674613e-01f, 1.47218511e-01f, -2.59535521e-01f, 1.59726515e-01f, -4.62345749e-01f, -3.51446062e-01f, -2.62945592e-01f, -8.86601686e-01f,
  -3.57775718e-01f, -3.83803010e-01f, 1.52568566e-02f, 1.00528345e-01f, -3.53570342e-01f, 1.16479680e-01f, -9.74853113e-02f, -2.00920075e-01f, -1.21371169e-02f, -1.03479415e-01f,
  -7.17617050e-02f, -1.18827097e-01f, -1.54926911e-01f, -2.06336081e-01f, -1.44101396e-01f, 6.67314604e-02f, -1.74837798e-01f, -1.40872389e-01f, -1.72081083e-01f, -1.31329089e-01f,
  -2.96929598e-01f, -2.15548709e-01f, -2.69016325e-01f, -1.76556513e-01f, -1.77055851e-01f, -7.66925737e-02f, -2.89445668e-01f, -2.43444487e-01f, -1.76640347e-01f, -1.99873507e-01f,
  -4.96723037e-03f, -6.35088608e-02f, 2.81271082e-03f, 1.30693205e-02f, 1.97445378e-01f, -1.86133124e-02f, -1.06037043e-01f, 1.65968593e-02f, 1.58437714e-01f, -2.03988869e-02f,
  -7.47920349e-02f, 8.78425166e-02f, -5.32576144e-02f, -2.37991381e-02f, 4.66704629e-02f, -1.25488089e-02f, -1.19638080e-02f, -6.54284377e-03f, -9.12539884e-02f, 9.89949629e-02f,
  -2.35770158e-02f, -5.46811260e-02f, 7.54301995e-02f, -1.63277220e-02f, 8.05644598e-03f, -7.50329867e-02f, 5.39078899e-02f, -1.24131985e-01f, 1.07278049e-01f, 8.48325640e-02f,
  2.36020222e-01f, 2.01831296e-01f, 2.79875338e-01f, 8.96640196e-02f, -4.11156863e-02f, -3.24946735e-03f, -3.86648998e-02f, -7.69358799e-02f, 2.82315305e-03f, 9.03301239e-02f,
  4.77679633e-02f, 1.56293869e-01f, -1.15160033e-01f, -8.88952315e-02f, 1.65359840e-01f, 4.07425687e-02f, 1.66855305e-02f, 1.51179507e-01f, 1.30714670e-01f, 9.88118052e-02f,
  1.25947118e-01f, 1.55462012e-01f, 3.62727821e-01f, 2.00071543e-01f, 4.30122837e-02f, 3.28620732e-01f, -7.63937365e-03f, 1.10339403e-01f, 3.15315366e-01f, 4.40185159e-01f,
  -7.77617753e-01f, -3.97687584e-01f, -5.89899182e-01f, 9.10509937e-03f, 3.23656142e-01f, -1.16961217e-02f, -2.73588032e-01f, -5.10597862e-02f, 1.41119599e-01f, -1.68972239e-01f,
  -2.37661883e-01f, 7.45868683e-02f, 2.05951720e-01f, 4.18006405e-02f, -1.04513265e-01f, 1.67485520e-01f, 4.84164506e-01f, 3.02944779e-02f, -9.70814228e-02f, -7.61431158e-02f,
  4.11933601e-01f, 2.17776552e-01f, -1.53620109e-01f, -2.44033267e-03f, 3.68046284e-01f, 8.99077803e-02f, 7.33506829e-02f, 6.08526319e-02f, 2.31436659e-02f, 4.64370400e-01f,
  -5.05347490e-01f, -4.60651100e-01f, 1.86094314e-01f, -1.22446660e-02f, -1.45257503e-01f, -1.55374646e-01f, 3.62539999e-02f, -1.01494439e-01f, -1.71780109e-01f, 1.38798105e-02f,
  -2.44114958e-02f, -1.30906403e-01f, 2.49147311e-01f, -2.83302784e-01f, -1.00288540e-01f, -2.35554159e-01f, -2.78231442e-01f, -2.54941821e-01f, -3.80946785e-01f, -4.15007144e-01f,
  6.50974095e-01f, -5.07954806e-02f, -3.40628356e-01f, 5.92822395e-02f, -3.35181385e-01f, 2.13503554e-01f, -5.03312588e-01f, -7.91129936e-03f, -3.05795461e-01f, -2.82347441e-01f,
  6.61540031e-02f, -7.45846257e-02f, 3.59940343e-02f, 5.68236969e-02f, -2.96174712e-03f, 2.23957852e-01f, 5.51630296e-02f, -4.17305902e-02f, 1.81628779e-01f, -1.78394929e-01f,
  7.09288046e-02f, -1.95658088e-01f, -1.04739159e-01f, -1.58199832e-01f, 1.64174110e-01f, -4.45383638e-02f, 3.15149091e-02f, 2.23944075e-02f, -4.40695658e-02f, -4.47792038e-02f,
  -3.41801271e-02f, -3.16130966e-02f, 1.29457921e-01f, -6.29296154e-02f, -1.00338578e-01f, -5.15176468e-02f, -1.06381737e-01f, -1.52150020e-01f, -1.73787132e-01f, -6.35972321e-02f,
  -3.52478325e-01f, 3.32034290e-01f, 2.05181483e-02f, -6.50593638e-02f, -1.33023858e-02f, 9.59850028e-02f, -1.37734741e-01f, 5.54485694e-02f, 5.72329871e-02f, -1.16758682e-01f,
  -1.57062620e-01f, -2.34772414e-01f, -9.55839083e-02f, -1.49102882e-01f, -3.20186138e-01f, 6.47655576e-02f, -8.86647925e-02f, -3.80000889e-01f, -2.23036245e-01f, -6.61274567e-02f,
  -1.36850700e-01f, -2.75885284e-01f, -6.44247532e-01f, -2.45153859e-01f, 5.79120405e-02f, -3.47828001e-01f, -3.32955688e-01f, -2.21499905e-01f, -4.51688588e-01f, -9.93576646e-01f,
  -2.24470079e-01f, -1.09713149e+00f, 7.75762975e-01f, -2.81545877e-01f, 2.28332177e-01f, 3.47176254e-01f, 4.32266325e-01f, -1.51801124e-01f, -2.12273926e-01f, -1.09522782e-01f,
  -4.36369270e-01f, -4.25108224e-01f, -2.63592690e-01f, -2.45601714e-01f, -2.35693902e-01f, 2.26834491e-01f, 3.03328842e-01f, 4.75080132e-01f, 6.33675396e-01f, 2.87991971e-01f,
  -2.23246381e-01f, -8.21587890e-02f, -1.26039684e-01f, -1.57048255e-01f, -2.11776584e-01f, 2.08086031e-03f, -9.83966812e-02f, -3.17546815e-01f, -3.31401348e-01f, -2.63604343e-01f,
  3.76387239e-01f, -4.65555370e-01f, -4.05857340e-03f, -2.96602607e-01f, -8.81257802e-02f, -1.35075614e-01f, 1.50287166e-01f, -3.05514373e-02f, -1.33037731e-01f, 1.17867664e-01f,
  -9.13866609e-02f, -6.16350919e-02f, -3.35333832e-02f, -1.26447424e-01f, -2.41794381e-02f, 4.52841483e-02f, -1.56171858e-01f, -1.89020231e-01f, -2.55300939e-01f, -1.74314842e-01f,
  -2.56870538e-01f, -2.56453287e-02f, 2.23485738e-01f, 1.22064792e-01f, -2.37539575e-01f, 8.10952857e-03f, -1.40740767e-01f, -1.23945199e-01f, -8.06533098e-02f, -6.80425316e-02f,
  1.04363434e-01f, 1.92376338e-02f, 3.37767182e-04f, 8.56817141e-02f, 4.50325198e-02f, 6.60237893e-02f, -8.14393312e-02f, -2.33453866e-02f, -4.65228036e-02f, 6.86131418e-02f,
  1.32935820e-02f, 3.63858305e-02f, 1.78963598e-02f, 1.22085074e-02f, -5.20042181e-02f, -1.11810662e-01f, 2.85116434e-02f, -2.78517567e-02f, -7.01155216e-02f, 3.49518135e-02f,
  -1.46838769e-01f, -4.59190235e-02f, 8.03398415e-02f, -6.93513677e-02f, -1.00316882e-01f, -3.55915935e-03f, -7.96529725e-02f, -6.59858733e-02f, -1.43924411e-02f, -5.02493931e-03f,
  7.97119737e-02f, -1.61894247e-01f, 2.07965747e-01f, -8.22412223e-02f, 1.11349165e-01f, -6.52899817e-02f, -1.47924602e-01f, -1.13032818e-01f, -4.91713285e-02f, 1.14371829e-01f,
  -1.89305216e-01f, 1.01091400e-01f, -1.35831878e-01f, -1.77263245e-01f, 2.82495767e-01f, 1.06284156e-01f, -2.82254487e-01f, 1.24488801e-01f, -8.12041685e-02f, -8.40052813e-02f,
  -1.83405757e-01f, 1.07587785e-01f, 3.50263327e-01f, 1.87461615e-01f, -1.60467289e-02f, 3.72109920e-01f, 2.84495205e-01f, 2.21195549e-01f, 2.65842587e-01f, 3.75847280e-01f,
  -4.63581651e-01f, -7.13425219e-01f, -5.89034915e-01f, -5.19090414e-01f, -2.68392414e-01f, 1.72696769e-01f, -2.43458927e-01f, 2.12658778e-01f, 1.67690486e-01f, -4.12844598e-01f,
  7.93307573e-02f, 4.61662680e-01f, -1.26562476e-01f, 8.91503617e-02f, 4.27090228e-02f, -5.42263150e-01f, -4.67988998e-01f, -1.39199913e-01f, 2.84331262e-01f, 6.07060671e-01f,
  2.19415292e-01f, -2.39091128e-01f, 8.61288011e-02f, 7.49555454e-02f, -2.61516929e-01f, -1.27170891e-01f, -5.51467061e-01f, -3.62270743e-01f, -3.28321233e-02f, -6.54441059e-01f,
  -1.79999173e-01f, 2.00982854e-01f, 2.92113543e-01f, 1.94389120e-01f, -1.85064882e-01f, 1.81049015e-02f, 6.19681701e-02f, -1.37912959e-01f, 2.22231839e-02f, 4.91636395e-02f,
  2.69088931e-02f, 1.17765069e-01f, -7.97135532e-02f, -1.81712359e-02f, -4.46617194e-02f, 1.13417141e-01f, 3.47162001e-02f, 3.63088511e-02f, -2.23310795e-02f, -2.90103052e-02f,
  -6.49132058e-02f, 2.10144460e-01f, 2.33875707e-01f, 1.69813991e-01f, 1.99703336e-01f, 1.81576565e-01f, 1.18092885e-02f, 2.54415572e-01f, 2.56523252e-01f, -2.07398325e-01f,
  2.42838264e-02f, -5.95840365e-02f, 7.55478665e-02f, 4.82172053e-03f, 1.60767022e-03f, 4.44952399e-02f, -8.80239252e-03f, -9.36757848e-02f, -6.90717921e-02f, -8.68741274e-02f,
  -8.16724226e-02f, -4.98295724e-02f, 1.18989304e-01f, -6.71684667e-02f, 7.73061365e-02f, -3.46130654e-02f, -2.16326062e-02f, 1.12319095e-02f, -1.05188545e-02f, 2.72336695e-03f,
  1.36821955e-01f, 1.42616376e-01f, -1.15854420e-01f, 9.13958028e-02f, 7.13140145e-02f, -1.46970898e-01f, 1.29568532e-01f, 1.49934189e-02f, -1.61185503e-01f, -2.44486332e-02f,
  -1.12247057e-01f, 8.43777508e-02f, -1.64941192e-01f, 1.28676727e-01f, -3.34433764e-02f, -2.02584695e-02f, 8.81134719e-02f, -3.41323093e-02f, -1.53202983e-02f, 3.98521870e-03f,
  1.23014875e-01f, -7.31971636e-02f, -2.67839849e-01f, -1.64930876e-02f, -3.96210477e-02f, 2.28651404e-01f, -2.87364777e-02f, -1.45937666e-01f, 1.16418704e-01f, -9.05034468e-02f,
  -6.79789707e-02f, 1.54711649e-01f, 1.17381893e-01f, -3.49762142e-02f, 7.89183006e-02f, 8.80021527e-02f, -8.37791264e-02f, -6.51006848e-02f, 1.62848865e-03f, -2.97368258e-01f,
  -4.91921991e-01f, 1.70687050e-01f, -5.31027853e-01f, -1.60688460e-01f, -2.51080573e-01f, -1.91203039e-02f, 1.10014014e-01f, 2.49272779e-01f, 3.70921552e-01f, 3.59878659e-01f,
  2.95544583e-02f, -3.61865342e-01f, -2.20886782e-01f, -3.15522403e-01f, -6.37928724e-01f, 1.97684616e-02f, -4.13276196e-01f, -9.68648493e-01f, -1.11444521e+00f, -4.54980969e-01f,
  -3.70703638e-01f, -5.31039000e-01f, -8.13297927e-01f, -4.78096902e-01f, 1.18418500e-01f, -2.23815560e-01f, 5.14669670e-03f, -5.17949998e-01f, -2.07647204e-01f, -8.41255710e-02f,
  -1.40966848e-01f, -6.86084554e-02f, -1.39968887e-01f, -2.16410428e-01f, -1.63978547e-01f, -2.01117247e-01f, -1.88898563e-01f, -2.44588032e-01f, -5.81717789e-02f, -3.49990129e-01f,
  -1.74946517e-01f, 1.94551349e-01f, -5.40129066e-01f, -4.43931758e-01f, -1.13848008e-01f, -1.92707524e-01f, -2.64208674e-01f, -2.28138179e-01f, -1.06624693e-01f, 2.61866182e-01f,
  -4.19541180e-01f, -6.37980640e-01f, -2.94658452e-01f, -2.23298725e-02f, -1.05770603e-02f, -1.68661609e-01f, 1.69962481e-01f, 2.19779368e-02f, -2.56954730e-01f, 5.15554190e-01f,
  1.82464883e-01f, 1.63971856e-01f, -1.28419355e-01f, -3.18525583e-02f, 2.66626924e-01f, -9.72204506e-02f, -4.74624932e-02f, -6.77173287e-02f, 4.00723517e-02f, 1.96617581e-02f,
  1.70037329e-01f, 6.07440770e-02f, -2.15381421e-02f, -5.14680631e-02f, -8.60845894e-02f, -2.10358486e-01f, 7.82524273e-02f, 7.68148676e-02f, 1.51999548e-01f, 6.87456282e-04f,
  -7.39279389e-02f, -1.16629459e-01f, 7.87632391e-02f, -7.16828257e-02f, 3.49622145e-02f, 3.76990773e-02f, -1.16571538e-01f, -5.92350811e-02f, -4.00217324e-02f, -1.95189863e-01f,
  2.44236201e-01f, -3.06769341e-01f, 2.11281106e-01f, 3.10141556e-02f, -5.31799793e-02f, 6.88162223e-02f, 1.23911977e-01f, -2.84967385e-02f, 8.41338094e-03f, 5.02997451e-02f,
  1.26582846e-01f, 9.31995139e-02f, 1.63166877e-02f, 2.15554461e-01f, 1.20572194e-01f, -1.43135386e-02f, 2.79614259e-03f, -1.81063220e-01f, -1.87833607e-01f, 3.73448789e-01f,
  -9.60644409e-02f, 3.27745043e-02f, 5.04161464e-03f, 1.20002497e-02f, 9.49861202e-03f, -3.30574751e-01f, 1.76050901e-01f, 3.75727974e-02f, -2.87773788e-01f, 6.18778408e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.36253220e-01f, 9.87099528e-01f, 4.01371747e-01f, 6.81165397e-01f, 1.24915636e+00f, 7.03351378e-01f, -3.70827645e-01f, 1.06102407e+00f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.38521006e-02f, -3.63464028e-01f, -2.66441137e-01f, -1.37071937e-01f, 1.21635702e-02f, -5.69225550e-01f, -1.42754242e-01f, 5.15557170e-01f, -3.12004656e-01f, 8.14027488e-02f,
  -1.21775649e-01f, -5.43755710e-01f, 2.32266113e-01f, -8.09816271e-02f, 2.53321111e-01f, 2.04241648e-01f, -1.27975285e-01f, -4.14199144e-01f, -8.79443344e-03f, 2.28096798e-01f,
  9.51178968e-02f, 1.15883261e-01f, -2.88666546e-01f, 1.99867740e-01f, 2.78249323e-01f, 4.22192633e-01f, -4.81824398e-01f, 6.68162107e-02f, 1.08127818e-01f, -1.26821041e-01f,
  2.14657605e-01f, 2.00277120e-02f, 1.43820152e-01f, -1.47496700e-01f, -1.53253600e-01f, -3.26529086e-01f, 8.46388862e-02f, -1.42873814e-02f, -4.87585396e-01f, 2.50220954e-01f,
  2.32374504e-01f, -2.01666743e-01f, -1.42945135e-02f, -3.09372663e-01f, 2.51400203e-01f, 5.99247403e-02f, 2.58611798e-01f, -2.83036996e-02f, 9.94974822e-02f, -7.42108226e-02f,
  -2.06482634e-01f, 1.34968698e-01f, 1.06699109e-01f, -9.46518332e-02f, -5.43839298e-02f, -5.68570793e-01f, 1.80757284e-01f, -2.99279779e-01f, -2.02501372e-01f, -2.33120754e-01f,
  2.23020390e-02f, -1.49970651e-01f, 8.12925398e-02f, 2.35355064e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.78871328e-01f, 1.07715702e+00f, 3.96912456e-01f, -1.68658644e-02f, -1.98905990e-01f, -2.57209927e-01f, -1.19248080e+00f, 5.82640469e-01f, 3.62431794e-01f, 1.26339352e+00f,
  -2.04634830e-01f, -4.48001415e-01f, 1.81838229e-01f, 1.29402721e+00f, -4.63936359e-01f, -2.18567342e-01f, 1.22245394e-01f, -2.59852856e-02f, 1.10919870e-01f, 5.83445430e-01f,
  -9.77053344e-02f, 6.85944140e-01f, -3.13491076e-01f, -2.79840052e-01f, 1.35316622e+00f, 1.54012167e+00f, -2.22381540e-02f, 9.69342887e-01f, -3.20560545e-01f, -9.57050204e-01f,
  9.43433285e-01f, 4.38944995e-01f, -6.08795043e-03f, 2.85040140e-01f, 2.18350187e-01f, 4.79031295e-01f, 1.10522337e-01f, 9.13613141e-01f, 8.21817100e-01f, 1.02121592e+00f,
  -5.06020725e-01f, -2.64792979e-01f, -2.63748735e-01f, 1.20353699e+00f, -3.60694528e-01f, 9.24183190e-01f, -3.06163996e-01f, 1.09772809e-01f, 1.27479598e-01f, 1.11084628e+00f,
  7.06825182e-02f, 1.20709872e+00f, 6.78015292e-01f, -4.34346676e-01f, 8.93736303e-01f, 1.90711290e-01f, -2.35999808e-01f, -5.52687347e-01f, -1.16629994e+00f, 1.15454644e-01f,
  4.60230291e-01f, -5.86738825e-01f, -1.15142918e+00f, 8.70643258e-01f, -2.44508058e-01f, -8.18700373e-01f, 7.54219070e-02f, -2.47361422e-01f, 2.12935567e-01f, -9.04233932e-01f,
  9.52553302e-02f, 6.82169199e-01f, -3.88489962e-01f, 1.20808387e+00f, 1.57656193e-01f, -5.29500604e-01f, 8.91780257e-01f, -5.71937025e-01f, -4.76651281e-01f, 2.92159081e-01f,
  -1.50052577e-01f, 4.00181770e-01f, 1.04172719e+00f, 4.33418632e-01f, -2.26547867e-01f, -1.56678557e-01f, 6.11540914e-01f, -8.77020776e-01f, 9.45402026e-01f, -1.34963191e+00f,
  1.73372477e-01f, -8.10275197e-01f, 1.32793188e+00f, -6.24849141e-01f, 1.54058829e-01f, 2.53365070e-01f, -2.76538223e-01f, -1.12371731e+00f, 3.82501394e-01f, -1.33197412e-01f,
  1.84192151e-01f, 2.45168313e-01f, -1.03760302e-01f, -2.60247141e-01f, 7.53759086e-01f, 1.48853555e-01f, 4.37273294e-01f, 1.29560828e+00f, -1.68303743e-01f, 3.41459930e-01f,
  8.24929833e-01f, 7.35830545e-01f, 1.89982578e-01f, 5.21277606e-01f, 7.43990913e-02f, 6.65516734e-01f, -1.32909179e-01f, -6.88341737e-01f, -1.08537507e+00f, 8.72301579e-01f,
  -5.99791743e-02f, -1.07870903e-02f, -8.30120504e-01f, -1.04852271e+00f, -1.77752107e-01f, 6.00759089e-01f, 6.99899048e-02f, 9.87343788e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.06424147e-01f, -6.40144423e-02f, 3.13324749e-01f, 7.00428188e-01f, 1.12678371e-01f, 7.55785167e-01f, 8.64194259e-02f, 7.16675699e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  5.13585173e-02f, -1.03344786e+00f, -1.12549400e+00f, -8.72879922e-01f, -2.70569116e-01f, -3.59599918e-01f, 3.58122945e-01f, 1.12021193e-01f, -8.10218751e-01f, 6.95792019e-01f,
  -9.95999515e-01f, -3.57350290e-01f, -1.25004160e+00f, -7.69078657e-02f, 2.70773232e-01f, -4.14518028e-01f, -8.61196339e-01f, 2.77499557e-01f, 2.36668617e-01f, -1.91185728e-01f,
  -4.07136828e-01f, 9.27058816e-01f, -8.30859721e-01f, -4.29720312e-01f, -5.21213412e-01f, 4.96810734e-01f, -2.50342898e-02f, -1.88271654e+00f, 1.81333125e-01f, -8.80042672e-01f,
  6.27118707e-01f, -1.42269802e+00f, -1.43884718e-01f, -4.88113426e-02f, -4.02634032e-02f, 3.19434583e-01f, -8.62221122e-01f, 9.32566643e-01f, 1.05732703e+00f, 9.93864387e-02f,
  6.46595120e-01f, 4.58931893e-01f, -6.33111656e-01f, -6.93547204e-02f, -1.06836569e+00f, 1.88545123e-01f, -3.19253325e-01f, -9.19043183e-01f, -1.45196557e+00f, -6.40844524e-01f,
  -1.35357594e+00f, 3.94969881e-01f, 4.60578352e-01f, -5.65515697e-01f, 9.23788786e-01f, 3.67664039e-01f, 4.85367626e-01f, 4.43007797e-02f, -1.09610534e+00f, -2.59164860e-03f,
  1.93594337e-01f, -8.37132096e-01f, 6.86406195e-02f, 4.95599240e-01f, 5.57698250e-01f, 1.54123262e-01f, 7.30616212e-01f, -5.81303656e-01f, 1.32331681e+00f, 1.04062593e+00f,
  7.45111033e-02f, 5.96602023e-01f, -6.95259154e-01f, -2.63539910e-01f, -1.34139824e+00f, 4.63492483e-01f, -4.43535745e-01f, 1.55110464e-01f, 1.41201943e-01f, 4.34420586e-01f,
  4.67285693e-01f, 5.74648678e-01f, 2.02385679e-01f, 1.86497241e-01f, -5.97606063e-01f, -5.76871395e-01f, -3.58104706e-01f, 2.12495830e-02f, -1.10981047e+00f, -9.15136188e-02f,
  6.92688763e-01f, 9.18121219e-01f, -1.97321668e-01f, -2.99907297e-01f, 1.00014366e-01f, -3.54139388e-01f, 6.88127160e-01f, -9.75713670e-01f, 5.54615676e-01f, 8.96022558e-01f,
  -9.73401368e-01f, -7.69723296e-01f, -2.60000471e-02f, -4.19094563e-01f, -3.79224479e-01f, -1.28950369e+00f, -3.98258448e-01f, -1.73655140e+00f, -5.36348701e-01f, 1.01585412e+00f,
  -8.96943331e-01f, -8.58105719e-01f, -9.93157923e-01f, -5.31957865e-01f, -5.47063529e-01f, -4.06996876e-01f, 3.48210752e-01f, -2.16789812e-01f, 4.67105389e-01f, -9.55143631e-01f,
  1.61632113e-02f, -1.03618121e+00f, -2.68539727e-01f, -7.60679960e-01f, 7.62623012e-01f, 2.24870026e-01f, -1.78034768e-01f, -6.43177509e-01f, -6.50041878e-01f, -1.47656113e-01f,
  -4.19291854e-01f, -8.83139729e-01f, 1.79300398e-01f, -5.44232547e-01f, -4.74472225e-01f, 2.77083218e-01f, 7.82946765e-01f, -1.09876871e+00f, 8.75940204e-01f, -1.39327955e+00f,
  -7.71173760e-02f, -3.62084895e-01f, 1.32338077e-01f, -9.39918220e-01f, 9.43002284e-01f, 1.20431495e+00f, 7.42474258e-01f, 3.69552493e-01f, 9.63429213e-01f, -5.89173853e-01f,
  5.35274148e-01f, 1.24566150e+00f, -1.00060177e+00f, -1.17607689e+00f, -6.18597388e-01f, 1.60574400e+00f, 1.32808313e-01f, 1.17261939e-01f, -1.31227553e+00f, -8.56979072e-01f,
  4.19870019e-01f, 3.59967977e-01f, 4.60639387e-01f, 4.50258851e-01f, -2.23003611e-01f, 7.85572708e-01f, 4.15872596e-02f, 1.18642755e-01f, 6.67266071e-01f, -8.92177820e-01f,
  2.73569167e-01f, 6.25415295e-02f, -1.26738715e+00f, -1.01569819e+00f, -5.55346549e-01f, 1.11654353e+00f, 6.32832766e-01f, 4.65065986e-01f, 3.86324942e-01f, -2.12572470e-01f,
  -2.83941895e-01f, -3.79841059e-01f, -9.27094698e-01f, -5.98385751e-01f, 8.47117722e-01f, 7.23040760e-01f, -8.78383338e-01f, -2.80088335e-01f, 3.51194769e-01f, -8.74466956e-01f,
  -9.37723756e-01f, -8.17128479e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.04612625e+00f, -1.74060702e-01f, 4.58938360e-01f, -2.09007815e-01f, -1.05978630e-01f, 8.42766911e-02f, 2.60619342e-01f, -4.37935255e-02f, -2.02697560e-01f, 4.72638398e-01f,
  -1.42493337e-01f, 9.03044567e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    