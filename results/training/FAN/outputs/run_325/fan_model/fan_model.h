/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.73248830e-02f, -2.09184438e-02f, 6.04599109e-03f, 9.55536738e-02f, -6.73952624e-02f, -3.74440342e-01f, -3.28747600e-01f, 1.51322447e-02f, 1.21042870e-01f, -1.40073612e-01f,
  -1.73240870e-01f, 5.96051849e-02f, -8.73898789e-02f, -1.20347932e-01f, -5.44820204e-02f, 1.40603883e-02f, -1.49979174e-01f, -1.32707253e-01f, 1.01089060e-01f, 6.19603582e-02f,
  3.60502750e-02f, -7.92866796e-02f, -1.71091557e-02f, -9.99552906e-02f, -6.50512278e-02f, 1.27230749e-01f, 1.13766097e-01f, 1.92527026e-02f, -1.02964781e-01f, -4.93795574e-02f,
  -1.12190798e-01f, 4.19564843e-02f, 8.53321794e-03f, 1.96536239e-02f, -2.93480773e-02f, -1.50039643e-01f, -2.69439276e-02f, 9.54633951e-03f, 1.10499851e-01f, -4.04145084e-02f,
  -4.42373976e-02f, -1.35451378e-02f, -3.15400735e-02f, -5.89292161e-02f, 5.18219173e-02f, -7.34602567e-03f, 1.14355437e-01f, -7.38440268e-03f, 7.20814615e-02f, -3.16595063e-02f,
  -8.74676835e-03f, 2.46207463e-03f, 4.87175658e-02f, -5.62029369e-02f, -4.52950317e-03f, -4.68873642e-02f, -5.34098558e-02f, 4.69076969e-02f, 1.71357878e-02f, 7.05677569e-02f,
  1.88668519e-02f, -1.27990777e-02f, -7.17120897e-03f, 5.11398874e-02f, -4.96708415e-02f, -4.26191837e-02f, -1.08615935e-01f, 2.48734467e-02f, 7.48915016e-04f, 1.26115140e-02f,
  -3.77022065e-02f, -7.87636451e-03f, -4.08845246e-02f, 8.85896944e-03f, 2.95835547e-02f, -2.72955187e-02f, 1.40315108e-02f, 2.88168397e-02f, 4.01967615e-02f, 4.10404839e-02f,
  4.92504761e-02f, 2.56549809e-02f, 1.22932170e-03f, -5.46963625e-02f, -6.21496290e-02f, 2.87465248e-02f, -2.79386472e-02f, -2.31729597e-02f, -3.17990966e-02f, -5.13928533e-02f,
  -1.45345163e-02f, 1.58284038e-01f, -5.24640717e-02f, -7.26606399e-02f, 9.92113575e-02f, -9.75410268e-03f, -9.64309648e-03f, 5.87917119e-03f, 1.83727909e-02f, 6.16495498e-02f,
  3.45868766e-02f, 7.00319652e-03f, 1.99990962e-02f, 1.20854629e-02f, -2.06653867e-02f, 4.39272597e-02f, -5.99653982e-02f, 5.49316453e-03f, -5.83322980e-02f, 1.59676876e-02f,
  4.41646017e-02f, 8.03349819e-03f, 3.67142335e-02f, -1.33587737e-02f, 2.17028856e-02f, 6.80870051e-03f, 5.56901917e-02f, -6.19879970e-03f, 2.53897421e-02f, -6.37701750e-02f,
  -2.81530321e-01f, -6.13225698e-02f, -2.09517358e-03f, 7.43234232e-02f, -4.38235626e-02f, -1.28170595e-01f, -8.08489397e-02f, 6.60725012e-02f, -7.96806216e-02f, 1.38482945e-02f,
  -4.03914647e-03f, -8.43954831e-02f, -1.45472651e-02f, -1.04484372e-01f, -2.59224206e-01f, -1.30879194e-01f, 3.45752388e-02f, -6.69098943e-02f, 3.40126753e-02f, 2.37183422e-02f,
  -7.54524842e-02f, 5.07714488e-02f, -4.25841734e-02f, 1.32088199e-01f, -2.06754915e-02f, 4.92547266e-02f, 5.02878800e-02f, -9.63259954e-03f, 1.24776974e-01f, 1.11204386e-03f,
  -1.20448537e-01f, -2.05563251e-02f, 5.30826263e-02f, -4.16538827e-02f, 7.13248700e-02f, 6.49471432e-02f, 5.36570922e-02f, -3.93077619e-02f, -4.00545523e-02f, -1.25132119e-02f,
  -3.96218076e-02f, -4.94392700e-02f, -1.05821099e-02f, -7.07562119e-02f, -2.13073827e-02f, -7.17317536e-02f, 1.13921957e-02f, 6.52811229e-02f, 1.32970260e-02f, -2.14672405e-02f,
  -3.53688374e-02f, -1.98560022e-02f, -1.18351625e-02f, 2.61076782e-02f, -4.80732061e-02f, -1.24791963e-02f, 1.99647713e-02f, -7.09512096e-04f, 5.89187145e-02f, -3.92385945e-02f,
  2.61982158e-02f, 2.87583675e-02f, 4.31417190e-02f, 2.46168636e-02f, -3.09172440e-02f, 1.87205225e-02f, 2.37665325e-02f, 4.48028557e-02f, 8.44410248e-03f, -2.98219714e-02f,
  6.78052567e-03f, 2.58239321e-02f, 1.19931959e-02f, -1.77872572e-02f, -1.28350230e-02f, 5.25403768e-02f, 1.94014981e-02f, -2.52119005e-02f, 1.77692994e-02f, -5.35520390e-02f,
  6.70034215e-02f, -2.17297208e-02f, -4.39282469e-02f, 1.24863079e-02f, -8.72674212e-02f, 2.98432913e-02f, 3.50052379e-02f, 2.29172297e-02f, -3.65505628e-02f, 3.92470248e-02f,
  -3.61437420e-03f, 1.37046456e-01f, -4.01662476e-02f, 2.87645124e-02f, -5.39099611e-03f, -4.41000424e-02f, -1.21269543e-02f, 2.96560284e-02f, 3.35871940e-04f, 4.85681966e-02f,
  -2.92695668e-02f, 4.28908458e-03f, 2.14955378e-02f, -3.14031802e-02f, -3.48419510e-02f, -5.94335832e-02f, 5.97961210e-02f, -3.38894315e-02f, 6.09581405e-03f, 8.08864385e-02f,
  3.14040855e-02f, 4.38009612e-02f, -2.05600895e-02f, -3.35432477e-02f, 4.09351625e-02f, -5.45010790e-02f, -5.80627136e-02f, -2.03635767e-02f, 5.33725992e-02f, -6.01616129e-03f,
  -3.97458561e-02f, 1.12289794e-01f, 3.67344283e-02f, 2.50847816e-01f, -1.16155848e-01f, 1.31367845e-02f, -2.51848176e-02f, 4.64328974e-02f, 3.31796557e-02f, 5.20391427e-02f,
  5.77402338e-02f, 8.74930173e-02f, 4.56492044e-02f, 1.59390405e-01f, 9.66072679e-02f, 7.59106874e-02f, 2.20479757e-01f, 1.17582202e-01f, 2.66068876e-02f, 5.40733300e-02f,
  5.64518273e-02f, 1.30258888e-01f, 1.88421961e-02f, 2.88013611e-02f, -1.44874277e-02f, 9.45364833e-02f, 1.07780015e-02f, 3.26486281e-03f, 2.96647139e-02f, -1.25988806e-02f,
  -9.60189477e-02f, 3.25929038e-02f, 1.99973751e-02f, -1.18350508e-02f, 6.05210438e-02f, -9.71020088e-02f, -7.84460753e-02f, -3.90180685e-02f, -2.82000620e-02f, 4.23593298e-02f,
  -5.35624325e-02f, -7.62923853e-03f, -9.37919598e-03f, -2.08167080e-02f, -5.42049222e-02f, -7.55822584e-02f, -2.55119614e-02f, 4.95204553e-02f, 4.19206358e-02f, -6.40297681e-02f,
  1.54197179e-02f, -1.45132793e-02f, -6.96492568e-03f, -7.21805021e-02f, 3.26470137e-02f, -5.06503172e-02f, 1.16359768e-02f, -7.40330815e-02f, -5.36419591e-03f, -5.36381118e-02f,
  -4.63950168e-03f, -2.18215920e-02f, 2.68156417e-02f, -3.24410084e-03f, -5.41794784e-02f, -4.35783006e-02f, -1.91688084e-03f, -5.14878854e-02f, -1.71723515e-02f, 4.46905894e-03f,
  3.11381388e-02f, 3.79160009e-02f, -4.48206887e-02f, 9.31627154e-02f, 1.45792384e-02f, -6.13372959e-02f, 8.21369607e-03f, 2.17603985e-02f, 2.09487998e-03f, 3.88189740e-02f,
  -4.26341407e-02f, 4.45883870e-02f, -5.19434810e-02f, -5.40210828e-02f, -1.50099481e-02f, -1.27441538e-02f, 8.84826332e-02f, 1.12192193e-03f, -1.74881127e-02f, -3.07577960e-02f,
  1.61149036e-02f, 1.26923159e-01f, -6.20952109e-03f, -1.11005500e-01f, 4.20328433e-05f, 1.53041561e-03f, 3.62585112e-02f, -2.30138842e-02f, 6.30745515e-02f, -2.01599039e-02f,
  -6.95186183e-02f, -3.09543069e-02f, -2.05436703e-02f, -2.50034109e-02f, 9.03590769e-02f, 1.00925885e-01f, 3.96273695e-02f, -1.95622928e-02f, 4.21738904e-03f, 3.00547797e-02f,
  -2.01360341e-02f, -2.44655758e-02f, 5.48005924e-02f, 8.63057282e-03f, -7.52141979e-03f, 1.66263580e-02f, -5.67566119e-02f, -5.16427532e-02f, -3.26868817e-02f, -5.89695666e-03f,
  -3.48933816e-01f, 1.46182045e-01f, 4.66725267e-02f, -1.01647720e-01f, -4.54817200e-03f, -1.75448701e-01f, -1.58536673e-01f, -5.48878592e-03f, 3.73305008e-02f, 2.92750243e-02f,
  -8.63718688e-02f, 1.07484207e-01f, 9.01897717e-03f, -1.00096442e-01f, -2.45729849e-01f, 2.95242630e-02f, -1.38631836e-01f, 1.97600760e-03f, -6.97023515e-03f, -7.60303512e-02f,
  -1.62855443e-02f, -8.20790976e-02f, -8.71492829e-03f, -7.54493847e-02f, -2.08894759e-02f, 5.45031503e-02f, 3.69648747e-02f, 2.07049656e-03f, 1.64725222e-02f, -2.06945147e-02f,
  1.11880757e-01f, 6.99252412e-02f, 5.07940957e-03f, 1.03365190e-01f, -4.48089354e-02f, -8.55021998e-02f, 3.16267423e-02f, -2.29970813e-02f, 9.03690141e-03f, 5.85788563e-02f,
  2.89257467e-02f, 3.01326737e-02f, 2.99908109e-02f, 3.24808285e-02f, -7.96565786e-02f, 7.60674998e-02f, -3.41302156e-02f, -7.92355314e-02f, 8.36613253e-02f, -8.01994931e-03f,
  3.04914899e-02f, 1.06237475e-02f, -3.91451605e-02f, 3.11839208e-02f, -6.36335090e-02f, 2.91437330e-03f, 9.33615714e-02f, -3.47566083e-02f, -4.24234979e-02f, 6.12772182e-02f,
  -7.07734823e-02f, -1.17996316e-02f, -1.60343107e-02f, 2.99906079e-02f, -1.57709923e-02f, 3.95959429e-02f, -2.63103154e-02f, 1.14041613e-02f, -4.42227349e-03f, 5.73607795e-02f,
  -6.76087663e-02f, -4.33105007e-02f, 4.76108342e-02f, -2.81222109e-02f, -5.55706099e-02f, -4.15912122e-02f, -6.11883998e-02f, -7.06931483e-03f, 4.05516028e-02f, -5.84278516e-02f,
  -3.16113867e-02f, -1.58080738e-02f, 5.63947251e-03f, -7.91797414e-03f, 1.66735798e-02f, -2.62442958e-02f, -3.79954204e-02f, 7.58748427e-02f, 1.41104842e-02f, -1.00172676e-01f,
  -9.99755710e-02f, 8.41454417e-03f, 3.51655036e-02f, -4.48794626e-02f, 4.94562723e-02f, 2.71607563e-02f, -4.96412627e-02f, -3.73196490e-02f, 8.25663004e-03f, -4.26715426e-02f,
  4.30246927e-02f, 1.31399082e-02f, -6.82125688e-02f, 3.46009806e-02f, -2.49687526e-02f, -4.68990318e-02f, 2.64890376e-03f, 2.39433404e-02f, -4.82467823e-02f, 3.53436451e-03f,
  6.40420849e-03f, 6.62842393e-02f, 6.38322672e-03f, -2.12052092e-02f, -1.52489655e-02f, 5.72947487e-02f, -1.69257391e-02f, 3.82446847e-03f, -2.49961577e-02f, 3.98627408e-02f,
  1.26168460e-01f, -4.19243798e-02f, 3.39297265e-01f, -1.25016361e-01f, 5.48076853e-02f, 9.85554904e-02f, 3.17441560e-02f, -2.67988015e-02f, 2.48075038e-01f, -1.02224998e-01f,
  -1.15371644e-01f, 2.60659456e-02f, 1.64389253e-01f, -3.41955125e-01f, -9.88023449e-03f, -5.51938713e-02f, -1.81533068e-01f, -1.80020511e-01f, -6.21973984e-02f, -2.78568733e-03f,
  -9.33173373e-02f, -2.86895514e-01f, -1.42619982e-01f, -7.32390210e-02f, -4.63862903e-02f, 4.74890582e-02f, -1.52242869e-01f, 5.02954423e-02f, -1.76775470e-01f, -8.10032561e-02f,
  -4.80067246e-02f, -2.41187848e-02f, 1.07374758e-01f, 1.15290703e-03f, 2.18101535e-02f, 3.23009342e-02f, -2.04725862e-02f, -2.53056716e-02f, 9.78612080e-02f, 4.68676537e-03f,
  1.18712662e-02f, -3.83733362e-02f, -8.75431001e-02f, -7.46009033e-03f, 1.69303697e-02f, 7.15482142e-03f, -3.29608805e-02f, 2.46776082e-02f, 5.59549369e-02f, 3.68724279e-02f,
  3.32642272e-02f, -3.88036147e-02f, -4.40521073e-03f, 1.24680437e-02f, 5.98424189e-02f, -4.16817404e-02f, -6.34280592e-02f, 4.11615968e-02f, -4.26146500e-02f, -4.33683954e-02f,
  -4.88459580e-02f, 3.32753286e-02f, -3.01907044e-02f, -2.42473534e-03f, -2.82202009e-02f, -2.41736472e-02f, -2.71958113e-02f, -1.97192263e-02f, 3.21022496e-02f, -4.70313877e-02f,
  1.77573494e-03f, -1.45130362e-02f, -8.47297907e-03f, 6.61749914e-02f, -1.81588940e-02f, -2.75733452e-02f, 3.88876162e-03f, -1.77032389e-02f, 2.12161783e-02f, 5.92449680e-02f,
  2.32271035e-03f, -3.75349377e-03f, -1.09339943e-02f, 5.85565157e-02f, 2.21929178e-02f, 2.19649635e-02f, -4.75052856e-02f, -1.85247194e-02f, 6.01353422e-02f, 1.50586870e-02f,
  -6.20769635e-02f, -9.51739773e-02f, -6.43988326e-02f, 1.46452896e-02f, -5.99337881e-03f, -5.13681099e-02f, -2.11739913e-02f, 3.91467027e-02f, -2.29330268e-02f, -5.58936968e-04f,
  -1.16031375e-02f, 4.64593014e-03f, 1.98995210e-02f, 3.88678573e-02f, 1.52831944e-02f, -2.41064169e-02f, -2.50189155e-02f, 4.17980365e-02f, -3.94441150e-02f, -6.71875477e-02f,
  -4.57163863e-02f, 1.07867895e-02f, 2.81708539e-02f, 1.67490530e-03f, -4.41756807e-02f, -5.75105660e-03f, 1.07567415e-01f, 8.58956855e-03f, -2.54808608e-02f, 4.27676812e-02f,
  -1.72294557e-01f, 1.03220023e-01f, 7.21473396e-02f, -1.15501724e-01f, -7.57206231e-02f, -7.10362103e-03f, 8.16607550e-02f, -7.81300962e-02f, -5.57719804e-02f, 3.80938947e-02f,
  -9.12476171e-05f, 1.23864762e-01f, 4.06800508e-02f, -2.82252058e-02f, -1.26491800e-01f, 1.64868742e-01f, -1.50156602e-01f, -1.50146382e-02f, -4.35914472e-03f, -1.07708886e-01f,
  -1.53069822e-02f, -1.94739804e-01f, -3.54243405e-02f, 6.52732179e-02f, 3.61989550e-02f, -2.01941188e-02f, 9.46771912e-03f, 2.15984657e-01f, -4.90351431e-02f, 6.98183030e-02f,
  -6.70747682e-02f, -1.06695250e-01f, 1.21300370e-01f, -6.64063869e-03f, 4.43060286e-02f, 5.00736423e-02f, 8.98473486e-02f, 9.71680228e-03f, 2.13040914e-02f, -3.52188498e-02f,
  -1.13547975e-02f, -5.32366149e-02f, -3.45621146e-02f, 6.07711822e-02f, 2.93189548e-02f, -2.10684266e-05f, -1.80468075e-02f, 4.14316840e-02f, -4.05312143e-02f, -6.47302419e-02f,
  -2.76556332e-02f, -5.91427162e-02f, -3.97917219e-02f, -4.98313233e-02f, -1.53986737e-02f, -3.91185703e-03f, -1.81462560e-02f, 8.28460441e-04f, -3.09873540e-02f, 2.50567663e-02f,
  3.19231227e-02f, 9.45689529e-02f, -1.77578516e-02f, -3.12121306e-02f, -5.82833849e-02f, -7.31488243e-02f, 2.63034888e-02f, -1.09865740e-02f, 4.83383797e-02f, -4.59152721e-02f,
  -1.23315752e-02f, -8.14226791e-02f, 3.39886658e-02f, -5.19844256e-02f, -2.74209734e-02f, 4.73137721e-02f, 1.66484527e-03f, -1.66401546e-02f, -5.70002496e-02f, 4.72335406e-02f,
  3.81494425e-02f, -8.26583803e-03f, -5.76217212e-02f, 5.55721447e-02f, 2.44571380e-02f, 7.08875339e-03f, -2.09537204e-02f, -3.37364385e-03f, 5.27997352e-02f, 4.97788116e-02f,
  -5.87816872e-02f, -6.64179027e-02f, 1.09411636e-02f, -6.68129027e-02f, -4.28185165e-02f, -2.60327850e-02f, -6.39666338e-03f, 4.42854725e-02f, 1.51382945e-02f, 4.70206924e-02f,
  -1.50005706e-02f, 8.97919014e-03f, 2.67629568e-02f, -4.81180474e-02f, 1.67065319e-02f, 7.32359961e-02f, -4.67643701e-02f, -1.97669640e-02f, -1.94960069e-02f, -3.14420424e-02f,
  -6.81991922e-04f, -5.64270467e-02f, 1.09813333e-01f, -1.83185302e-02f, -8.50417987e-02f, -3.10674775e-02f, 5.28785586e-02f, 4.95658554e-02f, -2.40977178e-03f, -1.39403548e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.10042624e-02f, -7.25017786e-02f, -3.15610990e-02f, -1.14038467e-01f, -6.74851611e-02f, -1.18960455e-01f, -5.19238831e-03f, -8.63291249e-02f, 1.87909565e-04f, 9.41218361e-02f,
  2.42404304e-02f, -3.40361558e-02f, 4.09661792e-02f, -5.70521019e-02f, 7.11895898e-02f, 1.01760283e-01f, -5.96731938e-02f, -3.67086753e-02f, -1.06950440e-02f, -4.85382648e-03f,
  5.21176495e-03f, -1.15357757e-01f, -5.37070669e-02f, 2.48824656e-02f, -2.19544582e-02f, -4.28169258e-02f, -4.54383716e-02f, 7.26105571e-02f, -2.43355632e-02f, -4.80028316e-02f,
  1.99717376e-03f, -5.75868459e-03f, -6.55004457e-02f, 7.66409785e-02f, -8.35218504e-02f, -8.09900463e-02f, -1.05813935e-01f, 7.17862546e-02f, -4.94643711e-02f, -1.14877835e-01f,
  2.34946422e-02f, -2.97066942e-02f, -1.01048723e-01f, -4.68355678e-02f, 4.18868959e-02f, -1.24560192e-03f, 8.84520188e-02f, 2.98525151e-02f, 2.62293350e-02f, 5.94865473e-04f,
  8.08157306e-03f, 3.51277664e-02f, 1.89946145e-02f, 7.54530504e-02f, -7.44286403e-02f, -4.05365452e-02f, 9.02581215e-02f, 4.92434166e-02f, -8.46070424e-02f, -6.96481243e-02f,
  -1.52271008e-02f, -6.19969033e-02f, 6.37172014e-02f, -6.39494583e-02f, -5.05298972e-02f, 8.76252204e-02f, -3.62844057e-02f, -6.24986887e-02f, 4.66609336e-02f, -3.87779227e-03f,
  -7.35029206e-02f, -6.73138946e-02f, -7.06081688e-02f, 5.65139800e-02f, -8.17551836e-02f, -4.42456529e-02f, 6.74524605e-02f, 2.41243504e-02f, 8.60248804e-02f, -5.49287051e-02f,
  4.56061624e-02f, 6.56627789e-02f, -7.07498342e-02f, -6.70061558e-02f, -8.24959651e-02f, -8.67502168e-02f, 3.93436961e-02f, -5.62495291e-02f, -6.78165555e-02f, 2.90179043e-03f,
  -2.44775340e-02f, -9.29596126e-02f, 6.72239289e-02f, -7.28287129e-03f, -3.52271609e-02f, 2.14069756e-03f, 1.81377381e-02f, 1.86498780e-02f, -2.87913457e-02f, 1.62173957e-02f,
  -1.00094043e-01f, 5.52428626e-02f, 2.20069122e-02f, -4.89518158e-02f, 6.36604726e-02f, 4.03449051e-02f, -1.30649973e-02f, -8.59564692e-02f, 7.88018182e-02f, -4.71760258e-02f,
  7.19784349e-02f, -1.02652209e-02f, 5.54284118e-02f, -5.61920106e-02f, -7.15095783e-03f, 3.65795791e-02f, 5.57552725e-02f, -8.66050571e-02f, -4.09941375e-02f, 7.46480450e-02f,
  -1.07200928e-01f, 8.94403830e-02f, 8.35332572e-02f, -5.74299917e-02f, 5.44200726e-02f, 8.85951892e-02f, -2.88365269e-03f, 1.97377075e-02f, -6.64889365e-02f, -3.71305309e-02f,
  -1.90059878e-02f, -4.71924841e-02f, 5.95987216e-02f, -1.30463734e-01f, 4.31999341e-02f, -2.31914688e-03f, -1.87815935e-03f, -8.18300843e-02f, -4.03472595e-02f, 5.39025292e-02f,
  5.40088341e-02f, -9.30515584e-03f, 5.10122553e-02f, 2.69936550e-06f, -1.43472716e-01f, -5.10796271e-02f, -7.45490044e-02f, -2.72358228e-02f, -1.23195276e-01f, -3.98444906e-02f,
  5.16488813e-02f, -6.53825700e-02f, 2.33104378e-02f, 1.80704854e-02f, 1.59065227e-03f, -8.71577114e-02f, -6.93637086e-03f, -2.20362190e-02f, 4.80607785e-02f, 8.21863010e-04f,
  -6.10935763e-02f, 4.81299823e-03f, -6.13535643e-02f, 1.23149388e-01f, 4.57393676e-02f, 1.01707153e-01f, 4.17096354e-02f, 6.24029487e-02f, -5.41483685e-02f, -6.96718739e-03f,
  7.69125521e-02f, 2.86319740e-02f, 5.53122237e-02f, 6.83824671e-03f, 4.50060815e-02f, 5.62803645e-04f, 6.09265268e-02f, 1.57504287e-02f, 3.87822315e-02f, -5.04006334e-02f,
  -4.24727425e-02f, -5.21368254e-03f, -4.49667200e-02f, -2.66284440e-02f, -2.38091927e-02f, 5.63858487e-02f, 5.40793762e-02f, -6.74962951e-03f, 5.97069832e-03f, -1.38906026e-02f,
  -2.55756676e-02f, 8.56240690e-02f, 1.68413706e-02f, 9.15227979e-02f, -2.04560789e-03f, 7.47128483e-03f, -2.59762444e-02f, 7.83661231e-02f, -3.61764170e-02f, -7.33659491e-02f,
  -7.54596107e-03f, 9.51961055e-03f, 2.02974826e-02f, -1.75175921e-03f, -2.45398900e-04f, -5.87927662e-02f, -9.66495872e-02f, -4.65022065e-02f, -7.32607096e-02f, 9.10279453e-02f,
  -1.17822684e-01f, -3.96859460e-02f, 3.14455875e-03f, -4.19107489e-02f, -7.12215081e-02f, 5.42056374e-02f, -6.09067231e-02f, 7.13314041e-02f, -1.74205808e-03f, 8.29053745e-02f,
  -9.30213779e-02f, -2.73115840e-03f, -8.30074251e-02f, 5.09444363e-02f, -1.62021685e-02f, -2.49557961e-02f, 3.96568626e-02f, -8.87477249e-02f, 7.29723871e-02f, -2.79610883e-02f,
  7.50480071e-02f, -1.06014069e-02f, 6.28440827e-02f, -5.71981957e-03f, 8.40376504e-03f, -4.84343469e-02f, -2.26760898e-02f, 2.08847728e-02f, -7.37820659e-03f, -6.95163161e-02f,
  5.29414741e-03f, -2.47011036e-02f, 1.06648929e-01f, -2.83822678e-02f, 3.86572741e-02f, -1.68695216e-04f, -1.92991383e-02f, -1.50781972e-02f, 3.23488452e-02f, -4.19444917e-03f,
  -6.28322139e-02f, 6.42413497e-02f, -3.80230471e-02f, 7.76430145e-02f, -6.42148778e-02f, -1.36959761e-01f, -6.49603605e-02f, 3.32726315e-02f, 2.58777868e-02f, 9.24936533e-02f,
  -2.55903751e-02f, -9.10664052e-02f, -1.03337087e-01f, 5.27007021e-02f, 2.29599494e-02f, 1.05593046e-02f, -2.88399570e-02f, 3.75337452e-02f, -8.14324096e-02f, -9.38968584e-02f,
  -7.40405545e-02f, -3.29065733e-02f, 6.86052963e-02f, -2.25605592e-02f, 2.70101968e-02f, 2.97354795e-02f, 4.61470932e-02f, -3.71862091e-02f, 9.96322185e-03f, -1.27259912e-02f,
  6.85493276e-02f, -6.96519157e-03f, 9.31878313e-02f, 3.81712685e-03f, -1.52645670e-02f, -7.39893615e-02f, 2.33251825e-02f, 6.17735609e-02f, 5.50225377e-02f, -8.19346234e-02f,
  1.84125397e-02f, -6.15647342e-03f, -3.22348513e-02f, 1.72398388e-02f, 1.50261000e-02f, 1.18927710e-01f, -3.52861509e-02f, -5.63401729e-02f, 2.03833319e-02f, 2.30089650e-02f,
  9.89462137e-02f, 6.39813393e-02f, -5.16172796e-02f, 2.36167777e-02f, -2.83060279e-02f, 5.53766377e-02f, 2.70793512e-02f, -1.12453159e-02f, 2.83111241e-02f, 2.86177229e-02f,
  4.87093031e-02f, 4.60614786e-02f, -6.84261471e-02f, 5.57690859e-04f, 2.71645784e-02f, -5.33631220e-02f, 7.42702112e-02f, 2.95725521e-02f, 1.43546378e-02f, 1.29702380e-02f,
  -5.98834381e-02f, 4.97365706e-02f, 6.50630742e-02f, -1.29810320e-02f, 6.97180629e-02f, 2.86302492e-02f, 1.25037478e-02f, 2.84359027e-02f, -7.57073006e-03f, 5.91698140e-02f,
  -1.03024893e-01f, 4.15527374e-02f, -8.35272819e-02f, 7.17662424e-02f, 1.43556241e-02f, -3.24199013e-02f, -5.17066829e-02f, 1.99613944e-02f, -4.45807306e-03f, -7.74453357e-02f,
  3.60691291e-03f, 3.09049729e-02f, 6.85457885e-02f, -1.00225821e-01f, -5.19944802e-02f, -8.41818452e-02f, -7.75509551e-02f, 4.85579744e-02f, -1.38491616e-02f, 1.69883016e-02f,
  9.31830779e-02f, 5.67254201e-02f, -6.95622433e-03f, 4.16139811e-02f, 7.14139268e-03f, 5.81500232e-02f, 4.50200699e-02f, -7.12184282e-03f, -4.10259068e-02f, -1.65032428e-02f,
  -7.65614957e-02f, 6.48285076e-02f, -1.85216933e-01f, 9.23425518e-03f, 3.97505565e-03f, -5.56765758e-02f, -1.41535535e-01f, 4.88468073e-02f, 6.10776432e-02f, 1.80404689e-02f,
  -3.34368367e-03f, 1.02995887e-01f, 6.95814565e-02f, -5.94308190e-02f, -6.81755468e-02f, -3.08152903e-02f, -1.47851869e-01f, -1.24182612e-01f, 5.10389693e-02f, -2.01509625e-01f,
  -8.77820924e-02f, -1.70035750e-01f, -1.04602396e-01f, -9.85074565e-02f, -2.12743148e-01f, -6.68823272e-02f, 1.80801507e-02f, 1.11851739e-02f, -8.26826990e-02f, 5.32337353e-02f,
  -1.16846964e-01f, -1.54370992e-02f, -4.99819815e-02f, -5.04461974e-02f, -3.57743725e-03f, -9.77533385e-02f, 7.08522415e-03f, 4.88786027e-02f, -1.45538049e-02f, 8.04608315e-02f,
  -7.76949674e-02f, -4.44731973e-02f, 4.62852344e-02f, 7.22693354e-02f, -6.17062598e-02f, 7.68934144e-03f, -8.46012309e-02f, -1.76539291e-02f, -3.66471969e-02f, -4.82362621e-02f,
  -1.00516811e-01f, -1.30993882e-02f, -1.89792383e-02f, 3.33107635e-02f, 1.83236916e-02f, -6.26218691e-02f, 1.11579642e-01f, 5.37624471e-02f, -9.74545330e-02f, -7.04565942e-02f,
  -3.63009572e-02f, -4.24257778e-02f, 3.60319503e-02f, -7.93248489e-02f, 2.96437740e-02f, 4.49734852e-02f, 2.19913432e-03f, 6.62613139e-02f, -8.95021483e-03f, -9.82690081e-02f,
  5.24058826e-02f, 4.42499109e-02f, 2.71799248e-02f, -2.87082829e-02f, -9.56341326e-02f, -3.91019769e-02f, -1.21146757e-02f, -8.25966373e-02f, 6.67108446e-02f, -2.03401688e-02f,
  -2.90043652e-02f, -4.61309440e-02f, 6.08166009e-02f, 3.76777053e-02f, 5.29836714e-02f, -2.41561811e-02f, 4.22079042e-02f, 4.18118984e-02f, 4.95184399e-02f, 3.80979478e-02f,
  -8.67685005e-02f, -1.30389929e-02f, -5.73682487e-02f, -3.59505266e-02f, -7.73994848e-02f, -5.20657785e-02f, -7.45953023e-02f, -1.16677582e-02f, -9.58615635e-03f, -4.31830771e-02f,
  2.79805139e-02f, 1.13247465e-02f, -1.09551735e-01f, 1.50492731e-02f, 5.67675494e-02f, -3.73869576e-02f, 5.24961650e-02f, 1.68103911e-02f, -1.91806722e-02f, -2.18535084e-02f,
  -5.25922105e-02f, -2.79896092e-02f, 5.44597432e-02f, -1.32728675e-02f, -8.65252875e-03f, -1.09810375e-01f, -2.62465309e-02f, -8.33540335e-02f, 5.23154102e-02f, -1.88160967e-02f,
  -4.46795411e-02f, 9.65942070e-02f, 7.43918791e-02f, -3.51045094e-02f, 6.22792430e-02f, 6.51627705e-02f, -8.20823684e-02f, 1.07174091e-01f, 1.17810503e-01f, -5.67771047e-02f,
  -1.15176722e-01f, 1.26999363e-01f, 6.58372641e-02f, 4.98386286e-03f, -1.15830921e-01f, -9.08633694e-02f, -6.14697821e-02f, -8.38765353e-02f, 7.02533126e-02f, -8.93053636e-02f,
  -8.03324357e-02f, 8.47521331e-03f, 4.14037481e-02f, -7.19923824e-02f, 5.72732762e-02f, -1.25793321e-02f, -1.46515712e-01f, 4.94974218e-02f, 2.09066104e-02f, -3.82201076e-02f,
  5.84668815e-02f, -2.41927523e-02f, 6.05426356e-02f, 1.08072810e-01f, 9.30437222e-02f, -7.15496317e-02f, -1.28923031e-02f, 5.58705702e-02f, 8.79007056e-02f, 7.73151293e-02f,
  -3.69424634e-02f, 4.04406711e-02f, 8.01092982e-02f, 3.31357270e-02f, 8.22920948e-02f, 7.88988769e-02f, -7.78532773e-02f, -1.80646847e-03f, -3.04124202e-03f, -2.74074376e-02f,
  6.56915596e-03f, 7.73360655e-02f, 1.04022965e-01f, 4.13247272e-02f, 1.55225880e-02f, -3.87874991e-02f, -2.33187750e-02f, 8.43562186e-02f, 8.52053016e-02f, -4.94249649e-02f,
  -4.03682999e-02f, -6.29421771e-02f, 1.82634350e-02f, 5.82658164e-02f, 7.16399848e-02f, 5.31436242e-02f, -4.25077155e-02f, -9.73176863e-03f, -3.12934816e-02f, 4.78426181e-03f,
  3.83583382e-02f, -4.23944779e-02f, 7.85131305e-02f, 1.62855238e-02f, 2.49524638e-02f, 5.96775860e-02f, 3.65962759e-02f, 9.18854475e-02f, -8.75272676e-02f, -3.51444930e-02f,
  2.27939375e-02f, -2.30407696e-02f, 1.02696242e-02f, 4.23181951e-02f, -5.84128350e-02f, 9.27249342e-03f, -3.29918042e-02f, 6.21534139e-02f, -7.23232999e-02f, 5.54982154e-03f,
  2.95400005e-02f, -8.16045627e-02f, 8.39214027e-02f, 8.77934843e-02f, -8.16039834e-03f, -3.98523360e-02f, -7.90642127e-02f, -5.69710694e-02f, -5.40543459e-02f, -4.23402041e-02f,
  -3.01427804e-02f, -9.70337167e-03f, -3.43677439e-02f, 1.60647184e-02f, 3.56914289e-02f, 8.25489312e-02f, -6.36417866e-02f, -8.80474970e-02f, -2.62197964e-02f, -6.42036721e-02f,
  -2.59888973e-02f, 2.60300301e-02f, 1.11321747e-01f, -4.51829061e-02f, -6.43397272e-02f, -6.17146492e-02f, 6.20465837e-02f, -5.34415692e-02f, -4.36029434e-02f, 1.53166084e-02f,
  1.11147895e-01f, -1.33881941e-01f, -2.53885034e-02f, 4.89979833e-02f, 4.09699865e-02f, 3.43520790e-02f, -5.63066304e-02f, -6.49981424e-02f, 8.59025680e-03f, -5.71183395e-03f,
  7.86497891e-02f, -3.10792942e-02f, -8.46478790e-02f, 8.41422230e-02f, 1.18020870e-01f, -8.96418095e-02f, 1.48414180e-01f, -4.35063802e-02f, -8.98794830e-02f, 3.63148451e-02f,
  5.74653260e-02f, 4.08734232e-02f, 9.32687521e-02f, 9.83629562e-03f, -2.44787894e-02f, 1.83115099e-02f, 9.20760930e-02f, 7.36662894e-02f, 4.61228415e-02f, -3.48829441e-02f,
  2.41566319e-02f, -1.04930185e-01f, 1.70860067e-02f, -2.51157898e-02f, -1.02464706e-01f, 1.84859615e-02f, 1.59199759e-02f, -1.02988966e-02f, 7.52427429e-02f, 3.30091752e-02f,
  7.71478564e-03f, 3.37345786e-02f, -5.45676164e-02f, -2.72378642e-02f, -2.65252795e-02f, 6.28430545e-02f, 6.08592629e-02f, 6.37301207e-02f, -2.26149000e-02f, 3.25131714e-02f,
  -7.47486278e-02f, -8.53346884e-02f, -3.05825155e-02f, 4.09830660e-02f, -3.99107523e-02f, -4.93407175e-02f, 6.29422115e-03f, 3.90715525e-02f, 2.57688742e-02f, 8.54704455e-02f,
  -7.40427226e-02f, 4.84967567e-02f, 1.71587169e-02f, 4.78166156e-02f, -1.97973289e-02f, -5.27829863e-02f, 4.31294926e-03f, 2.38400120e-02f, 9.88439098e-02f, 6.97477460e-02f,
  -4.01949286e-02f, -2.98121721e-02f, 1.07623756e-01f, -5.22317067e-02f, -8.95359218e-02f, -9.18368846e-02f, 1.54573750e-02f, 3.57377678e-02f, 3.14163156e-02f, -6.61217645e-02f,
  5.34555838e-02f, 4.41298336e-02f, -2.49050744e-02f, -2.42240541e-02f, 1.19118448e-02f, -3.52224596e-02f, 5.15445620e-02f, 3.76785621e-02f, 1.77765265e-02f, -8.21754336e-02f,
  3.71729094e-03f, -7.00330958e-02f, -5.41749522e-02f, -1.06262593e-02f, 4.42108624e-02f, 1.24045044e-01f, 3.30407433e-02f, -9.24482360e-04f, -7.68398866e-02f, 5.95324440e-03f,
  7.02143461e-02f, 7.76723027e-02f, -1.10547148e-01f, 8.83371383e-02f, -2.95568034e-02f, 7.53708035e-02f, -2.78618326e-03f, -2.70526875e-02f, 6.99560791e-02f, -1.52803464e-02f,
  -8.60808790e-02f, -5.38018858e-03f, 4.02904637e-02f, -5.75318821e-02f, -5.36055639e-02f, -2.35084947e-02f, -1.77812409e-02f, -2.24844553e-03f, 3.18627022e-02f, -6.31060675e-02f,
  -4.86541480e-01f, -1.06397226e-01f, -5.57989813e-02f, -3.63142908e-01f, -1.33785725e-01f, 5.74939959e-02f, -2.05613971e-01f, 2.49672122e-03f, -1.49648905e-01f, -7.98569769e-02f,
  -1.66952193e-01f, -7.76041970e-02f, 1.92412943e-01f, -1.53886065e-01f, 1.90249726e-01f, 2.74200439e-01f, -1.55371323e-01f, -3.73760536e-02f, -7.86620472e-03f, -1.59417525e-01f,
  9.05940384e-02f, -1.01774812e-01f, 4.39507961e-02f, -3.82603630e-02f, -1.15587510e-01f, -1.40564561e-01f, -2.89511755e-02f, -7.12047145e-02f, -1.59167290e-01f, -9.54235569e-02f,
  -1.06413119e-01f, -2.95581698e-01f, -3.40744630e-02f, 2.48040464e-02f, -7.52155185e-02f, 2.16086842e-02f, -4.39709872e-02f, -2.83903740e-02f, -4.36674953e-02f, -3.58281136e-02f,
  -1.74225569e-02f, 5.46913315e-03f, -7.65147507e-02f, 5.07496558e-02f, 4.53645270e-03f, 3.43229761e-03f, 8.80813319e-03f, 1.18294694e-02f, -2.73666740e-03f, 2.35910248e-03f,
  -5.12934364e-02f, -5.64625720e-03f, 2.03561373e-02f, 2.85769254e-03f, 3.02471220e-02f, -1.31927868e-02f, -5.37381954e-02f, 1.16613330e-02f, -4.95481119e-02f, -8.13667104e-03f,
  -6.26217648e-02f, 3.22737768e-02f, -4.16196808e-02f, 2.87087932e-02f, -1.90543812e-02f, -2.42233649e-02f, -6.66150525e-02f, 2.08274461e-02f, -9.18227062e-03f, 5.03459498e-02f,
  -2.55303495e-02f, 3.90250124e-02f, -5.19982837e-02f, 7.54774511e-02f, -1.89427249e-02f, -2.65526138e-02f, -3.34445504e-04f, -1.12552352e-01f, -2.10111737e-02f, 7.68554490e-03f,
  -4.86022979e-02f, -5.38953021e-02f, 1.02891317e-02f, 3.67174204e-03f, -1.58890653e-02f, 6.01964220e-02f, -7.16016665e-02f, -3.06645073e-02f, 3.45377717e-03f, -1.65868215e-02f,
  -2.51302540e-01f, -3.00362855e-01f, -3.17900144e-02f, -2.74245685e-04f, 1.29828257e-02f, 1.61449295e-02f, 8.04206878e-02f, 3.06890602e-03f, -1.01069249e-01f, -6.12176582e-02f,
  -1.00314073e-01f, -1.39123490e-02f, 1.21172182e-02f, -3.53838578e-02f, 3.10975555e-02f, -1.29616931e-02f, -1.01954818e-01f, -3.15341614e-02f, -5.90509921e-02f, -1.66759733e-02f,
  4.61309738e-02f, 1.62621289e-02f, 1.34636899e-02f, 2.81129517e-02f, 7.63769299e-02f, -8.45076442e-02f, 1.76486559e-02f, -6.55551208e-03f, -9.64423418e-02f, -2.58871969e-02f,
  -8.62255991e-02f, -1.16381407e-01f, 6.09287433e-02f, -1.48508236e-01f, -2.81589720e-02f, 1.07088238e-01f, 5.24002276e-02f, 2.62119099e-02f, -1.10047825e-01f, -6.46580160e-02f,
  1.02271371e-01f, -4.62177880e-02f, 1.36467054e-01f, -7.91858733e-02f, 1.67319730e-01f, 6.75026923e-02f, 3.66215929e-02f, 7.35683292e-02f, 5.74995726e-02f, 4.77467328e-02f,
  5.54841645e-02f, 2.50081215e-02f, 1.46590203e-01f, -1.56724453e-02f, 1.45257832e-02f, 4.69324924e-03f, 6.11339808e-02f, 7.74496645e-02f, 2.60468274e-02f, 1.17718369e-01f,
  -8.40781778e-02f, -5.86037897e-02f, 3.34207974e-02f, 7.86000192e-02f, 8.16041008e-02f, 9.73629020e-03f, -6.52609020e-02f, 4.07294184e-02f, 7.13923648e-02f, 6.69922307e-02f,
  5.82357533e-02f, 2.63887346e-02f, 2.30736453e-02f, 6.18032478e-02f, -8.06120038e-02f, -1.67956594e-02f, -7.18264580e-02f, -6.78980723e-02f, -7.14176297e-02f, 5.67767136e-02f,
  -4.83218394e-02f, -1.00867189e-01f, -3.82551178e-02f, 4.94034030e-02f, -4.81367074e-02f, 6.04378320e-02f, 2.68913321e-02f, 1.00171782e-01f, 5.53396568e-02f, 1.58620831e-02f,
  1.74150821e-02f, -1.27008753e-02f, -4.92894575e-02f, -9.09513533e-02f, 7.38459930e-04f, 2.24273857e-02f, 3.65255401e-02f, -3.57385501e-02f, -9.08456296e-02f, 2.44987905e-02f,
  -4.92984913e-02f, 6.59687296e-02f, 2.96225995e-02f, -6.57503232e-02f, -8.06436315e-02f, -5.89026138e-02f, 2.26977840e-02f, -2.69097984e-02f, 2.56698336e-02f, -7.82037601e-02f,
  -6.36945069e-02f, 1.41033940e-02f, -5.47647886e-02f, -7.32678249e-02f, -2.97377259e-02f, 7.16459453e-02f, -9.28981453e-02f, -6.87974766e-02f, -9.04443488e-02f, -1.03919357e-02f,
  -5.98121695e-02f, -1.42812625e-01f, -8.10412169e-02f, 5.31479493e-02f, -1.71868969e-02f, -4.51342808e-03f, -4.32573212e-03f, 1.20003326e-02f, -8.02128837e-02f, 4.07500891e-03f,
  -3.98050398e-02f, 7.71944523e-02f, 4.40400951e-02f, 1.76314246e-02f, -5.82366586e-02f, -5.85798398e-02f, -6.84240684e-02f, -6.79008439e-02f, 2.52762381e-02f, -6.63902760e-02f,
  -9.21324361e-03f, 7.30223730e-02f, 7.13618249e-02f, 3.63753065e-02f, -1.18652859e-03f, -4.17718180e-02f, 2.53667831e-02f, 5.89038730e-02f, 9.85166803e-02f, -3.74894477e-02f,
  -1.27286106e-01f, 1.04684383e-01f, 1.49390623e-01f, -4.69624139e-02f, -1.10376008e-01f, 5.01678623e-02f, 8.52520317e-02f, 2.34047184e-03f, 9.72926319e-02f, 1.28125355e-01f,
  -9.69606638e-03f, 3.26036327e-02f, 5.09830825e-02f, 8.67699981e-02f, -1.90440521e-01f, -1.75426066e-01f, -3.75370197e-02f, -3.67626846e-02f, 2.64121480e-02f, -5.54583892e-02f,
  -1.08543418e-01f, -8.36620703e-02f, -7.09786564e-02f, -2.51964834e-02f, 7.56901428e-02f, 6.50756359e-02f, -1.52773395e-01f, 7.07820803e-02f, 1.17487997e-01f, 1.48637034e-02f,
  6.38981164e-02f, 9.13674384e-02f, 5.09624556e-02f, 2.28827707e-02f, -1.18001744e-01f, 7.81673267e-02f, 3.05533260e-02f, -3.12702619e-02f, -2.97544338e-02f, 6.70868829e-02f,
  6.37515560e-02f, 2.54004337e-02f, 1.00079864e-01f, -7.14633465e-02f, -1.72281787e-02f, 1.31867424e-01f, 8.35423619e-02f, -6.46205842e-02f, 9.09116119e-02f, -2.25160317e-03f,
  1.05640553e-02f, -9.07882024e-03f, 7.65789747e-02f, 1.24860322e-02f, -3.75596434e-02f, 1.21705167e-01f, -1.81510691e-02f, 1.09529216e-02f, 6.09869286e-02f, 3.76861580e-02f,
  3.06306668e-02f, -7.80069921e-03f, -8.63083899e-02f, 9.00527090e-02f, -2.32251640e-03f, 1.12461984e-01f, 5.46406582e-02f, -4.62608710e-02f, 5.76312058e-02f, -7.11064562e-02f,
  -5.48220798e-02f, 5.65330535e-02f, 5.37393801e-02f, -5.12792468e-02f, -6.06942475e-02f, 6.32399172e-02f, 5.47062494e-02f, -5.60677797e-02f, 3.47018056e-02f, 9.88089666e-03f,
  4.37284410e-02f, 6.41318485e-02f, 6.79921806e-02f, 6.78809881e-02f, 7.32639581e-02f, 2.50228625e-02f, -6.10769801e-02f, -1.10195773e-02f, -3.20529640e-02f, 5.86785562e-02f,
  -9.44415014e-03f, 7.53105283e-02f, 1.60837434e-02f, -2.55565681e-02f, -6.62939548e-02f, -8.31761223e-04f, 1.10785123e-02f, -7.89583325e-02f, -7.37258792e-02f, -6.91078603e-02f,
  3.95768955e-02f, -3.43505144e-02f, -5.32841869e-02f, -5.13142832e-02f, -2.12911833e-02f, 2.05929782e-02f, 7.14548081e-02f, 3.39508913e-02f, -1.03793621e-01f, -5.14170453e-02f,
  1.21190473e-02f, -3.93819511e-02f, 4.45839129e-02f, -7.07548931e-02f, 8.00646434e-04f, 2.63870019e-03f, -1.08165182e-02f, 8.45668539e-02f, -1.02817744e-01f, 2.78221536e-02f,
  -2.54545033e-01f, 8.75519440e-02f, -4.29603718e-02f, -1.70678392e-01f, -2.00051349e-02f, -5.24397790e-02f, 5.89133799e-02f, -9.82201472e-02f, -1.15368910e-01f, -1.55612519e-02f,
  -1.17425062e-01f, -3.06253023e-02f, 8.15567970e-02f, -4.95194569e-02f, 6.01337440e-02f, 8.35522711e-02f, -6.34881034e-02f, -6.40196949e-02f, 5.18554226e-02f, -1.45793031e-03f,
  -3.69640440e-02f, -1.48494408e-01f, 3.76286618e-02f, 5.64954914e-02f, -1.08130537e-01f, -8.33852142e-02f, -3.30873467e-02f, -1.77437754e-03f, -8.81279111e-02f, 4.92801443e-02f,
  -1.37989223e-01f, -7.91574642e-02f, -1.64017573e-01f, -8.18469599e-02f, -9.92372334e-02f, 1.52073614e-03f, -5.92458481e-03f, -6.88084518e-04f, -4.01122160e-02f, 7.69714564e-02f,
  6.89931065e-02f, 3.94095108e-02f, -2.76687872e-02f, -5.77693731e-02f, 7.64810713e-03f, -5.68601526e-02f, 1.60168316e-02f, 6.43240884e-02f, -1.42823765e-02f, -9.74715780e-03f,
  7.75256306e-02f, -6.12551086e-02f, -3.58727053e-02f, 2.29616044e-03f, 6.16599582e-02f, 1.13509055e-02f, 1.33898761e-02f, 4.18495238e-02f, 6.28725579e-03f, -2.61879005e-02f,
  2.13722754e-02f, 1.72950898e-03f, -3.29751410e-02f, 1.98927987e-02f, 8.02588835e-02f, -1.13451697e-01f, -4.54119444e-02f, 1.29764725e-03f, -3.58195007e-02f, 8.31465870e-02f,
  9.26405713e-02f, -8.76591429e-02f, 2.76557226e-02f, -1.10600598e-01f, 2.81342156e-02f, 4.97588422e-03f, 2.98259617e-03f, 2.29368303e-02f, 2.06502248e-02f, 6.25378340e-02f,
  -9.06387791e-02f, 9.53251570e-02f, -6.40190989e-02f, -3.66762839e-02f, -1.00155503e-01f, 7.03782812e-02f, 5.96317202e-02f, 1.57883223e-02f, -1.32641405e-01f, -2.91445423e-02f,
  -1.64546743e-01f, -1.33003399e-01f, -9.71959066e-03f, -1.24784775e-01f, 2.38528028e-02f, -8.62996802e-02f, -6.66302443e-02f, 2.69744117e-02f, 5.05856052e-02f, -9.16315988e-02f,
  -4.96053211e-02f, 1.39943240e-02f, 1.57256313e-02f, 6.59531206e-02f, 9.25985202e-02f, -5.96372858e-02f, 5.09761982e-02f, -4.53967527e-02f, -2.29790919e-02f, -6.08783960e-03f,
  -8.79875943e-03f, -2.01138854e-02f, 6.16476424e-02f, -9.62171797e-03f, 1.72630753e-02f, 6.11683093e-02f, -6.41958043e-02f, 4.64407317e-02f, 5.07836901e-02f, -5.76200895e-02f,
  1.45777985e-01f, 1.82106961e-02f, 1.35215387e-01f, 6.67779297e-02f, 7.70062283e-02f, 8.94774571e-02f, -5.83250634e-03f, -5.69843203e-02f, 5.35218455e-02f, -1.90427080e-02f,
  -1.25779793e-01f, 8.72291923e-02f, -9.71208438e-02f, -7.38520101e-02f, 3.32080424e-02f, -9.87718180e-02f, -6.94319084e-02f, 4.42166589e-02f, -7.39627182e-02f, 6.46623224e-02f,
  -1.68484468e-02f, 4.50188704e-02f, -7.82153308e-02f, -8.17671418e-02f, 4.39002588e-02f, -6.20882027e-02f, 4.04048227e-02f, 4.90148924e-02f, 3.53846163e-03f, 3.06450762e-03f,
  -8.54161531e-02f, -1.30648175e-02f, -7.07740337e-02f, 2.42065149e-03f, -5.60219251e-02f, -8.56555179e-02f, 6.06173612e-02f, 7.76302889e-02f, -7.74438828e-02f, -2.22720578e-02f,
  7.56286690e-03f, -5.67534603e-02f, 6.78663403e-02f, -7.90318549e-02f, 6.67877346e-02f, 1.55131230e-02f, 3.14540602e-02f, 7.61436969e-02f, 3.60521115e-02f, -6.27944842e-02f,
  -6.34527951e-02f, -5.65884225e-02f, 3.33212465e-02f, 1.09071895e-01f, 5.13634086e-02f, -9.02683884e-02f, -1.08808586e-02f, 7.44205043e-02f, 2.85410509e-02f, -5.48055731e-02f,
  8.39785412e-02f, -5.54208383e-02f, -4.96282056e-02f, 7.21413046e-02f, -5.41128870e-03f, -1.97360590e-02f, -1.11445822e-01f, 4.86418270e-02f, 1.72956772e-02f, 6.64152130e-02f,
  3.15817371e-02f, 4.53252234e-02f, 6.52677054e-03f, -6.78364411e-02f, 7.47488216e-02f, 1.05552711e-02f, -7.17941374e-02f, 2.54823547e-02f, -4.47374545e-02f, -9.37025771e-02f,
  -3.41899619e-02f, -5.53797930e-02f, -6.05422556e-02f, 7.17620105e-02f, 9.57394093e-02f, 7.78202042e-02f, -1.00224987e-01f, -4.75575440e-02f, -5.91039956e-02f, -2.09806394e-02f,
  2.26656124e-02f, 4.86563100e-03f, -1.05085894e-02f, -7.02282190e-02f, -6.16187043e-02f, 4.34547924e-02f, 1.01459743e-02f, 7.36638457e-02f, 8.44992325e-02f, 4.31127362e-02f,
  -4.11500521e-02f, -3.87797952e-02f, -7.41635412e-02f, -2.67567523e-02f, -4.07963954e-02f, 2.75158025e-02f, 5.99299297e-02f, 8.33335146e-02f, -1.75150484e-02f, -2.20191129e-03f,
  2.55533271e-02f, 7.36992359e-02f, -1.30758099e-02f, -1.75641626e-02f, 1.39568485e-02f, 3.13015725e-03f, 4.35076132e-02f, 3.83871496e-02f, 5.45737781e-02f, -2.46242359e-02f,
  1.58881664e-01f, -8.45298320e-02f, -9.76157337e-02f, 2.27664839e-02f, 1.28773544e-02f, -2.41324604e-02f, 2.07531303e-02f, -1.62797347e-02f, -7.99633935e-02f, 4.38720398e-02f,
  -1.68438740e-02f, -2.24084668e-02f, 3.58410701e-02f, -1.52855730e-02f, 9.60610691e-04f, -8.26337654e-03f, 1.16930395e-01f, 6.91977516e-02f, 7.52379140e-03f, -4.29372527e-02f,
  3.83315468e-03f, 7.13001192e-02f, 6.46192282e-02f, 9.08430666e-02f, -3.76426615e-02f, -1.01908937e-01f, -3.58694978e-02f, 1.07061386e-03f, -5.84220029e-02f, 1.06188007e-01f,
  -1.23180088e-03f, -5.92791773e-02f, 7.77578950e-02f, -2.43778229e-02f, -7.55549129e-03f, -4.25538868e-02f, 5.38287312e-02f, -5.49686737e-02f, 5.17095253e-02f, 4.35803831e-02f,
  3.22935805e-02f, 5.95513582e-02f, 8.91583413e-02f, -5.02608269e-02f, -6.48982525e-02f, -8.28903820e-03f, 1.39015252e-02f, 2.97029521e-02f, 3.15220654e-03f, -1.88633974e-04f,
  -9.10234004e-02f, 3.65190655e-02f, 4.76305820e-02f, 3.26764397e-02f, -1.12136640e-01f, -6.60287663e-02f, 6.49944469e-02f, 5.95107600e-02f, 6.90263808e-02f, -7.49952644e-02f,
  1.13644280e-01f, 7.06912801e-02f, 9.64228511e-02f, 2.18603238e-02f, -5.87742627e-02f, 2.37242635e-02f, 6.68450631e-03f, -4.58426215e-02f, -4.88635674e-02f, -9.03277250e-04f,
  -8.87327567e-02f, -7.60073513e-02f, 1.47815011e-02f, 1.12755215e-02f, -6.92700520e-02f, -7.78418332e-02f, 2.45862249e-02f, 1.44346673e-02f, -7.48428032e-02f, -5.79308458e-02f,
  -7.14374408e-02f, -5.72939925e-02f, 6.69242814e-02f, -4.65502888e-02f, -8.82578120e-02f, 6.11318201e-02f, -4.26163971e-02f, -3.19653228e-02f, 5.43762185e-02f, -2.87950188e-02f,
  2.10453440e-02f, -9.89091396e-02f, 6.73573390e-02f, -5.61143458e-02f, 4.12844233e-02f, 3.38868909e-02f, -2.41679065e-02f, -1.61374863e-02f, 6.52515069e-02f, -2.20302101e-02f,
  3.65320817e-02f, 4.52108197e-02f, -6.07284494e-02f, 9.72916931e-03f, -2.46246159e-02f, -6.01190478e-02f, 2.32106689e-02f, -2.96697319e-02f, -3.59084606e-02f, -4.91043925e-02f,
  -6.31150380e-02f, -1.20426072e-02f, 2.95504425e-02f, 1.67742802e-03f, 6.88632652e-02f, -5.37381023e-02f, -6.06401823e-02f, -1.75806181e-05f, 1.67917833e-02f, -5.67362942e-02f,
  1.58987314e-01f, -2.93998986e-01f, -5.94986090e-03f, 9.78606269e-02f, 1.15210824e-01f, 1.12901077e-01f, 2.18478382e-01f, 1.42552689e-01f, 1.64863884e-01f, -2.94627190e-01f,
  -4.78071757e-02f, -2.35128738e-02f, -8.74354541e-02f, -4.12615053e-02f, 2.20471635e-01f, 3.05578932e-02f, 1.38965696e-01f, 4.14498523e-02f, 2.88732219e-02f, 3.45536768e-02f,
  1.02570690e-01f, 3.61136384e-02f, -1.46862352e-02f, -1.99451074e-01f, 2.49040835e-02f, -5.10357991e-02f, 4.49917419e-03f, -1.00231841e-01f, -1.23646885e-01f, 6.56557083e-03f,
  -4.40273061e-02f, 4.29001190e-02f, -5.67931272e-02f, -2.53168610e-03f, -8.28018188e-02f, -2.85719279e-02f, -3.74933099e-03f, -4.07098755e-02f, 2.69492380e-02f, -1.57062020e-02f,
  -6.75203651e-02f, -7.79092982e-02f, 2.37143543e-02f, 4.97829691e-02f, 4.76505123e-02f, -1.34299174e-02f, 2.23608203e-02f, 3.20510119e-02f, 9.45319235e-02f, -4.98208441e-02f,
  -4.74468656e-02f, -2.27929614e-02f, -7.62686552e-03f, 3.35198231e-02f, -3.84386890e-02f, 1.00747555e-01f, -5.02476143e-03f, -3.27844657e-02f, 2.66425461e-02f, 3.65490690e-02f,
  3.88805382e-02f, 4.54225354e-02f, 5.67008480e-02f, -6.63708081e-04f, 1.69224739e-02f, -9.33948148e-04f, 3.57288532e-02f, 1.14205023e-02f, -5.35757132e-02f, 5.13287932e-02f,
  6.64078146e-02f, 3.12993675e-02f, -2.31387820e-02f, -1.10796159e-02f, -2.79884413e-02f, 6.76386356e-02f, 6.25592992e-02f, 3.40952054e-02f, -9.14363265e-02f, 3.56453434e-02f,
  -2.48067956e-02f, 3.99989076e-02f, -1.22194327e-01f, -2.86867283e-02f, -2.09085718e-02f, 5.64271323e-02f, -9.01183262e-02f, 5.64097576e-02f, 1.50162522e-02f, 1.36043886e-02f,
  -3.48999947e-02f, -1.10458679e-01f, -5.93085289e-02f, 1.77414417e-02f, -5.97391948e-02f, -1.15382560e-01f, 4.57279123e-02f, 4.15220186e-02f, -3.36565822e-02f, 1.05231348e-02f,
  -6.39118552e-02f, -2.48143729e-02f, -1.55657409e-02f, 8.13948810e-02f, -5.53985722e-02f, -2.42037736e-02f, -1.69979630e-03f, -7.29834735e-02f, 1.13248359e-02f, -5.27866185e-03f,
  3.08367498e-02f, -4.65970710e-02f, 1.84915941e-02f, -6.63724961e-03f, -6.16471879e-02f, -6.20603673e-02f, 2.72011105e-02f, 3.63963433e-02f, -1.24945296e-02f, -5.03813662e-02f,
  8.39305371e-02f, 1.11461999e-02f, 1.06432796e-01f, 2.77461316e-02f, -8.47807899e-02f, -6.98498311e-03f, -4.36485261e-02f, 6.95139840e-02f, 7.36580119e-02f, -3.31507027e-02f,
  3.54204588e-02f, 2.33428907e-02f, -4.42855805e-03f, -6.61898479e-02f, -4.46755663e-02f, -9.08046290e-02f, 7.74345472e-02f, -5.91184646e-02f, 6.11092784e-02f, 7.56502943e-03f,
  -8.91877059e-03f, -1.95875503e-02f, 2.45689396e-02f, 5.64616397e-02f, -4.15143073e-02f, 1.33834764e-01f, 1.14352949e-01f, -4.29675868e-03f, 3.73706296e-02f, -4.84227166e-02f,
  3.68658118e-02f, -3.58626223e-03f, -3.43983877e-03f, 3.96534130e-02f, -7.33411014e-02f, 2.13784818e-02f, 3.45105715e-02f, -4.61688731e-03f, 1.60586904e-03f, -5.27613536e-02f,
  5.43804541e-02f, -5.49265444e-02f, -4.86609042e-02f, 5.84692769e-02f, -6.11801408e-02f, -1.46828359e-03f, 3.54334190e-02f, 4.48217914e-02f, 9.70121101e-02f, 1.95611711e-03f,
  -5.11247404e-02f, 8.76890309e-03f, 9.08304676e-02f, -2.09667832e-02f, -8.29412192e-02f, 1.95170175e-02f, 7.29235783e-02f, 2.56674178e-02f, -4.64934222e-02f, -5.45859709e-02f,
  5.25678769e-02f, 1.45153897e-02f, 1.36004537e-02f, 6.50539920e-02f, 8.09296966e-02f, 8.64703432e-02f, 4.42472659e-02f, -5.80491088e-02f, -9.38238855e-03f, 3.41137052e-02f,
  -5.94227836e-02f, 3.19187008e-02f, 1.05697438e-01f, 6.28332943e-02f, -1.59808733e-02f, -3.08488216e-02f, -2.63493881e-02f, -6.50456995e-02f, 6.85797483e-02f, -1.33760795e-02f,
  3.84956226e-02f, 3.42604592e-02f, -8.59381333e-02f, -3.68088810e-03f, -8.23180452e-02f, -4.85040806e-02f, -2.08956767e-02f, 6.01945743e-02f, 4.76189032e-02f, 6.93148971e-02f,
  4.92991209e-02f, -2.16626320e-02f, 9.14172083e-03f, -7.50824586e-02f, -2.49265786e-02f, 9.83545557e-02f, 7.96001852e-02f, -6.44418895e-02f, -2.74181198e-02f, -1.95747353e-02f,
  -6.85859770e-02f, 9.96813327e-02f, 6.86693341e-02f, 8.83887634e-02f, -1.96964499e-02f, -9.37570557e-02f, -2.19800230e-02f, 1.23335235e-03f, -4.98053245e-02f, -7.95724094e-02f,
  9.30100828e-02f, 3.59032974e-02f, 6.18013665e-02f, -1.12076895e-02f, -9.11596343e-02f, -1.82038301e-03f, 5.35827363e-03f, -6.38263822e-02f, 2.59031206e-02f, -7.02841729e-02f,
  -1.79786965e-01f, -1.00364320e-01f, 1.48198614e-03f, 1.10404924e-01f, -3.99629399e-02f, -1.08653136e-01f, -2.50898659e-01f, 3.50178145e-02f, -1.09715357e-01f, -6.67955354e-02f,
  -5.56739904e-02f, -6.83793426e-02f, -1.40790820e-01f, 5.83055466e-02f, 6.54456019e-02f, -1.10239685e-01f, -1.37581397e-02f, 1.12357000e-02f, 6.51884377e-02f, 1.23552106e-01f,
  2.08944514e-01f, 7.76042044e-02f, 1.85572013e-01f, 2.08852917e-01f, -4.48930226e-02f, 1.41299054e-01f, 1.79066122e-01f, 5.19918911e-02f, 1.52055383e-01f, -5.93093708e-02f,
  -4.44737934e-02f, 7.56852329e-02f, -4.89432514e-02f, 1.56148989e-02f, 1.49123780e-02f, 1.63476337e-02f, 3.56272273e-02f, 7.95516092e-03f, 8.46000314e-02f, -6.31544590e-02f,
  1.03859380e-02f, 8.88632461e-02f, -6.04906604e-02f, 6.15542755e-02f, 6.73762336e-02f, 6.78892508e-02f, 1.98505260e-02f, -1.96127035e-02f, -5.54285608e-02f, 2.72714663e-02f,
  -3.44253294e-02f, -4.75355126e-02f, -2.22525988e-02f, 2.97577381e-02f, 1.45144900e-02f, -1.09149650e-01f, 7.98853301e-03f, -2.27887705e-02f, -2.31529381e-02f, 7.12080076e-02f,
  2.58679111e-02f, 8.12905207e-02f, -7.44985044e-02f, 4.15780768e-03f, 4.87410184e-03f, -1.24131655e-03f, -2.84700673e-02f, 6.83878642e-03f, -3.44150625e-02f, -3.92284170e-02f,
  9.96854827e-02f, 2.87573319e-03f, -2.56035589e-02f, -5.22827096e-02f, 1.66487489e-02f, 6.60341159e-02f, 8.52779076e-02f, -2.29381267e-02f, 5.35824941e-03f, -3.47170420e-02f,
  -3.50926779e-02f, -1.46144424e-02f, 4.25130455e-03f, 6.02647141e-02f, -2.41859793e-03f, 1.03543140e-02f, -3.78527530e-02f, -7.43203834e-02f, -6.91886097e-02f, 4.17463342e-03f,
  -2.17286404e-02f, 9.17989314e-02f, 1.63985863e-02f, 2.88713985e-04f, 6.17980175e-02f, -1.05539650e-01f, 1.22384857e-02f, -5.86536862e-02f, 6.69304729e-02f, -1.34132113e-02f,
  1.48107791e-02f, -2.23792437e-02f, 3.22328322e-02f, 3.86770330e-02f, 5.08861057e-02f, -1.92178115e-02f, 7.15347901e-02f, 1.01045109e-01f, 1.03960298e-01f, 8.63767341e-02f,
  1.34417683e-01f, -9.63395908e-02f, 2.67609842e-02f, -7.19282106e-02f, -1.35400956e-02f, 4.65879366e-02f, 4.61685378e-03f, 6.28578886e-02f, -3.07133775e-02f, 2.04492752e-02f,
  1.82435602e-01f, 2.99160145e-02f, -1.13094084e-01f, -6.58436567e-02f, 1.04009248e-01f, 1.23738363e-01f, -2.39001568e-02f, -8.41847733e-02f, 4.90090586e-02f, -1.11180497e-02f,
  1.21406838e-01f, -9.55830235e-03f, -1.70463212e-02f, 2.55123265e-02f, 2.52556354e-02f, -8.73133074e-03f, -4.44071293e-02f, 3.56511101e-02f, 2.19106693e-02f, 1.27311796e-01f,
  -7.35850213e-03f, 1.38246879e-01f, -2.32511684e-02f, -6.15340956e-02f, -1.88383181e-02f, 3.78764421e-02f, -3.10031511e-02f, 9.38692540e-02f, -4.24470659e-03f, 5.39702401e-02f,
  -7.88617972e-03f, 3.01627498e-02f, 4.76502404e-02f, -8.05902034e-02f, 7.54677206e-02f, 1.84377450e-02f, -3.30108926e-02f, -3.22898440e-02f, 6.53956756e-02f, -2.11093593e-02f,
  -4.36209328e-02f, 7.81580284e-02f, 7.23543093e-02f, 4.46086051e-03f, 4.58212346e-02f, 3.40798348e-02f, 1.60489939e-02f, 6.89518303e-02f, -9.25626082e-04f, -6.17110692e-02f,
  3.88028920e-02f, 1.01379994e-02f, 8.00918266e-02f, 4.32690373e-03f, -6.09961711e-02f, -1.05260396e-02f, 3.95132452e-02f, 9.01000109e-03f, 2.67079622e-02f, 4.11259159e-02f,
  2.95586102e-02f, -6.43248931e-02f, -2.66232695e-02f, 6.22901693e-02f, -1.01507343e-01f, 5.24040423e-02f, -7.89568052e-02f, -2.04110257e-02f, -3.09882089e-02f, -5.77398902e-03f,
  -1.28283175e-02f, -7.46247843e-02f, 1.64608136e-02f, 7.32840225e-02f, 3.97990122e-02f, -2.57752798e-02f, 3.02938931e-02f, -1.84186921e-02f, 7.39167929e-02f, -1.02106221e-02f,
  -3.81796919e-02f, -6.47442229e-03f, 8.96335393e-02f, 2.07262412e-02f, 1.03451855e-01f, -2.70414837e-02f, -5.45527712e-02f, -2.51490027e-02f, 2.56387405e-02f, 2.98410445e-03f,
  -7.68811777e-02f, -3.50992866e-02f, -6.00174477e-04f, -6.36523515e-02f, 2.07180550e-04f, 6.34696782e-02f, 6.81215525e-02f, -5.57953641e-02f, 8.68455395e-02f, 6.91267103e-02f,
  -4.65051197e-02f, 7.25316703e-02f, -2.00119037e-02f, -1.18414648e-02f, -2.30768658e-02f, -6.97349757e-02f, 2.43681036e-02f, -4.46586171e-03f, 4.68224436e-02f, -8.12700484e-03f,
  5.67142293e-02f, 6.27874956e-02f, 2.27058176e-02f, -2.69178022e-02f, 5.05925622e-03f, -4.18822914e-02f, 4.61011156e-02f, 2.34145392e-02f, -3.12578119e-02f, 1.74627565e-02f,
  5.64087890e-02f, -7.39615783e-03f, 1.74102858e-01f, -9.01096985e-02f, 1.41324967e-01f, 1.39858350e-01f, 1.12851426e-01f, -1.37375453e-02f, -3.18770967e-02f, -6.33403063e-02f,
  -6.61551878e-02f, -3.43805295e-04f, 9.64249745e-02f, -1.26102656e-01f, 1.55899122e-01f, 2.77919620e-02f, -1.10860072e-01f, -2.11426876e-02f, 9.40368325e-02f, 2.89632510e-02f,
  -8.31762925e-02f, -7.66040906e-02f, 1.18075840e-01f, -2.99815424e-02f, 5.70972934e-02f, -1.70487538e-02f, -1.21508144e-01f, 1.81853995e-01f, -3.95565666e-02f, 9.22779143e-02f,
  -6.22097810e-04f, -1.20112903e-01f, -2.30063740e-02f, -9.48795155e-02f, 7.30970651e-02f, -1.22286744e-01f, 7.43447244e-02f, 9.34326872e-02f, -5.21091595e-02f, -6.79961368e-02f,
  -9.35983583e-02f, -6.25653118e-02f, -8.41913223e-02f, -4.82154489e-02f, -6.76051006e-02f, -1.01772748e-01f, 8.21345970e-02f, -8.39061365e-02f, -6.80141002e-02f, -1.49455825e-02f,
  -2.84109693e-02f, -5.55734262e-02f, -7.88073316e-02f, -5.02788350e-02f, -4.86334823e-02f, -3.69086526e-02f, 6.33736551e-02f, -6.01898506e-02f, 5.38142733e-02f, -2.52428185e-02f,
  8.52676183e-02f, 1.12262592e-01f, -5.49114496e-02f, 6.14537783e-02f, -4.79746982e-02f, 1.76788103e-02f, 4.31224145e-02f, -7.34295547e-02f, -4.22144011e-02f, -7.11193755e-02f,
  -5.33834426e-03f, 2.07083654e-02f, -2.54959837e-02f, -2.12369300e-02f, 6.12897389e-02f, -2.72090212e-02f, -3.90172824e-02f, 5.98809794e-02f, 7.01143816e-02f, -3.20671350e-02f,
  8.54301173e-03f, -4.09068912e-02f, -2.17301603e-02f, -2.36545373e-02f, -1.08138127e-02f, 8.56150836e-02f, -1.24323862e-02f, 4.24279533e-02f, -3.08111385e-02f, 7.40310038e-03f,
  -1.27498820e-01f, -1.23818405e-01f, -8.13121255e-03f, -7.17089474e-02f, 4.31955755e-02f, -5.72251715e-02f, 4.79483418e-03f, -3.69405001e-02f, 3.32086347e-02f, 3.35697755e-02f,
  7.67998323e-02f, 4.18737940e-02f, 3.95282023e-02f, -5.80628440e-02f, 1.22343479e-02f, 1.80209782e-02f, -2.02777237e-02f, 8.49780142e-02f, -5.94900735e-02f, -4.87547778e-02f,
  3.90500389e-02f, 5.10930717e-02f, -5.01337089e-03f, -7.10137412e-02f, 5.22471666e-02f, -2.57996134e-02f, 3.44020734e-03f, -3.95155884e-02f, -2.40009278e-02f, -4.48721759e-02f,
  1.03654429e-01f, 1.21917175e-02f, -1.00576468e-01f, -1.55917123e-01f, -8.68016630e-02f, 1.62689537e-01f, 1.27680063e-01f, -5.76667935e-02f, 1.30492228e-03f, -3.19338404e-02f,
  -4.23697457e-02f, -9.90932733e-02f, 1.51264235e-01f, 8.50538015e-02f, 7.14098439e-02f, 8.08624625e-02f, 2.51931660e-02f, -2.40447521e-02f, 3.46273109e-02f, -6.27712831e-02f,
  5.73965497e-02f, 5.73756620e-02f, -4.59998399e-02f, -7.33096972e-02f, -7.60148019e-02f, 3.31310630e-02f, -8.78040195e-02f, 1.13776959e-01f, 3.09631433e-02f, -3.68861146e-02f,
  4.14869934e-02f, 4.37858775e-02f, -5.54282144e-02f, -3.75437987e-04f, 1.00212514e-01f, -7.34445676e-02f, 2.21790280e-02f, 7.33448379e-03f, 4.00606468e-02f, 4.54569124e-02f,
  2.40473170e-02f, 1.34652089e-02f, -5.03935702e-02f, -4.80833240e-02f, -2.59610452e-02f, 4.33882475e-02f, 4.31431597e-03f, 4.08518016e-02f, 6.06340580e-02f, 5.41064739e-02f,
  -9.15495008e-02f, 3.22264619e-02f, -7.56174996e-02f, 3.08336709e-02f, 3.10498830e-02f, 3.01324595e-02f, -5.66714164e-03f, 9.10979807e-02f, 6.14979118e-02f, 3.67776677e-02f,
  -1.80221591e-02f, 4.38072011e-02f, -5.02136238e-02f, -3.44668180e-02f, 3.56992148e-02f, -4.37940955e-02f, 3.92900072e-02f, -7.97720179e-02f, -4.31305803e-02f, 3.62320505e-02f,
  -8.76234248e-02f, -1.17879957e-02f, 2.68697627e-02f, 3.70857790e-02f, -7.80266225e-02f, -7.30016902e-02f, 1.01124719e-01f, -8.40971544e-02f, -5.09302467e-02f, -4.74458709e-02f,
  5.07088378e-02f, 1.16493687e-01f, -2.48951521e-02f, 2.86851972e-02f, 5.17302342e-02f, -1.10919010e-02f, 4.44499850e-02f, 3.70825874e-04f, -2.30662618e-02f, 6.70671910e-02f,
  8.78150091e-02f, 1.73179116e-02f, -8.03973824e-02f, 6.64988458e-02f, 9.27299261e-02f, 5.93479909e-02f, 3.33015397e-02f, -1.06908739e-01f, -3.42516154e-02f, -3.48018631e-02f,
  3.60497199e-02f, 3.95939350e-02f, -6.83944598e-02f, 6.56561032e-02f, 2.58969069e-02f, 1.03729092e-01f, 2.62852702e-02f, 2.94270124e-02f, 4.57106270e-02f, -1.44434050e-02f,
  -4.31710333e-02f, 1.29656848e-02f, -2.90393941e-02f, 5.61345592e-02f, 1.12151066e-02f, 5.04204892e-02f, -6.12083524e-02f, 7.72861466e-02f, 1.53530957e-02f, 8.45176652e-02f,
  2.08996553e-02f, -9.66586694e-02f, 6.07777350e-02f, 5.58870006e-03f, 8.59883204e-02f, 1.52223054e-02f, 8.26057717e-02f, -4.02045436e-02f, -8.59161094e-02f, -1.70275673e-01f,
  5.33072613e-02f, 5.89347619e-04f, 9.95707065e-02f, 8.34649950e-02f, 4.50803600e-02f, 9.27098189e-03f, 9.13203433e-02f, -4.24615778e-02f, 4.17453162e-02f, -5.29967574e-03f,
  -7.05514327e-02f, -6.78052306e-02f, -4.05786261e-02f, -8.13923627e-02f, 5.51613458e-02f, -1.03103340e-01f, 4.24850136e-02f, -2.55656652e-02f, 4.26154807e-02f, 8.29077661e-02f,
  4.08317335e-02f, -7.79543146e-02f, 1.10300392e-01f, -5.01637394e-03f, -7.61948004e-02f, -3.63611728e-02f, -8.16767383e-03f, 1.08476579e-01f, -1.17866732e-02f, 2.65716892e-02f,
  4.64691408e-02f, 5.11919111e-02f, -4.86555621e-02f, 2.90442482e-02f, 7.56245246e-03f, -9.47144255e-02f, 2.48120502e-02f, 3.23870741e-02f, 4.92865182e-02f, -9.83965397e-02f,
  -2.33591925e-02f, 3.27686705e-02f, -3.89434174e-02f, 2.28484184e-03f, 3.88326123e-02f, 2.41712015e-02f, 9.93237644e-02f, 3.78953293e-02f, -7.95982080e-04f, 6.32848591e-02f,
  -6.71420172e-02f, 4.08858284e-02f, -6.75961524e-02f, -5.14520593e-02f, -2.81744506e-02f, -3.11297942e-02f, 4.04496454e-02f, 2.83778179e-02f, 1.15374461e-01f, 8.59675482e-02f,
  -8.48114416e-02f, 2.11573560e-02f, 1.86474714e-02f, 3.86621542e-02f, 4.44144234e-02f, 1.79765895e-02f, -3.03368084e-02f, 2.06197295e-02f, -2.22764388e-02f, -8.00736994e-02f,
  -6.36961907e-02f, 5.14578633e-02f, -4.23794761e-02f, -3.82219627e-02f, 7.33081400e-02f, -1.06513975e-02f, 3.40211391e-02f, -5.62871434e-02f, -5.60777225e-02f, 5.83813898e-03f,
  -9.15590972e-02f, -1.38838693e-01f, -1.55714499e-02f, -5.90639748e-02f, -3.82373147e-02f, -3.27793993e-02f, 1.75917223e-02f, -6.03521504e-02f, -8.44423622e-02f, -7.32855946e-02f,
  8.04117694e-03f, -4.88312133e-02f, 1.83045715e-02f, 3.20292055e-03f, 5.20163216e-03f, 5.75784557e-02f, 1.49902236e-02f, -5.61294258e-02f, 3.14783528e-02f, 4.26953919e-02f,
  -5.78680448e-02f, 5.19172177e-02f, 2.13544965e-02f, -3.92639786e-02f, -8.24970845e-03f, 6.37989193e-02f, 5.91051951e-03f, 5.73364198e-02f, -3.42186615e-02f, -1.62484348e-02f,
  1.30189238e-02f, 6.24300726e-02f, 7.95371085e-02f, -9.09804031e-02f, 1.09597690e-01f, -4.44419123e-03f, 8.49621668e-02f, -1.21343918e-01f, 7.76407197e-02f, -7.44184107e-02f,
  5.28102554e-03f, -4.94540436e-03f, -5.93687184e-02f, 7.94409495e-03f, 6.18527010e-02f, 8.67521316e-02f, 2.39359066e-02f, -6.39382154e-02f, 9.48789865e-02f, -7.45088384e-02f,
  2.62658205e-02f, -9.63879153e-02f, 3.81552577e-02f, -8.32937434e-02f, 5.11264428e-02f, 5.49408123e-02f, -4.14756052e-02f, 6.95172101e-02f, 1.82458595e-03f, 5.18662632e-02f,
  -7.55831376e-02f, 1.28245342e-03f, 7.93056116e-02f, 7.58576812e-03f, 9.04215872e-02f, 4.58984710e-02f, 2.59706192e-02f, 4.59997840e-02f, 6.93531930e-02f, -3.27703692e-02f,
  2.67205723e-02f, -3.11896615e-02f, -1.26147578e-02f, -1.00709572e-02f, 5.01631983e-02f, 1.65092219e-02f, 3.08009982e-02f, 6.29819259e-02f, -6.28784969e-02f, -8.88175052e-03f,
  1.09323431e-02f, 1.70609374e-02f, 5.32135321e-03f, -4.22055647e-02f, -3.16535272e-02f, -1.94024574e-02f, 7.30737597e-02f, -5.32492809e-03f, 2.69023906e-02f, 1.70156490e-02f,
  2.93307249e-02f, -3.58211808e-02f, 3.57386321e-02f, -2.17894856e-02f, -6.63641840e-02f, -2.92119756e-03f, -2.85505895e-02f, 1.99532565e-02f, 3.04867979e-02f, -2.26699710e-02f,
  -1.52973337e-02f, -1.55484602e-02f, -8.14441666e-02f, -3.90280969e-02f, -1.75104700e-02f, 1.22509981e-02f, -3.43307597e-03f, -6.79977760e-02f, 5.67605421e-02f, 4.89470325e-02f,
  4.90464792e-02f, -8.12065750e-02f, -6.57889694e-02f, 3.94210627e-04f, 2.25790143e-02f, 8.20909888e-02f, 1.81030352e-02f, 3.72160710e-02f, -8.44036564e-02f, -8.97474661e-02f,
  -1.01155927e-02f, -1.05227336e-01f, -7.47875646e-02f, 3.80164385e-02f, 8.72983132e-03f, 2.35725157e-02f, -5.33389486e-02f, -1.22380629e-02f, 3.55610438e-02f, -6.03981279e-02f,
  -2.50813514e-02f, -7.14406073e-02f, 6.54030815e-02f, 3.19326594e-02f, 3.74003425e-02f, 2.27889661e-02f, 6.37316108e-02f, 2.76617184e-02f, 5.51398098e-02f, -9.41535458e-02f,
  -4.04891111e-02f, 2.77904095e-03f, -1.08554713e-01f, -7.91855752e-02f, 3.40354554e-02f, -3.25745456e-02f, 6.43952787e-02f, -4.63303626e-02f, 3.89472954e-03f, 2.25505829e-02f,
  -5.50793745e-02f, 1.74245983e-01f, 7.35783130e-02f, 5.24084382e-02f, 4.65610996e-02f, 1.43254668e-01f, 4.17767167e-02f, -1.19264340e-02f, -2.51689535e-02f, 2.05750670e-02f,
  -1.20896846e-01f, -6.76848441e-02f, 8.38619918e-02f, -1.77497249e-02f, -6.81971535e-02f, 5.25515154e-02f, 5.52004799e-02f, 7.40041137e-02f, 9.01458487e-02f, 3.03609353e-02f,
  -7.46762007e-02f, -8.16532001e-02f, -6.18593022e-02f, -2.06739567e-02f, -7.95585960e-02f, -9.10497010e-02f, -4.73485850e-02f, -1.02252714e-01f, 1.00155190e-01f, -5.70491794e-03f,
  -4.06941362e-02f, 1.14813847e-02f, 7.01505244e-02f, 4.29172739e-02f, 6.58850372e-02f, -7.58040249e-02f, 3.10890693e-02f, 2.14911159e-02f, 6.26946986e-02f, 1.57843698e-02f,
  2.18448658e-02f, -6.09011948e-02f, 1.28510538e-02f, 2.21113861e-03f, 6.80199191e-02f, -5.47546595e-02f, 3.04724388e-02f, 3.69545482e-02f, -6.57562399e-03f, 3.81805003e-02f,
  3.41865867e-02f, 8.45406726e-02f, -2.00649556e-02f, 8.34970325e-02f, -1.11572100e-02f, -5.16477525e-02f, 9.84787494e-02f, 2.35347054e-03f, 5.57294954e-03f, -7.96030369e-03f,
  -4.01807986e-02f, 3.17714065e-02f, 2.48578172e-02f, -1.25205955e-02f, 7.17499927e-02f, 8.19307566e-02f, -4.26711068e-02f, -4.10753749e-02f, -1.81703884e-02f, -6.45020753e-02f,
  4.95040119e-02f, 7.96886627e-03f, -9.13444310e-02f, -5.78941926e-02f, 8.17736089e-02f, -1.66638475e-02f, 1.71253830e-02f, 9.10826549e-02f, 6.75041750e-02f, -4.49059866e-02f,
  2.82405000e-02f, -5.61520122e-02f, 1.10221049e-02f, -5.98407835e-02f, 7.94875324e-02f, -8.25665146e-02f, -3.25196125e-02f, -9.53835621e-02f, 1.19972164e-02f, -4.18632291e-02f,
  3.93761657e-02f, 3.75278071e-02f, 7.09556928e-03f, -8.05339683e-03f, 7.87524879e-03f, -7.87053779e-02f, -3.58616672e-02f, 1.30585833e-02f, 1.00143045e-01f, 2.96512842e-02f,
  -6.73249140e-02f, 1.08963668e-01f, 4.23490480e-02f, -9.06950310e-02f, 6.12266324e-02f, 1.08715231e-02f, -1.08962664e-02f, 9.99437459e-03f, -5.63548692e-03f, 3.86317484e-02f,
  4.54646908e-02f, -4.20743972e-03f, -9.13734287e-02f, -5.78124560e-02f, 3.95671017e-02f, -4.69138399e-02f, 5.47023378e-02f, -2.10872199e-02f, 7.49873668e-02f, 5.63370995e-02f,
  -3.85777466e-02f, 4.71806154e-02f, 9.41802263e-02f, -1.00441754e-01f, 1.34134777e-02f, 5.69228362e-03f, -8.26269537e-02f, 9.98126566e-02f, 5.45401871e-02f, 4.39534001e-02f,
  -1.34478249e-02f, -1.10767186e-02f, 1.21271290e-01f, -9.70961824e-02f, 5.90273440e-02f, -4.75166850e-02f, -1.05776824e-01f, 3.05331945e-02f, -4.94457558e-02f, -9.93684903e-02f,
  -6.76855026e-03f, -1.67212505e-02f, -1.00142382e-01f, 3.96495089e-02f, 2.79308259e-02f, -9.37904790e-02f, 2.43201405e-02f, -6.60862913e-03f, -3.73305730e-03f, 5.99851646e-02f,
  -6.97646663e-02f, 1.01096384e-01f, 3.50703262e-02f, 5.83449490e-02f, -7.94277564e-02f, 1.64153501e-02f, -3.96927446e-02f, 1.83754303e-02f, -2.21523456e-02f, -2.32759081e-02f,
  3.65553163e-02f, 1.84602384e-02f, 1.00014089e-02f, 6.12331517e-02f, 5.81461787e-02f, 7.09113628e-02f, 3.42306793e-02f, 4.89180014e-02f, -1.89693160e-02f, -5.76938801e-02f,
  -8.70912671e-02f, -3.02804001e-02f, -3.28235663e-02f, -1.98365021e-02f, -7.08183274e-02f, 7.00362772e-02f, -2.93841735e-02f, -4.45233891e-03f, -2.10290011e-02f, 3.46003920e-02f,
  -8.82453006e-03f, -6.18307367e-02f, 7.07052723e-02f, -5.63818514e-02f, -7.85691291e-02f, 6.52830675e-03f, -6.68044016e-02f, -3.28633003e-02f, 8.52278024e-02f, 4.08274978e-02f,
  6.24005422e-02f, 3.98973711e-02f, 9.50821191e-02f, 5.66035369e-03f, -6.95672333e-02f, -5.03250770e-02f, -1.34458942e-02f, -6.95486590e-02f, 4.44565993e-03f, -6.78307191e-02f,
  4.74112295e-02f, 7.06374049e-02f, 6.16741925e-02f, 2.66963877e-02f, 3.64828631e-02f, -7.73554146e-02f, 7.96744891e-04f, 1.99242998e-02f, 1.89354010e-02f, -4.43443470e-03f,
  -1.14856802e-01f, -6.62383661e-02f, -2.34066173e-02f, 6.39316887e-02f, 4.80253734e-02f, -4.93437378e-03f, -7.79152960e-02f, 1.64199956e-02f, 6.06072322e-02f, -9.33972187e-03f,
  8.35893303e-02f, 1.05276331e-02f, 5.64315952e-02f, 5.23536233e-03f, -6.68253610e-03f, 2.24550273e-02f, -1.06025577e-01f, -3.23925950e-02f, 4.49526496e-02f, -1.03678098e-02f,
  -3.02544311e-02f, 4.22160467e-03f, -5.91111816e-02f, 8.94622877e-03f, 3.57531607e-02f, 5.11104800e-02f, 3.46419103e-02f, -4.18560021e-02f, 7.61561990e-02f, 8.53581056e-02f,
  -2.26375073e-01f, 3.07239383e-01f, -1.95779633e-02f, 1.56529218e-01f, -1.14875041e-01f, 3.83006305e-01f, 4.19477552e-01f, 2.01989394e-02f, 1.34263769e-01f, 3.29150200e-01f,
  6.45181611e-02f, -6.18311353e-02f, 5.91265261e-02f, 2.57282436e-01f, 5.91401756e-03f, 1.59647733e-01f, 2.21633852e-01f, 1.81921512e-01f, -1.03210896e-01f, -3.76431011e-02f,
  -5.36115877e-02f, 1.81508631e-01f, -8.03383514e-02f, -3.30014341e-02f, -9.07379016e-02f, -1.77581653e-01f, -4.70525324e-02f, -1.42227560e-01f, -3.24334055e-02f, -3.32155898e-02f,
  8.74072313e-02f, -9.81148779e-02f, -5.96801862e-02f, -4.45579886e-02f, 4.38495586e-03f, 3.88526022e-02f, -1.91075355e-02f, -8.03935528e-02f, -4.98043336e-02f, -1.83698386e-02f,
  -1.86551772e-02f, -4.02938128e-02f, 4.70491201e-02f, -3.66037413e-02f, -1.82986204e-02f, -5.39568849e-02f, -4.16821763e-02f, -6.97425231e-02f, 1.45747289e-02f, -5.43425865e-02f,
  -6.36664852e-02f, -5.85054383e-02f, -7.89275113e-03f, 1.05407752e-01f, -1.14650510e-01f, 4.38211076e-02f, 9.53113884e-02f, -5.88914789e-02f, -3.63375209e-02f, 7.18589500e-03f,
  -1.45117333e-02f, 2.39435025e-02f, 2.01871470e-02f, -9.18026548e-03f, -1.11612491e-02f, -8.11128318e-02f, -3.53096910e-02f, -2.86410525e-02f, -1.44914631e-02f, 2.70556547e-02f,
  -2.01434735e-02f, -2.72554420e-02f, -4.06966470e-02f, -2.56536342e-03f, 3.24569345e-02f, 5.60035482e-02f, 2.56182961e-02f, -1.64836254e-02f, 2.95016244e-02f, 1.11816521e-03f,
  1.00679226e-01f, -1.77514609e-02f, 4.09983136e-02f, 9.78605449e-02f, -1.09212380e-02f, 2.53472868e-02f, -1.72288548e-02f, -6.46798685e-02f, -5.36209494e-02f, -8.76836851e-02f,
  1.45426586e-01f, 1.87114269e-01f, 2.10178588e-02f, 1.82633959e-02f, 2.17840225e-02f, 8.13828199e-04f, 2.24264730e-02f, 2.62601883e-03f, 1.53141422e-02f, 2.09103636e-02f,
  5.44219613e-02f, 2.29052566e-02f, 2.26123650e-02f, 9.13321599e-03f, -5.73189780e-02f, 5.89011684e-02f, 3.41897793e-02f, 6.03887998e-02f, -4.04641498e-03f, -6.98460117e-02f,
  -1.96908470e-02f, 3.79338935e-02f, 2.13440675e-02f, -5.30157052e-02f, 1.50686875e-02f, 5.11755794e-02f, -1.19996201e-02f, 7.01571675e-03f, -4.23482992e-02f, 3.52946594e-02f,
  -1.75103933e-01f, -9.74281132e-02f, -2.29661703e-01f, -8.64226967e-02f, 1.97370648e-01f, 4.05902825e-02f, -1.09327994e-01f, 6.78420290e-02f, -1.03604257e-01f, 6.58227131e-02f,
  4.79877107e-02f, -1.39970884e-01f, -4.07835208e-02f, -1.70163944e-01f, -1.12391107e-01f, -1.80942073e-01f, -8.59235227e-02f, -2.78041721e-03f, -1.10132262e-01f, -7.70884976e-02f,
  -2.12286394e-02f, -4.37577479e-02f, -8.39116722e-02f, 2.40480870e-01f, -3.82339060e-02f, 7.83550143e-02f, 1.24656856e-01f, 1.49754927e-01f, 8.37429315e-02f, 4.56284992e-02f,
  -7.24109169e-03f, -4.00025658e-02f, -3.41708362e-02f, -6.81787357e-02f, 5.86712807e-02f, 8.70637223e-02f, -4.10676096e-03f, -5.54110371e-02f, -7.01787248e-02f, 1.40924770e-02f,
  2.10575052e-02f, 1.57042127e-02f, -3.21458280e-02f, -6.65567964e-02f, -2.54129171e-02f, 4.60459627e-02f, -6.96801916e-02f, -6.19172584e-03f, -5.11985878e-03f, -8.96473080e-02f,
  -3.79009582e-02f, 1.42517649e-02f, -3.08549008e-03f, 6.46857172e-02f, 2.54720822e-02f, -2.76352186e-02f, 5.69177121e-02f, 3.24748196e-02f, -3.13870073e-03f, -4.45493013e-02f,
  -2.49944441e-03f, -5.47388382e-02f, -2.34806538e-02f, -1.10622076e-02f, 6.63219616e-02f, 4.26994674e-02f, -3.09264753e-03f, -2.95124594e-02f, 3.05977892e-02f, -1.48861827e-02f,
  2.63511054e-02f, -8.25220272e-02f, -3.58339846e-02f, 2.36224066e-02f, -6.26498163e-02f, 1.62615757e-02f, -1.68285184e-02f, 2.34917216e-02f, -5.80680855e-02f, 2.70561762e-02f,
  -1.99103169e-02f, -1.74463133e-03f, -6.35012761e-02f, 7.64405578e-02f, -8.63009971e-03f, -6.17939830e-02f, -3.13651562e-02f, -2.24567018e-02f, -5.41359298e-02f, 3.94338667e-02f,
  -6.75800815e-02f, -1.88926402e-02f, 2.32823323e-02f, 8.18084553e-02f, 1.03623075e-02f, 4.41094562e-02f, 4.44081910e-02f, -4.54490855e-02f, 3.72293927e-02f, -1.03706829e-02f,
  1.55997509e-02f, 9.26146954e-02f, 4.86979336e-02f, 2.08042073e-03f, 7.02342167e-02f, -5.14857285e-02f, 6.32043853e-02f, 3.35205086e-02f, 7.21759424e-02f, -6.98542297e-02f,
  4.27211709e-02f, -6.88373344e-03f, 1.27743497e-01f, 6.14049770e-02f, -5.25319250e-03f, 9.46404710e-02f, -3.50014716e-02f, -3.93775254e-02f, 1.69289801e-02f, -1.95301678e-02f,
  -2.07595825e-01f, 1.02554336e-01f, -2.07739785e-01f, -8.75866562e-02f, 1.81022853e-01f, 3.91368894e-03f, -6.68777898e-02f, 6.19424470e-02f, -1.55864343e-01f, 1.54028609e-01f,
  -2.62677260e-02f, -1.46437898e-01f, 2.58083548e-03f, -1.63377643e-01f, -2.69777894e-01f, -2.23752052e-01f, -1.52875841e-01f, -1.75050721e-01f, -1.69220388e-01f, -9.26023051e-02f,
  -1.30360574e-01f, 5.29358052e-02f, -1.88272417e-01f, 1.82104483e-01f, -1.78422220e-02f, 7.38101602e-02f, 1.50563791e-01f, 1.75094888e-01f, 3.47793847e-02f, 8.26092362e-02f,
  -3.97120491e-02f, -7.68436790e-02f, 5.67116439e-02f, -4.35631908e-02f, -5.83594479e-02f, 6.56399280e-02f, -1.83488689e-02f, -5.76938316e-03f, 5.28899767e-02f, -1.09397374e-01f,
  4.56885286e-02f, 3.05429138e-02f, -5.82797416e-02f, 3.28617729e-02f, -2.55111102e-02f, -6.53257892e-02f, 5.47977127e-02f, -9.08903126e-03f, 8.19582026e-03f, -1.28713921e-01f,
  -1.57131344e-01f, 3.62884514e-02f, -8.95514712e-03f, 3.48496363e-02f, -9.44208577e-02f, -9.96177942e-02f, -6.87018260e-02f, -3.45594399e-02f, -2.20988542e-02f, -3.00307013e-02f,
  -1.68446507e-02f, -4.41422239e-02f, 1.73120555e-02f, -8.77181664e-02f, -3.72818224e-02f, -3.02849896e-02f, -7.38750026e-02f, 4.55889367e-02f, -6.28469884e-03f, 4.87933680e-02f,
  -2.58079246e-02f, -4.39675488e-02f, -7.67692039e-03f, 3.95031124e-02f, 1.20445034e-02f, 5.68845533e-02f, 9.01814085e-03f, -3.04951947e-02f, -2.80119143e-02f, -5.63118197e-02f,
  9.16354284e-02f, -4.13991772e-02f, 7.80816749e-02f, -4.69029695e-02f, 6.20927326e-02f, -1.13206524e-02f, -1.41599579e-02f, -3.65136638e-02f, 3.10905706e-02f, -2.62705795e-03f,
  8.18087459e-02f, 1.24979997e-02f, -6.37401119e-02f, 8.28678608e-02f, 1.44278118e-02f, -7.05400705e-02f, 2.64912471e-02f, -4.01969533e-03f, 5.90357631e-02f, 4.15129475e-02f,
  3.77498604e-02f, -6.11639544e-02f, 4.41118442e-02f, 2.36497503e-02f, 7.88917989e-02f, 4.74104919e-02f, -4.58430592e-03f, 3.23102474e-02f, 6.38493896e-02f, -7.43633369e-03f,
  9.65670776e-03f, 3.93292382e-02f, -3.86232585e-02f, 5.75655028e-02f, 4.60625589e-02f, 8.51285383e-02f, 6.47289976e-02f, -1.42464219e-02f, -5.01075089e-02f, -4.26038615e-02f,
  -2.33323108e-02f, 3.14972959e-02f, 2.77567152e-02f, 8.29724371e-02f, -7.24036992e-02f, -1.03193194e-01f, 3.39511111e-02f, -5.39729488e-04f, 8.26970637e-02f, 7.69170821e-02f,
  7.06346380e-03f, 1.28004819e-01f, -1.13670802e-04f, -3.41653116e-02f, -6.93816468e-02f, -5.41994572e-02f, -8.99616629e-02f, 7.13200271e-02f, -7.08740652e-02f, -3.74010541e-02f,
  4.93456721e-02f, -5.56827374e-02f, -1.92019325e-02f, 4.60294597e-02f, 7.47933313e-02f, 6.65459484e-02f, -9.94679108e-02f, 1.74148157e-02f, -6.57880828e-02f, 4.45957780e-02f,
  -9.13975462e-02f, -1.45242112e-02f, -5.91958314e-02f, -7.26556107e-02f, -6.07724562e-02f, 6.26288876e-02f, -6.01596059e-03f, 2.50148177e-02f, -9.69714299e-02f, 3.54065821e-02f,
  2.77262349e-02f, 9.24380776e-03f, -6.57876581e-02f, -8.38567242e-02f, -5.89600727e-02f, -7.36394944e-03f, -6.64082915e-02f, -6.19508214e-02f, -5.43518104e-02f, 3.22979055e-02f,
  3.80623713e-03f, -6.88156933e-02f, 8.58902410e-02f, 8.50464031e-02f, 5.13605140e-02f, 6.77498803e-02f, 9.09836367e-02f, -4.69160527e-02f, -2.41762903e-02f, -1.54885696e-02f,
  2.37878412e-02f, -4.13957126e-02f, -7.62998909e-02f, 3.11021321e-03f, 5.58263734e-02f, -2.63968576e-02f, -2.32485533e-02f, 8.97637196e-03f, -6.29365966e-02f, -4.38639671e-02f,
  6.24761619e-02f, 9.88859758e-02f, -8.40264708e-02f, 1.25518274e-02f, 8.95065293e-02f, -6.70352578e-02f, -2.47753263e-02f, -7.79106766e-02f, 6.20735697e-02f, -8.46132860e-02f,
  -6.83055520e-02f, 5.54406717e-02f, 2.33889055e-02f, -2.91077383e-02f, -7.15233758e-02f, 7.96927512e-03f, -8.61645713e-02f, -7.83186853e-02f, -2.95841377e-02f, 1.80992074e-02f,
  -1.73530839e-02f, 9.48915780e-02f, -1.31206186e-02f, -6.98280036e-02f, -8.37943479e-02f, -4.23717089e-02f, 8.89761597e-02f, -4.85039968e-03f, 1.26546072e-02f, -6.39785603e-02f,
  -1.84026752e-02f, -7.20896050e-02f, -3.92188914e-02f, -6.08280674e-02f, -7.76661560e-02f, -7.76446238e-02f, -2.34724097e-02f, 5.59331733e-04f, 3.56402136e-02f, 6.38996065e-02f,
  5.90350665e-02f, 3.59535739e-02f, 7.16206804e-03f, -8.69609490e-02f, 1.41483480e-02f, -3.91638689e-02f, -3.58207710e-02f, 7.17766350e-04f, 8.79033208e-02f, 5.89938723e-02f,
  -1.70402369e-03f, 3.54450233e-02f, 9.98182595e-02f, 7.46440664e-02f, 4.58441116e-02f, -1.41581431e-01f, -6.32933015e-03f, 7.91906640e-02f, 1.21596761e-01f, -4.90837470e-02f,
  1.98079161e-02f, 8.25437307e-02f, 3.57236080e-02f, 9.83692482e-02f, 3.07164211e-02f, -5.85923418e-02f, -1.49091647e-03f, 1.52623712e-03f, 1.88154578e-02f, -1.32811116e-03f,
  1.65867001e-01f, 9.29686204e-02f, 3.72079462e-02f, 7.84783512e-02f, -3.05483732e-02f, 1.06752835e-01f, 8.60330760e-02f, -6.26355186e-02f, 1.20933540e-01f, -5.49661182e-02f,
  -3.40521969e-02f, 8.85767788e-02f, 2.30045104e-03f, -6.94338977e-02f, 8.77249539e-02f, -8.26233178e-02f, -1.10333860e-02f, -2.96780616e-02f, -2.71155615e-03f, 5.31807356e-02f,
  3.32997516e-02f, -1.36139607e-02f, 1.06072836e-02f, 4.20259451e-03f, -3.86693925e-02f, -2.01129839e-02f, 2.52829678e-02f, 9.16049909e-03f, 2.70666555e-02f, 5.95833361e-02f,
  8.24320018e-02f, 3.28247100e-02f, -5.97429164e-02f, -3.32855321e-02f, -2.99522094e-02f, 2.16457881e-02f, -1.19795846e-02f, 5.92981316e-02f, 8.25388059e-02f, 5.00426218e-02f,
  -1.93685349e-02f, 4.76292474e-03f, 9.25446581e-03f, -2.49121338e-03f, 5.94254881e-02f, -2.37789899e-02f, 8.84016324e-03f, 4.39626537e-02f, -9.00499672e-02f, -3.09396572e-02f,
  5.90680800e-02f, 8.52420479e-02f, 7.72298127e-02f, -5.14099300e-02f, 7.06726983e-02f, 7.32617676e-02f, -4.50247340e-02f, 8.07368197e-04f, -6.01511821e-02f, 4.21907492e-02f,
  6.02779463e-02f, -7.58121088e-02f, 3.64483856e-02f, -2.13115849e-02f, 5.40863303e-03f, 2.23616362e-02f, 8.50907639e-02f, 7.45234266e-02f, -6.93001077e-02f, -2.95903385e-02f,
  -2.05209777e-02f, 1.84518218e-01f, -8.18081647e-02f, -1.49876205e-02f, 7.12088868e-02f, -2.98213083e-02f, 6.45032600e-02f, -2.18760315e-02f, 6.48551732e-02f, -3.59620675e-02f,
  -1.39984377e-02f, -8.29473510e-02f, 7.48409629e-02f, 8.94624144e-02f, 7.72196576e-02f, -8.30569714e-02f, -1.67022441e-02f, -6.87423497e-02f, 6.73313215e-02f, 8.55068639e-02f,
  -2.20730230e-02f, -1.32881841e-02f, 5.27035631e-02f, -1.61079466e-02f, 6.41224608e-02f, -2.51758415e-02f, -9.25709680e-03f, 3.95365357e-02f, 7.96799511e-02f, 2.27793790e-02f,
  1.01350196e-01f, 1.18231706e-01f, 2.09437683e-01f, 2.06859693e-01f, -6.07538410e-02f, -6.95284307e-02f, -4.96423356e-02f, 5.69514260e-02f, 2.11713567e-01f, -4.96976748e-02f,
  -1.37388125e-01f, 2.24757969e-01f, -5.89142181e-02f, -6.24600099e-03f, 5.51218749e-04f, -9.96731743e-02f, 3.94040197e-02f, 1.66251175e-02f, 9.48620066e-02f, -5.85118420e-02f,
  -6.11602589e-02f, -5.81366755e-02f, -3.18448804e-02f, -1.54916896e-02f, 1.02841802e-01f, 3.44112664e-02f, -4.83692139e-02f, -9.01411101e-02f, -2.46789195e-02f, -2.17160508e-02f,
  5.57821393e-02f, 9.95545983e-02f, 7.67319202e-02f, 5.74787632e-02f, 5.62199764e-03f, -6.50029182e-02f, 1.06118303e-02f, -6.89023137e-02f, -6.03564940e-02f, 4.29207878e-03f,
  8.02979022e-02f, 1.71158779e-02f, 3.03054638e-02f, 5.05995415e-02f, 3.84389311e-02f, 1.58062112e-02f, 5.69097027e-02f, 2.22793240e-02f, 8.73195287e-03f, 5.37200505e-03f,
  6.76599070e-02f, 3.49206477e-02f, -2.41251457e-02f, 5.94391599e-02f, 7.58035555e-02f, 3.24353389e-02f, 6.83087036e-02f, -3.78610753e-02f, 4.28354032e-02f, 4.42975909e-02f,
  -1.14356847e-02f, 8.34075455e-03f, 2.02283822e-02f, -9.98304859e-02f, 5.57462312e-02f, 3.90598439e-02f, 8.17279071e-02f, -1.06803112e-01f, 9.86637771e-02f, -4.93011102e-02f,
  2.91184876e-02f, -5.59837930e-02f, 2.86245886e-02f, -5.49942590e-02f, 2.84124613e-02f, 1.46860089e-02f, -1.69276595e-02f, 5.51714227e-02f, -6.79896697e-02f, -1.68775339e-02f,
  -2.98573002e-02f, -6.84577674e-02f, -7.76761398e-03f, -1.74591653e-02f, -3.76414433e-02f, 4.65973765e-02f, -3.15684304e-02f, 2.50091646e-02f, -6.65087774e-02f, -8.67619216e-02f,
  3.36505249e-02f, 6.34829551e-02f, -4.57136706e-02f, -9.69617721e-03f, 1.90592501e-02f, 1.13999071e-02f, -4.42608707e-02f, -6.08427636e-02f, 5.02309389e-02f, 7.54226595e-02f,
  1.45771801e-02f, 3.31683010e-02f, 3.78955677e-02f, -6.45554960e-02f, -4.93008122e-02f, -1.41981719e-02f, 1.87088046e-02f, 4.48315069e-02f, -2.43180040e-02f, 2.52531208e-02f,
  8.49860758e-02f, -7.44380280e-02f, -6.02531955e-02f, -9.37273726e-03f, 2.47147549e-02f, -7.66738132e-02f, -3.58820781e-02f, 6.61718845e-02f, 2.50206366e-02f, 6.70887828e-02f,
  7.89764395e-04f, 2.01440174e-02f, 1.65519789e-01f, 9.85601470e-02f, 3.71468477e-02f, -1.19764972e-02f, 1.27375066e-01f, 7.89857209e-02f, 1.65422261e-01f, 2.21582223e-02f,
  -5.58274947e-02f, 5.69856204e-02f, -1.08849607e-01f, -1.11477442e-01f, 3.87572087e-02f, -1.57213733e-02f, -5.39315492e-02f, 2.22642645e-02f, -3.89291206e-03f, -4.99007627e-02f,
  8.54992028e-03f, -9.77976769e-02f, -8.29284787e-02f, 2.96206158e-02f, -5.03089912e-02f, -5.96699454e-02f, -8.57049078e-02f, -1.60358939e-02f, -7.29354769e-02f, 2.45160572e-02f,
  -7.46771544e-02f, 4.11680602e-02f, -1.85038783e-02f, 4.11836058e-02f, 8.59471038e-02f, -8.19293931e-02f, 6.89726025e-02f, 2.70439405e-03f, 4.67509665e-02f, 5.66947982e-02f,
  3.82046252e-02f, -1.13572786e-02f, -6.55706078e-02f, 2.91159041e-02f, 6.37856591e-03f, 3.41560356e-02f, -3.75641361e-02f, 7.14021474e-02f, 9.65566710e-02f, 1.07785374e-01f,
  -3.15032005e-02f, 3.13885733e-02f, 5.73341213e-02f, -6.00785092e-02f, 4.11181897e-02f, 9.59045812e-03f, 2.22664867e-02f, 7.59868557e-03f, -4.73575108e-03f, 5.43356538e-02f,
  -1.06382169e-01f, -7.15603009e-02f, 2.21535731e-02f, 1.50081581e-02f, -2.17529517e-02f, -1.16959242e-02f, -4.31669690e-02f, 1.02939412e-01f, 1.29611298e-01f, 6.65257871e-02f,
  -6.08908944e-02f, -8.91429409e-02f, -6.68817386e-02f, -9.83008519e-02f, -5.70034757e-02f, -1.88296866e-02f, -1.06925415e-02f, -6.44082129e-02f, 2.02492382e-02f, -4.88688685e-02f,
  3.99764925e-02f, 5.19122742e-02f, 6.86316714e-02f, 3.15498747e-02f, 1.57687999e-02f, -5.64201139e-02f, -1.64940383e-03f, -6.27704524e-03f, -8.68680701e-02f, 1.47302784e-02f,
  7.71502852e-02f, -3.47961560e-02f, 3.19026932e-02f, 1.31493602e-02f, 7.07521364e-02f, -8.81568994e-03f, -2.20582597e-02f, 6.48088455e-02f, 7.01642707e-02f, -7.40566873e-04f,
  8.10320973e-02f, 4.45673130e-02f, 1.41781168e-02f, 8.04175362e-02f, -3.42482626e-02f, 2.48446967e-03f, -6.02017418e-02f, -7.07679167e-02f, 2.62917373e-02f, 2.58489791e-02f,
  -5.00351898e-02f, 9.54908878e-02f, 1.93090271e-02f, -4.49273400e-02f, 7.99105018e-02f, 1.57247689e-02f, 2.35573184e-02f, -4.29929085e-02f, 8.35495591e-02f, 1.15844887e-02f,
  -2.34317482e-01f, -9.34446603e-02f, 1.58739254e-01f, -1.09038316e-01f, 9.02360529e-02f, 1.88111201e-01f, 1.98377594e-01f, 5.23398630e-02f, -8.03480595e-02f, -1.23101957e-01f,
  -1.11558422e-01f, -3.43606174e-02f, 1.39072880e-01f, -1.10058047e-01f, 1.14161961e-01f, 1.79263577e-01f, 7.74154663e-02f, -3.10677830e-02f, 1.99789554e-02f, -1.05511956e-01f,
  -1.53492823e-01f, -5.63458502e-02f, 1.48856297e-01f, -7.83931762e-02f, -7.40464106e-02f, -6.78178817e-02f, 2.35566031e-02f, 1.37622342e-01f, -1.03209987e-01f, -1.02198739e-02f,
  4.08216193e-02f, -4.41141017e-02f, 3.63907963e-02f, 6.21686131e-02f, -8.30718577e-02f, 1.64752528e-02f, -6.85379580e-02f, 4.24189568e-02f, 1.91348586e-02f, -3.50744352e-02f,
  -3.67711261e-02f, -1.29914451e-02f, 1.64213162e-02f, 3.13698836e-02f, 3.17292660e-02f, -4.74785753e-02f, 2.49141511e-02f, -1.26061784e-02f, 5.90539686e-02f, 1.19432494e-01f,
  8.19026306e-02f, -1.66437160e-02f, -7.11211190e-02f, -3.44588012e-02f, 5.16212322e-02f, 4.82043587e-02f, -9.81564298e-02f, -6.73449486e-02f, -5.54433689e-02f, 1.87336504e-02f,
  8.31961855e-02f, 6.69191871e-03f, 5.47991954e-02f, 6.85582682e-03f, 1.22473575e-02f, -1.08282529e-02f, 2.39171274e-02f, -6.21879892e-03f, -6.12905398e-02f, -7.94355497e-02f,
  -4.79772277e-02f, 8.13430920e-03f, 4.96281385e-02f, 5.82093224e-02f, 4.06271145e-02f, 1.93997752e-02f, 7.18863383e-02f, 1.73474650e-03f, -4.76734824e-02f, -5.58796525e-02f,
  2.67977975e-02f, 3.38305384e-02f, 4.57258485e-02f, 2.38907412e-02f, 4.92095649e-02f, -3.76101248e-02f, -1.48326426e-03f, 5.19779623e-02f, 4.66137454e-02f, 5.72254732e-02f,
  -1.39319627e-02f, 1.57243181e-02f, 2.01074872e-02f, 2.88875718e-02f, 1.11202486e-02f, -3.93850990e-02f, 1.33760180e-03f, 2.31030094e-03f, 3.44224982e-02f, -5.92288412e-02f,
  1.89331062e-02f, 5.37150949e-02f, -2.62953248e-02f, 1.86419431e-02f, -4.78414223e-02f, -6.90646991e-02f, -3.51645611e-02f, 8.82404577e-03f, 2.54113181e-03f, 5.17472774e-02f,
  -7.04933330e-02f, -4.36485000e-02f, 8.91383886e-02f, -4.54118364e-02f, -1.27224885e-02f, -4.48454991e-02f, -1.09850906e-01f, -5.97864296e-03f, -3.22508253e-02f, -6.34296313e-02f,
  3.17476355e-02f, -1.49162382e-01f, -3.27106863e-02f, -1.12437092e-01f, -5.08252084e-02f, -1.99303836e-01f, -2.40026385e-01f, 3.57577950e-02f, -4.11983095e-02f, 5.70231192e-02f,
  -5.37162938e-04f, -3.24456543e-02f, -5.73815070e-02f, -9.47542954e-03f, -3.74171743e-03f, 6.24986999e-02f, -6.84551001e-02f, -1.00965932e-01f, 1.03698462e-01f, 2.16212799e-03f,
  6.62673992e-05f, 5.22745289e-02f, -7.99837485e-02f, -6.81940913e-02f, -9.83189866e-02f, 7.39749894e-02f, 9.30879265e-02f, -3.23995799e-02f, -1.50695378e-02f, -2.58695371e-02f,
  -9.90754515e-02f, 1.36819884e-01f, 4.47016284e-02f, -1.15964711e-02f, -3.38987112e-02f, -3.78057435e-02f, -4.46997583e-02f, -3.61683103e-03f, -1.28571568e-02f, -7.28440434e-02f,
  7.23647922e-02f, -1.93546060e-02f, -5.37247397e-02f, -2.42718831e-02f, -8.27631205e-02f, 5.27608721e-03f, -6.92490786e-02f, -6.28552586e-02f, -1.34141184e-03f, 3.75171863e-02f,
  -6.71643019e-02f, -1.15421358e-02f, 7.71705359e-02f, 1.11463340e-02f, 5.60519798e-03f, 3.36624496e-02f, -1.00660190e-01f, 4.29263450e-02f, -5.44592775e-02f, 5.96965961e-02f,
  -1.33207357e-02f, -1.45469643e-02f, -8.15492049e-02f, -4.24972251e-02f, -9.86834019e-02f, -1.60101429e-02f, 9.17018056e-02f, -6.30186647e-02f, -3.66805792e-02f, -7.48295058e-03f,
  3.57604772e-02f, -4.98752706e-02f, -3.57618220e-02f, 2.35882364e-02f, -2.62711104e-02f, 1.78230498e-02f, -8.06424394e-02f, 1.07881483e-02f, -3.88134234e-02f, 1.92724913e-02f,
  -3.08444761e-02f, -1.53175183e-02f, 1.58779602e-02f, 5.36662526e-02f, 6.07153513e-02f, 8.20972584e-03f, -7.10007772e-02f, 4.14502621e-02f, -5.25366440e-02f, -2.00660117e-02f,
  2.47103851e-02f, 9.57245007e-02f, -6.20688461e-02f, 1.33417184e-02f, 1.79943666e-02f, -3.08183907e-03f, -5.90608418e-02f, -4.87015694e-02f, -6.50487766e-02f, -2.79680383e-03f,
  -3.00683714e-02f, 9.43913162e-02f, 6.32634163e-02f, -1.50537835e-02f, -5.81086166e-02f, 6.93799332e-02f, -5.76415882e-02f, 7.90047180e-03f, -1.91281028e-02f, 9.03169960e-02f,
  -4.09181379e-02f, -8.34101588e-02f, 6.32929336e-03f, -8.20938498e-02f, -1.93121321e-02f, 5.12915626e-02f, -4.83039916e-02f, 5.18425368e-02f, 3.44593190e-02f, 7.83346519e-02f,
  5.14843091e-02f, 3.87963951e-02f, -2.72204354e-02f, -1.04929902e-01f, -2.81254537e-02f, 9.38553642e-03f, -5.23847938e-02f, 4.58877794e-02f, 1.03569880e-01f, -3.37709971e-02f,
  -5.92533052e-02f, 1.18170865e-01f, 7.22016245e-02f, -3.36230583e-02f, 7.87770599e-02f, 2.04855064e-03f, 3.45106386e-02f, -7.55296946e-02f, 5.82399517e-02f, -1.16058506e-01f,
  1.41339907e-02f, -1.39331594e-01f, -1.00362942e-01f, 1.36406943e-02f, -1.45634547e-01f, 4.40116562e-02f, -3.87514643e-02f, -6.77004829e-02f, -1.10924385e-01f, 5.18314913e-02f,
  -1.05720088e-01f, 6.57162666e-02f, 2.70189028e-02f, -3.37886885e-02f, -1.07735015e-01f, -1.45115806e-02f, 1.73588004e-02f, -4.23646979e-02f, 2.09959168e-02f, 6.33111075e-02f,
  2.29214672e-02f, -1.25900665e-02f, -6.19984828e-02f, 2.49487311e-02f, 8.61490294e-02f, -2.44188234e-02f, 2.35878658e-02f, 4.68325131e-02f, -6.07869634e-03f, -5.21862172e-02f,
  -3.74322124e-02f, -3.87347862e-02f, -3.94064970e-02f, 7.99207538e-02f, -4.53162156e-02f, -1.30565539e-02f, -3.80099379e-02f, 9.18838456e-02f, 3.63789424e-02f, -1.05234459e-02f,
  7.53306821e-02f, 4.41950783e-02f, 2.62705460e-02f, -4.83203046e-02f, -9.52309892e-02f, -7.09225759e-02f, -3.40417288e-02f, 1.01768551e-02f, -6.34540990e-02f, 2.86104716e-02f,
  1.12524154e-02f, -5.43158539e-02f, -3.28489803e-02f, 7.09722564e-02f, 4.35138354e-03f, 6.19702004e-02f, 6.02837931e-03f, 3.18175065e-04f, 5.15942462e-02f, 7.89400116e-02f,
  -7.43826032e-02f, -7.29761794e-02f, -1.62972361e-02f, -4.81842719e-02f, -5.64697310e-02f, 5.32245124e-03f, 6.98694438e-02f, 8.89599472e-02f, 8.93320292e-02f, -5.17144240e-02f,
  -6.05572686e-02f, 7.37852454e-02f, -8.00948516e-02f, -5.09458631e-02f, 6.72943592e-02f, -1.98300015e-02f, 6.82854503e-02f, -4.38584052e-02f, 2.90988479e-02f, -6.14179224e-02f,
  4.59741242e-02f, -7.87586570e-02f, 5.59332706e-02f, -4.18903530e-02f, -3.36640738e-02f, -2.35459991e-02f, 5.39015792e-02f, -5.74274138e-02f, 5.00955172e-02f, 3.88682857e-02f,
  2.84706466e-02f, 4.03983407e-02f, 7.85938874e-02f, -3.66266556e-02f, -2.69079525e-02f, -5.71886003e-02f, -1.73120908e-02f, 3.25073227e-02f, 7.32303783e-02f, -1.14329730e-03f,
  -6.32058606e-02f, 1.61667410e-02f, -5.03404923e-02f, 2.89936755e-02f, -6.83158934e-02f, -2.18172520e-01f, -1.02401741e-01f, -7.80761987e-03f, -4.24945764e-02f, 1.27519697e-01f,
  -1.74888242e-02f, 1.24935791e-01f, 2.76873391e-02f, 3.49739119e-02f, 1.06666043e-01f, 1.57751255e-02f, 1.34331957e-01f, -5.23332655e-02f, 2.94125662e-03f, 5.58365397e-02f,
  1.11141637e-01f, 9.31274667e-02f, 1.37481489e-03f, -5.44432215e-02f, 1.02421612e-01f, 9.28942040e-02f, 4.66466546e-02f, -1.66111458e-02f, -4.67927493e-02f, 2.84439120e-02f,
  -1.23561099e-02f, 3.21376771e-02f, 3.78753915e-02f, -3.75922285e-02f, -6.35924190e-02f, 3.90366395e-03f, -8.21291357e-02f, -9.52958018e-02f, -2.36718301e-02f, 1.38859153e-02f,
  -1.63482949e-02f, 7.23103434e-03f, 4.58833715e-03f, -4.25184928e-02f, -3.11000273e-02f, 6.76121796e-03f, 9.78467613e-02f, 5.12641333e-02f, -3.96030620e-02f, -9.04802382e-02f,
  3.83122116e-02f, -7.72054540e-03f, -4.16907743e-02f, 1.53457522e-02f, 1.80551870e-04f, 2.66866684e-02f, -9.02898610e-02f, 9.01916996e-03f, -2.95754075e-02f, -4.29815538e-02f,
  4.92063500e-02f, -7.75697753e-02f, -5.59540279e-02f, -3.41932736e-02f, 2.53916606e-02f, -8.85651410e-02f, 7.68728880e-03f, -1.02789300e-02f, 5.76742142e-02f, -4.77774665e-02f,
  -8.77592042e-02f, -7.10072219e-02f, 9.38841030e-02f, 5.70922643e-02f, 2.78345682e-02f, 5.95542695e-03f, -1.02226222e-02f, 4.90557253e-02f, -2.38025393e-02f, 4.24844846e-02f,
  3.70277278e-02f, -7.28588775e-02f, 5.92969321e-02f, -8.33954588e-02f, -2.21615518e-03f, 3.61460447e-02f, -2.11113356e-02f, 7.68984705e-02f, -4.31510024e-02f, 3.90758328e-02f,
  3.02992505e-03f, 8.49788487e-02f, -4.54740189e-02f, -8.18071440e-02f, -6.11545295e-02f, -7.72498026e-02f, 6.03217818e-02f, -1.52532393e-02f, -3.51370350e-02f, 7.36061409e-02f,
  8.95331800e-02f, 3.99660505e-02f, -4.85172309e-02f, 4.20490392e-02f, -6.55647814e-02f, 5.83200753e-02f, -5.08916937e-02f, 3.72872949e-02f, -3.89725715e-02f, -4.26018648e-02f,
  -5.23129143e-02f, -5.88071048e-02f, -5.20956982e-03f, -3.11858617e-02f, -5.06235473e-02f, 6.18933514e-02f, -8.54272954e-03f, 8.25068429e-02f, -3.17909867e-02f, -4.83160540e-02f,
  -4.64208648e-02f, -1.87636763e-02f, -2.52342969e-01f, 1.13302074e-01f, 1.87528178e-01f, 4.00777794e-02f, -4.04813215e-02f, 1.57358065e-01f, -3.19319172e-03f, 6.84849778e-03f,
  8.80540907e-02f, -1.42294794e-01f, -1.53832197e-01f, 1.66817531e-01f, 1.63363993e-01f, -8.17171037e-02f, 1.92977667e-01f, 7.88537487e-02f, -1.38141617e-01f, 4.19293679e-02f,
  -6.14639707e-02f, 2.03469276e-01f, -6.73737377e-02f, 1.85446754e-01f, 1.59959689e-01f, -9.26725715e-02f, 1.34489790e-01f, -1.07864663e-01f, 1.40201569e-01f, 1.77092254e-01f,
  5.20184971e-02f, -6.86235875e-02f, -9.42136496e-02f, 5.25037118e-04f, -2.12227157e-03f, -4.67977859e-02f, -1.05121776e-01f, -2.98843086e-02f, -3.51682603e-02f, -1.71545688e-02f,
  -4.38485071e-02f, -6.63567036e-02f, 3.56470831e-02f, 3.71682458e-02f, -5.32042643e-04f, -4.54408489e-02f, -4.53945026e-02f, 4.90693152e-02f, -5.43113090e-02f, -1.41456351e-01f,
  -3.99666317e-02f, 1.56270415e-02f, -1.84533428e-02f, -7.87537470e-02f, -7.10347295e-02f, 6.12345189e-02f, -3.48451808e-02f, -8.33757520e-02f, 6.34995922e-02f, -1.17164738e-02f,
  2.08209548e-02f, -6.82863072e-02f, -7.61891603e-02f, -3.49051505e-02f, 6.45926148e-02f, -1.22876195e-02f, -1.01657705e-02f, 2.74466667e-02f, 7.12842718e-02f, 8.60486925e-02f,
  -2.93147229e-02f, -5.96989430e-02f, 1.55276209e-02f, -6.24943003e-02f, -4.89819050e-02f, -5.87612949e-02f, 1.98722887e-03f, -3.40798087e-02f, 1.12477988e-02f, 2.23388318e-02f,
  -6.17080703e-02f, -4.39201742e-02f, -5.34993038e-02f, 5.73057532e-02f, 3.05043571e-02f, 7.35129789e-03f, 4.15298296e-03f, 2.52397731e-02f, -7.33095706e-02f, 3.84035036e-02f,
  1.05992593e-01f, -8.69468506e-03f, -3.99758399e-04f, 1.25381825e-02f, 7.61489049e-02f, 6.21102527e-02f, 4.20868993e-02f, 4.08220515e-02f, 1.40389455e-02f, -6.40269369e-02f,
  5.21377362e-02f, -4.73236591e-02f, -5.55578992e-02f, 3.89988497e-02f, 9.95863080e-02f, 3.55577804e-02f, -9.35891494e-02f, 4.34595942e-02f, 6.84528872e-02f, 4.79200333e-02f,
  4.28939164e-02f, 7.66586214e-02f, 6.38345033e-02f, 8.13049078e-02f, 1.02751970e-01f, -8.21801946e-02f, 6.03527799e-02f, 8.01485404e-03f, 3.85926925e-02f, 7.52762109e-02f,
  -2.28923429e-02f, 2.71880403e-02f, 1.88449696e-01f, -8.80290717e-02f, 2.40315814e-02f, 1.39568463e-01f, 1.91617534e-01f, -9.54417139e-02f, -8.45346600e-03f, -1.14059456e-01f,
  -9.98896509e-02f, -1.39119336e-02f, 1.44980073e-01f, -5.16183674e-02f, 1.60878211e-01f, 5.27015962e-02f, 7.45786296e-04f, -2.45823395e-02f, -2.09773127e-02f, 1.83466710e-02f,
  8.57628286e-02f, -3.48527730e-02f, 6.69567883e-02f, -1.04442127e-01f, 3.02841868e-02f, -3.74751240e-02f, -1.13735862e-01f, 1.13834161e-02f, -9.19932872e-02f, 7.76134282e-02f,
  -1.22887179e-01f, -5.17897494e-03f, -5.64537197e-02f, 1.78198051e-02f, 2.39683297e-02f, -3.70449238e-02f, 4.08780798e-02f, -9.47358180e-03f, -6.61310032e-02f, 5.91303632e-02f,
  2.59660487e-03f, -3.48394504e-03f, -8.71048868e-03f, -5.13842702e-03f, -5.94354123e-02f, 4.97196466e-02f, 3.66485305e-02f, -1.22728506e-02f, -3.27432789e-02f, -2.89216638e-02f,
  -5.70777208e-02f, 2.39751786e-02f, -4.36730050e-02f, -1.28845014e-02f, -1.65416971e-02f, -8.22295919e-02f, -6.79722950e-02f, 1.26505628e-01f, 7.15313554e-02f, 1.22206528e-02f,
  -3.75160202e-02f, 3.15415449e-02f, -8.51532444e-02f, 2.74503268e-02f, 7.18287304e-02f, -8.43103826e-02f, -1.69040319e-02f, 6.17759526e-02f, 1.06840506e-01f, -6.21645600e-02f,
  -5.84048731e-03f, -6.52910024e-02f, -3.41708586e-02f, 6.77252933e-02f, -4.10146965e-03f, -6.95559755e-02f, 7.16395453e-02f, -7.94308856e-02f, -3.72170433e-02f, -7.49666467e-02f,
  4.91999052e-02f, -2.48629749e-02f, -7.86016732e-02f, -6.12423010e-02f, -9.53256413e-02f, -1.11396611e-02f, 1.74413286e-02f, 5.33516482e-02f, 9.47899884e-04f, 1.18006580e-01f,
  -3.82991917e-02f, -7.43215159e-02f, -3.72459851e-02f, -4.77846600e-02f, -1.16504822e-02f, -7.99850002e-02f, 8.61190334e-02f, -8.47630799e-02f, -2.70636939e-03f, 7.94488192e-02f,
  -6.55813664e-02f, 1.70997940e-02f, -1.04637835e-02f, 2.52016224e-02f, -4.17925678e-02f, -9.06041190e-02f, -6.19018897e-02f, -1.48629760e-02f, -5.25247306e-02f, 5.09590991e-02f,
  8.68168543e-04f, 5.85297197e-02f, 6.42143935e-02f, -7.60041028e-02f, -2.09083501e-02f, -2.37356573e-02f, -8.74291509e-02f, -7.21181482e-02f, 2.84962766e-02f, -1.74178630e-02f,
  -3.39067101e-01f, 8.04869905e-02f, -6.63161501e-02f, -3.18211466e-02f, -1.38382213e-02f, 6.40889779e-02f, 7.91958049e-02f, 7.25181103e-02f, -1.47093549e-01f, 9.69204828e-02f,
  5.13986163e-02f, -2.03950480e-01f, 1.32055148e-01f, -9.27067026e-02f, -1.91143572e-01f, -4.45667654e-02f, -1.36408120e-01f, -8.36070850e-02f, -1.14154719e-01f, 4.56384532e-02f,
  -1.36503249e-01f, -1.41889304e-01f, -1.84910432e-01f, 8.75560045e-02f, 2.67193653e-02f, 2.01469678e-02f, -1.46885976e-01f, 6.46811053e-02f, -6.11783098e-03f, 1.33817038e-02f,
  -2.75685731e-02f, -4.82160114e-02f, 6.50889277e-02f, -1.40642039e-02f, 1.21163521e-02f, 1.24463663e-02f, -6.55625314e-02f, 5.61627373e-02f, 2.73369756e-02f, -1.08241318e-02f,
  -5.97940460e-02f, -7.52251372e-02f, -5.47434203e-02f, 6.34917989e-02f, -5.84348757e-03f, 7.56847560e-02f, -2.61514317e-02f, 6.20140135e-02f, -2.22345646e-02f, 6.08248077e-02f,
  5.98827377e-02f, -4.69398387e-02f, 4.16924320e-02f, -9.40207094e-02f, -1.33130495e-02f, 1.81649793e-02f, -1.31072775e-01f, -5.62392035e-03f, 1.39459837e-02f, -9.80277881e-02f,
  1.09436261e-02f, -9.74039920e-03f, -2.97991149e-02f, 1.00296000e-02f, 1.96393300e-02f, -3.26976776e-02f, -7.60794105e-03f, -5.65089919e-02f, -2.64053345e-02f, -2.19388884e-02f,
  -4.87774871e-02f, 9.74740274e-03f, -6.71084151e-02f, 1.57662854e-02f, 1.02119548e-02f, -6.38051704e-02f, -2.88498998e-02f, 6.77522346e-02f, -8.00313056e-02f, 5.32885268e-02f,
  -1.56109622e-02f, -5.85222095e-02f, 2.83860713e-02f, -1.91887785e-02f, -1.14391288e-02f, -5.98449707e-02f, 4.79920283e-02f, 1.00281149e-01f, 7.62578920e-02f, 2.49660537e-02f,
  -5.42246960e-02f, -4.95789386e-02f, 4.79556853e-03f, -3.70922871e-02f, 9.49540138e-02f, 8.16618279e-03f, 5.13838753e-02f, -1.03815377e-01f, 5.72614335e-02f, 2.82000192e-02f,
  -5.57601377e-02f, -5.70860021e-02f, -2.57020555e-02f, -4.47640494e-02f, 2.22465806e-02f, -5.02545051e-02f, -5.18077835e-02f, -5.95265105e-02f, -3.61287594e-02f, -5.19912988e-02f,
  4.87118028e-03f, -1.27542382e-02f, -8.79851729e-02f, -1.84743553e-02f, -4.75857183e-02f, -8.26874077e-02f, 3.08754332e-02f, -8.05874914e-02f, 3.06778103e-02f, -7.40975738e-02f,
  -1.00271225e-01f, 1.68013945e-01f, -7.97418803e-02f, -4.77129081e-03f, -9.26460624e-02f, -3.80606693e-03f, 1.31309152e-01f, -6.86675236e-02f, 1.64190292e-01f, 1.60138220e-01f,
  6.39696419e-02f, -2.28473749e-02f, -3.96210551e-02f, -1.44530991e-02f, 3.47349942e-02f, 9.30920839e-02f, 1.54435664e-01f, 6.10508956e-02f, 3.23379450e-02f, 4.93480526e-02f,
  -4.09086759e-04f, 4.88984026e-02f, -5.77371344e-02f, -1.43851399e-01f, 3.76616530e-02f, -4.07685637e-02f, 5.96126840e-02f, -5.27221709e-02f, -1.94367021e-02f, 8.03501755e-02f,
  -6.05413578e-02f, -5.87806068e-02f, -1.21456422e-01f, -9.16793868e-02f, -3.95382978e-02f, -1.13024980e-01f, -8.19114596e-02f, -7.46024679e-03f, -3.74495378e-03f, -5.82480654e-02f,
  3.42102647e-02f, -1.20342165e-01f, 3.42224762e-02f, 7.72741660e-02f, 8.44277665e-02f, 2.44339760e-02f, -5.66132367e-02f, -4.06695455e-02f, -2.45880149e-02f, -6.39520809e-02f,
  -1.11052528e-01f, 5.59280515e-02f, 1.59872770e-02f, 9.69535783e-02f, 5.95511757e-02f, -1.59819406e-02f, -8.19776058e-02f, -1.73363555e-02f, 3.33326794e-02f, 4.16792259e-02f,
  1.91297699e-02f, -2.43586544e-02f, 6.74996451e-02f, 1.94388535e-02f, 4.17956188e-02f, 7.31057078e-02f, -4.57030758e-02f, -1.37494737e-02f, 7.41385818e-02f, -7.16169924e-02f,
  8.10503513e-02f, 8.93553719e-02f, 2.56051254e-02f, 6.31989613e-02f, -5.41574247e-02f, 1.98842734e-02f, -4.01128754e-02f, -8.01238194e-02f, 7.96436146e-02f, 6.14599809e-02f,
  1.94510855e-02f, -1.69283226e-02f, -2.31284816e-02f, -3.73652466e-02f, 2.34560557e-02f, -7.48719275e-02f, 6.67808950e-02f, -5.01598231e-02f, 2.16356292e-02f, -1.50625966e-02f,
  -1.84655171e-02f, 1.09759957e-01f, 1.97117273e-02f, 1.27656879e-02f, -7.58329630e-02f, 2.83375736e-02f, 4.64867167e-02f, 4.93533164e-02f, 5.84462658e-02f, 4.11599912e-02f,
  -4.31453362e-02f, -4.94030267e-02f, -5.24344966e-02f, -4.34541218e-02f, 2.21893489e-02f, 2.05255374e-02f, -1.41267795e-02f, 1.05505370e-01f, 2.15868489e-03f, -1.72706619e-02f,
  4.00763899e-02f, 2.06339415e-02f, 6.69764578e-02f, -3.80321667e-02f, -2.29606722e-02f, -4.18361276e-02f, 3.97125483e-02f, -5.59822582e-02f, 7.53009990e-02f, 5.58236167e-02f,
  2.05591112e-01f, -2.68020332e-02f, -4.51295786e-02f, 1.95920598e-02f, -1.02109693e-01f, -2.00355984e-02f, -1.38684973e-01f, -1.23959541e-01f, -9.60851982e-02f, 3.07636652e-02f,
  -5.72612546e-02f, -5.60302921e-02f, 7.92700611e-03f, -6.62634969e-02f, -2.97280345e-02f, 5.72267324e-02f, 5.29073067e-02f, -8.92737284e-02f, 8.15930218e-02f, -1.56934764e-02f,
  3.86803702e-04f, -8.55660997e-03f, 1.00465350e-01f, 3.36998627e-02f, 8.51921514e-02f, 4.90647331e-02f, 5.18802367e-02f, 4.00294363e-03f, -5.74383587e-02f, -5.31259105e-02f,
  8.17296281e-02f, -1.23329777e-02f, 4.64665443e-02f, 1.22309171e-01f, 2.70715021e-02f, -6.56855851e-02f, 3.09900697e-02f, 1.67164784e-02f, 2.53783390e-02f, -1.75765308e-03f,
  -3.60947587e-02f, -7.79610220e-03f, 1.28078330e-02f, -4.86717448e-02f, -3.85732315e-02f, -1.07475603e-02f, 1.54744033e-02f, -8.18112865e-02f, -7.78323039e-02f, 6.07763827e-02f,
  -7.01753348e-02f, -6.73025623e-02f, -6.94660097e-02f, -1.00315444e-01f, -8.88836086e-02f, -7.09760711e-02f, 2.45879516e-02f, 3.21611986e-02f, -8.81779119e-02f, -2.13230066e-02f,
  1.05703682e-01f, -9.36747789e-02f, 6.59669787e-02f, 3.84965837e-02f, 3.96807007e-02f, -1.91396940e-02f, 7.63086677e-02f, 2.49793250e-02f, 6.65479898e-02f, -8.65335539e-02f,
  4.20435891e-03f, 2.63559334e-02f, 3.27292494e-02f, 4.01173271e-02f, 3.37750837e-02f, -7.65384138e-02f, 7.73089156e-02f, 5.76314889e-02f, 1.86937302e-02f, -2.19958872e-02f,
  -8.00639391e-02f, 5.77488802e-02f, 8.25382397e-02f, 5.74410185e-02f, 1.37188220e-02f, 1.11457659e-02f, -8.30232054e-02f, -8.71467292e-02f, 3.41556892e-02f, 6.99954852e-02f,
  1.07591957e-01f, 2.89428439e-02f, 6.24477603e-02f, 5.55966720e-02f, 5.64190708e-02f, 8.67486447e-02f, 7.24833533e-02f, 3.12148612e-02f, 1.43938670e-02f, 8.33739042e-02f,
  4.53019254e-02f, 2.80803982e-02f, 7.62752965e-02f, -3.43832672e-02f, -6.62550479e-02f, -1.69916544e-02f, 8.84735808e-02f, -5.56034930e-02f, 7.85157755e-02f, 4.86388877e-02f,
  -4.87094782e-02f, 7.82418475e-02f, 4.29532491e-02f, 5.71055636e-02f, -2.73034386e-02f, 7.68349245e-02f, -7.04471022e-02f, 5.78335114e-03f, 1.03894435e-03f, 1.61018744e-02f,
  -1.84196323e-01f, 9.56149623e-02f, 1.29836679e-01f, 1.48821428e-01f, -7.11531639e-02f, 1.84280664e-01f, 2.18338251e-01f, -1.17613096e-02f, 2.01802671e-01f, 6.66115955e-02f,
  1.34542570e-01f, 1.05045699e-01f, 6.18674792e-02f, 3.75393890e-02f, 9.31354426e-03f, 8.40734690e-02f, 6.95379600e-02f, 6.28815591e-02f, -3.69770974e-02f, -8.08020011e-02f,
  -5.81617542e-02f, -1.89490300e-02f, 5.34927957e-02f, -4.67332229e-02f, -1.22098573e-01f, -1.03169844e-01f, -8.19587857e-02f, 4.51956540e-02f, 6.05651066e-02f, 1.23803072e-01f,
  9.40588582e-03f, -4.15352322e-02f, -4.65301350e-02f, 2.08001374e-03f, -4.04599309e-03f, -3.16771120e-02f, 4.02045958e-02f, 2.72569451e-02f, -1.26813501e-02f, -4.26387005e-02f,
  1.24917598e-02f, 9.85816494e-03f, 5.16905040e-02f, -2.29089111e-02f, -4.49850149e-02f, -6.63615465e-02f, -6.40909793e-03f, 4.75267731e-02f, 2.38115825e-02f, -1.43329725e-02f,
  1.14148734e-02f, 2.90080681e-02f, 1.15347803e-02f, 5.35608716e-02f, -6.14517964e-02f, 6.08975850e-02f, 8.36829916e-02f, -1.35478750e-02f, 8.32019839e-03f, -5.62873259e-02f,
  5.38149811e-02f, 6.71568960e-02f, -5.10962345e-02f, 4.91248025e-03f, 1.49420043e-02f, -1.92318186e-02f, 6.95552379e-02f, 7.03563169e-02f, -9.08783525e-02f, -4.19508852e-02f,
  3.25618982e-02f, -6.20167367e-02f, -2.63574962e-02f, -1.91109981e-02f, -5.28757833e-02f, -6.26084860e-03f, -9.97742116e-02f, -2.17422545e-02f, -4.87441160e-02f, -3.10626831e-02f,
  3.11429203e-02f, -7.05552578e-04f, -5.99094778e-02f, -6.49112836e-03f, -5.65651469e-02f, -1.63819436e-02f, -5.44960126e-02f, 3.16214077e-02f, -4.30334210e-02f, 8.84770378e-02f,
  1.80686101e-01f, 1.43456846e-01f, -7.33686462e-02f, -6.53966069e-02f, 8.89085978e-02f, -1.93913374e-02f, 3.78093347e-02f, -9.23314318e-02f, 1.01385385e-01f, -4.08937298e-02f,
  5.96583821e-02f, -7.73980021e-02f, 1.59976166e-02f, 3.23981456e-02f, 7.35557079e-02f, 6.17387053e-03f, 7.38203302e-02f, -3.28658670e-02f, 9.77900065e-03f, 3.67503762e-02f,
  1.47061190e-02f, -5.64347133e-02f, -1.10923104e-01f, -6.39914572e-02f, -7.60832280e-02f, 2.50665843e-02f, 5.62064536e-02f, 5.61928637e-02f, 2.65142880e-02f, 4.23780233e-02f,
  -2.07006067e-01f, -1.15474500e-01f, -1.12267084e-01f, -9.10445377e-02f, -1.00680189e-02f, -1.07013233e-01f, -1.88456118e-01f, -9.53780338e-02f, 9.96360704e-02f, -1.56530030e-02f,
  -2.56788405e-03f, -4.42158915e-02f, 6.61886111e-02f, -1.18450820e-01f, 1.55237764e-02f, 8.39621201e-02f, -2.08816662e-01f, -9.96427685e-02f, 1.08511023e-01f, -5.31205349e-02f,
  -1.63824260e-01f, -8.40408653e-02f, -6.28955886e-02f, -9.88794584e-03f, -2.01957211e-01f, 9.24361497e-03f, 3.45864743e-02f, -1.17963981e-02f, -1.11548893e-01f, -4.62929457e-02f,
  8.10633749e-02f, 1.14153653e-01f, 1.05852261e-01f, 6.86704814e-02f, -1.44192539e-02f, 3.17198150e-02f, -1.03113048e-01f, -2.84409430e-02f, 3.69049832e-02f, 8.97108242e-02f,
  2.63033365e-03f, 1.75892133e-02f, 3.69481335e-04f, -5.25696874e-02f, -1.68151818e-02f, -5.82130924e-02f, 5.87619767e-02f, 1.62821705e-03f, -7.58451894e-02f, -7.77581781e-02f,
  -8.58631954e-02f, -7.22324550e-02f, -1.33196175e-01f, 5.66081218e-02f, -1.12560041e-01f, -2.42727585e-02f, -1.13551430e-02f, 1.72329950e-03f, 7.65659958e-02f, -2.73382049e-02f,
  -3.75249013e-02f, -2.72442140e-02f, -1.57135595e-02f, 7.06323758e-02f, -5.01963496e-02f, 2.74944026e-02f, -1.03162080e-01f, 5.75031638e-02f, -1.48909288e-02f, -5.26530258e-02f,
  -4.80576530e-02f, -6.70534223e-02f, 3.93473469e-02f, -6.25318214e-02f, 5.12271840e-03f, 1.91590730e-02f, 6.76260442e-02f, 1.06390633e-01f, -9.11181271e-02f, 3.13069187e-02f,
  5.96201308e-02f, -3.64530943e-02f, 6.05703816e-02f, 7.61022866e-02f, 1.60694458e-02f, 3.91705148e-02f, -5.16984255e-05f, -8.46503749e-02f, 2.82922685e-02f, -5.86420968e-02f,
  1.91418584e-02f, -5.89255467e-02f, -1.88550949e-02f, 6.45512491e-02f, 6.01546653e-03f, -1.35192454e-01f, 5.03482819e-02f, -1.26458863e-02f, -2.15029120e-02f, -8.74409974e-02f,
  -3.92774791e-02f, -4.56334427e-02f, -8.72936174e-02f, 5.70514947e-02f, -6.99969893e-03f, -3.06444522e-02f, -5.60305221e-03f, -6.00822680e-02f, 6.02539368e-02f, -7.54664768e-04f,
  -3.33664045e-02f, 3.97380674e-03f, 7.51828309e-03f, 7.20849559e-02f, 2.20178347e-02f, -4.36289273e-02f, 5.23577519e-02f, 1.54880714e-02f, -4.12208913e-03f, 7.82619491e-02f,
  9.80178565e-02f, 6.67689666e-02f, 4.28402536e-02f, 5.85349053e-02f, 6.45652860e-02f, 6.34709001e-02f, 7.01006055e-02f, 1.63642559e-02f, 1.99135784e-02f, -1.07765853e-01f,
  -5.79240844e-02f, -5.96494712e-02f, 2.68356595e-02f, -2.81705428e-02f, 9.23297275e-03f, -8.19881260e-02f, 5.08565530e-02f, 2.08617616e-02f, 9.19653028e-02f, -9.45545435e-02f,
  5.93706928e-02f, 3.49999368e-02f, 1.66994855e-02f, -8.44031349e-02f, -5.10265268e-02f, -5.23984842e-02f, 1.28149176e-02f, -3.31848934e-02f, -1.28728822e-01f, -2.31215684e-03f,
  -2.48499047e-02f, -2.97194831e-02f, -3.25473817e-03f, 6.14158250e-02f, -6.27629459e-03f, 5.58389686e-02f, -2.73012239e-02f, -6.71700686e-02f, 9.75980163e-02f, 4.52865474e-02f,
  3.72250937e-02f, -2.60855556e-02f, 7.45061934e-02f, -1.53364660e-02f, 1.67504568e-02f, 2.94880643e-02f, 3.12740989e-02f, -3.31738554e-02f, -9.91573259e-02f, 4.08780798e-02f,
  7.61407316e-02f, -6.60484880e-02f, 8.94876495e-02f, -1.46786598e-02f, -7.61948004e-02f, -8.19897745e-03f, 7.69399777e-02f, 1.29200201e-02f, -2.92534232e-02f, 1.59730334e-02f,
  -3.08398698e-02f, -1.11319050e-02f, 7.70801604e-02f, 5.04532270e-02f, -1.87809728e-02f, -1.18045248e-02f, 7.62660056e-02f, -1.95484925e-02f, 7.55799338e-02f, 4.28990349e-02f,
  5.70426397e-02f, 7.16631785e-02f, 8.81571323e-02f, -5.90712503e-02f, 7.92334601e-02f, 8.09972361e-03f, -5.77068999e-02f, -7.40255937e-02f, 4.87974770e-02f, 3.92689556e-02f,
  3.47720012e-02f, -5.30665778e-02f, -3.04545392e-03f, 1.96944643e-02f, 1.03913106e-01f, 7.57559612e-02f, -7.81098679e-02f, -6.00414239e-02f, 5.21671399e-02f, -2.96840463e-02f,
  7.13601038e-02f, 6.49574846e-02f, 8.97691213e-03f, 3.91919427e-02f, -7.71699920e-02f, -8.49625319e-02f, -3.82460989e-02f, -9.03376564e-02f, 3.29175964e-02f, -6.10281043e-02f,
  2.05981061e-02f, -8.05939063e-02f, 8.40444788e-02f, 1.83192808e-02f, -5.53226210e-02f, -6.63344637e-02f, -6.15295023e-02f, 5.68343289e-02f, 6.63894415e-03f, 3.46981063e-02f,
  -7.10431784e-02f, 4.34202291e-02f, -4.62933667e-02f, 7.10805207e-02f, 9.53067988e-02f, -1.69304293e-02f, 3.04534342e-02f, -7.48534054e-02f, -7.45521113e-02f, 2.42331512e-02f,
  -5.68653308e-02f, 6.24554679e-02f, 3.77785340e-02f, -1.73407495e-01f, -4.40191738e-02f, -5.89491352e-02f, -1.49355367e-01f, -1.98398381e-02f, 1.22523466e-02f, 3.64481434e-02f,
  -8.27863738e-02f, 2.51736268e-02f, 8.59624669e-02f, -1.43788397e-01f, -8.91435668e-02f, 5.98932616e-02f, -9.88782719e-02f, 8.63107201e-03f, 1.14966035e-01f, -1.12615354e-01f,
  -3.17026749e-02f, 2.52469927e-02f, 1.77583974e-02f, 8.27744529e-02f, -3.69615853e-02f, -7.05562234e-02f, 6.32447898e-02f, -2.49568895e-02f, -1.02977820e-01f, 4.25725393e-02f,
  -5.04607335e-02f, 1.61509998e-02f, -8.11854526e-02f, 9.44117457e-03f, -3.53569188e-03f, -7.02012703e-02f, -6.70090094e-02f, 1.96609218e-02f, 4.22373898e-02f, -3.17997001e-02f,
  -1.10197432e-01f, 8.73215199e-02f, 3.36846076e-02f, 1.27413319e-02f, -5.46836182e-02f, -1.25428131e-02f, -1.91735271e-02f, 7.18487278e-02f, 8.50648880e-02f, -6.86503761e-03f,
  8.70201737e-02f, 6.77196011e-02f, -4.28474788e-03f, 7.31237456e-02f, 7.22816661e-02f, 7.34798238e-02f, -1.09548829e-01f, -9.32397619e-02f, -2.88727693e-02f, 3.77234146e-02f,
  7.68436342e-02f, -3.50687951e-02f, 9.35842544e-02f, 3.26927081e-02f, 4.95790131e-02f, -1.51506150e-02f, 6.28549904e-02f, -3.50073427e-02f, 6.06262088e-02f, -7.54928738e-02f,
  4.57114391e-02f, 9.13250446e-02f, -6.38746172e-02f, -3.19866277e-02f, -9.55776721e-02f, 2.85420604e-02f, 2.50075869e-02f, -4.05855477e-02f, 1.03840614e-02f, 2.59353220e-02f,
  5.72617091e-02f, 6.99740052e-02f, 8.28819349e-03f, -2.67551304e-03f, 2.43185144e-02f, 1.94837190e-02f, 3.44225019e-02f, 3.45556922e-02f, -8.18505585e-02f, 6.18842393e-02f,
  4.21078987e-02f, -6.32618964e-02f, 3.81661020e-02f, -1.98866986e-03f, -6.90969601e-02f, -3.20621207e-02f, -1.63151659e-02f, 1.27025768e-02f, -1.48549313e-02f, -9.20350477e-02f,
  -4.85801771e-02f, -1.60743743e-02f, 5.42520694e-02f, 6.78976476e-02f, 6.85219765e-02f, -3.21960226e-02f, 6.08315179e-03f, 5.93372509e-02f, -3.19382995e-02f, -2.04957724e-02f,
  -3.55953984e-02f, 8.06754902e-02f, -8.58705044e-02f, 3.23525257e-02f, 7.74722025e-02f, -7.89206028e-02f, -1.25442185e-02f, 3.03492434e-02f, -1.17004275e-01f, -4.42103259e-02f,
  1.72434170e-02f, -6.57587796e-02f, 1.26923203e-01f, 3.12162098e-02f, -6.21706769e-02f, 1.30038261e-01f, 6.26048893e-02f, -8.06524605e-02f, 1.02784842e-01f, 7.31272027e-02f,
  -1.67717580e-02f, 5.23252077e-02f, 6.77406490e-02f, 2.91555803e-02f, 1.39964625e-01f, -4.72994382e-03f, 5.13310768e-02f, -1.83741562e-02f, 6.41176328e-02f, 7.05435947e-02f,
  5.52808642e-02f, -3.58140990e-02f, -4.27011028e-02f, -1.04457170e-01f, -6.29162565e-02f, -4.19460721e-02f, -6.94772825e-02f, -1.98326763e-02f, -1.34737622e-02f, 4.83428389e-02f,
  3.06445220e-03f, -7.21220672e-02f, -7.94746727e-02f, -3.94147411e-02f, -7.29409009e-02f, 5.68809286e-02f, -2.69849841e-02f, -8.97514224e-02f, -5.15245795e-02f, -4.03747521e-02f,
  8.38319212e-02f, 2.39655972e-02f, -3.62726226e-02f, -6.82161003e-02f, 1.93645002e-03f, 6.14888482e-02f, -7.16164112e-02f, 5.37886433e-02f, 5.80304153e-02f, -5.22070602e-02f,
  -6.33418411e-02f, -7.02064708e-02f, 6.84283907e-03f, -9.59745571e-02f, 4.73860800e-02f, 5.13067702e-03f, 1.10545363e-02f, 3.48623004e-03f, 6.00126721e-02f, -6.93690181e-02f,
  2.24559829e-02f, -4.19834442e-02f, -4.05535512e-02f, 2.80303098e-02f, 3.66618149e-02f, -3.50568118e-03f, -1.10137118e-02f, 5.14643230e-02f, 6.95434734e-02f, 8.82477760e-02f,
  8.97914320e-02f, -3.13720480e-02f, 3.36630158e-02f, 7.85485953e-02f, -2.73223985e-02f, -4.91039492e-02f, -2.54670139e-02f, 1.55277718e-02f, 7.69704506e-02f, 8.14252719e-02f,
  -2.66262214e-03f, 5.73619828e-02f, -1.09244725e-02f, -2.68017165e-02f, 1.01515658e-01f, 2.30259076e-02f, 9.13796201e-03f, -7.85312653e-02f, -5.61697967e-02f, -1.46890646e-02f,
  9.24379006e-02f, 3.00121699e-02f, -1.56872359e-03f, 7.02434108e-02f, 4.62311916e-02f, -9.01870728e-02f, 2.53408700e-02f, -1.86566953e-02f, -4.62892614e-02f, -6.06506430e-02f,
  -1.32085178e-02f, -1.62243862e-02f, -6.86577410e-02f, -5.37738875e-02f, 3.41870300e-02f, -2.90320888e-02f, 7.64513239e-02f, -4.27359715e-03f, 1.15888221e-02f, -4.59593758e-02f,
  -4.77214949e-03f, 3.71417254e-02f, 1.94410849e-02f, -7.91168436e-02f, -1.70676243e-02f, -8.05138350e-02f, 7.41346832e-03f, 2.52458937e-02f, -7.85306543e-02f, -4.92510898e-03f,
  7.17328340e-02f, -5.43622375e-02f, 8.84572864e-02f, 2.01695666e-01f, 8.16810429e-02f, 6.95434809e-02f, 3.56215984e-02f, 2.86812857e-02f, 1.84400946e-01f, -1.42969012e-01f,
  -7.59845553e-03f, 3.34776491e-02f, -5.46621643e-02f, 8.12450722e-02f, 9.24953073e-02f, 7.75544439e-03f, 5.48182018e-02f, 6.62354380e-02f, 3.75485122e-02f, 7.45792240e-02f,
  1.01695068e-01f, -5.32227270e-02f, -6.83996752e-02f, -5.13990335e-02f, -9.83430771e-04f, -3.03536877e-02f, -7.62028396e-02f, -1.28169551e-01f, -7.54696354e-02f, -1.48007330e-02f,
  5.09859957e-02f, 1.23652793e-01f, 1.09482229e-01f, -4.98282872e-02f, -1.17514357e-02f, -8.33060220e-02f, 6.88711135e-03f, -3.53464782e-02f, -5.38217952e-04f, -9.98780131e-03f,
  -1.03547916e-01f, -1.00526445e-01f, 6.43838570e-02f, 5.11471033e-02f, -1.71247590e-02f, 2.32092869e-02f, 4.41155098e-02f, -2.66668089e-02f, -1.67172626e-02f, 9.39176232e-03f,
  5.37667284e-03f, -3.20215449e-02f, -5.46266697e-02f, -2.36037355e-02f, 5.25591858e-02f, -4.26671728e-02f, -3.91649490e-04f, -7.95731619e-02f, -1.10864371e-01f, 5.37101254e-02f,
  8.58974904e-02f, 6.87987357e-02f, -1.33441821e-01f, -7.58062825e-02f, -6.14183657e-02f, -3.73670608e-02f, -1.07751012e-01f, -1.65519733e-02f, 8.61056820e-02f, -5.41462786e-02f,
  -2.30919626e-02f, 6.52066544e-02f, 4.58673686e-02f, 7.86340535e-02f, -4.20200676e-02f, 4.58833463e-02f, -4.87251095e-02f, -9.74707454e-02f, 7.97331035e-02f, 5.82333989e-02f,
  2.83515416e-02f, 3.39681841e-02f, 2.52938690e-03f, -9.29574966e-02f, 1.24909710e-02f, -6.24642633e-02f, 1.80878583e-02f, 1.22792013e-01f, -9.69232321e-02f, 3.40755582e-02f,
  -1.25264585e-01f, 5.13732657e-02f, 3.93582582e-02f, 7.44368732e-02f, 6.34426698e-02f, -3.32178199e-03f, -6.90967366e-02f, 3.88977043e-02f, -7.60733709e-02f, -2.67847572e-02f,
  2.75725573e-02f, -4.65591103e-02f, 2.55365577e-02f, -6.96516484e-02f, 1.99998356e-02f, 2.90429201e-02f, -8.04869160e-02f, -2.73259021e-02f, -1.79988984e-02f, 5.51336771e-03f,
  -2.15909015e-02f, -9.76561978e-02f, 2.63619069e-02f, -7.18738660e-02f, 7.65630081e-02f, 4.90061752e-02f, -1.30323404e-02f, -6.13127947e-02f, -6.54296130e-02f, 5.15804663e-02f,
  -9.68980268e-02f, 5.80612458e-02f, -1.03645265e-01f, -2.15041250e-01f, 9.29990634e-02f, -8.61154869e-02f, -1.67445645e-01f, 3.66888829e-02f, -1.96300715e-01f, -1.68861330e-01f,
  -9.24536511e-02f, -9.63791832e-02f, -2.05204040e-02f, -1.32054314e-01f, 7.57136717e-02f, 6.86393678e-02f, -6.85455054e-02f, -1.12335615e-01f, 9.40977633e-02f, -2.43789423e-03f,
  -7.36766234e-02f, 7.57358298e-02f, 6.16250262e-02f, 1.11121155e-01f, 1.66981891e-02f, -4.88015637e-02f, -2.94648279e-02f, 6.86172023e-02f, -4.20984952e-03f, -6.67203143e-02f,
  -1.80452708e-02f, 5.71205057e-02f, -1.30920531e-03f, 2.81604682e-03f, 3.92136127e-02f, -5.21874763e-02f, 1.90405380e-02f, -5.70748374e-02f, -8.46142322e-03f, -6.99458271e-02f,
  -3.20948958e-02f, -6.72453865e-02f, -5.40037230e-02f, -1.44905942e-02f, -8.05684179e-02f, -9.27004311e-03f, -1.19876023e-02f, 7.92759005e-03f, -3.65082100e-02f, 2.82278750e-02f,
  6.88914582e-02f, 3.24801467e-02f, 6.81928918e-03f, -6.73610717e-03f, -8.36191997e-02f, -4.98348065e-02f, -2.09252872e-02f, -1.02462903e-01f, 4.94249836e-02f, -2.22005006e-02f,
  2.45121382e-02f, 3.64348851e-02f, 8.39089900e-02f, 3.74964327e-02f, 6.76288977e-02f, 4.52778563e-02f, -8.72577205e-02f, -5.26134670e-02f, -8.40241984e-02f, 3.20790187e-02f,
  -3.62140574e-02f, -3.06049902e-02f, -4.72142585e-02f, 4.27376330e-02f, 5.71554974e-02f, 1.42161101e-02f, 3.08346730e-02f, 2.89640147e-02f, 3.78098935e-02f, -1.23489194e-01f,
  9.43825617e-02f, 6.07825108e-02f, 4.34691086e-03f, -5.62918521e-02f, -1.53891128e-02f, 4.60358486e-02f, 2.07556970e-02f, -6.89763501e-02f, 7.92681500e-02f, -3.95448022e-02f,
  8.63303170e-02f, -6.28639236e-02f, 1.19795324e-02f, -3.52318026e-02f, -9.73391440e-03f, 1.09512662e-03f, 4.06768499e-03f, 3.08968145e-02f, -2.48564426e-02f, 5.70343658e-02f,
  -5.86928381e-03f, -5.46135157e-02f, -5.09229042e-02f, 5.13543375e-02f, -2.83930749e-02f, 4.27878052e-02f, 1.80305541e-02f, 2.18110140e-02f, -7.29671642e-02f, 8.43185112e-02f,
  -6.00701347e-02f, -6.88297451e-02f, 6.43332973e-02f, 4.97154146e-02f, 3.58792879e-02f, 2.20307782e-02f, -6.74472935e-03f, -3.48035283e-02f, 6.75661191e-02f, 3.60195823e-02f,
  6.71455264e-02f, 1.77342277e-02f, -2.63495483e-02f, 6.91371188e-02f, 9.89839658e-02f, 3.20953093e-02f, 3.15242633e-02f, 6.01080526e-03f, -4.79684882e-02f, 4.99642827e-02f,
  -4.83983103e-03f, -9.40498430e-03f, -6.16635494e-02f, -9.38762799e-02f, 5.14650065e-03f, -1.09859288e-01f, -6.75980970e-02f, -8.48756358e-02f, -8.16909503e-03f, 3.93866040e-02f,
  1.13144472e-01f, 1.34996921e-01f, -7.23682940e-02f, 1.31959081e-01f, 6.53963163e-03f, 5.63366488e-02f, 7.00184628e-02f, -5.97725995e-02f, 1.02116801e-01f, -6.26290888e-02f,
  -5.72404405e-03f, 2.05291919e-02f, 3.69774997e-02f, 4.11198102e-02f, 6.46114647e-02f, -1.46223260e-02f, -4.49188575e-02f, -6.68585673e-02f, 8.16192105e-02f, 7.81425387e-02f,
  4.16822592e-03f, 2.52304599e-02f, 5.04970849e-02f, 1.15498096e-01f, -5.15121669e-02f, 3.79909063e-03f, -5.22800945e-02f, 5.58097325e-02f, -5.38101327e-03f, 4.43192013e-02f,
  -9.09542143e-02f, -2.22285129e-02f, -4.17475700e-02f, 3.40628624e-02f, 6.21474423e-02f, 1.33905811e-02f, 7.04516992e-02f, -3.87305655e-02f, 1.02549037e-02f, 2.93291826e-02f,
  -2.04207860e-02f, -1.19698122e-02f, 2.85372697e-02f, 1.51136732e-02f, -1.01095941e-02f, -4.02970798e-02f, 4.69592027e-02f, 3.67443077e-02f, -5.82486019e-02f, -4.90354262e-02f,
  -2.08021142e-02f, 5.79863228e-02f, -3.14797983e-02f, 2.85678282e-02f, 6.09868839e-02f, -6.86610416e-02f, 1.32676270e-02f, -6.56980127e-02f, 2.54553370e-02f, -3.12572271e-02f,
  -5.68960458e-02f, -4.08423766e-02f, 1.25537589e-02f, -4.42181416e-02f, -9.95515361e-02f, 1.43186953e-02f, 1.59868151e-02f, 4.68724035e-02f, -5.54659702e-02f, -7.97525793e-02f,
  -1.36849023e-02f, -1.80829829e-03f, -6.02590516e-02f, -5.45964874e-02f, -2.92579960e-02f, -4.82680276e-02f, -6.48102164e-02f, -4.81590629e-02f, -1.48459151e-02f, 3.82069722e-02f,
  6.40546530e-02f, 2.05942653e-02f, 5.03803715e-02f, -3.20616812e-02f, -2.72018509e-03f, 1.04223460e-01f, 6.05098493e-02f, -2.40046103e-02f, -7.28136748e-02f, -1.30332345e-02f,
  -3.75843584e-03f, 6.74517676e-02f, -8.81139413e-02f, -8.44703615e-02f, 8.77192840e-02f, 5.95670529e-02f, 9.88422111e-02f, -2.70350091e-02f, 4.06274870e-02f, -3.79345194e-02f,
  1.48741931e-01f, -2.41858587e-01f, -5.95078431e-02f, 8.45907107e-02f, 2.05684498e-01f, 5.29474765e-03f, 4.74959761e-02f, -1.10382969e-02f, -5.12569882e-02f, -1.61051631e-01f,
  2.02658903e-02f, -1.06907420e-01f, -1.66166261e-01f, -2.28036586e-02f, 1.50488853e-01f, -3.10975332e-02f, 5.60042448e-02f, 6.91209361e-02f, 2.44212225e-02f, -8.48328620e-02f,
  4.68159243e-02f, 1.33368805e-01f, -3.21032740e-02f, 4.56909388e-02f, 8.48075002e-02f, -5.33155836e-02f, -7.78386891e-02f, -1.03735574e-01f, 7.18357936e-02f, 5.94770424e-02f,
  1.54736107e-02f, -4.03237753e-02f, 3.48009281e-02f, 1.74123105e-02f, 1.02738915e-02f, -3.79085690e-02f, -8.97011384e-02f, -3.91715951e-02f, -6.54345378e-02f, 5.67657426e-02f,
  -7.35926926e-02f, 8.61812830e-02f, 4.83082570e-02f, -1.13891009e-02f, 1.93092767e-02f, 4.59703915e-02f, -7.17106415e-03f, -4.92340177e-02f, -8.80332068e-02f, -4.07016054e-02f,
  -6.95137680e-02f, -3.21980231e-02f, 4.96898554e-02f, 5.21654971e-02f, -1.89932156e-02f, 1.11584783e-01f, -8.92011076e-02f, -1.15835695e-02f, -1.21582318e-02f, 8.53168219e-02f,
  7.10795939e-05f, -3.55178230e-02f, 9.98956151e-03f, 6.21423572e-02f, 8.77510774e-06f, 6.31046519e-02f, -3.40527892e-02f, -2.33512521e-02f, -8.31015930e-02f, -5.87581135e-02f,
  -1.46333165e-02f, 4.77281138e-02f, -4.79464978e-02f, 3.02053001e-02f, -3.23704258e-02f, -4.47405837e-02f, -4.93465774e-02f, -1.82988886e-02f, -2.09019240e-02f, -3.43489721e-02f,
  4.03805226e-02f, 1.28421709e-02f, -6.34710044e-02f, 3.89789455e-02f, -3.07678077e-02f, 6.49919882e-02f, 7.92337488e-03f, -5.32882363e-02f, -5.29783852e-02f, -5.41397557e-02f,
  -1.81494340e-01f, -1.14034146e-01f, 3.64465942e-03f, -8.75030532e-02f, -1.41444564e-01f, -1.00368060e-01f, -3.31134088e-02f, 1.12368846e-02f, -1.79293789e-02f, 3.78317870e-02f,
  2.48215208e-03f, -2.75316145e-02f, 1.83188394e-02f, -1.33693423e-02f, -3.65171023e-02f, -7.40861595e-02f, 5.59132732e-02f, -9.62254778e-02f, -1.04525641e-01f, 9.33977664e-02f,
  -6.64513409e-02f, 1.52135789e-02f, -3.05232015e-02f, 2.05340385e-02f, -2.33853813e-02f, -4.45810929e-02f, 5.64964116e-02f, -2.05497649e-02f, 1.64626576e-02f, 1.50440424e-03f,
  -5.82388006e-02f, 3.56975719e-02f, -1.93328951e-02f, -1.11645125e-01f, 8.08878168e-02f, -1.86303511e-01f, -1.14132553e-01f, -6.28034920e-02f, 3.87572795e-02f, -6.07689917e-02f,
  -6.80854321e-02f, -5.32220118e-02f, 1.90300234e-02f, -1.09152108e-01f, 5.77310659e-02f, 1.00964785e-01f, 4.34261095e-03f, -1.29641190e-01f, 1.08443573e-01f, -3.57389785e-02f,
  1.17721878e-01f, 8.02745968e-02f, 6.22890815e-02f, 1.07365616e-01f, 5.42322695e-02f, 1.04531817e-01f, 1.60564750e-01f, 1.12768814e-01f, 4.54997271e-02f, 7.62717724e-02f,
  -1.07443314e-02f, 2.16082390e-02f, -7.27475137e-02f, -7.96238780e-02f, -2.02787649e-02f, 6.19253665e-02f, -1.16191218e-02f, -5.32474602e-03f, -6.68624789e-02f, 4.96572107e-02f,
  5.89205734e-02f, 5.66227399e-02f, 2.61326935e-02f, 3.21866609e-02f, -2.34830938e-02f, 5.37644625e-02f, 7.79954121e-02f, 6.82830438e-02f, -6.21099770e-02f, 3.89549211e-02f,
  3.74000035e-02f, 7.94613436e-02f, -4.75952253e-02f, -6.53569475e-02f, -5.56595735e-02f, -1.86175108e-02f, -8.28988571e-03f, -3.30447666e-02f, -9.16758552e-03f, -4.36777547e-02f,
  4.80787084e-02f, -1.73176657e-02f, 3.33780572e-02f, 3.77044566e-02f, -2.58623976e-02f, -2.78769545e-02f, 2.87746228e-02f, -8.66507366e-03f, -3.20543423e-02f, -6.23330809e-02f,
  5.06528541e-02f, 6.43472522e-02f, -1.03053814e-02f, -4.59818281e-02f, 4.40197624e-03f, -6.23925105e-02f, -8.70076381e-03f, 5.02102785e-02f, -6.58969060e-02f, -2.18985807e-02f,
  -5.16668661e-03f, 6.14307784e-02f, -7.00649247e-02f, 5.80887124e-02f, 5.06744608e-02f, 4.81709428e-02f, -1.88193255e-04f, -1.75148770e-02f, -3.06558679e-03f, 2.12097284e-03f,
  7.31343776e-02f, 5.35039492e-02f, 7.51264840e-02f, -4.18143114e-03f, 1.10208499e-03f, -6.68149367e-02f, -4.08966951e-02f, 4.98743653e-02f, -3.78672220e-02f, 5.27825430e-02f,
  -7.38754347e-02f, 3.13788876e-02f, -3.80400121e-02f, -3.73173617e-02f, -1.81677770e-02f, -1.36926332e-02f, -4.84753307e-03f, -8.71858094e-03f, 9.17763114e-02f, -1.73495132e-02f,
  8.40035155e-02f, 1.69234984e-02f, -6.92059174e-02f, -2.97997072e-02f, -1.36315050e-02f, -9.00944173e-02f, 3.10273785e-02f, 2.71157939e-02f, 6.83264509e-02f, 4.58019748e-02f,
  1.18695043e-01f, -7.27412701e-02f, -2.86516156e-02f, -3.75170223e-02f, 2.45970823e-02f, 2.32877135e-02f, -1.18867733e-01f, -2.28292868e-02f, -3.26259024e-02f, 2.22250540e-02f,
  2.16263924e-02f, -1.46894157e-02f, 1.96972378e-02f, -1.30626246e-01f, 8.68043229e-02f, 4.93442155e-02f, -2.83416975e-02f, -6.35067299e-02f, -2.60219146e-02f, 4.09774333e-02f,
  -6.67337552e-02f, -1.00175098e-01f, -1.02350935e-01f, -3.97187658e-02f, -8.07151869e-02f, -1.31132066e-01f, 1.78763997e-02f, -1.46470182e-02f, -7.38795698e-02f, 1.68384216e-03f,
  -1.25736222e-02f, 7.63164163e-02f, 1.46164093e-02f, 7.69307613e-02f, 1.08016498e-01f, 2.59010550e-02f, -4.93797548e-02f, -6.12436607e-02f, 1.06773758e-02f, 9.21808463e-03f,
  -4.37893867e-02f, -2.18752176e-02f, 6.33396730e-02f, 5.33508733e-02f, -8.35163817e-02f, -7.91713446e-02f, -5.35101220e-02f, -6.97140098e-02f, -8.91353562e-02f, -2.44416967e-02f,
  -7.69651011e-02f, -4.11965922e-02f, -8.50493684e-02f, -2.89977938e-02f, 2.00122762e-02f, -2.14063562e-02f, -5.07097580e-02f, 1.93832293e-02f, -7.40331188e-02f, 8.01287293e-02f,
  1.22330815e-01f, -9.15393531e-02f, -2.82806326e-02f, 8.85921270e-02f, -4.10075253e-03f, 4.77996171e-02f, 5.32957586e-03f, 1.07043814e-02f, -8.39772727e-03f, -5.89443464e-03f,
  -4.17517312e-02f, -1.17342127e-02f, -7.57420063e-02f, -4.92188334e-03f, 1.46926902e-02f, 5.77908419e-02f, 1.86346658e-02f, 8.02341104e-02f, -5.19980788e-02f, 4.80746552e-02f,
  6.83622211e-02f, -1.25132650e-02f, 7.62277632e-04f, 7.48352241e-03f, 3.57305184e-02f, -5.69223911e-02f, -8.78667384e-02f, -2.88667772e-02f, 2.23605689e-02f, 8.34447667e-02f,
  8.11732635e-02f, 9.80916396e-02f, 5.12988083e-02f, 1.13340728e-02f, 9.09236968e-02f, -2.37211660e-02f, -6.46247342e-02f, -5.15706353e-02f, 1.09548844e-01f, 9.27359164e-02f,
  8.22299793e-02f, -2.52586044e-03f, 1.01508480e-02f, 1.89641342e-02f, -1.08813673e-01f, 1.45766791e-02f, 7.80545846e-02f, 4.80454601e-02f, 8.73637199e-02f, -4.26114313e-02f,
  -9.07449350e-02f, -2.68772785e-02f, 4.35918495e-02f, -1.08841814e-01f, -1.37567325e-02f, 3.27154547e-02f, -1.18381027e-02f, 3.87032032e-02f, 1.52434893e-02f, 1.09289810e-02f,
  -3.73470485e-02f, 4.02413681e-02f, -3.09272967e-02f, 6.45139143e-02f, 5.86221972e-03f, -5.07883392e-02f, -1.46324769e-01f, 5.18850349e-02f, 1.33758914e-02f, 1.15058310e-01f,
  -3.67052257e-02f, -8.07346553e-02f, -4.31907848e-02f, 5.81775941e-02f, -6.72173277e-02f, -3.03797740e-02f, -7.11417496e-02f, 4.69894744e-02f, -8.16012025e-02f, 7.73681104e-02f,
  -5.84402457e-02f, 4.89633903e-02f, 1.83352306e-02f, -5.41365929e-02f, -2.31737718e-02f, 6.39422983e-02f, 4.51637758e-03f, 3.93211842e-02f, 4.16738130e-02f, 5.59686758e-02f,
  -1.04687423e-01f, 6.20808415e-02f, -8.52414966e-03f, -1.21095274e-02f, -1.62303317e-02f, -3.74135817e-03f, -2.53651049e-02f, -1.26542732e-01f, 7.70098940e-02f, -4.50405627e-02f,
  2.44532302e-02f, -9.44760144e-02f, 3.71612906e-02f, 4.34457064e-02f, -6.25954494e-02f, -2.16800161e-02f, -7.31777549e-02f, 2.30611768e-02f, 8.21772777e-03f, 6.36903867e-02f,
  5.14995828e-02f, 3.46470252e-02f, 2.91971210e-02f, -3.77552793e-03f, -4.25209850e-02f, 6.27105162e-02f, 1.62739884e-02f, 7.88485557e-02f, 3.38390730e-02f, -7.44541213e-02f,
  -2.25276668e-02f, 4.45260555e-02f, 1.10001490e-01f, 3.25513966e-02f, -7.07130805e-02f, -5.45727313e-02f, -4.81111743e-02f, 5.98282814e-02f, 2.65823621e-02f, 4.90707345e-02f,
  -6.34162575e-02f, 3.35601531e-02f, 3.68487276e-02f, 9.12210122e-02f, 8.86080265e-02f, -6.12358563e-02f, 7.94529542e-02f, -2.22874503e-03f, -8.79664943e-02f, -9.28296670e-02f,
  -7.78401643e-02f, -9.56016220e-03f, -4.62386087e-02f, 2.92689502e-02f, 4.68684100e-02f, 6.05904534e-02f, 1.29423477e-02f, -6.04549088e-02f, -1.65673695e-03f, 3.12910564e-02f,
  -6.94000125e-02f, -5.19187748e-02f, 5.74470051e-02f, 6.36624098e-02f, -5.11742644e-02f, 4.67923516e-03f, -9.84741957e-04f, -2.03399621e-02f, -6.62653223e-02f, -6.07903525e-02f,
  9.97444540e-02f, -5.48225548e-03f, 4.81127165e-02f, -1.38747562e-02f, -4.24242578e-02f, 6.35086074e-02f, -4.94785197e-02f, -6.27395930e-03f, 1.10070005e-01f, 3.86394449e-02f,
  1.57802179e-02f, 9.16028172e-02f, 4.41960692e-02f, 9.56082810e-03f, -1.02382936e-02f, 5.71923293e-02f, 5.34592308e-02f, -4.14188281e-02f, -3.68585959e-02f, 2.37489026e-02f,
  1.75290015e-02f, 2.53809970e-02f, 1.03086546e-01f, -9.04172137e-02f, 1.10631205e-01f, 7.33718090e-03f, 9.61279422e-02f, 1.11384138e-01f, 2.76267044e-02f, -4.59355600e-02f,
  -1.41612679e-01f, -3.44036780e-02f, -1.13825880e-01f, -1.47318497e-01f, -1.93027601e-01f, -1.12736449e-01f, -5.73900603e-02f, 3.60112749e-02f, 7.52100945e-02f, -2.28316314e-03f,
  -3.10920440e-02f, -7.94056430e-02f, 3.82602215e-02f, 1.95896775e-02f, 1.15809262e-01f, 1.12613276e-01f, -9.16892663e-03f, 1.05874829e-01f, 1.75820813e-02f, -6.34411126e-02f,
  -7.07571730e-02f, 1.57015435e-02f, -2.23626215e-02f, 6.40640222e-03f, -1.84863131e-03f, -7.86051806e-03f, 2.72359699e-03f, -9.08383653e-02f, -3.77117582e-02f, 4.68523204e-02f,
  3.50956768e-02f, -6.75027966e-02f, -5.93598969e-02f, 1.16070313e-02f, -1.12421056e-02f, 4.54781689e-02f, 3.12717669e-02f, 1.04454167e-01f, -8.75565875e-03f, 8.99436250e-02f,
  -2.13384815e-02f, 4.03999686e-02f, 6.55774102e-02f, -1.73000805e-02f, -6.98751882e-02f, -4.09677718e-03f, -7.26525411e-02f, -9.04473849e-03f, -6.92651421e-02f, -7.12790340e-02f,
  5.98792769e-02f, 6.57508448e-02f, 3.05400626e-03f, 4.80294414e-02f, -7.92629868e-02f, -3.55404690e-02f, -8.15310515e-03f, 4.34682481e-02f, -1.88691653e-02f, -8.93377326e-03f,
  4.58346531e-02f, 8.30272511e-02f, -6.97616413e-02f, -4.47414815e-02f, -8.25600401e-02f, -4.19827774e-02f, -8.43956508e-03f, -9.16407630e-02f, -4.33523441e-03f, 1.04752295e-01f,
  2.19667403e-04f, -4.65375856e-02f, 4.46873046e-02f, -6.36700243e-02f, -1.09393194e-01f, -8.09600726e-02f, 8.00574198e-02f, -4.28041071e-02f, -6.78312257e-02f, 4.12741713e-02f,
  -1.43417224e-01f, -1.67425185e-01f, 5.87567203e-02f, -4.55495305e-02f, 1.34625295e-02f, -8.14598873e-02f, -5.35094291e-02f, 5.26390560e-02f, -9.15847495e-02f, -6.74537718e-02f,
  -1.07394783e-02f, 6.63266182e-02f, -6.65008277e-02f, -1.40123619e-02f, 6.34771213e-02f, 6.66174153e-03f, -1.24084860e-01f, -7.59889260e-02f, 1.71225723e-02f, -2.06091478e-02f,
  -3.24851088e-02f, -1.01438187e-01f, -4.84739318e-02f, -3.96742709e-02f, 3.77619825e-02f, -7.86158666e-02f, -9.32403374e-03f, 9.28712115e-02f, 2.96444390e-02f, 1.76289771e-02f,
  -1.12966515e-01f, 3.98660265e-02f, -2.29745060e-02f, 5.51747531e-02f, -7.73955211e-02f, -7.39569440e-02f, 6.48735017e-02f, -8.73427019e-02f, -6.34177625e-02f, 2.21257843e-02f,
  6.72008172e-02f, -1.08586453e-01f, 4.71755490e-02f, -1.00689888e-01f, -6.63001388e-02f, -5.17579820e-03f, -5.45013584e-02f, 2.80317068e-02f, 5.90975881e-02f, 2.86241621e-02f,
  -3.55203487e-02f, 6.00522421e-02f, -8.01829323e-02f, 3.91079821e-02f, -1.06120534e-01f, 3.50579284e-02f, -2.58808769e-02f, 6.33692443e-02f, -6.36797622e-02f, 6.31792471e-02f,
  7.10960254e-02f, 4.15039388e-03f, -4.86611761e-02f, -1.00565866e-01f, -5.62204272e-02f, -5.75970858e-02f, -4.58518714e-02f, -1.05950199e-02f, -6.63487017e-02f, -4.42593619e-02f,
  4.66050655e-02f, 5.98259754e-02f, 9.83655602e-02f, -4.50796597e-02f, 4.41993214e-02f, -3.50821167e-02f, 6.67215660e-02f, -5.75350635e-02f, 4.72748503e-02f, 5.87353110e-02f,
  -5.65104224e-02f, -8.28304216e-02f, -1.11180380e-01f, -4.81380597e-02f, 5.16337492e-02f, 5.41005582e-02f, 6.61729798e-02f, -5.38636968e-02f, -3.94528136e-02f, 3.26853953e-02f,
  -8.27781409e-02f, 4.14597616e-02f, -4.85849641e-02f, 6.13196790e-02f, -1.07826218e-01f, 6.73745573e-02f, 7.13478681e-03f, 8.38187039e-02f, 3.84719893e-02f, 6.13547750e-02f,
  -2.87331566e-02f, -1.88204588e-03f, -2.39625163e-02f, -9.97176394e-02f, -4.55975607e-02f, 1.32792696e-01f, -1.42092826e-02f, -4.28110659e-02f, -7.89070278e-02f, 7.37561360e-02f,
  3.27724405e-02f, -5.18013500e-02f, -1.80333853e-02f, 1.02862902e-01f, 9.43499878e-02f, 5.42496555e-02f, 7.69740194e-02f, 8.71566534e-02f, 1.07333278e-02f, 4.53933403e-02f,
  -5.68439290e-02f, -7.19788149e-02f, 9.54141319e-02f, 9.30607393e-02f, 5.28789125e-02f, 3.89838405e-02f, 1.26601616e-02f, 9.14372802e-02f, 4.38141488e-02f, -2.71867812e-02f,
  4.61229794e-02f, 5.71587980e-02f, -2.04536635e-02f, -5.35695255e-03f, 8.65644217e-02f, -2.95053720e-02f, -2.10348777e-02f, -2.84528863e-02f, 4.80307713e-02f, -7.37292925e-03f,
  -6.69173226e-02f, 2.69399062e-02f, 4.44864929e-02f, 8.25171452e-03f, -5.38801365e-02f, 3.49072516e-02f, 5.86451404e-02f, 4.24972400e-02f, -3.51569541e-02f, 5.95152006e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.07925989e-01f, 1.00088947e-01f, 4.38521393e-02f, 5.92775941e-02f, 7.56108537e-02f, -6.80256402e-03f, 2.36288622e-01f, 3.54991923e-03f, 4.85249497e-02f, 1.43434271e-01f,
  1.78936999e-02f, -5.14854677e-02f, -2.14657504e-02f, 1.07888035e-01f, 1.26986206e-01f, 3.81065235e-02f, 1.66442990e-01f, 1.58631399e-01f, 1.04698896e-01f, -4.44576852e-02f,
  8.89135897e-02f, -2.37789340e-02f, 1.13908872e-01f, 1.86872423e-01f, 1.62086442e-01f, -4.26022895e-02f, 1.04416229e-01f, 5.65716997e-02f, 3.21128964e-02f, 1.69674501e-01f,
  3.39832976e-02f, 1.29652619e-02f, 1.25212938e-01f, 1.19242035e-01f, 1.68557137e-01f, 2.18194395e-01f, 5.15440069e-02f, -4.60226201e-02f, 1.11187845e-01f, 7.41298050e-02f,
  -4.39346442e-03f, -2.29583136e-04f, 5.78262173e-02f, -3.10413428e-02f, 1.36214688e-01f, 4.23583090e-02f, 8.47493261e-02f, 5.67919668e-03f, -5.72355464e-02f, -4.39435914e-02f,
  1.93152115e-01f, -5.94037399e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.12525497e-02f, -1.05380647e-01f, -8.14659148e-02f, 4.42593135e-02f, -2.09557936e-02f, 1.00185342e-01f, 1.11053316e-02f, -1.98042057e-02f, 1.97883472e-02f, 1.28868774e-01f,
  7.65227899e-02f, 1.19406447e-01f, 1.50553770e-02f, 5.78619391e-02f, -7.67179355e-02f, -2.64324658e-02f, 4.93531413e-02f, -9.10282731e-02f, 2.72988379e-01f, 5.90209365e-02f,
  -4.95876223e-02f, 3.63824926e-02f, -7.14922473e-02f, 5.25957458e-02f, -5.24504930e-02f, -1.10120006e-01f, 7.76416883e-02f, -9.69253406e-02f, 2.12869868e-02f, 9.42915007e-02f,
  4.17800918e-02f, 1.22027904e-01f, -7.83910081e-02f, -4.99740662e-03f, -1.57574654e-01f, 7.82410353e-02f, -1.74778246e-03f, -1.00122280e-01f, -1.58494830e-01f, -2.80355755e-02f,
  1.10447779e-01f, 1.76613271e-01f, -6.97231442e-02f, 1.95152611e-02f, -1.30292237e-01f, -3.86608467e-02f, 9.90462899e-02f, -6.77743778e-02f, -7.73710534e-02f, -8.98768753e-02f,
  -9.54053327e-02f, 1.84368625e-01f, 5.45067303e-02f, -5.16847149e-02f, -7.48273507e-02f, 5.52897677e-02f, 1.14992976e-01f, -5.60715869e-02f, -3.98339331e-02f, 6.27674013e-02f,
  1.60275921e-02f, -7.66784102e-02f, 4.68519283e-05f, 8.64431635e-02f, 6.12115227e-02f, 4.23678663e-03f, 9.40555856e-02f, 1.63072534e-02f, -4.00479324e-02f, 1.04725011e-01f,
  1.65571436e-01f, 1.05107337e-01f, 1.21467091e-01f, 1.19301356e-01f, 2.43820041e-01f, -8.77382904e-02f, -8.11287165e-02f, -6.35583699e-02f, 3.63317877e-02f, -1.15290828e-01f,
  -1.69168916e-02f, -6.70485198e-02f, -2.88450867e-01f, -2.50611752e-02f, 1.91853195e-01f, 6.32355735e-02f, 1.48262093e-02f, -9.38918293e-02f, 1.26055419e-01f, 1.15504824e-01f,
  7.80105442e-02f, 1.24591857e-01f, -7.42409900e-02f, -6.40339702e-02f, -9.89369303e-02f, -3.51323709e-02f, -6.99903220e-02f, -9.06982049e-02f, -1.34017915e-01f, 5.18828891e-02f,
  1.41633660e-01f, 8.71148184e-02f, 2.15066299e-02f, 1.59008235e-01f, 2.54783891e-02f, -1.89638212e-01f, -1.01895198e-01f, -4.34284583e-02f, -1.57386307e-02f, -7.43161812e-02f,
  -7.84031972e-02f, 1.19570211e-01f, -8.89524072e-02f, -3.39724533e-02f, -5.15541695e-02f, -1.26605004e-01f, -6.08933941e-02f, -3.43659744e-02f, -5.98411709e-02f, 1.63515717e-01f,
  2.13989741e-04f, 1.48445386e-02f, -3.03834900e-02f, -1.23765036e-01f, -1.77988872e-01f, -1.51105027e-03f, 1.50606826e-01f, 1.22337796e-01f, -2.04928830e-01f, 6.57313168e-02f,
  -7.61179924e-02f, 3.69969122e-02f, -1.50332227e-01f, 6.77598268e-02f, 9.53230187e-02f, 8.63948762e-02f, 1.79522291e-01f, 6.95188642e-02f, -2.20905736e-01f, -1.68981805e-01f,
  9.45737064e-02f, 8.37782323e-02f, -1.54903024e-01f, 1.20273449e-01f, -5.52267097e-02f, -1.29918039e-01f, 1.92889884e-01f, -1.75272241e-01f, 1.85716413e-02f, -4.26495913e-03f,
  -1.89656559e-02f, 3.42462100e-02f, -1.80054784e-01f, 5.18199503e-02f, 7.46003687e-02f, -1.26259089e-01f, -3.71456631e-02f, 4.63509224e-02f, -9.25001651e-02f, -1.17068402e-02f,
  1.06869772e-01f, -8.45580325e-02f, 2.75913388e-01f, -1.32920891e-01f, -1.38956904e-01f, -1.02534421e-01f, 2.44768802e-02f, 1.09984808e-01f, -1.20305948e-01f, 2.51964685e-02f,
  1.86217949e-01f, 6.44195527e-02f, 1.57518312e-01f, 9.43780541e-02f, -1.42135993e-01f, 7.00540096e-02f, 2.09035143e-01f, 5.23478491e-03f, 6.96899742e-02f, -8.30676686e-03f,
  -4.75836918e-02f, 5.46946079e-02f, 1.96003672e-02f, 2.95909159e-02f, 3.65178809e-02f, -7.35570788e-02f, -1.15155272e-01f, 1.62051007e-01f, 1.75571099e-01f, -8.76603127e-02f,
  -2.12014079e-01f, 5.54995462e-02f, -1.02342464e-01f, 1.27135605e-01f, -1.43098086e-01f, -8.94862786e-02f, -1.16373092e-01f, -2.35751774e-02f, 1.49677515e-01f, 1.19424827e-01f,
  1.26891971e-01f, 1.91693723e-01f, -2.73361713e-01f, 8.93999413e-02f, -4.83822310e-03f, -9.64446962e-02f, 2.64440067e-02f, 1.93999171e-01f, -2.97719566e-03f, 2.09275261e-02f,
  1.00764573e-01f, 4.35143849e-03f, 7.85123333e-02f, -7.62021169e-03f, -5.93476593e-02f, -1.07596651e-01f, -1.43828109e-01f, -2.79441918e-03f, 1.20436683e-01f, -8.11860710e-02f,
  -1.36929378e-01f, 6.08528173e-03f, -2.00091656e-02f, 7.69532919e-02f, 1.40452564e-01f, 1.13655612e-01f, 1.75578073e-01f, -1.36517629e-01f, -1.29952177e-01f, 3.00432704e-02f,
  1.41688481e-01f, 1.64366856e-01f, -3.15007418e-02f, 1.01837285e-01f, -2.26095226e-02f, 2.06958652e-02f, 1.56606883e-02f, -4.53352593e-02f, -6.81816489e-02f, 1.62698388e-01f,
  1.85753077e-01f, 2.24105380e-02f, 1.08035086e-02f, 1.31969601e-01f, -1.29742444e-01f, -5.65603562e-02f, -2.99403425e-02f, -7.37823024e-02f, 6.57362118e-02f, 4.26828116e-02f,
  -1.63666546e-01f, -2.35955976e-02f, 6.48783445e-02f, -1.91610437e-02f, -9.40378457e-02f, 8.97517502e-02f, 1.50794134e-01f, 1.87996887e-02f, -6.63861185e-02f, 1.44224808e-01f,
  9.23695713e-02f, 4.83093001e-02f, -1.62281618e-02f, -1.59477875e-01f, 1.82700261e-01f, -2.37983480e-01f, -5.40772304e-02f, -1.58315361e-01f, 5.54965204e-03f, -6.65123761e-02f,
  -1.53518077e-02f, -1.18742533e-01f, -1.20091908e-01f, 1.95834339e-02f, 4.48728427e-02f, -1.06939226e-01f, -1.06446080e-01f, -1.42921105e-01f, -9.02830437e-03f, 1.31258607e-01f,
  1.37788177e-01f, 1.71468519e-02f, -6.60943389e-02f, 6.02271371e-02f, 9.17703211e-02f, -4.52609956e-02f, -1.13342591e-01f, 1.20517232e-01f, 4.03241850e-02f, -9.42301080e-02f,
  2.37797201e-01f, 1.02744030e-03f, -1.27204344e-01f, 1.87768918e-02f, 5.50968796e-02f, -6.22373484e-02f, 9.73619223e-02f, -6.97148789e-04f, -3.33972797e-02f, -7.07543269e-02f,
  -7.54886642e-02f, 1.68166533e-01f, 6.28147461e-03f, -9.76860076e-02f, 5.06311189e-03f, -4.06689495e-02f, 1.35231912e-01f, -1.02432750e-01f, 1.77207757e-02f, 7.23816454e-02f,
  -3.64108719e-02f, -4.97965664e-02f, -9.56904143e-02f, 2.94455253e-02f, -6.33508936e-02f, 3.31292599e-02f, 9.24211666e-02f, -8.63962844e-02f, 6.82408586e-02f, 1.06934039e-02f,
  4.79306504e-02f, -3.70206423e-02f, -5.14196083e-02f, 3.95617038e-02f, -7.28660449e-02f, -6.21847995e-02f, -5.71041666e-02f, 2.44821720e-02f, 8.17995593e-02f, -1.42092481e-01f,
  -2.09625393e-01f, -6.56627193e-02f, 3.88944820e-02f, -1.27234221e-01f, 6.71763793e-02f, -1.15582667e-01f, 4.54011038e-02f, 8.57055858e-02f, -9.36787352e-02f, 1.31702870e-02f,
  -8.48002508e-02f, -1.69074863e-01f, -1.07203119e-01f, 2.26384774e-03f, 3.26683894e-02f, 1.10245459e-01f, 6.73396736e-02f, 6.83993846e-02f, -8.10214952e-02f, 1.10102542e-01f,
  -9.13935801e-05f, -1.89179797e-02f, 3.45107801e-02f, -8.08731280e-03f, 2.47312665e-01f, -5.86135872e-02f, 1.59929559e-01f, -6.64678663e-02f, -8.76410753e-02f, -1.11128114e-01f,
  -1.51608348e-01f, -2.36436315e-02f, 7.68614421e-03f, -1.63828760e-01f, -3.76235992e-02f, 1.54913411e-01f, -9.52348262e-02f, -6.55706823e-02f, 1.99972577e-02f, -9.87046733e-02f,
  4.35030200e-02f, -1.93042278e-01f, -9.26222429e-02f, -3.98126896e-03f, -7.65952021e-02f, -6.46876618e-02f, 8.17944109e-02f, 1.07478894e-01f, 7.80644640e-02f, 3.38144973e-02f,
  -3.27855796e-02f, -6.81092963e-02f, -1.40948147e-01f, -2.74443533e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.31176408e-02f, 1.90461073e-02f, -4.83329296e-02f, 8.97476003e-02f, -5.90935908e-02f, 3.47053260e-02f, -1.24755345e-01f, 3.02264895e-02f, -1.29462555e-01f, -9.24377888e-02f,
  -8.54692459e-02f, 2.69357730e-02f, 5.14498912e-03f, -9.25325975e-02f, -8.74969289e-02f, -6.58702776e-02f, 4.38876403e-03f, 1.04254104e-01f, 1.79326713e-01f, 1.23207860e-01f,
  -1.28255516e-01f, -6.51789755e-02f, 9.56310257e-02f, -2.36402452e-02f, 1.69680100e-02f, -9.54065099e-02f, 9.90881678e-03f, -2.94422675e-02f, 7.08291456e-02f, 1.09288424e-01f,
  8.40278640e-02f, 1.21810175e-01f, -2.53690742e-02f, 6.20324612e-02f, -6.32660836e-02f, -1.10152379e-01f, 5.45355715e-02f, -3.53250913e-02f, 5.69636673e-02f, -1.63483876e-03f,
  7.25764632e-02f, -3.12238373e-02f, -1.15933046e-02f, -9.13358927e-02f, 7.20397159e-02f, -9.57572311e-02f, 1.23805515e-01f, 1.12057246e-01f, 9.85140540e-03f, -5.35349809e-02f,
  -6.15614355e-02f, 7.91639984e-02f, 1.28337175e-01f, -3.70822214e-02f, 2.58434508e-02f, -1.31980613e-01f, 9.20087993e-02f, -4.24516425e-02f, -3.37338001e-02f, -1.03082303e-02f,
  -7.95888063e-03f, 1.17213503e-01f, 2.34477199e-03f, -3.23809013e-02f, 5.16435839e-02f, 7.76273534e-02f, 7.61488825e-02f, 1.98583916e-01f, 2.39476696e-01f, 1.72530904e-01f,
  1.07528962e-01f, 7.89606124e-02f, -4.38898727e-02f, 2.52262652e-01f, -2.84344759e-02f, 1.10031098e-01f, 1.08261049e-01f, -5.53949438e-02f, 3.60364653e-02f, 1.99958026e-01f,
  1.45321190e-01f, -2.52625756e-02f, 1.03790954e-01f, -1.01861633e-01f, 2.28504762e-01f, 2.29838297e-01f, 1.71934292e-01f, -7.70417005e-02f, -9.73820314e-02f, 8.95010009e-02f,
  7.54094729e-03f, -1.28856927e-01f, 3.53841372e-02f, 6.01533204e-02f, 1.07838228e-01f, 1.67576876e-02f, 6.23367205e-02f, 2.23365705e-02f, 4.14153896e-02f, -1.22821018e-01f,
  -1.21089630e-01f, 3.94512191e-02f, 1.22183815e-01f, 8.41577947e-02f, 2.14607082e-03f, 1.62881270e-01f, 1.57896966e-01f, 9.88386124e-02f, 7.52930716e-02f, -1.81222394e-01f,
  -1.55896479e-02f, 2.21430004e-01f, 3.74270906e-03f, -6.21234104e-02f, 1.05405070e-01f, 2.02623129e-01f, -2.63399798e-02f, 1.47884518e-01f, 1.06444761e-01f, -8.25299323e-02f,
  -3.24801318e-02f, -4.63813767e-02f, -7.34712109e-02f, -8.76224041e-02f, 4.84105647e-02f, 4.38737422e-02f, 1.01811230e-01f, 7.18799084e-02f, 1.47429124e-01f, 1.87884420e-02f,
  5.81974536e-02f, 1.19768836e-01f, 2.99965777e-02f, 3.80961001e-02f, -3.26415598e-02f, 1.01156980e-01f, 1.89864486e-02f, 5.68166412e-02f, 1.22456387e-01f, 1.02355525e-01f,
  -5.72253466e-02f, 2.71556880e-02f, 1.03457540e-01f, 7.33517781e-02f, 8.28777403e-02f, 2.96428390e-02f, -9.43173096e-02f, -3.58220860e-02f, -7.58312866e-02f, 1.06450573e-01f,
  9.28989872e-02f, -6.01144042e-03f, 3.31421569e-02f, 5.46133006e-03f, 4.04473357e-02f, -6.70540407e-02f, 1.50359394e-02f, -8.72643963e-02f, 1.33876160e-01f, -9.81382057e-02f,
  -7.62808025e-02f, -7.81040266e-02f, -1.46968260e-01f, 2.25465715e-01f, 2.00313002e-01f, 1.06609811e-03f, 9.70750302e-02f, -7.01861084e-02f, -8.06238055e-02f, -7.98274651e-02f,
  2.05272939e-02f, -6.71258867e-02f, -6.91458806e-02f, 4.04569320e-02f, -3.18725966e-03f, 1.40803143e-01f, -1.66352261e-02f, -1.49081070e-02f, -1.18298084e-01f, 8.66578426e-03f,
  7.17899427e-02f, -3.95072699e-02f, -1.68001791e-03f, -6.82658181e-02f, 6.85851742e-03f, 7.44432136e-02f, 3.55614536e-02f, 9.41899568e-02f, 9.21908543e-02f, 4.88035493e-02f,
  3.43273468e-02f, -5.96443601e-02f, -1.05057031e-01f, 4.65471558e-02f, -9.24274847e-02f, -7.21260160e-02f, -3.43118571e-02f, 2.07649171e-02f, -1.46651566e-01f, -8.96704420e-02f,
  2.70759836e-02f, 8.70507658e-02f, -9.74073038e-02f, 8.20450559e-02f, 7.31586590e-02f, 7.70870671e-02f, -7.67999589e-02f, -7.35974759e-02f, 5.64290062e-02f, -6.77978396e-02f,
  7.74579421e-02f, -2.42422707e-02f, -7.75336474e-02f, 1.46072403e-01f, 7.87412897e-02f, 6.56947419e-02f, -4.85185650e-04f, 5.19990623e-02f, 4.80088107e-02f, 7.57725239e-02f,
  1.54050067e-01f, 1.27714470e-01f, 8.53961781e-02f, 5.93733750e-02f, -5.37663586e-02f, -1.10496860e-02f, 3.25839296e-02f, -5.98977739e-03f, 9.46582630e-02f, 8.81756470e-02f,
  -1.04781479e-01f, -1.33648619e-01f, 4.52996008e-02f, 8.20638835e-02f, 1.93998460e-02f, -3.30811851e-02f, 4.21198569e-02f, -2.05331389e-02f, 1.94390956e-02f, 2.32153665e-02f,
  -9.48191136e-02f, -2.94767506e-02f, 8.50219745e-03f, -3.75097967e-03f, 1.34173082e-02f, 6.30715489e-02f, 6.12734184e-02f, 4.11945358e-02f, 6.62247390e-02f, -6.03416488e-02f,
  -7.30787124e-03f, 1.15082406e-01f, -8.19046795e-02f, -5.17009944e-02f, 1.03098489e-01f, 1.39666602e-01f, -1.28646821e-01f, 3.14313211e-02f, -1.23293556e-01f, 1.14344656e-02f,
  -5.86239994e-03f, 9.81691703e-02f, 1.01165161e-01f, -1.53213125e-02f, 1.19332030e-01f, -8.36650059e-02f, -3.54423225e-02f, -1.34505659e-01f, 6.33047745e-02f, 2.89875586e-02f,
  -7.52181783e-02f, -9.68256667e-02f, -6.91713840e-02f, 1.39232352e-01f, -3.81591283e-02f, 7.70822763e-02f, -1.56596929e-01f, 1.56802628e-02f, -4.20117006e-02f, 8.97570606e-03f,
  6.95596263e-02f, 5.16275726e-02f, 1.14352629e-01f, 2.67953845e-03f, -3.90743650e-02f, -1.16238646e-01f, -4.78477925e-02f, -1.15103759e-01f, -1.18525200e-01f, -6.12618662e-02f,
  -3.68873961e-02f, -2.78300345e-02f, -4.10916507e-02f, 1.21553592e-01f, 1.44155174e-01f, 1.00330234e-01f, -1.25926271e-01f, 2.77691856e-02f, 1.24625087e-01f, -8.65370501e-03f,
  1.25896558e-01f, 1.49593756e-01f, -1.25100330e-01f, -1.37490034e-01f, 1.47662073e-01f, 5.81220314e-02f, 8.05594251e-02f, -9.55607817e-02f, 4.77844551e-02f, 1.14423297e-01f,
  -1.93756670e-02f, 4.75881584e-02f, 7.37313181e-02f, 1.06913291e-01f, -8.68718401e-02f, 9.44639370e-02f, 1.26555085e-01f, 8.72343406e-03f, 5.41366898e-02f, -8.87444019e-02f,
  -1.05219737e-01f, 1.58070922e-01f, 3.94423343e-02f, 9.47417319e-02f, -1.03469782e-01f, 1.30930111e-01f, 1.59414917e-01f, 8.09355304e-02f, 1.60901949e-01f, -5.18725179e-02f,
  -2.02925369e-01f, -7.66942697e-03f, -1.22894309e-02f, 1.09528966e-01f, -2.74268892e-02f, -5.43894060e-02f, 8.90085474e-02f, 1.24809574e-02f, -3.10561750e-02f, -4.66795340e-02f,
  3.28453295e-02f, -1.57492399e-01f, 2.50706226e-02f, -1.61849894e-02f, 9.91968513e-02f, 9.86597687e-02f, 2.66284406e-01f, -5.79697862e-02f, -1.57021165e-01f, 1.00073680e-01f,
  -2.15233602e-02f, -1.07628502e-01f, -9.43433344e-02f, -3.84421423e-02f, -2.24127434e-02f, 1.42049119e-01f, 1.42154947e-01f, 4.09476161e-02f, 1.35587379e-01f, 8.25783089e-02f,
  -8.82556662e-03f, -1.09604411e-01f, 1.12602398e-01f, 1.18668638e-02f, 1.43603608e-01f, 1.13891207e-01f, -1.27967954e-01f, -4.58643772e-02f, 7.82949477e-02f, 1.25628680e-01f,
  1.05714522e-01f, -1.08366052e-03f, 1.32265419e-01f, 1.04957521e-01f, 1.19068667e-01f, 1.07664727e-01f, 7.96716809e-02f, -6.19671270e-02f, 1.74934134e-01f, 5.03420979e-02f,
  1.24884821e-01f, -7.08717257e-02f, 5.82051538e-02f, -3.62693444e-02f, -3.16763297e-02f, -1.05690017e-01f, -2.18152013e-02f, -5.20589575e-02f, 5.21447659e-02f, -1.23078510e-01f,
  -9.01449919e-02f, 5.93012497e-02f, 3.22945379e-02f, -1.12250365e-01f, 1.93046592e-02f, 6.62853122e-02f, 1.16591498e-01f, -4.25246507e-02f, -3.32613289e-02f, -6.16947375e-02f,
  1.09159522e-01f, -1.20559014e-01f, 1.24471150e-01f, -8.73737931e-02f, -6.77875727e-02f, -1.83697627e-03f, 2.71092691e-02f, -6.59422204e-02f, 9.87993628e-02f, -6.34681582e-02f,
  2.18190253e-02f, 3.83768202e-04f, -1.90114975e-02f, -6.13469072e-02f, -1.16844915e-01f, -6.14177249e-03f, -8.70654434e-02f, 6.85778260e-02f, 9.71036926e-02f, -1.89645626e-02f,
  7.47977272e-02f, -2.18463168e-02f, 1.54205123e-02f, 1.86575390e-02f, 1.58276614e-02f, 6.51184618e-02f, -7.04312176e-02f, -7.89383873e-02f, -6.95935711e-02f, -1.17336409e-02f,
  -7.87281841e-02f, 1.62058007e-02f, 8.94952565e-02f, 1.05960526e-01f, 1.18847683e-01f, -5.44231720e-02f, 7.01605678e-02f, 9.99622121e-02f, -6.50592670e-02f, -3.19239385e-02f,
  4.54014074e-03f, 1.18726596e-01f, -1.00075021e-01f, -2.16557086e-02f, -7.53476247e-02f, -4.67340536e-02f, 2.04897001e-02f, -1.20813935e-03f, -9.65911150e-02f, 1.23624690e-01f,
  8.58503878e-02f, -2.19271015e-02f, -1.21225126e-01f, 4.89278175e-02f, -2.01011181e-01f, 6.35782033e-02f, -1.05346084e-01f, -1.84308849e-02f, -8.66955742e-02f, -7.43232146e-02f,
  6.94279373e-02f, -1.81994140e-02f, -1.83214117e-02f, -7.58078396e-02f, -8.41262266e-02f, 1.00851379e-01f, 9.95150059e-02f, -5.02557866e-02f, 2.35914961e-02f, 6.25391230e-02f,
  -1.16584718e-01f, 1.09458916e-01f, -1.80670954e-02f, 7.64207542e-02f, -5.33464290e-02f, -3.87678691e-03f, 9.11491141e-02f, -2.86118165e-02f, 1.00146875e-01f, -5.28678000e-02f,
  9.48821604e-02f, -1.04246009e-02f, 1.25383958e-01f, 9.40992907e-02f, 1.30989268e-01f, -6.92783622e-03f, -4.24439237e-02f, -3.32521461e-02f, -4.41644117e-02f, -4.97963354e-02f,
  3.86241190e-02f, -3.60122905e-03f, 7.40152523e-02f, 1.09852068e-01f, 4.97835167e-02f, 5.54050617e-02f, -8.10587853e-02f, 1.38721690e-01f, 3.24140564e-02f, -5.61105758e-02f,
  -7.05689639e-02f, 4.81862128e-02f, 9.97443646e-02f, 7.92155601e-03f, -6.55939281e-02f, 1.18767796e-02f, 1.02578022e-01f, 1.72326379e-02f, -9.42425504e-02f, -9.72040296e-02f,
  -8.48869160e-02f, 4.16411199e-02f, 6.17051460e-02f, 1.62849978e-01f, 2.41958606e-03f, 1.58149347e-01f, -1.79614536e-02f, 1.56079352e-01f, 5.53595349e-02f, 1.57799900e-01f,
  -5.27909808e-02f, 4.29489017e-02f, -6.09333031e-02f, 2.95187943e-02f, 5.41592389e-02f, -2.91493279e-03f, 9.58573297e-02f, 1.69445872e-01f, -4.75271401e-04f, 1.23841107e-01f,
  2.54409522e-01f, 1.04793899e-01f, 3.35465446e-02f, 1.78888261e-01f, -4.07043956e-02f, -4.74818610e-02f, -1.12364046e-01f, -3.05664986e-02f, 8.35369751e-02f, -7.79857486e-02f,
  6.60992507e-03f, -8.72047916e-02f, -3.62817049e-02f, 1.24397345e-01f, 2.52595022e-02f, -1.27411317e-02f, -1.22050592e-03f, 5.28780594e-02f, 1.72118887e-01f, 1.01699412e-01f,
  -6.95959851e-02f, -1.38949543e-01f, -9.57273990e-02f, 2.69465875e-02f, 6.28314093e-02f, -1.06651790e-01f, 8.62749368e-02f, 8.41594636e-02f, 3.92386466e-02f, 1.87617674e-01f,
  -3.52307521e-02f, 3.67555325e-03f, -7.21870288e-02f, 5.11755273e-02f, -6.47177100e-02f, 1.83668714e-02f, 2.28687581e-02f, -7.12311640e-02f, 1.80675328e-01f, -8.32417309e-02f,
  6.54034391e-02f, 5.22579588e-02f, 8.00612494e-02f, 6.43017590e-02f, -4.69348617e-02f, -5.86314611e-02f, 3.90136801e-02f, 1.00770913e-01f, 4.07856852e-02f, -1.00182161e-01f,
  -7.29283765e-02f, 1.14833899e-01f, -6.15721345e-02f, -1.49221301e-01f, -8.66323896e-03f, -1.32073268e-01f, 1.55546352e-01f, -9.45801754e-03f, 5.42002544e-02f, 1.06575064e-01f,
  1.12730805e-02f, -8.42952356e-02f, -2.94808391e-02f, 5.22376336e-02f, 7.89054409e-02f, -6.30916581e-02f, -2.68889926e-02f, -2.91785337e-02f, 5.96914329e-02f, 1.51728652e-02f,
  1.29141957e-01f, 9.00431946e-02f, -2.83537824e-02f, 4.43556756e-02f, 2.96628736e-02f, 1.37434736e-01f, -7.80865401e-02f, 1.48905128e-01f, -8.04679394e-02f, 4.58025262e-02f,
  -1.29932899e-03f, 4.77285311e-03f, -1.05140947e-01f, 9.69486088e-02f, -9.04443190e-02f, -9.92603749e-02f, 1.81981623e-02f, 1.08238421e-01f, -7.04788342e-02f, 1.51886806e-01f,
  8.84224623e-02f, -1.25037283e-01f, 6.66246563e-02f, 2.71500479e-02f, 3.41404253e-03f, 1.59052357e-01f, -2.54982878e-02f, 6.78838864e-02f, 7.16861635e-02f, -7.53739625e-02f,
  9.26188082e-02f, 1.04009978e-01f, 1.42329618e-01f, 1.12420149e-01f, 9.98134762e-02f, 1.00697088e-03f, 1.26598477e-01f, 4.66982238e-02f, -3.77958477e-03f, 6.49238303e-02f,
  1.12989888e-01f, 2.27722183e-01f, 2.06082940e-01f, 1.22844234e-01f, 1.68329105e-01f, 1.98462859e-01f, -2.50572953e-02f, -7.08477348e-02f, -2.05456148e-04f, 2.22980604e-01f,
  9.25942212e-02f, 2.43642673e-01f, 4.39712815e-02f, 1.65394455e-01f, -9.98033285e-02f, 1.33232085e-03f, 1.65699691e-01f, -1.37535840e-01f, 3.88208032e-01f, 1.15901917e-01f,
  1.83578432e-01f, 1.74049005e-01f, 6.32055104e-02f, -4.81391177e-02f, 7.64753893e-02f, -3.63115706e-02f, -1.97649404e-01f, 6.08400395e-03f, 2.62630403e-01f, 1.50313050e-01f,
  -4.43988964e-02f, 1.69095472e-01f, -6.09229021e-02f, 1.20778017e-01f, 8.48059729e-02f, -4.98482734e-02f, -4.06304598e-02f, 5.50351385e-03f, -1.15880013e-01f, -2.24655401e-02f,
  7.61121139e-02f, 2.54855752e-01f, 1.02009095e-01f, -1.38327444e-03f, -1.10045418e-01f, -1.72065079e-01f, 6.40300736e-02f, 2.05331564e-01f, 1.28370747e-01f, 6.63980395e-02f,
  1.99465483e-01f, 1.94511563e-01f, 1.10189922e-01f, 1.78389400e-01f, -3.29965986e-02f, -6.06557988e-02f, 1.83845192e-01f, -1.74950939e-02f, -2.63639316e-02f, -1.22107707e-01f,
  9.54359546e-02f, -3.86453979e-02f, 9.31367055e-02f, 8.75620320e-02f, -6.64621592e-02f, -7.13220388e-02f, -1.16772495e-01f, -4.78015654e-02f, -1.79768167e-02f, -2.65353266e-02f,
  -4.69364487e-02f, 4.00971062e-02f, 3.13210883e-03f, -1.09663256e-01f, 9.90279391e-02f, 4.89788651e-02f, 7.71304127e-03f, 1.21222876e-01f, 3.82593973e-03f, 4.71404605e-02f,
  -1.12908654e-01f, 7.65827522e-02f, -8.57172906e-02f, 1.03631653e-01f, -4.64280359e-02f, 3.34617570e-02f, -1.06540751e-02f, 1.43710962e-02f, 5.49798645e-02f, 4.83056754e-02f,
  -1.03548154e-01f, 2.90195830e-02f, -1.15921415e-01f, 5.22496700e-02f, -2.99584772e-02f, 4.95994277e-02f, -3.59887071e-02f, -1.09883271e-01f, 4.20488417e-02f, 2.69527324e-02f,
  4.35706005e-02f, 3.89113538e-02f, -1.47180865e-02f, -8.01723972e-02f, 2.33691707e-02f, -9.54822749e-02f, -1.16476983e-01f, -5.44973761e-02f, -5.85033186e-02f, -6.92204908e-02f,
  3.77106853e-02f, 1.06915653e-01f, 1.09846316e-01f, -1.19340710e-01f, 1.44254649e-02f, -6.90784827e-02f, -1.05573349e-01f, -3.86643372e-02f, 5.32250144e-02f, -5.04809292e-03f,
  -1.17664360e-01f, -9.89405215e-02f, -9.51569006e-02f, 7.66165927e-02f, 2.18110178e-02f, 5.12605906e-02f, 3.04896887e-02f, 8.54384378e-02f, 3.83906029e-02f, 1.50721461e-01f,
  -5.42888194e-02f, 7.08869919e-02f, 3.05925291e-02f, 1.55118704e-01f, -3.20121460e-02f, 1.03486560e-01f, 5.14199510e-02f, 6.22591190e-02f, -9.55009982e-02f, 9.87699777e-02f,
  -1.11964665e-01f, -6.48801103e-02f, 6.78986385e-02f, -6.77258745e-02f, 8.53601098e-02f, 1.69182289e-03f, -1.08018825e-02f, -4.06469181e-02f, 1.34636573e-02f, 3.87449451e-02f,
  -9.63946879e-02f, 6.78514317e-02f, -8.60973597e-02f, 3.80906723e-02f, 1.38008609e-01f, -6.72555640e-02f, 5.57159670e-02f, 4.64827418e-02f, -8.11075568e-02f, 9.43630859e-02f,
  1.59049094e-01f, -8.27944353e-02f, -3.30654904e-02f, -2.21679825e-02f, 9.19142067e-02f, 6.07114509e-02f, 1.50927186e-01f, 1.06338889e-03f, 1.37109458e-01f, -1.34276122e-01f,
  6.98120892e-02f, 1.51464105e-01f, 4.91805859e-02f, 7.69205615e-02f, -3.73076275e-03f, 1.18418470e-01f, 1.73830420e-01f, -1.12973072e-01f, -4.71918471e-02f, 3.08218598e-02f,
  1.13631606e-01f, -4.82282005e-02f, -4.19973955e-02f, 1.30182490e-01f, -1.11488044e-01f, 1.69582311e-02f, -6.05941452e-02f, -3.51880491e-02f, 1.32914726e-02f, 7.52652362e-02f,
  9.19586495e-02f, 2.25257333e-02f, 1.00131176e-01f, -5.18088453e-02f, 4.42762226e-02f, -3.25035825e-02f, -9.38953832e-03f, -2.67120581e-02f, -1.72262415e-02f, -6.04387708e-02f,
  5.36169000e-02f, -1.52270151e-02f, -6.92062303e-02f, 1.08735494e-01f, -3.68659720e-02f, -1.79948974e-02f, -1.77779645e-02f, -1.68166980e-02f, 2.33854377e-03f, -2.21514944e-02f,
  -3.66316587e-02f, -1.11809283e-01f, -3.50737050e-02f, 7.08645731e-02f, -1.03568934e-01f, 6.23730719e-02f, -2.33617239e-02f, 8.12733620e-02f, -1.04612462e-01f, 1.21671289e-01f,
  -5.69163188e-02f, 4.72881794e-02f, -3.29123512e-02f, -1.03104291e-02f, 9.49446037e-02f, 6.63904473e-02f, -8.56499523e-02f, 4.56456356e-02f, -9.65167135e-02f, -4.08073030e-02f,
  9.62593481e-02f, -6.01137765e-02f, -2.12193839e-02f, -8.45942721e-02f, -1.77487321e-02f, -3.05365268e-02f, -6.92983493e-02f, -1.01190366e-01f, -1.14750914e-01f, 7.25527480e-02f,
  4.92934361e-02f, -7.70032406e-02f, -2.64407787e-02f, 1.22179389e-01f, -1.33993691e-02f, -6.66090176e-02f, -1.13858715e-01f, -4.83930036e-02f, 9.35711339e-02f, -8.83354470e-02f,
  -4.19086143e-02f, 9.88935083e-02f, -1.06794327e-01f, -9.12968535e-03f, 1.20990649e-01f, -7.49510974e-02f, 9.34782065e-03f, 8.93327072e-02f, 1.63444668e-01f, -9.21313539e-02f,
  8.82613063e-02f, 5.49101382e-02f, 1.67542130e-01f, 1.78817123e-01f, -8.38486478e-02f, 3.26347411e-01f, 1.95062235e-02f, -1.67481750e-02f, 1.66731775e-02f, -3.12246801e-03f,
  1.05262771e-01f, 7.59107694e-02f, -5.42761898e-03f, 1.13913961e-01f, 2.61323273e-01f, 4.92523722e-02f, 1.15493372e-01f, 8.31238553e-02f, 4.85013910e-02f, 1.26019940e-02f,
  -7.44897723e-02f, 5.99859469e-02f, 9.58906040e-02f, -5.93496440e-03f, 1.12598360e-01f, -1.20464444e-01f, -8.58730823e-02f, -2.14312878e-02f, 1.18842229e-01f, -1.10062221e-02f,
  -2.56816208e-01f, 7.60629624e-02f, 1.02290556e-01f, 5.08851074e-02f, 2.20212918e-02f, -1.86436754e-02f, -8.62463042e-02f, -2.00072266e-02f, 1.62008584e-01f, 7.88722113e-02f,
  1.28542483e-01f, -1.17606118e-01f, -3.72822210e-02f, 3.00920218e-01f, -3.21465507e-02f, 8.25502872e-02f, -1.16554812e-01f, 2.90783465e-01f, -1.02737956e-01f, 2.11941019e-01f,
  -1.11113235e-01f, -1.18800968e-01f, 1.89485386e-01f, -2.50678565e-02f, -5.46786673e-02f, 8.25196505e-02f, 6.81110546e-02f, 1.05910815e-01f, 9.72483605e-02f, 8.73819217e-02f,
  1.03557907e-01f, -1.18163094e-01f, -1.01439334e-01f, -3.83931100e-02f, -3.46998088e-02f, -1.13187516e-02f, 8.69365484e-02f, 4.43086959e-02f, -1.06263302e-01f, 1.27463136e-02f,
  -1.06163107e-01f, 1.22092992e-01f, -7.80078769e-02f, 6.20893249e-03f, -8.84682238e-02f, -4.29585874e-02f, 1.15285575e-01f, -3.54448915e-03f, -1.19897269e-01f, 7.29367808e-02f,
  1.09642498e-01f, 1.07922517e-01f, 8.69904384e-02f, 5.51393256e-02f, -1.14594132e-01f, 1.73747502e-02f, -2.96212956e-02f, -1.19834512e-01f, -1.04336709e-01f, -1.17180526e-01f,
  -6.12443574e-02f, 3.84399481e-02f, -4.75269407e-02f, -1.91168394e-02f, 2.32720841e-02f, -9.16538611e-02f, -1.16431899e-01f, -1.04693867e-01f, -3.55224386e-02f, -5.08600241e-03f,
  -7.98443481e-02f, 4.53981571e-02f, -8.11349601e-02f, 6.32055327e-02f, -7.24196360e-02f, 1.39096379e-02f, 3.26315202e-02f, -8.81595835e-02f, -1.05809100e-01f, -8.20843410e-03f,
  -7.53374770e-02f, 8.10631216e-02f, -3.49145243e-03f, 2.60206703e-02f, -1.22071654e-01f, -8.90037939e-02f, -3.19993123e-02f, -8.34306329e-02f, -9.15928781e-02f, -5.82993142e-02f,
  7.93401524e-02f, 1.21734329e-01f, 9.60531607e-02f, -5.52026182e-02f, 3.92794721e-02f, 3.76592875e-02f, 1.49490191e-02f, -4.74081151e-02f, -7.61743933e-02f, 4.80334237e-02f,
  1.15801901e-01f, 9.36386585e-02f, -4.45549861e-02f, 4.08367328e-02f, -3.59355249e-02f, -1.31649315e-01f, -7.84694701e-02f, 3.50172222e-02f, -8.67487341e-02f, 1.85399167e-02f,
  -3.98289114e-02f, 1.38710022e-01f, -8.42967629e-02f, 4.91415616e-03f, -7.24342912e-02f, -9.54865813e-02f, 6.11355640e-02f, -1.09882921e-01f, -4.14072685e-02f, -5.86548727e-03f,
  -6.86780885e-02f, -1.83969121e-02f, 1.05873592e-01f, -7.60769122e-04f, -3.63933779e-02f, 2.72033010e-02f, 1.29904613e-01f, -9.01496634e-02f, 1.28218845e-01f, -9.11499262e-02f,
  6.90833703e-02f, 4.44640331e-02f, 6.05133474e-02f, 5.40123768e-02f, 9.40076336e-02f, 1.28792286e-01f, 1.65947340e-02f, -4.75710891e-02f, 1.40289202e-01f, 9.11196172e-02f,
  7.44315982e-02f, -1.56623032e-02f, 3.14510521e-03f, 7.58689493e-02f, -9.73345712e-02f, -1.78761091e-02f, -3.87767293e-02f, -2.58167833e-02f, -8.85922238e-02f, -6.19314462e-02f,
  8.59949812e-02f, -9.68578607e-02f, 9.48644206e-02f, 1.21934526e-01f, 8.40093866e-02f, 2.82730702e-02f, -6.90733828e-03f, 4.61110584e-02f, 4.70977873e-02f, 1.13466471e-01f,
  8.73930380e-02f, 4.16610241e-02f, -2.32716138e-03f, 1.31370932e-01f, 1.22543246e-01f, 8.07176381e-02f, -9.28813964e-02f, 2.12813422e-01f, -3.37696411e-02f, -3.46154277e-03f,
  1.31830722e-01f, 1.38411829e-02f, 5.60308993e-02f, 1.06623024e-01f, 1.86924438e-03f, -7.93506857e-03f, 1.58093736e-01f, 3.80901173e-02f, 1.75909311e-01f, 1.89839229e-01f,
  -2.43184101e-02f, -4.98551503e-02f, -1.10895485e-01f, -8.94233584e-03f, -8.81806538e-02f, -1.03778720e-01f, 6.72406703e-02f, -6.82203239e-03f, 1.20227657e-01f, 5.65781631e-02f,
  1.50794894e-01f, 1.36565775e-01f, -1.40166972e-02f, -6.40940517e-02f, 1.32249728e-01f, 3.18530686e-02f, -4.99736816e-02f, -6.28477782e-02f, 2.19077189e-02f, 1.29979610e-01f,
  1.66286439e-01f, -7.78730512e-02f, -3.92992422e-02f, -4.23401818e-02f, 7.35195801e-02f, 1.47747159e-01f, -3.11888345e-02f, -1.85958836e-02f, 4.09554206e-02f, 1.45543218e-01f,
  9.07611921e-02f, 8.41991603e-02f, 3.19145471e-02f, 2.37136967e-02f, 5.77988029e-02f, -9.22393948e-02f, -1.21914268e-01f, 5.96448518e-02f, -3.20811034e-03f, 6.43727109e-02f,
  4.29457501e-02f, 3.93281356e-02f, 3.74476425e-02f, 2.33771786e-01f, 1.33513272e-01f, 1.19383626e-01f, 5.03892526e-02f, 2.73771077e-01f, -2.01213300e-01f, -1.82483107e-01f,
  1.74782410e-01f, -2.51858570e-02f, -1.89176992e-01f, 2.47040670e-02f, 1.17219575e-01f, 1.48877770e-01f, -5.66672198e-02f, 1.13487773e-01f, 9.16691571e-02f, 1.95539370e-02f,
  2.24608421e-01f, -1.13659531e-01f, 6.25846535e-02f, 1.19065762e-01f, 1.78659379e-01f, 1.18579060e-01f, -1.91959009e-01f, 7.75941685e-02f, -2.67026331e-02f, 4.40288819e-02f,
  -3.31646167e-02f, 2.09960520e-01f, -3.77666168e-02f, -4.50218134e-02f, 1.61063865e-01f, 2.57233493e-02f, 5.24071634e-01f, -2.33943716e-01f, -3.22367787e-01f, 1.38748720e-01f,
  1.07514895e-01f, -3.47224250e-02f, 5.52821346e-02f, 9.38049555e-02f, 9.11752656e-02f, 9.92384031e-02f, 1.56768173e-01f, -1.40100211e-01f, 1.66740179e-01f, -2.84609552e-02f,
  1.50579512e-01f, 1.39166564e-01f, 3.23992044e-01f, -4.14395556e-02f, -6.85534179e-02f, 5.48830628e-02f, 1.31978467e-01f, -3.87517773e-02f, 6.10438269e-03f, -1.04444027e-01f,
  -2.25756586e-01f, -1.52608305e-02f, 1.05998814e-01f, 1.79720134e-03f, -1.42727226e-01f, 4.41831052e-02f, 7.40832761e-02f, -2.24170052e-02f, 1.02768309e-01f, -5.91248013e-02f,
  -1.19097091e-01f, 5.33474125e-02f, -1.31293878e-01f, 1.26739994e-01f, 1.28685176e-01f, -9.98023674e-02f, -1.45540982e-01f, -9.38068852e-02f, -5.00892773e-02f, 5.24859466e-02f,
  -1.14731729e-01f, -6.06220029e-02f, -1.11582130e-01f, -5.11083119e-02f, -9.65776518e-02f, 6.02708235e-02f, -7.51860216e-02f, 4.58669551e-02f, 5.62301315e-02f, 1.36277691e-01f,
  2.16202978e-02f, 1.20045021e-01f, 1.50195718e-01f, -5.30427843e-02f, -1.22144870e-01f, 5.93327247e-02f, 5.68998866e-02f, -8.56520087e-02f, 3.08616459e-02f, -8.44765529e-02f,
  1.38733104e-01f, 2.90750694e-02f, -1.01221748e-01f, 1.18539236e-01f, 1.46476775e-01f, -7.17839077e-02f, -1.07069343e-01f, -8.50981921e-02f, 3.64181809e-02f, -1.09895848e-01f,
  1.14847288e-01f, -1.79109555e-02f, 7.42653012e-02f, 1.18176699e-01f, 5.07148856e-04f, 3.73733677e-02f, 5.17573729e-02f, 5.05889673e-03f, -1.16364956e-01f, -7.97311142e-02f,
  -6.09526150e-02f, 2.27925461e-02f, 7.46014193e-02f, -3.12856473e-02f, 1.37147054e-01f, -4.36066911e-02f, 6.52411859e-03f, 2.89435200e-02f, -1.12031206e-01f, 8.26115236e-02f,
  3.83250080e-02f, 2.85129976e-02f, 5.17505892e-02f, -6.62032366e-02f, 5.19860014e-02f, -6.43822029e-02f, -1.10597141e-01f, 4.87898402e-02f, -6.45614788e-02f, 1.30547628e-01f,
  -1.76817235e-02f, 2.78011169e-02f, 1.52957842e-01f, 4.06952500e-02f, 3.65782753e-02f, 9.72566232e-02f, -1.37012207e-03f, 3.81835625e-02f, 2.67130375e-01f, 1.00252002e-01f,
  -4.17049117e-02f, 1.14119336e-01f, -5.78103736e-02f, -4.59727310e-02f, -6.84604049e-02f, 7.80798197e-02f, -3.38663422e-02f, -7.22958660e-03f, 3.88217792e-02f, 1.13737583e-01f,
  -3.55699509e-02f, -5.67287765e-02f, 1.08997129e-01f, 1.64191604e-01f, 3.54390591e-02f, 1.44636184e-01f, 1.25571713e-01f, 5.65650463e-02f, -8.72533619e-02f, -8.02640319e-02f,
  1.04031265e-02f, 4.71310206e-02f, -2.45044809e-02f, -3.83110978e-02f, 3.11415195e-02f, 6.72490299e-02f, 1.19161561e-01f, 4.16193344e-02f, 1.26038074e-01f, 2.48350520e-02f,
  1.13479897e-01f, 1.08682409e-01f, -1.35302860e-02f, 1.31452814e-01f, -4.77686850e-03f, -8.24067444e-02f, 6.29756153e-02f, -8.94262195e-02f, -8.47304240e-02f, 1.10740334e-01f,
  1.39429122e-01f, -2.36097313e-02f, 6.94910511e-02f, -5.86547554e-02f, 1.03251413e-01f, 6.93168715e-02f, -1.74258165e-02f, -1.80609059e-03f, 1.02566212e-01f, -7.72849023e-02f,
  -3.59489769e-02f, 3.17459702e-02f, -2.22200137e-02f, -3.69586758e-02f, -2.11903155e-02f, 1.67067170e-01f, 3.42584178e-02f, 1.56131387e-01f, -7.53467754e-02f, 2.14739591e-01f,
  2.57528410e-03f, -8.13156143e-02f, 2.67016172e-01f, 1.22519478e-01f, -5.83115108e-02f, 2.08572581e-01f, -5.85192367e-02f, -5.56310676e-02f, 5.40698655e-02f, -1.23356439e-01f,
  -1.06355011e-01f, -9.52797830e-02f, 5.17069781e-03f, 1.61807403e-01f, -7.58446082e-02f, -4.47195284e-02f, 1.00724444e-01f, 6.41105250e-02f, 1.18167095e-01f, 2.86325277e-03f,
  -1.36242867e-01f, -3.62291746e-02f, 3.45113724e-02f, 3.75790745e-02f, -4.26590182e-02f, 7.45584145e-02f, 3.83985378e-02f, 6.64217174e-02f, -5.95285296e-02f, -1.48870992e-02f,
  -1.35600707e-02f, 8.27780813e-02f, -3.51082981e-02f, 6.23878092e-02f, 8.38110447e-02f, 1.49534345e-01f, -8.49378705e-02f, -9.39219538e-03f, -4.53243405e-02f, -1.35351166e-01f,
  7.31286556e-02f, -4.98782843e-02f, -4.19429056e-02f, 4.80937911e-03f, 9.70743746e-02f, -1.25672683e-01f, 4.96047661e-02f, 1.33229733e-01f, -7.44854063e-02f, 1.65675089e-01f,
  3.03693227e-02f, 5.85996024e-02f, 1.22391686e-01f, 1.91318095e-01f, -6.56167045e-02f, -1.56270638e-01f, 1.14401110e-01f, 7.78031424e-02f, -1.55687714e-02f, 1.13853775e-02f,
  -1.38138868e-02f, 5.72603457e-02f, 2.11485326e-02f, 1.30414844e-01f, -8.74629095e-02f, -3.82760838e-02f, 1.99830875e-01f, 1.34106398e-01f, 5.34646623e-02f, 3.42636295e-02f,
  1.23771042e-01f, 1.16484962e-01f, -2.58721202e-03f, -6.24366850e-02f, -8.78853947e-02f, -3.15003060e-02f, 1.01018716e-02f, 1.34777412e-01f, 9.20908153e-02f, -9.17481557e-02f,
  -2.90593151e-02f, -1.01087630e-01f, 6.70804754e-02f, -1.30264029e-01f, -1.14668794e-01f, 3.77059765e-02f, -8.83185193e-02f, -5.92990487e-04f, -2.29561068e-02f, 1.97195351e-01f,
  7.74730882e-03f, -4.95607592e-02f, 9.32473224e-03f, 2.22671647e-02f, 2.88798939e-02f, 2.04343926e-02f, 2.02761397e-01f, 1.66682135e-02f, -4.68349317e-03f, 8.79471079e-02f,
  1.09461129e-01f, -2.02623587e-02f, 3.99973728e-02f, -7.75488541e-02f, -8.91948044e-02f, -4.34957780e-02f, -1.24180660e-01f, 1.58866122e-02f, -7.74598941e-02f, -1.15882464e-01f,
  -1.58251762e-01f, 6.94462508e-02f, 1.78774819e-01f, 3.74842174e-02f, 1.99813887e-01f, 1.28626615e-01f, 5.84039316e-02f, 4.17526476e-02f, 2.52127424e-02f, -2.06383690e-02f,
  4.89922576e-02f, 1.04440622e-01f, 1.97874054e-01f, 1.05225826e-02f, -1.20578078e-03f, 1.50407746e-01f, 1.47792861e-01f, -9.84436646e-02f, 1.11484446e-01f, -1.77967642e-02f,
  -1.34846736e-02f, -4.75678556e-02f, -4.54472378e-02f, -4.47495319e-02f, 5.28276265e-02f, -7.11772293e-02f, 1.16658971e-01f, 4.99791987e-02f, -1.41818702e-01f, -4.98840362e-02f,
  -2.67337766e-02f, 5.85046746e-02f, -1.06221132e-01f, 1.40086010e-01f, 7.51449913e-02f, -8.46524909e-02f, 1.38216361e-01f, 2.62976103e-02f, -1.09183624e-01f, 5.00523299e-02f,
  3.71546857e-03f, 2.23390102e-01f, 1.91487134e-01f, -1.31364120e-02f, 8.43692664e-03f, 1.01326384e-01f, 9.86350626e-02f, -8.11953321e-02f, 1.00091705e-02f, -2.65002996e-02f,
  -7.37931654e-02f, 3.42228264e-03f, 1.87891781e-01f, -1.12002470e-01f, 5.49723059e-02f, 7.60214478e-02f, 1.70925453e-01f, 1.20485008e-01f, -7.54239932e-02f, 6.05516471e-02f,
  -4.03268971e-02f, -1.11446120e-01f, -7.95287341e-02f, -2.79632080e-02f, 4.16883454e-03f, -8.08608383e-02f, 6.31230474e-02f, -7.96698220e-03f, -3.52202728e-02f, -2.22009253e-02f,
  -9.19884145e-02f, -7.50704482e-02f, -6.00216240e-02f, 8.12956616e-02f, 5.20383976e-02f, -2.83752028e-02f, -5.97551949e-02f, 6.63084686e-02f, -8.28200951e-02f, 7.25368336e-02f,
  9.36618894e-02f, 1.90044823e-03f, -8.34352672e-02f, 1.29887685e-01f, -6.65551871e-02f, -2.16711238e-02f, 5.76309003e-02f, 6.57705590e-02f, -1.07744418e-01f, 1.38176978e-02f,
  -1.07761435e-01f, 2.89918147e-02f, 1.30579367e-01f, 1.14067875e-01f, 3.26315244e-03f, 4.61749621e-02f, -8.95002391e-03f, 8.81036669e-02f, 1.52174244e-02f, 6.02257065e-03f,
  -4.28464636e-02f, 3.33371833e-02f, 1.02743716e-03f, -6.03950508e-02f, -3.51305120e-04f, 6.60390332e-02f, -9.72612482e-03f, 7.00638890e-02f, 9.39222947e-02f, -6.26926795e-02f,
  1.46139830e-01f, -9.83942375e-02f, 5.70421480e-02f, 3.16106565e-02f, -6.78352192e-02f, 4.72334027e-02f, -1.16777390e-01f, -8.51458535e-02f, 1.18794814e-01f, 2.78004296e-02f,
  -4.67389217e-03f, 5.56094050e-02f, 9.99781936e-02f, -4.97241830e-03f, -9.81965568e-03f, 4.68752384e-02f, 1.20798305e-01f, 7.21807107e-02f, -2.03754790e-02f, 8.74509886e-02f,
  3.98785286e-02f, 1.50541484e-01f, 1.14581190e-01f, 7.07270056e-02f, 7.94198662e-02f, 9.52391252e-02f, 4.46566381e-02f, 1.64684802e-02f, -3.37181501e-02f, 1.24955617e-01f,
  1.89653412e-01f, -5.41520584e-03f, 6.05852008e-02f, -2.82545239e-02f, 3.54088433e-02f, -1.06694577e-02f, 1.57548994e-01f, 8.31967220e-02f, -9.03573912e-03f, -1.73702296e-02f,
  -5.51402308e-02f, 1.18620813e-01f, 9.77500994e-03f, -8.61375257e-02f, 1.48697242e-01f, 7.39554316e-03f, 1.12145104e-01f, -3.80023383e-02f, 3.76141928e-02f, 9.17899329e-03f,
  9.86191705e-02f, 9.45433453e-02f, -5.27168065e-02f, 1.30432010e-01f, -1.22164749e-01f, 1.90852985e-01f, 5.65163717e-02f, 8.47326443e-02f, -9.99347121e-02f, 3.20280269e-02f,
  -3.40426601e-02f, 2.62752939e-02f, -7.47112185e-02f, -2.92826269e-04f, -4.02165111e-03f, -7.68353641e-02f, 3.82929742e-02f, -3.73104997e-02f, -9.64325964e-02f, -6.72055706e-02f,
  -1.16374917e-01f, 7.96536282e-02f, -8.06937367e-02f, 5.50325848e-02f, 1.53570634e-03f, -6.74080849e-02f, -2.68628206e-02f, -2.24659382e-03f, 1.04219683e-01f, -9.38187726e-03f,
  -3.18340063e-02f, 4.26236503e-02f, 1.08479582e-01f, 9.73513052e-02f, 4.34008725e-02f, 7.10590854e-02f, 1.97695270e-01f, 9.10977796e-02f, -1.65664684e-02f, 8.53078961e-02f,
  -2.01366037e-01f, 2.17648735e-03f, -4.75750007e-02f, -1.72782421e-01f, 2.15934083e-01f, 2.83571128e-02f, -1.64659717e-03f, 1.23788439e-01f, -5.02326945e-03f, -1.59268945e-01f,
  -4.56256494e-02f, 1.02039300e-01f, 1.07321031e-01f, 4.97285053e-02f, 7.02973157e-02f, 7.30390549e-02f, 1.46558762e-01f, 1.02114026e-02f, 5.01248911e-02f, 1.09303899e-01f,
  6.38985708e-02f, -2.77568540e-03f, 1.75464600e-01f, 1.07909694e-01f, -9.32825636e-03f, 1.48885444e-01f, 2.85686776e-02f, -1.03976861e-01f, 1.76637292e-01f, -6.95377169e-03f,
  2.24020369e-02f, 2.01057876e-03f, 2.70475745e-02f, -3.39711159e-02f, 7.63797611e-02f, 6.47222698e-02f, 8.28474015e-02f, -1.33709209e-02f, -8.94964207e-03f, 8.16222131e-02f,
  1.91160068e-01f, -1.37801170e-01f, 1.87173467e-02f, 2.92856316e-03f, -3.76025541e-03f, -1.23023771e-01f, 1.00895427e-01f, -1.05803944e-01f, 1.32770851e-01f, 8.19846541e-02f,
  9.71349180e-02f, 7.39445984e-02f, 1.38135329e-01f, -7.70344138e-02f, 1.00626033e-02f, -6.04823008e-02f, 1.36918530e-01f, 3.38615961e-02f, -4.61508557e-02f, 6.67024311e-03f,
  6.48903521e-03f, 7.48685300e-02f, -9.97388735e-02f, 1.48822200e-02f, -2.87155490e-02f, -3.68337991e-04f, 1.08928062e-01f, -1.18328393e-01f, -8.44902247e-02f, -1.36289164e-01f,
  9.39451307e-02f, -2.60825339e-03f, -1.17204383e-01f, -7.02716485e-02f, 2.45403945e-02f, 1.20598912e-01f, 9.88673717e-02f, 6.58426480e-03f, -2.19543800e-02f, -1.10079817e-01f,
  7.71814142e-04f, 7.41865635e-02f, 1.16911054e-01f, -1.86933186e-02f, 1.65758550e-01f, -2.29448080e-02f, -5.47879599e-02f, 4.25295671e-03f, -4.48860861e-02f, -5.80481291e-02f,
  -3.43060307e-03f, 1.14160649e-01f, -4.73758299e-03f, 2.04897877e-02f, 3.20768431e-02f, 2.20627245e-02f, 5.04266024e-02f, 9.42689031e-02f, -6.86986148e-02f, -7.19671622e-02f,
  6.39919862e-02f, -4.06288281e-02f, 2.11742558e-02f, 1.93394423e-01f, -7.95980915e-02f, 4.69722003e-02f, -1.11249862e-02f, -2.67717261e-02f, 6.78523304e-03f, 7.73757473e-02f,
  -3.76663953e-02f, -1.07307531e-01f, 7.17736557e-02f, 4.10074033e-02f, 1.25815906e-02f, 9.67004150e-02f, -1.01378793e-02f, -4.65855747e-03f, 3.37466076e-02f, 1.60905963e-03f,
  2.94320807e-02f, 6.92592710e-02f, 1.69147283e-01f, 1.57814905e-01f, -3.30950059e-02f, 5.76766469e-02f, -6.64241165e-02f, -8.03698823e-02f, -2.05729213e-02f, 9.65847597e-02f,
  3.65609117e-02f, 8.32272172e-02f, 1.23312421e-01f, 2.96992529e-02f, 4.16167490e-02f, -1.04306519e-01f, -4.81732860e-02f, -1.40180122e-02f, 3.49535011e-02f, -3.98306027e-02f,
  -4.38151509e-02f, 7.33335763e-02f, -4.90459204e-02f, -8.81162137e-02f, -1.67225562e-02f, -8.12595114e-02f, -8.23751464e-02f, -2.34802021e-03f, 8.11586976e-02f, -3.51779014e-02f,
  -4.53844257e-02f, -1.07753187e-01f, -5.20361215e-02f, 3.04971077e-02f, 3.72840241e-02f, -1.06253050e-01f, 5.96930645e-02f, 4.74831238e-02f, -4.38894518e-02f, 8.86823758e-02f,
  1.55685857e-01f, 1.98024303e-01f, 1.63535163e-01f, -2.24914532e-02f, -4.71301749e-02f, -2.34250668e-02f, 4.04834487e-02f, 6.74325749e-02f, 8.81438777e-02f, 9.20675918e-02f,
  6.18389733e-02f, 3.69645245e-02f, -8.02384466e-02f, -1.13947466e-01f, 1.31003574e-01f, 9.62056667e-02f, 1.00339673e-01f, -3.98524329e-02f, -7.54849985e-02f, 4.10784781e-02f,
  1.02706946e-01f, 5.04791923e-02f, -2.85292305e-02f, 1.09901272e-01f, -9.14774984e-02f, 9.33526680e-02f, -1.20065048e-01f, -4.56574336e-02f, 5.59082367e-02f, 1.22932382e-01f,
  -5.65166734e-02f, 1.31245375e-01f, 1.84324868e-02f, 1.77282952e-02f, -3.36267101e-03f, 4.30594385e-02f, -1.41980559e-01f, 1.27981082e-01f, 7.52756819e-02f, 4.11084257e-02f,
  1.08854525e-01f, -1.15233939e-02f, 2.55464483e-02f, 4.56829704e-02f, 9.48405266e-02f, -8.15895572e-02f, 1.08514123e-01f, 1.50206480e-02f, 8.03162605e-02f, -1.55160893e-02f,
  5.15203513e-02f, -4.40851375e-02f, 3.44324447e-02f, 9.94201675e-02f, -1.30917951e-01f, -1.95673201e-03f, 1.03228904e-01f, -3.94127481e-02f, 1.03420526e-01f, 4.37576473e-02f,
  6.22470281e-04f, -1.11139566e-01f, -9.00125355e-02f, 1.66002885e-02f, 9.14560333e-02f, 9.73106846e-02f, 6.32723719e-02f, -9.81678739e-02f, 7.06916898e-02f, -1.02416478e-01f,
  6.14695884e-02f, -2.03364752e-02f, -2.18905695e-02f, -1.05139278e-01f, 6.82992786e-02f, -1.17622003e-01f, 5.84705360e-03f, 7.45463977e-03f, -3.71213295e-02f, -6.07236437e-02f,
  -4.40067835e-02f, 3.28409374e-02f, 1.33955693e-02f, 5.84174730e-02f, 6.75239861e-02f, -8.35792720e-02f, -1.11046918e-01f, 1.79558694e-02f, 1.17010728e-01f, 1.76800843e-02f,
  -6.82802275e-02f, 2.08793476e-01f, -4.74428236e-02f, -4.89848815e-02f, 4.83148061e-02f, 1.92165852e-01f, 4.23249863e-02f, 1.39694940e-02f, 1.69618949e-02f, 2.70475864e-01f,
  -1.52788147e-01f, 5.96490279e-02f, 6.33292645e-02f, 1.48975357e-01f, 2.69727800e-02f, 2.68183738e-01f, 3.25018503e-02f, -1.19091868e-01f, 2.56734461e-01f, -1.14183828e-01f,
  2.19443634e-01f, 1.21469356e-01f, 9.61570814e-02f, 5.11058345e-02f, -1.40294492e-01f, 7.70108774e-02f, 9.30075943e-02f, -1.34440079e-01f, 5.45405634e-02f, 4.41314764e-02f,
  -1.01600461e-01f, -5.50394468e-02f, -8.95308738e-04f, -2.38357764e-02f, -9.57089737e-02f, -5.81718087e-02f, 3.40053290e-02f, 6.35593832e-02f, 2.05862354e-02f, 2.07080528e-01f,
  5.25107272e-02f, -3.12282294e-02f, 1.79091558e-01f, 8.93764198e-02f, 1.90302983e-01f, -1.29396901e-01f, -1.20931016e-02f, 8.55251700e-02f, 1.37029618e-01f, 1.17586210e-01f,
  5.62568605e-02f, 1.71970487e-01f, -1.26054704e-01f, 3.14021297e-02f, -7.48490021e-02f, -7.45614395e-02f, -4.73687649e-02f, 8.43664259e-02f, -9.92878526e-02f, -1.32120308e-02f,
  5.33889383e-02f, 1.85523957e-01f, 4.84329835e-02f, 1.29112497e-01f, 5.40377013e-02f, -8.74894857e-02f, -1.60061270e-02f, 9.22770277e-02f, -4.40525822e-02f, -4.49784696e-02f,
  8.80875885e-02f, 1.08922146e-01f, -5.16942106e-02f, 1.14713825e-01f, 1.30291656e-01f, -9.77909416e-02f, -4.61170971e-02f, -6.78132102e-02f, 3.60766724e-02f, -5.31543791e-02f,
  1.48558259e-01f, 7.95371309e-02f, -1.23138629e-01f, -6.20294027e-02f, 8.70361477e-02f, -2.20966376e-02f, -1.63444248e-03f, 9.89811774e-03f, 1.59274250e-01f, 6.63614869e-02f,
  -9.32998881e-02f, 1.35202318e-01f, 2.26856992e-02f, 9.11075100e-02f, 9.04064029e-02f, -6.18122630e-02f, -8.52160156e-02f, 3.01644634e-02f, -8.26015100e-02f, -3.85359935e-02f,
  1.11098222e-01f, 6.71711490e-02f, -5.44455871e-02f, 1.21671848e-01f, 3.96612845e-03f, -4.97576557e-02f, -3.39536071e-02f, -8.68680105e-02f, 2.26026475e-02f, 1.05793834e-01f,
  -5.10050319e-02f, -3.42691056e-02f, 1.04791105e-01f, 4.17541806e-03f, 5.80419526e-02f, 5.87080000e-03f, 8.81422162e-02f, 6.99937120e-02f, 1.22356564e-01f, 1.68433383e-01f,
  9.04314294e-02f, -6.85697198e-02f, 1.54430149e-02f, 4.08610143e-02f, -2.99204532e-02f, 4.85264882e-02f, 9.41949114e-02f, 7.76179731e-02f, 8.15031305e-03f, -6.49732202e-02f,
  -5.09370007e-02f, 6.60855547e-02f, -1.12377100e-01f, -9.53989327e-02f, -2.61387415e-02f, 4.88198875e-03f, -7.22246617e-02f, -1.05610035e-01f, 5.56715131e-02f, 6.97066039e-02f,
  -1.53457758e-03f, 7.48653933e-02f, -3.40288016e-03f, -6.23124768e-04f, -1.05523787e-01f, -4.12339158e-03f, -1.14878587e-01f, -3.13897841e-02f, -1.13447821e-02f, -2.11321097e-02f,
  2.78239306e-02f, 3.27441916e-02f, 1.02862611e-01f, -7.58030564e-02f, -2.63250172e-02f, 8.18633437e-02f, 6.42974675e-02f, -9.43731666e-02f, 6.02131821e-02f, -8.12844560e-02f,
  3.42700630e-02f, 5.49428351e-02f, -4.15551439e-02f, -4.69046682e-02f, 2.48746714e-03f, -1.12707168e-01f, 7.10942149e-02f, 2.86598522e-02f, -1.26875117e-02f, -1.13133244e-01f,
  -1.08657628e-01f, 7.90027827e-02f, 6.80933222e-02f, 1.18895970e-01f, 1.45239085e-02f, 1.19783372e-01f, 1.23690136e-01f, 8.71487986e-03f, -7.67845958e-02f, -7.50966817e-02f,
  2.70773862e-02f, 2.53940094e-02f, 1.37360189e-02f, 1.27745792e-01f, -1.19088128e-01f, -1.04781380e-02f, 7.50412047e-02f, 5.65544777e-02f, 2.41103135e-02f, 7.59303942e-02f,
  -1.03675772e-03f, -7.01232851e-02f, 3.44638795e-01f, 1.21354088e-01f, 2.87377030e-01f, 1.40229121e-01f, 7.01232180e-02f, 2.61348248e-01f, -1.26004130e-01f, -2.08928570e-01f,
  -6.18444160e-02f, -1.96110025e-01f, 2.52894402e-01f, 8.36271346e-02f, -5.45658246e-02f, -4.40696143e-02f, 5.65603785e-02f, 7.20905066e-02f, 9.34981406e-02f, 3.64836827e-02f,
  4.25008386e-02f, 1.90969512e-01f, -4.71089184e-02f, 1.28116131e-01f, 8.04588124e-02f, 9.51818973e-02f, 2.17407003e-01f, 6.46660179e-02f, -5.95471449e-02f, 1.52455688e-01f,
  2.06036076e-01f, 2.02927217e-01f, 1.98383391e-01f, 1.15265325e-02f, 8.85274261e-02f, -1.03252761e-01f, -1.20716030e-03f, -3.77827063e-02f, -1.18368991e-01f, -8.65716636e-02f,
  -3.34450463e-03f, 6.81826547e-02f, 9.21553373e-02f, 1.52431861e-01f, -1.06475458e-01f, 6.84258863e-02f, 7.34231398e-02f, 1.01701602e-01f, 2.00169548e-01f, -1.36564076e-01f,
  8.25093761e-02f, 1.54787868e-01f, 1.11630429e-02f, 4.89562191e-02f, 1.62947197e-02f, 7.64444144e-03f, 1.30622685e-01f, 2.05906421e-01f, 1.33684322e-01f, 1.86729506e-01f,
  2.03345314e-01f, -6.21640608e-02f, -4.48599197e-02f, -9.38025787e-02f, 1.39368087e-01f, -5.47059206e-03f, -5.09872399e-02f, 2.05308780e-01f, -8.99403542e-03f, 5.90874851e-02f,
  -1.71107631e-02f, 1.59689292e-01f, -1.13802224e-01f, 4.41063754e-02f, 1.63351685e-01f, 4.45823371e-02f, -1.90505460e-01f, -6.89382851e-03f, 1.38025969e-01f, 6.40686881e-03f,
  -4.48180437e-02f, 1.11622505e-01f, -1.13980122e-01f, -1.61215533e-02f, -1.85583811e-03f, 9.26721692e-02f, -9.97901037e-02f, 1.14001743e-01f, 2.93524247e-02f, 1.34822854e-03f,
  -3.25079113e-02f, -4.60479259e-02f, -1.14676036e-01f, 7.61853233e-02f, 5.15442602e-02f, -3.45770158e-02f, 1.02601796e-01f, -7.08197290e-03f, 4.35335115e-02f, 7.99484253e-02f,
  2.78474808e-01f, -2.72035133e-02f, -1.81194201e-01f, -5.12957945e-02f, 3.36855873e-02f, -5.68302460e-02f, 5.64966053e-02f, 7.11462721e-02f, 1.13216341e-01f, 8.67194086e-02f,
  -3.04693077e-02f, 7.77828842e-02f, -6.86747134e-02f, -7.26403669e-02f, 3.26953307e-02f, 2.07507387e-01f, 2.08739698e-01f, 9.93882194e-02f, 3.92658152e-02f, -5.91309927e-02f,
  -4.65980098e-02f, 5.41682355e-03f, 9.60909203e-02f, 8.45247507e-02f, 8.61902237e-02f, 9.63368639e-02f, 1.17694430e-01f, 8.10328129e-05f, -4.02818732e-02f, 1.11850381e-01f,
  -7.16348067e-02f, 6.43557459e-02f, 7.55046681e-02f, -7.13688880e-02f, 3.58370878e-02f, -6.70150965e-02f, 4.13962044e-02f, -3.05792429e-02f, 1.03919595e-01f, 5.81229478e-02f,
  -1.40736118e-01f, -1.23199768e-01f, 4.22231518e-02f, -4.24124524e-02f, -1.04202501e-01f, -9.38860327e-02f, 2.13984177e-02f, -3.14286947e-02f, -2.91062649e-02f, 1.23531863e-01f,
  -6.53107762e-02f, -8.27674270e-02f, -1.14671215e-01f, 9.24468562e-02f, -3.32462974e-02f, 1.31878898e-01f, 8.18558708e-02f, -9.93744470e-03f, 3.95424180e-02f, 8.45148787e-02f,
  5.05783260e-02f, -9.68285799e-02f, 1.12025969e-01f, -6.79013059e-02f, -1.54726813e-02f, -3.57755981e-02f, -1.03608668e-01f, 9.32748988e-03f, -6.10672217e-03f, -8.93990509e-03f,
  -2.40082443e-02f, 7.05058202e-02f, -8.41454938e-02f, -5.80770411e-02f, -5.13027199e-02f, 2.49112002e-03f, -1.17525086e-01f, 1.19482882e-01f, -5.08841537e-02f, 1.79985352e-03f,
  7.84005150e-02f, 1.85779687e-02f, 4.03312035e-02f, -1.07329033e-01f, 8.97536948e-02f, 2.90449765e-02f, 1.19205844e-02f, 2.29513478e-02f, -4.99406829e-02f, 1.08820021e-01f,
  5.75284436e-02f, -1.14444330e-01f, -1.13694511e-01f, -2.15191394e-02f, 1.07649140e-01f, -4.01381329e-02f, 3.63722909e-04f, -3.37672345e-02f, 1.71253942e-02f, -8.19234028e-02f,
  -7.24029094e-02f, 1.21158168e-01f, 4.43522334e-02f, -1.22253060e-01f, 1.64236948e-02f, 3.36645618e-02f, 7.95375109e-02f, 1.16924644e-02f, -7.43610412e-02f, 6.09862134e-02f,
  -1.82519890e-02f, 1.15368806e-01f, -2.45905556e-02f, -1.66327041e-02f, 4.00642455e-02f, -2.89510917e-02f, 6.71654493e-02f, 3.09969690e-02f, 1.75880473e-02f, -2.81153191e-02f,
  -7.91786835e-02f, -1.09679617e-01f, 7.53959268e-02f, -9.71446484e-02f, 6.49240464e-02f, 5.25189862e-02f, 7.75890872e-02f, 1.23141274e-01f, -3.03191841e-02f, -1.08560793e-01f,
  2.09033936e-02f, -1.49326678e-02f, -8.76436979e-02f, 1.71494782e-02f, -1.03692763e-01f, -1.03961639e-01f, 6.53712898e-02f, 1.00712784e-01f, -4.22402844e-02f, 3.46657336e-02f,
  6.02906682e-02f, 7.53893405e-02f, 8.43140259e-02f, 8.29209015e-02f, -8.34984556e-02f, -9.26197767e-02f, -4.06991914e-02f, -7.84737468e-02f, 1.19883865e-01f, -7.97942802e-02f,
  1.00724682e-01f, 3.70661840e-02f, -3.59530970e-02f, 5.82891107e-02f, -9.51687917e-02f, -1.00455657e-01f, 2.33150460e-02f, -2.57816911e-02f, 6.85772449e-02f, 1.40260428e-01f,
  -1.05050899e-01f, 1.37041882e-01f, 2.40353383e-02f, 9.41863805e-02f, -2.17438750e-02f, 7.16682076e-02f, -7.18515664e-02f, 3.93291488e-02f, -1.71752080e-01f, -1.07466370e-01f,
  -1.03586078e-01f, -1.00807615e-01f, -1.03331909e-01f, 3.00384201e-02f, 6.65269345e-02f, 7.98932612e-02f, -7.01772049e-02f, 1.36367187e-01f, -5.52567504e-02f, 4.19361256e-02f,
  5.61736934e-02f, 6.09730035e-02f, -3.37647647e-02f, -7.88569450e-02f, 1.56997859e-01f, 1.23787142e-01f, 8.00859034e-02f, 6.31093308e-02f, 3.01071513e-03f, -1.09263510e-01f,
  -6.89250976e-02f, -3.18553075e-02f, -9.57602412e-02f, 2.51954142e-02f, 1.35331005e-01f, -1.14250496e-01f, 6.92985505e-02f, -1.21605106e-01f, -5.75221293e-02f, -1.05789152e-03f,
  2.44153030e-02f, 3.86910401e-02f, 2.43879184e-02f, 2.20768258e-01f, -1.03601523e-01f, -4.23281230e-02f, -6.60680681e-02f, -3.81482095e-02f, -4.06788476e-02f, -9.35830846e-02f,
  -2.56846640e-02f, -1.67328138e-02f, 7.65506402e-02f, 3.46187390e-02f, -4.27684337e-02f, 4.83009443e-02f, -4.99242879e-02f, 2.60039326e-03f, 2.92402841e-02f, -2.34875977e-02f,
  -7.20336586e-02f, 4.57127765e-02f, 2.10234106e-01f, 1.30100250e-01f, 1.29030598e-02f, 1.65762290e-01f, 1.15644097e-01f, 1.70648739e-01f, 1.29914328e-01f, 4.00636718e-02f,
  2.66441479e-02f, -1.25793979e-01f, 3.21216047e-01f, -1.16065405e-01f, 2.82695461e-02f, 5.70847169e-02f, 1.20152041e-01f, -3.93576212e-02f, 1.09619282e-01f, 9.03920233e-02f,
  -2.42358372e-01f, -1.06148481e-01f, 1.53892025e-01f, -1.48669496e-01f, 1.21111400e-01f, -8.46891403e-02f, 1.58684015e-01f, 1.49616703e-01f, 2.80655716e-02f, 1.24679156e-01f,
  1.60515964e-01f, 3.58134136e-02f, 7.87249207e-02f, -4.80552763e-02f, -5.68207540e-02f, 3.61344554e-02f, 1.73895173e-02f, 1.18400585e-02f, -4.38982025e-02f, -5.51110804e-02f,
  -6.80636838e-02f, 1.81897670e-01f, 1.33854970e-01f, 9.36730877e-02f, 4.60281670e-02f, -3.07580456e-02f, -5.23142591e-02f, 6.32340759e-02f, 9.06330794e-02f, -7.11580515e-02f,
  6.21671090e-03f, 1.05668016e-01f, -5.98004796e-02f, -2.91076489e-03f, 1.33380413e-01f, 2.22827820e-03f, 9.78063419e-02f, 1.91582799e-01f, -1.46882400e-01f, 1.24324180e-01f,
  4.68358323e-02f, 2.66675465e-02f, -2.18242966e-02f, -6.05744943e-02f, 1.84885487e-01f, -5.91724254e-02f, -1.25041485e-01f, -1.17408939e-01f, -6.91206157e-02f, -1.27778500e-01f,
  -1.10159092e-01f, -2.47886945e-02f, 5.05551212e-02f, -2.23307814e-02f, 9.84419808e-02f, -5.84283881e-02f, -8.49013776e-02f, 1.51608745e-02f, -7.31496885e-02f, 5.51704364e-03f,
  -1.84499044e-02f, -7.07738101e-02f, -4.26843800e-02f, 8.06750506e-02f, -5.91589436e-02f, -1.04685709e-01f, -5.54039888e-02f, -1.21833207e-02f, 9.27043632e-02f, 4.82412577e-02f,
  5.85173331e-02f, 1.65854879e-02f, -1.57822389e-02f, 6.50880858e-02f, 6.81958348e-02f, -8.77670422e-02f, 2.84295529e-02f, -4.07428518e-02f, -9.05026868e-02f, 9.21427757e-02f,
  -2.63449047e-02f, 1.01501442e-01f, -3.15964967e-02f, -4.65253331e-02f, -4.01184075e-02f, 7.77794197e-02f, 4.65807468e-02f, -9.69325099e-03f, 1.15992520e-02f, 5.28471507e-02f,
  2.83349156e-02f, -3.28090414e-03f, 8.03103969e-02f, -9.74722430e-02f, -3.38885523e-02f, -1.09392218e-01f, 9.04741883e-02f, -9.17365551e-02f, -3.50004286e-02f, 5.15057482e-02f,
  7.74438530e-02f, 5.09183295e-02f, -4.02887948e-02f, -7.76928291e-02f, 6.37169108e-02f, 3.04693379e-03f, -2.13268455e-02f, 2.30653901e-02f, -5.87022491e-02f, -7.45227337e-02f,
  3.50840352e-02f, -4.27458175e-02f, -4.19850089e-02f, 1.07997105e-01f, -1.11236334e-01f, 9.09455568e-02f, 3.00047901e-02f, 1.41943758e-02f, 1.18340984e-01f, 1.32275438e-02f,
  -7.89998621e-02f, -9.83552411e-02f, -8.67892653e-02f, -9.09534618e-02f, -3.69765982e-02f, 7.11771995e-02f, 4.16108780e-02f, 2.31607109e-02f, 9.92053449e-02f, 6.61866367e-02f,
  -7.13899881e-02f, -9.68001112e-02f, 9.68726501e-02f, -6.68910658e-03f, 1.88047942e-02f, 8.00966695e-02f, 3.13349743e-03f, 1.05260789e-01f, 7.54357800e-02f, 4.61482331e-02f,
  8.28960165e-02f, -1.15944736e-01f, -1.16864383e-01f, -2.27130707e-02f, 1.86183706e-01f, 8.96976814e-02f, -1.23082779e-01f, -1.01297438e-01f, -1.17428482e-01f, 6.82840347e-02f,
  -3.62499803e-02f, -5.69401272e-02f, -4.33206223e-02f, 9.63242948e-02f, 4.16636504e-02f, 1.21536933e-01f, 3.45004387e-02f, 1.19904801e-01f, -6.29824474e-02f, 5.92767335e-02f,
  2.36418713e-02f, 6.58630580e-02f, -9.54507738e-02f, -4.61241603e-02f, 5.62469549e-02f, 2.99047790e-02f, 1.52162209e-01f, -3.50429676e-02f, -2.71795690e-02f, -3.48651186e-02f,
  1.30145222e-01f, 1.08095616e-01f, -8.38617310e-02f, 5.51158935e-02f, 1.16156481e-01f, 1.38424933e-01f, 1.19127534e-01f, 5.95473684e-02f, -6.95679635e-02f, 1.56407744e-01f,
  1.17912948e-01f, 1.56854670e-02f, -1.82239916e-02f, 1.96333632e-01f, 7.92703107e-02f, 6.07898384e-02f, 1.67163312e-01f, 8.46430063e-02f, -2.39499286e-02f, 8.40575323e-02f,
  1.34110078e-01f, 2.91545950e-02f, 1.09485909e-01f, 2.93468591e-03f, 1.25348449e-01f, 1.13468073e-01f, 8.35443586e-02f, -9.46054980e-02f, 1.35678928e-02f, -5.61066121e-02f,
  5.14987595e-02f, -6.59358501e-02f, -9.23855044e-03f, 7.24703744e-02f, -4.68735844e-02f, 1.20003849e-01f, 1.73639402e-01f, 9.63376239e-02f, 1.89339578e-01f, -1.58740506e-01f,
  -1.16896868e-01f, 2.58766487e-02f, 1.45871148e-01f, 1.41796291e-01f, 1.25522316e-01f, -1.46997813e-02f, -1.24530168e-02f, 6.29890338e-02f, -1.98979862e-02f, 7.99748860e-03f,
  3.82282473e-02f, -2.31642593e-02f, 1.23551495e-01f, 5.88225760e-02f, 1.37170270e-01f, -5.26702031e-02f, 4.45597805e-02f, 9.47613046e-02f, -8.72532055e-02f, -4.57834452e-02f,
  -1.14548422e-01f, -9.41655487e-02f, -1.08337477e-01f, -6.21491410e-02f, -4.97872569e-02f, 1.51673421e-01f, -4.42683175e-02f, 2.91302763e-02f, 1.55511588e-01f, 1.14343144e-01f,
  2.77764469e-01f, 5.83812930e-02f, 1.96522295e-01f, 5.60149252e-02f, -1.07456453e-01f, -2.43127540e-01f, -1.02104008e-01f, -2.70835012e-01f, 3.29731822e-01f, -1.71929225e-01f,
  -6.11676686e-02f, 6.75543547e-02f, 2.30277632e-03f, -5.92338070e-02f, 1.08360402e-01f, 1.89128727e-01f, -1.93431869e-01f, 1.36966575e-02f, -1.38424739e-01f, -1.46844327e-01f,
  1.20245203e-01f, 1.38743132e-01f, 3.64641398e-01f, -1.14317599e-03f, 8.69411752e-02f, 1.17556289e-01f, 1.67216927e-01f, 3.85430455e-02f, 1.28404751e-01f, 3.12607782e-03f,
  1.46371182e-02f, 3.81687544e-02f, -1.38141245e-01f, 1.33327544e-01f, 1.50700301e-01f, 5.08673266e-02f, -1.62639022e-02f, 1.05224505e-01f, 7.97298327e-02f, 7.07657710e-02f,
  1.67890284e-02f, -4.16364521e-02f, -5.50787114e-02f, 1.77300513e-01f, 1.36655003e-01f, -4.33870256e-02f, 5.49467877e-02f, 1.25574782e-01f, -5.02962759e-03f, -1.19394949e-02f,
  1.42744677e-02f, -1.17025957e-01f, -1.48004796e-02f, 1.64614886e-01f, 8.50689635e-02f, 6.84454069e-02f, 2.09513918e-01f, -1.19604632e-01f, 4.11477964e-03f, -1.08396150e-01f,
  2.89173480e-02f, 1.81386974e-02f, 8.91184509e-02f, 1.17549159e-01f, 2.06550300e-01f, -2.15308387e-02f, 1.66260704e-01f, 2.08197221e-01f, -1.16295330e-01f, -2.52320245e-02f,
  -3.79447360e-03f, 5.06832376e-02f, 1.47485152e-01f, 2.03509793e-01f, -9.83373076e-03f, 1.17664970e-01f, 6.35504723e-02f, -4.73628640e-02f, -2.07441114e-03f, 1.22730032e-01f,
  2.34993324e-01f, 1.82730332e-01f, 4.70305346e-02f, 4.05865312e-02f, 3.45944576e-02f, 6.46565333e-02f, 6.98573738e-02f, -4.91504855e-02f, -9.40608904e-02f, -1.25099090e-03f,
  2.24070817e-01f, -4.42415662e-03f, 7.63435736e-02f, 1.47287399e-01f, -1.27604771e-02f, -4.18554395e-02f, -1.40481189e-01f, 3.78190689e-02f, 7.62444586e-02f, 1.20873041e-01f,
  -2.51469687e-02f, -9.33383331e-02f, -8.59617069e-03f, 2.50690192e-01f, -1.18977472e-01f, 1.12000458e-01f, -5.86637631e-02f, -8.22094679e-02f, 2.28540450e-01f, 1.49902821e-01f,
  -3.50978449e-02f, -8.24737474e-02f, 8.24830905e-02f, -1.06066525e-01f, 8.66489857e-02f, 1.41443149e-03f, -2.32108254e-02f, -9.68436971e-02f, 2.68704258e-02f, 1.73321590e-02f,
  -9.29893181e-02f, -2.35153083e-02f, -7.91832991e-03f, -4.45965752e-02f, 1.58625320e-01f, 5.18019404e-03f, -1.21691562e-01f, -3.55043299e-02f, 1.05795056e-01f, -7.48312920e-02f,
  7.11564943e-02f, 5.00666052e-02f, -3.30783650e-02f, -6.41457215e-02f, -3.77908126e-02f, 2.13051159e-02f, 1.23550422e-01f, -5.17272577e-03f, 8.89345855e-02f, -1.06450461e-01f,
  -1.26527008e-02f, -7.37813115e-02f, -1.27883453e-03f, 3.83902043e-02f, 3.84358391e-02f, 8.78935531e-02f, 5.82289547e-02f, -6.22002501e-03f, 1.03982165e-01f, -1.03398874e-01f,
  -2.01568715e-02f, -3.56530063e-02f, -7.32032508e-02f, 4.29101363e-02f, -8.95012617e-02f, -1.02811687e-01f, 1.80684999e-02f, -4.80121151e-02f, -4.76379283e-02f, 9.56668556e-02f,
  -1.14948235e-01f, -8.02267641e-02f, 1.21785201e-01f, -6.91001117e-02f, 1.12928391e-01f, 1.08496966e-02f, 9.57250744e-02f, -5.52877374e-02f, -3.54710817e-02f, -1.11931995e-01f,
  1.00569390e-02f, 5.55912219e-02f, 4.81551066e-02f, -1.18746348e-01f, 1.10463135e-01f, -1.09345838e-01f, 7.61714857e-03f, -1.17117308e-01f, 7.91535676e-02f, 1.70361961e-03f,
  -7.10209459e-02f, -1.06379434e-01f, 1.22805405e-02f, -8.14505219e-02f, -8.29665065e-02f, 1.18490271e-02f, -9.59711149e-02f, -9.74882394e-02f, -9.89774242e-02f, 9.93804783e-02f,
  -9.92351174e-02f, -6.38237922e-03f, -6.96736276e-02f, -7.34557360e-02f, -1.17372520e-01f, -1.04276493e-01f, -3.24870087e-02f, 1.16122598e-02f, -3.28207910e-02f, 8.57747048e-02f,
  -1.17058583e-01f, -4.58797924e-02f, -1.20928667e-01f, 3.37497853e-02f, 8.67369249e-02f, -5.87334558e-02f, -6.24853149e-02f, 8.99893045e-03f, 1.92586873e-02f, -8.94102305e-02f,
  1.00474976e-01f, -3.82643454e-02f, 7.23254904e-02f, 1.29568223e-02f, -7.10184574e-02f, -1.67066250e-02f, -5.82635030e-02f, 9.42023620e-02f, -2.57204138e-02f, -7.47507736e-02f,
  -8.10009018e-02f, 1.03872448e-01f, -4.89060096e-02f, 2.93908324e-02f, 1.15239844e-01f, -4.82769683e-02f, 2.36201077e-03f, 1.41413929e-03f, 2.79721934e-02f, 2.91419290e-02f,
  3.81717924e-03f, -2.89435927e-02f, -6.12082183e-02f, 4.19935733e-02f, 3.35958451e-02f, 8.89088213e-02f, -1.87940784e-02f, -1.19424053e-01f, 8.27771276e-02f, -1.11752257e-01f,
  -1.08189054e-01f, -6.06549494e-02f, -1.93850864e-02f, 4.60241064e-02f, 1.21631056e-01f, 1.47188138e-02f, 1.09426826e-02f, -8.32624510e-02f, 9.83658955e-02f, -1.11779973e-01f,
  -1.28241228e-02f, -5.07797934e-02f, -7.52286911e-02f, 2.73596868e-02f, 1.16491050e-01f, 5.17513268e-02f, 3.45915407e-02f, -6.12448081e-02f, -1.15442686e-02f, -4.69904132e-02f,
  1.45394821e-02f, 1.18388154e-01f, -5.33001162e-02f, 3.69015820e-02f, 1.06755599e-01f, 8.91235769e-02f, 5.49813770e-02f, 7.08423704e-02f, 4.50156145e-02f, 6.75856024e-02f,
  3.66869532e-02f, 3.61477435e-02f, 1.37273297e-01f, 8.13453943e-02f, 8.08853097e-03f, -8.21728334e-02f, -8.11454430e-02f, -3.89367482e-03f, -9.89538133e-02f, -1.82143133e-02f,
  -1.13009609e-01f, 9.52709317e-02f, 1.36231840e-01f, 3.90845053e-02f, -3.01194517e-03f, -3.40852886e-02f, -9.15773213e-02f, 1.43593073e-01f, -1.42601281e-01f, 5.70596717e-02f,
  7.94286951e-02f, 8.19965377e-02f, 7.55230114e-02f, 8.48117247e-02f, 1.24241538e-01f, 1.38165625e-02f, -4.69472706e-02f, 1.18751302e-01f, -8.08373541e-02f, -1.10207297e-01f,
  1.16194881e-01f, 3.34433503e-02f, 5.91219701e-02f, 6.39087260e-02f, -2.35369969e-02f, -3.55480835e-02f, 5.62911257e-02f, -6.33186381e-03f, 1.40144601e-02f, 1.30747199e-01f,
  -2.25318801e-02f, 2.76907198e-02f, 6.19597659e-02f, 7.87608847e-02f, 4.95690145e-02f, -2.95495428e-02f, -3.15502658e-02f, 1.00941330e-01f, -3.83516103e-02f, -6.43173009e-02f,
  -1.04445964e-01f, 1.71708707e-02f, 8.00452977e-02f, 4.50656600e-02f, 1.04637749e-01f, 5.86594045e-02f, -6.87432587e-02f, -3.82723399e-02f, -7.12337941e-02f, 3.75086814e-02f,
  5.01299128e-02f, 1.52663495e-02f, -6.40899837e-02f, 2.31668223e-02f, -4.31419276e-02f, -4.49646935e-02f, 2.88352370e-02f, 3.37738581e-02f, -5.08806109e-02f, 7.89534599e-02f,
  -8.85576531e-02f, 1.89990457e-02f, 5.88756613e-02f, 1.23696774e-02f, 1.72443353e-02f, -3.69325802e-02f, 8.30594152e-02f, -7.66608864e-02f, -1.07546672e-01f, -9.20292363e-02f,
  -4.40091360e-04f, -1.81763563e-02f, -6.12687357e-02f, -8.70755985e-02f, -3.33613269e-02f, 9.86856669e-02f, -9.14229006e-02f, 1.04686685e-01f, -5.84085919e-02f, -1.58028249e-02f,
  -1.92067102e-02f, 4.70593013e-02f, -1.11741707e-01f, -3.71456146e-02f, 4.21438254e-02f, 8.05092743e-04f, -1.11099429e-01f, 1.09271765e-01f, -1.01121046e-01f, -1.09695986e-01f,
  2.57405434e-02f, -5.99846728e-02f, 1.00329015e-02f, -7.17712864e-02f, -7.22407997e-02f, -4.76188362e-02f, -1.16711348e-01f, -7.51255006e-02f, 1.14816995e-02f, -1.13868259e-01f,
  -6.91636279e-02f, 7.10597485e-02f, 4.14673463e-02f, 1.67779669e-01f, 4.42224666e-02f, 6.44209832e-02f, 4.68519283e-03f, -7.93547276e-03f, 1.80886433e-01f, 1.81836963e-01f,
  -4.05026786e-02f, -2.67574675e-02f, -2.00437963e-01f, -6.95775598e-02f, 6.35303333e-02f, -2.88388077e-02f, -6.95028901e-02f, 9.79268923e-03f, 4.00590599e-02f, 1.80633813e-01f,
  -8.78036544e-02f, -4.68403697e-02f, 2.08888762e-03f, -5.59098013e-02f, 6.41002730e-02f, 3.82671952e-02f, 2.29900144e-02f, 1.36599079e-01f, 3.38261366e-01f, 2.13997476e-02f,
  -1.70314703e-02f, 6.58879280e-02f, -6.28617927e-02f, -1.36539400e-01f, -7.49718100e-02f, -1.00916466e-02f, -1.48273513e-01f, 3.11852515e-01f, 3.05579931e-01f, -9.22245346e-03f,
  1.31414622e-01f, -1.25447214e-01f, 4.93078567e-02f, -1.05175205e-01f, 1.76360354e-01f, 5.66180907e-02f, 2.68314295e-02f, 3.05477172e-01f, -1.75201625e-01f, 1.99296370e-01f,
  -1.02495112e-01f, 4.94220518e-02f, -4.58058082e-02f, 4.72938605e-02f, -3.73370759e-02f, 7.37140104e-02f, 9.59538072e-02f, 1.68464929e-01f, 7.65302852e-02f, 1.70214757e-01f,
  2.23052293e-01f, 1.02034084e-01f, -3.24320048e-02f, 1.36027381e-01f, -4.35574129e-02f, 8.97400081e-02f, 1.69261351e-01f, -4.50618602e-02f, 6.44067153e-02f, -3.57751623e-02f,
  1.64725006e-01f, 1.03706092e-01f, 7.35093746e-03f, 5.46763800e-02f, -1.69339254e-01f, 1.93190932e-01f, 1.59252524e-01f, -1.22635784e-02f, 6.34960607e-02f, 2.64029158e-03f,
  9.06522050e-02f, 4.38470393e-02f, 6.40959889e-02f, -4.57026549e-02f, 1.01268031e-01f, 1.49698749e-01f, 1.96420833e-01f, -1.83503348e-02f, 1.00289539e-01f, 5.96437566e-02f,
  -1.17126733e-01f, -8.14271495e-02f, -5.36138639e-02f, 6.69558644e-02f, 1.29993930e-01f, -2.81141102e-02f, 2.93781087e-02f, -6.07290529e-02f, 8.85486789e-03f, 1.37812182e-01f,
  -2.41177991e-01f, 2.21504703e-01f, 2.31783792e-01f, -7.31259165e-03f, -4.80780415e-02f, -1.32162357e-03f, 1.14492111e-01f, 1.39385834e-01f, 9.67310891e-02f, -8.91522914e-02f,
  -5.59875630e-02f, 2.14278717e-02f, -7.96345621e-02f, 2.74216086e-01f, 2.20110128e-03f, -1.53074250e-01f, -1.51027724e-01f, 5.16329287e-03f, -4.85965572e-02f, 1.62377477e-01f,
  -1.32791355e-01f, 2.80637369e-02f, 1.51067138e-01f, 6.90558031e-02f, 1.45402197e-02f, 1.15130089e-01f, -2.35400796e-02f, 8.87945108e-03f, 1.34715125e-01f, 1.38213292e-01f,
  9.51816216e-02f, 1.88322917e-01f, 9.84613746e-02f, -4.78260219e-02f, 1.84988268e-02f, -2.51229201e-02f, -1.16285153e-01f, 1.31621182e-01f, 2.63993274e-02f, -1.07216304e-02f,
  -3.15098137e-01f, -7.77814612e-02f, 1.98101718e-03f, 1.00328438e-01f, 6.29579350e-02f, 4.57259566e-02f, -5.33933379e-02f, 1.42905161e-01f, 1.71703517e-01f, 8.03606361e-02f,
  -1.24159858e-01f, 1.17253900e-01f, -4.93356325e-02f, -2.78872345e-02f, -3.53406034e-02f, -6.34132773e-02f, 1.96893200e-01f, 4.99572456e-02f, 6.75877556e-02f, 1.23341389e-01f,
  -3.71870957e-02f, 8.28963071e-02f, 1.08228847e-02f, -6.21081283e-03f, 2.64244020e-01f, 1.90766856e-01f, 1.08535409e-01f, -6.86147436e-02f, -4.62722871e-03f, -1.59409061e-01f,
  -9.93535146e-02f, 1.13472797e-01f, 2.00925916e-01f, -1.25564665e-01f, 1.39978737e-01f, 2.85846889e-01f, 8.87521077e-03f, 1.44160986e-01f, 1.45942941e-01f, 1.06733460e-02f,
  -2.68174186e-02f, 2.22803559e-02f, -1.09964468e-01f, 1.15493849e-01f, -8.60338211e-02f, -1.35242581e-01f, 1.90936491e-01f, 7.03373030e-02f, -5.46278805e-02f, 1.29425094e-01f,
  1.64805949e-01f, 1.25227943e-01f, -1.74669009e-02f, 3.25576551e-02f, 1.74738988e-02f, 4.39261049e-02f, 1.03866681e-01f, -8.83928221e-03f, -9.00044516e-02f, -8.42737872e-03f,
  -1.32224530e-01f, -8.84325877e-02f, -4.15239111e-02f, -1.19072907e-01f, -2.79492121e-02f, 9.23836455e-02f, 2.45651454e-02f, 4.40783575e-02f, -3.77597921e-02f, -7.65995905e-02f,
  -1.19198784e-01f, 1.24458253e-01f, 7.18834102e-02f, 1.21153288e-01f, 4.74915542e-02f, 1.43491969e-01f, -3.44559476e-02f, 4.86543402e-02f, -5.46219200e-02f, -5.91313234e-03f,
  6.66672550e-03f, 1.27611563e-01f, 1.20453732e-02f, 7.29974285e-02f, 9.27196220e-02f, -4.40906547e-02f, -9.19043198e-02f, 9.35348645e-02f, 1.75263897e-01f, -3.28830741e-02f,
  6.08531907e-02f, -4.56989324e-03f, -8.34029466e-02f, -2.29781941e-02f, 7.86162242e-02f, 1.31490752e-01f, 5.38504943e-02f, -1.25512838e-01f, -5.52388728e-02f, 1.54331654e-01f,
  1.14038244e-01f, -8.32276344e-02f, -3.16649452e-02f, 1.47761539e-01f, 5.39268628e-02f, -1.13236822e-01f, -8.70412588e-02f, -5.45839444e-02f, 4.94832918e-02f, -1.51973769e-01f,
  1.02485612e-01f, 8.47253948e-02f, 5.34861349e-02f, -9.85575691e-02f, 4.87374421e-03f, -3.47429290e-02f, -3.50715257e-02f, -1.12808198e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -5.47404103e-02f, 1.39381409e-01f, 1.32962450e-01f, 2.42473520e-02f, 6.56810328e-02f, 1.83502451e-01f, -7.35572577e-02f, 8.11277553e-02f, 4.34174538e-02f, -3.67011391e-02f,
  2.41032898e-01f, -1.45419384e-03f, 1.85857117e-01f, 7.48664886e-02f, 2.12279677e-01f, 1.12349600e-01f, 3.96967642e-02f, 7.07988068e-02f, 1.48911580e-01f, -1.38161974e-02f,
  1.62137032e-01f, 1.51502937e-01f, -1.03582547e-03f, 6.33609816e-02f, -3.15491892e-02f, 9.12432671e-02f, 3.00326496e-02f, 7.40916654e-02f, 1.27904117e-01f, -1.10076450e-01f,
  2.54872084e-01f, 3.85348871e-02f, -9.29507166e-02f, 2.38432705e-01f, 4.19347398e-02f, -8.10169652e-02f, -7.05235600e-02f, -4.83963899e-02f, 1.85104683e-01f, 9.55671221e-02f,
  -6.92768395e-02f, 3.78688760e-02f, 7.63580650e-02f, 1.89812899e-01f, -2.54915990e-02f, -6.69376552e-02f, 5.66872582e-02f, -7.06069544e-02f, 9.02214050e-02f, 1.02437310e-01f,
  1.78467706e-01f, 3.77616175e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.16680637e-01f, 3.57120037e-02f, 1.13761105e-01f, -6.52152160e-03f, -8.19576159e-02f, 1.34301275e-01f, -5.46345189e-02f, 2.01963261e-01f, -1.12757728e-01f, -1.98471192e-02f,
  -1.04044579e-01f, -1.19177096e-01f, -1.03556430e-02f, 1.23162597e-01f, -5.41251041e-02f, -9.34394300e-02f, -8.41586664e-02f, -7.23487064e-02f, -8.05739909e-02f, -9.18363687e-03f,
  -1.71965361e-02f, -1.22215480e-01f, 6.93427697e-02f, 1.10348463e-01f, -1.03127323e-01f, 1.11821014e-02f, -1.56485468e-01f, 3.63816656e-02f, -3.76877338e-02f, 5.84961548e-02f,
  1.35188952e-01f, -5.54297790e-02f, -1.16239548e-01f, 1.13882851e-02f, 2.61255186e-02f, 1.84837148e-01f, -7.01967925e-02f, 1.39476717e-01f, 9.00303423e-02f, 3.81521359e-02f,
  -8.60629827e-02f, 1.14492457e-02f, -2.51664426e-02f, -8.14419091e-02f, 3.52071822e-02f, 6.20458126e-02f, -2.78797671e-02f, -7.65499771e-02f, 1.02916220e-03f, -1.28297687e-01f,
  1.83393896e-01f, 1.12481706e-01f, -8.82466733e-02f, 1.87601864e-01f, -8.04874599e-02f, -7.38045722e-02f, -2.62615047e-02f, -9.35177132e-02f, 7.82116503e-03f, 5.60942898e-03f,
  -1.87270224e-01f, -1.46140337e-01f, -7.11037144e-02f, 5.57006150e-03f, 1.07928656e-01f, -9.47070941e-02f, -7.42315948e-02f, 1.06341280e-01f, 5.06467558e-02f, 1.24461599e-01f,
  -5.88763766e-02f, 4.81262021e-02f, -1.52328745e-01f, -3.63228507e-02f, 8.50796606e-03f, -7.82925263e-02f, 2.19700299e-02f, 1.80646032e-02f, -4.59999926e-02f, 7.83332437e-03f,
  3.43472101e-02f, -1.05560757e-01f, -1.71008240e-02f, -1.92589238e-02f, -1.23844117e-01f, -9.73601788e-02f, -1.26003101e-01f, -4.95583452e-02f, 9.40032005e-02f, 6.84125498e-02f,
  -1.44668430e-01f, 3.68514918e-02f, -2.93418169e-02f, 3.98939289e-02f, 8.39430541e-02f, -1.21624991e-01f, -1.13463841e-01f, -1.65043607e-01f, -7.35049648e-03f, 1.49220064e-01f,
  -3.99731696e-02f, -5.00002652e-02f, 3.05902604e-02f, 1.00677155e-01f, 4.72244546e-02f, 1.04603656e-01f, -6.58505261e-02f, -1.43634928e-02f, -2.50277407e-02f, -5.14038876e-02f,
  -7.61433989e-02f, -9.87893119e-02f, 6.29934296e-02f, -1.30134225e-01f, 1.41223222e-01f, -4.84901527e-03f, -6.78289682e-02f, 9.58128553e-03f, 1.40563414e-01f, 9.58852842e-02f,
  -3.71557251e-02f, -6.15873449e-02f, 8.38696864e-03f, -1.01321906e-01f, 7.73328245e-02f, -6.97509423e-02f, 2.12119091e-02f, -1.19258702e-01f, 3.59497704e-02f, 1.28165826e-01f,
  1.26376087e-02f, 1.28780585e-02f, 9.39362124e-03f, 2.27546580e-02f, 1.47213042e-01f, -1.43780679e-01f, -4.43351492e-02f, -8.17143321e-02f, 1.50953412e-01f, 1.76326215e-01f,
  1.51203126e-01f, -9.48112831e-02f, -6.00017607e-02f, -8.86584520e-02f, 5.83029240e-02f, 1.50976516e-02f, 1.12872021e-02f, 1.13672026e-01f, 1.24775827e-01f, 1.31529838e-01f,
  -3.29735093e-02f, -1.21637501e-01f, -8.52361619e-02f, -6.40461370e-02f, -1.67707831e-01f, 9.98210236e-02f, 1.02692351e-01f, -1.12052364e-02f, -1.20072663e-01f, 8.16051438e-02f,
  -1.20673850e-01f, 6.39233440e-02f, 1.24375530e-01f, 4.91724610e-02f, -5.84727526e-02f, 1.08098582e-04f, -3.35386246e-02f, -8.91396962e-03f, -1.25143468e-01f, 9.38797146e-02f,
  -1.16445675e-01f, -5.31362370e-02f, -1.03594311e-01f, 2.00144082e-01f, -7.22488835e-02f, 2.94288322e-02f, -2.96408217e-02f, 2.48593129e-02f, 4.18033637e-02f, -4.80294451e-02f,
  -4.88807485e-02f, -4.51707020e-02f, 1.98588923e-01f, 9.23915301e-04f, 1.21765614e-01f, -9.76663530e-02f, 1.27125774e-02f, 4.60845418e-02f, 7.31898919e-02f, -1.25831217e-01f,
  -2.15784889e-02f, 5.00080884e-02f, -5.98165467e-02f, 3.45333219e-02f, -5.19138984e-02f, 6.20090403e-02f, -9.18490812e-02f, 6.48954883e-02f, 5.85063808e-02f, -1.45094823e-02f,
  -7.61271864e-02f, 4.89379317e-02f, 6.61328854e-03f, 9.55151767e-02f, -3.78670134e-02f, 7.58261681e-02f, -1.24154694e-01f, -9.82597843e-02f, -3.19410861e-02f, -3.30785364e-02f,
  8.92694220e-02f, 8.75812843e-02f, -4.94960099e-02f, 1.20693661e-01f, -4.00610231e-02f, 1.22035652e-01f, 5.02273515e-02f, -1.01311402e-02f, -1.15181543e-01f, 1.00688763e-01f,
  1.90839339e-02f, -1.31886974e-01f, 1.07194796e-01f, -1.30967125e-01f, -3.64026912e-02f, -8.26715454e-02f, 4.15057391e-02f, 1.32651702e-01f, -5.13074622e-02f, -1.91666523e-03f,
  1.16591327e-01f, 8.76671821e-03f, -1.12768076e-02f, -6.69725686e-02f, -1.20840758e-01f, 1.56277232e-02f, 5.08721992e-02f, 1.32392049e-01f, -3.63967977e-02f, 3.08243800e-02f,
  -1.09045813e-02f, -1.35872379e-01f, 1.68407589e-01f, 3.20603102e-02f, -5.91136664e-02f, -4.58404496e-02f, 9.57511514e-02f, -7.78913945e-02f, -1.16342334e-02f, 2.52306908e-02f,
  -1.71909165e-02f, 8.63491446e-02f, -1.51383832e-01f, -1.78750545e-01f, -3.44349034e-02f, -6.61259219e-02f, -8.52791145e-02f, -1.61412936e-02f, -1.12766705e-01f, -7.36164451e-02f,
  3.44684720e-02f, 8.46926719e-02f, -9.65057835e-02f, 1.06455229e-01f, -1.20879328e-02f, 5.95615916e-02f, 3.21867354e-02f, -3.02481465e-03f, -6.40160739e-02f, 6.89311549e-02f,
  -7.20915645e-02f, 3.74441296e-02f, -9.31820348e-02f, 8.67131818e-03f, -2.34495359e-03f, 1.20292582e-01f, 1.20581768e-01f, -9.79139656e-02f, -1.19236335e-01f, -6.51155636e-02f,
  -3.99731100e-02f, 1.00192390e-01f, -3.76808122e-02f, -4.65449765e-02f, -3.53525728e-02f, 6.43472448e-02f, -7.89699052e-03f, 1.35638952e-01f, 5.00652660e-03f, -9.17271078e-02f,
  -3.03767901e-02f, -7.62647539e-02f, 1.04299463e-01f, 2.35640649e-02f, 2.89016888e-02f, 6.40791878e-02f, -5.38881049e-02f, -1.03477575e-01f, -4.83521819e-02f, -7.33395591e-02f,
  -1.02643169e-01f, -1.17613472e-01f, 9.01045799e-02f, 3.63205969e-02f, 3.09261167e-03f, 1.25657573e-01f, -7.54041895e-02f, 1.26150316e-02f, -1.98502187e-02f, 6.62671924e-02f,
  -2.05651261e-02f, 7.53984554e-04f, 4.30595092e-02f, 6.53762072e-02f, -1.67247385e-03f, -1.67692918e-02f, 1.14299161e-02f, 1.23351447e-01f, 7.68785700e-02f, -2.34558992e-02f,
  1.58053920e-01f, 1.07709140e-01f, 1.11112893e-01f, 1.08314892e-02f, 8.00624490e-02f, 1.15293793e-01f, 1.42094523e-01f, 8.36379081e-02f, -1.79376170e-01f, -1.29024193e-01f,
  -2.37701777e-02f, -2.07843520e-02f, 9.00094435e-02f, -2.02818424e-01f, 6.53881952e-02f, -6.82804137e-02f, -1.14211768e-01f, 6.57878667e-02f, -3.87819000e-02f, -7.91355968e-02f,
  -1.18621841e-01f, 2.80965641e-02f, 3.32052968e-02f, 1.51907504e-02f, 7.29060099e-02f, 4.04868759e-02f, -1.25849694e-01f, -8.09522718e-02f, 2.24687047e-02f, -1.46012798e-01f,
  -2.52207052e-02f, -1.19733036e-01f, -8.25785771e-02f, 7.73642659e-02f, -3.83580029e-02f, -7.41381496e-02f, -1.04743592e-01f, 1.03581779e-01f, 7.68357739e-02f, -7.60837272e-02f,
  2.44775079e-02f, -1.30019441e-01f, -6.33576959e-02f, 2.76512671e-02f, 5.55721391e-03f, 1.19438991e-01f, 3.35157961e-02f, -2.01435685e-02f, -7.59706572e-02f, -3.51372249e-02f,
  1.57142401e-01f, -8.90221000e-02f, -1.70980878e-02f, -1.61815047e-01f, 1.89392373e-01f, 5.05048297e-02f, 4.70530614e-02f, 8.70219320e-02f, -3.74761224e-02f, 1.17358074e-01f,
  -8.59772265e-02f, 3.67897823e-02f, 3.38097587e-02f, 7.36033171e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.27976391e-02f, 7.70029798e-02f, -1.36116579e-01f, 1.40322104e-01f, -1.15176588e-01f, -9.86792613e-03f, 4.80954684e-02f, -6.35202006e-02f, 1.56138465e-01f, 2.39169687e-01f,
  -1.14084341e-01f, 5.47344200e-02f, 1.28505781e-01f, 1.48863912e-01f, -3.86398211e-02f, 1.28144175e-01f, -9.09090266e-02f, 1.07985601e-01f, -1.71221979e-02f, -7.84439966e-02f,
  3.30173895e-02f, 7.55664706e-02f, 2.01382235e-01f, 4.89236563e-02f, 8.94173980e-02f, -7.89204016e-02f, 1.48105249e-01f, -8.28417838e-02f, 7.24596158e-02f, 1.69756964e-01f,
  8.59317109e-02f, 1.05534256e-01f, 1.46669939e-01f, 1.93136968e-02f, -6.56993985e-02f, -1.21876128e-01f, 1.33909687e-01f, 1.18184373e-01f, 5.36854938e-02f, -1.30310908e-01f,
  -3.51098776e-02f, 1.02551781e-01f, 2.42513746e-01f, -2.72794757e-02f, -2.07393039e-02f, 7.09292889e-02f, 3.44589688e-02f, 1.16326243e-01f, 7.55657582e-03f, 8.13428685e-02f,
  -9.14621651e-02f, -5.93532110e-03f, 1.46062085e-02f, 1.43415660e-01f, -1.92536846e-01f, 2.62203626e-02f, 1.16212972e-01f, -4.78494130e-02f, -4.91361097e-02f, -3.96763124e-02f,
  -1.21928610e-01f, 5.70932031e-02f, 1.49323359e-01f, 1.43246111e-02f, 1.10852994e-01f, 7.75798857e-02f, 2.14923155e-02f, 1.33180454e-01f, -2.37771519e-03f, 8.83469209e-02f,
  1.65446460e-01f, -6.23055100e-02f, 5.87493256e-02f, -6.88728094e-02f, 6.78733140e-02f, -2.14413553e-01f, 1.94461998e-02f, 1.93268076e-01f, -1.34659535e-03f, 8.31237063e-02f,
  -1.12369619e-01f, -1.73867851e-01f, 7.60356039e-02f, -1.65093675e-01f, 1.19150095e-02f, 1.75238729e-01f, 1.27281621e-01f, -5.33946827e-02f, -2.92335451e-02f, -3.72962616e-02f,
  -6.94783628e-02f, 8.27764869e-02f, 2.10040007e-02f, 1.58309326e-01f, 1.42726824e-01f, -6.73722327e-02f, 1.36927087e-02f, 1.77795067e-01f, -8.41205195e-02f, 1.79770350e-01f,
  9.48227867e-02f, 5.08540310e-02f, -8.04766715e-02f, 5.57384118e-02f, 1.17234282e-01f, 1.14886627e-01f, 4.59568091e-02f, 5.14330566e-02f, 3.47914547e-02f, 2.35824987e-01f,
  3.19379084e-02f, 5.31088449e-02f, -2.50542089e-02f, -1.30452797e-01f, 1.86073273e-01f, 3.57133597e-02f, -5.32574318e-02f, 1.33715376e-01f, -9.36887190e-02f, 2.11881235e-01f,
  6.06724247e-02f, -4.57591340e-02f, -6.53693313e-03f, 9.65948775e-02f, -2.24244744e-01f, -9.78108719e-02f, -4.07554433e-02f, -9.81306061e-02f, 1.34402439e-01f, -5.54158874e-02f,
  7.06481487e-02f, 1.79261848e-01f, -3.81805524e-02f, 1.07627911e-02f, 1.47756815e-01f, -1.20370880e-01f, 1.30576536e-01f, 2.77883410e-02f, -5.41013926e-02f, -2.26789340e-01f,
  3.61056998e-02f, 2.47854710e-01f, 5.65040782e-02f, -4.07114998e-02f, 4.92945649e-02f, -1.13604456e-01f, -1.01934038e-01f, -1.55356079e-01f, 7.24815950e-02f, 1.49282292e-01f,
  3.37934345e-01f, 3.95008400e-02f, -1.20031528e-01f, 1.05019085e-01f, 1.69198319e-01f, -7.92164057e-02f, 9.18608829e-02f, 1.39052302e-01f, 9.62945148e-02f, 4.15081531e-02f,
  8.35231096e-02f, 1.65181994e-01f, 1.06173687e-01f, 1.00097559e-01f, 3.00487895e-02f, 1.62500575e-01f, -5.11046201e-02f, 2.29327157e-02f, -4.68224920e-02f, -9.75889787e-02f,
  7.34185204e-02f, -9.58899185e-02f, 1.06457092e-01f, 1.70307830e-01f, 3.06889750e-02f, 9.26128123e-03f, -2.86131576e-02f, -1.49413094e-01f, 6.49560466e-02f, 7.77654052e-02f,
  -3.62470821e-02f, 1.33591250e-01f, -2.89085414e-03f, 2.26190269e-01f, -9.34475288e-02f, -4.20530746e-03f, 1.71229199e-01f, 1.14393309e-01f, -1.91727027e-01f, 4.61519063e-02f,
  -4.22451496e-02f, -4.08488326e-02f, 7.93960318e-02f, -1.21616855e-01f, -2.10718587e-02f, -9.66310650e-02f, 4.37024087e-02f, 5.49315885e-02f, -8.01938549e-02f, 2.93317065e-02f,
  1.25892833e-01f, 5.54652773e-02f, 1.63208265e-02f, 7.12015927e-02f, 4.27877493e-02f, -2.83612050e-02f, 6.64173067e-02f, -8.43670294e-02f, -1.36060249e-02f, -6.71605319e-02f,
  9.02726203e-02f, 2.89870799e-02f, 5.65341897e-02f, 4.63492684e-02f, 7.46062770e-03f, -8.26433972e-02f, -5.37607744e-02f, -9.89437625e-02f, 4.76576760e-02f, 8.40163976e-03f,
  -1.22193038e-01f, -1.18073739e-01f, -8.49412903e-02f, 1.06984951e-01f, -4.65512015e-02f, -3.66356894e-02f, -8.27795453e-03f, 1.22757927e-01f, 6.76313192e-02f, 4.71921973e-02f,
  -2.76649147e-02f, -5.36349267e-02f, 9.64183211e-02f, 4.75481637e-02f, 2.60960571e-02f, -2.70014200e-02f, -1.85450986e-02f, 1.15385773e-02f, -1.23576917e-01f, -1.20306961e-01f,
  -5.27858064e-02f, 1.29310131e-01f, 3.42169032e-02f, -1.11978546e-01f, 8.71454105e-02f, -6.59665018e-02f, 8.94554928e-02f, -2.53821686e-02f, -3.86877619e-02f, -3.08905654e-02f,
  -3.30336429e-02f, -7.17466697e-02f, -3.07438225e-02f, 3.52486931e-02f, 8.02870765e-02f, -8.05789232e-02f, 1.01634227e-02f, 4.52818833e-02f, -2.46204864e-02f, 6.79501668e-02f,
  8.24454147e-03f, -2.05043645e-04f, -1.13462441e-01f, -2.13615566e-01f, 1.69648603e-01f, 5.46233952e-02f, 1.88421115e-01f, 2.51602363e-02f, 5.15836962e-02f, 8.22329707e-03f,
  1.21934656e-02f, 1.16870843e-01f, -6.62013441e-02f, -8.56671333e-02f, -1.00949682e-01f, 1.20859906e-01f, -1.42399371e-01f, 9.78290886e-02f, 2.34476745e-01f, -9.21769664e-02f,
  -7.65163731e-03f, -3.00519280e-02f, -2.12863877e-01f, 3.61491889e-02f, 1.99732538e-02f, 8.57289732e-02f, 4.55916196e-01f, 1.12448886e-01f, 5.02211265e-02f, -4.01895717e-02f,
  2.53504813e-01f, 6.62483871e-02f, 3.96791324e-02f, -4.18972708e-02f, -1.16385743e-02f, 7.13881031e-02f, -4.11886908e-02f, -4.62272428e-02f, -6.56593293e-02f, 7.13154078e-02f,
  2.11228207e-02f, 2.24067360e-01f, 1.55930400e-01f, -9.00476873e-02f, -4.17120680e-02f, -1.44836739e-01f, 5.18253967e-02f, -3.07995752e-02f, 3.79454419e-02f, 9.90958288e-02f,
  7.41208419e-02f, 1.63927659e-01f, -4.40371521e-02f, -1.89328194e-02f, -9.19155926e-02f, 3.73442993e-02f, -2.27299154e-01f, -2.24000722e-01f, 1.40962735e-01f, 6.45224899e-02f,
  1.23642884e-01f, 1.33579060e-01f, 4.23101857e-02f, 5.00264727e-02f, -5.90622649e-02f, 1.05972640e-01f, 3.17526422e-02f, -2.05191389e-01f, -7.51089826e-02f, 8.71584490e-02f,
  1.04726508e-01f, 2.19844118e-01f, 4.98206019e-02f, -1.50721639e-01f, -2.80306824e-02f, 1.24817453e-01f, 1.29418448e-01f, 1.44307718e-01f, 2.04267763e-02f, 1.49183005e-01f,
  3.55702527e-02f, -1.54493693e-02f, -5.69711812e-02f, -2.01647691e-02f, -1.15115389e-01f, -2.24330910e-02f, 2.09248476e-02f, -1.11850865e-01f, 5.98629825e-02f, 9.02535096e-02f,
  1.51457831e-01f, -4.59931567e-02f, 2.26301346e-02f, -6.60212487e-02f, -2.38796249e-02f, -1.40651911e-01f, -7.05623720e-03f, -4.64997068e-03f, 1.87060118e-01f, -5.05269282e-02f,
  5.00760078e-02f, 1.38745587e-02f, -1.75448637e-02f, -1.11941390e-01f, 1.29158556e-01f, 1.75156608e-01f, 1.53213829e-01f, 1.12437710e-01f, 7.61656687e-02f, 1.09674133e-01f,
  3.59864160e-02f, -6.64069727e-02f, 1.58706903e-01f, -9.17290524e-03f, 1.97852746e-01f, -5.51619427e-03f, -3.16813141e-02f, 8.57144296e-02f, -3.65060568e-02f, 2.88298074e-02f,
  9.79756638e-02f, -4.03020568e-02f, 1.96309939e-01f, 1.88515514e-01f, 4.81941029e-02f, -1.04999386e-01f, 6.89528212e-02f, 2.83693094e-02f, -7.15049077e-03f, -7.90254474e-02f,
  2.65535489e-02f, 6.55187219e-02f, -8.73707682e-02f, 1.32895127e-01f, 1.25419483e-01f, 3.82557698e-02f, -1.36473104e-01f, 1.75189778e-01f, -8.89181334e-04f, -2.98515111e-02f,
  -7.38980994e-02f, 1.11219905e-01f, -1.45707903e-02f, -1.08483642e-01f, -3.40131372e-02f, -9.77739021e-02f, 6.48593307e-02f, 1.00470953e-01f, 3.72927338e-02f, -6.54449686e-02f,
  4.93882643e-03f, -1.08063512e-01f, 9.06710625e-02f, 3.16964500e-02f, 8.01943988e-02f, 7.99465328e-02f, -7.30837137e-02f, -2.66781915e-02f, 6.36856258e-02f, 1.33383662e-01f,
  -3.56736071e-02f, -1.01183869e-01f, 9.18334275e-02f, 7.52500594e-02f, 1.73442941e-02f, 1.22128744e-02f, 2.29119118e-02f, 9.50794667e-02f, -1.14772402e-01f, -1.04016662e-01f,
  8.55699405e-02f, 9.79756787e-02f, -3.31508256e-02f, -8.19674134e-02f, 1.63274109e-01f, -1.11499727e-01f, -8.12673047e-02f, 8.06375369e-02f, 9.21021104e-02f, -4.32663150e-02f,
  -6.19926192e-02f, -1.65816601e-02f, -8.40781480e-02f, -7.06133544e-02f, -6.71802238e-02f, 4.31774370e-02f, -1.66265354e-01f, -1.12067230e-01f, 1.00005656e-01f, -3.45523632e-03f,
  -3.47124636e-02f, -1.02148622e-01f, -6.47946149e-02f, 1.17666975e-01f, 8.46539661e-02f, 5.72335795e-02f, -1.18369453e-01f, -1.28574222e-01f, 7.20015913e-02f, 1.62245054e-03f,
  -7.61661306e-02f, -4.65062670e-02f, 9.26008448e-02f, 1.07334204e-01f, 1.12354226e-01f, 5.11044217e-03f, -1.01263568e-01f, -1.20103605e-01f, -1.06357254e-01f, 5.29777966e-02f,
  1.72706861e-02f, 5.15911616e-02f, 9.79526341e-02f, -1.09653033e-01f, -1.19522803e-01f, 1.19810412e-02f, -3.07115931e-02f, -9.56347026e-03f, -1.16491668e-01f, -3.02936677e-02f,
  -6.12350218e-02f, -7.72520062e-03f, -3.22161131e-02f, 7.62362359e-03f, 2.90412679e-02f, -8.37916657e-02f, -6.86226040e-03f, 7.92349055e-02f, -6.68003634e-02f, -3.42951231e-02f,
  -9.42529142e-02f, 6.61489293e-02f, 4.96238172e-02f, 2.17243098e-02f, 4.95659038e-02f, 2.05058008e-02f, 9.01589077e-03f, 1.16796032e-01f, 9.47519392e-02f, -1.86424516e-02f,
  4.05792296e-02f, -3.64084467e-02f, 3.53849940e-02f, 2.05885526e-02f, 9.16165560e-02f, 2.17162799e-02f, -1.80915520e-02f, -7.46490285e-02f, 1.04772702e-01f, 3.05584050e-03f,
  -1.04505112e-02f, -9.31548923e-02f, 1.13108359e-01f, -9.49375182e-02f, -1.12197943e-01f, -2.15208251e-02f, -5.66986240e-02f, -8.42954870e-03f, 3.08785699e-02f, 4.43583243e-02f,
  8.15591440e-02f, -9.05009806e-02f, -3.12486268e-03f, -8.79277959e-02f, -2.92423298e-03f, 6.48617297e-02f, 6.84090108e-02f, -5.57364151e-02f, -1.00778915e-01f, -8.89812186e-02f,
  1.18795745e-02f, 4.95305061e-02f, 8.28443468e-03f, -8.99508297e-02f, 1.07329637e-01f, 3.64569798e-02f, -8.09185281e-02f, 3.78289968e-02f, -8.56184661e-02f, -3.55025381e-03f,
  4.13586088e-02f, -8.47361907e-02f, -1.01426378e-01f, -3.66554828e-03f, 6.57194406e-02f, -6.32209629e-02f, -9.88704115e-02f, -1.19191878e-01f, 3.34180780e-02f, 6.85790181e-02f,
  -2.36194395e-02f, -6.14502616e-02f, -2.32151570e-03f, 1.48991849e-02f, -3.78307402e-02f, -8.91552027e-03f, 9.93325002e-03f, 1.16823599e-01f, -7.04612508e-02f, -1.02576919e-01f,
  7.93631261e-05f, -6.13222569e-02f, 7.09823705e-03f, 9.13831294e-02f, -7.08204601e-03f, -8.65359008e-02f, -3.06081716e-02f, 3.82343568e-02f, 1.41642559e-02f, -8.20432231e-02f,
  -5.78827597e-02f, -4.18757424e-02f, 2.79771164e-02f, 1.42611628e-02f, 6.99655488e-02f, -1.13122821e-01f, -1.76866669e-02f, -1.00601301e-01f, -1.52140884e-02f, 4.03906666e-02f,
  -3.36338952e-02f, -2.40053050e-02f, -5.44781908e-02f, -1.07272170e-01f, -4.42701690e-02f, -1.02830753e-01f, 1.20195942e-02f, 7.95457810e-02f, 1.10467546e-01f, 9.57359895e-02f,
  2.12515984e-02f, -2.49769390e-02f, -6.22830801e-02f, -5.65999486e-02f, 7.37755299e-02f, -1.11886159e-01f, 9.43580829e-03f, -4.09772359e-02f, -2.75720432e-02f, -7.44949952e-02f,
  6.70665950e-02f, -4.77592647e-02f, -8.57035443e-02f, 7.77344406e-02f, -7.58154318e-02f, -1.19021855e-01f, -6.85299635e-02f, 1.16896026e-01f, 1.23812221e-01f, 1.09511218e-03f,
  1.14380661e-02f, 1.16502225e-01f, -5.97252399e-02f, -4.84261811e-02f, -5.54126762e-02f, 9.64208990e-02f, -5.01072295e-02f, -1.77817158e-02f, -1.14441156e-01f, 6.68024644e-02f,
  -7.76695609e-02f, -5.37940897e-02f, 4.68384735e-02f, 3.30029801e-02f, 2.38357317e-02f, -1.19544595e-01f, 2.55727228e-02f, -7.06715211e-02f, 1.11784652e-01f, 2.24532727e-02f,
  -3.53197306e-02f, -5.79300858e-02f, 1.01858424e-02f, -6.88063493e-03f, 1.48573006e-03f, -5.20046353e-02f, -1.08162634e-01f, -1.16217472e-01f, 8.74623284e-03f, -1.58787612e-02f,
  1.56005621e-01f, 1.20045364e-01f, 1.76438570e-01f, 7.48041719e-02f, 4.70653549e-02f, -5.61066493e-02f, 6.73972443e-02f, 1.63359374e-01f, -1.41768426e-01f, -1.45541757e-01f,
  -2.11317971e-01f, 8.43121633e-02f, 1.33795962e-02f, 9.08250585e-02f, 1.54978886e-01f, 7.93734342e-02f, -5.30458279e-02f, -2.03616824e-02f, 9.86075178e-02f, -1.62198599e-02f,
  9.41358358e-02f, -8.54402110e-02f, -1.41515294e-02f, 1.31525332e-02f, 1.48265868e-01f, -3.61247808e-02f, 2.86390275e-01f, -3.79267521e-02f, 6.90661892e-02f, 1.70117512e-01f,
  -2.99115896e-01f, 5.00202812e-02f, 1.14733167e-01f, -9.40695256e-02f, -1.45934060e-01f, -1.30860999e-01f, 6.37893528e-02f, 1.65090933e-01f, 1.22092083e-01f, 6.60647675e-02f,
  9.98105854e-03f, -1.11709289e-01f, 1.71460450e-01f, 3.89066637e-02f, 1.22704342e-01f, -5.74397016e-03f, -1.46874502e-01f, 1.20357804e-01f, 9.41828117e-02f, 1.67037342e-02f,
  -2.75983922e-02f, 3.82545143e-02f, -1.18567593e-01f, -7.34739453e-02f, 1.55917034e-01f, 1.64669678e-01f, 5.08214161e-02f, 4.93464805e-02f, -8.19877605e-05f, -8.70996043e-02f,
  3.13701332e-01f, 2.79426932e-01f, 1.34036809e-01f, 9.03260261e-02f, -6.40265495e-02f, -5.99711090e-02f, -1.02990493e-01f, -2.99519766e-03f, -8.20599422e-02f, -6.65742680e-02f,
  -3.94149646e-02f, -7.07171485e-02f, -7.11643323e-02f, 7.11312667e-02f, 1.87100731e-02f, 7.47947544e-02f, -1.70607548e-02f, 8.50063190e-02f, 4.78198528e-02f, -1.15304925e-02f,
  -3.85969207e-02f, 3.05399634e-02f, -9.10456479e-02f, 3.01908311e-02f, 3.81575599e-02f, -4.75988388e-02f, 3.51274423e-02f, 9.78290588e-02f, 8.99020061e-02f, -1.38890771e-02f,
  -4.50611748e-02f, 8.21418390e-02f, 2.83755679e-02f, 6.98960051e-02f, -9.69011784e-02f, 9.65288840e-03f, 8.52765366e-02f, -1.76786315e-02f, -3.44510339e-02f, -6.16526641e-02f,
  -6.83546141e-02f, -3.20816189e-02f, 1.18658967e-01f, -5.27542979e-02f, 4.50627394e-02f, -5.99991828e-02f, -9.16487873e-02f, -7.36024231e-02f, -5.97055256e-02f, -5.97416610e-02f,
  -4.37623598e-02f, 5.13275415e-02f, -1.19347381e-03f, -6.70395866e-02f, 2.16764547e-05f, -9.69859660e-02f, 1.05272084e-01f, -4.76694554e-02f, 4.91460860e-02f, 4.18123491e-02f,
  1.04239121e-01f, -8.06147978e-02f, -5.42389834e-03f, 6.29322827e-02f, 4.93129343e-02f, -1.19403109e-01f, -1.12645648e-01f, 6.71217665e-02f, 1.03309870e-01f, 1.37653977e-01f,
  -3.97210792e-02f, 1.46586612e-01f, 8.52968097e-02f, -3.63887548e-02f, -4.50221226e-02f, 2.74591465e-02f, 1.48846775e-01f, 1.82228327e-01f, -1.71897680e-01f, -7.05999434e-02f,
  -7.33827800e-02f, 1.21311255e-01f, -1.09500051e-01f, 1.68980882e-02f, -3.38963307e-02f, 3.52892913e-02f, -9.92903784e-02f, 1.79618895e-02f, -2.45837000e-04f, -1.20637976e-01f,
  1.37133852e-01f, -1.90598145e-02f, 1.11102141e-01f, 1.12992115e-01f, 1.76673442e-01f, -7.61590153e-02f, 2.08154097e-02f, 1.11886315e-01f, -1.89290792e-02f, -1.55484527e-02f,
  -7.97615945e-03f, -5.06297238e-02f, -5.04806750e-02f, 4.39596772e-02f, 4.82908376e-02f, 1.19309030e-01f, -1.18681863e-01f, -3.70737575e-02f, 7.09512532e-02f, 9.59511325e-02f,
  2.56364495e-01f, -1.80084631e-02f, 1.21731132e-01f, -8.04409608e-02f, -7.67889395e-02f, -1.05362087e-01f, -8.42099786e-02f, -3.55665619e-03f, -2.34637689e-03f, 5.09773977e-02f,
  -5.18551730e-02f, 2.39735082e-01f, 7.27175409e-03f, 1.21636413e-01f, -8.31606388e-02f, -9.95320454e-02f, 9.08373073e-02f, -3.08494773e-02f, 4.69786493e-04f, 1.59401214e-03f,
  -7.73356706e-02f, 6.09626435e-02f, 4.00348231e-02f, 1.16709635e-01f, 5.52922152e-02f, 1.48851171e-01f, 4.25084457e-02f, 9.95503440e-02f, 1.30257785e-01f, 1.74785312e-03f,
  -9.44500640e-02f, 1.05424695e-01f, -1.95409015e-01f, -5.74124865e-02f, -1.01637736e-01f, -2.44518816e-02f, -2.15533692e-02f, -3.32557224e-02f, 5.20649254e-02f, 1.54471751e-02f,
  2.87105255e-02f, -1.22415079e-02f, 1.17072284e-01f, 1.22167446e-01f, 1.29110599e-02f, 2.68189106e-02f, -5.97927086e-02f, 3.68511938e-02f, 2.50789940e-01f, 9.31130126e-02f,
  7.12430701e-02f, -3.53191601e-04f, -2.13209167e-01f, 5.38124442e-02f, 3.87167223e-02f, 3.52603272e-02f, -5.32291755e-02f, -6.85211644e-02f, -8.31905454e-02f, 3.74388020e-03f,
  -1.25387803e-01f, -5.45676239e-02f, 6.59920648e-02f, 3.03307194e-02f, 3.58713530e-02f, 9.39430818e-02f, 9.44436491e-02f, 4.47509699e-02f, -1.00385308e-01f, -6.38823956e-02f,
  5.36382496e-02f, 8.81243646e-02f, 1.16476029e-01f, 8.25080089e-03f, 4.89167273e-02f, 3.48891877e-03f, -6.00887164e-02f, 1.48035884e-01f, 5.80557548e-02f, -5.08247875e-02f,
  -2.63571646e-02f, 1.07585683e-01f, 1.64905563e-01f, 2.21465945e-01f, 1.08305924e-01f, -7.89723471e-02f, -6.09801710e-03f, 8.00132230e-02f, -9.07931128e-04f, 1.91020906e-01f,
  -3.06857713e-02f, 1.69031546e-01f, -1.61945462e-01f, 9.33765993e-03f, 2.10049793e-01f, 1.27763331e-01f, -2.34732814e-02f, 2.11814269e-01f, -6.21360950e-02f, 8.98205116e-03f,
  -1.22718317e-02f, -8.54914170e-03f, 6.75109848e-02f, 2.27199361e-01f, 7.65069127e-02f, 1.32521048e-01f, 1.51156366e-01f, -1.59754515e-01f, -1.68894842e-01f, 5.22833094e-02f,
  1.91167116e-01f, -3.48408930e-02f, 7.60961249e-02f, 6.82062954e-02f, -7.42885983e-04f, 7.24672992e-03f, 1.40157625e-01f, 1.02502212e-01f, -7.25819692e-02f, -6.14153966e-02f,
  8.77347738e-02f, 9.13557932e-02f, 1.29802927e-01f, -1.33852050e-01f, 8.59343857e-02f, 1.07264340e-01f, 9.12961438e-02f, 5.58516234e-02f, 4.57877256e-02f, -1.16915345e-01f,
  -7.75600225e-03f, -1.31426742e-02f, -3.50059979e-02f, 1.10505566e-01f, -5.72816618e-02f, 1.66597202e-01f, 8.92776474e-02f, -3.93569171e-02f, -5.89850806e-02f, -3.84129919e-02f,
  -1.24194421e-01f, 4.10776809e-02f, 1.42045673e-02f, -5.54985553e-02f, -3.62122506e-02f, 1.24170184e-01f, 2.38765776e-02f, 4.93728071e-02f, 2.77642369e-01f, -1.19288117e-02f,
  1.83665529e-01f, 1.73974052e-01f, 1.21236794e-01f, 4.33817618e-02f, 2.25978773e-02f, 1.66228339e-01f, -1.44525379e-01f, 1.51924908e-01f, 4.07800041e-02f, 2.21951246e-01f,
  7.88241774e-02f, -1.09778605e-01f, -8.42344612e-02f, 1.10917985e-01f, 5.26851937e-02f, -1.43228546e-01f, 2.17577994e-01f, 1.94894120e-01f, 4.13744338e-02f, -8.05329457e-02f,
  -3.40876095e-02f, -3.20588909e-02f, 8.35299492e-02f, -6.03918172e-02f, 2.15094313e-01f, -5.95194437e-02f, 1.12094902e-01f, -9.14344713e-02f, 3.09086274e-02f, 5.40397242e-02f,
  2.13310450e-01f, 5.58774248e-02f, -2.17024311e-02f, -9.70717371e-02f, -6.28604740e-02f, 1.87507570e-01f, 4.17267531e-02f, -1.18948661e-01f, -8.65386724e-02f, 1.70296070e-03f,
  1.74687013e-01f, 1.07339114e-01f, 2.18607947e-01f, 1.18296750e-01f, 1.31007312e-02f, -4.12226804e-02f, 1.04345888e-01f, -4.68020402e-02f, 3.84305194e-02f, -4.07146998e-02f,
  1.25122681e-01f, -5.57519719e-02f, -2.09778156e-02f, 4.31007780e-02f, -1.12596512e-01f, -1.58549681e-01f, 8.75924714e-03f, 1.66255571e-02f, 6.54825866e-02f, -1.09271243e-01f,
  1.12201549e-01f, -8.68591294e-02f, -8.78709182e-03f, -1.16810091e-01f, 8.86692142e-04f, -6.29701167e-02f, 1.37303006e-02f, -5.02959043e-02f, 6.51126960e-03f, -2.95423698e-02f,
  -8.84478986e-02f, -1.15520701e-01f, -6.29134402e-02f, 1.07750818e-01f, 5.72654754e-02f, 4.39885445e-02f, -9.50606763e-02f, -8.06259513e-02f, 8.15848485e-02f, 2.05492284e-02f,
  7.16962665e-02f, -5.99508062e-02f, 2.35027056e-02f, -1.11159220e-01f, 8.48089680e-02f, 5.04770614e-02f, 7.53427818e-02f, -6.67761341e-02f, 1.21566877e-02f, 3.83269275e-03f,
  3.28022167e-02f, 9.38826799e-02f, -6.66038543e-02f, -7.54782856e-02f, 4.48849313e-02f, 7.80089060e-03f, -1.22958951e-01f, 5.82255349e-02f, -1.08599924e-01f, -3.61630507e-02f,
  3.29244211e-02f, -7.40262493e-02f, -8.35433826e-02f, 8.95600095e-02f, 6.06322242e-03f, -1.14713445e-01f, 4.48610149e-02f, -3.10266484e-02f, -4.29537371e-02f, 9.18157678e-03f,
  -6.79075792e-02f, 4.61350270e-02f, -1.12867206e-01f, -7.02701956e-02f, 1.77698918e-02f, -1.14977106e-01f, 1.20891593e-01f, -8.89231786e-02f, 7.56694674e-02f, 3.61541547e-02f,
  -5.15450686e-02f, 1.86414516e-03f, 4.56975028e-03f, 9.56428945e-02f, -5.03996126e-02f, -8.89436454e-02f, -1.03604093e-01f, 1.06722370e-01f, -1.00039713e-01f, -1.23365019e-02f,
  -7.85222650e-02f, -1.95918977e-02f, -1.83119681e-02f, 5.29970825e-02f, 9.03838798e-02f, -4.54500876e-02f, 7.05105346e-03f, 1.03326067e-01f, 5.59653752e-02f, -4.75581512e-02f,
  -1.00743316e-01f, -9.13617760e-02f, 1.10603012e-01f, 3.70759750e-03f, -6.54116869e-02f, -8.14408716e-03f, -1.07975528e-01f, 1.03555493e-01f, 4.05720770e-02f, 3.46727297e-02f,
  -1.01292171e-01f, -1.35878716e-02f, 6.25314042e-02f, 9.77285951e-02f, 1.09798372e-01f, 6.70838356e-02f, 1.14842437e-01f, -1.24885418e-01f, 3.90250199e-02f, -1.09491184e-01f,
  -1.10430844e-01f, 2.27627158e-02f, -2.45942213e-02f, 9.82208401e-02f, 6.44173548e-02f, -6.17612973e-02f, 6.28424948e-03f, 9.33304578e-02f, -1.03001349e-01f, -1.21619068e-01f,
  -2.81972680e-02f, 8.68020132e-02f, -5.83911203e-02f, -9.33483988e-02f, -4.47656997e-02f, -1.22107640e-01f, 5.89325726e-02f, 5.89816011e-02f, 1.12286858e-01f, -6.53877556e-02f,
  8.97670984e-02f, 2.09465511e-02f, -1.81335323e-02f, -8.10273439e-02f, 1.02313221e-01f, 1.20299891e-01f, -8.47127363e-02f, 4.58731800e-02f, -1.36874085e-02f, 4.43109013e-02f,
  8.98883585e-03f, 3.48420478e-02f, 1.22650571e-01f, -4.25776206e-02f, 5.41217849e-02f, 1.01770386e-01f, 9.80054513e-02f, 2.45595314e-02f, -1.09252475e-01f, 1.16682537e-01f,
  2.56303817e-01f, 1.11182295e-01f, 1.44948691e-01f, 1.46577552e-01f, -1.28435373e-01f, 1.10498965e-01f, -6.91517070e-02f, -3.76611389e-02f, 7.05400929e-02f, 1.90819889e-01f,
  -1.06685638e-01f, 1.09007053e-01f, 1.16637982e-01f, 4.06716652e-02f, -1.22455940e-01f, -3.83810885e-02f, 1.57394987e-02f, -1.00572608e-01f, 1.60505460e-03f, 6.89258007e-03f,
  1.31123215e-01f, -7.39404978e-03f, 1.65529460e-01f, 1.43683732e-01f, 6.60478845e-02f, -4.93733073e-03f, -3.84854637e-02f, 3.31162363e-02f, 1.41655698e-01f, -1.48569629e-01f,
  -8.41394439e-02f, 3.54827866e-02f, 3.66657823e-02f, 3.94280851e-02f, 1.75649494e-01f, 5.22602461e-02f, 8.44555721e-02f, 8.43693838e-02f, 1.75385371e-01f, 1.27465099e-01f,
  4.72027734e-02f, -3.47798727e-02f, 5.40775545e-02f, 3.83893703e-03f, -3.05241998e-02f, 1.61482647e-01f, -6.14921339e-02f, -5.36318347e-02f, 6.47151694e-02f, -6.76631629e-02f,
  -1.34959565e-02f, -1.11532569e-01f, 1.79929435e-01f, -7.72689804e-02f, 1.18720636e-01f, 9.85939652e-02f, 9.00098756e-02f, -5.65547831e-02f, 1.20583870e-01f, -5.45325503e-02f,
  -6.41913563e-02f, -9.18662995e-02f, -5.75830974e-02f, -9.59737599e-02f, -1.02015011e-01f, -1.08784117e-01f, 7.03111803e-03f, -6.57240003e-02f, 7.83461034e-02f, -9.90128145e-02f,
  5.79889044e-02f, -7.80752599e-02f, -2.36939900e-02f, 1.25441805e-01f, -1.04780942e-01f, 6.92296028e-02f, 2.28504781e-02f, 4.83924374e-02f, -8.79551172e-02f, -9.50767193e-03f,
  9.67468470e-02f, -3.68449949e-02f, -7.66816437e-02f, 8.44802037e-02f, -4.53493297e-02f, 3.15721589e-03f, 7.34292343e-02f, -1.05561681e-04f, -1.07730366e-01f, -1.10432602e-01f,
  2.15012766e-02f, 3.50239761e-02f, 2.57859435e-02f, -8.36445764e-02f, 1.31420061e-01f, -1.51916072e-02f, 8.92267153e-02f, 1.01196598e-02f, -3.92697118e-02f, 9.89701524e-02f,
  1.10740162e-01f, 9.43905264e-02f, -1.15921311e-02f, -4.26252931e-02f, -4.70846221e-02f, -1.82029903e-02f, 1.02088727e-01f, -7.93116912e-02f, -1.09221376e-01f, 5.27141839e-02f,
  -3.66842560e-02f, -2.13608760e-02f, 5.73384985e-02f, 7.77158141e-02f, -7.33568966e-02f, 7.79743716e-02f, 3.26534435e-02f, 1.38186455e-01f, -4.26256433e-02f, -2.87529826e-02f,
  7.21153319e-02f, 9.99708101e-02f, 5.06414399e-02f, 4.44862545e-02f, 1.30372256e-01f, 1.24250604e-02f, 1.36740699e-01f, -2.65484869e-01f, 1.49203911e-01f, -6.95056915e-02f,
  5.90822026e-02f, -1.31915554e-01f, 7.61312097e-02f, 5.54664284e-02f, -3.40691060e-02f, 2.14358605e-02f, -1.00052960e-01f, -1.39312476e-01f, 4.63046096e-02f, -5.11995470e-03f,
  2.12114565e-02f, 1.44074168e-02f, 1.85312703e-01f, 9.13551822e-02f, -1.47716522e-01f, -2.30058022e-02f, 8.51025954e-02f, 2.75862906e-02f, 8.46967176e-02f, 1.10817164e-01f,
  2.39851817e-01f, -6.80515096e-02f, 2.19489127e-01f, 1.90751955e-01f, 1.57713994e-01f, -9.79981422e-02f, -1.02149069e-01f, -9.48871225e-02f, -2.30275895e-02f, 5.46353608e-02f,
  -5.55389412e-02f, -1.36650249e-01f, -6.05885386e-02f, -1.20155804e-01f, -5.11158593e-02f, 7.68853053e-02f, 2.09765285e-01f, -8.02031755e-02f, 8.65311325e-02f, -4.94336989e-03f,
  -1.76164016e-01f, -5.40923104e-02f, -5.79323098e-02f, 6.61460683e-02f, 4.81549390e-02f, 2.44470701e-01f, -4.46190387e-02f, -1.40954908e-02f, -3.47609818e-02f, -8.98001119e-02f,
  -1.18175440e-01f, -2.45403349e-02f, 9.71666425e-02f, 1.54707119e-01f, 1.61501899e-01f, -4.60058488e-02f, -1.04312643e-01f, 1.64039701e-01f, 2.00788707e-01f, -2.00163480e-02f,
  1.57258198e-01f, -9.35527608e-02f, 1.31597206e-01f, 1.75168157e-01f, -8.74025971e-02f, -1.63820386e-01f, 6.81942552e-02f, 3.74669224e-01f, -9.46991220e-02f, 7.12674558e-02f,
  -7.16344593e-03f, -1.39724404e-01f, 6.72302395e-02f, -4.02125753e-02f, 2.16918454e-01f, -6.85477033e-02f, 3.82426590e-01f, 1.05395146e-01f, 1.21831648e-01f, 1.08964428e-04f,
  2.01125279e-01f, 7.88742527e-02f, 5.76906539e-02f, 2.63733149e-01f, 3.39630634e-01f, -3.12530659e-02f, 9.39977393e-02f, 2.62145936e-01f, 2.00459033e-01f, 1.25160351e-01f,
  -1.15950711e-01f, -9.12802294e-03f, 8.75036940e-02f, -1.53389543e-01f, 5.95697910e-02f, 1.31150603e-01f, 3.45226437e-01f, -7.46712536e-02f, -2.91691013e-02f, 1.42442778e-01f,
  1.86225891e-01f, -6.58759698e-02f, -5.94810285e-02f, -1.25829518e-01f, -1.49389118e-01f, -2.46091280e-02f, -5.08324988e-02f, 7.25752115e-02f, -2.17219025e-01f, 1.00629129e-01f,
  -7.19093606e-02f, -5.80451600e-02f, 6.84104040e-02f, -4.84522013e-03f, -1.69817537e-01f, 1.88775361e-01f, 4.16453853e-02f, -3.90582420e-02f, -1.99949500e-04f, 6.78083003e-02f,
  -6.85225800e-02f, -9.61310044e-02f, -2.97971955e-03f, -9.49428752e-02f, 6.37181923e-02f, -3.21898684e-02f, -4.07978930e-02f, -5.61421104e-02f, 3.39047350e-02f, 7.02692941e-02f,
  -1.27854412e-02f, 8.13838542e-02f, 2.33866945e-02f, 1.13400303e-01f, -1.07539535e-01f, -9.10874829e-02f, -6.89861029e-02f, 7.18834624e-02f, 7.18265772e-02f, -8.55422840e-02f,
  1.00822538e-01f, -1.14347301e-02f, 8.10206905e-02f, -1.79295354e-02f, -8.72334093e-02f, -7.74536505e-02f, -1.21008821e-01f, -3.65650393e-02f, 3.31164896e-02f, -5.17163202e-02f,
  -1.32744713e-03f, 1.28054991e-01f, 9.30914059e-02f, -6.52007908e-02f, 1.80495679e-02f, -8.92411843e-02f, 8.53193551e-03f, 5.72910719e-02f, -7.72297233e-02f, -2.17989851e-02f,
  3.15924510e-02f, -8.08033720e-02f, 1.13244548e-01f, 6.79744333e-02f, 6.14751391e-02f, 6.89488277e-02f, 9.85255539e-02f, 5.17407730e-02f, 2.73513235e-02f, -5.93274236e-02f,
  8.21626652e-03f, -2.25567464e-02f, 2.02477276e-02f, -5.44041060e-02f, -8.41182917e-02f, 2.64262371e-02f, -1.23465240e-01f, -1.24917284e-01f, 9.70030017e-03f, 1.06164820e-01f,
  -1.17029078e-01f, -7.60410577e-02f, 7.55902007e-02f, -4.31668898e-03f, -7.99219832e-02f, 1.26169864e-02f, 8.40384290e-02f, -4.04512882e-02f, 1.05070360e-01f, 1.49662539e-01f,
  1.08982511e-01f, 1.70275897e-01f, -4.39589061e-02f, 2.16607675e-02f, -2.20267139e-02f, 1.63811907e-01f, 4.61519398e-02f, -9.28754061e-02f, 1.06561445e-01f, -1.89001560e-02f,
  1.25909187e-02f, 9.17167962e-02f, -4.86498699e-02f, 5.95912859e-02f, 1.02531388e-01f, -7.13257268e-02f, 1.08189151e-01f, 2.87168492e-02f, 1.20830067e-01f, -4.66335528e-02f,
  6.33673072e-02f, 9.78759527e-02f, 1.36285841e-01f, -7.77500030e-03f, -3.84909399e-02f, 2.07516830e-03f, -1.52091645e-02f, -4.11601365e-02f, -4.90639098e-02f, 1.93550587e-02f,
  -9.05212536e-02f, -3.72936614e-02f, 1.11442171e-01f, -5.16633205e-02f, 8.92445818e-02f, 1.13855682e-01f, -5.37062697e-02f, -8.96583274e-02f, 4.88527045e-02f, 5.78394830e-02f,
  -1.18146531e-01f, -5.90659492e-02f, 1.20445788e-02f, 1.19242847e-01f, -9.45650861e-02f, 1.73031822e-01f, -4.36558314e-02f, -8.10854658e-02f, -1.03134826e-01f, -1.05326928e-01f,
  2.46838499e-02f, 8.50211382e-02f, 4.78841737e-02f, -5.37636168e-02f, -8.76618996e-02f, -5.86447231e-02f, 9.37275216e-02f, 6.56458959e-02f, -1.19501986e-02f, 2.81537976e-03f,
  -8.45752358e-02f, 6.72928840e-02f, 1.19402066e-01f, 1.27838990e-02f, 5.60368709e-02f, -1.23667397e-01f, 2.66594868e-02f, 5.51971272e-02f, -8.72799605e-02f, 3.81653383e-02f,
  4.26677894e-03f, -9.06616263e-03f, -8.66928026e-02f, -1.61628261e-01f, 1.97861921e-02f, -3.52443159e-02f, 6.46654889e-02f, 9.36638266e-02f, 1.31766796e-01f, 2.15853006e-02f,
  4.49182466e-02f, 4.90871146e-02f, -4.82211933e-02f, 1.06388004e-02f, 9.12307128e-02f, -4.45272177e-02f, 1.77215457e-01f, 1.15413979e-01f, 1.33796751e-01f, 1.34987473e-01f,
  1.38488766e-02f, -6.32248893e-02f, -2.74278857e-02f, -9.25728828e-02f, 1.03896923e-01f, -7.84810707e-02f, 8.87850598e-02f, 7.05668554e-02f, -6.69116806e-03f, -1.22198753e-01f,
  -5.55404574e-02f, -2.98651159e-02f, -2.29603015e-02f, -6.80649057e-02f, 5.10600396e-02f, 3.33999507e-02f, -2.12153420e-02f, -1.00393549e-01f, 2.50523351e-03f, 3.48995477e-02f,
  2.16249004e-02f, -8.22516275e-04f, 8.90662447e-02f, 4.60440293e-02f, 1.45564647e-02f, -5.16473204e-02f, -9.69855785e-02f, -1.24780647e-01f, 9.47391763e-02f, 6.28982782e-02f,
  -2.95419339e-02f, 8.53825659e-02f, -5.73338568e-02f, 4.88169380e-02f, 2.67145168e-02f, -7.34236017e-02f, 5.09395897e-02f, 1.14900507e-01f, 1.09217800e-01f, -6.84626400e-02f,
  -1.10435486e-01f, -6.18700162e-02f, -1.23593338e-01f, -8.48644599e-02f, 3.88754569e-02f, 2.33573932e-02f, -6.51712194e-02f, -7.80120073e-03f, 1.20981939e-01f, 1.19742893e-01f,
  6.83347285e-02f, -4.31104973e-02f, -1.05699889e-01f, -1.18723281e-01f, -6.42533973e-02f, 5.90861924e-02f, -1.20557122e-01f, -9.63578746e-02f, -6.68290779e-02f, 1.00629151e-01f,
  9.18660536e-02f, -1.12445336e-02f, 3.68688144e-02f, -5.05623706e-02f, -7.05464929e-02f, -4.22395244e-02f, 1.15431752e-03f, 3.58380913e-03f, -5.57342768e-02f, 5.13494462e-02f,
  -5.85817508e-02f, 5.76778017e-02f, -1.00209631e-01f, 7.21043199e-02f, 1.08308420e-01f, -7.80249983e-02f, -2.02578902e-02f, -6.71286210e-02f, -7.02139661e-02f, 1.42222615e-02f,
  7.60260820e-02f, -3.76228429e-03f, -4.59425114e-02f, 1.10896960e-01f, 5.07030971e-02f, -1.00691654e-01f, -1.09472774e-01f, 7.56237432e-02f, 5.08593172e-02f, -1.15723647e-01f,
  -1.17671438e-01f, -9.37919319e-02f, 9.14591178e-02f, -2.82251351e-02f, 1.07321180e-02f, -4.01798598e-02f, -3.26144360e-02f, 1.73841380e-02f, 1.50642276e-01f, -4.40420136e-02f,
  4.52487394e-02f, -7.34093040e-02f, 1.02552123e-01f, -5.08364141e-02f, 7.98509493e-02f, 6.64192215e-02f, -7.34614953e-02f, 6.20267652e-02f, -2.12428719e-03f, 2.16054954e-02f,
  -6.67401850e-02f, 1.27302241e-02f, -1.04184836e-01f, -9.21197459e-02f, 1.03196241e-01f, 1.11016318e-01f, 1.46155819e-01f, -8.01664740e-02f, 9.56813172e-02f, 3.21931541e-02f,
  5.29663824e-02f, 4.16909494e-02f, 6.94117844e-02f, 1.40143126e-01f, 2.12446466e-01f, -1.12864226e-01f, 9.67745483e-02f, 1.40192851e-01f, -1.27314134e-02f, 5.12160547e-02f,
  3.64183672e-02f, 1.64718200e-02f, 9.02044848e-02f, -5.65728061e-02f, -2.02520960e-03f, 4.53493372e-02f, 7.93267116e-02f, -8.95090494e-03f, -4.25831117e-02f, -1.48750581e-02f,
  7.64649408e-03f, -1.03929333e-01f, -3.42997797e-02f, 6.79543987e-02f, -1.02028079e-01f, 4.00698138e-03f, 4.25596349e-02f, 1.67839870e-01f, -3.82350050e-02f, -7.62812048e-02f,
  -4.29533944e-02f, 1.19354479e-01f, -6.73028380e-02f, 2.55857222e-02f, -9.42929983e-02f, 7.72750750e-02f, 2.97033805e-02f, -4.54198867e-02f, -1.05674312e-01f, 1.67057235e-02f,
  9.28166434e-02f, -6.19416907e-02f, -1.37954745e-02f, -1.08154036e-01f, -1.17204497e-02f, -1.28897969e-02f, -4.95061576e-02f, 1.06457166e-01f, -4.32970785e-02f, 1.10300452e-01f,
  -1.17025129e-01f, -6.29264396e-03f, -2.44580600e-02f, -6.95452169e-02f, -7.76175708e-02f, -7.99463987e-02f, -1.86879858e-02f, 1.07353166e-01f, 8.06590840e-02f, -2.35334784e-03f,
  -2.76417769e-02f, -2.73795109e-02f, 6.94473907e-02f, 5.98155521e-02f, 1.29102126e-01f, -1.18949555e-01f, -1.16579197e-01f, -1.03379764e-01f, 1.88560523e-02f, 1.71112418e-02f,
  1.31370366e-01f, -9.39069018e-02f, -1.11927621e-01f, 5.79618253e-02f, 1.09275654e-01f, -5.01037017e-02f, 6.33057952e-02f, 4.14154828e-02f, -2.97011174e-02f, -8.39239266e-03f,
  1.00527652e-01f, 1.38168717e-02f, -3.67660932e-02f, -4.59850654e-02f, -1.36559187e-02f, 1.07700408e-01f, -1.18307881e-01f, -5.06608747e-02f, 8.71669874e-02f, 3.01701743e-02f,
  -7.12458864e-02f, -1.22905843e-01f, 1.33146614e-01f, -1.11320153e-01f, -5.55030219e-02f, -1.96761116e-02f, -1.76085923e-02f, 9.44558159e-02f, 8.55306238e-02f, -7.86497891e-02f,
  1.32917553e-01f, 4.06081900e-02f, 1.75290242e-01f, 1.64096639e-01f, 8.01519156e-02f, 1.37394682e-01f, 2.48914603e-02f, 3.41818333e-02f, -1.21766478e-01f, -1.63346440e-01f,
  1.36810124e-01f, -1.40814474e-02f, 2.20454022e-01f, 1.32564381e-01f, -4.79397886e-02f, -1.37597710e-01f, -2.19339710e-02f, -7.95690343e-02f, 8.52776393e-02f, 1.83174849e-01f,
  -6.34436756e-02f, -1.64001640e-02f, -2.30130404e-02f, 1.22678922e-02f, -2.15697929e-01f, 5.18525997e-03f, 1.42468929e-01f, -4.34255451e-02f, 1.99542399e-02f, -1.02087811e-01f,
  1.54440165e-01f, -7.88225755e-02f, 1.46598876e-01f, 6.84880391e-02f, 4.02029864e-02f, 5.38146049e-02f, -6.14621565e-02f, 2.45039873e-02f, 1.24399746e-02f, -1.10536806e-01f,
  -5.40035032e-02f, 2.17068702e-01f, 7.26746861e-03f, 4.07298692e-02f, -4.71920110e-02f, 6.55624494e-02f, -3.35740112e-02f, 1.40524045e-01f, 1.36490852e-01f, 1.26455948e-01f,
  -5.34075238e-02f, 1.20295763e-01f, -3.16580497e-02f, 1.00672096e-01f, 5.14249727e-02f, 5.30056022e-02f, 1.39714047e-01f, -1.17481954e-01f, -2.62888893e-02f, -9.46598351e-02f,
  -1.41634569e-01f, 1.05688676e-01f, 3.12612027e-01f, -7.78521150e-02f, 2.92644978e-01f, 6.07861280e-02f, 2.62270659e-01f, 2.26071149e-01f, 1.86708242e-01f, 1.27371952e-01f,
  1.57883778e-01f, 1.96901217e-01f, -9.72218812e-02f, 1.79993644e-01f, -1.97798833e-01f, -1.23713896e-01f, 8.51972327e-02f, -1.09871589e-01f, -1.19657233e-01f, 2.38848571e-02f,
  2.74064511e-01f, -6.27005920e-02f, -7.50572085e-02f, 1.52208626e-01f, 1.57194620e-03f, -4.93532084e-02f, 9.05578882e-02f, 9.46413353e-03f, 5.98878367e-03f, 1.17097124e-01f,
  8.55391175e-02f, -5.08247018e-02f, 1.49240121e-01f, 1.01136729e-01f, 1.28091499e-01f, 3.28013524e-02f, -3.40253323e-01f, -6.80254474e-02f, 5.84981255e-02f, -8.81678015e-02f,
  -1.59905702e-01f, 1.06869198e-01f, 8.25956240e-02f, 1.34173959e-01f, 8.30332860e-02f, -6.28110319e-02f, 5.70301861e-02f, -1.08132847e-01f, 1.59003574e-03f, 8.36603269e-02f,
  -1.17285503e-02f, 2.70469248e-01f, -1.59433335e-01f, 5.54397628e-02f, 1.12806875e-02f, 1.37473410e-02f, 2.35213041e-01f, -7.09110796e-02f, -1.08008690e-01f, -9.94080156e-02f,
  2.86582410e-01f, 1.61380321e-01f, -1.14911899e-01f, 1.82050858e-02f, 3.81292403e-02f, -5.09633608e-02f, 3.54905367e-01f, 2.78552949e-01f, 9.71485972e-02f, -1.07850313e-01f,
  9.25695598e-02f, 1.47789031e-01f, 1.32992759e-01f, 2.39346945e-03f, -7.84657151e-02f, 4.44222093e-02f, -7.83843845e-02f, -1.12789897e-02f, 1.77637324e-01f, 5.83053939e-02f,
  1.21132560e-01f, -4.54516448e-02f, 4.71558608e-02f, 7.04073021e-03f, -8.77261683e-02f, 1.17593436e-02f, 2.17518046e-01f, 1.38848826e-01f, 4.08999696e-02f, -7.39200637e-02f,
  9.35453922e-02f, 4.25431766e-02f, -9.66952369e-02f, 4.76344489e-02f, -3.96650136e-02f, 8.12484547e-02f, -2.84104794e-02f, -1.15129434e-01f, 1.02245875e-01f, 2.42442843e-02f,
  3.16949897e-02f, 6.01068065e-02f, -5.84926568e-02f, 1.06362179e-01f, -8.50645974e-02f, 1.27130494e-01f, 1.12777464e-01f, -1.28821060e-01f, -5.97364083e-03f, 1.69365734e-01f,
  5.44697568e-02f, -6.90720081e-02f, -9.53894407e-02f, 1.02265747e-02f, 7.21648261e-02f, 1.16409615e-01f, 5.19272126e-02f, -5.06742671e-02f, -3.84451970e-02f, 7.45260641e-02f,
  -4.63359850e-03f, -8.33923295e-02f, 9.29320976e-02f, -8.74617025e-02f, 1.45606309e-01f, -1.16830319e-01f, 6.83498979e-02f, -3.59027050e-02f, 8.31179842e-02f, 8.85664150e-02f,
  7.19054975e-03f, 8.30130279e-03f, -1.69489216e-02f, -3.98034900e-02f, -1.01364896e-01f, -7.58316834e-04f, -1.18541390e-01f, 4.78451513e-02f, -5.68906181e-02f, -1.04859723e-02f,
  1.16740368e-01f, -1.01156570e-01f, 2.44832737e-03f, -9.25989226e-02f, -3.01571712e-02f, 1.14240654e-01f, 9.69379768e-02f, -8.00255239e-02f, 1.35655114e-02f, 1.15755044e-01f,
  -3.93097363e-02f, -5.00267372e-02f, -6.37140647e-02f, -1.16368257e-01f, -1.54406410e-02f, -7.67104030e-02f, -1.10364616e-01f, 9.06339735e-02f, -1.72040015e-02f, -2.07601227e-02f,
  -1.71424653e-02f, -1.52463987e-02f, -2.48921588e-02f, 1.05821237e-01f, 8.44063312e-02f, 3.97328846e-02f, -7.62113359e-06f, -5.10198213e-02f, 1.19525984e-01f, 7.57277757e-02f,
  1.09173596e-01f, 4.52204384e-02f, 7.78703392e-02f, -4.22134288e-02f, -5.15534123e-03f, -7.26184994e-02f, -8.26102421e-02f, -3.15247402e-02f, -3.29766087e-02f, -1.15059875e-01f,
  -7.06426650e-02f, 6.18769880e-03f, -4.13237736e-02f, 6.99034408e-02f, -1.05417095e-01f, 2.07336284e-02f, 9.02253166e-02f, 1.20460376e-01f, -8.53198394e-02f, 6.58801794e-02f,
  1.61353964e-02f, -7.18115121e-02f, -3.55854705e-02f, 8.88245180e-02f, 8.77421647e-02f, -2.77391430e-02f, -5.39650843e-02f, 2.90921740e-02f, -8.44728127e-02f, -8.14595670e-02f,
  -7.44238943e-02f, 2.73627751e-02f, -1.53951356e-02f, -1.09155819e-01f, -2.10735500e-02f, 5.41873351e-02f, -3.81249301e-02f, -9.02851298e-02f, -1.25261605e-01f, -1.03803106e-01f,
  -8.45651925e-02f, -4.76264656e-02f, 2.79459842e-02f, -5.79338707e-02f, -7.38680363e-02f, -1.22083999e-01f, 8.09780508e-02f, -4.24042642e-02f, -7.82698567e-04f, -4.25850376e-02f,
  3.02919708e-02f, 1.09336689e-01f, -4.39573377e-02f, -4.69323285e-02f, 1.36402100e-02f, 8.36906135e-02f, -6.48613349e-02f, -7.38257319e-02f, 3.77964266e-02f, 9.27753523e-02f,
  2.65342910e-02f, 1.23597950e-01f, 8.46847147e-02f, -4.43589725e-02f, -1.04332589e-01f, -1.22745700e-01f, -3.63930166e-02f, 7.14099929e-02f, 2.88881473e-02f, 6.07870519e-02f,
  -2.60639805e-02f, 8.28129277e-02f, 6.96629807e-02f, 3.15278918e-02f, 1.20452702e-01f, 1.29552307e-02f, 2.48431321e-02f, 8.70082676e-02f, 9.15482342e-02f, 1.44398063e-02f,
  -1.87542345e-02f, -1.00569604e-02f, -5.00951074e-02f, 2.41452381e-02f, -9.03112814e-02f, -2.99661942e-02f, -3.60037424e-02f, -4.14095772e-03f, -8.32088068e-02f, -8.52576271e-02f,
  2.74499673e-02f, -3.87937799e-02f, 6.18334301e-02f, 2.12060362e-01f, 1.43409938e-01f, 1.22830667e-01f, 2.21922681e-01f, 2.64786929e-01f, 1.05333507e-01f, 2.13696018e-01f,
  -2.99490213e-01f, -2.95370191e-01f, 4.32606377e-02f, -1.57816172e-01f, -1.04507096e-01f, 8.01818669e-02f, 1.73146762e-02f, 6.60638735e-02f, -4.70187701e-02f, -6.82755858e-02f,
  -8.63950923e-02f, -1.09777354e-01f, -1.53464958e-01f, 2.86193788e-02f, 4.63766232e-02f, -9.74586532e-02f, -6.27764910e-02f, -6.08648993e-02f, 7.07250237e-02f, 7.03316554e-02f,
  5.46153560e-02f, 7.60965347e-02f, -9.52552781e-02f, -1.59044623e-01f, 2.54236106e-02f, 8.06012154e-02f, -6.30152151e-02f, 2.24353135e-01f, -1.31161073e-02f, 1.80820540e-01f,
  2.44090363e-01f, -8.24189652e-03f, 1.30702108e-01f, -1.04247287e-01f, -7.33433962e-02f, 9.01378542e-02f, -6.57704622e-02f, 3.34959596e-01f, -1.12061791e-01f, -1.26811832e-01f,
  7.87613615e-02f, 7.35585988e-02f, 3.25457484e-01f, -1.33647006e-02f, -5.33472262e-02f, 1.28457069e-01f, 3.32536966e-01f, 2.13505283e-01f, 1.11706667e-01f, -3.39660905e-02f,
  1.91729054e-01f, -8.37145373e-02f, -6.33873865e-02f, 9.47016105e-03f, -2.59350747e-01f, -1.24296337e-01f, -8.41165311e-04f, -2.54191197e-02f, -9.18005407e-02f, 4.85936739e-02f,
  1.66241363e-01f, 1.74857467e-01f, 1.96470972e-02f, 6.60125092e-02f, 1.51952460e-01f, 1.34136215e-01f, 3.83614078e-02f, 6.62959814e-02f, -4.84323651e-02f, 1.58581719e-01f,
  -1.00559620e-02f, -9.61914212e-02f, 2.61438731e-02f, 7.85251334e-02f, -4.66473736e-02f, -6.00162186e-02f, -1.22995391e-01f, -4.26690653e-03f, 1.60544384e-02f, 5.59496619e-02f,
  1.41844139e-01f, 4.24866602e-02f, 1.16792172e-01f, -9.01581347e-02f, 1.09655127e-01f, -6.23347126e-02f, 1.67205021e-01f, -5.40387928e-02f, -8.43224600e-02f, 8.01315680e-02f,
  6.81044087e-02f, 3.29636633e-02f, -1.05528854e-01f, -8.24728534e-02f, -1.55467063e-03f, -1.22738145e-02f, 1.19768672e-01f, 7.36594573e-02f, 1.69578955e-01f, 3.98246422e-02f,
  -8.55429247e-02f, -4.01197635e-02f, -3.00005600e-02f, 8.25192854e-02f, 1.08025931e-01f, 9.83757153e-02f, 3.52813825e-02f, -2.90695578e-03f, 1.04331844e-01f, 1.75280854e-01f,
  5.89938164e-02f, -1.50629431e-01f, -1.48751652e-02f, -9.38247964e-02f, 9.00117904e-02f, 1.33703928e-02f, -7.23733082e-02f, -9.60987955e-02f, -1.18422769e-01f, -1.14960454e-01f,
  6.35865480e-02f, 2.29945555e-01f, 6.93954676e-02f, 1.40203282e-01f, 9.76971388e-02f, 6.18028305e-02f, -1.63622648e-01f, 1.30710388e-02f, -4.41218317e-02f, -1.81254402e-01f,
  2.31511146e-01f, -1.60340399e-01f, 3.55021022e-02f, -6.51559457e-02f, -1.15980506e-01f, -8.76547471e-02f, -1.10448740e-01f, -5.45123890e-02f, 8.88901949e-02f, 2.54039094e-02f,
  -1.56901881e-01f, 1.87247872e-01f, 1.30227029e-01f, 1.90201625e-02f, 5.46304621e-02f, -7.74506181e-02f, -1.51961550e-01f, 9.80700105e-02f, 1.47797819e-02f, -7.12348595e-02f,
  2.55271226e-01f, 5.44275530e-02f, -1.35916069e-01f, -1.09771349e-01f, 2.93014310e-02f, 2.12342575e-01f, -5.88662513e-02f, 4.03402522e-02f, 2.63501823e-01f, 1.49905169e-02f,
  1.00637123e-01f, 1.21233240e-02f, -4.86709513e-02f, 6.23214282e-02f, 1.05435491e-01f, 3.69505405e-01f, 1.24077596e-01f, 1.06170110e-01f, -9.59254950e-02f, -6.98881522e-02f,
  1.81361511e-01f, -7.67057389e-02f, -5.98704591e-02f, 1.86081335e-01f, 3.02202493e-01f, 1.06005423e-01f, -1.15780190e-01f, -1.34872412e-02f, -4.43267785e-02f, 1.20497473e-01f,
  -4.21999730e-02f, -6.55227676e-02f, -1.54549733e-01f, 6.97118565e-02f, 1.18666440e-01f, -4.02015783e-02f, 6.69700801e-02f, 1.00171886e-01f, 1.82467341e-01f, 1.18877701e-01f,
  -6.89729080e-02f, -2.02575311e-01f, 3.43302898e-02f, -1.02928132e-01f, 2.12812871e-01f, 3.75714824e-02f, 2.77492590e-02f, 4.60841618e-02f, 1.10941105e-01f, 1.71921849e-02f,
  -7.35967085e-02f, 1.87920168e-01f, 9.09896046e-02f, -3.52995135e-02f, -7.51047358e-02f, -7.23044714e-03f, 1.80668607e-02f, -1.42338348e-03f, 8.17704201e-02f, 4.66711819e-02f,
  7.17821866e-02f, -8.50535706e-02f, 2.69140918e-02f, -2.35828944e-02f, 1.16159633e-01f, -1.36930551e-02f, 7.20096529e-02f, 5.03004529e-02f, 4.60885316e-02f, -2.25270037e-02f,
  1.50512820e-02f, 9.06119216e-03f, 2.19897851e-01f, 9.07418281e-02f, -5.23279645e-02f, -4.71634194e-02f, -1.00798383e-01f, 7.24442229e-02f, 2.31550145e-03f, 2.44308144e-01f,
  2.64893728e-03f, 3.00601106e-02f, 1.69669185e-02f, 1.64137706e-01f, 1.66344583e-01f, 1.15558058e-01f, 6.57332614e-02f, -5.58980852e-02f, 6.20542206e-02f, -6.26591593e-02f,
  -1.12981811e-01f, -1.20541289e-01f, -9.47100222e-02f, -8.33790451e-02f, -5.59961200e-02f, -6.26220927e-02f, 1.78161830e-01f, -1.10602230e-02f, 8.27912018e-02f, 9.12004784e-02f,
  2.18422040e-01f, 1.73498377e-01f, 4.09560613e-02f, 1.02964938e-01f, 1.81308556e-02f, -1.48491487e-01f, -1.24740131e-01f, -1.96790114e-01f, 4.68203500e-02f, 1.19455270e-01f,
  9.47640836e-02f, -6.32161871e-02f, -3.95325460e-02f, 4.48961034e-02f, 2.89945845e-02f, -7.94596896e-02f, 3.79621051e-02f, 3.31067853e-02f, 7.51099512e-02f, -3.97283621e-02f,
  1.41193986e-01f, -1.04884245e-01f, -1.60215478e-02f, -3.09256255e-03f, -1.63731292e-01f, -1.03131719e-01f, 1.79375838e-02f, -1.24518111e-01f, 5.46062328e-02f, -3.55836116e-02f,
  4.79818881e-02f, 1.30887821e-01f, 2.26877816e-02f, 1.80800542e-01f, 1.15038007e-02f, -1.17362291e-01f, 1.76491365e-01f, -2.99575161e-02f, -1.99704114e-02f, 3.73905487e-02f,
  -1.96929514e-01f, -9.46174958e-04f, -2.42531616e-02f, 3.03560615e-01f, 6.52391240e-02f, 9.35423151e-02f, 5.34188524e-02f, -2.08502281e-02f, 1.24862440e-01f, 1.16233312e-01f,
  6.89540356e-02f, 1.42577171e-01f, 1.51324764e-01f, 1.32467315e-01f, 6.28087521e-02f, 1.00237861e-01f, -2.22224463e-02f, -4.36248146e-02f, -8.33333582e-02f, -4.58804630e-02f,
  -4.11223173e-02f, 3.80728133e-02f, 4.78903204e-02f, 7.44297877e-02f, 1.10844031e-01f, 8.91672596e-02f, 1.07703999e-01f, 9.08936486e-02f, -1.03120416e-01f, 4.01568413e-02f,
  -1.17610870e-02f, 1.31822765e-01f, -9.02668945e-03f, -8.32572132e-02f, 2.52678152e-02f, 1.33438632e-01f, 4.52092476e-02f, 3.53777759e-05f, -7.42459074e-02f, -1.09279089e-01f,
  -4.94362749e-02f, 1.98625140e-02f, 9.40968916e-02f, -7.60633945e-02f, 1.00497156e-01f, -1.14487357e-01f, -6.39766641e-03f, -1.50772464e-02f, 1.69236869e-01f, -3.54324281e-02f,
  1.05448775e-01f, -6.72586076e-03f, 2.83179522e-01f, 3.79089825e-02f, 1.01756431e-01f, 1.92843601e-01f, 1.47586063e-01f, 2.38483194e-02f, -1.18246622e-01f, -8.96000117e-02f,
  1.54722612e-02f, -6.55193850e-02f, -4.03144099e-02f, 3.81642021e-02f, 2.28849217e-01f, -1.07636288e-01f, 9.12123248e-02f, -2.20459085e-02f, 5.55062629e-02f, -7.04922602e-02f,
  4.38393950e-02f, 1.87424496e-02f, -1.68233335e-01f, 7.03221262e-02f, 4.20852639e-02f, 1.60793796e-01f, -1.93319455e-01f, 1.72524005e-01f, -8.15444663e-02f, -1.06222719e-01f,
  -5.94803542e-02f, -1.17178626e-01f, -2.45799106e-02f, 7.05828443e-02f, 6.45708144e-02f, 1.25883251e-01f, 2.56641358e-02f, 1.42497823e-01f, 1.47744775e-01f, 1.33139640e-01f,
  1.41265228e-01f, 1.91681147e-01f, 1.00772478e-01f, 1.37172312e-01f, -2.14446291e-01f, -5.25702834e-02f, -1.13251716e-01f, -1.78609714e-01f, -8.20637420e-02f, 1.45870537e-01f,
  2.27672309e-01f, 2.72518992e-02f, -3.32271717e-02f, 1.94998030e-02f, 6.72455207e-02f, -4.42841053e-02f, 1.53986782e-01f, -1.78705472e-02f, 2.18633205e-01f, -1.23300269e-01f,
  2.78584734e-02f, -1.29178260e-02f, 2.46580914e-01f, 5.23215160e-02f, -3.75433639e-02f, 1.44864649e-01f, -2.35719100e-01f, -6.07467145e-02f, 1.00972265e-01f, 2.20670663e-02f,
  -1.09477624e-01f, 4.00259681e-02f, 9.07994434e-02f, 2.00822532e-01f, -8.36511552e-02f, -1.12159751e-01f, -4.47517596e-02f, -5.26889078e-02f, -2.70268563e-02f, 1.15130007e-01f,
  2.19097398e-02f, 1.02361269e-01f, 4.34205495e-02f, 1.01201072e-01f, 1.00994051e-01f, 4.44151238e-02f, 1.71017796e-01f, 8.71991888e-02f, -1.10823236e-01f, -9.91158411e-02f,
  6.66887499e-04f, 9.18383896e-02f, 7.81219453e-02f, 9.12074465e-03f, 1.99449137e-01f, 2.06666403e-02f, 9.49528962e-02f, 2.38572046e-01f, -4.98308130e-02f, -1.03397399e-01f,
  5.70810847e-02f, 4.39322218e-02f, 1.40258089e-01f, 1.04050241e-01f, -4.19551833e-03f, 1.17689908e-01f, -1.08708292e-01f, 4.18157950e-02f, 1.10674754e-01f, -1.66243568e-01f,
  -1.44710103e-02f, 1.64752871e-01f, 3.01876180e-02f, -1.80413514e-01f, 1.41087651e-01f, -5.08755483e-02f, 6.37090728e-02f, 1.19748451e-01f, -2.27831695e-02f, 4.02579829e-02f,
  2.21126955e-02f, 1.45429686e-01f, -3.31460461e-02f, -6.13194704e-02f, -3.79386730e-02f, 9.75486487e-02f, 4.88511994e-02f, 9.46228504e-02f, -5.36363572e-02f, -1.86845511e-02f,
  -7.54568875e-02f, 1.65026575e-01f, 7.59250596e-02f, -3.20728384e-02f, -7.51143545e-02f, -1.51853144e-01f, 1.02553129e-01f, 3.26370038e-02f, -3.43567170e-02f, 1.90987512e-01f,
  4.50179074e-03f, -7.59407431e-02f, -1.19285740e-01f, -6.45402521e-02f, 6.32895157e-02f, 1.15939215e-01f, 1.59930825e-01f, 9.73756164e-02f, 1.02835953e-01f, 4.82130274e-02f,
  -8.05029459e-03f, 9.39710885e-02f, 3.27054597e-02f, -2.82721734e-03f, 1.21344000e-01f, -1.10633457e-02f, -8.20413753e-02f, -2.08758079e-02f, 4.25468385e-03f, 8.24205577e-03f,
  2.68248200e-01f, -7.17729032e-02f, 2.18159229e-01f, -2.02293210e-02f, -8.70125070e-02f, 1.23825274e-01f, 2.50066351e-02f, 1.27405018e-01f, 4.46584113e-02f, -1.80225633e-02f,
  1.03138521e-01f, -1.34309217e-01f, 5.18769100e-02f, -1.79711003e-02f, 1.88455820e-01f, -3.98037992e-02f, -5.28790615e-02f, -9.84455226e-04f, -1.31264552e-01f, -4.17666323e-02f,
  -5.26094213e-02f, -8.29238445e-02f, -9.75302607e-02f, 5.46060801e-02f, -1.06239475e-01f, 3.72207314e-02f, 2.16673419e-01f, 4.50215265e-02f, 9.85059068e-02f, 2.14033015e-02f,
  -1.54345199e-01f, -1.05402015e-01f, 2.75340062e-02f, -5.33214509e-02f, 1.82915643e-01f, -8.24820548e-02f, 2.59369873e-02f, 4.41952385e-02f, 4.91519757e-02f, 9.56547856e-02f,
  -7.26410747e-02f, -9.20932442e-02f, 1.67806789e-01f, -3.85122746e-03f, 1.16767853e-01f, -1.18197694e-01f, -1.51392817e-01f, -3.52828279e-02f, -7.03296363e-02f, 9.78166386e-02f,
  1.81324020e-01f, 1.00196995e-01f, -1.05698287e-01f, -3.93013060e-02f, 1.47564113e-01f, -5.97340092e-02f, 2.38403678e-02f, 5.04240654e-02f, 2.01177225e-01f, 3.00527439e-02f,
  7.69453123e-02f, 6.57635853e-02f, 7.41086155e-02f, 9.68527198e-02f, -4.70787697e-02f, -1.34661779e-01f, 1.15614057e-01f, 1.21491708e-01f, 1.47769108e-01f, 2.21088633e-01f,
  1.95483893e-01f, 1.58082619e-01f, 2.35898897e-01f, 2.17287689e-01f, -3.54160480e-02f, 1.48005500e-01f, -3.27134728e-01f, -3.33181262e-01f, -1.73705220e-02f, -1.44075572e-01f,
  -1.97969712e-02f, 4.19504903e-02f, 7.70686790e-02f, 7.58687407e-02f, -1.61634743e-01f, -6.45209178e-02f, 2.21568104e-02f, 1.75374001e-01f, -4.38829213e-02f, 2.52489056e-02f,
  1.20682478e-01f, -5.88736357e-03f, -1.12471409e-01f, -5.22853807e-02f, 9.35292020e-02f, -4.78900298e-02f, 4.23013866e-02f, -5.97289912e-02f, -4.47067246e-02f, 9.48998556e-02f,
  -1.02465719e-01f, -1.22576118e-01f, -3.54756927e-03f, 1.53497502e-01f, -1.12080954e-01f, 3.18246894e-02f, 2.26513654e-01f, -8.54177177e-02f, -4.78803441e-02f, -5.41730318e-03f,
  -1.85939983e-01f, -7.37468898e-02f, 1.22684345e-01f, 3.43178540e-01f, -7.17733726e-02f, 2.32390687e-02f, 8.90741721e-02f, -2.87731327e-02f, 5.31109907e-02f, 6.31677359e-02f,
  2.66851299e-02f, -3.90248559e-02f, 3.23758513e-01f, 2.80118495e-01f, 6.56888708e-02f, 2.47368272e-02f, 4.46119867e-02f, 1.01426087e-01f, -1.03546917e-01f, 2.36629441e-01f,
  7.51545206e-02f, 1.44461408e-01f, -5.40273124e-03f, 1.22068733e-01f, -9.05108154e-02f, 5.77023402e-02f, 1.28014565e-01f, 4.84751314e-02f, 2.11123407e-01f, -2.18308732e-01f,
  1.86221823e-01f, 1.81021854e-01f, -1.80521876e-01f, 2.26618238e-02f, 6.00657240e-02f, 2.24892870e-01f, -4.33946066e-02f, 5.76845258e-02f, 9.26182866e-02f, -1.06663059e-03f,
  -6.33456558e-02f, 1.22145131e-01f, 2.63697356e-01f, -2.83118542e-02f, 3.35705549e-01f, -6.70277104e-02f, 1.12550505e-01f, -1.48892570e-02f, 2.53523320e-01f, 5.39257079e-02f,
  -5.89759164e-02f, 2.38804966e-01f, 7.83097371e-02f, 6.26330748e-02f, 2.23887652e-01f, 1.74157336e-01f, 1.20217271e-01f, -7.88786784e-02f, 1.44263273e-02f, 3.35437618e-02f,
  9.14487019e-02f, 1.73428319e-02f, -5.18758036e-02f, -2.38643344e-02f, 2.53363818e-01f, -7.31352344e-02f, -8.10720101e-02f, -7.27158189e-02f, 5.48922233e-02f, 2.90468102e-03f,
  -3.83337364e-02f, -1.16884314e-01f, -1.94571540e-01f, -4.02339287e-02f, 1.08835720e-01f, -3.50125581e-02f, -1.69236809e-01f, 9.24121663e-02f, 4.65005971e-02f, -1.40575971e-02f,
  1.41514748e-01f, 8.29167366e-02f, 5.60825989e-02f, 1.36711061e-01f, 2.81910777e-01f, -4.09431895e-03f, 7.77795017e-02f, 1.01077020e-01f, 8.01757649e-02f, 1.10557474e-01f,
  -3.74407470e-02f, -2.00893660e-03f, 1.26115218e-01f, -1.19243413e-01f, 8.63365382e-02f, 6.84780926e-02f, -7.61284232e-02f, -1.07163452e-01f, -6.53949082e-02f, 2.55171448e-01f,
  -7.16940537e-02f, 1.09302223e-01f, 6.96822852e-02f, -3.85198481e-02f, -4.30741385e-02f, 1.54955000e-01f, 1.50021404e-01f, -5.81215061e-02f, 3.29647511e-01f, 1.07266143e-01f,
  2.23850794e-02f, 1.07683852e-01f, 1.67305127e-01f, 5.90721481e-02f, 8.12397450e-02f, 7.44375288e-02f, 4.06126864e-02f, 1.12355417e-02f, 2.12660655e-01f, 2.21452117e-01f,
  -1.31778577e-02f, -8.47781301e-02f, -4.76104207e-02f, -5.36380932e-02f, -1.16707392e-01f, -3.58118713e-02f, -1.05981804e-01f, -2.17967890e-02f, 1.51542619e-01f, -9.38056484e-02f,
  -8.93757027e-03f, 3.52978781e-02f, -1.59411002e-02f, -4.18290347e-02f, 1.06719963e-01f, -1.16900038e-02f, -1.71157554e-01f, -7.95614421e-02f, 5.14240153e-02f, -2.33200402e-03f,
  -9.08091590e-02f, 9.98424068e-02f, 7.84579366e-02f, -6.63812757e-02f, 4.10630964e-02f, -2.11079735e-02f, -2.71507893e-02f, 2.24161789e-01f, 1.63256943e-01f, -1.00555802e-02f,
  1.28648654e-01f, 1.78650897e-02f, 1.25520453e-02f, -1.32944086e-04f, 7.52294995e-03f, -1.11047840e-02f, 7.05972686e-02f, -1.97202370e-01f, 2.82566071e-01f, 1.64733723e-01f,
  2.62248404e-02f, -4.06292602e-02f, -4.23970595e-02f, 3.76723930e-02f, -8.58906060e-02f, 1.07900180e-01f, 1.57091357e-02f, -3.56542580e-02f, -5.29685616e-02f, -8.56404193e-03f,
  2.17968319e-02f, 3.69959399e-02f, 5.54406494e-02f, -7.88503140e-02f, 1.49402441e-02f, -2.83877887e-02f, 1.79611593e-01f, 1.16803301e-02f, 4.13460657e-02f, 3.65669057e-02f,
  3.03185076e-01f, -4.28444892e-02f, 9.40412655e-02f, 4.80263308e-02f, 7.88304806e-02f, 1.02803409e-01f, -2.91620977e-02f, -9.51256528e-02f, -6.14731945e-02f, -9.68163684e-02f,
  -2.00420413e-02f, -8.62910375e-02f, 3.85378697e-03f, -4.93013375e-02f, 1.46462647e-02f, 9.30787176e-02f, 2.28159055e-01f, -9.36935320e-02f, 1.00638589e-03f, -7.46326447e-02f,
  -8.38291496e-02f, -7.79990330e-02f, 9.63303447e-02f, 1.47180766e-01f, -1.60981536e-01f, 1.12073086e-01f, 6.35022596e-02f, -6.11112043e-02f, 7.57662654e-02f, -1.04463704e-01f,
  4.35624942e-02f, -8.01358819e-02f, 1.66918904e-01f, 1.20704599e-01f, 5.42229936e-02f, -3.16623636e-02f, -1.19004905e-01f, 6.31488860e-02f, -1.13833383e-01f, 1.12081446e-01f,
  6.42250925e-02f, -6.42750561e-02f, 4.24461924e-02f, 6.22854121e-02f, 8.93186778e-02f, 1.07124649e-01f, -1.74176414e-02f, 8.75474215e-02f, 3.34882438e-02f, -6.10991120e-02f,
  2.36286037e-02f, -1.03307575e-01f, -1.12099588e-01f, -1.23444192e-01f, -1.09595180e-01f, 2.70013325e-03f, -7.70297796e-02f, 2.83766929e-02f, -8.52654725e-02f, 3.58561166e-02f,
  -1.03241421e-01f, 2.92611644e-02f, 4.54882421e-02f, 6.01078905e-02f, -2.03600209e-02f, -6.78277612e-02f, 1.67843290e-02f, 5.84423095e-02f, 9.16401446e-02f, -7.02090040e-02f,
  -7.60202259e-02f, 2.08136486e-03f, -7.49572590e-02f, 5.07580768e-03f, -1.33167170e-02f, 9.37614664e-02f, -2.82346494e-02f, 1.08148813e-01f, 4.69649732e-02f, 5.48159666e-02f,
  8.85824710e-02f, -7.97925424e-03f, -1.01729043e-01f, -5.14625534e-02f, 8.74486566e-02f, 1.00499682e-01f, -1.24107383e-01f, -3.59861553e-02f, 2.13773809e-02f, -1.07644513e-01f,
  3.04637216e-02f, -7.50247240e-02f, 1.03806920e-01f, -1.21066041e-01f, -5.08384109e-02f, -6.17057420e-02f, -3.53840031e-02f, 3.46929394e-02f, -3.55451219e-02f, 1.15621790e-01f,
  1.17442966e-01f, -4.31549773e-02f, -2.23572440e-02f, 9.74533483e-02f, -1.28097221e-01f, 7.76703656e-02f, 8.94101057e-03f, -3.22791189e-02f, -1.54426888e-01f, -1.20543934e-01f,
  4.64196168e-02f, 1.00371711e-01f, 5.66043966e-02f, -9.19380188e-02f, -4.75661941e-02f, 9.29990038e-02f, 4.54521924e-02f, -7.33472556e-02f, -3.59719954e-02f, -6.96553141e-02f,
  6.32931516e-02f, -5.15369214e-02f, 1.50679559e-01f, -1.55346971e-02f, 1.71611831e-01f, -4.07953821e-02f, -6.98728487e-02f, 1.64075166e-01f, 8.84696990e-02f, 7.91388825e-02f,
  1.45307809e-01f, -3.17994244e-02f, -1.04556471e-01f, 9.13071111e-02f, 7.12216869e-02f, -6.61066249e-02f, -1.50383234e-01f, -9.63019282e-02f, 3.23455664e-03f, -9.38436240e-02f,
  7.95712993e-02f, 8.06798860e-02f, -4.11616685e-03f, -9.35549755e-03f, -9.82700959e-02f, 8.99962932e-02f, 7.86553770e-02f, -3.06506976e-02f, 1.32728010e-01f, -9.03485566e-02f,
  5.37371524e-02f, 1.81069314e-01f, -8.12571570e-02f, 9.73497182e-02f, -4.06254008e-02f, 1.10845221e-03f, 1.87687259e-02f, -3.93544585e-02f, -8.74077901e-02f, 1.47774115e-01f,
  3.72427404e-02f, -1.37833849e-01f, 1.88898996e-01f, 8.11707452e-02f, 1.06765656e-02f, 7.66648073e-03f, 1.31321877e-01f, 4.43853810e-02f, 7.98342079e-02f, 1.09272286e-01f,
  -2.04311058e-01f, -1.51875272e-01f, -1.60107408e-02f, -1.69105694e-01f, 9.65318382e-02f, 1.00804241e-02f, 1.45893067e-01f, 5.22081181e-02f, -1.25004157e-01f, -3.45208831e-02f,
  -4.51647751e-02f, 5.22912517e-02f, 1.34113088e-01f, -1.20807607e-02f, -2.22994648e-02f, 1.09264508e-01f, 1.35587230e-01f, 2.04279386e-02f, 5.24556711e-02f, -1.06830366e-01f,
  -2.47239340e-02f, 2.73005683e-02f, -7.91875422e-02f, 5.95439263e-02f, 1.12571940e-02f, -1.20457955e-01f, -1.61431685e-01f, -9.49153118e-03f, 6.60430547e-03f, 7.18039796e-02f,
  -7.43735721e-03f, 3.72570194e-02f, 9.94066298e-02f, 7.16510266e-02f, -2.80128187e-03f, 2.47981939e-02f, 5.07208854e-02f, 1.82600692e-01f, -1.67863339e-01f, 6.50821701e-02f,
  -3.10223345e-02f, -4.65567783e-02f, 1.82418346e-01f, -2.70478632e-02f, -6.38602301e-02f, -1.28486787e-03f, 1.86828539e-01f, 3.26612517e-02f, -1.13662176e-01f, -8.98118094e-02f,
  -6.62033856e-02f, -4.97843362e-02f, 1.13122471e-01f, 1.51631296e-01f, -8.84868801e-02f, 2.71704104e-02f, 2.12200135e-01f, 1.77647546e-01f, 7.25589097e-02f, 2.06651717e-01f,
  -3.34204733e-02f, 2.28885368e-01f, 4.69667464e-03f, -8.04012865e-02f, -2.29256406e-01f, -2.30955824e-01f, 2.01677322e-01f, 3.99941914e-02f, -9.46275517e-02f, 9.64171737e-02f,
  -1.25839576e-01f, -1.01237126e-01f, -1.34722188e-01f, -1.62402868e-01f, -5.50337769e-02f, -3.81903127e-02f, -1.51558593e-03f, 2.07892463e-01f, 2.42046088e-01f, -6.46312460e-02f,
  -2.40712781e-02f, 5.78896329e-02f, -1.66936755e-01f, 4.18221541e-02f, 8.49283189e-02f, -1.78899802e-02f, 1.48483768e-01f, -1.08089969e-01f, 7.11744875e-02f, -6.70880526e-02f,
  3.03254779e-02f, 2.11097836e-01f, 5.03728166e-02f, -9.88873541e-02f, 1.46459058e-01f, -1.24685377e-01f, 1.23856820e-01f, -1.15239084e-01f, -1.67499632e-01f, 8.72859061e-02f,
  -4.72149141e-02f, 2.99193442e-01f, 1.35463834e-01f, -1.51234362e-02f, 8.50511640e-02f, -1.67267658e-02f, 1.55768439e-01f, 5.39407842e-02f, -2.41324473e-02f, -4.32728231e-02f,
  1.96136653e-01f, 2.38639876e-01f, 5.61101548e-02f, -8.34897012e-02f, -3.10599860e-02f, 9.80742555e-03f, -1.18885234e-01f, 4.74089161e-02f, -1.22907445e-01f, 2.27561798e-02f,
  -4.85615171e-02f, 7.29962960e-02f, 7.19300508e-02f, 5.05066887e-02f, 1.40765563e-01f, -1.80757325e-02f, -8.38027149e-02f, 2.20193155e-02f, -1.41589835e-01f, 6.24642484e-02f,
  -5.88077167e-03f, 2.44733654e-02f, 9.08533335e-02f, 1.60000607e-01f, 7.43402354e-03f, -9.11565647e-02f, -1.32413447e-01f, -8.95890221e-02f, 1.12604715e-01f, 8.40075687e-02f,
  2.92954724e-02f, -1.21521123e-01f, 7.52150416e-02f, -1.15102097e-01f, 9.53638777e-02f, 7.53077641e-02f, -8.81822333e-02f, 1.13888726e-01f, 6.89819604e-02f, -3.06122601e-02f,
  3.52143869e-02f, -2.21442338e-02f, 8.09893291e-03f, -8.82672444e-02f, -1.22801743e-01f, -7.61245415e-02f, -1.14723854e-01f, -1.22386301e-02f, -5.32085784e-02f, -1.11160755e-01f,
  2.15676054e-02f, -9.70618725e-02f, 3.66924070e-02f, -9.20412093e-02f, 3.72140482e-02f, 1.23056071e-03f, 6.52783886e-02f, 7.03868493e-02f, -4.69636545e-02f, 6.22820333e-02f,
  -3.24356556e-02f, 9.12526250e-02f, -5.07478928e-03f, 1.08654037e-01f, 1.16800666e-01f, 5.45876287e-02f, -1.01996906e-01f, -5.61234131e-02f, -8.21761712e-02f, -5.28946035e-02f,
  -6.12121262e-02f, 7.70814866e-02f, 5.69141358e-02f, 1.46042248e-02f, 1.25981405e-01f, 1.69812664e-01f, 4.75137541e-03f, 1.53624788e-01f, 1.78817019e-01f, 1.11821651e-01f,
  -1.30047336e-01f, 1.62366971e-01f, 7.91136548e-02f, 3.30925658e-02f, -4.58054021e-02f, 2.56617069e-02f, -9.69554037e-02f, -4.79291119e-02f, -1.73393544e-02f, -3.07999700e-02f,
  5.13078682e-02f, 1.14933088e-01f, -5.57432650e-03f, 6.18595295e-02f, 7.39989728e-02f, -1.06822148e-01f, -7.15688542e-02f, 5.65918796e-02f, 4.22479492e-03f, -7.73468241e-02f,
  3.02026160e-02f, 7.42053986e-02f, 1.25405595e-01f, 9.21393633e-02f, -1.48280719e-02f, 1.13145590e-01f, 1.07755564e-01f, -2.85851154e-02f, -1.14232069e-03f, -1.22845396e-01f,
  -5.38063012e-02f, 8.25745910e-02f, 3.76199260e-02f, 1.22828037e-01f, -5.85231408e-02f, -6.42116517e-02f, -5.66184931e-02f, -9.27010775e-02f, 5.34959696e-02f, 7.48899486e-03f,
  1.22202657e-01f, 7.47442916e-02f, -1.03942417e-01f, 7.34109208e-02f, 7.84295648e-02f, -9.26674455e-02f, -2.49586329e-02f, 4.43032607e-02f, -3.62346023e-02f, -1.04367390e-01f,
  -9.92949456e-02f, 7.42761120e-02f, -6.35569841e-02f, -8.65579993e-02f, 2.99618900e-01f, -7.33448938e-02f, 1.53347224e-01f, 1.34297803e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -7.72480369e-02f, -7.84438848e-02f, 7.54102096e-02f, 2.00388972e-02f, 1.03254639e-01f, 7.16082975e-02f, 8.07772949e-02f, -2.56044026e-02f, 4.41095643e-02f, -2.40469296e-02f,
  1.20519429e-01f, -1.03537381e-01f, 1.66544527e-01f, 1.21397391e-01f, 1.32632852e-01f, 1.44044325e-01f, -2.70435233e-02f, -3.30395508e-03f, 2.31655277e-02f, -7.51233548e-02f,
  -5.65970056e-02f, 1.57598734e-01f, 2.34477539e-02f, 7.05420524e-02f, -3.21829841e-02f, -1.82381086e-02f, -8.33085626e-02f, -2.20171381e-02f, 1.48619100e-01f, 2.05719545e-01f,
  8.76808465e-02f, 8.29128735e-03f, -9.73322615e-02f, 8.57069716e-02f, 9.88715887e-02f, 1.83608800e-01f, 1.48651406e-01f, 2.00959444e-01f, -5.95323294e-02f, -1.60565285e-03f,
  5.72016016e-02f, 8.70940760e-02f, 1.75150000e-02f, -1.58208865e-03f, 2.95058731e-02f, 8.34069028e-02f, -1.05117001e-01f, -3.12098637e-02f, 1.01828314e-01f, 2.05899984e-01f,
  -4.40997593e-02f, 2.09585905e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  6.57411059e-04f, 5.28636426e-02f, -1.45923868e-01f, 6.42156228e-02f, -2.39313226e-02f, -8.94772708e-02f, -1.96768239e-01f, -1.38610691e-01f, 1.22887142e-01f, -1.37374550e-01f,
  -1.07328624e-01f, 5.81950657e-02f, 2.08842773e-02f, -3.18320189e-03f, -7.21330419e-02f, 4.81068976e-02f, -8.56862366e-02f, 3.25342901e-02f, -1.92424357e-02f, -1.05976555e-02f,
  -1.21867605e-01f, -2.05187146e-02f, 1.09645203e-01f, -7.06271604e-02f, -1.34394974e-01f, 3.32807079e-02f, -9.66391787e-02f, -2.37546220e-01f, 5.87428734e-02f, -1.18136816e-01f,
  -6.83620721e-02f, -5.77931143e-02f, -7.55942613e-03f, -9.15069506e-02f, -1.12391755e-01f, -9.85751227e-02f, 9.79155153e-02f, 1.13850217e-02f, -1.31912977e-01f, -5.96425161e-02f,
  -4.42859083e-02f, 1.55654252e-01f, -4.11155745e-02f, -2.05983967e-02f, -4.22861129e-02f, -2.63770693e-03f, -1.74323380e-01f, -9.09013152e-02f, 1.18363678e-01f, 5.01680598e-02f,
  -8.04361776e-02f, 1.91311121e-01f, 3.38161513e-02f, 6.29947782e-02f, 1.90914899e-01f, 1.21033549e-01f, 9.52079818e-02f, -1.07422151e-01f, 1.19358607e-01f, 4.28444631e-02f,
  -1.76573973e-02f, 1.68637093e-02f, 8.33645388e-02f, -3.30260806e-02f, -4.63168770e-02f, 1.73334152e-01f, -2.74292547e-02f, 7.85775017e-04f, 1.26192108e-01f, -8.60031247e-02f,
  6.51778430e-02f, 1.08160950e-01f, 1.27535323e-02f, -3.51664284e-03f, 1.05842829e-01f, 1.04891375e-01f, -1.63566813e-01f, -1.30375266e-01f, -1.42110035e-01f, 3.80334891e-02f,
  -7.59697556e-02f, 1.72860339e-01f, -1.06858537e-01f, -3.43188308e-02f, -9.12603587e-02f, 7.69966617e-02f, -2.31733657e-02f, 5.73206879e-03f, -1.04192287e-01f, -3.03415488e-02f,
  -1.14139412e-02f, -1.07622981e-01f, 1.02447476e-02f, -3.79531421e-02f, -1.05139934e-01f, 1.19707905e-01f, -1.02264933e-01f, -1.70811117e-01f, -7.21283406e-02f, -1.14776462e-01f,
  5.66868037e-02f, 1.09282872e-02f, 1.01707503e-01f, 6.49226233e-02f, 9.56531614e-02f, 4.95169684e-02f, -4.05207202e-02f, -7.55847692e-02f, 1.09547429e-01f, 1.61815342e-02f,
  -6.39939234e-02f, 8.83928984e-02f, 5.67682907e-02f, 1.70980692e-01f, 7.66692832e-02f, 8.11055750e-02f, -3.97609472e-02f, -9.88246948e-02f, 1.46193698e-01f, -1.79877698e-01f,
  -1.62525587e-02f, -3.26868822e-03f, 3.34898606e-02f, -4.75554578e-02f, 1.48131281e-01f, 7.45671317e-02f, -1.40824141e-02f, -2.45374464e-03f, 1.53379410e-03f, -3.66492085e-02f,
  1.21881530e-01f, 1.40204802e-01f, -7.89412037e-02f, 1.33362263e-01f, -4.99566235e-02f, -6.99418783e-02f, 2.49780267e-02f, -7.52636511e-03f, -9.81580094e-03f, -3.00496742e-02f,
  7.35292211e-02f, -2.13951781e-01f, -1.08245471e-02f, -8.50707218e-02f, -4.18637432e-02f, 1.32718369e-01f, -1.43610677e-02f, -8.13448951e-02f, 5.66419214e-02f, -8.77154097e-02f,
  1.09084465e-01f, -9.55646038e-02f, 2.35356484e-02f, 1.58281121e-02f, 8.19072798e-02f, -2.21416745e-02f, 9.88156721e-02f, 3.23405489e-02f, 9.23527330e-02f, 6.85728267e-02f,
  -3.85066159e-02f, -1.59296662e-01f, -1.02549314e-01f, -7.98247829e-02f, -4.91099581e-02f, -3.46489400e-02f, 5.43348938e-02f, -2.21985904e-03f, 1.92236364e-01f, 7.97465518e-02f,
  1.51796445e-01f, -1.55064724e-02f, 7.43795708e-02f, -2.23386958e-01f, 8.54849741e-02f, -6.20236471e-02f, -1.63488984e-02f, -1.35345802e-01f, -1.25526994e-01f, -7.00343177e-02f,
  1.37836322e-01f, -1.08574949e-01f, -4.84975241e-02f, 8.46782550e-02f, -6.49028867e-02f, 6.76411763e-02f, 6.19023554e-02f, 9.83444825e-02f, -5.04714325e-02f, -8.29344913e-02f,
  -1.24538578e-01f, 1.61893040e-01f, -5.75985424e-02f, -4.08706591e-02f, 1.73765700e-02f, -1.48799539e-01f, -9.97186750e-02f, 1.03478715e-01f, -5.94461486e-02f, 4.01472338e-02f,
  -6.50771782e-02f, -1.69619352e-01f, -1.68001242e-02f, 2.70650312e-02f, 1.18016623e-01f, 4.34879661e-02f, -5.23836315e-02f, -8.04236978e-02f, -1.93946972e-01f, -8.24719593e-02f,
  -4.47414408e-04f, -1.07587762e-01f, -1.16689377e-01f, -1.06897317e-01f, 1.77645847e-01f, 1.05689660e-01f, 6.40054941e-02f, 1.47187620e-01f, 5.14249923e-03f, -4.84049395e-02f,
  -2.97492258e-02f, -7.52222613e-02f, 7.79906511e-02f, -7.17757940e-02f, -1.33663401e-01f, 8.76051188e-02f, -1.20579146e-01f, 4.75370474e-02f, 3.61961834e-02f, -3.21358107e-02f,
  5.84449433e-02f, 1.07717611e-01f, -1.85332224e-02f, 8.80241692e-02f, 5.36427423e-02f, -3.67152393e-02f, -8.38938355e-02f, -9.39634368e-02f, -8.97280425e-02f, -1.12686530e-01f,
  -2.59481743e-02f, 1.05668195e-02f, 4.55315709e-02f, -1.90833844e-02f, -3.80124003e-02f, -1.04694128e-01f, -1.44341365e-01f, 1.07286222e-01f, 1.46679595e-01f, 7.81337023e-02f,
  9.95026231e-02f, 1.29277576e-02f, 6.96358234e-02f, -1.12437770e-01f, 3.33152562e-02f, -7.80802071e-02f, -7.21975639e-02f, 2.38741450e-02f, 2.33347528e-02f, -2.62504630e-02f,
  -7.24389032e-02f, -2.03911252e-02f, 4.43464424e-03f, 3.94784845e-02f, -1.19263418e-01f, 4.95429896e-02f, 3.12479027e-03f, -1.67660236e-01f, 9.32476893e-02f, 1.29632816e-01f,
  6.06106110e-02f, -1.07172742e-01f, -2.39585247e-02f, -7.08048269e-02f, 3.58402953e-02f, -1.13187991e-01f, -3.06423660e-02f, -7.60327699e-03f, -1.48087844e-01f, -5.32385260e-02f,
  1.05357595e-01f, -6.56514391e-02f, -1.43745214e-01f, -2.84105260e-02f, 5.81698455e-02f, -1.55955199e-02f, -3.69899198e-02f, 5.02916649e-02f, 6.29856288e-02f, 1.37497619e-01f,
  7.94621184e-02f, 6.58977777e-03f, 1.55338030e-02f, 5.29700657e-03f, -3.31510343e-02f, -9.54455361e-02f, -8.36930871e-02f, -7.67900795e-02f, -4.28197868e-02f, -6.32113358e-03f,
  2.49976311e-02f, 1.18358470e-01f, 4.56299409e-02f, 2.99662482e-02f, -1.42041996e-01f, -8.22542310e-02f, 7.64410198e-02f, 6.91305986e-03f, -1.44544274e-01f, 8.93615838e-03f,
  -7.26774409e-02f, 6.83555007e-02f, -1.54515717e-03f, 1.22364670e-01f, 2.95373127e-02f, 8.17002431e-02f, -1.39183834e-01f, 5.84145896e-02f, -8.95536765e-02f, 3.41731869e-02f,
  -6.12309277e-02f, -1.04928911e-01f, 5.59672154e-03f, -4.33215946e-02f, 1.84213917e-03f, -2.61371005e-02f, -1.58291265e-01f, -7.94229209e-02f, 3.30068246e-02f, -1.66121230e-01f,
  6.52910993e-02f, 3.09302453e-02f, 2.27256902e-02f, -7.11467341e-02f, 7.01775476e-02f, -2.32982114e-02f, -1.46616861e-01f, 1.18573703e-01f, -2.61141025e-02f, 1.14336699e-01f,
  -7.05900639e-02f, -3.57333757e-02f, 1.49525881e-01f, 9.46848653e-03f, -9.16051790e-02f, 1.45332560e-01f, 5.66971786e-02f, -1.09742157e-01f, 9.13836360e-02f, 1.91145465e-02f,
  -5.08967005e-02f, -3.08929253e-02f, -5.96054876e-03f, 1.29402086e-01f, -6.00633286e-02f, 1.59666128e-02f, -1.51079642e-02f, 1.49878561e-02f, 4.88844551e-02f, 3.96477692e-02f,
  -5.61404694e-03f, -1.14112824e-01f, -1.08263798e-01f, -1.83113255e-02f, 9.01158303e-02f, -1.42651781e-01f, -1.37841493e-01f, -2.42529452e-01f, -7.01477900e-02f, -4.24467586e-02f,
  -2.42734631e-03f, 2.14628540e-02f, -3.37750791e-03f, -1.45092169e-02f, -1.59439579e-01f, 2.54830241e-01f, 1.22725211e-01f, -2.04646736e-02f, 1.01231206e-02f, -4.26255614e-02f,
  8.19894299e-02f, -1.15378402e-01f, -8.78792629e-02f, -1.60462279e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.70828477e-02f, 1.54516045e-02f, 1.46726668e-02f, 3.75260636e-02f, 5.62116131e-02f, -5.18907122e-02f, -6.31250367e-02f, -1.15280107e-01f, -1.67916045e-02f, -1.14846779e-02f,
  -1.28887342e-02f, -1.69649214e-01f, 6.29310459e-02f, 4.78338301e-02f, -8.92484635e-02f, 8.46986100e-02f, 7.20872059e-02f, -6.74972832e-02f, -1.12853885e-01f, 1.12154528e-01f,
  1.39307873e-02f, -4.49715964e-02f, 9.84716713e-02f, 3.42644565e-02f, -7.63987601e-02f, -5.27239852e-02f, -1.77847035e-02f, 1.06875442e-01f, 1.13110341e-01f, 5.57662547e-02f,
  -5.82944863e-02f, 5.29214647e-03f, -3.96061391e-02f, 2.02930391e-01f, 1.18457163e-02f, -2.81594414e-02f, -5.76909743e-02f, -1.41747799e-02f, 2.49009095e-02f, -1.01993643e-01f,
  1.76974870e-02f, -8.01868960e-02f, -9.37587842e-02f, 2.73914039e-02f, -2.78321523e-02f, -1.88872933e-01f, -1.78265348e-02f, -1.67136177e-01f, -2.86129322e-02f, 5.71452715e-02f,
  9.15105492e-02f, 1.92984771e-02f, 9.87921432e-02f, -3.76123935e-02f, -5.61340973e-02f, 2.37636805e-01f, 1.15098722e-01f, 1.48038208e-01f, 7.08357021e-02f, 4.17502299e-02f,
  -1.10307649e-01f, -6.14591055e-02f, 1.39869079e-02f, -2.78907437e-02f, 2.78713554e-02f, 8.09600279e-02f, 2.41974387e-02f, 4.33020443e-02f, -4.07015495e-02f, -1.08922403e-02f,
  7.63223767e-02f, 1.52737826e-01f, -9.69248787e-02f, -5.10753319e-02f, -1.13064736e-01f, 8.23359415e-02f, 7.12248012e-02f, 7.07508996e-02f, 9.12821218e-02f, -3.81821441e-03f,
  -1.97238728e-01f, -3.91533673e-02f, 2.74914280e-02f, 1.49130318e-02f, 7.19989687e-02f, 1.23504862e-01f, 2.18503118e-01f, -8.23324248e-02f, 1.49968043e-01f, 2.07703695e-01f,
  2.10844241e-02f, 1.52999848e-01f, -9.69360024e-02f, 4.35209684e-02f, -1.41829520e-01f, 1.14201680e-01f, -1.05542473e-01f, -4.16927710e-02f, 3.40489782e-02f, -1.05897963e-01f,
  -6.45735711e-02f, 1.22547343e-01f, -1.40340969e-01f, -5.39748520e-02f, -1.47462085e-01f, 2.57358700e-01f, -3.13166995e-03f, 4.88170758e-02f, 9.03598890e-02f, 2.41949275e-01f,
  -9.67627764e-02f, 9.38498527e-02f, 5.95842265e-02f, 4.93554585e-02f, -6.09858111e-02f, 1.64560378e-01f, -7.38896383e-03f, -1.22521780e-01f, 1.75178409e-01f, 4.73404862e-02f,
  -1.22077100e-01f, -2.12372169e-01f, 8.01303983e-02f, 2.15801671e-02f, 1.52471691e-01f, -2.29001082e-02f, 9.96782109e-02f, -1.79579249e-04f, -1.11103944e-01f, -6.37157559e-02f,
  6.38859421e-02f, 3.97254415e-02f, -1.21772930e-01f, -8.44099522e-02f, -1.63963414e-03f, 1.21034540e-01f, 1.33259094e-03f, -2.46619619e-02f, -1.94021780e-02f, -4.36461158e-02f,
  -1.89989917e-02f, -1.14948556e-01f, 1.56679694e-02f, -6.83638975e-02f, 5.46462089e-02f, 1.56414099e-02f, -7.98366517e-02f, -4.04533334e-02f, 9.48025659e-02f, -6.99362624e-03f,
  6.46771938e-02f, -3.00675835e-02f, -1.84940323e-02f, -3.36191617e-02f, 5.88742718e-02f, 3.99022996e-02f, 7.58486465e-02f, -1.23291835e-01f, 3.62930596e-02f, 4.94332165e-02f,
  8.17000642e-02f, -1.96012724e-02f, 8.56566280e-02f, -2.53356285e-02f, 7.99672604e-02f, -9.83888283e-03f, -8.44435021e-02f, 4.88732494e-02f, -2.80563012e-02f, 5.85794076e-02f,
  -1.08421803e-01f, -3.70569564e-02f, 6.37962222e-02f, 1.29465804e-01f, -6.85980842e-02f, 7.45360181e-02f, -6.40315488e-02f, -4.81418371e-02f, 4.83463109e-02f, 1.84420664e-02f,
  8.54107440e-02f, -9.08593982e-02f, 1.15303539e-01f, -9.00707915e-02f, -1.14541285e-01f, -2.07464397e-03f, -6.88179806e-02f, 8.66477489e-02f, 9.81573984e-02f, 1.01691121e-02f,
  6.07066378e-02f, 7.68979872e-03f, 3.61698978e-02f, 1.67128548e-01f, 2.08133608e-01f, 6.26945496e-03f, 7.80010521e-02f, 2.54978724e-02f, -7.70208389e-02f, -8.02869201e-02f,
  2.23094039e-03f, -1.52136102e-01f, -7.10771680e-02f, -8.86076316e-03f, 1.46691144e-01f, 5.52718248e-03f, 2.70111889e-01f, 1.89379435e-02f, 1.30823940e-01f, 1.12160973e-01f,
  -3.68496254e-02f, -6.21324852e-02f, 5.31439669e-02f, 4.68604043e-02f, -1.05898425e-01f, -5.76111637e-02f, 1.89505041e-01f, -1.17984209e-02f, 1.83034018e-01f, 2.15359852e-01f,
  1.24970503e-01f, -5.13193123e-02f, 2.20451951e-01f, -1.41923994e-01f, 2.16778025e-01f, 3.24457705e-01f, 1.21307664e-01f, -2.49262787e-02f, 1.04988568e-01f, 7.11407810e-02f,
  1.04631789e-01f, 1.02896392e-01f, -3.23636713e-03f, -1.76228061e-01f, 1.62746590e-02f, 7.43178651e-02f, -6.20825626e-02f, -1.86651886e-01f, 8.47904235e-02f, -8.91882777e-02f,
  6.15570880e-02f, -1.18025407e-01f, 1.42603636e-01f, 1.58169698e-02f, 9.14252773e-02f, 5.88635020e-02f, -1.72569770e-02f, 2.53451049e-01f, 2.36661285e-01f, 2.41261870e-01f,
  6.94949329e-02f, 6.53837435e-03f, -1.23538248e-01f, 2.62809601e-02f, -9.59551930e-02f, 1.10286385e-01f, -5.10437302e-02f, -6.16945326e-02f, 5.26821688e-02f, 4.92064543e-02f,
  1.12772193e-02f, 8.29789713e-02f, -4.25128406e-03f, -2.69312244e-02f, 1.06652059e-01f, 9.43589211e-02f, 1.05507644e-02f, 8.16687122e-02f, 1.31459720e-02f, 2.22631186e-01f,
  1.10574983e-01f, -1.22958243e-01f, 2.83699334e-01f, 1.83248699e-01f, -4.68341112e-02f, 7.46603534e-02f, 1.40634794e-02f, 3.87034267e-02f, -2.79795170e-01f, 7.16088712e-02f,
  -1.88822582e-01f, -1.86687693e-01f, -2.03055162e-02f, -9.80654657e-02f, -1.03149876e-01f, 1.23089522e-01f, 9.36808437e-02f, -4.35232930e-02f, 2.89216191e-01f, 1.68680117e-01f,
  1.31316900e-01f, -9.47938487e-02f, 1.61481693e-01f, 3.87054905e-02f, 5.17075956e-02f, 9.03611630e-03f, -4.01019901e-02f, -1.43366173e-01f, -8.51478726e-02f, 4.53329682e-02f,
  -8.55853111e-02f, -6.88735768e-02f, -9.55002308e-02f, 1.40638515e-01f, 2.17902556e-01f, 1.92277968e-01f, 1.32362440e-01f, -1.51681766e-01f, -8.34753886e-02f, 1.98816791e-01f,
  2.00417683e-01f, -8.43673497e-02f, 4.39998098e-02f, 1.97576374e-01f, -8.47501084e-02f, -4.53997962e-02f, -1.34143606e-01f, 1.97512984e-01f, 8.63391533e-03f, 8.73540193e-02f,
  -1.05178788e-01f, 4.03193161e-02f, 7.12231472e-02f, 2.29117759e-02f, 4.36575189e-02f, -5.97693510e-02f, -7.18441755e-02f, 7.40812495e-02f, -1.28416615e-02f, -7.43135065e-02f,
  -8.12563375e-02f, 7.85954744e-02f, 6.77734613e-02f, -7.49144927e-02f, 1.11546613e-01f, -4.56123091e-02f, -9.12942141e-02f, -1.13287181e-01f, 6.54862225e-02f, 1.54063217e-02f,
  -5.82057685e-02f, 5.36735058e-02f, -2.28288099e-02f, -1.01168649e-02f, -8.60760137e-02f, 1.20798111e-01f, -1.84804257e-02f, 9.99438092e-02f, -9.06536952e-02f, 8.85557756e-02f,
  -1.13227747e-01f, 1.05942756e-01f, 4.62479629e-02f, 8.54023453e-03f, -1.16162345e-01f, -1.97381172e-02f, -6.19716756e-02f, 7.34535828e-02f, -1.14405625e-01f, -1.43978717e-02f,
  -1.02045074e-01f, -1.24048948e-01f, -1.03090599e-01f, 2.51710173e-02f, 5.47098070e-02f, 1.15804650e-01f, -9.49247032e-02f, -4.49313745e-02f, -1.23267204e-01f, -1.18877195e-01f,
  1.27417490e-01f, 3.54167931e-02f, 3.78747694e-02f, -3.91061418e-02f, -9.25897714e-03f, 4.67556044e-02f, 1.10844187e-01f, -1.15784295e-01f, 6.94110915e-02f, 1.29440427e-02f,
  -8.07555765e-02f, -2.30136402e-02f, 8.51673111e-02f, -1.22283898e-01f, -1.62597612e-01f, -1.15710936e-01f, -4.75099310e-03f, -1.03344359e-01f, 1.22762593e-02f, -1.47799671e-01f,
  6.96250424e-02f, 1.63766310e-01f, -6.57060072e-02f, 1.67018801e-01f, -1.45456120e-01f, -9.62550938e-02f, 8.72199461e-02f, 1.32079914e-01f, 5.77825382e-02f, -8.44364148e-03f,
  9.32468623e-02f, -1.51648074e-01f, 1.61113694e-01f, 1.94134172e-02f, -9.69884992e-02f, -8.89656395e-02f, -3.35450247e-02f, -3.33840399e-05f, 1.40728489e-01f, -1.39419541e-01f,
  3.73724401e-02f, -2.01660711e-02f, -6.43110797e-02f, 7.66571611e-02f, -2.35090423e-02f, 9.21912491e-02f, -8.29351172e-02f, 7.01699331e-02f, 7.48599395e-02f, 8.86946023e-02f,
  -1.23748675e-01f, -1.12789996e-01f, 1.21879637e-01f, -2.27992870e-02f, -7.62645081e-02f, 4.63599786e-02f, -6.14122450e-02f, -9.86421928e-02f, 3.61399651e-02f, 2.12794572e-01f,
  6.65194541e-02f, 6.49202541e-02f, 6.70259818e-02f, 1.36373982e-01f, 5.20471372e-02f, 8.36691484e-02f, -1.39555782e-01f, 6.51071966e-02f, 1.35122389e-01f, 1.01381317e-02f,
  -1.10260092e-01f, -1.04472160e-01f, -8.54590684e-02f, 2.98786294e-02f, 1.34222597e-01f, 1.42905504e-01f, -1.07938290e-01f, -1.44845217e-01f, -8.77040103e-02f, -2.29438674e-02f,
  7.42759630e-02f, 9.43507925e-02f, 2.50354428e-02f, -8.14567059e-02f, -2.03067400e-02f, -1.30292252e-02f, -7.74067454e-03f, -7.67438719e-03f, 8.34495127e-02f, -7.54368976e-02f,
  1.04472183e-01f, 8.99378806e-02f, 3.78538743e-02f, 1.92329958e-02f, 9.12574530e-02f, -2.02274118e-02f, -1.04095936e-01f, 3.91717218e-02f, -1.25182003e-01f, 5.73711842e-02f,
  5.65176606e-02f, -1.22532137e-01f, 7.86949247e-02f, 5.30598685e-02f, -8.76174718e-02f, 7.12192580e-02f, 1.18259698e-01f, 6.28733262e-02f, -9.91023704e-02f, 7.35042393e-02f,
  -1.90803465e-02f, 1.52413651e-01f, 1.20633200e-01f, -1.43278753e-02f, 9.72975194e-02f, 3.76241691e-02f, -5.21936454e-04f, -4.01214771e-02f, 9.60694551e-02f, -1.47705814e-02f,
  -3.59976329e-02f, 1.01435892e-01f, -1.95447206e-02f, 2.49628238e-02f, 1.34506017e-01f, -7.38728568e-02f, -2.49884073e-02f, -8.76205489e-02f, 1.29921436e-01f, 2.59122755e-02f,
  -1.40004978e-01f, -6.85158968e-02f, -5.01845740e-02f, 1.67197332e-01f, 1.79581288e-02f, -8.60496983e-02f, -1.70028815e-03f, -5.05138822e-02f, -2.37582456e-02f, -1.29562989e-01f,
  -4.95377108e-02f, -3.03677283e-02f, 1.58229545e-01f, 9.36682448e-02f, 1.33769736e-01f, 1.42934710e-01f, 1.36608854e-01f, -2.15048138e-02f, 9.74282622e-02f, 2.63098031e-02f,
  -3.95855382e-02f, 4.72550988e-02f, -1.52728170e-01f, 2.32564107e-01f, -1.30565897e-01f, 1.39664263e-01f, 8.12805220e-02f, 1.16872005e-01f, -9.65989903e-02f, -7.88354054e-02f,
  1.44562379e-01f, 2.65842630e-03f, 8.11951160e-02f, 6.71262965e-02f, -3.40378173e-02f, 4.16116305e-02f, -6.06003441e-02f, 1.26625970e-01f, -4.83493693e-02f, 1.53948560e-01f,
  6.20987751e-02f, -4.39563058e-02f, 1.49199396e-01f, -4.17414634e-03f, -1.66817248e-01f, -1.09828576e-01f, -1.85992979e-02f, -2.83439457e-02f, -9.16127041e-02f, 8.30393359e-02f,
  6.24361970e-02f, -1.16293930e-01f, 1.23483604e-02f, 3.15317988e-01f, 1.68962345e-01f, -5.11995889e-02f, -4.50737290e-02f, 3.12900156e-01f, 1.35161281e-01f, 3.09699595e-01f,
  3.57462429e-02f, 4.24643867e-02f, -5.35903610e-02f, 2.30231896e-01f, 1.43449847e-02f, 3.99353988e-02f, 2.48314261e-01f, -2.68543929e-01f, -2.17099283e-02f, -2.02507991e-02f,
  9.12608057e-02f, 1.39963210e-01f, 1.73995718e-01f, 2.09019870e-01f, 2.38371678e-02f, 5.59533723e-02f, -3.15428227e-02f, -9.40671638e-02f, 8.39876384e-02f, -3.19398125e-03f,
  -1.83181204e-02f, 9.22126174e-02f, 1.31236985e-02f, 1.03115208e-01f, -6.50348887e-02f, 1.12997063e-01f, 9.84256938e-02f, -4.82819863e-02f, -7.06812888e-02f, -6.09104671e-02f,
  -2.83087790e-02f, 8.78110006e-02f, -6.12221472e-02f, -6.08319752e-02f, -1.30165573e-02f, 3.46422456e-02f, -1.11534111e-01f, 3.56713459e-02f, -1.19502835e-01f, 6.54858425e-02f,
  9.00375769e-02f, -5.99523373e-02f, -4.40462232e-02f, 1.02256566e-01f, -1.12317115e-01f, -9.53465402e-02f, -3.90136577e-02f, 1.79221935e-03f, 4.44968976e-02f, -1.08596899e-01f,
  -6.21349551e-03f, -9.63110626e-02f, -9.94254127e-02f, 3.39766033e-02f, -1.18239708e-01f, -1.20980315e-01f, 1.71906538e-02f, -9.24507231e-02f, 1.00294322e-01f, -1.97936557e-02f,
  -1.06814414e-01f, -2.85324510e-02f, 7.10972324e-02f, 5.42303324e-02f, 9.42359790e-02f, 8.45819488e-02f, -8.09926912e-02f, 7.43792858e-03f, -6.39539957e-02f, -7.71868080e-02f,
  -1.01708539e-01f, 1.33903222e-02f, 8.14862549e-02f, -3.77957933e-02f, 6.01990186e-02f, -1.69064477e-02f, 1.24686256e-01f, -1.75272692e-02f, -5.14923334e-02f, 7.25754872e-02f,
  7.41151795e-02f, -5.03269508e-02f, -1.05347961e-01f, -5.47630303e-02f, 6.37684995e-03f, 5.47173731e-02f, -1.06420882e-01f, -1.08158335e-01f, -9.35475379e-02f, -8.31806064e-02f,
  -6.86088502e-02f, 1.59070957e-02f, 8.98122489e-02f, 3.30348909e-02f, 8.64194483e-02f, 7.19418004e-02f, -9.88309179e-03f, -4.67386022e-02f, -1.07913651e-02f, -2.10290193e-03f,
  -3.55198979e-02f, -7.50633180e-02f, -9.77093130e-02f, -3.39762680e-02f, 8.05030614e-02f, 6.99043740e-03f, -1.01239130e-01f, 4.08428013e-02f, 1.12951599e-01f, 8.20957646e-02f,
  -4.80170250e-02f, -9.06765535e-02f, 8.37503448e-02f, 1.01037331e-01f, 8.44727606e-02f, 3.33480095e-03f, -7.78516084e-02f, -5.42828701e-02f, -8.42644554e-03f, -6.42657578e-02f,
  -7.96326846e-02f, -4.50147428e-02f, -9.24794227e-02f, 9.66997370e-02f, 2.98583638e-02f, 1.16349999e-02f, 1.21678025e-01f, -3.67554836e-02f, -8.39796066e-02f, 1.06377095e-01f,
  -2.42137648e-02f, -1.12588726e-01f, 3.44246663e-02f, 3.53347883e-02f, -7.01555684e-02f, 4.35885228e-02f, -8.80844817e-02f, 1.06295571e-01f, -1.14691168e-01f, -4.63065244e-02f,
  -7.52947032e-02f, -1.07229367e-01f, -7.82889873e-02f, -7.87850916e-02f, -5.76360449e-02f, -9.22499895e-02f, 2.78652702e-02f, 4.75275405e-02f, 9.75092202e-02f, -6.96018618e-03f,
  9.40949097e-02f, -2.11188961e-02f, 6.56882599e-02f, -2.27254648e-02f, -8.72193500e-02f, -1.17065132e-01f, -8.56149010e-03f, 8.33478197e-02f, -1.50487199e-02f, 1.19730242e-01f,
  1.23981602e-01f, 7.67495856e-02f, 3.05415597e-02f, 7.56670386e-02f, 7.95831755e-02f, 1.43041722e-02f, -1.97497103e-02f, -1.13618098e-01f, 5.48430569e-02f, 3.21405791e-02f,
  4.59105112e-02f, -2.15717908e-02f, -1.20441258e-01f, 6.39626309e-02f, -8.36359710e-02f, -5.76442517e-02f, 1.06457300e-01f, 1.55199558e-01f, 7.93466642e-02f, 1.03868164e-01f,
  1.43784940e-01f, -8.12928081e-02f, -3.75979654e-02f, -1.23843633e-01f, 5.76613210e-02f, -1.47601711e-02f, -1.00779764e-01f, -1.24147773e-01f, -7.61744082e-02f, -1.59781128e-01f,
  5.67211956e-02f, -7.26963431e-02f, 8.06107149e-02f, -3.96772921e-02f, 1.53335795e-01f, 9.37096626e-02f, 1.68933179e-02f, -9.28465053e-02f, 1.06501475e-01f, 2.32854620e-01f,
  2.03710318e-01f, 2.14937106e-02f, 2.95429379e-02f, -1.07096806e-01f, -1.59351416e-02f, -8.47156420e-02f, -2.20871493e-02f, 3.26537676e-02f, 2.43763015e-01f, 1.54531822e-01f,
  1.08456373e-01f, 2.19672710e-01f, 1.44724056e-01f, 1.57504633e-01f, -2.63524294e-01f, 6.62014335e-02f, 2.57129073e-01f, -1.31336212e-01f, 8.33920166e-02f, 2.54363120e-01f,
  -1.79613873e-01f, -2.36349717e-01f, -2.42062539e-01f, 1.50833633e-02f, -2.58338870e-03f, 1.65582925e-01f, -1.65600285e-01f, 4.69831787e-02f, -7.10866377e-02f, 1.08003303e-01f,
  2.81237096e-01f, -9.90322977e-02f, -1.08692281e-01f, 5.44068329e-02f, 1.32242218e-01f, -1.40713558e-01f, 6.10912964e-02f, 2.10012570e-02f, 1.42392889e-01f, 5.14966585e-02f,
  1.34659354e-02f, -3.24154884e-01f, -6.44288063e-02f, -1.28953159e-01f, -1.19643852e-01f, -3.09208129e-03f, -1.64814025e-01f, 3.71592236e-04f, 2.98377812e-01f, 3.82609457e-01f,
  2.41124570e-01f, -6.38533803e-03f, 9.24395174e-02f, 9.96304378e-02f, -6.69603199e-02f, -1.81682631e-02f, 3.05968344e-01f, 2.07343414e-01f, -4.87329327e-02f, 1.24354601e-01f,
  3.04711282e-01f, 6.39311895e-02f, 1.98166370e-01f, -4.50221486e-02f, -1.73248678e-01f, -5.98720685e-02f, -1.19230352e-01f, -1.47663817e-01f, 1.25478238e-01f, 1.05452634e-01f,
  -1.19979277e-01f, 3.11987102e-01f, -6.34687096e-02f, -8.50766972e-02f, -1.50851561e-02f, -1.02595493e-01f, 2.48230770e-02f, -1.34911276e-02f, 2.89009698e-02f, -4.17573489e-02f,
  7.67552406e-02f, 6.08770177e-02f, 2.75905337e-02f, -9.02635381e-02f, -7.16116726e-02f, 9.15072560e-02f, -1.04803890e-01f, -8.48463103e-02f, 6.25196695e-02f, -1.12681992e-01f,
  4.04131450e-02f, -4.61059660e-02f, -6.12582602e-02f, -5.19309640e-02f, 7.75187165e-02f, 1.17395841e-01f, 5.14000654e-02f, -5.60190640e-02f, 1.12999976e-01f, 6.93177208e-02f,
  -7.74316639e-02f, -3.59343663e-02f, 1.00875543e-02f, -5.24641424e-02f, 6.73018619e-02f, 3.63917723e-02f, 4.08511646e-02f, -1.04306489e-01f, -3.08982302e-02f, 2.36977115e-02f,
  -2.38272771e-02f, -7.75451660e-02f, -5.61026782e-02f, -1.10687755e-01f, -1.14038713e-01f, -7.97342733e-02f, -3.86526510e-02f, -1.11125983e-01f, 3.65219191e-02f, -3.33059691e-02f,
  -4.27931137e-02f, -1.21349022e-01f, -1.28022730e-04f, 1.17951371e-02f, -8.52428451e-02f, -1.90147720e-02f, -2.44669989e-02f, -1.11009680e-01f, -9.13929641e-02f, 5.85832857e-02f,
  7.31817782e-02f, -3.97576280e-02f, 3.00827529e-02f, 8.77525881e-02f, -1.56774223e-02f, 3.60252932e-02f, 3.61550972e-02f, 4.35779728e-02f, -7.94903412e-02f, 2.66240761e-02f,
  -7.35711306e-02f, -2.73496401e-03f, -7.36855865e-02f, -8.87189582e-02f, -7.85689950e-02f, 6.19519353e-02f, 1.04849026e-01f, 1.58008337e-02f, -1.92223601e-02f, -8.88074096e-03f,
  -9.99100804e-02f, 6.79439828e-02f, 7.89093673e-02f, -4.14295075e-03f, 2.03302596e-02f, -2.48695388e-02f, 7.98250660e-02f, 7.54177719e-02f, 5.79879060e-02f, 5.13487011e-02f,
  3.74812111e-02f, -7.89029300e-02f, -8.90079811e-02f, -9.48776156e-02f, 2.90987361e-02f, -5.16371578e-02f, -8.17346945e-02f, -9.71035361e-02f, 3.45299952e-02f, -9.09288377e-02f,
  -9.33385454e-03f, 1.57182366e-02f, 5.20902723e-02f, -1.22603990e-01f, -1.13063054e-02f, 7.01751783e-02f, -7.01663271e-02f, 1.86377726e-02f, -1.07081430e-02f, 9.59508866e-02f,
  -8.29658583e-02f, -1.00623593e-01f, -5.75757623e-02f, -1.10474639e-01f, 8.85551795e-02f, 2.12677214e-02f, -7.49012977e-02f, 1.03126258e-01f, 1.61412358e-02f, 9.54439305e-03f,
  1.18485279e-02f, -9.91278589e-02f, -1.94453262e-02f, -7.86081702e-03f, 9.35638100e-02f, -7.50313848e-02f, -5.21185100e-02f, -2.21680794e-02f, -8.07371214e-02f, -4.65941876e-02f,
  -1.20679006e-01f, 5.21809198e-02f, 4.88895178e-02f, -8.09349939e-02f, 6.46752026e-03f, 9.75012779e-02f, -9.76692438e-02f, -1.01274766e-01f, -6.29265010e-02f, 8.80001262e-02f,
  -6.92397505e-02f, -5.85722961e-02f, -2.82592624e-02f, 9.75487605e-02f, 1.00826576e-01f, 1.10906415e-01f, -6.46509528e-02f, -8.56298655e-02f, 1.72007903e-02f, -6.95609152e-02f,
  2.02684794e-02f, 7.61839896e-02f, -1.25115454e-01f, -1.01427482e-02f, -1.39814720e-03f, 1.14898011e-01f, 5.74485399e-02f, -1.25256971e-01f, -1.06965795e-01f, -8.53602141e-02f,
  1.90511923e-02f, -5.63331358e-02f, -7.05539808e-02f, -7.12176487e-02f, -1.82967745e-02f, 2.00094525e-02f, 1.13847233e-01f, -6.42679259e-02f, -3.64865921e-02f, 1.16227448e-01f,
  -4.77775261e-02f, 1.03643276e-01f, -9.57863107e-02f, 8.29102620e-02f, -7.30396584e-02f, 1.38321612e-02f, -1.24989256e-01f, 9.75051001e-02f, -1.22294016e-01f, -1.04050286e-01f,
  -9.50712636e-02f, -8.00433904e-02f, 5.86306527e-02f, 5.58397062e-02f, -5.52901700e-02f, 7.78317675e-02f, 6.48216456e-02f, 9.16387737e-02f, 5.51082604e-02f, -1.87384039e-02f,
  -2.58708131e-02f, -1.24998078e-01f, 6.39896616e-02f, -8.14690888e-02f, -3.18706706e-02f, 1.45397400e-02f, -3.15894955e-03f, 7.99376145e-02f, 3.49368784e-04f, 2.90911011e-02f,
  -1.13081872e-01f, -5.74515201e-02f, 8.18852335e-02f, 1.10167161e-01f, -1.06890604e-01f, -4.07362320e-02f, -5.82292303e-02f, -5.82083724e-02f, -5.79833500e-02f, 1.71518270e-02f,
  -5.27807251e-02f, -3.51718590e-02f, -3.00525278e-02f, -1.49048604e-02f, 1.25663786e-03f, -6.36192113e-02f, -6.69452623e-02f, 4.80846595e-03f, -9.36038792e-02f, 4.98372391e-02f,
  7.51587823e-02f, 9.40465927e-02f, -1.17426803e-02f, 5.53270243e-02f, -8.27078149e-02f, 5.17205894e-02f, -3.20956334e-02f, 6.32221848e-02f, 1.12527117e-01f, 9.91858449e-03f,
  -1.22925647e-01f, 2.47754832e-03f, 3.55508216e-02f, -6.39749765e-02f, 7.52147064e-02f, 3.90037782e-02f, -7.32857212e-02f, 1.03806302e-01f, -7.19606690e-03f, 6.99232221e-02f,
  4.21650223e-02f, -5.27341738e-02f, 7.89491832e-02f, -5.76813221e-02f, -5.42009659e-02f, 8.56575072e-02f, 2.65214052e-02f, -4.26617898e-02f, 6.81396946e-02f, -6.96221814e-02f,
  9.74290520e-02f, 5.12516685e-02f, -7.79128373e-02f, -9.52359512e-02f, 6.96987659e-02f, -5.76975867e-02f, 1.56417233e-03f, 1.24912091e-01f, 1.11688547e-01f, 8.11276585e-03f,
  9.29678082e-02f, -8.86162892e-02f, -1.24380991e-01f, -4.57207263e-02f, -1.08620457e-01f, 8.16851016e-03f, -2.70983335e-02f, -7.13523328e-02f, -1.17098734e-01f, 2.26239357e-02f,
  -9.91178602e-02f, 1.18707113e-01f, -1.03892043e-01f, -5.41347526e-02f, -1.04905188e-03f, -1.04640037e-01f, -2.62591732e-03f, 6.43234849e-02f, 5.18075228e-02f, 5.90810105e-02f,
  -2.52427533e-02f, 1.05745243e-02f, -9.44496095e-02f, 3.97504903e-02f, -3.97797264e-02f, 1.18428454e-01f, -2.89454199e-02f, -3.73570994e-02f, 5.84268011e-03f, -1.22259296e-02f,
  -4.92153224e-04f, 5.05102277e-02f, -1.02446064e-01f, -9.23101902e-02f, -6.05178587e-02f, 6.90823719e-02f, 3.16805094e-02f, 8.59829113e-02f, -9.45832133e-02f, 1.18250549e-01f,
  1.03459060e-01f, 8.58764127e-02f, 1.24098100e-02f, -1.17521711e-01f, -8.94252583e-02f, 5.24003208e-02f, -1.04631916e-01f, 2.37019584e-02f, -1.20011926e-01f, -4.23171856e-02f,
  -7.06680641e-02f, 2.76025129e-03f, -1.17309131e-02f, -5.52458726e-02f, 9.41163450e-02f, -1.05708703e-01f, 8.38079210e-03f, -6.60947934e-02f, -1.67249124e-02f, 7.17621893e-02f,
  4.25440259e-02f, -8.26312974e-02f, -6.75668120e-02f, 4.18672003e-02f, 1.14839533e-02f, -1.34490365e-02f, -5.76478355e-02f, 3.38365845e-02f, -7.93783814e-02f, -5.55601232e-02f,
  8.44989643e-02f, 2.57101487e-02f, -3.27640884e-02f, -1.63676366e-02f, 1.58279851e-01f, 1.69201389e-01f, 1.87677771e-01f, 1.08075589e-01f, 1.55294567e-01f, -8.48448798e-02f,
  -1.09036483e-01f, 7.66053796e-02f, -3.12698446e-02f, -1.26229785e-02f, -1.33195937e-01f, 2.55216882e-02f, -1.13835283e-01f, 3.66385095e-02f, -9.25048813e-02f, -1.57635972e-01f,
  -5.42537011e-02f, 1.91167817e-02f, 6.70486465e-02f, -9.81807262e-02f, 1.33164361e-01f, 1.50756791e-01f, 2.68331642e-04f, 1.38049405e-02f, 3.76199484e-02f, 7.63320178e-02f,
  6.21360540e-02f, -2.52719969e-02f, -1.54732868e-01f, -8.26585293e-03f, -7.52345622e-02f, 1.38979563e-02f, 2.51488332e-02f, 1.11641891e-01f, 3.50080542e-02f, 1.01779759e-01f,
  1.16401523e-01f, 1.12327941e-01f, -4.10637446e-02f, 6.39169589e-02f, 2.78209541e-02f, 1.31203920e-01f, -1.10268421e-01f, -4.55397591e-02f, 1.28763899e-01f, -5.43253385e-02f,
  9.39351395e-02f, -7.20903799e-02f, -1.26415968e-01f, 7.00810254e-02f, 4.65793395e-03f, -8.71786326e-02f, -3.87512669e-02f, 1.09296339e-02f, -8.03350657e-03f, -9.26173478e-02f,
  6.45754673e-03f, -1.19379349e-02f, -4.59180474e-02f, 1.61545575e-02f, -2.89589204e-02f, 7.05900416e-02f, 1.42006511e-02f, 9.97135490e-02f, -1.11406527e-01f, 7.10045472e-02f,
  -7.25505203e-02f, -5.85206002e-02f, -1.23414584e-01f, -8.84354636e-02f, -1.14106990e-01f, 8.84271637e-02f, -3.66797373e-02f, -4.91891354e-02f, -7.24351108e-02f, -6.82470277e-02f,
  9.58748460e-02f, 4.91900295e-02f, 1.64018404e-02f, -6.05258010e-02f, -5.83609790e-02f, -2.40335092e-02f, -9.11758095e-02f, -1.24092236e-01f, 6.93582222e-02f, 4.90579456e-02f,
  -1.03566080e-01f, -7.08931014e-02f, -8.17995444e-02f, -5.37457913e-02f, -1.31877251e-02f, 3.81758735e-02f, -8.44874457e-02f, -8.82316902e-02f, 4.42175604e-02f, 2.51387549e-03f,
  -1.12449192e-01f, -4.53996696e-02f, -6.13299645e-02f, -8.52937922e-02f, -4.74201739e-02f, -5.77518456e-02f, -6.57101907e-03f, -3.10995728e-02f, 7.99394175e-02f, -1.07441889e-02f,
  -1.05434150e-01f, -1.22753166e-01f, 5.73698319e-02f, -9.87858027e-02f, -1.58884674e-02f, 7.28707165e-02f, -1.18800439e-01f, -7.28382170e-02f, -2.01680306e-02f, 2.49169692e-02f,
  4.70029749e-02f, 2.03221738e-01f, 1.38872638e-01f, 1.20666429e-01f, 1.80307791e-01f, -2.94988640e-02f, 9.34982896e-02f, 3.70200817e-03f, 1.07662424e-01f, -7.19522983e-02f,
  -7.70716891e-02f, 2.21966773e-01f, -9.64100882e-02f, 7.54112378e-02f, 7.82107487e-02f, 6.69209212e-02f, 4.92221043e-02f, 1.59867778e-01f, -9.42045450e-02f, -1.07519276e-01f,
  6.14277227e-03f, -1.08755536e-01f, 1.19675502e-01f, 1.17109463e-01f, -7.41283372e-02f, 1.32267639e-01f, -1.79594159e-01f, -2.25090235e-01f, -4.50338237e-03f, 7.55957365e-02f,
  -1.86468393e-01f, 7.91520849e-02f, 2.28922188e-01f, -7.72414580e-02f, 1.89486798e-02f, -1.36010259e-01f, 7.63262957e-02f, 7.69352168e-02f, 1.34481527e-02f, 1.11057810e-01f,
  -8.65310952e-02f, 2.42530897e-01f, -1.00530021e-01f, 8.95628110e-02f, -7.26553947e-02f, 3.19030344e-01f, -2.12134659e-01f, 2.02173769e-01f, 4.09680344e-02f, 2.18098834e-01f,
  -3.36931960e-04f, 2.22113177e-01f, 1.01658367e-02f, 1.95251331e-01f, 3.72369647e-01f, -7.25536570e-02f, 2.23138146e-02f, -2.97126197e-03f, 4.20625135e-02f, 1.15598552e-01f,
  1.11473864e-02f, 3.99286777e-01f, 1.05594501e-01f, -9.22440514e-02f, 3.41716185e-02f, -1.47761449e-01f, -9.32762807e-04f, -2.75385864e-02f, -1.42339364e-01f, -4.61997055e-02f,
  -1.43342137e-01f, 3.04474011e-02f, -1.67884249e-02f, -2.95210574e-02f, -2.94835828e-02f, -7.77719766e-02f, 1.08789794e-01f, 4.63283323e-02f, 2.44515270e-01f, 3.42133604e-02f,
  -1.01043142e-01f, -1.37593523e-01f, 9.08382535e-02f, 9.92035344e-02f, -1.11226581e-01f, 6.89996853e-02f, 3.83124948e-02f, -1.16987213e-01f, 5.99942170e-03f, 1.32852301e-01f,
  -1.56384811e-01f, -4.22243327e-02f, -5.80996759e-02f, 2.03575250e-02f, -8.25269818e-02f, 1.16555378e-01f, 1.00376703e-01f, 3.82368243e-03f, -2.64399294e-02f, 6.82338178e-02f,
  -7.55242407e-02f, -4.46650125e-02f, 1.18963704e-01f, -7.57276341e-02f, -3.66693176e-02f, 2.22778376e-02f, 7.64052346e-02f, -5.24500012e-02f, 8.64280611e-02f, 5.34196869e-02f,
  6.70465501e-03f, -1.63116410e-01f, 1.86444335e-02f, -1.86959475e-01f, 8.91355500e-02f, 1.06897958e-01f, -3.20699103e-02f, -7.06986263e-02f, -1.59030095e-01f, 1.00708701e-01f,
  8.69956464e-02f, 1.14341103e-01f, 6.53794184e-02f, 3.28479111e-02f, -1.23868257e-01f, -6.26803190e-02f, -6.68283179e-02f, -5.40120043e-02f, 1.25287563e-01f, 6.55182600e-02f,
  -3.24222557e-02f, 9.71220434e-02f, 1.03929751e-01f, 3.38873938e-02f, 1.66739985e-01f, 1.07847461e-02f, -1.12631179e-01f, 4.23476845e-02f, -1.21424552e-02f, 2.21815243e-01f,
  -1.41543418e-01f, 1.76849991e-01f, 9.13503096e-02f, 6.97484091e-02f, -7.74196163e-02f, -9.04097036e-03f, 1.47501573e-01f, 6.49445951e-02f, 2.69305892e-02f, -1.03684470e-01f,
  3.83127034e-02f, 1.13655828e-01f, 1.36663750e-01f, -3.95609178e-02f, -2.05371544e-01f, 1.07098609e-01f, 3.10362652e-02f, -1.15679257e-01f, -1.21286362e-01f, 1.04130208e-01f,
  -1.03508227e-01f, -9.30701941e-02f, 6.57936856e-02f, -3.88804567e-03f, 8.76386017e-02f, 5.43637685e-02f, 4.94492427e-02f, 6.85980767e-02f, -1.68905437e-01f, 3.44917774e-01f,
  -1.68581046e-02f, 9.08970311e-02f, -5.51261678e-02f, 3.71485293e-01f, -1.33157909e-01f, 1.39979854e-01f, -1.00501915e-02f, 1.10222176e-01f, -9.34305191e-02f, 2.81051636e-01f,
  2.76253130e-02f, -5.55108814e-03f, 2.91884094e-01f, -5.43557778e-02f, 6.53753355e-02f, -1.75754284e-03f, 1.10535219e-01f, 6.13369532e-02f, 2.29443729e-01f, 2.25551218e-01f,
  1.06130362e-01f, -1.97136141e-02f, 1.02318928e-01f, -4.19855043e-02f, 1.06735475e-01f, 4.60154377e-02f, 1.03695706e-01f, -5.54120950e-02f, -5.71409129e-02f, -8.43595248e-03f,
  6.77973032e-02f, 6.43599629e-02f, -7.79318810e-02f, -9.99060869e-02f, 4.90716919e-02f, 7.48102292e-02f, 5.04780503e-04f, -4.36177291e-02f, -1.13519914e-01f, 4.49738763e-02f,
  -7.34422281e-02f, -1.09712340e-01f, 9.93698388e-02f, -1.78810619e-02f, 1.52944028e-02f, -6.76296577e-02f, 1.55325029e-02f, 2.50296537e-02f, 3.69370617e-02f, -6.00071400e-02f,
  1.04004983e-02f, 1.11305512e-01f, 8.77829418e-02f, -8.91125649e-02f, 7.36520365e-02f, -2.92654112e-02f, -9.28551704e-02f, -6.11959919e-02f, -5.84641695e-02f, -1.08106971e-01f,
  3.24772834e-03f, 1.28555447e-01f, 1.84894219e-01f, -1.23940654e-01f, -3.03001404e-02f, -7.07933158e-02f, -5.20607345e-02f, -1.61050409e-01f, -1.32766822e-02f, 1.00213639e-01f,
  1.04376644e-01f, -1.14788495e-01f, -4.09859978e-02f, 7.21007362e-02f, 3.23607586e-03f, 2.61563305e-02f, -1.17897131e-01f, 9.16555971e-02f, 6.24032505e-02f, 6.25393987e-02f,
  1.89259020e-03f, -7.68963769e-02f, 6.47661164e-02f, -1.42041638e-01f, -8.11499879e-02f, -2.48820316e-02f, -3.00216824e-02f, 2.96642520e-02f, -6.43138587e-02f, -3.24181914e-02f,
  -3.22044678e-02f, 8.87289122e-02f, -3.69672142e-02f, 1.18364453e-01f, 1.24912977e-01f, 1.64370611e-01f, -1.81649223e-01f, 1.53163359e-01f, -1.74332127e-01f, 1.54055119e-01f,
  1.33579791e-01f, -1.20098956e-01f, 1.84103787e-01f, 1.15066007e-01f, -7.82271996e-02f, 1.16142169e-01f, 9.86665860e-02f, -6.99903667e-02f, -2.64291335e-02f, -1.24819070e-01f,
  -6.71828017e-02f, -9.48719829e-02f, -1.59415260e-01f, 6.74928427e-02f, -1.12482533e-01f, 3.42032546e-03f, -4.28751744e-02f, -2.87582520e-02f, -4.24852371e-02f, -9.69013795e-02f,
  -6.59535602e-02f, -1.59145117e-01f, 1.06026419e-02f, 1.03600502e-01f, -4.96830344e-02f, -3.69810499e-02f, 1.47956461e-01f, 2.28902593e-01f, 4.05633077e-02f, 2.35558134e-02f,
  4.08836082e-03f, 2.99037546e-01f, 1.09981388e-01f, 2.35786468e-01f, 2.66577527e-02f, 1.28533289e-01f, -1.74566627e-01f, -3.94279547e-02f, 1.30746946e-01f, 1.06486939e-01f,
  1.00424901e-01f, -2.27870360e-01f, -9.26770121e-02f, -1.10382311e-01f, 7.45367706e-02f, -1.33902207e-01f, -6.67102560e-02f, 9.31816623e-02f, -1.09315366e-01f, 6.06324710e-03f,
  7.68455565e-02f, -8.70489329e-02f, 6.22794256e-02f, -1.27102032e-01f, -5.57727329e-02f, -7.63788074e-02f, -1.32056102e-01f, -4.06808704e-02f, -4.80271392e-02f, 6.22610450e-02f,
  2.29166914e-02f, 5.62042817e-02f, -1.38131857e-01f, -7.48776272e-02f, -1.46712109e-01f, 1.28388077e-01f, -4.60518152e-02f, 7.01139644e-02f, 1.02397375e-01f, -4.57071923e-02f,
  -5.70210926e-02f, -3.61792222e-02f, 1.16601087e-01f, -2.75207814e-02f, 9.16321129e-02f, 8.52709115e-02f, -9.90730822e-02f, 5.52744344e-02f, -1.07835889e-01f, -4.08996679e-02f,
  -6.32395819e-02f, -8.21933225e-02f, -1.15878507e-01f, -1.12939961e-01f, 1.04047105e-01f, 6.57140315e-02f, -9.23590735e-02f, 1.18087783e-01f, -3.16683985e-02f, -2.24326411e-03f,
  1.00508749e-01f, 9.92057845e-03f, -9.79522318e-02f, 7.80771859e-03f, 1.01036757e-01f, 2.06478685e-02f, 9.87137184e-02f, 7.05903396e-02f, 8.32868814e-02f, 1.20603472e-01f,
  3.67855430e-02f, -3.87072237e-03f, -6.35804310e-02f, 9.16492864e-02f, -6.30136505e-02f, 9.32032987e-02f, -1.25925571e-01f, 5.08399419e-02f, -3.70110236e-02f, 1.00953944e-01f,
  3.57451513e-02f, 5.99953048e-02f, 4.05577570e-02f, -6.25339821e-02f, 1.65398475e-02f, 9.56918299e-02f, 8.76242295e-02f, -3.63414316e-03f, 1.45766756e-03f, 6.63509741e-02f,
  2.15862289e-01f, -1.70300845e-02f, 1.33361056e-01f, 1.47018611e-01f, -7.27718920e-02f, 1.53979361e-01f, 5.89966029e-03f, 8.15263987e-02f, 2.55677193e-01f, -1.32291794e-01f,
  2.88387269e-01f, 7.42363557e-02f, 7.22280368e-02f, 5.53810503e-03f, 5.59306443e-02f, 1.17977634e-01f, -2.55116224e-01f, 3.98366638e-02f, 1.44553231e-02f, -1.17342873e-03f,
  -2.19801500e-01f, -1.72172189e-01f, -1.10691087e-02f, -1.06530733e-01f, 2.98134591e-02f, 1.06540427e-01f, 1.49481013e-01f, 2.06386238e-01f, 9.12993308e-03f, -7.50827342e-02f,
  1.23553559e-01f, -5.97607270e-02f, 1.06335007e-01f, 2.06134021e-02f, -1.57928750e-01f, -1.77722186e-01f, 1.05847090e-01f, -9.20712352e-02f, -8.59758034e-02f, 2.69289911e-01f,
  -6.24984205e-02f, 3.10205191e-01f, 1.05773024e-02f, 1.64278552e-01f, -2.84197628e-02f, -1.51771545e-01f, -7.76588619e-02f, 1.04887679e-01f, 2.29943782e-01f, -6.14820905e-02f,
  -3.49438563e-02f, 1.10464111e-01f, 1.03543289e-01f, -1.99509971e-02f, 5.09847030e-02f, 2.46316999e-01f, -8.07622522e-02f, -3.68570648e-02f, -2.76243929e-02f, -5.15425205e-02f,
  9.70715955e-02f, 1.22149147e-01f, -1.26070296e-02f, -3.07825543e-02f, 1.21225946e-01f, -6.60480112e-02f, 1.61597971e-02f, -5.70741370e-02f, -5.89057151e-03f, 3.76561582e-02f,
  -5.77144288e-02f, -1.63711496e-02f, 2.93746274e-02f, -5.60368262e-02f, 4.25443612e-02f, 4.00885567e-02f, -1.14610195e-01f, 1.61723644e-02f, 8.28146860e-02f, -1.11753613e-01f,
  -5.02616502e-02f, -4.25493009e-02f, -1.03207111e-01f, 2.68284790e-02f, 1.05594985e-01f, -8.48167837e-02f, 1.09747760e-01f, 1.13998473e-01f, 1.17493816e-01f, 1.01469330e-01f,
  -6.33568913e-02f, -1.01186708e-01f, -1.06992543e-01f, -8.34774598e-02f, 5.94037259e-03f, 6.60327971e-02f, -1.53912678e-02f, 1.23842373e-01f, -1.09180547e-01f, -9.27218646e-02f,
  -8.61296058e-02f, 6.37133271e-02f, -7.91802257e-03f, 2.46066060e-02f, 3.30640972e-02f, -9.95075479e-02f, -5.38247973e-02f, -1.03118166e-01f, -3.07234237e-03f, -4.58061174e-02f,
  -1.89480856e-02f, 1.22953862e-01f, 6.72308281e-02f, -9.91001949e-02f, 2.63826572e-03f, -7.61811063e-02f, 1.23376094e-01f, -1.14961922e-01f, 5.14804125e-02f, -5.57031445e-02f,
  7.62569979e-02f, 6.67484552e-02f, 6.05988614e-02f, 8.67705196e-02f, 9.38255116e-02f, 1.00563467e-01f, -1.54459439e-02f, 1.11144237e-01f, 7.69657865e-02f, 6.31129146e-02f,
  1.05841137e-01f, 3.45230885e-02f, 9.75089073e-02f, 1.19409680e-01f, -2.76989192e-02f, 4.28780764e-02f, 9.77850631e-02f, 4.20654379e-02f, 1.23228006e-01f, 1.14988610e-01f,
  -6.29289523e-02f, -7.69918226e-03f, 2.18472295e-02f, -1.76860485e-02f, -3.93152870e-02f, -1.10820107e-01f, 6.57107215e-03f, -1.61406830e-01f, 3.20621990e-02f, -5.75809292e-02f,
  8.42940211e-02f, -3.97169068e-02f, -5.88998795e-02f, 9.60158184e-02f, 2.74350587e-02f, 7.91824758e-02f, 9.65448767e-02f, -1.37673974e-01f, 2.32543256e-02f, -5.93789592e-02f,
  1.40062094e-01f, -1.95309408e-02f, -7.72157609e-02f, -1.19690403e-01f, 6.46281429e-03f, 2.32896060e-02f, -7.15545341e-02f, -5.01240743e-03f, -1.45523593e-01f, 2.27152511e-01f,
  1.15117617e-01f, 2.46375442e-01f, 9.89994779e-02f, -1.24194860e-01f, 3.93404216e-02f, 1.96989805e-01f, 2.48251885e-01f, 5.14179096e-02f, 2.71728542e-02f, 3.22801396e-02f,
  5.46715409e-02f, -1.77083686e-01f, -5.55805564e-02f, 1.69578865e-01f, 2.09883656e-02f, -7.76113989e-03f, -7.64839053e-02f, -6.26871362e-02f, -8.46711919e-02f, -9.64526534e-02f,
  -7.30484575e-02f, -3.04562766e-02f, -4.82656881e-02f, 5.14674559e-02f, -6.12617508e-02f, -1.76767204e-02f, -1.67676006e-02f, 7.92578906e-02f, -8.76936689e-03f, 3.35625536e-03f,
  -2.70223431e-02f, 4.26232070e-02f, -4.49771807e-03f, 6.01059310e-02f, -4.98644337e-02f, -8.12591761e-02f, -4.40397151e-02f, -1.06298119e-01f, -8.83976892e-02f, 3.49173509e-02f,
  -1.04625262e-01f, 6.23678323e-03f, -9.07512084e-02f, 3.33997607e-02f, 1.02100797e-01f, 6.01333864e-02f, -1.18757352e-01f, 3.48269194e-02f, -2.26505138e-02f, -5.78739420e-02f,
  -5.79275191e-02f, -1.20325238e-02f, -1.09788485e-01f, -2.24922094e-02f, -1.28597245e-01f, -5.98313883e-02f, -3.56433466e-02f, 7.89299700e-03f, 1.90886168e-03f, -4.59789187e-02f,
  -9.02366068e-04f, 1.29425889e-02f, 5.49170673e-02f, 9.86420289e-02f, 3.43382009e-04f, -2.09432319e-02f, -1.27385259e-01f, -5.87342400e-03f, 7.43647218e-02f, 1.05286218e-01f,
  1.03175163e-01f, -4.29042839e-02f, 4.40356731e-02f, -4.36468758e-02f, -9.72261187e-03f, 7.31457770e-02f, 9.88273025e-02f, -3.80781144e-02f, 1.12255707e-01f, -4.02448736e-02f,
  2.34563602e-03f, 3.08997054e-02f, -2.57648826e-02f, -8.85981098e-02f, -1.88856944e-02f, -6.14118837e-02f, 8.15325044e-03f, 3.12312506e-02f, 4.72025499e-02f, 9.69935432e-02f,
  -2.28218958e-02f, -1.46615421e-02f, -7.25129098e-02f, -1.20052621e-01f, 6.76998273e-02f, 8.95331129e-02f, 9.34468806e-02f, 2.32679141e-03f, -9.99442264e-02f, 4.63383906e-02f,
  -4.30547930e-02f, 6.97025359e-02f, 1.66443601e-01f, 3.73224691e-02f, -2.64153872e-02f, 1.24195479e-01f, -1.84650794e-02f, -1.44925103e-01f, -6.07510749e-03f, 1.17324591e-01f,
  -9.40863714e-02f, -9.82754529e-02f, -2.32660603e-02f, -4.21190187e-02f, -7.15152621e-02f, -1.20962724e-01f, 8.69722571e-03f, -3.96506973e-02f, 6.26602471e-02f, -5.44162095e-02f,
  -4.70411405e-03f, -1.12516694e-02f, -1.21752158e-01f, 1.21194057e-01f, -1.12096891e-01f, -8.55579451e-02f, 2.92787328e-02f, 6.22114837e-02f, 4.65944177e-03f, 2.82424223e-02f,
  -1.03160374e-01f, 3.30035686e-02f, -1.39440559e-02f, 7.71617610e-03f, 5.74989766e-02f, 1.37062207e-01f, 1.44486740e-01f, 5.41621819e-02f, -3.28771286e-02f, 8.61503184e-02f,
  -1.98357590e-02f, 9.00640115e-02f, -7.35418126e-02f, 1.09067045e-01f, -4.69329059e-02f, -7.54826143e-02f, -3.17770168e-02f, -1.06205031e-01f, -1.11664101e-01f, -4.08481769e-02f,
  -5.54295331e-02f, -6.17374666e-02f, 5.39805228e-03f, -1.01245366e-01f, -3.50555666e-02f, -1.01057373e-01f, -2.07025874e-02f, -9.54757333e-02f, -6.02987595e-02f, -4.90356274e-02f,
  4.74021137e-02f, -8.86351764e-02f, -9.26772207e-02f, -9.76686850e-02f, 3.60745192e-02f, 3.25770378e-02f, 1.28670171e-01f, 4.45895232e-02f, 6.30069971e-02f, -5.29576540e-02f,
  -3.72168096e-03f, 4.79424410e-02f, -3.93485790e-03f, -9.91132185e-02f, -1.15704753e-01f, -7.11090267e-02f, -4.11270969e-02f, 6.00921102e-02f, 6.96469173e-02f, -3.84398513e-02f,
  -2.03950368e-02f, 1.70029849e-02f, 6.48934096e-02f, 1.59970820e-02f, 8.79901052e-02f, 8.47288147e-02f, 7.20233321e-02f, 1.11894682e-02f, -1.00972699e-02f, -2.91603198e-03f,
  -1.88138448e-02f, -4.95679341e-02f, 1.38143282e-02f, 1.01239949e-01f, -6.42715544e-02f, -3.62031348e-03f, 1.32092878e-01f, 9.10221711e-02f, 1.09038047e-01f, 7.54920170e-02f,
  5.52022494e-02f, 1.12294424e-02f, -1.13510758e-01f, -9.10434127e-03f, -2.06434488e-04f, -9.37364250e-02f, -3.14609855e-02f, 3.74939777e-02f, -1.04656434e-02f, 1.39131382e-01f,
  1.24670401e-01f, 1.37005553e-01f, -7.60595277e-02f, 5.66816004e-03f, -3.75630744e-02f, -3.78161818e-02f, 1.47418991e-01f, 6.94854856e-02f, 2.14932468e-02f, 1.13271363e-01f,
  3.99860069e-02f, 1.03261627e-01f, 1.09929577e-01f, 5.80010526e-02f, 2.60329664e-01f, 1.72651380e-01f, 5.14120683e-02f, 5.77525720e-02f, -7.17816800e-02f, 2.51485296e-02f,
  -2.34057873e-01f, 9.38270092e-02f, 2.36915536e-02f, -5.13715623e-03f, -2.62044780e-02f, -8.09194446e-02f, 7.10035563e-02f, -5.26380055e-02f, -8.24585631e-02f, -8.09644833e-02f,
  1.72468990e-01f, 9.25101154e-03f, 1.26317024e-01f, -1.53728604e-01f, 1.03345677e-01f, -8.01203996e-02f, 1.35145232e-01f, 1.22333832e-01f, 8.71996507e-02f, -8.79077092e-02f,
  5.31054176e-02f, 1.10012470e-02f, 6.30500391e-02f, -8.73631053e-03f, -5.09068742e-02f, 2.62841046e-01f, 1.21252485e-01f, 2.67746091e-01f, -1.22419242e-02f, -3.53072099e-02f,
  -5.90410382e-02f, 2.34523654e-01f, 1.83891207e-01f, -5.76524027e-02f, 7.32464669e-03f, -3.68171185e-02f, 1.84900481e-02f, -1.04909360e-01f, -7.97582194e-02f, 3.01545918e-01f,
  1.27002867e-02f, -1.35788262e-01f, 1.90384939e-01f, 4.60223258e-02f, 2.16209352e-01f, 1.77399367e-01f, 1.88127488e-01f, 1.66850045e-01f, -5.92657253e-02f, 4.31671180e-02f,
  6.59970865e-02f, -4.55220230e-02f, 8.11156258e-02f, 6.49488121e-02f, -8.60730037e-02f, -1.22494645e-01f, -1.55425176e-01f, -8.20058137e-02f, 1.97575986e-01f, 1.48338139e-01f,
  1.63364917e-01f, -6.69736862e-02f, 1.68234936e-03f, 2.82545239e-02f, -1.04378730e-01f, -1.02482215e-01f, 1.22567467e-01f, 9.32640210e-02f, 1.66901976e-01f, 3.23973864e-01f,
  -1.21480576e-03f, 7.52616599e-02f, 3.45503479e-01f, 4.65076752e-02f, -1.60082266e-01f, -2.95481961e-02f, -6.90658614e-02f, -3.76211703e-02f, 3.63850929e-02f, -6.31017238e-02f,
  1.25791967e-01f, -8.85873884e-02f, 2.06109717e-01f, 2.52725538e-02f, 1.34662986e-02f, 6.84925690e-02f, -2.56558303e-02f, -6.82887947e-03f, 2.04433858e-01f, 1.33282661e-01f,
  1.04491368e-01f, -5.75417429e-02f, -1.24794636e-02f, -1.89891949e-01f, 7.72180110e-02f, 1.40176117e-01f, -1.71464011e-01f, -1.50294127e-02f, 5.53659499e-02f, 1.05082840e-01f,
  -1.14688903e-01f, 1.24902457e-01f, -1.16113216e-01f, 4.64703925e-02f, 3.92600298e-02f, 1.15657866e-01f, 7.70656615e-02f, 1.63606033e-02f, -6.94546402e-02f, 1.49863794e-01f,
  1.25459090e-01f, -9.38231125e-03f, 1.36492252e-01f, -1.06616365e-02f, 1.06265672e-01f, 1.07497849e-01f, -1.09831735e-01f, 5.78651251e-03f, -8.86712372e-02f, 6.79266006e-02f,
  1.50404453e-01f, -3.16691957e-02f, 6.25556475e-03f, -2.21399730e-03f, 1.40104294e-01f, 1.19725183e-01f, -9.43490192e-02f, 1.86172966e-02f, -1.53455660e-01f, 6.81024268e-02f,
  8.88197869e-02f, 7.35624805e-02f, -1.14995375e-01f, -2.97946222e-02f, 1.19462153e-02f, -1.00397579e-01f, 1.04160585e-01f, 3.73903885e-02f, 4.66903904e-03f, -2.77896263e-02f,
  -1.19456887e-01f, -5.85539639e-02f, -2.62542744e-03f, 1.14115097e-01f, -7.86366388e-02f, 1.18879229e-01f, -4.64038886e-02f, -8.54630321e-02f, -7.23854601e-02f, 6.72257543e-02f,
  -1.09649502e-01f, 4.41992506e-02f, 6.60414323e-02f, 1.82062238e-01f, 1.44548908e-01f, 1.54418156e-01f, -1.24399448e-02f, 1.43997017e-02f, 9.23349634e-02f, -2.28513815e-02f,
  -5.52115552e-02f, 3.36514064e-03f, 1.04011416e-01f, 6.46918491e-02f, 4.61812951e-02f, -3.82281281e-02f, -7.22445846e-02f, 2.01492444e-01f, 2.64445748e-02f, -1.12691648e-01f,
  -7.47914091e-02f, 8.00325945e-02f, -5.12674861e-02f, -6.73910454e-02f, 9.67324749e-02f, 3.31459045e-02f, -1.15495667e-01f, 1.02175787e-01f, 5.78731745e-02f, -2.88241114e-02f,
  -7.43301660e-02f, 8.01709816e-02f, -1.24404222e-01f, 4.24690023e-02f, -1.23034433e-01f, 1.29164867e-02f, 7.15230331e-02f, 4.14692722e-02f, 7.88689181e-02f, 4.88703102e-02f,
  8.09180066e-02f, 9.77173895e-02f, -1.08258717e-01f, 1.07334420e-01f, 1.21430784e-01f, -7.87345320e-02f, 3.26327682e-02f, -4.07900028e-02f, -8.45295936e-02f, 9.69408154e-02f,
  3.23382579e-02f, -9.47456807e-02f, -9.42616835e-02f, -1.98936556e-02f, -4.54289205e-02f, 9.02515650e-03f, -6.79390281e-02f, -1.08314261e-01f, -5.58353700e-02f, 1.20375969e-01f,
  -1.30615178e-02f, -6.18993416e-02f, -8.98068101e-05f, -2.81355679e-02f, 4.46416773e-02f, 1.05436277e-02f, -4.59852740e-02f, -1.05479971e-01f, -5.96098825e-02f, 1.47167696e-02f,
  -8.23708251e-02f, 4.28181374e-03f, 3.94547433e-02f, 1.89793613e-02f, -2.28598751e-02f, -7.81774521e-02f, 3.84314451e-03f, 9.98059064e-02f, 2.17216406e-02f, -6.47238195e-02f,
  5.17163472e-03f, -5.61863855e-02f, 5.01531214e-02f, 1.02656819e-01f, 9.64236259e-02f, 1.09937727e-01f, 8.60628709e-02f, 1.60231590e-02f, 1.04486786e-01f, -1.35809630e-02f,
  -1.63113639e-01f, -1.52881257e-02f, -1.84693057e-02f, -1.81111693e-02f, 4.72457036e-02f, -1.54543426e-02f, 8.96889493e-02f, -6.68131337e-02f, -6.76982396e-04f, 1.07280858e-01f,
  1.26128405e-01f, 1.42715797e-01f, 7.50629157e-02f, -3.07976659e-02f, -1.33134713e-02f, -1.09998703e-01f, 1.73328929e-02f, -1.38384728e-02f, -4.63932613e-03f, -1.30902201e-01f,
  1.83619216e-01f, 1.59574568e-01f, -1.08731147e-02f, -6.40561283e-02f, 1.61014080e-01f, -2.24565435e-02f, 6.67595444e-03f, 1.51444510e-01f, 8.44901726e-02f, -7.78765008e-02f,
  -4.90932167e-02f, 1.09319622e-02f, 1.27632692e-01f, -3.03420704e-02f, 5.55252135e-02f, -1.52953923e-01f, 3.03106438e-02f, -4.73686159e-02f, -1.10959299e-01f, -2.24513054e-01f,
  -2.37198062e-02f, 4.97679301e-02f, 1.48297951e-01f, 1.60296168e-02f, 1.21517450e-01f, -4.97865826e-02f, 2.87481137e-02f, 1.51888967e-01f, -2.10493311e-01f, 1.49762228e-01f,
  1.72769323e-01f, 2.59100646e-01f, 7.54947439e-02f, -5.97695112e-02f, -1.33222103e-01f, -8.31965059e-02f, 1.04222588e-01f, -3.84845063e-02f, -9.16940160e-03f, -1.09942444e-01f,
  1.33217499e-01f, 1.26852006e-01f, -6.26411662e-02f, -6.31129220e-02f, -3.71229686e-02f, 9.55905020e-02f, 3.14707682e-02f, 1.11401826e-01f, 3.06462329e-02f, 1.39802411e-01f,
  -3.57207246e-02f, 1.83602255e-02f, -1.62153002e-02f, -1.08865626e-01f, 3.22757252e-02f, 7.65905306e-02f, -8.43031853e-02f, -5.13658999e-03f, 8.34904388e-02f, -1.09218217e-01f,
  1.13207893e-03f, 9.03136097e-03f, 1.24836467e-01f, -4.89050895e-02f, 6.88640103e-02f, 8.71143267e-02f, -2.72656977e-02f, 9.98577997e-02f, -9.27697960e-03f, -3.32921147e-02f,
  -2.09477562e-02f, -3.71816643e-02f, -9.82472673e-02f, -7.53559470e-02f, -9.03993472e-02f, 1.02824099e-01f, 3.40214074e-02f, 1.09601580e-01f, 1.38319954e-01f, 1.45627037e-01f,
  -1.39490282e-02f, 1.24290325e-02f, -3.37050818e-02f, 1.33841991e-01f, -1.03755951e-01f, -9.20868292e-02f, 9.67677012e-02f, -3.72965559e-02f, -1.10301301e-01f, 1.47485092e-01f,
  -8.55768546e-02f, -5.84253632e-02f, 1.07969074e-02f, -6.72255382e-02f, -8.78707767e-02f, -1.23784564e-01f, -3.95021401e-02f, 8.49479809e-03f, -7.10273683e-02f, -1.05486520e-01f,
  7.81147853e-02f, -6.08649738e-02f, 7.03232959e-02f, -9.63395983e-02f, 3.62160876e-02f, -3.74194756e-02f, -3.60466316e-02f, 8.32585152e-03f, -8.85460600e-02f, -8.24320242e-02f,
  1.04935095e-01f, 8.99032727e-02f, 1.10914655e-01f, -9.60488170e-02f, -1.70174669e-02f, -1.17026672e-01f, -1.86271630e-02f, -8.70672390e-02f, -1.11874916e-01f, -1.76402163e-02f,
  9.32130516e-02f, 2.11477815e-03f, 8.14755113e-05f, 2.56157890e-02f, 1.26655586e-02f, 2.56788060e-02f, -1.14153676e-01f, -8.46603885e-02f, -9.92373191e-03f, 5.52703999e-02f,
  1.10061027e-01f, 1.00930169e-01f, -9.55941677e-02f, 9.14300978e-02f, 4.65536565e-02f, -1.20822586e-01f, -3.71753946e-02f, -6.09353855e-02f, 1.20180026e-01f, -1.28488876e-02f,
  1.18774764e-01f, -3.25955600e-02f, -7.27258325e-02f, -2.04168796e-03f, 7.10777268e-02f, -1.04241252e-01f, 8.78337249e-02f, -8.09338614e-02f, -1.11686669e-01f, 2.37278566e-02f,
  -3.00369188e-02f, -1.22423977e-01f, 8.34409967e-02f, 5.95126934e-02f, 4.62637246e-02f, -1.13808379e-01f, 2.10654233e-02f, -2.91902572e-02f, 2.11601947e-02f, -6.57318458e-02f,
  3.47458683e-02f, 3.11286151e-02f, 4.12093736e-02f, -2.74341311e-02f, -2.92721242e-02f, 3.41377817e-02f, -1.52345989e-02f, -7.98309073e-02f, 9.33827236e-02f, -3.21993185e-03f,
  -4.15025763e-02f, -8.57039392e-02f, -7.15874210e-02f, 9.01731849e-03f, -9.34497565e-02f, 4.69276905e-02f, -8.24562684e-02f, 9.59370136e-02f, 1.08813584e-01f, 7.20228404e-02f,
  8.14229250e-02f, -4.41848002e-02f, -4.06287499e-02f, -6.08740002e-02f, -7.65336901e-02f, -2.32221112e-02f, -4.71408889e-02f, -9.34482180e-03f, -2.85512917e-02f, 5.29010296e-02f,
  -1.06895640e-01f, 1.56086870e-02f, 2.39879135e-02f, 1.60646103e-02f, -6.28857166e-02f, 4.34727110e-02f, -2.32145796e-03f, 7.80585259e-02f, -1.29619017e-01f, 2.39569414e-02f,
  1.07157566e-01f, 3.30010951e-02f, 9.47065428e-02f, 1.24453127e-01f, -7.72801638e-02f, -1.03283741e-01f, -1.89870567e-04f, -3.68874185e-02f, 7.57928714e-02f, -1.24629915e-01f,
  7.03270808e-02f, -3.15850647e-03f, -9.45450440e-02f, -9.20919925e-02f, -7.81900659e-02f, -7.13572055e-02f, -1.14843920e-01f, 1.42669128e-02f, -6.99828863e-02f, 1.11211479e-01f,
  5.70127799e-04f, 1.06703818e-01f, -1.23483948e-01f, 6.62855357e-02f, 9.89108346e-03f, -9.71683860e-02f, -8.10610652e-02f, -4.13118005e-02f, 7.05927014e-02f, -3.62964533e-02f,
  -6.49601445e-02f, 3.08674644e-03f, -7.11656064e-02f, -8.59673172e-02f, 3.65018472e-02f, 1.08390562e-01f, -7.87477940e-04f, -2.46844050e-02f, 5.17033041e-02f, 1.02362940e-02f,
  7.59506896e-02f, 2.74030864e-02f, -1.09252639e-01f, -1.93399861e-02f, -6.14682697e-02f, -5.15621863e-02f, 1.14097707e-01f, -4.23646681e-02f, -8.38014036e-02f, 6.05023615e-02f,
  -5.10976315e-02f, -5.23107946e-02f, -5.98778129e-02f, 1.14222653e-02f, -1.98034197e-02f, 7.97387492e-03f, -9.17951241e-02f, 2.55474392e-02f, 8.95467699e-02f, -6.61469204e-03f,
  3.89873870e-02f, 9.17815194e-02f, -8.26149285e-02f, -1.08688265e-01f, -1.04675040e-01f, 8.84846598e-02f, 4.65038829e-02f, 7.73102045e-02f, -4.69585583e-02f, -4.50167656e-02f,
  -1.02388635e-01f, 4.61791307e-02f, -6.50482699e-02f, 8.03152099e-02f, -1.84959136e-02f, -5.65824881e-02f, -6.31771758e-02f, -2.14586724e-02f, 8.69035795e-02f, 1.06077470e-01f,
  -4.55973856e-02f, 1.02602057e-01f, -6.58370405e-02f, 4.91142226e-03f, 1.05403744e-01f, 2.38484722e-02f, -1.19443364e-01f, 1.17389530e-01f, 3.20082940e-02f, -1.39606465e-03f,
  -1.13577917e-01f, -6.70407861e-02f, 2.16604341e-02f, 1.02595866e-01f, 4.39057276e-02f, 1.00584269e-01f, 9.35825109e-02f, 1.50626123e-01f, 1.70124657e-02f, 1.49989098e-01f,
  3.63598242e-02f, -1.27004653e-01f, -2.49449518e-02f, 1.69696901e-02f, -5.58048487e-02f, -7.98770264e-02f, 2.77823955e-03f, 1.52624458e-01f, 3.51259597e-02f, -4.11125571e-02f,
  1.50533363e-01f, 6.09340072e-02f, 4.14306335e-02f, -1.47550061e-01f, -1.15737930e-01f, 1.06131285e-01f, -6.87610060e-02f, 9.89966244e-02f, 1.34448102e-02f, -6.82431310e-02f,
  3.20748729e-03f, -1.06969245e-01f, 9.61576328e-02f, 8.02315306e-03f, -7.26353526e-02f, -7.50679448e-02f, 1.29658297e-01f, 3.06059748e-01f, 7.01770112e-02f, 1.47168368e-01f,
  3.87787223e-02f, -8.86764154e-02f, -1.94215346e-02f, -3.48005593e-02f, -6.03319257e-02f, -5.77816293e-02f, -1.29720375e-01f, 3.71466726e-02f, 9.14215744e-02f, -1.05209969e-01f,
  7.89596438e-02f, -5.44858910e-02f, 1.28942151e-02f, 1.22412220e-01f, 1.95857614e-01f, -8.90798867e-02f, -5.28009534e-02f, -1.94798466e-02f, -8.56450498e-02f, 1.74485117e-01f,
  2.12400168e-01f, 8.20818767e-02f, -1.05844647e-01f, 1.13575207e-02f, 2.66248919e-02f, 1.52708128e-01f, 7.20397606e-02f, -2.20438302e-03f, 1.31434247e-01f, 8.02685693e-02f,
  1.73322067e-01f, 6.59849867e-02f, 9.99310538e-02f, 2.65371740e-01f, 1.26529768e-01f, 9.66877118e-03f, -9.69055444e-02f, 1.20177291e-01f, 2.73009334e-02f, -4.99172695e-02f,
  1.01321109e-01f, -6.28481060e-02f, -2.77568493e-02f, 3.48937847e-02f, 2.39678279e-01f, 1.41118020e-01f, 1.52033076e-01f, -3.50101851e-02f, 3.51078585e-02f, 7.13404268e-02f,
  -2.76513636e-01f, 1.15792841e-01f, 1.33651093e-01f, -1.69595227e-01f, 2.52680779e-01f, 3.59208435e-01f, -8.15942585e-02f, -7.13538080e-02f, 3.07349116e-01f, -8.21130797e-02f,
  -6.82733282e-02f, 6.66093454e-02f, -4.40691039e-02f, 1.77887604e-01f, 5.58325835e-02f, -1.01550169e-01f, -3.82743366e-02f, 7.18547851e-02f, 3.64851266e-01f, -2.01669127e-01f,
  2.23994672e-01f, 7.03164637e-02f, -1.97614226e-02f, -2.78203219e-01f, 1.62953988e-01f, 1.60313755e-01f, 2.03695357e-01f, 1.41630232e-01f, 2.00115174e-01f, -1.63521618e-01f,
  5.42206876e-02f, 4.32969406e-02f, -1.75664470e-01f, 2.89353170e-02f, -1.02006920e-01f, 2.19239220e-01f, 7.01769739e-02f, 2.42582578e-02f, -1.86761320e-01f, -3.75034735e-02f,
  8.83068740e-02f, 2.61468977e-01f, 1.66705668e-01f, 1.47439465e-01f, -4.78361174e-02f, 9.97540876e-02f, 1.62758723e-01f, 1.29510835e-01f, -2.29713246e-01f, -3.91550250e-02f,
  1.31780073e-01f, -2.87914537e-02f, -1.38692200e-01f, 1.87957570e-01f, 2.86632795e-02f, -2.07339332e-01f, -1.01889469e-01f, 1.73876192e-02f, 1.59474520e-03f, 2.65159339e-01f,
  -5.94357960e-02f, -8.02669004e-02f, 9.11958665e-02f, 7.42079169e-02f, 1.02766655e-01f, -1.01716863e-02f, -2.09312186e-01f, 1.41839921e-01f, 6.61170632e-02f, -6.17140420e-02f,
  -1.19675972e-01f, -1.21346153e-01f, 4.33935830e-03f, -2.60780230e-02f, 5.33236675e-02f, -2.38857716e-01f, 7.95727074e-02f, 1.49196368e-02f, -4.76039760e-02f, 1.20353043e-01f,
  -7.99859017e-02f, 1.12859704e-01f, 3.25216502e-01f, 1.57231957e-01f, 1.43020973e-01f, -1.00248843e-01f, -9.04486477e-02f, -7.96047524e-02f, -1.27943829e-01f, 1.13373607e-01f,
  9.40440372e-02f, 5.94359748e-02f, -3.42752561e-02f, 1.76923182e-02f, 3.27995449e-01f, 8.26718286e-02f, 1.15351737e-01f, 5.80397323e-02f, 7.29519799e-02f, 1.79627631e-02f,
  5.74494191e-02f, -1.24529570e-01f, 1.83964357e-01f, -1.73129030e-02f, -1.15822837e-01f, 1.71448171e-01f, 3.47196162e-02f, 6.11602142e-02f, -7.55841210e-02f, 3.11864465e-02f,
  8.61182287e-02f, 7.65005723e-02f, 2.51779296e-02f, 7.44112767e-03f, 1.21860512e-01f, 2.93194298e-02f, 6.97788224e-02f, 2.98957787e-02f, 6.74920082e-02f, 9.46757197e-02f,
  8.22084099e-02f, 8.72498825e-02f, -4.12913226e-02f, 9.02902782e-02f, -9.28891301e-02f, 5.47574162e-02f, -9.64471251e-02f, 9.83177423e-02f, -1.24609016e-01f, -4.50266786e-02f,
  -1.31748080e-01f, 4.74200696e-02f, -2.28478052e-02f, 1.47165820e-01f, -2.35943571e-02f, 6.92356005e-02f, 7.49186948e-02f, 4.61861081e-02f, -1.31984994e-01f, -1.11070186e-01f,
  4.89724055e-02f, 9.76795480e-02f, -9.23230648e-02f, -2.05141529e-02f, -4.12665866e-02f, 1.66727211e-02f, 1.74627751e-01f, 1.44893095e-01f, 1.71325743e-01f, 1.17763236e-01f,
  -1.23982996e-01f, 1.22582540e-02f, 1.35994464e-01f, -6.33177310e-02f, 1.68286905e-01f, -2.24420708e-02f, -1.01793364e-01f, -9.13100690e-03f, 7.23472908e-02f, -4.92730327e-02f,
  2.37208195e-02f, -1.25883847e-01f, 2.43350118e-02f, 8.40373784e-02f, 2.67367028e-02f, -3.85386720e-02f, -1.05169423e-01f, -7.40660401e-03f, 5.75415455e-02f, 6.37998879e-02f,
  3.05653531e-02f, 1.99512780e-01f, 1.85950607e-01f, 8.10280666e-02f, 1.09114140e-01f, 6.30702153e-02f, 1.89881831e-01f, 1.12465009e-01f, -3.86055820e-02f, -4.52541821e-02f,
  -1.04888707e-01f, 2.73365229e-01f, -1.62342429e-01f, -1.29993232e-02f, 6.91139547e-04f, 2.10887194e-02f, -1.69485673e-01f, -1.28388435e-01f, 7.59782121e-02f, 5.15018925e-02f,
  6.25618026e-02f, 1.24326490e-01f, 1.85189873e-01f, 7.55079240e-02f, 1.47721201e-01f, 3.15449126e-02f, -1.83463305e-01f, 1.34084493e-01f, -1.22357503e-01f, 2.32903585e-02f,
  -1.98740829e-02f, 8.24002028e-02f, -1.86086610e-01f, 6.13303557e-02f, 7.35940859e-02f, 6.05543181e-02f, -1.10745460e-01f, -4.31907177e-02f, -7.39573613e-02f, 6.66247085e-02f,
  -6.11076318e-02f, 3.82552177e-01f, -1.00389041e-01f, 1.10436767e-01f, -7.65843838e-02f, 4.55142409e-01f, 1.16564348e-01f, 3.09439749e-01f, 1.77030370e-01f, 1.87709779e-01f,
  6.37086050e-04f, 2.64819831e-01f, -1.07597865e-01f, 6.19798247e-03f, 3.32025766e-01f, -2.48155743e-01f, -3.59201655e-02f, -1.12543002e-01f, -8.48631337e-02f, 4.26359586e-02f,
  3.24402064e-01f, 2.71307081e-01f, 1.35397017e-01f, 6.59485981e-02f, -1.92121744e-01f, 8.39468613e-02f, 5.51105477e-02f, 1.09584540e-01f, 1.11671183e-02f, 9.12315771e-02f,
  2.58784652e-01f, 1.03160977e-01f, 3.87407504e-02f, 1.36819743e-02f, -1.48408666e-01f, 6.87956288e-02f, 1.20919190e-01f, 2.69283533e-01f, 2.61276901e-01f, 7.06669241e-02f,
  2.06834957e-01f, -1.76834419e-01f, 7.22844675e-02f, 4.24510188e-04f, -4.88776416e-02f, 4.13877144e-02f, -2.92843670e-01f, -4.54461109e-03f, 6.36396930e-02f, -1.08564898e-01f,
  1.90254464e-03f, 6.62619760e-03f, 1.04320437e-01f, -2.49058176e-02f, -9.92093086e-02f, -4.88731836e-04f, 2.33269855e-01f, 3.39600414e-01f, 2.58488767e-02f, 5.03402464e-02f,
  5.12873605e-02f, -8.33289623e-02f, 2.02585593e-01f, -9.21234637e-02f, -1.49917141e-01f, -1.72479570e-01f, 1.03885092e-01f, -1.16836898e-01f, -7.41959289e-02f, 8.57091025e-02f,
  1.81552768e-01f, 1.82543159e-01f, 4.16253023e-02f, 1.45052463e-01f, 1.57767609e-01f, -3.18939760e-02f, -2.07458034e-01f, 2.26981699e-01f, -6.78126067e-02f, 9.77305099e-02f,
  1.04363501e-01f, 2.04884097e-01f, 9.02347565e-02f, 1.08234376e-01f, -4.21466716e-02f, 1.89349443e-01f, -5.11922464e-02f, -1.08097538e-01f, -9.75778699e-02f, -1.25162184e-01f,
  -8.62073451e-02f, -1.84723902e-02f, -1.60655919e-02f, 2.30158083e-02f, 3.16199213e-02f, 9.54224989e-02f, 2.02491470e-02f, -7.78294206e-02f, 2.12273188e-02f, 3.91194150e-02f,
  1.24233723e-01f, -9.44136679e-02f, -1.92202255e-02f, 5.77569753e-02f, -1.17226943e-01f, -8.61262158e-02f, -4.66581434e-02f, -1.60616133e-02f, -1.02353469e-01f, 1.15817636e-01f,
  1.35570958e-01f, -4.64539081e-02f, 2.15637404e-02f, 1.35780200e-01f, -6.16770573e-02f, -1.20194457e-01f, -5.44117540e-02f, 5.61436312e-03f, -3.13504525e-02f, 8.22186247e-02f,
  -1.18690608e-02f, 1.36009067e-01f, 8.72732922e-02f, -2.71431394e-02f, -1.09931670e-01f, -8.28536749e-02f, 5.85361291e-03f, -4.08072807e-02f, 1.47950146e-02f, 4.26842384e-02f,
  -9.93012041e-02f, 9.35560241e-02f, 4.17807773e-02f, -7.54687935e-02f, 1.22243538e-01f, -9.88523141e-02f, -1.34562567e-01f, -8.91949907e-02f, -1.58374589e-02f, -6.06151298e-02f,
  3.57222520e-02f, -1.35004878e-01f, -1.11442462e-01f, 9.69494805e-02f, 1.25266537e-01f, 3.22454907e-02f, -5.84347397e-02f, 1.29943997e-01f, 5.53557426e-02f, -1.66433472e-02f,
  4.55468381e-03f, 6.68106601e-02f, 1.50019834e-02f, -9.90551710e-02f, -5.24226129e-02f, 1.15225144e-01f, -3.97322103e-02f, -4.95167151e-02f, -1.77403651e-02f, -2.08026972e-02f,
  2.05744542e-02f, 4.45312150e-02f, -8.30809772e-02f, -1.13435142e-01f, 1.11401170e-01f, -8.18052329e-03f, -6.31872863e-02f, -6.25630375e-03f, -3.52577344e-02f, 7.12876022e-02f,
  -4.42783795e-02f, -6.33519590e-02f, -9.20706689e-02f, 6.93421438e-02f, -1.24270014e-01f, 8.81782547e-02f, -1.23741329e-02f, -1.56165790e-02f, -2.33367644e-03f, -6.25961795e-02f,
  9.24051031e-02f, 6.66740313e-02f, -7.05067664e-02f, -7.13831633e-02f, -1.00885697e-01f, -1.05399959e-01f, -4.42450978e-02f, -4.27477583e-02f, 2.60219034e-02f, 1.09477974e-01f,
  4.02894616e-03f, -1.04393609e-01f, -5.77281192e-02f, -1.61655508e-02f, 8.12704861e-02f, 8.78208652e-02f, -8.25639721e-03f, -3.05125788e-02f, 9.04445499e-02f, 4.95525897e-02f,
  -6.65871054e-03f, -6.98703080e-02f, -1.05882160e-01f, 1.22748956e-01f, -1.01810731e-01f, -1.14616692e-01f, 9.15747955e-02f, -1.50762731e-02f, 6.31752387e-02f, 1.63509548e-02f,
  -9.07176957e-02f, -6.85690045e-02f, -2.62757372e-02f, 1.16877131e-01f, -1.21999288e-03f, 6.31598979e-02f, 1.14819162e-01f, 4.66537140e-02f, 1.43904284e-01f, 1.30680567e-02f,
  1.03547432e-01f, 8.48703645e-03f, -1.45222363e-03f, -7.80968368e-02f, -2.17034817e-01f, -2.80948937e-01f, 8.85898396e-02f, -9.14538875e-02f, 3.81145537e-01f, 1.09506033e-01f,
  4.16959196e-01f, 1.04028866e-01f, -2.00942799e-01f, -4.63251397e-02f, -1.19284414e-01f, -4.55450937e-02f, 9.63820294e-02f, 9.54495557e-03f, 1.83526933e-01f, -1.09761260e-01f,
  3.39960307e-01f, 2.99064159e-01f, -8.88619646e-02f, 6.20869175e-02f, 4.93134484e-02f, 8.09210762e-02f, 5.91680482e-02f, 7.19004273e-02f, 2.57775933e-01f, 6.05741978e-01f,
  -2.62347832e-02f, 1.79952279e-01f, -2.69876700e-02f, -7.11104870e-02f, 1.61018938e-01f, 5.24290167e-02f, -2.44087920e-01f, 1.37005061e-01f, -7.78480694e-02f, -1.16598181e-01f,
  6.11967444e-02f, -2.02279463e-02f, -2.59650815e-02f, -2.48468325e-01f, -4.36539128e-02f, -1.86685741e-01f, 3.18217486e-01f, 4.43157077e-01f, -1.79210678e-01f, -1.71145335e-01f,
  6.84931353e-02f, 5.64901531e-01f, 4.86427903e-01f, 1.98766783e-01f, -5.09782024e-02f, 2.71779388e-01f, -8.63597263e-03f, -1.20388366e-01f, 2.62043010e-02f, 4.43625487e-02f,
  1.87718257e-01f, 1.70926005e-01f, 8.37327242e-02f, -7.08372369e-02f, 2.12293684e-01f, 6.42433539e-02f, -1.75017994e-02f, -4.06658500e-02f, -1.09087657e-02f, -1.60508901e-01f,
  1.19022332e-01f, -1.23066053e-01f, 3.30515243e-02f, 3.73376384e-02f, 3.01519036e-02f, 6.15190640e-02f, -2.62416065e-01f, 2.84491386e-02f, -8.16444531e-02f, -1.18480157e-02f,
  -6.02901690e-02f, -3.27763334e-02f, 1.89109817e-01f, -5.89236841e-02f, 2.08470628e-01f, 1.15620501e-01f, 2.76586860e-01f, 2.34023184e-01f, -6.68130964e-02f, -2.36359760e-02f,
  4.76809517e-02f, 1.22541286e-01f, -2.20096096e-01f, 1.46318367e-02f, 1.09885603e-01f, 9.28665698e-02f, -1.10596418e-01f, -5.03712296e-02f, 4.91095297e-02f, -5.81265762e-02f,
  4.37099859e-02f, 3.53190005e-01f, 7.13382065e-02f, 1.23283025e-02f, 1.00058652e-01f, 4.41085659e-02f, 6.05541356e-02f, -2.83267200e-02f, -7.97894746e-02f, 1.17829135e-02f,
  -4.62158620e-02f, 1.93741724e-01f, 6.14903308e-02f, -5.04261330e-02f, 4.32645306e-02f, 2.47389469e-02f, 1.76704731e-02f, -1.56825423e-01f, 3.45011428e-02f, -2.06072279e-03f,
  5.37802316e-02f, -1.75901800e-01f, -1.47736100e-02f, 2.53521442e-01f, -9.19389874e-02f, -6.64255396e-02f, -1.17202260e-01f, -2.04579835e-03f, 7.77459145e-02f, 4.47852612e-02f,
  -1.32137075e-01f, -2.55560260e-02f, 4.27686647e-02f, 1.45619079e-01f, 5.43135703e-02f, 1.34124279e-01f, 8.92724767e-02f, 5.88348135e-02f, 4.42559794e-02f, 4.90223169e-02f,
  -5.14389388e-02f, 1.11816227e-01f, -9.45674777e-02f, 3.81434932e-02f, 1.19399808e-01f, 1.54945487e-03f, -3.60366665e-02f, -4.37244810e-02f, 4.62854356e-02f, -7.02958032e-02f,
  -1.27998337e-01f, -8.97438079e-02f, 1.17199406e-01f, 9.30201858e-02f, 4.84363399e-02f, 5.73591925e-02f, 3.39233200e-03f, -1.05810925e-01f, -5.16035035e-02f, -2.56318524e-02f,
  9.76349786e-03f, 1.00074492e-01f, -5.38699515e-02f, 3.32473591e-02f, 7.95013979e-02f, -2.46611275e-02f, -7.90631175e-02f, -7.33063892e-02f, -9.93182287e-02f, 1.24039747e-01f,
  -1.14804909e-01f, 1.58365771e-01f, 1.15370132e-01f, -3.71625051e-02f, -2.45121997e-02f, 8.36331546e-02f, 8.87894258e-02f, 7.29155913e-02f, 1.24721900e-01f, 6.09524213e-02f,
  -7.69260526e-02f, 5.87910265e-02f, 4.01910432e-02f, -1.62431374e-01f, 4.58624139e-02f, 1.36865750e-01f, -1.21376105e-01f, -9.33955088e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  -5.64000234e-02f, -1.64721143e-02f, -9.29198936e-02f, 1.81121677e-01f, 1.11823820e-01f, -8.19942951e-02f, 4.42454964e-02f, -1.61549877e-02f, 1.16629191e-01f, -4.77392375e-02f,
  -5.75732999e-02f, 7.54468292e-02f, 2.74553865e-01f, -8.84025469e-02f, -9.25948173e-02f, -7.63026327e-02f, -8.11981186e-02f, -1.21718064e-01f, -1.30479693e-01f, 8.41883942e-02f,
  3.76356207e-03f, 2.48960759e-02f, -7.86904544e-02f, -7.73682743e-02f, 1.40175238e-01f, -1.69709977e-02f, 3.50525379e-02f, -6.06492870e-02f, -1.99884865e-02f, -9.76070166e-02f,
  -7.84515962e-02f, 6.26740456e-02f, -7.49392435e-02f, 2.21203938e-01f, 8.62311646e-02f, -1.12131484e-01f, 1.42008036e-01f, 9.67082847e-03f, 7.18234479e-02f, -1.09984063e-01f,
  -1.06559150e-01f, -8.76138136e-02f, 3.65233496e-02f, 8.86876583e-02f, -1.01574222e-02f, 4.53527234e-02f, -1.15632281e-01f, 6.70969337e-02f, 8.11660197e-03f, 1.22027203e-01f,
  1.58155024e-01f, 8.63225311e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -4.40417901e-02f, 4.33997065e-03f, 1.80096820e-01f, 9.51794311e-02f, 5.37965000e-02f, 2.71308124e-01f, -2.12200493e-01f, -2.90053397e-01f, -2.20330015e-01f, -1.12616435e-01f,
  2.90808044e-02f, -2.83657722e-02f, 2.52358109e-01f, -1.34227127e-01f, 2.94477008e-02f, 2.05255941e-01f, 3.26008856e-01f, 1.84240863e-02f, -3.42041552e-02f, 3.05188242e-02f,
  -4.42290246e-01f, -1.15415275e-01f, 1.25535373e-02f, 2.28487357e-01f, -3.53933841e-01f, 7.75187165e-02f, -2.00605933e-02f, 5.54958871e-03f, 1.06018029e-01f, -2.34251246e-02f,
  4.37667705e-02f, -8.57671276e-02f, -2.72341222e-01f, -1.00784481e-01f, -4.23946828e-01f, -5.15257604e-02f, -3.34746510e-01f, 2.15336476e-02f, 7.84679875e-02f, 1.23169407e-01f,
  1.70734912e-01f, -1.24277338e-01f, 6.61971048e-02f, -6.83921203e-02f, 1.17023297e-01f, 1.80567697e-01f, 3.26683425e-04f, 6.22071028e-02f, 2.73905814e-01f, -6.59018159e-02f,
  -1.04344308e-01f, 7.56862238e-02f, -1.19814381e-01f, 2.59522736e-01f, 4.46489006e-01f, -2.68932462e-01f, -1.11410193e-01f, -4.62550253e-01f, 2.52647847e-01f, -5.54215945e-02f,
  7.66519383e-02f, 8.02257657e-02f, -2.15495303e-01f, -2.48007309e-02f, 8.80374685e-02f, 2.72781163e-01f, 4.20873612e-02f, 1.20392151e-01f, 4.71452437e-02f, 2.03177966e-02f,
  -3.05777881e-02f, 1.33303165e-01f, 2.45184571e-01f, -1.22454070e-01f, -3.30609441e-01f, -2.26872757e-01f, -1.35816142e-01f, -9.19573084e-02f, 7.74678290e-02f, 2.27562100e-01f,
  2.90162444e-01f, 1.13347873e-01f, -2.71719545e-01f, -8.36924985e-02f, -2.76769064e-02f, 4.79087494e-02f, -7.85603374e-02f, -7.79969012e-03f, 3.48961413e-01f, -1.16190009e-01f,
  -5.65478802e-02f, -7.33325481e-02f, -4.80247363e-02f, 5.03353626e-02f, -1.37276173e-01f, 1.18414074e-01f, 7.54914433e-02f, -1.54125184e-01f, -2.30167806e-01f, 1.01808436e-01f,
  6.43720999e-02f, -7.34347627e-02f, 3.49521451e-02f, 4.71946336e-02f, 1.88212842e-01f, 3.57229114e-02f, -8.49358663e-02f, 5.81876077e-02f, 3.28852803e-01f, 2.80096889e-01f,
  1.63255513e-01f, 2.77830735e-02f, 2.49070853e-01f, -1.00065060e-01f, 3.23717445e-02f, 7.22018406e-02f, -5.24129421e-02f, 3.62227708e-02f, 4.11022663e-01f, 3.74429762e-01f,
  1.23363644e-01f, -1.63807660e-01f, -2.34323069e-01f, 9.42374691e-02f, -3.93388234e-02f, -4.30061221e-01f, -1.73750311e-01f, 8.78404006e-02f, 5.03953770e-02f, 1.51562477e-02f,
  1.18800938e-01f, 1.95634693e-01f, -2.20202401e-01f, 8.08261782e-02f, 2.03644872e-01f, 4.26921159e-01f, 2.70054162e-01f, 1.12143792e-02f, -7.41129518e-02f, -2.22433180e-01f,
  -6.18338436e-02f, 1.05794370e-01f, 6.53586984e-02f, -4.27226663e-01f, -8.62233788e-02f, 1.22806236e-01f, -2.21874446e-01f, -1.18754255e-02f, 9.80429947e-02f, -7.35998303e-02f,
  5.02344221e-02f, -1.72097996e-01f, 8.13712895e-01f, -1.55847743e-02f, 1.22351974e-01f, 7.10736448e-03f, 1.22031093e-01f, 3.61291543e-02f, -1.17420830e-01f, -2.60024262e-03f,
  1.00113966e-01f, 7.34093832e-03f, -1.02478510e-03f, -1.14284962e-01f, 2.42812634e-01f, 1.44432783e-01f, -2.00727731e-01f, -5.91614880e-02f, 7.13857487e-02f, -1.16368733e-01f,
  -3.88117991e-02f, 9.72131565e-02f, 6.36062026e-02f, 1.55907750e-01f, 2.42683608e-02f, -1.19433150e-01f, -1.76005855e-01f, 1.36055380e-01f, 8.56818184e-02f, -6.91468194e-02f,
  -8.65961462e-02f, -1.29682243e-01f, -7.01121241e-02f, 4.78689909e-01f, 1.04636453e-01f, 2.34595746e-01f, -3.91381830e-01f, -1.18044689e-01f, -3.16116251e-02f, -6.40861392e-01f,
  1.51028931e-01f, 7.84218982e-02f, -1.38117280e-02f, -3.87491882e-01f, -2.18835343e-02f, -2.77884185e-01f, 1.22030951e-01f, -1.83941480e-02f, 2.16093108e-01f, -1.67480558e-01f,
  4.02427912e-02f, 1.82865672e-02f, 2.62262583e-01f, 4.16093141e-01f, 1.83570534e-01f, 2.15907022e-01f, 1.45566827e-02f, 3.14087979e-02f, -3.05748731e-01f, 5.49718700e-02f,
  -1.19699225e-01f, 1.72550802e-03f, -2.94512689e-01f, -8.00816938e-02f, -1.30255744e-01f, 1.03547923e-01f, -3.32045972e-01f, -3.43810134e-02f, -1.23172171e-01f, 2.25059111e-02f,
  -6.03531003e-02f, 7.92347938e-02f, -8.00511762e-02f, 7.35864192e-02f, 5.94146363e-02f, 3.35485697e-01f, 1.23978212e-01f, -1.25061616e-01f, -1.89022943e-01f, -5.03739491e-02f,
  -2.78001696e-01f, 1.73815079e-02f, -3.33170235e-01f, 1.55892894e-02f, 8.75791386e-02f, 4.19549495e-02f, -1.85113043e-01f, -3.27928543e-01f, -4.49522771e-02f, -6.37398884e-02f,
  -1.25418529e-01f, -8.24583545e-02f, 1.85786746e-02f, 4.62227762e-02f, -4.39673997e-02f, 5.03815673e-02f, -2.46893197e-01f, -2.59121269e-01f, -1.70759242e-02f, -1.99562252e-01f,
  -1.71394825e-01f, 1.77808702e-01f, -9.60918143e-02f, 7.65789926e-01f, 2.14618236e-01f, -1.32299513e-01f, 3.37712839e-02f, -3.03234935e-01f, -1.70329511e-01f, 1.02598615e-01f,
  1.52459871e-02f, 2.47014716e-01f, 1.40924171e-01f, -1.24997728e-01f, -4.77203205e-02f, 1.99399248e-01f, 6.87970147e-02f, 1.66187525e-01f, 1.66255645e-02f, 8.60772282e-03f,
  -3.18258181e-02f, 1.65518641e-01f, 6.31952733e-02f, -2.00963132e-02f, -8.80991444e-02f, 2.84350365e-02f, -9.60398689e-02f, 4.22296636e-02f, -4.84507009e-02f, 1.27120793e-01f,
  -1.72169507e-01f, -3.23249102e-02f, 1.03451177e-01f, 3.68332937e-02f, 3.88992876e-02f, 8.55609402e-02f, 2.44281918e-01f, -1.36468140e-02f, 2.71721900e-01f, -5.12551218e-02f,
  -1.93604957e-02f, 3.84189561e-02f, -3.13273460e-01f, 5.04584350e-02f, 1.70988426e-01f, 5.52146547e-02f, 1.53818905e-01f, -5.19899875e-02f, -2.97861826e-02f, 1.24064051e-01f,
  2.24330947e-01f, -2.77786225e-01f, 7.00237378e-02f, 4.30300012e-02f, 1.24647969e-03f, 5.00684232e-02f, 7.21724331e-02f, -6.83746561e-02f, 6.54505491e-02f, 1.08260207e-01f,
  -3.08492959e-01f, 1.70260649e-02f, -1.17964391e-02f, -1.49869636e-01f, 1.69657245e-01f, -2.04166114e-01f, 1.05563842e-01f, 4.27860558e-01f, -1.01437889e-01f, 1.43111601e-01f,
  -1.52243987e-01f, -8.80285278e-02f, -5.49183562e-02f, 6.67345598e-02f, -6.69163689e-02f, -2.32297346e-01f, -3.04366916e-01f, -2.49685124e-01f, -2.64132321e-01f, -2.42073804e-01f,
  8.90769362e-02f, 2.20270064e-02f, -1.92074850e-01f, -2.41984949e-01f, -5.26442789e-02f, -4.43852926e-03f, 3.15672696e-01f, -5.64454198e-02f, 1.31853849e-01f, -7.97281116e-02f,
  1.46554157e-01f, -2.17054877e-02f, -1.15232300e-02f, -1.56019926e-01f, -2.82975912e-01f, 2.35663131e-02f, -7.71289738e-03f, -9.92281288e-02f, -1.25330582e-01f, 5.99039495e-02f,
  1.79920599e-01f, -4.80782837e-02f, 9.20840725e-02f, 2.94372849e-02f, 2.63799336e-02f, -2.00060140e-02f, 1.42465532e-01f, 4.46461849e-02f, 2.49954358e-01f, 4.99961674e-02f,
  1.03945091e-01f, 1.47451228e-02f, -9.38895345e-02f, 2.47073490e-02f, 3.06999147e-01f, 1.64152384e-01f, 2.46828496e-01f, -1.20577954e-01f, -2.54130177e-03f, 3.66489254e-02f,
  -8.59486684e-02f, 2.04477534e-02f, -6.76948205e-02f, 1.36449069e-01f, 3.57139081e-01f, -3.16227138e-01f, 5.72966225e-02f, -1.48146944e-02f, 5.53076684e-01f, 9.33737606e-02f,
  -3.33056934e-02f, -3.43628258e-01f, -1.86558172e-01f, -4.58331555e-02f, -2.44171828e-01f, -6.13826811e-02f, -1.47608340e-01f, -2.22735301e-01f, -1.41405299e-01f, -8.42620283e-02f,
  1.43773049e-01f, 1.74866349e-01f, -1.63096532e-01f, -3.08502372e-02f, 3.25682312e-02f, 5.59493061e-03f, 3.54477800e-02f, 2.99669832e-01f, 4.98706400e-02f, -5.38938880e-01f,
  -4.45845537e-02f, -9.99172963e-03f, 2.12931216e-01f, -5.67988902e-02f, 3.84048820e-01f, -9.78529081e-03f, 5.81251050e-04f, -2.37983823e-01f, 1.37864664e-01f, 9.66463089e-02f,
  -9.00316760e-02f, 9.33609903e-02f, 9.59417745e-02f, -4.29540761e-02f, 2.35159229e-02f, -1.23296686e-01f, 2.28546172e-01f, 1.29537601e-02f, 3.64528745e-01f, -3.66408490e-02f,
  4.28226650e-01f, 9.63046178e-02f, 1.73375919e-01f, -8.79078656e-02f, -1.04653994e-02f, 7.49153364e-03f, 3.51228304e-02f, 6.55069649e-02f, 6.54842556e-02f, -3.26488353e-02f,
  9.61285830e-02f, -1.21555373e-01f, -2.50288248e-01f, -2.13339576e-03f, -5.68608344e-02f, 1.09905042e-01f, -8.73270482e-02f, -4.23088551e-01f, -2.35309154e-01f, -4.74116728e-02f,
  1.41774088e-01f, 4.24081355e-01f, -1.87403113e-01f, 9.47526246e-02f, 1.38288634e-02f, -6.37433887e-01f, -6.50146455e-02f, 2.24004120e-01f, -2.98552625e-02f, -3.04509878e-01f,
  -7.77347386e-02f, -2.01679140e-01f, -8.73986632e-03f, -2.82238692e-01f, -1.14594802e-01f, 5.84700555e-02f, 6.79598451e-02f, 8.95458162e-02f, 1.52521774e-01f, 2.18400627e-01f,
  2.12083578e-01f, -2.74725974e-01f, 8.44449475e-02f, 3.06794882e-01f, -1.03887059e-01f, 9.59515870e-02f, -3.85171697e-02f, 2.43974447e-01f, -4.68741834e-01f, 5.71114719e-02f,
  1.69625103e-01f, 4.26588096e-02f, -2.51179010e-01f, 4.96556312e-02f, 1.23022161e-01f, 1.60501227e-02f, -1.19316727e-01f, 7.36485329e-03f, 1.18306279e-01f, -1.07565463e-01f,
  -4.45495427e-01f, 3.12429875e-01f, -4.35892910e-01f, 2.55461782e-01f, 7.11099431e-02f, 3.62519212e-02f, -7.45339245e-02f, -5.00026383e-02f, -2.19531298e-01f, -7.36176446e-02f,
  -8.52983966e-02f, 6.28367290e-02f, -2.20334083e-01f, -7.84575641e-02f, 7.19793215e-02f, -7.07629602e-03f, 1.54413804e-01f, 8.02721307e-02f, -3.23607493e-03f, -4.16884944e-02f,
  -1.09121710e-01f, 1.31357789e-01f, -3.01902834e-02f, -8.85546431e-02f, 4.68202345e-02f, -5.24504066e-01f, 1.31651863e-01f, 8.83141458e-02f, 2.14105677e-02f, 5.96434414e-01f,
  -1.17394127e-01f, 8.14190730e-02f, 1.55170217e-01f, 2.84134001e-01f, 3.44893821e-02f, 1.01171650e-01f, 4.39535528e-02f, 3.00367415e-01f, -2.52649873e-01f, -1.72575012e-01f,
  2.08306670e-01f, 9.53875557e-02f, -1.61861748e-01f, 1.08074434e-01f, 9.57528800e-02f, 2.25619264e-02f, -1.33112386e-01f, 3.19867641e-01f, -3.17801952e-01f, 8.41466524e-03f,
  -1.00671433e-01f, -7.21214339e-02f, 1.22910731e-01f, -1.68537125e-02f, 5.16157374e-02f, 1.10251546e-01f, 3.50972116e-01f, 1.12875991e-01f, 6.04682602e-03f, 3.77957970e-02f,
  1.44236848e-01f, -9.03682187e-02f, -1.13992639e-01f, 3.21629792e-02f, -5.59427083e-01f, -1.30539089e-01f, -2.82020718e-01f, 1.60145238e-01f, -1.56523332e-01f, 8.15098286e-02f,
  -3.23507667e-01f, -9.94534045e-02f, -2.37218127e-01f, -1.23053186e-01f, -1.16490431e-01f, 9.82336104e-02f, -3.27584207e-01f, 4.68846202e-01f, -2.23384842e-01f, -6.72900900e-02f,
  1.74131125e-01f, -5.27626500e-02f, -7.93554485e-02f, -1.15111627e-01f, 5.65996505e-02f, -1.12213291e-01f, 5.20313144e-01f, 1.68424785e-01f, 2.17458293e-01f, -2.52743423e-01f,
  -2.17322022e-01f, -4.68757637e-02f, 4.41352911e-02f, -9.93529782e-02f, 4.61793184e-01f, -1.17321104e-01f, -8.52570459e-02f, 6.49402216e-02f, -2.20829144e-01f, -5.48272543e-02f,
  6.26599193e-02f, -1.68015286e-01f, 1.12019189e-01f, 1.58282563e-01f, 1.02540497e-02f, -1.67942196e-01f, 5.64184748e-02f, -2.81523496e-01f, -7.69265648e-03f, 4.53686994e-03f,
  1.03958048e-01f, -1.14976041e-01f, 3.43565375e-01f, 9.36665311e-02f, 1.81854516e-02f, -7.01355115e-02f, 1.21346312e-02f, 4.31874767e-02f, -1.01861820e-01f, 6.15070537e-02f,
  2.48705056e-02f, 1.15683302e-01f, -8.99376646e-02f, -6.02841415e-02f, -5.21946996e-02f, -3.06996275e-02f, 1.56218007e-01f, 1.09766386e-01f, 5.40679932e-01f, -9.98540893e-02f,
  1.68010846e-01f, 4.83159013e-02f, 1.33746639e-01f, 1.90980770e-02f, 4.84613687e-01f, -1.05460942e-01f, 2.58921146e-01f, -1.60559654e-01f, 1.65433422e-01f, 1.00904271e-01f,
  2.43401557e-01f, -3.61002773e-01f, 6.76639378e-02f, 8.70044753e-02f, -2.87984431e-01f, -1.50698021e-01f, -1.62756890e-02f, -1.24742612e-01f, -2.69154888e-02f, 1.23755030e-01f,
  -4.01872933e-01f, -5.66138178e-02f, -1.32856369e-01f, 3.58148292e-02f, 9.25151780e-02f, 9.14365575e-02f, 7.50390738e-02f, -2.39678755e-01f, -3.69127750e-01f, 4.05536145e-02f,
  5.84546626e-02f, 1.12299889e-01f, 1.80952594e-01f, -4.17229347e-02f, -2.44167820e-02f, 2.74214417e-01f, 2.76791632e-01f, -1.24040231e-01f, 4.05536853e-02f, 3.08735877e-01f,
  -1.12001687e-01f, 2.66733289e-01f, -7.49591440e-02f, 2.89881200e-01f, 7.09040165e-02f, -3.02555561e-02f, -3.18625629e-01f, -1.77514441e-02f, -1.47679001e-01f, -3.59630994e-02f,
  1.91725329e-01f, -5.66578992e-02f, -9.78119373e-02f, -7.27310926e-02f, 3.36402714e-01f, 1.95599310e-02f, -3.14760506e-02f, 7.38767385e-02f, 4.39655930e-02f, 8.38359669e-02f,
  -1.76404878e-01f, 1.03935823e-01f, 1.86481193e-01f, -1.14214256e-01f, 1.65031344e-01f, 4.99327481e-02f, -1.81051791e-01f, -1.25291245e-02f, -3.59513074e-01f, 4.94929627e-02f,
  -9.67690870e-02f, 2.48739570e-02f, 1.19007766e-01f, 5.05704582e-02f, -3.04330528e-01f, -3.64156924e-02f, -8.70449245e-02f, -3.75878401e-02f, -9.39835310e-02f, 1.33824244e-01f,
  -7.09740445e-02f, 1.05161153e-01f, -6.64914250e-02f, -5.26642613e-02f, -2.68671393e-01f, 5.61605468e-02f, -8.07573795e-02f, 3.24336499e-01f, -3.98040026e-01f, -7.82038048e-02f,
  1.20960400e-01f, 3.23052138e-01f, 3.03778052e-01f, -1.49844348e-01f, 1.88942343e-01f, 1.25348538e-01f, 8.47816318e-02f, 1.76128313e-01f, 1.50242954e-01f, -2.75812298e-02f,
  -2.15087250e-01f, -2.03379422e-01f, -2.41055831e-01f, 8.39438513e-02f, 2.34020606e-01f, -3.32260758e-01f, -1.31860644e-01f, 3.02476555e-01f, 1.08187750e-01f, -4.27758209e-02f,
  -1.76080257e-01f, 1.14601068e-01f, 2.12314054e-01f, 4.06653285e-02f, 3.99037719e-01f, 5.74545823e-02f, 3.72319482e-02f, -1.23179957e-01f, -3.60784739e-01f, -1.07043177e-01f,
  1.11435063e-01f, 4.82119760e-03f, -2.93861683e-02f, 2.85710208e-02f, -1.67050228e-01f, -1.09487511e-01f, 1.94056518e-02f, -1.79768741e-01f, 2.20103607e-01f, 3.65804173e-02f,
  -1.36826023e-01f, -1.22347772e-01f, 9.80596915e-02f, 9.52821150e-02f, -7.31189176e-02f, -1.19362827e-02f, -1.32342905e-01f, -1.63488090e-01f, -1.49081066e-01f, 3.20248976e-02f,
  1.09743744e-01f, -3.75436880e-02f, -2.23698139e-01f, 5.21930940e-02f, -6.76905736e-02f, 1.13055795e-01f, -1.20580971e-01f, 7.00461343e-02f, -1.44487957e-03f, -3.67049336e-01f,
  -9.05161873e-02f, 5.81758916e-01f, 1.37270108e-01f, -1.12225093e-01f, -9.27617028e-02f, 1.12618022e-01f, 1.26979515e-01f, -1.27187073e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.41050052e-02f, 1.62337229e-01f, 9.36539769e-02f, -1.34498209e-01f, 4.75701364e-03f, -1.41436413e-01f, -6.80509508e-02f, -7.94814155e-02f, 8.14149752e-02f, -1.41795993e-01f,
  -4.34916690e-02f, 1.75788477e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    