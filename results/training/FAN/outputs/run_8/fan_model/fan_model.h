/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.14613203e-02f, -3.34125340e-01f, 1.56871289e-01f, 3.60488556e-02f, 2.52283245e-01f, 1.84048653e-01f, -8.69648010e-02f, 2.02606499e-01f, 1.53702050e-01f, -2.88644344e-01f,
  -2.45015100e-02f, 5.85244037e-02f, -2.67027497e-01f, -6.43117994e-04f, -4.17188376e-01f, -1.17803894e-01f, -3.58924270e-02f, -1.98073968e-01f, 6.38484135e-02f, 1.38360649e-01f,
  1.62377506e-01f, -2.26705015e-01f, 8.06317776e-02f, -1.14170592e-02f, 1.61371842e-01f, 1.37369186e-01f, -2.21702144e-01f, -8.24238360e-03f, -1.39262021e-01f, -1.81576815e-02f,
  9.58421007e-02f, 3.13420802e-01f, 2.27704406e-01f, -1.26322851e-01f, 4.77706268e-02f, -2.60129408e-03f, -6.33772761e-02f, 2.53217071e-02f, 1.02739088e-01f, 4.57355976e-02f,
  2.53722183e-02f, 1.12599075e-01f, 4.94291894e-02f, -7.71391615e-02f, 3.35091427e-02f, 1.29981145e-01f, 3.34289074e-02f, 2.55454462e-02f, 9.82236490e-02f, 1.60999015e-01f,
  2.13712707e-01f, 8.40627700e-02f, 1.14517175e-01f, 3.77792791e-02f, 1.32158920e-01f, 4.06973809e-02f, 2.22761389e-02f, -2.87714158e-03f, -1.77264176e-02f, 1.66093767e-01f,
  -6.07288852e-02f, -1.05802715e-01f, 6.84105679e-02f, -3.33658159e-02f, 2.51737665e-02f, 1.28556430e-01f, 1.79896560e-02f, -1.94749869e-02f, 6.66608512e-02f, -3.70020382e-02f,
  3.58404405e-02f, -6.84310272e-02f, -3.51413339e-02f, 1.19018136e-03f, 4.74517280e-03f, -2.75757331e-02f, -1.07825641e-02f, 5.51125519e-02f, -5.78075051e-02f, -2.19632313e-02f,
  1.93908457e-02f, 9.33285356e-02f, -9.26347375e-02f, 1.15198031e-01f, -2.26417352e-02f, -4.01609056e-02f, 6.94083944e-02f, -1.23331724e-02f, 7.12390468e-02f, -5.16080149e-02f,
  -3.17919165e-01f, -5.61089516e-01f, -1.54335529e-01f, 7.52762035e-02f, -7.78960884e-02f, -1.52794309e-02f, -7.89601281e-02f, 7.01408368e-03f, -1.66991726e-01f, 1.63156670e-02f,
  -4.64355461e-02f, 1.20627712e-02f, -4.41421242e-03f, -2.95561068e-02f, -9.38793570e-02f, 1.19645782e-02f, -2.60985158e-02f, -1.09816872e-01f, -1.88829258e-01f, -1.51685759e-01f,
  -3.21971215e-02f, -1.70751847e-02f, 6.22390024e-02f, -2.14304775e-02f, -3.97829153e-02f, -8.12246501e-02f, 5.91513794e-03f, -7.01137781e-02f, 6.87816814e-02f, -4.86443378e-02f,
  -1.44869700e-01f, 2.33013228e-01f, 2.96763182e-01f, 1.33681789e-01f, -2.69178212e-01f, -4.01326358e-01f, 1.58713874e-03f, -1.15969265e-02f, 3.14061195e-01f, 1.23239227e-01f,
  -2.31472924e-01f, 2.92809725e-01f, 8.12058449e-02f, -2.14459598e-01f, -4.45403785e-01f, 2.95588709e-02f, -1.56016394e-01f, -1.75473113e-02f, 1.58725176e-02f, 1.34849563e-01f,
  -7.42773712e-02f, -2.93705881e-01f, -1.05989806e-01f, -2.89372751e-03f, -1.97333992e-01f, 2.73891598e-01f, -1.85938194e-01f, 1.58547908e-01f, -1.38191625e-01f, -8.32897052e-02f,
  -1.61718577e-01f, 1.97644547e-01f, 1.04844116e-01f, 5.00664255e-03f, -5.96421510e-02f, -7.39709809e-02f, -2.37445198e-02f, 3.12145129e-02f, 1.51879876e-03f, 4.36941534e-02f,
  2.40348168e-02f, -2.22862884e-02f, 9.15162042e-02f, -1.96087314e-03f, -3.37973908e-02f, 4.97920774e-02f, 5.20476066e-02f, -7.68912360e-02f, 1.32335365e-01f, -1.08513720e-01f,
  7.48845562e-02f, 1.59740075e-02f, 2.43856069e-02f, 8.24491680e-02f, 1.24683239e-01f, 3.72411534e-02f, 1.46681927e-02f, 2.22833958e-02f, 1.25156641e-02f, 4.29660194e-02f,
  -6.45495653e-02f, -6.74857795e-02f, 5.20956283e-03f, -1.55174598e-01f, -1.77800506e-02f, -9.43245515e-02f, -1.14686210e-02f, 1.96681861e-02f, 1.15968734e-01f, -8.13971534e-02f,
  1.08023081e-02f, -3.62033620e-02f, -9.31800753e-02f, 1.95916314e-02f, -1.57483190e-01f, 3.97254825e-02f, -5.83165959e-02f, -3.00755743e-02f, 8.99128988e-02f, -1.18264459e-01f,
  -9.92276054e-03f, -4.84322235e-02f, 3.27305235e-02f, -8.86218343e-03f, -1.44510195e-01f, 6.16197847e-02f, -9.86168720e-03f, 2.89267711e-02f, -2.65619531e-02f, -9.70652699e-03f,
  3.01359762e-02f, 1.69768661e-01f, 8.09136853e-02f, -1.24954581e-02f, 3.89692634e-02f, 4.77803871e-02f, 3.50219123e-02f, -6.31383434e-02f, 2.72016879e-02f, -1.09359100e-01f,
  -5.67500107e-02f, 1.14079341e-01f, -7.51420576e-03f, -5.01005836e-02f, 5.52159399e-02f, -7.85000157e-03f, -2.96627171e-02f, 4.86962646e-02f, -3.96130420e-02f, 4.19247523e-03f,
  -4.39660735e-02f, -4.02334966e-02f, 1.24761872e-01f, -2.33548749e-02f, -7.83091709e-02f, 1.37582347e-02f, -7.55341128e-02f, 8.11914653e-02f, -3.79707739e-02f, 1.41780093e-01f,
  -3.83910745e-01f, 3.26800019e-01f, 5.07154346e-01f, -1.87302623e-02f, -2.59808689e-01f, -2.32951924e-01f, -1.34234175e-01f, 8.30233842e-02f, -1.76745728e-01f, 1.49435163e-01f,
  -1.38872132e-01f, -2.52488889e-02f, 1.14814594e-01f, 1.23878323e-01f, -5.22992551e-01f, 5.18224128e-02f, 2.20871910e-01f, -1.05317116e-01f, 1.20823476e-02f, 1.74932986e-01f,
  -1.18431881e-01f, -1.24929182e-01f, 2.54502535e-01f, 4.96510454e-02f, -7.80475065e-02f, 2.10276917e-01f, 5.29783666e-02f, 7.88087770e-03f, 7.68391863e-02f, -1.53103679e-01f,
  4.72363224e-03f, -1.12462444e-02f, 9.86373499e-02f, -2.18546041e-03f, 3.00679263e-02f, -7.65331909e-02f, 6.90881759e-02f, 1.23945381e-02f, -5.64427041e-02f, 7.84018040e-02f,
  -3.80899198e-02f, -4.91978079e-02f, -6.02916665e-02f, -4.58265170e-02f, -1.63403302e-01f, 9.53684300e-02f, -9.33507457e-02f, -7.06711709e-02f, 1.14806984e-02f, -6.60627633e-02f,
  8.74153897e-02f, 3.59757170e-02f, -3.09481360e-02f, -3.52842845e-02f, -6.45054355e-02f, 2.59774681e-02f, 3.33497003e-02f, -7.63301225e-03f, -2.72398964e-02f, -1.34104177e-01f,
  -8.44619125e-02f, 1.15637034e-02f, -1.05977982e-04f, 7.04684854e-02f, 1.57881584e-02f, 2.45239697e-02f, -6.91448078e-02f, 2.18227394e-02f, 4.18065861e-02f, -4.97493036e-02f,
  -3.90161644e-04f, -8.49752035e-03f, -1.14747830e-01f, -1.83688570e-02f, -8.76823217e-02f, 2.67261863e-02f, -2.67758425e-02f, 4.30352837e-02f, -3.09682898e-02f, 1.02516674e-02f,
  -2.65940418e-03f, -8.07370767e-02f, 3.51112075e-02f, -3.58448140e-02f, -4.48955735e-03f, 1.59049053e-02f, -5.34248957e-03f, -3.77505347e-02f, 9.73034203e-02f, -3.06022186e-02f,
  -7.13544935e-02f, 6.85112104e-02f, 2.41178423e-02f, 3.20922844e-02f, 3.55134234e-02f, 2.53425743e-02f, -2.48833895e-02f, -2.13066246e-02f, 1.22999713e-01f, -9.40802470e-02f,
  6.88919723e-02f, 2.29280163e-02f, -2.35274434e-02f, -5.33281118e-02f, 5.63870780e-02f, -1.38225015e-02f, 1.33852348e-01f, 5.60246669e-02f, 6.78889677e-02f, -6.93299714e-03f,
  8.05408806e-02f, 2.28278954e-02f, -2.23387554e-02f, 2.95488304e-03f, -5.49405739e-02f, -1.14090621e-01f, -8.99372995e-02f, 6.00724220e-02f, -4.76282351e-02f, 1.24366479e-02f,
  1.08398855e+00f, 2.69984514e-01f, 2.42109701e-01f, 4.99404401e-01f, 1.81622412e-02f, 1.68099120e-01f, 4.52782214e-01f, -1.26619309e-01f, 3.93370092e-01f, -8.85961577e-02f,
  1.42545223e-01f, 8.15332085e-02f, 3.50871757e-02f, 2.76185423e-01f, 1.05184875e-01f, 1.28441215e-01f, 2.46629104e-01f, 2.00828195e-01f, -9.48258713e-02f, 1.69002861e-01f,
  1.29051864e-01f, 4.11417820e-02f, 2.60113150e-01f, -3.64903599e-01f, 3.17071438e-01f, -1.19816132e-01f, -3.93616445e-02f, -9.21945944e-02f, -5.57114407e-02f, -7.11600482e-02f,
  -1.51617914e-01f, -2.91795228e-02f, 5.69167249e-02f, -2.84693222e-02f, 7.92630091e-02f, 4.45432495e-03f, -7.24169910e-02f, -1.22568995e-01f, 4.09958214e-02f, -1.97367407e-02f,
  7.46082664e-02f, -1.03378922e-01f, 7.13394443e-03f, 2.84092966e-02f, 7.30333775e-02f, -3.60111110e-02f, 8.19106027e-02f, 7.76562020e-02f, -3.27397846e-02f, 1.15614861e-01f,
  1.27142355e-01f, 5.10491319e-02f, 2.21898496e-01f, 3.95188518e-02f, 5.69736585e-02f, 1.08358234e-01f, -1.99884288e-02f, 2.89574284e-02f, -3.75318564e-02f, 5.93614839e-02f,
  1.55597525e-02f, -3.07558198e-02f, 9.07495022e-02f, -3.92209589e-02f, 3.74620259e-02f, -1.67951044e-02f, 5.88093959e-02f, -1.79675594e-02f, 8.14208686e-02f, 2.47693378e-02f,
  -1.64289819e-03f, 3.28269228e-02f, 2.59341132e-02f, -1.99264027e-02f, 4.74203750e-02f, -6.19390048e-02f, 9.52262878e-02f, -1.02124587e-01f, 1.03613093e-01f, 7.08693713e-02f,
  -6.08082414e-02f, -1.99681171e-03f, -3.37652490e-02f, -1.00677516e-02f, -9.14980024e-02f, 9.23676789e-02f, 5.97239695e-02f, 6.54294491e-02f, -3.02157067e-02f, 7.93064460e-02f,
  6.68948367e-02f, 1.31499425e-01f, -2.86385417e-02f, -9.92630869e-02f, -5.98905981e-02f, 5.30072628e-03f, 1.67602450e-02f, 1.82553176e-02f, -1.17879346e-01f, 6.05853125e-02f,
  -2.79174019e-02f, 2.25411523e-02f, -2.91099921e-02f, -2.32392512e-02f, -1.17403315e-02f, 6.30832762e-02f, -9.05668642e-03f, -6.39520884e-02f, 3.45716216e-02f, -8.10675174e-02f,
  -5.89172021e-02f, -2.83268280e-02f, -6.33039474e-02f, -3.39311548e-02f, -9.68697518e-02f, -5.84770888e-02f, 9.31442082e-02f, -2.17161458e-02f, -5.22718728e-02f, -3.23012546e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.20814574e-01f, -1.57986566e-01f, -8.75131041e-02f, 2.29603723e-01f, 3.00247192e-01f, 2.95157909e-01f, 7.15902597e-02f, -1.09672636e-01f, -1.05004442e+00f, 1.28260165e-01f,
  1.70033485e-01f, 2.26095334e-01f, -5.07241905e-01f, 2.18977839e-01f, -2.14015156e-01f, -7.06792474e-01f, 3.55743438e-01f, 5.02340019e-01f, -3.35210115e-01f, 5.01664042e-01f,
  -4.24589306e-01f, 1.03879616e-01f, -2.13321730e-01f, 7.24695250e-02f, 5.36413491e-01f, 4.30080980e-01f, 7.24258542e-01f, 1.65036544e-01f, 8.26672614e-01f, 3.20476502e-01f,
  -5.42964414e-02f, -2.68958122e-01f, 5.94149716e-03f, -1.36394411e-01f, 8.77064317e-02f, 2.90752620e-01f, 4.13718939e-01f, 2.70667881e-01f, -2.55072434e-02f, -7.14494810e-02f,
  1.78609818e-01f, 1.61541700e-01f, -9.23940726e-03f, -1.56142727e-01f, -2.42843851e-02f, -1.18122131e-01f, -1.42281860e-01f, -2.22819179e-01f, -1.89862564e-01f, 2.19460465e-02f,
  -2.71275669e-01f, 1.55630901e-01f, 1.02630906e-01f, 3.48890908e-02f, -3.11510041e-02f, -7.61867389e-02f, 1.90186754e-01f, 3.62131655e-01f, -4.15535681e-02f, 1.23134412e-01f,
  2.52144039e-01f, 2.04143539e-01f, 1.61796063e-01f, -9.50724557e-02f, -1.05470359e-01f, 3.73407081e-03f, 2.08085426e-03f, -1.51288807e-01f, -1.15105562e-01f, -1.15112029e-01f,
  1.11071676e-01f, 8.05592015e-02f, -2.26814881e-01f, 2.21779346e-01f, 2.13329121e-01f, -1.26979966e-02f, 4.62612137e-02f, 2.19303802e-01f, -2.52852514e-02f, -8.07833076e-02f,
  -2.19488055e-01f, 1.00242577e-01f, 6.77756891e-02f, 2.18067080e-01f, -2.12071568e-01f, 6.27796873e-02f, 1.65084079e-01f, 1.44668687e-02f, 4.33777124e-02f, 1.08494170e-01f,
  -7.59113654e-02f, 1.19313926e-01f, -2.30429932e-01f, 3.90326902e-02f, -1.75064787e-01f, 7.91385770e-02f, -2.24765241e-01f, -1.41488034e-02f, 2.06074759e-01f, -6.06721751e-02f,
  2.25967631e-01f, 3.73591110e-02f, 8.24010521e-02f, 1.66652113e-01f, 2.65725479e-02f, 6.88807368e-02f, 1.09486729e-01f, 2.08460316e-01f, 2.46030614e-01f, 2.29433432e-01f,
  3.48843068e-01f, 2.43776307e-01f, 4.70347367e-02f, -1.13462292e-01f, 2.72384644e-01f, 1.05638459e-01f, 8.95798802e-02f, 1.19135842e-01f, 1.10372074e-01f, -6.84100538e-02f,
  -8.49989727e-02f, -3.58735710e-01f, -1.39130697e-01f, 8.96950185e-01f, 7.77282000e-01f, -6.26267374e-01f, -5.67466855e-01f, 9.24037397e-01f, 1.44366831e-01f, -3.68747801e-01f,
  5.08738756e-01f, -1.18888128e+00f, -2.63224661e-01f, 2.02266797e-01f, -1.50402319e-02f, -7.14306593e-01f, 1.10457480e-01f, -3.85120571e-01f, -6.62628487e-02f, 3.97855133e-01f,
  3.76075000e-01f, 9.75286841e-01f, 7.88346902e-02f, 8.45121086e-01f, 5.73609114e-01f, 4.95910734e-01f, 8.31737399e-01f, -5.40543646e-02f, 4.88477975e-01f, -1.83487102e-01f,
  -4.99537796e-01f, 1.32851020e-01f, 3.92317623e-02f, -2.87720650e-01f, 2.14564234e-01f, 7.33593553e-02f, -1.72136724e-01f, -3.63141328e-01f, -1.41868725e-01f, 2.77453307e-02f,
  -3.54665607e-01f, -6.60831691e-04f, -1.65666023e-03f, 5.10771796e-02f, 7.81444311e-02f, 4.77736108e-02f, 9.66966990e-03f, -2.93616652e-02f, -6.74101338e-02f, -6.11073774e-05f,
  -4.76683266e-02f, -5.27000315e-02f, 1.54381618e-02f, -2.32759699e-01f, 3.18796351e-03f, 5.30485734e-02f, -1.79153144e-01f, -2.14894190e-01f, 1.35757595e-01f, 3.92192304e-02f,
  -7.76157901e-02f, 5.81618994e-02f, -5.60272112e-02f, -6.56955317e-02f, 1.10644341e-01f, 7.17271045e-02f, -7.58024082e-02f, -3.84844886e-03f, 4.18391451e-02f, -7.29939342e-02f,
  2.29946166e-01f, 6.10850230e-02f, 1.56780869e-01f, 9.04419273e-02f, -8.84846076e-02f, 7.67099634e-02f, -1.61678031e-01f, 4.83245961e-02f, 2.60468721e-01f, 1.64775748e-03f,
  2.13226012e-04f, 1.22479260e-01f, 2.37510782e-02f, -3.88151854e-02f, -5.00119217e-02f, -1.61382258e-02f, 1.41534507e-01f, -7.90744275e-02f, -1.04649514e-01f, 1.99740544e-01f,
  -1.92276642e-01f, 4.74132180e-01f, 8.72556195e-02f, -3.72015685e-02f, -1.07258186e-01f, 9.37214047e-02f, -8.25440139e-02f, 6.85904026e-02f, 6.21493766e-03f, 2.06806231e-02f,
  6.58601671e-02f, 1.74361438e-01f, 6.03834875e-02f, 4.86039147e-02f, -2.76614856e-02f, 1.58938289e-01f, 4.69712093e-02f, 1.29471108e-01f, 2.26734966e-01f, 3.85904945e-02f,
  1.19174533e-01f, 3.60530727e-02f, 2.79735532e-02f, 2.05510065e-01f, 2.69360572e-01f, -6.23257421e-02f, 1.22712858e-01f, -7.73504600e-02f, 2.92200334e-02f, -1.78636946e-02f,
  -1.13113010e+00f, -5.00612080e-01f, 5.26914537e-01f, -1.44132614e+00f, 2.41927385e-01f, 6.99351728e-01f, -9.79213864e-02f, -1.88810512e-01f, -8.13366950e-01f, -1.21259555e-01f,
  -3.16368951e-03f, -4.42122310e-01f, 4.38374609e-01f, -1.12027395e+00f, 1.07514948e-01f, -1.15271740e-01f, -6.40882492e-01f, -4.60186899e-01f, -7.36040622e-02f, -1.24858856e-01f,
  -2.01652616e-01f, -4.57607359e-01f, 8.84200260e-02f, 8.93073007e-02f, -4.85952348e-02f, 4.17729765e-02f, 2.77048916e-01f, 7.17224717e-01f, -2.91969150e-01f, 1.09005652e-01f,
  -1.46574974e-01f, -3.63369823e-01f, 7.57323438e-03f, -2.28736084e-02f, 1.39640182e-01f, 3.12760063e-02f, 1.71224073e-01f, 1.03337079e-01f, -7.66002834e-02f, -7.72256330e-02f,
  -1.33635968e-01f, -3.64973657e-02f, -3.64795536e-01f, 7.95143545e-02f, -1.78756863e-01f, -3.95012237e-02f, 2.14908179e-02f, 1.87992036e-01f, 2.69116666e-02f, 1.76962726e-02f,
  2.79610995e-02f, 3.08445282e-03f, 1.72874108e-02f, -1.08805433e-01f, 1.47334069e-01f, -9.06869993e-02f, -6.40965328e-02f, 2.52599061e-01f, 6.09098375e-03f, -5.39607555e-02f,
  -6.17556237e-02f, 6.87673539e-02f, 3.73611152e-02f, -6.63333461e-02f, -4.92447391e-02f, -4.47071297e-03f, -9.85986441e-02f, 1.08658887e-01f, 4.83190734e-03f, -1.34138027e-02f,
  -7.32334927e-02f, -3.86407748e-02f, -7.50426203e-02f, -2.77789012e-02f, -1.11404501e-01f, -1.95571214e-01f, -3.69069725e-02f, -1.39345485e-03f, -2.33860593e-02f, 9.61824227e-03f,
  -1.95401404e-02f, -2.31193714e-02f, 2.92241778e-02f, -5.45069166e-02f, 2.74823401e-02f, -8.36984348e-03f, -1.09217823e-01f, -9.01611988e-03f, 8.26177821e-02f, 2.83080488e-01f,
  1.97333634e-01f, -7.07546994e-02f, -6.33950010e-02f, -4.01614495e-02f, -1.04427457e-01f, 6.96746334e-02f, -1.44063592e-01f, -5.28836139e-02f, -1.34710163e-01f, -5.21551631e-02f,
  4.18400504e-02f, -2.38562822e-02f, 2.08253503e-01f, -6.69643581e-02f, 1.89704150e-01f, 7.33966008e-02f, 4.36098687e-03f, -2.30282769e-01f, 3.95085942e-03f, 8.25958140e-03f,
  1.63493939e-02f, -5.16474210e-02f, -2.52008485e-03f, -4.98740450e-02f, -1.46729186e-01f, 8.05573314e-02f, -3.37116495e-02f, -1.31401703e-01f, 1.42769858e-01f, -1.02300748e-01f,
  -4.06263709e-01f, 1.28452563e+00f, -3.87550265e-01f, -5.88237524e-01f, 3.67069125e-01f, 1.45327818e+00f, 2.69542933e-01f, 5.40562272e-01f, 2.90061533e-01f, 5.08025587e-01f,
  2.60943592e-01f, -2.05579355e-01f, 1.31199092e-01f, 4.03218180e-01f, -3.55416954e-01f, 5.06148398e-01f, 2.44662762e-01f, 7.78179169e-02f, 3.46753240e-01f, 4.94409315e-02f,
  -1.94808021e-01f, 5.52539885e-01f, -7.22740173e-01f, 4.53766078e-01f, -5.31018525e-02f, -3.35439771e-01f, -6.77132010e-01f, -1.88309729e-01f, -1.50198057e-01f, 1.68867409e-01f,
  -2.90484205e-02f, 3.49717923e-02f, -1.28580526e-01f, -6.76212981e-02f, -6.41420633e-02f, -1.92245673e-02f, -4.62010987e-02f, -9.98062864e-02f, -2.01685920e-01f, -1.68407653e-02f,
  -6.05307519e-02f, 5.13799023e-04f, 1.47509679e-01f, 8.22914019e-02f, 1.51903987e-01f, -5.33856340e-02f, -1.01982683e-01f, 2.44820528e-02f, 2.76540536e-02f, -8.30474049e-02f,
  -1.11889645e-01f, -1.73170641e-01f, -1.21160872e-01f, 3.66892368e-02f, -1.71273351e-01f, 1.47870943e-01f, 1.02063224e-01f, -1.95652395e-01f, -5.29804118e-02f, 1.38482600e-01f,
  3.05514745e-02f, 2.34655261e-01f, 4.88912724e-02f, -1.64534897e-01f, 1.06408395e-01f, -9.99484062e-02f, -7.40287602e-02f, -1.58642232e-01f, -6.33296296e-02f, -6.14040950e-03f,
  -9.20769572e-02f, -1.02413103e-01f, 2.17367709e-01f, -5.82142882e-02f, 1.33344278e-01f, -2.86607575e-02f, -1.04215048e-01f, 5.89905344e-02f, -2.17306033e-01f, -6.62802458e-02f,
  -7.03169554e-02f, 1.75090611e-01f, 3.24242935e-02f, 1.91115700e-02f, 7.47783259e-02f, -2.08403751e-01f, 1.40540630e-01f, 7.45243160e-03f, -1.69463933e-01f, -1.01565652e-01f,
  3.02161783e-01f, 7.58088291e-01f, 4.95142005e-02f, 2.47212630e-02f, 3.14981006e-02f, 9.82169658e-02f, -2.51044184e-02f, 1.59728467e-01f, 9.49170291e-02f, 2.70686388e-01f,
  2.85007991e-02f, -4.54422012e-02f, -9.64397471e-03f, -1.45531714e-01f, -2.75412500e-01f, 3.06730628e-01f, -9.62848142e-02f, -1.93282347e-02f, -1.03021592e-01f, 2.49709245e-02f,
  -2.52929360e-01f, 1.54896989e-01f, -6.56884536e-02f, 3.12370416e-02f, 1.87391356e-01f, -1.44261181e-01f, 1.64573491e-01f, 1.95631190e-04f, -5.00325561e-02f, -6.15024082e-02f,
  -5.39167702e-01f, -4.33139890e-01f, -1.05128813e+00f, -1.85477063e-01f, -2.87759542e-01f, -8.96236122e-01f, -1.49931282e-01f, -2.78305024e-01f, -2.30291784e-01f, 6.18423641e-01f,
  5.99021912e-01f, -4.29626048e-01f, 8.54261935e-01f, -1.07528158e-01f, -9.28693235e-01f, 6.44867957e-01f, -2.96700358e-01f, 4.70928364e-02f, -3.05313542e-02f, -2.17108220e-01f,
  -3.54166955e-01f, 2.93007821e-01f, -2.91625232e-01f, 1.16247468e-01f, -5.40991008e-01f, -2.65948862e-01f, 1.04906988e+00f, 2.68341228e-02f, -1.45177886e-01f, -2.09361777e-01f,
  -3.22426669e-02f, 3.36174697e-01f, -3.00269932e-01f, -2.00498179e-01f, -1.07180692e-01f, 1.22888379e-01f, 2.86868475e-02f, 8.01304281e-02f, -1.39110154e-02f, -3.80492695e-02f,
  1.67150065e-01f, 3.91771421e-02f, -1.05149075e-01f, 5.21743447e-02f, -1.03295490e-01f, -6.49211332e-02f, -3.22313190e-01f, -6.49695471e-02f, 7.98090994e-02f, -2.80094407e-02f,
  -2.21410662e-01f, 1.94131434e-02f, 1.21555636e-02f, 1.19789869e-01f, -1.02532990e-01f, -8.89045093e-03f, 4.45202105e-02f, -7.85623491e-03f, 4.04889621e-02f, 1.03759579e-02f,
  1.59772467e-02f, 8.19623023e-02f, 1.97548613e-01f, 6.64870515e-02f, -3.14017415e-01f, 1.45987898e-01f, 1.27509180e-02f, 1.36948023e-02f, -1.43531591e-01f, -9.87758487e-02f,
  -1.55905068e-01f, -1.52704805e-01f, 1.72504425e-01f, 8.46059918e-02f, -3.95637006e-02f, 8.13188851e-02f, 5.98616600e-02f, 1.40498772e-01f, -1.32252589e-01f, -2.26389393e-01f,
  1.96906701e-01f, 4.52459194e-02f, -2.00070739e-02f, 2.07977384e-01f, 1.55494092e-02f, -2.69890800e-02f, 1.16782352e-01f, 2.56106351e-02f, 9.41093266e-02f, 2.35587619e-02f,
  -9.50466767e-02f, -9.65448469e-02f, 1.11604847e-01f, 3.94486189e-02f, -4.76844609e-03f, -3.26634124e-02f, -3.09635699e-02f, -3.95206839e-01f, -1.23576574e-01f, -7.74157718e-02f,
  6.85163885e-02f, 4.01154086e-02f, 2.57056337e-02f, -4.65685688e-02f, -5.98220006e-02f, -1.84823200e-02f, 4.27202553e-01f, 6.59077391e-02f, -1.44512147e-01f, 2.01573242e-02f,
  1.57249227e-01f, 8.22199285e-02f, -3.50072011e-02f, -1.26871616e-01f, 5.85605353e-02f, 9.43158492e-02f, -1.84382677e-01f, 1.90814547e-02f, 9.73819494e-02f, 2.56707589e-03f,
  7.58281291e-01f, -6.89562261e-01f, 8.95465672e-01f, 9.51085910e-02f, 3.66468281e-01f, 2.75427178e-02f, 8.03708732e-01f, -3.40374887e-01f, 1.12960112e+00f, -9.39476848e-01f,
  -8.61240149e-01f, -5.69070876e-03f, 6.95404690e-03f, -7.23543584e-01f, 1.05910122e+00f, 4.85438764e-01f, -5.87615073e-02f, 2.74901867e-01f, 6.18654132e-01f, -3.68987799e-01f,
  1.40716270e-01f, -9.46252286e-01f, -1.27140403e-01f, -1.09625757e+00f, -5.88185489e-01f, -2.43145987e-01f, -6.54722691e-01f, 1.26144543e-01f, -1.03974116e+00f, 1.64408255e-02f,
  -7.95272529e-01f, -2.45178774e-01f, -2.60695517e-01f, -7.20429569e-02f, -1.53954789e-01f, 2.06447598e-02f, -2.28961091e-02f, 2.69008070e-01f, 1.55479535e-01f, -9.24803615e-02f,
  6.39676908e-03f, 9.67815369e-02f, -1.08832173e-01f, 1.10624403e-01f, 1.40604571e-01f, -1.16508432e-01f, -1.41293317e-01f, 1.74277797e-02f, 2.63072755e-02f, 8.20080116e-02f,
  -9.85256881e-02f, 6.94780722e-02f, -6.95984066e-03f, 6.71416745e-02f, 1.31115824e-01f, -9.28604677e-02f, 1.89500496e-01f, 1.09859593e-01f, -1.75541192e-01f, 2.01091334e-01f,
  8.56989250e-02f, 2.17476547e-01f, 1.34442881e-01f, -3.15071940e-02f, -8.14523026e-02f, -6.31176829e-02f, -1.34650886e-01f, -1.48083329e-01f, 7.48400986e-02f, -8.48542340e-03f,
  -2.56027821e-02f, -8.14736560e-02f, 1.34600207e-01f, -5.96220233e-03f, -7.75583312e-02f, 1.39634660e-03f, 5.23090884e-02f, -3.72105688e-02f, 1.89987779e-01f, -6.54965341e-02f,
  4.91738841e-02f, -1.77509543e-02f, -1.40286431e-01f, 1.23412400e-01f, 5.46519943e-02f, 1.09232157e-01f, -2.83340484e-01f, 2.51183033e-01f, -8.45246483e-03f, -1.54633895e-01f,
  -7.88300395e-01f, -3.59506547e-01f, -1.96563542e-01f, -1.74414396e-01f, -1.55861094e-03f, -2.18377456e-01f, 1.72521219e-01f, -2.70882308e-01f, -1.09609589e-02f, 1.85011357e-01f,
  2.48235706e-02f, -5.22146188e-02f, -1.14856094e-01f, -1.27887921e-02f, -1.50276825e-01f, 3.50318104e-02f, 6.86961133e-03f, -1.35064557e-01f, -1.66823179e-01f, -9.24199596e-02f,
  -1.16268061e-01f, 1.73355907e-01f, 6.73269257e-02f, -9.63810012e-02f, -1.50659248e-01f, -1.74376909e-02f, -9.55748465e-03f, 1.91707909e-01f, -7.94158503e-02f, -9.16909948e-02f,
  -2.39975739e+00f, 2.48271853e-01f, -6.85687602e-01f, 1.56462923e-01f, 1.27501786e-02f, 2.13167682e-01f, 3.30724031e-01f, -1.04436219e-01f, -4.74935830e-01f, 1.48832470e-01f,
  3.57263207e-01f, -2.82237828e-01f, 4.11354518e-03f, 7.53907144e-01f, -3.30866054e-02f, 3.65470856e-01f, 3.43620889e-02f, 2.21960410e-01f, -9.03251916e-02f, -6.12137258e-01f,
  -3.23740214e-01f, 8.09404135e-01f, 3.18362921e-01f, 2.24805579e-01f, -4.28214408e-02f, -1.81756273e-01f, -7.92484656e-02f, 4.18572202e-02f, 5.48903763e-01f, 5.86201608e-01f,
  -7.31762469e-01f, -4.30499792e-01f, -1.07348084e-01f, -2.87869066e-01f, -2.36399919e-01f, -1.06903128e-01f, -7.77043328e-02f, 1.55057266e-01f, -9.60300304e-03f, -6.51423857e-02f,
  -6.56896159e-02f, -1.00818507e-01f, 2.05094993e-01f, 2.34461263e-01f, -7.83058554e-02f, 1.40062263e-02f, -1.28439263e-01f, -4.03455235e-02f, -1.25023231e-01f, 2.43326500e-02f,
  7.35222697e-02f, 5.97999841e-02f, -1.82334986e-02f, 1.41352400e-01f, 3.52821946e-02f, 3.10930107e-02f, 8.08180794e-02f, -1.41345961e-02f, -1.05744384e-01f, 2.11461447e-02f,
  1.54325599e-02f, 3.25303823e-02f, 4.78903279e-02f, 7.51492679e-02f, 3.58840004e-02f, 9.55170766e-02f, -1.06705107e-01f, 8.42059702e-02f, -1.25717167e-02f, -5.59624061e-02f,
  -4.75904495e-02f, -2.52107382e-02f, 1.68534033e-02f, -3.23212259e-02f, 4.52369004e-02f, 2.29743328e-02f, 3.16423108e-03f, 1.43738136e-01f, 1.24146566e-01f, 6.19719066e-02f,
  -7.52959102e-02f, 3.05344183e-02f, 2.67547742e-02f, 6.73929974e-02f, -7.92775862e-03f, -1.39027843e-02f, -1.73044577e-02f, 5.87393865e-02f, -1.55383523e-03f, -1.51247174e-01f,
  -1.66307771e+00f, -1.10159135e+00f, 2.04914689e-01f, -9.46875364e-02f, 8.56552124e-02f, 1.21233463e-01f, -9.41405352e-03f, -1.39047444e-01f, -1.71259269e-01f, -7.49840811e-02f,
  -1.69936344e-01f, 9.63600725e-02f, -2.13485226e-01f, 4.06207368e-02f, 3.66426967e-02f, -9.47429426e-03f, -1.78257272e-01f, -1.16698340e-01f, -8.56861919e-02f, -1.21807074e-02f,
  5.18249758e-02f, -2.61774063e-02f, 4.30527218e-02f, 2.93418244e-02f, 1.11984968e-01f, -8.49279910e-02f, -7.91912079e-02f, 1.13431804e-01f, -9.78083238e-02f, 7.41648450e-02f,
  2.09375516e-01f, 7.62927890e-01f, 1.55893803e-01f, -6.60501644e-02f, 1.45193323e-01f, -1.02381420e+00f, -3.83143067e-01f, -1.30612813e-02f, 3.70034754e-01f, 1.89519182e-01f,
  -5.50223172e-01f, 7.00299084e-01f, -3.89098287e-01f, -7.33890057e-01f, -1.46922839e+00f, -8.42578292e-01f, -1.19596899e+00f, -3.31553906e-01f, -8.58278498e-02f, -2.87861526e-01f,
  -4.57734287e-01f, -7.75307000e-01f, -6.77660763e-01f, 1.30021989e-01f, 1.64031595e-01f, 6.16704941e-01f, -4.06529993e-01f, 4.02528018e-01f, -2.96738744e-01f, -7.68597573e-02f,
  -1.47138417e-01f, 4.71321225e-01f, 3.34967464e-01f, -2.98962034e-02f, -4.12907273e-01f, 7.97029883e-02f, 3.43126319e-02f, -7.53670260e-02f, 6.73685893e-02f, 6.58465922e-02f,
  2.59670228e-01f, -9.70150605e-02f, -3.99499275e-02f, 1.77058101e-01f, 3.29959482e-01f, 2.02483594e-01f, 1.40897378e-01f, -4.06460688e-02f, 8.46707672e-02f, 2.73335159e-01f,
  5.43905944e-02f, -2.84743309e-02f, -1.26385480e-01f, -1.12546712e-01f, 5.58354184e-02f, 2.71416456e-02f, -8.50604996e-02f, 8.11594203e-02f, -7.00811744e-02f, -4.81538586e-02f,
  5.28525226e-02f, -4.82400460e-03f, -1.19743675e-01f, 1.69977814e-01f, -1.13750927e-01f, 5.77105731e-02f, -2.10758552e-01f, -4.70416173e-02f, 6.72840327e-02f, 8.47158767e-03f,
  -6.55095652e-02f, 2.88943172e-01f, -1.66190326e-01f, -1.31940335e-01f, -1.36018619e-01f, 6.37501329e-02f, -4.85762618e-02f, 7.31336605e-03f, 3.76877584e-03f, -1.04767680e-01f,
  -8.40604976e-02f, -2.53402948e-01f, 1.02990687e-01f, -1.56859949e-01f, -2.68518239e-01f, 1.10993519e-01f, -1.52189732e-01f, 4.12231721e-02f, -7.90485740e-02f, -2.13609800e-01f,
  -5.50167978e-01f, -5.24132192e-01f, -2.55573355e-02f, 9.05982777e-02f, -2.54258476e-02f, -7.41560683e-02f, -4.41335559e-01f, 1.61725715e-01f, -2.68039793e-01f, -1.20488957e-01f,
  1.62045404e-01f, -4.75514270e-02f, -1.59539774e-01f, 2.42166803e-04f, -1.69920355e-01f, -2.91152567e-01f, -2.80735195e-01f, 1.60541698e-01f, -1.54811651e-01f, -7.93677866e-02f,
  1.80135220e-01f, 8.06866810e-02f, 2.63596233e-02f, 5.34981601e-02f, 1.34283558e-01f, 5.79688847e-02f, 2.20490135e-02f, 2.48718157e-01f, 9.39554255e-03f, -2.47672290e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.80315995e+00f, 1.60792875e+00f, 1.78839576e+00f, 1.88910210e+00f, 1.08708096e+00f, 1.93434882e+00f, 1.24598849e+00f, 9.95982409e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.73492056e-01f, 6.85113668e-02f, 4.41979885e-01f, 1.01925462e-01f, -4.24770564e-01f, -3.97405535e-01f, 1.51766479e+00f, -4.00776058e-01f, -8.98841858e-01f, -1.51710975e+00f,
  -1.24007392e+00f, 3.23353767e-01f, 9.18539464e-01f, -8.58651996e-01f, 1.28345942e+00f, -9.66574132e-01f, 2.71375570e-02f, -1.37540805e+00f, -4.77348059e-01f, 1.70354277e-01f,
  -1.28552556e+00f, -1.72315800e+00f, -1.65515280e+00f, 1.55875826e+00f, 7.98534453e-01f, -2.77982652e-01f, -1.24496424e+00f, 1.03815389e+00f, 1.13388143e-01f, -1.87500811e+00f,
  -2.33147934e-01f, -6.07044697e-01f, 2.89927810e-01f, -1.16980708e+00f, 1.75870340e-02f, 7.84676611e-01f, 3.28901470e-01f, -4.93595213e-01f, -1.24955642e+00f, -1.45682549e+00f,
  7.53942251e-01f, 5.02832651e-01f, -1.20549178e+00f, -1.65041721e+00f, -1.55283868e+00f, -6.23473585e-01f, 8.94783735e-01f, -5.61764121e-01f, -3.13169301e-01f, -1.15394783e+00f,
  -8.31714928e-01f, -1.30165374e+00f, 6.10813916e-01f, 5.87435186e-01f, 4.87614155e-01f, -2.03943625e-03f, -2.11237812e+00f, -6.42549619e-02f, 4.52311248e-01f, 1.55326813e-01f,
  4.85151738e-01f, -1.26245677e+00f, 3.67521554e-01f, 8.54226708e-01f, 6.78273812e-02f, 2.61192083e-01f, 4.70033318e-01f, 5.01566410e-01f, 8.52714002e-01f, 1.32126972e-01f,
  1.65488696e+00f, -1.83619487e+00f, -1.36721325e+00f, -7.37818360e-01f, 1.46105289e+00f, 2.36154929e-01f, -1.25848508e+00f, -8.55963156e-02f, 5.59914172e-01f, -6.34095073e-01f,
  6.41507506e-01f, 1.20372725e+00f, 1.30615973e+00f, 2.86514133e-01f, -1.36967063e+00f, 1.86990225e+00f, 2.77923405e-01f, 9.58915293e-01f, 5.76855429e-02f, -1.04101884e+00f,
  -1.09858930e+00f, 1.01499653e+00f, -5.04879832e-01f, 5.47889948e-01f, -1.00657916e+00f, -1.63584173e+00f, -1.73211384e+00f, 9.27310586e-01f, 5.59386499e-02f, -1.19201636e+00f,
  1.56586790e+00f, -4.91704732e-01f, -1.13825774e+00f, 3.76032889e-01f, -5.03312349e-01f, 9.08186674e-01f, -1.57567549e+00f, -9.24816072e-01f, -8.79093468e-01f, 9.49103117e-01f,
  -1.29096580e+00f, -1.28016606e-01f, -2.79008716e-01f, 5.28592646e-01f, -4.33775544e-01f, -1.01342380e-01f, -1.05000579e+00f, 5.04864931e-01f, -9.75398004e-01f, -1.11823368e+00f,
  -1.13198960e+00f, -1.24785078e+00f, 2.89705712e-02f, -1.36575711e+00f, 1.09300697e+00f, 5.51004946e-01f, -1.12052047e+00f, 4.79820549e-01f, -1.32264540e-01f, 4.76139843e-01f,
  -8.95328045e-01f, 5.54079294e-01f, -5.76724172e-01f, 1.18275189e+00f, 1.56246102e+00f, 7.59898067e-01f, 3.35921019e-01f, 1.31495953e+00f, -1.14929211e+00f, -1.01168072e+00f,
  -1.72131568e-01f, -1.14673579e+00f, -1.29871202e+00f, -1.20983458e+00f, 9.99558866e-01f, -1.55441552e-01f, 3.04593831e-01f, 5.34999311e-01f, 9.64920521e-01f, -9.55583870e-01f,
  -1.04320133e+00f, 1.38316429e+00f, 1.05175324e-01f, -1.63573480e+00f, 8.99906874e-01f, -1.98531425e+00f, -7.65479743e-01f, 7.44769454e-01f, 6.74251020e-02f, -1.20118618e+00f,
  4.62514788e-01f, 6.85729980e-01f, -7.08425492e-02f, -5.70882916e-01f, -4.73859906e-01f, 1.90856397e-01f, -3.43262196e-01f, -1.46755528e+00f, 3.93587321e-01f, 3.36345911e-01f,
  8.80260348e-01f, 2.20379040e-01f, 6.50014132e-02f, -1.25561130e+00f, -1.23773026e+00f, 2.89395545e-02f, -1.30548654e-02f, -5.78824401e-01f, -2.47704566e-01f, 8.24242234e-02f,
  7.88871467e-01f, 7.51259327e-01f, 8.35566759e-01f, 1.08330023e+00f, 4.23761576e-01f, -8.46222579e-01f, -1.19431865e+00f, -5.74771702e-01f, -1.63676798e+00f, -2.11216584e-01f,
  -5.14444828e-01f, 1.57568324e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.78512752e-01f, -2.71637887e-02f, 2.17430647e-02f, -9.16885614e-01f, 3.13039541e-01f, 4.78131384e-01f, 4.14414823e-01f, -1.37518808e-01f, 2.53774852e-01f, 4.43145335e-02f,
  -7.76602685e-01f, 9.87755358e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    