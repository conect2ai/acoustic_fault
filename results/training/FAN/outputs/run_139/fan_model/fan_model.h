/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.62281269e-01f, 1.07460506e-01f, -1.24522455e-01f, 1.00239992e-01f, 1.74118876e-01f, 8.39941055e-02f, 1.40168831e-01f, -2.06516199e-02f, 1.82893649e-02f, 8.87571052e-02f,
  8.30799416e-02f, 1.41435325e-01f, -7.97567070e-02f, 6.55717105e-02f, -7.34969378e-02f, -2.80164391e-01f, 8.08378980e-02f, 1.17531210e-01f, -9.93878487e-03f, 1.27192646e-01f,
  -9.75973159e-02f, 7.67935663e-02f, -1.82222292e-01f, 1.46357352e-02f, 1.57150045e-01f, 4.22294140e-02f, 1.04070583e-04f, -7.18882829e-02f, 2.32640170e-02f, 8.50263834e-02f,
  1.59340184e-02f, -5.30808046e-02f, -3.99647132e-02f, -4.25694697e-03f, 6.04690518e-03f, 1.18823439e-01f, 9.50295627e-02f, 1.96829084e-02f, -5.44056781e-02f, -5.29653281e-02f,
  8.49394500e-02f, 1.17363557e-02f, 5.49926646e-02f, -5.69529608e-02f, 1.28968403e-01f, -6.71381354e-02f, -1.51575468e-02f, -6.76929131e-02f, -6.24688994e-03f, 2.29159147e-02f,
  -4.59559681e-03f, -4.78249863e-02f, 5.59072196e-03f, -6.01335168e-02f, -4.05997075e-02f, 1.21842157e-02f, -7.89336786e-02f, 1.72424335e-02f, -4.22457755e-02f, 3.23125422e-02f,
  1.81374792e-02f, 5.50199358e-04f, -6.97889552e-02f, 1.51080368e-02f, -2.52388492e-02f, -9.03873821e-04f, 1.67003891e-03f, 5.47769442e-02f, 2.10216399e-02f, 6.04194589e-03f,
  4.66809943e-02f, -6.41001016e-02f, 2.26584412e-02f, 3.04301288e-02f, 2.53661927e-02f, 2.97122207e-02f, -2.13775877e-03f, -1.22103371e-01f, 1.00048833e-01f, -3.58763486e-02f,
  -1.68128125e-02f, 7.64301792e-02f, 1.66054666e-02f, 2.50708573e-02f, 4.45908345e-02f, -4.93869334e-02f, -4.41907346e-02f, -4.59690467e-02f, 3.15037668e-02f, -4.59180810e-02f,
  5.66333458e-02f, -4.61778753e-02f, -1.30320024e-02f, -1.29870325e-02f, -3.35699506e-02f, 2.64994223e-02f, 3.83260101e-02f, 3.78818214e-02f, -1.11209311e-01f, -8.94245058e-02f,
  1.46757275e-01f, 9.24668163e-02f, -5.53393476e-02f, 3.68908644e-02f, -3.41050774e-02f, 1.22789061e-02f, 3.35878581e-02f, -2.95181107e-02f, 4.63354178e-02f, 1.28142852e-02f,
  2.33761524e-03f, 5.86902238e-02f, 8.49271491e-02f, 6.77650347e-02f, 2.36624293e-02f, 5.34504429e-02f, 1.14859352e-02f, 5.89075536e-02f, -5.14245331e-02f, -3.90167348e-02f,
  3.70820433e-01f, -1.27248406e-01f, -8.21277201e-02f, 2.21018434e-01f, -1.22743435e-01f, 8.59868005e-02f, 8.89331326e-02f, -2.17756666e-02f, 2.22296268e-01f, -1.06765732e-01f,
  1.21666461e-01f, -1.45832275e-03f, 2.53767744e-02f, 2.16322377e-01f, 3.56270134e-01f, 8.03803727e-02f, 2.94034749e-01f, 7.16034099e-02f, 9.25270915e-02f, -7.91734710e-05f,
  1.73315048e-01f, 1.24695122e-01f, 1.25064626e-02f, -1.18738994e-01f, -6.25035390e-02f, -2.31242716e-01f, -8.08846354e-02f, -2.37889871e-01f, 9.33902711e-03f, -1.11848190e-02f,
  5.52744120e-02f, -6.14876337e-02f, -1.03479199e-01f, 2.29215249e-02f, -3.70863862e-02f, -3.59759033e-02f, -8.65503326e-02f, -8.80299543e-04f, 2.02644281e-02f, 5.26372083e-02f,
  -2.37863511e-02f, 1.03229145e-02f, 1.07560977e-01f, -1.76057569e-03f, 5.32844756e-03f, -1.60110444e-02f, 1.72957759e-02f, -1.60390642e-02f, -7.71914562e-03f, 5.34784161e-02f,
  9.45658365e-04f, 2.73888139e-03f, -1.93272587e-02f, -8.14687908e-02f, 1.01698987e-01f, 3.08766626e-02f, 7.72528024e-03f, -9.60493013e-02f, -2.07359232e-02f, -2.23049428e-02f,
  2.03965139e-02f, 5.54440869e-03f, 4.42099273e-02f, 1.94896739e-02f, 2.07728124e-03f, -1.81446318e-02f, 3.72894481e-02f, -5.67960413e-03f, -3.77326757e-02f, 5.34970239e-02f,
  1.30050899e-02f, -3.82288843e-02f, 8.03525671e-02f, 6.14045374e-02f, 4.19266485e-02f, -4.50250693e-02f, -5.11103757e-02f, -3.33170570e-03f, 3.71193364e-02f, -4.86761145e-02f,
  -6.47858530e-02f, 9.92816756e-04f, -8.79308507e-02f, 4.26209625e-03f, 5.26068266e-03f, -1.56803150e-02f, 4.06792089e-02f, -7.00136181e-03f, -3.82284261e-02f, -8.06720182e-03f,
  3.66499601e-03f, -6.99824095e-02f, -8.23030621e-02f, -1.64604448e-02f, -1.07240751e-01f, -4.37247679e-02f, 1.75022762e-02f, 5.98639250e-03f, 9.62686259e-03f, 2.49912273e-02f,
  -8.36704224e-02f, -4.70543876e-02f, -3.02605741e-02f, 5.06713539e-02f, 2.78767999e-02f, 5.47510851e-03f, -8.58010277e-02f, -7.81387836e-02f, -1.76152751e-01f, -7.20366742e-03f,
  -5.42227626e-02f, -7.71045089e-02f, 4.41949330e-02f, -4.11521196e-02f, -3.31128351e-02f, -8.74500796e-02f, -1.06100477e-01f, -5.67649752e-02f, -1.56241679e-03f, -1.77124981e-02f,
  -1.70813069e-01f, -2.95165665e-02f, 3.91973518e-02f, -9.16282013e-02f, -1.51623428e-01f, 4.57672998e-02f, 1.91616058e-01f, -1.62049308e-01f, 1.86643004e-01f, 7.56244510e-02f,
  -3.73373255e-02f, 2.34675080e-01f, 2.12049946e-01f, -1.00899609e-02f, 3.12684834e-01f, 2.28220567e-01f, 6.78296089e-02f, 5.83719239e-02f, 4.97653969e-02f, -4.99481428e-03f,
  -1.70613062e-02f, -1.28909171e-01f, -3.05774920e-02f, -2.70997673e-01f, -2.60514319e-01f, -1.46085143e-01f, -5.83418123e-02f, -7.62561560e-02f, -2.19341949e-01f, 1.28183728e-02f,
  5.10002077e-02f, 7.27812499e-02f, -3.56209986e-02f, -3.56596597e-02f, 2.89080180e-02f, -1.09332271e-01f, -7.74425734e-03f, 1.46325201e-01f, -2.10164506e-02f, 3.74596678e-02f,
  -6.35887496e-03f, -3.50365937e-02f, -8.90675467e-03f, 1.04686329e-02f, -3.14896815e-02f, 2.88273320e-02f, 3.26242335e-02f, -5.24622155e-03f, 3.25746089e-02f, -5.93772205e-03f,
  4.14206460e-02f, -3.55375446e-02f, -1.45649523e-01f, -3.99745218e-02f, 2.29402781e-02f, 3.52076925e-02f, -1.25592545e-01f, -7.82983378e-02f, 3.39015052e-02f, -5.14651835e-03f,
  -3.11057456e-02f, -1.95059463e-01f, -4.19257432e-02f, -4.14646678e-02f, 5.85078113e-02f, -8.04651678e-02f, 6.42850995e-02f, -3.03099118e-03f, 2.37697754e-02f, 5.06483987e-02f,
  -5.75828478e-02f, 6.87282300e-04f, -4.78400551e-02f, 3.45990956e-02f, -2.57546585e-02f, -7.69956037e-02f, 8.46917927e-02f, 4.37827632e-02f, 3.23198549e-02f, 3.90696228e-02f,
  1.86418239e-02f, 4.69465256e-02f, -2.44366401e-03f, -2.62351334e-02f, 4.92101237e-02f, -2.63022706e-02f, -8.77369791e-02f, 3.62312756e-02f, -4.13406081e-02f, -2.04651598e-02f,
  4.77392338e-02f, 4.50606011e-02f, -1.64597891e-02f, -1.25516942e-02f, 9.39847752e-02f, -5.62141575e-02f, 1.60179362e-02f, 4.10931148e-02f, -2.13344432e-02f, 1.01746641e-01f,
  -1.36853447e-02f, -6.30478412e-02f, 7.63819590e-02f, -2.03493126e-02f, 1.29065057e-02f, -6.35882393e-02f, -3.26537229e-02f, -4.29489240e-02f, -4.49842028e-03f, 2.46614739e-02f,
  1.16845844e-02f, 1.17964342e-01f, -1.40330512e-02f, -5.18510677e-02f, -4.22904231e-02f, 3.42522096e-03f, -6.68483004e-02f, -3.48156691e-02f, -6.43445030e-02f, -3.75074358e-03f,
  -2.02855408e-01f, -6.72477856e-02f, -7.59753585e-02f, -1.81838244e-01f, 3.19680721e-02f, 2.52912268e-02f, -4.13312903e-03f, -8.09023529e-02f, -9.57916304e-03f, -1.23456724e-01f,
  -8.23170021e-02f, -3.56714055e-02f, 2.18094274e-01f, -2.33075142e-01f, 5.35204597e-02f, 1.84908479e-01f, -1.39311224e-01f, -1.23290174e-01f, 2.32834257e-02f, -1.14020489e-01f,
  -7.00818282e-03f, -1.70240432e-01f, 2.65220497e-02f, -1.30459573e-02f, -1.70656040e-01f, -8.28599110e-02f, -7.75918439e-02f, 1.39074683e-01f, -2.15199903e-01f, -1.22478090e-01f,
  -1.53329419e-02f, 1.09703854e-01f, -9.89584476e-02f, 3.55270468e-02f, -2.70056794e-03f, 1.42284641e-02f, -6.15312569e-02f, 6.46766201e-02f, -8.04615021e-03f, 3.84312570e-02f,
  2.25967802e-02f, 1.28084654e-02f, -1.43639058e-01f, -1.39308972e-02f, -2.35689506e-02f, -1.11616552e-02f, -1.39146242e-02f, -7.21011385e-02f, 3.82060930e-02f, 3.40853408e-02f,
  7.77076781e-02f, 1.84134915e-02f, -4.81375568e-02f, 2.94981594e-03f, -1.24979228e-01f, 1.54584963e-02f, 1.26258448e-01f, 3.49860340e-02f, -8.95685032e-02f, 5.14893681e-02f,
  -5.27991913e-02f, 9.47242603e-02f, -8.98995530e-03f, 4.40298729e-02f, 4.14960086e-02f, 1.79403219e-02f, -4.28394377e-02f, 7.22336024e-03f, -1.79560930e-02f, -2.92461608e-02f,
  -3.32085863e-02f, 3.00325751e-02f, 5.00805583e-03f, 9.50438611e-04f, -1.38377538e-02f, -9.33518335e-02f, 1.58166401e-02f, 4.54377420e-02f, -2.85223238e-02f, -4.67615388e-02f,
  -2.69440073e-03f, 4.89659980e-02f, 1.02366628e-02f, -3.53697166e-02f, 1.19356439e-01f, -6.58744888e-04f, 4.70072329e-02f, -1.57750491e-02f, -2.94430535e-02f, 2.69210804e-02f,
  9.33136977e-03f, -3.81455105e-03f, 4.20281589e-02f, 1.82866007e-02f, 3.02089583e-02f, 6.50692061e-02f, -2.67017372e-02f, -2.52164211e-02f, 4.49193157e-02f, 7.16776699e-02f,
  -1.65024921e-01f, -6.57385439e-02f, -1.03289923e-02f, -7.21883774e-02f, -2.38646958e-02f, -3.07456031e-02f, 4.43073362e-02f, -8.01120698e-03f, -3.13317701e-02f, -6.70075119e-02f,
  -2.01307400e-03f, -4.55117039e-02f, -8.38934351e-03f, -1.37797091e-03f, -4.41678427e-02f, 3.42339091e-03f, -3.55288610e-02f, 3.82594801e-02f, -4.28505018e-02f, -2.76053660e-02f,
  -1.13207221e-01f, -1.16770625e-01f, 3.16300213e-01f, -1.80326983e-01f, -7.66870305e-02f, 1.62068084e-02f, 1.63056888e-02f, 7.95783624e-02f, 1.05824396e-01f, -5.82434498e-02f,
  -6.67493045e-02f, -2.45450046e-02f, 1.09380350e-01f, -1.76407516e-01f, 1.45899221e-01f, 1.30414173e-01f, -8.91428813e-02f, -1.05609804e-01f, -6.77923113e-02f, -5.93695231e-02f,
  5.49240932e-02f, -5.00400774e-02f, -2.29904652e-02f, -5.89220524e-02f, 4.88922140e-03f, -1.22318842e-01f, -1.89045489e-01f, 2.33532209e-02f, -1.35663167e-01f, -1.21396845e-02f,
  -1.44880891e-01f, 2.44716872e-02f, -2.66537577e-01f, -2.55848952e-02f, -9.97441188e-02f, -4.11973707e-02f, 2.23261919e-02f, 1.68046989e-02f, -1.29662514e-01f, 2.89620878e-03f,
  1.54097797e-03f, 9.61120501e-02f, -5.58429249e-02f, -5.23607545e-02f, -5.24431886e-03f, -1.80548448e-02f, -1.17873913e-02f, -1.05833195e-01f, -2.16003582e-02f, 5.54661863e-02f,
  -7.61055499e-02f, -4.84125912e-02f, 8.39628093e-03f, -2.66142394e-02f, 7.32264901e-03f, -7.72292390e-02f, -1.99184977e-02f, 3.71039589e-03f, -1.89242542e-01f, 3.05249589e-03f,
  9.07953754e-02f, 6.20363047e-03f, -5.05527109e-02f, -6.03143685e-02f, 8.01197514e-02f, -1.88340042e-02f, 1.00601139e-02f, 4.23634890e-03f, -6.05445504e-02f, 9.94602218e-02f,
  2.78896261e-02f, -5.82590066e-02f, 9.46807563e-02f, -5.77505194e-02f, -9.40487608e-02f, -3.94776426e-02f, -4.73494045e-02f, 5.41802756e-02f, -9.62089468e-03f, -7.95979351e-02f,
  9.10098404e-02f, 2.73684114e-02f, 3.22067849e-02f, -1.61804259e-01f, -7.92029873e-02f, -2.19429694e-02f, -6.00390360e-02f, 5.95956780e-02f, -4.70839478e-02f, -2.87002213e-02f,
  -6.26174212e-02f, 4.67058122e-02f, -8.95330310e-02f, 8.55207723e-03f, -4.90701981e-02f, -1.97910458e-01f, 4.70167175e-02f, -8.07113498e-02f, -4.19715419e-02f, 6.79211095e-02f,
  -4.95267957e-02f, -1.93863665e-03f, 8.07094723e-02f, -1.38827590e-02f, -4.38680351e-02f, -9.65469405e-02f, -9.03665572e-02f, -4.27215695e-02f, -1.26023844e-01f, -4.30729724e-02f,
  -8.71570557e-02f, -3.18925194e-02f, 1.14548773e-01f, -1.22375570e-01f, -5.83612360e-02f, -6.60724640e-02f, 1.11512393e-02f, 6.76224800e-03f, -3.14124227e-02f, -6.62903711e-02f,
  3.18768136e-02f, -2.54761785e-01f, 1.62086174e-01f, -1.02700844e-01f, 7.87840784e-02f, -2.28195399e-01f, -8.02433342e-02f, -1.72466531e-01f, -3.06667630e-02f, -2.20433965e-01f,
  -2.78888363e-03f, 3.82357538e-02f, -1.16451927e-01f, -2.04202533e-01f, 1.92852274e-01f, -5.25531583e-02f, -1.44995242e-01f, 3.48935202e-02f, 1.40884134e-03f, -8.06468353e-02f,
  1.18549339e-01f, -1.70928836e-01f, 1.10602133e-01f, 3.65329161e-02f, -1.23244114e-01f, 7.07491115e-02f, 5.00254743e-02f, 1.33776456e-01f, -9.06157307e-03f, 7.93713331e-02f,
  -1.43366724e-01f, -2.39609499e-02f, 1.21393809e-02f, 9.66820214e-03f, -8.37710723e-02f, -6.71445876e-02f, 7.73832574e-02f, 1.21697441e-01f, 1.22185968e-01f, -1.11965491e-02f,
  1.27210692e-02f, -1.83278788e-02f, -4.26908284e-02f, -3.63039263e-02f, -5.76566383e-02f, 7.69588025e-03f, -9.51567944e-03f, -1.98057550e-03f, -2.49463208e-02f, -1.72767024e-02f,
  -2.41656452e-02f, -8.36240873e-02f, 6.50311708e-02f, 2.63105724e-02f, 4.43411479e-03f, -7.08705857e-02f, 1.97560824e-02f, 1.36844948e-01f, -6.51890561e-02f, 1.86911672e-02f,
  1.13941923e-01f, 8.09371751e-03f, -5.62095977e-02f, -8.69894177e-02f, 6.95716916e-03f, -7.54842907e-02f, -1.11619771e-01f, 2.77375039e-02f, -2.07813103e-02f, -7.01550022e-02f,
  -4.20945846e-02f, 9.57700016e-04f, -7.23224282e-02f, -1.90617125e-02f, -3.98103558e-02f, 4.13631871e-02f, -7.18409801e-03f, -2.68486924e-02f, -2.04295330e-02f, -9.47314315e-03f,
  5.30123077e-02f, -1.87990516e-02f, -5.40065430e-02f, -3.84080634e-02f, -6.98576421e-02f, 5.08785136e-02f, -8.92534852e-02f, -1.53768538e-02f, 3.94252595e-03f, 9.33526456e-02f,
  -3.21493655e-01f, -1.60141721e-01f, -2.66923942e-02f, -6.79555237e-02f, -6.73871441e-03f, -2.41246284e-03f, -2.78931540e-02f, -2.85345819e-02f, -1.58954579e-02f, -3.74474637e-02f,
  -9.05281082e-02f, -3.03569734e-02f, 2.08391510e-02f, 2.64938790e-02f, 1.22474404e-02f, -1.06798880e-01f, -6.53892905e-02f, -8.39219093e-02f, -3.43113244e-02f, -5.25010843e-03f,
  -1.44886509e-01f, -2.91713681e-02f, 6.07839972e-02f, 2.81844120e-02f, 1.08125284e-01f, 2.30918657e-02f, -6.95958510e-02f, 7.06066862e-02f, 4.39482257e-02f, -3.66559476e-02f,
  1.15416683e-01f, -9.03666168e-02f, 1.26721799e-01f, -1.55185699e-01f, 1.04989246e-01f, 4.21392143e-01f, 1.84598297e-01f, 9.86862928e-02f, -3.05189461e-01f, -1.84944525e-01f,
  -1.52930701e-02f, -1.58744991e-01f, 2.10198332e-02f, -3.35044861e-02f, 1.73507139e-01f, -7.80722797e-02f, 2.29101747e-01f, 6.99009299e-02f, -4.09653550e-03f, 6.21389598e-02f,
  9.90397781e-02f, -6.19635470e-02f, 8.50691125e-02f, 3.42743285e-02f, 1.39301136e-01f, 7.23418640e-03f, -1.12526499e-01f, 4.08955030e-02f, 9.69747379e-02f, -4.97434475e-02f,
  4.62066606e-02f, -7.80145675e-02f, 5.46866953e-02f, 9.91592649e-03f, 1.87964663e-01f, 1.06930092e-01f, 2.16850825e-02f, -9.02306810e-02f, 6.49205223e-02f, -4.70075347e-02f,
  1.52075244e-02f, -4.49793115e-02f, 3.93258557e-02f, -1.04072228e-01f, 6.05032779e-02f, -7.22937509e-02f, 2.97677591e-02f, 1.48772508e-01f, 1.09450426e-02f, 4.24133167e-02f,
  1.19226143e-01f, 5.15451171e-02f, 1.33595511e-01f, -4.01521213e-02f, 5.95825203e-02f, 2.25494895e-02f, -4.04607989e-02f, -1.74630638e-02f, -6.63664704e-03f, -1.18201695e-01f,
  -8.40990320e-02f, 9.83893201e-02f, 3.68466675e-02f, -8.33173171e-02f, -6.94123730e-02f, -1.52446210e-01f, 2.88832188e-03f, -7.71734938e-02f, -3.45903747e-02f, 5.08795120e-02f,
  -5.01088612e-03f, -5.48415668e-02f, 1.31884208e-02f, 3.62050459e-02f, -7.98885822e-02f, -9.91676003e-02f, 4.01367806e-02f, -3.82377133e-02f, -1.32355874e-03f, 1.06542557e-01f,
  -6.59709573e-02f, -6.76629134e-03f, -8.33800528e-03f, 1.27573144e-02f, 2.85054371e-02f, -9.44074094e-02f, 3.82521749e-02f, -3.01070022e-03f, -4.58666533e-02f, 1.06630459e-01f,
  2.49412060e-02f, -7.37620965e-02f, 4.42564264e-02f, -3.54184944e-04f, -3.20251584e-02f, 8.53926595e-03f, -2.11749505e-02f, 1.35700395e-02f, -4.18858230e-02f, 6.72306195e-02f,
  -2.98289619e-02f, -9.93907731e-03f, 5.64665534e-02f, 5.60862804e-03f, 1.52330603e-02f, -4.14066724e-02f, -5.97964451e-02f, -1.67571735e-02f, -1.26788560e-02f, 5.40016294e-02f,
  4.00479808e-02f, 2.56474409e-02f, -1.16333999e-01f, 3.21145654e-02f, 8.38163272e-02f, -1.78793794e-03f, 4.47659707e-03f, -2.40736548e-02f, 9.49944556e-02f, -2.62822788e-02f,
  2.52642304e-01f, -7.28058964e-02f, -2.34893318e-02f, 1.22825064e-01f, 1.05087407e-01f, -1.24339581e-01f, -2.22308964e-01f, 1.45674823e-02f, 7.89084733e-02f, -2.69286074e-02f,
  9.28525776e-02f, -3.31146456e-02f, -2.78073877e-01f, 8.45400468e-02f, -2.89911240e-01f, -1.38481393e-01f, 6.94843195e-03f, 2.94870958e-02f, -8.21534991e-02f, 1.34042412e-01f,
  3.31256166e-02f, 5.03368638e-02f, -2.20079929e-01f, -3.37101966e-02f, 9.63358358e-02f, 1.30731359e-01f, 9.88951549e-02f, -1.12017617e-01f, 1.14137724e-01f, -1.69649437e-01f,
  -5.88408299e-02f, 1.45188160e-02f, -1.95903964e-02f, -1.23857535e-01f, 6.53479546e-02f, 1.18647993e-01f, 2.95601673e-02f, -5.68055660e-02f, -2.54676188e-03f, 1.98069072e-04f,
  -1.22340051e-02f, -2.44396478e-02f, 8.08533952e-02f, -7.21111475e-03f, 2.77737547e-02f, 4.65451293e-02f, 9.75560248e-02f, 1.31718189e-01f, 2.85093412e-02f, 4.05139290e-02f,
  1.31077796e-01f, 3.22896205e-02f, 6.99426234e-02f, -5.27703576e-02f, 1.10249463e-02f, 8.12448263e-02f, -6.25969246e-02f, 1.30227329e-02f, -1.06149176e-02f, -2.91536679e-03f,
  4.21249941e-02f, 8.41367431e-03f, -6.46927208e-02f, 7.82501232e-03f, -1.57844052e-02f, 3.67195830e-02f, 1.26978820e-02f, 3.76581848e-02f, -8.01456813e-03f, -6.58149971e-03f,
  -4.87352125e-02f, 3.11759301e-02f, -6.52779173e-03f, 5.15042208e-02f, -4.22887392e-02f, 2.10246276e-02f, -2.61651352e-03f, 1.09707806e-02f, 5.69925383e-02f, 2.15471722e-02f,
  -5.95102459e-02f, -6.32851571e-02f, -5.50071374e-02f, -5.27109466e-02f, -1.92337614e-02f, -2.08149571e-02f, 8.93596485e-02f, 4.42102514e-02f, 2.36768811e-03f, -2.61736801e-03f,
  3.47426645e-02f, -4.68714014e-02f, -1.33755714e-01f, -4.25764658e-02f, -1.04767904e-02f, -1.22972392e-02f, -1.42980795e-02f, 6.90712333e-02f, -1.34743005e-01f, 1.39073441e-02f,
  1.12422109e-01f, -1.29176388e-02f, 2.78279139e-03f, -2.67330799e-02f, -1.42655559e-02f, -3.82664911e-02f, -1.02368193e-02f, -1.05869127e-02f, 9.96152684e-03f, -1.77693926e-03f,
  8.80423933e-02f, 6.16717301e-02f, 3.78004238e-02f, -6.37269095e-02f, 4.16509621e-02f, -9.68343206e-03f, 5.35883866e-02f, -3.17161344e-02f, 5.36021441e-02f, -3.08667440e-02f,
  1.76002756e-01f, 2.44358361e-01f, 2.16051906e-01f, 2.05597803e-01f, 2.08952472e-01f, 7.96898082e-02f, 6.28396422e-02f, 2.22406209e-01f, 2.85696447e-01f, -1.98309988e-01f,
  -1.65874749e-01f, 3.62515412e-02f, -1.93396494e-01f, 1.90368459e-01f, -1.33803293e-01f, -4.47732471e-02f, 1.43290401e-01f, 7.12642446e-02f, 1.94900259e-01f, 4.36701179e-02f,
  1.21956594e-01f, -1.25066414e-01f, -1.15529999e-01f, 2.56350599e-02f, 8.97189677e-02f, 5.29198907e-02f, -2.01149240e-01f, -1.28484024e-02f, -4.43838201e-02f, 2.97994446e-02f,
  8.56402814e-02f, 4.90740426e-02f, 1.98141206e-02f, -7.09138140e-02f, 4.61091027e-02f, 6.46722913e-02f, 1.01494156e-02f, -2.08145026e-02f, -1.07190991e-03f, -1.67707000e-02f,
  -1.45993054e-01f, -9.57261249e-02f, 7.98838213e-03f, 3.25335227e-02f, 7.35019892e-02f, 3.73462774e-02f, 6.07632287e-02f, 5.16419038e-02f, 8.95817950e-02f, 9.23090987e-03f,
  -2.54013240e-02f, -4.48894920e-03f, -7.11958930e-02f, 1.03194812e-04f, 1.40364431e-02f, 1.71727072e-02f, -7.35982656e-02f, -1.18431877e-02f, 3.37515622e-02f, 5.74461594e-02f,
  -6.36381805e-02f, 8.93337503e-02f, -9.63610481e-04f, 9.88461822e-03f, 7.57846460e-02f, 1.51887373e-03f, -8.84818360e-02f, -2.61325971e-03f, 4.73296307e-02f, -7.42904982e-03f,
  -4.70888317e-02f, -4.01406316e-03f, 7.95287266e-03f, 5.81118241e-02f, -2.15506945e-02f, 4.33185771e-02f, -3.38644795e-02f, -3.01270951e-02f, 6.69919774e-02f, 1.66730899e-02f,
  3.67054716e-02f, 2.16769706e-02f, -3.21619175e-02f, -1.35033801e-02f, 4.55334038e-02f, -2.57540103e-02f, -3.07378937e-02f, 1.18472129e-02f, 7.14620389e-03f, -4.98773307e-02f,
  6.59344310e-04f, 7.91274011e-02f, -1.69663459e-01f, -6.76996335e-02f, 2.63422076e-02f, -9.12722498e-02f, -1.23173213e-02f, 3.77556239e-03f, 2.78939251e-02f, 2.38299984e-02f,
  3.60846031e-03f, -6.48617372e-02f, 2.12490465e-03f, -2.12837495e-02f, -5.67890629e-02f, -7.70990625e-02f, -1.02117043e-02f, 3.66999581e-02f, 3.21721435e-02f, 2.00796104e-03f,
  -6.83025047e-02f, -7.77524933e-02f, 3.91868353e-02f, -1.08378576e-02f, -5.08852862e-02f, -4.74308394e-02f, -3.59101705e-02f, 2.70550940e-02f, -3.67179662e-02f, 3.40023786e-02f,
  2.45107129e-01f, -1.81090027e-01f, -1.52681932e-01f, -1.60201848e-01f, -1.37882959e-02f, -6.78460374e-02f, -1.19304091e-01f, -1.62394032e-01f, 1.14884138e-01f, -8.64622369e-02f,
  -9.71991196e-02f, 5.21764942e-02f, 1.12715229e-01f, -1.89704359e-01f, 9.23480615e-02f, 1.05498075e-01f, -6.60257414e-02f, -3.48421670e-02f, 1.25537738e-01f, 1.80807319e-02f,
  -5.26694134e-02f, -1.08737007e-01f, -1.08812742e-01f, -4.20129858e-02f, -3.49752642e-02f, 1.61531300e-03f, -6.33057132e-02f, -2.73183379e-02f, -2.33203262e-01f, -1.12205178e-01f,
  -3.91603559e-02f, -8.00239369e-02f, -7.11236671e-02f, -8.76734182e-02f, 3.69349234e-02f, 5.66095151e-02f, -7.30265165e-03f, -5.57890802e-04f, 4.13049124e-02f, -3.10325492e-02f,
  -6.67913482e-02f, 4.29157019e-02f, -4.09256816e-02f, 1.14425480e-01f, 9.09095481e-02f, -6.46680295e-02f, -6.28131479e-02f, -2.01523639e-02f, -6.38166964e-02f, 1.33692160e-01f,
  1.90227991e-03f, -8.06922689e-02f, -6.36033416e-02f, -7.25764632e-02f, -4.74607572e-02f, -6.20945282e-02f, -2.41971128e-02f, 2.10032463e-02f, 2.20862422e-02f, 1.21162729e-02f,
  1.03438504e-01f, -5.98145137e-03f, -1.19986229e-01f, -1.29466593e-01f, 4.58671665e-03f, -2.05275230e-02f, -8.64499062e-03f, -5.28598391e-02f, -9.79485437e-02f, -8.41712393e-03f,
  -8.41871575e-02f, -3.65314484e-02f, -3.11255474e-02f, -3.11108492e-02f, -1.02121651e-01f, -9.70927477e-02f, -4.10448611e-02f, -4.97534871e-02f, 5.73718809e-02f, -9.71338153e-02f,
  5.05934879e-02f, 1.17452770e-01f, -3.00137624e-02f, -2.74031069e-02f, 9.57602113e-02f, -1.47187989e-02f, -1.05968833e-01f, -8.60861540e-02f, -2.15253569e-02f, -5.93891330e-02f,
  2.53791343e-02f, -4.02742326e-02f, -4.88423705e-02f, -1.30519733e-01f, -9.54097603e-03f, 4.17574076e-04f, -9.71132517e-02f, -2.01848038e-02f, 1.34471301e-02f, -1.32086175e-03f,
  -6.83710026e-03f, -1.15176989e-02f, -5.35968915e-02f, -7.81014040e-02f, 6.01845384e-02f, 1.80070549e-02f, 5.17353974e-02f, -2.82835048e-02f, -1.93916319e-03f, -3.04677486e-02f,
  -1.03216276e-01f, 2.26920396e-02f, -1.48747265e-02f, -4.51746676e-03f, -3.90732922e-02f, -6.59701079e-02f, 8.17116424e-02f, 1.28114177e-02f, -1.73974745e-02f, -6.66685998e-02f,
  -4.26172733e-01f, 3.97325188e-01f, -1.66081870e-03f, 1.56530440e-01f, -2.97173291e-01f, -2.84928769e-01f, 2.50839777e-02f, -9.65841711e-02f, -3.10235727e-03f, 1.50097087e-01f,
  -1.24705337e-01f, 1.08619750e-01f, 1.40386835e-01f, 1.76085100e-01f, -1.53569475e-01f, 2.79912114e-01f, -8.21067318e-02f, 1.23712830e-02f, 2.46186238e-02f, -1.12596015e-02f,
  -1.01873651e-01f, -1.81839421e-01f, 7.16767535e-02f, 1.36455533e-03f, -8.10604021e-02f, 3.41457059e-03f, -8.16821381e-02f, 4.74753901e-02f, -4.22888659e-02f, -6.68665096e-02f,
  -6.20522574e-02f, 7.40398169e-02f, -1.09246194e-01f, 5.35840541e-02f, -9.55464914e-02f, -6.15879782e-02f, -1.01881595e-02f, 4.30293418e-02f, -7.65496120e-02f, -6.55756220e-02f,
  -3.61922309e-02f, -5.14965355e-02f, -8.67780596e-02f, -4.21054522e-03f, -3.98904793e-02f, -2.21085921e-02f, 3.36150825e-02f, -2.70381942e-02f, 6.57979101e-02f, 7.92784709e-03f,
  1.43407602e-02f, 3.24330442e-02f, -9.33257956e-03f, 7.45760873e-02f, -1.50978370e-02f, -4.69290428e-02f, 1.27736647e-02f, 4.42749299e-02f, -3.59916799e-02f, -4.99783270e-02f,
  -1.24926955e-01f, 5.71429469e-02f, 2.87255161e-02f, 8.98944363e-02f, -4.38611815e-03f, -7.70141259e-02f, -2.55619898e-03f, 7.31797144e-02f, 1.21281892e-01f, 1.55254500e-02f,
  -7.94054344e-02f, 5.02144136e-02f, 1.22285962e-01f, 4.81306203e-02f, -4.08982038e-02f, -2.55194958e-02f, 5.15831783e-02f, 5.62308822e-03f, 3.82964239e-02f, -1.14453053e-02f,
  7.62381107e-02f, -5.54908887e-02f, 4.10491265e-02f, 2.45494582e-02f, 3.72728333e-02f, 1.34419845e-02f, 5.84065095e-02f, 4.31066193e-02f, -3.64915089e-04f, -3.57274786e-02f,
  -2.12847069e-02f, 6.81877881e-02f, 8.06917623e-02f, 5.88821582e-02f, 1.36374056e-01f, 6.92571551e-02f, 8.70057642e-02f, -1.10553615e-02f, 4.44235688e-04f, -2.98112370e-02f,
  -7.86681697e-02f, 2.67263446e-02f, -9.74064460e-05f, 4.53208387e-02f, -6.14024214e-02f, -3.72771323e-02f, -1.65300649e-02f, 4.04573455e-02f, -6.51901960e-02f, -2.72194035e-02f,
  1.21205766e-02f, -6.48670346e-02f, 3.01334038e-02f, -6.06978759e-02f, -6.68820962e-02f, 1.91303380e-02f, -5.61793894e-02f, -3.60964425e-02f, -4.62141111e-02f, 4.66715433e-02f,
  -1.72551498e-02f, -1.09106749e-01f, -1.97623987e-02f, -2.35405907e-01f, -8.28806460e-02f, 2.50697970e-01f, 1.67104706e-01f, -8.30817670e-02f, -4.62505780e-02f, -7.59788007e-02f,
  1.71107993e-01f, -1.29695609e-01f, 3.26809108e-01f, -6.28498569e-02f, 2.71352857e-01f, 2.95167774e-01f, 1.48300231e-01f, 1.28211945e-01f, -6.28701299e-02f, -1.53844684e-01f,
  -1.91914719e-02f, -6.56908378e-02f, -6.69273734e-02f, -1.75305769e-01f, -2.53557026e-01f, -1.71637625e-01f, -1.20477863e-01f, -1.83579307e-02f, -8.54577869e-02f, 5.62826991e-02f,
  4.07384820e-02f, -3.42549309e-02f, -6.16317391e-02f, 3.71125489e-02f, 4.62482385e-02f, 2.04641018e-02f, 1.22857122e-02f, -1.50638195e-02f, 1.01171108e-02f, -1.51033625e-02f,
  9.10497829e-02f, -1.58799510e-03f, -2.18429938e-02f, -9.25413296e-02f, -8.52193683e-02f, -1.48884624e-01f, -5.81199080e-02f, -1.10345773e-01f, -7.12648109e-02f, -1.55780548e-02f,
  2.49301232e-02f, -2.67585553e-02f, 1.25272349e-01f, 1.07084855e-01f, -6.72887191e-02f, -1.97721310e-02f, -1.92545540e-05f, 7.32703432e-02f, -4.09722030e-02f, 3.64698237e-03f,
  6.47185147e-02f, -3.56415361e-02f, 2.15092357e-02f, -8.37771408e-03f, 1.14296466e-01f, -2.48841960e-02f, 1.31251486e-02f, -5.38936779e-02f, -8.18201248e-03f, -5.72973378e-02f,
  -8.62916466e-03f, -1.48719862e-01f, 1.47905014e-02f, -5.95780797e-02f, -4.36426029e-02f, 2.07336657e-02f, -6.05443399e-03f, 2.71061412e-03f, 4.13219854e-02f, -8.48101005e-02f,
  -4.69797775e-02f, 1.26460090e-01f, -3.75930071e-02f, -3.03854123e-02f, 3.20293605e-02f, -8.22745170e-03f, -6.22744933e-02f, -5.39002120e-02f, 3.47235948e-02f, -7.17819333e-02f,
  1.25583038e-01f, 1.20982386e-01f, 4.19858582e-02f, -9.18836966e-02f, 1.23647749e-01f, 2.21391078e-02f, -1.46009028e-02f, -3.93416248e-02f, 7.74767697e-02f, 6.15847036e-02f,
  2.73055527e-02f, 5.40551788e-04f, 3.04111134e-04f, -6.07686080e-02f, 7.96836801e-03f, -8.25299248e-02f, 9.58090052e-02f, 5.62558398e-02f, -4.13990133e-02f, -6.02130517e-02f,
  9.60227009e-03f, 1.02306582e-01f, 1.05987281e-01f, -6.02190150e-04f, -5.57453632e-02f, 4.54159901e-02f, 3.52874212e-02f, -6.34623840e-02f, 6.25846088e-02f, 3.73213589e-02f,
  -1.08531497e-01f, 3.38817760e-02f, 3.65017056e-02f, -2.14122295e-01f, -5.57651669e-02f, -2.73374379e-01f, -2.89460003e-01f, -4.75453436e-02f, -3.70179474e-01f, 3.35779898e-02f,
  -1.99385077e-01f, 5.54758236e-02f, 9.91319567e-02f, -2.89951593e-01f, -2.50226974e-01f, -1.86147898e-01f, -3.03495318e-01f, -8.66411328e-02f, -1.39109433e-01f, 6.59845173e-02f,
  -1.62484899e-01f, -1.33949548e-01f, 1.61325768e-01f, 1.68309674e-01f, -1.37230024e-01f, 1.29792660e-01f, 2.11353913e-01f, 1.29476175e-01f, 5.72787561e-02f, -2.17915364e-02f,
  -9.72993448e-02f, -1.37135265e-02f, 8.10087919e-02f, 2.19593048e-02f, 9.01122317e-02f, 6.03954382e-02f, 8.05081725e-02f, -4.06761877e-02f, 6.76530376e-02f, -4.24974458e-03f,
  3.42869461e-02f, 6.38332292e-02f, -8.81155729e-02f, -1.77040361e-02f, 5.50266879e-04f, 2.64566131e-02f, -6.82725012e-02f, -1.54967785e-01f, 1.57249272e-02f, 9.64208040e-03f,
  -6.67861030e-02f, 2.41279211e-02f, 4.15593572e-02f, -5.36900107e-03f, 3.77049524e-04f, -4.89414930e-02f, -2.93513648e-02f, 3.87622342e-02f, -1.11897610e-01f, 1.06962752e-02f,
  7.26114353e-03f, 6.79144114e-02f, 6.68018237e-02f, -5.87394740e-03f, 3.88183594e-02f, 8.37998763e-02f, -2.71669216e-02f, -1.00086804e-03f, -1.77472401e-02f, -6.01833686e-02f,
  -3.64931226e-02f, -3.58084552e-02f, -7.68783614e-02f, 6.29687980e-02f, -3.64011303e-02f, -6.22703545e-02f, 3.83458138e-02f, -1.82301216e-02f, -5.08128181e-02f, -7.61519372e-02f,
  -1.43435691e-02f, 7.23012835e-02f, 5.24601787e-02f, 8.79925415e-02f, -3.52274962e-02f, 6.71265498e-02f, 3.31801996e-02f, -2.83271726e-02f, 2.26094536e-02f, 4.47903760e-02f,
  -7.66125470e-02f, 4.16175835e-02f, -3.10581326e-02f, 3.78849404e-03f, -2.36460026e-02f, 1.08556725e-01f, -6.79632947e-02f, 8.41618422e-03f, 4.01941538e-02f, 1.25231430e-01f,
  8.51450861e-02f, 8.24138150e-02f, 8.90679657e-02f, 2.06901450e-02f, -4.27228101e-02f, -4.76695225e-02f, 5.27665615e-02f, 1.03332484e-02f, -3.76341455e-02f, 6.99826404e-02f,
  6.27482459e-02f, -2.57594343e-02f, -5.53882346e-02f, 8.83014593e-03f, 1.44404098e-02f, 6.89509362e-02f, -1.64782181e-02f, 9.51657444e-02f, -1.59329642e-02f, -4.85769659e-02f,
  2.91896332e-02f, -4.46169823e-02f, -1.92347690e-01f, -9.96280983e-02f, 9.30153728e-02f, 7.05890730e-02f, -8.26514587e-02f, 1.80478364e-01f, 1.87373802e-01f, 1.04227103e-01f,
  2.49695987e-01f, -1.83116347e-01f, 1.05494305e-01f, -1.06682137e-01f, -2.97023594e-01f, -9.04130861e-02f, -8.23485553e-02f, -1.82578802e-01f, -4.42565382e-02f, -2.91390903e-02f,
  -6.04545511e-02f, -6.03845008e-02f, -2.81954229e-01f, 1.66465305e-02f, -1.07711665e-01f, -2.35924441e-02f, -9.28830653e-02f, -1.11655168e-01f, -1.14341527e-01f, -5.36700198e-03f,
  1.39166892e-01f, 1.45037711e-01f, -2.74468139e-02f, 2.04247842e-03f, -5.40914573e-02f, -2.25103390e-03f, -1.26697510e-01f, -1.45796075e-01f, 1.65579394e-02f, 1.05495946e-02f,
  2.33663525e-03f, -4.84837741e-02f, 7.38798454e-02f, -1.55655295e-02f, -5.43141849e-02f, 5.95301986e-02f, 2.01142188e-02f, 7.23938718e-02f, 3.52121778e-02f, -5.70644550e-02f,
  -4.81319759e-04f, -8.84051770e-02f, -4.05628160e-02f, 2.30160076e-02f, 1.18171625e-01f, 7.34123737e-02f, -1.49673149e-01f, -1.16223536e-01f, -1.39964567e-02f, -2.46749800e-02f,
  6.35425076e-02f, -6.23623617e-02f, -6.86135069e-02f, -5.36776967e-02f, 4.98458557e-02f, 3.72382924e-02f, 4.51970473e-03f, 8.96054730e-02f, -8.62893835e-02f, -9.55540761e-02f,
  -8.80682934e-03f, -3.91777307e-02f, 1.91145986e-02f, -1.64907407e-02f, 3.63380164e-02f, 6.87986091e-02f, 1.13868248e-02f, -2.50422806e-02f, 3.18754744e-03f, -2.14563590e-02f,
  1.02653161e-01f, -3.24615501e-02f, 4.26664017e-03f, -6.82483613e-03f, 1.05699070e-01f, 1.19394762e-03f, 2.99049206e-02f, 6.90449635e-03f, -4.75581363e-02f, -5.14764339e-02f,
  1.15594864e-02f, 4.59760092e-02f, -3.92102823e-02f, 3.70623469e-02f, 2.12401226e-02f, -2.15987340e-02f, -8.35150182e-02f, -3.20475623e-02f, 5.87138459e-02f, -7.45997429e-02f,
  7.84334093e-02f, -1.98899675e-02f, -1.11318149e-01f, 6.27882034e-03f, -5.95493689e-02f, -1.50302853e-02f, 3.11182775e-02f, 6.35861754e-02f, 4.59027998e-02f, 4.64169588e-03f,
  1.53612634e-02f, -1.26129631e-02f, -6.00178577e-02f, 1.28246948e-01f, -1.92498639e-02f, -4.33743633e-02f, -3.26641575e-02f, 2.13109497e-02f, -3.91846634e-02f, 2.92583462e-02f,
  -3.82411569e-01f, -5.11881784e-02f, -9.00414139e-02f, -1.83490053e-01f, -1.22213457e-02f, 5.01309745e-02f, 1.41583204e-01f, -1.46742061e-01f, 8.74133781e-02f, 1.58969820e-01f,
  -9.58547816e-02f, -7.20263086e-03f, 1.72258034e-01f, 4.56123687e-02f, -9.96166393e-02f, 1.51803613e-01f, -1.27700716e-02f, -3.24125364e-02f, 3.87303308e-02f, -1.68899879e-01f,
  -1.60837293e-01f, -1.28676817e-01f, -7.94396326e-02f, -1.06387004e-01f, -1.47164434e-01f, -1.69387102e-01f, -2.11085007e-02f, 6.68559372e-02f, -1.33845732e-01f, -1.04388937e-01f,
  -9.86188948e-02f, -6.95365965e-02f, -7.07088560e-02f, 8.87123961e-03f, -1.36919737e-01f, -1.03318878e-02f, -2.80533526e-02f, -1.98024474e-02f, 3.68527658e-02f, -8.17322880e-02f,
  5.59568666e-02f, -1.26412616e-03f, -1.02802671e-01f, 9.86973289e-03f, 9.66513008e-02f, 1.05724350e-01f, -4.14385088e-02f, 4.67449315e-02f, 2.88789906e-02f, -1.16782077e-01f,
  6.75407946e-02f, 1.08114081e-02f, 3.51905935e-02f, 1.70279779e-02f, -2.55577546e-02f, -1.06485169e-02f, 1.19308971e-01f, -5.30630834e-02f, -5.89528941e-02f, -6.58422858e-02f,
  6.72630817e-02f, 3.09929159e-02f, 7.75515288e-02f, -8.78398344e-02f, -1.27463080e-02f, 1.37853958e-02f, 1.05442233e-01f, 1.03774108e-02f, 1.04300613e-02f, -5.88564053e-02f,
  -1.89089049e-02f, 5.16271628e-02f, 3.09719890e-02f, 6.56110793e-02f, 5.37047945e-02f, 6.84860647e-02f, 8.06266516e-02f, -1.52141703e-02f, -3.36995116e-03f, 6.26474395e-02f,
  8.91989768e-02f, -7.46272355e-02f, -5.23585901e-02f, 3.68765295e-02f, -4.27190177e-02f, 2.94405296e-02f, 8.06720033e-02f, 8.71565100e-03f, -9.58017930e-02f, -2.50986740e-02f,
  -4.05766629e-02f, -9.03233886e-02f, 1.72325000e-02f, -4.23186272e-02f, -1.19548221e-03f, -2.59500500e-02f, 3.55849899e-02f, 6.64002448e-02f, 2.06629820e-02f, -1.64777525e-02f,
  1.63545795e-02f, -8.68786685e-03f, -1.27221150e-02f, 2.97482163e-02f, 3.35740112e-02f, -2.58692242e-02f, -4.30083089e-02f, -6.47574887e-02f, 1.86294504e-02f, -9.68636498e-02f,
  4.54015285e-02f, 2.58829799e-02f, 4.62999791e-02f, 3.92963588e-02f, -1.89247690e-02f, -2.33435375e-03f, 1.93072185e-02f, -1.07232770e-02f, 3.65721770e-02f, 5.87878637e-02f,
  -3.56620878e-01f, 1.09793447e-01f, 2.63484474e-02f, -9.29398686e-02f, -6.67546093e-02f, -1.59530878e-01f, -1.68780491e-01f, 1.48033381e-01f, 1.36466771e-01f, -3.55070271e-02f,
  6.64406270e-02f, -5.81071340e-02f, 6.54575825e-02f, -1.12094089e-01f, -2.40640387e-01f, 1.30748674e-01f, -2.05071211e-01f, -3.14999148e-02f, 8.82837474e-02f, -1.08471140e-01f,
  7.28112087e-02f, -1.81545660e-01f, 7.72492727e-03f, 5.36572374e-02f, -2.30672866e-01f, 5.52446134e-02f, -1.46605149e-01f, -2.23815646e-02f, -1.94965273e-01f, -4.47450429e-02f,
  5.94034493e-02f, -1.08741689e-03f, -1.96890254e-02f, 4.94844168e-02f, -1.87440533e-02f, -4.00606431e-02f, -3.81158777e-02f, -2.84588542e-02f, 5.63782528e-02f, -1.36949047e-02f,
  5.90406545e-03f, -2.12861374e-02f, -1.71119142e-02f, -6.72307685e-02f, -8.43615364e-03f, 8.76472294e-02f, -9.39104334e-03f, -7.06926314e-03f, 7.45963231e-02f, 8.00183043e-03f,
  2.61093695e-02f, 7.31839389e-02f, 4.73036990e-02f, 4.95915599e-02f, -1.60218347e-02f, 5.42653166e-03f, 6.68033212e-02f, -4.90521751e-02f, 2.62634717e-02f, -8.97607133e-02f,
  -3.64493802e-02f, -1.20536494e-03f, -5.67763373e-02f, 4.15834673e-02f, -2.54818108e-02f, 8.41618553e-02f, -3.73849086e-02f, 9.73932818e-02f, 5.57817891e-02f, 4.75613307e-03f,
  1.13427714e-02f, 7.14256079e-04f, 7.42441863e-02f, 6.17752001e-02f, -8.88139755e-02f, -7.52363205e-02f, -1.80073604e-01f, 1.11096390e-02f, 4.88095656e-02f, 7.46079907e-02f,
  -7.53710642e-02f, 2.45185718e-02f, -8.20727199e-02f, 4.23394926e-02f, 1.88708864e-02f, -1.21213114e-02f, 5.45064313e-03f, 6.92517757e-02f, 8.09961259e-02f, -8.88617188e-02f,
  -8.42158347e-02f, -1.69372022e-01f, 1.20477632e-01f, 1.11104041e-01f, 4.43662256e-02f, -3.32381390e-02f, -4.43957262e-02f, 2.37437766e-02f, -2.90731508e-02f, -5.51046282e-02f,
  -1.46372076e-02f, 2.72111297e-02f, 2.31150035e-02f, 6.81329966e-02f, -4.66302708e-02f, -8.08743387e-03f, -4.96354923e-02f, 4.12632748e-02f, -1.34161604e-03f, 3.14743491e-03f,
  -4.51661721e-02f, -8.95974878e-03f, 7.40798982e-03f, -6.09972849e-02f, 3.29189003e-02f, -2.88792253e-02f, 2.01160721e-02f, 3.02188527e-02f, 4.55999793e-03f, 6.17825985e-03f,
  -1.48148211e-02f, 2.08060369e-02f, -3.02089840e-01f, -2.64458545e-02f, -3.64137217e-02f, -4.48599309e-02f, 5.33335330e-03f, 6.96061850e-02f, -1.47109941e-01f, 1.08675823e-01f,
  9.27195176e-02f, -1.23162873e-01f, -1.29850358e-01f, 1.50531054e-01f, 1.15450576e-01f, -1.40172422e-01f, 1.23576269e-01f, 9.39205587e-02f, -6.69170767e-02f, 8.03714469e-02f,
  2.18009762e-02f, 3.42885494e-01f, -6.97728395e-02f, 1.12011299e-01f, 5.95167391e-02f, -1.25418007e-02f, 2.77313441e-01f, -1.18950047e-01f, 1.03405230e-01f, 8.68007913e-02f,
  4.19498123e-02f, 4.84074466e-02f, -1.60243437e-02f, 2.25574207e-02f, 2.68908311e-02f, 4.43558395e-02f, -6.25391155e-02f, -8.64576176e-02f, 1.86790880e-02f, -2.08833255e-02f,
  -1.36024535e-01f, -1.60825383e-02f, 5.56384474e-02f, -9.36531276e-02f, -1.25601720e-02f, -5.07084131e-02f, -5.40478490e-02f, -5.45889512e-02f, 5.12081496e-02f, -4.58532572e-02f,
  -1.05415098e-01f, -6.71332255e-02f, 5.06714806e-02f, 6.48160726e-02f, 3.16716149e-03f, 1.91925429e-02f, -7.20048845e-02f, -6.30577430e-02f, 4.42191437e-02f, -4.46273535e-02f,
  -6.73502386e-02f, 7.54219368e-02f, -6.40155561e-03f, -2.53940821e-02f, 3.59781235e-02f, 7.93425143e-02f, 5.32066859e-02f, 8.43033642e-02f, -1.34502919e-02f, -4.07447964e-02f,
  2.66747531e-02f, 1.47079546e-02f, 7.82250892e-04f, -6.74681365e-02f, -7.74927959e-02f, 1.70473401e-02f, -2.44844370e-02f, -8.49362612e-02f, -2.39646621e-02f, -3.65311429e-02f,
  3.16102020e-02f, 2.90107597e-02f, -7.50370603e-03f, -1.23668899e-04f, 6.33538663e-02f, -3.48098502e-02f, -5.69732115e-02f, -1.56764269e-01f, -5.76368347e-02f, -8.28131139e-02f,
  1.55259028e-01f, 1.61476880e-01f, 7.88934622e-03f, 2.37595271e-02f, 5.71293011e-02f, 7.98009783e-02f, -1.50162132e-05f, -6.29254282e-02f, 1.30531684e-01f, -3.11894268e-02f,
  5.67272073e-03f, 3.88253443e-02f, 7.10536027e-04f, -9.71052349e-02f, 7.13193715e-02f, 9.64361131e-02f, 1.05281159e-01f, 5.16210124e-03f, 1.88854977e-01f, -1.19376499e-02f,
  -2.32932456e-02f, 3.82648297e-02f, 3.37233730e-02f, -1.48852938e-03f, 6.61385758e-03f, 4.29066159e-02f, 1.07782245e-01f, -3.63125093e-02f, 4.27514873e-02f, -1.12439040e-02f,
  1.67013451e-01f, 1.92559659e-01f, -1.39591590e-01f, -6.11249059e-02f, -2.32967779e-01f, -4.68422435e-02f, -9.90346726e-03f, -1.18753850e-01f, 4.20515500e-02f, 1.51725814e-01f,
  4.35124524e-02f, -1.62024684e-02f, 1.26565427e-01f, 1.36551633e-01f, 7.18381479e-02f, 1.52039289e-01f, -2.13181153e-02f, 1.55433938e-01f, -6.55716211e-02f, 3.16537730e-02f,
  -5.75823709e-02f, 5.21525331e-02f, -2.01804355e-01f, -5.43363318e-02f, -1.83320582e-01f, -1.26789898e-01f, -8.40030517e-03f, -2.14472428e-01f, -1.30037516e-01f, -1.28552597e-02f,
  -8.44475534e-03f, 1.03692107e-01f, -9.94852036e-02f, 5.41908841e-04f, -5.95171899e-02f, -8.07162002e-02f, 7.32026761e-03f, -1.68861169e-02f, 2.39452422e-02f, -3.37604657e-02f,
  -5.57307713e-02f, -7.19325393e-02f, 1.42388150e-01f, 8.71915221e-02f, -6.36133775e-02f, 1.37899909e-02f, -6.07712753e-02f, -4.46447581e-02f, -9.31296945e-02f, 9.47752502e-03f,
  -1.39192298e-01f, -1.06723234e-01f, -7.22867949e-03f, -3.38007659e-02f, -1.05730630e-01f, -8.13938379e-02f, -6.47365600e-02f, -9.67822820e-02f, -7.80741777e-03f, -1.08640119e-01f,
  7.77106807e-02f, -9.50497612e-02f, 8.29845145e-02f, -2.17116978e-02f, -4.77773510e-02f, -5.44557311e-02f, -1.37614841e-02f, 1.69890486e-02f, 3.02181393e-02f, 3.09056342e-02f,
  1.44682154e-02f, 6.84803817e-03f, -5.71472645e-02f, -5.69034414e-03f, 1.53119871e-02f, -6.27812818e-02f, 3.64423878e-02f, -8.30268394e-03f, 2.88078133e-02f, -1.11629386e-02f,
  9.76867136e-03f, 6.68860525e-02f, 1.15045302e-01f, -5.26335835e-03f, 7.43867457e-02f, -6.91149160e-02f, -3.83894220e-02f, -9.66198370e-02f, -1.01185180e-02f, -2.62527801e-02f,
  2.15042457e-01f, 2.17187867e-01f, -2.02536080e-02f, -3.64429392e-02f, 2.33403444e-02f, -2.02609859e-02f, 2.60151997e-02f, -2.28626709e-02f, 6.39843047e-02f, 2.50948388e-02f,
  6.19033948e-02f, 4.06580903e-02f, 1.21734506e-02f, 6.79898039e-02f, -1.17991343e-01f, 2.91990191e-02f, 9.07038748e-02f, 6.95038736e-02f, 4.01412286e-02f, 1.52562279e-02f,
  -2.38027144e-02f, 3.12753990e-02f, 2.15921216e-02f, -3.13170999e-02f, 5.30261779e-03f, -1.38353407e-01f, -4.15791571e-03f, -1.51359320e-01f, -2.35462040e-02f, 3.18119563e-02f,
  -3.64944428e-01f, -1.60569921e-01f, -2.00334582e-02f, -9.69436616e-02f, 9.86684486e-02f, -5.24324514e-02f, -1.88691035e-01f, -1.05947383e-01f, -3.93436611e-01f, -1.20540343e-01f,
  1.69509485e-01f, -3.11052710e-01f, 6.71280175e-02f, 6.06642626e-02f, -2.67536379e-02f, 6.75279945e-02f, 5.80424676e-03f, -2.94283349e-02f, -6.50263727e-02f, 4.39633653e-02f,
  -2.93423496e-02f, 1.53021783e-01f, 1.59401864e-01f, 1.55054644e-01f, 3.65271382e-02f, -9.22964290e-02f, 1.32217228e-01f, 9.31079164e-02f, 1.08595148e-01f, 5.65912668e-03f,
  5.48568591e-02f, -1.85375735e-01f, -1.90077480e-02f, -1.60481278e-02f, 4.40886542e-02f, -4.11055908e-02f, -4.68984395e-02f, 1.01299241e-01f, -2.31590308e-02f, -6.18651137e-02f,
  5.03634661e-02f, 3.50795686e-02f, -4.21027020e-02f, -3.08208112e-02f, -3.34196128e-02f, -4.10771109e-02f, 1.67232007e-02f, -3.75867076e-02f, 1.32542104e-02f, -2.01415699e-02f,
  3.55592184e-02f, 2.44755205e-02f, 2.42712293e-02f, 3.88338231e-02f, -3.64181437e-02f, -5.23593202e-02f, -2.87009776e-02f, -4.12101252e-03f, -9.34294909e-02f, -7.94083849e-02f,
  -7.03880042e-02f, 2.65021026e-02f, 4.07962278e-02f, 9.76940766e-02f, 5.97012565e-02f, 1.02194265e-01f, 5.93128242e-02f, 2.11260449e-02f, 3.06369774e-02f, -9.87745915e-03f,
  9.21968222e-02f, 3.18078464e-03f, -7.16003478e-02f, -5.60176894e-02f, 2.34276857e-02f, -6.44356683e-02f, 8.56373087e-02f, 6.21295720e-02f, -7.02864155e-02f, 5.28427996e-02f,
  3.78828868e-02f, 4.07196395e-02f, -1.21230632e-02f, 6.50138110e-02f, -5.92332846e-03f, 2.62124762e-02f, -7.67782107e-02f, 4.22330275e-02f, 1.99971516e-02f, 3.66041809e-02f,
  -3.35417874e-02f, -1.32927641e-01f, -6.03118027e-03f, 6.37762100e-02f, -2.27887314e-02f, 1.15646765e-01f, -1.03848544e-03f, -1.35277519e-02f, -1.54565880e-02f, -4.55176532e-02f,
  -4.05708663e-02f, 1.18345430e-03f, 4.14317772e-02f, 5.23947470e-04f, 5.35618402e-02f, -3.45036760e-02f, -5.94284059e-03f, 1.27194375e-02f, -8.59119277e-03f, -2.52641719e-02f,
  3.48885283e-02f, -4.22028638e-02f, -3.36721241e-02f, -1.99171789e-02f, -5.63145569e-03f, -2.19429173e-02f, -7.69646615e-02f, -1.76967904e-02f, 6.62424043e-02f, 1.94113441e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.15948811e-01f, 1.85670286e-01f, 2.29607344e-01f, -9.03888866e-02f, 3.10033723e-03f, 9.30430740e-02f, -7.54550025e-02f, 1.04204096e-01f, 1.00633157e-02f, 3.08795478e-02f,
  -2.27826182e-02f, 1.41147718e-01f, 5.92338927e-02f, 8.98935199e-02f, -1.27156049e-01f, -9.12591070e-02f, -1.36217596e-02f, -4.09310088e-02f, -3.57400775e-02f, 6.60807416e-02f,
  -9.09908190e-02f, -2.25655764e-01f, 7.42110014e-02f, 2.24353440e-04f, -8.58718455e-02f, 2.78008748e-02f, -1.94036543e-01f, -2.85602733e-02f, -4.48348150e-02f, -1.80599932e-02f,
  -3.94576648e-03f, 3.55837531e-02f, -6.71339557e-02f, 2.90286597e-02f, -3.78491990e-02f, 1.80741660e-02f, -6.42646551e-02f, -9.43316817e-02f, -2.21022367e-02f, 1.16704866e-01f,
  -4.38858122e-02f, 1.07523743e-02f, 5.24693867e-03f, 1.20773269e-02f, 6.37579849e-03f, 4.22705077e-02f, 2.89769452e-02f, -6.42553642e-02f, -4.56986912e-02f, 1.01774141e-01f,
  9.70909894e-02f, 1.29054710e-01f, 4.53983173e-02f, 5.11918357e-03f, -1.09364209e-03f, 6.91560432e-02f, 4.08817232e-02f, -1.18694482e-02f, -4.15885523e-02f, 8.11111256e-02f,
  1.21231563e-01f, -8.85156468e-02f, -6.65702447e-02f, 5.51585183e-02f, -6.02237135e-02f, 1.57086912e-03f, 3.54289939e-03f, -7.78244361e-02f, -6.76864525e-03f, 5.02766222e-02f,
  4.77171056e-02f, 5.37125841e-02f, -8.84661078e-02f, -2.48005074e-02f, 5.33728488e-03f, 6.28593564e-02f, 3.12996935e-03f, 2.92112939e-02f, 1.10614978e-01f, 4.09742090e-04f,
  2.10188627e-02f, 5.31353578e-02f, -1.16555216e-02f, -7.12959990e-02f, 6.59176633e-02f, -4.32175696e-02f, 2.08013617e-02f, -3.50789651e-02f, 4.08907235e-02f, -1.25830099e-01f,
  -1.21183373e-01f, -9.12688896e-02f, 3.98066640e-02f, 2.16492787e-02f, 4.32994999e-02f, -4.98590432e-02f, -4.86513339e-02f, -1.60429021e-03f, -1.05935317e-02f, -2.52391351e-03f,
  -2.35298462e-03f, -7.26061463e-02f, 5.07975854e-02f, 2.62220539e-02f, 4.72775381e-03f, -5.51994564e-03f, -9.99927074e-02f, -9.58133563e-02f, -9.81478691e-02f, 6.35679662e-02f,
  -1.13169700e-02f, -1.44273425e-02f, 5.77350818e-02f, -1.62946805e-02f, -4.09296118e-02f, -3.60879600e-02f, 6.11851886e-02f, 4.60411571e-02f, -8.52945521e-02f, 9.69880372e-02f,
  -3.24462235e-01f, 2.51176953e-02f, -1.49819568e-01f, -1.03210084e-01f, 1.43838406e-01f, -1.46307483e-01f, 3.20156850e-02f, 1.01858608e-01f, -5.00890054e-02f, 1.32145777e-01f,
  1.06484100e-01f, -7.55134970e-02f, 3.49491425e-02f, -3.25488418e-01f, -3.66477787e-01f, -2.38693491e-01f, -3.45604122e-01f, -1.21589296e-01f, -7.58369714e-02f, -1.57557249e-01f,
  -9.64869037e-02f, 5.42359129e-02f, -2.12331444e-01f, 1.52771011e-01f, 2.98907869e-02f, 1.00772172e-01f, 1.80480883e-01f, 1.80922598e-01f, -6.74101189e-02f, 6.94630295e-02f,
  1.91109013e-02f, 5.26755601e-02f, 3.46743725e-02f, -1.00614522e-02f, -4.23914790e-02f, -7.33442418e-03f, -4.38125543e-02f, 1.03578921e-02f, 2.09463853e-02f, -2.15716194e-02f,
  -5.14024645e-02f, -8.43554586e-02f, -1.08451739e-01f, 1.05943955e-01f, 6.67551458e-02f, 4.98949587e-02f, -2.98748594e-02f, 5.77218421e-02f, -3.57758142e-02f, -1.06009260e-01f,
  -3.88769247e-02f, -3.76679935e-02f, 3.58757116e-02f, -1.17578417e-01f, 2.05422100e-02f, 6.52865767e-02f, -8.28943029e-03f, 2.42734910e-03f, -9.45112258e-02f, -5.00148609e-02f,
  -4.84422930e-02f, 9.97301787e-02f, 4.42916229e-02f, -8.03826675e-02f, 7.60390460e-02f, 6.54084608e-02f, 6.68104291e-02f, -1.48013514e-02f, 3.77230905e-02f, -4.18556342e-03f,
  -5.26423156e-02f, 6.60466328e-02f, 1.67851113e-02f, 3.15021817e-03f, -2.75324564e-02f, -5.18338233e-02f, -1.84542947e-02f, -2.93434653e-02f, -1.01922207e-01f, 3.44968331e-03f,
  5.99889271e-02f, -3.48603986e-02f, -2.36962941e-02f, -9.85642225e-02f, 5.13318293e-02f, 4.61431034e-03f, 5.64201660e-02f, -1.27334951e-03f, -4.54398878e-02f, -1.50213600e-04f,
  -5.68369702e-02f, -1.10607129e-02f, 7.20972642e-02f, -7.73049178e-05f, -1.95199363e-02f, 3.40347216e-02f, 1.66669302e-02f, -2.98438650e-02f, -4.08729278e-02f, 3.08463778e-02f,
  5.33368327e-02f, 7.69365877e-02f, -7.09099174e-02f, -3.86299007e-02f, 2.88823321e-02f, 6.92759361e-03f, 5.88391833e-02f, 4.13108356e-02f, 5.83508164e-02f, 4.45026867e-02f,
  7.05940602e-03f, -2.10250146e-03f, -5.47994720e-03f, 5.04955091e-03f, -5.50799333e-02f, 7.68953711e-02f, -1.11325504e-02f, -5.70758153e-03f, 1.42866690e-02f, -3.31432745e-02f,
  -2.54617363e-01f, 1.16708107e-01f, -2.03622267e-01f, 2.64558773e-02f, -1.01259559e-01f, -1.28525654e-02f, -5.05946018e-02f, -5.15863486e-02f, -2.91248649e-01f, 2.82921672e-01f,
  1.93964750e-01f, -2.93126166e-01f, 1.44539446e-01f, 2.90564656e-01f, -1.69566825e-01f, 2.74951700e-02f, 1.61019802e-01f, 6.55331165e-02f, -1.15453281e-01f, -6.61298186e-02f,
  -1.04314990e-01f, 3.18695039e-01f, 9.59444568e-02f, 1.35672599e-01f, 5.92813157e-02f, -1.15428083e-02f, 1.38659492e-01f, -1.16292454e-01f, 7.30663240e-02f, -4.27471884e-02f,
  4.07622494e-02f, 6.96860403e-02f, -6.34171516e-02f, -8.33518580e-02f, 1.52949733e-03f, 1.39156848e-01f, -2.43173465e-02f, -9.44501385e-02f, -1.05461195e-01f, 1.38144754e-03f,
  3.66810686e-03f, 3.93095799e-02f, -3.99531648e-02f, -6.15490451e-02f, 5.37434332e-02f, 7.31122540e-03f, -1.18896011e-02f, -2.21151300e-02f, -7.56599903e-02f, -5.81170991e-03f,
  -6.64823651e-02f, -5.29272202e-03f, -1.13296676e-02f, 5.71232401e-02f, -3.83961871e-02f, -1.54581210e-02f, 3.54102775e-02f, -3.42328995e-02f, -9.39147472e-02f, 4.48736874e-03f,
  7.56834298e-02f, -2.04936266e-01f, -2.82113682e-02f, 9.93213952e-02f, -7.63832629e-02f, 8.08934495e-02f, -2.01741364e-02f, 4.87168655e-02f, -6.37204796e-02f, 4.45987061e-02f,
  -3.42880078e-02f, -6.52864352e-02f, -7.92552903e-02f, 3.78302783e-02f, 1.26795262e-01f, -2.95517854e-02f, -6.25338554e-02f, 3.03094219e-02f, -1.01951689e-01f, -8.72998834e-02f,
  7.32034892e-02f, 6.27518892e-02f, -2.44229101e-02f, -1.27312876e-02f, -2.38593128e-02f, -1.81459002e-02f, 3.22548440e-04f, -1.09675759e-02f, 8.86528045e-02f, -4.02284833e-03f,
  6.91290349e-02f, -1.55395856e-02f, 3.56159881e-02f, -6.85319975e-02f, 7.31185675e-02f, 4.45161127e-02f, 4.42554951e-02f, -6.71846606e-03f, -6.18387870e-02f, -5.49157560e-02f,
  3.31106707e-02f, 4.45796102e-02f, 1.11154601e-01f, -4.10318859e-02f, -1.08233936e-01f, 2.96431575e-02f, 9.28733721e-02f, -6.14008270e-02f, -3.03359330e-02f, 3.46554518e-02f,
  1.10372551e-01f, -2.60891747e-02f, -2.59674918e-02f, -1.15110271e-01f, 4.04581539e-02f, 7.07748160e-02f, -4.71699191e-03f, -5.05756512e-02f, -6.51572868e-02f, -3.41939069e-02f,
  -4.22805429e-01f, 5.23473695e-02f, 8.03830661e-03f, -3.87487113e-01f, 1.32298455e-01f, -3.73719223e-02f, -2.50274032e-01f, 4.32356372e-02f, -6.19991235e-02f, -1.38706133e-01f,
  -8.81365836e-02f, -8.26577172e-02f, 2.44531721e-01f, -3.67731079e-02f, -1.17416404e-01f, 1.48649931e-01f, -2.07674220e-01f, -1.11835450e-01f, 2.00122178e-01f, -5.72126098e-02f,
  1.87157989e-02f, 7.31226206e-02f, 3.65111120e-02f, 2.55556047e-01f, 1.35495020e-02f, -1.68022327e-02f, -8.28194711e-03f, 5.07616736e-02f, -4.74185869e-02f, 1.43565848e-01f,
  2.71607880e-02f, -3.44590172e-02f, 4.28879596e-02f, -8.81589483e-03f, 1.64338406e-02f, -1.44963339e-02f, -1.49514511e-01f, 1.48914546e-01f, 1.53002683e-02f, -4.61909361e-02f,
  -3.55037041e-02f, 4.73799445e-02f, 1.65113080e-02f, 4.92743328e-02f, -2.21047215e-02f, -8.11771024e-04f, 6.55627996e-02f, -4.76770736e-02f, 1.98436063e-02f, 1.08311810e-01f,
  -4.74362038e-02f, 1.11952148e-01f, -6.06033280e-02f, -7.36678764e-02f, 1.94670931e-02f, 1.27462046e-02f, -6.35192618e-02f, -3.18622999e-02f, -7.02067837e-02f, -9.50320512e-02f,
  2.94993464e-02f, -1.85163748e-02f, 5.40249087e-02f, 3.35498191e-02f, -4.80638519e-02f, 5.15845120e-02f, -1.91589519e-02f, -6.04414940e-02f, -5.08957542e-02f, 8.71467683e-03f,
  -2.12407056e-02f, -5.58302104e-02f, 5.48459031e-02f, -3.79297994e-02f, -5.10914102e-02f, -5.29421680e-02f, 4.02265564e-02f, -2.71877609e-02f, -5.50906099e-02f, -4.02572751e-02f,
  -6.88461661e-02f, -1.20266065e-01f, 1.53017789e-02f, 3.77002954e-02f, 1.10007718e-01f, 7.24877045e-02f, 1.38100371e-01f, -3.18672210e-02f, -2.56998511e-03f, -6.13466613e-02f,
  -1.49594218e-01f, -2.10143447e-01f, 5.78293838e-02f, -1.60809103e-02f, 2.41820477e-02f, -1.55998417e-03f, 5.49270660e-02f, -1.33337621e-02f, 1.16499355e-02f, -5.18625751e-02f,
  -8.55932087e-02f, 2.23623011e-02f, -1.33036748e-01f, 2.58535892e-02f, -3.22817191e-02f, 2.54922220e-03f, -8.95613432e-02f, -1.61229484e-02f, -7.08918273e-02f, 4.99451254e-03f,
  -7.00781271e-02f, 2.21340204e-04f, -5.69204278e-02f, 2.90490277e-02f, -7.26890564e-02f, -1.44956306e-01f, 1.92781556e-02f, -1.48829207e-01f, -2.52143983e-02f, -1.38130812e-02f,
  -4.75949019e-01f, -3.07981186e-02f, 8.42020214e-02f, -1.25675127e-01f, -1.66670293e-01f, 3.71900275e-02f, 1.68102056e-01f, -6.02168031e-02f, -4.72746566e-02f, 2.06949338e-01f,
  1.34463668e-01f, -6.78125545e-02f, 2.42972299e-01f, 7.11646229e-02f, -7.77010098e-02f, 8.89780074e-02f, -4.66347821e-02f, -1.41912010e-02f, 1.59856845e-02f, -1.18429594e-01f,
  -1.76392645e-01f, -4.93200868e-02f, 2.51517259e-02f, -8.02968144e-02f, -9.16026384e-02f, -8.06392655e-02f, 1.39888348e-02f, 5.25015369e-02f, 2.77551413e-02f, 3.86532210e-02f,
  -2.21455172e-01f, -8.95837694e-02f, -1.70956671e-01f, -1.16738260e-01f, -1.49958432e-01f, -3.44269611e-02f, -4.18504700e-02f, 8.98710862e-02f, 2.69499160e-02f, -6.60985056e-03f,
  1.75494421e-02f, -3.34831662e-02f, -6.63856566e-02f, 4.94592963e-03f, -3.38804349e-02f, 8.95869285e-02f, 4.68818098e-02f, -1.24965906e-02f, 3.85308117e-02f, 2.28760540e-02f,
  1.27610173e-02f, 1.98507141e-02f, -2.69102566e-02f, 5.53486086e-02f, 2.63343798e-03f, 8.81168991e-03f, 2.16985922e-02f, 1.63364448e-02f, -5.48706390e-02f, -1.99133772e-02f,
  1.05162524e-01f, 1.31121678e-02f, 2.08926611e-02f, 2.82898564e-02f, 6.25370592e-02f, -2.17680745e-02f, 1.30644841e-02f, 4.34415825e-02f, 2.31748354e-02f, -3.10688801e-02f,
  2.05348730e-02f, -1.14103081e-02f, -4.60219868e-02f, -3.78596559e-02f, 6.13918640e-02f, 7.81111186e-03f, 1.87772065e-02f, -1.68803930e-02f, 5.22725098e-02f, -9.25763994e-02f,
  -5.18014207e-02f, 5.28915897e-02f, 4.27752621e-02f, -1.09649673e-02f, 2.52036229e-02f, -1.26566574e-01f, -1.27360970e-02f, -5.07404096e-02f, -3.12125292e-02f, -3.88117395e-02f,
  -3.80929321e-01f, -3.09478223e-01f, 8.95450860e-02f, -9.23731402e-02f, -1.13692589e-01f, -9.72946808e-02f, -1.41231967e-02f, -6.16680682e-02f, 3.18627432e-02f, 2.24543698e-02f,
  -5.60573414e-02f, -5.66225350e-02f, -6.74106106e-02f, 1.40594859e-02f, -1.21062733e-02f, -9.50125977e-02f, -5.69916777e-02f, -6.41553551e-02f, -1.01017937e-01f, 6.23646043e-02f,
  -1.07211776e-01f, 5.23509877e-03f, 1.18923038e-01f, 2.36673672e-02f, 6.44067954e-03f, -4.65573929e-02f, -6.85117915e-02f, -5.13424911e-02f, -4.18454520e-02f, -4.84327935e-02f,
  1.58594638e-01f, -3.10323358e-01f, 3.95646095e-02f, 1.01025015e-01f, 2.30088726e-01f, -6.04483932e-02f, 1.34869918e-01f, -5.89982681e-02f, -7.47474656e-02f, -1.26873314e-01f,
  1.58534143e-02f, 4.38018031e-02f, -6.35341778e-02f, 6.74757641e-03f, 2.80586541e-01f, -7.14686513e-02f, 4.08347175e-02f, 2.58714762e-02f, -2.39141490e-02f, -8.47596228e-02f,
  1.45380218e-02f, -4.85652946e-02f, -1.03917476e-02f, -5.02953716e-02f, 1.10677049e-01f, 4.35669273e-02f, 9.30481777e-02f, 6.33456931e-02f, -3.66339236e-02f, 1.71960995e-01f,
  -3.98200750e-02f, 8.56352132e-03f, -4.91380394e-02f, -7.89647996e-02f, 3.05910856e-02f, 1.00488819e-01f, 7.86809996e-02f, 1.65172681e-01f, 1.00455284e-01f, -8.23325217e-02f,
  -7.59704486e-02f, 1.05188629e-02f, -6.62973966e-04f, 1.60877377e-01f, -3.43939625e-02f, 1.23426402e-02f, 8.23348761e-02f, -3.33931260e-02f, -5.80615960e-02f, 6.33564591e-02f,
  -6.17228029e-03f, -5.04200393e-03f, 1.32557586e-01f, 6.74873218e-02f, 1.75032895e-02f, 1.35446144e-02f, 1.59100611e-02f, 1.69665106e-02f, 9.82709602e-02f, 2.11181883e-02f,
  -7.09125474e-02f, 2.75754407e-02f, 9.45291109e-03f, -6.05369993e-02f, -1.01314381e-01f, 3.98924425e-02f, -1.31999860e-02f, -1.03067383e-02f, 4.98841815e-02f, -8.60024765e-02f,
  9.33609158e-02f, 6.22852817e-02f, 1.06250793e-02f, -8.03815052e-02f, -5.28413504e-02f, 5.53913116e-02f, 6.42646626e-02f, 3.06564309e-02f, -8.18671979e-05f, -6.13903301e-03f,
  2.26135682e-02f, 3.13800387e-02f, 9.62116867e-02f, 5.24566625e-04f, -4.80599552e-02f, -1.13334237e-02f, -8.41061249e-02f, -6.92253932e-02f, 6.33147880e-02f, 3.78087237e-02f,
  -1.84311345e-01f, -1.53463945e-01f, -2.03567035e-02f, 4.77227420e-02f, -3.88092711e-03f, 2.20848173e-02f, 6.31093513e-03f, -1.02837011e-01f, -5.58151118e-02f, -7.96362534e-02f,
  2.77187452e-02f, 1.55451953e-01f, -7.86434263e-02f, 1.40754625e-01f, -7.70571735e-03f, 3.07312477e-02f, -1.70550030e-02f, -1.39151746e-02f, -1.12450542e-02f, -4.71624993e-02f,
  -5.17146848e-02f, 6.91332817e-02f, 1.37092605e-01f, 1.02864675e-01f, -3.16853672e-02f, -1.16356388e-02f, 8.13870057e-02f, -1.10066600e-01f, 1.30662963e-01f, 2.53692884e-02f,
  1.01870894e-01f, 4.71422449e-02f, -2.77996641e-02f, 1.59386009e-01f, 4.34926637e-02f, -5.59699424e-02f, -3.42896521e-01f, 1.21563740e-01f, -1.31634757e-01f, -6.75532669e-02f,
  1.00753389e-01f, 1.89772490e-02f, -1.30054504e-01f, 2.52712458e-01f, 1.89637274e-01f, -1.31054655e-01f, 2.34780610e-01f, 1.02848642e-01f, 2.64415964e-02f, 1.74223065e-01f,
  1.11725286e-01f, 2.54565865e-01f, -5.03202900e-02f, 1.87671617e-01f, 5.46536818e-02f, -2.22566202e-02f, 1.50898457e-01f, -7.16224611e-02f, 2.05158889e-01f, 1.91608012e-01f,
  3.61100510e-02f, 5.69802560e-02f, -1.10669238e-02f, -5.21623762e-03f, -6.75131455e-02f, -2.06906218e-02f, -3.69655602e-02f, -1.19557036e-02f, -1.41159166e-02f, 4.07041200e-02f,
  -9.54031795e-02f, 1.06481194e-01f, 1.30893216e-01f, 6.02340661e-02f, -1.37045318e-02f, 1.21562034e-02f, 9.90705006e-03f, -9.88359079e-02f, -3.69828716e-02f, 5.83604425e-02f,
  -1.05490446e-01f, -5.70928901e-02f, 2.17296500e-02f, -5.59123680e-02f, 5.81941158e-02f, 4.63188328e-02f, -1.10626504e-01f, -4.11779173e-02f, 1.38387922e-02f, 2.45809387e-02f,
  -1.72849074e-02f, -1.13686463e-02f, -2.35594064e-02f, -9.06403549e-03f, -4.27108444e-02f, -1.00633629e-01f, 8.61648619e-02f, -5.10420687e-02f, -4.35147397e-02f, 7.40770192e-04f,
  3.93188074e-02f, -4.26821224e-03f, 2.83499770e-02f, -9.41599626e-03f, -2.87596751e-02f, -6.90631941e-02f, 3.00453659e-02f, -5.68558648e-02f, -9.05035734e-02f, -7.67325563e-03f,
  3.74119505e-02f, -3.47815044e-02f, -4.46428396e-02f, -3.23534310e-02f, 9.90877002e-02f, -3.19262408e-02f, 2.96297427e-02f, 4.56375116e-03f, -9.86871943e-02f, 1.21756401e-02f,
  9.37915891e-02f, 6.38276786e-02f, -9.28625166e-02f, -6.35218620e-03f, -7.30053037e-02f, 2.41419356e-02f, -7.23963305e-02f, 9.19569656e-02f, 9.06517655e-02f, -5.21570519e-02f,
  8.79110470e-02f, -4.58156280e-02f, -4.51915488e-02f, 5.23630939e-02f, 7.79042691e-02f, 7.28830174e-02f, 4.93953303e-02f, -7.30801672e-02f, 2.96732429e-02f, 1.14242606e-01f,
  -7.38568902e-02f, -1.13031249e-02f, -4.95528840e-02f, -5.55185974e-03f, -4.65679802e-02f, -4.99769673e-02f, 2.20101830e-02f, -2.80269124e-02f, 2.48566028e-02f, -2.04125065e-02f,
  -4.22809839e-01f, 4.44094427e-02f, -5.15708141e-02f, 2.59514421e-01f, -1.45519510e-01f, -6.00753129e-02f, 8.58982652e-02f, 1.23269424e-01f, -6.33423775e-02f, 1.32707968e-01f,
  1.89911574e-01f, -7.96057880e-02f, 1.56775802e-01f, 3.59915525e-01f, 1.53686404e-02f, 1.49977267e-01f, 1.93798855e-01f, 1.30205274e-01f, -4.78979237e-02f, 4.14740592e-02f,
  -9.30880476e-03f, 2.53003597e-01f, 2.66606569e-01f, 1.06202602e-01f, 1.00893728e-01f, 5.01800552e-02f, 1.60975024e-01f, 5.62368296e-02f, 3.05978596e-01f, 2.62725335e-02f,
  8.55184644e-02f, 7.69226754e-04f, 1.57570951e-02f, 3.20195854e-02f, -8.16907268e-03f, -1.15378916e-01f, 2.43949257e-02f, -5.73684573e-02f, -5.07478081e-02f, 6.22019581e-02f,
  -5.26686907e-02f, -1.67147312e-02f, -3.76789905e-02f, -3.13127153e-02f, -1.64999276e-01f, -5.96366227e-02f, 2.50370223e-02f, -8.03617314e-02f, -2.98991986e-03f, -1.12721033e-01f,
  -7.34222084e-02f, 4.94441064e-03f, 6.85072178e-03f, 1.10134810e-01f, -5.48373722e-03f, 1.94594655e-02f, 2.64116010e-04f, 4.21055593e-02f, -9.77587141e-03f, 1.00854207e-02f,
  -4.23367620e-02f, -1.61326248e-02f, 1.68459844e-02f, 5.68563752e-02f, -1.57148531e-03f, 6.89988807e-02f, 7.41563961e-02f, 1.86304410e-03f, 5.18561490e-02f, -1.86255537e-02f,
  -1.06875114e-02f, 2.40293052e-02f, 3.74224447e-02f, 1.17981741e-02f, 2.01834720e-02f, 7.56567717e-03f, 4.36138324e-02f, 1.11633828e-02f, -7.75504038e-02f, -4.22465801e-03f,
  -2.27826722e-02f, -1.17729150e-01f, -4.48489785e-02f, 8.75326470e-02f, 1.50576960e-02f, -1.13821896e-02f, -4.14705686e-02f, 6.65305331e-02f, 3.98008600e-02f, -6.02448620e-02f,
  4.82341126e-02f, 2.81655304e-02f, -2.81820726e-03f, -1.92451421e-02f, -4.30758949e-03f, -1.55570228e-02f, 3.94394770e-02f, -3.96157848e-03f, -5.62473275e-02f, -3.76831219e-02f,
  -3.78037728e-02f, 1.18764751e-01f, 1.16741940e-01f, 2.26341616e-02f, -7.15694577e-02f, 3.30346823e-02f, 5.19426167e-02f, 3.22506428e-02f, 8.35356787e-02f, -6.24160515e-03f,
  -9.21126083e-03f, 2.09847987e-02f, -4.80094738e-02f, -1.10471696e-02f, 9.04683843e-02f, 4.87899892e-02f, -9.33326259e-02f, -1.04232337e-02f, -6.25997931e-02f, -5.03146946e-02f,
  -1.34786382e-01f, -1.81572169e-01f, 4.51485179e-02f, -7.90266469e-02f, -3.30044106e-02f, -1.35309100e-01f, 1.91866457e-02f, -1.60364717e-01f, -1.02006659e-01f, -8.80961865e-02f,
  -4.58633229e-02f, 4.23344783e-02f, 2.53442615e-01f, -2.40536451e-01f, 3.56081814e-01f, 1.15607351e-01f, -2.25405067e-01f, -5.23512140e-02f, -9.44416896e-02f, -2.08808064e-01f,
  -1.67822391e-01f, -1.96928680e-01f, 4.72121947e-02f, -2.10050941e-01f, -1.63815454e-01f, -1.26406789e-01f, 1.31282881e-01f, 2.13023983e-02f, -1.30810067e-01f, 1.17747694e-01f,
  1.04693267e-02f, -1.78746805e-01f, -1.24636948e-01f, 3.73981260e-02f, -2.43957583e-02f, -3.93492989e-02f, 7.67156333e-02f, 1.27904847e-01f, -3.21353450e-02f, -3.61599065e-02f,
  4.60121222e-02f, 7.05261976e-02f, -1.23210505e-01f, -3.11779659e-02f, -5.62424436e-02f, -1.88851729e-02f, -2.11592345e-03f, -2.46091597e-02f, -2.52265297e-02f, 6.36813492e-02f,
  2.71126162e-02f, -5.87283634e-02f, -2.71305479e-02f, -3.85394283e-02f, 2.71395314e-02f, -1.56924278e-01f, -5.29188141e-02f, 1.59922808e-01f, -4.00268286e-02f, -1.09183080e-02f,
  -3.04772593e-02f, 3.95820588e-02f, -1.76661238e-02f, -9.98511463e-02f, -5.49875982e-02f, 1.39413131e-02f, -1.19358897e-02f, -1.10935442e-01f, 5.74945798e-03f, -9.22498927e-02f,
  -8.32702965e-02f, 1.30724795e-02f, -9.05939005e-03f, 5.13480464e-03f, 1.74674038e-02f, -2.87795030e-02f, 1.49797071e-02f, 4.45862561e-02f, -2.94234953e-03f, 3.47943567e-02f,
  -1.77369472e-02f, -5.29724136e-02f, 5.60826436e-02f, 1.62091162e-02f, -2.54378021e-02f, 9.31091681e-02f, 3.48443240e-02f, -2.68889870e-03f, 3.71147431e-02f, 1.14594959e-01f,
  -7.94543847e-02f, -1.74067795e-01f, -1.18848555e-01f, -7.41332322e-02f, 2.28910204e-02f, 4.85571101e-02f, -5.90476878e-02f, 2.85178348e-02f, 2.28224173e-02f, -1.13235660e-01f,
  -2.29012850e-03f, 8.00724104e-02f, 3.17069963e-02f, -3.88440713e-02f, 1.42983586e-01f, 2.92411894e-02f, -8.89189821e-03f, 7.52797797e-02f, -2.64409445e-02f, -2.99822335e-04f,
  -1.25690222e-01f, -6.60337284e-02f, 8.28832611e-02f, -6.95163235e-02f, -7.41211176e-02f, 8.41537432e-04f, -3.12513299e-02f, -2.09718812e-02f, 7.58483931e-02f, -4.01981845e-02f,
  9.02090371e-02f, -8.10299292e-02f, -1.06835499e-01f, 6.16723746e-02f, -7.24988133e-02f, -3.50667685e-01f, -1.77849188e-01f, -1.04114085e-01f, 7.61168450e-02f, -5.80417141e-02f,
  -8.85836855e-02f, 1.43111810e-01f, 7.14976341e-02f, -2.10324705e-01f, 1.82256922e-01f, 2.10345671e-01f, -1.98677361e-01f, -5.38543761e-02f, -2.13454645e-02f, -1.55395135e-01f,
  8.36473629e-02f, -1.65675059e-01f, -2.80724373e-02f, -2.07628861e-01f, -2.73613691e-01f, 3.23919468e-02f, 1.78779036e-01f, -1.53739259e-01f, -1.82134181e-01f, -5.81706921e-03f,
  1.56346299e-02f, -1.52446004e-02f, -1.09693371e-01f, 7.09341317e-02f, 1.89112350e-02f, -4.24877778e-02f, -1.72540188e-01f, -5.70358485e-02f, 8.20147470e-02f, 5.55256456e-02f,
  1.36851566e-02f, 6.82390556e-02f, 2.53747217e-02f, -3.00137582e-03f, -1.21005453e-01f, 5.44222556e-02f, 6.71028718e-02f, 3.84428799e-02f, 9.93883684e-02f, 2.03117356e-02f,
  1.29821189e-02f, 2.80876011e-02f, -9.34775695e-02f, 1.04545772e-01f, 1.08908363e-01f, -6.08630180e-02f, -1.25984773e-02f, -1.19440397e-02f, 4.34989482e-02f, 6.33142367e-02f,
  -7.21845776e-02f, 6.85801804e-02f, 1.25602856e-02f, -6.57729805e-02f, -6.11693077e-02f, -1.13080628e-01f, -4.36230004e-02f, 6.42929077e-02f, -1.11123547e-01f, -1.24946140e-01f,
  -1.98705010e-02f, 6.24484196e-03f, -5.56198992e-02f, 1.74760446e-02f, -7.82415792e-02f, 4.41199951e-02f, -6.39541298e-02f, -7.32055530e-02f, -1.40443891e-01f, -4.85792756e-02f,
  7.02449530e-02f, 8.91589653e-03f, 4.62398604e-02f, -8.93162489e-02f, -1.12868674e-01f, 6.48232475e-02f, -1.30483154e-02f, -8.93539414e-02f, 6.52111545e-02f, -6.73045814e-02f,
  -2.40998399e-02f, 9.41093713e-02f, -2.53682528e-02f, -5.33153377e-02f, -3.27587165e-02f, -5.13641909e-02f, -9.17633474e-02f, -8.59490708e-02f, -1.01437252e-02f, -9.75594744e-02f,
  -7.22122192e-02f, -3.12719382e-02f, 8.93707052e-02f, -3.09269801e-02f, 1.41847534e-02f, 3.81956398e-02f, 1.49381697e-01f, 1.36317253e-01f, 1.28860369e-01f, 1.15658781e-02f,
  -1.09380819e-02f, 9.21706334e-02f, 6.40408508e-03f, -1.95330195e-02f, -3.50435451e-02f, -2.44291819e-04f, 6.56947345e-02f, -3.32179144e-02f, 5.79446256e-02f, 7.48983994e-02f,
  -5.44449463e-02f, -2.41250902e-01f, 9.91484895e-02f, 1.82753485e-02f, 1.42013147e-01f, 6.17592409e-02f, 1.69091910e-01f, -4.76283627e-03f, -1.81893662e-01f, -3.25084150e-01f,
  -1.14010639e-01f, -9.20805186e-02f, -9.04358849e-02f, -1.21104486e-01f, 2.22740561e-01f, -1.39108449e-01f, -4.21662554e-02f, -1.22682536e-02f, -4.50344831e-02f, -4.07765657e-02f,
  4.97565567e-02f, 1.30985469e-01f, 1.22204147e-01f, 4.82060239e-02f, -6.13059774e-02f, -1.14058271e-01f, 7.39280833e-03f, 9.51254219e-02f, 8.51751585e-03f, 1.11288510e-01f,
  7.04275966e-02f, -8.44440013e-02f, 1.08513486e-05f, 9.15514752e-02f, 4.97886315e-02f, 1.75162796e-02f, 1.45900235e-01f, 1.10668965e-01f, 9.06184316e-02f, -4.93120700e-02f,
  9.34512690e-02f, 3.52416150e-02f, -1.95196792e-02f, -8.26296024e-03f, 7.47419298e-02f, 9.44659412e-02f, 3.64773721e-02f, 4.67503071e-02f, 3.43909264e-02f, -3.76521796e-02f,
  -7.35806599e-02f, 1.27363671e-02f, -4.84613441e-02f, -6.55639097e-02f, -1.69296507e-02f, 5.99246435e-02f, 4.55149002e-02f, -9.75738093e-02f, 5.50708035e-03f, 8.63698050e-02f,
  4.03697276e-03f, -7.40134045e-02f, 1.95191465e-02f, -7.63630075e-03f, -1.56986397e-02f, 4.03144993e-02f, 5.56465350e-02f, 7.56506110e-03f, 4.43643928e-02f, 5.30673889e-04f,
  -7.06400797e-02f, 4.50688377e-02f, -5.34591591e-03f, 7.45567456e-02f, -1.99515093e-02f, -1.26328140e-01f, 7.11109266e-02f, -1.12936862e-01f, -5.82820848e-02f, 4.42411862e-02f,
  1.18778069e-02f, 6.73938990e-02f, 8.90647247e-02f, -9.17111989e-04f, -5.91376089e-02f, 5.65252155e-02f, 3.66290398e-02f, -1.04651377e-01f, -6.01987205e-02f, 5.30400835e-02f,
  -9.28487852e-02f, -2.47125670e-01f, -3.77315730e-02f, 6.26431108e-02f, -1.37235075e-01f, -1.32828012e-01f, 6.77997842e-02f, 3.60475592e-02f, -2.22643856e-02f, 4.78956178e-02f,
  -1.80397592e-02f, -1.49758086e-02f, 6.26225248e-02f, 4.93764542e-02f, 1.22914352e-01f, -3.78500968e-02f, -3.30567360e-02f, 8.37750360e-02f, 8.37568715e-02f, -3.64250876e-02f,
  -1.90725904e-02f, 3.20289582e-02f, 3.67952250e-02f, 3.80906388e-02f, -5.29763438e-02f, 3.97161432e-02f, 7.10356608e-02f, -7.10338205e-02f, -2.84412224e-02f, -5.83330542e-02f,
  1.78587526e-01f, -2.40575567e-01f, -1.71600327e-01f, 1.14872539e-02f, 5.82491327e-03f, 8.19717348e-02f, -2.43427604e-01f, 7.82307163e-02f, -1.33526489e-01f, -2.25863624e-02f,
  1.44961506e-01f, 1.08082974e-02f, -2.01292858e-01f, 2.17815250e-01f, 1.83438703e-01f, -1.28626972e-01f, 1.31123975e-01f, 3.51453722e-02f, -9.66051295e-02f, -9.39966459e-03f,
  1.40873790e-01f, 2.69147813e-01f, 7.20701143e-02f, 2.36381784e-01f, -7.94594828e-03f, 5.66569082e-02f, 5.64134084e-02f, -6.80364389e-03f, 2.52963930e-01f, 2.08346516e-01f,
  4.79851738e-02f, -6.13843277e-02f, -2.53069587e-02f, -5.78096211e-02f, -1.49177667e-02f, 5.94252162e-02f, 4.21860702e-02f, 2.93327700e-02f, -3.01648546e-02f, -1.92999281e-02f,
  -4.68470156e-02f, 5.24105988e-02f, -3.99827510e-02f, 5.87710589e-02f, 1.73792318e-02f, -8.40541068e-03f, -9.07768160e-02f, 3.27645838e-02f, -3.05222217e-02f, 5.51853366e-02f,
  -7.74757788e-02f, -5.69244325e-02f, -7.32291639e-02f, -3.98787297e-02f, -8.54436010e-02f, 3.53001393e-02f, -5.83700687e-02f, -2.07804758e-02f, -1.03018709e-01f, -4.98172082e-03f,
  6.09794930e-02f, 2.85006012e-03f, -3.65282968e-02f, -8.07811618e-02f, -3.18512656e-02f, -7.23291114e-02f, -1.06596360e-02f, -9.61962566e-02f, -6.55640215e-02f, 5.32121444e-03f,
  -6.82385340e-02f, 3.20081562e-02f, 9.08352062e-02f, 5.76772615e-02f, -4.31733839e-02f, -1.73428934e-02f, 3.21488604e-02f, -5.51223569e-03f, -2.37851590e-02f, 4.53489833e-02f,
  4.80930656e-02f, 3.49075645e-02f, -6.07382180e-03f, 1.23161910e-04f, 7.00656623e-02f, 1.05037913e-01f, 6.97718337e-02f, 1.76188909e-02f, -1.18083611e-01f, -4.11489345e-02f,
  1.58738997e-02f, 3.79875489e-02f, 3.03026531e-02f, 1.01267789e-02f, -9.26391110e-02f, -2.54713986e-02f, -4.98586288e-03f, 1.86791550e-02f, -7.03873672e-03f, -2.81134583e-02f,
  6.28822446e-02f, -9.71182808e-02f, -1.02208830e-01f, 5.04134074e-02f, 1.32172238e-02f, -1.14329271e-01f, 5.96045144e-02f, -4.87029515e-02f, 1.05699059e-02f, 4.10635099e-02f,
  3.77016254e-02f, -3.48140337e-02f, -5.53147979e-02f, -1.19551281e-02f, -7.02520311e-02f, -3.25124972e-02f, 2.97634248e-02f, -3.18281651e-02f, 6.59851879e-02f, 6.15469031e-02f,
  -9.23199952e-02f, 2.64963359e-01f, -2.81241298e-01f, -1.16200000e-01f, 7.32468665e-02f, 2.62079477e-01f, 1.71903238e-01f, -7.63600990e-02f, -1.45103168e-02f, 2.00197160e-01f,
  1.44499704e-01f, 1.71333663e-02f, 6.26789266e-03f, 2.64415920e-01f, 4.90504764e-02f, 1.07451849e-01f, 1.28180444e-01f, 1.84493154e-01f, -1.52844951e-01f, 5.99553846e-02f,
  -1.02351911e-01f, 1.83162451e-01f, -1.68154448e-01f, -3.01109981e-02f, 6.90865740e-02f, -1.64303795e-01f, -4.18896750e-02f, -1.79968134e-01f, -2.25480590e-02f, 1.86321570e-03f,
  -2.12478843e-02f, -8.30843076e-02f, -8.05994794e-02f, -3.17267515e-02f, -2.30989680e-02f, 5.86648025e-02f, -2.89353281e-02f, -7.94213563e-02f, -9.80996266e-02f, -3.15273777e-02f,
  2.05898620e-02f, 1.57788005e-02f, -4.40126173e-02f, -1.04363309e-02f, -1.85070429e-02f, -1.66003853e-02f, 3.51985991e-02f, 1.70826484e-02f, 1.13749122e-02f, 5.83369210e-02f,
  -7.02662617e-02f, -1.46977995e-02f, 6.60188571e-02f, 4.41606641e-02f, -8.88890848e-02f, 1.58451952e-03f, 6.90180212e-02f, -2.49438696e-02f, -1.69803388e-02f, 5.87174855e-02f,
  3.27516510e-03f, 8.45078602e-02f, 8.98162648e-03f, -8.29270035e-02f, 1.47231622e-02f, -6.19025081e-02f, 7.32964352e-02f, 6.36716411e-02f, -6.57852739e-02f, 5.31368665e-02f,
  -7.42448643e-02f, 8.44662078e-03f, -3.54288612e-03f, 9.00796875e-02f, 5.87744229e-02f, -2.82318313e-02f, -5.92719615e-02f, 3.57320160e-02f, 3.46158892e-02f, 5.69409169e-02f,
  5.99871716e-03f, 1.75156537e-02f, -5.76070100e-02f, -2.06253640e-02f, 4.10824269e-02f, -2.29038633e-02f, 3.84168439e-02f, -1.91026293e-02f, -7.32416064e-02f, -9.79042351e-02f,
  1.65686578e-01f, 1.96895882e-01f, 8.36602133e-03f, 7.85035081e-03f, -3.04552671e-02f, 4.42910865e-02f, -2.63625365e-02f, -1.15816686e-02f, 2.63577240e-04f, 6.42842054e-02f,
  5.76442666e-02f, -7.53253177e-02f, -1.07541112e-02f, 1.10285841e-02f, -1.53618837e-02f, 5.86612038e-02f, 1.21838070e-01f, -6.10391945e-02f, -7.80452508e-03f, 4.96039502e-02f,
  1.28694344e-02f, 6.49164319e-02f, 1.05367573e-02f, 2.60727033e-02f, 1.03191920e-01f, 7.29712769e-02f, 8.04806948e-02f, -2.53591854e-02f, -1.39568653e-03f, 2.35081818e-02f,
  -2.32217073e-01f, -1.78651452e-01f, 4.77474108e-02f, -7.00790286e-02f, -1.02917351e-01f, 7.60056674e-02f, 1.69903517e-01f, -1.02246478e-01f, -1.75364897e-01f, 3.23968492e-02f,
  7.78660923e-02f, -2.12797057e-02f, 2.17379183e-01f, 1.21479318e-03f, 1.77438065e-01f, 3.69218662e-02f, 1.06399257e-05f, 9.96362343e-02f, -1.55530736e-01f, -2.89561097e-02f,
  -1.18416384e-01f, -8.34226236e-02f, 1.41358510e-01f, -2.01954082e-01f, -1.60750508e-01f, -9.26194638e-02f, -1.62647087e-02f, 5.07349148e-02f, 4.70602810e-02f, -8.39168392e-03f,
  -5.76861463e-02f, -1.19190723e-01f, -4.58450690e-02f, 8.80135000e-02f, -8.68443772e-03f, -7.27370754e-03f, 1.27106622e-01f, 1.11662984e-01f, -4.40272018e-02f, 3.12801078e-02f,
  5.03264554e-03f, -5.20965606e-02f, -1.65602967e-01f, -1.98466145e-02f, -8.20590705e-02f, 1.16882594e-02f, -1.00381553e-01f, -2.44722161e-02f, 1.23970294e-02f, 4.93070818e-02f,
  2.11686641e-03f, -6.86339452e-04f, 2.02808040e-03f, 7.32007399e-02f, -1.23892687e-02f, -5.61126247e-02f, 1.17082991e-01f, 3.47589813e-02f, -6.31447583e-02f, 1.65146217e-02f,
  -4.09461260e-02f, -7.57532865e-02f, 1.23478666e-01f, -4.73624766e-02f, -1.69141423e-02f, -7.31711090e-02f, -2.33340766e-02f, 6.14646487e-02f, 9.85353347e-03f, -1.97541788e-02f,
  -4.28289473e-02f, -3.68466564e-02f, -2.36697979e-02f, 1.35519532e-02f, 7.26768048e-05f, 5.73855883e-04f, -2.16612928e-02f, -3.63618769e-02f, 1.99435558e-02f, 2.30277563e-03f,
  3.34891938e-02f, -1.44334547e-02f, -7.22356960e-02f, 9.07054693e-02f, -4.09204699e-02f, 2.95999702e-02f, -7.06731677e-02f, -6.29338250e-02f, 3.47523019e-02f, 1.10534944e-01f,
  -1.13374621e-01f, -1.70239672e-01f, 3.36972214e-02f, -1.55882938e-02f, -7.09089860e-02f, 2.55618431e-02f, -3.02111432e-02f, -8.52151681e-03f, -3.81209105e-02f, 9.45016462e-03f,
  -4.42348048e-02f, -3.09725609e-02f, 9.91405696e-02f, -5.28750941e-04f, -1.35906162e-02f, -7.12982789e-02f, -2.86356341e-02f, 3.08099929e-02f, 5.79302944e-02f, -6.17038682e-02f,
  -6.91726059e-02f, -2.92840060e-02f, 8.49446356e-02f, -1.31788388e-01f, 1.02119103e-01f, 7.56522566e-02f, -7.01755956e-02f, 2.41624303e-02f, -5.42135425e-02f, -2.48447619e-03f,
  2.86995351e-01f, -3.39719504e-01f, -3.20042716e-03f, 1.03535175e-01f, 2.97242463e-01f, 3.36722769e-02f, 3.31497341e-02f, 1.93420976e-01f, 3.27130169e-01f, -1.85571730e-01f,
  3.37623693e-02f, -1.66320562e-01f, -2.94371814e-01f, 5.69192879e-02f, 1.19597793e-01f, -8.09705704e-02f, 1.10075764e-01f, -1.06824279e-01f, 3.83163542e-02f, 5.16978502e-02f,
  1.07337818e-01f, 7.58673251e-02f, 1.13006374e-02f, 2.80411001e-02f, 1.19969420e-01f, -2.63176095e-02f, -4.14588191e-02f, -9.97070745e-02f, 4.87929024e-03f, 6.39512786e-04f,
  -4.96912822e-02f, 6.69142157e-02f, 3.38002555e-02f, -1.83883049e-02f, -2.10567247e-02f, -9.56450254e-02f, -1.11508593e-01f, -1.16868541e-01f, 3.24560106e-02f, -1.48828272e-02f,
  -9.91338193e-02f, -8.41283519e-03f, -2.67099566e-03f, -4.00143750e-02f, -8.09151158e-02f, -2.67534377e-03f, -2.95715276e-02f, -4.98980880e-02f, 2.09969655e-02f, -7.51308575e-02f,
  -3.75925973e-02f, 1.54053625e-02f, 4.84161489e-02f, 3.98221798e-02f, -3.50016430e-02f, 4.07432579e-02f, 4.42663580e-02f, -1.33269817e-01f, -1.18414149e-01f, 1.22539267e-01f,
  7.32740329e-04f, -9.72123668e-02f, -1.13490773e-02f, 6.38935864e-02f, -2.29520984e-02f, 6.77862912e-02f, -6.51453882e-02f, -5.92775494e-02f, 3.73830535e-02f, 4.62931134e-02f,
  9.38143283e-02f, -3.94716747e-02f, -6.20920993e-02f, 1.19072273e-01f, 3.49511579e-03f, 9.73963514e-02f, 9.90114082e-03f, 3.76881063e-02f, -2.71789543e-02f, 1.19276293e-01f,
  -1.54864434e-02f, 6.33374974e-02f, 1.88666079e-02f, 1.01707757e-01f, 5.27906828e-02f, 2.84601003e-02f, -8.17179307e-02f, 9.39971879e-02f, 1.60223365e-01f, -7.43550807e-02f,
  -4.03377712e-01f, -2.70675033e-01f, -3.05488482e-02f, 5.29785976e-02f, 1.25312461e-02f, -3.09184156e-02f, -4.32389341e-02f, 9.34914313e-03f, -1.08922914e-01f, -1.46946851e-02f,
  -1.42159406e-03f, 3.19716074e-02f, 5.91927674e-03f, 1.41826225e-02f, -9.55738500e-02f, -4.93750675e-03f, -8.90215263e-02f, -1.10937960e-01f, -2.89254040e-02f, -1.93851702e-02f,
  2.60913372e-02f, -7.73256794e-02f, 1.39746023e-02f, 1.90973938e-01f, -2.06658412e-02f, -4.19166982e-02f, -7.23050013e-02f, -5.17667234e-02f, -4.49988432e-02f, 1.55201824e-02f,
  -4.28281240e-02f, -4.13584784e-02f, -3.46163623e-02f, 7.48320669e-02f, -2.86871791e-02f, -7.91351423e-02f, -1.67903841e-01f, 1.68118104e-01f, -1.99249208e-01f, 7.01259673e-02f,
  4.67940941e-02f, -2.44324744e-01f, 4.33144048e-02f, -8.28285143e-02f, -7.97241107e-02f, -1.08690865e-01f, 7.45321438e-02f, -2.35331338e-02f, 1.47148604e-02f, 8.35103095e-02f,
  6.84496164e-02f, 7.14804307e-02f, -3.20055336e-02f, 1.00722097e-01f, 5.03294393e-02f, 1.68778107e-01f, 2.99820274e-01f, 7.52823129e-02f, 2.25837603e-01f, -1.48206819e-02f,
  -7.58378953e-02f, -7.50840735e-03f, -3.62002151e-03f, -1.36018351e-01f, 8.70115981e-02f, 3.92987765e-02f, -7.38202082e-03f, 6.42384142e-02f, -4.88148973e-04f, 1.80316418e-02f,
  -4.27676290e-02f, 4.19950970e-02f, 1.09485768e-01f, 1.92163289e-02f, 4.98182923e-02f, -7.79276043e-02f, -7.60758370e-02f, -3.72744985e-02f, -9.24413875e-02f, -4.24709730e-02f,
  5.96231148e-02f, -2.53790524e-02f, 9.83719975e-02f, -7.51778483e-02f, -7.51306117e-03f, 9.29709896e-02f, -2.23982017e-02f, -3.11758146e-02f, 6.75301924e-02f, -3.78665179e-02f,
  1.47741422e-01f, -2.85177492e-02f, -2.08353773e-02f, -6.73737079e-02f, -5.77175282e-02f, 7.41448440e-03f, 7.04750493e-02f, 4.26538959e-02f, -4.94840834e-03f, -7.22966269e-02f,
  4.75645624e-02f, -2.88198777e-02f, 1.24310292e-02f, -3.55259068e-02f, -6.73873946e-02f, -5.52278273e-02f, 6.70101643e-02f, 2.95671988e-02f, -4.49590497e-02f, -5.54122552e-02f,
  2.14746199e-03f, 1.11042850e-01f, -3.88837866e-02f, 1.19431183e-01f, 3.26511823e-03f, 4.28232141e-02f, -3.41542438e-02f, -5.32872304e-02f, -4.31608111e-02f, -9.92035866e-03f,
  -5.48841804e-02f, 1.46498933e-01f, -2.31164843e-02f, -4.49514873e-02f, 2.13033855e-02f, 2.49243323e-02f, -3.85922380e-02f, 1.51514797e-03f, -4.68513556e-02f, -6.23521283e-02f,
  6.85664639e-02f, 2.46704109e-02f, 1.68343948e-03f, -4.93214540e-02f, 4.86206822e-02f, -5.17139386e-04f, 3.00864782e-03f, -2.84579583e-02f, 1.13893956e-01f, 5.61384968e-02f,
  7.29091018e-02f, 1.17093913e-01f, 3.96732055e-02f, 6.32538635e-04f, 5.34331873e-02f, 1.24561593e-01f, 1.40661329e-01f, -3.18853259e-02f, 1.10391416e-01f, 5.16959466e-02f,
  4.32435051e-03f, -1.23936854e-01f, -2.11044624e-02f, 2.42835730e-01f, -1.54671213e-02f, -2.04550624e-01f, -2.89626062e-01f, -8.15208703e-02f, -1.55101210e-01f, -2.21493080e-01f,
  -6.74025118e-02f, 3.46030332e-02f, -1.16682321e-01f, 1.89080790e-01f, 2.88607776e-01f, -4.13211286e-02f, 7.60630891e-02f, -4.03654836e-02f, 1.29938334e-01f, 1.00896843e-01f,
  1.99114665e-01f, 1.44612625e-01f, 2.09944174e-01f, 1.63813829e-01f, -1.07974950e-02f, 2.29596734e-01f, 2.68958300e-01f, 2.89125517e-02f, 2.45598838e-01f, 1.52904510e-01f,
  -5.20901941e-02f, 4.59830016e-02f, -2.42304169e-02f, -1.14973206e-02f, 7.85433501e-02f, -5.36968522e-02f, 3.64572629e-02f, 7.78336078e-02f, 3.81195620e-02f, 5.52738132e-03f,
  -3.59358378e-02f, -3.42318453e-02f, 4.67962250e-02f, 1.07400693e-01f, -3.85616571e-02f, 3.28311510e-02f, 6.11509122e-02f, -4.44373935e-02f, -7.81672522e-02f, 5.90119064e-02f,
  -1.09739482e-01f, -5.40702492e-02f, -3.42750698e-02f, 4.12808582e-02f, -4.13649157e-02f, -7.88512230e-02f, -3.67276184e-02f, 6.99603334e-02f, -9.78411064e-02f, 3.90028320e-02f,
  -4.12338153e-02f, -5.44657484e-02f, -5.92112616e-02f, 1.39616653e-02f, 2.12098029e-03f, 7.89502859e-02f, -1.28097637e-02f, 4.91781421e-02f, 5.00086546e-02f, 4.75412011e-02f,
  -2.57516839e-02f, 5.55088222e-02f, 4.83345650e-02f, -5.44758737e-02f, 5.04792901e-03f, -5.87443775e-03f, 6.86672181e-02f, 4.01233211e-02f, 4.25146818e-02f, -3.22309583e-02f,
  -6.75652921e-02f, -1.35731315e-02f, 5.61797200e-03f, -1.45432046e-02f, 4.19249805e-03f, 4.08011749e-02f, 5.69316670e-02f, -1.12033496e-02f, -2.28664204e-02f, 2.45411117e-02f,
  -5.94474226e-02f, 8.93941373e-02f, 4.95918021e-02f, -1.58843305e-02f, 5.08019552e-02f, 8.38730205e-03f, 7.72171319e-02f, 6.01986013e-02f, -3.55229899e-02f, -8.87248963e-02f,
  2.05273484e-03f, -4.04004082e-02f, -4.42313105e-02f, 6.25061840e-02f, 7.03309849e-02f, -1.03772748e-02f, 5.08758835e-02f, 1.96910053e-02f, 9.59711894e-02f, 1.26229778e-01f,
  -4.24790429e-03f, -1.17295057e-01f, -5.01452014e-02f, -9.60111339e-03f, -8.53789523e-02f, -1.31429359e-01f, 2.01838799e-02f, -1.51219079e-02f, 6.42125830e-02f, -5.38970204e-03f,
  -1.00337066e-01f, 7.09422156e-02f, -1.02311678e-01f, -1.47173345e-01f, 2.00982746e-02f, -1.85941130e-01f, -2.80343831e-01f, 8.74544531e-02f, 6.38249367e-02f, -1.08745039e-01f,
  -1.84804052e-01f, 4.92967404e-02f, 9.74611193e-03f, -2.21630514e-01f, 6.13617301e-02f, 1.50709227e-01f, -1.57263950e-01f, -1.48196831e-01f, 8.12141970e-02f, -1.56012759e-01f,
  -7.78759941e-02f, -2.31011853e-01f, -2.79618241e-02f, 6.58080056e-02f, -1.93432823e-01f, -1.02015391e-01f, 1.55566614e-02f, -1.36652840e-02f, 6.13494869e-03f, 6.43681660e-02f,
  7.22474977e-02f, -1.83152407e-02f, 6.32056817e-02f, 1.83037259e-02f, -9.08735991e-02f, -2.94995811e-02f, -1.17273659e-01f, 7.21555948e-02f, -3.35720070e-02f, -1.16238743e-01f,
  -9.84006524e-02f, -4.97078001e-02f, 2.16092207e-02f, -3.44170420e-03f, 1.48677838e-03f, 3.59495319e-02f, -6.72503412e-02f, 7.24685087e-04f, -1.22766383e-03f, 3.95052582e-02f,
  -5.08494899e-02f, 1.02929085e-01f, -7.17767850e-02f, -5.53388707e-03f, -3.97264026e-02f, 9.15127993e-02f, 1.92391053e-02f, -3.01104821e-02f, -2.23904774e-02f, 7.36395866e-02f,
  -2.24453099e-02f, -1.25788569e-01f, -1.59048270e-02f, 7.28630126e-02f, 6.99836463e-02f, 2.71478929e-02f, -1.51068978e-02f, -8.70298315e-03f, -1.61660865e-01f, -8.11586305e-02f,
  8.73440653e-02f, 1.13909721e-01f, -8.84571970e-02f, -7.21769705e-02f, -4.88823429e-02f, 4.86795194e-02f, 1.43199116e-02f, 1.35566089e-02f, 2.42798217e-03f, 7.94171095e-02f,
  2.64274050e-02f, -7.29750991e-02f, 3.63495536e-02f, -9.17808563e-02f, 4.86336313e-02f, 3.51062045e-02f, -7.91520346e-03f, 2.69669481e-02f, 7.33792922e-03f, -6.44588247e-02f,
  3.08281407e-02f, -1.27585500e-01f, -7.75336288e-03f, 3.57204191e-02f, -5.98398910e-04f, -1.75431706e-02f, -1.14092171e-01f, 7.03478605e-02f, -9.91493165e-02f, -2.45250911e-02f,
  -9.12676454e-02f, -8.98457840e-02f, 1.13194380e-02f, -5.49249584e-03f, 5.72024770e-02f, -9.38611850e-03f, -1.31850034e-01f, 2.52058301e-02f, 1.90566748e-03f, 4.27705161e-02f,
  -7.84175023e-02f, -5.71031980e-02f, -9.27268416e-02f, -8.81575719e-02f, -6.02999516e-02f, 1.63263064e-02f, 9.86775830e-02f, 6.82078600e-02f, -3.96441948e-03f, 7.88436458e-02f,
  1.66120335e-01f, 3.02824050e-01f, 3.75963449e-01f, 4.28198248e-01f, -8.40951726e-02f, -3.08094621e-01f, -1.80934802e-01f, 8.56822878e-02f, -5.03919721e-02f, 6.70455471e-02f,
  -3.62945348e-02f, 2.14708567e-01f, -4.06371839e-02f, 2.30065688e-01f, -2.60311067e-01f, -1.36129349e-01f, -1.00903861e-01f, 5.84222041e-02f, 5.00603346e-03f, 1.76966175e-01f,
  -9.43288058e-02f, -9.64068919e-02f, 1.65999159e-01f, -7.38047343e-03f, 1.50303647e-01f, 2.00819090e-01f, 1.01676676e-02f, -5.49338050e-02f, 2.75289237e-01f, -1.47663876e-01f,
  -1.40500709e-01f, 1.04819417e-01f, 1.22492097e-01f, -4.72463807e-03f, -2.07620356e-02f, -1.43207656e-03f, 8.38263426e-03f, -8.22651237e-02f, -6.58936501e-02f, 4.00787406e-02f,
  1.12855308e-01f, -8.90386999e-02f, -2.78431475e-02f, 3.18069458e-02f, 4.96299565e-03f, 7.18819126e-02f, 5.60558029e-02f, 2.52139978e-02f, 1.34514704e-01f, 1.14258654e-01f,
  1.39232233e-01f, 9.03243870e-02f, -1.65406875e-02f, 4.41083172e-03f, 1.20840650e-02f, 2.54077166e-02f, -1.38379857e-02f, 8.94928202e-02f, 7.54134133e-02f, 3.55087742e-02f,
  8.37352350e-02f, -1.59966290e-01f, -1.17895696e-02f, -1.99689474e-02f, 4.85347882e-02f, -3.35614383e-02f, 4.12308872e-02f, -1.47640482e-01f, -3.19405459e-02f, -6.10450702e-03f,
  -6.25218004e-02f, 1.51455577e-03f, 1.81258228e-02f, 1.78063158e-02f, 5.77123016e-02f, 2.46688146e-02f, -9.87229962e-03f, -6.06831573e-02f, -4.54765856e-02f, 1.16986617e-01f,
  -1.24933988e-01f, -9.58791524e-02f, 4.02058996e-02f, -1.88205596e-02f, -1.55640513e-01f, 3.23998369e-02f, -9.17655602e-03f, 4.47087623e-02f, 2.79547591e-02f, -1.82155706e-02f,
  3.57574672e-02f, 9.74208713e-02f, 4.54839766e-02f, -8.46640244e-02f, -1.20230415e-03f, -8.92538130e-02f, -6.91223815e-02f, 6.93022087e-02f, 7.36406371e-02f, -2.88987700e-02f,
  -3.88624594e-02f, -7.52859488e-02f, -3.01779434e-02f, 4.52566706e-02f, 4.52743508e-02f, -2.69684289e-03f, -9.20863971e-02f, 7.56430579e-03f, 9.50740743e-03f, 1.10840142e-01f,
  1.43531427e-01f, -7.63251781e-02f, -2.33699530e-02f, -7.78055340e-02f, 1.15413759e-02f, -6.21071681e-02f, -4.35083965e-03f, 5.64774573e-02f, 6.56896904e-02f, -6.25655055e-02f,
  -5.25654972e-01f, -1.51335254e-01f, -3.12648118e-02f, -3.78684402e-02f, -5.46131060e-02f, 1.20099202e-01f, 2.86763072e-01f, -1.98528960e-01f, -2.57995188e-01f, 2.05594704e-01f,
  2.34541014e-01f, -1.05917305e-01f, 1.84711322e-01f, 1.36309668e-01f, 6.24900078e-03f, 3.30003463e-02f, 8.28986391e-02f, 9.02222767e-02f, -1.00797072e-01f, -1.49235755e-01f,
  -8.71101767e-02f, 8.56917724e-02f, 1.46685556e-01f, -7.24891722e-02f, 1.27918199e-02f, -7.52815157e-02f, 7.28284568e-02f, 5.64914495e-02f, 9.96762365e-02f, -8.89409054e-03f,
  -6.16656020e-02f, -1.55094758e-01f, -2.95757651e-02f, 6.22750772e-03f, -1.76373068e-02f, 1.48601457e-03f, 8.73307660e-02f, 8.20019618e-02f, -4.30518650e-02f, -9.73490067e-03f,
  -1.13233747e-02f, -1.09496862e-01f, -8.25729370e-02f, 3.30788642e-02f, -2.52632033e-02f, 2.01749094e-02f, -1.15062229e-01f, 8.62060636e-02f, -2.05660202e-02f, 4.69922554e-03f,
  -2.34944671e-02f, -3.33605856e-02f, 1.07072450e-01f, 1.09891649e-02f, -4.00451720e-02f, -6.03391826e-02f, 2.63284706e-02f, 5.71085066e-02f, -1.02626070e-01f, -3.82923633e-02f,
  -7.82851353e-02f, -7.06689283e-02f, -5.12265190e-02f, 2.75748335e-02f, 9.86859128e-02f, 1.08526334e-01f, 5.81236333e-02f, 3.66877168e-02f, 1.32663734e-02f, -2.28409898e-02f,
  -2.68376339e-02f, -4.93449494e-02f, 2.25452501e-02f, 3.08965091e-02f, -3.34482901e-02f, 6.32069632e-02f, 6.49349391e-02f, 4.13082354e-02f, 1.56129822e-01f, -8.52222070e-02f,
  -2.11109184e-02f, -4.30039205e-02f, 9.69699249e-02f, -4.69523631e-02f, -3.71157452e-02f, 4.01516482e-02f, 9.12297070e-02f, 5.04109487e-02f, 3.36516239e-02f, 4.54376452e-02f,
  -2.19587281e-01f, -2.15984955e-01f, -5.98174967e-02f, 1.34966918e-03f, -8.69559571e-02f, 1.42494217e-02f, -3.97151262e-02f, -2.97290161e-02f, -6.37602527e-03f, -7.95028582e-02f,
  -6.90899864e-02f, -5.11326864e-02f, -1.31852813e-02f, 6.21014573e-02f, -5.21363840e-02f, 1.26698157e-02f, -1.14358075e-01f, 6.12551579e-04f, 2.17781384e-02f, -3.22416797e-02f,
  4.14591432e-02f, -5.12337163e-02f, -9.41280499e-02f, 3.52731459e-02f, 4.46389802e-02f, 1.04494886e-02f, -3.91577594e-02f, 3.96640711e-02f, -5.20749316e-02f, 3.14019434e-02f,
  -1.09775364e-01f, 3.78805883e-02f, 1.17258884e-01f, 2.19144702e-01f, -1.16443709e-01f, -3.27822298e-01f, -3.38517219e-01f, 2.68578287e-02f, -9.04556736e-02f, -1.42617673e-01f,
  -6.86878115e-02f, -5.92043325e-02f, 1.21182585e-02f, -3.66127025e-03f, 1.33972183e-01f, 1.45381570e-01f, -4.72351946e-02f, -7.10169598e-02f, 5.13210185e-02f, 9.62081254e-02f,
  1.49553165e-01f, 7.29723573e-02f, 3.13539863e-01f, 4.03311290e-02f, -1.51745351e-02f, 1.33334966e-02f, 2.40266457e-01f, -3.47165279e-02f, 3.21285278e-02f, -7.28552118e-02f,
  -6.02989793e-02f, 1.73404306e-01f, -1.17861442e-02f, 4.48150933e-02f, 9.36720800e-03f, -1.05319187e-01f, -6.23627901e-02f, -1.31820207e-02f, 1.67034063e-02f, 1.08473144e-01f,
  -1.84314642e-02f, 8.74610320e-02f, -3.62976305e-02f, -2.16392223e-02f, -7.55372569e-02f, 2.64396463e-02f, 2.39584241e-02f, -2.11613867e-02f, -1.58329140e-02f, -3.70843932e-02f,
  6.08657394e-03f, 3.11100520e-02f, -6.95333853e-02f, 1.25002578e-01f, 8.64558369e-02f, 6.28875708e-03f, 1.11857988e-02f, -1.07860621e-02f, 1.89885572e-02f, 7.85682872e-02f,
  -2.72031147e-02f, -8.55167508e-02f, -2.83522215e-02f, -5.90279102e-02f, 4.72692959e-02f, -8.60479102e-03f, -5.92438057e-02f, -3.47939841e-02f, -1.18078981e-02f, -6.81472793e-02f,
  3.46203241e-03f, 4.62089330e-02f, -2.65482720e-02f, -6.95347488e-02f, -1.82958003e-02f, -8.26073717e-03f, 1.34761231e-02f, 1.50335236e-02f, -6.27007857e-02f, -2.12005973e-02f,
  4.69579771e-02f, 8.80011357e-03f, -4.33424413e-02f, 4.36830381e-03f, -9.64680240e-02f, -4.21157368e-02f, -8.04328173e-02f, 2.78346129e-02f, 1.13197066e-01f, 4.35803607e-02f,
  1.05165347e-01f, 3.47508669e-01f, 4.30380292e-02f, -3.67761627e-02f, -2.50135045e-02f, 1.13218520e-02f, 1.28616849e-02f, -7.37178698e-02f, 7.22002760e-02f, 6.69412240e-02f,
  2.89461315e-02f, -2.82339100e-02f, -9.90514178e-04f, -6.54362291e-02f, -9.75604728e-03f, -3.51869501e-02f, -1.26847932e-02f, 4.24959734e-02f, 6.36282861e-02f, 5.77432923e-02f,
  2.57352665e-02f, -1.67199988e-02f, 1.90726593e-02f, -1.20102443e-01f, -7.09540257e-03f, 6.22872300e-02f, -7.20757991e-02f, -3.57508962e-03f, 8.89471099e-02f, 6.31718431e-03f,
  -1.72079593e-01f, 2.80873999e-02f, 2.34917912e-04f, -1.76962838e-01f, 3.98955494e-02f, -1.40436307e-01f, -2.40956619e-02f, 1.33667663e-01f, 7.42252469e-02f, 2.58538216e-01f,
  1.19550548e-01f, 6.41672090e-02f, 2.16973145e-02f, -5.41932583e-02f, -2.28234276e-01f, -8.58563855e-02f, -2.64190495e-01f, -9.95916277e-02f, -7.82527328e-02f, -7.46033639e-02f,
  -1.02037005e-01f, -3.10582924e-03f, -7.88961127e-02f, 5.50884157e-02f, -3.73887992e-03f, 1.26239434e-01f, 5.25359213e-02f, 5.58570400e-02f, -6.59451336e-02f, 4.17386219e-02f,
  5.53949587e-02f, 1.44591570e-01f, 5.01914062e-02f, 1.12271152e-01f, -5.12675494e-02f, -5.53284548e-02f, 6.43809745e-03f, 1.05684370e-01f, -2.05585212e-02f, 8.49278271e-02f,
  -1.63806714e-02f, 1.43030107e-01f, -4.61489987e-03f, 6.60520643e-02f, -6.94593939e-04f, 1.18347578e-01f, -8.51159543e-02f, -1.77372266e-02f, 1.26772866e-01f, -5.53368703e-02f,
  -7.97839612e-02f, -4.52640913e-02f, -7.73966908e-02f, 1.05515001e-02f, -4.99542058e-02f, 1.80513095e-02f, -2.10524891e-02f, 2.91831829e-02f, 3.81685048e-02f, -8.77930745e-02f,
  -3.96064408e-02f, -7.73166269e-02f, -2.29704622e-02f, 6.32444993e-02f, 4.73418869e-02f, 1.06354937e-01f, 4.66379300e-02f, 4.61214073e-02f, -2.18038931e-02f, 2.11441498e-02f,
  6.63847942e-03f, -1.62830632e-02f, -4.43409309e-02f, -4.10275571e-02f, -7.64132142e-02f, 5.58779165e-02f, 4.38722596e-02f, 4.47498038e-02f, -1.59736514e-01f, -4.27659526e-02f,
  -1.27506312e-02f, 4.36776429e-02f, 7.48189762e-02f, -2.84212381e-02f, 5.56254759e-02f, 1.92785133e-02f, -4.50926088e-02f, 3.97510681e-04f, 7.44908080e-02f, -7.94848651e-02f,
  -6.92886561e-02f, 5.25318198e-02f, 7.79566690e-02f, 1.32021114e-01f, 1.69442445e-02f, 3.80620770e-02f, -6.86252862e-02f, -1.90758817e-02f, -3.23030651e-02f, 3.22992466e-02f,
  -7.23185111e-03f, 9.58390236e-02f, 1.07654007e-02f, 7.97388256e-02f, -4.87085134e-02f, -4.15169522e-02f, 1.66367069e-02f, -7.67448694e-02f, -1.18776867e-02f, -1.33218551e-02f,
  -1.70303658e-02f, -5.20421937e-03f, 1.34187853e-02f, -9.05046090e-02f, 7.70830875e-03f, 2.80197877e-02f, 9.04460475e-02f, -1.95511002e-02f, -8.39512795e-02f, -4.18461338e-02f,
  -5.61875045e-01f, 2.55776823e-01f, 2.70611215e-02f, -2.48799443e-01f, 8.94716009e-02f, -1.07866175e-01f, -5.48542365e-02f, 7.74351656e-02f, -1.06653593e-01f, -6.04625884e-03f,
  6.81018550e-03f, -3.36421840e-02f, 7.87167773e-02f, 1.56437811e-02f, -1.76020578e-01f, -1.32790604e-03f, -9.82553884e-02f, -1.27905324e-01f, 7.31739551e-02f, -2.15023011e-02f,
  -1.05059117e-01f, 3.23568210e-02f, 8.01155251e-03f, 2.27622584e-01f, -6.01649545e-02f, -9.17367041e-02f, -1.04802348e-01f, 1.44352242e-01f, 9.23476834e-03f, 6.42035976e-02f,
  -2.23777279e-01f, -1.22842133e-01f, -2.18762040e-01f, -6.54486790e-02f, -1.51465029e-01f, -1.06844559e-01f, -1.05401151e-01f, 5.71049042e-02f, 3.07309977e-03f, -3.89710553e-02f,
  -5.60496412e-02f, 1.36645548e-02f, -6.89266622e-02f, -3.23126093e-02f, -3.44501324e-02f, -6.42375499e-02f, 6.28345981e-02f, -1.80195123e-02f, 6.09320253e-02f, 2.80513577e-02f,
  6.87484145e-02f, 5.64629249e-02f, -2.03214325e-02f, 3.57689708e-02f, -8.22403748e-03f, 2.82687554e-03f, -3.35291661e-02f, -1.63827147e-02f, -3.66657190e-02f, -6.38345480e-02f,
  5.94842657e-02f, -1.10995635e-01f, 4.51014638e-02f, 7.35589955e-03f, 5.05656609e-03f, 1.64245423e-02f, -2.29574945e-02f, -4.47442383e-02f, -5.10778278e-02f, 8.55274871e-02f,
  1.17514981e-02f, 1.61033999e-02f, -6.42330293e-03f, 1.62361488e-02f, 5.14902640e-04f, -1.70129333e-02f, -4.78828959e-02f, -2.69110575e-02f, 3.64972763e-02f, -1.07162194e-02f,
  -3.63911353e-02f, -2.14753784e-02f, 4.88795452e-02f, -2.14931127e-02f, -8.10826942e-03f, -4.61730883e-02f, 3.43101248e-02f, 2.70399619e-02f, -4.53709476e-02f, -2.47235168e-02f,
  -3.54257822e-01f, -3.12756658e-01f, -8.94069225e-02f, -2.72008795e-02f, -2.20836932e-03f, -3.49101499e-02f, 1.76852681e-02f, -5.22715524e-02f, -5.03822863e-02f, -5.73862903e-02f,
  1.39648607e-02f, -2.58025117e-02f, 1.69721898e-03f, 5.85673733e-05f, -9.63314250e-03f, -1.01703815e-01f, 6.82245241e-04f, 2.79362244e-03f, -1.41177461e-01f, -6.21826248e-03f,
  -4.64568613e-03f, -1.07953483e-02f, 6.65669441e-02f, 7.04021528e-02f, 3.28034237e-02f, -4.50143814e-02f, 9.37186461e-03f, 1.11638755e-02f, -4.35218401e-02f, 4.74805385e-02f,
  1.28958359e-01f, -1.67139769e-01f, 2.66513020e-01f, 2.29017087e-03f, 1.87992632e-01f, 7.14870766e-02f, 6.67480305e-02f, -4.07899059e-02f, 8.99749473e-02f, -1.48801357e-01f,
  1.20721288e-01f, -3.38306166e-02f, 9.55747217e-02f, -1.07585840e-01f, 2.61208028e-01f, -4.31694277e-02f, -9.89512056e-02f, -9.64191258e-02f, -3.61678191e-02f, -3.61214392e-02f,
  -3.18604298e-02f, -2.64657259e-01f, -5.21416329e-02f, -3.15195858e-01f, -2.83398759e-02f, -4.60365862e-02f, -9.33748931e-02f, 1.99686037e-03f, -1.51380464e-01f, 5.22314273e-02f,
  4.79883887e-03f, -5.51164337e-02f, 6.94793314e-02f, -1.70777943e-02f, -5.85151352e-02f, 6.31367266e-02f, 2.44742204e-02f, 9.52990502e-02f, 6.82919919e-02f, 7.62125179e-02f,
  -3.20095494e-02f, 1.00789607e-01f, -1.42742991e-01f, -1.48247005e-02f, 1.26166893e-02f, -5.37904799e-02f, 7.51147792e-02f, 9.46519449e-02f, 8.21584016e-02f, 9.04285014e-02f,
  8.46044794e-02f, 3.23831737e-02f, 4.48990837e-02f, -7.68469349e-02f, 3.28911357e-02f, 8.65442231e-02f, 8.50186311e-03f, 1.09981686e-01f, 4.36451193e-03f, 8.79105255e-02f,
  -1.20443299e-01f, 5.98948486e-02f, 8.38987157e-03f, -3.34857740e-02f, 3.70107777e-02f, 8.74151513e-02f, 3.92701924e-02f, 6.42075539e-02f, 7.50267729e-02f, 1.31504079e-02f,
  1.27502503e-02f, 7.83146769e-02f, -4.12721746e-03f, 9.28271376e-03f, -4.24836529e-03f, 1.95421092e-02f, -5.64026088e-02f, -3.79433855e-03f, -1.66318286e-02f, -8.59483257e-02f,
  -1.06312439e-01f, 4.81956936e-02f, -1.06018551e-01f, 6.50220066e-02f, -6.50682822e-02f, -2.62443237e-02f, -2.50136713e-03f, -8.00162032e-02f, 1.12354578e-02f, -1.06777437e-01f,
  -1.00192890e-01f, -2.41264820e-01f, -9.54815447e-02f, -2.45927330e-02f, -6.35463297e-02f, -8.65378454e-02f, 4.63691056e-02f, 2.67054569e-02f, -5.39111346e-02f, -2.42906995e-02f,
  2.49641202e-02f, 1.43512981e-02f, 2.93829646e-02f, 1.25682816e-01f, -5.21860160e-02f, -2.64754500e-02f, -6.10263720e-02f, -8.00393820e-02f, 4.25562300e-02f, -8.82904157e-02f,
  -3.29560637e-02f, 5.39921932e-02f, 8.71098340e-02f, -1.76361930e-02f, 6.69636950e-03f, 7.92321414e-02f, -1.25249457e-02f, -4.55552451e-02f, -4.00717147e-02f, -1.03232823e-01f,
  -3.03507239e-01f, -5.72916381e-02f, -1.79162771e-01f, -8.05840343e-02f, 1.28416583e-01f, -1.49351433e-01f, -5.87154329e-02f, -2.51700506e-02f, -9.76905823e-02f, 2.26185411e-01f,
  1.69090167e-01f, -1.57445639e-01f, 1.72605738e-02f, -2.71195304e-02f, -2.34754398e-01f, -1.48602739e-01f, -1.10211559e-01f, -5.64898625e-02f, -1.70498446e-01f, 1.52896598e-01f,
  -1.48806557e-01f, 1.66870058e-01f, -5.83167560e-02f, 1.44674554e-01f, 6.33337423e-02f, 5.39974384e-02f, 3.50511998e-01f, 8.25074464e-02f, 9.31071863e-02f, -1.00440204e-01f,
  -7.64730126e-02f, -1.29514677e-03f, -6.33084923e-02f, -6.01851381e-02f, 6.95175864e-03f, 3.59006301e-02f, 4.76991683e-02f, -5.67314997e-02f, 3.31204571e-02f, -2.33608000e-02f,
  -8.59453008e-02f, -8.78470615e-02f, -1.27521027e-02f, 2.40784436e-02f, -1.03279166e-01f, 2.05679331e-02f, -1.37748882e-01f, -4.50435169e-02f, -4.25958894e-02f, -5.69068417e-02f,
  -1.54374319e-03f, -7.86914527e-02f, -5.63917495e-02f, -6.58170599e-03f, -2.84578111e-02f, -4.10837233e-02f, -7.16780946e-02f, 8.52113664e-02f, 3.06200446e-03f, 8.35382640e-02f,
  4.85753343e-02f, -5.55302985e-02f, -9.24288332e-02f, -9.19963419e-03f, 4.50950749e-02f, 1.08412646e-01f, -9.90472212e-02f, -4.28376757e-02f, -2.21506692e-02f, 4.60885949e-02f,
  5.52149350e-03f, -3.70006263e-02f, -3.96987237e-03f, 3.20060775e-02f, -3.79026234e-02f, -6.78290278e-02f, -3.19787487e-02f, 9.52102765e-02f, 5.39262071e-02f, 5.02286069e-02f,
  3.94777022e-02f, -1.39388302e-02f, 5.25255501e-02f, -5.79257961e-04f, -5.76194599e-02f, 6.49091825e-02f, 8.11201613e-03f, 1.07193053e-01f, 1.94995403e-02f, -6.80010170e-02f,
  8.60647932e-02f, 1.97848067e-01f, -1.98472831e-02f, 7.31209442e-02f, -7.09104585e-03f, 1.92488208e-02f, 5.20095578e-04f, 3.77609092e-03f, 4.26466903e-03f, 1.08707167e-01f,
  1.78095669e-01f, -1.69131249e-01f, 4.62236106e-02f, 7.64908642e-02f, -9.79632586e-02f, 1.51333883e-02f, -1.84296165e-02f, 1.95472278e-02f, -2.68638064e-03f, -4.99480069e-02f,
  2.38188822e-02f, -5.11887716e-03f, -1.71579391e-01f, 9.09467265e-02f, -2.98712938e-03f, 3.86165939e-02f, -1.12696029e-02f, 1.28755704e-01f, 1.31130025e-01f, 9.75087509e-02f,
  7.55591318e-02f, 1.79438397e-01f, 1.53834924e-01f, 2.37934798e-01f, 2.56168516e-03f, 3.62522602e-02f, 1.17004506e-01f, -8.06521811e-03f, 3.40445340e-01f, 3.98504660e-02f,
  -9.24595594e-02f, 3.44123930e-01f, -1.41004756e-01f, 9.45451390e-03f, -2.17171863e-01f, -9.06206295e-02f, 1.23479001e-01f, 1.19341977e-01f, 5.25235049e-02f, 1.05310112e-01f,
  4.69524637e-02f, -2.60365009e-01f, -2.18458071e-01f, -2.08550841e-01f, -9.60605964e-03f, 1.26058072e-01f, -2.23698840e-01f, -2.90640574e-02f, 8.64887051e-03f, -1.57075021e-02f,
  4.48381230e-02f, 1.38669953e-01f, -1.01954760e-02f, 2.56357212e-02f, 6.37562247e-03f, 2.60252971e-02f, -4.49531898e-02f, -1.85550619e-02f, 9.89675969e-02f, 1.52416959e-01f,
  -3.87605117e-03f, -8.06744117e-03f, 3.39587256e-02f, -1.12987794e-01f, 6.50484711e-02f, -6.01485185e-02f, 1.33226893e-03f, -5.82738174e-03f, -2.53020413e-02f, 1.19782500e-02f,
  -3.37628089e-02f, 3.59104685e-02f, 1.89452376e-02f, 8.45527574e-02f, 7.26173073e-02f, 1.36869743e-01f, 1.67229399e-01f, -1.39329005e-02f, 7.24232867e-02f, 1.36300421e-03f,
  1.34018157e-02f, 6.73239976e-02f, -6.59719929e-02f, -2.28993893e-02f, -6.55913651e-02f, -1.68127026e-02f, 2.77789962e-02f, 3.98733467e-02f, 3.33415829e-02f, -1.23786526e-02f,
  4.57749981e-03f, -1.25077339e-02f, -6.29216507e-02f, 2.85159126e-02f, 6.30496361e-04f, 2.78743519e-03f, 9.02297422e-02f, 8.80377963e-02f, 8.36034212e-03f, -3.15374844e-02f,
  -5.24638891e-02f, -1.14917904e-02f, -5.26726581e-02f, -5.49308257e-03f, -1.75369885e-02f, -4.33338573e-03f, -1.14623979e-01f, 2.11062580e-02f, -3.97624634e-02f, -7.10977092e-02f,
  1.39434077e-02f, 1.62430540e-01f, -6.27569780e-02f, 2.30729673e-02f, 1.72626339e-02f, -8.90179724e-02f, 2.15613768e-02f, 2.62329150e-02f, 3.41907032e-02f, -5.15175425e-02f,
  3.65838185e-02f, 1.07825659e-01f, -4.29906771e-02f, -8.05116966e-02f, -9.50684026e-03f, 6.01573288e-02f, 5.25381602e-02f, 2.96371654e-02f, 4.37894464e-02f, -1.03664305e-02f,
  -1.15759961e-01f, 6.43186318e-03f, 5.65638533e-03f, -3.48805413e-02f, 4.29707244e-02f, 3.99510562e-02f, 8.25770348e-02f, 6.31512702e-02f, -3.51405591e-02f, 1.55634889e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.96799627e-02f, 1.03847615e-01f, 7.30376318e-02f, 5.76220788e-02f, 6.88308403e-02f, 2.94481907e-02f, 1.56638231e-02f, 1.06118627e-01f, -1.15749585e-02f, 1.36960521e-02f,
  1.22072093e-01f, -1.42808836e-02f, 8.74751583e-02f, 6.42162859e-02f, 8.36545080e-02f, 9.47164372e-02f, -1.06607182e-02f, -6.97464030e-03f, 4.41340283e-02f, 2.30926692e-01f,
  -6.32032081e-02f, 2.97303665e-02f, 2.39889789e-02f, 1.49191543e-01f, 1.07935913e-01f, 9.85990688e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.58160569e-02f, 4.42990847e-02f, 1.23719741e-02f, 6.10235184e-02f, 1.35770254e-02f, 6.01160992e-03f, -6.30786717e-02f, -2.35624611e-02f, -2.65888106e-02f, 4.40935269e-02f,
  4.33434211e-02f, 6.00701720e-02f, -3.87967601e-02f, 3.89400404e-03f, 1.23159155e-01f, 5.24187200e-02f, 2.06470359e-02f, -1.70739423e-02f, -8.30808654e-02f, -4.57039140e-02f,
  -3.48628536e-02f, 3.32188644e-02f, 9.74928215e-02f, 1.25288352e-01f, -8.45344886e-02f, 2.27882136e-02f, -6.53392598e-02f, 7.13991746e-02f, 2.75007728e-02f, 4.18958664e-02f,
  2.79020313e-02f, -3.21617797e-02f, 1.36707887e-01f, 3.85245681e-02f, 1.12480961e-01f, -1.14233039e-01f, -4.49962951e-02f, -1.22218743e-01f, 5.00044785e-02f, 1.05565719e-01f,
  -1.38295367e-01f, 1.14335008e-01f, 2.92693335e-03f, 6.55198172e-02f, -2.10657358e-01f, -1.84798226e-01f, 8.73733237e-02f, 1.89716816e-02f, 2.16279868e-02f, -2.09666044e-01f,
  1.04095954e-02f, 1.26286959e-02f, 1.00066453e-01f, -4.96349595e-02f, -1.29146904e-01f, 9.64607857e-03f, -1.05274655e-01f, -7.40601942e-02f, -4.18728823e-03f, 1.18302159e-01f,
  1.07460715e-01f, 1.03649907e-01f, -5.57971485e-02f, 1.46885619e-01f, 2.02747416e-02f, -2.02190578e-01f, 3.40849571e-02f, 8.33168700e-02f, -5.81103303e-02f, 8.09822381e-02f,
  2.71966886e-02f, -4.77608703e-02f, -1.21522015e-02f, 1.23922005e-01f, -5.42475618e-02f, -6.16144724e-02f, 1.81866325e-02f, 7.88022950e-02f, -5.96830957e-02f, 3.43748592e-02f,
  -5.25267273e-02f, 2.31053829e-02f, -5.40589169e-02f, 8.54971409e-02f, -8.93286169e-02f, -1.77360594e-01f, -1.03588472e-03f, 7.14584738e-02f, 8.52309614e-02f, -4.27191854e-02f,
  1.09044358e-01f, 6.68111071e-02f, 1.26318270e-02f, -7.07809553e-02f, -1.45229235e-01f, 2.28467852e-01f, 7.18611777e-02f, -7.58722797e-02f, 1.93905815e-01f, 9.47592873e-03f,
  -1.63687289e-01f, 1.08048916e-01f, 1.40806043e-03f, 2.85139501e-01f, 1.07788378e-02f, 1.40341952e-01f, -5.09329513e-02f, -1.88301504e-02f, -4.47801612e-02f, -1.79640844e-01f,
  -2.44619593e-01f, -1.50660977e-01f, -4.59744744e-02f, 2.29832232e-02f, -1.49087325e-01f, -2.06686407e-01f, 1.90490648e-01f, 6.82164282e-02f, -6.15994409e-02f, 6.81925714e-02f,
  1.19515628e-01f, -1.85314015e-01f, -1.10761054e-01f, 1.64567351e-01f, 1.18797243e-01f, 8.39810520e-02f, 1.21056490e-01f, -1.13873206e-01f, 4.67402004e-02f, -4.21325266e-02f,
  -2.52139233e-02f, 7.95999542e-02f, -2.82331109e-02f, 1.19342037e-01f, 1.58356905e-01f, 7.14902254e-03f, 1.24765918e-01f, 1.28266528e-01f, -9.96604785e-02f, 2.29274556e-02f,
  1.36963293e-01f, 1.24275491e-01f, 1.09248362e-01f, 8.77545178e-02f, -9.01597366e-02f, 7.49435723e-02f, 1.20220318e-01f, 1.12217560e-01f, 5.60908727e-02f, -3.51746120e-02f,
  5.29041328e-02f, -5.49838841e-02f, 6.59893230e-02f, 2.57298917e-01f, -3.75542752e-02f, 3.95883732e-02f, -2.07356736e-02f, -1.98342383e-01f, 7.72752538e-02f, -1.49631217e-01f,
  -1.40809417e-02f, -3.51229194e-03f, -6.96930662e-02f, -1.04114607e-01f, -1.98502213e-01f, 2.18786433e-01f, 1.42688137e-02f, 3.40399817e-02f, 8.20694715e-02f, -9.79942158e-02f,
  -7.91464671e-02f, 1.07639261e-01f, -5.08450083e-02f, -3.27913687e-02f, -1.31702106e-02f, -1.66179910e-01f, 1.99685961e-01f, 8.96687731e-02f, 2.00733412e-02f, 6.63137287e-02f,
  2.31171653e-01f, 6.20274097e-02f, -1.08546659e-01f, -9.66301411e-02f, -7.36045763e-02f, 1.79058552e-01f, -7.92418718e-02f, -8.45686570e-02f, -1.57551207e-02f, 1.16328724e-01f,
  3.74045745e-02f, -1.04245968e-01f, 4.01513651e-02f, -8.22115690e-02f, 1.47338370e-02f, 2.50067562e-02f, 3.40292044e-02f, -3.92637594e-04f, 1.37937322e-01f, 1.78788882e-02f,
  8.25827047e-02f, 8.48461315e-03f, -2.09040478e-01f, 5.19791171e-02f, -1.27168089e-01f, 5.03088571e-02f, -3.06093208e-02f, 1.24739334e-01f, -2.62454990e-02f, -2.21113879e-02f,
  1.48462921e-01f, 1.09201752e-01f, 7.95601606e-02f, -1.18864283e-01f, 3.50819677e-02f, -1.21542878e-01f, 5.16456068e-02f, 1.84963912e-01f, 5.08963242e-02f, -1.55419841e-01f,
  5.74844033e-02f, -2.79362589e-01f, 1.57826692e-01f, -2.23627016e-01f, 1.54948249e-01f, -1.56138232e-02f, -1.05956987e-01f, 2.17298567e-02f, -6.62748963e-02f, 1.12149984e-01f,
  -1.47698835e-01f, 4.04186919e-02f, 6.13744110e-02f, -2.23601460e-01f, -1.29045129e-01f, 2.33069152e-01f, -2.05606855e-02f, 3.52096558e-02f, -4.86687832e-02f, -1.69203982e-01f,
  1.75291106e-01f, 1.33082643e-01f, 1.01035759e-01f, 4.09912132e-02f, 3.09575528e-01f, 4.04102281e-02f, -1.18477136e-01f, -1.81937277e-01f, -2.88086951e-01f, 1.45118520e-01f,
  -1.97825059e-01f, -1.14556596e-01f, -1.46385506e-01f, 1.04295485e-01f, 1.03305601e-01f, -2.20906027e-02f, 6.94774836e-03f, -1.41414106e-01f, 1.77387036e-02f, 6.54340014e-02f,
  -1.47864874e-02f, 2.54799351e-02f, 2.99781822e-02f, -1.04546711e-01f, 6.30952492e-02f, 1.09641567e-01f, -1.06945731e-01f, -1.73696447e-02f, -9.38837752e-02f, 9.47539657e-02f,
  -2.29785945e-02f, 1.12582311e-01f, -3.39855999e-03f, -3.92783321e-02f, 7.68550113e-02f, -7.19214138e-03f, 1.31472619e-03f, -7.68391863e-02f, 8.83196592e-02f, 5.54081611e-02f,
  7.36459345e-02f, 6.27551302e-02f, 7.69544691e-02f, -1.15479226e-03f, 9.40235853e-02f, -4.65093441e-02f, 5.28457314e-02f, 3.94016802e-02f, 2.22985193e-01f, -1.31997149e-02f,
  9.75621566e-02f, -4.29976098e-02f, -1.44254372e-01f, 1.43238470e-01f, -4.17570993e-02f, 2.44180143e-01f, 5.71542867e-02f, 1.40126660e-01f, -8.18111598e-02f, 3.70335318e-02f,
  4.75778133e-02f, -8.88911858e-02f, -1.61833495e-01f, -2.21262231e-01f, 7.67147094e-02f, -1.09790703e-02f, 3.43474336e-02f, -1.52626857e-01f, 2.36925304e-01f, 9.48623568e-02f,
  -4.72452343e-02f, -4.32682596e-02f, -2.76455402e-01f, 3.37487012e-02f, -1.43520117e-01f, 9.72217247e-02f, 2.02885672e-01f, -4.24386822e-02f, 1.17641903e-01f, -1.54285923e-01f,
  2.34431401e-02f, -9.45503786e-02f, -2.33128201e-02f, 2.67241076e-02f, -6.42254874e-02f, 6.12065718e-02f, 2.47671008e-02f, 5.71018783e-03f, 1.10492088e-01f, -5.21105714e-03f,
  -1.17455488e-02f, -1.01233818e-01f, -3.29910070e-02f, -1.35565791e-02f, -5.04517853e-02f, -2.68697571e-02f, -1.22716919e-01f, 2.42985226e-02f, -4.31106426e-02f, 3.13320868e-02f,
  2.25383081e-02f, -1.10998973e-01f, -8.40997100e-02f, -7.34669641e-02f, -3.15326080e-03f, 6.00290410e-02f, 9.39358622e-02f, 8.10583159e-02f, -9.31185950e-03f, -4.62905578e-02f,
  -8.61071795e-02f, 4.32746820e-02f, 3.50327380e-02f, -6.47633001e-02f, 2.87663061e-02f, 1.29913852e-01f, -1.26129285e-01f, 2.05316931e-01f, 2.59329639e-02f, 1.25493202e-02f,
  7.95084089e-02f, -6.65759370e-02f, -1.60964265e-01f, -9.13987234e-02f, 2.17654556e-01f, 3.89753208e-02f, -2.21298248e-01f, -1.02432288e-01f, 2.05840971e-02f, 1.82003140e-01f,
  -1.69752762e-02f, -7.16979578e-02f, 6.88068494e-02f, 1.24353953e-01f, 3.34784463e-02f, -9.80407838e-03f, 6.90760389e-02f, 6.64218068e-02f, 7.91173801e-02f, -1.78054869e-02f,
  -8.20361450e-02f, -5.19983172e-02f, 1.33038715e-01f, -1.26499578e-01f, -1.35180466e-02f, -1.88567311e-01f, -1.47156805e-01f, 4.78103608e-02f, 9.87788755e-03f, -2.35866308e-02f,
  1.47732750e-01f, 4.09817845e-02f, -3.17868218e-02f, 1.24197742e-02f, -3.97956297e-02f, -4.46047299e-02f, -1.19696394e-01f, -1.40232760e-02f, -7.91548714e-02f, -8.39165449e-02f,
  -1.68908060e-01f, -1.07635468e-01f, -6.13981113e-03f, 1.05455264e-01f, -5.19748591e-02f, -2.39708811e-01f, -6.23439848e-02f, -1.21276818e-01f, 1.22222342e-02f, 5.11088455e-03f,
  1.11952096e-01f, 6.15879185e-02f, -4.86799441e-02f, -2.01911420e-01f, -5.03526740e-02f, 1.89124942e-01f, -7.63346180e-02f, -1.83533177e-01f, -1.29888192e-01f, 1.63735449e-01f,
  1.80348959e-02f, 9.24202129e-02f, -1.05225883e-01f, -4.28644530e-02f, 2.53187735e-02f, -6.46556616e-02f, -3.34262043e-01f, 3.89566384e-02f, 2.77393520e-01f, 6.35494590e-02f,
  -1.95774794e-01f, 1.81115791e-02f, -1.05102301e-01f, 2.49892756e-01f, 6.96788356e-02f, -1.30983740e-01f, 7.64100300e-03f, 6.30651638e-02f, 1.43781841e-01f, -6.02826364e-02f,
  1.32763132e-01f, -1.64898574e-01f, 1.25323012e-01f, -8.48634839e-02f, -1.85452461e-01f, -9.29370895e-02f, 1.69425741e-01f, -2.65475661e-02f, 1.55842956e-03f, -1.09196275e-01f,
  -8.03059712e-02f, 1.38758188e-02f, -3.56413722e-02f, -1.71648001e-03f, -1.02119163e-01f, 1.56811811e-02f, -1.13396302e-01f, -1.06108345e-01f, -8.32825303e-02f, 1.70042198e-02f,
  -1.44134074e-01f, -3.46657075e-02f, 2.27305163e-02f, -4.71417718e-02f, 6.54603466e-02f, -2.95311511e-02f, -1.40015399e-02f, -2.91710570e-02f, 1.60459448e-02f, 3.11039295e-02f,
  -1.85610522e-02f, -1.58979520e-01f, -1.32213578e-01f, -2.94910967e-01f, 9.60244089e-02f, -1.57040253e-01f, 9.52252299e-02f, 1.38685659e-01f, 1.05493926e-01f, 1.11697182e-01f,
  2.22916886e-01f, 1.00134186e-01f, 6.60295505e-03f, 1.78223878e-01f, 2.45287180e-01f, -1.90354735e-01f, -1.21245757e-01f, 8.43619257e-02f, 5.90777136e-02f, 5.65710999e-02f,
  3.80916372e-02f, -1.14096306e-01f, -1.24339655e-01f, -3.81972603e-02f, 8.05708990e-02f, 2.04682499e-01f, -1.54079825e-01f, 1.75479669e-02f, 6.29869923e-02f, 2.95297168e-02f,
  -1.35886461e-01f, -4.68077548e-02f, -6.19646721e-02f, -4.41638790e-02f, -2.12084576e-01f, 7.62488320e-02f, -4.84196059e-02f, 9.84399542e-02f, -3.68406326e-02f, -1.33580953e-01f,
  7.32701868e-02f, 8.34092125e-02f, 1.87362675e-02f, -2.95907469e-03f, 4.08696383e-03f, 2.62310337e-02f, -1.25533357e-01f, -8.24879631e-02f, -1.91188287e-02f, -1.00809745e-01f,
  -4.92537953e-02f, 1.40295237e-01f, 9.88746360e-02f, -2.68107690e-02f, 4.41333801e-02f, 6.80304617e-02f, 1.51782885e-01f, 9.11736786e-02f, -5.92684299e-02f, 2.46527418e-02f,
  -2.90950015e-02f, -1.20579168e-01f, -1.33229017e-01f, -2.09358856e-02f, 1.23892508e-01f, 1.16380356e-01f, -2.14494113e-03f, 2.34270189e-02f, -1.20173790e-01f, 1.40839398e-01f,
  1.25294132e-02f, 4.11515757e-02f, -9.07890350e-02f, 5.46954907e-02f, 7.24484101e-02f, -1.05322756e-01f, 1.21644691e-01f, -2.20872134e-01f, -7.14794025e-02f, -1.02686867e-01f,
  8.45383629e-02f, 3.28945778e-02f, -2.27678373e-01f, 1.03780068e-01f, 1.10196657e-02f, 2.57030856e-02f, -2.04751462e-01f, -1.91174418e-01f, 7.52935484e-02f, -8.52117911e-02f,
  2.53927670e-02f, -5.25543578e-02f, -1.60218373e-01f, -9.75862965e-02f, 6.90025166e-02f, -5.44834882e-02f, -6.16028048e-02f, 7.16584325e-02f, -7.10095167e-02f, -4.38558795e-02f,
  -1.18260071e-01f, 1.13450930e-01f, 1.59299925e-01f, 1.86870188e-01f, -2.33333439e-01f, 4.20948565e-02f, -8.71017426e-02f, -2.01516181e-01f, -3.47451977e-02f, 7.91616179e-03f,
  5.70032671e-02f, 4.68554236e-02f, -8.79610889e-03f, -5.11904508e-02f, -4.69236635e-02f, -3.08473483e-02f, -2.20186174e-01f, 1.20185994e-01f, -1.70035750e-01f, -2.60165371e-02f,
  -8.85771289e-02f, -2.84677953e-03f, 1.59725323e-02f, -1.74143285e-01f, 1.00786790e-01f, 1.08942181e-01f, -4.07664254e-02f, -7.17019290e-02f, 7.20503507e-04f, -2.47058779e-01f,
  -2.06062436e-01f, 7.46298861e-03f, 1.00666098e-02f, -9.01136994e-02f, 6.60872012e-02f, 5.46133891e-02f, 1.56091586e-01f, -5.78070916e-02f, 2.30581135e-01f, 1.24084704e-01f,
  -1.09437816e-02f, 9.74764675e-02f, 6.24365844e-02f, 1.79539114e-01f, -6.36551231e-02f, 6.84933662e-02f, 2.30108991e-01f, -1.08966224e-01f, 5.86741827e-02f, -2.38429494e-02f,
  -9.09916684e-02f, 8.37787464e-02f, -1.56770900e-01f, -1.17697537e-01f, -9.52230766e-02f, -6.72007538e-03f, 1.92735344e-01f, 9.82151181e-02f, -5.07716462e-02f, 2.81268097e-02f,
  -1.76951796e-01f, -2.48122349e-01f, -2.76476353e-01f, 2.32206330e-01f, -2.98303485e-01f, 3.33912186e-02f, -9.61738378e-02f, -1.90147087e-01f, 1.17918633e-01f, -5.13979373e-03f,
  -4.04295549e-02f, -8.68325979e-02f, 5.72139323e-02f, 4.71195132e-02f, 6.17377199e-02f, -4.61423919e-02f, -8.09447020e-02f, 1.42609410e-03f, -6.05250299e-02f, 5.38266525e-02f,
  3.23226675e-02f, 1.07706077e-02f, -4.22021337e-02f, -7.60110933e-03f, 1.70644410e-02f, 3.92505825e-02f, 3.08946129e-02f, -9.32600871e-02f, -7.58250430e-02f, -5.63184358e-03f,
  -1.10490501e-01f, -6.91773817e-02f, -1.79702163e-01f, -6.52650930e-03f, -7.07556009e-02f, -2.03439176e-01f, 1.13735370e-01f, -7.07395421e-03f, -8.19281638e-02f, 2.86757678e-01f,
  -1.55348733e-01f, 1.04943171e-01f, -2.15812121e-02f, 3.10175847e-02f, 1.16783641e-02f, 9.03367251e-02f, 1.32525995e-01f, -7.20006302e-02f, 2.21809484e-02f, 2.15519257e-02f,
  9.53424275e-02f, 4.42827269e-02f, 1.19972341e-01f, -1.93430111e-01f, -2.76629981e-02f, 4.51643877e-02f, -1.54211238e-01f, -9.97347012e-03f, -1.55155271e-01f, -1.08378172e-01f,
  2.13901624e-02f, -2.74902359e-02f, -2.52763599e-01f, -3.47417444e-02f, -8.34325254e-02f, -1.26385167e-01f, 2.78965265e-01f, 1.52179236e-02f, 9.18382183e-02f, 3.57401185e-02f,
  1.07609302e-01f, -1.50791764e-01f, 6.00559860e-02f, 1.19100697e-01f, 3.92753109e-02f, 1.46837920e-01f, -5.18356003e-02f, -8.62259939e-02f, 1.79071315e-02f, -1.14110775e-01f,
  -2.14652196e-02f, 3.88260186e-02f, 5.50211873e-03f, -6.92098588e-02f, 1.37967793e-02f, -6.76174089e-02f, 7.75097162e-02f, -3.62590589e-02f, 8.51124749e-02f, -6.87982216e-02f,
  -3.02998051e-02f, 5.60553409e-02f, 3.57857198e-02f, -6.30768165e-02f, 3.83886397e-02f, 1.63385555e-01f, 7.12227672e-02f, 7.06256926e-02f, 2.12469593e-01f, 3.60556841e-02f,
  -8.31926893e-03f, -1.61834583e-01f, 1.25791952e-01f, -1.86582565e-01f, 8.91555194e-03f, -1.07318744e-01f, -9.64883491e-02f, -9.10674557e-02f, -3.57112773e-02f, -1.46255657e-01f,
  -9.78998020e-02f, -5.93092889e-02f, 1.91537198e-03f, -6.28855228e-02f, -1.88152179e-01f, 2.94041540e-02f, 3.84497233e-02f, 8.19564164e-02f, -6.93634078e-02f, -7.00499415e-02f,
  2.47567102e-01f, 1.62487656e-01f, 1.41042948e-01f, 1.94830205e-02f, -1.74619377e-01f, 1.16686739e-01f, 3.07378061e-02f, -9.97172594e-02f, 3.52027826e-02f, 1.71185374e-01f,
  -2.08008900e-01f, -4.08207700e-02f, -5.65178983e-04f, -4.92337830e-02f, -6.25043511e-02f, 1.28043175e-01f, -1.31771803e-01f, -1.73485912e-02f, 3.50076817e-02f, 2.06170648e-01f,
  -8.33920836e-02f, 4.84624729e-02f, 1.50305461e-02f, 5.69126643e-02f, 5.91980033e-02f, 6.53801486e-02f, -9.96938944e-02f, -4.42406675e-03f, 5.22119552e-02f, 4.16970812e-03f,
  1.04165010e-01f, 1.35991618e-01f, 9.56513062e-02f, 1.00648649e-01f, 3.77534665e-02f, -1.70014091e-02f, -4.88103442e-02f, -1.47131324e-01f, 3.95358689e-02f, 1.22815870e-01f,
  1.54915135e-02f, 1.93666786e-01f, 1.05707176e-01f, 1.42820582e-01f, 2.03435197e-02f, 1.35664538e-01f, 1.88302472e-02f, -1.59876019e-01f, 7.57165998e-02f, -1.57042578e-01f,
  -1.93880394e-01f, -4.38714921e-02f, 7.18468502e-02f, -1.49167180e-01f, -1.01462178e-01f, -1.41497254e-01f, 1.81574486e-02f, -1.53378472e-01f, -2.07126215e-01f, 8.37727934e-02f,
  -7.97275305e-02f, 1.31644920e-01f, -7.16893747e-02f, -4.65364568e-02f, 1.06382914e-01f, 1.22064851e-01f, 1.46270260e-01f, -1.12646088e-01f, -2.64508333e-02f, 5.58218583e-02f,
  2.23521769e-01f, -1.15072824e-01f, 9.86459851e-02f, 2.03468576e-02f, -1.15971267e-01f, -1.58177674e-01f, 9.58480313e-02f, -9.65890437e-02f, 4.70934808e-03f, 2.41678089e-01f,
  -1.73894584e-01f, 5.43205626e-02f, -2.42236350e-02f, -1.41578570e-01f, -1.11609727e-01f, -7.96587542e-02f, 6.18297681e-02f, 5.48120402e-03f, 1.49529025e-01f, -5.90597242e-02f,
  9.70558822e-02f, -2.16161497e-02f, -7.81891961e-03f, -6.84449673e-02f, 2.84224544e-02f, -3.42022255e-02f, -4.44487892e-02f, -6.19407520e-02f, 1.28580583e-02f, 5.54371029e-02f,
  6.42619878e-02f, 1.77050918e-01f, 1.39209524e-01f, -5.20121902e-02f, -4.74552400e-02f, -6.15287945e-02f, 1.79391146e-01f, 1.44866541e-01f, -1.29018761e-02f, -7.68867284e-02f,
  4.76899147e-02f, -2.14285046e-01f, 4.72581610e-02f, -9.81570110e-02f, -1.22847915e-01f, -5.65331168e-02f, -1.82326943e-01f, 7.94660114e-03f, -1.44042775e-01f, 1.22659758e-01f,
  -1.34410098e-01f, -6.76214099e-02f, -7.75081217e-02f, -2.12018281e-01f, -1.07722089e-01f, 1.10098951e-01f, -1.82573684e-02f, -5.60643971e-02f, 4.94255498e-02f, -1.70773696e-02f,
  1.44644454e-01f, 7.71157593e-02f, -1.21466622e-01f, 5.62625155e-02f, 5.05256690e-02f, 5.39608411e-02f, 5.95178716e-02f, -1.05421886e-01f, 3.11687887e-02f, -2.37338897e-02f,
  5.85311577e-02f, -1.26505166e-01f, -2.37696275e-01f, 7.98585862e-02f, -8.42677876e-02f, -1.22881696e-01f, -1.41374823e-02f, -4.90430146e-02f, 2.11963933e-02f, -7.30894580e-02f,
  -1.19773997e-02f, -4.61898884e-03f, 2.36418992e-02f, -7.05401748e-02f, 1.26371890e-01f, 1.31272942e-01f, 6.01922758e-02f, -1.10015392e-01f, 1.14700466e-01f, -5.14703654e-02f,
  1.66255370e-01f, 1.52011544e-01f, -4.15660553e-02f, 2.16324866e-01f, 1.07967462e-02f, -6.99429587e-02f, -1.76503807e-01f, -1.28973767e-01f, -2.87359469e-02f, 6.22815900e-02f,
  3.41726810e-01f, -6.30565360e-02f, 1.91949263e-01f, 1.10502385e-01f, 1.20314203e-01f, -1.00213461e-01f, -1.88111633e-01f, 1.99170217e-01f, -1.55865550e-01f, -1.74873039e-01f,
  1.79732993e-01f, -1.90913573e-01f, -1.50406331e-01f, 1.47825718e-01f, 7.88212381e-03f, 2.59588510e-01f, -2.26904452e-01f, 1.97461814e-01f, -5.28467633e-02f, 1.38242558e-01f,
  6.02791049e-02f, -1.76610813e-01f, 2.37778381e-01f, 1.86880216e-01f, 3.01607121e-02f, -1.54894460e-02f, -2.42960870e-01f, -8.22606012e-02f, 1.83457240e-01f, 1.25696227e-01f,
  1.58314332e-01f, 3.06301951e-01f, 8.72496068e-02f, -1.21089906e-01f, 1.32387474e-01f, 5.19922450e-02f, 1.51260436e-01f, 2.19812885e-01f, 6.48217159e-04f, -7.65095279e-02f,
  -5.74809760e-02f, -1.08368054e-01f, -3.21360677e-02f, -9.19423699e-02f, 2.01185662e-02f, -8.93636141e-03f, -9.55289379e-02f, -4.19104211e-02f, 1.07393302e-01f, -1.92767233e-02f,
  -1.71430647e-01f, -6.89146668e-02f, 1.14922546e-01f, -1.32533446e-01f, -5.72793372e-02f, -2.84355786e-02f, 1.23856306e-01f, -1.39125204e-03f, 2.61914451e-02f, -1.04270883e-01f,
  -1.46157339e-01f, 3.92201953e-02f, 4.65663262e-02f, 5.05839065e-02f, 1.89095587e-01f, -1.10072032e-01f, -1.08377188e-02f, -1.92868501e-01f, 4.60117534e-02f, -4.23504002e-02f,
  -2.53212196e-03f, 5.78812361e-02f, 3.93156223e-02f, 1.84283987e-01f, 2.17070922e-01f, -8.31967965e-02f, -8.55806004e-03f, 2.36461654e-01f, -7.18886629e-02f, 2.70207077e-01f,
  9.06991959e-02f, 3.01349938e-01f, 2.66091198e-01f, 8.16361234e-02f, -1.61601216e-01f, 2.87392046e-02f, 2.54517406e-01f, 4.97253276e-02f, 8.88988748e-02f, -1.38168156e-01f,
  -1.31762236e-01f, 1.55954883e-01f, 9.83493924e-02f, -2.06508283e-02f, -7.79951317e-03f, 1.90518498e-01f, -3.04250866e-01f, 2.32351825e-01f, -1.13673605e-01f, -1.24245854e-02f,
  1.85225695e-01f, 8.20294544e-02f, 1.66343406e-01f, -2.39604458e-01f, 8.96838307e-03f, 1.39967620e-01f, -2.89315032e-03f, -1.27279878e-01f, 4.41534743e-02f, -1.46795973e-01f,
  -2.76117101e-02f, 8.21071789e-02f, -2.52075330e-03f, -1.89558417e-01f, 3.69164608e-02f, -3.54037806e-02f, -2.57602856e-02f, -3.16191688e-02f, -7.39258751e-02f, -1.01333179e-01f,
  -8.11026469e-02f, -6.58816919e-02f, 2.83750240e-03f, -6.34770989e-02f, 9.69614610e-02f, 1.02028690e-01f, -1.23907709e-02f, -8.42951760e-02f, 5.51889045e-03f, -2.14565750e-02f,
  -1.97656229e-02f, -1.51249275e-01f, 4.18172181e-02f, -5.80136254e-02f, 6.95745870e-02f, -1.65592004e-02f, -8.15875754e-02f, 3.34302448e-02f, -1.60463572e-01f, 7.83435479e-02f,
  1.18477404e-01f, -6.19533248e-02f, -1.13838598e-01f, -2.04730451e-01f, 1.05584554e-01f, -1.55892894e-01f, -2.84027196e-02f, -3.16107050e-02f, 1.69154450e-01f, 2.43410513e-01f,
  1.88969851e-01f, 1.52426451e-01f, -2.27191914e-02f, 1.00519784e-01f, -3.46435271e-02f, 1.67179868e-01f, -3.23220529e-02f, -1.77297425e-02f, 2.28800595e-01f, 1.56068742e-01f,
  2.22990885e-02f, 5.80705749e-03f, 2.11069390e-01f, -2.19470799e-01f, -1.31642252e-01f, -6.65341411e-03f, 6.33968413e-02f, -6.86031431e-02f, -6.26834705e-02f, 7.30934786e-03f,
  -6.16340451e-02f, -2.21288074e-02f, 9.63247847e-03f, 1.78597886e-02f, -1.51273534e-01f, -1.37935011e-02f, -2.73888484e-02f, -7.47888386e-02f, 1.80867583e-01f, -1.38265684e-01f,
  1.85934454e-02f, -2.91792918e-02f, 4.59101796e-02f, -6.96718171e-02f, 1.04056008e-01f, -1.34517774e-02f, -8.55765715e-02f, -1.49122896e-02f, -1.60817951e-02f, 3.28121893e-02f,
  -1.28982440e-01f, 7.22771659e-02f, 8.56878459e-02f, -3.02629411e-01f, 7.70606473e-02f, -5.08119650e-02f, -2.08590049e-02f, 1.91735253e-01f, -1.14700288e-01f, 1.73564747e-01f,
  -6.83708861e-02f, -4.63194139e-02f, 9.13267210e-02f, -2.23311465e-02f, 1.43455192e-01f, -2.36022949e-01f, 5.94045445e-02f, -2.04182602e-03f, -1.80270389e-01f, 9.87133570e-03f,
  5.26470272e-03f, -1.36011019e-01f, -8.67943093e-02f, -1.10417917e-01f, 1.81166083e-02f, 1.47700101e-01f, -1.72077432e-01f, -1.72312260e-01f, -5.51188141e-02f, -9.36749578e-03f,
  -2.03855485e-01f, -6.11681752e-02f, 4.83139977e-02f, 6.53467327e-02f, 1.46443844e-01f, -1.84779257e-01f, 6.07725456e-02f, 5.06330542e-02f, 6.31193593e-02f, 4.48438935e-02f,
  -1.43912315e-01f, 1.72783837e-01f, 6.37397841e-02f, 5.26938774e-02f, -1.11462034e-01f, 4.22561429e-02f, 7.42264837e-03f, 9.25021712e-03f, 1.02588996e-01f, 2.94235330e-02f,
  -1.23032577e-01f, -2.63148826e-02f, 5.65847419e-02f, -6.22000396e-02f, -1.14530104e-03f, 5.09071387e-02f, 6.07809946e-02f, -3.96467149e-02f, 5.53486086e-02f, -3.31207216e-02f,
  -8.53397697e-03f, 8.98947194e-02f, 1.63736835e-01f, 8.43556821e-02f, -1.01754948e-01f, 5.91363832e-02f, 3.87711078e-02f, -5.76694012e-02f, 5.10504581e-02f, 7.19888061e-02f,
  1.02392830e-01f, -7.64361545e-02f, -3.62922847e-02f, -1.73165187e-01f, -6.66953102e-02f, -6.46984950e-02f, -2.31148340e-02f, -1.46228135e-01f, 6.57721087e-02f, -2.74543673e-01f,
  6.22376148e-03f, -2.17878461e-01f, -1.75256684e-01f, -2.14334652e-01f, -1.31085187e-01f, 1.40846983e-01f, -6.90300763e-02f, -1.47148117e-01f, 9.42243338e-02f, 1.93958223e-01f,
  -5.61619215e-02f, -8.77946690e-02f, -5.48841581e-02f, 3.80604900e-02f, 1.30555764e-01f, -1.59638807e-01f, -8.00517648e-02f, -1.71427485e-02f, 8.02031010e-02f, -1.31941780e-01f,
  -9.05257240e-02f, -6.21403977e-02f, -2.84079432e-01f, 2.09918126e-01f, -2.97465354e-01f, 2.23542720e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.80862930e-03f, 1.24884650e-01f, 1.44394994e-01f, 3.24277580e-02f, -7.40975491e-04f, 1.75349077e-03f, -8.48381221e-02f, 1.41182408e-01f, 8.93770605e-02f, 3.33766430e-03f,
  -4.45337668e-02f, -1.99544169e-02f, 1.98009670e-01f, -6.41837567e-02f, 7.85815865e-02f, 1.85574964e-02f, 1.58795148e-01f, 8.08621272e-02f, -2.55726986e-02f, -1.58648089e-01f,
  -2.35663075e-02f, 2.47136503e-01f, 1.84743926e-01f, 1.52925208e-01f, -2.48466879e-02f, -4.42699939e-02f, -1.58567369e-01f, -1.55589148e-01f, -3.39674242e-02f, 1.99530035e-01f,
  1.52521178e-01f, -3.35313380e-02f, -6.92556500e-02f, 2.34066814e-01f, 1.36083961e-01f, -1.25268802e-01f, -3.26349633e-03f, 1.92979742e-02f, -1.92429801e-03f, -4.61004414e-02f,
  4.95872945e-02f, 1.55031025e-01f, 2.63892859e-01f, 3.17247957e-02f, -2.30583891e-01f, 3.73252407e-02f, 2.75489748e-01f, 7.96931516e-03f, 2.28855498e-02f, -9.66771543e-02f,
  6.46466613e-02f, 1.85122639e-01f, -1.03025362e-01f, -9.57489386e-02f, -1.16851572e-02f, -1.91859752e-02f, -1.13679476e-01f, 2.50177413e-01f, 9.32334140e-02f, 8.53611305e-02f,
  2.03631088e-01f, 7.09634647e-02f, -3.48429978e-02f, -5.68803214e-03f, 2.90935114e-02f, -5.05352393e-02f, 6.49019182e-02f, 3.98283489e-02f, 6.63449392e-02f, 6.81472197e-02f,
  -1.07827276e-01f, 5.73135391e-02f, 1.06129062e-03f, 1.55247962e-02f, -6.15842408e-04f, 1.90132573e-01f, -8.22779983e-02f, 2.37303097e-02f, -8.24075267e-02f, 9.69066322e-02f,
  7.15809986e-02f, -1.53906923e-02f, 9.48632807e-02f, -9.73309651e-02f, -5.55629507e-02f, 9.00526065e-03f, 4.21684086e-02f, -2.89320033e-02f, -1.27721727e-01f, -1.95072323e-01f,
  1.82106916e-03f, -8.54380429e-02f, 6.89817267e-03f, 1.95602477e-01f, 1.99999344e-02f, 1.85812965e-01f, 2.23215967e-01f, 1.69472039e-01f, 1.57822266e-01f, 1.33750468e-01f,
  1.32925749e-01f, -8.45925231e-03f, 2.16972381e-02f, 2.43405268e-01f, 1.80356741e-01f, 2.42626846e-01f, 1.53206289e-01f, -1.76639274e-01f, 6.38831556e-02f, 1.46731138e-01f,
  -3.05860080e-02f, 2.11187657e-02f, -3.59060848e-03f, 2.63249315e-02f, 1.17660910e-01f, 5.07279783e-02f, -1.92050055e-01f, 1.86712950e-01f, 1.04583718e-01f, 5.95162548e-02f,
  -9.52992365e-02f, 1.49852216e-01f, 1.47667244e-01f, 1.28404975e-01f, 2.10699111e-01f, -9.89641994e-02f, 2.77353406e-01f, -5.93130440e-02f, 2.04615463e-02f, 1.77318886e-01f,
  3.45173813e-02f, -2.02891976e-02f, -9.97663083e-05f, 7.51325563e-02f, 7.21920207e-02f, 6.28889054e-02f, 1.32552356e-01f, 1.54193312e-01f, 7.23542273e-02f, -6.02505729e-03f,
  2.93660194e-01f, 7.32064545e-02f, 1.83117241e-02f, 8.31384026e-03f, -3.43191624e-02f, 1.66357815e-01f, -5.09574190e-02f, -6.92388266e-02f, -1.36318048e-02f, 4.97117266e-02f,
  -8.95442367e-02f, 1.18743382e-01f, 5.35467714e-02f, 8.91966671e-02f, -4.86322418e-02f, 2.00703964e-01f, -2.49383464e-01f, 1.12765111e-01f, -9.91334915e-02f, -8.54223222e-02f,
  -2.82267630e-01f, -8.19209069e-02f, 2.54807882e-02f, -1.25809908e-01f, -2.04579771e-01f, 6.50872812e-02f, 1.64275691e-01f, -1.62769049e-01f, -8.59159529e-02f, 1.17338737e-02f,
  1.21250518e-01f, 1.08689189e-01f, 1.01964168e-01f, 1.08608477e-01f, 4.26638015e-02f, -1.66381717e-01f, 1.94883943e-01f, -3.41763021e-03f, -1.58100620e-01f, 5.77606559e-02f,
  -5.89166619e-02f, -2.44453177e-02f, 2.60495245e-01f, -1.51916081e-02f, 2.03301266e-01f, 8.28029439e-02f, 2.23387688e-01f, -9.08383653e-02f, 8.69298056e-02f, 1.00369282e-01f,
  -7.70403817e-02f, 8.54735598e-02f, 8.84852484e-02f, -1.77976303e-02f, -7.76562020e-02f, 1.11203469e-01f, -1.73135009e-02f, 1.23481132e-01f, 1.81120276e-01f, 3.69914025e-02f,
  -8.52855071e-02f, 9.05226544e-02f, 2.51188464e-02f, 6.03532642e-02f, -1.89045757e-01f, 8.08346421e-02f, 6.10688329e-02f, 7.41235614e-02f, -5.23044914e-02f, -4.95081432e-02f,
  7.90812224e-02f, 5.25152795e-02f, 7.91702420e-02f, -5.59181608e-02f, 3.25626805e-02f, 5.52626103e-02f, -7.78313726e-02f, 2.26808693e-02f, 4.47293594e-02f, 1.26345053e-01f,
  1.34599507e-01f, -1.49106070e-01f, 4.43186015e-02f, -8.14307630e-02f, 1.00340575e-01f, -6.67887479e-02f, 1.01189697e-02f, 5.31190298e-02f, 6.33061081e-02f, -2.45927796e-01f,
  2.70471792e-03f, -1.86280515e-02f, -7.58250430e-02f, -1.39444098e-01f, -2.03221366e-01f, 2.69427914e-02f, 5.89301996e-02f, -8.02410692e-02f, -1.75891817e-01f, -1.52344126e-02f,
  -3.99312191e-02f, -1.50021315e-02f, 1.63091123e-01f, -1.28954932e-01f, 2.16329366e-01f, 2.69337129e-02f, -1.53367609e-01f, -7.05157369e-02f, -3.59908268e-02f, -2.16210857e-01f,
  -9.32959691e-02f, 5.08181192e-02f, -1.70086056e-01f, 5.55151850e-02f, -8.34106803e-02f, 1.80860475e-01f, 1.22631326e-01f, 2.33234912e-01f, 1.17179520e-01f, 1.86666904e-03f,
  -3.86729576e-02f, -3.41096595e-02f, -8.83584842e-02f, 4.84660193e-02f, 8.08325224e-03f, 1.28707662e-02f, 7.81630948e-02f, 7.30175804e-03f, 2.49085784e-01f, 6.09092973e-02f,
  1.31394193e-01f, -4.70658764e-02f, 1.36668727e-01f, 7.83124492e-02f, 2.61150710e-02f, -1.84706002e-01f, -9.36375931e-02f, 1.83618367e-01f, 1.13785692e-01f, 4.77612130e-02f,
  -4.69587557e-02f, 5.27011976e-02f, -6.25831410e-02f, 8.18929672e-02f, -7.72770345e-02f, 1.48087174e-01f, -2.78643277e-02f, 1.22452239e-02f, 2.36302949e-02f, -2.50593685e-02f,
  7.25859106e-02f, -1.70224980e-01f, -2.62583829e-02f, -1.78330019e-01f, 8.38495344e-02f, -6.05428629e-02f, -1.25455096e-01f, 1.96379274e-01f, 2.00353339e-01f, 2.24553794e-02f,
  -1.30940795e-01f, -3.50298099e-02f, 1.42503887e-01f, 1.62089746e-02f, 8.61470401e-02f, -1.00825451e-01f, -6.23451695e-02f, 1.37466844e-02f, -5.79372682e-02f, -7.22251683e-02f,
  -1.74001325e-03f, 1.53864786e-01f, 4.58130538e-02f, 5.79335392e-02f, 2.61898190e-02f, 7.99621940e-02f, 2.04032972e-01f, 1.33491889e-01f, -1.01548553e-01f, -4.93719196e-03f,
  1.14960425e-01f, 1.37190968e-01f, 1.73569676e-02f, -5.38832620e-02f, 8.05360004e-02f, 3.02698053e-02f, 8.21371153e-02f, 1.13327794e-01f, 1.11495920e-01f, -7.56227672e-02f,
  -1.04993157e-01f, 1.10674530e-01f, 3.08378190e-02f, -1.75685883e-02f, -8.07693321e-03f, -4.87493956e-03f, 6.51590005e-02f, 3.36051472e-02f, 1.16476133e-01f, -7.87232742e-02f,
  1.64799467e-01f, 1.48355186e-01f, 9.32876840e-02f, -5.01678362e-02f, -9.56645161e-02f, 1.00082904e-01f, -1.49666622e-01f, -4.87098508e-02f, -7.47983158e-02f, -1.09294616e-01f,
  2.22457886e-01f, -2.49876678e-01f, 3.37079465e-02f, 8.19257423e-02f, -3.84408981e-02f, 5.63615710e-02f, 5.91551922e-02f, 1.59886956e-01f, -3.63769867e-02f, -1.26722813e-01f,
  1.88323662e-01f, -8.86949301e-02f, 1.64017573e-01f, 1.21034540e-01f, 7.95236528e-02f, 1.99886456e-01f, 1.27906546e-01f, -3.28271724e-02f, 1.98097572e-01f, 1.51922360e-01f,
  1.06162883e-01f, 2.16328248e-01f, 4.84008901e-02f, -3.99085879e-02f, 9.64744389e-02f, 2.49392260e-02f, -1.62583217e-01f, 2.69981682e-01f, 5.39503880e-02f, -6.94292933e-02f,
  -8.51313472e-02f, 7.28475079e-02f, -3.04729640e-02f, -1.07108466e-01f, 2.07650568e-02f, -6.45521209e-02f, 4.84157950e-02f, -1.43687194e-02f, 6.39197603e-03f, 5.20704985e-02f,
  2.12845773e-01f, -2.31725699e-03f, 9.52243656e-02f, 1.04922503e-01f, -3.96718308e-02f, -2.78357398e-02f, -9.76190493e-02f, 1.21989168e-01f, -3.43573280e-02f, 1.37965217e-01f,
  -2.37934962e-02f, 2.21892307e-03f, 1.36428297e-01f, 1.41798332e-01f, 7.64936861e-03f, -1.32916242e-01f, -8.37591588e-02f, -6.78659528e-02f, 2.81851739e-02f, 9.78715122e-02f,
  7.81166032e-02f, -4.54533994e-02f, -2.36058813e-02f, -2.74562806e-01f, -4.59337272e-02f, -2.12761406e-02f, 6.23124512e-03f, -1.77445784e-01f, -4.98104319e-02f, 6.01222590e-02f,
  -1.05962373e-01f, 9.43671763e-02f, -6.71795309e-02f, 1.11914702e-01f, 1.95549354e-02f, -1.45282447e-01f, -1.68533474e-01f, 1.88509170e-02f, 8.76826867e-02f, 4.30152379e-02f,
  -1.40113413e-01f, 2.39340942e-02f, 2.36524921e-02f, 1.51947230e-01f, 1.09850764e-01f, -8.32069144e-02f, 2.88605809e-01f, 8.46495032e-02f, 6.10532127e-02f, -2.85445782e-03f,
  -3.83738847e-03f, 4.19315770e-02f, -1.51554391e-01f, -7.65405893e-02f, -9.47395489e-02f, 1.44667476e-01f, 5.11348108e-03f, 4.17702086e-02f, 2.28514951e-02f, -1.12331145e-01f,
  7.36010149e-02f, 1.31253764e-01f, 7.25260004e-02f, 1.10869072e-01f, 1.77459028e-02f, -5.42783439e-02f, 2.27339379e-02f, 1.90846607e-01f, 7.86798224e-02f, -9.71427094e-03f,
  -2.54118089e-02f, 4.45536561e-02f, 1.36147305e-01f, 8.84401053e-02f, -2.59650778e-02f, 1.39066845e-01f, 6.68591261e-02f, -4.96641509e-02f, -1.06570952e-01f, -6.56639934e-02f,
  -2.45223902e-02f, 2.76998021e-02f, -2.71931514e-02f, -1.00105897e-01f, 3.82872261e-02f, 1.23284966e-01f, 1.95953958e-02f, 1.16926104e-01f, -1.47828996e-01f, 1.76528424e-01f,
  5.75974733e-02f, 4.05254029e-02f, 7.80651122e-02f, -1.24544650e-02f, -1.47351846e-02f, -1.08643048e-01f, 7.44304731e-02f, 1.89118057e-01f, -9.10853297e-02f, 1.61536068e-01f,
  4.61117066e-02f, -8.00035670e-02f, -6.85449736e-03f, -1.34720609e-01f, -8.32537711e-02f, -5.13149276e-02f, -6.30796030e-02f, -8.49227235e-02f, 1.49494158e-02f, -7.82636702e-02f,
  2.98917238e-02f, 1.04803808e-01f, -1.10345948e-02f, 6.50321692e-02f, 1.71890289e-01f, -5.38848042e-02f, 3.61254402e-02f, 1.45433292e-01f, 1.66002467e-01f, 9.87190008e-02f,
  9.28530842e-02f, 1.16463073e-01f, -3.58465686e-02f, 5.35360463e-02f, 5.42699136e-02f, -1.18656699e-02f, 9.68194455e-02f, 1.90688800e-02f, 2.44166963e-02f, 1.08680144e-01f,
  1.26270846e-01f, 1.67377174e-01f, 9.19673517e-02f, 3.14102434e-02f, 4.59688231e-02f, -5.10130040e-02f, 2.49973256e-02f, 4.73160334e-02f, 2.86473092e-02f, 3.43796574e-02f,
  5.34770526e-02f, -1.18953936e-01f, -1.99862584e-01f, 6.67136237e-02f, 1.09687448e-02f, 1.21451756e-02f, -2.00904068e-02f, -1.73355773e-01f, 1.17741162e-02f, 2.19971146e-02f,
  -9.03097019e-02f, 3.01654577e-01f, -1.46265730e-01f, 1.98634744e-01f, 1.23959137e-02f, 1.06022812e-01f, 1.84670046e-01f, 2.12419368e-02f, 1.46101013e-01f, -6.44754618e-02f,
  1.37147829e-01f, 1.36448875e-01f, 6.04289509e-02f, 2.33102024e-01f, 2.07000688e-01f, -2.35473663e-01f, 5.53957070e-04f, 1.22938067e-01f, -6.75229281e-02f, 4.94365543e-02f,
  -6.31303415e-02f, -8.96656439e-02f, -8.12067464e-02f, -3.02156601e-02f, -2.77071714e-01f, 1.01286106e-01f, 1.03467472e-01f, 1.81378275e-02f, 2.86719471e-01f, 6.76848367e-02f,
  1.88662231e-01f, 1.65577605e-01f, 2.72905022e-01f, -7.49123022e-02f, 1.10121012e-01f, 6.13917373e-02f, 8.44907686e-02f, -8.74694809e-02f, -6.87512010e-02f, -8.89785308e-03f,
  1.00794353e-01f, -3.26918960e-02f, 1.76898137e-01f, 6.50094301e-02f, 1.23502240e-01f, -2.40079705e-02f, -4.45887521e-02f, -4.31938954e-02f, 4.73077483e-02f, 5.02794422e-02f,
  3.58437672e-02f, 1.33005619e-01f, -4.85331416e-02f, 2.26907041e-02f, 1.02876157e-01f, 7.04734772e-02f, 6.88441992e-02f, -1.04176410e-01f, -7.16857091e-02f, -2.59520765e-02f,
  2.35983133e-01f, 1.44144744e-01f, 4.88475114e-02f, 1.07542470e-01f, 1.55113181e-02f, -2.78870136e-01f, -1.14377074e-01f, -1.00708216e-01f, -1.11427695e-01f, -2.50800073e-01f,
  -1.32811561e-01f, 1.22987079e-02f, -1.54309317e-01f, 1.74284026e-01f, -6.01297617e-02f, 1.10580727e-01f, -2.68065296e-02f, -7.73987845e-02f, -1.60033181e-01f, 2.32656360e-01f,
  1.51679873e-01f, 5.61411604e-02f, -2.58126575e-02f, -2.71939486e-02f, 2.45861307e-01f, 1.88733786e-01f, -3.88995670e-02f, 1.75248999e-02f, 2.55454540e-01f, 1.66357428e-01f,
  2.36256704e-01f, 7.60337412e-02f, 9.33838412e-02f, -3.56355123e-02f, -3.23251858e-02f, -1.71553586e-02f, -8.86611715e-02f, 1.23638600e-01f, 7.36109540e-02f, -1.31393224e-01f,
  3.74193601e-02f, 1.80040777e-01f, 3.10315117e-02f, 6.02879524e-02f, 5.80732664e-03f, -5.23665175e-02f, -4.74904887e-02f, -2.39982922e-03f, -4.37046401e-02f, 1.19346371e-02f,
  2.13493649e-02f, 5.58943413e-02f, 2.98882904e-03f, -3.65093648e-02f, 1.13671318e-01f, -5.41994302e-03f, 2.05340777e-02f, 6.29172623e-02f, 2.40087211e-02f, -1.31967235e-02f,
  8.43411982e-02f, 1.55050963e-01f, 7.62025490e-02f, 5.99460751e-02f, 2.65006982e-02f, 4.99187037e-02f, -4.46468443e-02f, 1.20362698e-03f, 2.43932959e-02f, -2.04439592e-02f,
  6.66484833e-02f, -1.25263527e-01f, -2.32833764e-03f, 2.39831135e-02f, -6.02628030e-02f, -1.23891830e-01f, 3.23050544e-02f, -1.17228016e-01f, -3.16287912e-02f, -1.10637479e-01f,
  -9.42212790e-02f, -6.69620931e-02f, 1.07469738e-01f, 1.82223439e-01f, -1.16194166e-01f, -1.06148608e-02f, 2.29440615e-01f, 9.81223881e-02f, 1.03790887e-01f, -4.24758159e-02f,
  -2.59038247e-02f, 1.62872374e-01f, 8.83199871e-02f, -7.30719343e-02f, 1.45466253e-02f, -2.96267401e-02f, -8.68639648e-02f, 9.08877701e-02f, 5.02398200e-02f, -3.88305485e-02f,
  -7.59900659e-02f, 6.66637346e-02f, -1.13895081e-01f, 6.97376877e-02f, 3.53169069e-02f, -8.54452178e-02f, 1.37019316e-02f, 1.13354899e-01f, -2.48291623e-02f, 5.05839884e-02f,
  1.42938942e-01f, 2.17702258e-02f, 1.34751752e-01f, 1.87204272e-01f, -1.30185500e-01f, 7.40096793e-02f, 4.96594459e-02f, 9.83352438e-02f, -1.18294302e-02f, 8.50611851e-02f,
  -2.42186449e-02f, 1.09474361e-01f, 8.09035897e-02f, -1.27900794e-01f, -1.20371565e-01f, -8.59996900e-02f, 1.29666096e-02f, -1.29920971e-02f, 9.39728599e-03f, 1.10030025e-01f,
  6.65073544e-02f, 5.53579330e-02f, -1.35866180e-01f, -1.10035665e-01f, -7.95628354e-02f, -7.75525793e-02f, 1.23683773e-01f, -3.13606020e-03f, 1.41072825e-01f, 7.08592683e-02f,
  -2.33296618e-01f, 2.48020127e-01f, 1.54984454e-02f, 2.04601839e-01f, 9.21641290e-02f, 1.41968235e-01f, 1.15564484e-02f, 1.47192217e-02f, 7.63627067e-02f, 7.24048540e-02f,
  -1.51266471e-01f, -2.47539595e-01f, 1.66757256e-01f, 6.79152682e-02f, 3.81277762e-02f, 1.39752319e-02f, 2.32948765e-01f, 9.02267843e-02f, 1.85930431e-02f, -4.91373613e-02f,
  -1.67073712e-01f, 1.83365107e-01f, -2.87067853e-02f, 5.36330640e-02f, 2.10681155e-01f, 1.12878056e-02f, 2.34515488e-01f, -1.35128766e-01f, 1.18164636e-01f, -6.80912137e-02f,
  1.59919132e-02f, 1.20467380e-01f, 4.13126461e-02f, 1.76916644e-01f, 3.73926274e-02f, 3.59860398e-02f, -2.35818028e-02f, 1.63679823e-01f, 1.30185232e-01f, 6.31210282e-02f,
  -1.46840900e-01f, 9.58127081e-02f, 8.48741904e-02f, 2.55553909e-02f, 6.36074096e-02f, 7.77233299e-03f, -1.56858303e-02f, 4.45726439e-02f, -1.03469074e-01f, 8.26387107e-03f,
  -3.68822254e-02f, 2.83159241e-02f, -1.89253226e-01f, -1.10949770e-01f, 6.80223405e-02f, 1.66490616e-03f, -6.99569508e-02f, 2.14073226e-01f, -8.39091241e-02f, 2.01811697e-02f,
  8.63821656e-02f, 1.26711771e-01f, 1.16756767e-01f, 6.09947322e-03f, 3.91515344e-03f, -1.04868725e-01f, 1.15552269e-01f, 8.85514766e-02f, 1.13582447e-01f, 1.28895901e-02f,
  4.58752401e-02f, -8.55364427e-02f, -1.36143252e-01f, 4.25833911e-02f, -1.66609138e-01f, -5.23519553e-02f, -1.32629290e-01f, -1.47494704e-01f, 1.73688293e-01f, -7.62712136e-02f,
  -5.88311143e-02f, -8.77681002e-03f, -2.62341946e-01f, -1.20418377e-01f, 1.44657835e-01f, 1.34265190e-02f, -6.86197206e-02f, 1.50707632e-01f, 7.18953758e-02f, -7.48240855e-03f,
  9.02783126e-02f, 2.29670510e-01f, 3.09427213e-02f, 1.78636491e-01f, -9.29590873e-03f, -6.35255799e-02f, 6.44225031e-02f, -1.29035935e-01f, -1.12420313e-01f, 6.54014125e-02f,
  -5.26950322e-02f, -1.18762955e-01f, 1.00256987e-01f, -1.50139052e-02f, -7.40759745e-02f, -2.37596724e-02f, 6.99682832e-02f, -1.04977727e-01f, 9.48564932e-02f, 6.25830591e-02f,
  1.04946811e-02f, -9.07073691e-02f, 1.10586219e-01f, 1.31112665e-01f, 4.25994769e-02f, 1.39388945e-02f, 1.04904592e-01f, -1.37840062e-01f, 4.57965843e-02f, -9.48370248e-02f,
  1.12333633e-01f, -5.18670231e-02f, -6.07893057e-03f, -2.58848350e-02f, -3.70220840e-02f, -1.42897861e-02f, -6.33816943e-02f, -1.49241565e-02f, 1.39011145e-01f, -1.64669946e-01f,
  -8.85276822e-04f, -8.08998346e-02f, -1.72674358e-01f, -1.33752972e-02f, -4.06145044e-02f, 6.21899590e-02f, -4.91091870e-02f, -7.04070926e-02f, 2.29798302e-01f, 2.49403879e-01f,
  -4.65027094e-02f, -9.53868090e-04f, -2.24498902e-02f, 7.83395469e-02f, -2.51328889e-02f, -2.22681034e-02f, 6.47047162e-02f, 1.96679205e-01f, -3.09642926e-02f, -9.93152112e-02f,
  1.10709734e-01f, -3.61731388e-02f, -1.07659869e-01f, 8.14857930e-02f, -4.69761379e-02f, 9.50181186e-02f, 2.80945990e-02f, 1.03270970e-01f, 9.49404947e-03f, 5.22334687e-02f,
  -2.57582357e-03f, 1.71285033e-01f, 1.25670582e-01f, -5.58935963e-02f, -6.47132620e-02f, 1.25390306e-01f, 1.49258107e-01f, -1.14615008e-01f, 7.16476887e-02f, 7.43498951e-02f,
  7.12741613e-02f, 4.76118736e-02f, 3.91944349e-02f, -4.06426415e-02f, -3.40510570e-02f, 1.01597279e-01f, 6.76824152e-02f, 7.02525079e-02f, -7.76864439e-02f, 1.84639134e-02f,
  -3.47499624e-02f, -5.35229631e-02f, -6.21203706e-02f, 1.37126595e-01f, -7.76011646e-02f, 1.82085276e-01f, -8.22228864e-02f, 4.80302833e-02f, -1.87832639e-01f, -4.68953922e-02f,
  -4.46491987e-02f, -8.64043981e-02f, 2.54581701e-02f, -2.79307872e-01f, 1.51779518e-01f, -2.48839691e-01f, -9.48631987e-02f, -2.19059065e-01f, -5.62170744e-02f, -9.69290435e-02f,
  -2.46696882e-02f, 1.36267850e-02f, -8.67726654e-02f, 2.15690285e-02f, -1.43623054e-01f, -2.29185093e-02f, 4.36760709e-02f, -1.69869757e-03f, -1.48116082e-01f, -5.47766574e-02f,
  -4.79202755e-02f, -4.86733690e-02f, 3.75651479e-01f, -1.46231517e-01f, 2.03391016e-02f, 3.16761322e-02f, -1.07846245e-01f, 9.17208195e-02f, -2.59325862e-01f, 2.62646437e-01f,
  1.31931931e-01f, 5.93423918e-02f, 1.25852719e-01f, 1.26681268e-01f, -6.45938888e-02f, 1.00803286e-01f, 1.22261219e-01f, 2.34018713e-02f, -1.80818029e-02f, 1.71404809e-01f,
  3.59965526e-02f, -5.63865528e-03f, 1.91066384e-01f, 5.93859479e-02f, 1.18564367e-01f, 1.03689544e-01f, -1.80699583e-02f, 8.89506936e-02f, 6.78116176e-03f, 2.28706785e-02f,
  2.72341967e-02f, 7.85348639e-02f, 5.23071028e-02f, 1.54699817e-01f, 6.69385269e-02f, 5.30433916e-02f, -1.37883455e-01f, 2.12596744e-01f, -6.46956563e-02f, 8.26378614e-02f,
  -6.58097565e-02f, -4.06473279e-02f, -1.02782331e-01f, -1.04089163e-01f, -1.48289325e-02f, -2.37404287e-01f, -1.12970792e-01f, -2.34614149e-01f, 1.56301692e-01f, -8.44343975e-02f,
  -2.19560400e-01f, 1.19242752e-02f, 5.41631617e-02f, 9.91917849e-02f, -2.83656996e-02f, -1.20387390e-01f, 2.99956743e-02f, 2.17657872e-02f, 1.34144217e-01f, -1.19977027e-01f,
  -1.06199674e-01f, 1.32819125e-02f, 1.14680111e-01f, -7.31845126e-02f, -2.25540027e-02f, 2.49339342e-02f, 1.32456571e-01f, -5.03276773e-02f, 5.69589203e-04f, 2.89887749e-02f,
  4.55547273e-02f, 2.82411873e-01f, -2.21896082e-01f, 1.61105573e-01f, 1.12443134e-01f, 6.03814609e-02f, 1.25637269e-02f, 1.70714688e-03f, 7.95847625e-02f, 4.70832214e-02f,
  6.48827404e-02f, 1.26156583e-01f, -7.82656521e-02f, -7.27597810e-03f, 1.36981998e-02f, 1.42420471e-01f, 5.79542890e-02f, -2.39155591e-02f, -1.08273633e-01f, 1.40181091e-02f,
  5.17176930e-03f, -9.80344564e-02f, 6.36760369e-02f, 3.95407230e-02f, 9.94993076e-02f, 8.43658373e-02f, -3.95215899e-02f, -1.17641956e-01f, -2.60195434e-01f, 1.75183173e-02f,
  -1.47344515e-01f, 1.25193903e-02f, -1.32720679e-01f, 7.67232627e-02f, 1.65364414e-01f, -2.00871021e-01f, -1.91485998e-03f, 8.67230296e-02f, -1.37707606e-01f, 1.01460449e-01f,
  1.46056920e-01f, 4.57876772e-02f, 3.06295920e-02f, -1.65664405e-01f, 2.21926153e-01f, -8.93481001e-02f, 1.35847241e-01f, -1.30010741e-02f, 1.30307183e-01f, 2.45205954e-01f,
  2.46435255e-02f, -2.58775335e-02f, 1.95230115e-02f, 5.47286123e-02f, 1.51158720e-01f, 1.54693350e-01f, -1.10242672e-01f, 3.89810242e-02f, 1.00831248e-01f, -1.20500937e-01f,
  -1.81947071e-02f, 2.01233253e-01f, -3.18753570e-02f, -4.12744582e-02f, -6.79707434e-03f, -1.14637420e-01f, 1.01359703e-01f, 8.90976638e-02f, -3.24848369e-02f, 1.45446435e-01f,
  -2.58778147e-02f, 6.47480190e-02f, 1.20537020e-01f, -2.37072371e-02f, 4.20847349e-03f, 2.60844845e-02f, 1.56811923e-01f, 3.17042787e-03f, 1.28339693e-01f, -2.53703296e-02f,
  6.18951619e-02f, 9.24846306e-02f, -3.16824801e-02f, -5.78690656e-02f, -2.82833595e-02f, 6.28365204e-02f, 3.78533155e-02f, 3.27199735e-02f, 3.01805064e-02f, -5.74519252e-03f,
  -1.35671407e-01f, 4.31942241e-03f, 7.57512525e-02f, -3.89938913e-02f, 1.02650985e-01f, 7.42204785e-02f, -9.56256464e-02f, 5.40836453e-02f, -1.54220060e-01f, 8.64916742e-02f,
  -2.48185202e-01f, -1.20849274e-01f, -1.00493133e-01f, 9.81550142e-02f, -2.34850170e-03f, -1.56683456e-02f, 8.79847780e-02f, -1.58097699e-01f, 4.22500679e-03f, -1.29160672e-01f,
  -7.71763995e-02f, -1.16164729e-01f, 2.03940779e-01f, 1.54359013e-01f, -1.04443595e-01f, -1.40127609e-03f, -9.70991775e-02f, 7.33195692e-02f, -1.91344824e-02f, -4.81555723e-02f,
  -1.74327388e-01f, 7.21739158e-02f, 1.85394719e-01f, 2.10997500e-02f, 3.17895889e-01f, -1.16316311e-01f, 2.16236562e-01f, -4.84784581e-02f, -1.07174888e-01f, -2.68201251e-02f,
  -1.03817424e-02f, 1.41390651e-01f, 7.00093582e-02f, -9.40778330e-02f, 1.50859669e-01f, 6.75175190e-02f, 5.82551546e-02f, 1.66199759e-01f, 1.63248569e-01f, -9.09692645e-02f,
  -2.69144680e-02f, 1.06842771e-01f, -9.26152337e-03f, -1.01848682e-02f, -7.08657783e-03f, 1.46695450e-01f, 7.95560628e-02f, 1.45652160e-01f, 4.56279702e-02f, 6.19196780e-02f,
  4.95675541e-02f, 1.85900088e-02f, -1.54172108e-01f, -1.49447322e-01f, -1.07497916e-01f, 2.71345265e-02f, -4.33989465e-02f, -4.01629508e-02f, 1.55172065e-01f, 8.02126825e-02f,
  -7.72074685e-02f, 6.97371364e-02f, -1.56093121e-01f, 1.98671669e-01f, 1.45929664e-01f, 2.46596076e-02f, 9.23406631e-02f, -7.45232627e-02f, -1.03474706e-01f, -1.25394044e-02f,
  2.51621082e-02f, 2.32951790e-01f, 8.24323967e-02f, 1.21646792e-01f, -1.53034525e-02f, -8.15249234e-02f, -5.11992462e-02f, -1.30807012e-01f, -1.31346837e-01f, -1.36849418e-01f,
  1.29995239e-03f, -8.75120461e-02f, -2.41874605e-02f, -5.34656122e-02f, -2.87121553e-02f, 8.13070089e-02f, -1.30812421e-01f, -5.70428669e-02f, 8.95023644e-02f, 8.87401849e-02f,
  -8.93290639e-02f, 8.28796625e-02f, 2.22944781e-01f, 2.96459831e-02f, 1.41036987e-01f, 1.11386165e-01f, -2.33466248e-03f, -3.42193730e-02f, -1.21548045e-02f, -4.17840580e-04f,
  5.69670014e-02f, -1.97603796e-02f, 7.41129518e-02f, 7.60166496e-02f, 3.93303111e-02f, -7.84199238e-02f, -5.44818304e-02f, 1.04641095e-01f, -5.97324371e-02f, -1.92017702e-03f,
  -1.56467229e-01f, -3.84340622e-02f, 1.57732815e-02f, -1.05411047e-02f, 1.22360669e-01f, -1.16727091e-02f, 2.49433685e-02f, -5.24351858e-02f, 6.51267311e-03f, -1.24641471e-01f,
  -9.57417265e-02f, -3.88327567e-03f, 3.98616232e-02f, -3.31543982e-02f, -7.58685619e-02f, -8.36796835e-02f, 6.42311946e-02f, 4.86857630e-02f, -4.94574942e-02f, -1.50532043e-02f,
  -4.21350151e-02f, 2.30500638e-01f, 6.78696632e-02f, 1.52618662e-01f, 4.85537545e-04f, -4.51006405e-02f, 1.68612882e-01f, -3.33416387e-02f, -1.08235851e-02f, -5.80959208e-02f,
  1.61675617e-01f, 2.10726693e-01f, -1.78470865e-01f, -6.31284267e-02f, -6.36829063e-02f, 2.19696194e-01f, 1.26044899e-01f, 1.69166587e-02f, -4.50607575e-02f, 1.41371235e-01f,
  1.52633205e-01f, -5.73494583e-02f, 9.44116861e-02f, 2.29883287e-02f, 1.88070878e-01f, -6.10008575e-02f, -6.21511489e-02f, -1.83925599e-01f, 1.28517404e-01f, -6.27931058e-02f,
  -5.31635620e-02f, 2.12101713e-01f, 1.69855848e-01f, -6.95968568e-02f, -6.55865595e-02f, -8.75859559e-02f, -1.98716417e-01f, 3.82839236e-03f, 4.29909937e-02f, 4.54576463e-02f,
  8.72911587e-02f, 1.13073979e-02f, 2.05522358e-01f, -6.38242215e-02f, 7.63431191e-04f, -3.14846151e-02f, 1.04480043e-01f, 1.16792589e-01f, 6.71421438e-02f, -1.81204215e-01f,
  -5.73465601e-02f, 1.79901928e-01f, 2.07439855e-01f, 1.29342258e-01f, 1.96077585e-01f, -2.97103152e-02f, -1.35998681e-01f, -1.90981388e-01f, 2.55481023e-02f, 9.54881907e-02f,
  9.38455202e-03f, 8.54479820e-02f, -1.16545923e-01f, 1.00793131e-01f, 1.15324847e-01f, -1.30795971e-01f, -3.41525339e-02f, 1.23877883e-01f, -8.98278970e-03f, 8.30808003e-03f,
  -7.29229255e-03f, 2.57846385e-01f, 1.84023917e-01f, -2.82731417e-05f, -3.11050396e-02f, 3.66722867e-02f, 2.75225431e-01f, 1.02388479e-01f, 1.42833337e-01f, -3.79624069e-02f,
  -7.98512846e-02f, 1.37731597e-01f, -1.30314454e-01f, -9.99613702e-02f, 4.51606400e-02f, 2.23817229e-01f, -1.23738140e-01f, 1.50146663e-01f, 1.02658615e-01f, 1.71960920e-01f,
  2.09876120e-01f, 1.55647531e-01f, 1.67638082e-02f, -1.88912109e-01f, 1.85833275e-01f, 1.37429953e-01f, -5.07168062e-02f, 1.33125454e-01f, 4.39297408e-02f, 9.14926082e-02f,
  2.05974981e-01f, 5.83544485e-02f, -1.54043540e-01f, 1.37891144e-01f, 9.62120071e-02f, 1.72052234e-01f, -1.92134500e-01f, 1.16867706e-01f, 1.13456585e-01f, -1.58746447e-02f,
  -3.53393960e-03f, -5.54306097e-02f, 1.40027985e-01f, 1.15715511e-01f, 2.17283323e-01f, 8.67684744e-03f, 1.29221886e-01f, 3.60368825e-02f, -2.15657696e-01f, 6.55533597e-02f,
  -3.01433112e-02f, 7.49627501e-02f, 2.00086892e-01f, -1.62507236e-01f, 1.42176330e-01f, -1.01079173e-01f, 2.42655113e-01f, -1.17286377e-01f, -1.29877403e-01f, 8.65720734e-02f,
  1.32915944e-01f, -2.81275660e-01f, 3.22681456e-03f, 9.01555270e-03f, -6.16952702e-02f, -1.63401142e-01f, -2.25545257e-01f, -1.71050113e-02f, 6.03142492e-02f, -1.47413149e-01f,
  -1.69424236e-01f, 3.52935083e-02f, 3.21365409e-02f, 1.39721925e-03f, 2.63988644e-01f, -8.96847397e-02f, 2.01371700e-01f, 7.14127049e-02f, -7.40977302e-02f, -7.00462759e-02f,
  -1.66836634e-01f, -1.97104245e-01f, -5.12259752e-02f, -5.54161938e-03f, -2.04390332e-01f, 6.32590875e-02f, -8.48255679e-02f, 1.33834437e-01f, -1.21243233e-02f, -3.52184065e-02f,
  4.26503569e-02f, 2.57208403e-02f, -3.14779766e-03f, 2.78747845e-02f, -1.68481618e-02f, 4.36677635e-02f, 3.85159813e-02f, 1.20700181e-01f, 1.60674676e-01f, 9.66731459e-02f,
  -3.47969495e-02f, 1.03026582e-02f, 1.03819557e-01f, 1.71065927e-02f, 2.52026692e-03f, 5.41747361e-02f, 6.54917136e-02f, -3.01421490e-02f, -1.68563187e-01f, -7.44645745e-02f,
  3.49166729e-02f, 3.13184261e-02f, 9.99665335e-02f, -1.44998014e-01f, 1.31765857e-01f, -2.18890384e-02f, 5.71011491e-02f, 4.29087654e-02f, -1.33704841e-01f, 2.08598986e-01f,
  1.42018601e-01f, 5.12266830e-02f, 1.80106834e-01f, -3.69623080e-02f, -8.34272802e-02f, 4.28411849e-02f, 1.99945457e-02f, 2.89421588e-01f, -2.62272283e-02f, 1.55178547e-01f,
  3.90078910e-02f, -3.41757983e-02f, -3.46682370e-02f, -1.76074415e-01f, 3.23638357e-02f, 8.34116116e-02f, -4.57887501e-02f, -7.87580237e-02f, -1.24811225e-01f, -1.23917595e-01f,
  3.20998020e-02f, 7.01609775e-02f, -9.74726975e-02f, 1.56898335e-01f, 1.03026114e-01f, 2.04933360e-02f, -6.16450189e-03f, 1.51353344e-01f, 1.27132386e-01f, 3.35402191e-02f,
  2.32496336e-01f, -5.40511869e-02f, 6.35640547e-02f, -7.08004460e-02f, 3.79746147e-02f, 2.17388161e-02f, 4.41106036e-02f, 9.86758620e-02f, 5.01604863e-02f, 1.57858115e-02f,
  7.59600615e-03f, 1.12006150e-01f, 1.70994192e-01f, -5.07038236e-02f, -8.82633477e-02f, -5.55824582e-03f, 8.88459980e-02f, 3.46214301e-03f, 9.28497761e-02f, 4.32869345e-02f,
  3.78699275e-03f, -3.72953378e-02f, -2.18794160e-02f, 1.84183493e-02f, -4.21323739e-02f, 8.05409104e-02f, -3.86504643e-02f, -9.01669934e-02f, 4.73671705e-02f, 1.17045462e-01f,
  4.27986123e-02f, 1.50623262e-01f, -5.22611849e-02f, 5.98046407e-02f, -3.49404290e-03f, -2.99267787e-02f, 1.60734311e-01f, -4.36046645e-02f, 4.05451357e-02f, -1.66308567e-01f,
  8.85028988e-02f, 6.73166737e-02f, -7.53617063e-02f, 1.50569335e-01f, 2.84418724e-02f, -6.77723065e-02f, -1.25098646e-01f, -1.60416663e-01f, -5.89485466e-03f, 7.65997842e-02f,
  2.58973725e-02f, -1.18034296e-01f, -2.58804928e-03f, -7.09452033e-02f, 7.57042840e-02f, -2.06244476e-02f, -8.50462690e-02f, 7.20720217e-02f, 1.13402337e-01f, -1.53186128e-01f,
  -2.76832357e-02f, 1.12433098e-01f, 1.13557935e-01f, 1.09598458e-01f, -1.24749258e-01f, 9.17837694e-02f, 1.49182009e-03f, -4.11428027e-02f, -5.25384061e-02f, -1.81479622e-02f,
  1.42679453e-01f, 5.02738655e-02f, 1.16850495e-01f, 2.45922878e-02f, 9.44334045e-02f, 6.62874952e-02f, 1.21386707e-01f, -7.85300042e-03f, 1.01052104e-02f, 1.46307468e-01f,
  -1.30477762e-02f, -5.43257222e-02f, 6.79740449e-03f, 6.20577037e-02f, 6.97697327e-02f, 1.00510595e-02f, -9.63089988e-02f, -1.15253657e-01f, -1.52751818e-01f, -1.74011365e-01f,
  2.69722659e-02f, -1.13637500e-01f, 1.76306531e-01f, 6.62852917e-03f, -7.57412389e-02f, -9.94530916e-02f, -2.31310323e-01f, 1.44668832e-01f, -5.32720871e-02f, -1.49485186e-01f,
  -3.31924334e-02f, 1.38470381e-01f, -4.25067693e-02f, 8.38103294e-02f, 1.88109837e-02f, 8.30112696e-02f, 9.98019278e-02f, -1.07447363e-01f, -2.01749623e-01f, -7.01431781e-02f,
  1.10822409e-01f, 2.59074126e-03f, -1.16834112e-01f, 4.20000143e-02f, -9.49417204e-02f, 4.83931862e-02f, -8.74358490e-02f, -9.80305672e-02f, -5.44907153e-02f, 2.03720629e-01f,
  1.91267133e-01f, 5.28279953e-02f, 3.11124951e-01f, -4.17733938e-02f, 1.13869213e-01f, -8.35491493e-02f, -9.25489143e-02f, 1.40383304e-03f, 1.89403713e-01f, 6.71259388e-02f,
  3.92253436e-02f, 1.47562310e-01f, 1.35086486e-02f, 9.89806373e-03f, 1.42580539e-01f, -7.26061389e-02f, 9.57304984e-03f, 6.71373829e-02f, 8.41584578e-02f, -4.76024970e-02f,
  -2.08851788e-03f, 1.19519807e-01f, 9.23054218e-02f, -5.05191572e-02f, -7.59949312e-02f, -5.48242107e-02f, 1.26835303e-02f, -7.84486812e-03f, 1.14559010e-01f, 6.61525596e-03f,
  1.38903379e-01f, 1.32743716e-01f, -6.01132698e-02f, -3.24283130e-02f, -3.10822725e-02f, -9.37854126e-02f, -4.10971940e-02f, -1.16033137e-01f, -1.38780877e-01f, 3.48177887e-02f,
  8.30636472e-02f, -4.67851199e-02f, -1.30065843e-01f, 1.69964917e-02f, -1.76481366e-01f, 1.03664204e-01f, 1.38937339e-01f, 1.94001365e-02f, -6.08077161e-02f, -1.35878608e-01f,
  1.72297180e-01f, -8.73462781e-02f, 1.58146083e-01f, 4.83921543e-02f, 8.22202489e-02f, 2.90413052e-01f, 5.82648888e-02f, 3.13265435e-02f, 9.20839757e-02f, 1.14347152e-01f,
  1.27192631e-01f, 9.49301422e-02f, -1.16230354e-01f, 2.24690344e-02f, 2.14233205e-01f, -1.70718804e-02f, -2.22197138e-02f, 1.80125520e-01f, 2.04460353e-01f, -5.65321594e-02f,
  -1.04212642e-01f, -1.12121701e-01f, 4.26027849e-02f, -1.06216244e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  7.78955519e-02f, 8.30986276e-02f, -2.00100467e-02f, 1.37548536e-01f, -4.15467545e-02f, 6.24672882e-02f, 1.33215845e-01f, 1.27411578e-02f, 9.17565152e-02f, 7.71485940e-02f,
  4.78214398e-02f, 7.41119459e-02f, 8.22535902e-02f, 1.82923432e-02f, 2.99494918e-02f, 3.52218188e-02f, 6.75939173e-02f, 2.51686852e-02f, -9.32430383e-04f, 8.15235544e-03f,
  4.89745066e-02f, 1.32778466e-01f, 8.64684880e-02f, 6.11546934e-02f, -2.89023072e-02f, 1.06518626e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  4.09988575e-02f, -3.05902250e-02f, 8.68989602e-02f, 6.17157556e-02f, 3.23254289e-03f, -2.12266054e-02f, -1.65527105e-01f, -3.93613726e-02f, 5.08093908e-02f, -7.40339532e-02f,
  -7.58397877e-02f, -3.97226354e-03f, -5.59953228e-02f, -2.12695654e-02f, 6.05543926e-02f, -5.44569641e-02f, -3.12652625e-03f, 9.20638740e-02f, -2.22595409e-02f, -2.53849179e-02f,
  -2.02746928e-01f, -8.81673470e-02f, -1.71063364e-01f, -1.94263950e-01f, -1.05159774e-01f, -1.85604870e-01f, -1.12754991e-02f, 5.53087518e-02f, -9.57086161e-02f, 1.73207179e-01f,
  6.80902079e-02f, 9.80701819e-02f, -6.81079328e-02f, -1.34758115e-01f, 1.07254982e-01f, 3.57254259e-02f, 8.64962712e-02f, 6.66209087e-02f, 2.53189385e-01f, -1.08112500e-03f,
  2.30077714e-01f, -1.29694074e-01f, 2.65807569e-01f, -2.97141764e-02f, -1.91959068e-01f, -3.64399292e-02f, 1.85934290e-01f, -1.83386922e-01f, 1.01120844e-01f, -7.65353367e-02f,
  1.02245420e-01f, -7.66462758e-02f, 1.59543395e-01f, 1.16015173e-01f, 9.51608345e-02f, 1.33607864e-01f, -1.97663554e-03f, -9.24035348e-03f, 2.34411672e-01f, -2.16562927e-01f,
  -1.12376176e-01f, 1.13422461e-02f, -1.04824841e-01f, 5.62768914e-02f, 2.60880543e-03f, -1.89839397e-02f, 7.37871882e-03f, 9.54071060e-02f, 6.50306884e-03f, 7.08230818e-03f,
  -5.59793934e-02f, 8.31324905e-02f, 1.02324300e-01f, -1.16811646e-02f, 4.60186861e-02f, -8.62278715e-02f, -9.89984721e-03f, 1.78176332e-02f, 8.73752125e-03f, -7.33421594e-02f,
  -2.28535347e-02f, 2.01359037e-02f, 4.16565239e-02f, 9.29916129e-02f, -1.71438545e-01f, -4.86013778e-02f, 6.52664304e-02f, -3.42573486e-02f, -8.46107453e-02f, -1.62320867e-01f,
  1.22425810e-01f, 9.67227817e-02f, 1.25139818e-01f, -6.94989190e-02f, 1.13385484e-01f, 1.61822200e-01f, -1.15344420e-01f, -2.00653240e-01f, 2.30303213e-01f, -5.24052884e-03f,
  -6.42956942e-02f, 2.95781866e-02f, 2.41343454e-01f, 5.29235229e-03f, -1.10011613e-02f, -9.69051719e-02f, 1.61947876e-01f, 1.48754239e-01f, -1.55934528e-01f, -1.18621029e-01f,
  -8.70826375e-03f, -1.44013911e-01f, 1.41057327e-01f, -2.02074591e-02f, 2.25190707e-02f, 4.57255132e-02f, -7.58847892e-02f, 4.02439572e-02f, 3.69608030e-02f, -1.12586915e-01f,
  -1.24086723e-01f, -3.81068327e-02f, 1.16317295e-01f, 8.72932076e-02f, -8.46791044e-02f, -1.12103149e-01f, -6.35775775e-02f, -1.55915143e-02f, 2.63899472e-02f, 3.67131196e-02f,
  -2.25516930e-02f, -1.11364154e-02f, -6.63442910e-02f, 4.92049605e-02f, 1.21718328e-02f, -3.54040647e-03f, -3.47420499e-02f, 2.95109935e-02f, -4.28159907e-03f, -3.88200097e-02f,
  -1.05059266e-01f, 5.51754199e-02f, 4.73113991e-02f, -5.82838058e-02f, -5.31762931e-03f, 7.78389648e-02f, -3.19910608e-02f, 9.76953879e-02f, 1.66563913e-01f, -1.96265243e-02f,
  -1.86579600e-01f, 7.25099668e-02f, -1.16743416e-01f, -7.55844787e-02f, -3.79077382e-02f, 1.99835405e-01f, -1.70845136e-01f, -4.22178470e-02f, 2.80710328e-02f, 3.40174325e-02f,
  -8.71605799e-02f, 1.27375633e-01f, -3.44416983e-02f, -1.57230258e-01f, 6.24454170e-02f, 6.86223581e-02f, -4.22305949e-02f, 1.64603144e-02f, -2.56295712e-03f, 8.88331085e-02f,
  4.51311655e-02f, -1.30784765e-01f, -9.45037380e-02f, 6.82069510e-02f, 4.93708961e-02f, 7.88336247e-03f, 1.75185762e-02f, -8.96755457e-02f, 4.65611443e-02f, 7.27245435e-02f,
  6.54534772e-02f, 8.70573744e-02f, -2.27123097e-01f, -7.43418112e-02f, 1.14494070e-01f, -1.91411749e-01f, -1.01398490e-02f, 8.48711282e-02f, 1.48790702e-01f, 1.14149697e-01f,
  2.72682812e-02f, -1.90600127e-01f, -3.06794420e-02f, 6.54607266e-02f, -2.81734131e-02f, -1.57950073e-02f, -3.30371708e-02f, -6.89496398e-02f, -8.52983966e-02f, -9.26887691e-02f,
  -5.12447953e-02f, -5.01723029e-02f, -9.52129811e-02f, -9.35509503e-02f, 4.53680567e-02f, -8.49725902e-02f, -6.47650510e-02f, 1.47987464e-02f, 4.57603261e-02f, -8.85413960e-02f,
  4.71197776e-02f, -1.34383246e-01f, -1.09277412e-01f, 4.67236896e-05f, -6.44623116e-02f, -8.84663388e-02f, 1.45002808e-02f, 7.67795965e-02f, -9.98070985e-02f, -5.90770394e-02f,
  -1.07928380e-01f, 9.83364210e-02f, 5.98066263e-02f, 7.01937005e-02f, 4.96386588e-02f, 1.89116582e-01f, 9.74147692e-02f, 1.09344929e-01f, 1.15248941e-01f, 2.06175055e-02f,
  8.10135677e-02f, -8.55411962e-02f, 2.00461894e-01f, -1.91840261e-01f, 7.59439170e-02f, 1.60740744e-02f, 6.12578876e-02f, -1.08865164e-01f, 1.00270137e-01f, 2.59716585e-02f,
  -5.77102304e-02f, -8.39616805e-02f, -1.16514482e-01f, 6.36119321e-02f, 4.14427482e-02f, -4.55766469e-02f, -8.34268611e-03f, 7.78926387e-02f, -7.97512010e-02f, -6.20280355e-02f,
  1.53153643e-01f, -2.57472187e-01f, -1.02352025e-02f, -5.00715375e-02f, 7.88514540e-02f, 1.08440980e-01f, 1.15126194e-02f, 1.72591694e-02f, -3.81457992e-02f, -4.97799776e-02f,
  -2.88051795e-02f, 8.28282386e-02f, 3.46726105e-02f, 3.88124175e-02f, -1.02924071e-02f, 1.21809997e-01f, 4.07005697e-02f, 3.13064978e-02f, 4.42355722e-02f, 1.12098977e-02f,
  8.50495026e-02f, 1.66722685e-01f, 1.17336139e-01f, 1.15680750e-02f, 1.33875772e-01f, 6.56720530e-03f, 4.31816913e-02f, 1.30929872e-01f, 2.02166572e-01f, 1.46304831e-01f,
  5.27361073e-02f, 1.16168678e-01f, -2.03373522e-01f, 7.46146291e-02f, -4.71019894e-02f, -2.25109771e-01f, 1.72885716e-01f, 7.20687509e-02f, 3.27718742e-02f, 1.95395857e-01f,
  2.63587236e-01f, -1.14345342e-01f, -1.97811618e-01f, -1.23921402e-01f, -6.01090379e-02f, -2.54388358e-02f, 7.11947829e-02f, 7.34181851e-02f, 1.00059584e-01f, 8.04402493e-03f,
  1.88855708e-01f, -5.89117780e-02f, -1.70735925e-01f, 1.09585665e-01f, 9.31216478e-02f, 1.93593755e-01f, -1.23577975e-01f, 1.96604300e-02f, -1.36842683e-01f, 1.89174451e-02f,
  -9.53427628e-02f, -5.07732034e-02f, -1.36311743e-02f, 4.25468646e-02f, 1.25069156e-01f, 4.69159074e-02f, 7.84969553e-02f, -4.94613834e-02f, -1.23704307e-01f, -7.49248490e-02f,
  5.03553711e-02f, 3.82050425e-02f, -6.87414557e-02f, -6.44077957e-02f, 1.13103092e-01f, 2.66718641e-02f, -1.25544026e-01f, 1.76742934e-02f, -6.83552586e-03f, 1.18897420e-04f,
  1.67663954e-02f, -3.19003058e-03f, -7.14364499e-02f, -6.33775070e-02f, -4.26043160e-02f, -4.54080552e-02f, -2.58847885e-02f, -1.93332732e-02f, -9.74887051e-03f, 1.02150522e-01f,
  3.28145036e-03f, -1.06938757e-01f, -1.10935949e-01f, 3.72920334e-02f, -4.49582972e-02f, -1.82725489e-01f, 1.00786090e-01f, 1.10972621e-01f, 9.60500259e-03f, 3.96458898e-03f,
  4.34540287e-02f, -7.96975289e-03f, -1.19283758e-01f, -6.34083524e-02f, 1.94072142e-01f, -4.25612815e-02f, -1.30298035e-03f, -1.00110814e-01f, 2.17504486e-01f, 9.55539793e-02f,
  -2.53885556e-02f, -7.80987889e-02f, 9.05449539e-02f, 1.03781268e-01f, -1.98206887e-01f, -6.63498640e-02f, 1.32722229e-01f, -1.25551090e-01f, -1.31905079e-02f, 6.73308671e-02f,
  4.66584340e-02f, -4.00627702e-02f, -1.62033468e-01f, -3.20029110e-02f, 5.92794977e-02f, -9.23531726e-02f, -5.90212829e-02f, -5.85407810e-03f, 2.30384976e-01f, -1.22155003e-01f,
  -3.07913553e-02f, -2.37135161e-02f, -1.09792657e-01f, 1.29263047e-02f, 7.06946291e-03f, 3.19919288e-02f, -1.29358232e-01f, -9.39702149e-03f, 3.81349735e-02f, -2.80360552e-03f,
  4.47360985e-02f, -1.49407731e-02f, 7.49121755e-02f, 6.02973327e-02f, -8.55234936e-02f, -1.84952572e-01f, 2.63107177e-02f, -5.19369654e-02f, 4.59323227e-02f, 3.19415145e-02f,
  3.16661336e-02f, -6.94272341e-03f, 9.26498249e-02f, -5.07995076e-02f, 1.54715059e-02f, 6.04148768e-02f, 7.62317777e-02f, -1.01073280e-01f, 1.76649932e-02f, 1.07874572e-01f,
  -8.22094902e-02f, 3.51660214e-02f, -1.21088855e-01f, -1.07757039e-01f, 1.40361220e-01f, 1.11509450e-01f, 1.70476407e-01f, 1.98537245e-01f, -4.63481545e-02f, 1.57214865e-01f,
  5.33105172e-02f, 6.61971197e-02f, -1.51860779e-02f, -1.97986990e-01f, -1.20096409e-03f, -2.67300867e-02f, -5.84886260e-02f, -4.27648425e-03f, 1.19937398e-01f, -4.71991487e-02f,
  -1.58595204e-01f, 1.75276548e-01f, 6.90963939e-02f, -1.06250033e-01f, -2.26306766e-01f, 1.54528931e-01f, -2.04371121e-02f, 8.43061507e-03f, -1.09310187e-01f, 9.26474556e-02f,
  -1.02848165e-01f, 2.60172244e-02f, 1.28550604e-01f, -8.02692473e-02f, 4.12575305e-02f, -1.23896245e-02f, 1.30825102e-01f, -4.08436172e-02f, 1.51630165e-02f, -1.46315590e-01f,
  -1.11696281e-01f, -1.05246998e-01f, -4.73444536e-02f, 2.40066107e-02f, -8.45296830e-02f, -1.62213426e-02f, -3.29452045e-02f, -6.29135370e-02f, -1.15917608e-01f, -1.52773574e-01f,
  -1.70461163e-01f, -1.78968355e-01f, -9.02752578e-02f, -4.40811738e-04f, -3.68022770e-02f, -5.70020750e-02f, -1.01612173e-01f, 2.47094426e-02f, -9.75977331e-02f, -1.38682172e-01f,
  7.11848075e-03f, 1.48589872e-02f, -1.01714648e-01f, -2.35531837e-01f, 2.06720084e-01f, 4.18620743e-02f, 1.36404276e-01f, 6.55355975e-02f, 4.99947257e-02f, -5.32889590e-02f,
  -3.68315540e-02f, -9.97237936e-02f, 2.20210791e-01f, 3.95257697e-02f, 8.30417722e-02f, -4.14614892e-03f, 1.77867055e-01f, 7.96932504e-02f, -1.57752052e-01f, -1.62648454e-01f,
  3.15210074e-02f, 5.79552129e-02f, -8.40177834e-02f, -1.95994601e-02f, -2.86305975e-02f, -8.75123292e-02f, 7.59733841e-02f, -3.67080830e-02f, -7.66429007e-02f, 3.06105576e-02f,
  -2.14216739e-01f, -6.82093427e-02f, -3.02378181e-03f, -1.86526686e-01f, -5.85024245e-02f, -1.17669068e-01f, 1.25962079e-01f, -7.60334432e-02f, 3.10446080e-02f, 1.95107404e-02f,
  -1.49035424e-01f, -5.06317196e-03f, -1.45114539e-02f, 1.64031740e-02f, 2.63955686e-02f, -5.49129546e-02f, 1.11560024e-01f, -1.92829836e-02f, -2.37142500e-02f, 8.11853185e-02f,
  8.96864831e-02f, -3.65581289e-02f, 7.90166259e-02f, -7.76208565e-03f, 5.91589585e-02f, -1.77552756e-02f, -1.95100214e-02f, 3.60848308e-02f, 6.34352490e-02f, -6.05342612e-02f,
  9.51898545e-02f, 1.97717771e-02f, -2.60090590e-01f, -1.22010276e-01f, 1.29761711e-01f, -1.86427385e-01f, -8.07854012e-02f, -6.31833151e-02f, 8.29377845e-02f, -7.98637792e-02f,
  7.45078325e-02f, -8.45242143e-02f, 1.08165815e-01f, 1.30627885e-01f, 8.78682435e-02f, -2.15919957e-01f, -7.18125403e-02f, 1.68793038e-01f, 1.71850938e-02f, 1.91458777e-01f,
  -1.94346788e-03f, -4.62003378e-03f, -6.14881404e-02f, 7.06732869e-02f, -4.37322557e-02f, 2.43337825e-01f, 4.65670452e-02f, -1.31203458e-01f, -1.33217305e-01f, 1.06181137e-01f,
  1.78880870e-01f, -1.23596832e-01f, -1.17555469e-01f, 1.75419450e-01f, 3.22613865e-02f, 3.29984874e-02f, 9.95021313e-02f, 1.36937601e-02f, -9.69633088e-02f, 5.59542775e-02f,
  1.52315907e-02f, 1.83261737e-01f, -8.85475054e-02f, -2.65904330e-02f, -8.55934247e-02f, 1.50951058e-01f, 2.73572747e-02f, -7.30891973e-02f, -1.06991576e-02f, -1.39603987e-01f,
  -7.18261069e-03f, -5.45741729e-02f, 1.20410034e-02f, -1.27304867e-01f, -3.63354385e-02f, -1.67739503e-02f, -1.07553445e-01f, -5.21786399e-02f, 6.77732080e-02f, -1.54280052e-01f,
  -1.07683703e-01f, 7.27346353e-03f, 1.67863443e-02f, -9.49641615e-02f, -1.34109342e-02f, -1.29075497e-01f, 9.68553275e-02f, -1.76764652e-02f, -3.21523920e-02f, 1.02800116e-01f,
  1.14046276e-01f, 9.02498439e-02f, 7.06782937e-02f, -1.58975571e-01f, 1.23584181e-01f, 1.62424445e-01f, -1.59329534e-01f, -1.32796973e-01f, 1.38034876e-02f, 2.76796315e-02f,
  4.66051102e-02f, -3.21010803e-03f, -3.25550698e-02f, -1.75206423e-01f, 2.40558181e-02f, 1.67857870e-01f, -2.38490105e-02f, -1.06822252e-01f, -9.57879573e-02f, -9.51935947e-02f,
  -6.25658929e-02f, 3.21828909e-02f, 1.77124813e-01f, 1.42646525e-02f, -1.65635943e-01f, 1.38219073e-01f, 8.53412226e-02f, -1.10031217e-01f, -4.70802560e-02f, -1.15008645e-01f,
  1.02408715e-01f, -3.42812985e-02f, 1.20079204e-01f, 8.16561729e-02f, -4.99431863e-02f, -8.01647827e-02f, 1.64121017e-02f, -8.18638280e-02f, 9.15908143e-02f, 9.25645083e-02f,
  3.89672234e-04f, 6.65276572e-02f, -7.21341744e-02f, -7.07940236e-02f, -1.44733058e-03f, 2.70630270e-02f, 6.06121612e-04f, -1.13471098e-01f, -4.41364497e-02f, 2.41640229e-02f,
  -1.66222036e-01f, -3.64401634e-03f, 2.01624762e-02f, 3.11962911e-03f, 1.07883319e-01f, 8.60065520e-02f, 3.91344056e-02f, 3.40705737e-02f, -1.60514191e-02f, 3.53846848e-02f,
  8.61127749e-02f, 1.44457906e-01f, 6.27366826e-02f, 8.44242200e-02f, -1.98695734e-02f, 1.84475537e-02f, -2.35357910e-01f, 1.77629665e-01f, -1.46493301e-01f, -7.58698732e-02f,
  1.10657580e-01f, 1.39730334e-01f, 1.13387674e-01f, 2.99050629e-01f, 1.17363222e-01f, -7.49567002e-02f, -6.47000298e-02f, 9.99808386e-02f, -8.08419958e-02f, -1.73436671e-01f,
  2.16751859e-01f, -5.69808893e-02f, -2.66611739e-03f, 5.89477867e-02f, -8.35481752e-03f, 2.41445880e-02f, -1.00126639e-01f, 2.35525921e-01f, 8.36173131e-04f, 5.28426319e-02f,
  -1.00745715e-01f, -6.60087615e-02f, 5.55965956e-03f, 1.66029558e-01f, -1.20732769e-01f, -5.13933115e-02f, 2.52501667e-03f, -1.36115700e-01f, 4.30117399e-02f, -8.24428350e-02f,
  -1.98953543e-02f, -6.63396791e-02f, -2.13060416e-02f, -9.27471220e-02f, 6.32534688e-03f, 1.53986551e-02f, 1.09050795e-01f, 8.77611861e-02f, 8.01318139e-03f, -4.32117507e-02f,
  5.42887812e-03f, 1.01721170e-03f, 1.56904124e-02f, 8.56420621e-02f, 6.92977607e-02f, 1.21966945e-02f, 1.08309858e-01f, 1.00522742e-01f, 9.58831757e-02f, -6.37223795e-02f,
  -5.08551411e-02f, 8.87059420e-02f, 1.18369602e-01f, 2.53893957e-02f, -1.22882895e-01f, -1.36848047e-01f, -1.27812564e-01f, -2.05334187e-01f, -1.90257356e-02f, 8.70401487e-02f,
  -1.15152644e-02f, 1.41600212e-02f, -1.22961603e-01f, -1.52695691e-02f, -3.95302884e-02f, 8.17928314e-02f, -3.11642922e-02f, -1.22421384e-01f, -3.11776549e-01f, 1.30295366e-01f,
  9.27375033e-02f, 9.70284194e-02f, -1.26832157e-01f, 2.02291328e-02f, 4.17323895e-02f, 6.37408420e-02f, 1.54014779e-02f, -5.01899756e-02f, -2.14700513e-02f, -1.18844574e-02f,
  -8.29655863e-03f, -1.65809933e-02f, 3.60301230e-03f, -1.09380841e-01f, 4.68844846e-02f, 1.70474187e-01f, 1.77461773e-01f, -1.62101332e-02f, 3.86875030e-03f, 1.75633565e-01f,
  -1.45266533e-01f, 5.52828833e-02f, 4.14938247e-03f, 1.96839541e-01f, -5.60295098e-02f, 5.40155023e-02f, 5.49989454e-02f, 1.22226449e-02f, -1.44716710e-01f, 4.77829836e-02f,
  7.51257837e-02f, -4.87219952e-02f, -2.70406809e-02f, 3.15222666e-02f, -2.55602542e-02f, -1.60852298e-01f, -9.97093618e-02f, -7.91967586e-02f, -1.14701577e-01f, 8.65697488e-02f,
  -4.47920077e-02f, -9.80725139e-02f, -2.23499350e-02f, -1.03177791e-02f, -1.40411794e-01f, 2.25314703e-02f, -8.95128846e-02f, -8.49187374e-02f, 1.96430013e-01f, 8.99215937e-02f,
  -5.23213297e-02f, 3.03797740e-02f, 1.07532538e-01f, 1.07885167e-01f, -1.38919473e-01f, 6.64502243e-03f, -1.55250221e-01f, 6.54639676e-02f, -6.04668632e-02f, -1.29227519e-01f,
  1.58228185e-02f, 1.46493569e-01f, 9.42167174e-03f, -6.97900951e-02f, 2.56111287e-02f, -1.15137786e-01f, -1.32777289e-01f, -4.23201622e-04f, 1.52584016e-01f, 2.93038343e-03f,
  -6.78188354e-02f, -1.39487669e-01f, 5.60290143e-02f, 1.47821680e-01f, 1.63634583e-01f, 8.08854029e-02f, -1.22516915e-01f, 7.79800713e-02f, 8.37924778e-02f, -1.50550917e-01f,
  2.04382278e-02f, 8.56510252e-02f, -9.77932364e-02f, 7.75769204e-02f, 1.54358670e-01f, 7.12923631e-02f, -1.34491205e-01f, -2.00318992e-01f, 6.98863119e-02f, 2.03485023e-02f,
  4.18358669e-02f, -2.32056715e-02f, -5.33341840e-02f, -4.99260835e-02f, 5.84792458e-02f, 1.61035836e-01f, 4.89258170e-02f, 3.15257907e-02f, -1.03656612e-01f, 3.58853984e-04f,
  -5.13035059e-02f, 2.25788038e-02f, 1.06140561e-01f, 8.30507427e-02f, -5.46801137e-03f, -3.70238274e-02f, 8.34848136e-02f, -5.74332289e-02f, -3.49184871e-02f, -2.73597110e-02f,
  9.48542636e-03f, 8.29918906e-02f, -1.62770599e-01f, 4.08667065e-02f, 2.76891235e-03f, -1.73521917e-02f, -8.56602341e-02f, -1.05354816e-01f, -7.81350210e-02f, 1.13505479e-02f,
  3.87604274e-02f, 5.93232969e-03f, -5.19848289e-03f, 1.40393928e-01f, -9.44226012e-02f, -2.08114281e-01f, 1.96547717e-01f, -1.03030883e-01f, -1.05852894e-01f, -3.67074795e-02f,
  1.91729546e-01f, -5.17642777e-03f, 1.32449403e-01f, -1.03004053e-01f, 1.48491696e-01f, 1.17094606e-01f, -1.22446902e-01f, -9.70248282e-02f, 2.62124669e-02f, -1.53834537e-01f,
  4.02370356e-02f, -1.76838357e-02f, -4.10888623e-03f, -6.64489940e-02f, -1.33190732e-02f, -1.56862084e-02f, 1.32080391e-01f, -7.52665177e-02f, -9.22575220e-02f, -1.77141968e-02f,
  2.42320355e-02f, -8.92368704e-03f, -1.65638313e-01f, -3.15813310e-02f, -1.88885182e-01f, -4.80549363e-03f, -3.51367444e-02f, -6.29690588e-02f, 1.32777244e-01f, 6.33170009e-02f,
  4.08740304e-02f, 9.75753441e-02f, 3.99236642e-02f, 6.47360533e-02f, 7.02256523e-03f, 8.69314419e-04f, -6.51380233e-03f, 1.28701672e-01f, 5.50145954e-02f, 1.17571950e-02f,
  -6.45215735e-02f, -1.87736060e-02f, 5.18366974e-03f, 7.67131448e-02f, -4.11353409e-02f, 5.28037501e-03f, 1.21841431e-02f, 6.82267174e-02f, 3.33735235e-02f, -1.18406573e-02f,
  9.85031389e-03f, -9.87341851e-02f, 9.42790285e-02f, -5.56024201e-02f, 2.45426774e-01f, 1.93235323e-01f, -1.48095682e-01f, -2.12547049e-01f, -5.52650951e-02f, -2.96690971e-01f,
  -1.48711756e-01f, -2.90307105e-02f, 3.08100339e-02f, -4.09490615e-02f, -3.81330639e-04f, 1.34497479e-01f, -4.60605277e-03f, 5.87104820e-02f, -6.37924522e-02f, 8.05909112e-02f,
  4.43435274e-02f, 1.95538867e-02f, 1.64214581e-01f, -1.68755367e-01f, -1.75622981e-02f, 1.46138510e-02f, 2.49227837e-01f, -1.46420181e-01f, 1.05243087e-01f, 2.80492101e-02f,
  1.32316843e-01f, 7.96877071e-02f, 1.40529111e-01f, 1.21415429e-01f, -1.30256712e-01f, 6.89501837e-02f, 3.86703312e-02f, 5.88480495e-02f, 8.63187388e-02f, 4.72482704e-02f,
  -2.16997694e-02f, -2.93548200e-02f, 1.04814135e-01f, 2.23453585e-02f, -5.64173274e-02f, -2.10545398e-02f, -1.38758440e-02f, -5.87738492e-02f, 3.06112934e-02f, -6.10441901e-02f,
  8.06218311e-02f, 9.03034806e-02f, 5.37322909e-02f, 8.93934257e-03f, 3.38498317e-02f, -7.89359137e-02f, -1.37356609e-01f, 5.86261563e-02f, 4.04153168e-02f, 2.69789100e-02f,
  3.02721728e-02f, -1.41751692e-01f, -3.30421269e-01f, -1.46380633e-01f, -4.31615748e-02f, 1.08376052e-02f, 8.00996870e-02f, 8.87180418e-02f, -2.08255023e-01f, 1.16489768e-01f,
  -6.23431876e-02f, -2.64325067e-02f, -1.25949353e-01f, 2.50512436e-02f, -3.04928780e-01f, 1.16795473e-01f, 2.08885983e-01f, 2.96864007e-02f, -1.11138225e-01f, -1.19763426e-02f,
  3.00247800e-02f, 4.36793715e-02f, 8.34466144e-02f, -1.74359307e-01f, -1.13881994e-02f, 1.60789102e-01f, 1.43903673e-01f, -1.28609195e-01f, -9.82737690e-02f, -9.49782804e-02f,
  4.04576138e-02f, 7.79517815e-02f, 1.85701415e-01f, 5.87778315e-02f, -1.22467153e-01f, 1.98212206e-01f, 4.74629849e-02f, 5.29263243e-02f, 8.83411840e-02f, 2.34804209e-03f,
  1.29954234e-01f, 1.55253664e-01f, 3.33813056e-02f, 2.68788300e-02f, -4.80265394e-02f, -5.94305843e-02f, -8.82749110e-02f, -5.58367185e-02f, -3.38756889e-02f, -1.02831885e-01f,
  -5.68414181e-02f, -2.60086227e-02f, -1.02588862e-01f, -7.42775202e-02f, 7.03443363e-02f, -2.70485636e-02f, 8.33392963e-02f, -1.45059507e-02f, -1.53790370e-01f, -1.94913633e-02f,
  -5.78031242e-02f, -1.32945657e-01f, -1.24443054e-01f, -1.61004424e-01f, -2.94000823e-02f, 2.21828595e-02f, 8.95314366e-02f, 9.72948000e-02f, 1.74950093e-01f, 2.19134614e-01f,
  1.06553562e-01f, -2.52937943e-01f, 2.90748447e-01f, 1.03948899e-01f, -1.85837582e-01f, -2.00763792e-01f, -1.16299288e-02f, -1.67208582e-01f, 1.95523482e-02f, 1.48758382e-01f,
  -1.30953878e-01f, -2.08769634e-01f, -5.46807460e-02f, 1.80129796e-01f, -2.03967523e-02f, -7.86976740e-02f, -2.57546186e-01f, 1.32228613e-01f, 8.33344236e-02f, -1.43973351e-01f,
  3.76310525e-03f, 5.08246832e-02f, -6.36293441e-02f, 6.27058595e-02f, -1.20359190e-01f, -4.58347648e-02f, -1.67520121e-01f, -3.10761571e-01f, 9.44490656e-02f, 1.11772433e-01f,
  -6.82739541e-03f, 1.69706464e-01f, -1.83219701e-01f, -1.55918241e-01f, -5.40165454e-02f, -1.33336887e-01f, 7.75430799e-02f, 1.55642405e-01f, -4.06114943e-02f, 1.19013838e-01f,
  -5.09783812e-02f, 1.41610298e-02f, 6.31132796e-02f, -8.63113627e-02f, -1.74433906e-02f, -6.58194795e-02f, 2.26998422e-02f, 4.13120724e-02f, 1.18928868e-03f, -3.68352421e-02f,
  3.56835388e-02f, 2.13155020e-02f, 6.77125901e-02f, 7.65349716e-02f, -4.58568111e-02f, 7.66014010e-02f, 1.60422191e-01f, -4.81496118e-02f, -5.64427003e-02f, -5.07156067e-02f,
  -7.79384822e-02f, -1.06985919e-01f, 3.68071683e-02f, 8.57888162e-02f, -1.71983108e-01f, 5.33209443e-02f, -2.87334830e-01f, -1.16737165e-01f, 1.26772389e-01f, 2.25952655e-01f,
  3.76330540e-02f, 2.75631636e-01f, 1.54230287e-02f, 1.29314110e-01f, 1.00194752e-01f, 1.14471458e-01f, -8.73703212e-02f, -1.51044905e-01f, 1.70798510e-01f, -7.39004090e-03f,
  4.43291441e-02f, 1.63725298e-02f, 4.26200510e-04f, -5.90541326e-02f, -7.65396729e-02f, 1.04815312e-01f, 2.68058032e-02f, -7.35775232e-02f, -1.62521437e-01f, 1.24651402e-01f,
  9.68247950e-02f, 1.95058919e-02f, -5.15139811e-02f, 1.47628218e-01f, -1.50121093e-01f, 1.77743118e-02f, 1.13934755e-01f, -1.15170829e-01f, -7.54807666e-02f, 2.67340317e-02f,
  7.44727999e-02f, -5.06637171e-02f, -2.06991341e-02f, -4.59415615e-02f, -6.46128803e-02f, -1.24583142e-02f, 4.14071493e-02f, -7.19031543e-02f, -7.09512085e-02f, -1.18539132e-01f,
  3.08245956e-03f, -4.94311154e-02f, -4.89800982e-03f, -9.46731046e-02f, -2.72555873e-02f, -1.62915632e-01f, -8.86548981e-02f, -5.76122254e-02f, -7.20083937e-02f, -1.33016050e-01f,
  -2.42574755e-02f, 4.03677858e-02f, 2.28124727e-02f, -8.26496854e-02f, -1.04472317e-01f, 1.13984318e-02f, -5.04925288e-02f, -1.14046112e-01f, 1.76997297e-02f, -1.47677783e-03f,
  -1.46274894e-01f, 6.46492653e-03f, 9.44309533e-02f, 3.18544284e-02f, 3.48419398e-02f, 1.80686891e-01f, 2.51672834e-01f, 4.02228609e-02f, 7.22184628e-02f, -2.74834633e-02f,
  1.11186571e-01f, -2.29212176e-02f, 3.12416572e-02f, -1.69953465e-01f, 1.03090174e-01f, 1.28652658e-02f, -7.85592720e-02f, -3.14392783e-02f, -1.75315235e-02f, 4.02517691e-02f,
  6.37924895e-02f, -2.03266069e-02f, -1.56735852e-01f, 1.95253249e-02f, -1.28933012e-01f, -7.20916018e-02f, -4.20716703e-02f, -2.61713713e-02f, -3.66267562e-02f, -6.63684309e-02f,
  1.37838081e-01f, -1.31764099e-01f, -2.75330767e-02f, 1.38046779e-02f, -1.14066742e-01f, 1.73706729e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.53433734e-02f, -6.03436679e-02f, -1.88870355e-02f, -5.52124763e-03f, -5.05045839e-02f, 2.19578631e-02f, -3.56498621e-02f, 1.49235353e-02f, -3.03178327e-03f, -6.63946643e-02f,
  -1.29378587e-02f, -1.60972718e-02f, -5.21973595e-02f, -4.76516001e-02f, -1.19500756e-01f, -1.55592104e-02f, -8.99915490e-03f, -2.92878952e-02f, -1.36365369e-01f, -9.90947057e-03f,
  8.74525905e-02f, -3.83023289e-03f, -2.07085665e-02f, 1.13564849e-01f, 1.45468572e-02f, -7.15783611e-02f, 1.05744593e-01f, -2.76670940e-02f, 7.07514733e-02f, 6.64231628e-02f,
  -4.70455922e-02f, -1.15899719e-01f, -4.37279344e-02f, 5.82234226e-02f, 1.83975101e-01f, -6.76132515e-02f, -2.78417598e-02f, -1.10545948e-01f, 1.35242134e-01f, 2.10917234e-01f,
  -8.09359252e-02f, -7.78108314e-02f, 7.16726808e-03f, 2.42325887e-02f, -4.73948456e-02f, 8.05130154e-02f, 1.49185315e-01f, -9.83185396e-02f, -4.22824286e-02f, 1.21755697e-01f,
  8.62390772e-02f, -5.53245172e-02f, -1.83961645e-01f, -7.67209679e-02f, 3.72099131e-02f, -9.20156240e-02f, 1.22638129e-01f, 1.44022470e-02f, 9.53480303e-02f, -1.08740903e-01f,
  1.45978004e-01f, 5.61731076e-03f, -1.01656197e-02f, 2.16181930e-02f, 6.71065180e-03f, 3.59446630e-02f, 6.17344268e-02f, 6.05136529e-02f, 9.74934101e-02f, 5.65391444e-02f,
  -4.18564975e-02f, 7.19953254e-02f, 3.29353251e-02f, 5.64811565e-02f, 1.15196683e-01f, 7.22147599e-02f, 1.66420773e-01f, 1.03260636e-01f, 2.10366268e-02f, -3.59648280e-02f,
  9.74553600e-02f, 2.88609471e-02f, 1.47664204e-01f, -8.66228417e-02f, -1.15080632e-01f, 1.35829583e-01f, 4.78195511e-02f, -1.36576682e-01f, 2.30220724e-02f, 1.07710421e-01f,
  -5.04615949e-03f, -9.78163406e-02f, 2.27306083e-01f, 1.73621252e-01f, -1.84983984e-01f, -4.19454351e-02f, -6.32674396e-02f, -3.80971313e-01f, -2.92816758e-01f, 3.05333380e-02f,
  -1.31945387e-01f, -6.88974336e-02f, 4.59023528e-02f, 1.57589257e-01f, 9.88283008e-02f, 6.31424338e-02f, -7.77170956e-02f, 1.82776883e-01f, -1.70202293e-02f, 8.34311265e-03f,
  4.38335389e-02f, -1.06998377e-01f, 4.20054235e-02f, 4.10219990e-02f, 2.22285107e-01f, -7.02844337e-02f, 1.64534599e-01f, -1.13235421e-01f, 3.25225383e-01f, 1.36188269e-01f,
  4.58994061e-02f, 1.89148754e-01f, -1.96670666e-01f, 9.52520669e-02f, -1.47576094e-01f, -1.06560729e-01f, 9.73463207e-02f, 2.21053869e-01f, 7.62450248e-02f, -1.05268382e-01f,
  1.31628038e-02f, -6.82341261e-03f, -1.03991449e-01f, 1.36787770e-02f, -7.01571926e-02f, 8.31374675e-02f, 6.63004350e-03f, -3.22841816e-02f, -3.37187909e-02f, 2.57186666e-02f,
  -5.81157357e-02f, -1.45252675e-01f, -1.05223186e-01f, 1.69153158e-02f, 1.17586413e-02f, 8.05561838e-04f, -2.53130138e-01f, 3.64453942e-02f, 1.70299530e-01f, 2.51476727e-02f,
  -4.91797598e-03f, 2.09275484e-01f, 4.58070785e-02f, -6.99520409e-02f, 1.78809717e-01f, -2.01158356e-02f, 1.06126070e-01f, 1.56102702e-01f, -1.00534171e-01f, -2.10549206e-01f,
  -1.28174379e-01f, 8.20412189e-02f, 3.35600346e-01f, -1.83737949e-01f, -1.13195896e-01f, -2.75298119e-01f, 1.77512571e-01f, 2.74464935e-01f, -9.17565450e-02f, -9.88887474e-02f,
  2.07777768e-02f, 3.98004577e-02f, -1.81184411e-02f, 1.74047530e-01f, 2.29102135e-01f, -1.66982383e-01f, -7.92040080e-02f, 2.60372490e-01f, 1.60111293e-01f, -1.31522208e-01f,
  -2.77994633e-01f, -1.34428740e-01f, 8.50566626e-02f, -1.59634158e-01f, 1.51853874e-01f, 3.55788181e-03f, 1.60695165e-01f, -1.81552291e-01f, 2.22752139e-01f, 5.82024269e-03f,
  -3.16478647e-02f, 2.93728020e-02f, 1.60378143e-01f, 1.05514906e-01f, 1.32155523e-01f, 1.50505617e-01f, -8.24646279e-02f, 3.15458849e-02f, 1.89873740e-01f, 1.03166783e-02f,
  4.03802358e-02f, 9.25588608e-03f, 1.46651536e-01f, 1.92289501e-01f, 1.01197317e-01f, 1.70257613e-01f, 8.17673504e-02f, 1.25583827e-01f, 7.89092034e-02f, 7.98314288e-02f,
  3.50939296e-02f, 7.24890158e-02f, 2.21440226e-01f, 1.38156608e-01f, -7.04563782e-02f, 5.63037544e-02f, 5.50345033e-02f, -1.49268070e-02f, -7.40117431e-02f, 1.22725531e-01f,
  -4.02013101e-02f, 1.43669218e-01f, -5.57304882e-02f, -5.89227639e-02f, -1.77410394e-01f, 1.74737155e-01f, -1.50141060e-01f, -1.95305660e-01f, 1.06767468e-01f, 1.09810673e-01f,
  -3.84687353e-03f, 5.77776320e-03f, 6.21694289e-02f, 2.57203549e-01f, 5.10431565e-02f, -1.26490965e-01f, 9.96277183e-02f, 2.31121421e-01f, 5.79162724e-02f, 1.54509498e-02f,
  -1.49989817e-02f, 3.42366174e-02f, 2.65087664e-01f, -2.52964720e-02f, 3.19076538e-01f, 1.78483829e-01f, -1.25727221e-01f, 9.94916633e-02f, 3.18764210e-01f, -9.66076404e-02f,
  -8.56432691e-02f, 2.16261968e-01f, 2.17091903e-01f, 2.60774404e-01f, 1.99817672e-01f, -2.00978771e-01f, 2.98314467e-02f, 5.07986844e-02f, -1.14428304e-01f, -3.94922644e-02f,
  8.23400617e-02f, -7.00124279e-02f, -5.62090892e-04f, -1.21280469e-01f, -7.48042315e-02f, -9.75804850e-02f, -4.46778648e-02f, -1.27046565e-02f, -5.93373701e-02f, -2.18424853e-02f,
  -5.86109534e-02f, 4.91594058e-03f, -5.54852970e-02f, -9.10838228e-03f, 1.36406869e-02f, 1.19360775e-01f, 1.99840575e-01f, 2.21876781e-02f, -1.27520412e-01f, 6.91954494e-02f,
  -4.98011112e-02f, -2.59318221e-02f, -2.19349980e-01f, 1.82636827e-01f, -3.91144603e-01f, -1.21414602e-01f, 1.49067536e-01f, 2.05030754e-01f, 8.89733508e-02f, 4.25713867e-01f,
  1.41924933e-01f, -5.68622760e-02f, 1.02220707e-01f, 7.84042999e-02f, -3.06289550e-02f, -1.51957795e-01f, 2.88439959e-01f, -5.26421256e-02f, 1.62065923e-01f, 3.44500579e-02f,
  6.60549700e-02f, 1.71524230e-02f, 4.91253212e-02f, 2.79322237e-01f, 6.51270673e-02f, 1.52370751e-01f, -5.98385148e-02f, 6.05983622e-02f, 9.61932763e-02f, 2.61330664e-01f,
  -2.05217168e-01f, 5.27749471e-02f, 5.62019162e-02f, -8.10432956e-02f, 1.33105159e-01f, -1.22601494e-01f, 4.17375900e-02f, 8.53812099e-02f, 1.21251829e-01f, -8.37252140e-02f,
  1.59801226e-02f, 9.76906866e-02f, -1.65203046e-02f, 3.19092683e-02f, 5.38715683e-02f, -1.50442962e-03f, -1.65393949e-01f, -3.62933539e-02f, 8.45130626e-03f, -3.60757448e-02f,
  -1.93758160e-02f, -1.43731669e-01f, 3.67438607e-02f, -8.91787410e-02f, 2.11325176e-02f, -3.70101444e-02f, 5.67028746e-02f, -9.11388472e-02f, 5.08049801e-02f, -7.29226395e-02f,
  -1.30246088e-01f, -1.17026782e-02f, 1.18439682e-02f, -9.58652571e-02f, 4.14452254e-04f, -3.61011811e-02f, -7.96562284e-02f, -5.54592274e-02f, -7.75922686e-02f, -6.39791340e-02f,
  1.06460720e-01f, 1.34256288e-01f, 1.89836193e-02f, 3.45336087e-02f, 2.45503157e-01f, 1.33223072e-01f, -3.98325399e-02f, -9.32428911e-02f, 1.95805162e-01f, -2.22387491e-03f,
  2.13686466e-01f, -2.01744184e-01f, 1.57271922e-02f, 2.16052011e-01f, 2.97479276e-02f, -1.02919564e-01f, 2.61929166e-02f, 1.09641820e-01f, 8.34746808e-02f, -3.64198051e-02f,
  -1.60321474e-01f, 8.11127946e-02f, -4.09696251e-02f, 8.68468825e-03f, 5.35647497e-02f, 1.04701780e-01f, -9.52198580e-02f, 9.40019935e-02f, 2.51227200e-01f, -2.36592308e-01f,
  -1.48789585e-02f, -6.24214895e-02f, 6.13698065e-02f, 1.83124036e-01f, -9.67837349e-02f, 2.42065010e-03f, 6.52050450e-02f, -3.19024473e-02f, 3.25992075e-03f, -3.66699323e-02f,
  -7.20382184e-02f, -3.52461338e-02f, -8.18372238e-03f, -2.63473410e-02f, -3.11972629e-02f, -4.06120176e-04f, 7.28737563e-02f, -4.28834856e-02f, 7.27390870e-02f, -2.96536274e-02f,
  -7.49263763e-02f, -2.72096414e-03f, 4.38109040e-02f, -7.64999837e-02f, -2.80064680e-02f, 5.76597899e-02f, 1.16084041e-02f, -4.25606817e-02f, 9.86329764e-02f, 1.93209291e-01f,
  -8.68939534e-02f, -1.12777151e-01f, 3.66979688e-02f, 1.11059081e-02f, -1.12284839e-01f, -7.58675560e-02f, 3.88870202e-02f, -1.24241235e-02f, -1.73931241e-01f, 1.32198870e-01f,
  -7.22975507e-02f, -1.53903961e-01f, -1.34067848e-01f, 4.21204604e-02f, 1.17290564e-01f, -2.36173719e-02f, -9.15308818e-02f, 6.68262020e-02f, 1.00392103e-03f, 2.81122010e-02f,
  1.13387138e-01f, 1.67877927e-01f, -9.49377269e-02f, 5.21917529e-02f, -4.51866575e-02f, -3.44403908e-02f, -3.68127450e-02f, -1.22852564e-01f, 1.13717161e-01f, 2.06748039e-01f,
  -4.79353592e-02f, 1.50550812e-01f, -3.83988991e-02f, -1.45848161e-02f, 1.66457351e-02f, -9.40271094e-02f, 2.13477507e-01f, 1.61576927e-01f, 5.23215123e-02f, 6.03832789e-02f,
  5.53011484e-02f, 1.69561449e-02f, 8.85909249e-04f, 5.79892769e-02f, 4.43537049e-02f, -6.13137819e-02f, -3.95192839e-02f, -8.26196596e-02f, 4.10510860e-02f, -1.17107993e-02f,
  -7.43744615e-03f, 1.63782213e-03f, -6.38450831e-02f, -7.61367604e-02f, -9.63897333e-02f, 2.14929413e-02f, -1.57406881e-01f, 6.61703423e-02f, 2.46579796e-01f, -6.13406971e-02f,
  -2.29031652e-01f, 1.12037763e-01f, 4.98332363e-03f, -5.97608462e-02f, 3.59513015e-02f, 9.75686461e-02f, -1.60347193e-01f, 9.63366255e-02f, -3.04430220e-02f, -1.06001683e-01f,
  -1.31556019e-01f, 2.52942264e-01f, 1.36692569e-01f, -1.11559734e-01f, 9.14209187e-02f, -1.01878434e-01f, 6.34997934e-02f, 2.35158011e-01f, 1.07304275e-01f, -5.99328242e-02f,
  1.57448843e-01f, -1.89797565e-01f, -7.66653568e-03f, 2.91284561e-01f, 3.34689081e-01f, -6.59189597e-02f, -7.99287930e-02f, 1.80164158e-01f, 2.26986006e-01f, 2.78908312e-02f,
  2.44955234e-02f, 4.38500158e-02f, -1.06844939e-01f, 4.14704569e-02f, 2.18075007e-01f, -3.63346152e-02f, 2.09286541e-01f, -1.77850500e-01f, 3.29720497e-01f, 1.54182851e-01f,
  1.45842120e-01f, -3.76628973e-02f, -5.94614856e-02f, 2.65029240e-02f, -5.79034910e-02f, -6.95212185e-02f, 1.14627620e-02f, -4.76298016e-03f, -9.65902731e-02f, -3.77850756e-02f,
  -4.69877124e-02f, 1.23008974e-02f, 3.02947462e-02f, -1.60366617e-04f, 5.94272185e-03f, -4.80688028e-02f, -5.73743088e-03f, 7.73311406e-02f, -4.85913381e-02f, -3.88777927e-02f,
  2.84481272e-02f, 3.10783216e-04f, 1.08844332e-01f, 9.14946292e-03f, 4.60680351e-02f, 9.78671536e-02f, 9.22958106e-02f, 1.47486284e-01f, -9.81705412e-02f, -5.25737740e-03f,
  -1.63742021e-01f, -1.36185408e-01f, 9.16485488e-02f, 6.36862963e-02f, 1.41707365e-03f, 2.70336568e-01f, 1.54251218e-01f, 4.92159510e-03f, -4.34246063e-02f, -1.46403715e-01f,
  2.17898786e-02f, 1.40522867e-01f, 4.78606634e-02f, -3.34919952e-02f, -1.09795080e-02f, 1.30067632e-01f, 8.68510008e-02f, 2.37764940e-02f, -5.22353128e-03f, 2.09178641e-01f,
  -1.75648034e-02f, 2.60083169e-01f, -1.23054139e-01f, 6.07706532e-02f, -1.80803612e-01f, -6.00277968e-02f, -8.02448466e-02f, -3.84236313e-02f, 9.52289440e-03f, 7.65949786e-02f,
  1.68096289e-01f, -4.90871770e-03f, 6.42801002e-02f, 7.38499090e-02f, 8.75096917e-02f, -2.77292430e-02f, -5.07615786e-03f, -2.94646658e-02f, 6.90569952e-02f, 6.75175637e-02f,
  -2.58640386e-02f, 6.22514002e-02f, -9.16612446e-02f, 3.67826782e-02f, -4.87446897e-02f, -1.43384421e-02f, -1.24825463e-02f, 4.51345667e-02f, 6.26317337e-02f, -1.15690112e-01f,
  -3.93787026e-02f, -3.63942012e-02f, -8.77911896e-02f, 1.82964914e-02f, -1.41814709e-01f, -2.65418347e-02f, 1.20156929e-01f, 1.36276782e-02f, -2.11622894e-01f, 9.54262391e-02f,
  1.68847181e-02f, -8.05455223e-02f, -8.67129862e-03f, 7.83253312e-02f, -1.03612185e-01f, 6.09462596e-02f, -2.50090118e-02f, -4.86082584e-02f, -8.95417556e-02f, 2.18261123e-01f,
  2.62956560e-01f, -2.01058034e-02f, -6.06929846e-02f, -2.64939725e-01f, 2.38017797e-01f, 2.42150307e-01f, 1.48622066e-01f, -2.20442861e-01f, 2.11905062e-01f, 4.44801450e-02f,
  -8.28859210e-02f, 1.96205288e-01f, 2.44620115e-01f, -9.66025218e-02f, -7.72925615e-02f, 8.15494433e-02f, 4.46590967e-02f, -1.04433894e-01f, -9.34319645e-02f, 2.80849505e-02f,
  -3.52638699e-02f, 2.82525662e-02f, 1.81876466e-01f, -1.47111500e-02f, 2.92823464e-01f, -2.88347095e-01f, 1.92529097e-01f, 3.38817500e-02f, -8.15819055e-02f, 7.13159516e-02f,
  7.09674582e-02f, -7.49722822e-03f, 1.15734391e-01f, 1.10482745e-01f, 3.02463342e-02f, 4.41086069e-02f, -4.96866181e-02f, 4.93422784e-02f, 5.05734794e-02f, 7.58867664e-03f,
  6.07940704e-02f, 1.00187883e-01f, 3.14821638e-02f, -6.44626468e-02f, 7.61374310e-02f, -1.09547004e-01f, -1.20886276e-03f, 6.60015047e-02f, -4.60352860e-02f, 9.41376239e-02f,
  -2.77808253e-02f, -6.04591966e-02f, -1.64065689e-01f, -2.69426759e-02f, -9.15500671e-02f, -1.86693147e-01f, 1.27885312e-01f, 7.98058882e-02f, -1.37512535e-01f, 1.09787643e-01f,
  2.84457114e-02f, 4.16635200e-02f, -1.62331149e-01f, -3.99331935e-03f, 8.82137418e-02f, -5.53862974e-02f, 1.22230560e-01f, 3.49019542e-02f, 2.44912580e-01f, 2.00262025e-01f,
  1.02501988e-01f, -1.03805540e-02f, 1.89137593e-01f, 5.67662120e-02f, -9.43293273e-02f, 1.48308992e-01f, 1.82412133e-01f, -1.54559553e-01f, 5.18892817e-02f, 5.73341511e-02f,
  1.33704796e-01f, 4.40146551e-02f, 7.45110884e-02f, 6.90856948e-02f, 8.99327844e-02f, 9.69958585e-03f, 7.09810629e-02f, -6.36981130e-02f, 2.03708485e-01f, 2.04740670e-02f,
  1.14673331e-01f, 1.50942445e-01f, -2.46985294e-02f, 7.17747910e-03f, 1.63889327e-03f, 6.72476143e-02f, 1.36618719e-01f, 1.45970836e-01f, 1.44298792e-01f, -2.53202543e-02f,
  -2.05486551e-01f, 6.41311631e-02f, 1.97178614e-03f, 1.59640871e-02f, 1.20741241e-01f, -2.98251002e-03f, 4.78873663e-02f, -2.34407764e-02f, 1.40161559e-01f, -6.31268546e-02f,
  -6.06144732e-03f, 5.44139892e-02f, 1.11559764e-01f, 5.34887724e-02f, -2.61607826e-01f, -6.25797510e-02f, -8.93624052e-02f, -1.73356593e-01f, -1.05011918e-01f, -4.06233296e-02f,
  -4.81877439e-02f, -1.61724780e-02f, -4.33249474e-02f, 1.84547920e-02f, -3.84215117e-02f, 1.40390947e-01f, -1.32310167e-01f, -2.91678339e-01f, -6.70232028e-02f, 1.31157681e-01f,
  -5.25125191e-02f, -1.14248898e-02f, 1.37575671e-01f, 1.32340536e-01f, 1.11922525e-01f, 4.40500155e-02f, 1.40341312e-01f, 1.87964424e-01f, -9.17803198e-02f, 4.82468307e-03f,
  1.38881475e-01f, -7.44433003e-03f, 2.66912971e-02f, 3.08136363e-02f, -5.21967486e-02f, 7.78204873e-02f, 1.13610871e-01f, 1.06793255e-01f, 2.23787814e-01f, 1.07057273e-01f,
  -1.90271139e-01f, 5.38234301e-02f, 1.49041459e-01f, 1.10026024e-01f, -8.33157301e-02f, -1.61606167e-02f, -1.14546768e-01f, 2.12739632e-01f, -8.95930380e-02f, 1.75958537e-02f,
  -1.01006087e-02f, -7.49362558e-02f, 4.30322401e-02f, -1.07764691e-01f, -1.07511461e-01f, -1.40185073e-01f, -5.91354556e-02f, -6.17949180e-02f, -8.03346708e-02f, -9.25440043e-02f,
  7.14431852e-02f, -8.20340365e-02f, 2.92347139e-03f, -1.07505918e-02f, -5.38612418e-02f, -7.50006437e-02f, -2.90621296e-02f, -1.41780943e-01f, -7.78200552e-02f, 6.75645424e-04f,
  3.33929015e-03f, -1.01916082e-01f, 7.06685483e-02f, 8.48567709e-02f, -9.33981240e-02f, -1.35225490e-01f, -1.34047985e-01f, 4.64506075e-02f, -2.14409623e-02f, 2.35708002e-02f,
  1.12413295e-01f, 1.28004909e-01f, -2.92871543e-03f, 2.00656727e-01f, 1.50776783e-03f, -4.88552898e-02f, 3.26445624e-02f, 1.14880297e-02f, 1.91247836e-01f, -1.67799383e-01f,
  -2.52634045e-02f, 9.22959670e-02f, 3.43860202e-02f, -4.46244217e-02f, 6.56721219e-02f, 1.46395937e-01f, -3.00994124e-02f, 6.66366443e-02f, -1.07798152e-01f, -2.14791596e-02f,
  -4.18949015e-02f, -7.48726949e-02f, 4.50923108e-02f, 2.24266633e-01f, -1.08183376e-01f, 1.65916190e-01f, 5.43331206e-02f, -2.33737990e-01f, -5.77236712e-02f, -1.26182586e-01f,
  1.72600016e-01f, 1.60939589e-01f, -1.68581232e-02f, -6.71236264e-03f, -1.45078093e-01f, -1.08099155e-01f, 6.22360557e-02f, 4.27740216e-02f, -8.87007415e-02f, -7.30154961e-02f,
  4.00191173e-02f, -8.26242287e-03f, -1.11288078e-01f, -5.77613562e-02f, -8.59565511e-02f, -7.54718157e-03f, -7.16126785e-02f, 1.02408357e-01f, 6.04778603e-02f, -5.54088056e-02f,
  4.07122485e-02f, 2.20761821e-02f, -8.22085291e-02f, 1.06440894e-01f, 2.39962965e-01f, 6.64584786e-02f, -1.82851981e-02f, -1.17382295e-01f, -1.27908900e-01f, 6.02886500e-03f,
  -1.65759940e-02f, -8.94856155e-02f, 1.45407125e-01f, 8.80048126e-02f, 1.80985302e-01f, 1.58448294e-01f, 2.71294713e-01f, -6.91561960e-03f, -1.40752956e-01f, 6.68335706e-02f,
  1.57837108e-01f, -1.18303888e-01f, 2.30431810e-01f, -8.64099562e-02f, -3.16782929e-02f, 2.44139224e-01f, 4.40165326e-02f, -9.65656340e-02f, -1.17916428e-01f, 2.48578012e-01f,
  1.29535645e-01f, 1.98149368e-01f, -1.44096464e-01f, -4.54358235e-02f, -1.22877799e-01f, 1.08343668e-01f, -1.64567064e-02f, -1.21759638e-01f, -4.92476113e-02f, -2.47036535e-02f,
  6.47733510e-02f, -1.51817426e-01f, -1.42852515e-01f, -9.68847945e-02f, -1.21908419e-01f, 1.00091860e-01f, 1.65474042e-03f, 4.58377488e-02f, 3.64260608e-03f, -5.00541031e-02f,
  -1.14879906e-02f, 4.53051645e-03f, 1.74763100e-03f, 6.36631921e-02f, -1.54722854e-02f, 4.64695990e-02f, 2.37955805e-02f, 1.14407099e-03f, 7.46963397e-02f, 3.46153155e-02f,
  1.57453101e-02f, 6.39117360e-02f, 2.09722165e-02f, -9.08018127e-02f, 7.87397567e-03f, -1.27757013e-01f, 6.00521676e-02f, 8.11496377e-02f, 1.36475056e-01f, 5.45390956e-02f,
  1.29695520e-01f, 2.72044152e-01f, 3.07747838e-03f, -1.54683515e-01f, 2.19149008e-01f, 3.63194980e-02f, -1.00613862e-01f, -1.64777160e-01f, 1.56699009e-02f, -6.55573234e-02f,
  -1.33562654e-01f, 8.12108070e-02f, -6.91283792e-02f, -2.34325215e-01f, -1.06037505e-01f, 9.76509899e-02f, -9.54102427e-02f, -3.38964462e-02f, -1.71297416e-01f, 8.29855874e-02f,
  9.06030014e-02f, -1.44287609e-02f, 3.55973057e-02f, 9.20920894e-02f, -9.00282562e-02f, 1.64324760e-01f, 2.43303999e-02f, -3.61369513e-02f, -1.16013005e-01f, -2.29287297e-01f,
  1.51629314e-01f, 1.21570982e-01f, 2.67985687e-02f, 2.24980429e-01f, -8.20896253e-02f, -8.46575666e-03f, 4.11400571e-02f, -1.22628450e-01f, 1.57654196e-01f, 1.29567042e-01f,
  1.45901009e-01f, 1.04369566e-01f, -6.34148568e-02f, 7.16753975e-02f, 1.09298952e-01f, 7.05762655e-02f, 2.04734448e-02f, 1.14650421e-01f, 7.89986104e-02f, 1.65435910e-01f,
  -1.99412499e-02f, -3.75344530e-02f, -1.37131028e-02f, 6.09143749e-02f, 1.41683266e-01f, 1.10473834e-01f, 1.80392757e-01f, 6.59631267e-02f, 1.75783500e-01f, 1.13683388e-01f,
  -9.30097476e-02f, 6.92360029e-02f, 2.18182132e-01f, 4.68457863e-02f, -8.78826603e-02f, -1.31493509e-01f, -1.59797236e-01f, 1.65069744e-01f, -8.50963444e-02f, -2.76449680e-01f,
  1.85370639e-01f, 2.44750947e-01f, 6.77031204e-02f, -6.24026987e-04f, 1.82563126e-01f, -1.51472524e-01f, -1.27616927e-01f, 1.58989161e-01f, 1.82347268e-01f, -1.00833349e-01f,
  4.11793068e-02f, 1.10036962e-01f, 1.12557277e-01f, 2.12993845e-01f, 1.89817905e-01f, 5.44489622e-02f, -1.86158210e-01f, 1.51929125e-01f, 2.04154357e-01f, 1.34944305e-01f,
  -1.38556277e-02f, 8.74884650e-02f, 4.01381636e-03f, 2.32533723e-01f, 2.88269073e-02f, -1.66143239e-01f, 4.69074175e-02f, -1.07741535e-01f, 2.87401900e-02f, 1.91342026e-01f,
  -3.19537744e-02f, 3.75357382e-02f, -1.84927642e-01f, -1.22860782e-02f, -3.43152732e-02f, -4.44021635e-03f, -7.04931244e-02f, 9.16705374e-03f, -2.81631779e-02f, -7.76953623e-03f,
  -5.31333424e-02f, 7.24680768e-03f, -7.86869004e-02f, -6.43074289e-02f, 1.61669534e-02f, -6.22608094e-03f, 7.49699995e-02f, 2.78292187e-02f, -2.81085689e-02f, 9.61752012e-02f,
  5.82256615e-02f, -8.74466598e-02f, -5.35483472e-02f, -5.92985116e-02f, 3.63783129e-02f, 1.34200126e-01f, 9.11877975e-02f, 1.05180196e-01f, 6.61773533e-02f, 7.65894577e-02f,
  -1.18660629e-01f, -6.33070469e-02f, 1.05295479e-01f, -1.56991426e-02f, 4.00724933e-02f, -9.02343355e-03f, -5.02173156e-02f, 1.20248914e-01f, 1.29751474e-01f, -1.36306118e-02f,
  -1.63378894e-01f, -2.37092480e-01f, 7.42369145e-03f, 4.40080371e-03f, 9.73923430e-02f, -1.20450132e-01f, -1.43352468e-02f, 2.01674089e-01f, 8.60020295e-02f, -4.63181809e-02f,
  -7.12686628e-02f, 1.18373923e-01f, -9.19974297e-02f, 2.36285970e-01f, -6.83865655e-05f, -8.15794319e-02f, -1.65122077e-01f, -6.43241554e-02f, 1.33685216e-01f, -6.86123744e-02f,
  3.97767462e-02f, 8.98516998e-02f, 1.17778458e-01f, -2.22397566e-01f, -6.94627613e-02f, -7.94567987e-02f, 8.59242224e-04f, 1.13952771e-01f, 9.31231678e-02f, -5.04354052e-02f,
  2.81237848e-02f, 1.32098654e-02f, 1.03745632e-01f, 3.67815010e-02f, 5.95533699e-02f, 7.79556483e-02f, 7.87400082e-02f, 1.43974289e-01f, 7.68018737e-02f, 5.98651581e-02f,
  1.28762973e-02f, 1.07245572e-01f, 5.35717122e-02f, 5.20380437e-02f, 1.27918854e-01f, 1.08202398e-01f, 1.56193525e-01f, 6.19570278e-02f, -1.99808553e-01f, -6.00514412e-02f,
  1.48665369e-01f, -6.97893053e-02f, -1.25806302e-01f, -7.94444457e-02f, 1.36176512e-01f, 4.91480194e-02f, 1.12116545e-01f, -5.87534457e-02f, 1.82567444e-02f, 9.58547965e-02f,
  5.48363721e-04f, -3.19008917e-01f, -1.84509501e-01f, 2.25242469e-02f, -2.74949912e-02f, 2.12161645e-01f, 1.00427262e-01f, -1.67655423e-02f, -8.30655098e-02f, 2.53642648e-01f,
  -7.07674995e-02f, 1.86501652e-01f, 6.34677038e-02f, 4.70820349e-03f, -1.38289347e-01f, 1.01831304e-02f, 1.41757324e-01f, -8.73596370e-02f, 9.43856835e-02f, 1.51163608e-01f,
  8.15438554e-02f, 3.37601528e-02f, 1.28131852e-01f, -3.61156948e-02f, -1.39383554e-01f, -2.29049604e-02f, -9.62521881e-02f, 3.20900053e-01f, -1.47217095e-01f, 7.03424588e-02f,
  -4.16814871e-02f, 1.47997022e-01f, -2.48560421e-02f, -4.85349186e-02f, 1.47613376e-01f, 1.24890357e-02f, -5.11365458e-02f, 6.45414926e-04f, 3.07273883e-02f, -5.10811694e-02f,
  3.30108851e-02f, -1.02878116e-01f, -4.10431102e-02f, -4.15729247e-02f, -6.86412724e-03f, -4.59242575e-02f, -3.67818139e-02f, -2.35572174e-01f, -1.06938146e-01f, 1.08599365e-01f,
  3.60530964e-03f, 2.37771682e-02f, -4.69392724e-02f, -2.09025443e-01f, -3.22953671e-01f, -2.94379383e-01f, -8.26188102e-02f, -1.02631882e-01f, 1.37153476e-01f, 2.81330589e-02f,
  -1.27596393e-01f, 2.88797498e-01f, -1.32214278e-01f, 1.04566673e-02f, 3.39187272e-02f, -8.28698371e-03f, -3.20959181e-01f, 9.44404826e-02f, 3.15379471e-01f, 2.72297233e-01f,
  -4.29507270e-02f, 7.79344663e-02f, 4.14437465e-02f, -1.93306920e-03f, 1.80157349e-02f, -1.86641678e-01f, -3.20882648e-02f, 1.83803633e-01f, 2.49449745e-01f, -4.02965695e-02f,
  -3.40951569e-02f, -1.45524845e-01f, 1.27020568e-01f, 1.24312103e-01f, 3.19778442e-01f, 4.17186432e-02f, 6.89122267e-03f, 3.16774666e-01f, 6.07344061e-02f, 1.50132515e-02f,
  4.11577225e-02f, -1.27427829e-02f, 1.63589269e-01f, 1.61856130e-01f, 2.34253094e-01f, 6.64816722e-02f, 5.97742945e-02f, -2.39264034e-02f, -8.00526217e-02f, -7.82571957e-02f,
  -9.72157158e-03f, -9.29064527e-02f, 2.08347104e-03f, -6.89358637e-03f, 1.70544554e-02f, -6.39110655e-02f, 2.48315912e-02f, -1.76825181e-01f, -4.96563986e-02f, -8.52744803e-02f,
  -1.04358651e-01f, -3.13833766e-02f, -5.83802350e-02f, -7.65796527e-02f, 4.89959903e-02f, 4.13131677e-02f, -3.28293703e-02f, -2.50169247e-01f, -1.17367454e-01f, -1.24675922e-01f,
  -4.11859937e-02f, 8.91197752e-03f, 2.83189386e-01f, 1.22301597e-02f, -4.60234769e-02f, -2.21885778e-02f, 7.68605396e-02f, 4.08690646e-02f, -8.01307708e-02f, 1.59551352e-02f,
  -8.76069069e-02f, 1.99539870e-01f, 2.01709911e-01f, 9.81559083e-02f, 5.98425269e-02f, 1.17629156e-01f, -2.36523658e-01f, -4.52867448e-02f, 6.79373965e-02f, -4.42519598e-02f,
  -6.87219054e-02f, -1.42598096e-02f, 2.33837180e-02f, -6.98668659e-02f, 1.10261953e-02f, -1.78955540e-01f, -1.19306594e-01f, 2.64925271e-01f, -8.15847591e-02f, -1.18189707e-01f,
  -1.30023450e-01f, 3.32172476e-02f, -1.11619934e-01f, -6.97713019e-03f, 1.09632485e-01f, -1.98630672e-02f, 1.89405441e-01f, 5.93724623e-02f, 9.13588926e-02f, -2.59008240e-02f,
  3.72172184e-02f, 2.89911181e-02f, 5.76790161e-02f, -5.73768727e-02f, -1.97590403e-02f, 6.02542721e-02f, 3.60580683e-02f, 5.33346273e-02f, 6.70937300e-02f, 9.60549191e-02f,
  7.77547136e-02f, 1.19601436e-01f, 1.00896895e-01f, 1.52932972e-01f, -4.98527335e-03f, 2.29425319e-02f, 1.01740316e-01f, -3.56575847e-02f, -2.49997303e-02f, -1.14709735e-01f,
  1.72472045e-01f, 1.32254541e-01f, 1.40883505e-01f, 6.90072775e-02f, 1.69546500e-01f, 2.71980673e-01f, -5.56296669e-02f, -1.18390489e-02f, 6.37149140e-02f, -3.07930671e-02f,
  -1.48275986e-01f, -1.53732151e-01f, -4.45661619e-02f, 7.26103317e-03f, -1.28518119e-01f, -9.30275321e-02f, -1.23740949e-01f, -1.58196688e-01f, -1.12620629e-01f, 4.58862893e-02f,
  2.80217435e-02f, 8.89049694e-02f, -7.19976351e-02f, 1.25374630e-01f, 2.22399056e-01f, 5.62685654e-02f, 2.85026189e-02f, 1.95444286e-01f, -7.44175538e-02f, 1.75670981e-01f,
  1.50628705e-02f, -9.74619612e-02f, 3.09258252e-02f, -5.90557717e-02f, 4.54027914e-02f, 1.11179493e-01f, 1.43931121e-01f, 1.33069009e-01f, -8.01756680e-02f, 1.23904526e-01f,
  4.60011028e-02f, 8.77913926e-03f, 2.28275046e-01f, 8.26392025e-02f, 3.52896601e-02f, 2.35817358e-02f, 1.46121224e-02f, -8.84593576e-02f, -5.27339205e-02f, 2.07779817e-02f,
  3.33936065e-02f, 7.51536414e-02f, 6.27978593e-02f, 4.53228019e-02f, 9.16031152e-02f, -2.00019609e-02f, 1.41455382e-01f, 8.95783827e-02f, -7.30563030e-02f, 6.40138686e-02f,
  7.41163641e-02f, -5.87545484e-02f, 4.17709127e-02f, -1.22984938e-01f, 7.46085346e-02f, 1.26255378e-01f, 1.92931980e-01f, 1.25845045e-01f, 1.38488308e-01f, 2.54095495e-01f,
  3.90846357e-02f, -1.82768434e-01f, 2.93122560e-01f, -1.85102746e-02f, -8.48543942e-02f, -1.78400308e-01f, -1.22599211e-02f, -1.03286296e-01f, -4.78376895e-02f, 7.60678425e-02f,
  -1.40215993e-01f, -1.68184265e-01f, -9.83511955e-02f, 7.09247366e-02f, -1.51636481e-01f, -3.78286988e-02f, -2.42208004e-01f, 2.22002432e-01f, 1.01020299e-01f, -2.24097930e-02f,
  8.88467804e-02f, 1.38135552e-01f, -7.44598135e-02f, 8.74697641e-02f, 9.22040194e-02f, -6.62112460e-02f, -1.07226260e-01f, -2.60314763e-01f, 1.50023669e-01f, 7.02646151e-02f,
  6.92283884e-02f, 2.47250691e-01f, -1.40490860e-01f, -1.20752268e-02f, 1.98237747e-02f, -1.35976732e-01f, 1.84833243e-01f, 6.20812438e-02f, 7.95401633e-02f, 2.03237068e-02f,
  -7.73891956e-02f, -2.13944782e-02f, -2.79435539e-03f, 4.27786894e-02f, 1.27478182e-01f, 1.99673586e-02f, 7.19231665e-02f, 1.30721882e-01f, 4.34811078e-02f, 9.00437534e-02f,
  -1.12005942e-01f, 7.32206404e-02f, 4.07017432e-02f, 1.19238451e-01f, 1.37991861e-01f, 1.83756389e-02f, 5.73435090e-02f, 1.65624231e-01f, 2.29230613e-01f, 1.73227713e-01f,
  2.17275023e-01f, 2.23052844e-01f, 5.34404628e-02f, 9.02830344e-03f, -6.69509023e-02f, 2.16761559e-01f, -3.57256159e-02f, -2.19172552e-01f, 1.23131543e-01f, -9.85162053e-03f,
  3.24936323e-02f, 2.24702999e-01f, 1.70688070e-02f, -2.27132797e-01f, -1.34175494e-01f, -2.86608748e-02f, -1.18612424e-01f, 7.48009831e-02f, -9.71682519e-02f, 2.43096501e-01f,
  -6.93417192e-02f, 4.69326191e-02f, 2.07564697e-01f, 1.28393218e-01f, -4.00265008e-02f, 2.58302987e-01f, 4.53898832e-02f, 2.51273066e-01f, 3.10724955e-02f, -1.79488342e-02f,
  -1.03989318e-01f, 8.52983072e-02f, -1.60293832e-01f, -1.12714455e-01f, 1.09529108e-01f, -1.08434945e-01f, -6.94962442e-02f, 2.30866104e-01f, 1.89672053e-01f, 9.72810015e-02f,
  5.98091148e-02f, -1.58983499e-01f, -1.98987257e-02f, 1.40786350e-01f, 5.24792410e-02f, 2.34419759e-02f, 1.50128037e-01f, 3.92327867e-02f, -3.84898088e-03f, -9.48879346e-02f,
  -1.14290034e-02f, -1.27354572e-02f, 1.28749730e-02f, 3.36916596e-02f, 4.48719151e-02f, 9.29695740e-02f, 2.14599624e-01f, -5.35304025e-02f, 6.71844184e-02f, 4.50325198e-02f,
  1.58916920e-01f, 7.02729896e-02f, -4.81273197e-02f, 3.17071676e-02f, -6.18610159e-02f, -8.40919092e-02f, -8.79275426e-02f, -3.39650624e-02f, -3.20587635e-01f, 1.64484859e-01f,
  -2.45687142e-01f, -8.05641562e-02f, 1.09699897e-01f, 2.69839495e-01f, -8.20924435e-03f, 1.21737555e-01f, -6.50867820e-02f, -8.09699669e-02f, 1.78136006e-02f, 1.40552670e-01f,
  1.70830451e-02f, -2.21884072e-01f, 3.54985267e-01f, 1.19599544e-01f, 1.82904378e-01f, 5.47987893e-02f, 2.65473519e-02f, -3.85339931e-02f, -1.86789327e-03f, 1.13994464e-01f,
  6.44813478e-02f, 5.17931506e-02f, 1.86185539e-02f, 4.40447871e-03f, 3.22542757e-01f, 2.62078106e-01f, 2.27116011e-02f, 9.23726335e-02f, -2.30724066e-02f, -1.10554546e-01f,
  1.58942696e-02f, 3.85964401e-02f, -1.18902788e-01f, 4.87220287e-02f, 3.76375131e-02f, 2.00035945e-02f, -5.11478446e-03f, 2.70229708e-02f, 2.29862682e-03f, 1.80312470e-02f,
  -8.59721750e-03f, 9.11682006e-03f, -5.92050962e-02f, 3.00435070e-02f, 2.65868343e-02f, 1.81129985e-02f, 9.77370963e-02f, 2.94119455e-02f, 1.63759347e-02f, -3.75974625e-02f,
  4.61101867e-02f, 2.95806453e-02f, 1.26503715e-02f, -1.05539933e-02f, 4.08655107e-02f, 1.19568380e-02f, -2.80915275e-02f, -6.51026815e-02f, 4.27335920e-03f, -1.56405866e-02f,
  2.60069519e-02f, 9.49644297e-02f, 8.23107511e-02f, -1.15612164e-01f, 1.11642711e-01f, 1.40074193e-02f, -8.21726993e-02f, -2.67482139e-02f, -1.11956649e-01f, -1.55888841e-01f,
  -9.42510813e-02f, 1.01910546e-01f, -8.67238734e-04f, -1.50471896e-01f, -7.49511586e-04f, 2.84053952e-01f, -2.47886796e-02f, 5.63866384e-02f, -6.81198090e-02f, 1.84825867e-01f,
  6.59881309e-02f, 9.72486008e-03f, 5.72358556e-02f, -5.56963831e-02f, -2.90264911e-03f, 1.18818015e-01f, -1.28135402e-02f, 6.88947439e-02f, -9.31458771e-02f, -1.74385294e-01f,
  1.86925605e-01f, 5.10916188e-02f, -1.88553613e-02f, 1.96279556e-01f, 6.63257837e-02f, 6.90704733e-02f, 2.07457542e-02f, -6.46461779e-03f, 9.05371085e-02f, 1.55153707e-01f,
  2.64584813e-02f, -3.72216702e-02f, -4.80794534e-02f, -2.86126435e-02f, 5.23407422e-02f, -2.35648081e-02f, -1.23383090e-01f, -2.75504645e-02f, 5.42720258e-02f, -1.00185446e-01f,
  -8.84545073e-02f, -1.90111116e-01f, -2.85535827e-02f, -8.31639469e-02f, -1.15929164e-01f, -6.10659905e-02f, -1.50769223e-02f, -4.38564532e-02f, 2.07726695e-02f, -6.53072298e-02f,
  -2.11204737e-01f, -1.11105412e-01f, -3.31122428e-02f, -1.29680783e-01f, -5.81992716e-02f, -1.47445738e-01f, 9.09460783e-02f, -1.17803857e-01f, -2.71837171e-02f, 5.28258607e-02f,
  4.27048691e-02f, 2.02583391e-02f, 6.34783432e-02f, -1.01311086e-02f, 1.70375824e-01f, 2.40152016e-01f, 5.63422479e-02f, 2.79561616e-02f, 2.81814009e-01f, 1.58109069e-01f,
  6.66552708e-02f, -2.27722839e-01f, 6.93495944e-02f, 2.73099333e-01f, -1.46028046e-02f, -7.63155892e-02f, 1.26961783e-01f, 9.92537513e-02f, 1.50601313e-01f, 1.06650637e-03f,
  -1.16768800e-01f, 2.10281894e-01f, -1.03332922e-01f, -8.82344693e-02f, 1.31511778e-01f, 1.04309335e-01f, -1.27849534e-01f, 1.28684670e-01f, 3.11565280e-01f, -2.25132689e-01f,
  4.14421670e-02f, -5.47738671e-02f, 8.51818770e-02f, 3.09078187e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.60964597e-03f, 1.36831943e-02f, -1.33277476e-02f, 1.54573331e-02f, 6.95875362e-02f, 6.49766549e-02f, 1.93645097e-02f, 2.89473473e-03f, 3.99071611e-02f, 5.06099872e-02f,
  3.46698053e-02f, 3.36054899e-02f, 2.71569062e-02f, -4.91762720e-02f, 2.67197937e-02f, 1.36894276e-02f, -6.85720704e-03f, 5.83700575e-02f, 2.65498180e-03f, 1.58705562e-02f,
  2.83914339e-02f, 2.69292034e-02f, 1.14741609e-01f, 4.01488170e-02f, 7.50533342e-02f, 4.21667285e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -3.26430909e-02f, -1.23602953e-02f, 1.35046199e-01f, -5.32425717e-02f, -6.55407682e-02f, 9.23069343e-02f, -8.00609868e-03f, 1.52932689e-01f, -1.04754388e-01f, -4.25198348e-03f,
  -5.17657921e-02f, -8.05175900e-02f, -5.38985594e-04f, -2.19388213e-02f, -4.54269573e-02f, 8.96241739e-02f, 9.81408078e-03f, 1.29450470e-01f, 5.09670377e-02f, 2.90786289e-02f,
  1.98681161e-01f, 1.12393778e-03f, -1.28604054e-01f, -2.26522014e-02f, 5.95918186e-02f, -1.48364380e-01f, 2.71327365e-02f, 1.94707662e-01f, -4.76908833e-02f, -8.61607864e-02f,
  3.22758108e-02f, -1.93403721e-01f, 9.34996605e-02f, 5.50183579e-02f, -1.10607855e-02f, -2.24222720e-01f, -8.16640109e-02f, 1.00239992e-01f, -5.74556552e-02f, -1.32682949e-01f,
  -1.14185929e-01f, 8.02439749e-02f, 4.39338200e-02f, -4.82992046e-02f, -1.79519966e-01f, -1.09523602e-01f, -1.28849030e-01f, -1.61339685e-01f, 1.03211276e-01f, 9.15349424e-02f,
  -1.28974587e-01f, 9.03094783e-02f, -1.56189442e-01f, 1.03439003e-01f, -1.67621374e-01f, 1.08137943e-01f, -3.28702070e-02f, 5.83722517e-02f, -1.39730364e-01f, -1.96107253e-01f,
  1.32903960e-02f, -2.36526560e-02f, -1.29755452e-01f, -5.03585711e-02f, -5.05813323e-02f, 4.17867750e-02f, -9.74310469e-03f, -3.22677158e-02f, 1.31769944e-02f, -9.60010812e-02f,
  7.21766651e-02f, -4.97120321e-02f, -6.89820852e-03f, 6.01104088e-02f, -8.53521377e-02f, -3.71101983e-02f, -3.69956531e-02f, 4.72416244e-02f, 3.53049934e-02f, -4.05320600e-02f,
  4.50064316e-02f, 1.23707913e-01f, 2.63147913e-02f, 5.35847470e-02f, -3.83617803e-02f, 1.11035421e-01f, 3.51905674e-02f, -1.20913625e-01f, -7.72301406e-02f, 5.88501766e-02f,
  3.54576483e-02f, 5.89365140e-02f, -8.01684409e-02f, 2.22231746e-02f, 1.26276210e-01f, -5.50994277e-02f, -1.31981447e-01f, -9.45792496e-02f, 8.44155475e-02f, -1.73251018e-01f,
  9.02348533e-02f, 8.66424292e-02f, 5.35575394e-03f, -2.17433378e-01f, -3.80112268e-02f, 1.28471404e-01f, 3.34805027e-02f, -7.41345659e-02f, -8.31046104e-02f, 1.58631679e-04f,
  -1.68939326e-02f, -1.90348085e-02f, 1.16454624e-01f, -1.25270784e-01f, -6.76190555e-02f, -9.38612074e-02f, -1.70427963e-01f, -7.31289834e-02f, -1.46416962e-01f, -1.79415159e-02f,
  1.46900997e-01f, 1.52661487e-01f, -8.23903829e-02f, -8.04895386e-02f, 1.60492808e-02f, -3.50040048e-02f, -3.28687504e-02f, -3.19373421e-02f, 1.00103822e-02f, -8.89550447e-02f,
  1.98647790e-02f, 1.21319788e-02f, 7.42726400e-02f, 1.03578465e-02f, 1.45304268e-02f, 4.51712869e-02f, -6.90678954e-02f, 3.83412242e-02f, 9.38679744e-03f, -2.82368008e-02f,
  1.41366990e-02f, -2.41346732e-02f, 7.82721266e-02f, 1.17163385e-04f, 6.11950783e-03f, 1.07628256e-01f, -7.62534738e-02f, -6.47396408e-03f, 1.42751206e-02f, 6.09550450e-04f,
  -7.35082850e-02f, -3.38060297e-02f, -3.18921916e-02f, 7.40684047e-02f, -3.03049386e-02f, 1.50589913e-01f, -9.11887661e-02f, 2.88081728e-02f, 5.61932661e-02f, -1.37519285e-01f,
  6.54685311e-04f, 2.33423728e-02f, -5.95702268e-02f, -1.31571278e-01f, -6.60871621e-04f, 3.26776579e-02f, -1.24044187e-01f, -3.96978594e-02f, -1.68803468e-01f, 1.01279877e-01f,
  9.46124122e-02f, 9.70777050e-02f, -1.48376644e-01f, -4.32363190e-02f, -1.13631196e-01f, -1.82380915e-01f, -1.05062462e-01f, -2.28394847e-02f, -3.12855020e-02f, 2.71026716e-02f,
  -9.69421864e-02f, 2.00111717e-01f, -1.18199222e-01f, 1.35558635e-01f, 2.48276722e-03f, 7.86864012e-02f, -3.50907110e-02f, 1.36645632e-02f, -4.00809012e-03f, 9.65782180e-02f,
  -6.31946176e-02f, -6.59888517e-03f, 2.40202906e-04f, 2.54185162e-02f, -6.16139499e-03f, 4.19279076e-02f, -8.58143643e-02f, -4.86560911e-02f, -4.92632575e-02f, 7.24443495e-02f,
  3.31571549e-02f, 1.04202501e-01f, 5.97871374e-03f, -1.36663169e-02f, 4.47019599e-02f, -2.74493434e-02f, 7.59101659e-02f, 5.40464036e-02f, -1.63499694e-02f, 1.08575284e-01f,
  7.36751109e-02f, 2.21701190e-02f, 1.68883339e-01f, 6.00943994e-03f, -2.18625702e-02f, 9.40101147e-02f, 1.32861212e-01f, -3.31090279e-02f, -2.14435551e-02f, 1.25975534e-01f,
  -1.00524530e-01f, 1.03586745e-02f, -4.30997610e-02f, -1.49317697e-01f, 1.59917608e-01f, 1.28622707e-02f, -8.16095024e-02f, 8.59947540e-05f, -6.06679060e-02f, 4.60054316e-02f,
  -4.69448481e-04f, -4.60929461e-02f, 3.65677960e-02f, -3.76274511e-02f, -5.10239564e-02f, 1.11863226e-01f, -9.13204625e-02f, -1.26109108e-01f, 5.04221022e-02f, 1.13327205e-02f,
  -2.40366455e-04f, 1.12119429e-01f, -9.64240059e-02f, 1.14621684e-01f, -6.69935271e-02f, 1.63444027e-01f, 2.03555934e-02f, 6.49556518e-02f, -1.51632950e-01f, 4.26048115e-02f,
  1.84322409e-02f, -6.65830746e-02f, 5.03695831e-02f, 8.38032961e-02f, 3.74118909e-02f, 8.04176554e-02f, -2.74991291e-03f, 2.48047188e-02f, -1.09296180e-02f, 3.69341439e-03f,
  -3.24962810e-02f, 4.59674820e-02f, -5.34934439e-02f, -2.32200641e-02f, -7.74092078e-02f, 2.13508625e-02f, 5.02335057e-02f, -2.45325477e-03f, -4.68503032e-03f, 7.06958491e-03f,
  8.94512013e-02f, 9.50099602e-02f, 4.55653109e-02f, 9.11761597e-02f, -2.48050690e-02f, -1.59392551e-01f, 2.18122154e-02f, 6.64443523e-03f, -3.01052108e-02f, -3.90076488e-02f,
  -1.12611696e-01f, 7.63210580e-02f, -4.62232269e-02f, 1.70391411e-01f, -5.44079468e-02f, -7.23520517e-02f, 1.24724165e-01f, -6.91509694e-02f, 3.74350883e-02f, 1.70780206e-03f,
  2.21933238e-03f, 5.49730361e-02f, 1.06094666e-02f, 1.94486585e-02f, -8.27618018e-02f, -3.62001546e-02f, -1.00811183e-01f, -8.93631652e-02f, -6.15568608e-02f, -1.59418937e-02f,
  5.45207709e-02f, -1.25411049e-01f, 9.95344371e-02f, -2.29236901e-01f, -1.09808736e-01f, 1.00080520e-01f, 4.37035924e-03f, 7.96112511e-03f, 6.08054101e-02f, 1.69489995e-01f,
  -5.01499251e-02f, 9.52427685e-02f, -6.76181167e-02f, 8.36385116e-02f, -2.58994605e-02f, -2.12937985e-02f, -2.28713341e-02f, 9.98764634e-02f, 6.13082051e-02f, 3.76679339e-02f,
  -1.33087412e-01f, -5.07560559e-02f, -6.40954673e-02f, -9.40334871e-02f, -1.52038112e-01f, -1.44323958e-02f, -9.16707423e-03f, 6.94649899e-03f, -1.15150355e-01f, -7.45599791e-02f,
  -9.22789648e-02f, -5.69829606e-02f, -3.35510075e-02f, -8.63681957e-02f, -4.58102636e-02f, -1.07967958e-01f, -4.69765365e-02f, -1.22636678e-02f, -3.97932753e-02f, -1.00327209e-01f,
  -8.04167390e-02f, 1.65977620e-03f, 4.88220081e-02f, 1.78605672e-02f, 2.58859321e-02f, 1.01233520e-01f, 1.22244917e-01f, -1.10389404e-01f, 5.67687191e-02f, 6.96126074e-02f,
  -1.39978215e-01f, -3.84448133e-02f, -4.86934707e-02f, -1.41513333e-01f, -3.10232043e-02f, 9.40326378e-02f, 2.09996384e-02f, 1.12767227e-01f, -5.77355959e-02f, 5.08502796e-02f,
  -1.80563778e-02f, -1.41463295e-01f, -1.02562100e-01f, -6.55617267e-02f, -9.08880308e-02f, -1.73387572e-01f, -8.06871727e-02f, -1.89917833e-01f, -1.98859558e-01f, -2.32202679e-01f,
  -1.28728449e-01f, 7.04706833e-02f, 5.54880053e-02f, 4.19952907e-02f, 4.81375828e-02f, -9.55616608e-02f, -1.15600131e-01f, -6.01083077e-02f, -1.81982163e-02f, 2.85534561e-02f,
  -5.21362163e-02f, -8.35301280e-02f, -1.62270144e-01f, -4.68849987e-02f, -5.47134206e-02f, 2.28798352e-02f, -1.48443859e-02f, -1.01322435e-01f, -8.21718574e-02f, 4.27436419e-02f,
  -1.64218888e-01f, -1.70602370e-02f, -7.68259168e-03f, -1.25046834e-01f, -4.61859778e-02f, -7.36453198e-03f, -5.82637340e-02f, 6.37767762e-02f, 3.95241790e-02f, 4.82205451e-02f,
  -1.24486461e-01f, -1.49801448e-01f, 5.35962395e-02f, -1.49068177e-01f, -1.28993019e-01f, 3.14259008e-02f, 4.16158438e-02f, 8.95973668e-02f, -1.22813903e-01f, 6.23130165e-02f,
  5.67735359e-03f, -1.32758901e-01f, 1.31683305e-01f, 1.61685064e-01f, 1.76575072e-02f, 7.71475136e-02f, -8.96465778e-02f, -6.21748045e-02f, -1.10956080e-01f, 9.97397527e-02f,
  2.57499814e-02f, 3.14199068e-02f, -2.97347587e-02f, -7.43075758e-02f, 2.08193786e-03f, 7.05717355e-02f, 1.40414536e-01f, 5.31368889e-02f, 4.29525487e-02f, -1.05606981e-01f,
  1.13326788e-01f, -9.40651223e-02f, -1.66304454e-01f, -5.27353287e-02f, 5.01780249e-02f, 6.59874305e-02f, 5.77689894e-03f, -8.41169879e-02f, 9.19722207e-03f, -6.07926445e-03f,
  -9.79448333e-02f, -8.31399933e-02f, 1.64347254e-02f, -9.60987061e-02f, 1.46792427e-01f, 1.60429180e-02f, -2.95105483e-02f, -4.36434001e-02f, -1.32233538e-02f, -9.26232636e-02f,
  2.67388672e-02f, 6.12719022e-02f, 2.02112384e-02f, -3.55867408e-02f, 7.92225357e-03f, 5.14778979e-02f, 1.14493012e-01f, 8.19907933e-02f, 1.06282890e-01f, -1.88650824e-02f,
  -4.47122492e-02f, -7.74801150e-02f, 5.34519227e-03f, 3.85494381e-02f, -6.41553253e-02f, 1.92457840e-01f, 8.48084281e-04f, 1.07233003e-01f, 1.65262416e-01f, -2.54145265e-02f,
  4.08368036e-02f, -1.61450915e-02f, 1.58155173e-01f, -7.92590082e-02f, 2.39776354e-02f, 2.69119069e-02f, -8.71347636e-02f, -3.06268930e-02f, 5.30606806e-02f, -1.52901486e-01f,
  1.51437208e-01f, -1.63194872e-02f, 1.04288764e-01f, -2.04973444e-01f, -5.31138368e-02f, 5.59055991e-02f, -7.51223639e-02f, 4.82073314e-02f, -1.60835162e-01f, -4.21768352e-02f,
  1.06602283e-02f, 7.89881349e-02f, -1.24807499e-01f, -7.17195123e-02f, 1.03065697e-02f, -2.47505512e-02f, 7.86303952e-02f, 1.40786693e-01f, -7.30607659e-02f, -1.76508520e-02f,
  -1.57474235e-01f, -1.27549004e-02f, -1.11569427e-01f, 1.29054755e-01f, -4.22592880e-03f, 6.34682849e-02f, -1.38161063e-01f, -1.15733653e-01f, -1.45090923e-01f, 5.16110053e-03f,
  2.97766598e-03f, 5.28365113e-02f, 6.54044822e-02f, 7.92371184e-02f, 2.50556953e-02f, -6.94371434e-03f, -4.87414114e-02f, 5.90850487e-02f, 1.99228153e-02f, 3.74283120e-02f,
  1.20400243e-01f, 6.07118346e-02f, 1.18015364e-01f, 1.28595218e-01f, 3.87551486e-02f, 7.17507452e-02f, 1.11890055e-01f, 1.93561867e-01f, 2.89399107e-03f, 1.69404849e-01f,
  1.03370540e-01f, -9.64243934e-02f, 2.07905285e-02f, 8.81861299e-02f, 5.39553016e-02f, 3.23518179e-02f, -6.22221604e-02f, 1.36271223e-01f, -5.85393310e-02f, -4.79611270e-02f,
  -3.77039872e-02f, 8.87832642e-02f, 7.28242099e-02f, 5.31291179e-02f, 2.24853922e-02f, -1.14346132e-01f, 1.24535197e-02f, -5.84019423e-02f, 6.79059848e-02f, 3.84621806e-02f,
  -5.23749813e-02f, -1.80458039e-01f, -8.90163183e-02f, -5.41544780e-02f, 2.24749565e-01f, 1.33612871e-01f, 4.41815630e-02f, 3.80940400e-02f, 1.67216048e-01f, -5.80137968e-02f,
  -5.36182430e-03f, 1.02442034e-01f, 9.17701274e-02f, 4.72764000e-02f, -3.61678600e-02f, 9.12969857e-02f, 3.53021780e-03f, -4.55765501e-02f, -7.35391676e-02f, 4.26927060e-02f,
  4.47067060e-02f, -1.66453905e-02f, 3.32177820e-04f, 1.72191113e-01f, -1.73569806e-02f, 1.28785726e-02f, -4.51925695e-02f, -9.16133262e-03f, -1.01626828e-01f, -5.67077659e-02f,
  6.14384115e-02f, 8.03224668e-02f, -3.25533710e-02f, -3.28010581e-02f, -1.32328242e-01f, -5.29972948e-02f, 5.71933091e-02f, -3.57511714e-02f, -1.12505658e-02f, 6.00424632e-02f,
  6.30888119e-02f, -1.54693378e-02f, 1.94442011e-02f, -3.43317427e-02f, 5.93853742e-03f, -9.10138413e-02f, 9.08553079e-02f, -1.28816754e-01f, 1.86242089e-02f, -7.64754340e-02f,
  2.66149566e-02f, 6.16528187e-03f, 4.57319170e-02f, 1.91835478e-01f, 1.97296422e-02f, -9.88479406e-02f, 1.63556978e-01f, -9.96375903e-02f, 1.54692801e-02f, -2.61790901e-02f,
  -1.60493404e-02f, 1.89384744e-01f, 4.28329781e-02f, -2.57816836e-02f, -5.96506968e-02f, 5.65548390e-02f, -1.08630806e-01f, -1.75205871e-01f, -5.00048511e-02f, 1.67095214e-01f,
  1.00715242e-01f, -1.02727957e-01f, 5.69868572e-02f, -1.98173568e-01f, -3.66418809e-02f, -2.13315096e-02f, 2.84050480e-02f, -9.89952008e-04f, 5.34621142e-02f, 1.56681687e-01f,
  2.34100875e-02f, 1.21633790e-01f, 2.84889317e-03f, 1.35807738e-01f, 8.52439553e-02f, 6.64122179e-02f, 3.14107095e-03f, -1.39374696e-02f, -2.49716043e-02f, 9.16004106e-02f,
  5.43243028e-02f, 1.64849192e-01f, 1.86814703e-02f, 8.24155137e-02f, 8.88756812e-02f, 1.02305897e-01f, 4.45949696e-02f, -4.52272361e-03f, -2.32436471e-02f, 4.58371267e-02f,
  1.11609064e-01f, 3.51921767e-02f, 1.59576014e-01f, 8.07099715e-02f, -9.86531675e-02f, 1.43904403e-01f, 6.18614964e-02f, -8.25247392e-02f, -6.22676313e-02f, -1.82074040e-01f,
  -7.96421468e-02f, -1.08912706e-01f, -2.56236624e-02f, 6.61466196e-02f, -4.16518450e-02f, -1.19676488e-03f, -9.75544527e-02f, 4.06428799e-02f, 1.41752437e-01f, -2.00514838e-01f,
  -5.71832899e-03f, -8.72756261e-03f, -1.08192854e-01f, 4.59953472e-02f, -6.77010641e-02f, 1.81938633e-01f, -1.35084152e-01f, -4.72908877e-02f, 7.45852962e-02f, 2.15788200e-01f,
  9.43761542e-02f, 2.56190542e-02f, -2.06424177e-01f, 2.61939433e-03f, 5.45352399e-02f, -1.19959563e-02f, 1.16946019e-01f, 3.11228205e-02f, 2.60374472e-02f, 1.47235189e-02f,
  3.09255142e-02f, -1.05617076e-01f, 1.63605765e-01f, -4.98758778e-02f, 1.51279390e-01f, 6.20473847e-02f, 1.65796075e-02f, 4.29609232e-02f, 1.90912575e-01f, 2.00624406e-01f,
  -4.06579971e-02f, -1.47128507e-01f, 2.01214403e-01f, 6.14937693e-02f, 7.33508691e-02f, 8.11187252e-02f, -2.60689203e-02f, -3.35550494e-02f, 4.40638289e-02f, -9.62592429e-04f,
  -6.91599473e-02f, -5.44229373e-02f, 1.12984097e-03f, 2.09204499e-02f, 5.17188795e-02f, -3.60781848e-02f, 5.22360057e-02f, 1.21839225e-01f, 9.96867381e-03f, 1.56629868e-02f,
  -3.27882171e-02f, -1.00083224e-01f, 1.09493002e-01f, 6.86880425e-02f, 3.11823748e-02f, 1.05832741e-01f, -2.48771533e-02f, 8.51493850e-02f, 4.69715707e-03f, 7.47385994e-03f,
  -2.75863744e-02f, -3.53220366e-02f, -1.42425047e-02f, -7.05625862e-02f, 4.60999086e-02f, 1.00882471e-01f, -6.00812137e-02f, 3.93793620e-02f, 1.46823451e-01f, -1.98875010e-01f,
  9.25400779e-02f, 6.29737154e-02f, 4.99423370e-02f, -9.56383869e-02f, 8.90167505e-02f, -6.22093529e-02f, 3.32995690e-02f, 1.38842717e-01f, 1.07990384e-01f, 9.87464786e-02f,
  1.17801040e-01f, 1.98282793e-01f, 8.97514001e-02f, 4.69408929e-02f, 1.29447728e-01f, 2.69279610e-02f, -1.14615345e-02f, -1.28900766e-01f, -2.52322759e-02f, -3.42239253e-02f,
  1.49777174e-01f, 1.53842986e-01f, -4.41901721e-02f, -9.11177173e-02f, -1.18821124e-02f, -5.90244215e-03f, 7.48146474e-02f, 1.10593177e-01f, -6.78335130e-02f, -1.69272944e-02f,
  -1.46096088e-02f, 2.91747861e-02f, 6.70933351e-02f, -1.46146372e-01f, 4.99499105e-02f, 5.62467650e-02f, -1.06689960e-01f, 3.73808742e-02f, -3.82325277e-02f, -1.29005732e-03f,
  -6.53641596e-02f, -1.07257022e-02f, -1.10850044e-01f, -1.47440895e-01f, -6.72152713e-02f, 2.02906989e-02f, -1.26840184e-02f, 1.84641227e-01f, 6.61259070e-02f, 6.65890202e-02f,
  -3.94676737e-02f, -1.83823645e-01f, 3.18907052e-02f, -6.91603273e-02f, 1.41861245e-01f, 1.46669611e-01f, -3.22789513e-02f, -5.65813817e-02f, 2.65567489e-02f, -5.17085120e-02f,
  3.44906002e-02f, 5.86346500e-02f, 9.64452550e-02f, -1.46050379e-01f, 3.66182365e-02f, 4.42661420e-02f, 4.36799899e-02f, 7.73074776e-02f, 2.61911959e-03f, -2.35054698e-02f,
  -1.43379167e-01f, -3.56289111e-02f, -1.41952589e-01f, 4.83206548e-02f, -7.37414360e-02f, -4.59287241e-02f, 8.23426396e-02f, -2.30943281e-02f, -1.33464202e-01f, -9.14089456e-02f,
  -9.42045078e-02f, -6.67959005e-02f, -1.06922850e-01f, -2.66145798e-03f, 7.42626339e-02f, 5.12773469e-02f, -5.62237874e-02f, -8.13373327e-02f, -2.14267299e-01f, -1.98540539e-02f,
  1.16355382e-02f, 2.28472129e-02f, 6.46315515e-02f, -6.02773093e-02f, -6.75858632e-02f, 4.14213203e-02f, 1.13091715e-01f, -9.40633491e-02f, -3.32719386e-02f, -4.85551953e-02f,
  -9.21540335e-03f, 2.47766320e-02f, 1.28206704e-02f, -5.10695726e-02f, 1.74371116e-02f, 1.48355830e-02f, -9.30022895e-02f, -9.17577520e-02f, -4.47026454e-02f, -1.23270661e-01f,
  -1.42129259e-02f, 2.45297268e-01f, -8.59050676e-02f, -1.48357637e-02f, 1.21432625e-01f, -1.38952971e-01f, 3.05783711e-02f, 1.62605494e-02f, 9.62738097e-02f, -1.06652163e-01f,
  1.79503247e-01f, -8.43097866e-02f, 1.71389095e-02f, 9.44948420e-02f, -5.21748029e-02f, -1.30703161e-02f, 1.28216669e-01f, -4.88205925e-02f, 9.74088162e-03f, 2.30796412e-02f,
  4.78570163e-02f, 9.63236857e-03f, 8.28124881e-02f, 4.44470979e-02f, -3.42904516e-02f, 7.45987473e-03f, 9.70232338e-02f, 3.45700756e-02f, -1.41116688e-02f, 1.12872325e-01f,
  8.87458995e-02f, 5.11827245e-02f, 8.55648518e-02f, -1.79454863e-01f, 1.83348209e-02f, -2.62535185e-01f, 6.24008069e-04f, -8.99957716e-02f, 1.02938704e-01f, 7.48635158e-02f,
  -2.02142401e-03f, -8.05196166e-02f, -1.40397176e-01f, -8.63878801e-02f, -6.45507500e-02f, 5.59949949e-02f, -1.01800695e-01f, 7.39764646e-02f, 3.52378562e-02f, 3.33663896e-02f,
  9.20634717e-02f, -5.83783118e-03f, -1.73432231e-02f, 7.62167992e-03f, -3.63442749e-02f, 2.85020191e-02f, -3.40829082e-02f, 3.74354310e-02f, -3.06631606e-02f, 3.06622982e-02f,
  -1.02725409e-01f, 5.21337651e-02f, -8.61481428e-02f, 8.77495669e-03f, -3.00700162e-02f, -4.22318354e-02f, -7.19152167e-02f, 9.91887674e-02f, -9.62490365e-02f, -8.22583660e-02f,
  -9.79931578e-02f, -5.68070151e-02f, -5.77357411e-02f, 4.64870445e-02f, -2.59813163e-02f, -7.34836534e-02f, 6.26594573e-02f, 4.43530604e-02f, -4.12693694e-02f, -1.11287227e-02f,
  3.88684981e-02f, -1.68206934e-02f, -7.26063699e-02f, -4.65202816e-02f, 2.20939610e-02f, -2.90421885e-03f, -2.64363494e-02f, 1.40170217e-01f, -1.14597246e-01f, -1.49842262e-01f,
  -2.08798070e-02f, 3.80366556e-02f, -8.65447596e-02f, 3.33002619e-02f, -4.94310446e-03f, -6.81610033e-02f, -8.01938772e-02f, -1.00916959e-01f, 7.31985737e-03f, -9.72519740e-02f,
  -6.93600178e-02f, 6.11802451e-02f, 1.16471261e-01f, 8.10373574e-02f, 3.33071835e-02f, 2.68500037e-02f, 9.69390869e-02f, -1.21474460e-01f, 5.16869165e-02f, -5.70060983e-02f,
  -7.20248893e-02f, 2.17119362e-02f, -4.36840532e-03f, 2.00223122e-02f, 1.87604770e-03f, -9.40736979e-02f, 7.84311518e-02f, 7.74023915e-03f, -4.71886657e-02f, 1.01312473e-01f,
  4.36684256e-03f, -1.06148779e-01f, 1.34730428e-01f, 7.68001936e-03f, -1.23485466e-02f, 9.90682393e-02f, 4.12345305e-02f, 7.38269463e-02f, -9.58643556e-02f, -2.28176396e-02f,
  -1.47414757e-02f, 7.49605671e-02f, -1.65812522e-01f, 4.95047569e-02f, 2.67119110e-02f, -1.14862733e-01f, -4.39514704e-02f, -2.35360162e-03f, -9.87041742e-02f, -1.11722335e-01f,
  -1.02291830e-01f, -1.44090876e-02f, 4.66968752e-02f, 6.64224178e-02f, 9.89994034e-02f, -1.86947674e-01f, -1.04124680e-01f, 5.35060838e-02f, 4.96478491e-02f, -2.02548280e-02f,
  9.94035229e-02f, 1.35651246e-01f, -4.31805663e-02f, -7.91838765e-02f, -1.06319815e-01f, 3.72851007e-02f, 8.30755755e-03f, 7.19044060e-02f, 7.41407946e-02f, -6.69083968e-02f,
  -1.36861295e-01f, -7.78157189e-02f, -4.40763794e-02f, -2.82775238e-02f, -1.05924331e-01f, -2.45751496e-02f, -6.34938404e-02f, -7.81621039e-02f, 2.90720956e-03f, -1.20327614e-01f,
  9.68954992e-03f, -9.19325948e-02f, 4.94965203e-02f, -1.40008837e-01f, 1.02590688e-01f, 4.29251604e-03f, 1.33648679e-01f, 3.81548442e-02f, 1.10930249e-01f, 1.06093645e-01f,
  9.17223170e-02f, 3.54519955e-07f, 9.49995499e-03f, 4.50115502e-02f, 1.15583546e-01f, 7.92413577e-02f, -6.09254604e-03f, 8.82915501e-03f, 5.51114641e-02f, 1.38368607e-01f,
  -5.67517802e-02f, 1.38092712e-01f, -8.91027674e-02f, 1.85133442e-02f, 5.21826111e-02f, -4.19171415e-02f, 6.28403947e-02f, -1.80034172e-02f, 2.57712472e-02f, 3.31968740e-02f,
  -6.81956708e-02f, 6.74900040e-02f, -1.02928445e-01f, -7.50270858e-02f, 4.91535664e-02f, -6.76101372e-02f, -5.88505855e-03f, -4.75792922e-02f, 3.25099262e-03f, -1.51369765e-01f,
  -4.60779816e-02f, 8.96142349e-02f, -1.02611989e-01f, 1.36079844e-02f, -1.79885074e-01f, 1.12475812e-01f, 3.66620570e-02f, 1.57348011e-02f, -3.90677713e-02f, -1.03828341e-01f,
  -1.21757425e-01f, -6.42011687e-03f, 3.49663869e-02f, 1.47154137e-01f, -9.04596373e-02f, -1.18173763e-01f, -2.00541597e-02f, 1.50844142e-01f, -5.78011759e-02f, 3.68065871e-02f,
  1.96119063e-02f, 6.70496449e-02f, -2.08716537e-03f, -1.11904562e-01f, 2.98690405e-02f, 1.34279877e-01f, -9.82725099e-02f, 1.09451478e-02f, -4.81028855e-02f, 7.41611794e-02f,
  7.23850029e-03f, -5.41542247e-02f, -4.13525887e-02f, 2.00290214e-02f, 2.49384753e-02f, -2.63121501e-02f, 1.81865692e-02f, 5.56208193e-02f, 9.13647637e-02f, 2.55747419e-02f,
  3.70760188e-02f, -4.44128215e-02f, -4.87290844e-02f, 1.32767241e-02f, 3.16739716e-02f, 1.13929072e-02f, -3.43418978e-02f, -2.12346092e-01f, -8.89027342e-02f, -2.86847875e-02f,
  6.98268041e-02f, 1.02046832e-01f, -2.09361371e-02f, 2.17216015e-02f, -7.92351142e-02f, -1.86635450e-01f, 1.15213357e-01f, 4.11538370e-02f, 4.48018424e-02f, 4.11066562e-02f,
  -4.73479256e-02f, 6.38626423e-03f, -4.70615812e-02f, 1.28050104e-01f, -9.41224396e-02f, 6.94694668e-02f, 5.22921095e-03f, 5.84041029e-02f, -6.18599541e-02f, 2.52826372e-03f,
  -8.74285866e-03f, 3.88565175e-02f, 1.31519184e-01f, 1.02429479e-01f, 2.61014588e-02f, 2.36553568e-02f, -6.28555715e-02f, -2.63481233e-02f, 7.92040527e-02f, -8.66967291e-02f,
  9.39306915e-02f, -1.29153371e-01f, 1.05042458e-02f, -1.65277213e-01f, -1.25368582e-02f, -2.68556047e-02f, 1.51237532e-01f, 3.87283042e-02f, 1.07928999e-01f, -9.03169587e-02f,
  1.33750029e-02f, -4.67870682e-02f, -5.89759834e-02f, 5.32184690e-02f, 4.54813726e-02f, -1.06851421e-01f, -5.47065362e-02f, 6.60395548e-02f, -1.34894088e-01f, -6.70315623e-02f,
  -1.23728923e-01f, -3.87887955e-02f, -5.97174466e-02f, 3.01883779e-02f, 4.92907986e-02f, 2.19508144e-03f, -3.27817872e-02f, -3.52845676e-02f, 6.49422482e-02f, -1.67246446e-01f,
  2.64470540e-02f, -8.36503208e-02f, -1.29562631e-01f, 3.46887670e-02f, 4.05329987e-02f, 4.04872000e-02f, -1.83951274e-01f, 1.71023570e-02f, -8.46418142e-02f, -9.55793038e-02f,
  8.08961838e-02f, 1.32346466e-01f, -4.71757762e-02f, 1.33329824e-01f, -1.21542282e-01f, 3.59049439e-02f, -2.92025041e-02f, -3.80323865e-02f, 8.07315335e-02f, 8.42302665e-03f,
  3.47641073e-02f, -1.56321034e-01f, 1.38331175e-01f, 1.98654085e-01f, 1.19514707e-02f, -9.28608477e-02f, -7.78102782e-03f, 4.09054710e-03f, 4.10903618e-02f, -4.63955700e-02f,
  -2.09897216e-02f, -1.34159490e-01f, 3.52805108e-02f, 1.48625165e-01f, -3.25321220e-02f, -7.76422098e-02f, -3.72023694e-02f, -1.30591355e-02f, 4.50271182e-02f, -8.61145630e-02f,
  1.34480178e-01f, 2.94531193e-02f, 1.50176600e-01f, 3.10949590e-02f, -1.21577404e-01f, -9.02865753e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -8.07204843e-02f, 2.07262468e-02f, 2.06778590e-02f, -9.16052833e-02f, 5.38826548e-02f, 4.44186181e-02f, -4.57250215e-02f, -1.17731005e-01f, -3.21541578e-02f, -5.83930314e-02f,
  8.02610815e-02f, 9.35440212e-02f, 3.45490612e-02f, 2.77026003e-04f, -6.36271909e-02f, 1.03613600e-01f, 9.53692347e-02f, -2.66068000e-02f, -8.65979865e-02f, -1.75676808e-01f,
  -1.62086219e-01f, -1.01613007e-01f, 9.25045460e-02f, -4.21084575e-02f, -7.43551999e-02f, 4.67204675e-02f, -1.24349363e-01f, 2.94440538e-02f, 6.17411248e-02f, 3.45461555e-02f,
  1.91792607e-01f, 4.46271002e-02f, -6.08139448e-02f, 1.65478755e-02f, -2.40122359e-02f, 1.20837830e-01f, -2.46719401e-02f, 4.13046330e-02f, -8.27630013e-02f, 1.60904154e-01f,
  -1.74298182e-01f, -1.94409024e-02f, 6.12893328e-03f, -1.33342296e-03f, 2.48364612e-01f, -1.53890863e-01f, 2.36612950e-02f, -1.46557659e-01f, -1.72776237e-01f, 1.01376928e-01f,
  1.75267890e-01f, -2.13186294e-02f, 1.99466631e-01f, -1.38806596e-01f, -4.68071172e-04f, -5.48430905e-02f, 4.82990481e-02f, 4.40995349e-03f, 2.05726385e-01f, 1.27951548e-01f,
  -6.66701719e-02f, 9.91275683e-02f, 5.87535277e-02f, -2.13563871e-02f, 1.69138182e-02f, -4.16228510e-02f, 4.49640453e-02f, 1.04925662e-01f, 6.80002496e-02f, -1.80116259e-02f,
  -8.71657580e-02f, 2.87219565e-02f, -1.76825985e-01f, -2.85473536e-03f, -1.63871180e-02f, 5.38040549e-02f, 7.31111988e-02f, 1.98336467e-02f, 1.29001036e-01f, -1.92063034e-01f,
  2.81550325e-02f, 6.34858236e-02f, 1.06067955e-01f, 9.46235433e-02f, 1.65667832e-01f, -1.07095197e-01f, 2.02197507e-01f, 7.32877254e-02f, 1.30210042e-01f, 1.36311516e-01f,
  9.96879563e-02f, 1.18690446e-01f, -5.31920902e-02f, -4.31815162e-02f, -4.98485230e-02f, -2.14368150e-01f, 5.34247756e-02f, -6.74098060e-02f, -9.44235697e-02f, 1.30330980e-01f,
  1.61649957e-01f, 1.17002472e-01f, -4.11938392e-02f, -4.78227250e-03f, -9.61896479e-02f, -2.57952154e-01f, 2.05311533e-02f, 2.53326923e-01f, 3.97071354e-02f, -1.10956080e-01f,
  1.65517747e-01f, 1.13323279e-01f, 7.17498660e-02f, 1.14653610e-01f, 1.96820170e-01f, 2.87155479e-01f, 4.29676138e-02f, 1.83205888e-01f, 2.01661021e-01f, 1.47246823e-01f,
  -8.28143582e-02f, 1.80045694e-01f, -3.41084844e-04f, 1.36965886e-01f, -7.75115192e-02f, 1.37362853e-01f, 1.33610919e-01f, 4.03576344e-01f, -1.01366704e-02f, -5.66243231e-02f,
  -7.88647383e-02f, 7.62533545e-02f, 8.59943256e-02f, -2.04149652e-02f, -6.18937761e-02f, 2.83289813e-02f, -5.47224507e-02f, 2.00263094e-02f, -1.75601523e-02f, -6.42259941e-02f,
  -5.57272807e-02f, -1.29869971e-02f, -9.19625312e-02f, -3.32268551e-02f, 6.13591745e-02f, 9.45669338e-02f, 3.47039625e-02f, 1.02915734e-01f, 4.15321887e-02f, -1.58901602e-01f,
  -1.58861764e-02f, -1.05810501e-01f, 4.08019833e-02f, 1.73185933e-02f, 1.26304880e-01f, 1.50093809e-01f, 6.26713857e-02f, -4.51986641e-02f, 7.23910183e-02f, -7.36669227e-02f,
  1.45887628e-01f, 1.49157107e-01f, -4.27712686e-02f, 1.60782143e-01f, -7.29507506e-02f, -7.13041350e-02f, 1.02639366e-02f, 3.49433124e-01f, 4.57812510e-02f, -1.80463761e-01f,
  -1.76625803e-01f, 1.81237653e-01f, 1.36131153e-01f, -1.85280442e-01f, 1.09318560e-02f, -5.36147617e-02f, 7.34033361e-02f, 3.01559210e-01f, 1.71246588e-01f, 1.17905073e-01f,
  9.88203064e-02f, -5.00382343e-03f, 6.84768260e-02f, 1.87889367e-01f, 4.97800410e-02f, -4.60478924e-02f, 1.65427744e-01f, 1.80755273e-01f, -1.54496059e-01f, 1.22955143e-02f,
  1.46422416e-01f, 2.31711268e-01f, -8.54682177e-02f, 1.96132511e-02f, -3.58958170e-02f, 4.72963750e-02f, -1.14837646e-01f, -1.02756642e-01f, -5.73370839e-03f, 1.15648076e-01f,
  9.65284854e-02f, 3.24349813e-02f, 2.30453592e-02f, 4.99456674e-02f, 1.52472764e-01f, 6.03630580e-03f, 1.31492004e-01f, 9.83041897e-02f, 7.61342347e-02f, 1.08203880e-01f,
  3.31442580e-02f, -1.83381125e-01f, 8.39458928e-02f, -6.78491294e-02f, 8.83489996e-02f, 2.26708576e-01f, 5.94181530e-02f, -8.03936198e-02f, -7.63362944e-02f, -1.24929763e-01f,
  9.18058008e-02f, 1.94954738e-01f, -1.74150661e-01f, 6.43459409e-02f, 1.27735883e-01f, 3.95371430e-02f, -1.41568840e-01f, 1.66562170e-01f, 1.52906785e-02f, -4.93846722e-02f,
  5.73883988e-02f, 8.54564011e-02f, 1.53194278e-01f, -1.83388218e-01f, 1.23174250e-01f, 2.35449031e-01f, 8.69461149e-02f, -1.45710381e-02f, 2.46663690e-01f, 1.19916506e-01f,
  -4.31001745e-02f, 8.69644731e-02f, 1.68006077e-01f, 2.51372665e-01f, 1.11705795e-01f, 1.23063840e-01f, 2.97455788e-01f, -1.25792369e-01f, -3.21973503e-01f, -1.47250488e-01f,
  1.79964572e-01f, 2.05994412e-01f, 5.68638369e-02f, 1.19634911e-01f, 1.36943549e-01f, 5.58625609e-02f, 1.66396219e-02f, -1.78670418e-02f, -3.63835366e-03f, 3.88586186e-02f,
  2.66007483e-01f, -4.01470577e-03f, -4.70918790e-02f, 8.47494751e-02f, -1.09272599e-01f, -1.67083621e-01f, 8.78043473e-02f, -5.08698188e-02f, -7.71739483e-02f, 3.03091779e-02f,
  -2.75801778e-01f, 5.48789762e-02f, 8.95394832e-02f, -1.13108501e-01f, -1.59682676e-01f, 1.45746142e-01f, 5.73686473e-02f, -1.16400234e-02f, -2.28191674e-01f, -1.72697797e-01f,
  5.25188781e-02f, -1.11638039e-01f, 4.74120453e-02f, 1.67673722e-01f, 7.84678608e-02f, -3.58803779e-01f, 1.16300084e-01f, -1.02649823e-01f, -9.67471115e-03f, 1.16024569e-01f,
  7.24445805e-02f, -1.39573971e-02f, -1.72778845e-01f, -1.72898278e-01f, 1.70529097e-01f, 3.32336843e-01f, 2.53024787e-01f, -4.01923731e-02f, -3.27742666e-01f, -1.33631051e-01f,
  6.69662505e-02f, 1.45641550e-01f, -5.66683486e-02f, 1.22231040e-02f, 1.60419315e-01f, 1.77030668e-01f, -1.06222451e-01f, -1.70615450e-01f, 1.68322206e-01f, -9.67831910e-02f,
  -1.33003578e-01f, 2.77327865e-01f, 2.83527195e-01f, 9.63680372e-02f, 1.10847645e-01f, 2.47485608e-01f, 2.55480912e-02f, -2.07291424e-01f, 2.82594144e-01f, 8.41319263e-02f,
  4.33809385e-02f, 7.43705854e-02f, -1.62111185e-02f, 3.68503630e-02f, -7.76730012e-03f, 3.58464494e-02f, 1.20309532e-01f, -7.31236814e-03f, 1.70834124e-01f, 2.27072433e-01f,
  1.83585867e-01f, 7.98757747e-02f, 1.43643484e-01f, -3.92604508e-02f, 9.05857142e-03f, 1.37673303e-01f, -1.13919474e-01f, 2.03445017e-01f, -6.78998884e-03f, -4.51095961e-02f,
  -7.44233746e-03f, 1.34587929e-01f, -5.87916300e-02f, 1.15067653e-01f, 6.38603419e-02f, -1.22939080e-01f, -1.32379010e-01f, -1.42141864e-01f, -4.04601544e-02f, 1.03393711e-01f,
  -8.69231448e-02f, 1.29076779e-01f, -1.62758250e-02f, 7.54992142e-02f, -3.92983481e-02f, -2.71332357e-02f, -1.25838026e-01f, 5.56007363e-02f, -1.66235641e-02f, -2.85109282e-02f,
  -1.07893982e-04f, 2.29072243e-01f, 1.46011487e-01f, -4.35075052e-02f, -1.05195247e-01f, 1.39414340e-01f, -2.86918152e-02f, 6.01219088e-02f, 9.39894766e-02f, -8.43630359e-02f,
  -1.44231081e-01f, -8.02104473e-02f, -9.35993120e-02f, 1.41207039e-01f, 2.22195946e-02f, -1.88066009e-02f, -6.50345162e-02f, -1.08330853e-01f, 6.54788315e-02f, 8.51744041e-03f,
  7.51219764e-02f, 1.49330214e-01f, -8.67118612e-02f, -2.29229629e-01f, -2.68772990e-03f, 2.88576074e-03f, 1.78903744e-01f, 1.16637968e-01f, -1.18277103e-01f, -8.92213807e-02f,
  3.61158885e-02f, 1.10504977e-01f, -3.27159166e-02f, 3.38325910e-02f, 7.27706030e-02f, 1.11206181e-01f, -4.88028536e-03f, 1.00120761e-01f, 2.49897927e-01f, 5.06650805e-02f,
  -4.26955670e-02f, 2.51144558e-01f, 8.02048817e-02f, 1.98783755e-01f, 1.74411625e-01f, 1.88295037e-01f, 3.73086892e-02f, 8.97570476e-02f, 7.10910037e-02f, 1.30642444e-01f,
  6.99788108e-02f, 6.78530261e-02f, -2.82153279e-01f, 1.18797638e-01f, -4.23742235e-02f, -8.57152566e-02f, 1.06881693e-01f, -1.30344033e-02f, 1.07155308e-01f, -4.97595161e-01f,
  1.05548427e-01f, 1.62998199e-01f, -6.53993338e-02f, -2.43938491e-01f, -5.30143045e-02f, -1.16366595e-02f, 3.21374834e-01f, 1.20609052e-01f, -2.08077073e-01f, 1.57768935e-01f,
  1.65466651e-01f, 1.46061137e-01f, 2.08608165e-01f, 2.08147585e-01f, -8.23506117e-02f, 2.17169330e-01f, -3.60186964e-01f, 3.08753729e-01f, -2.03707907e-03f, 7.26016164e-02f,
  5.83332814e-02f, 7.22278357e-02f, -2.01982707e-01f, -2.49393284e-01f, 1.41066343e-01f, 1.92712173e-01f, -1.59242541e-01f, 6.94568381e-02f, -4.44042347e-02f, -1.13452792e-01f,
  -1.04369536e-01f, 7.03520179e-02f, -1.20573476e-01f, -2.75335699e-01f, -2.21119329e-01f, 1.13028102e-01f, -7.02333972e-02f, -4.49754596e-02f, -1.87621161e-01f, -8.16802084e-02f,
  2.13897396e-02f, -8.91331583e-02f, 5.48381954e-02f, -1.93278477e-01f, 8.33724067e-02f, -2.05346063e-01f, 1.60233065e-01f, 2.17337430e-01f, 1.10290244e-01f, -7.80009180e-02f,
  1.30374476e-01f, 5.40708527e-02f, 9.19352695e-02f, 5.27938828e-02f, 2.51145512e-01f, -9.00376290e-02f, 1.21994123e-01f, 1.02170385e-01f, -2.59506911e-01f, 5.31651191e-02f,
  1.41949013e-01f, -9.28244144e-02f, -2.30662916e-02f, 1.11490197e-01f, 9.77802202e-02f, 9.74448919e-02f, 2.84018159e-01f, -1.49578536e-02f, 3.91170442e-01f, -3.21887106e-01f,
  7.02590942e-02f, 2.45322108e-01f, -1.26702338e-03f, 1.63628042e-01f, 1.85281411e-01f, 3.65429640e-01f, 9.62326601e-02f, 1.76861882e-02f, 1.87638536e-01f, 2.28727028e-01f,
  1.02606229e-02f, 4.23392989e-02f, 1.66719362e-01f, -1.66924030e-01f, -1.75801277e-01f, -1.16964228e-01f, -2.73433514e-02f, 2.13558581e-02f, -8.58437717e-02f, -6.04760051e-02f,
  5.29306158e-02f, 3.96392196e-01f, 9.26088449e-03f, 5.02019599e-02f, 4.65930514e-02f, -1.26829416e-01f, -1.96876451e-02f, -1.37055829e-01f, 1.16070881e-01f, -9.14232526e-03f,
  -3.43035208e-03f, 1.69516634e-02f, 1.14450276e-01f, 2.72246618e-02f, -9.41469744e-02f, 9.85416248e-02f, 8.49704966e-02f, 4.07099836e-02f, -2.75824079e-03f, -7.22431019e-03f,
  -9.66186523e-02f, -2.09387373e-02f, -6.75750375e-02f, 1.26424372e-01f, 6.46570995e-02f, 2.60396898e-02f, -1.87929031e-02f, -2.86867153e-02f, -1.19426660e-02f, -1.36491627e-01f,
  2.15542559e-02f, -6.28290251e-02f, 3.04152053e-02f, 6.15929626e-02f, -1.61667734e-01f, -2.72041336e-02f, 1.92172840e-01f, -1.46923423e-01f, 6.05192706e-02f, 6.54467940e-02f,
  9.26297009e-02f, -2.30773404e-01f, 2.00896770e-01f, 2.03141838e-01f, 2.08075970e-01f, -6.63905218e-02f, 5.82494326e-02f, 3.25618356e-01f, 2.00041398e-01f, 1.54410630e-01f,
  1.45372093e-01f, -8.05358440e-02f, 2.83861272e-02f, -1.71200544e-01f, 1.37491077e-02f, -6.51014000e-02f, -1.47019073e-01f, -8.41679424e-02f, 2.22389564e-01f, 1.76218972e-01f,
  7.87876025e-02f, -5.80411293e-02f, 7.49514922e-02f, -1.20881192e-01f, 1.01458907e-01f, -1.08514363e-02f, 2.39576530e-02f, -8.59118849e-02f, 6.32509589e-02f, -2.46553272e-02f,
  6.09826520e-02f, -2.57767737e-02f, 1.24542542e-01f, 1.81418415e-02f, 6.27101138e-02f, -5.91012388e-02f, 1.94800124e-01f, -4.18343320e-02f, -9.09179300e-02f, 3.85761634e-02f,
  8.43849406e-02f, 7.20677748e-02f, -1.08618271e-02f, 1.70626670e-01f, -4.82833348e-02f, 1.24974795e-01f, 1.02668628e-01f, 1.87022015e-02f, 1.24205358e-01f, -6.50408790e-02f,
  1.01006158e-01f, 5.44687696e-02f, 1.09137364e-01f, 1.38183888e-02f, -9.05273035e-02f, 2.48024110e-02f, 1.57040179e-01f, -9.07916650e-02f, 5.20381518e-02f, -1.93332937e-02f,
  1.94414765e-01f, -2.27199689e-01f, 6.61103651e-02f, 8.74905661e-02f, -4.50515300e-02f, -1.38930157e-02f, -1.07392952e-01f, -1.03253368e-02f, 1.60427183e-01f, 1.65614650e-01f,
  9.83458981e-02f, 1.53641537e-01f, 1.55807346e-01f, 2.25127220e-01f, 1.87455624e-01f, 1.95250615e-01f, 1.50470644e-01f, -5.08755222e-02f, -6.83748275e-02f, -9.14203152e-02f,
  -9.67360139e-02f, 4.62835096e-03f, 2.81030923e-01f, 1.88201025e-01f, -1.27952456e-01f, -8.64055306e-02f, -2.53029346e-01f, 1.77336410e-01f, 1.86568439e-01f, 2.73931026e-01f,
  1.28044501e-01f, -1.47818133e-01f, 7.97780827e-02f, 9.51418304e-04f, 1.12119883e-01f, 1.04427129e-01f, 8.91285241e-02f, -4.04770859e-02f, 8.98692161e-02f, -1.15267122e-02f,
  1.59002930e-01f, 2.37642927e-03f, -1.47980019e-01f, 1.78676490e-02f, -2.31523827e-01f, -3.51079404e-02f, -1.06131874e-01f, 1.60702735e-01f, -1.67354234e-02f, 3.05004418e-01f,
  6.89518750e-02f, -2.81201117e-02f, -4.83035520e-02f, -1.42242312e-01f, 1.00844070e-01f, -1.79942951e-01f, -4.50441428e-03f, -7.53194559e-03f, -1.52954264e-02f, 2.75374483e-02f,
  1.19721591e-01f, -5.24680875e-02f, 1.51391938e-01f, 1.42117053e-01f, 3.75445820e-02f, -1.99990451e-01f, -1.18084401e-01f, -1.06158413e-01f, -1.25347823e-01f, 2.65677810e-01f,
  -1.81260675e-01f, 1.30531371e-01f, -7.13809058e-02f, 4.85661291e-02f, 2.33625434e-02f, 1.87296867e-02f, -1.44343197e-01f, 1.32490069e-01f, 1.46329597e-01f, 2.44000539e-01f,
  4.60359231e-02f, 4.39518690e-02f, -1.04570203e-01f, 6.96876273e-02f, 3.93822498e-04f, 3.64439562e-02f, 3.09885114e-01f, -2.72553980e-01f, 7.54038990e-02f, -1.69995710e-01f,
  -1.83085904e-01f, 2.98782051e-01f, -6.46113977e-02f, -4.42296490e-02f, -9.19034183e-02f, 5.13088480e-02f, 6.44348934e-02f, -3.92284542e-02f, -1.54649183e-01f, 1.53113768e-01f,
  -7.09734857e-03f, -4.76509407e-02f, -1.42947491e-02f, -6.41406626e-02f, -6.90742731e-02f, 9.41929072e-02f, 6.47960678e-02f, 3.69913243e-02f, 1.22772023e-01f, -2.25778692e-03f,
  1.77609921e-02f, -3.88268605e-02f, -3.51487510e-02f, -2.85027355e-01f, -1.39941677e-01f, 3.06378473e-02f, 2.20343377e-02f, 1.95439517e-01f, -1.39869332e-01f, 1.04711004e-01f,
  -1.29485190e-01f, -9.70275477e-02f, 9.01914686e-02f, 1.66116387e-01f, -1.04108959e-01f, 1.29734725e-01f, -1.66200995e-01f, -6.94000050e-02f, -2.01802909e-01f, 2.41732717e-01f,
  -5.21163782e-03f, -2.96769701e-02f, -4.85381261e-02f, -5.24821458e-03f, -5.16241044e-03f, 6.66847154e-02f, 2.93036014e-01f, 3.34371701e-02f, 1.14555627e-01f, -3.14909890e-02f,
  2.99593389e-01f, -1.49297088e-01f, -1.91049248e-01f, -1.51925579e-01f, 1.28361210e-01f, 2.37104297e-01f, 2.09514722e-01f, 2.52750486e-01f, 1.91788673e-01f, 3.57116796e-02f,
  -1.83012784e-01f, -5.71490405e-03f, 2.43823841e-01f, 2.75302738e-01f, 3.19847286e-01f, 8.50059241e-02f, -1.59301404e-02f, -5.13743982e-02f, 2.45719985e-03f, 5.28840236e-02f,
  1.31486490e-01f, -4.25956100e-02f, -2.65070256e-02f, 6.92602322e-02f, 1.15806140e-01f, -9.39165205e-02f, 1.15983158e-01f, 9.61047560e-02f, 1.13758169e-01f, 9.20544341e-02f,
  1.08140036e-01f, 9.64169279e-02f, 1.27096787e-01f, 2.91603357e-01f, 5.33619290e-03f, 1.53321773e-01f, -5.43903373e-02f, -2.34326780e-01f, -2.04834659e-02f, 8.81712288e-02f,
  -1.67285830e-01f, 1.18403435e-01f, -5.65202795e-02f, -1.23978302e-01f, -2.50422806e-01f, -4.59006689e-02f, -1.50792301e-01f, 9.90792960e-02f, 1.13595061e-01f, 6.02141581e-02f,
  -3.03145144e-02f, 9.48082060e-02f, 2.08020061e-02f, -1.59742430e-01f, -9.02558863e-02f, -1.08109057e-01f, -1.32383570e-01f, 8.93448070e-02f, -2.43472338e-01f, 3.35175425e-01f,
  2.41778240e-01f, -1.33817181e-01f, -6.06220700e-02f, 2.55471133e-02f, 1.25336498e-01f, -1.14754118e-01f, 1.15025893e-01f, 2.57515702e-02f, -1.04642242e-01f, -3.50615233e-02f,
  -5.25132306e-02f, 2.60043532e-01f, 2.77123954e-02f, 2.38327608e-01f, -2.02711001e-02f, -6.79307505e-02f, 2.30233014e-01f, 3.63194197e-02f, 3.44443649e-01f, 3.76266927e-01f,
  -4.09649312e-03f, -2.61544257e-01f, 2.48566885e-02f, 1.52025819e-01f, -4.83103245e-02f, 3.30417603e-02f, 1.06851019e-01f, 1.43788517e-01f, 1.23143427e-01f, 2.36261729e-02f,
  -4.72438580e-04f, 6.06183968e-02f, 9.90036130e-02f, 1.39467537e-01f, 7.40549341e-02f, 7.66978711e-02f, -9.22922045e-02f, 1.28982775e-02f, -8.97645019e-03f, 1.42577589e-01f,
  -7.01097026e-02f, -2.18853608e-01f, 1.39728775e-02f, -7.76510313e-02f, -9.62163582e-02f, 4.75061536e-02f, -6.74710027e-04f, -3.71702798e-02f, -1.54860437e-01f, 7.85491168e-02f,
  1.16683178e-01f, -1.34747744e-01f, 7.26109743e-02f, -8.87873173e-02f, 7.82512128e-04f, 2.95785628e-02f, -1.04026228e-01f, 1.55460224e-01f, -1.35628611e-01f, -1.33763887e-02f,
  -7.68929645e-02f, 1.90400854e-01f, -1.43301323e-01f, -1.17413171e-01f, -3.31352860e-01f, -1.06680520e-01f, 7.76801556e-02f, -2.29399920e-01f, -3.41288149e-02f, -1.85660765e-01f,
  -1.51870072e-01f, 2.73761321e-02f, -8.19318146e-02f, -1.04772896e-01f, 2.26308838e-01f, -3.98644619e-02f, 3.78569253e-02f, 1.16319656e-01f, -1.54400915e-01f, 4.41006832e-02f,
  1.36700019e-01f, 2.41118118e-01f, -2.01752074e-02f, -1.68046534e-01f, 1.39318809e-01f, -9.06561166e-02f, 1.07123330e-02f, 7.49322921e-02f, -5.22471294e-02f, 4.44406793e-02f,
  -4.81354119e-03f, -2.02614501e-01f, 1.08754866e-01f, 1.96543142e-01f, -4.77715628e-03f, 1.20760709e-01f, 9.04190093e-02f, 3.22725102e-02f, 1.16441563e-01f, -9.64063331e-02f,
  2.97265779e-02f, 1.35982126e-01f, -1.40941087e-02f, 8.98576807e-03f, -1.32369297e-02f, -1.61052093e-01f, 1.87095568e-01f, 6.64524958e-02f, -1.24201633e-01f, 1.30560920e-01f,
  1.66884124e-01f, -1.82404518e-01f, -7.85688311e-02f, -8.77594724e-02f, 1.55015625e-02f, -1.67419255e-01f, -1.71865851e-01f, -7.89322481e-02f, 7.66152963e-02f, 1.10705402e-02f,
  5.52214012e-02f, -6.38539866e-02f, -9.24393460e-02f, 1.03218302e-01f, 1.97969243e-01f, -1.07341036e-01f, 3.90743047e-01f, 2.74595004e-02f, -5.91003038e-02f, -6.37492612e-02f,
  -1.25132829e-01f, 1.91630065e-01f, 9.71495882e-02f, 1.58599868e-01f, 1.32692561e-01f, 5.88284060e-02f, -1.69880822e-01f, -1.37771636e-01f, 5.26909679e-02f, -4.85997088e-02f,
  1.03658497e-01f, -1.15610354e-01f, -2.09742084e-01f, 7.55124837e-02f, 5.21525741e-02f, 1.25351965e-01f, 1.57147229e-01f, -1.91277623e-01f, 1.00118168e-01f, -7.56726786e-03f,
  7.47510139e-03f, -5.86471632e-02f, 6.37155473e-02f, -9.86152515e-03f, -4.90977652e-02f, 7.80140162e-02f, 9.02924016e-02f, 2.63415539e-04f, 1.41857594e-01f, 1.26319274e-01f,
  1.28907681e-01f, 3.83830480e-02f, -2.54455744e-03f, -6.82870150e-02f, 1.10412128e-02f, 1.75867975e-01f, 6.55025430e-03f, 1.16941161e-01f, -5.57466894e-02f, -1.80798844e-01f,
  -3.07959821e-02f, -8.49861354e-02f, 1.38695881e-01f, 1.76049903e-01f, 7.34547749e-02f, -1.45683810e-01f, -1.06567279e-01f, -1.91448331e-01f, 8.55405480e-02f, 1.07585058e-01f,
  1.81893837e-02f, 1.03544086e-01f, 5.73127046e-02f, 1.01436652e-01f, -3.91803384e-02f, 1.66423678e-01f, -1.31825805e-01f, 1.51725039e-02f, -6.93410411e-02f, 1.71602458e-01f,
  -7.27783889e-02f, 9.76422578e-02f, 6.56607281e-03f, 1.45433486e-01f, 1.73989803e-01f, -3.69650424e-02f, 1.25951365e-01f, 8.33495334e-02f, -3.16990614e-02f, 1.59373119e-01f,
  1.59707233e-01f, 3.48945372e-02f, 1.92910776e-01f, 3.42018604e-02f, 1.50226459e-01f, -8.34673792e-02f, -8.86870474e-02f, -1.09969549e-01f, 2.26482242e-01f, 8.93926620e-02f,
  -3.89036275e-02f, 1.20199516e-01f, 1.27596766e-01f, -5.69796190e-02f, -4.17309254e-02f, 6.53715879e-02f, -4.93495986e-02f, -2.90480293e-02f, -9.55524296e-02f, -4.61843684e-02f,
  4.61891554e-02f, -2.68976633e-02f, 1.53740451e-01f, 3.31655219e-02f, 7.85402805e-02f, 3.16824727e-02f, 5.22798114e-02f, -2.19154879e-02f, 5.79039343e-02f, 4.17402126e-02f,
  -5.06724678e-02f, 8.56996030e-02f, 1.83527675e-02f, -1.40386388e-01f, -1.18320741e-01f, 1.62309021e-01f, 9.82668833e-04f, 1.50348008e-01f, -3.02677769e-02f, -9.49848816e-02f,
  -1.58554092e-01f, -2.99457580e-01f, 8.90504196e-02f, 2.14583516e-01f, -1.72930524e-01f, 2.50540257e-01f, -8.76608193e-02f, 6.01117276e-02f, 1.18259639e-02f, -1.73040312e-02f,
  -3.04285623e-02f, -1.46677783e-02f, 8.57173726e-02f, -1.87030077e-01f, 2.12511063e-01f, 2.41878554e-01f, 2.14264989e-01f, -9.37351212e-02f, 3.07396054e-03f, 3.27394128e-01f,
  5.46009280e-02f, 2.77467430e-01f, 8.63144994e-02f, -1.25687018e-01f, 2.43707914e-02f, 8.63782410e-03f, -6.61759963e-03f, -6.61410168e-02f, 1.09563373e-01f, -2.81702787e-01f,
  -2.95269545e-02f, -1.69931948e-01f, 1.26070276e-01f, 1.07583981e-02f, 2.14549661e-01f, 5.84720559e-02f, -9.20873657e-02f, -2.34814450e-01f, -1.15986969e-02f, -1.00241236e-01f,
  -1.77008566e-02f, -8.48040730e-02f, 1.01821691e-01f, 1.88607544e-01f, 1.60496071e-01f, -1.97571158e-01f, 8.01054481e-03f, -5.99584468e-02f, 1.79210037e-01f, -1.81931779e-02f,
  -2.35016033e-01f, 9.85698029e-02f, -2.00166047e-01f, -1.14705689e-01f, -5.98305510e-03f, 6.52293563e-02f, -1.37016311e-01f, 4.05567372e-03f, -2.02978596e-01f, -8.77653994e-03f,
  7.76734650e-02f, -2.29524359e-01f, 1.29981274e-02f, 3.01605128e-02f, 1.19887600e-02f, -5.94380684e-02f, 1.11239210e-01f, -2.75068115e-02f, 1.16893277e-01f, 6.49170950e-02f,
  -2.28125021e-01f, 2.29827594e-02f, 1.22067340e-01f, 1.09753013e-02f, -2.77887535e-04f, -6.03126027e-02f, -6.98925257e-02f, 1.21813826e-01f, -1.77649111e-01f, 2.64320821e-01f,
  1.17946051e-01f, -6.73524011e-03f, 8.56709555e-02f, 1.96831301e-01f, -1.23473242e-01f, -5.69189265e-02f, 1.00510322e-01f, 2.65448671e-02f, 7.45423883e-02f, -2.90204972e-01f,
  1.11907780e-01f, -2.23612279e-01f, -1.35459274e-01f, -9.97385234e-02f, 4.82187361e-01f, 1.65688723e-01f, 1.40991971e-01f, 1.24631792e-01f, -1.58843353e-01f, 3.93437259e-02f,
  1.83618013e-02f, 4.37008888e-02f, 4.51297462e-02f, -6.55942783e-02f, -6.28316924e-02f, 1.51888812e-02f, -1.09987063e-02f, 7.17836469e-02f, -1.11320324e-01f, -9.85804647e-02f,
  -1.70408234e-01f, -9.69203487e-02f, -1.16393715e-01f, 1.28949452e-02f, -1.53876886e-01f, 8.64315778e-02f, -5.13029769e-02f, -3.42862397e-01f, -5.89565150e-02f, -1.43316701e-01f,
  3.94746773e-02f, 2.22421914e-01f, -9.39959139e-02f, -8.04878585e-03f, 1.43804580e-01f, -1.19040906e-01f, 4.18178551e-03f, 2.09886059e-01f, 1.61878869e-01f, 4.25406694e-02f,
  6.87165782e-02f, 9.88531411e-02f, 4.85449359e-02f, -2.46136857e-04f, -1.28027916e-01f, -1.23936757e-01f, 4.83782664e-02f, -5.47318496e-02f, 1.91433281e-01f, 2.94351429e-02f,
  -1.98848806e-02f, -4.49480629e-03f, -1.09048992e-01f, 5.52483136e-03f, 1.64052054e-01f, 2.29731798e-01f, 5.82773387e-02f, 1.24916822e-01f, 2.11365763e-02f, 9.37943906e-02f,
  7.08177313e-02f, 5.25219664e-02f, 2.29469687e-01f, 9.78498831e-02f, -2.27466412e-02f, -3.89050655e-02f, -1.58514399e-02f, -5.01146019e-02f, 3.78986925e-01f, 1.92559421e-01f,
  -5.47256786e-03f, -3.29784006e-02f, -1.23479739e-01f, 1.23867065e-01f, -2.59946920e-02f, 3.73332351e-01f, -2.01799069e-02f, 1.12501392e-02f, 6.69184327e-02f, 3.55859697e-02f,
  8.19331035e-02f, 1.18135810e-01f, 6.46196231e-02f, -6.36887103e-02f, 9.42966342e-02f, 1.09335907e-01f, 5.37184589e-02f, 8.68473873e-02f, 4.98933867e-02f, 3.19630164e-03f,
  -2.53102258e-02f, 1.93907276e-01f, 1.06130252e-02f, 1.21425748e-01f, -7.90832117e-02f, -1.75135374e-01f, 3.44359968e-03f, -1.23878801e-02f, -1.89180955e-01f, 6.62957504e-03f,
  -6.40769750e-02f, -1.30624548e-01f, -1.46120429e-01f, 7.81055540e-02f, -6.73105717e-02f, -4.74363901e-02f, 4.62570637e-02f, -1.87177528e-02f, 4.53708880e-02f, 1.75866768e-01f,
  -9.17634666e-02f, 7.75259659e-02f, -1.78014025e-01f, -1.03541851e-01f, -9.45998356e-02f, 2.62569427e-01f, -1.58832043e-01f, 2.69138783e-01f, 2.61458699e-02f, -6.84422404e-02f,
  -4.76868711e-02f, -9.05858502e-02f, 6.72566444e-02f, -2.20420614e-01f, 4.97166961e-02f, 1.23468444e-01f, -8.72277394e-02f, 2.45317481e-02f, 5.24069667e-02f, 2.02998251e-01f,
  1.12149812e-01f, 2.94937044e-01f, -6.52049109e-02f, -6.86320886e-02f, 1.57923058e-01f, 1.79993495e-01f, 1.71543628e-01f, 2.08343342e-01f, 3.09202000e-02f, -1.56666353e-01f,
  6.47012517e-02f, -3.00941337e-02f, 8.42879787e-02f, 4.63582873e-02f, 6.36538863e-02f, -9.97439176e-02f, 7.41041731e-03f, 7.09225535e-02f, 2.33401312e-03f, 1.02337338e-01f,
  1.27511159e-01f, -1.05969325e-01f, 1.00633249e-01f, -1.36261344e-01f, -9.90433842e-02f, 1.04095563e-01f, 7.78774451e-03f, -3.80234979e-02f, -3.48524004e-02f, 1.04132250e-01f,
  1.95114184e-02f, 1.02655366e-01f, -1.52520090e-01f, 6.67473674e-02f, 1.60015076e-01f, -2.58839905e-01f, -3.80700901e-02f, -1.44667447e-01f, -5.73461726e-02f, -3.68645182e-03f,
  -1.55147985e-01f, 8.44251364e-02f, 9.70951915e-02f, 1.35163590e-01f, 4.36403528e-02f, -2.10135281e-01f, -1.51497290e-01f, -6.03432246e-02f, 1.12276465e-01f, 9.54002887e-02f,
  2.77945131e-01f, 2.35269025e-01f, -4.63053957e-02f, -5.81354648e-02f, -1.20880961e-01f, 1.45515606e-01f, 2.83209793e-02f, 2.02499077e-01f, 2.09977940e-01f, -3.80065729e-04f,
  -1.47953585e-01f, -9.95693654e-02f, -8.16633180e-02f, 1.01228297e-01f, 4.93704602e-02f, -1.30255371e-01f, -2.78627388e-02f, -2.72030205e-01f, 1.13258488e-01f, -9.22934525e-03f,
  1.61084518e-01f, -1.66914221e-02f, -6.10609651e-02f, -1.91976070e-01f, -7.47487089e-03f, -7.97346011e-02f, 2.24900376e-02f, 2.86153667e-02f, 1.43534228e-01f, -1.85547754e-01f,
  8.93108081e-03f, 6.20679557e-02f, 4.69667614e-02f, 5.46023957e-02f, 1.53256983e-01f, -9.91213322e-02f, -2.07040589e-02f, -2.81211417e-02f, -7.32067227e-02f, 5.68495579e-02f,
  -2.65520047e-02f, 9.37009454e-02f, -2.94121746e-02f, 2.30483890e-01f, 1.13943025e-01f, 1.79607421e-02f, -3.44714224e-02f, -1.01453200e-01f, 1.24007225e-01f, -1.64976686e-01f,
  1.54816642e-01f, -1.36431828e-02f, -4.75520007e-02f, -1.06400788e-01f, 2.26139836e-02f, -4.46846634e-02f, 1.45896420e-01f, 1.58137605e-01f, 1.76048800e-01f, -2.22007498e-01f,
  -1.06846780e-01f, -2.28036195e-03f, 1.01057515e-01f, 1.52460366e-01f, 1.67471111e-01f, 7.56817758e-02f, -7.44248629e-02f, 3.24486196e-02f, -3.67338732e-02f, 2.03600124e-01f,
  -8.90044589e-03f, 2.83296108e-01f, 2.94583261e-01f, 2.62959272e-01f, -1.15182186e-02f, -1.59580141e-01f, -1.25584289e-01f, -3.83458436e-02f, -6.09997772e-02f, 5.06507456e-02f,
  2.31975883e-01f, -1.82357505e-02f, -3.07231434e-02f, -1.15688004e-01f, -1.61141098e-01f, 4.39116471e-02f, 1.40196055e-01f, 1.34167492e-01f, -7.99895078e-02f, 1.89200789e-02f,
  -1.51620686e-01f, -3.15295532e-02f, -9.86287743e-02f, -1.41330417e-02f, -1.00263566e-01f, -2.23623678e-01f, -7.04235882e-02f, -7.29265809e-02f, -1.84193254e-01f, 3.34837586e-02f,
  -1.33930773e-01f, 4.92255688e-02f, -8.59361514e-03f, -2.43585125e-01f, -7.60659501e-02f, -1.50982767e-01f, 2.32667606e-02f, -1.87282041e-02f, -3.17921370e-01f, 7.23446012e-02f,
  6.24608956e-02f, -6.28509074e-02f, -2.12244704e-01f, 6.51683658e-02f, -4.99919094e-02f, -9.67398658e-02f, 1.36370853e-01f, 1.50632232e-01f, -2.56650168e-02f, 2.82177836e-01f,
  -2.78791100e-01f, -1.01349428e-02f, -2.58988738e-02f, 1.15552008e-01f, 9.04437900e-02f, -1.07163757e-01f, 5.32816760e-02f, -5.24835251e-02f, 1.07515283e-01f, 2.53494382e-01f,
  2.49300674e-01f, -9.73000526e-02f, 1.30546331e-01f, 1.84133098e-01f, 2.44631176e-03f, 3.57414745e-02f, -5.36799803e-02f, -2.24949911e-01f, 1.37398705e-01f, 4.67737280e-02f,
  8.52786303e-02f, -8.82613584e-02f, 1.41236642e-02f, -1.06271267e-01f, 2.30126590e-01f, -4.47843149e-02f, 1.54328570e-01f, 1.07751496e-01f, 1.58270106e-01f, 9.94240642e-02f,
  -7.08654746e-02f, -1.52647421e-01f, -1.03900515e-01f, -8.22180733e-02f, -1.00349173e-01f, 1.92741100e-02f, 6.15769178e-02f, -9.02203619e-02f, -1.02998368e-01f, -1.43100485e-01f,
  1.14840582e-01f, 9.80533063e-02f, -3.13451961e-02f, -1.92402638e-02f, -5.72310500e-02f, 4.61791344e-02f, -3.77903208e-02f, -6.14545727e-03f, -2.35026814e-02f, 4.05060723e-02f,
  1.54876495e-02f, -1.03685610e-01f, -1.17567040e-01f, -8.40977207e-02f, 1.24439582e-01f, -9.90114063e-02f, -5.34418784e-02f, -1.15807075e-02f, 1.71885975e-02f, -3.81753817e-02f,
  8.28577951e-02f, 3.69460769e-02f, 9.47305709e-02f, 2.07415000e-02f, 4.06775856e-03f, 1.02459259e-01f, -5.78028262e-02f, 2.53266513e-01f, -1.96320172e-02f, -7.12049678e-02f,
  -1.15356203e-02f, 2.82354474e-01f, -4.55407239e-02f, -5.23991063e-02f, -2.64071277e-04f, 5.05118147e-02f, 1.51814252e-01f, -5.07465713e-02f, 6.36413991e-02f, 2.27991287e-02f,
  -3.99212874e-02f, 1.95513621e-01f, 1.55703142e-01f, 1.87053736e-02f, 1.25825390e-01f, -1.66029543e-01f, 9.55029801e-02f, -1.43378330e-02f, 5.41457385e-02f, -3.64401713e-02f,
  8.53490233e-02f, 1.70062289e-01f, -1.78278774e-01f, 1.03008002e-01f, 1.33863017e-01f, 7.39826411e-02f, -4.57940511e-02f, 1.31671429e-02f, -4.12936248e-02f, -2.84310058e-02f,
  1.05457775e-01f, 8.05601478e-02f, -2.65191253e-02f, 5.37806116e-02f, -1.20222107e-01f, -7.03668818e-02f, 1.32493125e-02f, 7.36454129e-03f, -6.17716089e-03f, -9.41563025e-02f,
  -1.99619710e-01f, -1.90726109e-03f, 1.01600111e-01f, -1.90611571e-01f, -1.00644909e-01f, -1.64662853e-01f, -2.08673459e-02f, -4.82436940e-02f, -1.32510498e-01f, 3.07345502e-02f,
  3.40750553e-02f, -1.02782935e-01f, -7.05282465e-02f, -6.99809045e-02f, 1.83171168e-01f, -2.28715599e-01f, -1.23352587e-01f, 2.76214406e-02f, -5.91587164e-02f, 3.46875414e-02f,
  -3.82819884e-02f, 2.40433753e-01f, -1.35502711e-01f, -1.71236582e-02f, 1.99282840e-01f, 1.57935038e-01f, 3.03513616e-01f, -6.43192371e-03f, -2.69479364e-01f, -1.14579283e-01f,
  7.37213716e-02f, 5.09768426e-02f, 1.46075279e-01f, 8.49643946e-02f, -9.67514329e-03f, -2.14648657e-02f, -2.82550557e-03f, -1.02860160e-01f, 2.94449687e-01f, -8.28408599e-02f,
  1.41992047e-01f, -3.73246074e-02f, -5.62105849e-02f, -9.36902221e-03f, 1.76314771e-01f, 2.66847849e-01f, 7.66531602e-02f, -3.10116589e-01f, 2.18408376e-01f, 5.22572920e-02f,
  -5.92333786e-02f, 7.63910487e-02f, 4.22127582e-02f, 8.07922035e-02f, -7.15940585e-03f, 2.99311359e-03f, -9.09981877e-02f, 1.58328205e-01f, -1.26161978e-01f, 9.48119443e-03f,
  -5.65512441e-02f, 1.00013457e-01f, 4.57153283e-02f, -3.28528695e-02f, -8.67047980e-02f, -2.39955895e-02f, 5.86926825e-02f, -8.15152004e-02f, 8.68531782e-03f, 2.27506422e-02f,
  1.41443595e-01f, 4.50957660e-03f, -2.24581793e-01f, 1.01975650e-01f, 6.57284334e-02f, 2.54629944e-02f, -5.80717735e-02f, 1.35076344e-01f, -1.97700318e-02f, -1.11835219e-01f,
  -1.21803842e-01f, -1.05816856e-01f, 7.92525113e-02f, 1.84572786e-02f, -1.06914677e-01f, 4.13476117e-02f, -7.71843120e-02f, -7.36470744e-02f, 3.63565087e-02f, 4.08838540e-02f,
  1.44551873e-01f, -3.54547016e-02f, -6.33333772e-02f, -5.08021824e-02f, -9.87873524e-02f, -1.64287612e-01f, 1.10025235e-01f, -6.14926443e-02f, 4.22402918e-02f, 4.53339182e-02f,
  -1.08698197e-01f, 1.92730874e-01f, 4.99063805e-02f, 3.34681839e-01f, 3.99524681e-02f, 2.61888683e-01f, -1.98240906e-01f, -1.08827002e-01f, 1.13185488e-01f, 5.75019754e-02f,
  2.93129355e-01f, -9.85405520e-02f, 5.41849397e-02f, -4.09466885e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -4.86567877e-02f, 4.80468757e-02f, 1.08563816e-02f, -4.26470265e-02f, 1.55416708e-02f, -2.38874666e-02f, 4.17863131e-02f, -2.70072762e-02f, 4.34407890e-02f, 5.36815403e-03f,
  2.00916035e-03f, 5.15255928e-02f, 1.02444634e-01f, 7.92459026e-03f, 5.35836630e-02f, -1.48683079e-02f, 7.01943925e-03f, -5.17294481e-02f, 2.75893733e-02f, 6.80173486e-02f,
  4.43753675e-02f, 2.94816843e-03f, -1.35475118e-03f, 1.08274594e-02f, 2.50169877e-02f, 7.97259733e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -5.22927288e-03f, -1.02822743e-01f, 3.95675376e-02f, -2.10179184e-02f, 4.50248644e-02f, -1.39633000e-01f, -1.47474155e-01f, 1.36941507e-01f, 1.56376049e-01f, 5.47830835e-02f,
  -5.44357188e-02f, -9.33820456e-02f, 3.96268331e-02f, 3.94662507e-02f, -3.96914175e-03f, 6.74782023e-02f, -5.38091622e-02f, 8.28459114e-02f, -2.73567736e-02f, -2.25321904e-01f,
  -2.94182319e-02f, -8.96316469e-02f, 7.13297054e-02f, 3.70623469e-02f, 1.84344172e-01f, -1.67585775e-01f, -3.97924557e-02f, -1.00468099e-01f, 1.32414103e-01f, 8.93684179e-02f,
  -8.79197344e-02f, 1.12674490e-01f, -4.75049950e-02f, -5.50549291e-02f, -1.15373015e-01f, -2.09431812e-01f, -9.33060572e-02f, -2.12021008e-01f, -2.59896636e-01f, 1.11475959e-01f,
  2.29922488e-01f, 1.38247341e-01f, 2.39363670e-01f, -1.62654489e-01f, -3.01926494e-01f, 3.34226042e-01f, -3.35122645e-01f, -2.07008526e-01f, 2.11329591e-02f, -2.15054870e-01f,
  -3.97418320e-01f, -1.25419632e-01f, 1.28841117e-01f, -6.61387146e-02f, -2.36798674e-01f, -2.30339766e-01f, -7.29230642e-02f, 1.08395908e-02f, 3.64150330e-02f, 6.09715059e-02f,
  -3.54696482e-01f, 1.25830695e-01f, 1.07711077e-01f, 4.99905869e-02f, 9.49829593e-02f, -9.66239870e-02f, 1.87869295e-02f, 1.36634940e-02f, -9.35381651e-02f, -1.20320365e-01f,
  1.19115315e-01f, 9.64084864e-02f, -1.58500895e-02f, -1.03710674e-01f, -2.06938729e-01f, -1.14975803e-01f, -8.39429051e-02f, -5.16076991e-03f, 1.45324320e-01f, -2.00422302e-01f,
  1.28929511e-01f, -4.87027429e-02f, 9.24032778e-02f, -1.00571215e-01f, 7.00617358e-02f, -1.91052318e-01f, 3.53530981e-02f, 7.62404576e-02f, -8.35887566e-02f, -7.24046901e-02f,
  -9.81145650e-02f, 1.41049922e-01f, 1.24415055e-01f, 2.40076467e-01f, -7.87266181e-04f, -2.47510523e-01f, 1.90654434e-02f, 1.60042588e-02f, -2.16830090e-01f, 7.15697184e-02f,
  1.93102106e-01f, -2.36576065e-01f, 1.95677876e-01f, -8.80957674e-03f, 8.17997009e-02f, -3.07716280e-02f, 2.03837901e-01f, -2.00727489e-02f, -3.82015765e-01f, -4.60502625e-01f,
  -2.98298210e-01f, -2.28055790e-01f, -1.77278765e-03f, 7.61027485e-02f, 3.94296534e-02f, 8.18038046e-01f, 3.57524655e-03f, 9.58650336e-02f, -2.28893608e-01f, 3.52296121e-02f,
  -1.62086517e-01f, 1.50207505e-01f, -2.59196609e-01f, -2.46556431e-01f, -3.18087101e-01f, 9.39628780e-02f, 1.95296273e-01f, 1.23606578e-01f, 8.00968483e-02f, -7.87889063e-02f,
  -4.98614572e-02f, 1.53551772e-01f, -1.02958351e-01f, -7.28126168e-02f, -2.56241024e-01f, 9.98900644e-03f, -8.58484134e-02f, 3.11544556e-02f, 1.92435786e-01f, 4.41826843e-02f,
  -9.19385105e-02f, -5.71853183e-02f, -1.86507583e-01f, -1.32026449e-01f, -1.07531399e-01f, -6.58502653e-02f, -1.83248241e-02f, -1.58481643e-01f, 4.19642217e-02f, -2.16803402e-02f,
  1.29857600e-01f, -1.34291127e-01f, -1.38877839e-01f, 1.13896437e-01f, -6.55112863e-02f, -4.29832190e-02f, -4.08286713e-02f, 7.88936615e-02f, -8.04707259e-02f, 3.90151925e-02f,
  -6.71720207e-02f, -5.16238324e-02f, 1.41542390e-01f, -1.83603823e-01f, 1.24354109e-01f, 2.08271921e-01f, 1.82912394e-01f, 1.09842658e-01f, 8.29736739e-02f, 1.65115014e-01f,
  -3.69231641e-01f, -3.06946814e-01f, -2.45255128e-01f, 2.00487822e-01f, -1.05151504e-01f, -2.43168354e-01f, -3.19513053e-01f, 2.49284059e-01f, -2.34217593e-03f, -2.32114956e-01f,
  -1.24581955e-01f, 8.50310624e-02f, -6.58186153e-02f, -2.26515129e-01f, 1.15567535e-01f, -2.69946712e-03f, -3.20149273e-01f, -5.11162519e-01f, 2.34379768e-01f, 1.78852797e-01f,
  -1.05537407e-01f, -3.20184678e-02f, -4.48003784e-02f, 6.30598217e-02f, -1.29078612e-01f, -3.43989655e-02f, -1.16364732e-02f, 1.88736506e-02f, -1.87098458e-02f, -7.48888925e-02f,
  6.18513823e-02f, -6.69336971e-03f, 1.21309504e-01f, -2.93201022e-02f, 2.69604381e-02f, -1.79130599e-01f, -4.32691015e-02f, -7.91669115e-02f, -1.03394836e-01f, -7.52679771e-03f,
  -8.24270844e-02f, 3.19164917e-02f, 3.02631557e-01f, -1.57687161e-02f, -2.21239224e-01f, -1.55448774e-02f, -2.04728127e-01f, -1.11956008e-01f, -2.10534498e-01f, -1.66018471e-01f,
  -2.63742171e-02f, -8.50884467e-02f, 1.63809538e-01f, 1.71448171e-01f, 6.48262026e-03f, 2.00394705e-01f, 1.04287438e-01f, -2.82374859e-01f, 1.62605438e-02f, 1.31075099e-01f,
  -7.40046799e-02f, -3.75124156e-01f, -2.82447547e-01f, -3.30607533e-01f, 2.59210348e-01f, -5.14293946e-02f, 5.14564551e-02f, 2.01151624e-01f, 2.26259977e-01f, -1.32042348e-01f,
  -1.66982234e-01f, -4.93860453e-01f, -3.64689648e-01f, -1.51885990e-02f, 1.62373826e-01f, -4.99637127e-01f, 8.57698619e-02f, -3.41221169e-02f, -1.89343411e-02f, -4.35861766e-01f,
  1.05632983e-01f, 1.15223117e-01f, 1.17361531e-01f, -2.75367826e-01f, 1.50203845e-02f, -2.67384499e-02f, 1.77179918e-01f, 4.64496911e-02f, -2.88743973e-02f, -4.42458466e-02f,
  1.07323661e-01f, -5.11509813e-02f, 6.93989247e-02f, 1.64935350e-01f, -1.55217960e-01f, 1.03728965e-01f, -1.99956261e-02f, 2.14857403e-02f, -7.90218916e-03f, 2.49792218e-01f,
  -1.59267858e-01f, 6.49423525e-02f, 1.41156420e-01f, 2.72199977e-02f, 1.96400270e-01f, -1.86849236e-01f, -2.63289243e-01f, -4.18878824e-01f, 2.13502556e-01f, -3.65519583e-01f,
  -1.69200182e-01f, -1.70885846e-01f, 1.24801889e-01f, 2.27770492e-01f, -2.93653488e-01f, -9.33995768e-02f, 2.23989531e-01f, -9.96359661e-02f, 1.25197172e-01f, -2.13435858e-01f,
  1.34895682e-01f, 1.78543739e-02f, 8.57214332e-02f, -1.68046400e-01f, -3.79995480e-02f, -4.72353958e-02f, -1.67319030e-01f, 2.06203729e-01f, -2.94178218e-01f, 2.07698748e-01f,
  2.26360008e-01f, 2.17134669e-01f, 5.80290146e-02f, 6.31702766e-02f, 8.36434588e-03f, -1.48890406e-01f, 2.79480536e-02f, -5.43154739e-02f, 2.56072879e-01f, 1.47209510e-01f,
  2.09003314e-01f, -3.52123559e-01f, -2.27201387e-01f, -1.22187853e-01f, 1.87458292e-01f, 1.53584078e-01f, -3.27187866e-01f, -6.14853539e-02f, -2.42094815e-01f, -8.02766681e-02f,
  4.22391715e-03f, 3.57351415e-02f, 1.79817989e-01f, 4.92254905e-02f, 3.31774913e-02f, 2.39133146e-02f, -4.72247042e-02f, -1.21364042e-01f, 2.00343773e-01f, 1.23145983e-01f,
  9.91428718e-02f, 3.00644170e-02f, 9.77898613e-02f, 1.31061375e-01f, 1.77565277e-01f, 1.49980858e-01f, -1.81257144e-01f, -1.14195645e-01f, 1.15400791e-01f, 3.81232619e-01f,
  -2.34895483e-01f, 2.19042048e-01f, 5.90528473e-02f, 2.25952581e-01f, -1.33119449e-01f, -2.45519578e-01f, 1.72707707e-01f, 1.57172173e-01f, 1.59195781e-01f, 2.69697327e-03f,
  -6.15451150e-02f, 1.62667900e-01f, -2.73745209e-01f, -1.14275903e-01f, 1.40655383e-01f, 1.35134026e-01f, -1.90138265e-01f, -2.52322704e-01f, 1.26751149e-02f, -1.45303085e-01f,
  9.83970985e-02f, -2.48326063e-01f, 2.61252046e-01f, -1.06573682e-02f, 1.15529805e-01f, -4.30119663e-01f, -1.73408598e-01f, 3.20321582e-02f, 3.33316475e-01f, -2.99645871e-01f,
  2.66040772e-01f, -1.93178475e-01f, -5.67321219e-02f, -2.54234392e-02f, -3.85651916e-01f, -2.58372929e-02f, -2.23652825e-01f, 2.29549229e-01f, 1.38286918e-01f, 2.48753965e-01f,
  -4.49145526e-01f, -2.60087736e-02f, -2.25095496e-01f, 9.09625441e-02f, -8.39007944e-02f, 1.71510443e-01f, -1.11887701e-01f, 6.82928935e-02f, 7.77151138e-02f, 1.14419669e-01f,
  2.09589023e-02f, 1.47544304e-02f, -1.76800489e-01f, 2.01003283e-01f, -6.74032643e-02f, -5.08034825e-02f, -1.67970017e-01f, -1.48541391e-01f, 2.01633684e-02f, 1.61089450e-01f,
  6.03890829e-02f, -4.12597656e-02f, -7.03704581e-02f, 1.60395086e-01f, -3.34072858e-02f, 1.31545067e-01f, 2.39117965e-01f, 1.17689356e-01f, 2.07397178e-01f, 2.79081225e-01f,
  -2.09759295e-01f, 9.32831503e-03f, 1.13481149e-01f, -1.62488386e-01f, -1.62257433e-01f, -1.20626852e-01f, -1.39695350e-02f, -1.70346051e-01f, -1.41114816e-01f, 7.65081719e-02f,
  -1.26514509e-01f, 2.15521306e-01f, -2.19519854e-01f, -1.90003231e-01f, -3.82717580e-01f, 4.61621098e-02f, -3.47819090e-01f, 1.50784642e-01f, 1.33392513e-01f, -3.09150040e-01f,
  2.77180113e-02f, -3.42775464e-01f, -2.14045778e-01f, 2.43928388e-01f, 2.96161622e-01f, -7.44809806e-02f, -9.27903317e-03f, -1.08411811e-01f, 9.86014307e-02f, -2.87462950e-01f,
  -3.33025187e-01f, 2.17546612e-01f, -4.63260561e-02f, -3.35813254e-01f, 9.12008286e-02f, -2.82497674e-01f, -3.59319538e-01f, 1.44443870e-01f, 1.05759531e-01f, 8.86400789e-02f,
  1.10497877e-01f, 3.69083248e-02f, 5.04961684e-02f, -1.20425560e-01f, -1.12331070e-01f, -6.82685450e-02f, -3.74836512e-02f, 9.57849324e-02f, 8.28572288e-02f, -6.75975084e-02f,
  -4.74968133e-03f, -2.10958775e-02f, 1.49878383e-01f, 1.02132753e-01f, -1.00818574e-02f, 7.07980692e-02f, -1.32673115e-01f, -8.95610731e-03f, 2.33663186e-01f, 5.85817434e-02f,
  7.85463825e-02f, 9.43171605e-02f, -2.31814682e-01f, -1.50449991e-01f, 8.79231095e-02f, 1.95549101e-01f, 1.75632522e-01f, -1.12673871e-01f, 5.03557250e-02f, 2.78870195e-01f,
  2.32667178e-01f, -7.03883991e-02f, 6.46496704e-03f, 1.43868536e-01f, -1.32572442e-01f, -1.46491498e-01f, -8.23644269e-03f, 1.96275055e-01f, -1.25932351e-01f, -2.49388784e-01f,
  8.26741233e-02f, -2.00444922e-01f, 1.82223767e-01f, -7.82001689e-02f, 2.60399431e-01f, 3.50317121e-01f, -2.35408112e-01f, -3.16819578e-01f, -2.19629690e-01f, -1.64714202e-01f,
  1.52810261e-01f, -2.76916504e-01f, -3.19157004e-01f, 1.88140467e-01f, 3.67933035e-01f, -2.67138511e-01f, -3.28594089e-01f, 9.61901918e-02f, -2.53460616e-01f, -8.44343826e-02f,
  -2.36835286e-01f, -3.26041073e-01f, -1.67009652e-01f, -2.31397953e-02f, -2.24429548e-01f, -9.71563086e-02f, -3.83232050e-02f, -1.19997533e-02f, -1.10437078e-02f, -4.54276167e-02f,
  -5.89575730e-02f, 1.09525420e-01f, 3.01849023e-02f, -4.30898108e-02f, -9.97955352e-02f, -6.03326447e-02f, -3.95625234e-02f, -1.62101790e-01f, -3.98195907e-02f, -1.17694415e-01f,
  2.41027097e-03f, -2.90233549e-02f, 4.79712756e-03f, -8.02412555e-02f, -1.75273642e-01f, -1.37678161e-01f, 2.45001346e-01f, 9.24900696e-02f, -8.77339169e-02f, 1.18585788e-02f,
  4.05269898e-02f, -1.59264803e-01f, -8.59357566e-02f, -4.58837971e-02f, 1.39570639e-01f, -4.62355800e-02f, 1.05825901e-01f, -1.00442082e-01f, 4.46765497e-02f, -7.80120715e-02f,
  1.63847819e-01f, -5.53465784e-02f, 1.51333511e-01f, 8.02918710e-03f, 1.00571230e-01f, -3.10141772e-01f, -3.29936206e-01f, -6.15403503e-02f, -3.85551415e-02f, 2.19421476e-01f,
  1.93345442e-01f, -8.20398405e-02f, -2.21536130e-01f, -1.51048154e-01f, -2.66718179e-01f, 1.03732705e-01f, -6.68269023e-02f, 2.72832990e-01f, 1.96105376e-01f, -1.30446404e-01f,
  -2.77497888e-01f, -7.91907981e-02f, 2.29137298e-02f, 1.75064504e-01f, -9.31382403e-02f, -3.85151416e-01f, 2.18597278e-02f, -1.76171184e-01f, -2.03428537e-01f, -3.72664109e-02f,
  6.25173226e-02f, 1.14983976e-01f, 8.46059620e-02f, 1.07353896e-01f, -1.61322862e-01f, -7.75894895e-02f, -4.01542746e-02f, 1.42019019e-01f, -1.25934839e-01f, -8.17989111e-02f,
  -1.85265228e-01f, -2.07957074e-01f, 2.02071760e-02f, -1.21419013e-01f, 1.00461014e-01f, 2.48473048e-01f, -3.32165807e-02f, 2.86496758e-01f, 4.44523059e-02f, 1.74200743e-01f,
  1.47908628e-01f, 1.89738736e-01f, 5.89284599e-02f, 3.58346221e-03f, 2.23808095e-01f, -5.46748117e-02f, 1.67155251e-01f, -9.81556773e-02f, -1.77220613e-01f, 1.33181602e-01f,
  -2.05660183e-02f, 2.09294394e-01f, -1.37032494e-01f, -2.36984808e-03f, -2.83891767e-01f, 3.22210073e-01f, -3.04291267e-02f, 3.87025587e-02f, -2.71461934e-01f, -1.15464255e-01f,
  2.77305156e-01f, 2.63733834e-01f, -3.08699131e-01f, -3.32439318e-02f, 4.17297818e-02f, 7.38853812e-02f, -6.98062330e-02f, -8.14287215e-02f, -2.99569547e-01f, -1.02006413e-01f,
  -3.35776299e-01f, -2.42983624e-01f, 2.67057240e-01f, -9.38623697e-02f, -2.25939482e-01f, -2.54986554e-01f, -3.55558187e-01f, -2.65821934e-01f, -4.12742704e-01f, 1.76603153e-01f,
  -2.07288966e-01f, -2.27750186e-02f, -6.30222559e-02f, -6.99477829e-03f, -1.31339639e-01f, -1.17706813e-01f, 1.24073729e-01f, -1.40643284e-01f, 2.18285590e-01f, 1.04615673e-01f,
  -6.12470414e-03f, -1.31036595e-01f, -1.24512561e-01f, 1.59047812e-01f, 2.28959620e-02f, 8.21228027e-02f, 6.70062751e-02f, -2.15744153e-01f, -1.18798628e-01f, -1.53578892e-01f,
  -9.79437605e-02f, -8.14852193e-02f, -2.24119484e-01f, -2.46873856e-01f, 9.53476802e-02f, -2.91371830e-02f, 5.63079454e-02f, -1.67161673e-01f, -2.28313014e-01f, 1.90952554e-01f,
  -7.28463456e-02f, -1.76229581e-01f, 3.07581294e-02f, 1.89275742e-01f, 1.27953142e-01f, -2.44810835e-01f, 1.26394138e-01f, 7.41133913e-02f, -8.29070732e-02f, -2.68114269e-01f,
  -2.45038360e-01f, -3.24384496e-02f, 2.49207497e-01f, 7.06371143e-02f, -3.85846764e-01f, -2.03849986e-01f, 8.08129385e-02f, -4.24414515e-01f, -3.69968742e-01f, 1.76015571e-01f,
  4.84600589e-02f, -9.85615477e-02f, 1.84934676e-01f, 5.30518517e-02f, 1.19177185e-01f, 6.97462186e-02f, -4.08155352e-01f, 4.95476797e-02f, 1.92405432e-01f, -1.69723541e-01f,
  4.74462919e-02f, -1.30930126e-01f, 3.41001332e-01f, 8.52285326e-02f, 1.05340503e-01f, 1.30449474e-01f, 2.23152801e-01f, -7.50723407e-02f, -9.42420438e-02f, 1.13070190e-01f,
  3.67513560e-02f, 1.19855054e-01f, 1.26330614e-01f, -7.49101043e-02f, -4.86359671e-02f, -1.21232964e-01f, 1.09469995e-01f, -5.64733939e-03f, 8.41376856e-02f, 1.31079286e-01f,
  -4.14638128e-03f, 7.29927272e-02f, 1.91365965e-02f, -1.42409623e-01f, 8.02544206e-02f, -1.07112244e-01f, -2.04682648e-01f, -3.74256521e-02f, 5.63779771e-02f, -5.95574751e-02f,
  -1.75496414e-01f, 6.42450973e-02f, -2.08854824e-01f, -1.08152561e-01f, -1.08758762e-01f, 9.69262049e-02f, 1.67090192e-01f, 1.75225381e-02f, 9.72938836e-02f, 1.92780644e-01f,
  1.86505228e-01f, 2.20491067e-01f, -1.71825811e-01f, -3.46178085e-01f, -3.42367321e-01f, -3.20870996e-01f, -2.54500389e-01f, 1.98854208e-01f, -6.25129640e-02f, -4.48606253e-01f,
  4.44834419e-02f, -8.70273560e-02f, 2.25930661e-01f, -1.87216431e-01f, 9.29858238e-02f, -1.15989476e-01f, -1.43032998e-01f, -4.88057360e-02f, 1.49642453e-01f, 2.77272642e-01f,
  2.49583080e-01f, -2.86290050e-02f, 8.30842331e-02f, 1.32705225e-02f, 2.44375467e-01f, 1.45728309e-02f, -4.25873548e-01f, -3.68639886e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  8.44401643e-02f, -7.83409998e-02f, -9.59674269e-02f, 1.04790600e-02f, -2.96660494e-02f, 1.05577549e-02f, 1.43892482e-01f, -3.88349630e-02f, -5.33392653e-02f, -1.09488945e-02f,
  -8.07923228e-02f, -5.88707700e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    