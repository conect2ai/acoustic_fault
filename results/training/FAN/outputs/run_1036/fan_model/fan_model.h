/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.80696154e-01f, -3.19186240e-01f, 3.01039731e-03f, -1.67402133e-01f, 1.46281004e-01f, 1.93512172e-01f, 1.54945608e-02f, 1.51698992e-01f, -1.86397415e-02f, -1.34313360e-01f,
  -7.31348097e-02f, 3.64363715e-02f, 2.51455139e-02f, 1.16444327e-01f, 9.99841914e-02f, 3.21788602e-02f, 1.89757213e-01f, 3.87854874e-02f, 5.15813418e-02f, 2.33823642e-01f,
  6.25137240e-02f, -2.47376800e-01f, -1.80916175e-01f, 5.54591678e-02f, -5.11367945e-03f, 1.54454142e-01f, 6.52534142e-02f, -2.03801952e-02f, 1.11031987e-01f, -1.57743618e-02f,
  -7.19467402e-02f, -2.34244660e-01f, 1.76550552e-01f, -2.83901207e-02f, 4.12176661e-02f, -7.97159672e-02f, -4.30294685e-02f, -9.83970091e-02f, 1.59762017e-02f, -1.19774146e-02f,
  1.31243737e-02f, 4.80571240e-02f, -1.52270840e-02f, 3.41573060e-02f, -1.44521017e-02f, -8.09214786e-02f, -1.76191013e-02f, 1.11021074e-02f, -7.71450810e-03f, -1.29686249e-02f,
  9.12637636e-02f, 4.74016592e-02f, -1.65882662e-01f, 3.55303325e-02f, 3.68014276e-02f, 1.18720911e-01f, -4.05870676e-02f, 1.00828514e-01f, -4.64269407e-02f, -9.70903113e-02f,
  1.77328866e-02f, -1.99213810e-02f, 1.46105131e-02f, -6.78843483e-02f, -3.40308994e-02f, 3.86257693e-02f, 5.51664755e-02f, 2.55451333e-02f, -2.32694242e-02f, -6.49515986e-02f,
  -1.96199846e-02f, 9.19316616e-03f, 1.71029493e-02f, -5.57090901e-02f, 5.04497960e-02f, -6.63968027e-02f, 3.27568799e-02f, -1.82323884e-02f, 9.86637268e-03f, -6.27268478e-02f,
  -4.38015722e-02f, -4.49851453e-02f, -7.66339749e-02f, 2.87073441e-02f, 1.07888021e-02f, 3.88707127e-03f, -3.26014981e-02f, 7.05462974e-03f, -8.37572217e-02f, -9.07147229e-02f,
  -1.68791696e-01f, 5.69132306e-02f, -2.10319497e-02f, 1.68430246e-02f, 4.19412414e-03f, -9.67509579e-03f, -3.07173654e-02f, 3.20862681e-02f, -2.28798464e-02f, -1.00301271e-02f,
  -3.24003287e-02f, -6.47520423e-02f, -7.58855939e-02f, 7.89936483e-02f, -1.12537818e-03f, 6.58803731e-02f, -2.45570149e-02f, 9.78382602e-02f, 6.29131645e-02f, 3.18938382e-02f,
  -2.11220589e-02f, 2.09214520e-02f, -1.09147966e-01f, -3.60389128e-02f, 6.49923179e-03f, -5.17339632e-02f, 4.12142090e-02f, -2.15600245e-02f, -9.97537654e-03f, -1.82363689e-01f,
  2.13484883e-01f, -8.56705159e-02f, -4.19273913e-01f, -7.84300640e-02f, -1.74878538e-01f, -2.49920651e-01f, -3.65877151e-01f, -3.54155563e-02f, 9.01306644e-02f, -1.80058405e-01f,
  3.66472080e-02f, 3.40664536e-01f, 2.47131020e-01f, 1.96286127e-01f, 7.05876648e-02f, -2.75146484e-01f, -2.29502767e-01f, -6.04546703e-02f, 1.05339237e-01f, 1.15274437e-01f,
  1.79987416e-01f, 1.05660915e-01f, 4.38106470e-02f, 1.47862986e-01f, -1.27479151e-01f, 1.30767390e-01f, -1.65408120e-01f, -1.21975034e-01f, 7.37100393e-02f, -2.48866051e-01f,
  -1.11057729e-01f, -2.97060460e-01f, -3.98743153e-02f, 1.59006432e-01f, 6.22109920e-02f, 5.31805381e-02f, 5.00131100e-02f, 5.19063771e-02f, 6.37164414e-02f, -6.38416708e-02f,
  -5.83300740e-02f, 4.58612964e-02f, 2.40950231e-02f, -9.43014957e-03f, -9.77731347e-02f, -1.06008071e-02f, -5.13415039e-02f, -6.02639355e-02f, -5.71057163e-02f, -7.76082575e-02f,
  4.88372780e-02f, -1.69338137e-01f, -1.56434119e-01f, -3.75974849e-02f, 2.83812080e-02f, 5.21804625e-03f, -8.10681880e-02f, -9.43546891e-02f, 1.41655467e-02f, -1.23365492e-01f,
  7.52038136e-02f, -2.01635957e-02f, -1.86840910e-02f, -8.42346847e-02f, 4.58932854e-02f, -4.53675464e-02f, -4.52820770e-02f, -3.01299263e-02f, 2.19416525e-02f, -4.89148721e-02f,
  5.00411773e-03f, -9.39558074e-02f, 3.78392823e-02f, -6.47252724e-02f, 3.72051150e-02f, -2.18033940e-02f, 3.56048867e-02f, 4.44769636e-02f, -5.26753403e-02f, -3.88328242e-03f,
  1.62210390e-02f, -3.29523683e-02f, 5.89109119e-03f, -1.46053210e-02f, -3.68131436e-02f, 3.15832868e-02f, -6.49383441e-02f, 7.39145130e-02f, 1.34349987e-01f, 9.59813520e-02f,
  1.89640731e-01f, -2.57941280e-02f, -2.98698340e-02f, 4.41912673e-02f, 3.54579389e-02f, 6.02331981e-02f, 5.24523854e-02f, 5.07674366e-02f, 4.15239520e-02f, 6.37030648e-03f,
  6.74469862e-03f, 1.53210731e-02f, 3.60069685e-02f, 1.20180082e-02f, 4.01277617e-02f, 1.43632875e-03f, 1.72164857e-01f, 2.83065569e-02f, 7.27113485e-02f, 1.21680185e-01f,
  2.69428398e-02f, 5.10103554e-02f, 5.31587265e-02f, 1.35857919e-02f, -3.40663940e-02f, 1.16913684e-01f, 4.04216647e-02f, 6.68178424e-02f, 7.21654445e-02f, 1.15892872e-01f,
  4.43875670e-01f, -2.62064606e-01f, -1.97416514e-01f, 1.31445229e-01f, -1.17012195e-01f, -2.01557517e-01f, -4.08802658e-01f, -7.13202953e-02f, 1.73861608e-01f, -2.53931165e-01f,
  4.76799496e-02f, 2.59314001e-01f, 1.63069472e-01f, 2.19745710e-01f, 8.07159543e-02f, -3.33851159e-01f, -3.09777856e-01f, 8.69570151e-02f, 4.10491616e-01f, 1.54275447e-01f,
  5.87450154e-03f, 3.15145031e-02f, 1.11014433e-01f, 1.12598218e-01f, -2.18563154e-01f, 1.33973435e-01f, -2.26544619e-01f, -1.18734702e-01f, -4.23607267e-02f, -4.60369736e-01f,
  1.06051877e-01f, 1.87194481e-01f, 1.04727559e-01f, 7.81799778e-02f, -1.78172458e-02f, 1.03593729e-01f, 1.06036440e-01f, -8.53409618e-02f, 3.94074172e-02f, -1.16127528e-01f,
  7.05423579e-02f, 7.25283623e-02f, 4.49382178e-02f, -2.40965337e-02f, -5.09980358e-02f, 6.12057783e-02f, -1.02050163e-01f, 7.84763973e-03f, 8.03252608e-02f, 2.07864237e-03f,
  -5.01510734e-03f, -1.00533210e-01f, 3.65312248e-02f, -3.92032638e-02f, 3.93832698e-02f, 7.79467523e-02f, -1.03454143e-01f, 4.71167155e-02f, 5.42847328e-02f, -1.62957758e-01f,
  -6.74091205e-02f, -1.09676898e-01f, -3.06478149e-04f, -6.46569654e-02f, -2.40314938e-02f, -1.53485369e-02f, 1.76922642e-02f, 4.80932482e-02f, 3.55348811e-02f, -5.97398821e-03f,
  3.32471095e-02f, 3.81436199e-02f, 7.28268251e-02f, 4.22098637e-02f, -1.19756973e-04f, -2.94270907e-02f, -1.27682360e-02f, -3.10776243e-03f, 8.35482627e-02f, -2.88683530e-02f,
  9.33176205e-02f, 4.74670865e-02f, -4.04575318e-02f, 4.72862050e-02f, -6.00268506e-02f, 7.48200156e-03f, -5.80940256e-03f, 5.93658090e-02f, -3.72164585e-02f, -4.86494526e-02f,
  1.37405366e-01f, 2.52476752e-01f, 7.63623789e-02f, 9.53650773e-02f, 2.77382061e-02f, 4.52560224e-02f, 2.89090276e-02f, 7.36139864e-02f, 3.80265675e-02f, 4.72470559e-02f,
  3.63139696e-02f, 1.17480598e-01f, 3.51197049e-02f, -7.10309148e-02f, -2.20373571e-02f, 5.98830963e-03f, -4.21565026e-03f, 6.07439801e-02f, 4.97460999e-02f, 3.10738124e-02f,
  -1.01172842e-01f, -6.09117858e-02f, 1.44116253e-01f, 2.13626530e-02f, 1.13011383e-01f, 1.28076717e-01f, -2.52216049e-02f, -1.72685925e-02f, 1.83921769e-01f, -9.35196280e-02f,
  -6.07990474e-03f, -9.19170529e-02f, -1.33618921e-01f, 2.93636382e-01f, 2.91566215e-02f, -2.54921496e-01f, -3.00408244e-01f, 1.16881505e-02f, 9.01340470e-02f, -1.21241815e-01f,
  -1.93108380e-01f, 1.27525568e-01f, 8.76911730e-02f, 2.37126604e-01f, 1.19005799e-01f, -2.83553544e-02f, 1.45528287e-01f, 2.85083055e-01f, 2.50501186e-01f, 2.05914587e-01f,
  2.25490481e-01f, 1.93073481e-01f, 2.62795001e-01f, 2.03568026e-01f, 1.35365114e-01f, 5.51469810e-03f, -1.91054448e-01f, -1.21440692e-02f, -2.43822020e-02f, 1.68797255e-01f,
  -1.08413976e-02f, -2.37746835e-02f, 1.64835498e-01f, 1.37625501e-01f, 7.63469338e-02f, 1.35362744e-01f, 5.71726076e-03f, 1.66845992e-01f, 8.82076845e-02f, 1.72089458e-01f,
  8.22739378e-02f, 1.76993370e-01f, 1.56510010e-01f, 1.34313151e-01f, 8.12359825e-02f, 8.90488699e-02f, 1.68280199e-01f, 1.23097576e-01f, 1.71725437e-01f, 7.52170384e-02f,
  3.08433831e-01f, 2.00865075e-01f, 5.39509729e-02f, 3.96979041e-02f, 1.25487000e-01f, 2.18140036e-01f, 4.31051552e-02f, 9.86984894e-02f, 2.26003081e-02f, -2.20646374e-02f,
  3.86714078e-02f, -1.70202553e-02f, -4.16029282e-02f, -3.61162610e-02f, 1.40454834e-02f, -6.60079718e-02f, 1.41925663e-02f, -4.51362208e-02f, 6.03403561e-02f, -2.89800167e-02f,
  -5.63846296e-03f, -8.43671337e-02f, -1.93412565e-02f, 3.03489808e-02f, -2.78382972e-02f, -6.53065916e-04f, -2.38381568e-02f, 2.43558865e-02f, 5.31142838e-02f, -9.26543251e-02f,
  1.67956147e-02f, 1.23569649e-03f, -5.25684841e-03f, 5.41254878e-02f, 3.47987190e-03f, 1.70598067e-02f, 1.00276567e-01f, 1.24170467e-01f, -5.68606798e-03f, -4.11007702e-02f,
  -1.84967481e-02f, -1.39468685e-02f, -4.92623262e-02f, 1.06433742e-01f, -3.96839119e-02f, 7.54094403e-03f, 2.47164350e-02f, 4.86589409e-02f, 3.42066889e-03f, 1.40041515e-01f,
  2.68714223e-02f, 6.62865639e-02f, -7.97381334e-04f, 7.44498447e-02f, 1.64056849e-02f, 3.33287269e-02f, 3.36456951e-03f, 4.83963899e-02f, 3.31653282e-02f, 4.97908853e-02f,
  1.50241107e-01f, -7.80325234e-02f, -1.61399115e-02f, -4.99403477e-02f, -1.53255081e-02f, -3.76984589e-02f, -4.06453796e-02f, -1.07079959e-02f, -7.88621255e-04f, -1.99324563e-01f,
  1.13399485e-02f, -2.15684205e-01f, -3.33953500e-01f, 7.48820379e-02f, -2.67915465e-02f, 5.05402200e-02f, -1.26065135e-01f, -2.59773191e-02f, -3.94469639e-03f, -1.80157959e-01f,
  -2.57658474e-02f, 1.62077591e-01f, 1.77716881e-01f, 7.56198466e-02f, 1.26731843e-01f, -2.84099072e-01f, -1.71127841e-01f, 1.53606478e-02f, 1.22720644e-01f, -1.25290509e-02f,
  1.12585142e-01f, 4.92224209e-02f, 6.18020073e-02f, 3.13077644e-02f, -1.33082151e-01f, 1.75537065e-01f, -2.63817757e-01f, -1.16810307e-01f, -6.27910495e-02f, -2.54839092e-01f,
  -1.33120820e-01f, -3.49778444e-01f, 1.45676091e-01f, 1.03056915e-01f, -8.54963958e-02f, -9.51477606e-03f, -3.58177796e-02f, -8.82785097e-02f, -1.51776774e-02f, -1.16662383e-01f,
  -3.83653529e-02f, -7.59205297e-02f, 7.16852620e-02f, 8.67032632e-03f, 3.92133407e-02f, -9.80662331e-02f, 2.27227993e-02f, -3.83753632e-03f, -5.49662448e-02f, -8.99917558e-02f,
  -6.22312315e-02f, -2.08259206e-02f, -1.72189936e-01f, 9.41435155e-03f, -2.58216001e-02f, 4.20415513e-02f, -1.46874607e-01f, -4.74286079e-02f, 3.47517361e-03f, -2.35059038e-01f,
  2.72681611e-03f, -3.45527939e-02f, -3.61162564e-03f, -8.08233991e-02f, -2.56513488e-02f, -2.81724781e-02f, 3.15317214e-02f, 1.01414464e-01f, 2.97221076e-02f, -1.00033641e-01f,
  5.26652634e-02f, -9.01442021e-02f, 3.99235263e-02f, 3.03146224e-02f, -2.57330127e-02f, -6.72555119e-02f, 6.53905571e-02f, -6.88626617e-02f, -2.83868220e-02f, 3.25798756e-03f,
  -8.26503057e-03f, 2.75442600e-02f, 3.65127064e-02f, 1.61816254e-02f, 4.88093589e-03f, -7.87815973e-02f, -3.46032791e-02f, -7.61805996e-02f, 7.45593011e-03f, -2.34856568e-02f,
  1.52302429e-01f, 5.00633232e-02f, -1.14343412e-01f, -8.35765526e-03f, -2.99928593e-03f, -1.76627170e-02f, -1.57356504e-02f, 9.57768038e-03f, -2.42540166e-02f, -1.59076735e-01f,
  -2.70326603e-02f, -3.01169381e-02f, 2.81859525e-02f, -1.92700152e-03f, -6.86399713e-02f, 2.12937631e-02f, -4.60805818e-02f, 1.73152104e-01f, 1.64269600e-02f, -1.57460168e-01f,
  1.98991634e-02f, 5.17729856e-02f, 5.26763126e-02f, -5.36827603e-03f, -1.43981978e-01f, 9.36933886e-03f, -6.57792315e-02f, -1.26928538e-01f, 6.44409806e-02f, -7.87236989e-02f,
  1.53776646e-01f, -1.34756178e-01f, 4.62019891e-02f, 1.69118702e-01f, 3.61812189e-02f, -1.77505866e-01f, -1.45530865e-01f, -1.42425090e-01f, -6.22123890e-02f, 6.96772337e-03f,
  -1.11518122e-01f, -1.31089911e-01f, -2.37545371e-01f, -7.16641769e-02f, -2.38770656e-02f, 6.01534806e-02f, 1.90457314e-01f, 1.46472543e-01f, -2.39267908e-02f, -1.20699136e-02f,
  4.82944250e-02f, 2.04295233e-01f, 1.84183419e-01f, 1.57186225e-01f, 2.64242828e-01f, 3.75789590e-02f, 2.12532625e-01f, 1.77844331e-01f, 9.07716975e-02f, 3.69942129e-01f,
  4.61413823e-02f, 7.66613483e-02f, -1.00900799e-01f, 5.37947789e-02f, -1.53823467e-02f, -3.57442647e-02f, 5.67344986e-02f, 1.42115384e-01f, -1.28005063e-02f, 5.84595948e-02f,
  1.05368964e-01f, 3.74559104e-03f, -3.85854468e-02f, 6.45059124e-02f, 6.00144453e-02f, 1.03862904e-01f, 2.21552085e-02f, 3.66954729e-02f, 6.68785125e-02f, -2.25077905e-02f,
  -1.18838775e-03f, 2.82702278e-02f, 4.44691218e-02f, -7.62237385e-02f, 2.31638234e-02f, -8.31811279e-02f, -6.90976456e-02f, 2.98446901e-02f, 7.33778551e-02f, 1.86436206e-01f,
  5.51972203e-02f, 4.65497971e-02f, 5.35261519e-02f, -3.01892348e-02f, 4.89625707e-02f, 1.37028741e-02f, 6.96320087e-02f, 9.72460434e-02f, -2.98049692e-02f, 8.20817873e-02f,
  -3.22343856e-02f, -5.17926253e-02f, 5.96759021e-02f, 5.71328215e-02f, 3.46961170e-02f, 7.16081783e-02f, 8.18205625e-03f, -7.82490596e-02f, -3.70839424e-02f, 1.00822337e-01f,
  -8.51595700e-02f, -6.91339374e-02f, 6.63346425e-02f, 7.59095922e-02f, 9.54671949e-03f, -4.63981507e-03f, 2.99027860e-02f, -7.72440759e-03f, 5.79646183e-03f, -3.45402621e-02f,
  1.84878204e-02f, -1.23062730e-01f, 1.54175041e-02f, 8.67195874e-02f, -3.41905840e-03f, -2.85699815e-02f, 4.32136767e-02f, -1.92142203e-02f, 5.16814850e-02f, 7.09167635e-03f,
  -3.79465148e-02f, -1.10223636e-01f, -2.80870270e-04f, 2.97921477e-03f, -5.73624782e-02f, -4.53356355e-02f, 7.68834352e-03f, -2.98366025e-02f, 1.93886962e-02f, -1.06353022e-01f,
  -2.49691717e-02f, 5.22095226e-02f, -2.95001026e-02f, -1.15229823e-02f, -4.42336649e-02f, -1.63770825e-01f, 5.22079004e-04f, -8.44849274e-02f, -1.29013062e-01f, -1.21653952e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.63171691e-01f, -4.16485220e-01f, -1.85613468e-01f, -3.18255454e-01f, -2.02116519e-01f, -1.28645137e-01f, -4.08812314e-01f, -5.36311381e-02f, -5.55506833e-02f, -2.18484908e-01f,
  -2.43481621e-02f, 1.31612211e-01f, 9.19390172e-02f, 5.04385270e-02f, -9.04865190e-02f, -3.81055295e-01f, -4.32494372e-01f, -3.29239666e-01f, 7.18697580e-03f, 1.36383101e-01f,
  -1.08534485e-01f, -4.72102791e-01f, -3.05426240e-01f, -1.98094964e-01f, -4.97586392e-02f, -2.12308913e-01f, -3.68165523e-01f, -4.04305071e-01f, -2.53671855e-01f, -5.94662368e-01f,
  2.09922716e-01f, 1.61931202e-01f, 1.07847787e-01f, -3.42038348e-02f, -9.89611745e-02f, 3.29760695e-03f, 8.48751422e-03f, 7.11387470e-02f, 2.04148546e-01f, 1.08691849e-01f,
  9.91111621e-02f, 4.72407974e-02f, -1.04573015e-02f, 2.57438868e-02f, -8.66016373e-02f, -3.84012721e-02f, 1.18671946e-01f, 3.59085239e-02f, 9.21180248e-02f, 1.42724842e-01f,
  6.54524267e-02f, 9.62186828e-02f, 1.71080023e-01f, 1.19698368e-01f, 2.56834954e-01f, 1.64520144e-02f, 9.63831767e-02f, 1.42140299e-01f, -4.74579893e-02f, -1.14524119e-01f,
  -2.53358901e-01f, 1.02186024e-01f, 8.09903219e-02f, 1.62776992e-01f, 1.20106652e-01f, 3.99310775e-02f, 7.74427950e-02f, -1.18946759e-02f, 1.64229888e-02f, -7.32328445e-02f,
  8.95584524e-02f, -3.38532515e-02f, 9.09673944e-02f, -1.11796252e-01f, -1.22673295e-01f, -8.33070055e-02f, -7.48474449e-02f, -4.25780490e-02f, 4.85579632e-02f, 9.76620242e-03f,
  2.00641751e-02f, -4.40674387e-02f, -9.60638598e-02f, -5.21865338e-02f, -7.04256445e-02f, -1.09519765e-01f, 2.58934908e-02f, 3.37478309e-03f, 5.17757311e-02f, -7.90190697e-03f,
  2.20690444e-01f, -7.08513185e-02f, -7.13665485e-02f, 1.65086925e-01f, 1.09217539e-02f, 4.17505689e-02f, -2.23322045e-02f, 8.35927296e-03f, 6.43391833e-02f, 7.17137158e-02f,
  7.99716190e-02f, 4.59536836e-02f, -6.60661757e-02f, 1.34384856e-01f, 9.69254076e-02f, 2.09523514e-02f, -8.93001854e-02f, -4.06060629e-02f, 8.35102703e-03f, 2.59415731e-02f,
  5.95166311e-02f, 1.96213387e-02f, 5.81260920e-02f, 1.50904387e-01f, 1.13815419e-01f, 3.71590629e-02f, -1.13870949e-02f, -7.21770376e-02f, -8.26960504e-02f, -1.44201338e-01f,
  1.75382152e-01f, -3.28932181e-02f, 4.23837185e-01f, -1.07923016e-01f, -1.60574019e-01f, 5.90613671e-02f, 1.31426929e-02f, 4.76896875e-02f, -1.75664991e-01f, -1.63233764e-02f,
  -2.00141892e-01f, -8.70403051e-02f, -1.50245056e-01f, 9.52126011e-02f, 1.88512638e-01f, 2.41780654e-01f, 4.79315929e-02f, 2.90423989e-01f, 3.63202423e-01f, 2.25813106e-01f,
  -7.45625421e-02f, 9.12227035e-02f, 1.32847816e-01f, 1.39828578e-01f, 6.48227111e-02f, 2.00321674e-02f, -3.68313603e-02f, -1.89383177e-03f, 7.06404746e-02f, 2.29645208e-01f,
  5.38300276e-01f, -1.30258594e-03f, -1.10332496e-01f, -1.21667653e-01f, -3.22694965e-02f, 1.14922702e-01f, 7.51521289e-02f, 3.49595919e-02f, 7.58996815e-04f, 9.04874578e-02f,
  4.31582183e-02f, 9.21144430e-03f, 2.91193202e-02f, 7.60639459e-02f, 1.41011849e-01f, 8.91336054e-02f, 7.33281299e-02f, 6.68839086e-03f, 6.81626424e-02f, 4.93533313e-02f,
  -1.09041862e-01f, 5.63520007e-03f, 1.27692252e-01f, -1.24481656e-01f, -3.70343067e-02f, -6.75464645e-02f, -3.29571255e-02f, 5.01381829e-02f, 2.26711612e-02f, 1.14615560e-01f,
  -6.46773055e-02f, -4.78846952e-02f, -4.49503809e-02f, -5.78650981e-02f, -1.25072643e-01f, -1.17493831e-02f, 9.29979384e-02f, 4.10296805e-02f, 1.04801014e-01f, 6.29709214e-02f,
  3.85980941e-02f, 7.63364509e-03f, -1.51616307e-02f, 5.83895221e-02f, 5.60770370e-03f, -4.01948467e-02f, 1.15580030e-01f, -4.76717250e-03f, -7.76788443e-02f, -1.88454241e-01f,
  -5.20976074e-02f, -1.39699066e-02f, -3.43948007e-02f, 4.29376923e-02f, -7.20828325e-02f, -1.63402651e-02f, 1.15250247e-02f, -2.17886083e-02f, -2.94433422e-02f, -5.48936911e-02f,
  1.97729290e-01f, -4.25697267e-01f, 1.07870311e-01f, 3.24753262e-02f, 1.30322501e-01f, 9.78214666e-02f, 9.12464783e-03f, -1.27482042e-02f, -1.39490776e-02f, 1.18899189e-01f,
  1.45657703e-01f, 1.98895916e-01f, 7.95075148e-02f, 6.18830174e-02f, 1.22419588e-01f, 1.48541495e-01f, -1.15906827e-01f, -3.16862799e-02f, 4.62663919e-02f, 1.42459676e-01f,
  -2.49329563e-02f, 1.38943508e-01f, 5.97031154e-02f, 2.15557832e-02f, 2.88505591e-02f, -1.18291378e-02f, 2.07862765e-01f, 1.28279582e-01f, 9.86948833e-02f, 1.01709150e-01f,
  -8.05654842e-03f, 4.07409787e-01f, 2.36321926e-01f, 1.28158122e-01f, 6.17565587e-03f, 2.95344740e-01f, 3.45677853e-01f, 1.37889653e-01f, -1.22567505e-01f, 1.06078133e-01f,
  -4.87848036e-02f, -2.32701674e-01f, 9.10397470e-02f, 5.67184389e-02f, 2.11671710e-01f, 2.54675895e-01f, 2.57017583e-01f, 1.73022524e-01f, -3.42821330e-02f, -8.46825913e-03f,
  -6.85039312e-02f, -1.89656597e-02f, -6.21617399e-02f, 1.42630801e-01f, 6.81967214e-02f, -1.32432505e-01f, 7.79129192e-02f, 1.70164213e-01f, 2.15122566e-01f, 2.01162308e-01f,
  -2.25569494e-02f, 3.55682194e-01f, -1.37082443e-01f, -1.21042415e-01f, -8.10405016e-02f, -2.19715446e-01f, -4.45527136e-02f, -1.15808837e-01f, -1.29077032e-01f, -8.36632028e-03f,
  -4.77922112e-02f, -1.91199496e-01f, 9.98475254e-02f, -5.26603200e-02f, 1.29233487e-02f, -4.12166752e-02f, 4.60524997e-03f, 2.31216669e-01f, 1.63383439e-01f, 7.40517229e-02f,
  -5.86508289e-02f, -9.38421488e-02f, 1.96537882e-01f, 1.08656481e-01f, 1.56015560e-01f, -9.92993191e-02f, 9.74686146e-02f, 1.10469528e-01f, 1.11692205e-01f, -1.09412275e-01f,
  -4.60860226e-03f, 5.51035628e-02f, 1.12358786e-01f, 6.92743063e-02f, -3.93314548e-02f, -3.21373343e-02f, -6.73332289e-02f, 6.66812137e-02f, 6.79003820e-02f, -5.36939204e-02f,
  -1.37407063e-02f, 9.52191055e-02f, 8.64352882e-02f, -4.03083675e-02f, -7.19461814e-02f, 1.93956736e-02f, 2.23347303e-02f, 3.20274048e-02f, -9.66960788e-02f, 3.53665128e-02f,
  -1.02321124e-02f, -2.52032420e-03f, -1.78374991e-01f, -2.86220256e-02f, 5.52327791e-03f, -7.14907274e-02f, -1.22221380e-01f, -6.01163618e-02f, -2.19265848e-01f, -1.10856362e-01f,
  -1.14177123e-01f, 2.91319788e-01f, -4.94358316e-02f, 1.39523283e-01f, 1.17636465e-01f, -1.34615302e-01f, 1.12048410e-01f, 8.37015361e-02f, 1.23580089e-02f, 1.02242038e-01f,
  -2.48012673e-02f, -2.09760889e-02f, 3.74368578e-03f, 3.15073617e-02f, -1.38129622e-01f, -2.28413090e-01f, -2.18051542e-02f, 1.91276222e-01f, 8.59158114e-02f, 1.06922891e-02f,
  -7.44082732e-03f, -1.31651565e-01f, -1.82505995e-01f, 2.28400882e-02f, -3.07648797e-02f, -2.13037670e-01f, -2.13218123e-01f, -2.18794942e-01f, -1.13197908e-01f, -3.80051911e-01f,
  -2.49737173e-01f, -4.64164674e-01f, 4.40590918e-01f, -1.48605570e-01f, 9.71815437e-02f, 1.69281602e-01f, 1.42210692e-01f, -1.12963513e-01f, -2.21324056e-01f, 3.38826701e-02f,
  -1.87103555e-01f, -2.33613297e-01f, -4.10521515e-02f, -3.62293348e-02f, -8.65818560e-02f, 1.34695113e-01f, 1.61417380e-01f, 2.12843686e-01f, 5.01774728e-01f, 1.96394607e-01f,
  2.18348876e-02f, 3.16808037e-02f, -1.15377136e-01f, -1.54064909e-01f, -3.71969827e-02f, 8.54242519e-02f, 1.10063069e-01f, -6.61887899e-02f, -1.06225789e-01f, 4.45229448e-02f,
  3.57272238e-01f, -3.12311560e-01f, 1.91516101e-01f, -1.79676592e-01f, 4.01140377e-02f, -1.19115718e-01f, 1.42078161e-01f, -9.46309194e-02f, -1.60518497e-01f, -4.75039072e-02f,
  -1.62952900e-01f, -2.40016244e-02f, 1.02726504e-01f, -1.40261799e-01f, -2.73081213e-02f, -1.95476804e-02f, -1.59506425e-01f, -9.08468887e-02f, -1.78869497e-02f, -2.26895567e-02f,
  -2.40882561e-01f, -8.18080977e-02f, 2.05903798e-02f, -5.64069450e-02f, -1.17347412e-01f, -3.46044339e-02f, -1.44110724e-01f, -1.37552977e-01f, -6.50463253e-02f, -4.58592847e-02f,
  -4.88613211e-02f, -1.13666186e-03f, -5.06420918e-02f, 3.04878224e-02f, 5.72800487e-02f, 8.68727341e-02f, -3.99814248e-02f, -2.99119782e-02f, -1.16646893e-01f, -3.17062363e-02f,
  -1.48130596e-01f, 3.45368846e-03f, 8.03544596e-02f, -1.17335850e-02f, -9.97282937e-02f, -7.58615695e-03f, -6.06169887e-02f, -5.75873964e-02f, -1.46324113e-01f, -6.81072921e-02f,
  -6.30556569e-02f, -1.29406542e-01f, -1.03999199e-02f, -4.23334613e-02f, -9.03882906e-02f, -1.01167113e-01f, 4.41101342e-02f, -1.16157562e-01f, -6.34570345e-02f, -1.54988050e-01f,
  2.77359515e-01f, -9.93027985e-02f, 2.36471757e-01f, -2.78568417e-02f, 2.81884917e-03f, -1.20294966e-01f, 1.10246921e-02f, -8.89458880e-02f, 9.44846869e-03f, 1.08937867e-01f,
  3.38239339e-03f, -6.50394261e-02f, -8.23036656e-02f, -1.93200737e-01f, 1.07401116e-02f, -4.36930591e-03f, -8.19706321e-02f, 2.22778283e-02f, -2.36501042e-02f, -7.73279369e-02f,
  -1.11577831e-01f, 3.00368555e-02f, 1.69802383e-01f, 1.07187681e-01f, 5.68479486e-03f, 2.05623642e-01f, 1.42103285e-01f, 7.82196894e-02f, 2.06671640e-01f, 4.66879793e-02f,
  -1.38800696e-01f, -3.39333564e-01f, 1.45178378e-01f, 3.02829981e-01f, -9.75360647e-02f, -4.76923704e-01f, -8.83539081e-01f, -4.43074942e-01f, 1.16471529e-01f, -1.95698902e-01f,
  -4.70228605e-02f, 8.36752355e-02f, 1.00181617e-01f, 4.62654643e-02f, -2.57224023e-01f, -5.77211678e-02f, 2.28234231e-01f, 2.06654519e-01f, -4.85443585e-02f, 3.88749950e-02f,
  1.57869652e-01f, 2.51651347e-01f, 2.11011007e-01f, 4.12023906e-03f, 2.68982321e-01f, 1.04602836e-01f, 2.10539937e-01f, 2.35825792e-01f, 5.95812723e-02f, 4.75879103e-01f,
  1.15419261e-01f, 4.67517739e-03f, -9.02984142e-02f, 5.58841750e-02f, 7.18628541e-02f, -2.50841260e-01f, 3.23477574e-02f, 1.12960733e-01f, -1.46782929e-02f, 1.78494491e-02f,
  1.06179841e-01f, -1.82639398e-02f, -4.36462425e-02f, 3.85417715e-02f, -2.33571857e-01f, -1.27042845e-01f, -5.60768880e-02f, 1.30945921e-01f, 3.87896970e-03f, -1.70867011e-01f,
  -2.42208615e-02f, 4.69819494e-02f, -2.70182192e-01f, -6.29290938e-02f, -4.29954454e-02f, 2.80702375e-02f, -1.97984725e-01f, -6.82946593e-02f, -2.02830240e-01f, -1.27367631e-01f,
  -1.08460099e-01f, 5.99204190e-02f, 6.65674433e-02f, 4.21863273e-02f, -5.11600114e-02f, -7.16126561e-02f, 1.70719996e-01f, 7.37684518e-02f, 1.62807450e-01f, -1.25955060e-01f,
  -2.63633523e-02f, 3.47287059e-02f, -2.41760202e-02f, -6.47157803e-02f, 2.64237449e-02f, 2.27975011e-01f, -8.19522068e-02f, -6.45857155e-02f, 1.45945892e-01f, -1.57629535e-01f,
  -1.07096680e-01f, 1.52755796e-03f, 4.18514609e-02f, 2.13856567e-02f, -1.34826377e-01f, 1.13832377e-01f, 1.74896747e-01f, -7.73315951e-02f, 8.47934186e-02f, -1.20463725e-02f,
  -1.03435144e-01f, 4.53927508e-03f, -1.21635897e-02f, -1.47454739e-01f, 4.81764525e-02f, -1.81854367e-01f, -6.56611100e-02f, -2.56746382e-01f, -5.46439476e-02f, -3.12641859e-01f,
  -2.13803858e-01f, -1.05396733e-01f, 1.55686568e-02f, -3.78635898e-02f, -1.47658929e-01f, -1.49138525e-01f, -1.43090114e-01f, -1.20339304e-01f, -2.12534234e-01f, -1.76751450e-01f,
  -1.26032099e-01f, -3.65709037e-01f, -3.74432653e-01f, -1.83133855e-01f, -1.88970193e-01f, -2.55357236e-01f, -1.12059653e-01f, -2.54291147e-01f, -5.77083290e-01f, -5.80613434e-01f,
  9.15390253e-01f, 3.71352851e-01f, 3.48705560e-01f, 1.16783738e-01f, 6.98763039e-03f, 2.35662162e-01f, 3.74534994e-01f, 2.23778978e-01f, -7.69339353e-02f, 1.24133430e-01f,
  -7.85684306e-03f, -2.21158549e-01f, -7.99251497e-02f, -1.06219701e-01f, 9.90378484e-02f, 1.67219460e-01f, 5.34024090e-02f, 2.65137583e-01f, 1.98249325e-01f, 1.69014037e-01f,
  7.11408397e-03f, 1.16307780e-01f, 3.33163738e-01f, 1.83151111e-01f, 1.49081752e-01f, -1.42276004e-01f, 1.29227370e-01f, 7.46362358e-02f, 1.24332130e-01f, 2.23111212e-01f,
  -2.18818426e-01f, 4.27462220e-01f, -1.28756329e-01f, -6.88409656e-02f, -1.32977590e-01f, 7.93212373e-03f, -1.22681670e-02f, -3.94828944e-03f, -1.21363670e-01f, -8.09950307e-02f,
  -2.17334419e-01f, -2.40431000e-02f, -4.45881635e-02f, -1.05484324e-02f, -7.25713978e-03f, 5.37723340e-02f, 1.88485701e-02f, 1.53592110e-01f, 2.25403942e-02f, 8.88156425e-03f,
  -7.85246268e-02f, 5.39077371e-02f, 1.17038906e-01f, 1.25147760e-01f, 8.39983076e-02f, -1.28079414e-01f, 5.75203709e-02f, 1.34928361e-01f, 7.71343112e-02f, 1.89556226e-01f,
  -7.48886466e-02f, 1.12308778e-01f, 1.63448691e-01f, 1.36632502e-01f, 9.70322937e-02f, -8.93032998e-02f, 1.99563000e-02f, 1.32852728e-02f, 1.49844065e-01f, 1.34292021e-01f,
  -6.76546171e-02f, 3.31577621e-02f, 6.54499605e-02f, 1.63314059e-01f, -9.31725428e-02f, 5.88374287e-02f, -7.08713382e-02f, 1.14289440e-01f, -4.71715219e-02f, -4.26517241e-02f,
  6.44817501e-02f, 2.63831522e-02f, -1.08221769e-01f, 1.17731094e-01f, -1.35050431e-01f, 7.09422082e-02f, 8.81557912e-03f, -4.48942930e-02f, 3.53839109e-03f, -3.22874426e-03f,
  -7.33864188e-01f, -2.25626618e-01f, -7.59738125e-03f, 3.35816480e-02f, 2.47040088e-03f, -1.08827986e-01f, 7.70634133e-03f, -1.02694454e-02f, -2.30600387e-01f, -4.88417521e-02f,
  4.73379530e-03f, 7.52857998e-02f, -3.01827211e-03f, 1.80907696e-02f, -1.70041982e-03f, -1.52086511e-01f, -4.98167388e-02f, -1.21467493e-01f, -1.01056740e-01f, -1.80999309e-01f,
  -7.36548230e-02f, -1.10513309e-03f, -7.22914338e-02f, 2.89631076e-02f, -1.17326388e-02f, -1.49630755e-01f, -1.30317703e-01f, -6.56787306e-02f, -1.04167424e-01f, -1.19465105e-01f,
  -5.34231305e-01f, 1.75853390e-02f, -1.55292526e-01f, 1.09224059e-01f, 8.02260414e-02f, 1.26936793e-01f, -6.39055967e-02f, 1.47199854e-02f, 1.19017430e-01f, 2.39360910e-02f,
  5.66032156e-02f, 2.98283547e-01f, 3.15423220e-01f, 2.81556487e-01f, 1.28232703e-01f, 1.97320223e-01f, 2.15018004e-01f, -5.41161187e-02f, -1.40830591e-01f, 9.53297541e-02f,
  2.81959265e-01f, -5.81758544e-02f, -2.91378826e-01f, -2.08095741e-02f, 2.05672801e-01f, 1.97331443e-01f, 2.85340995e-02f, -5.50426878e-02f, 1.84366629e-01f, 2.61511296e-01f,
  2.31748447e-01f, -1.17179275e-01f, 1.37236878e-01f, 4.68026362e-02f, -1.16867781e-01f, -1.96872637e-01f, -2.04753876e-01f, -8.64931270e-02f, -7.29275122e-02f, -6.65011033e-02f,
  -1.21807784e-01f, -7.69207850e-02f, -1.15104437e-01f, -8.18957612e-02f, -6.53522536e-02f, -8.44806209e-02f, 2.05549202e-03f, 5.08222319e-02f, 2.78703004e-01f, 6.57395571e-02f,
  4.72609252e-02f, -8.85293260e-02f, -7.24823996e-02f, 1.02158725e-01f, 1.68273896e-01f, 9.60128158e-02f, 1.15018010e-01f, 1.63097963e-01f, 1.39706865e-01f, -3.98678556e-02f,
  1.36676610e-01f, 4.90160584e-02f, 7.69547671e-02f, 3.67255099e-02f, -1.85083598e-02f, 5.86107895e-02f, -7.30020925e-03f, 1.44154634e-02f, 7.91596621e-03f, -2.41350517e-01f,
  -6.03596307e-02f, 1.18986651e-01f, 1.08307935e-01f, 6.48286268e-02f, 1.88875571e-02f, -7.02133253e-02f, -5.69310822e-02f, 7.21561611e-02f, -6.05153926e-02f, -1.01322435e-01f,
  -5.21168038e-02f, 5.67342006e-02f, -5.73405139e-02f, 3.11576519e-02f, 3.40360999e-02f, 9.86555219e-02f, -1.65251212e-03f, -2.38348264e-02f, -2.01762930e-01f, -4.62386794e-02f,
  3.16912115e-01f, 2.48677079e-02f, 1.82586998e-01f, -1.33300209e-02f, 3.91806252e-02f, -9.17088687e-02f, 7.01453239e-02f, -6.03303965e-03f, -1.64021533e-02f, 6.73584640e-02f,
  -1.42579079e-01f, -2.71991026e-02f, -4.26350124e-02f, -1.17270760e-01f, -1.76246017e-01f, -2.16872878e-02f, 5.66786602e-02f, 1.20646998e-01f, 1.91850409e-01f, 1.16016373e-01f,
  4.55905348e-02f, -3.90340015e-02f, 6.06682263e-02f, 5.95410913e-02f, 1.33110508e-01f, 1.18750289e-01f, -4.64624465e-02f, 2.41774153e-02f, 1.03794001e-02f, -6.00235276e-02f,
  8.06183994e-01f, -5.63414872e-01f, 5.45721173e-01f, 3.13226096e-02f, -1.72954753e-01f, -7.25801289e-03f, -3.23152244e-01f, -1.53280541e-01f, -3.16469297e-02f, -1.10116243e-01f,
  -2.93535084e-01f, -1.30864397e-01f, 9.43925232e-02f, -4.71239612e-02f, 1.24649368e-01f, -6.24472424e-02f, 9.70441923e-02f, 6.45874798e-01f, 6.23026609e-01f, 1.32808939e-01f,
  -3.27967584e-01f, 2.15497818e-02f, 3.29138905e-01f, 1.53301090e-01f, -3.38069797e-01f, -6.26856312e-02f, -3.49181257e-02f, -9.43417922e-02f, -2.63891190e-01f, -1.86238840e-01f,
  -1.64351016e-02f, -6.61051348e-02f, 6.47696853e-02f, -1.63429320e-01f, -5.99369220e-02f, -9.31566432e-02f, -9.10508037e-02f, 6.02850281e-02f, -7.73068070e-02f, -7.69085512e-02f,
  -9.81078371e-02f, 2.09018011e-02f, -3.90015244e-02f, -1.49305500e-02f, -9.23101902e-02f, -9.23847631e-02f, -9.88525571e-04f, 2.26082772e-01f, 9.35146287e-02f, -6.97790757e-02f,
  -2.99460948e-01f, -8.56772885e-02f, -2.75358316e-02f, -3.50520462e-02f, 2.25063935e-02f, 7.63758048e-02f, 2.86094670e-04f, -8.00651237e-02f, 1.63217828e-01f, -1.30916998e-01f,
  5.67403175e-02f, 6.60383776e-02f, -1.20870564e-02f, -3.29861604e-02f, 6.15354478e-02f, 2.97112372e-02f, 1.30671203e-01f, -7.45055825e-02f, 8.09338912e-02f, 7.23295361e-02f,
  -6.39498681e-02f, 1.41059414e-01f, -9.23004001e-03f, -2.72434074e-02f, -3.87496911e-02f, 7.47126043e-02f, -4.54901941e-02f, -8.58517587e-02f, 2.66109407e-02f, 6.42071441e-02f,
  1.61424652e-02f, 5.80052286e-02f, 8.04096647e-03f, -1.89460218e-02f, -6.94886446e-02f, 1.36243165e-01f, 1.85819101e-02f, -1.10662006e-01f, -3.01918760e-02f, -4.18206400e-05f,
  -4.48963672e-01f, 3.50069314e-01f, 5.78313693e-03f, 5.23490692e-03f, -1.01425974e-02f, 9.08755406e-04f, -4.34796186e-03f, -8.36827755e-02f, -1.36122048e-01f, -6.52467832e-02f,
  -9.50516667e-03f, 9.57595184e-02f, 7.03995526e-02f, -2.18846630e-02f, 1.64395481e-01f, -1.96529087e-02f, -8.96010399e-02f, 3.12561616e-02f, -3.79232652e-02f, -1.62809327e-01f,
  -1.20586775e-01f, 6.17002696e-03f, 1.05675831e-02f, 4.37351167e-02f, 5.48716113e-02f, 2.17373505e-01f, 5.10011055e-02f, 3.92397977e-02f, 1.65462568e-01f, -1.75309211e-01f,
  -6.27913058e-01f, 7.81122744e-02f, 3.19705665e-01f, -5.61725438e-01f, -1.99796602e-01f, -2.11223796e-01f, 1.48613025e-02f, -2.42657885e-01f, -4.02767956e-01f, 9.80182588e-02f,
  5.66581264e-02f, -4.58856560e-02f, 2.51985520e-01f, 4.89073433e-02f, -2.13261768e-01f, 2.65635103e-01f, -8.20437744e-02f, -2.16794789e-01f, -2.86264569e-01f, -3.47927123e-01f,
  -2.40876526e-01f, -4.35052574e-01f, -4.77373153e-01f, -3.00057948e-01f, -5.53681934e-03f, 1.91511273e-01f, 1.62953898e-01f, -1.91244036e-01f, 5.52841127e-02f, 1.25035957e-01f,
  4.67686117e-01f, -1.37286663e-01f, 1.94961485e-02f, -3.76302630e-01f, 1.04916312e-01f, -2.55329013e-01f, -1.98553298e-02f, 1.07046232e-01f, -6.36170357e-02f, -7.52691850e-02f,
  -1.78170279e-01f, -1.92354396e-01f, -9.22025964e-02f, 2.91095991e-02f, -1.27663612e-01f, -5.66866137e-02f, -1.65937811e-01f, -7.89794177e-02f, 1.79496668e-02f, 7.51163661e-02f,
  1.32824749e-01f, -9.24474820e-02f, 1.01262972e-01f, 1.14110157e-01f, -2.03323737e-03f, -6.89746737e-02f, 1.34853318e-01f, -5.23327589e-02f, 2.33162809e-02f, 2.20186159e-01f,
  -1.93572827e-02f, 1.42996728e-01f, -4.76329476e-02f, -7.61401327e-03f, -1.36394799e-01f, 5.20417206e-02f, 1.53673828e-01f, 1.36237875e-01f, -4.28631008e-02f, 4.15178202e-02f,
  5.13418056e-02f, 5.51212169e-02f, 2.66125239e-02f, 4.85750288e-02f, 1.25198513e-01f, 1.90169197e-02f, 1.56934583e-03f, 1.21459097e-01f, 1.18365712e-01f, -5.94286546e-02f,
  -1.01413742e-01f, 3.35886851e-02f, -9.49158426e-03f, 6.05257303e-02f, -5.49930818e-02f, 2.67056376e-02f, -1.35274120e-02f, -2.59411912e-02f, -1.09424880e-02f, -1.31505415e-01f,
  2.64187127e-01f, 1.21972039e-02f, 5.43064438e-02f, -2.08121091e-02f, 3.84021550e-02f, -7.81004801e-02f, 5.39445877e-02f, 2.81755049e-02f, -5.21111488e-02f, -1.21829137e-01f,
  -2.16660619e-01f, -3.76569517e-02f, 8.39603469e-02f, 7.22505897e-02f, -5.20782359e-02f, -2.41177697e-02f, 2.46020090e-02f, 8.70820656e-02f, -2.85525434e-02f, -1.39866024e-01f,
  -5.70643274e-03f, -1.22914799e-02f, 1.33050263e-01f, 2.25988925e-01f, -6.15795981e-03f, -1.14867138e-02f, 2.55175620e-01f, -2.49498580e-02f, 4.60072272e-02f, 1.90295398e-01f,
  1.47551104e-01f, -1.44952804e-01f, -1.17492117e-01f, 3.30192447e-01f, 2.97443718e-01f, 1.80939481e-01f, 9.75532159e-02f, 1.17879204e-01f, 1.48870200e-01f, 1.16789773e-01f,
  2.38845229e-01f, 4.00714189e-01f, 2.56811589e-01f, 2.40475282e-01f, 8.54204297e-02f, 1.57814939e-02f, 5.56721388e-05f, 8.29993747e-03f, 9.31570381e-02f, 1.40999168e-01f,
  1.75657257e-01f, -1.31203875e-01f, -1.30496025e-01f, -6.49048239e-02f, -1.11480966e-01f, 1.60003647e-01f, 5.85759953e-02f, -1.01197876e-01f, -6.11587763e-02f, -1.85735315e-01f,
  -4.05503035e-01f, -4.68045808e-02f, 1.52403906e-01f, 2.45616306e-02f, -1.24301687e-02f, -1.20317042e-01f, 5.08465953e-02f, -9.89592969e-02f, -4.62347176e-03f, 5.09469025e-02f,
  -6.27891868e-02f, -1.87757075e-01f, -3.91478837e-02f, 3.93252149e-02f, -2.03709394e-01f, -1.39185354e-01f, 3.17517370e-02f, 7.06327632e-02f, 7.14097768e-02f, -7.45397210e-02f,
  9.52684209e-02f, 9.63673964e-02f, 6.53683320e-02f, 1.35660291e-01f, 1.63095623e-01f, 6.19730987e-02f, 1.98148042e-02f, -4.71914262e-02f, -2.11980436e-02f, 5.27620725e-02f,
  1.62374437e-01f, 1.05996855e-01f, 1.65295884e-01f, 1.31730616e-01f, 7.22316355e-02f, 2.06901785e-02f, -1.94077510e-02f, -2.20513772e-02f, 1.50864318e-01f, -4.29464243e-02f,
  5.88038974e-02f, 1.00398161e-01f, 1.19285889e-01f, 8.57725516e-02f, 3.48104089e-02f, -3.15961018e-02f, -7.21747577e-02f, -8.93409997e-02f, -4.90866564e-02f, -1.57030433e-01f,
  -1.07658930e-01f, -3.64682488e-02f, -2.10790962e-01f, -1.57906204e-01f, -2.83734426e-02f, 4.52041849e-02f, -6.78104460e-02f, 4.99084890e-02f, 1.90285267e-03f, -1.36083990e-01f,
  1.34898210e-03f, 2.50685781e-01f, -4.74692956e-02f, 2.84939688e-02f, -7.04699606e-02f, -8.00213814e-02f, 1.94311321e-01f, -7.08028302e-02f, -1.29849687e-01f, 7.09516928e-02f,
  -1.69240907e-01f, -1.38918668e-01f, -1.21746466e-01f, -4.10518944e-02f, 1.36951543e-02f, -1.28029957e-01f, -1.28811086e-02f, 9.98806432e-02f, -3.07067614e-02f, -2.20252648e-01f,
  -2.63870712e-02f, 1.22073792e-01f, 6.46912903e-02f, 9.33819860e-02f, 1.63452491e-01f, 1.05215117e-01f, -7.21192434e-02f, 5.32352040e-03f, -3.00180856e-02f, 7.80225843e-02f,
  8.98099720e-01f, -1.53238758e-01f, -4.32100505e-01f, 2.22324684e-01f, -1.19877510e-01f, -1.47583514e-01f, -9.85791758e-02f, -3.33083235e-02f, 3.55102792e-02f, -4.53972211e-03f,
  6.56543747e-02f, 2.64948964e-01f, 1.55243456e-01f, -5.09977974e-02f, 6.56548142e-02f, -2.45316282e-01f, -1.92462429e-01f, -1.15398519e-01f, 1.15656726e-01f, -6.96125329e-02f,
  1.34266121e-02f, -1.60651699e-01f, 8.73257294e-02f, -6.93618208e-02f, -2.56177753e-01f, -1.12863801e-01f, -2.98686266e-01f, -2.72817224e-01f, -2.61594832e-01f, -4.50322717e-01f,
  -7.05666244e-02f, 7.54742026e-02f, 7.95231014e-02f, 1.33019499e-03f, -6.56455336e-03f, 8.62556100e-02f, 9.30236503e-02f, 5.08673340e-02f, 8.28064978e-02f, 8.80867690e-02f,
  -1.25866771e-01f, 2.94338935e-03f, -5.80440871e-02f, 2.60649584e-02f, -1.11046676e-02f, 8.39295834e-02f, -4.12310958e-02f, 7.39568025e-02f, -8.98972079e-02f, -5.15245013e-02f,
  -4.07043099e-03f, 8.65570232e-02f, -2.72256155e-02f, 3.49885374e-02f, 6.77568689e-02f, 1.02337308e-01f, -3.76405716e-02f, 1.65060610e-02f, 1.23231672e-01f, 9.75353271e-02f,
  -9.04056896e-03f, 1.12512652e-02f, 1.12991147e-01f, 2.05434427e-01f, 9.66024622e-02f, 1.05637811e-01f, 2.39221249e-02f, -5.29163778e-02f, 9.10441205e-02f, -1.24757066e-02f,
  3.17676663e-02f, 7.73445889e-02f, 4.61528730e-03f, 2.43012588e-02f, -3.83714773e-02f, -7.79854367e-03f, 4.07296512e-03f, -5.42837009e-03f, -1.44344848e-02f, -4.19109948e-02f,
  3.24761309e-02f, -1.31944746e-01f, -2.04499643e-02f, -1.00877739e-01f, -5.94586730e-02f, -9.16531030e-03f, -8.60804021e-02f, -1.05399750e-01f, -1.01690277e-01f, -7.19254687e-02f,
  2.85858959e-01f, 3.86912860e-02f, 5.95966429e-02f, -4.40826900e-02f, -8.33556801e-02f, -4.98797894e-02f, 1.36656314e-01f, 7.64660537e-02f, -1.33727938e-01f, -4.58825007e-02f,
  -2.00899728e-02f, 6.79808259e-02f, -1.04040399e-01f, -1.44297957e-01f, 1.00724578e-01f, -5.46514639e-04f, 8.18427205e-02f, 7.04890117e-02f, -1.30735919e-01f, -6.76802779e-03f,
  -1.63311929e-01f, 1.36329487e-01f, 1.91908836e-01f, 8.21951628e-02f, 3.61705907e-02f, 1.50126159e-01f, 1.07266018e-02f, -1.99290384e-02f, 3.85464057e-02f, 3.17738533e-01f,
  7.81196833e-01f, -5.28713107e-01f, -2.23677963e-01f, 3.36500078e-01f, 1.10588290e-01f, 4.10905704e-02f, 3.82704660e-02f, 9.20875520e-02f, 1.83166310e-01f, -1.10121146e-01f,
  -4.64037091e-01f, -4.81438130e-01f, -2.28257313e-01f, -3.34855050e-01f, -3.06593776e-01f, 1.27497688e-01f, 1.62995756e-01f, 7.95077011e-02f, 1.16296954e-01f, -4.50010560e-02f,
  -1.71181783e-01f, 2.01168165e-01f, 1.53835714e-01f, -8.74659419e-02f, -4.67935540e-02f, -1.18222646e-01f, -2.15252206e-01f, -1.14116810e-01f, -3.36531013e-01f, -2.73904949e-01f,
  -3.01393569e-01f, -2.92066693e-01f, 3.00610270e-02f, -7.27888197e-02f, -1.40023574e-01f, 4.63979803e-02f, -5.37188724e-02f, 3.21555696e-02f, -6.84168329e-03f, 7.11573113e-04f,
  -6.76444992e-02f, -2.95649357e-02f, 1.80214755e-02f, -1.63269341e-01f, 8.46012980e-02f, 2.17212457e-03f, -5.43804094e-02f, -7.86568820e-02f, -1.45193413e-01f, -1.18301950e-01f,
  -1.60797119e-01f, -4.42121550e-02f, -1.50996130e-02f, -1.29256919e-01f, -2.11695820e-01f, -6.98178709e-02f, -2.27728590e-01f, -2.08835050e-01f, -1.61599427e-01f, 7.34521747e-02f,
  6.82129934e-02f, -1.74826980e-02f, -1.22962818e-01f, 1.98475253e-02f, 1.01171367e-01f, 2.80607603e-02f, -6.77743519e-04f, 5.52261323e-02f, 1.68194734e-02f, 1.57548159e-01f,
  6.67632073e-02f, -6.13602847e-02f, -9.66568757e-03f, 6.27394542e-02f, -1.16970569e-01f, -6.61154240e-02f, -5.42213488e-03f, -3.21211070e-02f, 2.56981310e-02f, 6.68320209e-02f,
  -9.62204188e-02f, 1.29341166e-02f, -2.66328678e-02f, -8.02073330e-02f, -1.55123785e-01f, -9.45080221e-02f, -7.92774186e-02f, -1.15624487e-01f, 9.51931924e-02f, -2.82481443e-02f,
  1.46515682e-01f, -2.36948878e-01f, 2.77493238e-01f, -1.00642636e-01f, 1.02326378e-01f, -7.32869059e-02f, -2.21045122e-01f, -1.24996807e-02f, -6.70741424e-02f, 1.97237395e-02f,
  -2.00283721e-01f, -5.41287288e-02f, -8.62947553e-02f, -7.01283738e-02f, 1.89110681e-01f, 9.82384980e-02f, -2.62751840e-02f, 1.01412781e-01f, -8.35504681e-02f, 3.65672540e-03f,
  1.13864250e-01f, 2.42747083e-01f, 2.67884046e-01f, 9.73688141e-02f, 9.57222306e-04f, 2.14019164e-01f, 9.23536122e-02f, 2.00291947e-01f, 2.23543078e-01f, 5.64116359e-01f,
  -1.81245133e-01f, -2.50526160e-01f, 7.98792951e-03f, 1.81794122e-01f, 1.97040468e-01f, 2.24425811e-02f, -1.93300784e-01f, -2.10639954e-01f, 2.55516261e-01f, 2.81945884e-01f,
  2.11214110e-01f, 3.22547913e-01f, 1.65046915e-01f, 1.16894275e-01f, -2.01613918e-01f, -6.96551800e-03f, 3.97654921e-02f, 4.50968966e-02f, 6.74516335e-02f, 3.01731259e-01f,
  1.93560913e-01f, 2.37766638e-01f, 7.32860193e-02f, -3.77801545e-02f, 1.56614527e-01f, 2.58135915e-01f, 2.17862189e-01f, 1.18786603e-01f, 1.73910618e-01f, 2.14939848e-01f,
  3.86548877e-01f, -2.73717284e-01f, -3.92372906e-02f, 1.08988285e-02f, -1.17002167e-01f, -9.62756500e-02f, 4.75457162e-02f, -1.03653274e-01f, -1.14506438e-01f, -1.15733400e-01f,
  1.27235323e-01f, -1.59859676e-02f, -2.38792896e-01f, -4.45988812e-02f, -2.64657959e-02f, -6.92908168e-02f, -2.58064941e-02f, -1.32274672e-01f, -1.44471109e-01f, 1.03740513e-01f,
  -4.57094871e-02f, 1.35871664e-01f, -3.55718620e-02f, -1.26307592e-01f, -2.12879732e-01f, 5.62614854e-03f, -6.65993094e-02f, -1.92550898e-01f, -9.83912572e-02f, 3.86043489e-02f,
  3.10170114e-01f, 4.03608382e-03f, 5.65155968e-02f, 4.01355773e-02f, 1.88316070e-02f, 7.94071183e-02f, -2.03152318e-02f, 6.70681074e-02f, 1.73594385e-01f, 7.13346452e-02f,
  -4.30040620e-02f, 4.63125147e-02f, 1.07551530e-01f, -7.76758566e-02f, 9.73509625e-02f, -6.63942993e-02f, -1.38595521e-01f, -1.21164873e-01f, -7.02539757e-02f, -2.35160440e-02f,
  -1.11820899e-01f, -7.39704818e-02f, -3.05968318e-02f, -8.43840688e-02f, 2.79086996e-02f, -2.41259709e-02f, 8.82384330e-02f, -4.03648317e-02f, -3.90983047e-03f, 8.48665237e-02f,
  2.01612458e-01f, -1.22355796e-01f, 1.64805666e-01f, -9.90432501e-02f, -3.53422835e-02f, -1.22548245e-01f, 6.70190006e-02f, -1.28624812e-01f, -1.45753160e-01f, -9.85976085e-02f,
  -1.45377979e-01f, -7.38188401e-02f, -3.69125418e-02f, -2.80287601e-02f, 7.58285522e-02f, 4.66589779e-02f, 7.35954344e-02f, 6.95565194e-02f, 2.82619894e-02f, 7.84754232e-02f,
  -2.14331388e-01f, 1.57906860e-01f, 1.53924659e-01f, -7.44826645e-02f, -3.55482176e-02f, 1.47144526e-01f, 3.95469517e-02f, 5.77804111e-02f, -1.31549403e-01f, 5.11781350e-02f,
  3.73830587e-01f, 1.51684850e-01f, -4.42888252e-02f, 1.87118739e-01f, -1.29393101e-01f, -5.47239363e-01f, -7.32930839e-01f, -3.55700791e-01f, 2.39186957e-01f, 2.11727217e-01f,
  5.89362606e-02f, 1.76734943e-02f, 1.30947486e-01f, 2.55209208e-02f, -2.24310547e-01f, -1.36775896e-01f, 8.09168592e-02f, -5.16671017e-02f, -4.27187413e-01f, -3.26458484e-01f,
  -1.85586497e-01f, -8.37377757e-02f, -6.04307698e-03f, -1.26109242e-01f, 4.53020900e-01f, 4.88023721e-02f, 1.74065217e-01f, 2.45139584e-01f, -2.80322582e-02f, 7.00384736e-01f,
  2.81418890e-01f, 2.20125064e-01f, -2.45069608e-01f, 3.21889818e-02f, 1.16143227e-01f, 1.14245780e-01f, 2.88610514e-02f, 1.41532406e-01f, 1.82194822e-03f, -7.92374648e-03f,
  1.10466994e-01f, 5.57547025e-02f, 1.93301328e-02f, -9.21552777e-02f, -8.87105018e-02f, -1.02755636e-01f, 3.74306999e-02f, -4.10998687e-02f, 1.93888564e-02f, 1.33545950e-01f,
  3.33274081e-02f, -9.95829999e-02f, -2.19877049e-01f, -3.30463499e-01f, -4.02951520e-03f, -1.11150630e-02f, -1.73231214e-01f, 1.80974498e-01f, -1.82681188e-01f, 2.77109176e-01f,
  -6.63156584e-02f, 1.67198461e-02f, 5.16291000e-02f, -7.58535936e-02f, -1.09148249e-02f, 4.79810014e-02f, -2.24145371e-02f, -1.85391810e-02f, -1.01125911e-01f, -3.17614479e-03f,
  -3.09538450e-02f, 6.17947094e-02f, -3.13940980e-02f, 2.48087049e-02f, -1.20349256e-02f, 5.83429122e-03f, -1.42710330e-02f, -2.56755520e-02f, -2.49575097e-02f, 1.06757909e-01f,
  -7.58890808e-02f, -1.20447293e-01f, 1.20460846e-01f, 4.43082154e-02f, -7.62029318e-03f, 3.86334211e-02f, -4.58777323e-02f, -8.42501521e-02f, -5.89714125e-02f, 6.75828336e-03f,
  -4.87070605e-02f, -3.91234756e-01f, 2.77968109e-01f, 3.57347205e-02f, 1.69280916e-01f, 1.57647610e-01f, 2.27233753e-01f, 1.86242685e-02f, 2.45304063e-01f, -2.68193968e-02f,
  -8.10180753e-02f, 1.11638427e-01f, 7.40029812e-02f, -4.62384820e-02f, -1.29847184e-01f, -2.96399835e-02f, 7.94710070e-02f, 3.76596339e-02f, -4.08489211e-03f, 2.58494228e-01f,
  2.57685781e-02f, -2.47397155e-01f, -3.43039781e-01f, -5.56409322e-02f, 1.40421167e-01f, -1.81031942e-01f, -1.51081324e-01f, -5.98179363e-02f, -1.82973653e-01f, -2.37652406e-01f,
  -6.93291247e-01f, -5.27711585e-02f, 1.07473738e-01f, -5.88065267e-01f, -4.57740501e-02f, 1.58330053e-01f, -7.93232769e-02f, 5.11984862e-02f, -1.57735288e-01f, 5.96232563e-02f,
  8.18352029e-02f, -2.88099912e-03f, 2.35842746e-02f, -2.67969016e-02f, -1.34542495e-01f, -6.06286377e-02f, -2.21988603e-01f, -3.70137185e-01f, -5.27504124e-02f, 2.02236578e-01f,
  3.79742347e-02f, -2.42429286e-01f, -4.34605241e-01f, 4.73508760e-02f, 2.99187172e-02f, -1.03637271e-01f, -1.83717772e-01f, -1.37084350e-01f, 1.56243499e-02f, -4.27473456e-01f,
  2.20596924e-01f, -3.46325003e-02f, -1.82426106e-02f, -2.31586277e-01f, -3.27149630e-02f, -6.04903661e-02f, 1.12361647e-02f, -5.82210384e-02f, -3.29957493e-02f, 1.37638375e-01f,
  -2.77447607e-02f, 3.19725298e-03f, -1.78318232e-01f, 1.13093652e-01f, -1.25336364e-01f, 1.21448878e-02f, -1.28492370e-01f, -4.50048149e-02f, -1.27460733e-01f, 3.91445845e-01f,
  7.57536516e-02f, -1.16742015e-01f, -1.27791867e-01f, 6.38843402e-02f, 1.99732035e-01f, -5.05059995e-02f, 1.07744835e-01f, 2.47264598e-02f, -4.25221324e-02f, -1.28408551e-01f,
  -2.47898195e-02f, 1.61459282e-01f, 1.02893248e-01f, 2.28218157e-02f, 5.63425990e-03f, 4.87161539e-02f, -2.44350620e-02f, -1.09924801e-01f, 7.51682511e-03f, -1.14533314e-02f,
  1.32399112e-01f, -2.69632861e-02f, 1.49547607e-01f, 1.96947362e-02f, -9.92330760e-02f, -4.90084775e-02f, -1.37716793e-02f, 6.85821800e-03f, 5.51130027e-02f, -1.30632222e-01f,
  -5.58708906e-02f, -7.42695183e-02f, -9.79795381e-02f, 2.24172380e-02f, -2.68698148e-02f, -1.25084281e-01f, 9.22338665e-02f, 8.37272257e-02f, -3.38939838e-02f, -4.48390432e-02f,
  -5.02105616e-02f, -1.64183855e-01f, -1.12583704e-01f, 6.28882125e-02f, -4.04383577e-02f, 1.03560321e-01f, 2.77688205e-02f, 9.50268358e-02f, -4.30241525e-02f, -1.20534247e-03f,
  2.87223421e-02f, 8.59296471e-02f, -6.71435148e-02f, 1.63727120e-01f, 1.02487365e-02f, 4.24123593e-02f, -1.06832825e-01f, -1.66179284e-01f, -1.23179063e-01f, 2.21732348e-01f,
  8.59170686e-03f, -1.50918990e-01f, -1.39024451e-01f, -6.23396486e-02f, 4.71332632e-02f, -7.60974810e-02f, 1.77153170e-01f, 1.58123791e-01f, 7.50960410e-02f, -1.11448616e-01f,
  2.15288863e-01f, -1.04939580e-01f, -4.95785862e-01f, 1.52405635e-01f, -3.07901233e-01f, -3.63117725e-01f, -4.48510230e-01f, -1.61899403e-02f, 2.37698808e-01f, -3.62468302e-01f,
  3.17841768e-02f, 3.03668082e-01f, 9.75508019e-02f, -1.48012146e-01f, -3.36542875e-01f, -7.56854475e-01f, -6.01163507e-01f, -2.99013108e-01f, -4.94624116e-02f, -1.59232259e-01f,
  -3.67664620e-02f, -7.69510418e-02f, -5.81709258e-02f, 1.00750729e-01f, 2.87319392e-01f, 2.32539788e-01f, -1.04160719e-01f, -8.48654583e-02f, -1.03037193e-01f, -1.08622536e-01f,
  -1.19568527e-01f, 8.86597037e-02f, 1.42142933e-03f, 3.28442431e-03f, 9.58494544e-02f, 1.11180171e-01f, -9.57121029e-02f, 4.88773398e-02f, 9.63920355e-02f, 5.65588707e-03f,
  -3.35671641e-02f, -1.05686247e-01f, 1.80291295e-01f, 3.55733819e-02f, 3.19066830e-02f, 4.33415361e-02f, -2.80282125e-02f, -1.14140764e-01f, 4.23042774e-02f, 2.60065738e-02f,
  -3.34265232e-01f, -2.00270891e-01f, -6.24278784e-02f, -1.57488614e-01f, -2.29702462e-02f, -1.63228273e-01f, 2.25324497e-01f, 2.11095378e-01f, 1.14991270e-01f, 2.40730435e-01f,
  -5.09028323e-02f, 1.53037667e-01f, 1.06101697e-02f, 3.39017659e-02f, 3.30568850e-02f, -8.68691653e-02f, -2.86635198e-02f, 6.43654093e-02f, 5.76859862e-02f, -2.17272360e-02f,
  -8.30619112e-02f, -7.03106001e-02f, 3.79578844e-02f, -3.95978652e-02f, 7.31114373e-02f, 2.72215120e-02f, 1.41715333e-02f, -4.47598025e-02f, 5.49429953e-02f, -2.84990557e-02f,
  1.42516389e-01f, 5.26828058e-02f, 5.77005744e-02f, 1.19276859e-01f, -1.22813150e-01f, -7.13957921e-02f, -8.36141557e-02f, -8.15073866e-03f, 1.00416183e-01f, -1.11785263e-01f,
  3.37728530e-01f, -3.58986318e-01f, -2.82268826e-04f, 8.93515199e-02f, 4.64190841e-02f, -1.66803032e-01f, -6.73553571e-02f, -1.01082008e-02f, 1.06631786e-01f, 9.95227322e-02f,
  7.95746297e-02f, 2.16249712e-02f, 1.21851452e-02f, 2.75788717e-02f, -1.00140668e-01f, -7.65548497e-02f, -2.35537201e-01f, 3.30858454e-02f, -6.94837794e-02f, 7.23459199e-03f,
  -1.38177708e-01f, -5.99780828e-02f, 1.71909779e-02f, -8.54258835e-02f, 4.61522229e-02f, 4.26048152e-02f, 3.95772122e-02f, 1.92738637e-01f, 1.01112559e-01f, 1.95203811e-01f,
  -4.59926754e-01f, -4.89514679e-01f, -3.15490395e-01f, -4.34337705e-01f, -4.00885880e-01f, -1.12759091e-01f, -3.46907347e-01f, -1.80525687e-02f, 3.51919308e-02f, -3.47578317e-01f,
  -2.89562672e-01f, -1.85600728e-01f, -2.52960086e-01f, 2.95661781e-02f, 5.62663935e-02f, -2.72427768e-01f, -2.12720066e-01f, 1.64711829e-02f, 2.97529846e-01f, 7.38279298e-02f,
  -1.52431848e-02f, -1.63565621e-01f, 1.94043472e-01f, 7.46071860e-02f, -3.35937589e-01f, -1.57320410e-01f, -2.16959521e-01f, -1.79390177e-01f, 8.42704065e-03f, -3.28732312e-01f,
  -3.72741699e-01f, -3.26326907e-01f, 1.93038702e-01f, 3.57986428e-02f, -2.13624045e-01f, 1.36451393e-01f, -1.42837450e-01f, -1.54764960e-02f, 6.22261502e-02f, 3.00538428e-02f,
  -1.24001771e-01f, 7.54516274e-02f, -2.07293630e-01f, -7.07902983e-02f, -1.25871733e-01f, 3.05199232e-02f, 8.92647058e-02f, 1.99239478e-01f, 4.63702939e-02f, -3.76646109e-02f,
  -3.62494998e-02f, -8.13981071e-02f, -8.11128616e-02f, 2.17765063e-01f, 8.25072527e-02f, 1.26593281e-02f, 9.10435170e-02f, 2.57190377e-01f, 3.75117302e-01f, -1.30893886e-01f,
  5.93654364e-02f, -6.66585863e-02f, -9.34290420e-03f, -1.25218928e-01f, 1.44288149e-02f, 5.05840546e-03f, -7.79060945e-02f, -8.25107545e-02f, -1.14221396e-02f, 9.34910253e-02f,
  -6.06594644e-02f, -6.37608096e-02f, 4.65537310e-02f, -7.28614107e-02f, -1.15316041e-01f, 6.81050196e-02f, -4.82214615e-02f, -3.45004052e-02f, 3.80908110e-04f, -6.39550537e-02f,
  -1.03802448e-02f, 1.16352595e-01f, 1.34966699e-02f, 1.14083782e-01f, -5.42634055e-02f, -1.48328662e-01f, 2.05112305e-02f, 1.23174034e-01f, -5.90711199e-02f, -4.22025174e-02f,
  -2.08064124e-01f, 2.62296349e-01f, -2.78682262e-01f, 7.12222904e-02f, -5.81715442e-02f, 6.75512478e-02f, -2.22702459e-01f, -2.13521589e-02f, -8.42730775e-02f, -1.86679572e-01f,
  3.19107659e-02f, -1.19179636e-01f, -1.51049003e-01f, -5.05153537e-02f, -4.04152051e-02f, 7.41535872e-02f, -2.30994951e-02f, -1.21727467e-01f, 7.72607997e-02f, 1.44418746e-01f,
  7.72139132e-02f, 2.77725887e-02f, -1.01221725e-01f, 2.16341089e-03f, 6.58460408e-02f, -1.55295730e-01f, -1.47504419e-01f, 4.20803204e-02f, 1.98367044e-01f, -9.28639695e-02f,
  -7.22469747e-01f, -2.85092980e-01f, 1.72173306e-01f, -1.93351746e-01f, 9.36586559e-02f, 1.17486201e-01f, -7.53893703e-02f, -5.77367954e-02f, -6.84352815e-02f, -2.60236472e-01f,
  7.82488137e-02f, -2.50263866e-02f, -3.26050460e-01f, -1.93915769e-01f, -2.57267743e-01f, -4.13005799e-01f, -3.10538888e-01f, -7.66402930e-02f, 1.21442050e-01f, 3.15260410e-01f,
  1.63846985e-01f, 1.53296674e-02f, -4.84756790e-02f, 4.05589081e-02f, -1.95786729e-01f, -1.48814656e-02f, -1.75740257e-01f, -1.56455621e-01f, 6.99510947e-02f, -3.69459927e-01f,
  -3.17846864e-01f, -6.12450466e-02f, 1.65566713e-01f, -2.23767936e-01f, 2.06755415e-01f, -8.69909748e-02f, 7.38741532e-02f, -7.13659301e-02f, 1.67614132e-01f, -5.30642942e-02f,
  3.02701667e-02f, 1.67674750e-01f, -6.62531285e-03f, 1.71813488e-01f, -1.95565931e-02f, -1.51489703e-02f, 4.68479283e-02f, -4.60219532e-02f, -4.48772199e-02f, 1.76927119e-01f,
  -8.25600922e-02f, -2.82822037e-03f, -2.49166250e-01f, 3.89092714e-02f, 4.31882069e-02f, -1.16507575e-01f, 1.53347686e-01f, 7.95243904e-02f, -1.86214224e-02f, -3.60754669e-01f,
  3.19021791e-02f, 9.09134671e-02f, 3.28830220e-02f, 4.38473048e-03f, -6.57871040e-03f, 6.23855628e-02f, 5.01513481e-02f, 1.32492892e-02f, 4.82467189e-02f, -8.01476687e-02f,
  1.65939182e-01f, 9.03599635e-02f, 1.10187106e-01f, -5.71810231e-02f, 3.18804532e-02f, 4.66722213e-02f, -6.22529387e-02f, -9.32285488e-02f, -8.80118366e-03f, 1.52187884e-01f,
  -1.60616025e-01f, -3.41847353e-02f, 4.66738045e-02f, 4.99834269e-02f, -2.02998444e-02f, -1.63848832e-01f, 1.86418027e-01f, -8.88029858e-02f, -2.56465822e-02f, -9.58637819e-02f,
  -3.50554287e-01f, 1.97502166e-01f, -6.63694218e-02f, -3.42137553e-02f, 6.57853484e-02f, 4.42623980e-02f, 4.49834950e-02f, 2.40569431e-02f, 1.28171630e-02f, 7.77706213e-04f,
  2.17618681e-02f, -6.80058524e-02f, -8.45173523e-02f, 5.22870384e-02f, 2.42614858e-02f, -2.13186011e-01f, -1.64293110e-01f, -4.17844541e-02f, -1.98920161e-01f, 1.26290232e-01f,
  -1.81170031e-01f, -2.57851243e-01f, -4.51880395e-01f, -4.69710618e-01f, -3.02700907e-01f, -2.06510633e-01f, -2.52988994e-01f, -1.69666290e-01f, -3.03103685e-01f, -7.60518491e-01f,
  -3.48750204e-01f, 4.03344810e-01f, -2.45144710e-01f, 4.21208531e-01f, 2.87083834e-01f, 2.01082289e-01f, 2.99421400e-01f, 8.29318240e-02f, 4.41409983e-02f, 8.07559639e-02f,
  6.71623200e-02f, 1.99848805e-02f, 9.95497629e-02f, 7.08328038e-02f, 2.12742258e-02f, 7.43572339e-02f, 1.66721940e-01f, -1.64803416e-01f, -1.89982295e-01f, -1.09746559e-02f,
  2.06196114e-01f, 7.01991050e-03f, -2.73856640e-01f, -5.54701127e-02f, 1.05100267e-01f, 1.30779326e-01f, 7.93016423e-03f, -3.37591469e-02f, 7.75900856e-02f, 2.87822857e-02f,
  -3.81601304e-01f, -2.42335320e-01f, -2.16813490e-01f, -2.62000471e-01f, -1.27107352e-01f, -2.85685360e-01f, -1.31982669e-01f, -2.50757396e-01f, -1.64910823e-01f, -1.63335070e-01f,
  -2.70651095e-02f, -1.16665959e-01f, 2.44800150e-01f, -1.08074918e-01f, -7.18301013e-02f, -2.55795896e-01f, -3.33226979e-01f, -4.82134521e-01f, -4.04272228e-01f, -4.10131574e-01f,
  5.11726797e-01f, 1.95656389e-01f, -4.15164918e-01f, -8.05097595e-02f, -1.45545959e-01f, -1.18176498e-01f, -2.41673678e-01f, -2.83575654e-01f, -3.05965155e-01f, -4.81767863e-01f,
  -5.35009801e-02f, 6.07876200e-03f, -5.71352914e-02f, -6.43387139e-02f, 1.31749839e-01f, 4.37616929e-03f, 2.20561564e-01f, 1.00468352e-01f, 1.09870210e-01f, -1.32357165e-01f,
  1.49148613e-01f, -1.48131130e-02f, -1.35362580e-01f, -1.08528934e-01f, 1.95729986e-01f, 4.56256010e-02f, 7.32330233e-02f, -1.09629417e-02f, -1.44299477e-01f, -1.66988913e-02f,
  1.36317555e-02f, 7.30873644e-03f, -1.65838357e-02f, -2.23481178e-01f, -1.07871316e-01f, -1.02037817e-01f, -5.77724501e-02f, -6.02165721e-02f, -3.49248610e-02f, -4.16975245e-02f,
  9.67442170e-02f, 1.48998369e-02f, -5.50268292e-02f, 1.03721179e-01f, -1.19215444e-01f, -8.61841366e-02f, 1.50056317e-01f, 7.49485791e-02f, -2.81067728e-03f, -8.77262056e-02f,
  -2.05473509e-02f, 7.94570893e-02f, 2.75320321e-01f, -1.39683679e-01f, -9.71324816e-02f, -7.94715881e-02f, -3.70861180e-02f, -1.19455770e-01f, -1.25321552e-01f, -1.85055211e-01f,
  1.32154673e-01f, -2.81341071e-03f, -2.88574249e-01f, -1.10611148e-01f, -1.82843348e-03f, 2.06047282e-01f, -6.43609464e-02f, -3.00837964e-01f, -2.48709276e-01f, -3.06639731e-01f,
  5.02402067e-01f, -7.79300272e-01f, 2.41513580e-01f, 1.18221499e-01f, 4.53545637e-02f, 1.32553264e-01f, 1.83689804e-03f, -9.30325408e-03f, -9.68468469e-03f, -1.46455243e-01f,
  2.08803508e-02f, 1.37904540e-01f, 1.65586427e-01f, 7.08769634e-02f, 1.17824459e-02f, -1.41064152e-01f, -1.72470152e-01f, 2.11716279e-01f, 5.57180345e-01f, 2.62179285e-01f,
  -1.29286334e-01f, -1.54796049e-01f, -8.79818872e-02f, -9.16235894e-02f, -1.69882476e-01f, 2.79800236e-01f, -1.67623997e-01f, -2.33088374e-01f, -2.26513952e-01f, -3.90573621e-01f,
  3.11647058e-01f, -3.06517124e-01f, 2.82840014e-01f, -2.62522865e-02f, -2.65912637e-02f, 7.45837539e-02f, -6.29464956e-03f, -1.14417598e-01f, -5.18788658e-02f, 9.16944537e-03f,
  -7.99289793e-02f, -9.33507085e-02f, -4.01836932e-02f, 2.79698037e-02f, -6.69352710e-02f, 3.82587947e-02f, -1.81615889e-01f, -1.22046962e-01f, -5.54220788e-02f, 4.56102937e-02f,
  -2.17118263e-01f, -1.90991342e-01f, -6.35946691e-02f, -9.65023637e-02f, -6.03491776e-02f, 8.68405998e-02f, -1.41683042e-01f, -8.85497183e-02f, -5.91176040e-02f, -2.38268793e-01f,
  -3.95551659e-02f, 5.59072681e-02f, -9.23989788e-02f, 9.87128541e-03f, 6.29020035e-02f, 2.91578844e-02f, -5.21221980e-02f, 3.36298347e-03f, -7.03412220e-02f, 1.32087367e-02f,
  -6.68971986e-02f, 4.98079881e-02f, -9.31861028e-02f, 2.55207624e-02f, -7.87692294e-02f, -3.56522501e-02f, -3.88216786e-02f, -1.15411744e-01f, -2.21545063e-02f, 1.15216382e-01f,
  5.53132705e-02f, -3.00817825e-02f, 2.80285049e-02f, 9.64580011e-03f, 3.86055070e-03f, -7.85512198e-03f, 1.31045818e-01f, 8.02676845e-03f, 8.77833813e-02f, 1.38422977e-02f,
  1.10174745e-01f, -9.80382487e-02f, 2.09915936e-01f, -1.21719446e-02f, -8.15361440e-02f, -1.26197711e-01f, 5.91885857e-02f, -8.07648674e-02f, 2.96890084e-02f, -2.66847108e-02f,
  -4.07217108e-02f, -3.33602540e-02f, -1.72991119e-02f, -1.17491923e-01f, 1.23973221e-01f, 1.95667483e-02f, -1.08195096e-01f, 1.75275013e-01f, -2.01936625e-02f, -2.09603459e-02f,
  -1.46454766e-01f, 7.76575953e-02f, 1.93595156e-01f, 8.82296115e-02f, 6.53463975e-02f, 3.34102035e-01f, 1.96065798e-01f, 8.19343701e-02f, 2.62623042e-01f, -3.24352495e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.27572909e-01f, 7.12817758e-02f, 3.56045842e-01f, 1.73506826e-01f, 2.49147356e-01f, 1.42413631e-01f, -3.87584642e-02f, 6.57732487e-01f, 7.57683739e-02f, 1.57697916e-01f,
  1.68149620e-01f, 5.45839071e-01f, 3.52030426e-01f, 1.91172466e-01f, 6.11813702e-02f, 1.97601765e-01f, 3.73107105e-01f, 3.30687523e-01f, 2.41595551e-01f, 3.37954015e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.19048156e-01f, 1.84213176e-01f, 1.63405329e-01f, -3.71225387e-01f, -3.90045047e-02f, -2.37818301e-01f, 1.92942321e-02f, 1.36541724e-01f, 1.06291927e-01f, -8.15844722e-03f,
  -2.75047630e-01f, 8.75619799e-02f, 6.86116740e-02f, 2.75014378e-02f, -1.65647775e-01f, -8.62947777e-02f, 3.16900373e-01f, 5.95437139e-02f, -1.38452083e-01f, -5.47111034e-03f,
  -5.37575781e-02f, -1.44173816e-01f, -2.04570845e-01f, -3.28284234e-01f, 1.74435481e-01f, 4.66473371e-01f, 4.07007597e-02f, 8.39874223e-02f, -8.84635746e-02f, 1.32061010e-02f,
  -1.89913109e-01f, -3.23039651e-01f, 3.63855041e-03f, -1.45230636e-01f, -1.11770496e-01f, 1.09504135e-02f, 3.80771607e-02f, 7.26885200e-02f, -2.22054631e-01f, 2.11444691e-01f,
  6.91314861e-02f, -1.28654717e-02f, 1.25147372e-01f, -1.33939147e-01f, -1.87423736e-01f, 1.72746852e-01f, -1.14259377e-01f, 1.07751057e-01f, -2.49704853e-01f, -2.22416446e-01f,
  7.72471949e-02f, -1.52980730e-01f, 1.90731078e-01f, 1.46388799e-01f, 6.81463629e-02f, 4.23604727e-01f, 1.01952124e-02f, -1.12936899e-01f, -6.85474873e-02f, 2.73854248e-02f,
  -2.64511883e-01f, -4.13507968e-01f, 6.20155931e-02f, 3.29064935e-01f, 1.02216616e-01f, 1.41348287e-01f, -8.61845836e-02f, 1.64151549e-01f, 6.86970679e-03f, 3.92052606e-02f,
  2.75405258e-01f, -5.45834191e-02f, -1.12325445e-01f, -1.17240064e-01f, 9.08930507e-03f, -2.29949057e-01f, 1.80344507e-01f, 2.96127439e-01f, 3.41213569e-02f, 3.36961031e-01f,
  -2.02825069e-01f, -1.13150716e-01f, 1.86680064e-01f, 1.97453380e-01f, 2.50511885e-01f, 6.48812652e-02f, -1.01457186e-01f, -1.44529700e-01f, 1.02983780e-01f, -1.65944606e-01f,
  -7.91131780e-02f, 1.11620845e-02f, -3.31944004e-02f, 3.64383459e-01f, -3.00407439e-01f, 2.40428478e-01f, 3.26530566e-03f, -2.10782196e-02f, 1.34490684e-01f, 3.92438918e-02f,
  -2.41089575e-02f, 1.75944999e-01f, 1.77273944e-01f, 1.08139627e-01f, 1.86958879e-01f, -1.91984981e-01f, -4.56285067e-02f, 3.94540541e-02f, 1.32227689e-01f, -6.53496897e-03f,
  -7.29442611e-02f, -5.21560609e-02f, -3.26091439e-01f, 5.00528701e-02f, -5.80296069e-02f, 8.53948221e-02f, 1.06000490e-01f, 1.51243851e-01f, 1.44293085e-01f, -2.63809383e-01f,
  -9.38796718e-03f, -3.76576632e-01f, 3.81763875e-01f, -6.92085847e-02f, 1.38129547e-01f, 2.29004040e-01f, 1.20046700e-03f, 4.31155264e-01f, -3.91596854e-02f, 2.04395041e-01f,
  1.15686573e-01f, 5.47107868e-03f, -2.10572295e-02f, 6.06584176e-03f, 5.94843626e-02f, -3.55326906e-02f, -1.11023083e-01f, -5.58101721e-02f, -1.02384677e-02f, 5.18710911e-02f,
  -1.43796563e-01f, 7.82377645e-02f, 1.72433108e-02f, -1.19962871e-01f, 1.86835662e-01f, 7.34762289e-03f, 1.68269724e-01f, 5.18239625e-02f, 6.85329363e-02f, 4.89544496e-02f,
  -2.66431998e-02f, -1.35922879e-01f, 1.68288693e-01f, 2.54905581e-01f, -1.99015066e-02f, -3.58685493e-01f, -2.32041776e-01f, 4.03137803e-02f, 4.40111831e-02f, 4.66042496e-02f,
  -1.34754658e-01f, -4.71099727e-02f, -2.43564785e-01f, -3.58794257e-02f, 1.85987860e-01f, 1.94567636e-01f, -1.29738167e-01f, 9.47681367e-02f, 6.95404112e-02f, -1.13427378e-01f,
  3.06110214e-02f, -9.22173709e-02f, 1.01467967e-01f, -1.63581800e-02f, 1.54962778e-01f, -2.03130037e-01f, -2.01942831e-01f, -1.04066096e-01f, 2.14712303e-02f, -9.00090337e-02f,
  6.85793683e-02f, -8.89437199e-02f, 1.53450429e-01f, -1.18744761e-01f, -2.39656195e-01f, -2.81972587e-01f, -2.05203980e-01f, -3.16237956e-01f, -5.62871620e-02f, 1.00548863e-01f,
  2.20587812e-02f, -3.62303793e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.62539828e-01f, 2.89190292e-01f, 3.50583613e-01f, 1.56709865e-01f, 2.11645827e-01f, 1.23602143e-02f, 4.40902077e-02f, 1.85758974e-02f, -2.54280865e-01f, 6.57684030e-03f,
  -3.30553278e-02f, 1.76809251e-01f, 2.22352147e-02f, 2.53862679e-01f, -1.30250186e-01f, 1.76562905e-01f, 5.40614963e-01f, 6.41137436e-02f, 5.78808784e-02f, 7.28554502e-02f,
  3.38918626e-01f, -3.10044974e-01f, -3.94180827e-02f, 1.64079309e-01f, 3.18979286e-02f, 6.53638959e-01f, 2.01049954e-01f, -4.64060679e-02f, -1.13471374e-01f, -6.28365278e-02f,
  -3.60832721e-01f, -2.12183613e-02f, -1.11653106e-02f, 7.07138836e-01f, 3.89103621e-01f, -1.42473102e-01f, 3.74915868e-01f, 2.84550279e-01f, 1.12860814e-01f, -1.31703997e-02f,
  1.03426151e-01f, -3.07986081e-01f, 3.25931497e-02f, -1.82894722e-01f, 2.29039714e-01f, -1.58365026e-01f, -2.64341861e-01f, 2.25268248e-02f, 1.28103912e-01f, -8.11808929e-02f,
  1.67178009e-02f, -8.91011238e-01f, 6.24027610e-01f, 1.27023265e-01f, -5.61227761e-02f, -6.99271858e-02f, 2.34305620e-01f, 1.81285903e-01f, 2.38895357e-01f, 4.74686623e-02f,
  6.47912025e-02f, 3.39640379e-02f, 3.73067617e-01f, -1.74586833e-01f, 1.48841396e-01f, -1.12391658e-01f, -7.70357028e-02f, 6.08785637e-02f, 7.79899433e-02f, 7.58947656e-02f,
  -1.45446092e-01f, 2.95635849e-01f, 3.82240772e-01f, 2.24711914e-02f, -5.41712195e-02f, -2.70210654e-01f, 3.63192439e-01f, -2.52689779e-01f, -2.64083415e-01f, 1.30938336e-01f,
  7.07322955e-02f, -4.40094508e-02f, -1.76686682e-02f, -4.59129691e-01f, 2.70728320e-01f, 2.01245219e-01f, 6.12660591e-03f, -1.62177742e-01f, -3.89862130e-03f, 1.48529053e-01f,
  3.90330166e-01f, 4.93995905e-01f, 6.11520372e-02f, 1.37976393e-01f, 2.32055902e-01f, 1.06340259e-01f, 3.18229496e-01f, 3.06614369e-01f, 7.60368824e-01f, -5.74367754e-02f,
  3.97025496e-01f, -1.17043689e-01f, -2.89297938e-01f, -2.44923517e-01f, -9.98011008e-02f, 5.93586899e-02f, -2.92710185e-01f, 2.13911891e-01f, -8.73123482e-02f, 5.38903028e-02f,
  -1.61071252e-02f, 1.88657016e-01f, 5.68349123e-01f, 1.71383202e-01f, -4.04117644e-01f, 2.66366780e-01f, 1.72539815e-01f, -3.65413964e-01f, -1.73707336e-01f, 4.37615961e-01f,
  2.97485083e-01f, 7.38037288e-01f, -1.73646927e-01f, 1.77233770e-01f, -1.21057272e-01f, -1.19120575e-01f, -2.12379456e-01f, -4.55683731e-02f, 3.10633779e-01f, -1.14510462e-01f,
  1.33185759e-01f, 2.93595552e-01f, -2.26928331e-02f, 3.98371160e-01f, -8.23426470e-02f, 4.59380776e-01f, 3.06509644e-01f, 2.72916734e-01f, 3.41346920e-01f, 1.52307570e-01f,
  1.70593876e-02f, -1.71913728e-01f, -2.22750425e-01f, 5.67864105e-02f, 1.62035108e-01f, -3.07922840e-01f, -2.27644384e-01f, 6.76500499e-01f, -3.17856401e-01f, 3.45565856e-01f,
  4.85614985e-01f, 6.53914452e-01f, 6.74475953e-02f, -7.79150128e-02f, -3.10109496e-01f, 1.88056737e-01f, 3.87508661e-01f, 1.07200183e-01f, -1.62540615e-01f, 3.90992790e-01f,
  3.63336563e-01f, 2.51559019e-01f, 8.68305922e-01f, 4.48836163e-02f, 2.24883035e-01f, 2.24034674e-02f, 3.78627658e-01f, 3.46571177e-01f, 4.76051420e-02f, -9.83692557e-02f,
  -2.23475508e-02f, -7.17381388e-02f, 1.45106465e-01f, -7.31729865e-02f, -2.50554830e-01f, 3.26872796e-01f, 1.70770407e-01f, -1.01866290e-01f, -1.10047676e-01f, -1.94999769e-01f,
  5.48445582e-01f, 1.71204716e-01f, 1.79878920e-02f, 3.43801647e-01f, 4.91265148e-01f, 1.29391272e-02f, 2.42068663e-01f, 3.47861975e-01f, -3.39397967e-01f, 1.18255898e-01f,
  -3.69726829e-02f, 3.19064856e-01f, 4.59823549e-01f, 1.63306966e-01f, 4.68669713e-01f, 5.46126403e-02f, 2.54793465e-01f, 4.78510767e-01f, -2.67423004e-01f, -4.58200693e-01f,
  -3.17925304e-01f, -2.80228823e-01f, -4.26495284e-01f, 5.97989000e-02f, 1.65782183e-01f, -1.17887491e-02f, 4.00014341e-01f, 1.04345828e-01f, 1.45995256e-03f, 2.03763694e-01f,
  -4.43567574e-01f, 1.58316895e-01f, 2.48399794e-01f, -2.65425622e-01f, -3.83564889e-01f, 2.56299794e-01f, -1.12216644e-01f, 2.72151977e-01f, -6.37926310e-02f, -2.06557419e-02f,
  -3.59742045e-02f, 1.54282516e-02f, -2.13100508e-01f, 2.71720797e-01f, 1.12562194e-01f, 5.07066771e-02f, 1.27437174e-01f, 3.71711254e-02f, 2.10942507e-01f, 3.45539927e-01f,
  -8.99698436e-02f, 2.57603228e-01f, -4.14998345e-02f, -6.41672909e-02f, -1.05697535e-01f, -9.10897925e-03f, 3.45683485e-01f, 1.35255083e-01f, 1.35744184e-01f, 6.78253472e-02f,
  -3.79351169e-01f, 3.04911762e-01f, 9.70381349e-02f, 2.27053110e-02f, 3.92631322e-01f, 2.63725311e-01f, 7.70249739e-02f, 1.20174415e-01f, 2.59750992e-01f, -3.53326499e-01f,
  2.41278838e-02f, 1.65350601e-01f, 2.73614712e-02f, -1.00031324e-01f, 1.83835644e-02f, 4.19569552e-01f, 2.58970022e-01f, 3.97337198e-01f, 4.05810803e-01f, 2.24289268e-01f,
  7.56806433e-02f, 1.76039726e-01f, -1.74468264e-01f, 2.55263746e-01f, 5.51072694e-03f, -3.37564588e-01f, 8.24116752e-04f, -2.02758521e-01f, 7.48348162e-02f, -2.21294597e-01f,
  3.01825672e-01f, -7.07522184e-02f, -3.15275609e-01f, 2.92574584e-01f, 1.49696395e-01f, 5.02772257e-02f, 7.36848772e-01f, 2.56381065e-01f, 1.54433280e-01f, -2.77923882e-01f,
  -3.74755897e-02f, -3.92933726e-01f, 3.33505720e-01f, -1.01408958e-01f, 4.21231419e-01f, 2.90068299e-01f, 1.93435177e-01f, -1.29371062e-01f, 1.60109133e-01f, -1.15534797e-01f,
  3.21353674e-02f, 3.06254085e-02f, 1.07278466e-01f, 3.87595087e-01f, -4.97178853e-01f, 6.34569049e-01f, 1.69451028e-01f, -1.55853173e-02f, 3.64084274e-01f, 2.03342512e-01f,
  3.14965099e-01f, -1.32154271e-01f, -3.99394840e-01f, -4.97757196e-01f, 3.26920033e-01f, -2.35667467e-01f, -2.36680523e-01f, -6.74015701e-01f, -2.38660634e-01f, 2.99537271e-01f,
  2.16776296e-01f, 5.35760581e-01f, 2.73995936e-01f, 3.54304224e-01f, 4.99426238e-02f, 6.07988954e-01f, 6.66752830e-02f, 1.04092836e-01f, 2.46386200e-01f, -1.29709035e-01f,
  -3.75390351e-02f, 1.12822406e-01f, 5.04579991e-02f, -1.61737725e-01f, 2.22536087e-01f, 9.53752100e-02f, 3.00357312e-01f, 2.50502706e-01f, 2.01127678e-01f, 2.78595507e-01f,
  2.13987548e-02f, 5.23616485e-02f, 1.38262942e-01f, -4.82653022e-01f, 1.12307712e-01f, -4.35144544e-01f, 4.99975741e-01f, -2.78548121e-01f, 1.26036406e-01f, -1.27915040e-01f,
  -2.12771416e-01f, 3.09998512e-01f, 1.15287155e-01f, 2.87625343e-01f, 1.31543040e-01f, -2.68427610e-01f, 8.00293405e-03f, -3.73754948e-02f, 5.36892414e-01f, 6.13082528e-01f,
  3.33578050e-01f, -3.89198780e-01f, 2.84626335e-01f, -7.75471255e-02f, -6.48184240e-01f, 5.95631450e-02f, -1.73957035e-01f, 1.08687624e-01f, 3.19293290e-01f, 3.69127661e-01f,
  4.15448308e-01f, 2.85391599e-01f, 5.18104076e-01f, 1.50868548e-02f, 1.83795914e-01f, -3.25462162e-01f, 9.17182043e-02f, -1.86193287e-01f, 1.36143163e-01f, 6.37946203e-02f,
  1.07948422e-01f, 7.44884431e-01f, -2.32708901e-01f, 2.04749584e-01f, -9.03854296e-02f, -9.43110809e-02f, 1.48461774e-01f, -6.56935632e-01f, 1.33985013e-01f, 1.81888252e-01f,
  1.76002949e-01f, 9.05998498e-02f, -1.68408841e-01f, 4.57655966e-01f, 3.87939185e-01f, -7.94751868e-02f, 8.00389230e-01f, 3.70622754e-01f, 3.53293985e-01f, 3.71514797e-01f,
  -6.17773652e-01f, -8.74574557e-02f, -7.84843564e-02f, -4.74921644e-01f, 3.17646824e-02f, 1.26570567e-01f, -2.79232115e-01f, -1.53416125e-02f, 2.22178549e-01f, 5.02208062e-02f,
  1.64422914e-02f, 3.58795583e-01f, -3.46019149e-01f, 1.88061923e-01f, 3.84049416e-02f, -1.58313923e-02f, 4.99243811e-02f, 4.40905958e-01f, -8.36640745e-02f, 6.96523860e-02f,
  4.36671451e-02f, -2.07867220e-01f, 1.64321452e-01f, 1.74755789e-02f, 2.93352693e-01f, -2.86529064e-01f, -2.32984554e-02f, -1.68436840e-01f, -3.73163819e-01f, 3.15718025e-01f,
  2.25222096e-01f, 3.47647697e-01f, -2.18496367e-01f, -2.39123717e-01f, -1.66682348e-01f, 3.38709086e-01f, 1.51422650e-01f, -2.56997421e-02f, 1.46133706e-01f, -7.70459846e-02f,
  3.32025915e-01f, 4.34506238e-02f, -7.33337016e-04f, 3.84192228e-01f, 4.21614461e-02f, 4.43619996e-01f, -2.42854759e-01f, 2.45274216e-01f, 2.71692336e-01f, -2.19963938e-02f,
  4.89381962e-02f, -8.14275146e-02f, -1.35620683e-02f, 2.88019001e-01f, 2.86101460e-01f, -7.64075443e-02f, 3.13368976e-01f, 3.98017168e-01f, 5.41610084e-02f, 2.40218207e-01f,
  5.30586958e-01f, 1.53247163e-01f, 1.87913612e-01f, 2.47178711e-02f, 7.64805734e-01f, 6.54634163e-02f, 2.18368620e-01f, 1.77190796e-01f, 2.46419862e-01f, 2.01055288e-01f,
  2.76301116e-01f, -5.08946419e-01f, -8.13148469e-02f, -7.61296824e-02f, 3.61627370e-01f, -4.13783818e-01f, -1.08836040e-01f, 5.57733655e-01f, -1.88263297e-01f, -3.83032821e-02f,
  -5.76181412e-01f, -4.91959155e-01f, -1.63677365e-01f, -1.30436718e-01f, 3.04981560e-01f, -1.54194713e-01f, 3.39313775e-01f, 5.19891083e-01f, -9.11946520e-02f, -3.07554185e-01f,
  2.17077836e-01f, 3.24555099e-01f, 6.44512847e-02f, 1.45859599e-01f, 9.98436585e-02f, 2.60921687e-01f, -1.97022602e-01f, 3.23597528e-02f, 1.42658427e-01f, 6.62640557e-02f,
  -8.46339911e-02f, 1.28285913e-02f, 3.30162138e-01f, -4.22902517e-02f, -1.38885036e-01f, -2.04371303e-01f, 2.78912485e-01f, -3.61235678e-01f, 2.28111848e-01f, -2.23714188e-01f,
  -1.59226835e-01f, -1.10202776e-02f, 1.46298081e-01f, -2.82250673e-01f, 2.80073494e-01f, 5.45325518e-01f, 1.02872409e-01f, 4.07008231e-01f, 3.46388221e-01f, 3.36148441e-01f,
  2.13625938e-01f, -6.21110238e-02f, 5.23258746e-01f, 7.06960931e-02f, 5.01765966e-01f, 2.75610745e-01f, 2.95809567e-01f, 1.51628733e-01f, -2.02347204e-01f, 5.16944408e-01f,
  3.54693204e-01f, 4.46355715e-02f, 2.63922513e-01f, 1.87070310e-01f, 1.47951305e-01f, -1.50123462e-01f, -2.45682463e-01f, 2.65867501e-01f, 3.33788425e-01f, 7.05174431e-02f,
  -9.67651308e-02f, -1.31717429e-01f, -3.79290283e-01f, 1.27767757e-01f, 2.67715424e-01f, 1.02908504e+00f, 4.05592799e-01f, 6.46318316e-01f, -4.15114313e-02f, 4.96211559e-01f,
  -1.54910013e-01f, -1.95022285e-01f, 6.99874237e-02f, 2.57302940e-01f, 3.24461274e-02f, 2.66969711e-01f, -2.03722231e-02f, 2.45102435e-01f, 1.69549331e-01f, 3.27469170e-01f,
  -8.07961598e-02f, -1.32154912e-01f, -3.07394356e-01f, 1.09558828e-01f, -1.96753815e-03f, 2.51481771e-01f, -4.44810182e-01f, -8.64712596e-02f, 3.77943039e-01f, 2.33612597e-01f,
  5.82231700e-01f, 1.23561785e-01f, 3.05860519e-01f, -1.75024793e-01f, -4.88705218e-01f, 2.46176139e-01f, -2.11116016e-01f, -4.24166679e-01f, 1.86113626e-01f, 4.61066842e-01f,
  -4.85786587e-01f, -2.11435944e-01f, -3.52803439e-01f, 1.72961846e-01f, 4.61693615e-01f, -1.11260526e-01f, 2.59307951e-01f, 7.52375796e-02f, -1.16566859e-01f, 1.10436402e-01f,
  1.64381847e-01f, 1.39762387e-01f, 8.46886635e-02f, 2.83562809e-01f, 2.55548209e-01f, -8.30883458e-02f, 2.98615366e-01f, -1.87373161e-01f, 2.48723462e-01f, -1.98442400e-01f,
  2.12626994e-01f, -2.14680955e-01f, 2.11575180e-01f, -2.52796918e-01f, 2.46523187e-01f, -2.97627121e-01f, 1.89326450e-01f, 1.77469790e-01f, -5.42392433e-02f, 6.68540224e-02f,
  2.83134520e-01f, -1.65558726e-01f, 5.51286340e-02f, 2.52877504e-01f, 5.70297480e-01f, 4.95959997e-01f, 3.36981595e-01f, -1.54480115e-01f, 3.08305681e-01f, -1.41910613e-01f,
  -2.43465111e-01f, 3.95523906e-01f, 2.38061100e-01f, 1.49348572e-01f, -9.11954939e-02f, 9.11789536e-02f, 2.31931787e-02f, 1.88242227e-01f, -8.92535225e-02f, 3.78454663e-02f,
  7.36272633e-02f, 3.01583633e-02f, 2.94323210e-02f, 4.50760573e-01f, -1.45609155e-01f, 4.88590181e-01f, -2.06402928e-01f, 6.33152008e-01f, 2.72666484e-01f, 2.24777192e-01f,
  -3.07413787e-02f, 2.97623098e-01f, -1.76214855e-02f, -5.52836694e-02f, 3.24683730e-03f, -3.57634909e-02f, 3.76648009e-02f, -4.82796073e-01f, -2.65089810e-01f, 6.29550338e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  8.26358348e-02f, 2.14082271e-01f, 2.56730467e-01f, 2.05246374e-01f, 2.87764430e-01f, 8.11635479e-02f, 3.80972952e-01f, -7.92614594e-02f, 2.99163252e-01f, 3.08732152e-01f,
  3.56339633e-01f, 1.18633136e-01f, 3.69194597e-01f, 9.63536277e-02f, 3.01709980e-01f, 2.66088337e-01f, 1.83228031e-01f, 4.93946999e-01f, 3.98051500e-01f, -1.10369422e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.67884052e-01f, 2.63510019e-01f, -6.30247742e-02f, 2.87017487e-02f, -7.16156363e-02f, -7.65945166e-02f, -2.14832321e-01f, 4.06449251e-02f, 2.13547528e-01f, 1.99778497e-01f,
  4.30481099e-02f, -1.52148664e-01f, -4.30261791e-01f, -1.52408436e-01f, 2.28868201e-01f, -3.94725412e-01f, 4.08333167e-02f, 8.97492468e-02f, 8.94424245e-02f, 2.14212742e-02f,
  -2.84782015e-02f, 9.10697803e-02f, -5.40352352e-02f, 4.46747333e-01f, -7.21644461e-02f, 8.38660970e-02f, 1.90247476e-01f, -5.91670386e-02f, -3.16665433e-02f, 7.81145841e-02f,
  1.67777017e-02f, 2.62565613e-01f, -1.00951873e-01f, -3.74357440e-02f, 9.59278941e-02f, -7.90206343e-02f, -4.72337216e-01f, -2.29912147e-01f, -3.02102804e-01f, -1.57234948e-02f,
  6.25663027e-02f, -3.73080194e-01f, 8.02549541e-01f, -2.05581665e-01f, -1.60597101e-01f, -2.53153652e-01f, -1.84726268e-01f, -1.67790592e-01f, 2.56018192e-02f, -6.80915639e-02f,
  -2.42731363e-01f, -8.49443227e-02f, -2.42582202e-01f, 1.02804288e-01f, 3.19038518e-02f, 2.75108218e-01f, -2.10039511e-01f, 6.02040999e-02f, -6.18729778e-02f, 2.32869491e-01f,
  1.21901110e-01f, 1.70249611e-01f, 1.80204794e-01f, -1.75283790e-01f, -3.78907248e-02f, -1.63936958e-01f, 5.33774979e-02f, 3.24350372e-02f, 2.29414068e-02f, 1.03975572e-01f,
  3.94351959e-01f, -3.79451692e-01f, 5.33993170e-02f, 1.83785986e-02f, -1.05362698e-01f, 1.59052879e-01f, 1.89775586e-01f, 2.40651786e-01f, -1.88586205e-01f, 2.17738241e-01f,
  -8.95479992e-02f, 5.63066304e-02f, -1.71983317e-02f, -1.82380617e-01f, -4.19111475e-02f, -7.89548643e-03f, 1.70445487e-01f, -3.17714453e-01f, 6.76687807e-02f, -3.15730542e-01f,
  5.90606816e-02f, 1.89357534e-01f, 1.64712727e-01f, -9.14395675e-02f, -1.30555853e-01f, -1.89537555e-01f, 4.74078879e-02f, -2.28564158e-01f, 1.95436284e-01f, 2.56435513e-01f,
  -2.57983953e-02f, 2.99699396e-01f, -5.00153184e-01f, 3.37439209e-01f, -5.21663725e-01f, -9.49370414e-02f, -5.35549931e-02f, -2.62054820e-02f, -5.20052798e-02f, 1.17487818e-01f,
  3.90054844e-02f, -2.65264779e-01f, -7.54671395e-02f, 1.59661233e-01f, -7.14637190e-02f, 1.10513955e-01f, 1.31168425e-01f, 1.33251457e-03f, 4.43850532e-02f, -3.27136993e-01f,
  1.20552890e-01f, 3.83559801e-02f, -1.25268698e-01f, -3.82414103e-01f, -7.76525214e-02f, 8.01438913e-02f, -1.29716070e-02f, -6.46793172e-02f, 3.87072563e-01f, -1.89741760e-01f,
  -2.51817882e-01f, 1.71592861e-01f, -4.89806645e-02f, 1.38809606e-01f, -2.23467611e-02f, -1.03514649e-01f, 3.27448785e-01f, -2.81416953e-01f, 1.99432731e-01f, 2.09426552e-01f,
  5.48088402e-02f, -1.75460890e-01f, -2.39995763e-01f, 1.65160567e-01f, 1.39995605e-01f, -1.61174059e-01f, 3.66693497e-01f, -1.22622542e-01f, -1.89220533e-02f, -3.19428220e-02f,
  2.90221372e-03f, 9.03930962e-02f, 1.88972190e-01f, -1.18859671e-01f, 1.67775065e-01f, -3.41615938e-02f, -1.40665621e-01f, -9.48411375e-02f, 3.35645489e-02f, -1.01140521e-01f,
  -2.62027442e-01f, -3.48788947e-01f, -2.59499937e-01f, -1.67296603e-01f, -2.10237682e-01f, -3.54706466e-01f, 3.70906413e-01f, -3.27582359e-02f, 6.85628876e-02f, 1.11663572e-01f,
  -2.24569574e-01f, -1.45349860e-01f, 4.06180799e-01f, 6.03100210e-02f, -1.10100962e-01f, 5.24440929e-02f, -3.05969328e-01f, 9.50361267e-02f, 1.97932214e-01f, 1.47610158e-01f,
  -6.86399862e-02f, -2.35105351e-01f, 6.23096861e-02f, -1.72329754e-01f, 1.32705010e-02f, 1.86097156e-02f, 3.97072919e-02f, 2.15946529e-02f, -4.75616101e-03f, -1.83690310e-01f,
  -6.42415509e-02f, -5.04251160e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.25049227e-01f, -1.98001057e-01f, 4.13464904e-01f, 3.18312645e-01f, 1.12153096e-02f, 3.71429950e-01f, -7.07571357e-02f, -5.77622712e-01f, 2.24153131e-01f, 2.35468194e-01f,
  -7.88195431e-02f, -3.45848538e-02f, -4.04213876e-01f, 2.57281035e-01f, -9.24754702e-03f, -2.86496580e-01f, 2.73699015e-01f, -1.45799577e-01f, 1.34574383e-01f, -1.14241712e-01f,
  5.07204115e-01f, 2.37153396e-01f, 7.00352669e-01f, 4.65747088e-01f, 2.06297532e-01f, 1.30954176e-01f, 9.01600897e-01f, 3.69218111e-01f, -2.66335338e-01f, 3.20160151e-01f,
  6.56231880e-01f, -2.17534453e-01f, 2.46106997e-01f, -1.26808137e-01f, -1.47640228e-01f, -2.86033571e-01f, -8.83353829e-01f, -1.24329746e-01f, 2.08302498e-01f, 2.23176166e-01f,
  -9.85082611e-02f, 3.22474241e-01f, 9.53438506e-03f, 4.18575138e-01f, 2.21719697e-01f, -7.15424716e-02f, -3.30799706e-02f, 6.52277784e-04f, 1.56390056e-01f, -2.66674817e-01f,
  8.55055228e-02f, 4.64462750e-02f, -3.28159612e-03f, 1.44350141e-01f, -2.34760717e-02f, 2.41740495e-01f, 2.69956589e-01f, 1.78625569e-01f, -3.03119086e-02f, 1.04102030e-01f,
  -9.20770317e-02f, -6.53662011e-02f, -8.34938660e-02f, 1.42325759e-01f, 1.71214342e-01f, 3.31414700e-01f, 4.10529554e-01f, 6.55792773e-01f, 3.23019266e-01f, 4.40924644e-01f,
  -6.86984807e-02f, -2.32736953e-02f, -1.98560670e-01f, -1.33887053e-01f, -4.27735411e-02f, -5.12734763e-02f, 2.16896951e-01f, 8.07448030e-02f, -1.74196824e-01f, 4.01684076e-01f,
  1.84487954e-01f, 9.62942541e-02f, 3.07792336e-01f, 1.20100804e-01f, -2.67691582e-01f, 4.48605925e-01f, 6.17922517e-03f, -6.55502260e-01f, 4.25772280e-01f, 1.15168430e-02f,
  -3.43688838e-02f, 2.17560753e-01f, 5.17681360e-01f, 4.39348638e-01f, -2.18532309e-01f, -1.93516001e-01f, -9.30153113e-03f, 4.47816074e-01f, 2.78769970e-01f, 3.24865073e-01f,
  6.45728111e-01f, 4.39208448e-01f, -9.90189463e-02f, 6.74354911e-01f, 2.48052835e-01f, 5.67839742e-01f, -9.34554756e-01f, 5.45390174e-02f, -1.39184207e-01f, -2.56897006e-02f,
  3.62925567e-02f, -1.39196247e-01f, -7.98712149e-02f, 1.28297791e-01f, 4.41037357e-01f, 2.42841229e-01f, 2.20177904e-01f, 3.06405336e-01f, -2.44448617e-01f, -2.36216545e-01f,
  3.30362052e-01f, 1.25796318e-01f, -2.45957479e-01f, -1.13289710e-02f, 2.29496509e-01f, 5.59347644e-02f, -1.14401288e-01f, 1.98164657e-01f, -1.31443515e-01f, 2.86960632e-01f,
  8.72129500e-02f, -3.06493193e-01f, -5.41698933e-01f, -1.29801512e-01f, -1.55298874e-01f, 4.74038631e-01f, -2.56290585e-01f, 1.42732650e-01f, -5.38675953e-03f, -1.41283736e-01f,
  -3.64406139e-01f, 2.76292145e-01f, 5.52601814e-01f, -3.62124175e-01f, -1.98726788e-01f, 1.01143345e-01f, -1.20297648e-01f, 2.14941129e-01f, 5.71776032e-01f, 4.58032876e-01f,
  6.88369572e-02f, 2.09478423e-01f, -1.41509429e-01f, 2.18983307e-01f, -4.63315815e-01f, 3.74273926e-01f, 9.88661274e-02f, 4.12166029e-01f, 5.23666978e-01f, -3.17340679e-02f,
  1.83230489e-02f, 1.37894191e-02f, 4.60671842e-01f, 1.62931651e-01f, -4.85722214e-01f, 3.05175632e-01f, -2.84330189e-01f, 2.27883592e-01f, 2.00200424e-01f, 3.85308087e-01f,
  -2.19787240e-01f, 1.11032233e-01f, -3.20805669e-01f, 1.46167248e-01f, 2.18712121e-01f, -5.61878622e-01f, 3.14004987e-01f, -3.70731115e-01f, -1.31023690e-01f, 1.60597973e-02f,
  2.72655278e-01f, 3.14468175e-01f, 4.09512877e-01f, 2.33774595e-02f, 9.68561321e-02f, 2.11932451e-01f, -1.61984265e-01f, 1.23890929e-01f, 1.05563439e-01f, 2.87054479e-01f,
  3.37558866e-01f, -1.75551578e-01f, 1.50364056e-01f, 6.35898719e-03f, 5.19526713e-02f, 1.28261238e-01f, 4.39835697e-01f, 2.19867393e-01f, -5.16987443e-01f, 1.22553311e-01f,
  7.70931602e-01f, 2.29535639e-01f, 4.00155514e-01f, -2.04282603e-03f, 2.31198296e-01f, -7.40136862e-01f, -4.40612316e-01f, 6.19477987e-01f, 5.21398067e-01f, -1.06570430e-01f,
  5.77888191e-01f, 6.89817313e-03f, -3.37173194e-01f, -3.83540988e-01f, 2.79545970e-02f, 5.15197694e-01f, 4.01332408e-01f, 2.42371082e-01f, 3.31077665e-01f, -3.73994038e-02f,
  4.02347714e-01f, 1.88428506e-01f, -2.64348894e-01f, 2.71417141e-01f, 5.57989515e-02f, -2.76193675e-02f, 5.13610423e-01f, 9.89154726e-03f, -4.02769148e-01f, -5.32381050e-02f,
  -6.69483423e-01f, 6.99550688e-01f, 4.69374359e-01f, 1.33329509e-02f, 3.62047285e-01f, -2.92335987e-01f, -2.17859030e-01f, -3.49129975e-01f, -8.26026723e-02f, -3.02148517e-02f,
  8.82572770e-01f, 1.06413953e-01f, -1.52783319e-01f, -1.42234648e-02f, -2.09264994e-01f, 2.22269773e-01f, 1.32508934e-01f, 4.83533651e-01f, 1.61933258e-01f, 2.50276566e-01f,
  -1.71307132e-01f, -1.10575363e-01f, 6.74031794e-01f, 1.74889281e-01f, -7.79970735e-02f, 5.01810312e-01f, 1.35103583e-01f, -1.08807996e-01f, 6.18007839e-01f, 4.36884969e-01f,
  1.98953122e-01f, 5.98839745e-02f, 5.37701309e-01f, -3.34107012e-01f, -1.74690112e-01f, -2.12887004e-02f, -8.69333968e-02f, 6.86196685e-02f, 2.13082030e-01f, 4.76749577e-02f,
  1.04563035e-01f, 4.17015851e-01f, 2.72938222e-01f, 1.66884601e-01f, -1.45757332e-01f, -2.56088674e-01f, 1.81792434e-02f, 4.71789032e-01f, 4.57584292e-01f, -2.87267298e-01f,
  3.04905623e-01f, -4.22263175e-01f, 4.48953807e-01f, 2.83892423e-01f, 3.68446112e-01f, -4.22263481e-02f, 2.66397685e-01f, -6.12040520e-01f, -2.23640576e-01f, -5.78483986e-03f,
  -5.11338413e-01f, -4.50347483e-01f, 1.07454985e-01f, -2.82763571e-01f, 4.41599250e-01f, -3.70613515e-01f, -5.82375705e-01f, 4.97510694e-02f, -5.57697833e-01f, -3.64985496e-01f,
  2.95205057e-01f, 4.37847614e-01f, 3.77412587e-01f, 4.91950095e-01f, -2.10986316e-01f, 5.59279621e-01f, 4.54269759e-02f, -3.80176306e-02f, 1.44627288e-01f, 1.10582776e-01f,
  9.23981965e-02f, -2.72158921e-01f, -1.57256767e-01f, 3.16691995e-02f, 3.43623579e-01f, 1.91705361e-01f, 1.15688585e-01f, 1.60465047e-01f, 1.22797646e-01f, -9.04132891e-03f,
  -2.87439108e-01f, -3.25402111e-01f, -5.12421012e-01f, -4.59259450e-01f, -1.61811113e-01f, -4.83569890e-01f, -1.45749105e-02f, -4.05882180e-01f, 2.68767059e-01f, -3.06068752e-02f,
  2.49290243e-01f, -4.21283871e-01f, 8.74432251e-02f, -1.95418298e-03f, 6.23590685e-02f, 2.51782358e-01f, 1.72051205e-03f, 3.81315678e-01f, 2.63351172e-01f, 2.39648119e-01f,
  -3.36134471e-02f, -3.32989842e-01f, -8.41381371e-01f, -1.56485155e-01f, -2.00316161e-01f, -5.57539687e-02f, -7.52906427e-02f, 6.86739758e-02f, 1.45822585e-01f, 1.81786288e-02f,
  -2.91578352e-01f, 3.39051098e-01f, 2.68986702e-01f, 4.75116856e-02f, -2.57210761e-01f, -1.65897638e-01f, 2.86331177e-01f, 2.00038716e-01f, 1.07568793e-01f, -3.12831581e-01f,
  2.63474971e-01f, 3.52756172e-01f, -4.80561137e-01f, -1.95117325e-01f, 5.18334983e-03f, 3.65360439e-01f, 3.02868336e-01f, -2.02329800e-01f, 2.85163045e-01f, 4.93793458e-01f,
  3.13980341e-01f, 3.05118322e-01f, 5.99285185e-01f, 2.04217862e-02f, -1.19002558e-01f, 8.24799716e-01f, 8.93431008e-02f, 1.93120927e-01f, 5.46099842e-01f, 1.42791957e-01f,
  -2.19396293e-01f, -4.39642102e-01f, 2.80581176e-01f, 3.53110433e-01f, 2.27669224e-01f, -2.78946608e-02f, 6.92453861e-01f, 2.60912091e-01f, 1.26075268e-01f, -1.03869990e-01f,
  9.90695804e-02f, 3.86167206e-02f, 7.54075944e-02f, -7.66531453e-02f, -1.04826413e-01f, -4.10300493e-02f, -1.55831706e-02f, 1.85048252e-01f, 2.32603908e-01f, -5.54744154e-04f,
  1.96128875e-01f, 4.88416731e-01f, -1.01016097e-01f, 1.41573757e-01f, 1.88573197e-01f, 5.95035791e-01f, 3.44300330e-01f, 5.89268625e-01f, -2.60522157e-01f, 1.48678729e-02f,
  2.23634273e-01f, 3.43419284e-01f, 2.34415799e-01f, -2.28476614e-01f, 2.83892632e-01f, -2.51274049e-01f, 2.95608103e-01f, 1.08810760e-01f, 5.14992654e-01f, 4.21983182e-01f,
  4.26316299e-02f, 3.72009158e-01f, -5.99799976e-02f, -5.66962779e-01f, -4.82207723e-02f, -6.58891320e-01f, 4.34616983e-01f, 2.38045007e-02f, -1.13221496e-01f, 1.85994640e-01f,
  3.96987386e-02f, 9.11640152e-02f, -5.05893826e-02f, 1.45231918e-01f, -1.48467235e-02f, -2.45329678e-01f, 2.73554623e-01f, 1.06708117e-01f, 4.75590706e-01f, -3.14791873e-02f,
  2.33698830e-01f, 1.08902842e-01f, 3.65522772e-01f, 6.28060102e-02f, 1.46213630e-02f, 3.68425131e-01f, 2.11006925e-01f, -4.48652208e-01f, -5.26024289e-02f, -6.53858557e-02f,
  -2.50298828e-01f, -4.08211470e-01f, -5.83803654e-01f, 6.34423420e-02f, 1.02473110e-01f, 7.66102895e-02f, 2.62966990e-01f, 2.97936291e-01f, -9.19562727e-02f, 4.45351750e-01f,
  -6.76159263e-02f, -2.26077020e-01f, -1.75883435e-02f, -1.61445782e-01f, 2.42101565e-01f, -3.51178914e-01f, -7.68695772e-02f, 1.08213417e-01f, 6.78234398e-02f, -2.32449118e-02f,
  -2.93044806e-01f, 4.55331266e-01f, -2.22166106e-02f, 2.83013135e-01f, 1.99326426e-02f, 2.30736658e-01f, -4.84066037e-03f, -6.94690794e-02f, -2.15610534e-01f, 9.78522003e-02f,
  -3.31251949e-01f, -1.81295257e-02f, 1.57086194e-01f, -3.36970054e-02f, -8.53597879e-01f, -3.73769790e-01f, 7.46671669e-03f, -1.81565862e-02f, 6.50075734e-01f, 7.80316740e-02f,
  2.49543652e-01f, 7.10890954e-03f, 1.03798561e-01f, -2.34493658e-01f, -2.97810286e-02f, -1.32182330e-01f, 4.13467944e-01f, -2.22932637e-01f, -3.43638331e-01f, 2.40589812e-01f,
  1.79932695e-02f, 2.50476688e-01f, 2.47950032e-01f, 4.93011564e-01f, -1.82554126e-01f, 4.41057682e-01f, -1.86768956e-02f, 2.72494733e-01f, 1.00228406e-01f, 1.37213528e-01f,
  -3.26459147e-02f, 1.23971023e-01f, 2.38991305e-01f, 3.09761643e-01f, -3.74573678e-01f, 2.02758312e-01f, 5.91893606e-02f, 4.33805853e-01f, 1.25235245e-01f, -5.70498168e-01f,
  -1.57457903e-01f, -2.35646322e-01f, 1.57910451e-01f, -1.76835015e-01f, -1.30546942e-01f, -1.61873102e-02f, 1.08323418e-01f, 4.69166249e-01f, -5.01938879e-01f, -4.15330887e-01f,
  7.75765896e-01f, -1.40393630e-01f, 1.61186144e-01f, -3.12767208e-01f, -2.12414205e-01f, -4.78935033e-01f, 4.23286259e-01f, 3.11672032e-01f, -3.74089241e-01f, -6.33491427e-02f,
  -7.21010044e-02f, 3.68809760e-01f, 2.74900552e-02f, 2.84030706e-01f, -8.18476602e-02f, 3.79015595e-01f, -6.27351180e-02f, -2.15989545e-01f, 8.12977925e-02f, 3.96627262e-02f,
  5.06798565e-01f, 4.29201514e-01f, -1.54687360e-01f, -1.08465038e-01f, -2.96621472e-01f, -8.48796517e-02f, 4.09693927e-01f, 1.95464373e-01f, 9.15380344e-02f, 7.98243344e-01f,
  7.14111626e-02f, 3.89826208e-01f, 3.84086758e-01f, -1.49177551e-01f, -1.44343421e-01f, 2.71040708e-01f, -3.39692205e-01f, -2.68771648e-01f, 4.18830782e-01f, 8.03468823e-02f,
  -3.96457702e-01f, -4.96062860e-02f, 8.51665616e-01f, 4.10297006e-01f, -1.36672854e-01f, 2.88822532e-01f, 4.40186262e-01f, -3.69663358e-01f, -5.02554655e-01f, 1.59939751e-01f,
  -1.02119140e-01f, 4.17860627e-01f, -2.78802246e-01f, -1.50833368e-01f, 4.49270070e-01f, -3.66512179e-01f, 4.31396157e-01f, -2.39012867e-01f, 2.09245384e-01f, 1.42910361e-01f,
  -8.29171538e-02f, 6.51959181e-02f, -3.22950393e-01f, -7.59895593e-02f, 3.12170595e-01f, -1.69762403e-01f, 3.83874655e-01f, -2.87706196e-01f, 1.23744644e-01f, 8.99246708e-02f,
  4.16562170e-01f, -4.31898497e-02f, 2.97253788e-01f, 3.70323397e-02f, -6.79967821e-01f, 2.51733333e-01f, 1.94976404e-01f, -2.56343978e-04f, 5.09769320e-01f, 1.79053828e-01f,
  1.81486681e-01f, 2.80232102e-01f, 3.52271408e-01f, 4.51102942e-01f, -6.37401938e-01f, 7.51852453e-01f, -7.78357461e-02f, 3.78477782e-01f, -3.79938096e-01f, -3.97762269e-01f,
  -1.55547529e-01f, 1.12179972e-01f, -7.58322105e-02f, -2.51029246e-02f, 9.87699404e-02f, 2.91113764e-01f, 1.62553146e-01f, 2.37480015e-01f, 4.75640625e-01f, -9.76768583e-02f,
  -2.12626815e-01f, -9.12730545e-02f, 5.99621832e-01f, -5.92214242e-02f, -1.53493166e-01f, -3.18181515e-01f, 2.24593598e-02f, -2.13748589e-01f, 9.54531506e-02f, 2.95824945e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.83118576e-01f, 3.24016623e-02f, 3.01766306e-01f, -1.21244509e-02f, 1.50982127e-01f, 1.01622827e-01f, 2.25912318e-01f, 9.77260917e-02f, -3.72969336e-03f, 1.70792550e-01f,
  -4.86318097e-02f, -1.15295477e-01f, -5.07195555e-02f, 3.48458946e-01f, -1.59712613e-01f, -1.96072102e-01f, 3.74410599e-01f, 1.85025021e-01f, 4.44727153e-01f, 3.43812585e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.61751628e-01f, 3.22529525e-01f, 1.40667245e-01f, -3.15856010e-01f, -2.43599251e-01f, -2.31909275e-01f, -1.65817171e-01f, 6.85772836e-01f, -2.93613344e-01f, 1.95398889e-02f,
  -9.55743939e-02f, -7.19729543e-01f, 1.36000276e-01f, 1.87463209e-01f, -3.77346098e-01f, -5.46618700e-01f, 1.71777800e-01f, -2.38458579e-03f, -4.90925848e-01f, 2.22986075e-03f,
  1.18201181e-01f, -6.62580058e-02f, 3.67373228e-01f, 2.07563177e-01f, 2.11147010e-01f, 1.27716839e-01f, 9.71057564e-02f, 3.48312527e-01f, -5.57697237e-01f, -4.82414961e-01f,
  -5.80201626e-01f, -5.54935753e-01f, -3.11293513e-01f, 2.36704886e-01f, -2.45662928e-01f, -3.26114088e-01f, 2.90386025e-02f, -1.64268568e-01f, -2.87420303e-01f, 1.62382618e-01f,
  4.01821256e-01f, -6.14162445e-01f, -2.82640040e-01f, 7.21089765e-02f, 8.80851075e-02f, 2.21814856e-01f, -3.56552660e-01f, 1.77727655e-01f, 2.37095907e-01f, 2.66648918e-01f,
  5.04978932e-02f, 3.66279840e-01f, -5.60301125e-01f, -3.41499776e-01f, -2.57049143e-01f, 1.03903502e-01f, 8.81860685e-03f, -6.89759552e-01f, 2.62893856e-01f, 2.28939101e-01f,
  -9.08002034e-02f, -6.91159070e-02f, -3.70823070e-02f, 7.83184357e-03f, 8.49568769e-02f, 3.55027378e-01f, -6.81750104e-02f, -9.77131277e-02f, 1.60903513e-01f, -3.64710987e-01f,
  -3.23255152e-01f, -1.28983840e-01f, 3.75724614e-01f, -1.98190302e-01f, 5.39113581e-01f, 9.05408117e-04f, 3.21198702e-01f, 2.66712755e-01f, 1.24878837e-02f, -5.26890337e-01f,
  -6.84375942e-01f, -3.53317380e-01f, 3.59074742e-01f, 1.27067521e-01f, 2.73041755e-01f, -2.19647303e-01f, 1.99300811e-01f, 1.17027156e-01f, 6.54443949e-02f, 2.68799573e-01f,
  2.81320870e-01f, 1.04029544e-01f, -7.78501749e-01f, -3.31718206e-01f, 3.27081978e-01f, -3.37367177e-01f, 4.19481933e-01f, -2.03668773e-01f, 2.89365411e-01f, 3.97818625e-01f,
  1.19673111e-01f, 3.25215816e-01f, 3.15341771e-01f, -3.57380509e-01f, 3.98878336e-01f, -2.23379925e-01f, -4.68055695e-01f, -1.22586764e-01f, 2.57612407e-01f, -5.95103979e-01f,
  -8.55539083e-01f, -2.07472920e-01f, 8.01265836e-02f, -1.52276196e-02f, -3.05239528e-01f, -7.83161879e-01f, -6.80713728e-02f, 2.22255141e-01f, -5.74487507e-01f, 3.07455063e-01f,
  1.07726650e-02f, 4.52671461e-02f, -4.28462893e-01f, -5.30381083e-01f, -1.45220729e-02f, -7.43875444e-01f, 6.31058633e-01f, 2.42698625e-01f, 4.13118482e-01f, -4.30216402e-01f,
  -6.23596549e-01f, -5.19027591e-01f, -1.11821182e-01f, 6.18350446e-01f, 3.00015450e-01f, -3.93870622e-01f, 3.36500615e-01f, -1.00196928e-01f, 6.88985586e-02f, 5.26608527e-01f,
  2.08876058e-01f, -1.29419565e-01f, 4.23796363e-02f, 2.08142295e-01f, 5.66819943e-02f, 1.03822283e-01f, -3.69657040e-01f, -1.00982356e+00f, 2.41148889e-01f, 2.89791107e-01f,
  -1.14251040e-01f, 1.84466660e-01f, 9.50941667e-02f, -1.87443167e-01f, 3.97900455e-02f, -1.30705878e-01f, 2.46735469e-01f, 6.67437539e-02f, -4.90660191e-01f, -3.76722366e-01f,
  3.30465361e-02f, -2.63211995e-01f, 5.11069298e-01f, 4.79003072e-01f, -2.76788950e-01f, -3.06644410e-01f, 5.01085937e-01f, -4.78747368e-01f, -5.73232114e-01f, 2.79447496e-01f,
  -4.46923971e-01f, -4.21452940e-01f, -7.66391009e-02f, -2.48008408e-02f, 3.16977292e-01f, 3.37773919e-01f, 4.74917293e-02f, 1.61301598e-01f, -2.24834800e-01f, 1.42764166e-01f,
  4.81799282e-02f, -1.01109363e-01f, -5.45369267e-01f, -9.46551189e-02f, 8.27478841e-02f, -1.83045492e-01f, -1.97199881e-01f, -1.51548758e-01f, -5.75961292e-01f, 1.38207227e-01f,
  -3.38639200e-01f, 2.78898984e-01f, -2.52292186e-01f, 2.93126762e-01f, 2.37325922e-01f, -2.96734452e-01f, 1.54235378e-01f, -1.74294170e-02f, 7.12009817e-02f, -1.87324345e-01f,
  3.54955673e-01f, -5.14608264e-01f, 3.54023814e-01f, 3.24189901e-01f, -7.47593820e-01f, -8.64008255e-03f, 1.23891689e-01f, -4.66041118e-01f, -3.37460876e-01f, -5.08320153e-01f,
  1.60671681e-01f, 1.51136205e-01f, -2.66749978e-01f, 1.51660591e-01f, 2.80072272e-01f, -4.74569112e-01f, -1.08870065e+00f, -7.00052306e-02f, -7.04869702e-02f, -2.84028888e-01f,
  5.01567602e-01f, 3.51522774e-01f, 2.25713477e-01f, -6.92981541e-01f, 1.31955355e-01f, -3.95176768e-01f, 4.27109674e-02f, 1.78037822e-01f, -1.41976789e-01f, -4.37922716e-01f,
  -1.09803133e-01f, 5.55735707e-01f, -2.10753664e-01f, 2.24565014e-01f, -6.49943352e-02f, -2.31264368e-01f, 3.63556951e-01f, -2.67358720e-01f, 1.06394820e-01f, -2.99177021e-01f,
  3.18546772e-01f, 4.56465632e-01f, -1.32214516e-01f, -1.10840455e-01f, -4.30311859e-01f, -2.78889269e-01f, 2.90403366e-01f, -4.92728829e-01f, -2.41249353e-01f, 3.30508262e-01f,
  -2.47241125e-01f, 1.28229052e-01f, 5.68501055e-02f, -2.59602040e-01f, 2.91345000e-01f, -6.84569359e-01f, -5.38718924e-02f, -2.30099574e-01f, -4.71264273e-01f, 3.56992409e-02f,
  -2.04635803e-02f, -2.47056987e-02f, 4.55645084e-01f, -8.18035454e-02f, -2.10933641e-01f, 4.39836420e-02f, 1.32285655e-01f, 1.65202335e-01f, -7.16060698e-01f, -3.28569621e-01f,
  1.79271251e-01f, 1.81884348e-01f, -4.89603788e-01f, -6.82240605e-01f, 3.93083960e-01f, 4.25224334e-01f, -7.53715098e-01f, -1.64008260e-01f, 1.30185410e-01f, 5.62726334e-02f,
  -2.57087588e-01f, -5.42661905e-01f, -1.77968308e-01f, -1.00508943e-01f, -2.00378731e-01f, 2.56127834e-01f, -3.58993858e-01f, 1.83051705e-01f, -2.77170599e-01f, 2.46361732e-01f,
  2.50030737e-02f, -3.00130025e-02f, 3.10796320e-01f, 3.98641855e-01f, -2.03601733e-01f, 8.02260756e-01f, -7.03364536e-02f, -1.95408374e-01f, -9.00287777e-02f, 2.44140923e-01f,
  -2.29070485e-02f, 2.87753437e-02f, 2.91043758e-01f, -6.47014737e-01f, 4.50606197e-02f, -4.02800351e-01f, -1.28844604e-02f, -7.52524063e-02f, 3.34200263e-01f, 1.09716602e-01f,
  -6.00187480e-01f, -8.30439985e-01f, 3.16343382e-02f, 2.46157959e-01f, -2.51021385e-01f, -1.89912409e-01f, -2.71293014e-01f, 2.87174791e-01f, -7.76976943e-02f, -4.60694760e-01f,
  -9.38877687e-02f, -4.07314628e-01f, 1.23387039e-01f, 1.32506445e-01f, -3.39335471e-01f, 1.77173577e-02f, 3.05878103e-01f, 3.05084378e-01f, -3.26269805e-01f, 3.19633067e-01f,
  1.13511883e-01f, 2.70267040e-01f, -3.56508553e-01f, -7.21201360e-01f, -4.62724686e-01f, 1.72265917e-01f, 3.03705812e-01f, -5.02912164e-01f, -6.24128878e-01f, -3.40285987e-01f,
  -6.45844996e-01f, 3.28059524e-01f, 3.28195721e-01f, 3.85242522e-01f, 1.31638050e-01f, -4.94382620e-01f, -7.84074843e-01f, -6.75457537e-01f, -3.68257910e-01f, 2.11251691e-01f,
  -3.84877548e-02f, 4.25910354e-01f, 3.93706471e-01f, 8.39118138e-02f, 2.32106224e-02f, 3.92083228e-01f, -1.13859680e-02f, 3.64263743e-01f, -2.52388805e-01f, -3.84034753e-01f,
  -3.68453652e-01f, 5.69529831e-01f, 6.64848387e-01f, -4.91405547e-01f, 1.00217231e-01f, -2.45371997e-01f, 2.69515812e-01f, 2.48281434e-01f, -2.13382259e-01f, -1.87616274e-01f,
  2.91607946e-01f, -2.59818643e-01f, -2.49649480e-01f, -7.68912375e-01f, -8.49614203e-01f, -1.06113002e-01f, -6.13442123e-01f, 2.44151980e-01f, -2.39711702e-01f, -6.36841595e-01f,
  4.18792009e-01f, -3.49746123e-02f, 3.54877651e-01f, 4.25252080e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.46882692e-01f, -1.49332032e-01f, 2.08217233e-01f, -4.74958159e-02f, -1.38403609e-01f, -1.08221576e-01f, 1.13361098e-01f, -2.10554421e-01f, -3.22726667e-02f, 6.72270581e-02f,
  -5.62898256e-02f, 3.89994942e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    