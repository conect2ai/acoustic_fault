/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.81579435e-01f, -4.84933317e-01f, -4.54286560e-02f, 2.10563615e-01f, 4.94755767e-02f, -5.54339308e-03f, -2.84350395e-01f, -1.73703656e-01f, 1.09348521e-01f, 2.56681722e-02f,
  6.17954917e-02f, 2.36345679e-01f, 1.37163237e-01f, -1.72458664e-02f, -1.61451429e-01f, -1.05414540e-01f, -7.49097764e-02f, -7.92904422e-02f, 4.25505936e-02f, 1.26027837e-02f,
  5.99620771e-03f, -4.50828597e-02f, 1.10433973e-01f, -5.48257679e-02f, 6.48964494e-02f, 1.25610501e-01f, -3.03614791e-02f, -1.76471159e-01f, -8.91266316e-02f, -1.61708459e-01f,
  2.34138072e-01f, -3.54739636e-01f, 2.13989139e-01f, 7.70503506e-02f, 1.28314923e-02f, 2.89727971e-02f, 1.08948052e-01f, -2.47916188e-02f, 1.13103278e-01f, 3.28205526e-02f,
  4.99241287e-03f, 5.46101071e-02f, -2.71011833e-02f, -9.90584418e-02f, -8.02578554e-02f, -2.69902367e-02f, -1.23410024e-01f, -1.14604801e-01f, -4.52566333e-02f, -1.28501832e-01f,
  -4.14629839e-02f, -6.94065019e-02f, -3.70223932e-02f, -7.60567039e-02f, -8.51217359e-02f, 4.83859889e-02f, -2.21853092e-01f, -1.65808678e-01f, 1.95983388e-02f, -3.99463950e-03f,
  4.33068871e-02f, 7.32409880e-02f, -4.75783385e-02f, -4.00068127e-02f, 3.31329107e-02f, -1.89014571e-03f, -3.58702429e-02f, 1.13362651e-02f, 9.40694660e-03f, -3.05907801e-02f,
  -4.53426726e-02f, 4.62583825e-02f, -2.52171047e-02f, 1.53945172e-02f, 5.81661277e-02f, -8.79419371e-02f, 4.29896675e-02f, 2.16647964e-02f, 1.88123845e-02f, -1.39135607e-02f,
  -2.24842951e-02f, 5.86795323e-02f, -1.42466370e-02f, -4.47459370e-02f, -8.41802284e-02f, -7.10769966e-02f, 3.99864698e-03f, -6.54079616e-02f, -3.58679146e-02f, 2.41774190e-02f,
  3.37083489e-01f, 3.91803607e-02f, 1.70241654e-01f, 2.27025524e-02f, -1.75725576e-02f, -4.58893888e-02f, 5.72529733e-02f, 2.77399272e-02f, 1.16777625e-02f, 2.62056869e-02f,
  -1.68952742e-03f, -3.14030536e-02f, -3.32643501e-02f, -1.87424123e-02f, 1.24969952e-01f, 7.04497918e-02f, -1.28995124e-02f, 1.39640450e-01f, 2.25007813e-03f, 3.25515121e-02f,
  -5.24271764e-02f, 6.90817162e-02f, 2.37239286e-01f, 1.47356540e-01f, 6.94527328e-02f, 2.31731907e-01f, 1.00950092e-01f, 1.64419904e-01f, 1.19463511e-01f, 2.75325149e-01f,
  6.51276782e-02f, -1.48576453e-01f, -3.55799496e-01f, -4.70408350e-01f, -2.14860559e-01f, 1.45658433e-01f, -6.49570972e-02f, 1.92584485e-01f, -6.91755340e-02f, -2.87585527e-01f,
  -3.54726762e-02f, 1.17100239e-01f, 2.95124613e-02f, 1.11621834e-01f, 1.21312730e-01f, -9.73410606e-02f, -3.05826783e-01f, -7.41989119e-03f, 1.32954389e-01f, 1.50723588e-02f,
  -1.47788823e-01f, -2.48477101e-01f, -1.15144417e-01f, 3.67757976e-02f, -2.37154767e-01f, -2.41661929e-02f, -1.59024984e-01f, 1.44746713e-02f, 1.00368612e-01f, -6.23478234e-01f,
  -3.49538922e-01f, 1.26560792e-01f, 6.80557489e-02f, -3.49628332e-04f, 2.28011608e-03f, 7.97725767e-02f, 6.17461726e-02f, 2.92070769e-02f, 1.08359106e-01f, -3.78739052e-02f,
  -6.86190203e-02f, -4.30618413e-02f, -3.13113928e-02f, 4.39917259e-02f, 1.64139029e-02f, 3.36571150e-02f, 4.44228575e-02f, -1.27531616e-02f, -1.18573807e-01f, 1.06737120e-02f,
  -6.68487623e-02f, -2.69337017e-02f, 6.53071627e-02f, 1.93454802e-01f, 2.85417918e-04f, 4.27812524e-03f, -2.88845338e-02f, 1.04532912e-01f, 2.08245069e-01f, -7.42450878e-02f,
  -1.19364858e-01f, -3.11955176e-02f, 7.74217471e-02f, 2.20702812e-02f, 6.44555967e-03f, -4.89616627e-03f, -3.02517302e-02f, 3.32908668e-02f, -6.86408803e-02f, 5.49789034e-02f,
  1.81452103e-03f, -4.05369848e-02f, -1.66160315e-02f, -1.15473559e-02f, -6.36292398e-02f, 9.39135402e-02f, -1.98932234e-02f, -9.56985652e-02f, 2.57603042e-02f, 3.25867943e-02f,
  4.15901095e-02f, 3.68469283e-02f, -4.22795974e-02f, 8.13377555e-03f, -9.31630936e-03f, -7.56191686e-02f, 7.35011399e-02f, 6.53901398e-02f, 1.82938331e-03f, 7.36388788e-02f,
  2.41574705e-01f, 1.57744527e-01f, -1.19877927e-01f, 1.03056036e-01f, -4.34364825e-02f, -2.53963582e-02f, -6.06966466e-02f, 3.77944857e-02f, -5.31516857e-02f, 9.14440490e-03f,
  9.19796154e-02f, -2.42123194e-02f, 3.73986214e-02f, 3.57243270e-02f, 1.19099738e-02f, 5.77782355e-02f, -2.17516553e-02f, -1.03323326e-01f, 4.68328893e-02f, -1.08132713e-01f,
  -1.35164186e-01f, 1.06941141e-01f, 3.54155414e-02f, 2.49380749e-02f, 6.22394830e-02f, -1.60376467e-02f, 5.50001785e-02f, 1.22053642e-02f, 1.32597834e-01f, -5.64242266e-02f,
  -6.91922188e-01f, 3.42373043e-01f, 1.82861350e-02f, -4.17876214e-01f, 5.71696639e-01f, 3.21258366e-01f, 5.11689603e-01f, -1.34483680e-01f, -2.00974077e-01f, 2.44944021e-01f,
  2.49827862e-01f, -2.49357671e-01f, -1.23658501e-01f, -2.50011176e-01f, -2.76376128e-01f, 3.25343937e-01f, 1.19061403e-01f, -3.92103434e-01f, -3.00916433e-01f, -2.01459210e-02f,
  1.51064530e-01f, -1.26136139e-01f, -4.81328398e-01f, -2.27738991e-01f, 2.41996646e-01f, 1.84710212e-02f, 2.45188907e-01f, 9.45904404e-02f, 2.84297585e-01f, -9.77104008e-02f,
  -5.47512807e-03f, -1.12766989e-01f, -2.65583731e-02f, -9.24160180e-04f, 2.02985052e-02f, -8.77556577e-02f, 8.96782428e-03f, -7.71076828e-02f, 5.37150167e-02f, 3.12543660e-02f,
  1.04567684e-01f, 4.99793887e-02f, -9.98516008e-02f, 9.80518460e-02f, 1.23284996e-01f, 2.63304617e-02f, -4.93508838e-02f, -1.36312962e-01f, 1.99437775e-02f, 6.14421889e-02f,
  4.43658344e-02f, 5.17222770e-02f, 1.80895746e-01f, 1.32349089e-01f, -1.13181956e-01f, -1.93359721e-02f, 7.60420039e-02f, -1.02209762e-01f, -5.59421778e-02f, -2.29691297e-01f,
  -1.51280668e-02f, 1.92036331e-02f, -5.13470965e-03f, -1.24904010e-02f, -2.47777048e-02f, 4.08832580e-02f, -2.28314139e-02f, 2.85376869e-02f, -2.29084305e-02f, -4.06902749e-03f,
  -2.08290434e-03f, 3.18382829e-02f, 3.81118874e-03f, 3.61816003e-03f, -1.07685756e-02f, -7.64952681e-04f, -7.44626531e-03f, -1.68048050e-02f, -1.85133940e-05f, 9.84059880e-04f,
  -2.45196894e-02f, 1.37099251e-02f, 4.76165935e-02f, -3.95356938e-02f, 4.57339697e-02f, -3.40169258e-02f, -3.00636841e-03f, -4.75335633e-03f, 2.25215387e-02f, 3.68421003e-02f,
  -1.01021677e-02f, 9.16933417e-02f, -7.97909871e-02f, -1.02483682e-01f, 3.96577157e-02f, -2.81428844e-02f, 2.32800245e-02f, -7.28299003e-03f, 2.07209941e-02f, -5.57201542e-02f,
  -3.65566611e-02f, -4.64965366e-02f, 2.10667495e-02f, -5.83736710e-02f, -5.69369681e-02f, -1.71657465e-02f, 7.40771517e-02f, -1.88778713e-02f, -1.08521245e-02f, 9.26112477e-03f,
  -8.74043349e-03f, 6.12434372e-02f, 5.85856587e-02f, -1.90353636e-02f, -6.01399504e-02f, 6.47319714e-03f, 2.89775524e-02f, -3.80335399e-03f, 4.18000706e-02f, 2.37661988e-01f,
  5.56883574e-01f, -2.06795901e-01f, -2.38703728e-01f, 3.24654728e-01f, -1.27581850e-01f, -1.37160704e-01f, -1.65268913e-01f, 2.37586379e-01f, 2.87255734e-01f, -1.97147764e-03f,
  -1.95428208e-02f, -2.55818311e-02f, 1.63928699e-02f, -9.16717499e-02f, -3.42324711e-02f, -1.03326052e-01f, -3.10258925e-01f, -1.84168786e-01f, -7.84936622e-02f, 1.08784966e-01f,
  5.96654192e-02f, 5.09173702e-03f, 6.82604462e-02f, 1.24040544e-01f, -8.31189565e-03f, -2.55628228e-01f, -2.58316491e-02f, 4.69051767e-03f, -1.97689861e-01f, -4.97007251e-01f,
  2.68925056e-02f, 1.85454577e-01f, -1.08319402e-01f, -1.08407453e-01f, -4.80279475e-02f, 9.71095785e-02f, 2.19792817e-02f, 1.83311868e-02f, 2.65701469e-02f, 1.18080787e-01f,
  -1.14282228e-01f, -8.52548890e-03f, -8.39616582e-02f, -5.84121570e-02f, 8.65443274e-02f, 2.12466642e-02f, 6.00126088e-02f, 3.79349478e-02f, 1.77780893e-02f, 1.08913876e-01f,
  -6.09795302e-02f, -1.93835095e-01f, -1.33383140e-01f, -7.74253309e-02f, 2.01145448e-02f, -1.40372127e-01f, -9.60546210e-02f, -5.01247346e-02f, -7.52237067e-02f, 1.84501007e-01f,
  -4.33455072e-02f, -2.00159624e-02f, -1.50818611e-02f, 5.95205501e-02f, 5.22135384e-03f, 4.04338958e-03f, -4.43897136e-02f, -4.73762602e-02f, 5.56130856e-02f, 2.92321797e-02f,
  8.60341918e-03f, 1.79504398e-02f, -2.53915899e-02f, 1.50251955e-01f, -8.83650128e-03f, -5.45176268e-02f, -4.61143106e-02f, 1.21337119e-02f, 1.44776395e-02f, -3.35168168e-02f,
  2.24918760e-02f, -2.52023619e-03f, 7.20167756e-02f, -4.89398204e-02f, -5.80622489e-03f, -4.98538129e-02f, 3.13348323e-02f, 1.96591089e-03f, 6.12263419e-02f, 3.88620868e-02f,
  3.28143984e-01f, -2.94295460e-01f, 2.07177505e-01f, 1.01766236e-01f, -3.56507450e-02f, 4.51144204e-02f, 1.95483081e-02f, 1.32055152e-02f, 9.06298961e-03f, 6.35862909e-03f,
  4.24457788e-02f, 7.87452608e-02f, 6.53783279e-03f, 3.68629582e-02f, -6.59005111e-03f, 6.70499057e-02f, 6.72899038e-02f, -9.62453261e-02f, -1.42039433e-02f, 1.46340072e-01f,
  1.28590867e-01f, 2.46666353e-02f, 7.00528026e-02f, -9.15313838e-04f, -1.36370026e-02f, -7.46781155e-02f, 2.07134765e-02f, 1.15695395e-01f, -1.65902376e-01f, 2.60886610e-01f,
  1.89263765e-02f, -2.45252505e-01f, -2.23080546e-01f, -2.49613553e-01f, 1.50970310e-01f, 1.05213337e-01f, -3.38281184e-01f, -1.42896608e-01f, -4.07524109e-02f, -1.07914008e-01f,
  3.53847593e-01f, 3.99182498e-01f, 1.63632557e-01f, 1.87096342e-01f, -8.88235494e-02f, -4.84674990e-01f, -5.59934914e-01f, -1.44181713e-01f, 1.28797844e-01f, 2.92396665e-01f,
  1.62394404e-01f, -5.72144724e-02f, -2.01108176e-02f, 1.03781782e-02f, -1.94703177e-01f, 2.94289482e-03f, -1.86644524e-01f, -1.07236519e-01f, 1.15513645e-01f, -5.14744997e-01f,
  1.17766209e-01f, -1.10693246e-01f, 7.37493783e-02f, 1.23374639e-02f, 7.76388645e-02f, -6.79994375e-02f, -4.60174568e-02f, -1.56896695e-01f, 1.58998072e-02f, -1.01665638e-01f,
  1.32732511e-01f, 6.92243502e-02f, -2.00736728e-02f, -6.83597848e-02f, -4.19895984e-02f, -3.87908369e-02f, -7.87709057e-02f, -1.56070411e-01f, -1.06390715e-01f, 9.05690044e-02f,
  1.17834203e-01f, 2.61404425e-01f, 6.03920184e-02f, -4.17944230e-02f, 3.43048871e-02f, 1.52844578e-01f, 2.85061868e-03f, -1.00892402e-01f, -1.74647719e-01f, -3.35970879e-01f,
  3.94794159e-02f, -1.58840977e-02f, 5.20451106e-02f, -1.04140164e-02f, 6.18460588e-03f, 4.20412757e-02f, 1.90553106e-02f, 2.69005559e-02f, -4.11754400e-02f, 1.00207999e-02f,
  1.86169706e-02f, -2.57994077e-04f, -9.46376286e-03f, -4.28006537e-02f, 6.25787862e-03f, -4.95410636e-02f, 2.16421224e-02f, -5.43139465e-02f, 5.87797463e-02f, -3.75471450e-02f,
  -2.98336763e-02f, 4.44753803e-02f, -6.29588217e-02f, 3.26161236e-02f, 1.86300296e-02f, -4.43294235e-02f, -2.16451893e-03f, 6.90668896e-02f, 4.68185395e-02f, 8.11594538e-03f,
  -1.44222751e-01f, 2.30054587e-01f, -9.73969400e-02f, -4.55908962e-02f, -1.04243169e-02f, 2.33254284e-02f, -2.76948139e-02f, -6.54054107e-03f, 3.98268290e-02f, -6.18527345e-02f,
  4.85632457e-02f, -7.12670665e-03f, -5.62923122e-03f, 5.18856477e-03f, 2.79167015e-02f, -5.64745590e-02f, -8.91951192e-03f, 6.95713796e-03f, -5.08884434e-03f, -3.52283381e-02f,
  -9.14748535e-02f, -6.51924610e-02f, 3.47729288e-02f, -9.92523506e-02f, 1.29130529e-02f, 4.24813777e-02f, -1.60776824e-01f, -1.20822005e-01f, -1.18083507e-02f, -4.50252473e-01f,
  -4.40008491e-01f, 2.06523128e-02f, -5.58339357e-01f, 1.12060174e-01f, -3.21076252e-02f, -2.40777910e-01f, -3.84709597e-01f, -8.49210471e-02f, 1.87843665e-01f, -2.56978185e-03f,
  8.03529695e-02f, 1.62926912e-01f, 1.30471766e-01f, 4.27875854e-02f, -2.56801933e-01f, -1.51679531e-01f, -3.13113220e-02f, -2.25548804e-01f, -2.47758478e-01f, -2.25542054e-01f,
  1.44977733e-01f, 1.10346712e-01f, 4.37156931e-02f, 1.33665139e-02f, 2.16266692e-01f, 1.06115401e-01f, 1.04772478e-01f, 1.51877627e-01f, -1.61915049e-02f, 2.29750067e-01f,
  -4.99828197e-02f, -6.43742681e-02f, -1.24014854e-01f, 1.17717095e-01f, 1.36220992e-01f, -2.17569564e-02f, -5.91045469e-02f, 3.25290821e-02f, 7.55026713e-02f, -5.18979430e-02f,
  3.39428149e-02f, 1.38761222e-01f, 1.03001464e-02f, 1.19006500e-01f, -1.38523541e-02f, -2.73082815e-02f, 9.16482583e-02f, 1.05494251e-02f, -1.46864444e-01f, -8.48236308e-02f,
  1.47412598e-01f, -2.48204041e-02f, -2.42767215e-01f, -7.34594911e-02f, -1.45811677e-01f, 8.02889466e-02f, -1.17695946e-02f, 9.81696695e-03f, -6.10530563e-02f, 4.94843349e-02f,
  4.65621725e-02f, -4.03628387e-02f, 4.18632962e-02f, -2.65903771e-03f, 5.32570556e-02f, 8.38414126e-05f, 3.43524180e-02f, -3.01477686e-03f, -8.80317576e-03f, 7.00949952e-02f,
  -3.35228741e-02f, -1.09159620e-02f, -2.48198234e-03f, -8.43415707e-02f, 7.04895258e-02f, 1.23016452e-02f, -1.32198818e-02f, 4.65294085e-02f, -4.62392392e-03f, 9.00148321e-03f,
  -2.66006514e-02f, -5.39627671e-02f, 6.10052189e-03f, 7.34880986e-03f, 3.92186077e-04f, -2.59693037e-03f, -4.84228767e-02f, 7.55203068e-02f, 6.09738417e-02f, -3.88285853e-02f,
  1.19847879e-01f, -1.12767562e-01f, 7.82509893e-03f, -3.82319950e-02f, -3.40961143e-02f, 6.86293840e-02f, 5.18598109e-02f, -2.93162521e-02f, 3.20490710e-02f, 5.00613416e-04f,
  -6.01093434e-02f, -1.08896852e-01f, -2.60410979e-02f, 5.00197783e-02f, -5.15021272e-02f, -9.34615079e-03f, 5.11023439e-02f, -5.18338718e-02f, 1.56632178e-02f, 3.59819792e-02f,
  -3.04865156e-04f, -1.31853029e-01f, -1.79138839e-01f, -9.99641195e-02f, -7.55231222e-03f, -1.46211356e-01f, -8.33336562e-02f, -2.25824621e-02f, -1.85393438e-01f, -1.92635313e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.30816254e-02f, 2.61880457e-01f, -8.42047155e-01f, -2.45043308e-01f, -2.74941146e-01f, -1.96984574e-01f, 1.20231800e-01f, 3.92892361e-02f, 1.11629702e-02f, 5.88221438e-02f,
  4.53997292e-02f, -1.47959217e-01f, -1.44523248e-01f, -6.23495877e-02f, 4.54342328e-02f, -1.43367708e-01f, -1.94143385e-01f, -4.56452280e-01f, -3.59246165e-01f, -2.13036940e-01f,
  5.25148325e-02f, -2.55125284e-01f, -1.65578917e-01f, -5.55850975e-02f, -2.06035525e-01f, -2.96971887e-01f, -2.73559749e-01f, -4.13141131e-01f, -2.52787739e-01f, -2.93116599e-01f,
  -6.64726615e-01f, -1.98568910e-01f, -1.34289399e-01f, 1.80323720e-01f, -1.93308130e-01f, 4.26259264e-02f, 4.99206781e-02f, -7.32661262e-02f, 9.87522155e-02f, -4.02580015e-02f,
  -1.07969113e-01f, -7.55212680e-02f, -7.85319731e-02f, -8.39138106e-02f, -3.11153755e-02f, -9.27936584e-02f, -5.19874729e-02f, -1.66689947e-01f, -9.67233703e-02f, 4.81697079e-03f,
  8.90208185e-02f, -1.14175558e-01f, -2.64181465e-01f, -1.18864618e-01f, -1.27997860e-01f, -1.62939787e-01f, -1.10052265e-01f, -1.12387463e-01f, -2.26478845e-01f, 1.06195938e-02f,
  4.05542217e-02f, -1.10949781e-02f, -3.82328629e-02f, 4.03109938e-02f, 6.53033778e-02f, -5.11189774e-02f, -6.27826750e-02f, 1.75506417e-02f, 3.50487754e-02f, -3.99216823e-02f,
  -1.36529990e-02f, 1.52055640e-02f, 1.21608395e-02f, 2.91284416e-02f, -7.28209987e-02f, 1.68744884e-02f, 3.05162109e-02f, 9.78699848e-02f, -1.14006558e-02f, 1.91366822e-02f,
  -6.85888305e-02f, -5.17047606e-02f, -6.87581673e-02f, -2.95719579e-02f, -6.33993670e-02f, 1.53363254e-02f, -1.82124251e-03f, 9.32573378e-02f, -1.72979105e-02f, -3.62817524e-03f,
  2.41490304e-02f, -6.32702187e-02f, -4.05166224e-02f, 5.96908517e-02f, -1.70393914e-01f, 4.83024232e-02f, -3.70255783e-02f, -1.86161194e-02f, -6.30736053e-02f, -1.10880084e-01f,
  4.00856398e-02f, -1.78601537e-02f, -5.51546272e-03f, 2.13863384e-02f, -8.81984383e-02f, -5.54322489e-02f, 2.70454347e-01f, -7.34082833e-02f, -1.08104581e-02f, 7.82874599e-02f,
  1.21132180e-01f, 4.36622240e-02f, 1.01400137e-01f, 6.01199903e-02f, -2.51333714e-02f, -2.32591070e-02f, -1.33363113e-01f, -9.19633061e-02f, -6.29260615e-02f, 3.33873183e-01f,
  -4.29531246e-01f, -4.01451200e-01f, 2.13373482e-01f, -1.41781151e-01f, -5.71038462e-02f, -2.68775940e-01f, -6.24050617e-01f, -1.99740425e-01f, -5.17646819e-02f, -2.39224344e-01f,
  -1.52276695e-01f, -1.06692940e-01f, -1.71713620e-01f, -2.99545024e-02f, -3.10402423e-01f, -4.04768556e-01f, -2.70501316e-01f, -1.50624558e-01f, 1.02910865e-02f, -3.03488016e-01f,
  -2.49972016e-01f, -1.61328673e-01f, -1.07042260e-01f, -3.52675728e-02f, 7.97929019e-02f, 7.91173875e-02f, 1.04548797e-01f, -2.73527429e-02f, -7.88907260e-02f, -1.14656128e-01f,
  -1.67475641e-01f, -6.94519430e-02f, 1.13483950e-01f, -7.18788803e-02f, 7.11995810e-02f, -4.59271036e-02f, -7.20272362e-02f, 2.17358440e-01f, 1.27992317e-01f, -2.06107609e-02f,
  -3.90934609e-02f, -8.90764371e-02f, -1.09213963e-02f, 4.87387180e-02f, -2.60136183e-02f, -3.54118692e-03f, 4.59152088e-03f, 1.06762238e-01f, 1.78977937e-01f, -3.54027562e-03f,
  -1.50822818e-01f, -2.33456269e-01f, -1.31829783e-01f, 3.66637744e-02f, 2.43135169e-01f, -6.91854432e-02f, 9.68594700e-02f, 1.50370106e-01f, 2.61392564e-01f, 2.65642889e-02f,
  -1.27679985e-02f, 5.71355000e-02f, 9.16002411e-03f, -8.56522378e-03f, -1.18778035e-01f, 8.01421795e-03f, -8.66604690e-03f, -1.43593892e-01f, 3.61041836e-02f, -5.83776906e-02f,
  1.18748809e-03f, 3.66804004e-02f, 4.15323488e-02f, -8.23699757e-02f, -3.22539220e-03f, -1.46889612e-02f, -5.86620681e-02f, -5.50737046e-02f, -1.80705544e-02f, 3.12691294e-02f,
  -3.53601538e-02f, 5.60573563e-02f, 6.64667934e-02f, 1.33263995e-03f, 2.00252775e-02f, -1.50698209e-02f, 1.79928336e-02f, 2.19333656e-02f, 2.88355295e-02f, 1.92403384e-02f,
  -1.22966677e-01f, 1.79973826e-01f, -2.34277770e-01f, -1.35931075e-01f, -9.63285379e-03f, 1.26825854e-01f, -3.23963128e-02f, 1.04122795e-01f, 4.32257354e-02f, -9.22127739e-02f,
  -4.10797670e-02f, -5.64707890e-02f, -6.65108338e-02f, -7.75763020e-02f, -1.19302951e-01f, -1.27630353e-01f, -1.78587064e-01f, -9.29089934e-02f, -5.12996577e-02f, -4.00959998e-02f,
  -1.38023749e-01f, -4.00403529e-01f, -4.41005409e-01f, -2.14320913e-01f, -9.85869672e-03f, -2.84314215e-01f, -1.78870112e-01f, -6.56502768e-02f, -3.15849572e-01f, -4.72015500e-01f,
  -8.77797425e-01f, 4.31631804e-02f, -8.93252864e-02f, -7.53446937e-01f, -2.12419674e-01f, 1.32715568e-01f, 5.76216206e-02f, -9.07192081e-02f, -3.44786227e-01f, -1.73459649e-02f,
  1.66517705e-01f, 6.99581355e-02f, 6.47263378e-02f, 1.23151399e-01f, -7.08748326e-02f, -2.76058838e-02f, -4.12733436e-01f, -1.85179323e-01f, 1.11990079e-01f, 2.06248328e-01f,
  -7.78608695e-02f, -3.65220368e-01f, -3.13172460e-01f, -2.32779041e-01f, -8.63777399e-02f, 2.17668880e-02f, -2.04799041e-01f, -1.66149497e-01f, 1.73991978e-01f, -1.46091998e-01f,
  7.23906934e-01f, -2.08443373e-01f, 6.86793700e-02f, -2.23457694e-01f, 3.76228951e-02f, -3.96868773e-02f, 5.03489822e-02f, -8.92248005e-02f, -5.17123453e-02f, -5.76020889e-02f,
  -4.76330109e-02f, 2.72996891e-02f, -1.05566390e-01f, 1.02228627e-01f, -1.34430796e-01f, -1.17606353e-02f, -9.31577608e-02f, -1.56406894e-01f, -2.77424920e-02f, 5.02539985e-02f,
  -8.40190612e-03f, -3.97783369e-02f, -3.50343697e-02f, 1.75546184e-02f, 6.46422505e-02f, -1.27518192e-01f, 1.13070503e-01f, 5.90817221e-02f, 5.51200397e-02f, 1.61189660e-02f,
  -1.68310441e-02f, 4.91055436e-02f, 7.72112086e-02f, -2.39841789e-02f, -3.23468223e-02f, -8.27784091e-03f, -2.13910192e-02f, 5.10773854e-03f, 6.72314167e-02f, -2.12662872e-02f,
  2.93726791e-02f, 3.66428606e-02f, -9.48939845e-03f, -6.08707741e-02f, 3.44755538e-02f, -1.04710281e-01f, -3.38302925e-02f, 1.75037552e-02f, 3.83080356e-03f, -8.38699192e-02f,
  -1.77605692e-02f, 5.27104130e-03f, -1.03638239e-01f, 7.50065446e-02f, -5.84743321e-02f, -9.17243436e-02f, -2.66267750e-02f, 2.43319608e-02f, 5.07805236e-02f, -1.38743306e-02f,
  1.42805666e-01f, -1.49606273e-01f, 3.33500863e-03f, -2.76528299e-02f, -5.77432849e-02f, -4.18646932e-02f, 1.77576486e-02f, -2.23888718e-02f, -7.10339099e-02f, 8.04529563e-02f,
  1.61402836e-01f, 5.64104356e-02f, 1.25463884e-02f, 8.40797648e-02f, 2.97710449e-02f, 3.34505178e-02f, -1.27468616e-01f, -6.95723891e-02f, 3.61247435e-02f, 1.05697200e-01f,
  -5.62500842e-02f, -1.85635313e-01f, -8.46555158e-02f, 9.15435255e-02f, -3.07539105e-02f, -7.58148059e-02f, 2.61419177e-01f, 1.69903576e-01f, 4.40774485e-02f, -4.63535227e-02f,
  7.91688979e-01f, 6.97717011e-01f, 1.91652596e-01f, 3.09736550e-01f, -3.90141830e-02f, -2.29761600e-01f, -2.43850946e-01f, -2.69176930e-01f, -1.33837879e-01f, 3.73159647e-01f,
  3.21241498e-01f, -1.35583088e-01f, -9.00209621e-02f, -4.45400268e-01f, -4.57779318e-01f, -9.98876393e-02f, -1.20576873e-01f, -3.27463269e-01f, -7.13711441e-01f, -4.41395730e-01f,
  -1.76356465e-01f, 7.36411214e-02f, 7.11527765e-02f, -1.37814388e-01f, 2.63559997e-01f, -1.87894553e-01f, 3.46825004e-01f, 3.56698841e-01f, 1.53836414e-01f, 4.49536651e-01f,
  5.69360316e-01f, 7.41854787e-01f, -4.67264861e-01f, -1.75158270e-02f, 2.77771235e-01f, -5.69680426e-03f, 2.58554295e-02f, 1.38103634e-01f, 5.40863574e-02f, 4.67353202e-02f,
  1.69010669e-01f, 1.17086591e-02f, 1.02721306e-03f, -2.87220050e-02f, 3.93589996e-02f, -1.32515952e-01f, -5.46621606e-02f, -1.55331284e-01f, -1.53600678e-01f, 6.95482716e-02f,
  3.73689421e-02f, 2.84523070e-01f, 1.36841357e-01f, -2.42688030e-01f, -1.68486208e-01f, -1.80855393e-01f, 7.38773569e-02f, 7.00155199e-02f, -1.48576662e-01f, 1.92292839e-01f,
  -8.05521011e-02f, 6.08959794e-02f, 1.04178805e-02f, 1.49397552e-02f, 2.80027720e-03f, 5.62987179e-02f, -1.11192500e-03f, 2.18469445e-02f, -1.00747988e-01f, 4.08339500e-02f,
  -4.22958843e-02f, -2.53667007e-03f, 2.50862539e-02f, 8.53129011e-03f, 2.91717518e-02f, 7.81381503e-02f, -2.55667605e-02f, -2.40132231e-02f, -5.13811484e-02f, 3.27736810e-02f,
  -2.84144264e-02f, -2.68550590e-04f, 1.20359726e-01f, -8.20495635e-02f, 5.10321406e-04f, -6.71519786e-02f, 1.35267265e-02f, -8.39090422e-02f, 7.86626525e-03f, 1.16499349e-01f,
  1.67154875e-02f, -5.68555474e-01f, 1.16587341e-01f, -2.53944416e-02f, 8.28604549e-02f, 8.84973779e-02f, 1.87108576e-01f, -9.67837777e-03f, 1.02603070e-01f, -3.64163183e-02f,
  -1.42808747e-03f, -3.39850038e-02f, 1.62706196e-01f, -7.37817138e-02f, -1.23810977e-01f, -2.02063788e-02f, 8.04855824e-02f, -5.66979945e-02f, -2.04325080e-01f, 9.12284181e-02f,
  -1.10355116e-01f, -1.38986498e-01f, -2.31310531e-01f, -1.53949231e-01f, 3.62741426e-02f, -2.56653160e-01f, -1.37952417e-01f, -1.44730598e-01f, -2.45877728e-01f, -1.33108452e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.05596876e-01f, 3.01307440e-01f, 3.46810997e-01f, 1.00696981e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  2.98287630e-01f, -4.28595334e-01f, 3.22935760e-01f, -5.38575947e-01f, -1.10272157e+00f, -3.90903234e-01f, -4.26273532e-02f, -7.85987917e-03f, -7.35228181e-01f, 4.19235528e-01f,
  9.44526717e-02f, 6.40567690e-02f, 5.62160432e-01f, 6.86631978e-01f, 3.78042519e-01f, -8.32597673e-01f, -2.11547375e-01f, -1.09724343e+00f, -2.35142574e-01f, 3.95255923e-01f,
  3.39295655e-01f, 5.18784642e-01f, 8.79550576e-01f, 1.88122496e-01f, -1.48587334e+00f, 4.67851073e-01f, 9.91647005e-01f, -1.04021454e+00f, 5.41408241e-01f, -3.61760527e-01f,
  -1.81544587e-01f, -7.51778722e-01f, 4.58648950e-01f, 1.05877912e+00f, -3.66697669e-01f, 1.90332800e-01f, 4.55589771e-01f, 2.90013373e-01f, -3.20405334e-01f, 7.07529206e-03f,
  -1.10105884e+00f, -6.00804329e-01f, 7.56614685e-01f, 5.16937077e-01f, -5.01657724e-01f, 1.06254601e+00f, -2.94701606e-01f, -7.40216911e-01f, 2.63925105e-01f, 5.02687730e-02f,
  -1.05090284e+00f, 6.45899773e-01f, -3.66236538e-01f, 1.38619304e-01f, -8.91216516e-01f, 4.64524865e-01f, 1.10811245e+00f, -3.74319881e-01f, 7.57297337e-01f, -1.35540515e-01f,
  4.41677481e-01f, 3.50116491e-01f, 8.36707890e-01f, -6.39340222e-01f, -1.21018045e-01f, 4.38047796e-01f, 5.01514852e-01f, -5.15503526e-01f, -1.93727463e-01f, -5.67992628e-01f,
  1.58999458e-01f, 9.28254724e-01f, 7.37625420e-01f, 5.39853990e-01f, 4.50247437e-01f, 4.28002208e-01f, -3.74525189e-02f, 9.05294299e-01f, 2.01319933e-01f, 8.28481972e-01f,
  1.55419901e-01f, 6.79246604e-01f, 8.15610409e-01f, -5.60639799e-01f, 6.14811420e-01f, 3.82753402e-01f, 8.23008358e-01f, 7.29155660e-01f, -1.38692275e-01f, 4.44604486e-01f,
  -4.87157136e-01f, -1.66459624e-02f, 1.11898828e+00f, -6.04597390e-01f, -4.02465761e-01f, 2.57301450e-01f, -1.65176630e-01f, -1.88322812e-01f, -1.11124134e+00f, 5.13113081e-01f,
  -3.36072177e-01f, 6.49845302e-01f, -6.73449814e-01f, -6.44494236e-01f, -1.34786165e+00f, -3.08996476e-02f, -8.58577490e-01f, -5.42327538e-02f, -6.00448132e-01f, -2.82715738e-01f,
  -3.74139935e-01f, 9.79983389e-01f, -6.64059147e-02f, -8.04430068e-01f, 4.10137512e-02f, -9.88433838e-01f, -1.90401226e-02f, 6.12333477e-01f, -1.13454688e+00f, -5.34471869e-01f,
  1.24118328e+00f, -6.39430285e-01f, -9.62869883e-01f, 9.03474629e-01f, 3.50426696e-02f, -4.20102209e-01f, -3.38544756e-01f, -4.61493224e-01f, -1.07688591e-01f, 9.53992903e-01f,
  5.57709813e-01f, 9.73006010e-01f, 9.19265598e-02f, -1.16530621e+00f, 1.11726046e+00f, 1.80804655e-01f, 6.91352785e-01f, 2.31120035e-01f, -1.08759296e+00f, -9.49203789e-01f,
  -6.31602108e-01f, -2.96220452e-01f, -3.90767187e-01f, -4.67790663e-01f, 7.10933983e-01f, -2.54290462e-01f, 5.01696169e-01f, -1.41204342e-01f, 3.77801508e-01f, -5.48451006e-01f,
  -3.11684702e-02f, -4.37838346e-01f, -8.32989931e-01f, -1.31338969e-01f, 8.80552292e-01f, 1.16722786e+00f, -2.27090627e-01f, 4.92643155e-02f, -1.60893470e-01f, 1.14462256e+00f,
  -5.52343845e-01f, 1.70686528e-01f, -5.94573557e-01f, 3.48755419e-01f, 3.04912835e-01f, 3.93175155e-01f, 7.31670022e-01f, 5.21157801e-01f, 7.61425078e-01f, 1.20551765e-01f,
  1.13310993e-01f, -4.89132762e-01f, -4.13489461e-01f, -3.39788318e-01f, 1.44685507e+00f, -4.16310430e-02f, -2.92231470e-01f, 4.44908947e-01f, 5.07230282e-01f, 2.16537192e-01f,
  1.07708508e-02f, -1.48290187e-01f, -6.96020663e-01f, -3.82966697e-01f, 1.10061336e+00f, -1.97699249e-01f, 2.31893420e-01f, -1.43174160e+00f, -1.87901229e-01f, -3.36720258e-01f,
  -2.28977412e-01f, 1.10535312e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.42547566e-01f, 1.22699368e+00f, 4.50206287e-02f, -1.73493415e-01f, -3.71479213e-01f, 9.34071913e-02f, -3.07372063e-01f, 4.06857520e-01f, 3.83195341e-01f, -4.35266852e-01f,
  -2.76007444e-01f, -1.37728930e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    