/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.57653487e-01f, 9.95219499e-02f, 2.36485103e-05f, -1.78978369e-01f, 1.89640582e-01f, 2.36461505e-01f, 4.14273769e-01f, -9.26080812e-03f, -9.75062698e-03f, 1.49712279e-01f,
  -6.52006418e-02f, -1.61207378e-01f, -8.39292333e-02f, -1.41091093e-01f, -3.48889418e-02f, 2.56150156e-01f, 1.74857721e-01f, -1.54829726e-01f, -1.69532090e-01f, -9.77055207e-02f,
  2.01187998e-01f, -1.55319348e-01f, -3.06808054e-01f, -1.07233688e-01f, 8.30988735e-02f, 1.92301050e-01f, 1.92226201e-01f, -1.12329550e-01f, -4.57107723e-02f, 3.29131708e-02f,
  -4.63118479e-02f, -2.91933447e-01f, 3.17431018e-02f, -9.63468254e-02f, 1.10165980e-02f, -4.66151573e-02f, 6.92308471e-02f, -4.16045859e-02f, -5.79644479e-02f, -4.28432934e-02f,
  -1.44631322e-02f, -4.01985012e-02f, -1.13212988e-01f, 6.46206662e-02f, -2.11588736e-03f, -3.50247361e-02f, -6.49438575e-02f, -1.40442118e-01f, -8.73497576e-02f, 2.75509041e-02f,
  1.99883021e-02f, -1.62280902e-01f, -1.97551563e-01f, 2.12284662e-02f, -1.18865237e-01f, -1.19357303e-01f, -5.27870692e-02f, -1.78663701e-01f, -9.63045433e-02f, 9.77989882e-02f,
  6.98337406e-02f, 2.26556975e-02f, 5.28757013e-02f, 4.36106551e-04f, 4.66708876e-02f, 2.50035003e-02f, -2.55072284e-02f, 6.72149435e-02f, 1.55756800e-02f, -2.42395308e-02f,
  -2.07766704e-03f, -9.55465995e-03f, 1.93392821e-02f, -1.15768999e-01f, 3.22325639e-02f, -3.18282917e-02f, 1.16025761e-03f, 8.15317035e-02f, -7.05839321e-02f, 3.36842872e-02f,
  -4.14634421e-02f, 1.83492675e-02f, -1.79441867e-03f, 3.77479531e-02f, -9.40819755e-02f, -1.45137720e-02f, -2.08997037e-02f, -3.14923003e-02f, 3.50105539e-02f, 9.11809970e-03f,
  9.24156681e-02f, -1.16620272e-01f, 2.81329863e-02f, 4.98171989e-03f, 9.06332955e-02f, -4.54339720e-02f, -5.86242080e-02f, -5.00187427e-02f, 3.84453568e-03f, -3.00665642e-03f,
  -3.51422131e-02f, 8.09079409e-03f, 6.36369959e-02f, -1.62786935e-02f, 8.83542299e-02f, 4.01641149e-03f, 9.20513496e-02f, -1.44603010e-02f, -1.36926735e-03f, 4.78133373e-03f,
  2.89118998e-02f, 2.08820343e-01f, 1.51549906e-01f, 9.55546051e-02f, 3.07605439e-03f, 6.57815561e-02f, 2.82727659e-01f, 1.36866108e-01f, 4.26728539e-02f, 4.73654568e-01f,
  1.45081773e-01f, -3.30843121e-01f, 4.53623831e-01f, -2.23380268e-01f, -3.57386656e-02f, 2.71218777e-01f, 1.53732523e-01f, -6.47414923e-02f, -2.05969363e-01f, -1.57392010e-01f,
  -1.89908341e-01f, -1.50892004e-01f, -1.96167469e-01f, -1.18117973e-01f, 8.29449296e-02f, 5.93108870e-02f, 1.21943511e-01f, 3.26221406e-01f, 2.60670334e-01f, 8.79712701e-02f,
  -1.87985763e-01f, -1.36369660e-01f, 2.69042794e-02f, -5.51839657e-02f, -6.99109957e-02f, -2.08886340e-01f, -8.15706700e-02f, 6.54683784e-02f, -7.34646916e-02f, 2.14817017e-01f,
  2.13486061e-01f, 2.12172121e-01f, 4.04641926e-02f, -4.76504490e-02f, -1.22087441e-01f, 2.31836718e-02f, 6.95467144e-02f, -1.61598325e-02f, -9.81189758e-02f, -1.57580711e-03f,
  2.82096099e-02f, 4.93311211e-02f, 9.06685367e-02f, -5.76988697e-08f, -1.18242763e-02f, 5.50125204e-02f, -3.01120263e-02f, 5.70385940e-02f, -6.66295271e-03f, -1.51210288e-02f,
  -1.59111787e-02f, 1.00925609e-01f, 1.47151455e-01f, 2.82398500e-02f, 1.43927839e-02f, 2.02090576e-01f, -5.38839027e-02f, 7.44369850e-02f, 6.98653758e-02f, -8.08098391e-02f,
  -1.89907644e-02f, 3.41217369e-02f, 6.60551637e-02f, 3.44611220e-02f, -5.91589101e-02f, -8.84970352e-02f, 4.90269698e-02f, -5.09695634e-02f, 2.06854157e-02f, -7.86096510e-03f,
  -2.25654580e-02f, -2.89886650e-02f, -3.18865292e-02f, -3.27288434e-02f, -4.78506051e-02f, 6.89238822e-03f, 9.51661840e-02f, -5.86527064e-02f, 4.07826249e-03f, 1.00247152e-02f,
  -1.69894081e-02f, 3.52313817e-02f, -2.11081263e-02f, 4.41684108e-03f, 3.60193141e-02f, -1.22268628e-02f, 9.43710729e-02f, 4.15770821e-02f, -5.39442338e-02f, 3.19073796e-02f,
  -3.13142687e-01f, 8.56307223e-02f, -2.59923134e-02f, 1.91268139e-02f, 7.20846578e-02f, -9.04683843e-02f, 5.82638830e-02f, -3.74890529e-02f, 2.31441995e-03f, -5.10430001e-02f,
  2.74367314e-02f, 6.98060170e-02f, 9.57366824e-03f, -3.93994711e-03f, 4.15530754e-03f, -9.72864626e-04f, -7.98610076e-02f, -1.67667586e-02f, -4.26554214e-03f, -1.29420729e-03f,
  -1.00601152e-01f, -4.51002643e-02f, -7.18117598e-03f, -2.60662660e-03f, 3.41598764e-02f, 2.33978359e-03f, -6.02336340e-02f, -5.88424457e-03f, 4.52082939e-02f, -3.81948084e-01f,
  3.55910808e-01f, -1.28899589e-01f, 8.14678967e-02f, 1.94864333e-01f, -3.22692655e-02f, 1.94229614e-02f, -2.06763640e-01f, -2.92668468e-04f, 8.88509005e-02f, -1.85049862e-01f,
  -1.83536395e-01f, -5.15012396e-03f, 6.14793934e-02f, 8.79099295e-02f, 1.22582264e-01f, 9.72536057e-02f, 2.68419534e-01f, 2.25967988e-01f, 2.44765878e-01f, -1.25727458e-02f,
  3.92342210e-02f, 2.50129700e-01f, 2.09697306e-01f, 1.68310195e-01f, -1.88900027e-02f, 9.26030874e-02f, -3.01481411e-02f, 9.17685498e-03f, -6.51668012e-03f, 1.34278104e-01f,
  -3.86759304e-02f, -1.95552204e-02f, -5.96731342e-02f, 7.09768981e-02f, -9.42417979e-02f, 3.19652110e-02f, -1.02415524e-01f, -1.20286141e-02f, 5.67358397e-02f, -8.80929455e-02f,
  -4.55926172e-02f, -1.02086335e-01f, 1.53022170e-01f, 8.48318562e-02f, 1.70240030e-01f, 1.85107030e-02f, 7.85676613e-02f, -2.55367868e-02f, 4.30839621e-02f, -6.76197112e-02f,
  -1.26193494e-01f, -6.87193032e-03f, 1.01914361e-01f, -4.82815430e-02f, -1.22375444e-01f, 3.44972424e-02f, -7.81575143e-02f, -3.09906658e-02f, -8.95459428e-02f, -5.18708602e-02f,
  -5.19386455e-02f, -5.12629896e-02f, 2.69141626e-02f, -1.37421852e-02f, -7.88584817e-03f, -1.46295782e-02f, -3.44147161e-02f, -3.25281322e-02f, 1.10982712e-02f, 5.58852181e-02f,
  8.63983470e-04f, -2.03709342e-02f, -2.37349663e-02f, -1.62390787e-02f, -3.11166118e-03f, 7.34039694e-02f, -3.03743072e-02f, -4.79623936e-02f, -2.22065300e-02f, 6.01493940e-03f,
  -9.25457384e-03f, -3.69292609e-02f, 5.19855991e-02f, -1.62602984e-03f, -7.44645670e-02f, -5.07277660e-02f, -3.16397846e-02f, -2.15568338e-02f, 3.63250002e-02f, 3.83099988e-02f,
  2.46692345e-01f, -1.58940256e-01f, -7.90246204e-02f, 8.49457532e-02f, -1.17419269e-02f, -7.68911242e-02f, -8.32167044e-02f, -3.71382013e-02f, 5.53912669e-02f, 1.14614675e-02f,
  -3.24888639e-02f, 7.66945630e-02f, -6.91245422e-02f, -9.46036726e-02f, 2.06474420e-02f, 5.36521636e-02f, -3.07478160e-02f, 6.47511706e-02f, 9.20813764e-04f, -8.79286453e-02f,
  -6.04243428e-02f, -4.01743986e-02f, -1.52402110e-02f, -5.65791205e-02f, -2.77047753e-02f, 9.40595791e-02f, 1.27725840e-01f, -7.11717084e-03f, 7.89828226e-03f, -3.63591313e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.03556406e-01f, 1.66747775e-02f, -2.67706551e-02f, 2.56344918e-02f, 3.80130820e-02f, 1.67241991e-01f, 8.95322934e-02f, 9.19564813e-03f, -2.32890956e-02f, 3.80617082e-02f,
  1.05944246e-01f, 2.58362353e-01f, 2.38962203e-01f, 1.60978913e-01f, 8.35478082e-02f, -4.70941849e-02f, -1.34785427e-02f, 1.36526689e-01f, 1.36029243e-01f, 1.65238768e-01f,
  3.62147316e-02f, 1.20835509e-02f, -1.78581290e-02f, -6.63878571e-04f, 1.91960495e-03f, 4.14434634e-02f, 3.84659618e-02f, 2.26977263e-02f, -9.57365781e-02f, -6.53788149e-02f,
  1.38794571e-01f, 1.91968709e-01f, 1.08018545e-02f, 1.22791473e-02f, 4.39591706e-02f, 9.31767840e-03f, 7.57784843e-02f, -5.61872832e-02f, -2.63437396e-03f, -5.07361218e-02f,
  -6.82598203e-02f, 6.32071719e-02f, -9.06241965e-03f, 4.56907675e-02f, 5.82835227e-02f, 7.20840320e-02f, -8.36479217e-02f, 9.46056191e-03f, -3.53812985e-02f, -7.79864416e-02f,
  -1.35504454e-01f, 6.40849918e-02f, 3.81777510e-02f, -3.56351957e-03f, -8.78216028e-02f, 8.47686902e-02f, -4.24289815e-02f, -1.93050038e-02f, 3.18528563e-02f, -1.18286006e-01f,
  6.24075122e-02f, 1.16258807e-01f, 1.84413176e-02f, -1.20838219e-03f, 7.83230290e-02f, 6.47641346e-02f, 4.93017286e-02f, 2.95972005e-02f, 9.37340781e-02f, 7.40268687e-03f,
  1.06695168e-01f, 3.05744987e-02f, 9.17245522e-02f, 2.38441955e-02f, 1.05078802e-01f, 3.07335053e-02f, 5.19779837e-03f, 5.27968481e-02f, 4.24384549e-02f, -4.39558364e-02f,
  1.38265453e-02f, 6.35064170e-02f, 5.44191040e-02f, -2.01742854e-02f, -7.50955427e-03f, 9.82074365e-02f, 9.68353152e-02f, 1.28020227e-01f, 3.65159251e-02f, 1.33758737e-02f,
  -6.35744929e-02f, 1.68669894e-01f, 1.42318189e-01f, -3.68937515e-02f, -5.02893589e-02f, -8.88165832e-02f, -4.50940691e-02f, -1.06750816e-01f, -1.00122385e-01f, -1.06420405e-01f,
  -4.04953510e-02f, 2.78498558e-03f, -5.37042543e-02f, -2.65375022e-02f, -7.13643506e-02f, -3.33195105e-02f, -1.60960760e-02f, 8.18256363e-02f, -7.71556646e-02f, -4.57049645e-02f,
  -1.13031521e-01f, -4.38327864e-02f, 8.79679099e-02f, -4.06666249e-02f, -2.77229529e-02f, 1.71571031e-01f, -3.08314785e-02f, -8.04007947e-02f, 5.43539077e-02f, -4.83076908e-02f,
  2.20960915e-01f, 1.80240303e-01f, 1.49563536e-01f, 1.22915842e-02f, 6.19184449e-02f, 9.68887657e-02f, 1.35889992e-01f, 4.21630591e-02f, -1.31671414e-01f, -2.47908793e-02f,
  1.61990896e-02f, -1.61637366e-02f, -7.79621005e-02f, -1.01932675e-01f, -4.68308702e-02f, -1.07748576e-01f, -2.22802386e-02f, -1.03716977e-01f, -1.15357056e-01f, -8.47920328e-02f,
  -7.44472593e-02f, 5.77064827e-02f, 1.77185498e-02f, 5.11041135e-02f, 5.42580746e-02f, 1.61907487e-02f, 3.11568758e-04f, 1.46090761e-01f, 3.72764654e-02f, 1.33036479e-01f,
  1.80323184e-01f, 2.26685748e-01f, -1.32186506e-02f, 1.77765079e-02f, 7.27443025e-02f, 6.98141903e-02f, -2.78812032e-02f, 6.16310816e-03f, -4.47703153e-02f, 4.81514484e-02f,
  7.19766319e-02f, 8.37729126e-03f, 1.03774309e-01f, 9.87258181e-03f, -4.66238707e-02f, 1.16053279e-02f, -4.80934046e-02f, -2.71778237e-02f, -4.15062048e-02f, 9.98537838e-02f,
  3.67945321e-02f, 1.74317956e-01f, 4.78061847e-02f, -3.97838503e-02f, -2.61942088e-03f, -2.49225032e-02f, 1.62924856e-01f, -1.33163845e-02f, 7.52547979e-02f, 1.20131463e-01f,
  -1.09130852e-01f, -7.82789215e-02f, -4.49149534e-02f, 8.18758272e-03f, -6.45171255e-02f, -3.86929214e-02f, 2.05686782e-02f, 2.26128995e-02f, -8.92226491e-03f, 3.42000350e-02f,
  -8.37498158e-02f, -4.78037857e-02f, 8.49517062e-02f, -1.00090899e-01f, -9.90049243e-02f, -2.60693692e-02f, 7.10123777e-02f, -5.76977842e-02f, 2.58606113e-02f, -6.02635257e-02f,
  5.36122397e-02f, -5.49460389e-02f, 3.32918800e-02f, -1.63499489e-02f, -6.71482682e-02f, 4.46349718e-02f, -9.75896418e-02f, -6.57901019e-02f, -7.43000880e-02f, 7.99486712e-02f,
  1.05965488e-01f, -5.44348545e-03f, 4.34361249e-02f, 1.40231540e-02f, 9.37018991e-02f, -4.99148518e-02f, -1.30118607e-02f, -1.32083218e-03f, 1.12590916e-01f, 6.20983876e-02f,
  -3.77650224e-02f, 1.41341900e-02f, 8.96770358e-02f, 5.38135208e-02f, -9.66051444e-02f, -1.14950128e-02f, 4.28952351e-02f, 5.36364615e-02f, 9.34165120e-02f, 8.49940032e-02f,
  -5.66440374e-02f, -6.71878308e-02f, -1.19201735e-01f, -1.35190740e-01f, -7.04588965e-02f, -1.02271944e-01f, 2.86479155e-03f, 5.97679876e-02f, 1.53246084e-02f, -1.13183990e-01f,
  -3.33700866e-01f, -3.19909841e-01f, 1.68445602e-01f, -8.83756503e-02f, -2.08398089e-01f, -1.86450019e-01f, -1.79205328e-01f, -2.31105223e-01f, -4.95450245e-03f, -1.26479700e-01f,
  6.17579138e-03f, 1.77957937e-01f, 2.20092013e-01f, 1.08340211e-01f, 2.17436980e-02f, -4.53493781e-02f, -1.84688345e-01f, 1.31521240e-01f, 1.26666889e-01f, -4.38888408e-02f,
  -1.51387721e-01f, -5.31873712e-03f, 4.11517965e-03f, -1.26373880e-02f, 2.91172508e-02f, 1.70132488e-01f, -6.45947903e-02f, 3.62908468e-02f, -4.23321836e-02f, 1.27088446e-02f,
  4.40543413e-01f, -1.43712848e-01f, 4.19498011e-02f, -2.01945230e-01f, -9.02003449e-05f, -6.82895482e-02f, 1.38161685e-02f, 3.48064043e-02f, -3.83970351e-03f, 3.43045034e-02f,
  -5.28130569e-02f, -1.00014405e-02f, -4.53407913e-02f, -3.04880794e-02f, -9.69704986e-02f, -2.66823415e-02f, -1.81496173e-01f, 1.90671068e-02f, -8.24562982e-02f, -9.76518840e-02f,
  -6.79079145e-02f, -1.24524370e-01f, 1.03101760e-01f, -6.67286068e-02f, 3.50872241e-02f, 8.78426656e-02f, -4.79971282e-02f, -6.34633601e-02f, -1.21186748e-01f, -1.19033113e-01f,
  4.73381858e-03f, 4.33054231e-02f, 1.60596706e-02f, 5.20829409e-02f, 5.72360232e-02f, -3.29833888e-02f, 4.92442362e-02f, -3.50441374e-02f, -2.05066502e-02f, -2.96847802e-02f,
  -5.70040233e-02f, 2.76935175e-02f, 4.96899225e-02f, -4.13759947e-02f, -3.04781664e-02f, -2.89662220e-02f, -2.39788834e-02f, -1.72927212e-02f, -9.94183272e-02f, 5.62708341e-02f,
  3.04895267e-02f, 4.83915359e-02f, -2.36161985e-02f, 9.39622670e-02f, -5.19413762e-02f, 1.69073492e-02f, -5.83351636e-03f, -3.33571695e-02f, 2.97097228e-02f, -1.41990650e-02f,
  2.20477685e-01f, -2.44569499e-02f, 1.66312624e-02f, -3.97316292e-02f, -4.36797701e-02f, -2.50927005e-02f, 1.72459874e-02f, -1.33820355e-01f, 1.29817761e-02f, -4.22397396e-03f,
  -2.32881233e-02f, -1.80299999e-03f, -1.87552273e-02f, -3.27306278e-02f, 3.79067659e-02f, -5.58297671e-02f, -9.15043354e-02f, 3.46951894e-02f, 6.69324771e-02f, -3.74911912e-02f,
  -1.15211412e-01f, -4.14223745e-02f, 8.58638510e-02f, 1.03695109e-01f, 2.60199197e-02f, 6.48343712e-02f, 2.51663536e-01f, 1.03803821e-01f, 8.77461582e-02f, 3.29698902e-03f,
  -2.45869994e-01f, 3.58652249e-02f, 3.58306430e-02f, -1.75378360e-02f, 1.13115259e-01f, 9.10858661e-02f, 1.05402425e-01f, 1.05761752e-01f, -4.71924581e-02f, -7.65879974e-02f,
  -6.97180256e-02f, -1.24908313e-01f, -3.33314538e-02f, 2.82128192e-02f, -4.92125079e-02f, 9.43283439e-02f, 1.79611474e-01f, 5.47534898e-02f, -4.30734940e-02f, 1.56850629e-02f,
  4.85031009e-02f, -1.00809403e-01f, -1.06513992e-01f, -9.96329859e-02f, 2.68630893e-03f, -1.71413906e-02f, 5.64341322e-02f, 7.38723725e-02f, -6.75148703e-03f, 6.85517117e-02f,
  -1.10936165e-01f, -4.81774099e-02f, 2.23812414e-03f, -1.93703771e-02f, -4.92752902e-02f, -9.60912034e-02f, -5.87531105e-02f, -1.12685300e-01f, -1.49182584e-02f, 5.99428304e-02f,
  -1.02087967e-01f, -9.09730792e-02f, 3.79350409e-03f, -1.01975083e-01f, 1.27547793e-02f, -1.11084633e-01f, -7.20824227e-02f, -4.64676172e-02f, 9.03366953e-02f, 1.46167316e-02f,
  1.38942420e-01f, 3.95687185e-02f, 5.08847646e-02f, 1.12214781e-01f, 3.46286735e-03f, 6.00425936e-02f, 2.90346500e-02f, -1.40269371e-02f, -1.93015188e-02f, -3.12586911e-02f,
  1.02390964e-02f, -3.27161700e-02f, -5.82393706e-02f, 2.83542238e-02f, -5.24178930e-02f, -4.94385976e-03f, 1.81909706e-02f, 5.58861298e-03f, -4.71968353e-02f, 9.28635709e-03f,
  -6.25852272e-02f, -5.56204543e-02f, 4.83375192e-02f, 3.26889530e-02f, 3.02279294e-02f, 8.27054158e-02f, 1.16162084e-01f, -3.54808830e-02f, 5.29825389e-02f, 4.64960299e-02f,
  2.91895885e-02f, 9.03363675e-02f, 4.37253155e-02f, 6.75472617e-02f, -4.64489944e-02f, 6.91225305e-02f, 3.37375067e-02f, 1.77011900e-02f, -6.81581423e-02f, 6.41520321e-02f,
  -5.56630641e-02f, 1.03809223e-01f, -1.73735157e-01f, -8.42727199e-02f, -7.82868043e-02f, 5.02069481e-03f, 4.61269207e-02f, 1.20988367e-02f, 1.12270536e-02f, -1.44214062e-02f,
  6.57957122e-02f, 1.20792156e-02f, -6.45414889e-02f, -7.30366334e-02f, -8.25516433e-02f, -5.57830036e-02f, -1.85403489e-02f, -1.05752863e-01f, 2.46941280e-02f, 1.34352669e-02f,
  4.34861369e-02f, -6.53385818e-02f, -1.22915275e-01f, 1.68856569e-02f, -2.38214694e-02f, -1.15845092e-01f, -6.54695481e-02f, 4.02857997e-02f, -8.04583654e-02f, -4.16079946e-02f,
  3.97521585e-01f, 1.79345071e-01f, 1.61374629e-01f, 1.29711673e-01f, 7.95515925e-02f, 1.10745681e-02f, -1.66182537e-02f, -7.68673867e-02f, -4.88852449e-02f, 5.09944856e-02f,
  1.72521286e-02f, 1.08164482e-01f, -9.06203538e-02f, -1.43916115e-01f, -7.73672760e-02f, 2.13806145e-02f, -8.50752518e-02f, -4.13973108e-02f, -4.18118164e-02f, 4.93121743e-02f,
  3.08624133e-02f, 5.78387268e-02f, 3.14389877e-02f, 5.53201102e-02f, 1.93272725e-01f, 7.80712697e-04f, 6.91827461e-02f, 1.97915688e-01f, 1.75950244e-01f, 2.33105719e-01f,
  1.00651540e-01f, 1.20851867e-01f, -1.70277253e-01f, 4.43336889e-02f, 1.41968742e-01f, 2.45781317e-02f, -2.70943306e-02f, -3.87365595e-02f, -9.12856981e-02f, 4.03118655e-02f,
  -1.62171945e-02f, 9.01576802e-02f, -2.30456814e-02f, 7.96183478e-03f, 5.65471165e-02f, 2.05513984e-02f, -1.02116421e-01f, -1.98691841e-02f, -2.14873645e-02f, 6.74634948e-02f,
  6.99191317e-02f, 1.07611410e-01f, 1.16444221e-02f, -1.46637037e-01f, 2.60053426e-02f, -9.28133205e-02f, 9.15840492e-02f, 2.08884887e-02f, 4.06931043e-02f, 3.20700482e-02f,
  -5.62761724e-02f, 4.18721586e-02f, 7.91993085e-03f, 1.02085941e-01f, 1.22757945e-02f, -2.64311545e-02f, 8.71716887e-02f, 2.34636366e-02f, -7.52308443e-02f, 2.37510391e-02f,
  -2.56469976e-02f, -1.11116655e-02f, -3.80399562e-02f, -2.63542626e-02f, -1.06660062e-02f, 8.49367008e-02f, 1.21390037e-02f, -5.45458272e-02f, 3.13273035e-02f, 2.55947057e-02f,
  7.98509121e-02f, -7.03500584e-02f, -3.37714069e-02f, -5.25995903e-02f, 5.61338402e-02f, 9.72788185e-02f, 7.92175233e-02f, 3.26645598e-02f, 2.61658430e-02f, 4.80053155e-03f,
  -4.21162732e-02f, -2.28713349e-01f, -7.29505485e-03f, 5.09859137e-02f, 7.18013907e-04f, 3.80995907e-02f, 8.77587050e-02f, -9.03460979e-02f, -1.19792894e-02f, -1.00682292e-03f,
  3.09067275e-02f, 3.88062708e-02f, -4.97813821e-02f, 1.32147886e-03f, -1.00008294e-01f, 3.29759717e-02f, 4.65044565e-02f, -1.62948668e-02f, -1.29265577e-01f, -7.04586431e-02f,
  -8.05154890e-02f, -1.78285673e-01f, -2.19754919e-01f, -9.67351124e-02f, -6.08798712e-02f, -1.11955449e-01f, -5.86688407e-02f, -5.52525967e-02f, -1.61574349e-01f, -1.91869959e-01f,
  2.84125894e-01f, -7.18305632e-02f, 3.58160436e-02f, 2.57559180e-01f, 3.05427194e-01f, 1.80921808e-01f, 3.36949825e-01f, 3.42423439e-01f, 1.17549367e-01f, 7.35617876e-02f,
  -1.07039504e-01f, 4.36361618e-02f, 9.32021290e-02f, 2.52849013e-02f, 1.33969486e-01f, 1.11305110e-01f, 1.83483422e-01f, -6.85606990e-03f, 2.39150841e-02f, 4.19644155e-02f,
  7.56773949e-02f, 1.44831404e-01f, -4.88712499e-03f, 7.50236511e-02f, -5.14306463e-02f, 2.34610233e-02f, 7.88623020e-02f, 2.10117046e-02f, -1.92770302e-01f, -1.19796753e-01f,
  -3.53300661e-01f, 1.62427232e-01f, 3.96642741e-03f, -1.79905072e-02f, -1.11273229e-01f, -1.30016014e-01f, -1.48801152e-02f, -1.82326287e-01f, -5.06997257e-02f, -5.02779484e-02f,
  -3.12040225e-02f, 4.15092660e-03f, -4.97747362e-02f, -1.09649315e-01f, 2.47819070e-02f, 1.79990996e-02f, -1.04624733e-01f, 1.11588188e-01f, 1.78003646e-02f, -1.11694440e-01f,
  -1.15349256e-01f, -6.12602159e-02f, 1.02965109e-01f, 1.55895993e-01f, -8.10480583e-03f, -8.41756817e-03f, -1.13865793e-01f, -1.47040293e-01f, 4.11464609e-02f, 1.13878503e-01f,
  -8.12414195e-03f, -6.71118051e-02f, -4.39163186e-02f, 6.57095462e-02f, 1.50985690e-02f, -1.19786672e-02f, 5.75418882e-02f, -1.84643827e-02f, 2.21030638e-02f, 1.08189825e-02f,
  -7.21262246e-02f, 7.21624494e-02f, 5.40391505e-02f, 8.63715708e-02f, -5.32252453e-02f, 4.98846872e-03f, -3.21449339e-02f, 1.96505729e-02f, -1.19448103e-01f, 1.35653559e-02f,
  -2.80585140e-03f, -4.24504243e-02f, -9.19074491e-02f, 1.26700010e-02f, -6.10122085e-02f, -1.15499031e-02f, -5.68627641e-02f, 1.25917681e-02f, 6.91025555e-02f, 6.87861517e-02f,
  8.99132490e-02f, 5.81599586e-02f, -4.45255777e-03f, 3.15130763e-02f, -3.69598716e-02f, -1.01204187e-01f, -5.44485226e-02f, -9.12643820e-02f, -1.66681871e-01f, -3.70455272e-02f,
  -8.28551725e-02f, -2.43518502e-02f, -4.70100418e-02f, -3.07074301e-02f, 3.50580849e-02f, 4.09737080e-02f, -6.31665215e-02f, 1.02634788e-01f, 6.81195706e-02f, -4.29017246e-02f,
  1.79276969e-02f, 2.11399302e-01f, 1.19829722e-01f, 1.60029933e-01f, -4.49095741e-02f, 1.38599053e-01f, -1.39097162e-02f, 6.41741082e-02f, 1.14947356e-01f, 1.30412236e-01f,
  2.10568920e-01f, -2.64792740e-01f, -3.36129606e-01f, -1.61426991e-01f, -3.27827223e-02f, -2.82170903e-02f, -2.01017976e-01f, -1.63541734e-02f, -6.83081001e-02f, -1.36644468e-01f,
  -7.20737875e-02f, 1.53625533e-01f, -3.82927805e-02f, 5.61310463e-02f, 8.61421004e-02f, -2.29185328e-01f, -2.31239304e-01f, -1.36232236e-02f, 9.37054902e-02f, 4.03488539e-02f,
  4.38461080e-02f, -9.23042223e-02f, 4.58823424e-03f, -1.11810781e-01f, -1.74996793e-01f, -1.36144340e-01f, -2.55033284e-01f, -1.53258622e-01f, -1.04549535e-01f, -2.69569546e-01f,
  -2.90335983e-01f, -2.08461620e-02f, 1.37923107e-01f, 1.66796312e-01f, 2.83824047e-03f, 6.75307587e-02f, -5.38878655e-03f, 6.49289265e-02f, 3.14847939e-02f, -4.30214964e-02f,
  1.96283776e-03f, 5.73393479e-02f, 1.07273031e-02f, 1.32547878e-02f, 7.85346404e-02f, 3.17810997e-02f, 2.37553567e-03f, 3.62418070e-02f, 7.63478177e-03f, -8.96392390e-02f,
  -1.06071956e-01f, -5.56276739e-02f, 6.52770996e-02f, -2.01942176e-02f, -4.32362296e-02f, 2.51392256e-02f, 1.43262707e-02f, 5.12728728e-02f, 1.02293380e-01f, -4.56707478e-02f,
  1.77271180e-02f, 1.24157555e-02f, -5.75849749e-02f, -4.60697897e-02f, 7.59869292e-02f, 6.48083165e-04f, 3.40783340e-03f, 5.59441857e-02f, 6.91498518e-02f, 2.34820973e-02f,
  -6.84362799e-02f, 9.84084606e-03f, -6.54164283e-03f, -1.21552860e-02f, -2.21072417e-03f, -4.55469713e-02f, 4.96056490e-03f, -9.66524854e-02f, 4.76117730e-02f, -3.51441763e-02f,
  -9.69479419e-03f, 2.97596324e-02f, -7.04556480e-02f, -6.24400377e-03f, -2.78224088e-02f, -7.42346868e-02f, -9.01590660e-02f, -2.37974245e-02f, 3.85340154e-02f, -1.14546977e-01f,
  -4.40955125e-02f, 1.11067057e-01f, 3.72279622e-02f, 1.20685756e-01f, 4.17644391e-03f, 6.21977402e-03f, 4.74190935e-02f, 3.62112820e-02f, 1.50059862e-03f, 3.89986187e-02f,
  4.90130596e-02f, 3.86744039e-03f, -1.00527406e-01f, 1.36116184e-02f, 1.14103548e-01f, 1.61429662e-02f, -3.26905102e-02f, -1.05912341e-02f, 1.02990642e-01f, -9.73978862e-02f,
  -5.05110584e-02f, 8.55541602e-02f, 1.56232744e-01f, 1.40245959e-01f, 1.05746360e-02f, 2.43068650e-01f, 4.23219092e-02f, -1.52225168e-02f, 5.39216325e-02f, 4.01059166e-02f,
  -2.14071125e-01f, 3.87690924e-02f, 6.76558688e-02f, -6.15112856e-02f, -4.76829447e-02f, 9.09368172e-02f, 3.57544199e-02f, 2.30208486e-02f, -8.31706673e-02f, -8.65391418e-02f,
  -1.38743684e-01f, -9.55775157e-02f, -8.37061927e-02f, 4.40166071e-02f, 1.26675352e-01f, -1.46059773e-03f, 2.18631364e-02f, 4.25689667e-02f, 2.42872778e-02f, 3.62424813e-02f,
  2.72002295e-02f, 5.42397574e-02f, -8.53625536e-02f, -5.11505641e-02f, -4.64468114e-02f, -7.04329908e-02f, 7.36473799e-02f, -9.23531428e-02f, 8.01473260e-02f, -9.59555618e-03f,
  1.36055900e-02f, -1.38314590e-01f, 6.39460161e-02f, -3.85804921e-02f, 8.02495927e-02f, 1.05756409e-01f, 1.65599566e-02f, 4.13136370e-02f, -4.27084565e-02f, -4.75363433e-03f,
  -3.30770649e-02f, 2.54576504e-02f, 6.65951073e-02f, 8.15477818e-02f, 3.32496129e-02f, 6.49043769e-02f, 1.14854172e-01f, -1.20547591e-02f, -5.86455129e-03f, -5.81479073e-03f,
  -1.47225121e-02f, -8.59669819e-02f, -2.88224760e-02f, 1.09278463e-01f, 1.12938955e-01f, 1.81539189e-02f, -5.66354059e-02f, 6.52884543e-02f, 1.16770037e-01f, 8.74428228e-02f,
  -2.48883478e-03f, 4.09662239e-02f, 1.43076887e-03f, 5.17860278e-02f, 5.88716604e-02f, 9.53386799e-02f, 7.31911883e-02f, -2.35707574e-02f, -5.98339504e-03f, 2.59915404e-02f,
  -7.46141130e-04f, 8.74783620e-02f, 7.79498518e-02f, 6.57491572e-03f, -2.88102515e-02f, -7.26157576e-02f, -2.89233327e-02f, -3.48092467e-02f, -3.91326360e-02f, 3.77461128e-02f,
  -8.11624676e-02f, -4.40888815e-02f, -9.98347998e-02f, 1.02708559e-03f, 9.14673358e-02f, -8.48650038e-02f, 6.85516372e-02f, -8.91284123e-02f, 4.04382348e-02f, -3.31717394e-02f,
  -7.94629194e-03f, 5.08567765e-02f, -1.16818048e-01f, 2.82449392e-03f, -3.30096893e-02f, -4.15270515e-02f, -1.01517923e-01f, -6.91758171e-02f, -9.68996808e-02f, -1.01228133e-02f,
  -1.71937961e-02f, -1.04724415e-01f, 3.71405147e-02f, 5.86254522e-03f, -5.27400039e-02f, 5.70717342e-02f, 2.86114821e-03f, -3.33676562e-02f, 9.79532078e-02f, 8.94424170e-02f,
  -4.31975573e-02f, -8.05697143e-02f, -9.04976279e-02f, -3.18713821e-02f, -5.73250502e-02f, 1.38582913e-02f, -4.78029996e-02f, -8.06769282e-02f, 6.84115514e-02f, -3.48773174e-05f,
  -1.50933519e-01f, -1.97648466e-01f, -4.95120764e-01f, -6.38688281e-02f, 2.86312476e-02f, 8.74995366e-02f, -2.24686041e-01f, 1.34301245e-01f, 1.06422096e-01f, -1.40022263e-01f,
  -6.35070652e-02f, 1.65475622e-01f, -9.60673094e-02f, 3.27744856e-02f, -5.57440743e-02f, -4.68100727e-01f, -4.72040355e-01f, -2.07632437e-01f, 1.14956863e-01f, 3.58245254e-01f,
  4.14534733e-02f, -8.43655244e-02f, -6.96905097e-03f, 1.36848629e-01f, -7.50485361e-02f, 1.16921728e-02f, -2.24422872e-01f, -9.39363390e-02f, 7.90694878e-02f, -1.50340110e-01f,
  -3.66729856e-01f, 2.41560210e-02f, 6.60719126e-02f, 1.18100360e-01f, -1.32962242e-01f, -4.95822243e-02f, -8.61714408e-02f, -6.45031407e-02f, 3.34482454e-02f, 5.64212389e-02f,
  -3.62497196e-02f, 2.88071372e-02f, -1.61405299e-02f, 3.66504863e-02f, -5.93927763e-02f, 3.81147005e-02f, -7.85600021e-03f, 6.06069751e-02f, -4.24296632e-02f, 3.38644325e-03f,
  2.86043044e-02f, 1.62704308e-02f, -4.21935394e-02f, 5.01426570e-02f, 1.49202913e-01f, 1.07085578e-01f, 3.08479983e-02f, 1.80103689e-01f, 1.63463607e-01f, 4.63355146e-02f,
  -1.90892536e-02f, -4.55059931e-02f, 2.21104976e-02f, 1.23344563e-01f, -7.43888989e-02f, 5.97688854e-02f, 9.88859497e-03f, -5.45763336e-02f, 4.65225950e-02f, -5.67593202e-02f,
  4.64668162e-02f, -3.78575772e-02f, -3.24591585e-02f, -9.59818661e-02f, 2.55152564e-02f, -3.69109623e-02f, 1.48058112e-03f, 1.19992653e-02f, -2.84749977e-02f, 4.08132598e-02f,
  6.00002483e-02f, -1.41176786e-02f, -3.23426537e-02f, -2.87885685e-02f, 4.34205262e-03f, -8.41693059e-02f, -9.55711864e-03f, 1.39739811e-01f, 4.17567939e-02f, 1.56595170e-01f,
  -4.84380312e-03f, 1.08657129e-01f, -2.05336839e-01f, 5.93577586e-02f, -8.95034671e-02f, -9.55307670e-03f, -7.35993078e-03f, 3.25710401e-02f, -7.13626295e-02f, -3.97946537e-02f,
  1.26124263e-01f, 6.09947070e-02f, -7.45077580e-02f, 3.22465179e-03f, 7.06585646e-02f, 8.45206827e-02f, 2.09542494e-02f, 1.51613252e-02f, 1.73886314e-01f, 1.53323933e-01f,
  -4.44905423e-02f, 1.23804346e-01f, -3.29534374e-02f, 5.46031855e-02f, 3.91460053e-04f, -1.28289051e-02f, 9.93707124e-03f, 4.86239195e-02f, -5.78901246e-02f, -1.86589196e-01f,
  -1.12261549e-01f, -4.32051439e-03f, 1.95879623e-01f, 3.16898897e-02f, 1.70836747e-02f, -1.99364070e-02f, -4.13293950e-02f, -4.34866222e-03f, 9.95108709e-02f, 4.83225957e-02f,
  -3.13711949e-02f, 1.99016165e-02f, 1.74500998e-02f, 1.31200943e-02f, -6.16534846e-03f, -2.97029503e-02f, -2.78161503e-02f, 5.81081808e-02f, 3.87792699e-02f, -3.67497578e-02f,
  -7.23732561e-02f, 4.09307852e-02f, 4.63744439e-02f, 1.16099395e-01f, 9.75697339e-02f, 1.37542915e-02f, -1.64182093e-02f, -1.64403804e-02f, 4.24407497e-02f, 1.57003384e-02f,
  1.30973026e-01f, -3.26169394e-02f, 8.29528365e-03f, -6.63170144e-02f, 7.65198916e-02f, 2.96662399e-03f, 1.27323836e-01f, 3.36050708e-03f, 1.06573729e-02f, 8.93801749e-02f,
  1.16690151e-01f, 6.79230317e-02f, 8.66164193e-02f, 4.65482660e-02f, 3.31923962e-02f, 7.76336640e-02f, 5.76227941e-02f, -1.56473722e-02f, -3.71890776e-02f, 1.37308508e-01f,
  -4.98852925e-03f, 3.42083699e-03f, 1.09632378e-02f, 6.94308951e-02f, 3.49903591e-02f, -1.46009102e-02f, -4.15971875e-02f, 9.00168717e-02f, 3.23888175e-02f, 9.72554758e-02f,
  -5.92495408e-03f, -4.13405374e-02f, 7.88417924e-03f, 3.18379998e-02f, -1.07731707e-01f, 6.40695915e-02f, 3.13956365e-02f, -4.52051014e-02f, -7.22547695e-02f, 7.32058734e-02f,
  2.66138688e-02f, 3.74065042e-02f, 2.91741583e-02f, 6.70486188e-04f, 2.30767615e-02f, -1.73537713e-02f, 6.75580874e-02f, -2.50929408e-02f, -5.46015836e-02f, -6.79405779e-02f,
  -4.98361923e-02f, 3.87087725e-02f, -5.21134138e-02f, -7.18467310e-02f, -5.78052253e-02f, 3.55418846e-02f, 4.24444349e-03f, 4.92715091e-02f, -1.45612536e-02f, 3.93112414e-02f,
  2.06533242e-02f, -5.82087226e-02f, 2.52329614e-02f, 2.79607140e-02f, -5.90119697e-03f, 2.83232387e-02f, 1.36651658e-03f, 3.28453630e-02f, 1.02022858e-02f, 1.00700267e-01f,
  7.34178871e-02f, 1.01921624e-02f, 1.00957125e-01f, 3.42243128e-02f, 3.20041850e-02f, 1.37262791e-01f, 7.71241412e-02f, 2.76070740e-03f, 6.24869876e-02f, 8.39398578e-02f,
  -5.55234402e-03f, 3.96385603e-02f, 6.98511079e-02f, -2.28097606e-02f, 5.07296659e-02f, 6.44441172e-02f, 7.52922595e-02f, 4.59019318e-02f, 9.10571963e-02f, -2.95279454e-02f,
  -3.53748411e-01f, -2.29639202e-01f, -1.75477803e-01f, -1.14963315e-01f, -3.51713188e-02f, -9.88455489e-02f, -2.56246179e-01f, 6.57588914e-02f, -3.20248529e-02f, -2.12726399e-01f,
  -9.03863683e-02f, 9.98915285e-02f, 3.43135968e-02f, 5.79517074e-02f, 1.88673772e-02f, -3.58397871e-01f, -3.21446538e-01f, -7.97575712e-02f, 1.13737196e-01f, 1.74872875e-01f,
  6.85656667e-02f, -1.04680285e-01f, 1.26105640e-02f, 2.54426636e-02f, 4.01910804e-02f, 1.11487590e-01f, -4.30470482e-02f, 5.93765564e-02f, 5.22103682e-02f, -4.58791442e-02f,
  6.54167011e-02f, -1.73016682e-01f, 1.04039975e-01f, -1.34428427e-01f, -4.01576124e-02f, 7.60301575e-03f, -1.77405367e-03f, 3.51182260e-02f, -9.23836231e-02f, 6.90733418e-02f,
  -3.00663486e-02f, 4.00914364e-02f, 2.08125785e-02f, 3.01894620e-02f, -4.76773418e-02f, 4.75022756e-02f, -7.76140392e-02f, -1.80772878e-02f, -6.61848113e-02f, -1.18920589e-02f,
  -2.18733605e-02f, -1.11907572e-02f, -3.50907184e-02f, 9.08177570e-02f, 6.63823495e-03f, 8.24075863e-02f, 9.62913856e-02f, 2.12627307e-01f, 1.38096556e-01f, -6.92993477e-02f,
  -3.10745873e-02f, 1.19482353e-01f, -4.70819697e-02f, -3.50749902e-02f, 8.74826405e-03f, -5.92130646e-02f, -1.13767214e-01f, -6.62197918e-02f, 3.49458307e-02f, 1.12349410e-02f,
  6.18151389e-02f, -3.15573029e-02f, 2.31380505e-03f, -1.87323466e-02f, -2.29279697e-02f, -1.06140496e-02f, 2.89107338e-02f, 1.49198631e-02f, -3.28901857e-02f, 2.95828190e-02f,
  -4.72680256e-02f, 4.18521911e-02f, -6.06514849e-02f, 5.93686029e-02f, -1.45327911e-01f, -4.90921773e-02f, -3.22691165e-02f, 1.10835247e-01f, 2.54560690e-02f, -4.92607430e-02f,
  1.63276270e-01f, 5.51440404e-04f, -1.03297129e-01f, 1.16827730e-02f, -6.69115335e-02f, 3.51186246e-02f, -4.17547785e-02f, -5.32827117e-02f, 2.94647589e-02f, -3.10624596e-02f,
  6.42979145e-02f, -7.92669803e-02f, -9.33121517e-02f, 4.05568518e-02f, 7.31552988e-02f, 7.72877876e-03f, -1.27454758e-01f, -1.28758475e-01f, 3.64823192e-02f, 3.53939757e-02f,
  -2.87676193e-02f, -1.67745680e-01f, -8.85870904e-02f, -5.08039212e-03f, 1.09689444e-01f, -6.73230365e-02f, 1.03959262e-01f, 4.35899794e-02f, 2.68030837e-02f, -2.08629698e-01f,
  3.04483593e-01f, 1.19064562e-01f, 1.74694493e-01f, 1.50267884e-01f, 1.30091012e-01f, 2.00842068e-01f, 1.97013289e-01f, 1.80381402e-01f, 3.34171318e-02f, 1.60255820e-01f,
  2.26502672e-01f, 5.55132963e-02f, -6.82049543e-02f, -9.98563319e-02f, 5.24311364e-02f, -1.99595969e-02f, -1.76885724e-01f, -1.73388589e-02f, -1.96121307e-03f, 5.27051762e-02f,
  -8.87616947e-02f, 6.19265810e-02f, -4.61206585e-02f, -6.98573664e-02f, -9.23056602e-02f, -1.36696085e-01f, 8.93002097e-03f, -3.64715233e-02f, -3.23343165e-02f, -1.67133167e-01f,
  -3.41606103e-02f, 2.53549129e-01f, -1.36654511e-01f, -6.20621964e-02f, 9.23017561e-02f, -5.79648912e-02f, 3.54746245e-02f, 2.50904653e-02f, 6.44993633e-02f, 2.22453848e-02f,
  9.47789624e-02f, 1.71466507e-02f, 7.39874840e-02f, -4.27542590e-02f, -1.57439301e-03f, 3.26145850e-02f, -6.54388443e-02f, 5.61074018e-02f, -2.33352799e-02f, 4.63182777e-02f,
  7.28019401e-02f, 5.17591164e-02f, 1.54406816e-01f, 1.59100816e-02f, -1.10378712e-02f, -3.99097847e-03f, 1.22429356e-01f, 4.15177420e-02f, -5.26441261e-03f, 3.12551744e-02f,
  1.07610207e-02f, -3.05863209e-02f, -2.01341081e-02f, -1.85296230e-03f, -4.45676735e-03f, 2.94550601e-02f, 8.04142728e-02f, 6.28192797e-02f, -5.71300201e-02f, -7.64093548e-03f,
  -7.84318987e-03f, 2.29188129e-02f, 5.16035082e-03f, 9.24369097e-02f, -1.30707055e-01f, 6.67184442e-02f, -4.26424388e-03f, -3.02552786e-02f, 2.20356770e-02f, -7.35717267e-02f,
  9.64364037e-03f, -7.62917921e-02f, 2.24534832e-02f, 5.77992806e-03f, -8.59809443e-02f, 3.15102004e-02f, -5.90455905e-02f, 3.49482894e-02f, 4.71822396e-02f, -4.72127832e-02f,
  -1.41254783e-01f, 1.97924644e-01f, -1.16746917e-01f, -1.34560600e-01f, -6.72815517e-02f, -3.14997435e-02f, 3.95490639e-02f, -8.67725387e-02f, 5.34479041e-03f, 5.31609990e-02f,
  3.58743966e-02f, -4.44374159e-02f, 7.34649450e-02f, -8.86519030e-02f, 4.06745709e-02f, -4.29497957e-02f, 4.75633629e-02f, -2.54293215e-02f, 5.65606914e-02f, -2.73842402e-02f,
  -1.35782018e-01f, -5.19075692e-02f, 7.60573223e-02f, -8.92727748e-02f, 7.67062306e-02f, 2.35411618e-02f, -8.49579871e-02f, -4.58059683e-02f, 9.96365920e-02f, -9.62413922e-02f,
  2.60537982e-01f, 2.85861790e-01f, 1.99354604e-01f, 1.80018708e-01f, 3.33617657e-01f, 3.47570211e-01f, 3.40866327e-01f, 1.76554844e-01f, -4.10633255e-03f, 1.05078600e-01f,
  9.48209092e-02f, 4.54534590e-02f, -2.82698050e-02f, -7.81514049e-02f, 7.31109176e-03f, 2.70332471e-02f, 1.50314793e-01f, 5.44172414e-02f, -1.12436660e-01f, 1.31699536e-02f,
  4.59398441e-02f, 7.31070265e-02f, -9.17602256e-02f, -3.62974480e-02f, 9.48552191e-02f, -4.25858572e-02f, -1.99484285e-02f, 2.43348796e-02f, 5.35285547e-02f, -1.46024749e-02f,
  7.15459213e-02f, 3.90189439e-01f, -3.16140763e-02f, -1.49582237e-01f, 4.18250710e-02f, -1.84163198e-01f, 4.41758409e-02f, -8.81023332e-02f, 2.42491644e-02f, -6.51026666e-02f,
  -1.72847304e-02f, -1.20315151e-02f, 8.09088722e-02f, 5.17400354e-03f, 3.50817330e-02f, -5.69423381e-03f, -1.14960019e-02f, 1.26879951e-02f, -5.23951389e-02f, 3.25637832e-02f,
  -3.44023816e-02f, 6.95453137e-02f, 1.77679598e-01f, -3.52528729e-02f, 7.99309015e-02f, -5.79591244e-02f, 5.94909303e-02f, 3.51798572e-02f, -8.79260153e-03f, -9.46874768e-02f,
  -1.28282487e-01f, 6.89561442e-02f, 2.73239799e-02f, 4.03195843e-02f, -9.18563679e-02f, -5.21276742e-02f, 5.02901599e-02f, 3.28386202e-02f, -4.12735483e-03f, -8.90270323e-02f,
  -5.85049056e-02f, 3.99269611e-02f, 6.20704703e-03f, 3.13267298e-03f, -5.21869771e-02f, 4.05072346e-02f, -7.04212114e-03f, -4.88255136e-02f, -8.92293975e-02f, -1.86233558e-02f,
  -7.23939463e-02f, 4.34297547e-02f, 2.11439580e-02f, -8.28618258e-02f, -3.07166185e-02f, 5.26154377e-02f, -1.29883781e-01f, -1.07236199e-01f, -2.04729736e-02f, 6.17867894e-02f,
  -1.28120080e-01f, -2.67677996e-02f, -4.33172509e-02f, 5.46908239e-03f, 1.43051460e-01f, -8.85533839e-02f, 3.67238261e-02f, -1.16455713e-02f, -3.75791453e-02f, 2.76908278e-03f,
  1.51385009e-01f, -9.85787883e-02f, 2.33950187e-02f, -1.04504600e-01f, -2.51084603e-02f, -7.17918947e-02f, 3.66972685e-02f, 4.73110154e-02f, -9.21885730e-05f, -2.86359880e-02f,
  -3.09504401e-02f, 4.24150415e-02f, -8.63724053e-02f, 2.35745627e-02f, -3.84266414e-02f, -1.12864532e-01f, -1.01058878e-01f, -8.22887495e-02f, -2.59171445e-02f, -1.27970651e-01f,
  -3.96976322e-02f, -1.77671269e-01f, 1.47128269e-01f, -7.28072226e-02f, -4.24555540e-02f, 6.58030212e-02f, -4.45731394e-02f, -1.29849464e-01f, -1.03399985e-01f, -6.74030408e-02f,
  3.45691037e-03f, 7.55426288e-02f, 7.74884522e-02f, 1.58079982e-01f, 6.68962374e-02f, -6.91037998e-02f, -5.68308793e-02f, 1.50971532e-01f, 5.62510714e-02f, 9.51903015e-02f,
  -1.22166589e-01f, 4.42131609e-02f, -1.91061143e-02f, -1.00387566e-01f, 6.09756634e-02f, -4.61360812e-02f, -5.06697670e-02f, -8.23216215e-02f, -1.10032842e-01f, -2.38615908e-02f,
  3.21728081e-01f, -2.14929104e-01f, 5.02032079e-02f, -1.23377383e-01f, -2.77608391e-02f, -8.27252269e-02f, -4.07496700e-03f, 2.05060164e-03f, -6.57484680e-02f, 6.71520308e-02f,
  5.05068116e-02f, -5.08232489e-02f, 6.70946166e-02f, -5.55135980e-02f, -6.76578209e-02f, 3.06355916e-02f, -7.62303025e-02f, 4.02798504e-02f, -3.94017063e-02f, 2.55860798e-02f,
  -3.37961912e-02f, -7.17547769e-03f, 8.44613314e-02f, -1.03851728e-01f, 5.44904806e-02f, 2.11543292e-02f, -4.01055329e-02f, -9.05057043e-02f, 5.79159223e-02f, -3.45528647e-02f,
  8.22747424e-02f, -1.64558773e-03f, -8.18942636e-02f, 2.27635168e-02f, 3.49247418e-02f, 8.30907896e-02f, 9.98229161e-02f, 3.23703773e-02f, -2.61880718e-02f, 6.92010298e-02f,
  -4.21069451e-02f, 8.92382711e-02f, 6.93396106e-03f, -6.43664598e-02f, -5.47888204e-02f, 2.94131227e-02f, 2.27275640e-02f, -7.75216445e-02f, -5.16973548e-02f, -3.25358398e-02f,
  -9.41052958e-02f, -3.51239033e-02f, -6.85093552e-02f, -6.17327355e-02f, -4.30629618e-04f, 4.86316271e-02f, -6.66429326e-02f, 5.36008589e-02f, -4.91537759e-03f, 5.53842895e-02f,
  1.10254489e-01f, 2.14227159e-02f, 1.52527288e-01f, -2.39482112e-02f, -1.23980321e-01f, -4.92321737e-02f, -4.07410320e-04f, -1.26501888e-01f, -3.47858332e-02f, 9.42391530e-02f,
  4.46714722e-02f, 1.17816992e-01f, 3.90455015e-02f, -4.98549528e-02f, 1.86086167e-02f, -4.69098836e-02f, -1.51059970e-01f, -4.96805869e-02f, -2.89247464e-03f, -6.19856492e-02f,
  -7.30027035e-02f, 6.69745058e-02f, 1.22213051e-01f, 1.53886095e-01f, 4.31497209e-02f, 1.40918925e-01f, 1.45139754e-01f, 5.78035749e-02f, 6.97940961e-02f, 1.24402456e-02f,
  1.47860065e-01f, 1.74800456e-01f, 1.33665830e-01f, -2.69618561e-03f, 1.24726832e-01f, 1.70667484e-01f, -5.52187115e-03f, -1.25793085e-01f, 9.60031804e-03f, 6.30233809e-02f,
  1.76645786e-01f, -7.77797177e-02f, -1.26401305e-01f, -1.54193826e-02f, -1.12661049e-01f, -1.44905314e-01f, -1.35409594e-01f, -1.64540019e-02f, -1.58227786e-01f, -8.79990086e-02f,
  -3.47987674e-02f, -8.99550319e-02f, 1.83675811e-02f, -6.18755817e-02f, 5.78151047e-02f, 4.58910801e-02f, 7.43588284e-02f, 1.81363642e-01f, 1.33488715e-01f, 9.28674564e-02f,
  8.94882157e-02f, 8.72776657e-02f, -1.93329841e-01f, -7.64710084e-02f, 1.06572881e-01f, -1.44293848e-02f, 3.82858664e-02f, 3.71279232e-02f, 4.00310606e-02f, -1.33348733e-01f,
  1.28752425e-01f, 4.98160385e-02f, 5.09661026e-02f, -3.04035153e-02f, 4.40744273e-02f, -6.18819669e-02f, -7.09759146e-02f, -1.06267996e-01f, -8.84122960e-03f, -3.26392911e-02f,
  2.52594948e-02f, 1.32820383e-01f, 9.83430669e-02f, 6.34753751e-03f, -9.51347798e-02f, 4.62075770e-02f, 4.80938479e-02f, 7.96292573e-02f, -6.60850480e-02f, -1.13529243e-01f,
  -6.63666986e-04f, -7.09672412e-03f, 3.71845029e-02f, 5.32628521e-02f, -7.42204711e-02f, 1.01453125e-01f, -4.30277288e-02f, -4.24048156e-02f, 4.40062732e-02f, 8.15572590e-03f,
  8.50984752e-02f, -1.63684059e-02f, 7.37587735e-02f, -4.03311811e-02f, 1.42586064e-02f, -2.70926431e-02f, -2.82307081e-02f, -4.07495536e-02f, 1.35458456e-02f, 3.16534787e-02f,
  -7.06636384e-02f, -3.65147069e-02f, 8.32597315e-02f, -6.39167204e-02f, -3.98984291e-02f, 8.66027847e-02f, 4.12501991e-02f, 5.45073263e-02f, -3.91007103e-02f, 9.39224213e-02f,
  -1.61047831e-01f, 7.19717413e-04f, -1.69354025e-02f, -3.41867544e-02f, 1.43072782e-02f, -4.03161421e-02f, -5.77367423e-03f, 2.71958876e-02f, 8.70251358e-02f, 9.12333187e-03f,
  6.15045391e-02f, -7.85450339e-02f, -1.02388384e-02f, -1.41624603e-02f, -4.02005352e-02f, 2.95048952e-03f, -1.10060489e-02f, -1.17763482e-01f, 6.80140546e-03f, 8.06177408e-02f,
  -1.19051035e-03f, -1.40604898e-01f, -7.17483386e-02f, -7.47100934e-02f, -3.48520316e-02f, 4.16521020e-02f, 2.55774725e-02f, 4.14818898e-02f, -1.19413234e-01f, -8.19906890e-02f,
  2.75377333e-01f, 2.71111459e-01f, 1.64859612e-02f, 3.34138907e-02f, 5.48846684e-02f, -1.27304539e-01f, -1.10150360e-01f, -4.23060581e-02f, -3.71899642e-02f, -3.05923074e-02f,
  6.70170784e-02f, -8.76207091e-03f, -5.64428568e-02f, -8.68226774e-03f, -7.76310042e-02f, -1.87781472e-02f, -1.09439500e-01f, -2.93400530e-02f, -1.15296701e-02f, -1.51095223e-02f,
  5.23481816e-02f, 9.08053517e-02f, 1.43356295e-02f, 9.00652036e-02f, 1.68135509e-01f, 1.49548084e-01f, 8.43592137e-02f, 4.31544967e-02f, 6.10258393e-02f, 2.81920344e-01f,
  8.09547529e-02f, 9.34406593e-02f, -1.92098275e-01f, -2.44046841e-02f, 1.07441314e-01f, 4.91206087e-02f, -7.55851194e-02f, 7.12968782e-02f, -2.87739877e-02f, -1.22412071e-01f,
  2.98763029e-02f, 1.81635693e-02f, 1.97316855e-02f, -6.62505180e-02f, -4.28545177e-02f, -6.65900037e-02f, -1.05243675e-01f, 2.41547618e-02f, -1.03551500e-01f, 5.40115386e-02f,
  7.90422186e-02f, -4.32002395e-02f, -1.08715177e-01f, -1.56350389e-01f, 2.73017883e-02f, -1.39717022e-02f, 4.28291783e-02f, -4.96743135e-02f, 7.80108338e-03f, 5.74760102e-02f,
  2.76576704e-03f, -1.42507199e-02f, -3.88290584e-02f, 4.76963483e-02f, -1.48755908e-02f, -7.85685703e-02f, 1.35382209e-02f, -3.69126424e-02f, -1.11043334e-01f, 2.71898918e-02f,
  4.35672253e-02f, 5.77851534e-02f, -9.22597274e-02f, -2.14968305e-02f, -1.15136644e-02f, 6.52895914e-03f, -1.12241907e-02f, 3.75555158e-02f, -1.03808120e-01f, -5.59021346e-02f,
  -3.33182290e-02f, 2.33294349e-03f, 8.61072242e-02f, 5.23056723e-02f, 2.66633984e-02f, -8.96855518e-02f, 4.71834801e-02f, 4.37603407e-02f, -3.03078047e-03f, 6.32166713e-02f,
  -1.53275922e-01f, -2.82818049e-01f, -6.83740601e-02f, 7.54722729e-02f, 2.16835435e-03f, 1.43572316e-02f, -3.13718542e-02f, -7.72896558e-02f, 8.13649669e-02f, -8.79199579e-02f,
  2.42035417e-03f, -1.34881020e-01f, -7.50979260e-02f, -7.11712241e-02f, -2.21213177e-02f, -1.55434847e-01f, 3.53290439e-02f, -2.73166522e-02f, -1.36036187e-01f, 1.79392472e-02f,
  -2.02876497e-02f, -9.28646401e-02f, -1.29385129e-01f, -1.74829587e-01f, -8.31112266e-02f, -9.84728634e-02f, -1.50432751e-01f, -8.12550262e-02f, -2.32147619e-01f, -7.69938007e-02f,
  -6.99213818e-02f, -1.42769590e-02f, -4.74133939e-02f, 1.48508418e-02f, -2.22166404e-01f, -3.05473596e-01f, -2.28539437e-01f, -1.83220744e-01f, -1.29203901e-01f, -3.48511897e-02f,
  -6.97993860e-02f, 6.23580664e-02f, 6.80554062e-02f, -1.51162252e-01f, -2.78826475e-01f, -2.31600776e-01f, -2.53872931e-01f, -2.90781021e-01f, -3.33235860e-01f, -1.43950909e-01f,
  -1.49019569e-01f, -1.66254029e-01f, -2.20230922e-01f, -1.11739226e-01f, 1.60347149e-01f, 1.25071555e-01f, 9.11484361e-02f, -1.14150465e-01f, -2.66774055e-02f, -9.49573219e-02f,
  1.38639510e-01f, 6.87400103e-02f, -2.16957536e-02f, -1.78247634e-02f, 2.25992296e-02f, -2.14082990e-02f, -3.39427125e-03f, 6.80039870e-03f, 8.44744965e-03f, 1.06576875e-01f,
  -1.12707671e-02f, -5.82377389e-02f, 1.12497054e-01f, 1.27156660e-01f, -2.92895660e-02f, -1.52750639e-02f, -4.67301086e-02f, 1.52558824e-02f, 8.37073401e-02f, 1.87023524e-02f,
  -1.34373317e-02f, -1.35130197e-01f, -5.45170112e-03f, 5.42781204e-02f, 8.93359482e-02f, -4.03980687e-02f, 6.52648285e-02f, 4.00971584e-02f, -3.87757681e-02f, 9.86010283e-02f,
  -5.07419556e-02f, -7.97541998e-03f, 5.74110728e-03f, -2.13525705e-02f, 6.93874480e-03f, 3.94147448e-02f, 1.03658974e-01f, 4.05331515e-02f, -1.03761926e-02f, 1.04740247e-01f,
  -3.30830701e-02f, -1.10609084e-01f, -4.99631912e-02f, 9.21143219e-03f, 3.08503471e-02f, 2.58268900e-02f, -1.89198982e-02f, -8.99524316e-02f, 4.75208983e-02f, -7.59368464e-02f,
  1.84024181e-02f, -3.52803315e-03f, 1.61819905e-02f, 1.51046794e-02f, -1.12697534e-01f, 2.17733625e-03f, -1.12099852e-02f, -8.38168785e-02f, 1.49762454e-02f, 1.14007462e-02f,
  3.02692086e-01f, -2.20771044e-01f, 1.26120478e-01f, 6.17142096e-02f, 7.08792359e-02f, -1.92324724e-02f, 1.42535612e-01f, 9.46342647e-02f, 8.44639242e-02f, -3.22382413e-02f,
  -5.21354862e-02f, 8.01257193e-02f, 7.12110549e-02f, -6.06116187e-03f, -4.28394005e-02f, -4.57566567e-02f, -5.55486046e-02f, 8.68644863e-02f, -1.26989439e-01f, 7.65758427e-03f,
  3.00355088e-02f, -1.31340966e-01f, 1.04561515e-01f, 5.96265644e-02f, 3.34171094e-02f, -1.09496705e-01f, 1.65087953e-01f, 2.77721044e-02f, -6.88894466e-02f, 1.59939781e-01f,
  -1.31130025e-01f, -4.26970199e-02f, 1.75489355e-02f, 7.14348927e-02f, -5.47135323e-02f, -2.11574230e-02f, -2.65912749e-02f, 8.11837688e-02f, 6.45248219e-02f, -9.62134749e-02f,
  -5.03313541e-02f, -9.56550762e-02f, -2.38321815e-02f, 3.79208066e-02f, 7.42159262e-02f, 5.76875322e-02f, 2.27652699e-01f, 6.41487762e-02f, 1.66286021e-01f, 7.20822960e-02f,
  1.06052585e-01f, 9.77906026e-03f, 7.04286620e-02f, 1.42799646e-01f, 5.26177026e-02f, -2.42049471e-02f, -3.21430108e-03f, 9.12928581e-02f, -5.34939840e-02f, 1.52041122e-01f,
  -1.21101506e-01f, -2.10815785e-03f, -1.15217753e-02f, -6.57927692e-02f, 7.78609440e-02f, -2.77943555e-02f, 7.79807866e-02f, 1.29758745e-01f, -1.43640935e-02f, 1.16554074e-01f,
  -1.68675836e-02f, 1.10405022e-02f, -4.79064969e-04f, 2.74895076e-02f, -5.14917262e-02f, 5.16348220e-02f, -4.47877347e-02f, 1.42247155e-01f, 1.56204760e-01f, -1.38635291e-02f,
  -6.43229112e-02f, 3.27516943e-02f, 3.40801366e-02f, 2.76664644e-02f, 4.70739976e-02f, 5.87940104e-02f, 2.78122649e-02f, -1.46423001e-02f, 1.65332258e-02f, 1.18219621e-01f,
  -4.11868505e-02f, -1.48699241e-04f, -7.45808333e-02f, -2.32742894e-02f, 1.04745943e-02f, 5.46868555e-02f, 3.61678302e-02f, 2.08805525e-03f, 2.49096528e-02f, 3.18173654e-02f,
  -7.22891465e-02f, -4.67444491e-03f, -7.68110231e-02f, -3.35284439e-03f, -1.28050437e-02f, 6.47272021e-02f, -3.50876078e-02f, 6.85366839e-02f, -1.17481500e-01f, -3.54118533e-02f,
  -4.20906357e-02f, -1.53209614e-02f, 2.86941463e-03f, 5.73186129e-02f, -4.02339958e-02f, -1.87760144e-02f, -4.75094505e-02f, -5.35094514e-02f, 8.72761682e-02f, 1.79395005e-02f,
  1.05495088e-01f, 4.02932391e-02f, 1.26914252e-02f, 7.78650567e-02f, 6.03233874e-02f, -6.90515041e-02f, -6.12455681e-02f, 3.42314318e-02f, 2.29204055e-02f, 6.42362386e-02f,
  -1.02145836e-01f, -1.46428531e-03f, -1.76194739e-02f, 1.17480401e-02f, -4.13963012e-02f, -6.57828674e-02f, 3.17811593e-02f, -6.66179582e-02f, 8.80694687e-02f, 7.02555701e-02f,
  -4.30616997e-02f, -1.19543925e-03f, 4.89339866e-02f, -5.04665002e-02f, -3.17692943e-02f, 4.79683653e-02f, -3.57818194e-02f, -6.50344789e-02f, 9.04522464e-02f, -4.27016094e-02f,
  -2.94103235e-01f, -1.04638010e-01f, 2.23516643e-01f, -7.15257525e-02f, -1.10383652e-01f, -4.15319912e-02f, -2.35512014e-02f, -5.15174642e-02f, -6.38005883e-02f, -1.71650931e-01f,
  -2.01526478e-01f, 4.89485227e-02f, -3.20192100e-03f, 7.47418404e-02f, 9.61114094e-02f, 2.10239395e-01f, 3.39188546e-01f, 3.55346322e-01f, 1.84706315e-01f, 9.16992873e-02f,
  1.21833853e-01f, 3.96057926e-02f, 1.96749330e-01f, 2.10083157e-01f, 1.65380374e-01f, 9.02173445e-02f, 6.13938719e-02f, 9.70567316e-02f, 1.60404518e-01f, 2.03722879e-01f,
  -2.29937047e-01f, -1.55162111e-01f, 3.49881761e-02f, -2.33736690e-02f, 9.72257927e-02f, 6.88178688e-02f, -3.41890380e-02f, 1.09931082e-01f, -4.93234536e-03f, -4.70614992e-03f,
  -1.11559190e-01f, 1.99789293e-02f, -4.46465649e-02f, 6.44920617e-02f, -4.84819487e-02f, -4.12311256e-02f, 1.76438823e-01f, 8.72126594e-02f, 2.77808029e-02f, -5.67150749e-02f,
  3.78985442e-02f, -1.08044781e-01f, -1.32357359e-01f, -4.23503183e-02f, 4.67621870e-02f, 2.10649166e-02f, -1.31367352e-02f, 7.00484663e-02f, -7.08340779e-02f, -8.98361057e-02f,
  6.37932941e-02f, -1.84503812e-02f, 5.23448810e-02f, 2.00769864e-02f, -1.92102157e-02f, -3.17271682e-03f, 8.74697715e-02f, -9.94952396e-03f, -8.94620176e-03f, -4.06102231e-03f,
  7.31979981e-02f, -2.40642037e-02f, 7.56810680e-02f, -3.63060087e-02f, 5.99136725e-02f, 4.13421920e-04f, -3.39584723e-02f, 8.18747282e-02f, -7.63619179e-03f, -6.84796870e-02f,
  5.85453585e-02f, -2.14036144e-02f, 8.16583931e-02f, 1.18199535e-01f, 1.15622981e-02f, 8.80575329e-02f, -3.22703533e-02f, -4.92335521e-02f, -7.25231841e-02f, -1.09954020e-02f,
  -2.26693675e-01f, 8.46754760e-02f, -8.31866711e-02f, -6.59409836e-02f, -5.86868189e-02f, -5.15817143e-02f, -5.48326932e-02f, 2.82537658e-03f, -1.10770643e-01f, -4.77470830e-03f,
  -8.25691670e-02f, -1.74415410e-02f, -2.56977379e-02f, -5.78222387e-02f, -2.88047157e-02f, -1.18474834e-01f, -6.34406582e-02f, -3.55342515e-02f, -1.84347183e-02f, -4.06903103e-02f,
  9.23912972e-02f, -1.02356359e-01f, -1.64639309e-01f, -9.34995934e-02f, -4.58486825e-02f, -2.02863261e-01f, -1.71357840e-01f, -1.00559048e-01f, -2.08325788e-01f, -1.40465200e-01f,
  1.01515241e-01f, 2.79072285e-01f, -2.63033025e-02f, 9.03203152e-03f, 8.29248503e-02f, 1.44068990e-02f, 2.79583573e-01f, 1.64771989e-01f, -8.78561363e-02f, 8.00672099e-02f,
  1.66509137e-01f, -4.33699861e-02f, -8.09830055e-02f, -1.08636409e-01f, -2.79589929e-03f, 6.11902885e-02f, -1.12575091e-01f, -9.48998779e-02f, -2.10691348e-01f, -8.32517669e-02f,
  -1.42976806e-01f, -3.19594182e-02f, -1.44085363e-01f, -1.18764408e-01f, -5.13784923e-02f, -1.83779553e-01f, 7.54735321e-02f, 2.40706862e-03f, -6.31047189e-02f, -1.29359514e-01f,
  -6.05437867e-02f, 2.58048654e-01f, -1.81971341e-01f, -3.98252159e-02f, -4.35569696e-02f, -8.87944475e-02f, 2.05963776e-02f, 1.79555938e-02f, 1.03138998e-01f, 5.38499542e-02f,
  -8.14039726e-03f, -2.38261502e-02f, -2.30425522e-02f, 1.12139750e-02f, -3.45654115e-02f, 7.18941316e-02f, 3.79974730e-02f, -7.91696906e-02f, -2.26544105e-02f, 3.42072025e-02f,
  2.64474936e-02f, 1.20037325e-01f, 1.03363596e-01f, 1.30134881e-01f, 1.14380300e-01f, 4.52576242e-02f, 3.04025840e-02f, 7.99859315e-02f, -1.26586137e-02f, 3.69782597e-02f,
  -4.59492812e-03f, -5.15547991e-02f, -1.83726642e-02f, 3.16586792e-02f, 3.77180390e-02f, -6.67749941e-02f, 1.03363553e-02f, -7.46857673e-02f, -1.77057534e-02f, 1.75651610e-02f,
  2.88145095e-02f, 5.44509701e-02f, 6.63960055e-02f, 5.19885235e-02f, 2.50086319e-02f, 4.27877605e-02f, 1.18370950e-01f, 1.02023415e-01f, -7.10864216e-02f, 1.94939002e-02f,
  -1.01600908e-01f, -1.71673913e-02f, 2.65752021e-02f, -1.14202797e-02f, 7.62241185e-02f, -3.31527740e-02f, 4.69205976e-02f, 5.92115447e-02f, 1.11850232e-01f, 1.19713664e-01f,
  -1.27966776e-01f, 3.51314247e-02f, -1.76538780e-01f, -1.40431300e-01f, -5.36119752e-03f, -5.31367166e-03f, -4.57895547e-02f, 4.73456644e-02f, 7.14403763e-03f, -5.57039725e-03f,
  2.71130800e-02f, 1.39796548e-02f, 3.80512774e-02f, -4.78069894e-02f, -4.05488424e-02f, -8.62650797e-02f, -1.00289779e-02f, 4.27711792e-02f, 5.66918217e-02f, 8.25017411e-03f,
  1.03076234e-01f, 9.65522826e-02f, -5.64836524e-02f, -3.26878391e-02f, 6.13869168e-02f, -1.90775037e-01f, 3.24210115e-02f, -6.72526434e-02f, -3.75363082e-02f, 3.37508656e-02f,
  2.11563349e-01f, 7.11355805e-02f, -1.12233251e-01f, 1.52985707e-01f, 1.68488160e-01f, 9.58839059e-02f, 1.47433743e-01f, 1.52832538e-01f, -5.04939444e-03f, 9.56056863e-02f,
  1.57280460e-01f, 6.63163513e-02f, 1.30313829e-01f, 6.37097582e-02f, 3.42457928e-02f, 1.27031922e-01f, 8.48048180e-02f, -7.99199492e-02f, -5.79484552e-02f, 2.88584419e-02f,
  1.14314053e-02f, 4.76544574e-02f, 4.80502509e-02f, 4.23347317e-02f, 6.85108304e-02f, 7.66081065e-02f, 7.36217797e-02f, -1.05664365e-01f, -5.24539575e-02f, -3.78349274e-02f,
  -1.63490742e-01f, -1.76560692e-02f, 3.11169028e-02f, 5.03535271e-02f, -6.48309663e-02f, 1.44945914e-02f, 9.84550938e-02f, -2.28989590e-02f, -5.25702350e-02f, -4.80661355e-02f,
  3.56923826e-02f, -2.30009742e-02f, 6.47253841e-02f, -8.88625532e-02f, -7.39238337e-02f, 4.25828733e-02f, 3.89513299e-02f, 9.43769887e-02f, -7.47170597e-02f, 4.66264039e-02f,
  1.98379885e-02f, -9.35405679e-03f, -6.78665470e-03f, -2.69832299e-03f, 1.33818639e-02f, 7.66864605e-03f, -3.64254937e-02f, -1.80737991e-02f, 2.88426317e-02f, -2.75856648e-02f,
  6.45339563e-02f, -1.92874856e-02f, -8.49153548e-02f, 5.52770458e-02f, 5.19237146e-02f, -6.59177229e-02f, 3.17781419e-02f, -7.69245848e-02f, 6.12351403e-04f, 2.72139739e-02f,
  -5.26318466e-03f, 1.85919479e-02f, -7.72194266e-02f, -4.21282053e-02f, -1.05904318e-01f, -8.92571956e-02f, -9.65382084e-02f, 2.99347267e-02f, -9.07404274e-02f, -3.12347636e-02f,
  4.30569164e-02f, -1.92895848e-02f, -3.50014307e-02f, -7.20551535e-02f, 1.03499927e-02f, 7.40777552e-02f, -1.10121720e-01f, 3.90695520e-02f, -4.20886017e-02f, 4.63441499e-02f,
  2.89335754e-02f, -4.76665385e-02f, -2.32612956e-02f, 2.96873450e-02f, -7.13174790e-02f, -3.68167795e-02f, 1.06930370e-02f, -1.12540647e-01f, 5.44065200e-02f, -6.01547845e-02f,
  -5.41253947e-02f, -5.86392619e-02f, -4.87902537e-02f, -9.44413543e-02f, -1.06453687e-01f, -2.29171198e-03f, 1.10437177e-01f, -2.89897714e-03f, -4.29093987e-02f, -1.04458123e-01f,
  5.47188632e-02f, -8.76039192e-02f, -1.74536556e-02f, 5.07811829e-02f, 4.59546074e-02f, -8.78205001e-02f, -1.23747103e-02f, -4.48981998e-03f, -8.18619877e-02f, 9.53156352e-02f,
  -4.20143008e-01f, -1.81491319e-02f, 7.99192488e-02f, -1.42244831e-01f, 1.09129250e-02f, 1.74480602e-01f, 9.18552279e-02f, -6.25732448e-03f, -1.29127473e-01f, 6.23839945e-02f,
  4.17305417e-02f, -5.66834249e-02f, -9.32155252e-02f, 7.77041391e-02f, 1.01631165e-01f, 1.25442967e-01f, 6.37856796e-02f, 2.06120331e-02f, -1.30941406e-01f, -6.14068620e-02f,
  -2.34715249e-02f, -1.53209269e-01f, -2.10505098e-01f, -8.44362229e-02f, 3.25794667e-02f, -8.49996880e-02f, -4.44044806e-02f, -1.22370996e-01f, 1.07169628e-01f, 6.30957633e-02f,
  -7.42975324e-02f, -1.71754301e-01f, 2.97164749e-02f, -1.22750878e-01f, 1.76554322e-02f, -8.33580270e-02f, -2.45081540e-02f, -4.94445115e-02f, -4.25018230e-03f, -2.93645896e-02f,
  4.86119129e-02f, -6.68412447e-02f, -4.74187918e-02f, 1.62328724e-02f, -6.50369078e-02f, -3.42438780e-02f, 9.08146426e-02f, 5.59936762e-02f, 4.99206707e-02f, 6.26775175e-02f,
  1.40093192e-01f, -1.15876056e-01f, -1.22328892e-01f, -1.21717891e-02f, 1.29942015e-01f, -3.02998498e-02f, -1.13408796e-01f, -2.08714735e-02f, 2.41238568e-02f, -1.55968860e-01f,
  4.43474716e-03f, 7.43444730e-03f, 2.22821441e-02f, -7.86824599e-02f, 7.88031984e-03f, 2.91779414e-02f, -4.80281487e-02f, 6.17009923e-02f, -9.01881009e-02f, -5.36275767e-02f,
  8.89345706e-02f, -5.81569299e-02f, -6.19988739e-02f, -8.40740725e-02f, 1.83039717e-02f, -3.23004276e-02f, 7.95546845e-02f, -3.69176045e-02f, 3.97628099e-02f, -3.75949033e-02f,
  -7.69057870e-02f, 5.25515387e-03f, -1.15401328e-01f, -5.37392460e-02f, 5.69013655e-02f, 3.27715464e-02f, -5.45286722e-02f, -4.99193631e-02f, -5.65528609e-02f, -2.33529322e-02f,
  -1.80458218e-01f, 1.75341174e-01f, -5.20353839e-02f, -7.65925944e-02f, -6.54342920e-02f, 1.03296839e-01f, -2.07132827e-02f, -9.01565477e-02f, -1.06345356e-01f, -3.08095594e-03f,
  -5.31938970e-02f, -2.31462456e-02f, -1.02642305e-01f, 1.69560742e-02f, 4.03241627e-02f, -4.21926044e-02f, -4.92254868e-02f, 6.81377649e-02f, 8.40448961e-02f, 3.35061960e-02f,
  7.03190416e-02f, 2.04943940e-02f, -1.05978735e-01f, -5.74337915e-02f, 1.49677172e-02f, 4.13653702e-02f, -2.80526164e-03f, 1.82173308e-02f, 1.20228799e-02f, -1.22217186e-01f,
  6.41454523e-03f, 1.76912919e-01f, 6.32096156e-02f, 6.31852597e-02f, -1.01522163e-01f, 2.14157291e-02f, 1.93973780e-01f, 5.16848639e-02f, -5.65567128e-02f, 7.25620613e-02f,
  -1.80198833e-01f, -2.12694347e-01f, -2.73700934e-02f, -2.37174258e-02f, 9.59068313e-02f, 1.32305041e-01f, 1.81109101e-01f, 1.23739123e-01f, -9.58890021e-02f, -6.85207471e-02f,
  -2.52765659e-02f, 8.56604576e-02f, -7.22840801e-02f, 4.79608588e-02f, 8.02312270e-02f, -8.80442280e-03f, 3.71523350e-02f, 5.40772360e-03f, -1.33023575e-01f, 1.02371082e-01f,
  -9.67713073e-02f, -2.97096241e-02f, -1.22850224e-01f, -1.49963424e-01f, -1.36606365e-01f, 1.07498638e-01f, 3.39694731e-02f, 4.05907109e-02f, 9.80898272e-03f, 5.89431860e-02f,
  -7.26293027e-02f, 2.32490990e-02f, 6.85331970e-02f, 2.44518672e-03f, 6.73392862e-02f, -4.37703431e-02f, 1.98209342e-02f, 3.61314304e-02f, -4.52856347e-02f, 2.97199544e-02f,
  -2.26204400e-03f, -1.25123709e-01f, -1.61532052e-02f, -5.00560552e-02f, -5.98138757e-02f, -4.15692702e-02f, 2.38868669e-02f, 6.19651265e-02f, 3.26974578e-02f, 9.50641334e-02f,
  3.34347412e-02f, -5.73246963e-02f, -2.13633906e-02f, 2.96643060e-02f, 3.54800448e-02f, 1.47370053e-02f, -3.32506709e-02f, 4.42873724e-02f, -4.52645272e-02f, 9.03218612e-02f,
  -5.73660433e-03f, 1.04054622e-03f, 5.36018088e-02f, 4.57910821e-02f, -2.07809210e-02f, 4.47146446e-02f, -3.53753120e-02f, 2.32269149e-02f, 8.07372406e-02f, 4.44594659e-02f,
  3.65973599e-02f, -7.05242380e-02f, 3.60706449e-02f, 1.91545784e-02f, 5.20372689e-02f, -2.99501866e-02f, -4.54067849e-02f, -5.69372298e-03f, -1.87765285e-02f, 5.08928820e-02f,
  -9.89320129e-02f, -1.31613955e-01f, -2.02799123e-02f, 1.13087460e-01f, 5.26712276e-04f, -3.46434116e-02f, -1.10959020e-02f, -1.20378092e-01f, -5.80516495e-02f, 5.89844175e-02f,
  -9.64417383e-02f, 2.54626516e-02f, -1.05153434e-01f, 6.29081428e-02f, -7.59284347e-02f, -3.01641878e-02f, -4.95879389e-02f, 2.12335009e-02f, 4.82048001e-03f, 9.02351178e-03f,
  -6.07212298e-02f, -1.80932730e-02f, -8.79997239e-02f, -4.36962731e-02f, -8.17496888e-03f, -1.39650568e-01f, -1.21121198e-01f, -1.28799468e-01f, -3.10170874e-02f, 2.94438377e-02f,
  -5.51446855e-01f, -1.95027351e-01f, -1.59872025e-01f, -9.65303034e-02f, 2.24986181e-01f, 2.31182784e-01f, -8.66737068e-02f, 1.26466267e-02f, 2.09502839e-02f, 2.05023363e-02f,
  1.75968692e-01f, 9.06509683e-02f, -5.99551462e-02f, 1.14816643e-01f, -9.56808627e-02f, -1.73418000e-01f, -1.34853438e-01f, -2.38178164e-01f, 6.18480984e-03f, 2.37634882e-01f,
  1.81997180e-01f, -1.28646851e-01f, -1.47762924e-01f, -1.15946397e-01f, -8.83599222e-02f, 1.97013598e-02f, -1.13855027e-01f, 8.99370294e-03f, 5.57187982e-02f, -2.70456318e-02f,
  -1.14421379e-02f, 2.72562727e-02f, 1.88691467e-02f, 7.19385296e-02f, 9.13759097e-02f, -9.05449614e-02f, 5.99784311e-03f, -1.15034021e-01f, 2.76152492e-02f, -4.38832827e-02f,
  4.72272336e-02f, 3.80848981e-02f, 1.17941916e-01f, 2.66182981e-02f, -5.17341634e-03f, -2.30838954e-02f, -8.52007791e-02f, -1.78190976e-01f, -1.75038740e-01f, 1.16357487e-03f,
  1.94251478e-01f, 7.66126588e-02f, -1.04828134e-01f, -3.77307907e-02f, -1.27610266e-01f, -1.22749761e-01f, -1.51362076e-01f, -1.76059768e-01f, -2.48512834e-01f, -4.53612834e-01f,
  8.96767229e-02f, -3.49796116e-02f, 4.87998240e-02f, -7.73234144e-02f, 1.14470036e-04f, 4.22573090e-02f, 6.76334575e-02f, 4.75062244e-02f, 8.85634124e-03f, -8.39693621e-02f,
  9.66740027e-03f, 5.72527945e-02f, 2.25050729e-02f, -9.16049629e-02f, -5.06956838e-02f, 5.70860840e-02f, 1.25834327e-02f, -1.59029678e-01f, -1.07673625e-03f, -4.22205068e-02f,
  -1.93663053e-02f, -1.16595805e-01f, -1.33022759e-02f, 5.15759643e-03f, 3.93032841e-02f, 3.99681926e-02f, -5.05884066e-02f, 1.00596352e-02f, -7.26762041e-02f, 4.78037186e-02f,
  -2.59310931e-01f, 1.53269723e-01f, -1.66419551e-01f, -9.73347723e-02f, 9.50752795e-02f, -3.96122783e-02f, 4.19528484e-02f, 4.31823581e-02f, -2.73588300e-03f, -2.57062986e-02f,
  5.45748090e-03f, -1.06416330e-01f, -5.03428988e-02f, 1.06378142e-02f, -1.13898404e-01f, -1.10902190e-01f, -6.07740730e-02f, -1.03846088e-01f, -4.94201072e-02f, -3.90031226e-02f,
  -1.81492373e-01f, -2.16609001e-01f, -3.94671142e-01f, -3.20545763e-01f, -1.12550817e-01f, -1.47591561e-01f, -3.74785185e-01f, -3.10486585e-01f, -4.20242071e-01f, -6.70699835e-01f,
  7.42901117e-02f, 2.46111020e-01f, 3.13854776e-02f, 1.82874858e-01f, 1.16315171e-01f, -9.28022433e-03f, 7.13226646e-02f, 6.13975599e-02f, -4.73194681e-02f, 3.55763622e-02f,
  1.19090546e-02f, 9.23005342e-02f, -2.86826715e-02f, 8.59340206e-02f, 9.23351422e-02f, 1.07432686e-01f, 1.91450015e-01f, 3.53938341e-02f, -1.32797165e-02f, 1.19803241e-02f,
  1.65940046e-01f, 1.41782165e-01f, 7.19087869e-02f, 6.11182116e-02f, 1.48938566e-01f, 1.01998188e-01f, 7.54795894e-02f, 7.92434141e-02f, 8.78681690e-02f, 3.24095577e-01f,
  -4.83919895e-04f, 1.38061538e-01f, -1.57852784e-01f, 1.09119564e-02f, -7.79207051e-02f, -7.13145658e-02f, -7.08743781e-02f, -6.90335706e-02f, 1.26317833e-02f, -2.53099594e-02f,
  -8.21365267e-02f, 5.78727946e-03f, -3.08013689e-02f, 5.37385978e-03f, -3.55888493e-02f, -1.75101161e-02f, 4.60293330e-02f, 6.04253151e-02f, -8.81108046e-02f, 4.02371474e-02f,
  6.07723184e-02f, -2.83113997e-02f, -2.77479943e-02f, -9.00144875e-02f, 6.22691168e-03f, -1.49195744e-02f, -8.28912109e-02f, 5.37091903e-02f, -1.53036103e-01f, 8.02132562e-02f,
  3.53306495e-02f, 7.58933425e-02f, -1.90115143e-02f, -1.37964950e-03f, -4.39104065e-03f, 5.32254837e-02f, -4.12399434e-02f, 9.34524927e-03f, 8.63351524e-02f, 4.58614044e-02f,
  -3.69132347e-02f, -9.15292650e-02f, 1.02828015e-02f, 5.19451909e-02f, 3.79210263e-02f, -5.58240488e-02f, 1.75282974e-02f, 6.09590225e-02f, 2.83389930e-02f, -9.15820301e-02f,
  -1.49315596e-02f, -3.74624990e-02f, 9.72366706e-03f, 2.08338071e-03f, -6.02894127e-02f, 4.21362631e-02f, 6.58975616e-02f, -3.38703096e-02f, -2.29544621e-02f, -8.35731104e-02f,
  -1.56119958e-01f, -3.10207218e-01f, 7.29934126e-03f, -6.86267838e-02f, 3.23025230e-03f, -2.78315246e-02f, -8.23190585e-02f, -4.22223918e-02f, -1.20292418e-01f, -3.47212292e-02f,
  -5.12083545e-02f, 8.45529232e-03f, 4.91078664e-03f, -1.23832248e-01f, -7.10089803e-02f, -5.09955473e-02f, -8.33800361e-02f, 1.78744346e-02f, -8.87364671e-02f, -8.89887214e-02f,
  -7.67459860e-03f, -1.07896596e-01f, -2.84901798e-01f, -1.98933259e-01f, -5.81351109e-02f, -1.70634434e-01f, -2.14411095e-01f, -9.93880257e-02f, -2.26137713e-01f, -2.35070884e-01f,
  1.04371384e-02f, -1.63331963e-02f, -5.23052290e-02f, 1.99939072e-01f, 1.81436107e-01f, 3.71852033e-02f, 8.66759568e-02f, 1.36528388e-01f, 2.00961575e-01f, 5.98258935e-02f,
  -1.35188755e-02f, 1.62604511e-01f, 1.52802840e-01f, 8.65429267e-02f, 1.16523474e-01f, 7.24409297e-02f, 1.63636118e-01f, 6.32269681e-02f, -1.96632985e-02f, 1.31916896e-01f,
  -1.09735306e-03f, -1.31864045e-02f, -1.52026415e-02f, 4.80359234e-02f, 1.25023112e-01f, 1.55751511e-01f, -4.68591787e-02f, 5.53128384e-02f, -2.19372641e-02f, 8.79267752e-02f,
  -1.34463534e-01f, -4.81303371e-02f, 1.05437711e-01f, 1.18174717e-01f, -1.09172724e-01f, 5.03447652e-02f, -6.29401132e-02f, 2.51714252e-02f, 2.45751347e-03f, 6.27364740e-02f,
  4.42877598e-02f, -1.13298200e-01f, -5.90124540e-02f, 1.16842259e-02f, -1.12935483e-01f, -1.38761727e-02f, 2.30318271e-02f, -9.71916988e-02f, 6.72878623e-02f, 5.12865372e-02f,
  6.06236840e-03f, -5.70009276e-03f, -1.16905950e-01f, 6.59759715e-03f, -3.33335437e-02f, 7.71264061e-02f, -8.93781856e-02f, 4.28459421e-02f, -4.19608355e-02f, 1.67456884e-02f,
  6.59113377e-02f, -1.87801104e-02f, -1.57321133e-02f, -1.02228951e-02f, 5.07721640e-02f, -5.05635105e-02f, 4.95831035e-02f, 1.37303863e-02f, 6.34863004e-02f, 9.52248741e-03f,
  -2.31471583e-02f, 6.06985986e-02f, 1.72008742e-02f, 7.98903704e-02f, -3.88674438e-02f, -5.07421717e-02f, 8.56871158e-02f, -5.34051135e-02f, -5.65452538e-02f, -9.60542038e-02f,
  -5.42572839e-03f, -1.37133794e-02f, 8.19918886e-02f, -8.70051309e-02f, 5.94396368e-02f, 1.16272971e-01f, 9.22411308e-02f, 8.76274854e-02f, -1.32699963e-02f, 1.43214166e-02f,
  -5.48135266e-02f, 6.90947426e-03f, 1.36119574e-01f, 5.35001718e-02f, -6.96475792e-04f, -2.98632178e-02f, 3.17180268e-02f, -7.82731399e-02f, 3.84386443e-02f, -1.20096153e-03f,
  -7.14495480e-02f, -1.32765517e-01f, 3.53301615e-02f, 2.58708075e-02f, -8.68929774e-02f, 6.87454268e-03f, -2.78181825e-02f, 1.59393400e-02f, -2.67497450e-02f, 2.17065196e-02f,
  -8.64842609e-02f, -6.47089034e-02f, 7.80910626e-02f, -1.90239376e-03f, 3.13048363e-02f, 4.90597263e-02f, -7.96561539e-02f, -5.70839420e-02f, -1.90911777e-02f, -8.16107821e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.26191050e-01f, 5.29025495e-02f, 2.08639935e-01f, 6.91396594e-02f, 2.58323640e-01f, 3.64958644e-01f, 2.21150786e-01f, -4.17317189e-02f, 1.67194143e-01f, -8.18694383e-02f,
  3.22692662e-01f, -2.49762852e-02f, 1.48445517e-01f, 1.73592493e-01f, -6.70985924e-03f, 2.88306475e-01f, 2.05377623e-01f, 7.06171170e-02f, 2.24430963e-01f, 1.50561288e-01f,
  1.34426698e-01f, 9.09565911e-02f, 2.87716575e-02f, 3.29741448e-01f, 2.29363620e-01f, 1.88701063e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.15001121e-01f, 2.90399820e-01f, 3.07132244e-01f, -5.33102632e-01f, 6.48988366e-01f, 2.17758417e-01f, 2.14726925e-01f, 1.90455765e-01f, 2.87709326e-01f, -2.71816663e-02f,
  1.37315124e-01f, -2.49094382e-01f, 1.70268547e-02f, 1.57288779e-02f, -3.46408129e-01f, -3.07109524e-02f, -3.01580220e-01f, -6.93684816e-02f, 2.76188999e-01f, 2.29645848e-01f,
  2.77216733e-01f, 1.85109720e-01f, -1.23155363e-01f, -1.43608719e-01f, 3.36670801e-02f, -2.57811904e-01f, -2.35749334e-01f, -1.60099804e-01f, -9.99501944e-02f, -4.32673573e-01f,
  1.34694934e-01f, -1.71221510e-01f, -7.37790093e-02f, -5.72048090e-02f, -6.71384260e-02f, 4.04031068e-01f, -4.27358039e-02f, 2.78629363e-01f, -6.52318597e-02f, -2.21488237e-01f,
  1.02406725e-01f, 1.08583450e-01f, -2.73678422e-01f, 1.43574312e-01f, -5.39397523e-02f, 2.63290882e-01f, -2.14776563e-04f, -1.42491609e-01f, 1.39777496e-01f, -2.87766427e-01f,
  -2.54860163e-01f, -2.90221609e-02f, -1.83118656e-01f, -1.62674353e-01f, -4.40659374e-02f, 1.97603866e-01f, 3.75326544e-01f, -1.83403909e-01f, 8.88865888e-02f, 3.02128851e-01f,
  8.90469998e-02f, -2.10107103e-01f, -5.23717217e-02f, 2.61974595e-02f, 2.25582600e-01f, -1.90361768e-01f, 6.21699244e-02f, 6.77067861e-02f, -7.01048732e-01f, -1.96781680e-01f,
  9.29536372e-02f, -2.27636591e-01f, 9.76872444e-02f, -1.36271626e-01f, 4.65824865e-02f, 1.99929364e-02f, 1.55418441e-01f, 5.82030267e-02f, 2.40337327e-01f, -2.84195356e-02f,
  1.49325967e-01f, -2.10317627e-01f, -1.99163660e-01f, -2.36164089e-02f, -2.66761959e-01f, 9.29960329e-03f, 3.59919965e-01f, -8.19346905e-02f, -6.25308305e-02f, -2.12339349e-02f,
  -5.35880215e-02f, -2.19223425e-01f, -5.85538372e-02f, -1.87237799e-01f, 4.12709117e-02f, 8.97216722e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.02712163e-02f, 1.02659920e-02f, 3.46427321e-01f, -2.42453575e-01f, -9.68094021e-02f, 1.91038512e-02f, 1.78066522e-01f, -3.13610844e-02f, 4.66354162e-01f, -7.47080147e-02f,
  -1.01798810e-01f, -2.72231102e-02f, 3.25568914e-01f, -1.65076271e-01f, 4.45728190e-02f, -2.13792315e-03f, 2.75841445e-01f, 1.62379369e-01f, -1.00852109e-01f, 3.34265023e-01f,
  2.82988325e-02f, -5.61397150e-02f, 2.89338738e-01f, -8.29166323e-02f, -1.04855433e-01f, -2.88976163e-01f, 1.57858040e-02f, -1.59943670e-01f, -1.09772757e-01f, -1.32720862e-02f,
  -2.40839906e-02f, 1.86069738e-02f, 5.38233876e-01f, -1.26365542e-01f, 1.82008460e-01f, 1.28328234e-01f, -6.19509339e-01f, -3.43763500e-01f, -1.79799199e-02f, -5.81250992e-04f,
  1.38410345e-01f, -8.68293864e-05f, -7.04921558e-02f, 2.20435113e-02f, -6.51860982e-02f, -1.68936308e-02f, 3.04594517e-01f, -5.70783466e-02f, 1.27365604e-01f, -2.21548975e-01f,
  -1.65994659e-01f, -8.91596973e-02f, 3.63695733e-02f, 1.47105783e-01f, 5.59866846e-01f, 7.95037150e-02f, -1.41103059e-01f, -7.55885988e-02f, -6.55650347e-02f, -6.90179318e-02f,
  -4.31606099e-02f, 6.24327183e-01f, 1.98133737e-01f, 1.84494704e-01f, 4.75551449e-02f, 1.55086368e-01f, 3.21948379e-01f, -1.01856045e-01f, 2.64836311e-01f, 3.27504009e-01f,
  -2.46196479e-01f, 1.95863366e-01f, -1.50437415e-01f, 4.80346009e-03f, 3.28015715e-01f, 5.18131256e-03f, -2.17297435e-01f, -6.79881796e-02f, -2.09655032e-01f, -3.96866649e-02f,
  1.20296732e-01f, -2.68478990e-01f, 2.45469943e-01f, -1.63288429e-01f, -1.46617413e-01f, 4.36254889e-01f, -1.69447973e-01f, 1.71387687e-01f, 1.70703501e-01f, -1.11944355e-01f,
  1.27707511e-01f, -6.36931583e-02f, 3.39997232e-01f, 1.69837981e-01f, 5.28177857e-01f, -2.44184397e-02f, 3.98286372e-01f, 2.62852132e-01f, 2.56666780e-01f, 2.76549578e-01f,
  -1.49091884e-01f, 4.63427380e-02f, 3.19070339e-01f, -1.88689142e-01f, -2.12526135e-02f, -1.99076444e-01f, 1.72218168e-03f, 5.47382057e-01f, 5.02610862e-01f, -1.44840077e-01f,
  4.37777564e-02f, -1.56881511e-01f, -1.89850584e-01f, 7.16494471e-02f, 6.05095290e-02f, 5.57854995e-02f, -2.12746203e-01f, 6.70873597e-02f, 1.30025610e-01f, 3.48501652e-02f,
  -1.79968655e-01f, -4.75616492e-02f, 2.70343304e-01f, 4.47036624e-02f, -1.72634587e-01f, -2.17223287e-01f, -5.78726418e-02f, 2.63141960e-01f, 2.18905509e-01f, 4.01070118e-02f,
  -3.02917138e-02f, 3.16705974e-03f, -1.41698465e-01f, -7.49300942e-02f, 1.77365050e-01f, 1.56329140e-01f, -1.37374461e-01f, 8.41495320e-02f, -3.37603427e-02f, 1.44262046e-01f,
  1.11894250e-01f, -7.45151117e-02f, -7.22626075e-02f, 6.33326098e-02f, -1.47102118e-01f, -5.05667999e-02f, 2.14840502e-01f, 1.13687262e-01f, -2.46647559e-02f, -5.47242090e-02f,
  9.16214213e-02f, -1.74726755e-03f, -4.81698625e-02f, -4.07106951e-02f, -1.49543607e-03f, -2.22442806e-01f, 4.93970253e-02f, -1.99617431e-01f, -5.35013713e-02f, 4.23494689e-02f,
  3.51676494e-01f, 5.77152014e-01f, -1.71751045e-02f, -4.55363244e-01f, 3.41548063e-02f, -2.53790051e-01f, 2.80762818e-02f, -1.20046824e-01f, -2.60004867e-02f, 1.41149297e-01f,
  -2.14760806e-02f, -2.75856942e-01f, 2.82401800e-01f, 1.26417607e-01f, 8.71297121e-01f, -1.03308603e-01f, 5.92470050e-01f, -2.90489733e-01f, -2.95548409e-01f, -1.62515510e-02f,
  7.13381469e-02f, 2.64019333e-02f, -2.19103321e-01f, 3.75278182e-02f, 3.17273796e-01f, -4.44590263e-02f, -1.25468731e-01f, 2.68781066e-01f, -3.35141659e-01f, 9.29393351e-01f,
  1.70550153e-01f, 9.06216130e-02f, -1.09042995e-01f, -1.43692791e-01f, -1.03793584e-01f, 5.31123430e-02f, -1.23798989e-01f, 1.31422535e-01f, 1.48764163e-01f, -1.05255038e-01f,
  4.80497405e-02f, 6.12494722e-02f, 1.08996987e-01f, -1.80681661e-01f, 8.82378072e-02f, -1.52061701e-01f, -7.85009116e-02f, -4.70540412e-02f, 2.10739002e-01f, -1.97887309e-02f,
  -1.51806787e-01f, 1.07950903e-01f, 4.82783243e-02f, -1.39194772e-01f, 4.42367867e-02f, 6.18904494e-02f, 1.48522988e-01f, -5.94833959e-03f, -1.57950610e-01f, -1.10291325e-01f,
  1.56265438e-01f, -1.31688207e-01f, 4.97919992e-02f, -1.15345687e-01f, -1.29504874e-02f, 1.51088849e-01f, 5.44598810e-02f, 2.19925582e-01f, -2.77662724e-01f, -3.23090494e-01f,
  -6.93383515e-02f, 8.90355036e-02f, 5.45541160e-02f, -1.50009051e-01f, 2.34911870e-03f, -1.50948778e-01f, -1.37547851e-01f, -4.28832695e-03f, -9.55784619e-02f, 1.53438926e-01f,
  1.63152099e-01f, -1.14073247e-01f, -2.02683851e-01f, 6.79860637e-02f, 1.02080055e-01f, 9.62328836e-02f, 1.76301003e-01f, -1.40259385e-01f, -1.56129241e-01f, 1.73254833e-01f,
  8.39163437e-02f, 1.90748423e-01f, -1.20768704e-01f, 3.73832136e-01f, -1.48501908e-02f, 6.63014054e-02f, -1.30488023e-01f, 1.18974596e-01f, 9.31877270e-02f, 7.62424469e-02f,
  7.09644854e-02f, -1.00598857e-02f, 4.14746590e-02f, 1.18057765e-01f, 1.06839225e-01f, -1.80465996e-01f, -1.96983844e-01f, 5.57397753e-02f, -1.25716422e-02f, 1.58028156e-01f,
  1.75461292e-01f, 1.51875526e-01f, 7.70225450e-02f, -1.59978405e-01f, -1.25951156e-01f, 2.68826215e-03f, -2.22138278e-02f, -1.27757847e-01f, 2.27238357e-01f, -1.13320470e-01f,
  7.32518313e-03f, -1.06706716e-01f, 6.31774440e-02f, -1.14828728e-01f, 1.51565954e-01f, -1.21812455e-01f, -8.23165551e-02f, -1.12044655e-01f, 8.12699944e-02f, 2.41119221e-01f,
  2.78630573e-02f, 2.15952054e-01f, -6.47668913e-02f, 1.39232621e-01f, -2.01918200e-01f, 1.38234552e-02f, -4.51276116e-02f, 2.24924281e-01f, -1.63571417e-01f, 4.37457472e-01f,
  1.37061149e-01f, -1.63978919e-01f, 8.51619691e-02f, -9.24285874e-02f, -1.85777619e-01f, -1.50209025e-01f, 2.71666318e-01f, 1.51119437e-02f, -1.30322069e-01f, -1.78894941e-02f,
  1.63608760e-01f, 7.07624257e-02f, 2.18223214e-01f, -8.40275213e-02f, 2.56528258e-01f, 1.69937924e-01f, 1.24442689e-01f, 3.80090207e-01f, 1.32213011e-01f, 2.82331526e-01f,
  -1.44248113e-01f, 1.40981033e-01f, -1.62866294e-01f, -1.79293901e-02f, 4.76037674e-02f, 8.87032896e-02f, 9.68970209e-02f, -1.36692435e-01f, 6.06142469e-02f, -6.43510073e-02f,
  -1.11460779e-03f, -5.26643805e-02f, -8.33510533e-02f, 3.86600159e-02f, -1.43704265e-01f, -9.03187618e-02f, -1.77144051e-01f, -1.57503039e-01f, -1.23650908e-01f, 5.91540299e-02f,
  1.25418589e-01f, 9.82944220e-02f, -4.57084849e-02f, -3.23736668e-02f, -5.93464822e-02f, -1.56653211e-01f, -5.00419475e-02f, 2.00287476e-01f, 1.28186509e-01f, -5.59177250e-02f,
  7.99310654e-02f, 6.76015466e-02f, -2.59747338e-02f, -4.61993320e-03f, 1.04623102e-02f, -1.00630395e-01f, -1.59805223e-01f, 6.10680059e-02f, 1.37532026e-01f, 2.70318836e-01f,
  -1.28515288e-01f, 1.54190689e-01f, 4.29359311e-03f, 1.46076411e-01f, 9.88279004e-03f, 1.27692670e-01f, -1.39556795e-01f, 1.49776321e-02f, -1.68879312e-02f, 2.36743391e-01f,
  2.79070199e-01f, -6.13294728e-02f, 5.43831615e-03f, 1.22372285e-01f, 1.92392364e-01f, 1.48459002e-01f, -9.83199775e-02f, 1.08700685e-01f, -2.23943926e-02f, -1.80509314e-01f,
  1.66229844e-01f, 8.54560267e-03f, 9.88870338e-02f, -4.46687117e-02f, 3.65368634e-01f, -3.07166260e-02f, 1.29529387e-01f, -4.75863397e-01f, -1.56970754e-01f, -2.16297403e-01f,
  2.87281275e-01f, 2.13861719e-01f, -1.10344492e-01f, 6.30178722e-03f, 5.86573839e-01f, 9.37457904e-02f, -5.72604081e-03f, -2.21913397e-01f, -7.36176744e-02f, -2.81703025e-01f,
  -1.05977915e-01f, 2.94746101e-01f, 3.54339212e-01f, -1.74629048e-01f, 4.07542378e-01f, 4.18037146e-01f, 4.06375587e-01f, -2.09424108e-01f, -2.42812157e-01f, 4.43647802e-01f,
  3.00569296e-01f, -7.92211592e-02f, -5.46723530e-02f, 4.27851617e-01f, 3.44269902e-01f, -3.68958227e-02f, -1.79883927e-01f, 2.13531889e-02f, 4.72523421e-02f, 5.79520725e-02f,
  -2.75939819e-03f, -1.78049758e-01f, -1.48603648e-01f, 6.95031509e-02f, 1.04651280e-01f, -1.07691795e-01f, 4.92397435e-02f, -1.24411143e-01f, -1.06502496e-01f, -7.36971796e-02f,
  -5.86144850e-02f, 6.27925545e-02f, -1.05860025e-01f, 2.11810190e-02f, -8.64477083e-03f, -8.43699090e-05f, -1.14733307e-02f, -2.10082501e-01f, -1.45422652e-01f, -1.30687296e-01f,
  -1.03328161e-01f, 1.30535632e-01f, -2.82745417e-02f, -1.37366712e-01f, -1.09610289e-01f, -2.23162584e-02f, 1.33619025e-01f, 2.62922365e-02f, -2.61570811e-01f, 1.39718726e-02f,
  7.13751838e-02f, 7.32858479e-02f, -6.38814569e-02f, -2.04525054e-01f, 5.23101054e-02f, 1.25188068e-01f, 4.01848525e-01f, 8.24887231e-02f, -5.41688316e-02f, -1.09487966e-01f,
  -3.59996974e-01f, -9.87079442e-02f, -2.48924047e-01f, -8.25180952e-03f, 3.34068954e-01f, -1.94562808e-01f, -1.70496374e-01f, 2.96249747e-01f, -1.51213348e-01f, 1.46179765e-01f,
  3.10155064e-01f, 3.13941762e-02f, -1.22691229e-01f, -2.09100023e-01f, -2.13381704e-02f, 5.27021987e-03f, -4.62957770e-02f, -2.11282005e-03f, -8.12276080e-02f, 5.57863489e-02f,
  -2.09141493e-01f, 2.79067099e-01f, 2.67125338e-01f, 2.87276417e-01f, 4.30867225e-01f, 3.14925909e-01f, 7.42366314e-02f, -1.31282091e-01f, 2.31398821e-01f, 1.92273632e-01f,
  7.48253539e-02f, 1.60484105e-01f, 2.37664968e-01f, 1.27769798e-01f, -1.93280131e-01f, 1.79772839e-01f, -9.18804407e-02f, -1.16362885e-01f, -2.09754668e-02f, 9.40252990e-02f,
  -1.85756996e-01f, 2.51756478e-02f, -1.70730516e-01f, 2.17131764e-01f, 4.79940951e-01f, -1.76504567e-01f, -1.65176108e-01f, 1.38054028e-01f, 1.33535385e-01f, 1.22626707e-01f,
  2.16537863e-01f, 1.84202358e-01f, 3.84468943e-01f, 3.76060069e-01f, 4.14374024e-01f, -5.97182572e-01f, -2.71709174e-01f, -5.76022603e-02f, 4.17128772e-01f, -1.46324366e-01f,
  2.16680586e-01f, -2.14601338e-01f, 1.02172896e-01f, 3.00351512e-02f, 3.97743791e-01f, -2.59003133e-01f, 4.70735312e-01f, -2.43178308e-01f, 3.36434007e-01f, -3.89442928e-02f,
  2.48546824e-01f, 1.06248580e-01f, -1.31159559e-01f, 1.05419435e-01f, -1.76427010e-02f, -7.90502355e-02f, -6.52504042e-02f, -2.49479115e-01f, 2.25531191e-01f, -2.81128883e-01f,
  -1.95472598e-01f, 3.15231383e-02f, 1.90878399e-02f, 2.06112847e-01f, 9.72324610e-02f, 1.13141425e-01f, -9.44850743e-02f, 6.98181316e-02f, 2.71998882e-01f, 1.83926418e-01f,
  -4.79765758e-02f, -5.72862383e-03f, -1.22751795e-01f, 2.32632741e-01f, -9.95931774e-02f, 2.14021072e-01f, 1.03001125e-01f, 1.45332187e-01f, -2.54024528e-02f, -1.58915058e-01f,
  2.06536688e-02f, 3.71915065e-02f, 1.13753729e-01f, 1.63827777e-01f, 2.79480256e-02f, -1.18493348e-01f, 7.55787790e-02f, -4.36887369e-02f, 2.21943766e-01f, 1.54308751e-01f,
  2.59374883e-02f, -1.16209302e-03f, 1.00084931e-01f, 3.57291847e-02f, 1.97265029e-01f, 1.00476906e-01f, -4.28147838e-02f, 2.60056973e-01f, 7.53700063e-02f, 1.63750932e-01f,
  1.76090539e-01f, -5.71994446e-02f, 1.88570982e-03f, -2.03041583e-01f, 3.06266785e-01f, -1.14457332e-01f, -1.02099599e-02f, 2.09726006e-01f, -2.50022504e-02f, -8.28577504e-02f,
  -2.62328088e-02f, -9.96596366e-03f, 6.64744005e-02f, 1.86256334e-01f, -6.46776855e-02f, 1.11386232e-01f, 1.05213309e-02f, -8.69547874e-02f, 5.45195788e-02f, -6.81964159e-02f,
  -5.58607839e-02f, 6.92527890e-02f, -8.83463956e-03f, -1.42610133e-01f, 7.12131411e-02f, -1.76464021e-01f, -6.85280338e-02f, -1.40172452e-01f, -1.75026968e-01f, 6.44400418e-02f,
  6.29903153e-02f, -3.17844823e-02f, 2.67503690e-02f, 1.17294192e-02f, -7.64549449e-02f, -4.87330519e-02f, -1.13984071e-01f, 3.13715488e-02f, -1.74265817e-01f, 8.04074258e-02f,
  7.34846517e-02f, 1.16351238e-02f, -1.08123533e-01f, -8.51282254e-02f, -6.88850656e-02f, 1.23345941e-01f, 9.57835093e-02f, -6.90778196e-02f, -1.32947639e-01f, 3.24725062e-02f,
  -6.94121569e-02f, -1.01718761e-01f, 8.73550251e-02f, 7.69806504e-02f, 1.59494609e-01f, 1.89956531e-01f, -1.38570592e-01f, 8.39414373e-02f, 7.60006681e-02f, -1.30126685e-01f,
  2.83129849e-02f, 2.28256844e-02f, 7.04122633e-02f, 1.19876012e-01f, 2.24037141e-01f, 2.41780624e-01f, 1.60011023e-01f, -1.98340695e-02f, 1.78515509e-01f, 2.23694623e-01f,
  1.45987272e-01f, 2.04310030e-01f, -8.68696049e-02f, 2.01116383e-01f, -1.48343667e-01f, -7.63517842e-02f, 3.78271863e-02f, -1.77524701e-01f, 1.61600277e-01f, 2.12150186e-01f,
  -1.24592423e-01f, 1.87065482e-01f, 1.80096701e-01f, 1.60943434e-01f, 1.46217644e-01f, 4.84791808e-02f, -7.47315527e-04f, 2.71707833e-01f, 7.68420771e-02f, 2.38857940e-01f,
  2.27026850e-01f, 4.88368347e-02f, -5.05099772e-03f, 1.70205042e-01f, -4.38712649e-02f, 2.29951888e-02f, 5.29805981e-02f, 1.05570741e-01f, 3.20756614e-01f, 7.18894824e-02f,
  -1.11565553e-01f, -1.67957619e-02f, -6.44805506e-02f, 3.63563299e-01f, -1.09508283e-01f, -1.26473203e-01f, -7.81072527e-02f, 9.64539032e-03f, 1.29195377e-01f, 2.90523678e-01f,
  3.82687330e-01f, -8.49466249e-02f, 1.06042445e-01f, -1.12588137e-01f, 1.43484399e-01f, -1.01274878e-01f, -2.75196522e-01f, 2.02992558e-01f, 8.23306441e-02f, 1.52794316e-01f,
  -1.74243540e-01f, 2.46275455e-01f, 1.57742336e-01f, 1.40414998e-01f, -7.46448189e-02f, 1.47505075e-01f, 1.03302427e-01f, 3.44098777e-01f, 2.12011874e-01f, 1.58867344e-01f,
  -4.94600795e-02f, -2.40678653e-01f, -6.70429766e-02f, 2.79586375e-01f, -1.04291409e-01f, -2.29840446e-02f, 9.38339457e-02f, -6.01856329e-04f, 1.36335954e-01f, -1.81294098e-01f,
  9.70970616e-02f, -9.76467505e-02f, 2.41926815e-02f, -1.95377305e-01f, 5.69330677e-02f, -8.90359133e-02f, 6.30515441e-02f, 3.08889057e-02f, 2.82807410e-01f, 2.64587291e-02f,
  8.95223469e-02f, 7.12022781e-02f, -6.76350221e-02f, 4.91301298e-01f, -4.39764597e-02f, 5.96736223e-02f, -5.13943806e-02f, 1.76419728e-02f, 3.26299131e-01f, 2.30889440e-01f,
  -1.85682610e-01f, -2.82409251e-01f, 3.00337579e-02f, -3.30573283e-02f, 4.70175207e-01f, 8.11291933e-02f, -1.79716215e-01f, -9.43291560e-02f, -6.97188005e-02f, -4.94353957e-02f,
  -2.98381388e-01f, -2.46617142e-02f, 1.73106492e-01f, -3.99574079e-02f, -1.77283376e-01f, 2.50152081e-01f, 6.22847155e-02f, -1.21395513e-02f, 2.59634197e-01f, 4.24063653e-02f,
  -1.32594019e-01f, -7.19140917e-02f, -1.81986153e-01f, 1.46128505e-01f, -1.01503722e-01f, -5.19161262e-02f, -7.37910941e-02f, -5.83423004e-02f, -4.52773981e-02f, 3.75806630e-01f,
  2.46757835e-01f, -2.17300072e-01f, 2.96873719e-01f, 3.32619876e-01f, 2.17407852e-01f, -1.06856480e-01f, -5.62821478e-02f, -1.29111156e-01f, 2.01399565e-01f, 1.86857507e-01f,
  2.71793008e-01f, -9.19461250e-02f, 9.33164135e-02f, -6.85292408e-02f, 2.62285788e-02f, 3.16644530e-03f, -7.20072687e-02f, 1.01189502e-01f, 1.93188374e-03f, 1.06777012e-01f,
  -4.10428755e-02f, -3.04663684e-02f, 1.84704289e-01f, -2.34442532e-01f, 3.07427440e-03f, 1.62260249e-01f, 1.23368718e-01f, 2.10595177e-03f, 4.10233378e-01f, 2.38800570e-01f,
  2.31330749e-02f, 2.67437607e-01f, 1.92278638e-01f, -5.15918136e-01f, -1.36035398e-01f, 1.68050289e-01f, 5.64544415e-03f, 2.62695551e-01f, 2.16778681e-01f, -1.16936862e-01f,
  3.93362552e-01f, -2.83784866e-01f, -3.64327175e-03f, -1.83608666e-01f, 3.80708069e-01f, 3.53657752e-01f, 2.64558613e-01f, -1.49256825e-01f, -1.19458526e-01f, -1.77342877e-01f,
  -7.60798678e-02f, 3.38874161e-01f, 1.74215183e-01f, 1.32611364e-01f, 2.91857213e-01f, -3.51447076e-01f, -1.19659215e-01f, -1.90159678e-01f, -1.71141088e-01f, 1.62953973e-01f,
  1.93529412e-01f, 1.09031506e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.24402630e-01f, 4.31321800e-01f, 2.13809431e-01f, 2.61970669e-01f, -1.71514750e-02f, 2.50212461e-01f, -1.10372171e-01f, -7.07922922e-03f, -3.77088524e-02f, 2.59534091e-01f,
  -1.61056787e-01f, 1.92419402e-02f, 2.62794405e-01f, -1.63676575e-01f, 1.55719242e-03f, 3.72976154e-01f, 7.01184943e-02f, 1.50722452e-02f, 2.08875798e-02f, -1.64293081e-01f,
  3.54528487e-01f, 1.76564336e-01f, -1.88185833e-03f, 1.09018192e-01f, 2.77338296e-01f, 1.11189656e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.04397692e-01f, 2.04855695e-01f, -1.41214386e-01f, 4.22740996e-01f, -4.06615064e-02f, -3.64393592e-01f, -1.33568376e-01f, -4.42152582e-02f, 1.80595696e-01f, 2.09983885e-01f,
  1.93667397e-01f, -4.05423403e-01f, -8.57856497e-02f, -1.54744744e-01f, -1.07820034e-01f, 1.69657603e-01f, -9.90408882e-02f, 1.53857678e-01f, 9.34563577e-02f, 7.87605047e-02f,
  -3.15796770e-02f, 2.39721105e-01f, -9.62195396e-02f, 1.31447697e-02f, 6.36137947e-02f, 6.17194735e-02f, 1.43544031e-02f, 2.14636296e-01f, -1.14954464e-01f, 1.15520746e-01f,
  2.86965311e-01f, -1.69076711e-01f, 2.99659614e-02f, -1.39335558e-01f, 1.52004540e-01f, 3.97182614e-01f, -1.28188431e-01f, 5.50653785e-02f, 1.54013112e-01f, -2.02525511e-01f,
  -2.85857767e-01f, -9.71864164e-02f, -1.65055946e-01f, 3.20014596e-01f, 1.67374417e-01f, 4.79100235e-02f, 1.47278115e-01f, -2.02132910e-01f, 5.25613083e-03f, 5.79139404e-02f,
  2.05996752e-01f, -6.12822026e-02f, 1.51931271e-01f, -1.80549815e-01f, 3.17094028e-01f, 8.56047422e-02f, 9.29573327e-02f, 9.56768319e-02f, -7.61894658e-02f, -1.54737487e-01f,
  -1.15244888e-01f, 3.81556712e-03f, 4.55310456e-02f, 3.06429714e-01f, -2.08485976e-01f, 3.51817697e-01f, 1.88244581e-01f, 4.95355017e-02f, 5.15171932e-03f, 1.45673767e-01f,
  1.66584149e-01f, 1.07218546e-03f, 2.11069092e-01f, 1.84004992e-01f, -1.07597947e-01f, -4.91089255e-01f, -7.74967521e-02f, 1.64732132e-02f, 1.73332751e-01f, -5.57187293e-03f,
  4.75701727e-02f, -7.37309977e-02f, -2.30718195e-01f, 4.90433946e-02f, 2.00639188e-01f, -3.95545512e-02f, 1.71435580e-01f, -5.19499034e-02f, 1.73386559e-01f, -1.77393585e-01f,
  -3.30263376e-02f, -5.64389899e-02f, -1.85486093e-01f, -1.24807591e-02f, 7.34623000e-02f, 7.98173100e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.27215540e-01f, 4.18706447e-01f, 2.01368153e-01f, 5.32552779e-01f, -8.79396573e-02f, -2.94600666e-01f, 3.12582463e-01f, -3.17982495e-01f, -2.64756948e-01f, 1.10179357e-01f,
  -4.79032844e-02f, 6.93488061e-01f, 1.14626087e-01f, -2.81585723e-01f, -1.15444876e-01f, 7.93496072e-02f, -8.59054029e-02f, -2.94176251e-01f, -3.40649366e-01f, -1.92001149e-01f,
  -3.42935503e-01f, 1.46524787e-01f, 6.55116677e-01f, 1.01080373e-01f, 4.77838367e-02f, 2.79019936e-03f, -1.21230058e-01f, -8.53764936e-02f, 1.64569035e-01f, -1.51309550e-01f,
  2.72231400e-01f, 1.69443324e-01f, 1.60390720e-01f, 1.97904170e-01f, 1.22224621e-01f, -5.01393795e-01f, -1.22006364e-01f, 3.27216476e-01f, 8.08459446e-02f, 3.79154176e-01f,
  -5.59436763e-03f, 3.97529840e-01f, 7.80300945e-02f, -1.96335241e-01f, 3.23385629e-03f, -7.72645772e-02f, 6.67685717e-02f, 2.55631894e-01f, 5.10074385e-02f, 1.49368539e-01f,
  5.19438162e-02f, -6.51305839e-02f, -9.38308612e-02f, -1.34702146e-01f, 3.32050383e-01f, -1.20274745e-01f, -1.76867172e-01f, 5.99903986e-02f, -1.14496388e-01f, 8.79133940e-02f,
  7.94643983e-02f, -4.46903370e-02f, 1.75837159e-01f, -1.32432627e-02f, -2.96646710e-02f, 6.83981925e-02f, 2.13040225e-02f, 1.19421519e-01f, -2.09776238e-01f, 2.33969972e-01f,
  2.10268870e-01f, 1.88653618e-01f, -1.75555274e-01f, -1.14541173e-01f, 8.85562599e-02f, 3.64480376e-01f, -1.13093844e-02f, 2.65801344e-02f, 4.08361740e-02f, -3.02397180e-02f,
  5.56088723e-02f, 5.44893481e-02f, 1.63633287e-01f, -8.14144406e-03f, 1.20712221e-01f, -1.14903986e-01f, 3.40452284e-01f, 2.41975207e-03f, -6.78859651e-02f, -2.79637519e-02f,
  1.05424039e-01f, 6.68625236e-02f, -1.49165183e-01f, 9.21911597e-02f, -3.59742232e-02f, 2.29469731e-01f, 2.07931966e-01f, 5.38874030e-01f, 1.22470558e-01f, -9.00340497e-01f,
  3.04917574e-01f, 6.51000798e-01f, 2.50120848e-01f, 4.89814758e-01f, -1.04051203e-01f, 2.42222220e-01f, 2.14496106e-02f, 1.58501212e-02f, -5.66044599e-02f, 2.53703594e-01f,
  1.15292236e-01f, 3.49501595e-02f, -2.15318620e-01f, -9.88762006e-02f, 1.74727529e-01f, -1.16308458e-01f, 4.94854189e-02f, -1.72897235e-01f, 2.08697785e-02f, -5.44511825e-02f,
  8.83355290e-02f, -1.13938361e-01f, 1.03757687e-01f, -1.84855834e-01f, -1.53402507e-01f, 4.04548883e-01f, -2.22070202e-01f, -1.43501580e-01f, 1.81840993e-02f, 2.40690202e-01f,
  1.12488151e-01f, 3.56305838e-01f, -7.59532023e-03f, -4.90616083e-01f, -1.59875810e-01f, -3.84007752e-01f, 4.53465879e-01f, -1.21144086e-01f, -5.53384982e-02f, -1.58115670e-01f,
  6.28407300e-02f, -6.76082149e-02f, -7.62690008e-02f, 1.44916862e-01f, 1.45584255e-01f, 1.23268425e-01f, -1.71341226e-01f, -4.75532115e-02f, -8.26478526e-02f, 1.89545572e-01f,
  -8.58181119e-02f, 1.88538089e-01f, 8.30711126e-02f, 1.32475972e-01f, 3.03131759e-01f, -1.09251536e-01f, 9.42246169e-02f, -9.28848907e-02f, 1.58287227e-01f, -1.21414304e-01f,
  1.02993205e-01f, 1.00213200e-01f, -1.29194692e-01f, -1.54883608e-01f, 1.49631321e-01f, 1.29900217e-01f, -8.17472935e-02f, 2.33808756e-01f, 1.58110172e-01f, 2.02935585e-03f,
  -5.34757692e-03f, 4.66092527e-01f, 8.32480378e-03f, -6.02365360e-02f, 7.54959807e-02f, 1.94186807e-01f, -4.57180180e-02f, 1.66409299e-01f, -3.14436316e-01f, -1.42732352e-01f,
  -1.13111742e-01f, 2.55412370e-01f, 3.09531447e-02f, 1.58447430e-01f, 1.58463195e-01f, 8.45150426e-02f, 6.23955280e-02f, -1.55362830e-01f, 2.29672313e-01f, -1.15133807e-01f,
  6.81704506e-02f, 7.92529210e-02f, 2.62701690e-01f, 3.67645681e-01f, 3.52188766e-01f, -1.24210484e-01f, 1.47361055e-01f, 1.87649637e-01f, 4.43131268e-01f, 2.99732625e-01f,
  6.67262375e-02f, 5.01443408e-02f, 7.32150301e-02f, -1.87838450e-01f, 2.55279820e-02f, 7.09316209e-02f, -1.15777902e-01f, -1.13545708e-01f, -1.14701927e-01f, 1.15667015e-01f,
  6.92616552e-02f, 3.44076604e-02f, 3.80530566e-01f, -1.53294588e-02f, 3.37824792e-01f, -2.34277219e-01f, 8.44277516e-02f, 3.85202169e-02f, 2.26669699e-01f, -8.02802518e-02f,
  -2.31639057e-01f, 3.79682362e-01f, 1.74492329e-01f, 2.09324941e-01f, -1.41416818e-01f, -3.15647066e-01f, 4.49514994e-03f, -2.92770918e-02f, -3.19930434e-01f, 1.75736065e-03f,
  6.75044134e-02f, 5.24351373e-02f, 2.33195871e-01f, -1.60458907e-02f, -2.46649068e-02f, 1.35158962e-02f, -1.33035362e-01f, -9.85127911e-02f, -1.40894428e-01f, 2.53435373e-01f,
  -1.21764012e-01f, 7.72028491e-02f, 6.62028611e-01f, -1.13859892e-01f, -1.19249232e-01f, -1.29623204e-01f, 1.19799105e-02f, 1.81075469e-01f, -1.66466236e-01f, -2.72431411e-03f,
  1.68511868e-01f, 3.70205343e-01f, -1.18344598e-01f, 5.19207604e-02f, 5.39720058e-02f, -8.59066993e-02f, -2.29341358e-01f, 1.35650873e-01f, 3.36230849e-04f, 1.93804711e-01f,
  -2.62402862e-01f, -9.08571705e-02f, -1.82681873e-01f, 1.68440770e-02f, 3.61264378e-01f, 1.63338467e-01f, 1.04120068e-01f, -3.12625408e-01f, 7.48924091e-02f, -2.13589787e-01f,
  -4.13735257e-03f, -5.44881523e-02f, 1.69911593e-01f, 2.95650493e-02f, -4.37143780e-02f, -1.06568463e-01f, -9.31545421e-02f, 2.90854216e-01f, -1.67836115e-01f, 1.16076112e-01f,
  -1.21487737e-01f, -2.67713834e-02f, 1.45386323e-01f, -2.13584185e-01f, -1.01899028e-01f, -2.10821480e-01f, 6.64024577e-02f, 1.44204507e-02f, 3.71635884e-01f, -5.49420714e-02f,
  -7.74663836e-02f, 2.22718254e-01f, 1.55503720e-01f, 2.80814439e-01f, 3.72550011e-01f, 1.15826719e-01f, -5.05275652e-02f, -1.60260394e-01f, -9.86029059e-02f, 2.74333000e-01f,
  2.12746054e-01f, 8.94454345e-02f, 2.13718608e-01f, -1.96087450e-01f, 1.11758448e-01f, 8.22428090e-04f, -2.79800206e-01f, 6.39871657e-02f, 3.04515660e-01f, 2.47904330e-01f,
  3.72202426e-01f, -3.63989249e-02f, 1.88920379e-01f, -5.23415469e-02f, 2.98990365e-02f, 1.52498648e-01f, -1.96371496e-01f, 2.32689753e-01f, 3.88711654e-02f, 4.57058102e-01f,
  1.51393294e-01f, 1.11987870e-02f, -2.60755479e-01f, -2.58047938e-01f, 1.20233655e-01f, 2.41923451e-01f, 2.20320001e-01f, 3.76240462e-02f, -5.58679700e-02f, 1.87880561e-01f,
  7.21802711e-02f, -1.74874723e-01f, -7.52084553e-02f, -6.51107877e-02f, 3.24875973e-02f, 9.56002995e-02f, -4.77440655e-02f, 2.33921021e-01f, 2.00403944e-01f, 3.05050258e-02f,
  -5.37255369e-02f, -2.19346471e-02f, 2.34036624e-01f, -9.86005440e-02f, -7.27703944e-02f, -6.73309043e-02f, 3.47199850e-02f, 6.35712892e-02f, -1.82407871e-01f, -9.09387171e-02f,
  7.38401711e-02f, 3.47088538e-02f, 6.63662627e-02f, -1.27013415e-01f, -1.90918177e-01f, 2.84694165e-01f, -3.58024128e-02f, -2.03273952e-01f, -1.99760273e-01f, -1.79171443e-01f,
  4.23557371e-01f, -6.00393787e-02f, -1.19207777e-01f, -1.50819689e-01f, 1.24890529e-01f, -5.49773239e-02f, -1.32393166e-01f, 2.10994154e-01f, -8.37852061e-02f, 8.20568949e-02f,
  5.96609473e-01f, -1.93055093e-01f, 1.16828218e-01f, 1.49110332e-01f, 2.80046253e-03f, 1.48403093e-01f, 4.18448374e-02f, -1.22438274e-01f, 3.30251306e-01f, -3.05978414e-02f,
  7.46811926e-02f, -1.97462037e-01f, 1.40787587e-01f, 7.43375858e-03f, -1.39390742e-02f, -4.25312556e-02f, -3.29590105e-02f, 3.17268968e-01f, -4.62346882e-01f, 1.35971168e-02f,
  3.15949500e-01f, 1.02922663e-01f, 1.90496996e-01f, 1.28873602e-01f, 4.27799001e-02f, -1.11204267e-01f, -1.11389451e-01f, -6.69626221e-02f, 1.07600458e-01f, 3.26181240e-02f,
  -2.27672815e-01f, 1.60223931e-01f, 8.10874283e-01f, 9.93300974e-03f, -2.49456212e-01f, -3.60759288e-01f, 5.21365345e-01f, -2.02154019e-03f, 1.05986416e-01f, -2.51452979e-02f,
  7.45982304e-02f, 3.27369004e-01f, -2.62904137e-01f, -2.04134911e-01f, 2.66942650e-01f, 5.23564927e-02f, 2.24020835e-02f, 2.38080502e-01f, -1.34229079e-01f, 3.50740582e-01f,
  -1.42017901e-01f, 7.74499550e-02f, 4.78439070e-02f, -1.41570970e-01f, 1.63631320e-01f, 1.20810434e-01f, -7.89804012e-02f, 2.01340944e-01f, 1.04198374e-01f, -2.41970628e-01f,
  5.36398776e-02f, 7.52594620e-02f, -8.74113962e-02f, -1.55017609e-02f, 1.88364103e-01f, -1.70178324e-01f, -1.05240814e-01f, -6.78192973e-02f, 2.75463343e-01f, 4.58539873e-02f,
  -1.19443305e-01f, 1.06029540e-01f, 1.01045556e-01f, -2.65821785e-01f, 1.75221227e-02f, -2.18166426e-01f, 3.80767256e-01f, 4.16963696e-01f, 3.42427403e-01f, 3.94430488e-01f,
  1.55010507e-01f, -2.41716713e-01f, 2.89765950e-02f, 2.07718506e-01f, 8.43003436e-05f, -4.06774022e-02f, 3.17542106e-02f, -3.46570238e-02f, 1.42755046e-01f, 1.46555826e-01f,
  1.45468563e-01f, 1.50617346e-01f, -1.27262786e-01f, 2.52201885e-01f, -2.63530742e-02f, 4.77961265e-02f, 3.03868484e-02f, -9.37485471e-02f, -5.30549549e-02f, -1.46546233e-02f,
  -7.95002654e-02f, -2.17437446e-02f, -4.52395752e-02f, 1.18544072e-01f, 2.17801109e-01f, -1.12460047e-01f, 4.27179337e-02f, 2.70012438e-01f, -5.76376319e-02f, -3.24252665e-01f,
  -2.40446091e-01f, 1.20280743e-01f, -3.84049304e-02f, -6.35217428e-02f, 1.32163748e-01f, 4.94737290e-02f, 2.81662941e-02f, 3.69094163e-01f, 4.80744243e-02f, 1.43768683e-01f,
  -1.48209676e-01f, 7.09786713e-01f, 1.18509389e-01f, -3.64737026e-02f, -2.19374597e-02f, -9.14411619e-02f, 1.12264194e-01f, -1.81780457e-01f, -7.66324997e-02f, -3.85105275e-02f,
  -1.63458526e-01f, -8.48427042e-02f, 2.37101793e-01f, 1.64273575e-01f, -6.35151491e-02f, -9.21365470e-02f, -1.52694762e-01f, 1.06464587e-02f, 6.19308762e-02f, -2.10723490e-01f,
  -3.64843495e-02f, -9.46886316e-02f, 4.80624706e-01f, 3.34935158e-01f, -1.75840423e-01f, -5.73778674e-02f, 3.28961134e-01f, 2.77065858e-02f, 2.88377851e-01f, 1.88614860e-01f,
  8.61087516e-02f, 3.95566165e-01f, -9.67494100e-02f, -2.35897630e-01f, -1.09516710e-01f, 2.85750143e-02f, 2.34834254e-01f, 2.57582217e-01f, -4.60056402e-02f, -4.53990214e-02f,
  -1.19108811e-01f, 7.89808780e-02f, 4.92325127e-02f, 9.99587327e-02f, -1.27881421e-02f, 3.17132145e-01f, 2.33554587e-01f, 8.69945213e-02f, 1.31323650e-01f, 2.13713542e-01f,
  8.38392526e-02f, 2.67380595e-01f, 1.63529411e-01f, -3.73653442e-01f, 3.53135139e-01f, 1.46454439e-01f, 1.64535090e-01f, 8.59955475e-02f, 1.49693355e-01f, -4.54279967e-02f,
  6.69675355e-04f, -1.24939665e-01f, -1.39231071e-01f, 4.94200796e-01f, 1.78954661e-01f, 2.96012368e-02f, -1.95007116e-01f, 1.07475482e-01f, 1.53107122e-01f, -1.95900090e-02f,
  -1.15678705e-01f, -1.86779410e-01f, -1.11337528e-01f, -4.84994426e-02f, -2.27737233e-01f, 2.40940601e-01f, 1.70271069e-01f, 1.10463828e-01f, 2.49680996e-01f, -1.56935379e-01f,
  1.21792726e-01f, 1.36136100e-01f, -1.20532028e-01f, 1.48311496e-01f, 1.18863694e-01f, 9.02724825e-03f, 1.18039615e-01f, 6.21716827e-02f, 1.80535808e-01f, 6.39266253e-01f,
  -1.36243194e-01f, -1.85755134e-01f, 3.85977253e-02f, -7.60172755e-02f, 3.65239024e-01f, -9.61512625e-02f, -8.84234607e-02f, 2.82132447e-01f, 1.72063503e-02f, -1.51093423e-01f,
  2.25782990e-02f, -1.24647118e-01f, 3.06732450e-02f, -5.57619296e-02f, 1.20747894e-01f, -1.53711677e-01f, -1.81188330e-01f, 2.21178327e-02f, 3.11162919e-01f, 8.25603977e-02f,
  3.06880120e-02f, -1.10934898e-01f, -1.62906557e-01f, -3.04791898e-01f, -1.78725645e-01f, -7.78303295e-02f, 1.49754539e-01f, 4.61723685e-01f, 2.56460365e-02f, 3.90033126e-02f,
  1.87800169e-01f, 3.67028028e-01f, -1.54300034e-01f, -2.93262750e-01f, 1.06387906e-01f, -5.05588017e-02f, -5.28945141e-02f, 2.82377511e-01f, 1.31867364e-01f, -5.59186898e-02f,
  -2.47733183e-02f, -1.59247696e-01f, -1.41983613e-01f, -7.51222745e-02f, -4.59908731e-02f, -1.77042902e-01f, 3.03020608e-02f, -1.73493221e-01f, -1.13299258e-01f, 4.05342914e-02f,
  2.20424190e-01f, 1.48292795e-01f, 1.92701370e-01f, -1.05342366e-01f, 1.03272023e-02f, -1.61538776e-02f, 6.10686205e-02f, 5.62476665e-02f, 1.29917055e-01f, -2.47238297e-03f,
  1.86807573e-01f, 4.62373585e-01f, 3.86182368e-01f, 4.82309937e-01f, 9.82689559e-02f, -3.50183547e-01f, 8.58695060e-03f, -1.53911477e-02f, 4.14769202e-01f, -6.86892495e-02f,
  -1.73999235e-01f, 2.56834328e-01f, -1.68984935e-01f, 3.59222405e-02f, -4.26221043e-02f, 1.12500839e-01f, -3.12330062e-03f, -2.40686759e-01f, -2.91456789e-01f, -3.08934897e-02f,
  -7.59725049e-02f, 4.29880083e-01f, -3.30864847e-01f, 2.17173934e-01f, 8.57830495e-02f, 1.13783933e-01f, 3.49127352e-01f, -2.73975909e-01f, 2.05630302e-01f, 3.89835201e-02f,
  4.01171476e-01f, 2.88273096e-01f, 4.63461399e-01f, 3.30647677e-01f, 1.38471022e-01f, -1.99980170e-01f, 4.38392043e-01f, -3.05342600e-02f, 7.73420557e-02f, 1.94491252e-01f,
  -2.86606979e-02f, 5.18584847e-01f, -4.60984446e-02f, 4.79825437e-02f, -2.00095490e-01f, -8.32825899e-02f, -9.87163633e-02f, 5.39555788e-01f, 9.21064168e-02f, -1.01545110e-01f,
  -2.34791934e-01f, 6.17513768e-02f, -2.45479926e-01f, 3.44693512e-01f, 9.09883901e-02f, 1.60821244e-01f, 5.75883240e-02f, 1.35690987e-01f, 2.49749467e-01f, 2.10938454e-01f,
  2.56396502e-01f, 5.00051193e-02f, 1.77007645e-01f, -1.33288562e-01f, -6.92614987e-02f, -1.03514358e-01f, 7.80630345e-03f, 2.12529879e-02f, 3.86880189e-02f, 1.84933394e-02f,
  -9.08741206e-02f, 1.33278161e-01f, -3.94309759e-02f, 1.70259476e-01f, -1.37519822e-01f, 2.30697468e-01f, -1.39552161e-01f, -3.47162448e-02f, 9.91323069e-02f, -9.83844548e-02f,
  7.96890929e-02f, -8.19697306e-02f, -1.51140302e-01f, -1.67673733e-02f, -1.35343671e-01f, -7.08343312e-02f, -1.77067205e-01f, -4.06529978e-02f, 1.78541020e-01f, -4.42169681e-02f,
  1.34951770e-01f, 1.83452070e-01f, 1.14219271e-01f, -1.75056443e-01f, -2.17822827e-02f, -4.69095930e-02f, -8.01207591e-03f, -5.23557551e-02f, -1.39134191e-02f, 7.77685568e-02f,
  2.74508377e-04f, -5.22538014e-02f, -7.96312541e-02f, 5.95229045e-02f, 1.02798417e-01f, -8.43279809e-02f, 5.22591174e-03f, 2.56582140e-03f, -6.84297876e-04f, 9.71645191e-02f,
  1.84798405e-01f, 1.41644418e-01f, -5.62004298e-02f, -1.80788323e-01f, -4.16281894e-02f, -1.03833988e-01f, -2.34369375e-02f, -7.09396973e-02f, 1.86474416e-02f, 9.92119834e-02f,
  -1.45247906e-01f, 1.70193955e-01f, -8.05941597e-02f, -3.81719284e-02f, 6.91385195e-02f, -1.54923707e-01f, 1.71136260e-02f, 1.96063578e-01f, 9.88114998e-02f, 4.87105012e-01f,
  8.09881240e-02f, 2.05489039e-01f, 2.86659092e-01f, -3.88902694e-01f, -9.35702771e-02f, -8.69744867e-02f, 2.87832409e-01f, -1.04108945e-01f, -2.06323609e-01f, 2.06288934e-01f,
  -1.65820628e-01f, 9.00750309e-02f, 9.70472544e-02f, 1.47138461e-01f, 7.92053714e-02f, -1.18752345e-01f, -1.77764848e-01f, 1.20493937e-02f, 5.94801493e-02f, 4.71817881e-01f,
  -1.50885448e-01f, 3.90886404e-02f, -9.29305404e-02f, -1.66314393e-01f, 2.44260892e-01f, 2.11309753e-02f, 2.97750026e-01f, -4.20816690e-02f, 2.38370076e-01f, 1.89731061e-01f,
  -4.01289910e-01f, 2.74116278e-01f, 2.94718862e-01f, -4.04113024e-01f, -3.18140119e-01f, 2.31612310e-01f, -1.83654428e-01f, 8.20759833e-01f, 2.02406988e-01f, 6.99538291e-02f,
  1.17082126e-01f, 9.22300756e-01f, -2.25107536e-01f, 4.13710594e-01f, -1.52051702e-01f, 2.98126340e-01f, -5.70912054e-03f, -1.93199236e-02f, 4.20258582e-01f, -1.75186694e-01f,
  -1.35055795e-01f, -2.91433096e-01f, -7.50028640e-02f, -1.29365727e-01f, -1.90073356e-01f, -2.60348022e-02f, -7.98972994e-02f, 1.17125452e-01f, 2.57546812e-01f, -1.49363965e-01f,
  -1.46879554e-01f, 3.62318009e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  3.26062739e-02f, 7.49905640e-03f, -1.11345150e-01f, 4.59303737e-01f, 3.65157247e-01f, -1.76587503e-03f, 2.17573300e-01f, -5.41210659e-02f, -1.03192753e-03f, 1.83409497e-01f,
  5.66076376e-02f, 7.44928271e-02f, 1.52712181e-01f, 9.63327363e-02f, 1.14933312e-01f, 6.94618970e-02f, 2.91387796e-01f, 1.40168056e-01f, 2.18314737e-01f, 1.17689885e-01f,
  2.91055977e-01f, 6.27896413e-02f, 6.42439350e-02f, -1.14849366e-01f, 3.27687860e-02f, 1.24131940e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -3.54304314e-01f, -5.58904052e-01f, -3.32370192e-01f, 1.60179123e-01f, -5.22906959e-01f, 5.97515563e-03f, 2.97046572e-01f, -1.39897838e-02f, 4.27995145e-01f, -2.68388033e-01f,
  -3.46296765e-02f, 3.74338269e-01f, -1.73710838e-01f, -1.87125325e-01f, 8.57666135e-02f, 4.69350249e-01f, 1.88550159e-01f, -2.77483284e-01f, 1.18966438e-01f, 7.99029619e-02f,
  -2.66301066e-01f, 5.51554263e-01f, -1.06500879e-01f, -1.76288754e-01f, 1.87394962e-01f, -1.83466807e-01f, -3.90123188e-01f, -2.98169643e-01f, -4.46043275e-02f, 1.19597547e-01f,
  -1.79172024e-01f, 3.75339150e-01f, -3.65826339e-02f, -3.66913974e-02f, -1.83496680e-02f, -4.16985780e-01f, 1.70286030e-01f, 1.29538924e-02f, 7.47594535e-01f, 2.98941165e-01f,
  1.94772527e-01f, 6.51954040e-02f, -4.17971700e-01f, 8.95935148e-02f, 2.95455866e-02f, 2.26349488e-01f, -2.62321472e-01f, 3.44764590e-01f, 3.52139026e-01f, 4.75693978e-02f,
  3.74891728e-01f, 1.31617025e-01f, 3.78056313e-03f, 1.83405161e-01f, -4.57465462e-03f, 3.94708395e-01f, -1.17865042e-03f, 1.90179512e-01f, -3.46147716e-01f, 2.30078131e-01f,
  7.49350190e-02f, -2.15255558e-01f, -3.57152283e-01f, -4.03429002e-01f, 4.36738402e-01f, 1.65085107e-01f, 2.58936822e-01f, 1.50080010e-01f, 4.38547254e-01f, -2.76077598e-01f,
  6.99869812e-01f, -2.94419914e-01f, -8.60778764e-02f, -4.58512008e-01f, 1.48657456e-01f, 2.98734576e-01f, 1.02611966e-01f, -3.80514026e-01f, -2.98031062e-01f, 2.66320765e-01f,
  -2.61988789e-01f, -2.03195527e-01f, -5.45728266e-01f, 1.49371266e-01f, 7.04547670e-03f, 1.22756809e-01f, -2.80810922e-01f, 1.32290348e-01f, 4.64012384e-01f, 5.37939742e-02f,
  6.02313161e-01f, -4.64325119e-03f, 1.71861500e-02f, 1.38397172e-01f, 4.18795675e-01f, -1.69862002e-01f, -4.45748597e-01f, 9.64721814e-02f, -1.82845116e-01f, -7.18608379e-01f,
  4.33930397e-01f, -2.61310071e-01f, -2.44295858e-02f, -2.25353360e-01f, -5.92417009e-02f, 1.50101274e-01f, -1.79046512e-01f, 2.21194804e-01f, -4.53326017e-01f, -2.09815800e-01f,
  -1.61261439e-01f, -3.29890966e-01f, -6.11538552e-02f, -2.92201728e-01f, -4.05318290e-01f, -2.91092098e-01f, 3.22033763e-01f, 3.66691381e-01f, -1.30658716e-01f, 1.56527773e-01f,
  -3.85656774e-01f, -1.62996456e-01f, 1.36649787e-01f, 2.16773227e-01f, 2.62209028e-01f, -1.09663494e-01f, 2.25328028e-01f, 7.59685636e-01f, -6.71643972e-01f, -5.36102414e-01f,
  -9.17913690e-02f, -1.36518896e-01f, 5.55759549e-01f, -6.16621487e-02f, -6.68113887e-01f, 2.61103451e-01f, 3.08801025e-01f, 4.48875099e-01f, -5.27942479e-02f, -2.71579288e-02f,
  2.72664726e-01f, 3.59489948e-01f, -8.71914253e-02f, 9.84068587e-02f, -9.04245079e-02f, -5.25400368e-03f, 7.13782087e-02f, -3.36321265e-01f, -1.12099916e-01f, 2.34718863e-02f,
  -2.46417984e-01f, -9.30798352e-02f, -2.16131568e-01f, -2.65012622e-01f, -3.53235364e-01f, -1.15206160e-01f, -7.77581036e-02f, -1.24512510e-02f, -2.69617409e-01f, 7.36939847e-01f,
  5.18657565e-01f, 5.82727194e-01f, 4.46193874e-01f, -4.69675213e-01f, -2.85524726e-01f, 5.12558877e-01f, -4.68989611e-01f, 6.84663832e-01f, -1.30763158e-01f, 9.09064472e-01f,
  -2.30601951e-01f, 7.14789107e-02f, 2.40654394e-01f, -1.01204604e-01f, -1.47397965e-01f, -3.77167702e-01f, 3.69230360e-01f, -1.47132471e-01f, 7.70066082e-02f, 4.17756028e-02f,
  2.87041396e-01f, 6.37705699e-02f, 1.01032808e-01f, 5.12716100e-02f, -2.21476257e-01f, -1.76578537e-01f, -4.67208445e-01f, 1.54662073e-01f, -8.31513330e-02f, -1.75825007e-05f,
  -1.62143737e-01f, 2.58951247e-01f, -2.95949757e-01f, 2.71954417e-01f, 1.50006101e-01f, 5.66386223e-01f, -3.37884098e-01f, 2.97655731e-01f, -3.67937237e-01f, -1.34255767e-01f,
  -1.58092827e-01f, -3.28771561e-01f, 6.41650498e-01f, -2.98881412e-01f, -1.22803561e-01f, -1.08390354e-01f, 5.07584631e-01f, -1.06670119e-01f, -2.81347241e-02f, 3.60649973e-01f,
  1.55175060e-01f, 3.90269518e-01f, -2.35875413e-01f, -2.24266306e-01f, -4.18664753e-01f, -6.81894198e-02f, 5.25052965e-01f, 1.74030781e-01f, 4.65101451e-01f, -5.25126576e-01f,
  -1.13537051e-01f, -4.42370474e-02f, 3.45023423e-01f, -4.01116520e-01f, -2.15541497e-01f, -5.88658512e-01f, -2.54134178e-01f, 5.16036637e-02f, -3.58494669e-01f, -2.43275553e-01f,
  -2.84090012e-01f, 9.28570479e-02f, -2.51025766e-01f, -4.03431952e-02f, 2.59326935e-01f, 3.94670695e-01f, -3.73486102e-01f, -3.80845331e-02f, 1.63816698e-02f, -2.92929798e-01f,
  1.28131434e-01f, 3.74422342e-01f, -4.39650714e-01f, 6.51725680e-02f, 1.66100681e-01f, 1.12299092e-01f, 3.13961744e-01f, -1.04779132e-01f, -1.61259726e-01f, -3.06441307e-01f,
  3.27845126e-01f, 5.64630449e-01f, 1.67525541e-02f, 1.25895262e-01f, 4.30495888e-01f, -4.86087985e-02f, -1.76899046e-01f, 2.78192610e-01f, 8.89407396e-02f, 6.97888970e-01f,
  -7.19886065e-01f, 1.00780271e-01f, 2.93031752e-01f, 4.26833071e-02f, -1.67700961e-01f, -2.31229603e-01f, 4.13310558e-01f, -7.26824114e-03f, 1.58037171e-01f, -3.06020707e-01f,
  1.20877787e-01f, -6.02084137e-02f, -1.49738833e-01f, -7.50611573e-02f, -1.47894323e-01f, -2.08942682e-01f, 1.27121285e-01f, -2.84661740e-01f, 6.19199932e-01f, 5.33560097e-01f,
  1.69826634e-02f, 3.31854880e-01f, 3.69076073e-01f, 5.02374649e-01f, -4.49421778e-02f, -6.44364059e-02f, 2.66874671e-01f, -7.41783679e-01f, 5.55243313e-01f, -1.66583464e-01f,
  -2.00243145e-02f, 3.12912196e-01f, 2.66290516e-01f, -2.21851394e-01f, 1.95144147e-01f, -1.16394490e-01f, 2.44902864e-01f, -5.52320719e-01f, -2.41738170e-01f, -9.99248549e-02f,
  1.27030537e-01f, 9.57099125e-02f, -1.37493968e-01f, -3.53109799e-02f, -2.53007948e-01f, 7.67838880e-02f, 2.75215089e-01f, 3.35885793e-01f, -1.18328603e-02f, -8.26482754e-03f,
  -3.36550593e-01f, -1.52183250e-01f, 4.92052257e-01f, 1.26336426e-01f, 1.21609725e-01f, -3.08843315e-01f, -1.29266411e-01f, -1.21832127e-02f, -3.00667770e-02f, 4.66396958e-01f,
  4.08872575e-01f, 1.06325306e-01f, 1.45614659e-02f, -5.03466129e-01f, 1.60492614e-01f, 3.93268764e-01f, -3.17399472e-01f, -6.89405501e-02f, 1.00684345e-01f, 6.31130993e-01f,
  -2.45817021e-01f, 5.04674241e-02f, 7.08252549e-01f, -5.08981794e-02f, -8.09886530e-02f, 7.09233940e-01f, 9.32746604e-02f, -2.13835984e-01f, -4.05127078e-01f, -4.14987564e-01f,
  3.46565157e-01f, -3.41089636e-01f, 4.75128651e-01f, 7.31380507e-02f, -2.80984908e-01f, -9.69680771e-02f, -1.62412658e-01f, 1.42370788e-02f, -1.43337607e-01f, -5.50438045e-03f,
  -1.18121300e-02f, -6.51636064e-01f, -3.87589112e-02f, 2.09064007e-01f, -1.01501253e-02f, 6.14286602e-01f, -2.74244454e-02f, -3.91364068e-01f, -3.12544793e-01f, -3.64239991e-01f,
  -8.22076946e-02f, -3.74873638e-01f, 1.34898737e-01f, -3.20750803e-01f, -3.91397804e-01f, 5.36829948e-01f, -1.00741535e-01f, -3.07815164e-01f, 9.32250768e-02f, 5.71386874e-01f,
  7.21794546e-01f, -2.81710215e-02f, -2.71309055e-02f, -2.53032953e-01f, -1.61393777e-01f, -2.32504606e-01f, 6.76172823e-02f, 1.50231406e-01f, -4.08892393e-01f, -4.56482112e-01f,
  -1.34886131e-01f, -1.04156017e-01f, -3.49176705e-01f, -1.48410767e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.00616026e-01f, 2.57942528e-01f, 1.64442807e-02f, 1.18166767e-01f, -2.92351037e-01f, 2.68296272e-01f, -2.50376817e-02f, -2.62492210e-01f, 2.73697197e-01f, 1.01831637e-01f,
  -6.06924854e-02f, 2.57459164e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    