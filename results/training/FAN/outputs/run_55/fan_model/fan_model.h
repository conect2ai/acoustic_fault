/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.84275782e-01f, -3.69301736e-01f, -3.45715731e-01f, 1.84574097e-01f, -4.28215265e-02f, 1.66567206e-01f, 1.27387747e-01f, -7.98746273e-02f, 3.42052042e-01f, -1.81344852e-01f,
  3.05357426e-01f, 7.33194053e-02f, 3.54754440e-02f, 1.34421602e-01f, 5.73396087e-01f, 1.48435578e-01f, 1.81420654e-01f, 1.31555304e-01f, 5.05761281e-02f, 3.26474495e-02f,
  1.06882773e-01f, 1.24620110e-01f, -2.16448277e-01f, -2.28950113e-01f, -1.66628972e-01f, -2.81576663e-01f, 6.40731491e-03f, -2.00265080e-01f, -3.91277932e-02f, -1.70971379e-02f,
  -8.45784470e-02f, -8.06452185e-02f, -4.77320217e-02f, -1.40559509e-01f, 2.40120720e-02f, -5.42836599e-02f, 2.54948791e-02f, -8.07615519e-02f, 9.88530666e-02f, -1.84925795e-02f,
  7.29542784e-03f, 3.01407222e-02f, 2.94501092e-02f, -1.23986993e-02f, -4.42717373e-02f, -6.43154187e-03f, 6.20094053e-02f, -9.45327990e-03f, -3.75672132e-02f, -1.47190690e-02f,
  3.55209857e-02f, -7.75042847e-02f, 1.78371035e-02f, 6.18795212e-03f, -6.96341023e-02f, 1.75013151e-02f, -1.24887198e-01f, -8.64231661e-02f, 7.19268620e-02f, 1.09302811e-01f,
  1.13735616e-01f, -5.31462356e-02f, -7.81425014e-02f, -3.83098423e-02f, 6.66848151e-03f, -1.47029340e-01f, 1.20253228e-02f, -4.71415371e-02f, 1.24138976e-02f, -1.49992306e-03f,
  1.07619390e-01f, 1.45035200e-02f, 4.18135710e-02f, -2.37168875e-02f, -6.43599359e-03f, -1.68003477e-02f, -1.26202870e-02f, -5.26171699e-02f, 1.94270033e-02f, -6.30008662e-03f,
  -3.01355943e-02f, -2.99092513e-02f, -5.67300953e-02f, -1.61758363e-02f, 1.30347880e-02f, -9.81238112e-03f, -6.22277893e-02f, -3.02462764e-02f, -2.39406656e-02f, 5.14190644e-02f,
  2.26816326e-01f, 2.77445376e-01f, -3.49468440e-02f, 2.19935142e-02f, -7.87694082e-02f, 9.84016284e-02f, -2.20302902e-02f, -2.52534095e-02f, -3.00879404e-03f, 5.99013008e-02f,
  8.99998844e-03f, -5.04426360e-02f, -4.54368591e-02f, 1.34061668e-02f, -7.46078789e-02f, 3.16914283e-02f, 1.52044548e-02f, -1.57726614e-03f, 7.22727254e-02f, 1.03971470e-04f,
  3.73470671e-02f, 7.34255016e-02f, -1.02193944e-01f, -7.08077103e-02f, -4.36907262e-03f, -1.32061699e-02f, 1.41417831e-01f, -7.79456571e-02f, -1.28238490e-02f, -1.49666164e-02f,
  5.95075905e-01f, -7.95467943e-02f, -9.47645456e-02f, 1.30782142e-01f, 3.81644994e-01f, 5.03945351e-01f, 1.16714902e-01f, 1.67385980e-01f, 1.46032378e-01f, -1.94362417e-01f,
  1.07436413e-02f, -1.86029132e-02f, -9.15651396e-02f, 1.85440853e-01f, 4.74618763e-01f, -2.35649735e-01f, 2.55622715e-01f, -1.55268796e-02f, 4.13053297e-02f, 2.98788965e-01f,
  4.43206131e-02f, 2.78899282e-01f, 5.51161431e-02f, 7.55654797e-02f, 2.24416971e-01f, -9.31800753e-02f, 1.52849918e-02f, -1.80928364e-01f, 1.58637166e-01f, 1.18600605e-02f,
  1.99299350e-01f, -1.08272634e-01f, -1.24963298e-02f, -4.09756191e-02f, 2.14326844e-01f, -7.58597702e-02f, -5.73285623e-04f, -6.55279383e-02f, 1.13674160e-02f, 4.71589826e-02f,
  -2.73430850e-02f, 8.54832307e-02f, 2.13262485e-03f, -1.04525581e-01f, -4.54440229e-02f, -5.61345043e-03f, 3.05564180e-02f, 5.98302968e-02f, -3.57434861e-02f, 3.08242794e-02f,
  -3.60413007e-02f, -1.44214602e-02f, -1.31016877e-02f, -3.87620553e-02f, -8.86683315e-02f, -8.21298137e-02f, -1.72146056e-02f, -5.32431938e-02f, 6.43862933e-02f, 5.75299561e-02f,
  6.19327500e-02f, -7.84873441e-02f, -4.29808535e-02f, 3.55840400e-02f, 7.55436206e-03f, -1.52743505e-02f, -8.41277391e-02f, 3.74131836e-02f, -6.66674301e-02f, 7.95079321e-02f,
  7.82451108e-02f, -3.41631584e-02f, -7.95640144e-03f, 4.91783116e-03f, -4.55733128e-02f, -1.96866505e-02f, 3.25119160e-02f, 4.89680395e-02f, 7.90297333e-03f, 3.12266629e-02f,
  -7.99798742e-02f, 2.40593087e-02f, -5.17188385e-02f, 1.48250815e-02f, -3.18048261e-02f, -5.40129803e-02f, -5.55173978e-02f, -1.93656925e-02f, 1.24118440e-02f, 6.09147139e-02f,
  1.73003763e-01f, 9.22986716e-02f, -1.28107453e-02f, 1.00687690e-01f, -1.21265955e-01f, 4.71493090e-03f, -1.08893160e-02f, 5.20968214e-02f, -1.28984200e-02f, 9.26277041e-02f,
  4.65704463e-02f, -1.25221098e-02f, 8.86761770e-03f, 4.07806598e-02f, 5.99004291e-02f, -3.93770747e-02f, -2.01065064e-04f, -4.99596596e-02f, 1.32143140e-01f, 1.48853157e-02f,
  7.36679286e-02f, -1.25926444e-02f, -1.82230752e-02f, 5.39503619e-02f, 3.79221514e-02f, 3.01213171e-02f, 6.37092888e-02f, -6.76984638e-02f, 3.58483717e-02f, -1.76331382e-02f,
  4.87158090e-01f, -8.02927613e-02f, 1.00304939e-01f, 4.80592884e-02f, -6.20174315e-03f, -6.10730657e-03f, 1.38504475e-01f, -1.50848582e-01f, -3.14605504e-01f, -4.31622453e-02f,
  2.97269560e-02f, 3.27794045e-01f, 8.24031159e-02f, -2.16472954e-01f, 4.75034565e-01f, -3.99875909e-01f, -2.21114457e-02f, 6.13905601e-02f, -2.91090757e-01f, 2.19685093e-01f,
  2.08609980e-02f, -2.20330688e-03f, 5.00467382e-02f, -1.22136310e-01f, 1.57358885e-01f, 3.66293639e-02f, 2.54006565e-01f, -4.07482721e-02f, 2.68943369e-01f, -1.18623205e-01f,
  4.57166396e-02f, -2.37504765e-01f, -2.05106125e-03f, -1.09399587e-01f, 4.37667333e-02f, 7.07017928e-02f, 1.09366223e-01f, -1.72451753e-02f, -3.06117740e-02f, -9.11152083e-03f,
  1.28869032e-02f, -1.27784284e-02f, -1.85739309e-01f, -2.47252993e-02f, -1.11227430e-01f, -5.80889098e-02f, -2.80929673e-02f, -5.57518080e-02f, 1.98462568e-02f, 4.42786142e-02f,
  -1.12107582e-02f, 7.64139804e-06f, -6.75847530e-02f, 6.19022269e-03f, 9.82133225e-02f, -2.53957957e-02f, 9.23142582e-03f, 1.30283073e-01f, 3.52014392e-03f, -3.84678207e-02f,
  -1.05814151e-01f, 4.08984274e-02f, 4.69316393e-02f, -4.40858454e-02f, 1.18103474e-01f, -1.55649772e-02f, -3.32523212e-02f, -2.96747237e-02f, 1.51587641e-02f, 5.34174144e-02f,
  7.20353276e-02f, -4.57699001e-02f, -1.54339731e-01f, 4.33923900e-02f, 2.59348527e-02f, -6.09068945e-02f, 8.83977562e-02f, 8.32376927e-02f, 1.25180231e-02f, -3.17102000e-02f,
  -6.71541095e-02f, 9.67472699e-03f, 1.06589817e-01f, -9.43045877e-03f, -1.02206640e-01f, 5.54050989e-02f, -7.15154633e-02f, -5.13632363e-03f, -4.21900451e-02f, 6.36231229e-02f,
  2.71371037e-01f, 1.55394286e-01f, -5.07987402e-02f, 2.48966180e-02f, -8.12814906e-02f, -2.49847881e-02f, -1.11318357e-01f, -5.45122400e-02f, 1.82672456e-01f, -5.25027663e-02f,
  6.65567294e-02f, 2.97520086e-02f, 5.22860847e-02f, 4.95890938e-02f, 1.14538640e-01f, 7.72135481e-02f, 8.08704123e-02f, 3.07863336e-02f, 5.17443828e-02f, 9.21326131e-02f,
  1.14763036e-01f, 4.43588160e-02f, 2.07642075e-02f, 4.34399322e-02f, -5.29367998e-02f, 9.62248519e-02f, 5.10340035e-02f, 2.58609317e-02f, -3.97342583e-03f, -4.32901978e-02f,
  1.77120879e-01f, -1.39495686e-01f, 5.18960655e-01f, -1.43700663e-03f, -2.42178977e-01f, -4.70482297e-02f, 5.69104478e-02f, -9.50221941e-02f, 3.17183346e-01f, -2.40334839e-01f,
  -3.31614166e-01f, 3.13860893e-01f, -3.18805240e-02f, -1.71600699e-01f, 4.28579822e-02f, 2.68561125e-01f, -2.10190088e-01f, -2.82343314e-03f, 6.38499707e-02f, -2.97005326e-01f,
  6.64818585e-02f, -4.64401960e-01f, -8.64636675e-02f, -1.84223861e-01f, -1.36020049e-01f, 2.27101088e-01f, -3.20304573e-01f, 2.62366850e-02f, -1.72083914e-01f, 3.12276930e-02f,
  -5.35950847e-02f, 8.52838531e-02f, -5.62799769e-03f, 1.14090644e-01f, -6.26245588e-02f, -9.46934298e-02f, 4.06731665e-02f, 2.79012248e-02f, 8.51054937e-02f, 5.33875711e-02f,
  8.51799920e-02f, -4.13700156e-02f, 2.30945479e-02f, 1.01560183e-01f, -3.28180715e-02f, -1.00860940e-02f, 6.56525493e-02f, -6.19458072e-02f, -1.20973922e-02f, 6.95876479e-02f,
  7.18679503e-02f, 9.15664583e-02f, -1.30425617e-02f, 8.06955695e-02f, 1.96612626e-01f, 6.50268644e-02f, 9.14567187e-02f, 5.06521426e-02f, -2.06349622e-02f, 5.45344464e-02f,
  -3.97100560e-02f, -7.53478929e-02f, 2.07929239e-02f, -5.70107698e-02f, 2.25410424e-02f, -5.37876412e-02f, -7.16864094e-02f, -9.16892141e-02f, 1.01678655e-01f, -4.62105162e-02f,
  -7.27201924e-02f, 3.55872065e-02f, 3.09675075e-02f, 6.82819588e-03f, -1.05656169e-01f, 2.75341328e-03f, 2.21237205e-02f, 4.44838628e-02f, -2.01156810e-02f, -7.56567121e-02f,
  2.01775990e-02f, -3.58316749e-02f, -6.00557495e-03f, 4.05270793e-03f, 1.00983782e-02f, -1.59107782e-02f, -7.63418451e-02f, -9.00677755e-04f, 1.54356444e-02f, -5.45720756e-02f,
  -3.61331791e-01f, -3.21570575e-01f, -3.12362262e-03f, -2.82546971e-02f, -1.92557480e-02f, -9.55345854e-02f, -1.87705681e-02f, 1.08155794e-01f, -4.95398454e-02f, -2.13009082e-02f,
  -6.94310060e-03f, -1.44289404e-01f, -1.43319359e-02f, -5.40015437e-02f, -6.18004277e-02f, 8.70444928e-04f, -2.97233127e-02f, -2.58241966e-02f, -1.50013804e-01f, -1.13454781e-01f,
  -7.59366825e-02f, -1.84942130e-02f, 3.72514725e-02f, -1.02918625e-01f, -6.97053596e-02f, -9.00772680e-03f, -2.39105988e-02f, 1.59230918e-01f, -1.90421809e-02f, -3.23953778e-02f,
  -4.62631583e-02f, -1.66161694e-02f, -5.87350456e-03f, 1.74969509e-01f, -3.59182507e-01f, -3.27364355e-02f, 5.23167670e-01f, -2.26250619e-01f, 7.69734383e-02f, 2.40848690e-01f,
  1.35049999e-01f, -1.21194132e-01f, 1.67030632e-01f, 2.79455125e-01f, 4.06405687e-01f, 1.73382819e-01f, 3.48578185e-01f, 1.28524467e-01f, -1.44497335e-01f, 4.39434312e-02f,
  -2.66203769e-02f, 2.32559070e-01f, 7.78085738e-02f, -2.31605247e-01f, -9.79927480e-02f, -2.72021681e-01f, 1.25823244e-01f, -8.58866200e-02f, -1.62760347e-01f, -9.71703008e-02f,
  5.45356013e-02f, 5.49124293e-02f, 5.43235615e-03f, -5.08741029e-02f, 9.35125425e-02f, -3.76936328e-03f, 2.69498620e-02f, 1.70747843e-02f, 6.14957279e-03f, -3.51255690e-03f,
  -7.56546035e-02f, -1.26059607e-01f, -2.41000969e-02f, -5.34113981e-02f, -6.94744587e-02f, -1.10462621e-01f, -9.02697742e-02f, -5.98313250e-02f, -1.85746327e-01f, -7.22533315e-02f,
  -6.31383136e-02f, -9.49073210e-02f, 1.20319530e-01f, 3.09844501e-02f, -1.41683981e-01f, 1.77837387e-02f, -1.66929029e-02f, -1.35794664e-02f, -7.38119408e-02f, -1.31729376e-02f,
  4.76445034e-02f, 9.92923900e-02f, -1.15826637e-01f, -6.70151487e-02f, 6.30503148e-02f, -1.86149552e-01f, 2.45764758e-02f, -1.39949799e-01f, 1.05168764e-02f, -3.39093655e-02f,
  1.32063609e-02f, 4.09916155e-02f, 6.00419976e-02f, 3.97247821e-02f, 1.30850255e-01f, 6.73198625e-02f, 8.05598497e-02f, -1.66408390e-01f, -2.69815661e-02f, -1.15908317e-01f,
  2.50077378e-02f, 7.81608298e-02f, 3.50248180e-02f, -8.93304422e-02f, 9.34000313e-02f, 3.17648090e-02f, -7.03802779e-02f, -8.40824917e-02f, 5.60013540e-02f, 5.69891483e-02f,
  2.29928821e-01f, 4.26981747e-01f, 3.71084437e-02f, -5.47560193e-02f, 1.26355886e-02f, -5.46402894e-02f, -1.24977585e-02f, -1.07883448e-02f, 4.32489701e-02f, 2.55393870e-02f,
  5.05606048e-02f, -2.33369395e-02f, -2.63263960e-03f, 1.03580737e-02f, 6.32954240e-02f, 4.07984145e-02f, 1.82382986e-02f, 6.96966723e-02f, 1.85671911e-01f, 5.18941097e-02f,
  1.65208001e-02f, -4.89549451e-02f, -8.79804567e-02f, -8.82597864e-02f, 1.16249518e-02f, -2.37800763e-03f, 2.11710688e-02f, -9.05498713e-02f, -4.31033447e-02f, 7.85813015e-03f,
  -6.60421789e-01f, 3.22897226e-01f, -2.32525542e-01f, -2.74320662e-01f, -1.31973565e-01f, 2.85554409e-01f, 4.49643172e-02f, -1.44168615e-01f, -2.58601695e-01f, 1.54509202e-01f,
  -2.20807735e-04f, 1.89784933e-02f, 1.98764980e-01f, 1.88648731e-01f, 1.35603964e-01f, 3.75804812e-01f, -1.15858734e-01f, -5.26511157e-03f, 3.88483629e-02f, -2.47664064e-01f,
  -1.49208352e-01f, 1.99566454e-01f, 2.45281812e-02f, 4.90713604e-02f, -2.81526238e-01f, -2.70703018e-01f, -1.23394065e-01f, -3.03306486e-02f, -5.92890568e-02f, 1.54566094e-01f,
  1.67533830e-01f, -2.13781986e-02f, -1.10391244e-01f, -4.94113453e-02f, -1.66736931e-01f, -2.86481734e-02f, -1.04623631e-01f, 1.08534999e-01f, -8.06606561e-02f, -4.11915453e-03f,
  1.81243010e-02f, -3.98398973e-02f, 3.71782556e-02f, 5.22546880e-02f, -1.51282713e-01f, -1.07526407e-01f, -1.06900008e-02f, 5.45159578e-02f, 7.31592812e-03f, 1.35459695e-02f,
  1.29584214e-02f, -4.12162915e-02f, -1.63288727e-01f, 1.24217691e-02f, -8.57548341e-02f, 2.31806468e-02f, 5.24715818e-02f, 3.09422035e-02f, 8.09435248e-02f, -8.73496830e-02f,
  2.93006748e-02f, -1.95973124e-02f, 4.15529907e-02f, 1.38926014e-04f, 1.02218352e-01f, -3.94036695e-02f, -7.27050230e-02f, 6.73317537e-02f, -6.05207197e-02f, 1.79952737e-02f,
  -9.62016210e-02f, -4.82396856e-02f, 1.51645318e-02f, -7.75025561e-02f, -7.20947906e-02f, 2.87518892e-02f, 4.56976742e-02f, -6.46390542e-02f, -9.90672708e-02f, -2.42880080e-02f,
  5.16211353e-02f, -1.61231011e-02f, -2.19369829e-02f, -4.40432783e-03f, 7.97372535e-02f, -3.25830374e-03f, -5.09824865e-02f, -2.91761402e-02f, -1.57186147e-02f, -3.37372869e-02f,
  8.77084732e-02f, -1.35041907e-01f, -9.81977675e-03f, 8.31625313e-02f, 9.20164064e-02f, 3.91797125e-02f, 1.21867754e-01f, -9.78999306e-03f, -2.59454660e-02f, -1.81705728e-02f,
  -6.43649548e-02f, -5.62219620e-02f, -8.42053965e-02f, -1.80694424e-02f, 2.51563322e-02f, 2.66233049e-02f, 2.44378820e-02f, -1.39215425e-01f, -3.27627286e-02f, -1.84267405e-02f,
  -6.43243417e-02f, -2.04936136e-02f, 2.26793978e-02f, -3.30308229e-02f, -8.11966322e-03f, -2.96253916e-02f, -1.04977809e-01f, -6.46820152e-03f, 3.23488861e-02f, 2.94656102e-02f,
  6.53802097e-01f, -2.38147616e-01f, -1.48892209e-01f, 3.43940377e-01f, 2.07298398e-01f, 2.13959590e-01f, 5.07024467e-01f, -5.25684729e-02f, 1.62668235e-03f, 1.03211798e-01f,
  1.63315177e-01f, -1.03769869e-01f, -5.91635853e-02f, 1.68349028e-01f, -9.69127640e-02f, -2.59435117e-01f, 2.42041543e-01f, 2.43061334e-01f, -3.02512459e-02f, 5.76781482e-02f,
  7.14786500e-02f, 1.36986583e-01f, -1.65586136e-02f, -1.64025918e-01f, 2.55859047e-01f, 9.92598198e-03f, 6.62596300e-02f, -1.25961304e-01f, 2.11308040e-02f, 2.34695971e-02f,
  1.23015761e-01f, 1.96440220e-02f, 2.27781851e-02f, -1.36841357e-01f, 4.66341265e-02f, 6.41276389e-02f, 1.89330950e-02f, 1.18664771e-01f, -3.11041996e-02f, -1.88298486e-02f,
  8.10189322e-02f, 3.56423249e-03f, -3.40353884e-02f, -1.11662239e-01f, 4.22223583e-02f, -5.59116080e-02f, -5.45242541e-02f, 6.03472553e-02f, -3.15910652e-02f, 3.43314745e-02f,
  -1.25582227e-02f, 6.18183799e-02f, 8.14670101e-02f, -4.02504355e-02f, -4.89883199e-02f, 5.71243139e-03f, 4.68749041e-03f, 1.41496165e-02f, 1.12520576e-01f, 5.31896837e-02f,
  4.60118912e-02f, 2.46987864e-02f, -1.43501908e-02f, 3.73657118e-03f, -5.32012573e-03f, -4.01214138e-03f, 2.35241987e-02f, 4.59135994e-02f, -4.50604372e-02f, 1.52588207e-02f,
  2.12531909e-02f, 5.40098816e-04f, 6.37644529e-02f, 6.96134521e-03f, 9.32232887e-02f, 9.76218060e-02f, 5.37030883e-02f, -7.72001296e-02f, -4.43349704e-02f, 6.39830679e-02f,
  6.79268613e-02f, -2.94124447e-02f, -5.50248511e-02f, 8.63417462e-02f, 6.00435734e-02f, -3.80633660e-02f, 5.28498692e-03f, -7.22113699e-02f, -4.89376597e-02f, 6.62054420e-02f,
  -1.29425243e-01f, -3.60934675e-01f, -1.21238135e-01f, 5.85759021e-02f, -5.25755025e-02f, 6.71262294e-02f, -7.29852319e-02f, -5.86531237e-02f, -2.45639347e-02f, 2.18305141e-02f,
  8.56222957e-02f, 1.10176787e-01f, 1.52585115e-02f, 8.28469917e-02f, -6.30429164e-02f, -1.87583664e-03f, 2.40236297e-02f, 2.54999083e-02f, 1.82144269e-02f, -2.54480671e-02f,
  1.47759998e-02f, 6.54222295e-02f, 3.81877720e-02f, 5.60196936e-02f, 4.16015051e-02f, 7.00919107e-02f, 1.26664732e-02f, -3.09829470e-02f, -3.16736028e-02f, -6.51995018e-02f,
  2.12254584e-01f, -1.09407455e-01f, 1.99867010e-01f, 8.46061409e-02f, -2.36765325e-01f, 3.42701435e-01f, 5.20859182e-01f, -2.66067892e-01f, -3.83982398e-02f, 6.47400171e-02f,
  -1.17765166e-01f, 2.64650524e-01f, -7.25243613e-02f, 2.53770381e-01f, 5.75432554e-02f, 1.41534090e-01f, 2.95634329e-01f, 2.14391634e-01f, -7.11786672e-02f, -3.08876652e-02f,
  7.69321471e-02f, -1.55012161e-01f, 2.34118104e-01f, -4.58131522e-01f, 7.22265914e-02f, -1.84357345e-01f, -2.54048914e-01f, 4.29383330e-02f, -1.10849746e-01f, 2.74327584e-02f,
  2.49962285e-01f, -6.34731352e-02f, 4.25146483e-02f, -2.65216790e-02f, -1.79855246e-02f, 6.38970584e-02f, 1.68121174e-01f, 3.97866294e-02f, 1.41777750e-02f, -2.66525103e-03f,
  6.75536469e-02f, -6.33410513e-02f, -2.45105680e-02f, -6.51329532e-02f, 6.65988103e-02f, -1.05817639e-03f, -7.11807422e-03f, 1.68617934e-01f, -4.11872119e-02f, 5.94280921e-02f,
  -3.66732888e-02f, 1.34045511e-01f, 5.29148541e-02f, -6.70145527e-02f, 3.02566681e-02f, 4.45121303e-02f, 1.04705550e-01f, 7.18819946e-02f, -6.69881254e-02f, -4.32406031e-02f,
  -9.05651376e-02f, -6.01632968e-02f, 8.13939646e-02f, -6.49902225e-02f, -2.37537753e-02f, 4.96064126e-02f, 5.18722944e-02f, 9.97339934e-02f, 3.16001587e-02f, 3.35040912e-02f,
  -1.81175973e-02f, -3.70902009e-02f, -6.29234985e-02f, -8.69120937e-03f, 6.71791434e-02f, 1.97432339e-02f, 8.78917724e-02f, -4.97743450e-02f, 1.30491052e-02f, -9.25567225e-02f,
  2.21707635e-02f, 1.85682420e-02f, 3.01718805e-02f, 7.60900527e-02f, -4.61803470e-03f, -5.98564669e-02f, -2.17182934e-02f, 4.68873279e-03f, 1.90955680e-02f, 4.79556341e-03f,
  -3.59683074e-02f, -3.90457541e-01f, -4.20909226e-02f, 2.78123673e-02f, 8.96865875e-03f, 3.70526798e-02f, 3.89385186e-02f, -4.14385200e-02f, -8.37920308e-02f, -1.97727922e-02f,
  -7.96329230e-02f, 1.08163521e-01f, -9.47538391e-02f, -1.49261449e-02f, 3.51409018e-02f, -1.03457212e-01f, 8.83919150e-02f, 4.63134050e-02f, -1.36125311e-02f, -1.10960297e-01f,
  -3.51842269e-02f, -8.16816092e-02f, 6.48265928e-02f, 2.17019022e-02f, 3.75780053e-02f, -1.21862497e-02f, -9.75402445e-02f, -3.31008770e-02f, -8.69609639e-02f, 5.22405915e-02f,
  2.19133914e-01f, 2.71037102e-01f, -2.53155887e-01f, 1.02256507e-01f, 6.74135983e-02f, -3.88889164e-01f, 6.12511560e-02f, -1.10882714e-01f, 2.13104650e-01f, 9.04860049e-02f,
  2.63700094e-02f, 1.87420949e-01f, 2.51363754e-01f, -2.52052605e-01f, 3.76385078e-02f, 9.12951604e-02f, -1.71078056e-01f, 1.20651700e-01f, 1.18715139e-02f, 1.36137694e-01f,
  -1.00669995e-01f, 8.97653028e-02f, -1.72843158e-01f, -1.80140361e-02f, -1.53722838e-01f, -3.74468639e-02f, 1.27194956e-01f, 9.70198493e-03f, -2.13238105e-01f, -8.74715373e-02f,
  -1.59987032e-01f, -2.27121562e-02f, -6.92641810e-02f, -2.36263759e-02f, -8.29424188e-02f, 3.09557710e-02f, 2.72809118e-02f, 4.10850085e-02f, -6.17593862e-02f, -3.20057794e-02f,
  1.07495248e-01f, -6.38937429e-02f, -2.61621699e-02f, 9.56273824e-02f, 4.88992520e-02f, 2.60824710e-02f, -8.55113119e-02f, -1.77040622e-01f, -1.34232827e-02f, -1.28058970e-01f,
  -4.30460759e-02f, -1.67023063e-01f, -6.46388158e-02f, -1.09794177e-02f, -1.00402318e-01f, -5.11510521e-02f, -1.19091898e-01f, 2.99606789e-02f, -8.61027390e-02f, -1.50961652e-01f,
  3.89875583e-02f, 5.32401390e-02f, 4.58684238e-03f, -8.31704885e-02f, 1.03910036e-01f, -5.36756478e-02f, 6.12716191e-03f, -2.08668020e-02f, 4.75316904e-02f, 7.20949769e-02f,
  -1.69457626e-02f, 1.97639801e-02f, 7.46932551e-02f, -6.42006472e-02f, 1.89150649e-03f, -4.71060090e-02f, 2.43408997e-02f, -3.26234545e-03f, -4.23566671e-05f, -1.15440033e-01f,
  6.84274137e-02f, -5.92669891e-03f, 1.02810577e-01f, -3.37346643e-02f, 3.57972085e-02f, 6.25528693e-02f, -2.50380319e-02f, -4.59531434e-02f, 4.03107554e-02f, -7.91123975e-03f,
  2.42161155e-01f, 4.91634727e-01f, 4.05525863e-02f, -2.41981894e-02f, 1.19632609e-01f, 4.60799364e-03f, 2.86728255e-02f, -8.02790225e-02f, 6.32644817e-02f, 3.66539545e-02f,
  1.06868716e-02f, 3.61125078e-03f, 6.14240468e-02f, -3.29935253e-02f, 2.85805436e-03f, 2.08709706e-02f, 8.16714615e-02f, 1.06788911e-01f, 5.37706576e-02f, 8.36977363e-02f,
  4.36317436e-02f, 9.11084637e-02f, -1.09092578e-01f, -7.60675818e-02f, -1.15456469e-02f, 4.87819612e-02f, 1.16241790e-01f, -3.94602269e-02f, -6.09095320e-02f, 4.08317186e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.37644447e-02f, -1.00635529e+00f, 5.18150389e-01f, 5.15912652e-01f, 8.84846896e-02f, -5.27034163e-01f, -8.45161155e-02f, -4.45988446e-01f, -5.00855565e-01f, -8.98605168e-01f,
  -1.53527781e-01f, 3.07448149e-01f, -2.65106916e-01f, 3.54107097e-02f, 1.11268973e+00f, 9.47297644e-03f, -2.98508294e-02f, 1.29485399e-01f, 7.34165758e-02f, -1.79028641e-02f,
  4.47425216e-01f, 2.08331406e-01f, 7.23888814e-01f, -5.76586463e-02f, 3.22689749e-02f, 9.31150615e-02f, 4.85110432e-01f, 3.22429150e-01f, 2.28321984e-01f, 3.14365894e-01f,
  -4.80772138e-01f, -6.06960990e-02f, -3.86769325e-03f, -1.03276797e-01f, -2.09056392e-01f, -6.00296520e-02f, 1.44592658e-01f, 2.13668957e-01f, 1.20691486e-01f, -9.74414498e-02f,
  -2.09591025e-03f, 5.87182380e-02f, -4.15717959e-02f, 1.08335942e-01f, -1.59483925e-01f, -1.03046648e-01f, -1.35793731e-01f, -1.24385186e-01f, -1.53292548e-02f, 4.59216498e-02f,
  -2.89341062e-02f, -8.78984705e-02f, 6.20448701e-02f, 5.63111342e-02f, 2.23599032e-01f, -7.66243711e-02f, 1.10418208e-01f, 1.81918696e-01f, -8.53056982e-02f, -5.22993915e-02f,
  1.34640828e-01f, 3.59438248e-02f, -4.40726355e-02f, -1.27094695e-02f, -3.96731943e-02f, 5.12140431e-02f, 2.24412475e-02f, 5.92606440e-02f, 1.37638584e-01f, -1.45640507e-01f,
  -1.07629903e-01f, 9.42947492e-02f, -8.37147515e-03f, -1.27808481e-01f, 3.00760176e-02f, -8.75681341e-02f, 8.49458799e-02f, -6.16949052e-03f, -6.08480796e-02f, 2.58241817e-02f,
  5.54476827e-02f, -7.49148428e-02f, -1.09160319e-01f, 3.22714746e-02f, -1.62879989e-01f, 8.25191364e-02f, -1.12156995e-01f, -1.52046412e-01f, 2.70070974e-02f, 2.60527819e-01f,
  -7.38978863e-01f, -2.46397197e-01f, -3.99224013e-02f, -1.34423882e-01f, 4.92222421e-02f, -3.29861008e-02f, 1.49136499e-01f, -8.22820365e-02f, -6.95256591e-02f, 1.20822443e-02f,
  -5.81560880e-02f, 4.26385067e-02f, -6.87471405e-02f, 5.12521714e-03f, 1.75946280e-01f, -2.66120080e-02f, 5.19804843e-02f, -2.40228325e-02f, 1.10867806e-01f, -3.54383998e-02f,
  -3.15233804e-02f, -5.39589557e-04f, 1.51895359e-01f, 7.00915158e-02f, 3.21959145e-02f, 2.52324026e-02f, 2.91179791e-02f, -2.05571838e-02f, 4.76524681e-02f, 9.65896696e-02f,
  3.12881082e-01f, -3.59535456e-01f, -6.77999973e-01f, -4.54689950e-01f, -1.61938757e-01f, -7.38832772e-01f, -5.21004796e-01f, -2.12324932e-01f, 7.67002478e-02f, 2.85793096e-01f,
  4.73493785e-02f, -3.78098786e-02f, 6.02063060e-01f, -6.05108738e-01f, -4.90247577e-01f, 2.20587105e-01f, -8.14744592e-01f, -3.77210766e-01f, 1.30162686e-01f, -1.83062404e-01f,
  -7.73937330e-02f, -1.22182213e-01f, -4.31425452e-01f, 1.38251305e-01f, -2.81533450e-01f, 8.20520893e-02f, 4.51469004e-01f, 1.56719491e-01f, -3.65184307e-01f, -4.20257747e-02f,
  -2.17654526e-01f, 1.84033886e-01f, -1.76752955e-01f, -7.37674832e-02f, -2.17420131e-01f, 8.60176235e-02f, -9.06906724e-02f, -2.70516817e-02f, 1.42753422e-01f, -3.69849391e-02f,
  7.18842894e-02f, 2.45196745e-01f, -1.18394405e-01f, 1.22663163e-01f, 1.44164652e-01f, -7.01270029e-02f, -2.84898654e-02f, -2.54538327e-01f, -1.49678458e-02f, -9.75563936e-03f,
  -2.11156279e-01f, -1.02371804e-01f, -7.93638006e-02f, -1.93658024e-02f, -1.80276986e-02f, -1.73676421e-03f, -2.33616769e-01f, -4.38565537e-02f, 1.58314090e-02f, -6.74541742e-02f,
  9.23331380e-02f, 1.00513324e-01f, 5.20175733e-02f, 8.99891853e-02f, -8.52752775e-02f, 3.46353352e-02f, 1.50793552e-01f, 2.49564368e-02f, 7.79540464e-02f, -4.68484759e-02f,
  -4.73560058e-02f, -3.34079601e-02f, 7.36019388e-02f, -3.68198417e-02f, -4.09296416e-02f, 3.73227037e-02f, 1.51583366e-02f, 6.48743147e-03f, -1.94071859e-01f, -1.55326992e-01f,
  1.93011984e-01f, -6.48044795e-02f, -9.83716547e-02f, 1.03572659e-01f, -1.55458048e-01f, -5.95127605e-03f, 1.65389329e-02f, -1.53302163e-01f, 5.83163388e-02f, -2.46036127e-02f,
  -2.19918445e-01f, 1.79157630e-02f, 2.04868391e-02f, 2.45543439e-02f, -3.70940976e-02f, -1.54563002e-02f, -9.61025283e-02f, -2.22679704e-01f, 3.15248929e-02f, 2.63794530e-02f,
  -1.52771831e-01f, -3.88777792e-03f, -2.98085418e-02f, 1.47907417e-02f, -6.88148141e-02f, -2.20851585e-01f, 1.19460136e-01f, 1.52900502e-01f, -6.26970306e-02f, -2.42733229e-02f,
  1.57754928e-01f, 1.97794825e-01f, 8.36176872e-02f, 8.83284882e-02f, 4.11607102e-02f, 8.19071755e-02f, 2.51044352e-02f, -1.30300578e-02f, 4.54908200e-02f, 1.07176916e-03f,
  9.63859141e-01f, -5.22664130e-01f, -1.50248691e-01f, 7.33878732e-01f, 4.64778423e-01f, -1.40776694e-01f, -9.05875266e-02f, 1.48917764e-01f, 3.25757086e-01f, -2.61231333e-01f,
  4.70439404e-01f, -4.34456944e-01f, -2.32701778e-01f, 3.71612668e-01f, 3.00958395e-01f, -2.28652060e-01f, 2.83459723e-01f, -1.52522340e-01f, -2.37327926e-02f, 3.27622801e-01f,
  3.53148401e-01f, 5.13456523e-01f, -4.45251465e-02f, -3.25476145e-03f, 2.02015638e-01f, -1.56749897e-02f, -1.92508101e-01f, -3.31716716e-01f, -4.58999723e-02f, -1.22450836e-01f,
  1.35967910e-01f, 1.69720069e-01f, -9.22735874e-03f, -1.19579926e-01f, 1.47950679e-01f, -1.45469066e-02f, -1.45715758e-01f, -2.47203708e-02f, -4.49774116e-02f, -4.19381410e-02f,
  -1.13848425e-01f, -5.04899286e-02f, 1.00642525e-01f, -8.25316086e-03f, 1.60118908e-01f, 4.23883796e-02f, 7.80413719e-03f, -1.22632533e-02f, -1.18082948e-01f, 2.19083559e-02f,
  -7.23214471e-05f, 4.65065613e-03f, 1.69209242e-01f, -1.98874503e-01f, 1.43479798e-02f, 1.80604115e-01f, -3.52423564e-02f, -1.64632455e-01f, -1.06612287e-01f, -6.30376860e-02f,
  -3.40192486e-03f, -2.67324261e-02f, 1.45883530e-01f, -5.77739626e-02f, -2.61840373e-02f, 1.22869439e-01f, -3.87277454e-02f, -1.49590284e-01f, -6.36514351e-02f, 5.89249842e-03f,
  -2.71934383e-02f, 4.58939150e-02f, 1.45053834e-01f, -6.54277354e-02f, 4.87493351e-02f, -1.85949638e-01f, -9.32074804e-03f, -1.12882210e-02f, 1.88584581e-01f, -1.89773157e-01f,
  -1.24591671e-01f, -6.09029084e-02f, 4.41095196e-02f, -1.27550587e-01f, -1.40306488e-01f, 3.20520885e-02f, 9.21862647e-02f, 9.91849750e-02f, 1.27339244e-01f, -3.40942703e-02f,
  -2.38985747e-01f, -4.49869990e-01f, -1.09428763e-01f, -1.56391487e-01f, -1.39515907e-01f, 1.53199390e-01f, 8.56528655e-02f, 6.37056828e-02f, -2.65384048e-01f, 8.86769816e-02f,
  1.81055218e-01f, -1.07930690e-01f, 1.47634342e-01f, 9.86768231e-02f, -1.27372026e-01f, 1.02949142e-01f, -5.43903001e-02f, -1.09790646e-01f, -1.07886873e-01f, -1.18571557e-01f,
  -7.23985210e-02f, 2.73647532e-02f, -7.31106400e-02f, 3.62966843e-02f, 7.38071501e-02f, -1.24361485e-01f, 2.06474829e-02f, 7.51886591e-02f, 5.70437387e-02f, -1.09742515e-01f,
  -6.00837409e-01f, 5.92476130e-01f, 2.52380967e-01f, -8.42763484e-02f, -4.18802015e-02f, 2.13023454e-01f, 2.83250585e-02f, 5.05454481e-01f, 5.23237646e-01f, 2.65350878e-01f,
  -1.74390525e-01f, 3.42880338e-01f, 4.01514471e-01f, -4.65638377e-02f, -2.46517271e-01f, 1.70206249e-01f, -3.53421330e-01f, -1.74406394e-01f, 3.78882080e-01f, 5.50045073e-02f,
  -1.17037557e-01f, -9.57409889e-02f, -3.04169625e-01f, 4.47549760e-01f, -2.37306654e-01f, -3.94534692e-02f, -6.92562699e-01f, 2.57253110e-01f, -4.27140445e-01f, -1.48850441e-01f,
  -4.67924327e-01f, 1.76309034e-01f, -2.22483113e-01f, -7.33899325e-02f, -3.67632121e-01f, -1.02561980e-01f, -2.00187609e-01f, -7.53918663e-02f, -2.67231866e-04f, 6.92453384e-02f,
  7.71551579e-02f, 1.70101687e-01f, -1.16002761e-01f, 1.29909039e-01f, 1.31250650e-01f, 5.67877032e-02f, -1.80048764e-01f, -1.35409847e-01f, 2.10952431e-01f, -1.63500439e-02f,
  2.46829271e-01f, -3.31336521e-02f, -2.35682875e-01f, -2.02530965e-01f, -2.25942791e-01f, -1.61148924e-02f, -1.00813068e-01f, -3.13246816e-01f, -7.81428590e-02f, 1.37843909e-02f,
  1.91983625e-01f, -8.10155943e-02f, -5.71385399e-02f, 3.97447646e-02f, 1.62462845e-01f, -3.71924452e-02f, 1.70108974e-01f, -1.41463965e-01f, 4.86204587e-02f, -1.13060206e-01f,
  -1.30313531e-01f, -1.31345466e-01f, 5.90503141e-02f, -9.37017649e-02f, 1.98780596e-02f, 3.69477943e-02f, -1.62133515e-01f, 3.08582820e-02f, -5.79920895e-02f, -1.67800650e-01f,
  1.31453142e-01f, -1.00928552e-01f, 5.26353307e-02f, -2.36874372e-01f, 7.89902732e-02f, -3.41367312e-02f, -8.63916874e-02f, 6.11226708e-02f, 2.72993203e-02f, -1.03781067e-01f,
  -5.97128034e-01f, -2.84955233e-01f, -1.34557188e-02f, 8.61065239e-02f, -4.81052771e-02f, -1.17457397e-01f, 5.72197326e-03f, -3.63398306e-02f, -7.85582811e-02f, 1.33778438e-01f,
  -6.35067597e-02f, -7.07145259e-02f, -1.58872873e-01f, -4.34477702e-02f, 7.17080906e-02f, -1.21633507e-01f, -1.06361695e-01f, -2.90077198e-02f, -2.04183981e-01f, -1.00418039e-01f,
  6.11669035e-04f, 1.09164994e-02f, -2.75825653e-02f, -3.54130939e-02f, -1.92197800e-01f, -1.55298471e-01f, -5.00129536e-02f, 4.14941795e-02f, -2.14666262e-01f, 1.06782075e-02f,
  6.30709291e-01f, 1.08791903e-01f, -1.46025896e-01f, 7.89966583e-01f, 5.50454497e-01f, 1.86422952e-02f, 4.42175902e-02f, 5.56528389e-01f, 7.58004129e-01f, -4.15848315e-01f,
  6.39104918e-02f, -3.81803781e-01f, -7.45279133e-01f, 4.83983397e-01f, 6.68677866e-01f, -2.32707217e-01f, 8.39101851e-01f, 1.07939310e-01f, 3.80016893e-01f, 2.03088477e-01f,
  5.07767797e-01f, 5.62806666e-01f, 2.41129268e-02f, 3.00384611e-01f, 1.82458580e-01f, 1.63337812e-01f, 3.51963006e-03f, -2.04098165e-01f, -2.50372496e-02f, 1.07628904e-01f,
  3.06755118e-02f, 3.25951785e-01f, -4.18511070e-02f, -5.58096319e-02f, 5.30211441e-02f, -4.03803699e-02f, -8.51994231e-02f, -1.64980382e-01f, 8.52402970e-02f, -1.20463967e-01f,
  -1.45669520e-01f, 5.13731614e-02f, 1.14850745e-01f, -4.67616096e-02f, 1.82769462e-01f, 1.31181195e-01f, 2.16473509e-02f, -8.43082741e-02f, 1.09367282e-03f, -6.13219291e-02f,
  -4.11651582e-02f, 1.35640809e-02f, 1.67622954e-01f, 1.16080664e-01f, 8.63215625e-02f, 2.25995883e-01f, -3.00741987e-03f, -1.16190627e-01f, -9.68070775e-02f, 3.03969860e-01f,
  3.34204026e-02f, -4.39493135e-02f, -1.35158505e-02f, -1.01658754e-01f, 9.51610878e-02f, 8.74952972e-02f, -3.08148060e-02f, -3.51230577e-02f, 1.15886383e-01f, 3.96635644e-02f,
  9.40073803e-02f, 3.88895087e-02f, 1.59064412e-01f, -3.10739153e-03f, 1.13682427e-01f, 1.31898090e-01f, -3.72827202e-02f, -1.08651787e-01f, 5.29780574e-02f, 4.82063629e-02f,
  5.24491929e-02f, 1.91041544e-01f, -2.41206452e-01f, -2.03220956e-02f, 1.56513005e-01f, -7.86083639e-02f, -4.94721569e-02f, -6.98631331e-02f, -1.54905915e-01f, -6.87315091e-02f,
  2.24595413e-01f, 4.96054322e-01f, -1.09434566e-02f, -4.28213645e-03f, -4.98156026e-02f, 6.93505108e-02f, 6.62811100e-02f, 1.75890431e-01f, 2.78788567e-01f, 7.59047568e-02f,
  5.94770275e-02f, 5.66424876e-02f, -1.26864761e-01f, -3.68820503e-02f, -5.05678207e-02f, 3.52402888e-02f, -7.07134185e-03f, 9.99066681e-02f, 2.03090951e-01f, 6.43957630e-02f,
  -1.41596943e-01f, -6.86519891e-02f, 2.78093051e-02f, 2.24292278e-01f, 6.05174806e-03f, -1.37033895e-01f, 5.64794764e-02f, 1.18115041e-02f, -8.56718272e-02f, 3.34599130e-02f,
  -1.76411361e-01f, -2.53937356e-02f, 1.76419914e-01f, -8.23234677e-01f, 5.59620447e-02f, 3.31211030e-01f, -6.03310645e-01f, 5.68014830e-02f, -6.29959285e-01f, -2.76067466e-01f,
  -5.24309337e-01f, -4.11909640e-01f, -7.56948814e-02f, -6.09776855e-01f, 3.29307348e-01f, 7.35105947e-02f, -3.27268869e-01f, -5.40976048e-01f, -1.41645214e-02f, -3.19279879e-01f,
  -1.68068752e-01f, -4.98357296e-01f, 1.17773861e-02f, 5.76592935e-03f, -3.75958294e-01f, -5.63232377e-02f, 1.73941955e-01f, 1.40308971e-02f, -1.28957108e-01f, -1.83286697e-01f,
  8.91435798e-03f, -2.44542018e-01f, -2.03030810e-01f, 3.41661721e-02f, 1.13875188e-01f, 9.75343883e-02f, -5.91703970e-03f, -1.07597280e-02f, -3.96700874e-02f, 6.46293676e-03f,
  5.49710132e-02f, 1.88101023e-01f, -1.78419515e-01f, -5.37020043e-02f, -4.31471355e-02f, -2.32173447e-02f, 1.34762764e-01f, -1.61893256e-02f, 7.00770121e-04f, 1.18413337e-01f,
  1.61406659e-02f, 2.33119205e-01f, 5.62912859e-02f, -3.86267975e-02f, -9.47515517e-02f, -3.12370583e-02f, 7.50850439e-02f, 8.17492753e-02f, -3.42577649e-03f, 6.44065663e-02f,
  -2.84142476e-02f, 1.05965331e-01f, 1.06614985e-01f, -6.40074760e-02f, -3.86770703e-02f, 1.57013610e-02f, 2.54655331e-02f, -2.46445630e-02f, -2.04360075e-02f, 1.26451537e-01f,
  -8.71217623e-02f, -1.65088512e-02f, -1.18895985e-01f, 7.92671647e-03f, 6.01005964e-02f, 5.49948849e-02f, 3.30811292e-02f, 9.76055302e-03f, -4.22748774e-02f, 5.92763908e-02f,
  -1.45368561e-01f, 1.37512051e-02f, -1.12074338e-01f, -8.55583921e-02f, 1.06561281e-01f, 1.07875979e-02f, -4.28761542e-02f, 1.23627454e-01f, 4.84233834e-02f, -2.63069738e-02f,
  5.75941689e-02f, -3.89033705e-02f, -1.98254362e-01f, -2.02289581e-01f, -9.26939547e-02f, 1.58009440e-01f, -5.97962998e-02f, -4.01018113e-02f, -2.39497889e-02f, -2.39468012e-02f,
  1.20987177e-01f, -5.48165999e-02f, 1.39946476e-01f, -6.53330563e-03f, -5.76891229e-02f, -5.62360398e-02f, -1.41376987e-01f, -9.82878581e-02f, 3.50327566e-02f, 1.32047921e-01f,
  -7.73147389e-04f, -1.52960671e-02f, -5.75673729e-02f, 2.93181334e-02f, -1.12327926e-01f, 6.94244280e-02f, 7.88793191e-02f, -2.14778900e-01f, 5.82732297e-02f, -5.02144247e-02f,
  -2.80369461e-01f, 2.44141951e-01f, -4.77179646e-01f, 1.36574194e-01f, -3.30561310e-01f, -1.74768388e-01f, 1.66939795e-01f, -1.08239815e-01f, -3.80191863e-01f, 7.57003784e-01f,
  8.58721435e-01f, -5.09444594e-01f, 5.14782369e-01f, 1.04623830e+00f, -1.42796978e-01f, 7.06732333e-01f, 6.53273523e-01f, 4.69517708e-01f, -2.56082743e-01f, 6.37914985e-02f,
  -9.83256772e-02f, 6.28831267e-01f, 5.25630951e-01f, -1.25780264e-02f, 2.03705013e-01f, -3.87175769e-01f, 4.09718722e-01f, -3.05681050e-01f, 2.97836900e-01f, -2.48337425e-02f,
  1.26029253e-01f, 1.04720637e-01f, 5.12785241e-02f, -1.70882240e-01f, 1.19941812e-02f, -1.33737952e-01f, -6.14773594e-02f, -4.37868163e-02f, -2.09715679e-01f, -3.13615575e-02f,
  -1.96713626e-01f, -1.44772559e-01f, 6.37214854e-02f, 5.70452921e-02f, -2.32553646e-01f, -1.39447793e-01f, -4.42074463e-02f, -3.02902143e-02f, -3.93719487e-02f, -2.35874858e-02f,
  -6.50460795e-02f, 7.03239143e-02f, -2.88345423e-02f, 7.62590766e-02f, -1.70392200e-01f, -1.03500351e-01f, -7.64738619e-02f, -4.13759984e-02f, -4.63587269e-02f, -1.46498829e-01f,
  1.48698390e-02f, 5.30657098e-02f, 1.02653004e-01f, 9.21955481e-02f, 3.85431983e-02f, 1.10810503e-01f, 1.08378336e-01f, 1.22935288e-01f, -5.63373789e-02f, 9.92671922e-02f,
  1.02640679e-05f, -8.92037153e-02f, 9.15837195e-03f, -8.55091512e-02f, 6.06714748e-02f, 6.24122135e-02f, -5.60105313e-03f, 9.37682092e-02f, 1.48438262e-02f, 6.91534430e-02f,
  3.45955975e-02f, -1.12423845e-01f, 9.38986763e-02f, 1.09116584e-01f, 5.54156937e-02f, -1.41114593e-01f, 1.66052561e-02f, 6.32472485e-02f, 8.31830949e-02f, -1.09306484e-01f,
  1.23052277e-01f, 6.18551187e-02f, 1.61448941e-02f, -1.38812661e-01f, 5.41252941e-02f, -5.74290566e-02f, -7.36909499e-03f, -5.87637313e-02f, 6.57777935e-02f, -9.26088169e-02f,
  1.56820975e-02f, 1.94111001e-02f, -6.76583722e-02f, 4.15013954e-02f, -1.58925146e-01f, 3.95151414e-02f, 6.37620017e-02f, -1.10597432e-01f, -2.47297678e-02f, -2.68464144e-02f,
  1.44961970e-02f, -9.63961184e-02f, -1.10505782e-01f, 1.33399544e-02f, 1.30487680e-02f, 1.14438385e-01f, -1.50201395e-01f, -9.54538025e-03f, -1.49344909e-03f, 1.27209917e-01f,
  -7.12934911e-01f, 6.16586268e-01f, 3.50772142e-01f, 5.71116731e-02f, -3.08549881e-01f, 1.18388580e-02f, -1.38816968e-01f, 1.96691662e-01f, -3.70897949e-02f, 2.05654413e-01f,
  2.53449023e-01f, -1.71070874e-01f, 4.38411772e-01f, 1.96501479e-01f, 1.20596394e-01f, 4.57789660e-01f, 4.98517066e-01f, 1.99463710e-01f, 3.36293846e-01f, 5.66425383e-01f,
  5.09843230e-01f, 1.69611320e-01f, 5.57596207e-01f, 1.75180033e-01f, 2.94009656e-01f, 1.17092997e-01f, 3.81798893e-01f, 2.75944531e-01f, 3.77454281e-01f, -1.27430901e-01f,
  -2.47807037e-02f, -3.87224257e-02f, -3.87624651e-02f, -9.30347592e-02f, 3.44477057e-01f, -1.53553439e-02f, 7.32060075e-02f, -1.83968022e-01f, -1.27222836e-01f, 1.53515980e-01f,
  -1.66132241e-01f, -1.31865084e-01f, -4.35371958e-02f, -9.14859921e-02f, -1.96020767e-01f, -9.37274173e-02f, 6.03841282e-02f, 6.53752312e-02f, 4.16099913e-02f, -3.01089924e-04f,
  4.21150066e-02f, 4.35785837e-02f, 1.90823719e-01f, 2.13042080e-01f, 8.60222131e-02f, 7.59903900e-03f, 7.33574778e-02f, 1.65762037e-01f, -2.05951147e-02f, -7.47301877e-02f,
  1.21261656e-01f, -3.94444391e-02f, 3.27205062e-02f, -8.72598365e-02f, -7.20735863e-02f, 3.97572592e-02f, -9.49546620e-02f, -4.31771092e-02f, -4.42751311e-02f, -5.61765907e-03f,
  -1.33136287e-01f, 2.87912227e-02f, -7.51475692e-02f, -7.24124387e-02f, -1.15804404e-01f, -1.69004783e-01f, -8.27830583e-02f, -8.62924941e-03f, 5.71136624e-02f, -1.84136815e-02f,
  1.52621688e-02f, 3.87273505e-02f, 3.25639173e-02f, 8.51702765e-02f, -1.51622817e-01f, 1.06414638e-01f, 8.21199268e-02f, 2.08993554e-02f, 1.32185919e-03f, 1.13159716e-01f,
  4.13442641e-01f, 6.03622079e-01f, 1.87953040e-02f, -1.39152974e-01f, -3.21363434e-02f, 1.53099209e-01f, 6.74488544e-02f, 1.15930349e-01f, 2.88123995e-01f, 2.19291091e-01f,
  9.36868489e-02f, 9.84947570e-03f, 1.06999204e-02f, -1.51993051e-01f, 1.39107779e-02f, 3.19854975e-01f, 3.41887772e-02f, 2.72642542e-02f, 2.71762311e-02f, 1.62307590e-01f,
  1.09935984e-01f, -4.58422257e-03f, 2.38241926e-02f, -5.57297543e-02f, -1.66093811e-01f, 3.85362916e-02f, -1.36362180e-01f, -5.62392026e-02f, 5.19693233e-02f, 3.69855352e-02f,
  4.51105326e-01f, -4.34231818e-01f, -7.09073186e-01f, -2.81167358e-01f, 3.03827524e-01f, 5.39530933e-01f, -2.40855381e-01f, 5.92762753e-02f, -8.00420046e-01f, -6.56172708e-02f,
  2.96125591e-01f, -2.70303283e-02f, -5.13078749e-01f, 2.78245389e-01f, 5.26638210e-01f, -5.99248588e-01f, 2.19083682e-01f, 2.42408365e-01f, -2.69515187e-01f, 2.78592587e-01f,
  5.49202487e-02f, 6.60702884e-01f, -7.80819356e-02f, 4.55208927e-01f, 3.56761813e-01f, 1.66310012e-01f, 5.54237723e-01f, 1.42648920e-01f, 7.55725145e-01f, 4.85812128e-01f,
  -8.90843123e-02f, -7.04518184e-02f, -1.05841175e-01f, -1.39422163e-01f, 4.89616357e-02f, 1.07337810e-01f, 2.08558604e-01f, 2.49973834e-01f, -6.24195114e-02f, 9.13405567e-02f,
  1.26648664e-01f, -1.55725349e-02f, -7.56866392e-03f, 3.54794189e-02f, 4.79934588e-02f, 1.00713141e-01f, -1.93050243e-02f, -6.89630806e-02f, -1.04419433e-01f, 4.03655916e-02f,
  -2.66901404e-01f, -9.63953212e-02f, -2.79010944e-02f, -1.26736671e-01f, -1.10245541e-01f, -8.64243656e-02f, -1.41322762e-01f, 1.10026076e-01f, 1.71029828e-02f, 1.15395367e-01f,
  2.77481616e-01f, -3.59951742e-02f, -2.94826794e-02f, -1.43004730e-01f, -3.37640196e-02f, -1.22419804e-01f, 1.76753327e-02f, 1.99185126e-02f, -2.25279629e-02f, -9.72759444e-03f,
  -1.24763817e-01f, 1.21293575e-01f, 5.21945991e-02f, -3.79354097e-02f, 1.09400503e-01f, -1.48491636e-02f, 8.00210238e-02f, 6.54885992e-02f, -1.95398644e-01f, -8.65610018e-02f,
  -1.09583065e-01f, 8.93984064e-02f, 4.51727584e-03f, -5.50906882e-02f, -4.66355607e-02f, 3.52751203e-02f, 1.37219757e-01f, 5.99181764e-02f, -7.74807036e-02f, 6.25744835e-02f,
  1.02580078e-01f, 3.24804097e-01f, -1.16953842e-01f, 1.08297169e-01f, -1.27173513e-01f, 1.80774495e-01f, -1.31366864e-01f, 6.59498945e-02f, 2.92862467e-02f, 8.31188709e-02f,
  1.40270084e-01f, -1.10112190e-01f, 9.41379555e-03f, 2.39076447e-02f, 3.37284356e-02f, -5.34233190e-02f, -6.86910674e-02f, 2.56755874e-02f, 9.21345688e-03f, 1.11387260e-01f,
  8.14557001e-02f, 1.33422941e-01f, -4.18538861e-02f, -1.30935758e-01f, -1.76878809e-03f, -2.11391281e-02f, 1.12561293e-01f, -4.89289127e-02f, 1.79742455e-01f, -1.10178620e-01f,
  3.87832671e-01f, -3.62204641e-01f, 5.67024231e-01f, -1.58781052e-01f, 5.70032299e-01f, 6.43215001e-01f, 9.22152579e-01f, -7.80633837e-02f, 3.14662755e-01f, -6.75191164e-01f,
  -2.66293913e-01f, -1.78180665e-01f, 3.83368224e-01f, -5.64120233e-01f, 8.54539990e-01f, 5.99316478e-01f, 1.70259960e-02f, -2.07597405e-01f, 1.72309324e-01f, -1.09672777e-01f,
  -5.09439595e-02f, -5.29441833e-01f, 2.02614978e-01f, -5.50119936e-01f, -7.64798671e-02f, -3.29284251e-01f, -5.24248600e-01f, 3.76673907e-01f, -7.03809798e-01f, 2.04460397e-01f,
  1.62406459e-01f, 5.29044308e-02f, 1.28284186e-01f, -1.37142418e-02f, -7.14262342e-03f, 1.10925734e-01f, 8.12543090e-03f, 3.13248277e-01f, 2.05388993e-01f, -7.78513551e-02f,
  -4.76014987e-02f, -1.71878338e-01f, -2.24630818e-01f, 2.77787782e-02f, 3.51364678e-03f, -1.75078303e-01f, 4.91859913e-02f, 1.47044761e-02f, -6.92545399e-02f, 1.17902748e-01f,
  2.08832413e-01f, -8.65797326e-02f, 4.20841314e-02f, -8.68088752e-02f, 1.06465228e-01f, -7.57711530e-02f, 1.25568375e-01f, 2.54116684e-01f, 3.53257358e-02f, 5.05439192e-02f,
  -1.11864269e-01f, 2.27333441e-01f, 1.22108266e-01f, -6.84443787e-02f, 7.71650001e-02f, -5.06793857e-02f, -1.37868240e-01f, -6.32643029e-02f, 8.76587778e-02f, -3.42812315e-02f,
  -7.27815703e-02f, -1.19349912e-01f, 1.22822493e-01f, 1.02056749e-01f, -5.50924912e-02f, -1.34947866e-01f, 2.66573168e-02f, -2.32746676e-02f, 4.35719639e-02f, 2.42068805e-02f,
  4.88021448e-02f, 8.52847025e-02f, -7.34961708e-04f, 2.38554305e-04f, -9.84014124e-02f, 6.00088313e-02f, -2.07203627e-01f, 4.66775037e-02f, 7.71376789e-02f, 6.69992864e-02f,
  8.10041502e-02f, -1.67713255e-01f, -2.88881664e-03f, -2.31952891e-01f, -2.38863919e-02f, -1.08345300e-01f, 8.09582025e-02f, -8.59816745e-02f, 2.23962329e-02f, 3.48186940e-02f,
  -3.33337188e-01f, -1.34205297e-01f, -2.86487397e-03f, -5.64402975e-02f, -1.54802024e-01f, 4.90329042e-03f, 6.52997345e-02f, -1.69799611e-01f, 2.37945039e-02f, -2.14635938e-01f,
  -1.70817599e-01f, 6.39097989e-02f, 1.34075796e-02f, -1.44958764e-01f, -2.08149448e-01f, -4.85844798e-02f, 3.03503405e-02f, -5.14097512e-02f, 7.08407070e-03f, 9.55639931e-04f,
  3.25340986e-01f, 5.46508789e-01f, 1.82426602e-01f, 2.29897290e-01f, -6.49050236e-01f, -2.21374542e-01f, -2.96125054e-01f, -2.14710400e-01f, 5.11797011e-01f, 1.95189774e-01f,
  -6.82557404e-01f, 7.02099502e-01f, -3.76276314e-01f, -1.65773794e-01f, -1.23664930e-01f, 9.18576643e-02f, 1.08820289e-01f, 2.68780619e-01f, 9.97550339e-02f, 2.41878089e-02f,
  6.63711205e-02f, -5.58140576e-01f, -4.41797107e-01f, -5.51049531e-01f, -2.87700504e-01f, 2.24968284e-01f, -3.63178551e-01f, -3.85547161e-01f, -3.77441421e-02f, -3.04665864e-01f,
  -2.91320801e-01f, 4.68451008e-02f, -4.86008190e-02f, 1.84690803e-01f, 2.82893013e-02f, -2.88177785e-02f, 3.78789231e-02f, -1.67243436e-01f, -6.65172786e-02f, 1.99662566e-01f,
  1.76664039e-01f, -4.73295003e-02f, 1.71302810e-01f, -8.84240270e-02f, 6.37523131e-03f, 5.45244105e-02f, 6.86287954e-02f, 4.00785692e-02f, 5.98641038e-02f, -1.33550003e-01f,
  5.25659956e-02f, 9.30016935e-02f, 1.78560719e-03f, 2.33622745e-01f, 7.66894966e-02f, 3.61009850e-04f, 1.76153123e-01f, -3.45438570e-02f, 2.69647837e-01f, 1.20735541e-01f,
  7.00919330e-02f, 1.52513534e-01f, -2.13408805e-02f, -1.10514328e-01f, -1.02985024e-01f, -1.20386265e-01f, 2.27087513e-02f, -1.42463058e-01f, 1.10975474e-01f, -2.31426675e-02f,
  -1.03232220e-01f, 2.21771393e-02f, -5.47956787e-02f, 7.98397288e-02f, -4.77879792e-02f, 1.04715675e-01f, 1.69232320e-02f, 5.79015464e-02f, 1.63252577e-01f, -7.38533661e-02f,
  -9.77761671e-02f, 2.42405552e-02f, -4.72504944e-02f, -1.31236747e-01f, -1.05577983e-01f, -8.74859542e-02f, 8.37530419e-02f, 6.63985088e-02f, -4.07462642e-02f, -9.96942297e-02f,
  1.95598885e-01f, 5.50050795e-01f, 8.84773657e-02f, -6.99231848e-02f, 2.59927800e-03f, 5.81807047e-02f, 1.39722265e-02f, 1.19793460e-01f, 1.32536903e-01f, -7.49725401e-02f,
  -5.40320538e-02f, -4.72597480e-02f, 1.85857430e-01f, -6.01743460e-02f, 4.48002852e-03f, -6.25508663e-04f, 1.18284233e-01f, 1.93759993e-01f, 4.80645746e-02f, -5.43979043e-03f,
  -3.08910832e-02f, 1.71806648e-01f, 4.17884849e-02f, 3.03594675e-02f, 1.18046001e-01f, 9.25584882e-02f, 1.28352299e-01f, 1.28615811e-01f, -3.80380787e-02f, 7.36587867e-02f,
  -2.17904091e-01f, 1.67370103e-02f, -4.17094737e-01f, -1.33717626e-01f, 1.51633263e-01f, 1.02132797e+00f, 3.67489725e-01f, -8.84262845e-02f, -1.66717947e-01f, 5.08900940e-01f,
  1.01006523e-01f, -1.84318349e-01f, -3.59105259e-01f, 3.55008811e-01f, -1.04700103e-01f, 1.49399200e-02f, 6.07714891e-01f, 3.67165685e-01f, -2.54582405e-01f, 4.34371606e-02f,
  -1.38502032e-01f, 4.66060549e-01f, -4.43952411e-01f, 2.08753780e-01f, -4.14799862e-02f, -1.98668897e-01f, 1.72060803e-02f, -2.71661490e-01f, 3.26868773e-01f, 3.72736007e-02f,
  9.38119888e-02f, -2.63854146e-01f, -2.38840923e-01f, 1.71203427e-02f, 8.05397518e-03f, 1.04833513e-01f, 1.36037230e-01f, -6.57306314e-02f, -2.76778579e-01f, -1.12883165e-01f,
  -8.26466538e-04f, -1.73081979e-01f, -5.15618026e-02f, -1.70403078e-01f, 9.25792661e-03f, -8.73580575e-03f, -2.76726484e-01f, -1.46190643e-01f, -7.14874044e-02f, -2.12983355e-01f,
  -2.48261839e-01f, -1.36353940e-01f, 3.54310386e-02f, 7.81916082e-02f, -3.73878554e-02f, 3.91312651e-02f, 1.34816006e-01f, -1.34308249e-01f, 1.53755337e-01f, 7.53614455e-02f,
  1.12053633e-01f, 2.79076099e-01f, 1.07141308e-01f, 5.97273046e-03f, -5.66379093e-02f, 5.53099215e-02f, 3.99370007e-02f, -1.99494921e-02f, -1.10053018e-01f, 5.03310710e-02f,
  -2.63524130e-02f, -1.64011881e-01f, -8.84879753e-02f, 8.93819556e-02f, 5.61300665e-02f, -5.69060929e-02f, -1.54153913e-01f, -7.67540038e-02f, -4.58036214e-02f, -6.04431406e-02f,
  -8.98521990e-02f, 8.18949565e-02f, 3.82632427e-02f, -7.53778592e-02f, 3.41806151e-02f, -1.30908325e-01f, 1.15409875e-02f, -5.00504114e-02f, -1.13455784e-02f, 2.26583648e-02f,
  2.20411912e-01f, 4.28060293e-01f, 1.95358787e-02f, -4.68148366e-02f, -2.80792620e-02f, 1.39250115e-01f, 1.37667060e-01f, 1.05216270e-02f, 1.78556040e-01f, 4.42053042e-02f,
  1.01282634e-01f, 6.43277094e-02f, 2.49191731e-01f, -8.21043998e-02f, 4.30607945e-02f, 1.52782083e-01f, 1.98714092e-01f, -5.13048144e-03f, 9.92404521e-02f, 2.21979115e-02f,
  1.35283545e-01f, 2.99963385e-01f, 7.73527920e-02f, 6.29990026e-02f, 1.30136430e-01f, 1.19915875e-02f, 1.66520640e-01f, 7.41164619e-03f, -9.64985192e-02f, 4.46597561e-02f,
  -8.66024196e-01f, 6.47945762e-01f, -1.26923993e-02f, -4.95847851e-01f, 4.77832288e-01f, -2.86104560e-01f, -2.68612444e-01f, 4.17625844e-01f, -2.74954140e-01f, 6.07361853e-01f,
  1.60042718e-02f, -6.79629222e-02f, -2.22225226e-02f, -3.62468392e-01f, -1.19278347e+00f, -7.57659256e-01f, -5.67671716e-01f, -1.98846266e-01f, -3.61127913e-01f, 5.03182970e-02f,
  -3.84883761e-01f, -1.93602175e-01f, -3.75737488e-01f, 4.48894411e-01f, 3.85087371e-01f, 4.59836274e-01f, 1.30764306e-01f, 5.34466147e-01f, 2.39877954e-01f, -4.67601605e-02f,
  -7.93977529e-02f, 1.37892932e-01f, 2.99265981e-01f, 1.84135251e-02f, 2.36482956e-02f, 1.59807444e-01f, 1.62403256e-01f, 4.02238499e-03f, -1.23499289e-01f, -2.94445660e-02f,
  4.54293266e-02f, -9.73058417e-02f, -1.29379928e-01f, -6.72118738e-02f, 1.79852679e-01f, 1.79605857e-02f, 9.50831920e-02f, 1.16436735e-01f, 1.54580638e-01f, 4.77182399e-03f,
  -2.65125204e-02f, 4.89648711e-03f, -6.12154901e-02f, -1.93639994e-01f, -5.71515709e-02f, 4.60420698e-02f, -1.91556945e-01f, 3.11312117e-02f, -3.58960754e-03f, -1.99269913e-02f,
  -1.35445207e-01f, 4.86566499e-02f, 5.42098247e-02f, -9.74166840e-02f, -8.45460072e-02f, 1.42247900e-01f, -1.07278995e-01f, -7.88680464e-02f, 4.41218913e-02f, -4.23930436e-02f,
  9.16184410e-02f, 5.23069054e-02f, 8.87810588e-02f, -4.38332669e-02f, 2.20419988e-02f, -1.32570073e-01f, 8.72144327e-02f, 1.31566837e-01f, 1.86616499e-02f, -2.11114828e-02f,
  3.84693369e-02f, -4.43671718e-02f, 8.40243101e-02f, -1.12195667e-02f, -1.84698701e-01f, -2.31344216e-02f, 4.36606109e-02f, 6.14363812e-02f, -5.22878766e-02f, -9.23536532e-03f,
  1.26746252e-01f, 2.11432561e-01f, 9.20072123e-02f, 1.23882934e-01f, 2.96958908e-02f, -1.30765485e-02f, -1.74006835e-01f, -1.83739159e-02f, -5.05546257e-02f, -1.00632951e-01f,
  4.58513908e-02f, 5.33010028e-02f, 3.42859440e-02f, -3.70170884e-02f, -1.06759869e-01f, 3.67326802e-03f, 7.79832760e-03f, 4.13424484e-02f, 1.23823382e-01f, 8.85714442e-02f,
  2.37163052e-01f, 4.63821553e-02f, -8.25944021e-02f, -8.84215608e-02f, -2.13757921e-02f, 2.38483325e-02f, 1.00469284e-01f, -2.38308981e-02f, 5.81533872e-02f, -6.11331537e-02f,
  9.59893942e-01f, 6.69329107e-01f, 6.54185593e-01f, 7.54976273e-01f, 1.81640312e-02f, -7.67017901e-01f, -1.24879584e-01f, 2.90117174e-01f, 4.35098022e-01f, -3.00210863e-01f,
  -4.04924184e-01f, 5.63382626e-01f, -4.03406620e-01f, 3.11948389e-01f, -4.40551341e-01f, -5.10355651e-01f, 2.91030556e-01f, 6.51449263e-02f, 6.24164790e-02f, 3.95886779e-01f,
  3.14975739e-01f, -4.30544257e-01f, 4.15406018e-01f, -2.08453387e-01f, 4.22552317e-01f, 4.61626261e-01f, -1.74668148e-01f, -1.96664840e-01f, 1.64908752e-01f, -1.66255474e-01f,
  5.58922924e-02f, 3.37513089e-01f, 2.96311021e-01f, 1.42752174e-02f, 1.26377994e-03f, 3.06923632e-02f, 1.32917970e-01f, -2.53191024e-01f, 6.63715135e-03f, 6.77709579e-02f,
  7.34716803e-02f, -4.64885905e-02f, -3.56985144e-02f, -1.48135096e-01f, 1.43876538e-01f, 9.00003240e-02f, 1.46518737e-01f, 1.93466231e-01f, 1.88950971e-01f, 2.13767186e-01f,
  1.48613587e-01f, 1.65072665e-01f, 1.55373245e-01f, 2.23597270e-02f, 5.31140938e-02f, -4.52099368e-02f, -3.34556289e-02f, -1.35774375e-03f, 1.28090456e-01f, 2.32961029e-01f,
  1.09578565e-01f, -1.48397535e-01f, -8.67209435e-02f, 1.94866769e-02f, -8.11527967e-02f, -6.13707080e-02f, -4.04895097e-02f, -1.16416216e-01f, 1.08881732e-02f, -6.18669093e-02f,
  -9.90736485e-02f, 1.53181314e-01f, -5.43993637e-02f, -2.00876929e-02f, 1.55064747e-01f, 1.15676224e-01f, -1.49043769e-01f, -1.23240218e-01f, 2.73621473e-02f, 7.43615106e-02f,
  -1.58882085e-02f, -1.19760975e-01f, -1.73328742e-02f, 5.75641319e-02f, -1.28254503e-01f, -9.44348201e-02f, 2.31166370e-02f, 1.65700242e-01f, -1.22176978e-04f, -4.19564061e-02f,
  -9.47790518e-02f, 5.21286838e-02f, -2.94878483e-02f, -4.66668345e-02f, -6.54947013e-02f, -6.98368698e-02f, -1.39561016e-02f, 1.04315601e-01f, -1.29863396e-01f, -9.47539359e-02f,
  3.89056429e-02f, 3.26693431e-02f, -6.76036030e-02f, -6.82225637e-03f, -5.93314581e-02f, -1.29688941e-02f, -1.11431912e-01f, -1.12165608e-01f, -1.13919722e-02f, -8.72807857e-03f,
  5.62810116e-02f, -1.26640409e-01f, 7.82255009e-02f, 7.89426640e-02f, -9.53363702e-02f, 3.91438901e-02f, 9.51318815e-02f, 8.17060173e-02f, -5.62128909e-02f, -1.06085956e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.08620167e-01f, 4.74513143e-01f, 4.17241275e-01f, 7.05025911e-01f, 6.78990364e-01f, 7.10103393e-01f, 2.99383402e-01f, 7.35044181e-01f, 6.42728508e-01f, 1.04268122e+00f,
  7.37690389e-01f, 9.53794301e-01f, 8.43671858e-01f, 5.88105440e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  4.48789358e-01f, 3.93315613e-01f, 1.21238708e-01f, 2.03816354e-01f, -7.51418412e-01f, -5.38796842e-01f, 3.51747543e-01f, -3.69076878e-01f, 9.68489796e-02f, 4.20819856e-02f,
  -9.38930750e-01f, -8.42920542e-01f, -4.56551909e-01f, 4.65240657e-01f, 4.03568923e-01f, 3.02996188e-01f, 5.01065016e-01f, -3.16888213e-01f, -4.78771955e-01f, -1.95116997e-01f,
  -2.41258174e-01f, -8.90295655e-02f, -8.53864014e-01f, -7.79315710e-01f, 1.11965680e+00f, 4.29804802e-01f, -9.54120755e-01f, -7.59815991e-01f, -4.61628616e-01f, 5.59834182e-01f,
  -2.49931201e-01f, -5.37820399e-01f, -7.00959861e-01f, -8.87761831e-01f, 1.18601352e-01f, -6.38765335e-01f, -1.15500160e-01f, 1.88846141e-01f, -5.18300474e-01f, 2.39155233e-01f,
  3.02061409e-01f, 5.34187555e-01f, 8.76496673e-01f, 6.40081763e-01f, -7.57973433e-01f, 5.39676905e-01f, 7.79177666e-01f, 5.78877747e-01f, -1.61786422e-01f, 3.21073264e-01f,
  -1.42408919e+00f, 3.57396662e-01f, 6.15872860e-01f, -8.06221247e-01f, 1.92566186e-01f, 3.47741067e-01f, 3.50562662e-01f, 2.83625331e-02f, 6.87516391e-01f, -5.16026258e-01f,
  -6.59988940e-01f, 6.61123335e-01f, -1.06137133e+00f, -4.41363394e-01f, -1.01706296e-01f, -2.60162055e-01f, -3.39885280e-02f, 1.62959009e-01f, 1.36650279e-01f, 1.35705262e-01f,
  -1.63530722e-01f, -6.21131510e-02f, -7.08937705e-01f, -2.51302987e-01f, 5.74030280e-02f, 3.17889825e-02f, -2.40771532e-01f, -3.50683302e-01f, -2.12864563e-01f, 3.82420689e-01f,
  2.16895365e-03f, -4.58492786e-01f, 8.80242884e-01f, -6.39277697e-01f, 3.19661975e-01f, -4.62507904e-01f, 5.65244615e-01f, -3.59575421e-01f, -3.86535555e-01f, -1.05782211e+00f,
  7.73725390e-01f, -1.22194982e+00f, -5.30919790e-01f, 1.18819334e-01f, -1.68305635e-01f, -6.65220380e-01f, -3.69696140e-01f, -6.85432911e-01f, -2.74331152e-01f, 3.85718405e-01f,
  -2.74360150e-01f, 1.24581225e-01f, -3.59497577e-01f, -6.70964003e-01f, -1.10013507e-01f, -2.50928134e-01f, -3.64900053e-01f, -7.99599469e-01f, -4.42750193e-02f, -1.51284486e-01f,
  5.83910823e-01f, -5.02286315e-01f, -4.81216520e-01f, 5.89221656e-01f, -2.66214490e-01f, 5.98699629e-01f, 1.36899129e-01f, 6.63270593e-01f, -7.48022944e-02f, -5.92798352e-01f,
  -1.29974201e-01f, -7.13218272e-01f, -7.41423488e-01f, -6.12189054e-01f, -5.16368985e-01f, -7.55436242e-01f, 7.75245130e-01f, -3.25693339e-01f, 2.37154767e-01f, 3.49203944e-01f,
  2.72883028e-01f, 2.31740791e-02f, 7.08567262e-01f, -1.00394875e-01f, 1.39369816e-01f, 9.70668197e-01f, -9.50350240e-02f, -1.09309030e+00f, -3.67627531e-01f, -8.19680452e-01f,
  4.74800974e-01f, -1.03595889e+00f, 7.15372980e-01f, -1.07202041e+00f, 2.22328916e-01f, -1.02154219e+00f, 6.62760111e-03f, -9.96687055e-01f, -6.62431598e-01f, 5.39684176e-01f,
  -6.23810530e-01f, 8.84690344e-01f, -2.44194612e-01f, 6.07347131e-01f, -6.88703731e-02f, 3.52424979e-01f, -6.31933987e-01f, -2.05796480e-01f, -7.12491274e-02f, -5.61838508e-01f,
  -1.43645138e-01f, 5.91091871e-01f, -1.50952473e-01f, 9.96660173e-01f, -3.37481111e-01f, 3.72159719e-01f, 6.20920599e-01f, 3.26687932e-01f, 2.85238355e-01f, 1.08469319e+00f,
  5.94584584e-01f, -2.70292640e-01f, 5.26520312e-01f, 9.72074747e-01f, -6.97849765e-02f, -2.83745497e-01f, 4.17335898e-01f, 8.18663955e-01f, -7.02489018e-01f, -3.59158874e-01f,
  -7.34107792e-01f, 6.24110520e-01f, 3.90491128e-01f, -5.75083137e-01f, -7.50137210e-01f, 1.29648745e-01f, -5.19823909e-01f, 2.42684916e-01f, 9.66736555e-01f, 4.81971234e-01f,
  -9.07200933e-01f, -3.49198341e-01f, -2.06489936e-02f, -3.26319426e-01f, 1.95549816e-01f, -2.04170316e-01f, 1.08094990e-01f, -5.73563635e-01f, -4.87978190e-01f, 1.66464522e-01f,
  1.06489860e-01f, 1.33038893e-01f, 3.88360381e-01f, -4.60322350e-01f, 2.53503144e-01f, -4.59187478e-01f, -7.25579143e-01f, 5.34331262e-01f, -1.41090348e-01f, -5.24186492e-01f,
  -1.28003597e-01f, -1.10426374e-01f, 1.23150170e+00f, 1.35137692e-01f, 8.24167609e-01f, -5.72886169e-01f, -5.14370978e-01f, -1.02827764e+00f, -9.74730432e-01f, 4.03217375e-01f,
  -5.40508926e-01f, -8.08446646e-01f, -6.74907148e-01f, 4.47499275e-01f, 7.53821386e-03f, -4.81998235e-01f, 2.40109414e-01f, -5.06834149e-01f, -7.46954381e-02f, -1.08084254e-01f,
  -2.87953526e-01f, -7.96042308e-02f, -5.80680192e-01f, 6.11547530e-01f, -1.14626221e-01f, 1.37159759e-02f, 9.44088697e-02f, -2.34972790e-01f, 2.10058138e-01f, -3.65458637e-01f,
  -4.29203808e-01f, 2.96888560e-01f, 3.55826735e-01f, 8.41742754e-01f, -6.17159486e-01f, 6.09865859e-02f, -3.53672475e-01f, 6.00722849e-01f, -6.38436317e-01f, -2.83250988e-01f,
  -3.40230078e-01f, 3.55621055e-02f, 4.59986031e-01f, -6.04533017e-01f, -9.88229752e-01f, -3.11293900e-01f, 1.16345562e-01f, 2.39937901e-01f, -4.50665623e-01f, -4.06074733e-01f,
  -1.14269458e-01f, -1.71665967e-01f, -1.89401522e-01f, -5.14179766e-01f, -5.11936471e-02f, -1.34022087e-01f, 1.04992799e-01f, 2.86897659e-01f, -1.65992230e-01f, 3.62451494e-01f,
  -4.22009021e-01f, -8.01279545e-01f, -7.23625362e-01f, 2.80642748e-01f, 3.50242198e-01f, -2.54559696e-01f, -4.20481525e-03f, -6.22580886e-01f, 3.06300968e-01f, -3.84631336e-01f,
  2.08718553e-01f, 6.80578589e-01f, 8.46785083e-02f, -8.98060381e-01f, -9.67402980e-02f, -7.03769743e-01f, -1.80960119e-01f, 5.60519516e-01f, 3.57692420e-01f, 1.49960726e-01f,
  1.14889778e-01f, -1.94580033e-02f, 1.02887861e-01f, 5.69736540e-01f, 2.18306914e-01f, -7.60131001e-01f, 2.07551673e-01f, 5.20673394e-01f, 1.47634372e-01f, 1.02974129e+00f,
  6.47960901e-01f, 5.34982741e-01f, 7.53980801e-02f, 7.58903146e-01f, 5.33808410e-01f, 9.01434273e-02f, 1.03350258e+00f, -2.10107848e-01f, -2.65404046e-01f, -2.25836277e-01f,
  -1.10305750e+00f, 5.98738752e-02f, -4.99963164e-01f, -4.99547124e-01f, 1.24619886e-01f, 9.92986858e-01f, -7.08045781e-01f, -6.01536095e-01f, -5.71207941e-01f, -8.75446200e-01f,
  2.00658247e-01f, 6.06240094e-01f, 2.35740423e-01f, -2.67614245e-01f, 3.52051675e-01f, 6.66258335e-02f, 3.38558316e-01f, -1.29846990e-01f, 3.35868448e-01f, -3.53577375e-01f,
  -4.40451086e-01f, 6.72539234e-01f, -5.56958914e-01f, -2.16470927e-01f, -7.10268855e-01f, 2.39296153e-01f, -7.61264384e-01f, 1.72554478e-01f, -5.20337462e-01f, 1.58739626e-01f,
  -4.66583967e-01f, -1.26597643e+00f, -7.51006365e-01f, 4.60773647e-01f, -7.28720963e-01f, 1.99242830e-01f, 5.05823910e-01f, -8.53896558e-01f, -1.24661624e-01f, 6.22983098e-01f,
  7.96448588e-01f, -8.62533271e-01f, -1.52683437e-01f, 3.38925570e-01f, 2.11592317e-01f, -1.51979849e-01f, -1.36003584e-01f, -1.77660868e-01f, 2.12201953e-01f, 1.48009941e-01f,
  2.21353054e-01f, -5.90104401e-01f, -4.20447141e-01f, 4.15217936e-01f, 4.61198866e-01f, -4.62179571e-01f, -6.49581313e-01f, 3.55174959e-01f, 7.00566173e-01f, -3.70632738e-01f,
  -5.83992839e-01f, -6.90434039e-01f, -7.94173107e-02f, 1.25789046e-01f, -7.15096533e-01f, -6.22227073e-01f, -5.33572078e-01f, -2.82558501e-01f, -3.62384945e-01f, -4.68640774e-01f,
  7.76859164e-01f, -5.26369929e-01f, 3.08351338e-01f, 1.11934173e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.63345024e-01f, -4.37454209e-02f, -5.24996705e-02f, -6.72842413e-02f, 2.54328221e-01f, 1.17625771e-02f, 9.56442282e-02f, -1.72566220e-01f, -3.43746156e-01f, -5.80586754e-02f,
  -3.21643357e-03f, 1.69171706e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    