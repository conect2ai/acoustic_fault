/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.38750929e-01f, 3.25997204e-01f, -2.34454963e-02f, 2.17942327e-01f, -7.46316612e-02f, -2.89144069e-01f, -1.99460536e-01f, 9.12696589e-03f, 1.47552431e-01f, 3.07595462e-01f,
  -7.14091212e-02f, -1.10378049e-01f, -8.89680162e-02f, -7.96613693e-02f, -1.89683259e-01f, 8.85377079e-02f, 5.37424684e-02f, -1.51490897e-01f, -4.57995892e-01f, -2.81249225e-01f,
  3.56062949e-02f, 1.22214191e-01f, 1.83144987e-01f, -6.13794327e-02f, 2.47680634e-01f, -8.04266632e-02f, 1.94561973e-01f, 1.57246470e-01f, -1.37814283e-01f, 4.52453911e-01f,
  -1.37053072e-01f, 8.76846239e-02f, -1.77931800e-01f, -1.40823536e-02f, 4.85466979e-02f, 6.87163249e-02f, -2.61880346e-02f, 1.28610581e-01f, -1.41867204e-02f, 1.55291483e-01f,
  1.86343305e-02f, 4.16823588e-02f, 1.31578585e-02f, 7.93695748e-02f, 7.92354196e-02f, 4.29077595e-02f, 1.65171608e-01f, 7.76569694e-02f, 1.31556569e-02f, 5.00185564e-02f,
  -1.49410488e-02f, -1.54869100e-02f, -1.67697817e-02f, -1.45283088e-01f, -1.31655425e-01f, -1.65179167e-02f, -6.97773099e-02f, 2.12369096e-02f, -1.09720878e-01f, 3.05417269e-01f,
  6.64559677e-02f, 6.81770872e-03f, -7.41099939e-02f, -7.46809237e-04f, 3.67129929e-02f, -2.22043358e-02f, 6.28881343e-03f, -2.77495272e-02f, -7.33129978e-02f, 8.39159489e-02f,
  -5.86582720e-02f, -4.21890151e-03f, 3.00217979e-03f, 4.72322144e-02f, 2.60722134e-02f, -4.84837126e-03f, -4.87871394e-02f, 4.33288664e-02f, -8.34103394e-03f, 9.17828605e-02f,
  3.00439959e-03f, -1.34174181e-02f, 3.63968201e-02f, -6.89297318e-02f, 8.83620903e-02f, -4.32415083e-02f, 4.99428511e-02f, -2.42630485e-02f, 1.94414798e-02f, -2.08758563e-02f,
  1.52117247e-02f, -2.72927195e-01f, 1.90120786e-01f, -6.66180719e-03f, -3.67744789e-02f, 4.80046272e-02f, 1.10450787e-02f, -3.41485860e-03f, -2.20182873e-02f, -2.27851290e-02f,
  8.06782953e-03f, -5.30657321e-02f, 2.10036132e-02f, -2.82004531e-02f, -4.42990065e-02f, 3.76252718e-02f, -3.10060661e-02f, -4.58815508e-02f, -9.44201052e-02f, 6.23320751e-02f,
  8.02595317e-02f, -3.20226066e-02f, -1.41258955e-01f, -8.67071655e-03f, -8.03676248e-03f, -1.75069109e-01f, -7.05444142e-02f, -3.78433131e-02f, -2.06897885e-01f, 2.35240549e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.15584844e-01f, 2.46529728e-01f, -1.70252979e-01f, 6.09837249e-02f, 2.81703770e-02f, -1.56525970e-01f, 6.64331988e-02f, 2.62400485e-03f, -5.72894067e-02f, -3.04146782e-02f,
  -1.65265992e-01f, -1.68469772e-01f, 7.02841487e-03f, -2.00364925e-02f, 5.85098639e-02f, 2.81484008e-01f, 4.88303393e-01f, 7.83345625e-02f, -2.71540374e-01f, -1.29888862e-01f,
  1.31476671e-01f, -8.15259572e-03f, -1.93544716e-01f, 1.33485701e-02f, 1.63373113e-01f, -5.36234193e-02f, -1.09725572e-01f, 1.09718703e-01f, 2.67050005e-02f, 5.69137931e-01f,
  7.33389333e-02f, 3.13234404e-02f, -1.82664812e-01f, -5.11207655e-02f, -1.05713755e-01f, 4.60086428e-02f, 9.34891775e-03f, 8.04663748e-02f, -6.27232864e-02f, -1.54535193e-02f,
  4.54279110e-02f, 8.73117335e-03f, 5.72992451e-02f, 6.24366254e-02f, 2.96610594e-02f, 1.80955324e-02f, 5.60292378e-02f, 7.35713542e-02f, -8.65065753e-02f, -7.45312646e-02f,
  2.07241714e-01f, -8.23334903e-02f, 1.89268775e-02f, 2.52306629e-02f, 1.13846632e-02f, -9.17084888e-02f, -1.14070445e-01f, -1.06732156e-02f, -1.92120567e-01f, 1.20310187e-01f,
  4.67352569e-02f, 1.53259709e-02f, -1.70531124e-02f, 9.06919539e-02f, 1.54901296e-02f, -1.72080807e-02f, 5.82782701e-02f, -2.05573086e-02f, 5.83909377e-02f, -2.81758420e-02f,
  1.52641218e-02f, -1.04551248e-01f, -8.97476226e-02f, -7.26842368e-03f, -4.97491732e-02f, 4.37884852e-02f, -1.15909018e-02f, -1.72263272e-02f, -6.44140691e-02f, 4.96375561e-02f,
  1.61172058e-02f, 3.29522230e-02f, -2.82513276e-02f, 3.98751386e-02f, -5.01710922e-02f, -2.46602073e-02f, -1.39677692e-02f, -1.09243475e-01f, -4.05477397e-02f, 6.55970424e-02f,
  -1.68074429e-01f, -2.80965507e-01f, -3.06892004e-02f, 8.71687531e-02f, -1.27750915e-02f, 8.94542877e-03f, -2.37830486e-02f, -6.78390041e-02f, 5.12343049e-02f, -8.05985034e-02f,
  -1.25071958e-01f, -1.46679422e-02f, 2.00203191e-02f, -1.33993309e-02f, -9.26016122e-02f, 2.02165246e-02f, -7.36041442e-02f, 2.43964661e-02f, -8.84787738e-02f, -4.24284115e-02f,
  -8.84932950e-02f, -1.48393199e-01f, -2.11508617e-01f, -2.49417033e-02f, -7.29322508e-02f, -1.06986918e-01f, -1.29140258e-01f, -1.81788936e-01f, -3.01792562e-01f, -2.60042459e-01f,
  2.51442730e-01f, 2.73989081e-01f, 9.94233117e-02f, 6.28087446e-02f, 4.20085900e-02f, -1.33234352e-01f, -8.17696750e-02f, -6.58988357e-02f, -1.05257511e-01f, 3.72617356e-02f,
  -8.34992912e-04f, -1.27457336e-01f, -2.93123480e-02f, -3.40010375e-02f, -2.44089633e-01f, -5.80769591e-02f, 2.03971751e-02f, 5.08784465e-02f, -2.57059753e-01f, -2.06082404e-01f,
  -9.42005366e-02f, 4.41253595e-02f, 9.43977609e-02f, -1.04284242e-01f, 4.48002629e-02f, -5.58938235e-02f, 4.68347892e-02f, 2.47760475e-01f, 1.50018245e-01f, 3.89570057e-01f,
  7.51790851e-02f, 3.92734319e-01f, -2.83839375e-01f, -6.08626790e-02f, 9.16236416e-02f, 1.04950398e-01f, 4.75169942e-02f, 7.38057420e-02f, 5.41990735e-02f, -2.46021617e-02f,
  1.29142050e-02f, -4.64356914e-02f, 1.06117576e-01f, -1.05657756e-01f, -7.94941410e-02f, -7.29760006e-02f, 4.23605964e-02f, -4.12733182e-02f, -4.58433703e-02f, -4.27982915e-04f,
  7.46123493e-02f, 1.91996023e-01f, 8.07798877e-02f, -1.46215692e-01f, 7.00422451e-02f, -2.87975743e-03f, -2.52029230e-03f, -3.72644365e-02f, 4.93594818e-02f, 1.77789032e-02f,
  -2.87315659e-02f, 3.39783775e-03f, 3.99263650e-02f, 8.30637887e-02f, 7.82602355e-02f, -3.22051998e-03f, -7.84485508e-03f, 6.99199690e-03f, -6.14091717e-02f, 8.45085382e-02f,
  -4.51193787e-02f, 6.82808682e-02f, -2.14863895e-03f, 8.55936259e-02f, -3.79202026e-03f, -6.35590404e-03f, 3.77742387e-02f, 3.77775058e-02f, 1.67413838e-02f, 7.57769793e-02f,
  -1.34554058e-01f, -1.33425789e-02f, 4.53714021e-02f, -4.17173691e-02f, -1.31985098e-02f, 1.06499590e-01f, 6.73520751e-03f, -7.95130730e-02f, 6.70028552e-02f, 4.92010489e-02f,
  -2.58905500e-01f, -1.03263438e-01f, -2.10892726e-02f, -5.94947524e-02f, 1.18016012e-01f, 2.81652175e-02f, 1.29237771e-01f, 6.58242702e-02f, 2.75369212e-02f, 3.90506871e-02f,
  -6.45759255e-02f, 1.45307258e-02f, -6.55835820e-03f, -3.92764173e-02f, -1.12078916e-02f, -7.25623444e-02f, -7.33103082e-02f, -2.83486824e-02f, -1.87178865e-01f, -6.89896010e-03f,
  -8.91485959e-02f, -9.04714987e-02f, -1.02005102e-01f, -1.31967396e-01f, -5.03528537e-03f, -1.14631809e-01f, -1.87259853e-01f, -7.78070539e-02f, -1.93987131e-01f, -1.81689173e-01f,
  3.51721309e-02f, -1.63886800e-01f, 9.40564200e-02f, 1.10943854e-01f, -1.59720927e-02f, -1.03779636e-01f, -2.93369621e-01f, -1.97749779e-01f, 2.81216539e-02f, -7.11909160e-02f,
  -1.78914517e-02f, 1.47228450e-01f, 1.00018539e-01f, 7.83051271e-03f, 1.88339129e-02f, -8.27017985e-03f, 1.25371695e-01f, 1.92397237e-01f, 7.40906075e-02f, 4.09654435e-03f,
  -5.24684116e-02f, 1.16788790e-01f, 1.33809641e-01f, 2.36913804e-02f, 5.25936112e-02f, 1.28928661e-01f, 1.23415388e-01f, 1.37093842e-01f, -5.10239266e-02f, 1.74713373e-01f,
  2.94580441e-02f, -7.49101266e-02f, 3.78649421e-02f, -2.20159795e-02f, -1.30052688e-02f, -1.94140058e-02f, -1.77827645e-02f, 4.00505541e-03f, -6.76131099e-02f, -4.67205048e-02f,
  -4.92816679e-02f, -9.69716981e-02f, -1.87929664e-02f, -8.00633356e-02f, -1.22921750e-01f, -6.62661344e-02f, 7.46385474e-03f, 4.89254072e-02f, 8.99000540e-02f, -6.85605556e-02f,
  -8.57651532e-02f, 1.85323935e-02f, -7.05936924e-02f, -2.30265968e-03f, -9.74776372e-02f, 7.40505755e-02f, -3.06991208e-02f, -1.80224150e-01f, -4.05262150e-02f, -7.84186497e-02f,
  -7.08213523e-02f, 3.43681052e-02f, -3.76605727e-02f, -4.99010421e-02f, -1.56697482e-02f, -3.10795638e-03f, -5.67998439e-02f, 7.96615109e-02f, -1.26451226e-02f, -9.59321484e-02f,
  -5.19405566e-02f, 1.30332150e-02f, -3.39058004e-02f, 2.29032040e-02f, 1.40776679e-01f, 2.04455201e-02f, -8.01378638e-02f, 1.88478902e-02f, 1.23192452e-01f, -1.88353620e-02f,
  -7.97941815e-03f, -4.33897004e-02f, -3.79914567e-02f, 6.55107871e-02f, 1.89819615e-02f, -2.48727538e-02f, 5.78905232e-02f, 3.93114761e-02f, 9.62732919e-03f, 5.93573004e-02f,
  -1.55603290e-01f, 2.51979291e-01f, -1.17832854e-01f, -3.99192236e-02f, -1.76822171e-02f, 3.85608189e-02f, -4.61341403e-02f, 3.99328656e-02f, -5.46980789e-03f, -1.25137731e-01f,
  -1.19686328e-01f, -5.95978275e-02f, 4.66850679e-03f, -1.45069314e-02f, -1.34208694e-01f, -9.90407765e-02f, -2.74427831e-02f, 7.13121817e-02f, 5.46572804e-02f, 9.93329659e-03f,
  2.38753874e-02f, -1.22825250e-01f, -2.32526800e-03f, -9.23950523e-02f, -1.11025684e-01f, -2.53206491e-02f, -1.70825511e-01f, -7.85100162e-02f, -1.54249907e-01f, -2.20131919e-01f,
  8.93147051e-01f, -4.67145592e-01f, -4.61008430e-01f, 1.73921108e-01f, -2.34958366e-01f, -1.81415007e-01f, -4.83475149e-01f, 1.05690114e-01f, 2.36664698e-01f, -1.65286168e-01f,
  -1.99639440e-01f, 1.25032395e-01f, 1.48402989e-01f, 8.01245794e-02f, 2.35014290e-01f, -2.65820831e-01f, -1.95293248e-01f, 6.12987876e-02f, 1.86290652e-01f, -5.77577427e-02f,
  2.43908148e-02f, 1.65461063e-01f, 2.72052735e-01f, 1.99570924e-01f, -3.54315221e-01f, -2.31304709e-02f, -1.85016841e-01f, -2.30274469e-01f, -3.33897978e-01f, -5.99184752e-01f,
  -4.70441490e-01f, -2.74931610e-01f, 1.01933712e-02f, 1.23782597e-01f, -8.46652836e-02f, 1.17677458e-01f, -6.43742532e-02f, 1.14802802e-02f, 5.23378290e-02f, -1.09075350e-04f,
  8.73914268e-03f, 8.09093821e-04f, 4.60383780e-02f, -4.27177250e-02f, 5.27139977e-02f, -7.27603585e-02f, 3.19448300e-02f, 3.30609758e-03f, 7.28570595e-02f, -9.33944434e-02f,
  -1.08489715e-01f, -9.83297601e-02f, -2.19205558e-01f, -1.23306170e-01f, -3.52374837e-02f, 3.18333618e-02f, -3.27024430e-01f, -1.82094604e-01f, -1.63897708e-01f, -2.66687989e-01f,
  -3.56239304e-02f, -4.51515056e-02f, 2.02291664e-02f, -4.03619818e-02f, 9.61234942e-02f, 2.61361487e-02f, -5.28926775e-02f, -1.75266601e-02f, -9.59945284e-03f, 2.22939346e-02f,
  4.33477201e-03f, -8.53725523e-02f, -1.64520182e-02f, -9.18935053e-04f, -3.03367395e-02f, -7.85091966e-02f, 3.35923694e-02f, -5.99999838e-02f, 5.21334894e-02f, 6.91555738e-02f,
  1.05932178e-02f, -1.21019660e-02f, -1.74998734e-02f, 6.60236925e-02f, -8.73151794e-02f, -1.47699378e-02f, 4.02389839e-03f, -4.48949635e-02f, 1.00136854e-01f, 9.56717655e-02f,
  3.03459376e-01f, 7.33182654e-02f, -6.70102239e-02f, 1.06835505e-02f, 4.33656462e-02f, 5.49897514e-02f, 1.04204342e-02f, 1.04420394e-01f, 8.60612933e-03f, -2.07751263e-02f,
  -8.10100362e-02f, 9.05047208e-02f, -4.94806431e-02f, -4.95419353e-02f, -3.56914252e-02f, 1.01525458e-02f, 1.04010906e-02f, 2.39313375e-02f, -9.88996699e-02f, 1.55554460e-02f,
  8.97464305e-02f, 1.02000527e-01f, 1.87159747e-01f, 1.18664190e-01f, -5.22686169e-02f, 1.39923856e-01f, -6.39808998e-02f, -7.11951628e-02f, 1.40166074e-01f, 2.15600818e-01f,
  -3.97400737e-01f, -1.68288816e-02f, -1.63932398e-01f, -1.70254022e-01f, -2.22889796e-01f, -1.71314552e-01f, 1.42857609e-02f, 4.59911898e-02f, -3.42433490e-02f, -6.84576854e-02f,
  3.13820429e-02f, -6.99267238e-02f, -9.29837152e-02f, -1.91899553e-01f, -1.17580839e-01f, -1.51960298e-01f, -2.88067192e-01f, -2.75933087e-01f, -2.49499306e-01f, -1.83274493e-01f,
  -2.06332833e-01f, -2.37813070e-01f, -1.58225819e-01f, -1.40101910e-01f, 1.71301386e-03f, 1.16106821e-02f, 8.05307329e-02f, -1.50432795e-01f, -9.07125100e-02f, -6.20856658e-02f,
  2.36987382e-01f, -1.89948201e-01f, -8.48579332e-02f, -4.41234373e-02f, -8.36067349e-02f, -9.08839405e-02f, -1.22156600e-02f, -1.11912876e-01f, -1.29732322e-02f, -4.05462692e-03f,
  -1.14986956e-01f, 5.91015108e-02f, -8.53334293e-02f, -4.56971601e-02f, -1.66458804e-02f, -6.05959594e-02f, -4.48924489e-02f, -8.97860080e-02f, -6.26032501e-02f, 7.61021376e-02f,
  8.49165320e-02f, -6.56694919e-02f, -6.26855493e-02f, 1.03043079e-01f, -3.03386152e-02f, -3.45868133e-02f, 9.02112201e-02f, 4.92307693e-02f, 8.92011076e-03f, 2.71972209e-01f,
  -5.32390643e-03f, -7.50076473e-02f, -8.62051770e-02f, -4.33012322e-02f, 4.65774685e-02f, -1.15157478e-02f, -1.91538185e-02f, -6.62158281e-02f, 4.54063453e-02f, 2.10842844e-02f,
  1.04762450e-01f, 4.08990495e-02f, 5.53943180e-02f, 3.22355452e-04f, 2.53163185e-02f, 3.63109782e-02f, 1.99993681e-02f, 1.24075763e-01f, 5.37564866e-02f, -6.90415427e-02f,
  -1.04044788e-01f, -7.25739356e-03f, 2.10412173e-03f, 5.54089658e-02f, -2.70393956e-02f, -1.91467442e-02f, -2.25525331e-02f, -1.52155682e-02f, -9.31370854e-02f, -7.89737701e-02f,
  4.09053981e-01f, -8.14339146e-02f, -4.24470901e-02f, -5.72852790e-02f, -2.35904683e-03f, 8.82517826e-03f, -2.55653039e-02f, -7.98602309e-03f, 1.46948290e-03f, -4.45821956e-02f,
  -6.06815852e-02f, 1.05582282e-01f, -3.49507444e-02f, 3.59980874e-02f, 3.53903845e-02f, -6.09830022e-02f, 4.76469509e-02f, -2.62454581e-02f, -4.06829976e-02f, 1.37232587e-01f,
  5.04953749e-02f, -5.10873236e-02f, -4.09012521e-03f, 1.55503631e-01f, 2.75672488e-02f, -1.41735762e-01f, 1.63784340e-01f, 1.77259639e-01f, -1.23961233e-02f, 3.50425720e-01f,
  -6.15885675e-01f, -1.14347219e-01f, -1.88902006e-01f, -2.75035620e-01f, 3.33807655e-02f, 1.71881184e-01f, 1.81567654e-01f, 1.77922443e-01f, -3.73312905e-02f, 1.51613634e-02f,
  -1.47390456e-04f, -5.32986894e-02f, -3.63336466e-02f, 7.22942054e-02f, 3.92340826e-06f, 1.54519334e-01f, -5.82662039e-02f, -6.04206659e-02f, -3.95546183e-02f, 1.62297189e-01f,
  9.91849378e-02f, -1.55957431e-01f, -2.98291773e-01f, -6.91783875e-02f, -2.88554747e-02f, -1.27142653e-01f, -4.26653475e-02f, -2.13584900e-01f, 1.51010588e-01f, -5.70517145e-02f,
  -1.27262339e-01f, -7.26301670e-02f, 8.77003968e-02f, -8.11903924e-02f, 5.40204309e-02f, 7.44227618e-02f, 2.36097863e-03f, 7.45743327e-03f, 2.90285945e-02f, 9.42826048e-02f,
  1.49341598e-02f, 6.83090687e-02f, -3.86889242e-02f, 1.90450121e-02f, -1.02626808e-01f, 1.01469338e-01f, 2.68174317e-02f, -2.09106002e-02f, -8.06109458e-02f, 1.48175448e-01f,
  1.83153957e-01f, 6.78656623e-02f, -5.30745573e-02f, 1.97914034e-01f, 3.36863734e-02f, 2.62489682e-03f, -5.32170851e-03f, 7.03271106e-02f, 2.22866349e-02f, -1.01978011e-01f,
  -5.70238642e-02f, -2.17556395e-02f, 2.40912251e-02f, 3.26074590e-03f, -6.14038259e-02f, 4.64522876e-02f, -2.71057058e-02f, -7.27407038e-02f, -4.62264903e-02f, -4.02063541e-02f,
  5.06049506e-02f, 8.12250972e-02f, -1.52195031e-02f, -4.07783203e-02f, 3.00914701e-02f, -5.74283451e-02f, -4.77036759e-02f, 4.12984714e-02f, 8.86239186e-02f, -2.42076442e-02f,
  3.04258466e-02f, 8.66746809e-03f, -1.40441909e-01f, 2.67850608e-02f, -1.67034790e-02f, 4.41789515e-02f, 9.02497675e-03f, -3.48015204e-02f, 7.83509985e-02f, 9.29162875e-02f,
  -3.63732487e-01f, 2.76835635e-02f, -5.37752882e-02f, -6.32889196e-02f, -4.77927439e-02f, -2.78779380e-02f, -5.02345711e-02f, 5.99145703e-02f, -1.40996631e-02f, 2.06964035e-02f,
  8.03356022e-02f, -8.17508027e-02f, -2.82484107e-02f, 4.50905301e-02f, 3.38881090e-02f, -2.45468672e-02f, -1.88648626e-02f, -9.22028646e-02f, 6.29250333e-02f, 1.04440905e-01f,
  -2.42167152e-02f, -4.09862474e-02f, -1.02696732e-01f, 1.15666036e-02f, -7.54657686e-02f, -1.32010683e-01f, 4.28499915e-02f, -3.69772948e-02f, -5.36329560e-02f, -2.13589460e-01f,
  -1.79821134e-01f, -2.06728309e-01f, 4.67674583e-01f, 6.38378635e-02f, -7.91949034e-03f, -3.14870000e-01f, -4.59123760e-01f, -3.99733543e-01f, -1.03062443e-01f, -3.75587679e-02f,
  -2.76405886e-02f, 2.81815039e-04f, 8.17436427e-02f, 5.01172766e-02f, -7.98285156e-02f, -9.15738046e-02f, 1.30858749e-01f, 3.48035187e-01f, 1.69007733e-01f, -1.73075303e-01f,
  -5.51505722e-02f, 1.63671970e-01f, 2.10891172e-01f, -4.91060875e-02f, 4.76523265e-02f, 7.88058937e-02f, 1.57713801e-01f, 2.01886266e-01f, 6.21984527e-02f, 1.78349659e-01f,
  2.60567516e-01f, -1.07129607e-02f, 4.68244925e-02f, 1.42191574e-02f, 2.04786748e-01f, -7.79221281e-02f, -3.16446647e-02f, 1.90756321e-01f, 9.85060260e-02f, 1.78246815e-02f,
  1.28318369e-01f, 6.30788207e-02f, 1.47312162e-02f, 1.22885227e-01f, 8.27583950e-03f, -5.87524101e-02f, 1.95789803e-02f, 1.29473925e-01f, 8.76262225e-03f, 1.77632272e-02f,
  -4.06277627e-02f, 1.51758522e-01f, 5.66687323e-02f, -2.32029408e-02f, -6.11436218e-02f, 1.22468911e-01f, -7.36423358e-02f, -9.02106054e-03f, -6.49815574e-02f, -5.61507493e-02f,
  -4.53620739e-02f, -4.27282192e-02f, 6.47548288e-02f, -2.84705255e-02f, -1.18204504e-01f, 2.44339444e-02f, 5.99334091e-02f, -1.22359516e-02f, -2.60426812e-02f, -5.44316769e-02f,
  5.88569380e-02f, -2.69053094e-02f, 5.64368330e-02f, 2.74173878e-02f, 3.45666185e-02f, 3.44953686e-02f, -4.67718840e-02f, -5.73144630e-02f, 7.24424645e-02f, -7.00103268e-02f,
  1.29444703e-01f, 5.06604575e-02f, 1.20800557e-02f, -2.32921634e-02f, -3.57327051e-02f, 6.64624795e-02f, -1.19910821e-01f, -2.25269496e-02f, 4.60849702e-03f, 8.01502690e-02f,
  -2.00935289e-01f, 8.36543217e-02f, -4.34664972e-02f, -1.06995396e-01f, 7.87618160e-02f, -2.80842781e-02f, -6.08203746e-02f, -2.75488328e-02f, 4.72718887e-02f, -8.02572165e-03f,
  -1.50406480e-01f, -7.51506016e-02f, 8.11988413e-02f, -6.00356832e-02f, 2.77581904e-02f, 3.32883745e-02f, -2.11608130e-02f, 4.17363718e-02f, -1.29744634e-02f, -1.82366353e-02f,
  -7.13184699e-02f, -2.30919927e-01f, -2.46240318e-01f, -1.41839311e-01f, -6.47712946e-02f, -2.57810444e-01f, -3.01477276e-02f, -2.15666935e-01f, -1.02446206e-01f, -3.45199436e-01f,
  1.76683590e-01f, 3.45988780e-01f, 3.57138425e-01f, 2.32216641e-01f, 2.37731799e-01f, 3.62051725e-01f, 6.09008014e-01f, 1.47901371e-01f, -8.41905326e-02f, 8.76782909e-02f,
  3.33797000e-03f, -1.10467881e-01f, -9.90007967e-02f, -1.05364501e-01f, 1.19174510e-01f, 1.86633304e-01f, 2.29756206e-01f, -3.81305255e-02f, 3.89680685e-03f, -7.36708641e-02f,
  -1.43292978e-01f, -1.71087712e-01f, -2.12693274e-01f, 1.09679401e-02f, 1.36541024e-01f, -6.93940148e-02f, 1.03789583e-01f, 1.11013956e-01f, 6.56267554e-02f, -5.99478977e-03f,
  -1.01004660e-01f, 3.29737961e-01f, -6.87286928e-02f, -1.61822140e-01f, 5.26331216e-02f, -1.21552490e-01f, -8.87278989e-02f, -2.10577250e-01f, 1.41507415e-02f, -8.72624069e-02f,
  -4.20559477e-03f, -1.95971832e-01f, 1.22450180e-01f, -6.23401403e-02f, 1.12609252e-01f, -1.30542200e-02f, 5.58830332e-03f, 3.80698778e-02f, 9.49330106e-02f, 7.93691799e-02f,
  1.10985450e-02f, -4.69597429e-02f, 8.73170495e-02f, 1.10644326e-01f, 2.19526559e-01f, -5.44183441e-02f, 6.20582551e-02f, 2.04739254e-03f, 1.67992145e-01f, -1.04255125e-01f,
  -8.28833133e-02f, 1.06969643e-02f, 1.89381186e-02f, -1.49550261e-02f, -9.65271667e-02f, 1.42080300e-02f, 3.90930250e-02f, 8.92861513e-04f, 3.62506062e-02f, -9.78665352e-02f,
  -8.06856826e-02f, 8.93780813e-02f, 3.54879983e-02f, 1.21811122e-01f, 1.21175282e-01f, 3.94755341e-02f, 1.62368342e-02f, 4.61906567e-02f, -6.75599277e-02f, -5.90015948e-02f,
  2.11327337e-02f, -1.76278129e-02f, 9.92383286e-02f, 2.95163933e-02f, 3.34613584e-02f, 6.58142865e-02f, -6.36880547e-02f, -2.66498197e-02f, 2.05795169e-02f, -7.78864324e-02f,
  -4.12519038e-01f, 1.92087308e-01f, -1.45164594e-01f, -4.63381670e-02f, 5.81006007e-03f, -6.21680580e-02f, 8.89083892e-02f, 8.31350405e-03f, -4.85392511e-02f, 2.63260864e-02f,
  -2.23674420e-02f, 4.14361246e-02f, 6.75248057e-02f, 3.26938480e-02f, -1.00443929e-01f, -8.75055939e-02f, -6.83728431e-04f, 6.59138709e-02f, -1.24218613e-01f, -1.07851580e-01f,
  -6.54125912e-03f, -1.21034399e-01f, -2.37723127e-01f, -6.25995472e-02f, -1.18071832e-01f, -2.40982592e-01f, -1.17004849e-01f, -1.82337567e-01f, -1.20727740e-01f, -1.99047089e-01f,
  7.22399801e-02f, 1.29492030e-01f, -4.58313432e-03f, 1.48956269e-01f, -1.98725928e-02f, -1.21426053e-01f, -1.02047667e-01f, -9.51117501e-02f, -1.15819663e-01f, -3.20809595e-02f,
  2.58105509e-02f, 5.41164316e-02f, -3.05375941e-02f, -1.19661421e-01f, -1.03750482e-01f, 2.31173765e-02f, -3.09600867e-02f, -1.30750537e-01f, -1.78817600e-01f, -6.41031712e-02f,
  -1.63490307e-02f, 6.86755925e-02f, 1.03142112e-01f, -8.80238935e-02f, 8.39577019e-02f, 3.11073288e-02f, 1.67051524e-01f, 2.07796007e-01f, 1.81393623e-01f, 3.73110026e-01f,
  1.85546994e-01f, 3.22325937e-02f, -9.76126641e-02f, 1.13725394e-01f, 1.10777885e-01f, -1.12037517e-01f, -5.09107346e-03f, -8.21685493e-02f, -1.88082103e-02f, -6.32176623e-02f,
  1.27675280e-01f, 9.28970277e-02f, 8.92359670e-03f, -7.65093639e-02f, -2.45536938e-02f, -2.97774058e-02f, -3.33856456e-02f, -2.96860058e-02f, -1.25965461e-01f, -7.00801983e-02f,
  8.84325355e-02f, 1.62763566e-01f, -2.31524017e-02f, -1.22879170e-01f, 2.16747541e-02f, 4.95519750e-02f, 5.74010201e-02f, -6.96729794e-02f, 4.42666896e-02f, 4.90711117e-03f,
  -9.66787636e-02f, -1.20838927e-02f, -4.65691499e-02f, -9.46921706e-02f, -6.25697523e-02f, 6.28478080e-02f, -1.45103419e-02f, 8.47006142e-02f, -1.82912790e-03f, 3.15870568e-02f,
  -9.44687501e-02f, -9.29284915e-02f, 4.01620865e-02f, -6.38177246e-02f, -6.80720136e-02f, 1.09934568e-01f, -1.05914241e-02f, -6.11788854e-02f, -1.26699299e-01f, -4.73836400e-02f,
  -2.72047762e-02f, 8.89280960e-02f, 1.92135990e-01f, 8.74413103e-02f, 8.81871209e-03f, -6.29486740e-02f, -1.35107487e-01f, 2.15251534e-03f, -1.98376607e-02f, 2.38224305e-02f,
  -9.82231870e-02f, -1.20652944e-03f, 3.54042202e-02f, -4.75030281e-02f, 3.57918665e-02f, -6.75501227e-02f, 1.06132133e-02f, -2.49612760e-02f, -1.67257637e-02f, 3.34612802e-02f,
  6.65064603e-02f, -1.32417813e-01f, 5.73946396e-03f, -1.44132050e-02f, -1.29103512e-01f, 2.49994230e-02f, 2.32116170e-02f, -2.89100148e-02f, -2.95002274e-02f, 1.08947055e-02f,
  7.84374997e-02f, 4.14224043e-02f, -9.20794904e-02f, -7.39293545e-02f, 4.66138497e-02f, -1.87491288e-03f, -6.85269460e-02f, 2.70097870e-02f, -1.68713570e-01f, -1.49484739e-01f,
  -1.94383934e-01f, -3.90216894e-02f, -2.43435532e-01f, -7.40266219e-02f, 1.35457560e-01f, 3.04441024e-02f, -8.98945406e-02f, 2.34114770e-02f, 2.27904275e-01f, 4.55781594e-02f,
  1.75342649e-01f, 2.74386909e-02f, -1.79676712e-01f, -2.29839012e-01f, -3.85306656e-01f, -3.45808953e-01f, -3.09796154e-01f, -4.92890060e-01f, -3.53388965e-01f, -7.72529393e-02f,
  1.10336028e-01f, -1.76795885e-01f, -1.66788131e-01f, -1.46783181e-02f, 2.20188409e-01f, -1.58186033e-02f, -8.71518403e-02f, -4.66397181e-02f, 1.14003718e-01f, -2.61203013e-02f,
  -1.38455734e-01f, 8.53760466e-02f, 3.98731567e-02f, 2.47113369e-02f, -3.77301760e-02f, -3.54632805e-03f, 3.67580578e-02f, -6.10539801e-02f, 1.27723292e-01f, -5.87861873e-02f,
  -5.57317510e-02f, -2.96264011e-02f, -6.19048513e-02f, -1.73267275e-02f, -1.36019692e-01f, -4.13887165e-02f, -8.46447498e-02f, -7.29011521e-02f, -1.17092803e-01f, -3.08401659e-02f,
  2.69840136e-02f, -1.01078808e-01f, -1.94359079e-01f, -6.48236871e-02f, -1.79838650e-02f, -9.22821090e-02f, 3.40002812e-02f, -4.77365553e-02f, -1.29808977e-01f, 2.09448580e-02f,
  1.66074429e-02f, 1.20992467e-01f, 2.71133929e-02f, 3.17507982e-02f, 5.54423146e-02f, 1.15333490e-01f, 7.21087345e-05f, 8.14727768e-02f, -5.43089621e-02f, -5.09746410e-02f,
  1.94471721e-02f, 1.54264765e-02f, 3.17642614e-02f, -9.60927531e-02f, -2.01084781e-02f, 4.02293652e-02f, -5.88729568e-02f, -1.13254420e-01f, -1.08039647e-01f, 2.87229605e-02f,
  -6.39326051e-02f, -1.55021707e-02f, 1.76050346e-02f, -2.18566898e-02f, -8.87871012e-02f, -4.85382080e-02f, -7.83666596e-03f, -6.60075620e-02f, 2.46145912e-02f, -8.90041294e-04f,
  -1.07219681e-01f, -6.09131046e-02f, -3.28600034e-02f, -4.42110859e-02f, 1.35267712e-02f, 5.74022606e-02f, 6.67346269e-02f, -2.51530129e-02f, 7.23522678e-02f, 1.82109661e-02f,
  -3.77424993e-02f, 1.15196663e-03f, 2.69466229e-02f, 7.88569674e-02f, -1.29735261e-01f, -3.71282287e-02f, 5.57621568e-02f, -1.53924331e-01f, -1.44179940e-01f, 4.36820537e-02f,
  -7.49306381e-02f, -2.69879103e-01f, -2.79047430e-01f, -1.61337420e-01f, 5.26077114e-02f, -2.10897610e-01f, -2.05008864e-01f, -1.23457678e-01f, -1.62818640e-01f, -1.85022533e-01f,
  5.76741621e-02f, -9.62592382e-03f, -1.49637684e-01f, 2.08340093e-01f, 1.78211734e-01f, 2.12779026e-02f, -3.42137888e-02f, 1.05116345e-01f, 1.45878538e-01f, 4.26434763e-02f,
  1.28797144e-01f, 2.99654096e-01f, 1.23488657e-01f, 1.04170330e-01f, 1.34060055e-01f, 1.78144909e-02f, 8.27153772e-02f, -6.97306693e-02f, 8.58732313e-02f, 6.09148405e-02f,
  1.23263910e-01f, -5.76396510e-02f, -1.48382455e-01f, 8.93474296e-02f, 6.83687404e-02f, 1.84451453e-02f, -2.57662926e-02f, -3.84203866e-02f, 7.78393960e-03f, 3.01373601e-02f,
  1.79973687e-03f, -1.88387167e-02f, 1.86475381e-01f, 1.69334009e-01f, 3.80997360e-02f, -4.80882935e-02f, 6.51257187e-02f, -1.40545130e-01f, -5.12231924e-02f, -5.41084670e-02f,
  5.46387099e-02f, -5.69174066e-02f, -3.08488086e-02f, -6.07113987e-02f, -6.23153374e-02f, -7.13140294e-02f, -6.49515912e-02f, -5.74134327e-02f, 1.19730197e-01f, 7.26668611e-02f,
  1.36465311e-01f, -5.16843759e-02f, 3.35163996e-02f, 1.77623723e-02f, 5.86479940e-02f, 9.15996060e-02f, -8.36736187e-02f, 4.57769185e-02f, 2.79330532e-03f, -3.91863212e-02f,
  1.53369933e-01f, -2.69466601e-02f, 4.38238718e-02f, -5.80869336e-03f, 2.92826667e-02f, 4.06880789e-02f, 2.10733395e-02f, -1.32628456e-01f, -3.81200872e-02f, -6.84637576e-02f,
  -5.99514656e-02f, 7.49578252e-02f, 8.42525437e-02f, -9.75257903e-02f, 6.72921240e-02f, -5.09985797e-02f, -6.45681918e-02f, -6.81352168e-02f, 8.66208971e-02f, 2.67703156e-03f,
  4.89451140e-02f, -9.06916782e-02f, -1.61466047e-01f, -1.28310457e-01f, 3.41893770e-02f, 1.18925251e-01f, 7.30644027e-03f, -2.58232746e-02f, -3.41154151e-02f, -7.04372823e-02f,
  -6.69780225e-02f, 1.91386029e-01f, 1.27209604e-01f, 8.52107182e-02f, -3.73408780e-03f, -2.92070955e-02f, 8.71012658e-02f, -4.39934656e-02f, -8.51966292e-02f, -6.10919669e-02f,
  2.09039785e-02f, -1.25329178e-02f, -1.01429947e-01f, -2.83059645e-02f, -1.63793489e-02f, -3.14063914e-02f, -1.37834484e-02f, 1.08240776e-01f, 2.23731063e-02f, -3.41502018e-02f,
  2.84255426e-02f, -1.63717195e-02f, -1.06411435e-01f, -7.75175914e-02f, 6.03726134e-02f, 1.23047180e-01f, -2.04581935e-02f, -1.01955561e-02f, -7.50351872e-04f, -8.73516202e-02f,
  -3.73174012e-01f, -9.10643488e-02f, -3.19924980e-01f, -3.65663558e-01f, -8.59568268e-02f, 2.78483462e-02f, -6.91836849e-02f, 3.83143611e-02f, -9.19697583e-02f, -3.16535592e-01f,
  -1.14705108e-01f, 1.10183666e-02f, -5.29141985e-02f, -4.83958200e-02f, -4.24300842e-02f, -1.59095883e-01f, -1.26778260e-01f, -8.42696428e-02f, -3.88174802e-02f, 1.94321610e-02f,
  -2.08452772e-02f, -2.52253920e-01f, -1.47182256e-01f, 7.08934963e-02f, -1.87794771e-02f, -1.46183921e-02f, -2.52476424e-01f, -9.29900780e-02f, -4.60240580e-02f, -2.76732504e-01f,
  -2.75636047e-01f, 2.47317031e-01f, 7.64826015e-02f, -1.27753206e-02f, -1.17498063e-01f, 1.14394547e-02f, -7.13279694e-02f, 2.17349306e-02f, 4.15789410e-02f, -6.19378015e-02f,
  3.40268202e-02f, -9.93934646e-03f, -6.26332536e-02f, 1.67557076e-02f, -6.09619059e-02f, 7.88660161e-03f, -3.11718672e-03f, -7.58262873e-02f, 3.11233737e-02f, -5.33843897e-02f,
  9.95986909e-02f, 1.14459157e-01f, 1.32468641e-01f, 2.73579266e-03f, 7.83043429e-02f, 9.86853614e-02f, 7.10331276e-02f, 6.48481026e-02f, 7.38026723e-02f, -2.01113626e-01f,
  6.76425500e-03f, 1.07936445e-03f, 8.73019639e-03f, 1.03846051e-01f, -9.17968526e-02f, 7.50575513e-02f, -6.87811747e-02f, -8.39058775e-03f, 1.13290399e-02f, -1.17816599e-02f,
  -5.99097759e-02f, -2.77295690e-02f, 9.27516073e-03f, 2.76880786e-02f, -4.27732542e-02f, 1.28432484e-02f, 4.09976915e-02f, -7.61889219e-02f, 6.80754259e-02f, 2.56072488e-02f,
  1.98045000e-02f, 6.77301586e-02f, -1.41663384e-02f, 7.33477026e-02f, 2.67739184e-02f, -6.34901896e-02f, 2.37047188e-02f, 2.37504393e-02f, -8.41292590e-02f, -2.50851847e-02f,
  -3.50239128e-01f, 1.39844745e-01f, -6.56522438e-02f, 5.12752831e-02f, -1.35157779e-02f, 3.44475848e-03f, -4.63793948e-02f, -2.87793707e-02f, 3.81443910e-02f, -5.60227558e-02f,
  1.10962033e-01f, -3.33316065e-02f, -9.21118930e-02f, 4.90088128e-02f, -3.59329246e-02f, 9.33328643e-02f, -1.18071660e-01f, -4.17813472e-02f, 7.24889711e-02f, -2.12961901e-03f,
  -1.61975667e-01f, -1.97396036e-02f, -5.52003346e-02f, -7.71030709e-02f, 1.13788731e-01f, 7.03404052e-03f, 5.60532659e-02f, 7.04785623e-03f, 1.33855045e-02f, -1.99021071e-01f,
  6.12257540e-01f, -2.33849436e-01f, 3.42995733e-01f, 2.22581297e-01f, 3.42644900e-01f, 3.24187011e-01f, 3.26864898e-01f, 1.40119493e-01f, 1.35738134e-01f, -2.15631071e-02f,
  -1.54881626e-01f, -3.31949204e-01f, -3.39718193e-01f, -3.93266231e-01f, -1.66147098e-01f, 8.53895955e-03f, 1.43838804e-02f, 9.92205441e-02f, 1.74742788e-01f, 1.26979500e-01f,
  -4.62231375e-02f, -4.86848019e-02f, 5.64186908e-02f, -7.56944790e-02f, 3.17346454e-02f, 6.11703983e-03f, -7.90849477e-02f, 4.59420085e-02f, -1.86394289e-01f, -3.13024342e-01f,
  -5.43291420e-02f, 6.45856708e-02f, 1.13993280e-01f, -4.75149639e-02f, 2.11828873e-02f, 3.31551023e-02f, 3.10311913e-02f, -3.86636257e-02f, -1.60334131e-03f, 2.53901202e-02f,
  1.08571239e-02f, -4.25950252e-02f, -2.85922289e-02f, -8.18366650e-04f, 1.50831640e-01f, 9.75772738e-02f, 9.17803645e-02f, 4.30802722e-03f, -1.44731730e-01f, -8.81605297e-02f,
  -2.02185363e-01f, 1.23867519e-01f, 1.56539991e-01f, -4.62919883e-02f, -8.26353207e-02f, 1.99157763e-02f, 6.56132121e-03f, -2.19601281e-02f, -1.86800100e-02f, 1.79001838e-02f,
  4.32083122e-02f, -2.63273548e-02f, 4.13624458e-02f, -1.66855492e-02f, 2.95211980e-03f, 4.60118577e-02f, 4.08735760e-02f, -6.70813322e-02f, 6.79184571e-02f, 2.12884508e-02f,
  -9.05268546e-03f, -1.00062065e-01f, -4.36380729e-02f, 3.89048667e-03f, -5.89980744e-02f, 6.55334741e-02f, -4.85340767e-02f, -8.21107253e-02f, 3.59181203e-02f, -7.97039792e-02f,
  3.59580107e-02f, 4.41969782e-02f, 7.91214183e-02f, -1.65034443e-01f, -3.29954140e-02f, -9.96859670e-02f, 4.02015038e-02f, -9.70654041e-02f, -8.46306561e-04f, 1.18860215e-01f,
  -2.44805977e-01f, -6.29520938e-02f, 1.58896707e-02f, -1.29773051e-01f, 4.43769507e-02f, -3.60730253e-02f, 8.09910614e-03f, -7.22675249e-02f, -9.55627784e-02f, -4.06864798e-03f,
  -4.85018641e-02f, -7.76046887e-02f, -5.32976463e-02f, -6.97357953e-02f, 1.67520776e-01f, 7.09447265e-02f, -1.03273153e-01f, -1.94650088e-02f, -1.03150353e-01f, -3.80478203e-02f,
  -1.66584879e-01f, 1.52212575e-01f, 1.18995771e-01f, 8.51299167e-02f, -2.89905327e-03f, 8.60022381e-02f, 9.63273048e-02f, 4.51525524e-02f, 4.66799028e-02f, 2.46142268e-01f,
  3.08723122e-01f, 3.89272064e-01f, 2.44611710e-01f, 2.53508650e-02f, -7.74884745e-02f, -8.78231227e-02f, 2.43627787e-01f, 8.23568851e-02f, -1.53505847e-01f, 7.49553442e-02f,
  -1.65081576e-01f, -2.17434555e-01f, -1.79151192e-01f, -9.71517786e-02f, 1.29605338e-01f, 9.48726311e-02f, 4.65780906e-02f, -6.75375434e-03f, -1.25882685e-01f, -4.57842834e-02f,
  -1.09045625e-01f, 1.19064316e-01f, 8.13965574e-02f, 1.82657631e-03f, 5.29060699e-02f, -1.21469922e-01f, -1.96373891e-02f, 7.94567354e-03f, 1.85975488e-02f, 2.34358564e-01f,
  8.19932073e-02f, 3.68787199e-01f, -1.56888679e-01f, -5.40703908e-02f, -1.27013668e-01f, -7.48720160e-03f, -2.91499812e-02f, -1.37629127e-02f, -4.98886406e-02f, 3.83855365e-02f,
  -8.99956748e-02f, -8.48677754e-03f, 5.88576309e-02f, -4.56771292e-02f, -6.80658966e-02f, -8.68000686e-02f, -4.33030613e-02f, 4.25766818e-02f, 4.02159169e-02f, -1.27078121e-04f,
  9.29011498e-03f, -1.67595092e-02f, 7.40220919e-02f, 6.68538362e-02f, -5.66748343e-02f, -2.96410993e-02f, 1.40253767e-01f, 1.08037025e-01f, -1.52878575e-02f, -3.52295600e-02f,
  -2.00909019e-01f, 9.83310491e-02f, 6.58026189e-02f, -8.34255517e-02f, -4.92878035e-02f, 7.02653360e-03f, -6.73349947e-03f, -1.17455259e-01f, -7.70237530e-03f, -6.35834411e-02f,
  -3.27227190e-02f, -1.51831349e-02f, 2.14319099e-02f, -1.13271438e-02f, -9.74860117e-02f, -1.43515272e-02f, -1.34184808e-02f, 1.12982066e-02f, -4.72189039e-02f, 2.11499538e-02f,
  2.13233251e-02f, -2.02593990e-02f, -6.12272099e-02f, 6.82089552e-02f, -2.21028402e-02f, -8.26117694e-02f, -2.65734419e-02f, -1.25164427e-02f, 2.23557204e-02f, 5.93900904e-02f,
  -1.75491482e-01f, -1.13662601e-01f, -2.96720043e-02f, 1.63876042e-01f, 1.89579499e-03f, 4.72549088e-02f, 4.27249353e-03f, 1.57873750e-01f, 3.74207124e-02f, 1.50330812e-01f,
  -2.40829829e-02f, -4.05367203e-02f, -1.01777334e-02f, -2.50014551e-02f, -1.07663885e-01f, -2.68503670e-02f, 3.55051737e-03f, -5.52883297e-02f, 2.76471321e-02f, 1.31524161e-01f,
  2.28755604e-02f, -2.97651794e-02f, -1.04323961e-01f, -2.47128177e-02f, -4.58848737e-02f, -1.83353543e-01f, 3.31757008e-03f, -3.66497673e-02f, 1.32370070e-02f, -1.06655866e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.67544001e-01f, 4.12167251e-01f, 8.55786055e-02f, 4.10730481e-01f, 5.81343412e-01f, -1.30300736e-02f, 1.59123495e-01f, 3.07443559e-01f, 2.20670298e-01f, 2.35499710e-01f,
  1.23937830e-01f, 7.99894109e-02f, 3.16160411e-01f, 1.61422104e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.70272201e-01f, 1.70435235e-01f, -4.08330232e-01f, -2.32345849e-01f, 1.35405764e-01f, -1.11032121e-01f, 1.59427032e-01f, 3.34549621e-02f, 7.73551837e-02f, -1.95942700e-01f,
  -2.85649955e-01f, 2.67483532e-01f, -2.63658702e-01f, -5.35168462e-02f, -1.27695635e-01f, -2.63243556e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.66500914e-01f, 9.05945122e-01f, 5.88545203e-01f, 9.64716733e-01f, 5.18928766e-01f, 8.68504345e-02f, 2.91782767e-01f, -2.68772483e-01f, 9.53140855e-01f, -2.58603662e-01f,
  5.65428674e-01f, 5.23878373e-02f, -2.56042451e-01f, -3.78615350e-01f, -1.18566126e-01f, 3.10071975e-01f, 6.09597452e-02f, -5.74135900e-01f, 6.35579407e-01f, -7.06447586e-02f,
  1.86017036e-01f, 4.67730045e-01f, -3.78428288e-02f, -1.45988436e-02f, -1.05780996e-01f, 6.75618529e-01f, -1.64849773e-01f, -2.68433452e-01f, 2.84467489e-01f, 3.55522543e-01f,
  -3.12919855e-01f, -9.18669254e-02f, 1.02178872e-01f, -3.84709090e-01f, -1.33375704e-01f, -1.04742430e-01f, -1.99964419e-01f, -2.94744879e-01f, 5.49868643e-01f, -1.62816197e-01f,
  -1.30156010e-01f, 8.94309506e-02f, 2.22354472e-01f, 3.19630295e-01f, -7.93599337e-02f, -1.45044297e-01f, -1.98215377e-02f, 2.39656165e-01f, 3.03127497e-01f, -3.97042662e-01f,
  -2.08711289e-02f, -2.07780063e-01f, 1.32707775e-01f, 2.31705680e-02f, 1.34797201e-01f, -1.10453703e-01f, 4.51568633e-01f, -1.82531089e-01f, -8.94892886e-02f, -1.39183268e-01f,
  -3.69805276e-01f, -3.07469130e-01f, 5.50936997e-01f, -2.04510182e-01f, 6.00458860e-01f, -2.72599339e-01f, -4.44194794e-01f, 1.65107563e-01f, -9.37933996e-02f, 5.36889911e-01f,
  4.69996631e-01f, -3.54776293e-01f, 1.50321648e-01f, 3.94082606e-01f, 3.18783969e-02f, -1.54163420e-01f, -4.35995042e-01f, -3.48382711e-01f, 9.99027491e-01f, 2.84958899e-01f,
  2.22911760e-01f, 9.84994322e-02f, 3.79654430e-02f, 2.05942109e-01f, 2.29094163e-01f, 5.32789767e-01f, 2.43909404e-01f, 2.71619767e-01f, -7.60328174e-02f, -4.69417311e-02f,
  2.79173106e-01f, 7.25025594e-01f, -2.85767205e-02f, 5.51756203e-01f, -1.82220757e-01f, -3.23045611e-01f, 1.31542280e-01f, 1.83095008e-01f, -9.35858563e-02f, 1.70337304e-01f,
  -2.58843303e-01f, -2.00686172e-01f, 6.49585485e-01f, 6.43608272e-01f, -3.80227529e-02f, -4.13469136e-01f, 3.84517193e-01f, 9.03695047e-01f, 8.17934200e-02f, 1.54114008e-01f,
  1.21132424e-02f, -4.72986745e-03f, 6.81488821e-03f, -4.78992522e-01f, 7.46047378e-01f, 3.87658089e-01f, -1.60655364e-01f, -2.26650342e-01f, 2.68432766e-01f, 9.63023379e-02f,
  -1.85477659e-01f, 7.56289184e-01f, 7.32704997e-02f, -2.84479111e-01f, -2.62875408e-01f, 3.22027594e-01f, 1.37244657e-01f, 5.70736527e-01f, 6.14401810e-02f, -4.84812796e-01f,
  -7.50106573e-02f, 5.88945718e-03f, -1.08717725e-01f, -4.60743517e-01f, 5.63396633e-01f, 5.88957787e-01f, 1.53817564e-01f, -1.58706233e-02f, 5.41372299e-02f, 2.75403976e-01f,
  1.12089338e-02f, 5.15120566e-01f, -1.69991985e-01f, 1.06722623e-01f, 2.32469603e-01f, 9.97696593e-02f, 3.06505188e-02f, 9.28233285e-03f, -1.42712250e-01f, -1.52931571e-01f,
  -1.14102185e-01f, -1.36863649e-01f, -1.01645336e-01f, -1.20953741e-02f, -5.10584563e-02f, -1.17708795e-01f, -2.24119604e-01f, 4.70700338e-02f, 1.85055852e-01f, 8.61701742e-02f,
  5.30563235e-01f, -5.08382246e-02f, -4.48398851e-02f, -1.41781792e-01f, 4.42898095e-01f, 1.09393001e+00f, 7.23532289e-02f, -1.21386722e-02f, 3.48138183e-01f, 5.16501023e-03f,
  1.24686606e-01f, 4.14663404e-01f, 1.16084188e-01f, 3.93542945e-01f, 2.36978665e-01f, -4.93207604e-01f, 5.16462028e-02f, -3.16537440e-01f, 1.65564306e-02f, -1.21312536e-01f,
  -2.87557900e-01f, 9.01590705e-01f, 1.42326623e-01f, -6.10743202e-02f, -4.23891544e-01f, 7.63004601e-01f, -1.71349898e-01f, 3.91349718e-02f, -8.30668733e-02f, 1.18468851e-01f,
  3.56661350e-01f, 1.47136405e-01f, 4.12644207e-01f, 2.20301419e-01f, -3.56630266e-01f, 7.26187155e-02f, -2.34973077e-02f, 8.02399218e-01f, 4.78349835e-01f, -3.45763087e-01f,
  3.08928519e-01f, 3.08008939e-01f, 6.02499172e-02f, 1.39651135e-01f, -4.72533479e-02f, -1.20226778e-01f, 3.96801412e-01f, -1.90941304e-01f, 1.12388223e-01f, 4.39650416e-02f,
  4.11288105e-02f, -1.31756485e-01f, 6.49873540e-02f, 3.16519998e-02f, 5.68786524e-02f, -5.64911142e-02f, -1.06501520e-01f, 1.60686985e-01f, 2.72095725e-02f, -2.16918468e-01f,
  -9.25730690e-02f, 2.00783819e-01f, -2.19271153e-01f, -2.19099358e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  7.26367176e-01f, 2.24114731e-01f, 5.46611212e-02f, 2.99274981e-01f, 4.99993235e-01f, 1.29796639e-01f, 2.97345370e-01f, 4.35183465e-01f, 2.71999389e-01f, 4.36212793e-02f,
  4.55152839e-01f, 2.88408488e-01f, 3.72670263e-01f, -1.61513135e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.50082394e-01f, -4.98838663e-01f, 2.99335778e-01f, 1.39187589e-01f, -5.09413034e-02f, -3.55306417e-01f, -2.34041780e-01f, -4.36228402e-02f, 3.72897573e-02f, 1.08286627e-01f,
  3.98010947e-02f, -1.76811740e-01f, -2.32693732e-01f, 2.02961743e-01f, -6.36103675e-02f, -1.05331972e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.03673199e-01f, -1.36659697e-01f, -2.87345022e-01f, 8.64708602e-01f, -2.65158623e-01f, -4.87379590e-03f, -4.03474212e-01f, 3.26743960e-01f, -2.21953467e-02f, 5.43595254e-01f,
  -4.32199761e-02f, -3.16988230e-02f, 4.76465166e-01f, 2.75902629e-01f, -1.18901618e-01f, 1.89588919e-01f, -2.82418817e-01f, -1.72843561e-01f, -3.57419811e-02f, 5.41251659e-01f,
  7.56401122e-02f, -4.67104644e-01f, 2.02838078e-01f, 9.01431049e-05f, -2.00166985e-01f, 5.63565135e-01f, -1.64026380e-01f, -4.09796275e-02f, -1.45611033e-01f, 6.52935505e-01f,
  1.77274629e-01f, -1.56997204e-01f, 5.50510764e-01f, 1.64120123e-01f, -1.33228391e-01f, 1.73834190e-01f, -2.80605316e-01f, 4.07999575e-01f, 8.78218830e-01f, 2.00916931e-01f,
  -3.76755774e-01f, -3.00727099e-01f, -3.77747655e-01f, -5.03359325e-02f, 6.09914362e-01f, 4.60010856e-01f, 7.86076009e-01f, 2.20730722e-01f, 6.44681081e-02f, 4.39247131e-01f,
  4.85916138e-01f, -3.39934886e-01f, 1.33745655e-01f, -5.59526324e-01f, -3.53662491e-01f, 6.71670318e-01f, 6.61326766e-01f, -7.77382076e-01f, -1.51399881e-01f, -2.24424213e-01f,
  7.62670815e-01f, 2.13325426e-01f, 6.64402783e-01f, -4.04394837e-03f, 5.95442671e-03f, -2.38392547e-01f, -5.02833664e-01f, 3.13752443e-01f, 1.12480760e-01f, 1.11953229e-01f,
  1.05588824e-01f, 1.68062553e-01f, -3.72986078e-01f, 1.65803000e-01f, -2.15855092e-01f, 6.59830868e-02f, 4.52902466e-01f, 4.29193854e-01f, -9.51468870e-02f, -1.30954638e-01f,
  -3.23465168e-02f, -3.15166354e-01f, -3.37609142e-01f, 3.45291466e-01f, 1.74813092e-01f, -1.91407681e-01f, 3.70345026e-01f, 2.33391702e-01f, -1.39231995e-01f, 5.35998821e-01f,
  5.82483038e-02f, -1.11780889e-01f, -5.64297773e-02f, 2.88347155e-01f, -4.56693694e-02f, 1.34441340e-02f, -1.53485909e-01f, 3.55723836e-02f, -1.39470890e-01f, 4.83472310e-02f,
  -1.87133119e-01f, 2.01108515e-01f, 3.31058860e-01f, 1.68743923e-01f, -1.92530200e-01f, -1.35175034e-01f, -1.84377775e-01f, 8.38219654e-03f, 4.07407969e-01f, 3.27799827e-01f,
  4.87778783e-01f, -2.36570388e-01f, -2.39300162e-01f, -6.08776771e-02f, -9.55791473e-02f, 2.41225719e-01f, 1.59993112e-01f, -3.43377069e-02f, 7.30224475e-02f, -5.44637553e-02f,
  4.04563546e-01f, -8.25854465e-02f, 3.75849307e-01f, 2.18372986e-01f, -1.28351137e-01f, -1.06545664e-01f, 1.89451501e-01f, 3.10206637e-02f, 1.09108396e-01f, -1.67011246e-01f,
  2.42951021e-01f, 2.64198072e-02f, -8.09453204e-02f, -1.31864518e-01f, 5.57968430e-02f, -1.76346704e-01f, -2.56377935e-01f, 7.39207327e-01f, -8.72143283e-02f, 1.51561022e-01f,
  -4.24213052e-01f, 1.89468652e-01f, -1.94175333e-01f, 2.08492026e-01f, 5.26733577e-01f, 8.88631716e-02f, 4.28926975e-01f, 2.81965405e-01f, -3.81638110e-01f, -2.99273551e-01f,
  -3.07454050e-01f, 3.78804833e-01f, -1.42562211e-01f, -2.49651819e-01f, 2.58870840e-01f, -1.81221709e-01f, 6.64762735e-01f, 1.70817748e-01f, -3.16194296e-02f, 1.72715150e-02f,
  2.40143985e-01f, -3.45796853e-01f, 1.68864787e+00f, -3.64760309e-01f, 2.68230587e-02f, 2.16114104e-01f, 2.01346770e-01f, -1.74577177e-01f, 2.91122615e-01f, 2.91497171e-01f,
  3.50139588e-02f, -7.58162364e-02f, 1.01004792e-02f, -3.51578742e-01f, 7.48436153e-02f, -1.67246699e-01f, 1.13366455e-01f, 3.30881357e-01f, -5.49237013e-01f, -2.99353749e-01f,
  4.36213762e-01f, -2.56662756e-01f, -1.31971076e-01f, 6.78948581e-01f, 9.96561289e-01f, 2.55434543e-01f, 9.78708804e-01f, -3.94220874e-02f, 2.52105087e-01f, 2.24022850e-01f,
  1.23768451e-03f, -7.95673952e-03f, 7.49947578e-02f, -2.01733455e-01f, -5.77010989e-01f, -2.67751306e-01f, -2.50859171e-01f, 1.23606071e-01f, 4.31916296e-01f, -1.25432849e-01f,
  2.14596733e-01f, -2.83504248e-01f, -1.61590278e-01f, -2.29712166e-02f, 3.83148372e-01f, 4.44021493e-01f, 2.37073705e-01f, 1.11243859e-01f, 5.89072168e-01f, 1.86455473e-01f,
  -2.32647911e-01f, -1.70046002e-01f, 3.17056566e-01f, 4.08737183e-01f, 1.10677409e+00f, -3.44233274e-01f, -2.37152427e-01f, 1.55169740e-01f, 1.12255782e-01f, 1.50079444e-01f,
  2.04895794e-01f, 6.13005519e-01f, 6.25063241e-01f, -7.81717747e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -9.69526470e-02f, 4.23786007e-02f, 2.49453545e-01f, 1.67638376e-01f, -3.24152261e-01f, -1.02279030e-01f, 6.06899932e-02f, -3.71116698e-02f, 1.12922423e-01f, 7.94430077e-02f,
  5.04385233e-01f, 2.34687388e-01f, -1.00812376e-01f, 6.87888503e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.74791622e-01f, -1.82886407e-01f, 2.48822063e-01f, -1.15692236e-01f, -7.55864661e-03f, 4.15445715e-01f, 1.57887444e-01f, -1.86182722e-01f, 4.00494486e-01f, 6.38725683e-02f,
  9.29731354e-02f, 1.17261363e-02f, -7.34620214e-01f, 4.31737751e-01f, 3.80024940e-01f, -1.92498937e-01f, -2.46762395e-01f, -3.42967622e-02f, 3.75395209e-01f, 4.31120753e-01f,
  5.88143706e-01f, 7.98671097e-02f, 7.12825418e-01f, 3.69988054e-01f, 1.42038807e-01f, -1.67261586e-01f, -2.35350385e-01f, 4.87486012e-02f, -1.01600909e+00f, -3.74118179e-01f,
  7.85671771e-02f, 1.13206737e-01f, 3.51512402e-01f, -2.15490505e-01f, -1.71850890e-01f, -6.23886943e-01f, 5.12709200e-01f, 2.64179677e-01f, -1.53479904e-01f, -4.60539103e-01f,
  1.85327515e-01f, -4.75370809e-02f, -3.46563280e-01f, 5.01251101e-01f, 4.51343387e-01f, -8.01310241e-01f, -5.62358677e-01f, 1.41247019e-01f, -1.41754210e-01f, -2.98429191e-01f,
  -5.91198839e-02f, -1.49425760e-01f, -8.49223435e-01f, -1.16523325e-01f, -7.53987655e-02f, 2.38132596e-01f, -6.01717293e-01f, 1.47749335e-01f, -9.03504044e-02f, 3.32494885e-01f,
  -1.96299210e-01f, 1.06629372e+00f, -1.31549984e-01f, -4.99169111e-01f, -7.51011074e-03f, -2.81408072e-01f, -3.49230528e-01f, -2.47069150e-01f, -1.79509714e-01f, 8.37273180e-01f,
  -3.60741228e-01f, 1.01404235e-01f, 1.30716115e-01f, 3.48708779e-01f, -8.41036215e-02f, -1.62653446e-01f, 4.10020232e-01f, 3.27718139e-01f, -2.62655765e-01f, -5.41998506e-01f,
  3.52092162e-02f, -6.81116655e-02f, -3.94153714e-01f, 4.79892343e-02f, 5.32670856e-01f, 6.83764279e-01f, -3.11264515e-01f, -2.01550335e-01f, 5.92905246e-02f, -2.37887248e-01f,
  -2.18954131e-01f, 3.63420905e-03f, -1.74075067e-01f, -2.80396670e-01f, 3.38399947e-01f, 3.34418237e-01f, -4.50622812e-02f, 8.27122331e-01f, -3.83657187e-01f, 7.42042884e-02f,
  -3.81646901e-01f, -9.13954794e-01f, -8.85508582e-02f, -3.37949902e-01f, -2.65319496e-01f, 7.06014708e-02f, 5.40150225e-01f, -1.85875997e-01f, 9.97763693e-01f, -8.00802857e-02f,
  -1.13883607e-01f, -5.40378273e-01f, -4.77910906e-01f, 4.56558883e-01f, 9.53416348e-01f, 6.36758029e-01f, -7.56119132e-01f, -1.98176846e-01f, 6.65044188e-02f, 3.22394818e-01f,
  -2.73092270e-01f, 1.78365931e-01f, 5.08340836e-01f, -2.31861502e-01f, -2.90078893e-02f, -2.48996019e-01f, -1.93440169e-01f, -4.47148979e-01f, -1.72644183e-01f, -3.49405140e-01f,
  -4.14438665e-01f, -1.38536736e-01f, 5.88326633e-01f, -7.52519965e-01f, 2.14821160e-01f, -2.07507480e-02f, 2.77985632e-01f, -1.20104149e-01f, 2.56808195e-02f, -5.67920923e-01f,
  -2.16309264e-01f, -6.82306468e-01f, 5.07475615e-01f, 7.02421665e-01f, 3.84140462e-02f, 4.61659193e-01f, -1.71816662e-01f, -4.01165001e-02f, -3.72165889e-01f, 7.37146854e-01f,
  -7.96065032e-02f, -1.01965263e-01f, -3.83352727e-01f, -1.36184499e-01f, -4.32296127e-01f, 3.03045243e-01f, 7.99957871e-01f, -5.63057244e-01f, -1.85953408e-01f, -7.28041470e-01f,
  5.11056900e-01f, -9.86941218e-01f, -4.35142606e-01f, -3.90200585e-01f, 2.94539973e-06f, -1.92898929e-01f, -4.89811838e-01f, -1.90242216e-01f, -2.71771550e-01f, 2.88810790e-01f,
  -3.21821749e-01f, -5.38329899e-01f, 7.67907947e-02f, 4.64589000e-01f, -2.40997195e-01f, 9.04900610e-01f, 5.01522236e-02f, 2.95573592e-01f, -3.00460249e-01f, 4.39327478e-01f,
  4.07123193e-02f, -4.67932701e-01f, -5.30288406e-02f, 4.61765796e-01f, 1.88787550e-01f, 5.09127788e-02f, 4.22292769e-01f, -5.48156559e-01f, 2.43151531e-01f, -3.45916241e-01f,
  -3.40770036e-01f, 5.56955159e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.78457338e-01f, -4.42219824e-01f, 3.20827663e-01f, 8.47181454e-02f, -2.12120667e-01f, 1.11951135e-01f, 1.96853578e-01f, -1.88404191e-02f, -3.15259635e-01f, -2.26429831e-02f,
  3.76761705e-01f, 6.58498108e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    