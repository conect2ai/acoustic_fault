/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.47847873e-01f, 5.50434530e-01f, 5.43789744e-01f, 1.18813373e-01f, -3.58619303e-01f, -1.85150012e-01f, 1.03869382e-02f, 3.30780447e-02f, -1.91402212e-01f, 3.83948982e-02f,
  -5.89116700e-02f, 3.79847996e-02f, 1.01816349e-01f, 2.24707022e-01f, -1.22638322e-01f, 1.21557936e-01f, -1.28198385e-01f, 4.86550927e-02f, 4.97632585e-02f, 2.35565770e-02f,
  -5.76160401e-02f, 5.50891757e-02f, 2.00196221e-01f, 8.92669987e-03f, 1.85382813e-02f, 6.46851510e-02f, -6.63962141e-02f, 6.84298202e-02f, 8.13913532e-03f, -1.39190760e-02f,
  1.56788886e-01f, 9.40293595e-02f, 5.86312041e-02f, 1.86325833e-02f, -2.91317683e-02f, -3.88387404e-02f, -2.50333808e-02f, 9.85952914e-02f, -2.90049408e-02f, 9.17187054e-03f,
  -1.18825654e-03f, 1.57874241e-03f, 2.12709941e-02f, 9.74388048e-03f, -5.64337596e-02f, 5.74539602e-03f, -2.78325373e-04f, -3.72948847e-03f, 6.82271197e-02f, 3.01907547e-02f,
  6.92529157e-02f, 4.49706540e-02f, -2.86138039e-02f, 3.32403491e-04f, -2.46986281e-02f, 1.86691061e-02f, 1.16149988e-02f, 1.87244210e-02f, -2.22521592e-02f, -4.29336317e-02f,
  -1.19499438e-01f, -4.34725136e-02f, 9.50616412e-03f, 2.23484822e-02f, 1.88933294e-02f, 3.56335826e-02f, -2.58778650e-02f, 3.07478616e-03f, -2.19790377e-02f, 4.30629626e-02f,
  -5.71531914e-02f, -4.34930669e-03f, -8.36156011e-02f, -6.01482429e-02f, -8.22544284e-03f, -1.18491380e-02f, 1.90047210e-03f, 3.09284180e-02f, -2.31108032e-02f, -2.29313341e-03f,
  2.17445809e-02f, -8.75906367e-03f, 4.98287641e-02f, -2.69391630e-02f, 1.69124178e-04f, 2.16650516e-02f, -5.81475440e-03f, 1.71355642e-02f, 2.58586127e-02f, -4.16192487e-02f,
  -9.41078961e-02f, -4.23144810e-02f, 5.70715666e-02f, -2.53080409e-02f, 4.01393846e-02f, -4.10645120e-02f, 4.50219736e-02f, -4.80420925e-02f, -2.83157919e-03f, -2.96188444e-02f,
  -4.84372824e-02f, 1.26787964e-02f, -8.41970742e-02f, -2.34248117e-02f, 4.95515540e-02f, -3.02265827e-02f, -3.04330438e-02f, -4.62699272e-02f, -1.10595532e-01f, 1.97721422e-02f,
  -4.06004414e-02f, -4.35642004e-02f, 5.04187495e-03f, 6.06018817e-03f, -5.08741252e-02f, -3.54169495e-02f, -1.01120889e-01f, 8.55608005e-03f, -3.55986618e-02f, 5.22352848e-03f,
  6.81963116e-02f, 4.41459268e-02f, 1.48262963e-01f, 1.63767785e-01f, 2.31461227e-01f, 9.23062563e-02f, 5.12848496e-02f, 1.04070053e-01f, -8.18019956e-02f, -1.54378965e-01f,
  -1.09250359e-01f, -1.18034758e-01f, -2.35779449e-01f, -7.06156120e-02f, -1.00999549e-02f, -2.20807940e-01f, 6.74648434e-02f, 6.56640111e-03f, -2.24426738e-03f, 2.94816727e-03f,
  2.42765062e-02f, -4.20498550e-02f, 4.98272404e-02f, 7.08285570e-02f, 8.53593349e-02f, 2.22792462e-01f, 1.41852662e-01f, -2.24082973e-02f, 1.13826908e-01f, 2.66390736e-03f,
  -1.44754261e-01f, -2.26099398e-02f, 6.72370791e-02f, -9.45724323e-02f, 1.38289034e-01f, 3.93485837e-02f, -2.04831474e-02f, -5.35326190e-02f, 1.28874062e-02f, -5.39281815e-02f,
  -6.28717467e-02f, -3.89716737e-02f, -5.13735460e-03f, -1.49419755e-02f, -1.11294677e-02f, 4.54259701e-02f, 3.06840092e-02f, -1.41190868e-02f, -3.95446755e-02f, -1.11385258e-02f,
  9.80746839e-03f, -1.21983029e-02f, 2.55992692e-02f, 4.62820381e-02f, 2.34692954e-02f, -9.53479018e-03f, -5.42955175e-02f, -1.46742230e-02f, 1.83326099e-02f, 6.50487393e-02f,
  -5.41458689e-02f, -2.89152972e-02f, 3.77309211e-02f, 4.03138958e-02f, 8.06291252e-02f, 4.34014499e-02f, -1.05184456e-03f, 3.34339440e-02f, 5.63218556e-02f, 1.14531815e-02f,
  4.94772531e-02f, 1.01616783e-02f, -7.82534927e-02f, -1.64240003e-02f, -4.06398475e-02f, -3.36697474e-02f, -1.11455321e-02f, -3.87814008e-02f, 3.48569676e-02f, 1.00292712e-02f,
  -7.96016976e-02f, 1.57283153e-02f, 1.29135419e-02f, -6.49118051e-02f, -6.35237247e-02f, 1.09797819e-02f, -4.53801788e-02f, -7.15577975e-02f, -1.71517245e-02f, 1.84409525e-02f,
  -2.57579722e-02f, 2.50848755e-02f, -2.94491835e-02f, -8.91702436e-03f, 4.53322083e-02f, 1.05659954e-01f, -7.25963786e-02f, -6.80731470e-03f, -4.47950363e-02f, 3.21844071e-02f,
  -1.89393922e-03f, 2.32156869e-02f, 6.47403821e-02f, -5.64554706e-03f, -4.96873632e-03f, -2.10831426e-02f, -9.98343974e-02f, 8.13611895e-02f, 4.07079794e-02f, -3.78405442e-03f,
  3.86672653e-02f, -3.04261409e-02f, 3.12154577e-03f, 8.91017318e-02f, -2.38788351e-02f, -1.81059651e-02f, 7.10043088e-02f, 3.89999966e-03f, 3.38461623e-03f, -4.87878248e-02f,
  -2.33242840e-01f, 6.07968271e-02f, -1.86910685e-02f, -2.38123760e-01f, 4.03791480e-02f, 1.04125939e-01f, 2.30812710e-02f, 5.25147244e-02f, -1.44557923e-01f, 2.05417112e-01f,
  -1.51028559e-01f, -1.27357962e-02f, -3.04190423e-02f, -9.70472991e-02f, -5.33541024e-01f, -1.45347416e-01f, -9.46301892e-02f, -4.04111594e-02f, -6.40754029e-02f, 4.95594554e-02f,
  -1.00825891e-01f, -4.75956947e-02f, -7.37982914e-02f, 2.55780779e-02f, 1.31198227e-01f, 9.37378705e-02f, 3.24820615e-02f, 1.12932615e-01f, -1.18315602e-02f, -5.05184494e-02f,
  -5.25220186e-02f, -1.69658065e-02f, 3.67743075e-02f, 8.10108781e-02f, 1.34765329e-02f, 9.28823426e-02f, 5.16565032e-02f, -4.06016447e-02f, -5.96182831e-02f, -2.58420547e-03f,
  -1.00572724e-02f, -2.28295941e-02f, -5.77075891e-02f, -2.35741939e-02f, 7.71143809e-02f, -4.34320383e-02f, -4.03742678e-02f, 1.77652948e-02f, -3.55467610e-02f, -3.12552638e-02f,
  -3.60490605e-02f, -3.65370922e-02f, 3.92747447e-02f, -4.58210148e-02f, 5.93111990e-03f, 2.05459297e-02f, 2.69467644e-02f, 1.54381441e-02f, 1.87926888e-02f, -7.87521433e-03f,
  1.38935577e-02f, 3.80896311e-03f, 4.75971913e-03f, -9.59176384e-03f, -2.93800030e-02f, 1.23644220e-02f, -1.96603034e-02f, 1.83032136e-02f, 1.85302214e-03f, 6.62837829e-03f,
  -2.53962148e-02f, -3.51232700e-02f, -9.53417923e-03f, 3.29975933e-02f, 1.44822309e-02f, 2.24331114e-02f, -8.85010790e-03f, 1.55683421e-03f, -2.05217116e-02f, 1.78593732e-02f,
  -1.16447257e-02f, 2.99281776e-02f, 1.92584321e-02f, 7.31897494e-03f, -3.05566564e-03f, -2.77103074e-02f, -5.73670084e-04f, 2.07269881e-02f, -3.66177992e-03f, -1.41257299e-02f,
  -3.12515013e-02f, 5.41837923e-02f, 1.32721467e-02f, -2.26718709e-02f, -1.75899323e-02f, -3.79715785e-02f, -8.96569490e-02f, 6.01496734e-03f, 1.68950073e-02f, -5.46820229e-03f,
  8.81517008e-02f, 4.13476862e-02f, 7.04612285e-02f, -3.36270630e-02f, -4.89626117e-02f, 3.50150056e-02f, 2.68326309e-02f, -1.18735870e-02f, 4.72949855e-02f, -3.50196548e-02f,
  3.59798931e-02f, 2.54360531e-02f, 5.53141464e-04f, 7.26560801e-02f, 1.16186142e-02f, 2.22964250e-02f, 2.56997417e-03f, 7.41873635e-04f, -1.00580743e-02f, 6.47632126e-03f,
  6.16201639e-01f, 1.54271886e-01f, 9.49651077e-02f, 1.56724945e-01f, 1.10826962e-01f, 2.86245048e-01f, 2.50179976e-01f, 1.06811442e-03f, -4.66459952e-02f, -9.67435911e-02f,
  6.62972257e-02f, 3.43261380e-03f, -7.53776357e-02f, 1.78687334e-01f, 2.27058977e-01f, -1.26643926e-01f, 2.45418444e-01f, 2.03973483e-02f, -6.24562092e-02f, 8.28379095e-02f,
  7.91293830e-02f, 7.12893531e-02f, 7.71025196e-02f, -6.79039881e-02f, 1.76211983e-01f, 2.34842189e-02f, -6.94478080e-02f, 2.02283598e-02f, -1.68843940e-02f, 5.84099852e-02f,
  -1.47816733e-01f, -2.36609429e-01f, 4.77700122e-02f, -1.89392064e-02f, 4.33536544e-02f, -8.25195760e-03f, 4.99000251e-02f, -1.29127800e-02f, -2.36467607e-02f, -2.74021551e-02f,
  1.26533164e-02f, -5.22198230e-02f, 6.72977418e-03f, 1.17570683e-02f, 2.00569052e-02f, -2.04507839e-02f, 1.88584570e-02f, 7.07486318e-03f, -7.32522830e-02f, 1.39925927e-02f,
  2.39329673e-02f, -2.27769203e-02f, 8.09444860e-02f, -3.33658233e-02f, 6.62592277e-02f, 6.18043803e-02f, 4.45851265e-03f, 5.71573013e-03f, 3.95608991e-02f, 1.59946587e-02f,
  2.71759685e-02f, -3.25689255e-03f, 1.80436336e-02f, -2.23068465e-02f, 4.27285023e-02f, -6.35403246e-02f, 6.21688217e-02f, -4.54439037e-02f, 3.47869061e-02f, 3.14110257e-02f,
  9.98956338e-03f, 3.74695584e-02f, -1.01575237e-02f, 1.39677953e-02f, 6.38855547e-02f, -1.11762695e-02f, 2.23514270e-02f, -2.28425302e-02f, 1.55379958e-02f, 5.77139147e-02f,
  -6.32126629e-02f, 4.97598909e-02f, -1.28387054e-02f, 2.66595613e-02f, -2.46491507e-02f, 8.90456431e-04f, -1.50041739e-02f, 3.59128378e-02f, 1.37058971e-02f, 5.89160584e-02f,
  -7.24293850e-03f, 2.52492815e-01f, -4.86582629e-02f, 2.32149698e-02f, -5.45132766e-03f, 5.44385538e-02f, 2.62696370e-02f, 4.03198414e-02f, 3.22417542e-03f, -4.87333257e-03f,
  1.30365919e-02f, 4.28872220e-02f, 2.40984634e-02f, -1.52937640e-02f, 1.48799084e-02f, 3.64410356e-02f, -1.81190632e-02f, -1.24085667e-02f, 7.19083622e-02f, -2.57106125e-02f,
  -2.81890202e-03f, 2.85541359e-02f, -1.00499038e-02f, 3.73601653e-02f, -9.88528598e-03f, 3.60677205e-02f, 2.30055414e-02f, -2.71252301e-02f, 5.15006669e-03f, -3.60762477e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.06777418e-01f, -2.34646246e-01f, 4.39745218e-01f, 2.77257502e-01f, 2.15222195e-01f, 1.72691066e-02f, 3.24279189e-01f, 1.98945582e-01f, 4.69217598e-01f, -1.17375746e-01f,
  -1.55937418e-01f, 2.03064024e-01f, -9.29520205e-02f, -2.40128413e-02f, -4.80523743e-02f, -2.46692151e-02f, 7.56079853e-02f, 9.61425081e-02f, 1.74270853e-01f, 2.03601614e-01f,
  1.86487064e-01f, -2.08337009e-02f, -2.25231070e-02f, -4.21735168e-01f, 8.69687349e-02f, -2.48240773e-02f, -2.91133642e-01f, -1.73005909e-01f, -2.05298707e-01f, -1.96076855e-01f,
  1.72545342e-03f, 1.31025046e-01f, 8.69087800e-02f, 2.15097982e-02f, 1.58800613e-02f, -2.34283041e-02f, 2.58006006e-02f, -3.48318852e-02f, 2.70457882e-02f, -2.93615665e-02f,
  -2.51133717e-03f, -3.37085426e-02f, 1.22792562e-02f, 5.35279140e-02f, 4.12589312e-02f, 4.43303846e-02f, 1.45897374e-01f, 7.47839361e-02f, 1.56907529e-01f, 2.14018021e-02f,
  3.82107943e-02f, 4.32571843e-02f, -1.09251980e-02f, -2.27611661e-02f, -7.22290576e-02f, -1.93702839e-02f, -6.53450051e-03f, 4.06876318e-02f, -8.40317737e-03f, -3.88248265e-02f,
  -1.32179027e-03f, -6.95747416e-03f, -1.10825166e-01f, -3.48137766e-02f, -1.38693918e-02f, -4.63512540e-02f, -8.39232504e-02f, -6.09919149e-03f, -4.60368916e-02f, 2.38641701e-03f,
  -8.77512619e-03f, 3.70365530e-02f, -2.66165733e-02f, 6.92860559e-02f, -7.30756531e-03f, 4.39685583e-02f, -1.88260656e-02f, 1.35606918e-02f, 1.50997965e-02f, 8.03079829e-02f,
  -3.49291600e-02f, 3.56139243e-02f, -2.70514358e-02f, 2.60576531e-02f, -2.18223990e-03f, 4.45745438e-02f, -4.45997417e-02f, 2.44451594e-02f, 8.42642486e-02f, -2.86403727e-02f,
  -1.94404367e-02f, -1.61781758e-01f, -4.56925966e-02f, 1.50351953e-02f, -6.02646656e-02f, -1.37166856e-02f, -4.22160840e-03f, 2.50174087e-02f, 5.41175194e-02f, 1.05688453e-01f,
  8.68565291e-02f, 5.97405806e-02f, -4.26123217e-02f, -4.01264057e-02f, 1.74620294e-03f, -9.63724107e-02f, 3.56817469e-02f, 4.63866666e-02f, -4.01855148e-02f, -3.62587459e-02f,
  -1.80233810e-02f, -4.59676981e-02f, 4.33476530e-02f, -2.76339576e-02f, 3.14490125e-02f, -7.49811390e-03f, 1.37864603e-02f, -1.93010047e-02f, -1.12473853e-01f, -1.19366804e-02f,
  4.09205556e-01f, -4.02013958e-02f, 2.44350851e-01f, 4.15932685e-01f, 5.44629917e-02f, 9.34574977e-02f, -8.78883675e-02f, -5.68116866e-02f, 2.63343483e-01f, -1.73515171e-01f,
  -2.22426265e-01f, 4.24017668e-01f, -6.69786274e-01f, 4.00592655e-01f, -1.95026070e-01f, -4.75035161e-01f, 3.03626865e-01f, 2.94657767e-01f, 7.68316910e-03f, 2.10739113e-02f,
  3.41179147e-02f, -9.29533690e-02f, 2.98276008e-03f, 3.68321352e-02f, 1.69795170e-01f, 2.57462353e-01f, -3.86956602e-01f, -1.76602229e-01f, 3.08115751e-01f, 8.87155756e-02f,
  1.54767498e-01f, -7.42410272e-02f, 1.80498913e-01f, 1.31423309e-01f, -7.85966367e-02f, 6.68182969e-03f, 2.18248293e-02f, -1.99257359e-02f, 1.21615443e-03f, 5.60792089e-02f,
  -4.58101965e-02f, 1.22359365e-01f, 1.44809723e-01f, -4.08218354e-02f, 1.15992568e-01f, 8.39902684e-02f, 7.60776997e-02f, 5.65748885e-02f, 6.76865205e-02f, 3.79943252e-02f,
  9.30281878e-02f, 1.13694921e-01f, 8.74730423e-02f, 8.23949501e-02f, -1.47856399e-02f, 5.50703816e-02f, 7.19337612e-02f, 2.22706962e-02f, 5.59973307e-02f, 1.61929622e-01f,
  -1.07924245e-01f, -4.93471138e-02f, -5.48389368e-02f, 8.94576386e-02f, -8.83712769e-02f, 7.04062358e-02f, -8.90360866e-03f, -2.59318221e-02f, 4.36622510e-03f, -1.06558027e-02f,
  -2.73923576e-02f, 1.81086641e-03f, 3.03586689e-03f, -3.04854531e-02f, 3.37276794e-02f, 3.78238298e-02f, 2.86513548e-02f, -3.43157612e-02f, 2.27646250e-02f, 1.74536854e-02f,
  -6.18772581e-02f, 7.84900598e-03f, -6.92141801e-02f, 8.25574100e-02f, 4.38377112e-02f, -3.23319621e-02f, -8.13810453e-02f, 4.40331697e-02f, -3.91707756e-02f, -5.69706336e-02f,
  -4.10473824e-01f, -4.67861652e-01f, -4.75363135e-02f, 9.61618572e-02f, -1.29211834e-02f, -2.14545187e-02f, 4.57660519e-02f, 1.25672400e-01f, -3.50085343e-03f, -7.58197829e-02f,
  1.69728361e-02f, 2.21451260e-02f, -1.36683378e-02f, 1.00194089e-01f, -4.73386347e-02f, -1.53603196e-01f, -1.00218751e-01f, -5.36263958e-02f, -7.01457681e-03f, -2.82256734e-02f,
  2.91787623e-03f, -3.76945324e-02f, -8.28063115e-04f, -2.67776791e-02f, 6.08257130e-02f, -6.06251061e-02f, 6.62465626e-03f, 5.23723960e-02f, -4.27432507e-02f, 7.33095314e-03f,
  8.10862556e-02f, -3.90312374e-01f, 2.52365768e-01f, -1.17927961e-01f, 1.80539295e-01f, 3.23875323e-02f, 9.67904180e-02f, -1.81312636e-01f, -6.38369694e-02f, -4.83376116e-01f,
  -1.86538801e-01f, 3.59742977e-02f, 3.36303487e-02f, -3.22456986e-01f, 4.28711891e-01f, 1.66451856e-01f, -1.59000009e-01f, -6.26830831e-02f, 7.82826692e-02f, -2.41521537e-01f,
  5.78872263e-02f, -2.86762774e-01f, 2.20711529e-01f, -3.09630871e-01f, -2.96373963e-02f, -8.74850899e-02f, -7.66557232e-02f, 1.23437323e-01f, -2.75423318e-01f, 9.73312259e-02f,
  -1.72497168e-01f, -2.05471218e-01f, -1.93078741e-02f, 3.92022096e-02f, -6.62923455e-02f, -4.31489572e-02f, -1.61354095e-02f, 1.32031679e-01f, -4.55414411e-03f, -3.07683623e-03f,
  -1.30483145e-02f, 1.83336083e-02f, -1.26945823e-01f, 4.74215224e-02f, 1.29949313e-03f, -2.79757138e-02f, 1.29326154e-02f, -3.32082389e-03f, -2.02363264e-03f, 5.03545329e-02f,
  1.63120497e-02f, 2.11059451e-02f, 4.38087694e-02f, 4.03476469e-02f, 7.92629048e-02f, 2.54415944e-02f, 8.74557197e-02f, 6.81961179e-02f, -1.89978536e-02f, -6.48772269e-02f,
  -2.39949264e-02f, 3.58603969e-02f, -3.04696560e-02f, 2.50927322e-02f, -9.05863866e-02f, 2.08665952e-02f, -1.02764824e-02f, 3.18937451e-02f, 3.05288471e-02f, 2.27743573e-02f,
  -1.42022604e-02f, 7.60011375e-03f, 4.20034826e-02f, -4.90869880e-02f, 4.42698337e-02f, 3.79160345e-02f, 4.60044183e-02f, 1.64292529e-02f, 2.42856555e-02f, 4.13779467e-02f,
  2.95589603e-02f, 2.21527163e-02f, -1.42478561e-02f, 7.66708106e-02f, 3.01660020e-02f, 4.94688414e-02f, -6.27350658e-02f, 5.49709611e-02f, 3.80319096e-02f, 3.28784175e-02f,
  -2.66646475e-01f, -4.73837137e-01f, -1.20226793e-01f, -9.59092602e-02f, -7.77382851e-02f, -1.84430722e-02f, -3.56942415e-02f, -5.14482260e-02f, -9.16198716e-02f, -2.82946639e-02f,
  -2.98884534e-03f, 1.35181444e-02f, -3.96650657e-02f, 1.08555108e-02f, -6.99313059e-02f, -6.32245019e-02f, -1.17290072e-01f, -1.05536871e-01f, -5.98215945e-02f, -6.09950237e-02f,
  -8.06497559e-02f, -2.42252368e-03f, 8.15051049e-02f, -8.41637515e-03f, -4.38296199e-02f, -2.61316858e-02f, -1.12890853e-02f, 5.59543036e-02f, 1.30747510e-02f, 1.66524705e-02f,
  -3.18143129e-01f, 3.94258678e-01f, 5.29811859e-01f, -8.17228556e-02f, 1.11031912e-01f, 4.66642797e-01f, 2.72882640e-01f, 2.58845121e-01f, 4.09913361e-01f, -1.16576076e-01f,
  -3.51847410e-01f, 1.00234762e-01f, -6.29122704e-02f, -1.20880589e-01f, 1.52940854e-01f, 8.14434886e-02f, 1.53858215e-01f, -1.37691153e-02f, 3.19793135e-01f, -3.70459445e-02f,
  4.90586460e-02f, -1.38834104e-01f, -6.20280914e-02f, -4.57281396e-02f, -6.59046993e-02f, 5.98283438e-03f, -3.80791515e-01f, 5.80615699e-02f, -1.97671935e-01f, 8.25390592e-02f,
  3.19871791e-02f, -1.39584899e-01f, -1.95788264e-01f, 9.45540667e-02f, -1.05327452e-02f, 1.91258304e-02f, -5.11923395e-02f, -1.18997497e-02f, -2.53788847e-02f, 5.55471554e-02f,
  -8.22024867e-02f, 1.49905477e-02f, 2.24943608e-02f, -7.14610144e-02f, 1.01040304e-01f, -1.12207811e-02f, 6.16322868e-02f, 8.27115588e-03f, 3.15001681e-02f, 1.25658512e-01f,
  4.36753035e-02f, 1.00013286e-01f, 6.05713241e-02f, 4.99030389e-02f, 2.42324751e-02f, 4.23674546e-02f, 4.88739498e-02f, -3.08960420e-03f, -1.07574444e-02f, 6.54160455e-02f,
  7.55980909e-02f, 1.11784250e-01f, -7.51453862e-02f, -3.97634394e-02f, -3.04351896e-02f, -3.81026678e-02f, -2.51965155e-03f, -6.05663545e-02f, -1.63458996e-02f, -1.06881961e-01f,
  -1.18810154e-01f, -5.95381157e-03f, -2.42791455e-02f, -1.82377249e-02f, -2.63454895e-02f, -3.89833748e-03f, -3.87954749e-02f, 4.16217074e-02f, 1.45657947e-02f, -2.70545110e-02f,
  -3.42510194e-02f, 2.58258972e-02f, -6.44787401e-02f, -5.97604997e-02f, 7.84752369e-02f, -6.94431085e-03f, -1.06239840e-01f, 3.00480127e-02f, -2.38583144e-02f, -5.49554545e-03f,
  1.05826303e-01f, 1.32752329e-01f, -2.79619172e-02f, -2.06527468e-02f, 2.24512611e-02f, -6.76037595e-02f, 4.34373617e-02f, -3.44372168e-02f, 1.29691914e-01f, -4.23937244e-03f,
  2.29740106e-02f, 1.13536948e-02f, 1.54140946e-02f, 4.37868945e-02f, 8.43970478e-03f, 7.74502382e-02f, -3.90995853e-02f, 6.09279089e-02f, -4.86051068e-02f, -4.89866175e-02f,
  -1.16568603e-01f, -3.51661034e-02f, 5.85710863e-04f, -8.02458003e-02f, -3.90241519e-02f, -1.01704158e-01f, 3.17060621e-03f, 6.14467077e-03f, -6.24520378e-03f, 2.11860836e-02f,
  6.22028410e-01f, -3.78565729e-01f, 1.02206422e-02f, 1.66304559e-01f, 2.11895823e-01f, 3.15410435e-01f, 5.93368173e-01f, 1.55291893e-02f, 1.85765833e-01f, -1.41962305e-01f,
  2.48080082e-02f, -4.97170091e-02f, -6.33324543e-03f, 1.93948984e-01f, 3.53462487e-01f, -6.59058914e-02f, 2.74711251e-01f, 9.24609974e-02f, 9.19811334e-03f, 7.04755485e-02f,
  5.28136566e-02f, 1.61924928e-01f, -4.62129153e-02f, -2.04272375e-01f, 2.31036901e-01f, -1.14847668e-01f, -9.78011563e-02f, -5.82971275e-02f, -9.80075747e-02f, 1.08858228e-01f,
  8.50392804e-02f, 1.45944014e-01f, -1.48939211e-02f, -2.94046476e-02f, 5.31305233e-03f, -2.50246879e-02f, -6.52190745e-02f, 1.28831998e-01f, -3.47188413e-02f, 2.76370458e-02f,
  -1.22706173e-02f, 2.49638502e-02f, 6.41091689e-02f, -9.22247395e-03f, 1.22784875e-01f, -6.02928251e-02f, -7.32765496e-02f, -5.35682067e-02f, -4.50399667e-02f, -1.92882009e-02f,
  -1.85826246e-03f, -4.06615175e-02f, 3.73067297e-02f, -1.10160664e-01f, -2.28692181e-02f, 3.57753113e-02f, 2.34061703e-02f, 4.44642827e-02f, -4.81996536e-02f, 4.69159037e-02f,
  5.47373947e-03f, 6.22184910e-02f, 1.25081450e-01f, -5.37811890e-02f, 1.71723068e-02f, 9.71781439e-04f, -1.39205465e-02f, -2.99907383e-02f, -6.45319447e-02f, 1.58922132e-02f,
  -5.57280704e-02f, -1.47792250e-02f, -3.98980250e-04f, 1.96844433e-02f, 1.20958403e-01f, 6.73768446e-02f, 6.13257848e-03f, 1.60053873e-03f, -8.66257772e-02f, -5.49449958e-02f,
  5.08768111e-02f, 5.64266667e-02f, -6.54593930e-02f, -3.20607494e-03f, 2.74046846e-02f, -4.39926125e-02f, -2.52934638e-02f, 1.95061497e-04f, -3.56172770e-02f, -2.05078293e-02f,
  -7.50389323e-02f, -1.49475023e-01f, -4.33413424e-02f, 4.50027846e-02f, -1.36886254e-01f, -2.49696542e-02f, 4.61781304e-03f, -5.00866175e-02f, -1.17942896e-02f, -8.84272065e-03f,
  -5.50592225e-03f, 5.45433396e-03f, 3.78183927e-03f, -4.72174119e-03f, -8.21684673e-02f, 6.30156398e-02f, -5.14644757e-02f, -4.03400473e-02f, -1.45665510e-03f, -6.19385093e-02f,
  -6.86329380e-02f, 8.62270296e-02f, 3.96772921e-02f, 6.99989423e-02f, -6.41708225e-02f, -5.71493655e-02f, -1.23260878e-02f, 2.01128665e-02f, -6.69439323e-03f, -9.21064708e-03f,
  5.72029054e-02f, -1.26547024e-01f, -1.64436519e-01f, 2.93624520e-01f, 1.24902762e-01f, -2.03247100e-01f, -2.46632054e-01f, 3.02382022e-01f, -3.39042395e-01f, -1.79061797e-02f,
  1.91231206e-01f, -2.13828310e-01f, -2.72997886e-01f, 3.06222111e-01f, 1.06913850e-01f, -2.97344893e-01f, 3.39135557e-01f, 5.78921661e-02f, -1.51322201e-01f, 2.89764941e-01f,
  1.56632483e-01f, 4.28412855e-01f, 1.32830605e-01f, 4.41534311e-01f, 2.33187869e-01f, 2.63017029e-01f, 5.16851783e-01f, 2.09825914e-02f, 5.39421558e-01f, 1.38271615e-01f,
  -3.23688006e-03f, -2.68471148e-02f, 1.48032634e-02f, -4.71847281e-02f, 8.63791779e-02f, 6.92997500e-02f, -1.27574662e-03f, -2.32526977e-02f, -2.56300680e-02f, 8.70485231e-02f,
  -1.02065690e-01f, 4.89832200e-02f, 4.90430631e-02f, -9.85066057e-04f, 4.58108895e-02f, 2.74409377e-03f, -3.49819772e-02f, -3.90308946e-02f, -9.55297500e-02f, -7.17375576e-02f,
  -4.26734947e-02f, 3.99547443e-02f, 2.08398933e-03f, -5.49614690e-02f, -9.40432325e-02f, 4.62280307e-03f, -4.96629812e-02f, 3.87970954e-02f, 5.29676862e-03f, 4.91803661e-02f,
  1.28568575e-01f, 6.40999451e-02f, -5.43392226e-02f, 3.03096441e-03f, -1.78793799e-02f, -8.05008188e-02f, -2.09698826e-02f, 5.01493271e-03f, -1.32606730e-01f, 2.43094917e-02f,
  -1.15495827e-02f, 1.90599915e-02f, 4.86011133e-02f, 2.29754876e-02f, 3.58413644e-02f, 1.45306410e-02f, 3.87257896e-02f, 8.94541591e-02f, -2.81168669e-02f, -4.81233299e-02f,
  -2.51190048e-02f, 3.96420397e-02f, 2.91420147e-02f, 8.13495144e-02f, 5.79612590e-02f, 1.29501382e-02f, 6.48991615e-02f, 1.34038990e-02f, -3.04764342e-02f, 4.20422927e-02f,
  7.47736394e-02f, 2.30200201e-01f, -1.04205228e-01f, 2.81790886e-02f, -4.76324819e-02f, 1.41318589e-02f, -3.64934988e-02f, 3.84542928e-03f, 1.60816237e-02f, -7.30392039e-02f,
  1.92370266e-01f, 7.27257431e-02f, 1.37900626e-02f, -3.13093187e-03f, 2.03448925e-02f, 4.27178070e-02f, 1.26142666e-01f, 1.20786270e-02f, 1.09043911e-01f, 1.81440204e-01f,
  4.16928157e-02f, 3.42415497e-02f, -4.34896126e-02f, -9.34863016e-02f, 3.24173970e-03f, -4.02504057e-02f, -2.81595364e-02f, -4.87950742e-02f, 9.94464979e-02f, 3.01119387e-02f,
  -3.13725710e-01f, -1.70000702e-01f, 3.64894509e-01f, -3.87465268e-01f, 1.37798801e-01f, 3.37025702e-01f, 3.63084495e-01f, -3.57812166e-01f, -3.51227999e-01f, -1.84643313e-01f,
  -1.44599393e-01f, 1.06557749e-01f, 2.33863175e-01f, -6.20897021e-03f, 2.77690530e-01f, 2.06650600e-01f, -9.33788642e-02f, 1.36938959e-03f, -3.45486850e-02f, -1.76076278e-01f,
  -1.02930896e-01f, -2.19306678e-01f, 3.44689518e-01f, -1.81831166e-01f, 2.07538772e-02f, -9.72227380e-02f, -8.86636600e-02f, 1.01417661e-01f, -7.02715218e-02f, 5.20602427e-02f,
  -1.25890762e-01f, -2.09321305e-01f, 1.06069960e-01f, 9.26918164e-02f, 3.88791263e-02f, 1.02967724e-01f, 6.45269528e-02f, 1.78521395e-01f, 2.28563081e-02f, 4.21495475e-02f,
  9.16577876e-03f, 1.16566559e-02f, -5.46145402e-02f, -3.68588720e-03f, 2.72144214e-03f, -2.21668221e-02f, 4.11578417e-02f, 8.59814584e-02f, -4.10230346e-02f, 1.02090873e-01f,
  5.93719371e-02f, 3.42935026e-02f, 3.99203561e-02f, -7.74022341e-02f, 8.27919990e-02f, -4.52427976e-02f, 2.07467079e-02f, 1.51215553e-01f, -6.11692742e-02f, -4.54643779e-02f,
  -4.24748324e-02f, -1.78247821e-02f, 2.98050959e-02f, -6.40873462e-02f, 1.29212867e-02f, -9.36512128e-02f, 7.45349564e-03f, 6.86459150e-03f, -4.61624525e-02f, -6.56358823e-02f,
  -4.55263518e-02f, -6.71519861e-02f, 2.57745814e-02f, -7.24647939e-02f, -5.40160425e-02f, -9.70258117e-02f, 7.32718557e-02f, -5.07605001e-02f, -5.55871315e-02f, 3.51659916e-02f,
  2.92506651e-03f, -1.69058908e-02f, 4.48925309e-02f, 5.52558228e-02f, -5.16559929e-03f, 2.48126108e-02f, -4.41317707e-02f, 1.26122087e-02f, -1.55692594e-02f, 4.24538739e-02f,
  -1.12330705e-01f, -2.55078703e-01f, -3.05804312e-02f, 2.79379375e-02f, -4.74405922e-02f, 2.75263134e-02f, 3.54250520e-02f, -1.95780047e-03f, -7.39033893e-02f, -8.67772698e-02f,
  -1.17385536e-01f, -2.88848635e-02f, 8.40199515e-02f, -5.77600189e-02f, -1.04603115e-02f, -1.05101898e-01f, -1.24356337e-02f, -4.19820771e-02f, 1.22725572e-02f, -4.19597365e-02f,
  3.11885960e-02f, -2.61545437e-03f, -3.84286195e-02f, -4.59673814e-03f, -3.75248045e-02f, -5.00312075e-02f, 6.86228392e-04f, -1.11450747e-01f, 2.90995594e-02f, 2.59117130e-02f,
  -6.43572807e-01f, 2.45473966e-01f, -2.92495310e-01f, 1.63128436e-01f, -1.33400202e-01f, 6.07744157e-01f, 5.42673290e-01f, 2.49080975e-02f, 7.46578947e-02f, 4.44274157e-01f,
  2.37795696e-01f, -1.70128886e-02f, 5.31214438e-02f, 5.35705030e-01f, 2.92794593e-02f, 3.43565434e-01f, 5.16903758e-01f, 4.49899644e-01f, -3.48463356e-02f, -7.47454837e-02f,
  -7.31858760e-02f, 3.04194212e-01f, -6.15950348e-03f, -1.51803628e-01f, 5.87306311e-03f, -2.61531889e-01f, -7.01081231e-02f, -3.09472322e-01f, 1.63218290e-01f, 2.27090828e-02f,
  -4.75698300e-02f, -2.66316265e-01f, -8.52541178e-02f, -5.80623895e-02f, -1.77170546e-03f, 1.55609306e-02f, -2.62140296e-03f, -9.46739614e-02f, -1.21668711e-01f, -2.12195199e-02f,
  -3.09942919e-03f, -7.55943656e-02f, 2.86497250e-02f, 7.28923595e-03f, 9.03607905e-03f, -8.95857140e-02f, -2.62564532e-02f, 1.67677347e-02f, -1.25338603e-02f, -4.20963615e-02f,
  -2.19247993e-02f, 1.32969901e-01f, 3.42412069e-02f, 1.26094058e-01f, -4.08495637e-03f, 5.24323806e-02f, 4.08974625e-02f, -6.63724318e-02f, 1.39306337e-02f, 5.91982864e-02f,
  -3.15601453e-02f, -4.74471338e-02f, 4.39147353e-02f, 1.11274552e-02f, 4.67395131e-03f, -3.22213247e-02f, 4.16151658e-02f, 3.68036283e-03f, -5.93969524e-02f, -4.07536791e-05f,
  -1.08907949e-02f, 7.87423644e-03f, -9.15766135e-03f, 5.79806529e-02f, 6.50384724e-02f, 2.26737186e-02f, -1.87800582e-02f, -1.19533613e-02f, 5.60268462e-02f, -6.13413611e-03f,
  -1.34585844e-02f, 2.18389425e-02f, 8.10764059e-02f, 1.98252425e-02f, -1.23426290e-02f, 1.94145571e-02f, 2.04678997e-02f, -3.72309014e-02f, 2.39156839e-02f, -3.90369375e-03f,
  9.05091986e-02f, -2.11546291e-02f, -1.73149481e-02f, 2.83172280e-02f, 4.62776534e-02f, 1.30236343e-01f, -1.22016510e-02f, -9.38905962e-03f, 6.09929077e-02f, 7.50359707e-03f,
  2.82619279e-02f, -1.90013926e-02f, 1.27661182e-02f, 4.33983244e-02f, -3.86317121e-03f, 8.64926055e-02f, 4.22345325e-02f, 6.96223751e-02f, 5.70811294e-02f, -1.45366986e-03f,
  -3.33059542e-02f, -7.89472908e-02f, -6.27822131e-02f, 4.88405675e-02f, 6.30789669e-03f, -1.52339637e-02f, -3.13938856e-02f, 8.90428480e-03f, -3.57412063e-02f, 4.03631404e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.43922010e-01f, 2.60398835e-01f, 3.92982036e-01f, 4.83062685e-01f, 4.14397627e-01f, 3.91512424e-01f, 1.39301509e-01f, 3.80254894e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.76350321e-02f, -3.16068858e-01f, -1.09690055e-01f, -7.13624597e-01f, -1.42388076e-01f, -3.40435833e-01f, 1.30927861e-01f, -8.74863327e-01f, -2.57459581e-01f, 4.82696235e-01f,
  3.02477796e-02f, -2.45333672e-01f, -2.31719129e-02f, 1.81574553e-01f, -3.71523827e-01f, 3.40611964e-01f, 1.22030169e-01f, -1.33606017e-01f, -3.88906002e-01f, -3.56834024e-01f,
  -7.37042248e-01f, 2.35902593e-02f, 5.34033775e-01f, -3.99038166e-01f, 4.03957486e-01f, -8.93212557e-02f, 1.21394463e-01f, -2.82112181e-01f, 4.40892786e-01f, -2.51356542e-01f,
  1.91384166e-01f, -6.01001978e-01f, 3.19733024e-01f, 1.16070714e-02f, 4.60675418e-01f, 3.48775536e-01f, -8.51540089e-01f, -1.10316098e-01f, -4.05212790e-01f, 4.64705527e-01f,
  2.97577053e-01f, -1.96887195e-01f, 8.17052200e-02f, 2.63327897e-01f, 3.11079651e-01f, -2.94830531e-01f, 9.84499678e-02f, -3.18084657e-01f, 2.88370848e-01f, -2.52665132e-01f,
  5.86112618e-01f, 2.15046123e-01f, 3.01933616e-01f, -5.70842385e-01f, -2.18350980e-02f, -2.59624809e-01f, -3.28929454e-01f, -3.56765300e-01f, -4.17783648e-01f, 4.06327546e-01f,
  2.78512031e-01f, -3.00269306e-01f, 2.95281172e-01f, 3.50358903e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.47162449e-01f, -1.47912383e-01f, 4.57822472e-01f, 4.94038045e-01f, -7.31811643e-01f, 4.70619708e-01f, 9.48913321e-02f, 7.58170962e-01f, 8.30592334e-01f, 1.04284871e+00f,
  -1.98403195e-01f, 4.39389050e-01f, 9.99574125e-01f, 4.43962336e-01f, -6.71279788e-01f, 6.87057793e-01f, 5.92273712e-01f, 4.53093231e-01f, 4.38907504e-01f, -2.11516898e-02f,
  6.95048392e-01f, -4.97311741e-01f, 5.44922888e-01f, -1.13601172e+00f, 1.46210426e-02f, 2.47417778e-01f, -2.10330606e-01f, 7.43243277e-01f, -3.73666137e-01f, -3.89488846e-01f,
  -4.05214429e-02f, 4.08485085e-01f, 4.09462392e-01f, 9.98647034e-01f, -9.24026221e-02f, 4.87937421e-01f, 3.29358041e-01f, 3.88110042e-01f, 1.26318216e+00f, -6.33424997e-01f,
  -1.38928741e-02f, -4.11784083e-01f, -1.29387632e-01f, 8.05398375e-02f, -1.51431292e-01f, 7.95265853e-01f, 7.91435838e-02f, -2.95231462e-01f, 5.12210131e-01f, 4.78789091e-01f,
  3.92670810e-01f, -1.18103489e-01f, 3.24100018e-01f, 5.57763949e-02f, -1.22141622e-01f, -9.31114256e-02f, 6.17967725e-01f, 3.15271586e-01f, 9.02684271e-01f, 9.65984106e-01f,
  -5.71488999e-02f, -4.81975764e-01f, 4.70538825e-01f, -4.61182415e-01f, -1.16762191e-01f, -1.82952270e-01f, 4.10934299e-04f, -2.90859938e-02f, 1.34899527e-01f, -1.27356574e-01f,
  -1.52132744e-02f, -2.56602496e-01f, 7.33545870e-02f, -8.68461579e-02f, 2.09167048e-01f, 2.18108714e-01f, -2.52752632e-01f, -1.49178654e-02f, 1.26190752e-01f, 1.45127490e-01f,
  1.59457549e-01f, 3.73811543e-01f, 3.50457728e-01f, 6.50496244e-01f, 6.55730307e-01f, 2.54992813e-01f, 6.96203530e-01f, -3.29895392e-02f, 1.57916635e-01f, 5.56234121e-01f,
  -2.03401106e-03f, 3.23976487e-01f, -1.00042231e-01f, -4.97146845e-01f, 4.36126262e-01f, 4.88509536e-01f, 1.07097082e-01f, 2.41044879e-01f, 1.92344517e-01f, 3.95774424e-01f,
  7.23834753e-01f, 5.09430647e-01f, -6.06293976e-01f, 6.04592264e-01f, 2.61292875e-01f, 6.16942167e-01f, 2.19239935e-01f, -2.38905288e-02f, 7.67867118e-02f, 7.06078231e-01f,
  2.62916148e-01f, -2.72382140e-01f, 1.03226759e-01f, 1.92565039e-01f, 6.94758117e-01f, -3.21472704e-01f, 5.51063657e-01f, -5.71795523e-01f, -7.23383546e-01f, 1.93003863e-02f,
  -1.85543701e-01f, -6.15664363e-01f, 8.92897367e-01f, 1.79479986e-01f, 5.27461052e-01f, 5.59698820e-01f, 6.81099296e-01f, 1.07452536e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.02094361e-01f, 8.95049751e-01f, 5.90499938e-01f, 6.11001670e-01f, -5.04602008e-02f, 3.21767554e-02f, 1.98701620e-01f, 5.30875146e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -7.34046623e-02f, -2.90837198e-01f, 1.08331844e-01f, -5.48083365e-01f, 6.52220249e-01f, -1.88045427e-01f, -7.93195903e-01f, 1.26046583e-01f, -3.19068789e-01f, 4.92734224e-01f,
  -2.11349353e-01f, -8.58024299e-01f, 2.67923146e-01f, 4.07966524e-01f, -5.19839644e-01f, 8.71523499e-01f, 3.31169993e-01f, -1.91110626e-01f, 3.56338024e-01f, 5.67523718e-01f,
  -1.10246480e-01f, -3.26169759e-01f, 2.89603174e-01f, 9.30627227e-01f, 6.38656557e-01f, -5.15218019e-01f, -3.39511216e-01f, -1.00321662e+00f, 1.54070973e-01f, -2.50088990e-01f,
  -1.91631243e-01f, 6.89109206e-01f, 3.97449546e-02f, -4.32778075e-02f, 4.28497791e-01f, -5.83946943e-01f, 5.12730062e-01f, -6.18136287e-01f, 1.25786096e-01f, -8.53629410e-01f,
  9.06319261e-01f, -7.43634045e-01f, -5.77131510e-01f, -4.19611067e-01f, -2.14256458e-02f, -6.94404423e-01f, 5.47356963e-01f, -2.83339441e-01f, 1.74762890e-01f, 2.94404626e-01f,
  2.66571462e-01f, 4.20142382e-01f, 6.53675556e-01f, 2.13474885e-01f, -1.00237679e+00f, 6.32914662e-01f, -1.17239487e+00f, 1.17425370e+00f, 6.92766786e-01f, 3.69551480e-01f,
  6.91892207e-02f, -8.52544233e-03f, -5.91225445e-01f, -3.28029543e-01f, -2.18339741e-01f, -5.63923478e-01f, 5.96722178e-02f, -3.52483511e-01f, -6.23681545e-01f, -5.39351583e-01f,
  1.78692117e-01f, 5.22642374e-01f, -9.33966696e-01f, 4.87509966e-01f, 2.57536232e-01f, 6.57501698e-01f, 1.96635306e-01f, 5.93586802e-01f, -7.51307756e-02f, 2.69434839e-01f,
  1.90846905e-01f, -3.12376589e-01f, -6.28205121e-01f, -6.76750600e-01f, -7.37371266e-01f, -7.86676109e-01f, 5.53756058e-01f, 6.22945845e-01f, 5.24837136e-01f, 5.86773276e-01f,
  -7.22192228e-01f, 2.19562143e-01f, -3.41728665e-02f, 1.15202799e-01f, -1.84144929e-01f, -1.06527232e-01f, -6.78132176e-02f, 1.73268005e-01f, -7.54280388e-01f, -6.00629412e-02f,
  -7.10211575e-01f, 6.57342613e-01f, -9.83751416e-02f, -5.64854145e-01f, 9.63004053e-01f, -8.22565734e-01f, -3.37672234e-01f, 5.33907652e-01f, -1.67481810e-01f, -2.28892252e-01f,
  -3.91341001e-02f, -6.26223922e-01f, 4.26567733e-01f, 3.98109257e-01f, 5.07356115e-02f, 2.98323333e-01f, 8.34508061e-01f, 7.64379084e-01f, 9.69616771e-01f, 2.46143863e-01f,
  -8.13402295e-01f, 3.41207653e-01f, -7.06998408e-01f, 6.47801816e-01f, 3.00086617e-01f, -6.23529971e-01f, -5.76320171e-01f, 7.58982301e-01f, 2.53012776e-01f, -8.18369091e-01f,
  3.35363358e-01f, -1.13886990e-01f, -4.41556364e-01f, -5.25572181e-01f, -6.72762930e-01f, -7.94829249e-01f, -4.73242313e-01f, -4.11590636e-01f, 3.84636611e-01f, -1.73206940e-01f,
  -8.56834650e-03f, -5.70870459e-01f, 1.03727782e+00f, 2.76540339e-01f, -8.90983760e-01f, 2.33887136e-01f, -7.80737996e-01f, 2.17369407e-01f, -4.17719901e-01f, 4.31535542e-01f,
  1.21156521e-01f, 3.19790721e-01f, -3.48831445e-01f, -9.16867137e-01f, -4.87602592e-01f, 4.96561110e-01f, -1.96043104e-01f, 1.64819926e-01f, 3.73099208e-01f, 7.37580359e-01f,
  3.85618597e-01f, 3.03755581e-01f, 5.07589519e-01f, 4.99956280e-01f, -5.19141592e-02f, 4.85490531e-01f, -8.53401050e-02f, -4.18844700e-01f, 5.37431091e-02f, -7.06797689e-02f,
  1.53370261e+00f, -4.54734117e-01f, 6.75802026e-03f, 2.38702307e-03f, -4.27520305e-01f, -8.12041402e-01f, -2.14690506e-01f, 9.28771272e-02f, 3.57229918e-01f, 3.54006231e-01f,
  -4.24581692e-02f, -2.57524520e-01f, -1.40438467e-01f, -6.01991236e-01f, 3.36163193e-01f, 4.11048055e-01f, -9.46197733e-02f, 3.56312096e-01f, 1.08226538e-01f, 9.43311572e-01f,
  2.64455497e-01f, -1.26446903e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.96654303e-02f, 2.71797836e-01f, 1.10104799e-01f, -1.61488041e-01f, -9.23963934e-02f, 2.00523719e-01f, 5.15011735e-02f, 2.91909486e-01f, -6.52887747e-02f, -2.02501900e-02f,
  4.92195100e-01f, -2.71626264e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    