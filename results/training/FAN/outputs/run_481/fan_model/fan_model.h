/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.82266915e-01f, -2.98911512e-01f, 2.67296582e-02f, -4.28827554e-01f, 1.85070261e-01f, 4.72837538e-01f, 1.04758635e-01f, -9.17922426e-03f, -3.93144220e-01f, -1.22411542e-01f,
  4.25080061e-02f, -1.90350324e-01f, -2.82039195e-02f, -2.17415124e-01f, 3.53650004e-01f, -9.03241336e-02f, -2.34079640e-02f, -1.39221385e-01f, -2.21923664e-01f, -2.42849626e-02f,
  -3.24369292e-03f, -1.00575216e-01f, -8.26052483e-03f, -4.36186045e-02f, 1.78887490e-02f, -1.46315381e-01f, 7.42859840e-02f, 1.48515925e-01f, 1.30898118e-01f, 5.11405915e-02f,
  1.46689370e-01f, -2.15168834e-01f, -5.70904911e-02f, 2.27661971e-02f, 4.88534337e-03f, 7.77188912e-02f, 4.84742671e-02f, 1.03645213e-01f, -2.62122080e-02f, -3.91388126e-02f,
  3.82074597e-03f, 6.71606883e-02f, -8.59607384e-02f, -7.95433894e-02f, -1.78454928e-02f, -8.50208402e-02f, 1.20544545e-02f, 8.64743888e-02f, -5.09146079e-02f, 4.24938798e-02f,
  -1.55830150e-02f, 4.72015468e-03f, -6.02299497e-02f, -4.18090336e-02f, 1.10994861e-01f, -6.05706982e-02f, -1.30503494e-02f, 3.04945502e-02f, 3.50454338e-02f, -1.25308469e-01f,
  2.35161688e-02f, -7.88842216e-02f, 8.42670538e-03f, -1.13927118e-01f, -3.13899592e-02f, -8.26128945e-02f, 6.56741336e-02f, 6.90426975e-02f, -8.06126073e-02f, -7.07954448e-03f,
  -3.63945663e-02f, -7.03170300e-02f, -3.23212519e-02f, -5.08479029e-02f, -2.21528932e-02f, -6.40541464e-02f, -3.43675655e-03f, -2.73954291e-02f, 2.53801094e-03f, -1.20479167e-02f,
  -6.02079742e-02f, -9.31972824e-03f, 6.07659435e-03f, 1.54030487e-01f, 9.51163992e-02f, -1.94221176e-02f, -5.30964322e-02f, -2.27818303e-02f, -3.51045504e-02f, 1.35581955e-01f,
  1.40038267e-01f, -6.68187439e-02f, 4.06206585e-02f, 8.23765472e-02f, -3.05787344e-02f, 2.51996884e-04f, -7.76018351e-02f, -5.10437973e-02f, -3.14212553e-02f, -4.92755845e-02f,
  -1.13667985e-02f, 5.46007827e-02f, 6.03856593e-02f, -1.10704498e-02f, 3.95614058e-02f, 7.88379577e-04f, 1.39200808e-02f, -1.04434313e-02f, 7.01674819e-02f, 8.60234499e-02f,
  -3.38966325e-02f, -3.78738088e-03f, 2.75582783e-02f, 3.59913558e-02f, 4.62581590e-02f, 6.18021451e-02f, 3.51025164e-03f, -2.97295805e-02f, 4.70381491e-02f, -5.94429262e-02f,
  -2.07969248e-01f, 2.58487254e-01f, 2.22261772e-01f, -1.26722574e-01f, -2.43554533e-01f, -2.03065813e-01f, -1.13379061e-01f, -4.27955203e-02f, 1.57386497e-01f, -5.66832535e-02f,
  -2.74826020e-01f, 3.94294024e-01f, 2.25654751e-01f, -3.58991563e-01f, -2.41908967e-01f, 2.70885319e-01f, -3.55331093e-01f, -1.52543172e-01f, 5.05051315e-02f, -6.72498271e-02f,
  7.10730255e-03f, -3.09228837e-01f, -1.87112819e-02f, -4.96621579e-02f, -1.90588087e-01f, 7.69086033e-02f, -1.56917274e-01f, 2.27780312e-01f, -1.98923111e-01f, 4.56584478e-03f,
  -6.32488728e-02f, 3.74276452e-02f, 4.93228994e-03f, 4.54711094e-02f, -8.65783617e-02f, -6.31870851e-02f, -8.68422017e-02f, -1.06089758e-02f, 6.42615976e-03f, -6.64442256e-02f,
  2.11141258e-02f, 5.73380198e-03f, 1.05122710e-02f, 1.01163283e-01f, -1.17481155e-02f, 2.97644082e-03f, 6.43627420e-02f, -6.66946098e-02f, 1.26711756e-01f, 3.08988523e-02f,
  4.41192091e-02f, -2.91432682e-02f, -8.63899887e-02f, 3.27573437e-03f, 1.05879471e-01f, 2.28248481e-02f, 6.02785777e-03f, 6.37577549e-02f, -1.80084035e-02f, -2.45269984e-02f,
  -4.92215268e-02f, 6.47010922e-04f, -4.55040298e-02f, -3.27085480e-02f, 3.81057635e-02f, -3.55747491e-02f, -3.85590307e-02f, -6.16798140e-02f, 8.62659961e-02f, -1.61520895e-02f,
  -2.36588772e-02f, -3.70523892e-02f, -2.46193688e-02f, -1.54369576e-02f, -2.40257941e-02f, -4.17775922e-02f, -5.25933579e-02f, 4.54044994e-03f, -3.67160857e-04f, -2.15857127e-03f,
  3.04428060e-02f, 1.92133468e-02f, 7.99559504e-02f, -3.91892642e-02f, -3.13364677e-02f, 3.25354524e-02f, 6.57297745e-02f, -8.21339490e-04f, -1.72863733e-02f, 2.60501429e-02f,
  2.79844366e-02f, 2.69775659e-01f, 5.05311489e-02f, -2.47411784e-02f, 4.77887541e-02f, -2.18751505e-02f, 1.59089342e-02f, -1.62792373e-02f, 1.02779582e-01f, -6.50547910e-03f,
  -6.53769597e-02f, -3.87051217e-02f, -1.44743221e-02f, -6.85043186e-02f, -3.59366946e-02f, 1.54699963e-02f, 9.15608183e-03f, -1.46438070e-02f, -4.60423119e-02f, -4.64797802e-02f,
  -4.85463627e-03f, -5.52056432e-02f, 2.59001255e-02f, -4.81944121e-02f, -4.74609397e-02f, -2.91026551e-02f, 1.32134622e-02f, -7.29374448e-03f, -6.62145019e-02f, 6.32036701e-02f,
  -3.71259063e-01f, 2.77101565e-02f, -2.72839487e-01f, -2.30386704e-01f, -3.08099929e-02f, -1.17155671e-01f, -1.90966830e-01f, -4.36685309e-02f, -1.99417174e-01f, 2.35200211e-01f,
  2.01076180e-01f, -2.33151808e-01f, 3.91789407e-01f, -1.10784717e-01f, 1.66178271e-01f, 3.53931189e-01f, -1.32687449e-01f, -1.49508089e-01f, 4.61890511e-02f, -1.45926803e-01f,
  -1.48609340e-01f, 2.72149384e-01f, -1.41766563e-01f, 4.41013686e-02f, -9.69440043e-02f, -2.51676559e-01f, 3.80969882e-01f, 2.88303532e-02f, 8.01456720e-03f, 7.54835084e-02f,
  -8.34910199e-02f, -2.12377449e-03f, -1.04432113e-01f, -1.08249910e-01f, 7.41781620e-03f, -4.45274338e-02f, -1.26441479e-01f, 3.53950076e-02f, -5.59256831e-03f, -6.14024117e-04f,
  -1.12673417e-02f, -4.33989018e-02f, -1.63140297e-02f, 1.31780759e-01f, -7.72452280e-02f, -9.43469703e-02f, 5.08491043e-03f, 1.50934616e-02f, -9.63604525e-02f, -4.19265963e-02f,
  -7.81807303e-02f, -3.42886336e-02f, -1.39657691e-01f, 3.16691361e-02f, -7.56534338e-02f, -1.56622291e-01f, -5.87753803e-02f, 2.53942609e-02f, 5.33646382e-02f, -3.33932950e-03f,
  8.36012512e-02f, 7.35677220e-03f, -5.38962632e-02f, 4.17945012e-02f, 2.58087087e-02f, -8.30012411e-02f, -4.01829630e-02f, 1.85323004e-02f, 3.55521654e-04f, 6.04375452e-02f,
  -5.39657078e-04f, -8.33590552e-02f, 4.62124310e-02f, -4.79797088e-02f, -4.30005006e-02f, -8.00390616e-02f, -7.81226158e-02f, 8.01461115e-02f, -3.23052555e-02f, -2.53987052e-02f,
  6.90914392e-02f, -1.35629043e-01f, 4.51518781e-02f, -3.97795774e-02f, -1.39742848e-02f, 7.64825344e-02f, -6.57087341e-02f, -5.26227392e-02f, -2.56370399e-02f, 1.48469210e-02f,
  2.64373749e-01f, 2.60580122e-01f, -2.20953375e-02f, -4.09289226e-02f, 6.73579276e-02f, 7.88663998e-02f, -2.16753930e-02f, -1.76576618e-02f, -2.75783446e-02f, 4.81936969e-02f,
  -5.55810705e-02f, -1.09845735e-01f, 1.01853095e-01f, 1.27827022e-02f, 2.56567523e-02f, 7.25279376e-02f, -1.22492155e-02f, 3.30985487e-02f, -3.92506123e-02f, 3.51566933e-02f,
  3.43183614e-02f, 6.16219454e-02f, -8.27289298e-02f, -2.23185606e-02f, -4.79173921e-02f, 4.27427106e-02f, -4.28185537e-02f, 1.87082868e-02f, 1.27347916e-01f, 8.17295238e-02f,
  -4.77938980e-01f, 1.44799873e-01f, 1.40176028e-01f, -9.49712172e-02f, -2.39360884e-01f, -3.88264984e-01f, -2.24730998e-01f, -6.97468668e-02f, -1.12351663e-01f, 2.97861814e-01f,
  6.12189434e-03f, -9.60416198e-02f, 3.15769136e-01f, -8.30786452e-02f, -4.96505111e-01f, 3.82010549e-01f, -2.81589866e-01f, -1.03537068e-01f, 1.00904897e-01f, -2.50158668e-01f,
  -6.01908676e-02f, -1.62208065e-01f, 5.37550077e-02f, -2.84686889e-02f, -1.92023024e-01f, -1.09713338e-02f, 7.94713125e-02f, 1.93567500e-01f, -1.31153300e-01f, -7.62959719e-02f,
  -1.53536469e-01f, 1.17869535e-02f, -3.36480290e-02f, 8.43749568e-02f, -1.26030073e-01f, 5.35986461e-02f, 1.96185745e-02f, 1.18397169e-01f, -1.47255072e-02f, -3.09529845e-02f,
  6.46486655e-02f, -9.18597654e-02f, -3.71988080e-02f, 7.38382488e-02f, -2.09075585e-02f, 3.57648879e-02f, -2.77465954e-02f, 2.50694174e-02f, 2.52682231e-02f, -4.98674028e-02f,
  3.34358439e-02f, 4.62755859e-02f, -1.24610867e-02f, 6.11387528e-02f, -1.24584520e-02f, -2.81737801e-02f, 3.93361449e-02f, 3.83051969e-02f, -4.59434763e-02f, -1.06248476e-01f,
  5.80591597e-02f, 3.12371422e-02f, 3.31061557e-02f, -4.63615954e-02f, -5.44576272e-02f, -8.30992032e-03f, 5.45713119e-02f, -1.50218811e-02f, 3.12500298e-02f, -9.11966115e-02f,
  -1.05684407e-01f, -3.73386079e-03f, -1.01494025e-02f, 2.85858978e-02f, 4.96853283e-03f, -4.78713922e-02f, 4.44905311e-02f, -5.11748902e-03f, -6.03302903e-02f, -4.47684340e-02f,
  3.10663916e-02f, -5.61977737e-02f, 1.19936410e-02f, -3.81233357e-02f, -5.27643077e-02f, 7.61084398e-03f, 1.41560599e-01f, -1.20852084e-03f, 4.57339082e-03f, -6.25532493e-02f,
  -2.39984334e-01f, -2.98836362e-02f, 3.29641439e-02f, -6.15346730e-02f, 6.47797808e-02f, 3.59908044e-02f, 9.15561691e-02f, -6.00014552e-02f, 6.10439144e-02f, -9.43510502e-04f,
  1.16378367e-02f, -4.02151383e-02f, 3.57267745e-02f, -2.49192268e-02f, -2.11125556e-02f, -2.41898801e-02f, 4.83048260e-02f, 3.40600125e-02f, -1.01197511e-01f, 4.30372581e-02f,
  -1.69818476e-02f, 1.57587826e-02f, 4.58860286e-02f, -6.43889904e-02f, 2.47712415e-02f, 5.99107100e-03f, -1.11054108e-01f, 3.29884849e-02f, 7.92655796e-02f, 3.33946273e-02f,
  7.03629628e-02f, 1.17289677e-01f, -3.22472453e-02f, 9.21078399e-02f, -2.51156896e-01f, -1.29353121e-01f, 2.08861902e-01f, -2.10924640e-01f, -1.02418214e-02f, 1.52178332e-01f,
  -1.93445589e-02f, 3.98845464e-01f, 8.71841684e-02f, 2.23289654e-01f, 3.12175095e-01f, 2.54542202e-01f, 1.60020307e-01f, 2.23720014e-01f, 2.71883495e-02f, 1.09884497e-02f,
  -4.03284840e-02f, 9.79639813e-02f, 8.97668302e-02f, -1.81095466e-01f, -1.98894754e-01f, -1.48007378e-01f, 1.09729290e-01f, -3.29473093e-02f, -1.01517349e-01f, 1.02186806e-01f,
  5.22280186e-02f, -4.31574248e-02f, -6.02055434e-03f, 4.39006165e-02f, -4.58145700e-02f, -4.17259149e-02f, 1.00455843e-02f, 4.26169224e-02f, 9.15982574e-03f, -6.87382370e-02f,
  -3.69766541e-03f, -1.60805553e-01f, 6.67613968e-02f, -3.16649973e-02f, -7.29971156e-02f, -4.08279598e-02f, -1.73157051e-01f, -8.23591873e-02f, -4.53181230e-02f, -7.97193348e-02f,
  -4.83950190e-02f, -2.72615589e-02f, 6.88475221e-02f, 2.10100096e-02f, -9.82875228e-02f, -1.13032512e-01f, -6.71870708e-02f, 8.72248560e-02f, -5.19249812e-02f, -2.00244132e-02f,
  2.58849096e-02f, 6.25833943e-02f, 3.32210213e-02f, 5.07379360e-02f, 2.67374981e-02f, -6.48503527e-02f, 5.50254844e-02f, -1.77364598e-03f, -2.95628402e-02f, 2.39794911e-03f,
  -5.02835438e-02f, 5.57108875e-03f, -2.69024223e-02f, -4.86373454e-02f, 4.46861461e-02f, 9.39017162e-02f, 4.57340702e-02f, -5.57012148e-02f, -5.35887368e-02f, -8.35425779e-02f,
  1.46848783e-02f, -1.89541057e-02f, 1.48646235e-01f, -4.48268019e-02f, 4.91704047e-02f, -3.19170728e-02f, -9.24081355e-02f, -1.33959368e-01f, -8.76203701e-02f, 4.77592535e-02f,
  2.40480870e-01f, 3.19597423e-01f, -6.56490400e-02f, 1.31589388e-02f, 4.00699601e-02f, -3.29428315e-02f, -6.89392015e-02f, -5.88709861e-02f, -2.21688133e-02f, -4.54245992e-02f,
  -1.08847596e-01f, -3.59985158e-02f, 4.25888924e-03f, -1.92637797e-02f, 1.40938997e-01f, -8.30278546e-02f, 1.07310228e-01f, 1.45632446e-01f, 1.23979315e-01f, 6.25933409e-02f,
  5.47883706e-03f, 1.56542324e-02f, -7.58751854e-02f, -6.47764234e-03f, -1.00445122e-01f, 6.00600336e-03f, 5.75402826e-02f, -2.01833695e-02f, -7.17643052e-02f, -5.66983446e-02f,
  1.65036753e-01f, 6.04571879e-01f, -2.51341552e-01f, 1.26466990e-01f, -1.72859371e-01f, -3.27678949e-01f, -1.55382141e-01f, -7.71737769e-02f, -6.47652894e-02f, 1.90327287e-01f,
  1.93479151e-01f, 4.11886215e-01f, 1.74350575e-01f, 1.93347305e-01f, -1.72205374e-01f, -1.44988997e-02f, -7.03918189e-02f, -3.78897078e-02f, 1.16488794e-02f, -1.22732930e-01f,
  -6.31074011e-02f, 1.75458089e-01f, -8.76103863e-02f, 1.20383091e-02f, 6.64802715e-02f, 4.83213998e-02f, -7.93347806e-02f, -2.86995880e-02f, 7.75268599e-02f, 1.66297004e-01f,
  -1.04609616e-02f, 1.36078671e-01f, 7.46877491e-02f, 9.09481198e-02f, -1.00318193e-01f, 2.16705352e-02f, -9.54770967e-02f, -1.03791011e-02f, 1.21640250e-01f, -4.42414954e-02f,
  1.45175606e-01f, 1.69315562e-02f, 5.82444780e-02f, 7.25418478e-02f, 3.65106575e-02f, 5.78218810e-02f, 1.19714094e-02f, -7.70288184e-02f, 2.33815834e-02f, -1.18985713e-01f,
  -4.44861799e-02f, -7.27460086e-02f, -9.56792161e-02f, -5.97466575e-03f, 5.71422838e-02f, 9.39133635e-04f, -9.17867348e-02f, -5.09897321e-02f, -5.56236617e-02f, -7.94082060e-02f,
  -8.05576220e-02f, -4.32813764e-02f, -3.92260700e-02f, -4.12906371e-02f, 3.16521302e-02f, -1.42628541e-02f, 1.09877493e-02f, 7.52745122e-02f, -2.24969760e-02f, 6.92334399e-02f,
  -5.28953709e-02f, 1.36770338e-01f, 2.89648809e-02f, -8.72547626e-02f, -1.33298784e-02f, 3.56680565e-02f, -3.37549411e-02f, 6.11827560e-02f, -1.14838742e-02f, -3.71712670e-02f,
  3.57816368e-02f, -3.91918942e-02f, 1.33485526e-01f, -1.62847503e-03f, 3.88193913e-02f, 3.05728056e-02f, 1.21212378e-01f, -5.82261458e-02f, 2.10306179e-02f, -3.58255319e-02f,
  2.34016389e-01f, 8.48808438e-02f, 9.00569856e-02f, 1.25486046e-01f, -1.57082900e-02f, -4.23701964e-02f, -4.73459996e-02f, -2.82354150e-02f, 2.35890355e-02f, -3.45350355e-02f,
  -1.16988167e-01f, -6.52595609e-02f, -1.00438647e-01f, -6.57982975e-02f, 3.12457327e-02f, -4.29809652e-03f, 1.87851824e-02f, 1.08112141e-01f, -2.06997506e-02f, 8.48862007e-02f,
  1.38460705e-03f, 1.74124148e-02f, -4.35250252e-02f, 1.80201214e-02f, 1.01614911e-02f, 3.94473597e-03f, 3.53760570e-02f, -3.75460610e-02f, 2.32696012e-02f, 2.09109355e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.82599777e-01f, 4.18670893e-01f, -4.75150317e-01f, -1.12170801e-01f, 1.87130839e-01f, 2.52648145e-01f, 3.65633965e-01f, 1.96427658e-01f, 1.08804159e-01f, 4.41032648e-01f,
  2.86058217e-01f, 1.43303156e-01f, 3.26791584e-01f, 2.06263602e-01f, -3.42551619e-01f, 2.36112818e-01f, 2.76308030e-01f, 1.46358863e-01f, 1.39380619e-01f, 1.96332127e-01f,
  -1.16879106e-01f, 4.54497188e-01f, -2.88570493e-01f, 1.36332735e-01f, 9.87967476e-02f, -2.27604553e-01f, -6.36242852e-02f, -1.18726142e-01f, -9.63022709e-02f, 1.34342283e-01f,
  4.72077131e-02f, 1.22547314e-01f, -5.73765766e-03f, -7.80889019e-02f, -1.89177811e-01f, -7.39817470e-02f, -1.39695361e-01f, -1.15726903e-01f, -7.66926864e-03f, 7.34381378e-02f,
  5.71803339e-02f, 2.53307298e-02f, 1.04992457e-01f, -4.11467478e-02f, -3.27944979e-02f, -1.73286479e-02f, -6.81815445e-02f, -1.73684791e-01f, 1.09833606e-01f, -5.67343533e-02f,
  -2.22588092e-01f, -1.32515475e-01f, -1.44174704e-02f, 2.73476541e-03f, 7.59496866e-03f, 1.02691904e-01f, 3.28160562e-02f, -1.29806444e-01f, 5.05919829e-02f, -3.16449516e-02f,
  -3.05793062e-02f, 5.63498400e-02f, 4.60217446e-02f, 1.82232130e-02f, -2.50875321e-03f, -1.90645549e-03f, 1.21240601e-01f, -4.89762984e-02f, -9.83327776e-02f, 1.42438173e-01f,
  -8.13825130e-02f, 1.27478801e-02f, 1.89077854e-02f, -8.27724710e-02f, 8.04835483e-02f, 1.82837117e-02f, -1.19799167e-01f, 6.96739033e-02f, 2.36800611e-02f, -1.17301725e-01f,
  3.22692953e-02f, 1.47355661e-01f, 6.87239841e-02f, -9.52833295e-02f, 4.64721806e-02f, 9.09665320e-03f, 1.49448365e-01f, 5.00377715e-02f, -2.61449013e-02f, 7.45327622e-02f,
  2.39281058e-01f, 2.73524851e-01f, 6.15210049e-02f, -1.48712257e-02f, -4.26283777e-02f, -7.81738758e-03f, 1.73055157e-02f, 2.93670092e-02f, 1.13502070e-01f, 4.14618105e-02f,
  3.54536474e-02f, 9.70103443e-02f, -1.33274093e-01f, 5.94220869e-02f, -1.00659110e-01f, 6.74190000e-02f, 8.05070773e-02f, -7.14383349e-02f, -1.41285248e-02f, 3.90128717e-02f,
  -1.22818582e-01f, 9.62427706e-02f, -8.73912200e-02f, -3.87111343e-02f, 5.92653640e-02f, 4.13701795e-02f, 1.07703716e-01f, -2.45475248e-02f, -1.11916341e-01f, -4.35066503e-03f,
  4.03952807e-01f, -1.79445043e-01f, -3.13740522e-01f, -1.55777484e-01f, -6.77236542e-02f, -1.37766525e-01f, -2.19498500e-01f, -7.43699819e-02f, 3.75333071e-01f, -8.11872557e-02f,
  -1.64850906e-01f, 1.27222627e-01f, -9.81247202e-02f, -1.84405059e-01f, 3.66190523e-01f, 2.41011366e-01f, -1.71710122e-02f, -9.60237905e-02f, 2.11941272e-01f, -1.37210026e-01f,
  1.93575397e-01f, -7.92345926e-02f, -3.07664096e-01f, -1.26411229e-01f, -3.42933327e-01f, -1.84247494e-01f, -1.26991585e-01f, -2.27821097e-01f, -2.62761325e-01f, -1.32496685e-01f,
  -3.01513728e-02f, 9.56385806e-02f, -7.52880350e-02f, 9.35106277e-02f, -1.01930209e-01f, 2.27019424e-03f, -1.98001966e-01f, -3.66844572e-02f, 6.12151250e-02f, 1.15879506e-01f,
  -4.62416708e-02f, 2.23224387e-01f, 8.54390766e-03f, 1.08815804e-01f, -3.68748344e-02f, 9.96746272e-02f, 1.39623955e-01f, 5.41216992e-02f, -3.88743095e-02f, -3.60732600e-02f,
  7.15420172e-02f, 4.21940722e-02f, 1.25245363e-01f, 5.12156636e-02f, -1.53653398e-01f, 5.03141026e-04f, -7.06191733e-02f, -2.16537461e-01f, -1.93897542e-02f, 1.44841850e-01f,
  -8.90515000e-02f, 1.99759733e-02f, 8.34047496e-02f, 1.75581314e-02f, 2.82115433e-02f, -7.06762597e-02f, 7.06689283e-02f, 9.22546089e-02f, 1.07150048e-01f, -7.51776919e-02f,
  4.10964787e-02f, 7.17652515e-02f, 9.63401571e-02f, 6.36051074e-02f, 9.59544703e-02f, 1.09350041e-01f, 7.76103288e-02f, 9.93190110e-02f, 8.61354768e-02f, 6.75570816e-02f,
  1.24217095e-02f, 1.75631493e-01f, 5.46678156e-02f, -3.57644744e-02f, -7.58021921e-02f, -1.74182523e-02f, -3.73308510e-02f, -7.65568987e-02f, -8.66789147e-02f, -5.64127937e-02f,
  -1.20644130e-01f, 5.35493493e-02f, -5.16705066e-02f, 8.70248228e-02f, -2.02007577e-01f, 1.28071025e-01f, 2.09562927e-02f, 8.01645741e-02f, -1.27945825e-01f, 9.49090049e-02f,
  1.23883854e-03f, -1.60351414e-02f, -9.00257826e-02f, 1.39552161e-01f, -5.24479747e-02f, 1.45293668e-01f, -1.99804440e-01f, 7.57237896e-02f, -1.44063279e-01f, -1.85514256e-01f,
  -9.06742215e-02f, 1.24428451e-01f, 2.03713756e-02f, -2.41330583e-02f, -6.61353022e-02f, -5.32663912e-02f, 2.64909893e-01f, 3.23365256e-03f, -8.81465822e-02f, 5.25756702e-02f,
  5.40358186e-01f, -1.25742704e-01f, -3.42011333e-01f, 3.64494234e-01f, -2.55804621e-02f, 2.14771971e-01f, 1.55237511e-01f, 2.24838406e-01f, 2.97556758e-01f, 2.05273718e-01f,
  4.16611463e-01f, -2.45171592e-01f, -1.19758911e-01f, 6.56637609e-01f, 6.34556040e-02f, 1.90430403e-01f, 4.74517107e-01f, 9.01412517e-02f, 1.11454442e-01f, 2.44197413e-01f,
  1.89737186e-01f, 5.56187332e-01f, -1.14846297e-01f, -5.67066260e-02f, 2.87023604e-01f, -1.68998748e-01f, -1.73666194e-01f, -5.55506945e-01f, 2.00126544e-02f, -1.31180421e-01f,
  1.45312965e-01f, 1.34304628e-01f, 7.15571344e-02f, -1.12802163e-01f, 1.17165394e-01f, 3.37454528e-02f, -2.11235061e-01f, -2.32424945e-01f, -1.02877736e-01f, 9.07140411e-03f,
  -1.62734449e-01f, 3.54209654e-02f, 1.46021694e-01f, -1.59864649e-01f, 1.33011296e-01f, 5.89786731e-02f, 7.06820786e-02f, 5.03047928e-02f, -2.49261819e-02f, -8.41064844e-03f,
  -3.89518961e-02f, 6.46037236e-02f, 1.23460114e-01f, -1.33653834e-01f, -4.11121547e-02f, 1.05548061e-01f, -1.07080080e-01f, -2.00619668e-01f, -2.88938209e-02f, 8.68065879e-02f,
  1.23711303e-01f, 5.82394451e-02f, 1.95029482e-01f, 2.13148240e-02f, 4.61728498e-02f, 1.87073555e-02f, -4.27017584e-02f, -4.75466289e-02f, -3.63616310e-02f, 3.19212414e-02f,
  -3.29926945e-02f, 4.64830874e-03f, 1.16998933e-01f, -8.27482808e-03f, 1.94536328e-01f, 4.54927869e-02f, -7.54626766e-02f, 4.68380786e-02f, 1.28696233e-01f, -1.28826266e-02f,
  -1.55713975e-01f, 3.46905440e-02f, 5.69459908e-02f, -7.63900802e-02f, -2.32763663e-02f, -7.17324913e-02f, 2.21959129e-01f, 1.01804063e-01f, 1.26629593e-02f, -5.28573245e-02f,
  3.11850589e-02f, -1.94498412e-02f, 5.02085174e-03f, 3.36779319e-02f, -2.20805943e-01f, 1.05207451e-01f, 2.96840258e-02f, 5.11249248e-03f, -1.52408257e-01f, 1.45642981e-01f,
  -5.62607944e-02f, -1.19747445e-02f, -3.42144333e-02f, -1.83435401e-03f, -8.80674124e-02f, 7.17245564e-02f, 1.16464552e-02f, -4.03310172e-02f, -2.85824239e-02f, 5.95724769e-03f,
  -8.94500688e-02f, 3.85652371e-02f, 2.45785192e-02f, 6.30573705e-02f, 5.83436377e-02f, 2.93984506e-02f, 2.63543683e-04f, 7.95262456e-02f, 3.67571786e-02f, 1.92190818e-02f,
  -4.73221272e-01f, 4.70791459e-01f, 1.93363160e-01f, 3.46559674e-01f, -3.00385714e-01f, -6.07920349e-01f, -1.87585101e-01f, 1.18191950e-01f, 8.83067623e-02f, 4.12239581e-01f,
  1.38925329e-01f, 4.63215232e-01f, 4.11020964e-02f, 4.68722254e-01f, -5.90207160e-01f, 1.91644691e-02f, -9.39921662e-02f, 9.19385254e-02f, 1.06456771e-01f, -1.56756863e-01f,
  -1.30429596e-01f, 9.76179074e-03f, 7.13806078e-02f, 6.89885914e-02f, 9.95161608e-02f, 3.32161039e-01f, -1.42255828e-01f, 1.73541993e-01f, 3.96883562e-02f, -8.58507082e-02f,
  -2.94735014e-01f, 3.71478260e-01f, 1.20804541e-01f, -1.03155561e-01f, -9.85886902e-02f, -7.37147927e-02f, -6.85371161e-02f, 3.79121373e-03f, 1.21994153e-01f, 2.34355833e-02f,
  7.82378092e-02f, 4.90063131e-02f, 4.99788783e-02f, 8.69556796e-03f, -1.09238932e-02f, 1.10035762e-01f, 1.02814697e-01f, -2.52591912e-02f, 1.45972133e-01f, 1.48437172e-01f,
  1.55040085e-01f, 1.08510569e-01f, -8.53203833e-02f, 1.10915750e-01f, 3.13176168e-03f, 3.14049497e-02f, -7.42166862e-02f, 1.53250732e-02f, -7.08764466e-03f, -2.86527686e-02f,
  1.00197487e-01f, -6.65144548e-02f, -3.18740159e-02f, -4.61374002e-04f, 4.01953273e-02f, -1.10484716e-02f, -8.79326649e-03f, -6.24115542e-02f, 4.47692238e-02f, -9.57754068e-03f,
  -1.29434571e-01f, 3.62041779e-02f, 4.48875166e-02f, -8.99358839e-02f, 1.31765194e-02f, -1.49391200e-02f, 3.99944149e-02f, 3.67145687e-02f, -1.31214961e-01f, 2.04010680e-02f,
  1.36422172e-01f, -1.24101900e-01f, 1.08535953e-01f, -1.96324766e-01f, -1.31133541e-01f, -4.41398397e-02f, 6.54577315e-02f, 1.55153526e-02f, 4.85904068e-02f, -1.16183676e-01f,
  -6.35539055e-01f, -2.52348054e-02f, -4.11037952e-02f, -2.78749578e-02f, 2.47713272e-02f, -9.98086333e-02f, 4.34177630e-02f, -1.17037771e-03f, -7.87685290e-02f, -1.04918823e-01f,
  -1.86604947e-01f, -1.49146155e-01f, -1.31345063e-01f, 7.89833367e-02f, 1.89718883e-02f, -9.97055322e-02f, -1.07327491e-01f, 4.80015203e-02f, -5.65738641e-02f, 5.07855676e-02f,
  -8.06125067e-03f, 1.17979469e-02f, 2.24597380e-02f, -3.40808183e-02f, -2.83904802e-02f, -2.23684101e-03f, -3.24572772e-02f, 8.33132938e-02f, -1.46672148e-02f, 8.23996738e-02f,
  -5.52459478e-01f, -5.53475916e-01f, 4.72545058e-01f, 2.04035118e-01f, 1.34644778e-02f, 1.17894828e-01f, 1.89019784e-01f, -3.76362936e-03f, -1.80751875e-01f, -1.80472791e-01f,
  1.01218171e-01f, -2.68999010e-01f, 1.00608625e-01f, 2.26537839e-01f, 4.08810765e-01f, 3.21002096e-01f, 2.82634467e-01f, 5.76004013e-02f, 2.55857706e-01f, -3.87620069e-02f,
  3.04120004e-01f, 1.25094444e-01f, 4.15334672e-01f, 5.30581102e-02f, 6.58852980e-02f, -1.11221906e-03f, -2.80443784e-02f, 3.76012698e-02f, 5.61490431e-02f, 8.30930658e-03f,
  -3.34724784e-01f, -8.73389095e-02f, 4.65687513e-02f, -3.99466567e-02f, -7.01992819e-03f, -2.08213523e-01f, 8.06173161e-02f, 1.99240204e-02f, 7.35387206e-02f, -4.66645323e-02f,
  -1.13944381e-01f, 3.94051261e-02f, -3.80111486e-02f, -9.90829617e-02f, -1.25828087e-01f, -6.55866042e-03f, -1.33677414e-02f, 1.93187669e-01f, 6.34649247e-02f, -9.61309008e-04f,
  1.41427387e-02f, 6.18505180e-02f, 1.68403581e-01f, 1.17841400e-01f, 1.92466393e-01f, 3.03187501e-02f, 1.59428537e-01f, 6.28927872e-02f, -1.71841100e-01f, -1.08108468e-01f,
  8.15726966e-02f, 4.61399443e-02f, -1.06367186e-01f, -2.65456066e-02f, 2.28577740e-02f, 5.08071780e-02f, -4.04357538e-02f, -2.38294341e-02f, 5.84616363e-02f, 2.76532080e-02f,
  9.93264467e-02f, 1.09815793e-02f, 2.37537194e-02f, -8.95771757e-02f, 6.50861161e-03f, 5.69384657e-02f, 1.16243213e-01f, -9.86686572e-02f, 2.24043783e-02f, 1.35284394e-01f,
  -1.03907026e-01f, 4.32175677e-03f, 6.24709949e-02f, 4.11364846e-02f, -1.17937684e-01f, -1.59833524e-02f, 5.55628538e-02f, 7.22436979e-02f, 5.82362823e-02f, -3.26895081e-02f,
  -7.27248013e-01f, -5.43621361e-01f, -9.62750316e-02f, -1.95079982e-01f, -8.95235166e-02f, -7.68869668e-02f, -1.39286155e-02f, -7.20632300e-02f, -1.19597584e-01f, 6.66542053e-02f,
  -3.59025709e-02f, 1.91117510e-01f, -1.97935984e-01f, 1.49141876e-02f, 5.71591854e-02f, -5.36247566e-02f, -7.94763267e-02f, -1.44062757e-01f, -1.79434553e-01f, -2.54188497e-02f,
  -9.19205099e-02f, -1.10674407e-02f, 1.02516457e-01f, 1.15791053e-01f, 4.84078750e-02f, -5.50354496e-02f, -9.11158696e-02f, -1.22610815e-01f, 2.33541466e-02f, 4.96825315e-02f,
  -1.02620386e-01f, -6.78334832e-02f, 5.16701639e-01f, -5.00135347e-02f, 6.08207285e-01f, 7.67189741e-01f, 2.61260599e-01f, 5.36965311e-01f, 7.89166570e-01f, -3.19160432e-01f,
  -6.44446118e-04f, -4.63935375e-01f, 2.79549453e-02f, -1.01426236e-01f, 3.14639598e-01f, 2.04796150e-01f, 2.30978146e-01f, -5.95234968e-02f, 2.27158830e-01f, 7.82368556e-02f,
  1.61832795e-01f, -8.67780298e-02f, -2.41234109e-01f, -7.39430711e-02f, -4.04403135e-02f, -1.39157102e-01f, -4.59794819e-01f, 3.76078486e-02f, -5.05414665e-01f, 2.01150835e-01f,
  2.17374973e-02f, 4.49591614e-02f, -9.24501121e-02f, 4.91735041e-02f, 1.83435664e-01f, -9.45568457e-02f, -1.15854837e-01f, 3.53709385e-02f, 1.30127013e-01f, -3.04686818e-02f,
  -2.33370811e-01f, -1.20175876e-01f, -2.10115463e-02f, 1.21059053e-01f, 1.11890800e-01f, 9.21224356e-02f, 1.02693997e-01f, 1.05042249e-01f, 1.62107140e-01f, 1.37973219e-01f,
  6.65086433e-02f, -4.22490351e-02f, 5.68108037e-02f, -2.61218864e-02f, 9.66393948e-02f, 1.54923014e-02f, -5.06236851e-02f, 6.49078265e-02f, -3.62723842e-02f, 1.28408030e-01f,
  -1.34016678e-01f, 4.17095646e-02f, -5.20684272e-02f, -2.43318118e-02f, 5.24094179e-02f, -2.10859086e-02f, 1.37499571e-02f, -1.88276917e-02f, 8.94214734e-02f, -2.06514150e-02f,
  -1.51177286e-03f, -1.04183555e-01f, 2.06104200e-02f, -1.99809577e-03f, -6.27856106e-02f, -6.08596206e-02f, -6.03817515e-02f, 1.99412573e-02f, -9.11950320e-03f, 4.86837551e-02f,
  -3.76672223e-02f, 4.10644300e-02f, -2.60651503e-02f, -5.12183420e-02f, 5.64731807e-02f, 4.39766385e-02f, 2.68604234e-03f, 6.56369850e-02f, 7.60734305e-02f, -1.07336743e-02f,
  2.48285562e-01f, 6.95442222e-03f, 6.14583585e-03f, -2.52225965e-01f, -7.15245530e-02f, 3.65852863e-02f, 1.07320109e-02f, 1.22505888e-01f, 5.40135652e-02f, 4.60992865e-02f,
  -9.81557462e-03f, -1.43951029e-01f, 5.72738685e-02f, 1.69788990e-02f, -7.22597688e-02f, 2.04575107e-01f, -1.17443345e-01f, -1.69011783e-02f, 1.40920460e-01f, -1.26626372e-01f,
  -1.85281813e-01f, -2.10084990e-01f, -2.64159180e-02f, -8.60077236e-03f, -9.75652784e-02f, -1.12417355e-01f, -4.93859835e-02f, 1.03805356e-01f, -2.72813924e-02f, 2.97185238e-02f,
  -5.56903005e-01f, 1.60688490e-01f, -3.49222630e-01f, -1.68537438e-01f, -4.63778406e-01f, -2.07528934e-01f, -1.47406012e-01f, 2.77771801e-02f, 1.87448472e-01f, 3.40972543e-01f,
  -1.03572950e-01f, 2.88838446e-01f, 4.63587791e-01f, -1.72087416e-01f, -1.63824886e-01f, 3.79639685e-01f, -2.10155591e-01f, 3.87233719e-02f, 3.37645225e-02f, -2.30059311e-01f,
  -9.35905948e-02f, -1.82474270e-01f, -3.89952920e-02f, -6.93138018e-02f, -4.52623367e-01f, -1.99749380e-01f, -2.83775210e-01f, -7.94134513e-02f, -4.41891164e-01f, -1.63443938e-01f,
  -2.96915621e-01f, 1.89444125e-01f, 1.22915662e-03f, 1.30813688e-01f, -2.69699842e-01f, -1.98029488e-01f, -1.87108263e-01f, 1.41667109e-02f, 6.77195005e-03f, -1.76456682e-02f,
  6.78531006e-02f, 7.62248710e-02f, -7.26818922e-04f, 1.61864549e-01f, -6.08776771e-02f, 3.23643200e-02f, -2.04460975e-02f, -2.81488419e-01f, -7.65426690e-03f, -4.93220985e-02f,
  5.39780557e-02f, 4.06220257e-02f, -1.41914263e-01f, 2.77632084e-02f, -1.07789531e-01f, 6.10455796e-02f, -6.31724671e-02f, -6.45464510e-02f, -6.57741725e-02f, -1.89206168e-01f,
  -9.94507149e-02f, -5.99795729e-02f, -2.13874541e-02f, -4.16768854e-03f, 1.53289139e-01f, -8.34783912e-02f, 5.91703355e-02f, 1.66156255e-02f, 1.37950061e-02f, 7.94375315e-02f,
  -8.87431204e-02f, 5.07439077e-02f, -1.12330370e-01f, -1.96788330e-02f, -6.79816678e-02f, -5.07314410e-03f, -3.14892456e-02f, 6.65897802e-02f, -9.53454971e-02f, -2.09473483e-02f,
  1.60345599e-01f, -3.88819762e-02f, -1.41995810e-02f, -1.33077875e-01f, 2.29099300e-02f, -4.38524701e-04f, -1.22613318e-01f, 4.77622673e-02f, 1.88811291e-02f, -1.70422599e-01f,
  -3.90133202e-01f, -9.11301300e-02f, 1.42184719e-01f, 5.71462661e-02f, 4.08681259e-02f, -5.74073754e-03f, -1.30106047e-01f, -7.42230099e-03f, 1.28747448e-02f, -8.22693855e-03f,
  2.37430688e-02f, 1.23388104e-01f, -1.99283496e-01f, -5.44431573e-03f, 1.13888644e-01f, -8.91206041e-02f, -1.05210468e-01f, 4.12720367e-02f, -1.03376582e-01f, -1.30195349e-01f,
  -4.15048227e-02f, -2.91864248e-03f, 1.33167326e-01f, 9.25700217e-02f, -3.29763703e-02f, 1.39021743e-02f, -1.18212737e-01f, 1.05367675e-01f, -1.58653960e-01f, -2.47919634e-02f,
  -4.17470545e-01f, -4.65096325e-01f, -2.32050866e-01f, -1.13601096e-01f, -4.22442034e-02f, -2.26765916e-01f, -4.62924063e-01f, -1.50721937e-01f, -4.39011425e-01f, -2.86102682e-01f,
  -4.56973761e-02f, -7.44657367e-02f, -3.48039001e-01f, -9.74809751e-02f, 3.22609484e-01f, -2.52117395e-01f, 2.25407302e-01f, 1.38635486e-01f, 8.23757797e-02f, 2.35569477e-01f,
  3.94460231e-01f, 3.28870386e-01f, 5.47622263e-01f, 6.02453232e-01f, 1.02586761e-01f, 4.21388358e-01f, 4.40174580e-01f, 3.82460982e-01f, 5.27918637e-01f, 3.08605373e-01f,
  -1.26008600e-01f, -9.22712535e-02f, -7.84780979e-02f, 1.25319501e-02f, 5.44257984e-02f, 1.67905737e-03f, 1.39977977e-01f, 1.12667885e-02f, -1.27234071e-01f, 1.04265317e-01f,
  3.58572714e-02f, 1.64091215e-01f, -2.91790646e-02f, -2.64002178e-02f, -3.11994795e-02f, 1.07474327e-02f, 1.37390941e-01f, -1.35848289e-02f, 3.29287089e-02f, -1.97194785e-01f,
  -1.78881943e-01f, -9.82938334e-03f, -3.14773479e-03f, -1.09544890e-02f, -3.68915237e-02f, -1.44441098e-01f, -7.23902211e-02f, 2.70577222e-02f, -1.46878362e-01f, 1.55475028e-02f,
  4.43306826e-02f, -1.09448932e-01f, 2.53365822e-02f, -1.31209120e-01f, -2.56219469e-02f, -1.39237463e-01f, 7.36659765e-03f, -7.22119063e-02f, 8.86620879e-02f, 5.55001050e-02f,
  -8.42621699e-02f, -4.52452302e-02f, -2.75819469e-02f, -9.48579237e-02f, 7.47990832e-02f, -6.14863001e-02f, 9.68575701e-02f, 3.81732062e-02f, -1.74538754e-02f, -1.28246084e-01f,
  -1.93325326e-01f, 5.24502946e-04f, -5.58722094e-02f, 3.86920795e-02f, -8.74820501e-02f, 1.13590562e-03f, 6.52793050e-02f, -6.48274496e-02f, 7.94596076e-02f, 2.42326841e-01f,
  3.73844467e-02f, 1.74506411e-01f, 5.16067035e-02f, -5.20933643e-02f, -6.69014454e-02f, 7.75546134e-02f, 5.68482354e-02f, -6.42797425e-02f, 6.25335798e-02f, 6.96035922e-02f,
  2.23498553e-01f, 1.26227096e-01f, -1.04315907e-01f, -1.27729820e-02f, 1.36103705e-01f, -6.32640049e-02f, 7.39144310e-02f, 1.17000520e-01f, 1.50617599e-01f, 1.58261836e-01f,
  6.97183609e-02f, 5.40369712e-02f, 5.33289053e-02f, -7.90470839e-02f, -1.18051514e-01f, -3.27696726e-02f, -1.69024076e-02f, 2.28728205e-02f, -5.15632518e-02f, -1.30078057e-02f,
  -3.07026029e-01f, -4.67971247e-03f, -5.03142059e-01f, -3.21891069e-01f, 2.86891311e-01f, -4.10387576e-01f, -3.49917531e-01f, -3.75164635e-02f, -4.53226306e-02f, 2.86046445e-01f,
  8.81243646e-02f, -2.07414463e-01f, 1.96297303e-01f, -5.28586626e-01f, -3.96543920e-01f, -2.97123671e-01f, -4.77209955e-01f, -3.54414821e-01f, -6.90923408e-02f, -2.65409261e-01f,
  -2.48250723e-01f, -3.39584082e-01f, -4.36112136e-01f, 2.18933806e-01f, -2.07452402e-01f, 1.99211672e-01f, 2.67563075e-01f, 2.26790547e-01f, -2.10515901e-01f, -4.19913232e-02f,
  -1.21376455e-01f, 1.50030339e-03f, -1.58066303e-03f, -1.20137230e-01f, -9.01514292e-03f, 8.13903436e-02f, -6.40108287e-02f, -5.33105433e-02f, 7.52569214e-02f, -5.71092814e-02f,
  3.15110832e-02f, -1.87266190e-02f, -1.71430230e-01f, 2.21235249e-02f, 6.71008900e-02f, 4.72361594e-02f, -1.82204112e-01f, 3.37231383e-02f, -1.61252113e-03f, -1.66422188e-01f,
  -1.20508119e-01f, -1.39258862e-01f, -3.02951057e-02f, -1.46818273e-02f, -5.69290742e-02f, 6.94524050e-02f, -6.32727817e-02f, 1.30942045e-02f, 3.40155922e-02f, -1.07589170e-01f,
  -2.14669053e-02f, 1.44119533e-02f, 7.72429109e-02f, -2.10257736e-03f, 2.07725633e-02f, 9.09099206e-02f, 4.01535891e-02f, 2.26887595e-02f, 8.11968669e-02f, 3.49175595e-02f,
  2.89886165e-02f, 4.53285016e-02f, -2.84454040e-02f, -3.22622880e-02f, -4.63356301e-02f, -6.56882301e-02f, -6.72345236e-02f, 4.04480519e-03f, -6.46822378e-02f, -1.16041815e-02f,
  9.32307094e-02f, -1.78405587e-02f, 7.71887004e-02f, 7.74867535e-02f, 1.58676878e-02f, -6.02274248e-03f, 2.18956340e-02f, -1.85907975e-01f, 8.89998078e-02f, 2.98535489e-02f,
  5.73060140e-02f, 3.25730257e-02f, 2.66821627e-02f, 1.01582319e-01f, 5.72900660e-02f, -6.43305257e-02f, -1.31907817e-02f, -7.64035285e-02f, -2.00207178e-02f, -6.27335336e-04f,
  -1.82661600e-03f, 7.96403214e-02f, 1.84978023e-01f, 2.06742082e-02f, 7.39413500e-02f, -2.56030331e-03f, 2.40593106e-02f, 1.31292745e-01f, 6.78695962e-02f, 1.00139551e-01f,
  6.75520450e-02f, 1.14808597e-01f, -5.66130155e-04f, 3.14939804e-02f, 6.19505420e-02f, 1.38001233e-01f, 1.32719159e-01f, -3.36697139e-02f, 3.50450389e-02f, -1.05103548e-03f,
  5.69949210e-01f, -5.13016462e-01f, 8.66154730e-02f, 3.54084432e-01f, 2.98671961e-01f, 2.65416533e-01f, 4.87336129e-01f, 6.79266825e-02f, 1.03347085e-01f, -3.99384826e-01f,
  6.12683548e-03f, -1.89767346e-01f, 1.29164249e-01f, -7.35161453e-02f, 2.90559500e-01f, -6.40349509e-03f, 9.67244431e-02f, -1.19607203e-01f, 1.60383782e-03f, 1.63113140e-02f,
  2.39495128e-01f, 3.37908529e-02f, 2.01854318e-01f, -3.17426056e-01f, 1.90969169e-01f, -2.66723424e-01f, -1.55536428e-01f, 8.26485381e-02f, -3.54232788e-01f, 1.09724127e-01f,
  1.06733032e-01f, 2.47268043e-02f, 1.35523558e-01f, 6.98436575e-04f, 1.15788750e-01f, 1.31478056e-01f, 2.46816943e-03f, 1.16394579e-01f, 1.67038515e-02f, 1.13050640e-02f,
  3.40033439e-03f, -1.54641613e-01f, -1.64593443e-01f, 1.09723829e-01f, 7.35309720e-02f, -9.21362340e-02f, -2.91107651e-02f, 3.96856144e-02f, -1.44118741e-01f, -3.63827758e-02f,
  9.61465165e-02f, -1.12838507e-01f, 4.24027070e-02f, -1.40755042e-01f, 1.81139447e-02f, 7.08059371e-02f, 3.09735797e-02f, 1.33195277e-02f, -1.74266085e-01f, -7.18928352e-02f,
  -1.14009805e-01f, -1.70821436e-02f, 9.50181931e-02f, -5.85681433e-03f, 1.26628861e-01f, 6.92581162e-02f, -1.40277907e-01f, -1.03500679e-01f, 6.44783909e-03f, 6.89182132e-02f,
  9.92559195e-02f, -1.35833798e-02f, -2.30912473e-02f, 5.55430502e-02f, 2.38367282e-02f, 4.79666069e-02f, 8.89488533e-02f, -7.11679459e-02f, 9.28068534e-02f, 7.15240091e-02f,
  -2.92920284e-02f, 9.87893064e-03f, 1.22238003e-01f, 9.02532786e-03f, -1.35319367e-01f, 1.27754822e-01f, -1.82595141e-02f, 3.86603363e-02f, 4.30987775e-02f, 8.45688209e-03f,
  -8.93063173e-02f, -5.19053400e-01f, 3.58822122e-02f, -1.23078495e-01f, -4.68592420e-02f, 2.30816957e-02f, -9.68534574e-02f, -1.56191304e-01f, -9.63961259e-02f, 1.75480787e-02f,
  -6.51868731e-02f, 1.33702913e-02f, 3.94820906e-02f, 2.17022002e-03f, -8.21511075e-02f, 5.26612028e-02f, -8.69447142e-02f, -2.20998842e-02f, 3.05689573e-02f, -2.14172438e-01f,
  3.39865796e-02f, -1.79278124e-02f, 8.85276031e-03f, 2.11406816e-02f, -1.81149349e-01f, -1.08374640e-01f, -2.93349195e-02f, -4.88604903e-02f, -1.42145663e-01f, -2.41995722e-01f,
  2.80414760e-01f, 1.43114671e-01f, 3.89098413e-02f, -5.31357825e-01f, -1.83125690e-01f, -5.26333302e-02f, -4.69759703e-01f, 1.28286099e-02f, -2.09510520e-01f, 1.29271969e-01f,
  -3.26754987e-01f, 1.37076318e-01f, 2.02874858e-02f, -1.57662153e-01f, -2.11215422e-01f, -9.96675268e-02f, -3.09911877e-01f, -3.21101278e-01f, -1.51882336e-01f, -8.05206597e-02f,
  -1.80980325e-01f, -3.91180903e-01f, -3.27558935e-01f, -5.16608581e-02f, -2.53688961e-01f, 1.90490171e-01f, -1.83436096e-01f, -5.83768226e-02f, -1.20627940e-01f, -9.75150913e-02f,
  -4.97693047e-02f, -2.87735909e-02f, 1.09793752e-01f, 1.57619268e-01f, -1.75143760e-02f, 2.18319282e-01f, 3.20117176e-02f, 6.73390403e-02f, -2.21003339e-01f, 5.51791452e-02f,
  6.42838180e-02f, 5.97413220e-02f, 5.20778522e-02f, 1.16731949e-01f, -1.14453156e-02f, 1.18832864e-01f, -1.25942811e-01f, 1.06932610e-01f, 1.39963195e-01f, 1.01219311e-01f,
  -1.32223263e-01f, -3.03548183e-02f, -1.85475335e-01f, -2.91228712e-01f, -1.12061858e-01f, -1.23840600e-01f, 1.41399816e-01f, 2.83513442e-02f, 8.46375339e-03f, 4.38548364e-02f,
  1.52656157e-02f, 1.10994332e-01f, -2.25953683e-02f, -3.01752761e-02f, 9.72696394e-03f, 1.71502922e-02f, 3.14727202e-02f, -3.23925652e-02f, -7.96466842e-02f, 2.66070813e-02f,
  -7.12716579e-02f, 3.01532745e-02f, 6.42981231e-02f, -7.77729079e-02f, 4.13450301e-02f, 2.17997059e-01f, 1.17471576e-01f, -2.05942336e-02f, -1.91998422e-01f, 1.25714745e-02f,
  -1.78601027e-01f, -3.83861288e-02f, -4.30586003e-02f, -7.29780197e-02f, -8.73176977e-02f, -7.38010854e-02f, -3.94360013e-02f, 2.22273856e-01f, -2.22367942e-01f, -1.11651398e-01f,
  -6.68070838e-02f, -1.53234586e-01f, -1.58398598e-01f, 7.91487843e-02f, 5.47244586e-02f, 4.08576652e-02f, 6.43819869e-02f, -9.11896601e-02f, -1.66802078e-01f, -1.01201482e-01f,
  9.46137011e-02f, 2.14169230e-02f, -1.39838141e-06f, -1.25345187e-02f, 5.27457222e-02f, -4.66472991e-02f, -1.52651280e-01f, -1.10603958e-01f, -4.73320298e-02f, 2.61125881e-02f,
  8.66470411e-02f, -5.47890998e-02f, 4.63027856e-04f, -3.01778287e-01f, -8.62291306e-02f, 4.37813178e-02f, 8.42624716e-03f, 1.29578654e-02f, -1.99273005e-01f, -1.25393823e-01f,
  -7.84027398e-01f, 6.13802485e-02f, -4.85618919e-01f, -2.13118106e-01f, 3.99302766e-02f, -2.47688100e-01f, 1.80033688e-02f, -1.03928270e-02f, -2.05399469e-01f, 5.02506137e-01f,
  2.28255346e-01f, -4.22338903e-01f, 3.55687439e-01f, -2.09345207e-01f, -6.91094398e-01f, -1.41677007e-01f, -2.03339085e-01f, -2.48479750e-02f, -1.47422120e-01f, 3.56816724e-02f,
  -3.09527814e-01f, 1.52686998e-01f, -3.59725565e-01f, 3.30387145e-01f, -1.31693736e-01f, 1.89463943e-02f, 4.23240066e-01f, 2.12213069e-01f, 1.50796762e-02f, -2.80329049e-01f,
  -1.57150403e-01f, 1.06908791e-01f, -6.75425082e-02f, -4.34538797e-02f, 2.47901157e-02f, 1.48033291e-01f, 5.43375909e-02f, -4.58386121e-03f, -1.77375972e-02f, -7.66233206e-02f,
  4.39676978e-02f, -1.02808448e-02f, -7.51997530e-02f, -3.48621011e-02f, -8.66751671e-02f, -6.19487651e-02f, -1.15073957e-01f, -9.79949236e-02f, 5.71722537e-02f, -2.40826115e-01f,
  -1.60677195e-01f, -1.41133890e-01f, 5.62472828e-02f, -1.47663439e-02f, -1.02661125e-01f, 9.96399075e-02f, 2.88027246e-02f, -1.87087655e-02f, -3.90282683e-02f, -1.70063451e-01f,
  -1.04021452e-01f, -9.63786035e-04f, 1.30427465e-01f, 8.38693455e-02f, -4.03294042e-02f, 1.60218198e-02f, 5.80705032e-02f, 3.05851344e-02f, 1.55291415e-03f, -9.78171942e-04f,
  1.22799881e-01f, -9.91772041e-02f, 2.84974054e-02f, 1.12224249e-02f, 3.11667621e-02f, 1.69848874e-02f, 6.72010407e-02f, -2.29432844e-02f, -5.04942797e-02f, -4.17344719e-02f,
  1.07896879e-01f, -7.57517144e-02f, 3.80312912e-02f, 7.41989538e-02f, -8.04143548e-02f, -6.35500178e-02f, 1.14488274e-01f, -2.74165198e-02f, 1.37341812e-01f, 1.89524330e-02f,
  1.86566822e-02f, 1.19819805e-01f, 1.37165010e-01f, 6.20892495e-02f, 5.61823696e-02f, 8.75843875e-03f, -2.96636950e-02f, -1.01950191e-01f, -4.60103340e-02f, 2.46609957e-03f,
  6.47570863e-02f, 1.01982497e-01f, 9.24730077e-02f, -8.10897872e-02f, -4.54151183e-02f, -4.12196293e-02f, 1.27581820e-01f, 9.07565951e-02f, 1.11669227e-01f, -5.50126955e-02f,
  8.99291560e-02f, 1.27559483e-01f, 1.04989655e-01f, -1.08134747e-03f, 1.29857063e-01f, 3.98281217e-02f, -3.46652605e-02f, 3.11468402e-03f, 4.68253009e-02f, -4.28976379e-02f,
  -6.77091539e-01f, 3.39540720e-01f, -4.86853644e-02f, -2.88783163e-01f, 3.49120855e-01f, -3.17135841e-01f, 6.70588464e-02f, 4.28747326e-01f, 1.72448643e-02f, 3.65684986e-01f,
  1.90662637e-01f, -4.95075494e-01f, 2.34767258e-01f, -2.34280765e-01f, -5.46033859e-01f, -3.75077963e-01f, -3.94908726e-01f, -3.25361252e-01f, -2.75429189e-01f, -5.41019104e-02f,
  -2.34208092e-01f, 8.51647854e-02f, 9.60377082e-02f, 3.12973708e-01f, 2.06325233e-01f, 9.55382288e-02f, 3.92142773e-01f, 3.16017717e-01f, -2.02396005e-01f, -7.07532689e-02f,
  1.59087569e-01f, 2.02385426e-01f, 2.51859635e-01f, 1.12983517e-01f, 4.24768701e-02f, 8.22615926e-04f, 7.87679777e-02f, 1.09242566e-01f, -9.82547030e-02f, -3.64045687e-02f,
  -9.59470719e-02f, 1.01348706e-01f, -1.75330535e-01f, -9.03397128e-02f, 1.02297559e-01f, 1.08817004e-01f, -9.07597318e-02f, -5.44194765e-02f, 6.87332153e-02f, -9.61188599e-02f,
  4.67087887e-02f, -1.29708916e-01f, -1.82910949e-01f, -6.59837723e-02f, -5.88832609e-02f, -7.04164505e-02f, -1.46235660e-01f, -5.43945581e-02f, -1.03574879e-01f, -1.44806951e-01f,
  7.46062994e-02f, -1.09021753e-01f, -2.93094348e-02f, 1.11494459e-01f, -8.23704526e-02f, 1.22382596e-01f, -1.19797088e-01f, -9.54485536e-02f, -2.28608757e-01f, -1.12161979e-01f,
  -7.13506481e-03f, -6.74555451e-02f, 1.77113473e-01f, -1.65287815e-02f, -2.50254512e-01f, -4.89953905e-03f, -1.20740369e-01f, -1.68317799e-02f, -5.31256981e-02f, 7.55037069e-02f,
  1.27450466e-01f, -8.60126540e-02f, 1.04042329e-01f, 1.39020398e-01f, 1.00134633e-01f, -7.63342306e-02f, -1.01186804e-01f, -5.17199077e-02f, -1.10502429e-01f, -1.12439878e-01f,
  1.23213693e-01f, 1.55800894e-01f, 1.36804730e-01f, 1.17931709e-01f, 5.30899987e-02f, -9.66022313e-02f, -4.84250113e-02f, -1.18676603e-01f, -6.73557371e-02f, 5.57183810e-02f,
  -4.54618633e-02f, 9.82880034e-03f, -4.68811430e-02f, -3.43844324e-04f, -5.53976335e-02f, 1.60037056e-01f, 6.63803220e-02f, -3.11584398e-02f, 1.73010647e-01f, 8.00797641e-02f,
  1.31347999e-01f, -6.68049902e-02f, -2.23933041e-01f, -4.20585759e-02f, 1.58869475e-02f, 7.89075345e-02f, -7.66099691e-02f, 1.11030392e-01f, -7.16714114e-02f, 6.23127557e-02f,
  1.88345730e-01f, -5.29324055e-01f, -6.45076513e-01f, -2.21427754e-02f, 1.45128429e-01f, 1.88795656e-01f, -3.21912467e-01f, -1.45757407e-01f, -2.47421771e-01f, 5.28435409e-02f,
  1.63930535e-01f, 1.49978980e-01f, -3.05557847e-01f, 4.68226969e-01f, 3.29722792e-01f, -1.64727792e-01f, 2.00324431e-01f, 4.12419736e-01f, 4.44657803e-02f, -3.12472880e-01f,
  8.79070684e-02f, 3.28927934e-01f, -8.04350153e-02f, 6.74747378e-02f, 1.69512168e-01f, -1.04050532e-01f, 1.98958144e-01f, -2.37318590e-01f, 3.07848334e-01f, 4.30357635e-01f,
  2.28423059e-01f, -3.39683324e-01f, -1.05398051e-01f, 1.17999362e-02f, -7.93964341e-02f, 8.69960114e-02f, 1.34753868e-01f, 1.48917362e-01f, -3.90968174e-02f, -2.18036938e-02f,
  1.02634385e-01f, 5.01797982e-02f, 1.34080857e-01f, 4.88107987e-02f, -5.24716973e-02f, -1.66810602e-02f, -6.40226854e-03f, 4.66553345e-02f, -5.95075823e-02f, -1.72076508e-01f,
  -2.81517565e-01f, -4.26534787e-02f, 1.19503602e-01f, 1.18814241e-02f, -1.37595028e-01f, -1.64929386e-02f, 5.10116965e-02f, -9.80874375e-02f, 8.77163187e-02f, -7.83284605e-02f,
  -5.04432656e-02f, 8.98556504e-03f, -1.05125606e-01f, 5.83913587e-02f, -1.31326094e-01f, 7.54450634e-02f, 9.22566876e-02f, 6.95011318e-02f, 3.54059041e-02f, -1.09284341e-01f,
  -1.04981005e-01f, -2.79814694e-02f, 3.54660004e-02f, -1.48533154e-02f, 7.60163963e-02f, 1.82552468e-02f, 1.65565331e-02f, 1.91395972e-02f, -1.36151806e-01f, 1.15671739e-01f,
  2.65031606e-02f, 3.53103168e-02f, -1.01633690e-01f, 1.32307604e-01f, -1.10176569e-02f, -1.20955847e-01f, 9.81279761e-02f, -1.04375519e-01f, 5.81110548e-03f, 1.47388697e-01f,
  -6.05790652e-02f, -4.87418920e-01f, -2.13478163e-01f, 2.53698714e-02f, 5.35771102e-02f, -6.42699972e-02f, 5.88602796e-02f, 6.26634583e-02f, -2.33200821e-03f, -1.71009675e-01f,
  5.94945252e-02f, 4.78087515e-02f, 1.32089898e-01f, 1.13549814e-01f, 1.35785416e-01f, -1.71526551e-01f, -1.19054779e-01f, 8.07666332e-02f, 1.14897173e-03f, -7.73386238e-03f,
  -1.04518473e-01f, -1.04130737e-01f, 9.56524163e-02f, -6.15680180e-02f, 1.13115989e-01f, 3.51758525e-02f, 1.01260459e-02f, 3.09329610e-02f, 4.56148200e-02f, -5.23153506e-02f,
  -4.08114165e-01f, -9.16604605e-03f, 2.54206151e-01f, 5.36360860e-01f, 6.15003258e-02f, -4.49595809e-01f, -3.31283718e-01f, 4.89281230e-02f, 1.53724656e-01f, -5.19834161e-01f,
  -2.66158581e-01f, -1.45715266e-01f, -5.32906055e-01f, 3.01323831e-01f, 4.06843841e-01f, -1.07011847e-01f, 3.79137158e-01f, -3.05859242e-02f, 4.13992763e-01f, -1.27986753e-02f,
  3.48991632e-01f, 2.67453045e-01f, 3.59098017e-01f, 3.23725194e-01f, 1.48727283e-01f, 3.13894063e-01f, 4.32332814e-01f, 2.81457096e-01f, 4.46785420e-01f, 3.03698272e-01f,
  -1.06611192e-01f, 1.49738295e-02f, 4.33175154e-02f, 1.16299987e-01f, -2.12797850e-01f, -1.70073703e-01f, 2.85358950e-02f, -3.06924246e-02f, 1.14707172e-01f, 9.99296457e-02f,
  -2.56998360e-01f, 5.83138838e-02f, 2.03066856e-01f, 1.43947765e-01f, 4.62966561e-02f, 1.49403602e-01f, 7.94524252e-02f, -6.42162785e-02f, -2.12789401e-02f, -7.90738985e-02f,
  -7.79336505e-03f, -1.27315089e-01f, -5.66886663e-02f, 9.45555121e-02f, 1.58355206e-01f, 2.32252851e-01f, 1.74121097e-01f, 7.27178082e-02f, 8.05077553e-02f, 1.65413082e-01f,
  -1.99321389e-01f, 8.00610855e-02f, 7.30664507e-02f, 1.21064208e-01f, 1.12129577e-01f, 7.06967935e-02f, 6.77427873e-02f, 4.39924281e-03f, 7.90311843e-02f, -1.21699296e-01f,
  9.08564329e-02f, 2.39469111e-02f, 5.90955559e-03f, -1.01285107e-01f, -1.54181300e-02f, -5.01215830e-02f, -9.29773748e-02f, 1.55554503e-01f, -3.81351858e-02f, -3.11197545e-02f,
  1.60326939e-02f, 9.78396684e-02f, -4.57727723e-02f, -6.30520936e-03f, -9.45933610e-02f, -3.15486826e-02f, 7.36075640e-02f, -3.48845348e-02f, 1.45996669e-02f, 1.63865648e-02f,
  -2.58245748e-02f, 4.55841720e-01f, -1.33333821e-02f, -2.71514021e-02f, 1.03707194e-01f, -3.07318661e-03f, 1.20838225e-01f, 4.50003287e-03f, 1.81752846e-01f, -3.60443629e-02f,
  -1.71469480e-01f, 8.88291374e-02f, -9.83977839e-02f, 2.98851468e-02f, 1.75944380e-02f, -7.99026564e-02f, 7.12359846e-02f, 7.14165419e-02f, 2.00232089e-01f, 4.81314398e-02f,
  -4.50407453e-02f, -1.49113297e-01f, 4.98157181e-02f, 9.42283794e-02f, -1.11088471e-03f, -1.27188355e-01f, -7.83577040e-02f, -5.92315309e-02f, 1.56648487e-01f, 7.32287318e-02f,
  3.83281857e-01f, -8.65064561e-02f, -9.78154764e-02f, 1.14595003e-01f, 1.25397965e-01f, -1.58461556e-01f, -3.99836481e-01f, 1.97369218e-01f, -4.97457564e-01f, -4.27393407e-01f,
  3.01892430e-01f, -3.03083777e-01f, -2.85315424e-01f, 4.64277327e-01f, 5.79257667e-01f, 5.56265190e-02f, 4.33247775e-01f, 9.26772952e-02f, 5.69519922e-02f, 4.19695526e-01f,
  2.79041469e-01f, 4.60516274e-01f, 4.56075370e-01f, 3.42925012e-01f, 3.68296593e-01f, 7.60861635e-02f, 2.92831630e-01f, -2.03493852e-02f, 2.08021730e-01f, 1.80087432e-01f,
  1.12506695e-01f, 1.78808108e-01f, -9.20901727e-03f, -1.40231222e-01f, 1.84908584e-01f, 5.25922664e-02f, -1.57420838e-03f, 8.48340988e-02f, 7.97477737e-03f, -9.97009594e-03f,
  -9.06625018e-02f, 2.71705184e-02f, 2.62378789e-02f, -5.25956526e-02f, -8.34703371e-02f, -2.87351795e-02f, -1.01328962e-01f, -1.09209649e-01f, -2.04416245e-01f, -4.05795127e-02f,
  -4.14586291e-02f, 1.53233542e-03f, 7.32558593e-02f, 1.42806824e-02f, -5.03911451e-02f, -8.31160322e-02f, -2.19328344e-01f, -1.56616539e-01f, -1.18838519e-01f, 1.29218046e-02f,
  4.48547676e-02f, 5.24337254e-02f, -8.48982632e-02f, -3.67970690e-02f, -4.60797586e-02f, -8.58784989e-02f, 9.69053358e-02f, -7.86670148e-02f, -1.63674057e-01f, -6.22386523e-02f,
  -3.55293490e-02f, 1.39973357e-01f, -5.60470112e-02f, -1.06313571e-01f, 1.09737538e-01f, 5.32599315e-02f, 7.62825236e-02f, -2.90683024e-02f, -2.15245605e-01f, -2.06850767e-02f,
  -2.00141352e-02f, -2.28563230e-02f, -9.90157202e-02f, -3.86269093e-02f, 6.57780543e-02f, -1.41538516e-01f, -1.13724321e-01f, -5.29334322e-02f, 4.25285399e-02f, -1.42335612e-03f,
  -1.37385027e-02f, 2.91197449e-01f, -1.45443827e-01f, -8.03778842e-02f, -7.86932334e-02f, 9.66265053e-02f, 6.86914399e-02f, 6.58812672e-02f, -3.13127749e-02f, 1.15307130e-01f,
  4.70623709e-02f, -8.56375992e-02f, 7.04084011e-03f, 6.50723949e-02f, 1.64861679e-01f, -1.43537275e-03f, 8.61849636e-02f, -1.87709913e-01f, 7.03521222e-02f, 1.18670426e-01f,
  1.35872573e-01f, 5.23279887e-03f, -6.50916025e-02f, -1.06628366e-01f, -3.92673314e-02f, -4.41152081e-02f, 8.02934989e-02f, -1.18005365e-01f, 2.18452483e-01f, -4.79380600e-02f,
  6.57043517e-01f, -7.37011969e-01f, -2.80204535e-01f, 1.80403143e-01f, 5.22207737e-01f, 3.63289982e-01f, 4.27141219e-01f, -1.72005109e-02f, -3.22671905e-02f, -4.49182093e-01f,
  2.61834711e-01f, -8.91399756e-02f, -2.86245972e-01f, 1.08468749e-01f, 6.91732407e-01f, -3.72255683e-01f, 1.55017182e-01f, 9.13855359e-02f, -4.97599319e-02f, 3.43360268e-02f,
  2.90221810e-01f, 3.67502570e-01f, -8.61752108e-02f, -2.06271976e-01f, 1.47785604e-01f, -2.56211162e-01f, -6.66386336e-02f, -2.26240605e-02f, 2.93198097e-02f, 1.56526059e-01f,
  6.25619814e-02f, -1.38316974e-01f, 7.49032423e-02f, -1.73870146e-01f, -5.06960601e-03f, 1.22075519e-02f, -7.21796677e-02f, 6.16060160e-02f, 1.32522538e-01f, 5.32905236e-02f,
  -7.18425587e-02f, 6.24025874e-02f, 4.12563421e-02f, 6.20151386e-02f, 1.36436194e-01f, 1.16018698e-01f, 3.38457040e-02f, -4.66345856e-03f, 4.39131036e-02f, -5.27807027e-02f,
  -9.31456313e-02f, -4.64822128e-02f, -5.11450544e-02f, -2.20719829e-01f, 1.91992338e-04f, 1.01108029e-01f, -1.55076325e-01f, 8.35121349e-02f, -1.62634596e-01f, -5.55326529e-02f,
  -1.34840831e-01f, -3.32230181e-02f, 9.74797830e-03f, -2.30582654e-02f, 1.81292947e-02f, 3.46866101e-02f, 1.63163513e-01f, 3.32978740e-02f, 1.11452393e-01f, -2.76843850e-02f,
  1.34771168e-01f, 1.44597307e-01f, 8.38098079e-02f, 6.01334125e-02f, -2.03741193e-02f, -2.63541117e-02f, 4.04715352e-02f, 4.47697267e-02f, 6.02106899e-02f, 7.30878711e-02f,
  4.82681096e-02f, 1.42246392e-02f, 2.13861912e-02f, -3.12693454e-02f, -6.80366233e-02f, -1.36313755e-02f, -1.61803365e-01f, -1.46273477e-02f, -1.87076539e-01f, 5.01839779e-02f,
  -1.53701231e-01f, -4.92880434e-01f, -8.00660700e-02f, 4.82138284e-02f, -7.06311911e-02f, 6.57984018e-02f, -9.89268646e-02f, -4.72985469e-02f, -1.48697615e-01f, 1.91319399e-02f,
  -1.11826442e-01f, 1.50990756e-02f, 3.62845697e-02f, 6.81936145e-02f, -5.35753369e-02f, -1.07599936e-01f, -7.29064345e-02f, -1.13870567e-02f, 9.39919949e-02f, -2.93415729e-02f,
  -9.73217115e-02f, -5.27671017e-02f, -3.18019129e-02f, -4.34293002e-02f, -9.73778889e-02f, 2.54433155e-02f, -2.35185325e-02f, 3.98767255e-02f, -1.91769307e-03f, -1.29792904e-02f,
  5.98866105e-01f, -3.96622382e-02f, 3.54005307e-01f, 4.04382914e-01f, 2.57716626e-01f, 8.46063271e-02f, -1.41935453e-01f, 2.55461037e-01f, 3.49512339e-01f, -2.21187204e-01f,
  -1.59779757e-01f, 1.43676311e-01f, -5.68598032e-01f, 2.23136097e-01f, -3.41369331e-01f, -4.72244084e-01f, -7.84293003e-03f, -1.50681496e-01f, -7.28533119e-02f, 1.18464185e-02f,
  -1.03759207e-02f, -4.57207143e-01f, -1.33867115e-01f, -3.17229420e-01f, 3.06030512e-01f, 2.77397126e-01f, -2.85986066e-01f, -2.96270788e-01f, 1.90901428e-01f, -1.27988473e-01f,
  2.46661887e-01f, 1.70811683e-01f, 2.34456196e-01f, 1.32868052e-01f, 9.21099633e-02f, 3.30570117e-02f, -5.82237355e-03f, -1.94155678e-01f, 1.25873432e-01f, 2.20826901e-02f,
  6.34423643e-03f, -4.29067388e-02f, 1.28196418e-01f, -1.70295775e-01f, 1.41211480e-01f, 5.64867109e-02f, 1.79151461e-01f, 2.42346212e-01f, 8.59369710e-02f, -4.18089330e-03f,
  1.07176825e-01f, 2.02265456e-01f, 2.24790126e-01f, -1.61090538e-01f, 7.04159662e-02f, 3.27467248e-02f, -5.15945219e-02f, 1.25385392e-02f, 1.24243096e-01f, -1.93921234e-02f,
  -1.89393520e-01f, -9.68645960e-02f, -4.30445671e-02f, 1.53621003e-01f, -3.03377304e-02f, 2.77046370e-03f, 5.29650114e-02f, 9.54023842e-03f, 1.15414103e-02f, -1.18589155e-01f,
  6.06296062e-02f, 1.64865348e-02f, 3.43871117e-02f, -2.72189900e-02f, -1.36864662e-01f, 1.01329811e-01f, -5.00188163e-03f, -7.85878003e-02f, 8.04497954e-03f, 1.39894336e-01f,
  -1.90874971e-02f, -6.34673238e-02f, -1.21444702e-01f, 1.80615261e-02f, -3.02677322e-02f, -1.03037551e-01f, 1.54889980e-02f, 8.76441523e-02f, 7.51756728e-02f, -1.92336932e-01f,
  -8.51719752e-02f, -5.95423996e-01f, 3.31643745e-02f, -1.45413326e-02f, -1.50183877e-02f, 7.37772435e-02f, 1.57517537e-01f, 1.28730550e-01f, -1.77879617e-01f, -1.04080707e-01f,
  -6.13679215e-02f, -8.92711058e-02f, -2.71550957e-02f, 2.50073895e-02f, 2.77154264e-03f, -8.82759616e-02f, -1.59169823e-01f, -4.84412834e-02f, 6.90965652e-02f, 5.54728992e-02f,
  -4.13928553e-02f, -2.96885855e-02f, -5.89092262e-02f, 2.12529581e-03f, -2.70494986e-02f, -8.39736536e-02f, -3.62571850e-02f, -5.84011152e-03f, -1.24833159e-01f, 5.10204472e-02f,
  -6.45689890e-02f, -4.04542893e-01f, 3.15541089e-01f, 2.95615345e-01f, -2.05925658e-01f, 5.13975732e-02f, 4.82570380e-01f, -3.98459435e-01f, -5.64680398e-01f, -3.42832267e-01f,
  -9.67901200e-02f, 4.08327937e-01f, -1.24275953e-01f, 2.37188339e-01f, 5.92953324e-01f, -2.29281738e-01f, -3.11774090e-02f, 3.01457942e-01f, -2.37502053e-01f, -1.87817618e-01f,
  -1.50686488e-01f, 7.32694939e-03f, 2.63844252e-01f, -2.26406112e-01f, 1.05975181e-01f, 4.77095246e-02f, 2.26672307e-01f, 1.98954031e-01f, 3.56087059e-01f, 4.51756805e-01f,
  -1.77956223e-01f, -2.20423952e-01f, 1.28390808e-02f, -2.64464896e-02f, -1.39345050e-01f, 1.08926006e-01f, 2.11071253e-01f, 2.42843911e-01f, 1.69996724e-01f, -3.00012268e-02f,
  -3.39327715e-02f, -2.85060406e-02f, 4.45948094e-02f, 1.17488563e-01f, -9.06299800e-02f, -5.43619804e-02f, -8.67329910e-02f, -8.45789760e-02f, 5.79360612e-02f, -3.67256217e-02f,
  -1.46196499e-01f, -8.67625922e-02f, -1.05268946e-02f, 1.36454567e-01f, 5.23443110e-02f, -3.68881449e-02f, 1.78923294e-01f, 9.53144729e-02f, -2.10446045e-02f, -4.54235636e-02f,
  -6.96569532e-02f, -5.11158779e-02f, -1.01215616e-01f, 4.08534482e-02f, -5.72071932e-02f, 3.35671827e-02f, -6.24942482e-02f, 5.64824864e-02f, 1.12622328e-01f, -2.21847281e-01f,
  -4.30132449e-02f, -5.69317490e-02f, -2.29975674e-02f, -3.99602540e-02f, -1.09524257e-01f, -1.14484563e-01f, 1.76090494e-01f, 5.10686189e-02f, -6.84119463e-02f, -2.67967600e-02f,
  -6.57309070e-02f, 5.15074693e-02f, 5.08147627e-02f, 2.71330588e-02f, -4.05411758e-02f, -3.39578115e-03f, 4.32002246e-02f, -3.01250331e-02f, -1.54278884e-02f, 1.32702529e-01f,
  -1.59502193e-01f, -8.26842114e-02f, -2.99031660e-02f, -6.41277879e-02f, 7.05484003e-02f, -9.27663222e-02f, 3.89893204e-02f, -4.81508113e-02f, -7.43443742e-02f, -2.48216763e-02f,
  -1.29473612e-01f, 8.89894366e-02f, -5.63693494e-02f, 1.62071958e-01f, 1.07017450e-01f, -6.89222291e-02f, 1.44970804e-01f, 3.43646072e-02f, -3.81966075e-03f, -3.25070182e-03f,
  2.10767929e-02f, -2.53969543e-02f, 1.17654562e-01f, -9.14627016e-02f, -8.43180418e-02f, 2.54637562e-02f, 6.74018487e-02f, 2.88129821e-02f, 8.10752288e-02f, 1.21705502e-01f,
  1.65946245e-01f, -3.02375227e-01f, -5.21061301e-01f, -1.57361522e-01f, -3.20849627e-01f, -1.90527081e-01f, 3.13999236e-01f, -1.69963509e-01f, -8.10661614e-02f, 1.99736148e-01f,
  1.54627502e-01f, 2.33918443e-04f, 3.08656514e-01f, 2.16128081e-01f, 1.81698188e-01f, 6.17823541e-01f, 8.40399936e-02f, 3.18738580e-01f, -1.59275636e-01f, -6.27609566e-02f,
  -1.63636193e-01f, 2.90640630e-02f, 5.06494753e-02f, -5.00389457e-01f, -1.54771253e-01f, -3.79504830e-01f, 5.09913675e-02f, -2.81341374e-01f, -5.94176278e-02f, 7.42522478e-02f,
  -8.77111033e-02f, -5.17888702e-02f, -4.95716520e-02f, -3.37781720e-02f, -6.62090257e-02f, -7.45852813e-02f, -6.60595251e-03f, -2.40633078e-02f, 1.61976628e-02f, -1.98829789e-02f,
  9.10271555e-02f, 1.26610054e-02f, -9.33603197e-02f, -1.28550893e-02f, 2.40020771e-02f, -2.67957866e-01f, -1.78062871e-01f, 1.10310197e-01f, -1.24168903e-01f, -8.84686876e-03f,
  -1.02246188e-01f, -3.85045670e-02f, 1.19270049e-02f, 2.22509564e-03f, 6.57203496e-02f, -3.08358576e-02f, -5.88028599e-03f, 7.45067969e-02f, -1.08407915e-01f, -5.69512658e-02f,
  2.85122469e-02f, 1.56860322e-01f, 1.08972199e-01f, 3.10652908e-02f, -6.04457073e-02f, -5.50848991e-02f, 5.21409549e-02f, -1.10057862e-02f, -9.58318915e-03f, -4.70702245e-04f,
  -1.85402870e-01f, -6.22525774e-02f, -4.61295582e-02f, 5.86164370e-02f, 3.07930764e-02f, 1.46739800e-02f, -1.86398122e-02f, 2.51515638e-02f, 2.50239689e-02f, -7.71945268e-02f,
  4.90529425e-02f, -4.80753649e-03f, -1.16969597e-04f, 7.65074864e-02f, 3.93920206e-02f, 1.98283926e-01f, 1.33429002e-02f, 1.93422544e-03f, -9.85447201e-04f, -1.15370855e-01f,
  -1.67300664e-02f, -1.90306053e-01f, -2.07548942e-02f, -3.39130498e-02f, 4.72942442e-02f, 1.75343477e-03f, 4.18298207e-02f, -2.15139702e-01f, -9.61173922e-02f, -1.72408164e-01f,
  -1.95416268e-02f, 5.11096587e-05f, -2.99125556e-02f, 1.40401050e-02f, 4.53443732e-03f, -8.49090815e-02f, 2.09452853e-01f, 3.17450948e-02f, 1.33973449e-01f, -2.72391234e-02f,
  1.92391705e-02f, -4.09765430e-02f, 3.48159634e-02f, 6.12389594e-02f, 1.04530931e-01f, 6.76049143e-02f, -1.53090656e-01f, 3.35312597e-02f, -4.40161824e-02f, -1.10648490e-01f,
  4.38515007e-01f, -5.79836182e-02f, 2.00140342e-01f, 5.29088140e-01f, -3.17429781e-01f, -3.54262292e-02f, 2.27185428e-01f, 1.95895601e-02f, 5.28926909e-01f, -2.67929472e-02f,
  -1.92970797e-01f, 2.70007312e-01f, -2.30490088e-01f, -7.84657896e-03f, -3.60457867e-01f, -8.12221542e-02f, 2.31792465e-01f, 3.57055604e-01f, 7.90774971e-02f, 7.93173909e-02f,
  4.75075543e-02f, -4.03465509e-01f, -1.11852236e-01f, -3.60486925e-01f, 1.94573204e-03f, 1.01982392e-01f, -4.77483690e-01f, -2.85142243e-01f, -2.57312238e-01f, -2.32105091e-01f,
  -1.70052335e-01f, 1.00198857e-01f, 2.99650338e-02f, -4.18291353e-02f, -4.62078042e-02f, 9.50380415e-02f, 3.51554900e-02f, -9.32851657e-02f, -5.36365211e-02f, 1.19999386e-01f,
  1.32471308e-01f, 5.19358292e-02f, -2.85827387e-02f, 7.40126288e-03f, 1.85687825e-01f, 3.27961370e-02f, 1.63494349e-02f, 1.31986946e-01f, 3.87250856e-02f, 4.10171831e-03f,
  8.28611627e-02f, 2.43751165e-02f, -1.00800050e-02f, 1.38387918e-01f, 2.07967055e-03f, 3.26124183e-03f, 1.72092661e-01f, -4.56384234e-02f, -4.20865528e-02f, -4.24482580e-03f,
  1.30159212e-02f, -1.25274703e-01f, -5.11204340e-02f, -5.63502824e-03f, -7.30443746e-02f, -9.73308608e-02f, 2.56165937e-02f, -4.82589342e-02f, 8.39914680e-02f, -2.03523561e-02f,
  6.00481499e-03f, 3.36493040e-03f, 4.83738333e-02f, 8.90227109e-02f, 1.05024822e-01f, 2.87552774e-01f, -6.43226504e-02f, -1.56398620e-02f, 1.78101331e-01f, -3.17475200e-02f,
  -1.02005824e-01f, -1.21593185e-01f, -4.17165495e-02f, -2.14863140e-02f, -6.42744526e-02f, -2.64130929e-03f, 2.48598065e-02f, 6.26504198e-02f, 3.39833535e-02f, -1.26137808e-01f,
  -5.12336671e-01f, -2.86081880e-01f, -1.12401441e-01f, 1.99773852e-02f, -2.32436769e-02f, -7.01354668e-02f, 6.49903119e-02f, 7.09457835e-03f, -2.22399637e-01f, 1.54874533e-01f,
  -3.77062485e-02f, 6.18110038e-02f, 4.95866733e-03f, -5.76721914e-02f, 4.63048578e-04f, -4.35347408e-02f, -7.91681260e-02f, 2.23185606e-02f, -2.43593916e-01f, -1.31834999e-01f,
  -5.26605882e-02f, 1.36340614e-02f, -4.01970372e-02f, 2.54732948e-02f, -2.27519497e-02f, -1.43512994e-01f, -7.56363897e-03f, -6.87322244e-02f, -9.26237777e-02f, -3.57567854e-02f,
  3.88250947e-02f, -5.75206697e-01f, -5.42006316e-03f, 1.53016269e-01f, 4.49395150e-01f, 1.90430820e-01f, 1.91533685e-01f, -4.26622331e-02f, 2.19879821e-01f, -3.03541690e-01f,
  -2.17666373e-01f, -4.72594559e-01f, -3.96868020e-01f, -6.48945197e-02f, 7.13115111e-02f, -3.48434865e-01f, 9.57617760e-02f, -1.89451054e-01f, -1.73905089e-01f, -2.55321562e-01f,
  -6.12544492e-02f, -3.03639565e-02f, -1.10682078e-01f, 9.03517101e-03f, 3.93377207e-02f, 2.39208817e-01f, 2.46729791e-01f, 7.71823302e-02f, 1.12653166e-01f, 2.31416062e-01f,
  1.88206919e-02f, -1.75099954e-01f, 5.75095555e-03f, -5.66709153e-02f, 1.17236041e-01f, 1.36238590e-01f, 2.48498246e-01f, 2.42322013e-02f, 9.21969190e-02f, -1.18734390e-01f,
  -5.82808554e-02f, -1.58273041e-01f, -9.62534994e-02f, -1.28222713e-02f, 1.31677583e-01f, -8.19030628e-02f, 3.29870470e-02f, -2.84153670e-02f, -8.41394216e-02f, -6.02695532e-02f,
  -2.42566273e-01f, -7.44441822e-02f, 5.44604193e-03f, 6.70259297e-02f, -8.67483541e-02f, 5.50921261e-03f, -2.67861206e-02f, -3.32285278e-02f, 1.17756881e-01f, 1.41673878e-01f,
  7.38717243e-02f, 7.40617886e-02f, -2.80167848e-01f, -1.02327734e-01f, -4.54413183e-02f, 1.75979912e-01f, 5.08478582e-02f, -4.24388498e-02f, 1.25999674e-01f, 6.60564825e-02f,
  2.88319528e-01f, -1.93509087e-02f, -3.43481302e-02f, 6.24219850e-02f, 1.18058413e-01f, 1.18383780e-01f, -2.30734088e-02f, 8.17215219e-02f, -7.13117644e-02f, -1.54127125e-02f,
  5.00754751e-02f, 2.15247005e-01f, -8.19503888e-02f, 8.88239741e-02f, 3.15923616e-02f, -1.28619581e-01f, 9.78490934e-02f, -5.47649674e-02f, -9.45110470e-02f, -4.84595336e-02f,
  3.04766167e-02f, -2.42982879e-02f, -1.00719795e-01f, -1.11468233e-01f, -8.42779130e-02f, -7.60292709e-02f, 1.62400156e-02f, -6.87454864e-02f, -3.66369821e-02f, -8.98466706e-02f,
  3.44773680e-02f, -1.11296557e-01f, 1.43964410e-01f, 3.17039713e-02f, 1.02403171e-01f, -2.54394084e-01f, 8.38220399e-03f, 5.41394390e-02f, 2.59746403e-01f, 4.65752184e-02f,
  6.47479761e-03f, 3.47422920e-02f, -1.44143909e-01f, 3.52337174e-02f, 2.62360722e-02f, 6.84507936e-02f, -6.76194951e-02f, -1.21923849e-01f, -3.60286012e-02f, -6.23606844e-03f,
  -8.18187654e-01f, 3.08638334e-01f, -1.85623243e-01f, -4.72910106e-01f, -1.46950915e-01f, 6.11606203e-02f, -1.15388602e-01f, 1.11570336e-01f, 1.48548529e-01f, 2.32822701e-01f,
  -1.39268517e-01f, -9.52508673e-02f, 3.56484145e-01f, -1.52324110e-01f, -1.18565083e-01f, 3.40817004e-01f, -1.19405448e-01f, -7.92666674e-02f, 2.65517145e-01f, -1.81028545e-01f,
  -8.01096782e-02f, -2.00530127e-01f, -1.07912898e-01f, 1.02326304e-01f, -4.63480473e-01f, -2.54429013e-01f, -2.22328141e-01f, 5.54930978e-02f, -4.23325539e-01f, -1.44418284e-01f,
  -4.86760765e-01f, -3.50488245e-01f, -3.85490924e-01f, -2.09142417e-01f, -1.12617590e-01f, -7.54108606e-03f, -1.02195837e-01f, -1.09264188e-01f, 2.04002056e-02f, 7.08341897e-02f,
  2.99815070e-02f, -4.96652909e-02f, -5.69632463e-02f, 1.21057391e-01f, -7.89963380e-02f, -1.65435061e-01f, -9.11006406e-02f, -6.52315393e-02f, -5.95752224e-02f, 6.25119172e-03f,
  -1.02878824e-01f, 1.49863595e-02f, -1.23753235e-01f, -4.99877818e-02f, -1.54182956e-01f, -5.86807653e-02f, -5.64224198e-02f, -9.85382572e-02f, -1.48556471e-01f, -5.12315407e-02f,
  1.47633344e-01f, 8.86254385e-02f, -1.30809292e-01f, 1.02212308e-02f, -3.73803489e-02f, -1.07178748e-01f, -6.70681223e-02f, -3.90935317e-02f, 7.87074789e-02f, -5.37812449e-02f,
  7.66142681e-02f, -1.28939167e-01f, -1.45704344e-01f, -5.50366715e-02f, 1.28390387e-01f, 2.70140097e-02f, -3.39348204e-02f, -7.92707726e-02f, 8.73951614e-02f, -2.82605216e-02f,
  7.02020526e-02f, -3.77431512e-02f, -1.29564390e-01f, 8.62264354e-03f, 3.38978693e-03f, -5.66972643e-02f, 1.27178609e-01f, 5.44639379e-02f, -7.94683620e-02f, 1.82185080e-02f,
  -2.32581362e-01f, -2.54096836e-01f, -8.09455141e-02f, -2.56304622e-01f, 1.08552875e-03f, 2.52449270e-02f, 1.14394255e-01f, -1.25772521e-01f, -3.38777713e-02f, 1.17109090e-01f,
  3.42420749e-02f, -1.29759893e-01f, -8.70871320e-02f, 9.32807252e-02f, 2.02286914e-01f, 3.98013182e-02f, -5.02728261e-02f, 5.97832389e-02f, -4.27819118e-02f, 4.92524095e-02f,
  -6.63527707e-03f, 1.64315149e-01f, 6.96229413e-02f, -7.74224102e-02f, 8.82561505e-03f, -1.54709086e-01f, -3.88446520e-03f, -9.36960503e-02f, -3.01139597e-02f, 1.30079135e-01f,
  -1.10309564e-01f, 4.56531078e-01f, -6.16128705e-02f, 3.83718312e-01f, -2.16874734e-01f, -1.96775332e-01f, -6.67731985e-02f, 1.04810797e-01f, -2.81802237e-01f, 3.61840397e-01f,
  2.80472070e-01f, -1.08541146e-01f, 1.86056867e-01f, 5.33136249e-01f, -1.06741175e-01f, -5.23884594e-02f, 4.14062917e-01f, 2.21844420e-01f, -1.50540084e-01f, 3.51309836e-01f,
  1.85931593e-01f, 3.04864794e-01f, 2.94491261e-01f, 2.55394310e-01f, 2.39106134e-01f, 8.50228891e-02f, 2.80971467e-01f, -2.50872850e-01f, 4.77575481e-01f, -1.81373328e-01f,
  1.79914862e-01f, 1.32428050e-01f, -5.23788407e-02f, -1.76547676e-01f, 1.63235869e-02f, 7.46050104e-02f, 1.01980660e-02f, -9.96310934e-02f, -2.01416850e-01f, 5.57462499e-02f,
  -4.90833744e-02f, -1.00091726e-01f, 8.11546072e-02f, -1.45177364e-01f, -5.33117764e-02f, -6.29961565e-02f, -1.51057253e-02f, -4.34353426e-02f, -8.66539404e-03f, 1.09309204e-01f,
  -7.35411718e-02f, 2.76882723e-02f, 1.35922909e-01f, 7.20295161e-02f, -2.74356008e-02f, -4.03170027e-02f, 2.06822027e-02f, 8.77993777e-02f, 1.72099881e-02f, -5.84421195e-02f,
  3.02683637e-02f, -2.81580798e-02f, 1.01837002e-01f, -1.16189700e-02f, -2.40130965e-02f, 1.51779056e-01f, 1.40638649e-02f, 3.25940549e-02f, -1.51089624e-01f, 1.74303636e-01f,
  -1.99269652e-02f, 2.13488992e-02f, -6.35002106e-02f, 3.00431326e-02f, 4.69949245e-02f, 3.51916328e-02f, -8.37205127e-02f, 8.89605191e-03f, -2.73905657e-02f, 2.97242291e-02f,
  -1.09737612e-01f, -5.58562540e-02f, 2.14573573e-02f, -2.77866255e-02f, -2.59817112e-02f, 4.43935357e-02f, 5.81105463e-02f, 5.26470616e-02f, -5.71094938e-02f, -3.47220339e-02f,
  1.43802881e-01f, 2.91462600e-01f, -9.00128111e-02f, -8.74286890e-02f, 1.71462502e-02f, 8.97981822e-02f, -8.08954984e-02f, 1.01445362e-01f, 1.17437713e-01f, -7.44523033e-02f,
  1.46202728e-01f, -1.16886050e-01f, 1.47619233e-01f, -3.21318395e-03f, 4.03618328e-02f, 1.26288608e-01f, 6.86206669e-02f, -1.89495310e-01f, 1.65221363e-03f, 1.69950411e-01f,
  9.52488706e-02f, -1.99201740e-02f, 1.40720308e-01f, -1.16516843e-01f, 4.02411111e-02f, 4.29487936e-02f, -6.63826391e-02f, -9.21574384e-02f, 8.74384269e-02f, -6.39163926e-02f,
  -6.84305668e-01f, 6.37837827e-01f, 5.17137408e-01f, -5.19393086e-01f, 2.45650366e-01f, 4.99173522e-01f, -3.03145587e-01f, 2.74908036e-01f, -4.10387337e-01f, -3.30901183e-02f,
  -2.79090732e-01f, 1.02877297e-01f, -4.52207439e-02f, -2.28752762e-01f, -3.74855787e-01f, -1.33495569e-01f, -2.02668101e-01f, -2.73263514e-01f, 1.30453045e-02f, 5.12783006e-02f,
  -1.19820587e-01f, -3.18866193e-01f, -2.36048666e-03f, 3.31683129e-01f, 3.12414765e-01f, 1.99696019e-01f, -3.52902055e-01f, 1.95182428e-01f, 1.43724918e-01f, 2.88172849e-02f,
  -1.00822508e-01f, -1.91138536e-01f, -4.13331538e-02f, 3.76226939e-02f, 8.59654993e-02f, -1.48132502e-03f, -1.27834305e-02f, -1.25287905e-01f, -3.91170457e-02f, -4.84775566e-02f,
  -7.12219104e-02f, 5.75516336e-02f, -7.05522299e-02f, -2.26013418e-02f, 8.07849690e-02f, 1.61837533e-01f, 1.58282757e-01f, 6.40030056e-02f, 1.31623670e-01f, 1.55521572e-01f,
  5.06360494e-02f, 1.97723821e-01f, 9.74880680e-02f, 5.51327430e-02f, 1.16516486e-01f, -2.26294510e-02f, 9.56614688e-03f, 6.55177161e-02f, 2.00939059e-01f, 1.96880363e-02f,
  3.92553844e-02f, 9.76823643e-03f, 7.04592690e-02f, -1.88025143e-02f, -1.20320231e-01f, 9.84818488e-02f, -2.77470844e-03f, -6.02566451e-02f, 4.05486040e-02f, 3.86762097e-02f,
  -9.31642428e-02f, 9.65420529e-03f, 4.69409227e-02f, -3.72913815e-02f, -1.63543329e-01f, -1.16704635e-01f, -4.05248674e-03f, 5.03099225e-02f, -9.67902020e-02f, -1.87557042e-02f,
  -1.09389931e-01f, -2.28826459e-02f, 4.57543544e-02f, -1.80398822e-02f, -8.44747871e-02f, -3.43385222e-03f, 6.81868047e-02f, 5.67660406e-02f, -5.56373335e-02f, -7.98651055e-02f,
  -1.60358816e-01f, -2.02469662e-01f, -1.55007213e-01f, 9.12983343e-02f, -7.93991685e-02f, 1.90464612e-02f, -7.38867819e-02f, 3.46299224e-02f, 2.67071854e-02f, -9.90757719e-03f,
  8.28074068e-02f, -8.93276259e-02f, 3.52722071e-02f, -1.40696630e-01f, 8.54437202e-02f, 8.76745384e-04f, -2.02415362e-01f, -2.11919054e-01f, -1.07680850e-01f, 8.73778760e-02f,
  7.14072213e-02f, -5.49829863e-02f, -8.15162659e-02f, 1.08178675e-01f, -8.39597825e-03f, -2.56771930e-02f, -3.74661274e-02f, -7.45687867e-03f, -1.46627426e-02f, -1.85011756e-02f,
  3.03593755e-01f, 3.36472243e-01f, 3.43846530e-01f, 6.01504564e-01f, 4.05518860e-02f, -2.86731243e-01f, 1.61577001e-01f, 2.62584299e-01f, 5.56060374e-01f, -1.06097706e-01f,
  -2.17634216e-01f, 2.23837927e-01f, -2.02859893e-01f, 9.13354382e-02f, -3.66921067e-01f, -2.41557598e-01f, 2.54524231e-01f, 1.16568003e-02f, 4.48127061e-01f, 3.11480254e-01f,
  2.53236443e-01f, -2.28089526e-01f, -1.18223518e-01f, -1.77908421e-01f, 8.99988264e-02f, 3.33719343e-01f, -3.30886275e-01f, 4.00679857e-02f, -1.30771801e-01f, -2.82494128e-01f,
  4.08875011e-03f, 1.73298120e-01f, 1.07289655e-02f, -1.26100376e-01f, 1.54691383e-01f, 4.21953835e-02f, -9.22530442e-02f, -2.07917884e-01f, 1.92219075e-02f, 3.38540822e-02f,
  1.11766934e-01f, -1.27018496e-01f, -7.61553794e-02f, -1.65710121e-01f, 6.85627460e-02f, 3.58737223e-02f, 1.22943148e-01f, 1.56566083e-01f, -4.88035902e-02f, 1.02281392e-01f,
  -3.04330718e-02f, 3.81239653e-02f, 2.03677714e-01f, 1.28751248e-02f, 2.93700434e-02f, 1.86469212e-01f, -5.67668937e-02f, -1.89253658e-01f, -3.00943144e-02f, 1.70135468e-01f,
  9.85960662e-02f, 6.72501922e-02f, -4.68670912e-02f, -4.61332574e-02f, -1.06055932e-02f, 7.37724081e-02f, 2.37526726e-02f, -1.11746959e-01f, 6.33599460e-02f, -8.85030106e-02f,
  -1.43232597e-02f, 1.32355615e-01f, 1.12393759e-02f, 2.95170285e-02f, 2.20440432e-01f, 1.38251811e-01f, -1.37994081e-01f, -5.55356368e-02f, 1.61565229e-01f, -9.48283449e-03f,
  -4.09351178e-02f, -4.68833558e-02f, -8.87612253e-02f, 3.61547694e-02f, -4.93908487e-02f, 7.86268711e-02f, 7.45215863e-02f, 1.23771457e-02f, -4.14561406e-02f, -2.31536641e-03f,
  1.67210057e-01f, 3.76964122e-01f, 3.35241482e-02f, -3.89399454e-02f, -1.12522244e-02f, -1.19648568e-01f, 1.91425458e-02f, 6.25213757e-02f, 1.47366703e-01f, -1.54728204e-01f,
  7.35690221e-02f, 5.43026254e-03f, -1.55505687e-02f, -1.40311211e-01f, -2.18252037e-02f, -5.67263328e-02f, 1.24038860e-01f, 1.44061267e-01f, 1.85380653e-01f, -5.33193303e-03f,
  -2.31495500e-02f, 1.62128001e-01f, 1.42297104e-01f, 7.78413266e-02f, 2.16703303e-02f, 5.81010357e-02f, 2.37213187e-02f, 4.19949628e-02f, -6.78754672e-02f, -1.01755284e-01f,
  -2.25864381e-01f, 2.84938902e-01f, -2.16161102e-01f, -1.83453694e-01f, -1.20609015e-01f, 6.99014843e-01f, 2.81328678e-01f, -1.95145488e-01f, -9.00178403e-02f, 3.70197743e-01f,
  -1.20093580e-02f, -2.09048867e-01f, 2.09580019e-01f, 2.96652138e-01f, 2.28361666e-01f, 3.52326572e-01f, 4.06833202e-01f, 1.81664735e-01f, -1.44474074e-01f, -2.55653739e-01f,
  -1.89130574e-01f, 2.31006145e-01f, -3.08676716e-02f, -3.34640183e-02f, -1.28693208e-01f, -2.87936836e-01f, -2.67875016e-01f, -2.94770926e-01f, -6.10298999e-02f, -5.10331318e-02f,
  1.01295762e-01f, -2.40159810e-01f, -1.77887112e-01f, 3.15651931e-02f, -5.54755563e-03f, -1.25642374e-01f, -1.73493754e-02f, -1.50625139e-01f, -2.13598728e-01f, -1.97584555e-01f,
  3.69045250e-02f, 2.07897741e-02f, 3.68273854e-02f, -1.12235770e-01f, -9.91464332e-02f, -6.97045475e-02f, -3.20275053e-02f, -4.31117378e-02f, -4.95543480e-02f, 3.80324200e-02f,
  -6.93231374e-02f, 8.57985020e-02f, -1.05118789e-01f, 1.62289292e-01f, -5.45340404e-02f, 1.20574916e-02f, 2.35170200e-01f, -4.02484424e-02f, 2.47164682e-01f, -5.93752274e-03f,
  4.34346311e-02f, 1.66116446e-01f, 1.00095764e-01f, 9.02849622e-03f, -1.68775301e-02f, -1.69101860e-02f, 3.86487283e-02f, -6.76497770e-03f, -1.47257060e-01f, 5.44044524e-02f,
  -2.40233149e-02f, -7.90133253e-02f, -7.48727247e-02f, 1.65543407e-01f, 3.32832597e-02f, 3.67869399e-02f, -3.56131494e-02f, -9.60763767e-02f, -3.30437571e-02f, 1.67775348e-01f,
  -5.98636782e-03f, 1.55276654e-03f, 2.69785617e-02f, -2.01852806e-02f, 1.32568121e-01f, -1.11009106e-01f, -1.03032673e-02f, 9.66832100e-04f, -8.64702538e-02f, 1.68866627e-02f,
  1.75256059e-01f, 3.43377560e-01f, 1.06812911e-02f, 1.72177870e-02f, 9.78065804e-02f, 1.02679186e-01f, 6.37842938e-02f, -2.16590818e-02f, 1.44074515e-01f, 1.13453068e-01f,
  7.65812770e-02f, -5.11412881e-02f, 1.52427815e-02f, -1.12139255e-01f, -4.23246995e-02f, 1.23666659e-01f, 1.61602244e-01f, -3.74320187e-02f, 6.36736602e-02f, -3.35429832e-02f,
  -6.03262819e-02f, 2.01940387e-02f, -1.77799701e-03f, 1.00145310e-01f, -8.84487107e-03f, -4.75244187e-02f, 3.66215780e-02f, -1.16957508e-01f, 1.02699194e-02f, -5.03623933e-02f,
  -8.45222652e-01f, 6.74045026e-01f, -4.52489145e-02f, -4.37139809e-01f, 1.67200610e-01f, 1.61518045e-02f, -9.89601240e-02f, 6.42517731e-02f, -4.78297509e-02f, 1.72806010e-01f,
  4.28410433e-02f, -1.76785275e-01f, 4.32403624e-01f, 1.97397038e-01f, -3.19918305e-01f, 2.64783978e-01f, -2.44641006e-01f, -2.30974510e-01f, 1.28773093e-01f, -2.17278078e-01f,
  -1.28590137e-01f, 5.22745168e-03f, 9.58661586e-02f, 3.51469874e-01f, -2.23528758e-01f, -2.39303082e-01f, -2.58158982e-01f, 1.85236335e-01f, -1.27432108e-01f, 8.61376226e-02f,
  -4.22572404e-01f, -3.94005001e-01f, -3.49217534e-01f, -2.04825148e-01f, -2.68383175e-01f, -1.73814207e-01f, -2.27813646e-01f, 7.02073891e-03f, -3.96003313e-02f, 3.54179516e-02f,
  -7.12245256e-02f, 2.24440228e-02f, 8.61695688e-03f, 1.06743962e-01f, -1.47936299e-01f, -1.09167092e-01f, 9.81797650e-02f, -2.32918803e-02f, 4.38718908e-02f, 7.59099871e-02f,
  1.29287139e-01f, 5.84271029e-02f, -3.82787660e-02f, 1.47711709e-02f, -5.36599942e-02f, 1.08940443e-02f, 2.69495882e-02f, -1.22520491e-03f, -1.50138110e-01f, -6.67778477e-02f,
  1.67388916e-02f, 2.32415162e-02f, 7.44286031e-02f, -4.73484509e-02f, 7.59043768e-02f, 2.43662614e-02f, -5.44928387e-02f, -1.44421961e-03f, -9.06769261e-02f, -5.43566532e-02f,
  1.03395041e-02f, -6.89286143e-02f, -4.95856516e-02f, -4.98121567e-02f, -5.95345460e-02f, -4.85610254e-02f, 1.22710941e-02f, 3.51537694e-03f, -1.80259123e-02f, 2.24632043e-02f,
  -8.00450221e-02f, 3.15184593e-02f, 5.08701894e-03f, -3.57448938e-03f, -4.51185368e-02f, 5.00052311e-02f, 1.06069278e-02f, -3.02912984e-02f, 4.53769676e-02f, 1.82662010e-02f,
  -5.57086527e-01f, -3.34703088e-01f, -7.33333826e-02f, -1.07141852e-01f, -2.42334940e-02f, -3.74108516e-02f, 9.38086677e-03f, -7.20343664e-02f, -9.51055512e-02f, -5.87072857e-02f,
  -5.69740310e-02f, 5.08707389e-02f, -1.22101098e-01f, -8.16643015e-02f, -1.40880439e-02f, -3.70084420e-02f, -1.03537709e-01f, -1.01692706e-01f, -2.67598182e-01f, -1.28026262e-01f,
  -1.07433155e-01f, 1.45519385e-02f, 5.87455556e-03f, -1.09648965e-01f, -6.89804628e-02f, -1.12672254e-01f, -1.17051423e-01f, 1.40613811e-02f, -7.85427541e-02f, 1.14516743e-01f,
  -2.19112828e-01f, -2.47740015e-01f, -4.26579595e-01f, -2.95305312e-01f, 1.24525525e-01f, -1.41941205e-01f, -2.77262777e-01f, 1.11619132e-02f, 1.38472870e-01f, 1.66424394e-01f,
  3.74853634e-03f, 6.55665472e-02f, 2.67834306e-01f, -4.76283461e-01f, -5.41010320e-01f, -2.21617103e-01f, -4.43817407e-01f, -1.71266124e-01f, -8.08842182e-02f, 2.96342988e-02f,
  -1.12504981e-01f, -8.88938159e-02f, -4.17201579e-01f, 2.70038158e-01f, -3.69050205e-01f, 3.06970533e-02f, -1.26748439e-02f, 1.54806480e-01f, -2.17885017e-01f, -8.93690959e-02f,
  -1.34169266e-01f, -8.24279785e-02f, -1.37251779e-01f, -1.74594685e-01f, -4.15603667e-02f, 4.89281155e-02f, 7.75188357e-02f, -3.82038392e-02f, 4.67828587e-02f, -1.72271375e-02f,
  3.85143310e-02f, 1.35913610e-01f, 1.62413605e-02f, -3.07260659e-02f, 4.98200506e-02f, -3.76596339e-02f, -1.27479737e-03f, -3.19242813e-02f, -6.28324077e-02f, -1.68116912e-01f,
  -3.62621725e-01f, -4.63877097e-02f, 3.78026739e-02f, 1.81481123e-01f, -1.36287417e-02f, -1.20463595e-01f, -1.13917001e-01f, -6.63066357e-02f, -1.25866141e-02f, -1.72174931e-01f,
  1.06320277e-01f, 1.05083160e-01f, -7.84979314e-02f, -1.81881469e-02f, -4.05182764e-02f, 6.24669641e-02f, -7.03805685e-02f, -8.97080544e-03f, -5.13240956e-02f, -8.63817930e-02f,
  1.86159268e-01f, -4.19758633e-02f, 3.12148537e-02f, -4.67804335e-02f, -1.22020878e-01f, 1.15990251e-01f, -2.06848681e-02f, 8.36282969e-03f, 1.97576601e-02f, -4.23360318e-02f,
  -4.98880371e-02f, 2.30731349e-02f, 4.39516865e-02f, 7.18203112e-02f, -7.08952323e-02f, 1.41519010e-01f, 9.55737159e-02f, -3.78024168e-02f, -1.35202453e-01f, 7.90784210e-02f,
  9.87539962e-02f, 2.09452689e-01f, -4.29784246e-02f, 7.12186992e-02f, 1.06953703e-01f, 1.69103324e-01f, -6.26950059e-03f, 1.60557247e-04f, -5.30520082e-02f, 9.55725238e-02f,
  7.90993869e-02f, 7.36811981e-02f, 7.76969269e-02f, -7.15832561e-02f, 1.17176190e-01f, -2.20616549e-01f, 1.38776183e-01f, 2.45951042e-01f, 1.19710818e-01f, 2.04722539e-01f,
  2.32299455e-02f, 2.98608840e-01f, 1.42602054e-02f, 2.20819250e-01f, 4.58767675e-02f, 5.82374223e-02f, 6.53191954e-02f, -5.21358028e-02f, 9.01924670e-02f, 3.31271552e-02f,
  -1.69655830e-01f, 1.60550233e-02f, 4.85338777e-01f, 4.62689213e-02f, 3.05813611e-01f, 4.82970029e-01f, 4.50070739e-01f, 2.01293796e-01f, 4.09034759e-01f, -2.46907294e-01f,
  -4.16499227e-01f, -2.93915253e-02f, 1.65901557e-01f, -1.58922121e-01f, 3.09415936e-01f, 1.89426869e-01f, 2.08328348e-02f, 2.39787418e-02f, 3.65479827e-01f, -8.18982273e-02f,
  -3.77547629e-02f, -3.18274349e-01f, -2.28301004e-01f, -7.84191266e-02f, -9.58957076e-02f, 3.07121333e-02f, -4.04295355e-01f, 3.99955928e-01f, -3.72666746e-01f, 2.14357600e-01f,
  4.57792962e-03f, 1.11382812e-01f, -3.99635397e-02f, 2.14044955e-02f, -1.09717064e-01f, 6.46146433e-03f, -1.35973915e-01f, 1.72667474e-01f, 2.41244763e-01f, -1.44593120e-02f,
  -7.72158504e-02f, 3.75621170e-02f, 2.07991861e-02f, -7.56285042e-02f, 1.94038630e-01f, -1.95673928e-01f, -5.93324341e-02f, -1.18324310e-01f, 1.45233363e-01f, -9.00949687e-02f,
  -9.71029103e-02f, 4.97629680e-02f, -5.45323268e-02f, -8.83087143e-02f, -4.45049629e-02f, 7.74179697e-02f, 6.05691262e-02f, 3.41908596e-02f, -5.56557365e-02f, 8.84185880e-02f,
  1.03734098e-01f, 1.93661973e-01f, -4.80504036e-02f, -6.24362053e-03f, 7.70453066e-02f, -1.73545733e-01f, -7.20192418e-02f, -2.65789807e-01f, -1.25431586e-02f, -1.19835995e-02f,
  -9.76266116e-02f, -5.57385711e-03f, -2.03038082e-02f, 1.15581020e-03f, -8.25243518e-02f, -1.27912521e-01f, 2.23328024e-02f, -1.36066407e-01f, 2.41508856e-02f, -8.91247243e-02f,
  -7.42431283e-02f, 1.11096010e-01f, -4.11331989e-02f, -1.78032845e-01f, 1.22267462e-01f, 1.38721347e-01f, -1.82941094e-01f, 4.38796356e-02f, -6.86732754e-02f, -3.85127366e-02f,
  1.35469094e-01f, 3.06860298e-01f, -4.66085747e-02f, -1.33667022e-01f, -5.56574464e-02f, -5.56722246e-02f, 9.06238183e-02f, -1.17304005e-01f, 1.26072317e-01f, -6.04341514e-02f,
  -1.19039811e-01f, -1.15059525e-01f, 1.79491229e-02f, -1.25603318e-01f, 4.95636538e-02f, -1.22602887e-01f, -2.29357127e-02f, 1.19020164e-01f, -8.78182650e-02f, -1.14447191e-01f,
  -1.33259892e-01f, 1.11124618e-02f, 4.77578491e-02f, -9.72362608e-02f, -1.63903251e-01f, -1.52348028e-02f, -1.05542421e-01f, 1.14814609e-01f, -1.18979095e-02f, 8.70862231e-03f,
  1.45874679e-01f, -2.55765796e-01f, 1.75991848e-01f, -4.86803949e-01f, 7.63924718e-02f, -1.16886109e-01f, -9.19965729e-02f, -2.84440964e-01f, -3.05004090e-01f, -5.02557814e-01f,
  -3.00326645e-01f, -2.02777028e-01f, 1.88020721e-01f, -4.42348301e-01f, 4.21124667e-01f, 3.53206605e-01f, -2.52774179e-01f, -2.75681138e-01f, 1.79703802e-01f, -1.89590588e-01f,
  -2.99765170e-02f, -2.66319782e-01f, 3.76774907e-01f, -2.49674127e-01f, -1.13033108e-01f, -1.55160040e-01f, -7.70296603e-02f, 1.47489712e-01f, -4.14757848e-01f, -3.14954631e-02f,
  1.09990907e-03f, 1.62940651e-01f, -1.66515466e-02f, 1.21770062e-01f, -5.19926883e-02f, 8.56791362e-02f, -1.85495596e-02f, 1.40393466e-01f, 5.01159579e-02f, 8.16438943e-02f,
  -5.76435141e-02f, 5.65082431e-02f, -2.17741683e-01f, 1.62481651e-01f, -1.05422564e-01f, -1.14859119e-01f, 1.78190976e-01f, 1.97216636e-03f, -1.12835124e-01f, 1.75406590e-01f,
  2.87835021e-02f, 2.43942477e-02f, 4.56942134e-02f, -1.37892850e-02f, 3.08646280e-02f, -1.42014697e-01f, 2.88760127e-03f, -4.79829079e-03f, -7.08248988e-02f, -1.12763397e-01f,
  7.10379854e-02f, 4.13557887e-02f, 1.09645009e-01f, -5.87633774e-02f, 6.06725030e-02f, -9.02618989e-02f, -1.63515434e-02f, 5.45155555e-02f, -1.86413806e-02f, -9.41733420e-02f,
  -1.33646891e-01f, -1.27329260e-01f, 8.25660825e-02f, 8.39676242e-03f, -7.89199471e-02f, 8.47068056e-03f, -4.04971614e-02f, 1.34993140e-02f, -7.00200498e-02f, -3.88053320e-02f,
  -1.87001601e-02f, -1.60936099e-02f, 3.08399694e-03f, 6.93150191e-03f, 2.97886319e-03f, 8.93740356e-02f, -4.17458043e-02f, -4.42553125e-02f, 7.27318898e-02f, 6.53486624e-02f,
  -5.73630631e-02f, -1.85254797e-01f, -2.41865646e-02f, -1.18379012e-01f, 4.34564650e-02f, -1.75517071e-02f, 5.18900156e-03f, -8.89298916e-02f, -1.26733378e-01f, 4.90458161e-02f,
  -1.57307625e-01f, -1.10260785e-01f, -1.59477115e-01f, -2.29559708e-02f, 6.10063113e-02f, -1.90868407e-01f, -1.56647749e-02f, -9.95104462e-02f, -5.44400774e-02f, -2.17960030e-01f,
  -5.20321131e-02f, -7.70787448e-02f, -3.36633734e-02f, -1.29602432e-01f, -3.60625647e-02f, -1.40385717e-01f, 1.44955814e-01f, -3.01051252e-02f, 4.35805470e-02f, -2.03343600e-01f,
  -5.03778398e-01f, 4.11601573e-01f, 1.48234040e-01f, 1.24496318e-01f, -4.32403177e-01f, 5.96994460e-01f, 5.59063375e-01f, -1.74783822e-02f, 1.72506154e-01f, 1.24706857e-01f,
  -1.27411202e-01f, -6.53934106e-02f, 3.37409079e-01f, 2.56079763e-01f, 2.97333062e-01f, 6.46437168e-01f, 4.24701989e-01f, 2.71666318e-01f, -1.77548286e-02f, 4.64773029e-02f,
  1.75875649e-02f, -6.63079470e-02f, 5.65255545e-02f, -2.03394085e-01f, -2.73711771e-01f, -2.35239133e-01f, -2.79097825e-01f, 6.26457483e-02f, -7.98704773e-02f, -1.17997542e-01f,
  1.63062707e-01f, -1.53209448e-01f, -4.68953140e-02f, 9.90344733e-02f, 1.45562917e-01f, 2.04259865e-02f, -2.29213759e-02f, -6.58973232e-02f, -1.18360393e-01f, 2.72479337e-02f,
  -6.75175488e-02f, 8.11700746e-02f, -1.00803014e-03f, -7.99839199e-03f, -1.35259837e-01f, -8.76832232e-02f, 3.82798538e-02f, -5.59201390e-02f, 1.06018715e-01f, -6.55866265e-02f,
  6.68031052e-02f, 1.31020683e-03f, -9.48889088e-03f, -3.25366817e-02f, -1.25135854e-01f, 1.35697305e-01f, 1.64501727e-01f, -9.80724618e-02f, -2.19325325e-03f, 2.07403880e-02f,
  -1.23419106e-01f, 1.52001619e-01f, 1.24383830e-01f, -4.46601138e-02f, 1.05802588e-01f, -2.45682709e-02f, 1.14273116e-01f, 1.83264315e-02f, -6.74559223e-03f, 1.38009161e-01f,
  -4.65501584e-02f, 4.12091129e-02f, 1.53891638e-01f, 1.91926643e-01f, -6.05202727e-02f, -4.47820462e-02f, 3.15949367e-03f, 2.11184621e-02f, 7.74249882e-02f, 3.38189956e-03f,
  3.49408463e-02f, 1.07209623e-01f, 3.13835451e-03f, -4.20439579e-02f, 8.66946951e-02f, -1.22413054e-01f, -1.58251017e-01f, -4.56133001e-02f, -2.62955371e-02f, -5.03674857e-02f,
  3.32768053e-01f, 2.28458136e-01f, 6.08401820e-02f, 5.28733246e-02f, 1.87129140e-01f, -3.60094663e-03f, 6.00032657e-02f, 5.47919422e-03f, 8.95432010e-02f, -1.58063620e-02f,
  -6.30608052e-02f, 1.64750695e-01f, 4.34010252e-02f, -1.50851279e-01f, 5.40150031e-02f, 1.17099166e-01f, 1.55568898e-01f, 1.24020666e-01f, 8.87641609e-02f, -3.76555324e-02f,
  4.35756110e-02f, -3.39200944e-02f, 6.85118139e-03f, -1.01354353e-01f, -6.08873852e-02f, -1.94883626e-02f, -1.29450127e-01f, 3.14525552e-02f, -8.96680281e-02f, 1.39592186e-01f,
  3.51134241e-01f, -2.65837312e-01f, 3.33476663e-01f, 4.55059297e-02f, 1.09944507e-01f, 1.89062953e-01f, 4.54620123e-01f, -5.77460788e-02f, 4.64233994e-01f, -3.66760045e-01f,
  -5.20974934e-01f, 3.05420876e-01f, 1.95814028e-01f, -3.70021701e-01f, 6.13631785e-01f, 3.53276432e-01f, -1.49957478e-01f, -1.73298325e-02f, 5.22201136e-02f, -9.97014344e-03f,
  3.84039357e-02f, -2.07298890e-01f, -1.95965528e-01f, -3.74945939e-01f, -3.13653827e-01f, -1.97631702e-01f, -3.46991420e-01f, 1.62569106e-01f, -3.47205967e-01f, -1.03097586e-02f,
  -3.76597941e-01f, -2.30943382e-01f, -1.87467918e-01f, 2.06984878e-02f, -6.83448315e-02f, -1.48505226e-01f, 1.23622611e-01f, 9.37317312e-02f, 2.92455088e-02f, 8.39140043e-02f,
  3.22118625e-02f, -6.55674711e-02f, 2.06654519e-02f, 1.42464399e-01f, 2.07413989e-03f, -5.05616777e-02f, -3.08143012e-02f, -2.62777746e-01f, -4.59963158e-02f, 5.91115840e-02f,
  1.46435509e-02f, -1.71363756e-01f, 2.94260923e-02f, -1.04795769e-02f, 7.56494410e-04f, -1.84632793e-01f, 1.42557979e-01f, 1.80393711e-01f, -9.58192348e-02f, -5.57339005e-02f,
  2.78323647e-02f, 1.02325901e-01f, 9.88788754e-02f, 3.64438966e-02f, -2.07851063e-02f, -1.38637066e-01f, 5.61104231e-02f, -1.05271200e-02f, -1.84146520e-02f, -8.26964900e-02f,
  -7.56623223e-02f, 8.13532714e-03f, 1.10091783e-01f, 5.01091108e-02f, -1.82338636e-02f, -2.85679251e-02f, 1.08264834e-01f, 5.45909861e-03f, -6.14302903e-02f, -1.33144081e-01f,
  1.08233683e-01f, 8.46109167e-02f, -2.31503054e-01f, -6.54522032e-02f, -1.62147135e-01f, 7.44284242e-02f, -1.62336230e-01f, -6.87689111e-02f, -7.00314492e-02f, -3.36005702e-03f,
  4.14819829e-02f, 4.98138182e-02f, -1.13557860e-01f, -1.57605946e-01f, 7.15312362e-02f, -1.82648778e-01f, 1.39455959e-01f, 7.27246925e-02f, 5.58292754e-02f, 4.67415638e-02f,
  -8.82795826e-02f, -1.07520543e-01f, 6.29320741e-02f, 7.31439888e-02f, -1.90845598e-02f, -3.44639048e-02f, 7.58333355e-02f, -6.38841838e-02f, -1.31416112e-01f, -1.50057077e-01f,
  -1.67584419e-01f, 2.05950797e-01f, 1.20357938e-01f, -1.09045662e-01f, -9.99128968e-02f, -8.10860693e-02f, 1.63861483e-01f, -6.04132377e-02f, -3.43887843e-02f, 1.40676191e-02f,
  -7.24584162e-01f, 5.37298918e-01f, 3.83368820e-01f, 5.66176586e-02f, -1.86092943e-01f, 5.91281593e-01f, 4.75664198e-01f, -3.42835933e-02f, 8.47726017e-02f, 5.06739020e-01f,
  1.87947944e-01f, 6.26394004e-02f, 1.35688797e-01f, 3.14081639e-01f, 1.03014685e-01f, 3.72226596e-01f, 3.80970329e-01f, 3.24712664e-01f, -2.45324537e-01f, -1.98323220e-01f,
  -1.65167093e-01f, 1.14698045e-01f, 2.63618141e-01f, -2.73951709e-01f, 1.17850028e-01f, -1.93081960e-01f, -1.85499519e-01f, -1.68701142e-01f, 2.76985675e-01f, 1.24901876e-01f,
  -1.42272025e-01f, -4.90420610e-01f, -8.20003673e-02f, 3.42491642e-02f, 5.67296520e-02f, -3.30594219e-02f, 1.41658530e-01f, -9.12328660e-02f, -1.75560459e-01f, 6.75495937e-02f,
  2.86560841e-02f, -9.82816741e-02f, -5.93215786e-02f, -2.25068498e-02f, -1.10500798e-01f, -6.92392588e-02f, 5.58139607e-02f, 1.15989327e-01f, 1.94864318e-01f, 1.35802895e-01f,
  1.16586424e-01f, 1.61250189e-01f, 3.52290198e-02f, 2.16784790e-01f, 8.06611478e-02f, 2.40209159e-02f, 8.02349672e-02f, 5.10685295e-02f, 1.39039397e-01f, 2.84659397e-02f,
  1.45844206e-01f, -3.02277207e-02f, 1.24645159e-01f, -1.15965018e-02f, 2.71940827e-02f, -6.55555502e-02f, -5.47251217e-02f, 1.72818881e-02f, 3.31938528e-02f, -2.63885241e-02f,
  5.08067124e-02f, -1.79470927e-02f, -6.17950223e-02f, 6.85646236e-02f, -3.73310484e-02f, -3.03256083e-02f, -2.34381799e-02f, 3.53957387e-03f, 1.11926235e-02f, 7.73138553e-02f,
  -5.40509038e-02f, 4.45263460e-03f, 1.44953460e-01f, 1.41830724e-02f, 1.33980393e-01f, 1.48395360e-01f, -3.92149389e-02f, 9.27459002e-02f, -2.66573690e-02f, 3.90148547e-04f,
  7.68366829e-02f, -2.20445991e-01f, -1.59412026e-02f, -1.74120814e-02f, 4.71123308e-02f, 6.01431802e-02f, 2.93999612e-02f, 7.07220137e-02f, 1.52459726e-01f, 6.60135364e-03f,
  -6.82604313e-02f, 4.55533788e-02f, -9.43557322e-02f, 1.09462418e-01f, 7.41905496e-02f, 1.29458755e-01f, -7.92445019e-02f, -4.98083606e-02f, -4.49207351e-02f, -7.83165172e-02f,
  -4.06534448e-02f, -1.54982358e-01f, -1.28448099e-01f, 2.77217925e-02f, 1.72103383e-02f, 1.38707235e-01f, -1.36020973e-01f, -4.72929962e-02f, -1.95984934e-02f, 1.46134824e-01f,
  4.56393152e-01f, -4.17677015e-02f, -2.28026539e-01f, 1.39766335e-01f, 1.20414309e-01f, 3.45861197e-01f, 2.56060243e-01f, 3.10900718e-01f, 1.65769070e-01f, -1.82015039e-02f,
  -3.87973385e-03f, 1.30639225e-01f, -1.56315163e-01f, 1.87989518e-01f, 5.51793635e-01f, -1.42319843e-01f, 3.59833449e-01f, 2.67855555e-01f, 3.18650864e-02f, 3.29076439e-01f,
  1.43389910e-01f, 3.40989918e-01f, -1.59863591e-01f, -2.19684355e-02f, 5.56772761e-02f, -3.22469741e-01f, -2.18719035e-01f, -2.49265209e-01f, -3.18465894e-03f, 5.85297421e-02f,
  3.03779333e-03f, -2.30863616e-02f, -1.24476001e-01f, 3.08639910e-02f, -5.17399199e-02f, -9.65131596e-02f, 2.42082085e-02f, 9.32383910e-03f, -5.21246195e-02f, -4.92519513e-03f,
  2.76468340e-02f, 1.29314840e-01f, 1.05298132e-01f, -3.84281054e-02f, 8.23183209e-02f, -5.05798571e-02f, -3.52629870e-02f, -1.83683589e-01f, 5.06637953e-02f, 5.29196076e-02f,
  4.20703320e-03f, -6.31584376e-02f, -7.17560872e-02f, 6.23887521e-04f, -5.66393211e-02f, 3.54013667e-02f, 9.20395181e-02f, -4.44596894e-02f, 1.46181941e-01f, 1.07993022e-01f,
  1.60937592e-01f, -2.83854827e-02f, -1.25305101e-01f, -2.20228825e-03f, 2.68516485e-02f, -1.98937654e-01f, -5.85272647e-02f, -1.02505997e-01f, -1.90723203e-02f, -1.14530278e-02f,
  -1.10092752e-01f, -6.33172467e-02f, 4.35636640e-02f, 1.01653740e-01f, -5.01131220e-03f, 9.45501216e-03f, 1.18037879e-01f, -8.12306553e-02f, 1.98956998e-03f, -5.33930957e-02f,
  2.46212371e-02f, 8.19473341e-02f, -2.42333189e-02f, -1.44863918e-01f, 2.76486427e-02f, -6.45666718e-02f, -3.78464833e-02f, 8.75431225e-02f, -9.74554196e-02f, 1.04431838e-01f,
  1.22218862e-01f, 3.55812699e-01f, -8.92465562e-02f, -7.10860714e-02f, -4.84682135e-02f, 6.95120469e-02f, 1.89030152e-02f, 1.25515684e-01f, 2.48958871e-01f, 2.25669771e-01f,
  8.56183693e-02f, 2.19969805e-02f, -7.62426704e-02f, -6.22192286e-02f, 2.51979269e-02f, 1.03530861e-01f, -4.81383828e-03f, 6.52170852e-02f, 1.21345833e-01f, 1.22567140e-01f,
  1.40892128e-02f, 4.97401282e-02f, 9.52432677e-03f, 3.33677828e-02f, -1.52841546e-02f, -1.03849145e-02f, 4.76229638e-02f, 8.39343853e-03f, 2.22819801e-02f, -2.67080758e-02f,
  3.41141708e-02f, 2.55858898e-01f, -2.80697078e-01f, 4.14738171e-02f, 2.69102395e-01f, 5.75370967e-01f, 3.75780463e-01f, -3.11556645e-02f, 2.60469347e-01f, 2.82181501e-01f,
  2.56326348e-01f, -1.67523012e-01f, -2.13659659e-01f, 5.28558671e-01f, -8.51755366e-02f, 1.07978955e-01f, 3.22280765e-01f, 4.01876211e-01f, -1.46158427e-01f, 1.67438999e-01f,
  -2.21538246e-01f, 4.38323230e-01f, -3.28708470e-01f, 1.36755571e-01f, 1.19029924e-01f, -3.18495542e-01f, -2.17654675e-01f, -4.25037235e-01f, 5.74354716e-02f, 5.19762672e-02f,
  9.49203894e-02f, 5.39054349e-02f, -2.00277865e-01f, -1.22826956e-01f, 3.98395993e-02f, 5.55376932e-02f, -5.36977202e-02f, -1.48785844e-01f, -2.76540130e-01f, -1.78526230e-02f,
  -1.71327237e-02f, -1.04614899e-01f, 7.27923587e-02f, -8.05428103e-02f, 1.84596181e-01f, -1.93743650e-02f, -1.94643512e-01f, 3.53965759e-02f, -4.53862622e-02f, -7.38848299e-02f,
  2.06466522e-02f, -3.53579223e-02f, 1.31523415e-01f, 1.41432837e-01f, -1.66561734e-02f, 7.83357769e-02f, 5.70136646e-04f, -1.41928077e-01f, 3.84174883e-02f, 7.35254511e-02f,
  4.65940824e-03f, -1.65096519e-03f, -1.03254780e-01f, 2.24889908e-02f, 7.09410235e-02f, 4.21742530e-04f, 5.30748740e-02f, 7.35883862e-02f, -5.98019697e-02f, 3.04251194e-01f,
  5.49985282e-02f, 4.83619608e-03f, 5.44182323e-02f, 6.08559623e-02f, 7.26458877e-02f, 1.93421543e-01f, -1.20624103e-01f, 5.21822125e-02f, -7.57619068e-02f, -1.25630081e-01f,
  -1.31383926e-01f, 1.90574601e-02f, -2.87498976e-03f, -5.79521954e-02f, -4.29060747e-04f, -1.85137987e-01f, -1.09332219e-01f, -1.00769937e-01f, -1.25616286e-02f, 1.39389560e-03f,
  2.18718141e-01f, 3.01954955e-01f, -8.64509717e-02f, 5.13580367e-02f, -5.60737774e-02f, -3.71909812e-02f, -6.55239671e-02f, -1.31029725e-01f, 5.68707474e-02f, 4.30145413e-02f,
  -1.56928390e-01f, 6.12051338e-02f, 1.54247418e-01f, 4.62539792e-02f, 4.63252440e-02f, 9.81420353e-02f, 7.23714828e-02f, 6.81681335e-02f, -2.39238710e-04f, -8.62693489e-02f,
  1.02920584e-01f, 1.76019222e-01f, -7.31994882e-02f, 2.18845025e-01f, 1.23327725e-01f, -4.96259108e-02f, 1.47834584e-01f, -1.04733117e-01f, -1.35071382e-01f, -1.93169024e-02f,
  1.16600618e-01f, 4.04789597e-01f, 5.80094680e-02f, 1.82037637e-01f, 3.52338791e-01f, -4.17814285e-01f, 2.01787189e-01f, 2.69628525e-01f, 3.66601318e-01f, -5.62476879e-03f,
  -3.07640314e-01f, -4.29037493e-04f, -2.19651163e-01f, -7.73472115e-02f, -6.98203564e-01f, -4.86583680e-01f, -3.54684293e-01f, -3.20324719e-01f, -1.38673171e-01f, -3.40787023e-02f,
  -1.11449510e-01f, 6.66721985e-02f, -4.70140856e-03f, 3.32902908e-01f, 4.68385488e-01f, 4.93834049e-01f, -3.02830637e-01f, 1.87497497e-01f, -4.44012173e-02f, -2.15493180e-02f,
  -5.72641827e-02f, 2.00358450e-01f, 2.01606244e-01f, 1.61831707e-01f, -2.22914740e-01f, -9.66686085e-02f, -2.38249183e-01f, 3.75585072e-02f, 8.99855569e-02f, 8.33596289e-02f,
  1.40477798e-03f, -1.47736976e-02f, 9.05466080e-02f, 1.75482765e-01f, 2.59940267e-01f, 6.17654584e-02f, -1.69262732e-03f, -2.96890587e-02f, 1.21188045e-01f, -1.05201557e-01f,
  8.40935186e-02f, -9.72926319e-02f, -1.10304713e-01f, -4.07385938e-02f, -8.39212760e-02f, 6.36687726e-02f, -1.53571218e-01f, -8.44642147e-02f, -3.18827195e-04f, 5.96615747e-02f,
  -2.98696999e-02f, -5.59656397e-02f, -1.02800474e-01f, 2.22151548e-01f, -2.27651782e-02f, 7.80012459e-02f, 6.65968582e-02f, 7.83986524e-02f, 9.64698941e-02f, 1.88454185e-02f,
  -6.07462339e-02f, 4.04006541e-02f, 5.56159727e-02f, -3.50379199e-02f, -2.16011945e-02f, 1.04435340e-01f, 8.58166255e-03f, -4.94548008e-02f, -4.34241407e-02f, -1.69963390e-01f,
  1.28188450e-02f, -1.31200895e-01f, 2.89778784e-02f, 1.03748098e-01f, 6.00083673e-04f, 6.94203824e-02f, -5.92727438e-02f, 3.26476842e-02f, -4.54260558e-02f, -1.15937367e-01f,
  -6.59338176e-01f, -3.76398563e-01f, 9.78937671e-02f, 2.35120624e-01f, -8.15426633e-02f, -1.91842109e-01f, -1.37987092e-01f, 3.22332047e-02f, -4.62577082e-02f, -3.73024866e-02f,
  1.38433268e-02f, 8.91652182e-02f, -1.09531306e-01f, -1.01854382e-02f, -1.51393607e-01f, -1.76596552e-01f, -9.70736519e-02f, 3.21252830e-02f, -9.49073881e-02f, -1.35115907e-01f,
  -3.67490984e-02f, -4.07920592e-02f, -5.74461445e-02f, 2.33088747e-01f, -2.94665899e-02f, -1.18915169e-02f, 5.11926040e-02f, 7.44608045e-02f, -7.14475811e-02f, -1.14586934e-01f,
  2.46581227e-01f, -2.90773064e-01f, -4.50014383e-01f, -1.30782798e-01f, 2.83705652e-01f, 4.39247757e-01f, 1.01985842e-01f, 7.39170425e-03f, -5.49112797e-01f, 1.34740770e-02f,
  1.93702459e-01f, -2.46872842e-01f, -4.42664564e-01f, -1.26210511e-01f, -1.04533084e-01f, -4.57337499e-01f, 1.56653881e-01f, 6.96237385e-02f, -3.10925066e-01f, 1.79364979e-01f,
  -6.44972548e-02f, 3.11475039e-01f, -3.05279851e-01f, 3.19351256e-01f, 3.38937044e-01f, 2.34015554e-01f, 3.60647500e-01f, 2.83206324e-03f, 3.04595292e-01f, 6.26375824e-02f,
  -7.22827911e-02f, -1.68519363e-01f, -6.48369119e-02f, -1.14937350e-01f, 1.46698460e-01f, 1.83927774e-01f, 4.18275855e-02f, 7.67889619e-02f, 3.26732807e-02f, -1.67734787e-01f,
  1.46789044e-01f, 1.53882895e-02f, -3.35278474e-02f, -6.07295632e-02f, 1.27346113e-01f, -5.73513610e-03f, -7.71681890e-02f, -1.40378624e-01f, -2.14136839e-01f, -5.38279787e-02f,
  -1.38662189e-01f, -4.27423269e-02f, 1.04657419e-01f, 5.65107614e-02f, -4.64923978e-02f, 1.31549640e-02f, 8.66906196e-02f, 4.85121310e-02f, 6.39311671e-02f, 1.00492038e-01f,
  9.90593657e-02f, 9.78951976e-02f, 7.42160156e-02f, -1.38870627e-01f, -3.32278088e-02f, -1.69468354e-02f, -1.05232894e-01f, -3.10911871e-02f, -7.14775100e-02f, -7.69911632e-02f,
  2.96090394e-02f, 8.22679624e-02f, -2.01064393e-01f, 4.29221243e-02f, 1.40308216e-01f, -6.83272630e-02f, 3.12656462e-02f, 6.67242333e-02f, 2.43967120e-02f, -1.11284859e-01f,
  -1.69824660e-01f, 8.42178687e-02f, -2.90215220e-02f, 3.30043286e-02f, -5.77685386e-02f, -1.93058271e-02f, -4.64356533e-04f, -1.93710215e-02f, -2.70097964e-02f, -3.64592224e-02f,
  6.45957217e-02f, 4.41135466e-02f, -7.43626729e-02f, 8.52569863e-02f, -9.95839462e-02f, 1.05129816e-01f, -1.26753658e-01f, -2.15091985e-02f, 8.20654333e-02f, 8.68092030e-02f,
  3.08671296e-01f, 1.65045455e-01f, 5.90736941e-02f, 3.34191322e-02f, -3.02068722e-02f, 1.05051421e-01f, 7.29385540e-02f, -4.05180705e-04f, -2.37535778e-02f, -5.56191914e-02f,
  2.28884190e-01f, 1.95337534e-01f, 2.72853803e-02f, 1.16348743e-01f, 1.44096747e-01f, 8.50647092e-02f, 1.31590188e-01f, 6.26748726e-02f, 4.29178514e-02f, -7.27596581e-02f,
  4.88969982e-01f, -4.50090140e-01f, 3.93780060e-02f, 4.09276485e-01f, 2.22977519e-01f, -5.82875550e-01f, -1.26458317e-01f, -2.83937365e-01f, 2.95246959e-01f, -4.96548682e-01f,
  5.99293709e-02f, -1.30488053e-01f, 2.18030125e-01f, -4.02347088e-01f, 3.23285609e-01f, 2.09703967e-01f, -3.18267405e-01f, -2.75400430e-01f, 5.35736047e-02f, -2.98022684e-02f,
  2.77934194e-01f, -1.79351076e-01f, 1.16870880e-01f, -3.17559004e-01f, -1.22580536e-01f, -1.61231253e-02f, -3.72925773e-02f, 6.80515096e-02f, -4.95267004e-01f, 6.91663986e-03f,
  -3.16671431e-02f, 2.22581580e-01f, 2.67074667e-02f, -7.51121640e-02f, 1.58271324e-02f, 1.42029077e-02f, -4.79710437e-02f, 8.45485926e-02f, 1.61779761e-01f, -7.55769983e-02f,
  5.53813167e-02f, 9.01316032e-02f, -1.21443287e-01f, -3.64691839e-02f, 3.19341421e-02f, -9.01204124e-02f, 5.86497970e-02f, -5.54012656e-02f, 6.29620627e-02f, 1.29989624e-01f,
  1.28106788e-01f, 5.50513938e-02f, 8.89660940e-02f, -2.21542884e-02f, 9.67867449e-02f, 2.55953036e-02f, 2.11455263e-02f, -1.05977111e-01f, 1.16707021e-02f, 9.63461623e-02f,
  -5.90325519e-03f, 6.68063387e-02f, 2.66533718e-02f, 9.89587163e-04f, 1.22337788e-01f, 1.49787692e-02f, 5.92093579e-02f, -1.01367757e-02f, -7.31994025e-03f, -3.05541195e-02f,
  5.28665595e-02f, 3.68104056e-02f, 3.72360982e-02f, 4.44864063e-03f, 1.09144680e-01f, 2.06005387e-02f, -4.69688093e-03f, -3.52228843e-02f, 5.28021716e-02f, -6.45745024e-02f,
  2.08605994e-02f, 3.15170706e-04f, -6.37966916e-02f, -6.80435374e-02f, -8.09599459e-02f, 1.72841139e-02f, -2.83574332e-02f, 2.15034448e-02f, -9.22134817e-02f, 9.81495157e-02f,
  -7.47541040e-02f, -3.44745517e-01f, -3.36739607e-02f, -1.03288971e-01f, -1.41782030e-01f, -1.24953076e-01f, -1.16636539e-02f, -9.22765359e-02f, -1.31244538e-02f, -2.07965691e-02f,
  -2.38623187e-01f, 1.05852196e-02f, -2.68839449e-02f, -5.23004532e-02f, -1.03497535e-01f, -1.58381797e-02f, -7.80658191e-03f, -1.77966170e-02f, -5.32918572e-02f, -1.11465096e-01f,
  -1.65641736e-02f, -5.16014313e-03f, 3.36577967e-02f, -6.53320178e-02f, -8.58049095e-02f, 4.39031981e-03f, -1.40800834e-01f, 1.05282158e-01f, 6.19127564e-02f, -3.17613147e-02f,
  4.81539786e-01f, -3.44637632e-01f, 3.09722722e-01f, 2.14531019e-01f, 2.17373595e-01f, 8.44513476e-02f, 2.87227660e-01f, -1.86719507e-01f, -6.41006455e-02f, -4.28469241e-01f,
  -4.16365974e-02f, 1.04327045e-01f, 1.41905904e-01f, -5.07929802e-01f, 2.44364977e-01f, -1.44532472e-01f, -3.01083952e-01f, -1.59453928e-01f, -8.85811150e-02f, -1.92674413e-01f,
  -6.29472062e-02f, -5.39867043e-01f, -2.65337788e-02f, -5.97396076e-01f, -7.99227953e-02f, -3.36830691e-02f, -3.47022973e-02f, 9.55590308e-02f, -3.51646751e-01f, -3.78618129e-02f,
  -5.83221391e-02f, -2.34799653e-01f, 2.69927969e-03f, -9.28377882e-02f, 3.30215357e-02f, 1.37509063e-01f, 5.53729236e-02f, -1.23662753e-02f, 2.26918414e-01f, 2.43552271e-02f,
  1.16061959e-02f, 2.44951360e-02f, -1.74932510e-01f, 1.36278898e-01f, 2.06492748e-02f, 2.09508054e-02f, 2.95461365e-03f, 7.17747211e-02f, -2.67350394e-02f, 2.14158267e-01f,
  1.23980574e-01f, 1.76971808e-01f, 1.44242108e-01f, -3.82994637e-02f, 6.68502375e-02f, 5.47764003e-02f, 1.02024704e-01f, 2.56516188e-01f, -4.18700576e-02f, 6.41539767e-02f,
  -7.82027766e-02f, -6.99174777e-02f, -3.74326631e-02f, 1.54403364e-02f, -1.01210222e-01f, 1.68685801e-02f, -1.76946953e-01f, -1.41080758e-02f, 4.29532789e-02f, 3.21847871e-02f,
  1.25290547e-02f, -3.19094025e-02f, -9.61003825e-02f, -5.85056748e-03f, -5.05664647e-02f, 6.66414127e-02f, 3.23102884e-02f, 1.39168262e-01f, -2.51394156e-02f, -8.40466563e-03f,
  -2.24661380e-02f, -5.36853895e-02f, 2.22086851e-02f, 6.27835840e-02f, -4.24352176e-02f, 2.10987143e-02f, -1.58438459e-01f, 1.66484520e-01f, -5.63867502e-02f, 4.13308963e-02f,
  -1.34161979e-01f, -5.70448041e-01f, -2.14433432e-01f, 3.40242684e-02f, -1.47792324e-01f, -2.42707357e-02f, -1.14098437e-01f, -2.16680750e-01f, -7.89450333e-02f, -2.01717541e-01f,
  1.12537153e-01f, 1.11068040e-01f, -7.82686174e-02f, -2.78658774e-02f, -9.34582949e-02f, 3.96378562e-02f, -6.78269658e-03f, 1.29094183e-01f, -6.24057055e-02f, -1.27494363e-02f,
  5.04253767e-02f, 1.35132879e-01f, 5.58804125e-02f, -6.93504289e-02f, -5.50926663e-03f, 1.17350422e-01f, -1.46513898e-02f, -2.27055456e-02f, 5.95109761e-02f, -4.72060256e-02f,
  8.73174332e-03f, -2.27209553e-01f, -2.94726580e-01f, -2.52032757e-01f, -4.45417501e-02f, 2.71509618e-01f, 6.63747370e-01f, -3.00822258e-01f, -3.91475081e-01f, 3.02357346e-01f,
  3.45939606e-01f, -1.23545371e-01f, 4.37429070e-01f, 1.11087793e-02f, -1.62077658e-02f, 2.07093805e-01f, 1.21367900e-02f, 1.92207679e-01f, -2.15153575e-01f, 1.99920386e-01f,
  -9.99295712e-02f, 3.53911161e-01f, 8.18962678e-02f, -6.44304976e-02f, 1.03317447e-01f, -3.10058355e-01f, 1.31738558e-01f, 1.93010211e-01f, -5.17362729e-02f, 1.30457589e-02f,
  1.91851556e-02f, 2.55502593e-02f, -2.43985076e-02f, 5.81960343e-02f, 6.51352853e-02f, 8.81318972e-02f, 1.09012380e-01f, 1.42954588e-01f, -8.68779793e-02f, 1.26844302e-01f,
  2.68787146e-02f, -1.07418396e-01f, -1.91156566e-01f, -1.31570995e-01f, -1.67739019e-01f, -2.77707964e-01f, -1.51702031e-01f, -1.53232096e-02f, -1.58629566e-01f, -4.47385833e-02f,
  6.70574382e-02f, 1.30824642e-02f, 1.35567011e-02f, -2.44540945e-02f, -1.91240124e-02f, 1.27320923e-02f, -5.59434034e-02f, 1.29697427e-01f, -1.15293078e-01f, -1.90223940e-02f,
  -9.69742090e-02f, 1.54880777e-01f, -3.16404812e-02f, -1.14267528e-01f, -2.43672021e-02f, -1.45565003e-01f, -1.12026623e-02f, -4.99069728e-02f, -5.85447550e-02f, 1.06641725e-01f,
  -6.80528730e-02f, -8.63932744e-02f, 5.06156981e-02f, 7.69492984e-02f, 6.69280514e-02f, -4.34163027e-02f, 1.96923658e-01f, 1.61952879e-02f, -1.16534047e-02f, -1.32663339e-01f,
  -5.26397936e-02f, 1.72884334e-02f, -3.40547264e-02f, 1.45356571e-02f, 3.33193615e-02f, 4.18926217e-02f, 3.34645063e-02f, 2.57214513e-02f, -1.40607711e-02f, 1.49100453e-01f,
  2.22937390e-02f, -1.22239180e-02f, -1.67423543e-02f, -7.24309087e-02f, -3.52263381e-03f, 6.92699999e-02f, 4.92324494e-03f, -2.13706553e-01f, 8.11385363e-03f, 2.97509748e-02f,
  -1.28993154e-01f, -9.41102579e-02f, -5.08631952e-02f, -7.95845315e-02f, -1.30170614e-01f, 1.85523964e-02f, 5.73389344e-02f, -9.05470923e-02f, -6.98436573e-02f, -3.60900685e-02f,
  6.04158342e-02f, 3.26113068e-02f, 8.74311849e-03f, -9.63014811e-02f, -9.57187116e-02f, 1.02255605e-01f, -1.29780546e-01f, -1.05014876e-01f, 5.72967529e-02f, -5.85497394e-02f,
  -6.70947552e-01f, -2.39803359e-01f, 1.52294695e-01f, -4.42276895e-01f, -3.37146133e-01f, 3.83132577e-01f, 2.89251179e-01f, -3.13756436e-01f, -4.27704185e-01f, -1.25715673e-01f,
  -4.14415030e-03f, -2.41902784e-01f, 4.17554379e-01f, -8.84046331e-02f, 6.10109150e-01f, 4.24360454e-01f, -7.61854136e-03f, 8.97502229e-02f, -1.76096722e-01f, -3.46193880e-01f,
  -1.60336033e-01f, -3.76821607e-01f, 4.00029629e-01f, -4.17281121e-01f, -2.83052653e-01f, -3.46136898e-01f, 4.16218080e-02f, 1.35536030e-01f, -1.54824629e-02f, 1.93061724e-01f,
  -2.41561979e-01f, -5.58619320e-01f, -1.31991625e-01f, -2.97963648e-04f, -7.62600154e-02f, 2.95787863e-02f, 5.40746972e-02f, 2.45258629e-01f, -1.06921885e-02f, 3.20116207e-02f,
  5.84644871e-03f, 2.29436941e-02f, -1.91597328e-01f, 6.14608340e-02f, -1.90824881e-01f, -9.48197693e-02f, 1.81535957e-04f, 7.94531778e-02f, -1.04503157e-02f, 8.78759995e-02f,
  1.70716215e-02f, 2.80810148e-02f, -4.13685944e-03f, 7.67899230e-02f, 3.38037424e-02f, -2.76383441e-02f, 8.31594095e-02f, 5.01467437e-02f, -2.66278256e-02f, -5.75908907e-02f,
  2.92500835e-02f, 3.73813473e-02f, -5.23900799e-02f, -2.23960914e-02f, -3.25985886e-02f, 7.73385307e-03f, 4.12920378e-02f, 1.03610694e-01f, 2.85341404e-02f, 6.73626587e-02f,
  -4.81834598e-02f, -9.24097523e-02f, -1.09748766e-01f, -2.55838148e-02f, -1.24328891e-02f, -1.40600512e-02f, -2.10990272e-02f, -1.69125050e-01f, -3.63978595e-02f, -6.89778328e-02f,
  -7.50023350e-02f, -7.33185839e-03f, 4.43696342e-02f, 8.26475024e-02f, 1.78914599e-03f, 1.46542087e-01f, -1.10365018e-01f, 2.66012140e-02f, -4.46812920e-02f, 6.90000355e-02f,
  -3.26932490e-01f, -4.32087034e-01f, -1.80703998e-01f, -1.12132110e-01f, -3.96372266e-02f, -5.22634462e-02f, -6.77248240e-02f, -8.99694189e-02f, -8.04886594e-02f, -1.53581798e-01f,
  -4.00398374e-02f, -1.48955323e-02f, -6.33039474e-02f, -2.26170048e-02f, 4.28839494e-03f, -3.79129052e-02f, 3.11753806e-02f, -5.02756871e-02f, -5.09597994e-02f, -9.20880362e-02f,
  -6.06282428e-02f, -8.28279480e-02f, 5.41582182e-02f, -1.09066866e-01f, -5.35927489e-02f, 1.13694817e-02f, -2.25516334e-01f, -7.84274563e-03f, 2.98168976e-02f, -1.96808279e-02f,
  9.53831300e-02f, 2.56499380e-01f, 8.99977535e-02f, 9.17521268e-02f, -1.98678091e-01f, -1.85684592e-01f, -2.12897778e-01f, -1.93350971e-01f, -2.60575175e-01f, 1.48118898e-01f,
  -2.20577791e-01f, 2.66169220e-01f, -3.95072609e-01f, -1.65176407e-01f, -4.13369328e-01f, -5.03771901e-01f, -2.53417008e-02f, -3.51346657e-03f, -1.72752827e-01f, 3.55938673e-01f,
  4.37664986e-02f, -1.47031605e-01f, -3.18796895e-02f, 2.08469126e-02f, 1.18086502e-01f, 4.30395186e-01f, 3.37002307e-01f, 1.98800559e-03f, 4.55722004e-01f, -1.03797607e-01f,
  -9.80958343e-02f, -4.55963099e-03f, 7.38810224e-04f, -1.45972027e-02f, 2.22883627e-01f, 7.85685554e-02f, 1.34284168e-01f, -8.58672187e-02f, -5.74315935e-02f, 4.11613956e-02f,
  1.10623114e-01f, -1.12958234e-02f, 6.79541081e-02f, -1.55390739e-01f, -2.67851893e-02f, 1.13169909e-01f, 7.39099830e-02f, 8.73603821e-02f, 9.21008922e-03f, -3.97418626e-03f,
  7.34712854e-02f, 1.70286924e-01f, 7.46675283e-02f, 1.33877128e-01f, 1.65307030e-01f, -1.62228644e-02f, 1.10069223e-01f, 2.17013776e-01f, 9.39266980e-02f, 1.81236088e-01f,
  3.32981870e-02f, 1.08953394e-01f, -1.00182258e-01f, -2.32820809e-01f, -1.72055643e-02f, -1.13394797e-01f, 4.49365452e-02f, 1.09197397e-03f, 2.41363905e-02f, 5.79805113e-02f,
  4.83614579e-02f, -1.65073350e-02f, -1.23442009e-01f, 2.19260454e-01f, 1.52420714e-01f, -1.06262259e-01f, -8.93158987e-02f, 7.51530081e-02f, 9.14254114e-02f, 1.80603075e-03f,
  -1.12787768e-01f, 7.91062564e-02f, 1.09794714e-01f, 2.07867641e-02f, -1.70284197e-01f, 1.44498333e-01f, 1.18521400e-01f, -3.36762778e-02f, 2.73011103e-02f, 3.19743454e-02f,
  1.72110453e-01f, 2.42297754e-01f, 6.71024919e-02f, -1.23301171e-01f, 1.12621514e-02f, 3.59035656e-02f, -2.53398865e-01f, 3.70919984e-03f, 1.01757415e-01f, -4.19349468e-04f,
  2.04917833e-01f, 1.52100027e-01f, 2.72329986e-01f, -6.94769770e-02f, -5.96242175e-02f, 1.20517813e-01f, 2.36562341e-02f, 1.55251712e-01f, 1.30555525e-01f, 1.73377737e-01f,
  1.77057937e-01f, 3.28564756e-02f, 9.02569741e-02f, 6.55154511e-02f, 1.39996856e-01f, 1.20443605e-01f, 7.45084435e-02f, 7.12952688e-02f, 7.44191930e-02f, 9.44745839e-02f,
  -2.11366355e-01f, 3.86165917e-01f, 4.69440728e-01f, -3.85962069e-01f, 1.24635667e-01f, 2.79401928e-01f, -2.03356192e-01f, 1.10109430e-02f, -2.73818165e-01f, -8.70054960e-02f,
  -2.53903180e-01f, 2.33432069e-01f, 4.07301784e-02f, -6.64304793e-02f, 2.90888920e-02f, -8.91389623e-02f, -1.44397214e-01f, 1.19737014e-02f, 2.50100881e-01f, -7.72552341e-02f,
  -9.94539484e-02f, -3.17871630e-01f, 2.41471484e-01f, -1.01151027e-01f, 9.58590582e-02f, -1.28754694e-02f, -2.06539303e-01f, 6.84182942e-02f, -7.32712597e-02f, -4.79367524e-02f,
  1.11383907e-01f, -2.32628241e-01f, 2.39540800e-01f, 1.74935848e-01f, -1.92357246e-02f, 5.84717430e-02f, 9.82655361e-02f, -1.52295213e-02f, -1.03849426e-01f, 5.89888878e-02f,
  6.73914924e-02f, 5.10311313e-03f, -7.73887858e-02f, 3.10838111e-02f, 8.97458270e-02f, 5.79794198e-02f, 2.35589400e-01f, 2.17627823e-01f, 1.13205560e-01f, 2.06910074e-01f,
  2.67841578e-01f, 2.53782809e-01f, 1.30950302e-01f, -3.67842428e-02f, -8.92785937e-02f, 2.99238809e-03f, -1.63646877e-01f, 1.84591562e-02f, -2.73628794e-02f, 1.07420452e-01f,
  -3.61991376e-02f, -6.16595782e-02f, 7.00770244e-02f, 1.34086059e-02f, -2.84396466e-02f, -1.13559179e-01f, -4.17302735e-03f, -1.34469278e-03f, -8.80330876e-02f, 5.31724319e-02f,
  -1.22371875e-01f, 1.04369603e-01f, -1.19843125e-01f, -8.07996690e-02f, -3.88947427e-02f, -6.61255717e-02f, 1.16774417e-01f, -2.26199236e-02f, 3.33634540e-02f, -1.10041760e-01f,
  -5.62136658e-02f, 2.84759067e-02f, -8.17986578e-02f, -4.06937078e-02f, 3.54271494e-02f, 1.83539093e-01f, -4.30006273e-02f, 5.16364761e-02f, 8.03779066e-02f, -3.50771435e-02f,
  -1.35538369e-01f, -3.87013406e-01f, -5.14477417e-02f, -1.49524221e-02f, 3.35727148e-02f, 1.49787530e-01f, 5.49194925e-02f, 8.56714919e-02f, -4.18740511e-02f, -1.01881750e-01f,
  1.62945688e-02f, -7.72803649e-02f, 3.18583250e-02f, -8.18743408e-02f, 6.40961528e-02f, 3.62273827e-02f, -3.32772806e-02f, -1.01404227e-01f, 4.89331819e-02f, -1.39996678e-01f,
  -5.29548377e-02f, 2.67450176e-02f, -1.07195944e-01f, -6.23753853e-02f, -8.47117603e-02f, -7.75529370e-02f, -1.31138176e-01f, -7.46894395e-03f, 8.00989103e-03f, 6.36495277e-02f,
  -7.79996753e-01f, 4.42362845e-01f, -1.14432462e-01f, 3.17725912e-02f, -2.82400310e-01f, -1.96152583e-01f, 2.85600096e-01f, -9.76289064e-02f, 1.34361625e-01f, 3.39914173e-01f,
  2.78499246e-01f, -3.62217166e-02f, 3.30963492e-01f, 3.07420045e-01f, -4.53686684e-01f, 3.29470158e-01f, -1.27926186e-01f, 1.10340737e-01f, -1.46572098e-01f, -1.73998266e-01f,
  -1.64788589e-01f, 9.87594388e-03f, -1.07155912e-01f, 8.50535259e-02f, -2.24178523e-01f, -1.35566771e-01f, -2.84587085e-01f, 6.75040483e-02f, -9.47665870e-02f, -1.41060501e-01f,
  -4.02124971e-01f, -1.53414071e-01f, -4.77449037e-02f, -1.05609089e-01f, -1.80575579e-01f, -2.82442272e-02f, -7.99515694e-02f, 1.00953311e-01f, -2.31236424e-02f, -9.34217274e-02f,
  -1.12356298e-01f, 1.63372681e-02f, 1.97824929e-02f, 1.01005465e-01f, -6.96627870e-02f, 6.83697835e-02f, -5.71836792e-02f, -3.10382396e-02f, 6.84798583e-02f, -7.71728829e-02f,
  1.03714138e-01f, -4.99109440e-02f, -9.96495504e-03f, -4.96504493e-02f, -1.40816733e-01f, -3.65561768e-02f, 7.06207827e-02f, -1.08163066e-01f, -4.05914672e-02f, -1.24315135e-01f,
  -1.41997654e-02f, -3.61399129e-02f, 1.64168298e-01f, 2.69540250e-02f, -1.79149844e-02f, 3.78958397e-02f, 9.04575363e-03f, 4.72584851e-02f, 8.32101554e-02f, -9.74867865e-02f,
  -6.20696470e-02f, -3.95416208e-02f, -5.32174930e-02f, -2.63537318e-02f, 2.13330556e-02f, 1.78737156e-02f, -8.84389225e-03f, -1.93960909e-02f, -3.94868329e-02f, -7.53889158e-02f,
  1.82630885e-02f, -3.19028944e-02f, 3.74679640e-02f, 2.89853550e-02f, -7.26474971e-02f, 2.53239297e-04f, -5.08079305e-02f, 1.08558051e-02f, -3.98317017e-02f, -1.53683215e-01f,
  -5.62024772e-01f, -4.27913040e-01f, -2.47312877e-02f, -6.14590831e-02f, -5.46656607e-04f, -1.09278699e-02f, -6.34188112e-03f, -5.11233509e-02f, -1.19569749e-01f, 9.24753956e-03f,
  1.18211871e-02f, 6.78917766e-02f, -9.61066261e-02f, -6.30725250e-02f, -4.99878731e-03f, -6.43464848e-02f, 1.88154746e-02f, 9.32872202e-03f, -1.27648577e-01f, -6.41929358e-02f,
  5.19692041e-02f, 5.01840413e-02f, -1.55688571e-02f, -5.11563122e-02f, -2.83494173e-03f, -4.57087122e-02f, -6.76501989e-02f, 1.03931054e-01f, -1.67041376e-01f, 1.22372515e-01f,
  5.59258580e-01f, 3.45695205e-02f, 4.69117135e-01f, 6.19305670e-01f, -2.47871563e-01f, -1.35330051e-01f, 1.42929435e-01f, -2.19965503e-01f, 5.01828730e-01f, -3.74704301e-01f,
  -3.58377755e-01f, 5.11450171e-01f, 2.01888159e-02f, -1.73357308e-01f, 3.87346625e-01f, 7.65238255e-02f, 1.14654340e-01f, 6.56618550e-02f, 1.01160064e-01f, 1.75665900e-01f,
  2.23130196e-01f, -4.11256731e-01f, 5.42998835e-02f, -3.72716993e-01f, -6.65467605e-02f, 1.21259481e-01f, -1.77557305e-01f, -1.35916919e-01f, -3.41675162e-01f, -1.88303560e-01f,
  -4.11780536e-01f, 1.10784750e-02f, 4.66271713e-02f, -7.91969597e-02f, -1.85811505e-01f, -7.63214231e-02f, 1.48357987e-01f, 4.38027382e-02f, -1.08444236e-01f, 1.16158342e-02f,
  1.63717672e-01f, 5.60519136e-02f, -6.09694459e-02f, 5.38730919e-02f, -1.07286446e-01f, 4.40768339e-02f, -5.71484342e-02f, -2.56899148e-02f, 2.04472113e-02f, -2.02493463e-02f,
  1.14407927e-01f, -6.52936101e-02f, -1.08657070e-01f, -6.58019185e-02f, 2.36735210e-01f, -3.39671969e-02f, -3.42362002e-02f, 7.07333013e-02f, 3.93838659e-02f, -2.98330374e-02f,
  -2.06089346e-03f, 1.94838524e-01f, -6.21925369e-02f, -1.34644046e-01f, -1.02862217e-01f, -8.79113451e-02f, 1.75221078e-02f, -1.03113435e-01f, 5.41654192e-02f, 3.43454815e-02f,
  -3.88708152e-02f, -8.06746352e-03f, 4.85596694e-02f, -9.55318660e-02f, -3.60271819e-02f, 7.65244812e-02f, -2.55218185e-02f, -1.06769450e-01f, -3.92955095e-02f, 7.49945268e-02f,
  8.27610195e-02f, -1.35552213e-02f, 9.59472172e-03f, -1.79211423e-02f, -5.61034195e-02f, -1.51014766e-02f, -3.61434892e-02f, 1.40663758e-02f, 1.32248282e-01f, 1.27600312e-01f,
  -1.78569034e-01f, 1.58912793e-01f, 1.35277696e-02f, -3.86323296e-02f, 8.76154825e-02f, -6.30788272e-03f, 1.00667914e-02f, -5.84036484e-02f, 1.92784388e-02f, 1.06981486e-01f,
  -5.22228666e-02f, -3.11385770e-03f, 2.88613699e-02f, -1.37017788e-02f, -5.82947433e-02f, -7.30285654e-03f, 6.01093434e-02f, -1.44022241e-01f, -6.05365485e-02f, -4.98883501e-02f,
  7.02463910e-02f, -3.27985547e-02f, -1.08946957e-01f, -8.20782781e-02f, -2.78466176e-02f, -8.87041911e-02f, 1.78739160e-01f, -6.32609278e-02f, 1.55558495e-03f, 2.36343667e-02f,
  -4.18402433e-01f, 1.27843261e-01f, 5.36463439e-01f, -6.26655638e-01f, 1.86420381e-01f, 2.64834434e-01f, 1.15571089e-01f, -1.88981026e-01f, -3.72586966e-01f, -3.01594406e-01f,
  -2.27703616e-01f, 3.17015409e-01f, 3.42189431e-01f, -3.79929483e-01f, -6.47934005e-02f, -4.66825143e-02f, -4.40114439e-01f, -1.81326196e-01f, 5.20311520e-02f, -4.15861122e-02f,
  -1.25067726e-01f, -2.29424700e-01f, 1.08395189e-01f, -1.15740970e-01f, 7.50586018e-02f, 7.88927358e-03f, -2.59831190e-01f, 3.81623924e-01f, -1.65213183e-01f, 1.52996838e-01f,
  -3.04983370e-02f, -3.40996027e-01f, 7.84248710e-02f, -3.77393030e-02f, -1.33406490e-01f, 1.23235166e-01f, 3.16995718e-02f, 1.57019705e-01f, -8.27244893e-02f, 2.61361655e-02f,
  7.37299621e-02f, 9.02679265e-02f, -1.27353966e-01f, 2.19976213e-02f, -7.65559450e-02f, -7.31953532e-02f, 7.57919028e-02f, 5.26561253e-02f, 6.44345880e-02f, 1.09452024e-01f,
  7.20570311e-02f, 7.99728632e-02f, 1.06625147e-02f, -6.68668300e-02f, 1.16209559e-01f, 1.19163767e-01f, -1.75269116e-02f, 1.20567240e-01f, 9.19080377e-02f, -1.21539235e-01f,
  -1.39550686e-01f, 2.66642217e-02f, 8.70562270e-02f, 5.08600175e-02f, 4.88312691e-02f, 7.45530203e-02f, 2.56339367e-03f, -1.28873056e-02f, 6.70157024e-04f, 5.37059791e-02f,
  -2.62664887e-03f, 1.79856196e-02f, -3.39413956e-02f, -1.20680831e-01f, -1.80365462e-02f, -8.18402842e-02f, 1.87661633e-01f, -2.69292928e-02f, -8.29729959e-02f, 7.98035190e-02f,
  -5.05735725e-02f, 7.82944169e-03f, -7.36448988e-02f, -6.39047846e-02f, -3.33636217e-02f, 1.11947253e-01f, 2.67748255e-02f, 5.63352928e-02f, -8.62044692e-02f, 1.33797362e-01f,
  -3.24356288e-01f, -5.08192301e-01f, -6.45987764e-02f, -2.96506975e-02f, -5.21949120e-02f, -1.07457019e-01f, -6.52742460e-02f, -6.13691919e-02f, -3.32420804e-02f, -5.86922877e-02f,
  -1.16520151e-01f, -1.35024264e-01f, 5.07324412e-02f, 7.67270923e-02f, -2.95888837e-02f, 1.68691780e-02f, -1.19177982e-01f, 1.31284734e-02f, -4.75759953e-02f, -4.00672145e-02f,
  3.04852910e-02f, -4.78289761e-02f, 2.05512717e-02f, -1.33773223e-01f, -1.51703879e-01f, -2.29498371e-03f, -4.37305309e-02f, 9.15863924e-03f, -3.27609181e-02f, -9.53114182e-02f,
  1.30018234e-01f, 5.02060354e-01f, 4.57023233e-01f, -1.19691141e-01f, -3.11966568e-01f, 1.67653352e-01f, 8.08469206e-02f, 3.51203457e-02f, -6.82865381e-02f, 2.22330794e-01f,
  -3.23583037e-01f, 3.66374791e-01f, -1.57286972e-02f, -1.97437435e-01f, 9.50513482e-02f, 9.71977562e-02f, -1.18279085e-01f, -8.67661610e-02f, -8.20453465e-02f, 1.03375383e-01f,
  -5.98993190e-02f, -4.61236537e-01f, -7.01470813e-03f, -2.34928161e-01f, -7.54289422e-03f, 4.06979620e-02f, -4.64636415e-01f, -1.27531886e-01f, -1.63777500e-01f, -1.96000021e-02f,
  -6.42751157e-02f, -3.70839126e-02f, 2.44795263e-01f, 2.74878085e-01f, -4.27872390e-02f, 5.54650612e-02f, -3.31805795e-02f, 5.56790344e-02f, -1.65854573e-01f, 4.92607541e-02f,
  7.09950626e-02f, 3.34556587e-02f, -1.08461594e-02f, -2.56444607e-02f, -1.07498914e-01f, -7.73845091e-02f, 1.71795394e-02f, 1.22507282e-01f, 5.89744672e-02f, 5.76959327e-02f,
  2.17559487e-01f, 1.70704931e-01f, -1.57939106e-01f, 1.32203475e-01f, -2.18779966e-02f, -5.99760897e-02f, 2.19757110e-01f, 2.99834341e-01f, 1.24447927e-01f, -1.61090009e-02f,
  -1.18885666e-01f, -1.12712279e-01f, 4.07141410e-02f, -1.60615705e-02f, -1.81401402e-01f, -1.62845299e-01f, -2.45392267e-02f, -1.25004917e-01f, -1.04194516e-02f, -7.50971287e-02f,
  1.06089629e-01f, 1.38770297e-01f, -1.69495538e-01f, 4.38696370e-02f, -1.90151900e-01f, 2.02911571e-01f, -5.29019488e-03f, 5.65149672e-02f, 1.30789846e-01f, 8.75055790e-03f,
  -7.90197328e-02f, -9.66437384e-02f, -6.61274642e-02f, -6.16951101e-02f, 4.70607840e-02f, -8.87904167e-02f, -8.03138968e-03f, 8.85287523e-02f, -2.00046420e-01f, -4.84478511e-02f,
  1.45709574e-01f, 5.90997450e-02f, 6.57288134e-02f, 1.41147643e-01f, 4.60522659e-02f, 3.61407772e-02f, 1.66308018e-04f, 6.14646226e-02f, 3.69819254e-02f, 7.58121312e-02f,
  -2.37489656e-01f, 1.28296286e-01f, 5.55427335e-02f, -2.93341149e-02f, 6.35900348e-02f, 3.40563338e-03f, -8.35060850e-02f, -1.55398175e-01f, 9.71469935e-03f, -5.13012521e-02f,
  5.35439746e-03f, -1.04319096e-01f, 5.41807562e-02f, -1.20964006e-01f, 1.76315814e-01f, -6.53289035e-02f, 2.27454200e-01f, 1.80931285e-01f, -9.46192595e-04f, -1.37076499e-02f,
  -4.49870601e-02f, 4.34148520e-01f, 3.00583690e-01f, -6.99642450e-02f, -5.09983003e-01f, -7.60164186e-02f, -1.87618494e-01f, 1.18024237e-01f, 4.66244668e-01f, 5.05270110e-03f,
  -1.63685426e-01f, 5.58000840e-02f, 1.39188722e-01f, -1.35074332e-01f, 2.50813365e-01f, 4.24169272e-01f, 9.35731679e-02f, -1.22464918e-01f, 1.58686250e-01f, -1.68829843e-01f,
  -2.70169973e-02f, -5.66074967e-01f, -1.61515892e-01f, -3.28212380e-01f, -2.33857855e-01f, 2.27144044e-02f, -3.91987234e-01f, -2.91657597e-01f, -1.90643251e-01f, -2.43071709e-02f,
  1.13494910e-01f, 1.72306359e-01f, 1.23851538e-01f, 2.08869085e-01f, 1.31000102e-01f, -1.03759207e-01f, -8.43569040e-02f, -1.15089826e-01f, 1.40191674e-01f, 1.95903823e-01f,
  3.64993303e-03f, -6.43552914e-02f, 5.06483242e-02f, -1.45768389e-01f, -3.36550623e-02f, 5.92241958e-02f, 4.69590425e-02f, 1.18764617e-01f, 2.82285027e-02f, -7.90837258e-02f,
  -1.77590083e-02f, 7.64721781e-02f, -1.18586831e-01f, 8.98890048e-02f, 1.29535139e-01f, 1.60226062e-01f, -4.86096181e-02f, -5.62190711e-02f, 1.65737551e-02f, 1.22247912e-01f,
  -3.60579491e-02f, -4.27665114e-02f, -1.06916435e-01f, -1.03656333e-02f, -5.49408197e-02f, 3.27033512e-02f, -1.36857048e-01f, -1.74652159e-01f, 3.63520533e-02f, -8.21209922e-02f,
  1.41368017e-01f, 8.47609341e-02f, -4.95315753e-02f, 4.45696488e-02f, -4.80497368e-02f, 1.06011070e-01f, -7.09702671e-02f, 1.81190148e-01f, 1.02450430e-01f, 4.47606593e-02f,
  -1.34358972e-01f, -8.99949372e-02f, 3.95139679e-02f, -9.49552208e-02f, -1.19965345e-01f, -4.44798209e-02f, -1.52438685e-01f, -2.11171806e-02f, -2.06723399e-02f, -1.73955381e-01f,
  3.39363277e-01f, 2.80447394e-01f, 1.17550373e-01f, 1.34683549e-01f, 3.86559106e-02f, -1.21724568e-01f, -1.34214506e-01f, 3.98009755e-02f, 1.13718972e-01f, -6.95861131e-02f,
  -4.46464717e-02f, -1.76041611e-02f, -7.51547096e-03f, -2.62856781e-02f, -2.45059896e-02f, 1.05601074e-02f, -4.87492159e-02f, 1.64184615e-01f, -9.78713930e-02f, 5.58633097e-02f,
  -1.61623359e-01f, -1.42337874e-01f, 9.26470906e-02f, -3.00331730e-02f, 1.39559597e-01f, 9.04053226e-02f, -1.05390966e-01f, 2.36898363e-01f, -7.51002133e-02f, -5.19558694e-03f,
  -2.59915799e-01f, 3.24807853e-01f, 3.70618969e-01f, -7.19524641e-03f, -1.65298060e-01f, -3.70606154e-01f, -3.40740502e-01f, 2.71430343e-01f, -1.85338348e-01f, 1.74320146e-01f,
  -3.21048871e-02f, 5.21429488e-03f, 8.43440816e-02f, -2.47487411e-01f, -1.94606036e-01f, -4.19186860e-01f, -1.10522047e-01f, -3.29228342e-02f, -1.78198591e-01f, 4.03196007e-01f,
  1.75270721e-01f, -2.57374704e-01f, 2.65432686e-01f, 1.89392760e-01f, 2.40823641e-01f, 2.73683637e-01f, 2.69750893e-01f, 2.40796775e-01f, 2.25468218e-01f, -2.22749203e-01f,
  -1.21252313e-01f, -1.40941516e-02f, 2.07896471e-01f, -1.09886296e-01f, 2.08180159e-01f, 8.76304954e-02f, 5.15681244e-02f, -7.91568756e-02f, 2.52261274e-02f, -1.46786496e-02f,
  -6.00251928e-02f, 4.07563336e-02f, -5.09699360e-02f, -6.53268993e-02f, -1.10398442e-01f, -1.02237212e-02f, 6.32448262e-03f, 7.68884793e-02f, 3.76968049e-02f, 3.45948674e-02f,
  1.23824313e-01f, -1.43182371e-02f, 8.44112560e-02f, -6.69857860e-02f, 1.07755372e-03f, -6.27493262e-02f, 1.11607350e-02f, 2.35485762e-01f, -1.41221985e-01f, 2.96733137e-02f,
  6.93677962e-02f, -9.77774188e-02f, -1.10361733e-01f, -1.26910275e-02f, -8.75975937e-02f, -1.05821624e-01f, -1.06093422e-01f, -5.69892637e-02f, -1.14391255e-03f, -6.07306696e-02f,
  -1.09191164e-02f, 1.45030525e-02f, -1.50872841e-01f, -3.86533216e-02f, 3.68192121e-02f, -1.72577709e-01f, -7.18402937e-02f, 1.42477259e-01f, 1.46511674e-01f, 4.48344238e-02f,
  -5.10696657e-02f, -9.09475312e-02f, -3.51260565e-02f, -1.10450760e-02f, -1.91170335e-01f, 7.13184625e-02f, 3.14971507e-02f, -2.30327086e-03f, -4.68537100e-02f, 1.25693351e-01f,
  1.63780108e-01f, 3.57981265e-01f, 3.18014286e-02f, -1.75618485e-01f, -8.55539814e-02f, -2.33705482e-03f, -7.75325447e-02f, 2.58123036e-02f, 3.33267078e-02f, -2.48154309e-02f,
  1.14630543e-01f, -9.34606139e-03f, 1.32868802e-02f, -1.40009642e-01f, 2.60323696e-02f, 6.93343729e-02f, 9.31286886e-02f, 3.23004164e-02f, 1.39982238e-01f, 1.42917886e-01f,
  2.20448643e-01f, 5.06670326e-02f, -4.98550199e-02f, -6.57250360e-02f, 6.28676191e-02f, 3.68016772e-02f, 4.38506231e-02f, 6.93294704e-02f, 2.92416848e-02f, -2.15940475e-02f,
  -2.02353716e-01f, -3.62158716e-01f, -1.15833156e-01f, -1.00297287e-01f, 3.31288904e-01f, -5.14369570e-02f, -5.71680307e-01f, 2.74575144e-01f, 6.05767965e-02f, -5.06445050e-01f,
  -2.50034213e-01f, -1.71981797e-01f, -5.31865180e-01f, 5.58386557e-02f, 2.41665110e-01f, -2.11295951e-02f, 2.09040031e-01f, -1.15092196e-01f, 3.64959478e-01f, -1.17910318e-01f,
  2.93448955e-01f, 8.52859393e-02f, 6.52139932e-02f, 2.79301375e-01f, 2.16558371e-02f, 9.21567678e-02f, -1.16075441e-01f, -2.66106054e-02f, -6.09060712e-02f, 1.03190772e-01f,
  -2.36535653e-01f, -2.13742107e-01f, -1.59325212e-01f, 1.65870190e-02f, -7.64709339e-02f, -2.18098104e-01f, -1.38850838e-01f, -8.04028511e-02f, -4.66374867e-02f, 1.32080801e-02f,
  -2.51967847e-01f, 2.18400285e-01f, 6.40095100e-02f, -4.94405441e-02f, 2.38933135e-03f, 1.70937315e-01f, 5.82664311e-02f, -2.96651423e-02f, 7.21869916e-02f, 1.42263204e-01f,
  2.40845308e-02f, 1.56328186e-01f, 9.45476517e-02f, 8.87306631e-02f, 8.55030417e-02f, 1.38665929e-01f, 1.22817315e-01f, -9.20454711e-02f, 5.53194061e-02f, 2.83440426e-02f,
  5.31284213e-02f, -7.03404322e-02f, -9.66337696e-02f, -6.56870976e-02f, -1.85853571e-01f, -6.61221892e-02f, -9.04758498e-02f, -3.29793878e-02f, -1.75591055e-02f, 2.36491840e-02f,
  8.36842656e-02f, -3.77823077e-02f, 2.66302198e-01f, -8.05349462e-03f, -3.01144756e-02f, -5.45353331e-02f, -8.33331868e-02f, -3.26716043e-02f, 1.37442335e-01f, -4.60696816e-02f,
  -5.83298914e-02f, 1.18528686e-01f, 4.78062145e-02f, 4.26783748e-02f, -2.46668160e-02f, 3.13053541e-02f, 3.38684320e-02f, 2.16919944e-01f, -1.62000153e-02f, 4.02719863e-02f,
  -8.33490491e-01f, -5.18264174e-01f, -2.00914651e-01f, -4.91009206e-02f, -1.42644897e-01f, -7.20421076e-02f, -2.58799996e-02f, 1.95885718e-01f, -1.04769632e-01f, 1.99454818e-02f,
  -5.38554154e-02f, -8.87146890e-02f, 7.64798606e-03f, 1.35076925e-01f, -8.08546767e-02f, 2.33887359e-02f, -2.47935995e-01f, -1.30709708e-01f, -2.63464093e-01f, 6.29420429e-02f,
  -9.75835249e-02f, 1.03592612e-02f, -3.42429765e-02f, 1.27637371e-01f, -5.39395679e-03f, -4.09676284e-02f, -1.97768491e-02f, 5.80226518e-02f, 1.52547702e-01f, -4.96641025e-02f,
  3.19253147e-01f, 1.09019548e-01f, -4.37843651e-01f, -2.05202729e-01f, 7.08509460e-02f, 4.16918039e-01f, 2.18650728e-01f, 2.34038174e-01f, -1.72594730e-02f, 2.66003489e-01f,
  2.52388865e-01f, -4.47207950e-02f, -1.40348718e-01f, 3.15076917e-01f, 2.59297401e-01f, 5.37519827e-02f, 2.61772931e-01f, 1.96290195e-01f, 1.85571760e-02f, 2.28757620e-01f,
  1.93163082e-01f, 3.37363660e-01f, -3.47286075e-01f, 1.59502178e-01f, 3.79835129e-01f, -2.09524006e-01f, -2.93895751e-01f, -3.84508789e-01f, -5.32391369e-02f, 1.35681868e-01f,
  3.36452387e-02f, 4.03208099e-02f, -7.99287669e-03f, -8.57795123e-03f, -4.06948738e-02f, 8.50195717e-03f, -8.70406162e-04f, -1.36856169e-01f, -1.25219643e-01f, -1.00411158e-02f,
  4.56998637e-03f, -1.45351529e-01f, 1.48077920e-01f, -1.86328068e-02f, 1.43309729e-02f, -1.08976707e-01f, -6.35318132e-03f, 1.69126056e-02f, -1.26829833e-01f, 7.75526837e-02f,
  -1.04683056e-01f, -1.02313414e-01f, -3.45187075e-02f, -2.85175219e-02f, -1.43808737e-01f, -2.72975154e-02f, -1.41398966e-01f, -7.35038742e-02f, 2.25949785e-04f, 5.69387376e-02f,
  1.91170618e-01f, -3.74330357e-02f, 4.55033332e-02f, 5.12225181e-03f, 6.62915483e-02f, 3.63661386e-02f, -9.34122428e-02f, -3.11959926e-02f, 4.70089354e-02f, -4.72955732e-03f,
  1.44655667e-02f, -5.01172282e-02f, 4.59475480e-02f, 7.87052419e-03f, 1.06782682e-01f, -7.78932273e-02f, -4.16391045e-02f, 4.01933305e-02f, -1.22979291e-01f, -5.26840538e-02f,
  -7.73649290e-02f, 7.37331286e-02f, 5.53108975e-02f, -1.75219483e-03f, -6.60371482e-02f, 3.70459370e-02f, 1.88169777e-01f, 8.36052150e-02f, -5.14516830e-02f, -1.27444370e-02f,
  6.34377673e-02f, 2.20576093e-01f, 2.35788468e-02f, -2.18490642e-02f, -3.82814147e-02f, 2.16874003e-01f, 7.67101496e-02f, 1.39390424e-01f, -3.66398506e-02f, 1.28544956e-01f,
  4.25628349e-02f, -1.11993410e-01f, 1.40516251e-01f, -3.82377319e-02f, -1.78165913e-01f, 2.14264914e-01f, 7.44929723e-03f, -1.35970607e-01f, -4.94276248e-02f, 4.98333201e-02f,
  -2.89698299e-02f, 1.01543061e-01f, -6.36574440e-03f, -1.25787526e-01f, 9.02073607e-02f, -7.89898559e-02f, 1.79847196e-01f, -2.15863302e-01f, 9.84052494e-02f, -8.79706070e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.62805808e-01f, 2.51278341e-01f, 3.56166512e-01f, 4.76205260e-01f, 5.01830697e-01f, 3.87807637e-01f, 3.17739338e-01f, 4.90460545e-01f, 4.11682934e-01f, 2.25806355e-01f,
  5.70486367e-01f, 3.83194447e-01f, 5.29576600e-01f, 2.74195075e-01f, 1.69001773e-01f, 3.60032499e-01f, 4.18775380e-01f, 4.48963851e-01f, 3.39249223e-01f, 2.44847059e-01f,
  4.85782564e-01f, 3.56354535e-01f, 5.14493644e-01f, 4.87995923e-01f, 5.26962161e-01f, 5.03915846e-01f, 6.01647675e-01f, 1.35021567e-01f, 4.17357683e-01f, 5.13727725e-01f,
  3.84430796e-01f, 5.06396949e-01f, 4.83052790e-01f, 4.72141474e-01f, 4.18498576e-01f, 3.99174839e-01f, 3.73421580e-01f, 5.06330848e-01f, 4.66262549e-01f, 3.60632211e-01f,
  4.83865350e-01f, 4.33951229e-01f, 5.29589951e-01f, 3.25983822e-01f, 2.16689274e-01f, 6.64837360e-01f, 4.95256841e-01f, 4.84476775e-01f, 3.43838662e-01f, 5.00434875e-01f,
  3.07623267e-01f, 2.27232412e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.16812870e-01f, 6.02279939e-02f, -1.92087993e-01f, 5.28840395e-03f, -2.25051165e-01f, 1.23675250e-01f, -1.20894797e-01f, -4.39490318e-01f, 1.28884733e-01f, 5.71734130e-01f,
  1.44450262e-01f, -1.05295293e-01f, 3.08355778e-01f, -5.35302401e-01f, 7.57607073e-02f, 2.85893798e-01f, 3.55922461e-01f, -5.33633471e-01f, 2.73116767e-01f, -5.18208027e-01f,
  -2.79871941e-01f, -1.14383452e-01f, -5.76309204e-01f, 2.81371385e-01f, 1.84842795e-01f, -3.53350351e-03f, -5.01672864e-01f, -2.15330303e-01f, -5.58439493e-01f, -1.62770420e-01f,
  -3.99284884e-02f, 4.30373549e-01f, 1.22084960e-01f, -2.13563815e-01f, 9.92621034e-02f, 2.93950796e-01f, -5.94092548e-01f, -4.32081699e-01f, 4.21485841e-01f, 2.05051526e-01f,
  -5.37052095e-01f, -7.25818336e-01f, -3.09757978e-01f, 3.80082339e-01f, -6.84088051e-01f, 5.18322349e-01f, -4.98711258e-01f, 2.47974232e-01f, -1.44976929e-01f, -4.40391839e-01f,
  -3.87081385e-01f, -3.72900486e-01f, 4.29087788e-01f, 3.94064337e-01f, -2.12628171e-01f, -1.78800657e-01f, 4.77442473e-01f, -4.70405132e-01f, -5.82125604e-01f, -1.84303448e-01f,
  -1.13066984e-02f, -3.40671062e-01f, -3.67883146e-01f, -1.88344747e-01f, 2.32128009e-01f, -2.71948576e-01f, 8.60459283e-02f, -3.49415928e-01f, 9.79221836e-02f, -9.45617557e-02f,
  1.31127879e-01f, -3.79229069e-01f, 3.38873804e-01f, -5.59199333e-01f, 3.27035218e-01f, 4.74757135e-01f, 5.68625748e-01f, 1.47451103e-01f, 3.52028728e-01f, -3.99799079e-01f,
  -4.54619497e-01f, 1.42481044e-01f, -4.93904084e-01f, -8.11903104e-02f, -3.92616391e-01f, 1.22970000e-01f, 2.37605035e-01f, -4.15335894e-01f, -4.52771813e-01f, 2.23947093e-01f,
  -5.72975516e-01f, 2.98721433e-01f, 2.81871885e-01f, -2.60542691e-01f, -4.22299087e-01f, 2.95151353e-01f, -7.64762938e-01f, -2.90069878e-01f, -7.54436851e-01f, 2.97618151e-01f,
  -1.64212380e-02f, -4.44690883e-01f, 4.12542045e-01f, -5.82844257e-01f, -2.58663893e-01f, -2.76627451e-01f, 1.69637084e-01f, -4.60383371e-02f, -7.59588003e-01f, 3.10313791e-01f,
  4.61454719e-01f, 5.26030540e-01f, -3.53461713e-01f, 4.95918334e-01f, 7.51710162e-02f, -1.86913833e-01f, 3.68295670e-01f, -3.59925359e-01f, -1.83708131e-01f, -1.17831409e-01f,
  -5.93917072e-01f, -8.41529191e-01f, -4.01678294e-01f, -2.96368927e-01f, -5.52012384e-01f, -3.56707126e-01f, -3.22896123e-01f, 5.34318984e-01f, -1.56401679e-01f, -4.54451650e-01f,
  1.51837086e-02f, -3.04958522e-01f, 2.07829755e-02f, 1.24733783e-02f, 2.76183069e-01f, -2.03160942e-01f, -3.55403453e-01f, -1.12493888e-01f, -7.43686482e-02f, -3.22617084e-01f,
  -6.30741477e-01f, 9.62352306e-02f, -8.87710899e-02f, -2.59638578e-01f, 2.86004126e-01f, -6.15173817e-01f, -2.11160541e-01f, 3.61561060e-01f, -3.28752756e-01f, -1.51107877e-01f,
  -1.41172394e-01f, -3.53338361e-01f, -8.94008279e-02f, 5.55248857e-01f, 3.52035314e-01f, 2.68827558e-01f, 5.18736541e-01f, 1.61158890e-01f, 4.06879872e-01f, -2.33756319e-01f,
  -4.17118728e-01f, 4.23720121e-01f, -3.35608125e-01f, -2.45675102e-01f, -1.63399205e-01f, -6.14814818e-01f, -8.98905993e-02f, -2.16197968e-01f, 7.13217333e-02f, -2.90748745e-01f,
  -3.18074137e-01f, -8.31458718e-02f, -3.69264394e-01f, -4.12431389e-01f, 1.91702932e-01f, -8.08199570e-02f, 1.43820494e-01f, 3.32240224e-01f, -4.50394988e-01f, -5.79608023e-01f,
  -6.25053942e-01f, -4.61639725e-02f, -5.47207482e-02f, -4.06461954e-01f, -2.63024986e-01f, -4.46099311e-01f, -3.19743127e-01f, -4.07649636e-01f, -2.56765723e-01f, -4.63442951e-01f,
  4.56027091e-01f, -1.44080594e-01f, -4.31959182e-02f, -2.61433631e-01f, 2.34490819e-02f, -4.12505090e-01f, -1.38499364e-01f, -2.67854840e-01f, -4.71794635e-01f, 3.25705677e-01f,
  1.78371817e-01f, 1.55082569e-01f, -6.66503310e-02f, 4.93981928e-01f, 3.67949396e-01f, -2.54121184e-01f, -2.57686526e-01f, 5.75209796e-01f, -4.57013160e-01f, -4.64191198e-01f,
  3.75976562e-01f, -5.81525445e-01f, 3.92258704e-01f, -3.28778714e-01f, 1.22343734e-01f, 4.06354755e-01f, 4.62050617e-01f, -4.78578776e-01f, -1.34805560e-01f, -3.05881202e-01f,
  -8.80832151e-02f, -6.13370359e-01f, -2.68682420e-01f, -2.62227893e-01f, -1.52450457e-01f, -6.40296102e-01f, 2.94694930e-01f, -2.72706091e-01f, 1.45967290e-01f, 6.12158142e-02f,
  -7.18811274e-01f, 4.76552784e-01f, 3.20221901e-01f, 1.52031183e-02f, -1.13740698e-01f, -5.89325368e-01f, -1.77345499e-01f, -5.53935409e-01f, -3.39365214e-01f, -9.55522954e-02f,
  4.73608524e-01f, -7.21207261e-01f, 9.98140052e-02f, -5.79017758e-01f, 5.30561320e-02f, -5.65433741e-01f, -4.64054108e-01f, -1.78387966e-02f, 4.27729189e-01f, -4.93808925e-01f,
  3.41895640e-01f, -2.88342144e-02f, -2.75201112e-01f, -5.06629124e-02f, 1.18674943e-02f, -3.68503213e-01f, -4.70061563e-02f, 1.93593457e-01f, 2.70074099e-01f, 1.24510773e-01f,
  -1.40563049e-03f, -9.00189355e-02f, 5.36340177e-01f, 3.35487694e-01f, 5.65185137e-02f, 4.50931638e-01f, -3.26327175e-01f, -4.28147376e-01f, -3.57989937e-01f, -1.69146925e-01f,
  -4.15310562e-01f, -1.26163915e-01f, 3.51625532e-01f, 3.28834146e-01f, 5.69890440e-02f, 3.86318982e-01f, -2.38544777e-01f, -1.81126118e-01f, 2.68155068e-01f, -4.30014193e-01f,
  6.04881123e-02f, -3.46399665e-01f, -5.71972020e-02f, 1.76084206e-01f, -4.22857136e-01f, 7.86212981e-02f, -5.06699622e-01f, -7.41842508e-01f, -3.01668793e-01f, -1.37743980e-01f,
  2.62324899e-01f, -2.54960537e-01f, 5.57229102e-01f, -4.17159706e-01f, 1.73448622e-01f, 4.42774534e-01f, -3.89380902e-01f, 1.84291571e-01f, 3.30461860e-01f, 6.85330108e-02f,
  -5.49020618e-02f, 3.05511475e-01f, -6.34964705e-01f, -2.97822207e-01f, -3.15772057e-01f, -3.59052002e-01f, -6.35997474e-01f, -1.55207608e-02f, -8.27211365e-02f, 3.88321221e-01f,
  -5.85843265e-01f, 4.36211675e-01f, 3.39994207e-02f, -4.79554385e-01f, 4.29786444e-01f, 2.92724222e-01f, 2.12287113e-01f, 1.15094744e-01f, 4.41073745e-01f, -1.51698709e-01f,
  9.73027572e-02f, 3.66552055e-01f, 3.31902951e-01f, 1.52393907e-01f, 5.21168597e-02f, 1.74962178e-01f, -2.34728351e-01f, 3.72689873e-01f, -2.94245183e-01f, -2.66062319e-01f,
  4.91292387e-01f, -6.01207092e-02f, 2.00833485e-01f, 1.80186361e-01f, -9.38406140e-02f, -4.09353256e-01f, -4.49179441e-01f, 2.69312769e-01f, 3.49083841e-01f, -3.20866644e-01f,
  -4.69637483e-01f, -3.46245408e-01f, -3.74406017e-02f, -2.94711322e-01f, -7.66873896e-01f, -6.80664182e-01f, 4.14602101e-01f, -7.08789349e-01f, -4.95439291e-01f, -4.24565285e-01f,
  3.63093764e-02f, -3.71937640e-02f, 2.51485825e-01f, 1.90391541e-01f, 2.98874557e-01f, -3.23180109e-01f, -5.18229127e-01f, 4.45821553e-01f, 3.17347050e-01f, -1.88187823e-01f,
  2.85708785e-01f, 5.14116764e-01f, -4.49493349e-01f, 4.57019717e-01f, 4.73362029e-01f, 5.86231798e-02f, 3.41508687e-01f, 2.00585350e-01f, -5.26045978e-01f, -1.50080442e-01f,
  -5.75276911e-01f, -4.02626753e-01f, -6.18424229e-02f, -3.01185608e-01f, 1.53464675e-01f, -1.92107141e-01f, -1.09594896e-01f, 3.63652915e-01f, -5.95461309e-01f, 4.09846514e-01f,
  3.41616213e-01f, -3.76951039e-01f, -4.90811765e-01f, 5.25355116e-02f, 1.73942417e-01f, 1.48968980e-01f, -3.66306037e-01f, -2.08716214e-01f, -1.36691272e-01f, -2.80630946e-01f,
  -2.12199092e-01f, -3.78378123e-01f, -3.20201695e-01f, -1.43843845e-01f, -4.88253504e-01f, -4.21710938e-01f, -3.06804508e-01f, 2.67475992e-01f, 4.11212355e-01f, -5.50465047e-01f,
  2.28097618e-01f, 4.04426754e-01f, -4.26461756e-01f, -4.76409584e-01f, -3.29989418e-02f, 4.81600404e-01f, -8.04066777e-01f, -3.01960200e-01f, 1.46021098e-01f, -4.10922140e-01f,
  -2.31471449e-01f, -1.62007108e-01f, 4.20868158e-01f, 4.16731060e-01f, -5.22188187e-01f, -1.13238037e-01f, 4.64606732e-01f, 2.68265218e-01f, -4.42974150e-01f, -3.79114777e-01f,
  -3.24976236e-01f, 3.78315777e-01f, -6.07367456e-01f, -2.71712780e-01f, -3.14024329e-01f, 1.09006815e-01f, -6.57026693e-02f, -1.95683211e-01f, 1.23189285e-01f, -6.58455193e-01f,
  8.70682225e-02f, -3.67423147e-02f, 4.35978055e-01f, -4.02360968e-03f, 4.79821324e-01f, 2.59101391e-01f, -3.77305776e-01f, -6.27168536e-01f, -4.77748483e-01f, -2.66055971e-01f,
  -3.64834189e-01f, 2.70470500e-01f, -4.58101630e-01f, -5.03130794e-01f, -7.20486641e-02f, -2.95632392e-01f, 4.24265981e-01f, -6.54613525e-02f, -2.60431916e-01f, -2.90205151e-01f,
  -4.06086266e-01f, -1.74632773e-01f, -2.03079581e-01f, -1.43762663e-01f, -2.55472720e-01f, 1.91223308e-01f, 2.73936123e-01f, 2.52676874e-01f, 6.63522407e-02f, 1.50735095e-01f,
  -3.74013841e-01f, 4.20164973e-01f, -1.98220208e-01f, -5.39514162e-02f, -3.69353563e-01f, -2.38023579e-01f, 3.80401611e-01f, 2.11646035e-01f, 3.11423063e-01f, -4.80673403e-01f,
  2.86979169e-01f, -2.04268500e-01f, -3.96635771e-01f, 2.57195771e-01f, -1.35190040e-01f, -3.25023860e-01f, -3.60485047e-01f, -3.22593182e-01f, -1.87953398e-01f, 2.80822515e-01f,
  2.47941334e-02f, -2.84450233e-01f, 3.23498338e-01f, -3.71596396e-01f, -4.90421325e-01f, -4.42455173e-01f, -1.21956833e-01f, -3.56693529e-02f, 3.57637584e-01f, -1.88459411e-01f,
  4.07441050e-01f, -5.74182212e-01f, 2.76876599e-01f, -5.21904588e-01f, -2.81735301e-01f, -3.11225653e-01f, -4.36816067e-01f, -3.90818775e-01f, 4.34139132e-01f, 2.34558895e-01f,
  -2.75323987e-01f, 2.06425667e-01f, 2.07402967e-02f, 3.46311852e-02f, -2.07355842e-01f, 2.22320005e-01f, 6.86453357e-02f, 7.12515041e-02f, 3.15612674e-01f, -3.02889049e-01f,
  2.54632473e-01f, -3.48023683e-01f, -8.85274708e-02f, 1.23885348e-01f, -1.39596283e-01f, 1.19559057e-01f, 8.39402154e-03f, 5.50243519e-02f, -4.38701183e-01f, 4.54293974e-02f,
  1.09421410e-01f, 1.48907915e-01f, 3.69984955e-01f, 3.80656123e-01f, -2.23012239e-01f, -3.50675732e-01f, -3.36932093e-02f, 3.23454261e-01f, 1.62306160e-01f, -4.07963395e-01f,
  -1.97600335e-01f, 4.41662490e-01f, -4.67580825e-01f, -2.92791426e-01f, -3.59330773e-01f, -1.22227222e-01f, 7.71553069e-02f, -3.74250233e-01f, 5.60080588e-01f, 4.22548831e-01f,
  -3.40113968e-01f, -4.49795872e-01f, 1.00697607e-01f, -2.59512544e-01f, -2.47105867e-01f, -3.62357080e-01f, -3.20178837e-01f, 4.54253495e-01f, -3.11211616e-01f, 2.80508995e-01f,
  -3.04172367e-01f, -2.69394457e-01f, -3.61520052e-01f, -4.16051328e-01f, -7.23093599e-02f, -7.59237111e-02f, -3.98287624e-01f, -4.63838995e-01f, 1.24228179e-01f, -4.20380235e-01f,
  -1.69370562e-01f, -2.67111838e-01f, 1.49590939e-01f, -3.83728415e-01f, -3.67253184e-01f, -2.77886927e-01f, 2.91550875e-01f, -4.64635074e-01f, -2.88864851e-01f, 2.63130188e-01f,
  -3.52822334e-01f, -2.69625094e-02f, 9.76386964e-02f, 4.35200423e-01f, -2.10350856e-01f, -1.76746473e-01f, -2.63455540e-01f, 1.88995779e-01f, 1.58568934e-01f, 2.03046635e-01f,
  2.30248645e-01f, -5.26895486e-02f, 4.91237819e-01f, 3.20011936e-02f, -6.57526776e-02f, -1.91915885e-01f, 2.24132627e-01f, 2.23410199e-03f, -5.04338562e-01f, -2.40461096e-01f,
  -7.79799163e-01f, -2.59155408e-02f, 2.13013306e-01f, -5.69597073e-02f, -2.07022548e-01f, -2.38121644e-01f, -2.70678073e-01f, 4.26881790e-01f, -3.36460352e-01f, -2.20706433e-01f,
  -5.18720210e-01f, -2.56403238e-02f, -5.16572654e-01f, -5.93834184e-03f, 3.98136586e-01f, -4.40373957e-01f, 5.49989343e-01f, 2.49210194e-01f, -1.61304295e-01f, 9.52677876e-02f,
  -2.76556551e-01f, -4.65635598e-01f, -5.41436434e-01f, -8.06405425e-01f, -1.04085535e-01f, -5.93177021e-01f, -1.15238838e-01f, 1.34395748e-01f, 4.22258437e-01f, 3.33042932e-03f,
  4.86056596e-01f, 7.40469992e-02f, -8.90941769e-02f, -7.31337309e-01f, -6.52053773e-01f, 3.71667580e-03f, 3.70103896e-01f, 5.39195836e-01f, 4.16249394e-01f, 5.04398465e-01f,
  -2.81085432e-01f, 7.21074343e-02f, -3.83505702e-01f, 2.46854499e-01f, 4.70202476e-01f, 1.32663846e-01f, -5.27066588e-01f, -1.61645591e-01f, -3.68005306e-01f, -5.03888249e-01f,
  4.97842804e-02f, 3.22662979e-01f, 1.72715232e-01f, 2.43211761e-01f, 1.61241055e-01f, 2.35001743e-01f, 4.64603633e-01f, -1.28094897e-01f, 3.33872110e-01f, 8.90506282e-02f,
  -4.19425517e-01f, -1.95050970e-01f, 3.71976220e-03f, -4.32385534e-01f, -3.49007159e-01f, -5.25423884e-01f, -4.56042022e-01f, -1.96144894e-01f, -6.80600822e-01f, 3.17912817e-01f,
  5.26792943e-01f, -3.37944478e-01f, 1.78685263e-01f, 4.87518519e-01f, 3.38390142e-01f, -9.02680084e-02f, -4.12581772e-01f, -5.69481850e-01f, 1.36506632e-02f, -1.86133504e-01f,
  -3.56141895e-01f, -2.31384411e-01f, -3.78352344e-01f, 3.15059513e-01f, -2.84465589e-02f, -7.36538041e-03f, 1.85109109e-01f, 6.52369037e-02f, 1.46308271e-02f, -4.33167040e-01f,
  5.26252449e-01f, -4.18918699e-01f, -5.27208269e-01f, -1.99519262e-01f, -2.67022729e-01f, -4.76030946e-01f, -2.50814855e-01f, 1.92256585e-01f, -1.73558518e-01f, 5.84191263e-01f,
  -3.38184863e-01f, 1.44531727e-01f, 2.74996072e-01f, -3.50551933e-01f, 4.45646077e-01f, -2.79495001e-01f, -4.66348350e-01f, -4.45367783e-01f, -2.65429281e-02f, -3.01104516e-01f,
  -5.80713630e-01f, 4.36317205e-01f, -2.94703960e-01f, -1.24589443e-01f, 1.21565051e-01f, 5.32915778e-02f, -3.79228115e-01f, 1.49809316e-01f, 1.25833675e-01f, 1.45587735e-02f,
  -4.01476771e-01f, 3.02837372e-01f, -4.60900307e-01f, 6.31831586e-02f, -3.45084108e-02f, 3.73969048e-01f, -2.94054419e-01f, -2.83399671e-01f, -3.44884604e-01f, 5.27930379e-01f,
  -3.50520879e-01f, -6.40519857e-01f, -8.78395140e-02f, -5.61640620e-01f, -2.24516407e-01f, -3.18986356e-01f, 3.19729865e-01f, -3.89519215e-01f, -2.51985431e-01f, -9.37374588e-03f,
  -4.04711872e-01f, -5.45971096e-01f, -1.35579243e-01f, 4.59663540e-01f, 9.31535661e-02f, -1.68303773e-01f, 5.68909228e-01f, -2.69652188e-01f, -4.20083940e-01f, 1.05460115e-01f,
  3.97509098e-01f, 3.98350000e-01f, -4.82838243e-01f, -3.47999781e-01f, -2.03617945e-01f, -1.76657870e-01f, -5.43705106e-01f, -4.00338352e-01f, -1.60908580e-01f, 2.41784960e-01f,
  -4.20986474e-01f, -3.67754191e-01f, 3.83928359e-01f, -1.40591800e-01f, -1.33391127e-01f, 2.59151369e-01f, -4.42087263e-01f, -4.72396344e-01f, 3.95087451e-01f, 3.86958271e-01f,
  -9.53109488e-02f, 3.08511943e-01f, 2.76582658e-01f, 5.03714859e-01f, 2.02363491e-01f, 2.65228987e-01f, -1.51602268e-01f, -2.79920340e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.64624512e-01f, 1.22788355e-01f, 3.83660682e-02f, -1.01792537e-01f, 1.16788417e-01f, 1.53281718e-01f, 1.23387426e-02f, -3.42121758e-02f, -1.02097467e-02f, -3.20586711e-02f,
  6.83125407e-02f, 1.15282377e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    