/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.17035466e-01f, -1.08958423e-01f, -4.78186943e-02f, 1.05772018e-01f, 8.28090124e-03f, -1.63569063e-01f, -6.35367557e-02f, -1.06527843e-01f, -4.79804166e-02f, -1.17577702e-01f,
  -1.29387200e-01f, -8.93499553e-02f, -2.27085397e-01f, -8.32177252e-02f, -7.64153600e-02f, -2.71415234e-01f, -1.59362108e-02f, -2.02899016e-02f, -3.13161798e-02f, -4.29422669e-02f,
  2.09462177e-02f, -6.49497733e-02f, 9.34728608e-02f, -3.36230733e-02f, 1.08825006e-01f, 9.63578895e-02f, 1.55795678e-01f, -6.23675548e-02f, 1.30593345e-01f, -2.44997889e-02f,
  1.44709426e-04f, -7.52004832e-02f, 7.61893988e-02f, -8.23022574e-02f, 5.73002324e-02f, 2.12860797e-02f, -1.84642933e-02f, 1.29563571e-03f, -1.05300425e-02f, -3.67513373e-02f,
  -2.86334585e-02f, -4.39195856e-02f, -2.83589726e-03f, 2.83156764e-02f, -4.06650379e-02f, -1.21107129e-02f, -1.96665134e-02f, 1.00485250e-01f, 2.73142811e-02f, -3.02271675e-02f,
  6.08390644e-02f, 3.09514105e-02f, 9.39383954e-02f, 2.07721535e-02f, 5.21891937e-02f, 2.23262999e-02f, 7.71425366e-02f, -2.05701832e-02f, -3.05531062e-02f, -1.76821034e-02f,
  -9.43447370e-03f, -3.92779075e-02f, -8.04976299e-02f, -2.92974553e-04f, 2.12614518e-02f, 4.82371822e-02f, 9.61246118e-02f, 2.32269578e-02f, 5.58379218e-02f, 2.63514575e-02f,
  6.40145764e-02f, -2.15381291e-02f, 4.76571880e-02f, -9.52426810e-03f, 6.32231236e-02f, -1.38296885e-03f, 6.38279766e-02f, 4.74905632e-02f, 4.76904064e-02f, 7.09895045e-02f,
  5.62058166e-02f, 1.18991164e-02f, 2.60133985e-02f, 5.77976461e-03f, 6.11294701e-04f, 4.20197919e-02f, 6.17467705e-03f, -1.14802811e-02f, 3.67959263e-03f, -4.96293604e-02f,
  -4.90031540e-02f, -8.46036151e-02f, 4.16112784e-03f, -3.10998550e-03f, 1.66410841e-02f, -2.10729018e-02f, -2.44214460e-02f, 3.84638086e-02f, -5.56377992e-02f, -3.74072529e-02f,
  -3.61141004e-02f, -5.15104365e-03f, -5.14609292e-02f, -1.59915444e-02f, 1.76028572e-02f, 2.96732504e-02f, -2.99776695e-03f, -9.27410927e-03f, 1.32271210e-02f, -5.63684246e-03f,
  -2.71608345e-02f, -4.78215441e-02f, 3.41906119e-03f, 6.81895614e-02f, 2.64481152e-03f, 7.71470219e-02f, -6.78644050e-03f, 3.55717279e-02f, -3.78070027e-02f, -2.27365792e-02f,
  -2.95685939e-02f, -2.49827448e-02f, 2.49258712e-01f, -1.04926720e-01f, -1.11131489e-01f, 4.54534069e-02f, 5.10702655e-02f, -4.71105017e-02f, -5.33032864e-02f, -1.47495210e-01f,
  -1.98494680e-02f, -1.59169473e-02f, 8.69602785e-02f, -7.79823214e-02f, 2.66046554e-01f, 1.49836496e-01f, -3.30816507e-02f, 2.11440232e-02f, -3.65140429e-03f, -7.10636824e-02f,
  1.45531878e-01f, -5.62466457e-02f, 1.66931674e-01f, -2.24942677e-02f, -5.39388433e-02f, -2.28751935e-02f, -1.24421947e-01f, -3.58333439e-02f, -5.50715365e-02f, -1.09481104e-01f,
  -2.76700035e-02f, -1.38957351e-01f, 7.15745017e-02f, -2.07931246e-03f, -5.20304143e-02f, -1.16015282e-02f, -3.98242697e-02f, 3.48951295e-02f, 1.50986966e-02f, -7.46810660e-02f,
  -6.88433349e-02f, 1.30691631e-02f, -1.39646162e-03f, 8.95160809e-03f, -1.95665266e-02f, -5.10970801e-02f, 6.02334067e-02f, -2.55571734e-02f, 5.50330058e-03f, 9.04540494e-02f,
  -3.44653428e-02f, -1.32543640e-03f, 7.76917711e-02f, 1.31394193e-02f, -3.76518408e-04f, -9.08330828e-02f, 9.10241436e-03f, 3.87622938e-02f, 8.88987631e-03f, -1.53395804e-02f,
  -2.87911054e-02f, -1.01497593e-04f, 2.68753413e-02f, 2.46558432e-02f, -2.43624225e-02f, -4.13768627e-02f, 9.71856248e-03f, 7.09969271e-03f, 3.79340276e-02f, 5.89571707e-02f,
  6.23205937e-02f, -2.12755613e-03f, 8.40953365e-03f, -1.26363551e-02f, 5.14260195e-02f, -3.18903625e-02f, 2.52092425e-02f, -1.04729936e-01f, 9.40229073e-02f, 8.62627774e-02f,
  -5.31989709e-02f, -5.27691506e-02f, 5.00798284e-04f, -5.08285947e-02f, 3.13993776e-03f, 4.27513570e-02f, 1.17005957e-02f, 1.90220978e-02f, -1.83969494e-02f, 2.71949489e-02f,
  -1.70766309e-01f, -1.40685037e-01f, -6.35606349e-02f, -3.73545028e-02f, -1.93669628e-02f, 9.85139236e-02f, 3.10050678e-02f, 2.27783062e-02f, -3.03515084e-02f, -6.90532401e-02f,
  -6.48877770e-02f, 2.16718893e-02f, 4.68245409e-02f, -6.53942674e-02f, -2.45070718e-02f, 9.33143720e-02f, 2.45655375e-03f, -5.16921990e-02f, -2.10996959e-02f, -6.05931953e-02f,
  5.10609858e-02f, -8.78870115e-02f, -3.69733945e-02f, 2.07354315e-02f, 1.15819974e-02f, -3.54367197e-02f, 2.62918007e-02f, 1.17646186e-02f, 1.06141930e-02f, 3.13311517e-02f,
  -6.35804236e-02f, -3.28052975e-02f, 7.90469646e-02f, 8.67756922e-03f, 1.68950893e-02f, 9.24127176e-02f, 2.88815331e-02f, 6.10412695e-02f, -4.34039384e-02f, -2.00585321e-01f,
  -7.14327767e-02f, -1.04649201e-01f, 4.89100963e-02f, -8.42619613e-02f, 2.02224314e-01f, 7.45947212e-02f, -8.51431414e-02f, -1.39603391e-01f, 8.41772035e-02f, -8.94184038e-03f,
  3.47033441e-02f, -1.01989359e-02f, 1.05522878e-01f, -5.27837351e-02f, 4.90096919e-02f, -1.67820416e-02f, 1.02022225e-02f, 6.54245391e-02f, -7.06817433e-02f, 2.46342681e-02f,
  -5.59374616e-02f, -4.65051783e-03f, 7.99305812e-02f, 2.00112592e-02f, 6.01563370e-03f, -3.71813625e-02f, 1.30393787e-03f, -1.85118914e-02f, 4.19194959e-02f, -4.07775603e-02f,
  -1.89783368e-02f, 5.64977378e-02f, 3.83377634e-02f, -7.60704686e-04f, 4.51359935e-02f, 8.13037530e-03f, -4.92106825e-02f, -1.66408473e-03f, -2.70970259e-02f, -4.99339355e-03f,
  7.08223656e-02f, -7.42273056e-04f, -7.09318295e-02f, -2.01027170e-02f, 1.96688976e-02f, 5.28379483e-03f, -3.78141217e-02f, 5.55801876e-02f, -7.92733580e-02f, 8.66088271e-02f,
  6.88137300e-03f, 1.16681429e-02f, 6.41244650e-02f, -3.12116183e-02f, 9.36981514e-02f, -3.08400504e-02f, 4.89418358e-02f, 2.08722912e-02f, -1.02032702e-02f, 3.88455614e-02f,
  -9.58443433e-03f, 4.13919566e-03f, -5.20450771e-02f, -2.14501619e-02f, -9.01045203e-02f, 2.08757203e-02f, -9.23730507e-02f, 8.13837498e-02f, -4.07438353e-02f, -4.04840074e-02f,
  -3.30000855e-02f, 2.19506864e-02f, 3.48234475e-02f, -5.80869103e-03f, 5.58319874e-02f, 8.05393048e-03f, -4.83423285e-02f, -5.60108125e-02f, 2.15929318e-02f, -4.43286486e-02f,
  2.05695704e-02f, 2.00512577e-02f, -2.18009893e-02f, 6.46289960e-02f, 1.82202365e-02f, -3.34438542e-03f, -5.64192757e-02f, 1.81293173e-03f, -4.76558246e-02f, 4.75474335e-02f,
  -7.74656683e-02f, -4.17784974e-02f, 4.69385460e-02f, 4.00270373e-02f, -5.65176248e-04f, -4.37540226e-02f, -1.61707159e-02f, -1.50795025e-03f, 2.49044616e-02f, 5.68112880e-02f,
  1.51120606e-04f, -5.12822531e-02f, -1.17005510e-02f, -3.14265788e-02f, -2.38091983e-02f, -4.26307581e-02f, -4.12693359e-02f, 4.84054536e-02f, 6.31374568e-02f, -2.29287241e-02f,
  2.12357759e-01f, 5.75839542e-02f, 2.28281170e-01f, 7.67385727e-03f, 3.19262706e-02f, 7.35145733e-02f, 1.32141605e-01f, 3.93837206e-02f, 2.69665927e-01f, -7.07324147e-02f,
  -6.27974421e-02f, 2.10196711e-02f, 2.24499121e-01f, -8.86281580e-02f, 1.76428765e-01f, 1.59902319e-01f, -3.58056352e-02f, -6.31687418e-02f, 2.91544478e-02f, -1.67909674e-02f,
  4.00113501e-02f, -1.10012561e-01f, 4.56129992e-03f, -1.02916688e-01f, -1.16056614e-01f, -3.92613187e-02f, -1.25578120e-01f, 2.88920607e-02f, -2.64170796e-01f, -1.92014333e-02f,
  1.21148184e-01f, 4.12659198e-02f, 7.53345117e-02f, -6.76708743e-02f, -2.05608681e-02f, -6.31147698e-02f, -7.76285455e-02f, -2.26537716e-02f, 4.03144807e-02f, -5.04953340e-02f,
  -5.72502753e-03f, -5.14517501e-02f, -7.53067061e-02f, -9.99248400e-03f, -6.53514042e-02f, -4.11015190e-02f, -5.44522107e-02f, 4.99039702e-02f, 5.92259467e-02f, 8.43930319e-02f,
  1.01781659e-01f, 2.46089720e-03f, 4.56286743e-02f, -3.17666233e-02f, 3.00915819e-02f, -5.00701368e-03f, 1.14634009e-02f, -3.54772396e-02f, -1.65950786e-02f, -4.33684280e-03f,
  -4.85805832e-02f, -3.26442011e-02f, -8.05756673e-02f, 1.94822531e-02f, -3.51125449e-02f, 2.57252976e-02f, -9.37109254e-03f, -1.13852732e-02f, 1.84351287e-03f, 1.42908208e-02f,
  -2.40393262e-02f, -8.73407871e-02f, -6.95666149e-02f, 1.76612125e-03f, -2.91321315e-02f, -8.49329159e-02f, -3.49795707e-02f, -4.23424281e-02f, 5.83749153e-02f, -3.13802734e-02f,
  -2.91786641e-02f, -4.23442349e-02f, 7.01611564e-02f, 3.96542028e-02f, -3.26119503e-03f, -1.89703275e-02f, -5.12218811e-02f, 2.97593493e-02f, 3.65664177e-02f, -2.23358385e-02f,
  -1.01775654e-01f, -4.83653359e-02f, -8.84488970e-03f, 5.36864884e-02f, -2.68378425e-02f, -1.44390566e-02f, 3.13898735e-02f, 7.25952461e-02f, 1.88146085e-02f, 1.34927621e-02f,
  -1.42666902e-02f, -2.46879570e-02f, -5.52531071e-02f, -1.55702028e-02f, 1.03011196e-02f, -1.43911662e-02f, 1.58494562e-02f, -6.94232434e-02f, -4.04998250e-02f, -1.49908736e-02f,
  2.29523312e-02f, -3.26981721e-03f, -4.63670157e-02f, -5.90733141e-02f, -7.14594573e-02f, 1.43457195e-02f, -1.57380700e-02f, 1.53677603e-02f, -7.88704827e-02f, 1.04810275e-01f,
  4.86489773e-01f, 2.84690559e-01f, 6.27736300e-02f, 2.15230480e-01f, 1.71450712e-02f, 1.84454992e-01f, 1.15025327e-01f, 1.19834796e-01f, -1.12296427e-02f, 2.99242232e-02f,
  1.48000875e-02f, -3.42283696e-02f, -8.64920113e-03f, 7.94342309e-02f, 6.28608391e-02f, 5.83703369e-02f, 2.13670880e-01f, 1.63454309e-01f, -6.10536002e-02f, 6.25241995e-02f,
  2.05875468e-02f, 7.39884973e-02f, 7.45028257e-02f, -5.76095916e-02f, 5.55149354e-02f, -2.72302907e-02f, -4.11348194e-02f, -1.01884045e-01f, -4.79437783e-02f, 4.58732322e-02f,
  5.03954664e-02f, 1.19779542e-01f, -7.52738714e-02f, -1.89280957e-02f, -3.72917168e-02f, -2.75143273e-02f, -4.23198007e-02f, -9.42177400e-02f, -9.82420668e-02f, 9.52685904e-03f,
  8.20225384e-03f, -3.26216407e-03f, 4.04933728e-02f, -2.59243194e-02f, 1.21312181e-03f, 4.47769128e-02f, -6.33108541e-02f, -2.46098768e-02f, 4.64134887e-02f, -2.71118060e-02f,
  2.92067206e-03f, 4.34661843e-02f, -8.63976404e-03f, 1.61404647e-02f, 1.43530769e-02f, -2.45651808e-02f, -1.55527228e-02f, 5.91601059e-03f, 5.86717762e-02f, 3.18712294e-02f,
  2.30282452e-02f, -2.46997792e-02f, 1.49592713e-01f, -5.18148877e-02f, 5.38422652e-02f, -7.62391416e-03f, 5.41549437e-02f, -9.55825299e-03f, -1.09312246e-02f, 8.98804069e-02f,
  7.12012351e-02f, -2.39557866e-02f, -3.92319961e-03f, 2.05851216e-02f, -3.32483500e-02f, 5.93997985e-02f, -2.89577991e-02f, 3.43871824e-02f, 6.05620490e-03f, 5.21628521e-02f,
  1.55566540e-02f, 3.07849254e-02f, 3.17913219e-02f, 2.65483628e-04f, 1.77942961e-02f, -6.73907474e-02f, 3.05371330e-04f, 4.09028716e-02f, 1.00132851e-02f, 7.74029875e-03f,
  1.05405703e-01f, 8.69934931e-02f, -2.05589700e-02f, 5.12063652e-02f, -1.00326911e-02f, 5.91514409e-02f, 5.78595139e-02f, -2.70159473e-03f, 6.08429015e-02f, 3.12221628e-02f,
  -7.73073174e-04f, -3.58875580e-02f, 7.23247509e-03f, -3.08883898e-02f, -8.97227004e-02f, -1.06776126e-01f, 5.19305132e-02f, -3.84427309e-02f, 3.14551964e-02f, -3.02754305e-02f,
  -1.10046240e-03f, 5.55624589e-02f, -3.80991474e-02f, 1.77795475e-04f, -4.58737202e-02f, 3.30833755e-02f, 6.90024570e-02f, 7.37195322e-03f, 3.83933522e-02f, -2.32090969e-02f,
  -1.56728655e-01f, 4.10054564e-01f, -2.64673326e-02f, -5.64583056e-02f, -1.68047264e-01f, 9.27879959e-02f, -1.13961466e-01f, 1.49986312e-01f, -4.53877300e-02f, 2.43140519e-01f,
  -8.46127346e-02f, 1.00835294e-01f, 1.38806447e-01f, 7.88112730e-02f, -1.76915795e-01f, -5.51024303e-02f, -1.28634889e-02f, -2.52578873e-02f, -5.27663417e-02f, -1.07374769e-02f,
  -9.31695700e-02f, -1.10008456e-02f, -8.26003402e-02f, 8.51439014e-02f, -3.10803973e-03f, 2.55113933e-02f, -3.60073447e-02f, -1.57481413e-02f, 6.60999818e-03f, -1.24371864e-01f,
  9.50731058e-03f, -5.28009161e-02f, 1.59908593e-01f, 8.31951424e-02f, 1.17861323e-01f, 3.28979343e-02f, 4.45597060e-02f, -7.61068165e-02f, -3.95838469e-02f, -2.31994446e-02f,
  2.17035934e-02f, 2.45246682e-02f, -6.91844150e-02f, -7.85562024e-02f, -5.21240905e-02f, 8.46555084e-03f, -5.02731130e-02f, -1.84367306e-03f, -2.87948642e-02f, -3.28160748e-02f,
  3.04465722e-02f, 2.71448214e-02f, 1.00114517e-01f, -7.99382925e-02f, -5.24990782e-02f, 3.48129347e-02f, -2.68492904e-02f, -1.58709437e-02f, 3.87454256e-02f, 3.15889600e-03f,
  -9.61193591e-02f, 3.16786580e-02f, -3.81938890e-02f, -1.17823770e-02f, -1.61162484e-02f, -4.97644581e-02f, -2.04851460e-02f, -3.80943120e-02f, 3.07347812e-02f, 2.00697817e-02f,
  4.34653610e-02f, -2.19138414e-02f, 8.36596638e-03f, 1.26096923e-02f, -2.54986100e-02f, -7.48652369e-02f, -4.17168811e-03f, 7.80690787e-03f, 8.84897336e-02f, -1.43198483e-02f,
  -2.68296450e-02f, -9.54368059e-03f, 4.04035598e-02f, -5.75857796e-02f, -3.48390937e-02f, 1.81808847e-03f, 1.57464415e-01f, 2.39979196e-03f, -2.18722969e-02f, -2.31479760e-02f,
  3.50561559e-01f, 2.48492897e-01f, 2.18175352e-02f, 3.93749550e-02f, -2.88227182e-02f, -2.66605262e-02f, -8.31057206e-02f, -1.39864087e-02f, 3.40092368e-02f, -4.02570516e-02f,
  1.64460577e-02f, -1.26915704e-02f, 4.98591661e-02f, -4.40231301e-02f, 6.77828640e-02f, 1.58025231e-02f, -4.39293571e-02f, 6.52654693e-02f, 9.02085975e-02f, 8.17841291e-02f,
  7.34201968e-02f, -4.52792905e-02f, -1.13253385e-01f, -5.24293259e-02f, -3.66924144e-02f, -1.83754060e-02f, -4.95560057e-02f, 8.31906777e-03f, -4.18274067e-02f, 1.48512125e-02f,
  -5.81210554e-02f, -8.58975947e-02f, -2.22536728e-01f, -1.28072221e-02f, 1.94943827e-02f, -1.37239605e-01f, -1.67908534e-01f, -8.47551972e-02f, -1.40001982e-01f, -4.71566245e-02f,
  1.47467837e-01f, 3.12927626e-02f, -4.30583693e-02f, -8.92500430e-02f, -1.65049511e-03f, 8.11857209e-02f, -4.76227328e-02f, 1.21530164e-02f, -4.58442420e-02f, -4.58126254e-02f,
  5.62433302e-02f, -5.40594161e-02f, -6.30595461e-02f, 2.39275340e-02f, -3.33683454e-02f, 1.18412308e-01f, 1.59843892e-01f, -2.03842986e-02f, 1.95114426e-02f, -8.57522935e-02f,
  -7.17582330e-02f, 2.64768489e-02f, 3.04198060e-02f, 1.38244834e-02f, 2.43072677e-02f, -8.31724051e-03f, 2.05986202e-02f, -2.20159367e-02f, -6.41183332e-02f, -5.19729704e-02f,
  9.24576744e-02f, 4.55186777e-02f, 6.26949519e-02f, 5.73064685e-02f, 3.49862799e-02f, -4.16840129e-02f, -8.95567983e-03f, -4.53449041e-02f, -1.48681626e-02f, -6.36173114e-02f,
  4.10600053e-03f, 4.65286970e-02f, -3.85272838e-02f, -2.31093448e-02f, 7.90544525e-02f, 5.75238839e-02f, 3.38162147e-02f, -8.29799101e-03f, -5.82297146e-02f, -1.00946501e-02f,
  -8.98004845e-02f, -1.58492886e-02f, 7.91144520e-02f, 4.49050143e-02f, 6.28358647e-02f, -2.56778989e-02f, 2.92636268e-02f, 8.67459401e-02f, -4.26454917e-02f, 7.48204365e-02f,
  4.90783043e-02f, 2.48439666e-02f, -3.86974774e-02f, 5.27632087e-02f, -2.79591326e-02f, 4.85468134e-02f, 9.57473740e-02f, -4.01422046e-02f, 8.09475705e-02f, 2.43463535e-02f,
  -1.04189306e-01f, -3.91388088e-02f, -8.22290778e-02f, 2.94007268e-02f, -2.75019519e-02f, 1.10190101e-02f, -6.39142245e-02f, 4.00444306e-02f, 3.17642763e-02f, -3.41490246e-02f,
  8.94027725e-02f, 6.17912598e-03f, -1.59687083e-02f, -6.73558889e-03f, 6.28933683e-03f, 8.57288986e-02f, 4.11077822e-03f, 6.05759695e-02f, -4.48204614e-02f, -1.38434833e-02f,
  2.38157697e-02f, 3.82762104e-02f, 2.25602444e-02f, -2.13896073e-02f, -1.15932547e-01f, -5.48363850e-02f, 2.68898662e-02f, -4.07136120e-02f, -2.96980795e-02f, -2.03073658e-02f,
  2.56090611e-03f, 9.17242393e-02f, -4.06346610e-03f, -1.51276421e-02f, 6.93308115e-02f, 6.51677549e-02f, 3.56427878e-02f, 1.25036146e-02f, 4.96340357e-02f, -8.02616701e-02f,
  -2.16465488e-01f, 5.28317243e-02f, 2.40983255e-02f, 3.04663796e-02f, -1.23735704e-01f, -2.02338919e-01f, 2.35054065e-02f, 8.87977798e-03f, 1.38716713e-01f, 2.38511246e-03f,
  -1.08995073e-01f, 4.64958586e-02f, 2.84850240e-01f, -5.80925792e-02f, -6.00020662e-02f, 1.85394734e-01f, -8.71308967e-02f, -8.82572979e-02f, 4.40260097e-02f, -1.03929557e-01f,
  -7.24490955e-02f, -8.68802294e-02f, 4.61716205e-03f, -1.75563514e-01f, -1.64825559e-01f, 1.80124901e-02f, -1.25955557e-02f, 2.36484371e-02f, -2.36037478e-01f, -1.36907786e-01f,
  -3.29884402e-02f, 8.54439735e-02f, 6.59646839e-02f, -2.34961882e-02f, -2.22247094e-02f, -3.39634009e-02f, -1.67642925e-02f, -3.42111886e-02f, 2.73867548e-02f, 7.41730258e-02f,
  -4.23120242e-03f, -7.84681365e-03f, 7.34570064e-03f, -2.94170789e-02f, 1.75335072e-03f, -6.32998347e-02f, -2.33064848e-03f, -2.96217110e-02f, 7.06172064e-02f, 6.88213808e-03f,
  2.88614109e-02f, 4.35792208e-02f, -5.92442695e-03f, 9.73844377e-04f, 3.71455364e-02f, 3.83981429e-02f, 1.63813308e-02f, 3.85297649e-02f, 1.49466312e-02f, -5.10333255e-02f,
  -4.14655358e-02f, -6.56608120e-02f, 2.87892818e-02f, -3.61519158e-02f, 3.18183303e-02f, -7.70877227e-02f, 1.92305283e-03f, 5.45050530e-03f, -3.44448462e-02f, 5.65466750e-03f,
  1.74864347e-03f, 1.60176456e-02f, -3.27938572e-02f, 5.31438701e-02f, -2.10479368e-02f, 1.97928064e-02f, -7.34657189e-03f, -6.96915668e-03f, 7.75440177e-03f, 3.58866714e-02f,
  3.64337973e-02f, -2.21920218e-02f, 9.28630903e-02f, 6.50705695e-02f, -1.35799199e-02f, -4.72370833e-02f, 6.40929863e-02f, -2.75372230e-02f, 2.07363702e-02f, 1.48405321e-02f,
  -8.97550508e-02f, 1.14536032e-01f, 4.45835739e-02f, -3.80844984e-04f, 7.56237432e-02f, -9.09291878e-02f, 3.16397473e-02f, -5.63208200e-02f, 4.08066548e-02f, 2.85183843e-02f,
  -4.36810143e-02f, 1.63906533e-02f, -8.52200463e-02f, -4.13984321e-02f, -2.74308212e-02f, 3.51717770e-02f, -4.61821780e-02f, 3.53760123e-02f, -4.09180112e-03f, -5.87518364e-02f,
  -5.49094826e-02f, -1.46627575e-02f, -2.65135728e-02f, 1.15725920e-02f, -5.66163287e-02f, -6.07231706e-02f, -5.01874164e-02f, -1.20026069e-02f, -6.23302814e-03f, 1.54567007e-02f,
  4.44894135e-02f, 1.69578373e-01f, 1.23161659e-01f, 3.96172516e-02f, -1.39100164e-01f, 5.19341826e-02f, 6.30116835e-02f, -3.63225378e-02f, 1.64474010e-01f, 7.68558905e-02f,
  -6.70812130e-02f, -5.97786009e-02f, 1.07154071e-01f, 1.58243448e-01f, -3.69528718e-02f, 4.52936031e-02f, 7.23833665e-02f, 8.79631564e-02f, 8.05709437e-02f, -2.74820197e-02f,
  -4.11294848e-02f, -3.65992263e-02f, 5.67344315e-02f, -7.09782839e-02f, -9.33010206e-02f, -4.80821989e-02f, -1.34241223e-01f, -1.09629072e-01f, -7.66496807e-02f, -1.51808737e-02f,
  1.31504275e-02f, 1.20968014e-01f, 1.21284248e-02f, 7.88121000e-02f, 1.14939772e-02f, 1.54780839e-02f, -1.14280637e-02f, -3.89052145e-02f, -6.34612665e-02f, 8.09451863e-02f,
  -6.13955967e-02f, 4.61109802e-02f, 5.36254011e-02f, 7.93136749e-03f, 2.36628447e-02f, -4.76975441e-02f, 2.70436425e-02f, 1.33481435e-02f, -1.62993814e-03f, -1.00066066e-01f,
  7.44185820e-02f, 2.10158359e-02f, 2.43423022e-02f, 5.67065328e-02f, -3.09221316e-02f, -4.04424127e-03f, 6.93623573e-02f, 2.63629598e-04f, -2.41899006e-02f, -8.32516141e-03f,
  2.42895763e-02f, 7.86648411e-03f, 2.00012308e-02f, -4.72065285e-02f, 4.53974716e-02f, -6.12766892e-02f, -2.42287889e-02f, 2.95422636e-02f, -8.16201046e-03f, -4.67216522e-02f,
  -2.26426106e-02f, 2.48672850e-02f, 6.06971607e-02f, 4.91989590e-02f, 6.08878061e-02f, 8.00287798e-02f, 3.98408473e-02f, -3.18615623e-02f, -2.94555780e-02f, -5.86648360e-02f,
  -2.16084607e-02f, 1.28925825e-02f, -3.63394828e-03f, 6.19273670e-02f, 5.16920537e-02f, 2.90882625e-02f, -2.61561312e-02f, 7.14825243e-02f, -4.30317149e-02f, -2.27843300e-02f,
  3.27488296e-02f, 1.04303025e-01f, 5.25421910e-02f, -8.12628120e-03f, 1.47988377e-02f, -8.78369510e-02f, -1.47736324e-02f, -4.63601574e-02f, 2.28736792e-02f, 2.32933369e-02f,
  -5.68809472e-02f, -5.64846210e-02f, -1.88251212e-02f, -6.27672579e-03f, 3.22331786e-02f, -2.48184018e-02f, 3.83584686e-02f, -5.59374392e-02f, -3.80298905e-02f, 3.68950330e-02f,
  -7.63133634e-03f, 5.48040904e-02f, -1.29512176e-02f, -2.46220753e-02f, -6.66485983e-04f, 3.12848203e-02f, 2.09897105e-02f, 2.14525368e-02f, 2.84089874e-02f, 1.29144220e-02f,
  3.12910564e-02f, 6.94779009e-02f, 2.05053687e-01f, 1.22667938e-01f, -7.37205967e-02f, 9.68698412e-02f, 2.98319161e-01f, -8.41416791e-02f, -7.17987195e-02f, -3.68013568e-02f,
  1.01894647e-01f, -1.18818380e-01f, 1.75555274e-02f, 1.21792942e-01f, 2.60812044e-01f, 1.07569292e-01f, 1.96368426e-01f, -1.29551087e-02f, -1.87700260e-02f, 5.52503057e-02f,
  5.00525311e-02f, -3.65711562e-02f, 2.24379599e-01f, -1.33678719e-01f, 1.47849217e-01f, -8.70866627e-02f, -1.41055927e-01f, 1.44881114e-01f, 2.91781574e-02f, 2.69366391e-02f,
  -1.83533747e-02f, -4.86329198e-02f, 1.53097343e-02f, 3.90080921e-02f, 8.70622844e-02f, 2.26913970e-02f, 6.86838571e-03f, -2.16634755e-04f, -4.84064966e-02f, 3.23371664e-02f,
  9.27728228e-03f, -5.85560650e-02f, 1.81050729e-02f, -7.69164413e-02f, -3.61492708e-02f, 1.10139474e-02f, 5.00211678e-03f, 1.24377906e-02f, -1.33731393e-02f, 6.10012934e-02f,
  8.95723775e-02f, -7.10743666e-03f, 8.82558599e-02f, -4.42854986e-02f, -3.37839760e-02f, -2.82924064e-02f, 6.28390908e-03f, -2.47314982e-02f, -4.51550186e-02f, -7.69286305e-02f,
  -1.08943328e-01f, -4.29811962e-02f, 5.58800101e-02f, -5.41781113e-02f, -1.79224089e-02f, -6.64049909e-02f, 6.57341704e-02f, -6.70410506e-03f, -5.86894602e-02f, 1.30034294e-02f,
  -3.98601592e-02f, -3.40330489e-02f, -8.23734105e-02f, 9.87406299e-02f, -4.25625518e-02f, 4.58072349e-02f, 8.19013268e-02f, -1.22673316e-02f, -6.80803880e-03f, 3.39578167e-02f,
  2.08230950e-02f, 5.53933568e-02f, -3.70196328e-02f, -4.13316563e-02f, 3.63930129e-02f, 3.75803970e-02f, -6.15792908e-02f, 6.06839219e-03f, 3.79295498e-02f, -1.25137356e-03f,
  -5.66730611e-02f, -9.03275162e-02f, -1.88960638e-02f, -8.75340179e-02f, -3.19495723e-02f, 1.72081329e-02f, 6.17282540e-02f, -2.44496316e-02f, 1.50488187e-02f, 1.77225471e-02f,
  1.68620553e-02f, 1.94345079e-02f, 5.06190676e-03f, 4.37618122e-02f, 3.99107337e-02f, -5.49686886e-02f, -1.63671877e-02f, 3.22680846e-02f, 3.18122804e-02f, -4.82205525e-02f,
  -5.02144881e-02f, 1.82308108e-02f, -7.71783367e-02f, 2.52585718e-03f, -5.21603450e-02f, 5.82622439e-02f, -4.18467186e-02f, -5.11403158e-02f, -1.41719952e-02f, -4.69047539e-02f,
  4.57385987e-01f, -1.92017872e-02f, 3.29323947e-01f, 6.22917805e-03f, 5.45013994e-02f, 1.83005795e-01f, 4.94086603e-03f, 1.96195394e-01f, 1.63987488e-01f, 2.24949159e-02f,
  1.58901185e-01f, 4.22333218e-02f, 8.63737613e-02f, 6.08090498e-02f, 1.75058499e-01f, -8.86520967e-02f, 1.43155083e-01f, 1.40247002e-01f, -2.25420520e-02f, 1.30461738e-01f,
  7.74898566e-04f, -2.00748909e-02f, 1.42120674e-01f, 2.88080201e-02f, 2.24720184e-02f, 1.63186155e-02f, -5.47961390e-05f, 3.82407457e-02f, 7.26292357e-02f, 3.43227163e-02f,
  -1.02365129e-02f, 3.81263196e-02f, 1.43430114e-01f, 9.72211733e-02f, 1.44697294e-01f, 3.21044889e-03f, -2.36089677e-02f, 1.59672089e-02f, -2.22351477e-02f, 1.71754435e-02f,
  1.86110928e-03f, 7.46030435e-02f, 2.18809005e-02f, -1.08762132e-02f, 9.94930696e-03f, -3.17643210e-02f, 3.96732651e-02f, -7.57133737e-02f, 4.25529927e-02f, 4.97250911e-03f,
  2.90449616e-02f, -4.02559303e-02f, -7.83259515e-03f, 3.05135213e-02f, -4.63628583e-02f, -6.58408180e-02f, 5.71216084e-02f, -3.87756228e-02f, -8.74522552e-02f, -1.09545281e-02f,
  -1.14540551e-02f, 1.31612584e-01f, 3.16465832e-02f, 2.13319194e-02f, 5.03977723e-02f, -5.86672835e-02f, -2.24712715e-02f, 5.93136996e-02f, -2.42506657e-02f, -3.71219181e-02f,
  7.59200100e-03f, 6.50737807e-02f, -1.92827433e-02f, 5.79092698e-03f, -2.20009591e-02f, -1.09016053e-01f, -2.51951702e-02f, -3.01498733e-02f, 4.90162745e-02f, -3.59496996e-02f,
  -4.38700020e-02f, 1.23467110e-02f, -8.42594635e-03f, -1.52892414e-02f, -3.33687626e-02f, 3.91733982e-02f, 3.21740732e-02f, -1.00795053e-01f, 1.26756672e-02f, -2.41346657e-02f,
  -6.46007583e-02f, 3.41516137e-02f, 3.47168110e-02f, -4.97837514e-02f, 1.94820222e-02f, -1.68897100e-02f, 3.27339862e-03f, 9.31478012e-03f, -5.75653903e-05f, -5.85954776e-03f,
  1.73557345e-02f, -2.68255211e-02f, -3.55407521e-02f, 6.00043219e-03f, 1.68783851e-02f, -4.68795076e-02f, -6.03993870e-02f, 1.33427586e-02f, -6.11851998e-02f, 1.53848836e-02f,
  -1.65215286e-03f, -4.14980724e-02f, -6.51782528e-02f, 7.06892982e-02f, 1.18578346e-02f, 7.30732456e-02f, 6.65791035e-02f, -9.68439691e-03f, -6.72257915e-02f, 3.55031416e-02f,
  3.66617650e-01f, -3.53735715e-01f, -5.57914712e-02f, -2.24372000e-01f, 6.42125830e-02f, -2.18495596e-02f, 7.28831738e-02f, -1.48661107e-01f, 4.48358525e-03f, -1.19065873e-01f,
  4.78780130e-03f, -2.81892065e-02f, -9.95720103e-02f, -4.96555045e-02f, 1.55067831e-01f, -7.03454390e-02f, -2.88262405e-02f, -5.17820045e-02f, -3.95001955e-02f, -1.43729657e-01f,
  -1.09686665e-02f, -4.85384464e-02f, -4.99005504e-02f, -1.24456147e-02f, 4.31183772e-03f, -3.40838986e-03f, 1.29787236e-01f, 6.15142845e-02f, -7.99239147e-03f, 6.18548319e-03f,
  6.30193800e-02f, -8.32363591e-02f, 2.29604833e-04f, -1.59025714e-02f, -1.38935344e-02f, 2.67280303e-02f, 8.03582147e-02f, 4.97313030e-02f, 1.58283636e-02f, 8.83985683e-02f,
  3.38607840e-02f, 1.70262605e-02f, 6.60847574e-02f, 3.39102671e-02f, -5.09289950e-02f, -4.48344201e-02f, -5.16040958e-02f, -4.66919169e-02f, 9.88627411e-03f, -2.21612286e-02f,
  -3.90423350e-02f, -3.71497162e-02f, -6.92548305e-02f, -4.01799148e-03f, 9.40503727e-04f, 4.05660272e-02f, -3.19079310e-02f, 7.88282454e-02f, -2.10357010e-02f, -3.18463296e-02f,
  5.92936203e-02f, -6.17100708e-02f, 8.19157586e-02f, -1.60478950e-02f, -8.01809579e-02f, -3.31321955e-02f, -3.56792323e-02f, 1.09994719e-02f, -4.59881425e-02f, -2.98364367e-02f,
  5.43418005e-02f, -6.14829324e-02f, -8.17263406e-03f, -4.73603606e-02f, -5.23048751e-02f, 1.42755574e-02f, 3.43040675e-02f, 1.07720941e-02f, 2.48117093e-02f, -2.96138804e-02f,
  -3.60159017e-02f, -4.21065278e-02f, 2.04943679e-02f, 3.30286920e-02f, -1.15445312e-02f, -6.16033971e-02f, 4.40174080e-02f, -9.76287853e-03f, 1.42959123e-02f, 4.63364609e-02f,
  -1.52541041e-01f, -1.46045536e-01f, 9.03108567e-02f, 1.59286354e-02f, -1.71343377e-03f, 4.85559963e-02f, -2.05895361e-02f, -4.71687736e-03f, 6.68940227e-03f, -1.05098705e-03f,
  2.96483412e-02f, 2.36447770e-02f, 2.19138917e-02f, -1.51448688e-02f, -8.44078790e-03f, -1.48170739e-02f, -6.15053847e-02f, 1.53304613e-03f, 1.10102473e-02f, -1.48247406e-02f,
  -3.21759023e-02f, -6.46837102e-03f, 1.63739771e-02f, -9.69626755e-02f, -7.63918459e-02f, 5.60415722e-03f, -2.04935223e-02f, -1.15283411e-02f, -1.86134707e-02f, -3.59282754e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.32650986e-01f, -8.18225965e-02f, -8.63049924e-02f, -1.67603776e-01f, -1.34687662e-01f, -3.60197365e-01f, -2.12659746e-01f, -1.63082600e-01f, 3.24638374e-02f, -1.87076349e-02f,
  -1.49055338e-02f, 5.17907590e-02f, 1.03313968e-01f, -2.10255578e-01f, 4.10274835e-03f, 8.26747045e-02f, -2.98953176e-01f, -4.36634347e-02f, -7.98605476e-03f, -1.54466137e-01f,
  -8.96194056e-02f, -8.74530226e-02f, 1.24494284e-02f, -1.02957413e-01f, -1.34741634e-01f, -9.46817026e-02f, 3.11190579e-02f, -9.51063484e-02f, -1.88512549e-01f, -7.71224918e-03f,
  7.16722012e-02f, 1.05789043e-01f, 4.63617742e-02f, 3.80582325e-02f, -8.75832662e-02f, -6.38316795e-02f, -5.27750663e-02f, 1.19338660e-02f, -2.07871124e-02f, -2.73965709e-02f,
  -1.09357089e-01f, -5.37193147e-03f, -1.25756497e-02f, -1.97348036e-02f, -4.55670282e-02f, -3.00544016e-02f, -3.65741514e-02f, 4.94746584e-03f, -2.30647195e-02f, 3.23778465e-02f,
  -4.10253741e-02f, -3.67657421e-03f, -2.15876680e-02f, 4.27788235e-02f, 2.86953580e-02f, -9.57428187e-04f, -6.09696880e-02f, -6.94144443e-02f, -8.13897625e-02f, -3.05031128e-02f,
  -8.24292749e-02f, 2.69375797e-02f, 1.87689941e-02f, 3.75919826e-02f, -1.38049424e-02f, 1.09529952e-02f, -2.45880466e-02f, 2.97237979e-03f, 5.07125864e-03f, 1.57768242e-02f,
  3.61238644e-02f, -1.01130130e-02f, 1.42366008e-03f, -5.05350530e-02f, -4.62179445e-02f, 2.50092857e-02f, 9.15089846e-02f, -4.48922394e-03f, -1.15848556e-01f, 6.15142286e-02f,
  1.74553283e-02f, 4.29580137e-02f, 3.06031276e-02f, -2.75165634e-03f, 2.89842654e-02f, 7.60483497e-04f, -2.64503006e-02f, 7.99991656e-03f, 3.85487564e-02f, 5.81201240e-02f,
  -8.97034109e-02f, -7.59736300e-02f, 3.24420407e-02f, 4.02044281e-02f, 7.12597594e-02f, -7.64495730e-02f, -1.69669893e-02f, -4.49003316e-02f, -1.12165652e-01f, -1.22975297e-02f,
  4.36041364e-03f, -7.24353194e-02f, -6.59334809e-02f, 3.98003263e-03f, -6.63955286e-02f, -6.11982681e-02f, 2.54384298e-02f, -4.71110642e-02f, -2.22310945e-02f, 9.00171697e-03f,
  7.87680447e-02f, 6.35272861e-02f, 1.90150663e-02f, 2.67093685e-02f, -6.79520741e-02f, 1.89607181e-02f, 4.19323854e-02f, -7.11639300e-02f, -1.19407907e-01f, -5.79955019e-02f,
  8.37308019e-02f, -1.25984341e-01f, 3.36406566e-02f, 4.62132059e-02f, 9.53010097e-02f, 7.08510876e-02f, 1.35759085e-01f, 5.51996194e-02f, 1.60527706e-01f, -5.93026122e-03f,
  5.14892936e-02f, -1.34361889e-02f, 2.43245568e-02f, -3.43840104e-03f, 2.10567135e-02f, -2.22384445e-02f, 7.19037727e-02f, 3.01811565e-03f, 5.04894108e-02f, 8.47454742e-02f,
  1.02498926e-01f, -2.67620906e-02f, 2.17194837e-02f, -1.98360801e-01f, -7.02294484e-02f, -1.23632587e-01f, -6.77460581e-02f, -5.96470460e-02f, -1.20064825e-01f, -6.16522543e-02f,
  5.28020822e-02f, 1.09640462e-02f, -9.95573401e-02f, 3.66014801e-02f, -8.46218169e-02f, 4.42786925e-02f, 2.20216978e-02f, -1.35770794e-02f, -5.80319874e-02f, 5.35245202e-02f,
  -2.56850105e-02f, 7.54849315e-02f, 6.23861030e-02f, -6.71593919e-02f, 7.55386576e-02f, 8.30977038e-03f, 5.88550093e-03f, -4.07487601e-02f, 6.25972003e-02f, -5.69867715e-03f,
  6.16641119e-02f, -3.68068367e-02f, 2.08361037e-02f, -8.98107588e-02f, 4.63204645e-02f, 1.98285002e-02f, 2.05898602e-02f, 3.84363905e-02f, 1.32060675e-02f, -1.63906943e-02f,
  -1.69694014e-02f, -7.16000199e-02f, -2.36492977e-02f, 5.53500317e-02f, 1.54071422e-02f, -1.10437488e-02f, 4.25447896e-02f, 3.95617634e-02f, 6.70480654e-02f, -8.45490489e-03f,
  9.74634755e-03f, 5.17076813e-02f, 4.19493392e-02f, -3.56422737e-03f, -6.11895844e-02f, -1.38050597e-02f, -3.15477811e-02f, 2.93650497e-02f, -1.13219880e-02f, -3.37059498e-02f,
  -5.51117910e-03f, -8.57589766e-02f, -1.18825488e-01f, -1.04395226e-01f, 3.46008167e-02f, -6.35021692e-03f, -5.09731993e-02f, 4.02063429e-02f, 5.39951846e-02f, 4.10157368e-02f,
  8.91434103e-02f, -1.05249202e-02f, -1.46465749e-02f, 5.77150844e-02f, -1.38682267e-02f, -8.17773938e-02f, 7.60357231e-02f, 3.26583460e-02f, 8.02972093e-02f, 7.07071945e-02f,
  -3.65568362e-02f, 1.12570830e-01f, -5.78186139e-02f, 5.57527058e-02f, 8.37695599e-03f, 7.74849132e-02f, 2.98334863e-02f, -3.50158140e-02f, -2.45465133e-02f, -4.78665382e-02f,
  -8.19678679e-02f, 8.64975750e-02f, 1.05215490e-01f, -3.71635593e-02f, 6.68177800e-03f, -1.15358308e-01f, -5.37803881e-02f, -4.24177051e-02f, 2.14165337e-02f, -6.34859502e-02f,
  8.62229317e-02f, 1.26579136e-01f, 5.55506535e-02f, -7.99212046e-03f, 1.03756033e-01f, 8.06836318e-03f, 3.76278050e-02f, 8.94006640e-02f, 1.91766024e-01f, 3.27152200e-02f,
  -9.60751399e-02f, 5.15553132e-02f, -5.23302108e-02f, -1.95365790e-02f, -5.81368804e-02f, 5.58261666e-03f, 1.03360869e-01f, 6.96762353e-02f, 1.01602748e-02f, 5.11836372e-02f,
  5.93619570e-02f, 6.42819330e-03f, -2.05501348e-01f, -1.68122619e-01f, -1.60558760e-01f, -7.03563094e-02f, -1.83888018e-01f, -6.04900010e-02f, -9.66233090e-02f, -9.87630263e-02f,
  -8.01206231e-02f, 6.43802211e-02f, 5.07337674e-02f, -4.49069105e-02f, 1.23000778e-02f, 4.93774132e-04f, -6.00210093e-02f, 2.18212069e-03f, 3.21140625e-02f, -5.44506200e-02f,
  1.06789641e-01f, -3.42127718e-02f, 5.33372797e-02f, -6.02149777e-02f, 4.73257527e-02f, -2.29134168e-02f, 8.74907337e-03f, 2.63885986e-02f, 7.07005858e-02f, -7.50852898e-02f,
  -6.47465587e-02f, 3.74594927e-02f, 1.04435794e-02f, 1.08233646e-01f, 8.41871426e-02f, 8.85091871e-02f, -1.97353326e-02f, 1.87160484e-02f, -4.74464968e-02f, -7.59220961e-03f,
  -4.41684537e-02f, 5.35650216e-02f, -3.94730717e-02f, -8.03828537e-02f, -7.07949176e-02f, -8.33925456e-02f, -1.38201443e-02f, -2.48472691e-02f, -7.94624239e-02f, 6.96804002e-02f,
  1.86562669e-02f, -1.32551910e-02f, 3.57071161e-02f, -4.56387624e-02f, 8.91920552e-02f, 9.97395664e-02f, 8.13773423e-02f, -2.99486816e-02f, -3.09043992e-02f, 2.78896205e-02f,
  -5.40386401e-02f, 4.52335691e-03f, -4.68207039e-02f, -6.26291484e-02f, 1.85041185e-02f, -6.66950718e-02f, -9.48569402e-02f, -7.45858550e-02f, 4.60024029e-02f, -7.72212371e-02f,
  6.70996755e-02f, 1.09553210e-01f, 4.43827026e-02f, 7.72929415e-02f, 3.01311798e-02f, 2.97495052e-02f, 2.49441992e-02f, 3.08674593e-02f, -4.04148139e-02f, 3.57857049e-02f,
  1.18227400e-01f, -2.27247290e-02f, 1.06349185e-01f, 7.64662772e-02f, 7.34762326e-02f, -2.35395748e-02f, 2.61649396e-02f, 5.71182035e-02f, 6.11332729e-02f, 2.91765984e-02f,
  3.06584574e-02f, 8.89122114e-03f, 9.94094908e-02f, 3.48343849e-02f, -2.23940518e-03f, -8.68025236e-03f, 1.15792401e-01f, -7.92092085e-02f, -3.30482796e-02f, 1.11459635e-01f,
  -3.07771713e-01f, 1.84633449e-01f, 2.98517514e-02f, -7.00875223e-02f, -3.12240832e-02f, -1.60572454e-02f, 1.36217654e-01f, -2.39509642e-02f, 1.73397586e-02f, 3.64841744e-02f,
  -3.53953280e-02f, 3.86964642e-02f, -2.96748057e-02f, 1.04305252e-01f, -4.70524542e-02f, 2.04018131e-02f, -2.74870060e-02f, -2.00925134e-02f, 3.07264831e-02f, -5.26463017e-02f,
  -6.11664876e-02f, -1.01006411e-01f, 1.17436126e-01f, 5.81661016e-02f, -4.19457294e-02f, -1.77083779e-02f, 1.49817197e-02f, 9.17598158e-02f, 5.05462997e-02f, 1.06721362e-02f,
  -1.58877522e-01f, -1.44979164e-01f, -1.30261555e-01f, -9.62433666e-02f, -8.90770257e-02f, -7.21077388e-03f, 1.51627688e-02f, 6.21270239e-02f, 3.93558517e-02f, -5.82894795e-02f,
  3.68968509e-02f, -5.94233023e-03f, 1.02865114e-03f, 7.52947628e-02f, -5.15732840e-02f, -1.72587689e-02f, 2.01910660e-02f, -3.30357766e-03f, 9.40096676e-02f, -2.11419929e-02f,
  1.74907092e-02f, -5.38663492e-02f, -8.06513876e-02f, -7.00423121e-02f, 9.00343508e-02f, -7.36723617e-02f, 7.87444972e-03f, -4.76592779e-02f, -5.62693216e-02f, -3.85564636e-04f,
  -1.02122299e-01f, 6.79412065e-03f, 2.25613713e-02f, 2.05972102e-02f, 3.83797996e-02f, -3.50866504e-02f, 4.62592952e-02f, -7.96121806e-02f, -5.08724414e-02f, -4.79713827e-02f,
  -4.97032516e-03f, -1.12537481e-03f, -6.81615174e-02f, 1.84472874e-02f, 1.68743283e-02f, -2.76311170e-02f, -6.96268454e-02f, 5.85226417e-02f, 8.79206061e-02f, -4.07273415e-04f,
  -7.58412480e-03f, -4.13281005e-03f, 1.87250860e-02f, -5.58886342e-02f, 2.72040977e-03f, -9.81371850e-03f, -4.44756486e-02f, -1.76948104e-02f, -7.25131556e-02f, -3.83043550e-02f,
  -1.63609430e-01f, -1.51945665e-01f, 2.17622947e-02f, -9.86445025e-02f, -5.50176427e-02f, -3.19891274e-02f, -3.54377404e-02f, 2.76689138e-02f, 2.11558882e-02f, -7.11779948e-03f,
  -8.21986124e-02f, -5.37037402e-02f, -1.40237459e-03f, 6.60579428e-02f, 2.36118138e-02f, -6.80376068e-02f, -4.73994985e-02f, -1.40644787e-02f, -7.57660046e-02f, 8.42792764e-02f,
  -2.89269052e-02f, -1.78763755e-02f, 8.94407555e-02f, -6.80229366e-02f, -5.06535284e-02f, 4.46558557e-02f, -3.32151391e-02f, -4.46434990e-02f, -7.95335621e-02f, 1.95885971e-02f,
  -1.84167549e-02f, 3.92633565e-02f, 1.20164238e-01f, 1.76138282e-01f, -8.17672759e-02f, -9.97487828e-02f, -4.01239991e-02f, -1.89366918e-02f, -1.33491427e-01f, -1.10224299e-01f,
  7.79958665e-02f, -5.82212843e-02f, 1.70433775e-01f, 8.45106244e-02f, 8.86674300e-02f, 1.19760163e-01f, 2.96841133e-02f, -1.02924258e-01f, -3.91519889e-02f, 1.56940490e-01f,
  8.71433169e-02f, 1.24728665e-01f, 2.50574112e-01f, 7.75374696e-02f, 2.07616091e-02f, 1.23185933e-01f, 1.73641071e-01f, 7.03356713e-02f, 3.76563706e-02f, -1.31910266e-02f,
  -6.83902726e-02f, -4.56711501e-02f, 5.58910854e-02f, 1.75109468e-02f, 1.15451522e-01f, -1.60537325e-02f, 7.71793276e-02f, -2.55870987e-02f, -2.77340338e-02f, -5.44686466e-02f,
  -3.77685130e-02f, 5.42411618e-02f, 1.26622373e-03f, 1.02795903e-02f, 1.25488518e-02f, 5.47045469e-02f, 2.54412275e-02f, -3.21558602e-02f, 1.63013469e-02f, 3.01744938e-02f,
  5.30383922e-02f, 2.65802760e-02f, 7.59018511e-02f, 1.13898320e-02f, 3.10320985e-02f, 4.80399132e-02f, -4.26507592e-02f, 4.33789752e-02f, 1.24833779e-02f, -3.28087881e-02f,
  -6.58147596e-03f, 9.38832818e-04f, -7.28730485e-02f, -1.07570753e-01f, 5.95352873e-02f, 4.96542528e-02f, -6.10195920e-02f, 4.38283570e-02f, 4.43849862e-02f, 8.05697814e-02f,
  4.58847508e-02f, -5.58760501e-02f, 8.62062152e-04f, -1.08833341e-02f, 8.41527656e-02f, 9.39632878e-02f, 2.31545549e-02f, -8.97368565e-02f, -5.90582080e-02f, -4.83476780e-02f,
  6.84070885e-02f, -4.81609777e-02f, -2.39272844e-02f, -9.20808092e-02f, 6.91203680e-03f, 1.08203543e-02f, 5.53699695e-02f, -2.05270834e-02f, -6.50467724e-02f, -2.97360010e-02f,
  1.52278319e-02f, 1.33331731e-01f, -1.03353290e-02f, -2.52138898e-02f, 8.12944099e-02f, 6.82693794e-02f, -3.82507071e-02f, 1.00150267e-02f, 8.28034356e-02f, 8.57050791e-02f,
  4.77055870e-02f, 1.18495412e-02f, 6.56790137e-02f, 4.75408547e-02f, 1.17625725e-02f, 2.70162597e-02f, 7.79977217e-02f, -6.09917156e-02f, -4.32804860e-02f, -4.03139368e-02f,
  -4.62322384e-02f, -9.64665338e-02f, -4.60440759e-03f, -4.94527034e-02f, -1.34646147e-02f, 3.57045121e-02f, -2.26438325e-02f, -4.32275571e-02f, -7.91801326e-03f, -2.56088376e-02f,
  8.50061141e-03f, -4.05862518e-02f, 1.99577454e-02f, -6.89836591e-02f, 5.88989183e-02f, -9.07074511e-02f, -9.69138443e-02f, -3.07625365e-02f, -3.74473818e-02f, -1.68697303e-03f,
  3.22443657e-02f, -2.48912778e-02f, -4.67637330e-02f, -5.70484065e-02f, -6.70125037e-02f, 2.09563840e-02f, 8.12296383e-03f, 6.91969553e-03f, -1.30168826e-03f, -4.20794487e-02f,
  -1.96920298e-02f, -9.98124713e-04f, 3.24923731e-02f, -3.99625152e-02f, -1.55579159e-03f, -7.08819255e-02f, -1.60019584e-02f, -3.89002860e-02f, 2.55890843e-02f, 1.36982827e-02f,
  -4.41961028e-02f, 2.60360632e-02f, 1.27036255e-02f, -3.82469334e-02f, -5.19564077e-02f, -6.76079765e-02f, -4.36329916e-02f, -7.36936852e-02f, 4.25486304e-02f, 4.52378020e-02f,
  6.64637238e-02f, 4.46510166e-02f, 3.25025916e-02f, -7.64415711e-02f, -4.18051817e-02f, -1.25862397e-02f, -8.46509710e-02f, -7.02894777e-02f, 1.02357287e-02f, -1.87884718e-02f,
  -7.40333647e-02f, 9.63391289e-02f, -7.05171525e-02f, 8.76809061e-02f, -4.08452898e-02f, 3.22320834e-02f, 7.56325722e-02f, -6.49686903e-02f, 7.82796219e-02f, 7.69644603e-02f,
  -4.66476232e-02f, -4.81836647e-02f, -5.27659506e-02f, -1.90913137e-02f, 1.55869784e-04f, 5.99970445e-02f, 7.75380582e-02f, 2.89509222e-02f, -8.16829130e-02f, -6.01504743e-02f,
  1.05156004e-02f, -4.98648472e-02f, -2.76822075e-02f, -3.52832079e-02f, 6.73968419e-02f, 6.39339238e-02f, -5.03222533e-02f, 7.17176124e-02f, -4.39018533e-02f, 4.66864407e-02f,
  -7.72366077e-02f, -4.61200178e-02f, -4.71563786e-02f, -8.38904828e-02f, 7.21483752e-02f, 8.72258842e-03f, 1.03034601e-02f, -7.30575696e-02f, -1.55853061e-02f, -7.91827291e-02f,
  -7.96834305e-02f, -2.00914294e-02f, -1.19801518e-02f, 2.04126220e-02f, -7.87615180e-02f, -5.38951438e-03f, -6.46105409e-02f, 1.31637873e-02f, 7.43193924e-02f, 2.96495799e-02f,
  -7.11881071e-02f, -8.78072083e-02f, -7.36522153e-02f, -6.96408972e-02f, -1.03378398e-02f, 7.68214613e-02f, -7.88414553e-02f, 5.12905158e-02f, 4.00389545e-03f, -1.41230377e-03f,
  4.42294665e-02f, -3.36002670e-02f, -4.48430181e-02f, 7.42917554e-03f, 5.52628040e-02f, -1.45388180e-02f, 2.44463142e-02f, -5.66938706e-02f, 7.31917769e-02f, 8.48034546e-02f,
  -1.59367710e-01f, 1.18886568e-01f, -5.12223393e-02f, -1.32037222e-01f, 2.83439513e-02f, -1.06502086e-01f, 3.60603817e-02f, 7.11895302e-02f, 1.18401892e-01f, 8.92252550e-02f,
  5.21643795e-02f, 2.00052392e-02f, 1.04016311e-01f, 4.13500331e-02f, -2.10399181e-01f, -6.96561784e-02f, -2.49607340e-01f, -1.07738309e-01f, 5.17636351e-03f, 1.77252665e-02f,
  -1.37585640e-01f, -1.70865916e-02f, -1.60888880e-01f, 1.05201587e-01f, -3.37988175e-02f, 4.20942865e-02f, -5.38281864e-03f, 1.14165619e-01f, 5.47356308e-02f, -2.15072650e-02f,
  -1.28784264e-02f, -5.11589386e-02f, -2.80264276e-03f, -5.88436611e-02f, -7.28845596e-02f, -7.29557052e-02f, -1.16597503e-01f, 5.11083677e-02f, 6.10052831e-02f, -4.34558578e-02f,
  1.08227162e-02f, 5.89671880e-02f, 6.79995418e-02f, -2.42966805e-02f, 6.92193285e-02f, 8.39894190e-02f, 2.46820785e-02f, 1.39472063e-03f, 5.48900403e-02f, -7.37644406e-03f,
  -4.61853168e-04f, -3.75201888e-02f, -1.05310269e-02f, -6.10147566e-02f, -8.48501772e-02f, -4.05106619e-02f, -1.16309077e-02f, 4.65067066e-02f, -1.12983450e-01f, 5.52304182e-03f,
  -8.52864757e-02f, 5.53409830e-02f, -8.27284306e-02f, 2.38217339e-02f, 7.43083470e-03f, -4.20660712e-02f, 3.11941803e-02f, 3.67498919e-02f, 3.40050720e-02f, -5.92908300e-02f,
  7.03343078e-02f, -3.80933881e-02f, 8.75379294e-02f, -4.62020002e-02f, 1.89452320e-02f, -2.01647040e-02f, 1.68015584e-02f, 3.43137421e-02f, 6.29615635e-02f, -4.45088670e-02f,
  2.86474396e-02f, 1.05925448e-01f, 5.97051643e-02f, -9.37359631e-02f, -1.03897713e-02f, -5.36587499e-02f, -1.83539931e-02f, 4.30402458e-02f, 8.83367285e-02f, -8.42945054e-02f,
  -6.57555014e-02f, -4.56261728e-03f, 5.43601960e-02f, -4.60034274e-02f, 2.80080345e-02f, -3.01243807e-03f, 1.73340533e-02f, -6.79238215e-02f, -6.05301596e-02f, -1.99111737e-02f,
  2.56173667e-02f, -1.01389189e-03f, -5.14647961e-02f, -7.12940516e-03f, -2.10893732e-02f, 7.74927735e-02f, -1.92445256e-02f, -3.66213475e-03f, -7.26841018e-02f, 1.66965537e-02f,
  2.59239855e-03f, -4.43616174e-02f, -3.06114685e-02f, -6.48791566e-02f, -3.39065753e-02f, 5.75922541e-02f, -7.51174763e-02f, 8.75700861e-02f, 8.38588830e-03f, 6.48741052e-02f,
  -1.61585793e-01f, 1.30278394e-01f, -1.38267577e-01f, 1.16174847e-01f, -3.89784196e-04f, 7.73325339e-02f, 4.54149358e-02f, 6.93287104e-02f, 9.45458654e-03f, 1.17324419e-01f,
  1.58628643e-01f, 2.48400848e-02f, -6.56287419e-03f, 9.69759151e-02f, 1.13574699e-01f, 1.04958557e-01f, 6.32603914e-02f, 1.50148064e-01f, -4.07158621e-02f, 5.37133776e-02f,
  1.32130221e-01f, 2.22287074e-01f, 3.52937430e-02f, -4.30676416e-02f, 1.07019976e-01f, -8.65715593e-02f, 5.76499179e-02f, -2.48130709e-02f, 9.08974037e-02f, -5.25318608e-02f,
  6.90112561e-02f, 3.55462767e-02f, -1.29286842e-02f, -8.23142659e-03f, -1.02121159e-02f, -1.55174443e-02f, 3.22511308e-02f, 1.02191381e-01f, -8.97326022e-02f, 6.04182705e-02f,
  4.90324898e-03f, 3.54329706e-04f, 4.96765301e-02f, -8.72376636e-02f, 2.37624962e-02f, -1.88222118e-02f, -6.77727535e-02f, -4.76229936e-02f, -2.32661911e-03f, 4.46597300e-02f,
  -5.08107878e-02f, -5.29605746e-02f, -2.12683100e-02f, 7.11564869e-02f, -6.84505776e-02f, -3.44812088e-02f, 6.09048530e-02f, -3.98622639e-03f, -4.91416901e-02f, -2.74963398e-02f,
  -8.50667506e-02f, 5.54191135e-02f, 7.74008781e-03f, 3.11261192e-02f, 1.98565796e-02f, -1.74671467e-02f, 4.28646654e-02f, 8.71153921e-02f, -9.38724428e-02f, -2.74022482e-02f,
  4.45017554e-02f, 1.45876892e-02f, 4.23061140e-02f, -6.74215257e-02f, -4.69620042e-02f, -8.11805949e-02f, 5.88600105e-03f, -3.76219526e-02f, 9.67876092e-02f, -5.37013225e-02f,
  -1.52808167e-02f, -7.64960051e-02f, 9.96779799e-02f, -2.36985199e-02f, 1.07389353e-01f, 7.72541612e-02f, 2.36134809e-02f, -6.09242953e-02f, -5.59410416e-02f, -6.78359643e-02f,
  7.26553798e-02f, 4.24849465e-02f, 3.81509252e-02f, -3.58058251e-02f, 3.96090001e-02f, 1.07777238e-01f, -5.58104366e-02f, 4.22793552e-02f, -6.09552711e-02f, -4.57982458e-02f,
  -4.86455001e-02f, -1.25971913e-01f, -1.06458887e-02f, -2.44274959e-02f, -3.61691788e-02f, 9.92191881e-02f, -2.69673262e-02f, -6.50059506e-02f, 3.29659730e-02f, -6.77643716e-03f,
  -1.19714709e-02f, -5.08519188e-02f, 8.33415315e-02f, -5.37666567e-02f, -2.56185629e-03f, -4.48094197e-02f, 4.48191352e-02f, 5.65159246e-02f, 8.29396695e-02f, 6.68567941e-02f,
  -5.16266562e-02f, 1.30812705e-01f, 4.10637259e-03f, 1.06187940e-01f, -1.19113072e-03f, -9.70661789e-02f, 6.89882506e-03f, 4.85751033e-02f, 1.19215176e-01f, -6.37866259e-02f,
  7.96580280e-04f, 7.65651166e-02f, 3.73754613e-02f, -1.33675253e-02f, -4.11948413e-02f, 1.02890059e-02f, -6.53635338e-02f, 3.16229276e-03f, 2.96026841e-02f, -4.25254144e-02f,
  8.53152655e-04f, -7.14495257e-02f, 1.09292760e-01f, 3.99491191e-02f, 2.02385131e-02f, -5.34826629e-02f, -3.35923359e-02f, 3.15626450e-02f, -4.47891988e-02f, -9.95380133e-02f,
  4.58445624e-02f, 3.17731090e-02f, 4.37207855e-02f, 8.66131112e-02f, -6.47487193e-02f, 4.98621464e-02f, 6.11240463e-03f, 5.34240231e-02f, 1.33253550e-02f, -3.02907098e-02f,
  4.30032201e-02f, -6.02844954e-02f, -3.91751118e-02f, -1.72242951e-02f, -2.51133479e-02f, 6.97887456e-03f, 6.24614991e-02f, 2.27887314e-02f, 5.80298007e-02f, 9.43757221e-03f,
  -3.47464569e-02f, 4.77328263e-02f, 7.12654646e-03f, 9.05400068e-02f, 4.16539125e-02f, 3.29243354e-02f, -7.01167509e-02f, 5.10445759e-02f, -6.94406452e-03f, 1.35682616e-02f,
  6.45634346e-03f, -5.48361465e-02f, -2.81957984e-02f, -1.56874638e-02f, -6.27376437e-02f, -9.57209840e-02f, 5.20998314e-02f, 2.23574694e-02f, 4.97106696e-03f, 2.73750611e-02f,
  3.03460918e-02f, -3.94028239e-02f, -7.40883080e-03f, -3.37036848e-02f, -4.87104431e-02f, -7.34196380e-02f, 8.15578848e-02f, -5.86750694e-02f, 2.43272576e-02f, 3.87738831e-02f,
  3.63855576e-03f, -4.34611849e-02f, -4.86697331e-02f, -8.30132514e-03f, -1.72619764e-02f, -2.41109934e-02f, -4.44770828e-02f, 2.19898447e-02f, 5.36950827e-02f, 6.12784848e-02f,
  7.73365870e-02f, 1.09707974e-01f, -2.99398266e-02f, 3.33776772e-02f, 2.34869216e-02f, 6.43068925e-02f, -6.28323704e-02f, 1.46647571e-02f, 8.47618580e-02f, 9.07610878e-02f,
  7.13399276e-02f, 6.99970499e-02f, -8.63473490e-02f, -3.47358175e-02f, -5.14753722e-02f, -2.39281021e-02f, 4.59933504e-02f, 3.50722596e-02f, 8.94526169e-02f, 3.25980447e-02f,
  -4.94650006e-02f, -9.03178006e-02f, 1.49242701e-02f, 6.54902533e-02f, 6.51077256e-02f, 6.22074567e-02f, -7.78601095e-02f, -1.49030080e-02f, 5.30306920e-02f, 9.28209126e-02f,
  -3.51051725e-02f, -2.36891769e-03f, -6.55185655e-02f, 6.89634830e-02f, 8.77584890e-02f, -8.74605961e-03f, -3.01337359e-03f, 3.63818631e-02f, -6.73014224e-02f, -1.12367431e-02f,
  4.71989997e-02f, -1.21499702e-01f, -1.63313404e-01f, 3.44184637e-02f, -8.18719566e-02f, -2.79916320e-02f, -8.32157359e-02f, -4.21720184e-02f, -3.69381458e-02f, 2.00231969e-02f,
  -4.84411791e-02f, 1.04397282e-01f, 4.13237698e-02f, -7.03174900e-03f, 4.00872156e-02f, 4.61330675e-02f, 1.02971971e-01f, -4.55224998e-02f, 2.66792551e-02f, -1.02000069e-02f,
  2.00894140e-02f, -6.30585849e-02f, 4.67778780e-02f, -9.01157632e-02f, 4.77029197e-02f, -8.66142437e-02f, 4.94970419e-02f, -1.46443322e-02f, -1.56652462e-02f, -4.21480536e-02f,
  -2.92246267e-02f, 5.64059466e-02f, 8.69852751e-02f, 5.79782985e-02f, 2.85772756e-02f, 2.79643689e-03f, 3.08864415e-02f, 4.38065901e-02f, -1.77257787e-02f, 4.74963430e-03f,
  -4.06861193e-02f, -1.04688957e-01f, 5.23344912e-02f, -3.38720120e-02f, 8.53098705e-02f, -7.54373148e-02f, -1.66921914e-02f, 7.84947649e-02f, 5.57415129e-04f, 7.64940232e-02f,
  2.96189617e-02f, -3.39356214e-02f, 1.35271503e-02f, -5.92978597e-02f, 4.88142967e-02f, 6.91184551e-02f, 6.01716451e-02f, 5.56157455e-02f, 6.29822686e-02f, 5.18754609e-02f,
  -1.18930237e-02f, -2.38342285e-02f, 8.01284909e-02f, -1.19473869e-02f, -6.13633879e-02f, 7.94236585e-02f, 6.56842068e-02f, -1.51212728e-02f, 4.99746241e-02f, 8.78359973e-02f,
  2.87396256e-02f, 5.07885553e-02f, -3.61289829e-02f, -5.94551563e-02f, -5.17602228e-02f, 5.87116629e-02f, -4.17599976e-02f, 1.97224449e-02f, -7.95049518e-02f, 9.76315141e-03f,
  3.10415532e-02f, -9.49275345e-02f, -2.19993964e-02f, 5.76939881e-02f, 2.44563352e-02f, 4.38469127e-02f, -5.45146801e-02f, 7.01754168e-02f, -8.50093961e-02f, 1.09751765e-02f,
  -9.27112028e-02f, 8.25063735e-02f, 6.34098426e-02f, -6.58737198e-02f, 3.56899314e-02f, 4.33572903e-02f, -6.45286366e-02f, 5.32596670e-02f, -3.88350151e-02f, 4.41756286e-02f,
  3.63727286e-02f, 7.35497773e-02f, -2.40174681e-03f, -6.23345189e-02f, 7.30364472e-02f, -4.03994285e-02f, -2.56639682e-02f, -2.74059922e-02f, 5.04312059e-03f, 2.66345814e-02f,
  1.64540097e-01f, 6.47812784e-02f, 1.13079570e-01f, 2.48195738e-01f, 4.87703197e-02f, -6.86769038e-02f, 1.36969298e-01f, 1.57343492e-01f, 2.07994521e-01f, -4.65738475e-02f,
  -1.69198518e-03f, -5.05622290e-02f, 6.83197826e-02f, -2.97804866e-02f, 1.26568809e-01f, 6.80938810e-02f, 5.13744168e-02f, 1.91010609e-02f, 1.36788011e-01f, 8.24486092e-02f,
  1.57692537e-01f, -6.56732917e-02f, 5.35449758e-02f, -1.17048882e-02f, -1.63341723e-02f, 7.47207478e-02f, -2.26620561e-03f, -3.17920186e-02f, -1.59252793e-01f, -3.13014612e-02f,
  3.47534120e-02f, 4.70286496e-02f, -3.76382587e-03f, -1.12456411e-01f, 1.28407730e-02f, -5.41363768e-02f, -2.02800892e-02f, -1.12284422e-01f, 4.80370894e-02f, 4.42034639e-02f,
  1.47755127e-02f, -1.47306398e-01f, 1.80709288e-02f, 2.70920843e-02f, -2.12924127e-02f, -4.44766833e-03f, -1.70512982e-02f, -8.66572708e-02f, 3.02920962e-04f, 3.22056562e-02f,
  9.43229534e-03f, -9.65592340e-02f, -4.63422537e-02f, -1.40380353e-01f, -5.52938543e-02f, 3.70658352e-03f, -4.00544181e-02f, -1.60753634e-02f, 1.45521211e-02f, -6.61773793e-03f,
  -1.08572669e-01f, 5.00155762e-02f, 8.27962756e-02f, 9.15626436e-02f, 3.80324610e-02f, -2.43983194e-02f, 6.31114915e-02f, -1.04959635e-02f, 4.83996309e-02f, -3.43010426e-02f,
  2.01605614e-02f, 3.04764956e-02f, -1.33449351e-02f, -4.23512049e-02f, 6.13058358e-02f, 3.92179154e-02f, 5.41377738e-02f, -3.92144509e-02f, -2.55267490e-02f, 7.81249627e-03f,
  3.08336634e-02f, 4.98497076e-02f, 5.25907241e-02f, 2.24270802e-02f, 1.11218765e-02f, -2.66268644e-02f, -1.86044555e-02f, -3.84868495e-02f, 2.78679226e-02f, -2.54965555e-02f,
  -1.74467750e-02f, 6.38594627e-02f, -1.80970579e-02f, -4.26093191e-02f, 1.83201451e-02f, -6.02663793e-02f, -1.19230188e-01f, 1.31145306e-02f, -5.36750741e-02f, -5.19112609e-02f,
  -1.14657953e-01f, 8.81824791e-02f, -9.50305089e-02f, 3.89280282e-02f, 2.46134878e-04f, 7.12379888e-02f, -3.63599695e-02f, 3.13463947e-03f, -8.86063650e-02f, -1.92520507e-02f,
  7.05213621e-02f, -4.89840731e-02f, 2.17428561e-02f, -6.32953122e-02f, -4.86029461e-02f, -7.72981625e-03f, 3.56471762e-02f, 2.24222131e-02f, 6.60493877e-03f, -1.12471506e-01f,
  8.77463371e-02f, -5.88604286e-02f, 7.68716261e-02f, 1.95132434e-01f, 7.19232187e-02f, -7.48030543e-02f, -7.09986538e-02f, 5.16480953e-02f, -8.82427245e-02f, -1.09071925e-01f,
  7.23983534e-03f, 2.23073307e-02f, -1.29589811e-01f, 1.61349192e-01f, 1.39339507e-01f, -2.30233356e-01f, 6.82968199e-02f, -9.45620909e-02f, -3.24305557e-02f, -6.50707493e-03f,
  5.74848577e-02f, 1.02260225e-01f, 1.13896139e-01f, 2.24230271e-02f, -1.36873191e-02f, 1.49403170e-01f, 6.25449792e-02f, 7.27230832e-02f, 1.87408492e-01f, -3.67148034e-03f,
  -2.74014240e-03f, -5.67860603e-02f, -2.58659832e-02f, 4.69695851e-02f, -1.23236872e-01f, -3.94977778e-02f, 3.74821387e-02f, 3.22088599e-02f, -5.77504188e-02f, -7.36898780e-02f,
  -3.95834669e-02f, 8.59218240e-02f, 8.98955688e-02f, -5.66914305e-02f, -1.97924115e-02f, 9.89883840e-02f, -1.51099300e-03f, 2.36897003e-02f, 9.10821706e-02f, -1.20643787e-01f,
  -6.54777512e-02f, 4.35770489e-02f, -3.24844420e-02f, 5.70303351e-02f, 9.20061208e-03f, -1.96164604e-02f, 5.01636229e-02f, 4.19255458e-02f, 1.02344062e-02f, 3.70149948e-02f,
  -3.91549952e-02f, -6.59348071e-02f, -8.27292632e-03f, 3.75115126e-02f, -2.50181276e-02f, 5.29044047e-02f, -8.40114057e-02f, 4.00684215e-02f, -4.03848514e-02f, 1.57575402e-02f,
  -4.80823591e-02f, 9.10921544e-02f, -1.97628364e-02f, 2.58345157e-02f, -4.84361826e-03f, 1.22335856e-03f, 3.18245180e-02f, -2.33509801e-02f, 5.19491509e-02f, -6.84335306e-02f,
  2.28079706e-02f, -7.91194066e-02f, -2.06640139e-02f, 3.99286151e-02f, 6.26423443e-03f, 4.15881984e-02f, 7.64148533e-02f, 1.47772171e-02f, -2.25489344e-02f, 1.54145304e-02f,
  -7.76745155e-02f, -3.81305367e-02f, 5.08634709e-02f, 5.14391474e-02f, -6.54641688e-02f, 4.86830212e-02f, -3.70971188e-02f, 2.94325277e-02f, -1.06801644e-01f, -6.52622581e-02f,
  1.56175243e-02f, -2.37160567e-02f, -6.50633033e-03f, 5.97970262e-02f, -1.68608669e-02f, -1.70993209e-02f, 4.15917151e-02f, -7.17507824e-02f, 4.61131558e-02f, -1.98385818e-03f,
  -5.42734042e-02f, -7.36369267e-02f, -6.90613016e-02f, 5.23173995e-02f, 1.32201761e-02f, -1.78396143e-02f, -3.99514735e-02f, -1.05521582e-01f, -6.30539879e-02f, 2.94759087e-02f,
  -1.21412342e-02f, -6.07678331e-02f, 1.23522608e-02f, 4.40034047e-02f, 9.90017653e-02f, -6.35111108e-02f, 4.55164835e-02f, -3.42107899e-02f, 2.61577684e-02f, -4.14198264e-02f,
  -8.82783309e-02f, 2.75419801e-02f, 3.99188884e-02f, -5.05548306e-02f, -1.17361741e-02f, -9.36300159e-02f, 1.10741057e-01f, -2.86428817e-02f, -2.01825295e-02f, 5.83439171e-02f,
  9.47265362e-04f, -9.24279690e-02f, 7.54697546e-02f, 5.80488667e-02f, -6.93816617e-02f, 4.38598096e-02f, 4.06789444e-02f, -8.58224407e-02f, 1.39609573e-03f, -5.68205565e-02f,
  5.59826419e-02f, 4.99294661e-02f, -6.36478141e-02f, -8.25180039e-02f, -8.02053660e-02f, -1.15467198e-02f, -7.09242001e-02f, -5.29087847e-04f, 5.04394509e-02f, -6.60402104e-02f,
  6.08348437e-02f, 5.20637608e-04f, 8.63568261e-02f, 7.75249973e-02f, -7.47049004e-02f, 9.38827544e-02f, 7.30875805e-02f, 6.90896586e-02f, -3.03159431e-02f, -7.94567689e-02f,
  -4.90857773e-02f, -5.88113293e-02f, 4.62238565e-02f, -6.73550591e-02f, -2.93481443e-02f, 7.60390535e-02f, 4.75703888e-02f, 3.16583812e-02f, 5.45553863e-02f, 2.17064340e-02f,
  -4.53092065e-03f, -4.19210228e-05f, 8.51769969e-02f, -4.44622003e-02f, -2.09259358e-03f, 1.02338148e-02f, 3.66750062e-02f, -5.43755703e-02f, 1.06295086e-01f, 7.80832814e-03f,
  1.57835186e-02f, 8.22505727e-02f, 5.55496924e-02f, -5.30199334e-02f, 5.91806918e-02f, 6.98845088e-02f, -7.00659901e-02f, 4.02449779e-02f, 3.19155375e-03f, -5.72169758e-03f,
  4.94472831e-02f, 2.69962922e-02f, -4.88127470e-02f, 7.18936175e-02f, -4.47561368e-02f, 6.20285422e-03f, 5.67824766e-02f, -4.39525135e-02f, 4.63019088e-02f, 2.16769017e-02f,
  1.04752788e-02f, -8.15414414e-02f, 4.90660295e-02f, 6.28565112e-03f, -2.82285325e-02f, 2.44042780e-02f, -1.37516689e-02f, 1.54426768e-02f, 6.44888058e-02f, 6.28337935e-02f,
  -7.71328807e-02f, 1.62814390e-02f, 2.90441830e-02f, 8.19185302e-02f, -9.23271999e-02f, -1.47000747e-02f, -9.79773104e-02f, -3.63497324e-02f, -4.53707799e-02f, 7.24644680e-03f,
  -2.90389489e-02f, 6.95043653e-02f, 8.00732970e-02f, -8.44666734e-02f, -4.52513024e-02f, -4.80281599e-02f, -1.65641345e-02f, -9.80287511e-03f, -4.73246872e-02f, 4.73451652e-02f,
  1.20278694e-01f, 4.88086045e-02f, -6.77688280e-03f, 7.45832026e-02f, -1.34736672e-01f, -1.63456976e-01f, -1.76784754e-01f, -4.08465648e-03f, -6.77429438e-02f, -1.02047525e-01f,
  5.94455898e-02f, -5.62124774e-02f, -3.32476683e-02f, -3.27923596e-02f, 2.69384794e-02f, 1.01998180e-01f, 1.06335022e-01f, -5.06524518e-02f, 5.99786118e-02f, 1.09049544e-01f,
  1.64231062e-01f, 8.05180669e-02f, 7.23714083e-02f, 1.14822142e-01f, 1.06362015e-01f, 7.96043277e-02f, 2.30476692e-01f, 8.23931247e-02f, 9.08527672e-02f, -4.11444902e-02f,
  6.28065318e-03f, 7.88132027e-02f, 3.17190997e-02f, 4.82678749e-02f, -3.55202407e-02f, -6.86497465e-02f, -6.04547076e-02f, -6.47097006e-02f, 6.15609251e-02f, -3.77378170e-03f,
  -4.61389050e-02f, -4.59123440e-02f, -1.60399433e-02f, -4.33633159e-06f, -2.91791488e-03f, -4.30988111e-02f, -3.72149958e-03f, 1.77450534e-02f, -1.04435153e-01f, -2.86329798e-02f,
  -5.89538068e-02f, -3.27647403e-02f, -1.58813614e-02f, 1.31263556e-02f, -2.01116735e-03f, -4.76472750e-02f, -3.50508317e-02f, -6.56236988e-03f, -2.89909989e-02f, -6.33207187e-02f,
  -1.61577743e-02f, 8.26547891e-02f, 8.14497545e-02f, 6.56813532e-02f, 7.01650754e-02f, 1.49781639e-02f, -5.18592540e-04f, 2.86867144e-03f, 9.16945719e-05f, 2.10656933e-02f,
  2.88112443e-02f, 6.16699383e-02f, -6.72905967e-02f, -7.66425729e-02f, 3.09884325e-02f, -8.00274685e-02f, 2.53455393e-04f, -6.89183222e-03f, -5.43847866e-03f, -5.11440895e-02f,
  3.76915634e-02f, 8.09065923e-02f, 2.08112504e-02f, -1.30517688e-02f, 2.88118813e-02f, 6.67675734e-02f, 6.57643899e-02f, -1.07950047e-02f, 2.23061685e-02f, 4.85789916e-03f,
  -3.86455022e-02f, 1.35464847e-01f, -8.27374831e-02f, -8.12619552e-02f, 5.56579977e-02f, -3.13745365e-02f, 7.17620924e-02f, 2.75743846e-02f, 6.62020147e-02f, 1.15497656e-01f,
  8.94138869e-03f, 8.68965685e-02f, 4.49805595e-02f, 4.76546288e-02f, -8.72062445e-02f, 7.93984458e-02f, 3.78272869e-02f, -5.00123911e-02f, 1.44466432e-02f, -4.80401479e-02f,
  6.94373697e-02f, 5.24320751e-02f, -1.15483198e-02f, -6.62451833e-02f, -1.07483901e-02f, 1.82371996e-02f, -8.30538347e-02f, 5.21443896e-02f, -3.81948799e-02f, 5.01188301e-02f,
  8.12853798e-02f, 7.69543462e-03f, -4.32816558e-02f, -7.84816667e-02f, 3.34301665e-02f, -3.81961837e-02f, 1.87160019e-02f, -2.96230782e-02f, 6.58130273e-02f, -7.28227720e-02f,
  -8.89973342e-02f, 6.47085235e-02f, 3.27684283e-02f, 1.91400256e-02f, -3.29963006e-02f, -5.92607334e-02f, 2.09886301e-02f, 7.73124695e-02f, 6.65647760e-02f, 1.79920569e-02f,
  -2.95008756e-02f, 2.77097356e-02f, 8.89595151e-02f, -9.41112414e-02f, -1.03400551e-01f, 6.70192018e-02f, -1.46282353e-02f, -8.70964453e-02f, -4.95698117e-02f, -8.38616937e-02f,
  -7.42923990e-02f, 5.92072261e-03f, 5.19489422e-02f, 7.70423263e-02f, -8.78552943e-02f, -3.22189666e-02f, 6.97697550e-02f, -3.48499827e-02f, 4.36630808e-02f, 8.15850943e-02f,
  -2.81250756e-02f, 4.85851942e-03f, -5.75807095e-02f, 8.46379325e-02f, -8.32964331e-02f, -9.51770321e-03f, -4.30233032e-02f, -1.67810488e-02f, 5.33204852e-03f, -1.62992086e-02f,
  -1.71349794e-02f, -8.86913091e-02f, -1.78725757e-02f, -2.68761292e-02f, 5.07543273e-02f, -5.51546812e-02f, 2.87856590e-02f, -5.08938842e-02f, 6.26152456e-02f, 4.94582504e-02f,
  3.55220065e-02f, 3.84703614e-02f, 8.09151381e-02f, -5.15979063e-03f, 1.26654375e-02f, 9.96065810e-02f, 6.12801723e-02f, -2.87487567e-03f, -3.29425819e-02f, 4.96369302e-02f,
  7.67215714e-02f, 4.36609723e-02f, -8.24946165e-02f, -6.22133277e-02f, -2.76012477e-02f, 1.63071528e-02f, 7.70216957e-02f, -5.06886579e-02f, -6.07448667e-02f, 3.00854389e-02f,
  -1.45098995e-02f, -4.02542464e-02f, -2.80618910e-02f, 4.32736538e-02f, 6.41849311e-03f, 6.33570775e-02f, 5.17719164e-02f, 3.83590758e-02f, -4.12087664e-02f, -6.54414073e-02f,
  7.62990415e-02f, -1.94098968e-02f, 2.86076404e-02f, -6.39997423e-02f, -6.39461204e-02f, 8.87283161e-02f, -3.58923315e-03f, -3.78751270e-02f, 8.36695060e-02f, 8.73684213e-02f,
  3.37814819e-03f, 3.84943150e-02f, -7.51435310e-02f, 4.79301671e-03f, 7.39651499e-04f, 2.70291511e-02f, -5.46545275e-02f, -6.33813813e-02f, -7.21020326e-02f, -9.09316465e-02f,
  -5.10564782e-02f, 7.26732761e-02f, 4.28741053e-02f, -2.43787356e-02f, -1.02103084e-01f, -9.51116011e-02f, 4.80522886e-02f, -3.13311033e-02f, -7.84970894e-02f, 7.17232004e-02f,
  -2.22679272e-01f, -1.71146691e-02f, 6.54083565e-02f, -1.14371240e-01f, 1.44205347e-01f, 3.15056071e-02f, 1.06315117e-03f, 1.34024948e-01f, -7.56615922e-02f, -7.60893971e-02f,
  2.61313561e-02f, 3.23240310e-02f, 9.25954655e-02f, 4.31103632e-02f, 1.55358380e-02f, 1.32291694e-04f, -1.80980209e-02f, -7.94199184e-02f, -4.03686874e-02f, -8.53178743e-03f,
  3.04115228e-02f, -3.30277346e-02f, 8.80045071e-02f, 7.39246160e-02f, 5.71075492e-02f, 5.61933182e-02f, -8.02151337e-02f, 9.97194797e-02f, 9.95659903e-02f, 7.48164207e-02f,
  1.52757089e-03f, -1.16460904e-01f, 1.69524718e-02f, 9.13808239e-04f, -2.91765667e-02f, 2.25860532e-02f, -9.82346609e-02f, -1.66146476e-02f, 7.05996007e-02f, 2.32062838e-03f,
  5.78181632e-02f, 1.86316948e-02f, -7.59968022e-03f, 5.12496680e-02f, -3.43957320e-02f, 3.65794934e-02f, 7.59966746e-02f, 7.34817311e-02f, 5.52494675e-02f, 5.67957945e-02f,
  -2.26819739e-02f, 4.64791059e-02f, -8.60384479e-02f, 6.39773235e-02f, 2.57613845e-02f, -2.22388562e-02f, 6.13871664e-02f, 1.63400136e-02f, -6.56736940e-02f, -9.03163254e-02f,
  1.50437448e-02f, -4.62955460e-02f, -9.38199833e-02f, -1.85409859e-02f, 5.14459014e-02f, 8.75238925e-02f, 4.68904376e-02f, 8.54606926e-02f, 2.49206834e-02f, -3.31823295e-03f,
  9.73915830e-02f, 6.40867427e-02f, -5.37720099e-02f, -7.17367157e-02f, 2.87584052e-03f, 8.47439691e-02f, -2.93898229e-02f, 3.31360400e-02f, -7.78112374e-03f, 1.49259558e-02f,
  -5.63304648e-02f, 2.63862330e-02f, -7.36516668e-03f, -3.48183028e-02f, -7.79391006e-02f, 4.67977338e-02f, -3.92679833e-02f, -6.81706145e-02f, 4.34171502e-03f, -3.78896706e-02f,
  1.52899539e-02f, -1.49902403e-01f, 9.47208256e-02f, -1.84570579e-03f, -8.99257138e-02f, 6.46644235e-02f, -9.82184112e-02f, 1.75011661e-02f, -5.27562015e-02f, -6.61464967e-03f,
  -2.34858990e-02f, -6.68354034e-02f, -1.30242081e-02f, 8.45150799e-02f, 7.92266801e-02f, -7.69656599e-02f, -4.33913954e-02f, 8.75222869e-03f, 1.17747104e-02f, 3.21598947e-02f,
  -3.14660631e-02f, 2.45458651e-02f, 3.88578884e-02f, 5.38654700e-02f, -5.12049161e-02f, -5.67330346e-02f, -2.28575524e-02f, 4.84313555e-02f, 1.19264144e-02f, 6.61612675e-02f,
  2.39477586e-02f, -7.41585121e-02f, -7.21132010e-02f, -9.79288220e-02f, -5.37220538e-02f, -1.56590790e-02f, -6.92727417e-02f, 2.76458561e-02f, 4.24601398e-02f, 3.80841829e-02f,
  -6.77696615e-02f, 4.08719182e-02f, 2.34673247e-02f, 2.02279794e-03f, 2.77805794e-02f, -1.32962875e-02f, -1.14568286e-01f, 1.05430380e-01f, -4.07553203e-02f, -1.06645580e-02f,
  1.94635764e-02f, -4.77101617e-02f, -1.24221370e-02f, 1.80353113e-02f, -1.83229856e-02f, -8.37634876e-02f, 8.23366791e-02f, 9.58703458e-02f, -1.07256034e-02f, 4.63062339e-02f,
  5.80107719e-02f, 7.20480308e-02f, -1.93776970e-04f, 2.26548165e-02f, -4.65444066e-02f, 2.84398645e-02f, -1.19018052e-02f, 7.89997652e-02f, -2.06649280e-03f, 4.52719480e-02f,
  6.68995604e-02f, 7.61535466e-02f, -3.63791920e-02f, -5.04819676e-02f, 6.52960613e-02f, 1.26264514e-02f, 8.22601467e-02f, -1.75346453e-02f, 4.92517240e-02f, -7.10588023e-02f,
  4.01847251e-02f, -5.98530658e-02f, -3.74173149e-02f, 4.14869972e-02f, -5.16785868e-02f, -5.87723851e-02f, 4.21842113e-02f, 4.64663133e-02f, 3.48799713e-02f, 1.52020399e-02f,
  4.87272330e-02f, 2.28822697e-02f, -2.64536735e-04f, -3.43037583e-02f, 7.86458626e-02f, -1.39988940e-02f, 9.43530276e-02f, 6.03339151e-02f, -9.32014883e-02f, 3.06183342e-02f,
  -6.39590025e-02f, 6.78444728e-02f, -1.65955361e-03f, -1.73628982e-02f, 6.79723397e-02f, 1.06338307e-01f, -1.05950274e-01f, 1.31462922e-03f, 2.72041583e-03f, 6.01146333e-02f,
  6.14178330e-02f, 1.04262598e-01f, 3.55201773e-02f, 4.82617086e-03f, 8.08945894e-02f, -5.54794818e-02f, 5.18769287e-02f, 3.63665596e-02f, 5.45992106e-02f, -6.78343326e-02f,
  -3.75335775e-02f, -1.35386968e-02f, 4.19026017e-02f, 5.15616387e-02f, -2.59367116e-02f, 2.61530261e-02f, 1.67763829e-02f, -4.96381074e-02f, 1.72778517e-02f, 4.35762890e-02f,
  2.26705223e-02f, 1.02300011e-01f, -2.20203083e-02f, 6.78069741e-02f, -9.49772298e-02f, 4.32054922e-02f, 5.88045456e-02f, -5.47765158e-02f, -2.76228297e-03f, 7.05782026e-02f,
  -6.15525395e-02f, 4.92397472e-02f, 1.58559307e-02f, -1.11799471e-01f, -8.91637206e-02f, 9.96649563e-02f, -3.95394154e-02f, 9.70960259e-02f, 3.40905972e-02f, 2.41787788e-02f,
  9.75997362e-04f, 1.74115356e-02f, 7.23077059e-02f, -2.27199160e-02f, 5.26285246e-02f, 6.57153949e-02f, 3.29184942e-02f, -2.18119603e-02f, 4.64771912e-02f, 1.64703671e-02f,
  -3.59545685e-02f, 7.09587559e-02f, 6.60304502e-02f, -3.66939604e-02f, 5.15073352e-03f, -2.03293860e-02f, 5.76757593e-03f, 5.16552068e-02f, 5.56332655e-02f, 3.69778983e-02f,
  -6.65505379e-02f, -3.97928171e-02f, 5.68457432e-02f, 1.28867812e-02f, 2.54101250e-02f, -6.51854426e-02f, -8.59160945e-02f, 7.41451308e-02f, 2.51729805e-02f, 1.03132010e-01f,
  5.10888100e-02f, -2.38458789e-03f, -5.48417456e-02f, -1.00098811e-02f, 5.89048937e-02f, -9.68291014e-02f, 3.46655622e-02f, 3.02227344e-02f, -4.63742800e-02f, 4.49270308e-02f,
  -8.04573596e-02f, 6.43462762e-02f, -2.71050297e-02f, -5.45599498e-02f, -1.01711795e-01f, 8.24909508e-02f, 2.03971881e-02f, -9.55252647e-02f, 1.01087047e-02f, -9.74214673e-02f,
  -1.00587616e-02f, -3.69567722e-02f, -7.86299631e-02f, 3.96427326e-02f, -2.25464720e-02f, 5.54270186e-02f, 3.43157612e-02f, -3.07878517e-02f, 7.61168599e-02f, 8.24421048e-02f,
  1.83164012e-02f, 9.49052796e-02f, -6.39553815e-02f, -4.86683846e-02f, 6.15141615e-02f, 1.11881476e-02f, 1.87036209e-02f, 5.07739410e-02f, 6.31123409e-02f, -9.38110128e-02f,
  -3.72476615e-02f, 6.14519604e-02f, -3.44048403e-02f, -7.90446699e-02f, -7.04699084e-02f, -3.06620523e-02f, 5.06786704e-02f, -8.17785412e-02f, -6.27781302e-02f, 6.60036802e-02f,
  -7.26552233e-02f, 2.34670993e-02f, 9.24739763e-02f, 8.21901411e-02f, 4.98834923e-02f, -6.02996536e-02f, -5.51692843e-02f, -1.85067882e-03f, 3.46804895e-02f, 1.16139958e-02f,
  4.16216813e-03f, 7.27656409e-02f, 8.31669345e-02f, 5.17189987e-02f, 3.21893804e-02f, 4.89381850e-02f, -1.38724931e-02f, 3.91447544e-02f, 8.38840206e-05f, 2.01436132e-02f,
  2.59784590e-02f, -1.91172455e-02f, -1.57500152e-02f, 3.20630148e-02f, 5.15031219e-02f, 7.83229694e-02f, -1.95586085e-02f, 2.17830390e-02f, -4.87120748e-02f, 1.57170091e-02f,
  7.68672824e-02f, -5.61932987e-03f, 4.91399830e-03f, 8.55716702e-04f, -2.32443903e-02f, -4.29368094e-02f, -2.02551694e-03f, 3.21746692e-02f, 4.26048338e-02f, -5.16684800e-02f,
  1.29105985e-01f, 9.57194157e-03f, -1.92303374e-01f, -5.29476963e-02f, -3.25646065e-02f, 1.70492008e-01f, 7.61023909e-02f, -2.29999851e-02f, -1.32168957e-03f, 1.12329274e-01f,
  6.09065853e-02f, 9.79717448e-03f, 3.84218879e-02f, 2.16496244e-01f, -2.53777094e-02f, 4.55514938e-02f, 1.65980294e-01f, 5.52270412e-02f, 8.31493214e-02f, 2.31554434e-02f,
  1.69726722e-02f, 1.86705485e-01f, -5.06765097e-02f, 4.70598862e-02f, -2.50755213e-02f, -1.25720114e-01f, -6.66989982e-02f, -1.39109328e-01f, -6.34470116e-03f, 2.67680716e-02f,
  1.11162057e-02f, -5.89828491e-02f, -8.43762830e-02f, -1.19318448e-01f, -3.80122215e-02f, -6.60526007e-02f, 4.07261308e-03f, 1.48037244e-02f, 2.37920079e-02f, 3.61057110e-02f,
  -3.50520723e-02f, -6.52401075e-02f, -1.40063604e-03f, -6.12573437e-02f, 1.60510908e-03f, -6.93565086e-02f, -1.06176928e-01f, -4.15978506e-02f, -9.47625041e-02f, -9.31314006e-02f,
  -1.02405258e-01f, -6.11091033e-02f, 3.53770796e-03f, -8.64099115e-02f, 9.34302527e-03f, 1.46532888e-02f, -5.23068272e-02f, -5.53902611e-02f, 6.45244718e-02f, -5.86006679e-02f,
  6.94334954e-02f, -8.52881670e-02f, 4.23612818e-02f, -1.02493423e-03f, -5.66836111e-02f, -3.96199571e-03f, -4.89401892e-02f, -1.15013435e-01f, 6.73132166e-02f, 2.41161026e-02f,
  -5.83510660e-02f, -7.37341028e-03f, -5.42669259e-02f, 1.02402285e-01f, -3.33293490e-02f, 2.57331338e-02f, -4.70841601e-02f, 1.55440066e-02f, 1.44133521e-02f, 1.31335463e-02f,
  -5.77999614e-02f, -2.05432437e-02f, 4.01431657e-02f, 5.12078106e-02f, -4.23987433e-02f, 7.28746783e-03f, 5.84411398e-02f, 7.06996620e-02f, -4.53347079e-02f, 7.49253333e-02f,
  4.87600006e-02f, 1.51467081e-02f, 2.79492047e-02f, 2.86148544e-02f, 3.80026014e-03f, -6.00823574e-02f, -2.32290663e-02f, 8.88333097e-02f, 4.35236655e-02f, 1.92781128e-02f,
  4.09289971e-02f, -1.64247900e-02f, 4.22381796e-02f, 4.34855260e-02f, -6.68516522e-03f, 7.96881244e-02f, 1.34253344e-02f, -3.47014405e-02f, 9.09157768e-02f, -1.22435708e-02f,
  -7.70058781e-02f, 2.19750386e-02f, 3.61916907e-02f, -1.23132132e-02f, -7.16089383e-02f, -7.81558231e-02f, -6.53973147e-02f, 3.65061611e-02f, 5.09257875e-02f, 4.64721993e-02f,
  3.61256190e-02f, 7.33667687e-02f, -8.48319605e-02f, -8.50671083e-02f, 1.18968837e-01f, -5.04413247e-02f, -3.99368815e-02f, -5.74279092e-02f, 6.33495580e-03f, 8.11190112e-04f,
  -5.63478582e-02f, 1.06412023e-02f, 1.62909739e-02f, -1.02169685e-01f, -4.43678834e-02f, 4.77017881e-03f, 2.98897102e-02f, -1.99101809e-02f, 5.00899144e-02f, 1.17998190e-01f,
  -8.19775164e-02f, -6.25664368e-02f, -9.02010426e-02f, -3.25729437e-02f, 4.10172939e-02f, 2.08071750e-02f, 1.39482645e-02f, -5.77987209e-02f, -3.49167548e-03f, -5.17397746e-02f,
  -9.22340434e-03f, -2.56458297e-02f, -7.76625844e-03f, 4.76734573e-03f, -1.99246816e-02f, -3.96001432e-03f, -2.55571939e-02f, -6.79186173e-03f, -7.12604299e-02f, 4.70411032e-03f,
  1.90903165e-03f, -9.66765266e-03f, -7.99605548e-02f, -8.08099210e-02f, -7.01700225e-02f, -4.67800982e-02f, -8.46361369e-02f, -7.33912885e-02f, 3.47330421e-02f, 6.83508217e-02f,
  -9.92280617e-03f, 4.47659530e-02f, -1.00889295e-01f, 1.24480817e-02f, -2.66408864e-02f, -9.00695175e-02f, 3.75609435e-02f, -9.33693256e-04f, 8.29228982e-02f, -3.11021786e-02f,
  -5.75914718e-02f, 6.60963356e-02f, 5.39957695e-02f, 2.10371818e-02f, -6.82483763e-02f, -7.48342872e-02f, -1.08550042e-02f, -3.25252339e-02f, -4.44897339e-02f, -1.25684747e-02f,
  2.57007647e-02f, -9.12279412e-02f, -1.37662152e-02f, -8.76546949e-02f, -1.84265282e-02f, -1.19365351e-02f, 4.56865737e-03f, 3.60759944e-02f, -6.91872090e-02f, -7.35147670e-02f,
  -4.47472110e-02f, -3.42340320e-02f, 8.45100544e-03f, 6.75129890e-02f, 3.98283601e-02f, 5.01361042e-02f, -5.84038012e-02f, 1.13694128e-02f, -7.12179914e-02f, 3.15094218e-02f,
  9.59619582e-02f, 4.07522209e-02f, -4.35270704e-02f, -8.09618682e-02f, 4.14779335e-02f, 7.44088739e-02f, -2.91185994e-02f, 5.80835827e-02f, -6.04996122e-02f, -3.03801335e-02f,
  2.12556496e-02f, -4.16742936e-02f, 6.06617518e-03f, -1.42688286e-02f, -4.26868722e-02f, -6.96118698e-02f, -5.90638667e-02f, 1.30431848e-02f, 5.38547784e-02f, -4.60554026e-02f,
  6.36131838e-02f, 8.31002668e-02f, -6.49011880e-02f, -5.85477799e-03f, -2.10894435e-03f, 3.63924541e-02f, 3.10321171e-02f, 3.57143395e-02f, 6.47181273e-02f, 2.91799959e-02f,
  7.01760948e-02f, -9.21308696e-02f, 3.16577218e-02f, 5.75771555e-02f, -3.17269303e-02f, -2.01324653e-02f, 7.59643242e-02f, 3.36784013e-02f, -8.69842619e-02f, -3.70590389e-02f,
  -1.11910421e-02f, -9.22268331e-02f, 7.83632696e-02f, -2.49805897e-02f, 2.84168515e-02f, -2.60826331e-02f, 4.33434434e-02f, 4.38786335e-02f, 2.31175050e-02f, -7.84221515e-02f,
  -8.80177245e-02f, 3.30692753e-02f, 3.21029834e-02f, -4.61660177e-02f, 8.09881240e-02f, -5.73660731e-02f, -6.24915287e-02f, -7.81634822e-03f, -8.38039536e-03f, -6.67455867e-02f,
  -7.46048763e-02f, -4.24924567e-02f, -7.05938712e-02f, -3.14721391e-02f, -2.98371222e-02f, 5.09708188e-02f, -4.65780497e-02f, 3.69291455e-02f, -8.46238732e-02f, 5.57008535e-02f,
  2.48586349e-02f, -7.06275851e-02f, -1.49462726e-02f, -7.76679814e-02f, -7.94255137e-02f, -6.57622218e-02f, 8.43732730e-02f, 7.70603567e-02f, 1.71645265e-02f, 7.82973841e-02f,
  -3.38641019e-03f, 8.47542882e-02f, 8.44890401e-02f, 1.16431508e-02f, 6.24786802e-02f, 9.26283300e-02f, -8.97041112e-02f, -7.66284838e-02f, 1.02661867e-02f, -5.60119972e-02f,
  7.00310022e-02f, -3.10858563e-02f, -3.94762494e-02f, -4.14102301e-02f, 1.12655833e-02f, -5.80794811e-02f, 8.77415910e-02f, -2.95837615e-02f, -6.93238690e-04f, -3.42926616e-03f,
  -7.02574924e-02f, 3.85841280e-02f, 6.77950308e-03f, -7.08288997e-02f, 2.58359592e-02f, 3.48963886e-02f, 7.54240379e-02f, -9.43252668e-02f, 9.12231654e-02f, 2.25480013e-02f,
  -4.47138958e-02f, 3.20424438e-02f, -9.42781009e-03f, 3.71450745e-02f, 3.03905597e-03f, -8.53364393e-02f, 7.90135935e-02f, -2.80610826e-02f, -6.75712749e-02f, -7.67081678e-02f,
  3.17288339e-02f, -5.75641729e-02f, 6.15844615e-02f, -6.80193007e-02f, 2.32203417e-02f, -7.07484186e-02f, 3.44919488e-02f, -9.08372328e-02f, -4.53585833e-02f, -1.88819524e-02f,
  7.27151856e-02f, -4.78215776e-02f, 6.26088008e-02f, 3.34279723e-02f, 7.26885274e-02f, -7.88060855e-03f, -7.08579347e-02f, -4.67297509e-02f, 2.00464334e-02f, 3.64800245e-02f,
  4.31576632e-02f, 7.50376061e-02f, 5.26748747e-02f, 4.67403717e-02f, 1.75100639e-02f, -6.94284439e-02f, -8.65406170e-02f, -2.77003888e-02f, -6.82991445e-02f, 2.57207155e-02f,
  -7.90822282e-02f, -1.07899629e-01f, -6.28100783e-02f, -1.13312915e-01f, -1.57887250e-01f, -1.96578234e-01f, 1.91190038e-02f, -2.25804418e-01f, -6.20246269e-02f, -3.92158329e-02f,
  1.15469713e-02f, 1.47616476e-01f, 2.50360638e-01f, -1.73262358e-01f, 1.64125338e-01f, 1.69277161e-01f, -2.15867415e-01f, 3.43460329e-02f, -4.27340083e-02f, -3.09944749e-02f,
  -3.39623094e-02f, -5.32209165e-02f, 7.27991238e-02f, -3.87245230e-02f, -1.36130780e-01f, -1.79292127e-01f, 1.17244095e-01f, 2.06224897e-04f, -1.42663419e-01f, 1.00599088e-01f,
  -2.73733847e-02f, -9.34347808e-02f, -6.36751801e-02f, 4.83467504e-02f, -6.09016456e-02f, 2.55525354e-02f, 6.15284871e-03f, 3.27498727e-02f, -9.63034853e-02f, 1.03812143e-02f,
  1.18766904e-01f, 4.31299731e-02f, -1.48373619e-01f, 6.88792113e-03f, -6.40264973e-02f, 1.26428986e-02f, 4.10379879e-02f, 4.38634492e-02f, -7.79959112e-02f, -2.54490133e-02f,
  6.41824976e-02f, -9.19972435e-02f, 4.80555408e-02f, -3.58852185e-02f, 5.15161566e-02f, -1.46630138e-01f, -3.71915475e-02f, 2.05663070e-01f, 5.59462532e-02f, -7.74566550e-03f,
  9.79440566e-03f, 2.65876576e-02f, 6.70427456e-02f, -1.01000555e-01f, -9.84709803e-03f, -1.21652824e-03f, -7.27484226e-02f, -1.01704840e-02f, 9.30692255e-03f, -6.03822395e-02f,
  -2.13709511e-02f, -3.16850916e-02f, 1.56705696e-02f, -1.33954100e-02f, -1.24176983e-02f, 6.50635920e-03f, 1.25771109e-02f, 5.77079412e-03f, 5.68125509e-02f, -2.02586278e-02f,
  5.13196923e-02f, 1.91023871e-02f, -3.91664729e-02f, 5.50896414e-02f, -1.70557806e-03f, 8.41807500e-02f, 4.44461033e-02f, -2.89746262e-02f, -1.40843363e-02f, -1.54221725e-05f,
  -2.08425015e-01f, -1.72527581e-01f, -6.03075735e-02f, -1.84070342e-03f, 3.73596861e-03f, 6.15613908e-02f, -1.87692102e-02f, 7.86741450e-03f, -1.48550300e-02f, 5.94928861e-02f,
  -3.16054262e-02f, -3.38345184e-03f, -1.81096443e-03f, 3.79657038e-02f, -2.62308847e-02f, -7.96812847e-02f, -7.27846324e-02f, 2.47593541e-02f, -8.75190571e-02f, 2.39542518e-02f,
  -1.08552329e-01f, -2.04038457e-03f, 1.55848740e-02f, -2.89355014e-02f, 1.07673723e-02f, 1.74692404e-02f, 3.03966142e-02f, -2.73202658e-02f, 7.40314201e-02f, 2.25012563e-02f,
  -3.29526424e-01f, 1.53318018e-01f, -1.33387208e-01f, 1.96532711e-01f, -1.40424669e-01f, 1.68131635e-01f, 1.84354320e-01f, -1.56401861e-02f, 2.76499707e-03f, 1.99415386e-01f,
  1.79526404e-01f, -1.53109074e-01f, 1.55381914e-02f, 2.71974474e-01f, 5.35296872e-02f, 3.91696356e-02f, 2.42200360e-01f, 1.88897178e-01f, -1.53049231e-01f, -5.62472418e-02f,
  -8.50861818e-02f, 1.82214379e-01f, 5.85759431e-03f, -9.40522477e-02f, -3.07829492e-03f, -1.29954606e-01f, 9.66952834e-03f, -9.66153592e-02f, 2.44254190e-02f, 9.95678306e-02f,
  4.71799728e-03f, -6.14545532e-02f, -4.13330570e-02f, 2.27728835e-03f, 9.01758671e-03f, 5.06047811e-03f, -4.63822968e-02f, -7.36814663e-02f, 3.99467088e-02f, 5.60257472e-02f,
  2.07134765e-02f, -3.77510600e-02f, 1.33002758e-01f, 3.13382484e-02f, -8.79336596e-02f, -6.98380321e-02f, -1.74506716e-02f, 2.06646416e-02f, 3.84423025e-02f, -2.70810281e-03f,
  -3.59639712e-03f, 2.56052595e-02f, 7.22057596e-02f, 8.00644457e-02f, -7.96323717e-02f, 2.11265627e-02f, 3.75874713e-02f, 4.50105825e-03f, -4.02753614e-02f, 1.34489937e-02f,
  -1.79943442e-02f, -2.08518039e-02f, 1.29781254e-02f, 5.34507520e-02f, -5.85851632e-02f, -2.28847424e-03f, -9.40003712e-03f, -4.13053595e-02f, -7.40217417e-02f, -4.30175709e-03f,
  6.08530827e-02f, -4.79599237e-02f, -7.92564731e-03f, -7.55985314e-03f, 8.14146474e-02f, 2.76585482e-02f, 4.65305187e-02f, 2.81971227e-02f, -2.66642813e-02f, -5.17073311e-02f,
  7.09274560e-02f, -1.99121633e-03f, 1.09790936e-02f, 4.28839773e-02f, -3.40904519e-02f, -3.24071944e-03f, 1.79074612e-02f, -5.20017520e-02f, 4.67410125e-02f, 2.90655922e-02f,
  1.82190001e-01f, 1.28666740e-02f, 9.62680802e-02f, 4.07296233e-03f, -2.81144213e-02f, -1.44572509e-02f, 8.02126899e-02f, 3.38826180e-02f, 8.90017580e-03f, -3.60563025e-02f,
  5.62145635e-02f, 4.63859253e-02f, -2.69161966e-02f, 5.39381579e-02f, -5.40318005e-02f, 1.01645283e-01f, -1.01764323e-02f, 4.52599814e-03f, -3.37648988e-02f, -3.69748771e-02f,
  1.08331433e-02f, -6.12852573e-02f, -4.25253473e-02f, -1.54375052e-02f, 3.12151704e-02f, 4.21238393e-02f, 2.49055289e-02f, -8.27351436e-02f, -9.57648605e-02f, 7.08919466e-02f,
  -5.12785790e-03f, -9.26910117e-02f, 3.96227613e-02f, -9.33864862e-02f, 1.53571777e-02f, 8.07762295e-02f, 2.94890236e-02f, -5.33157885e-02f, -8.58184025e-02f, 7.81106055e-02f,
  7.67011940e-03f, -1.22787626e-02f, 1.14538232e-02f, -4.36577536e-02f, -3.04861441e-02f, -4.53590155e-02f, -4.57196543e-03f, -2.07924377e-02f, -7.29037896e-02f, -1.29164138e-03f,
  -4.13565822e-02f, -1.39708529e-04f, 6.33963733e-04f, -5.99859543e-02f, 1.06317446e-01f, 1.05422638e-01f, 5.04927225e-02f, -2.19574273e-02f, 1.10631518e-01f, -1.06427796e-01f,
  2.46924162e-02f, 1.26592234e-01f, -1.69161428e-03f, 6.81275651e-02f, 2.12764498e-02f, 3.69057059e-02f, 1.02973603e-01f, -2.85077356e-02f, -5.98553978e-02f, 2.16213726e-02f,
  3.17777656e-02f, 2.01039575e-02f, 4.28097174e-02f, -2.87630577e-02f, 3.37773301e-02f, -1.23367307e-03f, 5.01030423e-02f, 4.19608783e-03f, 2.86702067e-02f, 5.33954352e-02f,
  1.04061693e-01f, -4.71130386e-02f, 2.23040786e-02f, 3.00745349e-02f, -6.61134720e-02f, 7.54486620e-02f, -5.27910776e-02f, -7.51304403e-02f, 6.45355433e-02f, -3.55524221e-03f,
  4.20893691e-02f, -2.37120204e-02f, 1.06549330e-01f, 3.50935049e-02f, 7.19542354e-02f, 3.36199030e-02f, -3.64262350e-02f, -7.42146000e-02f, -1.13494834e-02f, 5.33311442e-02f,
  5.48555776e-02f, 4.36632112e-02f, -3.41275372e-02f, 2.82079875e-02f, -1.90520417e-02f, -3.89272980e-02f, -1.47486674e-02f, -8.20498243e-02f, -8.64406824e-02f, 4.86111194e-02f,
  -5.40330485e-02f, 2.55121430e-03f, 7.26067647e-02f, 6.15176782e-02f, -3.83708104e-02f, -3.42977345e-02f, 8.91237780e-02f, -4.78336103e-02f, 2.97433063e-02f, -5.11067845e-02f,
  9.21203103e-03f, 1.01215102e-01f, 7.66261369e-02f, 4.64303456e-02f, 7.49933422e-02f, 9.16167796e-02f, -1.17157400e-02f, -7.43735805e-02f, 9.79435220e-02f, -5.81308790e-02f,
  5.08881994e-02f, -5.24780639e-02f, 8.90853330e-02f, -5.97396232e-02f, -4.79604825e-02f, 6.16802555e-03f, -4.78789397e-02f, -3.41589772e-03f, 2.04288028e-02f, 8.77955835e-03f,
  3.93796116e-02f, 1.05526038e-01f, -8.92591327e-02f, -7.93431178e-02f, 5.87975886e-03f, 3.99370790e-02f, 9.94408876e-02f, -2.43436024e-02f, 1.70742394e-04f, -8.53673518e-02f,
  -1.40588105e-01f, 1.94047857e-03f, 5.55525087e-02f, 8.56986120e-02f, 7.00127752e-03f, 4.03553843e-02f, 9.49725732e-02f, -8.41786191e-02f, -1.01150416e-01f, 1.65930614e-02f,
  1.81985442e-02f, -2.20688060e-02f, 2.64304951e-02f, 1.51560514e-03f, 4.53874879e-02f, 1.46049142e-01f, 7.76028335e-02f, 1.16073467e-01f, -6.61965683e-02f, 3.88393961e-02f,
  1.07760774e-02f, 7.59329721e-02f, 7.24487305e-02f, -5.84739319e-04f, -7.79540762e-02f, 5.23792766e-02f, 3.96261625e-02f, -1.13641188e-01f, 6.25719056e-02f, -2.79151145e-02f,
  1.03986010e-01f, -3.00979870e-03f, 6.74850568e-02f, -6.62764832e-02f, -1.29711786e-02f, -5.24978004e-02f, 1.36531489e-02f, -4.14056778e-02f, -3.83275636e-02f, -7.80676082e-02f,
  -8.03625733e-02f, 6.15775920e-02f, -4.42112610e-02f, 4.40285802e-02f, 3.76942828e-02f, -9.52491909e-02f, -2.41439715e-02f, 1.58829894e-02f, -3.71932648e-02f, 2.65864655e-02f,
  4.09019887e-02f, -5.70302866e-02f, 4.02425928e-03f, 7.40176365e-02f, -6.58572465e-02f, 3.27595435e-02f, 1.40766082e-02f, -4.42875214e-02f, -4.71158419e-03f, -2.03648917e-02f,
  -4.69073877e-02f, -6.07315488e-02f, -4.56550941e-02f, -7.38716573e-02f, 5.69259236e-03f, 1.81311369e-02f, 3.36783305e-02f, 5.81072643e-02f, 1.73531901e-02f, 5.97744286e-02f,
  -1.70440711e-02f, -1.39812510e-02f, -1.27322674e-02f, -2.93867048e-02f, -7.01068118e-02f, -9.44934227e-03f, -7.34702051e-02f, -5.33660017e-02f, 6.45003887e-03f, -4.99660857e-02f,
  2.89878622e-03f, 3.04586478e-02f, 5.36233708e-02f, 7.50846267e-02f, 4.92365519e-03f, -6.75692335e-02f, 3.85702476e-02f, -4.01612483e-02f, 7.96365142e-02f, 7.10438788e-02f,
  -1.45469261e-02f, -9.31869298e-02f, -3.52091379e-02f, 6.11476786e-02f, -1.37138665e-02f, 6.24838062e-02f, -6.29946440e-02f, 6.29411712e-02f, -9.37133841e-03f, 1.67653207e-02f,
  -6.16464503e-02f, 7.68573284e-02f, 4.19130139e-02f, 5.38130738e-02f, -5.47581837e-02f, 4.51302379e-02f, 3.27942632e-02f, 5.11863157e-02f, 3.55460532e-02f, 8.62513706e-02f,
  3.61855999e-02f, 6.94991468e-05f, -4.47620787e-02f, -4.34293821e-02f, -2.35282872e-02f, -1.17154410e-02f, 2.79179625e-02f, 1.99153498e-02f, -8.47049057e-02f, -3.17069143e-02f,
  -3.71088505e-01f, 9.51321125e-02f, 1.25559252e-02f, -7.47245401e-02f, -9.67453048e-02f, -1.23698294e-01f, 1.27898261e-01f, -8.91863853e-02f, 5.25435656e-02f, 1.49407804e-01f,
  9.29617416e-03f, -8.68014544e-02f, 1.34563342e-01f, 1.08410083e-01f, -1.61721990e-01f, 9.64286178e-02f, 6.71736896e-02f, 5.78120463e-02f, -2.46662945e-02f, -4.92198542e-02f,
  -4.54592071e-02f, 5.89994080e-02f, 3.10018230e-02f, 3.06730028e-02f, -1.44140637e-02f, 3.44397202e-02f, -2.41036620e-02f, -1.77710801e-02f, 6.19115075e-03f, -1.25724360e-01f,
  -2.13957280e-02f, -1.11128591e-01f, -2.79502980e-02f, 6.42886106e-03f, -8.46379325e-02f, -4.64218110e-03f, -3.08148731e-02f, -2.57255454e-02f, -4.96470965e-02f, 2.52368450e-02f,
  3.76171805e-02f, -9.38336924e-02f, 3.18068042e-02f, 3.01828925e-02f, -7.74723068e-02f, -2.88822465e-02f, -1.53028294e-02f, -6.20282888e-02f, 8.93157050e-02f, -4.91750352e-02f,
  8.60937536e-02f, -1.34577909e-02f, -6.90957010e-02f, 7.85153285e-02f, -2.73576118e-02f, 6.84695914e-02f, 4.21505496e-02f, -3.16235721e-02f, -5.00284322e-02f, -5.13466001e-02f,
  1.63243730e-02f, 1.52373239e-02f, 8.85676369e-02f, 7.34173134e-02f, -7.97379464e-02f, 6.98877871e-02f, 3.45916972e-02f, -2.07216069e-02f, 2.23451611e-02f, 5.64580299e-02f,
  2.93431748e-02f, -1.36038316e-02f, 6.40579406e-03f, -3.83458063e-02f, -6.84941188e-02f, -2.13887170e-02f, 8.13099369e-03f, -3.08830515e-02f, -5.75440982e-03f, 3.69050466e-02f,
  -4.61553596e-02f, -4.72222567e-02f, 9.70915183e-02f, 7.01462030e-02f, -8.53244662e-02f, 1.03257354e-02f, 6.54417500e-02f, -3.54275517e-02f, -2.71553802e-03f, -7.19252974e-02f,
  -2.28898421e-01f, -2.21822813e-01f, 1.19682094e-02f, 8.34537018e-03f, 3.25214379e-02f, -3.96027602e-03f, -1.17398584e-02f, 3.60117033e-02f, -2.67548934e-02f, 1.36713916e-02f,
  -6.38908222e-02f, -3.56238447e-02f, -5.17254025e-02f, -7.27128908e-02f, 3.60905342e-02f, -1.90218666e-03f, 5.06320484e-02f, -9.09125898e-03f, -9.98866744e-04f, -9.79793146e-02f,
  3.09886169e-02f, -5.61615489e-02f, 7.59221092e-02f, 7.86566287e-02f, 5.78224994e-02f, -2.55867317e-02f, 1.42638674e-02f, 3.30219381e-02f, -8.10924396e-02f, -8.12281668e-02f,
  2.09988609e-01f, 6.97676912e-02f, -1.84367344e-01f, 8.25137496e-02f, -1.93014786e-01f, 3.60237435e-02f, 1.94661077e-02f, 2.68078726e-02f, -1.00628763e-01f, 1.07677206e-01f,
  3.63398418e-02f, -1.47952974e-01f, 1.18181914e-01f, 3.10216576e-01f, 5.72279096e-02f, 1.69757485e-01f, 1.53151199e-01f, 7.56171122e-02f, -3.62169966e-02f, 9.14271697e-02f,
  1.46438986e-01f, 2.50567079e-01f, 3.22255399e-03f, 3.19108218e-02f, -1.23122828e-02f, -4.48430553e-02f, 6.18258677e-03f, -1.66910253e-02f, 6.53038472e-02f, -5.15263416e-02f,
  1.55320363e-02f, -4.71173674e-02f, -4.84199785e-02f, -5.48093878e-02f, -1.13227004e-02f, -8.61827750e-03f, -2.65114307e-02f, 3.77792381e-02f, 9.02988482e-03f, 3.01763066e-03f,
  -7.72781372e-02f, 3.47421095e-02f, -1.35411518e-02f, -2.01110765e-02f, -7.33254030e-02f, -1.47797288e-02f, -4.99349162e-02f, -5.76672330e-02f, -3.99870798e-02f, -1.69701148e-02f,
  -9.88146961e-02f, -6.37700558e-02f, -3.28128263e-02f, 1.00729726e-02f, -2.17196010e-02f, -6.22767583e-02f, -2.64753010e-02f, -2.83315927e-02f, 7.07375333e-02f, 5.01879901e-02f,
  1.38997575e-02f, -5.15147448e-02f, 3.02907024e-02f, 6.33390620e-02f, -2.19350401e-02f, -2.65590623e-02f, 3.08464281e-02f, 4.62799110e-02f, -1.76547859e-02f, -1.35559710e-02f,
  -7.79621825e-02f, -5.15167452e-02f, -4.21832763e-02f, 1.97747699e-03f, 4.74259444e-02f, 4.34312634e-02f, 2.20260490e-02f, -4.29919874e-03f, 4.67272028e-02f, 2.24292204e-02f,
  -2.60002185e-02f, -2.67711021e-02f, 6.66312352e-02f, 3.73311304e-02f, 1.41009632e-02f, -9.79784057e-02f, -2.22279001e-02f, -1.09051494e-02f, -1.83580667e-02f, -3.15748677e-02f,
  5.30328043e-02f, 1.90965645e-02f, 4.67033871e-02f, 2.36965343e-03f, -1.60581525e-02f, 7.61829913e-02f, 8.59085377e-03f, -2.25025117e-02f, -3.28328647e-02f, -9.99546144e-03f,
  -2.58774478e-02f, 1.92242321e-02f, 3.89474146e-02f, 2.98733823e-02f, 2.97161769e-02f, 5.51649407e-02f, -1.69032777e-03f, -6.98169554e-03f, -4.59156074e-02f, 6.83696067e-04f,
  -1.36724208e-02f, -3.81681994e-02f, 1.00629730e-02f, 6.30713999e-02f, 1.18071623e-01f, -4.89733331e-02f, -3.37690301e-02f, -5.75189665e-03f, -7.98283443e-02f, -5.59239015e-02f,
  -1.03048444e-01f, 1.95871200e-02f, 1.43503686e-02f, -2.93415897e-02f, 2.66388413e-02f, -9.47447121e-03f, -4.15418372e-02f, 2.34368425e-02f, -5.72322644e-02f, 2.35431027e-02f,
  1.00208387e-01f, -6.77352697e-02f, 1.75915344e-03f, 1.14986680e-01f, 1.09660588e-01f, 9.89332199e-02f, 1.00557208e-01f, 1.60800875e-03f, 3.39682624e-02f, 4.99115624e-02f,
  9.34498161e-02f, 8.81109238e-02f, 1.30337536e-01f, 8.34094957e-02f, 3.62704173e-02f, 3.71904764e-03f, 8.90939403e-03f, -4.30341139e-02f, 2.64592860e-02f, -1.11146420e-02f,
  2.57576350e-02f, -9.18231010e-02f, 5.64134233e-02f, -1.67251043e-02f, 4.33895513e-02f, -7.71908313e-02f, -9.27966237e-02f, -1.86175952e-04f, -6.48662001e-02f, 1.58345439e-02f,
  3.19425389e-02f, 3.32421288e-02f, -3.63136805e-03f, 6.11979179e-02f, 2.83398712e-03f, -2.08041407e-02f, 1.21406401e-02f, 1.10092342e-01f, 2.64569721e-03f, 8.30163285e-02f,
  9.06023979e-02f, 6.58982396e-02f, 1.00625545e-01f, -3.73772159e-02f, 7.92940632e-02f, 1.03023261e-01f, 8.18106160e-02f, 6.80429628e-03f, -3.99926417e-02f, 4.37856726e-02f,
  4.92578372e-02f, -5.33292741e-02f, 2.08455790e-03f, -2.04546261e-04f, 4.90927845e-02f, 6.49288073e-02f, -7.50988126e-02f, -3.20477337e-02f, 6.47352412e-02f, 6.18059710e-02f,
  -3.58974524e-02f, 9.66894533e-03f, 4.74860966e-02f, 6.80009648e-03f, -1.68720298e-02f, -4.44579273e-02f, 1.20425075e-02f, 6.06915739e-04f, -7.36016184e-02f, 3.60121764e-02f,
  -1.48429163e-02f, 5.09816594e-02f, -8.89427364e-02f, -3.37288529e-03f, 5.02762161e-02f, 7.78477564e-02f, 7.64281303e-02f, -4.62278649e-02f, -7.70307183e-02f, -7.11412579e-02f,
  -1.44761195e-02f, -7.91554898e-02f, -1.24596031e-02f, -8.58836770e-02f, 1.58852693e-02f, -3.78082693e-02f, -5.10984240e-03f, -1.97417848e-02f, -2.42982991e-02f, -1.73616633e-02f,
  -7.60185942e-02f, -4.88950908e-02f, 4.06876691e-02f, 3.29120904e-02f, 9.41203237e-02f, 9.91064236e-02f, -5.92217930e-02f, -3.47574912e-02f, 8.51405859e-02f, -1.40022859e-02f,
  -1.64554752e-02f, 6.40042406e-03f, -9.84441712e-02f, -2.08675507e-02f, 4.89850622e-03f, -2.78502982e-02f, -1.18202642e-02f, -4.50743102e-02f, -1.94980614e-02f, 5.85382916e-02f,
  2.83925701e-02f, -1.00206323e-01f, -1.12583593e-01f, -6.97927549e-02f, 3.59458383e-04f, -1.19695580e-02f, -1.00147545e-01f, 4.89300629e-03f, -3.85523103e-02f, -4.35874201e-02f,
  7.49369152e-03f, 1.90144535e-02f, -1.83591042e-02f, -6.47398904e-02f, 8.79457071e-02f, -8.35911334e-02f, -7.24859238e-02f, -4.78335805e-02f, -3.85891050e-02f, -1.09566934e-01f,
  3.50591280e-02f, 2.36730520e-02f, -1.88625883e-02f, 5.95431738e-02f, -2.35841721e-02f, 3.32497582e-02f, -2.05591647e-03f, -9.23302770e-02f, 9.09307003e-02f, 1.06189221e-01f,
  2.73357844e-03f, -1.13115035e-01f, -1.14031568e-01f, -7.79187903e-02f, 2.92756897e-03f, 4.79913899e-04f, 5.47597893e-02f, 3.36968317e-03f, 4.52346019e-02f, -3.31165381e-02f,
  -6.64443057e-03f, -2.95316987e-02f, 8.89619812e-02f, -3.93469408e-02f, 4.34419662e-02f, -3.79790813e-02f, 2.86935866e-02f, 1.85477678e-02f, -4.31838259e-02f, -3.46741267e-02f,
  2.03257818e-02f, 8.30239505e-02f, 7.65330344e-03f, 1.60883479e-02f, -7.81176537e-02f, 2.74080001e-02f, 3.60894427e-02f, 2.52933837e-02f, 7.99709260e-02f, 7.98587576e-02f,
  7.99889416e-02f, -1.70747656e-03f, 4.61807810e-02f, 2.43435265e-03f, -4.70296619e-03f, -1.30944503e-02f, -3.10949888e-02f, -2.37550512e-02f, 5.54778278e-02f, 1.53101273e-02f,
  1.56928059e-02f, 4.91699390e-02f, -1.60713010e-02f, 5.32029495e-02f, 1.63548980e-02f, -3.02187204e-02f, -9.33176558e-03f, -1.92573797e-02f, -5.39139733e-02f, 3.15022133e-02f,
  -7.53113553e-02f, -4.04060446e-02f, -9.45780054e-03f, -3.35853477e-03f, 2.29382068e-02f, 5.41746654e-02f, 5.24835251e-02f, -5.98169677e-02f, 2.38734242e-02f, -7.87312537e-02f,
  -1.05719343e-01f, -6.53785169e-02f, 2.92627290e-02f, -4.10972983e-02f, 5.37588298e-02f, -5.57951108e-02f, -6.59943447e-02f, -4.67071384e-02f, -3.51627879e-02f, -8.39249194e-02f,
  6.01245575e-02f, 3.64975668e-02f, 3.48348282e-02f, -5.90354837e-02f, 1.70944706e-02f, -6.59736469e-02f, -2.84126066e-02f, -6.78007454e-02f, 1.48465596e-02f, -4.98518236e-02f,
  7.68754482e-02f, -5.32584917e-03f, -4.25419584e-02f, 8.91166031e-02f, 6.32862672e-02f, -1.34433769e-02f, 6.19842894e-02f, 1.04584776e-01f, 7.29562640e-02f, 5.16439490e-02f,
  9.78220627e-02f, 9.73751619e-02f, 5.07893674e-02f, 5.42119965e-02f, -8.67941156e-02f, -9.71453935e-02f, -3.57046425e-02f, 1.80969876e-03f, 6.34123832e-02f, -1.63544081e-02f,
  -8.63379389e-02f, 1.00655749e-01f, -2.65047094e-03f, -6.90248460e-02f, -6.39341101e-02f, -8.86254609e-02f, 5.37507760e-04f, -4.41701449e-02f, 5.53873852e-02f, 4.84421616e-03f,
  -2.73656119e-02f, -4.64676395e-02f, -1.08362965e-01f, -5.60766160e-02f, 5.04180789e-02f, -3.46487910e-02f, -6.31147474e-02f, -1.89514067e-02f, -1.18483789e-02f, -8.27480778e-02f,
  -7.32391328e-02f, -1.65827293e-02f, 1.66417245e-04f, -2.27926560e-02f, -7.51598254e-02f, 2.61478201e-02f, 6.14497922e-02f, -2.81033721e-02f, 6.70169964e-02f, -1.15120679e-01f,
  6.75954893e-02f, 5.65622700e-03f, 8.03939104e-02f, -5.46252802e-02f, 1.66013520e-02f, -1.42422700e-02f, 5.44948801e-02f, 7.68683478e-02f, -3.66088301e-02f, 6.36456907e-02f,
  8.42866376e-02f, -5.52148139e-03f, 2.21233498e-02f, 1.19862892e-01f, 9.03584287e-02f, 4.96235825e-02f, -4.93902937e-02f, 4.91388068e-02f, 3.04682255e-02f, -4.35211929e-03f,
  -4.33505774e-02f, -2.75523998e-02f, -3.12067177e-02f, 4.57469784e-02f, -2.58616041e-02f, 3.10681462e-02f, -3.32879722e-02f, -1.18822213e-02f, 2.22073533e-02f, 1.92729163e-03f,
  4.92072839e-04f, 2.65485048e-02f, -1.48868514e-02f, 2.05473360e-02f, -8.08068290e-02f, 2.29541827e-02f, 6.82664439e-02f, 6.00776561e-02f, 3.65338549e-02f, 6.53355941e-02f,
  -4.42043394e-02f, -7.94087127e-02f, 7.18403459e-02f, 3.85540836e-02f, -2.28759497e-02f, 4.27544788e-02f, -6.62755817e-02f, -7.99309090e-02f, -6.00516461e-02f, -1.00864358e-01f,
  9.29187536e-02f, 6.95638582e-02f, 8.32503438e-02f, -6.37832237e-03f, -8.42501298e-02f, -6.99652918e-03f, -9.42125246e-02f, 7.32130259e-02f, -4.73989211e-02f, 1.10441418e-02f,
  -1.98587161e-02f, -1.37134260e-02f, -3.84694226e-02f, 5.09296805e-02f, 7.34428018e-02f, -2.07362268e-02f, -8.08604881e-02f, 3.02782692e-02f, 5.93665950e-02f, 1.07004605e-02f,
  8.50531012e-02f, -1.01317480e-01f, 8.93830881e-03f, -5.49838319e-02f, 9.99107957e-02f, -5.85854705e-03f, 7.09073767e-02f, -1.24548795e-02f, 4.71254289e-02f, -4.81382608e-02f,
  5.68784438e-02f, 8.82853568e-02f, -2.64036171e-02f, 1.97514996e-01f, -7.55194128e-02f, -1.40834153e-01f, -6.77872077e-02f, 9.38710719e-02f, -2.33931411e-02f, -4.88191657e-02f,
  3.93181331e-02f, 3.02821063e-02f, -6.78992942e-02f, 1.31704837e-01f, 2.38300487e-02f, 3.86014022e-02f, 5.85788894e-06f, -7.27888048e-02f, -4.15195338e-02f, 9.90324616e-02f,
  4.47431616e-02f, 1.69432968e-01f, 4.11855131e-02f, 1.85957924e-01f, 4.23357915e-03f, 1.44657999e-01f, 1.36046082e-01f, 4.92793247e-02f, 1.07933544e-01f, 5.83408438e-02f,
  -4.77890335e-02f, -4.19876864e-03f, -7.87468031e-02f, -6.44096285e-02f, -5.59615642e-02f, 7.62690604e-02f, 1.28904423e-02f, -1.55622372e-02f, 1.09951757e-01f, -8.41834918e-02f,
  -7.38464594e-02f, -8.90004332e-04f, -1.01257883e-01f, -7.44807571e-02f, -4.46903519e-02f, 3.38471569e-02f, 4.74908166e-02f, 2.10409127e-02f, 4.04556692e-02f, 4.69343700e-02f,
  5.03390357e-02f, 1.14986738e-02f, -2.80129965e-02f, 6.23519048e-02f, -4.69262432e-03f, 9.03497040e-02f, 1.54413879e-02f, 6.05151169e-02f, -9.62426246e-04f, 9.59020201e-03f,
  -4.92459461e-02f, -3.30862566e-03f, -1.28737539e-02f, -6.55775815e-02f, 4.82653007e-02f, 2.17962526e-02f, -2.62110364e-02f, 3.74297798e-02f, -6.67089820e-02f, -4.47494052e-02f,
  7.76435062e-02f, -7.72019103e-02f, 2.45837625e-02f, -6.30028769e-02f, -3.02536301e-02f, 8.25098082e-02f, -9.88874435e-02f, 6.63939863e-02f, 7.01652989e-02f, -4.48170267e-02f,
  -1.43070519e-02f, 8.13780576e-02f, -1.04485266e-02f, -2.34365650e-02f, -1.90488007e-02f, -3.49904746e-02f, 3.40289176e-02f, 8.87865946e-03f, 5.84895946e-02f, -2.78315023e-02f,
  6.46947185e-03f, 3.03731933e-02f, -4.66008708e-02f, 2.07430348e-02f, -5.56326024e-02f, 8.21971074e-02f, 1.13450866e-02f, 7.92019963e-02f, 4.55003325e-03f, 2.25603431e-02f,
  -6.34441376e-02f, 3.50301191e-02f, -2.12235563e-02f, -8.34206194e-02f, 8.36253837e-02f, -9.64672267e-02f, 2.67269611e-02f, 9.22328383e-02f, -1.87828802e-02f, 2.66654734e-02f,
  4.24417891e-02f, 9.87830013e-03f, 6.23275265e-02f, 2.35315412e-02f, -6.98787626e-03f, -1.01730051e-02f, -5.47379144e-02f, -3.98828555e-03f, 2.04881951e-02f, 8.34974181e-03f,
  -6.95082694e-02f, 8.45758170e-02f, -4.00993936e-02f, 1.10172711e-01f, -1.34568378e-01f, -3.70167196e-02f, 6.49394542e-02f, 2.13941913e-02f, -6.94651306e-02f, 2.84660142e-02f,
  2.18456872e-02f, 5.20032533e-02f, 9.46525708e-02f, 1.58349305e-01f, 6.64764922e-03f, 1.32965147e-01f, 1.02013603e-01f, -2.33371966e-02f, -2.55409162e-02f, -2.19519828e-02f,
  9.77956108e-04f, 1.03450529e-01f, 1.45546913e-01f, 6.34118542e-02f, 7.72637948e-02f, 9.92590189e-02f, 5.83368354e-02f, -2.44099759e-02f, 4.56356816e-02f, 2.55058091e-02f,
  4.68849763e-02f, 1.03675522e-01f, 2.36916393e-02f, -1.46888401e-02f, -7.64569864e-02f, -7.17146099e-02f, -7.31586665e-02f, -5.40222488e-02f, -9.49020684e-03f, -9.59884524e-02f,
  1.71114132e-02f, -4.53909440e-03f, 5.32507040e-02f, -3.47365402e-02f, 4.83389348e-02f, -2.69111078e-02f, 2.11455952e-02f, 1.24237292e-01f, -8.05214792e-02f, -8.24634433e-02f,
  7.13539496e-02f, 7.69883171e-02f, -4.75181900e-02f, 6.28987923e-02f, -3.67482402e-03f, 6.50763586e-02f, 1.28224015e-01f, 6.23336062e-03f, 5.18390462e-02f, 2.60500200e-02f,
  1.96139570e-02f, -8.25265795e-02f, 2.99473666e-02f, 6.19495511e-02f, 4.31632027e-02f, -7.45254830e-02f, 5.65914810e-03f, 5.38355112e-02f, 9.30840746e-02f, -2.35096775e-02f,
  -1.12072248e-02f, 4.26866338e-02f, -7.97803104e-02f, -5.91292344e-02f, 4.71807458e-02f, -8.01834017e-02f, -8.29109997e-02f, -3.46169733e-02f, 4.60869856e-02f, 5.15874512e-02f,
  -5.54867461e-02f, -1.02435485e-01f, -2.15372513e-03f, 7.14282170e-02f, 3.39418650e-02f, -6.10723123e-02f, -9.64105874e-03f, 2.21133907e-03f, 1.72629487e-02f, 3.29731666e-02f,
  2.34539784e-03f, 3.40346843e-02f, -2.21157297e-02f, -1.78785231e-02f, -7.93820992e-02f, -9.40860510e-02f, 5.42175360e-02f, -3.06420457e-02f, 5.10448068e-02f, 7.38472492e-02f,
  -4.32890505e-02f, 1.69855412e-02f, -5.54616936e-02f, -3.23764272e-02f, 1.47107076e-02f, 1.08513923e-03f, -7.77930161e-03f, -1.46638295e-02f, -7.05477744e-02f, -5.36193475e-02f,
  -5.53214215e-02f, 2.40513161e-02f, -4.51582894e-02f, 2.95263361e-02f, -2.56353449e-02f, 4.75541241e-02f, 3.55371647e-02f, 2.57041994e-02f, 4.40943427e-02f, 9.29015875e-03f,
  2.07827836e-01f, 1.21557906e-01f, 1.43141374e-01f, 5.58301955e-02f, -8.40193704e-02f, -9.18522179e-02f, -7.53753856e-02f, -3.45328311e-03f, 6.19974136e-02f, -3.80767249e-02f,
  -9.37509835e-02f, 4.76037301e-02f, 7.21482327e-03f, 2.71025989e-02f, -4.83978167e-02f, 9.61435307e-03f, 6.98966580e-03f, -1.02466717e-01f, -4.20134701e-02f, 5.95178083e-02f,
  -1.05657829e-02f, 6.00291565e-02f, 7.99267367e-02f, 1.23421140e-01f, 1.30211785e-01f, 1.80234596e-01f, 3.18835489e-02f, -1.43598849e-02f, 8.56243894e-02f, -2.70250998e-02f,
  1.44554004e-02f, 6.91407127e-03f, 7.01235309e-02f, -6.13796264e-02f, -4.73580100e-02f, 8.29088911e-02f, 2.58463044e-02f, 1.04367062e-02f, 5.51474318e-02f, -3.50139812e-02f,
  -8.27438384e-03f, -2.80932290e-04f, 4.70337607e-02f, 7.05651343e-02f, -4.12067771e-03f, 7.26384297e-02f, 2.70590875e-02f, 5.19548580e-02f, -7.33062923e-02f, -1.82405710e-02f,
  8.44588280e-02f, -4.02997956e-02f, 1.31149059e-02f, 1.80917475e-02f, 2.22724769e-02f, -1.21453693e-02f, 6.37433529e-02f, 2.60929335e-02f, 5.85557669e-02f, 5.32269403e-02f,
  6.02010228e-02f, -1.18184499e-02f, -5.35824969e-02f, -9.03303176e-02f, -4.32391651e-02f, 4.81985211e-02f, 2.06433106e-02f, 6.37028366e-02f, -1.87930670e-02f, -4.10311706e-02f,
  -4.73486371e-02f, -6.96106330e-02f, 2.72843409e-02f, 2.43353862e-02f, 1.75586287e-02f, -6.44135997e-02f, 6.27812669e-02f, -9.69269779e-03f, -1.39334099e-02f, 8.10275227e-03f,
  4.20817174e-02f, -3.02785765e-02f, 6.94126412e-02f, 8.11763778e-02f, -7.91218802e-02f, -4.31635566e-02f, -8.46364796e-02f, 5.34186047e-03f, -4.66716439e-02f, 2.49905717e-02f,
  -1.09930690e-02f, 9.14814547e-02f, 2.60226987e-03f, -4.59816009e-02f, -2.78173741e-02f, -1.17719449e-01f, -1.18969947e-01f, 6.29367009e-02f, 8.81920159e-02f, 8.65745991e-02f,
  6.63788915e-02f, 2.77014393e-02f, -1.96898580e-02f, -4.79674526e-02f, 6.66133538e-02f, -8.41723531e-02f, -4.06524865e-03f, 4.15800698e-02f, 1.11159664e-02f, 1.07916534e-01f,
  -5.51590957e-02f, 3.86525616e-02f, -2.79393885e-02f, -5.36319949e-02f, -3.84470373e-02f, -5.39535210e-02f, 1.68455057e-02f, -3.42072174e-02f, -3.49652618e-02f, -5.75447418e-02f,
  6.72282875e-02f, -5.49138002e-02f, 1.43857989e-02f, -6.49142265e-02f, -8.38527083e-03f, -4.98012975e-02f, -9.02309790e-02f, -3.86202075e-02f, -7.98594877e-02f, 6.71483427e-02f,
  -4.20976393e-02f, 2.50547435e-02f, -4.50728796e-02f, -3.44699658e-02f, -3.97290289e-02f, -5.18609323e-02f, 9.79437828e-02f, 6.08009882e-02f, -6.64514601e-02f, 1.15327805e-01f,
  7.78532296e-04f, 7.13484436e-02f, 2.18779780e-02f, -1.10176699e-02f, 5.51910810e-02f, 1.02187626e-01f, 8.24688673e-02f, -1.84569787e-02f, -1.12009337e-02f, 1.04136191e-01f,
  1.25626735e-02f, -5.13360500e-02f, 5.11192568e-02f, -6.60236627e-02f, 1.67869814e-02f, 9.08742007e-03f, -5.11853993e-02f, -1.82981193e-02f, 1.42264646e-02f, 5.01905493e-02f,
  -5.12276404e-02f, -6.29682615e-02f, -5.21029197e-02f, 5.82521968e-02f, -7.90245384e-02f, -4.04379591e-02f, -4.45337445e-02f, 7.28127956e-02f, -2.96645407e-02f, -8.54024813e-02f,
  8.09342042e-02f, -3.25621739e-02f, -3.14295664e-02f, -3.99528183e-02f, -4.70167324e-02f, -6.21360876e-02f, -3.48819271e-02f, 1.75505430e-02f, -9.80456695e-02f, -3.66068780e-02f,
  8.77344459e-02f, -9.56654102e-02f, 6.16465881e-02f, -4.79277298e-02f, 1.98520347e-02f, 4.38483357e-02f, 4.98922132e-02f, -1.22748679e-02f, -1.23160575e-02f, -3.28802504e-02f,
  -9.36671253e-03f, -1.53517455e-03f, 2.77985837e-02f, -2.54128929e-02f, 1.04471020e-01f, -4.06963751e-02f, 3.02860904e-02f, -1.90727469e-02f, 3.07801017e-03f, 1.61845218e-02f,
  1.68504715e-02f, 1.04110405e-01f, 5.30648455e-02f, -5.73729202e-02f, -1.79952625e-02f, 6.53539374e-02f, -7.28462487e-02f, 8.26468691e-02f, -9.37304795e-02f, -6.13349639e-02f,
  6.04748651e-02f, 1.06591471e-01f, 6.78110793e-02f, -6.16629906e-02f, -1.36913061e-02f, 3.71928923e-02f, 4.69527654e-02f, -1.23091266e-02f, 8.66111517e-02f, -5.89257777e-02f,
  9.97044146e-02f, 2.66782213e-02f, -5.79893775e-02f, 5.44552766e-02f, -5.56641705e-02f, 8.82141143e-02f, 2.57501323e-02f, 5.04862815e-02f, 4.89133038e-02f, -5.21541461e-02f,
  5.59055395e-02f, -6.36239424e-02f, 4.49820533e-02f, -6.75450936e-02f, -3.57905328e-02f, 2.75629349e-02f, 4.71258834e-02f, -8.05964172e-02f, -6.74875453e-02f, -4.53541242e-02f,
  3.30787562e-02f, -5.21983355e-02f, 2.09093112e-02f, 5.19662574e-02f, 3.08645107e-02f, -4.16798843e-03f, -6.47532344e-02f, 1.45064713e-02f, 7.56924897e-02f, -5.74623700e-03f,
  -9.13966745e-02f, 1.09098211e-01f, -5.15501685e-02f, 5.56852967e-02f, -1.29372224e-01f, -5.46936281e-02f, 1.72462407e-02f, -2.46146675e-02f, -1.09854601e-01f, 2.78538354e-02f,
  -6.76654503e-02f, -9.88746807e-03f, -7.16049299e-02f, 6.59503564e-02f, 6.90617934e-02f, 1.29917189e-01f, -7.00161308e-02f, 7.32695982e-02f, 4.18291613e-02f, -3.77362929e-02f,
  -5.01568690e-02f, -8.55522056e-04f, 6.66900426e-02f, -2.71150377e-02f, -1.21907583e-02f, 7.69637004e-02f, -6.47902489e-02f, -7.85661340e-02f, -3.88837908e-03f, -3.68635133e-02f,
  2.57495022e-03f, 7.46091828e-02f, 1.37943383e-02f, -1.86308902e-02f, 2.31009983e-02f, -1.19960187e-02f, 6.79032654e-02f, 6.26780689e-02f, -1.96695607e-02f, 5.59590496e-02f,
  -1.74806360e-02f, 7.88024068e-02f, -3.07285376e-02f, -5.54358065e-02f, -7.95361251e-02f, -8.06009695e-02f, -7.02797761e-03f, -6.19871840e-02f, -4.20535244e-02f, 6.58423528e-02f,
  -5.79591021e-02f, -1.66735724e-02f, -3.25720049e-02f, 1.02994226e-01f, 8.93652737e-02f, 4.41848636e-02f, 6.59090951e-02f, 2.95163020e-02f, 1.01449765e-01f, 9.15758535e-02f,
  6.32160306e-02f, 4.22256626e-03f, -3.56524624e-02f, 6.73424751e-02f, -3.68588194e-02f, 5.72508238e-02f, 8.22182521e-02f, 2.20106058e-02f, -6.08754866e-02f, -8.07791762e-03f,
  -1.61643815e-03f, -4.44873609e-02f, 1.41094495e-02f, 9.81995463e-02f, -1.93997230e-02f, 5.02234288e-02f, -6.76109269e-02f, 5.36144339e-02f, -5.58304489e-02f, -4.20890376e-02f,
  -1.38978614e-02f, -3.39628980e-02f, -1.01372078e-01f, -4.52772900e-02f, 4.16674241e-02f, 1.15937367e-01f, 8.16848949e-02f, -3.49851958e-02f, 2.51447074e-02f, 1.46291424e-02f,
  -3.88842745e-04f, 2.75864210e-02f, -9.18380637e-03f, 1.22633368e-01f, -7.45010599e-02f, 9.05543715e-02f, 1.80826336e-02f, 6.30933493e-02f, -4.19823527e-02f, -3.02867107e-02f,
  4.39684466e-02f, 8.91052037e-02f, -2.17027031e-02f, -8.64531845e-02f, 5.53550422e-02f, -5.77718429e-02f, -2.42002513e-02f, -3.07725277e-02f, 1.05053492e-01f, -1.97070464e-02f,
  4.32053715e-01f, 2.04908594e-01f, 3.27472836e-01f, 3.16467613e-01f, -5.69716133e-02f, -1.56494513e-01f, 1.10766269e-01f, -7.32120574e-02f, 1.18412755e-01f, 5.61189055e-02f,
  2.80056149e-02f, 2.07506254e-01f, -4.00334410e-02f, 4.11246531e-02f, -1.87254846e-01f, 4.51807752e-02f, -9.46571156e-02f, 5.13101257e-02f, 9.33730751e-02f, 1.07026752e-02f,
  3.35918032e-02f, -1.73340678e-01f, 5.51797822e-02f, -1.21137008e-01f, 2.23404273e-01f, 1.30761787e-01f, -2.25149348e-01f, -2.41962709e-02f, 2.76485458e-02f, -1.66291222e-01f,
  -4.16886881e-02f, 4.82286140e-02f, 1.00618288e-01f, -1.80952216e-03f, -2.99455505e-02f, 1.24338008e-02f, -2.16219015e-03f, -2.97260787e-02f, 9.59631614e-03f, 4.64531146e-02f,
  7.07511650e-03f, 5.08770458e-02f, 9.67454165e-03f, 1.40363798e-02f, 4.89392085e-04f, -6.20431034e-03f, 3.71522941e-02f, 1.32232189e-01f, 2.14595813e-02f, 7.18867779e-02f,
  4.04500216e-02f, 8.30296203e-02f, -1.93806160e-02f, -4.92770597e-02f, -3.17001082e-02f, 1.22148842e-02f, -1.77232921e-02f, 3.85889709e-02f, 8.44549164e-02f, -1.43004758e-02f,
  8.57370812e-03f, -1.20582297e-01f, -3.26167457e-02f, 3.98341790e-02f, 5.25525073e-03f, -3.16052921e-02f, -1.60825383e-02f, -1.31269351e-01f, -4.03552502e-02f, 5.33258962e-03f,
  -1.72443762e-02f, -1.99020728e-02f, -5.39452173e-02f, -1.60232838e-02f, 4.49391492e-02f, -1.21389162e-02f, -4.09112759e-02f, -9.79878195e-03f, -2.57388428e-02f, 5.59367649e-02f,
  -4.32811938e-02f, 6.36516605e-03f, 9.77780484e-03f, 4.33754222e-03f, 2.29836740e-02f, 7.55597800e-02f, 5.86846732e-02f, 8.22461769e-02f, 1.76261999e-02f, -6.79118633e-02f,
  -1.48172811e-01f, -2.01799944e-01f, 2.74735764e-02f, 9.87624377e-03f, -8.30160752e-02f, 4.54727635e-02f, -3.07846777e-02f, -5.90705201e-02f, -4.19939086e-02f, -4.16146033e-02f,
  -2.44382229e-02f, 1.34438258e-02f, 1.84226371e-02f, -1.20988134e-02f, -4.59400602e-02f, 5.23014218e-02f, 9.78286471e-03f, -6.31933510e-02f, -5.58534041e-02f, -7.81091303e-03f,
  -1.98122356e-02f, -8.28911141e-02f, -8.46277773e-02f, 6.66587502e-02f, 6.82318434e-02f, -4.75763902e-02f, 2.51868181e-03f, 2.52676085e-02f, -4.83542047e-02f, -7.22803408e-03f,
  7.59260356e-02f, -3.02340705e-02f, 1.41108800e-02f, -7.39647299e-02f, -4.20995988e-02f, 5.96279874e-02f, 1.06517196e-01f, -4.40530181e-02f, -1.13838941e-01f, -1.04884312e-01f,
  2.27966774e-02f, -1.09500371e-01f, 5.30826934e-02f, 2.57813446e-02f, 7.16433451e-02f, 1.07420459e-01f, -3.06155607e-02f, 5.57200760e-02f, 7.97972269e-03f, -5.13591021e-02f,
  -4.47360650e-02f, -5.57489768e-02f, -4.52379361e-02f, 1.43270614e-02f, 1.32952118e-02f, -3.97238620e-02f, -8.71591642e-02f, 5.87244816e-02f, 2.22112797e-02f, -8.64492431e-02f,
  1.09741777e-01f, 5.29568419e-02f, -4.84740641e-03f, -6.65043890e-02f, -8.04120768e-03f, 7.45327026e-02f, 5.76687232e-02f, 1.02199689e-02f, -7.24107251e-02f, -6.20956160e-02f,
  -1.00335525e-02f, 6.87176269e-03f, 2.30461638e-02f, -2.65597031e-02f, 6.80593122e-03f, 4.51560579e-02f, 7.46479630e-02f, 3.49108502e-02f, -1.07157841e-01f, -5.86443916e-02f,
  3.46844038e-03f, 4.59254868e-02f, -9.12581980e-02f, 2.67584771e-02f, 2.82354858e-02f, -6.21770881e-02f, -7.84391537e-02f, -3.70907150e-02f, 3.86143625e-02f, 3.12946108e-03f,
  -1.39146307e-02f, -3.35969515e-02f, 6.08739741e-02f, -4.59140353e-02f, 9.91802290e-03f, -7.42810592e-02f, 1.61884781e-02f, -3.10771298e-02f, 1.73239391e-02f, -3.05116344e-02f,
  2.53858976e-02f, -6.47458062e-02f, 1.12790272e-01f, -2.63401354e-03f, -2.12360118e-02f, -7.50898495e-02f, 5.19473664e-02f, -5.85468486e-02f, 5.70986478e-04f, 8.10267963e-03f,
  -2.62921359e-02f, -5.20935729e-02f, 2.96697933e-02f, 7.95033947e-02f, -3.06960586e-02f, -7.40603951e-04f, -5.45007624e-02f, 8.90757740e-02f, 8.51827338e-02f, 2.45987978e-02f,
  5.78438900e-02f, 2.68422551e-02f, 9.26441029e-02f, 7.96132162e-02f, 3.99748748e-03f, 9.83825773e-02f, -6.64556632e-03f, -8.35793465e-02f, -4.55293544e-02f, 2.26044822e-02f,
  -1.74868479e-02f, -8.65703598e-02f, 2.67321859e-02f, -1.03773251e-01f, -1.47009697e-02f, 3.69726457e-02f, 9.63180885e-03f, 2.46216916e-02f, -8.71024206e-02f, -8.75460580e-02f,
  4.30494621e-02f, -5.50156869e-02f, -6.47186264e-02f, -2.43704431e-02f, 1.04442723e-02f, 1.43317599e-02f, 2.62055006e-02f, -2.73067784e-02f, 8.99251178e-02f, 3.79897133e-02f,
  7.23654777e-02f, -1.19255543e-01f, -6.23559766e-02f, 5.99993467e-02f, 2.37509678e-03f, -6.80917799e-02f, 8.53564814e-02f, 3.84202600e-02f, 1.06225178e-01f, -1.44586235e-01f,
  7.32182562e-02f, -2.59803310e-02f, -7.97046628e-03f, 5.00648730e-02f, -1.83991902e-02f, 6.91359788e-02f, -3.91420573e-02f, 5.46550043e-02f, 3.02207842e-02f, 7.96498060e-02f,
  1.05839051e-01f, 2.54452638e-02f, -9.62067917e-02f, -1.41072318e-01f, 6.09135665e-02f, -4.65842001e-02f, 3.69709320e-02f, 1.67728122e-02f, -1.13818891e-01f, -1.03159018e-01f,
  6.23226352e-02f, 1.53944334e-02f, -1.74414963e-02f, 6.29503429e-02f, 2.61832383e-02f, -1.54513004e-03f, -4.89656962e-02f, 1.87833961e-02f, 1.64652951e-02f, 4.95746173e-02f,
  -4.00331430e-02f, -1.00735322e-01f, 5.00089414e-02f, 6.96676522e-02f, -3.11445929e-02f, 3.86199430e-02f, 1.19831726e-01f, 6.89963475e-02f, -9.84334573e-02f, -5.87960444e-02f,
  6.51522428e-02f, -2.39278581e-02f, 1.01752430e-02f, -5.78325018e-02f, 2.10803598e-02f, 4.96438667e-02f, 4.31238897e-02f, 6.47234097e-02f, 1.92816393e-03f, 5.26187047e-02f,
  -1.18771210e-01f, -1.50322691e-02f, -3.58308963e-02f, -6.42731264e-02f, 3.03868335e-02f, -3.19196992e-02f, 3.37413661e-02f, -8.62917025e-03f, -3.70914437e-04f, -3.95963378e-02f,
  -2.77863368e-02f, 7.20007792e-02f, 7.36724958e-02f, -2.02478468e-03f, 6.41032755e-02f, 7.79111162e-02f, -2.59671677e-02f, -2.03341879e-02f, 3.20724919e-02f, 1.57754067e-02f,
  7.04380050e-02f, -1.65553540e-02f, 1.07435677e-02f, 5.39685637e-02f, -3.59832086e-02f, -5.11425622e-02f, -6.83390629e-03f, 3.27280313e-02f, 8.65170658e-02f, 6.81603849e-02f,
  2.99140662e-02f, -6.12853728e-02f, -4.69159670e-02f, 4.52479050e-02f, 9.59738791e-02f, 4.72330526e-02f, 4.90078032e-02f, -6.84487224e-02f, 6.22633360e-02f, 2.03058533e-02f,
  -5.45419715e-02f, -2.74712611e-02f, 6.05485998e-02f, 5.01789190e-02f, -6.06627669e-03f, 1.17512308e-02f, -3.89377773e-02f, 4.76006493e-02f, -2.84791682e-02f, -9.25796330e-02f,
  5.49926609e-02f, 4.04431857e-02f, 6.78042844e-02f, 4.33693714e-02f, 4.40412723e-02f, -6.11645579e-02f, -4.15451862e-02f, -4.08788491e-03f, -6.13827780e-02f, -4.39606234e-02f,
  3.38421345e-01f, 3.42830390e-01f, 3.16653490e-01f, 1.44612044e-01f, -1.81841701e-01f, -2.41267249e-01f, -1.18856393e-01f, 3.15202512e-02f, -1.09742887e-01f, 1.30640820e-01f,
  -1.11008868e-01f, 2.82385826e-01f, 4.46257442e-02f, 1.16953835e-01f, -1.11886695e-01f, -1.67613894e-01f, -4.08397941e-03f, -1.54281594e-02f, -6.37122318e-02f, 8.57322365e-02f,
  6.04848489e-02f, -1.06075950e-01f, 1.82587594e-01f, -6.47868216e-02f, 1.10477619e-01f, 1.35854483e-01f, -2.21902467e-02f, -5.43158548e-03f, 1.40205100e-01f, -1.12664565e-01f,
  -3.45568806e-02f, 4.88072149e-02f, 7.40007982e-02f, 6.15435950e-02f, 6.91832602e-02f, 1.72973946e-02f, -1.29830316e-02f, -1.63394623e-02f, -5.57940416e-02f, 5.66754416e-02f,
  5.81434071e-02f, -6.04505502e-02f, 3.83382961e-02f, 1.40348738e-02f, 7.93681219e-02f, 1.29966075e-02f, 8.98167789e-02f, 3.51364701e-03f, 4.82107289e-02f, 8.18686113e-02f,
  7.97683373e-02f, -1.28937289e-02f, 1.14347987e-01f, -3.05072125e-02f, 1.02452347e-02f, 5.13001680e-02f, -6.83197845e-03f, 6.54461607e-02f, 3.63885872e-02f, 6.89285100e-02f,
  3.04037216e-03f, 5.79326507e-03f, -2.89995726e-02f, 2.95006507e-03f, -6.10115193e-03f, -1.02283575e-01f, 1.37703056e-02f, -6.81340881e-03f, 6.21153740e-04f, -5.98850213e-02f,
  -4.21896391e-02f, 6.50594458e-02f, -2.71116998e-02f, -5.75950257e-02f, -2.46763341e-02f, -3.55924219e-02f, -4.36235406e-02f, -1.07234262e-01f, -4.60533649e-02f, -2.99748145e-02f,
  -1.01396792e-01f, -4.57423218e-02f, 5.55834696e-02f, -2.90801190e-02f, -3.65430452e-02f, -7.70286247e-02f, 3.99004705e-02f, 4.69763018e-02f, 1.46579621e-02f, 9.88975819e-03f,
  -1.92183964e-02f, 1.14307418e-01f, 3.81131507e-02f, -2.40249876e-02f, 2.82815024e-02f, -7.64819458e-02f, -2.72975885e-03f, 1.03925332e-01f, -3.38972919e-02f, -8.95059947e-03f,
  1.97557248e-02f, -4.26924713e-02f, -5.23081757e-02f, -1.40189985e-02f, -7.06306845e-02f, 3.36205214e-02f, 2.73085851e-02f, -2.58731432e-02f, 4.32766713e-02f, 9.67331417e-03f,
  2.76843961e-02f, -2.83342600e-02f, -1.07000652e-03f, -2.74141598e-02f, 2.75484156e-02f, 7.61847617e-03f, -3.55615914e-02f, 7.78756440e-02f, -4.87970859e-02f, 5.67951538e-02f,
  -1.90687669e-03f, -1.46011993e-01f, 8.94478410e-02f, 8.37127790e-02f, 1.29554402e-02f, 8.86502266e-02f, 1.57030627e-01f, -3.73576917e-02f, 3.55704948e-02f, -7.53156394e-02f,
  -8.73853415e-02f, -1.09770373e-01f, 9.02871490e-02f, -1.58220485e-01f, 7.13436399e-03f, -9.99797508e-02f, 4.98382747e-02f, -8.78595654e-03f, -8.14581439e-02f, -7.33749196e-02f,
  -4.08282839e-02f, -1.00665838e-01f, 9.22371447e-03f, -5.83135374e-02f, 6.71957806e-02f, 6.64293841e-02f, -8.93779919e-02f, 7.03973696e-03f, 5.90105169e-02f, 8.79033655e-02f,
  1.94928504e-03f, 4.24213782e-02f, -4.59224582e-02f, -4.83033955e-02f, 6.18602894e-02f, -7.72575513e-02f, 2.16981452e-02f, -7.84961358e-02f, 9.76169854e-02f, -1.63742863e-02f,
  -7.72781372e-02f, 6.43179640e-02f, 2.13925764e-02f, 3.28245200e-02f, 1.24754738e-02f, 6.41448945e-02f, 1.06225275e-01f, 4.57482859e-02f, -6.09962568e-02f, -1.09343909e-01f,
  -7.70905688e-02f, 4.82435301e-02f, 3.78383212e-02f, 6.87913299e-02f, -8.37905779e-02f, 1.06773354e-01f, -5.22234216e-02f, 2.50535272e-02f, 3.69002894e-02f, -8.57816860e-02f,
  -1.14613459e-01f, -2.58253012e-02f, 3.78131457e-02f, 6.22023791e-02f, 7.13773370e-02f, 8.24164525e-02f, -3.20305377e-02f, -1.09762801e-02f, -4.00552191e-02f, -2.05267984e-02f,
  -2.13586856e-02f, -2.51160432e-02f, -1.77590698e-02f, 1.13916285e-01f, 4.19705734e-02f, -1.34129096e-02f, -2.26492900e-02f, 1.93694364e-02f, -6.70320615e-02f, 2.16542631e-02f,
  5.05869798e-02f, 6.73654862e-03f, 6.92050010e-02f, 1.07649095e-01f, 6.42384216e-03f, 7.74426162e-02f, 1.72404796e-02f, 1.05638787e-01f, -7.79005587e-02f, -3.15484740e-02f,
  8.64589959e-02f, -1.10203259e-01f, -8.35979581e-02f, -4.08452228e-02f, -6.84740720e-03f, -1.05023503e-01f, -4.80953045e-02f, -1.71125568e-02f, -3.98771605e-04f, 3.55943181e-02f,
  -6.20527007e-02f, -2.05523707e-02f, 2.14515883e-03f, -1.57228224e-02f, 1.57092027e-02f, 5.22382893e-02f, 7.57368952e-02f, -2.60116775e-02f, 7.78273866e-02f, -3.47540677e-02f,
  4.71191853e-02f, 3.92968692e-02f, 1.40444273e-02f, -8.35919939e-03f, -1.04568154e-01f, -5.86352218e-03f, 4.54991385e-02f, -6.02457188e-02f, -1.40877941e-03f, 1.14832133e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  8.58354345e-02f, 1.12318940e-01f, 1.74029887e-01f, 1.26135588e-01f, 1.10737108e-01f, -9.79868602e-03f, 1.33362394e-02f, 9.57729667e-02f, 4.70047258e-02f, -3.02236304e-02f,
  1.03614010e-01f, 1.13482781e-01f, 2.02040914e-02f, -6.02693744e-02f, -1.72933415e-02f, 1.98966675e-02f, -2.55193915e-02f, 8.81885961e-02f, 2.78828237e-02f, 9.66368616e-02f,
  -3.96662354e-02f, 1.39852047e-01f, -9.26174596e-02f, 6.33209525e-03f, -5.14501035e-02f, -1.18880635e-02f, 7.08638430e-02f, 5.25832139e-02f, 4.34060246e-02f, 7.64783770e-02f,
  3.65693937e-03f, -2.79304776e-02f, -1.13612618e-02f, -4.16979529e-02f, 1.28376395e-01f, -2.59056746e-04f, 4.38526012e-02f, -5.04659042e-02f, -5.70074394e-02f, 1.45098060e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.79125041e-02f, -4.34439443e-02f, -5.36830947e-02f, -5.85161615e-03f, -4.11645621e-02f, -1.41161397e-01f, 9.55253746e-03f, 6.92474544e-02f, 4.12521698e-02f, -1.05069235e-01f,
  -1.15300447e-01f, -6.99662566e-02f, 2.25447431e-01f, 8.06266665e-02f, 4.60196286e-02f, -6.56638816e-02f, 1.93328455e-01f, -1.25504434e-01f, 1.55993983e-01f, -1.07195504e-01f,
  -1.81100041e-01f, -6.75044879e-02f, 1.82037681e-01f, 1.22410849e-01f, 4.65635210e-02f, 1.07931599e-01f, -1.42064646e-01f, -6.35470683e-03f, 1.08044729e-01f, 8.25985596e-02f,
  -2.30693758e-01f, -7.47207785e-03f, -9.21147019e-02f, -9.10850391e-02f, -2.77651716e-02f, 1.11948676e-01f, -6.75260350e-02f, 1.24850109e-01f, 7.21727535e-02f, -8.17766413e-02f,
  7.18523413e-02f, -9.94197726e-02f, -2.93083135e-02f, -6.16632961e-02f, 1.94456838e-02f, 4.39113006e-03f, -1.35526508e-01f, -4.98216273e-03f, 8.91946778e-02f, -1.65383935e-01f,
  1.47116394e-03f, 6.10941015e-02f, -9.06440020e-02f, 1.04418851e-01f, 5.20917885e-02f, -7.96672106e-02f, 1.31329000e-01f, 5.98104671e-02f, 2.51705218e-02f, 1.69076502e-01f,
  8.39707814e-03f, 6.58645853e-02f, 1.08177617e-01f, 1.09253954e-02f, -4.20518359e-03f, -1.32247031e-01f, 2.84517203e-02f, 1.34243011e-01f, -1.42336100e-01f, 4.91397902e-02f,
  -3.24530751e-02f, 1.72858760e-02f, 8.31163116e-03f, 4.79192808e-02f, -5.85069209e-02f, -1.16291881e-01f, -8.75440314e-02f, 1.37712359e-01f, -2.92642098e-02f, 4.21319529e-03f,
  -1.02177290e-02f, 1.21023946e-01f, -6.22365810e-02f, 1.29095152e-01f, 4.14363034e-02f, -4.49254140e-02f, -7.14826509e-02f, -2.42642224e-01f, 2.25499228e-01f, -2.39816681e-02f,
  -1.71579290e-02f, 6.26939684e-02f, 1.69045910e-01f, -1.22447424e-02f, 8.99763703e-02f, 1.39974177e-01f, -5.65926023e-02f, -1.22581013e-01f, -5.86596765e-02f, 1.71017200e-02f,
  3.81609499e-02f, 1.19454086e-01f, 7.36348107e-02f, -8.42171907e-02f, -1.79184508e-02f, -1.04074664e-01f, 7.69243389e-02f, 5.79534099e-02f, -1.68236496e-03f, 9.36170220e-02f,
  5.17527163e-02f, 1.83871258e-02f, 3.40932086e-02f, 3.55601609e-02f, 1.00502186e-01f, -1.03388922e-02f, -4.17620912e-02f, 4.99070659e-02f, 5.13276011e-02f, 2.76725739e-02f,
  1.28551275e-02f, 7.94889554e-02f, -8.87334347e-02f, 3.73915769e-02f, 1.31645799e-01f, -2.04159077e-02f, -6.35983273e-02f, -1.56861879e-02f, 3.61947566e-02f, 3.92645299e-02f,
  -7.11891204e-02f, -6.65333867e-02f, -1.09966427e-01f, 1.05454981e-01f, -6.84114471e-02f, -1.11746989e-01f, 2.23155972e-02f, 3.39490548e-02f, 1.39346365e-02f, -8.60042647e-02f,
  7.36320987e-02f, -1.35535330e-01f, 1.05859339e-01f, 7.38914385e-02f, 4.44065481e-02f, 1.75489530e-01f, -1.07165582e-01f, 1.20980635e-01f, -5.43403402e-02f, 1.44598978e-02f,
  1.32343829e-01f, -1.56922221e-01f, -1.39884382e-01f, 9.86904055e-02f, 6.62120357e-02f, -2.76824776e-02f, -5.09406924e-02f, -3.05573046e-02f, -8.86883661e-02f, -2.27717273e-02f,
  9.96015295e-02f, 9.83611941e-02f, 1.20185427e-02f, 3.45987413e-04f, 1.05313146e-02f, 2.23654341e-02f, 7.09735081e-02f, -1.21858291e-01f, -5.88930435e-02f, -8.05319324e-02f,
  1.33050203e-01f, 5.80049586e-03f, -6.61873147e-02f, -6.51603341e-02f, 1.05841190e-01f, 1.20343775e-01f, -4.05172631e-02f, -5.90436012e-02f, -1.16361037e-01f, -8.86007026e-02f,
  -1.34157851e-01f, 2.76778936e-02f, 1.06449515e-01f, -1.01563551e-01f, -8.47588554e-02f, -6.17672950e-02f, 7.32219517e-02f, 1.20443165e-01f, -1.30265728e-01f, -8.74873102e-02f,
  9.01434943e-02f, -5.99783845e-02f, -1.90452591e-01f, 6.62358701e-02f, -4.70876060e-02f, -2.85985675e-02f, 9.43601578e-02f, -1.66553542e-01f, -1.39461756e-02f, -4.54643518e-02f,
  3.80623043e-02f, 9.18791071e-02f, 3.26343253e-02f, -1.03975318e-01f, 8.65401253e-02f, 1.10565744e-01f, -5.28267361e-02f, -8.96751806e-02f, 6.73880205e-02f, -1.05961092e-01f,
  -1.52416363e-01f, -1.78727701e-01f, -6.61836565e-02f, 2.60236841e-02f, 1.93984002e-01f, 9.96060371e-02f, -1.85694113e-01f, 8.27434361e-02f, -4.65118699e-03f, -1.02911800e-01f,
  -9.63526666e-02f, 5.10948896e-02f, -1.32221654e-01f, -2.63809524e-02f, -1.01822749e-01f, 1.00898311e-01f, 8.59972835e-02f, 1.59936920e-01f, -4.53707250e-03f, -2.54363064e-02f,
  9.25515741e-02f, 1.16171226e-01f, 5.11278324e-02f, -2.80777644e-02f, -1.16998786e-02f, -1.24175876e-01f, -6.44244850e-02f, -2.10750550e-01f, 8.15369654e-03f, -2.22935099e-02f,
  -5.15001379e-02f, -1.13964099e-02f, -6.17601955e-03f, 6.53100833e-02f, 8.10077321e-03f, -5.12516201e-02f, 5.80385067e-02f, -9.07317698e-02f, 1.08568840e-01f, -5.90569489e-02f,
  6.28340989e-02f, 1.76036775e-01f, -2.36045979e-02f, 4.95980792e-02f, 7.89188221e-02f, -6.81344718e-02f, -7.83398747e-02f, -8.13401267e-02f, 7.14345649e-02f, -6.74770623e-02f,
  -7.76079372e-02f, 1.52766317e-01f, -1.10461496e-01f, 3.18884887e-02f, 1.13989394e-02f, 9.77858827e-02f, -1.08501995e-02f, -1.26311823e-03f, -4.24485980e-03f, -1.21404864e-01f,
  -1.02636345e-01f, -1.43107280e-01f, 5.43647446e-02f, 1.36899143e-01f, 9.67136249e-02f, -2.13024765e-01f, -2.40277931e-01f, -1.30072922e-01f, -1.24081783e-01f, -1.57617047e-01f,
  -1.12951130e-01f, 6.20348155e-02f, -1.36180865e-02f, 4.71416190e-02f, 1.39978170e-01f, 1.61357876e-02f, 4.24717757e-04f, 1.45913631e-01f, -4.51726504e-02f, -4.72936258e-02f,
  5.79207055e-02f, -6.06935881e-02f, -3.75437178e-02f, -4.72008158e-03f, -1.02276012e-01f, 5.07316776e-02f, -7.46429935e-02f, -4.24411744e-02f, 8.65229638e-04f, 2.37728357e-02f,
  5.47711812e-02f, -1.11310512e-01f, 1.42506272e-01f, 1.12029403e-01f, 3.40918191e-02f, 2.34431475e-02f, 8.06301553e-03f, 8.13571215e-02f, -5.31472042e-02f, -6.76337779e-02f,
  1.02843232e-01f, 9.59826857e-02f, 1.21651717e-01f, 6.29880354e-02f, 1.11702703e-01f, -1.43252924e-01f, -1.14385327e-02f, -6.24535717e-02f, 1.05742507e-01f, -1.51062787e-01f,
  -3.94643247e-02f, 1.46728784e-01f, 7.35761896e-02f, 9.65004563e-02f, 6.35871366e-02f, -1.21098123e-01f, -7.21563920e-02f, 1.49520099e-01f, 1.17108345e-01f, 5.67025244e-02f,
  -9.18210968e-02f, 1.02972388e-02f, 1.16087608e-02f, 2.42515385e-01f, -7.68346861e-02f, 2.85112590e-01f, 2.48315129e-02f, -3.01222861e-01f, -1.12128193e-02f, 7.96398446e-02f,
  5.10387644e-02f, 1.93412557e-01f, 4.80525158e-02f, 1.15000114e-01f, 1.51678279e-01f, 1.33711889e-01f, 5.24172895e-02f, -1.37367556e-02f, -8.23154822e-02f, 1.60970818e-02f,
  -1.74298719e-01f, -1.83782913e-02f, -1.02509879e-01f, -1.15661219e-01f, 1.57713294e-01f, 6.94186687e-02f, 1.03374504e-01f, -1.57539472e-01f, -1.08972937e-03f, -9.36916843e-02f,
  -5.47082489e-03f, 3.61097371e-03f, -1.09707855e-01f, -7.76963681e-02f, 2.71701012e-02f, 1.82188436e-01f, -1.84289634e-01f, -1.00481294e-01f, -7.26173669e-02f, 8.20014104e-02f,
  -9.67756212e-02f, 4.53421921e-02f, -9.80117694e-02f, -1.36639804e-01f, -1.82971507e-01f, -1.16516270e-01f, 7.06135184e-02f, -1.19911529e-01f, -1.36477202e-01f, -1.91694964e-02f,
  1.76870927e-01f, 1.14919685e-01f, -1.02973312e-01f, 4.99145351e-02f, -3.14273275e-02f, 7.35532641e-02f, -4.51694243e-02f, -1.11427903e-01f, 1.52153522e-01f, -1.78370416e-01f,
  5.66221885e-02f, 7.72281587e-02f, 1.36266500e-01f, -2.48894244e-02f, -4.88515804e-03f, 9.35379192e-02f, -1.98631268e-02f, 1.41126379e-01f, 1.30584821e-01f, 9.34792608e-02f,
  -1.61403388e-01f, -2.55917668e-01f, -1.52423486e-01f, -1.56935215e-01f, -1.15370125e-01f, 8.81421044e-02f, 1.71539366e-01f, 2.55996108e-01f, -3.25447172e-02f, 2.59077642e-02f,
  5.32322824e-02f, 3.22925635e-02f, 8.44380781e-02f, 1.30493373e-01f, -8.97342414e-02f, 1.53209809e-02f, 6.05857559e-02f, -6.79909289e-02f, 5.79393767e-02f, 1.40345290e-01f,
  8.27054679e-02f, -1.27495006e-01f, -2.40120925e-02f, 7.62137398e-02f, 3.28014269e-02f, -1.82136055e-02f, -3.11181806e-02f, -1.50487258e-03f, 1.15546219e-01f, 1.59057215e-01f,
  -2.03275993e-01f, 3.65102030e-02f, -1.24612413e-01f, -7.33356224e-03f, -1.72479287e-01f, 1.45449508e-02f, -4.38535325e-02f, 7.87720531e-02f, 8.31191912e-02f, -2.13072356e-02f,
  2.76846979e-02f, 7.70120323e-02f, 2.51568817e-02f, 9.21211764e-03f, -4.40590940e-02f, -6.23185188e-02f, -7.71926045e-02f, 1.36717886e-01f, -5.54755377e-03f, 4.20556441e-02f,
  4.01834249e-02f, 2.20198072e-02f, 7.33358264e-02f, -1.45756871e-01f, -8.61734897e-02f, 1.60428584e-01f, 3.71806808e-02f, 2.69882325e-02f, -7.23228529e-02f, 6.72560409e-02f,
  -6.45921603e-02f, 2.26371437e-01f, 1.69941038e-01f, 1.62883312e-01f, -1.62589550e-01f, -1.40807152e-01f, -6.26285672e-02f, 1.51527822e-01f, -5.13724126e-02f, 5.46151400e-02f,
  3.61239277e-02f, 1.34009331e-01f, 1.95667416e-01f, 1.29866600e-01f, 1.27590686e-01f, 9.15695578e-02f, 1.04686774e-01f, -3.85322943e-02f, -6.33734614e-02f, -1.56812713e-01f,
  9.33816135e-02f, 1.00497209e-01f, 9.95094329e-03f, -1.53757725e-02f, -1.11575186e-01f, -1.74695421e-02f, -1.75174661e-02f, -3.79810482e-02f, -1.41156122e-01f, 5.44352606e-02f,
  -9.20391008e-02f, 1.59384292e-02f, -1.35703227e-02f, 2.54631609e-01f, -6.47043586e-02f, 1.57016180e-02f, 7.61625767e-02f, 6.67117536e-02f, -9.53828096e-02f, -8.32935721e-02f,
  7.96733052e-02f, -8.29447061e-02f, -1.31834477e-01f, 4.86589521e-02f, 6.40736893e-02f, 3.68079133e-02f, 4.17566709e-02f, -1.32993504e-01f, -5.67677543e-02f, 9.51509625e-02f,
  -1.98820278e-01f, 1.54677778e-01f, -1.88790206e-02f, 1.63961891e-02f, 1.26244932e-01f, -1.24494053e-01f, 1.47203598e-02f, -1.28682375e-01f, 1.85859092e-02f, -6.58199117e-02f,
  -6.02317527e-02f, -1.37946308e-01f, 2.61148214e-02f, 5.62520884e-02f, 1.71333954e-01f, -1.36304528e-01f, -2.02959757e-02f, -5.51797114e-02f, -6.64770156e-02f, -2.06924573e-01f,
  8.56804252e-02f, -4.55311090e-02f, -7.00291768e-02f, -1.90597832e-01f, 1.09061264e-01f, 1.91510901e-01f, 1.05413198e-01f, 1.25312224e-01f, 1.25401855e-01f, -1.52410328e-01f,
  -1.64127514e-01f, -3.56852859e-02f, -9.82284397e-02f, -1.15168735e-01f, -1.05251394e-01f, -5.49109690e-02f, 7.09412470e-02f, 7.18521029e-02f, 9.13388804e-02f, -3.31675522e-02f,
  -2.66031306e-02f, -1.64813682e-01f, 1.14451520e-01f, 1.68721052e-03f, -3.23393382e-02f, 1.98561568e-02f, 6.84734881e-02f, -1.84248891e-02f, -1.03616558e-01f, -1.41614214e-01f,
  4.93236743e-02f, -8.01645964e-02f, -1.12571225e-01f, -1.20668568e-01f, 1.18324824e-01f, 1.14312530e-01f, 4.17096028e-03f, 9.90567077e-03f, -5.62290549e-02f, -3.48862447e-02f,
  5.15756458e-02f, 1.56473130e-01f, -1.94971301e-02f, -1.46408693e-03f, -8.03747699e-02f, 6.93695471e-02f, -3.38161513e-02f, -9.91332904e-02f, -6.98039085e-02f, -7.23875910e-02f,
  5.79198785e-02f, 6.73909932e-02f, 1.21271610e-01f, 1.04494365e-02f, -1.02765635e-02f, 3.70086282e-02f, -2.26449482e-02f, 8.74463096e-02f, -7.53536029e-03f, -6.83352724e-02f,
  9.90506262e-02f, 1.14445873e-01f, 1.85002238e-01f, 1.17880963e-01f, -8.49651843e-02f, -1.66767780e-02f, 1.45535216e-01f, 1.82545841e-01f, -1.12035550e-01f, -1.46831512e-01f,
  -7.07309395e-02f, -8.30141455e-02f, 9.88581479e-02f, -4.09099236e-02f, 1.73156753e-01f, -1.19585125e-02f, -1.86684430e-01f, 1.80715933e-01f, -8.18070248e-02f, -5.00902273e-02f,
  -1.09486710e-02f, -1.49663597e-01f, -1.08918674e-01f, 1.25652358e-01f, -9.72693712e-02f, -3.76262404e-02f, -7.05800951e-02f, -3.68288695e-03f, 1.95629865e-01f, 8.94886255e-02f,
  2.83349846e-02f, -1.23585463e-01f, 2.49127954e-01f, 1.34123012e-01f, 1.10409081e-01f, 1.22838624e-01f, 1.43920675e-01f, -3.74877416e-02f, -7.76811019e-02f, -7.70727172e-02f,
  -7.44718462e-02f, 1.58711076e-01f, -1.15783734e-03f, -6.76630512e-02f, -8.08432177e-02f, -5.58404140e-02f, -6.16456792e-02f, -1.37868524e-01f, 7.73375705e-02f, 2.33751815e-02f,
  -1.27641574e-01f, -4.92533259e-02f, 1.87002588e-02f, 9.37907994e-02f, 7.79010952e-02f, 3.26908007e-02f, 8.20197538e-02f, 9.66501329e-03f, 7.05832848e-03f, 1.08043559e-01f,
  1.00893038e-03f, -1.00544930e-01f, 6.44119130e-03f, 2.67470721e-03f, 1.48564680e-02f, -7.79389888e-02f, -5.26196845e-02f, 9.72150937e-02f, 1.07295275e-01f, -1.17221870e-01f,
  5.38566522e-02f, -8.99549201e-03f, 1.16716675e-01f, -9.18261055e-03f, -1.15797646e-01f, -1.20025218e-01f, -7.74101960e-03f, -2.91018169e-02f, -2.89176330e-02f, 3.28860991e-02f,
  7.85183012e-02f, 7.31513351e-02f, 4.25054692e-02f, 4.03598957e-02f, -5.99183626e-02f, -7.79817905e-03f, -7.18847513e-02f, -9.58602875e-02f, -1.72855631e-02f, -3.43431309e-02f,
  9.88234300e-04f, -6.60778722e-03f, -4.57756668e-02f, -4.56219241e-02f, -8.82598385e-02f, -1.05018623e-01f, -1.14229806e-01f, -1.19061485e-01f, -1.05122559e-01f, -1.49451509e-01f,
  3.72118801e-02f, 3.99764888e-02f, 1.19631238e-01f, 7.19418153e-02f, -3.36855017e-02f, -9.88666564e-02f, -1.00380220e-01f, -1.09129339e-01f, 6.69372156e-02f, -8.60845372e-02f,
  -7.81758651e-02f, -8.22224170e-02f, -6.32921234e-02f, 1.19224638e-01f, 1.55481040e-01f, 1.66962035e-02f, -9.31020528e-02f, 8.51671472e-02f, -1.58863410e-01f, -6.67842999e-02f,
  1.02281682e-01f, -7.07272366e-02f, 7.32626840e-02f, 4.19592895e-02f, 6.26948290e-03f, 1.35658622e-01f, 2.56827218e-03f, -9.17228088e-02f, -6.24039490e-03f, -2.57526278e-01f,
  -2.52023876e-01f, 2.19136998e-01f, 2.58610994e-01f, -2.25793362e-01f, -2.87988782e-01f, -2.00472340e-01f, -1.60530984e-01f, 3.34590040e-02f, 1.16013877e-01f, -1.61320731e-01f,
  -1.48354337e-01f, -1.03516616e-01f, 1.17666379e-01f, -4.10249755e-02f, 7.73487911e-02f, 5.66420816e-02f, -1.13550901e-01f, -4.66091000e-02f, -1.13577180e-01f, 7.82002285e-02f,
  1.03705078e-01f, 3.50158401e-02f, -1.39246643e-01f, -5.28851636e-02f, 7.88037628e-02f, -9.70099196e-02f, 5.29574715e-02f, 9.29135904e-02f, -1.65165775e-02f, -6.75546005e-02f,
  1.90175578e-01f, 1.54439779e-02f, 1.14003003e-01f, -4.40485366e-02f, 1.47018149e-01f, -1.27299475e-02f, 5.75129278e-02f, -8.22704509e-02f, 8.00910145e-02f, 5.93228117e-02f,
  -4.29043807e-02f, 1.64371699e-01f, -7.09373653e-02f, -3.06090474e-01f, -5.16253859e-02f, -1.45182982e-01f, -1.52205780e-01f, -1.67291224e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.46554768e-01f, 1.16085999e-01f, 2.90093739e-02f, 1.44977383e-02f, 1.16443180e-01f, -1.24708541e-01f, 1.31991103e-01f, 1.13657318e-01f, 1.78789645e-01f, -3.49063128e-02f,
  1.58695370e-01f, 5.83202485e-03f, 1.27299234e-01f, 1.80714875e-01f, 1.52742743e-01f, 2.20859125e-01f, 5.61753847e-02f, -1.26337618e-01f, -1.19732425e-01f, -1.06478214e-01f,
  -1.16768584e-01f, 8.14540088e-02f, 4.18464318e-02f, 9.26506817e-02f, -5.49619384e-02f, 2.51098238e-02f, 7.04960674e-02f, -8.72740000e-02f, 1.61614627e-01f, 9.10342187e-02f,
  -5.43364286e-02f, -1.21168807e-01f, -9.16631892e-02f, 1.87357590e-02f, 1.44349873e-01f, 7.27943629e-02f, 9.24574502e-04f, 6.78091198e-02f, 1.38116166e-01f, -8.02858472e-02f,
  -1.56419612e-02f, 9.25963521e-02f, -4.15583476e-02f, 1.35536185e-02f, -6.63907006e-02f, 1.89148158e-01f, -1.71329543e-01f, -2.80217244e-03f, 7.29933903e-02f, 2.08754977e-03f,
  2.81035975e-02f, 2.67728721e-03f, -7.55058154e-02f, -1.30935967e-01f, -8.81411284e-02f, 9.45305973e-02f, -4.52764332e-02f, 9.24298763e-02f, 2.86572780e-02f, 1.57441318e-01f,
  7.82698318e-02f, 4.33373228e-02f, 7.51904920e-02f, 7.34251812e-02f, 1.62534684e-01f, 8.23011175e-02f, 7.17515200e-02f, 4.58464138e-02f, -1.70520525e-02f, 3.76579501e-02f,
  1.43971210e-02f, 3.91401947e-02f, 1.36876315e-01f, -1.66137367e-02f, 1.01113014e-01f, 3.92711200e-02f, 9.90186483e-02f, 2.90026125e-02f, -1.32731512e-01f, -1.13638610e-01f,
  -1.68106154e-01f, 1.45615265e-01f, 1.40956387e-01f, 3.77119333e-02f, -4.95764427e-02f, -2.07743809e-01f, -1.58528507e-01f, 1.03108160e-01f, 2.86650240e-01f, 5.68493158e-02f,
  3.01726237e-02f, 2.12711748e-03f, -3.57174836e-02f, 2.64422242e-02f, 9.21942964e-02f, -3.20762619e-02f, 1.47492975e-01f, -5.23753166e-02f, -1.00739375e-01f, -9.46261585e-02f,
  -3.02486587e-02f, 2.94566844e-02f, -7.17225000e-02f, -1.15783758e-01f, 1.45738006e-01f, -7.32093398e-03f, -1.10447645e-01f, 1.85387731e-01f, -1.00436501e-01f, 2.59104311e-01f,
  -3.02906726e-02f, 6.26452938e-02f, 2.61030402e-02f, -2.47049425e-02f, -4.82507050e-02f, -1.42142236e-01f, 1.01886116e-01f, 7.20960274e-02f, -1.18586443e-01f, -1.21595472e-01f,
  -1.08589634e-01f, -6.96082264e-02f, 1.31305680e-01f, 1.20744497e-01f, -8.83559212e-02f, -8.30283687e-02f, 2.31212080e-02f, 8.81626531e-02f, 2.34288257e-02f, 1.06032798e-02f,
  5.37339300e-02f, 5.98311564e-03f, -6.38744012e-02f, -1.18390486e-01f, 7.26843029e-02f, 1.42980993e-01f, 6.80650249e-02f, 8.08195844e-02f, 6.37604147e-02f, 1.08887196e-01f,
  9.05601457e-02f, 1.79158375e-02f, 1.10807478e-01f, -4.43415157e-02f, 4.25832830e-02f, -4.55942862e-02f, -3.24141867e-02f, 6.06736504e-02f, 1.02886185e-01f, 1.33160427e-01f,
  1.49868593e-01f, 9.58615914e-02f, -1.21413156e-01f, -3.63645554e-02f, -2.39511132e-02f, 9.14017633e-02f, 1.24451019e-01f, 1.12139300e-01f, -1.20672785e-01f, -2.72761229e-02f,
  1.19650019e-02f, 2.86612231e-02f, 1.36340559e-01f, 1.33091703e-01f, -1.14822924e-01f, 1.36648729e-01f, -1.40205934e-03f, 1.19791150e-01f, 6.69890344e-02f, -1.00624241e-01f,
  -8.41233283e-02f, -8.59986432e-03f, -4.89389896e-02f, -7.00688139e-02f, 3.91506068e-02f, -1.19557455e-01f, -8.29292834e-02f, -5.78373261e-02f, 1.02476366e-01f, -8.34053904e-02f,
  1.06836252e-01f, 3.63530335e-03f, 4.66174148e-02f, 9.48315952e-03f, 5.03736213e-02f, -1.17680676e-01f, 3.41129750e-02f, 3.09811309e-02f, 8.91168267e-02f, 1.44836325e-02f,
  1.30579904e-01f, 6.49033254e-03f, 1.53470084e-01f, 2.37367943e-01f, 1.49897650e-01f, 1.37738447e-04f, 2.69677509e-02f, -4.66857813e-02f, 1.05141453e-01f, 1.95943415e-01f,
  7.04543144e-02f, 2.06987843e-01f, 1.22984372e-01f, 1.86072052e-01f, 1.35630712e-01f, -1.91444859e-01f, -1.40768066e-01f, 7.76819512e-02f, 2.19215065e-01f, 1.18433118e-01f,
  -5.93369566e-02f, -1.73332155e-01f, 7.40432069e-02f, -6.13751076e-03f, 8.99186283e-02f, 1.17605738e-01f, -2.27536440e-01f, 4.51869369e-02f, 1.36273861e-01f, 1.33990031e-02f,
  9.14561972e-02f, 5.87936863e-02f, -1.30252600e-01f, 1.15067668e-01f, 6.39985725e-02f, 8.17460418e-02f, 1.63194895e-01f, 7.33619630e-02f, 7.79525843e-03f, -8.32747854e-03f,
  -3.60676683e-02f, 7.53757879e-02f, -1.14894114e-01f, -9.50242355e-02f, -8.80589150e-03f, 1.13071285e-01f, 8.91595930e-02f, -2.82718390e-02f, -3.59157138e-02f, 1.05765253e-01f,
  -1.00867808e-01f, -8.89515728e-02f, -1.14812814e-01f, -7.00568929e-02f, -4.98888977e-02f, 5.02007231e-02f, 1.70438662e-01f, 4.24823686e-02f, -4.79405466e-03f, -8.75215754e-02f,
  1.04109079e-01f, 2.09228918e-01f, -8.30786154e-02f, 1.29909471e-01f, 2.38568261e-01f, 1.36733636e-01f, 4.44315188e-02f, 6.72876015e-02f, 1.15505427e-01f, 1.18696012e-01f,
  1.46377951e-01f, 1.70763671e-01f, 1.01836853e-01f, 2.22838596e-01f, 9.04737040e-02f, 2.27353409e-01f, 1.03689633e-01f, 1.14069216e-01f, 1.13668233e-01f, 4.46752971e-03f,
  5.20449020e-02f, 1.48149252e-01f, 1.62177831e-01f, 1.12601385e-01f, -2.00035214e-01f, -5.37126437e-02f, 1.56293869e-01f, 1.15068229e-02f, 1.99465781e-01f, -9.22051370e-02f,
  -1.73920795e-01f, 2.57059485e-02f, 2.55032480e-01f, -2.03024484e-02f, -2.14891229e-02f, -6.06375225e-02f, -9.59534198e-02f, -8.32143351e-02f, 4.63905884e-03f, -5.43024987e-02f,
  2.14345798e-01f, 1.22697167e-01f, -3.66076380e-02f, 1.25536742e-03f, 1.39759138e-01f, -9.43365842e-02f, -1.35949388e-01f, 6.63392022e-02f, 1.10517725e-01f, 1.42006185e-02f,
  -4.29669842e-02f, -1.42912790e-01f, -1.26017824e-01f, -4.60631661e-02f, -5.63867241e-02f, 2.95970868e-03f, 9.88654271e-02f, -1.27178729e-01f, -3.59421894e-02f, 1.56946585e-01f,
  -2.05829535e-02f, 7.37011656e-02f, 6.61467463e-02f, -1.21327667e-02f, 1.03741191e-01f, 2.43160024e-01f, 8.44143927e-02f, -7.41907358e-02f, 8.77161399e-02f, 9.14716870e-02f,
  -4.74995710e-02f, -1.18063902e-02f, 1.34459510e-01f, 1.09784380e-01f, 1.24218374e-01f, -4.63809520e-02f, 1.01433665e-01f, -1.29852399e-01f, 5.74089736e-02f, 4.50350717e-02f,
  -3.12764458e-02f, 1.43070713e-01f, 4.52909991e-02f, -3.74102630e-02f, -5.81939816e-02f, -1.83199078e-01f, 9.92547274e-02f, 4.24563028e-02f, 9.41874087e-03f, -1.43632099e-01f,
  -5.71069634e-03f, -8.59625754e-04f, -3.50751914e-02f, 1.11960247e-01f, 3.37882601e-02f, -1.17425025e-01f, -1.27600461e-01f, 4.85461354e-02f, 6.18263297e-02f, -6.35461211e-02f,
  9.45231840e-02f, -3.06932610e-02f, 3.22455689e-02f, 1.32692859e-01f, -1.08374089e-01f, 1.59551427e-01f, -5.54342419e-02f, 3.63336392e-02f, 7.90047795e-02f, 1.32883694e-02f,
  -1.07990131e-01f, 7.71824494e-02f, 2.41521765e-02f, 2.71658897e-02f, -3.59504484e-02f, -8.59431773e-02f, 1.85709819e-01f, -2.10153330e-02f, -7.56631419e-02f, 6.40291795e-02f,
  1.28743485e-01f, 7.79107362e-02f, -7.27761984e-02f, -3.41412239e-02f, 2.33643819e-02f, 3.41118388e-02f, -9.28458646e-02f, -4.19681668e-02f, 7.69591853e-02f, -1.44247681e-01f,
  -1.09613352e-01f, -2.11862307e-02f, -6.98593166e-03f, -7.66715631e-02f, 1.09199673e-01f, -9.19075459e-02f, -1.00087583e-01f, 1.25558332e-01f, 1.22133987e-02f, -2.80909780e-02f,
  -8.58998224e-02f, 8.72794017e-02f, -3.07026226e-02f, 7.43470937e-02f, 8.07478875e-02f, -4.42116447e-02f, 1.39801055e-01f, -1.58666559e-02f, -1.14785537e-01f, -8.53487700e-02f,
  1.30869940e-01f, 7.45131969e-02f, 1.10110290e-01f, 1.09137133e-01f, -5.08283526e-02f, 3.84965464e-02f, 3.20230313e-02f, -1.13931417e-01f, -1.26899555e-01f, -6.38588071e-02f,
  1.40041694e-01f, -5.42074218e-02f, -2.51057968e-02f, 9.83434990e-02f, -3.13941427e-02f, -1.27589047e-01f, 7.63520747e-02f, -6.37508631e-02f, -6.11478835e-02f, 4.77618985e-02f,
  -4.38992046e-02f, 1.19751751e-01f, -8.83924291e-02f, 8.66216049e-02f, -4.26961966e-02f, 3.80288474e-02f, 1.09346375e-01f, -9.64804888e-02f, -4.32003569e-03f, -3.56304972e-03f,
  -1.21471077e-01f, 6.49032369e-02f, -6.81355819e-02f, -6.25053495e-02f, 1.12136349e-01f, 7.92765468e-02f, -9.95869711e-02f, 6.37344345e-02f, -8.66361484e-02f, 5.42746335e-02f,
  -5.86722344e-02f, 9.55992043e-02f, -7.00055063e-02f, 1.64434507e-01f, -9.75092575e-02f, -6.11958802e-02f, 2.03450039e-01f, -2.06664447e-02f, -2.38790456e-02f, 2.74734288e-01f,
  1.43400908e-01f, -3.70607264e-02f, 2.37799942e-01f, -2.26921849e-02f, 4.20153402e-02f, 2.21064165e-01f, 1.61181822e-01f, 2.61678517e-01f, 1.56019017e-01f, 2.25169495e-01f,
  1.13108344e-01f, 9.34319571e-02f, 4.43841964e-02f, 5.37116379e-02f, 1.75730467e-01f, -7.52465129e-02f, -1.26835138e-01f, -1.29201427e-01f, -9.10428017e-02f, 7.43602067e-02f,
  2.03803778e-01f, -3.68928649e-02f, -2.32667446e-01f, 1.17545137e-02f, -8.76504462e-03f, -1.33107617e-01f, -2.58178860e-02f, -1.00477554e-01f, -1.16472051e-01f, 3.24253701e-02f,
  1.39096051e-01f, 1.47298023e-01f, 2.07628429e-01f, 2.32818350e-01f, 1.06363602e-01f, 1.84925482e-01f, -6.66022897e-02f, -9.71389189e-02f, -1.72412187e-01f, -8.69466458e-04f,
  1.16513588e-01f, 5.46064526e-02f, -4.59829420e-02f, -2.33853474e-01f, -1.23213179e-01f, -5.97577281e-02f, 1.13362990e-01f, -1.62515506e-01f, 4.66788299e-02f, 6.93814084e-02f,
  9.19712707e-02f, 1.35465711e-01f, 4.85059805e-02f, 9.54167098e-02f, 1.64868400e-01f, -5.39571717e-02f, -4.81459685e-02f, 2.13281751e-01f, -2.54076323e-03f, -1.57755427e-02f,
  2.42651805e-01f, 5.61808571e-02f, -5.77686578e-02f, -7.08020851e-02f, -8.59162882e-02f, 3.04043107e-02f, 6.25648275e-02f, 9.51153710e-02f, 6.85130432e-02f, -8.59424919e-02f,
  1.10368222e-01f, -3.00412290e-02f, -2.41922233e-02f, 7.67924711e-02f, -7.91379288e-02f, 2.09278171e-03f, 1.02896161e-01f, -1.17767297e-01f, -5.91013506e-02f, 8.31866637e-02f,
  -1.17502078e-01f, 1.10606357e-01f, 4.64950651e-02f, 5.55995591e-02f, 1.77443586e-02f, -2.90115047e-02f, 7.01548648e-04f, -1.03821695e-01f, 4.70300950e-02f, -1.49240997e-02f,
  1.24348521e-01f, 5.66302724e-02f, 8.72939900e-02f, 3.70128229e-02f, -1.24836564e-02f, 3.38662378e-02f, 1.00320198e-01f, 1.17116548e-01f, 7.49130771e-02f, 1.49006173e-01f,
  3.49180400e-02f, 1.15836516e-01f, -1.86240878e-02f, -1.11967228e-01f, -7.48668090e-02f, 4.50675450e-02f, -6.26273528e-02f, -2.32302155e-02f, -6.51983842e-02f, 1.12352788e-01f,
  9.69568714e-02f, -1.34170234e-01f, 1.11833066e-01f, 4.66440320e-02f, 7.68745737e-03f, -9.30566434e-03f, -7.80628761e-03f, 1.06075220e-01f, 1.40390009e-01f, -7.58700669e-02f,
  4.67819609e-02f, -1.06711082e-01f, -4.97144908e-02f, -7.41825923e-02f, -3.19701806e-02f, -7.87830725e-02f, 9.17755142e-02f, 6.53363764e-02f, -2.75836140e-02f, 7.58339614e-02f,
  -3.32484320e-02f, -9.86942202e-02f, 1.08938582e-01f, 1.22796558e-01f, 3.73270772e-02f, -7.30026141e-02f, -1.02579698e-01f, 5.77579904e-03f, -9.12401080e-02f, 1.12249032e-01f,
  -2.61945184e-02f, 2.32183523e-02f, -1.01878516e-01f, -9.74276066e-02f, 2.72455122e-02f, 4.61359434e-02f, 1.12509849e-02f, 1.18669212e-01f, -9.72222984e-02f, 5.45261502e-02f,
  9.22858566e-02f, -3.16295330e-03f, -1.14554511e-02f, 9.17997137e-02f, -6.88845292e-02f, 5.74920028e-02f, 3.88854705e-02f, 9.21132788e-02f, 3.75717133e-03f, -1.32498175e-01f,
  8.73412490e-02f, -5.57491519e-02f, -7.90595785e-02f, -9.06742886e-02f, 4.34226245e-02f, 1.05980895e-01f, -4.57123071e-02f, -5.59875593e-02f, -6.43452331e-02f, 6.95112124e-02f,
  9.14306417e-02f, 1.68051988e-01f, 4.34819385e-02f, 5.61112538e-02f, 1.27670467e-02f, -2.03324780e-02f, -8.39502141e-02f, -1.74544360e-02f, 1.39133362e-02f, 6.45718426e-02f,
  2.69984640e-02f, -7.31687993e-02f, 1.09446339e-01f, -5.00104390e-02f, -7.22079352e-02f, -7.46699721e-02f, 2.58181933e-02f, -6.69678375e-02f, -1.45619465e-02f, 3.28283058e-03f,
  7.12727085e-02f, -1.01302834e-02f, 7.37074316e-02f, 8.20963308e-02f, -6.94090780e-03f, 1.66906074e-01f, 1.23279959e-01f, 5.20590730e-02f, -4.49279025e-02f, 2.19342299e-03f,
  1.57372907e-01f, 2.30135649e-01f, -7.66131952e-02f, -2.06668094e-01f, -1.52226761e-01f, -1.23242967e-01f, 1.58680245e-01f, 2.43057340e-01f, -1.81626510e-02f, 5.02646416e-02f,
  1.20729869e-02f, -1.60294995e-01f, 5.27178869e-02f, -9.19046551e-02f, -1.27426445e-01f, -1.13184396e-02f, 8.18342939e-02f, -1.73296288e-01f, 5.66098131e-02f, 5.86496703e-02f,
  4.99932133e-02f, -7.32809082e-02f, -1.12661002e-02f, -8.52520764e-02f, -2.54159216e-02f, -2.17590891e-02f, -3.78123000e-02f, -1.01870537e-01f, 9.42773223e-02f, -2.01614350e-02f,
  3.77103612e-02f, -7.17927888e-02f, -7.50964731e-02f, 1.51188716e-01f, -1.27044525e-02f, 2.34715473e-02f, 2.98760142e-02f, 1.49943471e-01f, -1.19617127e-01f, -8.30673203e-02f,
  -4.34042439e-02f, -7.45152459e-02f, 1.01667002e-01f, -8.04339722e-03f, -5.35719357e-02f, -1.16363548e-01f, 9.32205617e-02f, -1.43614290e-02f, 1.72109932e-01f, 4.45714779e-02f,
  -7.54968002e-02f, 9.81464535e-02f, 2.17941970e-01f, -7.62938559e-02f, -1.16406888e-01f, 1.94990903e-01f, 1.19701460e-01f, 1.23241171e-01f, 9.04833898e-02f, 1.37187168e-01f,
  1.77217841e-01f, 5.75804114e-02f, -8.86479542e-02f, 8.59729052e-02f, 1.19884267e-01f, 5.73187359e-02f, 8.74894392e-03f, 8.02393630e-02f, 6.76798970e-02f, -4.93464135e-02f,
  2.75660366e-01f, 1.34393364e-01f, 7.03225732e-02f, 1.23025728e-02f, -5.23017794e-02f, 6.88830316e-02f, 1.60819501e-01f, -2.15538427e-01f, -1.81491803e-02f, 8.89957920e-02f,
  1.29645452e-01f, -1.22252584e-01f, 1.33659452e-01f, -7.41440952e-02f, -1.35714397e-01f, 2.05552801e-02f, 1.47055939e-01f, -3.36345769e-02f, 1.86314404e-01f, 1.05515160e-01f,
  7.58170038e-02f, 1.21480450e-02f, 3.30401659e-02f, -8.75300691e-02f, -6.49238080e-02f, 9.05405506e-02f, -4.26423363e-02f, 1.36885475e-02f, 7.24989846e-02f, -1.79916620e-01f,
  6.75461441e-02f, -8.29289109e-02f, -7.07168654e-02f, -1.64146394e-01f, 7.68176222e-04f, 2.99324412e-02f, -4.52514812e-02f, 1.24291725e-01f, 2.02235624e-01f, 1.09385692e-01f,
  1.54260859e-01f, 1.59789436e-02f, -3.38050537e-02f, 2.35215932e-01f, -1.17618814e-01f, 4.88685891e-02f, 2.84695774e-01f, -7.72471800e-02f, 1.06926814e-01f, -5.27965762e-02f,
  1.99682135e-02f, -7.82860741e-02f, 1.49894252e-01f, 1.09238699e-01f, 1.04545042e-01f, 1.39643624e-01f, 1.42573759e-01f, 1.46039635e-01f, -2.71422565e-02f, -1.05795320e-02f,
  -2.63619842e-03f, -2.31814869e-02f, 2.13123448e-02f, 1.67385623e-01f, 5.44238053e-02f, -4.06073108e-02f, -4.72246595e-02f, 1.18605420e-01f, 4.46231849e-02f, 1.32213801e-01f,
  6.10327232e-04f, -9.60572660e-02f, 6.36943430e-02f, 1.49204299e-01f, 1.37257546e-01f, -1.03986144e-01f, -9.76803675e-02f, 1.14524499e-01f, 3.83918099e-02f, -3.72561961e-02f,
  5.99319078e-02f, -5.97763285e-02f, 1.18050221e-02f, -1.10493697e-01f, 1.25488922e-01f, -1.28487960e-01f, -4.81595173e-02f, 2.70852298e-02f, 7.14493692e-02f, 6.38605133e-02f,
  2.59599723e-02f, 8.20891708e-02f, -6.42296597e-02f, -8.12926516e-02f, -7.56058842e-02f, -8.48019272e-02f, -6.93257526e-02f, -4.45738807e-02f, 7.32915848e-02f, -8.01449418e-02f,
  -8.85035004e-03f, -3.22857685e-02f, -7.94137195e-02f, -9.77620482e-02f, -4.42907661e-02f, 8.54544044e-02f, 6.48797080e-02f, 7.07369670e-02f, 3.69445421e-02f, -8.27728659e-02f,
  -9.02914926e-02f, 1.24056973e-01f, 8.68409425e-02f, -9.13759321e-02f, 3.54029648e-02f, -2.42272504e-02f, -1.00906618e-01f, -9.69758332e-02f, 6.15989007e-02f, 1.39968116e-02f,
  -5.96128888e-02f, -2.33433153e-02f, -4.68405038e-02f, 1.25522956e-01f, 3.10149845e-02f, 7.72065148e-02f, -1.29994407e-01f, -3.39050777e-02f, 7.21618161e-02f, 1.97195709e-02f,
  -1.24128371e-01f, -9.56932828e-02f, 7.26721659e-02f, 9.41302702e-02f, 1.12512536e-01f, 2.30709966e-02f, 9.85996649e-02f, -8.66485573e-03f, -2.08867830e-03f, -1.12365000e-01f,
  -3.39726508e-02f, 5.91860525e-02f, -1.08166024e-01f, -9.30026248e-02f, -1.02293164e-01f, 3.55054997e-02f, -1.00218169e-02f, -4.31328453e-02f, 5.74720651e-03f, -4.11467850e-02f,
  7.30741620e-02f, 9.19786096e-02f, -5.00663258e-02f, -8.15194100e-02f, 2.60994341e-02f, 6.85258657e-02f, 6.00655302e-02f, 3.17979679e-02f, -9.04086679e-02f, 1.14555275e-02f,
  2.42013987e-02f, -9.42420140e-02f, 8.68685842e-02f, -1.15881739e-02f, -4.44072522e-02f, -6.93949237e-02f, -6.90767765e-02f, 7.25472122e-02f, 8.32145438e-02f, 6.84379637e-02f,
  1.17927246e-01f, -8.79123881e-02f, 6.71869516e-02f, 9.24856886e-02f, 7.31254816e-02f, 1.99279245e-02f, 1.08035445e-01f, 8.20242763e-02f, -9.44482908e-02f, 8.44701082e-02f,
  -8.96004587e-02f, -1.91372633e-02f, -1.87676828e-02f, -4.52165082e-02f, 6.61712093e-03f, 9.88295525e-02f, 8.73204395e-02f, -1.23090103e-01f, -1.12502143e-01f, -4.76546213e-03f,
  2.87247710e-02f, 1.06026651e-02f, -4.90995236e-02f, -6.16952516e-02f, 2.87660714e-02f, 1.31676987e-01f, -8.29631835e-02f, -6.46909103e-02f, 2.72494531e-03f, 1.48151116e-02f,
  1.62104025e-01f, -3.82011547e-03f, -3.60879349e-03f, 5.93266338e-02f, -6.98894113e-02f, 1.17871158e-01f, -1.25747006e-02f, 1.05604623e-02f, 4.49513458e-03f, -3.94914150e-02f,
  -1.38698407e-02f, -1.24326736e-01f, 8.38919915e-03f, 6.34429827e-02f, 1.17669635e-01f, -1.58577655e-02f, -5.57195656e-02f, -3.73377986e-02f, 2.02698819e-02f, 5.87500185e-02f,
  1.10607594e-01f, 2.81811915e-02f, 1.01789422e-01f, -1.22753859e-01f, -5.50858043e-02f, -4.03901264e-02f, 4.45183963e-02f, -5.27608842e-02f, 2.51521543e-02f, -7.95004144e-02f,
  -1.20150268e-01f, 9.38239843e-02f, -5.61643876e-02f, 1.09415382e-01f, -4.00623530e-02f, -2.27995161e-02f, 1.33033440e-01f, 7.61194155e-02f, -5.97541332e-02f, -3.91601212e-02f,
  1.58154085e-01f, 1.50893452e-02f, 3.64843793e-02f, 2.03552052e-01f, 1.04058236e-01f, 1.75314128e-01f, 1.66562021e-01f, 1.07915260e-01f, 1.11721054e-01f, 4.29130420e-02f,
  -3.27696428e-02f, 3.69476788e-02f, -2.38919303e-01f, 2.50488073e-01f, 1.53880119e-01f, 1.60718616e-02f, -2.23923877e-01f, 3.34790125e-02f, -2.41428781e-02f, 1.95457891e-01f,
  6.24554120e-02f, 2.25468934e-01f, -1.51212260e-01f, -2.27244452e-01f, 1.09812677e-01f, -6.84728250e-02f, -1.24805853e-01f, 2.96432376e-01f, 1.03641912e-01f, -8.31714198e-02f,
  6.82407990e-02f, 5.53639717e-02f, 8.34870264e-02f, -1.20244443e-01f, -2.99981367e-02f, 5.44284210e-02f, 2.83727124e-02f, -9.64284465e-02f, -1.07399561e-01f, 1.64215237e-01f,
  8.51956308e-02f, 9.41930488e-02f, -7.90473074e-03f, -2.04210468e-02f, 1.33062720e-01f, 2.13203236e-01f, 1.43018961e-01f, 1.25046685e-01f, -8.39173887e-03f, 2.82908916e-01f,
  -4.03623208e-02f, 1.61350265e-01f, -9.63807553e-02f, 1.01389453e-01f, 2.20860969e-02f, 5.76394089e-02f, -1.33210793e-01f, -9.07680243e-02f, 2.17695776e-02f, -1.85041994e-01f,
  6.38098791e-02f, -1.05305657e-01f, -4.40197848e-02f, -4.89809588e-02f, -7.57030845e-02f, 1.26743078e-01f, 9.00470018e-02f, 8.85304511e-02f, -4.16968167e-02f, 3.10958214e-02f,
  1.07768342e-01f, 9.64699239e-02f, -3.76955979e-02f, -3.71241868e-02f, 1.20747380e-01f, -3.58358398e-03f, 9.49259177e-02f, 1.53353646e-01f, 1.45791233e-01f, 7.13558719e-02f,
  6.54612016e-03f, -9.04633403e-02f, 1.00792006e-01f, 3.46033312e-02f, -1.39430895e-01f, 1.33924782e-01f, 9.34942365e-02f, 2.03328952e-01f, -5.28512672e-02f, 1.01164959e-01f,
  2.69447360e-02f, 1.15340963e-01f, -1.08986251e-01f, 8.05177987e-02f, 6.86223358e-02f, 4.16837893e-02f, -7.16844499e-02f, -1.05599575e-01f, 8.12840462e-02f, 1.42248228e-01f,
  6.91022351e-02f, -2.19825730e-02f, 1.20993473e-01f, 9.91673395e-02f, 1.04221895e-01f, 7.33688986e-03f, -2.20082682e-02f, -7.42828324e-02f, 1.05357811e-01f, 1.05519630e-01f,
  -6.42471686e-02f, -1.07170455e-01f, -3.79252620e-02f, -3.07161901e-02f, -1.10969655e-01f, 4.80094366e-02f, -1.72886346e-02f, -8.15690160e-02f, -2.77113495e-03f, 1.04447819e-01f,
  -1.12445600e-01f, 4.61512990e-02f, -9.01982859e-02f, -1.02439761e-01f, 1.45807311e-01f, 1.47880718e-01f, -1.29342228e-01f, -3.18888016e-03f, 8.74488354e-02f, -5.99094629e-02f,
  2.88286153e-02f, -1.17051497e-01f, -1.20754272e-01f, -1.13422992e-02f, 4.26454991e-02f, -1.01027705e-01f, 1.04772151e-01f, -2.22420283e-02f, -7.52122328e-02f, -1.09237410e-01f,
  -6.48229867e-02f, 2.56970916e-02f, 3.68115716e-02f, -1.13084957e-01f, -1.02322593e-01f, -8.61046091e-02f, 7.08457679e-02f, 1.25821289e-02f, 2.54239179e-02f, 1.13714278e-01f,
  5.92587590e-02f, -2.51315162e-02f, 7.95629807e-03f, -9.38544422e-02f, -3.47179212e-02f, 5.53232729e-02f, -4.71452698e-02f, 4.07208689e-02f, -1.03633404e-01f, -4.06558402e-02f,
  -1.37314675e-02f, -1.07089588e-02f, 1.41101331e-03f, -7.09314868e-02f, -3.63806412e-02f, 7.06204548e-02f, -8.80529061e-02f, -5.17401807e-02f, 1.15951328e-02f, -1.12401508e-02f,
  -7.15816990e-02f, -1.04134127e-01f, -8.88259858e-02f, -1.50550401e-03f, 6.37788251e-02f, -3.99023108e-02f, 1.18094482e-01f, 5.49511760e-02f, -9.37141329e-02f, -1.57227144e-02f,
  5.22808824e-03f, 4.08941358e-02f, 1.17729427e-02f, 1.26930296e-01f, -1.12119116e-01f, -6.65978715e-02f, 3.32598239e-02f, -1.12750158e-01f, 3.04385554e-03f, -1.76774468e-02f,
  1.20689683e-01f, 1.08518399e-01f, 7.21923932e-02f, -3.34879830e-02f, 1.16825597e-02f, -6.43345192e-02f, 9.44937915e-02f, 7.46325180e-02f, 4.40779924e-02f, -3.81637067e-02f,
  -3.26498151e-02f, 1.37684688e-01f, -6.72533438e-02f, 1.02951556e-01f, 1.31001249e-01f, 5.07533597e-03f, -1.12615868e-01f, 2.58329958e-02f, 1.22000501e-01f, -6.47244602e-02f,
  1.06255531e-01f, -1.33421719e-01f, -7.77740255e-02f, 3.37505154e-02f, 1.48398191e-01f, -1.03941239e-01f, -1.20700128e-01f, -1.16920814e-01f, 1.30204946e-01f, 2.36228723e-02f,
  -7.28290826e-02f, -5.52920774e-02f, 1.10900514e-01f, 3.31178703e-03f, 5.30286767e-02f, 4.55269367e-02f, 3.68776172e-02f, 5.41900806e-02f, 1.15853675e-01f, 5.00795692e-02f,
  1.05423681e-01f, -1.22566327e-01f, 4.08814922e-02f, -6.47578165e-02f, -1.28081784e-01f, 3.78386527e-02f, -2.33070664e-02f, 1.01062190e-02f, -1.03181101e-01f, -8.30864012e-02f,
  -9.44056511e-02f, 4.30084243e-02f, 8.64965245e-02f, -7.63378218e-02f, -7.77797401e-02f, 4.96968254e-02f, 1.27577037e-01f, -8.56903344e-02f, 9.32254493e-02f, 1.05093323e-01f,
  1.37962848e-01f, 2.05489129e-01f, -3.86823453e-02f, 1.02883257e-01f, 1.13602772e-01f, -1.15140945e-01f, -6.25989661e-02f, -8.31473991e-02f, 1.20417990e-01f, -1.03541277e-01f,
  1.16636232e-01f, -4.83186496e-03f, -2.54276805e-02f, 1.72625463e-02f, -8.56093913e-02f, 7.15378150e-02f, -6.46088794e-02f, -8.55918694e-03f, 7.11320862e-02f, 1.21306218e-01f,
  1.18713245e-01f, 1.10852703e-01f, -2.67460272e-02f, -1.26290008e-01f, 2.60949880e-02f, 3.39104198e-02f, 3.72699164e-02f, 1.20898724e-01f, 6.14094771e-02f, 1.54013157e-01f,
  -5.41056581e-02f, 1.27562344e-01f, -1.23246141e-01f, -8.42006356e-02f, 9.15620923e-02f, -8.85674879e-02f, -2.49998160e-02f, 7.23939836e-02f, 5.92523664e-02f, -9.35965851e-02f,
  7.35762864e-02f, 4.59301807e-02f, 6.40038550e-02f, -1.09900542e-01f, -1.05231740e-01f, -1.07171476e-01f, -8.00597221e-02f, -9.68709663e-02f, 2.16412283e-02f, 1.07932739e-01f,
  2.72495206e-02f, 8.21989030e-02f, 6.82758391e-02f, -4.88162525e-02f, -9.76757109e-02f, -5.96869886e-02f, 3.87611464e-02f, -9.25233215e-02f, 2.62511503e-02f, 8.30533355e-02f,
  3.52702977e-04f, -5.15864566e-02f, 4.68593137e-03f, -8.41201991e-02f, -5.09582693e-03f, -4.96032871e-02f, 1.04646981e-01f, 2.69566253e-02f, -1.19595774e-01f, -3.83068956e-02f,
  2.65914705e-02f, -6.28415942e-02f, 5.21869138e-02f, 7.58073106e-02f, -8.32650289e-02f, 1.67593986e-01f, 9.09877494e-02f, 8.76872391e-02f, 1.42690420e-01f, 5.35335019e-02f,
  -1.91130824e-02f, -7.88101479e-02f, 1.09113622e-02f, -1.10172160e-01f, -9.64665040e-02f, 1.11172140e-01f, 4.95786630e-02f, 4.69374731e-02f, 9.39092264e-02f, 6.96378388e-03f,
  1.56252891e-01f, -6.48592561e-02f, 4.97641303e-02f, -1.84455037e-01f, 9.54311565e-02f, -9.04432908e-02f, -5.64593151e-02f, 9.06003523e-04f, -1.22709079e-02f, -5.91598377e-02f,
  -9.42204669e-02f, 5.87179922e-02f, 4.86593060e-02f, -7.44124129e-02f, 1.05505306e-02f, -9.51527208e-02f, 5.13500199e-02f, -1.18244655e-01f, 1.66092440e-02f, -5.22601791e-02f,
  -3.84768583e-02f, -2.22592950e-02f, 6.34377971e-02f, -7.73257688e-02f, 5.93229569e-02f, 8.88240710e-02f, 2.05871701e-01f, -3.74001227e-02f, 4.50509861e-02f, 1.21737525e-01f,
  7.85276815e-02f, -6.88580284e-03f, -1.12439491e-01f, -1.05547369e-01f, -3.31139080e-02f, 1.35252625e-01f, -1.08894370e-01f, 1.26852930e-01f, -1.17525950e-01f, 4.50435560e-04f,
  9.96376798e-02f, -8.28371495e-02f, -8.96672979e-02f, 9.59344581e-02f, 5.85844219e-02f, 1.50670111e-01f, -2.88636126e-02f, 1.41545817e-01f, 6.39609620e-02f, 8.23764652e-02f,
  1.93212610e-02f, 1.38738170e-01f, 5.42145595e-02f, 1.59602612e-01f, -8.03186372e-02f, 1.82629630e-01f, -1.22430980e-01f, -1.76682770e-01f, 6.32243752e-02f, 6.93949498e-03f,
  2.24659264e-01f, 2.68872052e-01f, 5.82255051e-02f, -2.77477764e-02f, 1.59997661e-02f, -1.86299309e-02f, -1.99123081e-02f, -2.25027114e-01f, 1.58868975e-03f, 5.19416742e-02f,
  -4.22324762e-02f, -9.42364037e-02f, 2.62455583e-01f, 9.08315834e-03f, -1.26330718e-01f, 2.36903921e-01f, 3.24772336e-02f, -5.67809418e-02f, 9.25511792e-02f, -1.04596261e-02f,
  3.42941913e-03f, 2.01124385e-01f, 6.31759092e-02f, 5.56735098e-02f, 5.83265387e-02f, 3.61427926e-02f, 2.74474353e-01f, 7.51081556e-02f, -6.60587549e-02f, -1.72272071e-01f,
  2.88644522e-01f, 9.98977423e-02f, 1.39485216e-02f, -5.97242862e-02f, 3.08554232e-01f, 5.79635873e-02f, -1.02327429e-01f, -6.26659989e-02f, 1.38875410e-01f, 1.14116512e-01f,
  1.42151192e-01f, 2.03494921e-01f, -6.58176094e-02f, 7.25871250e-02f, 1.77237228e-01f, 1.05197215e-02f, 1.52283181e-02f, -1.94008857e-01f, -5.06448299e-02f, 1.05641320e-01f,
  1.92510430e-02f, 8.32418352e-02f, 8.21543112e-02f, 3.13305855e-02f, 6.80617094e-02f, 2.67760962e-01f, 1.88201815e-01f, 1.79851085e-01f, 1.23017758e-01f, 2.00700954e-01f,
  -1.26614626e-02f, 9.00201872e-02f, -8.82425755e-02f, -2.88680624e-02f, 1.08180143e-01f, 1.03949286e-01f, -1.53107971e-01f, -1.08971491e-01f, 1.09789982e-01f, 5.07979542e-02f,
  1.48730546e-01f, 7.11755827e-02f, -8.38444382e-02f, 1.52634487e-01f, 1.96095735e-01f, 6.44370392e-02f, -2.21861508e-02f, -1.14115529e-01f, 7.84752890e-02f, -2.79587284e-02f,
  2.16155220e-03f, 1.66792572e-02f, 1.60172954e-01f, -1.16860762e-01f, 1.17070436e-01f, 5.60178906e-02f, 7.83750787e-02f, 4.06233594e-02f, -1.43465146e-01f, -7.43554160e-02f,
  -4.11031040e-04f, 8.89645964e-02f, 9.50902179e-02f, -7.33285919e-02f, -1.01958573e-01f, 1.00912057e-01f, 3.49014103e-02f, -9.72071812e-02f, -8.01594555e-02f, -1.16602391e-01f,
  -1.05726548e-01f, 9.26559698e-03f, -1.96417328e-02f, 2.60711890e-02f, -4.96333539e-02f, 6.74667135e-02f, 1.21847242e-01f, 8.37634355e-02f, 3.99796851e-02f, 6.61669597e-02f,
  1.28037006e-01f, 6.30399063e-02f, -1.31443162e-02f, 3.82378846e-02f, 1.18380800e-01f, 7.99164996e-02f, -8.23221654e-02f, 1.76291838e-01f, -2.37746313e-02f, 1.41412228e-01f,
  1.54419243e-01f, 4.08764966e-02f, 6.74649179e-02f, 1.24890000e-01f, -1.56891406e-01f, -1.32409945e-01f, -1.56952050e-02f, 6.14336729e-02f, -4.84048715e-03f, 1.64309353e-01f,
  7.57773742e-02f, -8.11690241e-02f, 6.37801588e-02f, -5.08463867e-02f, -7.98522159e-02f, -1.90282613e-01f, 4.03024219e-02f, 4.02584299e-02f, 7.41065741e-02f, 9.41051543e-02f,
  -1.09327316e-01f, 1.30391181e-01f, 1.49700701e-01f, 9.33874175e-02f, 1.74054019e-02f, 2.91508567e-02f, -8.49735588e-02f, -1.18371539e-01f, -1.04361244e-01f, -1.30933478e-01f,
  1.02243990e-01f, 3.04745566e-02f, 7.93465972e-02f, 7.02993870e-02f, 1.18613183e-01f, -9.87029150e-02f, -1.62155982e-02f, -9.01920423e-02f, 7.06293136e-02f, 1.66617498e-01f,
  1.06992401e-01f, 1.90761864e-01f, 1.17835887e-01f, 6.70672432e-02f, -7.17061386e-02f, 5.82389720e-03f, -1.20828018e-01f, 1.45580843e-01f, -8.77839401e-02f, -1.17282905e-01f,
  -5.51704597e-03f, -9.80359092e-02f, 1.24578692e-01f, -4.36142050e-02f, -1.33162707e-01f, -8.54849815e-03f, 2.12205332e-02f, 4.01887260e-02f, 8.15994218e-02f, 2.65315967e-03f,
  -3.02818194e-02f, -6.05582185e-02f, -1.19812107e-02f, 6.77471682e-02f, 1.05582714e-01f, 1.48782626e-01f, 1.15644783e-01f, -2.21928302e-02f, -1.17739163e-01f, -1.97753552e-02f,
  2.08149459e-02f, 6.76726773e-02f, 1.60010636e-01f, -1.65632553e-02f, 8.45167190e-02f, -7.71653727e-02f, 1.22654475e-01f, -4.43733931e-02f, 2.98605338e-02f, -4.63839024e-02f,
  -7.87390396e-02f, 1.50033191e-01f, 1.91569611e-01f, -8.17383751e-02f, 3.75750326e-02f, -1.00342862e-01f, -5.99884167e-02f, -1.69701893e-02f, -4.72052433e-02f, -2.45065894e-03f,
  4.89036739e-02f, -2.76571941e-02f, 5.31229228e-02f, 9.59535167e-02f, -1.02675244e-01f, -9.19931605e-02f, -4.19349521e-02f, 6.12172298e-02f, 4.04212996e-02f, -1.10632315e-01f,
  -1.74075656e-03f, -1.24829486e-01f, 4.51544076e-02f, -1.16937496e-02f, -7.89396092e-03f, -1.33475989e-01f, 1.30512878e-01f, 1.00244172e-01f, -2.69536544e-02f, -3.38064916e-02f,
  -5.60289361e-02f, 5.78501932e-02f, -1.35325799e-02f, 7.05594346e-02f, 1.19306715e-02f, -5.88656478e-02f, -2.59745177e-02f, 1.12136893e-01f, 1.39840037e-01f, -1.34884790e-01f,
  -1.92535892e-02f, -3.70443985e-03f, -1.77879408e-02f, -6.28056601e-02f, 1.31489888e-01f, -1.08991049e-01f, 1.13367788e-01f, -2.13391911e-02f, 1.20208725e-01f, 3.65128703e-02f,
  -8.18450004e-03f, -7.58361891e-02f, 1.13898627e-01f, 6.15746900e-02f, 3.64300907e-02f, -3.27935889e-02f, -2.95937266e-02f, 1.50860008e-02f, 2.64053214e-02f, 5.31338118e-02f,
  6.24005571e-02f, -9.11639407e-02f, 5.38593978e-02f, 1.27897009e-01f, 1.85952280e-02f, -4.75735925e-02f, -3.67089943e-03f, -1.12846941e-01f, -1.24486968e-01f, -1.20761758e-02f,
  1.29051819e-01f, -1.19934015e-01f, -1.08539753e-01f, -2.97217462e-02f, -1.63099042e-03f, -1.03472561e-01f, -9.39183533e-02f, -9.36862528e-02f, -3.63359079e-02f, -2.37775806e-04f,
  -8.88938531e-02f, 1.10858098e-01f, -8.21909904e-02f, 7.18078241e-02f, -5.44479210e-03f, -2.28174473e-03f, 1.54351220e-02f, 8.38797763e-02f, 9.01853591e-02f, -6.11471906e-02f,
  -9.63643789e-02f, -1.82445571e-02f, -1.00202627e-01f, 1.36333987e-01f, -1.96172856e-02f, -1.14636250e-01f, 1.24088727e-01f, -6.43289611e-02f, -1.04504563e-01f, 3.10006402e-02f,
  -2.68755993e-03f, -4.83012199e-02f, 3.25836465e-02f, -3.61059681e-02f, 4.66772467e-02f, 5.86375669e-02f, 1.29449636e-01f, 7.57014677e-02f, 1.93248726e-02f, 5.12916408e-02f,
  -3.19603719e-02f, 6.20331652e-02f, 1.31152809e-01f, 6.31575435e-02f, 2.12067105e-02f, -9.37071145e-02f, -5.12303002e-02f, 1.37329493e-02f, 1.23705678e-01f, 1.32124946e-01f,
  1.40568212e-01f, 9.43313465e-02f, -3.33635919e-02f, 1.13133289e-01f, 2.23297682e-02f, 1.83514692e-02f, 1.73218831e-01f, 7.38096982e-02f, -9.25718546e-02f, -3.69369574e-02f,
  -1.08884886e-01f, 1.43561978e-03f, 4.29601176e-03f, -9.29676816e-02f, -5.08396551e-02f, -1.29753808e-02f, -2.88678391e-04f, -8.34129676e-02f, 1.10211506e-01f, -8.52037743e-02f,
  -9.43325311e-02f, 9.75226760e-02f, -3.77139188e-02f, 1.39725655e-01f, 5.25931865e-02f, 1.07349701e-01f, -7.59095922e-02f, -5.12178726e-02f, -5.87081388e-02f, 5.11204749e-02f,
  1.12678111e-02f, 4.05381136e-02f, -5.86809479e-02f, -1.06113113e-01f, 1.21287361e-01f, 1.12940677e-01f, -2.08147746e-02f, -5.78916334e-02f, 1.14439443e-01f, 4.98267375e-02f,
  1.20228209e-01f, 3.21754813e-02f, 9.38953087e-02f, 9.85967442e-02f, -2.54477486e-02f, -8.68040174e-02f, 1.55973360e-01f, 6.66240230e-02f, 5.13393581e-02f, -6.43400550e-02f,
  1.52012378e-01f, 1.22842722e-01f, 6.28120527e-02f, -1.70251384e-01f, 5.72486110e-02f, 2.11682543e-01f, 1.04619719e-01f, 1.06365174e-01f, 1.98256690e-02f, -2.99513750e-02f,
  3.87675166e-02f, 8.03493783e-02f, 8.44519660e-02f, 2.27216303e-01f, 1.46208137e-01f, -3.59473489e-02f, -3.26389298e-02f, 7.95851573e-02f, -1.15845628e-01f, 8.68305042e-02f,
  1.21763952e-01f, 1.65227890e-01f, -1.60165522e-02f, 1.73474208e-01f, -7.90729597e-02f, -1.18563719e-01f, 1.18308567e-01f, -1.28633931e-01f, -2.81219129e-02f, -1.53059838e-02f,
  -8.81646276e-02f, -2.05659866e-02f, 1.14759609e-01f, -1.27721325e-01f, 3.22644375e-02f, -5.17023839e-02f, 1.50977140e-02f, -2.10266951e-02f, -4.88541694e-03f, 1.02111280e-01f,
  -1.57521576e-01f, 1.19068593e-01f, 1.16180137e-01f, 1.84579372e-01f, -5.41197062e-02f, 7.00686723e-02f, 2.76294854e-02f, -1.02957264e-01f, -1.00166872e-01f, 9.18831602e-02f,
  5.78820184e-02f, -3.31062227e-02f, -9.76900235e-02f, 8.79558176e-03f, -1.13653354e-01f, -9.40624028e-02f, 2.42582220e-03f, 1.36495948e-01f, 1.66905910e-01f, 1.41852587e-01f,
  -8.89633745e-02f, 1.23467091e-02f, 4.04274575e-02f, -5.45492955e-02f, 6.56026825e-02f, 6.17543682e-02f, -8.95741805e-02f, 1.12284318e-01f, -6.56374777e-03f, 1.76980600e-01f,
  1.66146845e-01f, -4.33911150e-03f, 1.01099297e-01f, -2.91844364e-02f, -1.57370716e-01f, 1.24654181e-01f, 1.55901061e-02f, -1.24440655e-01f, -1.07546866e-01f, 1.50441319e-01f,
  1.05920263e-01f, 7.86790401e-02f, 1.51739612e-01f, 1.94393277e-01f, 1.25905676e-02f, -5.02116571e-04f, -5.35171432e-03f, -1.35708144e-02f, -1.38725430e-01f, 7.00447783e-02f,
  1.68126911e-01f, 2.83599161e-02f, 5.82558364e-02f, 2.03304276e-01f, -7.13448301e-02f, 3.62199284e-02f, 8.30916688e-02f, -1.25565216e-01f, 1.18314914e-01f, 3.50832865e-02f,
  -6.47533685e-02f, 9.30892080e-02f, 1.04596652e-01f, -2.00325847e-02f, -2.44583003e-03f, -8.72444436e-02f, -5.17529733e-02f, -8.40737224e-02f, 2.51480252e-01f, 7.18139857e-02f,
  1.64915487e-01f, 2.39594251e-01f, 2.23527327e-01f, 8.14735070e-02f, -1.43329144e-01f, -1.16453677e-01f, 9.96072292e-02f, 1.72628775e-01f, 1.35462895e-01f, -5.28975017e-02f,
  -3.34869814e-03f, -5.76484315e-02f, 1.95573666e-03f, 9.76980105e-02f, -6.29756302e-02f, 3.50089781e-02f, -4.67152894e-02f, -1.03689775e-01f, -1.13122553e-01f, -3.36827114e-02f,
  -9.08955932e-02f, -9.22683924e-02f, -1.20734572e-01f, -4.87934500e-02f, -8.15180875e-03f, 1.21237800e-01f, -3.86558753e-03f, 1.50238920e-03f, -7.10784122e-02f, -2.78984867e-02f,
  -3.54546271e-02f, -1.00009300e-01f, 9.46131721e-02f, 5.86955547e-02f, 9.97306406e-02f, 5.62152863e-02f, 1.42113995e-02f, 1.14958271e-01f, -1.08582033e-02f, -3.64083238e-02f,
  4.70453352e-02f, 1.29126295e-01f, 5.36716022e-02f, -4.80012260e-02f, -1.48541927e-02f, 4.54986095e-02f, 3.25225182e-02f, 6.24696128e-02f, -1.00584604e-01f, 1.02342784e-01f,
  -1.21381499e-01f, -7.30329826e-02f, -5.97685874e-02f, -8.76799449e-02f, -1.23457089e-01f, 1.42620327e-02f, -1.02373660e-01f, 5.57394922e-02f, 5.95723689e-02f, -2.93318499e-02f,
  7.52543509e-02f, 8.40010792e-02f, 1.10774092e-01f, -8.17135200e-02f, 4.82524699e-03f, -8.73610750e-02f, 2.40598097e-02f, -5.52222729e-02f, 9.65470541e-03f, 3.11108269e-02f,
  -4.68410701e-02f, -3.51900756e-02f, 1.08495774e-03f, 2.39341985e-02f, 8.96043610e-03f, 1.04350314e-01f, -8.43223631e-02f, 7.73366615e-02f, 6.55539334e-02f, 4.29006033e-02f,
  -4.32402529e-02f, 8.87507014e-03f, -7.13692382e-02f, 2.59822141e-02f, 8.10998753e-02f, -7.72309974e-02f, -9.05380324e-02f, -1.11497760e-01f, 4.12276275e-02f, -9.95178521e-02f,
  -7.21199363e-02f, -7.02504516e-02f, -9.04461294e-02f, -6.24363050e-02f, -2.52769198e-02f, -9.14452225e-02f, -7.33567402e-02f, -4.10399213e-02f, 1.34020284e-01f, 8.91156271e-02f,
  8.10426772e-02f, -6.07691482e-02f, 2.15296764e-02f, 6.17480241e-02f, 1.16355054e-01f, 1.20929535e-02f, 1.26583070e-01f, 7.20989611e-03f, -4.08093631e-02f, 1.27094731e-01f,
  1.04607426e-01f, -4.31954898e-02f, 8.96526277e-02f, 3.18277143e-02f, 3.35357487e-02f, 7.46730417e-02f, 9.54235271e-02f, -2.26471163e-02f, 2.19365172e-02f, -1.35306686e-01f,
  -9.26878080e-02f, 4.44841897e-03f, 9.47600752e-02f, 4.95226346e-02f, 4.58137877e-02f, 7.15360194e-02f, -4.82998639e-02f, 8.42780545e-02f, 2.17119269e-02f, -1.56990886e-02f,
  -1.06120139e-01f, -9.48806703e-02f, 1.07838944e-01f, 1.32585168e-01f, -1.05944782e-01f, -1.17819592e-01f, 6.27517700e-02f, -1.60618275e-02f, 2.97650378e-02f, 7.69398920e-03f,
  8.23917389e-02f, -8.69918093e-02f, -8.59603509e-02f, 2.39291620e-02f, -3.65849137e-02f, -7.89523050e-02f, 9.22604203e-02f, -8.84224400e-02f, -4.21054102e-02f, -1.37016289e-02f,
  2.70563969e-03f, -9.78143979e-03f, 1.21244276e-03f, -1.05665080e-01f, -1.67122539e-02f, -7.68034160e-02f, 7.06371292e-02f, -9.53551829e-02f, -7.03778258e-03f, 2.27466132e-02f,
  7.63049722e-02f, 6.26420155e-02f, -4.59202230e-02f, 5.46665043e-02f, -8.78871977e-02f, 1.21688686e-01f, 1.24196157e-01f, -2.04378203e-03f, -6.09253384e-02f, 6.10712208e-02f,
  -5.27553959e-03f, 6.08031936e-02f, 1.44611653e-02f, 1.86454941e-04f, 4.14802507e-02f, 2.47595366e-03f, -4.27858084e-02f, 7.53097907e-02f, 9.30392221e-02f, -5.95863648e-02f,
  1.01213656e-01f, -1.71314878e-03f, -7.37539008e-02f, 2.03749500e-02f, -5.06671257e-02f, 1.14422277e-01f, 3.66863050e-02f, -2.69037168e-02f, -1.06318511e-01f, -9.08886865e-02f,
  6.39993092e-03f, -1.66921802e-02f, 5.56979179e-02f, -1.22945093e-01f, -1.20071962e-01f, -4.50502411e-02f, 1.20429702e-01f, 8.79751053e-03f, 6.58575371e-02f, -8.88452232e-02f,
  1.10823557e-01f, 1.00643210e-01f, -7.71690458e-02f, 1.18927486e-01f, 1.12385480e-02f, -3.06899454e-02f, -5.86798997e-04f, 1.14313029e-01f, -3.71544734e-02f, 5.86014874e-02f,
  8.67491737e-02f, -3.90873253e-02f, -8.22487995e-02f, 1.16810501e-01f, 9.43208635e-02f, -1.15518160e-01f, 1.44304216e-01f, 9.08712223e-02f, 1.17093734e-01f, 1.27409771e-01f,
  -1.07514620e-01f, -1.10622324e-01f, 7.42317587e-02f, -1.25646219e-01f, -1.47344600e-02f, -3.48591735e-03f, 6.92350119e-02f, 1.28245413e-01f, -2.13045720e-03f, 1.07878692e-01f,
  -1.49392292e-01f, 1.29709886e-02f, 1.02654837e-01f, 9.70941633e-02f, 4.02027927e-02f, -4.41156998e-02f, -7.89096504e-02f, 1.28661558e-01f, -4.03063931e-02f, -3.84620428e-02f,
  -5.35381436e-02f, 9.38883349e-02f, -1.03880517e-01f, 3.73380296e-02f, -1.03115151e-03f, 7.73049966e-02f, 2.52982024e-02f, 2.26661488e-02f, 3.77538949e-02f, 4.99492250e-02f,
  1.33952692e-01f, 6.56012371e-02f, -4.63962369e-02f, -1.21239074e-01f, -7.12560117e-02f, -9.82569680e-02f, -9.28022489e-02f, -1.04516156e-01f, 1.56853437e-01f, 9.67952833e-02f,
  1.19399264e-01f, -7.39121735e-02f, 1.14679679e-01f, 6.99050203e-02f, 4.06711772e-02f, -4.88224365e-02f, -2.19878536e-02f, 5.20231016e-03f, 9.39648077e-02f, 5.78903556e-02f,
  -1.38705581e-01f, -7.08283931e-02f, -1.56322923e-02f, 9.07395408e-02f, 9.62812081e-02f, 5.43896481e-02f, 1.78897172e-01f, 1.45483911e-01f, 1.49422526e-01f, -2.55342368e-02f,
  7.63336197e-02f, 1.62598684e-01f, 1.59763172e-02f, 9.05653238e-02f, -1.98217556e-02f, -2.03312457e-01f, -7.29116201e-02f, -1.93439320e-01f, 1.98567733e-02f, 2.81927846e-02f,
  -3.54602300e-02f, -9.58151221e-02f, -5.18931523e-02f, 1.91930793e-02f, -4.33096178e-02f, -4.07206314e-03f, -1.19126908e-01f, 9.02028382e-02f, 3.47690918e-02f, 4.28279787e-02f,
  1.38638824e-01f, -4.69669327e-03f, 3.00398003e-02f, 6.98801950e-02f, -1.35037944e-01f, 6.83685988e-02f, -1.15392625e-01f, 1.60496473e-01f, -1.63588894e-03f, 1.81708410e-02f,
  -8.81753638e-02f, 8.65640491e-02f, 1.25836030e-01f, 9.44138616e-02f, 6.44529462e-02f, 5.09800054e-02f, 1.17589332e-01f, -1.38551950e-01f, 7.64228925e-02f, 8.71650502e-02f,
  1.49539858e-01f, -1.71454325e-02f, 1.18121006e-01f, 8.25059339e-02f, 9.52147394e-02f, 1.69949625e-02f, 1.24810882e-01f, -8.89368281e-02f, 4.74269837e-02f, 1.59709394e-01f,
  3.02193202e-02f, -1.52756423e-01f, 1.16926543e-01f, 6.98872358e-02f, 3.98738198e-02f, -7.87926763e-02f, 5.50091825e-02f, 1.21551760e-01f, 3.75395603e-02f, 1.59436706e-02f,
  -3.33368145e-02f, 7.28459954e-02f, -5.01206182e-02f, -8.68972987e-02f, -2.87840553e-02f, 1.11357354e-01f, 5.44032604e-02f, -2.33981162e-02f, 1.09080307e-01f, -4.53687496e-02f,
  5.57323657e-02f, -6.58816621e-02f, 1.18281320e-02f, 1.27311587e-01f, -8.26121420e-02f, -6.84418902e-02f, -1.71368361e-01f, -1.71374492e-02f, 9.58247632e-02f, 1.00200355e-01f,
  6.22661039e-02f, -1.35092158e-02f, 5.06404415e-02f, -5.70827127e-02f, 7.74978995e-02f, 9.49627832e-02f, 1.10230364e-01f, 1.77507624e-02f, -9.34169367e-02f, 6.18970245e-02f,
  -3.24562080e-02f, 1.12179844e-02f, 7.73405796e-03f, -4.08751369e-02f, -6.04134649e-02f, 1.11912020e-01f, -4.14806232e-02f, -6.74078837e-02f, 1.35699973e-01f, -4.70109209e-02f,
  1.17379956e-01f, -3.00330278e-02f, -6.78369729e-03f, -2.07219440e-02f, -5.80018088e-02f, -9.23330635e-02f, 4.02251445e-03f, -5.47613129e-02f, -2.77338792e-02f, 9.23612341e-02f,
  -7.05347210e-02f, -2.20910031e-02f, 1.18144125e-01f, 1.15901038e-01f, 1.21415094e-01f, 1.32723093e-01f, 1.23430096e-01f, 1.18517548e-01f, 9.37424193e-04f, 8.17055404e-02f,
  1.33846059e-01f, 6.07292615e-02f, 3.02322442e-04f, 1.94183066e-01f, 9.76749659e-02f, 2.32067764e-01f, 9.41189453e-02f, 1.37736827e-01f, -2.89313942e-02f, 1.64503962e-01f,
  -1.76136084e-02f, 2.47871354e-02f, -5.34123927e-02f, -4.23299707e-02f, 2.31679287e-02f, -5.29030114e-02f, 7.92116299e-02f, 3.34005244e-02f, -1.90344900e-01f, 2.25087106e-01f,
  1.69305190e-01f, 1.33773461e-01f, -8.24633241e-02f, -3.03105950e-01f, -3.48065570e-02f, 1.50268987e-01f, 8.81773829e-02f, 1.02926031e-01f, 9.63425115e-02f, -2.55812649e-02f,
  1.30813599e-01f, 5.21565564e-02f, 1.04215339e-01f, -3.56503204e-02f, 3.57082412e-02f, -8.29538405e-02f, 2.87530106e-02f, -7.24491775e-02f, 1.32123502e-02f, 5.90720810e-02f,
  8.17065611e-02f, 3.93911544e-03f, 7.64020458e-02f, 1.19695604e-01f, -3.47739458e-02f, -2.70258393e-02f, 2.35624984e-01f, -9.78539586e-02f, 1.35806650e-01f, 3.59040312e-02f,
  6.13207296e-02f, 1.22766040e-01f, 1.46820080e-02f, 9.30707753e-02f, -4.98790406e-02f, -1.95584036e-02f, -1.86852999e-02f, -1.53856007e-02f, -1.17777228e-01f, -1.51637301e-01f,
  6.89500719e-02f, -1.05707355e-01f, 6.44349083e-02f, 9.12339017e-02f, 1.06397070e-01f, -1.37427542e-02f, 6.08721599e-02f, 7.52875023e-03f, 7.35891685e-02f, 5.23112640e-02f,
  -5.54440022e-02f, 5.73980622e-02f, -3.07911285e-03f, -7.67696574e-02f, -7.02786520e-02f, 1.44908935e-01f, 1.15187079e-01f, -1.26570165e-01f, -7.18940645e-02f, -1.61835492e-01f,
  -7.81976581e-02f, 1.22325197e-01f, 1.69635527e-02f, -1.32033408e-01f, -1.09720103e-01f, -1.70256644e-01f, -7.16102645e-02f, -1.04137681e-01f, -1.22686075e-02f, -8.25772136e-02f,
  8.85946378e-02f, -3.07189655e-02f, -1.12588838e-01f, 7.89463893e-02f, 5.05823754e-02f, -1.74850430e-02f, 3.19842957e-02f, 4.60448749e-02f, -1.27896801e-01f, -1.22995824e-01f,
  6.26701489e-02f, -1.20320283e-01f, -2.21062768e-02f, 1.06786005e-01f, -5.38055599e-02f, 7.28307962e-02f, -7.31222332e-02f, -4.12410917e-03f, -1.23659790e-01f, 7.27418950e-03f,
  -6.38113022e-02f, 6.61972836e-02f, -6.24870434e-02f, -5.56195267e-02f, -2.17402596e-02f, -1.37380473e-02f, 5.20160682e-02f, 7.15324283e-02f, 6.77730665e-02f, 9.68989581e-02f,
  4.08663154e-02f, 1.22412965e-01f, 3.17214206e-02f, -3.49125676e-02f, 9.73592997e-02f, 1.48413971e-03f, -2.90325023e-02f, 1.33398980e-01f, 4.74626292e-03f, 6.30860403e-02f,
  -1.04166567e-01f, -9.20922980e-02f, 9.13827568e-02f, 5.69706522e-02f, 1.08942032e-01f, 1.44768745e-01f, -1.15478687e-01f, -4.10975851e-02f, -9.31000039e-02f, -7.61661828e-02f,
  -3.72013710e-02f, -7.11654052e-02f, -9.19303149e-02f, 1.06859878e-01f, -4.13342938e-02f, -5.56358248e-02f, -3.44053246e-02f, -9.78718325e-02f, 9.45475250e-02f, 1.49382696e-01f,
  -6.80625588e-02f, -1.89810935e-02f, -3.21095884e-02f, 1.37311533e-01f, -7.23979920e-02f, -4.63708900e-02f, 3.24219912e-02f, -4.36839201e-02f, 4.33199629e-02f, -1.09928161e-01f,
  5.70448227e-02f, -7.98382908e-02f, -2.65628267e-02f, -5.29343523e-02f, 7.83070475e-02f, 2.13959627e-02f, 4.87015136e-02f, -8.16852078e-02f, 1.07325008e-02f, 6.28933497e-03f,
  -2.73936354e-02f, -1.97496582e-02f, -3.58090773e-02f, 7.42108449e-02f, 3.21794339e-02f, -1.26453057e-01f, -1.02336086e-01f, 2.59095132e-02f, -6.81052059e-02f, -9.76006165e-02f,
  -9.52165127e-02f, 4.47380096e-02f, -1.23719566e-01f, 8.99673551e-02f, 8.66833702e-02f, 3.43688354e-02f, -1.15345925e-01f, 5.22504114e-02f, -7.39248246e-02f, -9.27522108e-02f,
  -9.15107876e-02f, -2.65573449e-02f, 9.72306654e-02f, 2.81186048e-02f, 7.75930136e-02f, -2.13295575e-02f, -2.56543048e-02f, -7.78778717e-02f, 1.87538844e-02f, -7.37232789e-02f,
  8.00248086e-02f, 4.80184564e-03f, -8.03731680e-02f, 6.19842038e-02f, 9.67291445e-02f, -5.07124364e-02f, -6.92041665e-02f, -8.36457536e-02f, -9.67831016e-02f, 1.15906838e-02f,
  1.84047390e-02f, 1.05277998e-02f, -7.38182757e-03f, 3.75553854e-02f, 1.23301379e-01f, 1.20292351e-01f, 3.35499495e-02f, 2.84612719e-02f, 7.43146837e-02f, 1.58539247e-02f,
  -1.25740990e-01f, 3.59306745e-02f, -5.72472177e-02f, -3.69910859e-02f, -9.35439020e-02f, -1.17673099e-01f, 4.02084291e-02f, -7.14522228e-02f, -7.60968477e-02f, -3.70718800e-02f,
  -7.96853602e-02f, 6.30507767e-02f, 1.04046958e-02f, -1.18704200e-01f, 8.19164794e-03f, 1.36569738e-01f, 1.16932303e-01f, 1.13662042e-01f, 3.76515128e-02f, -1.15977200e-02f,
  3.11634596e-03f, 2.75147203e-02f, -9.52462703e-02f, -1.29609466e-01f, 6.79838061e-02f, 1.16353761e-02f, -8.60934481e-02f, 4.47811969e-02f, -3.18761244e-02f, -1.16504341e-01f,
  -7.40201995e-02f, -6.73495308e-02f, -1.67675372e-02f, 4.64871973e-02f, 1.19390294e-01f, -8.46301094e-02f, -4.85982606e-03f, 2.03302667e-01f, 1.06573477e-01f, -7.55646825e-03f,
  1.76763147e-01f, 2.14071944e-01f, -9.39676911e-03f, 7.71346614e-02f, 6.52638227e-02f, 2.41302982e-01f, 5.67798577e-02f, -2.57294010e-02f, -3.03622112e-02f, 9.61536765e-02f,
  -1.44547269e-01f, 1.43335268e-01f, 3.43020141e-01f, 1.49387762e-01f, -1.42055959e-01f, 9.22185555e-03f, 2.22927466e-01f, 1.79896891e-01f, 1.84036300e-01f, -7.81512260e-02f,
  -1.34225518e-01f, 1.21858373e-01f, 1.02592468e-01f, 1.05596162e-01f, 2.50068912e-03f, -8.79123993e-03f, -1.62345886e-01f, 5.54412417e-02f, 9.13395807e-02f, -1.28725260e-01f,
  2.67428085e-02f, 9.93181169e-02f, 1.09931886e-01f, 1.44069135e-01f, 3.86620350e-02f, -1.53473079e-01f, 5.77748902e-02f, -6.61330074e-02f, 6.06971681e-02f, -8.84705633e-02f,
  -7.61440210e-03f, -6.49536625e-02f, 6.28456548e-02f, -1.48240373e-01f, -2.71118265e-02f, -5.15109748e-02f, 1.35038063e-01f, -4.97464910e-02f, -3.55177000e-02f, 1.43299490e-01f,
  1.28546059e-01f, 1.26915216e-01f, 7.46162459e-02f, 1.39830425e-01f, 1.23506047e-01f, 2.53707379e-01f, -1.10666946e-01f, 3.82220782e-02f, 2.97263116e-01f, -8.05215985e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.42154902e-01f, 1.13833122e-01f, 4.98321652e-02f, 1.89915612e-01f, -1.42249921e-02f, 2.61456035e-02f, 5.63638397e-02f, 2.98007190e-01f, -1.86264552e-02f, 4.05269153e-02f,
  1.48483112e-01f, 8.98779649e-03f, 1.07707947e-01f, -1.07908480e-01f, 9.80647840e-03f, 1.76398695e-01f, -2.37843245e-02f, -1.03565447e-01f, -4.34310846e-02f, -6.65727013e-04f,
  -3.76531817e-02f, -4.57862169e-02f, 1.75273970e-01f, 4.43708636e-02f, 1.23001531e-01f, 6.58978224e-02f, -6.69214800e-02f, 1.23547450e-01f, 1.88321099e-01f, 2.37246733e-02f,
  2.44275648e-02f, 1.95798352e-02f, 5.21073416e-02f, 4.09590341e-02f, 1.41880542e-01f, 1.41919032e-01f, 1.55551195e-01f, 1.16000533e-01f, -8.20588768e-02f, 1.70212984e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  5.56930304e-02f, 1.05480880e-01f, 5.22665679e-02f, -6.67955503e-02f, 1.07567996e-01f, -2.60227881e-02f, -7.06640258e-02f, -4.46280912e-02f, 4.67791110e-02f, 7.28669092e-02f,
  -6.55895323e-02f, 1.50413085e-02f, -2.23545253e-01f, 4.01380435e-02f, -3.18127759e-02f, -8.38758331e-03f, -1.41630039e-01f, 5.53049967e-02f, 1.38971224e-01f, 2.12144345e-01f,
  -1.07929319e-01f, 3.09359543e-02f, -1.73507947e-02f, -8.36038291e-02f, -1.97865684e-02f, 4.09337180e-03f, -2.67814100e-02f, -2.59396248e-02f, -4.43233326e-02f, 5.82556576e-02f,
  -2.23995522e-02f, -5.33660427e-02f, 8.44556987e-02f, -2.14192667e-03f, -1.41709447e-01f, -1.53938130e-01f, 7.88430348e-02f, 9.63854045e-02f, 6.69722585e-03f, 9.67937559e-02f,
  6.47153035e-02f, -6.36265799e-02f, -1.29313603e-01f, 8.01498815e-02f, -1.38863146e-01f, -6.40970692e-02f, -5.85507005e-02f, 1.61285460e-01f, -1.22982496e-02f, 5.87732345e-02f,
  4.63518389e-02f, -8.60487744e-02f, -6.42839074e-02f, 5.11487275e-02f, -8.35006014e-02f, -2.27218717e-02f, 8.83975811e-03f, 3.91842760e-02f, -8.02617520e-02f, 7.36982003e-02f,
  1.20753825e-01f, 7.44444877e-02f, -6.52213171e-02f, -2.31253728e-01f, -1.57994345e-01f, -4.54020649e-02f, -3.53057636e-04f, 4.73606698e-02f, -1.22586839e-01f, 3.26865576e-02f,
  -1.18460193e-01f, -5.41681275e-02f, -1.27914235e-01f, -3.30256782e-02f, -6.23936951e-02f, 3.53420824e-02f, -9.80733633e-02f, 1.07603982e-01f, 1.32650986e-01f, 2.82207988e-02f,
  1.12659201e-01f, -2.67391615e-02f, -2.06100196e-01f, -2.21921399e-01f, -2.26694554e-01f, 7.95223862e-02f, -3.10759973e-02f, -2.21272763e-02f, -1.60699904e-01f, -2.12363273e-01f,
  -5.73446453e-02f, 5.73854521e-02f, 1.40090182e-01f, -7.86543190e-02f, 3.92335514e-03f, 1.06430754e-01f, -1.05458517e-02f, -7.29577988e-02f, -1.08915567e-01f, 1.58294007e-01f,
  6.23331629e-02f, 3.70790251e-02f, -6.05344027e-02f, 9.26824287e-02f, -2.63940152e-02f, -5.23405382e-03f, 7.30289444e-02f, -7.93496668e-02f, -7.25080296e-02f, 2.92859048e-01f,
  5.74828126e-03f, 3.82914115e-03f, 4.41347137e-02f, -7.20655918e-02f, 3.89749557e-02f, -1.44404724e-01f, 1.39744684e-01f, 4.18856777e-02f, -2.26054583e-02f, -1.12583056e-01f,
  -5.91162331e-02f, 1.08896270e-01f, 5.73774278e-02f, 3.65213640e-02f, -1.53795078e-01f, 6.77898899e-02f, -7.06035551e-03f, 8.96632373e-02f, -4.83570807e-02f, -3.54530290e-03f,
  1.48727939e-01f, 1.18656978e-01f, -5.25768031e-04f, -1.09917894e-01f, 1.39147803e-01f, 3.10176909e-02f, 6.42741174e-02f, 2.16537356e-01f, 7.81241199e-03f, -3.66637856e-02f,
  -6.13867864e-02f, 3.32117714e-02f, -1.71165451e-01f, -6.03164826e-03f, -1.82197139e-01f, 2.00830042e-01f, 1.87518001e-01f, 1.32357001e-01f, -2.00030804e-02f, -1.96346790e-01f,
  3.80299576e-02f, -8.97439122e-02f, 9.07255635e-02f, 2.52726953e-03f, -1.01559022e-02f, 5.78238592e-02f, -1.21816263e-01f, -7.82656074e-02f, -4.50466163e-02f, 5.08335531e-02f,
  -6.93142787e-02f, 1.86098423e-02f, -1.74988329e-01f, -2.05770299e-01f, 1.05930023e-01f, 5.81864826e-03f, 6.39899671e-02f, 1.17447644e-01f, 1.08544923e-01f, -7.30351061e-02f,
  -1.25316724e-01f, -1.74945593e-02f, -1.45295084e-01f, -2.38716111e-01f, 1.31469831e-01f, 3.47250029e-02f, -9.66006219e-02f, 8.16146806e-02f, 1.49575118e-02f, 1.20960422e-01f,
  8.50036442e-02f, -1.33136585e-01f, -6.06418066e-02f, 4.03390937e-02f, -1.92907434e-02f, -1.45451084e-01f, 3.67035791e-02f, -6.44755960e-02f, 7.66570345e-02f, -1.60561129e-02f,
  -6.12208843e-02f, -1.38665557e-01f, -1.00847222e-01f, -3.14536244e-02f, -5.48674576e-02f, 1.23320874e-02f, 5.90609526e-03f, 7.51021579e-02f, 1.66614503e-01f, -1.35187833e-02f,
  1.31215319e-01f, 1.36313647e-01f, 1.35597959e-01f, -1.18542612e-01f, -1.04070686e-01f, 4.62465547e-02f, 6.68696165e-02f, -6.63134456e-02f, 8.04987475e-02f, -1.39879107e-01f,
  -1.06741533e-01f, 7.88680017e-02f, -1.06662311e-01f, -1.06744759e-01f, -2.75391107e-03f, 1.00000195e-01f, 8.45184028e-02f, 2.15533242e-01f, -1.14522122e-01f, 8.62263069e-02f,
  5.41245826e-02f, -1.29426166e-01f, -8.55573937e-02f, -1.86808944e-01f, 7.51052331e-03f, -5.77121638e-02f, 1.63257539e-01f, 8.63635913e-02f, -7.06991181e-02f, -6.52561486e-02f,
  8.24158490e-02f, 5.46640977e-02f, 8.75004381e-02f, -5.70153911e-03f, 2.52933204e-02f, -1.01578452e-01f, 3.73700671e-02f, -2.03595370e-01f, -5.94233163e-02f, -1.11996770e-01f,
  -1.38614833e-01f, 8.05976465e-02f, 6.84582116e-03f, -1.30912498e-01f, -1.14742883e-01f, 8.00627051e-04f, 8.76819268e-02f, 6.84795156e-02f, -5.13685718e-02f, -1.37926742e-01f,
  -5.54715358e-02f, 3.86211686e-02f, 8.86210352e-02f, 1.03348028e-02f, 3.54369543e-02f, -2.99879983e-02f, -7.85653666e-02f, -1.04294606e-01f, -3.19986641e-02f, -5.54022416e-02f,
  5.21457829e-02f, 8.57956931e-02f, -7.15135038e-02f, 1.74549837e-02f, -1.22730605e-01f, 8.40003192e-02f, -1.06161810e-01f, 1.57991576e-03f, 4.71189320e-02f, -7.22724199e-02f,
  -3.44046727e-02f, -9.66168419e-02f, 1.25517264e-01f, 8.15213472e-03f, -1.15099311e-01f, 9.07372460e-02f, -5.70867173e-02f, -1.42690808e-01f, 2.75046267e-02f, 5.42335510e-02f,
  1.44148665e-02f, 4.77347970e-02f, -1.14592992e-01f, 1.08084470e-01f, 9.55192298e-02f, -5.58070876e-02f, -8.00928101e-02f, 9.34138987e-03f, -4.72472869e-02f, 1.07403755e-01f,
  1.19181596e-01f, -1.49537936e-01f, 8.81419852e-02f, 6.32720143e-02f, -3.71135995e-02f, -9.68772545e-02f, 5.52827716e-02f, -8.01685452e-02f, -9.15539786e-02f, 4.70323898e-02f,
  6.54882938e-02f, -8.32495391e-02f, 1.33312017e-01f, 6.36926666e-02f, 7.94464946e-02f, 9.25176442e-02f, 7.48178363e-02f, -4.62042503e-02f, -4.96762879e-02f, 1.19246189e-02f,
  -1.00423815e-03f, 1.62446499e-02f, -1.00274511e-01f, 1.39982030e-02f, -8.71304274e-02f, -2.30806246e-02f, 1.31939426e-01f, 2.93838214e-02f, -8.08463842e-02f, -1.57617450e-01f,
  6.15559444e-02f, 8.28923360e-02f, -1.45660698e-01f, 6.67638257e-02f, 7.88657963e-02f, -1.13917634e-01f, 1.04707956e-01f, -2.25516539e-02f, -4.91618924e-02f, -6.07848261e-03f,
  -9.43109244e-02f, -1.79443181e-01f, 1.47834783e-02f, -4.30030189e-02f, 2.15650320e-01f, -6.69386536e-02f, 1.33304134e-01f, -5.69561012e-02f, -3.03111561e-02f, -5.76995425e-02f,
  -2.66552381e-02f, 1.33806288e-01f, -8.16569999e-02f, -1.23436913e-01f, -1.29062444e-01f, -4.55692597e-02f, -7.09110126e-02f, 1.11235574e-01f, 1.41572073e-01f, -1.23669982e-01f,
  7.49950483e-02f, 8.86423737e-02f, 5.33571318e-02f, -1.14647590e-01f, 1.86661735e-01f, 1.78259820e-01f, 1.45814121e-01f, -3.12601402e-02f, 1.50893279e-03f, -1.22587353e-01f,
  -6.76055476e-02f, -3.10678557e-02f, 9.22219455e-02f, 1.09048516e-01f, -5.61909601e-02f, 7.22065717e-02f, 1.82182178e-01f, -2.61665285e-02f, 1.22322455e-01f, -2.15123501e-02f,
  1.44041210e-01f, 1.02557912e-01f, 2.90130209e-02f, 6.91535324e-02f, -1.23487450e-01f, 9.39875618e-02f, 5.18412590e-02f, -1.51857138e-01f, 9.52330381e-02f, -2.94736703e-03f,
  8.88909474e-02f, 9.09051858e-03f, -3.35312076e-02f, 3.31687815e-02f, -8.70032310e-02f, 9.26286727e-02f, -4.99262102e-02f, -1.12855382e-01f, -1.22465529e-02f, -1.10340007e-01f,
  -6.11448139e-02f, 1.09988645e-01f, 8.02898705e-02f, 3.65283675e-02f, 4.66429070e-02f, -7.53220320e-02f, -4.76743020e-02f, 7.34915957e-02f, -1.66292444e-01f, -1.62520379e-01f,
  -1.64444387e-01f, -3.59255858e-02f, 4.51467149e-02f, 1.43332928e-01f, 1.35589108e-01f, -1.69830889e-01f, -1.25097586e-02f, -1.52928591e-01f, 1.17064659e-02f, 1.86890125e-01f,
  -1.09893829e-01f, 3.63474563e-02f, -9.85741690e-02f, 4.81021032e-02f, -4.62140180e-02f, -1.65526852e-01f, 5.28072659e-03f, -1.42243747e-02f, 7.10440055e-03f, -1.34142399e-01f,
  1.37324095e-01f, -1.87527332e-02f, 2.31974907e-02f, 2.18422934e-02f, -3.18656862e-02f, -3.73146906e-02f, -1.44429594e-01f, 1.20653637e-01f, 6.71311840e-02f, -1.99979365e-01f,
  1.92740746e-02f, 7.76696310e-04f, -1.35769084e-01f, -5.80797493e-02f, -1.03584863e-01f, -3.01642846e-02f, -1.03409655e-01f, 3.01847700e-02f, -1.10407360e-02f, 6.10648282e-02f,
  5.51494695e-02f, -1.98873989e-02f, -1.02286771e-01f, 1.12505570e-01f, -1.34446681e-01f, 9.53335762e-02f, -5.77618927e-03f, 1.62157323e-03f, -7.34180212e-02f, -9.65362117e-02f,
  2.24085059e-02f, -4.57865298e-02f, 6.21184707e-02f, -6.63191900e-02f, 5.96582815e-02f, 1.82237346e-02f, -5.74436225e-02f, 7.38554001e-02f, 3.20584252e-02f, -6.62597790e-02f,
  -6.57806844e-02f, -1.05572954e-01f, 3.95123325e-02f, -1.06806820e-02f, -3.75577658e-02f, 2.13095043e-02f, 1.92430604e-03f, -8.43226761e-02f, 3.11160106e-02f, -4.70988415e-02f,
  -6.07905425e-02f, -9.33154002e-02f, 6.93060681e-02f, 1.11534595e-01f, -1.14696249e-01f, 1.80021522e-03f, -1.36938587e-01f, 1.29190281e-01f, -9.45532769e-02f, -1.61098260e-02f,
  4.00399603e-03f, -4.10883501e-02f, -1.19840316e-01f, -1.36612549e-01f, -6.95809126e-02f, 1.05960034e-01f, 1.33024618e-01f, 8.22706074e-02f, 7.08032772e-02f, 1.35817835e-02f,
  4.95174639e-02f, 9.55497026e-02f, -8.82015154e-02f, -1.50364086e-01f, 2.09378507e-02f, 2.92830952e-02f, 1.87729932e-02f, 4.60126102e-02f, -1.35290265e-01f, -2.36079320e-02f,
  -3.40407416e-02f, -1.17688030e-01f, 1.40021577e-01f, -3.37501355e-02f, 1.37752622e-01f, 8.67877603e-02f, 1.24533802e-01f, -1.65177479e-01f, 9.94594395e-02f, 4.60009836e-02f,
  -2.95172893e-02f, -1.71844065e-01f, 1.25910893e-01f, -7.90448766e-03f, 1.50972247e-01f, 1.69367716e-02f, 1.40259773e-01f, 1.81688353e-01f, -7.35563189e-02f, -5.20048626e-02f,
  1.23803034e-01f, 7.06426054e-02f, -5.40506057e-02f, -2.94224620e-02f, -1.23507775e-01f, 1.05998643e-01f, -4.29427661e-02f, -2.03002930e-01f, 1.48845762e-01f, -1.49564788e-01f,
  -5.03766052e-02f, -5.10305054e-02f, -8.29759538e-02f, 6.32108450e-02f, 7.30668977e-02f, 2.40211532e-01f, 1.51433991e-02f, 1.02233216e-01f, -6.30844161e-02f, -2.26003155e-02f,
  -2.06364214e-01f, 5.30751087e-02f, -2.54995027e-03f, -1.68062553e-01f, 2.61468422e-02f, 1.11445785e-01f, -3.67094763e-02f, -1.60445631e-01f, 9.24084261e-02f, -2.82575376e-02f,
  -8.59384015e-02f, 1.96071416e-01f, 5.61069585e-02f, -7.13396370e-02f, -1.24927707e-01f, 1.10526189e-01f, 5.06473705e-02f, 7.46863708e-02f, -4.57661273e-03f, 1.70843318e-01f,
  -6.55170530e-02f, -3.71863432e-02f, -1.69195667e-01f, -9.26924199e-02f, 1.26810342e-01f, -7.70505369e-02f, 8.78798962e-03f, -9.94299054e-02f, 6.13486320e-02f, 6.05271086e-02f,
  7.96009153e-02f, -4.16978002e-02f, 5.59292920e-02f, -6.99154437e-02f, 1.08356692e-01f, -1.10525064e-01f, -2.66020317e-02f, -5.60848378e-02f, 3.69011872e-02f, 1.01950273e-01f,
  -1.03866048e-02f, 7.37905875e-02f, -1.97966862e-02f, 6.28439486e-02f, 1.15756653e-01f, 1.41112730e-01f, 5.82459830e-02f, -1.50412217e-01f, 2.22629290e-02f, -1.77728057e-01f,
  1.62333235e-01f, 4.48238775e-02f, -1.38933703e-01f, 1.89999610e-01f, 1.40284553e-01f, 7.69812539e-02f, 5.49018383e-02f, 3.54062505e-02f, 1.09871648e-01f, -2.68972874e-01f,
  4.90709618e-02f, 5.54363616e-02f, 9.82199982e-02f, -4.93232198e-02f, 2.25023106e-01f, -1.51973709e-01f, 4.46204953e-02f, 1.25564471e-01f, 2.20551006e-02f, 4.27216962e-02f,
  9.04190242e-02f, 1.32216573e-01f, 1.68154418e-01f, 1.23190179e-01f, -1.45286217e-01f, -1.18418053e-01f, 1.01950154e-01f, 4.52369079e-02f, 1.16765834e-01f, 1.95136853e-02f,
  -8.28502327e-02f, -2.03924760e-01f, 1.98987514e-01f, 1.07588964e-02f, 4.49141189e-02f, 6.58781454e-02f, 1.35014169e-02f, -6.05875663e-02f, -2.06534356e-01f, -7.46776059e-04f,
  1.08848505e-01f, -1.77155007e-02f, -5.54960258e-02f, -1.65856868e-01f, -7.36002624e-02f, 5.79778850e-02f, -9.36460570e-02f, 1.23938158e-01f, 4.70458604e-02f, 1.80199012e-01f,
  5.02573065e-02f, 1.07153431e-01f, -4.27294448e-02f, -1.12705432e-01f, -1.06685355e-01f, 5.46751246e-02f, -5.60691878e-02f, 3.92851979e-02f, -4.70269509e-02f, 5.47899641e-02f,
  9.79182422e-02f, -1.47977918e-01f, -3.61796468e-04f, -4.00703102e-02f, 7.89390504e-02f, -2.67691929e-02f, 1.40373826e-01f, -3.52779143e-02f, -7.05161393e-02f, -9.44174454e-03f,
  3.39296125e-02f, -5.02722822e-02f, 7.59699149e-03f, 1.36319280e-01f, -1.01179965e-01f, -4.25552428e-02f, 4.26002182e-02f, 2.26257946e-02f, -9.16645397e-03f, 9.03301612e-02f,
  -3.11733000e-02f, -7.63774887e-02f, -1.12522263e-02f, -1.09450981e-01f, 9.56514627e-02f, 3.63133624e-02f, -7.66183734e-02f, -6.64940104e-02f, -1.25280460e-02f, 4.61255088e-02f,
  -6.66704699e-02f, 1.98357347e-02f, 7.91851953e-02f, 9.96550098e-02f, 4.55257762e-03f, -3.17696221e-02f, -3.47750224e-02f, 8.04353952e-02f, -1.21660046e-01f, 5.43483123e-02f,
  -1.19566731e-01f, 6.46142662e-02f, 5.78626692e-02f, -1.07062720e-01f, 3.67624909e-02f, -1.41436525e-03f, -6.45750016e-02f, -3.46235558e-02f, 1.05359629e-01f, -1.29975110e-01f,
  6.04012050e-02f, -5.57431653e-02f, -4.58374508e-02f, -7.83392787e-02f, -4.79125343e-02f, 6.96991161e-02f, -1.12132452e-01f, -3.61529477e-02f, 2.02775262e-02f, 5.72548993e-02f,
  1.03364617e-01f, 5.12259156e-02f, -7.60713294e-02f, 4.52514365e-02f, -4.64658700e-02f, -3.13929492e-03f, -4.28152233e-02f, -2.49368906e-01f, 1.36865396e-02f, 8.60814750e-02f,
  1.90078616e-02f, -1.24441348e-01f, -6.15290478e-02f, -4.12741378e-02f, 2.63060063e-01f, -2.09028319e-01f, -3.17429900e-02f, 4.29480672e-02f, 5.06485924e-02f, 1.93305567e-01f,
  2.18904465e-02f, -1.64202955e-02f, 1.40735582e-02f, -5.03404364e-02f, 1.12461345e-02f, 6.09304532e-02f, -2.14917529e-02f, 5.54777943e-02f, 1.11017555e-01f, -8.03360343e-02f,
  1.07397035e-01f, -4.89126444e-02f, 1.42627526e-02f, -2.10642368e-01f, 5.14631569e-02f, 1.03207808e-02f, -4.00822721e-02f, 5.13169207e-02f, -8.10917690e-02f, -1.48566708e-01f,
  2.80647874e-02f, -3.91614303e-05f, 7.84263611e-02f, -4.54852395e-02f, -1.51460007e-01f, 3.22943293e-02f, -1.25509173e-01f, 6.82033151e-02f, 1.26030847e-01f, -5.99254966e-02f,
  -4.63826507e-02f, 5.46146296e-02f, 1.16957210e-01f, -5.48058748e-02f, 1.54599637e-01f, -7.07751513e-02f, 1.32579446e-01f, -1.88422307e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  5.42348288e-02f, -1.30033139e-02f, 1.17815912e-01f, -3.96700464e-02f, 2.01437473e-02f, 1.01825155e-01f, -3.74625809e-02f, 7.65657946e-02f, 1.91755578e-01f, 9.83884931e-02f,
  1.40680090e-01f, -8.04534629e-02f, 8.66093766e-03f, 1.30086794e-01f, 9.46929380e-02f, -4.22672331e-02f, 1.03220940e-01f, -9.40405801e-02f, -6.79410994e-02f, -1.52692541e-01f,
  8.99232253e-02f, 1.43988086e-02f, 1.01323454e-02f, -1.54825887e-02f, -1.10520966e-01f, 1.51296079e-01f, -2.43211016e-02f, 2.07559377e-01f, 8.86848271e-02f, -9.16416720e-02f,
  5.07657193e-02f, 1.31787639e-02f, -1.40835106e-01f, -9.09734368e-02f, 2.68770725e-01f, 1.08876817e-01f, 2.42561363e-02f, 1.24324746e-01f, 1.13632545e-01f, -1.50401443e-01f,
  -9.48375911e-02f, -7.56022930e-02f, 1.47149907e-02f, -3.34374569e-02f, 9.70021822e-03f, 2.28553832e-01f, 1.84118360e-01f, 1.23281717e-01f, -3.00644506e-02f, 1.25301912e-01f,
  1.14678435e-01f, -1.21332951e-01f, -1.67912364e-01f, -2.66733970e-02f, -6.70228079e-02f, -4.81780916e-02f, 3.23103257e-02f, 3.93576100e-02f, 1.56018838e-01f, -9.29963887e-02f,
  1.37575436e-02f, -6.55508563e-02f, 8.12784135e-02f, 1.24822177e-01f, 2.18884796e-01f, 2.00812936e-01f, 2.14622289e-01f, 7.51232579e-02f, 1.44256979e-01f, -7.90959373e-02f,
  1.43873185e-01f, 2.56929964e-01f, 9.11711827e-02f, 3.04345459e-01f, 1.56436935e-01f, 2.35926472e-02f, 1.50159687e-01f, -1.87364578e-01f, 1.75606087e-02f, 3.02504897e-01f,
  -2.12801825e-02f, 2.29416505e-01f, 2.78408945e-01f, 9.44690928e-02f, 1.27724810e-02f, -1.02685466e-02f, -8.90277624e-02f, -4.46677387e-01f, 3.14529538e-01f, -2.54644841e-01f,
  1.48767710e-01f, 3.79452020e-01f, 4.58735675e-01f, -6.56022057e-02f, 8.32522586e-02f, 4.29546326e-01f, -5.75160943e-02f, -6.05229437e-02f, 3.32918614e-02f, 3.21249276e-01f,
  1.88428462e-01f, 3.02211940e-03f, -8.21618885e-02f, -8.38432088e-02f, 6.32987591e-03f, -1.16287313e-01f, 1.40228018e-01f, 1.39449880e-01f, -1.17017301e-02f, -1.32695541e-01f,
  3.75824928e-01f, -1.54140204e-01f, 3.81293409e-02f, -6.37498498e-03f, 1.68668687e-01f, 2.83283472e-01f, -1.42456338e-01f, -3.48812379e-02f, -1.43540323e-01f, 1.11059412e-01f,
  -1.77441627e-01f, -4.85047996e-02f, -2.18804944e-02f, 8.56252834e-02f, -3.51887420e-02f, 1.25443101e-01f, 8.52865130e-02f, 4.16361958e-01f, -5.91775496e-03f, 1.16062343e-01f,
  -3.53365727e-02f, -7.21606389e-02f, 5.78792915e-02f, 6.67458251e-02f, 6.60773218e-02f, -6.31400719e-02f, -5.22983260e-02f, 3.65971215e-02f, -2.67998297e-02f, 1.18615381e-01f,
  1.40761241e-01f, 4.46022525e-02f, 9.42936987e-02f, 1.71637744e-01f, 8.24024752e-02f, 4.40181047e-02f, 1.10379115e-01f, 2.44980268e-02f, 9.47811455e-02f, -1.33045800e-02f,
  6.09642267e-02f, -1.45889744e-01f, 1.13726206e-01f, -4.27085645e-02f, 3.77685833e-03f, 1.23305211e-03f, 1.27937928e-01f, 4.54503782e-02f, -7.09125176e-02f, 2.29099005e-01f,
  9.25676450e-02f, -1.05159916e-01f, -7.20412582e-02f, 1.09530196e-01f, 7.83926919e-02f, 8.34937468e-02f, -1.19921342e-01f, -1.35118231e-01f, 1.13150567e-01f, -9.73480195e-02f,
  3.88586000e-02f, -1.36182746e-02f, -7.35749453e-02f, 2.54027988e-03f, 3.67037766e-02f, -7.77620375e-02f, 2.40092017e-02f, -5.04355915e-02f, 4.53814631e-03f, 2.65402179e-02f,
  -1.42519223e-02f, -2.89769862e-02f, -1.00022636e-01f, -3.56868804e-02f, -1.25783578e-01f, 1.31245345e-01f, 9.67146382e-02f, -7.09805638e-02f, -7.78654218e-02f, 6.57722494e-03f,
  -3.67046073e-02f, 1.13339782e-01f, -7.56656844e-03f, 7.37723634e-02f, 4.44821082e-02f, 1.30166635e-01f, 2.21157044e-01f, 2.18821779e-01f, 1.33949801e-01f, 1.92885131e-01f,
  -2.02822797e-02f, -2.14499719e-02f, 7.28221536e-02f, 2.17762932e-01f, -1.55239210e-01f, 5.20080626e-02f, -8.34038258e-02f, -1.21764332e-01f, 2.85060734e-01f, -1.95736662e-01f,
  5.42652756e-02f, 5.15981428e-02f, -3.09878141e-01f, 2.66094327e-01f, 3.72107215e-02f, 1.62657917e-01f, -6.21800311e-02f, -1.69264168e-01f, -3.22324894e-02f, 1.07897155e-01f,
  5.41876890e-02f, 9.78064314e-02f, -9.69469324e-02f, 1.26731530e-01f, 1.56018287e-02f, -6.04919493e-02f, -7.94248134e-02f, 1.18679173e-01f, -4.61212881e-02f, 7.06201196e-02f,
  -1.01177670e-01f, 2.80244976e-01f, 1.17711518e-02f, 2.67884298e-03f, -1.08472809e-01f, -1.10810407e-01f, 2.14648303e-02f, 3.60434264e-01f, 9.66709629e-02f, 7.51365796e-02f,
  2.91760685e-03f, -1.66364044e-01f, 1.36412308e-01f, -1.51418567e-01f, 1.72690779e-01f, -5.15379235e-02f, -1.39610842e-01f, -2.09230725e-02f, 1.49761006e-01f, 2.46431828e-01f,
  1.04465261e-01f, 3.02444458e-01f, 2.65166610e-02f, -5.51194288e-02f, -1.04855157e-01f, 2.17100810e-02f, 2.94526145e-02f, 1.05691805e-01f, 1.38193265e-01f, 2.37822328e-02f,
  -1.38436593e-02f, -8.82738456e-02f, -5.36161736e-02f, 3.52564156e-02f, 6.59815893e-02f, 1.30620226e-01f, -2.35499460e-02f, -8.92062187e-02f, 1.53802678e-01f, -5.46187162e-02f,
  -1.35167778e-01f, 4.09151763e-02f, -7.99094606e-03f, -1.28387166e-02f, -8.02362189e-02f, -2.15693074e-03f, 3.42885740e-02f, -9.61389020e-02f, 8.43602642e-02f, 1.85837924e-01f,
  9.10768136e-02f, 1.69116601e-01f, 6.25917539e-02f, 1.80316821e-01f, -1.93434674e-02f, -5.93455173e-02f, -1.32082934e-02f, -3.94094177e-02f, -7.51253292e-02f, -7.27992728e-02f,
  6.26560301e-02f, -9.86021198e-03f, 1.16660766e-01f, 6.52944371e-02f, -8.44883323e-02f, -1.30761400e-01f, 8.11241344e-02f, 9.42347646e-02f, 5.62693402e-02f, -2.71987673e-02f,
  -7.16293231e-02f, 1.01618394e-02f, 1.21072419e-01f, 8.19108039e-02f, 6.71134964e-02f, 1.02190010e-01f, 6.25678003e-02f, 6.41912520e-02f, -1.33043360e-02f, -2.45255101e-02f,
  7.48912990e-02f, -4.15948816e-02f, -7.42465481e-02f, 1.49993360e-01f, 5.46028987e-02f, -1.02370651e-02f, 1.00494608e-01f, 5.91134317e-02f, -1.08264707e-01f, 3.44020389e-02f,
  1.70243442e-01f, 1.81123629e-01f, 3.32117267e-02f, 1.92453340e-01f, -1.68444950e-03f, 1.51972175e-01f, 1.64964780e-01f, 1.59111798e-01f, -1.63573809e-02f, -4.00850922e-03f,
  1.64549738e-01f, 3.16160433e-02f, -6.49594590e-02f, 1.14776718e-03f, -1.27678104e-02f, -1.45928964e-01f, 8.14135447e-02f, -1.37033030e-01f, -1.30502895e-01f, -1.50990441e-01f,
  1.64963696e-02f, 1.33207411e-01f, 1.34559706e-01f, 1.31092817e-01f, -6.63993657e-02f, 1.38786122e-01f, -1.36899903e-01f, 6.38628229e-02f, 1.08845159e-02f, -1.82230473e-02f,
  2.88910381e-02f, 6.71797013e-03f, 1.09905124e-01f, -1.30297154e-01f, -7.62802688e-03f, 6.35829493e-02f, -6.46352842e-02f, -9.44990963e-02f, -7.44056031e-02f, -8.95602107e-02f,
  -1.15464874e-01f, -1.20719612e-01f, 9.89358798e-02f, 3.18157300e-02f, 2.14085393e-02f, 5.38437776e-02f, -6.55487776e-02f, 8.10288042e-02f, -4.70859483e-02f, 6.57605603e-02f,
  -1.09485723e-01f, 8.24777260e-02f, 2.56923549e-02f, 3.43696885e-02f, -1.65866278e-02f, 7.14649782e-02f, 1.72818094e-01f, 1.48062870e-01f, -8.56681466e-02f, -4.78548892e-02f,
  -6.09137118e-02f, -1.33541942e-01f, -1.21584363e-01f, 8.89423490e-02f, -8.00486282e-02f, 5.26896343e-02f, 4.05116566e-02f, 1.49373144e-01f, 1.71738282e-01f, 8.84958729e-02f,
  -1.25573827e-02f, -4.30996122e-04f, 1.16387196e-01f, 7.65117928e-02f, 1.74065605e-01f, 4.69620042e-02f, 5.47669036e-03f, 2.53200438e-02f, -6.87710196e-02f, -1.49183780e-01f,
  -2.10442618e-01f, 2.03946739e-01f, -2.99708173e-02f, 2.02655002e-01f, -1.52280286e-01f, -2.80889329e-02f, -9.13863331e-02f, -1.92302123e-01f, 4.35464568e-02f, 1.02971688e-01f,
  -9.64531824e-02f, -8.21379349e-02f, 1.46593988e-01f, -7.34377652e-02f, -6.42962679e-02f, -1.21212602e-01f, -1.18519545e-01f, 1.98632712e-03f, 1.00966685e-01f, -2.24731304e-02f,
  -2.55207587e-02f, 1.76261067e-02f, 1.46279708e-01f, 2.18963802e-01f, 1.62491888e-01f, 3.86708863e-02f, -9.77361724e-02f, 6.69712499e-02f, 5.44489548e-03f, 1.08752191e-01f,
  7.78819397e-02f, 1.26320705e-01f, 4.06759866e-02f, 3.21877562e-02f, -5.45394309e-02f, 1.11238845e-01f, 1.89664736e-02f, -1.01921566e-01f, 4.19276468e-02f, -6.64953813e-02f,
  1.81701649e-02f, 5.49330711e-02f, -1.18809879e-01f, 1.71720952e-01f, -1.55918226e-01f, 1.18337810e-01f, 9.51420367e-02f, 2.76847463e-02f, 7.00748386e-03f, 6.82739913e-02f,
  -8.94277990e-02f, -9.91736874e-02f, 9.94042531e-02f, -8.11371356e-02f, 3.96714285e-02f, -9.93989855e-02f, 4.68186997e-02f, -6.94945753e-02f, -5.99543788e-02f, -1.25283062e-01f,
  1.09316252e-01f, -9.69379768e-02f, 6.06008768e-02f, -1.26199991e-01f, 7.13043064e-02f, -1.03745528e-01f, 5.83896413e-02f, 7.36979246e-02f, 8.26383606e-02f, 9.16348696e-02f,
  -4.02123965e-02f, -1.03953332e-01f, -3.14435624e-02f, -8.85450020e-02f, 9.18157324e-02f, -9.35103893e-02f, -4.59848307e-02f, -3.97780761e-02f, 1.66292656e-02f, -4.48877141e-02f,
  4.73873988e-02f, -3.42552252e-02f, 9.98161733e-02f, 7.48212710e-02f, 1.14352532e-01f, -4.37250733e-02f, -6.86959997e-02f, -7.14261308e-02f, 4.95191216e-02f, -1.00747995e-01f,
  1.09066255e-01f, -1.88434273e-02f, 5.15047600e-03f, -6.31664135e-03f, 8.83244425e-02f, -1.12445250e-01f, -1.10895537e-01f, -3.03211417e-02f, -2.54094154e-02f, -7.67628402e-02f,
  -5.45214266e-02f, 3.07163727e-02f, 7.48965889e-03f, 1.10619806e-01f, 7.12545291e-02f, -9.99499261e-02f, -1.16584085e-01f, -4.50445339e-04f, 8.24209377e-02f, 5.15391640e-02f,
  1.21052852e-02f, 3.68793420e-02f, 1.21209599e-01f, 6.80934414e-02f, 7.64283612e-02f, -4.61316667e-03f, -2.45898706e-03f, 1.30129486e-01f, 1.93597704e-01f, 7.10518211e-02f,
  8.62626955e-02f, -4.33882102e-02f, 1.33150607e-01f, 2.96846796e-02f, 1.26143679e-01f, -1.71352495e-02f, -2.40154304e-02f, 1.42051473e-01f, 1.67130679e-02f, -1.48118734e-01f,
  9.82335117e-03f, -1.88346639e-01f, -4.25739586e-02f, -1.70761067e-02f, -6.54642954e-02f, 1.34832337e-01f, 8.51548314e-02f, 8.09977204e-02f, 8.06210041e-02f, 2.68385530e-01f,
  5.93362413e-02f, 1.36412635e-01f, 7.70885050e-02f, 2.94862270e-01f, -8.20613801e-02f, -1.29392996e-01f, 1.65353075e-01f, 1.08048886e-01f, -6.92548230e-02f, -1.09009510e-02f,
  -8.24698880e-02f, -2.20061496e-01f, -1.23625301e-01f, -8.90276954e-02f, 1.06667317e-01f, -1.41510233e-01f, -9.80800241e-02f, 2.05573097e-01f, -1.48708718e-02f, -1.26628056e-01f,
  1.47231936e-01f, -1.10134915e-01f, -5.51889427e-02f, 3.38062793e-02f, -3.61090787e-02f, -6.14829995e-02f, 4.89079431e-02f, -1.10335305e-01f, -1.06990688e-01f, 1.01442814e-01f,
  1.90987915e-03f, -7.12565407e-02f, -8.20885692e-03f, -1.13740839e-01f, 1.00956433e-01f, 3.50864604e-02f, -4.44830284e-02f, -6.58877566e-02f, 1.15539998e-01f, 3.89896147e-02f,
  1.57016248e-01f, 1.56759664e-01f, 1.08811378e-01f, 7.97111169e-02f, -6.06976077e-02f, 2.17605606e-02f, -1.86733063e-02f, 1.57391727e-02f, -8.52425769e-02f, 6.46589622e-02f,
  -5.53603955e-02f, 1.58872772e-02f, 1.16863102e-01f, -7.85524771e-02f, 9.78190079e-03f, 7.76339471e-02f, -6.80961534e-02f, 6.22974485e-02f, 5.56542389e-02f, 1.13273270e-01f,
  -9.72612873e-02f, -1.06516117e-02f, 5.89619465e-02f, -1.10456795e-01f, -1.01030476e-01f, 5.07935733e-02f, -1.20068729e-01f, -7.24477395e-02f, 9.05391586e-04f, 1.19167812e-01f,
  -7.00549409e-02f, 3.72582972e-02f, 7.32740238e-02f, -3.52361016e-02f, -1.04714438e-01f, 1.40727654e-01f, -1.03403971e-01f, 9.24979225e-02f, 5.16160913e-02f, 6.22939095e-02f,
  5.22264875e-02f, 1.33754060e-01f, 4.74084988e-02f, 4.49537076e-02f, 8.47271532e-02f, -8.12345296e-02f, 3.48989456e-03f, -2.28109360e-02f, 1.67079806e-01f, -3.86711434e-02f,
  -4.98684235e-02f, -9.08285230e-02f, -5.36650158e-02f, -9.35012028e-02f, -5.16318008e-02f, 5.49570806e-02f, -1.97602790e-02f, -2.91503351e-02f, -7.95996934e-02f, 4.59434390e-02f,
  1.16429202e-01f, -7.65967295e-02f, 7.75469169e-02f, 2.91760955e-02f, 1.07215703e-01f, 1.13525689e-01f, 5.94316684e-02f, 1.28057808e-01f, -2.91877110e-02f, 4.61698398e-02f,
  -5.54250628e-02f, -5.17386608e-02f, -1.00533321e-01f, 1.29603986e-02f, 7.12288823e-03f, 1.06871106e-01f, -3.24325003e-02f, -4.15631495e-02f, -1.44913271e-01f, -1.71739683e-01f,
  3.31783555e-02f, 1.38744652e-01f, -3.56188901e-02f, -7.84511790e-02f, -7.58832917e-02f, 9.70297679e-02f, -1.07462727e-01f, 1.29603252e-01f, 1.04162857e-01f, 3.26969996e-02f,
  1.25886410e-01f, 7.84907490e-02f, -8.31948668e-02f, -9.90175232e-02f, 2.32591480e-02f, 2.12108180e-01f, -4.67963479e-02f, 1.25346884e-01f, -9.40242708e-02f, -1.53481647e-01f,
  -1.38670549e-01f, 6.16998374e-02f, 6.73495457e-02f, -5.71873523e-02f, -5.78262247e-02f, 2.35440042e-02f, 6.72838092e-02f, -6.63888976e-02f, -3.35729588e-03f, 2.52306573e-02f,
  3.29333320e-02f, -5.22199050e-02f, 2.81034913e-02f, -8.32161028e-03f, -3.09796096e-03f, -2.65997108e-02f, -1.36028424e-01f, 8.94584656e-02f, 3.88315767e-02f, 1.10095456e-01f,
  1.75860729e-02f, 2.81390417e-02f, 3.22524905e-02f, 1.95374846e-01f, 6.79912046e-02f, 3.61566469e-02f, 1.81352273e-01f, 1.93423182e-01f, 7.70902038e-02f, 5.15930168e-02f,
  -4.95311059e-02f, -8.70334432e-02f, 1.10367900e-02f, 1.84711620e-01f, 1.26821354e-01f, 3.51773463e-02f, 8.98716226e-02f, -2.02432126e-02f, -2.23857224e-01f, 1.12892024e-01f,
  -1.19617499e-01f, 2.08268583e-01f, 1.96130365e-01f, 2.16834888e-01f, 4.31132782e-03f, -1.16562182e-02f, 4.70695086e-02f, -1.24536995e-02f, 1.88370362e-01f, 1.00669034e-01f,
  9.88035742e-03f, -3.04798223e-02f, -3.34671959e-02f, -1.21002972e-01f, -6.73996508e-02f, 1.67038515e-01f, -9.19084325e-02f, 1.33069813e-01f, -1.89007834e-01f, -1.26333952e-01f,
  4.50947210e-02f, -1.01132363e-01f, 2.23611407e-02f, 8.99876952e-02f, 1.68016896e-01f, -1.21971716e-04f, 5.16511174e-03f, 5.32390513e-02f, -7.46202916e-02f, -7.86828697e-02f,
  4.89994138e-02f, -9.60793570e-02f, -6.78062588e-02f, -1.08208880e-01f, 3.46601494e-02f, 1.04616113e-01f, 1.67142257e-01f, 1.01487273e-02f, 8.87317285e-02f, 3.92817855e-02f,
  -3.81783210e-02f, -6.47279015e-03f, 2.09490526e-02f, -1.10409789e-01f, -2.61490215e-02f, -8.46555158e-02f, -9.27510858e-02f, -6.71973750e-02f, 1.38969813e-02f, 9.17889550e-02f,
  1.24530278e-01f, 5.13926372e-02f, 1.16489008e-01f, 1.84144527e-01f, 2.13842243e-01f, 2.15132445e-01f, 1.74940437e-01f, -3.59812379e-02f, 7.49777257e-02f, -4.90493067e-02f,
  -2.20470458e-01f, -1.55479521e-01f, -6.77208006e-02f, 1.87769271e-02f, 1.53661534e-01f, -5.18743917e-02f, 4.54198793e-02f, -1.56789482e-01f, 7.74434209e-02f, -3.33502032e-02f,
  8.03245008e-02f, 1.32285461e-01f, -1.27286062e-01f, 1.14934459e-01f, -1.22170404e-01f, 9.67692658e-02f, 7.34825730e-02f, -2.92118546e-02f, 3.87480557e-02f, -1.08137742e-01f,
  -7.89737105e-02f, 6.24689870e-02f, 2.05518007e-01f, -9.76100843e-03f, 5.48049202e-03f, 4.65295762e-02f, -7.48968273e-02f, -1.08692959e-01f, -5.44541180e-02f, -1.20982580e-01f,
  8.93216729e-02f, -6.64919317e-02f, 4.50008027e-02f, -5.82500510e-02f, 6.18523285e-02f, 1.12890288e-01f, 3.12145222e-02f, 1.15664646e-01f, 5.89861162e-02f, -1.40800968e-01f,
  1.01080351e-02f, 6.60568327e-02f, 7.22875744e-02f, 6.87332675e-02f, 2.30752788e-02f, 1.82079226e-01f, 1.21562809e-01f, 7.88607076e-02f, 1.93153456e-01f, 3.65991220e-02f,
  1.29615694e-01f, -9.76280347e-02f, 7.85175618e-03f, -7.28498176e-02f, 8.51459131e-02f, -1.44030889e-02f, 1.19972654e-01f, -1.52963707e-02f, -1.44141944e-04f, 9.15239751e-02f,
  3.99559364e-02f, -5.62881045e-02f, 2.64160316e-02f, 1.44564196e-01f, 7.15009943e-02f, 1.61474586e-01f, 2.12524328e-02f, -7.18084127e-02f, -6.14897311e-02f, 5.98415621e-02f,
  8.17043055e-03f, 1.39385179e-01f, -6.20200038e-02f, -2.85897646e-02f, -1.35436594e-01f, -7.62008578e-02f, 1.55190498e-01f, -9.78888497e-02f, -1.03422906e-02f, 1.99949387e-02f,
  8.85194447e-03f, -6.92930743e-02f, 4.37107049e-02f, 1.77486286e-01f, 4.42496426e-02f, 3.62355188e-02f, -1.79045815e-02f, 6.11335412e-02f, -1.07066822e-03f, -2.73539387e-02f,
  4.47949693e-02f, -7.64193535e-02f, -4.13109586e-02f, -1.17134079e-01f, -5.84260598e-02f, 1.30800888e-01f, 9.93772000e-02f, 2.33314380e-01f, 6.76748157e-03f, -8.82242247e-02f,
  6.94154277e-02f, -7.79807866e-02f, 1.23160042e-01f, 1.43182650e-01f, 1.17237650e-01f, -1.26581877e-01f, 1.01293132e-01f, 5.99703155e-02f, 4.97321934e-02f, -3.69605012e-02f,
  7.67428055e-02f, -4.14877720e-02f, -1.15379155e-01f, 6.09919205e-02f, 9.80282053e-02f, -2.31994968e-02f, -1.10355273e-01f, -9.28279310e-02f, -2.95672137e-02f, 5.20785265e-02f,
  -1.00988857e-01f, -7.98247382e-02f, -7.40752146e-02f, 1.03509672e-01f, 8.91318247e-02f, 7.56485015e-02f, -5.90375587e-02f, 2.24141683e-02f, -9.47955623e-02f, 9.87743363e-02f,
  -1.17618732e-01f, -8.62521902e-02f, 1.01235449e-01f, -3.70302461e-02f, -1.22155510e-01f, -7.08563775e-02f, -8.98513049e-02f, -3.56602482e-02f, -1.26634061e-01f, -8.98330137e-02f,
  1.79596208e-02f, -5.74517436e-02f, -8.68764073e-02f, 1.05989121e-01f, -6.65491156e-04f, -5.74423335e-02f, -7.60571882e-02f, -2.93238531e-03f, 2.23884732e-02f, -9.43865702e-02f,
  -9.41180810e-02f, -4.50350419e-02f, 6.21714406e-02f, 6.89341649e-02f, -8.62883031e-02f, 1.18717588e-01f, -6.24922775e-02f, -1.04880044e-02f, -9.35628936e-02f, -9.47784483e-02f,
  -1.53851397e-02f, 3.45992409e-02f, 2.39597429e-02f, 3.16583104e-02f, 9.33902040e-02f, 6.18721992e-02f, -7.43779645e-04f, -4.91264015e-02f, 1.34978876e-01f, 8.22579712e-02f,
  -7.86935911e-02f, 8.22011102e-03f, -8.19692910e-02f, -1.03092678e-01f, -1.08525135e-01f, -6.82733813e-03f, 9.71489847e-02f, -4.92579192e-02f, -6.47675619e-02f, 1.11860320e-01f,
  -1.11928560e-01f, 4.75955749e-04f, 1.78324878e-02f, -6.49042055e-02f, -1.09693855e-01f, -1.08240649e-01f, 4.84256707e-02f, 7.52292424e-02f, -8.66918489e-02f, 2.54752878e-02f,
  -2.20630486e-02f, -7.12037608e-02f, 6.02212474e-02f, -2.90395971e-02f, -5.50514758e-02f, 1.01379096e-03f, -5.10789417e-02f, -1.12628289e-01f, 5.85052297e-02f, -1.19716741e-01f,
  -4.15069871e-02f, 2.28506159e-02f, -7.19464105e-03f, -4.43239957e-02f, -1.27447039e-01f, -8.70564431e-02f, 3.76064032e-02f, 2.15522237e-02f, -6.68638349e-02f, 8.56818706e-02f,
  -7.70605877e-02f, 1.10057317e-01f, 4.36972044e-02f, 1.15071319e-01f, -3.38826664e-02f, 6.41111657e-02f, 6.16739728e-02f, 9.42006856e-02f, 9.43856761e-02f, -2.82931402e-02f,
  -6.45725727e-02f, -1.15819685e-01f, -9.15544406e-02f, 1.10328970e-02f, -2.37417333e-02f, -6.09176196e-02f, 8.07458609e-02f, 2.14685090e-02f, 1.72002930e-02f, 3.73459533e-02f,
  -1.05906077e-01f, -7.35170022e-03f, -3.36970575e-02f, 2.33165752e-02f, 3.08257807e-02f, 6.61538243e-02f, -4.33570333e-02f, -7.47231394e-02f, -2.38750745e-02f, 8.83356258e-02f,
  4.76024598e-02f, -2.81715486e-02f, -1.15337931e-01f, 8.81086513e-02f, 1.17683508e-01f, 2.01845571e-01f, 8.63590613e-02f, 3.91842797e-02f, 1.28000274e-01f, -1.82108618e-02f,
  1.59635618e-01f, 9.20490269e-03f, 1.79050922e-01f, 1.34138942e-01f, -3.65258977e-02f, 1.56100437e-01f, 9.44680274e-02f, -6.20139651e-02f, -5.74442782e-02f, -1.81293219e-01f,
  -1.78486735e-01f, 1.62878811e-01f, 1.65739521e-01f, 2.15986803e-01f, 1.07161880e-01f, 4.05886471e-02f, 2.90286783e-02f, -1.95310369e-01f, 1.69093743e-01f, 1.45251870e-01f,
  2.10301876e-02f, 5.95062077e-02f, -1.29568810e-02f, -3.13050896e-02f, 6.46944866e-02f, -1.00370884e-01f, -1.31099597e-01f, 1.88280329e-01f, -1.54675897e-02f, -4.73772250e-02f,
  1.61735281e-01f, 4.55140546e-02f, 1.85913648e-02f, 5.97649440e-02f, -4.57544625e-02f, 8.88754148e-03f, 5.51082334e-03f, -4.50833216e-02f, 6.89370930e-02f, 9.17238928e-03f,
  4.89240959e-02f, -3.99775319e-02f, -6.08476959e-02f, -1.73139274e-02f, -3.62355858e-02f, 2.27877080e-01f, 8.51881579e-02f, -5.46682067e-02f, 8.45423639e-02f, -4.09664353e-03f,
  -1.20704725e-01f, -1.29851729e-01f, 8.94577503e-02f, 5.13545498e-02f, 9.36977193e-02f, -6.52584657e-02f, 6.56385869e-02f, -3.82970795e-02f, -6.20874129e-02f, 9.85335186e-03f,
  -2.42852103e-02f, -9.80468467e-02f, 6.90427274e-02f, -4.64405515e-04f, 1.89417433e-02f, 8.71072561e-02f, 1.28254756e-01f, 1.31002963e-01f, -9.18561369e-02f, -9.02037397e-02f,
  3.60143855e-02f, 9.08175260e-02f, 3.29524316e-02f, -1.38444319e-01f, -1.24406658e-01f, -8.79702643e-02f, 5.20087034e-02f, 1.08433500e-01f, -3.65662649e-02f, -8.21880922e-02f,
  -6.93126619e-02f, -5.75415343e-02f, 6.46310076e-02f, -2.74523571e-02f, -6.82798633e-03f, -5.13778590e-02f, -1.27287302e-02f, -1.03664093e-01f, 4.64316942e-02f, 7.52840340e-02f,
  1.09005449e-02f, 1.33590072e-01f, -1.07763857e-01f, 1.90194994e-02f, -9.02986154e-02f, -9.99475121e-02f, -7.75003731e-02f, 1.59037143e-01f, -4.09074202e-02f, -3.77856568e-02f,
  8.91029984e-02f, -1.22508541e-01f, -9.21481401e-02f, -1.54901370e-02f, 1.02375969e-01f, 2.31810715e-02f, -1.03225566e-01f, -5.88302054e-02f, -8.87446329e-02f, 1.30474463e-01f,
  8.43203664e-02f, -4.55822311e-02f, -3.31292748e-02f, -8.31871293e-04f, -1.00835562e-01f, 4.47006151e-03f, -4.88320105e-02f, -6.96035773e-02f, -1.67980678e-02f, 2.13420447e-02f,
  1.15190670e-01f, 2.03849133e-02f, -9.39501449e-03f, 1.25418544e-01f, 4.37232666e-03f, 1.24693081e-01f, 2.83028241e-02f, -5.01739159e-02f, 1.25115857e-01f, 1.22511880e-02f,
  -7.17319399e-02f, 1.37672573e-01f, 1.45397440e-01f, 1.13968916e-01f, -2.04701759e-02f, -9.34825093e-02f, 7.46359117e-03f, 1.58087596e-01f, -1.98870867e-01f, -8.85992497e-03f,
  2.31002927e-01f, 1.70196578e-01f, -2.80631203e-02f, -1.91775262e-02f, 2.72368733e-03f, -7.59501457e-02f, 3.81867215e-02f, -6.25272244e-02f, 1.48816168e-01f, 2.00065941e-01f,
  1.78728625e-01f, -2.65686288e-02f, 9.74761397e-02f, 1.94981828e-01f, -1.17382832e-01f, -8.01593512e-02f, -1.56095445e-01f, -7.20865726e-02f, -9.34860390e-03f, 9.24775228e-02f,
  -1.43152043e-01f, -6.91411039e-03f, -5.19907773e-02f, -8.82339925e-02f, 5.90909943e-02f, -1.95280798e-02f, -3.25998738e-02f, -8.28132182e-02f, 2.50500869e-02f, -1.18458018e-01f,
  -6.18868768e-02f, -1.78901814e-02f, 3.92261259e-02f, 1.55438170e-01f, -2.43801121e-02f, 5.35497107e-02f, -9.62962732e-02f, 1.01934552e-01f, -5.96129633e-02f, -5.95082454e-02f,
  9.14383400e-03f, -3.76585722e-02f, -3.86868864e-02f, 5.03564328e-02f, -5.09183593e-02f, 3.33136693e-03f, -3.35996747e-02f, -1.16578378e-01f, 8.22567195e-02f, 6.03631176e-02f,
  1.63824782e-02f, 1.17791571e-01f, 9.07034650e-02f, 6.90009957e-03f, -7.74976909e-02f, -3.04498407e-03f, -1.14211768e-01f, 1.59864419e-03f, -9.29490626e-02f, 6.03078641e-02f,
  -3.17409523e-02f, 8.87046009e-02f, -4.88747284e-02f, -7.37236515e-02f, -1.16575561e-01f, 1.86442845e-02f, -1.01871863e-01f, -2.06406489e-02f, -6.42772391e-02f, -1.08074874e-01f,
  3.23474109e-02f, -3.05980779e-02f, 5.84172904e-02f, -2.57475637e-02f, -1.49635589e-02f, 4.34148349e-02f, 7.24876449e-02f, -7.49254376e-02f, 2.75810957e-02f, -6.81023747e-02f,
  1.01894520e-01f, 1.09447382e-01f, -5.21261394e-02f, 4.01352197e-02f, 1.06268123e-01f, -3.49192284e-02f, -1.45925405e-02f, 9.59261507e-02f, -9.66380909e-02f, -6.02749810e-02f,
  -4.89828363e-03f, -3.59081142e-02f, -7.91825280e-02f, -1.20824136e-01f, 4.45791036e-02f, -9.92758945e-02f, -4.36031865e-03f, -1.00197129e-01f, -6.08666204e-02f, -9.92963687e-02f,
  5.21424077e-02f, -1.06547289e-01f, -1.11659944e-01f, 2.49348544e-02f, 7.57239163e-02f, -2.09075436e-02f, 6.62743151e-02f, -8.91107246e-02f, -6.50856784e-03f, -9.90820676e-03f,
  -5.54656349e-02f, -5.10926098e-02f, 8.46138522e-02f, 3.22643183e-02f, 6.84372932e-02f, 1.04093263e-02f, 1.31579623e-01f, -3.77918710e-03f, 1.35482803e-01f, -5.98542206e-02f,
  1.37490496e-01f, -9.17311087e-02f, -2.03564942e-01f, 5.54160252e-02f, 1.70441970e-01f, -6.21529445e-02f, -3.74219082e-02f, 5.00530899e-02f, -9.55978930e-02f, 1.75044406e-02f,
  -6.17600158e-02f, 1.09563237e-02f, 1.43694177e-01f, -1.36269107e-01f, -8.40432346e-02f, -2.13787928e-02f, -5.58341518e-02f, 1.89422712e-01f, 2.15697438e-01f, -1.64064482e-01f,
  1.41203761e-01f, 1.30798921e-01f, 2.76275072e-03f, 5.48994876e-02f, 1.24419038e-03f, 8.98688585e-02f, 9.94561315e-02f, 7.23244622e-02f, -1.06323257e-01f, -5.38166054e-02f,
  8.27139318e-02f, 1.94333214e-02f, -5.71096577e-02f, -9.74697098e-02f, 7.04200119e-02f, -5.66997938e-02f, 8.73548016e-02f, -4.54344898e-02f, 8.65461975e-02f, 1.93047579e-02f,
  -3.68176401e-02f, 3.62249538e-02f, -5.00735305e-02f, 6.57073110e-02f, 3.08261402e-02f, -7.94790015e-02f, -1.44978808e-02f, 9.54488963e-02f, -4.01308052e-02f, 1.01577997e-01f,
  -9.41819027e-02f, 5.40849268e-02f, 7.83586968e-03f, 1.02059647e-01f, -2.70053428e-02f, 1.00158952e-01f, 1.37103943e-03f, 9.74172950e-02f, 6.69735891e-04f, 1.33033052e-01f,
  -3.96137498e-02f, 6.43114885e-03f, -3.24706314e-03f, 1.32835731e-01f, -4.55804765e-02f, -1.05995566e-01f, 7.38294572e-02f, -7.80106708e-02f, 3.55646312e-02f, 6.30579814e-02f,
  7.45803192e-02f, 2.92410590e-02f, -5.77582978e-02f, -8.44520237e-03f, 1.37775496e-01f, 2.39204373e-02f, 8.26923773e-02f, 1.05281703e-01f, -9.40748230e-02f, -1.48830697e-01f,
  1.20741516e-01f, 1.38367891e-01f, 1.52683318e-01f, -5.32268733e-02f, -2.20250692e-02f, 1.36201903e-01f, -2.80756562e-04f, -2.50884108e-02f, 6.24691416e-03f, 1.47063524e-01f,
  7.64833316e-02f, -1.20586842e-01f, -1.06431218e-02f, -5.20089157e-02f, -1.12484954e-01f, -6.68453276e-02f, 1.45846546e-01f, 8.19270313e-02f, -2.88867764e-02f, 5.00751799e-03f,
  1.40833288e-01f, -3.18906307e-02f, 1.52956322e-01f, -1.19012147e-01f, -6.36014342e-02f, -1.16628081e-01f, -1.37551710e-01f, 2.87896246e-02f, 1.94147751e-02f, -1.10959738e-01f,
  9.73216146e-02f, -1.81384990e-03f, -1.05233220e-02f, 1.20057523e-01f, 9.16261822e-02f, -8.11226368e-02f, -4.99506742e-02f, 7.90657178e-02f, 1.08427979e-01f, 1.93214454e-02f,
  8.59798789e-02f, 3.56958359e-02f, 3.00720856e-02f, 1.10224694e-01f, 1.15777142e-01f, 1.20397627e-01f, 1.36587128e-01f, -6.70283064e-02f, -5.13272025e-02f, -1.52724519e-01f,
  -7.29439408e-02f, 2.01804144e-03f, 4.01301384e-02f, 1.84724033e-01f, 4.76560965e-02f, -1.93746053e-02f, -3.45129427e-03f, -6.21226132e-02f, 4.78398912e-02f, 2.88532488e-02f,
  7.41473809e-02f, -9.20629129e-02f, -7.08531886e-02f, 9.23274923e-03f, 1.91457085e-02f, 2.51462907e-01f, 1.96391374e-01f, 8.73510987e-02f, -6.34564366e-03f, 1.98784053e-01f,
  2.25150445e-03f, -5.76336868e-02f, 1.34217024e-01f, 1.59761265e-01f, -5.31071350e-02f, -1.13655888e-01f, 8.18819180e-02f, -2.11594358e-01f, -1.19906195e-01f, 1.09745286e-01f,
  5.69871254e-02f, -8.02291781e-02f, 6.58969507e-02f, 1.33567423e-01f, -9.84460395e-03f, -1.35654047e-01f, 1.51958466e-01f, 1.87123492e-02f, -3.58047113e-02f, -1.22034982e-01f,
  -1.33882061e-01f, -6.09044544e-03f, 6.15567453e-02f, 8.60385373e-02f, -2.52641514e-02f, -2.11535897e-02f, 9.20573846e-02f, 6.01851568e-02f, 1.73228793e-02f, 3.31283063e-02f,
  8.66543576e-02f, 2.81005591e-01f, 1.42619833e-01f, 1.96107887e-02f, 1.67908147e-01f, 1.94791406e-01f, 6.11611791e-02f, -5.81123382e-02f, 6.59432709e-02f, 1.44114181e-01f,
  1.13732040e-01f, 2.41445988e-01f, 1.78025380e-01f, 1.34800062e-01f, 7.38360882e-02f, -1.77646384e-01f, -5.90873025e-02f, 1.54012576e-01f, -5.02225012e-02f, 1.32749781e-01f,
  7.29603693e-02f, 1.12350754e-01f, 1.57219067e-01f, -1.54377997e-01f, 7.54403099e-02f, -6.98154047e-02f, 5.49020506e-02f, 5.23474663e-02f, 7.87117630e-02f, 1.48778185e-01f,
  1.10032214e-02f, -3.52564384e-03f, -7.85387903e-02f, 2.86049515e-01f, -1.20083764e-01f, -6.04771227e-02f, -1.50312558e-02f, -6.40736371e-02f, -6.93605989e-02f, -8.23584571e-02f,
  -1.56259537e-02f, -7.14841262e-02f, 1.62813202e-01f, -6.52150363e-02f, -8.21937993e-02f, 3.32523440e-03f, 1.59810036e-02f, -1.48549512e-01f, 1.05630420e-01f, -1.49425596e-01f,
  -8.04655254e-02f, -5.94766252e-02f, -4.15528715e-02f, 2.71260794e-02f, -1.01697989e-01f, 8.46784785e-02f, 1.01443298e-01f, -1.18785143e-01f, -9.17624235e-02f, 8.35742056e-02f,
  1.41903728e-01f, -1.05063260e-01f, 8.44227299e-02f, -4.11409959e-02f, -2.17337701e-02f, -6.05400130e-02f, 4.13075536e-02f, 2.20745504e-01f, 7.13949353e-02f, 1.65489167e-01f,
  5.75318784e-02f, 2.35289186e-01f, 9.92497429e-02f, 1.94910720e-01f, 1.22095466e-01f, 1.11869708e-01f, 1.43060401e-01f, 2.12927729e-01f, -9.19773728e-02f, 2.00978041e-01f,
  7.27761760e-02f, -2.36450285e-01f, 5.08469492e-02f, -1.40266031e-01f, -1.61911428e-01f, -9.34283137e-02f, -2.33615458e-01f, 1.02028146e-01f, -4.87377159e-02f, 2.33073562e-01f,
  5.72475558e-03f, 3.69813368e-02f, -6.95134178e-02f, -7.19066486e-02f, -3.75454361e-03f, 6.62978506e-03f, 2.06922945e-02f, -1.14855446e-01f, 1.38868719e-01f, 1.56453773e-02f,
  -4.04640548e-02f, 1.08256713e-01f, -3.56942415e-02f, -1.16968475e-01f, -3.56104434e-03f, 3.40442151e-01f, -9.71089676e-02f, -5.99520132e-02f, -1.86411347e-02f, -1.25097662e-01f,
  1.79440409e-01f, 1.96022511e-01f, 3.81454118e-02f, 2.32887238e-01f, -1.16187604e-02f, -1.03090294e-01f, 4.15483415e-02f, -1.39006555e-01f, 1.60948068e-01f, 9.95881017e-03f,
  -4.22822824e-03f, -7.41808712e-02f, -2.62584109e-02f, 1.16399303e-01f, 3.82391401e-02f, 3.12414199e-01f, -5.81903942e-02f, 5.37806675e-02f, 7.17523545e-02f, 7.85083473e-02f,
  1.50115892e-01f, 1.91511139e-01f, 1.46049401e-02f, 2.34541707e-02f, 1.91023365e-01f, 1.31532818e-01f, 2.71076337e-02f, 1.73700035e-01f, 1.88428402e-01f, 1.30677983e-01f,
  1.28655836e-01f, 6.45328639e-03f, -7.30051696e-02f, -5.40861264e-02f, -2.32788902e-02f, -1.79717883e-01f, 1.12970874e-01f, -1.18575236e-02f, 9.98360887e-02f, 1.31231681e-01f,
  5.37396595e-02f, 1.93402190e-02f, -5.01096435e-02f, 1.09098740e-01f, -5.37071116e-02f, 7.98627660e-02f, -6.76423013e-02f, 9.79910605e-03f, 8.09343606e-02f, -9.52659920e-02f,
  -1.09341424e-02f, -5.10622971e-02f, -7.53746480e-02f, -5.40121645e-02f, -9.69074853e-03f, -6.95616752e-02f, -4.68411529e-03f, 6.50828481e-02f, -5.15220463e-02f, 1.09274626e-01f,
  9.61877629e-02f, -2.53354087e-02f, -1.17606767e-01f, -1.43755442e-02f, 4.23189513e-02f, 7.23828971e-02f, 1.48431987e-01f, -5.89072704e-02f, -9.72614251e-03f, 6.39479160e-02f,
  -6.81464225e-02f, 1.54033586e-01f, -1.34389466e-02f, 1.04970127e-01f, -8.99924636e-02f, -1.16594486e-01f, 5.35608605e-02f, 5.74733652e-02f, 1.08565539e-01f, 8.89391676e-02f,
  1.21260293e-01f, 4.33090655e-03f, -8.01542252e-02f, -1.39476836e-01f, -2.70992983e-02f, 4.73473929e-02f, 9.68194082e-02f, 1.04545861e-01f, 7.36827552e-02f, -3.85622233e-02f,
  -1.13691472e-01f, 1.41048998e-01f, -7.78842997e-03f, 1.07700951e-01f, 5.07482700e-02f, -1.31567210e-01f, -5.37977107e-02f, -1.18195988e-01f, -3.14665884e-02f, 1.50100425e-01f,
  -1.03436321e-01f, 1.10879339e-01f, 1.17266901e-01f, 1.88026391e-02f, 1.55796513e-01f, 6.45807981e-02f, 1.09070845e-01f, -2.21835985e-03f, -1.88442692e-02f, -9.73226875e-02f,
  8.56207013e-02f, 1.12164482e-01f, 8.48701894e-02f, 1.34450018e-01f, -1.57243311e-02f, 1.15803080e-02f, -5.31446841e-03f, 2.63830479e-02f, 1.14673465e-01f, -1.08605869e-01f,
  -1.15112245e-01f, -5.16423807e-02f, -9.24079567e-02f, -7.31322467e-02f, 1.23892315e-01f, -2.75958516e-02f, 7.05105066e-02f, -1.55246072e-02f, -3.13800052e-02f, 5.50741591e-02f,
  5.32979071e-02f, 3.97292078e-02f, 5.53765427e-03f, 2.54052337e-02f, -9.13508423e-03f, -9.14423913e-02f, 9.85825583e-02f, -2.42104921e-02f, 4.00693379e-02f, 9.27841407e-04f,
  6.74015954e-02f, 7.80432746e-02f, 9.16394293e-02f, -7.82133341e-02f, 5.54265678e-02f, 8.55363160e-03f, -5.37188724e-02f, 6.01687888e-03f, -4.68638837e-02f, -1.23559929e-01f,
  -2.22328119e-02f, -5.85134886e-02f, 1.18086949e-01f, -1.16516694e-01f, -1.21548340e-01f, 8.10474604e-02f, -4.29847315e-02f, -6.52484298e-02f, -1.62934940e-02f, -1.15312316e-01f,
  3.60847488e-02f, 3.84778082e-02f, 6.48034811e-02f, 3.56885195e-02f, -1.15570784e-01f, 5.07351272e-02f, 1.09702535e-01f, -4.52008434e-02f, -1.34544848e-02f, -2.12192163e-02f,
  1.74519569e-02f, -5.78570701e-02f, -1.18249103e-01f, 3.90431397e-02f, -9.64225456e-02f, 5.14184088e-02f, -7.12535009e-02f, -2.91050412e-03f, 9.51179024e-03f, -5.75322695e-02f,
  8.62657502e-02f, -6.90895095e-02f, -9.03071985e-02f, 9.77798738e-03f, -9.55912992e-02f, -7.93635398e-02f, 9.41169634e-02f, -7.11905211e-02f, -5.70194190e-03f, -5.85919172e-02f,
  -2.78801583e-02f, 8.36096033e-02f, 3.56584080e-02f, 8.90635028e-02f, 3.87455039e-02f, -9.18329507e-02f, 2.21377821e-03f, 1.20089650e-01f, -8.75504687e-02f, 1.11707717e-01f,
  8.71845931e-02f, 5.95575720e-02f, 8.04617181e-02f, 2.26140432e-02f, -6.53931350e-02f, -1.34962937e-02f, -7.40112662e-02f, -1.52746746e-02f, 1.23195097e-01f, -1.03082865e-01f,
  -4.10842970e-02f, 1.21272691e-01f, -8.58682841e-02f, 7.84813166e-02f, 9.07422900e-02f, 1.22349232e-01f, -2.31114198e-02f, 9.20488983e-02f, -5.07898144e-02f, 1.39360726e-01f,
  -1.13672346e-01f, -2.75365543e-02f, -5.23239374e-02f, -6.58605248e-02f, -9.75667238e-02f, 2.60701496e-02f, -8.71897638e-02f, -6.93362625e-03f, -6.11843653e-02f, -1.78072061e-02f,
  -1.35024890e-01f, -7.13970363e-02f, -1.42278999e-01f, 1.05050758e-01f, 1.18738012e-02f, -1.43707348e-02f, -7.49920979e-02f, -3.91855948e-02f, 1.40183344e-01f, 3.37381028e-02f,
  2.52248067e-02f, -7.13828206e-03f, 7.43646547e-02f, -3.71952541e-02f, -5.60843870e-02f, 8.26629698e-02f, -1.10737301e-01f, 1.21789560e-01f, 9.07781813e-03f, 3.33790295e-02f,
  -1.46023240e-02f, 1.17326185e-01f, -1.07718721e-01f, 3.78589183e-02f, -1.11307360e-01f, -5.94756342e-02f, 1.61871701e-01f, 9.14239287e-02f, -6.83595538e-02f, 8.55896249e-02f,
  1.05831251e-02f, -1.85113470e-03f, -1.38661312e-02f, 6.38062134e-03f, 2.44096979e-01f, 5.97202033e-02f, -1.11993857e-01f, -2.22451799e-02f, 5.22890724e-02f, -5.67973452e-03f,
  -9.37210396e-02f, 2.03186408e-01f, 7.32391700e-02f, 5.68233542e-02f, -1.13509379e-01f, 1.43009603e-01f, -6.23860620e-02f, 7.66306818e-02f, -2.51268335e-02f, 1.26753047e-01f,
  1.20843714e-02f, 5.51145412e-02f, 8.05640817e-02f, -6.15046062e-02f, -9.37798768e-02f, 1.36191219e-01f, 7.63377398e-02f, -1.64839569e-02f, 8.11077096e-03f, -7.75244236e-02f,
  -5.12549430e-02f, 1.76156294e-02f, 1.29510939e-01f, -1.83319509e-01f, -4.17904725e-04f, -5.26425103e-03f, 1.34327009e-01f, -4.70450856e-02f, 7.74674714e-02f, 1.66737154e-01f,
  6.63707852e-02f, -6.57123253e-02f, -2.46137958e-02f, 1.88877955e-01f, 7.82902911e-02f, -7.50817209e-02f, 1.34987354e-01f, 1.64191365e-01f, 4.82689291e-02f, -1.65060232e-03f,
  4.93657142e-02f, 1.23013161e-01f, 2.20297482e-02f, -5.62631059e-03f, -4.60385904e-02f, -1.10199913e-01f, -3.63529958e-02f, 1.02874832e-02f, 1.21265277e-01f, -3.44056077e-02f,
  -1.40056923e-01f, -1.74735319e-02f, 1.49513111e-01f, -1.82215981e-02f, 1.16947919e-01f, -5.61250141e-03f, 4.90255393e-02f, -7.63307661e-02f, 5.37269153e-02f, 1.15695916e-01f,
  -8.37402269e-02f, 6.73171654e-02f, -2.33545690e-03f, 1.37928590e-01f, 1.21031225e-01f, -1.22757301e-01f, 6.33444488e-02f, 1.36140455e-02f, 8.51954669e-02f, 8.94417539e-02f,
  1.36750922e-01f, 6.57253265e-02f, 3.34988236e-02f, 1.65204078e-01f, 4.13730480e-02f, 4.22390550e-02f, -2.78317854e-02f, 7.79578686e-02f, 1.13512702e-01f, -6.27442822e-02f,
  -5.39013408e-02f, 7.92708844e-02f, 1.98200136e-01f, 1.16427287e-01f, -3.58249322e-02f, -6.86396658e-02f, 8.64085183e-02f, 1.19173154e-01f, 4.75659072e-02f, 2.87178773e-02f,
  -4.96960729e-02f, 5.71601391e-02f, -6.55535311e-02f, -1.11350708e-01f, 2.09633857e-01f, -7.52027109e-02f, 1.53132737e-01f, 1.38491586e-01f, 1.83901802e-01f, 1.03947539e-02f,
  -7.87643492e-02f, 2.02909172e-01f, 1.13038473e-01f, 9.83968303e-02f, -1.28049999e-01f, 1.63154393e-01f, -1.16045870e-01f, 6.14529774e-02f, -1.36959716e-03f, 2.87680551e-02f,
  1.16824441e-01f, -2.07406282e-02f, 2.99037923e-03f, -7.00009987e-02f, 3.46507318e-02f, 2.26109475e-01f, -4.08939235e-02f, -8.52972195e-02f, -3.40590626e-02f, 9.30860415e-02f,
  1.74714610e-01f, -2.13434547e-02f, 4.38321084e-02f, 3.87221649e-02f, -1.02919884e-01f, 1.73342377e-02f, -1.16415180e-01f, 4.69186753e-02f, -4.49012630e-02f, -6.09036861e-03f,
  -1.41617626e-01f, -1.00504577e-01f, -1.19714014e-01f, 1.52834743e-01f, -3.04536019e-02f, -2.18216386e-02f, 1.06476150e-01f, 6.89574927e-02f, -2.45183427e-02f, -7.79632702e-02f,
  1.01747863e-01f, -7.40176588e-02f, -4.78584692e-02f, 6.46730885e-02f, -2.40170863e-02f, -1.69561442e-03f, 1.76153392e-01f, 1.95495132e-03f, -2.26309313e-03f, 4.40881494e-03f,
  5.57812415e-02f, -1.86501667e-01f, -5.38051091e-02f, 2.76424643e-02f, -1.43208858e-02f, 2.74364650e-02f, 3.36966291e-02f, -3.42305154e-02f, 5.11309095e-02f, 8.47653449e-02f,
  -1.00291036e-02f, 2.03225687e-01f, 2.36461591e-02f, -6.27760291e-02f, 1.39089227e-01f, 1.19016275e-01f, -2.96663921e-02f, -6.08575679e-02f, 9.64500234e-02f, 6.65973127e-02f,
  -2.85470895e-02f, 1.08032830e-01f, -9.73711014e-02f, 5.61974496e-02f, -1.51202723e-01f, 6.57114536e-02f, 2.14349963e-02f, -6.49824366e-02f, 9.81020033e-02f, 7.86493346e-03f,
  7.37381205e-02f, -6.44670352e-02f, -2.96668615e-02f, -9.14045647e-02f, 5.04776128e-02f, -9.40149799e-02f, 3.71337309e-02f, -4.88544889e-02f, -3.44971835e-04f, 4.12654467e-02f,
  -1.45350218e-01f, -2.44678594e-02f, 9.38388333e-02f, -1.21707581e-02f, 8.82357508e-02f, -2.42690034e-02f, -1.21473983e-01f, 1.69176638e-01f, 1.49825532e-02f, 3.32215279e-02f,
  -7.16481358e-02f, 9.76423621e-02f, 2.78243981e-02f, 6.62207603e-02f, 8.29394087e-02f, 3.38499248e-02f, 8.73786584e-02f, -1.05448030e-01f, 1.28661513e-01f, -3.19797941e-03f,
  -1.48394331e-02f, 1.09632641e-01f, -3.27694826e-02f, 5.16443402e-02f, 1.25899300e-01f, 5.31548858e-02f, -1.08225429e-02f, -5.09762391e-02f, -1.40002847e-01f, 1.76328033e-01f,
  7.68559501e-02f, 6.53623864e-02f, -3.70283686e-02f, 6.91967681e-02f, -1.21123061e-01f, 2.32923087e-02f, -6.16590083e-02f, 1.24870330e-01f, -2.92868875e-02f, -1.17659867e-01f,
  5.28103970e-02f, -1.18884891e-01f, 8.06961879e-02f, 7.85217211e-02f, 2.39358936e-02f, 2.07416359e-02f, 9.35588703e-02f, 2.78298799e-02f, -2.40442436e-02f, -8.79094899e-02f,
  -7.43793473e-02f, -1.22337162e-01f, 2.05225348e-02f, 2.66610868e-02f, -2.11286712e-02f, 1.53385729e-01f, -9.18470323e-02f, -8.49061683e-02f, -1.22322448e-01f, -4.76270318e-02f,
  -3.18711288e-02f, -8.40610079e-03f, -1.25481546e-01f, -4.50894013e-02f, 1.31378964e-01f, 6.52135387e-02f, 6.28856495e-02f, 1.08608469e-01f, -1.15912117e-01f, 9.61141512e-02f,
  -9.24588814e-02f, -1.86680339e-03f, -2.09429357e-02f, -1.14425328e-02f, 3.06833140e-03f, -3.23542096e-02f, 1.13164507e-01f, 5.80142401e-02f, -1.16328083e-01f, -1.82187129e-02f,
  2.23350860e-02f, 7.36120865e-02f, 6.03210963e-02f, -4.80781905e-02f, 5.74550405e-02f, 6.68242052e-02f, -1.31568342e-01f, 6.41541779e-02f, 7.35510141e-02f, 8.19089487e-02f,
  -5.24556153e-02f, -1.07565433e-01f, 2.18885839e-02f, 7.43906200e-02f, 1.11436516e-01f, 2.26688478e-02f, 3.79490554e-02f, -5.54385707e-02f, -2.90257595e-02f, 1.26030408e-02f,
  -2.29954943e-02f, 8.81443098e-02f, 3.69464830e-02f, 9.58304331e-02f, -4.53371853e-02f, 6.31312653e-02f, 4.41870652e-02f, -5.54053287e-04f, -1.18337601e-01f, 1.08732603e-01f,
  -1.10348083e-01f, 2.27737450e-03f, 1.49877276e-03f, -5.79513200e-02f, 1.08905295e-02f, 5.05193099e-02f, 1.17405588e-02f, -1.16067633e-01f, -2.74117142e-02f, 1.07368156e-01f,
  -1.14341095e-01f, 4.51377556e-02f, -3.40569168e-02f, -1.09678678e-01f, -9.69310626e-02f, 1.09498482e-03f, -9.25864056e-02f, 1.01959594e-01f, -9.95545760e-02f, -3.38641256e-02f,
  7.51993060e-02f, 7.04713315e-02f, -2.74611544e-02f, 9.79628861e-02f, -1.98985916e-02f, -1.03464790e-01f, -4.07607555e-02f, 7.28454664e-02f, 4.03384678e-03f, 1.55624554e-01f,
  -1.91259384e-02f, -7.53740072e-02f, -1.50085222e-02f, 9.89442542e-02f, 1.35849670e-01f, 3.45420726e-02f, 1.13467336e-01f, 1.23887256e-01f, 1.34506956e-01f, -1.42638475e-01f,
  -6.43186122e-02f, 6.71871752e-02f, -1.32735655e-01f, 1.40228152e-01f, 1.04854047e-01f, 7.90782273e-02f, -2.63692196e-02f, -4.05024588e-02f, 6.39856905e-02f, -1.93993673e-01f,
  2.10005552e-01f, -5.46259172e-02f, 1.43400952e-01f, 2.18157530e-01f, 2.27668732e-02f, -1.19122945e-01f, 1.79709774e-02f, 2.31937423e-01f, 4.82203849e-02f, -9.47775245e-02f,
  -1.37694821e-01f, 5.94245642e-02f, -4.88702469e-02f, 8.16747844e-02f, 1.12423919e-01f, -9.77470279e-02f, 7.45411366e-02f, 9.76551548e-02f, -1.44002829e-02f, 1.36888087e-01f,
  -1.18826285e-01f, -1.31323617e-02f, 1.34042561e-01f, -2.27678102e-02f, 1.24550357e-01f, 6.42780662e-02f, 5.33832125e-02f, 1.00298777e-01f, -4.65572253e-02f, -6.07712008e-02f,
  1.09870415e-02f, 7.39577925e-03f, 1.16180733e-01f, 4.46641110e-02f, -3.85294780e-02f, -1.08838044e-01f, -7.51311630e-02f, 5.14177792e-02f, 7.03314319e-02f, 1.91350251e-01f,
  -9.18419883e-02f, -8.98233727e-02f, -4.71157990e-02f, 4.09757271e-02f, 1.37460634e-01f, -7.14561194e-02f, 4.58001085e-02f, 7.84660727e-02f, 1.27999587e-02f, 1.02162555e-01f,
  -1.94197008e-03f, -7.81750157e-02f, -9.73388553e-02f, 1.22987896e-01f, -3.72063438e-03f, -9.86739025e-02f, 7.66412169e-03f, -1.28631920e-01f, 2.38291696e-02f, -1.17012873e-01f,
  3.27758188e-03f, -6.34059161e-02f, -8.14493224e-02f, -1.49307325e-02f, -4.63785678e-02f, -9.23849419e-02f, 5.58696352e-02f, 2.65256613e-02f, 7.65684694e-02f, 1.21079519e-01f,
  -9.52158123e-02f, 9.89217237e-02f, 3.22717731e-03f, 4.92978795e-03f, 4.14104350e-02f, 2.92524463e-03f, 5.72012365e-02f, 3.19117540e-03f, 1.31041892e-02f, 1.21887140e-01f,
  9.97648463e-02f, 1.09773263e-01f, 7.42395744e-02f, -5.85282557e-02f, -1.03852704e-01f, -1.09533995e-01f, -9.86679792e-02f, -5.94074726e-02f, -1.23102754e-01f, 6.82541355e-02f,
  -9.84783173e-02f, -8.67491812e-02f, 1.39946625e-01f, 8.08853433e-02f, -1.02541059e-01f, -5.89362532e-02f, -8.08532983e-02f, -3.03598996e-02f, -1.76663231e-02f, -6.80678561e-02f,
  8.43248889e-02f, -5.38211949e-02f, 1.66621879e-02f, -1.43787593e-01f, 1.57058269e-01f, 8.73171911e-02f, 1.71941116e-01f, 8.47941339e-02f, 3.38482447e-02f, -5.64438738e-02f,
  1.30048275e-01f, 4.91003692e-02f, 1.97966248e-01f, 9.22757313e-02f, 9.24654528e-02f, 6.58533424e-02f, 1.64285779e-01f, -1.29142478e-01f, 9.82515365e-02f, 1.73992038e-01f,
  1.03299983e-01f, -2.36947924e-01f, -2.43488178e-02f, -2.47128353e-01f, -1.55824004e-02f, -1.27410486e-01f, 1.37526378e-01f, 2.31871113e-01f, -5.29916398e-02f, -8.70114937e-02f,
  -7.28636864e-04f, 1.00714229e-01f, 8.87939110e-02f, 1.41471878e-01f, 5.48403673e-02f, 2.42606908e-01f, 1.14893533e-01f, -1.00683540e-01f, 5.69303408e-02f, 2.56779820e-01f,
  -1.57178253e-01f, -3.74402814e-02f, -7.99638703e-02f, -2.99545079e-01f, 2.07465198e-02f, -1.17038816e-01f, 9.98275429e-02f, 9.65550356e-03f, 1.09088756e-02f, 1.88706279e-01f,
  4.49631475e-02f, -7.23310411e-02f, 4.85761054e-02f, 1.49912415e-02f, 4.61142473e-02f, -1.13098539e-01f, -1.45902276e-01f, -5.63457534e-02f, 8.05665404e-02f, 5.88000305e-02f,
  1.49742395e-01f, 2.04103410e-01f, 8.34653676e-02f, -1.58312276e-01f, -3.23099345e-02f, -3.37602268e-03f, -1.34266734e-01f, 1.94732353e-01f, 7.78525248e-02f, 8.03025812e-02f,
  1.31396040e-01f, 9.68182832e-02f, 1.07648320e-01f, 1.49389252e-01f, 1.37132391e-01f, 1.33095339e-01f, 3.81995663e-02f, -8.30080584e-02f, 5.15387952e-02f, -7.02388287e-02f,
  1.32115990e-01f, -1.06156744e-01f, -5.95978312e-02f, 1.06514871e-01f, 1.63700908e-01f, -9.54551548e-02f, 6.35203868e-02f, -1.43056780e-01f, 4.57405411e-02f, -3.38791199e-02f,
  2.95284763e-02f, 2.02783212e-01f, 6.52320385e-02f, 1.37210846e-01f, -5.72180562e-02f, -2.95015294e-02f, 6.12442866e-02f, 1.19857080e-01f, 1.16632260e-01f, 1.32651240e-01f,
  3.60342674e-02f, 3.95438410e-02f, 8.76638889e-02f, 8.11995193e-02f, 4.53582816e-02f, -5.33246249e-02f, -1.18497729e-01f, -9.01020598e-03f, -1.41721249e-01f, 1.18949518e-01f,
  7.63509274e-02f, -1.09471865e-01f, -7.96348155e-02f, 1.78093195e-01f, 1.01203695e-01f, -1.13273881e-01f, 2.92465501e-02f, 7.04989359e-02f, 3.14915106e-02f, -9.37843621e-02f,
  -4.48396876e-02f, -1.10980093e-01f, 7.06335828e-02f, -1.03874341e-01f, -1.07660115e-01f, 6.71359897e-02f, 3.39926295e-02f, -1.10379376e-01f, 1.49890974e-01f, -8.30705985e-02f,
  -9.83272791e-02f, 2.27241553e-02f, 4.30191793e-02f, -1.07511580e-01f, 4.65478003e-02f, 9.28706452e-02f, -7.94769824e-02f, -5.07320538e-02f, 6.99409656e-03f, -2.66263690e-02f,
  7.78656304e-02f, -4.83546890e-02f, -2.38741115e-02f, -1.93817448e-02f, 1.90004464e-02f, -3.05266976e-02f, -1.46290019e-01f, -1.47949710e-01f, -8.27926248e-02f, -4.18296680e-02f,
  -1.19628839e-01f, -2.01069210e-02f, 1.02839112e-01f, 4.42290045e-02f, -5.20685725e-02f, -7.08359107e-02f, -1.29112331e-02f, -1.99506222e-03f, 5.21570705e-02f, -7.40434527e-02f,
  -1.83315005e-03f, 1.17379889e-01f, -2.24702479e-03f, -1.23222537e-01f, 1.28737554e-01f, -4.07113843e-02f, -9.96826440e-02f, -2.08094213e-02f, -3.71134952e-02f, 6.99518993e-02f,
  9.05715227e-02f, 9.58077535e-02f, -1.01683483e-01f, 6.29312098e-02f, 1.10788293e-01f, 1.10580097e-03f, 1.27611086e-01f, -8.64552557e-02f, 1.56779662e-02f, 2.37783547e-02f,
  8.04976225e-02f, -5.10798171e-02f, 9.40037966e-02f, -5.33959232e-02f, -7.53094107e-02f, -3.06760482e-02f, -1.14478022e-01f, 2.23140642e-02f, -7.58579969e-02f, -2.76385415e-02f,
  -7.56001994e-02f, -2.07826048e-02f, -8.79834965e-02f, 4.72339243e-02f, 4.68373410e-02f, 7.26502240e-02f, 1.02579165e-02f, 1.98883578e-01f, 1.09944686e-01f, 1.19888462e-01f,
  2.14497792e-03f, 5.32731190e-02f, 8.08638856e-02f, 8.00240487e-02f, -4.72284295e-02f, -1.96487866e-02f, 2.00685382e-01f, 2.82845683e-02f, -1.08078487e-01f, 1.78731814e-01f,
  9.31110159e-02f, -1.66521251e-01f, 8.87669548e-02f, -8.66356343e-02f, -2.42692932e-01f, -1.94572896e-01f, -3.16067219e-01f, 2.54228085e-01f, -8.06101561e-02f, 9.63513032e-02f,
  -7.25445449e-02f, -9.14174467e-02f, 9.26200971e-02f, 1.88733581e-02f, 1.05645962e-01f, 3.47153358e-02f, -4.10685278e-02f, 1.04848877e-01f, -3.98280583e-02f, -1.73420627e-02f,
  1.81631267e-01f, 4.65363152e-02f, 8.80865157e-02f, 7.17217401e-02f, 8.07884037e-02f, 1.60685509e-01f, -1.65034860e-01f, -1.37927771e-01f, -6.20888099e-02f, -1.59243777e-01f,
  1.79634348e-01f, 3.74905437e-01f, 1.59065947e-01f, 2.47100636e-01f, 1.79782450e-01f, -1.45144641e-01f, -7.04470724e-02f, -1.10489026e-01f, 2.26409778e-01f, 3.83337140e-02f,
  -1.02067448e-01f, 1.01172522e-01f, 8.93752128e-02f, 4.92212512e-02f, -8.66769552e-02f, 3.13579082e-01f, -1.74622759e-02f, 1.05599225e-01f, -8.37759897e-02f, 2.91429371e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  3.52037884e-02f, 2.31594115e-01f, -9.32826381e-03f, 1.70264199e-01f, 1.15442283e-01f, 1.72547624e-01f, 5.20093665e-02f, 6.43821657e-02f, 1.67446092e-01f, -3.61920781e-02f,
  -5.98974936e-02f, 7.66919404e-02f, 2.22495869e-01f, 4.53888737e-02f, 7.22610950e-02f, -2.01127101e-02f, 8.88579935e-02f, -8.62775967e-02f, 8.56772065e-02f, -4.03685123e-02f,
  -1.06383171e-02f, -2.76246965e-02f, -4.51588482e-02f, 1.22361556e-01f, 2.46513337e-01f, 8.59748796e-02f, -8.82950351e-02f, 2.61612497e-02f, 1.28867589e-02f, -2.16516107e-03f,
  4.59067561e-02f, -3.56067978e-02f, 7.21757580e-03f, 9.98095945e-02f, 1.74431145e-01f, 1.02904178e-01f, 4.94553111e-02f, -6.77830055e-02f, 1.34600222e-01f, 5.46997115e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  7.45507404e-02f, 6.18719086e-02f, 4.55991291e-02f, 3.50714824e-03f, -2.27969624e-02f, 6.19406849e-02f, 1.85487926e-01f, 6.30172119e-02f, 7.30245486e-02f, -3.24556697e-03f,
  1.90528724e-02f, 1.00503892e-01f, -1.23045638e-01f, -1.78321600e-01f, 9.20836478e-02f, 2.82740332e-02f, 1.06598422e-01f, -1.35598695e-02f, -4.20318879e-02f, -1.02795228e-01f,
  -1.20922156e-01f, 8.61432496e-03f, 7.40683824e-02f, 1.27080604e-01f, -5.45738451e-03f, 2.53154308e-01f, 1.33569166e-01f, -2.56233841e-01f, 5.47110811e-02f, -1.20505065e-01f,
  -1.07861385e-02f, -7.52266720e-02f, 4.54923250e-02f, -4.59607318e-03f, 1.05629280e-01f, 1.95087895e-01f, 1.22514494e-01f, -1.34390116e-01f, -5.32765016e-02f, -1.04621708e-01f,
  1.81855381e-01f, 8.78670961e-02f, 1.16072267e-01f, -8.37672651e-02f, -1.36645958e-01f, 8.21711570e-02f, -9.04369876e-02f, 2.56533355e-01f, -1.96895346e-01f, -8.50253552e-03f,
  -6.08837456e-02f, 5.63583821e-02f, -8.84785503e-02f, 1.98862795e-02f, -1.11800388e-01f, -5.24474308e-02f, 4.05112701e-03f, -2.70213969e-02f, 8.61382037e-02f, -9.37451050e-02f,
  8.41098428e-02f, 3.55591774e-02f, 2.85173226e-02f, -2.59395003e-01f, -4.33183126e-02f, -1.00525036e-01f, -1.30688131e-01f, 9.41355750e-02f, -1.02028750e-01f, 1.22522060e-02f,
  8.77726078e-02f, 7.07493871e-02f, -1.54766254e-02f, -1.73744664e-01f, -1.17480084e-01f, -1.52942608e-03f, -1.10233463e-01f, -5.56426458e-02f, 4.52649854e-02f, -1.41642958e-01f,
  8.24455693e-02f, -3.30264568e-02f, 1.02200091e-01f, -8.64351634e-03f, -1.22096084e-01f, 6.65215328e-02f, -2.34463960e-02f, 1.39602035e-01f, 7.99680725e-02f, 2.60567874e-01f,
  -6.53344989e-02f, -1.60074279e-01f, 1.02106333e-01f, 2.42429692e-02f, 1.37296692e-01f, -9.34111550e-02f, -2.80810148e-02f, -4.71089594e-02f, -9.95087530e-03f, 2.46115476e-02f,
  1.57608949e-02f, 1.20603338e-01f, -4.80255224e-02f, 8.79559293e-02f, 1.84339970e-01f, -6.13805018e-02f, -8.76797959e-02f, -5.92113063e-02f, 2.65391637e-02f, -1.07929915e-01f,
  4.90405271e-03f, -2.31737830e-02f, -1.67787790e-01f, 3.53560448e-02f, -1.16283400e-02f, 3.20504904e-02f, 5.13676107e-02f, 6.77145943e-02f, 3.40930745e-02f, -8.83181542e-02f,
  -5.35888374e-02f, 6.43585622e-02f, -1.58791561e-02f, -7.22850412e-02f, -1.62809074e-01f, -6.20857254e-02f, -1.95614286e-02f, -1.91741779e-01f, 9.28665046e-03f, -9.87183228e-02f,
  -7.65862763e-02f, -1.04466043e-01f, 7.07906261e-02f, -1.65179268e-01f, -6.85531199e-02f, -1.20962143e-03f, -6.07818970e-03f, -2.12484319e-02f, -1.57810897e-01f, 5.19107617e-02f,
  -1.45853028e-01f, -3.90816852e-02f, -1.18756995e-01f, -3.90525721e-02f, -6.53789118e-02f, 1.46714717e-01f, 7.58668333e-02f, -1.12193622e-01f, -1.63601011e-01f, 8.00940990e-02f,
  -4.85393591e-02f, -2.59926915e-02f, -9.68221724e-02f, 2.62880981e-01f, 1.71823695e-01f, -5.83937280e-02f, 3.04528512e-02f, -9.37942415e-02f, -5.48603199e-02f, 1.29398584e-01f,
  -9.71388421e-04f, -5.83546162e-02f, 5.90019636e-02f, -7.92198181e-02f, -1.49528801e-01f, 9.95306298e-02f, -6.15943000e-02f, -1.79950111e-02f, 4.98812981e-02f, -6.86540231e-02f,
  1.20439999e-01f, -1.16448037e-01f, -5.63091673e-02f, 8.39210525e-02f, 1.01107746e-01f, 1.18437134e-01f, -2.60272861e-01f, -4.90560569e-02f, -7.96947926e-02f, -7.37998709e-02f,
  -7.70985633e-02f, 9.48362499e-02f, 1.24187157e-01f, 5.04265130e-02f, -7.66578019e-02f, -1.23164706e-01f, 1.88916698e-01f, 2.03605127e-02f, 2.37720292e-02f, -4.81626578e-03f,
  6.08983152e-02f, -1.89850464e-01f, 3.50099877e-02f, 1.76532522e-01f, -4.22550505e-03f, 1.32464737e-01f, -1.24618188e-02f, -2.85544395e-02f, 5.08716553e-02f, 1.23503789e-01f,
  2.14106187e-01f, 3.23342532e-02f, 1.42760882e-02f, 1.77044258e-01f, 3.26501019e-02f, -2.30762690e-01f, 2.04437956e-01f, 9.16914046e-02f, -2.94076838e-03f, -4.60803248e-02f,
  4.78850342e-02f, -6.46145688e-03f, 3.40868123e-02f, 1.57321095e-01f, -8.48025456e-02f, 1.74606219e-01f, -8.26097503e-02f, 1.23636775e-01f, 4.67364267e-02f, -1.47524670e-01f,
  6.73619211e-02f, 8.21357518e-02f, 4.28857729e-02f, 3.47364023e-02f, -1.90864857e-02f, -1.49319053e-01f, -1.35217488e-01f, 1.11500390e-01f, -6.76590651e-02f, -9.09253806e-02f,
  -1.16392888e-01f, 9.62772593e-02f, 1.79731636e-04f, 1.53402667e-02f, 7.02775596e-03f, -4.06981595e-02f, -8.17058533e-02f, 8.86737928e-02f, 7.69767463e-02f, 1.15541831e-01f,
  -7.50945136e-02f, -1.51337786e-02f, -3.77209298e-02f, -1.11952744e-01f, -4.69052466e-03f, -5.89220151e-02f, 9.41288546e-02f, -1.39312878e-01f, -1.40011504e-01f, 9.64438021e-02f,
  2.08032995e-01f, -4.37185615e-02f, 2.92110816e-02f, 8.03652778e-02f, -4.31452831e-03f, -2.11892784e-01f, -7.05716833e-02f, -1.44986361e-01f, -1.09410949e-01f, 7.20623210e-02f,
  -6.39116839e-02f, -5.61074279e-02f, -7.95771182e-02f, -1.51454479e-01f, 1.84816420e-02f, 2.21913122e-02f, 8.53191912e-02f, 1.92971509e-02f, 4.18668054e-02f, 1.56018853e-01f,
  -2.37426758e-01f, -1.49467762e-03f, -5.60955890e-02f, 1.06884159e-01f, -6.23190999e-02f, -1.46156549e-01f, 1.53477311e-01f, 6.75149411e-02f, 1.13242045e-02f, 1.04651246e-02f,
  -8.34589452e-02f, -6.32030070e-02f, 3.01687676e-03f, 1.88019812e-01f, 4.15958241e-02f, 1.30427107e-01f, 7.77844936e-02f, 5.93224280e-02f, 3.85654420e-02f, -3.99100855e-02f,
  6.49688095e-02f, -5.39294854e-02f, -1.08674608e-01f, -5.28231114e-02f, 2.26530433e-02f, 1.28851458e-03f, -1.77783474e-01f, -2.55577862e-02f, -1.43755645e-01f, -6.06683977e-02f,
  1.14761047e-01f, -7.47416541e-02f, -7.41294175e-02f, -1.81489009e-02f, -2.15205587e-02f, 5.13990112e-02f, -1.44348899e-03f, -6.52038753e-02f, 3.02880201e-02f, -7.73679838e-02f,
  -1.61656849e-02f, 5.10559864e-02f, 8.96921828e-02f, 4.95850891e-02f, -7.57451281e-02f, 8.48550443e-03f, -9.29202661e-02f, -2.15468835e-02f, 6.17919415e-02f, 2.49477535e-01f,
  5.72815873e-02f, -2.47209631e-02f, 4.38673198e-02f, -8.51536617e-02f, 4.91126329e-02f, -6.96616694e-02f, -8.48176777e-02f, 6.35659769e-02f, 1.27907112e-01f, 4.37377729e-02f,
  -2.70333351e-03f, 5.09784929e-02f, 7.01753572e-02f, -4.35594991e-02f, 8.67217127e-03f, 1.53433949e-01f, -6.67042211e-02f, 5.04328087e-02f, 1.17260277e-01f, -2.89601032e-02f,
  -6.57211095e-02f, 1.62758008e-01f, -7.16759264e-02f, 8.26886222e-02f, 1.17574194e-02f, 2.16889977e-01f, 9.96451676e-02f, -1.35321021e-01f, -5.30045927e-02f, 1.28963124e-02f,
  6.20903485e-02f, -7.79336542e-02f, 1.14008211e-01f, 3.95666882e-02f, -7.05547445e-03f, 1.88590903e-02f, 1.02277823e-01f, 6.23378232e-02f, -4.05133516e-02f, -6.84833378e-02f,
  1.18272640e-01f, 1.20814450e-01f, 1.28139749e-01f, 7.45255426e-02f, 7.98023418e-02f, 1.75218401e-03f, 1.78770766e-01f, 6.28327345e-03f, -6.75638840e-02f, 2.20668945e-03f,
  -8.74879137e-02f, -1.16161212e-01f, -1.56421289e-01f, 1.52715221e-01f, -7.45417625e-02f, -9.74856988e-02f, -1.41918987e-01f, -7.08650574e-02f, 7.39263967e-02f, -1.15807682e-01f,
  1.83068991e-01f, -3.31906625e-03f, 8.65942910e-02f, -1.13222405e-01f, 2.04928920e-01f, -5.90285286e-02f, 5.34596704e-02f, 8.43131468e-02f, 1.22978523e-01f, 2.19485238e-01f,
  8.28601122e-02f, -2.60486305e-02f, 8.08778778e-02f, 2.06933007e-01f, -8.49434827e-03f, 6.32551983e-02f, 8.06310996e-02f, -1.00108996e-01f, 1.12563826e-01f, -3.08646057e-02f,
  -6.06137328e-02f, -3.97590213e-02f, 9.04660448e-02f, 9.11657289e-02f, 2.35494152e-01f, -2.26263572e-02f, -1.72637263e-03f, 1.28964409e-01f, -2.46706195e-02f, -7.22492114e-02f,
  -1.20647967e-01f, 3.45402174e-02f, 9.42335650e-02f, 1.85366347e-01f, 3.54082324e-02f, 9.31844488e-02f, -6.03783391e-02f, 7.61909634e-02f, 5.50201461e-02f, 1.61013324e-02f,
  4.97622825e-02f, -1.47795556e-02f, -1.85753424e-02f, -1.31611049e-01f, 3.67570892e-02f, -8.76452923e-02f, -1.42905056e-01f, 2.90752146e-02f, -2.78174784e-02f, -6.64759576e-02f,
  -1.05871014e-01f, -2.47261990e-02f, 6.45411313e-02f, 1.21380314e-01f, -2.77952733e-03f, -1.30125418e-01f, -3.04349884e-02f, -1.16232574e-01f, -8.16993490e-02f, -1.02658518e-01f,
  7.62267038e-02f, -4.29194495e-02f, -5.65125644e-02f, 6.19905107e-02f, 6.13599122e-02f, -2.70941406e-02f, 3.56755294e-02f, -6.22710139e-02f, -1.37763396e-01f, -1.27534300e-01f,
  -7.64080510e-02f, 6.83120862e-02f, -8.67483467e-02f, -1.86238319e-01f, -1.83906183e-01f, -4.49769907e-02f, 1.75102558e-02f, -2.56450512e-02f, 6.46106526e-02f, 1.00020312e-01f,
  -1.72579557e-01f, 1.92856528e-02f, -2.40598753e-01f, -9.52194929e-02f, -4.06235009e-02f, 1.83758706e-01f, -2.00464785e-01f, 2.39533093e-03f, -7.15097995e-04f, 8.76121596e-02f,
  -1.71424020e-02f, 1.44913122e-01f, 4.15773541e-02f, 7.75898248e-02f, 3.36321108e-02f, 4.92064469e-02f, 5.80217652e-02f, -8.87749493e-02f, -1.17818728e-01f, -7.68855959e-02f,
  4.44418751e-02f, -8.35086629e-02f, 4.64282148e-02f, -1.17360204e-01f, 1.25621660e-02f, 1.27798274e-01f, -2.10052188e-02f, -5.76279461e-02f, -5.17461821e-02f, 8.69799107e-02f,
  -3.87172326e-02f, -4.37183958e-03f, 8.63480121e-02f, 1.15862951e-01f, 6.20894842e-02f, -8.38747844e-02f, 1.67694539e-02f, -6.11993950e-03f, -6.74081221e-02f, -2.72719469e-02f,
  2.76987092e-03f, -2.93852799e-02f, 4.33377773e-02f, 1.14394433e-03f, -4.39907648e-02f, -4.80925180e-02f, -5.10213114e-02f, -5.20163700e-02f, 2.81731457e-01f, 1.10145949e-01f,
  -2.01989468e-02f, -8.88727158e-02f, -1.69676617e-02f, -1.59318596e-01f, -1.48866531e-02f, 1.14829978e-02f, -8.78339708e-02f, -1.88521504e-01f, -1.58826426e-01f, -4.57642935e-02f,
  -4.30999510e-02f, -1.70520380e-01f, 6.05182126e-02f, -1.41434278e-02f, -8.81781429e-02f, -2.14649364e-02f, -1.65860116e-01f, -1.70404688e-02f, 6.72546923e-02f, 1.65194482e-01f,
  -8.08982085e-03f, -1.20651975e-01f, -2.49890480e-02f, 7.19527230e-02f, -1.11277066e-01f, -1.44931629e-01f, 1.35133997e-01f, 2.24046513e-01f, -5.96083235e-03f, -9.23144296e-02f,
  -1.09529302e-01f, 9.54598710e-02f, 4.50248495e-02f, 6.09805621e-02f, -8.64900202e-02f, -1.50532305e-01f, 1.01009220e-01f, -8.34587440e-02f, -1.28509268e-01f, 2.78988760e-03f,
  2.53060134e-03f, 2.34747939e-02f, 1.35435900e-02f, 5.71247749e-02f, 3.80505249e-02f, -2.75818259e-02f, 6.07169531e-02f, -6.40301257e-02f, 3.53582948e-02f, -1.47916004e-01f,
  -8.17067102e-02f, -7.09048733e-02f, -4.51636538e-02f, 7.88184702e-02f, 3.01833805e-02f, -8.78373608e-02f, 5.50783910e-02f, 1.64284289e-01f, -1.33361071e-01f, 4.93432097e-02f,
  6.97249696e-02f, 4.76938151e-02f, 9.40438583e-02f, 7.84219243e-03f, -9.99863222e-02f, 2.67201196e-02f, -8.30768887e-03f, -1.11669011e-01f, -3.48013528e-02f, 1.92919164e-03f,
  -3.74881886e-02f, -4.17001396e-02f, 1.48050293e-01f, 1.19805425e-01f, -3.49087641e-02f, 9.31450501e-02f, -8.78056791e-03f, 1.27172783e-01f, 1.22646235e-01f, -7.54173249e-02f,
  -3.87728997e-02f, -9.16906372e-02f, 1.23404957e-01f, -7.09459782e-02f, -9.89866406e-02f, 1.00001507e-02f, 2.03594908e-01f, -3.02811135e-02f, 7.59153366e-02f, 2.30311304e-02f,
  1.57982688e-02f, -3.27270299e-01f, -5.53453602e-02f, 1.01899318e-01f, 8.14648792e-02f, 1.54238880e-01f, -6.12675771e-02f, 1.79151986e-02f, 6.63380474e-02f, 4.52570841e-02f,
  -4.64932434e-02f, -7.14780539e-02f, 1.65909022e-01f, -4.56175320e-02f, -2.74982508e-02f, -1.02816232e-01f, 7.33997375e-02f, 6.46066107e-03f, -1.44214496e-01f, -3.59268449e-02f,
  -9.98506844e-02f, -1.05378293e-01f, -8.08488727e-02f, -9.86035820e-03f, 1.25591949e-01f, 1.70283228e-01f, 4.17508036e-02f, -1.18024044e-01f, -7.92683735e-02f, 6.92718625e-02f,
  -1.60457134e-01f, -1.61163285e-01f, 9.36015174e-02f, 1.12742558e-02f, -9.53585356e-02f, -5.99913336e-02f, -4.49712761e-02f, -6.60257265e-02f, 1.05908602e-01f, 1.50509551e-01f,
  -8.63811001e-02f, 6.73576724e-03f, 1.36622697e-01f, 6.22657277e-02f, -6.84972703e-02f, -1.29122153e-01f, 6.25882968e-02f, -1.52714476e-01f, -6.29071966e-02f, -2.20795736e-01f,
  -1.43524304e-01f, -1.08613342e-01f, 9.74513441e-02f, 5.48062213e-02f, 1.02806509e-01f, 5.21934554e-02f, -1.74460821e-02f, -6.62010387e-02f, 2.65228190e-02f, -1.10402867e-01f,
  -1.91240191e-01f, 2.04226643e-01f, -5.23642870e-03f, 1.39515311e-01f, 5.17239012e-02f, 2.96925098e-01f, 1.20772682e-01f, -3.67591679e-02f, 4.14842404e-02f, -1.21986315e-01f,
  -1.29964482e-02f, 7.79595301e-02f, -1.06054759e-02f, -1.36248618e-01f, 1.23822130e-01f, -2.87858732e-02f, 1.65909100e-02f, -1.02380760e-01f, -9.25679877e-02f, -1.69597974e-03f,
  -1.46032438e-01f, 2.50451434e-02f, 1.46219984e-01f, 1.11734964e-01f, 1.18580647e-01f, 1.24510296e-01f, 8.61902237e-02f, 1.26668051e-01f, -1.10751659e-01f, 7.65117034e-02f,
  1.06725395e-01f, 1.31482288e-01f, -2.83774249e-02f, 1.15598775e-01f, -8.29441920e-02f, 8.14982057e-02f, -3.01964511e-03f, -9.45289806e-02f, 8.22195411e-02f, 7.25170821e-02f,
  1.11251712e-01f, 7.13709965e-02f, -1.45653963e-01f, -1.81619525e-01f, 1.12347558e-01f, 1.15524203e-01f, 2.62293853e-02f, -1.06792212e-01f, 6.23121336e-02f, -6.22484460e-02f,
  1.18658625e-01f, 8.90863966e-03f, -3.28771584e-02f, -1.12548873e-01f, -5.59910610e-02f, 5.45501895e-02f, 7.30475709e-02f, -9.46541578e-02f, 1.31819814e-01f, 2.17454489e-02f,
  3.73133309e-02f, -1.46153361e-01f, 1.48659348e-01f, -1.70430504e-02f, 8.07651877e-02f, 2.15813648e-02f, 8.61576423e-02f, -1.46875963e-01f, -1.18783988e-01f, -1.44948304e-01f,
  -4.41819727e-02f, -4.04141098e-02f, -8.64994079e-02f, -1.17582858e-01f, 1.98789865e-01f, 3.83316316e-02f, -5.34328148e-02f, 3.34300511e-02f, -8.00076127e-02f, 1.52486026e-01f,
  -1.07120655e-01f, -1.74608119e-02f, 1.27638146e-01f, -4.74781170e-02f, 8.02411735e-02f, -6.80552498e-02f, 1.43139334e-02f, 4.15648632e-02f, 9.63156763e-03f, -1.29657313e-01f,
  -1.01698317e-01f, 3.70995253e-02f, 1.73980564e-01f, 1.11981675e-01f, -1.35148361e-01f, -5.80044873e-02f, 4.95628901e-02f, -1.07795238e-01f, 9.08436030e-02f, 2.85546891e-02f,
  9.53886807e-02f, 3.41072343e-02f, 2.89046038e-02f, 9.07088351e-03f, -2.28817657e-01f, -1.23332955e-01f, 9.52215642e-02f, -1.21924363e-01f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -2.55674664e-02f, -1.09826162e-01f, -7.77712017e-02f, -1.65970158e-02f, -6.24673851e-02f, -5.93325943e-02f, -4.39368188e-02f, 1.39607210e-03f, -1.04155265e-01f, 4.30740789e-02f,
  -4.58245091e-02f, -5.10106422e-02f, -1.28279075e-01f, 4.01052721e-02f, -4.60617878e-02f, -4.75095101e-02f, 4.58435901e-02f, 6.29367977e-02f, -3.26306233e-03f, -7.53091425e-02f,
  -4.95628230e-02f, -1.10436931e-01f, 2.23536380e-02f, -6.11668527e-02f, -6.54768478e-03f, -2.30922289e-02f, -8.00535753e-02f, 1.90570757e-01f, 7.13102669e-02f, 9.77751464e-02f,
  -3.23625049e-03f, -1.11299390e-02f, 1.09172001e-01f, 7.27212802e-03f, 3.21643576e-02f, -7.00857043e-02f, -5.68212084e-02f, 9.09807906e-02f, 9.17855650e-02f, 1.24586791e-01f,
  -4.81951535e-02f, -3.45750637e-02f, -3.30043472e-02f, -1.01171330e-01f, -1.14643596e-01f, -1.11840084e-01f, 3.70767191e-02f, -1.07732877e-01f, -6.69538882e-03f, -1.18467614e-01f,
  -6.58331662e-02f, 9.60193053e-02f, 1.09274633e-01f, 4.69131097e-02f, 6.84301415e-03f, 1.33394584e-01f, -6.54945299e-02f, -1.17321685e-01f, 6.08741790e-02f, -5.61755598e-02f,
  -2.37692408e-02f, 1.14299804e-02f, -1.08780023e-02f, 1.97619110e-01f, 3.97797823e-02f, -4.22092490e-02f, -5.06169051e-02f, -1.08819999e-01f, -9.78735760e-02f, 5.89352921e-02f,
  1.12036392e-01f, 6.43001646e-02f, 4.51810732e-02f, 1.06170274e-01f, 2.97598299e-02f, -2.12627538e-02f, 1.09368823e-02f, -3.45378518e-02f, 1.50459737e-01f, -1.10601828e-01f,
  7.22481906e-02f, 7.65612125e-02f, 5.75287305e-02f, -1.91892665e-02f, 9.11444202e-02f, 1.02045961e-01f, 5.80720324e-03f, 4.17031236e-02f, 1.07962534e-01f, -1.13682263e-02f,
  1.81345437e-02f, -1.05043530e-01f, -2.50124820e-02f, -1.04013957e-01f, -4.45338985e-04f, 8.50304812e-02f, 1.44024193e-03f, 3.78787108e-02f, 8.23518038e-02f, -1.02234155e-01f,
  4.06082440e-03f, 4.09211591e-02f, 5.58365099e-02f, 3.37470509e-02f, 8.13076273e-02f, 1.07527144e-01f, -5.69404624e-02f, 1.05545856e-01f, -4.46667224e-02f, -3.63312550e-02f,
  8.24024007e-02f, 2.78420672e-02f, 2.17863359e-02f, 6.36048019e-02f, 8.24976340e-02f, -5.42751327e-02f, -7.34446272e-02f, -7.91931748e-02f, 4.02308963e-02f, -3.35311033e-02f,
  -1.18090317e-01f, -3.26697454e-02f, -9.28641856e-03f, 4.56596678e-03f, 5.24824187e-02f, -5.92046753e-02f, 1.05251782e-01f, -8.79927352e-02f, 1.18184283e-01f, 2.24096373e-01f,
  -8.44472926e-03f, 1.18156321e-01f, -2.34118048e-02f, 2.58548617e-01f, 2.53291577e-01f, 8.84084404e-02f, 2.18395088e-02f, -3.40866670e-02f, 1.90575287e-01f, 1.47062197e-01f,
  1.60739765e-01f, -2.13238984e-01f, 3.03930521e-01f, 1.42533198e-01f, 1.57944247e-01f, 5.58667891e-02f, 1.74288228e-02f, -8.61031339e-02f, 1.34365514e-01f, 5.22374958e-02f,
  5.59653938e-02f, 1.22173727e-01f, -1.42573431e-01f, 8.72438997e-02f, -2.34891474e-02f, 1.68931276e-01f, 1.17762350e-01f, 2.41118167e-02f, 9.21128541e-02f, 9.85748693e-02f,
  6.58215359e-02f, 4.95627820e-02f, -8.98362100e-02f, 1.07008845e-01f, -3.30950040e-03f, 7.49006122e-02f, 2.15750607e-03f, -1.16951102e-02f, 4.33304682e-02f, -4.01619412e-02f,
  1.35207579e-01f, -1.41660795e-01f, -3.03284414e-02f, -1.47993073e-01f, -1.73332363e-01f, -4.43212269e-03f, 7.99623504e-02f, 2.31332347e-01f, -4.40824628e-02f, -8.41025487e-02f,
  2.07999162e-02f, 8.09473470e-02f, -5.07875383e-02f, -1.38644189e-01f, 5.52258734e-03f, -8.90289769e-02f, 1.74232274e-02f, 2.26223916e-02f, -1.43685237e-01f, -9.18017402e-02f,
  1.04465364e-02f, 1.44751575e-02f, 4.70451005e-02f, 7.11760372e-02f, 1.37342036e-01f, 1.64129421e-01f, 1.37786567e-01f, 3.20867717e-01f, 1.15509249e-01f, 6.87866211e-02f,
  2.48081654e-01f, 3.05615604e-01f, 2.32684776e-01f, 2.83241272e-01f, 1.22387998e-01f, -2.67662764e-01f, 3.16325009e-01f, 1.11078851e-01f, -1.02951951e-01f, -2.70798057e-01f,
  1.73754513e-01f, -4.51115072e-02f, 6.51854873e-02f, 2.31599018e-01f, -1.91129863e-01f, -7.97631592e-02f, -1.70854941e-01f, 5.07054366e-02f, -1.39156640e-01f, 3.02794483e-02f,
  1.59068201e-02f, -8.03124979e-02f, 2.64596760e-01f, 3.00614219e-02f, -1.12970255e-01f, 2.02312246e-02f, -2.22628176e-01f, 2.34655604e-01f, -1.80567294e-01f, 1.66722655e-01f,
  -1.33756295e-01f, -8.54758918e-02f, 3.06051403e-01f, 1.23494811e-01f, 1.70932189e-01f, -9.47013795e-02f, -1.34592190e-01f, -1.35963291e-01f, -2.39947557e-01f, 8.59335959e-02f,
  2.06732973e-01f, 9.69646722e-02f, -1.41086027e-01f, -1.92838442e-02f, -5.11806682e-02f, -4.73974198e-02f, 9.35884491e-02f, -5.09720203e-03f, 2.21735961e-03f, 6.92035407e-02f,
  -4.69904719e-03f, -6.25006109e-03f, -1.48287527e-02f, 4.22603078e-02f, -5.77506199e-02f, -2.30736211e-01f, 3.32016759e-02f, 3.80337983e-02f, -5.74359745e-02f, 7.52101243e-02f,
  5.22903837e-02f, 9.03831199e-02f, -2.71537919e-02f, -9.47299413e-03f, 2.34126776e-01f, 1.60941049e-01f, -3.83183509e-02f, -3.58487889e-02f, 6.58698380e-02f, -1.09376349e-01f,
  -1.43202879e-02f, -1.78129047e-01f, -3.57303843e-02f, -2.85430327e-02f, 5.54865599e-02f, -1.06076218e-01f, -9.75847989e-02f, 1.85558766e-01f, 4.78243418e-02f, -1.55340731e-01f,
  -1.67893901e-01f, 1.18337758e-01f, -8.43903646e-02f, 1.61549732e-01f, -9.59438980e-02f, 7.10237920e-02f, 9.46195945e-02f, 5.10106273e-02f, -1.10619344e-01f, 3.62410694e-02f,
  -1.04281614e-02f, 1.80883914e-01f, 6.92806486e-03f, 8.91833678e-02f, -1.22918151e-01f, 2.03339085e-02f, 3.19868289e-02f, 9.07070860e-02f, 1.14058122e-01f, 5.36340289e-02f,
  7.50985369e-02f, 8.59436914e-02f, -5.82915805e-02f, 9.59749296e-02f, -6.02523983e-02f, 2.31861230e-02f, 7.10300654e-02f, 4.24283147e-02f, 7.09278509e-02f, -3.26744169e-02f,
  1.55453607e-01f, -9.63979661e-02f, -1.29063547e-01f, 5.07664718e-02f, 1.06226861e-01f, -1.23552762e-01f, -1.37772888e-01f, 4.26715538e-02f, -2.40091197e-02f, 1.28207147e-01f,
  8.75065401e-02f, -2.32831780e-02f, 3.83004248e-02f, 9.63813737e-02f, 1.60815403e-01f, -3.15085910e-02f, 1.57514945e-01f, 2.40821689e-02f, 8.79515931e-02f, -9.87146646e-02f,
  4.88652326e-02f, -2.89609488e-02f, -5.19938301e-03f, -1.69057492e-02f, -1.32530570e-01f, -9.86150699e-04f, 1.32626705e-02f, -1.95948835e-02f, 8.13195854e-02f, -8.52709115e-02f,
  -2.09423713e-02f, 6.31440058e-02f, -1.52765796e-01f, -2.38324516e-02f, 6.50219694e-02f, 3.74432765e-02f, -5.02041504e-02f, -9.11277384e-02f, 7.81835988e-02f, 7.83452019e-02f,
  1.71197936e-01f, 1.09342061e-01f, 1.66926496e-02f, 4.92823450e-03f, 5.44946902e-02f, -8.72815773e-02f, 1.24312513e-01f, 4.33864333e-02f, 8.75803456e-02f, -4.21600454e-02f,
  2.66641956e-02f, -6.04844512e-03f, -1.22809127e-01f, 1.19528316e-01f, -1.22013353e-02f, 5.39829805e-02f, 1.18519582e-01f, 2.31534559e-02f, 2.24347353e-01f, 1.20789222e-01f,
  -8.70990977e-02f, -5.06593920e-02f, 6.09539486e-02f, -1.21001184e-01f, -1.12162739e-01f, -3.87218855e-02f, 9.87126157e-02f, -4.60340641e-02f, -1.00649729e-01f, -1.39722824e-01f,
  -1.23112634e-01f, -9.38157961e-02f, 3.76538076e-02f, 6.57222643e-02f, 1.64424539e-01f, -5.16323410e-02f, 7.10555464e-02f, 1.45308346e-01f, 2.43239626e-01f, 2.13032454e-01f,
  1.20496802e-01f, 1.87296003e-01f, 7.34141096e-02f, 2.92319596e-01f, 1.76102564e-01f, 2.17557594e-01f, -1.34055778e-01f, -2.00298533e-01f, -2.56733615e-02f, 1.82710022e-01f,
  -6.79300576e-02f, -1.60513625e-01f, 1.85904622e-01f, 1.12529613e-01f, 1.15899213e-01f, -1.60933778e-01f, 5.73145151e-02f, 2.40984946e-01f, 1.77330077e-01f, -1.29909545e-01f,
  -4.49996488e-03f, -1.16224155e-01f, 1.17821090e-01f, 2.17896461e-01f, 3.02154366e-02f, -7.41604790e-02f, 2.69549906e-01f, -7.81357065e-02f, 8.54928941e-02f, -1.35024805e-02f,
  2.22323626e-01f, 4.24991436e-02f, -3.87989655e-02f, -1.07189119e-01f, 2.17883587e-02f, 2.67613102e-02f, -1.13109209e-01f, -5.18406592e-02f, -1.44069299e-01f, 3.35797854e-02f,
  -5.41379005e-02f, 1.82695791e-01f, 1.00865774e-01f, 2.04592511e-01f, 8.35379884e-02f, -9.30965096e-02f, -1.82584688e-01f, -3.19029838e-02f, -3.58168371e-02f, -2.69984398e-02f,
  -1.01931885e-01f, -7.75681138e-02f, 5.17165884e-02f, -1.76876113e-02f, 1.64222017e-01f, 2.25315332e-01f, 3.39936242e-02f, -1.63758337e-01f, 8.52924362e-02f, 1.03392884e-01f,
  -7.58939385e-02f, 1.20272383e-01f, -6.49048388e-02f, 1.50476489e-02f, -6.86975569e-02f, 9.75473691e-03f, -2.89136022e-02f, -1.50939167e-01f, -4.93471436e-02f, 7.22587630e-02f,
  -1.09729409e-01f, 6.34669662e-02f, 9.32807326e-02f, -8.12237263e-02f, -2.29413733e-02f, 9.34287161e-02f, 6.09879233e-02f, 8.78349170e-02f, 6.40076548e-02f, 5.33821806e-02f,
  -1.08350135e-01f, 4.81472798e-02f, -2.97571644e-02f, 6.85573146e-02f, 7.18293712e-02f, -6.78727329e-02f, 1.41133487e-01f, 2.47374307e-02f, 5.34225442e-02f, -3.51766199e-02f,
  2.72535812e-02f, -5.74495867e-02f, 5.86939007e-02f, 7.25972652e-02f, -9.32238773e-02f, 3.30396295e-02f, -1.90956462e-02f, -4.88522947e-02f, 7.53174582e-03f, 1.12769119e-01f,
  -1.09731974e-02f, 8.72702152e-02f, 6.57990277e-02f, 1.98338516e-02f, -1.02441251e-01f, 1.26163393e-01f, -7.47344121e-02f, -1.03625171e-01f, 1.10155225e-01f, 3.81787270e-02f,
  -1.09060936e-01f, 6.20233528e-02f, -2.64206082e-02f, -1.83121990e-02f, -7.53714936e-03f, -2.37483226e-04f, 5.34621142e-02f, 9.08106007e-03f, 5.76166622e-03f, 2.09385566e-02f,
  1.00391090e-01f, -1.34219155e-01f, 6.81772605e-02f, -1.11083359e-01f, -1.26586452e-01f, -2.39797719e-02f, -1.28841221e-01f, 2.61177793e-02f, -8.16751495e-02f, -5.13466708e-02f,
  -9.22690034e-02f, 3.00430283e-02f, -4.56749871e-02f, 1.39657408e-02f, 1.13890514e-01f, -1.48473894e-02f, -1.02385953e-02f, 1.68574671e-03f, 3.32604907e-02f, -3.84446904e-02f,
  -1.10717362e-03f, -1.10966908e-02f, -4.74429969e-03f, -1.03039354e-01f, -5.12518249e-02f, 1.01349644e-01f, -5.72312437e-02f, -4.28142324e-02f, 7.90740624e-02f, -4.24835123e-02f,
  -8.02488029e-02f, 3.21161225e-02f, 4.33688723e-02f, -5.11391647e-02f, 2.84628607e-02f, 4.96801063e-02f, 9.88813713e-02f, 5.75475432e-02f, 7.13093057e-02f, -6.92022070e-02f,
  1.05727628e-01f, -6.62114471e-02f, -6.61807880e-02f, -6.83653578e-02f, 8.42306837e-02f, -3.81934049e-04f, -7.86184072e-02f, 1.20283946e-01f, 2.66792695e-03f, -6.31387457e-02f,
  -5.74515201e-02f, -9.33898985e-02f, 8.75449646e-03f, -8.32175910e-02f, -6.80169538e-02f, 4.43021394e-02f, -1.08195886e-01f, -2.06816848e-02f, 8.78844112e-02f, -3.77850868e-02f,
  1.03029655e-02f, -3.05515435e-02f, 4.49067168e-02f, -8.10793117e-02f, -7.18091875e-02f, -5.07570468e-02f, 6.27844056e-05f, 7.76074678e-02f, 2.02700701e-02f, 6.46007285e-02f,
  1.05342269e-01f, 3.90932970e-02f, 3.77044119e-02f, 6.41560182e-02f, 5.61268665e-02f, 2.16975555e-01f, -1.76951885e-02f, 8.14476050e-03f, 5.61617017e-02f, 6.15516119e-02f,
  -1.53684646e-01f, -5.31591550e-02f, 1.00038737e-01f, 1.13113441e-01f, -3.24586593e-02f, -7.07327500e-02f, 7.66473264e-02f, -1.29615694e-01f, 1.06675737e-01f, -3.43798175e-02f,
  1.21377721e-01f, -1.67440402e-03f, -7.28849992e-02f, 3.54118198e-01f, 3.44465673e-03f, 1.72879249e-01f, -1.73519775e-01f, -7.64148682e-02f, 1.79537505e-01f, 4.49033231e-02f,
  7.83301331e-03f, -3.85667011e-02f, 1.82195157e-01f, -1.22425459e-01f, -8.21477771e-02f, -4.03146958e-03f, -1.53528526e-01f, -3.32271643e-02f, -1.10957213e-01f, -1.02780454e-01f,
  -7.11381584e-02f, 8.58523399e-02f, 4.49962206e-02f, 1.67796053e-02f, 2.83163369e-01f, 1.42203510e-01f, 2.88892519e-02f, -1.40952870e-01f, 3.66686694e-02f, 1.91893160e-01f,
  -5.81611432e-02f, 1.42172292e-01f, 1.61932915e-01f, -9.19384509e-02f, -5.10637350e-02f, 1.21012643e-01f, 1.33354694e-01f, 1.33198813e-01f, -3.13135348e-02f, 1.08282484e-01f,
  -7.91865066e-02f, -2.78405044e-02f, -4.22983766e-02f, -5.65319620e-02f, -2.97778249e-02f, 1.17323555e-01f, -1.15054533e-01f, -8.75763893e-02f, 4.98275310e-02f, -4.34625968e-02f,
  -1.16411299e-01f, -3.33827287e-02f, 6.51039109e-02f, 3.15872915e-02f, -4.16180491e-02f, -1.12110032e-02f, -1.15119092e-01f, -6.52114823e-02f, -1.08292885e-01f, 4.83118072e-02f,
  -1.20547496e-01f, 9.04897004e-02f, -9.35797468e-02f, -4.62490581e-02f, -5.71325496e-02f, -9.09369662e-02f, -3.70779634e-02f, -7.78362378e-02f, 1.11762337e-01f, 3.66092362e-02f,
  -6.13969052e-03f, -1.07332300e-02f, 5.52707054e-02f, -9.85870734e-02f, -3.00575793e-02f, -8.82442743e-02f, -1.64034981e-02f, -1.37505606e-02f, 8.81016776e-02f, -1.09879158e-01f,
  9.86477807e-02f, 4.44030017e-03f, -8.07089955e-02f, 9.30257216e-02f, 9.31381285e-02f, 1.01443365e-01f, 3.88104767e-02f, -5.03689535e-02f, 6.07136302e-02f, 1.07303582e-01f,
  -9.30929258e-02f, 7.88557455e-02f, -2.07597110e-02f, -1.20111391e-01f, -3.71961370e-02f, -7.72505924e-02f, 6.51991367e-02f, -1.07226677e-01f, -1.83926634e-02f, 1.21132955e-01f,
  -5.76409623e-02f, -9.74059477e-02f, -4.33914997e-02f, 1.28498245e-02f, -3.84406000e-02f, 1.90643877e-01f, 2.28159890e-01f, 1.01981275e-01f, 1.04159094e-01f, 2.04677545e-02f,
  2.07624853e-01f, -1.60319230e-03f, -4.29869443e-02f, -9.47904214e-02f, -1.16363559e-02f, 1.67412862e-01f, -6.09460287e-02f, 3.04928217e-02f, -3.80362086e-02f, -8.07507411e-02f,
  -9.69307125e-02f, -1.52966276e-01f, -1.27025723e-01f, -2.08482090e-02f, -7.58389244e-03f, 1.62675261e-01f, 9.91692096e-02f, 3.15181050e-03f, -9.21831951e-02f, 2.26252854e-01f,
  -5.68547808e-02f, 5.88302054e-02f, -9.24345385e-03f, -3.31407003e-02f, -4.29822132e-02f, 4.27625291e-02f, 4.07976247e-02f, -8.62412527e-02f, 1.52599677e-01f, 7.23019149e-03f,
  3.81702483e-02f, 6.09153435e-02f, -8.24064091e-02f, 5.26027866e-02f, -4.40637767e-02f, 2.45471895e-02f, 1.38076171e-01f, -8.17728639e-02f, 2.67977337e-03f, -3.19351070e-02f,
  -4.05711420e-02f, 2.43193328e-01f, -1.11809596e-01f, 2.71336958e-02f, -1.53847560e-02f, -6.42307801e-03f, -4.94910367e-02f, -2.02926286e-02f, 2.55458876e-02f, 1.02930002e-01f,
  6.30915686e-02f, 1.12200223e-01f, -1.27578499e-02f, 3.47900647e-03f, 4.22571860e-02f, 1.16247602e-01f, -7.37375990e-02f, -1.39771953e-01f, 7.98836350e-02f, 1.89346336e-02f,
  -1.16554290e-01f, 7.29610398e-02f, 8.55137631e-02f, 4.98068407e-02f, -1.51952416e-01f, -4.19299528e-02f, -3.95158455e-02f, 5.46353757e-02f, 5.04872166e-02f, -7.95592815e-02f,
  -1.16980001e-01f, 3.15078050e-02f, 2.49156617e-02f, -5.39736040e-02f, -8.90732333e-02f, 1.08973727e-01f, -1.38957575e-01f, 1.82045773e-02f, 2.94237062e-02f, -9.44696739e-02f,
  -7.31936246e-02f, -1.07535981e-01f, -3.92130576e-02f, -4.94508743e-02f, 1.09612308e-01f, 1.33307278e-01f, 8.57522339e-02f, -6.46135584e-02f, -3.84204992e-04f, -1.20527565e-01f,
  1.81743637e-01f, -3.24924923e-02f, 9.31733400e-02f, 2.02671178e-02f, 1.42605114e-03f, -1.08545989e-01f, -1.04673706e-01f, -2.43743770e-02f, -1.74311608e-01f, 4.04310711e-02f,
  4.55097482e-02f, -4.16372977e-02f, -8.61799717e-02f, -1.09054253e-01f, -8.65227208e-02f, -2.63604075e-02f, 7.06172660e-02f, -4.66177724e-02f, 4.10347991e-02f, -5.52802533e-02f,
  -3.37697472e-03f, 1.59780383e-01f, 1.19999141e-01f, 2.51270123e-02f, 9.54255462e-02f, 1.10462636e-01f, -5.46099693e-02f, -8.65982696e-02f, 1.95954144e-01f, 1.31778508e-01f,
  9.52074006e-02f, -1.31577775e-02f, 2.46294234e-02f, 1.05644614e-01f, -7.26998076e-02f, 1.46395653e-01f, 1.60417765e-01f, -8.88641104e-02f, 1.63448006e-02f, 3.32021490e-02f,
  1.42026255e-02f, 1.29375786e-01f, 4.43108082e-02f, 7.06659779e-02f, -9.27276909e-02f, -1.37764513e-01f, 7.90947452e-02f, 2.27841511e-02f, 7.15303719e-02f, 8.69272202e-02f,
  1.23519607e-01f, -7.98024889e-03f, 1.17318362e-01f, -9.33592394e-02f, 5.01845032e-02f, -3.61232758e-02f, 1.75098374e-01f, -1.77696850e-02f, -7.72775114e-02f, -8.31411332e-02f,
  1.32469445e-01f, -1.25874169e-02f, 6.67784922e-03f, 8.40334129e-03f, 1.24114476e-01f, -8.97496492e-02f, 1.89381987e-02f, -1.06221817e-01f, 4.10661511e-02f, -6.71130270e-02f,
  -6.62233904e-02f, -1.06247209e-01f, -3.46645489e-02f, 6.30208552e-02f, 9.68356878e-02f, -1.14573672e-01f, 1.28743485e-01f, 5.31700812e-02f, 1.02956565e-02f, -3.37926708e-02f,
  1.22730611e-02f, 1.70674771e-01f, -8.00096721e-04f, -5.76555021e-02f, -3.48192491e-02f, 1.51933134e-01f, -7.55788833e-02f, 1.34372652e-01f, -1.74523965e-02f, -6.50947075e-03f,
  -6.79465830e-02f, 1.08714305e-01f, -4.43680286e-02f, 1.36534393e-01f, 7.07823038e-02f, 3.33178081e-02f, 2.77755945e-03f, 4.21073176e-02f, 8.62889290e-02f, -1.68896355e-02f,
  3.55152898e-02f, 4.55374224e-03f, -1.09555282e-01f, -1.45255411e-02f, -9.18436050e-02f, -5.68734258e-02f, -1.08253613e-01f, 1.05959408e-01f, -1.15431003e-01f, 2.53979508e-02f,
  -1.50589002e-02f, -7.11203590e-02f, 1.21356897e-01f, 8.61197636e-02f, -1.53651550e-01f, -1.02751985e-01f, -2.01286394e-02f, -3.81930731e-02f, 9.56600532e-02f, 8.57799426e-02f,
  1.70200437e-01f, -1.62967704e-02f, -1.01720683e-01f, -6.27413392e-02f, -4.72077355e-02f, 8.91039893e-02f, 8.64838660e-02f, 3.63193937e-02f, -6.21375162e-03f, 1.02515608e-01f,
  1.80123262e-02f, -1.41780302e-01f, -1.63276400e-02f, 5.78113422e-02f, -1.07724272e-01f, 5.42493984e-02f, 8.42622072e-02f, 5.84322866e-03f, -9.84915197e-02f, -5.13791740e-02f,
  -3.50056477e-02f, 1.67695861e-02f, 1.65776744e-01f, -2.42756004e-03f, 5.48557155e-02f, -3.98221873e-02f, 9.94444415e-02f, 1.17110528e-01f, 1.22053623e-01f, 8.77723247e-02f,
  -4.19814475e-02f, -1.11502573e-01f, -9.26854014e-02f, 7.39359856e-02f, -1.30268307e-02f, -1.23791985e-01f, 8.94072428e-02f, -3.27797309e-02f, -9.63574722e-02f, 1.17669247e-01f,
  -7.71388412e-02f, 5.40237948e-02f, -1.08193316e-01f, 6.06504641e-03f, -1.32342279e-01f, 3.53824726e-04f, -1.08705744e-01f, -2.28638668e-02f, -6.47891238e-02f, -8.87080431e-02f,
  -1.23147413e-01f, 7.89008960e-02f, -4.57184538e-02f, 1.03774428e-01f, -1.01482540e-01f, -4.93145548e-02f, 1.17436856e-01f, -2.91111022e-02f, 4.09648288e-03f, -8.21287185e-02f,
  1.01511978e-01f, -9.79661662e-03f, -4.18721251e-02f, 3.53601985e-02f, 1.12235233e-01f, 7.05634803e-02f, 5.08909449e-02f, -1.08317778e-01f, -2.03453172e-02f, -8.51392224e-02f,
  -1.48678636e-02f, 1.28727118e-02f, 1.79021936e-02f, -7.86696374e-02f, -5.03233783e-02f, 7.41813555e-02f, 7.17400433e-03f, 6.44638762e-02f, 9.37780291e-02f, 2.16764654e-03f,
  -8.02551433e-02f, 4.99880649e-02f, 1.82004590e-02f, 1.04954071e-01f, -7.43947923e-02f, -8.44886452e-02f, -1.01362973e-01f, -3.94794419e-02f, 5.54238707e-02f, -9.20914486e-02f,
  1.05136462e-01f, 8.43457431e-02f, -5.33491746e-02f, -1.13849148e-01f, -2.18964834e-02f, -4.56044301e-02f, 6.05218485e-02f, 7.71263689e-02f, -9.99348313e-02f, 6.58037513e-02f,
  -3.02830003e-02f, -6.95559457e-02f, 4.44303558e-04f, -1.04129300e-01f, 3.31983119e-02f, -4.10143584e-02f, -7.15438160e-04f, 8.22227448e-02f, -6.87323138e-02f, 5.21675907e-02f,
  4.30242307e-02f, -8.84265080e-02f, 1.71339884e-02f, -1.28346607e-01f, 7.94228688e-02f, -1.19958641e-02f, -8.73827934e-02f, -1.04894340e-02f, -7.38424584e-02f, 1.03554964e-01f,
  -2.66656820e-02f, 1.20275408e-01f, -2.95700077e-02f, -5.21863662e-02f, -1.42085090e-01f, -1.23927064e-01f, -4.85677868e-02f, -5.69283627e-02f, 1.74121797e-01f, 1.77210465e-01f,
  -2.88828518e-02f, -1.80555716e-01f, 5.41674979e-02f, 1.12280864e-02f, 9.38720033e-02f, -1.12384349e-01f, 1.77500881e-02f, 2.47747563e-02f, 7.04962462e-02f, 2.83747744e-02f,
  7.75718763e-02f, -1.52599782e-01f, 2.97926776e-02f, -6.82578385e-02f, 5.88974729e-02f, 9.00634900e-02f, 8.93030316e-02f, -1.21949062e-01f, 3.55544724e-02f, -4.39061895e-02f,
  9.53714997e-02f, -2.34031118e-02f, -1.22254334e-01f, -9.36945602e-02f, 2.16914080e-02f, 1.08423531e-01f, -7.12994188e-02f, 1.68238971e-02f, -1.05956808e-01f, 1.37227818e-01f,
  9.85093880e-03f, -3.49911526e-02f, 8.80241692e-02f, 4.60704528e-02f, -1.13040611e-01f, 9.28104520e-02f, 2.48075500e-02f, 1.05125807e-01f, -6.90658838e-02f, -2.16832161e-01f,
  2.93389466e-02f, 4.23958451e-02f, -6.48066550e-02f, -2.32513323e-01f, -1.24128744e-01f, 7.16009643e-03f, 1.78957179e-01f, 5.18293083e-02f, 9.02195275e-02f, -1.40986770e-01f,
  -2.73669869e-01f, 1.33243710e-01f, -3.41475815e-01f, -1.46271586e-01f, -4.61589694e-02f, 3.83211598e-02f, -1.91757321e-01f, -1.65155262e-01f, -1.84763655e-01f, -8.24336112e-02f,
  -2.37163547e-02f, 1.91261079e-02f, 1.51567146e-01f, 1.02016203e-01f, 1.26341701e-01f, 2.03582585e-01f, 8.97914246e-02f, 1.28484964e-01f, -1.24381401e-01f, 3.05941310e-02f,
  3.45686913e-01f, 1.76661424e-02f, 1.71219036e-01f, -2.14641750e-01f, 1.42754260e-02f, 1.47446558e-01f, 9.78887733e-03f, 1.01807177e-01f, -2.53813893e-01f, -9.08763632e-02f,
  -6.24349713e-02f, 7.09691718e-02f, 1.37674376e-01f, 1.84900180e-01f, 2.76446730e-01f, -1.00047074e-01f, 3.87217477e-02f, -8.54307339e-02f, 5.72085679e-02f, 2.35624872e-02f,
  1.29125193e-01f, 1.92994744e-01f, 2.66349882e-01f, 3.73564065e-02f, 4.06253673e-02f, 8.21243525e-02f, 1.18172586e-01f, -2.87054311e-02f, 3.48595291e-01f, -1.08518898e-02f,
  -9.25587341e-02f, 3.07937026e-01f, 1.62804142e-01f, 1.17041737e-01f, -1.05609939e-01f, 1.33326501e-01f, -7.48039931e-02f, -8.40993449e-02f, 6.91066831e-02f, -8.96439925e-02f,
  8.33326802e-02f, -1.31994691e-02f, -5.86090125e-02f, -3.22570093e-02f, -4.28615585e-02f, -4.66110595e-02f, 2.98718642e-03f, 3.25861610e-02f, -4.21355106e-02f, 8.58853906e-02f,
  -6.60435334e-02f, -9.65854302e-02f, 1.25865400e-01f, 8.24672803e-02f, -1.27198741e-01f, -8.39934200e-02f, -5.31721450e-02f, 1.83403283e-01f, -2.25164164e-02f, 5.27422018e-02f,
  4.95440103e-02f, 3.03976126e-02f, 1.65511984e-02f, -4.02555615e-02f, -1.30753890e-01f, 5.82811311e-02f, 1.18208915e-01f, 1.52228832e-01f, 4.90050651e-02f, -7.37782717e-02f,
  9.58221257e-02f, -4.79805544e-02f, -1.03013664e-02f, 5.40007558e-03f, 1.46434963e-01f, 5.63742332e-02f, 1.59231946e-01f, -9.32630077e-02f, -1.13178104e-01f, 9.51483622e-02f,
  9.12300218e-03f, 1.58431217e-01f, -9.05606300e-02f, -8.77815038e-02f, -7.10160360e-02f, -6.19945414e-02f, 1.44038782e-01f, -1.26799420e-01f, -2.61040144e-02f, -6.52846172e-02f,
  3.76692787e-02f, -7.75125772e-02f, -1.29938677e-01f, -1.16543509e-01f, 1.06703810e-01f, 2.28808708e-02f, 1.07610375e-01f, 1.66606694e-01f, 1.27777427e-01f, 1.16559893e-01f,
  1.56040294e-02f, -3.39870192e-02f, 6.50966614e-02f, 1.37614608e-01f, 5.38061373e-02f, -1.04559891e-01f, -6.48184568e-02f, 7.12906569e-02f, 4.92655374e-02f, 5.11779003e-02f,
  1.26345307e-01f, -1.86499301e-02f, -8.68827328e-02f, 4.38525761e-03f, -6.22182079e-02f, 8.08253363e-02f, -1.47297263e-01f, 1.30197676e-02f, -1.08141340e-01f, 1.49724381e-02f,
  -7.21322894e-02f, 9.83768404e-02f, 5.67165166e-02f, 1.41948596e-01f, -6.31917194e-02f, -1.23703115e-01f, 3.22767086e-02f, 1.76281556e-02f, -1.64615154e-01f, -9.04994309e-02f,
  -4.86257970e-02f, 3.17082591e-02f, 7.95351118e-02f, -1.17255412e-01f, 1.09348208e-01f, -5.64545915e-02f, -5.11234291e-02f, -9.11051631e-02f, -3.58421504e-02f, -7.60392323e-02f,
  1.63721204e-01f, -5.47479503e-02f, 1.21979319e-01f, -6.84401095e-02f, 1.25406861e-01f, -9.16118324e-02f, 1.40924469e-01f, 7.40819722e-02f, 5.69139533e-02f, -6.87775388e-02f,
  -1.23215884e-01f, -3.21085937e-02f, -6.85224533e-02f, 6.92142025e-02f, -3.30915488e-02f, 2.31753364e-02f, 3.66152115e-02f, 5.71790431e-03f, -1.07551515e-01f, 1.41029924e-01f,
  -1.19723767e-01f, -7.77268689e-03f, 9.54934433e-02f, -1.07541203e-01f, -1.28821105e-01f, 5.41920960e-02f, -1.37419909e-01f, -1.09976679e-01f, 9.24267247e-02f, -9.43437740e-02f,
  -1.04917377e-01f, 1.54619373e-03f, 5.48770092e-03f, 3.32894805e-03f, -1.00867286e-01f, -1.10237449e-01f, -7.85745308e-02f, -2.56726006e-03f, -1.76404435e-02f, 6.20844886e-02f,
  7.28426799e-02f, 3.49257328e-02f, 8.96737650e-02f, -1.16434678e-01f, -3.09566166e-02f, -1.13078661e-01f, 1.22622363e-01f, 1.71209332e-02f, -3.76111865e-02f, 4.43058535e-02f,
  -1.27280295e-01f, 3.63685116e-02f, 1.06750041e-01f, 2.52776165e-02f, 1.26448244e-01f, -1.20180406e-01f, 3.51000689e-02f, 8.90544355e-02f, -4.92875390e-02f, 9.84827951e-02f,
  -6.08186126e-02f, 1.27774611e-01f, 4.12850715e-02f, 1.12279996e-01f, 4.61280346e-02f, 1.82465604e-03f, -1.70825589e-02f, -1.49812615e-02f, -1.97860096e-02f, 9.16352589e-03f,
  -1.06506251e-01f, -3.74169610e-02f, 3.86300161e-02f, 4.26679850e-02f, 3.79417166e-02f, -7.19103441e-02f, 8.18893239e-02f, -5.35164401e-02f, 1.31139755e-01f, 1.23072475e-01f,
  7.54266232e-02f, 3.77414636e-02f, -4.96637709e-02f, 3.49992961e-02f, -1.59276798e-01f, 8.84546041e-02f, 6.10186122e-02f, 7.74831325e-02f, -3.96385118e-02f, -1.68011248e-01f,
  -1.54277876e-01f, -1.39247105e-01f, 1.26020819e-01f, -1.25081062e-01f, -9.33142928e-06f, 7.96916895e-03f, -1.31878853e-01f, 1.40520772e-02f, -1.72148794e-01f, 1.07464083e-01f,
  7.55002350e-02f, 2.00277105e-01f, -1.28970623e-01f, 3.84603739e-02f, -8.28029066e-02f, 1.39715731e-01f, -4.75208387e-02f, 5.93817011e-02f, 9.67955291e-02f, 1.44736364e-01f,
  -4.01218459e-02f, 2.13176813e-02f, 6.34080619e-02f, 8.00696313e-02f, 5.11321165e-02f, -6.58188090e-02f, 9.84589607e-02f, -7.47253466e-03f, 1.23578310e-01f, -9.62956026e-02f,
  3.22062746e-02f, 2.64865328e-02f, -6.57604486e-02f, 1.07321285e-01f, -1.12493031e-01f, 6.39690738e-03f, -1.23424433e-01f, -2.71660108e-02f, 1.41896293e-01f, 1.24906458e-01f,
  1.51022121e-01f, -6.92698658e-02f, 3.54777016e-02f, -4.16474137e-03f, -8.99919569e-02f, -4.03731391e-02f, -7.51277208e-02f, 1.56646073e-01f, 1.29861474e-01f, 1.27282515e-01f,
  5.05512170e-02f, 6.07710481e-02f, 4.09617834e-02f, -9.83946398e-02f, 1.66166529e-01f, 1.71416983e-01f, -6.80520460e-02f, 1.33495152e-01f, -3.43721248e-02f, 1.37344599e-01f,
  1.68081596e-01f, -7.79948384e-02f, 6.09081499e-02f, -9.02842134e-02f, -1.03805527e-01f, -8.69614705e-02f, -5.95715046e-02f, 3.55597474e-02f, 9.89982486e-03f, 1.20943658e-01f,
  -1.11621112e-01f, -8.15479532e-02f, 5.02818078e-02f, 1.21088088e-01f, 3.99238318e-02f, 1.65753230e-01f, -7.94886947e-02f, -2.81209801e-03f, -1.33277893e-01f, 1.45807952e-01f,
  9.86761823e-02f, 1.61838934e-01f, 2.92667709e-02f, 5.78032658e-02f, -1.19091822e-02f, 1.40529081e-01f, -9.98160336e-03f, -2.31982227e-02f, -9.90381166e-02f, 4.75817025e-02f,
  1.97139859e-01f, -1.62323508e-02f, 4.99473698e-02f, -9.85393003e-02f, -3.63774225e-02f, 1.70904901e-02f, -9.13072824e-02f, -1.16655804e-01f, 1.35367131e-02f, -8.93114060e-02f,
  1.10073537e-01f, -5.02988622e-02f, 4.65130284e-02f, 1.11171469e-01f, 1.16243236e-01f, 3.88721563e-02f, -9.83546674e-02f, 7.37838298e-02f, 1.11459203e-01f, -1.58587447e-03f,
  7.27489665e-02f, 1.95415884e-01f, 1.17776610e-01f, -1.31478328e-02f, -9.48058590e-02f, 6.88163415e-02f, -6.16908111e-02f, 8.34081769e-02f, 1.52200669e-01f, -1.56576314e-03f,
  -7.38927200e-02f, 1.64415650e-02f, 2.63366010e-02f, -2.98003573e-02f, -5.25341183e-02f, 7.24541098e-02f, -2.52296537e-04f, -1.50717366e-02f, -5.27327470e-02f, -1.70195565e-01f,
  1.47591054e-01f, -2.41743848e-02f, -1.00523278e-01f, 5.44896945e-02f, -1.18899882e-01f, 1.47610486e-01f, -2.11732060e-01f, 3.17817554e-02f, -7.68796131e-02f, 1.97332472e-01f,
  -1.94978081e-02f, -1.50341019e-02f, -5.29943081e-03f, 1.03212938e-01f, -2.22544316e-02f, 4.44868244e-02f, 1.58755526e-01f, -5.16680814e-03f, -1.10259786e-01f, -5.45478091e-02f,
  1.10043861e-01f, -3.47980224e-02f, -4.50862721e-02f, -8.89438204e-03f, 1.87824935e-01f, 1.61024928e-02f, 7.49967620e-02f, -1.59796953e-01f, -8.94523934e-02f, 1.05348982e-01f,
  -4.41463329e-02f, 5.82495704e-02f, 2.86867060e-02f, -4.36415039e-02f, -1.61686689e-01f, 4.81770784e-02f, 1.64272979e-01f, 5.34258336e-02f, 1.38895914e-01f, -1.42404333e-01f,
  1.16105132e-01f, -7.61588961e-02f, -4.53888774e-02f, -2.92701200e-02f, -5.82152419e-02f, -4.70786765e-02f, 9.17237028e-02f, 1.68939605e-01f, 3.35664153e-02f, -3.15506221e-03f,
  -2.01659612e-02f, -1.35970756e-01f, 1.88293085e-02f, 5.22110984e-02f, -1.21433944e-01f, 1.96237594e-01f, 1.17195360e-01f, 1.38947546e-01f, 1.00387551e-01f, 6.66832477e-02f,
  -4.06265557e-02f, 1.18361138e-01f, -2.43790131e-02f, 2.37409510e-02f, -6.76879734e-02f, 4.03119735e-02f, 5.38925081e-02f, -3.95761579e-02f, 8.97987634e-02f, 2.59986543e-03f,
  7.12940022e-02f, 3.49216349e-02f, 9.22779292e-02f, 4.96340580e-02f, 1.08685002e-01f, 1.04266740e-01f, 2.46485341e-02f, 5.16759939e-02f, -1.03319280e-01f, -5.24107041e-03f,
  3.12210321e-02f, -1.23108707e-01f, -4.12069336e-02f, -4.72609624e-02f, 1.37340248e-01f, -3.12561132e-02f, -1.67561844e-02f, 1.15602709e-01f, 8.25698003e-02f, 9.92304683e-02f,
  -2.09251326e-02f, -1.10715464e-01f, 9.85906273e-02f, 9.06670094e-02f, -4.99678552e-02f, -9.04313177e-02f, 2.48674732e-02f, -6.72551319e-02f, 8.84735733e-02f, -3.18468325e-02f,
  -4.68879305e-02f, -1.02852225e-01f, -6.12801239e-02f, -1.90463774e-02f, 4.52191606e-02f, 1.62408173e-01f, -4.97863479e-02f, 2.04855781e-02f, 4.24501710e-02f, 1.94143766e-04f,
  -2.89486926e-02f, -9.13702846e-02f, -1.44471487e-05f, 8.88030976e-02f, -9.40727517e-02f, -9.06400606e-02f, 1.18185513e-01f, -4.44292165e-02f, -6.70531914e-02f, -3.55244577e-02f,
  3.40018570e-02f, -3.92821133e-02f, 1.46997392e-01f, -1.11290626e-02f, -7.35197514e-02f, -2.09785625e-02f, 8.36987048e-02f, 5.17976936e-03f, -1.12338282e-01f, -3.47254612e-02f,
  -7.80272335e-02f, -3.14076319e-02f, 5.46076894e-02f, 1.60556167e-01f, -8.73290300e-02f, 9.64823440e-02f, -1.23165488e-01f, 7.41364881e-02f, 3.66831124e-02f, -4.95971255e-02f,
  -7.36499503e-02f, -8.84007439e-02f, -2.79393420e-03f, 2.72922050e-02f, -9.13839787e-02f, -1.37882039e-01f, 1.40716759e-02f, 1.94618925e-01f, -1.02597065e-01f, 3.68145891e-02f,
  1.25137672e-01f, -1.32370457e-01f, 1.56928543e-02f, -4.22935840e-03f, 1.57707687e-02f, 7.78522715e-02f, 1.32780835e-01f, -2.46486515e-02f, -2.55929176e-02f, 4.44811247e-02f,
  -9.06877518e-02f, -6.79100528e-02f, 3.44256945e-02f, -1.10744178e-01f, -3.34508233e-02f, 9.47474465e-02f, -4.26357426e-02f, -4.92803752e-02f, 1.76304847e-01f, -1.06645942e-01f,
  1.20468415e-01f, 1.99159253e-02f, 8.72982144e-02f, -2.76185479e-02f, 4.27658036e-02f, 3.15939216e-03f, 5.53016029e-02f, -2.00351467e-03f, -5.72028086e-02f, -1.04762815e-01f,
  8.43492672e-02f, 6.07024841e-02f, 5.02866544e-02f, 1.74512014e-01f, 1.01521909e-01f, 1.21255703e-01f, 3.81496623e-02f, -3.21764834e-02f, 5.35358004e-02f, -8.62872899e-02f,
  -4.78590615e-02f, -1.05508812e-01f, -1.02413543e-01f, -1.15057036e-01f, -8.18525702e-02f, -9.62741226e-02f, 2.11930033e-02f, -8.09019282e-02f, -3.90270241e-02f, 1.29236296e-01f,
  -8.65419060e-02f, 2.96366345e-02f, 8.88003632e-02f, 1.00412071e-01f, 9.10992771e-02f, 8.47341642e-02f, 1.22008786e-01f, 1.80056226e-02f, -1.03718109e-01f, -9.88726970e-04f,
  -5.87757677e-02f, 9.71341506e-03f, 1.18801326e-01f, 5.00085279e-02f, -1.02837324e-01f, -1.87649322e-03f, 6.91516772e-02f, 8.58998448e-02f, 8.74289572e-02f, -1.03700586e-01f,
  1.22757345e-01f, 7.38361776e-02f, 7.97639936e-02f, -5.37402630e-02f, 1.05760843e-01f, 1.09481260e-01f, -1.17506802e-01f, 8.83154869e-02f, 1.11058112e-02f, -7.10560903e-02f,
  -8.42656717e-02f, -7.33308271e-02f, -3.65940854e-02f, -3.82216349e-02f, 3.63301206e-03f, 8.91111046e-02f, 3.33576612e-02f, -7.09410906e-02f, 5.98957948e-02f, 9.60248113e-02f,
  -1.08061709e-01f, -1.20880671e-01f, 1.30844237e-02f, -7.54774641e-03f, 3.22576724e-02f, -8.64604488e-02f, 1.08485438e-01f, 9.50822979e-02f, -1.08222179e-02f, -7.30163651e-03f,
  3.46616805e-02f, 6.07907772e-02f, -1.13064714e-01f, -1.11495350e-02f, -1.45386100e-01f, -7.83444494e-02f, -1.67574026e-02f, 9.14979354e-02f, 1.11400537e-01f, -1.07793994e-01f,
  -7.61275645e-03f, 1.55475765e-01f, -1.76869422e-01f, -1.79919168e-01f, -2.06305832e-02f, 9.84843820e-03f, -4.50472422e-02f, 3.31994742e-02f, 5.13411034e-03f, 4.46909331e-02f,
  -1.22284785e-01f, -1.48559064e-01f, -2.06883308e-02f, 8.27483013e-02f, 3.03520150e-02f, 2.05029562e-01f, -8.90198946e-02f, -4.62648273e-02f, -8.34374651e-02f, -9.05841887e-02f,
  7.18630850e-02f, -1.71698611e-02f, 1.30333886e-01f, 3.71374637e-02f, -1.43661618e-01f, 1.09171338e-01f, 9.12057236e-02f, 5.74068874e-02f, -7.38396570e-02f, -3.91494595e-02f,
  -2.55851331e-03f, -1.31594939e-02f, -7.33631775e-02f, 1.36757061e-01f, 1.57889336e-01f, 2.52406746e-02f, 4.42656409e-03f, -4.19662520e-02f, 2.91035860e-03f, -7.89724141e-02f,
  1.27159297e-01f, 4.52294201e-02f, 1.36738792e-01f, -7.30826259e-02f, -2.67263744e-02f, 2.34893300e-02f, 1.08405739e-01f, -3.47755440e-02f, 2.33465493e-01f, -3.88723686e-02f,
  -1.45924045e-02f, 1.84700668e-01f, -1.74026772e-01f, -8.52254629e-02f, -2.27577277e-02f, 2.04773657e-02f, 4.41920608e-02f, -5.24735488e-02f, -2.37704128e-01f, -8.17486793e-02f,
  6.81414679e-02f, 1.15072221e-01f, -2.75880955e-02f, -5.60275055e-02f, -1.40450656e-01f, 5.46447597e-02f, -1.24136485e-01f, 4.29708734e-02f, -4.85174023e-02f, 1.40774012e-01f,
  -2.12591887e-01f, -9.58665237e-02f, -8.93637985e-02f, -5.65565610e-03f, 1.32844374e-01f, -1.06564872e-01f, 2.21472621e-01f, 2.77101547e-01f, 3.60552012e-03f, 1.69345155e-01f,
  1.31413862e-01f, 7.78054260e-03f, -1.11254424e-01f, -7.19815791e-02f, 1.70409173e-01f, -1.40559688e-01f, -5.47187310e-03f, 5.66021204e-02f, -5.70339970e-02f, 4.14666953e-03f,
  2.31127087e-02f, -5.02657369e-02f, 2.18521990e-02f, 7.60404542e-02f, -7.92311579e-02f, -8.55108351e-02f, -7.99217597e-02f, -6.05195053e-02f, 1.72192995e-02f, 7.38468543e-02f,
  1.40718281e-01f, -4.50290181e-03f, -1.04114383e-01f, 8.94414559e-02f, -9.64524969e-02f, 3.79589945e-02f, 1.84193805e-01f, 2.04097956e-01f, -6.03942089e-02f, -5.56380413e-02f,
  -1.00635320e-01f, -7.70962760e-02f, 1.32205471e-01f, 2.54364938e-01f, -5.99830337e-02f, 1.28328636e-01f, -7.48541355e-02f, -6.53795600e-02f, 9.22339708e-02f, -7.29866549e-02f,
  4.63397056e-02f, -1.20406821e-01f, -5.37764281e-02f, 9.31658074e-02f, 7.62024224e-02f, -1.96438342e-01f, -4.54932526e-02f, -1.20184831e-01f, -1.18472204e-01f, -2.56983861e-02f,
  -4.79860455e-02f, 6.25461191e-02f, -6.13362305e-02f, -6.38298839e-02f, -3.74240689e-02f, -9.31343213e-02f, 4.36664335e-02f, -1.22342713e-01f, -1.48937600e-02f, 8.26804712e-03f,
  9.77800880e-03f, 1.67171329e-01f, -3.46495472e-02f, 4.76147467e-03f, 9.21739712e-02f, -1.15747705e-01f, -3.41276685e-03f, -2.60138027e-02f, 8.30092728e-02f, -1.12584032e-01f,
  1.72713131e-01f, -5.11791781e-02f, 1.06163308e-01f, -1.22672983e-01f, 1.05164737e-01f, 3.83393876e-02f, 4.37031724e-02f, 7.84508660e-02f, 1.45441413e-01f, -7.96854049e-02f,
  5.47500048e-03f, 5.26877418e-02f, 9.37712863e-02f, -8.86827782e-02f, 1.49088595e-02f, -6.38327152e-02f, -3.82521451e-02f, -5.88267744e-02f, 1.06752142e-01f, -5.43487109e-02f,
  6.28472939e-02f, 1.27593070e-01f, -5.82998991e-02f, -4.99128476e-02f, 9.29369703e-02f, -3.94488424e-02f, -3.05116996e-02f, 1.01805761e-01f, 6.10648170e-02f, 1.48192808e-01f,
  -6.50508553e-02f, 1.18890358e-02f, 2.62420904e-02f, 1.59603238e-01f, -9.08077210e-02f, -6.62836283e-02f, 1.22323416e-01f, 2.31230282e-03f, 1.81094706e-01f, -1.18625633e-01f,
  -5.50654717e-03f, 4.77138441e-03f, -3.13917408e-03f, 3.08556017e-02f, -2.42349785e-02f, -1.16624407e-01f, 5.18265963e-02f, 4.40786639e-03f, -4.62614149e-02f, -4.60168123e-02f,
  -2.49115303e-01f, 5.68558611e-02f, 1.42567530e-02f, -1.80224419e-01f, -7.16384919e-03f, 4.99492317e-01f, 1.53904408e-01f, 1.44845203e-01f, -1.33363008e-01f, -7.87081867e-02f,
  1.15083881e-01f, -1.10440634e-01f, -1.66901108e-02f, -1.30446523e-01f, -6.08994290e-02f, 4.79536466e-02f, -1.90373048e-01f, 1.99077606e-01f, 9.35671702e-02f, -5.82563169e-02f,
  8.63226503e-02f, -9.86068621e-02f, 8.08177516e-02f, 8.57134089e-02f, 1.45303279e-01f, -7.93531835e-02f, -7.82915279e-02f, 6.19660169e-02f, -8.94106776e-02f, 4.27120589e-02f,
  6.98331045e-03f, -2.91649364e-02f, 5.30216843e-04f, 4.92962310e-03f, 7.93372989e-02f, -5.65616824e-02f, 1.57201234e-02f, -1.35665372e-01f, 2.68836647e-01f, -4.23118845e-02f,
  -3.52374129e-02f, -1.91311792e-01f, -3.91053818e-02f, 1.70792446e-01f, 2.35372126e-01f, -2.87809242e-02f, 6.28194539e-03f, 9.08103511e-02f, 1.20484211e-01f, 1.42018422e-01f,
  2.87027687e-01f, 1.42150611e-01f, 2.35830620e-01f, 1.27241418e-01f, 1.15990996e-01f, 2.17278272e-01f, 1.09905913e-01f, -3.70686911e-02f, 2.66069531e-01f, -1.69527099e-01f,
  -7.98903629e-02f, 5.92591278e-02f, 3.66797224e-02f, 7.57027045e-02f, 3.39771900e-03f, 2.39870876e-01f, -1.76620334e-01f, -1.53359413e-01f, -1.29254431e-01f, 2.68299311e-01f,
  5.49126826e-02f, -1.36754736e-01f, 8.82150382e-02f, -8.27322230e-02f, 1.67591274e-01f, 4.33032075e-03f, 3.64373699e-02f, 5.27967550e-02f, -1.30295277e-01f, 2.36015603e-01f,
  -1.39902130e-01f, 1.19954735e-01f, -4.68079299e-02f, -4.81122658e-02f, 2.34279320e-01f, 6.48256317e-02f, 1.21917883e-02f, -1.11229405e-01f, 1.00340387e-02f, 4.84779999e-02f,
  -1.26131341e-01f, 1.34127438e-01f, -7.18361735e-02f, 9.12590995e-02f, -4.10454869e-02f, -1.05859824e-01f, -8.66661295e-02f, -1.76510632e-01f, 1.79340512e-01f, -1.00666463e-01f,
  -7.18459487e-02f, -1.22529663e-01f, 2.62689173e-01f, -5.94253540e-02f, -1.74467579e-01f, -1.99188873e-01f, -3.83471362e-02f, -1.93225108e-02f, 7.64281303e-02f, 1.73922196e-01f,
  2.84388475e-02f, 1.12332858e-01f, 8.55311826e-02f, -1.25454605e-01f, 1.73173752e-02f, 8.08280334e-02f, 1.96356981e-04f, -1.24215536e-01f, 2.96593476e-02f, 6.23650737e-02f,
  3.46426899e-03f, 5.20590357e-02f, 9.77205560e-02f, 1.92283422e-01f, 5.84121272e-02f, 5.21618389e-02f, 1.20623320e-01f, -1.14523761e-01f, 2.04373226e-02f, 1.26878694e-02f,
  -2.12383885e-02f, -8.94852355e-02f, 2.51287282e-01f, 2.17717290e-02f, -1.00783899e-01f, -6.79317862e-02f, -7.92942643e-02f, 1.34347796e-01f, 3.85493226e-02f, -7.78239742e-02f,
  4.12968583e-02f, 4.86583868e-03f, 1.25919819e-01f, -1.61815301e-01f, 8.79992247e-02f, -1.43430322e-01f, -5.02356840e-03f, 5.22661172e-02f, 2.15219911e-02f, 6.18217438e-02f,
  3.25109402e-04f, -5.89348152e-02f, 2.04670936e-01f, 4.51447815e-02f, 1.93698891e-02f, -8.83345678e-02f, 4.26113047e-02f, 5.35921343e-02f, -2.17127927e-05f, -8.89490172e-02f,
  -1.05626881e-01f, -1.22194119e-01f, -1.05338067e-01f, 1.32030705e-02f, -3.12154647e-02f, -8.54410678e-02f, 3.94051969e-02f, -3.89220826e-02f, 1.72123890e-02f, 1.49623631e-03f,
  -9.43816975e-02f, 1.79684937e-01f, 7.44925439e-02f, 1.54827060e-02f, -1.28077701e-01f, 9.02887061e-02f, -8.40130299e-02f, -2.49697808e-02f, -7.11126402e-02f, 5.15287407e-02f,
  -6.28121495e-02f, -1.14975952e-01f, 1.22314140e-01f, -7.95630962e-02f, -1.09909333e-01f, 1.24526478e-01f, 1.39356345e-01f, -1.41915783e-01f, -4.13033664e-02f, -3.01368106e-02f,
  -1.31538555e-01f, -1.08561419e-01f, 9.02117114e-04f, -1.42353520e-01f, -1.01498947e-01f, -4.16894406e-02f, -1.26849756e-01f, 2.18854457e-01f, 5.35408817e-02f, 2.34315678e-01f,
  -7.61392415e-02f, -8.26935396e-02f, 7.56733492e-02f, -6.65485859e-02f, -1.14058696e-01f, 1.55962765e-01f, -1.16539188e-02f, 1.37781069e-01f, -2.18883619e-01f, 1.77432314e-01f,
  8.43057334e-02f, -1.21282138e-01f, 1.56964734e-01f, 1.37814820e-01f, 3.44046652e-02f, -9.97640938e-02f, -6.47799075e-02f, -7.57736340e-02f, -1.18959308e-01f, -1.13880090e-01f,
  2.83209205e-01f, -6.75968006e-02f, -1.32538266e-02f, 3.50781134e-03f, 1.63106933e-01f, -1.54019281e-01f, 1.99252859e-01f, -8.03118665e-03f, 1.35933861e-01f, -2.64822990e-02f,
  8.53207111e-02f, -1.19244151e-01f, -1.76096976e-01f, 5.42345680e-02f, 1.07594743e-01f, 2.14948803e-01f, 1.99531421e-01f, 2.75912821e-01f, 1.71048254e-01f, 1.61326408e-01f,
  2.92642623e-01f, 2.39506379e-01f, 1.74229458e-01f, 2.86842376e-01f, 2.23950855e-02f, 1.19050458e-01f, 7.61678442e-02f, 2.33122185e-01f, -8.41382369e-02f, 8.21956992e-02f,
  -1.98356152e-01f, 1.86909139e-01f, -1.01717906e-02f, 2.30423864e-02f, -2.38873109e-01f, -1.69971213e-01f, 3.41675699e-01f, -4.37349752e-02f, -5.95276691e-02f, -1.54285803e-01f,
  1.16401106e-01f, -1.14045471e-01f, -1.22136503e-01f, 4.90510464e-01f, -1.00164615e-01f, 2.23747060e-01f, 1.57064140e-01f, 3.31162028e-02f, -8.91072303e-02f, 1.97776079e-01f,
  -3.78008746e-02f, -1.96500808e-01f, 2.68352598e-01f, -1.37383908e-01f, 8.79846215e-02f, 5.31397760e-02f, 3.15242894e-02f, 9.64188948e-02f, -1.42999247e-01f, 7.18750700e-04f,
  1.31325662e-01f, 2.45181248e-02f, 1.01783589e-01f, -1.55596837e-01f, 5.85282266e-01f, 1.95111960e-01f, -1.29696280e-01f, -3.69283818e-02f, 1.85720459e-01f, -1.13190152e-01f,
  -6.66464642e-02f, -7.59740993e-02f, 6.78580999e-02f, -4.39669676e-02f, -2.61237711e-01f, 1.07249856e-01f, -1.76163018e-01f, 5.35419099e-02f, -8.16361159e-02f, 5.06576300e-01f,
  -9.11483243e-02f, 2.63279155e-02f, -5.92375314e-03f, 7.74926692e-02f, 8.76246393e-02f, 2.52668536e-03f, 1.27695113e-01f, -1.70009714e-02f, -9.40676630e-02f, -2.90162675e-02f,
  8.60228091e-02f, -7.02140853e-02f, 8.34911913e-02f, 1.81597143e-01f, -1.58550233e-01f, 9.39061418e-02f, -3.41785289e-02f, 7.19421580e-02f, -3.60381156e-02f, -1.46564975e-01f,
  -9.58752111e-02f, -3.45708430e-02f, -3.70432921e-02f, -2.08403096e-01f, -1.79331645e-01f, 1.05050653e-01f, -1.87944248e-02f, 1.96718767e-01f, -1.59264132e-01f, 3.15436386e-02f,
  1.95951670e-01f, 1.17417090e-01f, -1.93961468e-02f, 8.63906369e-02f, 1.01691768e-01f, -2.30620932e-02f, -4.76972200e-02f, 5.85009567e-02f, 9.02218819e-02f, -8.15652385e-02f,
  7.09096715e-02f, 1.08769014e-01f, 5.65157197e-02f, 8.94484073e-02f, -1.25654752e-03f, -3.74396294e-02f, -8.50270316e-02f, -2.80791037e-02f, 2.05990702e-01f, 2.24458482e-02f,
  3.19575481e-02f, -2.29004696e-02f, 1.84558183e-01f, -1.42563790e-01f, -9.27075744e-03f, 5.52679338e-02f, -9.09128264e-02f, 5.28440885e-02f, 1.04459890e-04f, 7.24864230e-02f,
  -2.28402182e-01f, -9.65167508e-02f, 5.73400669e-02f, 1.18897818e-01f, -4.83582132e-02f, -5.51339984e-02f, -5.63592725e-02f, -1.32809728e-02f, 8.51154700e-02f, 1.34243250e-01f,
  -6.23848177e-02f, -8.23572464e-03f, -4.40382659e-02f, -2.54978985e-02f, 6.14076033e-02f, 1.39785662e-01f, -6.48673996e-02f, -8.30721781e-02f, -1.27918378e-01f, -1.32383212e-01f,
  -8.65153745e-02f, 1.27684265e-01f, -1.33934841e-01f, 8.55893418e-02f, -4.55188230e-02f, -4.97191725e-03f, -2.34090490e-03f, -3.03516667e-02f, -4.78615016e-02f, 7.30230063e-02f,
  1.60999760e-01f, 1.90813914e-01f, 9.24876854e-02f, 7.59292319e-02f, -8.36478081e-03f, -9.84381139e-02f, 1.45011321e-01f, 8.08431730e-02f, -1.10430464e-01f, 8.91217403e-03f,
  3.84834558e-02f, -7.55766481e-02f, 1.01771161e-01f, 1.10587902e-01f, -1.05679147e-01f, -6.78396598e-02f, -6.61576688e-02f, 1.55054322e-02f, -9.95146036e-02f, 7.59433061e-02f,
  1.32847890e-01f, 3.37311104e-02f, -9.99111608e-02f, 1.13039494e-01f, -5.65814711e-02f, -5.11804372e-02f, -7.46050179e-02f, -3.31442840e-02f, 3.71007957e-02f, -3.81744392e-02f,
  -8.64552408e-02f, 2.01350506e-02f, 1.39228821e-01f, -1.40648698e-02f, 1.68851778e-01f, 9.92411971e-02f, -1.33577228e-01f, 1.11207545e-01f, 3.98509689e-02f, 2.26331308e-01f,
  8.62442032e-02f, 8.77652913e-02f, 6.49651065e-02f, 1.87602565e-01f, 6.15075305e-02f, 1.17171600e-01f, -3.80631983e-02f, 1.02844909e-01f, 7.53211826e-02f, 2.18977213e-01f,
  1.01845786e-01f, -3.09655443e-02f, -3.31812128e-02f, -4.65048961e-02f, 1.74270883e-01f, 3.47035676e-02f, -5.40543497e-02f, 1.29672093e-02f, 2.57236987e-01f, -1.52767122e-01f,
  4.91777807e-02f, 1.72238618e-01f, 1.40361965e-01f, -2.06347242e-01f, -1.11692980e-01f, 2.11833522e-01f, 5.87929366e-03f, 1.73268884e-01f, -1.08414374e-01f, -9.90494490e-02f,
  1.22104935e-01f, -3.62715796e-02f, -1.34667039e-01f, 2.40052026e-03f, 2.28147134e-01f, 2.27763932e-02f, -1.17695086e-01f, 2.64035687e-02f, -3.14213079e-03f, 1.41839273e-02f,
  -9.48774219e-02f, 5.71454950e-02f, 6.48489743e-02f, -3.87124456e-02f, -9.15093794e-02f, -5.86625561e-02f, 4.33224626e-02f, -7.37172179e-03f, 5.16264476e-02f, -1.25868618e-01f,
  -7.11702630e-02f, 2.60008983e-02f, -1.27495781e-01f, 1.03081234e-01f, 8.45747739e-02f, 1.17274553e-01f, -1.21179614e-02f, 1.26723453e-01f, 2.45615467e-01f, 5.20896874e-02f,
  -3.99954095e-02f, 5.83099239e-02f, 1.61526367e-01f, 3.29086542e-01f, 1.59187421e-01f, 1.49000868e-01f, 1.53110787e-01f, 1.27052113e-01f, 2.47177869e-01f, 1.74596697e-01f,
  1.97219089e-01f, -8.64299387e-02f, -1.11455461e-02f, 1.91453606e-01f, -1.24631179e-02f, -7.90948346e-02f, 1.77920580e-01f, -6.12974539e-02f, 1.34403156e-02f, 1.21184245e-01f,
  -2.83288360e-01f, -3.94770764e-02f, -3.04767221e-01f, 3.53412032e-01f, -1.00996785e-01f, 2.20834315e-01f, -1.29032731e-02f, 9.83217120e-01f, 1.78260878e-01f, -1.13982208e-01f,
  9.33904573e-02f, 6.76169917e-02f, -1.13831885e-01f, -1.67188607e-02f, 3.03092152e-01f, -1.00196339e-01f, 1.95422322e-02f, 2.74605496e-04f, 4.86281030e-02f, -2.73744762e-02f,
  -1.15951866e-01f, -2.68317964e-02f, 3.50293443e-02f, -5.01734912e-02f, 2.33103067e-01f, -5.14163263e-02f, 1.78467974e-01f, 1.08272865e-01f, 2.27736726e-01f, 4.03768986e-01f,
  -1.75152004e-01f, 9.39658433e-02f, 1.65071800e-01f, -1.19211607e-01f, -1.64071381e-01f, 8.65889564e-02f, 9.95060951e-02f, 1.64287418e-01f, -7.46141225e-02f, 4.32420336e-02f,
  2.24127650e-01f, -8.37805718e-02f, 1.56986088e-01f, 1.60055775e-02f, -7.79276490e-02f, -1.51333660e-01f, -1.11707531e-01f, -3.27123851e-02f, -1.04730822e-01f, 4.74190824e-02f,
  -2.65701432e-02f, -1.08214058e-01f, -1.21713519e-01f, -3.33931744e-02f, -1.31223956e-02f, -3.33933234e-02f, -1.91244520e-02f, -4.49816212e-02f, 4.47815880e-02f, 7.53506050e-02f,
  5.89814484e-02f, 1.13302590e-02f, 6.83163758e-03f, 5.68991117e-02f, -1.14169881e-01f, -1.43852904e-02f, 4.19720672e-02f, 3.43168601e-02f, 5.67412097e-03f, 6.57775104e-02f,
  6.13684580e-02f, -1.15254894e-01f, -6.14712425e-02f, -8.33239332e-02f, 1.01221055e-01f, -1.01825021e-01f, 1.03939518e-01f, 8.45890194e-02f, -7.30501935e-02f, 6.34194613e-02f,
  -8.80155154e-03f, 3.44440229e-02f, -1.15986645e-01f, -1.87442731e-02f, 6.90131709e-02f, 6.85029253e-02f, 2.36511491e-02f, -9.51560959e-02f, 9.00728069e-03f, 5.69862034e-03f,
  8.52637589e-02f, -1.02274150e-01f, 8.46999362e-02f, -7.91112892e-03f, -4.50118370e-02f, -9.81204659e-02f, 4.72455733e-02f, 7.45007247e-02f, -7.65235648e-02f, 9.57666561e-02f,
  -4.93757538e-02f, -7.72608593e-02f, 8.15574974e-02f, -6.55300692e-02f, 1.11249054e-03f, -3.88433635e-02f, -1.01269595e-01f, -1.09289184e-01f, 2.34202878e-03f, -5.78279532e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  1.00251317e-01f, -6.69815838e-02f, 2.13296592e-01f, 1.28366172e-01f, 1.35615259e-01f, 1.98362052e-01f, 2.19772369e-01f, 4.72046137e-02f, -3.42479572e-02f, 1.33204460e-01f,
  9.18857381e-02f, -2.76515298e-02f, -1.40377088e-02f, -5.09023927e-02f, 2.60515176e-02f, -8.21519718e-02f, -8.80430266e-02f, 8.52025971e-02f, -7.92574137e-02f, 1.13790192e-01f,
  -1.21074416e-01f, 1.16751753e-01f, -8.58540982e-02f, 6.38097376e-02f, 1.43719286e-01f, -8.44280198e-02f, 5.00102825e-02f, -9.13751200e-02f, 1.03435628e-01f, -3.70240770e-02f,
  7.82241523e-02f, 1.92269832e-02f, 1.21809512e-01f, 7.57737160e-02f, 1.04795106e-01f, -6.55336156e-02f, -4.94476967e-02f, 1.77057594e-01f, 1.50440305e-01f, -2.44896989e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.50245761e-02f, -5.42606972e-02f, -9.42034498e-02f, -4.80364889e-01f, -9.80419666e-02f, -1.44548938e-01f, -8.18250477e-02f, 6.48597702e-02f, -1.67001691e-02f, -1.16450965e-01f,
  -2.80117273e-01f, 1.30740315e-01f, -1.67419329e-01f, -1.86183572e-01f, -3.81758958e-02f, -1.12955868e-01f, 6.78220391e-02f, -4.49870974e-01f, 1.49585441e-01f, -1.53220460e-01f,
  -3.52579951e-02f, 5.73350750e-02f, -4.02541429e-01f, 5.55700362e-02f, 2.38224208e-01f, 6.61526322e-02f, -1.34446949e-01f, -2.07023904e-01f, -8.10834542e-02f, 1.68120250e-01f,
  -2.61880964e-01f, -6.96197059e-03f, 1.11596398e-01f, 2.57868264e-02f, 2.86986940e-02f, -3.41644548e-02f, -1.42271984e-02f, -1.41350120e-01f, -2.46626996e-02f, 3.54629345e-02f,
  1.83924399e-02f, 9.94637907e-02f, -4.55532819e-02f, 4.59556095e-02f, 3.60377915e-02f, -2.02032134e-01f, -8.03516954e-02f, -1.75308827e-02f, -2.97834575e-02f, 2.89273143e-01f,
  -2.05186699e-02f, 1.07120089e-01f, -1.37166724e-01f, 8.77582356e-02f, -1.16837546e-01f, -2.47835085e-01f, -1.41030893e-01f, 4.15065676e-01f, 5.55766523e-01f, 4.25196409e-01f,
  -9.09207985e-02f, -1.09335236e-01f, -5.80823779e-01f, -9.37723890e-02f, -1.95043027e-01f, -1.62426353e-01f, 1.48786977e-01f, -1.37289703e-01f, -8.54188353e-02f, 2.08900601e-01f,
  2.62452401e-02f, -3.41382533e-01f, -4.21697572e-02f, 1.87963575e-01f, 1.83906272e-01f, -2.81443208e-01f, -2.49116912e-01f, 4.63755354e-02f, -2.46154413e-01f, -2.69961268e-01f,
  2.20968187e-01f, -9.68111977e-02f, -1.81627495e-03f, 1.66024610e-01f, 1.80538997e-01f, 6.91767931e-02f, -3.47492158e-01f, -1.28813952e-01f, 1.78926483e-01f, 6.23303726e-02f,
  -3.00093830e-01f, -1.75796002e-01f, -4.16126475e-02f, -1.72421858e-02f, 9.65215638e-02f, 9.56036821e-02f, 1.25815973e-01f, 2.88995266e-01f, 1.23890072e-01f, -2.13605374e-01f,
  2.31348619e-01f, 1.13215288e-02f, 1.76889643e-01f, -7.86334947e-02f, 6.52230578e-03f, 4.65981007e-01f, -1.30767543e-02f, -1.55052736e-01f, -6.85917065e-02f, 1.61984533e-01f,
  -6.16668426e-02f, 2.14741692e-01f, -1.07903346e-01f, 7.41134211e-02f, -9.09136012e-02f, 1.81984439e-01f, 2.79231191e-01f, 5.32600097e-02f, -5.52209392e-02f, -1.46407962e-01f,
  3.73652317e-02f, 6.30219206e-02f, 1.73387975e-01f, -2.24683389e-01f, 2.25898355e-01f, 2.30919346e-01f, -5.31824648e-01f, -8.86091664e-02f, -1.73893005e-01f, 1.08850554e-01f,
  1.64635167e-01f, -9.37990993e-02f, 7.42771402e-02f, -1.04055725e-01f, 8.31437260e-02f, 1.55862004e-01f, 2.45249823e-01f, 4.72160690e-02f, -1.86197758e-01f, -1.04242414e-01f,
  3.74901026e-01f, -1.04139805e-01f, 3.56860131e-01f, 3.28152210e-01f, -1.41695097e-01f, 1.93410620e-01f, 4.33878750e-02f, 1.49942219e-01f, -1.51301697e-01f, -2.96345413e-01f,
  4.71713811e-01f, -4.97496724e-02f, -4.06376086e-02f, 3.24003585e-03f, -1.03504822e-01f, 5.23708016e-02f, 8.34990740e-02f, -1.82160914e-01f, 2.98144698e-01f, -4.05865125e-02f,
  7.71332756e-02f, 9.90327671e-02f, 9.19487502e-04f, 3.20658118e-01f, 1.67761996e-01f, -9.44371521e-02f, 1.19797131e-02f, 9.82297957e-02f, -1.06619135e-01f, 1.46920100e-01f,
  -6.91611469e-02f, 1.18470818e-01f, -1.12514481e-01f, -7.39567205e-02f, 1.16297893e-01f, -2.59702116e-01f, -7.31390947e-03f, 3.92579548e-02f, -1.23036481e-01f, 1.29620835e-01f,
  -7.72277191e-02f, -4.20723483e-02f, -8.02904069e-02f, -8.73520449e-02f, -2.74950653e-01f, -2.66029090e-01f, -2.33595416e-01f, -1.17512599e-01f, 2.46129215e-01f, 1.14102982e-01f,
  5.60114682e-01f, -1.06814593e-01f, 7.83039033e-02f, -3.12785208e-02f, -1.16219833e-01f, 1.34151608e-01f, 2.09747732e-01f, 2.40186065e-01f, 4.46213186e-02f, 8.32985342e-03f,
  1.20511934e-01f, -3.29110492e-03f, -2.30473112e-02f, 2.38040499e-02f, -3.77358377e-01f, -2.66130745e-01f, -8.92095789e-02f, -3.13573867e-01f, -8.77060294e-02f, -8.68470222e-02f,
  2.38351762e-01f, -1.92466393e-01f, -2.86174536e-01f, 2.56925821e-01f, -4.86556321e-01f, 1.67090103e-01f, -8.44689906e-02f, 6.07018471e-02f, 3.02103579e-01f, 3.80526818e-02f,
  -2.11493224e-01f, 8.78692567e-02f, 1.81672528e-01f, -1.31709486e-01f, -3.35014835e-02f, 1.59421325e-01f, 6.81984946e-02f, -1.66892454e-01f, -4.84500751e-02f, 5.59845492e-02f,
  -6.85518309e-02f, 9.10524502e-02f, -8.49319175e-02f, -4.24948424e-01f, -1.11643061e-01f, 1.33030176e-01f, -1.11981630e-01f, -2.55520105e-01f, -9.70032290e-02f, -1.36847094e-01f,
  1.23155810e-01f, 1.56904206e-01f, -1.46435038e-03f, -2.58152902e-01f, -2.88448006e-01f, -1.01907916e-01f, -2.57388830e-01f, -2.32276320e-01f, 1.47722051e-01f, -9.21226107e-03f,
  6.64934874e-01f, -6.23214431e-03f, -6.64447621e-02f, 4.17355150e-01f, -7.30767667e-01f, 2.62101628e-02f, 1.14066564e-01f, 3.16380225e-02f, 1.78319290e-01f, 2.61152476e-01f,
  1.31561890e-01f, 2.62117535e-01f, 2.60797471e-01f, 1.06501512e-01f, 1.66929096e-01f, 2.44932041e-01f, 2.59291410e-01f, 2.99295753e-01f, -1.14910968e-01f, -1.46987200e-01f,
  -1.86310828e-01f, 1.17122464e-01f, 1.29783452e-01f, 1.45273879e-01f, 1.44097298e-01f, -7.55418539e-02f, -1.04703091e-01f, -1.64453194e-01f, 1.42345363e-02f, 1.08213373e-01f,
  -1.55786751e-02f, 7.26655405e-03f, 2.97165722e-01f, 3.78384471e-01f, 2.73240000e-01f, -7.77518302e-02f, -3.77098948e-01f, -9.42566171e-02f, 1.96858658e-03f, 1.04350001e-01f,
  5.77282198e-02f, 3.38232145e-02f, 7.21236095e-02f, -1.07513770e-01f, -7.68503919e-02f, 1.20566068e-02f, -1.76743999e-01f, -3.70715439e-01f, 1.90695032e-01f, 8.05272758e-02f,
  2.81004012e-02f, -1.28249422e-01f, -1.37092158e-01f, -1.60883680e-01f, -9.61153582e-02f, -1.28752440e-01f, 2.77769901e-02f, -1.17125466e-01f, 7.79189840e-02f, -9.37766582e-02f,
  1.61462858e-01f, 2.91012406e-01f, -3.68992649e-02f, 2.44630426e-01f, 4.04779524e-01f, 1.17569134e-01f, 3.47833261e-02f, -1.34181902e-02f, 5.02187423e-02f, 2.23802030e-02f,
  3.19731861e-01f, 7.68251121e-02f, 3.03389251e-01f, 2.26173013e-01f, -7.03440607e-02f, -3.98123264e-02f, 2.41259229e-03f, 1.38720414e-02f, -1.06716029e-01f, 1.04946986e-01f,
  6.14434890e-02f, -5.61735556e-02f, -2.56505400e-01f, 9.70654413e-02f, 1.66682571e-01f, -2.85634160e-01f, 2.16848686e-01f, 2.25111634e-01f, -8.64218622e-02f, 2.06637323e-01f,
  3.27094197e-01f, -3.70981187e-01f, 3.10744554e-01f, -1.99917763e-01f, -8.25135782e-02f, 3.98199484e-02f, -1.81271613e-01f, -2.59896785e-01f, 1.74265951e-01f, 2.22162783e-01f,
  -2.98574299e-01f, -2.39260159e-02f, 8.91934931e-02f, -1.26520365e-01f, -4.87575009e-02f, 3.09121571e-02f, -2.02401668e-01f, -1.18633464e-01f, 9.95278135e-02f, 3.21355052e-02f,
  7.90115446e-04f, 2.39365041e-01f, 1.70099244e-01f, 2.43682399e-01f, -1.38004124e-01f, 2.32513636e-01f, 4.49100249e-02f, 2.82256931e-01f, -4.53602821e-02f, 3.20794508e-02f,
  -3.11689060e-02f, 1.75199155e-02f, -1.37138039e-01f, -8.08630418e-03f, 3.47807646e-01f, 4.59590927e-02f, 2.12957248e-01f, -6.77553117e-02f, 2.65146762e-01f, 1.76602513e-01f,
  -1.93369947e-02f, -1.84573427e-01f, 1.60820305e-01f, -9.82125327e-02f, -2.09187403e-01f, -9.32389572e-02f, -1.64992407e-01f, -1.03028215e-01f, -2.49686778e-01f, -2.17616782e-01f,
  -2.56283015e-01f, 3.24397255e-03f, -2.32141063e-01f, -2.97157496e-01f, -1.37732238e-01f, -1.34542892e-02f, 2.10368652e-02f, 2.57979482e-01f, -2.03126818e-01f, 2.24542141e-01f,
  -1.38518959e-01f, 6.00723960e-02f, -2.93765098e-01f, 5.45131490e-02f, 1.57355562e-01f, 2.43353277e-01f, -1.77753896e-01f, -2.43989363e-01f, -4.20158356e-02f, 7.82357305e-02f,
  7.46534169e-02f, -3.66783559e-01f, -7.95423612e-02f, -9.30911116e-03f, -4.72642742e-02f, 2.17942357e-01f, -4.35018837e-02f, -2.97355801e-01f, -2.96105407e-02f, 2.68484559e-02f,
  -1.44078329e-01f, -1.37048587e-02f, -1.28036082e-01f, -6.37958348e-02f, 1.10528491e-01f, -1.15128741e-01f, -1.21768471e-02f, 5.36325090e-02f, 6.30041361e-02f, -7.02026412e-02f,
  1.24808416e-01f, -2.04402223e-01f, -7.21366182e-02f, -1.04576208e-01f, 6.38863221e-02f, 2.79293377e-02f, -1.74115505e-02f, 9.44965482e-02f, 3.16457301e-01f, 1.98152721e-01f,
  -1.72292903e-01f, 1.02527939e-01f, -5.81023097e-01f, -1.22521333e-01f, 1.55525148e-01f, -6.36767596e-02f, 6.78036153e-01f, -1.48843434e-02f, 4.32078168e-02f, 1.06945269e-01f,
  3.35608363e-01f, 1.19026296e-01f, 2.52668321e-01f, 1.59749746e-01f, 1.90059487e-02f, 2.29788363e-01f, 1.59674734e-01f, 2.21162349e-01f, 1.78619474e-01f, 1.15427814e-01f,
  2.96005279e-01f, 1.39630288e-01f, -1.35325864e-01f, 5.18151999e-01f, -2.94461399e-01f, 3.01515937e-01f, 2.73618430e-01f, -3.07404816e-01f, -1.83078825e-01f, 2.94078905e-02f,
  -3.74828756e-01f, 1.41386449e-01f, 3.82628553e-02f, 1.43374413e-01f, 1.06258936e-01f, 7.29902506e-01f, -3.01010311e-02f, 2.26463735e-01f, 5.80448210e-01f, 7.09954873e-02f,
  -1.10053994e-01f, -3.29431504e-01f, 5.98268062e-02f, -9.71515570e-03f, -1.91062286e-01f, 5.11702485e-02f, -1.22094549e-01f, -1.41525969e-01f, -9.98233184e-02f, -2.34054074e-01f,
  -9.83962510e-03f, -1.20730020e-01f, -7.27088898e-02f, -1.31266862e-01f, -2.01931491e-01f, -5.72663136e-02f, 3.69255841e-02f, -1.88390493e-01f, 1.10782115e-02f, -1.37332931e-01f,
  -2.66280055e-01f, -1.73103809e-01f, -1.60499290e-01f, 4.35344309e-01f, 8.21115822e-03f, -3.82746235e-02f, -1.27125993e-01f, -2.51196057e-01f, -2.36066729e-01f, -6.11465164e-02f,
  -2.15372220e-01f, -1.46323711e-01f, 6.85540168e-03f, -2.38768030e-02f, -2.30235502e-01f, 5.40202074e-02f, -8.78949240e-02f, -1.76299870e-01f, -3.03500831e-01f, -3.34718794e-01f,
  -4.90500361e-01f, -4.23275262e-01f, -1.35357395e-01f, -3.30812037e-02f, -2.56557673e-01f, -1.50594383e-01f, 2.08062485e-01f, -1.64072037e-01f, 1.79732993e-01f, 8.04691240e-02f,
  -2.84333289e-01f, -2.06048444e-01f, 1.47449374e-01f, -1.35497972e-01f, 2.85742193e-01f, 8.07352830e-03f, 2.25385606e-01f, -1.18696839e-02f, -2.29485303e-01f, -4.43640910e-02f,
  2.17254441e-02f, -1.87038958e-01f, -1.31211251e-01f, -1.49451971e-01f, 8.91771987e-02f, 1.38543636e-01f, 1.05163813e-01f, -1.93869963e-01f, 2.05279857e-01f, -1.11455128e-01f,
  -1.25879109e-01f, -1.00052528e-01f, -1.26724377e-01f, 5.23483634e-01f, -1.56629741e-01f, -1.66494176e-01f, 1.02996051e-01f, 2.08183587e-01f, 2.02947959e-01f, 2.80429304e-01f,
  -4.53953035e-02f, -5.06465435e-02f, -8.69759470e-02f, 2.69839793e-01f, 4.48144078e-01f, 4.87137064e-02f, 6.41364306e-02f, -2.65809566e-01f, -2.03200608e-01f, 8.32226425e-02f,
  -3.76457095e-01f, 2.13918812e-03f, 1.85300276e-01f, -1.54006585e-01f, -1.55871555e-01f, 2.37931255e-02f, -3.63517910e-01f, -2.08117083e-01f, -2.46808186e-01f, -1.02479212e-01f,
  -9.61108208e-02f, -3.56463194e-02f, 1.63956925e-01f, 1.50353953e-01f, -4.17307578e-02f, -2.31034353e-01f, -4.27157395e-02f, 1.18797474e-01f, 3.12809162e-02f, 3.20958912e-01f,
  3.29712689e-01f, 1.09055482e-01f, -1.22509532e-01f, 1.12555183e-01f, 5.45325167e-02f, -3.11137199e-01f, 7.50636533e-02f, -2.52038926e-01f, 4.15154785e-01f, 9.99412164e-02f,
  -8.48263353e-02f, 1.00337312e-01f, 2.47739419e-01f, 4.11775470e-01f, 2.67091125e-01f, -1.45020902e-01f, -6.80287853e-02f, -2.25337688e-02f, -4.18045595e-02f, -2.88230687e-01f,
  8.23597461e-02f, 6.90526068e-02f, -2.18815859e-02f, -5.48047386e-02f, -9.84580666e-02f, -8.97294953e-02f, -2.61422968e-03f, -4.49585050e-01f, 2.04021946e-01f, -6.42741099e-02f,
  -1.15233883e-01f, -3.15416247e-01f, -1.45685256e-01f, -4.99158427e-02f, -4.96647693e-02f, -1.90675016e-02f, 2.23458372e-02f, -2.08440244e-01f, -1.10327296e-01f, 1.88851058e-02f,
  3.11409026e-01f, 4.59072143e-01f, -1.96059912e-01f, 2.04321116e-01f, -4.84630734e-01f, 9.84991640e-02f, -2.87876036e-02f, -1.77410483e-01f, 3.57012063e-01f, 7.61997029e-02f,
  2.77928382e-01f, -2.75665540e-02f, 1.26953095e-01f, 3.05131882e-01f, 1.26949335e-02f, 2.00331584e-01f, 2.69733928e-02f, 1.37492552e-01f, 1.94665849e-01f, 9.77837890e-02f,
  4.11835194e-01f, -6.81080148e-02f, 2.36282691e-01f, -6.96381480e-02f, -7.44187310e-02f, -2.21483316e-03f, 5.12356758e-02f, 1.87469229e-01f, 2.90644288e-01f, 1.43022567e-01f,
  -7.00971037e-02f, 3.34592670e-01f, 5.94515242e-02f, -2.78932124e-01f, -4.71300185e-02f, -7.39718825e-02f, 1.97368741e-01f, -2.04595402e-01f, -1.33755967e-01f, -3.74680832e-02f,
  3.61307949e-01f, -1.12744652e-01f, -3.15259993e-02f, 3.63135755e-01f, 3.30381952e-02f, 4.24222760e-02f, -4.64024171e-02f, 1.73747122e-01f, 1.78819187e-02f, -1.29122741e-03f,
  6.60655797e-02f, -7.68634900e-02f, 7.38562318e-03f, -1.44206405e-01f, -1.39285132e-01f, 7.18064755e-02f, 1.91628411e-01f, 9.14397389e-02f, 1.46098956e-01f, -8.27192143e-02f,
  1.14979461e-01f, -2.38299474e-01f, 1.10639371e-01f, -3.50371450e-02f, -4.13493156e-01f, -3.30727726e-01f, -1.07362960e-02f, -4.13946003e-01f, 3.26605201e-01f, -1.53658301e-01f,
  8.86579007e-02f, 3.81338328e-01f, 1.34633243e-01f, -6.17964752e-02f, -1.13836281e-01f, 7.37842247e-02f, -1.39584765e-01f, 5.98860830e-02f, 1.56075522e-01f, -1.09875828e-01f,
  -2.94782937e-01f, -1.59396112e-01f, -3.30656826e-01f, -2.57681638e-01f, -5.62708117e-02f, -1.80309758e-01f, 3.58527750e-01f, 2.37623766e-01f, 2.69753970e-02f, 2.65543982e-02f,
  -9.56207439e-02f, -5.08398786e-02f, -1.65471449e-01f, -1.10203223e-02f, 2.12569624e-01f, 1.34227604e-01f, 6.96725324e-02f, 5.94591051e-02f, 1.32221356e-02f, 7.33691975e-02f,
  -3.48824531e-01f, -3.69594038e-01f, -2.61046112e-01f, 1.00276634e-01f, -6.76899329e-02f, -4.67440523e-02f, 4.81826104e-02f, -1.09115049e-01f, 2.11084876e-02f, 2.43954465e-01f,
  3.12782228e-02f, 1.21782310e-01f, 1.37475207e-01f, 9.36024413e-02f, 2.88371921e-01f, 2.05010995e-01f, -4.78892662e-02f, 1.01058409e-02f, -4.90770154e-02f, 2.12896466e-01f,
  9.93330181e-02f, 8.50107446e-02f, -2.22453959e-02f, -6.32190779e-02f, -8.13412964e-02f, -9.17774513e-02f, 2.18522921e-01f, 3.39885056e-01f, 3.10977492e-02f, -3.26662004e-01f,
  2.46821880e-01f, -1.30816787e-01f, -2.79138446e-01f, -1.01858586e-01f, -4.49645966e-02f, -2.18010738e-01f, 4.72826689e-01f, 1.10356107e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.71001102e-02f, 4.09912579e-02f, 5.62444925e-02f, 1.77569047e-01f, -3.14789102e-03f, -2.83918325e-02f, -1.41781271e-01f, 2.54169881e-01f, -3.79316695e-02f, -3.10486723e-02f,
  2.48271935e-02f, 6.52823877e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    