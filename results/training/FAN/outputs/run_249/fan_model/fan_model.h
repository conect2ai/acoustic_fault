/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.85201907e-01f, 9.00471304e-03f, 8.67342427e-02f, 3.73979747e-01f, 2.40249753e-01f, -2.80010939e-01f, -1.14880860e-01f, 2.02054694e-01f, 9.75712091e-02f, -1.38897598e-01f,
  1.08093418e-01f, -6.83208331e-02f, -2.59318590e-01f, 1.67522028e-01f, -1.47372290e-01f, -3.98680210e-01f, -7.08967261e-03f, -5.54695018e-02f, -1.20259561e-02f, 1.19593978e-01f,
  9.75999981e-02f, 5.02801649e-02f, 4.35926653e-02f, 1.38872966e-01f, 1.74655929e-01f, 2.26948529e-01f, 1.10719986e-01f, 2.51786839e-02f, 2.07405522e-01f, -4.49359417e-02f,
  -2.85993777e-02f, 5.28251082e-02f, 1.53238535e-01f, -8.85311738e-02f, 4.60330620e-02f, -3.60883609e-03f, -4.71103229e-02f, -5.65960407e-02f, 2.43318956e-02f, -1.80091392e-02f,
  -9.23120677e-02f, 1.26084452e-02f, 1.40412990e-03f, 1.75067186e-02f, 4.39404845e-02f, 6.64444342e-02f, 1.62220877e-02f, 4.24331939e-03f, 2.88316216e-02f, -6.20862329e-03f,
  6.71288371e-02f, 6.21792814e-03f, 6.38209134e-02f, -9.33543742e-02f, 6.85487762e-02f, 3.93633768e-02f, -2.34211255e-02f, -1.58703774e-02f, -3.04704234e-02f, 2.32983772e-02f,
  -1.30459145e-02f, 2.79404633e-02f, -1.58471114e-03f, 5.68872727e-02f, 1.29061639e-02f, 7.06596747e-02f, 1.33273592e-02f, -1.45514980e-02f, -5.60801884e-04f, -2.69999611e-04f,
  4.14831787e-02f, 1.83482356e-02f, 1.63232181e-02f, -1.03706094e-02f, 3.09943147e-02f, 2.33052056e-02f, -2.74588093e-02f, 1.79708209e-02f, 1.63146257e-02f, 2.45765802e-02f,
  -4.25764592e-03f, -3.91625389e-02f, 2.17189430e-03f, -2.31761970e-02f, -4.33928110e-02f, 2.12677848e-03f, 1.64707564e-02f, -1.63157715e-03f, 1.90713778e-02f, -2.22536586e-02f,
  -1.75408065e-01f, -5.12018390e-02f, 2.47773957e-02f, -1.54090859e-02f, -7.48244599e-02f, 5.98690612e-03f, -2.60582622e-02f, -3.05198599e-03f, -7.98056647e-02f, -3.53269354e-02f,
  2.64138840e-02f, 6.86435355e-03f, -2.48345155e-02f, 7.29281828e-03f, -3.60362008e-02f, -2.21993085e-02f, -2.58898130e-03f, -8.86473712e-03f, 5.39877266e-02f, 5.26215322e-02f,
  3.46582495e-02f, -5.72824404e-02f, -4.52951603e-02f, 5.86915575e-02f, -5.28647080e-02f, -2.73814611e-02f, 2.11653411e-02f, -2.43881382e-02f, -2.98549072e-04f, -3.87241095e-02f,
  1.39005989e-01f, -2.09825203e-01f, -2.38837615e-01f, -1.66629165e-01f, 1.63251996e-01f, -1.93025887e-01f, -3.15399796e-01f, -4.25335057e-02f, -7.50379935e-02f, -3.85781862e-02f,
  -9.23919678e-02f, -4.46053818e-02f, -1.65356383e-01f, -3.56243998e-01f, -3.46446335e-01f, -3.11794996e-01f, -2.92063951e-01f, -1.17452212e-01f, -1.48402294e-02f, -2.34110728e-02f,
  -4.86278348e-02f, -1.77497819e-01f, -2.61299372e-01f, 1.22216344e-01f, 3.12806331e-02f, 1.56608284e-01f, 1.24246441e-01f, 1.10141419e-01f, 5.99267744e-02f, -1.81998797e-02f,
  -1.31675620e-02f, -6.94583077e-03f, 1.81834232e-02f, -8.59613270e-02f, -5.64043783e-02f, 1.75432041e-02f, 4.56701070e-02f, 7.51870219e-03f, 2.87559461e-02f, -1.71974059e-02f,
  3.73610929e-02f, 4.56684455e-02f, -3.62140164e-02f, -1.72369778e-02f, 5.57241030e-02f, -6.31565647e-03f, -6.91282516e-03f, 2.20856853e-02f, -9.13248584e-03f, -2.19630226e-02f,
  -4.77694683e-02f, 6.18227292e-03f, 9.68288630e-03f, -4.61801700e-03f, 2.35352688e-03f, -1.98911801e-02f, -5.07557280e-02f, 4.34146263e-02f, 2.01490242e-02f, 2.47895438e-02f,
  5.56167997e-02f, 1.45090679e-02f, -1.98550615e-02f, 3.70411687e-02f, -5.23990765e-02f, 3.65570448e-02f, -1.27226338e-02f, 6.99216826e-03f, 1.07988333e-02f, -2.39381217e-03f,
  -1.93380180e-03f, -2.51077916e-02f, -5.29045844e-03f, -1.46162380e-02f, -1.39434822e-02f, 5.15143014e-02f, -4.86992579e-03f, 1.76225640e-02f, -3.51324566e-02f, -3.56262922e-02f,
  2.70330906e-02f, -1.11895911e-02f, -2.37837695e-02f, 5.26925363e-02f, -2.30134167e-02f, 8.84782150e-03f, 2.74101296e-03f, 8.71586893e-03f, 4.13805610e-05f, 1.98800601e-02f,
  -2.06760153e-01f, -7.62440488e-02f, -1.69318207e-02f, 7.59517476e-02f, -2.05927175e-02f, -4.68169563e-02f, -7.08206743e-02f, -2.21303292e-03f, -5.28061278e-02f, -2.80367900e-02f,
  4.64389026e-02f, 1.77991053e-03f, 2.34805048e-02f, 4.21186201e-02f, -1.77459617e-03f, -5.84730841e-02f, -4.46536765e-03f, 3.94396596e-02f, 1.57356150e-02f, 1.69911701e-02f,
  4.27016690e-02f, 1.78381465e-02f, 1.06032146e-02f, 3.92109097e-04f, 2.05904022e-02f, 6.50466979e-02f, 7.63777457e-03f, 9.30850022e-03f, 3.09837554e-02f, -2.29308102e-02f,
  -3.81314039e-01f, 4.39601272e-01f, 2.22450957e-01f, -8.78991634e-02f, -2.68665999e-01f, -2.91904807e-01f, -3.11974943e-01f, 5.05346991e-02f, -8.09052289e-02f, 8.58318806e-02f,
  -1.45095289e-01f, 1.00389577e-01f, 1.00121260e-01f, -1.57739606e-03f, -3.06022555e-01f, 1.38178363e-01f, -2.46949434e-01f, -1.28751129e-01f, 4.82049845e-02f, -1.23793282e-01f,
  -3.76428887e-02f, -1.54832050e-01f, 1.04111552e-01f, 5.31491674e-02f, -7.83206299e-02f, 4.41705249e-02f, -1.43131539e-01f, 1.06534310e-01f, 3.92966270e-02f, 1.02153989e-02f,
  -5.76904453e-02f, 1.84807494e-01f, 5.31664900e-02f, 5.02156913e-02f, -1.29226983e-01f, -4.78836559e-02f, -4.35852595e-02f, -1.17566492e-02f, 4.27808333e-03f, -5.56976208e-03f,
  -2.97431983e-02f, 9.85137932e-03f, 7.41241453e-03f, 6.11887947e-02f, -6.19842857e-02f, 4.25401740e-02f, 5.95564507e-02f, 1.69063471e-02f, 7.55117163e-02f, 7.89158568e-02f,
  8.79180282e-02f, 2.85598431e-02f, 1.25174392e-02f, 1.09627256e-02f, -1.14677399e-02f, 8.01259652e-03f, -2.20969934e-02f, -3.70158739e-02f, -8.42720456e-03f, -1.01018108e-01f,
  4.47513815e-03f, -9.29931700e-02f, 2.72258576e-02f, -2.85854004e-02f, 2.29439344e-02f, -5.26551977e-02f, -1.27801467e-02f, -1.94471341e-03f, -3.07807159e-02f, -6.99543431e-02f,
  -9.77930203e-02f, 1.06652519e-02f, -2.73559503e-02f, -4.76496406e-02f, -4.61357050e-02f, -5.57782501e-02f, -1.76996575e-03f, -1.84444413e-02f, -2.33103931e-02f, -2.42735557e-02f,
  3.26183625e-02f, -1.95807498e-02f, 4.49866951e-02f, 9.05779831e-04f, -1.75462086e-02f, 2.98296940e-02f, 2.34947391e-02f, 4.76352349e-02f, -2.31611039e-02f, -8.84448886e-02f,
  -3.62991065e-01f, -2.04410717e-01f, -1.96866272e-03f, -3.63567322e-02f, -4.79207300e-02f, -5.06827421e-02f, 2.20426228e-02f, 1.23417610e-02f, -1.27534813e-03f, -4.75944430e-02f,
  -4.69308533e-02f, -6.69691935e-02f, -6.55925199e-02f, -3.71089615e-02f, -2.57555190e-02f, -2.18618494e-02f, -5.30205034e-02f, -6.38596341e-02f, -1.41427696e-01f, -2.34669093e-02f,
  -3.38461213e-02f, -1.57801751e-02f, -3.98839079e-02f, -1.55034456e-02f, -4.49250303e-02f, -7.36683831e-02f, -2.35367399e-02f, 7.62904286e-02f, -2.70649139e-02f, 4.34862487e-02f,
  -1.44284129e-01f, -3.42449099e-01f, -5.79812229e-02f, 4.12773415e-02f, 1.18343875e-01f, 5.24829328e-02f, -7.24984854e-02f, 6.45555258e-02f, -3.25716525e-01f, -1.46544129e-01f,
  1.89920843e-01f, -3.58641893e-01f, -1.85216814e-02f, 7.63850659e-02f, 3.13556433e-01f, -9.54649597e-02f, 1.98756605e-01f, 5.80442809e-02f, 2.84171347e-02f, 1.30989134e-01f,
  1.66860074e-01f, 2.10287169e-01f, 2.39442259e-01f, 2.23385274e-01f, 1.41346544e-01f, -1.04129151e-01f, 2.14452654e-01f, 2.43812427e-02f, 1.66170165e-01f, -4.76241224e-02f,
  3.76184322e-02f, -1.15850933e-01f, -4.70712446e-02f, -8.93360376e-02f, 1.13268882e-01f, 4.07730788e-02f, 5.48909195e-02f, -2.01473366e-02f, 4.22204696e-02f, -3.97613421e-02f,
  -4.05201986e-02f, -8.15989636e-03f, 6.83689909e-03f, -2.74598692e-02f, -1.55800870e-02f, -2.89430888e-03f, 1.52838118e-02f, 6.04045652e-02f, -7.44994730e-02f, 2.88392641e-02f,
  -9.51098651e-03f, 2.99678203e-02f, 3.73899154e-02f, -1.26664499e-02f, 1.61709655e-02f, -2.86899265e-02f, -6.51709065e-02f, -9.25432425e-03f, -5.35563529e-02f, -2.19776817e-02f,
  -2.64758733e-03f, -8.60349450e-04f, -1.72511991e-02f, 1.99649949e-02f, -2.35140268e-02f, 3.88671383e-02f, 1.02214431e-02f, 2.14482639e-02f, -1.39752831e-02f, 9.56930500e-03f,
  1.13058966e-02f, -6.25547580e-03f, -1.23066576e-02f, -2.52218153e-02f, 1.08563909e-02f, -9.68178734e-03f, 1.22534847e-02f, -4.43900339e-02f, -5.73776243e-03f, 5.29090986e-02f,
  -2.43401919e-02f, 1.80469658e-02f, -1.91400480e-02f, 3.61701772e-02f, -1.69687271e-02f, -4.10176581e-03f, -2.40702927e-02f, -3.40059586e-02f, 4.28174399e-02f, 4.44458984e-02f,
  1.01928804e-02f, -6.96202591e-02f, -4.94083650e-02f, 2.41462886e-02f, -2.91910116e-02f, 4.86937128e-02f, 2.04142984e-02f, 2.61203060e-03f, -1.27053484e-02f, 3.32758762e-02f,
  5.60746454e-02f, 2.33197934e-03f, -2.21985020e-02f, 3.16542536e-02f, 4.02494036e-02f, -8.24026950e-03f, 1.61338635e-02f, -5.01409210e-02f, 5.31160980e-02f, 5.92260510e-02f,
  1.53037822e-02f, 2.70089265e-02f, -9.98205785e-03f, 5.91228455e-02f, 3.90083641e-02f, 3.29167023e-02f, 6.81837136e-03f, -6.89051822e-02f, 2.85493825e-02f, 2.68307189e-03f,
  -3.30841392e-01f, -1.33865416e-01f, -6.43658116e-02f, -4.36143242e-02f, 3.60377878e-01f, -7.10018277e-02f, -2.07856551e-01f, 3.14242393e-01f, 2.33669668e-01f, -1.38466433e-01f,
  1.97971433e-01f, -3.38618755e-01f, -1.31053269e-01f, 4.35306132e-02f, 5.32072559e-02f, 2.56624375e-03f, 4.08200454e-03f, -1.95933118e-01f, 1.33584484e-01f, 3.41178179e-02f,
  8.45376626e-02f, 2.49684379e-01f, -9.17231366e-02f, 3.35292041e-01f, -1.38182072e-02f, -1.22218197e-02f, 2.77482439e-02f, 2.16733608e-02f, -5.15999533e-02f, 6.83544204e-02f,
  -5.01410151e-03f, 1.28133908e-01f, -4.06171121e-02f, -2.52486784e-02f, -4.59229166e-04f, -6.29626736e-02f, -1.30626336e-01f, -7.83103183e-02f, -8.53179675e-03f, 1.87736077e-05f,
  -1.28313556e-01f, 3.07944193e-02f, 6.93620592e-02f, 5.44098355e-02f, -1.57518759e-02f, 5.92046604e-02f, 4.01373319e-02f, 4.65842411e-02f, -1.79155543e-02f, -7.04415217e-02f,
  -1.54235046e-02f, -2.51783337e-02f, 1.37114525e-02f, -6.50796667e-02f, 4.68040705e-02f, 6.06620163e-02f, -8.23118314e-02f, -7.37795308e-02f, 3.27350223e-03f, 1.53290164e-02f,
  -1.64940972e-02f, 1.71688502e-03f, -1.08038234e-02f, 1.77493300e-02f, 1.43156387e-02f, 4.62710187e-02f, 2.28656214e-02f, 5.62666263e-03f, 3.40026058e-03f, -2.02791095e-02f,
  3.66114378e-02f, 4.89362143e-02f, 5.88403568e-02f, -5.51815983e-03f, -6.83230311e-02f, -3.50262560e-02f, -2.04498544e-02f, -1.38645144e-02f, 3.72420102e-02f, 6.60580471e-02f,
  -7.43399141e-03f, 4.33012564e-03f, 2.21801791e-02f, -3.07141393e-02f, 6.16717748e-02f, 4.32694033e-02f, 2.45664082e-02f, -1.73996277e-02f, 5.85732237e-03f, -1.32261980e-02f,
  -1.24633275e-02f, 1.50711890e-02f, 2.96294447e-02f, 1.20783539e-03f, 1.45402402e-02f, 6.55012578e-02f, 2.00220966e-03f, 8.15131664e-02f, 3.05722393e-02f, 5.00810333e-02f,
  1.67009956e-03f, -2.73804390e-03f, -3.27837057e-02f, 1.43530471e-02f, 5.33831073e-03f, 3.80280316e-02f, -2.53741965e-02f, -3.95890288e-02f, 1.55881476e-02f, -2.00580973e-02f,
  -2.88967378e-02f, -1.89242996e-02f, -2.57505048e-02f, 8.18889141e-02f, -7.83776771e-03f, -5.99553436e-02f, 3.29118483e-02f, -4.57253773e-03f, -4.52483557e-02f, 8.48185550e-03f,
  1.68910846e-01f, -4.79362249e-01f, -5.84745407e-01f, -2.06231028e-01f, 2.81824172e-01f, -3.61655875e-05f, -8.73028114e-02f, -1.00466743e-01f, -7.52341561e-03f, -1.16747774e-01f,
  1.13876775e-01f, -1.51655406e-01f, -1.13058127e-01f, -1.84113413e-01f, 1.10734381e-01f, -4.87126671e-02f, -1.28872007e-01f, -3.80802676e-02f, 2.53031440e-02f, -1.35600373e-01f,
  -5.89736179e-02f, 8.46318714e-03f, -2.46569291e-01f, 7.37762377e-02f, -8.35380331e-02f, -1.05637647e-01f, 1.17494017e-01f, -2.31195055e-02f, -5.99961616e-02f, 1.11490535e-02f,
  3.24966237e-02f, -7.13663548e-02f, -1.11580640e-01f, -6.48772940e-02f, 1.35439895e-02f, 6.61461726e-02f, 5.00914059e-04f, -1.07631525e-02f, -1.80178788e-02f, -3.62383351e-02f,
  9.10260826e-02f, 2.56346390e-02f, -2.33525829e-03f, -7.88209785e-04f, 4.71567921e-02f, -7.27692544e-02f, 1.23075629e-02f, -5.52934296e-02f, -4.20576036e-02f, -1.14759048e-02f,
  -1.03383809e-01f, -2.34176163e-02f, -2.15272140e-02f, -6.54618343e-05f, -2.58550178e-02f, 1.24073750e-03f, 2.15277483e-04f, 4.33671614e-03f, 8.76500923e-03f, 5.77545613e-02f,
  1.19221129e-01f, 2.43510082e-02f, 6.45013712e-03f, -2.31612939e-02f, 5.04753105e-02f, 9.88401007e-03f, 1.32269273e-02f, 4.67898212e-02f, 2.55019609e-02f, -3.21697397e-03f,
  3.12520750e-02f, 2.19617947e-03f, 6.81293476e-03f, 1.36631390e-03f, -2.09119413e-02f, -8.50013364e-03f, 1.41087882e-02f, 1.33168902e-02f, -2.93310471e-02f, -7.15761213e-03f,
  2.42860545e-03f, 2.12203600e-02f, -3.35181616e-02f, 3.35485153e-02f, -9.95125622e-03f, -6.61809114e-04f, 2.93767098e-02f, -1.85545962e-02f, -3.37642469e-02f, 2.49487478e-02f,
  -4.58609089e-02f, -1.48873433e-01f, -5.50586879e-02f, 3.20560373e-02f, -6.28486648e-02f, 1.89253651e-02f, -2.04791408e-02f, 4.81055147e-04f, -2.59720348e-02f, 6.60863379e-03f,
  -8.86558276e-03f, -5.39562292e-03f, -1.63543911e-04f, 1.46298960e-03f, -2.26863171e-03f, 3.71989794e-02f, -1.60632934e-02f, 2.16880180e-02f, 2.17620153e-02f, -2.23560398e-03f,
  2.95502134e-02f, 4.63040322e-02f, 2.13804916e-02f, 2.10601930e-02f, 1.90634169e-02f, 1.38380434e-02f, 3.25065702e-02f, -1.57280136e-02f, 4.17035669e-02f, -5.04008159e-02f,
  4.24420595e-01f, -2.55747020e-01f, 4.23622519e-01f, 9.52196401e-03f, 3.83202657e-02f, -2.76440203e-01f, -1.69834569e-01f, -8.92038867e-02f, -9.43123456e-03f, -3.19173902e-01f,
  -2.56919384e-01f, -2.15921868e-02f, -1.22793838e-01f, -3.15160275e-01f, 7.46021196e-02f, -2.32781455e-01f, -1.05111673e-01f, -1.21731192e-01f, 5.17824367e-02f, -6.47666026e-03f,
  1.36713266e-01f, -3.07761043e-01f, 7.76615366e-02f, -2.19035774e-01f, -1.06692044e-02f, 9.69803482e-02f, 1.24941859e-02f, -1.43985888e-02f, -1.40591636e-01f, -8.14695284e-02f,
  -8.80432427e-02f, 4.75756787e-02f, 1.14626028e-01f, 7.86438137e-02f, 4.39682268e-02f, 6.49879575e-02f, 5.72342947e-02f, 2.43861303e-02f, 7.62604550e-02f, 2.07906030e-02f,
  5.30078122e-03f, 1.19260047e-03f, 1.82823709e-03f, -5.82078379e-03f, 5.76812997e-02f, 1.08092181e-01f, -2.56685987e-02f, 2.01918203e-02f, -7.22030997e-02f, -2.64314609e-03f,
  2.68944614e-02f, 1.21436380e-02f, 6.85653389e-02f, -5.14760576e-02f, 2.98557486e-02f, -9.49560665e-03f, 3.42138717e-03f, 9.00629908e-03f, -5.70010766e-02f, 9.13993828e-03f,
  -2.20845081e-02f, 5.78346141e-02f, -3.36813182e-02f, 3.63858603e-02f, -2.07914598e-03f, 2.26677395e-02f, -1.29277864e-02f, -1.24491304e-02f, 2.80082095e-02f, -6.45434298e-03f,
  -1.27392393e-02f, 3.96318659e-02f, 1.60017553e-05f, 2.60738824e-02f, 1.66417714e-02f, 1.55002391e-02f, 6.69834465e-02f, -3.68979797e-02f, 3.62442285e-02f, -8.19956698e-03f,
  -4.54891659e-03f, 6.02852507e-03f, -4.24619913e-02f, 1.98247395e-02f, -1.66569147e-02f, 6.52829632e-02f, 1.32935178e-02f, 2.90430337e-03f, 3.73019166e-02f, 3.31834666e-02f,
  -1.71112120e-01f, -1.78801179e-01f, -5.36136217e-02f, -6.71806782e-02f, -2.20852420e-02f, -8.78411811e-03f, -2.17616390e-02f, -1.07007641e-02f, -6.40330687e-02f, -1.73584577e-02f,
  4.63182926e-02f, 3.84903140e-02f, -5.56388916e-03f, 4.84956987e-03f, -4.91994657e-02f, -6.83136210e-02f, -1.00667104e-02f, 7.66061153e-03f, -9.91453417e-03f, 3.13684298e-03f,
  -3.90972681e-02f, -1.88702680e-02f, 1.38285197e-02f, -1.95191223e-02f, 4.42375476e-03f, 1.00370729e-02f, 1.39833214e-02f, 2.19541155e-02f, 9.63198487e-04f, -4.86316159e-02f,
  -6.18577480e-01f, -1.45007432e-01f, -8.67565945e-02f, -1.68472111e-01f, 1.21290907e-02f, -1.59877703e-01f, 2.74206191e-01f, -9.38210338e-02f, -1.73212290e-01f, 1.85721993e-01f,
  1.98869705e-01f, -3.23650867e-01f, 3.20628852e-01f, -4.25050929e-02f, -3.92186135e-01f, 1.66633368e-01f, -2.17715234e-01f, -3.32550742e-02f, 4.60373284e-03f, -1.40632465e-01f,
  -1.28053397e-01f, 2.77667418e-02f, 4.84971218e-02f, 1.46120237e-02f, 7.42451996e-02f, -1.19028553e-01f, 1.37568310e-01f, 1.81370214e-01f, -1.23994626e-01f, -6.61934391e-02f,
  -6.51348010e-02f, 6.69611618e-02f, 5.29932678e-02f, -1.48845632e-02f, -4.79883589e-02f, 4.22546379e-02f, -3.15170363e-02f, 1.09262951e-01f, 1.46196724e-03f, -7.19707012e-02f,
  1.04502430e-02f, -5.64775206e-02f, -1.56662121e-01f, 6.18079007e-02f, 2.72521432e-02f, -3.69495004e-02f, 5.91888651e-03f, 7.91986212e-02f, 3.07460111e-02f, 1.90555013e-03f,
  3.58813070e-02f, 2.61011273e-02f, 2.84388140e-02f, -7.96032976e-03f, -2.34554685e-03f, 2.20456291e-02f, -4.00088504e-02f, -8.49456526e-03f, -7.37956241e-02f, -7.67693743e-02f,
  2.62994412e-02f, -4.35009263e-02f, 6.83932677e-02f, -4.33863699e-03f, -1.90416165e-02f, 6.95177838e-02f, -1.04883984e-02f, 2.53141690e-02f, -3.57094705e-02f, 1.76478550e-02f,
  -5.66329733e-02f, 2.82119215e-02f, -2.65161768e-02f, 2.62369178e-02f, -4.51491307e-03f, 2.65274402e-02f, -1.33178150e-02f, -1.63878277e-02f, -5.25389165e-02f, -1.71409431e-03f,
  4.41914350e-02f, -3.54471728e-02f, -1.36087304e-02f, 4.23543975e-02f, -3.64675187e-02f, 5.08936048e-02f, 4.43446226e-02f, 2.53760554e-02f, 2.26359740e-02f, 7.57939229e-03f,
  -2.41495624e-01f, -2.49047548e-01f, 2.88872328e-03f, -1.88461971e-02f, -1.49569120e-02f, 1.86535344e-02f, -6.80344692e-03f, -5.99438474e-02f, -4.85007055e-02f, -8.27467535e-03f,
  1.62043758e-02f, 2.64602527e-02f, 1.51988436e-02f, -3.52545753e-02f, -2.78285872e-02f, 5.11705354e-02f, -3.61528189e-04f, -4.96439040e-02f, -5.35188504e-02f, -2.76472252e-02f,
  -1.47663848e-02f, -4.46681585e-03f, -1.23448223e-02f, 3.85103584e-03f, -2.17847750e-02f, -1.28964717e-02f, -8.97072479e-02f, -2.96586882e-02f, -3.69173032e-03f, -5.41827157e-02f,
  -3.90396684e-01f, 3.36021870e-01f, -2.72328436e-01f, 9.61703360e-02f, -1.45973831e-01f, -3.51902753e-01f, -3.06852996e-01f, 6.46856427e-02f, 3.18844058e-02f, 1.73381463e-01f,
  1.37852207e-01f, -8.68236832e-03f, 1.98342830e-01f, 8.70011300e-02f, -1.84911489e-01f, 9.07121450e-02f, -1.75999358e-01f, -7.23314881e-02f, 8.59955102e-02f, 2.10602228e-02f,
  4.93445247e-03f, 1.33844212e-01f, -2.91676689e-02f, 1.68270886e-01f, -1.88790530e-01f, -1.59691069e-02f, 7.23032355e-02f, 1.22849923e-03f, 1.14003368e-01f, -5.11942320e-02f,
  -4.38619256e-02f, 1.19761258e-01f, -6.06982931e-02f, -6.07728511e-02f, -1.47729859e-01f, -1.23128742e-01f, -9.84188914e-02f, -7.18143731e-02f, 7.05878623e-03f, 1.24317361e-02f,
  -2.97099631e-02f, 4.35615666e-02f, 3.38876918e-02f, -1.76164806e-02f, -3.72898839e-02f, 4.80282307e-02f, -3.63291353e-02f, -3.13135423e-02f, -6.36722939e-03f, -6.79344684e-02f,
  -4.66166958e-02f, -2.06634514e-02f, -7.41334260e-02f, 4.70364913e-02f, -2.23647784e-02f, -1.30424201e-02f, -1.51218250e-02f, -6.06891885e-02f, 4.90680803e-04f, -2.27106642e-02f,
  -3.96295413e-02f, 5.78973268e-04f, -4.55076108e-03f, 1.11079160e-02f, 4.91889343e-02f, 2.18413435e-02f, 5.21503715e-03f, 5.08849770e-02f, -5.10258786e-02f, -1.21510550e-02f,
  5.73283918e-02f, -3.55861075e-02f, 2.72979997e-02f, -3.70082222e-02f, -1.70557061e-04f, 1.21686819e-04f, 1.07316403e-02f, 7.10979849e-03f, -3.39243449e-02f, -1.89097375e-02f,
  8.39407891e-02f, -1.04257632e-02f, 2.44897921e-02f, -1.51001997e-02f, 8.67373674e-05f, -7.29791867e-03f, 3.63548137e-02f, 1.81055740e-02f, 3.46037373e-02f, -4.02483381e-02f,
  -1.83244757e-02f, 1.92898765e-01f, 5.54891415e-02f, 1.49355642e-02f, 5.56609482e-02f, -8.12714547e-03f, 5.93009703e-02f, -2.43412107e-02f, 2.94439550e-02f, -2.28333175e-02f,
  -2.39009168e-02f, -3.74892093e-02f, -8.59966949e-02f, 1.51356021e-02f, 1.52541511e-03f, -7.36065814e-03f, 2.37530638e-02f, 1.02598602e-02f, -8.08699653e-02f, 3.02221067e-02f,
  -4.11645556e-03f, -1.83070544e-02f, 5.05633578e-02f, -1.79355163e-02f, 1.49372090e-02f, -1.47576267e-02f, -5.46528623e-02f, 8.82964116e-03f, 4.72662505e-03f, -1.02176145e-02f,
  -5.94918013e-01f, 2.60308266e-01f, -1.48861900e-01f, -2.77378738e-01f, 1.27965584e-02f, -2.37175211e-01f, -3.19065899e-01f, 2.79122442e-02f, -1.24700241e-01f, 3.20131540e-01f,
  -2.84838919e-02f, -3.51643860e-02f, 9.66229662e-02f, -1.28060937e-01f, -4.29050922e-01f, 4.53737229e-02f, -2.47834891e-01f, 1.90013777e-02f, -3.98902670e-02f, 2.97239609e-02f,
  -9.87082347e-02f, -3.52491923e-02f, -1.61933318e-01f, 1.79584295e-01f, -1.43232524e-01f, -1.97298639e-02f, 1.13720469e-01f, 5.25380000e-02f, 3.29661816e-02f, 1.26941511e-02f,
  -1.27189711e-01f, 7.12554306e-02f, -9.23314411e-03f, 2.94360276e-02f, -6.10046536e-02f, 2.30291281e-02f, 2.11609453e-02f, -7.29053169e-02f, -6.47759438e-02f, -2.64939871e-02f,
  -1.66532844e-02f, -2.14911867e-02f, 7.63979787e-03f, 1.05696088e-02f, -7.54788844e-03f, -7.63362786e-03f, -3.55948717e-03f, -2.66581457e-02f, 6.47082180e-03f, -8.84070918e-02f,
  -2.71109473e-02f, 3.41901626e-03f, -2.14736722e-02f, 2.06215996e-02f, -3.27284411e-02f, -1.45899979e-02f, -4.42051552e-02f, -2.62446105e-02f, -2.91155502e-02f, -2.50314977e-02f,
  2.92063300e-02f, 4.64506308e-03f, -1.19522111e-02f, 5.90149546e-03f, -8.19774065e-03f, 3.06469910e-02f, -9.71477292e-03f, 5.79267554e-02f, -1.70199219e-02f, 1.79326087e-02f,
  -4.02911752e-02f, -2.37602368e-02f, -2.66860682e-03f, -2.23125657e-03f, -1.78117137e-02f, 4.35453560e-03f, -1.86387189e-02f, 7.17399269e-02f, -4.71569151e-02f, -3.08747552e-02f,
  1.59483822e-03f, 2.73565501e-02f, 4.73246351e-03f, -1.68839004e-02f, 1.24111699e-04f, -1.08322669e-02f, 1.63209643e-02f, 3.05965468e-02f, 5.70908189e-03f, -7.15170577e-02f,
  7.12338686e-02f, 1.97625577e-01f, 3.01908180e-02f, 5.46317659e-02f, 9.26462114e-02f, 9.15105734e-03f, -3.72063965e-02f, 3.01031694e-02f, 4.42038625e-02f, 1.87967941e-02f,
  4.38153781e-02f, 1.21545754e-02f, 1.10391034e-02f, -1.61084495e-02f, -1.86586436e-02f, 4.19571884e-02f, 1.50199542e-02f, 1.63233355e-02f, -2.11765636e-02f, 8.10379982e-02f,
  3.21960375e-02f, 9.39676631e-03f, -5.07813990e-02f, 1.24703432e-02f, 6.24281820e-03f, 1.85998138e-02f, 3.79895717e-02f, 3.77777778e-03f, 3.92701812e-02f, 5.53404130e-02f,
  1.65083185e-01f, 1.98475748e-01f, -2.12997034e-01f, 2.33038247e-01f, 9.36329458e-03f, 9.07669216e-02f, -5.00042783e-03f, 7.56189898e-02f, -9.40845609e-02f, 2.69744843e-01f,
  1.75875992e-01f, -1.02991343e-01f, -9.02109221e-02f, 3.41481507e-01f, -3.21694762e-01f, -1.16218135e-01f, 3.04190785e-01f, 1.86876774e-01f, -1.18477993e-01f, 8.27533081e-02f,
  -1.23130694e-01f, 2.74309903e-01f, -1.68521196e-01f, 7.82983601e-02f, 1.43829614e-01f, 4.85847145e-03f, 8.38043168e-03f, -2.32914224e-01f, 2.86137104e-01f, -4.75716181e-02f,
  4.40107249e-02f, 2.70799845e-02f, 1.01301476e-01f, 1.46205435e-02f, 2.23942474e-02f, 1.10222399e-01f, 7.24064857e-02f, -4.70143147e-02f, -3.98320481e-02f, 1.13098081e-02f,
  3.75862345e-02f, -2.05577407e-02f, 8.29673260e-02f, -3.73801813e-02f, 3.70083749e-02f, 6.77055679e-03f, -3.68631892e-02f, 2.31153928e-02f, -1.20937750e-02f, -1.05603514e-02f,
  -7.04776635e-03f, 6.24745786e-02f, 6.82248771e-02f, 5.73348030e-02f, -9.36794654e-02f, -1.75208889e-03f, -4.18993458e-02f, -3.47533450e-02f, 1.30979102e-02f, 4.58129682e-02f,
  3.15692984e-02f, 1.80580076e-02f, -4.52534715e-03f, 3.09495833e-02f, 1.76781707e-03f, 2.74318438e-02f, 1.90192275e-02f, 2.04788186e-02f, -4.37867008e-02f, 3.93973403e-02f,
  1.17637282e-02f, 2.58660521e-02f, 5.63514121e-02f, 2.62702033e-02f, 1.35948826e-02f, 3.08624171e-02f, -4.46585715e-02f, 2.68203821e-02f, -2.27943738e-03f, 7.09439721e-03f,
  7.87041243e-03f, -7.80754769e-03f, 1.29099493e-03f, 2.83583645e-02f, 2.93923193e-03f, -1.71078406e-02f, 4.47276421e-02f, -2.03918829e-03f, -6.07536966e-03f, -1.90680977e-02f,
  -5.60111105e-02f, -3.95112783e-02f, -5.68408929e-02f, -7.60158582e-04f, -2.49587987e-02f, 1.88826025e-02f, -4.32116538e-02f, -7.16124021e-04f, -6.65731430e-02f, -6.07011579e-02f,
  4.00888138e-02f, 5.06655574e-02f, -3.42583470e-02f, 3.88540439e-02f, -1.30397137e-02f, 1.36893867e-02f, 1.41111417e-02f, -4.11423892e-02f, 3.72270644e-02f, -3.50051485e-02f,
  -3.13279592e-02f, -1.89205799e-02f, -5.28581440e-02f, -1.33079686e-03f, 1.17997825e-01f, 1.15299383e-02f, -1.09787229e-02f, -4.38372791e-02f, 1.22652203e-02f, -5.60734048e-02f,
  2.73716271e-01f, -5.72403818e-02f, -1.92698345e-01f, 1.68918952e-01f, -2.14387596e-01f, -1.22376688e-01f, 1.05286568e-01f, -1.26351804e-01f, 7.50915259e-02f, 6.52870536e-02f,
  2.11575449e-01f, -4.43358533e-02f, 7.29648694e-02f, 1.52252853e-01f, 3.97407085e-01f, 2.41928756e-01f, 2.72817314e-01f, 2.22524181e-01f, -6.66101575e-02f, 4.35691103e-02f,
  7.52614485e-03f, 2.86831800e-02f, -8.48170556e-03f, -2.69613445e-01f, -1.57340884e-01f, -2.26022780e-01f, 1.22002214e-01f, -2.89910853e-01f, 4.37210016e-02f, -1.35188848e-02f,
  -4.33228947e-02f, 1.13101684e-01f, -7.20731318e-02f, 1.30381566e-02f, 2.18381528e-02f, 1.57744698e-02f, 4.21488360e-02f, -4.95951138e-02f, -2.56762542e-02f, -4.45071608e-02f,
  2.38604774e-03f, -6.26693442e-02f, -5.84892817e-02f, -7.17442334e-02f, -2.50458103e-02f, -2.41634883e-02f, -8.70619118e-02f, -3.43518122e-03f, -9.28452760e-02f, -4.50558811e-02f,
  -7.04633892e-02f, 3.92201766e-02f, -1.00563746e-03f, 4.41591516e-02f, -3.38183269e-02f, -1.18081598e-03f, -4.01648581e-02f, -3.54675353e-02f, 4.45582531e-03f, -3.47212963e-02f,
  6.13805559e-03f, -1.04935402e-02f, 1.42701026e-02f, -3.38907428e-02f, 1.96492746e-02f, -5.82577884e-02f, -6.70145778e-03f, -2.32457230e-03f, -2.78029889e-02f, 1.75414197e-02f,
  -2.46596318e-02f, 6.10569231e-02f, 9.56005510e-03f, -6.01869309e-03f, 5.32852747e-02f, -9.34917759e-03f, 6.46287249e-03f, -9.88712534e-03f, 3.99722531e-03f, 5.04545793e-02f,
  -1.05476370e-02f, 3.82252596e-02f, -1.60217583e-02f, 5.57576399e-03f, -1.82178859e-02f, -3.00703086e-02f, -2.35504825e-02f, -3.93398255e-02f, -2.71024159e-03f, 3.56394388e-02f,
  2.04225332e-01f, 2.95891166e-01f, -1.75655179e-03f, -6.74024820e-02f, -2.11101044e-02f, 2.50743772e-03f, -4.22597770e-03f, -5.35748564e-02f, 1.26233613e-02f, 9.29050148e-03f,
  -5.58963902e-02f, 2.87220869e-02f, 2.31382027e-02f, 3.33782807e-02f, -5.69207035e-03f, 4.56897356e-02f, 9.20348316e-02f, -1.39558781e-02f, 6.82228059e-02f, 3.02948002e-02f,
  1.50079224e-02f, -2.05255412e-02f, 1.26447354e-03f, -6.36250749e-02f, 6.11821301e-02f, 2.34951135e-02f, 4.53976840e-02f, -4.62376215e-02f, -1.72474962e-02f, -1.48250572e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.48211941e-01f, 9.82841104e-02f, -2.18690053e-01f, 3.32868062e-02f, -2.98570871e-01f, -2.74534017e-01f, -2.08788931e-01f, -1.53064737e-02f, -7.94578120e-02f, 7.42706805e-02f,
  4.55294549e-02f, 1.43147945e-01f, 7.80845014e-03f, 2.63097256e-01f, 2.21934661e-01f, 1.98120639e-01f, 3.06804836e-01f, 1.01054490e-01f, 1.35931909e-01f, 7.70594254e-02f,
  2.69560695e-01f, 3.18226784e-01f, 2.21487299e-01f, 8.59283656e-02f, 5.38455993e-02f, 1.16644196e-01f, 2.55587101e-01f, -9.06687006e-02f, 8.63751099e-02f, 4.34105769e-02f,
  -4.05253246e-02f, 1.22603029e-01f, -6.21070825e-02f, -1.11308090e-01f, -2.73915380e-02f, -7.09589124e-02f, -1.35205492e-01f, -7.43784197e-03f, -2.93999463e-02f, -4.93805707e-02f,
  -2.48538088e-02f, -6.70715868e-02f, -3.68114263e-02f, 3.29664685e-02f, -1.01665601e-01f, -3.56584415e-02f, 1.66640989e-02f, -8.77037719e-02f, -6.23024292e-02f, 8.44182912e-03f,
  -3.85649018e-02f, 4.49282303e-02f, 1.98615957e-02f, 1.70606691e-02f, 2.67047547e-02f, -6.35210276e-02f, 5.61027229e-02f, 6.15135534e-03f, 1.10283121e-01f, 7.92871714e-02f,
  1.20258015e-02f, 2.13827181e-04f, 6.48009703e-02f, -4.20402959e-02f, -1.25287222e-02f, 1.36269815e-02f, 3.05047054e-02f, 3.54337394e-02f, -7.18173683e-02f, 9.05469656e-02f,
  -3.76623459e-02f, -2.39649732e-02f, -8.41064453e-02f, 5.55279963e-02f, 2.16659512e-02f, 1.71053279e-02f, 7.54834292e-03f, 4.32568304e-02f, -1.82054359e-02f, -4.55643656e-03f,
  -1.40257291e-02f, 4.00086343e-02f, 1.00711454e-02f, -4.63342108e-02f, -3.82985622e-02f, -1.01792738e-02f, 1.31504461e-01f, -5.18404506e-02f, -1.60256028e-02f, -6.90120319e-03f,
  1.38642132e-01f, 2.56261081e-01f, -7.01884702e-02f, -6.94572404e-02f, -2.25410406e-02f, 1.06263952e-02f, 9.54239070e-02f, 6.59390017e-02f, 4.20983434e-02f, 2.40649562e-02f,
  2.79583018e-02f, -7.70359579e-03f, 9.90295261e-02f, 3.77870239e-02f, -5.10644866e-03f, 2.61239205e-02f, 1.20650932e-01f, -5.26402369e-02f, 4.05208353e-04f, 7.33039677e-02f,
  1.62437167e-02f, -4.20610756e-02f, 8.30649957e-03f, -9.46171507e-02f, 3.23803760e-02f, 1.00754008e-01f, -2.47868318e-02f, 4.04704586e-02f, 1.30155519e-01f, 2.56801471e-02f,
  -6.96080402e-02f, 3.24466676e-01f, 2.31743619e-01f, 1.47117749e-01f, -7.06565306e-02f, -1.48465887e-01f, -1.32697985e-01f, 3.01085468e-02f, -2.45227039e-01f, 1.75639048e-01f,
  -1.11381840e-02f, 2.27015078e-01f, -1.78989753e-01f, -9.47887599e-02f, -2.77267456e-01f, -3.72789711e-01f, -3.14685889e-02f, 2.68209614e-02f, -1.81086794e-01f, 3.02636623e-01f,
  5.84976263e-02f, -1.00605600e-01f, 5.68542890e-02f, 9.35947821e-02f, 2.77393907e-01f, 4.28528994e-01f, 2.83083588e-01f, 2.76490878e-02f, 3.25352877e-01f, -1.22242436e-01f,
  -1.72674254e-01f, 2.34353058e-02f, 1.04086228e-01f, -8.93090591e-02f, 1.68473229e-01f, 7.65103027e-02f, 1.51748881e-01f, -1.03199892e-01f, -5.57690114e-02f, -1.08221835e-02f,
  1.27487525e-01f, -5.95143670e-03f, -5.90626560e-02f, -8.86562541e-02f, 1.56487823e-02f, 7.70558864e-02f, 4.10702750e-02f, 1.41134873e-01f, 3.02704740e-02f, 8.58694538e-02f,
  9.76657644e-02f, 1.08050965e-01f, 1.42671540e-01f, 1.09779514e-01f, 4.22573313e-02f, 2.44756900e-02f, 7.03225061e-02f, 2.06777945e-01f, 1.41210213e-01f, -1.48229003e-02f,
  9.23679695e-02f, 2.00574901e-02f, 4.24453337e-03f, -1.03425793e-01f, 7.75874965e-03f, -4.44865562e-02f, 2.36766450e-02f, -5.92114255e-02f, 2.50464324e-02f, 1.77663879e-03f,
  -2.36740392e-02f, 3.26019116e-02f, -4.32418436e-02f, 5.46580181e-02f, 9.05643217e-03f, -6.26245514e-02f, 3.62550654e-02f, 1.17029184e-02f, 6.65970519e-02f, -2.61987876e-02f,
  -5.77409454e-02f, -2.35387459e-02f, 9.85871255e-03f, 1.96975432e-02f, -9.04217362e-02f, 4.86411154e-02f, 4.65356596e-02f, 1.82113405e-02f, 7.22705051e-02f, -1.70770343e-02f,
  2.41868481e-01f, 3.48331541e-01f, -1.69452447e-02f, -6.53209165e-02f, -1.92542560e-02f, 1.09397762e-01f, -8.58920515e-02f, 5.26829511e-02f, 1.14369668e-01f, 2.46383175e-02f,
  1.31671757e-01f, -1.86137855e-02f, 1.14520662e-01f, -1.66994222e-02f, -2.42174603e-02f, 5.93399070e-03f, 1.13695323e-01f, 7.56108994e-03f, 1.08990304e-01f, 1.24403231e-01f,
  1.22164488e-01f, 2.66504921e-02f, -2.65248585e-02f, -3.68732549e-02f, 1.29149090e-02f, 5.89965880e-02f, 8.25157687e-02f, 3.62650715e-02f, 1.49427203e-03f, 8.30385908e-02f,
  3.12606126e-01f, -7.48489574e-02f, -4.44251269e-01f, -2.67004937e-01f, 1.19713038e-01f, 1.16231695e-01f, -1.00635551e-01f, 3.15688252e-02f, -1.74248293e-01f, 2.21325248e-01f,
  1.56505764e-01f, 1.66770834e-02f, -2.61891671e-02f, 5.85732497e-02f, 1.22348979e-01f, -1.32464215e-01f, 6.25666156e-02f, 1.14790894e-01f, -1.61389545e-01f, 7.93201402e-02f,
  1.54028861e-02f, 3.10087085e-01f, -2.79157490e-01f, 7.58046135e-02f, 3.23173031e-02f, -1.08414456e-01f, 1.21232606e-01f, -2.81967986e-02f, 1.05116807e-01f, 1.30131170e-01f,
  -7.38393813e-02f, -6.27502799e-03f, -1.18998542e-01f, -9.04826820e-02f, -3.89663987e-02f, 1.70136411e-02f, 1.47610828e-02f, -2.71925796e-02f, -3.37426327e-02f, 1.65373217e-02f,
  -4.66071516e-02f, -2.22440138e-02f, -9.17444602e-02f, -3.07589155e-02f, -1.39028579e-02f, -6.51819110e-02f, -8.65278244e-02f, -5.26339598e-02f, -6.48969635e-02f, -2.08093096e-02f,
  -9.68805701e-02f, -1.10867150e-01f, -4.88366671e-02f, -1.09493427e-01f, -1.38007715e-01f, 6.18199259e-02f, -8.40321630e-02f, -4.21982296e-02f, 1.47500262e-02f, -1.66866500e-02f,
  9.16005522e-02f, 2.00688038e-02f, 9.37538967e-02f, -2.62898430e-02f, -5.01764975e-02f, -1.13771111e-01f, 2.47659441e-02f, -4.95928228e-02f, -6.43484965e-02f, 1.66519396e-02f,
  4.98911962e-02f, -1.08675463e-02f, -1.91427674e-02f, 9.44544077e-02f, 9.39682648e-02f, 3.16259377e-02f, -1.05310325e-02f, 1.26238838e-02f, -6.85238913e-02f, -1.52254611e-01f,
  -2.07407158e-02f, 3.26267183e-02f, 8.88171569e-02f, 2.82485429e-02f, 2.43139658e-02f, 6.56344742e-02f, 6.55765682e-02f, 7.40891963e-04f, 8.69867206e-03f, -1.10425297e-02f,
  1.05659395e-01f, 1.23258412e-01f, -2.12669987e-02f, -4.40665483e-02f, 2.97232177e-02f, 8.46844167e-02f, 4.09214772e-05f, 6.85921758e-02f, 6.94343895e-02f, 7.01801181e-02f,
  1.42936036e-01f, 3.44916396e-02f, 6.67290911e-02f, 3.24431136e-02f, -1.09110186e-02f, 1.17655873e-01f, 4.06612307e-02f, 3.13001797e-02f, -8.07629246e-03f, -1.47946514e-02f,
  2.65252143e-02f, 9.91862640e-02f, -3.25402506e-02f, 4.46230844e-02f, 5.44229411e-02f, -3.21073383e-02f, 8.56267437e-02f, -4.28262316e-02f, -1.11725833e-02f, 1.88805368e-02f,
  6.41232073e-01f, 6.95127547e-02f, 6.14911579e-02f, 4.73737508e-01f, 1.97472304e-01f, 2.45853961e-01f, 3.00910085e-01f, 3.08187693e-01f, 7.76067257e-01f, 1.38831623e-02f,
  -1.53252661e-01f, 1.98100165e-01f, -3.08936477e-01f, 1.24904945e-01f, -1.38065234e-01f, -1.58473387e-01f, 1.99369952e-01f, 1.25728473e-01f, 2.50419199e-01f, 2.13160038e-01f,
  2.30141386e-01f, -4.24899906e-02f, -3.28035414e-01f, -2.57620007e-01f, 1.59864187e-01f, 1.39076757e-04f, -4.18965966e-01f, -2.46174902e-01f, -1.36735052e-01f, -1.67069435e-01f,
  2.49994677e-02f, 1.66598722e-01f, -1.16912052e-02f, -5.52229062e-02f, 2.54058260e-02f, 6.28225654e-02f, -8.32922310e-02f, -1.59574330e-01f, 4.22212221e-02f, 6.37082383e-02f,
  3.02814394e-02f, 2.64423154e-03f, 4.15682830e-02f, 2.82586552e-02f, 1.46527991e-01f, 5.18766530e-02f, 4.46766354e-02f, 1.18234836e-01f, -4.25297730e-02f, 3.35671566e-02f,
  9.53149274e-02f, -6.20771106e-03f, 1.01235472e-01f, -6.67647691e-03f, 3.27478424e-02f, 8.40249956e-02f, -2.19286177e-02f, -7.26636052e-02f, 6.72077313e-02f, 1.22583449e-01f,
  3.08283810e-02f, -2.79378295e-02f, -7.69975595e-03f, 9.07716341e-03f, 5.49464971e-02f, -8.97718314e-03f, -2.62324908e-03f, -2.63806358e-02f, 3.79927084e-02f, -4.85317968e-02f,
  5.65368980e-02f, 2.97759008e-02f, 2.59416234e-02f, -8.14164430e-03f, 4.86974232e-02f, 8.00249726e-02f, -7.13017732e-02f, 1.70534793e-02f, 6.80499664e-03f, 3.20081972e-02f,
  -2.58086696e-02f, 2.91675758e-02f, -7.49220280e-03f, -4.25573671e-03f, -2.81862449e-02f, -2.16246005e-02f, 2.64910869e-02f, 9.49273035e-02f, -1.41738588e-03f, -8.88712779e-02f,
  5.27223237e-02f, 1.34775415e-01f, -5.33383973e-02f, 3.01371831e-02f, -8.57879147e-02f, -1.09365210e-02f, 3.78851965e-02f, 1.11209325e-01f, 8.66412651e-03f, 6.19003624e-02f,
  4.09541950e-02f, 3.71638760e-02f, 3.42420749e-02f, -7.00248405e-02f, -1.21599875e-01f, 1.07434213e-01f, -5.58820926e-02f, -6.41768351e-02f, -3.57767157e-02f, -7.11742267e-02f,
  -9.66626257e-02f, 7.19451234e-02f, 1.31651936e-02f, 9.16347131e-02f, 1.70594323e-02f, -7.07286745e-02f, 1.17430575e-01f, -2.63233688e-02f, -6.54938146e-02f, -5.61351608e-03f,
  4.44718003e-01f, -6.07054122e-03f, -1.73962191e-01f, 1.16423972e-01f, 1.55382276e-01f, 1.17227942e-01f, 5.01038842e-02f, 5.44546731e-02f, -2.50003666e-01f, -4.30001393e-02f,
  1.30066916e-01f, 1.04399845e-01f, 3.31795636e-05f, 2.15973303e-01f, 3.15026343e-01f, 2.76656915e-02f, 2.57440627e-01f, 4.42816410e-03f, -7.01437704e-03f, 2.34032065e-01f,
  6.72816709e-02f, 2.53028631e-01f, 1.34316713e-01f, 1.23944931e-01f, 2.82742590e-01f, -6.50708601e-02f, 1.84269264e-01f, -4.73034158e-02f, 6.26711249e-02f, 1.22476861e-01f,
  -3.79335918e-02f, 8.85146484e-02f, -3.73350978e-02f, -8.02037492e-02f, 1.77893676e-02f, 9.73968729e-02f, 2.67293211e-02f, 1.05097309e-01f, 1.86112300e-02f, -6.67867288e-02f,
  1.79931875e-02f, 1.92401242e-02f, -1.55080541e-03f, 4.44106236e-02f, 2.89232526e-02f, -5.40515371e-02f, -3.55042401e-03f, -5.44657744e-02f, -1.07073463e-01f, -7.28589157e-03f,
  1.58166103e-02f, 2.49202717e-02f, 3.38717662e-02f, -8.73988271e-02f, 1.59807447e-02f, 8.09965655e-03f, -8.65187347e-02f, 3.75485769e-03f, -3.14965434e-02f, 4.93042246e-02f,
  1.35364994e-01f, -1.46308644e-02f, -5.74531186e-05f, -7.37713231e-03f, 3.31609957e-02f, -1.45058697e-02f, -7.83140212e-03f, 1.75967328e-02f, -1.25334403e-02f, 6.79119602e-02f,
  -3.31231989e-02f, -4.01852764e-02f, 3.33551913e-02f, -8.20906758e-02f, 5.03826551e-02f, -5.45886979e-02f, -1.19878575e-02f, 3.98612097e-02f, 5.48887299e-03f, 1.67491417e-02f,
  -7.41895810e-02f, 2.15303991e-02f, -7.17450008e-02f, -4.00014259e-02f, -4.05629212e-03f, -4.56580520e-02f, 5.81560060e-02f, 6.63225492e-03f, -6.33722544e-02f, 9.39656701e-03f,
  8.48835930e-02f, 1.73211932e-01f, -4.31992002e-02f, -5.57063743e-02f, -3.55734043e-02f, 4.79174703e-02f, -6.08254923e-03f, -2.21239533e-02f, -1.87334623e-02f, 5.34580313e-02f,
  -4.96953279e-02f, -1.31314069e-01f, 4.65711281e-02f, -5.55717535e-02f, -8.77319276e-02f, 2.16764417e-02f, -6.33562952e-02f, -2.01299526e-02f, 2.88263466e-02f, 8.34589973e-02f,
  5.80572858e-02f, -3.23385969e-02f, 2.92803850e-02f, -1.04148760e-02f, -3.16722877e-03f, -3.36173736e-02f, 9.37321931e-02f, 3.91165502e-02f, 4.68049012e-02f, -9.18367133e-02f,
  1.21381782e-01f, -7.13036001e-01f, 1.51588529e-01f, 9.56674665e-02f, 6.54547736e-02f, 1.31886080e-02f, 1.53360799e-01f, -3.73744726e-01f, -2.69783914e-01f, -6.06766284e-01f,
  -1.30887315e-01f, 1.90567777e-01f, -4.67457771e-02f, -1.37069330e-01f, 5.35463512e-01f, 3.30134071e-02f, -1.39336005e-01f, 1.00996671e-02f, -1.06751457e-01f, -2.54230469e-01f,
  1.05459858e-02f, -6.25943840e-02f, 1.12550639e-01f, -2.92947471e-01f, -9.68091711e-02f, -1.79785058e-01f, 1.61602534e-02f, 1.32767916e-01f, 2.97652604e-03f, 2.94819444e-01f,
  -2.26630718e-01f, -1.91788778e-01f, -4.52938564e-02f, -7.91242793e-02f, -1.41456127e-01f, 2.18485426e-02f, 9.41175744e-02f, 2.22143292e-01f, -1.10967197e-02f, -5.78645393e-02f,
  1.24048218e-02f, 2.73438133e-02f, -9.44452584e-02f, 9.92823690e-02f, -1.23542450e-01f, -5.96369617e-02f, -1.27891386e-02f, -6.23019151e-02f, -8.12318251e-02f, 5.31346090e-02f,
  1.31787919e-02f, -9.44004133e-02f, -9.19980276e-03f, -5.45675159e-02f, 9.64838713e-02f, -6.19694516e-02f, 9.41160694e-03f, 1.46441922e-01f, -2.59804484e-02f, -6.99060187e-02f,
  -3.60351824e-03f, 7.10259285e-03f, -1.54893631e-02f, -4.10408191e-02f, 7.54521985e-04f, -1.76785924e-02f, 6.47474499e-03f, 8.25653672e-02f, -4.18150994e-05f, -5.88411130e-02f,
  2.98328884e-02f, -4.46298830e-02f, 2.59873681e-02f, 1.39312949e-02f, -2.29501836e-02f, -1.59110744e-02f, 7.13570863e-02f, 1.90498102e-02f, -1.68080758e-02f, 1.80220130e-04f,
  -7.19824061e-03f, 1.35739418e-02f, 5.13803661e-02f, 3.38516310e-02f, -2.74303667e-02f, -3.59047130e-02f, -4.73127030e-02f, -2.70389523e-02f, 2.42817122e-02f, 5.35974354e-02f,
  -3.94604474e-01f, -4.92561460e-01f, -8.26400146e-02f, -8.14540610e-02f, -4.38927859e-02f, -4.35279608e-02f, -4.97935414e-02f, -5.64422980e-02f, -2.28700992e-02f, -7.17494935e-02f,
  -3.88936400e-02f, 6.34087473e-02f, -4.44916710e-02f, 1.35974484e-02f, 4.14221082e-04f, -8.41648877e-02f, -3.54238339e-02f, -1.63595788e-02f, -4.71635349e-02f, -1.02549158e-01f,
  -2.78515387e-02f, 2.19071060e-02f, 8.91303495e-02f, 1.99803915e-02f, 2.12412048e-03f, 2.21997891e-02f, 6.88804984e-02f, -1.51035078e-02f, 4.54865173e-02f, 2.68983003e-02f,
  -4.07984644e-01f, 1.04736470e-01f, 1.58760011e-01f, -1.07722506e-02f, -1.32107228e-01f, 3.98208946e-01f, 3.39637935e-01f, -5.96924014e-02f, 1.34189487e-01f, 2.53197163e-01f,
  -7.40759494e-03f, -2.15831384e-01f, 2.09218070e-01f, 1.80368587e-01f, 6.66265562e-02f, 3.32694620e-01f, 3.21942598e-01f, 1.81675911e-01f, 3.56373638e-02f, -6.65237233e-02f,
  5.52386530e-02f, -7.59779662e-02f, 1.05535790e-01f, -1.26447499e-01f, -1.47476628e-01f, -2.93439299e-01f, -1.41645581e-01f, -7.42661580e-02f, -5.05755730e-02f, -1.08519778e-01f,
  -6.71959296e-02f, -2.40165696e-01f, -2.19283417e-01f, -6.08711615e-02f, -9.38719362e-02f, -5.91701604e-02f, 7.03494102e-02f, -7.65700489e-02f, -2.55872663e-02f, 7.88361952e-03f,
  -4.53171767e-02f, -4.11419347e-02f, -9.82684717e-02f, -3.38469669e-02f, 3.30642462e-02f, -3.19668166e-02f, 4.84207757e-02f, -3.22468691e-02f, 6.12940313e-03f, -7.02699507e-03f,
  8.86171535e-02f, -1.23732686e-02f, 8.54685679e-02f, 6.15986399e-02f, 8.30732808e-02f, -5.13071020e-04f, 2.68334318e-02f, 2.47048140e-02f, -1.62827726e-02f, 6.63421229e-02f,
  9.26673338e-02f, 7.37569183e-02f, -1.57651305e-02f, -4.55415957e-02f, -7.19438307e-03f, -7.81504214e-02f, -8.28584936e-03f, -9.17886868e-02f, -2.54659522e-02f, 2.47278847e-02f,
  -8.12899917e-02f, -1.01677753e-01f, -5.80316670e-02f, 7.90381730e-02f, -4.29549366e-02f, 5.51422685e-02f, 4.46909070e-02f, -5.75570129e-02f, 9.41456035e-02f, -4.05096896e-02f,
  -2.29359902e-02f, -6.53114319e-02f, 5.69570884e-02f, 7.10385218e-02f, 4.80112806e-02f, -4.18329537e-02f, -4.20439206e-02f, -2.55789757e-02f, 7.92353153e-02f, -7.83611238e-02f,
  -1.33422017e-01f, -1.27136409e-01f, -8.40598717e-02f, -6.85798228e-02f, 2.26693153e-02f, -3.17575186e-02f, -3.42353582e-02f, -2.71839146e-02f, -1.17243426e-02f, 3.20859849e-02f,
  2.56379647e-03f, -2.89962906e-02f, 1.26463966e-02f, -7.46761262e-02f, -5.10402471e-02f, -4.30428162e-02f, -6.83704615e-02f, -3.23629496e-03f, 9.48591251e-03f, -7.52211586e-02f,
  -3.82117778e-02f, -5.20206913e-02f, 7.62288570e-02f, 2.56599784e-02f, 3.71095128e-02f, -4.53257300e-02f, -1.57492682e-02f, 2.34900061e-02f, 8.68954882e-03f, 6.79423511e-02f,
  -4.54785377e-02f, -1.90924764e-01f, -2.08713561e-01f, 1.32416472e-01f, 1.87921539e-01f, 1.48963779e-01f, 4.21658717e-03f, -6.72294572e-02f, -2.24266544e-01f, -7.56909624e-02f,
  4.48702276e-02f, 1.28424633e-02f, -4.03230578e-01f, 2.18443736e-01f, 2.56993532e-01f, -1.74831107e-01f, 8.12503397e-02f, 9.33295414e-02f, -1.35197699e-01f, 7.71496864e-03f,
  -2.45930571e-02f, 2.15919510e-01f, 4.50871810e-02f, 1.58422232e-01f, 7.05482066e-02f, 3.28778923e-02f, 2.69512475e-01f, 9.23064947e-02f, 4.71218228e-01f, 3.45416367e-01f,
  1.17383227e-01f, -1.47947967e-01f, -1.41192842e-02f, -4.95146662e-02f, -4.21380699e-02f, 8.99889842e-02f, 6.74187690e-02f, 1.50680393e-01f, 2.10200846e-02f, 1.51238302e-02f,
  -5.97341312e-03f, 1.02249585e-01f, 1.42240003e-01f, 4.15994152e-02f, 5.60986325e-02f, 3.37257832e-02f, -3.45901698e-02f, 2.95288693e-02f, -5.91311678e-02f, -3.68852802e-02f,
  -1.70653284e-01f, 3.71705927e-02f, -5.36468662e-02f, 4.51064333e-02f, -8.41789693e-03f, 2.13360935e-02f, 4.19395342e-02f, 4.21916833e-03f, 1.68340709e-02f, 1.73178390e-02f,
  3.57488617e-02f, -4.01403084e-02f, 1.98844709e-02f, -5.65689206e-02f, 4.31418084e-02f, 8.38648006e-02f, 8.24357104e-03f, -3.20714675e-02f, 3.08209620e-02f, 4.05506603e-03f,
  4.93040197e-02f, 4.44923947e-03f, 3.46370861e-02f, 4.64844704e-02f, 2.18393542e-02f, -2.18876265e-02f, 8.00271407e-02f, 4.51320736e-03f, -6.98660389e-02f, -1.52025390e-02f,
  -3.20310961e-03f, 4.19010036e-02f, 1.30985975e-02f, -4.09007557e-02f, -2.03555194e-03f, 2.59891078e-02f, 9.26527530e-02f, 2.08644830e-02f, 4.17208709e-02f, -7.81615265e-03f,
  9.30604860e-02f, -2.76885219e-02f, -7.39594400e-02f, 8.31049755e-02f, -2.21461020e-02f, -1.44688217e-02f, 2.67244130e-02f, 9.43723395e-02f, 3.40187736e-02f, -2.63354182e-02f,
  8.92914645e-03f, -2.87468489e-02f, 8.88759568e-02f, -2.86556929e-02f, 3.13094929e-02f, 5.58831505e-02f, -3.41770463e-02f, 8.28085176e-04f, 8.54271743e-03f, 3.38440239e-02f,
  -3.72675695e-02f, -3.64133567e-02f, 3.55594829e-02f, -6.61803260e-02f, -2.83453707e-02f, -2.28256918e-02f, -8.32441822e-03f, 2.73392946e-02f, -4.03650291e-02f, -4.50190417e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.16718817e-01f, 4.31451738e-01f, 2.41860017e-01f, 4.79352593e-01f, 1.07344352e-01f, 5.01056075e-01f, 2.55902648e-01f, 7.88128823e-02f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.63475394e-01f, -4.11769897e-01f, 2.26227894e-01f, 4.40931469e-01f, 1.31647527e-01f, -2.78915670e-02f, -5.07966638e-01f, -4.19457227e-01f, 1.47411674e-02f, 8.72176960e-02f,
  -1.64518043e-01f, -2.38548219e-01f, -6.13670528e-01f, -6.39920473e-01f, 3.36553365e-01f, 3.24125111e-01f, -3.18183661e-01f, -2.43277490e-01f, -5.66164553e-01f, 7.50969470e-01f,
  3.57844114e-01f, 1.87974021e-01f, 9.03924406e-01f, 6.40024900e-01f, 2.83405662e-01f, -7.87667930e-02f, -1.00105882e-01f, -4.59861487e-01f, -3.06242377e-01f, -2.02982932e-01f,
  7.58057058e-01f, -1.87998265e-01f, 5.17497718e-01f, -1.08741440e-01f, -3.75489324e-01f, 2.05775097e-01f, -2.49054417e-01f, 2.79436290e-01f, -8.24937701e-01f, 2.80796617e-01f,
  7.90559500e-03f, 1.67984292e-01f, -5.36092758e-01f, -3.41331601e-01f, -2.94350535e-01f, -2.78414488e-01f, -5.21115422e-01f, 4.05212671e-01f, 1.64490938e-02f, 3.26837003e-01f,
  -5.39843500e-01f, -5.50986469e-01f, -1.54952750e-01f, -2.87918180e-01f, 6.40925944e-01f, 4.89984542e-01f, 3.41894835e-01f, -9.63070765e-02f, 7.37215877e-01f, 3.14378977e-01f,
  6.45456553e-01f, -5.17154872e-01f, -1.81284264e-01f, 1.81085452e-01f, -3.12088400e-01f, 1.58579618e-01f, -9.55908075e-02f, -7.59422123e-01f, -4.03936990e-02f, -2.21434329e-02f,
  2.64871687e-01f, -3.69511276e-01f, 1.61934748e-01f, 8.78109317e-03f, 7.97021091e-02f, -1.73092522e-02f, 4.41969067e-01f, 3.09377849e-01f, -2.41603896e-01f, 6.40460849e-01f,
  5.13043344e-01f, 2.78182209e-01f, 1.71996076e-02f, -5.31928599e-01f, -2.67045408e-01f, -5.00438154e-01f, 4.33693618e-01f, -1.73616603e-01f, 7.41606671e-03f, -2.22338036e-01f,
  3.40368971e-02f, -3.92075419e-01f, 1.52597606e-01f, 6.11682534e-01f, -4.00804609e-01f, 9.08288300e-01f, 3.21130037e-01f, -7.30308592e-02f, -5.82280457e-01f, -2.40554601e-01f,
  4.58215885e-02f, 5.28752685e-01f, 4.14306700e-01f, -5.72188795e-01f, -5.41430831e-01f, -8.15680802e-01f, 4.50236529e-01f, -4.86550748e-01f, 5.39674908e-02f, 7.87568390e-01f,
  4.99031514e-01f, -7.67915487e-01f, 3.65832955e-01f, 1.31602600e-01f, -5.55139661e-01f, 6.66721523e-01f, 7.93570995e-01f, 3.48913819e-01f, -1.32575840e-01f, -5.16765654e-01f,
  -1.19500406e-01f, -1.32149488e-01f, -2.97167562e-02f, -1.31054953e-01f, -1.91962138e-01f, -3.43783647e-01f, -2.98606515e-01f, -9.09565911e-02f, 3.42204213e-01f, 6.42578721e-01f,
  -7.81896040e-02f, -1.25501618e-01f, 2.72703886e-01f, 2.16876850e-01f, 2.06235513e-01f, 3.47448170e-01f, 2.42119953e-01f, 8.32823992e-01f, 2.21697539e-01f, 3.91586833e-02f,
  -7.70152092e-01f, -5.16176581e-01f, 7.98028409e-01f, 1.89704940e-01f, 3.49697649e-01f, -2.91784614e-01f, -6.15760908e-02f, 6.58857942e-01f, -1.47653490e-01f, 1.83899507e-01f,
  -8.53558719e-01f, -1.04940033e+00f, -1.86742529e-01f, -2.84574926e-01f, -3.25179219e-01f, -2.93806225e-01f, -1.05682001e-01f, 7.80475289e-02f, 4.26073521e-01f, -9.02960673e-02f,
  -2.78319389e-01f, -1.31970048e-01f, 2.19044045e-01f, 2.05046803e-01f, -3.06590251e-03f, 1.02795050e-01f, 4.62339461e-01f, -4.23269160e-03f, 1.11229561e-01f, 5.31500161e-01f,
  4.46453333e-01f, 7.33406618e-02f, -5.86867988e-01f, -7.02609599e-01f, -5.77285051e-01f, -9.79833186e-01f, -1.54768497e-01f, -2.34079182e-01f, -8.31678987e-01f, -7.24434018e-01f,
  -2.83310324e-01f, -4.29183215e-01f, -1.25799507e-01f, 5.58758080e-01f, 1.20714763e-02f, -9.62585732e-02f, -1.66217331e-02f, 6.63739145e-01f, -1.79741055e-01f, -4.30418849e-01f,
  2.42564365e-01f, -9.91088226e-02f, -2.25762501e-01f, 2.12301001e-01f, -9.69997197e-02f, 5.50318301e-01f, -1.18230358e-01f, 3.10088158e-01f, 4.36799340e-02f, 1.03334241e-01f,
  -2.29234442e-01f, -5.95663428e-01f, 3.61650437e-01f, -9.45789590e-02f, 6.76515996e-01f, -7.01357499e-02f, -4.50029761e-01f, 1.79540351e-01f, 5.02188325e-01f, 2.68216282e-01f,
  7.77693391e-01f, -1.05003908e-01f, -6.33856833e-01f, -6.17168427e-01f, -2.05442861e-01f, -1.52334064e-01f, -3.42914760e-01f, -4.93972093e-01f, -2.47491777e-01f, 9.74111855e-01f,
  -4.62153666e-02f, 1.19733758e-01f, -4.89501916e-02f, -3.08296770e-01f, -5.64119160e-01f, -2.79435545e-01f, -4.41502854e-02f, -1.89070955e-01f, 2.04537943e-01f, -7.23450363e-01f,
  -4.96014237e-01f, 2.19026193e-01f, 1.55760229e-01f, 1.37316853e-01f, -6.07437968e-01f, 3.72958869e-01f, -5.29598176e-01f, 7.83915162e-01f, 6.04608536e-01f, -4.82900620e-01f,
  -5.26987135e-01f, 7.13447213e-01f, 6.72160566e-01f, 3.73584293e-02f, 4.99950320e-01f, 4.76515144e-01f, -6.76032901e-01f, 5.17248154e-01f, 3.27381253e-01f, -2.01319501e-01f,
  1.20573163e-01f, -1.90098643e-01f, -1.06641557e-02f, 5.23942351e-01f, 2.23411806e-02f, -2.50964671e-01f, -4.57411140e-01f, 1.16134800e-01f, 1.99528009e-01f, -3.01695168e-01f,
  3.26744244e-02f, -5.50214410e-01f, -3.38794291e-02f, -1.36145782e-02f, -3.39007556e-01f, 2.43330762e-01f, 7.44596943e-02f, -3.60514522e-02f, 6.07925415e-01f, -4.84325290e-01f,
  2.64412344e-01f, 5.56242347e-01f, 3.16756427e-01f, -6.14373505e-01f, 1.91135585e-01f, -3.90345931e-01f, 5.76375604e-01f, 4.28841263e-02f, 9.06369761e-02f, 3.56462926e-01f,
  6.59313738e-01f, 6.70925379e-01f, -7.00509399e-02f, -3.49426568e-01f, 3.50651354e-01f, -3.06403905e-01f, -4.31329668e-01f, 3.69292162e-02f, 1.60068542e-01f, 2.31155738e-01f,
  6.36665598e-02f, 3.16173792e-01f, -3.27624828e-02f, 7.35321036e-03f, -8.65518451e-02f, 3.37881863e-01f, -4.92092580e-01f, -3.96583319e-01f, -1.25361830e-01f, 3.84880960e-01f,
  -4.77179468e-01f, -2.32318327e-01f, -5.02208710e-01f, 3.51900578e-01f, -6.50270283e-01f, 7.77946338e-02f, 1.94520622e-01f, 3.36261898e-01f, -4.59752202e-01f, -6.61394775e-01f,
  -6.00328863e-01f, 8.15359727e-02f, -4.42479819e-01f, -2.88435578e-01f, -2.11363032e-01f, -5.51196337e-01f, 1.01218067e-01f, 1.05642688e+00f, -3.07174795e-03f, 8.24441314e-02f,
  2.28969008e-01f, -4.82777387e-01f, 5.50611675e-01f, 5.15906811e-01f, 2.47294545e-01f, 1.54380545e-01f, 1.88039586e-01f, 1.94635957e-01f, 3.50083143e-01f, -2.42373884e-01f,
  1.68962359e-01f, 7.90988803e-02f, 2.97381401e-01f, 8.54352355e-01f, -6.55725241e-01f, 3.07017773e-01f, -7.19736218e-02f, 4.10332710e-01f, 9.87789184e-02f, 4.98145729e-01f,
  3.64575274e-02f, 8.63384724e-01f, 1.33044779e-01f, -2.22449243e-01f, -2.14741647e-01f, 7.06357718e-01f, 3.08451921e-01f, -2.08634526e-01f, -2.12181911e-01f, -4.24890786e-01f,
  -1.90647751e-01f, 1.31835461e-01f, -1.49385883e-02f, 3.80452871e-01f, -9.30771008e-02f, -3.92124325e-01f, -4.35841471e-01f, -3.76071125e-01f, 1.10361136e-01f, -3.10632074e-03f,
  1.49616554e-01f, 4.01558936e-01f, 2.65518457e-01f, 1.90165099e-02f, 4.95398015e-01f, 4.84726518e-01f, 6.90881371e-01f, -6.64959133e-01f, -7.67747045e-01f, -5.22605538e-01f,
  6.14283741e-01f, -5.07202566e-01f, -3.37090731e-01f, 4.15550508e-02f, 3.85980815e-01f, -2.15058818e-01f, -2.30885491e-01f, 6.82610989e-01f, -3.43326837e-01f, 5.20091236e-01f,
  -2.27679044e-01f, -1.77107483e-01f, -2.97342658e-01f, -1.69932380e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.03938372e-02f, -1.06882051e-01f, -9.56100672e-02f, 3.60212177e-01f, 2.70891964e-01f, 1.41828088e-02f, -3.05870846e-02f, 8.49904120e-02f, -5.08620217e-02f, -2.21487164e-01f,
  -9.04543698e-02f, 8.11929703e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    