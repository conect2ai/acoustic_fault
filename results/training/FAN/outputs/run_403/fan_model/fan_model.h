/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.70257258e-01f, -1.82612255e-01f, -4.50450391e-01f, -2.29954198e-02f, 6.16054870e-02f, 1.78047135e-01f, 8.81064236e-02f, -1.55550987e-01f, 1.08283676e-01f, 7.73026273e-02f,
  1.69347122e-01f, -2.71198731e-02f, -5.99370152e-03f, 2.75273323e-01f, 5.13304844e-02f, 1.97594419e-01f, 1.91553026e-01f, 1.83269992e-01f, -2.80736499e-02f, -2.57396773e-02f,
  -3.31943408e-02f, 1.28109857e-01f, -1.30372867e-01f, -4.45155762e-02f, -9.26481634e-02f, -2.32904986e-01f, 5.60021885e-02f, -1.47447020e-01f, 2.38857716e-02f, 5.70952035e-02f,
  -2.18847439e-01f, -2.99422681e-01f, -9.10950676e-02f, 1.99235100e-02f, 9.51603986e-03f, 1.42315537e-01f, 4.08737697e-02f, 2.24569179e-02f, -3.49346288e-02f, 1.73152555e-02f,
  1.20847337e-01f, -3.40996459e-02f, 3.13141830e-02f, 7.33912513e-02f, 9.85396057e-02f, 3.42819728e-02f, 1.11172618e-02f, -4.70540207e-03f, -6.16157949e-02f, -2.39308588e-02f,
  -7.86755234e-02f, 8.08683932e-02f, 2.02139884e-01f, 1.32813141e-01f, -1.06377024e-02f, -9.55715403e-02f, -1.00134835e-01f, 2.73537356e-02f, 7.74225518e-02f, 1.34256072e-02f,
  1.03031956e-01f, -1.55059367e-01f, 6.48869574e-03f, 1.20511707e-02f, -1.61793590e-01f, -1.16680423e-02f, 8.02934542e-02f, -1.45208905e-04f, -9.10989493e-02f, 6.81275278e-02f,
  6.66049123e-02f, 5.78226261e-02f, 2.75945012e-02f, -2.94432919e-02f, -7.73420511e-03f, -6.80947825e-02f, 3.96814682e-02f, -7.19636958e-03f, 1.43797100e-01f, -9.78926122e-02f,
  3.33509184e-02f, 2.74439678e-02f, 1.15567349e-01f, 1.68931559e-01f, 6.66132048e-02f, 8.97077322e-02f, -1.60741080e-02f, -1.53802778e-03f, -9.98033732e-02f, 8.06774497e-02f,
  1.78589270e-01f, -9.40656513e-02f, 7.38248881e-03f, 1.12414162e-03f, -2.44208928e-02f, 1.34825222e-02f, -3.46930549e-02f, -2.08990965e-02f, -5.32306321e-02f, -3.58809680e-02f,
  6.31447807e-02f, -4.94754054e-02f, 1.67040415e-02f, 5.23113757e-02f, -2.97312196e-02f, 4.46446911e-02f, 3.52950133e-02f, 7.51373032e-03f, 5.67692593e-02f, 2.14153528e-02f,
  -8.73852521e-02f, -4.78659645e-02f, -8.76488835e-02f, -7.69326538e-02f, 1.02010444e-01f, 5.73991053e-02f, 1.48304822e-02f, -4.93255667e-02f, 9.89412982e-03f, 8.88305008e-02f,
  -1.54860720e-01f, 1.55268565e-01f, -9.30681154e-02f, 9.94705111e-02f, -1.41595051e-01f, 4.89452444e-02f, -6.16597161e-02f, 5.19482046e-02f, -3.48005205e-01f, 2.89523602e-01f,
  1.72217891e-01f, -2.04536423e-01f, 2.11353436e-01f, 2.38633960e-01f, -3.14417571e-01f, -5.93879335e-02f, 8.92317295e-02f, 1.04951799e-01f, -1.13372654e-01f, 4.34360653e-02f,
  2.88208760e-02f, 1.67018533e-01f, 1.05827518e-01f, 4.44077095e-03f, 1.27061859e-01f, 6.96979240e-02f, 8.83583128e-02f, -3.34100462e-02f, 1.61368266e-01f, -7.13939965e-02f,
  -1.03949696e-01f, -1.53608741e-02f, 1.24230064e-01f, 7.89482296e-02f, 9.54272225e-02f, 9.81294215e-02f, -2.56275665e-02f, -6.85614198e-02f, -1.51841253e-01f, -5.19706216e-03f,
  7.15939514e-03f, -5.71993701e-02f, -8.14037770e-03f, -4.89137471e-02f, 3.91365737e-02f, 3.99181694e-02f, -9.01715271e-03f, -5.79148307e-02f, -3.72001790e-02f, -5.12636341e-02f,
  -4.72310744e-02f, 6.56660423e-02f, 8.53086486e-02f, -1.02894522e-01f, 2.24235491e-03f, -2.60290522e-02f, -2.54682731e-02f, 1.16612567e-02f, 8.90379176e-02f, -2.95067225e-02f,
  7.34385177e-02f, 6.57109097e-02f, -2.86100749e-02f, 8.47500265e-02f, -5.63324876e-02f, -2.78525874e-02f, -2.73937713e-02f, -2.31251102e-02f, -1.13993727e-01f, 8.15190747e-02f,
  -1.19592501e-02f, 3.23271565e-02f, 1.00531131e-01f, 1.68517586e-02f, 2.16722805e-02f, 2.31176112e-02f, -5.43487398e-03f, -3.17492597e-02f, 4.67682071e-02f, -3.19489539e-02f,
  -2.32525896e-02f, -1.21285923e-01f, 6.11389428e-02f, -2.15318184e-02f, 4.55875099e-02f, 1.26288831e-02f, 5.93790822e-02f, -5.03698215e-02f, -3.92248370e-02f, -1.17556294e-02f,
  5.30444868e-02f, 1.18991636e-01f, 7.76241124e-02f, -6.91186041e-02f, -7.29166195e-02f, -5.93795739e-02f, -3.06262840e-02f, -3.52610312e-02f, 5.78781776e-02f, 2.13389639e-02f,
  -2.76579093e-02f, -3.38243768e-02f, -6.33403510e-02f, -1.63016114e-02f, -1.92415006e-02f, -3.41863115e-03f, -1.54651115e-02f, -2.34128181e-02f, 1.03630826e-01f, 6.47670105e-02f,
  2.67199129e-02f, -1.94190943e-03f, -9.77001041e-02f, 6.54246716e-04f, -2.41513383e-02f, 5.45110404e-02f, -1.54711500e-01f, 1.13233738e-01f, -3.54894176e-02f, 1.97559595e-02f,
  6.90242231e-01f, -5.10945357e-02f, 3.66330743e-01f, -7.96021074e-02f, 2.05121383e-01f, 3.42884302e-01f, 2.90142566e-01f, -3.12654823e-02f, 4.53942508e-01f, -3.99232097e-02f,
  1.95544824e-01f, 1.40561253e-01f, 3.25855576e-02f, 3.38273555e-01f, 1.75977618e-01f, -6.44548163e-02f, 1.21580236e-01f, 8.26696679e-02f, -3.43171670e-03f, 2.20815353e-02f,
  4.17942293e-02f, -2.86744591e-02f, 5.23430146e-02f, -1.26451522e-01f, 2.68471688e-01f, -5.57309985e-02f, -2.92140901e-01f, -9.75024924e-02f, -6.05925992e-02f, 5.79061136e-02f,
  3.31977308e-02f, 1.82430759e-01f, 1.12582438e-01f, 9.48228016e-02f, 2.62774173e-02f, -3.78732421e-02f, -8.11940506e-02f, -7.04135001e-02f, 7.33449124e-03f, -1.56657565e-02f,
  -9.79049224e-03f, 5.65968733e-03f, 2.71500926e-02f, 2.02764645e-02f, 7.34345242e-02f, 8.95186067e-02f, 4.98632379e-02f, 6.39515594e-02f, 8.88011698e-03f, 1.09419376e-01f,
  1.52545059e-02f, -2.87237726e-02f, 3.79750580e-02f, 2.39084251e-02f, 1.27869146e-02f, 2.67725997e-02f, -4.40661469e-03f, 4.67235669e-02f, -8.26385543e-02f, 7.30280951e-02f,
  -4.81409095e-02f, 5.17470986e-02f, -1.94995571e-02f, 5.98258292e-03f, 7.44878575e-02f, 1.89956464e-03f, 8.26749485e-03f, -1.21401615e-01f, 7.27059022e-02f, 2.15724539e-02f,
  -2.78986152e-02f, 1.07785933e-01f, -1.84295624e-02f, 5.68470508e-02f, -1.80361588e-02f, -3.81382853e-02f, -3.10849398e-02f, -3.15496512e-02f, 8.01399127e-02f, -2.24923138e-02f,
  -5.28035760e-02f, -2.02602781e-02f, 6.46748543e-02f, -1.03654854e-01f, 1.18597802e-02f, -2.50919871e-02f, 8.39750748e-03f, -3.90376449e-02f, -5.27348043e-03f, -9.54715461e-02f,
  -1.54677466e-01f, -2.07972303e-01f, -1.55531317e-02f, 4.83406754e-03f, -1.17324654e-03f, 5.35745844e-02f, 2.31734514e-02f, -8.33315030e-03f, -2.66670864e-02f, 2.71277837e-02f,
  -2.54225116e-02f, 1.16386833e-02f, -6.29946291e-02f, 6.85354695e-03f, -7.03518167e-02f, -7.10480884e-02f, -1.20806247e-01f, -7.60701252e-03f, 6.57367520e-03f, -8.05991217e-02f,
  -1.04114629e-01f, 3.66067560e-03f, 3.64653766e-02f, -2.46890262e-02f, 7.85207003e-03f, -1.31997783e-02f, -2.66602356e-03f, -8.50150287e-02f, -6.34505600e-02f, -6.63726358e-03f,
  3.59075844e-01f, 1.59025416e-02f, -1.09448805e-01f, 1.83498368e-01f, -4.46206965e-02f, 2.16419429e-01f, 2.79695302e-01f, -1.04804918e-01f, -1.91724654e-02f, 4.85245846e-02f,
  1.45858884e-01f, -2.05188245e-02f, 3.04342061e-02f, 4.38767731e-01f, 3.06662053e-01f, 1.44892201e-01f, 4.31298077e-01f, 1.39497638e-01f, 6.53281510e-02f, 1.38774943e-02f,
  -1.58591028e-02f, 2.54607141e-01f, 1.36532888e-01f, -1.14786200e-01f, 3.88732441e-02f, -2.18188107e-01f, -7.01981485e-02f, -1.54970542e-01f, 6.04883507e-02f, 2.10068338e-02f,
  4.96083610e-02f, -1.06003201e-02f, -6.75164014e-02f, -4.10701148e-02f, 7.72192376e-03f, -2.57979762e-02f, -5.08815497e-02f, -5.52008785e-02f, -5.52670695e-02f, 9.21114385e-02f,
  -1.26588391e-02f, 2.34772433e-02f, 7.65769035e-02f, -7.51035735e-02f, -2.85455752e-02f, -7.18951039e-03f, -2.82556633e-03f, 1.69612770e-03f, 3.00870724e-02f, 7.52247795e-02f,
  5.81105277e-02f, 7.69993057e-03f, -8.76200479e-03f, 5.75506054e-02f, -3.92121412e-02f, 3.88484672e-02f, 2.57682838e-02f, -3.85389216e-02f, -3.94886583e-02f, 5.00768749e-03f,
  3.42097841e-02f, 5.79562485e-02f, 1.08714239e-03f, -1.06432941e-02f, 1.51094124e-02f, -3.18716951e-02f, 6.22300841e-02f, 1.40790511e-02f, -2.19168700e-02f, 2.65623014e-02f,
  2.02711560e-02f, 3.77272442e-02f, -1.08188484e-02f, 2.45106928e-02f, 5.92821836e-02f, 2.32693870e-02f, -6.61593676e-02f, 4.30208743e-02f, 5.79392686e-02f, 2.84268446e-02f,
  -3.36609723e-04f, -4.12971601e-02f, -3.96774523e-02f, 4.75915149e-02f, 1.65107585e-02f, -6.60948157e-02f, 1.44298766e-02f, -5.40813170e-02f, -1.59590989e-02f, -2.44506020e-02f,
  -5.36064319e-02f, 4.14879881e-02f, 4.91422117e-02f, -7.44812377e-03f, -2.06941292e-02f, 5.40549085e-02f, 9.59217101e-02f, 5.10202982e-02f, -5.29439598e-02f, -3.74508724e-02f,
  -6.44164532e-02f, -5.63607216e-02f, -8.18362087e-02f, 2.08006315e-02f, -1.46749606e-02f, 2.27637012e-02f, 7.46193901e-02f, -9.06155407e-02f, -4.72349450e-02f, 4.10701558e-02f,
  -4.37831916e-02f, -6.31557265e-03f, -2.87680868e-02f, -8.38300288e-02f, 1.34744411e-02f, -3.66375521e-02f, -7.50360638e-02f, -3.11717503e-02f, 2.51201224e-02f, 4.16150279e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.94380844e-01f, 7.24000037e-01f, 8.55189383e-01f, 9.41516876e-01f, 1.90069638e-02f, -4.85740960e-01f, 1.05637005e-02f, 4.06852216e-01f, 2.83315659e-01f, -1.93452314e-01f,
  -1.35026336e-01f, 3.68583530e-01f, -3.68399888e-01f, 3.21947634e-01f, -1.01520047e-01f, -3.81000191e-01f, 3.95533681e-01f, 1.11998752e-01f, 9.81724635e-02f, 4.62605268e-01f,
  3.76588196e-01f, -6.51157349e-02f, 3.75206023e-01f, -1.30471587e-02f, 5.08337796e-01f, 4.00269032e-01f, -1.85617991e-02f, 9.16807652e-02f, 2.06118241e-01f, -2.36597642e-01f,
  -2.08907396e-01f, 6.81237876e-02f, 1.85605302e-01f, 9.81164351e-02f, 1.48108453e-01f, 1.41360203e-03f, 3.55198383e-02f, -1.32163346e-01f, 2.53250403e-03f, 4.59242985e-03f,
  1.60900634e-02f, -2.72594169e-02f, 8.97231400e-02f, 1.84046419e-03f, -1.54291149e-02f, -1.94374900e-02f, 1.47092581e-01f, 1.87514946e-01f, 1.57162845e-01f, 1.43596455e-01f,
  2.65974253e-01f, -4.12426982e-03f, 7.19247982e-02f, 1.83038972e-03f, 1.89061061e-01f, -3.02365497e-02f, -6.46730736e-02f, 3.48846167e-02f, -6.35871058e-03f, -2.35356390e-02f,
  -1.17855862e-01f, -8.89872164e-02f, -4.28531468e-02f, -1.45276999e-02f, 1.03102945e-01f, -1.53442854e-02f, 1.32038742e-01f, -1.63205370e-01f, 1.72352899e-04f, -1.38206586e-01f,
  -1.29205389e-02f, 1.61952019e-01f, -1.05984047e-01f, -1.24623487e-02f, 6.36640340e-02f, 6.83420748e-02f, -6.60112277e-02f, 1.66091826e-02f, 8.11002105e-02f, -2.74484251e-02f,
  -2.52927765e-02f, -6.26737401e-02f, 1.61413267e-01f, 6.53619543e-02f, -1.18582740e-01f, -2.82636788e-02f, -2.55762450e-02f, 2.50581205e-01f, -6.40870258e-02f, 9.64208767e-02f,
  -1.36358961e-01f, 1.93117112e-01f, 7.65140653e-02f, -2.27015272e-01f, -1.40390530e-01f, -2.88741719e-02f, 9.63281724e-04f, 1.53892621e-01f, -1.73067451e-02f, -7.09824711e-02f,
  5.94232306e-02f, 8.89337212e-02f, -1.45404339e-01f, -2.82239635e-03f, -2.18312219e-02f, 1.47556096e-01f, 1.29949907e-02f, 7.63821006e-02f, -3.57726216e-02f, -3.64802801e-03f,
  1.10310592e-01f, -1.36599973e-01f, 1.99160930e-02f, 5.04425280e-02f, -6.73537236e-03f, 3.97904441e-02f, 5.42370835e-03f, 5.24270013e-02f, 7.75484294e-02f, 6.08237134e-03f,
  7.24377275e-01f, -4.92281675e-01f, 7.26026654e-01f, 2.37594068e-01f, 6.00134671e-01f, 5.70896745e-01f, 5.14488459e-01f, -3.19138058e-02f, 1.08370557e-01f, -7.42564321e-01f,
  -3.11652333e-01f, -6.49858192e-02f, 1.54997379e-01f, -3.63114297e-01f, 5.75556993e-01f, 1.25202194e-01f, -1.74190819e-01f, -1.44857019e-01f, -2.63674185e-02f, -1.07730679e-01f,
  2.17964202e-01f, -3.12038571e-01f, 4.53433067e-01f, -3.96719873e-01f, 4.07609940e-02f, -1.13590859e-01f, -3.26905072e-01f, 2.61844397e-01f, -3.68984133e-01f, 2.10959405e-01f,
  -2.27837235e-01f, -2.16974705e-01f, -1.53034866e-01f, -1.14582568e-01f, 8.07245728e-03f, -5.02937066e-04f, 6.12184219e-02f, 1.18999869e-01f, 2.09857095e-02f, 8.51120353e-02f,
  -7.76446536e-02f, 1.48787908e-02f, -9.50430557e-02f, 4.43989821e-02f, 6.32887557e-02f, 5.06824777e-02f, 1.57913417e-01f, -1.03553288e-01f, 6.36047721e-02f, 1.83031529e-01f,
  2.42752060e-01f, 5.12119569e-02f, 7.99133852e-02f, -9.95441079e-02f, 1.30348474e-01f, -8.49690214e-02f, 1.85171552e-02f, 2.27337360e-01f, -3.26506123e-02f, 6.59905598e-02f,
  1.26224801e-01f, 1.00156903e-01f, -2.04055887e-02f, -1.42437547e-01f, 3.83723318e-03f, -1.16540834e-01f, -7.09509328e-02f, 2.94837505e-02f, -1.07125014e-01f, 4.47705723e-02f,
  -8.75047594e-03f, -2.78236791e-02f, 8.45940933e-02f, 1.95077166e-01f, -4.07217629e-02f, -1.64669305e-02f, -1.37221953e-02f, -1.61091596e-01f, 1.04348727e-01f, 5.62448837e-02f,
  8.21588039e-02f, -1.54987335e-01f, -1.23499567e-02f, 8.87595341e-02f, -7.41184279e-02f, 1.40591308e-01f, -1.14900827e-01f, 1.77330866e-01f, -1.56923145e-01f, 2.00763017e-01f,
  -8.71226430e-01f, -7.98057497e-01f, -1.79361135e-01f, -1.13257267e-01f, -1.95788771e-01f, -2.34490097e-01f, -1.07007056e-01f, 2.86278618e-03f, -1.96588650e-01f, -3.15673724e-02f,
  4.62490357e-02f, -9.48273093e-02f, -1.18092328e-01f, 1.11962035e-01f, -2.64500100e-02f, 2.76990272e-02f, -1.21372886e-01f, -2.29189828e-01f, -1.48065269e-01f, -4.84538302e-02f,
  1.43578295e-02f, 9.52175558e-02f, 8.72873664e-02f, -4.55781221e-02f, -1.28148600e-01f, 1.03734761e-01f, -9.48515534e-02f, -3.04107741e-02f, 6.85683116e-02f, -8.70718062e-02f,
  -7.78615057e-01f, 6.48900688e-01f, 4.63684916e-01f, 6.21445060e-01f, -6.10365212e-01f, 4.28318083e-01f, 6.26459956e-01f, 1.62887350e-01f, 4.11483943e-01f, 4.70171183e-01f,
  -1.62354633e-01f, 1.37340605e-01f, 2.52506107e-01f, -2.37067286e-02f, 4.71755534e-01f, 5.77531457e-01f, 3.26742381e-01f, 2.53239214e-01f, 1.98835582e-01f, 1.68893740e-01f,
  1.82540566e-01f, 7.03733414e-02f, 2.87270367e-01f, -2.13631421e-01f, -3.64764571e-01f, -4.57822233e-02f, -7.91354254e-02f, -9.99542326e-03f, -2.64253408e-01f, -1.17485471e-01f,
  -4.07079220e-01f, -1.53223991e-01f, -3.33217710e-01f, 5.69735356e-02f, -1.16282962e-02f, -1.45268440e-01f, 7.15035722e-02f, 7.68925995e-02f, 3.79458331e-02f, -1.16212979e-01f,
  -2.31251642e-02f, 2.57594883e-02f, 4.69938293e-02f, 4.67130691e-02f, -1.08352013e-01f, 8.74868110e-02f, -6.99925348e-02f, -7.36107603e-02f, 2.75711492e-02f, -1.24237038e-01f,
  -7.33861476e-02f, -9.72342044e-02f, 3.54878493e-02f, -8.30776431e-03f, 3.28963213e-02f, 2.32447721e-02f, 1.21050827e-01f, -6.33537695e-02f, -1.06825486e-01f, -3.27242259e-03f,
  7.92086571e-02f, 1.89396545e-01f, 6.52711913e-02f, -1.34479165e-01f, 6.19034246e-02f, -1.47919193e-01f, 3.72526385e-02f, -2.67088264e-02f, 1.77787698e-03f, 3.76556031e-02f,
  -2.60887533e-01f, -2.51174159e-02f, -1.54510409e-01f, 6.61259368e-02f, 1.13887049e-01f, -2.86683366e-02f, 5.41590936e-02f, -1.18659586e-01f, 1.05170578e-01f, -1.23135909e-01f,
  6.89495169e-03f, 7.75078014e-02f, -8.88940170e-02f, -1.84928566e-01f, -9.99759212e-02f, 3.35840099e-02f, -1.57964192e-02f, -3.25209685e-02f, 6.86989650e-02f, -6.47461368e-03f,
  3.63482475e-01f, 5.37665427e-01f, -7.06812367e-02f, -8.10061768e-02f, 5.71817486e-03f, -1.20737769e-01f, 3.15384343e-02f, -5.30155487e-02f, 1.59317642e-01f, 1.28157660e-01f,
  7.86549598e-02f, 6.97674081e-02f, 1.36192381e-01f, -4.29672282e-03f, 1.26509860e-01f, 6.49348497e-02f, 1.47216409e-01f, 1.35593295e-01f, 2.43837535e-02f, -6.94040284e-02f,
  -6.42271638e-02f, 1.41101494e-01f, 6.17805608e-02f, 1.63840372e-02f, -8.56552497e-02f, 3.05478852e-02f, -3.18048708e-02f, -6.38503116e-03f, -6.94412179e-03f, 5.53234257e-02f,
  5.12115300e-01f, 6.72255278e-01f, 3.31829906e-01f, -2.26904247e-02f, -4.53752786e-01f, -6.45168185e-01f, -5.61487198e-01f, -2.04764500e-01f, 6.07028119e-02f, 1.53166756e-01f,
  -5.85859358e-01f, 7.88155615e-01f, -9.78485197e-02f, -2.30891272e-01f, -3.27073306e-01f, 1.31037664e-02f, -2.91790932e-01f, 1.89109325e-01f, 2.11061537e-03f, -3.67785573e-01f,
  -1.73278257e-01f, -5.28455257e-01f, -7.98581019e-02f, -4.77747768e-01f, -5.16782165e-01f, 1.26095504e-01f, -3.79335374e-01f, -3.53977531e-01f, -8.87248889e-02f, -1.90195084e-01f,
  -2.07912996e-01f, -1.39839232e-01f, 1.09415576e-02f, 3.24480236e-02f, -2.83440083e-01f, 2.56187171e-02f, -8.97589996e-02f, 5.06573319e-02f, -9.48007181e-02f, 2.02733964e-01f,
  1.81401417e-01f, -8.29370022e-02f, -1.04915366e-01f, -6.69877157e-02f, 5.02437763e-02f, 1.97910011e-01f, 4.37398143e-02f, -6.80425391e-02f, 1.98681533e-01f, 1.08864278e-01f,
  1.17887132e-01f, 1.66633576e-01f, 3.42437439e-02f, 4.78611290e-02f, -1.33025080e-01f, -5.12299389e-02f, 6.75784796e-02f, 6.09735772e-02f, 1.19418003e-01f, 2.00895861e-01f,
  1.40172124e-01f, -1.96190417e-01f, -5.18868826e-02f, 3.51933693e-03f, -1.88012943e-01f, -8.70037600e-02f, -8.46828371e-02f, -9.09415483e-02f, -1.90094579e-02f, -2.93819308e-02f,
  -1.49996758e-01f, 7.89531916e-02f, 6.57131746e-02f, -7.17885792e-02f, 7.79740736e-02f, 8.53207856e-02f, 1.55032733e-02f, 8.27336535e-02f, 3.67738381e-02f, 1.69066526e-03f,
  -6.57371953e-02f, -6.54486641e-02f, 1.83103401e-02f, -9.90381986e-02f, -1.91927209e-01f, 6.27779169e-04f, 7.51388595e-02f, 1.81125626e-01f, -2.24986728e-02f, -2.29404774e-02f,
  -2.29885891e-01f, -5.37805378e-01f, -4.97332178e-02f, -6.16482235e-02f, -8.09780695e-03f, -9.45293531e-02f, -1.20313331e-01f, 1.81721613e-01f, -2.04668298e-01f, -1.49768606e-01f,
  -1.53312996e-01f, -1.29014015e-01f, -5.42479120e-02f, 6.67201653e-02f, -3.29040661e-02f, -6.06799871e-03f, -2.36718774e-01f, 2.60471739e-02f, -1.05857395e-01f, 7.89344460e-02f,
  -3.29954848e-02f, -3.11915763e-02f, -3.45554575e-02f, -1.12941951e-01f, 2.73008235e-02f, 7.46458478e-04f, 9.94320959e-02f, 1.45504236e-01f, -9.24782157e-02f, -7.43919536e-02f,
  2.72024572e-01f, -5.64821303e-01f, -3.40752006e-01f, 1.08477458e-01f, 3.32320720e-01f, -5.58971763e-01f, -4.76856619e-01f, 2.44550016e-02f, 4.37720597e-01f, -2.65007585e-01f,
  -5.44965379e-02f, -3.73691499e-01f, -3.46080273e-01f, -4.85180348e-01f, -1.56196550e-01f, -1.08189479e-01f, -4.33251530e-01f, -4.10531521e-01f, 2.65357792e-01f, 2.74333004e-02f,
  2.58056194e-01f, -3.34501207e-01f, -4.60413277e-01f, -1.09931715e-01f, -3.35102201e-01f, 1.61038876e-01f, 3.25310379e-01f, 6.35836646e-02f, -8.60062465e-02f, -1.49482608e-01f,
  -1.78613976e-01f, 4.76805605e-02f, -8.55978280e-02f, -1.18428536e-01f, 2.18921915e-01f, -8.52132663e-02f, -7.58811608e-02f, -2.33950883e-01f, 9.51194093e-02f, 3.38458493e-02f,
  -1.19247206e-01f, -1.71698648e-02f, -6.28957525e-02f, -7.33130611e-03f, -2.11649779e-02f, -2.99422331e-02f, 1.91461295e-02f, 2.65398443e-01f, -9.14636329e-02f, -4.58001122e-02f,
  -2.56194882e-02f, 7.92792998e-03f, 2.32088000e-01f, 2.57216573e-01f, 2.11355593e-02f, 1.70868577e-03f, -6.95874691e-02f, -1.53531179e-01f, 9.76797938e-02f, 1.90837026e-01f,
  2.29147002e-02f, 2.93601215e-01f, -2.11300060e-01f, 1.20409355e-01f, -9.41967741e-02f, 9.65167489e-03f, -3.04579008e-02f, 1.67263951e-02f, 1.21246673e-01f, -1.61112234e-01f,
  2.15354878e-02f, -6.74117357e-03f, 4.12781723e-03f, -8.94859359e-02f, 9.82562974e-02f, 1.00144960e-01f, 8.59373063e-02f, -1.25503913e-01f, 1.64826527e-01f, 6.96665719e-02f,
  -7.92029947e-02f, -4.36601378e-02f, -1.69491880e-02f, 1.00921303e-01f, -4.02584150e-02f, 5.02957366e-02f, 3.18489247e-03f, -2.51863282e-02f, 1.46248892e-01f, -8.35115016e-02f,
  -8.01518932e-02f, -1.54876888e-01f, 5.52165657e-02f, -3.94177847e-02f, -5.64556196e-03f, -2.68725902e-02f, 4.74856496e-02f, -8.07396695e-02f, -2.40446910e-01f, 1.26241427e-02f,
  9.94659141e-02f, -2.10815226e-03f, 2.12790906e-01f, 4.87428643e-02f, 2.90042944e-02f, -2.03422233e-02f, 1.50851354e-01f, -1.45932389e-02f, -8.09909850e-02f, -1.00403726e-02f,
  -3.78961563e-02f, -4.38803509e-02f, 6.62106574e-02f, 8.36920887e-02f, -1.20025314e-01f, 6.72023520e-02f, -2.61659287e-02f, -2.42303982e-02f, -3.41677777e-02f, 3.57583947e-02f,
  -1.76074123e+00f, 5.26599944e-01f, -2.14526400e-01f, -3.34867477e-01f, -1.76140770e-01f, -1.31707653e-01f, -1.05194837e-01f, 3.47276255e-02f, -6.00736029e-03f, 3.69913012e-01f,
  1.00091053e-03f, -1.18427098e-01f, 3.10118437e-01f, 3.18264455e-01f, -7.11483181e-01f, 4.77915376e-01f, -4.82725829e-01f, -1.01355627e-01f, 3.79399285e-02f, -3.71577621e-01f,
  -2.38734901e-01f, 3.44771594e-02f, 8.28645900e-02f, 3.48813742e-01f, -4.26294357e-01f, -2.14374810e-01f, -1.77852884e-01f, 2.08521143e-01f, -1.52564898e-01f, 2.29551941e-02f,
  -6.60558403e-01f, -4.30900961e-01f, -2.32081205e-01f, -8.07243586e-02f, -3.93861353e-01f, -1.32933766e-01f, -1.26501262e-01f, 9.23186168e-02f, -2.13071425e-02f, -6.37256773e-03f,
  5.19605773e-03f, -2.54719220e-02f, 6.64678067e-02f, 1.92056343e-01f, 8.55540950e-03f, 1.31828949e-01f, 1.22845963e-01f, 9.80080757e-03f, 2.05999672e-01f, 1.26208499e-01f,
  1.20459147e-01f, -3.90609168e-02f, -7.94234723e-02f, 7.49812182e-03f, -2.88856681e-02f, -1.45555884e-02f, 6.02680556e-02f, -2.87043955e-02f, -2.48195380e-01f, -6.21848693e-03f,
  5.88422529e-02f, -1.74311567e-02f, 2.66401488e-02f, -1.14785535e-02f, 1.33028971e-02f, 1.11013018e-02f, -5.24749756e-02f, 1.23017083e-03f, -3.31554450e-02f, -4.05097939e-03f,
  -1.24067068e-01f, -2.14052293e-02f, -1.04908332e-01f, -2.70378031e-02f, -2.27590408e-02f, -6.74253330e-02f, -5.00426032e-02f, -4.52960506e-02f, 5.80758266e-02f, -1.62573578e-03f,
  -1.05732987e-02f, 3.79919745e-02f, 1.95265770e-01f, -2.77768038e-02f, -1.53340578e-01f, 4.20256704e-02f, 2.39972305e-02f, 1.04793020e-01f, 1.69570558e-02f, -1.42425865e-01f,
  -1.05087674e+00f, -8.01008761e-01f, -3.85696851e-02f, -2.79162019e-01f, -1.98961586e-01f, -2.36745998e-02f, 5.40347733e-02f, -8.89207050e-02f, -2.08165169e-01f, -3.95652317e-02f,
  -9.77519974e-02f, -2.74610911e-02f, -2.74627239e-01f, 3.92558277e-02f, -2.24494245e-02f, 8.29944611e-02f, -7.06291273e-02f, -6.69410527e-02f, -1.19808652e-01f, -4.83290851e-02f,
  -1.57007817e-02f, 6.21698471e-03f, 1.21629732e-02f, 3.17469463e-02f, 2.67442483e-02f, -1.26822710e-01f, -8.67478400e-02f, 1.16487816e-02f, -2.28331927e-02f, 3.77191193e-02f,
  -8.71278405e-01f, -9.78704631e-01f, 5.30935705e-01f, -4.97642398e-01f, 2.22671106e-01f, 2.12814867e-01f, -4.15700704e-01f, -2.75993645e-01f, -5.99863172e-01f, -7.20244110e-01f,
  -2.38236174e-01f, 1.33476814e-03f, -3.57080400e-01f, -5.59222810e-02f, 7.10812569e-01f, -1.18464619e-01f, -9.58486721e-02f, -3.08149487e-01f, -1.64044369e-02f, 1.09204790e-02f,
  1.07164562e-01f, -1.57536268e-02f, 3.83480370e-01f, 3.56353104e-01f, -4.51037735e-02f, 3.62506062e-02f, 2.57572591e-01f, 3.32037508e-01f, 5.25015771e-01f, 3.29151452e-01f,
  4.36368100e-02f, -1.90477207e-01f, 1.27509832e-01f, 1.46569878e-01f, -5.67415403e-03f, -9.71080735e-02f, 1.91279903e-01f, 1.36703655e-01f, 7.68179446e-02f, -1.33519918e-01f,
  -2.26680785e-02f, 7.29635283e-02f, 7.37476675e-03f, 9.88468528e-02f, -1.53883964e-01f, -4.72837884e-04f, -3.07133514e-02f, 3.67637463e-02f, 1.15509488e-01f, -7.61669427e-02f,
  -1.03901923e-02f, 7.77027607e-02f, 2.37935968e-02f, -3.50221656e-02f, 1.07021198e-01f, -8.27035531e-02f, -1.37530848e-01f, 1.14908546e-01f, -4.98937927e-02f, -8.20738971e-02f,
  8.23448673e-02f, 1.35310903e-01f, -1.10955872e-01f, 8.73335302e-02f, -4.22129445e-02f, -1.33842453e-01f, 1.44758776e-01f, 1.24495607e-02f, -3.37648243e-02f, -1.00035794e-01f,
  -4.60249037e-02f, 9.18906033e-02f, -2.14602679e-01f, -6.58513531e-02f, 4.52462817e-03f, -1.92228928e-01f, 6.04839288e-02f, -9.99678448e-02f, -2.25970484e-02f, 3.93493548e-02f,
  -1.05670668e-01f, -3.92073244e-02f, -6.08641934e-03f, -3.34260315e-02f, -4.85412553e-02f, -9.35031101e-03f, -4.58432026e-02f, 9.39701963e-03f, 4.55631427e-02f, 9.13041905e-02f,
  -6.85788810e-01f, -5.69306135e-01f, 1.19473726e-01f, -9.97911468e-02f, 4.18729074e-02f, 2.00611949e-02f, 3.01899556e-02f, -2.44398080e-02f, -3.60548906e-02f, 3.24943811e-02f,
  3.14212106e-02f, 5.23888804e-02f, -1.40117705e-01f, 2.45119147e-02f, 1.84219137e-01f, -1.58606470e-01f, 1.00437738e-03f, 1.30322471e-01f, 4.49199304e-02f, 6.75049052e-02f,
  6.45945296e-02f, -8.66004601e-02f, 1.13399155e-01f, 1.00227430e-01f, 4.10729498e-02f, -1.90533772e-02f, -7.68305436e-02f, -8.70922953e-02f, 2.07988396e-01f, 7.55981877e-02f,
  1.68507993e-01f, -3.83971274e-01f, -5.33295155e-01f, -3.05325501e-02f, 6.31583154e-01f, 4.01829898e-01f, 2.13927943e-02f, 2.86682576e-01f, -3.74438047e-01f, 3.64927128e-02f,
  2.47501761e-01f, -5.00118256e-01f, -6.50070488e-01f, 1.00075372e-01f, -1.22017458e-01f, -7.18695521e-01f, 3.13480586e-01f, 1.07559159e-01f, -2.94505507e-01f, 2.50979304e-01f,
  4.82068397e-02f, 7.34595060e-01f, -2.39597946e-01f, 6.31063104e-01f, 4.64623630e-01f, 2.47739032e-01f, 3.66624743e-01f, -1.55691013e-01f, 4.99594331e-01f, 2.85659600e-02f,
  1.30465673e-02f, -1.46277145e-01f, -1.44200295e-01f, -9.47488993e-02f, 1.13047920e-01f, 1.00560412e-01f, 8.49428922e-02f, 4.97616939e-02f, 1.99182574e-02f, -1.20095484e-01f,
  -5.78670390e-02f, 4.21093814e-02f, -4.01609056e-02f, 1.09419912e-01f, 1.99046835e-01f, 1.03721529e-01f, -1.28820941e-01f, -4.78727408e-02f, 8.27870984e-03f, -1.54132620e-01f,
  -1.80253848e-01f, -1.24519303e-01f, -6.33452833e-02f, -1.59283906e-01f, 5.32532716e-03f, -7.08650425e-02f, -2.10840572e-02f, -7.14939013e-02f, -5.01769930e-02f, 1.88562535e-02f,
  1.92060381e-01f, 8.30361992e-02f, 7.30904797e-03f, 3.41516696e-02f, 1.59745142e-01f, 2.57420726e-02f, -1.98741555e-02f, 1.33555429e-02f, -1.79987997e-01f, -5.44931069e-02f,
  -8.97268653e-02f, 1.10856313e-02f, -5.30012846e-02f, 1.65012568e-01f, 1.19091116e-01f, -5.95883913e-02f, -4.12798673e-02f, 3.48660909e-02f, 5.29298596e-02f, 5.31850830e-02f,
  -1.05353087e-01f, 8.83288458e-02f, 1.43956035e-01f, -6.49458915e-02f, -9.34456512e-02f, -6.16209880e-02f, 1.07678741e-01f, 6.51941970e-02f, -4.86612506e-02f, 8.41712952e-02f,
  4.03601397e-03f, -3.15294228e-02f, -1.19236879e-01f, -6.39302358e-02f, -1.57744601e-01f, 1.28481388e-01f, -1.57069251e-01f, 2.18516067e-02f, -3.34732514e-03f, 3.72778960e-02f,
  2.59102196e-01f, 1.18403234e-01f, 4.36709821e-02f, 1.53839737e-02f, -4.98237759e-02f, 1.52253464e-01f, 7.03118742e-02f, 9.36018229e-02f, 5.08136116e-02f, 4.15887013e-02f,
  2.33098656e-01f, 7.03868642e-02f, -6.92208707e-02f, 7.93455169e-02f, 9.51018184e-02f, -4.79009114e-02f, 1.43800929e-01f, 4.02092189e-02f, -1.12352362e-02f, -9.33589265e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.07950109e-01f, 8.35074365e-01f, 7.33393371e-01f, 3.24909598e-01f, 5.89641571e-01f, 5.38477063e-01f, 3.72189313e-01f, 8.60146046e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.41077536e-01f, 2.30726317e-01f, 7.59954080e-02f, -1.49845317e-01f, 7.61149049e-01f, -2.07770184e-01f, 7.99147904e-01f, 5.41438520e-01f, -3.69862735e-01f, 1.75912697e-02f,
  -3.32769094e-04f, 6.61236495e-02f, 2.91370630e-01f, -4.26075280e-01f, 4.11726423e-02f, 3.97020996e-01f, 2.04563394e-01f, 6.19603574e-01f, 2.85947531e-01f, -6.75195754e-01f,
  8.59947130e-02f, 2.14408547e-01f, -4.14150655e-01f, -7.54304051e-01f, -5.46577930e-01f, -2.33464628e-01f, -2.28968248e-01f, -1.04734533e-01f, 1.50792480e-01f, 3.30650628e-01f,
  2.67326027e-01f, 2.76202083e-01f, -5.80812097e-01f, -2.15355754e-01f, -3.99075091e-01f, -7.48131156e-01f, -3.04872692e-01f, 7.63997614e-01f, -6.78841352e-01f, -1.92764536e-01f,
  -1.43420314e-02f, 7.73187280e-02f, -7.17415586e-02f, -4.40374494e-01f, 2.92170972e-01f, 3.29028487e-01f, -3.81428808e-01f, 9.62017924e-02f, 7.45339453e-01f, -1.42078323e-04f,
  -2.21448183e-01f, 4.25603092e-01f, -2.39134789e-01f, -8.71932566e-01f, 7.05802143e-02f, -9.82174218e-01f, -1.77134290e-01f, 3.70131761e-01f, -2.09510088e-01f, 6.49429038e-02f,
  7.41762668e-02f, -1.63942929e-02f, 5.03105700e-01f, 5.01800850e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.13012064e+00f, -1.24375530e-01f, -2.56352425e-01f, 5.72647691e-01f, 1.35773597e-02f, -9.86033797e-01f, -5.92346787e-01f, -8.53805721e-01f, -4.51411068e-01f, 8.19086611e-01f,
  -3.93433243e-01f, -1.64784387e-01f, 8.07839811e-01f, 2.79608846e-01f, 1.29465652e+00f, 9.09438789e-01f, 3.55365813e-01f, 6.02004766e-01f, 4.37388062e-01f, 1.05085447e-01f,
  -1.41694927e+00f, 3.75699043e-01f, -1.22561073e+00f, -1.66513717e+00f, 4.77349550e-01f, -6.17984571e-02f, -7.54116997e-02f, 8.82584393e-01f, 1.45050794e-01f, 1.38370836e+00f,
  5.23567617e-01f, -6.98053598e-01f, 3.14400733e-01f, -3.44636329e-02f, -7.00020671e-01f, -3.65630984e-02f, 1.08963534e-01f, 5.04057050e-01f, -2.03988746e-01f, -2.05349922e-01f,
  1.46968138e+00f, -4.47964855e-02f, 5.08612335e-01f, 4.27335322e-01f, 9.11252856e-01f, -5.83142161e-01f, -5.95837772e-01f, 1.39952397e+00f, 4.26837385e-01f, 1.03411114e+00f,
  7.66997397e-01f, 7.71065772e-01f, -2.07344234e-01f, -8.69311035e-01f, 1.60702765e+00f, 7.64647663e-01f, 6.79843485e-01f, 1.07843256e+00f, 2.46243879e-01f, 6.37863815e-01f,
  -3.75761509e-01f, -2.19953194e-01f, 8.02547991e-01f, 4.20539021e-01f, 4.03106958e-01f, 1.37086406e-01f, 1.06308818e+00f, 1.04729903e+00f, 2.57988036e-01f, 7.28861690e-01f,
  -5.94386280e-01f, 8.10006678e-01f, 3.13702196e-01f, -6.70698239e-03f, 1.42757213e+00f, -5.35308361e-01f, -6.41870379e-01f, 1.10583365e+00f, 7.03590333e-01f, -6.89438581e-01f,
  7.95337141e-01f, 1.28924549e-01f, -5.39681725e-02f, 1.30386961e+00f, -2.57227391e-01f, -6.85299098e-01f, 1.24413216e+00f, 4.80330922e-02f, 3.64507467e-01f, 1.45541787e+00f,
  5.59710383e-01f, 5.89112163e-01f, 1.85656175e-01f, -7.05990791e-02f, -3.39259475e-01f, -6.91196859e-01f, -4.12731737e-01f, -1.03966452e-01f, 2.82169640e-01f, -1.96335122e-01f,
  6.39495969e-01f, -1.43401148e-02f, 5.38459301e-01f, 7.01929331e-01f, -1.09599255e-01f, -1.58307597e-01f, 4.10156578e-01f, 9.77125406e-01f, 1.06477833e+00f, 4.32291836e-01f,
  -7.99795032e-01f, -1.50667354e-02f, 1.11692145e-01f, 1.32334876e+00f, 5.43993354e-01f, -4.16741788e-01f, 7.92536080e-01f, 3.82712752e-01f, 1.12066187e-01f, 1.09666198e-01f,
  -9.90417659e-01f, -1.95813969e-01f, 4.91307348e-01f, 1.65711883e-02f, 2.79992849e-01f, 9.87628460e-01f, 4.17644531e-01f, 7.54676819e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.48066473e-01f, 7.99061596e-01f, 6.78336680e-01f, 3.79869014e-01f, 6.72393918e-01f, 2.09043160e-01f, 8.65936339e-01f, 1.13282323e+00f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  5.42282164e-01f, 6.07631981e-01f, 1.96780652e-01f, -5.74897766e-01f, -7.31066167e-01f, 4.90056902e-01f, 8.29306662e-01f, -7.64101326e-01f, -1.23147154e+00f, -1.77587539e-01f,
  -9.52695966e-01f, -1.25909209e+00f, 9.67143655e-01f, -1.03780198e+00f, 5.80079556e-01f, 5.06989300e-01f, -6.63645506e-01f, 8.97687733e-01f, 8.18318725e-01f, -1.22942358e-01f,
  8.79975021e-01f, 8.67468834e-01f, 3.94134283e-01f, -1.20527267e+00f, -6.60969734e-01f, -1.34691679e+00f, 5.17460763e-01f, 1.89857930e-02f, -3.34809572e-01f, -1.18011737e+00f,
  4.67624336e-01f, 7.74778485e-01f, -6.95946455e-01f, -1.04013339e-01f, -5.04994273e-01f, -4.85083073e-01f, 4.63933915e-01f, 6.94337547e-01f, -6.57471240e-01f, 6.04680240e-01f,
  8.43577564e-01f, -1.24322939e+00f, -2.61866778e-01f, 3.90094995e-01f, -6.37769580e-01f, -1.34813535e+00f, -1.30912590e+00f, 3.34214956e-01f, -5.31910241e-01f, -5.11468232e-01f,
  -3.56580198e-01f, 1.02262211e+00f, -7.51683891e-01f, 2.92570114e-01f, 8.50527763e-01f, 1.32916078e-01f, -2.90208787e-01f, 9.88952279e-01f, -6.36252344e-01f, -1.35918021e+00f,
  -2.50810266e-01f, -1.19189727e+00f, 5.37048951e-02f, 4.99107778e-01f, 1.41942305e-02f, 3.87837254e-02f, 8.81411076e-01f, -2.02051550e-01f, -9.62262690e-01f, 1.15462053e+00f,
  -5.50569117e-01f, 6.15219295e-01f, 1.43723279e-01f, 4.59926188e-01f, -1.11076677e+00f, 2.84416005e-02f, 4.41074580e-01f, 8.98732021e-02f, -7.08601594e-01f, 2.22252849e-02f,
  3.72152090e-01f, -1.99239731e-01f, -1.15172470e+00f, 8.03147316e-01f, 6.56990290e-01f, -9.75436747e-01f, -8.97544086e-01f, -5.76387644e-01f, -1.28068125e+00f, -1.04782796e+00f,
  -3.32554311e-01f, 1.41181260e-01f, 6.36954546e-01f, 5.15511870e-01f, 2.82667935e-01f, 1.08998820e-01f, 4.62089539e-01f, -2.48732716e-01f, 9.25726533e-01f, -3.31568420e-01f,
  4.84172672e-01f, -8.68737519e-01f, -1.67345852e-01f, 6.18894935e-01f, 2.82222271e-01f, -1.32166684e+00f, 3.72359931e-01f, 7.28150606e-02f, -1.37827110e+00f, 7.88219035e-01f,
  -9.04530287e-02f, -8.98830473e-01f, -2.07471713e-01f, 1.68076605e-01f, -1.06804006e-01f, -6.65930033e-01f, 1.98792100e-01f, 7.42109179e-01f, -2.47703657e-01f, 5.11467218e-01f,
  2.31649846e-01f, 4.61537033e-01f, -1.89028099e-01f, -6.90544665e-01f, -1.44664943e+00f, 2.17202947e-01f, 7.65830219e-01f, -4.57828939e-01f, -2.65039772e-01f, -2.59167999e-01f,
  5.82967579e-01f, 3.16574037e-01f, -7.05721021e-01f, -8.05907011e-01f, 3.48361790e-01f, -3.48824888e-01f, -1.29591674e-01f, 2.68428594e-01f, 8.90996516e-01f, -3.63233179e-01f,
  7.34858334e-01f, -1.01249027e+00f, -6.68362916e-01f, -1.31655419e+00f, -2.99705006e-02f, 3.11003566e-01f, -1.30219233e+00f, -4.39652652e-01f, 5.84530711e-01f, -7.08509505e-01f,
  -7.25535816e-03f, 2.86889374e-01f, 3.52346711e-02f, -8.83231401e-01f, -1.74939704e+00f, 6.14184618e-01f, 6.86788633e-02f, 6.64908111e-01f, -1.13455689e+00f, -6.41539544e-02f,
  4.29084390e-01f, -1.14746070e+00f, 2.67151576e-02f, 2.02709377e-01f, 7.28118896e-01f, 3.90072614e-01f, 9.63618219e-01f, 1.15086865e+00f, 7.17132747e-01f, -1.64918274e-01f,
  6.66555107e-01f, -1.67723596e+00f, -1.15006614e+00f, -9.39593494e-01f, -5.01519382e-01f, 4.00911152e-01f, -7.84609318e-02f, -1.32036686e-01f, -6.84479296e-01f, 2.12720469e-01f,
  -5.63697755e-01f, -4.43260342e-01f, -6.01355672e-01f, 3.32490087e-01f, -1.47427297e+00f, 5.36662221e-01f, 3.80409718e-01f, 5.08836031e-01f, -1.24773526e+00f, 3.02391917e-01f,
  2.64630802e-02f, -1.20539129e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.72829661e-03f, 6.25500441e-01f, 1.33678496e-01f, 1.13122396e-01f, -2.68969815e-02f, -7.68274441e-02f, 8.25425908e-02f, -3.72632772e-01f, 3.51695240e-01f, -4.50872518e-02f,
  8.23137909e-02f, -3.49705279e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    