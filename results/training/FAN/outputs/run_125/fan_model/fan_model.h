/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.33152384e-01f, 2.47566193e-01f, -1.97354808e-01f, 7.75527135e-02f, -2.17558965e-01f, -3.25342178e-01f, -1.24008441e-02f, -3.55949029e-02f, -1.96645901e-01f, 2.43995599e-02f,
  -8.64864737e-02f, 1.53091937e-01f, 1.30633009e-04f, 5.81406280e-02f, -2.34227747e-01f, 9.51678753e-02f, -2.72092134e-01f, -8.42526406e-02f, 1.99862756e-02f, 1.50396451e-02f,
  -7.81239523e-03f, 1.30211841e-02f, 2.11383745e-01f, 1.89383496e-02f, -5.39274178e-02f, -2.02931687e-02f, -1.37102365e-01f, 6.65025637e-02f, -8.81349519e-02f, -1.06696054e-01f,
  -4.77864817e-02f, 1.04964161e-02f, -4.03865539e-02f, -8.21961537e-02f, -1.67168245e-01f, -5.26439510e-02f, -5.50362431e-02f, 1.06806956e-01f, -1.94758531e-02f, 5.87667190e-02f,
  -1.75736193e-02f, 8.76885951e-02f, 4.75223809e-02f, -2.82042865e-02f, -7.82628953e-02f, 4.56967987e-02f, 4.47759330e-02f, -1.96139775e-02f, 1.03335395e-01f, 1.18115745e-01f,
  1.92095749e-02f, -8.88343155e-03f, 4.03021276e-02f, 8.25244039e-02f, -1.53317684e-02f, 9.26774219e-02f, -5.91056282e-03f, -2.25379132e-02f, -1.01220839e-01f, -8.76242220e-02f,
  4.39020097e-02f, -1.69180498e-01f, 2.98252758e-02f, -1.30966783e-01f, -5.47542498e-02f, -1.78262088e-02f, -8.03814754e-02f, -3.09326109e-02f, 3.30997705e-02f, -6.66453466e-02f,
  -1.43766642e-01f, -4.52786088e-02f, 8.20724443e-02f, 1.90329850e-02f, -9.56345201e-02f, -5.91691118e-03f, -2.41227616e-02f, 4.93459404e-02f, -6.98315501e-02f, -1.31905451e-02f,
  9.60606039e-02f, -9.05808955e-02f, -5.23761101e-02f, 8.70790146e-03f, 3.97707857e-02f, -4.42560762e-02f, -1.24595966e-02f, 9.01893526e-02f, 6.70554787e-02f, -1.24895759e-02f,
  -2.83208787e-01f, -1.94894627e-01f, 4.81161065e-02f, -1.48304095e-02f, -3.37034315e-02f, -1.94631778e-02f, 3.47458608e-02f, -3.16823646e-02f, -5.11176288e-02f, -1.13562800e-01f,
  -7.41261840e-02f, 1.17804082e-02f, -1.15848511e-01f, -2.49229949e-02f, -5.49786724e-02f, -3.42904329e-02f, 1.17909061e-02f, 3.69298793e-02f, -8.04993957e-02f, -3.41838971e-02f,
  1.67618021e-02f, -7.24943951e-02f, 1.24835491e-01f, -4.97176219e-03f, -8.98030400e-03f, -3.64340842e-02f, -4.01433185e-02f, -2.43190546e-02f, 1.00732269e-02f, -1.11838803e-01f,
  -2.19651356e-01f, -1.46295682e-01f, 3.54410894e-02f, -2.17685103e-01f, 2.48072576e-03f, 1.09838858e-01f, 1.21977173e-01f, -1.78502262e-01f, 3.43147069e-02f, -5.43935969e-03f,
  -9.24319029e-02f, -4.10954431e-02f, 1.45764565e-02f, -4.58308198e-02f, 1.82049647e-01f, 7.22890645e-02f, 7.77113885e-02f, 5.25911488e-02f, 4.20787372e-02f, -4.35939319e-02f,
  -5.82277998e-02f, -5.35879508e-02f, -4.13214937e-02f, -1.63146138e-01f, -8.65080208e-02f, -6.07768521e-02f, -1.91766750e-02f, -3.19498107e-02f, 4.88680676e-02f, 6.52793348e-02f,
  -1.68271512e-01f, -1.69736058e-01f, -4.06185500e-02f, 8.28827992e-02f, -3.18446383e-02f, 3.50835733e-02f, 4.49432321e-02f, 9.76840779e-02f, -1.50326733e-03f, -4.02504802e-02f,
  6.41542226e-02f, 9.81489848e-03f, -5.12880906e-02f, 8.96234140e-02f, 3.03868633e-02f, -5.94915561e-02f, 4.03725430e-02f, -9.16142166e-02f, -6.27342286e-03f, 2.55881045e-02f,
  -1.35053555e-02f, -8.49240180e-03f, 4.35739122e-02f, -5.81843872e-03f, 4.63395342e-02f, -6.89066201e-02f, 7.84129351e-02f, 3.12917726e-03f, -4.32004295e-02f, -3.96451615e-02f,
  1.21442871e-02f, 6.49097413e-02f, 4.83378842e-02f, -1.06004603e-01f, -6.27572685e-02f, -7.53458366e-02f, 9.12585333e-02f, -7.86551740e-03f, 7.49946311e-02f, -8.42267424e-02f,
  -3.92179042e-02f, -5.22595793e-02f, 2.67099906e-02f, 7.37188458e-02f, 4.94252592e-02f, -1.55427046e-02f, 9.22865886e-03f, -4.06386144e-02f, 1.14393327e-02f, -6.97779730e-02f,
  6.82390556e-02f, 8.35505202e-02f, -1.42303512e-01f, -1.96854416e-02f, 3.05863395e-02f, 1.20620757e-01f, 2.18307525e-02f, 5.35081774e-02f, -4.02661674e-02f, 2.34856140e-02f,
  -1.23535637e-02f, -1.61845773e-01f, -1.70852356e-02f, -3.88264023e-02f, -1.92761384e-02f, 3.99609022e-02f, 2.03591883e-01f, 6.64031506e-02f, 8.02290291e-02f, -5.74562959e-02f,
  8.20460320e-02f, -5.95444329e-02f, -8.68479833e-02f, -3.74804623e-02f, 9.56247747e-02f, 2.15661693e-02f, 1.02547705e-01f, -1.41536757e-01f, -3.94031182e-02f, -1.18406862e-02f,
  -5.51896319e-02f, -7.94648677e-02f, 9.10099149e-02f, -2.03623213e-02f, -4.60108779e-02f, 3.10374741e-02f, 3.67862768e-02f, -6.36196882e-02f, 9.41330940e-02f, 7.64055476e-02f,
  -1.69605523e-01f, 7.72966817e-02f, -8.38418752e-02f, 1.60574555e-01f, -9.28436741e-02f, -1.95699543e-01f, -9.90546644e-02f, 6.47685900e-02f, 6.27434850e-02f, 1.67405367e-01f,
  3.72998863e-02f, 1.89615458e-01f, -1.00445785e-01f, 1.58288717e-01f, -3.31865311e-01f, -7.22783133e-02f, 4.29738835e-02f, 2.05092520e-01f, 1.02089919e-01f, -2.27327868e-02f,
  6.51826849e-03f, 1.34002147e-02f, -1.10378653e-01f, 8.11541304e-02f, -7.66337663e-02f, 4.57338877e-02f, 1.72269531e-02f, -3.38853262e-02f, 1.58593714e-01f, 3.26390751e-03f,
  -1.91706166e-01f, 2.03674454e-02f, -6.52226852e-03f, 1.06424121e-02f, 5.38996770e-04f, 3.27563360e-02f, -3.41100954e-02f, 8.41299370e-02f, -5.93545102e-02f, 8.16179290e-02f,
  1.20435379e-01f, -5.02868108e-02f, 4.22713310e-02f, 4.25213315e-02f, 1.27701327e-01f, 3.63334045e-02f, -2.56354418e-02f, -1.93568338e-02f, 2.87496727e-02f, -7.72467814e-03f,
  2.92475130e-02f, -2.49713734e-02f, 1.59323931e-01f, 5.95744252e-02f, 9.04513430e-03f, 2.17222013e-02f, 4.59437817e-02f, 2.44311038e-02f, -3.81592102e-02f, 1.44809395e-01f,
  4.53955606e-02f, -4.92405556e-02f, 3.51899564e-02f, -3.73402834e-02f, -3.22420709e-03f, 6.18199743e-02f, 3.62553522e-02f, 5.71285549e-04f, 6.21866919e-02f, -7.92651847e-02f,
  -1.84301838e-01f, -7.20255449e-02f, 1.22746406e-02f, 5.46060763e-02f, -1.01350704e-02f, 4.61708456e-02f, 1.16751390e-03f, 4.41718027e-02f, 1.27058383e-02f, -1.72686968e-02f,
  3.37739326e-02f, 3.54395434e-03f, -6.48048744e-02f, 8.38290006e-02f, -4.40934934e-02f, -3.48173492e-02f, 1.20549537e-01f, 2.90142074e-02f, -2.31802016e-02f, -1.05355866e-01f,
  -1.78265981e-02f, -2.86866259e-02f, 1.17661227e-02f, -5.59646226e-02f, -2.04595532e-02f, 3.03755011e-02f, -1.93877667e-02f, 5.97760081e-02f, -2.87357327e-02f, -5.28175384e-02f,
  1.01241589e-01f, 6.69887736e-02f, -7.39115551e-02f, -9.04594432e-04f, 1.55826081e-02f, -5.26969731e-02f, 2.10335068e-02f, 1.76193379e-02f, 1.26908556e-01f, 5.02603799e-02f,
  3.49872448e-02f, 4.99845408e-02f, -2.77029481e-02f, -4.78472300e-02f, 1.55509844e-01f, 4.85442430e-02f, -2.31989082e-02f, -1.54647352e-02f, 4.12776694e-02f, -2.29651630e-02f,
  4.35241014e-01f, -2.79502459e-02f, 1.49787396e-01f, 1.34415373e-01f, 1.80203735e-03f, -5.29332645e-02f, 1.25780597e-01f, -1.55305639e-02f, 2.36394390e-01f, 1.27690053e-02f,
  -1.17297336e-01f, 2.60661006e-01f, -9.85304713e-02f, -2.11287901e-01f, 4.51477952e-02f, -1.24401852e-01f, -3.89094763e-02f, 1.45690799e-01f, -3.19502987e-02f, 6.03280663e-02f,
  -5.87629005e-02f, -2.75881737e-01f, -4.14561667e-02f, -1.08779013e-01f, 1.23906797e-02f, 5.08206822e-02f, -3.31178866e-02f, -1.37217015e-01f, -9.16367099e-02f, -1.68882292e-02f,
  -6.17026612e-02f, -1.57358035e-01f, -6.78240433e-02f, -1.43213704e-01f, -1.16283316e-02f, -3.78843695e-02f, -3.33205536e-02f, -8.06347281e-03f, -7.42445067e-02f, 1.38210990e-02f,
  5.46205342e-02f, -1.36093458e-03f, 2.79683303e-02f, -6.94874767e-03f, 8.35638493e-02f, -6.98943017e-03f, 6.40852600e-02f, 7.30971545e-02f, 7.55818710e-02f, 1.37322292e-01f,
  4.49096784e-02f, 6.59642816e-02f, 2.33829170e-02f, 3.70379463e-02f, 6.22767173e-02f, 9.01352614e-02f, 6.13728538e-02f, 2.32600626e-02f, 2.08068290e-04f, 1.51750371e-01f,
  1.28129125e-01f, -6.04069186e-03f, -6.60262853e-02f, 1.43024968e-02f, -5.16781956e-02f, -4.29605041e-03f, -4.41177003e-02f, 1.24560874e-02f, -1.10052405e-02f, -3.04639433e-02f,
  -2.39796471e-02f, -4.58668880e-02f, 1.83463730e-02f, 1.05273686e-02f, 2.30932906e-02f, 3.77657898e-02f, 9.59417000e-02f, -8.20276961e-02f, 1.31108277e-02f, 1.81742348e-02f,
  3.86220613e-03f, -1.65764224e-02f, 5.93658313e-02f, 5.85361794e-02f, -5.37544116e-02f, 4.30368669e-02f, 2.69996114e-02f, 5.19054122e-02f, -4.81163450e-02f, -1.40744403e-01f,
  -8.79197940e-02f, -4.55054604e-02f, -1.64140001e-01f, -1.01065241e-01f, -4.66752984e-02f, -3.27261947e-02f, -1.50367633e-01f, -9.74657945e-03f, -1.11900479e-01f, 1.76999741e-03f,
  6.85805380e-02f, 1.38645321e-02f, 7.57997716e-03f, -9.52462107e-03f, -2.62709521e-03f, 5.06040603e-02f, -2.67009195e-02f, -5.76912910e-02f, 4.22468334e-02f, 1.05041908e-02f,
  4.65014279e-02f, 4.68758196e-02f, -1.40589662e-02f, -8.01202725e-04f, 4.48253788e-02f, 7.75611773e-02f, 3.32667902e-02f, 1.16087995e-01f, 1.04735689e-02f, -3.67429741e-02f,
  1.98984459e-01f, -2.88600381e-02f, -1.00553453e-01f, -1.95784926e-01f, 4.19295169e-02f, -3.97828072e-01f, -1.72607735e-01f, -2.41517313e-02f, -2.56805196e-02f, -9.89293978e-02f,
  -2.74797366e-03f, 1.22077458e-01f, -4.38798741e-02f, -1.94298685e-01f, -1.76524788e-01f, -6.37959018e-02f, -2.81282783e-01f, -5.49028963e-02f, 2.91753318e-02f, 4.92301360e-02f,
  -9.71072838e-02f, -1.01181515e-01f, -1.70500487e-01f, -1.50467856e-02f, -7.15128034e-02f, 4.74817269e-02f, 1.79265380e-01f, 1.05105981e-01f, -2.89101060e-02f, 4.11818102e-02f,
  -1.20539144e-01f, 1.06983297e-01f, -9.56054702e-02f, -4.52456810e-02f, -1.72065869e-02f, -2.91397702e-02f, -2.20325384e-02f, 1.05928414e-01f, 1.67327840e-02f, 6.37759492e-02f,
  1.43730253e-01f, -2.64454465e-02f, 3.90342250e-02f, -2.10654195e-02f, 7.83307943e-03f, -7.62963593e-02f, -1.40620425e-01f, -4.76091094e-02f, -7.76015371e-02f, 8.32764134e-02f,
  -3.86728421e-02f, 7.49811009e-02f, -2.23410362e-03f, -4.11434360e-02f, -4.44768369e-02f, -2.71313805e-02f, -5.28816395e-02f, 7.87542388e-02f, 8.63461010e-03f, 7.40985200e-02f,
  1.06554039e-01f, -1.95759218e-02f, -3.93884555e-02f, -4.61501479e-02f, -8.98984075e-03f, 6.86011389e-02f, 3.86257432e-02f, -9.09271184e-03f, -3.55336145e-02f, -9.27893445e-02f,
  -1.56129636e-02f, -2.52122208e-02f, 9.68926102e-02f, -5.39382063e-02f, -1.94044653e-02f, -8.21041912e-02f, -8.47664252e-02f, 6.55215047e-03f, -1.22582965e-01f, -5.02242744e-02f,
  5.07380590e-02f, -3.45588997e-02f, 1.07995607e-02f, 1.72561128e-02f, 2.91972067e-02f, 3.51047292e-02f, 4.52552065e-02f, -1.83369443e-02f, -2.82051750e-02f, 5.48533425e-02f,
  3.72128338e-02f, 9.74265710e-02f, -7.65727237e-02f, -9.24739018e-02f, -2.95091048e-02f, -8.27078074e-02f, 4.77112224e-03f, 8.20192099e-02f, 4.65031527e-02f, 8.94352868e-02f,
  2.57539656e-02f, -6.30162358e-02f, 9.22112241e-02f, 2.99425237e-03f, 4.43975367e-02f, -3.56353633e-02f, -3.14360820e-02f, -2.34115566e-03f, 1.17009521e-01f, 8.68348032e-02f,
  9.21254680e-02f, 1.15023002e-01f, 1.33094341e-01f, 1.17523074e-02f, 3.68803963e-02f, 5.02512865e-02f, 1.87148601e-02f, 1.24492720e-02f, 2.02118251e-02f, 5.10056615e-02f,
  -2.63376564e-01f, -8.10585916e-02f, 1.76503748e-01f, -1.53164029e-01f, 7.90505484e-02f, -5.15118428e-02f, -2.42635146e-01f, 3.79577242e-02f, -5.37429489e-02f, -1.38919771e-01f,
  -2.35034928e-01f, -5.08211413e-03f, -4.65071090e-02f, -3.96281146e-02f, 9.17142704e-02f, -1.58551112e-01f, -7.28934407e-02f, -1.42934769e-01f, 6.08414784e-02f, -9.29552019e-02f,
  1.53825268e-01f, -1.08344303e-02f, -9.27994121e-03f, 1.14729941e-01f, 1.87685229e-02f, 3.22161242e-02f, -8.77434462e-02f, 6.67599496e-03f, 1.54262511e-02f, 9.17721093e-02f,
  -7.07989037e-02f, 5.28885459e-04f, 6.23560958e-02f, 1.15978681e-02f, -1.02113917e-01f, -5.18733561e-02f, 1.13168340e-02f, 4.70492803e-02f, 1.17257079e-02f, -1.62019935e-02f,
  -2.75419187e-02f, -1.63029879e-02f, 1.06839314e-01f, 3.63252237e-02f, -3.56763601e-02f, 9.81442854e-02f, 1.76560748e-02f, 3.14702024e-03f, 3.29940729e-02f, 5.72299846e-02f,
  9.99021605e-02f, 1.20595060e-01f, 3.97894979e-02f, -6.74034527e-04f, 6.52905330e-02f, 2.64312513e-02f, 1.10408314e-01f, 5.44391200e-03f, 1.80417653e-02f, 3.53270024e-02f,
  -3.90633605e-02f, 6.50312006e-02f, 1.33113578e-01f, 2.37024613e-02f, 7.13961869e-02f, 2.09380407e-02f, 1.46731228e-01f, 7.54021481e-02f, 4.33010943e-02f, -9.88319814e-02f,
  -9.42347199e-02f, -3.82817797e-02f, -1.18196793e-02f, 2.84324232e-02f, 6.01881966e-02f, -4.25017513e-02f, -8.35984424e-02f, 8.64784047e-02f, -4.08698944e-03f, -1.56738479e-02f,
  2.83958763e-02f, 2.00389400e-02f, -1.96143426e-02f, -1.32764995e-01f, 5.44709861e-02f, 8.30014125e-02f, 5.95108531e-02f, -5.69139421e-02f, -9.63994935e-02f, 2.69976314e-02f,
  -1.32634550e-01f, -3.43467034e-02f, 7.51347616e-02f, -1.03322387e-01f, -5.79336993e-02f, -7.00472221e-02f, 1.26025334e-01f, 6.17487505e-02f, -5.71676902e-02f, -1.44922987e-01f,
  -5.28028719e-02f, 3.65873612e-03f, -4.78896946e-02f, 8.33041035e-03f, -4.62174080e-02f, -1.93648506e-02f, -9.37104151e-02f, -2.21561035e-03f, -2.81370655e-02f, 2.61042379e-02f,
  -9.47379321e-02f, -2.85989475e-02f, 7.57660642e-02f, -2.22062296e-03f, -4.98759486e-02f, -5.64493239e-03f, -7.02466369e-02f, -3.85819525e-02f, 1.52402669e-01f, 3.51655968e-02f,
  2.79868931e-01f, 3.89757268e-02f, -1.81788635e-02f, 4.45463359e-02f, 1.41954586e-01f, -5.36693782e-02f, -2.39692498e-02f, 9.66145173e-02f, 2.94952951e-02f, -5.21884635e-02f,
  3.52472067e-02f, -6.04380714e-03f, 4.26327996e-02f, 1.73441600e-02f, 2.13918164e-01f, -5.11247963e-02f, 8.24305117e-02f, -9.09989551e-02f, -9.31579322e-02f, 1.00105293e-01f,
  2.40098387e-02f, 1.49168193e-01f, -2.19935812e-02f, 1.29193030e-02f, 1.79447994e-01f, -1.47183642e-01f, 1.47001430e-01f, 2.46679224e-02f, -2.22281385e-02f, 2.31468491e-02f,
  1.55619517e-01f, 1.01155661e-01f, -3.12946774e-02f, -6.40201271e-02f, 2.04890524e-03f, 7.54894456e-03f, -8.70741010e-02f, -1.06970213e-01f, -8.49164724e-02f, -3.44561972e-02f,
  -9.22238547e-03f, 2.08414197e-02f, 1.65922195e-03f, -1.11343630e-01f, -6.62416890e-02f, 6.03690110e-02f, 4.76695895e-02f, -1.17294684e-01f, -1.61516648e-02f, 2.92570759e-02f,
  -2.18210761e-02f, 8.12535658e-02f, -3.90472193e-03f, 2.94265058e-02f, -1.14124473e-02f, 2.02000737e-02f, -4.21952596e-03f, 2.77837068e-02f, 5.54814823e-02f, -5.58727607e-02f,
  -2.08430849e-02f, -2.46423850e-04f, -5.16785833e-04f, -3.20980176e-02f, -1.29895080e-02f, 9.87636745e-02f, -2.83877980e-02f, -2.34546605e-02f, -1.97703585e-01f, 6.23073131e-02f,
  5.09382635e-02f, 8.43863413e-02f, -3.61842476e-02f, -2.86077932e-02f, -5.39560579e-02f, 1.63807031e-02f, -5.05275950e-02f, 3.16696502e-02f, -5.97705916e-02f, -4.62934002e-02f,
  1.23101017e-02f, -4.47451770e-02f, 8.28585923e-02f, -3.71762067e-02f, 1.91975676e-03f, 1.78144835e-02f, 7.58106355e-03f, 1.57610662e-02f, -1.56923085e-02f, -2.58759689e-02f,
  1.61455289e-01f, 2.49416471e-01f, -3.13808769e-02f, 9.46208611e-02f, -5.70937842e-02f, -6.87472001e-02f, -9.10918601e-03f, -9.12019834e-02f, -7.06347898e-02f, -1.31703289e-02f,
  -1.22289412e-01f, 6.03884235e-02f, 1.35552242e-01f, 5.49342036e-02f, 2.84150280e-02f, 1.45818363e-03f, -4.13524956e-02f, -4.66581248e-02f, 1.44288272e-01f, 7.00529516e-02f,
  6.09223023e-02f, 6.52939305e-02f, -1.95077732e-02f, 7.77401254e-02f, 1.45520465e-02f, 4.74133082e-02f, 1.33542363e-02f, -9.11902264e-03f, 1.06702715e-01f, -4.28962260e-02f,
  -7.62416050e-02f, 1.10896111e-01f, 2.09372491e-01f, 1.38047516e-01f, -5.29152453e-02f, -2.73739159e-01f, -5.56627102e-02f, 2.12313309e-01f, 2.62584519e-02f, 1.31492736e-02f,
  -1.38732120e-01f, -1.75826043e-01f, -4.16647317e-03f, -1.98453605e-01f, -3.83252889e-01f, -3.58928144e-02f, -2.46849135e-01f, -2.00291365e-01f, 1.89719759e-02f, 2.33426262e-02f,
  -1.96615793e-02f, -9.61846709e-02f, 1.35781854e-01f, 1.11380830e-01f, 1.27567276e-01f, 2.53334284e-01f, 2.22107872e-01f, 1.00028165e-01f, 1.36350736e-01f, -1.05169930e-01f,
  -1.24087714e-01f, -7.41658434e-02f, 1.02042757e-01f, -8.18730425e-03f, 5.53919114e-02f, -7.38650411e-02f, -2.54202187e-02f, -3.73677409e-04f, 4.34403531e-02f, -1.71657780e-03f,
  1.01346495e-02f, -5.75303435e-02f, -3.21701169e-02f, -5.00215776e-02f, -7.80948773e-02f, 8.54544062e-03f, -1.18246533e-01f, 7.31846178e-03f, -3.96316312e-02f, 7.10944459e-03f,
  -4.36462201e-02f, -4.23341170e-02f, -8.47201869e-02f, 6.14390783e-02f, 8.04837570e-02f, -3.93880606e-02f, 4.48984429e-02f, -5.28806113e-02f, -4.71054427e-02f, 9.81212314e-03f,
  6.51956797e-02f, 1.91468410e-02f, 3.35360989e-02f, -2.41016094e-02f, 3.76082473e-02f, 4.79529165e-02f, -9.34241787e-02f, -4.52431515e-02f, -8.76590908e-02f, 3.16122174e-02f,
  -1.24049552e-01f, -4.22796048e-02f, -2.69418322e-02f, -2.44412478e-02f, -7.92652816e-02f, 4.90147108e-03f, -3.49980816e-02f, 6.96314573e-02f, 1.35887444e-01f, 1.24890603e-01f,
  -2.60261707e-02f, -4.68600318e-02f, -9.16317943e-03f, 7.45277926e-02f, -1.04324073e-01f, 2.93403380e-02f, -3.32684144e-02f, 1.35967165e-01f, 7.16001466e-02f, -7.03459457e-02f,
  3.74093093e-02f, 9.90275070e-02f, 8.19363371e-02f, 5.30796945e-02f, -4.72844392e-02f, -1.01712607e-01f, -6.27357662e-02f, 2.11962909e-02f, -3.27778831e-02f, 9.11823660e-02f,
  -8.12743139e-03f, 3.63591127e-02f, 2.82642394e-02f, -4.43923883e-02f, -1.54722799e-02f, -2.31043566e-02f, -5.82047738e-02f, 8.33482575e-03f, 4.86362819e-03f, 5.87959997e-02f,
  1.02336198e-01f, 1.21297641e-02f, -8.69635642e-02f, 1.14444725e-01f, 2.57618371e-02f, -1.32155167e-02f, 1.81543697e-02f, -5.69415558e-03f, -1.39338905e-02f, -1.43857496e-02f,
  -4.23255354e-01f, 4.15160134e-02f, 6.84738159e-02f, -1.16674505e-01f, -5.38230948e-02f, 8.00919905e-02f, 1.45400614e-01f, -5.92290238e-02f, 4.15914766e-02f, 1.06362604e-01f,
  -8.13537911e-02f, 1.30988270e-01f, 5.19980527e-02f, -2.53567267e-02f, -2.41278678e-01f, 1.50859207e-01f, -1.40477940e-01f, -4.77664806e-02f, 6.64473373e-06f, -6.71697333e-02f,
  -3.08945142e-02f, -1.78606100e-02f, 3.07866256e-04f, -2.98092626e-02f, -3.00103053e-02f, -9.20618773e-02f, -1.67544916e-01f, 9.57977623e-02f, -1.64454803e-02f, 1.14171118e-01f,
  1.68393981e-02f, -4.74162847e-02f, 9.45907906e-02f, 3.07876850e-03f, 1.18364738e-02f, -2.73012444e-02f, -7.48532116e-02f, -8.24267566e-02f, -1.67387612e-02f, 6.41302019e-02f,
  -1.52929053e-02f, -6.56966269e-02f, 4.80679497e-02f, 5.52079789e-02f, -8.76854826e-03f, 8.53723437e-02f, 2.75264662e-02f, -9.01217088e-02f, 1.51325231e-02f, -6.61600083e-02f,
  9.12373811e-02f, -7.62978122e-02f, -1.54747650e-01f, 9.39061195e-02f, -1.54968249e-02f, -1.69430852e-01f, 4.80311401e-02f, 6.75628148e-03f, 2.20927838e-02f, 7.68306255e-02f,
  -7.58226886e-02f, -2.08968180e-03f, -2.60982439e-02f, -2.64607370e-02f, 1.19233048e-02f, -6.91328719e-02f, -1.18075900e-01f, -2.94381287e-02f, 2.20713373e-02f, 6.41125068e-02f,
  3.29235345e-02f, -4.13681716e-02f, -9.08152610e-02f, -3.88795361e-02f, -5.09700440e-02f, -8.00592825e-03f, 1.49805946e-02f, -9.45537584e-04f, 1.22190729e-01f, -2.98256930e-02f,
  -6.29384145e-02f, -4.04129690e-03f, 6.22658022e-02f, 3.18121910e-02f, -8.13985318e-02f, -2.69179773e-02f, 8.04115534e-02f, 7.98912123e-02f, -2.04638913e-02f, -3.17758434e-02f,
  -4.64781094e-03f, -8.99583325e-02f, 6.02892935e-02f, 2.37163901e-02f, 7.93113634e-02f, 8.13189372e-02f, 3.79697978e-02f, 4.60120291e-02f, -1.19130775e-01f, 1.43246735e-02f,
  -4.33618613e-02f, -2.97350297e-03f, 3.88007499e-02f, 6.08626343e-02f, 2.06093956e-02f, 5.77864386e-02f, -1.02799870e-01f, 1.10835610e-02f, 3.63598019e-03f, -8.10656548e-02f,
  -1.24523185e-01f, -2.04818938e-02f, -7.08114803e-02f, 1.73916090e-02f, -1.00866526e-01f, -1.33430824e-01f, -6.33704439e-02f, 3.92543338e-02f, 2.42987033e-02f, 6.90232441e-02f,
  -7.30336010e-02f, -6.51362538e-02f, -1.42263323e-01f, -2.72936951e-02f, 1.18541315e-01f, -3.48550268e-02f, -2.72651196e-01f, 1.71057940e-01f, -1.46224409e-01f, 6.56705797e-02f,
  -5.24318106e-02f, -2.79777616e-01f, -1.42361686e-01f, 1.45130292e-01f, -2.18993142e-01f, -1.39562726e-01f, 1.08080111e-01f, -4.02023233e-02f, 2.25382932e-02f, 9.15322155e-02f,
  6.59111589e-02f, 1.82770878e-01f, -4.53393050e-02f, 2.40708455e-01f, 1.49591565e-01f, 9.90098044e-02f, 4.52878363e-02f, -4.01844084e-02f, 3.65088321e-02f, -4.05678563e-02f,
  1.04023013e-02f, -6.08282238e-02f, 6.62904531e-02f, -2.66558304e-02f, -4.49203746e-03f, 1.26686901e-01f, -1.16353355e-01f, 2.85010617e-02f, 9.41704120e-03f, -7.16041550e-02f,
  -2.70687845e-02f, -2.13029981e-02f, -3.84475663e-02f, 1.89704746e-02f, 8.04412812e-02f, -3.46229188e-02f, 5.96297942e-02f, 2.32782885e-02f, -2.16981061e-02f, -7.74467140e-02f,
  -1.10727720e-01f, 2.93618031e-02f, 2.15003639e-03f, -3.86424623e-02f, 3.78600471e-02f, 5.90847991e-02f, -3.34090889e-02f, -3.70601490e-02f, -2.55384631e-02f, -7.40438178e-02f,
  2.87751891e-02f, -3.44289504e-02f, -2.58159731e-02f, 6.86128736e-02f, -5.41810654e-02f, 9.24060494e-02f, 6.48963749e-02f, 7.66108409e-02f, 7.80933350e-02f, -5.56993224e-02f,
  2.59132944e-02f, 3.13962847e-02f, -2.94608437e-02f, 4.91200164e-02f, -2.21423935e-02f, -3.11133824e-03f, -3.70289683e-02f, 5.59867993e-02f, -3.19372192e-02f, -2.79703327e-02f,
  -4.15466540e-02f, -3.81115898e-02f, -6.44743890e-02f, 3.20132752e-03f, 6.01907587e-03f, 2.36989353e-02f, 6.38583452e-02f, -8.29728767e-02f, -2.92292293e-02f, -3.80271347e-03f,
  1.55504653e-02f, -3.47659029e-02f, -6.63856789e-02f, 6.33070944e-04f, -1.21973224e-01f, -8.28470849e-03f, -1.29549518e-01f, -7.53358155e-02f, 4.58674319e-02f, -3.08383871e-02f,
  2.02925205e-02f, 1.13974810e-01f, 1.15336977e-01f, 3.20119672e-02f, 4.61571552e-02f, 3.66279297e-02f, 6.90274313e-02f, -1.09582141e-01f, 2.30307411e-02f, 2.08150372e-02f,
  3.24490815e-02f, 8.17702059e-03f, -3.82801634e-03f, -5.45312986e-02f, 8.90312567e-02f, 7.44704530e-02f, 3.15909944e-02f, -4.11178581e-02f, -3.26115601e-02f, -6.08804077e-02f,
  1.75429299e-01f, 1.08002558e-01f, 1.28207654e-01f, 2.25292563e-01f, 2.82851327e-02f, -4.84432764e-02f, -1.87308460e-01f, 1.60191625e-01f, 1.28808394e-01f, 1.18983258e-02f,
  -2.36598954e-01f, 3.83302607e-02f, -2.39758402e-01f, 1.60080730e-03f, -2.70024508e-01f, -1.83020100e-01f, 1.15650006e-01f, 3.81348096e-02f, -5.03594801e-02f, -9.89557244e-03f,
  6.13506511e-02f, -8.01657587e-02f, -1.41052932e-01f, 9.56830978e-02f, 6.09736592e-02f, 1.39407024e-01f, -1.89981218e-02f, -1.01199582e-01f, -4.12812550e-03f, 3.96593958e-02f,
  -1.33719310e-01f, 2.04296019e-02f, 9.45175625e-03f, -5.14587462e-02f, 2.79933736e-02f, 1.16610648e-02f, -1.47716954e-01f, -8.91444236e-02f, -1.00765727e-01f, -1.94455255e-02f,
  -1.48784427e-03f, -3.83002795e-02f, 9.02422890e-02f, 1.90030821e-02f, 1.47005737e-01f, -5.65979294e-02f, -1.18379472e-02f, -4.67162654e-02f, -6.17268607e-02f, 4.61996645e-02f,
  -9.70530417e-03f, -2.00508721e-02f, 4.18297090e-02f, 1.40704651e-04f, -8.93626660e-02f, -6.43905178e-02f, -1.02489427e-01f, -3.06047704e-02f, -4.91937846e-02f, 1.01688705e-01f,
  9.55190286e-02f, 9.18431506e-02f, 5.94490208e-02f, 2.29884516e-02f, 5.36660217e-02f, 1.73033625e-02f, -5.11218198e-02f, -1.10557117e-01f, 5.62229007e-02f, -6.05720542e-02f,
  2.37278622e-02f, 1.22186365e-02f, 3.10785472e-02f, 3.08982357e-02f, 5.03477827e-02f, 1.39306769e-01f, -1.00036561e-02f, -7.55420029e-02f, -1.20582245e-02f, -8.76285732e-02f,
  3.06993462e-02f, 1.45144183e-02f, -3.53385806e-02f, 1.87496655e-02f, -8.55805129e-02f, 7.81716555e-02f, 2.35529095e-02f, 4.59068082e-02f, -1.53217494e-01f, -3.21848057e-02f,
  1.71167534e-02f, 6.01319969e-02f, -1.12794310e-01f, 1.52939316e-02f, -7.80513734e-02f, 2.40723733e-02f, 2.58872751e-02f, 7.58469775e-02f, -8.18582252e-02f, -3.83059457e-02f,
  8.76426548e-02f, 7.99126849e-02f, 6.94746375e-02f, 3.67318131e-02f, 2.95675942e-03f, -1.53733371e-02f, -3.83647624e-03f, -8.44973624e-02f, -3.74920517e-02f, -2.85033439e-03f,
  -4.66190614e-02f, -7.28913248e-02f, -1.03674017e-01f, 5.31145558e-03f, 1.62938777e-02f, 2.33597849e-02f, -3.36946584e-02f, 5.38010336e-02f, -1.04859255e-01f, -1.23742551e-01f,
  -6.18503205e-02f, 3.84140849e-01f, -9.90177877e-03f, 1.46647796e-01f, -2.05251932e-01f, -1.43541813e-01f, -5.49594983e-02f, 3.45172733e-02f, 2.64127731e-01f, 2.29460850e-01f,
  -2.54288107e-01f, 1.45597264e-01f, -9.41653922e-02f, 5.36940433e-02f, -3.16305906e-01f, 8.20608214e-02f, 5.10154478e-02f, -1.35986889e-02f, 7.07390311e-04f, -1.26810789e-01f,
  -1.29923344e-01f, -5.49641103e-02f, -2.83469349e-01f, -3.37122716e-02f, -1.48930892e-01f, -1.54286465e-02f, -1.82707906e-01f, -1.45166263e-01f, -1.00967638e-01f, -1.82190053e-02f,
  -7.39480136e-03f, 1.18237652e-01f, -2.15354897e-02f, -2.42665913e-02f, -1.00909047e-01f, 5.62219648e-03f, -1.38034252e-03f, 1.47825014e-02f, -1.02832161e-01f, -2.22065691e-02f,
  -9.42926016e-03f, -2.81605553e-02f, 6.86968192e-02f, -1.24144768e-02f, -4.72739339e-02f, -2.33731978e-02f, -1.05975948e-01f, -4.28284286e-03f, -2.11679861e-02f, -4.42712083e-02f,
  -6.42422885e-02f, -5.76261468e-02f, -7.00451853e-03f, 9.34283733e-02f, -1.25210568e-01f, -2.59814188e-02f, 2.31015147e-03f, -4.91283201e-02f, 3.72936353e-02f, 4.81774919e-02f,
  -7.09293708e-02f, 4.45429645e-02f, 7.66538680e-02f, 4.59139608e-02f, 4.52877395e-02f, -4.88706976e-02f, 6.44190237e-02f, -2.25944706e-04f, 2.72333249e-02f, -3.50113958e-02f,
  -3.31496261e-02f, 3.00002694e-02f, 2.38503534e-02f, -3.32315862e-02f, -4.56721010e-03f, 8.83869529e-02f, -1.25225499e-01f, 1.24741979e-02f, 4.75007556e-02f, 1.75073631e-02f,
  8.54457840e-02f, 3.93540934e-02f, -7.32706487e-02f, 6.53962940e-02f, -1.56106823e-03f, -6.63132891e-02f, 5.49563877e-02f, 3.11683137e-02f, 2.63524558e-02f, -5.77793047e-02f,
  4.20318097e-02f, 2.20533699e-01f, -2.22398043e-02f, -5.52889444e-02f, 4.51938845e-02f, -4.65043783e-02f, 1.01468369e-01f, -3.29983514e-03f, 4.52262312e-02f, 1.53032625e-02f,
  -3.65198776e-02f, -3.83407883e-02f, 2.61817314e-02f, 1.53321279e-02f, -7.37121515e-03f, 5.86098358e-02f, -4.25738050e-04f, 3.91679183e-02f, -2.28296053e-02f, -6.98190406e-02f,
  -6.93432838e-02f, -4.69468385e-02f, -1.58772171e-02f, 3.44844833e-02f, -2.34219898e-02f, -1.55003620e-02f, 3.00719459e-02f, 3.12717408e-02f, -2.77989861e-02f, -7.46174296e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.20765257e-01f, 4.75832671e-02f, 1.80137694e-01f, 4.63349931e-02f, -1.77392170e-01f, 3.57067376e-01f, 4.16028321e-01f, -2.21840143e-02f, -1.93933751e-02f, 8.81944895e-02f,
  5.64374216e-02f, -8.73583462e-03f, 2.28135660e-01f, 1.03929944e-01f, 1.77270100e-01f, 3.22319388e-01f, 1.69243231e-01f, 1.11666329e-01f, -7.01267496e-02f, -1.85799941e-01f,
  -1.39768586e-01f, -5.65077849e-02f, 7.01783597e-02f, -1.71801880e-01f, -4.97896895e-02f, -1.58489451e-01f, -9.02820826e-02f, 1.04355164e-01f, 6.79922849e-02f, 1.47407681e-01f,
  5.56644760e-02f, 3.06750573e-02f, -7.49928728e-02f, -7.59332580e-03f, 5.70489205e-02f, -6.61711618e-02f, 3.57613675e-02f, -3.98157835e-02f, -2.20284704e-02f, -3.08374874e-02f,
  1.36224525e-02f, 3.08621395e-02f, 2.74043363e-02f, -1.25494361e-01f, -1.19082689e-01f, 1.39454454e-02f, -3.89319398e-02f, 3.07169231e-03f, 1.22700389e-02f, -5.51862270e-03f,
  -1.29889995e-02f, -2.56023090e-02f, 2.64164582e-02f, 3.50853115e-05f, 6.96925148e-02f, 5.12907505e-02f, 1.53434217e-01f, 4.41364497e-02f, 6.81512803e-02f, -1.00557327e-01f,
  -1.08958498e-01f, 6.82561472e-02f, 6.53726980e-02f, -1.06466793e-01f, -3.07490826e-02f, -1.59463920e-02f, -4.08320725e-02f, -3.37333195e-02f, -2.12056339e-02f, -2.72855442e-02f,
  5.24488129e-02f, 4.55270484e-02f, 1.66651197e-02f, -4.22835089e-02f, -2.46919189e-02f, 1.40840299e-02f, 8.06583464e-02f, 1.22103840e-02f, 4.46190573e-02f, -1.16226776e-03f,
  8.84302519e-03f, -9.36237723e-02f, -3.78504097e-02f, 1.01055458e-01f, 1.02842860e-01f, 3.82173806e-02f, -1.16165236e-01f, -4.18207981e-03f, 7.30227157e-02f, 8.44020844e-02f,
  1.38633206e-01f, 1.32428870e-01f, 8.18185136e-02f, -3.00003421e-02f, 6.89391419e-02f, -1.02867059e-01f, -4.74358052e-02f, 1.34325018e-02f, 8.35941136e-02f, -3.70358750e-02f,
  -1.03146080e-02f, 5.98216392e-02f, -3.86551693e-02f, -5.55349439e-02f, 2.90052891e-02f, -2.31317747e-02f, 8.04577395e-02f, 2.56946147e-03f, 3.75784263e-02f, 8.02885834e-03f,
  -1.30126188e-02f, -2.75652595e-02f, 9.39040445e-03f, 4.96674031e-02f, 1.27648041e-02f, 5.01021147e-02f, -1.76324040e-01f, 4.20905724e-02f, 4.31638882e-02f, 8.79045427e-02f,
  -1.13842025e-01f, 1.03457369e-01f, -3.63085195e-02f, -2.11598843e-01f, -8.92385319e-02f, -7.58902654e-02f, 4.32121009e-02f, -7.87827969e-02f, 4.61789630e-02f, 1.50242925e-01f,
  -1.29097492e-01f, 9.52923205e-03f, -3.72124761e-02f, -1.29389703e-01f, -4.52825993e-01f, -3.20150763e-01f, -1.71511754e-01f, 2.87596183e-03f, -2.09874675e-01f, 1.07514322e-01f,
  -1.18521720e-01f, -1.80242032e-01f, -3.18611354e-01f, 7.17146024e-02f, 6.21864162e-02f, 2.08833069e-01f, 2.38034371e-02f, 1.01327285e-01f, 9.24897641e-02f, -1.12316169e-01f,
  -9.04559121e-02f, -3.97219062e-02f, 1.43320680e-01f, 1.41586319e-01f, 1.72696188e-02f, 1.33857444e-01f, 3.11155561e-02f, -8.60642269e-02f, 2.71448842e-03f, 7.68793970e-02f,
  -5.96363621e-04f, -8.26914012e-02f, 2.81926757e-03f, -1.33148715e-01f, 4.02350985e-02f, -4.12163930e-03f, -4.28304262e-02f, 4.88702208e-04f, 5.29598072e-02f, -6.58965856e-02f,
  7.76153952e-02f, 1.07240565e-01f, 6.68411106e-02f, 9.64030549e-02f, -2.58833487e-02f, 5.96240759e-02f, -3.06207985e-02f, 1.47244737e-01f, 9.47974995e-02f, -3.51256365e-03f,
  -2.15220102e-03f, 7.19234496e-02f, 2.07786299e-02f, -9.01154056e-02f, -2.12243292e-02f, 1.90266576e-02f, 5.08059673e-02f, -8.76614228e-02f, 1.83893330e-02f, 9.98892710e-02f,
  -2.05197334e-02f, 2.05295682e-02f, -5.74179776e-02f, 7.15003088e-02f, -8.75458494e-03f, -8.00299421e-02f, 3.38624865e-02f, -7.61205107e-02f, 1.14997802e-02f, -4.84633818e-02f,
  -2.16782396e-03f, -1.48409083e-02f, 2.39066724e-02f, -7.26468340e-02f, -1.29239205e-02f, 4.53426465e-02f, -1.75878350e-02f, 6.46267310e-02f, -3.09728440e-02f, -5.57814538e-02f,
  1.82048436e-02f, 3.07683703e-02f, -4.01988334e-04f, -7.08357319e-02f, 1.70921367e-02f, 8.84693190e-02f, -1.57884702e-01f, -3.34215462e-02f, -3.10087260e-02f, -3.09435129e-02f,
  7.56293237e-02f, 6.40491545e-02f, 2.22789839e-01f, -3.86604555e-02f, 2.31804256e-03f, 3.71896625e-02f, -9.01447609e-02f, 8.11348855e-02f, 1.54405206e-01f, 4.34189476e-02f,
  1.01639412e-01f, 8.63463581e-02f, 5.39714992e-02f, 1.10667974e-01f, -3.91026102e-02f, 1.04796417e-01f, -2.65831500e-02f, 4.50750291e-02f, 3.83221842e-02f, -1.02229238e-01f,
  -2.28837281e-01f, -1.44237831e-01f, -3.32847178e-01f, -1.68847486e-01f, -4.98123728e-02f, -2.99444675e-01f, -2.50038326e-01f, -2.15525348e-02f, -1.15580589e-01f, 9.62894261e-02f,
  3.00133154e-02f, -7.73160607e-02f, 1.94279552e-01f, -1.67559877e-01f, -2.71842420e-01f, 2.13652343e-01f, -3.09316725e-01f, -2.77017504e-02f, -4.74889688e-02f, -7.56626204e-02f,
  -6.88282251e-02f, -2.69586835e-02f, -4.04854044e-02f, 2.91110501e-02f, -2.08191946e-01f, -6.47893548e-02f, 5.59146702e-02f, 8.60915408e-02f, -1.77699462e-01f, -8.84788111e-02f,
  7.05488399e-02f, 1.12554036e-01f, 1.11215942e-01f, -2.43810215e-03f, -7.04815611e-02f, 3.12342364e-02f, -7.03327805e-02f, 6.97973222e-02f, -2.50306614e-02f, 6.23302646e-02f,
  2.37483718e-02f, -1.10301282e-02f, -2.19794158e-02f, -4.08230200e-02f, -3.93681116e-02f, 2.84266248e-02f, -9.56733536e-04f, -6.83705211e-02f, -7.02048943e-04f, -4.41445643e-03f,
  -1.21776285e-02f, 4.93969321e-02f, -4.40662764e-02f, 4.02779020e-02f, -1.90779381e-02f, -1.16519174e-02f, 5.22691710e-03f, 4.94975820e-02f, -4.24214229e-02f, -4.86768745e-02f,
  -2.06795167e-02f, -4.03394252e-02f, 8.20237622e-02f, -7.26343971e-03f, -4.69405651e-02f, -4.99926582e-02f, -1.02371059e-01f, 4.65646647e-02f, -1.44301549e-01f, 2.61254292e-02f,
  1.23260440e-02f, -6.71279132e-02f, 6.72052577e-02f, -1.46230355e-01f, -9.45466086e-02f, 4.16812301e-02f, -9.85268503e-03f, 3.68890464e-02f, -1.37316003e-01f, 2.31069867e-02f,
  8.48515108e-02f, -5.28005250e-02f, -3.45420279e-02f, 5.52228242e-02f, -3.79681438e-02f, -3.45375836e-02f, -2.86497343e-02f, 4.07698229e-02f, 1.90998111e-02f, -6.25691116e-02f,
  -3.62318382e-02f, -1.30390897e-01f, 1.19323462e-01f, 5.21248654e-02f, 1.00594349e-01f, 4.29427810e-03f, -5.13962656e-02f, 4.62144706e-03f, -8.89618844e-02f, 1.28041189e-02f,
  -1.47741035e-01f, 1.11616906e-02f, -2.03675032e-02f, -5.84405623e-02f, -1.21201567e-01f, -2.63028145e-02f, 1.24853730e-01f, 1.08828945e-02f, -2.94113997e-02f, -4.70002145e-02f,
  2.06580777e-02f, 4.49104793e-02f, -7.77984560e-02f, -2.01240312e-02f, -7.02068806e-02f, -2.46637426e-02f, 6.11870131e-03f, -8.50112364e-03f, 3.49301659e-02f, -3.98689471e-02f,
  3.16828966e-01f, 1.09068990e-01f, 5.45421280e-02f, 1.50916070e-01f, -1.52770594e-01f, -2.71566808e-01f, -1.11599691e-01f, -7.86775500e-02f, 8.67006406e-02f, 1.83964372e-02f,
  -2.26280302e-01f, 2.98637718e-01f, -1.61146104e-01f, 3.69071066e-02f, -3.07795435e-01f, -1.05847009e-01f, 1.68658197e-02f, 1.18674552e-02f, -2.55367775e-02f, 6.62883511e-03f,
  -8.02347735e-02f, -2.18518972e-01f, -4.78474796e-02f, -2.46155128e-01f, -4.83055897e-02f, 1.66684225e-01f, -4.05178256e-02f, -7.60889500e-02f, 5.44547848e-02f, -9.07086115e-03f,
  -5.45968525e-02f, 1.31949291e-01f, 9.28947628e-02f, 8.00549835e-02f, 3.86651494e-02f, 1.93365440e-02f, -1.12271450e-01f, -2.88629606e-02f, -7.63030574e-02f, 1.69547368e-02f,
  8.29334110e-02f, -5.38551733e-02f, -5.47996685e-02f, -9.14246663e-02f, 6.88758790e-02f, 1.07192449e-01f, 1.08204164e-01f, 1.12154528e-01f, 4.93926927e-02f, -4.40503918e-02f,
  2.89734229e-02f, 2.57764645e-02f, 1.66256055e-01f, 1.59712642e-01f, 1.08333468e-01f, 1.81890074e-02f, -1.26147255e-01f, 1.23317733e-01f, 6.50608465e-02f, 1.18027870e-02f,
  -4.83510643e-02f, -6.60987198e-02f, -1.02030508e-01f, -1.73821393e-02f, 1.27325337e-02f, -8.08355957e-02f, -2.06302814e-02f, -5.00669889e-02f, -9.20823868e-03f, -4.82034385e-02f,
  -4.32563163e-02f, 1.10106960e-01f, -1.02945805e-01f, -9.14531201e-02f, -9.95623544e-02f, 1.30391702e-01f, 7.49942288e-02f, -7.04294965e-02f, 1.28653035e-01f, -1.47893671e-02f,
  -6.20966665e-02f, -6.72694668e-02f, 4.08690833e-02f, 1.80144478e-02f, -1.21303186e-01f, 2.18299888e-02f, -7.02304989e-02f, 1.75987959e-01f, 4.10186127e-02f, -7.45153129e-02f,
  -1.28902839e-02f, 4.80907261e-02f, 7.52188079e-03f, 8.66561532e-02f, 1.37910238e-02f, -1.49582624e-02f, -9.49347466e-02f, 7.10619763e-02f, -1.40803993e-01f, -2.25030184e-02f,
  -6.24202751e-02f, -1.47781475e-02f, 2.54564025e-02f, -4.32563908e-02f, -1.89080071e-02f, -7.69559518e-02f, -2.45641284e-02f, 4.22549658e-02f, 9.60407853e-02f, -1.17866164e-02f,
  -1.94041003e-02f, -4.60753888e-02f, 7.10073262e-02f, 5.10499626e-02f, 4.41073664e-02f, 3.30327041e-02f, 6.33523911e-02f, 9.75395888e-02f, -6.71902951e-03f, -7.50852600e-02f,
  -3.21341664e-01f, 2.41633192e-01f, -2.09155858e-01f, 3.00408065e-01f, -1.85547754e-01f, -6.57430366e-02f, 8.03268328e-02f, 7.90025219e-02f, -8.29567984e-02f, 3.61121982e-01f,
  2.57792503e-01f, -2.06259992e-02f, 1.00224428e-01f, 3.05169284e-01f, -8.67764801e-02f, 1.71193302e-01f, 2.83486754e-01f, 1.72760367e-01f, -1.86798349e-01f, 7.93759823e-02f,
  9.29930713e-03f, 3.41164649e-01f, 9.70134214e-02f, 5.74656352e-02f, 1.43777141e-02f, -1.53028697e-01f, 2.08349794e-01f, -3.49594131e-02f, 1.33279786e-01f, 9.94130149e-02f,
  4.69541401e-02f, -3.28536518e-03f, -7.07312375e-02f, -8.42981562e-02f, -9.97929350e-02f, -8.88283402e-02f, -9.08419713e-02f, -1.78982615e-02f, -1.08608007e-01f, -2.51032654e-02f,
  -1.34891272e-01f, -8.56092572e-02f, -5.62444404e-02f, -3.53789981e-03f, -7.91298300e-02f, 4.46361303e-03f, -1.97527857e-04f, 5.47264330e-02f, -9.19712998e-04f, -3.55580002e-02f,
  -5.55613078e-02f, -3.29133011e-02f, 1.42949030e-01f, 3.07664964e-02f, -6.75991327e-02f, 2.48076022e-03f, -2.16984074e-03f, -7.64961615e-02f, 7.98045397e-02f, 2.18160711e-02f,
  -5.80668971e-02f, 5.02567589e-02f, -7.38389567e-02f, 1.74277946e-02f, 8.21528770e-03f, -2.21879706e-02f, 1.29999772e-01f, -1.98285598e-02f, -2.56522465e-02f, 8.60807002e-02f,
  3.81924324e-02f, -1.63056348e-02f, -8.88896286e-02f, 9.64057446e-02f, 4.87286113e-02f, 3.79235297e-02f, -4.25519384e-02f, 6.92444295e-02f, 6.74392581e-02f, 4.38568965e-02f,
  -3.19417231e-02f, 2.16241693e-03f, 3.38527225e-02f, 2.25564558e-02f, 8.36870670e-02f, 2.19307040e-04f, -4.49090004e-02f, -1.94484759e-02f, 6.40253648e-02f, -4.67428528e-02f,
  1.01656981e-01f, 5.04930951e-02f, 5.68584539e-02f, -1.17461704e-01f, -9.84181836e-03f, 3.28267291e-02f, -5.89962816e-03f, -3.32376026e-02f, -3.18447896e-03f, -4.83743772e-02f,
  5.91784231e-02f, 1.19925179e-02f, -8.57793912e-03f, 5.38668931e-02f, 2.57546771e-02f, 1.30913094e-01f, 9.19972956e-02f, -2.98173223e-02f, 8.75095278e-02f, -8.61507189e-03f,
  8.67229626e-02f, -6.77167773e-02f, -5.78688867e-02f, -2.73775905e-02f, 3.11451349e-02f, 8.35906267e-02f, 1.13005824e-02f, -1.71541404e-02f, -8.10466707e-02f, -2.49438155e-02f,
  -7.11397827e-02f, -3.23165596e-01f, -4.85920534e-02f, 9.51237157e-02f, 4.17247079e-02f, 1.05896361e-01f, -7.59282932e-02f, -9.37966928e-02f, -2.47334242e-01f, -2.44630769e-01f,
  1.75628304e-01f, 1.56980343e-02f, -1.35271937e-01f, 2.80150529e-02f, 3.41676474e-01f, 1.90619826e-02f, 1.03313223e-01f, 7.01246783e-02f, 1.61380947e-01f, -4.51719686e-02f,
  1.62869394e-01f, 2.26138920e-01f, 1.11090183e-01f, 1.40180215e-01f, 2.95346659e-02f, 3.07280552e-02f, -1.28386728e-02f, 4.65441756e-02f, 8.29450414e-02f, 5.21174334e-02f,
  1.50361666e-02f, -9.88294780e-02f, -3.22274454e-02f, 3.44235823e-02f, 4.36993688e-03f, 8.53836313e-02f, 1.05707787e-01f, 1.33149803e-01f, 8.88265222e-02f, -8.41995403e-02f,
  -1.08606284e-02f, 3.24423835e-02f, -5.17652556e-02f, 1.40474454e-01f, 3.17463763e-02f, 9.07513425e-02f, 5.55724502e-02f, 2.48140972e-02f, 1.52078709e-02f, -1.35068614e-02f,
  -8.27649683e-02f, -3.31831239e-02f, -2.54780948e-02f, -6.83342516e-02f, 2.12798342e-02f, 8.14433694e-02f, 2.11520046e-02f, 2.08291430e-02f, 4.99594398e-02f, -5.57924025e-02f,
  1.88931245e-02f, -1.05906963e-01f, -1.25539646e-01f, -2.23365650e-02f, 5.39902076e-02f, 1.34736031e-01f, 3.02290525e-02f, 8.84428918e-02f, 3.34233269e-02f, 8.83294418e-02f,
  4.90223020e-02f, 3.62436362e-02f, 8.70157182e-02f, -1.17155001e-01f, -4.29274850e-02f, -5.38426042e-02f, 1.81501031e-01f, 4.05793637e-02f, -9.44395661e-02f, 9.50057134e-02f,
  7.02469870e-02f, 5.29266968e-02f, 5.89139387e-02f, 5.84264062e-02f, -9.00653540e-04f, -1.30272537e-01f, 4.23515588e-02f, -4.63206172e-02f, 3.47485929e-03f, 1.43167367e-02f,
  -1.08474959e-02f, -2.91806072e-01f, -6.90603331e-02f, -6.70897514e-02f, -4.41473722e-03f, 3.87679115e-02f, -1.00033581e-02f, 2.99473237e-02f, -4.14209142e-02f, 4.22886536e-02f,
  -1.04728397e-02f, 1.00104451e-01f, -8.01141933e-02f, 7.93523788e-02f, 2.61777014e-01f, -1.09204546e-01f, -8.84560645e-02f, 1.16179384e-01f, 7.32547343e-02f, 1.09188706e-01f,
  7.43681267e-02f, -8.38302374e-02f, 9.91419330e-02f, 8.87197703e-02f, 6.28700107e-03f, 5.54773025e-02f, 6.58022836e-02f, -8.17374364e-02f, 4.85205054e-02f, -1.25258751e-02f,
  -5.65253906e-02f, -5.06604254e-01f, -1.66400652e-02f, -1.30147254e-02f, 1.75563753e-01f, 2.64131315e-02f, -7.48795643e-02f, -1.59960866e-01f, -2.23653883e-01f, -3.27295929e-01f,
  1.11987993e-01f, 3.53885517e-02f, -1.51722938e-01f, 4.28675450e-02f, 4.18578476e-01f, -7.10712224e-02f, 6.05434105e-02f, 8.73757601e-02f, 1.76652649e-03f, -8.54351744e-02f,
  5.20696715e-02f, 8.26650634e-02f, 1.58067018e-01f, 1.10663518e-01f, 1.22644372e-01f, -5.40928543e-03f, 6.71184510e-02f, 1.69406727e-01f, 7.84813240e-02f, 1.26227766e-01f,
  -6.95969090e-02f, -7.37087131e-02f, 1.49665736e-02f, 2.29747314e-02f, -3.54925618e-02f, 5.21250884e-04f, 2.36949548e-02f, 1.47881404e-01f, -2.78249420e-02f, -2.26486977e-02f,
  -8.15292299e-02f, 7.49180987e-02f, 6.09112829e-02f, -2.59368084e-02f, -1.48085654e-01f, -3.01757883e-02f, 7.89508596e-02f, -5.18650226e-02f, -4.62609306e-02f, -1.04544647e-01f,
  3.44731361e-02f, -1.66045967e-02f, -2.38928339e-03f, 1.44406244e-01f, 1.36513943e-02f, 2.84079593e-02f, -6.95812516e-03f, -4.06631902e-02f, -5.06876819e-02f, -4.33112681e-02f,
  -3.38604883e-03f, 1.53108360e-02f, -1.83006942e-01f, 2.47917250e-02f, -1.53914660e-01f, 6.72977790e-02f, 3.45927961e-02f, 9.52611212e-03f, -6.47184178e-02f, 3.86857288e-03f,
  6.36793301e-02f, -2.37621069e-02f, -7.12159835e-03f, 1.23005658e-02f, 5.86845838e-02f, 1.02939289e-02f, 5.84155321e-02f, 1.45551905e-01f, -3.08154635e-02f, 7.24292025e-02f,
  1.09597474e-01f, -6.80238474e-03f, 2.39577256e-02f, 5.12088574e-02f, -2.21629925e-02f, -1.69979148e-02f, -2.60002837e-02f, -7.58582503e-02f, -3.39140147e-02f, 6.47352189e-02f,
  -1.74216524e-01f, -3.53727072e-01f, 8.35600048e-02f, 6.31574392e-02f, 5.32583296e-02f, -1.04795601e-02f, 8.60441253e-02f, -9.31309313e-02f, -4.85811681e-02f, -3.78160477e-02f,
  -7.55771026e-02f, 1.66546270e-01f, -4.97462749e-02f, 3.98590527e-02f, 9.06327143e-02f, -1.56079650e-01f, -5.81831858e-02f, -3.06711998e-02f, 1.32737845e-01f, -7.64888758e-03f,
  -6.62544044e-03f, -4.17488478e-02f, 4.97694425e-02f, 6.68009371e-02f, 6.42746463e-02f, 2.61598062e-02f, -2.76646931e-02f, -9.49018821e-02f, 1.01235740e-01f, -2.17618812e-02f,
  -2.41028205e-01f, -2.50092238e-01f, -2.62688577e-01f, -1.12194017e-01f, 1.34384468e-01f, -1.56106025e-01f, -3.70085031e-01f, 1.19547479e-01f, -1.64740235e-01f, -7.25275138e-03f,
  4.45517115e-02f, -8.32739621e-02f, -1.19026408e-01f, -7.11643919e-02f, -8.62875953e-02f, -1.83972523e-01f, -1.84010509e-02f, -2.26878505e-02f, -5.66860214e-02f, 1.36983264e-02f,
  5.37008755e-02f, 1.60156026e-01f, 6.37804493e-02f, 1.33503690e-01f, -1.16121516e-01f, 1.71622366e-01f, 3.93854380e-01f, -1.05454870e-04f, 2.53784060e-01f, 2.19944552e-01f,
  -1.27645895e-01f, 6.43594339e-02f, -1.01673231e-01f, -9.75433737e-02f, 4.36244570e-02f, -1.74834160e-03f, -1.81436329e-03f, 8.25103670e-02f, 3.65245342e-02f, 4.43533584e-02f,
  1.21938018e-02f, 5.18350713e-02f, 3.13869901e-02f, 4.71519418e-02f, 4.91467789e-02f, -5.01939803e-02f, 4.14181873e-03f, -7.04201013e-02f, 1.88057832e-02f, -6.95458427e-02f,
  -7.57634267e-02f, -1.43690500e-03f, -3.90708409e-02f, -6.87364340e-02f, -6.53781891e-02f, 6.94640428e-02f, 8.30810145e-02f, 1.11502245e-01f, 2.90038949e-03f, -9.63080227e-02f,
  4.09943201e-02f, -6.80018142e-02f, 1.63004231e-02f, -7.82292709e-02f, 1.28846550e-02f, -3.83134633e-02f, -4.28926013e-02f, 1.16857395e-01f, 5.50145134e-02f, -9.99343097e-02f,
  1.18521757e-01f, -1.40360534e-01f, 1.00202657e-01f, 7.32333586e-02f, -2.42262464e-02f, 1.40653281e-02f, -5.00623807e-02f, 1.73184834e-02f, -5.09898877e-03f, 6.32533655e-02f,
  4.84236293e-02f, 1.01773581e-02f, -3.77195962e-02f, -2.46886946e-02f, -9.79548916e-02f, 6.75012320e-02f, -4.91365977e-02f, -4.50371467e-02f, -6.40093610e-02f, 1.18217329e-02f,
  -1.83024968e-03f, 1.35451853e-01f, 2.93181911e-02f, -2.86734086e-02f, -5.83052374e-02f, -2.95908730e-02f, -1.05808705e-01f, -6.10531494e-03f, 4.52028066e-02f, 3.94053161e-02f,
  7.50922784e-02f, 7.94529691e-02f, -8.36227182e-03f, 2.34830566e-02f, 8.60570595e-02f, 2.13615689e-03f, 9.16825086e-02f, -4.62124161e-02f, 1.54262837e-02f, 1.37907773e-01f,
  1.27117679e-01f, 2.60241795e-02f, 1.94441751e-02f, -1.01832673e-01f, 7.30958953e-02f, -1.56462390e-03f, 7.16441125e-02f, 6.22335449e-02f, -4.60779667e-02f, 5.33105806e-02f,
  -6.58794120e-02f, -1.30166933e-01f, -1.94584906e-01f, -4.42538271e-03f, -2.74486504e-02f, 3.08750570e-01f, 1.76720485e-01f, -1.96345851e-01f, -3.21947843e-01f, 9.78653058e-02f,
  5.01563475e-02f, -2.59104848e-01f, -1.49573684e-02f, 2.13787407e-01f, -2.37566847e-02f, -4.18662168e-02f, 2.53381580e-01f, 7.16446042e-02f, -1.93126455e-01f, -1.33230612e-01f,
  -2.10647974e-02f, 2.76615024e-01f, -3.62978093e-02f, -2.83908974e-02f, 1.94872394e-02f, -1.88094512e-01f, -3.17636058e-02f, -1.78159699e-02f, 1.48020566e-01f, 1.65030524e-01f,
  7.35928565e-02f, -1.62312314e-01f, -8.41207504e-02f, -1.50989797e-02f, -1.21266879e-02f, -1.87686514e-02f, -9.54418853e-02f, 9.80425030e-02f, -4.48580831e-02f, -1.05923610e-02f,
  5.32759912e-02f, -1.70027196e-01f, 1.75719321e-01f, -1.63718030e-01f, -4.79574986e-02f, -2.80270237e-04f, -1.03616446e-01f, -3.97461466e-02f, -1.23843543e-01f, -3.09785530e-02f,
  -7.99727887e-02f, 1.79365221e-02f, -1.28659680e-01f, 1.23594776e-01f, -5.94216771e-02f, -5.29121831e-02f, -1.06762186e-01f, -9.99858901e-02f, 4.22252268e-02f, -8.92785098e-03f,
  3.74160446e-02f, -9.08453837e-02f, 6.89090192e-02f, -4.48213927e-02f, 7.34883025e-02f, -4.26173816e-03f, 3.63267632e-03f, -9.54119265e-02f, -1.06850728e-01f, -3.52193192e-02f,
  2.26721466e-02f, -1.21013090e-01f, -8.08572024e-02f, -1.02046784e-02f, 6.33541271e-02f, 5.37380651e-02f, 2.25066710e-02f, -1.21742383e-01f, -9.51131582e-02f, -9.94791389e-02f,
  -6.01732135e-02f, -1.00930557e-01f, 1.94183826e-01f, 1.27449229e-01f, -4.93623875e-02f, 2.21199356e-02f, 5.79982512e-02f, -1.03486069e-01f, 3.68736722e-02f, 9.94739681e-03f,
  -1.13204442e-01f, -9.50740427e-02f, -1.94981974e-02f, 9.26556587e-02f, 1.30903795e-02f, -7.90350419e-03f, 5.01273982e-02f, -7.80823035e-03f, 4.77172900e-03f, -1.78650934e-02f,
  7.62002692e-02f, -1.69393532e-02f, 5.63846640e-02f, -8.53215903e-02f, 9.39257219e-02f, 1.09987848e-01f, -2.27341093e-02f, 5.77944331e-02f, 4.84452205e-04f, -3.26771736e-02f,
  1.27188697e-01f, 7.02014863e-02f, -7.35973343e-02f, -3.07302899e-03f, 5.66526651e-02f, -2.35989131e-02f, -6.47095367e-02f, -5.03103845e-02f, 1.13819726e-01f, -7.40418211e-02f,
  -3.56885105e-01f, 3.29047143e-01f, -1.55627146e-01f, 3.48810047e-01f, -1.31710902e-01f, -1.97848484e-01f, -3.51753160e-02f, 1.60470352e-01f, -9.79730561e-02f, 1.51167482e-01f,
  2.76505113e-01f, -1.17586724e-01f, 6.28196821e-02f, 3.99291575e-01f, -8.90532881e-03f, 2.95612097e-01f, 2.23211810e-01f, 1.37143821e-01f, -3.94095993e-03f, 6.33353442e-02f,
  1.08833745e-01f, 2.21767187e-01f, 3.24908555e-01f, 3.26593406e-02f, -2.40411349e-02f, 5.16716242e-02f, 1.32964268e-01f, -2.65727732e-02f, 2.41437942e-01f, -4.36613485e-02f,
  4.10917141e-02f, 7.77645558e-02f, -5.68712801e-02f, -1.30799994e-01f, -3.27403247e-02f, -1.18776552e-01f, -9.52735692e-02f, -1.31415114e-01f, -1.07201546e-01f, 9.36503187e-02f,
  -5.52633554e-02f, -1.34743704e-02f, 3.15704681e-02f, 2.76792981e-02f, -2.27398388e-02f, 1.33298598e-02f, -1.26594260e-01f, 4.41995496e-03f, -8.85726139e-03f, 1.70629546e-02f,
  5.18387184e-02f, 2.09982041e-02f, 1.29926637e-01f, 7.05743283e-02f, 4.26646397e-02f, -1.97272114e-02f, -3.62633653e-02f, -4.93811630e-02f, 2.42256001e-03f, 8.23954493e-02f,
  -1.22441389e-01f, -1.66966729e-02f, -1.15043320e-01f, -8.50026160e-02f, 3.30805853e-02f, -5.39853312e-02f, 8.01048502e-02f, -5.75101599e-02f, -1.05621628e-01f, -5.58204763e-03f,
  -7.84218982e-02f, -2.70727240e-02f, -4.81772758e-02f, 2.03911215e-02f, 4.82598655e-02f, -9.28367078e-02f, -8.80981982e-02f, 9.14322436e-02f, -5.83897755e-02f, 5.42925857e-02f,
  1.41561888e-02f, -3.21084894e-02f, 8.03387761e-02f, 6.48571402e-02f, 7.16106296e-02f, -7.46811852e-02f, 6.86917305e-02f, -2.17597485e-02f, -1.26710336e-03f, -4.73410338e-02f,
  1.46175712e-01f, 1.71991974e-01f, 5.25151670e-04f, -2.87596267e-02f, 4.10435125e-02f, -1.31454080e-01f, -6.78536147e-02f, -5.30064665e-02f, 8.12214054e-03f, 4.36544642e-02f,
  -9.32150781e-02f, -5.33611560e-03f, 6.57089129e-02f, 2.07044724e-02f, 3.75275686e-02f, 7.29519408e-03f, 1.85955241e-02f, -2.39554234e-03f, 1.77105591e-02f, 4.63335589e-02f,
  8.45324770e-02f, -1.22716211e-01f, -9.77449417e-02f, 9.56542641e-02f, 5.84815815e-02f, 4.70896736e-02f, 1.61589365e-02f, -1.37004005e-02f, -4.01091687e-02f, 1.33176416e-01f,
  1.78005457e-01f, 3.11042339e-01f, 3.23994607e-01f, 3.00316870e-01f, -1.78597525e-01f, -2.52938598e-01f, -1.17279895e-01f, 3.89049053e-02f, -5.30362576e-02f, -8.32268521e-02f,
  -9.87477005e-02f, 3.21661949e-01f, -1.46275640e-01f, 1.61812171e-01f, -1.62597626e-01f, -1.75734997e-01f, 2.59800237e-02f, 9.60196480e-02f, 9.59554594e-03f, 1.14048727e-01f,
  3.74055058e-02f, -1.16358295e-01f, -1.46790203e-02f, 1.27815202e-01f, 2.24565536e-01f, 2.00464070e-01f, -4.18857671e-03f, 6.92291334e-02f, 1.16059937e-01f, 2.25251429e-02f,
  -4.98605371e-02f, -2.53537335e-02f, 8.94091129e-02f, 2.20249966e-02f, -1.49337193e-02f, -8.34522694e-02f, -1.37444800e-02f, -6.63805678e-02f, -1.03412032e-01f, 4.88650799e-02f,
  3.33092883e-02f, -8.58942140e-03f, 7.80183077e-02f, 1.25235632e-01f, -1.24003462e-01f, 3.68506685e-02f, 9.89191700e-03f, -4.39099036e-02f, 5.72685078e-02f, 1.23525135e-01f,
  1.10321380e-01f, 3.84366848e-02f, 1.36065101e-02f, -3.86798056e-03f, 2.26168279e-02f, -7.77432323e-02f, 3.87098268e-02f, 5.28773479e-02f, 4.66296561e-02f, -1.75071266e-02f,
  -8.50538760e-02f, 1.04692891e-01f, -3.97283491e-03f, 2.92950720e-02f, 1.91105052e-03f, 1.78572424e-02f, 5.97000271e-02f, -5.41726723e-02f, -4.50655967e-02f, -1.64491460e-02f,
  -1.71854589e-02f, 1.10679276e-01f, 5.62252514e-02f, 3.32360389e-04f, 1.61402323e-03f, -6.42899498e-02f, -6.94004893e-02f, 7.09419791e-03f, -2.71342937e-02f, 2.07376275e-02f,
  -2.37237774e-02f, -4.80481423e-02f, 5.10015190e-02f, 6.58478290e-02f, -9.69417021e-02f, 9.29342732e-02f, 1.21224351e-01f, -6.14299476e-02f, 1.59776546e-02f, -1.34270331e-02f,
  -1.42670255e-02f, 4.49116826e-02f, 1.72583908e-02f, -1.02787158e-02f, -8.97828117e-02f, 8.35271366e-03f, -6.25792518e-02f, 2.37896293e-02f, -2.05207150e-02f, -4.81065921e-02f,
  3.98196168e-02f, 1.45236263e-02f, -4.31496240e-02f, 6.08097985e-02f, -5.48492000e-02f, 8.38446990e-02f, 3.55420150e-02f, -1.01350360e-01f, 3.57686318e-02f, 1.18777074e-01f,
  1.15683593e-01f, -3.61856626e-04f, -9.71833393e-02f, -1.03297114e-01f, -1.39752673e-02f, -2.04567797e-02f, -1.95795521e-02f, 3.14081758e-02f, 1.19025365e-01f, 7.45170284e-03f,
  -9.41732600e-02f, -5.91127761e-02f, -1.70216709e-01f, -4.20310348e-03f, -1.54173046e-01f, -2.08032340e-01f, -1.91758528e-01f, -5.19497506e-02f, 1.46498606e-01f, 6.51701167e-02f,
  -1.35714069e-01f, 1.36226088e-01f, -4.25251909e-02f, -1.91695452e-01f, -6.63327202e-02f, 1.12894818e-01f, -3.16698581e-01f, -6.82732761e-02f, 1.01663411e-01f, -1.93928465e-01f,
  -1.57787845e-01f, -1.90462902e-01f, -1.00717083e-01f, -2.18878925e-01f, -2.99007624e-01f, -1.17732152e-01f, 8.47074315e-02f, -1.48009315e-01f, -1.33575276e-01f, -7.94452131e-02f,
  -2.60358341e-02f, 1.43689528e-01f, -2.83164140e-02f, 1.09274462e-02f, -1.09377056e-01f, -9.82597470e-02f, -5.90518080e-02f, 9.49405041e-03f, -6.78907149e-03f, 3.94918285e-02f,
  -1.86148323e-02f, 4.99670766e-02f, -1.48512572e-02f, -2.77091134e-02f, 2.41774637e-02f, 1.30006310e-03f, 7.40617793e-03f, 5.22325165e-04f, 1.08848870e-01f, -9.75473039e-03f,
  -1.41863510e-01f, 4.90852967e-02f, -6.84133470e-02f, 1.45986691e-01f, 5.71673661e-02f, 2.15231664e-02f, 4.67502549e-02f, 5.19970618e-02f, 1.73168760e-02f, 1.06950909e-01f,
  2.54144240e-02f, -5.94604164e-02f, -8.49498138e-02f, -9.70772579e-02f, -9.39139947e-02f, -8.66161585e-02f, -1.09023921e-01f, -2.94019487e-02f, -6.38433099e-02f, -5.02860844e-02f,
  8.52441788e-02f, 2.08754260e-02f, -2.64695361e-02f, -1.11294411e-01f, -1.24098487e-01f, 7.22248629e-02f, -5.31055368e-02f, 4.67976592e-02f, -8.50085542e-02f, -5.08462312e-03f,
  -8.80450383e-03f, 3.01053487e-02f, 5.89685515e-02f, -5.00214705e-03f, -4.23680879e-02f, 6.49700267e-03f, 1.89899583e-03f, -6.35608286e-02f, 1.24816552e-01f, -3.29243578e-02f,
  1.32215664e-01f, 1.30613342e-01f, -1.15425792e-02f, 1.85746357e-01f, -2.59607583e-02f, -2.06044391e-02f, -3.58311944e-02f, -6.23614574e-03f, 1.07278652e-01f, 2.76162755e-02f,
  -8.42589885e-02f, 1.34269036e-02f, 6.91404343e-02f, 7.00607663e-03f, 4.36920039e-02f, 6.26784610e-03f, -5.29256240e-02f, 1.63129553e-01f, 3.02295815e-02f, 2.01805234e-02f,
  -3.51439938e-02f, 7.45810429e-03f, 7.12920651e-02f, 1.29187211e-01f, 5.48053235e-02f, 5.22331335e-03f, 2.13234574e-02f, 1.82660446e-02f, 5.23323454e-02f, 6.31534830e-02f,
  4.23222035e-01f, -5.61688691e-02f, -1.01088151e-01f, -3.17349471e-02f, -9.31051672e-02f, 2.19724894e-01f, 1.43737555e-01f, -1.13628112e-01f, 7.26656020e-02f, 1.65007159e-01f,
  -3.38721983e-02f, 1.39371961e-01f, 9.66269150e-02f, 6.07582442e-02f, 1.34194136e-01f, 1.40327707e-01f, 1.59873247e-01f, 1.08784169e-03f, 3.28826346e-02f, 1.81307957e-01f,
  6.38343841e-02f, 1.05595924e-01f, -1.18035056e-01f, -1.03541337e-01f, -1.29941599e-02f, -7.24345893e-02f, -2.61268824e-01f, -1.73465505e-01f, -2.25911528e-01f, 2.23041978e-02f,
  -1.59722809e-02f, 3.28706056e-02f, 6.01011515e-02f, 9.83299986e-02f, -7.52419829e-02f, 4.54336628e-02f, -5.33256307e-02f, 1.04404306e-02f, -2.03928240e-02f, 2.42343755e-03f,
  6.48674294e-02f, 2.45793778e-02f, 2.16621011e-02f, 1.66086592e-02f, 1.94659382e-02f, -4.17995155e-02f, 1.76785197e-02f, -1.60129786e-01f, -6.65870830e-02f, 7.72823021e-02f,
  2.29806099e-02f, -7.04185888e-02f, -2.38779858e-02f, -9.32771116e-02f, -8.49301592e-02f, -1.42065808e-03f, 1.85536724e-02f, -4.60026041e-02f, -2.99043134e-02f, 8.99644047e-02f,
  9.94340237e-03f, 4.21597995e-02f, 9.58583653e-02f, -2.71317270e-02f, 3.98968346e-02f, 1.49992276e-02f, 2.69171298e-02f, 5.02317026e-02f, 5.06710708e-02f, -1.42565947e-02f,
  1.09925997e-02f, -1.44560188e-01f, 5.16419262e-02f, 9.89517048e-02f, 8.32144171e-02f, 3.84223238e-02f, -1.58203878e-02f, -9.64783579e-02f, -4.10640016e-02f, -4.91695032e-02f,
  8.42770468e-03f, 1.02350593e-01f, -3.73607613e-02f, -9.75838602e-02f, -6.89448640e-02f, 1.19689964e-01f, 5.00861555e-02f, 7.34839449e-03f, -1.50484234e-01f, -7.53322169e-02f,
  8.57142210e-02f, 1.94603398e-01f, 5.63059635e-02f, -1.07881324e-02f, -1.24049343e-01f, 2.50755642e-02f, 1.18323222e-01f, 1.06360905e-01f, 8.97540599e-02f, 7.19122961e-02f,
  -9.99387205e-02f, -9.07076709e-03f, -1.14922905e-02f, -3.57059427e-02f, -3.52608152e-02f, 3.65442000e-02f, 1.24324271e-02f, -9.81903151e-02f, -3.21036465e-02f, -3.51133905e-02f,
  -6.30386770e-02f, 3.37163098e-02f, 5.18224724e-02f, -5.45050725e-02f, -2.03977954e-02f, -1.76319480e-02f, 6.34996146e-02f, -4.17967029e-02f, 1.73405297e-02f, 1.12217158e-01f,
  -1.33741796e-01f, 6.41860887e-02f, -1.58967391e-01f, -2.21700460e-01f, 1.55266613e-01f, -9.32712387e-03f, -8.88634026e-02f, 2.10508406e-02f, -1.49464205e-01f, 2.45326221e-01f,
  1.59224086e-02f, -2.13012382e-01f, 3.31737995e-02f, -4.07382071e-01f, -3.27523887e-01f, -3.87128055e-01f, -2.38897070e-01f, -2.25051746e-01f, -1.69891700e-01f, 4.00097780e-02f,
  -2.35092670e-01f, -8.51045102e-02f, -3.16974133e-01f, 2.91954130e-01f, 1.00730263e-01f, 1.74267173e-01f, 2.81809062e-01f, 1.78501561e-01f, -4.07742560e-02f, -2.33715847e-02f,
  -9.53601152e-02f, -7.00956583e-02f, 8.38291943e-02f, -8.12919438e-02f, -1.77564528e-02f, 2.15795055e-01f, 2.97307037e-03f, -5.41716926e-02f, -7.52377883e-02f, -9.53993723e-02f,
  -5.80939204e-02f, -7.14274347e-02f, -9.72345844e-02f, -8.62256624e-03f, 6.45847023e-02f, -1.16932325e-01f, -5.04955985e-02f, -6.57228306e-02f, -1.22217260e-01f, -9.48012248e-02f,
  -9.11627784e-02f, -6.01016043e-04f, 1.00964516e-01f, -3.64347845e-02f, -2.64822207e-02f, 6.66492507e-02f, 3.56139615e-02f, 7.46867657e-02f, 1.70005462e-03f, 2.46636756e-02f,
  6.07731268e-02f, 1.27082303e-01f, -9.17967036e-03f, -3.85313518e-02f, 1.35242371e-02f, 1.11113019e-01f, 3.02081020e-03f, -7.99606729e-04f, 1.19636439e-01f, -3.94847579e-02f,
  -4.51149605e-02f, -6.26748428e-02f, -4.43141442e-03f, 3.10378745e-02f, 4.75124605e-02f, 5.07866219e-02f, 6.01344369e-02f, -4.80965304e-04f, -6.14466034e-02f, -1.31887212e-01f,
  8.52674767e-02f, 6.45022432e-04f, -4.92897332e-02f, 2.25741323e-02f, -5.25738299e-02f, 9.51397419e-02f, 2.83326693e-02f, -2.63912566e-02f, 2.18767896e-02f, 5.73890395e-02f,
  6.56563640e-02f, 2.21133992e-01f, -3.15827206e-02f, -6.30614609e-02f, -5.31211235e-02f, 1.04900643e-01f, -8.94578993e-02f, -1.29170403e-01f, -3.29352985e-03f, -1.32105022e-03f,
  9.64456201e-02f, 1.70164332e-02f, 6.95036203e-02f, 4.83695604e-02f, 1.42247528e-02f, -1.38152274e-03f, 1.42094880e-01f, 7.07120523e-02f, 1.04848571e-01f, -7.18182512e-03f,
  1.04772486e-01f, 1.96941737e-02f, 2.35795639e-02f, -5.26737347e-02f, 3.27956304e-02f, 9.13413242e-02f, 8.89732912e-02f, -6.47150278e-02f, 2.96409987e-03f, -1.33414296e-02f,
  -4.42377999e-02f, -1.09584026e-01f, -5.74834384e-02f, -1.68169066e-01f, -1.30357504e-01f, -6.90022856e-02f, -1.87912453e-02f, -1.86019748e-01f, -4.66936789e-02f, -1.60896838e-01f,
  -1.03266679e-01f, 6.76449612e-02f, 2.38518506e-01f, -2.33171105e-01f, 4.13381994e-01f, 2.16626704e-01f, -1.98997527e-01f, 3.83804785e-03f, -5.28534129e-02f, -9.57300365e-02f,
  -3.10566109e-02f, -6.62776157e-02f, 8.72101486e-02f, -2.67698914e-01f, -1.72442228e-01f, -2.01175302e-01f, 2.73437425e-02f, 5.95519319e-02f, -1.98022187e-01f, -1.33580090e-02f,
  -1.29595667e-01f, -2.57078141e-01f, -1.17497168e-01f, -1.32391199e-01f, -6.52853623e-02f, 4.86120582e-03f, -2.59869862e-02f, 9.26610548e-03f, -1.26134977e-01f, -4.05838005e-02f,
  1.86480165e-01f, 3.37205157e-02f, -1.34006381e-01f, 9.03172716e-02f, -2.65787430e-02f, -1.77956611e-01f, -6.55269474e-02f, -6.97617382e-02f, 7.14016799e-03f, 7.99997747e-02f,
  4.87038158e-02f, -3.86589691e-02f, -5.57791926e-02f, 2.86490079e-02f, -1.88387688e-02f, -5.67164160e-02f, -2.30101552e-02f, 1.41138390e-01f, -7.71124149e-03f, -5.95084839e-02f,
  3.09304316e-02f, 7.46229440e-02f, 1.23847812e-01f, 5.52273840e-02f, 1.11354537e-01f, 4.78770882e-02f, 7.42939189e-02f, 8.66248831e-02f, -6.41830638e-02f, 1.34154167e-02f,
  -6.76712543e-02f, -1.52580766e-02f, 5.72590083e-02f, 1.44553646e-01f, 1.99514199e-02f, -6.39651064e-03f, 7.07768649e-02f, 2.55285157e-03f, -9.33599398e-02f, -2.82260794e-02f,
  1.75047945e-02f, -3.94495092e-02f, -6.21987879e-02f, -6.22106940e-02f, -3.44107263e-02f, 6.42421916e-02f, 4.14739512e-02f, -4.29609697e-03f, -6.91310391e-02f, 6.82305619e-02f,
  -1.44534186e-01f, -2.83440977e-01f, -8.44859108e-02f, -7.19360411e-02f, -1.40434792e-02f, -1.06461436e-01f, 9.15518776e-02f, 1.19203649e-01f, -1.00576833e-01f, -4.87872586e-02f,
  4.40696739e-02f, -4.73920852e-02f, -4.57921922e-02f, 4.58671451e-02f, 1.14250451e-01f, 1.37071693e-02f, 2.66245008e-02f, -9.04868543e-02f, -2.31110752e-02f, -5.10210283e-02f,
  5.43025434e-02f, -2.36528013e-02f, 1.22293591e-01f, -3.17111462e-02f, -2.10617599e-03f, 1.47218280e-03f, 9.39629413e-03f, -3.27703767e-02f, -7.57071306e-04f, -1.52854361e-02f,
  -7.73668349e-01f, 2.58874565e-01f, 4.00374025e-01f, -1.81588262e-01f, -9.14170779e-03f, 3.01583171e-01f, 2.14340854e-02f, 2.88664520e-01f, 6.12835847e-02f, 1.75124958e-01f,
  -3.06205787e-02f, -7.32656494e-02f, 2.09728017e-01f, 9.10835937e-02f, 1.31890820e-02f, 1.15344346e-01f, 9.27625820e-02f, 4.81436066e-02f, 6.63760304e-02f, -8.41247663e-02f,
  -1.14905179e-01f, -1.21809162e-01f, 1.20265387e-01f, 1.64280698e-01f, -1.14785314e-01f, -1.21577375e-01f, -2.00398102e-01f, 5.65210320e-02f, -3.31912078e-02f, 4.17546220e-02f,
  -2.38033190e-01f, -1.03154823e-01f, -1.27309561e-01f, -8.97132675e-04f, 1.20960437e-02f, 1.99508686e-02f, -4.95588034e-02f, -3.78387943e-02f, -9.20145288e-02f, -4.04152274e-02f,
  -9.45592523e-02f, 3.02984305e-02f, -4.88209836e-02f, -2.23208312e-02f, 7.52599239e-02f, 5.92855886e-02f, 7.61140659e-02f, 5.43259969e-03f, 9.06522050e-02f, 4.52749319e-02f,
  1.25365138e-01f, 8.74214470e-02f, -6.78315461e-02f, 9.00693387e-02f, -2.13674922e-02f, 5.23289554e-02f, 6.13910705e-02f, -8.30491036e-02f, 2.86346227e-02f, -3.03971916e-02f,
  5.88445663e-02f, 2.64364965e-02f, 8.79584439e-03f, -1.00146867e-02f, 1.05863512e-02f, -9.08609293e-03f, -1.22685207e-03f, -3.58806886e-02f, 8.02818760e-02f, -8.98747891e-03f,
  -8.51093531e-02f, -4.67434106e-03f, 3.48378951e-03f, 9.22840275e-03f, -4.75379080e-02f, 1.69630675e-03f, -5.26114516e-02f, -9.21447426e-02f, -1.19096907e-02f, -6.21581413e-02f,
  6.61088750e-02f, 1.47859037e-01f, -3.14745046e-02f, -1.21898465e-01f, 5.62700555e-02f, 3.81356329e-02f, -1.76762827e-02f, 4.53195758e-02f, -1.51641518e-01f, -8.55921507e-02f,
  -1.95899010e-01f, -1.01663940e-01f, -1.24064974e-01f, -2.68767048e-02f, -1.25558361e-01f, -7.34735606e-03f, 7.93015435e-02f, -1.16565458e-01f, -6.93065077e-02f, -3.73809040e-02f,
  6.63147680e-03f, -8.17831382e-02f, -1.83685035e-01f, -9.57552865e-02f, 8.76758620e-02f, -2.15420891e-02f, -3.03513501e-02f, -6.40943050e-02f, -2.04295993e-01f, 5.40711805e-02f,
  -5.64965978e-02f, -9.22405645e-02f, 5.20481952e-02f, -1.95285387e-03f, -2.03446820e-02f, -8.41017663e-02f, -5.10737933e-02f, 6.75544292e-02f, -2.51311045e-02f, 3.06737684e-02f,
  1.53041378e-01f, -1.47434920e-01f, -8.51113573e-02f, 1.36568263e-01f, 1.22861184e-01f, 9.76047069e-02f, -5.49997762e-02f, 1.94457963e-01f, 3.73734385e-02f, -1.01558834e-01f,
  4.49625961e-02f, -1.74850166e-01f, -1.65959999e-01f, 1.51978701e-01f, 1.92341924e-01f, -7.58262724e-02f, 1.26161784e-01f, 3.35286418e-03f, 5.94009571e-02f, 4.72616144e-02f,
  1.17949665e-01f, 1.63485363e-01f, 4.88892905e-02f, 8.75984207e-02f, 2.56430581e-02f, 1.09402865e-01f, -3.85199077e-02f, -1.16521016e-01f, 6.82029128e-02f, -6.34554029e-03f,
  1.31444531e-02f, -2.06832625e-02f, -2.91148741e-02f, -5.69812134e-02f, -5.32361493e-02f, -5.68958111e-02f, -1.20570339e-01f, -8.03000480e-02f, -7.23947585e-02f, -9.79287997e-02f,
  -2.78141014e-02f, -7.15360120e-02f, 6.27921596e-02f, 1.51894540e-01f, 6.85877949e-02f, 4.57507782e-02f, 4.49792594e-02f, 9.69622657e-03f, -7.83375651e-02f, -5.67756034e-02f,
  -1.12608872e-01f, -3.00750472e-02f, -2.55763885e-02f, -7.92819411e-02f, 5.77858649e-02f, 7.32046505e-03f, -5.76199591e-03f, 4.73629264e-03f, 3.32131283e-03f, 6.94428533e-02f,
  -2.79511269e-02f, -2.82494351e-02f, -3.56671028e-02f, 4.35416624e-02f, 6.68967888e-02f, -7.40263931e-05f, 2.51220800e-02f, -7.52317370e-04f, -3.19123417e-02f, -4.13477384e-02f,
  -8.34074151e-03f, 8.05597827e-02f, 1.10406606e-02f, 3.33135091e-02f, 7.40961805e-02f, -2.97939149e-03f, -1.17167421e-02f, -2.34449608e-03f, 5.16622849e-02f, 3.94319184e-04f,
  1.96629250e-03f, 5.13422415e-02f, -3.17525119e-02f, -2.01221574e-02f, -5.27570620e-02f, 4.74423766e-02f, 4.81406637e-02f, -2.82014180e-02f, -5.23098446e-02f, -3.35333906e-02f,
  6.04628623e-02f, 3.91983464e-02f, -2.98190173e-02f, 4.35163453e-02f, 3.13480129e-03f, -4.64738496e-02f, -7.96746314e-02f, -4.92685102e-02f, 1.75050143e-02f, 2.11025309e-02f,
  -3.30792405e-02f, -8.39623958e-02f, -6.99706376e-02f, 1.07813396e-01f, 5.67256100e-02f, -2.26930156e-02f, -1.08409552e-02f, 1.58929303e-02f, -9.93607752e-03f, 5.69210127e-02f,
  -4.74943779e-02f, -4.48782407e-02f, -8.63875598e-02f, -6.54549897e-03f, -6.43423991e-03f, -6.39198795e-02f, 4.88165505e-02f, 3.28915156e-02f, -6.34563863e-02f, -1.60826072e-02f,
  8.85719135e-02f, -1.19518317e-01f, -2.82693923e-01f, -8.57696757e-02f, 2.76015252e-01f, 2.48261482e-01f, -1.32314414e-01f, 8.37312713e-02f, -1.77008197e-01f, 9.51584801e-03f,
  2.69858632e-02f, -2.15571970e-01f, -2.88899004e-01f, 1.44833475e-01f, 1.14884958e-01f, -3.04990083e-01f, 2.05903858e-01f, 7.43781179e-02f, -1.46492139e-01f, -8.73179361e-02f,
  -1.49240047e-01f, 2.52206713e-01f, -2.74287373e-01f, 2.43153378e-01f, 1.12172075e-01f, -1.03890643e-01f, 1.13042168e-01f, -1.65278465e-01f, 1.07056014e-01f, 1.58120722e-01f,
  2.52236370e-02f, -9.20145288e-02f, -1.05784245e-01f, -3.08368932e-02f, -3.44056375e-02f, 9.81111731e-03f, -2.22059060e-02f, 1.48039702e-02f, -7.12383762e-02f, -1.85998470e-01f,
  7.71923512e-02f, -2.75057759e-02f, 2.75983624e-02f, -2.42177639e-02f, 6.80064932e-02f, 5.33266030e-02f, 3.04763229e-03f, -1.37730632e-02f, -4.66118269e-02f, -8.29113647e-02f,
  -9.74375904e-02f, 9.90003422e-02f, 5.83894588e-02f, 1.10495249e-02f, 2.95419972e-02f, -3.65432315e-02f, 5.72728105e-02f, -6.17768951e-02f, 1.03851967e-02f, -3.07179131e-02f,
  2.01693401e-02f, 1.00453109e-01f, -4.98806126e-03f, 2.93242503e-02f, 2.68472498e-03f, 4.21213843e-02f, 7.73059130e-02f, -5.93297090e-03f, -7.20383152e-02f, -4.85143699e-02f,
  1.95706617e-02f, -7.63790309e-02f, 1.00191892e-03f, 5.98791055e-02f, -3.39954067e-03f, 1.02609187e-01f, 1.84354354e-02f, -1.24343559e-02f, -1.11057900e-01f, 1.80118380e-03f,
  -1.93377417e-02f, 4.53253239e-02f, -7.16684163e-02f, -2.84026489e-02f, 5.81282377e-02f, -6.80296794e-02f, 7.07863644e-02f, -5.40878028e-02f, -1.94035377e-02f, 5.91410063e-02f,
  6.19594231e-02f, -2.23749373e-02f, -1.33427233e-01f, -9.38009843e-03f, -6.32064641e-02f, 1.33235112e-01f, -4.68545333e-02f, 5.76444156e-03f, -6.92842714e-03f, -5.92421927e-02f,
  1.02665760e-01f, -1.17518594e-02f, 2.12441534e-02f, -1.28008146e-02f, 5.49917445e-02f, -3.53902206e-02f, 4.91166394e-03f, -7.82538503e-02f, 9.85113606e-02f, -3.24836448e-02f,
  1.19861312e-01f, 6.30462542e-02f, -5.19755967e-02f, 8.51440150e-03f, 8.35328102e-02f, 9.00503844e-02f, 2.11770888e-02f, -6.57651946e-02f, 8.85749906e-02f, -4.50791307e-02f,
  1.91115126e-01f, 1.67706087e-01f, -8.30356553e-02f, 1.05322979e-01f, -5.36905751e-02f, -9.65218246e-02f, -6.31180108e-02f, -3.39875594e-02f, -1.46108955e-01f, 1.72357380e-01f,
  -1.86171327e-02f, 3.65287475e-02f, 9.11679938e-02f, 2.12925181e-01f, 2.87156343e-01f, -2.70223394e-02f, 2.45954975e-01f, -6.47166893e-02f, -6.74064308e-02f, 1.91666067e-01f,
  1.14698306e-01f, 3.31014991e-01f, 1.60765409e-01f, 8.44572783e-02f, 1.76959202e-01f, -6.57216832e-02f, 1.27817512e-01f, -1.21602938e-01f, 1.15950204e-01f, 1.02340586e-01f,
  1.69000681e-02f, 4.04884182e-02f, -2.33606454e-02f, -8.10373649e-02f, 4.59992476e-02f, 8.89613777e-02f, -6.01945557e-02f, -4.69290884e-03f, -1.48677200e-01f, -3.39178788e-03f,
  2.67469008e-02f, 5.57029201e-03f, 1.66329667e-02f, -2.14002887e-03f, -3.77984941e-02f, 8.88129137e-03f, -5.52758016e-02f, -1.45104662e-01f, -7.17124045e-02f, 7.21535310e-02f,
  -2.65713371e-02f, -7.12158233e-02f, 6.33616671e-02f, 2.58819554e-02f, -1.31247237e-01f, 1.68146808e-02f, 5.91921918e-02f, -1.01283509e-02f, 3.48201506e-02f, 1.35296015e-02f,
  1.04634151e-01f, -5.25325909e-02f, 2.09326725e-02f, -8.44839402e-03f, 3.28643218e-04f, 3.77937146e-02f, -3.40610258e-02f, 8.39454122e-03f, 6.09154776e-02f, -1.95344575e-02f,
  -4.04941626e-02f, 3.33535932e-02f, 3.09800059e-02f, 3.07746530e-02f, 1.15561910e-01f, -2.66582984e-02f, -1.09566920e-01f, -3.08955107e-02f, 3.56326289e-02f, -1.20617911e-01f,
  -1.42061478e-02f, 8.39855969e-02f, 3.84044996e-03f, -9.20074135e-02f, 1.32835582e-02f, 1.61391795e-02f, 1.38781473e-01f, 2.03343909e-02f, -8.21039006e-02f, -2.34245621e-02f,
  7.92509541e-02f, 2.15577364e-01f, -3.39932181e-02f, -7.73863420e-02f, 4.73175524e-03f, 1.08760133e-01f, 1.47181079e-01f, 4.09927517e-02f, 9.51548517e-02f, -6.77621067e-02f,
  1.13743424e-01f, -1.00899987e-01f, -4.43640165e-02f, -3.82477604e-02f, -5.60338758e-02f, 8.42677131e-02f, 2.86116474e-03f, -4.75823320e-02f, 2.90719774e-02f, 6.08242825e-02f,
  6.92814663e-02f, 7.83319585e-03f, 1.05426691e-01f, -1.08262666e-01f, 4.87630740e-02f, 3.07920333e-02f, 3.61114508e-03f, -3.01450007e-02f, 1.60741165e-01f, -5.15463278e-02f,
  7.85315260e-02f, -3.22206289e-01f, -1.64219424e-01f, 8.53477642e-02f, 9.90878865e-02f, -8.02261755e-02f, -9.14144740e-02f, 4.82319258e-02f, -1.50774345e-01f, -1.57580256e-01f,
  3.09733618e-02f, -2.42625043e-01f, -2.15355963e-01f, -1.02335282e-01f, 9.40914676e-02f, -1.93982288e-01f, 3.90895456e-02f, -9.19624716e-02f, 1.89320706e-02f, 1.79306604e-02f,
  1.88109964e-01f, 1.71094209e-01f, 1.02448471e-01f, 2.26348624e-01f, 1.06253840e-01f, 2.00550094e-01f, 2.07585648e-01f, 5.61560653e-02f, 1.29393220e-01f, 1.30082756e-01f,
  -1.01510854e-02f, 1.43803367e-02f, 1.33332834e-02f, -7.22473860e-02f, 9.92764011e-02f, 1.55798927e-01f, 1.01753250e-01f, -5.57013936e-02f, -5.78184426e-02f, -5.59800193e-02f,
  -7.75964856e-02f, 8.43156204e-02f, 7.43998960e-02f, -6.63927495e-02f, 3.54127549e-02f, 1.98349878e-02f, -7.02217221e-02f, 7.66437501e-03f, 4.08426411e-02f, -2.09070280e-01f,
  -6.65833578e-02f, -5.36704138e-02f, 1.68771967e-02f, -1.25926016e-02f, -9.22208279e-02f, 3.25050838e-02f, 1.06659353e-01f, -2.28000153e-02f, 3.82887237e-02f, 1.87182799e-01f,
  2.98390687e-02f, 5.84486797e-02f, 1.98312271e-02f, -4.15708218e-03f, -3.57469693e-02f, -6.08386993e-02f, 5.06272987e-02f, -1.03638329e-01f, -8.25205818e-03f, -2.63558067e-02f,
  3.21733952e-02f, 1.07915729e-01f, -8.07790235e-02f, -9.17854682e-02f, -3.46614234e-02f, -3.05860043e-02f, 2.36366149e-02f, 8.60297903e-02f, 6.51161596e-02f, -7.93729629e-03f,
  -4.58171405e-02f, -6.65339604e-02f, -7.56756291e-02f, 6.74062595e-03f, -7.23599494e-02f, -1.43805623e-01f, -4.60239453e-03f, -8.59712213e-02f, 1.08931199e-01f, 9.41239670e-02f,
  -9.78372619e-02f, -4.47868146e-02f, 5.92529997e-02f, 3.55640240e-02f, 8.94787014e-02f, 3.25019881e-02f, -1.85018033e-02f, -5.81497587e-02f, -4.33295406e-02f, -5.43455407e-02f,
  6.48897141e-02f, 8.26469660e-02f, 1.32985590e-02f, -6.10250160e-02f, -2.00157911e-02f, -2.59972494e-02f, -3.28625962e-02f, 1.32063687e-01f, 1.72060519e-01f, -1.83184147e-02f,
  7.20610423e-03f, -1.38010725e-01f, 1.15345411e-01f, 1.07601747e-01f, -4.67385501e-02f, -3.99296954e-02f, 5.98119665e-03f, -2.37207743e-03f, 9.00118425e-03f, 5.83756492e-02f,
  -4.08846885e-01f, 6.11717626e-02f, 1.65676754e-02f, -2.02698365e-01f, 1.19774446e-01f, 1.35052754e-02f, -1.03479706e-01f, 7.94403255e-02f, -8.94433334e-02f, 8.18523020e-02f,
  1.53383955e-01f, -2.78283000e-01f, 1.50230408e-01f, -1.83506012e-01f, -3.43993425e-01f, -4.67033358e-04f, -2.10840330e-01f, -1.67305097e-01f, -6.68475032e-02f, -1.22895524e-01f,
  -1.06996790e-01f, -1.25580076e-02f, -1.49469078e-01f, 1.59059435e-01f, -1.21135235e-01f, -8.33693370e-02f, -5.14408909e-02f, 1.80906951e-01f, -1.22525349e-01f, 2.69978261e-03f,
  1.27341136e-01f, 2.13772114e-02f, 6.94048628e-02f, 5.01202270e-02f, 6.70990124e-02f, -1.38752414e-02f, -3.24184857e-02f, -4.64821234e-02f, 1.18638910e-01f, -1.17199728e-02f,
  -6.44845376e-03f, 3.36445682e-02f, -5.52285016e-02f, 2.60045677e-02f, 5.36035374e-02f, 1.19180560e-01f, -5.71822822e-02f, -4.72024642e-02f, 1.04376681e-01f, -5.95308244e-02f,
  -4.00987007e-02f, -2.84447446e-02f, -1.15369350e-01f, -8.05115029e-02f, -1.80429798e-02f, 1.01173989e-01f, -5.08008376e-02f, 1.11854263e-03f, -2.82824282e-02f, -6.20154180e-02f,
  -4.44885753e-02f, 9.35616624e-03f, 9.75664984e-03f, 9.56702232e-02f, 1.63719449e-02f, 1.10596679e-01f, -6.81737661e-02f, -1.36399521e-02f, -8.51727948e-02f, 4.98988330e-02f,
  4.22721393e-02f, -2.73131542e-02f, 4.90118526e-02f, -7.76251107e-02f, -4.36673313e-02f, 2.74986215e-02f, 1.09679131e-02f, 9.36913490e-02f, -3.71534266e-02f, -1.12883113e-02f,
  -2.01676562e-02f, -1.83342993e-02f, 6.19049110e-02f, -3.48100476e-02f, 1.46086678e-01f, -1.03289157e-01f, -4.13300656e-02f, 2.86619086e-02f, 1.17453754e-01f, -8.40745345e-02f,
  4.31756191e-02f, -4.26172689e-02f, 8.60836208e-02f, 4.86672372e-02f, 1.16583802e-01f, 1.54048968e-02f, -4.21074890e-02f, 7.65640885e-02f, -3.54261063e-02f, 5.82882669e-03f,
  -1.72655564e-02f, 8.99090245e-03f, 3.16369310e-02f, 3.37094180e-02f, 3.10090594e-02f, 6.96607381e-02f, -1.22990310e-02f, 3.73464078e-02f, 2.84724664e-02f, 8.85445997e-02f,
  2.55530644e-02f, 7.10489377e-02f, -1.00561373e-01f, -8.43450613e-03f, -8.31407160e-02f, -6.83142664e-03f, -8.02704021e-02f, 8.98128375e-02f, -5.06281890e-02f, -1.28621915e-02f,
  -3.04886788e-01f, 3.39936584e-01f, 1.07104406e-01f, 2.31302232e-01f, -5.91727234e-02f, -3.18074703e-01f, 5.15772216e-02f, 4.19467799e-02f, 2.96680897e-01f, 5.34087345e-02f,
  -9.74138901e-02f, 2.59672612e-01f, 4.02820744e-02f, 1.79066047e-01f, -3.14695150e-01f, -1.69574827e-01f, -8.37304890e-02f, 6.40370175e-02f, 6.58476651e-02f, 8.06142911e-02f,
  -2.29356840e-01f, 1.15204230e-02f, -1.59052595e-01f, 4.46872180e-03f, 9.04142708e-02f, 1.41068056e-01f, 5.24425879e-02f, 1.25692338e-01f, -7.97686080e-05f, 5.65260984e-02f,
  -1.33751735e-01f, 6.65166900e-02f, -2.73323767e-02f, 7.46623725e-02f, -1.24700844e-01f, -3.47460881e-02f, -1.01787701e-01f, 2.86732689e-02f, 3.98516729e-02f, -1.49756119e-01f,
  -1.87782124e-02f, 2.37067174e-02f, -1.03373803e-01f, 6.60758913e-02f, 9.35474783e-02f, -3.68422680e-02f, 8.83819908e-02f, -4.87324782e-02f, 9.70194936e-02f, -6.52131140e-02f,
  -3.74168679e-02f, 3.39288637e-02f, 5.79930656e-02f, -1.17275469e-01f, -3.98308225e-02f, 3.93911265e-02f, -8.70742183e-03f, 2.83434894e-02f, -6.82225972e-02f, 4.15382311e-02f,
  -5.09091187e-03f, -9.32427496e-02f, 1.14916161e-01f, 1.53277352e-01f, 1.17344521e-01f, 1.84200723e-02f, 1.20200574e-01f, -2.41859164e-02f, 1.58185169e-01f, -1.16656616e-01f,
  -1.17562480e-01f, 6.24655709e-02f, 2.60378793e-02f, -1.83008462e-02f, 1.49716018e-02f, 1.56244859e-01f, -1.09879086e-02f, -2.01086383e-02f, -1.25726700e-01f, -9.08132344e-02f,
  1.35051325e-01f, 4.88109142e-02f, -8.26810822e-02f, -1.23370424e-01f, -7.40102530e-02f, 1.16202623e-01f, -2.79527493e-02f, -1.18931636e-01f, -1.00437731e-01f, -5.20453416e-02f,
  1.19182933e-02f, 1.53873146e-01f, -3.99474353e-02f, -3.00156157e-02f, -6.47212490e-02f, -4.35902998e-02f, 1.09474780e-02f, -1.68156549e-01f, -1.12860352e-02f, -1.01230226e-01f,
  9.12257954e-02f, -7.67256739e-03f, -1.12938955e-01f, -6.85771108e-02f, -2.36148331e-02f, 2.37125047e-02f, 1.43907756e-01f, 2.24385262e-02f, -1.25387646e-02f, -6.91403821e-02f,
  1.38573591e-02f, 4.48875874e-02f, -1.88014582e-01f, -3.55499424e-02f, -2.84338202e-02f, 7.62639716e-02f, 7.04892427e-02f, -8.39371979e-02f, -7.82552883e-02f, -5.60743287e-02f,
  2.31513187e-01f, -3.58176939e-02f, -2.69620381e-02f, 1.04379632e-01f, -7.56492615e-02f, -2.21626684e-01f, -2.72541732e-01f, 5.76899014e-02f, -1.78042546e-01f, -1.00812949e-01f,
  1.58757612e-01f, -7.63719156e-02f, 2.41827276e-02f, 1.69310287e-01f, 2.77771652e-01f, -3.16622704e-02f, 1.44144833e-01f, 3.00456472e-02f, 6.19956143e-02f, 1.23849638e-01f,
  2.79071122e-01f, 2.44987950e-01f, 2.05321059e-01f, 2.21037641e-01f, 4.35795859e-02f, 2.29302824e-01f, 1.79911181e-01f, 6.14612363e-03f, 1.47455722e-01f, 4.61884029e-02f,
  -3.92563641e-03f, 9.16997045e-02f, -3.77610102e-02f, -4.80696112e-02f, 6.07995503e-02f, -6.87966943e-02f, -6.28853738e-02f, 5.22010662e-02f, 8.06476846e-02f, 4.52238247e-02f,
  -1.08834663e-02f, 7.22141638e-02f, 2.51210388e-02f, 2.06381064e-02f, -2.73646228e-02f, -8.49458724e-02f, -4.09337841e-02f, -4.13194448e-02f, -1.40000314e-01f, -2.67299567e-03f,
  -5.66072613e-02f, -5.35262562e-02f, 3.43696326e-02f, -1.42737508e-01f, -6.97311684e-02f, 8.31799805e-02f, -3.87907005e-03f, -5.78311384e-02f, 7.71342218e-02f, 2.11483128e-02f,
  1.72262967e-01f, -8.82667750e-02f, -1.43057918e-02f, 3.69038358e-02f, -6.46170452e-02f, -1.51952608e-02f, 7.75106624e-02f, 5.55855185e-02f, 8.27669259e-03f, 3.08060623e-03f,
  1.51636293e-02f, 6.14564940e-02f, 5.98743930e-02f, -2.19921358e-02f, -2.76387576e-02f, -5.72553948e-02f, 1.45230917e-02f, -9.95987467e-03f, -9.08185840e-02f, -3.86099145e-02f,
  -8.96051154e-03f, 4.12978940e-02f, -5.03579564e-02f, 1.02060754e-02f, -4.69337730e-03f, 2.50431895e-02f, -1.26193545e-03f, -6.67422861e-02f, -5.97825721e-02f, -4.40788828e-02f,
  -7.56537989e-02f, 1.14079706e-01f, -1.13404714e-01f, -1.01091221e-01f, -7.23606795e-02f, -1.01503648e-03f, -2.52553038e-02f, 5.73312901e-02f, 1.29253730e-01f, -8.91947933e-03f,
  6.12551905e-02f, -1.08880131e-02f, -2.43274905e-02f, -1.10512199e-02f, 9.45695862e-02f, -2.18884498e-02f, 7.44038448e-02f, -6.48634359e-02f, -7.71669522e-02f, 1.14004426e-01f,
  3.59315127e-02f, -1.03943925e-02f, 5.58819659e-02f, -9.47825238e-02f, 4.40418161e-02f, -8.97994563e-02f, 2.11308841e-02f, -4.38129082e-02f, 5.40406778e-02f, -9.94790718e-03f,
  -4.44925725e-01f, 3.15347701e-01f, -3.25802535e-01f, 1.30387411e-01f, -1.31778657e-01f, 3.76196414e-01f, 3.54272902e-01f, 1.54700831e-01f, 2.27405190e-01f, 3.68953258e-01f,
  1.75718993e-01f, -2.12811809e-02f, 4.66414057e-02f, 2.18116432e-01f, 9.25747585e-03f, 2.22402960e-01f, 2.86008716e-01f, 2.03194723e-01f, -2.44009197e-02f, -2.35201721e-03f,
  -1.61639959e-01f, 1.92227066e-01f, -7.70783424e-02f, -1.21760853e-01f, -1.36616617e-01f, -3.57983053e-01f, 4.00661072e-03f, -2.75069296e-01f, 6.21686224e-03f, 2.36668494e-02f,
  -9.90151539e-02f, -1.65165856e-01f, -8.14763755e-02f, -6.90956265e-02f, -1.66491330e-01f, -1.45986393e-01f, -6.36500120e-02f, -3.68097350e-02f, -1.40164029e-02f, 3.33707668e-02f,
  -1.74418073e-02f, -6.40683845e-02f, -1.72214843e-02f, -1.32621741e-02f, 6.87880367e-02f, -2.92924345e-02f, 7.94877186e-02f, 1.95037246e-01f, 1.30776241e-01f, 4.81457002e-02f,
  3.87453772e-02f, 1.19668245e-02f, 1.22185439e-01f, 5.83637170e-02f, -2.41014790e-02f, 6.74580634e-02f, 3.37933376e-02f, -3.23882028e-02f, 1.69438124e-02f, 6.86333515e-03f,
  -8.96950066e-02f, -9.16487202e-02f, -3.57009321e-02f, -3.23251523e-02f, -2.51023248e-02f, -7.21021518e-02f, 7.96881393e-02f, -1.58293750e-02f, 3.48802237e-03f, -1.91470664e-02f,
  7.19296560e-02f, 7.00577050e-02f, 2.41840538e-02f, 6.31303620e-03f, 1.33688599e-02f, 4.39017452e-02f, -1.50752878e-02f, 3.74322408e-03f, 5.39485663e-02f, 9.76032689e-02f,
  6.69487752e-04f, -3.50564159e-02f, -2.43104752e-02f, -1.06305212e-01f, -5.80274351e-02f, -1.05098672e-02f, 4.26256247e-02f, 3.67416702e-02f, -1.07200388e-02f, -4.20676693e-02f,
  1.65320024e-01f, 9.30470824e-02f, -2.68317554e-02f, -3.61926034e-02f, -3.58711295e-02f, 2.78738663e-02f, -6.82378337e-02f, 8.75244197e-03f, -1.36569049e-02f, -1.34811848e-01f,
  1.30521178e-01f, -5.67537434e-02f, -1.02682307e-01f, -1.80767272e-02f, 8.07150081e-02f, 4.95937876e-02f, 5.15751168e-03f, -3.46275046e-02f, 5.44648841e-02f, -2.94864643e-02f,
  -3.70222032e-02f, 4.50224541e-02f, 5.09388857e-02f, -6.62790015e-02f, 5.77627458e-02f, 1.92222856e-02f, 5.29922694e-02f, -2.08075549e-02f, -6.27774447e-02f, 3.60011086e-02f,
  8.15327168e-02f, -1.72663659e-01f, -4.81248610e-02f, 1.62626356e-01f, 1.69122979e-01f, -1.14848517e-01f, -8.73762816e-02f, 8.87875706e-02f, 3.42497639e-02f, -1.92211509e-01f,
  3.91411558e-02f, 4.57970314e-02f, -5.07009961e-02f, 3.06316856e-02f, 2.13984951e-01f, -1.90930247e-01f, 2.24023089e-01f, 9.88273323e-02f, 5.60461879e-02f, 7.85110220e-02f,
  1.95638865e-01f, 8.45136195e-02f, 1.10741794e-01f, 4.37392779e-02f, 4.72707078e-02f, 5.44388480e-02f, 2.18887419e-01f, -2.14295164e-02f, 8.67237598e-02f, 2.60691140e-02f,
  -4.25918177e-02f, 5.44631891e-02f, 1.28790457e-02f, -2.03216206e-02f, 2.43211016e-02f, -3.27902772e-02f, -1.10825196e-01f, 4.51108664e-02f, 3.08315419e-02f, -3.45403031e-02f,
  -4.48224470e-02f, 6.25377074e-02f, 4.79622893e-02f, 1.15907028e-01f, 1.65504720e-02f, 7.52347857e-02f, 1.99681744e-02f, -5.37905209e-02f, -5.42878434e-02f, -1.02524586e-01f,
  -8.10573548e-02f, -5.31024076e-02f, 3.47643904e-02f, 2.63738465e-02f, -7.64303189e-03f, -2.62500849e-02f, 5.99953495e-02f, 7.72766024e-02f, -3.41056995e-02f, -3.51608172e-02f,
  -1.20123941e-02f, 2.79039014e-02f, 4.20477334e-03f, 2.26568989e-02f, 6.88029826e-02f, -2.00391784e-02f, -1.17443567e-02f, 2.72284392e-02f, -2.16643196e-02f, -3.50097232e-02f,
  -3.67129291e-03f, 2.82423198e-02f, -4.53656130e-02f, 6.79438561e-02f, 6.74675182e-02f, -6.04127347e-02f, -1.47266861e-03f, -7.94654526e-03f, -6.33996306e-03f, 1.33853517e-02f,
  1.55992256e-02f, 1.35982791e-02f, 1.69505645e-02f, -2.35265270e-02f, -9.10504609e-02f, 4.50502858e-02f, -2.06139982e-02f, -3.37828472e-02f, -3.84662971e-02f, 3.36166508e-02f,
  -1.02064582e-02f, 1.41781522e-02f, -1.15037441e-01f, -7.13147968e-02f, -3.10772173e-02f, -7.69067854e-02f, -5.24926409e-02f, 1.03027822e-04f, -6.71680719e-02f, -1.43332705e-01f,
  2.70339381e-02f, 3.21217142e-02f, -7.80501822e-03f, 9.09860507e-02f, 3.80650572e-02f, 4.22482006e-02f, 6.07278086e-02f, -4.43098284e-02f, 3.41548175e-02f, 4.79199365e-03f,
  4.93665189e-02f, -2.51226798e-02f, -4.73264046e-02f, -5.67620136e-02f, 4.47084941e-02f, 4.10450883e-02f, 1.13222115e-02f, -1.91667490e-02f, -2.25422047e-02f, -1.55393325e-03f,
  1.51085347e-01f, -2.20214337e-01f, -3.16491365e-01f, 4.06611711e-04f, 1.39529526e-01f, 2.64741570e-01f, 4.41821441e-02f, -4.61595282e-02f, -1.54915974e-01f, 1.31387383e-01f,
  1.27961278e-01f, -1.08198255e-01f, -7.17063397e-02f, 2.22265184e-01f, 5.94422631e-02f, -1.66596323e-01f, 3.06211978e-01f, 7.77324513e-02f, -1.18135244e-01f, -5.36943637e-02f,
  1.97805725e-02f, 3.05587143e-01f, -2.08113462e-01f, 1.62991047e-01f, 1.79196075e-01f, -1.87361836e-01f, -5.80445491e-03f, -2.21395135e-01f, 8.75637457e-02f, 7.01252520e-02f,
  1.01741508e-01f, -1.01663746e-01f, 9.92878247e-03f, 1.49560357e-02f, -9.62479711e-02f, 6.28235415e-02f, -1.81765761e-02f, -1.83201544e-02f, -1.14465408e-01f, -1.51851922e-01f,
  1.83188673e-02f, -4.03448157e-02f, -2.69765630e-02f, -3.37807126e-02f, 6.53544292e-02f, 2.98601463e-02f, 1.92513727e-02f, -1.13104723e-01f, -1.28358006e-01f, 4.40638885e-02f,
  -9.06513333e-02f, -7.40227178e-02f, -5.29141836e-02f, -1.16948858e-01f, -2.51017250e-02f, -8.77333060e-02f, -9.69780013e-02f, -2.66950745e-02f, -1.45087345e-02f, 1.93332229e-02f,
  7.87910521e-02f, 2.68514697e-02f, 4.88463901e-02f, 1.37759820e-02f, -3.30647454e-02f, 1.32626489e-01f, 8.07974860e-02f, -1.03546530e-02f, -5.89216687e-02f, -3.26096155e-02f,
  -4.74283323e-02f, 6.03188910e-02f, -4.21711206e-02f, 8.52249712e-02f, 2.91943345e-02f, 6.91753179e-02f, -4.61019725e-02f, 3.75520438e-02f, -2.55242288e-02f, -2.04117186e-02f,
  -3.26274596e-02f, 4.66535650e-02f, -5.15600927e-02f, -8.18721280e-02f, 1.61095206e-02f, 1.59633439e-02f, 1.59098711e-02f, -4.51885648e-02f, -8.11825246e-02f, 4.17541750e-02f,
  5.56003302e-02f, -8.90613943e-02f, 1.56160733e-02f, -2.44914480e-02f, -1.08701877e-01f, 9.24103856e-02f, -7.17787445e-02f, -3.98728587e-02f, -5.89979440e-02f, -5.82199693e-02f,
  9.39250812e-02f, -2.39189807e-03f, 8.02066550e-03f, -9.18822654e-04f, -1.18288711e-01f, 6.60714209e-02f, 5.89261986e-02f, -7.02645183e-02f, -2.84519792e-02f, -7.41389627e-03f,
  4.10676524e-02f, 2.59093400e-02f, -1.11145303e-01f, -4.20142636e-02f, 8.86002705e-02f, -3.80292907e-02f, -8.38153064e-02f, -9.18526202e-02f, -6.41331589e-03f, -1.07750036e-01f,
  -2.50262588e-01f, -1.82688072e-01f, -3.03933144e-01f, -2.02043235e-01f, -1.77560762e-01f, -2.69599140e-01f, -1.54149219e-01f, -8.42548460e-02f, 7.21774548e-02f, 2.09402263e-01f,
  1.10916220e-01f, 3.08911279e-02f, 1.46558911e-01f, -1.12549953e-01f, -1.68850526e-01f, 1.53947994e-01f, -1.61317930e-01f, 1.23931048e-02f, -8.81389808e-03f, -2.60088533e-01f,
  -9.62215140e-02f, -6.16571829e-02f, -1.33326620e-01f, -4.40907963e-02f, -2.28239417e-01f, 4.49328385e-02f, 1.17149465e-01f, -1.61480427e-01f, -7.08714649e-02f, 3.66036594e-02f,
  -9.08681601e-02f, -1.08958362e-02f, -9.40923393e-02f, -1.21672206e-01f, -9.03673321e-02f, -8.12880471e-02f, -5.04054800e-02f, 5.20071015e-02f, 7.21790083e-03f, -1.19406186e-01f,
  -1.45484479e-02f, 8.54837671e-02f, -2.67308392e-02f, 8.92842412e-02f, -8.14442802e-03f, -8.35091807e-03f, -1.23791425e-02f, -5.15395477e-02f, -5.18216901e-02f, -9.17958934e-03f,
  -2.10136641e-02f, -5.39449416e-02f, 7.83766583e-02f, 8.38023499e-02f, 2.43961290e-02f, 3.50703038e-02f, 4.21130322e-02f, -7.45507479e-02f, -1.64821327e-01f, -4.36258093e-02f,
  -7.31877089e-02f, -2.88609997e-03f, -2.58359239e-02f, 1.15599222e-02f, 2.39306409e-03f, 5.30430041e-02f, 7.60026136e-03f, -2.14261934e-02f, 7.18824565e-02f, -8.70805606e-03f,
  5.28346375e-03f, -2.94741578e-02f, 4.36945073e-02f, -2.74822488e-02f, -5.20898476e-02f, -3.30002941e-02f, 9.44555551e-02f, -3.85660380e-02f, -1.32786678e-02f, -3.60384770e-02f,
  1.00128815e-01f, 4.30848077e-03f, -4.03525261e-03f, 2.60040932e-03f, -1.29389048e-01f, 5.91311883e-03f, 1.08677298e-01f, -1.07270986e-01f, 7.10700825e-02f, -2.36915387e-02f,
  -9.76088420e-02f, -1.06641784e-01f, -3.92742157e-02f, -2.72473991e-02f, 1.14030018e-02f, -7.05329478e-02f, -1.38068441e-02f, -8.16361681e-02f, -1.20090514e-01f, -1.84607729e-01f,
  3.32049206e-02f, -3.36316228e-02f, -1.40696630e-01f, 5.91300204e-02f, 1.57621711e-01f, -2.07817871e-02f, -2.11475492e-02f, -8.76500234e-02f, -5.43543212e-02f, 4.17294390e-02f,
  1.17150567e-01f, 5.95727414e-02f, 1.81354538e-01f, 9.62716416e-02f, 1.09006941e-01f, 8.03218558e-02f, -5.99567555e-02f, -3.56006250e-02f, -5.52812889e-02f, 4.38803285e-02f,
  -3.78522314e-02f, -3.05971861e-01f, 1.42890781e-01f, -7.26511553e-02f, 5.74534992e-03f, -7.46248513e-02f, 3.30128931e-02f, -2.06455216e-01f, -1.18704200e-01f, -1.81186870e-01f,
  -1.18931592e-01f, 2.94255406e-01f, 2.14673683e-01f, -2.18398467e-01f, 3.98806304e-01f, 1.50084227e-01f, -1.41825274e-01f, -8.55730996e-02f, -7.56464899e-03f, -6.19911663e-02f,
  3.43840756e-02f, -1.89054787e-01f, 3.29081491e-02f, -3.43192965e-01f, -2.20013469e-01f, -1.15821794e-01f, 1.00175641e-01f, 1.11126468e-01f, -1.42768413e-01f, 1.73143715e-01f,
  -5.96680641e-02f, -1.92921057e-01f, -1.94471747e-01f, -4.16616350e-02f, -1.32499740e-01f, 1.11302927e-01f, 1.35112956e-01f, 1.69211507e-01f, -6.13824129e-02f, -8.36464241e-02f,
  -1.34495832e-02f, -1.99266039e-02f, -3.84847857e-02f, 1.03511102e-01f, -3.79692987e-02f, -1.88042596e-02f, 3.13301571e-02f, -8.48198533e-02f, -5.71457483e-02f, 7.65333995e-02f,
  -2.56119249e-03f, 8.64498504e-03f, -2.71701925e-02f, -1.35739535e-01f, -2.94841337e-03f, -6.77760169e-02f, -4.81062420e-02f, 9.04255435e-02f, 9.17338952e-03f, -1.54091949e-02f,
  -1.20918289e-01f, 1.03692062e-01f, 5.12960404e-02f, 4.09430601e-02f, 7.35410601e-02f, 7.23789558e-02f, -7.41132628e-03f, 1.86717108e-01f, 3.41130956e-03f, -4.32862006e-02f,
  -5.40754870e-02f, -2.28235368e-02f, -4.87906039e-02f, 7.91667026e-06f, 1.87793318e-02f, -3.30349170e-02f, 8.46245140e-02f, -1.01696037e-01f, -1.26233310e-01f, 5.33158034e-02f,
  5.36616296e-02f, 1.16101302e-01f, -1.01920508e-01f, 5.05385324e-02f, -2.12313309e-02f, 6.71338812e-02f, 9.95579176e-03f, -8.74505639e-02f, 6.70986529e-03f, 5.72737344e-02f,
  -1.01436846e-01f, -2.08635211e-01f, -1.18493527e-01f, -1.29502282e-01f, -1.31988958e-01f, -3.34489122e-02f, 4.44266340e-03f, 7.77393505e-02f, -5.65501899e-02f, -1.04115784e-01f,
  -6.45065755e-02f, 2.74483431e-02f, 5.93695277e-03f, 1.02012837e-02f, -1.59898810e-02f, 8.33422411e-03f, 3.87962498e-02f, 2.87018921e-02f, -8.16870257e-02f, 4.37362529e-02f,
  -2.64582541e-02f, -1.85938906e-02f, 1.50193982e-02f, -1.43292308e-01f, -4.70248284e-03f, 2.59563737e-02f, 4.87071462e-02f, -5.51945902e-02f, 1.01478644e-01f, 6.97810715e-03f,
  2.93089509e-01f, -3.99916828e-01f, 9.38308313e-02f, 2.61850148e-01f, 2.48268753e-01f, 2.87604872e-02f, 1.61811486e-01f, -4.38509695e-02f, 2.86500305e-01f, -2.91909218e-01f,
  8.19084644e-02f, -9.74674374e-02f, -5.05614504e-02f, -2.37075686e-02f, 1.94126531e-01f, -1.43750042e-01f, 6.14614971e-02f, 9.50629544e-03f, 7.81414136e-02f, 6.09082617e-02f,
  2.17087418e-01f, -1.82056185e-02f, -4.02118973e-02f, -2.07572401e-01f, 8.28448981e-02f, -3.44993809e-04f, -7.19828978e-02f, -6.27845600e-02f, -1.37131914e-01f, -9.23109576e-02f,
  1.06263019e-01f, 5.50792813e-02f, 3.39204594e-02f, -4.09121923e-02f, -3.63491438e-02f, -7.73455650e-02f, -4.76218238e-02f, -2.74423435e-02f, 3.17163207e-02f, 2.41104718e-02f,
  -5.75732887e-02f, -1.46500934e-02f, 4.73093055e-03f, 1.67352512e-01f, 6.90675378e-02f, 3.04930396e-02f, 1.70308538e-02f, 5.77412769e-02f, -4.30404246e-02f, -1.88405123e-02f,
  2.98153609e-02f, -8.91369954e-02f, 9.44799483e-02f, -7.51796514e-02f, 2.20426079e-02f, 8.47894996e-02f, -1.16901956e-01f, 6.37463555e-02f, -1.77606791e-02f, -5.55533729e-02f,
  -7.84314722e-02f, -7.74711818e-02f, 2.87382957e-02f, -3.17687206e-02f, -2.09080651e-02f, 6.70418814e-02f, 5.42855449e-02f, -2.69152839e-02f, 9.51615721e-02f, -1.43829724e-02f,
  3.75774987e-02f, 8.71923491e-02f, 3.76126170e-02f, -4.06961218e-02f, 5.96998073e-02f, 4.24263440e-02f, -1.41382637e-02f, -1.19701654e-01f, -7.59338308e-03f, -2.02312618e-02f,
  1.58277825e-01f, 7.64593855e-02f, -8.23462382e-02f, 3.45666520e-02f, -4.56140302e-02f, 1.57616064e-02f, -5.14466427e-02f, -2.97105376e-04f, -5.35195954e-02f, 3.27231437e-02f,
  2.91138068e-02f, -2.85314292e-01f, -2.37092171e-02f, -7.94416517e-02f, -7.07878843e-02f, -1.28737092e-01f, -1.66335180e-02f, -8.02135915e-02f, -7.50970170e-02f, -6.80023357e-02f,
  -4.56139855e-02f, 1.26352040e-02f, -7.28671551e-02f, 5.26574738e-02f, -8.06875527e-03f, -6.15084022e-02f, -4.23921086e-02f, -1.26672447e-01f, -8.11624974e-02f, -4.57860678e-02f,
  4.64478135e-02f, -8.60265568e-02f, 4.91241850e-02f, -5.10692336e-02f, -1.24969454e-02f, -1.20433047e-01f, -2.73750741e-02f, -5.71404621e-02f, -2.45475583e-02f, -3.40147726e-02f,
  5.39887585e-02f, -6.94755241e-02f, 9.59919859e-03f, -2.12046923e-03f, -1.17343761e-01f, -1.91752791e-01f, -2.06058308e-01f, -1.52153462e-01f, 6.30339384e-02f, -2.08937731e-02f,
  -2.07328439e-01f, 2.35813260e-01f, -1.67797487e-02f, -2.09547684e-01f, 1.07774802e-01f, -8.33419990e-03f, -2.03793168e-01f, -1.65207824e-03f, -1.40893295e-01f, -1.81048393e-01f,
  -9.41183940e-02f, -2.30184451e-01f, -1.50195435e-01f, -2.54905552e-01f, -2.06458256e-01f, 5.23373298e-02f, 8.99153575e-02f, -7.91015923e-02f, -1.51267305e-01f, -1.34327918e-01f,
  -2.00855546e-02f, -1.82904869e-01f, -4.20808271e-02f, -3.07261962e-02f, -1.47919759e-01f, -4.09798436e-02f, -5.47623001e-02f, -1.12328969e-01f, 1.28016546e-01f, 1.35804981e-01f,
  4.57488112e-02f, -2.33533587e-02f, 3.00694928e-02f, 4.20361683e-02f, -7.86711872e-02f, 4.87066880e-02f, 2.70766560e-02f, 8.31520036e-02f, 4.06808704e-02f, 9.74142551e-02f,
  6.30472824e-02f, 3.72840166e-02f, -2.72482447e-02f, 1.88508518e-02f, -1.09027244e-01f, -9.63441357e-02f, 4.50748540e-02f, 1.77266344e-01f, 6.05594888e-02f, 1.38755813e-01f,
  -7.14554787e-02f, -6.57824334e-03f, -2.64221318e-02f, -5.41005060e-02f, 6.13970980e-02f, -2.68778466e-02f, 8.31981003e-02f, 8.96110432e-04f, -5.98531887e-02f, 3.27739120e-02f,
  -6.27612472e-02f, -7.85449073e-02f, -1.02803312e-01f, 5.77227063e-02f, -4.86057950e-03f, 1.13022469e-01f, 3.43625546e-02f, 2.68786214e-02f, 3.83950509e-02f, 2.78763492e-02f,
  -5.10135144e-02f, -6.71449602e-02f, 1.47693297e-02f, 6.04197942e-02f, -8.49099308e-02f, 1.72146149e-02f, 3.07640135e-02f, 1.30621478e-01f, 2.91155279e-02f, -2.82350630e-02f,
  -9.92001742e-02f, -1.49509847e-01f, -1.09998830e-01f, -3.57228443e-02f, -6.40762448e-02f, 3.75747085e-02f, -1.66616648e-01f, -5.29408790e-02f, -1.02393543e-02f, -3.86989005e-02f,
  -5.62721938e-02f, -6.15143962e-02f, 2.15579450e-01f, 7.20377564e-02f, -4.14009951e-02f, 7.93696046e-02f, -1.23049863e-01f, 7.88708553e-02f, -1.14898039e-02f, 2.28989217e-02f,
  2.40928754e-02f, -1.46724701e-01f, 2.32757553e-02f, 1.56116653e-02f, -2.65659280e-02f, 2.38487404e-02f, 4.81099673e-02f, -1.24003865e-01f, -1.92628466e-02f, -6.15206510e-02f,
  2.82711834e-01f, -2.29565069e-01f, 5.25039658e-02f, 1.65582020e-02f, 1.51436359e-01f, -9.38293932e-04f, 2.22318321e-01f, -1.38107643e-01f, -7.17281699e-02f, -3.09598118e-01f,
  -1.47491589e-01f, -2.17547454e-02f, 1.84054255e-01f, -2.19165698e-01f, 4.31938708e-01f, 1.22824341e-01f, -4.07466963e-02f, -3.20160724e-02f, 2.64335908e-02f, -2.03095108e-01f,
  -5.36283739e-02f, -1.96404994e-01f, 2.70574670e-02f, -2.87558407e-01f, -1.08515695e-01f, -7.41533563e-02f, -3.53477299e-02f, 1.63835227e-01f, -1.91240504e-01f, -2.15404965e-02f,
  8.47611502e-02f, 1.16038419e-01f, 3.38717438e-02f, -3.32093388e-02f, -3.44328880e-02f, -3.48558910e-02f, 1.09030744e-02f, 8.16023946e-02f, 9.67283100e-02f, 2.75289491e-02f,
  2.34377664e-02f, 1.15566747e-02f, -4.27962206e-02f, 6.75929040e-02f, 3.54313850e-03f, -8.92437920e-02f, 1.67776027e-03f, -8.52736682e-02f, -7.50480071e-02f, -1.22785456e-02f,
  8.00749287e-02f, -1.15637900e-02f, 7.25496411e-02f, -8.46195444e-02f, 8.51165876e-02f, -4.86754514e-02f, 1.11424714e-01f, 9.87851247e-02f, -2.62071248e-02f, -2.26220489e-02f,
  7.61052966e-02f, 6.20695204e-02f, 8.09364319e-02f, -4.45211306e-02f, -1.65487267e-02f, -1.18011713e-01f, -3.36342934e-03f, 5.04293367e-02f, -1.40771121e-02f, -9.55337733e-02f,
  -3.18922177e-02f, 1.03458911e-01f, 1.31630868e-01f, -3.91903780e-02f, -2.74384171e-02f, -2.36311299e-03f, -1.58305280e-02f, -6.41761795e-02f, 2.28551726e-04f, -3.17888893e-02f,
  6.95749223e-02f, 3.46923061e-02f, -1.19505726e-01f, -9.27194059e-02f, -1.13820255e-01f, 9.01846811e-02f, -3.50433104e-02f, -7.01990351e-02f, 6.18865639e-02f, 3.48553881e-02f,
  -7.08440766e-02f, -6.20367900e-02f, 3.28720994e-02f, -4.42211553e-02f, 3.02601811e-02f, -1.22976527e-01f, 6.39426261e-02f, 4.78043072e-02f, -1.57454014e-01f, -7.10214525e-02f,
  -5.42923808e-02f, -1.14252344e-01f, -3.47115658e-02f, -8.33852682e-03f, -3.69767882e-02f, -1.03960253e-01f, 3.48329241e-03f, -2.79246382e-02f, 2.08414774e-02f, -1.30446618e-02f,
  2.81288363e-02f, 8.54617953e-02f, 8.72844532e-02f, -5.81651330e-02f, 5.02003692e-02f, 6.26044571e-02f, 1.04635045e-01f, 3.90098989e-02f, 2.72055119e-02f, -4.33559753e-02f,
  2.69111753e-01f, -4.22765821e-01f, -4.66027036e-02f, 1.42114341e-01f, 2.56052911e-01f, 2.90975291e-02f, 1.52464598e-01f, 6.60492405e-02f, 1.59282219e-02f, -3.03426176e-01f,
  2.47530788e-02f, -1.58999756e-01f, -1.70379743e-01f, -1.12053948e-02f, 2.74525911e-01f, -2.15883374e-01f, 3.79237421e-02f, -1.00947782e-01f, 4.62078229e-02f, -2.90265270e-02f,
  1.22323066e-01f, 1.31440058e-01f, 5.56294434e-02f, -3.05720009e-02f, -5.66581599e-02f, -8.52371603e-02f, -6.71224594e-02f, -7.73856267e-02f, -7.23538622e-02f, 2.18819641e-02f,
  8.00483003e-02f, -2.48197187e-03f, 9.67566017e-03f, 1.37908645e-02f, -1.09327726e-01f, 3.15433256e-02f, 5.97977117e-02f, 9.78623927e-02f, 8.53779465e-02f, -1.14050284e-02f,
  -1.20804608e-01f, 4.27017584e-02f, -4.24372032e-02f, 5.65155596e-02f, -1.56107070e-02f, 5.75586334e-02f, -7.67485611e-03f, 1.07796855e-01f, 2.08443347e-02f, -3.55915800e-02f,
  -4.25692834e-02f, -1.15933307e-01f, 1.98589675e-02f, -7.47348219e-02f, -5.21552302e-02f, 5.33417985e-02f, -1.93647947e-02f, -8.56408700e-02f, -7.32786059e-02f, 2.72994079e-02f,
  -8.59510973e-02f, -8.48290548e-02f, -3.69233936e-02f, 9.84711498e-02f, 1.00719938e-02f, 9.19787586e-02f, 1.61517411e-02f, -3.48684080e-02f, -6.11616708e-02f, -3.02384607e-02f,
  2.18170751e-02f, 2.49805022e-02f, 7.10221231e-02f, 9.75646153e-02f, 1.25654798e-03f, 2.69326698e-02f, 7.02545345e-02f, 3.06427609e-02f, 3.99789773e-02f, 4.19401750e-02f,
  1.64301395e-02f, 4.84088659e-02f, -6.52258843e-02f, 6.69640452e-02f, -2.41865078e-03f, -2.28052009e-02f, -8.37184209e-03f, -9.16059539e-02f, -2.72216089e-02f, -2.57674977e-02f,
  -1.24481857e-01f, -2.83485681e-01f, 3.33435237e-02f, -4.85327542e-02f, -5.41865006e-02f, -7.73433745e-02f, -2.47963406e-02f, -4.71238326e-03f, -1.35642171e-01f, 9.73176658e-02f,
  2.57404782e-02f, 1.52569758e-02f, -6.25067949e-02f, 7.05980361e-02f, 3.89899164e-02f, -4.18059491e-02f, -8.20393190e-02f, -7.69186914e-02f, 7.52503844e-03f, -1.32603541e-01f,
  -2.02873312e-02f, -1.14935778e-01f, 6.23984300e-02f, -3.24527808e-02f, -3.28178927e-02f, -8.70137662e-03f, 1.15702767e-02f, -5.60626350e-02f, -4.10004482e-02f, 9.22451243e-02f,
  3.47810358e-01f, 2.57418305e-01f, 1.89797074e-01f, 3.00963432e-01f, -9.98838246e-02f, -1.22150183e-01f, -5.63842319e-02f, 9.13215280e-02f, 1.37971655e-01f, 1.51003001e-03f,
  -2.29758054e-01f, 2.67500967e-01f, -1.14039317e-01f, 8.93913507e-02f, -1.02798656e-01f, -2.79252622e-02f, 5.50995693e-02f, 1.42931089e-01f, -7.08794072e-02f, 6.91770762e-02f,
  1.27138942e-01f, -1.44349530e-01f, -8.01512003e-02f, -1.08758964e-01f, 6.70204759e-02f, 1.28526360e-01f, 1.50613335e-03f, -1.50234951e-02f, 3.27262543e-02f, -2.48975325e-02f,
  -7.17881396e-02f, -2.71412544e-02f, -4.22076173e-02f, 8.83889794e-02f, 1.53277978e-01f, -8.17492977e-03f, -1.13510296e-01f, -5.04559055e-02f, -2.20187511e-02f, 4.05489979e-03f,
  8.26333240e-02f, -1.20082777e-02f, -1.85789037e-02f, 1.37531400e-01f, -2.26734877e-02f, 6.04272261e-02f, 7.21465051e-02f, 1.24423295e-01f, 5.67078926e-02f, 5.95152415e-02f,
  1.50637627e-01f, 1.37991637e-01f, 1.37354687e-01f, 9.37567502e-02f, 3.03362999e-02f, -4.76959683e-02f, 2.53884681e-02f, 2.89331730e-02f, 5.94672523e-02f, -2.77827997e-02f,
  1.42209977e-01f, -6.45708889e-02f, -1.45266816e-01f, -4.14336175e-02f, 1.52749382e-03f, -4.68951687e-02f, 1.20850271e-02f, 1.25476243e-02f, 1.41508179e-02f, 2.41061719e-03f,
  -1.01997994e-01f, 2.92496160e-02f, -1.35757271e-02f, 9.77922454e-02f, 5.12993075e-02f, 5.63781522e-02f, 3.54011916e-02f, -3.72651145e-02f, 1.08331390e-01f, 5.31296656e-02f,
  2.88005862e-02f, -4.99363281e-02f, -1.15070352e-02f, 3.86458747e-02f, -7.93076679e-02f, 6.26544803e-02f, 8.24356601e-02f, 1.99149475e-02f, -1.58849657e-01f, -7.73354024e-02f,
  4.13215570e-02f, 9.50699896e-02f, 3.37657630e-02f, -2.15969458e-02f, -3.52518335e-02f, -3.85714769e-02f, -3.88985587e-04f, 1.09246053e-01f, -1.56051386e-02f, 6.63385913e-02f,
  -1.90192070e-02f, -4.47388925e-02f, -5.80450855e-02f, -3.18595618e-02f, 2.18464267e-02f, -5.13202026e-02f, 5.65032214e-02f, 5.30111194e-02f, -4.16295119e-02f, 1.01473294e-01f,
  -5.93603496e-03f, -1.35266911e-02f, 6.59198761e-02f, 2.12616231e-02f, 5.10506239e-03f, 3.09566073e-02f, 2.75613274e-02f, 7.09229484e-02f, 3.97967212e-02f, -4.34997305e-02f,
  2.80341923e-01f, -7.17916861e-02f, 1.98938280e-01f, 3.69194746e-01f, 3.15634757e-01f, 2.15435565e-01f, 2.10300773e-01f, 2.58836657e-01f, 6.33167624e-01f, -1.31521478e-01f,
  -7.30068982e-02f, -4.92515333e-04f, -3.99530232e-02f, -4.01219260e-03f, -2.66238283e-02f, -6.02070726e-02f, 1.61525577e-01f, 2.15804446e-02f, 3.11487436e-01f, 2.85326988e-02f,
  2.14716330e-01f, 5.07333362e-03f, -2.47045711e-01f, -2.29205459e-01f, -5.38287684e-02f, -6.01979010e-02f, -3.80168557e-01f, -9.58850384e-02f, -2.85240114e-01f, 1.22447759e-02f,
  8.06966797e-02f, 9.29658711e-02f, -8.10291246e-02f, -1.15971483e-01f, 7.06017017e-02f, -8.00896585e-02f, -3.17317247e-02f, -1.49567261e-01f, 1.27736315e-01f, -1.79923009e-02f,
  1.12672552e-01f, -2.32862141e-02f, 9.44522321e-02f, 8.27329755e-02f, 3.29850055e-02f, -2.57628765e-02f, 6.91302046e-02f, -3.98706598e-03f, -8.65224227e-02f, -1.85547937e-02f,
  -6.60471544e-02f, -1.42369987e-02f, 5.71101680e-02f, -8.66352301e-03f, -4.87802066e-02f, 6.38896250e-04f, 4.12764028e-02f, 3.02071287e-03f, -2.79860012e-02f, 8.95068329e-03f,
  -4.17608246e-02f, 1.50245354e-02f, -3.72597687e-02f, -5.14707342e-02f, 5.38140573e-02f, 7.10237846e-02f, -4.74491306e-02f, 7.51508549e-02f, 7.54197538e-02f, -7.38748685e-02f,
  -6.00362346e-02f, 3.26829813e-02f, 8.41339603e-02f, 2.78315023e-02f, 1.82443872e-01f, -2.29228996e-02f, -4.87126596e-02f, 4.62608151e-02f, 5.20252325e-02f, -6.05366658e-03f,
  7.85795748e-02f, 2.59308200e-02f, -5.37787676e-02f, 3.52097973e-02f, -2.79318299e-02f, 5.07731177e-02f, 6.20059185e-02f, -1.68142151e-02f, -2.20277961e-02f, 3.62432119e-03f,
  3.19093093e-02f, 5.37493899e-02f, -8.44550133e-02f, -1.33195333e-02f, 8.20313245e-02f, -1.19610094e-02f, 8.43032375e-02f, 8.11286420e-02f, 3.57098468e-02f, -4.71957251e-02f,
  -7.07727717e-03f, 5.22129275e-02f, -7.53487796e-02f, 7.82980304e-03f, -9.38203335e-02f, -6.58308109e-03f, 6.93119764e-02f, -2.19799951e-02f, -8.30255151e-02f, -5.38403057e-02f,
  -7.66504407e-02f, 3.23318541e-02f, -1.10507747e-02f, -7.54089504e-02f, 5.51245101e-02f, -4.84733395e-02f, 1.12363219e-01f, -8.66586044e-02f, 5.78435250e-02f, -1.89952403e-02f,
  -6.53804362e-01f, 2.11757258e-01f, 1.43491775e-01f, -4.09606695e-01f, 1.55488178e-01f, 2.45400723e-02f, -1.41908735e-01f, 2.27603793e-01f, -1.53097153e-01f, -3.16342786e-02f,
  4.32330295e-02f, -2.19537809e-01f, 7.76518732e-02f, -1.26106992e-01f, -1.38046175e-01f, -4.35815677e-02f, -1.10245161e-01f, -1.29224047e-01f, 9.91342496e-03f, -1.14346314e-02f,
  -6.51023909e-02f, -1.61183909e-01f, -8.14737529e-02f, 2.13889197e-01f, -1.16607379e-02f, -1.10664688e-01f, -1.83604553e-01f, 4.13128734e-02f, 4.75034788e-02f, 3.89899090e-02f,
  -2.58924633e-01f, -2.01276377e-01f, -8.61407146e-02f, -2.47260053e-02f, -5.94029538e-02f, -1.70212854e-02f, -3.43598761e-02f, -2.17990428e-02f, -2.24969350e-02f, 5.61677199e-03f,
  -1.12689221e-02f, 6.75966963e-02f, -9.13674310e-02f, 2.15687733e-02f, 2.43489146e-02f, 5.76966181e-02f, 5.72076552e-02f, 7.16867670e-02f, -1.13009997e-02f, 6.68598264e-02f,
  5.68593107e-02f, -7.31494650e-02f, 4.84340778e-03f, -6.17796257e-02f, 1.32726520e-01f, 2.09654327e-02f, -3.98038281e-03f, -4.11885865e-02f, 3.61860171e-02f, 8.44620392e-02f,
  7.87542537e-02f, 2.99539119e-02f, 4.45765741e-02f, -9.34795756e-03f, -1.86620671e-02f, 1.52185246e-01f, -3.57707813e-02f, -2.48190761e-02f, 5.84807955e-02f, -4.91511039e-02f,
  -2.94551887e-02f, 4.31353562e-02f, -2.17399076e-02f, -7.47495964e-02f, 7.63046592e-02f, 1.81467123e-02f, -7.96997100e-02f, -9.66845974e-02f, 6.54511452e-02f, -3.06294393e-02f,
  -6.81769773e-02f, -1.01685785e-02f, -4.67386824e-04f, -4.91620228e-02f, 9.19516310e-02f, -9.51433405e-02f, -2.98525654e-02f, -4.66869548e-02f, -7.15047941e-02f, -8.66422877e-02f,
  -3.96453381e-01f, -3.33523840e-01f, -1.36521503e-01f, -1.64510552e-02f, -5.69196232e-02f, -6.97128475e-02f, -6.82657436e-02f, -7.14221448e-02f, 4.93344516e-02f, 7.22869579e-03f,
  -2.74870137e-04f, 5.25131710e-02f, -8.13839510e-02f, -6.74967915e-02f, 6.15493469e-02f, -5.97126633e-02f, -4.27553542e-02f, -1.53260306e-01f, -1.59238160e-01f, -2.55557876e-02f,
  5.07867709e-02f, -2.09761541e-02f, -2.32278705e-02f, -4.89669293e-02f, -2.49566063e-02f, 4.51618247e-02f, -9.34027787e-03f, -4.71722754e-03f, 3.72672342e-02f, -3.72480564e-02f,
  9.92988646e-02f, -6.57166839e-02f, -2.90117741e-01f, 5.38579524e-02f, -1.68567687e-01f, 5.56577072e-02f, 1.68284364e-02f, -7.81385601e-02f, -2.64561445e-01f, 1.79548129e-01f,
  1.91841945e-01f, -1.71485513e-01f, 2.70976484e-01f, 3.12529057e-01f, -4.05391604e-02f, 1.74574703e-01f, 1.96227342e-01f, 1.28703982e-01f, -1.51878729e-01f, 6.24251328e-02f,
  -7.75963888e-02f, 3.38273823e-01f, 9.58642289e-02f, 3.85329947e-02f, 1.89240336e-01f, -1.67090297e-01f, 9.09283385e-02f, -1.41701892e-01f, -2.25236383e-03f, -1.42350355e-02f,
  4.90406044e-02f, 7.23200887e-02f, 2.20592804e-02f, -3.92283089e-02f, -2.62519419e-02f, 1.34638503e-01f, 2.70190220e-02f, -5.05128950e-02f, -1.30180776e-01f, -2.91521456e-02f,
  3.34885567e-02f, -4.80992198e-02f, -5.53735793e-02f, -3.01731620e-02f, -4.90751415e-02f, -1.01475939e-01f, -9.21622142e-02f, -1.32296473e-01f, -8.64357874e-02f, 9.72345378e-03f,
  1.58639383e-02f, -9.48809981e-02f, -3.37924771e-02f, -5.79976756e-03f, -1.22720569e-01f, 7.01585487e-02f, -5.76140806e-02f, -2.63502542e-02f, 4.40527610e-02f, -1.85960699e-02f,
  1.60224289e-01f, -6.08140007e-02f, 1.25840485e-01f, 3.54987057e-03f, -5.32939844e-02f, 8.76189098e-02f, -7.93873519e-03f, 7.40046129e-02f, 3.66572570e-03f, 9.94427130e-02f,
  3.07961535e-02f, -3.55191603e-02f, 1.38214137e-02f, 1.36503145e-01f, 8.46042112e-03f, -4.29164693e-02f, -6.52714670e-02f, 4.22935821e-02f, -1.10767923e-01f, -5.94779253e-02f,
  4.01651859e-02f, -3.59013975e-02f, 1.40424743e-02f, 7.01779574e-02f, 8.67902935e-02f, -2.88494979e-03f, 6.02110960e-02f, -8.64270143e-03f, -1.43880293e-01f, -3.66538204e-02f,
  -5.03416499e-03f, 1.54362887e-01f, -4.10574526e-02f, -5.42613156e-02f, -2.84447446e-02f, 1.34206325e-01f, 1.14700116e-01f, -1.10774182e-01f, 3.38367596e-02f, -1.15158692e-01f,
  9.49680805e-02f, -2.16287281e-02f, 4.46671769e-02f, -9.41949636e-02f, -3.73049043e-02f, -6.69838190e-02f, 1.22999743e-01f, -1.88797519e-01f, -3.28667201e-02f, -1.88286155e-02f,
  6.78210482e-02f, 2.23494712e-02f, -3.51575837e-02f, -1.04252994e-01f, 2.79996712e-02f, -4.97935293e-03f, -7.04557225e-02f, -6.26603439e-02f, 1.15682874e-02f, -6.22228161e-02f,
  -3.93111631e-02f, -1.58380285e-01f, 5.76212406e-02f, 1.83853164e-01f, 6.08960129e-02f, -2.06578851e-01f, -2.00157553e-01f, 1.27963945e-01f, -1.75592937e-02f, -1.79869577e-01f,
  -1.00154243e-01f, -1.81230307e-01f, -2.06612885e-01f, -8.87975097e-02f, 2.78596417e-03f, -8.89335126e-02f, 5.31377755e-02f, 3.32758902e-03f, 7.04636378e-03f, -2.01531965e-03f,
  9.31924209e-02f, 7.94883221e-02f, 2.45970845e-01f, 2.92989492e-01f, 1.29792497e-01f, 2.64114022e-01f, 2.38737419e-01f, -5.13346307e-02f, 2.02577978e-01f, 1.19676806e-01f,
  -8.87709633e-02f, -9.63141248e-02f, -3.91761512e-02f, 9.55258012e-02f, 5.41756069e-03f, -1.59146655e-02f, -1.10982349e-02f, 6.56886548e-02f, 1.54534010e-02f, -6.62880316e-02f,
  -1.38041615e-01f, -1.53614709e-03f, 9.25273728e-03f, 1.22772016e-01f, 5.69787025e-02f, -3.22508179e-02f, 2.20006015e-02f, 7.53409714e-02f, -6.92102909e-02f, -3.93985473e-02f,
  -4.47639115e-02f, -2.76863519e-02f, -2.49084942e-02f, 5.94990700e-02f, -4.29771282e-02f, -1.24857396e-01f, 9.76284686e-03f, -1.61538552e-02f, -1.75678674e-02f, -3.40318307e-02f,
  -6.34070784e-02f, -1.87699292e-02f, 6.23453856e-02f, 1.05604053e-01f, 5.43661751e-02f, -6.83827847e-02f, -6.46655709e-02f, 1.44473137e-02f, 1.52667817e-02f, -6.18745498e-02f,
  8.20537880e-02f, -4.67310958e-02f, 1.03977047e-01f, -4.95291827e-03f, 1.05811004e-02f, 2.28373017e-02f, 5.26205152e-02f, 6.91857040e-02f, 1.17609359e-01f, 3.48519944e-02f,
  8.32430795e-02f, 5.85601516e-02f, -1.95121411e-02f, -4.88078222e-02f, -1.29571944e-01f, 2.11379416e-02f, 9.07539800e-02f, -5.15457056e-02f, -3.93564105e-02f, 1.03775546e-01f,
  -5.70646301e-02f, 2.48745922e-03f, -4.04052250e-02f, -4.40241992e-02f, -9.83478427e-02f, -6.77433535e-02f, -3.55158448e-02f, 5.99184958e-03f, -1.69684906e-02f, -4.45871875e-02f,
  2.90795732e-02f, 4.81498204e-02f, -6.29382730e-02f, 1.21644303e-01f, 1.60446525e-01f, -4.65407558e-02f, 7.79919140e-03f, -5.22330869e-03f, 9.19230133e-02f, 7.19034299e-02f,
  3.79455797e-02f, -1.63087860e-01f, -1.09869987e-01f, 4.78647985e-02f, -5.79669811e-02f, -5.98373264e-02f, -2.68975459e-02f, 5.21648899e-02f, -3.61099141e-03f, -2.52116397e-02f,
  4.26434278e-01f, 1.18717395e-01f, 1.65586516e-01f, 3.27537745e-01f, 1.11551017e-01f, -2.63507485e-01f, -5.28623611e-02f, 1.77193478e-01f, 2.22637996e-01f, -4.83088866e-02f,
  8.68226960e-03f, 1.95018962e-01f, -1.45849198e-01f, 2.47563630e-01f, 1.06379792e-01f, -1.07204340e-01f, 1.56116888e-01f, -7.38331527e-02f, 1.92204982e-01f, 2.06103668e-01f,
  2.21502811e-01f, 3.54441032e-02f, 1.93282396e-01f, 5.35118841e-02f, 1.51145577e-01f, -7.94922095e-03f, -8.10396671e-03f, -1.63615450e-01f, -4.79853479e-03f, -1.23304330e-01f,
  3.22311930e-02f, 1.28972858e-01f, 2.96694785e-02f, -6.07927330e-02f, 6.45943657e-02f, 9.09438655e-02f, 5.70483021e-02f, -1.61725104e-01f, 4.82227392e-02f, -2.09360383e-02f,
  -3.14526968e-02f, 7.54857808e-03f, -3.81977335e-02f, -1.19027093e-01f, -6.25138953e-02f, 1.91193428e-02f, 4.39796597e-02f, 3.59614119e-02f, 1.33306563e-01f, 4.89361621e-02f,
  1.93979651e-01f, 2.93556079e-02f, 5.45477830e-02f, -1.10958748e-01f, 1.03117205e-01f, 5.48715740e-02f, -1.07470686e-02f, -9.19667631e-02f, -1.14055462e-01f, 1.04521781e-01f,
  -4.62921821e-02f, -2.45389454e-02f, -5.79179339e-02f, 1.66459028e-02f, -1.47833815e-02f, 2.38566902e-02f, 4.39672768e-02f, -9.38103050e-02f, -1.52826905e-01f, 8.69821981e-02f,
  -3.00714169e-02f, -4.53341044e-02f, -1.02724403e-01f, -1.07089378e-01f, -1.37695279e-02f, 1.61185320e-02f, 2.07399148e-02f, -5.35336211e-02f, 7.48630092e-02f, 6.22025989e-02f,
  -7.77601153e-02f, -6.35143742e-03f, 3.65816392e-02f, -4.56356667e-02f, 6.87536001e-02f, -1.11137368e-01f, -8.27190652e-02f, -1.73946982e-03f, 1.11273780e-01f, -5.97385578e-02f,
  -8.59499499e-02f, 2.40070559e-02f, 2.22046692e-02f, 4.85515874e-03f, 1.50043163e-02f, 9.10789445e-02f, 9.95244309e-02f, 2.94474829e-02f, 7.10584745e-02f, 2.22289506e-02f,
  -9.12010148e-02f, 2.71057338e-02f, 4.07219259e-03f, -1.77505866e-01f, -3.30057777e-02f, 5.50763384e-02f, -1.27783671e-01f, 1.45237193e-01f, 4.27489057e-02f, -3.12479865e-02f,
  7.30461534e-03f, -5.45001812e-02f, -1.27045047e-02f, 1.66423127e-01f, -4.26645912e-02f, -8.54018405e-02f, -4.05288152e-02f, -5.21092005e-02f, 4.97452952e-02f, 1.75029971e-02f,
  -2.20170721e-01f, 2.12618589e-01f, 1.21516407e-01f, 1.07096367e-01f, 2.08711758e-01f, -2.63360530e-01f, -1.20163888e-01f, 1.64707720e-01f, -1.52728587e-01f, 8.79759621e-03f,
  2.05439497e-02f, 1.73350617e-01f, -3.05946954e-02f, 3.37558314e-02f, -1.34293631e-01f, -1.13285884e-01f, -4.33510877e-02f, -1.09412961e-01f, -3.87761332e-02f, 1.50429070e-01f,
  -4.74945828e-02f, 2.73003429e-02f, 1.32814780e-01f, 2.63272017e-01f, -2.43001468e-02f, 1.77087113e-02f, 7.83632323e-02f, 7.01677576e-02f, 1.14948891e-01f, 5.94526529e-02f,
  -4.18281257e-02f, -6.86267093e-02f, -5.24427854e-02f, 4.94449772e-02f, -2.81343795e-02f, -2.01477017e-02f, -1.50232911e-01f, 1.42503986e-02f, -9.73439664e-02f, -9.11573768e-02f,
  -7.18820048e-03f, -4.84787971e-02f, -2.34034657e-02f, 5.67206964e-02f, 1.78906054e-03f, -5.04621416e-02f, 5.36194257e-03f, 3.80175970e-02f, 3.09368987e-02f, -5.80499247e-02f,
  6.36122152e-02f, 1.19419293e-02f, 1.16431072e-01f, 3.93108055e-02f, -3.86909433e-02f, -1.82919973e-03f, -3.34025780e-03f, -2.06040870e-03f, -1.60839558e-01f, 2.35767681e-02f,
  -5.11816852e-02f, -1.55129638e-02f, 8.54883268e-02f, -4.11049053e-02f, 1.23626068e-02f, -3.22932340e-02f, -7.56203979e-02f, -3.78943831e-02f, -6.75328150e-02f, -5.24064824e-02f,
  -6.86855463e-04f, 8.52560550e-02f, 9.19085667e-02f, -7.94131458e-02f, -2.98194997e-02f, 9.41615999e-02f, 3.67419608e-02f, -8.92024934e-02f, 2.54184492e-02f, -1.35642245e-01f,
  1.19088097e-02f, 3.02566737e-02f, -5.00024855e-03f, -5.65849096e-02f, 3.56585183e-03f, 1.79893374e-02f, 7.80730024e-02f, 2.69722044e-02f, 6.75588921e-02f, -1.01641931e-01f,
  -4.59390096e-02f, -9.04373638e-03f, -6.77140206e-02f, -2.28476673e-02f, -1.68795250e-02f, -1.42874094e-02f, 4.16559465e-02f, 5.73210232e-02f, 9.35393944e-03f, -1.15310572e-01f,
  9.48296860e-02f, -1.02658933e-02f, -8.11306983e-02f, -5.86900972e-02f, 7.62602389e-02f, -2.23639533e-02f, 7.21520633e-02f, 4.85808365e-02f, 1.61683291e-01f, -5.83213046e-02f,
  8.17214847e-02f, -2.53275651e-02f, 4.19675224e-02f, -8.64671776e-04f, -6.45167902e-02f, -6.16205260e-02f, 3.76559533e-02f, 9.43751857e-02f, 2.22175103e-02f, -1.12543412e-01f,
  -4.30602670e-01f, 1.67431489e-01f, -3.05062592e-01f, -2.51927793e-01f, 2.52231389e-01f, -2.07001165e-01f, -1.64644584e-01f, 7.69148096e-02f, -1.02012098e-01f, 1.67769089e-01f,
  7.48454556e-02f, -3.04738656e-02f, 8.09935778e-02f, -1.19361833e-01f, -3.93707335e-01f, -2.53188219e-02f, -3.45022023e-01f, -2.75065184e-01f, 7.96583132e-04f, -3.73633765e-02f,
  -2.20793307e-01f, -5.03048189e-02f, -2.03474104e-01f, 1.72863290e-01f, -1.28659055e-01f, -1.18534442e-03f, 1.17012054e-01f, 8.24921206e-02f, -9.56660137e-02f, -6.90104887e-02f,
  -7.96727389e-02f, -1.22224716e-02f, 9.72294956e-02f, -4.97681685e-02f, -1.40591338e-01f, -2.01638918e-02f, -8.62096846e-02f, 5.21652773e-02f, 2.51031145e-02f, -9.54404995e-02f,
  -3.71969268e-02f, -9.98921990e-02f, -8.44780281e-02f, 2.32791994e-02f, 9.08155739e-03f, -5.13126981e-03f, -1.63474828e-02f, 2.75478363e-02f, -9.57101658e-02f, -1.66505948e-01f,
  -9.42833349e-02f, -5.17687537e-02f, -9.49193984e-02f, -5.31335175e-02f, 6.06362820e-02f, -7.57927671e-02f, -6.48356900e-02f, 3.41097638e-02f, -1.22249678e-01f, 4.82768454e-02f,
  -6.19416311e-02f, -1.96679756e-01f, -9.07995626e-02f, 1.67326145e-02f, 8.83444119e-03f, 1.76039711e-02f, 1.63932089e-02f, 8.57362151e-03f, 4.22013327e-02f, -1.24681741e-01f,
  -1.88340321e-02f, 5.40175941e-03f, 6.50705323e-02f, -8.49122480e-02f, -1.53253943e-01f, -6.11785799e-03f, -7.22424835e-02f, 1.05210535e-01f, 9.43684392e-03f, 2.49789096e-02f,
  2.19146032e-02f, -4.73860139e-03f, 8.94994289e-02f, 1.79496650e-02f, 4.24377574e-03f, 3.31804343e-02f, -2.49045547e-02f, -1.59487911e-02f, 8.58194381e-02f, -7.18642324e-02f,
  -6.33832514e-02f, 5.22498414e-02f, 3.60084996e-02f, 9.04648826e-02f, 5.13773821e-02f, 5.20469295e-03f, -7.23740235e-02f, 6.80421814e-02f, 3.15356106e-02f, 7.25317523e-02f,
  -9.67702419e-02f, -7.27650523e-02f, -6.83504939e-02f, 3.42761502e-02f, 1.26426583e-02f, -6.30824268e-02f, 4.04730886e-02f, 2.13250853e-02f, 1.71014760e-02f, -1.69841703e-02f,
  -1.37663960e-01f, 4.96566221e-02f, -6.20783716e-02f, 1.05760999e-01f, -1.42337661e-02f, 4.91118319e-02f, 3.09862401e-02f, -2.32955199e-02f, -3.35107818e-02f, -2.66449694e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.52998507e-01f, 1.12057559e-01f, 1.62282467e-01f, 1.10287793e-01f, 1.11263543e-01f, 8.82546678e-02f, 8.03099573e-02f, 5.58508001e-02f, 1.19990237e-01f, 2.58953720e-01f,
  3.16697583e-02f, -4.92005236e-02f, 1.35830790e-01f, 1.20417744e-01f, 1.14400297e-01f, 3.57978672e-01f, 1.78711072e-01f, 4.60779406e-02f, 3.31904329e-02f, 1.77118480e-01f,
  1.45637080e-01f, 1.25149429e-01f, 1.55807287e-02f, 1.36181593e-01f, 1.14778690e-01f, 1.59776434e-02f, 8.52258354e-02f, 1.01394415e-01f, 1.45824581e-01f, 1.06703654e-01f,
  1.17911533e-01f, 9.14623365e-02f, 1.43283322e-01f, 9.85792875e-02f, 2.61737078e-01f, 1.45398855e-01f, 2.24200767e-02f, 2.03664318e-01f, 2.75370851e-02f, 1.89501092e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  4.14261222e-02f, 7.27076754e-02f, 3.55134793e-02f, 7.78298602e-02f, 6.58658668e-02f, 4.32240628e-02f, -8.52478668e-02f, -1.17431864e-01f, -1.18403576e-01f, -5.43809533e-02f,
  4.35276628e-02f, -5.94569109e-02f, -4.18088101e-02f, -1.18365558e-02f, 1.04545303e-01f, -1.42306715e-01f, -1.58409066e-02f, 2.19351366e-01f, 1.01481326e-01f, 5.68035878e-02f,
  7.38988146e-02f, 7.42766112e-02f, 5.72821125e-02f, 1.31002709e-01f, -1.14962362e-01f, 1.02005206e-01f, -8.68056417e-02f, -1.39579643e-02f, -1.62795640e-03f, 2.98139527e-02f,
  5.45491055e-02f, 1.49003848e-01f, 9.12888646e-02f, 7.41652325e-02f, 5.86027578e-02f, -1.47446275e-01f, -1.60056084e-01f, 1.80586427e-01f, -8.35210010e-02f, 2.44313069e-02f,
  6.63836747e-02f, 1.71151400e-01f, 2.50699352e-02f, 5.29092997e-02f, 5.67523167e-02f, 7.38835707e-02f, 2.07361616e-02f, 4.40412983e-02f, -1.04448851e-02f, -2.47647446e-02f,
  -5.62259667e-02f, -2.19758525e-01f, -2.42332473e-01f, -1.35015011e-01f, -3.14655244e-01f, -1.14862092e-01f, -1.36206567e-01f, -3.41484159e-01f, 7.95202106e-02f, -1.19171008e-01f,
  1.02187864e-01f, -5.99841913e-03f, 1.50448801e-02f, 2.94027776e-01f, 1.02643907e-01f, 2.97392849e-02f, 6.17946312e-02f, -5.54747358e-02f, 1.37978256e-01f, 1.63796323e-03f,
  4.01106477e-02f, -4.51439470e-02f, 3.90868597e-02f, -4.60797213e-02f, -6.51060939e-02f, 3.96252461e-02f, -1.16748184e-01f, -3.09721380e-02f, -9.85409543e-02f, 6.14826642e-02f,
  -7.54099106e-03f, 9.18943435e-03f, 1.68446392e-01f, -6.98112920e-02f, -5.12418970e-02f, -1.13477912e-02f, -7.34057054e-02f, -1.44994721e-01f, 1.97382960e-02f, -7.80420750e-02f,
  -1.82335470e-02f, -1.13865845e-02f, -8.71652067e-02f, 4.81109209e-02f, 1.90809712e-01f, 1.07782101e-02f, 1.55462753e-02f, -9.84544083e-02f, -1.02680311e-01f, 6.23983182e-02f,
  1.12530246e-01f, -2.70152856e-02f, 1.34177078e-02f, -5.53846620e-02f, 6.93568736e-02f, 1.74438700e-01f, -1.67265646e-02f, 8.03742334e-02f, -8.16374645e-02f, -2.18284637e-01f,
  8.46416876e-02f, -1.06113628e-01f, -4.51938063e-02f, 1.27877235e-01f, -1.46253929e-01f, 6.21255003e-02f, 1.19588077e-01f, 5.71912229e-02f, 1.21944278e-01f, 1.56094685e-01f,
  -3.44047435e-02f, 6.30403608e-02f, 1.38715450e-02f, 5.99845387e-02f, 3.21135558e-02f, 1.39767945e-01f, -6.01791441e-02f, -1.01284787e-01f, 2.00250223e-01f, 3.73502672e-02f,
  3.25419707e-03f, 1.43672135e-02f, 9.66996104e-02f, 1.14728063e-01f, 1.87627330e-01f, 6.96790889e-02f, 1.83481723e-01f, 3.80980819e-02f, 2.09235046e-02f, -9.37374383e-02f,
  -1.61762670e-01f, 6.50629625e-02f, -5.11307642e-02f, 2.25562260e-01f, -4.00668383e-02f, -4.95846830e-02f, 3.20976377e-02f, -1.60954017e-02f, -8.39195922e-02f, -1.12460203e-01f,
  -7.74561800e-03f, 6.21089600e-02f, 1.13640979e-01f, 6.40588850e-02f, -1.73620880e-02f, 8.35559443e-02f, -1.67071030e-01f, -1.28717735e-01f, -9.38698277e-02f, -1.38146549e-01f,
  -6.30669221e-02f, -2.35977769e-01f, 1.73922330e-02f, 2.58435439e-02f, 8.61615986e-02f, -3.32944398e-03f, 5.78447357e-02f, -5.49503192e-02f, 2.61422880e-02f, -5.21001630e-02f,
  -1.61743760e-01f, -4.75418456e-02f, -7.79609829e-02f, -1.55390412e-01f, -2.32212037e-01f, -1.72568947e-01f, 1.76884967e-03f, -8.01885650e-02f, -8.55823085e-02f, 1.05618939e-01f,
  9.32225659e-02f, 1.44025058e-01f, 1.00606449e-01f, 2.35828459e-02f, 4.24334733e-03f, 1.93055063e-01f, 2.95919869e-02f, -1.07852168e-01f, -5.41439205e-02f, 9.65288132e-02f,
  -1.36700021e-02f, -1.81925461e-01f, 1.62201479e-01f, 1.05566308e-01f, 3.87804173e-02f, -1.18618645e-02f, 1.65108830e-01f, 1.56192660e-01f, 1.54086694e-01f, 3.48497443e-02f,
  -8.87033157e-03f, 5.44363074e-02f, 2.76948698e-02f, 2.95379758e-02f, -1.47532402e-02f, -1.19086467e-01f, -6.42770901e-02f, 1.01297036e-01f, -5.45330532e-02f, -4.69148010e-02f,
  5.47688045e-02f, 4.08000499e-03f, -6.98685870e-02f, -2.48739317e-01f, -5.15086856e-03f, -4.92636561e-02f, 4.86726426e-02f, -7.07974285e-02f, -1.72167704e-01f, 1.45821691e-01f,
  -1.30504236e-01f, -2.08595935e-02f, 3.30051780e-02f, -7.27178007e-02f, -1.10593721e-01f, -4.04924378e-02f, 1.98164985e-01f, -6.75366372e-02f, 1.76371545e-01f, -1.15643486e-01f,
  -4.51805480e-02f, -1.13959489e-02f, 3.99797149e-02f, -2.11183783e-02f, 1.13541648e-01f, 1.19172066e-01f, -1.80197924e-01f, -3.85484248e-02f, 1.45105943e-01f, 1.78554431e-02f,
  6.18349724e-02f, -7.07594976e-02f, -1.75141990e-01f, 6.32575676e-02f, 4.89379317e-02f, -3.03920149e-03f, 1.35275081e-01f, 2.04847064e-02f, 1.39244467e-01f, 1.41540200e-01f,
  -2.15948354e-02f, -4.72418545e-03f, 3.18382606e-02f, 3.26410919e-01f, 3.46950255e-02f, -2.17839926e-01f, -7.41811916e-02f, -8.46561641e-02f, -6.76556118e-03f, 8.99257977e-03f,
  -7.98155367e-02f, -1.27737507e-01f, 1.28194736e-02f, -4.79932018e-02f, 2.56204363e-02f, 3.34089249e-02f, -1.10207893e-01f, -4.95727621e-02f, 6.36520758e-02f, 2.14913804e-02f,
  -7.96789378e-02f, -1.34205401e-01f, 1.67479798e-01f, 1.04684561e-01f, -7.17168599e-02f, 1.35650441e-01f, 3.92571576e-02f, 1.90631285e-01f, 1.29617274e-01f, 1.56312853e-01f,
  -1.91745996e-01f, 1.89055815e-01f, 1.73991874e-01f, 5.09799756e-02f, 6.72118797e-04f, -2.58429855e-01f, -2.42349699e-01f, 1.08530864e-01f, -1.18783973e-01f, -1.63604811e-01f,
  6.28688112e-02f, 7.44385645e-02f, -4.29418683e-02f, 2.75618494e-01f, -3.98869775e-02f, 5.17689914e-04f, -6.22107759e-02f, -8.06398466e-02f, -4.19954993e-02f, -1.20076418e-01f,
  5.09989113e-02f, 6.60589039e-02f, -6.82429969e-02f, -1.82234257e-01f, -1.11008212e-01f, -6.44872859e-02f, -2.07001865e-02f, -1.11666046e-01f, -2.03465223e-01f, 4.04527485e-02f,
  -1.03395104e-01f, -1.73035696e-01f, -4.30519246e-02f, -1.65844262e-01f, 1.08878538e-01f, -6.52961060e-02f, 5.99690415e-02f, -1.62185133e-01f, 3.83254029e-02f, 9.30451304e-02f,
  -1.02069989e-01f, -1.18149117e-01f, -3.52286324e-02f, 2.76539903e-02f, -7.38033578e-02f, -7.91012496e-02f, -1.07012533e-01f, 5.59769422e-02f, 2.12326460e-02f, 6.63998872e-02f,
  8.32052901e-02f, -8.83794650e-02f, 2.11867273e-01f, 4.39087972e-02f, 3.05538811e-02f, -9.49646011e-02f, -1.13167293e-01f, 1.62607998e-01f, -1.66097045e-01f, 1.18517250e-01f,
  1.47675216e-01f, 8.33838619e-03f, 9.81349275e-02f, 1.06520958e-01f, 6.10849224e-02f, -4.39236267e-03f, 1.33691102e-01f, -6.02639057e-02f, 7.24214241e-02f, -5.78185469e-02f,
  -1.02752224e-01f, -1.40875235e-01f, -1.02962710e-01f, 1.53142139e-01f, 1.25291392e-01f, -3.64681743e-02f, -1.30903348e-01f, -1.47502825e-01f, -7.39098266e-02f, 2.63059318e-01f,
  -7.08498359e-02f, -2.13719875e-01f, -3.21049690e-02f, -2.19128489e-01f, 1.40854001e-01f, 2.28139445e-01f, -1.22609571e-01f, 1.24688871e-01f, -2.32933704e-02f, -1.32209197e-01f,
  -1.12426812e-02f, -1.12227373e-01f, -1.57199010e-01f, -9.12328064e-02f, -1.26932114e-01f, -4.72865030e-02f, 1.50816873e-01f, -8.38536993e-02f, 1.29408658e-01f, 7.31446072e-02f,
  -1.58232823e-02f, 9.27278679e-03f, 1.21863127e-01f, 4.57341559e-02f, 3.03160083e-02f, -9.78523046e-02f, 2.66280379e-02f, -2.11926065e-02f, -1.11102842e-01f, -6.49936423e-02f,
  -1.10889070e-01f, -2.77693849e-02f, -2.04541665e-02f, 5.26365079e-02f, -3.79524403e-03f, -1.22650601e-02f, 1.93492919e-02f, -8.90157819e-02f, 1.47718564e-01f, 2.20570248e-02f,
  2.96531338e-02f, -2.53128022e-01f, -6.16694279e-02f, 1.77730024e-02f, -5.20122796e-02f, 2.16716863e-02f, 1.98042989e-01f, 2.85407066e-01f, -1.02898637e-02f, 2.40061507e-02f,
  9.93037447e-02f, 1.50858000e-01f, 2.49279514e-01f, -2.32089713e-01f, -2.52407908e-01f, 2.06440035e-02f, -1.18788682e-01f, 1.14705026e-01f, 2.05555055e-02f, 9.64568257e-02f,
  1.98844433e-01f, 1.43940076e-01f, -1.35568529e-01f, -9.56558734e-02f, -3.34104337e-02f, -9.25344997e-04f, 2.39019230e-01f, -2.09486574e-01f, -4.89073433e-02f, 1.91618159e-01f,
  8.61488953e-02f, 9.40111578e-02f, -3.42902131e-02f, 1.21132068e-01f, 7.42927287e-03f, -2.52821177e-01f, -1.32707311e-02f, -8.74743387e-02f, 5.85554959e-03f, -1.82930291e-01f,
  1.53423205e-01f, -9.34882276e-03f, -9.47909877e-02f, 2.61220217e-01f, -7.45784640e-02f, -3.27227414e-02f, -1.33686969e-02f, 2.18742304e-02f, -2.43338421e-02f, 7.09837601e-02f,
  8.32875967e-02f, -1.11650573e-02f, 2.61378270e-02f, 6.00799657e-02f, -4.88118567e-02f, 7.17302598e-03f, 4.03269827e-02f, 1.10968925e-01f, 1.28450572e-01f, 8.14398676e-02f,
  -2.99425609e-02f, -6.21635914e-02f, 7.51493797e-02f, 1.38133168e-01f, -2.07485303e-01f, -1.09602384e-01f, -3.09530599e-03f, 1.78523496e-01f, 5.42702749e-02f, 4.63242866e-02f,
  1.63641825e-01f, 2.49538288e-01f, -1.37558375e-02f, 5.57481982e-02f, -1.66834995e-01f, 8.60707834e-02f, 1.53695107e-01f, -1.36436224e-01f, -2.46272698e-01f, -2.43879095e-01f,
  -7.53026456e-03f, 9.79933590e-02f, 1.35813177e-01f, -2.25269288e-01f, -2.73699057e-03f, -6.21463265e-03f, -1.00688897e-01f, 9.71769691e-02f, 6.73918054e-02f, 4.09282036e-02f,
  -5.71833700e-02f, -1.32679865e-01f, -5.26554547e-02f, 1.99937016e-01f, -8.44318867e-02f, 1.84139416e-01f, 1.56451780e-02f, 6.02031909e-02f, -6.54439554e-02f, -1.99133009e-01f,
  6.66974038e-02f, -1.22823268e-01f, -1.07441507e-01f, -1.95335876e-02f, 6.38449565e-02f, 2.64257520e-01f, 3.80458087e-02f, -9.45451260e-02f, 3.53767499e-02f, 2.19424441e-01f,
  1.10914178e-01f, 4.92599122e-02f, 6.84600472e-02f, 1.69361964e-01f, 7.51118883e-02f, -3.54000553e-02f, 2.40118653e-01f, 8.99664611e-02f, 7.47351199e-02f, 9.14031640e-02f,
  -1.02488569e-03f, -4.35164087e-02f, -3.12305801e-02f, -5.98298237e-02f, 8.75484943e-02f, 4.52747308e-02f, -4.53833416e-02f, 7.77072757e-02f, 1.66897140e-02f, 1.32210940e-01f,
  -6.08247966e-02f, 1.89309698e-02f, 7.97715709e-02f, 1.65878441e-02f, -1.63778663e-01f, -1.66538823e-02f, -1.24189183e-01f, 4.17642146e-02f, 1.18214032e-02f, 2.83157378e-02f,
  -2.09471554e-01f, -1.07381612e-01f, 4.97283526e-02f, 3.97506310e-03f, -1.40444145e-01f, -2.45147362e-01f, 3.40506025e-02f, -1.16033871e-02f, -6.64735585e-02f, 7.09815398e-02f,
  1.79616317e-01f, -7.57194031e-03f, -1.16532706e-01f, -1.49672687e-01f, -1.27583250e-01f, -1.09571209e-02f, 1.00419842e-01f, 6.90028518e-02f, -9.01065841e-02f, -2.41493553e-01f,
  -7.60965496e-02f, -1.25787020e-01f, -1.22159878e-02f, 1.17280044e-01f, 6.63775951e-02f, 1.10470928e-01f, 3.55727114e-02f, -1.93017796e-02f, -1.14642523e-01f, -4.22659405e-02f,
  1.71691850e-01f, -2.29014218e-01f, -1.52159795e-01f, 2.81049982e-02f, -4.60771006e-03f, 1.53493866e-01f, 7.34053180e-02f, -3.68396118e-02f, -1.83676574e-02f, -4.57614474e-03f,
  1.24459140e-01f, 4.57333475e-02f, 5.36137782e-02f, -6.15111254e-02f, -9.89846662e-02f, -1.01797491e-01f, -1.00097433e-01f, -1.12541579e-03f, -2.29882479e-01f, -2.49449983e-02f,
  -1.17661357e-01f, 6.87966794e-02f, -5.04164211e-02f, -9.76862088e-02f, 1.28694877e-01f, -1.16828382e-01f, -2.33500954e-02f, -4.39095013e-02f, -1.63878530e-01f, -2.61758536e-01f,
  -1.22190248e-02f, 1.61002651e-02f, -1.33331597e-01f, -1.26673952e-01f, -6.16596565e-02f, 9.98738781e-02f, 2.00844541e-01f, -9.48496014e-02f, 1.77283332e-01f, -2.08684385e-01f,
  -9.72904637e-02f, -2.02413976e-01f, 3.17661352e-02f, 1.02369882e-01f, -6.23921417e-02f, -1.33995488e-01f, -5.40472679e-02f, 1.83345899e-01f, -9.61849764e-02f, 1.41230196e-01f,
  -5.07233888e-02f, -1.96586236e-01f, -7.33659491e-02f, -9.72242579e-02f, -2.67321779e-03f, 8.16315860e-02f, -1.72266811e-01f, 3.54989991e-02f, 2.08116591e-01f, -1.14397191e-01f,
  9.21006724e-02f, 1.97586015e-01f, -1.74452722e-01f, -1.19898297e-01f, -1.15013704e-01f, 1.10413902e-01f, -9.36892852e-02f, 3.17225493e-02f, -3.36681828e-02f, -6.42816350e-02f,
  -9.40883607e-02f, 1.19471170e-01f, 9.84738767e-02f, -1.44704385e-03f, 1.64422337e-02f, 4.85281879e-03f, -6.34394512e-02f, -1.32252932e-01f, -1.33404538e-01f, -3.65773402e-02f,
  3.30435112e-02f, 1.45799583e-02f, -5.17269038e-02f, 1.07819423e-01f, 1.26521736e-01f, -2.20350221e-01f, 2.53535137e-02f, 2.23963618e-01f, -5.67292888e-03f, 3.85657214e-02f,
  8.06248710e-02f, 2.40824167e-02f, -7.24917352e-02f, -4.69499901e-02f, 1.24386344e-02f, 1.21737428e-01f, -5.72568439e-02f, -1.52553380e-01f, 2.38180116e-01f, 9.27800238e-02f,
  7.09865093e-02f, 1.48398653e-01f, 1.23509452e-01f, 1.81607008e-01f, -2.63440236e-02f, -2.14824453e-02f, -2.26147681e-01f, 1.73003688e-01f, -1.50930643e-01f, 3.09210108e-03f,
  -1.26469294e-02f, 1.96312308e-01f, 9.72634554e-02f, 8.23048577e-02f, 1.34914026e-01f, 7.49650151e-02f, -3.71535146e-03f, 1.15339123e-01f, 7.45249316e-02f, 1.79754689e-01f,
  2.53609773e-02f, -1.40427604e-01f, -2.68931150e-01f, -1.99016199e-01f, -3.65880191e-01f, -8.16941187e-02f, -1.65656209e-01f, -3.32359999e-01f, 1.31689087e-01f, 1.25964610e-02f,
  2.22638529e-02f, -1.77763999e-01f, 3.10162101e-02f, 1.96855828e-01f, 7.03039244e-02f, -9.20126662e-02f, 1.16283059e-01f, 4.75375690e-02f, -8.80297646e-02f, 1.74521818e-03f,
  5.64686023e-02f, -1.04226075e-01f, 7.71537200e-02f, 1.30620552e-02f, 7.57194534e-02f, -2.41257269e-02f, -3.29306610e-02f, -2.44451128e-02f, 1.38532892e-01f, 2.65932698e-02f,
  1.85475543e-01f, -8.52738693e-02f, -1.02969736e-01f, 6.58070892e-02f, -5.68715408e-02f, 8.12897459e-02f, 2.15148255e-01f, 2.42256969e-01f, -2.34031022e-01f, 1.29637733e-01f,
  1.91193014e-01f, 4.54295091e-02f, -4.03894782e-02f, -1.46571890e-01f, -3.05746973e-01f, 1.39441997e-01f, -2.58058041e-01f, -7.29400888e-02f, 8.28859061e-02f, 1.81913182e-01f,
  4.54385430e-02f, 3.40893805e-01f, -1.22604715e-02f, -1.12604260e-01f, -9.96257551e-03f, 6.11462863e-03f, 3.01800761e-02f, -6.66883141e-02f, 8.75807628e-02f, 1.30005285e-01f,
  8.90442450e-03f, -2.04147518e-01f, 3.04262303e-02f, -6.45130053e-02f, 1.27918944e-01f, -3.10651325e-02f, -5.26512749e-02f, 9.54802111e-02f, -4.65726331e-02f, -1.66607693e-01f,
  8.63036588e-02f, 1.43271700e-01f, -4.24149930e-02f, 3.35247978e-03f, -9.92814545e-03f, 5.75661985e-03f, 2.24465095e-02f, 2.30109215e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.00267717e-01f, 6.17376044e-02f, 9.88605320e-02f, 9.66095552e-02f, 9.73809585e-02f, 9.05505940e-02f, 1.46985784e-01f, 5.87665625e-02f, 1.51667833e-01f, 1.44975990e-01f,
  8.46396387e-02f, 1.12528212e-01f, 1.70666248e-01f, -1.14535958e-01f, 8.79104286e-02f, -1.16549293e-02f, 1.52987028e-02f, 1.19064048e-01f, -6.38605133e-02f, 1.46145344e-01f,
  4.06565182e-02f, -1.61047280e-03f, 1.28835589e-01f, 5.31810261e-02f, -2.05475643e-01f, 1.30195573e-01f, -8.47419444e-03f, 1.80788174e-01f, -4.59815795e-03f, -2.86366455e-02f,
  -4.42097299e-02f, 1.03378154e-01f, -2.41075128e-01f, 1.17994234e-01f, 1.43427387e-01f, 9.40330699e-02f, -7.06959665e-02f, 8.53292271e-02f, -5.36911339e-02f, 1.28272861e-01f,
  1.12603717e-01f, -1.22270837e-01f, -4.79876511e-02f, 2.77017560e-02f, 7.58803338e-02f, 2.04812750e-01f, 8.03452432e-02f, -1.40850484e-01f, 9.93678868e-02f, -1.97299495e-01f,
  -3.62766944e-02f, -1.07671591e-02f, -6.99403277e-03f, 5.23066074e-02f, -1.41699258e-02f, -1.47294290e-02f, 1.87983096e-01f, 2.43082628e-01f, 1.31455615e-01f, -1.13379978e-01f,
  2.11188838e-01f, 2.38863647e-01f, 1.26408488e-01f, 1.05595350e-01f, 1.08870625e-01f, 1.37240797e-01f, 1.93135694e-01f, -1.42502477e-02f, 1.19588248e-01f, 1.93868011e-01f,
  1.47466436e-01f, -3.57818790e-02f, -1.90976687e-04f, 1.01969108e-01f, 1.43084347e-01f, 8.84969234e-02f, -6.85196668e-02f, -1.83319017e-01f, 8.94116834e-02f, 5.37355617e-02f,
  1.01496369e-01f, -8.08200687e-02f, 8.77222568e-02f, 1.21063359e-01f, 5.45739010e-02f, 6.14694059e-02f, 5.01928777e-02f, 1.16524901e-02f, -1.43160418e-01f, 2.98461616e-01f,
  -1.08919546e-01f, 1.22545615e-01f, 6.61265031e-02f, -8.03990811e-02f, -2.33542815e-01f, -9.69570130e-03f, -1.85769290e-01f, 9.36601907e-02f, 2.33761147e-01f, -1.52281269e-01f,
  -9.38583687e-02f, 2.63752371e-01f, -1.13024332e-01f, -1.43621176e-01f, -9.66043547e-02f, -1.26191294e-02f, 7.45499060e-02f, 8.65713581e-02f, -7.98122608e-04f, 1.94165438e-01f,
  6.02411814e-02f, -8.81981030e-02f, -1.50996922e-02f, -1.17378019e-01f, -4.82390225e-02f, -1.16739385e-01f, -8.38679299e-02f, -7.92586245e-03f, -1.74571037e-01f, -1.16134398e-01f,
  1.12625428e-01f, -2.37189550e-02f, 5.29673509e-03f, -5.39994575e-02f, -4.69115414e-02f, 1.85857326e-01f, 1.03156045e-01f, 1.19626522e-01f, 7.57852122e-02f, -1.41981954e-03f,
  9.53971595e-02f, -2.32067853e-02f, 1.71538845e-01f, 5.39029539e-02f, 1.00450471e-01f, 1.25695005e-01f, 6.85633272e-02f, 1.30603120e-01f, 8.21386948e-02f, 1.34618983e-01f,
  3.62698674e-01f, -9.99444723e-02f, -1.52429482e-02f, 1.39720412e-02f, -1.04888894e-01f, 2.22188264e-01f, -7.99754784e-02f, 1.33001998e-01f, 2.94003617e-02f, -4.86826673e-02f,
  8.22291747e-02f, 7.25986734e-02f, -1.31941646e-01f, 1.89706292e-02f, 3.08364425e-02f, 2.63492137e-01f, 4.18726131e-02f, -4.47121933e-02f, -5.94254285e-02f, -7.78919831e-02f,
  -2.40805984e-01f, 1.27156466e-01f, 2.75766850e-01f, 8.61630216e-02f, 3.37501802e-02f, -5.13556451e-02f, -4.04675156e-02f, 3.14508051e-01f, -1.09699927e-02f, -1.93813130e-01f,
  1.83966264e-01f, -1.04464598e-01f, 6.78244680e-02f, 2.98962265e-01f, 9.72882360e-02f, -1.20356828e-01f, 8.60252231e-02f, -1.88154563e-01f, -8.71570632e-02f, 1.89674422e-02f,
  -1.66393772e-01f, 2.41821017e-02f, 8.39488879e-02f, -1.46072105e-01f, 2.36747712e-01f, -2.02214178e-02f, 3.12003583e-01f, -1.15430029e-02f, 1.24386877e-01f, 2.14818060e-01f,
  1.92162782e-01f, 5.32576218e-02f, 1.21820264e-01f, 7.37149641e-02f, 8.29555541e-02f, 1.44349724e-01f, -2.82581802e-02f, 1.62327260e-01f, 5.11333123e-02f, 2.76144780e-02f,
  -4.74531688e-02f, 9.04089063e-02f, 9.19199586e-02f, 1.42388314e-01f, -1.78438537e-02f, 6.79037273e-02f, 5.11503406e-02f, -6.25864193e-02f, -3.51927765e-02f, 2.23175511e-01f,
  -2.51342030e-03f, 1.22399688e-01f, -1.23506039e-02f, 1.15194358e-01f, 3.13735625e-04f, -9.30668190e-02f, -5.52146770e-02f, 1.34586483e-01f, -1.97960436e-03f, -2.06011888e-02f,
  -4.53310236e-02f, 7.10989311e-02f, 7.53255114e-02f, 2.15616778e-01f, -4.40514227e-03f, 4.03740034e-02f, -3.12339943e-02f, -1.28322644e-02f, -1.24223508e-01f, 2.23734558e-01f,
  -3.79197896e-02f, -2.24490464e-02f, 9.25547406e-02f, 1.45475775e-01f, -1.03366964e-01f, 1.66976288e-01f, 3.24696600e-02f, -1.69766769e-01f, 5.25393896e-02f, -3.17045348e-03f,
  9.56946984e-02f, 1.38843685e-01f, 4.29158136e-02f, -3.13521996e-02f, 9.88023505e-02f, 3.89887318e-02f, -7.57309347e-02f, 5.94787225e-02f, -8.65863562e-02f, -1.93151966e-01f,
  8.04127827e-02f, 4.31412794e-02f, 1.65258050e-01f, -3.47005911e-02f, 1.47444624e-02f, 2.27378204e-01f, -5.67675121e-02f, 1.38066402e-02f, 1.88558891e-01f, 1.10602424e-01f,
  1.53968245e-01f, -3.27376537e-02f, -8.74971226e-02f, 2.77248747e-03f, -7.87772611e-02f, 2.08653301e-01f, 6.83485270e-02f, 1.14015780e-01f, -5.17091677e-02f, -1.33764476e-01f,
  -4.33095619e-02f, -1.75000578e-01f, -8.14426839e-02f, 9.94272605e-02f, 1.24169312e-01f, 1.68304101e-01f, -3.16001698e-02f, 5.45249507e-02f, 7.33312266e-03f, -7.32438788e-02f,
  -1.02268219e-01f, -1.21992178e-01f, 4.65370230e-02f, -7.50981346e-02f, 9.48219523e-02f, 1.27068967e-01f, 6.55411407e-02f, 7.13787004e-02f, 4.51106057e-02f, 2.57066548e-01f,
  2.07573455e-02f, -1.17204793e-01f, 6.79891407e-02f, 4.42066789e-02f, -1.08038135e-01f, 1.04659304e-01f, 1.39101431e-01f, 1.87476590e-01f, 9.48469043e-02f, 1.59066588e-01f,
  1.15053020e-01f, -4.96070124e-02f, 3.37644100e-01f, 9.11954418e-02f, 1.22400232e-01f, 1.54939011e-01f, -1.46881506e-01f, -1.32359147e-01f, 8.44274834e-02f, -8.58507454e-02f,
  7.13647753e-02f, 1.41163573e-01f, 2.77067591e-02f, 1.33357365e-02f, 1.47863656e-01f, 1.44833565e-01f, 1.39031291e-01f, 1.74205959e-01f, 1.45364761e-01f, 1.20843343e-01f,
  2.17700228e-01f, 8.49264637e-02f, 1.53010279e-01f, 1.95094690e-01f, 8.41374546e-02f, 2.57085592e-01f, 2.15500504e-01f, 1.81169271e-01f, 2.75927901e-01f, 3.66763049e-03f,
  1.34797573e-01f, 4.28682789e-02f, 3.93019579e-02f, 1.54548272e-01f, -5.67610264e-02f, 2.64714635e-03f, 1.67208999e-01f, 2.08472367e-03f, -3.69713493e-02f, -3.07812565e-03f,
  -4.02495861e-02f, -7.71710873e-02f, -1.21423766e-01f, -2.23245397e-01f, -4.15503085e-02f, 9.77921560e-02f, 8.01218376e-02f, -1.96228921e-02f, -1.14515804e-01f, 2.94372663e-02f,
  1.16122879e-01f, 1.19832724e-01f, -1.10461481e-01f, -2.20554590e-01f, -8.52591097e-02f, 9.31423903e-02f, -9.12352726e-02f, 2.44721711e-01f, 2.82999665e-01f, -6.05535023e-02f,
  2.00676396e-02f, -2.92169210e-02f, -1.31306931e-01f, 3.71129252e-02f, 9.76331308e-02f, -2.00689510e-01f, -1.13705322e-01f, -3.26082975e-01f, 3.09019163e-02f, -4.86106984e-02f,
  1.81325212e-01f, 3.09005231e-01f, 1.25695348e-01f, 2.58260459e-01f, 2.02611029e-01f, 7.44164363e-02f, -1.18877038e-01f, -1.37324736e-01f, 1.23391002e-01f, -1.06187314e-01f,
  6.89722225e-02f, -8.59757215e-02f, -1.11433081e-01f, 1.78029314e-01f, -2.41870340e-02f, -2.70305295e-03f, 1.24453582e-01f, 9.30232406e-02f, -2.84534600e-02f, -4.55721095e-03f,
  1.29115190e-02f, 2.03986704e-01f, 9.18419659e-02f, 7.73898587e-02f, 1.31658822e-01f, 2.13069823e-02f, 2.25955248e-01f, 1.26204684e-01f, -1.57839265e-02f, -1.99436590e-01f,
  -1.13991216e-01f, 1.96141943e-01f, -2.19185591e-01f, -1.85902696e-02f, 9.71314386e-02f, 2.83650458e-02f, -5.19367978e-02f, -4.65726927e-02f, 1.17392831e-01f, -3.31606306e-02f,
  1.65302366e-01f, -1.03621781e-01f, 5.91440164e-02f, 9.11569148e-02f, 1.20390169e-01f, 3.28919813e-02f, 4.91247736e-02f, 1.15868390e-01f, -1.33864775e-01f, 1.36041969e-01f,
  -4.08983566e-02f, 1.17895715e-01f, 1.99652791e-01f, 3.08280945e-01f, 2.76346132e-02f, -1.82444364e-01f, -8.74798596e-02f, -1.02337904e-01f, 1.97494194e-01f, 7.39193410e-02f,
  -7.88420513e-02f, -5.33874982e-06f, -2.01593358e-02f, -1.06232911e-01f, 2.21286640e-01f, 1.15178809e-01f, -3.93152945e-02f, 8.62199292e-02f, 8.57096240e-02f, -5.19689731e-02f,
  -8.98968652e-02f, -1.68619931e-01f, 3.39710355e-01f, 3.78790908e-02f, 4.61932570e-02f, -2.02808186e-01f, 8.49674921e-03f, 2.82013595e-01f, 6.28297701e-02f, 1.57111034e-01f,
  1.49032012e-01f, -2.35002302e-02f, 2.40280658e-01f, 1.51583984e-01f, 1.32371292e-01f, 5.78237474e-02f, 2.11035505e-01f, 4.64319885e-02f, 1.07440799e-01f, -2.74059288e-02f,
  -1.65496603e-01f, 3.03769484e-02f, 9.92074683e-02f, 1.10638306e-01f, -9.83996689e-02f, -1.50003061e-01f, 3.44220293e-03f, -1.11100525e-01f, 2.69145332e-02f, -1.98658511e-01f,
  1.77639455e-01f, 4.15245891e-01f, 1.41968027e-01f, 2.95564928e-03f, -1.81407228e-01f, 1.81188509e-01f, -5.79427183e-02f, -8.63891765e-02f, -2.19819427e-01f, -1.63964644e-01f,
  -4.15118299e-02f, 5.24564721e-02f, 1.98201925e-01f, 7.41890594e-02f, 1.96026817e-01f, -1.50958493e-01f, -8.90890807e-02f, -8.11115094e-03f, 9.94173065e-02f, -6.45761490e-02f,
  1.10058904e-01f, -1.11283064e-01f, -1.35945648e-01f, 1.54157430e-01f, -1.74453169e-01f, 2.45320261e-01f, 2.62338892e-02f, -1.43915847e-01f, -1.13622896e-01f, -1.53780237e-01f,
  5.35481460e-02f, -2.19943170e-02f, -1.22693852e-01f, -1.22533470e-01f, 2.16278270e-01f, 3.54288697e-01f, -2.09437564e-01f, -1.48094147e-01f, -6.04944676e-02f, 2.00200856e-01f,
  2.10390799e-02f, -2.39260674e-01f, 6.63200393e-02f, -4.01253300e-03f, 7.29909614e-02f, -1.74215883e-02f, 2.02454448e-01f, 9.48625356e-02f, 1.75530598e-01f, 6.38520718e-02f,
  3.44946794e-02f, 4.17376868e-02f, 9.73386224e-03f, 6.29214570e-02f, 1.37506530e-01f, -5.49552925e-02f, 9.26963016e-02f, 1.50379702e-01f, -2.30557136e-02f, -3.10973488e-02f,
  2.04876419e-02f, 1.54783815e-01f, -2.32594064e-03f, 1.31248524e-02f, 1.34491161e-01f, 8.38136822e-02f, -1.89276099e-01f, 1.33623302e-01f, -1.71070360e-02f, 2.92871773e-01f,
  6.81854412e-02f, -4.46627736e-02f, -1.36797324e-01f, -6.73428131e-03f, -2.51078427e-01f, 6.12504520e-02f, 2.80484498e-01f, 1.34179115e-01f, 3.51106301e-02f, -1.30933896e-01f,
  6.44184742e-03f, 9.75540653e-03f, -2.19928902e-02f, -1.52306333e-01f, 1.34870827e-01f, -4.52206023e-02f, -1.64352491e-01f, 2.77541906e-01f, -9.44189727e-04f, -1.67533323e-01f,
  8.89212936e-02f, -1.66619331e-01f, 2.50060800e-02f, 5.54202087e-02f, 3.60898115e-02f, 8.73226598e-02f, -4.76930961e-02f, -8.02998915e-02f, 2.26734519e-01f, 1.56885549e-01f,
  1.62790343e-02f, -8.43387172e-02f, 9.55802873e-02f, 2.77650684e-01f, 1.37498707e-01f, -8.18836875e-03f, 2.34829307e-01f, 7.93624222e-02f, 2.26602018e-01f, 8.10752511e-02f,
  -3.41996551e-02f, 1.02473252e-01f, 7.44912624e-02f, -5.72628267e-02f, -3.17512895e-03f, 1.91975031e-02f, 1.45137245e-02f, 2.39516348e-02f, -2.44768932e-01f, 2.66175400e-02f,
  1.46447971e-01f, -5.64294346e-02f, 4.62211296e-02f, 3.45347486e-02f, 6.33376315e-02f, 1.58844665e-01f, -8.61752480e-02f, 1.37649357e-01f, 9.38659161e-03f, -1.42276675e-01f,
  -1.51905447e-01f, 2.71949053e-01f, -8.63753110e-02f, -7.36687779e-02f, -1.96888074e-02f, 1.24405831e-01f, 1.12211622e-01f, 3.22612733e-01f, 7.58701265e-02f, -3.56204174e-02f,
  -6.53452054e-02f, -6.11161180e-02f, -2.23804697e-01f, 3.02456528e-01f, -1.17865622e-01f, -3.38215709e-01f, 2.01900327e-03f, 2.40086883e-01f, -9.29046050e-03f, 1.44556209e-01f,
  -3.75079773e-02f, -1.18951865e-01f, -3.12031750e-02f, -1.46222010e-01f, 1.01357736e-01f, 3.81648578e-02f, 3.09731569e-02f, -1.04807161e-01f, -9.55100730e-03f, -3.01013198e-02f,
  -1.55810952e-01f, -2.68012565e-02f, -8.25503767e-02f, -9.63756740e-02f, -3.09553593e-02f, -4.43809517e-02f, 1.48362130e-01f, 3.24092805e-02f, 3.63835394e-02f, 7.62291178e-02f,
  1.36071935e-01f, 1.24729089e-01f, 1.10001683e-01f, 2.98783854e-02f, 1.65096670e-01f, 7.73310065e-02f, 2.10117519e-01f, 1.52072504e-01f, 9.27085131e-02f, 1.34154752e-01f,
  -3.26988427e-03f, 8.25721845e-02f, 1.77970320e-01f, 1.13893591e-01f, -2.81075146e-02f, -2.58145928e-02f, -2.06621010e-02f, 4.53115962e-02f, -1.59092516e-01f, -3.76931392e-02f,
  9.59700942e-02f, -2.31494345e-02f, -1.76032167e-02f, 1.14424817e-01f, -3.13521456e-03f, 4.96560074e-02f, 1.29400581e-01f, 2.82664280e-02f, -4.64068130e-02f, -7.65753463e-02f,
  2.86095403e-02f, -1.02982847e-02f, -4.96263318e-02f, -7.72183463e-02f, 9.31133255e-02f, 1.62086800e-01f, 3.29604670e-02f, -2.86951452e-03f, 2.18348563e-01f, 1.63664237e-01f,
  1.17284805e-03f, -1.40487984e-01f, -9.27942842e-02f, -1.64090946e-01f, 2.13060826e-01f, 5.96305281e-02f, -1.13537833e-01f, -8.51927325e-03f, -2.71709282e-02f, -8.37737322e-02f,
  1.05170175e-01f, 1.45314097e-01f, -1.25623211e-01f, 1.12955272e-01f, 1.39859438e-01f, -5.44359684e-02f, -2.95813894e-03f, -2.72563729e-03f, 2.70784348e-01f, -8.26962963e-02f,
  1.94634553e-02f, -7.21746013e-02f, 9.29089636e-03f, 1.01961017e-01f, -7.07920194e-02f, 7.39644319e-02f, 1.53328508e-01f, 1.65501356e-01f, 9.91578922e-02f, 6.57740161e-02f,
  1.46698028e-01f, 6.29406869e-02f, 1.17979884e-01f, 1.58739805e-01f, 9.29682553e-02f, 1.73223764e-01f, 5.92408665e-02f, 1.68555796e-01f, 4.67648506e-02f, -8.97935852e-02f,
  -1.27391636e-01f, -8.55727568e-02f, -5.29946126e-02f, -1.99796394e-01f, 1.24752417e-01f, -1.62405133e-01f, 1.11466639e-01f, 2.10783109e-01f, 2.22016320e-01f, 2.92856842e-02f,
  2.44595669e-02f, 8.79883207e-03f, 1.67977154e-01f, -3.23433727e-02f, -2.25393057e-01f, -8.44251439e-02f, 6.98052049e-02f, 6.99882135e-02f, 6.15004301e-02f, 1.30349845e-01f,
  1.29769921e-01f, -1.72945380e-01f, 4.20072190e-02f, 2.50574023e-01f, 5.07567190e-02f, -8.25339183e-02f, 8.13006982e-02f, -2.18761235e-01f, -5.92774190e-02f, 1.18301600e-01f,
  -6.29128143e-02f, 2.23317102e-01f, 3.77361029e-02f, 1.70064289e-02f, 1.87283140e-02f, -6.40699938e-02f, -1.92622080e-01f, 3.76719758e-02f, -7.04332516e-02f, -2.49882385e-01f,
  1.30751297e-01f, 1.67812198e-01f, -3.26236635e-02f, 1.01089433e-01f, -1.86423007e-02f, -5.77707663e-02f, -3.89257283e-03f, -4.06627022e-02f, 3.58458191e-01f, 1.47919372e-01f,
  2.30129480e-01f, 1.69241309e-01f, 1.91805765e-01f, 2.73892313e-01f, 2.70201921e-01f, -7.13324873e-03f, 2.56238163e-01f, 1.88146904e-02f, 1.25119999e-01f, 1.08670160e-01f,
  -1.11299366e-01f, 8.65747184e-02f, 4.00406867e-02f, 2.28657350e-01f, 9.78795160e-03f, -2.12087370e-02f, -7.46250560e-04f, 9.86283571e-02f, -8.88851359e-02f, 1.34710129e-02f,
  2.90622022e-02f, 6.50672801e-03f, -3.34676690e-02f, 2.28202343e-01f, 5.59840314e-02f, 1.10564329e-01f, -1.53446048e-01f, 3.80007401e-02f, -4.36512986e-03f, 3.41051072e-02f,
  -1.68216258e-01f, -1.24267556e-01f, 8.39908347e-02f, 1.16701335e-01f, -1.85451098e-02f, 1.66145965e-01f, 1.35705650e-01f, -6.85926601e-02f, 7.03691095e-02f, 6.14601374e-02f,
  -1.55117571e-01f, 1.82489112e-01f, 2.44068019e-02f, -8.20352435e-02f, -1.63694754e-01f, -1.65066838e-01f, 1.65766254e-01f, -1.32337242e-01f, 5.32689784e-03f, 1.18723467e-01f,
  3.33333433e-01f, 2.22693473e-01f, 1.08676948e-01f, 1.68586254e-01f, 5.35315163e-02f, 2.28939041e-01f, 2.35980526e-02f, -2.13449746e-01f, 1.61273882e-01f, 2.13338867e-01f,
  -5.94065338e-02f, 3.88125554e-02f, 6.64563105e-02f, 2.05858108e-02f, 1.77253932e-01f, 1.23079419e-02f, 1.41277984e-01f, 3.73751819e-02f, 1.38540193e-01f, -1.21878244e-01f,
  -1.35326553e-02f, 1.11261584e-01f, 1.22528769e-01f, 1.44403353e-01f, -7.96252340e-02f, -1.48846254e-01f, 6.66051358e-02f, 1.15260601e-01f, 2.82552689e-02f, -1.13865361e-01f,
  1.14813246e-01f, 9.94207934e-02f, -2.73837689e-02f, -7.73348333e-03f, 7.82062560e-02f, 6.31787628e-02f, -9.31729600e-02f, 5.86870983e-02f, -6.95602819e-02f, 9.46950465e-02f,
  5.27541824e-02f, -6.75015450e-02f, -9.84546319e-02f, -2.19555534e-02f, -1.14345729e-01f, 1.29162371e-01f, 2.07120255e-01f, -2.65065813e-04f, -1.80200785e-02f, 3.36081833e-02f,
  -9.48504806e-02f, -1.34451464e-01f, 1.79866385e-02f, -6.74896091e-02f, 6.78108186e-02f, 7.81971589e-02f, -1.68262944e-01f, 6.16581850e-02f, 1.52668342e-01f, 2.71027442e-02f,
  1.21222831e-01f, -1.16699688e-01f, -1.21678405e-01f, -1.13178290e-01f, 1.65573478e-01f, -2.21717581e-02f, -5.43221533e-02f, -6.25572819e-03f, 1.10718638e-01f, 2.11877003e-01f,
  -1.17556863e-01f, -6.04259595e-02f, 8.53089839e-02f, 2.95323759e-01f, 5.58685549e-02f, -8.92038122e-02f, 1.32312387e-01f, 6.25060648e-02f, 1.07865192e-01f, 3.85304727e-02f,
  1.01227403e-01f, 5.66318929e-02f, 9.28880572e-02f, 1.31760597e-01f, 6.43407181e-02f, 1.07534014e-01f, 3.12103517e-03f, 1.01435646e-01f, 1.72133565e-01f, -7.08880946e-02f,
  4.09291312e-03f, -3.96415554e-02f, -3.01718246e-02f, 1.67285740e-01f, -9.09759030e-02f, 1.75001949e-01f, 7.75233284e-03f, 1.18160792e-01f, 4.45076898e-02f, -8.16912875e-02f,
  -1.56955928e-01f, 2.20003009e-01f, 2.41361745e-02f, 6.73292950e-02f, -4.61963378e-02f, -6.73043281e-02f, -6.98698685e-02f, 1.08003482e-01f, -1.91684186e-01f, -2.77652144e-02f,
  1.85367599e-01f, -5.67999808e-03f, -6.56407550e-02f, 1.94029808e-01f, -6.46455884e-02f, 2.57954717e-01f, 1.33312419e-02f, -9.94557068e-02f, 2.98117828e-02f, -4.51745242e-02f,
  1.82105646e-01f, 1.37626186e-01f, 5.26607782e-02f, -1.89012051e-01f, 4.22306778e-03f, -1.24494806e-01f, -1.56538747e-02f, -4.41416427e-02f, -9.72247496e-02f, -1.66746194e-03f,
  2.03754324e-02f, -7.63596371e-02f, 1.05681442e-01f, -8.27914178e-02f, 2.89283633e-01f, -3.85469981e-02f, 1.06928803e-01f, 5.47938421e-02f, 1.65692076e-01f, 1.72467217e-01f,
  -6.00008236e-04f, 1.79728612e-01f, 6.35285527e-02f, 6.17061593e-02f, -4.66628596e-02f, 4.32446450e-02f, 1.02028988e-01f, 1.26030058e-01f, 4.69267927e-02f, 9.51316282e-02f,
  1.61844626e-01f, 1.58905610e-01f, 2.53072709e-01f, 7.41573274e-02f, 1.84033915e-01f, -2.15153709e-01f, 3.00902911e-02f, 1.63623560e-02f, -2.66513675e-01f, -1.02843717e-01f,
  1.12899564e-01f, 7.27213398e-02f, -2.02385653e-02f, 1.89193726e-01f, 1.80713668e-01f, 7.78333470e-02f, 2.15697289e-01f, -3.25088538e-02f, 2.19855145e-01f, 2.84549966e-02f,
  -1.21736109e-01f, 1.66052189e-02f, 4.78157140e-02f, 2.55141348e-01f, -1.73733551e-02f, 1.14056520e-01f, -4.06222604e-02f, 7.25644976e-02f, 1.67952329e-01f, 1.74608603e-01f,
  -1.96843967e-02f, -1.21279351e-01f, -4.86121066e-02f, -8.16934854e-02f, 1.59176409e-01f, 2.43145376e-01f, -1.20117716e-01f, 1.17221296e-01f, -7.81115843e-03f, -2.28243582e-02f,
  2.16376245e-01f, 1.08950352e-02f, -1.54291764e-01f, 1.81138460e-02f, -1.18372798e-01f, -1.31932333e-01f, -5.63324280e-02f, -1.52049419e-02f, 1.73121080e-01f, 1.93941459e-01f,
  -5.83545258e-03f, -1.64386839e-01f, 9.47352573e-02f, 2.80570596e-01f, 3.95789631e-02f, 1.96130678e-01f, 1.65413648e-01f, 1.63592875e-01f, 2.15301260e-01f, 1.74143374e-01f,
  2.58058906e-01f, 2.73312867e-01f, 1.06794238e-01f, 5.68393543e-02f, 9.81993154e-02f, 6.75445274e-02f, -8.44760090e-02f, 1.73762664e-01f, -1.67364910e-01f, -9.10741761e-02f,
  -1.13774680e-01f, 1.60010323e-01f, 7.64213363e-03f, -1.15562260e-01f, 6.40563816e-02f, -1.98553205e-01f, -6.82446882e-02f, -8.49803761e-02f, 2.37555683e-01f, -1.16142429e-01f,
  -5.84643446e-02f, -1.81087360e-01f, -1.21296734e-01f, 5.89237548e-02f, 5.41191101e-02f, -9.38572809e-02f, 6.31252900e-02f, -5.25112264e-02f, -3.36320624e-02f, 4.75695096e-02f,
  8.70167390e-02f, -2.06547886e-01f, 1.97824180e-01f, 3.35297734e-01f, 2.09842995e-02f, -1.51904225e-01f, -8.77955481e-02f, -1.81260362e-01f, -3.44816856e-02f, -1.10452920e-01f,
  -1.00665629e-01f, 1.56299700e-03f, 5.33296689e-02f, -1.81103721e-01f, 7.08781229e-03f, 1.70086160e-01f, -5.08453115e-04f, 2.20957976e-02f, 2.53432900e-01f, 1.00785434e-01f,
  -3.10427751e-02f, 4.41363826e-02f, 1.80468783e-02f, -1.07108153e-01f, -5.36683574e-03f, -1.57206520e-01f, -2.46367864e-02f, -1.22327983e-01f, 1.65157020e-01f, 9.39181596e-02f,
  1.93699554e-01f, 9.14509967e-02f, 1.31393582e-01f, 5.21663912e-02f, 5.75446431e-03f, -7.24016130e-02f, -2.63927411e-02f, 1.33581415e-01f, 7.29851350e-02f, 2.22422689e-01f,
  -1.11081429e-01f, -1.43211633e-01f, -8.33591223e-02f, 2.61511393e-02f, -1.67762011e-01f, 1.25723317e-01f, 5.62009774e-02f, 2.43065402e-01f, -1.36920318e-01f, 1.08488940e-01f,
  7.61735588e-02f, -2.21703112e-01f, -1.60976797e-01f, 5.42015918e-02f, -1.88217238e-01f, 1.22306079e-01f, -6.49857447e-02f, 6.21136352e-02f, -8.05017538e-03f, 8.89725164e-02f,
  -2.20202133e-02f, 2.54389979e-02f, -5.88390343e-02f, -1.22510076e-01f, -2.62950696e-02f, 1.60697550e-01f, -1.21673405e-01f, -4.77589071e-02f, 1.53733730e-01f, 6.79074898e-02f,
  -9.51575562e-02f, 2.41436064e-01f, -2.35633496e-02f, -2.29805991e-01f, 1.04370758e-01f, -1.05318183e-03f, 2.94872746e-02f, 4.05733958e-02f, -1.51537940e-01f, 4.54368303e-03f,
  2.64173478e-01f, -3.45726013e-02f, 1.12263165e-01f, 2.66365796e-01f, -6.24549165e-02f, 2.31326938e-01f, 1.05705634e-01f, -9.82975364e-02f, 1.95623651e-01f, 2.05928952e-01f,
  7.08599463e-02f, -6.94056507e-03f, 3.84373665e-02f, 1.28685266e-01f, 1.64708063e-01f, 8.08303151e-03f, 5.19973822e-02f, 6.00105375e-02f, 1.50062963e-01f, 2.37169996e-01f,
  9.83644202e-02f, 5.35638742e-02f, 8.50883871e-02f, 1.09446160e-02f, 2.07940638e-01f, 6.28609508e-02f, -5.78132179e-03f, -1.30535811e-01f, -4.68085259e-02f, 1.26119167e-01f,
  -2.51338929e-01f, -2.48655304e-02f, 9.30212662e-02f, 2.56596971e-02f, 7.54183456e-02f, 1.81145370e-01f, 7.41032213e-02f, 1.35228038e-01f, 1.44784644e-01f, 3.08023058e-02f,
  7.03582317e-02f, -1.22277355e-02f, -7.97883719e-02f, 1.48874521e-02f, 1.13383948e-03f, 4.14432287e-02f, 6.98826909e-02f, 5.21388128e-02f, -1.41555825e-02f, -3.19980457e-02f,
  2.45433692e-02f, 3.63787800e-01f, -1.98691078e-02f, -1.52640492e-01f, -2.11802311e-02f, -1.20023131e-01f, 2.22984090e-01f, 1.63563222e-01f, -1.23601191e-01f, 1.36345044e-01f,
  -5.10511138e-02f, -9.94054377e-02f, 1.18710294e-01f, 6.56935051e-02f, -1.36505872e-01f, 8.57230276e-02f, 3.86593901e-02f, -1.31533250e-01f, 3.95327359e-02f, -3.90121974e-02f,
  3.23934764e-01f, -5.05202003e-02f, -3.91285773e-03f, -1.28760174e-01f, 7.68285543e-02f, 9.36811119e-02f, 1.72643531e-02f, -2.22109016e-02f, -1.32440235e-02f, 7.95000326e-03f,
  -2.61483015e-03f, 1.20448377e-02f, 1.83366593e-02f, -6.71522552e-03f, -5.57444058e-02f, 2.06898320e-02f, -5.42298183e-02f, 1.79833896e-03f, 1.77711725e-01f, -4.68429513e-02f,
  9.77066606e-02f, -8.08687788e-03f, 1.44575849e-01f, -1.05317319e-02f, -1.90139394e-02f, 6.29192963e-02f, -2.49946117e-02f, -1.11897048e-02f, 5.16497940e-02f, 5.74976299e-03f,
  -1.60380229e-01f, 1.11471072e-01f, 5.46025112e-02f, 1.39916494e-01f, 7.46446522e-03f, -4.26636934e-02f, -7.08506182e-02f, 9.11468640e-02f, -1.86420828e-01f, 1.08066857e-01f,
  1.99045092e-01f, 7.17085451e-02f, -6.06854148e-02f, 1.43785045e-01f, -4.68677981e-03f, 3.25064473e-02f, -1.02967530e-01f, -1.58013552e-01f, 9.43370312e-02f, -3.54965776e-02f,
  -3.55169065e-02f, 2.58115917e-01f, 7.25430697e-02f, -1.99543446e-01f, 4.21441756e-02f, -9.02183875e-02f, 1.04692154e-01f, 5.01105897e-02f, -7.04366863e-02f, 2.36175209e-02f,
  2.75019165e-02f, -9.12144333e-02f, 1.56409532e-01f, -1.98365778e-01f, 1.10381685e-01f, 9.17830411e-03f, 6.77709579e-02f, -4.15694341e-03f, 8.29811916e-02f, 1.84555724e-01f,
  4.03321944e-02f, 1.59615189e-01f, 1.34383723e-01f, 2.84830038e-03f, 1.64434731e-01f, 7.41043165e-02f, 2.25997001e-01f, 2.25989774e-01f, 1.88911125e-01f, 1.22254957e-02f,
  5.58781661e-02f, 4.33898643e-02f, -1.23721868e-01f, 1.11277714e-01f, -6.44558147e-02f, 4.04850915e-02f, -1.81670487e-02f, -5.70585132e-02f, 5.50784245e-02f, -1.58520356e-01f,
  3.86483520e-02f, -1.23711534e-01f, 5.70993870e-02f, 1.07401252e-01f, 2.86026224e-02f, 1.23868041e-01f, 1.66945249e-01f, 1.77780747e-01f, -1.55248180e-01f, -6.68526813e-02f,
  -8.46225843e-02f, -1.26612142e-01f, 7.16714263e-02f, -2.09190354e-01f, 4.59886603e-02f, 1.86594129e-01f, 2.34797478e-01f, -1.36476591e-01f, 2.03431383e-01f, -8.72625317e-03f,
  -1.37235215e-02f, -6.72935620e-02f, 2.84968521e-02f, -6.92073926e-02f, -4.63314205e-02f, -5.34690591e-03f, -5.39533235e-02f, -5.73438071e-02f, -5.95086953e-03f, -1.02878725e-02f,
  3.99926119e-02f, 1.68780088e-01f, -9.05923918e-02f, 1.60992205e-01f, 6.07342646e-02f, 1.19007314e-02f, 3.99874337e-02f, 1.79623812e-01f, -9.53735560e-02f, -8.40456262e-02f,
  -7.67000318e-02f, 3.59098651e-02f, -8.00229609e-02f, -8.90977308e-02f, 2.58172005e-01f, 1.02420136e-01f, 1.77017406e-01f, 1.15076825e-01f, 1.14151597e-01f, 2.68365681e-01f,
  2.12436140e-01f, 1.41825750e-01f, 1.52719766e-01f, 1.28106520e-01f, -5.08597633e-03f, 8.40471014e-02f, 6.56363228e-03f, -6.20122030e-02f, 8.62782747e-02f, 1.35608912e-01f,
  8.39985162e-02f, -4.61101159e-02f, -1.51025981e-01f, 1.06368586e-01f, -2.88444478e-02f, 1.59541011e-01f, 2.94535607e-02f, -8.65676031e-02f, -2.38525093e-01f, 3.45857769e-01f,
  6.62621334e-02f, 1.25112921e-01f, -9.19314325e-02f, -1.52885973e-01f, -8.13597515e-02f, 7.61103332e-02f, -1.12928465e-01f, -2.83839017e-01f, 5.06102815e-02f, 1.01513892e-01f,
  -7.47431740e-02f, 3.25212717e-01f, 7.52907097e-02f, -1.82221100e-01f, -5.11422642e-02f, 4.24721017e-02f, -1.92936480e-01f, 7.91535974e-02f, 1.22648098e-01f, 6.75471351e-02f,
  -2.39637926e-01f, -2.38812029e-01f, -5.38136363e-02f, -8.37162435e-02f, 1.59569263e-01f, 1.74039155e-01f, 1.18896872e-01f, 2.50872582e-01f, 2.88394541e-02f, 5.47870956e-02f,
  7.60513842e-02f, -7.86022916e-02f, 1.71706051e-01f, -1.47936985e-01f, -2.94276346e-02f, 3.74698751e-02f, -5.90620236e-03f, 2.67417043e-01f, -1.37144163e-01f, -3.10661159e-02f,
  6.29332066e-02f, 4.34295945e-02f, -2.02264965e-01f, 8.31813589e-02f, -2.28731660e-03f, -6.16518706e-02f, -3.48694362e-02f, 6.80580065e-02f, 4.97796061e-03f, 1.51032805e-01f,
  1.62900910e-01f, -5.13729304e-02f, 8.87844786e-02f, -1.68473110e-01f, 2.90852904e-01f, -1.96275860e-01f, -4.57344353e-02f, -1.05256550e-01f, -3.18257324e-02f, 6.87926114e-02f,
  -5.65563403e-02f, 1.05589643e-01f, 1.73681090e-03f, -1.68088973e-01f, 2.73191512e-01f, 2.18260273e-01f, 2.65163869e-01f, -3.56305577e-02f, -8.34271237e-02f, 2.74849415e-01f,
  1.20290816e-01f, 2.84956157e-01f, 3.63013223e-02f, 1.59035921e-01f, 7.22828880e-03f, -6.46361932e-02f, 2.10167691e-01f, -4.83025685e-02f, -8.00738409e-02f, -1.45296261e-01f,
  1.45454377e-01f, -2.10375693e-02f, 3.45825516e-02f, 1.47386357e-01f, 2.32666492e-01f, 1.22800916e-01f, 4.54280004e-02f, -1.09250862e-02f, 3.17677945e-01f, 1.95385873e-01f,
  -7.00388849e-02f, 1.31890625e-01f, 1.59198329e-01f, 1.14593245e-02f, 1.59577817e-01f, -1.98528647e-01f, -5.37409075e-02f, 2.91718453e-01f, 2.69301813e-02f, -7.94504657e-02f,
  -4.32983832e-03f, 1.25653967e-01f, 1.33365870e-01f, 9.72902030e-02f, 7.16806017e-03f, 7.63621032e-02f, 1.42859384e-01f, 8.45342726e-02f, 1.34715125e-01f, 1.52377233e-01f,
  1.96582809e-01f, 3.94466668e-02f, 4.10088487e-02f, 1.78755745e-02f, 7.65872002e-02f, 1.82550922e-01f, -1.97045747e-02f, 9.82346460e-02f, 1.94052503e-01f, -4.48651575e-02f,
  -6.95575327e-02f, -8.86226594e-02f, -7.78478533e-02f, -5.85739017e-02f, -7.89356381e-02f, -1.72278471e-02f, 5.26121119e-03f, 1.09400794e-01f, 1.72307670e-01f, 1.38072371e-01f,
  -1.35201037e-01f, -7.86975250e-02f, 8.91809314e-02f, 4.80467044e-02f, -7.98959471e-03f, -2.06339419e-01f, 3.14392671e-02f, 2.92460084e-01f, 4.33233418e-02f, -7.51176625e-02f,
  2.91412562e-01f, 1.86083056e-02f, -5.62924929e-02f, -3.85069288e-02f, -8.09159279e-02f, -6.79891184e-02f, 1.17537593e-02f, -5.66915497e-02f, -8.07838514e-02f, -1.65331647e-01f,
  9.55264568e-02f, -1.50080293e-01f, 2.25612655e-01f, 3.02686185e-01f, 8.66473746e-03f, 1.89702153e-01f, 1.31040633e-01f, -7.55697563e-02f, 6.74379319e-02f, -3.21257152e-02f,
  -1.01556048e-01f, -2.53579915e-02f, -7.83337802e-02f, -1.46094084e-01f, -1.17184915e-01f, 6.10006414e-02f, -4.29403260e-02f, 1.12440601e-01f, 1.30230322e-01f, 7.39131197e-02f,
  5.72658367e-02f, 3.27600725e-02f, -5.50690144e-02f, -3.11337486e-02f, -8.42249170e-02f, 2.98865568e-02f, 2.71725021e-02f, 1.37141317e-01f, -2.79042162e-02f, -1.22193299e-01f,
  1.65161893e-01f, -1.92230910e-01f, 2.63555571e-02f, 2.93687209e-02f, 1.74907491e-01f, 8.65859389e-02f, -6.63245693e-02f, 4.73817214e-02f, -5.67840412e-02f, -5.55243641e-02f,
  2.99657844e-02f, 2.83550844e-02f, 1.43761262e-01f, -1.16583154e-01f, 3.22223812e-01f, 2.25966677e-01f, 1.83620483e-01f, 2.04899341e-01f, 2.66779423e-01f, 3.83822113e-01f,
  1.05011538e-01f, -1.10321663e-01f, -6.12157136e-02f, 1.82727069e-01f, -1.15413517e-01f, -4.96930704e-02f, 8.95332694e-02f, 2.40471050e-01f, 1.15373813e-01f, 1.36629403e-01f,
  8.83450955e-02f, 1.17797539e-01f, 2.57575721e-01f, 1.75711617e-01f, 1.15363272e-02f, 1.56891495e-01f, 6.18472770e-02f, -1.80184945e-01f, -1.38023317e-01f, -1.57352507e-01f,
  -1.90605238e-01f, 2.93748099e-02f, -4.22635786e-02f, -2.73397207e-01f, 2.96251755e-02f, 2.40553752e-01f, 1.56656399e-01f, -5.64734936e-02f, 1.17595658e-01f, 2.55597234e-01f,
  5.17453626e-02f, 1.15848370e-01f, 8.94070268e-02f, 1.50676042e-01f, 1.04736201e-01f, 2.51074135e-02f, 4.65634055e-02f, 2.97444947e-02f, 1.27934843e-01f, 1.22092791e-01f,
  5.67343608e-02f, 2.30716802e-02f, -2.81856626e-01f, -2.98522227e-02f, -2.72240341e-02f, -1.10912127e-02f, 4.18489166e-02f, -2.74734557e-01f, 2.39071101e-01f, -1.79322749e-01f,
  -2.44810525e-02f, -8.47596452e-02f, -1.47416875e-01f, 5.48790172e-02f, 2.44136363e-01f, -1.79363817e-01f, -1.12872142e-02f, -5.56393825e-02f, 2.07801521e-01f, -2.79893503e-02f,
  -1.33014470e-01f, -1.17092930e-01f, 9.18226019e-02f, 6.61508143e-02f, -1.23366445e-01f, -7.59792402e-02f, 2.57074714e-01f, -9.06928405e-02f, 6.66450113e-02f, -4.77757566e-02f,
  -2.39948072e-02f, 1.75734349e-02f, 1.90283254e-01f, 2.68657822e-02f, -1.56315699e-01f, 3.14067975e-02f, 1.18918866e-01f, 3.11880052e-01f, -1.12766534e-01f, 1.48409605e-01f,
  5.01661934e-02f, -2.86061480e-03f, 6.81576878e-02f, -8.03026184e-02f, 1.59749702e-01f, -1.22445170e-02f, 2.24434808e-02f, 1.54528022e-01f, -2.74699003e-01f, 2.44330376e-01f,
  -2.42790133e-01f, 8.29880014e-02f, -1.09670930e-01f, -9.76428762e-02f, 1.44320115e-01f, 1.45739511e-01f, 1.69275001e-01f, 4.75036614e-02f, 1.39810279e-01f, 5.95140159e-02f,
  9.22465697e-02f, -8.60683843e-02f, 6.51841611e-02f, 7.97144547e-02f, 9.63159371e-03f, 1.01308264e-01f, -2.08955318e-01f, -1.52010173e-01f, -6.31785439e-03f, 1.55395538e-01f,
  -9.26416367e-02f, -7.16609284e-02f, 8.06469023e-02f, 1.84981331e-01f, -1.62459806e-01f, 1.13592118e-01f, 2.39443202e-02f, -2.75721829e-02f, -1.31772295e-01f, 3.65919322e-02f,
  -1.69139311e-01f, 6.48685992e-02f, -4.62121703e-03f, 9.59022269e-02f, 7.99278319e-02f, 1.09051630e-01f, 7.13751540e-02f, -4.49784361e-02f, -7.17728212e-02f, -2.47047730e-02f,
  1.02599263e-01f, 1.11448370e-01f, -1.60836875e-01f, -1.15647554e-01f, 1.76737770e-01f, 2.03430265e-01f, -8.12617242e-02f, 2.37961069e-01f, -2.17906106e-02f, -1.98062032e-01f,
  1.09741114e-01f, -2.62425803e-02f, 1.24557458e-01f, 6.94307238e-02f, -8.31905901e-02f, -1.58100113e-01f, 2.95519620e-01f, -7.13767931e-02f, 9.93634164e-02f, 2.26248235e-01f,
  -2.55099144e-02f, 8.62885341e-02f, -1.13534443e-01f, 3.82368527e-02f, 1.75691962e-01f, 1.77728415e-01f, 7.83745125e-02f, 6.77282065e-02f, -3.33206318e-02f, 8.32234100e-02f,
  9.82700065e-02f, 1.28069460e-01f, 1.72853738e-01f, -7.14331819e-03f, 8.11731219e-02f, 1.81146756e-01f, 1.05254859e-01f, 1.35759354e-01f, 5.02304547e-02f, 6.90785646e-02f,
  -2.64757257e-02f, 8.47160369e-02f, -1.29527837e-01f, -1.17976166e-01f, -7.70858675e-02f, 7.41479546e-02f, 3.64003070e-02f, -5.91234826e-02f, 9.17587355e-02f, -3.66913565e-02f,
  -1.28634751e-01f, -1.68178067e-01f, 2.46329695e-01f, -1.60415500e-01f, -9.82997380e-03f, -1.31844178e-01f, 1.34141743e-01f, 1.63325027e-01f, 1.65859580e-01f, -1.74592376e-01f,
  1.75607517e-01f, 1.81058273e-01f, -6.79746866e-02f, -2.20355451e-01f, 1.73048809e-01f, -2.81954080e-01f, 7.58195892e-02f, 3.09633017e-01f, 3.06104608e-02f, 3.36217508e-02f,
  1.11635409e-01f, -6.00741394e-02f, -2.19152682e-02f, -9.09570307e-02f, 3.76420990e-02f, 3.11998814e-01f, -1.80722661e-02f, 1.11266591e-01f, -8.43699649e-02f, 9.58219171e-02f,
  -7.92027265e-02f, -7.54475892e-02f, 4.95052487e-02f, 5.73346131e-02f, -4.24491912e-02f, -6.95945993e-02f, 1.14717685e-01f, 1.63014233e-01f, -5.79099767e-02f, -6.00368865e-02f,
  -4.33710963e-02f, -1.41386285e-01f, -3.18645164e-02f, 7.23747211e-03f, 5.16738631e-02f, 2.22549308e-02f, 1.02049790e-01f, 6.81606606e-02f, 2.47163177e-02f, 1.76619187e-01f,
  -1.19323877e-03f, 8.92453417e-02f, 7.73533806e-02f, 1.67870671e-02f, 2.93279588e-01f, 6.64188266e-02f, -8.27883705e-02f, -9.65172276e-02f, -8.49687606e-02f, 2.84902513e-01f,
  -9.08647925e-02f, 6.55570999e-02f, 1.09251715e-01f, 1.36091113e-01f, 4.53697843e-03f, 3.70389558e-02f, -9.06329006e-02f, 8.52936134e-02f, 1.30655721e-01f, -1.46903098e-01f,
  -7.39423484e-02f, 7.98035413e-02f, 9.31387097e-02f, 6.55481741e-02f, -5.56714199e-02f, 3.04344688e-02f, -8.34252685e-02f, 6.71501309e-02f, -3.90306637e-02f, 1.60225511e-01f,
  -8.66019502e-02f, 3.57250214e-01f, 6.60688281e-02f, -2.18751598e-02f, -5.32691926e-02f, -6.47938251e-02f, 3.17527384e-01f, 1.33819968e-01f, 1.15530770e-02f, -4.40470390e-02f,
  -8.67453590e-03f, -1.49035213e-05f, 1.57421492e-02f, -6.99328110e-02f, -8.87834430e-02f, -5.51457144e-02f, 3.07515282e-02f, -3.80651257e-03f, -9.70496610e-02f, -1.01399794e-01f,
  3.68728131e-01f, -6.75814599e-02f, 1.04199938e-01f, -1.72544390e-01f, 1.49568796e-01f, 3.10752124e-01f, -6.33261576e-02f, 9.35966223e-02f, 1.03538103e-01f, -9.74356104e-03f,
  8.33478794e-02f, 1.06954912e-03f, 6.28873333e-02f, -1.46752121e-02f, 3.80958989e-02f, 1.53357923e-01f, 1.79269090e-01f, 1.10768124e-01f, -4.13758829e-02f, -4.08358686e-02f,
  -8.65175668e-03f, -1.00378223e-01f, -1.34500310e-01f, 5.43061905e-02f, 1.28978416e-01f, 1.70823187e-01f, -2.51856782e-02f, -9.11501050e-02f, 1.09271891e-01f, 6.75976351e-02f,
  8.74125287e-02f, -5.45263104e-02f, -2.70096008e-02f, 8.80020931e-02f, 1.40467182e-01f, 6.39047399e-02f, -8.90281498e-02f, -2.36947350e-02f, 1.14230670e-01f, 2.34586701e-01f,
  8.78104046e-02f, 4.78016352e-03f, 9.76073742e-02f, -7.86888823e-02f, -9.91886333e-02f, 1.02899596e-01f, 1.10341139e-01f, 4.76807123e-03f, 1.74676865e-01f, 1.42394349e-01f,
  9.57184099e-03f, -2.29824781e-02f, 1.24875478e-01f, 2.83211976e-01f, -1.28004989e-02f, 6.85149878e-02f, -4.50024828e-02f, -2.02516839e-01f, -2.71393918e-02f, -7.31968507e-02f,
  -2.63430309e-02f, -1.60358977e-02f, 1.19785488e-01f, 1.52531415e-01f, -1.24458894e-02f, 9.51259583e-02f, 1.00685932e-01f, 1.77380294e-01f, 9.81218219e-02f, -2.62161512e-02f,
  2.55882412e-01f, 1.11819699e-01f, 3.95069644e-02f, 3.96301933e-02f, 3.00341785e-01f, 2.39618942e-01f, 2.91077644e-01f, 2.14758769e-01f, 2.39957616e-01f, 1.15199760e-01f,
  1.33607894e-01f, 9.40832943e-02f, -8.45131502e-02f, 5.55769764e-02f, -1.36961415e-01f, 1.76580787e-01f, -1.54264927e-01f, 1.30658634e-02f, 2.44835373e-02f, 1.99858332e-03f,
  1.62598863e-02f, -1.40162155e-01f, -1.16354823e-02f, -4.46689241e-02f, 1.25214785e-01f, 3.93174067e-02f, -2.04648241e-01f, 2.82863136e-02f, -2.06487849e-01f, -7.44966343e-02f,
  2.50002574e-02f, -2.01939508e-01f, -4.46899980e-02f, -1.67079866e-01f, 1.77836623e-02f, -2.75435653e-02f, 1.59571022e-01f, -1.87557593e-01f, 1.59317121e-01f, 2.25839570e-01f,
  1.65603086e-02f, -1.77498966e-01f, -8.00049156e-02f, -9.63821933e-02f, -7.73183778e-02f, -5.13530560e-02f, -2.45437399e-01f, 5.38503155e-02f, -1.68788480e-03f, -2.32261628e-01f,
  -6.38609827e-02f, 1.83748990e-01f, 2.41293147e-01f, 6.13756292e-02f, 2.43571222e-01f, 1.03906944e-01f, 7.72109851e-02f, 4.16673839e-01f, 1.41319372e-02f, -2.01966435e-01f,
  -3.56666371e-02f, 1.39546424e-01f, -1.83926821e-02f, -1.18677467e-01f, 2.42154654e-02f, 2.11420223e-01f, 1.65378049e-01f, 2.65535861e-01f, -6.13050535e-03f, 8.56349915e-02f,
  8.07830617e-02f, 7.03597218e-02f, 1.40731081e-01f, 1.61351472e-01f, 6.29391223e-02f, 1.55868664e-01f, 7.73230121e-02f, 2.03865036e-01f, 6.07975647e-02f, -2.23188937e-01f,
  -9.05560926e-02f, 1.02776095e-01f, -2.17783004e-01f, -3.89462672e-02f, 1.31548300e-01f, 1.33089766e-01f, -3.56393345e-02f, 8.02397504e-02f, 1.45166457e-01f, 1.91381365e-01f,
  1.40966281e-01f, -2.19163015e-01f, 2.40418866e-01f, 5.81076145e-02f, -5.41601144e-02f, 9.46702138e-02f, 1.82807535e-01f, 1.84693754e-01f, -1.92318961e-01f, -9.85492989e-02f,
  -1.39749035e-01f, 1.85071334e-01f, -1.29424199e-01f, 2.90864348e-01f, 1.17046110e-01f, 1.01388432e-01f, -8.03369284e-02f, -4.33235988e-02f, 3.17180276e-01f, 1.42729342e-01f,
  -7.68218562e-02f, 2.11983919e-01f, -1.05461173e-01f, 1.49886593e-01f, 1.04235023e-01f, -1.56660214e-01f, -1.87185943e-01f, -1.40319735e-01f, -1.92036584e-01f, -4.99936081e-02f,
  -1.36077747e-01f, -4.88413647e-02f, 2.28105724e-01f, 1.94596499e-01f, -4.42441255e-02f, -1.90014273e-01f, 4.78047021e-02f, 2.33941212e-01f, 4.45390008e-02f, 1.74030617e-01f,
  7.72721916e-02f, 8.48799050e-02f, 5.19544631e-02f, 2.09138855e-01f, 8.22696313e-02f, 2.36426413e-01f, 4.32395078e-02f, -7.73065258e-04f, 1.90796647e-02f, -7.59441853e-02f,
  1.71146974e-01f, 1.89681739e-01f, -5.62977120e-02f, -9.36714709e-02f, 1.40657634e-01f, -3.76919098e-02f, -1.51573226e-01f, -1.82120979e-01f, 7.22144619e-02f, -1.38876423e-01f,
  -1.65378600e-01f, -2.59252340e-02f, 1.94128662e-01f, -1.02969818e-02f, 2.33444825e-01f, -1.16874300e-01f, 6.96042702e-02f, 1.35202348e-01f, 2.17031956e-01f, 4.84974496e-02f,
  1.16382077e-01f, 6.19378313e-02f, -2.29050498e-02f, 1.33880973e-01f, -3.13220695e-02f, -7.11248815e-02f, 3.27153921e-01f, 1.09445356e-01f, -3.51166390e-02f, -2.07890034e-01f,
  -1.05784476e-01f, -1.83139503e-01f, 4.63665202e-02f, 7.82464370e-02f, -4.02666405e-02f, -7.73903430e-02f, 6.84460625e-02f, -1.74824610e-01f, 2.50581920e-01f, 2.99992591e-01f,
  8.92267912e-04f, 1.81479052e-01f, 1.42363474e-01f, -1.60180479e-02f, -7.61528462e-02f, -2.56324023e-01f, 9.38318744e-02f, 7.36056492e-02f, -8.96720514e-02f, -1.59195825e-01f,
  -3.70462090e-02f, 1.68262303e-01f, -5.45828566e-02f, 1.03705088e-02f, 1.71204597e-01f, 9.01328251e-02f, 9.99415517e-02f, 1.19028457e-01f, -9.16399509e-02f, -1.17201969e-01f,
  -1.06309146e-01f, -8.31590034e-03f, 1.59411073e-01f, 1.43962175e-01f, -8.36913660e-02f, -2.11329266e-01f, 1.92502439e-02f, -8.22105166e-03f, 7.83342272e-02f, -3.04147732e-02f,
  2.58807361e-01f, 2.47963946e-02f, -5.12434952e-02f, -3.65199931e-02f, 8.90426338e-02f, -2.19575204e-02f, -1.42979726e-01f, -4.84336652e-02f, -8.25172365e-02f, 3.16414759e-02f,
  1.98918954e-01f, 1.45103678e-01f, 3.05107683e-02f, 1.68941200e-01f, 9.45364684e-02f, 1.74836248e-01f, 1.25128210e-01f, -1.08317927e-01f, 3.39314826e-02f, 5.69276251e-02f,
  -1.77355647e-01f, -1.49154872e-01f, 9.23749357e-02f, 2.22728163e-01f, 1.21644102e-01f, 2.38406017e-01f, -8.53049457e-02f, -1.33457473e-02f, 2.12308317e-01f, 8.44749138e-02f,
  1.18021756e-01f, 2.18555823e-01f, -7.10839927e-02f, -1.31975681e-01f, 4.52517644e-02f, -8.36260170e-02f, -9.87824500e-02f, -1.55717451e-02f, 1.86565537e-02f, 5.40972017e-02f,
  -1.68562636e-01f, 1.59362704e-01f, 1.31471485e-01f, 2.25928128e-01f, 1.29775003e-01f, 8.42936430e-03f, 9.27415397e-03f, 1.46362960e-01f, 1.03065930e-01f, -4.02833801e-03f,
  1.29107580e-01f, 6.56355098e-02f, 7.45115103e-03f, 2.69857235e-02f, -4.07797098e-03f, 1.56931192e-01f, 1.65507883e-01f, 1.43384203e-01f, -1.59592062e-01f, -1.75704435e-01f,
  -1.29250839e-01f, -1.22831482e-02f, -1.71661489e-02f, -1.18264966e-01f, 2.76423573e-01f, -3.16920131e-02f, -1.61259875e-01f, 2.89474688e-02f, -1.95730403e-02f, -1.35371521e-01f,
  -6.84925839e-02f, -8.70454386e-02f, 2.88658566e-03f, 1.48373283e-02f, 6.18552305e-02f, 1.58151329e-01f, 6.15265109e-02f, 1.66684896e-01f, 1.50928900e-01f, 1.12202413e-01f,
  -7.19738528e-02f, -1.63969606e-01f, 1.93501189e-01f, 2.35921666e-01f, -1.45712286e-01f, -1.57198980e-01f, 1.69067562e-01f, 1.98646903e-01f, 3.03710476e-02f, 2.43745670e-01f,
  -7.51155391e-02f, -1.80338934e-01f, 2.10826844e-01f, 7.14544430e-02f, -2.96918722e-03f, 2.14740634e-01f, -1.15929648e-01f, -1.32972106e-01f, 2.00511098e-01f, -1.21923767e-01f,
  1.39684141e-01f, 1.97462186e-01f, -3.86238396e-02f, 8.10630098e-02f, -8.25720578e-02f, 3.48769128e-02f, 7.03853741e-02f, 1.51253939e-01f, 2.30480526e-02f, 3.76928076e-02f,
  5.78965507e-02f, 2.52651628e-02f, 1.50381416e-01f, 3.28495391e-02f, 1.72447935e-01f, 1.80296823e-01f, 2.57732533e-02f, -5.62478416e-02f, 3.33534144e-02f, 5.92158511e-02f,
  2.75023445e-03f, 7.41321668e-02f, -2.80903075e-02f, -9.23131779e-02f, 6.22035824e-02f, 2.26082909e-03f, -5.00150062e-02f, 1.12514988e-01f, 5.85380429e-03f, 1.66014075e-01f,
  -7.87512027e-03f, -5.20490743e-02f, 5.53848222e-02f, 2.88315900e-02f, -1.48017019e-01f, 1.23062216e-01f, -1.89535707e-01f, 2.62565464e-02f, 5.64245470e-02f, 1.10847481e-01f,
  1.33064622e-03f, 6.86027631e-02f, -8.06951895e-02f, 9.54404920e-02f, 1.45863235e-01f, -9.36055332e-02f, -7.74036571e-02f, 1.61353014e-02f, -1.32650033e-01f, -5.95209049e-03f,
  1.13916650e-01f, 2.77971085e-02f, 1.41461119e-01f, 1.67289168e-01f, -4.24296129e-03f, 5.52708730e-02f, 1.14121370e-01f, 2.71366332e-02f, 1.20462187e-01f, -9.09194201e-02f,
  -9.42944437e-02f, -5.72789684e-02f, 1.15702696e-01f, -3.97887900e-02f, -5.78501150e-02f, -6.20464003e-03f, 1.14364788e-01f, 1.39879927e-01f, 1.18942633e-02f, -2.71458030e-02f,
  1.83721200e-01f, 2.03934297e-01f, 1.22564666e-01f, 1.90563407e-02f, -2.28036232e-02f, 1.11249372e-01f, 1.18095666e-01f, 9.74067822e-02f, 1.36523768e-01f, 7.74364471e-02f,
  -2.36776993e-02f, 7.46053010e-02f, -3.89528088e-02f, 4.76968999e-04f, 1.99605748e-02f, 8.28296393e-02f, 1.97369128e-01f, 1.07132427e-01f, -1.44975081e-01f, -7.21265003e-02f,
  -1.15365833e-01f, 4.19539303e-01f, -1.58132669e-02f, 7.61483982e-02f, 2.04143226e-01f, 9.00241639e-03f, -1.88051909e-01f, -1.95977733e-01f, 1.06347084e-01f, 3.10721472e-02f,
  -2.56229848e-01f, -1.96738258e-01f, -1.51455253e-01f, 3.87294888e-01f, 4.37389016e-01f, 7.80321881e-02f, 1.90859139e-01f, 1.17509505e-02f, 8.60311538e-02f, -5.56053966e-02f,
  -2.17566520e-01f, -2.95900822e-01f, 9.87184495e-02f, 3.37184429e-01f, 8.81198570e-02f, 9.25051868e-02f, -9.48710814e-02f, 1.20291375e-01f, 1.39014944e-01f, -1.89145580e-01f,
  1.05236463e-01f, -7.79266423e-03f, 1.58185020e-01f, 4.29272987e-02f, -8.87101814e-02f, 1.73694491e-01f, -2.19825786e-02f, 3.94528061e-02f, 2.79155257e-03f, 2.12194845e-01f,
  -2.17458364e-02f, -2.40333676e-01f, 2.72767335e-01f, -2.43115127e-01f, 2.56841362e-01f, -1.09016269e-01f, 9.62723792e-02f, 1.38714444e-02f, -1.50436953e-01f, 5.32962456e-02f,
  1.73195705e-01f, 5.74595891e-02f, 1.12671666e-01f, -4.30091955e-02f, 1.35574892e-01f, 3.57802734e-02f, 1.81703959e-02f, 5.66150062e-02f, 1.08723365e-01f, 9.29848012e-03f,
  -1.82758912e-01f, -5.81151387e-03f, -1.00265443e-02f, -1.62580997e-01f, 7.62336468e-03f, -2.32826173e-01f, 1.49009153e-01f, -2.43528605e-01f, 7.24072456e-02f, -1.13513812e-01f,
  -7.37237856e-02f, 1.27089724e-01f, 2.74386704e-01f, -1.85420454e-01f, 1.89551264e-01f, 1.66793466e-02f, 2.83927500e-01f, -5.44580668e-02f, -1.99230775e-01f, -1.66057989e-01f,
  2.48733342e-01f, 2.85228997e-01f, -7.69507512e-02f, -8.88293907e-02f, 2.95347244e-01f, -1.20658495e-01f, 3.82900126e-02f, 1.48813426e-01f, 9.85562615e-03f, 1.22063436e-01f,
  1.87769234e-01f, -8.45348835e-02f, -7.85956159e-02f, 4.49497625e-02f, 5.78981005e-02f, 4.21614230e-01f, -4.12114710e-02f, 1.74167946e-01f, 6.11743666e-02f, -1.65503442e-01f,
  -1.83631465e-01f, -1.07629351e-01f, 1.72835030e-02f, -1.05952993e-01f, 2.31861672e-03f, 1.06241159e-01f, -2.42155105e-01f, 3.20361823e-01f, -2.46697426e-01f, -1.12437963e-01f,
  -4.34215032e-02f, -1.15306720e-01f, 6.47329539e-02f, 9.72183868e-02f, 2.01477319e-01f, 1.69015184e-01f, 6.96246624e-02f, 1.78309277e-01f, -2.25178599e-02f, 1.97033621e-02f,
  7.52505437e-02f, -2.16991585e-02f, 1.16323620e-01f, 8.32921080e-03f, -1.49603903e-01f, 6.54866770e-02f, 9.18574482e-02f, -8.13027769e-02f, 2.20625624e-01f, 5.00250002e-03f,
  1.63425002e-02f, -1.16264425e-01f, 6.93828659e-03f, 1.76494438e-02f, -1.36026159e-01f, -1.62858754e-01f, -3.98162529e-02f, 1.55513227e-01f, 2.66591102e-01f, -2.51337048e-02f,
  1.31503806e-01f, 1.97309315e-01f, 1.32299006e-01f, 2.73629427e-01f, 2.05348581e-01f, 3.62243131e-02f, -2.31234767e-02f, -1.31406076e-02f, 2.07830742e-02f, 3.10746580e-01f,
  7.50422552e-02f, -1.44141629e-01f, -7.21276030e-02f, 1.99665472e-01f, 9.39339995e-02f, 1.28573388e-01f, 4.93625703e-04f, -5.75141935e-03f, 9.97017920e-02f, 3.51561233e-02f,
  1.10422872e-01f, 2.63803631e-01f, 2.03625426e-01f, 1.13022126e-01f, -4.17907536e-03f, 4.99630943e-02f, 6.03324100e-02f, 4.39305678e-02f, -1.47958770e-01f, -4.12089169e-01f,
  -4.99883145e-02f, 1.94248959e-01f, -2.49722842e-02f, -1.47157818e-01f, -5.41246533e-02f, 2.22198948e-01f, 1.51929975e-01f, 1.16826013e-01f, 2.40263671e-01f, 1.16803020e-01f,
  2.69247681e-01f, 1.35334536e-01f, 2.18000650e-01f, 1.40193641e-01f, 1.97016641e-01f, 8.62361565e-02f, 1.99204654e-01f, 7.87511319e-02f, -3.30658734e-01f, -1.76337548e-02f,
  -1.69025883e-01f, 7.11201057e-02f, -5.23911342e-02f, -1.11582682e-01f, 2.04882175e-01f, -4.72482964e-02f, -7.79077038e-02f, 1.05324006e-02f, -4.91053723e-02f, -1.71534717e-01f,
  6.19304590e-02f, 8.83357152e-02f, -1.68990850e-01f, -3.61708156e-03f, -8.58731270e-02f, 8.80629048e-02f, 8.64116326e-02f, 3.85147296e-02f, 1.31326780e-01f, -6.19118735e-02f,
  -1.34046704e-01f, -6.64777085e-02f, 1.64484814e-01f, 6.49174601e-02f, 7.34987929e-02f, 5.67053817e-02f, 1.19673997e-01f, 2.07963139e-01f, -2.69055963e-02f, 2.01674163e-01f,
  2.85629630e-02f, -2.11349845e-01f, 1.16814952e-02f, 1.19240277e-01f, 7.28888214e-02f, 7.79592395e-02f, -1.12703912e-01f, -2.79337578e-02f, 2.52870172e-01f, 3.10235564e-02f,
  2.35369787e-01f, 2.01530993e-01f, -2.34688260e-02f, 3.67542654e-01f, -2.67944429e-02f, -4.79044020e-02f, 9.05149151e-03f, 1.29396603e-01f, -3.13639678e-02f, -5.56894206e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  8.14953819e-02f, 5.87624460e-02f, 3.99259627e-02f, 1.17481112e-01f, 9.96079668e-02f, 5.61475717e-02f, 1.00911275e-01f, 3.71847488e-02f, 8.83271173e-02f, 4.82299067e-02f,
  8.06963146e-02f, 1.60496697e-01f, 1.83443218e-01f, 4.11037281e-02f, 9.97366980e-02f, 1.91618726e-02f, 4.42632847e-02f, 1.60596520e-01f, 1.35807961e-01f, 2.51683742e-02f,
  1.13925166e-01f, 8.33897740e-02f, 4.35283594e-02f, 1.58901155e-01f, 8.51233117e-03f, 4.23885733e-02f, 5.38231246e-02f, 1.38644338e-01f, 3.93082388e-02f, 1.11208275e-01f,
  1.84057310e-01f, 1.91545352e-01f, 1.38704062e-01f, 6.83148354e-02f, 1.37958661e-01f, 8.72016996e-02f, 1.41135219e-03f, 1.21844292e-01f, 1.77070767e-01f, 1.47184104e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.23892944e-02f, -1.37793636e-02f, 6.93787858e-02f, 4.89960834e-02f, 6.50050119e-02f, -9.60293114e-02f, 5.96357919e-02f, -3.39379087e-02f, 7.64749050e-02f, -7.49336109e-02f,
  1.57267019e-01f, 3.56352739e-02f, -1.32691965e-01f, 3.53497304e-02f, 5.21455109e-02f, 8.33144635e-02f, -7.54403770e-02f, 3.99020826e-03f, -6.70269057e-02f, -1.25475913e-01f,
  -1.17744170e-01f, -3.95456911e-04f, -1.31965429e-02f, -1.21987775e-01f, -1.21784203e-01f, -1.87706891e-02f, -9.04400870e-02f, -5.59209026e-02f, -1.41402766e-01f, -3.58432494e-02f,
  2.64772233e-02f, 2.24454682e-02f, -5.22453375e-02f, 5.33492714e-02f, 2.92997602e-02f, 5.54674454e-02f, 1.14225885e-02f, -8.39052200e-02f, -1.61677241e-01f, 9.66665596e-02f,
  9.76976529e-02f, -1.53558150e-01f, -2.09998507e-02f, -2.43665613e-02f, 1.22532219e-01f, -7.04579661e-03f, 1.37476861e-01f, 7.13232309e-02f, 7.30591938e-02f, -2.86542643e-02f,
  -6.45247195e-03f, 6.97137415e-02f, -1.05138838e-01f, -1.62959415e-02f, -1.10116430e-01f, -5.69659881e-02f, 7.97924399e-02f, -3.47973709e-03f, -1.12104155e-01f, -6.33653030e-02f,
  7.45859295e-02f, 1.56745501e-02f, 1.74364313e-01f, 4.40490544e-02f, -5.22175208e-02f, -3.06049697e-02f, 5.29983826e-02f, -4.67252061e-02f, -1.85652182e-01f, 1.09748043e-01f,
  2.42727976e-02f, -1.11495368e-02f, 4.40710299e-02f, -9.75334179e-03f, 5.20710908e-02f, -1.52795762e-01f, 6.02066703e-02f, -3.65400538e-02f, 5.57309836e-02f, -4.82799001e-02f,
  4.64596786e-02f, -7.02691972e-02f, -1.20911859e-01f, -1.46626517e-01f, 1.82430446e-01f, 1.47602454e-01f, -6.71639219e-02f, -6.20487109e-02f, -4.43999320e-02f, -1.22159328e-02f,
  4.31072479e-03f, 4.88999784e-02f, 1.36990799e-02f, 1.73587531e-01f, 1.02815524e-01f, -9.39593911e-02f, -7.72128999e-02f, -6.13457896e-02f, 1.65648162e-02f, -1.27729952e-01f,
  2.28363499e-02f, -1.50466114e-01f, 1.62471291e-02f, -9.43866298e-02f, -2.74362229e-02f, -5.33106066e-02f, 6.77569434e-02f, 1.77357811e-03f, 1.01004839e-02f, 2.01410979e-01f,
  -5.24571687e-02f, 1.57435834e-01f, -8.67512897e-02f, -1.01537250e-01f, -1.00793190e-01f, -4.07535657e-02f, 1.22456260e-01f, -1.80793703e-01f, 5.20034553e-03f, -2.39684097e-02f,
  6.23518415e-03f, -8.65655467e-02f, -1.23226255e-01f, -1.06139503e-01f, 5.17177209e-02f, -1.87589765e-01f, 6.27662987e-02f, 9.88865048e-02f, 6.47622198e-02f, -8.43762308e-02f,
  -5.99119738e-02f, -3.04783601e-02f, -8.18515487e-04f, -1.06422566e-01f, -6.10907972e-02f, 1.55945256e-01f, -6.06646165e-02f, -4.66299988e-02f, -8.10012072e-02f, -3.90806310e-02f,
  5.47126047e-02f, 5.93590438e-02f, -9.08331648e-02f, -9.72624496e-02f, 7.09229857e-02f, -4.52074111e-02f, -1.13722250e-01f, 2.57671662e-02f, -2.78311763e-02f, 4.48427424e-02f,
  1.42474636e-01f, -1.00737460e-01f, 4.29621041e-02f, -4.27380130e-02f, -1.02260500e-01f, 4.11281586e-02f, 1.44981354e-01f, 8.73356909e-02f, 8.08531567e-02f, -1.85754001e-01f,
  -1.34803057e-01f, 1.48194879e-01f, -8.94118100e-02f, -1.59077913e-01f, 1.13130890e-01f, -3.41260843e-02f, 5.16256243e-02f, 7.88838193e-02f, -1.15354858e-01f, 1.92784637e-01f,
  -4.24460508e-02f, 5.92615362e-03f, -1.22949928e-01f, 2.21801214e-02f, -7.17265205e-03f, -6.43678084e-02f, 2.12426767e-01f, -1.02047093e-01f, 2.03270078e-01f, 7.65174925e-02f,
  1.25908375e-01f, 1.07498229e-01f, -5.65895177e-02f, 5.15238009e-02f, 1.35214729e-02f, 7.66842589e-02f, 2.07135752e-01f, 4.19451967e-02f, 1.33345604e-01f, -9.05053094e-02f,
  2.87196450e-02f, 8.02245885e-02f, -8.64239261e-02f, -1.25390798e-01f, 2.09650505e-04f, -8.78218189e-02f, 9.93523151e-02f, -1.27058953e-01f, -9.50999260e-02f, 1.07091488e-02f,
  -1.33052738e-02f, -3.21364729e-03f, -2.05502789e-02f, -9.34079438e-02f, 8.04243684e-02f, 9.87448916e-02f, -5.52039780e-02f, 2.49306764e-02f, 5.10960035e-02f, -8.35128948e-02f,
  1.07515045e-01f, 7.68929645e-02f, -4.69588041e-02f, 2.57311556e-02f, 8.21944848e-02f, 2.00915355e-02f, 1.68007314e-02f, -2.48208689e-03f, -9.13585187e-04f, 3.78564112e-02f,
  1.21142097e-01f, -1.42812327e-01f, 9.69747640e-03f, -6.57126456e-02f, -2.28254311e-02f, 4.64611687e-03f, -1.07321687e-01f, -3.11091039e-02f, -7.01351911e-02f, 4.51025032e-02f,
  -4.41661961e-02f, 8.16803984e-03f, -1.28719091e-01f, 1.00536853e-01f, -8.78297612e-02f, 3.30283046e-02f, -1.04066618e-01f, -1.17746688e-01f, 3.60370614e-02f, -9.60103869e-02f,
  4.48449403e-02f, 2.23006923e-02f, 9.59011167e-02f, -4.69168648e-02f, -5.38206846e-03f, 1.08968429e-01f, -1.88854039e-01f, -7.73401291e-04f, -1.04366347e-01f, 1.01490922e-01f,
  1.04214445e-01f, 7.48572201e-02f, -3.49392667e-02f, 5.24151884e-02f, -5.73636070e-02f, 7.58644938e-02f, -4.33880743e-03f, 2.55709458e-02f, -3.02906558e-02f, 3.02728247e-02f,
  6.96228519e-02f, -2.34949309e-03f, 5.00216857e-02f, 7.32766837e-02f, -5.09973541e-02f, 8.71717706e-02f, -4.34915423e-02f, 8.68407264e-02f, 1.57791629e-01f, -2.73481943e-02f,
  -9.84944254e-02f, -9.92233381e-02f, 1.12404987e-01f, 1.02646701e-01f, 5.68248108e-02f, 1.88631907e-01f, -4.12785709e-02f, -1.18820883e-01f, 2.04370499e-01f, 9.23288763e-02f,
  7.51744211e-02f, 1.31285042e-01f, 8.05465728e-02f, -1.21432971e-02f, 1.00447640e-01f, -1.11393720e-01f, 3.72659191e-02f, 7.69017786e-02f, 5.98779470e-02f, 2.97393333e-02f,
  1.81277737e-03f, 5.06729856e-02f, 1.27554918e-02f, 3.92676629e-02f, 6.94909617e-02f, 1.00601397e-01f, -5.00476584e-02f, 6.27830997e-02f, 2.26854291e-02f, -3.09943780e-03f,
  1.37336431e-02f, 4.24618609e-02f, -1.18886136e-01f, -5.06194420e-02f, 6.58742636e-02f, -1.07914731e-01f, 8.98959264e-02f, -7.23410305e-03f, 1.13627464e-01f, 9.28659663e-02f,
  -8.05771276e-02f, 1.19603246e-01f, -4.63670678e-03f, 3.41539085e-02f, 4.60831001e-02f, 1.42068654e-01f, -9.98779014e-03f, -1.04078747e-01f, -9.11541283e-02f, -3.44583504e-02f,
  -8.62407461e-02f, -3.49855199e-02f, -6.89788759e-02f, -4.16226387e-02f, 1.54944316e-01f, -2.87468284e-02f, -3.52167594e-03f, 7.88485706e-02f, 6.23273849e-02f, 9.88257751e-02f,
  -1.21822201e-01f, -1.05788466e-02f, -8.26458782e-02f, 1.58915207e-01f, 1.56962052e-01f, -2.71807089e-02f, -1.37686834e-01f, -2.67885923e-01f, -8.06503594e-02f, -3.46732289e-02f,
  -4.00230959e-02f, 8.07600990e-02f, -1.16520934e-01f, 2.57236287e-02f, -9.48204473e-02f, -1.08142219e-01f, -8.31206664e-02f, -8.54476765e-02f, -6.64956644e-02f, 3.65434820e-03f,
  -7.89486691e-02f, -4.69529517e-02f, 1.39597524e-02f, 2.69463882e-02f, -7.47094527e-02f, -8.89403895e-02f, 1.08247273e-01f, 5.30107580e-02f, -1.71653263e-03f, -1.50163502e-01f,
  5.53494021e-02f, 1.10346444e-01f, -2.27822028e-02f, -9.79834422e-02f, -3.51623930e-02f, -2.82242447e-02f, -1.06324412e-01f, 4.05039527e-02f, -2.17101067e-01f, 3.97424214e-02f,
  6.85197487e-02f, -1.09774642e-01f, -1.75559729e-01f, -6.05343916e-02f, 1.35593936e-01f, -2.24668846e-01f, -3.88139091e-03f, -8.27984884e-02f, -8.64532739e-02f, 2.58546341e-02f,
  -3.38806249e-02f, -5.17255478e-02f, -9.75639746e-02f, 1.32997185e-01f, 6.10119849e-02f, 4.32254821e-02f, -2.93838680e-02f, -4.62849475e-02f, 5.74295819e-02f, 1.40297115e-01f,
  -1.49756363e-02f, -2.41105705e-02f, -7.20848963e-02f, -2.40597967e-03f, 8.32105055e-02f, -5.03753051e-02f, -1.19475260e-01f, 6.26161322e-02f, -7.85040110e-02f, 3.25702578e-02f,
  -7.85954818e-02f, -5.62540768e-03f, 1.95038408e-01f, 7.16986954e-02f, -1.99867085e-01f, -1.81541502e-01f, -7.09615042e-03f, 1.40453145e-01f, -4.65339124e-02f, 2.95296907e-02f,
  2.52029169e-02f, 5.35136089e-02f, -1.10568166e-01f, -6.04432859e-02f, -9.82900709e-02f, 1.04095988e-01f, 1.28025576e-01f, 2.41013821e-02f, -1.29568771e-01f, 1.12568371e-01f,
  -5.65813258e-02f, 1.39672011e-01f, -9.98934582e-02f, -4.95085232e-02f, -1.60324752e-01f, -6.18003234e-02f, -6.56129122e-02f, 2.68670116e-02f, 6.26871884e-02f, -1.05870828e-01f,
  1.61707789e-01f, 3.00474502e-02f, 2.96984334e-02f, 1.10429756e-01f, -1.00496516e-01f, 7.13783205e-02f, -2.22235724e-01f, 7.68179446e-02f, -3.66541073e-02f, -1.71928778e-01f,
  -9.92619246e-02f, 1.17936328e-01f, 7.18470514e-02f, -2.19575614e-02f, -1.20314606e-01f, 8.68380144e-02f, -5.82326250e-03f, -3.04199737e-02f, 8.48883167e-02f, 5.45709841e-02f,
  1.00016415e-01f, 6.09572157e-02f, 6.80978447e-02f, 5.55880889e-02f, 2.19368879e-02f, 3.89014669e-02f, -1.02029480e-01f, -4.35952004e-03f, -6.65362319e-03f, -9.45948884e-02f,
  3.75808068e-02f, -1.87684596e-02f, -1.49259105e-01f, -6.77315220e-02f, -4.52127829e-02f, 9.96380672e-02f, 8.53738189e-02f, 2.40452075e-03f, -2.39060055e-02f, -3.72793488e-02f,
  1.41990378e-01f, 1.02985546e-01f, -1.00670457e-01f, 2.27707792e-02f, -5.78669831e-02f, -4.88029085e-02f, -5.83350174e-02f, 6.63951635e-02f, 1.42481342e-01f, -1.26309544e-01f,
  -2.49430053e-02f, -8.67518689e-03f, 4.53436710e-02f, 1.95925739e-02f, -5.73943630e-02f, -1.23435870e-01f, -2.24559177e-02f, 1.85233831e-01f, -6.85477406e-02f, -4.79380749e-02f,
  1.24153972e-01f, 6.50920300e-03f, 5.87209426e-02f, 8.97392929e-02f, 5.68537526e-02f, 1.08816512e-02f, 4.77655530e-02f, -5.43468110e-02f, -2.99184620e-02f, 1.89932100e-02f,
  9.01726708e-02f, -3.49863023e-02f, -1.80359825e-01f, 1.94428682e-01f, 2.59039421e-02f, -6.65920302e-02f, 5.93233183e-02f, -1.32385880e-01f, -9.21309963e-02f, 4.42431867e-02f,
  1.53435841e-01f, -4.59639132e-02f, -1.73548423e-02f, -5.13818450e-02f, 6.99114129e-02f, -3.76591533e-02f, 8.91451165e-03f, -4.73198257e-02f, -1.84917092e-01f, 3.82487923e-02f,
  -6.48861676e-02f, -9.38472971e-02f, 1.40607908e-01f, 1.67386234e-02f, 4.76295594e-03f, -5.62428124e-02f, -1.12744160e-01f, -6.40719458e-02f, 1.04854822e-01f, 1.71775892e-01f,
  -1.42881259e-01f, -3.16838659e-02f, 3.92509624e-02f, 1.50804268e-02f, 1.24842577e-01f, -2.39902716e-02f, 1.21966600e-02f, -6.21903501e-02f, 4.50896807e-02f, 1.80276912e-02f,
  5.99089786e-02f, 7.92671293e-02f, 1.37813389e-01f, -1.54607967e-01f, -8.54409784e-02f, 9.27014742e-03f, -4.22010459e-02f, -9.95939299e-02f, -5.69905005e-02f, -1.06416538e-01f,
  3.27044651e-02f, 8.68346989e-02f, -3.39046167e-03f, 1.17390919e-02f, 2.19861809e-02f, 5.57697285e-03f, -1.42571121e-01f, -3.48002091e-02f, 3.20824385e-02f, -6.62832633e-02f,
  4.37977836e-02f, -8.20391253e-02f, -8.51896033e-02f, -4.53507877e-04f, 9.92871821e-02f, 3.04476488e-02f, -5.39648309e-02f, 1.29091874e-01f, 1.83883961e-02f, -1.97285553e-03f,
  -3.18903960e-02f, -1.52533995e-02f, 2.21795365e-01f, -1.20203570e-02f, 8.10629129e-02f, -4.64691855e-02f, -7.02450052e-02f, -3.82878147e-02f, 4.06777710e-02f, -2.47158483e-02f,
  4.92811278e-02f, -6.54036030e-02f, -4.15054597e-02f, -6.33302331e-02f, -3.41659263e-02f, 2.00856868e-02f, -1.88080654e-01f, -4.49858941e-02f, 1.70909777e-01f, -8.90843347e-02f,
  -4.61621862e-03f, -4.96773981e-02f, 8.94548967e-02f, 3.36066484e-02f, 1.61989406e-02f, 1.12065226e-01f, 1.94550194e-02f, 8.91826451e-02f, 4.76507619e-02f, -8.43280926e-02f,
  1.57787371e-02f, 1.29702345e-01f, 3.90198291e-03f, 1.21798215e-03f, -3.61480303e-02f, -6.64161742e-02f, -1.70578286e-01f, -6.49882946e-03f, 6.98260218e-02f, 1.21320441e-01f,
  -4.79401350e-02f, -1.35474309e-01f, 2.14242134e-02f, 1.16795883e-01f, -2.51821242e-02f, -1.43839225e-01f, -7.78831765e-02f, 1.20966554e-01f, -1.29604071e-01f, 2.72384305e-02f,
  -1.08466245e-01f, 8.08093026e-02f, -1.54539317e-01f, -1.49962232e-01f, 8.35024044e-02f, -3.07138655e-02f, 9.08173770e-02f, 2.38899216e-02f, -1.45763174e-01f, -4.39856425e-02f,
  4.97421473e-02f, 5.00654131e-02f, -9.96504799e-02f, 1.21828370e-01f, 9.70508531e-02f, 1.94548164e-02f, 3.53249945e-02f, -1.50739616e-02f, -7.11853150e-03f, -3.73610365e-03f,
  -1.20695136e-01f, 6.46050349e-02f, 2.80876402e-02f, -9.60720703e-02f, -7.86538646e-02f, 4.46145386e-02f, 1.52475853e-02f, -2.68170368e-02f, -9.35531557e-02f, -1.03468820e-01f,
  -5.83439060e-02f, -1.12975471e-01f, 9.78016108e-02f, -9.39600915e-02f, -2.89123449e-02f, 4.84657213e-02f, 4.74905558e-02f, -2.36517638e-02f, 4.04328667e-02f, 6.92782633e-04f,
  -1.59493610e-02f, -1.59282669e-01f, -1.30586296e-01f, 1.15318075e-01f, 1.38606548e-01f, 2.11391956e-01f, -1.03457915e-02f, -8.24612901e-02f, -8.97679776e-02f, 5.36236055e-02f,
  -3.40445936e-02f, 1.24573000e-01f, 3.65433805e-02f, 9.21904147e-02f, -4.58657071e-02f, 4.82048392e-02f, 1.04345180e-01f, 9.42690745e-02f, 4.02375981e-02f, 3.01065855e-02f,
  -9.60158743e-03f, -1.00765608e-01f, 6.51226006e-03f, 2.02159584e-02f, 9.99003723e-02f, 2.10878644e-02f, 1.26715586e-01f, 7.50241503e-02f, 2.17600651e-02f, -3.09270248e-02f,
  -1.51234180e-01f, -1.76439837e-01f, -4.76634279e-02f, -4.83818427e-02f, -9.25859585e-02f, 5.54764457e-03f, 6.51271790e-02f, -7.70806218e-04f, -1.01327926e-01f, 6.86148852e-02f,
  -1.84071973e-01f, 2.76728403e-02f, 9.00090337e-02f, -6.94871098e-02f, 5.15838750e-02f, -6.50282130e-02f, -1.78851429e-02f, 3.64480652e-02f, -5.94017170e-02f, -9.52266604e-02f,
  1.93919279e-02f, 1.43500436e-02f, 5.00204973e-02f, -8.76112804e-02f, 4.10554856e-02f, 2.99443323e-02f, -1.40717283e-01f, -2.79878639e-02f, 2.29372717e-02f, 5.46367951e-02f,
  -1.57879591e-01f, -5.79341426e-02f, -1.15351632e-01f, -7.22199585e-03f, -1.67453423e-01f, 6.87146559e-02f, -6.55702949e-02f, -2.04538703e-01f, -1.73721120e-01f, -1.58123210e-01f,
  -1.51377901e-01f, 2.47444101e-02f, -8.34365040e-02f, -3.73163894e-02f, -7.13686869e-02f, 6.15703426e-02f, -1.16358325e-01f, -5.20435534e-02f, -1.25964940e-01f, 1.17671035e-01f,
  -1.95555612e-02f, -1.60560831e-01f, -1.15361325e-01f, -9.23109148e-03f, 7.02509806e-02f, -7.53587186e-02f, -2.43077800e-02f, -1.29435375e-01f, -8.44016373e-02f, -8.60099941e-02f,
  -8.49787965e-02f, -8.50571990e-02f, 4.58136052e-02f, 1.49993002e-01f, -1.38985990e-02f, 6.31986633e-02f, -9.13305804e-02f, -2.21115630e-02f, 5.33309057e-02f, 3.01860329e-02f,
  9.01637226e-02f, 3.78887318e-02f, -2.62452886e-02f, -1.92425027e-02f, 8.45725462e-02f, 1.70525730e-01f, 5.02613410e-02f, 6.13424480e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.39364928e-01f, 1.07464828e-01f, 1.81310266e-01f, 2.47863621e-01f, 1.72639236e-01f, 6.02825433e-02f, 2.99091712e-02f, 2.28229716e-01f, 1.42551392e-01f, 1.57491222e-01f,
  1.68049932e-01f, 8.67703408e-02f, 6.98454455e-02f, 1.84280276e-01f, 5.22847064e-02f, -7.30675831e-02f, -4.48875129e-02f, -1.51206940e-01f, -1.27660573e-01f, -1.29210651e-01f,
  5.95721267e-02f, 1.28521189e-01f, 2.19043404e-01f, -4.46111411e-02f, -9.15077031e-02f, -1.96010228e-02f, -2.16134876e-01f, 2.66418338e-01f, 2.20388860e-01f, 1.55408755e-01f,
  2.68962774e-02f, -2.26496130e-01f, -2.83243656e-01f, 1.47746041e-01f, -8.06513429e-02f, -4.31513861e-02f, -1.56042408e-02f, -1.13925971e-01f, 4.68182378e-02f, -2.63810270e-02f,
  8.89972597e-02f, 1.46860376e-01f, -5.84743842e-02f, -7.59734139e-02f, 8.14213976e-02f, 4.43749279e-02f, -2.53569394e-01f, -6.70007914e-02f, 2.30570003e-01f, -1.66266914e-02f,
  9.70763713e-02f, 9.18191299e-02f, 8.31084996e-02f, 5.25191128e-02f, 4.94876802e-02f, 2.13984445e-01f, -6.03329316e-02f, 1.06191903e-01f, 3.41481358e-01f, -4.01220061e-02f,
  2.44460434e-01f, 9.90154222e-02f, 1.71923414e-01f, 3.08992654e-01f, 1.93477213e-01f, 9.39204320e-02f, 1.92372799e-01f, 1.64349988e-01f, 1.30396321e-01f, 4.73571829e-02f,
  -1.46735124e-02f, -2.84229335e-03f, 1.10880218e-01f, -2.67646015e-02f, 1.73334420e-01f, 4.34473231e-02f, -3.61658037e-02f, -1.07012540e-01f, 1.03077576e-01f, 6.54134899e-02f,
  1.11541167e-01f, 1.84416607e-01f, 2.96237543e-02f, 6.65822029e-02f, 8.09058771e-02f, -1.67280436e-01f, -1.01754330e-01f, 1.00755639e-01f, 1.65643439e-01f, 1.29168078e-01f,
  2.21487433e-01f, 1.30333990e-01f, -7.49640465e-02f, 1.52295679e-01f, 1.29959375e-01f, 1.07376970e-01f, 2.23713875e-01f, -5.43307252e-02f, 2.65089512e-01f, 2.67266572e-01f,
  1.95942625e-01f, 4.96806167e-02f, 2.48183385e-01f, 2.56028056e-01f, 1.36266723e-01f, -1.48556173e-01f, 2.92363167e-01f, 9.99685228e-02f, 1.61395207e-01f, 1.75100639e-01f,
  4.28777710e-02f, 2.06919476e-01f, -1.43029585e-01f, -1.62498221e-01f, -9.95200798e-02f, -1.26349991e-02f, 1.01520978e-01f, 1.18309550e-01f, 2.12948546e-01f, 7.73682445e-02f,
  1.70741841e-01f, -1.04881853e-01f, -1.77740708e-01f, 6.16087429e-02f, -1.84342936e-02f, -3.14593129e-02f, 5.12236468e-02f, -1.14742279e-01f, -1.41655967e-01f, -1.37129918e-01f,
  -1.25535160e-01f, -1.99703962e-01f, -1.60678968e-01f, -5.80542861e-03f, 8.62878710e-02f, -1.96708545e-01f, -8.56503397e-02f, -2.28712901e-01f, -8.41570273e-02f, -1.80879712e-01f,
  3.71396653e-02f, -1.04297757e-01f, -8.42188820e-02f, 6.12276644e-02f, 1.16549298e-01f, 1.05821133e-01f, 8.11360478e-02f, 1.01752006e-01f, -5.15994579e-02f, -1.14722632e-01f,
  -4.74559404e-02f, 1.54778466e-01f, 2.45187193e-01f, 1.49998575e-01f, 2.74023443e-01f, -3.46882045e-02f, 1.50617557e-02f, 1.67973917e-02f, 1.11340493e-01f, 1.51628286e-01f,
  2.96139300e-01f, -4.29953821e-02f, 1.92217961e-01f, 8.88716280e-02f, 4.36398946e-02f, 1.78613886e-01f, 1.20299757e-01f, 2.59014368e-01f, -1.03429846e-01f, -1.39209673e-01f,
  1.42184809e-01f, 2.16774210e-01f, 6.81529343e-02f, 9.49770510e-02f, 2.51307636e-01f, 5.11695221e-02f, 7.24525005e-02f, -1.35682989e-02f, -1.00807898e-01f, -1.43401727e-01f,
  3.81631553e-02f, 1.28490895e-01f, -4.34070565e-02f, -9.04547647e-02f, 1.03385463e-01f, 8.10621902e-02f, -1.56270087e-01f, 1.03226572e-01f, -1.08372472e-01f, 6.28923997e-02f,
  -2.03356296e-02f, -2.00211748e-01f, -3.34212109e-02f, -8.91745090e-02f, 4.62098327e-03f, 2.09239703e-02f, 1.95839107e-02f, -9.05450284e-02f, -1.25796288e-01f, 4.01523001e-02f,
  -2.68955361e-02f, -1.21779814e-01f, -2.73126699e-02f, -1.38015077e-01f, 1.30239353e-01f, -6.11569323e-02f, -1.49776354e-01f, -1.85485691e-01f, 2.14298472e-01f, 1.25873893e-01f,
  -2.25373700e-01f, -1.89446613e-01f, 1.29867047e-01f, -9.37704090e-03f, 2.76675373e-01f, -2.88766231e-02f, 1.17534526e-01f, -4.40083932e-05f, -2.22363863e-02f, 2.71780014e-01f,
  1.32228076e-01f, 1.94991797e-01f, 2.85832375e-01f, -2.71117836e-01f, -1.19577810e-01f, 1.96567729e-01f, 1.93152323e-01f, -6.79591447e-02f, 9.69018787e-02f, -9.48543325e-02f,
  1.03440866e-01f, 2.32434660e-01f, 7.69703016e-02f, 3.62670273e-02f, 2.11450756e-01f, 2.67653726e-02f, -1.07259572e-01f, 1.35091797e-01f, -5.08076251e-02f, 7.78584927e-02f,
  2.43232056e-01f, -2.13952348e-01f, 1.24574257e-02f, 1.74213317e-03f, 3.19044709e-01f, -5.64959571e-02f, -1.57979563e-01f, 2.70590454e-01f, 2.17333198e-01f, -1.85380299e-02f,
  5.20929620e-02f, 1.10931627e-01f, 3.54878604e-01f, -2.10684806e-01f, 1.70566589e-01f, -8.22931975e-02f, 2.54769400e-02f, 4.68305387e-02f, 3.29882763e-02f, -2.42206804e-03f,
  3.85651439e-02f, 7.87855312e-02f, 7.54113868e-02f, 8.24030414e-02f, 9.10368562e-02f, 9.98977721e-02f, -1.20364413e-01f, -6.44036010e-03f, 1.45245209e-01f, 4.49104868e-02f,
  1.05187245e-01f, -2.35468410e-02f, 1.24916777e-01f, -1.17961518e-01f, 7.16703907e-02f, 1.05095148e-01f, -1.40991330e-01f, -1.83346495e-01f, 1.02776155e-01f, 1.68698937e-01f,
  9.39854980e-02f, 2.40001693e-01f, -7.12563172e-02f, 1.70014068e-01f, 4.93785143e-02f, -4.05484475e-02f, -1.94010958e-01f, 2.52793819e-01f, 1.18620209e-01f, 2.68361837e-01f,
  -8.36987272e-02f, 9.32498872e-02f, 2.40436837e-01f, 1.58399761e-01f, 3.42572480e-02f, -8.96705166e-02f, -4.99091931e-02f, 1.94801688e-01f, -8.34084898e-02f, -7.29298219e-03f,
  -4.45859432e-02f, 1.10294521e-01f, -2.31624246e-01f, -1.40451908e-01f, 4.97619202e-03f, -4.00965810e-02f, 2.34125942e-01f, -1.32608801e-01f, -6.89695179e-02f, 1.35645613e-01f,
  1.45559376e-02f, -6.70973361e-02f, -3.19799066e-01f, 1.87812388e-01f, 5.00540324e-02f, 1.42875448e-01f, -9.88768637e-02f, -3.07204202e-02f, 6.37986585e-02f, 1.38248742e-01f,
  7.28177801e-02f, 6.94325864e-02f, 2.34419890e-02f, 7.95677081e-02f, 1.78259194e-01f, 2.65736021e-02f, 3.76823992e-02f, 1.06967546e-01f, 1.19803190e-01f, 1.66173920e-01f,
  -8.79147798e-02f, 9.37814917e-03f, 8.63626450e-02f, 1.14538018e-02f, -1.83011778e-02f, -2.82432064e-02f, 1.67483136e-01f, -3.60713117e-02f, -2.59928238e-02f, 1.38394728e-01f,
  8.57436657e-02f, 4.85180877e-02f, 1.33608595e-01f, 6.39938787e-02f, 1.59949824e-01f, 1.90511256e-01f, 8.95809382e-02f, 1.61896423e-01f, 2.62394458e-01f, 5.20900600e-02f,
  -8.79506245e-02f, -1.16939675e-02f, 2.77098976e-02f, 1.69100419e-01f, -4.18158136e-02f, -9.06570703e-02f, 1.57164320e-01f, 7.16292411e-02f, 2.43068650e-01f, -8.83740708e-02f,
  5.03602773e-02f, 2.15202436e-01f, -2.55150925e-02f, 2.71453485e-02f, -6.70962259e-02f, 1.82400599e-01f, -1.99085340e-01f, -9.74122807e-02f, 1.35406971e-01f, -8.04286674e-02f,
  1.98945433e-01f, 5.79364412e-02f, 1.16441116e-01f, 9.25528333e-02f, 1.19941384e-01f, 5.74315637e-02f, -2.08300695e-01f, 1.70180202e-01f, 1.18681990e-01f, 2.26763174e-01f,
  1.36350870e-01f, -1.40424192e-01f, 6.60572946e-02f, 1.01545103e-01f, -6.46176777e-05f, 3.25345248e-02f, 3.32443267e-02f, -3.89786027e-02f, 7.35885883e-03f, 4.04293798e-02f,
  -3.22152562e-02f, -5.71624078e-02f, -5.93348267e-03f, -2.36819964e-02f, 1.71566778e-03f, 7.78229535e-02f, 6.07534759e-02f, 5.64838052e-02f, -1.66257113e-01f, 7.47554749e-02f,
  -8.59769061e-02f, -5.94721511e-02f, 6.20901585e-02f, -7.34207854e-02f, -1.15711153e-01f, 1.36490003e-03f, 1.31065980e-01f, -4.19196002e-02f, -1.34337610e-02f, 2.79316120e-02f,
  1.05038397e-01f, 1.09206997e-02f, 2.37642467e-01f, -1.62792236e-01f, -1.57554314e-01f, -2.77945567e-02f, 5.18335924e-02f, -3.69741209e-02f, -1.02388330e-01f, -1.50499968e-02f,
  -5.85932694e-02f, 6.18288331e-02f, -7.32395798e-02f, -1.56343579e-01f, -1.00306951e-01f, 6.94838315e-02f, -1.69147372e-01f, 7.87131861e-02f, 1.65484436e-02f, -2.22056448e-01f,
  1.69713929e-01f, 2.73040291e-02f, 1.86742842e-01f, 1.39464051e-01f, 1.21166073e-01f, 2.25914642e-02f, -3.75474319e-02f, 4.34618555e-02f, -2.16056883e-01f, -2.13758335e-01f,
  -7.90223107e-02f, 2.41463840e-01f, 2.23914862e-01f, 1.14338562e-01f, 1.24392755e-01f, 3.21924277e-02f, 1.65340081e-01f, 2.56321654e-02f, -2.46125255e-02f, -2.77224071e-02f,
  -7.76733831e-02f, -1.84396386e-01f, -8.23449939e-02f, 9.63805523e-03f, 1.08731359e-01f, 1.12361550e-01f, 9.72505808e-02f, 5.98664433e-02f, -1.74536765e-01f, -9.79913101e-02f,
  2.12905630e-01f, -1.46221355e-01f, 2.68312655e-02f, -1.36251122e-01f, 2.55719602e-01f, 7.13997483e-02f, 1.59379601e-01f, 1.04950018e-01f, 6.02828003e-02f, -8.16665739e-02f,
  1.18057117e-01f, 2.38556206e-01f, 1.06237017e-01f, 3.22130084e-01f, 8.90050307e-02f, -2.42049638e-02f, -4.47783731e-02f, 1.32266786e-02f, -1.05184451e-01f, 3.66439968e-02f,
  2.19002709e-01f, 2.16983095e-01f, -7.95272589e-02f, -7.36640394e-02f, 1.26562119e-01f, 1.52643785e-01f, 1.95044011e-01f, 3.27087194e-02f, -2.29212046e-01f, 1.76775157e-02f,
  3.89595777e-02f, 1.46034122e-01f, -1.35493219e-01f, 2.56275594e-01f, -1.25691012e-01f, -6.91875294e-02f, 1.12213373e-01f, -8.38727057e-02f, -4.84980680e-02f, -2.62731284e-01f,
  -1.63236596e-02f, -6.21295010e-04f, -6.93323612e-02f, 1.26653433e-01f, -1.11932538e-01f, 9.17396247e-02f, 5.39874163e-05f, 1.54575095e-01f, -2.68140137e-01f, -1.74476042e-01f,
  5.24167456e-02f, -6.24968559e-02f, -4.22060490e-02f, 8.37122574e-02f, 2.97598056e-02f, -8.25041963e-04f, -1.37801217e-02f, 3.85985076e-02f, 1.50420412e-01f, -1.29611745e-01f,
  1.22733563e-01f, 9.87867936e-02f, 1.63264927e-02f, 3.20967771e-02f, -1.21224876e-02f, -1.38048679e-02f, 1.32783756e-01f, 4.85763401e-02f, 1.18412457e-01f, -5.73330447e-02f,
  9.39334780e-02f, 1.56850114e-01f, 5.41477790e-03f, -5.13714962e-02f, -1.81506082e-01f, 1.27659768e-01f, 1.50612742e-01f, 1.85597256e-01f, 1.55069798e-01f, 4.00911048e-02f,
  -5.52033558e-02f, 1.40659392e-01f, -5.93929924e-02f, 2.50346720e-01f, 1.99385867e-01f, 7.54845291e-02f, 9.95401591e-02f, 6.31177351e-02f, 2.60276258e-01f, 1.96693555e-01f,
  9.50383395e-02f, -6.12637540e-03f, 3.97885069e-02f, 5.63865826e-02f, 6.04460016e-02f, 8.84520635e-02f, 1.02024227e-01f, 2.46811405e-01f, -7.88778998e-03f, 1.34950906e-01f,
  -1.33910075e-01f, -3.87968048e-02f, 4.52000760e-02f, -1.22452699e-01f, -7.76882917e-02f, 1.23267872e-02f, 2.50257820e-01f, -7.90333375e-02f, -4.07569483e-02f, 4.22936454e-02f,
  -4.29231636e-02f, 8.05902630e-02f, -2.62195259e-01f, -5.06836437e-02f, -6.45335987e-02f, 9.32849273e-02f, 9.22659319e-03f, -7.66210333e-02f, 1.34638138e-02f, 2.19235737e-02f,
  -9.41950455e-02f, 2.27181125e-03f, -3.96237746e-02f, -5.45733981e-02f, -2.24019550e-02f, 3.10269557e-02f, -7.27691203e-02f, 2.08878107e-02f, 4.72961590e-02f, 6.46187961e-02f,
  -7.72707090e-02f, 5.15832715e-02f, 1.31613889e-03f, 4.96641174e-03f, 5.69634624e-02f, 1.62910923e-01f, -6.42348528e-02f, 6.42189234e-02f, 8.70321915e-02f, -9.76681858e-02f,
  -6.61211759e-02f, -2.95456350e-02f, -3.70886107e-03f, -5.73640019e-02f, 1.92733362e-01f, -1.60417303e-01f, -1.01006873e-01f, -6.46686703e-02f, 1.44321769e-02f, -1.18852980e-01f,
  -1.73557222e-01f, 1.17056862e-01f, -3.74065004e-02f, 6.90412242e-03f, -7.32569024e-02f, -8.27717930e-02f, -1.14681527e-01f, 1.29167616e-01f, -1.07835002e-01f, 5.36674587e-03f,
  -6.00774959e-02f, -1.78859025e-01f, 2.02377200e-01f, -1.12810500e-01f, 1.58949673e-01f, 2.09903136e-01f, 1.69633001e-01f, 6.45863861e-02f, -1.35868609e-01f, 9.39215794e-02f,
  -2.09110230e-02f, -7.57345036e-02f, -1.64544970e-01f, 9.01006162e-02f, 1.91972390e-01f, 2.20507924e-02f, -2.54179053e-02f, 2.22351238e-01f, 2.21196283e-02f, 8.59802365e-02f,
  1.59023285e-01f, 1.74216270e-01f, 1.40890196e-01f, 2.25623623e-01f, 2.25104481e-01f, 1.07837595e-01f, 2.82433834e-02f, 2.08799675e-01f, 2.08274052e-01f, 1.99089482e-01f,
  1.52364120e-01f, 1.91625834e-01f, -2.92133149e-02f, 7.33451173e-02f, 1.45211056e-01f, 7.01230094e-02f, -1.27707087e-02f, -9.08100754e-02f, -8.09133500e-02f, 9.51809213e-02f,
  -2.46403571e-02f, 2.27372050e-02f, 3.07419617e-02f, -4.82302904e-02f, -7.81078115e-02f, 4.08946304e-03f, -7.11763576e-02f, 1.56439722e-01f, 1.00748613e-01f, 3.75393927e-02f,
  -4.95060198e-02f, 1.04700722e-01f, -1.33540198e-01f, 1.37054995e-01f, 6.96340203e-02f, 6.51075020e-02f, 1.45887524e-01f, -9.19376500e-03f, 2.41059549e-02f, -1.35755032e-01f,
  1.59904420e-01f, 2.00762734e-01f, 4.85783517e-02f, -1.45513922e-01f, 8.68486091e-02f, 5.20191416e-02f, -2.75880635e-01f, -3.60492840e-02f, -1.45594114e-02f, -1.65940076e-03f,
  1.52688339e-01f, 1.32870272e-01f, 5.18066995e-02f, 1.72827974e-01f, 1.62668064e-01f, 1.55305967e-01f, -1.65299058e-01f, 4.03998885e-03f, 1.49183810e-01f, 5.69025502e-02f,
  1.44027010e-01f, 7.77908340e-02f, 5.08738980e-02f, 2.87207574e-01f, -2.15472504e-01f, -9.82964970e-03f, -2.64316928e-02f, -1.41450120e-02f, -1.13227069e-01f, -8.64266381e-02f,
  5.36004938e-02f, -1.97876275e-01f, -1.48642175e-02f, 8.25286061e-02f, -1.78011343e-01f, -1.26382232e-01f, -4.71649878e-02f, 4.93484996e-02f, 1.07791044e-01f, 1.41279986e-02f,
  1.22084491e-01f, -2.64687419e-01f, -5.09225130e-02f, -1.15199544e-01f, 1.17717832e-01f, 1.55340537e-01f, -5.57279252e-02f, 4.77794707e-02f, 1.03629760e-01f, 2.33555026e-02f,
  -4.15529637e-03f, 1.00580402e-01f, -1.79162353e-01f, 3.29400688e-01f, -2.98574492e-02f, -1.31309703e-01f, 1.16983443e-01f, 1.49816781e-01f, 3.66562307e-02f, -1.42185926e-01f,
  3.51171941e-01f, 9.25596133e-02f, 7.59026930e-02f, -1.01828314e-01f, -2.22654478e-03f, 2.23773003e-01f, -9.10828486e-02f, 1.28795803e-01f, 9.14750844e-02f, 4.10169363e-01f,
  1.02846466e-01f, 2.00587139e-01f, -1.93049714e-01f, 2.28221621e-03f, 2.02132285e-01f, -1.66408166e-01f, -2.17897862e-01f, -1.84128314e-01f, 1.46558747e-01f, -2.64097542e-01f,
  1.95155025e-01f, -9.73906666e-02f, -1.92966741e-02f, -7.31957778e-02f, -2.27964312e-01f, -2.48697907e-01f, 7.89313316e-02f, 4.38826457e-02f, 5.73809296e-02f, 6.70941919e-02f,
  5.40661532e-03f, 1.04160637e-01f, 3.02907154e-02f, 5.28943278e-02f, 1.45058781e-01f, -4.20357846e-02f, 3.14825475e-02f, 6.28555641e-02f, -4.95023578e-02f, 1.80796664e-02f,
  3.58653590e-02f, -5.06331632e-03f, 9.67444852e-03f, -1.19432665e-01f, 1.57505617e-01f, -5.91395535e-02f, 2.14019999e-01f, 6.43346310e-02f, 2.04872829e-03f, -9.76158381e-02f,
  2.89130900e-02f, 1.40665874e-01f, 2.60835011e-02f, 2.36757591e-01f, -5.02469465e-02f, 7.31520578e-02f, -4.77810437e-03f, -1.55554982e-04f, 6.32785261e-02f, 8.00352842e-02f,
  6.58969879e-02f, 1.12082802e-01f, 3.47263366e-02f, 5.51019795e-02f, 1.31141916e-01f, 1.42584452e-02f, -1.99702960e-02f, 1.60950929e-01f, -1.15930863e-01f, -3.70929204e-02f,
  9.93318856e-02f, 1.30977025e-02f, 5.57354353e-02f, 2.00494826e-01f, 1.77776203e-01f, 5.12883067e-02f, -2.89363153e-02f, 1.03713483e-01f, 7.23028835e-03f, -1.83014259e-01f,
  -5.50603233e-02f, -3.31857614e-02f, -1.05945617e-01f, 1.41840085e-01f, -1.37123950e-02f, -5.75622730e-03f, -6.32217973e-02f, -6.77721621e-03f, -3.12147617e-01f, 1.67275876e-01f,
  9.91999283e-02f, 2.81141549e-02f, -6.24035895e-02f, -3.20852920e-02f, 2.49549523e-02f, -7.35791633e-03f, -3.24558234e-03f, 9.27739963e-03f, -9.49806720e-02f, -1.17415093e-01f,
  -2.46006753e-02f, -6.64368421e-02f, 1.13093637e-01f, -1.28189981e-01f, 8.54427814e-02f, 1.70990489e-02f, -2.04922352e-02f, -3.58510464e-02f, 7.55444765e-02f, -6.20087869e-02f,
  6.55099079e-02f, -1.15399919e-01f, 1.39529109e-01f, 2.67413612e-02f, -3.61364223e-02f, 1.23523086e-01f, 1.17637120e-01f, 1.18332580e-01f, 2.19539762e-01f, 5.16268760e-02f,
  2.02098805e-02f, 2.99189597e-01f, 1.31743252e-01f, -1.40526623e-01f, 9.11670178e-02f, -1.90082416e-02f, 1.97709560e-01f, 9.72974394e-03f, 1.39292434e-01f, 6.96841534e-03f,
  1.95021570e-01f, 1.11043051e-01f, -4.52950550e-03f, -5.78579716e-02f, 7.22115338e-02f, 1.94216713e-01f, 1.55988291e-01f, 2.24951193e-01f, 2.47819424e-01f, 2.67722070e-01f,
  1.62076261e-02f, -8.28692913e-02f, -6.05165176e-02f, -1.74859479e-01f, 1.50724828e-01f, -5.29747605e-02f, -2.67380700e-02f, -1.80909172e-01f, 2.04379573e-01f, -4.73477170e-02f,
  8.45561561e-04f, 1.83582841e-03f, -4.62632552e-02f, -6.91440850e-02f, 2.37519994e-01f, -1.29532844e-01f, -7.10670054e-02f, 6.41582087e-02f, 1.64745241e-01f, 5.27570471e-02f,
  1.29511133e-01f, 1.47638330e-02f, -1.01592951e-02f, 2.73943096e-02f, 1.28943518e-01f, 7.16689825e-02f, -6.74290136e-02f, -7.78920725e-02f, -8.49661510e-03f, 1.05130263e-01f,
  1.09584965e-01f, -1.25261158e-01f, 1.63358867e-01f, -2.46074274e-01f, -1.56692326e-01f, -2.10611641e-01f, 2.49584932e-02f, 8.69732350e-02f, 4.04229313e-02f, 3.01194564e-02f,
  7.17475638e-02f, -5.84784709e-02f, -1.98537394e-01f, 1.19782098e-01f, -6.23835698e-02f, 3.36021453e-01f, 3.92423421e-02f, -1.71063244e-01f, -8.88949707e-02f, 1.71885952e-01f,
  1.74415544e-01f, -1.59086257e-01f, 3.51437896e-01f, -6.15539849e-02f, 4.94876585e-04f, -4.33842326e-03f, 6.54012337e-02f, 1.70532465e-01f, 1.55268032e-02f, -4.12569866e-02f,
  1.45306110e-01f, 2.81411976e-01f, -6.58122823e-02f, 2.80723006e-01f, -9.75511409e-03f, -1.10967398e-01f, 2.24433452e-01f, -3.94460782e-02f, 1.85279902e-02f, -8.27123225e-02f,
  1.71384722e-01f, 2.86991522e-02f, 1.64995596e-01f, -7.01832846e-02f, 9.78015438e-02f, -6.57486841e-02f, 1.47010878e-01f, -1.87768579e-01f, 2.72022009e-01f, 1.96395770e-01f,
  1.69490557e-02f, -2.00123880e-02f, 2.75415443e-02f, 3.39169055e-02f, 2.29573064e-02f, 2.52992790e-02f, -3.31636844e-03f, 3.33710685e-02f, -8.97609070e-03f, 4.76409830e-02f,
  5.20604886e-02f, 1.01420581e-01f, 8.31317753e-02f, 6.85845464e-02f, -1.63130283e-01f, 2.50965394e-02f, -1.06055729e-01f, -1.49305295e-02f, 6.72100708e-02f, -2.46220063e-02f,
  -7.98301697e-02f, 9.43287835e-03f, 1.75594375e-01f, -9.59470402e-03f, -7.73043633e-02f, 4.40032668e-02f, 2.86245830e-02f, 5.37310690e-02f, 1.99882656e-01f, -1.28555745e-01f,
  -6.15218095e-02f, -3.34328949e-03f, -3.61227803e-02f, -2.04148516e-02f, -7.96460882e-02f, 6.91347755e-03f, -9.05080810e-02f, 6.18743114e-02f, -1.25776129e-02f, -2.13489737e-02f,
  -1.30270794e-01f, -2.50187218e-02f, -8.68883505e-02f, 4.50994931e-02f, 2.27908790e-02f, -1.65605724e-01f, 1.12521738e-01f, -5.50554991e-02f, 2.09432647e-01f, 1.05978876e-01f,
  2.29633003e-02f, 9.87693146e-02f, -2.39705276e-02f, 1.99237838e-01f, -1.80659965e-01f, 5.31593822e-02f, -7.48600662e-02f, 2.10916653e-01f, 2.24668920e-01f, 2.50924798e-03f,
  8.75352100e-02f, 1.07931145e-01f, 1.98420331e-01f, 5.64624704e-02f, 1.03845328e-01f, 6.17491379e-02f, 7.68915117e-02f, 7.51247704e-02f, 2.60455668e-01f, 1.34713769e-01f,
  -1.68243293e-02f, 4.03429531e-02f, 1.65787995e-01f, 8.40648040e-02f, 7.10493922e-02f, 2.42349416e-01f, 4.86831255e-02f, -1.70990136e-02f, 2.23828167e-01f, 9.79746804e-02f,
  -1.25257997e-02f, 1.44764125e-01f, -2.09349558e-01f, 2.42374986e-01f, 1.23897940e-01f, -1.52188465e-01f, -1.31300867e-01f, -9.79278609e-02f, 2.60446846e-01f, 1.55486837e-01f,
  3.82234156e-01f, 4.71581612e-03f, 2.15665653e-01f, -9.02370736e-02f, -2.86182966e-02f, 1.40779734e-01f, 2.96244740e-01f, -5.38891219e-02f, 9.23994035e-02f, 3.16179581e-02f,
  2.10106745e-01f, 1.70165390e-01f, 1.95221379e-01f, -2.24760562e-01f, 1.86770320e-01f, 3.69263619e-01f, 1.49385408e-01f, -2.30380706e-02f, 2.31528515e-03f, -5.31581743e-03f,
  -3.68037164e-01f, -1.28208742e-01f, -5.99158071e-02f, -1.70015395e-01f, 1.15736127e-01f, 1.26762092e-01f, 7.95445666e-02f, 1.17679007e-01f, 2.32493222e-01f, -1.09174252e-01f,
  -1.22808181e-01f, 1.08660394e-02f, 3.06711271e-02f, 2.85290241e-01f, 3.14195633e-01f, -2.37418741e-01f, -3.70410442e-01f, 1.59362167e-01f, -1.95328165e-02f, 1.16444811e-01f,
  8.81884247e-03f, 2.40620691e-03f, -2.53133103e-02f, 8.27595890e-02f, 1.85502097e-01f, 6.27333149e-02f, 1.47127420e-01f, 8.43908191e-02f, -4.28997213e-03f, 1.32601082e-01f,
  -1.70933813e-01f, -7.64627233e-02f, 1.45262659e-01f, 2.45835409e-02f, -1.66069314e-01f, -3.02826695e-04f, 9.19962004e-02f, 1.44381031e-01f, -3.52042541e-02f, -3.90977934e-02f,
  -1.07213527e-01f, -5.70803285e-02f, -2.80599250e-03f, 4.18504663e-02f, -1.67774811e-01f, 2.84030757e-05f, -1.45329461e-02f, -1.23802021e-01f, -5.77003919e-02f, 2.16740474e-01f,
  -5.80781214e-02f, 2.84382440e-02f, -2.06651147e-02f, 2.04814196e-01f, 7.30828643e-02f, -1.61240697e-02f, -7.22947121e-02f, 1.45041004e-01f, 2.23339692e-01f, -3.73648964e-02f,
  5.12278304e-02f, -1.60382211e-01f, 9.94746760e-02f, -3.73704284e-02f, -1.07751116e-01f, 2.07788274e-02f, -1.10105649e-01f, 2.59974182e-01f, -2.04428211e-02f, 1.24943182e-01f,
  -1.32788748e-01f, 1.46013871e-01f, 1.93528607e-01f, 2.03305200e-01f, 1.64266257e-03f, -1.17656745e-01f, 9.08837002e-03f, 3.19736376e-02f, -1.27714425e-01f, 2.39692569e-01f,
  -1.21961601e-01f, 1.80231467e-01f, 9.34228599e-02f, 1.15338013e-01f, -6.16546301e-03f, 8.05033818e-02f, 1.65495083e-01f, 1.19612388e-01f, -2.17409600e-02f, 1.00477628e-01f,
  1.03183217e-01f, -5.80225587e-02f, 2.34188527e-01f, 1.48544041e-02f, -4.75872532e-02f, -1.54632524e-01f, -2.96421489e-03f, 8.83607790e-02f, -1.28514767e-01f, 2.81774789e-01f,
  1.38764799e-01f, 2.05401629e-01f, -6.58473447e-02f, -2.27810934e-01f, -5.55101037e-02f, -2.62638815e-02f, 2.39002779e-01f, 2.11601377e-01f, 3.55114430e-01f, -6.50647134e-02f,
  4.00063135e-02f, -2.30275065e-01f, 1.28820106e-01f, 3.08609992e-01f, 1.88455522e-01f, -1.94831118e-01f, 1.60788819e-01f, 2.02116251e-01f, -1.18190736e-01f, 1.23192102e-01f,
  1.42138258e-01f, 2.41846904e-01f, 9.46846008e-02f, -5.87307177e-02f, 2.20440492e-01f, 6.39829114e-02f, -7.33001437e-03f, -2.43142277e-01f, -2.76552625e-02f, -5.73053099e-02f,
  -2.26042215e-02f, -8.45293701e-03f, -8.09429437e-02f, 2.38196254e-01f, 2.47521196e-02f, 2.63714820e-01f, 9.81487259e-02f, 8.53901878e-02f, 5.19209206e-02f, -1.76413096e-02f,
  -9.34062079e-02f, 1.37239084e-01f, 1.07819222e-01f, 8.66692141e-02f, -1.24410629e-01f, -3.82161625e-02f, -1.97029524e-02f, -8.24058279e-02f, -2.12857444e-02f, -3.21489982e-02f,
  -1.85162872e-01f, 6.36061355e-02f, -8.43620971e-02f, 5.44538200e-02f, 8.44310075e-02f, -5.24379537e-02f, -1.23246856e-01f, -2.40547508e-02f, -1.23593193e-02f, 1.98752910e-01f,
  1.09710045e-01f, 1.98669106e-01f, -1.17021643e-01f, -1.76776782e-01f, -1.20444752e-01f, -7.61449262e-02f, 5.65474555e-02f, 2.14798182e-01f, -1.43957525e-01f, -1.32379860e-01f,
  -7.05748349e-02f, -8.80937576e-02f, -1.23980287e-02f, 9.96579379e-02f, 1.73333004e-01f, 1.20666459e-01f, -1.88544303e-01f, -1.07756659e-01f, 1.04500726e-02f, -8.01558271e-02f,
  -6.73317686e-02f, -7.46905105e-03f, 4.15546410e-02f, 1.61557645e-02f, -8.92683640e-02f, -2.61594415e-01f, 1.58338249e-01f, 1.54587284e-01f, -2.23863974e-01f, -2.72568455e-03f,
  7.58453086e-02f, -6.59963936e-02f, -7.61437882e-03f, 3.50374766e-02f, 6.30368814e-02f, 2.01824009e-01f, 1.22629441e-01f, 1.48148984e-01f, -1.72157943e-01f, 4.02781107e-02f,
  1.20697655e-01f, -2.54119337e-01f, -7.44742900e-03f, 1.46413997e-01f, 2.60981441e-01f, 1.08703766e-02f, 7.46979862e-02f, 5.63414656e-02f, 1.22014381e-01f, 1.74701080e-01f,
  1.21102035e-01f, 9.97703820e-02f, -1.53513504e-02f, 4.56476538e-03f, 1.36852771e-01f, 8.58567730e-02f, -3.22298845e-03f, 1.37002736e-01f, 2.29461398e-02f, -6.80477768e-02f,
  9.67668965e-02f, -9.56980586e-02f, -6.18083812e-02f, -8.44079885e-04f, -7.11569712e-02f, -1.39833644e-01f, -2.88940817e-02f, 1.51799321e-01f, -2.02539116e-01f, -1.29708931e-01f,
  1.26695514e-01f, 1.36594232e-02f, -6.83302283e-02f, -1.14420615e-01f, 4.70686657e-03f, -1.94531694e-01f, 4.52711806e-02f, 1.90482527e-01f, 8.65697935e-02f, 1.86736673e-01f,
  3.55892599e-01f, -1.99365050e-01f, -3.52461487e-02f, -9.63865519e-02f, 2.26510346e-01f, 1.54585943e-01f, 8.05610269e-02f, -1.79447070e-01f, 8.87051225e-02f, 2.82870561e-01f,
  1.66460425e-01f, -1.29281655e-01f, 1.41614884e-01f, 1.28134536e-02f, 4.65630852e-02f, -3.76122147e-02f, 3.07012826e-01f, 1.13075472e-01f, 3.83310094e-02f, -8.56531858e-02f,
  -1.44588172e-01f, 2.27789953e-01f, 1.57140017e-01f, -6.38224557e-02f, -9.22625139e-03f, 2.16454625e-01f, 2.75129050e-01f, -2.02010006e-01f, -6.52986914e-02f, -1.40414461e-01f,
  2.70896822e-01f, 1.55496031e-01f, 1.91012949e-01f, -4.42509018e-02f, 1.39790162e-01f, 2.10842967e-01f, 1.51475459e-01f, 2.16774628e-01f, 2.61720628e-01f, 1.68137565e-01f,
  2.56981887e-02f, 4.09747735e-02f, 3.04222852e-02f, 9.01512951e-02f, 7.34239817e-02f, 1.85054511e-01f, -2.12317780e-01f, 1.79325901e-02f, 8.37333426e-02f, 1.73177525e-01f,
  -1.78033710e-01f, 5.76370247e-02f, -1.54862985e-01f, 8.57403129e-03f, 1.38131632e-02f, -1.16221756e-01f, -1.62096962e-01f, -1.01250842e-01f, -3.41534726e-02f, -2.04871029e-01f,
  5.60709350e-02f, 2.22005472e-02f, 7.23372176e-02f, 1.36577591e-01f, 1.28665522e-01f, -3.58197726e-02f, -7.25609586e-02f, -1.53196007e-01f, 1.36829451e-01f, 1.42163724e-01f,
  1.86700746e-01f, -8.79874304e-02f, -5.53594604e-02f, -2.23681703e-02f, 2.13402897e-01f, 2.22130075e-01f, 9.48663950e-02f, -1.35993287e-01f, 1.96560457e-01f, -5.29361852e-02f,
  -7.20999166e-02f, 5.17311990e-02f, -1.96563348e-01f, 3.28824185e-02f, 9.30309966e-02f, 1.85380787e-01f, -1.48328813e-02f, 7.85549060e-02f, 3.08156759e-01f, 5.88719063e-02f,
  1.33336755e-02f, -1.88906491e-02f, 1.35028780e-01f, -6.22057915e-02f, 4.91145141e-02f, 6.61098212e-02f, -1.51049837e-01f, 2.27190197e-01f, 1.52989909e-01f, 4.19055335e-02f,
  5.29526807e-02f, 5.61806001e-02f, 1.36453688e-01f, 8.68849456e-02f, 1.32589331e-02f, 1.28376976e-01f, 1.35924891e-01f, -1.62597187e-02f, 1.19499654e-01f, 1.20800510e-01f,
  -4.62650955e-02f, -3.38241830e-02f, 3.20460424e-02f, 8.80835950e-02f, -6.52702600e-02f, 2.21094057e-01f, 5.15238121e-02f, 1.82612807e-01f, 7.44562298e-02f, -1.22959919e-01f,
  -6.23531155e-02f, -4.89999354e-02f, 1.10670932e-01f, -1.08622517e-02f, 1.04765870e-01f, -5.18815890e-02f, 8.24579448e-02f, -1.05365761e-01f, 1.97750837e-01f, 9.53301862e-02f,
  -4.51769568e-02f, -2.25772038e-01f, 1.67277753e-01f, 3.10737491e-01f, -5.27573302e-02f, -9.46835130e-02f, 8.96734595e-02f, 1.21667899e-01f, 1.89240992e-01f, -9.73221809e-02f,
  2.27346823e-01f, -5.91482669e-02f, 5.24771549e-02f, -8.24021772e-02f, -1.78347781e-01f, -1.27277672e-01f, -4.71032737e-03f, 1.71269793e-02f, -1.21892609e-01f, 1.74830958e-01f,
  2.40399480e-01f, 9.75957885e-02f, 2.53601491e-01f, 3.27331901e-01f, -6.31043911e-02f, -1.02624722e-01f, -2.57399678e-03f, 3.43614481e-02f, 1.14466129e-02f, 1.53636530e-01f,
  -1.79852813e-01f, 2.14751586e-02f, 7.10884407e-02f, 1.99246973e-01f, 1.68348938e-01f, 1.00576825e-01f, 1.35461032e-01f, 1.59731820e-01f, 9.69047546e-02f, 2.03259056e-03f,
  1.87856182e-01f, 5.02488986e-02f, 1.36092931e-01f, 1.32389516e-01f, -2.03543678e-01f, 3.67714763e-02f, 1.79343089e-01f, 1.34568915e-01f, -1.16909057e-01f, 1.53091140e-02f,
  -2.19713032e-01f, -1.52491808e-01f, 5.83690293e-02f, 3.23913968e-03f, -2.18851447e-01f, -7.36626387e-02f, -2.82693212e-03f, -1.89501911e-01f, -9.60460901e-02f, 6.34239614e-03f,
  -4.83348593e-02f, 8.76960158e-02f, 1.49932504e-01f, -6.26543909e-02f, -1.10918611e-01f, -1.09148458e-01f, 4.58354242e-02f, 1.66800007e-01f, 6.22970723e-02f, -9.16774478e-03f,
  -1.87364407e-02f, 2.40979679e-02f, 2.68223643e-01f, 1.14699546e-02f, 8.37415755e-02f, -1.70362607e-01f, 1.26664951e-01f, -1.78036541e-01f, 5.08825518e-02f, 2.06437439e-01f,
  -1.77721530e-01f, 6.35628551e-02f, 6.81652501e-02f, 2.50483334e-01f, -6.20522089e-02f, 5.59653491e-02f, 2.49752045e-01f, 1.05284497e-01f, 2.51057535e-01f, -1.59946859e-01f,
  -2.21413355e-02f, 1.48589788e-02f, 1.61399603e-01f, 1.02244280e-01f, -2.42074151e-02f, 2.72643834e-01f, -2.26223748e-02f, -8.95997956e-02f, 3.96759436e-03f, -2.32812986e-02f,
  -3.10886614e-02f, -7.80490637e-02f, -9.60549787e-02f, 1.60919756e-01f, -4.51487266e-02f, -9.60813388e-02f, -8.31353664e-02f, -4.02225666e-02f, 2.09767178e-01f, -8.14510956e-02f,
  -3.00273240e-01f, -1.32013574e-01f, 6.10204637e-02f, 1.00431874e-01f, -3.91017497e-02f, -6.83047846e-02f, -8.00113976e-02f, 7.66649796e-03f, 3.96465421e-01f, -3.60430218e-02f,
  5.57082519e-02f, -1.74227040e-02f, 9.39705148e-02f, 1.87027022e-01f, 3.01106870e-01f, -1.58629104e-01f, 1.72619179e-01f, -2.54735112e-01f, -7.55930915e-02f, 9.27563757e-02f,
  -5.55562600e-02f, 1.09802566e-01f, -2.22380549e-01f, 6.63890131e-03f, 4.61047329e-02f, 1.44334748e-01f, -2.74815573e-03f, -3.35161425e-02f, 9.33005288e-02f, 9.42428187e-02f,
  -2.31473759e-01f, -1.91060647e-01f, 2.54039645e-01f, -1.42285675e-01f, 3.76100123e-01f, -2.77577899e-02f, -6.48774812e-03f, 1.17096350e-01f, 1.26064554e-01f, 1.68608293e-01f,
  -2.00292170e-01f, 2.73392051e-01f, 1.26501262e-01f, 2.21273005e-01f, 6.69442713e-02f, 1.49384007e-01f, 3.06048036e-01f, 2.15792716e-01f, 2.77542144e-01f, -2.31351424e-02f,
  1.12109758e-01f, 1.75489277e-01f, 1.39838502e-01f, 1.32291541e-01f, -8.22080448e-02f, 6.30961731e-02f, 1.37788340e-01f, 1.16623640e-01f, 1.45580962e-01f, 1.31241336e-01f,
  9.58075970e-02f, 1.22333653e-01f, -1.82485446e-01f, 8.61049145e-02f, 2.06170440e-01f, 1.74556881e-01f, -2.42087334e-01f, -1.42106906e-01f, -6.10162169e-02f, -8.40366110e-02f,
  -5.21687344e-02f, 1.77112475e-01f, -2.48295650e-01f, -1.69277489e-01f, -1.54934064e-01f, 2.76793651e-02f, -1.72726780e-01f, 3.73987947e-03f, -8.91141128e-03f, 2.65449822e-01f,
  2.25821417e-03f, 3.66229154e-02f, -7.39826635e-02f, -1.55842435e-02f, 3.07153687e-02f, 1.15047053e-01f, 2.03495443e-01f, -7.50944316e-02f, -1.63896814e-01f, -4.59022075e-02f,
  2.97977120e-01f, 9.15060863e-02f, -6.26181215e-02f, -9.81109813e-02f, 2.01673180e-01f, 1.10141344e-01f, -5.64284772e-02f, 1.59768686e-01f, -1.04597293e-01f, 2.69396096e-01f,
  1.42973006e-01f, 1.80580631e-01f, -1.52945042e-01f, -5.77800646e-02f, 2.11536303e-01f, 6.11556359e-02f, 1.56779781e-01f, -9.83075798e-02f, 1.36106268e-01f, -1.25745758e-01f,
  -7.57626444e-02f, 1.87271744e-01f, 2.01978922e-01f, 2.92837918e-01f, -1.50232762e-01f, -3.09328008e-02f, -7.54274130e-02f, -1.44378722e-01f, -1.29246101e-01f, -5.02849817e-02f,
  5.29951975e-02f, -8.59434810e-03f, 4.75783385e-02f, -6.11830354e-02f, -7.10577071e-02f, 1.19299367e-01f, -2.59953756e-02f, 7.25291967e-02f, 7.99785629e-02f, 1.27291530e-01f,
  -8.97784904e-02f, -1.57564908e-01f, -1.32759303e-01f, 6.29612058e-02f, -8.03958799e-04f, 1.56457692e-01f, -3.90539542e-02f, -1.55104831e-01f, 4.48594391e-02f, -8.30077603e-02f,
  -3.87339033e-02f, 2.99134888e-02f, 8.66455063e-02f, 5.46132140e-02f, -1.45760849e-01f, 8.72714967e-02f, 4.05246541e-02f, -2.43368298e-02f, -9.64997932e-02f, -4.34339941e-02f,
  1.37946844e-01f, 1.80659875e-01f, -7.78262168e-02f, -1.76562294e-01f, 5.97930923e-02f, 1.12941213e-01f, -1.78957954e-01f, -9.80656687e-03f, -2.48373523e-02f, -1.02809682e-01f,
  -5.05279601e-02f, 9.48201399e-03f, 7.66905248e-02f, 1.90303043e-01f, 2.00524867e-01f, 7.27364793e-02f, -1.85188472e-01f, 1.20770507e-01f, 2.99146503e-01f, -2.45412916e-01f,
  1.02943098e-02f, 1.95832208e-01f, 2.25729957e-01f, 1.26209900e-01f, 1.36876836e-01f, 3.64847220e-02f, -1.47861436e-01f, 2.56242365e-01f, 1.72198907e-01f, 4.06060778e-02f,
  4.31516021e-03f, -2.30657347e-02f, -1.55345593e-02f, 4.58319597e-02f, -2.92966198e-02f, -1.68757319e-01f, 8.01782534e-02f, -1.33298356e-02f, 2.08204314e-01f, -1.20029366e-02f,
  3.50074843e-02f, -1.25876144e-02f, 1.11110628e-01f, 6.60421401e-02f, 7.66355395e-02f, 1.14858441e-01f, -1.21301919e-01f, -1.92016345e-02f, 2.09346682e-01f, -3.55912745e-02f,
  -7.36791417e-02f, -1.47455186e-03f, 3.31355669e-02f, 3.12044495e-03f, 1.79333940e-01f, -4.17654701e-02f, -4.46851030e-02f, 1.01342149e-01f, 5.10831363e-02f, -4.17220779e-02f,
  1.61416411e-01f, -1.98741183e-01f, 1.47863731e-01f, 2.39471835e-03f, 7.73677230e-02f, -7.50705153e-02f, 1.84614696e-02f, 5.71051538e-02f, 9.18039605e-02f, 2.06754804e-02f,
  1.54602960e-01f, 9.85010937e-02f, 9.28044319e-02f, 1.84117243e-01f, -8.90617594e-02f, 1.79256201e-01f, -2.60586292e-01f, -2.97545582e-01f, -1.15789808e-01f, -3.51861529e-02f,
  5.82631007e-02f, -8.82703066e-02f, 9.03408006e-02f, -1.19419470e-01f, 1.25397190e-01f, -2.07484782e-01f, -1.41129985e-01f, -1.17945559e-02f, 9.17803720e-02f, -2.36484721e-01f,
  -4.99325916e-02f, -1.04885265e-01f, 5.74911162e-02f, -2.44701654e-02f, 8.11278075e-03f, 1.21848173e-02f, -8.09251741e-02f, 3.23856138e-02f, 2.97867544e-02f, 5.97666651e-02f,
  -8.37274566e-02f, 1.32363765e-02f, -1.04361579e-01f, -1.21817663e-01f, 1.97304711e-01f, -8.92287716e-02f, -2.28059068e-01f, -1.76244408e-01f, 4.54341918e-02f, 8.61315876e-02f,
  2.76037548e-02f, -2.55015008e-02f, -5.98304756e-02f, -3.52726206e-02f, 2.68736780e-01f, 5.32702878e-02f, -2.49602254e-02f, 1.07287370e-01f, 4.14311476e-02f, 1.92707255e-01f,
  2.38136590e-01f, 1.09819444e-02f, 1.54826030e-01f, -2.01223224e-01f, 4.61002477e-02f, 2.35277545e-02f, -5.61359525e-02f, -2.21654680e-02f, -1.27526596e-01f, -5.39362803e-03f,
  6.66036233e-02f, 3.03269625e-01f, -1.20742455e-01f, 4.39134650e-02f, 1.42925277e-01f, 1.26912236e-01f, -1.93446741e-01f, -4.03808542e-02f, 3.01399738e-01f, -9.50274393e-02f,
  3.00418705e-01f, 1.78598389e-02f, -1.06159680e-01f, 3.21674012e-02f, 1.06149137e-01f, 1.44113690e-01f, -2.37538189e-01f, 2.14092150e-01f, 4.32020128e-02f, 1.17551535e-01f,
  1.16538005e-02f, 6.85991114e-03f, 2.41499091e-03f, 1.86240599e-01f, 1.45820290e-01f, -1.33464813e-01f, 1.21084221e-01f, 1.89210147e-01f, 3.22243720e-02f, 8.21922272e-02f,
  8.00102502e-02f, 9.53594223e-02f, 1.71700507e-01f, -1.02353923e-01f, 1.59126595e-01f, 7.84264877e-02f, 1.45209894e-01f, 1.91498145e-01f, -4.86739315e-02f, 3.17096598e-02f,
  4.00851630e-02f, 1.56172082e-01f, -8.69758949e-02f, -1.23262681e-01f, 2.86816120e-01f, 1.25441089e-01f, -9.56426561e-02f, -2.22301468e-01f, -1.69428185e-01f, 8.70788321e-02f,
  1.93648219e-01f, 2.31436446e-01f, 1.78211123e-01f, -8.30716640e-02f, 3.36950868e-02f, -1.50548503e-01f, -2.33622789e-01f, 3.32626790e-01f, 1.91827685e-01f, -9.39850360e-02f,
  -4.02408615e-02f, 1.89158589e-01f, 3.37873660e-02f, 2.28155747e-01f, 2.04916894e-02f, -2.07814407e-02f, -7.62596801e-02f, -1.21239088e-02f, 4.91986936e-03f, 6.47908822e-02f,
  2.46499330e-01f, 2.85698520e-03f, 5.80281392e-02f, 9.44572017e-02f, -8.61339122e-02f, 1.06328212e-01f, 1.75541788e-02f, -4.83164787e-02f, -1.72955245e-01f, 1.90947935e-01f,
  9.85043719e-02f, -1.33300096e-01f, -1.76318035e-01f, 1.33190945e-01f, 7.69625008e-02f, 1.83751553e-01f, -3.21317106e-01f, 2.25150734e-01f, -2.26298086e-02f, 1.47756249e-01f,
  -2.53440976e-01f, 2.62387078e-02f, -1.06257506e-01f, -1.20555036e-01f, -9.90114808e-02f, -1.87584814e-02f, 1.98227298e-02f, 3.99226099e-02f, -1.25588477e-02f, 3.47750448e-02f,
  -2.29719207e-01f, -6.79777116e-02f, 7.47167319e-02f, 3.76286507e-02f, 1.10806167e-01f, -6.02703206e-02f, 9.84110013e-02f, -1.84020206e-01f, -2.17365786e-01f, -1.22992836e-01f,
  3.35232839e-02f, 2.14337304e-01f, -2.52308119e-02f, -2.35937294e-02f, 4.23577167e-02f, 9.06483307e-02f, -2.73498207e-01f, 1.44820973e-01f, -1.05276346e-01f, 3.03295195e-01f,
  -5.51732630e-02f, -1.65440381e-01f, 7.97205418e-03f, 2.96064943e-01f, -4.00767401e-02f, -2.21034050e-01f, 3.10010016e-01f, -1.48813743e-02f, -4.95889261e-02f, -2.22714022e-01f,
  4.09130864e-02f, 1.35639444e-01f, -1.50596127e-01f, -6.57025278e-02f, 1.85722243e-02f, 2.83855736e-01f, -2.63451063e-03f, 2.02176034e-01f, -2.53104623e-02f, -6.93109557e-02f,
  7.37604797e-02f, -1.38923734e-01f, -1.55949622e-01f, -1.25126898e-01f, 9.02750790e-02f, -1.86313853e-01f, 3.36688757e-02f, -1.41572030e-02f, 1.54997230e-01f, 6.01056851e-02f,
  -8.97466764e-03f, -2.45610654e-01f, 1.23507909e-01f, 2.28360370e-01f, -9.17470455e-02f, -1.42803714e-01f, -8.92793313e-02f, -1.82170674e-01f, -8.14167932e-02f, -1.21714793e-01f,
  1.55236162e-02f, 8.75915587e-02f, 3.28925028e-02f, 3.55026014e-02f, -2.18103454e-01f, -5.63843213e-02f, 2.70325482e-01f, -7.66413510e-02f, 6.93236738e-02f, -1.72778383e-01f,
  2.80971855e-01f, -6.52938616e-03f, -1.40317634e-01f, 1.46846205e-01f, 3.39125246e-02f, -7.86064100e-03f, 1.44385457e-01f, 1.22403257e-01f, 2.32819825e-01f, 1.08432598e-01f,
  -2.94199940e-02f, 1.66499019e-01f, 1.25808924e-01f, 6.48297220e-02f, -3.61836255e-02f, 3.57266143e-02f, 1.34903267e-01f, 2.09850758e-01f, 2.27746200e-02f, -1.62231967e-01f,
  2.63600439e-01f, 1.20261170e-01f, 1.59171715e-01f, -4.74336781e-02f, -1.77486405e-01f, 2.28444800e-01f, -7.88330287e-02f, 3.66267934e-02f, -5.87401204e-02f, 2.16209784e-01f,
  -2.30601966e-01f, -3.65940928e-02f, 3.43979634e-02f, -2.12853163e-01f, 1.46500185e-01f, -2.11947799e-01f, 7.23151341e-02f, -1.78868361e-02f, -3.09595894e-02f, 1.47377536e-01f,
  -1.71168968e-01f, 9.44747031e-02f, 1.32953644e-01f, 1.64694250e-01f, 8.76236781e-02f, -3.10247540e-01f, 6.01224741e-03f, 2.44157780e-02f, 8.28082189e-02f, -3.66675407e-02f,
  8.75139236e-02f, -5.83884083e-02f, -7.36303329e-02f, -7.19744265e-02f, 1.37074158e-01f, 9.04315785e-02f, -1.19728059e-01f, -2.66764406e-02f, -7.90559202e-02f, -5.38234748e-02f,
  2.07335427e-01f, -1.01680562e-01f, -1.94869742e-01f, -2.33568415e-01f, 5.19067533e-02f, 5.42435311e-02f, 1.35225877e-01f, 1.05545528e-01f, -6.45084828e-02f, 2.05897801e-02f,
  3.41277272e-01f, 1.02576815e-01f, -5.37486188e-02f, 1.80166155e-01f, -1.25469103e-01f, 1.87400058e-01f, 7.99199715e-02f, -1.49536982e-01f, -5.33726923e-02f, -1.14878394e-01f,
  -8.48123655e-02f, 9.25828293e-02f, -4.82239351e-02f, 3.28555666e-02f, -1.48900732e-01f, -4.69628386e-02f, 4.16033529e-02f, 1.88076839e-01f, -1.41480759e-01f, -1.08246028e-01f,
  6.10142015e-03f, 4.58590090e-02f, -8.52839872e-02f, -4.05001417e-02f, 7.37919360e-02f, -1.33606553e-01f, 3.68555665e-01f, 1.02309935e-01f, 9.03042480e-02f, 9.82576460e-02f,
  -1.54912928e-02f, 1.39526308e-01f, -1.37142256e-01f, 3.26135814e-01f, 3.38854939e-02f, 1.78541958e-01f, 1.48496881e-01f, 5.40309921e-02f, -6.46457076e-02f, 2.49279931e-01f,
  2.65504241e-01f, -8.16631466e-02f, 3.17296572e-02f, -1.32005602e-01f, -3.56296934e-02f, -9.21571180e-02f, -1.88590378e-01f, 1.30221006e-02f, -1.78695232e-01f, 2.56061591e-02f,
  -1.08368456e-01f, -1.70348465e-01f, 4.10406105e-02f, -2.09924936e-01f, 3.95205133e-02f, 5.31729832e-02f, 2.05903985e-02f, 3.93760167e-02f, -5.88408522e-02f, -1.71304774e-02f,
  -1.93705052e-01f, -3.27730656e-01f, 1.68676898e-01f, 2.50663936e-01f, 3.23018730e-02f, -6.73941001e-02f, -1.07849643e-01f, -8.02643672e-02f, 1.01239443e-01f, 7.05178156e-02f,
  -3.07945721e-02f, 9.07201096e-02f, 1.21898822e-01f, -3.14757168e-01f, -4.20278050e-02f, -7.68004358e-02f, 8.47341940e-02f, -8.60429853e-02f, 1.27277290e-02f, -1.75312594e-01f,
  4.56871465e-02f, -3.77238765e-02f, 1.74277931e-01f, -1.37715146e-01f, 8.40338040e-03f, 1.24123491e-01f, -1.41402977e-02f, 1.07439600e-01f, -5.97381257e-02f, 1.68206349e-01f,
  1.05138250e-01f, -3.75342481e-02f, -1.05726607e-01f, 1.64311662e-01f, 7.88812265e-02f, -1.36297822e-01f, 1.27944499e-01f, 1.54999364e-03f, 3.54158103e-01f, -7.09745437e-02f,
  1.04276715e-02f, -6.86131939e-02f, 4.12896156e-01f, -5.83864376e-02f, 2.54360080e-01f, -2.27455292e-02f, -1.06213383e-01f, 1.29837720e-02f, -8.20675567e-02f, -3.44196633e-02f,
  1.87570564e-02f, -3.92557569e-02f, -2.81829946e-02f, -6.90955818e-02f, 8.74414854e-03f, -2.15313993e-02f, -9.11242664e-02f, -1.57739148e-01f, 1.51819840e-01f, -3.38854752e-02f,
  -1.70167442e-02f, -3.76513079e-02f, 2.12171197e-01f, -5.03353961e-02f, -3.78526188e-02f, 3.90279479e-02f, 8.21857248e-03f, -5.65424338e-02f, 7.04119802e-02f, 1.40962109e-01f,
  2.21285880e-01f, 1.80730700e-01f, 1.19124338e-01f, 1.34371564e-01f, -1.18237967e-02f, 8.84063914e-02f, 1.73583790e-03f, -1.88181493e-02f, 2.19883248e-01f, 1.50947556e-01f,
  3.08728106e-02f, -1.74840372e-02f, 1.81418553e-01f, 1.84007764e-01f, 1.52467102e-01f, 5.55335917e-02f, -1.18472748e-01f, 1.21475145e-01f, -5.29913185e-03f, 1.40824378e-01f,
  -2.05877759e-02f, 1.42158791e-01f, 9.50490087e-02f, 6.79928437e-02f, 8.58414248e-02f, -8.56674463e-02f, 1.77867208e-02f, -1.71870872e-01f, 1.08633637e-02f, 1.21056415e-01f,
  -8.74291509e-02f, -3.40749347e-03f, -3.10806260e-02f, 2.08056290e-02f, -2.30555311e-02f, 1.57609448e-01f, -7.56791681e-02f, -2.14838505e-01f, 2.07898077e-02f, -1.16133623e-01f,
  -3.05720139e-02f, 2.77893916e-02f, 7.02381646e-03f, 1.80736724e-02f, -1.90031484e-01f, -2.55468413e-02f, 9.42846313e-02f, -1.69261675e-02f, 1.26872331e-01f, 3.81620787e-02f,
  1.60367768e-02f, 7.61712715e-02f, -1.97981626e-01f, 4.63445075e-02f, 2.36219466e-02f, 1.34257510e-01f, -2.11861581e-01f, -2.10468560e-01f, 5.50104044e-02f, -1.15708232e-01f,
  -1.52767926e-01f, 1.00097284e-01f, -2.44268253e-01f, -7.82874152e-02f, -1.05344810e-01f, -1.13401607e-01f, -1.95122689e-01f, -7.40519091e-02f, -1.88643057e-02f, 1.24407653e-03f,
  -1.09036848e-01f, 2.02578038e-01f, -5.30437455e-02f, -5.35706654e-02f, -4.95158061e-02f, 1.07634239e-01f, 8.89803320e-02f, 4.45174277e-02f, -2.18178660e-01f, -4.30209972e-02f,
  2.19136193e-01f, -3.02275512e-02f, -1.07069157e-01f, -7.41444528e-02f, 1.63182393e-01f, -1.50994346e-01f, 1.32395655e-01f, 1.43537387e-01f, -4.63689044e-02f, 2.85221577e-01f,
  5.33141680e-02f, 1.19495571e-01f, -2.66776562e-01f, -4.28878749e-03f, 2.56885886e-01f, -3.77606191e-02f, 1.24936491e-01f, 5.56758866e-02f, 1.60627455e-01f, -4.37052734e-02f,
  -6.75893351e-02f, 2.73103327e-01f, 3.30896005e-02f, 2.07055062e-01f, -2.34662779e-02f, 2.08330788e-02f, -1.65744852e-02f, 7.47833587e-03f, 7.70907849e-02f, -3.55085880e-02f,
  -9.66443494e-02f, -2.01875959e-02f, 6.45485148e-02f, 1.28815204e-01f, -2.71016527e-02f, 1.01721853e-01f, 1.71974659e-01f, 1.31241113e-01f, -4.05839570e-02f, 2.83738686e-04f,
  9.91742238e-02f, -8.20738524e-02f, -1.43936813e-01f, 1.01171628e-01f, -1.59883313e-02f, 9.40709934e-02f, 1.58980191e-01f, -3.64179872e-02f, 1.82798535e-01f, 3.76014113e-02f,
  6.42009377e-02f, 1.21681727e-01f, 2.39818156e-01f, -9.32662860e-02f, -6.78720027e-02f, -1.02328740e-01f, 7.95442462e-02f, 1.56196788e-01f, -1.26078576e-01f, -1.44115791e-01f,
  1.21188767e-01f, 1.60276562e-01f, 1.02001458e-01f, -1.66779920e-01f, 1.27694327e-02f, 2.95787483e-01f, -1.11385308e-01f, -1.42233716e-02f, -1.76173732e-01f, 3.51113230e-02f,
  -5.40468954e-02f, -1.67613447e-01f, 1.91344306e-01f, -1.13648370e-01f, 2.71753669e-01f, 4.09536064e-02f, 3.62349711e-02f, 2.05341876e-01f, 6.18806109e-02f, 3.63520831e-02f,
  -2.38727033e-01f, 2.50067085e-01f, 1.11674175e-01f, 1.30986094e-01f, 2.16923982e-01f, -1.28905147e-01f, 8.04656893e-02f, 1.18718185e-01f, -4.31260802e-02f, -3.36501817e-03f,
  4.04150598e-02f, -5.91597743e-02f, -5.38120000e-03f, 8.83890036e-03f, 8.50880817e-02f, 4.71084518e-03f, 2.92591490e-02f, 1.00698851e-01f, 4.84899580e-02f, 1.22777171e-01f,
  -1.68987084e-02f, 1.95173062e-02f, 1.10250041e-02f, 1.24576457e-01f, -1.73136920e-01f, -1.40213907e-01f, 3.44526991e-02f, 1.55291066e-01f, -1.23669140e-01f, -2.30673095e-03f,
  -9.72776338e-02f, 6.06532544e-02f, 1.46798745e-01f, 6.28388021e-03f, 3.20537249e-03f, 3.78027335e-02f, 1.78464487e-01f, -2.25244805e-01f, -2.09546134e-01f, 2.60649532e-01f,
  1.30640224e-01f, -3.59488651e-02f, -3.16951871e-02f, 1.34878874e-01f, 7.16929063e-02f, 1.70950770e-01f, -7.85289854e-02f, -1.78461373e-01f, -7.13625774e-02f, 1.51845202e-01f,
  -1.56372041e-01f, -4.49635908e-02f, 9.98989716e-02f, -1.44120723e-01f, -5.18771540e-03f, -7.65632242e-02f, -3.20152231e-02f, 1.37709931e-01f, 1.58722430e-01f, -3.85739207e-02f,
  -8.88521001e-02f, 1.66695535e-01f, 7.19830245e-02f, -1.39100835e-01f, -2.34020561e-01f, 1.27407894e-01f, 1.59656376e-01f, 8.43549818e-02f, -1.10697411e-01f, 1.80934146e-01f,
  -8.60557184e-02f, 1.36505738e-01f, -2.78858691e-02f, 4.36210707e-02f, 6.99174870e-03f, 2.54326649e-02f, -2.95243971e-02f, -4.51012189e-03f, 1.22807540e-01f, -1.37773613e-02f,
  -8.18243772e-02f, 9.07206014e-02f, -4.59434045e-03f, 1.13413505e-01f, -2.49561723e-02f, -5.08955680e-02f, -1.45709291e-01f, -2.78320350e-02f, -1.51006550e-01f, -9.23413783e-02f,
  1.00431807e-01f, 5.39221726e-02f, -1.98612064e-01f, -3.68573405e-02f, 1.99726015e-01f, -5.17065153e-02f, -3.81842777e-02f, -1.11580798e-02f, -1.46194533e-01f, 1.89623192e-01f,
  1.23240046e-01f, -6.15014322e-02f, -1.45633951e-01f, 4.81272973e-02f, -9.14604515e-02f, 1.89572439e-01f, -1.88602045e-01f, 1.60383001e-01f, -4.91183139e-02f, 6.85419738e-02f,
  -1.41115174e-01f, 1.57379676e-02f, -1.29194468e-01f, -6.53985562e-03f, -7.10538030e-02f, -1.71121303e-02f, -7.21088648e-02f, -7.83149451e-02f, 2.12069914e-01f, -4.28933203e-02f,
  2.72421509e-01f, 2.20089003e-01f, 6.57608882e-02f, 2.27599636e-01f, -1.54130638e-01f, 8.32902044e-02f, -6.85276911e-02f, 1.65343598e-01f, 6.41423371e-03f, 1.82762071e-01f,
  1.76896587e-01f, 9.54907611e-02f, -4.70600799e-02f, 1.77102208e-01f, 2.84155071e-01f, 8.20179358e-02f, 1.12660922e-01f, 4.97020669e-02f, 3.94951664e-02f, -1.65320300e-02f,
  -4.85421382e-02f, 2.28189845e-02f, 1.88829631e-01f, -4.13317867e-02f, 1.70755554e-02f, 5.82415164e-02f, 4.49207872e-02f, 7.06892014e-02f, -1.36515737e-01f, 1.26570789e-02f,
  -1.04985952e-01f, 2.01646984e-02f, -2.74474144e-01f, 3.26734185e-02f, 1.82604775e-01f, 1.46828890e-01f, -2.03891188e-01f, -2.69017704e-02f, -6.53502420e-02f, -6.91387132e-02f,
  -1.58539623e-01f, -1.66924652e-02f, -1.62703186e-01f, -1.29962573e-02f, 1.17355473e-01f, -1.94460288e-01f, -1.08812056e-01f, 2.11578369e-01f, 8.33463296e-03f, -1.46255895e-01f,
  -5.46786338e-02f, 1.71622545e-01f, -2.20325232e-01f, 4.32021357e-02f, -2.20614225e-01f, 1.97829455e-01f, 5.58813848e-02f, -1.18245080e-01f, 6.43224493e-02f, -8.74918178e-02f,
  3.67182307e-02f, -2.80912668e-01f, 2.38601044e-01f, -7.20660910e-02f, 1.88297361e-01f, 2.48052895e-01f, -8.46926346e-02f, 2.49672100e-01f, -2.63355047e-01f, 1.65167674e-01f,
  1.47505384e-02f, 2.08165258e-01f, 5.88050559e-02f, 1.43727705e-01f, 1.05934598e-01f, -5.42916171e-02f, -1.98673204e-01f, 3.98667961e-01f, 1.60975102e-02f, -1.42514538e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  2.01244041e-01f, 9.75046903e-02f, -6.46282434e-02f, 9.23191905e-02f, -8.27070698e-02f, 2.66071260e-02f, 5.48350625e-02f, -4.99696322e-02f, 2.97733080e-02f, -3.61978710e-02f,
  1.00183010e-01f, 8.09850916e-02f, 2.10550409e-02f, 6.41166866e-02f, -2.92877969e-03f, -1.80359539e-02f, 1.37774661e-01f, 6.25126287e-02f, 6.96004480e-02f, -1.55134499e-02f,
  1.16988467e-02f, 5.42660393e-02f, 1.22286808e-02f, 2.56111287e-02f, 3.94786596e-02f, 3.96653153e-02f, 6.32181242e-02f, 6.92774951e-02f, 7.96116814e-02f, 1.22624159e-01f,
  -1.85541715e-03f, -1.79583643e-04f, -3.65142860e-02f, 4.14968506e-02f, -6.87983707e-02f, 5.92149161e-02f, 9.52661112e-02f, 2.40434222e-02f, 7.58834369e-03f, 1.44348517e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -6.16585575e-02f, -1.24478966e-01f, 4.09268476e-02f, -2.42670774e-02f, 6.62254021e-02f, 2.69399304e-02f, 5.95175661e-02f, -1.86173737e-01f, 6.14118762e-02f, 1.07886575e-01f,
  5.44829927e-02f, -7.87865594e-02f, 1.12418294e-01f, -6.86183423e-02f, -6.40650466e-02f, 1.01225674e-01f, 6.22212479e-04f, -1.89514995e-01f, 1.98992565e-01f, 6.57055154e-02f,
  2.69785076e-01f, -5.43142147e-02f, -9.62118953e-02f, 9.22750682e-02f, -5.58589920e-02f, -8.17997456e-02f, -2.17553601e-02f, -2.18899194e-02f, -3.27054620e-01f, -4.10686165e-01f,
  -2.58858502e-01f, 5.35931496e-04f, -4.37042713e-01f, 5.49548268e-02f, -1.27350047e-01f, -4.33918573e-02f, 3.81208188e-03f, -3.04639012e-01f, -3.81806552e-01f, 4.28743893e-03f,
  -4.63206083e-01f, 1.05802998e-01f, 1.86048895e-01f, -3.21724027e-01f, 2.29734302e-01f, -1.23076048e-02f, 1.40439644e-01f, 1.06992282e-01f, 2.90351093e-01f, -1.12773873e-01f,
  -2.40960598e-01f, -1.23062111e-01f, 2.80189663e-01f, -1.77122772e-01f, -1.13478765e-01f, -9.34721380e-02f, 1.90509096e-01f, -7.46037439e-02f, -1.62352860e-01f, -4.65739593e-02f,
  -3.40731114e-01f, -2.39862785e-01f, 1.67693317e-01f, 3.03471148e-01f, 7.34415045e-03f, -1.81489941e-02f, 4.00593355e-02f, -5.03849834e-02f, -4.38155942e-02f, 1.07602188e-02f,
  5.39384261e-02f, 9.45365503e-02f, 2.88016014e-02f, 1.14271417e-01f, 4.39765304e-02f, 8.32251981e-02f, -5.85465413e-03f, -1.10117830e-01f, -1.12964258e-01f, 2.22547397e-01f,
  6.35984994e-04f, -1.00475691e-01f, 2.26250753e-01f, 2.31609240e-01f, -1.58751577e-01f, 2.00210422e-01f, -1.54193729e-01f, 1.04146801e-01f, 1.85345829e-01f, -4.38116133e-01f,
  -3.65106732e-01f, -3.62336248e-01f, -6.18996285e-02f, -3.44431438e-02f, 2.38749593e-01f, -1.80575773e-01f, -2.70787448e-01f, 2.57286489e-01f, 1.38005065e-02f, -1.16089463e-01f,
  4.95904009e-04f, -1.32732943e-01f, -1.58740997e-01f, 2.28349671e-01f, -3.87550622e-01f, -3.14966682e-03f, -1.18660450e-01f, 1.12165719e-01f, -2.49021530e-01f, -8.86765271e-02f,
  -5.19871898e-02f, -1.73058793e-01f, 1.23939693e-01f, 7.35713914e-02f, 5.06433025e-02f, -4.11562547e-02f, 1.22156546e-01f, 2.03172579e-01f, -1.34319842e-01f, -3.73373747e-01f,
  2.13279903e-01f, -1.56481400e-01f, -2.97519147e-01f, 1.12753831e-01f, -2.81889327e-02f, 2.02113524e-01f, 2.73994148e-01f, 2.62682408e-01f, 1.32324100e-01f, -6.14220873e-02f,
  -1.00066826e-01f, -5.39888032e-02f, 9.12065953e-02f, 7.17370734e-02f, -9.40979179e-03f, 1.70650240e-02f, -1.41471192e-01f, -9.17218029e-02f, -1.73814490e-01f, 2.23388541e-02f,
  1.38095453e-01f, 2.80600339e-02f, 1.94799691e-01f, 9.26923305e-02f, 1.01256043e-01f, 9.05054063e-02f, -9.64946598e-02f, -2.96975765e-02f, 3.61075811e-02f, 3.25604784e-03f,
  -1.17945120e-01f, 1.27327144e-01f, 1.87312692e-01f, -3.56372148e-01f, -2.10067764e-01f, 2.40355819e-01f, 1.02109872e-01f, 1.25831410e-01f, 1.85285375e-01f, -2.84257025e-01f,
  -3.82667869e-01f, 1.39594628e-02f, 7.82809481e-02f, -1.99629247e-01f, -4.15350050e-01f, -2.38448456e-01f, 2.22875029e-01f, 9.94907990e-02f, -1.57618709e-02f, -3.36767018e-01f,
  -3.89244050e-01f, 7.36850873e-02f, -1.81146666e-01f, -1.87379420e-01f, -2.74849385e-01f, -1.22417271e-01f, 2.02332690e-01f, -1.25928059e-01f, 1.90755755e-01f, -1.91574931e-01f,
  -1.11382537e-01f, -4.26485777e-01f, 1.97510555e-01f, 2.31541276e-01f, 3.27293091e-02f, 1.59673646e-01f, -9.73176584e-02f, -5.96470200e-02f, 2.20025852e-01f, 5.28206006e-02f,
  1.29404366e-01f, -1.06778011e-01f, -7.90125281e-02f, -4.69416194e-02f, 9.99955162e-02f, -1.07266463e-03f, -9.67495814e-02f, 6.97325021e-02f, -9.78827253e-02f, -6.50884584e-02f,
  -1.84449870e-02f, -1.95703626e-01f, -6.10702746e-02f, -1.49107188e-01f, -1.33030623e-01f, 2.40552530e-01f, 6.30951375e-02f, -1.06456637e-01f, 1.26632648e-02f, -1.94905683e-01f,
  -1.21769980e-01f, -1.82899818e-01f, 7.12099522e-02f, -1.85986742e-01f, 1.48800194e-01f, 1.97564457e-02f, -2.45338723e-01f, 1.31022289e-01f, 2.77073771e-01f, 2.22144738e-01f,
  -2.08874851e-01f, -9.46773216e-02f, 9.24959332e-02f, 1.77924931e-01f, -3.34904678e-02f, 2.52750292e-02f, -4.36134219e-01f, -1.13142125e-01f, 5.91497608e-02f, 1.80728495e-01f,
  -3.04182656e-02f, -2.16617972e-01f, -2.68483698e-01f, -4.24189359e-01f, 3.20495889e-02f, 1.12661161e-01f, 9.76732671e-02f, -3.49717200e-01f, 1.15821421e-01f, -3.13136071e-01f,
  1.51698098e-01f, -4.43691343e-01f, 2.50283647e-02f, 1.32242545e-01f, 2.26923287e-01f, -2.51041204e-01f, -2.81603485e-01f, 1.82513669e-01f, 1.59278646e-01f, 1.61810175e-01f,
  8.00704807e-02f, -3.55800316e-02f, -4.11594242e-01f, 2.93192128e-03f, -4.37417030e-01f, -2.72497654e-01f, 1.54030368e-01f, 1.29658058e-01f, -5.60134016e-02f, 1.21394312e-02f,
  9.22122896e-02f, 1.74787849e-01f, -7.74829313e-02f, -8.31915662e-02f, 1.46572545e-01f, -7.24169984e-02f, 1.14605352e-01f, 1.77148119e-01f, -6.71175718e-02f, 1.41086876e-01f,
  1.71643384e-02f, 1.58384461e-02f, 4.63553779e-02f, -1.52145416e-01f, -5.70726953e-02f, 2.78345019e-01f, 1.82543680e-01f, -1.23191632e-01f, -1.92591682e-01f, -3.04736078e-01f,
  2.85197943e-01f, 1.48491561e-01f, -2.03598008e-01f, 1.79427892e-01f, -1.34527460e-01f, 1.01170599e-01f, 6.08994178e-02f, -4.10808057e-01f, -2.04415202e-01f, -1.52215660e-01f,
  1.24715708e-01f, -4.44772840e-01f, -7.69482329e-02f, 3.16021852e-02f, 4.82798591e-02f, -3.31692919e-02f, 3.86191219e-01f, -1.21484004e-01f, 1.72862276e-01f, -2.28068292e-01f,
  2.75122166e-01f, 2.45969415e-01f, 2.12736249e-01f, 2.12991312e-01f, 9.90506262e-02f, -8.59799534e-02f, -3.15662950e-01f, 1.72479108e-01f, 3.59267406e-02f, -1.29018828e-01f,
  -3.10661107e-01f, -1.86593071e-01f, -1.98199689e-01f, 8.56330320e-02f, -8.45839530e-02f, -3.71175766e-01f, 9.51427519e-02f, -2.21503466e-01f, -2.49292612e-01f, -2.66756892e-01f,
  8.34874809e-02f, -9.76344049e-02f, -1.74743503e-01f, 2.07745768e-02f, 3.60032581e-02f, 3.66608389e-02f, -3.22380546e-03f, 4.05894630e-02f, -1.85868159e-01f, -9.44699869e-02f,
  1.35735810e-01f, 2.56553739e-02f, 5.87028638e-02f, -1.28256634e-01f, -1.71771318e-01f, -8.74804333e-02f, -8.12701657e-02f, 2.78413564e-01f, 1.49392456e-01f, -1.88316870e-02f,
  -1.44289538e-01f, -1.01453319e-01f, 8.77810195e-02f, 2.40719348e-01f, -1.51294693e-01f, 1.28775001e-01f, -5.07942541e-03f, -4.54640806e-01f, 1.32329702e-01f, -2.33062223e-01f,
  -1.67256698e-01f, -2.31140509e-01f, 1.03504457e-01f, -1.83389843e-01f, 5.13356067e-02f, -4.13650155e-01f, 5.41823953e-02f, -1.76963389e-01f, -1.80448964e-01f, -1.14728019e-01f,
  3.79766896e-02f, 2.66261578e-01f, 2.65733600e-01f, -1.62783489e-01f, -5.03248014e-02f, 8.93406346e-02f, 2.26015374e-01f, 2.27279484e-01f, -2.61421531e-01f, 1.44157395e-01f,
  -1.99917890e-02f, -9.92347971e-02f, -4.51254338e-01f, 3.09274465e-01f, -2.96708196e-01f, -3.74187082e-01f, -1.93088248e-01f, -2.50161678e-01f, -2.56054401e-01f, 2.16882646e-01f,
  -2.73615450e-01f, 1.92679107e-01f, -1.77421197e-02f, 1.64359331e-01f, -7.92444050e-02f, -1.35920197e-01f, 3.99859680e-04f, 1.25850856e-01f, 1.22201191e-02f, -1.82001501e-01f,
  1.05828896e-01f, -1.53106317e-01f, -1.35775700e-01f, 3.23856249e-02f, 4.50705513e-02f, 1.11485101e-01f, -2.43252382e-01f, -1.83696654e-02f, 1.16249010e-01f, 1.10918216e-01f,
  -8.47341344e-02f, -1.49457723e-01f, -1.52685180e-01f, 2.40918193e-02f, -5.43775447e-02f, 1.86897933e-01f, -1.99533805e-01f, 4.67412546e-02f, -3.70033421e-02f, -3.23201984e-01f,
  -2.31118381e-01f, -3.32999080e-01f, 1.96591511e-01f, 1.63003191e-01f, -1.62738279e-01f, -4.55637090e-02f, 1.51290134e-01f, 1.09964937e-01f, 5.37056513e-02f, 1.98548019e-01f,
  -1.42546564e-01f, -2.96873748e-01f, 1.26204237e-01f, -2.03423619e-01f, 2.71568149e-01f, 4.43751179e-02f, -2.77111471e-01f, 1.17179103e-01f, -4.28308159e-01f, 1.08669370e-01f,
  -7.26800561e-02f, -2.60405988e-02f, -4.98890877e-01f, 1.61526166e-02f, 2.51879334e-01f, -5.36286756e-02f, -1.34886757e-01f, 1.56340189e-02f, 2.39258170e-01f, 2.13034913e-01f,
  -4.25642520e-01f, -4.12972182e-01f, -8.74120742e-03f, 3.75953726e-02f, 1.98639333e-01f, 2.28489712e-01f, -7.73321241e-02f, -9.07366201e-02f, -1.41734868e-01f, 1.01087399e-01f,
  -1.45821586e-01f, -4.67217565e-02f, 8.86299387e-02f, -1.00766964e-01f, -1.12186961e-01f, -6.78014010e-02f, 5.45648672e-02f, 3.02373879e-02f, -8.89002457e-02f, 1.30097184e-03f,
  1.47752285e-01f, 5.37795983e-02f, -8.96205232e-02f, -5.66188479e-03f, -2.36530155e-01f, -1.71848736e-03f, 1.82523549e-01f, 9.66043845e-02f, -4.96388562e-02f, 5.24107702e-02f,
  1.54031754e-01f, -1.07319959e-01f, -3.34813952e-01f, 1.57732859e-01f, 2.27720976e-01f, 4.36770506e-02f, -2.07107320e-01f, -3.60492110e-01f, 2.81612854e-02f, -2.71408290e-01f,
  9.28956419e-02f, -3.77420187e-02f, -3.83486390e-01f, 3.79347920e-01f, 1.34255722e-01f, 2.90264845e-01f, 2.88849235e-01f, -4.22889479e-02f, -3.96768123e-01f, -2.83962816e-01f,
  -2.12923035e-01f, -2.14488253e-01f, 2.39187673e-01f, 1.20390812e-03f, -3.42748970e-01f, 1.01561695e-01f, -2.27830514e-01f, -3.98799665e-02f, -2.18773142e-01f, 2.04767048e-01f,
  -7.99753889e-02f, 5.37528284e-02f, 2.25197643e-01f, -1.85694963e-01f, -3.52381229e-01f, 1.20988868e-01f, 7.67482147e-02f, -6.15492687e-02f, -8.11934322e-02f, 1.09568434e-02f,
  -1.26475515e-02f, -6.94064647e-02f, -2.18940124e-01f, -1.52210090e-02f, 4.90379930e-02f, 5.18252105e-02f, -8.43457580e-02f, -1.35140866e-01f, -6.85248151e-02f, -2.90347617e-02f,
  -3.47653553e-02f, -1.29112527e-01f, 3.61486077e-02f, -8.06645453e-02f, -1.63201109e-01f, 7.60393664e-02f, 6.29854351e-02f, 8.34646970e-02f, 1.33131027e-01f, 5.10986969e-02f,
  1.40845388e-01f, -2.06948742e-01f, -6.61990717e-02f, 1.35044143e-01f, 1.17071465e-01f, -2.55734682e-01f, -3.04580361e-01f, -1.85142025e-01f, 2.37693787e-01f, -1.47218660e-01f,
  1.51945874e-01f, 1.80586874e-01f, 3.03833395e-01f, 1.54660836e-01f, 7.65306782e-03f, 1.96616665e-01f, -2.36562982e-01f, -2.31250852e-01f, -9.90660712e-02f, 3.96547429e-02f,
  -3.66293162e-01f, 1.54148459e-01f, 2.40850374e-01f, -2.76031643e-01f, 2.06476316e-01f, 6.98490217e-02f, -1.29467502e-01f, -3.03174436e-01f, -1.68968067e-01f, -3.00702870e-01f,
  2.21316531e-01f, -3.90992343e-01f, 1.85722798e-01f, -2.24136010e-01f, 2.42016718e-01f, 2.13185012e-01f, -6.48511127e-02f, 9.86407418e-03f, 4.96702753e-02f, -4.99816984e-02f,
  1.49487376e-01f, -7.62837976e-02f, 1.73056737e-01f, 1.68262362e-01f, 1.35460228e-01f, 2.52622250e-03f, -7.10859746e-02f, 1.47891030e-01f, 1.55452222e-01f, -1.73773780e-01f,
  -2.94482291e-01f, -5.52661493e-02f, 3.45544629e-02f, 6.21361211e-02f, 1.23407654e-01f, 4.96792085e-02f, 9.66741368e-02f, -1.40312910e-01f, 1.78613022e-01f, 1.00508399e-01f,
  8.22839327e-03f, -7.40548223e-02f, -1.72162428e-01f, 1.74556449e-01f, -2.24888682e-01f, -1.66330248e-01f, -1.98167861e-01f, -1.81087822e-01f, -2.06051990e-01f, 1.90645128e-01f,
  7.40129203e-02f, -1.56716198e-01f, -2.32567072e-01f, -1.12593696e-01f, -3.52113515e-01f, -1.41711861e-01f, -1.54262900e-01f, 1.25095267e-02f, -6.66766390e-02f, -1.96724057e-01f,
  -7.24291205e-02f, 2.54522800e-01f, -3.89601260e-01f, -1.61819588e-02f, 2.07114458e-01f, -2.61866510e-01f, -1.05441816e-01f, 4.44188453e-02f, -2.28050560e-01f, 2.69538254e-01f,
  7.68545717e-02f, 2.64846422e-02f, -5.90330996e-02f, 2.19420612e-01f, -2.29633942e-01f, 2.54360318e-01f, 1.39107540e-01f, 6.59351498e-02f, -2.98788220e-01f, -3.66905868e-01f,
  2.03759253e-01f, -3.16541046e-01f, -2.68169940e-01f, 4.78781343e-01f, -3.13203543e-01f, 2.22684443e-01f, -1.99093521e-01f, -2.08874211e-01f, -8.70380178e-02f, -3.42265181e-02f,
  -2.98703387e-02f, 6.50089905e-02f, -5.33834063e-02f, 1.21251948e-01f, -8.46567005e-02f, 1.83073580e-02f, 1.29315272e-01f, -2.01827377e-01f, 8.77632722e-02f, 1.72442928e-01f,
  2.88035590e-02f, -1.23634517e-01f, -8.80647972e-02f, 1.12505130e-01f, 1.62331522e-01f, -6.99423999e-02f, 1.67202517e-01f, 1.87113062e-01f, -1.82656229e-01f, 8.97021219e-02f,
  -5.14934696e-02f, 2.29514033e-01f, 1.61487028e-01f, -2.52749175e-01f, 2.06602469e-01f, -5.82418218e-02f, -1.51710629e-01f, 9.19338986e-02f, 3.12980443e-01f, 1.97938949e-01f,
  -2.31812119e-01f, 2.73759186e-01f, 8.92484412e-02f, -2.46205106e-01f, 7.45564932e-03f, 2.42426202e-01f, 1.42784059e-01f, 8.82998016e-03f, 2.95784920e-01f, -5.38765118e-02f,
  -1.36494502e-01f, -3.46154794e-02f, -3.38179260e-01f, -3.40393424e-01f, -1.13186359e-01f, -2.84162343e-01f, -3.06787580e-01f, -1.95496455e-01f, 4.25203070e-02f, -7.93306902e-02f,
  -2.98920274e-01f, -1.92248270e-01f, 1.78902850e-01f, -5.48197329e-02f, 3.36318940e-01f, 2.51700491e-01f, 2.01918259e-01f, -2.03306496e-01f, 1.32274806e-01f, -3.44284415e-01f,
  5.75044975e-02f, -3.30047220e-01f, 1.20124117e-01f, -1.20493874e-01f, -3.38935219e-02f, 9.85390916e-02f, -5.90002574e-02f, 6.65875748e-02f, -7.00468570e-02f, -2.17105565e-03f,
  4.31428477e-02f, 8.26949030e-02f, -6.55621514e-02f, 1.12236872e-01f, 5.73614947e-02f, -1.09730244e-01f, -1.11919358e-01f, -2.07191661e-01f, -2.23474279e-01f, -1.15953885e-01f,
  1.61166772e-01f, -4.45191711e-02f, 1.90741405e-01f, 2.98076384e-02f, -1.35201588e-01f, 8.34973063e-03f, 1.16708070e-01f, -1.39586106e-01f, -3.29999775e-01f, 2.24187240e-01f,
  1.57329470e-01f, -2.65470028e-01f, 1.32314786e-01f, 8.30430686e-02f, -2.12163359e-01f, 2.04188883e-01f, 2.54539639e-01f, -1.65462926e-01f, -8.04791823e-02f, 1.46556646e-01f,
  6.72717839e-02f, 6.24025054e-02f, -9.85407457e-02f, -1.97020590e-01f, 2.81208336e-01f, -9.01062489e-02f, 2.39702985e-01f, -2.92445242e-01f, -3.45016360e-01f, -1.40582666e-01f,
  1.23873372e-02f, -1.65679708e-01f, -4.12159055e-01f, -1.74163520e-01f, -1.72987938e-01f, 2.29982689e-01f, -2.28967607e-01f, 3.22096884e-01f, -4.81052846e-02f, 1.08538777e-01f,
  -1.28525227e-01f, -1.14769541e-01f, 1.13457151e-01f, -2.91863173e-01f, -5.81332222e-02f, -8.42050612e-02f, -2.32430294e-01f, -3.98853272e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.90844333e-03f, -5.08826785e-02f, -3.35919741e-03f, -7.14840926e-03f, 1.04589790e-01f, 8.53582025e-02f, -2.51000430e-02f, -2.88782250e-02f, -9.22677107e-03f, -8.34254269e-03f,
  -7.57190734e-02f, -1.58484653e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    