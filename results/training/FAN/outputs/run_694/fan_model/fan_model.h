/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.03549637e-01f, 8.97105504e-03f, -3.14621702e-02f, -2.98196673e-01f, -1.25198916e-01f, 1.51697606e-01f, 7.84608275e-02f, 1.67702571e-01f, -1.99257880e-01f, -8.99227485e-02f,
  -1.03787124e-01f, -3.59205425e-01f, -2.37407297e-01f, -4.67650294e-02f, 5.60912527e-02f, -2.68551670e-02f, -1.83189854e-01f, -1.09395750e-01f, 7.64351059e-03f, -5.19499816e-02f,
  -1.24613561e-01f, 5.79859875e-03f, -3.43922190e-02f, -7.64692482e-03f, 2.16569211e-02f, -1.98476270e-01f, -5.01390211e-02f, 8.88613090e-02f, 8.59151930e-02f, -3.31822038e-01f,
  -2.33071700e-01f, 1.36376813e-01f, -1.96092874e-01f, -2.26225853e-01f, -4.34827022e-02f, -1.53325632e-01f, -1.27392292e-01f, -7.74895623e-02f, -1.16935059e-01f, -3.97658236e-02f,
  -1.02827720e-01f, -1.45358622e-01f, -1.69630677e-01f, -1.73443351e-02f, -6.62173927e-02f, -2.47671381e-02f, 1.19650131e-02f, -6.86810985e-02f, -1.30770495e-02f, -5.92599921e-02f,
  -5.06031811e-02f, 7.91610871e-03f, -1.79122686e-02f, 5.39441034e-02f, 9.87858921e-02f, -4.79645841e-02f, -2.39723586e-02f, -2.33605504e-02f, 1.60956547e-01f, -1.72201078e-02f,
  -1.17250681e-01f, -3.99798751e-02f, 9.93615910e-02f, 2.36709900e-02f, 1.31090162e-02f, -1.51717411e-02f, 8.40604827e-02f, -2.91217454e-02f, -7.96142500e-03f, 4.31620255e-02f,
  9.94058978e-03f, 7.58535787e-02f, 3.22290547e-02f, 1.06195137e-01f, 7.77465403e-02f, 5.58628328e-02f, 7.83482683e-05f, 1.05670922e-01f, 1.53937966e-01f, 1.27128571e-01f,
  2.57656667e-02f, 8.66277888e-02f, 6.22511394e-02f, 1.04764350e-01f, 1.97398722e-01f, 2.95716547e-03f, 1.13684356e-01f, 7.20349923e-02f, 6.47072792e-02f, 2.53285486e-02f,
  -3.16591203e-01f, 1.14000358e-01f, -2.23153949e-01f, -1.09097019e-01f, -6.44006282e-02f, -1.26818508e-01f, -1.59353077e-01f, -5.28240874e-02f, -6.99578375e-02f, -1.14150196e-01f,
  6.82170242e-02f, -1.22455120e-01f, 4.01541637e-03f, -3.82795297e-02f, -1.40514925e-01f, -8.71806890e-02f, -8.16734806e-02f, -2.39299193e-01f, -3.75618935e-02f, -7.55850598e-02f,
  -8.12145174e-02f, -1.14506952e-01f, -1.22350208e-01f, -1.39094234e-01f, -6.04665317e-02f, -1.09856002e-01f, -6.64624646e-02f, -1.12749644e-01f, 6.51386678e-02f, -1.77643836e-01f,
  -4.43870187e-01f, -5.24367392e-01f, -1.90743387e-01f, 3.17221470e-02f, 2.44067252e-01f, 1.25185475e-01f, -1.62771150e-01f, 7.72088394e-02f, 2.20587060e-01f, -1.06286548e-01f,
  2.07295287e-02f, 2.84311086e-01f, 1.90374762e-01f, 1.51454926e-01f, -2.95160804e-02f, -2.01581985e-01f, -2.00837836e-01f, -4.88615036e-02f, 3.33790183e-01f, 1.06554665e-01f,
  1.38677120e-01f, -1.55119181e-01f, -1.40406378e-02f, 7.12834224e-02f, 1.26097754e-01f, 3.60513389e-01f, -1.03010997e-01f, -1.91206615e-02f, 7.65429661e-02f, -1.48220643e-01f,
  -1.09401405e-01f, -2.50915885e-01f, 2.01562464e-01f, 1.16906375e-01f, 7.57994354e-02f, 1.47480248e-02f, 8.03014338e-02f, 4.40626927e-02f, 1.53448373e-01f, -3.21815275e-02f,
  -3.02525945e-02f, 1.99129172e-02f, 4.29369360e-02f, 8.47647414e-02f, -5.80293424e-02f, 6.49320334e-02f, -1.67434774e-02f, -7.89667219e-02f, -9.80471224e-02f, -5.78439496e-02f,
  1.52974069e-01f, 1.85142718e-02f, -1.88484043e-03f, 6.22196831e-02f, -5.66260181e-02f, 1.04261480e-01f, -4.83296402e-02f, 1.83606334e-02f, 5.46618402e-02f, -4.55866419e-02f,
  5.48002496e-02f, 1.15147550e-02f, -2.43802499e-02f, -9.60986782e-03f, -4.38904241e-02f, -1.97969261e-03f, 2.37209518e-02f, -4.02306654e-02f, -1.56290212e-03f, -1.38373263e-02f,
  -1.75288506e-02f, -6.55035600e-02f, -3.19257341e-02f, 9.01766121e-03f, 1.65188666e-02f, 3.26061584e-02f, -3.21093686e-02f, -6.38836026e-02f, 1.27637209e-02f, 2.17572916e-02f,
  3.97818238e-02f, 1.12085631e-02f, -4.69888151e-02f, 4.54328768e-03f, 3.29691842e-02f, -2.64742295e-04f, 4.34157252e-02f, -2.88367793e-02f, 2.13900693e-02f, -3.64860259e-02f,
  -1.90222845e-03f, 2.86713685e-03f, 2.57101003e-02f, 3.87751847e-03f, -3.05415248e-03f, 5.25020398e-02f, 7.73139447e-02f, -2.54714899e-02f, -4.27047256e-03f, 2.63962820e-02f,
  8.28246549e-02f, -7.67014846e-02f, -4.47894819e-02f, 4.01573069e-03f, 8.95757899e-02f, 1.08050652e-01f, -5.43552041e-02f, 5.08155823e-02f, -3.41595784e-02f, -3.75051238e-02f,
  -2.62826891e-03f, -2.55649704e-02f, 2.96369866e-02f, -2.29378268e-02f, 1.18333533e-01f, 1.51227832e-01f, 6.88682869e-02f, 1.39258653e-01f, 5.72556034e-02f, -1.79615095e-02f,
  1.75233886e-01f, 8.90662894e-02f, -4.24327970e-01f, -1.86619371e-01f, -1.73013210e-01f, 1.66832045e-01f, 2.03564599e-01f, 1.57406747e-01f, -1.78783815e-02f, -1.18941084e-01f,
  -6.00783862e-02f, -1.87891722e-01f, -2.46787667e-01f, -1.04997821e-01f, -3.72201167e-02f, -7.33045489e-02f, -3.54370505e-01f, -3.89115989e-01f, -2.40845159e-01f, 9.69747230e-02f,
  1.75753180e-02f, -8.78539830e-02f, -9.25452635e-02f, -1.65197581e-01f, -7.39761367e-02f, -1.03793569e-01f, -8.91953856e-02f, -1.94628052e-02f, 3.67178991e-02f, -3.62632006e-01f,
  -2.62014866e-01f, -1.37812109e-03f, -5.34637570e-02f, -1.30960390e-01f, -9.54028293e-02f, -4.30090427e-02f, -7.73590356e-02f, -2.09203169e-01f, -8.96909460e-02f, -8.70397240e-02f,
  -1.91836864e-01f, -3.48623320e-02f, -1.50453895e-01f, -4.94992211e-02f, -6.76059797e-02f, -1.59507588e-01f, -6.27807826e-02f, -2.03061596e-01f, -1.27137497e-01f, 5.86327491e-03f,
  -1.50760546e-01f, -4.72547561e-02f, -3.09330001e-02f, 1.92108694e-02f, -7.05347136e-02f, -1.64930746e-01f, -2.00940222e-02f, -6.05762936e-02f, 2.52729766e-02f, -1.16685130e-01f,
  -1.35416418e-01f, -2.41166931e-02f, 2.38424633e-02f, -1.35947336e-02f, 3.21853459e-02f, -5.03367418e-03f, -1.23464689e-01f, 1.41225094e-02f, 1.47544211e-04f, 1.19127948e-02f,
  -5.41093647e-02f, -4.08422993e-03f, -7.80274421e-02f, 2.53306162e-02f, -3.08541190e-02f, -8.07275772e-02f, -2.48281416e-02f, 3.81062292e-02f, -3.07921842e-02f, -3.91301885e-02f,
  1.57044642e-02f, -5.45911258e-03f, 1.92867173e-03f, -4.69180532e-02f, 3.35293710e-02f, -5.64972311e-02f, -2.91241501e-02f, 6.13648072e-02f, 1.56436558e-03f, -9.36952159e-02f,
  1.37493044e-01f, -3.32696065e-02f, -8.21285322e-02f, -4.30294536e-02f, -5.73810227e-02f, -5.79919182e-02f, -6.90068752e-02f, -1.80284493e-02f, -3.31546552e-02f, -1.86884925e-02f,
  1.12149017e-02f, -6.31658137e-02f, -1.99639946e-02f, -1.98268350e-02f, 1.75536387e-02f, -3.40540968e-02f, -9.20598302e-03f, -8.45824629e-02f, 4.10181191e-03f, -9.32155922e-02f,
  -2.82153301e-02f, 2.37101316e-02f, 1.78064853e-02f, -6.43206015e-02f, 1.25224432e-02f, -2.27615405e-02f, 3.62698510e-02f, -4.70589772e-02f, 6.50568008e-02f, 1.11703739e-01f,
  -8.15350339e-02f, 1.88193679e-01f, -1.11816481e-01f, -8.74170512e-02f, -9.28430236e-05f, -1.19469121e-01f, 1.99531410e-02f, -1.44003138e-01f, -1.21565737e-01f, 4.57800776e-02f,
  2.57004023e-01f, 8.41850787e-02f, 1.80108845e-02f, -8.93081725e-02f, -1.25482410e-01f, -2.21146524e-01f, -2.91453272e-01f, -2.39677116e-01f, -1.44303054e-01f, 6.66531250e-02f,
  -3.61263677e-02f, -8.94870907e-02f, -5.97960092e-02f, -1.15046248e-01f, -8.96371808e-03f, -1.14465080e-01f, 1.12738959e-01f, 1.15493998e-01f, 1.96492687e-01f, 1.06425501e-01f,
  1.38327688e-01f, 1.10019252e-01f, -1.27398983e-01f, -5.08866534e-02f, 1.70162041e-02f, -5.65551408e-02f, -9.16980952e-02f, -6.52857050e-02f, 5.28602265e-02f, -8.24425071e-02f,
  3.64247300e-02f, 3.56488824e-02f, -1.72452594e-03f, -2.57120822e-02f, -5.30186594e-02f, 2.25707348e-02f, -4.45756093e-02f, -9.98579487e-02f, -6.59818798e-02f, 5.78861721e-02f,
  -7.59251975e-03f, 1.61448017e-01f, 3.27651650e-02f, -3.99995446e-02f, 5.64081073e-02f, -9.65509489e-02f, -1.30917933e-02f, -2.54039932e-02f, -8.77921209e-02f, 2.17911806e-02f,
  -4.84789535e-03f, 1.06275529e-01f, 9.01144817e-02f, 8.16277489e-02f, 1.09422930e-01f, 1.01648577e-01f, 9.59282890e-02f, 1.45967215e-01f, 7.29881823e-02f, 4.59336042e-02f,
  1.32532358e-01f, 8.35518092e-02f, 7.14222044e-02f, 3.83806340e-02f, 4.39030156e-02f, 1.07668884e-01f, 7.51173943e-02f, 1.71380192e-02f, 1.15448371e-01f, 4.67322059e-02f,
  9.07712728e-02f, 4.85547483e-02f, 1.28786102e-01f, 5.71977235e-02f, -4.26790230e-02f, 5.48973829e-02f, 5.85810542e-02f, 8.81253481e-02f, 1.14178628e-01f, 1.01080298e-01f,
  6.08867779e-02f, -6.09778836e-02f, -1.16587318e-01f, -3.29134949e-02f, -4.05341536e-02f, -4.05382589e-02f, 8.77029914e-03f, -8.72764662e-02f, -1.67567171e-02f, -1.44019118e-03f,
  2.36561242e-02f, -8.39342996e-02f, -9.60523412e-02f, -8.11824203e-02f, -1.32337958e-01f, -1.16145559e-01f, 2.96123493e-02f, 2.54789367e-03f, -1.25868902e-01f, 1.33918887e-02f,
  -1.75363526e-01f, -2.08836809e-01f, -1.70527712e-01f, -9.68701690e-02f, -1.09038830e-01f, -1.35897279e-01f, -1.09412940e-02f, -1.19927526e-01f, -2.52608865e-01f, -1.89855635e-01f,
  -3.48478779e-02f, 1.90758407e-01f, 8.72786716e-02f, 1.02191955e-01f, 1.15975586e-03f, -9.83204246e-02f, -2.58488040e-02f, -2.21384153e-01f, -1.52101964e-01f, 4.70266677e-02f,
  2.45756824e-02f, -2.90295072e-02f, -4.82474938e-02f, 3.64205576e-02f, -9.98383537e-02f, 9.48872492e-02f, 1.24119855e-01f, 8.19201488e-03f, -3.26448381e-01f, -1.68229982e-01f,
  1.25985490e-02f, -1.55999996e-02f, -2.68505923e-02f, -3.86874750e-02f, 8.01063050e-03f, -9.19150263e-02f, -1.72059983e-02f, 1.20720960e-01f, 6.08410165e-02f, 2.60797679e-01f,
  -7.55307227e-02f, -1.29878493e-02f, -2.31488138e-01f, -8.76778811e-02f, -5.57409860e-02f, -2.05988452e-01f, -2.15362728e-01f, -1.36473089e-01f, -6.36815205e-02f, -1.21086545e-01f,
  -5.45172133e-02f, -7.72304609e-02f, -8.09654072e-02f, -1.82911023e-01f, -1.62482217e-01f, -8.16338956e-02f, -6.16896898e-02f, -2.37169843e-02f, -1.94558308e-01f, -1.06941886e-01f,
  3.39065157e-02f, -5.63130751e-02f, -5.39225340e-02f, -2.08704263e-01f, -1.85630947e-01f, -1.76592976e-01f, -8.51134583e-02f, -2.13237599e-01f, -1.95154533e-01f, -2.12581098e-01f,
  5.60213961e-02f, 1.30320624e-01f, 1.63589731e-01f, 9.08363014e-02f, 2.63869405e-01f, 1.93884477e-01f, 2.33621508e-01f, 1.26271576e-01f, 2.06932411e-01f, 1.33475944e-01f,
  1.05997726e-01f, 1.81428418e-01f, 1.05213143e-01f, 8.35293233e-02f, 5.51995710e-02f, 1.42562568e-01f, 1.17874399e-01f, 1.33969381e-01f, 3.03659029e-02f, 6.80099651e-02f,
  9.59590226e-02f, 8.36381763e-02f, 6.01952225e-02f, 1.24838531e-01f, 1.75907686e-01f, 1.30421638e-01f, 1.58419132e-01f, 1.21783502e-01f, 1.35147780e-01f, 1.72307298e-01f,
  -2.35470936e-01f, -2.40610778e-01f, -1.80168718e-01f, -2.33006775e-01f, -2.31207624e-01f, -1.57362714e-01f, -2.09400393e-02f, -1.67813614e-01f, -5.51938042e-02f, -1.89192012e-01f,
  -5.38078621e-02f, -1.65821090e-01f, -4.87305447e-02f, -2.03166738e-01f, -9.28974375e-02f, -2.11770236e-01f, -1.20780945e-01f, -1.16748236e-01f, -1.21309288e-01f, -9.90013257e-02f,
  -4.31341007e-02f, -3.05640221e-01f, -2.25281343e-01f, -2.55782902e-01f, -1.81065276e-01f, -1.81425422e-01f, -2.91083425e-01f, -3.06421787e-01f, -3.87138516e-01f, -2.89394468e-01f,
  3.52982432e-01f, -1.65194586e-01f, 1.86138749e-01f, 3.72810990e-01f, 4.03549999e-01f, 1.34423584e-01f, -1.06699303e-01f, 7.36971706e-05f, 1.12371542e-01f, 2.36356016e-02f,
  -7.50269964e-02f, 5.03280684e-02f, 8.17132592e-02f, -4.40909574e-03f, -7.60607645e-02f, -5.81964524e-03f, 1.12372413e-01f, 1.12752214e-01f, 1.52212963e-01f, 1.80793419e-01f,
  9.50577185e-02f, 2.80433357e-01f, 2.34156325e-01f, 9.34244972e-03f, 1.37687206e-01f, 9.10363644e-02f, 1.02115043e-01f, 1.64395243e-01f, -2.89109424e-02f, -1.32072009e-02f,
  -5.56329116e-02f, 1.16803154e-01f, 1.13205098e-01f, 6.65487796e-02f, 1.98412001e-01f, 5.92425913e-02f, 2.28435341e-02f, 9.61154848e-02f, 1.21293999e-01f, 1.28884465e-01f,
  1.81264549e-01f, 1.19192295e-01f, 1.89787775e-01f, 2.52408758e-02f, 1.52550906e-01f, 1.14593096e-01f, -1.88580453e-02f, 5.31499200e-02f, 1.44622818e-01f, 4.48953845e-02f,
  1.01128608e-01f, 9.92156416e-02f, 1.20852008e-01f, -1.03244253e-01f, 2.69543435e-02f, 2.60246824e-02f, 2.35847309e-02f, -2.39549652e-02f, -8.99738893e-02f, -6.40704706e-02f,
  2.92459764e-02f, -6.84831738e-02f, -3.93299088e-02f, -6.22366667e-02f, -3.35335098e-02f, -1.02587290e-01f, 1.28353212e-03f, 2.93249674e-02f, 6.23964481e-02f, -7.45372800e-03f,
  4.88641225e-02f, -4.14064601e-02f, -5.90179637e-02f, -1.69790778e-02f, 3.91812250e-02f, 1.52548298e-01f, -9.57400799e-02f, -8.75664502e-02f, -4.56992611e-02f, -1.76239088e-02f,
  6.52941316e-02f, 5.83862253e-02f, 4.59589586e-02f, -1.32515922e-01f, 3.71781960e-02f, 2.32147202e-02f, 5.98993525e-02f, 1.11220228e-02f, -4.21595294e-03f, 1.40273303e-01f,
  -1.51570225e-02f, 9.09199342e-02f, 3.19153741e-02f, -7.43078738e-02f, 1.16572782e-01f, -3.46785188e-02f, 1.29718417e-02f, 3.69042763e-03f, 1.06169201e-01f, 5.77464281e-03f,
  3.21876258e-02f, -2.07404252e-02f, -1.06606102e-02f, -4.84679751e-02f, 1.06580041e-01f, 6.14799932e-02f, 2.40219086e-02f, 9.36991721e-02f, -9.28333029e-03f, -1.74293891e-02f,
  3.69801484e-02f, 4.06964449e-03f, -1.20839238e-01f, -9.27709192e-02f, -8.80587399e-02f, 8.66681454e-04f, -3.81757356e-02f, -6.86737671e-02f, -1.01455837e-01f, -2.04967469e-01f,
  -1.54311270e-01f, 2.35312730e-01f, -6.42773658e-02f, -2.01109931e-01f, 2.18619704e-02f, 2.00878888e-01f, 4.49839383e-01f, 2.27912411e-01f, -4.73791696e-02f, 1.07624523e-01f,
  -3.20803672e-02f, -1.50689036e-01f, -1.56033024e-01f, -1.93091873e-02f, 1.83077857e-01f, 3.89601499e-01f, 2.81281114e-01f, -5.18361665e-02f, -9.97027382e-02f, 1.29646491e-02f,
  1.63055435e-01f, 2.51732655e-02f, 3.06091551e-02f, 4.98260520e-02f, -7.58721307e-02f, -2.14645520e-01f, 4.14548330e-02f, 4.22540605e-02f, 1.62927777e-01f, 1.50791138e-01f,
  -2.51825064e-01f, 1.05706073e-01f, -2.33544968e-02f, -2.76372917e-02f, -4.28093225e-02f, 2.58546323e-02f, 3.11355796e-02f, -4.72609550e-02f, 2.48889625e-02f, -2.45883800e-02f,
  -2.58882735e-02f, 5.70375510e-02f, -2.12470386e-02f, -3.08102407e-02f, 6.30861521e-02f, 2.61982866e-02f, 1.19053841e-01f, 3.97958271e-02f, 9.77417752e-02f, 1.09837957e-01f,
  7.78127685e-02f, 3.93589251e-02f, 2.26996727e-02f, 1.20633073e-01f, 6.23471476e-02f, -4.36045863e-02f, -5.81633672e-03f, 5.94220385e-02f, 9.96003523e-02f, -4.80537117e-02f,
  -6.28164262e-02f, -2.64393073e-02f, -5.31896278e-02f, -9.53556038e-03f, -3.69894430e-02f, 1.10676251e-02f, 6.55707438e-04f, 2.94708852e-02f, -4.16802652e-02f, -1.00426167e-01f,
  7.46808015e-03f, 9.34765786e-02f, 2.62653530e-02f, 1.21112997e-02f, -2.15905812e-02f, 4.73827831e-02f, -1.66546721e-02f, 1.69449728e-02f, 3.45146284e-02f, 6.57589757e-04f,
  -3.09303906e-02f, -3.80653851e-02f, -5.11872880e-02f, -1.92812961e-02f, 6.79455698e-02f, 2.37506293e-02f, -1.79243814e-02f, 2.43590884e-02f, -3.24436352e-02f, -2.71704923e-02f,
  -7.77835101e-02f, 1.51505545e-01f, 4.13110964e-02f, 1.02269158e-01f, 4.01493758e-02f, 1.57046150e-02f, -1.36194108e-02f, 7.46122450e-02f, 3.36643099e-03f, 8.75496492e-02f,
  -2.01056004e-02f, 2.24361476e-02f, -2.10882593e-02f, 3.91700864e-02f, -1.02579221e-02f, 6.39904961e-02f, 1.34047255e-01f, -4.73238248e-03f, 8.77447426e-02f, 3.81710380e-02f,
  7.69308954e-02f, 1.44133940e-01f, -1.17659152e-01f, 1.41071323e-02f, -1.19027859e-02f, -9.24452320e-02f, -8.22295770e-02f, 4.31027962e-03f, -1.70444716e-02f, 7.42313936e-02f,
  -9.04549882e-02f, -2.36501917e-01f, -2.71042287e-02f, -2.42365580e-02f, -1.46631360e-01f, -5.62646538e-02f, -1.01574644e-01f, 8.14854875e-02f, 9.56877396e-02f, 1.99691616e-02f,
  7.34772980e-02f, 1.71416625e-01f, 2.31292024e-01f, 1.43310681e-01f, 1.40628770e-01f, -7.76256025e-02f, -2.25756437e-01f, -3.22148167e-02f, 1.36038586e-01f, 1.09226257e-02f,
  -3.45281772e-02f, -1.02245688e-01f, 8.88468176e-02f, 1.43264264e-01f, 5.20298630e-02f, 1.33465394e-01f, 4.95983884e-02f, -2.62873042e-02f, -6.87410086e-02f, -1.80148154e-01f,
  1.11583203e-01f, -1.61154270e-01f, 7.14679137e-02f, -8.54445994e-02f, 2.31405329e-02f, 2.52986941e-02f, -2.10670382e-03f, 9.64717194e-02f, 6.97347848e-03f, 3.68579254e-02f,
  -6.67213649e-02f, -2.88161989e-02f, 7.80633688e-02f, -3.93360341e-03f, 2.77653653e-02f, 4.83774543e-02f, 4.39054780e-02f, 1.07371859e-01f, 4.50743735e-02f, -8.85442458e-03f,
  -1.49113119e-01f, -2.11641163e-01f, -2.05434114e-02f, 1.26522314e-02f, 1.09789722e-01f, -1.35314679e-02f, 9.79752187e-03f, -5.52302822e-02f, -1.53548568e-02f, -5.84583431e-02f,
  3.95357646e-02f, -2.55636778e-02f, 6.26809672e-02f, -3.25326435e-02f, 4.71546827e-03f, 4.10224311e-02f, 2.90053040e-02f, -7.65420347e-02f, 7.93844238e-02f, 9.67744365e-03f,
  4.16313931e-02f, 1.51310125e-02f, -3.53697762e-02f, 1.00285718e-02f, -1.51558947e-02f, -3.99337672e-02f, 1.70144979e-02f, 1.52333202e-02f, 3.27229835e-02f, 3.61863188e-02f,
  -6.49667694e-04f, 3.17389593e-02f, -1.64241921e-02f, 2.32206471e-02f, 2.27470882e-03f, 4.90973443e-02f, 9.68227163e-02f, -1.88214350e-02f, 4.89631854e-02f, -1.78968534e-02f,
  2.14801669e-01f, 6.49472773e-02f, 6.57081753e-02f, 5.09287417e-03f, 1.78817206e-03f, 5.67506859e-03f, -9.56085101e-02f, -9.55564007e-02f, -3.17355320e-02f, -2.21797470e-02f,
  2.12167539e-02f, 1.65074551e-03f, 2.42899749e-02f, -4.99858633e-02f, -1.10389283e-02f, 6.04876578e-02f, -1.05900139e-01f, -4.77970801e-02f, 5.59771992e-02f, 7.20893666e-02f,
  -1.00182876e-01f, -7.94972256e-02f, -4.63811029e-03f, -1.35276921e-03f, 5.21021150e-02f, -2.84186751e-02f, 4.26644422e-02f, 1.35044694e-01f, 1.26841858e-01f, 1.15127333e-01f,
  2.40095317e-01f, -2.93557364e-02f, 5.34048259e-01f, -1.58845924e-03f, 1.44774973e-01f, 2.10731998e-01f, 1.71651930e-01f, 4.70694117e-02f, -2.41559803e-01f, -4.10912596e-02f,
  -1.47792557e-02f, -2.41199329e-01f, -2.05698609e-01f, -1.85314089e-01f, 2.95417774e-02f, 1.82528108e-01f, 2.18975246e-01f, 2.18103960e-01f, 4.44533750e-02f, 1.26767233e-02f,
  -2.44694188e-01f, -1.37661874e-01f, -8.16022977e-02f, -2.80842539e-02f, -4.82574441e-02f, -1.30435690e-01f, 6.50388151e-02f, -4.57539177e-03f, 1.10790014e-01f, 2.18779162e-01f,
  3.01934540e-01f, 2.76310503e-01f, -6.21143095e-02f, 1.94734093e-02f, 7.62739480e-02f, -8.67214426e-02f, -2.87663308e-03f, 1.00002519e-03f, -7.55223408e-02f, 9.23768245e-03f,
  5.12293763e-02f, -8.78623500e-02f, 1.17592490e-03f, 3.21375057e-02f, 6.63686842e-02f, 7.36172587e-05f, -8.77851620e-03f, 1.47234067e-01f, 9.65433791e-02f, 7.55279660e-02f,
  -1.27896249e-01f, 1.49194688e-01f, 2.29834408e-01f, 8.40730816e-02f, 8.28448609e-02f, 3.00807841e-02f, 8.13636705e-02f, 5.46633862e-02f, 9.36354250e-02f, 6.67668954e-02f,
  -3.81523743e-02f, 5.37025407e-02f, 3.99240255e-02f, 5.24947904e-02f, -6.54901341e-02f, 3.71634997e-02f, 9.94519889e-03f, 3.52254547e-02f, -8.42650328e-03f, -2.96266563e-02f,
  -1.33466609e-02f, -1.04536267e-03f, 3.60842310e-02f, 6.53036535e-02f, -1.27947271e-01f, 1.08259723e-01f, 5.23586236e-02f, -3.93658988e-02f, 6.64039254e-02f, -2.64637321e-02f,
  3.02569102e-02f, 1.60496712e-01f, -5.09561319e-03f, 7.37622604e-02f, 3.99203710e-02f, 2.84298323e-02f, 1.16973231e-03f, -9.66925621e-02f, -3.33247595e-02f, -1.32761209e-03f,
  -3.17006707e-01f, 3.83927040e-02f, 6.85755759e-02f, -5.59258685e-02f, 5.67971244e-02f, -7.52962986e-03f, 7.09298626e-02f, -5.38263135e-02f, 1.66126452e-02f, 2.90274229e-02f,
  4.67238836e-02f, 4.67804149e-02f, -1.01203909e-02f, 7.28286942e-03f, -2.33900379e-02f, 4.54250686e-02f, -4.19797525e-02f, -1.42459990e-02f, 1.01255430e-02f, -2.58231466e-03f,
  -1.31766260e-01f, -2.95155365e-02f, 7.40043214e-03f, -2.04031263e-02f, 9.32188146e-03f, 2.49728356e-02f, -8.00921842e-02f, -1.40049355e-02f, -8.88621435e-02f, -2.43102640e-01f,
  -4.19807166e-01f, 1.35598019e-01f, -2.21915096e-01f, 1.04545452e-01f, 2.52933297e-02f, -2.78005481e-01f, -1.30258664e-01f, -1.92272037e-01f, 2.26609297e-02f, 7.90905356e-02f,
  4.12526578e-02f, 2.14268714e-01f, 1.88275009e-01f, 2.29987372e-02f, -1.13244452e-01f, -8.51062164e-02f, 4.71953675e-02f, -3.09338897e-01f, -3.42846990e-01f, -2.71829069e-01f,
  -1.47732291e-02f, 9.35271233e-02f, -1.63304076e-01f, 1.74603816e-02f, 2.62972713e-01f, 1.28127456e-01f, 1.19375385e-01f, 1.74890533e-02f, 3.63486223e-02f, 1.78124294e-01f,
  7.85020888e-02f, -8.58914554e-02f, -2.33226910e-01f, -5.07552065e-02f, -2.60611102e-02f, -1.30045876e-01f, -1.14090346e-01f, -5.92626631e-02f, -1.73822537e-01f, -1.96429472e-02f,
  -6.12090863e-02f, -1.38635814e-01f, -1.73785929e-02f, 2.72371061e-02f, -6.97855055e-02f, -1.00674510e-01f, -2.32393872e-02f, -1.25931963e-01f, -7.64557794e-02f, -8.61308947e-02f,
  4.12312262e-02f, -9.65129137e-02f, -7.05671310e-02f, -5.87760331e-03f, -6.63896278e-02f, -1.49299711e-01f, -5.04314490e-02f, -9.12732631e-02f, -1.20386571e-01f, -5.44911996e-02f,
  7.20487116e-03f, 4.94318828e-03f, 1.05439954e-01f, 1.30699068e-01f, 7.79052600e-02f, 1.47145659e-01f, 1.44723654e-01f, 1.82900310e-01f, 6.62503242e-02f, 1.14187941e-01f,
  8.96904245e-02f, 7.28257373e-02f, 9.78239626e-02f, 4.11677286e-02f, 1.56303570e-01f, 1.33281067e-01f, 1.04422443e-01f, 1.25278592e-01f, 6.79507852e-02f, 1.97830230e-01f,
  4.90224734e-02f, 2.83905715e-02f, 1.41283765e-01f, 6.67928457e-02f, 2.86709014e-02f, 7.84130767e-02f, 7.98639283e-02f, 5.81489243e-02f, 1.89759716e-01f, 2.20380053e-02f,
  1.54643431e-01f, -2.49192551e-01f, -5.06387167e-02f, -8.65127146e-02f, -1.04668409e-01f, -4.78276610e-02f, -3.16767544e-02f, -1.40226409e-01f, -3.65160517e-02f, -1.00263402e-01f,
  -1.65790189e-02f, -1.03600867e-01f, -4.96814176e-02f, 6.27070782e-04f, -9.54003930e-02f, 1.34476675e-02f, 1.03496708e-01f, -8.03906238e-04f, -1.03290789e-01f, 5.39723225e-02f,
  -5.68660125e-02f, -1.06977597e-01f, -4.38201502e-02f, -3.93669680e-03f, -4.03876081e-02f, -7.51274005e-02f, -2.27213651e-02f, 6.87311310e-03f, -1.68090314e-01f, -7.07075372e-02f,
  -4.56781775e-01f, -3.47215921e-01f, 5.05417697e-02f, 1.55670360e-01f, 1.70941681e-01f, -1.86622411e-01f, -4.79746819e-01f, -1.56798393e-01f, 1.36265725e-01f, -2.08109096e-01f,
  -8.48089531e-02f, 5.95861524e-02f, 7.86505267e-02f, 5.25783142e-03f, -2.49798238e-01f, -2.11786419e-01f, 7.97904283e-02f, 1.45408437e-01f, -5.04657030e-02f, -3.42020355e-02f,
  1.18293025e-01f, 7.45018795e-02f, 9.87972170e-02f, 7.98029676e-02f, 1.76069885e-01f, 1.90231130e-01f, 1.56307161e-01f, 6.16597980e-02f, -4.59628776e-02f, 2.82991946e-01f,
  -3.34591158e-02f, -1.78032890e-01f, 6.12170156e-03f, 5.20325564e-02f, 1.40965655e-01f, 1.59309823e-02f, -7.09498897e-02f, 1.33212432e-01f, 8.01783726e-02f, 3.32729444e-02f,
  2.59359367e-02f, 1.18486710e-01f, 1.15861729e-01f, 8.38260576e-02f, 4.15106453e-02f, 5.30500524e-02f, 4.88153547e-02f, 6.55254275e-02f, 3.19904350e-02f, -4.05262224e-02f,
  5.69607764e-02f, -6.58172462e-03f, -1.14332318e-01f, -8.63055512e-02f, -3.52200062e-04f, 5.63510284e-02f, 4.95176129e-02f, 1.05174696e-02f, 5.51352799e-02f, -6.72942027e-02f,
  -5.53334318e-02f, 6.80886582e-02f, 8.52755010e-02f, 4.50336002e-03f, 7.64305815e-02f, 7.20960367e-03f, 2.66129132e-02f, 2.12996523e-03f, 6.96210982e-03f, 3.31008472e-02f,
  3.14993449e-02f, -7.51871616e-02f, 4.96800197e-03f, -1.49508016e-02f, 2.42508221e-02f, 7.30126202e-02f, 4.42812918e-03f, 7.48382369e-03f, 3.36666033e-02f, 8.74723196e-02f,
  2.95160785e-02f, 4.22150716e-02f, 5.21120727e-02f, 4.76731844e-02f, 2.86550634e-02f, 1.77751835e-02f, -1.42444829e-02f, 8.01740661e-02f, 1.39136342e-02f, -1.00485124e-02f,
  -1.32283509e-01f, -3.58376391e-02f, -1.13816492e-01f, -8.11349228e-02f, 2.40642428e-02f, 1.00947479e-02f, 4.16703112e-02f, -2.24841237e-02f, -6.26395419e-02f, -7.79433921e-02f,
  -7.26174563e-02f, -9.43354294e-02f, -5.87406429e-03f, 2.21312679e-02f, -4.05413620e-02f, -3.81840728e-02f, -1.56720877e-02f, -2.72834729e-02f, -6.48666769e-02f, 1.27451764e-02f,
  2.51237694e-02f, -1.15329109e-01f, -2.28717715e-01f, -8.15378204e-02f, -3.63849476e-02f, -1.09152019e-01f, -5.03210872e-02f, -4.33964916e-02f, -1.93857074e-01f, -1.40040666e-01f,
  -3.55580181e-01f, -8.34070817e-02f, 2.91545153e-01f, -1.25744760e-01f, -1.08011970e-02f, -1.81212962e-01f, -2.33969867e-01f, -1.83127552e-01f, -9.75729972e-02f, -1.18969932e-01f,
  -9.70770270e-02f, 1.36703774e-01f, 6.23545609e-02f, 1.75798148e-01f, -4.95772064e-02f, 7.99191520e-02f, 2.03365847e-01f, 1.60386503e-01f, -1.25288337e-01f, -1.11032482e-02f,
  4.76899520e-02f, -4.36027981e-02f, -5.16718589e-02f, 8.80059600e-02f, 7.20847547e-02f, 6.34831813e-05f, -9.67737869e-04f, 6.64960891e-02f, 9.78044420e-02f, 3.80381227e-01f,
  -1.09407576e-02f, -1.02367461e-01f, 4.74362448e-02f, -1.04785450e-01f, -3.78423706e-02f, -3.03375088e-02f, -3.06042861e-02f, -2.48546689e-03f, -1.51936719e-02f, 6.64455667e-02f,
  4.62837666e-02f, 4.48943265e-02f, -1.10863656e-01f, -1.83324516e-03f, -9.54668447e-02f, 3.02747916e-02f, -1.10667711e-02f, 1.31147698e-01f, 2.31478792e-02f, 8.06233808e-02f,
  1.18941434e-01f, 1.94735304e-02f, -1.75407290e-01f, -2.51820292e-02f, -5.78113534e-02f, -4.86735478e-02f, -8.75193775e-02f, -1.49703948e-02f, -8.31398740e-02f, -1.60200328e-01f,
  -1.02229947e-02f, -5.39000817e-02f, -3.82707343e-02f, -8.37945472e-03f, -2.12676376e-02f, 3.12054437e-02f, 8.53691399e-02f, -5.05264960e-02f, 2.89846379e-02f, 3.95031832e-02f,
  -6.61295885e-03f, -9.36812256e-04f, -2.72808895e-02f, -5.32762287e-03f, 5.82235008e-02f, -3.24564651e-02f, 1.83035098e-02f, 2.49552019e-02f, 8.38321000e-02f, -2.81243697e-02f,
  9.46691539e-03f, 2.23060381e-02f, 8.16773176e-02f, 7.32278749e-02f, 7.63428435e-02f, 1.40571995e-02f, 7.87698478e-02f, 4.10758518e-02f, -1.69671085e-02f, -1.92590747e-02f,
  -3.14275324e-01f, 2.36979295e-02f, -1.38805155e-02f, -5.13712093e-02f, -5.89202903e-02f, -7.44209737e-02f, -3.95070128e-02f, 3.13267559e-02f, 4.02534343e-02f, -9.40675661e-02f,
  -6.42338768e-02f, -1.22271523e-01f, 2.00006738e-02f, 1.98062416e-02f, -4.57644090e-02f, -6.25760406e-02f, -7.58231729e-02f, -1.33907776e-02f, -6.19931743e-02f, -5.89975715e-02f,
  -1.84867401e-02f, -2.16242552e-01f, -1.26245320e-01f, -8.72142315e-02f, -9.68738832e-03f, -2.01455548e-01f, -1.35521412e-01f, -6.98917881e-02f, -3.06687117e-01f, -1.73117012e-01f,
  2.70256996e-01f, -2.14627907e-01f, 2.35984057e-01f, 5.72777167e-02f, -4.35995758e-02f, -2.09617522e-02f, -1.97314501e-01f, -2.07531787e-02f, 6.38531521e-02f, -1.38596356e-01f,
  -2.81894773e-01f, 7.19679892e-02f, -2.11983407e-03f, 1.30108565e-01f, 2.25132570e-01f, 7.84054026e-02f, 1.57035455e-01f, 2.92626023e-01f, 3.63249362e-01f, -4.61365022e-02f,
  -1.04554333e-01f, 3.12383007e-02f, 8.89332518e-02f, 1.22439653e-01f, -1.24361366e-01f, 1.19577646e-01f, -2.30602659e-02f, 4.76910137e-02f, -3.21927406e-02f, 2.05670912e-02f,
  2.61109392e-03f, -1.20110195e-02f, 1.10069834e-01f, -8.07359517e-02f, 5.43163763e-03f, -2.26068161e-02f, -7.32075125e-02f, -7.64876828e-02f, -7.98875466e-02f, -1.21955415e-02f,
  -7.44095370e-02f, -1.11594446e-01f, -4.51771915e-02f, -6.52068704e-02f, -5.45911416e-02f, -1.37110651e-01f, -1.15884937e-01f, -2.27603056e-02f, -3.48225492e-03f, -7.84838125e-02f,
  -5.83208203e-02f, -4.19282429e-02f, 6.31394759e-02f, -1.08761534e-01f, -4.87957411e-02f, 4.13429141e-02f, -3.77784222e-02f, 3.23613919e-02f, 4.43736017e-02f, -1.56458497e-01f,
  1.50445271e-02f, 4.42010611e-02f, 5.46755269e-02f, -6.92126751e-02f, -5.46792485e-02f, -6.06747484e-03f, -4.25153859e-02f, 6.09723702e-02f, 4.04339507e-02f, -8.22623521e-02f,
  1.56386830e-02f, 1.22776754e-01f, 2.04777624e-02f, -2.48525459e-02f, 1.85071081e-02f, 7.60870650e-02f, -1.76584776e-02f, 1.05783083e-02f, 1.18889268e-02f, 5.51768905e-03f,
  4.10646014e-02f, -7.13511184e-02f, 1.33813648e-02f, -2.11241990e-02f, -1.41969575e-02f, 1.13489524e-01f, 8.26244503e-02f, 7.39481002e-02f, 1.28038563e-02f, -1.41689312e-02f,
  -4.81771566e-02f, 1.74740255e-01f, -1.71896040e-01f, 8.55669903e-04f, -2.54525561e-02f, -1.65845051e-01f, -4.65653650e-02f, -7.09109306e-02f, -3.00424974e-02f, -1.31264523e-01f,
  -1.99053325e-02f, -1.94365755e-02f, -3.22106406e-02f, 1.61737553e-03f, 1.04455976e-02f, -9.21927616e-02f, -8.24471265e-02f, 9.74975806e-03f, -4.94503416e-04f, -3.96930277e-02f,
  -1.94605365e-02f, -7.36867860e-02f, -7.23146647e-02f, -9.75622684e-02f, 2.56099161e-02f, 9.41521972e-02f, -8.95280316e-02f, -1.32398546e-01f, 7.98702389e-02f, -1.92716554e-01f,
  7.95701146e-02f, 3.70582566e-02f, -3.23063195e-01f, 1.04165815e-01f, 5.39354980e-02f, -1.99198388e-02f, -1.45828709e-01f, 1.00798607e-01f, 1.84589282e-01f, 1.20703457e-02f,
  1.55634016e-01f, 3.67238611e-01f, 2.05698848e-01f, 1.30928263e-01f, 1.16344362e-01f, -1.43989354e-01f, -1.02032907e-01f, -1.18999675e-01f, 1.33022457e-01f, 1.74426585e-01f,
  1.86040536e-01f, 2.43145227e-01f, 1.03008665e-01f, 2.12998033e-01f, 1.86391398e-01f, 2.94931412e-01f, -7.97630288e-03f, 7.00406954e-02f, 1.42494068e-01f, -1.85174078e-01f,
  -1.72680095e-01f, -1.15743086e-01f, 8.25872049e-02f, 2.77273059e-01f, 1.89605542e-02f, -5.14612608e-02f, -7.71590834e-03f, -9.21740457e-02f, 1.79320455e-01f, 1.65314954e-02f,
  1.84510782e-01f, 2.08528817e-01f, 1.16140112e-01f, 8.10154453e-02f, 4.09968570e-02f, 4.55797426e-02f, 1.02693021e-01f, 2.10925508e-02f, 2.72497199e-02f, 2.46545468e-02f,
  1.94679037e-01f, 1.56632829e-02f, -1.15341740e-02f, 1.43056680e-02f, 6.76936656e-02f, 1.55936629e-01f, 7.73396567e-02f, -2.75028702e-02f, 9.50481370e-02f, 8.13580677e-02f,
  -1.86476354e-02f, 6.85865283e-02f, 7.25665689e-02f, -5.27029708e-02f, 2.58642714e-02f, -6.21149540e-02f, 2.67724339e-02f, 1.89131033e-02f, 4.45213392e-02f, -5.49026467e-02f,
  -5.68259396e-02f, -1.32942237e-02f, -5.24064340e-02f, -3.18842083e-02f, 1.05876697e-03f, -1.13553688e-01f, -2.96634547e-02f, 1.06638763e-02f, -3.15706134e-02f, -3.50391716e-02f,
  -8.78369659e-02f, -1.01430573e-01f, -1.01098634e-01f, -1.15596116e-01f, -1.75905153e-01f, -1.56249896e-01f, -1.63277730e-01f, -2.59394292e-02f, -1.00500263e-01f, -1.84375152e-01f,
  3.87324840e-01f, 1.32250920e-01f, 1.81657463e-01f, 1.00824602e-01f, 1.40532166e-01f, 1.45874515e-01f, 9.03841481e-02f, 1.85555920e-01f, 1.11570358e-01f, 8.87872949e-02f,
  1.31172165e-01f, 1.35289416e-01f, 1.25464976e-01f, 7.80421719e-02f, 1.16541520e-01f, 1.77309617e-01f, 2.28292659e-01f, 1.60010636e-01f, 2.03574896e-01f, 7.08455592e-02f,
  1.77234203e-01f, 1.61512762e-01f, 1.33959889e-01f, 9.93021280e-02f, 2.24639878e-01f, 1.22563228e-01f, 2.23567948e-01f, 6.22333661e-02f, 1.44640431e-01f, 1.55763119e-01f,
  4.60691273e-01f, -2.69778460e-01f, -2.27286890e-01f, -5.79433069e-02f, -4.80828226e-01f, -3.21755081e-01f, -4.61804092e-01f, -1.38904557e-01f, 1.33175373e-01f, -3.85886192e-01f,
  -3.09450388e-01f, 9.14633945e-02f, -2.05538198e-02f, 1.13554016e-01f, 2.19299316e-01f, -2.79829651e-01f, -1.04552671e-01f, 2.66635597e-01f, 2.94973552e-01f, 1.89236924e-02f,
  -3.12539563e-02f, 1.00299515e-01f, 3.92962366e-01f, 2.35761642e-01f, -9.26671475e-02f, -3.12046707e-02f, -1.66074529e-01f, -1.37219861e-01f, -1.36492208e-01f, -1.51307195e-01f,
  -1.97058037e-01f, 1.66725777e-02f, -5.83051741e-02f, 6.22184575e-02f, -1.05667472e-01f, 1.31456807e-01f, 2.18813848e-02f, 6.39554560e-02f, 1.57122407e-02f, -3.67731005e-02f,
  -3.13248374e-02f, -2.70965025e-02f, 7.35712424e-03f, -1.63228381e-02f, 8.57759174e-03f, -6.84482008e-02f, 5.62972352e-02f, 7.71677420e-02f, 4.75125127e-02f, -4.83863950e-02f,
  -1.00937054e-01f, -8.82629231e-02f, -7.85131976e-02f, -1.17216475e-01f, -2.05236431e-02f, -7.48629048e-02f, -1.59028158e-01f, 1.07266709e-01f, 1.71179697e-02f, 9.74721741e-03f,
  -9.18981954e-02f, -7.16020688e-02f, -4.50421274e-02f, 2.48194643e-04f, -3.43074352e-02f, -5.08979335e-02f, 1.72737073e-02f, -2.56528985e-02f, 1.11587951e-02f, -1.25294961e-02f,
  1.44424951e-02f, -3.13313827e-02f, 1.45143713e-03f, 4.96687666e-02f, -8.71119574e-02f, -3.20888832e-02f, -4.62560765e-02f, -3.50640789e-02f, -6.54390752e-02f, 9.79431067e-03f,
  -3.19397263e-02f, 4.87230830e-02f, -3.28685232e-02f, 3.20518538e-02f, -3.34728025e-02f, -2.30573048e-03f, 1.27669852e-02f, -1.48638822e-02f, -2.64952835e-02f, 6.66978806e-02f,
  9.09829661e-02f, -8.98965225e-02f, -7.60498196e-02f, 5.62551171e-02f, -2.34243795e-02f, 1.76744703e-02f, -1.24310881e-01f, -3.32436003e-02f, -1.60680637e-02f, -7.88620859e-03f,
  -1.76920723e-02f, 6.07435172e-03f, -4.32287790e-02f, -1.51136545e-02f, -1.71304010e-02f, 2.92445738e-02f, -8.58037770e-02f, -2.61085033e-02f, 5.98806702e-03f, -5.06681092e-02f,
  -1.43623920e-02f, -8.04324001e-02f, -1.50841370e-01f, -8.65710229e-02f, -3.09386887e-02f, -6.95242658e-02f, -9.72016081e-02f, -1.06692813e-01f, -1.82300899e-02f, -1.87744200e-01f,
  -7.99731538e-02f, -8.33482221e-02f, -3.54104429e-01f, 1.07694402e-01f, -7.27778673e-02f, -2.26175413e-01f, -3.56740743e-01f, -1.32546917e-01f, 7.09674209e-02f, -5.49847782e-02f,
  -1.10674255e-01f, -5.36988787e-02f, -1.69248983e-01f, -1.93328008e-01f, -2.36703545e-01f, -2.07181633e-01f, -8.22478086e-02f, -2.78228611e-01f, -3.18486124e-01f, -2.29098260e-01f,
  2.26722080e-02f, -8.94927308e-02f, -1.88390881e-01f, -7.54415914e-02f, 2.20064566e-01f, 6.76662195e-03f, 6.96903188e-03f, -3.82699072e-02f, -2.25591920e-02f, 2.02661589e-01f,
  -2.06548092e-03f, 1.57052740e-01f, -1.36921957e-01f, -1.34200841e-01f, -1.39514089e-01f, -1.82980061e-01f, -1.96089700e-01f, -1.66809216e-01f, -1.05995469e-01f, -1.44677684e-01f,
  -1.16502449e-01f, -1.26867995e-01f, -4.30347249e-02f, -2.03355238e-01f, -1.48623154e-01f, -2.25224718e-01f, -2.07002625e-01f, -2.68697947e-01f, -2.42068693e-01f, -1.12089992e-01f,
  -3.87074351e-02f, -1.94331422e-01f, -2.54151523e-01f, -2.90196598e-01f, -2.17212617e-01f, -1.39933839e-01f, -1.59132779e-01f, -3.46418954e-02f, -1.95808634e-01f, -9.55128148e-02f,
  -1.18513331e-02f, 5.24586858e-03f, -7.92005844e-03f, 1.05240174e-01f, 3.66958156e-02f, 1.09679490e-01f, 2.63232812e-02f, 2.31060926e-02f, 2.82783844e-02f, 1.28014207e-01f,
  5.38801448e-03f, 7.04917014e-02f, 1.07824877e-01f, 1.25364736e-01f, 3.66708972e-02f, 9.52094644e-02f, 5.17290905e-02f, 7.88721889e-02f, 1.14961360e-02f, 1.34487122e-01f,
  1.17597759e-01f, 2.52609868e-02f, 7.69420043e-02f, 6.32479414e-02f, 1.02770321e-01f, 1.01608574e-01f, 9.65515971e-02f, 1.23733729e-01f, 1.01605952e-01f, 1.07623450e-01f,
  -1.12699226e-01f, -1.82004333e-01f, -1.95999108e-02f, -7.15502873e-02f, -3.07749789e-02f, -2.72971578e-02f, -5.66129908e-02f, -1.09894350e-01f, -5.50135672e-02f, -1.37266815e-01f,
  -1.43674269e-01f, -1.31261632e-01f, -8.67113397e-02f, -1.47566378e-01f, -1.48709923e-01f, -1.72547147e-01f, -1.28128812e-01f, -1.16393887e-01f, -1.41581059e-01f, -1.53763562e-01f,
  -2.37103894e-01f, -1.78152010e-01f, -2.57316411e-01f, -2.51982301e-01f, -1.03176676e-01f, -2.27759033e-01f, -1.51161715e-01f, -2.29990408e-01f, -2.54264116e-01f, -2.81422764e-01f,
  -2.98810065e-01f, 2.88591143e-02f, -8.91628712e-02f, -6.96865767e-02f, 4.02309261e-02f, -8.22346881e-02f, -3.71485144e-01f, -2.15906829e-01f, -1.49780929e-01f, -3.82030159e-02f,
  3.30389678e-01f, 2.78160840e-01f, 1.54620916e-01f, 5.40146828e-02f, -2.16633976e-01f, -4.33074117e-01f, -4.50905174e-01f, -2.58479148e-01f, -1.06378973e-01f, 3.38968867e-03f,
  8.19636509e-02f, -2.55262610e-02f, -8.87183696e-02f, -1.63906487e-03f, 2.65734978e-02f, 6.95912018e-02f, -5.71566336e-02f, 1.37044042e-01f, 9.13720950e-02f, 4.66929562e-02f,
  2.16137603e-01f, 3.01506609e-01f, 1.89566296e-02f, 4.48754355e-02f, 1.97247446e-01f, -1.05131261e-01f, -1.76823847e-02f, 1.37223480e-02f, 1.71097845e-03f, -1.17006022e-02f,
  1.42958999e-01f, 4.57891310e-03f, -2.12198012e-02f, 5.47603443e-02f, 4.24870625e-02f, -6.12028614e-02f, -9.06529874e-02f, -5.84443621e-02f, -7.43002910e-03f, 1.04861081e-01f,
  3.85135300e-02f, 1.77174270e-01f, 1.73442103e-02f, -2.73801629e-02f, -4.24951687e-03f, 5.78571446e-02f, 1.06534719e-01f, 2.71248240e-02f, 6.25404576e-03f, -2.15691309e-02f,
  1.07144434e-02f, -7.48595893e-02f, 1.86844962e-03f, -1.62792001e-02f, -7.67077878e-02f, -2.82982104e-02f, 9.74043831e-02f, -5.04118316e-02f, -3.50157246e-02f, -1.29929828e-02f,
  7.40037952e-03f, 3.71355191e-02f, 2.48070601e-02f, -4.86613624e-02f, 2.16082968e-02f, -9.17893350e-02f, -7.55105168e-02f, -1.12462444e-02f, 2.23663468e-02f, -9.20330435e-02f,
  2.04116125e-02f, -4.62779887e-02f, -1.83311652e-03f, 5.64865768e-02f, -4.28311974e-02f, -1.75746083e-02f, -2.30206344e-02f, -2.42972909e-03f, -7.69239366e-02f, -6.17490001e-02f,
  5.18028773e-02f, 3.22163045e-01f, 5.55701554e-03f, 5.84226623e-02f, -5.21551992e-04f, 1.09747566e-01f, 1.45820796e-01f, 1.34707172e-03f, 1.16674438e-01f, 2.12438703e-02f,
  7.04768375e-02f, 4.65844050e-02f, 6.71825483e-02f, 1.75007209e-02f, -3.65481004e-02f, 7.31015801e-02f, -5.52632585e-02f, 3.96115473e-03f, -8.99423193e-03f, 6.22080192e-02f,
  -3.95725556e-02f, -1.63618669e-01f, -1.02613494e-01f, -1.22552216e-02f, -2.03217678e-02f, -8.14559218e-03f, -2.41526570e-02f, -7.50403032e-02f, -3.05968411e-02f, -2.72280008e-01f,
  3.89819205e-01f, 3.52762312e-01f, 3.35817635e-01f, 4.35720235e-01f, 3.72280359e-01f, 1.56140998e-01f, 3.54139924e-01f, 2.00973615e-01f, 2.15416066e-02f, 1.73294351e-01f,
  6.52150661e-02f, 8.95011723e-02f, 8.38061869e-02f, 7.78308064e-02f, 1.62774771e-01f, 2.99392015e-01f, 2.98892438e-01f, 1.06862649e-01f, 1.18032865e-01f, 2.06817716e-01f,
  1.17617391e-01f, 2.46514037e-01f, 1.25618488e-01f, 1.68932959e-01f, 2.00841695e-01f, 1.11338764e-01f, 1.10290878e-01f, 1.35494664e-01f, 8.24040398e-02f, 1.45622358e-01f,
  1.77364320e-01f, 2.67728984e-01f, 5.33076115e-02f, 1.65079504e-01f, 1.01207435e-01f, 4.98658232e-02f, 3.60550433e-02f, 1.89825013e-01f, 2.80746520e-02f, 9.64189693e-02f,
  1.16065443e-01f, 4.28868644e-03f, 7.27392659e-02f, 7.55590945e-02f, 2.05199614e-01f, 6.13417886e-02f, 7.67035782e-02f, 1.65911257e-01f, 2.38930136e-02f, 1.08885244e-01f,
  7.60310590e-02f, 1.91563234e-01f, 2.18852177e-01f, 7.40103647e-02f, -7.47372489e-03f, 1.35024980e-01f, 1.33511469e-01f, 1.71087254e-02f, 1.74012054e-02f, 2.46273540e-03f,
  -1.33126944e-01f, -3.55561413e-02f, -1.00133874e-01f, 8.75767469e-02f, -5.09957373e-02f, -1.09316677e-01f, -8.19485541e-03f, 3.93089838e-02f, -2.71490701e-02f, 5.51448716e-03f,
  -6.17049634e-02f, -4.31198627e-02f, -1.86504889e-02f, 7.92607665e-02f, 8.20747167e-02f, -1.88221522e-02f, -1.10529866e-02f, 4.63281907e-02f, 2.68743578e-02f, 3.65589522e-02f,
  -6.36012480e-02f, -8.10878128e-02f, -1.54321240e-02f, -8.33596736e-02f, -1.29553080e-02f, -2.05574222e-02f, 3.16899121e-02f, -9.81111601e-02f, 5.63386753e-02f, 5.70136160e-02f,
  1.40187562e-01f, 1.86791673e-01f, 1.19636454e-01f, 5.16593494e-02f, 3.19662094e-02f, -1.89688019e-02f, 1.33718088e-01f, 7.75432289e-02f, 1.61112845e-01f, 1.64157197e-01f,
  1.34264290e-01f, 1.30932689e-01f, 1.83018550e-01f, 3.75409089e-02f, 8.13760310e-02f, 7.67520890e-02f, 2.30957810e-02f, 1.06030479e-01f, 1.26554236e-01f, 1.07164709e-02f,
  6.93256631e-02f, 7.61028528e-02f, 1.00708291e-01f, -2.87903333e-03f, 1.05751969e-01f, 1.71809047e-01f, 6.27382994e-02f, 9.98880491e-02f, 1.07925177e-01f, 7.88271278e-02f,
  -3.88791859e-02f, -2.27951199e-01f, -2.95733333e-01f, 1.41205370e-01f, 7.13786557e-02f, 1.37788504e-01f, -5.96890561e-02f, 2.30065897e-01f, 1.78581655e-01f, -1.96580455e-01f,
  -7.36704692e-02f, 9.84482653e-03f, 8.41295049e-02f, -1.44941891e-02f, 5.96879087e-02f, -1.71281531e-01f, 1.05446624e-02f, 1.28811136e-01f, 2.44782925e-01f, 1.16589263e-01f,
  1.35716736e-01f, 1.25188902e-01f, -4.23471406e-02f, 5.69573604e-02f, -1.00887688e-02f, 1.70370445e-01f, -1.68116629e-01f, -1.57310084e-01f, -1.31309584e-01f, -3.26602966e-01f,
  -3.33014965e-01f, -2.74975926e-01f, 1.46296337e-01f, 4.10200804e-02f, -1.06510833e-01f, -6.61683679e-02f, -2.60803718e-02f, -8.45147879e-04f, -4.32488695e-02f, 4.45964048e-03f,
  -3.56519222e-02f, -1.10381536e-01f, -4.11365554e-02f, -1.16877750e-01f, -6.63126111e-02f, -1.69914216e-03f, -8.13855156e-02f, 6.54557813e-03f, -1.24972605e-03f, -4.78217341e-02f,
  -1.77391618e-02f, -7.88613707e-02f, -1.53066907e-02f, -9.87457037e-02f, -5.54273312e-04f, -5.99410422e-02f, -1.64919570e-01f, -1.28244713e-01f, -6.51346333e-03f, -8.47716406e-02f,
  8.89525115e-02f, -5.90100046e-03f, 7.18032271e-02f, 7.56164715e-02f, 7.22113922e-02f, 5.39922193e-02f, 5.71603216e-02f, -1.68660451e-02f, 1.01737380e-01f, 7.29893474e-03f,
  4.62341793e-02f, 4.11486402e-02f, 6.41601384e-02f, 1.14576079e-01f, 1.33409217e-01f, -5.13638556e-02f, -1.22040734e-02f, -4.44602743e-02f, 2.31604259e-02f, 3.72528061e-02f,
  9.32311174e-03f, 1.55217834e-02f, 7.01122358e-02f, 4.88694236e-02f, 5.92992641e-02f, -4.38580401e-02f, 6.62271231e-02f, 4.13515046e-02f, 9.60474312e-02f, 1.20334521e-01f,
  2.74533242e-01f, -3.82032655e-02f, -8.97221193e-02f, -2.18372326e-02f, -7.21259266e-02f, 1.59347411e-02f, -2.66813729e-02f, 1.96284391e-02f, -1.34886345e-02f, -3.91809754e-02f,
  -1.47312507e-01f, 4.11884598e-02f, -1.18193209e-01f, 2.77933348e-02f, 2.25982405e-02f, 6.67925701e-02f, -1.78825464e-02f, -3.61498855e-02f, -1.76237859e-02f, -9.29159224e-02f,
  4.26525474e-02f, 9.25547257e-02f, 4.65291403e-02f, 6.50610253e-02f, -9.43793207e-02f, 1.26623943e-01f, -1.51012456e-02f, 1.29538313e-01f, 1.08790010e-01f, 2.47692153e-01f,
  4.17741984e-01f, -1.42320916e-01f, 2.96813816e-01f, 1.97255105e-01f, -1.47536859e-01f, -5.21828756e-02f, -1.12852171e-01f, 1.10383272e-01f, 5.94779067e-02f, -5.64009435e-02f,
  -2.93060422e-01f, -3.17169458e-01f, -2.08143428e-01f, -1.70794040e-01f, 2.07219981e-02f, -2.98315287e-02f, 3.38234901e-02f, 3.12300116e-01f, 2.50330091e-01f, 6.13359585e-02f,
  -1.76815286e-01f, 5.44260181e-02f, 2.41470605e-01f, 9.87310633e-02f, 8.13909154e-03f, 4.24253307e-02f, 5.99632971e-02f, 1.45504639e-01f, 2.93348171e-02f, -4.29266617e-02f,
  3.35753374e-02f, 2.13165611e-01f, 7.24982396e-02f, -7.87157193e-02f, -1.76962223e-02f, 2.30711162e-01f, 2.28826124e-02f, 1.86475694e-01f, 8.33524913e-02f, 8.78034756e-02f,
  8.59231427e-02f, 7.70105422e-02f, 3.92294787e-02f, 5.13557717e-03f, 6.48621693e-02f, 9.40577537e-02f, 9.60053653e-02f, 3.35583866e-01f, 7.16187134e-02f, 1.11538872e-01f,
  -1.98671073e-01f, 7.09087998e-02f, 2.48855576e-01f, 1.51981696e-01f, 2.11786613e-01f, 1.16482168e-01f, 1.40974313e-01f, 2.30457917e-01f, 2.57807016e-01f, 2.69787014e-01f,
  1.15519939e-02f, -2.99917925e-02f, 3.51958796e-02f, -1.72523987e-02f, -4.01429944e-02f, -2.59337127e-02f, -1.50543144e-02f, -1.06720962e-01f, -7.74042383e-02f, 2.78226063e-02f,
  -5.00668660e-02f, -9.29537714e-02f, -2.30824891e-02f, -5.48793003e-02f, -8.88339803e-02f, -8.91283974e-02f, -4.58604991e-02f, -8.31812248e-02f, -4.52160053e-02f, -3.10618002e-02f,
  -8.63785073e-02f, -2.76505593e-02f, -2.08639428e-02f, -2.43871920e-02f, 5.40902764e-02f, 7.26402253e-02f, 2.09051650e-02f, -7.78018162e-02f, -3.28551978e-02f, -8.72483030e-02f,
  -1.00041084e-01f, 2.92311870e-02f, 8.82062241e-02f, 1.06225729e-01f, 3.83102782e-02f, 2.40074676e-02f, -5.04000150e-02f, 8.72181058e-02f, -4.14664671e-03f, 3.37012485e-02f,
  -1.46786403e-02f, 4.06511314e-02f, -1.19004874e-02f, 7.86219314e-02f, 6.38360605e-02f, 6.52014762e-02f, -4.91239205e-02f, 2.20279340e-02f, 3.06880008e-02f, 9.33243483e-02f,
  2.06885077e-02f, 9.58668813e-02f, 1.01290077e-01f, -1.05606960e-02f, 6.20587452e-05f, 9.61593688e-02f, 5.70774674e-02f, 9.99516919e-02f, 7.11702779e-02f, -1.45479375e-02f,
  -6.18375063e-01f, 4.05101739e-02f, 9.92905721e-02f, -3.41206878e-01f, 9.71261412e-02f, 1.67108729e-01f, 1.21426024e-01f, -9.98270214e-02f, -1.82086453e-01f, -4.85696755e-02f,
  -1.31371655e-02f, -7.88909271e-02f, 7.20497146e-02f, 6.59633204e-02f, 5.17233945e-02f, 2.09948584e-01f, 1.87254012e-01f, 1.45231530e-01f, 3.71856168e-02f, 9.32986066e-02f,
  5.39814122e-02f, -1.21504046e-01f, -2.71755546e-01f, -4.21476178e-02f, 9.14101116e-03f, 9.79984552e-02f, 1.19486168e-01f, -5.28359525e-02f, 2.12290660e-01f, 1.92503184e-01f,
  -5.91797195e-02f, -2.43771285e-01f, 9.58194807e-02f, 9.61932391e-02f, 9.67288017e-02f, -6.61700964e-02f, -7.28962943e-02f, 1.82502232e-02f, -1.03354208e-01f, -5.53427711e-02f,
  3.89010943e-02f, -6.15604594e-02f, 2.12779026e-02f, 3.61584425e-02f, -1.06914848e-01f, -6.06215000e-02f, 1.25094801e-02f, -7.24461079e-02f, -2.36904062e-02f, -6.88166916e-03f,
  1.44041315e-01f, -8.34928602e-02f, -1.42335013e-01f, 1.20841628e-02f, 4.07120027e-02f, 8.23604167e-02f, -2.15032846e-02f, 1.11402854e-01f, 1.38938397e-01f, -1.59531265e-01f,
  3.70100215e-02f, -2.58033685e-02f, 4.90191914e-02f, 2.30397307e-03f, -3.78626026e-02f, -7.58939683e-02f, 9.72828362e-03f, 3.09034949e-03f, 9.39290747e-02f, -9.57014561e-02f,
  5.35626449e-02f, 3.50986305e-03f, 1.79636455e-03f, -1.12122912e-02f, 2.17563137e-02f, 1.11768348e-02f, -4.08064537e-02f, 1.18239541e-02f, 1.71733666e-02f, 2.61996165e-02f,
  -1.11332443e-02f, 2.03367565e-02f, -3.41636501e-02f, -5.05865179e-02f, 5.79440817e-02f, -7.27091124e-03f, -5.32691926e-02f, -1.57405734e-02f, 3.44186579e-03f, -1.05116881e-01f,
  -2.40285397e-01f, 2.08519191e-01f, -6.89895600e-02f, -1.12992944e-02f, -2.59407051e-02f, 9.54514742e-02f, 8.23842734e-02f, 4.64863628e-02f, -1.13246301e-02f, -6.37307316e-02f,
  9.48467851e-02f, -7.82539845e-02f, 4.03452404e-02f, 5.81752658e-02f, 2.69313250e-02f, 7.75343478e-02f, 5.42324111e-02f, -1.47832781e-02f, 4.51570153e-02f, -5.18474989e-02f,
  8.14905167e-02f, -6.03564130e-03f, -1.13904074e-01f, -2.08289381e-02f, 7.95073584e-02f, 5.28677851e-02f, 3.71920131e-02f, 2.58443728e-02f, 1.41852731e-02f, -1.95753530e-01f,
  5.61363734e-02f, -3.63220274e-01f, -1.21046677e-01f, 2.16707364e-01f, -7.83690158e-03f, -5.28822951e-02f, -4.34065938e-01f, -4.67242151e-02f, 6.45373464e-02f, -1.17127284e-01f,
  8.81368071e-02f, 2.88186759e-01f, 2.95632213e-01f, 1.79288104e-01f, -6.54611215e-02f, -3.14822286e-01f, -2.00337395e-01f, -8.73953849e-03f, 2.90640622e-01f, 3.93892601e-02f,
  -5.74047491e-02f, 4.89517674e-02f, 1.83416262e-01f, 7.86646008e-02f, 6.32615313e-02f, 2.34964788e-01f, -1.31361797e-01f, -6.15102760e-02f, -1.15400195e-01f, -2.08800271e-01f,
  4.47069928e-02f, -2.12853998e-01f, 7.69884810e-02f, 1.57772914e-01f, 3.42103355e-02f, -6.00677030e-03f, 3.07087530e-03f, 5.88637516e-02f, 7.88074657e-02f, -8.43881592e-02f,
  6.47747591e-02f, -5.35102189e-03f, 3.28829996e-02f, 4.31686118e-02f, -2.18116380e-02f, 8.51856079e-03f, 5.22957928e-02f, -3.25627178e-02f, -8.34909617e-04f, -7.52211958e-02f,
  -7.10958913e-02f, -7.09489807e-02f, -3.58671090e-03f, -4.60123271e-02f, -9.49225500e-02f, 3.20262760e-02f, 6.39296463e-03f, -5.56060709e-02f, 1.24979150e-02f, -5.79242688e-03f,
  -3.71311940e-02f, 4.18446288e-02f, -3.92517112e-02f, -4.33651730e-02f, -2.16149595e-02f, 4.69905473e-02f, -1.98355634e-02f, 3.68208811e-02f, 3.86182629e-02f, 5.34517057e-02f,
  -5.48392907e-02f, 2.53046416e-02f, 2.20990106e-02f, 9.34886048e-04f, 1.46755418e-02f, 6.41226396e-03f, -8.02902654e-02f, 2.58913115e-02f, 2.62719039e-02f, -5.14772944e-02f,
  6.68109879e-02f, -4.43538614e-02f, -3.37107629e-02f, -5.59246391e-02f, -4.24502566e-02f, -3.98760438e-02f, -9.57133889e-04f, 3.45307291e-02f, 6.03781901e-02f, -8.97089168e-02f,
  1.73894987e-01f, 8.25782940e-02f, 1.66179556e-02f, -2.42540669e-02f, -1.09767672e-02f, 2.13516559e-02f, -9.91220307e-03f, 6.55059889e-03f, -4.59030047e-02f, 3.30077624e-03f,
  4.04127724e-02f, 5.76535426e-02f, -2.67478917e-02f, -3.90213430e-02f, 8.69450495e-02f, 6.57837391e-02f, 2.07387414e-02f, 3.74284685e-02f, 1.83367785e-02f, -8.88179638e-04f,
  -1.02480855e-02f, 6.95351213e-02f, 1.47710457e-01f, 9.22524109e-02f, 3.26764490e-03f, 1.77470759e-01f, 7.93096051e-03f, 9.10602286e-02f, 9.23024267e-02f, -3.07254493e-02f,
  -4.85246480e-01f, -2.15975404e-01f, 2.83220619e-01f, -8.40434432e-02f, 7.73828551e-02f, 1.68890297e-01f, 9.43899676e-02f, -2.02618003e-01f, -1.58313796e-01f, 4.45593335e-02f,
  -1.28656283e-01f, 1.32245272e-01f, 1.31562725e-01f, 1.80208638e-01f, 9.37008634e-02f, 1.47914499e-01f, 3.01224887e-01f, 2.29656070e-01f, 3.38008642e-01f, 5.68616688e-02f,
  -2.01326516e-02f, -7.20013008e-02f, -8.24186280e-02f, -1.22130439e-01f, -1.25847489e-01f, -4.61163037e-02f, 7.37222470e-03f, -1.42698973e-01f, 5.19134589e-02f, 6.59224242e-02f,
  1.04153454e-01f, -4.24078792e-01f, 1.79018185e-01f, -7.95894191e-02f, -3.18275280e-02f, -5.38594574e-02f, -1.71578303e-02f, -9.03204158e-02f, 9.41397063e-03f, -4.68280576e-02f,
  5.01885712e-02f, 2.08608042e-02f, -1.74183175e-02f, 7.89474472e-02f, -6.11202233e-02f, 1.22848237e-02f, -2.68002655e-02f, -8.52794424e-02f, 4.20965888e-02f, -4.53487560e-02f,
  9.82893854e-02f, 3.38697173e-02f, -3.41687910e-02f, -6.87211454e-02f, -7.80406669e-02f, 6.43703267e-02f, -2.41399799e-02f, -1.39240518e-01f, -8.25797468e-02f, -9.43379626e-02f,
  -6.19403459e-02f, 2.63105184e-02f, 2.41230559e-02f, 1.98048837e-02f, 9.49838459e-02f, 1.12925731e-01f, 9.70520675e-02f, 8.63397419e-02f, 1.31614119e-01f, 6.74503744e-02f,
  6.37126118e-02f, 1.33094609e-01f, 1.26739353e-01f, 2.82353889e-02f, 9.67099294e-02f, 9.92551446e-02f, 7.47170150e-02f, 9.55668762e-02f, 8.89598504e-02f, 6.30138218e-02f,
  6.27805591e-02f, 9.16874707e-02f, 1.17361685e-02f, 1.02229593e-02f, 1.64970476e-02f, 9.53056440e-02f, 6.20489568e-02f, 6.15660474e-02f, 2.87526418e-02f, 6.30699620e-02f,
  -8.49676803e-02f, 8.29695389e-02f, -2.34160032e-02f, -5.53372353e-02f, -8.32799748e-02f, -2.36154255e-02f, 3.67361084e-02f, -3.25973183e-02f, -4.82524419e-03f, -3.25487577e-03f,
  -1.19329225e-02f, 1.77003089e-02f, -7.78129473e-02f, 2.90243756e-02f, 1.57324336e-02f, 1.99181233e-02f, -5.69546744e-02f, 7.24678710e-02f, -4.75973375e-02f, -1.55170977e-01f,
  -1.04296923e-01f, 3.86880450e-02f, 1.40012994e-01f, 7.46612996e-02f, -3.31171080e-02f, 2.78394278e-02f, 1.17791839e-01f, -3.29279564e-02f, 7.20785037e-02f, -7.91869834e-02f,
  -8.41197558e-04f, -2.40934312e-01f, 1.45708069e-01f, -6.96081966e-02f, -6.15580473e-03f, 2.33041123e-01f, 3.50086987e-01f, 1.10111743e-01f, -1.77630171e-01f, 1.98416300e-02f,
  -1.49744704e-01f, -1.28360957e-01f, -8.16308185e-02f, -1.06945485e-01f, 1.98756799e-01f, 1.88109905e-01f, 1.85707971e-01f, 9.56178308e-02f, 1.78347722e-01f, 3.29771936e-02f,
  -9.85133834e-03f, 2.25519557e-02f, -1.32993981e-01f, -3.69292758e-02f, -2.29321077e-01f, -4.45370115e-02f, -1.21115215e-01f, -2.36293659e-01f, -1.23022445e-01f, -3.23126286e-01f,
  8.83623436e-02f, -1.82628348e-01f, -5.15312478e-02f, -1.65835589e-01f, -5.19508719e-02f, -2.88773179e-02f, 1.61167122e-02f, -1.36102855e-01f, -2.92221140e-02f, -6.77628145e-02f,
  -1.57766953e-01f, -7.84744173e-02f, -6.78520203e-02f, -4.29452248e-02f, -7.42310807e-02f, -4.21123393e-02f, -8.83227587e-02f, -1.23843111e-01f, -7.75671527e-02f, -7.16875196e-02f,
  -1.05406411e-01f, 3.84077476e-03f, 4.30838093e-02f, 1.98985748e-02f, -9.20695718e-03f, -4.35941890e-02f, -1.52479351e-01f, -1.52081132e-01f, -9.91623849e-02f, -1.19981840e-01f,
  2.21982263e-02f, -3.84884067e-02f, 5.75911021e-03f, 7.93734938e-02f, 3.44250835e-02f, 3.22592407e-02f, 2.87645143e-02f, -7.32925907e-03f, -3.93387675e-02f, 1.10406257e-01f,
  -2.48187967e-02f, 1.77459028e-02f, 1.70079209e-02f, -9.39785168e-05f, -1.20627722e-02f, 2.40443903e-03f, 6.31000921e-02f, -3.48037593e-02f, -4.97607775e-02f, 5.84605895e-02f,
  -2.71054395e-02f, -1.46730253e-02f, 9.11363401e-03f, -4.11671214e-02f, -7.85952061e-02f, -1.32620931e-02f, 1.31773821e-04f, -5.71381338e-02f, -3.08534433e-03f, -5.49660809e-03f,
  9.72255990e-02f, -7.15312883e-02f, 2.69673243e-02f, -9.84557644e-02f, -3.95780653e-02f, -9.06997472e-02f, -1.19689994e-01f, -9.18679163e-02f, -9.39324349e-02f, -4.74316515e-02f,
  -2.30146782e-03f, -3.18328813e-02f, -3.69195081e-02f, -3.38538066e-02f, 4.47158553e-02f, -2.81139147e-02f, -1.27401754e-01f, 3.85636911e-02f, -1.58489838e-01f, -1.15150094e-01f,
  -8.43522400e-02f, -6.96281865e-02f, 6.05713613e-02f, 3.18125524e-02f, -1.14307679e-01f, 8.14748630e-02f, 9.47626531e-02f, 3.23362499e-02f, 1.25520676e-01f, 9.01952609e-02f,
  -2.18421176e-01f, -6.89679291e-03f, -2.35035568e-01f, 8.96665733e-03f, 2.02314127e-02f, -2.13879183e-01f, -2.18946636e-01f, -1.28450260e-01f, -4.93054688e-02f, -1.52222052e-01f,
  -2.58889496e-01f, -3.02065015e-01f, -2.00646043e-01f, -2.44843259e-01f, -2.85726488e-01f, -2.07594149e-02f, 1.60514668e-01f, -1.09883063e-01f, -3.20970446e-01f, -1.55202821e-01f,
  -7.01632574e-02f, 9.26307738e-02f, 4.24283594e-02f, -4.89580911e-03f, 6.71680570e-02f, -1.23102762e-01f, 7.25067854e-02f, 1.41572868e-02f, -1.39097691e-01f, 8.83737504e-02f,
  -4.44580793e-01f, -1.26807749e-01f, -1.82813779e-01f, -6.53907880e-02f, -1.03356153e-01f, -1.35836825e-01f, -1.01621680e-01f, -9.80036482e-02f, -1.08477473e-01f, -1.12315170e-01f,
  -1.22378521e-01f, -1.94344714e-01f, -9.59565341e-02f, -6.47892356e-02f, -5.49230054e-02f, -1.22012660e-01f, -9.52201858e-02f, -1.67769894e-01f, -1.94438621e-01f, -2.17737034e-01f,
  -1.38315618e-01f, -1.72046885e-01f, -1.37429103e-01f, -8.92373994e-02f, -1.47083536e-01f, -1.69537067e-01f, -2.69971311e-01f, -1.95262045e-01f, -1.87495068e-01f, -2.19476193e-01f,
  3.97636741e-02f, 7.10095391e-02f, 5.11125624e-02f, 5.65953553e-02f, 1.11863762e-01f, 6.67842254e-02f, 1.91441402e-01f, 1.17576621e-01f, 1.00528233e-01f, 1.26824498e-01f,
  8.55456069e-02f, 6.80227131e-02f, 5.09476289e-02f, 9.51775908e-02f, 1.29824668e-01f, 1.32104263e-01f, 1.40133679e-01f, 7.48752803e-02f, 2.87197512e-02f, 2.06189916e-01f,
  2.02284101e-02f, 5.44564649e-02f, 1.93757087e-01f, 1.35817736e-01f, 7.48706684e-02f, 8.02888796e-02f, 9.62511897e-02f, 3.03769894e-02f, 2.85990424e-02f, 8.59639123e-02f,
  -1.37480557e-01f, -1.88867480e-01f, -1.49300084e-01f, -8.92021209e-02f, -1.16014726e-01f, -1.33459359e-01f, -1.33176625e-01f, -1.00046970e-01f, -1.55091479e-01f, -1.61351219e-01f,
  -1.30165428e-01f, -2.02324241e-01f, -1.56964183e-01f, -1.11759700e-01f, -1.39307112e-01f, -1.33675426e-01f, -6.67314008e-02f, -1.52220383e-01f, -1.38729453e-01f, -1.40810400e-01f,
  -5.33635616e-02f, -1.51351511e-01f, -3.49380642e-01f, -2.65071750e-01f, -2.06753656e-01f, -1.86594501e-01f, -2.91730404e-01f, -2.08603337e-01f, -3.58361602e-01f, -3.86449605e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.85681224e-01f, 3.52809578e-01f, 1.70533329e-01f, -1.33873492e-01f, 1.11981891e-01f, -4.24349785e-01f, -5.17372429e-01f, -5.16106665e-01f, -2.43628189e-01f, 3.48770082e-01f,
  1.26239032e-01f, -8.92691612e-02f, 5.39568327e-02f, -2.21516982e-01f, -5.38279235e-01f, -1.69689566e-01f, -1.80505455e-01f, -4.30997074e-01f, -8.60021234e-01f, -6.36700928e-01f,
  -2.03533173e-01f, -3.67403984e-01f, -4.18058574e-01f, -2.20364079e-01f, 4.42435592e-01f, -5.64257149e-03f, 2.59432375e-01f, -1.78530645e-02f, 2.97336094e-02f, 5.13351738e-01f,
  1.66775554e-01f, 2.59083435e-02f, -2.00975269e-01f, -1.49679482e-01f, 1.27420519e-02f, -1.01268589e-01f, -1.24135487e-01f, 6.50935294e-03f, 7.98659748e-04f, -4.60275933e-02f,
  -5.41168191e-02f, -3.16710919e-02f, -2.30517313e-01f, -1.27333449e-02f, -2.03274339e-01f, -1.76969931e-01f, -4.14160602e-02f, -1.58928856e-01f, -4.86535802e-02f, 1.67224944e-01f,
  2.24176437e-01f, 5.36192060e-02f, 7.28369877e-02f, -1.14040598e-01f, -5.57394847e-02f, 5.76535948e-02f, 1.95288166e-01f, 4.52502929e-02f, 9.14277136e-02f, 2.55802125e-01f,
  -8.95860493e-02f, 7.05498606e-02f, 5.67953847e-03f, 7.93142691e-02f, -1.07223161e-01f, -3.28473896e-02f, 1.40889203e-02f, 7.03684166e-02f, -1.13149166e-01f, -6.04568236e-02f,
  8.45295042e-02f, 8.99140984e-02f, -3.94514911e-02f, -5.97640313e-03f, 1.92972850e-02f, 6.46571117e-03f, -8.10532272e-02f, 5.59383631e-02f, 1.13081466e-02f, 2.81862319e-02f,
  -4.56186533e-02f, -9.04025137e-03f, 8.87798294e-02f, 3.72255072e-02f, 1.29806325e-01f, 1.03784055e-01f, 8.59188661e-02f, -2.96112299e-02f, -1.04259245e-01f, -4.58313851e-03f,
  4.47098501e-02f, -1.53143946e-02f, 1.11605197e-01f, -4.13711593e-02f, 6.22743070e-02f, 1.41362414e-01f, 2.59778619e-01f, 8.85747597e-02f, 1.46094322e-01f, -6.10693246e-02f,
  -5.89959361e-02f, -1.74672864e-02f, 9.58693400e-02f, 1.07941754e-01f, -1.65622309e-01f, 1.16663119e-02f, 8.14718008e-02f, 5.29111065e-02f, 1.85970422e-02f, 1.80671990e-01f,
  1.41803324e-01f, -4.17066328e-02f, -4.83995900e-02f, 1.16881505e-02f, 1.44494753e-02f, -7.91781247e-02f, 7.43781105e-02f, 1.04450360e-01f, 4.37991470e-02f, 1.29219785e-01f,
  5.05511940e-01f, -5.62537551e-01f, -1.35962173e-01f, -1.33198634e-01f, -3.47698927e-01f, 3.08618061e-02f, -4.45858598e-01f, 3.91715243e-02f, -1.64275374e-02f, -5.21776974e-01f,
  -1.19289779e-03f, 4.83822674e-01f, 2.15736255e-01f, 2.88402259e-01f, 4.75867152e-01f, -5.66037953e-01f, -3.21611345e-01f, 3.63857627e-01f, 7.18182743e-01f, 1.32355466e-01f,
  -2.61705905e-01f, -1.17416063e-03f, 4.27150041e-01f, 1.17127746e-01f, -5.00883877e-01f, 1.40483454e-01f, -4.73002255e-01f, -1.90822303e-01f, -2.39144996e-01f, -7.30327904e-01f,
  -1.18291989e-01f, -8.46456140e-02f, 7.76644275e-02f, 4.76141609e-02f, -1.74227342e-01f, -1.54266572e-02f, -8.02691281e-02f, -1.96805492e-01f, -5.59338182e-02f, -1.29252225e-01f,
  -1.02146879e-01f, 4.26230505e-02f, 7.90975913e-02f, -8.11800640e-03f, -8.35624039e-02f, -3.07073984e-02f, -1.38317570e-02f, 1.04710661e-01f, 3.71543281e-02f, -1.75641552e-01f,
  -1.46047071e-01f, -9.59358290e-02f, 2.56082788e-02f, 2.61919224e-03f, 2.10778981e-01f, 2.04378501e-01f, -6.12608418e-02f, 1.34582728e-01f, 2.89596319e-01f, -4.49074119e-01f,
  -9.17162672e-02f, 5.96363917e-02f, -5.29278181e-02f, -3.71989384e-02f, -9.68425535e-03f, -7.20192268e-02f, -7.57208746e-03f, -4.00702003e-03f, -1.50873931e-02f, -2.56824773e-02f,
  2.55073383e-02f, 2.32683285e-03f, 1.09173946e-01f, -8.49887729e-02f, 4.52029705e-03f, 9.17465538e-02f, -1.02285460e-01f, -2.31347289e-02f, -3.83115821e-02f, 3.64798564e-03f,
  4.96223643e-02f, 4.95935977e-02f, -1.84934828e-02f, 1.17043480e-01f, -3.74662876e-02f, 1.21122353e-01f, 6.82460889e-03f, 4.80872765e-02f, 4.22234572e-02f, -8.31734240e-02f,
  -5.02975248e-02f, 4.05993670e-01f, -1.34783372e-01f, 6.42174780e-02f, -7.16988221e-02f, -5.10991476e-02f, -2.11111810e-02f, 3.52859125e-02f, 1.70517508e-02f, 5.84828742e-02f,
  3.23723033e-02f, 8.06504712e-02f, -7.64760077e-02f, -7.40012601e-02f, -3.37897167e-02f, 2.66755819e-02f, -4.08662260e-02f, 7.35338032e-02f, 1.26929700e-01f, -1.70770541e-01f,
  -1.34619042e-01f, 1.75224580e-02f, 1.43340603e-01f, 6.73005208e-02f, -6.24687970e-02f, 1.63826570e-01f, -5.89462370e-02f, -1.07671134e-01f, 2.21867293e-01f, -3.46580505e-01f,
  -1.29710063e-01f, -3.35886598e-01f, -4.55320954e-01f, 3.72061163e-01f, -1.31497994e-01f, -2.20507979e-01f, -4.78066087e-01f, 2.96408117e-01f, 4.27175850e-01f, -5.78777254e-01f,
  -2.75422871e-01f, 1.67960107e-01f, -2.27510128e-02f, -1.04610585e-01f, -3.84859324e-01f, -6.51166677e-01f, -5.44624388e-01f, -4.08919990e-01f, -1.31482288e-01f, 1.62098169e-01f,
  5.85738979e-02f, 1.52669951e-01f, 1.79343507e-01f, 1.70581549e-01f, 2.22938985e-01f, -9.40516517e-02f, -1.41113847e-01f, -1.53389484e-01f, -3.28911036e-01f, -5.66143811e-01f,
  -5.34888208e-01f, 1.25306845e-01f, -9.64672938e-02f, -1.12351798e-01f, -1.54514927e-02f, 1.33944318e-01f, -1.40066072e-02f, 1.45976283e-02f, 7.42264390e-02f, -1.51748911e-01f,
  -2.66482010e-02f, 1.69661734e-02f, 4.90988344e-02f, 3.95754129e-02f, 1.61559805e-01f, -3.23364213e-02f, 1.36109188e-01f, 2.78557558e-02f, 5.12776300e-02f, 1.62346110e-01f,
  -1.36729889e-02f, -2.31799617e-01f, -8.42150599e-02f, -1.11369967e-01f, 1.57765925e-01f, -4.05068360e-02f, 2.62886994e-02f, 5.71059510e-02f, -1.73687235e-01f, -1.98210821e-01f,
  1.39467239e-01f, 7.45155513e-02f, 6.97746724e-02f, 1.00836292e-01f, 1.08738489e-01f, -1.68544054e-02f, -7.24794865e-02f, 2.03175191e-03f, 1.37953073e-01f, -9.57540497e-02f,
  1.08573111e-02f, -3.25623006e-02f, 1.45143736e-02f, -9.61598605e-02f, -6.01414219e-02f, -1.67802181e-02f, -1.64521068e-01f, -9.56145674e-02f, -7.46145397e-02f, -1.71764612e-01f,
  -1.33741423e-01f, -5.06581664e-02f, -8.22667554e-02f, -2.35083196e-02f, -1.92099750e-01f, -4.40533683e-02f, -5.57993762e-02f, 3.21056098e-02f, 1.42955165e-02f, -6.15245365e-02f,
  4.16299641e-01f, -4.63595897e-01f, -7.64539614e-02f, 9.55725610e-02f, -1.33224264e-01f, -2.36803782e-03f, 3.64427939e-02f, 1.87587235e-02f, 1.53400423e-02f, 3.29081602e-02f,
  -1.47767842e-01f, -7.43832737e-02f, -4.16799597e-02f, -1.55499596e-02f, -8.02346915e-02f, -6.08713850e-02f, -1.62329420e-01f, -1.49339795e-01f, 3.28316838e-02f, 1.93596423e-01f,
  -2.64588147e-02f, -1.74912751e-01f, -1.72133058e-01f, -1.80428490e-01f, 1.75978601e-01f, -1.01533800e-01f, -1.00381961e-02f, 1.05767064e-01f, -2.26371840e-01f, -2.47066662e-01f,
  8.16937745e-01f, -6.75615892e-02f, 4.26405400e-01f, 1.98817447e-01f, -3.01349312e-01f, -2.98708260e-01f, -4.14157778e-01f, -6.42921403e-02f, 1.65668234e-01f, 1.17379792e-01f,
  9.10931677e-02f, 1.28951460e-01f, 2.54397810e-01f, 2.55046725e-01f, 3.10420662e-01f, 1.82147436e-02f, -4.35538404e-02f, 2.29139179e-01f, 2.16439977e-01f, -2.85017435e-02f,
  2.71407142e-03f, 2.92767286e-02f, 2.16410562e-01f, 1.83649957e-01f, 7.69046247e-02f, 1.26983583e-01f, -7.17206672e-02f, -2.39181384e-01f, -1.98797777e-01f, 2.06715450e-01f,
  4.00757641e-01f, 6.46753162e-02f, 1.15899585e-01f, 3.64186689e-02f, -2.62378119e-02f, 1.73066258e-01f, -2.40120180e-02f, -3.97345424e-03f, -1.15130991e-01f, -4.80624884e-02f,
  3.50033157e-02f, -6.26184195e-02f, -1.33199006e-01f, -1.33484095e-01f, -5.92258722e-02f, -4.08647954e-03f, -4.06992063e-02f, 3.76532897e-02f, 5.68417311e-02f, 6.05788343e-02f,
  -8.51999521e-02f, -1.30608350e-01f, -2.50373423e-01f, -1.48539677e-01f, 3.52040641e-02f, -1.29750773e-01f, -2.53152382e-02f, 6.26572594e-02f, 6.76767677e-02f, 1.25280216e-01f,
  1.52854502e-01f, 1.56070918e-01f, 5.68303801e-02f, -1.21978886e-01f, -1.52351722e-01f, -7.26168528e-02f, -9.93911549e-02f, -1.28404498e-01f, 4.41752747e-02f, -1.54417902e-01f,
  -1.65719956e-01f, 7.03830719e-02f, 3.26820277e-02f, -3.28528620e-02f, 1.49960667e-01f, -4.09534127e-02f, -9.93811488e-02f, 1.61559659e-03f, -2.11657528e-02f, -4.67418768e-02f,
  -3.73784564e-02f, -3.58269066e-02f, -2.90300790e-02f, -1.72536388e-01f, -7.82973692e-02f, 6.41644821e-02f, -3.57455723e-02f, -6.84526786e-02f, -1.23872161e-02f, -1.24883093e-01f,
  -1.31869197e-01f, -4.35741693e-02f, 1.94266021e-01f, 1.65839627e-01f, 1.19692497e-01f, 1.14257023e-01f, 1.51143566e-01f, 5.20013198e-02f, 5.25376480e-03f, 9.22095031e-02f,
  3.00502423e-02f, 1.91519633e-01f, -3.67070436e-02f, -7.99120404e-03f, -5.33003695e-02f, 6.02042377e-02f, 2.17361450e-02f, 2.88425721e-02f, 1.60973921e-01f, 1.16639294e-01f,
  2.38397382e-02f, -1.44690312e-02f, 1.16548911e-01f, 3.90879400e-02f, 9.02443752e-03f, 1.26353189e-01f, 1.43895606e-02f, -2.15294659e-02f, -3.53101268e-02f, -1.52872398e-01f,
  2.84800112e-01f, -3.87674451e-01f, 1.30361214e-01f, 2.47183725e-01f, 1.89992607e-01f, 2.12535277e-01f, 3.75483441e-03f, 1.33406781e-02f, 1.74864769e-01f, 7.92586133e-02f,
  2.41350792e-02f, 1.83878824e-01f, 1.90811038e-01f, 1.54423401e-01f, 6.51030093e-02f, 1.43284917e-01f, 8.32577795e-02f, 2.16620699e-01f, 2.22871006e-01f, 5.72017767e-02f,
  5.41666970e-02f, -4.71823849e-02f, -5.28824851e-02f, 2.08858307e-02f, -4.64318655e-02f, 7.30175674e-02f, -1.61991175e-02f, -2.03552425e-01f, -1.95633039e-01f, -6.30499795e-02f,
  -1.40619073e-02f, -5.93591221e-02f, 2.88264394e-01f, -8.29477236e-02f, -1.34231523e-01f, -4.77395058e-02f, 8.45601484e-02f, -3.50893438e-02f, -7.74251148e-02f, -1.18000507e-02f,
  -1.30707142e-03f, -1.82344884e-01f, -4.15604673e-02f, -2.07640097e-01f, -1.29103750e-01f, -1.08918913e-01f, -1.48453861e-01f, 2.05823518e-02f, 5.24722412e-02f, -3.54207791e-02f,
  -6.06819913e-02f, -2.64048837e-02f, -7.85193667e-02f, 7.51358494e-02f, 7.86100775e-02f, -2.77684033e-02f, -4.07197600e-04f, -1.75436810e-02f, -2.00285465e-02f, 9.41749103e-03f,
  3.63708258e-01f, -2.60674767e-03f, -8.15146863e-02f, -2.84806881e-02f, 1.01480968e-01f, -1.01156840e-02f, -3.69803049e-02f, -7.78504508e-03f, 7.60504231e-02f, -3.58578786e-02f,
  -3.00214663e-02f, -2.03783810e-02f, 6.08981438e-02f, 5.86241204e-03f, 5.29550910e-02f, -2.68860068e-02f, 2.84768585e-02f, -3.84060740e-02f, -5.35732806e-02f, 3.42379175e-02f,
  -3.48491520e-02f, -6.81308880e-02f, -8.17638561e-02f, -2.63267785e-01f, -2.03715116e-01f, -2.26640627e-02f, -8.51198211e-02f, -1.38423771e-01f, -1.17165826e-01f, 2.50886604e-02f,
  -2.30021447e-01f, 1.39105916e-01f, 2.39076883e-01f, 5.91467805e-02f, -5.71318604e-02f, -8.88339579e-02f, 9.69275236e-02f, -3.26670386e-04f, 5.95966280e-02f, 1.16230421e-01f,
  7.56213591e-02f, -2.22365782e-02f, -4.89910953e-02f, -4.42117862e-02f, 5.29481508e-02f, 4.99481671e-02f, -1.43452249e-02f, 6.30870834e-02f, 1.01822898e-01f, -3.40878256e-02f,
  -3.01634930e-02f, 9.60428193e-02f, 1.88408464e-01f, 1.03175722e-01f, 1.91953063e-01f, 1.42480537e-01f, 2.49376614e-02f, 1.46571130e-01f, 1.04218110e-01f, 1.26925083e-02f,
  -1.67805076e-01f, -4.10980582e-01f, -4.66844469e-01f, -2.50587136e-01f, -1.62160069e-01f, 1.05717674e-01f, 6.34808186e-03f, 2.41289169e-01f, 5.33492900e-02f, -3.31141084e-01f,
  -5.33444472e-02f, -1.55941814e-01f, -2.76021153e-01f, -2.55429387e-01f, -1.13174878e-01f, -3.23025703e-01f, -4.98484284e-01f, -3.89378577e-01f, -8.09665304e-03f, 2.15708941e-01f,
  -5.53688407e-02f, -1.86235383e-01f, -2.83974614e-02f, -1.54054895e-01f, -3.23188037e-01f, -2.49216229e-01f, -2.86547273e-01f, -3.03478271e-01f, -1.22865021e-01f, -6.02941871e-01f,
  -4.19589370e-01f, 2.05721423e-01f, 1.15094773e-01f, 6.24761335e-04f, -6.67165816e-02f, 1.38627421e-02f, 4.50439639e-02f, 5.34045063e-02f, 9.38394070e-02f, 4.35622409e-02f,
  1.26639297e-02f, 1.39152780e-01f, 5.25330566e-02f, 6.55774847e-02f, 2.75758728e-02f, 1.58085585e-01f, 2.37852544e-01f, 9.67814177e-02f, -9.06820372e-02f, 1.59845486e-01f,
  4.21796814e-02f, 9.30193290e-02f, 1.76271304e-01f, 1.67390376e-01f, 2.45610014e-01f, 1.89573944e-01f, 2.51181096e-01f, 2.23543555e-01f, 1.91392213e-01f, -1.32154627e-02f,
  2.75232606e-02f, -1.57374352e-01f, -8.28565508e-02f, 7.63826519e-02f, 1.11458473e-01f, 2.42135078e-01f, -1.32665383e-02f, -4.29838710e-02f, 1.74142912e-01f, 6.49025217e-02f,
  2.42584813e-02f, 2.07229634e-03f, 6.12458847e-02f, 4.13910598e-02f, -1.85006589e-01f, -1.08324654e-01f, 1.76609214e-02f, 1.81534160e-02f, 5.52468263e-02f, 2.40321942e-02f,
  1.28469169e-01f, 1.01417623e-01f, -1.09687217e-01f, 1.07742354e-01f, -9.36791301e-02f, -2.46898904e-02f, 1.25192562e-02f, 1.02026701e-01f, 8.73690173e-02f, -3.49035896e-02f,
  -1.68355718e-01f, 8.48196819e-02f, -1.44691393e-01f, 3.47764231e-03f, -9.95303765e-02f, 2.43500043e-02f, -1.50274798e-01f, -1.48502305e-01f, -1.55972689e-01f, -7.44767413e-02f,
  1.74189687e-01f, -2.91219782e-02f, 7.02360496e-02f, 7.75460675e-02f, 1.11832522e-01f, 8.89625400e-02f, 9.84077677e-02f, -7.07542291e-03f, 4.44069952e-02f, -2.78753345e-03f,
  1.46894038e-01f, 2.32100472e-01f, 1.44305483e-01f, -8.03694036e-03f, 2.89657831e-01f, -3.79673168e-02f, 1.72535758e-02f, 5.09049669e-02f, 7.75736384e-03f, 2.86131557e-02f,
  9.08481240e-01f, 2.26527631e-01f, 1.86059728e-01f, 2.45754525e-01f, -2.14209199e-01f, -2.24979386e-01f, -1.81072190e-01f, -6.83961660e-02f, 1.10496879e-01f, 1.54946834e-01f,
  4.81753759e-02f, 1.55433863e-01f, 1.89259276e-01f, 2.54521906e-01f, 1.52555436e-01f, 1.22939184e-01f, 4.80849594e-02f, 2.45321527e-01f, 2.53837854e-01f, 2.08513901e-01f,
  1.79341927e-01f, 1.50929138e-01f, 3.59830409e-01f, 1.84584722e-01f, 2.42033601e-01f, 5.58017120e-02f, 6.84351921e-02f, 1.38025239e-01f, 1.81635633e-01f, 4.03297305e-01f,
  4.81049031e-01f, 2.30261490e-01f, -1.55302227e-01f, -6.33383021e-02f, -6.26299009e-02f, 4.19468693e-02f, -1.88799910e-02f, -7.82030150e-02f, -7.07939593e-03f, 1.79771427e-02f,
  -4.94864099e-02f, -3.23332474e-02f, -1.44069508e-01f, -8.16994607e-02f, 1.62825212e-02f, -4.44246493e-02f, 8.75850543e-02f, 9.51740816e-02f, 4.35870811e-02f, 5.91479018e-02f,
  1.18126965e-03f, -1.93842605e-01f, -1.94749713e-01f, -8.03941265e-02f, 6.67440593e-02f, 8.71217996e-02f, 5.40795662e-02f, 1.13138892e-01f, -6.41454682e-02f, 1.60910651e-01f,
  5.79647273e-02f, 9.93430838e-02f, 1.42051965e-01f, 2.57336915e-01f, 3.65153223e-01f, -4.93842587e-02f, 2.60095093e-02f, -5.66200577e-02f, 1.50844157e-01f, 1.01038434e-01f,
  -2.35407632e-02f, 7.34355254e-03f, -1.32786646e-01f, 3.86862345e-02f, 3.77677404e-03f, -3.76610644e-02f, 6.23148531e-02f, 1.24034025e-01f, -5.90685243e-03f, -2.43911929e-02f,
  1.00545779e-01f, 5.42417914e-02f, 4.38429937e-02f, 8.32266062e-02f, -5.96418604e-02f, -5.83435707e-02f, 1.42060965e-01f, -2.70037428e-02f, 8.27714056e-02f, 4.87137809e-02f,
  -4.22289014e-01f, -3.10052186e-01f, 2.28103846e-01f, -4.92524356e-02f, -1.54042661e-01f, -9.89680290e-02f, -2.48345803e-03f, -7.76688233e-02f, -1.81278050e-01f, -7.78752491e-02f,
  -6.40634224e-02f, 6.67477250e-02f, -9.31142345e-02f, -2.09859163e-02f, -1.91558361e-01f, -1.55240163e-01f, -2.55211052e-02f, -1.24924451e-01f, -1.41714603e-01f, -1.15271509e-01f,
  -1.96746990e-01f, -3.62127423e-01f, -3.29518586e-01f, -3.13127697e-01f, -2.03939050e-01f, -2.02636242e-01f, -1.07296720e-01f, -2.22619340e-01f, -1.48191333e-01f, -2.07919776e-01f,
  -7.60420918e-01f, -2.39259064e-01f, 2.03629345e-01f, -6.25252783e-01f, -1.25558943e-01f, 3.76808167e-01f, 2.33144939e-01f, 8.96617945e-04f, -3.76319855e-01f, -7.07464516e-02f,
  -2.65174266e-03f, -3.57595533e-01f, -4.10087228e-01f, 5.35469092e-02f, 3.11407447e-01f, 3.75381075e-02f, 3.17755453e-02f, 1.53290033e-01f, 4.34535980e-01f, 3.26438904e-01f,
  3.00085340e-02f, -1.38017997e-01f, 1.37695804e-01f, 3.24285515e-02f, -4.76088703e-01f, -2.52968162e-01f, -1.83982670e-01f, -1.99869305e-01f, 2.96198606e-01f, -4.45244342e-01f,
  -1.88079566e-01f, -1.49498716e-01f, 4.53366749e-02f, -6.30902173e-03f, 2.04828568e-02f, -1.71546661e-03f, 5.65465949e-02f, -2.25858897e-01f, 1.80620998e-01f, -7.91052952e-02f,
  -3.81740004e-01f, 1.92762598e-01f, -2.26246998e-01f, 1.04139946e-01f, -5.95544055e-02f, 1.47619843e-02f, 4.45065014e-02f, 9.98472050e-02f, 1.17691249e-01f, 1.40755817e-01f,
  3.07203867e-02f, -8.34633037e-02f, -8.44531059e-02f, 1.70690611e-01f, 2.96574950e-01f, 7.19705001e-02f, 1.95267409e-01f, 2.58294970e-01f, 3.83942693e-01f, -3.59558761e-01f,
  -5.42948116e-03f, -7.18498975e-02f, 1.76464841e-01f, -9.59646422e-03f, -8.95542186e-03f, -1.51046947e-01f, -1.40144363e-01f, 5.65838143e-02f, -4.50525619e-02f, -1.81128308e-01f,
  3.72372568e-02f, 2.32596286e-02f, -2.65734829e-02f, -1.33769274e-01f, -4.00388204e-02f, -2.47008149e-02f, 1.23674288e-01f, 1.01308167e-01f, 1.16967477e-01f, 2.66390890e-02f,
  2.24425197e-02f, -3.79644744e-02f, -7.52376765e-02f, 1.28336191e-01f, 5.85904233e-02f, 6.06895462e-02f, -2.04995722e-02f, 1.12547241e-01f, -1.63899511e-01f, -8.89035240e-02f,
  -4.71873075e-01f, 5.58033586e-01f, -4.41588283e-01f, 6.72485009e-02f, -2.74238773e-02f, 8.99219289e-02f, -1.23175897e-01f, 2.05727443e-01f, -7.95963332e-02f, -6.83272704e-02f,
  2.42399216e-01f, -1.39209196e-01f, -1.55864745e-01f, 8.35908726e-02f, -5.32215834e-03f, -9.09409765e-03f, -1.71885062e-02f, -1.66360408e-01f, 1.75787672e-01f, 1.03665501e-01f,
  4.71322909e-02f, -8.56607854e-02f, -3.45964760e-01f, -2.50129342e-01f, -2.62837380e-01f, -3.17648530e-01f, -2.57448167e-01f, 7.74204824e-03f, -1.60955582e-02f, -5.00079691e-01f,
  -6.70658350e-01f, 1.69603005e-01f, 4.01677072e-01f, -3.61707270e-01f, 3.45820338e-01f, 1.37742162e-01f, 3.71567644e-02f, 8.52063671e-02f, 1.25240930e-03f, 4.17359965e-03f,
  4.44035083e-01f, -5.64429685e-02f, -1.05857514e-01f, -5.31252623e-02f, -3.24960560e-01f, -1.85248554e-01f, -1.48571983e-01f, -2.91274846e-01f, -1.81242868e-01f, 7.40476772e-02f,
  -1.07548796e-01f, -3.07161450e-01f, -3.43279392e-01f, -2.39405572e-01f, -1.73681229e-01f, -3.45044315e-01f, 9.29857865e-02f, -3.11395898e-02f, -4.55024745e-03f, -2.94157982e-01f,
  1.27712265e-01f, 3.43494773e-01f, 1.38241962e-01f, -2.91658074e-01f, 7.18217194e-02f, -2.54978061e-01f, -2.30278075e-02f, 7.25652501e-02f, -1.50594180e-02f, -3.07112676e-03f,
  3.08279935e-02f, 3.18829566e-02f, 9.82523933e-02f, -1.58264920e-01f, -8.61663222e-02f, -1.00185767e-01f, 3.27636562e-02f, 5.54629788e-02f, -1.19200528e-01f, -4.36544530e-02f,
  -1.53068930e-01f, 4.57100831e-02f, 3.95070314e-02f, 1.87160477e-01f, 1.43200785e-01f, 1.08398452e-01f, 3.31312232e-02f, -9.00334865e-02f, 2.05684416e-02f, -4.32612181e-01f,
  -3.29748006e-03f, 9.80493203e-02f, 1.44442007e-01f, 1.70657819e-04f, -2.08888024e-01f, 1.33530989e-01f, -3.48600782e-02f, -1.66145101e-01f, 7.74329379e-02f, -5.43747619e-02f,
  6.85485974e-02f, 1.75918013e-01f, 1.08040415e-01f, 7.27185234e-02f, -1.69947483e-02f, 9.77010205e-02f, -7.97626153e-02f, -1.51614428e-01f, -1.47883296e-01f, -6.16609119e-02f,
  -1.33082137e-01f, -1.88311096e-02f, 2.06519365e-02f, -2.33439375e-02f, 1.54692875e-02f, -4.49638702e-02f, 1.22626066e-01f, 6.35774583e-02f, 1.08317338e-01f, 2.38749921e-01f,
  -2.83393055e-01f, 1.21118605e-01f, -3.42650443e-01f, -2.13727996e-01f, 7.99918473e-02f, -1.00219004e-01f, 1.09211169e-01f, -2.16477945e-01f, 1.92938179e-01f, -1.79519832e-01f,
  2.18564227e-01f, 5.26157916e-02f, -1.41944794e-03f, -1.50394425e-01f, -2.27735281e-01f, 1.56482264e-01f, -2.39321381e-01f, -9.21797752e-02f, -7.09567592e-02f, -3.99268940e-02f,
  -3.69843513e-01f, -4.41510379e-01f, -2.88778514e-01f, -1.74339101e-01f, -2.05930889e-01f, -3.16300273e-01f, -4.08302516e-01f, -4.12391603e-01f, -4.44102943e-01f, -8.13299239e-01f,
  -1.00439787e+00f, -1.58648610e-01f, -1.66431442e-02f, -2.60081649e-01f, 2.60454386e-01f, 2.36490443e-01f, 1.73113778e-01f, 1.73040107e-02f, -1.93142354e-01f, -5.09490296e-02f,
  -2.77928412e-01f, -1.44678935e-01f, 3.90228219e-02f, 8.44676346e-02f, -8.08419511e-02f, 4.28585291e-01f, 3.96063626e-01f, -2.36866903e-02f, -5.28896935e-02f, 2.42822655e-02f,
  2.43034676e-01f, -6.54784739e-02f, -3.79157543e-01f, -9.36239287e-02f, 5.26314676e-02f, 1.24438941e-01f, 3.97898890e-02f, 8.07245150e-02f, 3.74684483e-02f, 1.42575711e-01f,
  2.81011108e-02f, -3.71811360e-01f, 4.21373472e-02f, -2.79085875e-01f, -1.47573605e-01f, -2.68686444e-01f, -3.90638784e-02f, -1.84947550e-01f, -2.07713604e-01f, -7.09942952e-02f,
  -1.09178700e-01f, -1.89138606e-01f, -1.93196312e-02f, 8.97272006e-02f, 3.79696041e-02f, -1.69173732e-01f, -9.06653106e-02f, -1.74394861e-01f, -1.40440419e-01f, -1.46398982e-02f,
  2.44126737e-01f, 6.04908122e-03f, -1.54046908e-01f, 7.44694173e-02f, -8.91842097e-02f, -1.27898246e-01f, -1.72614425e-01f, -1.84798345e-01f, -2.23167568e-01f, -2.84304559e-01f,
  1.25446901e-01f, 7.42912963e-02f, -3.83154303e-02f, -9.72872227e-03f, -3.15532414e-03f, 8.04482400e-02f, 1.22092828e-01f, 1.42708257e-01f, -1.41274612e-02f, 1.29187256e-02f,
  -6.71451241e-02f, -8.65481570e-02f, -3.55883613e-02f, -1.06761657e-01f, -7.18875229e-02f, -1.00368977e-01f, -5.33176064e-02f, -4.13048752e-02f, -8.90218168e-02f, -1.74084216e-01f,
  -1.28393933e-01f, 1.68552659e-02f, -4.47524935e-02f, -1.85444858e-02f, -6.03748150e-02f, -6.14310950e-02f, 4.21762429e-02f, 7.12774741e-03f, 6.70004461e-04f, 3.71377822e-03f,
  -1.88354552e-02f, -1.40682489e-01f, 1.32912202e-02f, 1.19416244e-01f, 5.69978245e-02f, -1.10930234e-01f, -8.50246027e-02f, -1.28910884e-01f, -9.54077404e-04f, 3.11055202e-02f,
  -3.75184715e-02f, -4.32231985e-02f, 5.75331450e-02f, -1.62333529e-02f, 1.08599052e-01f, 2.52643786e-02f, -2.08804514e-02f, 4.87573855e-02f, 6.83747828e-02f, 1.04860440e-01f,
  3.08955088e-02f, 8.14717337e-02f, 7.24954754e-02f, 7.99331218e-02f, 2.21838400e-01f, 1.22312024e-01f, 1.53306663e-01f, 1.30277291e-01f, 1.38929024e-01f, 1.51167586e-01f,
  -1.88427404e-01f, -6.30718470e-01f, 2.45627746e-01f, 1.17239632e-01f, 3.28154981e-01f, 2.93177813e-01f, 1.28066897e-01f, 1.76732913e-02f, 9.90383625e-02f, -6.99953809e-02f,
  -1.73256382e-01f, -2.31873259e-01f, -1.52557179e-01f, -2.43650347e-01f, -1.86466902e-01f, -5.70471585e-02f, 1.53790358e-02f, -3.25453691e-02f, 1.10621043e-01f, 4.08930592e-02f,
  -1.76561832e-01f, -2.07861140e-03f, -1.17246360e-01f, -2.26954278e-02f, 4.43307944e-02f, -6.42327070e-02f, 1.24288805e-01f, 1.59855887e-01f, -2.77739596e-02f, -9.98318791e-02f,
  3.08082789e-01f, 4.69911024e-02f, -2.58562267e-02f, -8.33669528e-02f, 2.17697527e-02f, -1.89901695e-01f, -1.11263981e-02f, 1.00766728e-02f, -2.66946964e-02f, 7.60511681e-02f,
  1.04953609e-01f, 1.69359036e-02f, 1.00018986e-01f, 5.10013327e-02f, 2.88221911e-02f, 1.54202372e-01f, 7.23349527e-02f, -2.31928173e-02f, -2.08869614e-02f, 1.01936258e-01f,
  -1.24659054e-01f, 1.72908574e-01f, 2.96246380e-01f, 2.23601330e-02f, 9.48833674e-02f, 1.01252407e-01f, 1.11394763e-01f, 1.17281608e-01f, 1.66613385e-01f, 1.19230170e-02f,
  -5.39053464e-04f, -1.00404739e-01f, 6.03762381e-02f, 1.25642776e-01f, 7.60968104e-02f, -4.24860381e-02f, 7.07905218e-02f, -1.64974332e-02f, -9.24027618e-03f, -1.67588051e-02f,
  2.01165676e-03f, 1.10619076e-01f, 2.66651455e-02f, -9.77266356e-02f, -4.37551364e-02f, 9.07451585e-02f, 4.55133729e-02f, -3.46498750e-02f, 1.57110766e-01f, 2.02392176e-01f,
  4.83929180e-02f, -4.37485473e-03f, -6.02636263e-02f, 5.99595644e-02f, 2.00896244e-02f, 2.26675346e-02f, 6.77982420e-02f, 5.38908616e-02f, -2.01953817e-02f, -6.01482689e-02f,
  2.04347476e-01f, 5.47801480e-02f, -7.79524669e-02f, -5.21999188e-02f, 6.32364601e-02f, -2.22973689e-01f, -6.88697696e-02f, -1.74026489e-02f, 6.46497682e-02f, 3.34381051e-02f,
  6.42464682e-02f, -1.46292850e-01f, -4.61576805e-02f, -9.41504315e-02f, 2.37152204e-02f, -6.04908690e-02f, -1.61450610e-01f, -3.38760354e-02f, -7.85383582e-02f, 1.89468637e-02f,
  -1.76356718e-01f, -3.85791063e-02f, 9.93242636e-02f, 3.23604718e-02f, -1.90597355e-01f, -1.13025099e-01f, -2.63151247e-03f, -9.33867767e-02f, 3.84801365e-02f, -9.89956930e-02f,
  7.10117161e-01f, -4.47189547e-02f, 3.80160481e-01f, 1.98835850e-01f, 3.23382854e-01f, 3.81677270e-01f, 3.91762376e-01f, 2.92999774e-01f, 1.63710341e-01f, 1.44329861e-01f,
  -6.10726513e-02f, -3.92701253e-02f, -1.22814149e-01f, -1.88622668e-01f, 5.78867421e-02f, 9.66836736e-02f, 3.20839509e-02f, 1.06807671e-01f, 1.79224372e-01f, 1.59215316e-01f,
  2.17109337e-03f, 1.36147648e-01f, 1.23428784e-01f, 6.42736331e-02f, -1.04775496e-01f, -1.96805611e-01f, 8.53843465e-02f, -8.76569375e-02f, -1.18690617e-01f, -1.66373104e-01f,
  -2.72058249e-01f, 8.33216682e-02f, -1.95745230e-01f, -2.42756262e-01f, -2.18635246e-01f, -2.03769401e-01f, -1.75573193e-02f, -2.65495311e-02f, -1.71500117e-01f, -9.94330496e-02f,
  -2.20646545e-01f, -1.14103511e-01f, -2.97627449e-02f, -8.33455473e-02f, 2.21355017e-02f, 3.94191295e-02f, -5.30644916e-02f, 7.54823834e-02f, -6.30390272e-02f, -1.18685879e-01f,
  -1.84189305e-01f, 1.02771796e-01f, 1.73060521e-01f, 1.71151355e-01f, 1.42552540e-01f, 2.29418781e-02f, 5.16176559e-02f, -7.89303929e-02f, 1.52645335e-01f, 2.29860365e-01f,
  1.40642047e-01f, 2.84982055e-01f, 9.22022909e-02f, 7.96014220e-02f, 9.37576685e-03f, 2.02036444e-02f, -2.83418652e-02f, 4.22181562e-02f, 2.31165543e-01f, 2.08883941e-01f,
  -6.38534352e-02f, 1.05172999e-01f, 1.47071570e-01f, 9.85884517e-02f, 5.63021116e-02f, 1.02725439e-01f, -5.60982488e-02f, -6.30624741e-02f, -1.06588654e-01f, -2.15241641e-01f,
  1.18410297e-01f, -4.10224963e-03f, -7.01716617e-02f, -1.82458479e-02f, 4.40938771e-02f, 6.14476949e-03f, -1.80232793e-03f, 6.15665177e-03f, 8.02260861e-02f, 1.27725471e-02f,
  -3.36921453e-01f, -4.80491295e-02f, -2.20754132e-01f, -1.49734810e-01f, 2.68241912e-02f, 1.41602494e-02f, 2.56027635e-02f, -8.48315507e-02f, -1.73800796e-01f, -9.29131433e-02f,
  1.59746245e-03f, -1.25606194e-01f, -9.35116038e-02f, 6.19343631e-02f, 1.54351443e-01f, 6.87658936e-02f, 1.00702934e-01f, 1.63054198e-01f, -6.71093389e-02f, -1.34618923e-01f,
  5.51964268e-02f, 1.45543084e-01f, 9.10912678e-02f, 1.25049204e-01f, 1.30600771e-02f, 1.00572981e-01f, 1.17028952e-01f, 9.30013359e-02f, 1.64068148e-01f, 2.83922791e-01f,
  5.23596723e-03f, 4.52331364e-01f, -1.16316609e-01f, 1.81072146e-01f, 5.04526258e-01f, 3.84145528e-01f, 5.44974029e-01f, 1.61297187e-01f, -8.40112660e-03f, 2.01506972e-01f,
  3.16041499e-01f, 2.20259145e-01f, 1.25934154e-01f, 8.59813020e-02f, 1.79035842e-01f, 1.09258659e-01f, 6.44352138e-02f, -1.16883583e-01f, -4.95068021e-02f, -5.64740949e-05f,
  2.01953411e-01f, 5.45941368e-02f, -6.18457645e-02f, 6.99501336e-02f, 1.88490197e-01f, -3.46134119e-02f, 4.19302732e-02f, 3.04317296e-01f, 2.48868853e-01f, -5.13655953e-02f,
  -2.54403710e-01f, 7.38515258e-02f, -2.98185736e-01f, 7.97296241e-02f, 4.34132926e-02f, -1.82038844e-01f, -1.83651745e-01f, -9.94185731e-02f, 1.06557123e-02f, -1.62258849e-01f,
  1.09253094e-01f, -2.92758662e-02f, 1.46631733e-01f, 5.83291277e-02f, 3.58735770e-02f, -6.58316463e-02f, -1.93351302e-02f, -1.14030629e-01f, 1.12456456e-02f, -8.04270282e-02f,
  1.72763020e-01f, 1.87968940e-01f, 8.15088227e-02f, 4.75420319e-02f, 1.31669253e-01f, 9.88786593e-02f, 2.96413954e-02f, 5.81176206e-02f, -8.62316787e-02f, -1.73499048e-01f,
  5.57008944e-03f, 3.55554074e-02f, 1.48485959e-01f, -2.49652751e-02f, 7.28312582e-02f, -1.59557872e-02f, -1.35827661e-01f, 1.39955491e-01f, 1.58721507e-01f, -9.64498613e-03f,
  -2.05779940e-01f, -1.51487216e-01f, -2.10547283e-01f, -2.14713052e-01f, 1.27259493e-01f, -2.90633552e-02f, 4.32895422e-02f, 7.02990144e-02f, 1.88512921e-01f, 2.61432528e-02f,
  4.66634780e-02f, -1.56207487e-01f, 2.46576723e-02f, -5.82353026e-02f, -1.39401644e-01f, -1.88328639e-01f, -8.89020935e-02f, -5.46912514e-02f, -1.66228563e-02f, -3.21642458e-02f,
  -2.71022886e-01f, 2.19313875e-01f, -1.48739532e-01f, 1.84688885e-02f, 2.24363580e-01f, 2.69608647e-02f, 1.06573157e-01f, -1.69169270e-02f, 3.94700207e-02f, -2.08397120e-01f,
  -5.22355400e-02f, -6.69019595e-02f, 8.20663422e-02f, -1.23678252e-01f, -9.15692821e-02f, -5.21840416e-02f, 8.44382644e-02f, -1.07144617e-01f, -1.20251313e-01f, -9.01441574e-02f,
  -2.05985811e-02f, -3.08111608e-01f, -3.28901052e-01f, -1.64279565e-01f, -6.90618381e-02f, -1.11548118e-01f, -4.12815697e-02f, -2.09073201e-01f, -1.05479635e-01f, -3.18896085e-01f,
  -1.28284752e+00f, 1.35292783e-01f, -1.73437260e-02f, -2.23354787e-01f, 7.07410797e-02f, 1.77770481e-02f, 2.10523903e-01f, 7.96432495e-02f, -1.81411192e-01f, -5.91546334e-02f,
  1.68247167e-02f, 1.29225880e-01f, 9.67756286e-02f, 1.17708743e-01f, 4.39595170e-02f, 1.79731250e-01f, 2.79324710e-01f, -2.56269015e-02f, -1.13817312e-01f, -3.13812941e-02f,
  1.62617341e-01f, -1.42255321e-01f, -3.11246634e-01f, -9.18897390e-02f, 1.82015032e-01f, 1.03731498e-01f, 5.96275255e-02f, 8.02174360e-02f, 2.36727923e-01f, 1.12395987e-01f,
  5.67844331e-01f, -1.73196301e-01f, -3.49961519e-02f, -5.77205233e-02f, -9.89053771e-02f, -1.97588935e-01f, -7.51442909e-02f, 3.28702226e-05f, -3.49031277e-02f, 1.09677061e-01f,
  -8.47340152e-02f, -4.88703288e-02f, -6.03070445e-02f, 1.24538571e-01f, 7.29598328e-02f, -5.21631613e-02f, 5.84775135e-02f, 4.07309011e-02f, 2.19005704e-01f, 9.62684304e-02f,
  4.68321443e-02f, 1.14268325e-01f, 2.50596285e-01f, 1.46894902e-01f, 4.85628732e-02f, 4.53891531e-02f, -1.16500808e-02f, -7.96406996e-03f, -3.29475217e-02f, -9.70304105e-03f,
  8.13479424e-02f, -9.06731933e-02f, 6.06266186e-02f, -3.84691358e-02f, -1.53623717e-02f, -1.61655713e-02f, 5.62108792e-02f, 2.43133549e-02f, 1.38602331e-02f, -1.41204968e-01f,
  2.05494449e-01f, 2.09998727e-01f, 1.04906425e-01f, 1.71871148e-02f, 8.36121012e-03f, 1.02864385e-01f, -2.12828629e-02f, 9.72603112e-02f, -5.50036617e-02f, -5.92517555e-02f,
  -2.59181000e-02f, 2.81335097e-02f, 6.74497988e-03f, 6.72822148e-02f, 2.02359915e-01f, 3.56855653e-02f, 2.68921331e-02f, -3.29227559e-02f, -8.21152627e-02f, -5.65345585e-03f,
  5.53580582e-01f, -1.38897538e-01f, 4.40646261e-02f, -5.39314039e-02f, -1.04859434e-01f, -1.23223476e-01f, 2.08571032e-02f, -5.49464263e-02f, 1.24163412e-01f, 1.48806915e-01f,
  4.45804149e-02f, -1.09696969e-01f, 4.17272979e-03f, -1.10149402e-02f, -1.66592315e-01f, 6.02161214e-02f, -1.02155998e-01f, 5.97145036e-02f, 1.30393535e-01f, 1.46268800e-01f,
  -7.86679462e-02f, 5.27246967e-02f, 6.95834234e-02f, 6.88838866e-03f, -1.10780299e-01f, 2.40808837e-02f, 1.18533105e-01f, -9.11693182e-03f, 1.14893414e-01f, -6.40950575e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.18544078e-01f, 1.67561397e-01f, 3.98648791e-02f, 1.56651884e-02f, -1.05808012e-01f, 1.29937604e-01f, 5.15192211e-01f, 3.62364471e-01f, 2.50974327e-01f, 7.71343350e-01f,
  4.47100550e-01f, 3.91058743e-01f, 4.33843434e-01f, -9.92623251e-03f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.47517414e-02f, -1.65621281e-01f, 1.37320876e-01f, 5.24131395e-02f, -3.73133942e-02f, 4.86444384e-02f, 2.30817944e-02f, -1.43156439e-01f, -1.76281139e-01f, -8.40478763e-02f,
  -9.18527693e-02f, -5.32678477e-02f, -3.78547586e-03f, 4.76472825e-03f, 6.39696419e-02f, 1.12031132e-01f, -1.25793517e-01f, -5.80715649e-02f, -6.44964650e-02f, -2.56447285e-01f,
  -6.57407418e-02f, -1.56177236e-02f, -1.19846277e-01f, -3.74292046e-01f, -7.62955993e-02f, 1.99183136e-01f, -1.22046635e-01f, -4.77393232e-02f, 6.66807368e-02f, 7.57571608e-02f,
  -1.52531359e-03f, 1.46716371e-01f, -9.61093158e-02f, 3.64389330e-01f, -2.61240527e-02f, 3.68452370e-02f, 5.67825511e-02f, -7.91896656e-02f, -6.26376718e-02f, -1.21509239e-01f,
  1.22388631e-01f, -1.51781654e-02f, 7.64901713e-02f, 5.18502109e-02f, 2.24468276e-01f, -1.72089227e-02f, -1.03667103e-01f, -1.28329635e-01f, -4.75689545e-02f, 2.12768942e-01f,
  -1.06608652e-01f, -5.94747543e-01f, -1.52199030e-01f, 4.28076787e-03f, 4.96479422e-02f, 2.52024233e-01f, 5.82117923e-02f, 1.30207568e-01f, 3.95565629e-01f, -6.15749545e-02f,
  1.25810906e-01f, 2.16817155e-01f, -2.17995029e-02f, -4.13037539e-02f, -3.17388326e-02f, -2.22348616e-01f, 6.79438114e-02f, -6.52892888e-02f, 6.48508817e-02f, 1.15841562e-02f,
  -1.10951558e-01f, -7.54813328e-02f, -1.76853612e-01f, 2.40257401e-02f, -1.67803362e-01f, -8.49020574e-03f, 1.64794363e-02f, -7.30355084e-02f, 1.88608207e-02f, 3.68493609e-02f,
  6.19641207e-02f, -7.72278011e-02f, -1.27738982e-01f, -1.32485494e-01f, -1.74360260e-01f, 7.48469681e-02f, -3.04726027e-02f, -2.12123826e-01f, 8.19193870e-02f, 1.23769067e-01f,
  -4.75369208e-02f, 7.14357048e-02f, 8.28920752e-02f, -1.57757789e-01f, -7.78353363e-02f, 2.35096887e-01f, -1.18213385e-01f, 1.00788191e-01f, -1.38093144e-01f, 5.27623147e-02f,
  9.33287293e-03f, -1.48338377e-01f, 3.28918472e-02f, -1.31517917e-01f, 1.41477972e-01f, -8.17626622e-03f, -8.12352076e-02f, -5.49873784e-02f, 6.38052300e-02f, 9.69118327e-02f,
  -8.55662152e-02f, -1.00598678e-01f, -3.92772034e-02f, -1.19458728e-01f, -4.84169088e-02f, -6.07236862e-01f, -1.64975256e-01f, -5.65859303e-02f, -1.16870478e-01f, 2.79301386e-02f,
  -1.87491760e-01f, 4.12266493e-01f, 3.66498888e-01f, -1.22422248e-01f, 8.69594738e-02f, 2.10588336e-01f, 1.72259718e-01f, 4.49219942e-02f, 2.75412574e-03f, -1.08536027e-01f,
  1.18896249e-03f, -1.43191461e-02f, -4.75264452e-02f, 1.49147183e-01f, -1.01186410e-01f, -2.33269315e-02f, -8.13369229e-02f, 5.97010069e-02f, -1.09182671e-01f, -1.18634388e-01f,
  4.97632939e-03f, -9.54563357e-03f, 1.09788515e-02f, 5.30394539e-03f, 1.88801214e-02f, 9.61217210e-02f, -9.54885557e-02f, -1.87623724e-02f, 9.92303714e-02f, 2.31961980e-02f,
  -5.86059950e-02f, -1.06556438e-01f, 4.12507690e-02f, 8.29945877e-03f, -2.52441585e-01f, 7.52343684e-02f, 9.97575596e-02f, 1.30097970e-01f, 2.49748770e-02f, 3.97824459e-02f,
  -9.54550952e-02f, 2.76706487e-01f, 6.01625219e-02f, 2.00909302e-01f, 2.60260493e-01f, -1.20872542e-01f, -1.03008011e-02f, 2.27661535e-01f, 2.72416379e-02f, 9.24352258e-02f,
  -2.47956812e-02f, -1.65715098e-01f, 1.48255959e-01f, -1.02140002e-01f, -5.43968976e-02f, -1.24945201e-01f, -4.73206602e-02f, -6.98652789e-02f, 2.00756237e-01f, -3.24526340e-01f,
  3.30960825e-02f, 1.41065747e-01f, -6.41153827e-02f, -3.02367419e-01f, 1.91612318e-01f, -4.09803808e-01f, -2.00519245e-02f, -1.37452796e-01f, -1.07687004e-01f, -1.11663952e-01f,
  2.84353308e-02f, -1.08567074e-01f, -8.94220360e-03f, -1.61749721e-01f, 1.47174254e-01f, 6.46215864e-04f, 1.05109230e-01f, 3.26106884e-02f, -1.21555172e-01f, -4.76748794e-02f,
  -1.13445692e-01f, -2.63903514e-02f, -8.10872912e-02f, 1.78900391e-01f, 4.19616662e-02f, -1.25671968e-01f, -2.09406391e-02f, 1.47280339e-02f, -2.74210386e-02f, -1.09190747e-01f,
  -1.43640339e-01f, -5.71868420e-02f, 2.39656097e-03f, 1.20446479e-04f, -5.00759948e-03f, -1.21601954e-01f, 1.08285509e-01f, 4.67813648e-02f, -1.40461475e-01f, 1.11816190e-01f,
  5.94266355e-02f, 4.88220081e-02f, -1.73909217e-01f, 1.06983460e-01f, 3.37667651e-02f, -4.85173985e-02f, 6.92384224e-03f, -5.20578399e-02f, 2.27995589e-02f, 7.66866803e-02f,
  3.70843522e-02f, -2.49035414e-02f, 4.25712671e-04f, 5.78665994e-02f, -9.05332156e-03f, -1.68548241e-01f, 2.89982953e-03f, -2.18052175e-02f, -9.97034833e-02f, -2.16826633e-01f,
  2.90907212e-02f, -1.15023524e-01f, 3.33808452e-01f, -3.10049444e-01f, 1.13367662e-01f, 6.00744300e-02f, -9.77900699e-02f, 1.05455279e-01f, -1.51608540e-02f, 1.52044162e-01f,
  3.71805012e-01f, -4.72795457e-01f, -7.26324767e-02f, -2.53450751e-01f, 9.84565094e-02f, -1.03434868e-01f, -8.34499747e-02f, -9.20052603e-02f, -2.75767818e-02f, 1.19050480e-01f,
  1.56248838e-01f, -3.08458805e-02f, -1.68287352e-01f, -1.20289110e-01f, 1.09514277e-02f, -9.50709283e-02f, 5.22514768e-02f, -5.25683835e-02f, -1.08242907e-01f, -1.75530314e-01f,
  6.95254803e-02f, 5.90670779e-02f, 1.97140966e-02f, -1.99524760e-02f, 3.79345380e-02f, -1.04767993e-01f, -6.81753829e-02f, -2.04907190e-02f, 1.63901612e-01f, 2.58868784e-01f,
  -1.05728373e-01f, 2.78870352e-02f, -1.42026827e-01f, 1.36666626e-01f, 5.86608835e-02f, 9.19100270e-02f, -8.62769037e-02f, 2.44634539e-01f, 9.13877785e-02f, -1.59693211e-01f,
  -7.64194597e-03f, -5.05159616e-01f, -1.62515447e-01f, -1.95648715e-01f, 1.51113784e-02f, -1.22890130e-01f, -7.52263442e-02f, 1.78486466e-01f, 6.37496039e-02f, 5.30437157e-02f,
  -1.35677844e-01f, 8.49908441e-02f, -1.31272763e-01f, 2.80849356e-02f, 6.71331733e-02f, -1.45110518e-01f, 2.15505213e-01f, 2.80480564e-01f, -1.54855236e-01f, -7.94141293e-02f,
  5.02651595e-02f, -2.24175081e-01f, -1.55589342e-01f, 2.86809951e-01f, -1.80923000e-01f, 3.04334313e-01f, -2.58412242e-01f, -1.19014807e-01f, 3.60166401e-01f, 2.74360865e-01f,
  -5.25229461e-02f, -1.62174344e-01f, 2.97073554e-02f, 1.48889320e-02f, 1.09063335e-01f, -1.10899219e-02f, -8.96932483e-02f, -5.52113689e-02f, 1.95001476e-02f, -5.12493716e-04f,
  -1.33824140e-01f, -1.78059805e-02f, -1.00618908e-02f, -5.52767515e-02f, 4.54269946e-02f, -1.28175512e-01f, -3.63600552e-02f, 5.23001850e-02f, -1.08237803e-01f, -4.94615594e-03f,
  -5.38078099e-02f, -1.27754405e-01f, -5.95049225e-02f, -2.08797097e-01f, 3.81933711e-02f, 1.33541182e-01f, -2.47006372e-01f, 8.07158947e-02f, 3.75090912e-02f, 7.73497745e-02f,
  -1.30475685e-01f, -7.01625571e-02f, -3.68465111e-02f, 7.99461380e-02f, -6.89678416e-02f, 5.38829267e-02f, -8.49087071e-03f, -1.50679350e-02f, -7.88345039e-02f, 4.08572294e-02f,
  6.89102188e-02f, 7.04245567e-02f, 4.70459647e-02f, -1.12535320e-01f, 1.14198841e-01f, 1.33611839e-02f, -8.68901089e-02f, -1.79413363e-01f, -1.02976106e-01f, -7.52634974e-03f,
  1.60947621e-01f, -4.85187829e-01f, -1.98689885e-02f, -1.20533787e-01f, -1.09014235e-01f, 1.09037206e-01f, 7.20871836e-02f, -5.76741323e-02f, 3.47178191e-01f, -3.39156061e-01f,
  -1.74302962e-02f, -4.19709496e-02f, 2.19846055e-01f, 4.98908237e-02f, 1.72080263e-01f, -1.15569733e-01f, -1.48785831e-02f, -1.03266547e-02f, -1.04897141e-01f, -5.30546382e-02f,
  4.26511047e-03f, 1.51363790e-01f, -1.61590219e-01f, 4.82629426e-02f, 1.26055196e-01f, 5.91851473e-02f, 7.20943697e-03f, -9.77770835e-02f, -3.80686149e-02f, 1.01469150e-02f,
  4.01454158e-02f, 4.03302349e-02f, 5.58688724e-03f, -3.75439003e-02f, 1.33605286e-01f, 4.93015386e-02f, -1.16932809e-01f, -2.27617417e-02f, 5.10618016e-02f, -1.52889714e-01f,
  -3.27551663e-01f, -1.70855522e-02f, -1.68511865e-03f, -5.48164584e-02f, -1.22675952e-03f, 1.54394940e-01f, -1.37163088e-01f, 2.25848749e-01f, 9.60853845e-02f, -2.52782911e-01f,
  -2.94024318e-01f, 4.27253693e-02f, -8.76047537e-02f, -4.90884408e-02f, 6.62594428e-03f, -3.48650724e-01f, 1.10684134e-01f, -7.63735501e-03f, 7.81279132e-02f, -2.66864538e-01f,
  -1.71607047e-01f, -1.14470936e-01f, -3.62893678e-02f, 3.08091901e-02f, -3.43000561e-01f, -2.05815688e-01f, -1.61810219e-01f, 5.57137690e-02f, -3.49845402e-02f, -1.82113111e-01f,
  4.18752208e-02f, 6.46992773e-02f, -5.35932817e-02f, 3.24247568e-03f, 4.96546403e-02f, -5.12354970e-02f, 3.80147621e-02f, 2.19810735e-02f, 3.13599706e-02f, -1.34048596e-01f,
  2.21849412e-01f, -8.49923864e-02f, -2.31896773e-01f, -4.39358614e-02f, -1.24701530e-01f, -8.34598169e-02f, -7.35852048e-02f, -3.03467270e-02f, -4.67904145e-03f, -5.08614965e-02f,
  1.04090139e-01f, -4.45070677e-02f, -2.35453680e-01f, 9.57782567e-02f, -1.35776266e-01f, -2.26748601e-01f, 7.04635978e-02f, -1.36340529e-01f, -1.57425970e-01f, -2.59540588e-01f,
  9.65485908e-03f, -1.55253500e-01f, 7.71815851e-02f, -8.20095912e-02f, 4.35585640e-02f, -5.63781075e-02f, -1.01564163e-02f, 9.07683820e-02f, 1.57781988e-01f, 1.51309907e-01f,
  -1.79213241e-01f, 2.41032884e-01f, -1.21247306e-01f, 1.08335786e-01f, -4.72918153e-02f, 2.10195363e-01f, -5.44625111e-02f, -3.09424132e-01f, 1.15767442e-01f, 5.19204028e-02f,
  1.12397984e-01f, -1.07369788e-01f, 7.51177371e-02f, 1.67408958e-01f, -1.84014469e-01f, -8.61082599e-02f, 9.55959409e-02f, 2.35284679e-02f, -4.59138006e-01f, 1.25412211e-01f,
  -1.01453364e-01f, -1.20710053e-01f, 1.01335533e-01f, 3.29205990e-01f, -1.00166872e-01f, 2.21059874e-01f, 8.59332979e-02f, 6.64932504e-02f, -2.07031127e-02f, 4.98753451e-02f,
  1.94703534e-01f, -2.40193859e-01f, -9.08219740e-02f, -1.42119244e-01f, 2.06265438e-04f, 1.43337250e-01f, 1.52880698e-01f, -2.29289872e-03f, 1.20634355e-01f, 1.56080285e-02f,
  -1.05919063e-01f, 1.08203791e-01f, 1.48103774e-01f, 2.64664263e-01f, 2.41701484e-01f, 1.01886645e-01f, -1.72994629e-01f, 5.69613017e-02f, 3.75643790e-01f, -3.56104895e-02f,
  -1.64724067e-01f, 1.36208639e-01f, -1.55190423e-01f, -1.50611550e-01f, 5.58818989e-02f, 1.67030886e-01f, 2.51540124e-01f, 5.58613725e-02f, -1.22928761e-01f, 2.42798985e-03f,
  1.02433294e-01f, 4.45603393e-02f, -1.22437915e-02f, 6.32138103e-02f, -9.94654372e-02f, 1.44714236e-01f, -4.61383685e-02f, -1.66197106e-01f, -1.63231358e-01f, 1.89533919e-01f,
  1.50434710e-02f, -6.90449774e-02f, 1.30549043e-01f, -1.92500167e-02f, -7.70170614e-02f, -9.65768397e-02f, 1.60099611e-01f, -9.19736773e-02f, -1.21144027e-01f, -1.41251475e-01f,
  -1.44112587e-01f, -7.66506866e-02f, -5.73300757e-02f, 4.04077590e-01f, -6.31338060e-02f, -4.87415195e-02f, -6.63376600e-02f, 2.36137122e-01f, 1.16068944e-01f, 2.70063698e-01f,
  2.13400617e-01f, -3.01843792e-01f, -4.46939580e-02f, 1.00473434e-01f, -2.16465537e-03f, -1.83529183e-02f, 7.08163669e-03f, 1.20395139e-01f, 5.66036580e-03f, -7.09727639e-03f,
  -2.09849045e-01f, 1.30465969e-01f, -5.28811058e-03f, 1.95409525e-02f, 5.78955002e-02f, -7.41939694e-02f, -5.57460338e-02f, -5.86164556e-03f, 4.38297093e-02f, 2.28609890e-01f,
  9.08935294e-02f, -7.35305920e-02f, -1.78591684e-02f, 7.25718588e-02f, -1.30340504e-03f, 2.19064951e-02f, 9.35706049e-02f, 5.75766601e-02f, -1.22903913e-01f, -2.32913047e-01f,
  9.69958678e-03f, -6.22360371e-02f, 1.08250722e-01f, -8.72873217e-02f, -4.77206707e-02f, -1.33394912e-01f, 3.52292880e-02f, 1.69404641e-01f, -1.11851409e-01f, 2.13463202e-01f,
  -1.49783224e-01f, 2.09766403e-01f, 2.16762796e-01f, -2.42233679e-01f, -4.06770967e-03f, -1.55177534e-01f, -2.13166490e-01f, 1.70245662e-01f, -1.35817319e-01f, -2.14525640e-01f,
  -8.64259079e-02f, 3.05687279e-01f, -2.38086462e-01f, -6.78028166e-02f, -1.88380629e-02f, 2.34414279e-01f, 2.66548723e-01f, -4.10504788e-01f, -3.01356941e-01f, -2.36738309e-01f,
  -1.98201686e-01f, -2.48877078e-01f, 3.34091596e-02f, -4.76586074e-02f, 2.41171122e-01f, 1.87661484e-01f, -2.04583593e-02f, -4.86155748e-02f, 1.27222493e-01f, 2.87563711e-01f,
  7.97853712e-03f, 1.06311209e-01f, -2.28120595e-01f, -3.39350337e-03f, -7.16680810e-02f, -4.35344921e-03f, -2.24148799e-02f, 1.56231895e-02f, 2.68403199e-02f, -1.70451365e-02f,
  -1.23173177e-01f, 2.27939021e-02f, 4.25493754e-02f, 7.38566741e-02f, 9.22489315e-02f, 4.23605507e-03f, -1.77997332e-02f, 3.69146280e-02f, -1.51436813e-02f, -2.95335776e-03f,
  -7.61036053e-02f, -7.42973899e-03f, 8.66354734e-04f, -3.02712247e-02f, 1.25548821e-02f, -1.31594852e-01f, -8.77189562e-02f, 2.08292957e-02f, -3.22910175e-02f, -8.15033317e-02f,
  9.48514789e-02f, 5.22083342e-02f, -1.57280177e-01f, -3.07677746e-01f, 1.05048068e-01f, 2.53268611e-03f, 1.32235931e-02f, -2.19257548e-01f, 6.52219951e-02f, -1.47602126e-01f,
  4.67856973e-02f, 3.24808732e-02f, 4.75976281e-02f, -5.72923478e-03f, -2.10306555e-01f, 1.17420882e-01f, -3.40714515e-03f, -5.48405945e-02f, -2.04232708e-02f, -6.59752637e-02f,
  2.62016684e-01f, -6.69546306e-01f, -2.25955993e-01f, -3.00444424e-01f, -1.28608301e-01f, 7.77386129e-02f, -8.85685384e-02f, -6.94557577e-02f, 3.13022941e-01f, 1.48420677e-01f,
  -7.68905059e-02f, -3.80158499e-02f, 3.03749561e-01f, 1.44161388e-01f, -1.16358161e-01f, -8.64124149e-02f, -2.40823068e-02f, 4.16855849e-02f, -3.09568513e-02f, -1.10065872e-02f,
  -1.13255650e-01f, -4.30773906e-02f, -3.76037925e-01f, 6.55607581e-02f, -1.57345012e-01f, -9.76935327e-02f, 8.53685811e-02f, -1.35634795e-01f, 1.86641753e-01f, -6.41756877e-02f,
  7.76101127e-02f, 1.75039074e-03f, -1.49408013e-01f, -1.46381199e-01f, -1.54708996e-01f, -1.39180720e-02f, -1.46350870e-02f, 1.10339880e-01f, 1.29609838e-01f, 3.61555517e-02f,
  -3.14235628e-01f, 3.57658178e-01f, 9.76288915e-02f, -7.57086463e-03f, -3.83068318e-03f, 5.06068587e-01f, -6.77348003e-02f, -3.49447936e-01f, 8.82579312e-02f, -1.82143182e-01f,
  -1.85213268e-01f, -1.25198603e-01f, 1.56359896e-01f, 2.16996353e-02f, -9.47492942e-03f, -1.62957236e-01f, -6.17640726e-02f, 6.64445907e-02f, -1.98061734e-01f, -2.56860871e-02f,
  -5.54099567e-02f, -2.78951675e-01f, -2.16714665e-01f, -5.22390306e-02f, -5.81246987e-02f, -4.57697183e-01f, 1.57028437e-02f, 2.68452000e-02f, 2.59020124e-02f, 7.76362717e-02f,
  -9.23939049e-02f, 8.62893835e-02f, 7.17795491e-02f, 4.26980183e-02f, -2.24159107e-01f, -1.51620461e-02f, 3.04628789e-01f, 2.08544955e-01f, 3.52935083e-02f, 1.33858770e-01f,
  -7.62602761e-02f, 8.37501362e-02f, -7.12526031e-03f, 4.38419171e-02f, 5.05908541e-02f, -1.14882976e-01f, 8.30872133e-02f, 7.77477995e-02f, -4.39627990e-02f, 9.44862440e-02f,
  8.44025537e-02f, 8.96213576e-02f, -1.25982627e-01f, 1.17004395e-01f, 2.94298735e-02f, 2.43877880e-02f, -6.58112625e-03f, 2.23808765e-01f, 1.06806174e-01f, 4.37958073e-03f,
  -4.40347791e-02f, 9.68570709e-02f, 1.34705186e-01f, -3.15970206e-03f, 1.39849663e-01f, -6.04634956e-02f, 1.87132489e-02f, -3.99345160e-02f, -1.57960188e-02f, -9.54405814e-02f,
  -3.36901210e-02f, -1.22724257e-01f, -7.20823854e-02f, 5.45015782e-02f, 4.54920456e-02f, 5.74715622e-02f, 4.81192097e-02f, -4.49720137e-02f, -1.20556340e-01f, 1.54839784e-01f,
  -9.14092138e-02f, -1.49465829e-01f, 8.74017701e-02f, 1.87772550e-02f, 1.14260837e-01f, 2.32015830e-02f, -8.02920014e-02f, 2.67221723e-02f, -1.74583476e-02f, 6.02664530e-01f,
  4.72963639e-02f, -1.76811814e-01f, -6.87727630e-02f, 1.31670430e-01f, 5.16620418e-03f, 1.26647487e-01f, -2.26960741e-02f, 1.49216980e-01f, -8.30795765e-02f, -1.15981296e-01f,
  -6.76014051e-02f, -4.83639091e-02f, -6.58422112e-02f, -8.59073177e-02f, -7.79197440e-02f, 4.12980020e-02f, 1.26257325e-02f, 9.99246240e-02f, 1.32991597e-01f, 1.09012589e-01f,
  -5.78574091e-02f, 3.38019133e-01f, 3.67900021e-02f, -4.18368019e-02f, -1.69625729e-02f, -1.55884072e-01f, 8.72590616e-02f, -1.36667058e-01f, 1.84291974e-01f, 8.47011954e-02f,
  -1.10143654e-01f, 5.64121418e-02f, 2.33829655e-02f, 1.68451920e-01f, 3.22930962e-02f, 1.86477035e-01f, 1.01771824e-01f, -5.28831184e-02f, -3.81566763e-01f, 1.11082532e-01f,
  6.46759495e-02f, 8.30140635e-02f, 9.68492255e-02f, 1.88524961e-01f, -1.40317380e-01f, -2.14508936e-01f, 1.75442189e-01f, -2.08073482e-02f, -5.83788976e-02f, -8.09090305e-03f,
  3.46145928e-02f, 9.79729295e-02f, -3.17369285e-03f, -1.16987914e-01f, 7.32328519e-02f, 3.41595821e-02f, -2.20121094e-03f, -1.04627095e-01f, -8.90606046e-02f, -1.76459968e-01f,
  -1.34115860e-01f, 1.12351589e-01f, 6.38213977e-02f, -5.32690346e-01f, 1.26870170e-01f, -1.04108766e-01f, -2.97248829e-02f, 2.38932192e-01f, 1.34901524e-01f, 8.16656053e-02f,
  1.67246297e-01f, -2.23988801e-01f, -2.72887535e-02f, 2.54837871e-02f, 4.60991003e-02f, -2.08528545e-02f, 6.76425397e-02f, 2.13368922e-01f, 1.02848180e-01f, -1.20580897e-01f,
  1.18794672e-01f, 3.10807787e-02f, 3.52065973e-02f, 1.58818021e-01f, 8.76700431e-02f, -7.40096495e-02f, -1.53337553e-01f, -2.48149917e-01f, -1.30542204e-01f, 2.86520179e-02f,
  1.61796197e-01f, -3.09667550e-02f, -4.78605693e-03f, -3.38458829e-02f, 4.80170138e-02f, 9.27508324e-02f, -9.15405825e-02f, 1.28656641e-01f, 1.31216855e-03f, 7.29287229e-03f,
  3.69160101e-02f, -5.67070358e-02f, -3.91193554e-02f, -4.49572057e-02f, -2.07242399e-01f, 5.07915430e-02f, 7.86644667e-02f, 4.86836433e-02f, -7.45981261e-02f, 1.21712431e-01f,
  -3.27139422e-02f, 1.95395514e-01f, 3.44604075e-01f, 2.49818832e-01f, -2.81617846e-02f, 1.85804721e-02f, -8.57196376e-02f, -1.52086958e-01f, 8.82325023e-02f, -6.76051006e-02f,
  -4.30802591e-02f, -8.50096121e-02f, 3.21230590e-02f, -5.34802713e-02f, -3.20751546e-03f, 9.21174809e-02f, -1.72149949e-02f, -1.83531821e-01f, -3.36298108e-01f, 2.06218168e-01f,
  4.84504104e-02f, -1.19196124e-01f, 3.16267401e-01f, -9.13207605e-02f, 1.69504210e-01f, -6.34645075e-02f, -1.50520336e-02f, 1.46469459e-01f, -6.77323416e-02f, 1.76499542e-02f,
  2.48691067e-03f, -6.18267134e-02f, 1.60784215e-01f, 2.65894122e-02f, 1.85057614e-02f, -5.88261299e-02f, -5.84475212e-02f, 7.25227594e-02f, -1.32898495e-01f, 7.95206577e-02f,
  1.22471079e-01f, 2.16735080e-02f, 3.77156548e-02f, -1.47548318e-01f, 3.89100574e-02f, 1.89974066e-02f, 4.11816202e-02f, -1.95491090e-02f, 7.44147226e-02f, -7.75859430e-02f,
  -3.51870023e-02f, 3.76564125e-03f, 1.39799630e-02f, -8.17228183e-02f, 1.22258797e-01f, 1.14470534e-01f, 2.84604877e-01f, -3.44615243e-02f, 1.75200999e-02f, 3.31404991e-02f,
  -1.41421586e-01f, -8.00623149e-02f, 2.61009056e-02f, -3.38990055e-02f, -5.18500768e-02f, 1.39863729e-01f, -1.28316700e-01f, -9.91275832e-02f, -7.02244416e-02f, -6.66207597e-02f,
  -5.38408421e-02f, 1.13508813e-01f, -1.20567180e-01f, 9.38864145e-03f, 3.52388658e-02f, 1.88961238e-01f, -3.61517221e-02f, 4.51177470e-02f, -5.88026047e-02f, -5.21246390e-03f,
  1.26030251e-01f, 3.17775071e-01f, 2.44280249e-01f, -1.45530641e-01f, -3.31460126e-03f, 2.29154959e-01f, -1.58392996e-01f, 1.76521167e-01f, 8.55769292e-02f, -1.27144068e-01f,
  -5.15437610e-02f, -1.43213913e-01f, 3.05655450e-02f, -1.69004992e-01f, 1.20179079e-01f, 1.05377935e-01f, 4.16985750e-02f, 1.48786604e-02f, 2.23863125e-01f, -7.26469420e-03f,
  6.60581067e-02f, 2.16398478e-01f, 3.67470235e-02f, -7.99816996e-02f, -9.19901952e-02f, -8.30881298e-02f, -2.83804955e-03f, 1.62901118e-01f, 1.89299792e-01f, -1.75091103e-01f,
  -2.04069391e-01f, 7.18955025e-02f, 1.03911884e-01f, 3.84298787e-02f, 3.16274092e-02f, 2.23260030e-01f, -2.86568124e-02f, -4.60932292e-02f, 2.17292383e-02f, 1.12339504e-01f,
  2.34343737e-01f, -6.53279200e-02f, -1.10606827e-01f, 6.96753990e-03f, -9.95239317e-02f, 1.04256436e-01f, 4.82103378e-02f, -1.33763820e-01f, 6.91386759e-02f, 3.33858192e-01f,
  2.79502571e-01f, -6.13101106e-03f, 7.13743716e-02f, -1.64838001e-01f, 1.11538963e-02f, -3.58793251e-02f, -2.66759451e-02f, 1.78350613e-01f, 6.09540008e-03f, 3.42617393e-01f,
  1.20822050e-01f, 2.61362374e-01f, 9.82598960e-02f, -2.83450005e-03f, -3.58806476e-02f, -3.76541018e-01f, 6.99177608e-02f, 1.52283423e-02f, 1.69454053e-01f, 3.95573378e-02f,
  -3.00372630e-01f, 3.69084567e-01f, 3.11583579e-01f, 3.47853363e-01f, 8.61013830e-02f, -3.88887301e-02f, -1.10447347e-01f, 1.57580912e-01f, -2.57402230e-02f, 2.14040503e-02f,
  7.94765204e-02f, 2.66154800e-02f, -7.05517232e-02f, 1.10519724e-02f, 5.12626022e-02f, 6.59999028e-02f, -3.04907650e-01f, -2.07416922e-01f, 1.07934281e-01f, -1.48165496e-02f,
  -1.38663780e-02f, -4.27279137e-02f, 1.71508312e-01f, 4.82003056e-02f, -4.88587283e-03f, -3.12025342e-02f, 6.17194027e-02f, -2.63063721e-02f, 3.09950653e-02f, -3.71726975e-02f,
  1.24299258e-03f, 4.76634204e-02f, 3.83011363e-02f, -1.14211470e-01f, -7.15441257e-02f, 4.30728570e-02f, 6.44561574e-02f, 1.41975386e-02f, 1.52414724e-01f, -1.54652610e-01f,
  -9.67335775e-02f, 1.78097144e-01f, -6.92069158e-02f, -2.64318943e-01f, -3.31796974e-01f, 3.02937105e-02f, -1.84586458e-02f, -1.08066961e-01f, -5.75862750e-02f, -4.66609932e-02f,
  3.42900702e-03f, 5.49071357e-02f, -1.35942310e-01f, -1.60426855e-01f, 6.18139766e-02f, 5.45053072e-02f, 8.58326852e-02f, 2.58598085e-02f, 2.98094481e-01f, -2.14817956e-01f,
  8.76440108e-02f, -1.92756906e-01f, -2.14049578e-01f, -9.14128348e-02f, -2.42269352e-01f, -4.09874916e-01f, -2.38277867e-01f, -7.90103897e-02f, 1.51677892e-01f, 2.19584838e-01f,
  2.54617691e-01f, 1.39696687e-01f, 1.04802549e-02f, -2.54354216e-02f, 9.96550918e-02f, 1.49026379e-01f, -5.92409894e-02f, -9.46228672e-03f, -1.28310934e-01f, -1.35600746e-01f,
  6.13857135e-02f, 3.92424911e-02f, -1.65759355e-01f, 2.91635934e-02f, 7.57815689e-02f, 5.53104952e-02f, -7.47705996e-02f, -1.23178445e-01f, -5.51441833e-02f, 5.89702800e-02f,
  -1.73602195e-03f, 3.51572707e-02f, -3.49502563e-02f, -4.22050953e-02f, 4.76351418e-02f, 7.51040354e-02f, 2.08577774e-02f, -1.15715578e-01f, 1.52360663e-01f, -2.19633773e-01f,
  -8.15652311e-02f, -1.77990664e-02f, -5.57425134e-02f, -2.00307090e-02f, 1.38681913e-02f, 1.80224806e-01f, -1.08113132e-01f, 3.26149575e-02f, 2.77459890e-01f, 1.56990543e-01f,
  -5.70565648e-02f, -1.16050497e-01f, -1.82195343e-02f, 8.84665772e-02f, 1.83202475e-02f, -5.72166815e-02f, 7.23111033e-02f, 2.65750557e-01f, -1.20284129e-02f, 1.15774401e-01f,
  6.57768920e-02f, 7.92321004e-03f, 3.12871158e-01f, -2.00324073e-01f, -2.72689521e-01f, -2.30214924e-01f, -2.39259321e-02f, -1.05783775e-01f, 4.31841388e-02f, 1.96311295e-01f,
  1.90230235e-01f, 5.73455989e-01f, -2.67450605e-02f, -1.08725101e-01f, 1.28539979e-01f, 6.41888976e-02f, -6.59665912e-02f, -1.24177948e-01f, 1.52248576e-01f, -9.37852710e-02f,
  9.15639400e-02f, -6.96065426e-02f, 9.50246826e-02f, -4.86811362e-02f, 9.35216844e-02f, -5.92315458e-02f, 1.69939563e-01f, 9.41386912e-03f, -1.19072169e-01f, -8.96181613e-02f,
  -1.39771640e-01f, -3.29084471e-02f, -6.95324242e-02f, 1.16868236e-03f, -1.52922824e-01f, -1.04312018e-01f, -1.43266963e-02f, -1.58327639e-01f, -6.16514385e-02f, -7.53623992e-03f,
  -9.74361673e-02f, 1.03749931e-01f, 7.27059133e-03f, -4.84538730e-03f, 2.72836965e-02f, 2.99967621e-02f, -6.24582693e-02f, -1.51939243e-01f, 1.16992407e-01f, 3.11193794e-01f,
  4.42753488e-04f, -1.23591743e-01f, -8.17999542e-02f, 1.06969170e-01f, -9.34259593e-02f, 2.31402833e-02f, 5.66101894e-02f, -1.37236282e-01f, 8.25148299e-02f, -5.23382165e-02f,
  1.81680351e-01f, -1.00035906e-01f, -1.18025929e-01f, 1.76729664e-01f, 1.79253310e-01f, -2.67562032e-01f, -3.35146673e-02f, 4.38216925e-01f, -1.69706479e-01f, 1.22011349e-01f,
  1.01996049e-01f, -6.47355169e-02f, -3.57197486e-02f, -1.70546234e-01f, -3.58833641e-01f, 7.76809528e-02f, 1.67965060e-04f, -6.39235899e-02f, -1.74384013e-01f, 2.51044393e-01f,
  8.98524225e-02f, -1.02611467e-01f, -5.94710261e-02f, 8.16791505e-02f, -1.47016095e-02f, 7.68591911e-02f, -2.34974883e-02f, 1.51489526e-02f, -3.02996784e-02f, -2.29266053e-03f,
  -1.28563330e-01f, 2.48797894e-01f, 3.92730385e-02f, 1.36546120e-01f, -9.87997577e-02f, 1.27336765e-02f, 5.66802695e-02f, 1.80992022e-01f, 1.27373353e-01f, 1.87143721e-02f,
  9.07862633e-02f, -4.00316976e-02f, -1.11894598e-02f, 2.39114761e-02f, 3.48260552e-02f, 9.02160108e-02f, -3.17860954e-02f, -1.50956780e-01f, -9.19549242e-02f, 1.55941412e-01f,
  1.47407204e-01f, 8.93541649e-02f, -7.47761726e-02f, -1.85375288e-01f, 1.20854177e-01f, 4.54390049e-01f, 4.16878432e-01f, 2.18186788e-02f, -8.84900913e-02f, 2.97169760e-02f,
  -6.00052103e-02f, -1.15088567e-01f, 1.09769821e-01f, 2.12651864e-02f, 1.28055587e-01f, 3.76661569e-02f, 1.24416113e-01f, -4.44848370e-03f, -2.91560978e-01f, 1.78239375e-01f,
  -9.12010670e-02f, -5.34406677e-02f, 9.73086059e-02f, 9.48821008e-02f, -1.27678260e-01f, 6.46641999e-02f, 1.65002614e-01f, -1.51508763e-01f, 7.68521652e-02f, -3.00305456e-01f,
  -1.40793607e-01f, -3.12906086e-01f, 8.30820724e-02f, 2.26594824e-02f, -2.99407523e-02f, 9.78487656e-02f, -3.56011279e-02f, -7.64263840e-03f, -1.03703700e-01f, -2.71936525e-02f,
  -1.88504174e-01f, 9.67732221e-02f, 2.35302866e-01f, -7.42916241e-02f, -1.09973788e-01f, -1.93204246e-02f, -1.21610768e-01f, 2.68625140e-01f, 1.06750010e-02f, -4.35390510e-03f,
  6.12186268e-02f, 2.28495315e-01f, 1.02619797e-01f, 2.89714396e-01f, 5.90081848e-02f, 7.48039633e-02f, -1.16233289e-01f, -5.40894736e-03f, -8.35459381e-02f, 9.89764463e-03f,
  1.55785799e-01f, 3.76935303e-02f, -1.03558665e-02f, 5.38525321e-02f, -8.16272125e-02f, -2.21527040e-01f, -5.10512218e-02f, -3.58132869e-01f, -5.07223420e-02f, 1.04393445e-01f,
  4.25248779e-02f, -1.89096093e-01f, -3.29555087e-02f, -1.54891595e-01f, -2.12450083e-02f, 1.80762485e-01f, -7.84954727e-02f, 2.37881821e-02f, -3.85544479e-01f, 1.79586619e-01f,
  1.04028046e-01f, 2.78555248e-02f, -1.60392269e-01f, -3.39897461e-02f, 3.48412246e-01f, -2.86902487e-01f, -1.14515781e-01f, -8.35668892e-02f, 2.07227290e-01f, -1.52623981e-01f,
  -1.67094581e-02f, -4.60020334e-01f, 3.86198051e-02f, 3.64141047e-01f, 2.17141174e-02f, -1.64963081e-02f, -8.28850083e-03f, 2.31423348e-01f, -9.92911286e-04f, 7.21690580e-02f,
  3.63057815e-02f, 6.68894798e-02f, 1.86221655e-02f, 2.87865940e-02f, 5.32370433e-02f, 1.47275954e-01f, 6.23598360e-02f, -3.42375003e-02f, -1.56152472e-02f, 1.73673015e-02f,
  3.47857885e-02f, -9.04034823e-02f, -5.22511564e-02f, 7.86777809e-02f, -6.27179369e-02f, -5.53619824e-02f, -3.80796157e-02f, 5.19883819e-02f, 1.48225710e-01f, 1.59683600e-02f,
  1.18451253e-01f, 1.86147243e-01f, 1.32284567e-01f, -7.70493746e-02f, 1.10317566e-01f, 8.51408753e-04f, -4.12661396e-03f, -5.92786297e-02f, 8.49501416e-02f, -2.34402940e-01f,
  1.05179444e-01f, -7.63811544e-02f, -3.61104012e-02f, -1.01974495e-01f, -3.98595929e-01f, 1.78417396e-02f, -4.18651104e-02f, -7.25580333e-03f, -1.53969124e-01f, 6.92320913e-02f,
  1.82107277e-02f, 6.29081875e-02f, -4.77995053e-02f, -9.30332839e-02f, 1.39377922e-01f, 1.07789382e-01f, 1.17225781e-01f, -2.55369902e-01f, -2.74005920e-01f, 7.17254400e-01f,
  1.63578987e-01f, -1.31230175e-01f, -8.63147154e-02f, 1.82160527e-01f, -1.59316823e-01f, -7.96879828e-02f, -2.58922428e-01f, -8.63086060e-03f, 1.76327720e-01f, -2.07171082e-01f,
  -6.22453988e-02f, -2.03946143e-01f, 3.26804407e-02f, -1.95032045e-01f, 1.67842299e-01f, -1.60496145e-01f, 1.89149842e-01f, 1.12879742e-02f, -3.47255990e-02f, -2.25597732e-02f,
  -7.83524588e-02f, 1.82785634e-02f, -5.07501177e-02f, 1.18490383e-02f, 6.61745593e-02f, -3.54328193e-03f, -2.72354968e-02f, -4.58555743e-02f, -1.28365070e-01f, -1.39987208e-02f,
  5.06278649e-02f, -7.65443668e-02f, 1.31683052e-01f, 1.09971948e-02f, -1.15262292e-01f, -2.05234319e-01f, -3.94591540e-02f, 9.80374739e-02f, 1.67767271e-01f, 1.68279096e-01f,
  6.98366165e-02f, 6.62226230e-02f, -7.70330504e-02f, -2.31738225e-01f, 3.94674838e-02f, 2.75618453e-02f, 4.01407592e-02f, 1.53383210e-01f, 1.46432772e-01f, -3.26852202e-02f,
  -9.06813070e-02f, -6.56836554e-02f, 9.69865397e-02f, 9.23473537e-02f, 1.41045032e-02f, -1.01832956e-01f, 4.83740643e-02f, 3.66547294e-02f, -6.27971888e-02f, -6.01989441e-02f,
  -1.76363543e-01f, -1.26296982e-01f, 2.31784776e-01f, -2.80565292e-01f, 2.83235222e-01f, -7.82817602e-02f, -3.42181325e-03f, -1.05661586e-01f, -1.08558975e-01f, -2.69876570e-01f,
  1.21201180e-01f, 8.00250322e-02f, 2.38418430e-02f, -2.47294262e-01f, -8.01369622e-02f, -2.13748962e-02f, -1.37192719e-02f, 7.76235312e-02f, -9.97726843e-02f, -9.80235264e-02f,
  6.91589958e-04f, -1.37618080e-01f, 1.19213685e-01f, -2.70846859e-02f, -2.25663930e-02f, 5.01276515e-02f, 5.99328168e-02f, -1.53130963e-02f, 4.63562040e-03f, -8.09606537e-02f,
  6.21206732e-03f, -8.48745927e-02f, 6.79072291e-02f, 1.47160724e-01f, 1.44431010e-01f, -1.10854194e-01f, -3.16806929e-03f, 1.61353186e-01f, 1.27363935e-01f, 3.71006280e-02f,
  1.88031420e-02f, 1.90489188e-01f, 2.59298533e-02f, 1.29706949e-01f, 3.34282517e-02f, -3.41197103e-02f, 3.21535803e-02f, 1.47091240e-01f, 1.91809013e-01f, -3.23616564e-01f,
  8.68268386e-02f, -1.92580327e-01f, -2.62767047e-01f, -2.43904293e-01f, 7.60682002e-02f, -2.74191767e-01f, -8.65406319e-02f, -8.32976773e-02f, -8.68074819e-02f, 2.95530856e-01f,
  -2.55291522e-01f, 7.20303729e-02f, 5.66077558e-03f, -1.48552535e-02f, 1.09675951e-01f, -1.08737141e-01f, 5.80126829e-02f, -2.50329316e-01f, 2.15978045e-02f, 2.36176662e-02f,
  1.40312985e-01f, 1.42015785e-01f, -2.21872881e-01f, 3.07956874e-01f, -1.78213835e-01f, 3.98492992e-01f, -1.39630035e-01f, 3.15373577e-02f, 6.37334436e-02f, -6.53270930e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.92759597e-01f, 4.55927886e-02f, 1.60118267e-02f, 6.38947189e-02f, 2.69915998e-01f, 1.26062125e-01f, -1.51557410e-02f, 4.63296026e-02f, -4.50529695e-01f, -4.90871258e-02f,
  -8.85360017e-02f, -9.02106091e-02f, 5.81023004e-03f, -6.41690344e-02f, -2.10782960e-01f, 1.15586288e-01f, 1.23711422e-01f, -1.03831813e-01f, 1.55319095e-01f, 1.01690218e-01f,
  4.55006845e-02f, -4.43360955e-02f, 3.17222476e-02f, 1.05307698e-01f, -8.21366683e-02f, 2.76441555e-02f, 5.87248243e-02f, 1.23744912e-01f, -1.66849121e-01f, -5.11953644e-02f,
  1.87781751e-02f, 3.25533152e-01f, -1.42270438e-02f, -3.14900666e-01f, -6.23009652e-02f, -7.73770288e-02f, -8.73553306e-02f, 2.45366529e-01f, 7.61473775e-02f, -1.52069673e-01f,
  1.14296764e-01f, 4.41227518e-02f, -1.42577349e-03f, -2.29318775e-02f, -2.72236198e-01f, 2.11900622e-01f, -4.21088301e-02f, 4.82004695e-02f, 1.76160589e-01f, 2.33133316e-01f,
  -4.16924864e-01f, 9.97454301e-02f, 2.74714865e-02f, -2.27672741e-01f, -1.62949279e-01f, 6.63028061e-02f, -2.18054175e-01f, 4.35558856e-01f, 2.10108846e-01f, 3.41107726e-01f,
  1.04786970e-01f, -6.19333647e-02f, 5.69645166e-01f, 4.78821024e-02f, 1.36454225e-01f, 1.78491607e-01f, 2.19197758e-02f, 2.52880342e-02f, -2.75168777e-01f, 1.45661458e-01f,
  -1.69885606e-01f, 1.71165794e-01f, 3.44940305e-01f, -2.10547335e-02f, 2.33647674e-01f, 2.71580145e-02f, 5.70100397e-02f, 8.62493217e-02f, -4.98600230e-02f, -7.52958283e-02f,
  -2.82169157e-03f, 1.87612846e-01f, 2.08622009e-01f, 1.26200348e-01f, 9.04854271e-04f, 1.57029271e-01f, 2.17706501e-01f, 3.33070666e-01f, -2.47652754e-01f, -3.33308905e-01f,
  -3.25200595e-02f, -1.82898536e-01f, -1.74794090e-03f, 4.30262059e-01f, 1.85574070e-01f, 4.52775136e-02f, -1.75028756e-01f, -2.23607555e-01f, 1.67365342e-01f, 2.84068704e-01f,
  3.94813359e-01f, 1.38745517e-01f, 4.20433357e-02f, 1.47241488e-01f, 7.67998546e-02f, -1.44059449e-01f, 4.96791810e-01f, -4.82938401e-02f, -3.01731259e-01f, 1.88728590e-02f,
  -1.26984790e-01f, -1.20201096e-01f, -8.14943463e-02f, 3.04965287e-01f, -3.04891020e-02f, -3.92127901e-01f, 2.09979311e-01f, 1.98009592e-02f, 1.24086939e-01f, -5.18199623e-01f,
  4.53568339e-01f, -8.38435233e-01f, -7.59866610e-02f, 7.05612779e-01f, -1.33885741e-02f, -1.03811808e-01f, 2.75088161e-01f, 4.05993521e-01f, -2.97400486e-02f, 2.09066018e-01f,
  -1.16976956e-02f, 2.41148740e-01f, 7.75894448e-02f, 1.02740489e-01f, 9.71507281e-02f, 1.66302308e-01f, 4.98777270e-01f, 1.58488050e-01f, -3.34560522e-03f, 7.91455284e-02f,
  5.23875169e-02f, 2.35873461e-01f, 2.71385074e-01f, -1.33167803e-01f, 2.73272365e-01f, 1.28025468e-02f, 6.81148618e-02f, 6.16889372e-02f, 1.92577377e-01f, 1.75690696e-01f,
  2.75586456e-01f, 1.97716290e-03f, 2.32702062e-01f, -1.65751576e-01f, -9.11430717e-02f, -2.06383929e-01f, -7.67109916e-02f, 6.47574440e-02f, -7.75155947e-02f, -1.50927333e-02f,
  -1.67377293e-01f, 1.54328793e-01f, 1.00728855e-01f, 3.72798860e-01f, 5.84522665e-01f, 1.99819580e-01f, 1.55478135e-01f, 3.54060888e-01f, -7.76659371e-03f, 1.72893822e-01f,
  5.86007498e-02f, -3.72359395e-01f, 1.95978835e-01f, 3.21239710e-01f, 1.60683729e-02f, 1.35310501e-01f, -2.78855324e-01f, 5.58524113e-03f, 5.02384782e-01f, 1.97009340e-01f,
  -3.25687528e-02f, 2.96096087e-01f, -1.32032484e-01f, -2.09097192e-01f, 4.04847711e-01f, 4.71611232e-01f, 2.62797683e-01f, -1.33072272e-01f, -1.81852967e-01f, -6.73211992e-01f,
  -2.33248517e-01f, -3.07051063e-01f, -7.92659670e-02f, 1.36764020e-01f, 8.41105282e-02f, 2.29097381e-01f, 3.60594779e-01f, -5.44397309e-02f, 2.17556357e-01f, 2.68643737e-01f,
  -8.13886374e-02f, 1.83960468e-01f, 3.54114890e-01f, 3.82554308e-02f, 1.17922239e-01f, -5.90148196e-02f, 2.37625897e-01f, 7.75366873e-02f, 1.83622148e-02f, 1.49099678e-01f,
  1.36100650e-01f, -4.76874551e-03f, -1.04560897e-01f, 1.17256597e-01f, 1.07356951e-01f, 2.13313282e-01f, 3.48868370e-01f, 1.23102717e-01f, -6.82697520e-02f, 1.08533539e-01f,
  -8.11295286e-02f, -1.05894230e-01f, -8.78486410e-03f, 1.12492450e-01f, 2.12445576e-02f, -8.14397410e-02f, -1.25374362e-01f, -2.36085817e-01f, 2.39279196e-02f, -5.24737537e-02f,
  -2.87237540e-02f, 2.32594609e-01f, -3.66793461e-02f, -3.17932755e-01f, -2.18288675e-02f, 2.87468761e-01f, 2.85020679e-01f, 2.72971597e-02f, -1.33873835e-01f, -1.11423552e-01f,
  8.44653770e-02f, 3.39961946e-02f, -1.56995922e-01f, 6.15449369e-01f, -2.55636107e-02f, 2.95032740e-01f, 1.29035980e-01f, 4.89192754e-01f, 3.42902631e-01f, 6.42693639e-01f,
  -6.93804026e-02f, 5.56667671e-02f, -2.56438851e-01f, 1.19541019e-01f, -2.33433694e-01f, -4.82653648e-01f, 1.80904359e-01f, 2.25941613e-01f, 2.73543149e-01f, 1.24652125e-01f,
  1.54599324e-01f, 5.56395426e-02f, 1.28533155e-01f, 1.43505380e-01f, 2.77407885e-01f, 3.92003283e-02f, 3.48959751e-02f, 2.68690765e-01f, 9.47186053e-02f, 1.62955746e-01f,
  2.74822354e-01f, 8.07783231e-02f, -8.79165437e-03f, 2.80624360e-01f, 1.63169652e-01f, -1.28554301e-02f, 3.25199872e-01f, 2.90663183e-01f, 1.71675220e-01f, 1.20464168e-01f,
  2.10986897e-01f, 3.51703018e-02f, 1.26991734e-01f, -8.53139386e-02f, 8.78152996e-02f, -9.53137781e-03f, -1.04452446e-01f, -1.46048754e-01f, 3.61126997e-02f, -1.38095528e-01f,
  2.59473622e-01f, 4.25484329e-01f, 4.06847477e-01f, -2.95374751e-01f, -5.38575230e-03f, -1.87083721e-01f, 1.90726131e-01f, 3.31206322e-01f, -1.42543182e-01f, -1.48864567e-01f,
  -2.85586149e-01f, 2.40597069e-01f, 1.86222434e-01f, 6.58381209e-02f, -2.76616424e-01f, 1.75973013e-01f, 7.32445300e-01f, -3.02724093e-01f, 4.68123168e-01f, -8.24045390e-02f,
  -1.01581432e-01f, 3.18462282e-01f, 5.34894802e-02f, 5.16970158e-01f, 1.03938437e+00f, 4.17830527e-01f, 2.82131642e-01f, -6.58264816e-01f, 8.52357596e-02f, 4.72594529e-01f,
  2.58622970e-02f, 1.14349447e-01f, 2.85179764e-01f, 2.44968370e-01f, -1.81016028e-01f, -4.11448032e-02f, -1.12044506e-01f, 2.63321787e-01f, 3.01664054e-01f, 1.58487067e-01f,
  8.31585601e-02f, 1.49538457e-01f, 5.29373810e-03f, 2.33924955e-01f, 2.13966578e-01f, 7.75768235e-02f, 2.42266774e-01f, -9.34992637e-03f, -1.62272491e-02f, 3.27796817e-01f,
  -2.11428761e-01f, 1.27698138e-01f, 1.16066910e-01f, 1.25742868e-01f, 5.38326278e-02f, 7.36372396e-02f, 8.43098313e-02f, -8.96580890e-02f, 6.29259124e-02f, 1.13808224e-02f,
  8.03806037e-02f, 2.92633884e-02f, -1.68957591e-01f, 5.20138919e-01f, 1.42341796e-02f, -1.07649542e-01f, 1.88626215e-01f, 9.27737802e-02f, 5.68500683e-02f, -2.43162498e-01f,
  2.75801122e-01f, 4.78656471e-01f, 8.77840295e-02f, -4.09878790e-01f, -1.30692005e-01f, 3.54055524e-01f, -7.55804554e-02f, 1.99530404e-02f, 3.47678177e-02f, -3.23513709e-02f,
  2.65933752e-01f, 9.75324884e-02f, -4.01220322e-01f, -6.99355602e-02f, -1.76809624e-01f, 5.26060797e-02f, 4.88879800e-01f, 3.03904533e-01f, 3.81174028e-01f, 1.30972013e-01f,
  1.46089643e-01f, 1.22311957e-01f, 5.39701462e-01f, -3.84569801e-02f, 7.50893950e-02f, 1.32840827e-01f, 1.35093927e-01f, 2.03213573e-01f, 1.79893717e-01f, -1.96620062e-01f,
  2.62031138e-01f, 2.11035311e-01f, 1.09613858e-01f, -1.57995969e-01f, 4.50119376e-01f, 1.85408756e-01f, 2.53719777e-01f, -1.60069585e-01f, 5.83966553e-01f, -3.15777771e-02f,
  2.76636690e-01f, 9.19485465e-02f, -1.33041844e-01f, -1.52927071e-01f, 2.60094255e-01f, 2.29578465e-01f, 1.74151495e-01f, 3.78158242e-02f, 3.45519513e-01f, -1.07079029e-01f,
  -3.21330816e-01f, 1.98418215e-01f, 1.98290005e-01f, -7.01515377e-02f, -1.30209520e-01f, 1.75994784e-01f, -1.64229900e-01f, 2.87787795e-01f, 1.16900712e-01f, -2.03420997e-01f,
  -8.03567246e-02f, -1.90579407e-02f, -2.81771347e-02f, 7.94961825e-02f, 1.66995615e-01f, -7.06153154e-01f, 6.85616955e-02f, -2.56762207e-01f, 3.83454293e-01f, -7.47844875e-01f,
  -1.76702484e-01f, -3.97500157e-01f, -1.17391251e-01f, -2.17128247e-02f, 4.47407305e-01f, -5.02652109e-01f, 3.13987494e-01f, 1.49368616e-02f, -5.19761778e-02f, -6.20953664e-02f,
  2.79459387e-01f, -2.50749588e-01f, 9.65015292e-02f, -2.04116657e-01f, -1.21002182e-01f, 1.28111288e-01f, -3.02780181e-01f, -5.78479648e-01f, 2.21385434e-01f, 2.31496487e-02f,
  2.81129718e-01f, 1.08455129e-01f, -7.95643404e-02f, 1.56918630e-01f, 9.62103084e-02f, 1.59331575e-01f, 7.30294883e-02f, 2.00638309e-01f, 3.37449610e-02f, 9.22819674e-02f,
  2.39576429e-01f, -7.06473067e-02f, -5.69412299e-02f, -6.50166050e-02f, 5.19157015e-02f, -4.31777425e-02f, 4.04375792e-02f, -2.87767291e-01f, 3.06426376e-01f, -3.59240137e-02f,
  1.58234626e-01f, 2.63591319e-01f, 1.65127978e-01f, 7.62800798e-02f, -3.85667756e-02f, -9.46113244e-02f, -1.35324895e-01f, 3.06592453e-02f, 2.38550514e-01f, 4.80034918e-01f,
  -2.35679075e-01f, 4.03429687e-01f, -3.27989429e-01f, -2.76855618e-01f, -3.79022979e-03f, 2.67045230e-01f, -2.38429978e-01f, -2.22027540e-01f, 3.35355923e-02f, -3.74317110e-01f,
  1.46350011e-01f, -1.64205674e-02f, 4.31703627e-01f, -9.04133171e-02f, -4.04092133e-01f, 7.60985389e-02f, 3.01697195e-01f, 2.65580136e-02f, -4.67887253e-01f, -2.09042609e-01f,
  -1.26624480e-01f, -2.10626155e-01f, -6.34927377e-02f, 1.82518676e-01f, -1.75887585e-01f, 9.54828620e-01f, 7.34796345e-01f, 4.13186699e-01f, 4.60059464e-01f, 2.74691224e-01f,
  1.43006578e-01f, 3.06595743e-01f, 4.99699563e-02f, 2.95203298e-01f, -1.73982009e-01f, 1.26955122e-01f, 7.05615897e-03f, 1.72046684e-02f, 1.53712764e-01f, 3.90379816e-01f,
  4.91750874e-02f, 1.97097078e-01f, -1.59055158e-01f, 8.43380019e-02f, 5.97486347e-02f, 8.12911391e-02f, 4.47088033e-01f, 2.21529603e-01f, 5.84727585e-01f, 1.62422180e-01f,
  4.91393842e-02f, 2.45188802e-01f, 1.01934299e-01f, 1.32197171e-01f, 2.66509503e-01f, 2.85078943e-01f, 2.90247560e-01f, 5.00246771e-02f, -4.83287960e-01f, 8.51739943e-02f,
  1.05236970e-01f, 9.57605913e-02f, 3.96431610e-02f, -1.05272442e-01f, -1.77076850e-02f, -3.96288186e-01f, 6.81454912e-02f, -4.60467577e-01f, -6.28931642e-01f, -1.34336561e-01f,
  2.57241845e-01f, 1.18138241e-02f, 5.70743494e-02f, 9.66217443e-02f, -2.48263851e-02f, -6.95513096e-03f, -4.96865034e-01f, -3.61778200e-01f, 2.37125695e-01f, -3.08902681e-01f,
  -2.50226259e-01f, -2.15675488e-01f, 4.84698474e-01f, -3.22452456e-01f, -3.44352201e-02f, -2.18017884e-02f, -2.31853306e-01f, -1.89001426e-01f, 1.30215734e-01f, -1.70911148e-01f,
  2.39372417e-01f, -5.11962473e-01f, -2.22041637e-01f, 1.23666577e-01f, 3.95480752e-01f, -2.19096527e-01f, 1.61348864e-01f, 1.22923292e-01f, 1.72653019e-01f, 1.85782984e-01f,
  1.58696309e-01f, -1.21739432e-01f, 2.53259182e-01f, 5.58286607e-02f, -2.43258089e-01f, 2.18295790e-02f, 1.69169873e-01f, 9.63930860e-02f, 1.49644256e-01f, 1.20239466e-01f,
  2.43725050e-02f, 1.59867436e-01f, 3.15553814e-01f, 4.55798022e-02f, 1.20726600e-01f, 2.24353448e-01f, 1.65930182e-01f, 2.26141304e-01f, 8.33267793e-02f, 2.30128825e-01f,
  2.70923942e-01f, 2.18775317e-01f, 1.75613873e-02f, 3.81067023e-02f, -5.85683733e-02f, -1.28301755e-01f, 2.65264120e-02f, -1.90609396e-02f, -4.27726731e-02f, 1.86819866e-01f,
  -3.35625917e-01f, -4.36787486e-01f, -5.59154034e-01f, 2.11111009e-01f, 1.23652667e-01f, -1.61539763e-01f, -1.04701817e-02f, -5.82191870e-02f, -6.48946967e-03f, 1.33113667e-01f,
  2.61953712e-01f, -2.58246452e-01f, 9.01735425e-02f, 1.84639692e-02f, 4.13881093e-01f, -1.62155598e-01f, -3.65176871e-02f, 5.97684383e-01f, -2.08052188e-01f, -7.80300125e-02f,
  -4.26322548e-03f, 3.04981887e-01f, 1.05669618e-01f, 3.27978492e-01f, -1.57167494e-01f, -9.07219350e-02f, 3.78115848e-02f, 4.84350532e-01f, 2.59357065e-01f, -4.39669102e-01f,
  3.73371616e-02f, 2.18262494e-01f, 6.39613941e-02f, 6.78846985e-02f, -6.02381602e-02f, -7.70063698e-02f, 2.21458748e-01f, 6.78212941e-02f, 1.92873642e-01f, 5.78650273e-02f,
  9.56857204e-02f, -5.03266007e-02f, 2.52707928e-01f, 1.00437524e-02f, -5.93741536e-02f, -6.49901107e-02f, 2.65717179e-01f, 1.79404616e-01f, 1.47492558e-01f, 2.41666853e-01f,
  3.09044987e-01f, -1.27718389e-01f, 2.18023788e-02f, 3.99837010e-02f, 5.57111800e-02f, -3.26864719e-02f, 3.66029292e-02f, 1.20774629e-02f, 8.08198825e-02f, 2.09487528e-01f,
  1.65150300e-01f, -2.71154404e-01f, 5.82222790e-02f, -2.23254055e-01f, 1.58567980e-01f, 4.20636296e-01f, 2.03869969e-01f, 5.82136353e-03f, 1.93490490e-01f, 4.13780779e-01f,
  1.87871650e-01f, 2.62359023e-01f, 9.44653526e-02f, -8.13683197e-02f, 1.07875779e-01f, -3.63308072e-01f, 2.59477466e-01f, -4.82814088e-02f, -3.58608097e-01f, 1.01486914e-01f,
  2.24845171e-01f, 7.54396081e-01f, 4.87327307e-01f, 3.70269805e-01f, 1.05574705e-01f, 7.26931989e-02f, 8.10142815e-01f, -3.87049317e-01f, 1.08417310e-01f, -6.30092919e-01f,
  1.12458490e-01f, 1.47198960e-01f, 2.44154647e-01f, -2.70709842e-01f, 1.79927900e-01f, -1.77494943e-01f, 1.45928711e-01f, 6.34853244e-02f, -6.17281161e-02f, 3.45987886e-01f,
  2.10049003e-01f, 1.14271075e-01f, 2.73256689e-01f, 3.48499447e-01f, 4.93040942e-02f, 1.13414504e-01f, 1.65053889e-01f, 1.60621181e-01f, -1.98018536e-01f, 3.68875228e-02f,
  2.97535360e-01f, -4.60205302e-02f, -1.05429158e-01f, -3.84771079e-02f, 1.64447710e-01f, -1.61331445e-01f, 1.18207335e-01f, 2.97982335e-01f, 1.70690835e-01f, 2.35539541e-01f,
  -5.86550355e-01f, -3.04320455e-01f, -8.17875788e-02f, 1.86976999e-01f, 2.44691223e-01f, 2.15215757e-01f, -1.12678699e-01f, 4.98552054e-01f, 1.04299806e-01f, 3.14677984e-01f,
  4.73385990e-01f, 5.48113585e-01f, -1.88780814e-01f, 2.90149152e-01f, 1.89969435e-01f, -2.58716375e-01f, 1.27523825e-01f, -4.62623328e-01f, 4.85951543e-01f, 1.61534280e-01f,
  -3.09132814e-01f, -1.11179516e-01f, -2.92113692e-01f, 2.26084828e-01f, -3.68511006e-02f, 2.63268054e-01f, -3.09983492e-01f, -1.72897533e-01f, -5.53009093e-01f, -3.97350430e-01f,
  1.37727380e-01f, 6.20363772e-01f, 3.62544507e-01f, 1.68563336e-01f, -2.03019127e-01f, -1.07190244e-01f, 1.55325308e-01f, -4.60381508e-02f, 7.84294009e-02f, 5.79715660e-03f,
  2.22925112e-01f, -6.69110194e-02f, 7.07630366e-02f, -6.12959974e-02f, 2.18313575e-01f, 6.40785247e-02f, 9.16555896e-02f, -4.50839773e-02f, 2.15781450e-01f, 1.93702251e-01f,
  -1.04709975e-02f, -3.07793263e-02f, 1.98074788e-01f, 7.17416639e-03f, 4.66912724e-02f, 1.00304827e-01f, 1.42300069e-01f, 1.77091405e-01f, 3.36366564e-01f, 7.88002387e-02f,
  -1.12328336e-01f, 9.59396288e-02f, 5.72008714e-02f, -1.90276988e-02f, 5.19028381e-02f, 5.74984886e-02f, 1.23428337e-01f, -7.95243308e-02f, -1.16541274e-01f, -2.25251392e-01f,
  2.44034827e-01f, -2.85848916e-01f, 1.59729287e-01f, -1.87139183e-01f, -3.12283576e-01f, -2.72185177e-01f, 2.01569512e-01f, -1.26225233e-01f, 2.15005070e-01f, 1.81501254e-03f,
  -2.86370426e-01f, 2.89433986e-01f, 4.95267883e-02f, -4.06464219e-01f, 1.80826858e-01f, -1.66231602e-01f, -5.62499873e-02f, 3.95188890e-02f, 4.42616403e-01f, -1.55947253e-01f,
  6.50327206e-01f, -1.92595556e-01f, -1.82864293e-01f, 3.13095540e-01f, -6.96333423e-02f, -3.23313661e-02f, 2.40572244e-01f, -4.03468907e-02f, -3.67972516e-02f, -2.83377081e-01f,
  -4.14321460e-02f, 1.52839854e-01f, 3.30656096e-02f, -2.23926738e-01f, 3.19562145e-02f, 5.82789592e-02f, -1.28643528e-01f, -1.40608653e-01f, 4.49459888e-02f, -1.60295397e-01f,
  -1.16809763e-01f, -2.97238063e-02f, 6.01002164e-02f, 3.25549953e-02f, 5.53888381e-02f, -2.11705118e-01f, -2.86103904e-01f, -1.31589815e-01f, -8.46430659e-02f, -2.40530938e-01f,
  -9.32900310e-02f, 5.60062155e-02f, -1.84158627e-02f, -1.49101630e-01f, -9.56091285e-02f, 5.27196005e-02f, -5.00903055e-02f, 1.08485505e-01f, 1.60799846e-01f, 1.25726864e-01f,
  9.49678272e-02f, -4.41237912e-02f, -4.28657234e-02f, 3.09743807e-02f, 3.25781256e-01f, -9.04871821e-02f, 8.19003908e-04f, -7.69964680e-02f, -4.02675509e-01f, 1.14275590e-01f,
  2.96778917e-01f, 2.16759056e-01f, 2.05292434e-01f, 2.87677020e-01f, 4.33197506e-02f, 2.68971056e-01f, 1.42391682e-01f, -1.50687635e-01f, 1.22105844e-01f, -5.78957312e-02f,
  -1.37359679e-01f, -2.60305375e-01f, -3.69497061e-01f, 8.86452019e-01f, 2.89576471e-01f, 1.10135414e-02f, 9.23672318e-02f, 3.05422038e-01f, 3.24315041e-01f, 2.89476335e-01f,
  1.02543995e-01f, -5.33036828e-01f, 1.05484322e-01f, 2.59444624e-01f, 4.62851733e-01f, -1.74056768e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.40737727e-01f, 1.38656005e-01f, 1.02723189e-01f, 2.67869681e-01f, 1.00560375e-01f, 6.03646897e-02f, 2.79311508e-01f, 2.21941113e-01f, 2.68571287e-01f, 3.85366887e-01f,
  2.65465915e-01f, 3.18426818e-01f, -1.71815767e-03f, 2.62539797e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  2.52553195e-01f, 7.62289539e-02f, -3.75923902e-01f, -5.56115687e-01f, 2.93741608e-03f, 1.08218230e-01f, -3.56498420e-01f, 2.23522365e-01f, -3.21800739e-01f, -4.14564371e-01f,
  2.67300278e-01f, -1.01175323e-01f, -4.43719208e-01f, -7.74284080e-02f, -4.02143627e-01f, 3.88164446e-02f, -2.66611397e-01f, -3.64550091e-02f, 2.43138984e-01f, -1.15559615e-01f,
  -1.24744043e-01f, -1.03724696e-01f, -6.97203040e-01f, -3.61515880e-01f, -1.20807342e-01f, -2.96241343e-01f, -1.52167171e-01f, 3.19655895e-01f, 1.08878732e-01f, -2.87332982e-01f,
  3.30624521e-01f, -1.97146535e-02f, 1.40209004e-01f, -3.98545772e-01f, -3.53929311e-01f, -2.04630196e-01f, -1.02061883e-01f, 3.55441391e-01f, 1.27637565e-01f, 3.86265606e-01f,
  -5.22010386e-01f, 2.79007167e-01f, -8.92038122e-02f, -2.92312920e-01f, -6.66543603e-01f, 3.69401462e-02f, -5.08395791e-01f, 2.92608559e-01f, 3.49455804e-01f, 1.25744343e-01f,
  3.72751236e-01f, -7.66335130e-01f, -2.82384902e-01f, 7.81043768e-02f, 2.70852536e-01f, -5.55360675e-01f, -6.14764988e-01f, -1.17671698e-01f, -3.50780427e-01f, -3.69327873e-01f,
  1.33197129e-01f, -2.76469588e-01f, 2.82417655e-01f, 4.06288534e-01f, -4.68672752e-01f, -2.30133832e-01f, -1.77552760e-01f, 9.32186991e-02f, 8.72863606e-02f, 2.58949436e-02f,
  -1.57423317e-01f, 2.06659392e-01f, -3.24525893e-01f, -3.40521723e-01f, -4.94292319e-01f, 5.76225147e-02f, -5.74772239e-01f, 2.33331248e-01f, -4.21893507e-01f, -5.60643494e-01f,
  1.18172817e-01f, 3.94623756e-01f, -1.39054224e-01f, 3.42372209e-02f, 2.87818938e-01f, 1.38620526e-01f, -1.75757080e-01f, -2.19797716e-01f, 2.26037204e-01f, -1.96819127e-01f,
  6.90433308e-02f, -1.05215006e-01f, -2.66905099e-01f, 9.40454900e-02f, -5.27617693e-01f, -1.73847720e-01f, -2.93064564e-01f, 1.95194669e-02f, -1.26947790e-01f, -5.77757597e-01f,
  -3.28524947e-01f, 8.86857733e-02f, -2.37107754e-01f, -1.51095614e-01f, 1.12763539e-01f, -4.59042907e-01f, -3.76554549e-01f, -4.00670797e-01f, 9.76359427e-01f, -4.24375653e-01f,
  -1.12884445e-02f, -3.90538946e-02f, 2.30226964e-01f, 4.11229469e-02f, -4.96661216e-01f, -2.78953053e-02f, -1.68720379e-01f, 2.30251253e-01f, -5.01407266e-01f, 2.18077615e-01f,
  -8.54819641e-02f, -3.85419965e-01f, 1.88060533e-02f, 2.76854306e-01f, 2.70412683e-01f, -8.05792570e-01f, -1.13354020e-01f, 3.75493050e-01f, -3.12668055e-01f, -1.66811123e-01f,
  1.93590015e-01f, 6.56240657e-02f, -9.29281861e-02f, 6.99034929e-02f, 1.42545477e-01f, 2.91335464e-01f, -1.04986906e-01f, 4.95041534e-02f, -4.00490552e-01f, -1.58535108e-01f,
  -4.10312682e-01f, 1.88210160e-01f, 9.95436907e-02f, 2.25281641e-01f, 1.32425055e-01f, -3.05370212e-01f, -2.62852192e-01f, -1.16326511e-01f, -5.08661628e-01f, 1.55964062e-01f,
  2.17144296e-01f, -1.15044199e-01f, 9.52406898e-02f, -5.44317923e-02f, -1.29237995e-01f, -5.50920367e-01f, -3.13545689e-02f, -1.80020794e-01f, -1.37582600e-01f, -3.14761639e-01f,
  4.22202563e-03f, 4.17107254e-01f, -2.05677435e-01f, -3.98023307e-01f, -1.93902656e-01f, 3.08597177e-01f, -2.65983474e-02f, 5.63898921e-01f, 7.44019523e-02f, 3.71211052e-01f,
  -1.09500781e-01f, 2.71886677e-01f, -4.29641038e-01f, 3.73449743e-01f, -3.45333517e-01f, -1.21504338e-02f, -2.82483697e-01f, -2.92871863e-01f, 2.40773350e-01f, -8.19052041e-01f,
  3.27972144e-01f, 1.73828378e-01f, 3.47036794e-02f, -4.85642701e-02f, -5.79796612e-01f, -1.97476611e-01f, -5.71872532e-01f, -1.76436082e-02f, 1.02367364e-01f, 7.09788144e-01f,
  -4.42004651e-01f, -1.57338485e-01f, -2.49518752e-01f, -4.96882290e-01f, -4.78537649e-01f, -1.49966106e-02f, -1.30087703e-01f, 9.91677493e-02f, -3.66738796e-01f, 4.08750743e-01f,
  -2.92849004e-01f, 2.49716663e-03f, -3.65811884e-01f, -8.56292546e-02f, -3.06081384e-01f, -2.71953881e-01f, 1.67011425e-01f, -7.92275295e-02f, -4.21009332e-01f, -2.04640448e-01f,
  -8.29201400e-01f, -9.40660164e-02f, 6.53998032e-02f, -1.15445957e-01f, -1.33342698e-01f, 2.93467671e-01f, -6.08424664e-01f, 1.73636526e-01f, 6.23842597e-01f, 1.87681720e-01f,
  1.62411883e-01f, 7.41063833e-01f, 3.12000662e-01f, -5.04052863e-02f, -2.22144067e-01f, 2.75087416e-01f, 5.49590290e-01f, -2.42528617e-01f, 5.58703780e-01f, 2.50236988e-01f,
  3.38960081e-01f, -2.83204138e-01f, 2.05109656e-01f, -1.65932596e-01f, -1.68200985e-01f, 3.79849523e-01f, -2.05273256e-01f, -5.24788737e-01f, -8.59458074e-02f, -4.14008200e-01f,
  4.82078791e-02f, 1.50975928e-01f, -5.26507534e-02f, -9.37674999e-01f, 2.76577175e-01f, 1.82027966e-01f, 2.30904013e-01f, 3.68742406e-01f, -2.77572095e-01f, 3.33929628e-01f,
  -3.50670959e-03f, -8.70394334e-02f, -1.26260340e+00f, -9.90984961e-02f, -1.05375677e-01f, -5.55429220e-01f, 1.04245372e-01f, 3.75409126e-01f, 4.23267692e-01f, -3.16056460e-01f,
  1.42097548e-01f, -3.87557477e-01f, -2.44938061e-02f, -2.70111322e-01f, 2.49223590e-01f, 2.74883777e-01f, -4.37261522e-01f, 1.20164631e-02f, 4.76807475e-01f, -2.82584310e-01f,
  2.35208780e-01f, -2.99027175e-01f, -4.21271324e-01f, 2.06388354e-01f, 2.92163134e-01f, -1.52030997e-02f, 3.12730998e-01f, -1.33170173e-01f, 1.37361288e-01f, -5.43555081e-01f,
  4.87199426e-01f, 3.21101189e-01f, 5.59214354e-01f, -8.90381709e-02f, -1.71701372e-01f, -3.34511697e-01f, 3.89845014e-01f, 3.02737534e-01f, -1.36999190e-01f, 4.97659929e-02f,
  1.60484448e-01f, 5.41911721e-01f, -1.09742977e-01f, -6.96475059e-02f, -3.54778022e-02f, -6.91400051e-01f, 5.63981414e-01f, 5.01696408e-01f, -3.92632604e-01f, 5.01709938e-01f,
  -2.84878492e-01f, 1.64729461e-01f, 3.31864387e-01f, -5.17442785e-02f, 4.94466126e-01f, 1.96011096e-01f, -5.51468492e-01f, -2.44718149e-01f, 1.60030629e-02f, -3.34812403e-01f,
  2.36663625e-01f, -2.12741107e-01f, 3.73640686e-01f, -5.85233755e-02f, 1.58911268e-03f, -5.00945091e-01f, 2.23083436e-01f, -6.27544582e-01f, 1.94085971e-01f, -1.85014158e-01f,
  -2.37592191e-01f, 4.48550910e-01f, 2.22207561e-01f, 3.57740879e-01f, 2.62641571e-02f, 5.34691572e-01f, 2.56137133e-01f, -3.59270334e-01f, 2.47644797e-01f, 8.45572278e-02f,
  4.94437099e-01f, 1.56233236e-01f, 6.19000196e-01f, -2.25056052e-01f, 2.54142910e-01f, 1.21245183e-01f, 3.13292235e-01f, -5.19884229e-02f, 2.07016170e-01f, 4.94555593e-01f,
  1.74242005e-01f, 1.68349221e-01f, 4.16037962e-02f, 4.30513062e-02f, -2.07642853e-01f, -2.70963430e-01f, -4.05668080e-01f, -1.92657292e-01f, 2.30999187e-01f, 3.14087033e-01f,
  1.91983450e-02f, 2.69872397e-02f, -7.64954761e-02f, 2.51562148e-01f, -5.83647728e-01f, 5.96684456e-01f, 4.06042725e-01f, -5.52815050e-02f, 4.05936241e-01f, -5.18831968e-01f,
  5.52279055e-01f, -8.37337673e-02f, 5.16415358e-01f, -6.77394271e-01f, -5.77950180e-01f, 8.37772265e-02f, 1.81998596e-01f, 6.03649735e-01f, -2.19664082e-01f, 3.08476835e-01f,
  1.17715947e-01f, -1.90216061e-02f, -3.71375680e-01f, 3.10944498e-01f, -3.37052256e-01f, -5.20194292e-01f, 3.76197636e-01f, -2.90308535e-01f, 4.62443769e-01f, 1.68531269e-01f,
  1.24056358e-02f, -3.52437437e-01f, 1.49159074e-01f, -1.13424487e-01f, 7.27530479e-01f, 2.31939375e-01f, -4.73412037e-01f, 2.33486965e-01f, -1.36857048e-01f, 8.33313838e-02f,
  -1.80976346e-01f, 1.80641845e-01f, -3.79103601e-01f, 2.10051969e-01f, -1.37132322e-02f, 1.71033159e-01f, 1.67471245e-01f, -4.67261404e-01f, -3.29781264e-01f, -2.36181095e-01f,
  -2.22279787e-01f, -1.24154724e-02f, 1.43384069e-01f, 3.63542140e-01f, -3.64769578e-01f, 2.05522822e-03f, -1.37852043e-01f, -3.75568159e-02f, -2.69363821e-01f, 3.04862440e-01f,
  -3.10196280e-01f, 6.12925112e-01f, 2.56950319e-01f, -1.43852204e-01f, 2.56040633e-01f, 2.47481853e-01f, -2.12287530e-01f, 7.91321248e-02f, -5.39449938e-02f, -5.89283168e-01f,
  -3.25472967e-04f, -5.60511231e-01f, -1.18802637e-01f, 7.59861842e-02f, -3.07243168e-01f, -5.73300645e-02f, -5.31985700e-01f, -1.57217786e-01f, 3.81132305e-01f, 2.52433747e-01f,
  -6.04724169e-01f, -4.03116375e-01f, -2.33217686e-01f, -1.99126959e-01f, -7.51424491e-01f, -1.24676272e-01f, 5.69144785e-01f, 1.64051682e-01f, -9.14056480e-01f, -1.38270453e-01f,
  4.76716310e-01f, -3.53730440e-01f, -2.09294498e-01f, -3.72920334e-01f, 1.08244382e-01f, 4.76052016e-01f, -5.91102421e-01f, -4.26458359e-01f, -4.06958945e-02f, 9.34084207e-02f,
  3.15329432e-01f, 3.10205035e-02f, -1.78672671e-01f, -1.12402268e-01f, 1.64226040e-01f, -1.86823681e-01f, 2.53597438e-01f, -2.06951648e-01f, -4.48285639e-01f, -7.86210969e-02f,
  -1.26834080e-01f, -1.03694394e-01f, -2.96177804e-01f, -4.67291057e-01f, -4.80360612e-02f, -5.61042340e-04f, -5.15970528e-01f, -2.54251689e-01f, 1.38334949e-02f, -1.91370860e-01f,
  -4.67767090e-01f, -1.71284601e-01f, -1.25837605e-02f, 3.62531960e-01f, 2.38002762e-01f, -1.28318220e-01f, -3.94374073e-01f, 5.31796575e-01f, -1.56543911e-01f, 2.49149024e-01f,
  3.38647962e-01f, -3.25114638e-01f, -1.78762116e-02f, 2.83664733e-01f, 3.33842903e-01f, -2.44002402e-01f, -7.52976164e-02f, 2.78364301e-01f, -1.81524932e-01f, -1.97224971e-02f,
  -2.56532729e-01f, -9.95555967e-02f, -3.89359832e-01f, 1.53455749e-01f, 1.43867880e-01f, -9.18262079e-03f, -2.15847492e-01f, 2.04556510e-01f, 5.60145319e-01f, 5.09320557e-01f,
  -5.38037121e-01f, -5.79206526e-01f, -2.29980089e-02f, 7.79963806e-02f, -7.80488610e-01f, 2.62242854e-01f, -4.48538780e-01f, -4.49705780e-01f, -1.79473404e-02f, 2.60276854e-01f,
  -6.73888385e-01f, -1.66418299e-01f, 3.92496079e-01f, 7.13932514e-02f, -2.01921925e-01f, -5.99366188e-01f, 1.73126310e-01f, -3.63206774e-01f, 6.86395168e-02f, 1.94437638e-01f,
  4.88730967e-01f, 4.87230234e-02f, 2.23298743e-01f, -1.66158915e-01f, 1.39963403e-01f, 3.12398434e-01f, 1.96314469e-01f, 2.16526806e-01f, 3.66618335e-02f, 1.26510009e-01f,
  3.67429137e-01f, 7.35980645e-02f, -1.99629188e-01f, 6.53683096e-02f, 2.05695406e-01f, 2.77003586e-01f, -1.12052649e-01f, 7.20000327e-01f, -7.05994308e-01f, -2.52360642e-01f,
  -1.86020672e-01f, -6.07619464e-01f, -2.70319194e-01f, -2.02207435e-02f, 6.14759028e-01f, 1.47270232e-01f, -5.50931059e-02f, -4.86395895e-01f, -3.90712470e-01f, -6.02217138e-01f,
  -4.40308809e-01f, 4.45513338e-01f, -2.74490386e-01f, 4.93011624e-01f, 5.64402759e-01f, 1.59345165e-01f, 3.77530038e-01f, -1.15494423e-01f, -1.38647571e-01f, 2.63400704e-01f,
  -6.33762538e-01f, 1.96247518e-01f, 2.19209362e-02f, -1.80563390e-01f, -2.34158441e-01f, 1.25725403e-01f, -4.59266722e-01f, -2.86451131e-02f, 3.32998633e-01f, 5.88033259e-01f,
  -1.02020991e+00f, 3.17613006e-01f, -3.56861830e-01f, -3.66432071e-01f, -4.57870245e-01f, -1.43004477e-01f, -2.07833704e-02f, -1.34666488e-01f, -1.23284899e-01f, 1.90482885e-01f,
  -1.21554323e-01f, 3.33433062e-01f, 4.40488160e-01f, -2.79534180e-02f, 3.59968722e-01f, 6.06540479e-02f, 5.11554599e-01f, 2.41677120e-01f, -7.71433860e-03f, 1.19302213e-01f,
  9.87621918e-02f, 1.44075543e-01f, 5.54363370e-01f, 2.70771742e-01f, 3.00178438e-01f, -5.41237772e-01f, -3.07819217e-01f, -3.30890156e-02f, 3.40484455e-02f, 4.68591452e-01f,
  1.43617928e-01f, -4.23709780e-01f, -5.19147098e-01f, 7.34178245e-01f, 2.18742743e-01f, -4.57651854e-01f, 2.00368613e-01f, -5.71199000e-01f, -4.63850707e-01f, -5.38122691e-02f,
  5.15419304e-01f, 2.07053304e-01f, -9.42722484e-02f, 1.71082154e-01f, 2.18405098e-01f, 3.35267156e-01f, -3.53185713e-01f, -3.34237248e-01f, -3.58703017e-01f, 1.28433690e-03f,
  -3.38391274e-01f, 3.10898066e-01f, 7.08391905e-01f, -2.30570212e-01f, 3.29640776e-01f, -5.46657741e-01f, -5.97108841e-01f, 2.28292793e-01f, 3.66130501e-01f, -6.59261346e-01f,
  2.29736567e-01f, 1.91813916e-01f, -6.36266023e-02f, -8.96296442e-01f, 3.49971801e-01f, -4.97211128e-01f, 1.61547333e-01f, -9.63430628e-02f, -3.11589479e-01f, -9.05372202e-01f,
  -2.40040827e-03f, -1.96213126e-01f, -1.94371432e-01f, 3.94351512e-01f, -3.56606156e-01f, -1.36552081e-01f, 5.74700311e-02f, -4.17047083e-01f, 4.69564289e-01f, 6.17796332e-02f,
  2.07089372e-02f, 1.28317520e-01f, -6.98922351e-02f, 4.10603136e-01f, -7.86044076e-02f, 5.04088998e-01f, 1.01765037e-01f, 2.12574806e-02f, -2.85093158e-01f, 2.95261085e-01f,
  -1.67302359e-02f, -4.80336130e-01f, 4.64438409e-01f, 3.61008316e-01f, -1.72809646e-01f, -6.40891016e-01f, -7.93844640e-01f, -1.89646989e-01f, -6.88308358e-01f, 7.75439858e-01f,
  -5.06414771e-01f, -4.57435399e-01f, -1.55171499e-01f, -4.55448031e-01f, 3.92225236e-01f, 5.46404779e-01f, -3.90033036e-01f, 5.33542871e-01f, -8.37275565e-01f, -3.95297319e-01f,
  -2.35490561e-01f, 5.33399343e-01f, 3.85503471e-01f, 3.60005528e-01f, 8.61650407e-01f, -4.23065066e-01f, 2.69681543e-01f, 3.43193442e-01f, 3.58707339e-01f, 1.49901077e-01f,
  7.04626786e-03f, 5.06046638e-02f, -4.50554490e-01f, -4.84781086e-01f, 3.84074390e-01f, -9.57959071e-02f, -6.26923084e-01f, -2.28137687e-01f, -1.03994884e-01f, -4.00145561e-01f,
  -8.83863389e-01f, -7.99221173e-02f, 3.20910871e-01f, -5.78276336e-01f, -2.14624405e-01f, -5.70503652e-01f, 3.22464734e-01f, 4.28339481e-01f, 3.27705175e-01f, -4.93074069e-03f,
  -5.82340062e-02f, 7.98432902e-03f, -6.36242151e-01f, 2.07861766e-01f, 3.81492317e-01f, -4.55630124e-02f, 6.42815381e-02f, -9.22086462e-02f, 3.08565944e-01f, 1.57662839e-01f,
  -1.70898307e-02f, -6.24743402e-02f, 1.41007185e-01f, 7.98842460e-02f, 2.24479735e-01f, 2.12426826e-01f, -1.25269055e-01f, -1.18971795e-01f, 3.58122200e-01f, 4.58666801e-01f,
  8.41018498e-01f, 3.56416762e-01f, 3.53483349e-01f, -3.77883315e-02f, 7.88582563e-01f, 2.15867668e-01f, 6.37423515e-01f, -2.38076344e-01f, 3.37068677e-01f, 5.57801664e-01f,
  3.53591800e-01f, -7.95272738e-02f, -7.68466108e-03f, 3.75039607e-01f, -1.15414500e-01f, -4.53311443e-01f, 7.10968256e-01f, -2.75055692e-02f, -9.53431204e-02f, -1.35292083e-01f,
  -5.89702547e-01f, -7.91166723e-02f, -8.18285048e-02f, -4.87352550e-01f, 4.01306748e-01f, -7.01365232e-01f, -6.56852484e-01f, -6.55293882e-01f, -2.07093090e-01f, 2.40545169e-01f,
  2.39223391e-01f, 1.89234570e-01f, 2.87564427e-01f, 2.66438246e-01f, -1.54516354e-01f, 3.01634073e-01f, -2.98417937e-02f, 2.02578500e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.77104765e-01f, -3.79576720e-02f, 5.27015701e-02f, -1.40969023e-01f, 1.07577786e-01f, 2.47110143e-01f, -4.29305760e-03f, 8.65267366e-02f, 1.47010878e-01f, -1.49814889e-01f,
  1.31767988e-01f, 6.32492453e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    