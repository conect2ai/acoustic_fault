/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.49532628e-01f, -6.72085807e-02f, -1.57286823e-02f, 3.24970663e-01f, -6.32110937e-03f, -5.77869862e-02f, -3.20392907e-01f, -7.75266439e-02f, 8.60102773e-02f, 8.86170417e-02f,
  6.01135604e-02f, 1.98161438e-01f, 4.05528620e-02f, 5.23332469e-02f, 1.49628697e-02f, -1.75104052e-01f, 3.40234395e-03f, 2.41634354e-01f, 1.49763525e-01f, 5.36853150e-02f,
  -7.14943856e-02f, 1.68423891e-01f, 1.54607192e-01f, 6.52353317e-02f, -1.30288238e-02f, 1.08493626e-01f, -1.15429044e-01f, 1.14227243e-01f, 2.50233021e-02f, 1.25381276e-01f,
  1.70251474e-01f, 1.98864937e-01f, 4.54772338e-02f, 1.50321633e-01f, -1.27743445e-02f, 7.49341305e-03f, 7.86545426e-02f, 8.00609589e-03f, 6.16616532e-02f, 7.26923645e-02f,
  8.97809789e-02f, 1.20732605e-01f, 2.26897582e-01f, 9.84027088e-02f, 7.73198716e-03f, 7.26281777e-02f, 5.35256229e-02f, 8.54414552e-02f, 7.90555924e-02f, 2.82689147e-02f,
  1.36455342e-01f, 1.64096460e-01f, 1.54484719e-01f, -8.07343051e-02f, 2.40231678e-02f, 2.57345229e-01f, 7.57242292e-02f, 3.51801291e-02f, 3.49851847e-02f, -7.89874326e-03f,
  5.50669469e-02f, 4.99441363e-02f, -5.99628426e-02f, -5.08955820e-03f, -6.42059818e-02f, -6.80939108e-03f, 5.88573478e-02f, 2.53145266e-02f, -1.16680525e-02f, 1.78710502e-02f,
  4.32242267e-03f, -2.91408654e-02f, -1.21673763e-01f, 4.52031894e-03f, -1.01020135e-01f, 1.21462503e-02f, -6.72333986e-02f, -5.95613979e-02f, -1.11027956e-02f, 3.86404060e-03f,
  8.62328708e-02f, -3.08377924e-03f, -7.27987364e-02f, -1.35383040e-01f, -4.36284840e-02f, -5.39637636e-03f, -3.17871980e-02f, 3.85151431e-03f, -4.52608727e-02f, 9.05571803e-02f,
  -2.41227373e-01f, 5.75183146e-02f, 1.80293068e-01f, 8.44086930e-02f, 3.85737382e-02f, 2.23349668e-02f, 5.81750683e-02f, 1.84615776e-02f, 5.17342389e-02f, 1.65404826e-02f,
  7.18628541e-02f, 7.87307471e-02f, 2.51201857e-02f, 1.94654576e-02f, 1.52693287e-01f, 8.28197226e-02f, -4.64610942e-02f, 8.23452100e-02f, 4.58916137e-03f, 3.14196534e-02f,
  -3.59587036e-02f, 7.70820677e-02f, 2.15849325e-01f, 2.02181060e-02f, 1.78987794e-02f, 2.18488514e-01f, -5.88279031e-02f, 6.13825880e-02f, 1.42417960e-02f, -1.21102676e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.32133758e+00f, 1.69057730e-05f, -9.33049679e-01f, 4.67124343e-01f, -7.14043260e-01f, -6.14906311e-01f, -3.58717322e-01f, 2.61805445e-01f, 3.90333652e-01f, -2.52595395e-01f,
  -4.66489047e-01f, -4.97573651e-02f, 1.09425023e-01f, -2.60907356e-02f, 2.14413837e-01f, -3.90385687e-01f, -2.61911392e-01f, -1.07885659e-01f, -1.26679078e-01f, -2.33142048e-01f,
  4.39806655e-02f, 3.42071891e-01f, 4.99424607e-01f, 1.15034178e-01f, -1.59610555e-01f, -1.63866833e-01f, -1.12233877e-01f, -8.85270685e-02f, -4.31366861e-01f, -4.20002997e-01f,
  -6.01389825e-01f, 6.88831508e-02f, -4.02141243e-01f, 6.01856317e-03f, -1.49842709e-01f, 2.11105615e-01f, 4.12941463e-02f, -9.62780118e-02f, 3.49438712e-02f, -4.68032807e-02f,
  -1.00020975e-01f, 6.50467956e-03f, -4.46635559e-02f, 1.11301132e-02f, -1.24313617e-02f, 1.58235475e-01f, 1.96265519e-01f, 2.16994271e-01f, 9.45892483e-02f, -8.90339911e-02f,
  4.60681468e-02f, -2.22023427e-01f, -4.09766048e-01f, -7.15665594e-02f, -1.21061742e-01f, -8.28749612e-02f, -2.57618189e-01f, -1.91404238e-01f, -2.22819611e-01f, 1.31160663e-02f,
  6.35956377e-02f, 5.65795563e-02f, -6.01146109e-02f, 6.21142872e-02f, 1.93607762e-01f, -2.17494126e-02f, 5.10281213e-02f, -3.93744521e-02f, -7.95648769e-02f, 4.58998308e-02f,
  5.60422428e-02f, -1.16284706e-01f, 1.96232442e-02f, 1.55755863e-01f, -9.78250876e-02f, -7.35029876e-02f, 6.48799958e-03f, 1.19199030e-01f, -1.91208776e-02f, 1.11651726e-01f,
  -1.15947500e-01f, 4.61439453e-02f, -6.94667101e-02f, -1.42448647e-02f, -1.41185135e-01f, -1.70857217e-02f, -8.84853154e-02f, -1.43459424e-01f, -2.63471412e-03f, 2.34107636e-02f,
  4.29285645e-01f, -1.56665146e-01f, -1.18877485e-01f, 1.82942636e-02f, -1.55268013e-01f, -1.06145501e-01f, -1.57330215e-01f, 4.80197631e-02f, 6.92165047e-02f, -1.27131507e-01f,
  -1.29144877e-01f, -5.76142073e-02f, -2.03914300e-01f, -8.16635564e-02f, -8.04085582e-02f, -3.83545682e-02f, -2.63578650e-02f, -2.08583519e-01f, -6.66856989e-02f, 1.65343344e-01f,
  1.20810933e-01f, 1.85847506e-01f, 1.53968811e-01f, 5.90867810e-02f, -1.40177505e-02f, 2.59720832e-02f, -1.39182687e-01f, -4.78925137e-03f, -2.09160559e-02f, 4.98400122e-01f,
  8.84027854e-02f, 1.05249608e+00f, 5.43874323e-01f, -3.21911722e-01f, 1.55097827e-01f, 4.10960585e-01f, 8.57848167e-01f, 1.43293709e-01f, -5.16985714e-01f, 1.17884584e-01f,
  9.66091752e-02f, -6.86666131e-01f, -3.55646521e-01f, -3.07388872e-01f, -6.46938235e-02f, 3.68675351e-01f, 5.98842576e-02f, -2.90723145e-01f, -2.47687414e-01f, -1.03384256e-01f,
  -2.53667444e-01f, -2.33381540e-01f, -2.86465555e-01f, -8.01475719e-02f, 3.67911011e-02f, -3.17801237e-01f, 9.41936001e-02f, 1.29039139e-01f, 4.63964611e-01f, 8.95402431e-02f,
  7.61645734e-02f, 4.60372180e-01f, -4.44931090e-01f, -2.28639007e-01f, 6.04017302e-02f, -1.61615968e-01f, -5.86761497e-02f, -1.64479420e-01f, 9.71947908e-02f, -1.77993011e-02f,
  9.90877748e-02f, 4.20200080e-02f, -1.22908400e-02f, 6.51501194e-02f, 7.84493014e-02f, 1.14280684e-02f, -2.09579971e-02f, -4.19939635e-03f, -1.52710721e-01f, 1.06408641e-01f,
  9.02230758e-03f, 2.77616769e-01f, 2.38928482e-01f, 8.85618627e-02f, 1.76998541e-01f, -2.21382052e-01f, 3.35511923e-01f, 9.58549529e-02f, 1.89814553e-01f, 3.83087993e-02f,
  -1.38093874e-01f, 6.44576550e-02f, 1.53282136e-01f, 2.69794781e-02f, -6.94087124e-04f, -2.91090012e-02f, 1.71524119e-02f, -1.46918923e-01f, -7.83135649e-03f, 5.28973863e-02f,
  -4.68381010e-02f, -1.00754224e-01f, -9.43319350e-02f, 1.47957757e-01f, -1.83530912e-01f, 4.82359789e-02f, 7.01971948e-02f, 5.60710300e-03f, 2.54431106e-02f, 1.74628245e-03f,
  -1.74697250e-01f, 2.79230159e-03f, 4.07194421e-02f, -1.92437638e-02f, 1.04654983e-01f, -4.00505029e-02f, 9.40347090e-02f, 1.20988563e-01f, -4.82687466e-02f, -5.52951498e-03f,
  -7.11164951e-01f, 2.45528698e-01f, -3.84796172e-01f, -6.20219251e-03f, 6.04008362e-02f, -4.74604070e-02f, 1.23165496e-01f, -3.39018763e-03f, 2.17876621e-02f, 7.12325200e-02f,
  1.91309154e-02f, -7.19866827e-02f, 1.06456675e-01f, -4.37606825e-03f, -1.95799515e-01f, -9.79602784e-02f, 3.22020054e-02f, -1.29339084e-01f, -1.84831306e-01f, 1.24252059e-01f,
  -1.18095003e-01f, -1.47766128e-01f, -6.72624409e-01f, -2.41670266e-01f, -3.17820221e-01f, -4.98857558e-01f, -1.89074039e-01f, -2.30535254e-01f, -5.26695289e-02f, -1.77249730e-01f,
  1.02260864e+00f, 4.91332859e-02f, 2.20253527e-01f, 4.22867090e-01f, 2.88639188e-01f, 2.69168735e-01f, 2.61956185e-01f, 3.01198125e-01f, 2.10133761e-01f, 2.09350809e-01f,
  1.62465319e-01f, 2.52432644e-01f, 3.07239681e-01f, 2.02783108e-01f, 1.34427890e-01f, 3.37829739e-02f, 4.61926982e-02f, 1.53135926e-01f, 1.46340922e-01f, 1.56927809e-01f,
  2.30211496e-01f, -3.13427113e-02f, 5.62038571e-02f, 3.15040648e-02f, -4.95075323e-02f, 2.01349825e-01f, -2.80136932e-02f, -9.18089747e-02f, -4.24337164e-02f, -8.34432989e-02f,
  8.64285380e-02f, 2.35157818e-01f, 1.67326361e-01f, 1.73616614e-02f, -1.56619906e-01f, -9.13839340e-02f, -5.28975315e-02f, -2.80148268e-01f, -1.04257740e-01f, -6.05494417e-02f,
  -1.08146228e-01f, -7.74303153e-02f, -5.76941036e-02f, -4.99885529e-02f, -5.74090518e-02f, -9.63971615e-02f, -1.51228160e-01f, -2.28097010e-02f, -3.60748060e-02f, -1.55745372e-01f,
  -3.31777297e-02f, -1.03521496e-01f, -1.56540111e-01f, 1.55732324e-02f, 1.01907291e-01f, 3.11304089e-02f, -2.80826632e-02f, 1.49513073e-02f, -2.12846417e-02f, 4.75892238e-02f,
  -1.60903167e-02f, 4.04082716e-01f, 1.80299476e-01f, 1.23856395e-01f, 4.69588228e-02f, 1.42342195e-01f, 1.09344453e-01f, 1.69903323e-01f, 1.69504017e-01f, -1.93234026e-01f,
  -1.38068303e-01f, -1.64454486e-02f, 1.85523584e-01f, -2.94712577e-02f, 2.03276619e-01f, 5.58562987e-02f, 6.08876930e-04f, 1.24912500e-01f, 1.05382182e-01f, -1.57232583e-02f,
  -3.71035337e-02f, 8.51459429e-03f, -1.48370460e-01f, -1.02290571e-01f, -9.47774500e-02f, 1.19307041e-01f, 8.14730488e-03f, 6.24858961e-02f, -1.08951970e-03f, -2.60297935e-02f,
  -4.86594886e-01f, 2.59749681e-01f, 8.57204050e-02f, -2.22153217e-01f, -2.16158964e-02f, -5.17919026e-02f, 1.03723630e-01f, -1.74492091e-01f, -1.45781532e-01f, -1.84015021e-01f,
  -2.40954787e-01f, 4.12429944e-02f, 1.25899594e-02f, -4.35140394e-02f, -1.37548313e-01f, -1.83033839e-01f, -1.43497020e-01f, 1.83254830e-03f, 3.36652459e-03f, -2.29450256e-01f,
  -1.21770658e-01f, 4.99044172e-03f, -1.47472084e-01f, 8.91895220e-02f, -4.25471030e-02f, 2.07800791e-02f, -1.36799484e-01f, -1.12702847e-01f, 3.58199663e-02f, -4.15646136e-02f,
  3.07046883e-02f, 2.57677585e-01f, 3.67522597e-01f, 3.03627968e-01f, 1.65928021e-01f, -3.53556186e-01f, -4.37349707e-01f, -3.32085639e-01f, -1.35224283e-01f, 1.18532412e-01f,
  -1.04499236e-03f, -9.22154337e-02f, 4.52405252e-02f, -1.03924045e-04f, -3.07665557e-01f, 3.02034925e-04f, 3.98524523e-01f, 7.23909959e-02f, -4.40939575e-01f, -4.18468237e-01f,
  -5.54230213e-02f, -2.04085335e-02f, -4.49768156e-02f, -6.44301157e-03f, 3.86811823e-01f, -2.32862785e-01f, 2.08855972e-01f, 4.16916758e-01f, 1.37944922e-01f, 7.73304045e-01f,
  1.83973581e-01f, 4.94718790e-01f, -3.48119229e-01f, -1.20784394e-01f, 2.92717248e-01f, 1.57628000e-01f, -3.63065489e-02f, 2.39868253e-01f, -3.31306905e-02f, 9.84671190e-02f,
  2.30564997e-01f, 2.02383161e-01f, 3.03885490e-01f, 4.77766283e-02f, -1.89950645e-01f, -3.92195165e-01f, 1.70039192e-01f, 2.94778720e-02f, 2.44650487e-02f, 2.65400887e-01f,
  3.59636545e-01f, -3.59318107e-02f, -7.74378851e-02f, -4.03941154e-01f, 2.91983560e-02f, -1.41812474e-01f, -2.84987539e-01f, -1.01145186e-01f, -5.76615453e-01f, -1.08723072e-02f,
  3.31385396e-02f, 1.07830381e-02f, 1.53516725e-01f, 9.61104482e-02f, 3.57188396e-02f, 2.06134439e-01f, 2.19179064e-01f, -4.82881442e-02f, -1.11794777e-01f, -4.39758077e-02f,
  1.26992799e-02f, -3.26324739e-02f, 7.54278824e-02f, 2.27751583e-03f, -1.06713513e-03f, 6.92291278e-03f, -1.08910486e-01f, -1.75053507e-01f, 9.39430073e-02f, 4.35837284e-02f,
  -2.98006041e-03f, 1.03650533e-01f, -5.09221740e-02f, -7.32908919e-02f, 2.59930082e-02f, 7.12075830e-02f, 1.49049431e-01f, -1.39077023e-01f, -9.36709344e-02f, 1.25131369e-01f,
  -2.37388641e-01f, -4.04442996e-01f, 6.12429082e-02f, -1.93274960e-01f, 6.24064766e-02f, 3.95900421e-02f, 1.13918900e-01f, -1.19083747e-01f, -5.27750142e-02f, -2.53943443e-01f,
  -1.65408462e-01f, -4.24566679e-02f, 1.48918092e-01f, 3.03214369e-03f, -2.52636343e-01f, -3.84540707e-02f, -1.77527428e-01f, 5.54476827e-02f, -2.32100338e-01f, -2.97166295e-02f,
  -1.03331342e-01f, -6.90844536e-01f, -5.70394874e-01f, -2.02703476e-01f, -2.37357497e-01f, -4.78333622e-01f, -3.82706374e-01f, -4.36861038e-01f, -8.74477506e-01f, -6.98490620e-01f,
  -1.02926028e+00f, -1.11577797e+00f, -3.34266633e-01f, -8.84314179e-01f, -7.71292984e-01f, -2.08385676e-01f, -6.08301163e-01f, -2.60470480e-01f, -3.81878644e-01f, -6.32106721e-01f,
  -4.70873825e-02f, 5.68833113e-01f, 4.53800529e-01f, 4.35440570e-01f, 4.85843301e-01f, -5.49208164e-01f, -6.03857636e-01f, 8.72414708e-02f, 2.78492421e-01f, -2.21667334e-01f,
  -7.41624117e-01f, -8.19532931e-01f, -4.70689446e-01f, -2.21074626e-01f, -4.04462874e-01f, 3.32510233e-01f, -1.81916475e-01f, -2.82646507e-01f, 1.82179615e-01f, -2.00105205e-01f,
  3.28490824e-01f, -1.05727300e-01f, 2.98667282e-01f, 8.35471451e-02f, -1.38253376e-01f, 8.18427801e-02f, -5.08694276e-02f, -9.16481689e-02f, 4.79505137e-02f, -1.74628288e-01f,
  -1.39472216e-01f, -9.37201455e-02f, -3.85560021e-02f, -9.10931006e-02f, -4.07237411e-01f, -6.61052018e-02f, -1.97212353e-01f, -1.03604570e-01f, 8.16342607e-03f, 4.53811511e-02f,
  -3.29892933e-01f, -1.94968179e-01f, 2.65663236e-01f, 3.31574529e-01f, 2.97201276e-01f, 2.56771743e-01f, 1.40683413e-01f, 2.32121766e-01f, 3.72457653e-01f, -1.24062397e-01f,
  -1.94777787e-01f, 4.09221351e-02f, 3.84791121e-02f, 1.78154968e-02f, -6.27732929e-03f, -4.11150977e-02f, 5.79855256e-02f, 1.30232930e-01f, -1.07949354e-01f, -2.53600292e-02f,
  -4.88302484e-03f, 4.98608649e-02f, 1.61363810e-01f, 2.90534534e-02f, 1.43961385e-01f, -4.63559888e-02f, -2.52257213e-02f, -8.46865680e-03f, 1.26347104e-02f, -1.03687530e-03f,
  5.60405329e-02f, 6.01522848e-02f, -6.80608749e-02f, 8.28152299e-02f, -4.65243198e-02f, -1.45950079e-01f, -2.22868342e-02f, 1.01015769e-01f, 7.13715330e-02f, -1.59609854e-01f,
  3.00921202e-01f, 2.46645361e-01f, 4.61291820e-02f, 1.32331327e-01f, -1.12502545e-01f, -3.61060835e-02f, -8.14508349e-02f, -6.91713616e-02f, 5.60065210e-02f, -1.12140141e-01f,
  -1.36648014e-01f, -1.99177131e-01f, -8.78852829e-02f, 8.25279020e-03f, -1.98816676e-02f, 2.14466192e-02f, -1.46786660e-01f, -6.58183619e-02f, 1.02203123e-01f, -1.66386783e-01f,
  -1.71110779e-01f, -2.83956416e-02f, 1.65373653e-01f, 2.25136220e-01f, 1.62211567e-01f, 3.28248441e-01f, 2.27023691e-01f, 7.93063641e-02f, 3.32552046e-01f, -2.41436824e-01f,
  5.59543729e-01f, -6.35493755e-01f, 5.82998395e-01f, 2.07686588e-01f, 3.12614262e-01f, 3.29329163e-01f, 3.00851732e-01f, 6.28060251e-02f, 2.36617044e-01f, 6.11005025e-03f,
  -8.15744936e-01f, -8.74192595e-01f, -7.42142320e-01f, -4.56410736e-01f, -4.57844526e-01f, 2.39152327e-01f, 3.52905840e-01f, 3.85594934e-01f, 3.55673045e-01f, 3.76207501e-01f,
  -9.65132192e-02f, 3.63019556e-01f, 2.58223027e-01f, 1.60785750e-01f, -1.63216852e-02f, -8.19151551e-02f, 2.18554422e-01f, -8.03811774e-02f, -2.49137104e-01f, 1.90158367e-01f,
  -3.33261251e-01f, -1.75818965e-01f, 2.17724413e-01f, -2.10726127e-01f, -2.67694920e-01f, -9.12476331e-02f, -6.14972413e-03f, 8.51787999e-02f, -7.70542175e-02f, 1.75922349e-01f,
  -1.99782714e-01f, -9.43976492e-02f, -2.49503627e-01f, -1.13516718e-01f, 1.06097944e-01f, -1.19856093e-02f, 1.67136677e-02f, -1.75429396e-02f, 3.61652821e-02f, -2.53416508e-01f,
  -3.39782268e-01f, -7.94620365e-02f, 3.86971906e-02f, 2.62741093e-02f, -3.52522060e-02f, -7.27871507e-02f, -2.44623721e-02f, -1.08912155e-01f, 1.68690516e-04f, 1.49054199e-01f,
  3.88876684e-02f, 3.67830321e-02f, 3.01943207e-03f, 2.23327547e-01f, 4.09751274e-02f, -5.28707216e-03f, 5.16217574e-02f, -1.88444585e-01f, 1.72334507e-01f, 1.48029178e-01f,
  7.15741366e-02f, -7.18161091e-02f, -2.53139194e-02f, 1.22699074e-01f, -8.05838257e-02f, -3.12063731e-02f, -6.69817030e-02f, -2.10408657e-03f, 3.62424271e-06f, 8.08684006e-02f,
  -8.51811748e-03f, -4.46770748e-04f, -3.75256762e-02f, -1.41904458e-01f, -8.80208910e-02f, -1.15480661e-01f, 7.03562647e-02f, -8.44062772e-03f, -3.86305712e-02f, 1.46938726e-01f,
  1.49494587e-02f, -3.92732859e-01f, 2.08807155e-01f, -8.07545185e-02f, 1.01770170e-01f, 2.36682426e-02f, -1.15596622e-01f, -1.66162580e-01f, -4.99510169e-02f, -1.15725569e-01f,
  -2.76681095e-01f, -2.94592977e-01f, -1.76314563e-01f, -9.80797186e-02f, 1.92213610e-01f, 1.01893879e-01f, -2.48081759e-01f, -6.02420382e-02f, 9.38590318e-02f, -5.89201823e-02f,
  -1.19864851e-01f, 3.07214081e-01f, 2.36168131e-01f, 1.50824890e-01f, -4.65486906e-02f, 1.40869796e-01f, 1.16784707e-01f, 1.55295298e-01f, 1.72458515e-01f, 4.37716424e-01f,
  3.12774122e-01f, -1.29915357e-01f, 8.29757512e-01f, -2.74724774e-02f, -6.96355760e-01f, -7.82274425e-01f, -9.47121918e-01f, -5.02029955e-01f, -1.37219429e-01f, -9.85367224e-02f,
  -2.72121280e-01f, -2.30430454e-01f, 1.93571374e-01f, 1.35266883e-02f, -1.10162646e-02f, -1.13118745e-01f, 3.16929132e-01f, 6.14427626e-01f, 3.05453509e-01f, -5.73320091e-01f,
  -4.50450182e-01f, 1.94878116e-01f, 6.81648970e-01f, 3.54704678e-01f, 3.68240662e-02f, -1.91223100e-02f, 3.34142834e-01f, 1.87677845e-01f, -2.30337866e-02f, 6.20831072e-01f,
  4.85624820e-01f, -8.66519287e-02f, 1.20067839e-02f, -2.58911103e-02f, 1.30674094e-01f, -7.70392641e-02f, -1.56849489e-01f, 3.16729188e-01f, -8.14310014e-02f, 7.22677112e-02f,
  -8.82081501e-03f, -1.51036412e-01f, -8.61225203e-02f, 5.86436735e-03f, -7.87434131e-02f, -1.50855988e-01f, 1.08300835e-01f, 4.54678446e-01f, 2.38941997e-01f, -1.31967187e-01f,
  -3.16245198e-01f, -2.30082691e-01f, -5.01259007e-02f, -2.32281119e-01f, 1.04609281e-01f, 7.24930614e-02f, -1.26193181e-01f, -2.40153186e-02f, 1.22832581e-01f, 5.53476810e-02f,
  -1.33770496e-01f, 6.10517114e-02f, 3.20931710e-02f, -4.57549915e-02f, -1.54319420e-01f, -8.46770108e-02f, -2.06006467e-02f, 1.29410103e-02f, 3.60595398e-02f, 1.11059509e-02f,
  -1.71248093e-02f, 1.01763904e-01f, 3.17098573e-02f, -7.12754950e-02f, -1.15368357e-02f, 2.64488794e-02f, -3.73232253e-02f, 1.49013191e-01f, -3.63905206e-02f, -1.68769449e-01f,
  -1.11920960e-01f, -5.91510907e-02f, 3.75681408e-02f, -5.48685528e-02f, -5.76472841e-02f, 3.91560569e-02f, 1.86684895e-02f, -9.86864865e-02f, -4.73171137e-02f, -2.98510143e-03f,
  1.42885253e-01f, 3.69907767e-02f, 2.05841679e-02f, 1.63656250e-01f, 5.37924021e-02f, -1.36659099e-02f, 8.57222676e-02f, -9.02415216e-02f, 4.00169827e-02f, -1.43541023e-01f,
  -9.76838917e-02f, -2.13720590e-01f, 1.17901757e-01f, 2.71111041e-01f, -1.59825623e-01f, -1.78835485e-02f, -2.13026777e-01f, -2.06333712e-01f, -5.90610988e-02f, -1.36514828e-01f,
  9.51883644e-02f, -3.38754207e-01f, -3.30458283e-01f, -3.33136916e-01f, -1.29550025e-01f, -2.54384637e-01f, -9.96397659e-02f, -7.83384517e-02f, -2.78849781e-01f, -5.06229937e-01f,
  -1.26609087e+00f, 3.66874039e-01f, -8.27908814e-01f, -1.52729347e-01f, 3.36212218e-01f, 1.66497156e-02f, 1.95372000e-01f, -3.97966087e-01f, -4.95431632e-01f, -1.01066172e-01f,
  5.35182282e-02f, 1.12825468e-01f, 1.61962271e-01f, 2.57423192e-01f, -1.24771170e-01f, 1.65383488e-01f, 2.22660929e-01f, -1.85223296e-01f, -2.44017944e-01f, 3.95012051e-01f,
  9.17416811e-01f, 7.44562671e-02f, -6.63462162e-01f, -2.84555644e-01f, 4.13621694e-01f, 2.01546177e-01f, -2.89865345e-01f, 8.88692029e-03f, 2.09593803e-01f, 5.24821043e-01f,
  3.67035329e-01f, -6.43782437e-01f, -1.49285734e-01f, -6.09459244e-02f, 6.30454021e-03f, -2.10199580e-01f, -4.31148224e-02f, -2.83667296e-01f, -1.29682451e-01f, -1.45867720e-01f,
  -1.76224019e-02f, -2.31794924e-01f, 4.48572375e-02f, 1.13934346e-01f, -4.18789200e-02f, -9.57168117e-02f, -1.57030344e-01f, -3.04640979e-01f, -4.25385296e-01f, 6.34018183e-02f,
  6.32739544e-01f, -1.96941309e-02f, -2.43381619e-01f, -5.34847192e-02f, 1.52877532e-02f, -3.05123590e-02f, -8.25682208e-02f, 2.82779511e-04f, -5.01761913e-01f, -1.83425069e-01f,
  -6.66126087e-02f, 3.76140419e-03f, 4.15304191e-02f, 2.85729114e-02f, -7.07005262e-02f, 6.28254041e-02f, 8.69471282e-02f, 1.18464507e-01f, 4.62253466e-02f, 1.00804279e-02f,
  -9.08416510e-02f, 5.88322692e-02f, -9.09772068e-02f, -8.13498870e-02f, 1.57316223e-01f, -8.63504559e-02f, -7.13604689e-02f, -7.45642632e-02f, -1.24042153e-01f, -2.87264496e-01f,
  2.80312058e-02f, -1.30690411e-01f, -1.20245233e-01f, 5.88308275e-02f, -3.08044814e-03f, -1.44029468e-01f, 4.07858603e-02f, 6.58579990e-02f, 4.81200591e-02f, 2.99476944e-02f,
  2.14868888e-01f, -3.94468218e-01f, 1.22943588e-01f, -1.63061339e-02f, 3.51502821e-02f, 5.14408462e-02f, -3.81245394e-03f, -7.80590326e-02f, 2.41700672e-02f, -7.99257457e-02f,
  -1.07039534e-01f, -1.08779185e-01f, 6.83943480e-02f, 1.66640416e-01f, 5.74479811e-02f, -3.49947736e-02f, 2.32256889e-01f, 8.22333694e-02f, 3.50945629e-02f, -4.57351525e-05f,
  1.09836221e-01f, -1.99858755e-01f, -2.67070848e-02f, -7.35243931e-02f, 3.34178925e-01f, -1.26494497e-01f, 9.67353433e-02f, 4.29726653e-02f, -2.86087990e-01f, -2.46408880e-02f,
  -3.54611129e-02f, 3.56499732e-01f, -4.93065506e-01f, 6.08163595e-01f, 2.52200633e-01f, -5.19306660e-01f, -6.10355318e-01f, -3.97527516e-01f, 3.10113341e-01f, 9.20261070e-02f,
  1.88859180e-01f, 4.19601388e-02f, 5.85244447e-02f, -3.08191001e-01f, -5.02723396e-01f, -8.63235630e-03f, 2.17957512e-01f, -3.97612423e-01f, -9.05019879e-01f, -5.80515087e-01f,
  2.12088034e-01f, 3.01396668e-01f, -9.26396698e-02f, -2.06940085e-01f, 7.45713472e-01f, 3.08447063e-01f, 4.18924958e-01f, 3.55813950e-01f, 2.06248567e-01f, 8.09706151e-01f,
  -2.66834319e-01f, 1.97260305e-01f, -3.65026355e-01f, 1.88995004e-01f, 3.46839912e-02f, -1.62833363e-01f, -6.71106651e-02f, -5.82762510e-02f, 3.88773121e-02f, 9.08328816e-02f,
  1.64263308e-01f, 9.55470726e-02f, 1.23633809e-01f, 1.25259444e-01f, 1.16684072e-01f, -1.46269858e-01f, -3.49653140e-02f, -4.65039492e-01f, -2.61487186e-01f, -9.65864435e-02f,
  3.24756354e-01f, -1.19869530e-01f, -4.21259403e-01f, -2.82600433e-01f, -2.83313364e-01f, -7.78745934e-02f, -1.38843626e-01f, 1.70752302e-01f, -3.36407155e-01f, 3.37050527e-01f,
  -1.98777497e-01f, 6.46734983e-02f, -8.89260918e-02f, 8.71719345e-02f, 1.37300462e-01f, -9.33772698e-02f, 7.81289935e-02f, 3.54959369e-02f, -3.60463783e-02f, -3.97629198e-03f,
  -3.76751758e-02f, 6.08293675e-02f, -8.05916935e-02f, 9.38892588e-02f, 6.36894852e-02f, 9.41137895e-02f, 1.06841616e-01f, 4.59954552e-02f, 3.68468650e-02f, 1.45642698e-01f,
  -1.43547013e-01f, 3.35137430e-03f, 2.02425018e-01f, -1.67328969e-01f, 3.23895328e-02f, -3.34489606e-02f, 7.17080459e-02f, 2.61581689e-03f, 6.11729026e-02f, 1.54272929e-01f,
  2.98464864e-01f, -3.20515841e-01f, 1.95821092e-01f, -1.62311401e-02f, 1.12057708e-01f, 6.74775839e-02f, 2.17758536e-01f, -4.24276659e-04f, 3.34252864e-01f, 1.45554245e-02f,
  -9.39047113e-02f, -7.59983957e-02f, 1.03702545e-01f, -2.16628224e-01f, -3.24175626e-01f, -1.07080340e-02f, 1.82564005e-01f, -3.99445221e-02f, -2.37767801e-01f, 1.63486138e-01f,
  2.69955657e-02f, -1.82602964e-02f, -3.32535356e-01f, -1.66741237e-01f, 1.61836267e-01f, -1.26249582e-01f, 8.31466448e-03f, -7.09047168e-02f, -4.96157736e-01f, 2.32283492e-02f,
  2.66264498e-01f, 2.18407571e-01f, -4.36128348e-01f, -2.47260123e-01f, -6.26466811e-01f, -5.87128520e-01f, -2.19079271e-01f, -2.29578242e-01f, -2.80204624e-01f, -4.74450327e-02f,
  -1.12527035e-01f, 6.68795258e-02f, 3.79202276e-01f, -9.34157670e-02f, 1.78315192e-02f, 1.55535355e-01f, -1.54001087e-01f, -1.33892342e-01f, -5.98122716e-01f, -9.01670933e-01f,
  -5.57583451e-01f, -1.52984455e-01f, -3.53180110e-01f, -2.94635653e-01f, -2.44082153e-01f, -1.13762170e-01f, 1.33643979e-02f, -3.44268858e-01f, -2.94650376e-01f, -4.73163985e-02f,
  5.35954714e-01f, -3.47829461e-02f, -4.95933369e-02f, -2.28280142e-01f, 1.70842111e-02f, -1.21921457e-01f, 1.00479675e-02f, 6.14927635e-02f, 4.83916365e-02f, -1.07119158e-01f,
  -6.02093451e-02f, -1.78186357e-01f, -3.99171896e-02f, -8.79648924e-02f, -1.68642849e-01f, -1.36666819e-01f, -1.64527550e-01f, -1.51434481e-01f, -1.09722726e-01f, -1.27634823e-01f,
  -3.41582924e-01f, -3.46429795e-01f, 3.12348939e-02f, 1.56966560e-02f, -1.69581369e-01f, -6.88590258e-02f, -2.13747695e-02f, -3.17476779e-01f, -1.31677926e-01f, 1.26721606e-01f,
  8.12037755e-03f, 5.72715402e-02f, -9.36508924e-02f, 1.12593081e-02f, 2.66894363e-02f, 4.86188792e-02f, 1.19460240e-01f, 2.33972713e-01f, -2.32401527e-02f, 1.48842990e-01f,
  -2.99876016e-02f, -1.78814661e-02f, 1.18926324e-01f, 7.78568983e-02f, 1.35662183e-01f, -8.37321058e-02f, 1.53645009e-01f, 1.96666658e-01f, 2.11952895e-01f, 1.68749467e-01f,
  -6.61041364e-02f, -6.62667155e-02f, 1.56777620e-01f, 1.12663783e-01f, -2.58488238e-01f, 2.12417394e-02f, -2.55031176e-02f, -1.61878258e-01f, -1.39775515e-01f, -1.72287658e-01f,
  6.91200256e-01f, -2.30229586e-01f, 2.93297529e-01f, -1.25280812e-01f, 4.70998604e-03f, -1.19645983e-01f, 8.08428377e-02f, 3.45715210e-02f, 9.12483335e-02f, 3.27934907e-03f,
  -1.25599712e-01f, 1.64255708e-01f, 3.15241925e-02f, 3.66675481e-02f, -1.86253592e-01f, -1.59721732e-01f, -2.32747331e-01f, 2.85938662e-03f, -9.62350294e-02f, -3.53731476e-02f,
  -1.41658053e-01f, -2.39884853e-03f, 4.35047448e-01f, 3.83468926e-01f, -4.88537066e-02f, 1.49641573e-01f, 4.14272040e-01f, 2.78584987e-01f, 2.68659770e-01f, 4.49067414e-01f,
  -9.04559493e-01f, 3.63854975e-01f, 2.12751612e-01f, -2.11947471e-01f, 4.42085117e-01f, 4.51689601e-01f, 7.28006899e-01f, 3.22656333e-01f, 4.42808913e-03f, 2.78974593e-01f,
  2.65634865e-01f, -1.76932186e-01f, -8.92689973e-02f, 9.55260098e-02f, 3.09641212e-01f, 5.30354619e-01f, 3.82110834e-01f, -1.36146650e-01f, -2.63199985e-01f, 5.63990790e-03f,
  3.96380462e-02f, -1.56801134e-01f, -3.93720448e-01f, -1.42858371e-01f, 2.67190132e-02f, -2.11687490e-01f, 1.89120248e-01f, 1.30513817e-01f, 4.26842749e-01f, -1.09321252e-01f,
  1.33106679e-01f, 8.46133530e-02f, -1.43797874e-01f, -5.53207248e-02f, -2.72588171e-02f, -3.44340146e-01f, -1.07620887e-01f, -2.78558940e-01f, -1.70239821e-01f, -4.36857790e-02f,
  9.13637877e-03f, -1.52900144e-01f, -5.59010394e-02f, -5.68981394e-02f, -7.77220204e-02f, -8.89513716e-02f, -1.23324350e-01f, 4.33595031e-02f, 2.01099887e-01f, 1.39303014e-01f,
  3.61164398e-02f, 2.15974614e-01f, 2.04947039e-01f, 1.66933015e-01f, 2.03775018e-01f, -3.62101831e-02f, 1.17677331e-01f, 7.82232136e-02f, 1.34513870e-01f, -2.27489769e-01f,
  -7.92082921e-02f, -2.52409615e-02f, 1.39532402e-01f, -1.49727449e-01f, -3.33368219e-02f, 3.38917524e-02f, -4.66144308e-02f, 2.43579373e-02f, 1.09902777e-01f, -1.86917022e-01f,
  2.72743441e-02f, 2.12409183e-01f, 9.73000098e-03f, -2.37311572e-02f, -2.34031938e-02f, 1.12940155e-01f, -3.78895625e-02f, -1.63374115e-02f, 6.58291252e-03f, 1.89660024e-02f,
  -1.19579755e-01f, 1.25092193e-01f, -1.54316192e-02f, 9.20623243e-02f, 1.36839285e-01f, -5.89943156e-02f, -1.40564993e-01f, -3.23709548e-02f, -5.92149757e-02f, -2.20583882e-02f,
  -1.14784509e-01f, 4.23458010e-01f, -1.61652654e-01f, 6.04262762e-02f, 6.13068044e-02f, -6.75041378e-02f, -1.05952911e-01f, -3.56947035e-02f, 7.32133687e-02f, 1.39615033e-02f,
  -1.76749453e-02f, -2.32518598e-01f, 2.35494301e-02f, -5.53826094e-02f, -2.09060788e-01f, -1.29311100e-01f, 1.00284114e-01f, -1.23887951e-03f, 1.84347734e-01f, 6.48936555e-02f,
  7.09815398e-02f, -6.31078333e-02f, -5.23367599e-02f, -7.30756298e-02f, -5.53957522e-02f, -1.32504016e-01f, -6.39986768e-02f, -9.00569931e-02f, 7.03278333e-02f, -3.96292627e-01f,
  -7.24546790e-01f, -4.92341757e-01f, -3.67548853e-01f, -5.96821070e-01f, -1.18341610e-01f, -2.91869521e-01f, -6.14516795e-01f, -4.19898063e-01f, 8.94440990e-03f, -2.33550951e-01f,
  4.04977649e-01f, 3.37460786e-01f, -2.33361378e-01f, -1.65551990e-01f, -4.15838420e-01f, -6.89181626e-01f, -5.60467541e-01f, -5.27898133e-01f, -5.74208349e-02f, 4.57935512e-01f,
  3.74468744e-01f, -1.17810303e-02f, 4.12901677e-03f, -9.81269479e-02f, -1.31977379e-01f, -7.80058578e-02f, -3.30998451e-01f, -2.33402282e-01f, -7.98140019e-02f, -4.51628834e-01f,
  -2.88744897e-01f, -2.53708541e-01f, 2.45806962e-01f, 1.26602009e-01f, 3.75261009e-01f, -7.36253858e-02f, -3.29834968e-02f, 1.08839951e-01f, 1.70353264e-01f, -2.19963163e-01f,
  -2.69337334e-02f, 2.95496210e-02f, -2.82800227e-01f, 6.43302649e-02f, -1.71218351e-01f, -2.58918315e-01f, -2.63841361e-01f, -2.31231436e-01f, -3.25426430e-01f, -7.86648318e-02f,
  -4.80064424e-03f, 1.08552702e-01f, -5.45358360e-01f, -1.68473437e-01f, -4.37066436e-01f, -2.45411277e-01f, -2.79804200e-01f, -3.15153092e-01f, -4.29368794e-01f, -6.84584975e-01f,
  1.39722973e-01f, 1.17589369e-01f, 2.62017488e-01f, -2.60952890e-01f, 1.14121646e-01f, 1.05538845e-01f, -8.75032097e-02f, 2.71570198e-02f, 1.57974362e-01f, -1.13852613e-01f,
  5.78377284e-02f, -1.21415213e-01f, 3.09921745e-02f, -1.06746435e-01f, -9.67693552e-02f, -8.35823491e-02f, 1.63060687e-02f, -1.23533132e-02f, -8.69141817e-02f, -1.84496008e-02f,
  1.29784606e-02f, -1.35698887e-02f, 9.84200612e-02f, 1.69419810e-01f, 9.58277211e-02f, -1.98315252e-02f, 1.01585537e-01f, 1.71146691e-01f, -2.83690840e-01f, 1.26904473e-01f,
  -3.79164964e-01f, 5.15471995e-01f, -1.44343704e-01f, -3.06456923e-01f, -1.65544391e-01f, 2.16769367e-01f, 2.24134084e-02f, 1.43804383e-02f, -1.22744828e-01f, 5.22848405e-02f,
  -1.52097955e-01f, -1.77095607e-01f, -2.67013699e-01f, 1.72060817e-01f, -3.42703350e-02f, -2.01777011e-01f, -2.61874855e-01f, -1.95492104e-01f, 4.53071259e-02f, 7.12654144e-02f,
  -3.70896190e-01f, -4.89469737e-01f, -6.34978116e-01f, -5.14044225e-01f, -2.39226595e-01f, -2.74632365e-01f, -4.79567856e-01f, -5.98317921e-01f, -7.28919208e-01f, -8.78411770e-01f,
  -1.16152287e+00f, 2.13172764e-01f, 4.49566364e-01f, -3.86669070e-01f, -7.41104111e-02f, 1.04108699e-01f, 4.89021331e-01f, -3.34995426e-02f, -1.36348143e-01f, 5.39040804e-01f,
  -5.71338460e-02f, -6.55339301e-01f, -1.74008891e-01f, -1.92914069e-01f, -3.57533723e-01f, 7.18081057e-01f, 3.21240962e-01f, -3.41589659e-01f, -4.05515194e-01f, -2.24034682e-01f,
  -1.44080579e-01f, -4.61704612e-01f, -6.75290704e-01f, -3.48071665e-01f, -2.06453478e-04f, -2.64367640e-01f, 2.16151193e-01f, -3.05929244e-01f, -1.72843069e-01f, -1.43093362e-01f,
  4.59796250e-01f, -4.69775915e-01f, -4.99101058e-02f, -4.27148044e-01f, -1.53419720e-02f, -1.01312771e-01f, -6.08943999e-02f, 5.59094809e-02f, 1.42727969e-02f, 1.14134483e-01f,
  -2.55988866e-01f, 2.71311998e-02f, -1.76773563e-01f, 2.96714939e-02f, -1.11608543e-01f, -2.72203609e-02f, -2.48936713e-02f, -1.71280593e-01f, 5.12725580e-03f, 2.38414109e-01f,
  2.44394466e-02f, -2.48161390e-01f, -9.24859419e-02f, 1.04829758e-01f, -2.43559539e-01f, -3.06173980e-01f, 2.90504061e-02f, -2.89255321e-01f, -2.53347456e-01f, 1.90080419e-01f,
  9.39269587e-02f, 1.10595107e-01f, -1.12768643e-01f, -4.39277925e-02f, -4.14930806e-02f, 1.23966865e-01f, 2.93444134e-02f, -3.00532184e-03f, -7.72470012e-02f, -1.91685945e-01f,
  -2.17663217e-03f, 6.47469163e-02f, 5.82026541e-02f, -4.93336655e-02f, -8.48795921e-02f, -3.11157424e-02f, -1.81175797e-04f, 1.00520775e-01f, -6.59296215e-02f, -2.37674899e-02f,
  -1.29630834e-01f, 1.29890600e-02f, 7.18064085e-02f, 4.11026739e-02f, -9.12365224e-03f, -2.02562399e-02f, -4.54236232e-02f, -1.69616252e-01f, -8.68324041e-02f, -1.58673301e-02f,
  1.38833076e-01f, -3.61305147e-01f, 2.09928825e-01f, -1.29883349e-01f, 1.66467533e-01f, 3.78271192e-02f, -3.86927975e-03f, -2.26851534e-02f, -4.13258970e-02f, 7.26724267e-02f,
  -1.67185113e-01f, 1.11130543e-01f, -3.15171666e-02f, 1.14321783e-01f, -7.27956370e-02f, -1.24099152e-02f, 1.27447426e-01f, -3.17541547e-02f, -1.16361842e-01f, 1.58629194e-01f,
  1.84269011e-01f, 1.12022243e-01f, 3.03613245e-02f, 2.13844165e-01f, 1.26384646e-01f, -3.34621919e-03f, 2.92362392e-01f, 2.45601639e-01f, 2.00548768e-02f, 7.60544181e-01f,
  -5.21713793e-01f, -7.11151540e-01f, 2.33753491e-02f, 9.18843970e-03f, -3.34191710e-01f, -2.53498822e-01f, -7.50327289e-01f, -1.83680002e-02f, 2.76377439e-01f, -4.26260263e-01f,
  -2.39245385e-01f, 1.18925698e-01f, -2.35343963e-01f, -1.21766716e-01f, -1.77723989e-01f, -7.01908112e-01f, -3.59412998e-01f, -1.16291121e-01f, 2.70283133e-01f, 1.05407134e-01f,
  -6.01195060e-02f, -6.47401512e-02f, 3.09989154e-01f, 2.41187260e-01f, -1.63566366e-01f, -1.66721284e-01f, -1.68036088e-01f, -2.07881480e-01f, -2.73397744e-01f, -8.21502268e-01f,
  -4.48655993e-01f, -2.47356340e-01f, -9.61743221e-02f, -1.49992317e-01f, -1.34616002e-01f, -1.97193529e-02f, -1.45653024e-01f, 1.22823082e-01f, -1.81879324e-03f, -3.74623016e-02f,
  1.00659758e-01f, 1.35409847e-01f, 9.43720415e-02f, 9.41608623e-02f, 3.01129073e-02f, -2.02267038e-04f, 2.76869863e-01f, 9.12331417e-02f, -4.45235260e-02f, 4.10495885e-02f,
  -1.38061550e-02f, -7.64555037e-02f, -6.33338168e-02f, 6.95268288e-02f, 2.19832227e-01f, 7.68446326e-02f, 6.56641871e-02f, 1.84067339e-01f, -5.12823947e-02f, -4.27334249e-01f,
  -5.57971895e-02f, -1.63088560e-01f, -1.23983368e-01f, 1.58436134e-01f, 2.28035171e-02f, 1.66651592e-01f, -1.80739854e-02f, -1.10908054e-01f, 1.37943015e-01f, 4.30571241e-03f,
  9.86076072e-02f, -1.31306902e-01f, -6.69789314e-02f, -1.29512802e-01f, -5.64043373e-02f, -2.01798771e-02f, -4.27600481e-02f, -4.45768163e-02f, -1.09316051e-01f, -1.08904026e-01f,
  -5.88552579e-02f, 3.21132652e-02f, 4.65923967e-03f, -1.07937776e-01f, -1.94698066e-01f, -1.59777164e-01f, 4.67825262e-03f, 6.95912167e-03f, -1.85159203e-02f, 2.29923874e-01f,
  1.66217703e-02f, -1.64526030e-01f, -4.52652007e-01f, 9.47874691e-03f, 4.12265286e-02f, 7.78497607e-02f, -1.54233752e-02f, 8.69625658e-02f, -1.22908674e-01f, -1.16229746e-02f,
  6.45465776e-02f, 1.40651807e-01f, -7.18712248e-03f, 4.88519296e-02f, -3.57106514e-03f, 2.09153160e-01f, 1.64335757e-01f, -5.04533909e-02f, -4.74967919e-02f, 2.85373122e-01f,
  2.28393346e-01f, -1.62710145e-01f, -3.86489421e-01f, -1.10760331e-01f, 1.08011095e-02f, -1.62759662e-01f, -2.56761521e-01f, 2.07183715e-02f, -2.46855170e-01f, -6.53672516e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.92809856e-01f, 7.09436059e-01f, 6.39096200e-01f, 5.73689222e-01f, 9.81302977e-01f, 4.24892634e-01f, 6.85250640e-01f, 6.07054293e-01f, 9.96534646e-01f, 4.06558663e-01f,
  5.34795821e-01f, 6.58163130e-01f, 9.90188837e-01f, 4.62323904e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.66742161e-01f, -9.79474932e-02f, -1.60089120e-01f, 4.89886343e-01f, 2.25717485e-01f, -3.07244897e-01f, 5.50072074e-01f, -4.18968320e-01f, 2.56686043e-02f, -1.65929407e-01f,
  -3.33384126e-01f, -2.41677523e-01f, 9.63400118e-03f, 2.73219179e-02f, -2.47280434e-01f, 4.36125398e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.20759262e-02f, 1.20597251e-01f, -5.02541959e-01f, 8.49467576e-01f, -1.61563590e-01f, 2.23943144e-01f, 3.37278426e-01f, -3.76391441e-01f, -4.72912550e-01f, 1.76608694e+00f,
  8.06752682e-01f, 7.45400429e-01f, 3.31128061e-01f, 2.72105038e-01f, 4.71259147e-01f, -1.42053336e-01f, 3.16571742e-02f, 2.62964398e-01f, 8.95524859e-01f, -7.80337095e-01f,
  6.57339275e-01f, 2.74860799e-01f, -1.34920478e-01f, 4.05882180e-01f, 1.00387275e+00f, 4.25831050e-01f, 3.04060847e-01f, 4.98824716e-01f, -5.40314019e-01f, -2.07692817e-01f,
  2.59469718e-01f, -3.84418458e-01f, 1.79308906e-01f, 1.72743306e-01f, -6.62149906e-01f, 1.50427175e+00f, -4.76744950e-01f, 1.20516503e+00f, 1.26916915e-01f, 4.15133297e-01f,
  1.09767973e+00f, -4.60853368e-01f, 7.25153863e-01f, 1.43110618e-01f, 3.90776813e-01f, -1.08104028e-01f, 8.17272604e-01f, -1.08915210e-01f, 4.67620850e-01f, -3.18821251e-01f,
  8.38248909e-01f, -1.50856659e-01f, 3.65630805e-01f, -3.52546334e-01f, 5.74474454e-01f, -4.69968289e-01f, -1.01494096e-01f, -2.99879223e-01f, 3.32674950e-01f, 5.06604552e-01f,
  1.09265812e-01f, 6.11015558e-01f, -1.41547859e-01f, 1.18537807e+00f, 2.86871612e-01f, -8.62219110e-02f, -6.32206917e-01f, 9.71639037e-01f, -3.96802694e-01f, 7.17911124e-01f,
  2.21767843e-01f, 1.12924218e+00f, 4.06150013e-01f, -9.46532488e-01f, 7.66191840e-01f, -7.41379380e-01f, 4.26225573e-01f, 7.44430900e-01f, 5.38404644e-01f, 4.93328035e-01f,
  9.38365087e-02f, -3.21016043e-01f, 4.53388929e-01f, -2.35464126e-01f, 4.74434197e-01f, -2.10006237e-01f, 7.23891556e-01f, 4.99844462e-01f, 5.78540981e-01f, -1.15180671e-01f,
  -2.12620869e-01f, 8.69609594e-01f, -4.97316331e-01f, -9.22893062e-02f, 5.88618040e-01f, 2.81906992e-01f, -2.31083751e-01f, 1.03901133e-01f, 5.28350711e-01f, 3.57180655e-01f,
  3.22454780e-01f, 6.45545602e-01f, -1.13014925e+00f, -2.57862657e-01f, 2.89903611e-01f, 7.17683494e-01f, 6.85655653e-01f, -2.12108493e-01f, 5.28504848e-01f, -3.98377925e-01f,
  -2.00043723e-01f, -9.18092012e-01f, 5.01365483e-01f, 4.85968180e-02f, 1.22087419e+00f, 2.94044256e-01f, 6.81189418e-01f, 1.64649501e-01f, -4.13927913e-01f, 1.22700766e-01f,
  -5.10940373e-01f, -3.58200818e-02f, 4.85983551e-01f, 5.27261555e-01f, 6.11035883e-01f, -4.38107908e-01f, 4.71484214e-02f, 3.90181392e-02f, 1.39138192e-01f, -3.72256935e-01f,
  1.40138015e-01f, -1.08038008e-01f, -4.09779930e-03f, -3.73897046e-01f, -2.30785668e-01f, 8.43020201e-01f, -5.76179504e-01f, 1.02459049e+00f, 6.36263728e-01f, 1.76009402e-01f,
  2.16132700e-01f, 4.32241529e-01f, 1.12623966e+00f, -1.11400694e-01f, 4.67283785e-01f, 5.92033900e-02f, 8.97479475e-01f, -4.59333152e-01f, 1.62938088e-01f, 4.40108180e-01f,
  -3.39242108e-02f, -2.77904242e-01f, 1.09717453e+00f, -6.81309462e-01f, 8.15892637e-01f, -2.31542364e-02f, -7.75044441e-01f, -2.07927707e-03f, 3.38091254e-01f, 2.76228134e-02f,
  3.08987409e-01f, 2.94964790e-01f, 9.38014686e-02f, 1.21298385e+00f, 3.55602562e-01f, -1.20646253e-01f, 3.09851706e-01f, 4.39623982e-01f, -9.49690104e-01f, 9.19198543e-02f,
  -5.57543755e-01f, 4.35336530e-02f, 6.25377119e-01f, 4.61802095e-01f, 1.11969694e-01f, 7.00379116e-03f, -2.17787754e-02f, 3.99111718e-01f, 2.10724339e-01f, 5.46602607e-01f,
  5.19865096e-01f, 2.83333898e-01f, 6.25712752e-01f, -3.80622417e-01f, 1.60112157e-01f, 3.35485721e-03f, -6.39097989e-01f, 1.03340834e-01f, -2.44425014e-02f, 5.68488777e-01f,
  -1.54278123e+00f, 6.30340457e-01f, 2.98178270e-02f, -1.21078379e-01f, -1.14363879e-01f, -8.58064830e-01f, 5.20296954e-02f, 9.77320373e-02f, 6.22632913e-02f, -4.82094347e-01f,
  -4.85808909e-01f, 1.02471435e+00f, 1.14269114e+00f, 3.07078324e-02f, 5.06110609e-01f, 1.08756351e+00f, 5.94077170e-01f, 5.76729655e-01f, -2.55479753e-01f, -2.81633765e-01f,
  -2.08239451e-01f, 7.36969531e-01f, 4.28157866e-01f, 5.77354252e-01f, 4.25901413e-01f, -1.58247158e-01f, -1.56597570e-01f, 2.83241183e-01f, -3.19604087e-03f, 5.78586578e-01f,
  8.09066892e-01f, -2.79863805e-01f, 4.68468755e-01f, -1.24389619e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -5.11081159e-01f, 6.86968207e-01f, 1.87972143e-01f, 4.37647581e-01f, 3.43783587e-01f, 4.68061298e-01f, 1.63836256e-01f, 7.70536065e-01f, -1.38406172e-01f, 8.45870376e-01f,
  1.55306250e-01f, 7.53388405e-01f, 5.03924012e-01f, -1.19937398e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  4.90131408e-01f, -6.17030170e-03f, -3.06959689e-01f, -4.60840762e-01f, -1.31220794e+00f, 4.67424244e-01f, -1.90719180e-02f, -2.76827458e-02f, -6.25945032e-02f, -4.11714643e-01f,
  1.79648891e-01f, -2.22966090e-01f, -2.24608183e-02f, 6.24196351e-01f, 3.61841708e-01f, -8.74240100e-01f, 2.98141718e-01f, 9.11657810e-01f, -6.90819919e-01f, 4.34459627e-01f,
  -1.01009607e+00f, 3.41115505e-01f, -1.07282877e+00f, 3.34776968e-01f, 3.18907946e-02f, 3.14213395e-01f, -1.20302296e+00f, -6.08704425e-02f, 1.52466357e-01f, 6.72445178e-01f,
  -2.32385814e-01f, 2.17937738e-01f, 2.83055991e-01f, 3.23135734e-01f, -1.08916235e+00f, 1.39973350e-02f, 2.35982195e-01f, -1.07671190e-02f, 5.14676690e-01f, 3.04033250e-01f,
  -8.60516667e-01f, -8.97492945e-01f, -8.96391690e-01f, 5.60712218e-01f, -6.35444522e-01f, 3.83575797e-01f, -3.45993154e-02f, -9.11794186e-01f, -6.96077406e-01f, -2.40093797e-01f,
  3.57988179e-01f, -1.74555552e+00f, -3.19045745e-02f, -4.57530953e-02f, 2.29891956e-01f, -2.40361750e-01f, -1.09667861e+00f, -1.32632375e+00f, 2.97663718e-01f, -1.47346854e+00f,
  5.97147226e-01f, -3.64634275e-01f, 1.39934629e-01f, 2.06935123e-01f, -1.71781912e-01f, 9.51323807e-01f, -1.26375780e-01f, -6.03094280e-01f, 1.84984043e-01f, 1.81752563e-01f,
  3.26766551e-01f, -6.90079946e-03f, -6.48462325e-02f, -6.64549991e-02f, -1.59609571e-01f, -6.88366964e-02f, -4.84472841e-01f, -2.55139470e-01f, 2.38451496e-01f, 1.91199526e-01f,
  2.80210912e-01f, -8.32401931e-01f, -1.87270224e-01f, 3.87961656e-01f, -8.25511098e-01f, 1.19922072e-01f, -9.87887204e-01f, 7.68502653e-02f, 8.48638825e-03f, 6.08771503e-01f,
  6.33365989e-01f, 6.04569495e-01f, -1.54173642e-01f, -7.42001534e-01f, 1.38354108e-01f, -5.66852510e-01f, 5.00818014e-01f, -4.85336334e-01f, -7.40546882e-01f, 4.59218740e-01f,
  6.90760672e-01f, -1.08642626e+00f, 1.83698744e-01f, -1.04893178e-01f, 1.19115449e-01f, -1.66971266e-01f, -9.46261168e-01f, 6.11094177e-01f, -9.57994938e-01f, -1.78842723e-01f,
  -1.18490386e+00f, -2.05458865e-01f, -8.68396610e-02f, -6.00138247e-01f, 3.18752617e-01f, -5.44199169e-01f, -2.62851454e-02f, -7.32721984e-01f, -2.90657848e-01f, -9.23876822e-01f,
  3.45536619e-01f, 1.95649549e-01f, 1.89572513e-01f, -9.51782703e-01f, -1.17351189e-01f, -3.38370115e-01f, 3.97610784e-01f, 2.67541200e-01f, -9.02537405e-02f, -5.85628748e-01f,
  -5.96591890e-01f, 3.44200224e-01f, -2.39221334e-01f, -8.28085363e-01f, 6.62888229e-01f, 2.02678353e-01f, -3.33198220e-01f, 2.98457861e-01f, 7.64882863e-01f, -1.12087607e+00f,
  2.57530868e-01f, -3.52712303e-01f, -6.08277678e-01f, -2.52097547e-02f, -3.37914735e-01f, -8.35508466e-01f, 3.42148215e-01f, 3.88886660e-01f, 2.26127341e-01f, -4.92375225e-01f,
  1.77282766e-01f, -1.14094090e+00f, 1.94059074e-01f, -3.63230348e-01f, -3.43309492e-01f, 2.67242402e-01f, -1.01805854e+00f, 2.28393495e-01f, 5.12211859e-01f, -8.86754215e-01f,
  -6.78863406e-01f, 6.38275892e-02f, 8.02847028e-01f, 2.09355112e-02f, -2.19589278e-01f, -4.43055481e-01f, -1.36464739e+00f, 3.70631784e-01f, -9.17328894e-01f, -6.88835621e-01f,
  4.02031869e-01f, -1.20291913e+00f, -9.01543677e-01f, -7.33121097e-01f, 3.90652418e-02f, 4.19294924e-01f, -7.27327466e-02f, 1.02894223e+00f, 2.28973135e-01f, -6.74227178e-01f,
  4.28569645e-01f, -3.89615446e-01f, 3.77769589e-01f, -4.79969472e-01f, -3.63800734e-01f, 2.29742974e-02f, -6.51528239e-01f, -3.94182473e-01f, 7.02452064e-01f, 4.62551236e-01f,
  -1.07278395e+00f, -1.17422350e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.63048431e-01f, 1.69261083e-01f, 1.64519429e-01f, -6.01712584e-01f, -1.72844991e-01f, 1.07361183e-01f, -9.95050836e-03f, -3.58075798e-01f, 1.33577958e-02f, -2.33051300e-01f,
  -6.24020875e-01f, 5.31472228e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    