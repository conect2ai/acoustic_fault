/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.29190889e-02f, 1.82422310e-01f, 9.07083452e-02f, 9.29121375e-02f, 2.55426109e-01f, 1.60793737e-01f, 2.18354478e-01f, -6.64086267e-02f, -1.07949302e-02f, 2.22253665e-01f,
  2.34628707e-01f, -1.50936246e-02f, -6.26273379e-02f, -4.57149893e-02f, -9.88466516e-02f, 2.36273333e-02f, -4.08718782e-03f, -9.36632752e-02f, -2.43979804e-02f, 1.75539218e-02f,
  1.13276310e-01f, -9.18188542e-02f, -3.03271055e-01f, -1.14978112e-01f, 4.50965054e-02f, -6.67278394e-02f, 4.13103634e-03f, -2.19544731e-02f, -3.29010673e-02f, 1.34423718e-01f,
  1.45024419e-01f, 3.10000330e-01f, 1.28794938e-01f, 1.34535223e-01f, 2.44405612e-01f, 1.61330581e-01f, 1.79781973e-01f, 9.02542248e-02f, 8.80766809e-02f, 4.84217703e-02f,
  2.32439294e-01f, 9.77344289e-02f, 1.75647989e-01f, 9.13170129e-02f, 6.59341514e-02f, 1.40052855e-01f, -1.30940443e-02f, -1.16934413e-02f, 7.10711926e-02f, 9.23740193e-02f,
  1.25665963e-01f, 1.88436002e-01f, 1.49294481e-01f, -4.80525270e-02f, -3.14226002e-02f, 1.91886976e-01f, 2.01168098e-02f, 2.85149906e-02f, -2.93711037e-03f, -5.34189492e-03f,
  -1.21606119e-01f, -9.52961817e-02f, -2.26798430e-02f, -1.34448603e-01f, -8.14018622e-02f, -6.03222251e-02f, -2.63758027e-03f, -1.33066103e-01f, -7.61378780e-02f, -6.14509284e-02f,
  5.62082268e-02f, -6.12526648e-02f, -4.39326279e-02f, -5.78106940e-03f, -1.44146889e-01f, -1.05388030e-01f, -9.70275328e-02f, -9.02016014e-02f, -6.16777018e-02f, -6.21580482e-02f,
  -7.24007189e-02f, -3.86106409e-02f, -4.09784243e-02f, -1.03696242e-01f, -6.34879693e-02f, 3.16398926e-02f, -1.26908168e-01f, -4.19516899e-02f, -5.92643842e-02f, -1.38255179e-01f,
  -1.28611416e-01f, 1.58581108e-01f, 1.34837791e-01f, 2.17913203e-02f, 2.13452596e-02f, 8.41745213e-02f, 7.12147132e-02f, 4.11505923e-02f, 1.34776860e-01f, 6.74887374e-02f,
  1.02087080e-01f, 9.88430306e-02f, 1.55796781e-01f, 7.79641271e-02f, 1.77244544e-01f, 7.22301081e-02f, 4.62936237e-02f, 9.17034000e-02f, 1.05900958e-01f, 1.39402477e-02f,
  -4.64493521e-02f, -1.65200327e-02f, -5.61572276e-02f, 2.67392136e-02f, 2.44118944e-02f, 1.10952131e-01f, 2.17867270e-02f, 4.49496843e-02f, -3.25407200e-02f, 1.32412352e-02f,
  -9.29601192e-02f, 9.61527899e-02f, 1.13089524e-01f, -1.17457606e-01f, 2.83265878e-02f, 3.44683445e-04f, 2.60447301e-02f, -2.04331130e-02f, -1.24201708e-01f, 4.34219986e-02f,
  -7.61947315e-03f, 1.67999715e-01f, 1.34148657e-01f, 1.25689104e-01f, 1.34161741e-01f, 1.25800774e-01f, 9.27286074e-02f, 8.17863867e-02f, -1.46343233e-02f, -5.21783419e-02f,
  -2.33720578e-02f, -1.16717648e-02f, -3.20575163e-02f, -9.91143938e-03f, 1.11699842e-01f, 8.78297389e-02f, 4.71724346e-02f, 1.16712920e-01f, 1.85577199e-01f, 3.48974079e-01f,
  1.55255497e-01f, 9.66866985e-02f, 7.51049370e-02f, 4.16809134e-03f, 1.00337364e-01f, 1.14801846e-01f, 9.58568230e-03f, 1.39376685e-01f, 6.95847943e-02f, 1.06462672e-01f,
  1.74791619e-01f, 7.94517919e-02f, 6.71459734e-02f, 7.69924447e-02f, 7.51543120e-02f, 1.27775863e-01f, -2.06844211e-02f, 9.23799425e-02f, 1.64301664e-01f, 5.10361120e-02f,
  1.19332865e-01f, 1.09754257e-01f, 2.13265702e-01f, 6.25727326e-02f, 1.09350331e-01f, 1.36181355e-01f, 1.09691575e-01f, 7.11421221e-02f, 2.32786462e-01f, 2.57214665e-01f,
  8.48890245e-02f, 1.52264610e-02f, -2.71822102e-02f, -9.74657089e-02f, -3.10097765e-02f, -4.09571603e-02f, 1.97602492e-02f, -6.32817000e-02f, -8.12976733e-02f, -1.22244053e-01f,
  -1.07911102e-01f, -5.90664819e-02f, -1.60734449e-02f, -1.08884752e-01f, -6.33095354e-02f, -1.28462881e-01f, -2.31314041e-02f, -4.60911021e-02f, 1.43777300e-02f, -3.55125852e-02f,
  -4.58210371e-02f, 1.71864498e-02f, -2.15829536e-02f, 4.23301049e-02f, 1.46156149e-02f, -4.68283482e-02f, -3.03516239e-02f, -1.95203349e-01f, -8.79653171e-02f, -8.60427767e-02f,
  -5.24672046e-02f, 7.70121291e-02f, 9.28663239e-02f, 1.52111441e-01f, 2.82089170e-02f, 7.73846135e-02f, 1.41677231e-01f, 3.68953533e-02f, 7.43253976e-02f, 1.31319370e-02f,
  8.95076692e-02f, 9.37698334e-02f, 1.43921942e-01f, 9.08742398e-02f, 1.56504184e-01f, 9.61199477e-02f, 1.08950712e-01f, 2.37066329e-01f, 3.82150221e-03f, -1.17005389e-02f,
  7.44294599e-02f, 1.13593653e-01f, 1.76930889e-01f, 2.45777100e-01f, 9.58345309e-02f, 1.25687078e-01f, 6.97514787e-02f, 3.67191285e-02f, 1.37490630e-01f, 3.06407828e-02f,
  2.57673979e-01f, 8.15371796e-02f, -8.52556303e-02f, 3.90808105e-01f, 1.77516222e-01f, 4.22595581e-03f, -1.47142619e-01f, -3.31261791e-02f, 3.52800963e-03f, -1.89439848e-01f,
  -2.78428923e-02f, 7.52242580e-02f, 7.73816630e-02f, 5.99781163e-02f, -3.50369252e-02f, -1.06381401e-01f, 1.07422568e-01f, 1.41646951e-01f, 1.82920814e-01f, 1.26245424e-01f,
  1.90992683e-01f, 2.14675933e-01f, 1.34123206e-01f, 4.82752994e-02f, 1.21481098e-01f, -2.89534847e-03f, -1.91292748e-01f, 6.58952594e-02f, 7.48652443e-02f, 1.35867044e-01f,
  -5.55427969e-02f, 2.84587771e-01f, 4.25761886e-04f, 2.50602156e-01f, 2.40539405e-02f, -4.06990871e-02f, 5.28039075e-02f, 6.02577068e-02f, 1.11778334e-01f, 8.18840414e-02f,
  1.11778677e-01f, 3.15157976e-03f, 2.24134356e-01f, 4.34951223e-02f, 1.97847098e-01f, 2.16268823e-01f, 1.15204319e-01f, 1.81695819e-01f, 1.67017967e-01f, 1.59015805e-01f,
  2.99008399e-01f, 3.37176532e-01f, 1.70589596e-01f, 1.81211933e-01f, 1.09243177e-01f, 1.86958671e-01f, 1.82945088e-01f, 1.29377261e-01f, 8.24811682e-02f, 1.15899250e-01f,
  4.97966819e-02f, -5.70170321e-02f, -4.74305376e-02f, -7.51193911e-02f, -1.17362663e-02f, -7.18422756e-02f, 3.07231415e-02f, -3.14317569e-02f, 3.47681232e-02f, -2.32092384e-02f,
  3.78157422e-02f, 2.72981301e-02f, -7.56527334e-02f, -1.05430998e-01f, -1.29864261e-01f, 6.71078786e-02f, -5.35584651e-02f, 4.13911529e-02f, -1.21411607e-01f, -5.72965667e-02f,
  -1.64184064e-01f, -7.90053159e-02f, -1.64606020e-01f, 2.76993345e-02f, -2.82686874e-02f, -1.99970091e-03f, -1.40934780e-01f, -8.35976228e-02f, 3.32325287e-02f, 1.22358119e-02f,
  -1.26332447e-01f, 6.91595972e-02f, -2.20219959e-02f, -3.24420375e-03f, -1.85821392e-02f, -3.14072743e-02f, 1.18697416e-02f, 6.75087124e-02f, 8.54465216e-02f, 7.01748952e-03f,
  1.59240574e-01f, 3.69773135e-02f, 1.85707718e-01f, 1.33782057e-02f, 3.53946164e-02f, 6.69697896e-02f, -7.48142898e-02f, 1.21899962e-01f, -7.42488122e-03f, 6.14860579e-02f,
  1.18873999e-01f, -6.50236160e-02f, -7.18722045e-02f, -3.35966423e-02f, 4.54325415e-02f, 3.63079347e-02f, -4.47038114e-02f, -3.63996327e-02f, -4.56854999e-02f, -1.90647185e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.24739401e-01f, -1.62115663e-01f, -5.48711479e-01f, -8.44310969e-02f, -4.11801010e-01f, -9.91865098e-02f, 9.40109268e-02f, 9.06681120e-02f, 1.77010849e-01f, 7.97469392e-02f,
  8.25365260e-03f, -5.54333031e-02f, -1.10606544e-01f, -3.43966577e-03f, 2.14390293e-01f, 2.99361590e-02f, -2.31672540e-01f, -1.24624863e-01f, -8.05714428e-02f, 4.60929237e-02f,
  2.33098865e-01f, 9.25669912e-03f, 1.79588109e-01f, 1.04527287e-01f, -3.71307313e-01f, -2.79456168e-01f, -2.83331215e-01f, -3.23582143e-01f, -2.38786891e-01f, -6.55334473e-01f,
  -4.66071993e-01f, -3.63448888e-01f, -8.60625952e-02f, 4.72226962e-02f, -1.11147411e-01f, 1.26978949e-01f, 6.83824206e-03f, 3.83847542e-02f, 1.51841879e-01f, 4.51299623e-02f,
  -2.16594726e-01f, 9.83019099e-02f, -1.30481675e-01f, -7.22736120e-02f, -1.06702767e-01f, -6.08175136e-02f, 1.36692107e-01f, 1.28003284e-01f, 1.28725529e-01f, 7.84568712e-02f,
  3.90987396e-02f, 2.71311514e-02f, -2.42699951e-01f, -2.18840167e-02f, -1.07050044e-02f, -1.86724588e-01f, -1.90471798e-01f, -2.81463832e-01f, -1.27210006e-01f, -1.95374638e-01f,
  1.57155603e-01f, -1.33370116e-01f, 7.03572929e-02f, 1.10577933e-01f, 2.26924524e-01f, 3.83848266e-04f, -9.86393169e-02f, 1.02515846e-01f, 1.90966129e-02f, 2.00408753e-02f,
  -1.32064996e-02f, 1.00500911e-01f, 2.69483905e-02f, -1.22782206e-02f, -5.39646856e-03f, 2.30055451e-02f, -3.94553179e-03f, 4.21831235e-02f, -1.87220238e-02f, 7.95908347e-02f,
  -4.21532802e-02f, -4.84085716e-02f, -1.30444139e-01f, 6.36333739e-03f, -9.72328056e-03f, -6.31521689e-03f, -4.13812585e-02f, -1.53029887e-02f, -7.95771629e-02f, -2.75667533e-02f,
  -6.32967129e-02f, 9.50118378e-02f, -2.29131371e-01f, 7.77746411e-03f, 2.00008595e-04f, 1.25663146e-01f, -1.27362058e-01f, 8.63420889e-02f, 1.24921901e-02f, 2.98849624e-02f,
  -1.14822045e-01f, 1.04713872e-01f, -1.89320564e-01f, -8.79247189e-02f, -2.93293484e-02f, -2.58475356e-02f, 2.03467980e-01f, -1.73025757e-01f, 5.94676286e-02f, 1.19740395e-02f,
  1.41534373e-01f, 2.06439972e-01f, 1.07460789e-01f, -2.85507143e-02f, -7.18079284e-02f, -7.35329613e-02f, 1.08069312e-02f, -1.55598998e-01f, 8.48839954e-02f, 2.35964060e-01f,
  4.89795804e-01f, -2.75854677e-01f, 1.86758116e-01f, 2.22764865e-01f, 3.41262221e-02f, 1.66117787e-01f, -1.97090190e-02f, 6.87050521e-02f, 2.48902515e-01f, 1.56361967e-01f,
  -3.19914753e-03f, 2.38152847e-01f, 2.52241343e-01f, 2.71143436e-01f, 1.31197944e-01f, 1.81060597e-01f, 1.30884916e-01f, 3.17000031e-01f, 1.84186980e-01f, 1.40424877e-01f,
  -4.31676283e-02f, -5.31476848e-02f, -2.60469634e-02f, -7.28169363e-03f, -8.30894783e-02f, 1.88389659e-01f, -2.33851839e-02f, 1.84164234e-02f, -6.20021373e-02f, 1.27436683e-01f,
  1.55880541e-01f, -3.47243845e-02f, 3.02512944e-01f, 7.28115290e-02f, -9.59640965e-02f, -1.25841156e-01f, 1.06079884e-01f, -4.56614494e-02f, -1.14291705e-01f, 2.30352413e-02f,
  -2.20664889e-02f, -1.69083208e-01f, -1.22229792e-01f, -1.12075031e-01f, -2.45780438e-01f, -9.85732153e-02f, -7.13031068e-02f, 1.80975035e-01f, 1.36175707e-01f, -1.07561902e-03f,
  -1.07596584e-01f, -7.60373846e-02f, 1.84360608e-01f, 1.34898201e-01f, 8.05786997e-02f, 7.15047792e-02f, -5.86219616e-02f, 1.61170606e-02f, 9.80329886e-02f, 6.53236583e-02f,
  1.95981503e-01f, 3.36093679e-02f, 6.28628582e-03f, 1.15501201e-02f, 6.32687286e-02f, 1.99587971e-01f, 1.26592843e-02f, -8.90962780e-02f, 5.99143542e-02f, -1.73767433e-01f,
  -3.01915570e-03f, 1.10389352e-01f, 1.18311405e-01f, 2.00436115e-01f, -2.04410106e-02f, 3.64084132e-02f, 3.66743580e-02f, -1.61782250e-01f, -4.72148620e-02f, -8.39231163e-02f,
  -1.04703762e-01f, 5.49243055e-02f, -1.64078966e-01f, -7.07243159e-02f, -3.26496474e-02f, 5.02394773e-02f, -7.35011697e-02f, -1.15449600e-01f, -1.15626052e-01f, -5.58971316e-02f,
  2.57923931e-01f, 4.43424918e-02f, 1.14445545e-01f, 3.83609496e-02f, -1.73209995e-01f, -1.97932318e-01f, 7.67322183e-02f, -1.52427390e-01f, -2.53305614e-01f, 3.83906290e-02f,
  -1.72363490e-01f, -4.65595014e-02f, -1.57202318e-01f, -1.59800634e-01f, -6.99831769e-02f, -1.15948819e-01f, -1.98651627e-01f, 1.02466233e-01f, -5.89615256e-02f, -1.03004023e-01f,
  -1.70276284e-01f, 2.59042263e-01f, 4.48177725e-01f, 2.78713971e-01f, -4.97446992e-02f, 3.33280087e-01f, 6.32971898e-02f, 1.05809860e-01f, 1.27691507e-01f, 2.20236897e-01f,
  -3.70674720e-03f, -2.91777194e-01f, -2.91872680e-01f, -2.71746106e-02f, 3.50943319e-02f, 1.64538145e-01f, -5.71671985e-02f, 2.30213255e-01f, 8.42230693e-02f, -3.19541603e-01f,
  5.69201931e-02f, 1.30663171e-01f, -7.53329173e-02f, -8.12106207e-03f, -6.04558252e-02f, -4.60015386e-01f, -4.07003969e-01f, -2.45885834e-01f, 1.63513571e-01f, 2.54554719e-01f,
  2.69662917e-01f, 2.96626543e-03f, 9.43662599e-02f, 1.72335282e-01f, 5.41466521e-03f, 2.31964793e-02f, -1.47618070e-01f, -4.28022034e-02f, 8.91363993e-02f, -4.17849988e-01f,
  -4.45602238e-01f, 1.96457952e-01f, -3.43093043e-03f, 1.34962842e-01f, -1.71797544e-01f, 1.31633177e-01f, 1.59297287e-01f, -1.97020784e-01f, 1.45455347e-02f, -2.13312209e-01f,
  -4.96916734e-02f, -7.01639727e-02f, 5.12792245e-02f, 7.20945373e-02f, 7.69160092e-02f, -3.37922312e-02f, -1.40030071e-01f, -8.87189582e-02f, -1.54662598e-03f, -1.05214827e-02f,
  -2.81630717e-02f, 2.96972822e-02f, -1.00507312e-01f, -8.33699852e-03f, 1.20080225e-01f, -1.08673885e-01f, 6.76823109e-02f, 2.31333449e-01f, -1.99862253e-02f, -2.70679265e-01f,
  7.55327344e-02f, 2.37373486e-02f, -6.57188222e-02f, 6.76855147e-02f, 1.39826257e-02f, -6.59070909e-02f, 4.02145982e-02f, -1.69046760e-01f, 8.65011662e-02f, -1.22266196e-01f,
  -1.18791401e-01f, -1.04701318e-01f, -8.00568014e-02f, -1.06925346e-01f, -6.99307099e-02f, -3.49958986e-02f, 1.19430143e-02f, -1.07664995e-01f, 6.48111552e-02f, -1.57492198e-02f,
  -5.23042940e-02f, 3.67907546e-02f, -3.86233330e-02f, 1.14592843e-01f, -2.29285825e-02f, -8.04796740e-02f, 1.84103139e-02f, -5.74081540e-02f, 1.09244166e-02f, -8.95307586e-02f,
  -1.70585513e-01f, 4.94438112e-02f, -6.87328205e-02f, -1.04636791e-04f, -1.00758910e-01f, -1.36476815e-01f, -1.09052397e-01f, -2.27931023e-01f, -5.51320380e-03f, 1.45981871e-02f,
  -3.82544212e-02f, -3.91758792e-02f, -1.59710422e-02f, 4.34795482e-04f, 1.97445303e-01f, -6.37040809e-02f, -1.79114230e-02f, -9.87157598e-02f, 1.45156321e-03f, 9.36763883e-02f,
  -1.60255343e-01f, -2.27409810e-01f, -1.84713736e-01f, 5.41475788e-03f, -2.19071321e-02f, -3.62333246e-02f, -4.18729410e-02f, 3.61937545e-02f, 5.02918735e-02f, -1.67287961e-01f,
  -2.35294908e-01f, 8.08334202e-02f, -9.37044919e-02f, 1.54610738e-01f, 3.38047683e-01f, 2.56296098e-01f, 3.31077397e-01f, 9.95990112e-02f, -4.77317870e-02f, 2.09046043e-02f,
  8.50939900e-02f, -5.20232320e-02f, -3.57815139e-02f, 5.94478138e-02f, 2.40761824e-02f, 1.16172843e-01f, 6.95628822e-02f, 1.94404013e-02f, -1.51499823e-01f, 1.34662688e-01f,
  3.04708667e-02f, -1.21282734e-01f, -3.72863144e-01f, -1.49912879e-01f, 6.53866157e-02f, 5.17478324e-02f, -5.57470098e-02f, 3.75561453e-02f, 4.25003329e-03f, 1.53577060e-01f,
  1.68034360e-02f, 5.36641479e-02f, -1.55852184e-01f, -1.23644650e-01f, 5.59204295e-02f, -9.40011293e-02f, -1.07001096e-01f, -2.46454269e-01f, 1.64439417e-02f, -1.55682251e-01f,
  2.36825012e-02f, -1.40633211e-01f, 1.46030739e-01f, -9.32801068e-02f, -1.02135465e-01f, -9.50471219e-03f, 2.53867973e-02f, -1.33591324e-01f, -2.91805208e-01f, 2.24607754e-02f,
  1.43358663e-01f, -1.26332447e-01f, 1.16881458e-02f, 1.32377502e-02f, -8.83632153e-02f, 1.87464487e-02f, -1.90865785e-01f, -8.53219554e-02f, -2.63010085e-01f, -3.46629232e-01f,
  -1.30833939e-01f, 1.71541441e-02f, -6.15503043e-02f, 4.23490629e-02f, -5.79196922e-02f, -7.23663047e-02f, 1.47508495e-02f, -5.46003766e-02f, 1.16237057e-02f, -1.51237577e-01f,
  3.75475101e-02f, -1.26289073e-02f, -2.88496874e-02f, -1.58905778e-02f, -3.05596273e-02f, -1.04295857e-01f, 1.81025952e-01f, -2.55030580e-02f, -3.37361991e-02f, -1.16166681e-01f,
  -4.16307971e-02f, 1.07260145e-01f, -2.04576105e-01f, 1.38134226e-01f, 1.09378688e-01f, 6.32105097e-02f, -9.43146050e-02f, -1.20306924e-01f, -1.97085544e-01f, -1.65703341e-01f,
  -3.06812525e-01f, -2.82294620e-02f, 4.41413075e-02f, 1.06797908e-02f, 1.69031788e-02f, -5.46017587e-02f, 8.38408098e-02f, 2.01617375e-01f, 7.21583366e-02f, 1.47674695e-01f,
  -2.51116753e-02f, 8.98354352e-02f, -9.15700346e-02f, -4.16764338e-03f, -1.14650249e-01f, -4.18098979e-02f, -1.78057812e-02f, 1.13136172e-01f, -8.95759687e-02f, -8.30422565e-02f,
  4.31735031e-02f, -2.34840006e-01f, -2.46697307e-01f, -3.73434909e-02f, -2.24636689e-01f, -7.13531524e-02f, -2.78525472e-01f, -2.14559704e-01f, -3.52931917e-01f, -2.70545810e-01f,
  -4.40430909e-01f, 7.76414797e-02f, 2.61116832e-01f, -6.35912716e-02f, 9.27988738e-02f, 3.57939191e-02f, 7.54142180e-02f, -1.29464120e-01f, -1.79577485e-01f, -7.61761889e-02f,
  -2.65194744e-01f, -4.32285786e-01f, -1.25864163e-01f, -4.91787940e-02f, -4.74671610e-02f, 1.86010674e-01f, 2.72971213e-01f, 2.47165918e-01f, -1.27725974e-01f, -7.54749104e-02f,
  -7.08852038e-02f, 8.40258449e-02f, 2.19106022e-02f, 1.03457170e-02f, -4.30169143e-02f, -1.52281463e-01f, 2.09396556e-01f, 5.12518696e-02f, 1.64575979e-01f, 1.79582730e-01f,
  1.89543925e-02f, 2.01517448e-01f, -2.18485557e-02f, -2.81586915e-01f, 5.30070066e-02f, -8.52717757e-02f, -1.22600585e-01f, 7.29187503e-02f, -7.08534420e-02f, 4.25955318e-02f,
  -9.35340673e-02f, -1.52991593e-01f, -1.26990512e-01f, -7.02543929e-02f, -2.52989773e-02f, 2.87375576e-03f, 4.99949679e-02f, 1.58078700e-01f, 1.13149047e-01f, -1.04442807e-02f,
  -3.80092934e-02f, 7.92195275e-02f, 7.26766884e-02f, 7.06379414e-02f, 6.53703436e-02f, -5.44389635e-02f, -8.62485319e-02f, -3.25803570e-02f, 1.24962784e-01f, -3.07068378e-01f,
  -6.54731244e-02f, 4.40315716e-02f, 1.19229697e-01f, 1.12024479e-01f, -9.90351960e-02f, -1.05601870e-01f, 9.82753336e-02f, 2.98031289e-02f, 1.38190538e-01f, 8.65250267e-03f,
  8.89908150e-02f, 5.16314805e-02f, 2.66858265e-02f, 6.75928742e-02f, -1.01294354e-01f, 1.46335522e-02f, 1.63636468e-02f, 7.72310048e-02f, 4.07036347e-03f, 3.88179049e-02f,
  6.37072176e-02f, 9.20305699e-02f, -2.47562677e-02f, 6.36316254e-04f, 4.11531776e-02f, 3.61966677e-02f, -2.41516829e-02f, -6.26552105e-02f, 1.21212989e-01f, 9.63705853e-02f,
  -2.27014408e-01f, 3.78692806e-01f, -1.48330569e-01f, -8.54977220e-02f, 1.19905047e-01f, 9.29879695e-02f, 9.96101499e-02f, 1.51024655e-01f, 1.53117269e-01f, -9.42377672e-02f,
  -1.68443993e-01f, -4.35629971e-02f, 5.39769977e-02f, -1.36936903e-01f, -3.73573631e-01f, -8.20653960e-02f, 3.81992850e-03f, -1.92550831e-02f, 3.96092646e-02f, -5.82476631e-02f,
  -1.45677850e-01f, -7.36191198e-02f, -2.11602494e-01f, -1.93260834e-01f, -1.23055913e-01f, -1.92610338e-01f, -5.05011976e-02f, -1.94779053e-01f, -5.87571003e-02f, -5.11254370e-01f,
  -4.34959888e-01f, 1.49473161e-01f, -1.65184110e-01f, -4.45125774e-02f, 4.02486175e-01f, 1.08675018e-01f, -2.16868781e-02f, -3.00376654e-01f, -1.78311393e-01f, 7.73255825e-02f,
  2.98364073e-01f, 9.22053754e-02f, 7.62269348e-02f, -1.90090034e-02f, -2.53594458e-01f, 1.46329477e-01f, 2.46139079e-01f, -6.77300319e-02f, -2.54057884e-01f, 2.58425791e-02f,
  2.83621371e-01f, -1.57677174e-01f, -2.29287431e-01f, -1.34151787e-01f, 9.49742869e-02f, 4.58845012e-02f, -1.02271815e-03f, 1.39522910e-01f, 1.50477916e-01f, 3.97200018e-01f,
  1.04139373e-01f, -1.38356417e-01f, -3.05345561e-02f, 1.54645205e-01f, 2.47093625e-02f, -1.81149140e-01f, -1.11112349e-01f, -2.03643501e-01f, -9.91158746e-03f, -7.77439475e-02f,
  9.81393605e-02f, 1.33795599e-02f, 9.77215096e-02f, 6.44216686e-02f, -1.05554275e-01f, -1.13654062e-01f, -1.22003026e-01f, -2.94333428e-01f, -3.21603358e-01f, -1.48334190e-01f,
  4.21882212e-01f, 2.73822337e-01f, -4.52454276e-02f, -1.64794087e-01f, -1.90121457e-01f, 1.67560801e-02f, 6.96750544e-03f, 3.50476243e-02f, -2.03802541e-01f, -3.01551912e-02f,
  -4.94086556e-02f, 5.28514944e-02f, 1.43239245e-01f, -5.37865702e-03f, 5.57211973e-02f, 3.32317911e-02f, 6.57165349e-02f, 8.33496898e-02f, 3.94331478e-02f, -6.44740835e-02f,
  6.45814687e-02f, 3.15679400e-03f, 1.84201580e-02f, -9.71184224e-02f, -1.19324230e-01f, -2.61441842e-02f, 4.08138968e-02f, 7.97821581e-03f, -1.02998845e-01f, 6.96697459e-02f,
  -6.71427995e-02f, -1.71494503e-02f, 5.17843291e-03f, -1.21351503e-01f, 3.16104330e-02f, 1.17927240e-02f, 3.94273829e-03f, 3.89059223e-02f, -3.68853994e-02f, 8.67014602e-02f,
  -3.26706231e-01f, -1.50924465e-02f, 4.03673574e-02f, -5.66716231e-02f, 1.43055424e-01f, 1.20274751e-02f, 8.12871531e-02f, -6.07416704e-02f, 1.27277337e-02f, -9.87085700e-02f,
  -6.29789904e-02f, -7.83491284e-02f, -9.03215632e-02f, -4.23973538e-02f, 1.53253917e-02f, 2.51061674e-02f, 1.25542551e-01f, 1.27358604e-02f, -7.28249922e-02f, -1.11552581e-01f,
  -7.67502785e-02f, 9.62191494e-04f, -1.18744723e-01f, -1.01545960e-01f, -5.17610312e-02f, -1.04968235e-01f, -6.37953356e-02f, -3.57552916e-02f, -3.60081196e-01f, -1.77301243e-01f,
  5.32832980e-01f, -4.86871123e-01f, -3.30108315e-01f, 1.37380183e-01f, -2.36423507e-01f, -1.64066955e-01f, -4.77092415e-01f, 5.62420934e-02f, 8.18208046e-03f, -3.47968906e-01f,
  -3.92209515e-02f, 4.24702436e-01f, 2.06210360e-01f, 2.56096601e-01f, 3.64167750e-01f, -5.07930875e-01f, -3.82913649e-01f, 2.04346344e-01f, 4.14003819e-01f, 1.32534713e-01f,
  6.47064596e-02f, -1.46464929e-02f, 2.09892958e-01f, 2.23315239e-01f, -3.28723848e-01f, 1.04714364e-01f, -4.32458609e-01f, -1.45098001e-01f, -1.20893337e-01f, -4.06194001e-01f,
  -3.88521135e-01f, 2.05198437e-01f, 1.77727312e-01f, 2.45289013e-01f, -1.78699806e-01f, 3.10406350e-02f, -9.84197110e-03f, -2.72485167e-02f, -6.71693869e-03f, -1.28321514e-01f,
  6.14943504e-02f, 8.51379149e-03f, 9.10834372e-02f, -1.98416337e-02f, -1.43399939e-01f, 4.76144291e-02f, -1.70671642e-01f, 7.02681094e-02f, 4.34320699e-03f, -1.00262299e-01f,
  -1.00947998e-01f, -1.10082388e-01f, -1.15965694e-01f, -1.58945411e-01f, -2.95326654e-02f, 5.78222945e-02f, -1.49686441e-01f, -6.99733123e-02f, -1.40419113e-03f, -4.72882479e-01f,
  -1.30946547e-01f, -4.13381718e-02f, 1.95764005e-02f, 2.57730614e-02f, 3.59401181e-02f, -2.40275953e-02f, 1.08101040e-01f, 5.70575222e-02f, 1.62001196e-02f, -7.07150996e-02f,
  2.99835298e-03f, 2.84327641e-02f, 1.31580690e-02f, -1.07082203e-02f, -1.04229711e-01f, 1.19586121e-02f, 5.00131696e-02f, -3.49123850e-02f, 5.92944808e-02f, 4.50541712e-02f,
  1.23519339e-01f, -7.02900440e-02f, -6.73978850e-02f, 6.79534972e-02f, -3.50019969e-02f, -6.15057126e-02f, 8.17270577e-03f, 3.69280502e-02f, 4.04034145e-02f, 3.62996086e-02f,
  -1.11461528e-01f, 2.42793381e-01f, -1.52301461e-01f, 6.97540641e-02f, -8.61901324e-03f, -8.50942582e-02f, -8.30678865e-02f, 7.72052556e-02f, 1.07051499e-01f, 3.32797058e-02f,
  5.91090694e-02f, -2.97971885e-03f, -6.45069480e-02f, 7.67828291e-03f, 1.20771535e-01f, -1.35403890e-02f, -8.98788646e-02f, 2.32344819e-03f, 6.00908361e-02f, -1.08626418e-01f,
  -1.87576979e-01f, -2.27897149e-02f, 1.05654724e-01f, 5.71769616e-03f, 3.66609059e-02f, 1.72777280e-01f, -6.07889704e-02f, -1.06649220e-01f, 1.79676488e-01f, -2.34079257e-01f,
  -2.66164690e-01f, 1.19183041e-01f, -1.14781139e-02f, 1.68565676e-01f, 2.75283754e-01f, 4.74242046e-02f, -2.01003075e-01f, -7.72465020e-03f, 1.97808072e-01f, -1.14038594e-01f,
  9.16800722e-02f, -9.69775859e-03f, -1.44136325e-01f, -2.65993565e-01f, -5.57759821e-01f, -3.23862046e-01f, -2.78623849e-01f, -4.55027312e-01f, -3.49375814e-01f, -1.13088191e-01f,
  -5.34760170e-02f, -1.04825445e-01f, -2.74033934e-01f, -1.52085721e-01f, 4.26544249e-02f, -8.86303410e-02f, 1.00691915e-02f, -2.70442702e-02f, -6.11788295e-02f, -1.10520469e-02f,
  -9.86029580e-02f, 1.02715448e-01f, 8.99256915e-02f, 2.11079847e-02f, 4.71301749e-02f, 4.67223115e-02f, -9.08600166e-02f, 9.60175246e-02f, 1.19577557e-01f, -4.21122974e-03f,
  6.96106851e-02f, -9.14970115e-02f, 1.32263839e-01f, -1.57608129e-02f, -1.20027915e-01f, -2.04763681e-01f, 2.51844879e-02f, -7.43480921e-02f, -3.02958279e-03f, 2.11968012e-02f,
  8.14050213e-02f, 1.21772476e-01f, 1.55255413e-02f, 8.61789391e-04f, -5.94096445e-02f, -3.27664018e-02f, -1.32194817e-01f, -2.73830034e-02f, -2.15278164e-01f, -1.62387028e-01f,
  -4.98184636e-02f, 1.05504304e-01f, 2.15948932e-02f, 7.34185800e-02f, -3.48262303e-02f, 9.22912583e-02f, 2.80977208e-02f, -1.90056056e-01f, -3.83108519e-02f, 1.77365113e-02f,
  -1.09054781e-02f, 1.06858313e-01f, -7.90995434e-02f, -7.75457546e-02f, -3.70498784e-02f, 1.17796259e-02f, -5.08845486e-02f, -1.82987645e-01f, -1.70736432e-01f, 5.46669634e-03f,
  -6.76451996e-02f, 3.25573049e-02f, 1.21309653e-01f, -2.43985020e-02f, -1.00651547e-01f, -7.90650100e-02f, -1.17986925e-01f, -4.69381884e-02f, -5.41666076e-02f, -1.88229084e-02f,
  -1.71402633e-01f, -9.13409423e-03f, -7.42040938e-05f, -1.29870743e-01f, 8.58961120e-02f, 7.79342130e-02f, 5.74990548e-02f, -9.00201052e-02f, 1.14218533e-01f, -3.87685113e-02f,
  -2.71065123e-02f, -4.85262945e-02f, -9.11353081e-02f, 3.01122740e-02f, -4.74032350e-02f, -2.00911969e-01f, -1.94603503e-01f, -2.68865582e-02f, -9.74561423e-02f, 3.95731442e-02f,
  -1.27352655e-01f, -3.46065372e-01f, -2.65248746e-01f, -2.88151782e-02f, -1.85520928e-02f, -2.64761746e-01f, -2.97760129e-01f, -1.79154098e-01f, -3.38772893e-01f, -4.75685090e-01f,
  4.58046824e-01f, 7.81590864e-02f, 1.36292294e-01f, -3.48664261e-03f, -3.91718835e-01f, -3.23697418e-01f, -4.51848924e-01f, -2.30720207e-01f, -6.56791702e-02f, -3.83121446e-02f,
  -1.90121517e-01f, -1.39602358e-02f, -7.77995065e-02f, 2.09657401e-02f, 1.13211267e-01f, 2.76361734e-01f, 2.15121269e-01f, 3.43513757e-01f, 1.16635650e-01f, -3.43930013e-02f,
  -7.47286379e-02f, 1.97443917e-01f, 3.32972497e-01f, -3.43664140e-02f, 1.07181005e-01f, -3.43445241e-02f, -3.20278034e-02f, 3.65997814e-02f, -4.42281924e-02f, 4.59455073e-01f,
  1.48156285e-01f, -6.84171310e-03f, 5.59144989e-02f, 1.03874780e-01f, -3.49322595e-02f, 1.48501441e-01f, -9.75862816e-02f, 2.09348455e-01f, -3.69592686e-03f, 1.32426471e-01f,
  2.55919863e-02f, -2.20306050e-02f, -1.13960437e-01f, 2.59872600e-02f, 1.11765517e-02f, -1.06531613e-01f, 1.16087183e-01f, 2.23089263e-01f, 9.78359953e-02f, -1.12813599e-01f,
  -1.24387302e-01f, -1.54840499e-01f, -2.61313051e-01f, -3.57221246e-01f, -7.61729032e-02f, -1.72234997e-01f, -1.08112000e-01f, 2.96875704e-02f, -2.12795168e-01f, 1.81444973e-01f,
  -1.04054913e-01f, 3.55081409e-02f, 1.56618711e-02f, -8.79433900e-02f, -4.84914035e-02f, 2.43029650e-02f, -1.55944422e-01f, -1.77919790e-01f, -1.28241077e-01f, -1.73211291e-01f,
  -5.19882664e-02f, 5.52742109e-02f, 4.26216312e-02f, -1.71564937e-01f, -1.54725805e-01f, 3.76977250e-02f, -4.48146984e-02f, -6.33579642e-02f, -2.84815878e-02f, -1.19383492e-01f,
  -2.02534925e-02f, -1.65895939e-01f, -5.37516363e-03f, -1.02800094e-01f, -5.96085824e-02f, -1.29787475e-01f, -6.32424951e-02f, -1.25379667e-01f, 1.31244827e-02f, -4.42863675e-04f,
  -1.06443539e-01f, -2.10627645e-01f, 1.53745025e-01f, 2.80561268e-01f, 1.52699143e-01f, 2.05838948e-01f, 7.70480931e-02f, 2.82968041e-02f, -1.29517121e-02f, 3.44205834e-02f,
  7.81730115e-02f, 1.86982796e-01f, 2.65388587e-03f, 8.53164941e-02f, -1.80750992e-02f, -8.55905339e-02f, 1.02816913e-02f, -6.23430870e-02f, 1.93949901e-02f, 5.04575334e-02f,
  6.15013614e-02f, -1.13406003e-01f, -1.78089783e-01f, -1.26968652e-01f, -1.23555876e-01f, -2.18203098e-01f, -1.74505934e-01f, -1.17080770e-01f, -2.41324306e-01f, -2.95891762e-01f,
  -7.53973842e-01f, -1.79830287e-02f, -9.89253074e-02f, -2.12495714e-01f, 2.09434524e-01f, 3.91354322e-01f, 6.69718266e-01f, 4.14122902e-02f, -1.22408561e-01f, 8.19320157e-02f,
  -4.56264690e-02f, -1.38590246e-01f, 5.66272400e-02f, 6.90327445e-03f, 1.05859406e-01f, 3.75852466e-01f, 2.98825741e-01f, -7.29498034e-03f, -1.18519038e-01f, -4.81334291e-02f,
  1.25328675e-01f, -1.25555754e-01f, -2.62637645e-01f, -1.19099908e-01f, -1.30819947e-01f, -1.13124199e-01f, -7.87377656e-02f, 3.81612685e-03f, 5.80499768e-02f, 1.49597570e-01f,
  -2.36431703e-01f, -4.00041044e-01f, 1.65921822e-01f, -7.69487321e-02f, -1.99309856e-01f, -1.39316067e-01f, -6.63482919e-02f, -2.03523412e-01f, -8.99669304e-02f, -4.52915323e-04f,
  -9.45048332e-02f, 1.24033518e-01f, 3.38808298e-02f, 3.60725783e-02f, -6.48304522e-02f, -1.32699227e-02f, -9.72750485e-02f, -9.66509730e-02f, -1.42231643e-01f, 1.66113544e-02f,
  3.82951647e-01f, -1.69327796e-01f, -1.66203618e-01f, 8.00616443e-02f, -1.26536950e-01f, -1.95851684e-01f, -4.01059166e-02f, -6.26885816e-02f, -1.03126168e-01f, -3.93271089e-01f,
  5.86658493e-02f, 5.86589687e-02f, 1.66857749e-01f, 3.75535153e-03f, -7.02471957e-02f, 8.86437763e-03f, 8.68478324e-03f, 7.66536668e-02f, 8.47018883e-02f, 1.80529170e-02f,
  -7.35010672e-03f, -1.95030849e-02f, -2.12273281e-02f, -1.33943751e-01f, 5.11833131e-02f, 2.95560174e-02f, 4.65397574e-02f, 1.00907490e-01f, -5.81272505e-02f, 2.76407157e-03f,
  -1.65488943e-02f, 6.61558956e-02f, -1.16534762e-01f, 7.22190291e-02f, 7.01393187e-02f, -9.25454348e-02f, -1.29709572e-01f, 3.86269055e-02f, -3.61352973e-03f, -8.82099494e-02f,
  -2.83738017e-01f, 1.85007781e-01f, -1.76921591e-01f, -4.23739515e-02f, -1.25602167e-02f, 2.83667538e-02f, 6.64353669e-02f, -8.94135609e-03f, -3.18710580e-02f, 3.66787612e-02f,
  2.37943251e-02f, -7.26588219e-02f, -1.09951779e-01f, 4.39197682e-02f, 1.56725869e-01f, -8.98545794e-03f, 1.04928531e-01f, 6.64935410e-02f, 3.29963900e-02f, -4.77281138e-02f,
  1.89288482e-01f, 4.45199497e-02f, -2.23740548e-01f, 6.90302253e-02f, 1.21229771e-03f, -5.79655394e-02f, -4.29645032e-02f, -1.09476514e-01f, -3.63318548e-02f, -9.10264105e-02f,
  2.38779694e-01f, 3.54630649e-02f, 8.26005265e-02f, 1.48700669e-01f, -2.62604862e-01f, -5.77601254e-01f, -5.54470181e-01f, -9.63836089e-02f, -3.83764021e-02f, -1.72182992e-01f,
  -3.33884448e-01f, -1.42588943e-01f, -1.41639754e-01f, 7.40682781e-02f, -7.26912469e-02f, -2.03899816e-02f, 2.02028841e-01f, 2.46961772e-01f, 7.01098191e-03f, -7.52322599e-02f,
  -1.12680607e-01f, 1.47719935e-01f, 2.69441336e-01f, 6.70112297e-02f, 1.32644519e-01f, -8.06177855e-02f, 1.99408010e-02f, 1.28221497e-01f, -2.93329656e-02f, 3.24714512e-01f,
  1.07809857e-01f, 7.11664632e-02f, -4.73261550e-02f, 1.34570878e-02f, -1.45715266e-01f, 5.11119850e-02f, -1.89452488e-02f, 1.72854796e-01f, -1.09189570e-01f, -4.43343073e-02f,
  -5.21879680e-02f, -5.09075932e-02f, -1.35761455e-01f, -1.57524273e-01f, -1.05250746e-01f, -7.78557956e-02f, -2.75433306e-02f, 2.29256555e-01f, 1.10804759e-01f, -1.10857822e-02f,
  -2.60554254e-02f, -9.05868486e-02f, -3.19898799e-02f, -1.11565381e-01f, 7.20283687e-02f, 8.03957805e-02f, -2.40549132e-01f, 4.55598533e-02f, -1.72468945e-02f, 1.15476176e-01f,
  8.56635571e-02f, -7.29273185e-02f, -4.43802550e-02f, -5.10091111e-02f, 8.83524418e-02f, -5.33490144e-02f, 8.92575309e-02f, 6.76337704e-02f, 1.23129990e-02f, 3.12589519e-02f,
  6.73166523e-03f, 5.67872114e-02f, -5.58296889e-02f, 1.69568986e-01f, 1.09755687e-01f, 2.69189868e-02f, -1.49373919e-01f, 1.34549318e-02f, -8.88531655e-02f, -7.93058611e-03f,
  4.10686694e-02f, -2.64225453e-02f, -1.21259905e-01f, -4.74413484e-02f, 2.60409452e-02f, 2.37680271e-01f, 1.81901529e-02f, -2.37376336e-02f, 3.25626098e-02f, 1.20567501e-01f,
  -2.89399922e-01f, -2.05823720e-01f, -1.03670983e-02f, -1.94505081e-02f, -1.06648594e-01f, -8.40232149e-02f, -1.13040611e-01f, 1.05681479e-01f, 5.01703583e-02f, -9.07056555e-02f,
  -1.21736974e-01f, 3.72661538e-02f, -9.90960300e-02f, -3.51297893e-02f, -7.07339272e-02f, 3.05506233e-02f, -9.29294154e-02f, -1.06593058e-01f, -1.91695794e-01f, -9.22446474e-02f,
  -8.63904804e-02f, -1.70842662e-01f, -1.31600007e-01f, -4.34280969e-02f, -1.00669615e-01f, -1.86452284e-01f, -1.59226507e-01f, -9.42576602e-02f, -3.22579086e-01f, -2.10816503e-01f,
  -4.85151261e-01f, -2.55910218e-01f, -2.66017705e-01f, -7.15195060e-01f, -3.23547959e-01f, 1.53441317e-02f, -1.91231608e-01f, 6.71439394e-02f, -3.07354387e-02f, -3.97072464e-01f,
  -1.61368728e-01f, -1.91834439e-02f, -8.75554681e-02f, 1.72327325e-01f, 1.60632297e-01f, -2.41626263e-01f, -3.20188463e-01f, -2.64111161e-01f, -4.43257913e-02f, 1.15889870e-01f,
  -1.31250411e-01f, -5.96106827e-01f, -4.19089764e-01f, -1.75600544e-01f, -4.66462165e-01f, -3.17845881e-01f, -6.03477001e-01f, -4.07721788e-01f, -2.80334279e-02f, -6.16894305e-01f,
  -3.43363494e-01f, 9.08282027e-03f, 1.02211103e-01f, -7.30077177e-03f, -1.31877229e-01f, 5.81154367e-03f, 3.16832252e-02f, -2.39348095e-02f, 5.04348166e-02f, 3.60435657e-02f,
  -9.19616520e-02f, 8.34167823e-02f, -1.36208072e-01f, -5.48672266e-02f, -1.97098956e-01f, -1.78895202e-02f, -3.28791626e-02f, 1.04972288e-01f, 6.86761066e-02f, 1.86635971e-01f,
  1.44440562e-01f, 1.24463975e-01f, 1.32868350e-01f, 1.52772009e-01f, 3.77703637e-01f, 9.89091024e-02f, 1.25284389e-01f, 1.18173689e-01f, 1.14048511e-01f, -1.57124519e-01f,
  -6.79232925e-02f, -5.18747978e-02f, -7.14621460e-03f, -4.04830612e-02f, -5.04023917e-02f, -2.55519953e-02f, 4.01688032e-02f, -1.15770072e-01f, -2.53247432e-02f, 1.81036443e-02f,
  5.03197014e-02f, -1.94469411e-02f, 1.70426201e-02f, 7.41648301e-02f, -9.65472758e-02f, 2.38799769e-02f, -1.26696184e-01f, -1.33365154e-01f, 1.21881507e-01f, 2.70206388e-02f,
  6.05907198e-03f, 1.11198217e-01f, -9.83027145e-02f, -5.39733842e-02f, 9.53984335e-02f, 4.44326736e-02f, 9.85267907e-02f, -1.61964707e-02f, 4.86364737e-02f, 1.01290338e-01f,
  -5.71348965e-01f, 1.09326400e-01f, -1.66652530e-01f, 8.27696398e-02f, -1.02951683e-01f, 3.13308053e-02f, -1.59347430e-01f, 4.83840151e-04f, -1.05692945e-01f, -7.10079744e-02f,
  8.34525228e-02f, -1.01838790e-01f, -1.20105825e-01f, 2.42772892e-01f, -7.98475295e-02f, 1.26652503e-02f, -5.93149364e-02f, -1.30722761e-01f, 1.05127111e-01f, 1.04479626e-01f,
  7.38458261e-02f, 4.22851592e-02f, 1.22143894e-01f, 1.14609608e-02f, 9.69055071e-02f, 7.06264749e-02f, 8.50885734e-02f, 2.90618688e-02f, 1.01796627e-01f, -1.35049358e-01f,
  1.26175165e+00f, 5.37678659e-01f, -9.93112400e-02f, 1.63301349e-01f, -2.32525408e-01f, -9.67222080e-02f, 2.86079049e-01f, 2.74346322e-01f, -3.05151381e-03f, 9.87473056e-02f,
  1.26436437e-02f, -2.36431971e-01f, -1.24536000e-01f, -1.89247042e-01f, 1.21652290e-01f, 6.12491295e-02f, -1.05806254e-01f, -8.13784748e-02f, -6.64773732e-02f, 3.42789367e-02f,
  -1.12195365e-01f, 1.50674149e-01f, 2.70634383e-01f, 4.09423001e-02f, -1.69591367e-01f, -2.25299478e-01f, -1.81009978e-01f, -1.29058823e-01f, -1.16773412e-01f, -2.53983855e-01f,
  -2.48482123e-01f, 2.03619018e-01f, -1.67628303e-01f, -6.23626672e-02f, -2.31783967e-02f, 2.18543336e-01f, 7.84296170e-02f, 4.57030833e-02f, 1.93575755e-01f, -6.45294115e-02f,
  -1.51257768e-01f, -2.59664934e-02f, 4.78702150e-02f, 5.70350364e-02f, 1.72663569e-01f, -2.05607619e-03f, 8.67660195e-02f, 1.03327788e-01f, -8.86392314e-03f, -1.11805208e-01f,
  -5.54680638e-02f, 5.74450754e-02f, 1.40782177e-01f, -2.02735905e-02f, 5.61557375e-02f, -1.50231168e-01f, 1.35243554e-02f, -3.22157890e-02f, 1.23277642e-02f, 2.03387931e-01f,
  -1.53148681e-01f, -6.01023585e-02f, -2.97866110e-03f, 2.52169985e-02f, 4.91099432e-02f, 7.89332390e-02f, -1.24479858e-02f, -2.90918443e-02f, 1.32277802e-01f, 1.69571385e-01f,
  9.69983488e-02f, -2.51999766e-01f, -1.59145556e-02f, 1.30553141e-01f, -8.28073248e-02f, -3.38702314e-02f, 3.04214470e-02f, -8.57052505e-02f, -5.35672111e-03f, 2.37309765e-02f,
  2.57172510e-02f, 1.40107736e-01f, 2.97525413e-02f, -3.43715325e-02f, -8.75903592e-02f, 1.15050096e-02f, -5.67452721e-02f, 3.90513474e-03f, -4.66586649e-02f, 3.76889273e-03f,
  -8.50703046e-02f, -1.34687394e-01f, -4.62139323e-02f, -7.78337047e-02f, 9.20879766e-02f, 8.95472392e-02f, -5.58365434e-02f, -7.88393766e-02f, -8.20757970e-02f, -1.83518436e-02f,
  -1.08608522e-01f, 6.67342246e-02f, 1.00123547e-01f, 7.07553178e-02f, 1.24118486e-02f, 5.06418087e-02f, 1.38786644e-01f, 7.47885182e-02f, -1.05588295e-01f, -2.23272666e-01f,
  9.29276571e-02f, 1.15709156e-01f, 3.93183008e-02f, 5.86767308e-02f, -1.25358626e-01f, -1.35933176e-01f, -6.35461998e-04f, -7.12761376e-03f, -1.89969130e-02f, 2.64278740e-01f,
  2.97237992e-01f, -1.50929257e-01f, 5.84684730e-01f, -8.32222626e-02f, -2.86229467e-03f, 1.17622040e-01f, 1.07848778e-01f, 1.62297919e-01f, -1.26397759e-01f, -1.04086943e-01f,
  -4.24771667e-01f, -3.92116517e-01f, -3.29794556e-01f, -2.17476398e-01f, 5.98343201e-02f, 2.16980323e-01f, 2.22082794e-01f, 4.24778283e-01f, 3.62063795e-01f, -3.66061889e-02f,
  -2.16526642e-01f, 2.07381174e-01f, 3.93839061e-01f, 3.82668488e-02f, -2.21450999e-02f, -2.15843797e-01f, 2.35305801e-01f, 1.02313571e-01f, -3.34196761e-02f, 1.80462208e-02f,
  1.04867563e-01f, 2.31192410e-01f, -1.07113525e-01f, -2.94509977e-01f, -9.03304759e-03f, -2.30811536e-02f, -5.40780127e-02f, 2.15530582e-02f, -1.66726887e-01f, 1.97298564e-02f,
  -2.16497675e-01f, -3.12497560e-02f, -3.24894674e-02f, -8.85790214e-03f, 7.86682665e-02f, 2.04134211e-02f, 4.05909084e-02f, 5.74837364e-02f, 5.74062988e-02f, -7.15094730e-02f,
  -3.76634538e-01f, -8.76338482e-02f, 6.73215687e-02f, 3.37002836e-02f, 1.48727342e-01f, -1.07410617e-01f, 1.88846793e-02f, 1.18946984e-01f, 4.88579832e-02f, -5.22547625e-02f,
  7.23687783e-02f, 9.49978177e-03f, 7.68573135e-02f, -1.53261668e-03f, -5.64579070e-02f, -6.66642636e-02f, -5.59513718e-02f, -1.48290113e-01f, -3.40270065e-02f, 7.96712711e-02f,
  -1.60610899e-01f, 4.62998599e-02f, -4.72534373e-02f, -5.31099439e-02f, -8.42826292e-02f, 1.47457849e-02f, -3.20184939e-02f, -9.21887532e-02f, -8.53039995e-02f, -6.59281835e-02f,
  -2.56311204e-02f, 6.25619143e-02f, -4.28282423e-04f, -1.95851643e-02f, 1.17141232e-02f, -1.76374968e-02f, -1.27080441e-01f, -8.02031606e-02f, 3.63083296e-02f, 7.64966905e-02f,
  -3.23248565e-01f, -9.05411094e-02f, -1.18173033e-01f, -5.41721955e-02f, 1.12150036e-01f, 4.60201222e-03f, -5.86364418e-02f, -1.12688325e-01f, -6.95332959e-02f, -8.69217142e-02f,
  -6.43062592e-02f, -6.30971268e-02f, 4.47777659e-03f, 9.89014581e-02f, -4.04488109e-02f, 6.65948391e-02f, -1.94722921e-01f, -4.52196635e-02f, -1.09460056e-01f, 6.39572507e-03f,
  -1.34485826e-01f, -2.67189238e-02f, -4.79486212e-02f, -2.22208917e-01f, 6.69491813e-02f, -2.59630587e-02f, -3.81102189e-02f, -3.83128747e-02f, 7.36902207e-02f, -1.19363941e-01f,
  5.75942278e-01f, 3.04140504e-02f, 2.50919461e-01f, 2.46111825e-01f, -2.09544110e-03f, 1.45183340e-01f, 2.90291727e-01f, 2.05616057e-01f, 7.46877640e-02f, 4.57798503e-02f,
  -1.02530420e-01f, -2.16365576e-01f, -1.64132982e-01f, -1.48393810e-01f, 5.82724847e-02f, 1.05608456e-01f, 8.97646323e-02f, 2.26345673e-01f, 7.04201758e-02f, 1.04189888e-01f,
  -2.20873237e-01f, 1.93699643e-01f, 2.56679863e-01f, 9.89025757e-02f, -4.67361286e-02f, -1.58840209e-01f, -2.77488008e-02f, 2.66666543e-02f, -3.73762585e-02f, -1.49584830e-01f,
  -3.40673596e-01f, 1.22851588e-01f, -4.42775413e-02f, -1.40151039e-01f, -1.48901194e-01f, -7.89350644e-02f, -3.56160440e-02f, -3.02186087e-02f, 3.08097042e-02f, 3.75855900e-03f,
  -7.29662329e-02f, -5.03732897e-02f, -1.35463476e-01f, -8.38250816e-02f, 4.03615693e-03f, -2.57081427e-02f, 6.11038879e-02f, -4.76276390e-02f, 4.19232659e-02f, -1.47075698e-01f,
  -1.94033131e-01f, 1.22048296e-02f, 1.27909407e-01f, 1.16995201e-01f, 6.87801745e-03f, 2.48137582e-02f, 6.23873714e-03f, -1.82394385e-02f, 1.14333801e-01f, -4.53183763e-02f,
  4.45764437e-02f, 3.87480594e-02f, -4.58054384e-03f, 8.82327482e-02f, 6.43026903e-02f, 1.74318720e-02f, 7.85189942e-02f, 5.76149300e-02f, 9.77650471e-03f, -8.40256084e-03f,
  4.98543717e-02f, 4.39798981e-02f, 1.24441229e-01f, 1.25382626e-02f, -6.06898069e-02f, -3.34069356e-02f, 9.67693701e-03f, 1.28680747e-02f, 5.15518226e-02f, 8.55013281e-02f,
  3.75753902e-02f, 1.00144230e-01f, -3.45510915e-02f, -8.01191330e-02f, 5.84993176e-02f, -1.20900050e-01f, -7.24877194e-02f, -9.29354727e-02f, 1.31928995e-01f, 1.29636109e-01f,
  -2.22481057e-01f, 2.67234799e-02f, 4.48209196e-02f, -1.52866244e-01f, -2.48852726e-02f, -5.55621348e-02f, -5.52160032e-02f, -8.08646064e-03f, -1.89832989e-02f, -3.94186564e-02f,
  1.08871736e-01f, -5.18795140e-02f, -4.41589467e-02f, 1.33691534e-01f, -4.09964547e-02f, 3.99539769e-02f, -1.01262860e-01f, -1.48736301e-03f, -7.78292567e-02f, -1.98103487e-02f,
  -3.41808759e-02f, 5.65633625e-02f, 1.15007060e-02f, 6.47998303e-02f, -6.54071793e-02f, 2.66107637e-02f, 7.01623634e-02f, 3.96642871e-02f, 7.69833997e-02f, 2.08694577e-01f,
  1.93290502e-01f, -1.61748216e-01f, -1.37135714e-01f, 2.71582633e-01f, 2.52594620e-01f, -3.67024913e-02f, -4.54152584e-01f, 5.04459925e-02f, 4.05690253e-01f, 4.92229089e-02f,
  2.36046687e-01f, 2.23207325e-01f, -1.22699747e-02f, -9.41302776e-02f, -3.25600594e-01f, -3.09438169e-01f, -1.63414702e-01f, -3.09723407e-01f, -4.36272845e-03f, 1.11895069e-01f,
  9.25716683e-02f, 1.07799850e-01f, 9.89105999e-02f, -1.46613335e-02f, 1.36575714e-01f, 3.28778811e-02f, -1.55575663e-01f, 9.67595540e-03f, -2.42469788e-01f, -2.24525049e-01f,
  -1.66653544e-01f, 1.18895993e-01f, 3.02518979e-02f, 5.75407334e-02f, 6.28361776e-02f, 5.21510988e-02f, 4.33025882e-03f, 8.38841051e-02f, 1.26613989e-01f, 1.05165772e-01f,
  2.24075109e-01f, 1.13706306e-01f, 5.40718846e-02f, 6.42392561e-02f, 2.04516023e-01f, 2.22711742e-01f, 1.79133937e-01f, 3.42124701e-02f, -1.42766342e-01f, -8.68990377e-04f,
  1.30884737e-01f, 1.81541353e-01f, 5.52758016e-02f, 3.46930064e-02f, -1.37259051e-01f, 3.25977691e-02f, -1.85744554e-01f, -6.95315897e-02f, -2.44593725e-01f, -2.23016828e-01f,
  -1.00410648e-01f, -1.10400401e-01f, 5.63753694e-02f, 1.09338440e-01f, 6.40164539e-02f, 2.99662966e-02f, -5.30440807e-02f, -1.21448636e-01f, -1.99288297e-02f, 1.15590133e-01f,
  -5.01344167e-02f, -1.84352580e-03f, -9.64652980e-04f, -1.24424443e-01f, -9.42711383e-02f, 4.47285175e-02f, -4.75090966e-02f, -1.36466026e-01f, -1.30311310e-01f, 1.39140815e-01f,
  9.76462290e-02f, 3.03371958e-02f, 1.89815477e-01f, -4.71435376e-02f, -3.66388299e-02f, -4.32211012e-02f, 6.91781342e-02f, 2.31099054e-01f, 1.89615369e-01f, 1.33705676e-01f,
  9.67063606e-02f, -2.70980090e-01f, 9.62581392e-03f, -7.80824423e-02f, 1.20898284e-01f, 7.78943077e-02f, -8.32552239e-02f, 5.24071157e-02f, 4.38248068e-02f, -2.08396520e-02f,
  -6.40504807e-02f, 8.83883680e-04f, -1.67364165e-01f, -8.61084387e-02f, 3.07495035e-02f, -7.24084768e-03f, 6.18408173e-02f, -9.50948298e-02f, -1.07166074e-01f, 4.95837368e-02f,
  -8.79283845e-02f, -7.26866350e-02f, -1.43083900e-01f, -5.43900095e-02f, -3.82515676e-02f, -2.25354254e-01f, -2.45651364e-01f, -1.50818482e-01f, -3.78072441e-01f, -3.83828759e-01f,
  2.75010884e-01f, -6.80499792e-01f, -6.79458231e-02f, 2.99491227e-01f, 2.62257576e-01f, 1.85575768e-01f, 6.28440827e-02f, 1.98686346e-01f, 3.03051680e-01f, -1.59292102e-01f,
  -4.76376355e-01f, -5.13552487e-01f, -5.52089155e-01f, -3.78635079e-01f, -1.94466606e-01f, -5.51813543e-02f, 7.73684233e-02f, 1.52086034e-01f, 4.00139570e-01f, 2.51055151e-01f,
  5.92778586e-02f, 2.21656606e-01f, 9.44569409e-02f, 8.00838694e-02f, -1.50618762e-01f, 8.97314027e-02f, -4.98214327e-02f, -1.69517085e-01f, -3.37769836e-01f, -4.70730066e-01f,
  -3.23053181e-01f, -2.56299585e-01f, 2.49970973e-01f, 3.72074619e-02f, -2.41750732e-01f, 3.19188274e-02f, -8.07831585e-02f, -8.74499306e-02f, -5.92771657e-02f, -4.69483406e-04f,
  -4.08165194e-02f, -2.08846200e-02f, -2.53905505e-01f, -6.00795485e-02f, 9.44360346e-02f, 4.42668386e-02f, -7.65290558e-02f, -1.82690486e-01f, -2.12675869e-01f, -1.78801045e-01f,
  -1.52943268e-01f, -1.68910235e-01f, -7.43553862e-02f, -4.11117487e-02f, -1.45541862e-01f, -5.93982972e-02f, -1.90359697e-01f, -1.93981364e-01f, -2.46283412e-01f, -2.51932759e-02f,
  1.53752416e-02f, -7.81648532e-02f, -1.77620025e-03f, 9.25414264e-02f, -1.31043652e-02f, 1.05503440e-01f, -3.56384963e-02f, 1.80449411e-02f, 4.50088978e-02f, -2.23164018e-02f,
  -2.27942388e-03f, -5.88462800e-02f, -5.88183105e-02f, 1.53471855e-02f, -4.64613847e-02f, -8.03438202e-02f, 6.17434606e-02f, -1.03078755e-02f, -6.25890270e-02f, 5.15798926e-02f,
  -6.81865960e-02f, -5.01450077e-02f, 9.78118703e-02f, -1.74192041e-02f, -5.34174591e-02f, -7.27727711e-02f, 9.53520462e-02f, -1.39362499e-01f, -1.07510155e-02f, 6.58821268e-03f,
  1.34581164e-01f, -2.48837009e-01f, 2.03971982e-01f, -2.58312840e-03f, 1.05326973e-01f, -9.65000391e-02f, -1.76653773e-01f, 6.22083023e-02f, 2.44276715e-04f, 5.22618406e-02f,
  2.00278778e-02f, 3.37739848e-02f, -1.32205173e-01f, -4.70468625e-02f, 1.90398186e-01f, 1.73829511e-01f, -2.55655274e-02f, 7.73133896e-03f, 4.61106189e-02f, 1.06958270e-01f,
  1.31595612e-01f, 1.78534880e-01f, 1.94915161e-01f, 4.22623008e-02f, -6.00631721e-03f, 3.43019545e-01f, 6.71179220e-02f, 1.28984511e-01f, 1.09836146e-01f, 3.72654796e-01f,
  4.19368446e-01f, 2.60173023e-01f, 9.96717811e-02f, 2.52315283e-01f, 1.92072198e-01f, 3.63733649e-01f, 3.00164670e-01f, 2.30765179e-01f, 1.02062024e-01f, 7.08133653e-02f,
  2.50245929e-01f, 7.93398097e-02f, 1.58621594e-01f, 8.22389424e-02f, 6.87217712e-02f, -1.41010405e-02f, -1.07414357e-01f, 5.68865659e-03f, -2.04279032e-02f, 4.29818854e-02f,
  -5.68290986e-03f, -1.08319856e-01f, -1.22759566e-01f, -5.58603089e-03f, 5.35664894e-02f, 8.77849162e-02f, 3.02353110e-02f, 7.31287375e-02f, 5.46606593e-02f, -2.32214078e-01f,
  -4.06681627e-01f, 3.07690233e-01f, 8.57520998e-02f, 4.91306745e-02f, 1.07227208e-03f, 3.84814739e-02f, 1.42922383e-02f, -7.86171407e-02f, 1.02610841e-01f, -3.99640463e-02f,
  3.82192694e-02f, -1.29255950e-01f, 5.80748357e-02f, 1.62030105e-02f, 1.89285334e-02f, 7.15197772e-02f, -3.18606868e-02f, 6.74448684e-02f, -1.75529290e-02f, -2.01350488e-02f,
  -7.13950768e-02f, 7.28010908e-02f, 9.60395038e-02f, 1.15362711e-01f, 1.30553663e-01f, 9.74567607e-02f, 1.53646275e-01f, -1.68162361e-02f, 9.96421278e-02f, 6.42943056e-03f,
  -1.56837597e-01f, -1.56794488e-01f, 3.51035371e-02f, -1.10954173e-01f, -2.06353106e-02f, -5.89120649e-02f, -1.69118807e-01f, -7.49763027e-02f, 3.53639275e-02f, -1.78605601e-01f,
  -1.12583213e-01f, -7.62497783e-02f, 2.34966094e-04f, 9.39520225e-02f, -4.81593609e-02f, -3.02470382e-03f, 6.34220988e-02f, -2.52470397e-03f, 4.73216213e-02f, -2.95210294e-02f,
  4.71996255e-02f, -5.79968048e-03f, 8.86137784e-02f, -2.81257741e-02f, -3.19133885e-03f, 6.64070770e-02f, -8.88463780e-02f, 3.76139618e-02f, 2.15992406e-02f, -3.02718785e-02f,
  -2.67593235e-01f, 1.33211583e-01f, -1.92027941e-01f, -1.19189419e-01f, -1.13501251e-02f, -9.65423658e-02f, -3.11538633e-02f, -9.92340818e-02f, -9.74561945e-02f, 5.23259379e-02f,
  -5.59511315e-03f, -7.57534951e-02f, -7.32281283e-02f, -1.09753929e-01f, -6.25740439e-02f, -5.12647405e-02f, -4.53728810e-02f, -2.36253794e-02f, -1.33768827e-01f, -1.98124409e-01f,
  -2.33569503e-01f, 4.35657948e-02f, -1.46276206e-02f, 9.77689251e-02f, -1.03550360e-01f, -7.65135884e-03f, -1.01112187e-01f, -5.20610772e-02f, 4.30248678e-02f, 2.45663244e-02f,
  7.46074796e-01f, 8.17490816e-02f, 2.24645540e-01f, 2.07589060e-01f, 2.00182199e-02f, 1.32733449e-01f, 5.78669161e-02f, 2.02269346e-01f, 1.85360849e-01f, 1.01008587e-01f,
  2.21205920e-01f, 2.97163606e-01f, 2.71792293e-01f, 2.54930228e-01f, 1.69784889e-01f, 8.48317221e-02f, 1.57968044e-01f, 3.25578898e-01f, 2.74328500e-01f, 2.04792038e-01f,
  -5.36527969e-02f, -1.41207397e-01f, -2.42957603e-02f, -9.77715999e-02f, -9.85992178e-02f, 6.24161251e-02f, -6.53047934e-02f, -4.94801924e-02f, 2.61639841e-02f, 1.31823599e-01f,
  1.50823280e-01f, 1.16919383e-01f, -1.92928072e-02f, -3.62047777e-02f, -3.80563806e-03f, -9.95552838e-02f, -3.07914633e-02f, -1.18100375e-01f, -5.94308898e-02f, -7.08580837e-02f,
  1.26519911e-02f, 1.03647849e-02f, -2.98337638e-02f, -1.89601615e-01f, -1.19135097e-01f, -3.01145017e-02f, -2.32009478e-02f, 2.34334573e-01f, 1.98830396e-01f, -7.07313195e-02f,
  4.16380353e-03f, 1.00265630e-01f, 9.29730386e-02f, 1.27052575e-01f, 2.11391136e-01f, 1.75112888e-01f, 3.94512899e-02f, 3.91105103e-04f, 1.48459524e-01f, 1.08369753e-01f,
  2.19584510e-01f, 2.30465829e-01f, 1.11676030e-01f, 7.20368512e-03f, 1.32703498e-01f, 1.13949075e-01f, -1.07822726e-02f, -2.35540662e-02f, 1.79504380e-01f, -4.72472310e-02f,
  -1.40000105e-01f, 8.12737718e-02f, 1.33979529e-01f, -1.39550352e-02f, 9.50512514e-02f, 5.66279739e-02f, 2.01367252e-02f, -2.19264682e-02f, -7.55536929e-02f, -1.05425343e-01f,
  1.75532904e-02f, 3.41493152e-02f, -3.76681350e-02f, 2.95542274e-02f, 3.57708000e-02f, 5.73041663e-02f, 6.96454337e-03f, -4.21125516e-02f, -1.39297292e-01f, -5.19781671e-02f,
  -1.80218309e-01f, 1.84359550e-02f, -2.17879787e-02f, 5.48074022e-02f, -6.11126088e-02f, -8.64039138e-02f, 9.96695384e-02f, -1.40063122e-01f, -2.35484838e-01f, -1.35943457e-01f,
  -1.56838551e-01f, 4.80870157e-02f, -1.69503763e-02f, -4.19742912e-02f, -1.30397514e-01f, -1.83360204e-01f, -2.51401030e-02f, 2.37846166e-01f, 5.67418076e-02f, -1.53113455e-01f,
  -1.29133284e-01f, 1.25281677e-01f, 1.71803936e-01f, 4.20279503e-02f, 1.41008580e-02f, 1.12300351e-01f, -1.11087244e-02f, 4.40742914e-03f, 1.12957165e-01f, 1.02481069e-02f,
  2.47192621e-01f, -4.34007376e-01f, -5.43825589e-02f, 5.80422692e-02f, -1.60473257e-01f, 1.37940854e-01f, -2.40331918e-01f, 5.34535609e-02f, 1.78186074e-01f, -2.76245743e-01f,
  -5.08197770e-02f, 2.58351475e-01f, 6.09344728e-02f, 1.43217206e-01f, 2.08924726e-01f, -3.15636843e-01f, -3.06253791e-01f, 1.12220049e-01f, 4.24678952e-01f, 3.06516826e-01f,
  6.75948709e-02f, 5.13177998e-02f, 2.41353333e-01f, 1.72543734e-01f, -3.66322786e-01f, 1.27860591e-01f, -2.30482861e-01f, -2.29439750e-01f, -6.81221113e-02f, -6.97273493e-01f,
  1.34213092e-02f, -1.60114810e-01f, 9.05477777e-02f, 3.69827747e-02f, 1.59270167e-02f, 1.00307032e-01f, 7.15214908e-02f, -8.58569369e-02f, -9.69605893e-02f, -6.17963150e-02f,
  -6.09598160e-02f, -1.17980465e-01f, -6.68762671e-03f, 2.23812778e-02f, -1.93704560e-01f, 2.06829812e-02f, -2.06926003e-01f, -2.64248084e-02f, -3.11725046e-02f, -1.23473769e-02f,
  -1.77990735e-01f, -1.22042038e-01f, -1.05953291e-01f, 4.22114618e-02f, -7.14313388e-02f, 6.44937307e-02f, -1.64200023e-01f, -1.72713660e-02f, -1.13001987e-02f, -4.11831051e-01f,
  3.49929109e-02f, 2.17222851e-02f, -7.75745660e-02f, -6.03133738e-02f, 3.45902145e-02f, -4.36935900e-03f, -1.10717855e-01f, -1.05788819e-01f, -7.38486946e-02f, -2.05195639e-02f,
  6.63615018e-02f, -5.87349175e-04f, 2.12170016e-02f, 2.76138540e-02f, -2.29429509e-02f, -4.45231348e-02f, 3.88599709e-02f, -7.75398687e-02f, -4.75592092e-02f, 1.03379950e-01f,
  1.16833076e-01f, 1.82434544e-02f, -2.91676484e-02f, -6.04274087e-02f, -6.68945014e-02f, -5.53826466e-02f, 2.68588439e-02f, 5.74935637e-02f, 4.49969759e-03f, -7.42445886e-02f,
  2.05556437e-01f, 1.10078409e-01f, 2.73864269e-02f, -3.04502179e-03f, -3.75161655e-02f, 7.97725767e-02f, 4.26184833e-02f, 1.23096310e-01f, 5.14371470e-02f, 4.13136976e-03f,
  -6.16998598e-02f, 2.20405273e-02f, -6.28397539e-02f, 1.11330592e-03f, 1.06485054e-01f, 3.41166556e-02f, -3.88775542e-02f, 6.37816414e-02f, 2.23402623e-02f, -9.28150639e-02f,
  -1.96005777e-02f, -1.84033047e-02f, -3.93542610e-02f, 5.41669428e-02f, -3.29917371e-02f, 4.78121303e-02f, -1.38383105e-01f, -3.29415724e-02f, 1.70598522e-01f, -3.99975292e-02f,
  -4.13354546e-01f, -2.72950947e-01f, -1.40679538e-01f, -3.17634374e-01f, -1.51467577e-01f, -1.35915503e-01f, -2.90340155e-01f, -3.73364016e-02f, -9.06941369e-02f, -2.61962980e-01f,
  -1.32463858e-01f, 6.05836045e-03f, -7.15626171e-03f, -2.67750751e-02f, -9.31865722e-02f, -1.77887425e-01f, -3.30823869e-01f, -1.18585177e-01f, -5.08223251e-02f, 4.37031388e-02f,
  -1.17808253e-01f, -1.38339028e-01f, -6.87095895e-02f, 6.06497154e-02f, -1.96884898e-03f, 1.81398809e-01f, -5.01370206e-02f, 2.68581938e-02f, 8.72682184e-02f, -1.66283175e-02f,
  3.40496689e-01f, -1.93673253e-01f, 1.32607549e-01f, 3.62411402e-02f, -1.75249588e-03f, -2.27696784e-02f, 3.02980393e-02f, 8.78401846e-02f, 1.14846610e-01f, 2.03046665e-01f,
  5.31847514e-02f, 1.75533276e-02f, -8.11100705e-04f, -3.23284343e-02f, 4.21958268e-02f, 1.34827141e-02f, 1.69714689e-02f, -5.97500354e-02f, -2.49455981e-02f, -1.01603102e-03f,
  -4.70981076e-02f, -9.52104405e-02f, 1.16160035e-01f, 1.20190345e-01f, 5.40743060e-02f, -3.71607952e-02f, 1.41592622e-01f, 4.97877784e-02f, 1.71755269e-01f, 1.15182601e-01f,
  2.03019213e-02f, -8.40115920e-03f, 9.04493209e-04f, 2.94866110e-03f, 5.37862368e-02f, -5.58657385e-02f, 1.48620099e-01f, 2.24671185e-01f, -1.03036270e-01f, -9.33112949e-02f,
  2.33792085e-02f, -2.01351687e-01f, -1.07632354e-01f, -5.77488281e-02f, -6.85005933e-02f, -7.47351050e-02f, 2.28887852e-02f, 3.46605591e-02f, -2.02247128e-02f, -5.11419699e-02f,
  -5.84995821e-02f, 9.61301550e-02f, -8.48744586e-02f, 5.50203808e-02f, -1.41410187e-01f, -3.96669060e-02f, -4.37975787e-02f, -1.27069995e-01f, 7.05526322e-02f, -9.67264473e-02f,
  3.99377197e-01f, -3.43626827e-01f, -7.25505278e-02f, 4.79505807e-02f, 2.07414538e-01f, 9.58024114e-02f, -1.35531768e-01f, 9.81712267e-02f, 9.92153808e-02f, 2.29841992e-01f,
  1.96077019e-01f, 1.63385689e-01f, -5.48944101e-02f, -1.28127160e-02f, 1.06321111e-01f, 8.41223076e-02f, 4.85972464e-02f, 4.36379537e-02f, 5.22953421e-02f, 9.00760069e-02f,
  1.71019211e-02f, 2.52030399e-02f, 2.35778689e-01f, 2.51181275e-01f, 9.91326645e-02f, 3.18105109e-02f, 1.42694473e-01f, 1.80141062e-01f, 1.47710472e-01f, 2.84617305e-01f,
  1.49769694e-01f, 8.05143118e-02f, 1.67422414e-01f, 2.58189023e-01f, 5.79959899e-02f, -9.93103236e-02f, -5.44500411e-01f, -1.26287103e-01f, 1.80499300e-01f, -8.75043198e-02f,
  -1.23343794e-02f, -2.20812559e-02f, -6.89179376e-02f, -2.20590785e-01f, -4.91613358e-01f, -3.96699697e-01f, -2.69184291e-01f, -3.08220297e-01f, -2.78505296e-01f, -1.21060789e-01f,
  -9.25002769e-02f, -1.70660123e-01f, -7.59270117e-02f, 2.16023456e-02f, 3.43853712e-01f, 2.21291021e-01f, 1.90723404e-01f, 1.63864359e-01f, 1.60959229e-01f, 3.72986078e-01f,
  8.15725476e-02f, 1.67761356e-01f, -2.87888665e-02f, -5.28824143e-03f, 1.70324761e-02f, 9.98405390e-04f, -1.46936104e-01f, 1.45079687e-01f, -4.80948053e-02f, 5.55613451e-02f,
  -4.89351414e-02f, -1.85568854e-01f, 6.65007532e-02f, -1.48396753e-02f, -1.47114769e-01f, -4.23076451e-02f, -1.67299494e-01f, -1.11656755e-01f, -2.21625730e-01f, -8.34963545e-02f,
  -1.05664484e-01f, 7.72908479e-02f, -1.51938349e-01f, 1.83867868e-02f, -2.39504855e-02f, -4.16547060e-02f, 3.38549726e-02f, 2.14923397e-01f, -3.45993973e-02f, 2.68887222e-01f,
  -1.14738885e-02f, -1.36669800e-01f, -2.21169163e-02f, -1.09978549e-01f, -1.44438177e-01f, 1.96241409e-01f, 1.56772938e-02f, -5.44181978e-03f, 9.01379529e-03f, -9.49816965e-03f,
  -4.02901098e-02f, -1.37456302e-02f, 8.74365587e-03f, 9.64251906e-02f, 1.29202425e-01f, 6.51341304e-02f, 4.86301184e-02f, 1.40525792e-02f, 7.03730807e-02f, 2.24516373e-02f,
  -5.37512302e-02f, 5.00413775e-02f, 5.74538112e-02f, 1.04885744e-02f, 5.81121109e-02f, 1.31442240e-02f, 3.32592838e-02f, -2.53893714e-02f, -8.66747797e-02f, 6.69976026e-02f,
  -7.82892480e-02f, -2.00414076e-01f, 3.53162959e-02f, -8.82769823e-02f, 1.45720486e-02f, 8.98880288e-02f, 1.31988078e-01f, -1.00633048e-01f, -4.68025617e-02f, -9.36738998e-02f,
  -1.62095428e-01f, -8.88520554e-02f, 4.34726104e-02f, 7.24623650e-02f, -9.56736356e-02f, -7.48321563e-02f, -1.60139635e-01f, 1.54697239e-01f, -7.22767413e-02f, 5.15164770e-02f,
  -8.41502845e-02f, -2.88159996e-01f, -2.02938348e-01f, -4.76492057e-03f, -1.05413143e-02f, -1.16391115e-01f, 3.28746848e-02f, 1.31640375e-01f, -2.50875682e-01f, -9.95874852e-02f,
  3.37030441e-01f, 8.53619352e-02f, 2.78074443e-01f, -2.93078460e-02f, 3.16426247e-01f, 4.03542012e-01f, 5.03041804e-01f, 1.91317588e-01f, -1.19100824e-01f, 1.06678419e-01f,
  9.05931890e-02f, -2.93736190e-01f, -3.23726267e-01f, -2.36859918e-01f, 1.19320606e-03f, 7.70911807e-03f, -2.99057513e-02f, 2.42026895e-02f, 7.10350201e-02f, -2.29194537e-02f,
  -1.85545027e-01f, 1.22203313e-01f, 4.32330891e-02f, -3.63927260e-02f, -2.28352845e-01f, -2.70410627e-01f, 1.35344505e-01f, 5.78084216e-02f, -3.17889750e-02f, -4.46677387e-01f,
  -7.25021884e-02f, 3.70810241e-01f, -4.08526734e-02f, -4.41507883e-02f, 2.59684660e-02f, -1.46049634e-01f, 4.45446409e-02f, 4.63057272e-02f, 1.53305814e-01f, 1.51510835e-02f,
  9.63202044e-02f, -4.58004624e-02f, 1.55581206e-01f, 7.27216527e-02f, 2.14552015e-01f, 1.15039930e-01f, 4.99917679e-02f, -4.86051245e-03f, -8.11169446e-02f, -4.72446717e-02f,
  -1.69381380e-01f, 1.77597091e-01f, 2.49905661e-01f, 6.82014376e-02f, 1.16286002e-01f, 2.15352755e-02f, 2.74047256e-01f, 6.15060404e-02f, 1.74491897e-01f, -1.12541124e-01f,
  -1.24390572e-01f, 4.79771718e-02f, -1.28193498e-02f, 1.18607774e-01f, -4.07347176e-03f, -6.58477098e-02f, -2.32963618e-02f, 1.39728561e-01f, 1.02308184e-01f, -1.87993739e-02f,
  -3.02478205e-02f, 5.58798723e-02f, -6.82900846e-02f, -2.59026177e-02f, -1.92228463e-02f, -2.79088654e-02f, 2.22431943e-02f, 9.70302057e-03f, 1.04356438e-01f, -7.81239197e-02f,
  2.53550112e-02f, -9.53045674e-03f, 6.89564049e-02f, 2.25944333e-02f, 5.71539514e-02f, -1.41365662e-01f, -7.64408857e-02f, -5.27149141e-02f, -3.89287286e-02f, -7.73126855e-02f,
  -3.16680849e-01f, 2.95671582e-01f, -2.30982304e-01f, -1.47532687e-01f, 2.63763554e-02f, -2.29391977e-01f, -6.54511899e-02f, -1.81478724e-01f, -1.73431300e-02f, -1.50199980e-02f,
  1.42004669e-01f, -5.45682274e-02f, 5.70544824e-02f, -4.84601781e-02f, 1.30904272e-01f, 7.89676905e-02f, -8.52566436e-02f, -9.93734673e-02f, -1.43356204e-01f, -5.28582931e-02f,
  -2.67177850e-01f, -2.97039934e-03f, -1.27927840e-01f, -1.68056756e-01f, -8.80578533e-02f, -1.38209999e-01f, 4.76946756e-02f, -4.98297773e-02f, 1.34005278e-01f, 1.15115698e-02f,
  -4.89176482e-01f, -1.06050773e-02f, 2.78568655e-01f, -2.39380047e-01f, 1.28747839e-02f, 1.09367698e-01f, 2.55374789e-01f, 3.45737338e-02f, -2.62311369e-01f, 8.91924202e-02f,
  -1.78866342e-01f, -1.60986498e-01f, -8.50737467e-02f, 1.31163150e-01f, 2.71823555e-01f, 2.78439373e-01f, 3.99158657e-01f, 3.22871178e-01f, -5.55977318e-03f, -7.32861087e-02f,
  -6.05454808e-03f, -5.80114536e-02f, -8.65994245e-02f, 8.06289390e-02f, -3.57422419e-02f, -1.31673412e-02f, 9.60291624e-02f, -5.92870871e-03f, 1.58175617e-01f, 1.22169204e-01f,
  -1.85616776e-01f, 2.84845699e-02f, 1.90399632e-01f, -1.06057040e-01f, -1.52400821e-01f, -1.83157120e-02f, -8.15275908e-02f, 1.34038940e-01f, 3.09851556e-03f, -1.01298420e-02f,
  1.12196850e-02f, 2.35935524e-02f, -3.89711149e-02f, -3.28543261e-02f, -2.08307996e-01f, -1.37642518e-01f, 1.08749047e-02f, 1.87919483e-01f, 4.63214777e-02f, 1.74851492e-02f,
  6.55558631e-02f, -1.47758976e-01f, -1.11086898e-01f, 1.02298647e-01f, 7.46638551e-02f, -8.55113715e-02f, 3.73822674e-02f, 4.82178405e-02f, 1.14326656e-01f, -1.74450964e-01f,
  -4.49995659e-02f, -9.02842879e-02f, 2.78606135e-02f, 4.96475063e-02f, -1.32769058e-02f, -9.79670808e-02f, 1.33900374e-01f, 2.01745168e-03f, 2.74693477e-03f, -7.32154697e-02f,
  7.02436864e-02f, -7.42494836e-02f, -5.49426302e-02f, -3.04243919e-02f, 1.02488743e-02f, 4.66712937e-02f, -3.23405974e-02f, -1.68004781e-02f, 2.48389635e-02f, 1.25570551e-01f,
  1.42447561e-01f, 1.02483884e-01f, 4.99100089e-02f, -6.46468177e-02f, 1.59341589e-01f, 1.91979229e-01f, -8.89322385e-02f, 3.21323238e-03f, -2.23625138e-01f, 1.09100208e-01f,
  -2.54847348e-01f, 4.27318871e-01f, -1.88367143e-01f, 9.35605764e-02f, 1.07059270e-01f, 6.05991073e-02f, 8.85129049e-02f, 7.49119744e-02f, 7.75834247e-02f, -1.92906454e-01f,
  6.48384215e-03f, 2.15259171e-03f, 3.00304648e-02f, 2.44295485e-02f, -1.13808885e-01f, -9.08553600e-02f, -1.32565126e-01f, -8.06269720e-02f, -5.49070351e-02f, -2.22977743e-01f,
  -1.74148753e-01f, -1.39958993e-01f, -3.45208824e-01f, -2.15031460e-01f, -1.69329017e-01f, -1.91984832e-01f, -1.49545074e-01f, -1.37671471e-01f, -1.15219228e-01f, -1.70600548e-01f,
  2.96726823e-01f, 3.87327373e-02f, 1.07686535e-01f, 2.50012457e-01f, -7.52333999e-02f, -4.01404202e-01f, -4.00914490e-01f, -1.80826798e-01f, 4.04838733e-02f, 1.36466146e-01f,
  1.49668911e-02f, 2.04070508e-01f, -7.98305795e-02f, 1.31992713e-01f, -3.72335315e-03f, 6.68462366e-02f, 2.13981271e-01f, 2.63943702e-01f, -1.54191554e-02f, 1.92772020e-02f,
  6.77895248e-02f, 1.29426569e-01f, 1.55995369e-01f, 2.72824205e-02f, 2.89914072e-01f, 8.49165767e-02f, -8.25707242e-02f, 1.31521538e-01f, 1.14778429e-01f, 5.38989961e-01f,
  1.69554681e-01f, 1.87071748e-02f, 5.12549728e-02f, -8.64492636e-03f, -1.08691730e-01f, 1.59349620e-01f, -7.46389525e-03f, 1.21943951e-01f, -2.13345382e-02f, -6.25349656e-02f,
  1.29471377e-01f, 1.15643941e-01f, -9.81054157e-02f, 6.51462600e-02f, -1.07959352e-01f, 4.84647825e-02f, -2.64165904e-02f, 1.31987631e-02f, 2.04306804e-02f, 6.06630975e-03f,
  7.96085969e-02f, 2.14176159e-03f, -1.16673738e-01f, -1.82877183e-01f, -1.73177958e-01f, -3.74985747e-02f, -3.04908939e-02f, 5.86833060e-02f, -7.70933330e-02f, 1.91597447e-01f,
  -5.37736574e-03f, 6.66582882e-02f, 5.40908501e-02f, -5.03988005e-02f, -8.24935138e-02f, -5.58618307e-02f, 9.94724631e-02f, -7.24435002e-02f, 1.30391121e-03f, 3.35834105e-04f,
  -1.04814552e-01f, 1.45586669e-01f, -2.46885582e-03f, -2.20710672e-02f, 2.92560495e-02f, 1.64150298e-01f, 1.03721507e-01f, 1.41844615e-01f, -3.08791026e-02f, -2.84704715e-02f,
  7.34941289e-02f, -5.23827001e-02f, 4.43802662e-02f, 5.27177304e-02f, 8.56496543e-02f, 6.80599660e-02f, 5.98734953e-02f, 3.13738249e-02f, -9.45974812e-02f, 1.34009525e-01f,
  8.27894881e-02f, -2.50500888e-01f, 1.30715713e-01f, 2.56764740e-01f, 6.69545233e-02f, 2.07620248e-01f, 1.09628424e-01f, 1.09076194e-01f, 5.23534529e-02f, 6.38336912e-02f,
  6.29526516e-03f, 1.71199828e-01f, 5.69869066e-03f, 3.59030295e-04f, 2.10756417e-02f, -8.80845450e-03f, 8.97082984e-02f, 1.30174622e-01f, 5.91769479e-02f, 1.58995852e-01f,
  3.31276208e-02f, -1.70615613e-02f, 8.65821633e-03f, -1.63573176e-01f, -7.32991844e-02f, -5.70186339e-02f, 5.37182800e-02f, 8.13183039e-02f, -3.93684488e-03f, -2.52015084e-01f,
  6.22977987e-02f, 3.04369107e-02f, 5.18356636e-02f, 8.74204263e-02f, 6.03668094e-02f, -2.51667798e-01f, -3.56059760e-01f, -2.21295282e-01f, -5.31134568e-02f, -1.15156129e-01f,
  -1.18504860e-01f, 3.59661132e-02f, 7.84939900e-02f, 3.32191363e-02f, 1.15887068e-01f, -7.25040305e-03f, 1.72783822e-01f, 1.87697455e-01f, -2.57389601e-02f, 5.43419383e-02f,
  1.05340675e-01f, 2.44258538e-01f, 2.73366511e-01f, 8.49477425e-02f, 1.26580372e-01f, 1.27103822e-02f, 1.39382392e-01f, 2.92406827e-01f, 1.96970984e-01f, 3.49040806e-01f,
  1.93970129e-01f, 2.10226011e-02f, -2.65867174e-01f, 4.64085937e-02f, -5.47497943e-02f, 2.28739996e-02f, -2.51703173e-01f, -3.90447974e-02f, -1.38186023e-01f, 4.69066091e-02f,
  5.93534298e-02f, -5.60254753e-02f, -1.16268873e-01f, -5.48184365e-02f, -7.40308762e-02f, -9.85113010e-02f, -6.75025061e-02f, 5.54169044e-02f, -1.28745228e-01f, -1.08044513e-01f,
  7.01682642e-02f, 1.87262461e-01f, -1.04767188e-01f, -2.07471460e-01f, 3.03423088e-02f, -2.83833733e-03f, -1.83431923e-01f, 1.44693658e-01f, -7.52440169e-02f, 4.52849083e-02f,
  -6.95136115e-02f, -4.02726494e-02f, 1.06346488e-01f, 1.09743334e-01f, 5.72475530e-02f, 8.20643827e-03f, 8.49914327e-02f, 1.87963825e-02f, 1.91953659e-01f, 3.91341969e-02f,
  -5.74635603e-02f, -1.08078830e-01f, -5.43245077e-02f, -2.74793487e-02f, -4.75652106e-02f, 1.16961403e-02f, -1.54695243e-01f, -7.78327584e-02f, -8.15380588e-02f, -2.15265923e-03f,
  6.43312559e-02f, -6.64307624e-02f, -1.65336113e-02f, -1.43375590e-01f, -6.35769665e-02f, -8.18726886e-03f, -4.55213785e-02f, -1.38363823e-01f, -1.91176869e-02f, 8.55806544e-02f,
  -5.14645167e-02f, 7.44019076e-02f, -2.78023809e-01f, -9.27453116e-02f, -4.09212895e-02f, 7.59411231e-02f, -1.69394478e-01f, -5.36242500e-02f, -1.42772675e-01f, -1.80692002e-01f,
  -2.75991946e-01f, -1.81173399e-01f, -7.16966623e-03f, -1.43730119e-01f, -1.48102939e-01f, -4.60877921e-03f, -1.44642860e-01f, -1.85117915e-01f, -1.74746841e-01f, -1.07116923e-01f,
  -1.71952158e-01f, -1.54968992e-01f, -1.36276603e-01f, -2.28941262e-01f, -5.77239953e-02f, -3.41757745e-01f, -1.41969323e-01f, -8.36029276e-02f, -3.42966259e-01f, -2.57271886e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.07523042e-01f, 1.72268957e-01f, 2.59636827e-02f, 6.50298968e-02f, 3.39332759e-01f, 1.22767963e-01f, 1.40162617e-01f, 3.28252017e-02f, 1.77954793e-01f, 1.86380193e-01f,
  2.48098537e-01f, 2.24874988e-01f, 3.95909488e-01f, 3.17964494e-01f, 1.21068612e-01f, -4.67095785e-02f, 2.76107311e-01f, -1.03231974e-01f, 2.33958364e-01f, 1.90148875e-01f,
  -3.62937123e-01f, 1.16114564e-01f, -1.71904471e-02f, 1.46512121e-01f, 2.07139328e-01f, 1.79374292e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  8.09112415e-02f, 1.31933466e-01f, -2.15090290e-01f, 2.50651259e-02f, -5.02863862e-02f, 6.25932813e-02f, 1.72742575e-01f, -5.56263030e-02f, -1.24298884e-02f, 1.43463343e-01f,
  7.34529421e-02f, 2.40235835e-01f, -3.21071714e-01f, 7.38531873e-02f, -9.97688323e-02f, 7.60017931e-02f, 1.01322010e-01f, 3.76252122e-02f, 1.01823788e-02f, -1.12163778e-02f,
  -1.95922300e-01f, -1.42245248e-01f, -3.94263953e-01f, 5.21265268e-02f, -2.19786346e-01f, -2.72365510e-01f, -1.02961533e-01f, -1.46164179e-01f, 1.14533091e-02f, 1.01253353e-01f,
  -8.70518386e-02f, 3.87365192e-01f, -9.94961336e-03f, -4.75980155e-03f, -1.11129038e-01f, 1.11971095e-01f, -3.47584672e-03f, -1.58508763e-01f, -2.60031253e-01f, 2.62392182e-02f,
  3.34427208e-02f, 6.83001205e-02f, -5.24774566e-02f, 1.88412204e-01f, -3.10974628e-01f, 2.09790379e-01f, 3.52430306e-02f, -1.24038421e-01f, -7.38485903e-02f, -7.58774206e-02f,
  -1.28695250e-01f, -2.91186482e-01f, -2.92854644e-02f, 1.29788384e-01f, -1.29746184e-01f, 8.35459307e-02f, -9.35769081e-02f, -4.15351614e-02f, 2.40273118e-01f, 3.71602178e-01f,
  -1.68261468e-01f, -2.38267481e-01f, 3.50712705e-03f, -8.88583735e-02f, 1.37725234e-01f, 1.28132939e-01f, -8.25611874e-02f, 1.00474574e-01f, 7.05976114e-02f, 1.02287263e-01f,
  5.02905436e-02f, -1.19603639e-02f, 1.36562228e-01f, 1.18509658e-01f, -5.16606607e-02f, 4.45194751e-01f, 3.60486284e-02f, 4.56229709e-02f, -7.06113353e-02f, 2.52227187e-01f,
  -2.72738993e-01f, 3.34006608e-01f, -2.13331670e-01f, -2.84355968e-01f, -2.69197673e-01f, -5.07030264e-02f, -2.70599574e-01f, -1.09333456e-01f, 7.70924687e-02f, 3.42472553e-01f,
  8.59786570e-02f, 1.14803918e-01f, -1.29361734e-01f, 1.69234678e-01f, -9.99449119e-02f, 3.19734365e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.97749996e-01f, 1.92142472e-01f, -2.10070610e-01f, 6.28477037e-02f, 2.16944456e-01f, 1.20227255e-01f, -1.56872407e-01f, 2.50158817e-01f, 1.25603214e-01f, 1.86056316e-01f,
  1.21859327e-01f, 2.42164612e-01f, -4.66696352e-01f, 9.17505659e-03f, 3.57305221e-02f, 4.53201622e-01f, -2.47506887e-01f, 1.38457015e-01f, -8.25117826e-01f, -8.91943797e-02f,
  -4.07079309e-01f, -2.27098078e-01f, 2.73104794e-02f, -8.63769054e-02f, -1.25640007e-02f, -2.74010837e-01f, 7.69000500e-02f, -1.73352107e-01f, -3.42378110e-01f, 4.95462939e-02f,
  8.86084661e-02f, -2.21728757e-02f, -1.32365033e-01f, 2.41218600e-02f, -1.69570353e-02f, -1.53905883e-01f, 2.07376838e-01f, -5.18314540e-02f, -2.71478621e-03f, 1.13420606e-01f,
  2.36302558e-02f, -1.43846544e-02f, -4.49683189e-01f, -3.41449797e-01f, 4.50388283e-01f, -2.70343632e-01f, 2.14286089e-01f, -2.33000785e-01f, 5.01096547e-02f, 2.81592369e-01f,
  2.05221232e-02f, 2.36854963e-02f, -2.92227827e-02f, -1.43626213e-01f, 1.95697229e-03f, -7.15599507e-02f, 2.62743473e-01f, 5.30739725e-01f, 6.03740476e-02f, -3.33034933e-01f,
  -1.89076718e-02f, -3.48263413e-01f, -1.00779250e-01f, -2.12849781e-01f, 3.18943739e-01f, 1.92218218e-02f, 4.13131177e-01f, -1.76401168e-01f, 2.94743031e-01f, -2.36610055e-01f,
  9.82619151e-02f, -1.01758309e-01f, 4.35398445e-02f, 1.90342870e-02f, 4.28305835e-01f, 1.66310549e-01f, 9.21475142e-02f, 2.22896039e-01f, -1.06625967e-01f, 9.06579867e-02f,
  -9.47668776e-03f, 5.22616506e-01f, -5.49782336e-01f, -7.64023419e-03f, -1.58714548e-01f, 8.84970948e-02f, -1.33025765e-01f, -4.17220771e-01f, -1.11752398e-01f, 1.37954175e-01f,
  2.52668381e-01f, 1.68869793e-01f, -1.08401053e-01f, 2.99539953e-01f, -6.68928251e-02f, 1.10458560e-01f, 3.59972626e-01f, 3.73731911e-01f, 6.22195192e-02f, -3.79607856e-01f,
  -1.66250378e-01f, -3.37989867e-01f, 3.38035971e-01f, 1.30932117e-02f, -1.22544184e-01f, -2.55929321e-01f, 2.33099490e-01f, -5.58318913e-01f, -3.84164006e-01f, -1.92181915e-01f,
  3.55923802e-01f, -1.24195695e-01f, 1.31528810e-01f, -1.81905776e-01f, 2.59295583e-01f, 4.82444435e-01f, 2.45627552e-01f, -2.66939223e-01f, 7.36398101e-01f, -9.34350416e-02f,
  -1.99459046e-01f, 6.84934705e-02f, 2.28058416e-02f, -2.78007358e-01f, 1.22093514e-01f, 1.81681290e-01f, -2.52797425e-01f, 2.63849735e-01f, 2.38200784e-01f, 9.53721777e-02f,
  -6.51752725e-02f, -3.24991614e-01f, 3.59977148e-02f, -2.41279066e-01f, -1.56937286e-01f, -4.57556210e-02f, -1.01265773e-01f, -1.17776573e-01f, 1.15546077e-01f, -2.14827716e-01f,
  -2.60120600e-01f, 2.48199895e-01f, 2.60784566e-01f, -4.26905662e-01f, 4.41621780e-01f, 5.41006774e-02f, -2.23184496e-01f, 2.04819217e-01f, -2.95925498e-01f, -3.72684337e-02f,
  -2.00215548e-01f, -3.08528364e-01f, -1.01856895e-01f, -9.23696384e-02f, -7.39069248e-04f, 5.50582051e-01f, -4.22840863e-01f, 1.02599807e-01f, 2.31317624e-01f, 4.05128568e-01f,
  1.33832425e-01f, 1.61979467e-01f, 1.58249274e-01f, 6.25902936e-02f, 4.42308933e-02f, 2.18198732e-01f, -1.47371039e-01f, 9.57111120e-02f, -1.79773107e-01f, 1.66099876e-01f,
  9.65750515e-02f, 4.76897001e-01f, -1.15394749e-01f, 2.28315577e-01f, -9.21628848e-02f, 2.74565786e-01f, 8.01056474e-02f, 1.42586201e-01f, -5.10090888e-01f, -2.09065050e-01f,
  -3.85480285e-01f, -1.73945308e-01f, -4.42363679e-01f, -2.82655746e-01f, -1.86425239e-01f, -3.63992006e-01f, 5.41392714e-02f, 1.56535298e-01f, -2.61386454e-01f, 4.41974066e-02f,
  2.61965632e-01f, 1.99160516e-01f, 4.95356321e-02f, 1.65847272e-01f, -2.25700233e-02f, -3.83150391e-02f, 2.14354664e-01f, 7.42954686e-02f, -3.34410220e-01f, 1.16935819e-01f,
  -1.05556421e-01f, 3.81138176e-02f, 2.42624525e-02f, 2.17590556e-01f, -2.85810202e-01f, -2.58108437e-01f, -1.49493352e-01f, 5.88630676e-01f, -1.58604518e-01f, -2.06070244e-01f,
  -7.86619410e-02f, -4.11248267e-01f, -2.03348681e-01f, -4.24905002e-01f, 2.10133001e-01f, -5.71307316e-02f, 1.27064466e-01f, 1.02157757e-01f, 3.22210282e-01f, 1.75938923e-02f,
  1.63489997e-01f, 1.50307715e-01f, 9.87016261e-02f, 4.33029756e-02f, 1.59612045e-01f, 1.46774873e-02f, 4.45273742e-02f, -8.95304084e-02f, -1.81953236e-02f, 1.94991112e-01f,
  -2.62121558e-01f, -1.05004765e-01f, 2.24168211e-01f, -8.77761096e-02f, 1.83300689e-01f, 2.78497308e-01f, 1.99903265e-01f, -2.79412508e-01f, 1.34901777e-01f, 1.93570212e-01f,
  2.42095426e-01f, -1.84506655e-01f, -1.40332207e-01f, 1.48887783e-01f, -2.10264236e-01f, -3.75110395e-02f, 4.30070125e-02f, -1.29798144e-01f, -8.80306736e-02f, -4.78112847e-01f,
  4.74008322e-02f, 3.43408547e-02f, -3.18570822e-01f, 1.24394484e-01f, 1.30198002e-01f, 2.14077875e-01f, -1.34093821e-01f, 2.91364998e-01f, -2.20807809e-02f, -3.30785424e-01f,
  2.45157883e-01f, 3.14942718e-01f, -1.12500377e-01f, -1.87038556e-01f, 8.67268909e-03f, -1.67254299e-01f, 1.16876654e-01f, -1.51552632e-01f, 3.57671529e-01f, -2.13050365e-01f,
  3.10184330e-01f, -1.07287601e-01f, 5.41966915e-01f, -3.92594397e-01f, -3.39674145e-01f, 5.02415821e-02f, 1.55505138e-02f, -1.89373314e-01f, 5.46221808e-02f, -3.70385736e-01f,
  5.97856520e-03f, -3.58618088e-02f, -6.24154568e-01f, -1.48802400e-02f, -5.06249130e-01f, 2.24064752e-01f, 2.74178833e-01f, 2.35471338e-01f, -1.09782033e-01f, 1.12714179e-01f,
  3.07287782e-01f, -2.53504127e-01f, -1.02988090e-02f, -8.59842170e-03f, 9.51298326e-02f, 2.25102603e-01f, 3.24610263e-01f, 1.37591004e-01f, -2.21595928e-01f, -3.20244461e-01f,
  6.01840556e-01f, 1.32456988e-01f, -3.09532166e-01f, -1.36368886e-01f, -4.78318706e-02f, 2.38833085e-01f, 3.09618145e-01f, -2.64552206e-01f, 5.46740321e-03f, 2.88560480e-01f,
  -7.85175487e-02f, 1.43805549e-01f, 1.08787969e-01f, 3.04429024e-01f, -3.57078053e-02f, -8.10965709e-03f, -5.22149652e-02f, -2.91431218e-01f, -8.45365152e-02f, 1.43222243e-01f,
  -1.47685379e-01f, -6.59257844e-02f, 8.67599919e-02f, 2.54069895e-01f, 3.61915827e-02f, 1.34482443e-01f, -6.45109296e-01f, -4.98425633e-01f, 1.14396773e-01f, 4.04499233e-01f,
  2.09389821e-01f, 2.93411046e-01f, -3.58367711e-01f, 1.00022525e-01f, 4.40845676e-02f, 1.82560757e-01f, -1.08384907e-01f, -2.55638093e-01f, 4.75295961e-01f, 7.48396665e-03f,
  4.53313366e-02f, -1.34370178e-01f, -5.48021317e-01f, -5.26207462e-02f, 8.54441896e-02f, -6.30116880e-01f, -3.40308040e-01f, 5.34480028e-02f, 4.83084857e-01f, 1.58572078e-01f,
  -1.91516802e-01f, 2.93108642e-01f, 1.31075367e-01f, 1.70803681e-01f, -5.84945232e-02f, 1.64073035e-01f, -5.06082661e-02f, 2.97316819e-01f, -2.75000185e-01f, -7.37896115e-02f,
  -2.21770890e-02f, -1.24651030e-01f, -4.80881184e-02f, 8.31873566e-02f, -3.39158662e-02f, -3.32703963e-02f, 6.34772837e-01f, -5.24453402e-01f, 4.53210056e-01f, -1.70224030e-02f,
  -4.70436439e-02f, 1.18128195e-01f, -1.58995777e-01f, 2.43865401e-01f, -9.42835286e-02f, -2.28909537e-01f, -8.82259086e-02f, -2.68084109e-01f, -4.25713599e-01f, 1.25978589e-01f,
  -4.74116832e-01f, -1.06909566e-01f, 4.02235001e-01f, 2.98715323e-01f, 1.22924224e-01f, 1.63457558e-01f, 3.72253686e-01f, 2.68787593e-01f, -1.03401199e-01f, 3.45619321e-01f,
  2.32365027e-01f, 1.10273279e-01f, 4.40060854e-01f, 2.35680029e-01f, 1.56905875e-01f, 3.97163212e-01f, 5.85813858e-02f, 4.52932835e-01f, -1.47245318e-01f, 3.54967803e-01f,
  -2.71984339e-01f, 2.31789976e-01f, 3.44546624e-02f, -2.56610543e-01f, -3.59600963e-04f, 2.98834562e-01f, -3.31597954e-01f, 2.80377150e-01f, 2.61583120e-01f, -7.25823790e-02f,
  -2.60547042e-01f, 6.95314780e-02f, 4.53875996e-02f, -2.63987985e-02f, -9.71043389e-03f, 1.65823892e-01f, -7.27029070e-02f, 8.74280035e-02f, 3.27514321e-01f, -1.29530534e-01f,
  1.79181904e-01f, -1.45466462e-01f, 3.57014656e-01f, -3.83989662e-02f, 2.48671800e-01f, 1.32606253e-02f, -6.50307715e-01f, -1.00801088e-01f, 5.60233414e-01f, -7.91695938e-02f,
  -3.12281132e-01f, -1.38893902e-01f, -2.50259310e-01f, 8.67606699e-02f, 3.71524245e-01f, -5.63976526e-01f, 1.41824976e-01f, 3.78171243e-02f, 1.32272109e-01f, -2.28916049e-01f,
  -3.51370245e-01f, 4.35738027e-01f, 2.40189508e-02f, 1.01174600e-01f, -4.22216207e-01f, -3.73460799e-01f, 4.33732271e-02f, -2.97218591e-01f, 1.01719007e-01f, 5.35209440e-02f,
  1.16249077e-01f, 1.34437531e-01f, -1.20751441e-01f, 9.38082188e-02f, -4.79888529e-01f, 1.28628567e-01f, -2.65530467e-01f, 3.89453709e-01f, 1.98357061e-01f, -1.03418104e-01f,
  -3.14075947e-01f, 8.94574821e-02f, -2.61772722e-01f, 4.36819196e-01f, 1.35544077e-01f, -4.46826369e-01f, -2.40369022e-01f, 3.07372510e-01f, 1.26433745e-01f, -1.30513921e-01f,
  6.47878528e-01f, 6.06523938e-02f, 2.74267211e-03f, -1.24077119e-01f, 1.94225177e-01f, -1.26464874e-01f, 2.15787247e-01f, 2.32929617e-01f, -2.37382382e-01f, -3.36805061e-02f,
  2.62288630e-01f, 2.68140703e-01f, 4.06985462e-01f, 4.12739694e-01f, 2.09832013e-01f, 2.69567609e-01f, -3.79270554e-01f, -5.63445911e-02f, -5.02232730e-01f, 8.62527341e-02f,
  2.95234799e-01f, -2.12848067e-01f, -4.03960496e-01f, -1.52831808e-01f, -1.36002362e-01f, 2.12903336e-01f, 1.08787104e-01f, -3.89744371e-01f, 1.94598019e-01f, 4.05361682e-01f,
  4.25157487e-01f, -3.46225232e-01f, 3.87744576e-01f, -4.82786354e-03f, 1.71188816e-01f, -1.67935282e-01f, -2.86857277e-01f, -9.49563738e-03f, 2.57976264e-01f, 1.61566392e-01f,
  -1.06664285e-01f, -6.38788491e-02f, 4.70351204e-02f, 3.18298906e-01f, 2.68540084e-01f, -3.66730869e-01f, -9.22313035e-02f, -1.04086518e-01f, 2.11317107e-01f, 9.64023098e-02f,
  4.28904533e-01f, -6.77649048e-04f, -1.60183355e-01f, -4.01783317e-01f, 3.08493644e-01f, -5.83698675e-02f, -1.22007704e-03f, 1.49809971e-01f, 1.47409752e-01f, 4.79961745e-02f,
  1.82938039e-01f, 1.41935468e-01f, 1.41602382e-01f, 1.07843794e-01f, 7.15921998e-01f, -1.11992903e-01f, -2.91536719e-01f, 5.32088041e-01f, 1.42011652e-02f, -3.19550365e-01f,
  -2.11334884e-01f, 1.67570695e-01f, -1.34241134e-01f, -8.39099754e-03f, 1.14156738e-01f, 2.77651101e-01f, 2.03201041e-01f, 1.75430536e-01f, 5.56177795e-02f, 2.40687996e-01f,
  -1.09071806e-01f, 1.98983580e-01f, -1.80184573e-01f, 3.03364813e-01f, 1.91328779e-01f, -5.49120642e-02f, 4.20321941e-01f, -3.06193322e-01f, -1.22298390e-01f, 1.06816344e-01f,
  -1.61003858e-01f, 1.80333048e-01f, 1.25447763e-02f, 5.97191155e-02f, 1.69609323e-01f, -3.09187055e-01f, -1.66033983e-01f, 2.81968694e-02f, 1.63951799e-01f, 1.93310753e-01f,
  -2.54298776e-01f, -4.77216206e-02f, 1.90701168e-02f, 3.02291453e-01f, 1.29801229e-01f, 9.98692065e-02f, 1.64069280e-01f, 1.01681747e-01f, 6.48408085e-02f, 2.07848892e-01f,
  1.69661731e-01f, 2.50695467e-01f, 8.73664245e-02f, 4.22434896e-01f, -2.04409927e-01f, 1.62554398e-01f, 2.50841916e-01f, 1.35270789e-01f, 3.00865322e-01f, -9.00313258e-02f,
  -3.22761200e-02f, 4.37018216e-01f, -2.78153628e-01f, 1.68174192e-01f, -2.70611495e-01f, 2.58540809e-01f, -9.25912615e-03f, -3.81437957e-01f, 1.64519370e-01f, -2.49458998e-02f,
  2.43829519e-01f, 3.27175669e-02f, -1.91116527e-01f, -2.66461879e-01f, -7.07042441e-02f, 3.92637342e-01f, 9.91644785e-02f, 1.06173214e-02f, 1.92521572e-01f, 8.44899788e-02f,
  2.75238603e-01f, 3.07452977e-01f, -1.32280082e-01f, 4.34667198e-03f, 1.40694812e-01f, -4.01162356e-01f, 3.89456064e-01f, 4.54440489e-02f, 2.73410827e-01f, 2.78024971e-01f,
  -6.61759824e-02f, 4.23745900e-01f, -2.07554344e-02f, 2.07185984e-01f, -3.28193535e-03f, 2.41360530e-01f, -5.82531989e-01f, -1.69446349e-01f, -3.34961742e-01f, 4.50020224e-01f,
  1.70327842e-01f, -1.53385758e-01f, -3.23622487e-02f, 1.50117487e-01f, 1.21606320e-01f, 4.69467938e-01f, -1.95598379e-01f, 8.75055641e-02f, 8.61539468e-02f, 2.93542564e-01f,
  1.77344471e-01f, 2.76136249e-01f, 1.70959145e-01f, 4.45575230e-02f, 8.46607611e-02f, 3.12898606e-01f, 2.61492610e-01f, -1.96373045e-01f, 8.34618807e-02f, -1.31022796e-01f,
  1.15833975e-01f, 3.79181832e-01f, -1.42084017e-01f, 2.26982027e-01f, 1.49469092e-01f, 2.62432814e-01f, 1.08476251e-01f, 2.13825598e-01f, -2.59082705e-01f, 9.26648080e-02f,
  -2.97309875e-01f, 1.81849614e-01f, -8.29956084e-02f, -2.01470569e-01f, -5.72518185e-02f, -1.56791061e-01f, -3.80728781e-01f, -1.10020183e-01f, -1.19538017e-01f, 1.07846096e-01f,
  1.55447777e-02f, 1.60565272e-01f, 4.08132762e-01f, 8.71275961e-02f, -3.25424403e-01f, 3.95848811e-01f, 2.13859215e-01f, 7.82590136e-02f, -6.52204677e-02f, 4.78156880e-02f,
  -6.75675571e-02f, 6.74994290e-02f, 1.06201787e-02f, 2.69258708e-01f, -4.44852412e-01f, -5.97419180e-02f, -1.28302783e-01f, 5.17864347e-01f, -4.29716110e-01f, 2.77920544e-01f,
  -2.18954816e-01f, -2.60075957e-01f, -1.49443001e-01f, -2.39755884e-01f, -1.47697464e-01f, 6.41385280e-03f, -2.79804580e-02f, -3.52531999e-01f, -6.30149543e-02f, -6.00179881e-02f,
  -3.43128294e-01f, 3.02955568e-01f, -8.79583508e-02f, 1.73337117e-01f, 1.34711504e-01f, 6.88887984e-02f, 2.24415049e-01f, -1.51811972e-01f, 2.54932314e-01f, 1.69227883e-01f,
  -1.91883683e-01f, -3.04118514e-01f, -1.02037095e-01f, 6.43411130e-02f, 2.36503184e-01f, -5.50676771e-02f, 3.04623067e-01f, -1.40711367e-01f, 3.03859919e-01f, -1.94415152e-01f,
  1.89294696e-01f, -3.52764428e-01f, 4.48213816e-02f, 7.22056851e-02f, 1.10127240e-01f, 8.98839012e-02f, -2.07988620e-01f, -2.69712210e-01f, -1.63236819e-02f, -2.39726782e-01f,
  -4.69328195e-01f, -5.87976314e-02f, -7.80950487e-02f, 2.57724136e-01f, 2.15382233e-01f, 7.71307126e-02f, 1.88016370e-01f, 1.77568749e-01f, 4.72248241e-04f, 1.82540834e-01f,
  2.20458865e-01f, 1.60242483e-01f, 8.56357068e-02f, 1.01359472e-01f, 7.88193569e-02f, 1.94560349e-01f, -5.48858829e-02f, -5.77529296e-02f, 2.49146909e-01f, 8.36093202e-02f,
  3.36572051e-01f, -4.94828969e-01f, 4.08295274e-01f, 1.47232652e-01f, 3.85602802e-01f, 1.51458278e-01f, 9.75004397e-03f, 1.70968369e-01f, -2.81888962e-01f, 1.69060454e-02f,
  1.50488272e-01f, -3.87936711e-01f, 9.82638225e-02f, 6.31332636e-01f, -3.47952902e-01f, -3.06585371e-01f, 3.61356616e-01f, 2.31950030e-01f, 2.67100781e-01f, 1.82509154e-01f,
  6.17932379e-02f, 1.17667988e-01f, -3.23303789e-02f, 1.41727820e-01f, 1.49397135e-01f, -3.21867645e-01f, 7.91601762e-02f, 5.93160801e-02f, 1.95260957e-01f, -1.21614069e-01f,
  -1.53054014e-01f, -1.07347593e-01f, 2.71194249e-01f, 2.52397507e-01f, 2.10116968e-01f, 1.35461107e-01f, 2.87115067e-01f, 4.49528515e-01f, 1.72213130e-02f, -1.71272576e-01f,
  -2.44037673e-01f, 7.16254264e-02f, -9.87679586e-02f, -4.34351802e-01f, -2.03720540e-01f, -1.90713599e-01f, 1.14234649e-01f, 2.33027309e-01f, -1.41006947e-01f, -3.72492080e-03f,
  1.04957424e-01f, -7.40264356e-02f, 7.60420412e-02f, -1.15594223e-01f, -1.18059389e-01f, 2.26652876e-01f, -4.94810253e-01f, -9.75674763e-02f, -2.14168012e-01f, 2.89431989e-01f,
  -1.79047912e-01f, 3.43458056e-01f, -3.32878023e-01f, -9.74083021e-02f, 3.30115795e-01f, 1.63699433e-01f, 5.41337393e-02f, -6.45911276e-01f, 1.76229700e-01f, -1.58318773e-01f,
  1.91298187e-01f, 2.23450914e-01f, -1.94183901e-01f, -1.91340744e-01f, 8.27448517e-02f, -6.88565135e-01f, -1.41552314e-01f, 1.22794174e-01f, -1.37024626e-01f, 1.62768394e-01f,
  2.79569119e-01f, 1.78143531e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.25249124e-01f, 2.06899807e-01f, 2.42053196e-01f, 4.81714785e-01f, 1.84657618e-01f, 1.65705115e-01f, -2.92857617e-01f, 3.69562730e-02f, 1.97273456e-02f, 1.66406050e-01f,
  2.61620820e-01f, -3.41153219e-02f, 3.00641656e-01f, 5.11593074e-02f, 2.11397409e-01f, 2.20227823e-01f, 2.56619871e-01f, 2.22799942e-01f, 2.92752028e-01f, 2.11721048e-01f,
  1.16948068e-01f, 9.94882509e-02f, 3.23852897e-02f, 3.06524406e-03f, 3.95319253e-01f, -1.70336068e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.80308744e-01f, 1.06765606e-01f, 1.92491010e-01f, -1.38417885e-01f, 2.20935076e-01f, 1.75427832e-02f, -1.86462715e-01f, 7.43110776e-02f, 2.27680832e-01f, -1.21656526e-02f,
  -1.58241451e-01f, 4.28337827e-02f, -1.18575029e-01f, 5.25716227e-03f, -1.19262606e-01f, -2.37941332e-02f, -1.28001377e-01f, -1.27910212e-01f, 1.26726866e-01f, 1.02093332e-01f,
  -3.11130345e-01f, 7.13612884e-02f, -3.86493020e-02f, 2.29745328e-01f, 1.58981487e-01f, 2.08616391e-01f, -3.01696192e-02f, -1.48007050e-01f, -1.17569454e-01f, -1.05619229e-01f,
  -1.96728513e-01f, -7.35736126e-03f, -3.94141167e-01f, 1.44663483e-01f, -1.26135796e-02f, -4.47673529e-01f, -2.53242433e-01f, -1.79937661e-01f, -2.96811666e-02f, 3.31331730e-01f,
  5.56039773e-02f, -1.47713289e-01f, 1.22651488e-01f, -1.68746024e-01f, -1.01772517e-01f, 5.76096736e-02f, -1.16604604e-01f, 1.25868440e-01f, -6.47213310e-02f, 1.98053196e-01f,
  -1.67011917e-01f, 4.08935845e-02f, 2.26514637e-01f, 7.16657490e-02f, 1.69238642e-01f, -6.75096959e-02f, 2.21013010e-01f, 1.05892561e-01f, -2.27808282e-01f, -1.52616284e-03f,
  5.72397746e-02f, 1.69483051e-01f, -1.28089994e-01f, -1.33957401e-01f, 9.18620080e-02f, 2.09799722e-01f, 1.54361933e-01f, 3.30693215e-01f, -2.84675628e-01f, -1.72986165e-02f,
  -5.52802794e-02f, 4.68976656e-03f, -1.82354182e-01f, 1.48481518e-01f, -2.18223497e-01f, -1.72326192e-02f, -4.36708964e-02f, 9.41212922e-02f, -1.48543194e-01f, -5.02401330e-02f,
  1.85048297e-01f, 1.64830834e-01f, 5.33653870e-02f, -2.22365379e-01f, 2.16466472e-01f, 2.38501113e-02f, -2.28634626e-01f, 9.78313982e-02f, 2.46276677e-01f, -1.36188284e-01f,
  -3.91909182e-02f, 3.20363864e-02f, -6.61749244e-02f, 1.82957396e-01f, 1.26929924e-01f, 4.48816456e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.02537282e-01f, 9.75319669e-02f, 2.90089250e-01f, 3.14602226e-01f, -5.87150335e-01f, -4.25291568e-01f, 1.77673131e-01f, 2.46350709e-02f, -4.44119759e-02f, 1.29698962e-01f,
  1.55556025e-02f, 1.76337600e-01f, -4.58858937e-01f, 1.99056551e-01f, 4.23467427e-01f, -1.20198764e-01f, 3.99156064e-01f, 2.19015375e-01f, 8.01755413e-02f, -2.66625524e-01f,
  -5.28773516e-02f, -3.72392982e-02f, -6.98563531e-02f, -9.32090133e-02f, -4.16369848e-02f, 2.25138173e-01f, 4.04825509e-01f, -2.11767666e-02f, 5.21138012e-01f, 3.38200569e-01f,
  2.66001582e-01f, -1.08652018e-01f, 2.74115324e-01f, 2.67251074e-01f, 3.79630089e-01f, 3.96822393e-01f, 7.44206831e-02f, -2.19553232e-01f, 2.61436790e-01f, -1.87825840e-02f,
  8.99589900e-03f, -3.66958767e-01f, -2.18552336e-01f, 3.26942414e-01f, -2.07745835e-01f, 1.36183100e-02f, 1.19417347e-01f, 3.13482597e-03f, 5.98903537e-01f, -2.69952327e-01f,
  2.05331594e-01f, -1.82379484e-01f, 8.95459726e-02f, 2.61737227e-01f, -4.03559178e-01f, 1.31557241e-01f, 2.91081667e-01f, -6.01080386e-03f, 2.48586506e-01f, 3.69855613e-01f,
  1.09188505e-01f, -1.04011349e-01f, 2.87677020e-01f, -1.78900003e-01f, 6.06295645e-01f, 2.94446588e-01f, 2.15093836e-01f, 3.73408228e-01f, -5.25173366e-01f, -2.15711251e-01f,
  2.87044972e-01f, -2.02951208e-01f, 1.33336678e-01f, 6.07995868e-01f, -1.89698026e-01f, 1.83520764e-01f, -6.19902670e-01f, -5.03407605e-02f, 1.89119019e-02f, -2.32400060e-01f,
  2.08593056e-01f, -2.43101835e-01f, 1.43020406e-01f, 5.07534528e-03f, 1.88034832e-01f, 2.30590314e-01f, 8.96041691e-02f, 1.00882657e-01f, -1.08052073e-02f, 1.65158391e-01f,
  3.97202969e-01f, 1.95064545e-01f, 1.51729092e-01f, -3.36587131e-01f, 3.07045102e-01f, -2.83480376e-01f, -2.96386451e-01f, 1.52604487e-02f, 4.09130938e-02f, -4.69110981e-02f,
  1.44250587e-01f, 2.68797517e-01f, 7.34246895e-03f, 4.85405475e-01f, 4.21366878e-02f, -3.30567449e-01f, -2.59713978e-01f, -9.06456634e-03f, 1.99073613e-01f, 1.63508117e-01f,
  1.00853592e-01f, 2.25594401e-01f, -3.46015513e-01f, 3.26570570e-01f, -1.00238360e-01f, 8.18944275e-02f, 1.90344363e-01f, 9.19622853e-02f, 1.04503855e-01f, 2.43672565e-01f,
  -4.71494123e-02f, -8.35211109e-03f, -1.37895092e-01f, -7.16196373e-02f, -5.25730625e-02f, 1.74481735e-01f, -6.25538826e-02f, 9.34502389e-03f, -1.24967590e-01f, 4.74771373e-02f,
  -7.81807229e-02f, -3.70615810e-01f, 2.80793935e-01f, 1.60492718e-01f, -5.73299080e-02f, 2.53297627e-01f, 2.43566021e-01f, -2.22593993e-01f, -2.00360045e-01f, -6.89755604e-02f,
  -2.35110372e-01f, -1.53582990e-01f, -3.13905001e-01f, 1.48696601e-01f, -3.75017732e-01f, -1.33792371e-01f, -1.26566729e-02f, 1.55475184e-01f, -2.28030309e-02f, 9.43334680e-03f,
  1.43287376e-01f, 2.84628958e-01f, 2.42681742e-01f, -1.06510527e-01f, -4.70313787e-01f, -4.03351858e-02f, -3.14340055e-01f, -1.34897590e-01f, -1.43099934e-01f, -1.39295027e-01f,
  -2.84122862e-02f, -1.67204052e-01f, -2.94012658e-04f, -4.13254738e-01f, 5.41882098e-01f, 4.79299396e-01f, -2.04516366e-01f, -5.09720981e-01f, 1.74628347e-01f, -9.26413089e-02f,
  5.74835658e-01f, -8.93714949e-02f, -7.79334605e-02f, -1.40182331e-01f, -3.05545300e-01f, -8.94886926e-02f, -2.27335170e-01f, -2.56089889e-03f, 9.77709070e-02f, -2.31879056e-02f,
  -5.47389269e-01f, -1.57211795e-01f, -8.57702717e-02f, -4.91684407e-01f, -5.22284687e-01f, 2.13863447e-01f, 2.26964466e-02f, -3.69967014e-01f, -2.01524854e-01f, 2.42028892e-01f,
  1.16086110e-01f, -2.68180758e-01f, -5.95706105e-01f, 3.38799767e-02f, 1.01179346e-01f, -9.15678293e-02f, -1.08966805e-01f, -2.51349419e-01f, 3.90474290e-01f, 1.71662971e-01f,
  -6.23329997e-01f, -2.69438326e-01f, -1.19030803e-01f, -1.00576237e-01f, -6.28439933e-02f, 2.50303835e-01f, 1.05928458e-01f, -7.08528534e-02f, 1.52750835e-01f, 5.59673235e-02f,
  3.92750911e-02f, 5.65722957e-02f, -3.70322354e-02f, 5.52173018e-01f, -2.84203261e-01f, 2.67373025e-01f, 3.66930157e-01f, -3.09695512e-01f, -7.10844174e-02f, 3.91055420e-02f,
  -6.24892265e-02f, 2.68858135e-01f, 2.04770073e-01f, 5.01422226e-01f, -2.14619473e-01f, -8.00370127e-02f, -2.56677002e-01f, -3.38347673e-01f, 3.19534093e-01f, -1.36654913e-01f,
  1.37027755e-01f, -2.29767129e-01f, -4.28340703e-01f, -1.02323532e-01f, -1.28128435e-02f, 3.67561013e-01f, 3.07125878e-02f, 2.66160011e-01f, 2.59748459e-01f, -1.66017920e-01f,
  8.62262100e-02f, 4.43346500e-01f, -1.96303539e-02f, 1.32955134e-01f, 1.18611746e-01f, -4.09473144e-02f, -3.01404446e-01f, 9.16425362e-02f, 8.06635022e-02f, -2.63497889e-01f,
  8.30932483e-02f, 3.46193105e-01f, 2.56141663e-01f, 1.41764000e-01f, -1.56581327e-01f, 5.17171800e-01f, -5.02952695e-01f, -2.29586616e-01f, -5.85815497e-02f, -7.14228302e-02f,
  -1.29325822e-01f, -4.60155338e-01f, 2.30880395e-01f, -1.02208078e-01f, -1.99994221e-01f, 4.28286731e-01f, 5.43044787e-03f, -3.66710089e-02f, 4.96860556e-02f, 1.64314047e-01f,
  3.48296195e-01f, -3.84974718e-01f, -3.80604714e-02f, -2.60151904e-02f, -3.25833976e-01f, -2.79937953e-01f, 2.18585983e-01f, 4.12865847e-01f, 2.69686580e-01f, 1.12740956e-01f,
  1.28894061e-01f, -3.58927816e-01f, 5.86434565e-02f, 7.71883875e-02f, 1.80200174e-01f, -1.25544161e-01f, -5.76251326e-03f, 3.91838290e-02f, -1.02055512e-01f, 3.70465636e-01f,
  2.96580754e-02f, -1.69547722e-01f, -1.83770403e-01f, -5.02155125e-01f, -2.37826183e-02f, -1.15936041e-01f, 2.57810593e-01f, -5.07426970e-02f, -5.44871688e-01f, -3.08078647e-01f,
  -2.81567603e-01f, -7.12991655e-02f, -2.10690498e-01f, 2.76591659e-01f, -4.75191623e-01f, 8.61934647e-02f, 4.22495842e-01f, 4.51104671e-01f, -2.40070999e-01f, 8.38042647e-02f,
  4.94747996e-01f, 2.69833934e-02f, 2.06249207e-01f, 2.28055835e-01f, 1.16965570e-01f, -4.52507883e-02f, -1.72055606e-02f, -1.68527275e-01f, -2.50116549e-02f, -1.73729464e-01f,
  -1.17836565e-01f, 2.01974675e-01f, 1.55840769e-01f, -3.33581805e-01f, 1.87094316e-01f, 3.51590723e-01f, -3.49833816e-01f, -7.24548921e-02f, 4.92287055e-03f, -7.91029930e-02f,
  1.11232527e-01f, -3.14703703e-01f, -3.55275512e-01f, -3.59539539e-01f, -3.46666962e-01f, 2.97412783e-01f, -3.12492251e-01f, -2.46889338e-01f, 1.59797505e-01f, 3.35604757e-01f,
  -1.33403450e-01f, 1.08413748e-01f, 2.50203758e-01f, 1.37096539e-01f, 1.67269751e-01f, 4.40988466e-02f, -1.02989800e-01f, -2.59231687e-01f, -3.04341078e-01f, 1.60589546e-01f,
  -1.46434143e-01f, -2.99788658e-02f, 3.07321995e-01f, 2.18671620e-01f, 1.81500673e-01f, -2.74422020e-01f, -8.16858232e-01f, -2.69240052e-01f, -5.17672181e-01f, 8.78116582e-03f,
  -1.39676601e-01f, 3.58571708e-01f, -4.83461291e-01f, -6.18914485e-01f, -1.76165849e-01f, -2.63312966e-01f, -5.61544061e-01f, -3.37520652e-02f, 4.43963148e-02f, -1.77262530e-01f,
  9.66042206e-02f, 4.76334691e-01f, 6.64303452e-02f, 6.34534955e-02f, 2.55454659e-01f, -1.12243302e-01f, -3.64741795e-02f, -1.52826486e-02f, 3.97226550e-02f, -2.15150088e-01f,
  -2.06154227e-01f, 2.44916797e-01f, 9.23751444e-02f, -5.97620790e-04f, 4.38844889e-01f, 3.26854646e-01f, 2.12152064e-01f, -4.03213978e-01f, 4.89108324e-01f, 1.84333682e-01f,
  5.23483574e-01f, -1.12443522e-03f, 2.96367258e-02f, 5.21677792e-01f, 2.97449619e-01f, 1.25065129e-02f, 2.29838639e-01f, -6.13046698e-02f, -6.16505027e-01f, -5.37440300e-01f,
  -6.07959211e-01f, -6.99990928e-01f, -5.41970670e-01f, 6.15732037e-02f, 4.72200900e-01f, 3.59551460e-01f, 1.23251267e-01f, -1.78142354e-01f, 1.77255452e-01f, 4.06077579e-02f,
  -6.29751563e-01f, 2.33509436e-01f, -6.53386533e-01f, -7.89271533e-01f, -4.12920207e-01f, -2.72624761e-01f, 1.22652680e-01f, 1.89143568e-01f, -3.21827382e-02f, -4.58577394e-01f,
  -1.16027147e-01f, -2.69033741e-02f, -6.93383366e-02f, -3.10985804e-01f, 5.54504879e-02f, 4.35519516e-01f, 4.52089846e-01f, 8.13632980e-02f, -1.84030861e-01f, 1.30225360e-01f,
  2.80137062e-01f, 3.20470668e-02f, -4.87807244e-01f, 8.17977637e-02f, 1.80596218e-01f, 1.21194139e-01f, -1.21839102e-02f, 9.81402695e-02f, 2.09609851e-01f, 2.77014766e-02f,
  9.37608331e-02f, 1.46783248e-01f, 1.65102616e-01f, 3.98416892e-02f, 4.76990314e-03f, 9.21321586e-02f, -1.55228078e-01f, -2.71455258e-01f, 1.54413581e-01f, 3.72334480e-01f,
  3.92784998e-02f, -2.46265486e-01f, -6.00250900e-01f, -7.03701615e-01f, -3.30713272e-01f, 1.20735556e-01f, -1.29053608e-01f, 4.32309479e-01f, 6.47602528e-02f, -4.00500804e-01f,
  -4.45164144e-01f, -1.55133680e-01f, 2.10799843e-01f, 1.28967166e-01f, -3.70938256e-02f, 1.44826204e-01f, -7.27471486e-02f, 2.42672876e-01f, 2.12459370e-01f, 3.22930485e-01f,
  4.46694851e-01f, 9.27401707e-02f, 4.87401597e-02f, -1.25323124e-02f, -3.45082991e-02f, -3.99637461e-01f, 1.77402154e-01f, -3.33164781e-02f, 3.27406377e-01f, -3.02802827e-02f,
  -8.51718634e-02f, -8.34035575e-02f, -2.42842548e-02f, -1.55219018e-01f, 2.01581091e-01f, -8.14796891e-03f, 4.09759581e-01f, -3.77226770e-01f, 1.82345614e-01f, -4.20922339e-01f,
  1.34778470e-01f, 6.76288828e-02f, -2.91287005e-01f, 1.68341070e-01f, 2.32215121e-01f, 8.39323848e-02f, 7.69103393e-02f, 1.84122369e-01f, 3.75211954e-01f, 1.74528752e-02f,
  -2.84119576e-01f, -3.44036043e-01f, 5.18166833e-02f, -2.67943650e-01f, -2.18378946e-01f, 4.55944866e-01f, 9.32152644e-02f, 6.39190078e-02f, 1.35310411e-01f, 1.86877251e-01f,
  -1.34971915e-02f, -1.37665376e-01f, -1.95782054e-02f, 1.28889114e-01f, 3.07695091e-01f, -6.48334742e-01f, -2.61609823e-01f, 2.29863450e-01f, -2.15379998e-01f, 2.39225894e-01f,
  6.70127869e-02f, 1.06801808e-01f, -1.60496399e-01f, -2.37692699e-01f, 5.46368770e-02f, -4.00188982e-01f, -4.60516006e-01f, 3.43479365e-01f, -2.18561694e-01f, -1.35022372e-01f,
  -2.67147273e-03f, 4.78432178e-01f, -7.98262507e-02f, -5.38062602e-02f, 3.40441495e-01f, -1.72408342e-01f, -3.45267385e-01f, 2.46907026e-01f, -1.50439739e-01f, -2.23155946e-01f,
  -4.77208942e-01f, 2.90168840e-02f, -1.76423892e-01f, -2.66340822e-01f, -2.97405779e-01f, -6.97746202e-02f, -3.69427145e-01f, -1.06139079e-01f, 2.71150261e-01f, 2.12266788e-01f,
  3.10332358e-01f, -9.59704220e-02f, 4.37357932e-01f, -3.47561151e-01f, -3.45126927e-01f, 1.37590870e-01f, -6.69438392e-02f, -1.01234891e-01f, -3.33045214e-01f, 1.69932336e-01f,
  1.23790298e-02f, -2.70876825e-01f, 2.02862203e-01f, 1.02755785e-01f, -4.35756370e-02f, -3.94312069e-02f, 1.75743505e-01f, 1.71725571e-01f, 1.54287830e-01f, 2.88114190e-01f,
  1.22417852e-01f, 3.92320782e-01f, -2.81219155e-01f, -2.73440570e-01f, -9.83959064e-02f, -1.21413141e-01f, 9.31263342e-02f, 1.41683042e-01f, 3.29231888e-01f, -2.17744291e-01f,
  -3.81684780e-01f, 3.47963452e-01f, -4.41333532e-01f, 3.03989828e-01f, -8.58692750e-02f, -1.21649720e-01f, -1.31631911e-01f, -1.34194002e-01f, -2.57979870e-01f, -3.70573491e-01f,
  -4.17572856e-01f, 2.31496215e-01f, -1.38402119e-01f, -8.29231739e-02f, 2.27457359e-02f, 3.08889091e-01f, -2.68105090e-01f, -8.76557007e-02f, 1.37085214e-01f, 2.48882860e-01f,
  8.81625861e-02f, -3.47062439e-01f, -4.61934268e-01f, -3.45175862e-01f, -3.66276830e-01f, 1.45933360e-01f, -1.20250612e-01f, 1.02910087e-01f, -2.07406446e-01f, 1.81547582e-01f,
  -6.84291199e-02f, -3.00167829e-01f, -1.61853686e-01f, -6.12078369e-01f, 7.91126043e-02f, -5.26152141e-02f, -5.69561243e-01f, 5.45436859e-01f, 3.00495774e-01f, 1.64711550e-02f,
  -3.31758261e-01f, 1.16085768e-01f, 1.12533018e-01f, -6.59410581e-02f, 1.08818986e-01f, 3.15275729e-01f, -3.08279186e-01f, -1.64674833e-01f, -1.47651359e-01f, 2.48696312e-01f,
  6.03348128e-02f, 3.74590047e-02f, 1.19202964e-01f, -5.25215447e-01f, -2.34601460e-02f, -1.41775787e-01f, 2.69065559e-01f, 2.56313324e-01f, 1.48835823e-01f, 2.64970183e-01f,
  -1.12783231e-01f, -1.69601694e-01f, -2.07513750e-01f, -2.85827368e-01f, 4.36829507e-01f, 3.31954122e-01f, -2.82418281e-01f, -2.05331460e-01f, 5.99006675e-02f, -4.25513744e-01f,
  2.97895581e-01f, 1.58634949e-02f, 2.55815208e-01f, 1.65879652e-02f, -6.60898313e-02f, 1.14263922e-01f, 5.90920681e-03f, 1.07034042e-01f, 1.75299510e-01f, -7.55014494e-02f,
  1.47803888e-01f, -1.88244388e-01f, -5.40543534e-02f, -1.57162681e-01f, -4.18131053e-01f, 3.25106382e-01f, 4.58104610e-02f, -2.34956175e-01f, -1.62821203e-01f, 4.36504871e-01f,
  -2.13464096e-01f, 1.37646034e-01f, -3.53042006e-01f, 2.02409208e-01f, 2.98728496e-01f, 1.03482813e-01f, -1.26394138e-01f, 5.05815819e-02f, 1.03690214e-01f, 1.64254799e-01f,
  6.23045936e-02f, -1.12377256e-01f, -5.38110435e-01f, 2.60532320e-01f, -9.68932062e-02f, -1.45446613e-01f, -3.92502755e-01f, 9.09330472e-02f, 2.63907909e-01f, -5.42512119e-01f,
  2.40930408e-01f, 1.18143581e-01f, 2.07474396e-01f, 4.54062581e-01f, -9.79637206e-02f, 2.02225178e-01f, 4.35115665e-01f, -2.29300782e-01f, -1.20246671e-01f, 3.16803098e-01f,
  -1.22289747e-01f, -9.24061760e-02f, 7.66068250e-02f, 1.42094687e-01f, 6.56265080e-01f, 3.14753771e-01f, 3.86248797e-01f, -1.32584870e-01f, 4.16651249e-01f, 5.70089698e-01f,
  5.53721428e-01f, 1.79254100e-01f, 3.31252933e-01f, 2.45948181e-01f, 1.98141456e-01f, 2.67480969e-01f, -3.18195581e-01f, 1.11300750e-02f, -2.76551545e-01f, 6.23250417e-02f,
  -3.30770791e-01f, -4.80532765e-01f, 5.55503890e-02f, 2.35082269e-01f, 6.28299788e-02f, -9.07490104e-02f, 2.51437612e-02f, 6.58010244e-02f, 1.72162801e-01f, 5.18305190e-02f,
  -2.56127477e-01f, 4.47371781e-01f, -1.46043584e-01f, -2.37784386e-01f, 2.15125561e-01f, -3.71069849e-01f, -7.39634708e-02f, -1.56792048e-02f, 1.96075141e-01f, 2.76951700e-01f,
  8.39668214e-01f, 2.02196077e-01f, 4.96563435e-01f, -1.06639400e-01f, 1.71874940e-01f, -5.24610341e-01f, -1.66045092e-02f, 4.58001047e-01f, 1.06919356e-01f, 2.01581955e-01f,
  1.09846652e-01f, 1.80345140e-02f, -8.02143514e-02f, 9.30122659e-02f, 3.03880751e-01f, -2.72565454e-01f, 2.32084900e-01f, -3.09106201e-01f, -1.04785934e-01f, 1.81297943e-01f,
  3.85867655e-01f, 3.54918301e-01f, 3.75911355e-01f, 5.70269406e-01f, 1.13931440e-01f, -4.29540174e-03f, -6.63552284e-02f, -5.16638421e-02f, -3.90052870e-02f, 8.14004894e-03f,
  1.53134808e-01f, 6.14669584e-02f, 1.54603824e-01f, -1.95313785e-02f, 3.35003108e-01f, -4.15816307e-02f, -6.25139356e-01f, -3.71338129e-01f, 5.39053464e-04f, 4.72421050e-02f,
  -2.16146424e-01f, 3.72020938e-02f, -3.42369787e-02f, -2.23238796e-01f, 3.68370116e-01f, 3.57418597e-01f, 2.24158123e-01f, -8.60131383e-02f, -1.63945585e-01f, 1.15995854e-01f,
  -3.65946442e-01f, 1.61411297e-02f, -1.15264170e-01f, -1.95510402e-01f, 1.80914804e-01f, 1.97294265e-01f, 2.77673453e-01f, 3.58512133e-01f, 2.41367128e-02f, 5.46899199e-01f,
  2.18328491e-01f, 2.30477139e-01f, 4.72272485e-01f, -6.37793168e-02f, -2.35711187e-01f, 1.08693585e-01f, -5.82950935e-02f, -4.49655950e-01f, 1.22576773e-01f, 3.69507462e-01f,
  5.28729379e-01f, 2.69463658e-01f, -4.33265269e-01f, -5.31785898e-02f, 4.54199672e-01f, 1.47920307e-02f, -3.01927894e-01f, 4.80417192e-01f, 9.67442095e-02f, -1.86192915e-01f,
  -3.78483951e-01f, -3.14883590e-01f, 1.66724741e-01f, -7.19178701e-03f, -7.66618177e-02f, 2.87139595e-01f, 4.19312090e-01f, 9.75596309e-02f, 3.18134844e-01f, 2.34328821e-01f,
  3.21035273e-02f, -2.36675113e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.69333631e-01f, 4.48026597e-01f, 3.65148813e-01f, -2.48236172e-02f, 1.29483357e-01f, -4.85446397e-03f, 4.94137742e-02f, -1.14107206e-01f, 2.95526758e-02f, 8.77387226e-02f,
  -4.75503728e-02f, 7.44844750e-02f, 3.02764237e-01f, 8.05199444e-02f, 3.16706121e-01f, 1.42477930e-01f, 2.92785078e-01f, 1.06152847e-01f, 4.51319152e-03f, 1.83805913e-01f,
  -1.43299541e-02f, 1.46566272e-01f, 3.33194107e-01f, 2.35396683e-01f, 3.15926641e-01f, 2.73665786e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -3.14095557e-01f, -1.82096705e-01f, -2.15805307e-01f, 2.37465516e-01f, 5.98521382e-02f, 6.96827397e-02f, -8.88874382e-02f, 1.02532700e-01f, 1.60854355e-01f, -1.04043178e-01f,
  -1.99456692e-01f, -1.31442398e-01f, -1.49285063e-01f, -6.70557693e-02f, 1.97625890e-01f, -1.16984792e-01f, -8.88249278e-02f, -2.64880061e-02f, 2.40316615e-01f, -1.89973135e-02f,
  6.82128146e-02f, 2.48953439e-02f, -1.36476666e-01f, -1.30863383e-01f, -1.67545736e-01f, -1.90905914e-01f, 2.41538920e-02f, 2.38952935e-01f, -8.92241076e-02f, -1.03684045e-01f,
  -4.99836467e-02f, -1.37556523e-01f, -7.08642602e-02f, 2.34125033e-01f, -1.63576663e-01f, -2.22061560e-01f, 1.77509621e-01f, 2.67638564e-01f, 6.56936243e-02f, 1.23169385e-01f,
  2.42710799e-01f, -6.09665364e-02f, -2.59120941e-01f, -1.82867169e-01f, -1.14803351e-01f, -2.55017638e-01f, 1.92940012e-01f, 1.22335404e-01f, -1.03600778e-01f, -1.05485553e-03f,
  6.17867988e-03f, 2.62886547e-02f, 1.20724775e-02f, 2.28916973e-01f, 1.47561515e-02f, 1.22119971e-02f, -2.30876788e-01f, 4.07421179e-02f, 1.74441695e-01f, -2.25510463e-01f,
  -2.10649669e-01f, -1.05083324e-01f, 7.69799948e-02f, -2.28878465e-02f, 4.08684492e-01f, -7.57325962e-02f, 4.16558564e-01f, 2.76723057e-01f, 3.08308482e-01f, -3.67180526e-01f,
  -1.77009165e-01f, 1.22399159e-01f, -4.20697071e-02f, -7.37104863e-02f, -4.16717492e-02f, 1.78055882e-01f, -1.76139191e-01f, 6.42081574e-02f, 1.03286356e-01f, -1.47927195e-01f,
  2.24191234e-01f, -2.37855613e-01f, 2.81163871e-01f, 2.02560559e-01f, 1.47250980e-01f, 9.25580263e-02f, -4.38297912e-02f, -1.20285384e-01f, -1.33851349e-01f, 1.34413674e-01f,
  -2.25749969e-01f, -2.25407362e-01f, -2.54908726e-02f, -5.17438687e-02f, 1.19758718e-01f, 2.16135591e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.61144990e-01f, 4.24443543e-01f, 2.05103159e-01f, 1.06705576e-01f, 1.96772516e-01f, -1.26940742e-01f, -1.19451746e-01f, -2.66839657e-03f, 3.57921422e-01f, -2.37625897e-01f,
  1.02031253e-01f, -2.72392988e-01f, -6.93046814e-03f, -4.41968292e-01f, 1.71462908e-01f, -3.70661393e-02f, -2.86671937e-01f, -7.26074502e-02f, 1.02709901e+00f, -1.41654730e-01f,
  2.08653763e-01f, 1.08111531e-01f, 3.09622139e-02f, 9.31153670e-02f, -9.01585445e-02f, -2.92697176e-02f, -1.12198209e-02f, 1.63540289e-01f, 8.63854885e-02f, -1.22652441e-01f,
  -2.38284811e-01f, -4.17659551e-01f, -4.33052659e-01f, -9.06270504e-01f, -7.13075519e-01f, 2.45416179e-01f, 1.01867178e-02f, 5.07381320e-01f, 2.04165637e-01f, 6.66400939e-02f,
  -7.45148808e-02f, -1.04615130e-02f, 2.70697922e-01f, -1.93239480e-01f, 8.21198896e-02f, 1.26669735e-01f, 6.32050335e-02f, 3.18030864e-01f, 2.76029050e-01f, 1.50055230e-01f,
  3.28372344e-02f, -2.69981455e-02f, 4.59367603e-01f, -4.63618338e-02f, 2.77645171e-01f, 1.06882714e-01f, 2.77723558e-02f, 2.31145069e-01f, -1.18637420e-01f, -1.40912039e-02f,
  -1.39130354e-01f, -2.83835471e-01f, 7.34886341e-03f, -1.32944226e-01f, 2.66148925e-01f, -1.25428349e-01f, 5.03321826e-01f, 4.44173604e-01f, 3.97348583e-01f, -2.48044685e-01f,
  3.65715586e-02f, 1.85355321e-01f, 3.11371684e-01f, -1.50623485e-01f, -1.08016971e-02f, -6.37805700e-01f, -2.04026550e-01f, -3.02390426e-01f, -6.85691014e-02f, 1.97699428e-01f,
  1.59782276e-01f, 3.80762845e-01f, -6.53065860e-01f, 1.39611647e-01f, 3.67769212e-01f, -1.02067657e-01f, 1.17061816e-01f, -1.95665911e-01f, 4.00703251e-01f, 4.75139581e-02f,
  -5.53065658e-01f, 1.24146283e-01f, 8.52725059e-02f, 3.03209350e-02f, -3.64017159e-01f, 1.38544410e-01f, 5.16033888e-01f, 2.28224561e-01f, 6.21472597e-01f, -1.00074418e-01f,
  3.03130358e-01f, 2.09098250e-01f, 1.33562028e-01f, 3.27458419e-02f, 3.80758017e-01f, -4.52404991e-02f, 1.38204306e-01f, -3.72367799e-01f, -2.32701764e-01f, -2.96315234e-02f,
  -1.08210251e-01f, 6.06926940e-02f, -2.15761229e-01f, 6.61599636e-02f, 8.11727226e-01f, -9.16817039e-02f, -1.48223102e-01f, 1.78748965e-01f, 5.04713431e-02f, -2.85521033e-03f,
  -2.37531483e-01f, 9.37655382e-03f, -2.30506554e-01f, 3.14712413e-02f, 2.60322243e-01f, 3.91672671e-01f, 5.21564446e-02f, 6.83925077e-02f, 3.99414480e-01f, 1.90274417e-01f,
  2.55626172e-01f, 2.72152442e-02f, 5.85354626e-01f, 1.25283062e-01f, 1.00495793e-01f, -1.25575885e-01f, 3.08017254e-01f, -5.12552679e-01f, -2.78190911e-01f, -3.47311407e-01f,
  -1.71952739e-01f, 1.05678076e-02f, 2.54374564e-01f, 1.75889488e-03f, -2.69320071e-01f, 2.44579986e-01f, 3.08784157e-01f, 1.42820463e-01f, 4.64161277e-01f, -1.48214206e-01f,
  8.98351893e-02f, -1.01099461e-01f, -7.26527125e-02f, 3.72437805e-01f, -5.29285192e-01f, -1.65137261e-01f, 2.65831292e-01f, -3.01193148e-01f, -2.25910544e-01f, 6.95726946e-02f,
  3.05433571e-01f, 3.65325958e-01f, 1.47168651e-01f, -4.64426279e-01f, 9.73159373e-02f, 4.54990476e-01f, 3.65713298e-01f, 3.15261900e-01f, 1.71246096e-01f, -3.68195027e-02f,
  -2.45119855e-01f, -4.84274387e-01f, -6.45109713e-02f, 3.93863022e-02f, -6.48956895e-02f, -1.25663206e-01f, -5.10507941e-01f, -1.27617165e-03f, -5.24389386e-01f, 1.41083583e-01f,
  8.12691674e-02f, 2.68383354e-01f, -5.62883198e-01f, -4.76707183e-02f, -9.71926190e-03f, 1.61255926e-01f, 4.58326489e-02f, -3.33469182e-01f, -2.09754393e-01f, 1.71910927e-01f,
  3.05924147e-01f, 3.06607127e-01f, 4.13609087e-01f, -2.53539771e-01f, 5.84942177e-02f, -1.73063595e-02f, 1.96279213e-01f, 4.83053327e-01f, -1.45318238e-02f, 3.77747118e-01f,
  4.34750766e-01f, -1.35807663e-01f, -1.49134666e-01f, 8.49489123e-02f, 2.67931819e-01f, 1.35030538e-01f, 1.56380400e-01f, -4.12144125e-01f, -2.72846967e-01f, 2.17680752e-01f,
  -1.32224396e-01f, -2.80877918e-01f, 2.93735683e-01f, -2.25551829e-01f, -1.36010408e-01f, 2.88358718e-01f, -6.97134659e-02f, 3.10766309e-01f, -3.30456942e-01f, 2.76124537e-01f,
  1.09431349e-01f, 1.68218374e-01f, 2.29523629e-01f, -4.10046905e-01f, 2.45557204e-01f, 1.59192353e-01f, -1.74656510e-01f, 3.45225424e-01f, 1.96291313e-01f, -2.55553901e-01f,
  2.69799642e-02f, 1.65939704e-02f, -1.88672885e-01f, -5.70548698e-02f, 1.43790841e-01f, 6.68756485e-01f, -3.70123237e-01f, 1.14985257e-01f, -1.67853773e-01f, 1.69658810e-02f,
  1.68117896e-01f, -2.41255730e-01f, 2.05315009e-01f, 3.03048640e-01f, -4.54010636e-01f, 1.11906551e-01f, 1.82492241e-01f, 3.36085021e-01f, -3.30806553e-01f, -1.63403019e-01f,
  4.40160424e-01f, -4.41657782e-01f, 2.92512715e-01f, -3.82885174e-03f, -4.03975248e-02f, 2.69393206e-01f, 1.07719086e-01f, 2.03938276e-01f, 1.43485114e-01f, 4.91283983e-01f,
  -1.49453208e-01f, -6.78295255e-01f, -3.05533074e-02f, 3.50897729e-01f, 2.85168678e-01f, -6.59406632e-02f, 2.94529021e-01f, 3.90556782e-01f, 2.43196517e-01f, -1.37477323e-01f,
  -4.17802446e-02f, 1.04453653e-01f, 2.23556504e-01f, -7.17913136e-02f, 6.81626871e-02f, 1.90993343e-02f, -1.93745032e-01f, -1.33333996e-01f, 1.33870155e-01f, 2.15134472e-01f,
  1.72855720e-01f, -3.11999679e-01f, 2.29181834e-02f, 4.35928911e-01f, 3.37226987e-01f, 4.66223150e-01f, -1.26100332e-01f, 2.19151322e-02f, -2.11467743e-01f, -1.40941828e-01f,
  4.02146757e-01f, 8.56440980e-03f, -7.22614378e-02f, 3.42529327e-01f, -3.46270241e-02f, -2.34182760e-01f, -9.64433998e-02f, 6.44846708e-02f, 7.48615898e-03f, 2.41972819e-01f,
  2.30616823e-01f, 5.54730713e-01f, 4.20782804e-01f, 1.78826347e-01f, -1.12203673e-01f, 2.37160981e-01f, 3.08393300e-01f, 2.46279582e-01f, 2.93216020e-01f, 1.61592647e-01f,
  1.12759173e-01f, -1.71729147e-01f, -9.30804908e-02f, 2.15820104e-01f, 4.48601037e-01f, -2.85990119e-01f, -3.39060545e-01f, 2.48029053e-01f, 1.66086644e-01f, 3.06659639e-01f,
  2.53974706e-01f, -4.31962907e-02f, 2.23298594e-02f, -1.10057034e-02f, 1.22920491e-01f, 1.34350136e-01f, 1.71056196e-01f, 2.56566018e-01f, 3.62624109e-01f, 1.86602831e-01f,
  8.65687504e-02f, 1.43562689e-01f, -3.29923518e-02f, -1.47348702e-01f, -1.13643289e-01f, 4.98087965e-02f, -7.18262792e-02f, 1.04913615e-01f, -5.71898758e-01f, 2.43138850e-01f,
  -1.02442503e-01f, 3.27188611e-01f, -1.50357811e-02f, 3.31284821e-01f, -3.41804177e-01f, -2.45293066e-01f, 8.44345614e-02f, 1.33845672e-01f, 3.64648521e-01f, 3.58346760e-01f,
  -3.43304515e-01f, 8.44934881e-02f, 7.56265745e-02f, -4.21903878e-02f, 2.64610142e-01f, -5.40510118e-01f, 6.52699351e-01f, 6.42608702e-01f, 1.97936103e-01f, 4.96485159e-02f,
  2.64479488e-01f, 1.83764338e-01f, -1.65849149e-01f, -4.14214194e-01f, -1.64100360e-02f, 5.56473099e-02f, 3.42715919e-01f, -7.83061460e-02f, -3.37872088e-01f, -4.64363784e-01f,
  -2.17238784e-01f, 2.67994046e-01f, 1.44963533e-01f, 5.98477274e-02f, -4.28779691e-01f, -6.71484228e-03f, -3.86393815e-01f, -6.61414117e-02f, 3.82197718e-03f, -1.17575131e-01f,
  1.16662169e-02f, 3.77999693e-01f, 9.12828222e-02f, 1.34180114e-01f, 4.75822031e-01f, 3.69001627e-01f, 3.94633830e-01f, 5.51881716e-02f, 5.19333363e-01f, 1.30261347e-01f,
  9.32925195e-02f, 1.65704653e-01f, 4.30931270e-01f, -2.13321716e-01f, -1.37708068e-01f, -4.42248911e-01f, -3.75772566e-01f, -5.08709073e-01f, -7.00079724e-02f, 2.16546893e-01f,
  -9.94062126e-02f, 1.20058082e-01f, -2.87842035e-01f, 7.38248751e-02f, 3.04148465e-01f, 1.99281365e-01f, -1.58055946e-01f, 1.07071228e-01f, -1.18234053e-01f, 1.13079503e-01f,
  -2.76825786e-01f, -1.50524467e-01f, 4.18208688e-02f, -1.65595382e-01f, -9.52730924e-02f, 2.60089397e-01f, -4.64556783e-01f, -6.13317430e-01f, -5.07722080e-01f, 3.23364556e-01f,
  -4.88680648e-03f, 4.15180415e-01f, 1.52050868e-01f, 3.83699164e-02f, -1.52868837e-01f, 1.48774549e-01f, 2.05905542e-01f, -2.67223418e-01f, 4.46851291e-02f, 8.52916241e-02f,
  9.24140587e-02f, 3.43930870e-01f, 4.09982577e-02f, 1.13050215e-01f, -1.05055347e-01f, 1.22957371e-01f, 1.54667124e-01f, 5.25504500e-02f, -5.19097708e-02f, 3.23650688e-01f,
  9.47713852e-04f, 1.52459115e-01f, -2.38626435e-01f, 9.71097965e-03f, 1.79035559e-01f, -3.76736403e-01f, 2.42146999e-02f, -1.98063273e-02f, 1.54708862e-01f, -8.43365639e-02f,
  -9.95931998e-02f, 1.23218894e-01f, 1.27939478e-01f, -6.21488020e-02f, 1.70282219e-02f, 2.39498671e-02f, 1.24065697e-01f, -2.53506124e-01f, -1.01887062e-01f, -1.65689081e-01f,
  8.44555497e-02f, -2.59301551e-02f, 1.29635558e-01f, -8.84018242e-02f, -7.74945645e-03f, -2.23106340e-01f, -3.62857163e-01f, -2.88288798e-02f, 2.11582676e-01f, -1.77807465e-01f,
  -2.63439983e-01f, -1.06967211e-01f, -3.52504104e-02f, 2.80413181e-01f, -2.92581439e-01f, -1.49058327e-01f, -2.11757421e-01f, -1.36189893e-01f, 1.85608760e-01f, 1.83234230e-01f,
  5.60912013e-01f, 5.57880580e-01f, 1.90421060e-01f, 4.88482676e-02f, 6.36342943e-01f, -6.64338693e-02f, 1.19608408e-02f, 2.28092689e-02f, 1.91449925e-01f, 4.51702662e-02f,
  1.26448810e-01f, -5.33920387e-03f, -6.70866519e-02f, -4.16752189e-01f, -5.99501431e-02f, -1.43737257e-01f, 8.31067786e-02f, 5.66078067e-01f, 7.90264428e-01f, -4.09747511e-02f,
  3.82870018e-01f, -4.08654183e-01f, 3.07322711e-01f, -1.98105916e-01f, 4.59159255e-01f, 7.63764605e-02f, -2.69562770e-02f, -3.85458618e-02f, 3.54462445e-01f, -4.94293869e-01f,
  1.55467942e-01f, -3.09117109e-01f, -7.34849155e-01f, -7.15283751e-01f, -5.44852316e-01f, 1.56715930e-01f, -1.59097329e-01f, 2.83359766e-01f, 8.12264457e-02f, 2.16470622e-02f,
  -1.21260636e-01f, 3.04536730e-01f, 6.89964741e-02f, -7.95588717e-02f, 2.73960620e-01f, 7.80517310e-02f, 4.74735117e-03f, 3.69779885e-01f, 2.05703795e-01f, 4.32882696e-01f,
  -2.62302548e-01f, 9.83551517e-02f, 4.13001955e-01f, -1.82001024e-01f, 4.18518662e-01f, 1.76999852e-01f, 1.79003775e-01f, 2.81276107e-01f, 1.47174075e-01f, 7.67206494e-03f,
  -2.15792246e-02f, -3.27550232e-01f, 2.33816609e-01f, -1.74397171e-01f, -2.94732898e-01f, -4.46203589e-01f, 1.44653738e-01f, 2.99421579e-01f, -3.13036144e-01f, 3.60081531e-02f,
  -6.53784201e-02f, -1.03970513e-01f, -1.31591201e-01f, 7.30679855e-02f, -1.15779229e-01f, 4.16784525e-01f, 1.24801621e-01f, 2.66058385e-01f, 3.59160483e-01f, 2.37588122e-01f,
  3.04633439e-01f, 6.72334880e-02f, 2.85041854e-02f, 5.93276769e-02f, 1.56461790e-01f, 1.81575254e-01f, 2.09259301e-01f, 2.58619606e-01f, -1.24070130e-01f, 2.20548108e-01f,
  2.66549498e-01f, 8.29641894e-02f, -4.96867187e-02f, -1.15520321e-02f, 1.54151514e-01f, -2.73624677e-02f, 2.18878984e-01f, -1.86919317e-01f, 1.52476549e-01f, -2.76057839e-01f,
  4.05820459e-01f, 2.01437771e-01f, 1.52768955e-01f, 6.04363419e-02f, 5.61503291e-01f, -3.97025228e-01f, -2.11573809e-01f, -2.43075073e-01f, -2.40761027e-01f, -2.34584078e-01f,
  1.49706200e-01f, 2.18323871e-01f, -8.72593448e-02f, 4.01396334e-01f, 6.02304898e-02f, 7.28875920e-02f, 3.57972085e-01f, -6.76744878e-02f, 1.04119517e-01f, 1.80948898e-01f,
  -3.71809900e-01f, -1.22502752e-01f, -3.92715454e-01f, 9.91603285e-02f, -1.87508136e-01f, -9.03789140e-03f, -2.25447759e-01f, 2.09770650e-01f, 3.48903179e-01f, 1.02624379e-01f,
  -3.00368875e-01f, -4.70964193e-01f, 3.99926156e-01f, 2.81233549e-01f, 1.35991022e-01f, 3.18943918e-01f, 3.98611054e-02f, 1.05344012e-01f, 3.64892010e-04f, -2.85047084e-01f,
  4.49311554e-01f, -1.59222886e-01f, 3.12477052e-01f, 3.87211032e-02f, -4.99100517e-03f, 7.33507648e-02f, -1.31745636e-01f, 6.48806617e-02f, 7.59080499e-02f, -5.13841629e-01f,
  -1.78706467e-01f, -4.16402698e-01f, 1.28642591e-02f, 3.05463344e-01f, -1.37306631e-01f, 3.69605958e-01f, -1.55740961e-01f, 2.42666364e-01f, 3.45596045e-01f, -4.78679150e-01f,
  2.78366476e-01f, -4.39273342e-02f, -1.77190956e-02f, 1.56495944e-01f, 2.65059799e-01f, -2.29418371e-02f, 1.79333821e-01f, -2.48557255e-01f, 6.82217255e-02f, -1.64371550e-01f,
  -2.24277452e-01f, 4.89655524e-01f, -1.85605943e-01f, 1.37613967e-01f, 3.92440528e-01f, 1.87941417e-01f, 1.42719924e-01f, -1.42980888e-01f, 5.28702624e-02f, 4.19778407e-01f,
  1.17329247e-02f, 3.25788558e-01f, 1.15538746e-01f, 1.03141680e-01f, -2.56836951e-01f, 2.63246208e-01f, 3.01857769e-01f, -3.83598179e-01f, -4.31695506e-02f, 1.43461823e-01f,
  -1.70022979e-01f, 4.12609965e-01f, -4.35162574e-01f, 9.54544917e-02f, -1.09351046e-01f, -5.84695816e-01f, 3.88719529e-01f, 5.28488994e-01f, 9.66341570e-02f, 2.64604413e-03f,
  2.43670240e-01f, 1.85044959e-01f, -3.46740276e-01f, -4.07985479e-01f, 1.04252659e-01f, -1.18258558e-01f, 5.89050427e-02f, 1.01702393e-03f, -4.42001134e-01f, -3.98523035e-03f,
  -7.16585338e-01f, -1.63785443e-01f, 7.66892284e-02f, -1.44118041e-01f, 3.59529108e-02f, -8.14620480e-02f, -3.98233205e-01f, -1.61848545e-01f, 1.58594877e-01f, 1.19623005e-01f,
  1.53451368e-01f, -6.06519505e-02f, -3.13234627e-01f, 1.71701729e-01f, -3.60352965e-03f, -4.02890056e-01f, -2.63474405e-01f, 1.85088143e-01f, -3.04868430e-01f, 3.66810828e-01f,
  -1.71646699e-01f, 3.36992830e-01f, -1.30211338e-01f, 1.87496301e-02f, 2.98972726e-01f, -2.44823381e-01f, -5.20639084e-02f, -2.10428968e-01f, -2.63597697e-01f, 3.60785365e-01f,
  1.54482588e-01f, -1.68691471e-01f, 3.43701005e-01f, 1.91954419e-01f, -1.72020599e-01f, 2.22437158e-01f, 6.92922547e-02f, 4.22565967e-01f, -7.21692890e-02f, -7.80731887e-02f,
  -1.54708952e-01f, -8.55031535e-02f, 3.20109487e-01f, 3.61169249e-01f, -1.27752557e-01f, -2.37058908e-01f, 5.39041281e-01f, 3.30477983e-01f, -1.61206663e-01f, -3.21845680e-01f,
  9.96269565e-03f, 4.26281631e-01f, 3.76722395e-01f, 3.35168004e-01f, 2.18878597e-01f, -3.68110955e-01f, -3.51898462e-01f, -6.95154294e-02f, 2.53066927e-01f, 1.79879859e-01f,
  1.57565117e-01f, -3.43902707e-01f, -3.51779908e-01f, 2.11101115e-01f, -5.54158092e-01f, -3.29884976e-01f, -6.66171536e-02f, 1.08652174e-01f, 4.12638336e-02f, -3.22523266e-01f,
  4.15265523e-02f, -7.84895476e-03f, -1.62914805e-02f, 8.57681483e-02f, -3.33575904e-01f, -5.20415641e-02f, 5.22211611e-01f, 9.43459570e-02f, 3.57532442e-01f, 1.74636498e-01f,
  3.37566644e-01f, 2.76413351e-01f, 3.97569388e-01f, -1.84221610e-01f, -2.99134761e-01f, -4.41831589e-01f, 4.02988493e-02f, 1.48245499e-01f, -9.39892083e-02f, 1.13770053e-01f,
  -4.03261483e-02f, -3.19058716e-01f, -5.73051274e-01f, 3.68883848e-01f, 2.88979799e-01f, 1.99422240e-01f, -2.20737457e-01f, 1.86940908e-01f, 2.10473448e-01f, 2.37976402e-01f,
  3.36015999e-01f, 1.32407872e-02f, 2.13525549e-01f, -1.44451648e-01f, 3.08193773e-01f, -4.07493711e-01f, 1.21111535e-01f, -3.00516367e-01f, -4.05146837e-01f, 1.98230028e-01f,
  5.72745539e-02f, -1.94341242e-01f, 2.07033738e-01f, -1.99242402e-02f, 4.69207615e-01f, 3.17332298e-02f, -1.10657439e-01f, -1.69281721e-01f, -9.95376632e-02f, 1.55522019e-01f,
  1.86118528e-01f, -1.21612988e-01f, -2.22239807e-01f, -3.39141071e-01f, -6.56012475e-01f, 4.20817763e-01f, 2.35501453e-01f, 2.87627935e-01f, -9.13098231e-02f, 9.37490836e-02f,
  4.56843860e-02f, -2.64299631e-01f, 4.49495822e-01f, 1.10069878e-01f, 3.55760187e-01f, -2.79972553e-01f, -4.58665460e-01f, 3.98759246e-02f, 1.40141338e-01f, -4.46267456e-01f,
  6.10859431e-02f, -1.47211611e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.41518235e-01f, -2.46669769e-01f, 2.05806613e-01f, 2.49008253e-01f, 3.27615291e-01f, 2.11184874e-01f, -9.37190205e-02f, 2.02842191e-01f, 2.62260318e-01f, -7.73725808e-02f,
  3.84832323e-01f, 9.07801539e-02f, 2.75559634e-01f, 1.81953367e-02f, -3.28693390e-02f, 5.17151475e-01f, -2.18213033e-02f, -3.21867615e-01f, 6.85433373e-02f, 3.43556523e-01f,
  1.61715336e-02f, 3.81666273e-01f, 1.23841897e-01f, 2.50170022e-01f, 9.79257002e-02f, 6.83774054e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  4.96586442e-01f, 2.46908925e-02f, -4.07833844e-01f, 3.01432069e-02f, 1.50664104e-02f, -3.49372357e-01f, -1.09496556e-01f, 4.07943994e-01f, -3.51212621e-01f, -1.20003238e-01f,
  -3.52264583e-01f, -3.41656715e-01f, -3.18133265e-01f, 1.17560789e-01f, -2.63572037e-01f, 1.76900089e-01f, 9.50904340e-02f, -1.57152459e-01f, -4.10432043e-03f, 2.87694991e-01f,
  1.46151967e-02f, -3.90940607e-01f, 3.30881178e-01f, 1.77715629e-01f, 1.99283808e-01f, -6.33228481e-01f, -5.10042207e-03f, 1.58550248e-01f, 2.27103233e-01f, -3.79785299e-01f,
  2.33115315e-01f, 9.83918458e-02f, -5.06134257e-02f, -4.98467416e-01f, -3.93201113e-01f, -3.18092495e-01f, 3.64189774e-01f, -3.22528630e-01f, -1.60755619e-01f, 3.94916654e-01f,
  2.68721461e-01f, -5.24559200e-01f, -5.58783591e-01f, -2.71952271e-01f, -1.07107893e-01f, -5.32826424e-01f, 2.04424083e-01f, -1.70608446e-01f, -9.24297725e-04f, -5.87760061e-02f,
  -5.31534791e-01f, 2.72323728e-01f, -1.62583500e-01f, 2.39111662e-01f, 3.16946983e-01f, -1.01795226e-01f, -4.89021599e-01f, 1.46315381e-01f, -6.92173302e-01f, 2.36793607e-01f,
  1.10347173e-03f, -1.67339683e-01f, -2.17914935e-02f, 2.99226552e-01f, 3.93454760e-01f, 2.22916320e-01f, -3.77807170e-01f, -3.45494956e-01f, 1.83283553e-01f, -2.22938418e-01f,
  -6.30993009e-01f, -2.64315754e-01f, 3.04179639e-01f, 4.99902591e-02f, 4.02594447e-01f, 1.86255872e-02f, -4.49710459e-01f, -3.10988694e-01f, -3.49113613e-01f, 2.10848097e-02f,
  1.51531816e-01f, 3.72483671e-01f, 3.76035780e-01f, 2.03727819e-02f, 1.00123875e-01f, -1.92681342e-01f, -2.30358258e-01f, -3.71298730e-01f, 2.98642963e-01f, 3.96563970e-02f,
  5.72613403e-02f, 4.48799729e-01f, -2.79379427e-01f, -3.34575921e-01f, -1.90477207e-01f, -4.26856279e-01f, -2.38964230e-01f, -3.03499661e-02f, 3.58988866e-02f, 2.10227817e-02f,
  1.25037566e-01f, -4.30963874e-01f, 9.46105197e-02f, -2.74849385e-01f, 5.22318035e-02f, 3.33764434e-01f, -2.71455795e-01f, 9.87258404e-02f, -1.94360062e-01f, -4.76489626e-02f,
  2.76078582e-01f, -6.48405492e-01f, 2.14915648e-01f, -2.01192554e-02f, 3.19651663e-01f, 2.03015015e-01f, -7.85580873e-02f, -3.72983038e-01f, -1.98550880e-01f, -2.18768150e-01f,
  4.15823683e-02f, -5.50690472e-01f, -2.34097049e-01f, -1.99126497e-01f, 2.83811688e-01f, -2.36261457e-01f, -1.20640069e-01f, 7.93925375e-02f, -3.11007202e-01f, 2.62040526e-01f,
  1.88592568e-01f, 2.65505791e-01f, 3.18928838e-01f, 4.58632678e-01f, -3.45782012e-01f, -4.61586624e-01f, -4.26707596e-01f, -3.30517113e-01f, -1.76429316e-01f, -3.06686670e-01f,
  -1.93478554e-01f, 3.71442437e-01f, 3.15438598e-01f, -8.03997666e-02f, 1.97296098e-01f, -4.53777730e-01f, -8.91163498e-02f, -5.32436110e-02f, 2.12759674e-02f, -2.86561877e-01f,
  -1.22278474e-01f, 1.07763670e-01f, -6.52474612e-02f, 1.20737351e-01f, 2.71750838e-01f, -5.11055708e-01f, -2.42464039e-02f, -4.39516336e-01f, 1.92607239e-01f, -9.39567164e-02f,
  -4.75304544e-01f, 2.57407039e-01f, 2.71486700e-01f, -5.42301595e-01f, -7.61212289e-01f, 3.56593728e-02f, -1.66778892e-01f, -2.16433942e-01f, 3.08674484e-01f, 1.93690937e-02f,
  2.68714786e-01f, -4.95365977e-01f, -2.63038099e-01f, -1.08793303e-02f, 5.63879721e-02f, 8.37750137e-02f, 7.23297149e-02f, -3.83285224e-01f, 4.05141681e-01f, -7.59867430e-02f,
  -2.40308702e-01f, 1.97866827e-01f, 2.16396078e-01f, -1.60619970e-02f, 2.36799434e-01f, -2.44524777e-02f, -1.70335934e-01f, 1.40841275e-01f, -3.43891591e-01f, -1.87727794e-01f,
  2.96250254e-01f, 1.92966938e-01f, -4.12155956e-01f, -1.40561476e-01f, 1.34491161e-01f, 5.28610218e-03f, -1.53080687e-01f, 3.99115026e-01f, -1.41580269e-01f, 2.60718822e-01f,
  -2.44129092e-01f, -5.32735348e-01f, 3.07987839e-01f, 4.58746143e-02f, 1.37620373e-02f, -3.94774556e-01f, -5.63053966e-01f, 1.93594381e-01f, -5.97507298e-01f, 2.22224742e-02f,
  -6.16730377e-02f, 3.00613165e-01f, 2.42329761e-01f, -2.43341804e-01f, 2.18887076e-01f, 1.41901881e-01f, -1.17257200e-01f, 4.47685495e-02f, 6.47884384e-02f, -1.70411110e-01f,
  1.17474794e-01f, 8.13027844e-02f, -2.21727163e-01f, 1.75841544e-02f, 6.79433171e-04f, -3.17961603e-01f, 3.44070271e-02f, 3.71218622e-01f, -1.63157821e-01f, -2.70740390e-01f,
  -9.15822163e-02f, -2.93525100e-01f, -4.01291877e-01f, 8.16123411e-02f, -3.83798003e-01f, -1.55817613e-01f, 3.08878452e-01f, -5.17243147e-01f, 1.57237530e-01f, -4.00097162e-01f,
  1.69690132e-01f, 1.07795887e-01f, -6.70038760e-01f, -1.86991826e-01f, -4.70427573e-02f, -3.15065891e-01f, -2.27654055e-01f, -1.26777887e-01f, -1.15961842e-02f, 1.78050950e-01f,
  -1.85703710e-01f, 1.35810417e-03f, 1.74354717e-01f, 2.52493799e-01f, -1.69792145e-01f, -2.40732595e-01f, 6.45408183e-02f, 1.61439031e-01f, 4.12055850e-01f, 9.61823642e-01f,
  2.18795627e-01f, 1.70756370e-01f, 4.34557766e-01f, 3.69885080e-02f, -1.34170249e-01f, 1.31111532e-01f, 2.36859366e-01f, -4.81166631e-01f, 1.57484204e-01f, -1.45142019e-01f,
  -3.20670370e-04f, 4.00546193e-01f, -2.77906120e-01f, -7.08230585e-02f, 3.58274020e-02f, 3.09435576e-02f, -1.80701450e-01f, 1.69364899e-01f, 8.83869305e-02f, 2.08342105e-01f,
  2.82912880e-01f, 8.16151798e-02f, -3.95115055e-02f, -6.21185482e-01f, -5.44039547e-01f, -2.61843443e-01f, -9.18077290e-01f, -3.11514109e-01f, -2.07158729e-01f, -1.92369699e-01f,
  2.63520598e-01f, -1.35931805e-01f, 3.44421625e-01f, 2.88412422e-01f, -1.13380931e-01f, -4.68007356e-01f, -6.35620296e-01f, 1.71002984e-01f, -4.92664009e-01f, 2.70772129e-01f,
  -1.06967591e-01f, 3.80271375e-02f, -2.81208038e-01f, 2.29410231e-01f, -9.31546614e-02f, 1.72124684e-01f, -6.61972817e-03f, -2.87828356e-01f, 6.14673570e-02f, -3.09394717e-01f,
  -3.70396018e-01f, -1.22101173e-01f, -2.84805328e-01f, 4.29094620e-02f, 1.86929703e-01f, -1.41123891e-01f, -4.37111080e-01f, 2.93673515e-01f, -2.27290273e-01f, 4.17714864e-02f,
  5.66149235e-01f, 1.60426989e-01f, -6.27420843e-02f, -2.74757206e-01f, -6.04687572e-01f, 7.66809821e-01f, 6.31740570e-01f, -4.62078124e-01f, -1.37485296e-01f, 5.96740425e-01f,
  1.00301489e-01f, -5.08483708e-01f, -6.61673129e-01f, 2.19511822e-01f, 1.72298476e-01f, -6.30868971e-01f, -1.36169299e-01f, -5.36021233e-01f, -1.22089997e-01f, -2.59305239e-01f,
  -1.00210495e-01f, 4.90799874e-01f, -5.54131746e-01f, -7.06887662e-01f, -5.20202100e-01f, -5.99457741e-01f, -4.31261092e-01f, -3.56833935e-01f, 1.13867417e-01f, -1.70619383e-01f,
  5.83336949e-02f, 1.46652669e-01f, 1.56363159e-01f, 1.18900977e-01f, 1.49779543e-02f, 3.06518316e-01f, 1.20896148e-02f, -5.23080170e-01f, 1.41497791e-01f, 1.25852808e-01f,
  1.39216021e-01f, -2.31680006e-01f, 1.28515780e-01f, 1.36254784e-02f, 2.42809370e-01f, -6.70517311e-02f, -2.02698529e-01f, -4.04715598e-01f, -1.96488455e-01f, -2.74981350e-01f,
  3.20475280e-01f, 2.24680416e-02f, 5.33352941e-02f, 2.57318050e-01f, 4.57951315e-02f, -3.61135662e-01f, 2.72166222e-01f, 2.33915254e-01f, -5.00526309e-01f, 5.21464050e-02f,
  -5.60510933e-01f, 4.30268109e-01f, -5.16698897e-01f, -2.64876574e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.82033408e-01f, 1.56904787e-01f, 3.14811796e-01f, 1.81141011e-02f, 1.46204919e-01f, 8.06838721e-02f, -9.98654962e-02f, -1.59707651e-01f, -4.36395667e-02f, -2.41983905e-02f,
  1.27974628e-02f, -1.21873587e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    