/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.74349415e-01f, -3.48000795e-01f, -9.69089344e-02f, -3.26443799e-02f, 3.73269208e-02f, 8.40740949e-02f, -3.29910100e-01f, -4.91966717e-02f, 2.24347636e-01f, -2.27899402e-01f,
  -9.99424160e-02f, 2.82757610e-01f, 1.09604195e-01f, 5.57673387e-02f, 1.44960776e-01f, -1.90224916e-01f, -1.49056032e-01f, 1.71304777e-01f, 4.49252784e-01f, 2.91685373e-01f,
  -8.79677534e-02f, -1.26158789e-01f, 1.95166364e-01f, 7.41368905e-02f, -3.19273680e-01f, 2.76928306e-01f, -2.28657216e-01f, -3.57022136e-02f, -5.11621535e-02f, -5.85281312e-01f,
  -2.79697388e-01f, -2.32055694e-01f, 1.45511553e-01f, 9.40490142e-02f, -7.74383917e-02f, 2.47281548e-02f, 5.36274277e-02f, -1.16996653e-02f, 2.03454886e-02f, 2.30474747e-03f,
  -2.73082890e-02f, 9.82667506e-02f, 1.14575792e-02f, -3.76648717e-02f, -1.70221180e-01f, -2.69578006e-02f, -7.21145645e-02f, -3.03773079e-02f, -6.37371093e-02f, -3.80310230e-02f,
  -1.22099012e-01f, -2.58731581e-02f, -3.90802994e-02f, 2.36901995e-02f, -1.07549205e-01f, 2.06878379e-01f, -9.22092199e-02f, -3.76025192e-03f, -3.49454209e-02f, -1.52759388e-01f,
  1.92214027e-02f, 1.12777548e-02f, -3.76144201e-02f, 2.94851547e-04f, 2.69493051e-02f, 5.27179465e-02f, -3.90012972e-02f, 5.37687400e-03f, 1.43908858e-02f, 3.94075736e-02f,
  -4.26179469e-02f, -1.86988094e-03f, 8.70356895e-03f, 6.07529329e-03f, 1.60265900e-02f, 1.84196569e-02f, -2.74125524e-02f, -6.52509853e-02f, 5.91698028e-02f, 9.49645136e-03f,
  2.74513010e-02f, -5.74527085e-02f, 3.51448916e-02f, -8.13998580e-02f, 3.33563201e-02f, -1.56959780e-02f, 1.30503047e-02f, -1.01546412e-02f, 4.77847159e-02f, -1.70758460e-02f,
  1.56768262e-01f, 1.37416214e-01f, -5.94334863e-02f, -4.78364192e-02f, 2.11132988e-02f, -4.45530191e-02f, -5.82216568e-02f, 6.59611588e-03f, -5.41712195e-02f, -6.82721511e-02f,
  -1.70269366e-02f, -1.42007284e-02f, -5.78629673e-02f, -6.35373369e-02f, 1.34735510e-01f, -1.33787813e-02f, 2.81041823e-02f, 4.05570976e-02f, 1.56593323e-02f, -9.35101807e-02f,
  -2.88070589e-02f, 1.18608378e-01f, 3.10206264e-01f, 1.17276303e-01f, 4.30713706e-02f, 2.25328177e-01f, 2.66215112e-02f, 4.34846580e-02f, 1.37436613e-01f, 6.05577938e-02f,
  2.59843409e-01f, 4.60802346e-01f, -4.83208179e-01f, 2.02786401e-01f, -4.86737102e-01f, -4.19427663e-01f, -3.60356569e-01f, -7.77469724e-02f, 1.70538202e-01f, 1.07401922e-01f,
  2.10750923e-01f, 7.29558319e-02f, 8.92141610e-02f, -5.16527100e-03f, -5.99966720e-02f, 3.75171937e-02f, -1.90679774e-01f, -3.34756285e-01f, -4.29205477e-01f, -1.39548972e-01f,
  1.03775427e-01f, 9.53398943e-02f, 1.52401030e-01f, 2.21604154e-01f, 2.00591922e-01f, 1.69198588e-01f, 1.04502372e-01f, 4.39778045e-02f, 1.18093215e-01f, -3.36417439e-03f,
  -7.01675341e-02f, 8.73193424e-03f, -1.00006093e-03f, 4.50322740e-02f, 5.38512692e-02f, 4.62207124e-02f, -2.20953878e-02f, -1.00569025e-01f, -3.66797112e-02f, 4.04066741e-02f,
  -2.41133291e-02f, 3.25641669e-02f, -1.02342278e-01f, -2.03912538e-02f, -5.91203496e-02f, -1.35068670e-01f, -3.30493250e-03f, -8.01473707e-02f, -5.79180848e-03f, -1.64147131e-02f,
  1.60941809e-01f, -1.00715593e-01f, -2.27432385e-01f, -5.11898175e-02f, -9.79510769e-02f, -5.66250086e-02f, -7.25928247e-02f, -7.78970271e-02f, -1.27544090e-01f, 8.39806441e-03f,
  1.33756278e-02f, 6.54660091e-02f, -1.38479425e-02f, -1.90533251e-02f, 1.32543622e-02f, 2.55737845e-02f, -3.58136669e-02f, 1.21938754e-02f, 1.29578216e-02f, 9.84590966e-03f,
  -5.99429458e-02f, 9.35421586e-02f, 4.13922817e-02f, -5.63291414e-03f, 1.43734038e-01f, -4.08195183e-02f, 9.34735015e-02f, 6.48857728e-02f, 3.25263813e-02f, -3.79806310e-02f,
  -1.32615432e-01f, 1.24759332e-03f, 4.56278026e-02f, 7.11302832e-02f, -1.50182117e-02f, -4.59574834e-02f, 4.46649082e-02f, -6.86980039e-02f, 4.05217856e-02f, -3.51070426e-02f,
  2.39683509e-01f, -1.54286116e-01f, 1.58956349e-01f, -2.42890548e-02f, 1.63005721e-02f, 4.59629372e-02f, 5.32921869e-03f, 3.44049856e-02f, 3.04736551e-02f, 6.37574270e-02f,
  -3.87015156e-02f, 1.33661767e-02f, 9.29468870e-02f, 2.79288776e-02f, -2.26614233e-02f, 1.32488431e-02f, 3.63177732e-02f, 7.79597387e-02f, 5.74724935e-02f, 7.85706788e-02f,
  1.54332727e-01f, -8.07624310e-03f, -2.55873688e-02f, 2.58404836e-02f, 8.72223899e-02f, -1.16025977e-01f, -8.31261054e-02f, 8.25639516e-02f, -2.03374820e-03f, 2.02200234e-01f,
  -2.95387805e-01f, -1.69578224e-01f, 1.41884729e-01f, -2.65370101e-01f, -2.26370562e-02f, -1.44577384e-01f, -4.42865670e-01f, -2.76219338e-01f, 8.19566101e-03f, -8.84089097e-02f,
  2.32583791e-01f, 4.28091735e-01f, 4.44598466e-01f, 3.09315056e-01f, -1.31895691e-01f, -1.07771300e-01f, -1.58482403e-01f, 1.62626848e-01f, -1.44934848e-01f, -3.74571472e-01f,
  -2.63176244e-02f, -3.57594967e-01f, -5.12857996e-02f, -9.80864186e-03f, -1.11835273e-02f, 1.87921822e-01f, 6.48038611e-02f, 2.37667887e-03f, 1.85113192e-01f, 2.30881453e-01f,
  2.29897171e-01f, 9.67551954e-03f, 1.57617256e-01f, 8.29419866e-02f, 1.05145268e-01f, 1.80283174e-01f, 1.49063850e-02f, 1.20441318e-01f, 3.94867510e-02f, -3.12484466e-02f,
  1.60321191e-01f, 4.99298386e-02f, 6.01586923e-02f, 1.94554061e-01f, 1.37371793e-02f, 1.54456925e-02f, 5.19627780e-02f, -4.80845831e-02f, 1.26903102e-01f, 3.65654342e-02f,
  2.73086522e-02f, 3.72787379e-02f, 2.30380595e-02f, 7.90837109e-02f, -7.50676692e-02f, 1.67007282e-01f, 9.65839699e-02f, 6.71432465e-02f, 1.45908430e-01f, 4.86098044e-02f,
  1.91074237e-02f, 6.64028302e-02f, 1.58459228e-02f, -1.17942914e-01f, -1.11449689e-01f, 5.74309938e-02f, -3.32177095e-02f, -5.25082974e-03f, -4.59744446e-02f, -7.22933635e-02f,
  3.65859531e-02f, -1.03357611e-02f, 6.53969171e-03f, -3.10179610e-02f, 5.70415221e-02f, 6.14905059e-02f, -1.42639419e-02f, -3.63798738e-02f, 8.69242772e-02f, -5.28504513e-02f,
  2.02173013e-02f, 4.53604758e-02f, 3.33538353e-02f, 8.93278513e-03f, -2.31615584e-02f, -4.16933782e-02f, 1.20897349e-02f, -2.14756671e-02f, -2.96352897e-02f, -3.26019078e-02f,
  -4.18858603e-02f, 2.36381248e-01f, 8.45860839e-02f, 4.11160663e-02f, 4.63119708e-02f, 9.56498012e-02f, 2.78437696e-02f, 1.58836916e-01f, 1.96282104e-01f, 1.24017209e-01f,
  6.48516119e-02f, 1.29622445e-01f, 1.46178484e-01f, 2.46467274e-02f, -1.73566584e-02f, 7.45730400e-02f, -3.16575030e-03f, -2.74187536e-03f, 5.04655913e-02f, 1.65120006e-01f,
  5.87865859e-02f, -7.53072798e-02f, -3.05900108e-02f, 6.34018108e-02f, 9.13316980e-02f, -1.22738145e-02f, 5.41293062e-02f, 2.61473376e-02f, -2.60559954e-02f, -1.36826098e-01f,
  -2.37303287e-01f, 1.20624438e-01f, 4.77017462e-01f, -5.20251155e-01f, -6.75983131e-02f, 1.87038153e-01f, 4.90087956e-01f, 3.46908681e-02f, -3.48722458e-01f, 1.71768904e-01f,
  -1.63060725e-01f, -2.75241107e-01f, -1.10826418e-01f, 8.01153779e-02f, 2.56928742e-01f, 4.99641865e-01f, 2.94902056e-01f, 1.90030947e-01f, 1.86669603e-01f, 2.65536155e-03f,
  -1.37203544e-01f, -2.53978580e-01f, -3.12456995e-01f, 9.29122493e-02f, -1.80940911e-01f, -1.16762042e-01f, -1.82427634e-02f, -1.51275963e-01f, 2.49308899e-01f, 2.58102268e-01f,
  -5.83402850e-02f, -7.42896693e-03f, -5.16403876e-02f, -9.40130726e-02f, -4.84000407e-02f, 3.88685316e-02f, 4.19788994e-02f, -3.80570032e-02f, -1.12515941e-01f, 4.99390140e-02f,
  -1.68639317e-01f, -5.16088493e-02f, 3.27185355e-02f, -8.97221938e-02f, -1.67657305e-02f, 3.15724164e-02f, 4.17773314e-02f, 3.62382010e-02f, 5.20385504e-02f, 2.11055856e-02f,
  -1.11604460e-01f, 8.52930546e-03f, 9.68726426e-02f, 8.50653052e-02f, 2.14574169e-02f, -8.35491866e-02f, 1.14653818e-02f, -5.46467416e-02f, 1.66827977e-01f, 1.44607760e-02f,
  -1.48892906e-02f, -1.67118534e-02f, 6.38565719e-02f, -3.36356945e-02f, -8.63468554e-03f, 1.74929500e-02f, -5.05112228e-04f, -3.17680873e-02f, 4.93675331e-03f, 1.95196290e-02f,
  4.36982103e-02f, 4.38011400e-02f, 7.70259555e-03f, 3.37182283e-02f, -1.15607330e-03f, 2.59279981e-02f, -3.00695989e-02f, 5.09582981e-02f, -7.05456436e-02f, 1.78135522e-02f,
  -7.10217888e-03f, 3.91902402e-02f, -8.37827325e-02f, 8.40890631e-02f, 2.99066622e-02f, 5.58397174e-02f, -2.99013015e-02f, -1.04310857e-02f, -7.26923048e-02f, 7.73001229e-03f,
  -2.59770960e-01f, 9.61922854e-02f, -7.81729743e-02f, 3.67996730e-02f, -2.11149734e-02f, -6.76275864e-02f, -7.48409480e-02f, 3.31931328e-03f, -2.72688195e-02f, -1.82480719e-02f,
  1.30327391e-02f, 2.40105167e-02f, 1.41721545e-02f, 5.19374348e-02f, -5.20270653e-02f, 3.90667282e-03f, -6.80641085e-02f, -1.20850466e-01f, 9.33842361e-02f, -8.67214799e-03f,
  4.93670292e-02f, 5.92026003e-02f, -1.01627350e-01f, 6.22254312e-02f, -5.70527464e-02f, -1.36914209e-01f, -2.43968200e-02f, -6.57661036e-02f, 7.81059265e-02f, -2.55757142e-02f,
  -5.43336570e-01f, -2.16795430e-01f, 2.96746910e-01f, -5.62031493e-02f, 2.33580805e-02f, 5.88382669e-02f, -5.04778445e-01f, -4.49166298e-01f, 1.36718482e-01f, -9.49617550e-02f,
  1.04768954e-01f, 3.27804893e-01f, 1.59269542e-01f, 8.56647715e-02f, -3.81880365e-02f, -1.37583494e-01f, -1.88791350e-01f, -1.54727008e-02f, 2.05744982e-01f, 2.29157314e-01f,
  3.64741832e-02f, -1.84367105e-01f, 2.44610589e-02f, 6.70268387e-02f, 4.28396724e-02f, 1.04832381e-01f, -8.42343494e-02f, -3.67756491e-03f, 3.23133856e-01f, 1.12255350e-01f,
  3.22092026e-01f, -1.35826662e-01f, 7.45235085e-02f, 3.43311168e-02f, -1.90613102e-02f, -1.12800665e-01f, -9.52958986e-02f, 6.63488582e-02f, 8.30284785e-03f, 1.69441495e-02f,
  5.02889976e-02f, 1.12237357e-01f, 2.00827029e-02f, 7.15972036e-02f, 3.75656858e-02f, 2.65319403e-02f, -1.16512425e-01f, -7.00026331e-03f, 4.00012359e-02f, -5.90270273e-02f,
  -3.79262678e-02f, 6.55537099e-02f, -7.64153898e-02f, -9.79672745e-02f, 4.59298044e-02f, 1.16240762e-01f, 1.82604103e-03f, 5.67820892e-02f, 6.85950816e-02f, -1.93313837e-01f,
  -4.44689170e-02f, 4.40662913e-02f, 4.83422205e-02f, -7.44347498e-02f, -1.18926086e-01f, 1.12085640e-02f, 4.35504429e-02f, 1.52144749e-02f, 1.04484089e-01f, -1.20007135e-01f,
  -8.49358831e-03f, 7.08830059e-02f, 5.89969009e-02f, -1.03175648e-01f, 1.54041395e-01f, -7.43221492e-02f, 7.85929263e-02f, -1.44998077e-02f, 6.93031475e-02f, 2.66301297e-02f,
  8.63996074e-02f, 6.36150837e-02f, 8.61100331e-02f, -6.13428392e-02f, 5.45574129e-02f, 2.98566278e-02f, 9.08232667e-03f, -3.29504162e-02f, -1.49341941e-01f, 1.53889805e-02f,
  -2.70874500e-02f, 7.39204511e-02f, 5.53032905e-02f, -8.51399265e-03f, 1.64282352e-01f, 4.81399819e-02f, -5.33551946e-02f, -1.80753022e-02f, 7.10403919e-02f, -3.33277099e-02f,
  7.55910426e-02f, -3.53140570e-02f, 8.41462687e-02f, -5.51023223e-02f, 3.21013704e-02f, -4.29348573e-02f, 2.61347760e-02f, -5.04796579e-02f, 8.15138817e-02f, 3.43702957e-02f,
  -2.54861247e-02f, -5.87452948e-02f, -1.21721432e-01f, -1.22958198e-01f, -9.33098271e-02f, -1.27126202e-01f, -1.12653807e-01f, -1.83656365e-02f, -8.41344595e-02f, -5.30939281e-01f,
  2.51749724e-01f, 1.04190096e-01f, -1.58047974e-01f, -4.80800606e-02f, -3.18874768e-03f, 2.95370638e-01f, 3.68002832e-01f, 3.52671862e-01f, 8.90780613e-02f, 1.47143632e-01f,
  2.48010010e-01f, -1.24419466e-01f, -2.48440984e-03f, -9.29967687e-02f, 5.64455725e-02f, 2.37646773e-02f, -3.09878290e-01f, -4.53318417e-01f, 3.12530845e-02f, 2.76536196e-01f,
  -2.36351237e-01f, -3.84362996e-01f, -1.26119241e-01f, -1.85082883e-01f, -1.93358347e-01f, -1.98716819e-01f, -3.60151567e-02f, -1.10323012e-01f, -9.67300609e-02f, -8.18293452e-01f,
  1.21665724e-01f, 1.64090380e-01f, -1.09396549e-02f, 8.87702927e-02f, -1.17695294e-01f, -1.01129133e-02f, 7.44770542e-02f, 2.46566143e-02f, 4.13534231e-02f, -6.94524795e-02f,
  -3.05325561e-03f, -1.36377672e-02f, -2.40809768e-02f, -5.47560453e-02f, -8.83783326e-02f, -3.07403505e-04f, 1.48698036e-02f, -8.66212249e-02f, -5.89062385e-02f, -1.64562799e-02f,
  -2.00065047e-01f, -1.23200007e-01f, -6.78623170e-02f, 9.26006734e-02f, 1.19068816e-01f, -2.03584105e-01f, 6.99823052e-02f, 4.23995964e-02f, -3.97570468e-02f, 4.16106507e-02f,
  -5.68917813e-03f, 1.40457870e-02f, 4.36540656e-02f, 9.97295380e-02f, -4.43928763e-02f, 6.77253976e-02f, -3.21623869e-02f, 6.26699030e-02f, 2.63923910e-02f, 6.02138937e-02f,
  3.01113781e-02f, 3.39178853e-02f, -5.87582737e-02f, 1.27240062e-01f, -1.87777504e-02f, 5.30698919e-04f, -4.52535078e-02f, -4.99781929e-02f, 2.61572860e-02f, 7.44520873e-03f,
  9.01433527e-02f, 1.07410669e-01f, -1.97067503e-02f, -2.38022171e-02f, -3.58054936e-02f, -2.08956506e-02f, -7.22898692e-02f, 6.29041493e-02f, 5.63618019e-02f, -4.71836850e-02f,
  1.03788808e-01f, -8.05732608e-02f, -9.97305810e-02f, 3.05286590e-02f, -1.33375144e-02f, -1.05077717e-02f, -1.74117878e-01f, -4.32149731e-02f, -2.23564170e-02f, -5.33589460e-02f,
  3.25928926e-02f, 9.43927616e-02f, -9.81747285e-02f, -9.41989105e-03f, 3.34509201e-02f, 2.44791396e-02f, 2.17265319e-02f, -2.40991618e-02f, 8.91877164e-04f, -1.88036449e-02f,
  2.29986515e-02f, 1.21267430e-01f, 1.91959873e-01f, 2.89969016e-02f, -5.27829751e-02f, -2.99471896e-02f, 6.33629933e-02f, 1.52234631e-02f, 1.22160055e-01f, 9.43197832e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.36917204e-01f, -1.44889265e-01f, 5.34276247e-01f, -4.59023565e-01f, -7.65417874e-01f, -5.29410481e-01f, -4.09461826e-01f, -1.54579654e-01f, -2.72759348e-01f, -1.35296613e-01f,
  -3.00064217e-02f, 1.86055273e-01f, 3.66202325e-01f, 4.97033656e-01f, 4.12363321e-01f, -8.77076164e-02f, -1.83794022e-01f, 5.66583812e-01f, 4.53548312e-01f, -3.33279036e-02f,
  -2.65292048e-01f, -7.08557898e-04f, 3.17465365e-01f, 2.54079372e-01f, 1.63658168e-02f, 1.82435527e-01f, 1.45548776e-01f, 6.24589901e-03f, -1.61140934e-02f, 4.50556546e-01f,
  3.21474552e-01f, -1.55929327e-02f, -4.44654860e-02f, -2.14706853e-01f, -4.95414287e-02f, 1.18781708e-01f, -5.91141693e-02f, 5.72101884e-02f, -1.70379072e-01f, -2.41587237e-02f,
  -2.08792567e-01f, -1.24060951e-01f, -1.27314031e-01f, 9.19506699e-03f, -1.06948867e-01f, 1.12699449e-01f, 3.84042338e-02f, 3.25863570e-01f, 8.93037692e-02f, 1.12529650e-01f,
  -7.24669993e-02f, -1.65844277e-01f, -9.64010581e-02f, -9.81040150e-02f, -1.13250753e-02f, -8.82299691e-02f, 4.76532206e-02f, 8.55361819e-02f, 1.65866707e-02f, 2.99295425e-01f,
  -8.43388066e-02f, 6.18821345e-02f, -6.42027557e-02f, 6.01922162e-02f, 1.14634380e-01f, -1.10698789e-01f, 4.39790264e-02f, -7.07230493e-02f, 5.17685674e-02f, 9.48625710e-03f,
  2.13373359e-02f, 4.66333441e-02f, 1.39701003e-02f, 5.56438323e-03f, 6.83189556e-02f, -1.28039539e-01f, -3.62498052e-02f, 8.04511085e-02f, -1.52449667e-01f, 3.82199697e-02f,
  -1.10010840e-01f, 2.87581496e-02f, -4.71325926e-02f, 6.57650158e-02f, -6.02731928e-02f, 6.74608499e-02f, 1.81826558e-02f, 1.90165173e-03f, -4.09736596e-02f, -6.75645145e-03f,
  -2.38645434e-01f, -1.89305972e-02f, 7.95387626e-02f, 2.25028262e-01f, -9.00788158e-02f, -1.24744168e-02f, 1.70734234e-03f, -5.47470003e-02f, -1.30795106e-01f, 2.10129209e-02f,
  3.28903086e-02f, 6.13883808e-02f, 1.68589391e-02f, 8.37732330e-02f, 8.08840692e-02f, -1.72440380e-01f, -1.19891338e-01f, 1.67431533e-01f, 9.15734656e-03f, -1.01568654e-01f,
  -1.44875282e-02f, -8.26923624e-02f, -2.83337552e-02f, -1.46692060e-02f, -6.44726306e-02f, -5.74728213e-02f, 1.43024400e-01f, 2.87642386e-02f, 4.33227345e-02f, 2.94144768e-02f,
  -6.09374903e-02f, -4.71233785e-01f, -4.83908579e-02f, -4.46316928e-01f, 4.04501567e-03f, 1.98130295e-01f, 3.87017280e-01f, 6.28430694e-02f, -2.11173326e-01f, 1.22722723e-01f,
  -3.70090067e-01f, -3.52446377e-01f, -1.02185369e-01f, -2.34926492e-01f, -1.82521388e-01f, 3.10493529e-01f, 1.04160413e-01f, 6.07652143e-02f, 1.02650791e-01f, -2.39787132e-01f,
  -1.97408319e-01f, -2.42783219e-01f, -3.86170864e-01f, -1.40516043e-01f, 6.85387403e-02f, 2.53921926e-01f, 9.43790600e-02f, -6.59198612e-02f, -1.94330756e-02f, 1.53159760e-02f,
  5.60225368e-01f, -3.35233539e-01f, -1.14771545e-01f, -2.59074450e-01f, -2.07832024e-01f, 5.68551058e-03f, 9.71664935e-02f, -4.03379053e-02f, -6.63876906e-02f, 6.21048324e-02f,
  -2.21622989e-01f, -6.46962970e-02f, 1.82111617e-02f, 3.38097960e-02f, 6.47133216e-02f, 6.55301809e-02f, -1.02620572e-01f, -3.11103076e-01f, -2.93784708e-01f, -1.08920019e-02f,
  -1.59892619e-01f, -2.21564829e-01f, -8.05775076e-02f, -4.00609756e-03f, -2.03125611e-01f, -1.56456649e-01f, -1.21236071e-01f, -6.27998114e-02f, -6.19041100e-02f, 3.20247471e-01f,
  4.39276285e-02f, 1.38974532e-01f, -1.44817829e-02f, 9.24136192e-02f, 1.13863833e-01f, 9.05819014e-02f, 2.28859223e-02f, 4.00743596e-02f, 2.37478390e-02f, 1.05747059e-01f,
  -3.25248614e-02f, -6.57785907e-02f, 2.33060699e-02f, -2.76111681e-02f, -2.03427337e-02f, -1.74730182e-01f, 4.63049440e-03f, 4.46447097e-02f, 7.26745948e-02f, -4.58308496e-02f,
  -3.15838382e-02f, 1.15458556e-01f, -3.28966901e-02f, -9.72257636e-04f, -1.27697825e-01f, 2.21667308e-02f, 1.13853291e-02f, -2.08480898e-02f, -4.82695363e-02f, -2.51394603e-02f,
  2.10465088e-01f, -3.21406275e-01f, 3.03664356e-01f, -3.36761065e-02f, 5.28242700e-02f, -1.85686409e-01f, 2.08475534e-02f, -4.38179821e-02f, 5.37563935e-02f, 1.78069890e-01f,
  -1.62722483e-01f, 8.41894299e-02f, 6.53214902e-02f, 3.89362834e-02f, 1.79860666e-01f, -9.49728116e-02f, 7.94845168e-04f, 2.29533613e-02f, -1.26783058e-01f, -1.79815590e-02f,
  -2.11311094e-02f, 3.30243528e-01f, 2.79308915e-01f, 2.22632885e-01f, 4.14822474e-02f, 2.36731723e-01f, 3.55056673e-01f, 2.62630373e-01f, 3.15331489e-01f, 5.84578454e-01f,
  -9.27428544e-01f, 7.60052353e-02f, -2.30627477e-01f, -6.84524775e-01f, -1.55321673e-01f, 1.86963901e-01f, 2.55886540e-02f, 2.68854111e-01f, -5.17071486e-02f, -1.64064735e-01f,
  -1.77957918e-02f, -2.16880590e-01f, -4.88099515e-01f, -1.12898527e-02f, -1.29080847e-01f, -1.74762905e-01f, -5.69419265e-01f, -5.48034251e-01f, 1.95161238e-01f, 8.47713411e-01f,
  3.89756918e-01f, -1.32237360e-01f, -3.24132890e-01f, 1.88719943e-01f, 1.11980699e-01f, -1.35959700e-01f, -5.70011675e-01f, -2.10525423e-01f, 3.25661480e-01f, -6.87719643e-01f,
  6.10878468e-02f, -7.58703053e-03f, 7.83061534e-02f, -1.37888074e-01f, 8.68512914e-02f, -2.52643060e-02f, 1.68625161e-01f, -3.99173588e-01f, 1.03325641e-03f, -7.89640099e-02f,
  -1.95689544e-01f, 7.98541382e-02f, -2.16896072e-01f, 2.74370462e-02f, -7.74840405e-03f, 5.19938543e-02f, 7.03318343e-02f, 1.15106590e-01f, 4.52945381e-02f, 3.81803870e-01f,
  9.57229584e-02f, 9.38310381e-03f, -1.32029355e-01f, 2.98300415e-01f, 3.57685983e-01f, -9.88906473e-02f, 2.43443444e-01f, 1.39988258e-01f, 8.01933091e-03f, -1.11643657e-01f,
  2.24501528e-02f, 1.49932234e-02f, 2.63223909e-02f, 7.75480419e-02f, -1.12325400e-02f, -7.26996213e-02f, -1.01906620e-01f, -2.57058740e-02f, 3.59462164e-02f, -1.54871065e-02f,
  4.24644053e-02f, -1.33767640e-02f, 1.01675838e-01f, -1.03714444e-01f, -9.38585773e-02f, -4.27086167e-02f, -2.84399986e-02f, 4.65496145e-02f, -4.91631925e-02f, -1.46151692e-01f,
  -6.51182011e-02f, -8.01529139e-02f, -4.96085212e-02f, 1.36850029e-01f, -3.70666273e-02f, -1.38376042e-01f, 9.23294276e-02f, 6.71246722e-02f, 1.01202354e-01f, 2.76556499e-02f,
  -9.26013514e-02f, -1.98898211e-01f, -2.56353259e-01f, 4.59987000e-02f, -2.15905085e-01f, 5.72978184e-02f, -9.78406072e-02f, 1.40663669e-01f, -6.85357377e-02f, 1.05146296e-01f,
  8.97041336e-02f, -6.87973723e-02f, -4.37776484e-02f, 1.49358988e-01f, 9.35133919e-02f, 1.65309981e-02f, -8.97646993e-02f, -2.45345056e-01f, -3.94163132e-02f, 7.24195167e-02f,
  1.34521164e-02f, -2.57146686e-01f, -3.65917772e-01f, -2.51797289e-01f, 5.11989780e-02f, -2.68914819e-01f, 5.62166970e-05f, 1.25084072e-01f, -2.00790167e-02f, 7.48197129e-03f,
  1.16042995e+00f, -1.11665092e-01f, 4.60985273e-01f, 1.33132428e-01f, 1.76147237e-01f, 2.77536333e-01f, 1.45900160e-01f, 6.97908923e-02f, 1.30085081e-01f, 1.56286627e-01f,
  1.73093066e-01f, -2.90836096e-01f, -2.57882863e-01f, -1.85931593e-01f, 1.32942379e-01f, -1.65311649e-01f, -2.35317379e-01f, 3.93243070e-04f, 2.32389823e-01f, 2.38878757e-01f,
  -3.19784731e-01f, 3.24263936e-03f, 1.50125653e-01f, 5.82429878e-02f, 6.41061068e-02f, 1.52169183e-01f, 1.34455442e-01f, 3.65306705e-01f, 3.82077038e-01f, 6.68998212e-02f,
  3.89024466e-01f, 1.48854524e-01f, -8.20696875e-02f, -4.12197113e-02f, -8.99202898e-02f, -2.37534568e-02f, 1.23295723e-03f, 1.56246116e-02f, -4.90901470e-02f, 6.82453662e-02f,
  1.64823066e-02f, -5.36443293e-02f, -3.16968225e-02f, -8.34373310e-02f, 7.26187304e-02f, 3.02577596e-02f, -1.65628269e-01f, 8.41107294e-02f, 1.59304783e-01f, 6.61952943e-02f,
  -3.45275104e-01f, 8.52809921e-02f, 2.25751743e-01f, -1.20829919e-03f, 8.85681063e-02f, -4.05525230e-02f, 1.38481110e-02f, 1.88824043e-01f, 1.76359892e-01f, 1.78798705e-01f,
  1.63267404e-02f, 6.38924763e-02f, 2.93229278e-02f, 2.15157755e-02f, -8.34638774e-02f, -3.03399265e-02f, -2.29065046e-02f, -8.19391087e-02f, -7.01264814e-02f, -8.75410661e-02f,
  -1.12485094e-02f, 1.17642164e-01f, -3.18533406e-02f, 3.50284763e-02f, -1.06057480e-01f, -2.87537538e-02f, 3.89192402e-02f, -4.03540209e-02f, -5.06737232e-02f, 7.47661665e-02f,
  9.13029984e-02f, -1.27560824e-01f, 2.13835184e-02f, -3.80006917e-02f, 2.93436982e-02f, 1.04017012e-01f, -4.57830541e-02f, 1.72722172e-02f, 4.88855876e-02f, -1.41042639e-02f,
  -9.50024500e-02f, 1.14604570e-01f, 5.53004257e-02f, -5.63385263e-02f, 1.34029686e-01f, -8.74177739e-02f, -2.99127237e-03f, 6.26806021e-02f, 9.48756486e-02f, 1.26242772e-01f,
  1.43763617e-01f, 4.00106348e-02f, 3.97619642e-02f, -5.73781244e-02f, 8.75637680e-02f, 1.44269448e-02f, -7.00928792e-02f, 8.22404101e-02f, 1.51715264e-01f, -2.37734970e-02f,
  -2.24704117e-01f, 2.81791221e-02f, 2.01438680e-01f, -8.83885026e-02f, 3.24845128e-02f, 6.55356273e-02f, 1.99832153e-02f, 3.63181867e-02f, 2.24938095e-01f, 9.26547311e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.65199971e-01f, 8.11804116e-01f, 9.46511030e-02f, 3.27052504e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.28222060e-01f, 1.90552045e-02f, 5.01177125e-02f, -1.04213893e-01f, -1.99768126e-01f, 4.61751632e-02f, 8.48974049e-01f, 4.19726014e-01f, 1.47177845e-01f, -6.80288672e-01f,
  1.18657157e-01f, 6.48349673e-02f, 5.56659373e-03f, 1.81964263e-01f, 5.94877422e-01f, 9.12520289e-02f, 2.73943663e-01f, -2.05357134e-01f, -5.31829633e-02f, -1.07901439e-01f,
  -2.75210381e-01f, -5.44006564e-03f, 3.50153863e-01f, 5.21317758e-02f, -3.56131732e-01f, 2.61712074e-02f, -1.42953217e-01f, 3.12804610e-01f, -6.39915287e-01f, -1.85910374e-01f,
  3.39931101e-01f, 5.87001108e-02f, 1.21709727e-01f, -2.41076320e-01f, 1.38308452e-02f, 2.45473355e-01f, -3.92061099e-02f, 4.20940429e-01f, 4.54702288e-01f, 3.75754982e-02f,
  -2.21403658e-01f, -6.99101016e-02f, -3.10625374e-01f, 5.05231977e-01f, -2.06603721e-01f, 5.73847413e-01f, -4.46136713e-01f, 1.76706120e-01f, -1.50332004e-01f, 3.09437931e-01f,
  1.06948890e-01f, -1.23501243e-02f, 1.39484391e-01f, -6.23495616e-02f, -2.93510497e-01f, 1.10637896e-01f, -3.73124704e-02f, -5.45360684e-01f, 1.87381566e-01f, -1.35735258e-01f,
  3.00891429e-01f, -2.78562516e-01f, -1.11106575e-01f, 1.63300514e-01f, -6.33630231e-02f, -9.42802057e-02f, -1.46236330e-01f, 1.45773843e-01f, -1.35292998e-02f, 4.48765680e-02f,
  -4.68371779e-01f, -2.85716981e-01f, -2.57875234e-01f, 7.43947208e-01f, -8.08008015e-02f, -1.88600466e-01f, 2.14252308e-01f, 6.59244740e-03f, -1.37972618e-02f, 2.98071146e-01f,
  1.87235892e-01f, 9.60653573e-02f, 1.90353096e-01f, -1.98398516e-01f, -1.90383986e-01f, -4.52071726e-01f, 1.52348399e+00f, -2.25679904e-01f, 8.35263580e-02f, -1.77287355e-01f,
  3.75659093e-02f, -1.78187534e-01f, 9.80312303e-02f, -7.71353394e-02f, 2.67889172e-01f, -4.50306237e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.23011911e-01f, 5.09672761e-01f, 9.09825712e-02f, 7.00925663e-02f, 3.87151182e-01f, 2.14936256e-01f, 3.16816598e-01f, -2.15753004e-01f, 2.32718751e-01f, 2.11802557e-01f,
  4.86991942e-01f, 6.52727664e-01f, 7.76492178e-01f, 4.04239804e-01f, 6.16523921e-01f, -9.96550143e-01f, -5.23511350e-01f, 3.29329401e-01f, -4.58136201e-02f, 1.96943894e-01f,
  2.71282524e-01f, 2.76232749e-01f, 6.59950227e-02f, 2.24821731e-01f, 4.74360399e-02f, -2.62673438e-01f, -1.41904324e-01f, 6.79132879e-01f, -4.24508974e-02f, -5.69871766e-03f,
  -1.11020595e-01f, 4.50853020e-01f, 3.52452606e-01f, 4.05894607e-01f, 7.86527842e-02f, -1.79142319e-02f, 7.14012563e-01f, -3.20317090e-01f, 6.68054998e-01f, -5.93798041e-01f,
  1.35624856e-01f, 1.29184139e+00f, 5.83315313e-01f, -8.53602171e-01f, 1.17896438e-01f, 1.17381863e-01f, 3.43626648e-01f, -6.67824328e-01f, -5.92009425e-01f, 2.07561985e-01f,
  -2.53469851e-02f, 4.42637861e-01f, 8.99241030e-01f, 5.82090914e-01f, 4.67596576e-02f, -2.53867745e-01f, 9.35074538e-02f, 6.07578397e-01f, -2.18217805e-01f, -2.36356929e-02f,
  8.75828266e-01f, 6.30066276e-01f, 1.40259370e-01f, 2.58772867e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  4.12687957e-01f, 1.13617174e-01f, 4.39415067e-01f, -1.78240225e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.43280703e-01f, -4.47663873e-01f, -1.74351692e-01f, -1.86477810e-01f, -4.75277960e-01f, 7.69642219e-02f, -8.42901319e-02f, -5.67638993e-01f, -3.50844860e-01f, 1.51956856e-01f,
  -1.18477426e-01f, 1.42949879e-01f, -5.33313334e-01f, -1.52607217e-01f, 2.68823624e-01f, 2.64504284e-01f, -4.74547923e-01f, 5.47965527e-01f, 5.42983711e-02f, -7.65123740e-02f,
  -6.76840544e-02f, 1.98592305e-01f, -2.94151515e-01f, 3.99324805e-01f, -4.29223239e-01f, -7.18788505e-01f, 6.13738120e-01f, -5.48002541e-01f, -4.71746475e-01f, -3.82557750e-01f,
  1.66017517e-01f, 9.55584571e-02f, 2.78243661e-01f, -4.22391027e-01f, 1.01013705e-01f, -3.32414031e-01f, -9.70822573e-02f, -2.46676221e-01f, -1.63404584e-01f, -2.86961555e-01f,
  -9.60861221e-02f, 8.52477372e-01f, -1.22415073e-01f, -4.70152795e-01f, -5.11198714e-02f, 2.18000505e-02f, 2.65135884e-01f, -2.35605121e-01f, 2.14234099e-01f, 4.56211865e-01f,
  -2.75962830e-01f, 7.09384084e-02f, -1.52232684e-02f, 4.16295230e-01f, 1.99379250e-01f, -1.15237854e-01f, 3.48763615e-01f, -1.68829992e-01f, -2.13805333e-01f, 4.39552695e-01f,
  -7.26298168e-02f, 3.12073469e-01f, -6.58440709e-01f, -5.15080877e-02f, 2.13010028e-01f, 9.66244191e-02f, 5.81473589e-01f, 2.76064306e-01f, 3.24285746e-01f, -2.21574366e-01f,
  -1.53162628e-01f, 4.37243313e-01f, -6.31312370e-01f, 7.28003383e-02f, -3.27576607e-01f, -2.05685303e-01f, 3.36485654e-01f, -6.02236867e-01f, 1.99455515e-01f, -5.21378100e-01f,
  3.17971498e-01f, 3.18130612e-01f, 3.70651454e-01f, 2.34295890e-01f, 2.17721060e-01f, -7.52967149e-02f, 1.64753512e-01f, 4.71871793e-02f, -1.57860264e-01f, 2.00498551e-01f,
  -5.88674009e-01f, 6.00470826e-02f, 4.73272085e-01f, -2.02088892e-01f, 1.59980267e-01f, -4.96281147e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.60905528e-01f, 4.12900507e-01f, 9.99240994e-01f, 1.60926664e+00f, -3.08017224e-01f, 3.34757447e-01f, -8.68583679e-01f, -4.92598623e-01f, 7.38064528e-01f, -1.61915049e-01f,
  1.05129218e+00f, -8.51179302e-01f, 1.46316573e-01f, -1.70144327e-02f, 4.35374051e-01f, 5.75430632e-01f, 7.63809144e-01f, -7.24579215e-01f, 2.11512432e-01f, -2.54006594e-01f,
  2.41524592e-01f, 6.91335738e-01f, 1.05445981e+00f, -1.37218738e+00f, 4.52771127e-01f, 9.11113322e-01f, -5.53238280e-02f, 5.64294219e-01f, 4.68288064e-01f, -2.43582875e-01f,
  4.02948707e-01f, 7.76079357e-01f, 3.79566282e-01f, -6.67612314e-01f, -2.63022482e-01f, -1.78495914e-01f, -4.63830195e-02f, -1.88363183e+00f, -2.71174580e-01f, -3.41909885e-01f,
  -7.93949366e-01f, -1.00714087e+00f, 5.25914192e-01f, 9.60412994e-02f, 6.55199528e-01f, -5.48946440e-01f, 1.57522380e+00f, 2.43840531e-01f, 7.95507193e-01f, 9.43130851e-01f,
  -8.23387429e-02f, -2.39022657e-01f, 3.56823683e-01f, 6.07377589e-01f, 4.77603495e-01f, -2.93504238e-01f, -1.20631504e+00f, -4.52549696e-01f, 8.46815705e-01f, 8.04284394e-01f,
  -3.63241017e-01f, -9.32224169e-02f, 8.54873598e-01f, 1.03537028e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  3.52904826e-01f, -1.44580483e-01f, -2.82180160e-01f, 6.38127625e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.76123375e-01f, -8.30869377e-01f, 8.12343061e-01f, -5.17495871e-01f, -4.90752548e-01f, -8.61182988e-01f, -1.60192117e-01f, -4.72043008e-01f, -7.08169341e-02f, -7.33314037e-01f,
  1.58861190e-01f, 1.47973672e-01f, -3.19749206e-01f, -1.11163414e+00f, 1.20147383e+00f, -9.93009210e-01f, 5.94740272e-01f, -1.63460708e+00f, 3.31815392e-01f, -9.28691149e-01f,
  -3.43921036e-01f, 3.32894385e-01f, -9.24842417e-01f, -2.17409968e-01f, -9.31963980e-01f, 3.76969606e-01f, -4.36664015e-01f, -1.28939990e-02f, 1.19682126e-01f, 6.51491582e-01f,
  -1.90559316e+00f, -2.27089643e-01f, 6.21807396e-01f, -1.42470467e+00f, -1.82400197e-01f, -1.27329743e+00f, 1.34001255e-01f, -3.75354171e-01f, 1.23964167e+00f, -1.01948328e-01f,
  1.42479205e+00f, 1.37191251e-01f, 7.37705052e-01f, 3.00232947e-01f, -1.01773179e+00f, -4.87940870e-02f, 6.52803242e-01f, 3.77012312e-01f, -9.69429374e-01f, 2.01511574e+00f,
  -8.93250883e-01f, -6.26167595e-01f, -4.15006965e-01f, -5.37852168e-01f, -7.16740429e-01f, 1.14192760e+00f, -7.95569360e-01f, -7.44267762e-01f, 7.56084859e-01f, 6.72832489e-01f,
  -4.26434070e-01f, -2.86594391e-01f, 5.32054007e-01f, 3.89734834e-01f, -1.27433741e+00f, 9.05929029e-01f, 1.43394530e-01f, 1.77915430e+00f, -7.37481773e-01f, -1.46306324e+00f,
  -4.51660722e-01f, -8.61841559e-01f, -1.19549084e+00f, -7.98269451e-01f, 1.43044400e+00f, 7.90627837e-01f, 3.34521055e-01f, -6.96560442e-02f, -1.08437610e+00f, -4.60184067e-01f,
  -8.22384238e-01f, 9.57124710e-01f, -1.36367190e+00f, 8.49765018e-02f, 1.82293463e+00f, 1.23044431e+00f, -1.28647661e+00f, -1.21329403e+00f, -8.80469382e-01f, 1.46401417e+00f,
  -1.11953032e+00f, 1.08093297e+00f, -6.10707104e-01f, -5.37318647e-01f, -5.52370727e-01f, -1.93683431e-01f, -1.30211878e+00f, 7.86895335e-01f, -2.72895455e-01f, -6.26141667e-01f,
  3.53346854e-01f, -5.47770977e-01f, 1.39605546e+00f, -2.07365602e-01f, 2.00523186e+00f, -1.01968515e+00f, -1.28169358e+00f, -2.01555824e+00f, 9.62057561e-02f, 2.36667201e-01f,
  -5.05925775e-01f, -9.72022563e-02f, 7.44058549e-01f, -8.10602129e-01f, 2.83203721e-01f, -6.36486888e-01f, -8.38437304e-02f, 2.78289646e-01f, 3.70977938e-01f, 4.74516839e-01f,
  6.13297522e-01f, -1.38826773e-01f, 6.69518650e-01f, 5.66897035e-01f, 6.41303360e-01f, -1.10172594e+00f, -4.80989553e-02f, 4.46456909e-01f, 6.33776248e-01f, 4.40279603e-01f,
  -9.52066123e-01f, 5.30293763e-01f, -6.97936118e-01f, -9.26028371e-01f, 1.69658494e+00f, 1.50925159e+00f, -1.09014106e+00f, 6.72798157e-01f, -3.75325114e-01f, -7.30168343e-01f,
  1.71036109e-01f, -2.79665917e-01f, -7.49711752e-01f, 8.02793980e-01f, 9.64216173e-01f, 5.52000701e-01f, 6.32337630e-01f, 1.44318354e+00f, 7.15271592e-01f, 7.71051764e-01f,
  8.16082120e-01f, -8.54196787e-01f, 2.03005385e+00f, 3.90931107e-02f, 1.25929487e+00f, 1.19776893e+00f, -9.84264076e-01f, 2.66442388e-01f, -1.09307694e+00f, 6.04939401e-01f,
  3.49923670e-02f, -5.19483030e-01f, -8.48057389e-01f, 9.74380895e-02f, 5.53915799e-01f, 6.26073778e-01f, -4.20584343e-02f, -3.14859599e-01f, -5.81611991e-01f, -4.48464811e-01f,
  -1.24782455e+00f, 2.71977596e-02f, -4.17256027e-01f, 4.65409815e-01f, 5.94855011e-01f, -8.97594213e-01f, 2.55977899e-01f, 6.79695845e-01f, 7.29226828e-01f, 1.01959765e+00f,
  -1.45475626e-01f, 1.52677298e-01f, -5.97964644e-01f, 6.40522778e-01f, 4.00134951e-01f, 7.29994118e-01f, -1.22238946e+00f, -1.21925402e+00f, 8.67011786e-01f, -1.42057884e+00f,
  -1.04638100e+00f, -1.36112833e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.25891924e-01f, -3.84992994e-02f, -2.75124442e-02f, -9.90045488e-01f, 6.01275623e-01f, 1.15739167e+00f, 1.38237374e-02f, 1.72643270e-02f, -5.48583716e-02f, 3.25359613e-01f,
  -1.55670905e+00f, -2.85583109e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    