/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.02888685e-01f, -9.86313149e-02f, 2.77323723e-01f, -1.81790143e-01f, -2.52629016e-02f, 8.56409408e-03f, -2.50680074e-02f, 1.17662968e-02f, 2.35585362e-01f, -1.31450519e-01f,
  -5.54372035e-02f, 6.97730035e-02f, 1.66686743e-01f, -1.44670367e-01f, 2.16143638e-01f, 3.24933864e-02f, -1.45936310e-01f, -2.53407434e-02f, -5.90007054e-03f, -2.28395239e-02f,
  4.94711660e-02f, -2.02532694e-01f, 4.14089374e-02f, -9.11758319e-02f, -1.14220031e-01f, 2.91463006e-02f, -1.40912682e-01f, 6.05993420e-02f, -1.60760969e-01f, -3.72632407e-02f,
  7.84952417e-02f, 1.90143287e-01f, 1.90510415e-02f, 1.00554146e-01f, 1.13027588e-01f, -1.00613702e-02f, 4.06763377e-03f, 6.67163208e-02f, 3.78214233e-02f, -7.45413527e-02f,
  3.95036377e-02f, -9.44124348e-03f, -1.77031178e-02f, 7.43108289e-03f, -3.69970240e-02f, -9.36022848e-02f, -4.42861468e-02f, -2.86616222e-03f, 5.76523133e-02f, -2.26550065e-02f,
  -4.44250107e-02f, 6.33924603e-02f, -1.21720713e-02f, 8.84743501e-03f, -3.12332809e-02f, -9.67788696e-02f, -1.93120632e-02f, 8.68288055e-03f, -5.53619824e-02f, 4.20171060e-02f,
  -7.36166984e-02f, 1.64567530e-01f, 3.32132652e-02f, -1.62643027e-02f, 6.51552156e-02f, -1.96007229e-02f, 4.15666588e-02f, -2.38484424e-02f, 8.24116394e-02f, -2.56493483e-02f,
  2.76807062e-02f, 1.62883904e-02f, 2.11940203e-02f, 3.69441025e-02f, 6.06857939e-03f, -3.87397856e-02f, 2.31337473e-02f, -7.80695975e-02f, -7.13537931e-02f, -5.02546169e-02f,
  1.13845896e-03f, 5.83804995e-02f, -8.31895471e-02f, -4.80078310e-02f, 3.97702754e-02f, 7.54227340e-02f, 2.74648480e-02f, 5.11423172e-03f, 6.89731613e-02f, 8.54337066e-02f,
  3.59149985e-02f, 8.81357044e-02f, -4.97643985e-02f, -5.95496073e-02f, 4.70891669e-02f, 4.86535393e-03f, -2.70248037e-02f, -6.64395988e-02f, 6.20395020e-02f, 1.10124601e-02f,
  -9.18552279e-02f, -4.96417731e-02f, 5.88854365e-02f, 5.85214905e-02f, 6.85554370e-03f, 7.13472739e-02f, 3.00325695e-02f, 7.90739432e-02f, -4.96020541e-02f, -1.16095752e-01f,
  -6.04154319e-02f, 1.15150642e-02f, -8.36784914e-02f, -3.74295563e-02f, -7.38985687e-02f, -1.28801633e-02f, -3.30387950e-02f, 2.51943478e-03f, -5.43312095e-02f, 1.18094049e-02f,
  4.09347206e-01f, -3.44580919e-01f, -1.40779853e-01f, 1.11642390e-01f, -5.12503758e-02f, 2.34637499e-01f, 1.24133758e-01f, -3.72177958e-02f, 6.35543615e-02f, -1.80354416e-01f,
  1.96790546e-01f, -6.33286536e-02f, 4.12563197e-02f, -8.94228055e-04f, 5.15375018e-01f, 2.50083685e-01f, 2.46177405e-01f, 4.26324457e-02f, 1.54323414e-01f, -6.03356771e-02f,
  1.56315595e-01f, 2.42546171e-01f, -7.62830663e-04f, -7.85275027e-02f, -1.91171855e-01f, -1.35321259e-01f, -3.94312590e-02f, -1.08380415e-01f, -1.03091903e-01f, 1.23815075e-01f,
  -5.41888140e-02f, -4.30532917e-02f, -8.72644857e-02f, -3.19160856e-02f, -2.25973725e-02f, -7.84202665e-02f, -7.19686002e-02f, -5.67009635e-02f, 1.47267589e-02f, -6.76358165e-03f,
  -7.92866573e-02f, 3.07846107e-02f, 9.93000716e-02f, 4.34353314e-02f, 2.52745915e-02f, 4.08784598e-02f, -2.17326041e-02f, -7.12460428e-02f, -3.32298130e-02f, 1.83502445e-03f,
  -5.10772318e-02f, -5.95768355e-03f, -1.42427795e-02f, -1.46816857e-02f, 1.49961011e-02f, 1.02391511e-01f, -6.88718923e-04f, -5.38099408e-02f, -3.54040228e-02f, 9.88073200e-02f,
  3.09985671e-02f, 2.37071570e-02f, 1.96207687e-03f, 1.73288826e-02f, 3.79681885e-02f, -3.67676727e-02f, 6.93403333e-02f, 4.36491482e-02f, -3.29010561e-02f, 3.29780877e-02f,
  4.96658683e-02f, -1.34693785e-02f, -3.64043750e-02f, 4.35140841e-02f, 3.38258743e-02f, -6.07929453e-02f, 5.61873941e-03f, 2.77627874e-02f, 1.80639175e-03f, 6.25372771e-03f,
  2.06272975e-02f, 5.04848808e-02f, -5.82400113e-02f, -7.69867888e-03f, -9.27472138e-04f, 2.18980666e-02f, 8.90092924e-02f, -3.35726254e-02f, -4.68596220e-02f, 2.30616014e-02f,
  -5.19265980e-03f, -6.07314752e-03f, -1.49272720e-03f, 2.28549875e-02f, -2.26278715e-02f, -2.93731950e-02f, 3.93451983e-03f, -4.55632471e-02f, -1.00920245e-03f, 7.54866451e-02f,
  -2.88522802e-02f, -4.53999788e-02f, -8.25010017e-02f, 2.14228537e-02f, -1.12131669e-03f, 3.34445387e-02f, 5.48278354e-03f, -6.17989898e-02f, 7.25131808e-03f, 3.51384133e-02f,
  -5.50620630e-02f, -4.10263613e-02f, 1.09060332e-01f, 3.96804512e-02f, -3.70822661e-02f, -1.20650865e-01f, -6.08029813e-02f, -4.87186685e-02f, 6.28425479e-02f, 3.21022086e-02f,
  -4.85582829e-01f, -1.16954304e-01f, 7.31255263e-02f, -2.21033636e-02f, -7.62545317e-02f, -1.43869221e-01f, -2.15828955e-01f, 1.53463501e-02f, 9.15688574e-02f, -1.02417298e-01f,
  -1.37142941e-01f, -4.54066359e-02f, 5.39256148e-02f, -4.81897630e-02f, 1.44976094e-01f, 1.02993459e-01f, -1.95372596e-01f, -2.84170210e-02f, 8.99723694e-02f, -9.21628028e-02f,
  8.41073990e-02f, -8.26153681e-02f, 5.66308852e-03f, 9.39743221e-03f, -1.99869856e-01f, 2.34457348e-02f, -6.63710237e-02f, -5.43614440e-02f, -9.83470678e-02f, 6.94322363e-02f,
  -1.27101168e-01f, -3.95106804e-03f, -2.42337510e-02f, 1.60127833e-01f, -7.56045133e-02f, -2.52805669e-02f, -3.68510857e-02f, -2.62113195e-02f, 3.46114533e-03f, -7.24610090e-02f,
  4.22314368e-03f, -5.50467297e-02f, -8.33447091e-03f, 7.64213875e-02f, 5.02030961e-02f, 9.03833732e-02f, 2.47628987e-02f, -2.12717336e-02f, -2.23360080e-02f, -2.15753168e-02f,
  1.75187737e-02f, -1.99280940e-02f, 4.87621352e-02f, -2.70576328e-02f, 1.01565346e-01f, -1.21338824e-02f, 1.51037099e-02f, 1.42900832e-02f, -1.53645491e-02f, 1.87664628e-02f,
  3.35139735e-03f, -6.23555779e-02f, 2.74316519e-02f, -4.83796671e-02f, 7.54549652e-02f, -1.33534759e-01f, -6.07111156e-02f, -1.30592836e-02f, 9.57397074e-02f, -4.11254503e-02f,
  -1.07528130e-02f, 8.01018775e-02f, 2.59893499e-02f, 3.04048788e-02f, 3.72269228e-02f, -1.34628356e-01f, -4.06603217e-02f, 1.37088383e-02f, -4.54373434e-02f, 3.05648660e-03f,
  8.35075136e-03f, -7.00602084e-02f, 4.70742816e-03f, -1.21638209e-01f, -2.50671636e-02f, 7.63300061e-02f, 6.56171218e-02f, 1.07910126e-01f, -8.60839486e-02f, -6.72541931e-03f,
  -4.44316957e-03f, 4.56660129e-02f, 1.58309825e-02f, -7.53584132e-02f, 6.25924766e-02f, 4.78234775e-02f, 1.91400051e-02f, 2.41342355e-02f, 5.54205403e-02f, -9.62563977e-03f,
  2.12576389e-02f, 3.64711024e-02f, -1.10931480e-02f, 5.09171821e-02f, -2.74962862e-03f, 5.55111095e-02f, -3.56910983e-03f, 3.60608585e-02f, 5.19742332e-02f, -7.18654767e-02f,
  4.52560782e-02f, -6.36457726e-02f, 9.00016800e-02f, -4.04722206e-02f, -3.32162157e-02f, 5.21902815e-02f, -3.25741991e-02f, -2.29935888e-02f, 8.32650624e-03f, -8.69915932e-02f,
  -3.62943530e-01f, 1.45836901e-02f, -2.20425203e-01f, 1.56949252e-01f, -1.46334946e-01f, 1.44636855e-02f, 1.65063590e-02f, -1.62034035e-02f, 1.02946065e-01f, 2.28802964e-01f,
  4.91277017e-02f, 1.31145611e-01f, 9.26656201e-02f, 2.02374682e-01f, 1.38006613e-01f, 2.67816097e-01f, 8.74571204e-02f, -1.87351033e-02f, 7.75317699e-02f, -8.18059817e-02f,
  -7.76706338e-02f, 1.93321481e-01f, 3.64205129e-02f, 1.41996657e-02f, -5.36648324e-03f, 7.18864202e-02f, 1.12502776e-01f, 1.38815716e-01f, 5.85439440e-04f, 1.39112636e-01f,
  -2.59825978e-02f, -4.30294424e-02f, -1.26837566e-01f, -9.26939249e-02f, -6.49290830e-02f, -1.07384369e-01f, -1.08733311e-01f, -1.07439995e-01f, -3.17202210e-02f, 3.93055268e-02f,
  3.73906083e-02f, 4.63485047e-02f, -1.37608815e-02f, 9.63126868e-02f, -3.89433019e-02f, 1.52899586e-02f, 6.92080660e-03f, 5.61299026e-02f, -5.51013127e-02f, -4.14837524e-02f,
  -1.74663048e-02f, -3.48218456e-02f, 1.58141758e-02f, -5.32539673e-02f, -4.14935835e-02f, 5.45228980e-02f, 8.19111988e-02f, 3.58276889e-02f, 4.13192771e-02f, -8.28496739e-02f,
  -2.52048802e-02f, 5.63881211e-02f, -2.65687965e-02f, -1.13409214e-01f, -2.71734651e-02f, -5.32485805e-02f, -4.09744754e-02f, -5.88182062e-02f, -1.33233294e-02f, 1.20078893e-02f,
  -3.52803059e-02f, -7.97844827e-02f, -6.22568093e-03f, 1.23528309e-01f, 4.14598994e-02f, 4.69670147e-02f, -3.23467739e-02f, 1.37348277e-02f, -1.01048104e-01f, 3.17921815e-03f,
  6.88538179e-02f, -1.62919872e-02f, 1.34971468e-02f, 1.43575352e-02f, 5.00012003e-02f, 3.25802676e-02f, -5.82120288e-03f, 8.22303966e-02f, -1.04499884e-01f, -7.22681433e-02f,
  1.20543480e-01f, 1.18728064e-01f, 3.30844261e-02f, 2.19622310e-02f, -3.55500318e-02f, -6.46196008e-02f, 8.17620233e-02f, -2.89214123e-02f, 1.12229571e-01f, -5.20467684e-02f,
  -4.12261896e-02f, 2.79423445e-02f, 5.24257571e-02f, 1.08340494e-02f, 9.77873653e-02f, 2.88086925e-02f, 4.69618142e-02f, -8.17204267e-03f, -2.18472444e-02f, -5.89563400e-02f,
  -2.99581550e-02f, -9.83048156e-02f, -4.39978167e-02f, -4.70476337e-02f, -2.80594658e-02f, 1.99581322e-04f, 5.30861958e-04f, -6.21982897e-03f, 2.72079837e-02f, -4.00475264e-02f,
  3.11533093e-01f, 5.56833632e-02f, -3.40347029e-02f, -7.15535646e-03f, 2.14535482e-02f, 2.72120889e-02f, 1.59973815e-01f, -8.20338726e-02f, -8.42900202e-02f, 1.12546384e-01f,
  4.08780053e-02f, 1.07386276e-01f, -3.79407182e-02f, 1.54752567e-01f, -1.60841999e-04f, 4.12342660e-02f, 1.25560910e-01f, 1.00915497e-02f, -9.24992040e-02f, 8.69784430e-02f,
  -1.20278657e-03f, 1.98802538e-02f, 8.43594074e-02f, 2.66343597e-02f, 1.04318835e-01f, 1.13763781e-02f, 1.35391593e-01f, 1.64238382e-02f, 5.92093505e-02f, 1.93051957e-02f,
  3.41145359e-02f, -1.02289386e-01f, 7.53460526e-02f, -8.56060758e-02f, 6.48916140e-02f, 8.94180238e-02f, 6.18739389e-02f, -1.01072798e-02f, 2.97936350e-02f, 7.71433720e-03f,
  1.03578061e-01f, 5.44964299e-02f, -1.81233808e-02f, 7.50298351e-02f, 4.20343364e-03f, 5.86273782e-02f, 8.12695473e-02f, -2.19138544e-02f, 6.02290314e-03f, 1.55816555e-01f,
  5.61589599e-02f, -8.57718438e-02f, 2.77317632e-02f, -6.45869151e-02f, -6.64698929e-02f, 5.47415204e-02f, 5.94126880e-02f, 2.99440734e-02f, 6.41609877e-02f, 5.50247133e-02f,
  7.91830793e-02f, 8.72585624e-02f, -1.70030817e-02f, -5.60453944e-02f, -1.44579886e-02f, -6.13498390e-02f, 4.06440087e-02f, -6.53796047e-02f, -4.62387912e-02f, 8.94912854e-02f,
  -2.22546197e-02f, -1.49345296e-02f, -8.34476377e-05f, 4.03010622e-02f, 5.44163734e-02f, 1.43707078e-02f, -4.88725752e-02f, 3.82938087e-02f, -4.92173620e-02f, 1.61737967e-02f,
  7.45013654e-02f, 8.54480341e-02f, -1.03587285e-03f, -2.16116686e-03f, 1.45284832e-02f, -3.07587348e-02f, 2.95748077e-02f, 5.27879857e-02f, -6.54871836e-02f, -7.39103034e-02f,
  -5.69623373e-02f, -1.59920260e-01f, 1.32345501e-02f, 1.20812142e-02f, -8.49304944e-02f, 1.68432016e-02f, 1.64056793e-02f, -1.09490439e-01f, -9.51889381e-02f, -1.95415821e-02f,
  4.02319953e-02f, -6.79351538e-02f, 2.96836644e-02f, 2.02823114e-02f, 7.62305707e-02f, 1.11802109e-02f, 8.72057304e-02f, -9.81478840e-02f, -1.02459833e-01f, -3.46674882e-02f,
  -8.29100311e-02f, -1.17396958e-01f, -6.47811666e-02f, -1.17171146e-01f, 4.73279804e-02f, 7.50667155e-02f, 1.10213779e-01f, 1.92793980e-02f, 1.45484898e-02f, -1.71123743e-02f,
  6.29941106e-01f, -1.71360727e-02f, 1.78171277e-01f, 1.75508544e-01f, 1.94446854e-02f, -8.34961310e-02f, 1.44636706e-01f, -3.03562526e-02f, 2.55999953e-01f, -8.87042359e-02f,
  -7.17445016e-02f, 2.88950026e-01f, -1.48566246e-01f, -5.93965407e-03f, 1.89960375e-01f, -2.74160914e-02f, -2.05133501e-02f, 5.31435385e-03f, 5.03355823e-02f, -7.75955096e-02f,
  1.42008483e-01f, -1.40887767e-01f, -5.48712984e-02f, -2.46534377e-01f, 8.14820379e-02f, -3.85124236e-02f, -2.01207712e-01f, -6.57867566e-02f, -1.26632944e-01f, -1.62967313e-02f,
  9.64106172e-02f, 6.22136369e-02f, 1.90621782e-02f, 8.95187166e-03f, -7.52932057e-02f, -5.18005751e-02f, -4.74346289e-03f, -5.39195165e-02f, 3.04002669e-02f, 3.72780859e-02f,
  4.54470031e-02f, 7.52151608e-02f, -4.79682386e-02f, 3.50066721e-02f, 3.97998095e-02f, 1.12676144e-01f, -3.53769250e-02f, 8.00759299e-04f, 5.37331309e-03f, 1.78060401e-03f,
  2.53483802e-02f, -1.59989037e-02f, 4.85262573e-02f, 1.35325668e-02f, 6.67482913e-02f, 3.05617303e-02f, 3.67269702e-02f, 5.96091636e-02f, -6.91607594e-03f, 9.92743522e-02f,
  -5.30363247e-02f, 4.74736765e-02f, -8.27742368e-02f, 8.52006208e-03f, -3.24231014e-02f, -5.63233458e-02f, -2.69510206e-02f, -6.26423061e-02f, 8.61859322e-02f, 2.47286130e-02f,
  1.62663851e-02f, 2.59879995e-02f, 4.04977091e-02f, 1.62254889e-02f, 2.55177096e-02f, 4.84268181e-02f, 2.69217994e-02f, -3.91585492e-02f, 3.36275399e-02f, 4.57843170e-02f,
  2.60887202e-02f, -9.85949486e-03f, 9.44850594e-02f, -7.20662475e-02f, -1.43119916e-02f, 3.03482953e-02f, -2.05720942e-02f, 4.25555520e-02f, -5.36319837e-02f, -8.21122900e-02f,
  -1.48090273e-01f, -1.42264515e-01f, 3.51216160e-02f, 5.07633109e-03f, -7.88062736e-02f, -4.11566943e-02f, 2.03960780e-02f, 2.34109946e-02f, 1.17851561e-02f, -5.09806760e-02f,
  2.98969392e-02f, -3.16791944e-02f, -4.13889438e-02f, 2.52000764e-02f, 5.62549233e-02f, 1.79537963e-02f, -4.69977111e-02f, -9.04607587e-04f, -9.01627317e-02f, -2.70115528e-02f,
  -1.31439567e-02f, -3.83143127e-02f, 1.18282869e-01f, -3.45110297e-02f, -1.82978697e-02f, -1.19438116e-02f, -1.33828362e-02f, 8.02855790e-02f, -3.85701172e-02f, -4.28886712e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.02068254e-01f, 2.39924967e-01f, 2.92447120e-01f, -2.92682320e-01f, 1.73677206e-01f, 2.77644978e-03f, -3.07068974e-01f, 1.19111128e-01f, 2.71901619e-02f, -1.96589276e-01f,
  -1.97246626e-01f, 7.13264719e-02f, -2.41891276e-02f, -9.46645886e-02f, -3.19318734e-02f, 9.71382763e-03f, -2.02430725e-01f, -8.91871750e-02f, 2.29393452e-01f, -3.26224603e-02f,
  4.11269739e-02f, -2.53996611e-01f, 7.41859227e-02f, 1.45428345e-01f, 4.30575758e-02f, -4.96908613e-02f, -2.25466073e-01f, 1.26522928e-01f, -1.65529177e-02f, 9.62110832e-02f,
  5.55865206e-02f, -8.42898712e-02f, 8.62662792e-02f, 1.60225466e-01f, 6.60343003e-03f, -2.99953539e-02f, -8.12324882e-03f, 8.93524662e-02f, -1.04533292e-01f, -1.55234002e-02f,
  2.32663341e-02f, -2.57650409e-02f, -7.74652064e-02f, 7.80018494e-02f, -1.71401612e-02f, 9.02154446e-02f, 2.81190455e-01f, 1.33371189e-01f, 9.82875377e-02f, 1.56911746e-01f,
  1.83038563e-01f, 4.13404442e-02f, -1.80278402e-02f, -5.32894880e-02f, 1.43440291e-01f, 1.68139562e-02f, 1.70673002e-02f, -1.84031930e-02f, 4.18120101e-02f, -1.46571975e-02f,
  5.16723767e-02f, 8.01936910e-02f, -2.74098739e-02f, 1.60245672e-02f, 4.21951152e-02f, 1.45352595e-02f, 5.93201630e-02f, -6.87937364e-02f, -9.87391546e-03f, -1.46714017e-01f,
  -1.01218335e-01f, -5.17033823e-02f, 4.38938700e-02f, 4.22589481e-02f, -3.92722003e-02f, -2.38025617e-02f, -7.67073408e-02f, 7.61307627e-02f, -2.23733783e-02f, -3.02947368e-02f,
  -5.81998937e-02f, -4.73267473e-02f, 4.38547358e-02f, -6.08305000e-02f, -5.40002994e-02f, 5.01417518e-02f, -2.09447034e-02f, -3.87443416e-02f, -1.48849756e-01f, 6.27134442e-02f,
  -2.05109999e-01f, -3.14413220e-01f, -1.85984503e-02f, 6.73167184e-02f, -1.70357283e-02f, -1.78117808e-02f, 6.03090376e-02f, 6.36020526e-02f, -1.11334741e-01f, 1.61705408e-02f,
  4.73911949e-02f, -8.54226723e-02f, -6.18531071e-02f, 1.14531489e-02f, 4.20696549e-02f, -9.48465616e-02f, -2.14824349e-01f, -7.31737018e-02f, -1.48646072e-01f, 5.70468381e-02f,
  8.82767960e-02f, -4.95625660e-02f, -4.85821180e-02f, -1.10164039e-01f, -3.21128368e-02f, -7.65268505e-02f, 7.96036422e-02f, 4.52752002e-02f, -4.01739888e-02f, 1.70955993e-02f,
  1.00667827e-01f, -8.18111822e-02f, -2.09445387e-01f, -3.83080095e-02f, -5.13736457e-02f, -1.68600261e-01f, -2.57298023e-01f, -1.62019908e-01f, -8.62283483e-02f, -1.46397695e-01f,
  -5.28659374e-02f, -6.22266084e-02f, 2.66176730e-01f, -1.91530451e-01f, 1.66742578e-01f, 4.00725275e-01f, -8.72441754e-02f, -1.39519395e-02f, 1.55491799e-01f, 4.02201293e-03f,
  -1.04795776e-01f, -1.40379220e-01f, 2.20887095e-01f, 3.34799364e-02f, -1.71998277e-01f, -9.22071561e-02f, 3.50308605e-02f, -2.31522813e-01f, -3.07138234e-01f, -9.55520123e-02f,
  1.13181971e-01f, 9.49941669e-03f, 5.61958812e-02f, 6.15367480e-02f, -3.61151714e-03f, -4.96354587e-02f, -5.13473116e-02f, -5.88611364e-02f, -1.17520750e-01f, -1.32622046e-03f,
  6.43528774e-02f, 8.65937676e-03f, -9.85802412e-02f, 7.25798681e-02f, -4.19200696e-02f, -1.11013994e-01f, -3.55268754e-02f, 7.65508041e-02f, 1.31028503e-01f, -6.81754015e-03f,
  -1.13849983e-01f, 3.54195796e-02f, -9.52172801e-02f, 1.02218620e-01f, 2.13356689e-02f, 2.09335107e-02f, 7.25041032e-02f, 2.06341576e-02f, 1.86447818e-02f, -9.97917578e-02f,
  6.80669993e-02f, -1.65874317e-01f, 1.22249378e-02f, -1.12463035e-01f, -7.79459476e-02f, 4.48689051e-02f, 3.96766104e-02f, 5.50762797e-03f, 6.07554130e-02f, -3.70148532e-02f,
  1.06789470e-01f, -1.32882865e-02f, -5.63336760e-02f, 3.55867334e-02f, 2.43069828e-02f, 4.98617925e-02f, 2.43193600e-02f, -7.59535581e-02f, -1.75830517e-02f, -1.47909150e-02f,
  -2.12010518e-02f, -6.54339567e-02f, -5.35289720e-02f, 7.35011175e-02f, -8.35882593e-03f, -2.20397245e-02f, -1.85433730e-01f, 5.78043945e-02f, -4.54838946e-02f, -1.05847269e-02f,
  1.73111349e-01f, 4.38906662e-02f, 9.89073366e-02f, 6.30983412e-02f, 1.83411539e-01f, -8.10303017e-02f, -2.26253811e-02f, -6.37329966e-02f, -5.15222922e-03f, 7.62399733e-02f,
  -1.15444854e-01f, 5.02145551e-02f, -1.38356581e-01f, 7.17701092e-02f, -6.34946069e-03f, -7.37643540e-02f, -7.49136209e-02f, 5.68559803e-02f, 4.30596098e-02f, -7.66259618e-04f,
  2.77985409e-02f, 5.99814057e-02f, 5.84819280e-02f, 9.82005149e-02f, -7.11717755e-02f, -6.40236028e-03f, -8.91104434e-03f, 3.91178392e-02f, 5.18554673e-02f, 4.97242017e-03f,
  3.64672840e-01f, -4.30184066e-01f, -1.19883917e-01f, 3.80468994e-01f, 2.21465275e-01f, -7.67860115e-02f, -3.84186842e-02f, 1.90422341e-01f, 2.57054031e-01f, -2.68664539e-01f,
  1.45621315e-01f, -2.05235690e-01f, -3.57306987e-01f, 1.08856276e-01f, 8.60196874e-02f, -1.94590554e-01f, 3.84188220e-02f, -1.92712341e-02f, 1.20426388e-03f, 4.61861268e-02f,
  1.37446761e-01f, 5.88611811e-02f, -4.50967392e-03f, 5.69712510e-03f, 2.72310264e-02f, 5.66680022e-02f, 4.19052094e-02f, -1.07949622e-01f, -3.80605534e-02f, -5.22783771e-03f,
  1.61305144e-01f, -4.25560661e-02f, -5.92623577e-02f, -9.05239768e-03f, 8.53178799e-02f, -9.90850758e-03f, -1.16510667e-01f, -1.09107345e-01f, 1.89876437e-01f, 7.89880678e-02f,
  -1.21622078e-01f, -3.50682586e-02f, 2.73324940e-02f, -4.23338823e-03f, 1.34698033e-01f, 8.69826227e-02f, 1.15476856e-02f, -3.52120027e-02f, 2.13813577e-02f, -5.45299836e-02f,
  -4.75754812e-02f, -3.73954140e-02f, 7.67166018e-02f, -2.36873627e-02f, -8.69199112e-02f, 1.03466831e-01f, -4.27049883e-02f, -2.63699871e-02f, 9.04773921e-03f, 1.50470585e-01f,
  8.43765438e-02f, -8.44281241e-02f, -2.57696100e-02f, 7.25347698e-02f, 5.75569496e-02f, 9.23755392e-02f, -5.20210899e-03f, -7.42709190e-02f, 2.55079661e-02f, 2.58169752e-02f,
  -7.11934129e-03f, -5.24753183e-02f, 2.40679625e-02f, -5.29125147e-02f, -1.92684773e-02f, -5.08507416e-02f, -3.57347517e-03f, -4.74160127e-02f, 9.59876552e-03f, 6.68763742e-02f,
  -3.78275737e-02f, 2.73280926e-02f, -8.55896715e-03f, -2.15170998e-02f, 5.25278151e-02f, -9.19164997e-03f, 2.34862827e-02f, -2.10296027e-02f, 1.25510484e-01f, -8.11121911e-02f,
  -2.02005073e-01f, -3.21558356e-01f, -4.40015132e-03f, -2.79678106e-02f, -8.82276334e-03f, -5.79923913e-02f, -1.01552337e-01f, 3.03492397e-02f, 3.43446583e-02f, 3.89298727e-03f,
  -3.08210328e-02f, 8.29391256e-02f, 2.13827025e-02f, -2.34848075e-02f, -6.98446557e-02f, 1.62979390e-03f, 3.43682654e-02f, 8.44930485e-02f, -1.85689870e-02f, 1.07667511e-02f,
  -2.80285943e-02f, -1.02633901e-01f, -2.36279014e-02f, -4.17839065e-02f, 1.83696225e-02f, -9.74650830e-02f, -1.22189624e-02f, -1.75399221e-02f, -1.38949335e-01f, -2.27436777e-02f,
  -7.01854080e-02f, -2.84011304e-01f, -3.06453049e-01f, -2.71252453e-01f, -5.07250763e-02f, -3.80507797e-01f, -3.58653516e-01f, -2.82294042e-02f, 1.60330996e-01f, 1.12713482e-02f,
  -6.94434866e-02f, 6.55698180e-02f, 1.52199596e-01f, -1.34882659e-01f, -3.82275172e-02f, 1.24604478e-01f, -3.88762236e-01f, -1.02320157e-01f, 6.27812222e-02f, -1.25791609e-01f,
  -1.66159764e-01f, -4.36753184e-02f, -9.70633477e-02f, 2.17186511e-02f, -1.01282358e-01f, 3.84595655e-02f, 2.16244265e-01f, 1.68548413e-02f, -2.31993392e-01f, 1.22804105e-01f,
  -1.18591692e-02f, 1.53397650e-01f, 1.20678786e-02f, 1.13454670e-01f, -1.81355000e-01f, -1.88208930e-02f, -1.15445018e-01f, 3.10719647e-02f, -8.40080604e-02f, 9.57669616e-02f,
  -1.48838265e-02f, -9.45871114e-04f, 5.99638894e-02f, 1.01500889e-02f, -5.42959087e-02f, 8.21769610e-03f, 3.40283327e-02f, -1.12516724e-01f, -6.23311177e-02f, -6.57777190e-02f,
  -3.18080187e-02f, -5.48058301e-02f, -9.21029970e-02f, -2.15964410e-02f, -5.67555726e-02f, -3.73980701e-02f, -1.11849517e-01f, 7.33237490e-02f, -1.04383104e-01f, -6.42319247e-02f,
  -2.87600029e-02f, -1.72182601e-02f, -6.99263290e-02f, 2.04016119e-02f, 2.77604032e-02f, -3.75256352e-02f, -1.01617806e-01f, 8.71101096e-02f, 6.73575327e-02f, 6.10480495e-02f,
  -1.01717897e-01f, 6.61670491e-02f, 1.66351218e-02f, 2.38943864e-02f, -9.47948992e-02f, -5.77739812e-02f, -5.05830459e-02f, -2.53771674e-02f, -1.86972454e-01f, -1.69790536e-02f,
  8.25391412e-02f, 3.71166058e-02f, 3.87421548e-02f, -3.33402678e-02f, -2.33149100e-02f, 4.97635193e-02f, -1.22643029e-02f, -6.90622197e-04f, 6.80586845e-02f, -9.99406129e-02f,
  -1.10826015e-01f, -1.14745758e-01f, 3.50221321e-02f, -8.14080387e-02f, 3.46596017e-02f, -4.24385034e-02f, -3.91148962e-02f, -4.37756591e-02f, -1.10529162e-01f, -1.78396571e-02f,
  -1.77944690e-01f, 4.33791569e-03f, -6.45527244e-02f, -2.73716077e-02f, -2.37870980e-02f, -3.40200327e-02f, -3.74166630e-02f, -7.57199898e-02f, -2.89133005e-02f, 5.86287677e-03f,
  -1.08233415e-01f, -2.34118737e-02f, 7.13521838e-02f, -6.83574006e-02f, -9.28021595e-02f, 2.78745387e-02f, 4.31958325e-02f, 2.10672319e-02f, -1.93064325e-02f, -7.56295174e-02f,
  3.15648496e-01f, -3.08365703e-01f, 2.42720038e-01f, 2.20936745e-01f, 2.68763565e-02f, -2.27393359e-01f, 1.27707630e-01f, -1.72886595e-01f, -3.46267730e-01f, -3.41180861e-01f,
  3.90204303e-02f, -4.56302278e-02f, 1.88298047e-01f, -1.09069146e-01f, 5.13396323e-01f, -9.42879990e-02f, 1.01858703e-02f, -7.20605850e-02f, -5.10027707e-02f, -7.02447146e-02f,
  2.14260846e-01f, 1.78448334e-01f, 3.08885992e-01f, 1.05558157e-01f, 2.69182175e-01f, 1.01244859e-01f, 2.80800194e-01f, 3.65898788e-01f, 1.60431862e-03f, 1.80392191e-01f,
  -1.33506075e-01f, -4.31328453e-02f, 2.83128861e-02f, -1.89348944e-02f, 1.74587984e-02f, -1.51589522e-02f, -2.51640119e-02f, 1.74764991e-01f, -5.99520244e-02f, 2.19241753e-02f,
  -2.88202502e-02f, -2.20185257e-02f, -1.28519759e-01f, -3.89242847e-03f, -8.93804058e-02f, 3.11335046e-02f, -5.81240654e-02f, -1.25759095e-01f, -8.30911696e-02f, 4.84475754e-02f,
  -2.87666917e-03f, -3.49669568e-02f, 1.62160043e-02f, 2.52544098e-02f, 7.95487016e-02f, -3.50731537e-02f, -1.37581024e-03f, 1.29435673e-01f, -4.28886190e-02f, -1.85229108e-02f,
  2.41136681e-02f, -3.76383811e-02f, -1.84733532e-02f, 6.08732700e-02f, -5.30517735e-02f, -2.30755210e-02f, -4.12303656e-02f, -3.71151380e-02f, -2.08686497e-02f, -7.28034452e-02f,
  -2.34013535e-02f, 6.05644621e-02f, -6.78315237e-02f, -1.03768021e-01f, -6.20706119e-02f, -8.40265378e-02f, 1.69986069e-01f, 1.15914293e-01f, 5.82332648e-02f, -9.86075699e-02f,
  3.83398421e-02f, 2.83707995e-02f, 1.01247624e-01f, 8.14452469e-02f, 1.79952197e-02f, -7.96937197e-03f, -7.64868259e-02f, 5.44605888e-02f, -7.58834928e-02f, 6.58995062e-02f,
  -5.08771837e-02f, -6.12453856e-02f, -3.14196851e-03f, -3.47505100e-02f, 7.81912170e-03f, -6.28543571e-02f, -2.16580648e-02f, -9.61646363e-02f, 2.76753269e-02f, 3.40951467e-03f,
  -5.80229089e-02f, -3.73358205e-02f, 5.29774912e-02f, 2.08542515e-02f, 5.23648448e-02f, -1.22572288e-01f, 3.32161114e-02f, -7.06237704e-02f, 6.03589788e-02f, 1.85740832e-02f,
  8.01749825e-02f, -3.68078426e-02f, 1.06157400e-01f, 2.84978431e-02f, 1.85475945e-02f, 2.64816359e-02f, -1.75020639e-02f, -2.59762537e-02f, 1.03403792e-01f, -1.52615858e-02f,
  2.40975723e-01f, -5.28704047e-01f, -2.77596898e-02f, 1.29191160e-01f, 3.51982147e-01f, 1.09656066e-01f, 2.35185266e-01f, -1.76837444e-02f, -3.62325758e-02f, -2.78556943e-01f,
  1.11310422e-01f, -6.22774623e-02f, -1.61161542e-01f, -1.42394295e-02f, 3.92367482e-01f, -9.50692073e-02f, 2.32797135e-02f, -1.33717963e-02f, -6.45819455e-02f, -1.23764873e-02f,
  3.21199708e-02f, 1.11344904e-01f, 1.06163412e-01f, -8.25705454e-02f, 9.69488844e-02f, -1.35650977e-01f, 6.56246692e-02f, 1.22042140e-02f, 1.17271906e-02f, 2.59965479e-01f,
  -1.31788835e-01f, -6.20291829e-02f, -2.39135306e-02f, -3.05978488e-02f, -1.03545360e-01f, -2.25638859e-02f, -3.13848234e-03f, 1.14028402e-01f, 1.11429309e-02f, -1.30927311e-02f,
  2.63488144e-02f, 6.66802051e-03f, 2.07708552e-02f, 1.03179678e-01f, -8.36153403e-02f, -6.17090054e-02f, -6.02299068e-03f, 3.82700004e-02f, 1.75985470e-02f, -2.62759849e-02f,
  6.26143580e-03f, -6.96143061e-02f, -1.29781906e-02f, -4.01861779e-02f, 1.75011740e-03f, 7.66694546e-02f, 1.42582372e-01f, 1.01253323e-01f, -3.80701460e-02f, -5.74897788e-02f,
  4.54159118e-02f, 3.55015113e-03f, 1.49934050e-02f, -4.41081673e-02f, 5.41307554e-02f, 1.00114837e-01f, -4.52052578e-02f, 8.36322233e-02f, 2.89311521e-02f, -8.75560641e-02f,
  -3.35836038e-02f, -1.25584137e-02f, 5.14763640e-03f, -1.82137582e-02f, -1.09285358e-02f, -5.12652062e-02f, 7.76720699e-03f, -1.73053667e-02f, -1.26798838e-01f, -7.52209360e-03f,
  3.02164052e-02f, -2.96710748e-02f, 3.61068803e-03f, -2.52892133e-02f, -6.10401062e-03f, 9.83866081e-02f, -3.86864133e-02f, -7.25330785e-02f, 9.05743763e-02f, 5.18212952e-02f,
  -3.50919724e-01f, -3.74448687e-01f, -4.08710307e-03f, -2.19730590e-03f, -2.84123775e-02f, -2.83177253e-02f, 1.10721691e-02f, -6.90379515e-02f, -3.78379375e-02f, -4.53438275e-02f,
  -9.12321284e-02f, 4.23656851e-02f, -9.00668427e-02f, -1.84206162e-02f, -1.34085882e-02f, 1.31839700e-02f, 2.10831966e-02f, -9.19253901e-02f, 6.47713616e-02f, -1.16045706e-01f,
  -7.07907155e-02f, 9.43477172e-03f, -4.06602770e-03f, 5.54622225e-02f, -6.39835075e-02f, 9.62988287e-02f, -3.84164887e-04f, 6.72054216e-02f, 2.59165298e-02f, -2.10156888e-02f,
  -1.10735074e-01f, -7.90641010e-02f, -3.15761149e-01f, -1.66220754e-01f, -1.55878216e-01f, -3.41654956e-01f, -2.17837915e-01f, -5.35850003e-02f, 1.38101414e-01f, -7.32080787e-02f,
  -7.30238557e-02f, 1.98070869e-01f, 1.17475323e-01f, -2.01815248e-01f, 5.25266901e-02f, -8.53226427e-03f, -4.18949813e-01f, -2.60195553e-01f, 5.26670367e-02f, -1.98822349e-01f,
  -1.74322486e-01f, -1.29410505e-01f, -2.28823841e-01f, -2.33818553e-02f, -2.22415060e-01f, -8.98437761e-03f, 1.44073591e-01f, -1.57512650e-02f, -2.23869368e-01f, 1.35041669e-01f,
  -3.57581675e-02f, 9.59585011e-02f, -2.50652730e-02f, -6.66636676e-02f, -1.85033351e-01f, -1.47872642e-01f, -1.51416942e-01f, -4.10023816e-02f, -2.50437669e-02f, -4.85247485e-02f,
  -6.62066936e-02f, 1.14315197e-01f, -1.17501412e-02f, 1.90204874e-01f, -7.07257837e-02f, 5.91490008e-02f, -1.81369949e-02f, -9.12467837e-02f, -5.39110973e-02f, -1.50774136e-01f,
  -1.31187767e-01f, 5.17649204e-02f, -1.21363737e-01f, 5.65020703e-02f, 4.74011563e-02f, 2.33670254e-03f, -1.43025899e-02f, 2.64857449e-02f, -3.66774388e-02f, 6.30220547e-02f,
  -8.93073305e-02f, -2.09478159e-02f, 1.61314923e-02f, -4.31273840e-02f, 2.47181337e-02f, 8.49898607e-02f, -3.37103121e-02f, 9.01218969e-03f, 4.60512787e-02f, -9.07479227e-02f,
  1.13473438e-01f, 3.24537233e-02f, -4.12519043e-03f, -5.10208197e-02f, -6.15079254e-02f, 1.67151570e-01f, -1.79262888e-02f, 2.17934139e-02f, -1.11291967e-02f, -3.32467593e-02f,
  4.39720973e-02f, -6.53348491e-02f, -6.98736459e-02f, -2.29821261e-02f, -3.65110114e-02f, 4.85672653e-02f, -5.02986088e-03f, -7.32510351e-03f, -1.28975511e-02f, -1.35184035e-01f,
  -7.07893521e-02f, -7.23848194e-02f, 1.91855244e-02f, 2.33886857e-02f, -4.05314676e-02f, -7.81447627e-03f, -1.92792773e-01f, -3.02063134e-02f, -8.98082405e-02f, -2.51011029e-02f,
  -1.09757327e-01f, 5.26189879e-02f, -3.27489562e-02f, -3.47799510e-02f, 6.01606295e-02f, -7.81917199e-03f, -9.30680484e-02f, -2.92161084e-03f, 2.78978497e-02f, -6.24216394e-03f,
  -1.42707881e-02f, 7.66878203e-02f, 3.04673631e-02f, 3.90798822e-02f, -1.12486981e-01f, -1.25284456e-02f, 1.15136638e-01f, -3.44387814e-02f, -2.29067020e-02f, 2.56847106e-02f,
  2.74936795e-01f, -2.17211142e-01f, -3.41090351e-01f, -1.05132937e-01f, 2.64044583e-01f, 1.87516376e-01f, -1.13479979e-01f, 2.96347663e-02f, -3.04136962e-01f, 1.03706129e-01f,
  2.13835105e-01f, -6.47833869e-02f, -3.35977584e-01f, 7.84372836e-02f, 1.27189547e-01f, -3.65348697e-01f, 2.31256917e-01f, 5.49754798e-02f, -2.41670519e-01f, 2.32489910e-02f,
  -1.54518664e-01f, 3.43579382e-01f, -1.42293409e-01f, 2.47049704e-01f, 1.82355106e-01f, -8.44129473e-02f, 2.56449580e-01f, -1.55072272e-01f, 2.01268449e-01f, 2.51670122e-01f,
  -2.21975823e-03f, -1.42368615e-01f, -1.83915123e-02f, -2.67395731e-02f, 5.20545207e-02f, 1.76094264e-01f, 5.83818294e-02f, -1.17373858e-02f, -1.39986068e-01f, -8.87131169e-02f,
  -7.54221454e-02f, -4.26959470e-02f, -3.69841382e-02f, 1.25466501e-02f, 6.73157945e-02f, -2.30005886e-02f, -1.37646034e-01f, -2.59677246e-02f, -1.10615604e-01f, -1.52609631e-01f,
  -2.20982224e-01f, -8.15927312e-02f, -2.44472306e-02f, -5.46987467e-02f, -4.16296832e-02f, -3.01912054e-02f, 2.72350684e-02f, -4.26907204e-02f, 4.36015939e-03f, -1.41260994e-03f,
  1.04112120e-03f, -8.17368645e-03f, -1.96704715e-02f, 6.13369830e-02f, -2.14294661e-02f, -1.41247502e-02f, -6.90783095e-03f, 3.58875003e-03f, 6.10038973e-02f, 6.10514777e-03f,
  2.16862578e-02f, 1.11785814e-01f, 8.43421295e-02f, 1.77774823e-03f, 8.57243463e-02f, -8.27431753e-02f, -3.68852317e-02f, 2.05499735e-02f, -4.98351455e-02f, -1.92455426e-02f,
  5.63247036e-03f, -2.18672189e-03f, 7.36949742e-02f, -9.23067927e-02f, -5.91852926e-02f, 1.26390979e-01f, 2.39150114e-02f, 8.07369780e-03f, -8.47645104e-03f, 8.56907070e-02f,
  1.80948228e-01f, -2.89058574e-02f, 2.78179869e-02f, 4.61932644e-02f, -3.19825672e-02f, 1.23140000e-01f, -5.62429838e-02f, -4.05127257e-02f, 8.57480243e-02f, 6.24344200e-02f,
  4.27515991e-02f, 5.12150750e-02f, 2.80581554e-03f, 1.07127592e-01f, 3.04965880e-02f, 7.01912716e-02f, -5.41101247e-02f, 3.55103686e-02f, 1.12304389e-01f, 1.36107979e-02f,
  3.82289067e-02f, -6.55952692e-02f, 4.41799685e-02f, 2.19115578e-02f, 4.65197191e-02f, -3.43063846e-02f, 1.16691301e-02f, 1.59734208e-02f, 3.04809529e-02f, -1.49984539e-01f,
  2.53885865e-01f, -3.08755040e-01f, 4.48330306e-02f, 2.18228891e-01f, 2.72874713e-01f, -1.11064397e-01f, -1.18412718e-01f, 1.91657558e-01f, 3.17994684e-01f, -2.80398428e-02f,
  2.69706338e-03f, -1.55760005e-01f, -1.49860144e-01f, 1.06664307e-01f, 1.47530064e-01f, -1.81361195e-02f, 1.57289833e-01f, 7.24930540e-02f, 5.18725673e-03f, -5.60224317e-02f,
  5.77735901e-02f, 9.24831033e-02f, -1.14672460e-01f, -5.55185974e-02f, -8.69095996e-02f, -2.64412444e-02f, -3.69859152e-02f, -1.45053670e-01f, 3.91825894e-03f, -5.92588373e-02f,
  7.08754361e-02f, -1.35293975e-01f, -3.60236280e-02f, -8.20927694e-02f, -1.32074535e-01f, -1.22645892e-01f, -5.76294884e-02f, -6.74007833e-02f, -2.20742486e-02f, -2.17287876e-02f,
  -1.66325927e-01f, -1.10870190e-02f, 5.87013289e-02f, 1.51779562e-01f, 3.27953361e-02f, 7.39334300e-02f, 8.57054144e-02f, 6.19321465e-02f, -3.23694386e-02f, -3.51935737e-02f,
  2.59900112e-02f, -2.10400522e-02f, 9.27491039e-02f, -1.18594706e-01f, 1.45103350e-01f, -6.19968697e-02f, -1.13404475e-01f, -1.85228616e-01f, -5.61344204e-03f, -1.15488485e-01f,
  6.92093931e-03f, -3.35207395e-02f, -4.93405052e-02f, 3.06520276e-02f, 8.56873542e-02f, -3.15334648e-02f, 7.54522756e-02f, 5.59970625e-02f, 9.02677402e-02f, 1.14169838e-02f,
  -5.39623871e-02f, 6.92990720e-02f, 1.65933996e-01f, 1.26568275e-02f, 1.24322122e-03f, -9.59213153e-02f, -4.78007272e-02f, 1.49121769e-02f, 2.49934364e-02f, 1.16266189e-02f,
  6.79448247e-02f, 3.89921516e-02f, -7.42951632e-02f, 1.96284079e-03f, 4.85151671e-02f, 2.87092794e-02f, 6.89808503e-02f, 6.41367063e-02f, 7.32503906e-02f, -7.23112449e-02f,
  2.28578951e-02f, -7.81645775e-02f, -6.41774610e-02f, 1.34573169e-02f, -7.80335441e-03f, 5.59587851e-02f, -2.91796238e-03f, -1.02722563e-03f, -3.51351406e-03f, -4.98828292e-02f,
  -7.83327967e-02f, -4.23321389e-02f, -2.68632062e-02f, 7.72081614e-02f, 3.70460339e-02f, -1.09063834e-01f, -2.57045850e-02f, -7.08812922e-02f, 1.11831436e-02f, 9.93765146e-03f,
  -3.60000357e-02f, -8.45789835e-02f, -1.42389700e-01f, -5.26842140e-02f, 1.66003685e-03f, -2.46231891e-02f, 1.93698965e-02f, -1.21880867e-01f, 4.95656990e-02f, 4.35227826e-02f,
  -5.31938553e-01f, -5.11201471e-03f, 1.59373730e-01f, 3.68262857e-01f, -1.27124444e-01f, -1.56114429e-01f, -1.75743252e-01f, 2.30795264e-01f, -1.24189384e-01f, -5.55766635e-02f,
  9.73995253e-02f, -1.39783993e-01f, 1.06226914e-01f, 2.17923865e-01f, 2.59751618e-01f, 4.70485538e-02f, 1.55495718e-01f, -3.83446477e-02f, 5.05204238e-02f, 1.09539479e-01f,
  9.80118662e-02f, 1.54512644e-01f, 3.10636461e-01f, 9.54164267e-02f, 1.06985077e-01f, 1.91481099e-01f, 2.27320388e-01f, 5.83749264e-02f, 2.98133016e-01f, -2.92895194e-02f,
  -4.92894724e-02f, 1.11037426e-01f, 6.10124040e-03f, 2.90780589e-02f, 5.87028116e-02f, -1.40733179e-02f, 1.33887380e-02f, 9.18194931e-03f, 6.44785315e-02f, 6.12558378e-03f,
  -6.47313520e-02f, -6.94165453e-02f, 1.24179751e-01f, -9.48324800e-02f, -1.22832887e-01f, 4.36050724e-03f, -6.62820116e-02f, -4.36704904e-02f, 2.47135740e-02f, 1.06864423e-01f,
  1.89333968e-02f, 4.59368899e-02f, 6.79891650e-03f, 2.31544003e-02f, 5.29326685e-02f, -7.65756965e-02f, -8.60871524e-02f, 1.11996885e-02f, 2.35327482e-02f, -4.31314334e-02f,
  -3.88688743e-02f, -5.49475700e-02f, 3.51660624e-02f, -2.82166768e-02f, 5.50346188e-02f, 1.61617890e-01f, 1.43722715e-02f, 1.28125376e-03f, -8.53829831e-02f, 5.52351847e-02f,
  5.44827320e-02f, 6.33843690e-02f, 9.87533666e-03f, 2.85786707e-02f, 9.09917504e-02f, -1.53817015e-03f, 1.98937170e-02f, -4.22580764e-02f, 8.21771398e-02f, 4.41940799e-02f,
  2.27471925e-02f, 8.08987580e-03f, -2.61499640e-02f, -7.45661138e-03f, 3.04415450e-02f, 1.88310386e-03f, 3.47973555e-02f, -2.33064257e-02f, 1.51163951e-01f, 2.18345840e-02f,
  1.52776077e-01f, 3.73153597e-01f, 8.19010474e-03f, -9.79734510e-02f, 1.18597806e-01f, 3.24956141e-02f, 4.61507253e-02f, -3.36213037e-02f, 1.44926250e-01f, 6.59584114e-03f,
  -4.77780662e-02f, -6.08124770e-02f, 1.39036372e-01f, -1.97363719e-02f, 5.79615124e-03f, 8.74599963e-02f, 1.45715877e-01f, -7.01484270e-03f, 8.33459049e-02f, 1.69435784e-01f,
  1.20832557e-02f, -4.39168215e-02f, 1.22282263e-02f, -6.78855628e-02f, -1.08477734e-01f, -4.25027363e-04f, -4.83898073e-02f, 5.62081672e-02f, 9.17666126e-03f, -6.75624833e-02f,
  1.15250088e-01f, -1.64347053e-01f, -2.48332471e-01f, 1.77863851e-01f, 5.12644760e-02f, -2.63749510e-01f, -3.90089482e-01f, 8.94258381e-04f, -2.38986224e-01f, -1.57720476e-01f,
  2.15736795e-02f, -5.66277951e-02f, -3.18576507e-02f, 3.52268368e-01f, 2.36201853e-01f, -7.82159492e-02f, 1.08541436e-01f, -1.35624141e-01f, -1.40220359e-01f, 1.08126730e-01f,
  6.44079968e-02f, 4.38287437e-01f, 1.04240708e-01f, 2.38146707e-01f, 7.15907887e-02f, 1.71125785e-01f, 2.83667624e-01f, -1.07697673e-01f, 2.46955708e-01f, 8.29315111e-02f,
  -9.67688784e-02f, 8.68146494e-02f, -8.62253457e-02f, -2.61149872e-02f, 3.53694931e-02f, -4.61646989e-02f, -4.30439115e-02f, 4.04356122e-02f, -1.64948683e-02f, -8.78327265e-02f,
  -1.76013801e-02f, 8.61691684e-02f, -4.76914607e-02f, 8.54346156e-02f, 2.71351468e-02f, 5.47702387e-02f, -1.54614784e-02f, -1.00618832e-01f, -1.18357083e-02f, 1.92279760e-02f,
  -1.34403631e-01f, 5.73665537e-02f, -4.68159392e-02f, -5.72134368e-02f, -9.70698148e-02f, -7.65244365e-02f, -1.66195519e-02f, 2.11471617e-02f, -3.98975760e-02f, 7.73569643e-02f,
  3.17948312e-02f, 6.29906505e-02f, -5.58786467e-02f, -1.28136873e-02f, -5.57828471e-02f, -2.84890346e-02f, 4.14500535e-02f, 3.00428141e-02f, -3.41281667e-02f, 7.35126212e-02f,
  -7.17903078e-02f, -2.75322087e-02f, 5.14442585e-02f, -1.98377371e-02f, 2.45984714e-03f, -2.05839742e-02f, 9.69770551e-02f, 6.36009127e-02f, -1.53991148e-01f, -8.61030072e-02f,
  1.21426433e-02f, 7.74113089e-02f, -1.92776695e-01f, 2.98116170e-02f, 8.88803527e-02f, -3.17023806e-02f, 3.18110287e-02f, -7.69127440e-03f, -8.32335725e-02f, -1.33525804e-01f,
  8.88968706e-02f, 2.10228503e-01f, -9.06639248e-02f, 3.43538029e-03f, -6.50783107e-02f, -3.84050570e-02f, -4.70856726e-02f, 3.19224782e-02f, 3.43780667e-02f, -1.10296436e-01f,
  4.20984104e-02f, 1.14137875e-02f, -2.58487109e-02f, -2.46241558e-02f, 6.99142367e-02f, -8.46322551e-02f, 6.74381331e-02f, 1.24901921e-01f, -2.96767801e-02f, 6.36448711e-02f,
  1.04293905e-01f, 7.76018798e-02f, -1.15806283e-02f, -1.06540367e-01f, -1.05047850e-02f, -3.69416401e-02f, -7.08122104e-02f, -7.11076409e-02f, 1.16342328e-01f, 1.99812334e-02f,
  -5.45738041e-01f, 2.45308891e-01f, -2.15746596e-01f, 3.87403928e-02f, -4.76173067e-04f, 3.28396559e-01f, 2.86461532e-01f, 1.65269792e-01f, 1.53523102e-01f, 3.67924601e-01f,
  1.62965626e-01f, -2.96139680e-02f, 3.89177874e-02f, 2.96245396e-01f, -1.10416576e-01f, 9.53832120e-02f, 1.84017360e-01f, 1.69050500e-01f, 1.45062208e-02f, -1.25451148e-01f,
  -8.37616026e-02f, 3.57474014e-02f, -1.01571254e-01f, -9.08235461e-02f, -1.15550198e-01f, -1.57466665e-01f, -1.36481300e-01f, -6.90933615e-02f, -3.27667147e-02f, 2.31558383e-02f,
  -9.99278799e-02f, -1.23363398e-01f, 2.37961002e-02f, -1.40883550e-01f, -7.63493478e-02f, -9.34172571e-02f, -7.34118074e-02f, 3.72540485e-03f, -9.40757245e-02f, 7.66352639e-02f,
  -7.99146891e-02f, 3.31282169e-02f, 4.22084481e-02f, -4.13801009e-03f, -1.71881523e-02f, -8.23900942e-03f, 1.16933629e-01f, 1.24396406e-01f, 8.73726383e-02f, -4.52979840e-02f,
  4.50324342e-02f, 4.22733910e-02f, -7.33570079e-04f, 4.12817784e-02f, -9.47163478e-02f, 2.21710689e-02f, 4.20314670e-02f, -3.11443824e-02f, 4.65586595e-02f, 1.64114572e-02f,
  -8.16606581e-02f, 3.39235999e-02f, -5.61796315e-02f, 3.69282812e-02f, 1.46398265e-02f, -3.01251654e-02f, 4.62530479e-02f, -2.12980192e-02f, -6.77798390e-02f, -1.25712473e-02f,
  -2.53021587e-02f, 3.94821279e-02f, -9.45725515e-02f, 9.46636647e-02f, 1.55680571e-02f, 3.87567431e-02f, -9.06031281e-02f, -3.65934260e-02f, 2.51471400e-02f, -1.08375642e-02f,
  7.95882493e-02f, -2.96092257e-02f, -2.26790621e-03f, -1.81985497e-02f, -5.51376417e-02f, 8.72334186e-03f, -3.61179709e-02f, -5.15259511e-04f, -6.92324936e-02f, -5.73280826e-02f,
  1.41826361e-01f, -5.72781265e-02f, 7.72492811e-02f, -4.93561998e-02f, -6.00626543e-02f, 1.32919336e-02f, -5.98443560e-02f, 5.96412346e-02f, -1.28700644e-01f, -8.11840892e-02f,
  -9.99089926e-02f, -1.74728930e-02f, -1.25893638e-01f, 9.69478115e-03f, 4.57534529e-02f, 1.85167138e-02f, -5.18585369e-02f, -7.88505301e-02f, 3.86448689e-02f, -4.23153527e-02f,
  -7.07414374e-02f, 1.18696596e-02f, 2.00720858e-02f, -1.77451987e-02f, -4.80025262e-02f, 4.97162044e-02f, 1.76373944e-02f, -2.77886931e-02f, -8.74130055e-02f, 8.44405517e-02f,
  1.77841410e-01f, 1.17194772e-01f, -2.83577353e-01f, 6.71794191e-02f, -6.10055812e-02f, 2.12080777e-01f, 1.59460917e-01f, 5.68916909e-02f, -1.62876472e-01f, 2.07609326e-01f,
  1.10923134e-01f, -1.31999940e-01f, 8.28921124e-02f, 2.34861255e-01f, 1.57999963e-01f, 1.39661014e-01f, 1.29953146e-01f, 1.55868679e-01f, -3.20368595e-02f, 9.76339504e-02f,
  6.01187274e-02f, 3.23858589e-01f, -2.73253722e-03f, 1.11734182e-01f, 9.23049599e-02f, -5.19588105e-02f, 1.41074313e-02f, -1.97599113e-01f, 2.11695343e-01f, 9.68212336e-02f,
  7.64894411e-02f, -1.25313727e-02f, -4.80119549e-02f, -1.12254936e-02f, 9.60674733e-02f, 1.96085721e-02f, -2.29099113e-02f, -5.27728535e-02f, -9.64542553e-02f, -1.76978540e-02f,
  4.20400649e-02f, -5.33077866e-03f, 2.44223513e-02f, -2.29418222e-02f, -5.36528714e-02f, 3.70803699e-02f, 2.48868130e-02f, -9.94737968e-02f, -8.61558616e-02f, 1.10099185e-02f,
  -6.20186441e-02f, -6.83034062e-02f, -1.00547075e-01f, 4.12222818e-02f, -2.16357987e-02f, -3.16597372e-02f, -3.59846838e-02f, -4.49647903e-02f, -4.51755859e-02f, 1.83892045e-02f,
  6.45633191e-02f, -5.91461100e-02f, 8.63599181e-02f, 6.25629202e-02f, 3.08908746e-02f, 1.34336634e-03f, 9.53935739e-03f, 4.57326472e-02f, -5.93938828e-02f, 5.68550639e-03f,
  5.23316264e-02f, 3.17073576e-02f, -1.25143388e-02f, -5.81859350e-02f, 8.06079581e-02f, 2.40120795e-02f, 6.17494956e-02f, -5.19268513e-02f, -7.36773685e-02f, 3.42013799e-02f,
  -5.48702478e-02f, -3.71578112e-02f, 1.29587464e-02f, 6.13224134e-02f, -1.26735903e-02f, -9.12747979e-02f, -6.49050027e-02f, -8.50178674e-03f, -8.92339721e-02f, -2.96646599e-02f,
  3.09155226e-01f, 1.86549217e-01f, 2.18854044e-02f, -5.90360687e-05f, 5.53929806e-02f, 1.53304469e-02f, 3.15196179e-02f, -3.01917996e-02f, 4.97442670e-02f, 6.47921264e-02f,
  7.37670735e-02f, -1.71623118e-02f, -1.87604409e-02f, -6.96982518e-02f, -8.88837725e-02f, 4.70700413e-02f, -2.14608386e-02f, -4.82627712e-02f, -2.63329092e-02f, -4.22372036e-02f,
  -1.73611045e-02f, -1.15861110e-02f, -6.41446114e-02f, 7.16940686e-02f, 1.62205026e-02f, -3.39813903e-02f, -4.14773542e-03f, -1.70719787e-01f, 2.76561808e-02f, -1.49807278e-02f,
  -5.14548898e-01f, 2.08993599e-01f, 7.16594234e-02f, -1.06290467e-01f, 3.25721800e-02f, 3.64856660e-01f, 3.25302124e-01f, 2.30997398e-01f, 3.17624360e-01f, 2.52366841e-01f,
  7.70515949e-02f, 4.26959731e-02f, 1.13555253e-01f, 1.59183905e-01f, 1.95519432e-01f, 1.27658382e-01f, 2.05969200e-01f, 1.01677477e-01f, -2.57995911e-03f, -1.62908778e-01f,
  -1.87219959e-02f, 2.47097071e-02f, -1.49100572e-01f, -8.92606527e-02f, -2.38756701e-01f, -1.69887587e-01f, -1.64236754e-01f, -4.20105048e-02f, -2.66708490e-02f, 1.24031713e-03f,
  1.10124284e-02f, 3.15956809e-02f, -8.81259236e-03f, 1.00170672e-01f, 8.54460672e-02f, 5.14725260e-02f, -9.94118396e-03f, -5.07997051e-02f, -4.02819850e-02f, 3.97883654e-02f,
  2.42900141e-02f, -7.42360428e-02f, 3.17943655e-02f, -3.50223035e-02f, -7.72281587e-02f, -3.92875681e-03f, -1.51930368e-02f, -1.22282721e-01f, -5.66704087e-02f, -4.82449681e-02f,
  3.53348441e-02f, 2.58270595e-02f, -9.52247530e-02f, 9.32601392e-02f, -1.12829380e-01f, 3.65333213e-03f, 7.74250031e-02f, -6.04797639e-02f, -3.29019176e-03f, 5.16732484e-02f,
  -2.13468429e-02f, 2.07891986e-02f, 8.94729644e-02f, -2.53810510e-02f, 8.79132971e-02f, -3.73661667e-02f, -4.35147136e-02f, -6.55654771e-03f, 1.67263728e-02f, -7.09131360e-02f,
  -5.58526926e-02f, 4.07777950e-02f, 6.73496500e-02f, -9.69934314e-02f, 1.69241223e-02f, -2.43284795e-02f, -6.06473051e-02f, 3.21526974e-02f, 3.32840346e-02f, -1.22942431e-02f,
  9.19823721e-02f, -2.14102846e-02f, -3.99494581e-02f, 1.47632845e-02f, -4.10396717e-02f, -6.11798465e-02f, 7.69525617e-02f, 1.32741807e-02f, 1.10991366e-01f, -1.57770161e-02f,
  2.22870126e-01f, 2.23939970e-01f, 5.50423097e-03f, 7.68341171e-03f, -2.19553038e-02f, -1.40117994e-02f, -4.86601554e-02f, -1.35741634e-02f, 1.25324041e-01f, 3.92562263e-02f,
  3.18311229e-02f, -7.28316680e-02f, -3.69552001e-02f, -4.99834456e-02f, 2.21115933e-03f, 2.07024574e-01f, -5.10547729e-03f, 8.04297552e-02f, 4.00987193e-02f, -5.32753170e-02f,
  -1.55467778e-01f, -8.83794948e-02f, -5.00318687e-03f, -6.58739433e-02f, -5.48167787e-02f, -6.32350296e-02f, -4.03434485e-02f, -1.14267459e-02f, 9.33424104e-03f, -6.55459315e-02f,
  -1.66950673e-01f, -2.23206162e-01f, -2.33881697e-02f, -1.16771489e-01f, -2.22548872e-01f, 2.12401092e-01f, 3.97841573e-01f, -1.50180623e-01f, -1.42283127e-01f, 1.98497489e-01f,
  4.23519965e-03f, -3.10021229e-02f, 3.76330763e-01f, -1.23853132e-01f, 3.21219563e-01f, 1.16673909e-01f, -4.23646607e-02f, 4.32166979e-02f, -2.39611030e-01f, -1.40937239e-01f,
  -9.16967019e-02f, -2.24928379e-01f, 5.92201352e-02f, -3.47775310e-01f, -1.50133774e-01f, -3.14496309e-01f, 1.82036068e-02f, 2.98468228e-02f, -1.73730716e-01f, -4.92052659e-02f,
  -2.63450325e-01f, -3.02226096e-01f, 2.89297011e-03f, 2.36690901e-02f, -6.25168607e-02f, 4.06306982e-02f, 2.96095889e-02f, 1.28869638e-01f, 4.19234782e-02f, 4.83430773e-02f,
  6.27214238e-02f, 3.99528667e-02f, -1.09016910e-01f, -1.64600811e-03f, -5.25360787e-03f, 1.76453423e-02f, -5.85524701e-02f, 2.02294942e-02f, -1.48773128e-02f, 4.03326489e-02f,
  9.46947262e-02f, -2.38983817e-02f, 3.15420590e-02f, -9.83720925e-03f, 1.02652004e-02f, -3.37899178e-02f, -1.77319776e-02f, 3.34683899e-03f, -4.82391380e-02f, -9.66357961e-02f,
  4.68825689e-03f, 4.80482914e-02f, -1.08151860e-03f, 5.55172190e-03f, 5.13077639e-02f, -2.65271179e-02f, 4.25421633e-03f, 2.39244979e-02f, -5.68648465e-02f, 1.42050805e-02f,
  -1.13374114e-01f, -1.72483958e-02f, -8.67340416e-02f, 5.53940572e-02f, -1.04530081e-01f, -4.93019857e-02f, 1.34030245e-02f, -5.27703762e-02f, -3.21888551e-02f, -1.95100475e-02f,
  -4.90139462e-02f, -5.04224375e-02f, 2.18074117e-02f, 3.20502445e-02f, -2.32110769e-02f, -7.38125620e-03f, -6.20209835e-02f, -5.60235903e-02f, -9.38531850e-03f, 8.37370679e-02f,
  -1.57296821e-01f, -2.57170498e-01f, -4.30109240e-02f, -4.86373231e-02f, -6.38767704e-02f, 4.30197902e-02f, 1.51777528e-02f, -4.45070975e-02f, -5.99458218e-02f, -1.12299196e-01f,
  -9.49870571e-02f, 3.08621358e-02f, 2.48216223e-02f, -9.32121370e-03f, 8.83762315e-02f, -2.63759289e-02f, 5.72111867e-02f, -3.60699929e-02f, -5.01001105e-02f, -3.52724106e-03f,
  7.97458515e-02f, -1.23733962e-02f, 3.01183835e-02f, -7.97459111e-02f, 4.47469130e-02f, 4.37515192e-02f, -4.56523523e-02f, 4.65213768e-02f, -2.01094523e-02f, -1.58001408e-02f,
  -1.16004527e-01f, -2.35515490e-01f, 3.00996844e-02f, 2.47244447e-01f, 9.67700556e-02f, -2.14430869e-01f, -8.85985419e-02f, 2.26996064e-01f, -1.81354620e-02f, -1.22531421e-01f,
  -4.14225683e-02f, -3.54694724e-01f, -1.54799119e-01f, -1.79478809e-01f, 2.97746360e-02f, -2.48019204e-01f, -8.60840976e-02f, -1.99173942e-01f, -1.05732009e-01f, 1.48917779e-01f,
  1.84588686e-01f, 1.42321944e-01f, 2.80657202e-01f, 1.97240621e-01f, 1.59355272e-02f, 2.52807498e-01f, 3.23270470e-01f, 8.93775299e-02f, 1.79838955e-01f, -1.73196226e-01f,
  -8.99831206e-02f, 1.13896757e-01f, 1.20629985e-02f, -1.43103898e-01f, 1.78719968e-01f, 1.95082858e-01f, 9.35533419e-02f, -8.57697651e-02f, 8.71055424e-02f, 3.16867530e-02f,
  -2.63940096e-02f, 8.18363018e-03f, -3.38499397e-02f, 2.39308551e-03f, -5.96859353e-03f, 7.09665120e-02f, -1.01030022e-01f, -6.87324256e-02f, -8.22191238e-02f, -2.27086637e-02f,
  1.97095927e-02f, -1.04917862e-01f, 3.30029987e-03f, -1.05812699e-02f, 1.02878064e-01f, -7.88811371e-02f, 1.33611783e-02f, -1.30060920e-02f, -1.33470690e-03f, 3.82762104e-02f,
  2.24043685e-03f, 9.56259519e-02f, -4.71375138e-02f, 2.21990999e-02f, 1.89081952e-02f, -1.30335083e-02f, -6.30285069e-02f, -3.88249420e-02f, 3.93788479e-02f, 1.13527142e-02f,
  3.60110290e-02f, -4.23062146e-02f, -2.35022400e-02f, 1.52876139e-01f, 1.09952409e-03f, -3.55942622e-02f, -5.24756825e-03f, 1.29465503e-03f, 4.28936705e-02f, 7.33986422e-02f,
  1.11640938e-01f, -9.81869474e-02f, 2.95653827e-02f, -8.51311088e-02f, -1.17523827e-01f, 8.48195851e-02f, 9.76067483e-02f, -5.11685610e-02f, 6.28356412e-02f, -1.54337822e-03f,
  -2.27212626e-02f, 2.08223373e-01f, 5.27193993e-02f, -3.71234715e-02f, -3.64989340e-02f, -4.10130955e-02f, -9.39441696e-02f, -8.18420872e-02f, -2.81264633e-03f, -1.12063669e-01f,
  2.37816229e-01f, 4.31433357e-02f, 9.22086462e-03f, -6.82783052e-02f, 2.90460140e-02f, 1.31679878e-01f, 3.08132600e-02f, -5.38690798e-02f, 1.04444765e-01f, 9.53461155e-02f,
  2.99314894e-02f, -1.31838828e-01f, -1.03286006e-01f, -9.53044221e-02f, 8.62303078e-02f, 5.43421134e-03f, -2.82967836e-02f, 8.70791301e-02f, 4.74305786e-02f, -2.24428270e-02f,
  -3.07375312e-01f, 8.23002011e-02f, -3.70115004e-02f, 2.51909107e-01f, -3.77144851e-02f, -8.71883035e-02f, -1.08231418e-01f, -4.34365729e-03f, -9.53080952e-02f, 8.53625834e-02f,
  1.31253734e-01f, -1.18563369e-01f, 2.59736534e-02f, 1.92373201e-01f, 6.90127984e-02f, 1.50410905e-01f, 2.33290523e-01f, 2.28663012e-02f, 9.19218212e-02f, 5.01727685e-02f,
  7.00306371e-02f, 2.51465380e-01f, 2.12562516e-01f, 1.55777454e-01f, 7.88953081e-02f, 9.58334282e-03f, 1.14848331e-01f, 1.89458579e-02f, 1.13185897e-01f, -3.14624719e-02f,
  -6.51798621e-02f, 1.36893436e-01f, -7.08333775e-02f, -5.85014261e-02f, -4.07375256e-03f, 2.08830945e-02f, -1.03562940e-02f, -9.12173316e-02f, -1.07807115e-01f, 5.26743792e-02f,
  -4.34239507e-02f, 3.21490839e-02f, 3.31220739e-02f, -2.74517220e-02f, 2.26807762e-02f, -2.44619069e-03f, 4.20160741e-02f, -9.77694709e-03f, 2.83864457e-02f, 7.28995427e-02f,
  -5.37431799e-02f, 7.66563565e-02f, -3.00152022e-02f, 2.71096081e-02f, -4.52196375e-02f, 2.86507569e-02f, -1.29177021e-02f, 6.75685555e-02f, -1.39534045e-02f, 9.39047989e-03f,
  2.66686804e-03f, -7.89374784e-02f, -4.92230430e-02f, -5.15815057e-02f, 1.00254705e-02f, 6.95685744e-02f, 7.21393302e-02f, 2.81537678e-02f, -7.85464346e-02f, 5.51459678e-02f,
  -2.94135418e-02f, -9.75691341e-03f, -1.14778355e-02f, -2.37771426e-03f, 3.47456662e-03f, 4.22156975e-03f, -6.42558560e-02f, -9.27843079e-02f, 3.05293929e-02f, -7.62904063e-02f,
  -4.20222469e-02f, -3.85373347e-02f, -6.31072223e-02f, 3.64854336e-02f, -1.58232823e-02f, -4.71425317e-02f, 5.12477010e-02f, 6.62104115e-02f, 7.98364952e-02f, -1.03611931e-01f,
  1.59249276e-01f, 1.76909998e-01f, 2.64522508e-02f, -3.28713320e-02f, 1.37816951e-01f, -5.28137609e-02f, -3.57495993e-03f, 4.04964425e-02f, 1.58979371e-02f, 6.36390373e-02f,
  9.35640372e-03f, -6.02132529e-02f, 6.84250705e-03f, -2.85938792e-02f, -7.16704270e-03f, 2.97887623e-02f, 9.18708183e-03f, -1.94306243e-02f, 6.33983538e-02f, 5.29831052e-02f,
  7.80687202e-03f, -5.35912327e-02f, 6.38247374e-03f, -7.21052215e-02f, -1.11902375e-02f, 7.98525810e-02f, -1.37782581e-02f, 5.63639626e-02f, 1.39508499e-02f, -3.98078524e-02f,
  -4.47119474e-01f, -9.56633408e-03f, -1.72634810e-01f, -1.02497556e-03f, -2.67028630e-01f, -1.66307792e-01f, -3.99305411e-02f, -1.81120425e-01f, -5.33752441e-02f, 2.15390459e-01f,
  5.11330813e-02f, -1.09450437e-01f, 6.30866364e-02f, 1.49273783e-01f, -1.29673555e-01f, 2.08802551e-01f, 6.74726292e-02f, 1.56378429e-02f, -5.65592311e-02f, -1.93612933e-01f,
  1.93946585e-02f, 2.26073842e-02f, 1.32769644e-01f, 3.81919183e-02f, -1.77379116e-01f, -1.02080844e-01f, 9.45270583e-02f, -8.88512060e-02f, -1.42790347e-01f, -1.59913093e-01f,
  -2.85307258e-01f, -9.35827270e-02f, -5.30116931e-02f, 2.23864475e-03f, -9.99954939e-02f, -6.47194684e-02f, 6.39288500e-03f, 1.44547690e-02f, 5.96032925e-02f, -9.24413130e-02f,
  -4.76468280e-02f, -4.80544046e-02f, 4.48294654e-02f, 3.88948619e-02f, -1.36612698e-01f, 6.74477667e-02f, -5.86635806e-02f, 4.61282842e-02f, -1.00445636e-01f, 2.08256636e-02f,
  -1.61178205e-02f, -9.48193148e-02f, 9.26741660e-02f, 6.71935678e-02f, -1.82370283e-02f, -5.42231798e-02f, -5.74609265e-02f, -8.55608881e-02f, -1.15368530e-01f, -1.26767322e-01f,
  9.00335759e-02f, 1.43685974e-02f, 4.49660942e-02f, -5.81162609e-02f, -1.59684848e-02f, -9.21042450e-03f, 4.46422622e-02f, 6.13535149e-03f, -4.51295674e-02f, 3.11287250e-02f,
  1.00816675e-02f, -5.76087683e-02f, -3.10347006e-02f, -3.17109302e-02f, -8.08392391e-02f, 6.66929930e-02f, -6.72296733e-02f, -9.98360962e-02f, 4.28604260e-02f, -1.10266712e-02f,
  -7.22456127e-02f, 4.79216799e-02f, 1.10783488e-01f, 7.96436146e-02f, 5.59373805e-03f, -4.81450036e-02f, -1.44194590e-03f, 1.05816536e-01f, 1.80840343e-02f, -9.41450335e-03f,
  -3.01466495e-01f, -2.65790612e-01f, -2.25549974e-02f, -5.39217032e-02f, -4.90961969e-02f, -4.45376746e-02f, 2.19045002e-02f, -1.28525332e-01f, -1.13776699e-01f, -2.03337461e-01f,
  -5.01394086e-03f, 5.31838927e-03f, -1.80190485e-02f, -3.06643639e-02f, 1.33963469e-02f, 4.18969197e-03f, 5.11269495e-02f, -7.36098131e-03f, -7.35290647e-02f, 3.92049132e-03f,
  6.65822253e-02f, 4.81561944e-02f, 9.66453999e-02f, 4.23028208e-02f, 5.55602014e-02f, 8.19187704e-03f, -6.84812069e-02f, 2.78369151e-02f, -3.29810567e-02f, -2.99920770e-03f,
  -7.59027779e-01f, 2.94693172e-01f, -1.46741837e-01f, -2.41630405e-01f, 1.55724976e-02f, -8.40152577e-02f, -7.07266033e-02f, 2.21648943e-02f, -1.83381394e-01f, -5.40971197e-02f,
  -9.78067741e-02f, -1.03457049e-01f, 1.71156749e-01f, -1.40719200e-02f, -1.63437933e-01f, 1.99712992e-01f, -1.77965552e-01f, -4.83732671e-02f, 4.97187339e-02f, -1.33191437e-01f,
  1.22698508e-02f, 3.14250514e-02f, -6.95312172e-02f, 2.22873062e-01f, -9.66367200e-02f, -3.24406922e-02f, -1.78510189e-01f, 1.35817692e-01f, 1.93387624e-02f, 1.13414496e-01f,
  -2.64214993e-01f, -2.22281501e-01f, -1.12741061e-01f, -4.93747927e-02f, -1.84819654e-01f, -8.00123662e-02f, -7.74615677e-03f, 5.48252882e-03f, -4.55403375e-03f, 5.40802255e-04f,
  -4.35974114e-02f, 8.44020098e-02f, -5.51464595e-02f, 4.73000184e-02f, -1.02573372e-01f, -6.57422170e-02f, 1.50279701e-02f, -1.24616101e-01f, -2.22457275e-02f, 1.26659200e-02f,
  5.09458184e-02f, -4.07498106e-02f, -6.81851283e-02f, -4.36456837e-02f, -4.37109508e-02f, -3.83340828e-02f, -1.12735918e-02f, 2.78642680e-02f, -6.22232035e-02f, -7.65752271e-02f,
  1.36975601e-01f, -3.04265711e-02f, 1.89317903e-03f, -3.66195701e-02f, 1.98208056e-02f, -5.76945730e-02f, -7.45694041e-02f, -9.86230746e-02f, -2.62035765e-02f, 2.98785307e-02f,
  -1.12427928e-01f, -1.11741219e-02f, 2.89704953e-03f, -9.96423736e-02f, -1.01729698e-01f, -5.80494739e-02f, 1.28279692e-02f, 4.37870212e-02f, -1.87699199e-02f, 4.89906929e-02f,
  -5.61060533e-02f, -3.08479741e-03f, -5.78925246e-03f, 1.24011980e-02f, 7.23669380e-02f, 5.05228639e-02f, 5.45745380e-02f, 3.44782360e-02f, -4.01646867e-02f, -1.09562483e-02f,
  -4.72087979e-01f, -4.06023353e-01f, -6.05576560e-02f, -5.15864268e-02f, -2.54563577e-02f, 4.11003120e-02f, 7.52180740e-02f, -1.14802811e-02f, -6.45545945e-02f, -6.01446489e-03f,
  -4.97148074e-02f, -3.28549631e-02f, -7.34371692e-02f, -2.43202113e-02f, -3.71422013e-03f, 1.39387427e-02f, -4.41949852e-02f, -1.43734440e-02f, -9.30488259e-02f, 1.46998437e-02f,
  -5.13406619e-02f, -3.91158052e-02f, -2.35726777e-02f, -2.59285066e-02f, -5.63739017e-02f, -4.57155891e-02f, 6.59023002e-02f, 1.24709113e-02f, -3.00794262e-02f, -8.23467597e-03f,
  -2.20348701e-01f, 1.48418946e-02f, -8.42151642e-02f, -2.08171785e-01f, 1.70751065e-01f, -1.97846845e-01f, -5.95073476e-02f, 1.75864816e-01f, 3.56210358e-02f, 3.02735150e-01f,
  1.47137448e-01f, -2.22046375e-01f, 9.10331309e-02f, -3.90149802e-01f, -5.17218292e-01f, -3.58851343e-01f, -5.52639902e-01f, -1.35876924e-01f, -1.86397702e-01f, -2.07173824e-03f,
  -2.35236853e-01f, -1.42579734e-01f, -2.94614643e-01f, 1.09106295e-01f, 1.03851646e-01f, 1.85594395e-01f, 2.34537825e-01f, 2.65724152e-01f, -7.12742805e-02f, -8.07511061e-03f,
  9.06013474e-02f, -8.09051618e-02f, 6.83895871e-02f, 3.36451679e-02f, 5.74530512e-02f, 3.80136631e-03f, -7.40305707e-03f, -5.90324700e-02f, 9.63501111e-02f, -3.17027308e-02f,
  3.08440241e-04f, -4.01382074e-02f, -1.11388750e-01f, 6.52879151e-03f, 1.06614411e-01f, 2.58475356e-02f, -1.16934285e-01f, 2.01734174e-02f, 2.93390471e-02f, -2.51765102e-01f,
  -8.62280056e-02f, -3.43877003e-02f, -5.47300503e-02f, -3.35277021e-02f, -1.48658259e-02f, -7.08575593e-03f, -3.59814651e-02f, 3.92326061e-03f, -2.31314879e-02f, 2.63851415e-02f,
  -1.21455044e-01f, 1.35990167e-02f, -2.08172649e-02f, 3.64723727e-02f, 4.01873812e-02f, 8.34729299e-02f, -1.39697092e-02f, 8.26622695e-02f, 5.73682413e-02f, -1.60320867e-02f,
  1.28921098e-03f, -3.12829833e-03f, -7.41670728e-02f, -2.79907007e-02f, 7.91513361e-03f, -1.27839476e-01f, -6.67020166e-03f, 5.00546135e-02f, -1.05215013e-01f, -7.48525281e-03f,
  1.36616435e-02f, 2.24402193e-02f, 6.68899098e-04f, 9.62931837e-04f, 1.65578574e-02f, -3.79289985e-02f, -1.81988422e-02f, -6.00461438e-02f, -9.67660174e-03f, -4.57168445e-02f,
  7.94064999e-02f, -3.39775085e-02f, 6.05112426e-02f, 1.36585776e-02f, 5.29928617e-02f, -3.95123009e-03f, -1.11721374e-01f, -1.23328745e-01f, 2.31680255e-02f, -5.60566178e-03f,
  2.29092035e-02f, 1.24469660e-01f, 5.00538833e-02f, 4.20247763e-02f, 6.74922690e-02f, 4.41402644e-02f, -4.40822132e-02f, 1.10119455e-01f, 4.47440632e-02f, -1.82443820e-02f,
  9.97103825e-02f, 1.47610186e-02f, -4.01867889e-02f, 9.19992924e-02f, -4.17848304e-03f, -3.17149572e-02f, 1.17832050e-02f, -6.49571866e-02f, 8.81326199e-02f, 3.31739187e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.96531498e-01f, -1.06974125e-01f, 6.48663789e-02f, -9.97716188e-02f, 2.37905353e-01f, 1.29524112e-01f, -8.32977220e-02f, 5.45008294e-02f, -6.32024258e-02f, 7.69917965e-02f,
  1.02352031e-01f, 1.39586046e-01f, 1.38439760e-01f, 1.17734730e-01f, 8.58598128e-02f, 2.63763130e-01f, 2.54725310e-04f, 7.39640594e-02f, 1.01330794e-01f, 2.24543929e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  6.99016303e-02f, -7.91955814e-02f, -3.29070650e-02f, -8.64252448e-02f, 1.13202728e-01f, 1.69959471e-01f, -2.07151603e-02f, 1.13567255e-01f, 2.54208706e-02f, 1.11777343e-01f,
  1.37693003e-01f, 1.82875887e-01f, -1.36772975e-01f, 8.70752335e-03f, -1.03671215e-01f, -3.27109277e-01f, 3.02011728e-01f, 2.30732441e-01f, -2.60976195e-01f, 1.54599294e-01f,
  -1.23540565e-01f, 1.65256530e-01f, 2.06942111e-01f, 2.03200132e-01f, 1.73399612e-01f, 1.71069503e-01f, 9.36139449e-02f, -4.84622456e-02f, 1.37320384e-01f, -4.45297509e-02f,
  -2.11182743e-01f, -2.77127117e-01f, 9.59594995e-02f, -2.67749932e-02f, 2.34369352e-01f, 1.01552457e-01f, 1.59650266e-01f, -9.00262371e-02f, 7.38662556e-02f, 8.24870169e-02f,
  -2.10649028e-01f, -9.38742384e-02f, 1.90086007e-01f, 1.75798237e-01f, 5.87241426e-02f, -9.79582369e-02f, 2.40583103e-02f, -2.33932436e-01f, 1.07329696e-01f, 2.03661367e-01f,
  -4.54811454e-02f, -1.32210955e-01f, -6.87072985e-03f, -8.22857544e-02f, 7.38854557e-02f, -1.90213948e-01f, -5.93013782e-03f, 2.69310381e-02f, -1.39397690e-02f, 3.77716646e-02f,
  -7.39196539e-02f, -1.59689561e-01f, -1.43623948e-02f, -5.68379685e-02f, 1.66163310e-01f, -1.65235907e-01f, 1.73683211e-01f, 1.07805938e-01f, -9.81427170e-03f, -1.08860247e-01f,
  -1.78111177e-02f, -2.31125057e-01f, 2.61175856e-02f, -5.53183109e-02f, -7.98173025e-02f, -4.27004695e-02f, 7.47679621e-02f, -8.67023915e-02f, 3.16203117e-01f, -2.83785075e-01f,
  2.19853707e-02f, 6.59485981e-02f, -3.80776301e-02f, 1.12940483e-01f, 1.46246612e-01f, 1.88698247e-01f, 9.26485062e-02f, -2.66674280e-01f, -2.36601695e-01f, -2.76989639e-01f,
  -2.66068846e-01f, 2.52890974e-01f, 3.27038132e-02f, -2.36013792e-02f, 6.67356551e-02f, 1.17891572e-01f, -1.66648805e-01f, -9.35414359e-02f, -8.46640095e-02f, -3.49552520e-02f,
  -1.27988771e-01f, -2.28028208e-01f, -2.57299870e-01f, -3.55982743e-02f, -2.88866479e-02f, -7.20362067e-02f, -1.34326801e-01f, -3.19509245e-02f, -1.80371195e-01f, -2.88198650e-01f,
  1.67038605e-01f, -1.48589015e-01f, -1.35060176e-01f, 6.84427246e-02f, -2.24550843e-01f, 8.19221288e-02f, 1.67113379e-01f, -2.66865134e-01f, 1.19924098e-01f, 3.08615454e-02f,
  1.93819571e-02f, 1.33792469e-02f, -2.01146856e-01f, 4.17296775e-02f, -1.65654570e-02f, 3.81328613e-02f, -1.66530073e-01f, -1.61249489e-01f, -3.70106697e-02f, 2.15582907e-01f,
  -2.14558598e-02f, -1.37138115e-02f, -5.04777841e-02f, 8.76389146e-02f, 2.89842874e-01f, 3.49612385e-01f, 5.53185530e-02f, -9.81354266e-02f, 1.80114225e-01f, 2.93878466e-01f,
  1.18102670e-01f, -1.11679360e-01f, -3.60453315e-03f, 5.39696263e-03f, 1.20957591e-01f, 1.31598607e-01f, 1.35534286e-01f, -3.30669463e-01f, -1.50481164e-01f, -2.81944454e-01f,
  -2.71661431e-01f, -2.20409483e-01f, -2.74004787e-01f, 4.40684753e-03f, 2.72701234e-01f, 7.98004940e-02f, -2.45614484e-01f, -3.20050456e-02f, 4.65394137e-03f, -2.06285045e-01f,
  7.23547637e-02f, -7.07090199e-02f, -4.86135185e-02f, 1.05697945e-01f, -4.29749340e-02f, -2.91964319e-02f, 1.96459144e-01f, -1.26206083e-02f, -1.32382363e-01f, -9.23040658e-02f,
  -9.27440003e-02f, -1.18150048e-01f, -1.72007337e-01f, 7.68866763e-02f, 6.86551630e-02f, -2.76458621e-01f, 1.58292770e-01f, 1.27827808e-01f, -1.90522969e-01f, 2.54350573e-01f,
  6.58273101e-02f, -3.31741236e-02f, 6.06423095e-02f, -9.29319113e-02f, 9.31985751e-02f, -3.27574983e-02f, -1.70501575e-01f, 1.35057479e-01f, -9.71354693e-02f, -3.10145050e-01f,
  -3.76954228e-01f, 4.31393236e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.27333701e-01f, -9.32047367e-02f, 1.59115031e-01f, -1.00063309e-01f, 1.15803480e-01f, 8.20198432e-02f, -2.40170822e-01f, -2.50502974e-01f, 1.14395127e-01f, 7.21924976e-02f,
  1.02915745e-02f, -3.36722910e-01f, -2.67106235e-01f, -8.06837827e-02f, 1.48673922e-01f, -9.42446366e-02f, 2.42591575e-01f, -3.08986544e-03f, -2.68889099e-01f, 5.60410926e-03f,
  7.02964514e-03f, 4.08784270e-01f, 3.89000058e-01f, 3.44951339e-02f, 6.28860220e-02f, -8.37222710e-02f, 1.52814522e-01f, 2.84806699e-01f, 1.77692547e-01f, 1.94358662e-01f,
  -1.86756372e-01f, -6.46120403e-03f, 2.28624314e-01f, 2.09167987e-01f, 3.54494363e-01f, 1.87853634e-01f, 2.71665722e-01f, -4.91593182e-02f, -1.55207932e-01f, -3.50637078e-01f,
  1.04970269e-01f, -2.23892123e-01f, -3.04745026e-02f, -2.60337919e-01f, 1.87404901e-01f, -2.62784958e-01f, 3.99888754e-01f, -1.89876288e-01f, 1.41552344e-01f, 8.52589905e-02f,
  -4.60763834e-02f, -1.15585484e-01f, 9.84525457e-02f, 4.09913599e-01f, 2.46794418e-01f, 5.37100658e-02f, -2.78596848e-01f, -3.20875198e-01f, -3.02771866e-01f, 4.94558871e-01f,
  1.01113744e-01f, 1.00930035e-01f, 4.32523459e-01f, 4.85327840e-01f, 7.48060644e-03f, 2.35454470e-01f, -4.69769202e-02f, -1.99136406e-01f, -9.90804583e-02f, 1.86413154e-01f,
  -1.32788017e-01f, 8.02859291e-02f, -2.01783344e-01f, -1.02672860e-01f, -1.29595593e-01f, 2.62734629e-02f, -4.12412547e-02f, 2.86526531e-01f, -4.58809547e-02f, -1.44712210e-01f,
  -1.95221812e-01f, -1.47205917e-02f, -2.84557864e-02f, 2.14865103e-01f, 6.99782073e-02f, -1.73500851e-01f, 3.96149829e-02f, 7.06953257e-02f, 3.61900121e-01f, 1.41600832e-01f,
  -1.03425831e-01f, -2.16932625e-01f, -4.23824154e-02f, -4.13038135e-02f, -7.20890239e-02f, -4.07280847e-02f, 3.52213025e-01f, 2.68791437e-01f, 3.12749565e-01f, 1.03149012e-01f,
  2.65670568e-01f, 2.59066343e-01f, -6.51546419e-02f, -1.91523701e-01f, 1.67417601e-01f, 1.78751245e-01f, -8.66622776e-02f, 1.78825840e-01f, 3.31809551e-01f, 1.07520863e-01f,
  8.33209977e-02f, 3.22524272e-02f, -1.61405638e-01f, -2.44021922e-01f, 1.41556934e-01f, -3.76890421e-01f, -3.58598903e-02f, 1.07112609e-01f, -1.40636682e-03f, 1.49112299e-01f,
  6.26136065e-02f, 4.59929705e-01f, 2.90173646e-02f, -1.06947720e-01f, 1.67390928e-01f, 1.62084877e-01f, 2.77951986e-01f, 5.12709767e-02f, 1.57535404e-01f, 5.89489415e-02f,
  2.17539802e-01f, 1.11400791e-01f, 3.47323492e-02f, 1.57218948e-01f, 3.37025151e-02f, 8.33829194e-02f, 1.31960616e-01f, 5.78985289e-02f, -5.16726077e-02f, 2.02249922e-02f,
  3.68815899e-01f, 1.00878097e-01f, -1.12186298e-01f, 2.26404443e-01f, -8.56981054e-02f, -5.48475124e-02f, 2.64203072e-01f, -4.61860865e-01f, -5.17574102e-02f, -3.41426842e-02f,
  1.16563685e-01f, 6.88242242e-02f, -9.33348611e-02f, 9.17604938e-03f, -7.45017380e-02f, -7.02045560e-02f, -1.79570168e-02f, 4.28548381e-02f, 4.14047182e-01f, 2.44049385e-01f,
  1.00972272e-01f, -1.35240287e-01f, 1.18180215e-01f, 1.03083602e-03f, 9.76078212e-02f, 6.30818978e-02f, -1.49942294e-01f, -3.63171935e-01f, 1.94722325e-01f, 3.14354151e-02f,
  -9.27408189e-02f, -5.08816659e-01f, 4.07147184e-02f, 1.04767159e-01f, -2.98215300e-01f, 3.88059318e-01f, -1.56353638e-01f, -9.98941660e-02f, 3.49452436e-01f, -1.81130871e-01f,
  -2.02634186e-01f, 1.08632505e-01f, 2.23193124e-01f, 6.66430071e-02f, 2.91437861e-02f, -5.36817275e-02f, 2.04325825e-01f, 2.59674698e-01f, 7.44882300e-02f, 3.93064559e-01f,
  3.21813017e-01f, 5.29396713e-01f, 3.00331324e-01f, -1.20100155e-01f, 3.45890909e-01f, 1.52279034e-01f, 6.02887869e-02f, 4.47859103e-03f, -1.75047934e-01f, -9.17879045e-02f,
  -1.23318471e-01f, -7.67081976e-02f, -6.31432980e-02f, -2.05958724e-01f, -4.60637501e-03f, 6.35802164e-04f, 3.57047588e-01f, -2.46051326e-02f, -1.61973566e-01f, 1.43164694e-01f,
  2.03757212e-01f, 3.73371482e-01f, 3.20263982e-01f, -5.44882240e-03f, 7.99672380e-02f, -6.19840026e-02f, -8.09766576e-02f, -2.27633283e-01f, -2.51953453e-01f, 1.55409902e-01f,
  -3.57582383e-02f, -2.54044197e-02f, -1.03000641e-01f, 4.14707720e-01f, -9.93795916e-02f, 4.86433059e-02f, -1.84917878e-02f, 1.78340003e-02f, -1.68243110e-01f, 6.24731965e-02f,
  -1.43439293e-01f, 1.32777204e-04f, -1.94415286e-01f, -8.88416693e-02f, 4.30127941e-02f, -2.26288587e-01f, -4.85011861e-02f, 2.05080405e-01f, -8.60453099e-02f, -3.15704849e-03f,
  -2.57962316e-01f, 2.14451365e-02f, -9.71597806e-02f, 6.04921356e-02f, 8.31029639e-02f, -5.35935424e-02f, 8.99187177e-02f, 9.08059850e-02f, 1.34082153e-01f, -9.21193231e-03f,
  7.52537474e-02f, -2.33066306e-01f, 7.21579045e-02f, 1.20856687e-01f, 8.61924067e-02f, 1.08598478e-01f, 3.42381895e-02f, 3.81688416e-01f, 7.49395937e-02f, 4.69447076e-02f,
  9.38518047e-02f, 3.19828719e-01f, -1.07609212e-01f, 4.87283282e-02f, 1.08632892e-01f, 2.45437682e-01f, -1.33254647e-01f, 7.57048978e-03f, 1.44193798e-01f, -6.33191913e-02f,
  -1.06061369e-01f, -3.34990650e-01f, 1.97260365e-01f, -1.35864228e-01f, -2.88624763e-01f, -1.77241042e-01f, -6.84628263e-02f, 4.67878491e-01f, 7.32563948e-03f, 4.45922375e-01f,
  2.10039958e-01f, 4.36187774e-01f, 3.14090014e-01f, 1.55827969e-01f, 2.88036972e-01f, 1.64480060e-01f, 2.37878814e-01f, -3.39057386e-01f, -1.10879708e-02f, 2.19136313e-01f,
  -1.03103342e-02f, 7.65364617e-02f, -3.94293964e-02f, 2.00082704e-01f, 4.02286023e-01f, 2.70079702e-01f, 1.70724407e-01f, 6.28508581e-03f, -2.01638594e-01f, 4.57580686e-02f,
  -3.71107012e-02f, 3.39891165e-01f, -2.20928997e-01f, 1.86578482e-01f, 3.50332022e-01f, -5.97640611e-02f, 2.76048601e-01f, -3.19725692e-01f, -1.55684352e-01f, 2.51141578e-01f,
  9.99620780e-02f, -6.23205155e-02f, 5.68785239e-03f, 1.20897263e-01f, 4.19471204e-01f, 3.25013064e-02f, 1.23321287e-01f, 5.61776087e-02f, 3.25918570e-02f, -1.62540793e-01f,
  2.54902840e-01f, -5.93590885e-02f, 1.44557819e-01f, 2.27661118e-01f, 2.62653619e-01f, -7.65828565e-02f, 1.73107848e-01f, -1.43433556e-01f, -1.72957361e-01f, -2.29900151e-01f,
  1.33177355e-01f, 3.75404447e-01f, 7.99603462e-02f, -4.67301868e-02f, 2.04249680e-01f, -1.83276728e-01f, 1.23313833e-02f, -1.47732869e-01f, 2.33560447e-02f, -8.87112245e-02f,
  1.44301385e-01f, -2.01166466e-01f, -3.42776358e-01f, -6.33430406e-02f, -6.28701225e-02f, -1.64077625e-01f, -1.13387264e-01f, 1.41552597e-01f, -9.02236551e-02f, -8.27557072e-02f,
  -1.71268076e-01f, 1.13660403e-01f, -1.34425433e-02f, -1.17813982e-01f, -1.81936517e-01f, 3.80561464e-02f, 1.96282696e-02f, -1.26717156e-02f, -3.18556964e-01f, -1.78465664e-01f,
  8.50826427e-02f, 7.41364658e-02f, 1.37604326e-01f, -8.06140006e-02f, -3.33810955e-01f, 8.13402906e-02f, 1.46338537e-01f, -9.00786079e-04f, 6.61517084e-02f, 2.67413780e-02f,
  -2.01120675e-01f, 2.24969909e-01f, -3.66556868e-02f, 1.60415277e-01f, 1.44243494e-01f, 3.50024700e-01f, 1.95432633e-01f, 7.79019669e-02f, 8.41419026e-02f, 1.18120506e-01f,
  1.11245044e-01f, 2.35162094e-01f, -1.13122001e-01f, -1.89912379e-01f, 2.72296995e-01f, 2.88469821e-01f, 1.07273176e-01f, 2.38236561e-01f, 1.71604261e-01f, 1.60796121e-01f,
  4.60005730e-01f, 3.52638006e-01f, 1.00854732e-01f, 5.87260276e-02f, -1.08472414e-01f, 3.14866871e-01f, 3.50552201e-01f, 2.23228171e-01f, 3.27723175e-02f, 7.31761083e-02f,
  4.59623039e-01f, 4.77327526e-01f, 2.60875165e-01f, -4.50828820e-01f, 1.34587422e-01f, 1.82126850e-01f, 1.06372461e-01f, -1.34162679e-01f, -8.43835175e-02f, 5.39593585e-02f,
  2.43950367e-01f, 1.69157743e-01f, 2.81383656e-02f, 1.09612413e-01f, 1.49050042e-01f, -6.58665225e-02f, 2.06848055e-01f, 1.52697474e-01f, 1.20189413e-01f, 1.42344743e-01f,
  2.11707622e-01f, 2.68756181e-01f, 1.92227229e-01f, 4.72479910e-01f, 3.69883925e-02f, -7.40208030e-02f, 2.30843276e-02f, 2.12184563e-01f, -1.88359976e-01f, -1.05553858e-01f,
  4.44535255e-01f, -7.54350051e-02f, 4.87361014e-01f, 4.75583911e-01f, -1.21304967e-01f, 3.25519919e-01f, 3.04713517e-01f, -5.90960234e-02f, 3.62121254e-01f, 1.11179665e-01f,
  9.12380442e-02f, -2.89237942e-03f, 3.71468440e-02f, 2.67770905e-02f, 5.78441434e-02f, -3.63612443e-01f, -2.92612225e-01f, -1.69410899e-01f, 2.55210727e-01f, 1.24373890e-01f,
  8.08414072e-02f, 1.18333973e-01f, 3.61528963e-01f, -4.48650792e-02f, 1.70375973e-01f, -3.95963490e-02f, -2.34486639e-01f, -2.32861802e-01f, 1.57060221e-01f, 2.21184492e-01f,
  1.30920768e-01f, -5.51729603e-03f, 2.67085165e-01f, -2.10438594e-01f, 3.00003588e-01f, 2.68139780e-01f, -6.75482154e-02f, -4.86961417e-02f, 9.99614894e-02f, 8.73004124e-02f,
  -8.17194134e-02f, -2.28095263e-01f, -1.07021295e-01f, -1.85539186e-01f, 1.87988639e-01f, 1.06315456e-01f, -7.15771019e-02f, -9.14625674e-02f, 4.85917777e-02f, 1.45809967e-02f,
  1.00404687e-01f, -1.02214485e-01f, 2.76788712e-01f, 2.24476323e-01f, 1.67517900e-01f, -7.83113092e-02f, 1.38613805e-01f, 1.37853637e-01f, -2.28048429e-01f, -3.08147550e-01f,
  -1.21619083e-01f, 2.33338252e-01f, -6.71173483e-02f, -2.21135262e-02f, 2.74047732e-01f, -2.94776022e-01f, 3.81908342e-02f, 3.58935326e-01f, 2.33648792e-02f, 1.93201169e-01f,
  4.00690675e-01f, -2.02284634e-01f, -1.64742574e-01f, -1.18655875e-01f, -1.03818864e-01f, -3.07006836e-01f, 1.52139785e-02f, 1.93978235e-01f, 1.16080664e-04f, -1.06888071e-01f,
  -1.75045937e-01f, 1.64674520e-01f, -1.95357185e-02f, 1.88711241e-01f, 1.08989924e-01f, 9.01701301e-03f, 3.03018223e-02f, 2.62433320e-01f, -1.77742481e-01f, 1.14886999e-01f,
  -1.52503625e-01f, 1.06111325e-01f, -6.80265501e-02f, -1.20119333e-01f, -3.34031463e-01f, 1.64988905e-01f, 1.61494851e-01f, -1.02202833e-01f, -6.38880804e-02f, 6.83706254e-02f,
  -1.68124303e-01f, 3.83596629e-01f, 1.13116257e-01f, 3.76592539e-02f, 2.86746114e-01f, 3.03056866e-01f, 3.60871404e-01f, 2.29280785e-01f, 7.94785023e-02f, -1.63281977e-01f,
  1.80860162e-01f, 2.07207739e-01f, -2.86697835e-01f, -4.04106975e-02f, 1.17303342e-01f, 8.38463977e-02f, -4.07253094e-02f, 1.21387951e-02f, 1.50016189e-01f, 1.54602855e-01f,
  -2.45724425e-01f, -3.65801007e-02f, 2.41704196e-01f, 2.05163732e-01f, 7.69059509e-02f, -1.86765373e-01f, 2.30305374e-01f, 2.07109869e-01f, -1.74269661e-01f, 1.79678932e-01f,
  2.04696611e-01f, -1.85583159e-01f, -1.15697354e-01f, -1.30421072e-01f, -1.85279503e-01f, 1.95149571e-01f, 5.34092002e-02f, 2.89249957e-01f, 1.59610987e-01f, 2.05925018e-01f,
  3.47478479e-01f, 1.38406560e-01f, 3.01803052e-01f, 2.77990043e-01f, 4.60759997e-01f, 3.54064330e-02f, 2.95181483e-01f, 5.17236963e-02f, 1.88634709e-01f, 2.54442453e-01f,
  3.43801022e-01f, 1.78646222e-01f, 3.94424796e-01f, -6.46211803e-02f, -2.74712324e-01f, -1.24243245e-01f, 5.55702485e-02f, 5.48862815e-01f, 3.22437763e-01f, 3.36622596e-02f,
  1.82238877e-01f, -1.64072365e-01f, 1.01093516e-01f, -5.30018657e-02f, -8.82177874e-02f, -3.36268783e-01f, 1.37210801e-01f, -6.69060871e-02f, -4.87103343e-01f, 1.69101477e-01f,
  -1.36738613e-01f, 1.46099105e-01f, 8.86635855e-03f, 3.46962512e-02f, -1.42036676e-01f, -1.64466932e-01f, -1.07103787e-01f, -1.25001639e-01f, 1.19757570e-01f, 1.24450937e-01f,
  4.68879230e-02f, 1.10839047e-01f, 2.00433820e-01f, 2.94187486e-01f, 2.52353936e-01f, 4.59380597e-01f, 1.42764986e-01f, 3.39572728e-02f, -1.06184795e-01f, 7.88495168e-02f,
  -1.04220890e-01f, 2.12022021e-01f, 1.28172129e-01f, 1.28536731e-01f, 3.87133330e-01f, 4.35571611e-01f, 1.92883193e-01f, 2.78218240e-02f, -3.07482686e-02f, 2.02568829e-01f,
  4.77146000e-01f, -3.11086383e-02f, 7.64740482e-02f, 1.66277997e-02f, 2.41669104e-01f, 5.09731062e-02f, 1.11635774e-01f, 2.93840226e-02f, -2.38395303e-01f, -2.31621429e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  4.50160839e-02f, 2.42180452e-01f, -5.06863445e-02f, 1.48751169e-01f, 1.25190377e-01f, 8.27435106e-02f, 8.48155767e-02f, 2.47080699e-02f, 2.20114514e-01f, 2.20191821e-01f,
  1.38687849e-01f, -1.84895494e-03f, 1.66992426e-01f, -3.80651839e-02f, 2.54515946e-01f, 6.89355657e-02f, 5.98969078e-03f, 2.81154752e-01f, 1.70476809e-01f, 1.62457749e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  8.41581002e-02f, -3.30243781e-02f, 2.11767823e-01f, -5.97676858e-02f, 5.14142625e-02f, 2.70069778e-01f, 1.34488419e-01f, 9.41104814e-02f, -9.56714377e-02f, -3.42488974e-01f,
  2.11079702e-01f, 2.16156363e-01f, -1.87957272e-01f, -3.06219727e-01f, 5.01258671e-02f, -1.36897326e-01f, -7.10305050e-02f, -1.59329787e-01f, -3.57760377e-02f, -1.08837135e-01f,
  1.23244941e-01f, -5.38428053e-02f, 2.46354222e-01f, -1.37566492e-01f, 3.98297757e-02f, -1.73199568e-02f, 2.31928378e-01f, 1.61191225e-01f, 9.35491920e-03f, 1.24010816e-01f,
  2.38274574e-01f, -8.84362981e-02f, -9.47486609e-02f, -2.70187715e-03f, -3.18858437e-02f, -1.62753329e-01f, -9.44308937e-02f, -1.08646281e-01f, 1.17904050e-02f, -7.38758519e-02f,
  -2.52822824e-02f, -1.62772406e-02f, 8.70262235e-02f, -2.44392067e-01f, 2.13688433e-01f, -2.46365145e-02f, -7.66626224e-02f, -9.64074060e-02f, 2.16246456e-01f, 9.81730223e-02f,
  -1.20415419e-01f, 1.10982530e-01f, 2.47533824e-02f, 2.26864502e-01f, -1.75951138e-01f, 1.08150868e-02f, 1.09646134e-01f, -2.19105840e-01f, 7.48733431e-03f, -4.36076932e-02f,
  -1.61447927e-01f, 1.46255597e-01f, -6.71137795e-02f, 7.01864734e-02f, -1.33680582e-01f, -7.32052559e-03f, -3.60993594e-02f, 1.21346302e-01f, 6.00417592e-02f, 1.99933186e-01f,
  2.19939828e-01f, 1.31778941e-01f, 5.83997741e-02f, 4.09898870e-02f, -2.02688247e-01f, 1.13356851e-01f, -1.06153078e-01f, -2.11935818e-01f, 1.09018281e-01f, -5.30501381e-02f,
  1.58824474e-02f, -1.93097547e-01f, 1.87559798e-01f, -6.07293565e-03f, -8.11677426e-02f, -4.86353599e-02f, 1.47339433e-01f, -6.38161078e-02f, 5.05125932e-02f, 1.08848706e-01f,
  1.56357870e-01f, 1.97526947e-01f, 7.97506347e-02f, -2.12608755e-01f, 1.83971241e-01f, -2.76589356e-02f, 3.10478061e-01f, -8.22617412e-02f, 9.03393850e-02f, -6.90736100e-02f,
  4.16662195e-04f, 8.79584849e-02f, 3.59211564e-02f, 6.09751977e-02f, 1.20753065e-01f, 6.34380504e-02f, 1.81777388e-01f, -1.50506813e-02f, -5.57796359e-02f, 1.23007365e-01f,
  -2.14619458e-01f, -1.54755369e-01f, -6.13555871e-02f, -1.81574240e-01f, -1.88409120e-01f, -1.52092353e-01f, 1.73174605e-01f, 9.73250493e-02f, 2.03930348e-01f, -1.31517202e-01f,
  3.75766195e-02f, -9.67429504e-02f, 2.46112630e-01f, -7.18988329e-02f, -3.10507834e-01f, 1.15407743e-01f, 2.05901682e-01f, -3.18697095e-02f, -1.48168027e-01f, 1.02530466e-02f,
  -1.24148093e-01f, -7.68350735e-02f, -8.75279531e-02f, -1.43460631e-01f, -1.63531408e-01f, -1.21720344e-01f, 1.13458112e-01f, -3.55489179e-02f, -1.63080305e-01f, 4.39811759e-02f,
  2.04393834e-01f, 5.19089885e-02f, 7.59774894e-02f, -2.04212517e-01f, -1.50720134e-01f, 3.04617375e-01f, 2.77756393e-01f, -3.10868863e-02f, -8.84072762e-03f, -2.13098854e-01f,
  -1.66238055e-01f, 1.69420332e-01f, -2.66831458e-01f, -7.60481507e-02f, -1.34052604e-01f, -1.85514856e-02f, 2.71662265e-01f, 3.83890718e-02f, -2.67186016e-01f, 1.12713119e-02f,
  1.17919378e-01f, -1.39069885e-01f, 4.37135622e-03f, 1.40883490e-01f, -1.22538514e-01f, 6.99636787e-02f, 9.88205820e-02f, -2.26467133e-01f, -2.42485851e-01f, 4.57990021e-02f,
  -2.81444509e-02f, 2.01355498e-02f, -1.29220486e-01f, -2.40748748e-01f, 3.09971154e-01f, -8.71440768e-02f, -2.40903512e-01f, -2.51132190e-01f, 1.67072434e-02f, 2.64848918e-01f,
  3.21337581e-02f, -4.26904708e-02f, -2.12726071e-02f, 1.53859213e-01f, -2.01863527e-01f, -8.00021067e-02f, -7.81195462e-02f, 6.20891862e-02f, 2.79074460e-01f, 1.43434912e-01f,
  3.97981256e-02f, -1.72065049e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.87782511e-01f, 8.02449286e-02f, 3.11202630e-02f, -3.00006688e-01f, -5.34118116e-02f, -1.60958901e-01f, -1.18773408e-01f, -3.82877551e-02f, -1.80856541e-01f, 7.25615770e-02f,
  3.31626050e-02f, -1.25735059e-01f, -9.13981274e-02f, 2.56848603e-01f, 1.84962582e-02f, 1.23478800e-01f, 2.48450264e-01f, 3.65717232e-01f, 4.32948656e-02f, 5.36114573e-02f,
  -2.42531970e-01f, 3.61786872e-01f, -1.43478572e-01f, -3.20488274e-01f, 3.76825988e-01f, 5.39036207e-02f, 9.42658037e-02f, -1.67277027e-02f, -4.31948304e-01f, 1.86906576e-01f,
  -2.98968673e-01f, 3.07887673e-01f, 3.54476482e-01f, 2.38317356e-01f, 3.98833603e-02f, 3.33892405e-01f, 4.56515223e-01f, 1.45904630e-01f, -1.15578793e-01f, 1.13367140e-01f,
  2.02944472e-01f, -1.79437399e-01f, 3.76438908e-02f, -9.92264077e-02f, 1.80494227e-02f, 2.52915502e-01f, -1.65859774e-01f, 4.61245775e-01f, 8.46288353e-02f, -1.36139780e-01f,
  -5.24602905e-02f, -1.29609689e-01f, 1.93846628e-01f, -1.65269777e-01f, 3.03489894e-01f, -1.39720500e-01f, 3.92109528e-03f, -3.10585856e-01f, -4.75834217e-03f, 5.66070825e-02f,
  2.51326580e-02f, -5.72366826e-03f, 4.24494624e-01f, -2.96230853e-01f, 1.71064332e-01f, 1.77602261e-01f, 1.41270354e-01f, 2.38395095e-01f, -6.73696119e-03f, 1.81884781e-01f,
  1.42744094e-01f, 2.50693202e-01f, -4.34229821e-02f, -2.79397339e-01f, 2.30270192e-01f, 3.13246936e-01f, -1.26373932e-01f, -6.53161034e-02f, 9.65819880e-02f, 8.78674462e-02f,
  -1.26755275e-02f, -2.55070180e-01f, 3.50406498e-01f, -1.64068818e-01f, -2.07151193e-02f, -1.31477132e-01f, 2.62077272e-01f, -1.53490245e-01f, 1.48769349e-01f, 5.00163496e-01f,
  2.94393331e-01f, 4.04880166e-01f, 9.24102366e-02f, 1.03222169e-01f, 4.25409734e-01f, 3.32055062e-01f, 5.44225238e-02f, 9.42659080e-02f, 1.71095021e-02f, 2.81985588e-02f,
  8.71056691e-02f, -1.63468458e-02f, -3.47725064e-01f, -1.64786987e-02f, 3.14154387e-01f, -1.82151660e-01f, -1.08262151e-01f, -5.98729448e-03f, 5.62751405e-02f, 4.92128760e-01f,
  -3.17240596e-01f, 1.75640583e-01f, 1.45449296e-01f, 4.45373207e-01f, 2.85575330e-01f, -2.74522603e-02f, -7.34701902e-02f, -2.09325582e-01f, 1.82075307e-01f, 1.39744300e-02f,
  -3.66911516e-02f, -1.33892357e-01f, 8.37578177e-02f, 5.67120835e-02f, -1.38169244e-01f, 2.87828714e-01f, 2.22636499e-02f, -1.45780832e-01f, 2.79746115e-01f, 1.37346998e-01f,
  2.12079972e-01f, 1.45292267e-01f, 4.85508144e-01f, 1.20343948e-02f, 1.47521213e-01f, -2.39687692e-02f, -3.44055854e-02f, -1.29089013e-01f, -4.40631472e-02f, -2.58753628e-01f,
  7.76367486e-02f, 8.92662853e-02f, -8.57675672e-02f, 4.74098057e-01f, 7.13712126e-02f, -5.58284111e-02f, -2.31634393e-01f, -3.63351442e-02f, 4.52657521e-01f, -7.12746307e-02f,
  8.31799731e-02f, 1.30460963e-01f, -2.81184670e-02f, -1.65142283e-01f, -1.17433280e-01f, -2.90709674e-01f, -4.67230827e-02f, 3.35325181e-01f, 2.07824290e-01f, -1.53000981e-01f,
  1.76494241e-01f, 1.41611978e-01f, 7.91213885e-02f, 1.97676226e-01f, 1.65050164e-01f, 2.08616138e-01f, 4.48881090e-02f, 2.62718946e-01f, 2.14527905e-01f, 1.26676522e-02f,
  2.58864373e-01f, 1.20693676e-01f, 6.88516423e-02f, 1.91466808e-01f, -2.16732085e-01f, 5.38893268e-02f, -2.63697747e-03f, -2.90735811e-01f, 2.75458116e-02f, -1.44329339e-01f,
  1.87754914e-01f, 3.87203209e-02f, 2.44195521e-01f, -1.66137457e-01f, 3.33795696e-01f, 9.86542404e-02f, 4.00369763e-01f, 3.42748970e-01f, -2.42199600e-01f, -1.45599470e-01f,
  4.31635708e-01f, 2.54016370e-02f, -2.19628334e-01f, 7.78730959e-02f, 4.38949354e-02f, 1.62721545e-01f, -8.82408172e-02f, 2.86223050e-02f, 2.73368359e-01f, -5.66235930e-02f,
  -2.20476419e-01f, -1.32116556e-01f, -1.81527212e-01f, 2.74642020e-01f, 1.36707872e-01f, 2.91609648e-03f, -2.29604632e-01f, -1.76131397e-01f, -2.04239681e-01f, -2.95301884e-01f,
  3.66480872e-02f, -2.79674262e-01f, 1.32334590e-01f, 1.90308154e-01f, -1.29777953e-01f, 8.65442455e-02f, 1.92487344e-01f, 5.10353863e-01f, 2.18932763e-01f, 9.83160827e-03f,
  2.75787294e-01f, -4.71791427e-04f, 5.50346486e-02f, 4.48663414e-01f, -6.43686764e-03f, 1.05655462e-01f, -8.29213783e-02f, 1.51662216e-01f, 1.07240938e-01f, -1.95938777e-02f,
  -1.52866036e-01f, 1.18813552e-02f, 3.28601658e-01f, 9.48880985e-02f, -1.32453650e-01f, 1.51292294e-01f, 1.73773959e-01f, 3.73929024e-01f, -3.44602704e-01f, -1.51621290e-02f,
  3.06054857e-02f, 3.72490555e-01f, 4.39335614e-01f, -8.19973275e-02f, -3.40068489e-01f, -3.55762362e-01f, 8.60406607e-02f, 5.79877943e-02f, -1.06723964e-01f, 1.15081586e-01f,
  1.14306122e-01f, 2.84916610e-01f, -1.53304348e-02f, -1.99436024e-01f, -1.39171883e-01f, 1.79205433e-01f, -2.42089629e-01f, 1.06752463e-01f, -6.40442371e-02f, 5.77958785e-02f,
  -1.43923596e-01f, -4.32049856e-02f, 1.58165827e-01f, -5.30602559e-02f, 1.24149099e-01f, 8.98530409e-02f, 5.94905466e-02f, 1.92142546e-01f, 3.88894975e-01f, 1.85098305e-01f,
  -7.91138262e-02f, -1.53425783e-01f, -2.95487307e-02f, -2.67155677e-01f, -3.74646336e-02f, -1.82990462e-01f, 3.18556249e-01f, 2.98404604e-01f, -7.21213175e-03f, 5.58582544e-02f,
  4.23698157e-01f, 6.21647835e-01f, 1.12587959e-01f, 1.66859433e-01f, 1.61698520e-01f, 6.18402064e-02f, -1.49372950e-01f, 3.45542014e-01f, 2.31015354e-01f, 5.20921610e-02f,
  1.52350729e-02f, 2.30788499e-01f, 1.33550167e-01f, 1.66585907e-01f, -3.42713803e-01f, 1.03563070e-01f, 4.17132735e-01f, 8.24844986e-02f, 3.06629334e-02f, 1.09509468e-01f,
  -2.76915599e-02f, 4.72817272e-01f, -7.11415261e-02f, -2.55706813e-02f, 1.32746309e-01f, 1.60620451e-01f, 5.38892984e-01f, -8.87464881e-02f, -2.88585722e-01f, -3.79597872e-01f,
  1.93622425e-01f, 3.77299041e-02f, -1.07064508e-01f, 4.63243993e-03f, 1.53213635e-01f, 2.68445462e-01f, 1.16637491e-01f, -1.37102023e-01f, 4.12081853e-02f, -2.06551164e-01f,
  7.78096169e-02f, 1.68828368e-01f, -6.06882982e-02f, 2.34915689e-01f, 9.71321389e-02f, 1.98328093e-01f, 1.34185359e-01f, -1.81794971e-01f, -6.66502416e-02f, -2.30980784e-01f,
  -3.71620566e-01f, 2.43448298e-02f, 4.07355994e-01f, 3.22022259e-01f, -1.11737110e-01f, 1.76989675e-01f, -1.71954185e-01f, 1.67834401e-01f, -3.79660130e-02f, -8.38415772e-02f,
  5.35190523e-01f, 6.12749532e-02f, -1.29675195e-01f, 3.15518439e-01f, -2.70123154e-01f, 4.23916467e-02f, -9.99620855e-02f, -2.79608458e-01f, 2.18528569e-01f, 4.01837826e-01f,
  -1.23406164e-01f, 1.02886587e-01f, -1.48010671e-01f, 2.07482241e-02f, -6.36764839e-02f, -7.04274997e-02f, -1.09214634e-01f, 6.19962905e-03f, -1.79238603e-01f, -8.30442458e-02f,
  3.96477073e-01f, 7.89025216e-05f, -1.72017172e-01f, -6.24563964e-03f, 2.93911010e-01f, 6.34339631e-01f, -2.81912953e-01f, -1.29030645e-01f, 1.32454010e-02f, 2.05163002e-01f,
  2.15303063e-01f, -1.29753157e-01f, 6.21554703e-02f, 5.89828156e-02f, -1.14819914e-01f, -1.01554982e-01f, 9.04526636e-02f, 7.38906488e-02f, 4.10491228e-02f, 2.04758141e-02f,
  -1.88931286e-01f, 9.32746977e-02f, -2.39389405e-01f, -2.90438123e-02f, -1.58878602e-02f, -8.87660384e-02f, 5.89916147e-02f, -2.14771047e-01f, 2.96534155e-03f, -2.23118633e-01f,
  -1.11687630e-01f, -9.96084660e-02f, -1.29990965e-01f, 2.37828493e-02f, 2.95858324e-01f, -2.29792356e-01f, -2.70830780e-01f, 1.12933934e-01f, 3.31594527e-01f, 4.71915007e-02f,
  3.33251297e-01f, 2.10067272e-01f, 2.28455558e-01f, 2.74139315e-01f, -1.46426648e-01f, 1.74445450e-01f, -1.76872224e-01f, -2.28532597e-01f, 3.12106758e-01f, -1.58923179e-01f,
  -7.78196976e-02f, -1.05808645e-01f, 7.55105168e-02f, 6.04881085e-02f, -6.10594749e-02f, 2.39918828e-01f, 8.20204150e-03f, 2.16296420e-01f, 1.87505364e-01f, -3.36141996e-02f,
  1.35465696e-01f, 6.18823431e-02f, -2.44965330e-02f, 1.07091986e-01f, 3.15756910e-02f, -1.94239751e-01f, 1.38843894e-01f, -1.81662917e-01f, -1.85792029e-01f, 1.58832163e-01f,
  -1.50529951e-01f, 2.32927039e-01f, 2.83921868e-01f, -5.73059469e-02f, -2.11822569e-01f, -1.05569087e-01f, 5.03981337e-02f, 1.31235555e-01f, 1.16332863e-02f, -2.72806227e-01f,
  2.43758738e-01f, -1.13213852e-01f, 1.02436334e-01f, -1.99254900e-01f, -2.82868713e-01f, 1.83108747e-01f, 1.05391584e-01f, 6.67736074e-03f, 1.67991385e-01f, 1.94556877e-01f,
  2.13712946e-01f, 1.55694813e-01f, 2.07828790e-01f, 1.06585033e-01f, 4.17300820e-01f, -1.97479576e-01f, -5.26579022e-01f, -2.56792039e-01f, -2.48307496e-01f, -2.31719762e-01f,
  1.10888638e-01f, -2.32311621e-01f, -1.44002363e-01f, 4.30027962e-01f, 2.02090114e-01f, 1.24795675e-01f, 3.33360769e-02f, -2.76987374e-01f, 4.91413087e-01f, 1.68095216e-01f,
  -2.57341385e-01f, 1.84293255e-01f, 1.11367248e-01f, -1.45332590e-02f, -5.27045727e-02f, -1.99868187e-01f, 2.65119702e-01f, 3.57335955e-01f, -1.47622302e-01f, 3.15166861e-01f,
  1.68375313e-01f, -1.80557165e-02f, -5.54328226e-02f, 5.74746914e-02f, 1.20002531e-01f, -6.50440082e-02f, -5.10260612e-02f, 1.24260366e-01f, 3.21783274e-01f, 1.02747595e-02f,
  3.39508057e-01f, 5.86180799e-02f, 1.53196573e-01f, 4.27773029e-01f, -2.56627947e-01f, -2.26161666e-02f, -5.32980189e-02f, -2.22828880e-01f, 2.19162949e-03f, -8.33157152e-02f,
  1.79303423e-01f, -1.17851757e-01f, 6.26936629e-02f, -1.74177244e-01f, 3.80731761e-01f, 1.57641187e-01f, 3.41909915e-01f, 3.90422553e-01f, -1.79205179e-01f, -3.71971950e-02f,
  1.69150382e-01f, 1.15544990e-01f, -4.43790719e-04f, -1.63309261e-01f, -6.45176396e-02f, -1.61463454e-01f, 1.70091167e-01f, -2.03662977e-01f, -1.17824934e-01f, -7.25831613e-02f,
  1.86926976e-01f, -3.28604970e-03f, -8.93889926e-03f, -1.10033132e-01f, 1.97458431e-01f, 4.24455166e-01f, -2.15659946e-01f, 1.32122235e-02f, 2.04568759e-01f, 5.22063673e-01f,
  3.13614085e-02f, -8.05717781e-02f, 2.05350533e-01f, 1.26344860e-01f, -1.30696565e-01f, 1.66197896e-01f, 3.63929644e-02f, -2.37877309e-01f, -1.63366701e-02f, -2.86918879e-01f,
  -4.66254763e-02f, 4.42839563e-01f, -3.01002651e-01f, 2.58100890e-02f, 2.60627627e-01f, 1.28738374e-01f, 1.80980533e-01f, 5.84334284e-02f, 2.32255027e-01f, 1.78223342e-01f,
  1.72836274e-01f, 2.91001499e-01f, 6.50704652e-02f, -1.51109397e-01f, 2.48977870e-01f, -1.01055272e-01f, -2.88776577e-01f, -1.28442392e-01f, -6.93990216e-02f, 2.07023248e-01f,
  9.10716578e-02f, -2.35875234e-01f, -1.25494510e-01f, -6.95571154e-02f, 1.35346819e-02f, 2.40548879e-01f, 2.51241803e-01f, -2.80618787e-01f, 4.70960438e-01f, 2.01943487e-01f,
  2.54654050e-01f, 2.27719203e-01f, -2.28851050e-01f, -4.86840028e-03f, 5.63220739e-01f, 5.16211987e-02f, 2.94615507e-01f, 2.19600201e-01f, 1.84793755e-01f, 1.33330286e-01f,
  2.93003023e-01f, 1.60756633e-01f, -2.64796138e-01f, 2.30655402e-01f, 3.64430100e-01f, -1.09842092e-01f, -1.15470402e-01f, -5.03506884e-02f, -1.82168260e-01f, 3.41104150e-01f,
  -6.78689182e-02f, 1.39402077e-01f, 1.53138712e-01f, 1.07596494e-01f, 1.80833772e-01f, -6.84012994e-02f, -8.75430182e-02f, -3.14439267e-01f, 3.84515047e-01f, -1.59746587e-01f,
  -4.71369363e-02f, -1.64787158e-01f, 2.10725352e-01f, 1.58461958e-01f, -1.96835935e-01f, 1.22943811e-01f, 2.92355835e-01f, -3.32074314e-01f, -4.03411053e-02f, 1.11949900e-02f,
  1.91677406e-01f, -2.27993488e-01f, 1.60814181e-01f, -1.98416635e-01f, -1.15317460e-02f, -6.75778389e-02f, -1.77893177e-01f, -5.81125319e-02f, 4.13938224e-01f, -3.00213069e-01f,
  -7.72639662e-02f, -3.94711271e-02f, 9.79616493e-02f, 3.90737057e-01f, 2.75000453e-01f, 1.92270339e-01f, -9.59324911e-02f, 4.95761409e-02f, 2.47980610e-01f, 5.19252956e-01f,
  -1.70510814e-01f, -3.02814007e-01f, 5.30995965e-01f, -4.90736449e-03f, 8.02684054e-02f, -1.24829404e-01f, -1.27424568e-01f, 3.22017699e-01f, 2.78035644e-02f, 3.11742812e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -9.21331570e-02f, 1.21718295e-01f, 2.65619218e-01f, 2.14065015e-01f, 4.88042869e-02f, 2.20229160e-02f, 2.82655172e-02f, 2.28994619e-03f, 1.23266675e-01f, 2.39357233e-01f,
  2.97828158e-03f, -1.08876273e-01f, -6.17204197e-02f, 1.47346631e-01f, 2.50943631e-01f, 4.43526171e-03f, -5.26028760e-02f, 8.97393301e-02f, 1.44661173e-01f, 1.48384899e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.93539852e-01f, -7.25554675e-02f, -7.33807161e-02f, 1.04960561e-01f, -1.64820757e-02f, -2.62658801e-02f, -2.86847591e-01f, 1.30517629e-03f, -1.18618481e-01f, -1.74476728e-01f,
  1.78706974e-01f, -1.17894270e-01f, 7.22035691e-02f, -2.32178673e-01f, -1.43204033e-01f, 5.35977818e-02f, -2.22746372e-01f, 9.66471732e-02f, 4.69811857e-02f, 1.16781019e-01f,
  7.80907199e-02f, -5.91267683e-02f, -1.26888275e-01f, 1.91605479e-01f, 2.95688715e-02f, 1.78414006e-02f, 3.27180838e-03f, -4.67046350e-02f, 1.61918357e-01f, -2.74052292e-01f,
  1.29250521e-02f, 7.27557242e-02f, 2.46269535e-02f, -1.08490348e-01f, 3.51516753e-02f, -1.67360678e-01f, -1.34299159e-01f, -9.89289880e-02f, 1.43395886e-02f, 5.61549366e-02f,
  -1.29408002e-01f, 9.65922102e-02f, 2.53426015e-01f, 1.40072644e-01f, 1.37178108e-01f, -1.82690039e-01f, 4.50184494e-02f, 5.40000387e-02f, -1.58861428e-01f, 1.55339658e-01f,
  1.00651085e-01f, -1.34371847e-01f, 1.60969600e-01f, -4.03704774e-03f, -1.04507998e-01f, -3.76414508e-02f, -4.54478059e-03f, -9.55371782e-02f, -4.72296402e-02f, -9.63191502e-03f,
  -9.28363428e-02f, -8.26186035e-03f, -1.39786035e-01f, -9.20625627e-02f, 3.84359732e-02f, 1.39957681e-01f, -1.08738162e-01f, 3.43425609e-02f, -1.28917769e-01f, -5.29790930e-02f,
  -6.10664263e-02f, 1.20082885e-01f, -4.25916947e-02f, -1.26486406e-01f, 1.59266531e-01f, 9.95958894e-02f, -1.98644742e-01f, -6.94579557e-02f, -1.20095186e-01f, -6.61725923e-02f,
  5.11344038e-02f, -2.31531829e-01f, 1.84412976e-03f, -1.80618256e-01f, -2.87100524e-02f, -1.21805929e-01f, 1.07780762e-01f, 1.57416254e-01f, 4.35093930e-03f, 4.30649705e-02f,
  -1.64047882e-01f, -2.38230363e-01f, 4.64508943e-02f, -1.73423871e-01f, -8.25752704e-06f, -1.86269164e-01f, 9.18746963e-02f, -1.18924990e-01f, -7.94102103e-02f, -1.61518708e-01f,
  1.86248094e-01f, -1.83849409e-02f, -1.56131089e-02f, -4.45064018e-03f, 6.18483871e-02f, 2.46895105e-01f, -1.71857432e-01f, -1.15408853e-01f, 1.45024091e-01f, -5.97164109e-02f,
  -6.10804968e-02f, -9.77502838e-02f, -4.67555299e-02f, 1.22182019e-01f, -9.92652178e-02f, -6.62745014e-02f, -1.97219685e-01f, 7.48342052e-02f, 5.18399961e-02f, -1.14388861e-01f,
  1.99687406e-01f, 1.33763269e-01f, -3.46049410e-03f, -6.50288463e-02f, 7.30504319e-02f, 6.72092214e-02f, 1.19278662e-01f, -2.14505964e-03f, 1.79233506e-01f, -3.91831510e-02f,
  -1.97421983e-02f, -2.31025163e-02f, 1.74199551e-01f, -4.13956307e-02f, -1.86138779e-01f, 4.90416540e-03f, -5.60368411e-03f, 1.68001562e-01f, -2.31886096e-02f, -3.18705201e-01f,
  2.28749186e-01f, 4.43584062e-02f, 9.94097590e-02f, 1.87043056e-01f, 6.90527484e-02f, -8.66675749e-02f, 4.22793180e-02f, 2.00152978e-01f, 1.75998956e-01f, 7.08832666e-02f,
  -1.75094336e-01f, 1.79255813e-01f, 3.47886324e-01f, 2.05980629e-01f, -1.62060097e-01f, 2.71624863e-01f, 2.63327695e-02f, -8.49062428e-02f, 6.42041415e-02f, 1.68745041e-01f,
  -3.11481878e-02f, -3.52023430e-02f, 1.08176386e-02f, -2.02283427e-01f, -3.23251933e-02f, -1.88258931e-01f, 1.97198212e-01f, -1.85028180e-01f, 5.21755703e-02f, 3.01664680e-01f,
  -1.85588047e-01f, -1.86235547e-01f, -7.63197616e-02f, -7.40909856e-03f, 1.03775650e-01f, -5.25319390e-02f, -2.50643551e-01f, 3.73119712e-02f, -9.72249955e-02f, -1.46619111e-01f,
  -1.25544297e-03f, 6.02671038e-03f, -1.84802309e-01f, -1.89966992e-01f, -3.29968147e-02f, 5.93652800e-02f, -1.86538801e-01f, 1.08019963e-01f, -1.99185401e-01f, -4.34376561e-04f,
  1.23889618e-01f, -2.74272591e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -7.11175799e-02f, 2.96912827e-02f, -2.27907121e-01f, 6.30965903e-02f, -6.76036701e-02f, -3.78255039e-01f, -1.52523711e-01f, 1.44252777e-01f, 1.17894197e-02f, 2.42537409e-01f,
  3.69379297e-02f, -2.56077290e-01f, 2.26960748e-01f, -1.54907152e-01f, 1.51554942e-01f, 4.15855110e-01f, -5.31886853e-02f, 4.07906510e-02f, 1.80502515e-02f, 3.15329492e-01f,
  1.17531382e-01f, 2.87435770e-01f, 6.72049001e-02f, 5.94708085e-01f, 1.60653695e-01f, 3.46681364e-02f, -2.53860176e-01f, 4.16695505e-01f, 2.74883956e-01f, -1.53597623e-01f,
  1.50759920e-01f, 1.31341502e-01f, 5.66936731e-02f, 9.72481221e-02f, -9.91452113e-02f, 1.48527417e-02f, 8.45902637e-02f, -1.17217936e-02f, 4.46624793e-02f, 1.69321954e-01f,
  -1.39401287e-01f, 2.32307866e-01f, -2.74187833e-01f, -3.26224677e-02f, -5.91198616e-02f, -1.87210307e-01f, 2.21952498e-01f, -1.04598746e-01f, 1.22553512e-01f, 1.56915680e-01f,
  1.04076698e-01f, -3.33682209e-01f, 3.23080659e-01f, -1.72634423e-01f, 2.23994583e-01f, -3.68797407e-02f, 3.21483500e-02f, 8.74803588e-03f, 1.19921044e-01f, 2.43978024e-01f,
  5.31991161e-02f, 2.18008235e-01f, -2.99929172e-01f, 3.60021025e-01f, -1.91563174e-01f, -4.34329920e-02f, -1.35602877e-01f, -1.25815660e-01f, -2.45345179e-02f, -9.95372981e-02f,
  -1.78824335e-01f, 1.00997157e-01f, 1.97222941e-02f, -2.86148161e-01f, 1.97295994e-01f, 1.28764093e-01f, 5.68580627e-01f, -2.26661742e-01f, -6.68453425e-02f, 2.76345342e-01f,
  -1.21898681e-01f, -2.69161940e-01f, -1.15866490e-01f, 1.32930771e-01f, -2.24298269e-01f, 1.44992799e-01f, -2.40784988e-01f, 9.44106355e-02f, 3.87212634e-01f, 1.78008512e-01f,
  1.03808858e-01f, -1.05045669e-01f, 8.96942466e-02f, 1.75432488e-02f, 9.71752033e-02f, 3.14063877e-01f, 2.13902667e-01f, -6.95024133e-02f, 1.19485736e-01f, 2.19095662e-01f,
  1.91414297e-01f, -1.83326527e-01f, 2.98421532e-01f, -7.80875534e-02f, 1.90193728e-01f, 3.99431854e-01f, -4.34330851e-01f, -1.39995396e-01f, 1.28518522e-01f, 2.44505137e-01f,
  9.81607363e-02f, 1.19302953e-02f, 2.41224408e-01f, 3.02842945e-01f, -2.20536500e-01f, -1.13858640e-01f, 1.07947495e-02f, 9.74273160e-02f, -1.61234647e-01f, -1.89030811e-01f,
  2.05940694e-01f, 7.03035071e-02f, -2.64554136e-02f, 2.70029247e-01f, 3.90612483e-02f, 3.39472264e-01f, 2.20071852e-01f, 3.68309557e-01f, 1.46144345e-01f, 2.99048852e-02f,
  -9.68548506e-02f, 2.92036474e-01f, 1.60730302e-01f, 1.25326440e-01f, -9.59595218e-02f, 1.12160973e-01f, -2.33956009e-01f, 9.10785124e-02f, -2.62973219e-01f, -1.82028651e-01f,
  -9.21118930e-02f, 4.23572868e-01f, -1.63600773e-01f, 2.92849094e-01f, 4.58544225e-01f, 1.14395572e-02f, -1.91914678e-01f, -1.18598990e-01f, -1.59460500e-01f, -9.19182152e-02f,
  2.79992998e-01f, 1.78153794e-02f, 6.19026758e-02f, 3.64785939e-01f, 2.64278471e-01f, -2.62614191e-02f, 3.32885206e-01f, 1.14389837e-01f, 2.70985752e-01f, 3.24943334e-01f,
  -3.21621060e-01f, -1.78132832e-01f, -2.46342868e-01f, -7.35980868e-02f, -2.65903063e-02f, -3.37324172e-01f, -2.42344990e-01f, 3.55724275e-01f, -9.02573988e-02f, 3.81728895e-02f,
  -2.94293612e-02f, -1.14436992e-01f, 4.24850971e-01f, -1.91654414e-01f, -3.52939576e-01f, 9.61564779e-02f, -6.61829934e-02f, 9.36183780e-02f, 2.26261606e-03f, -1.63263995e-02f,
  2.68598020e-01f, -2.48730630e-01f, -2.29591671e-02f, 3.16646814e-01f, 2.23225757e-01f, 2.05378920e-01f, -6.46689683e-02f, 1.48798168e-01f, 4.24559981e-01f, -2.02049967e-02f,
  -2.01075420e-01f, 4.58280712e-01f, 2.74108350e-01f, 1.44628257e-01f, -6.53261170e-02f, 1.79085396e-02f, 2.01900333e-01f, -5.66886701e-02f, 9.95299220e-02f, -6.82167569e-03f,
  -7.11081252e-02f, 2.83146530e-01f, -6.48548007e-02f, -2.94211041e-02f, -1.05012625e-01f, 3.41312647e-01f, -7.30876774e-02f, 3.27049851e-01f, 5.35835862e-01f, -1.06660210e-01f,
  -2.58502990e-01f, -1.35115609e-01f, -2.76785612e-01f, 1.08739078e-01f, 4.48882073e-01f, -1.88502118e-01f, -1.49012774e-01f, 4.60661612e-02f, 3.41939986e-01f, 2.50471607e-02f,
  2.28936449e-01f, -6.38901591e-02f, 3.23715508e-01f, -2.09824275e-02f, 2.89601386e-02f, 9.15141776e-02f, 7.73805529e-02f, -1.74735293e-01f, -1.59792200e-01f, 1.45018935e-01f,
  2.59888750e-02f, -1.32434601e-02f, -1.52362198e-01f, -2.90711701e-01f, 4.01661128e-01f, 3.41945976e-01f, -7.96472579e-02f, -1.55521989e-01f, 1.36384061e-02f, -1.08905204e-01f,
  1.92120820e-01f, -1.32536352e-01f, 2.94832379e-01f, -1.85318053e-01f, 2.28168592e-01f, -1.79261416e-01f, 3.95881087e-01f, -1.60632700e-01f, -2.35596433e-01f, -2.31857374e-01f,
  2.31838152e-01f, -2.39770919e-01f, 1.02064334e-01f, -3.22155654e-01f, -6.00766838e-02f, -5.97969703e-02f, -3.46275687e-01f, 3.29536162e-02f, 7.75087029e-02f, 1.39214158e-01f,
  1.03721648e-01f, 2.77159780e-01f, 1.98364541e-01f, 3.23925801e-02f, -2.03131661e-02f, 2.30688136e-03f, -2.23990858e-01f, -1.37790248e-01f, 2.01920554e-01f, -1.37860522e-01f,
  2.62066662e-01f, -2.29597494e-01f, -5.23095019e-02f, 2.95492917e-01f, -1.05112098e-01f, -1.96308419e-01f, -2.23110653e-02f, -4.22266334e-01f, -2.42950216e-01f, -3.02863002e-01f,
  9.22970250e-02f, 3.09739113e-01f, 2.12565392e-01f, 3.32047120e-02f, -2.97410727e-01f, 2.87454158e-01f, -3.46143752e-01f, 4.65377599e-01f, -1.03807878e-02f, 1.94824979e-01f,
  4.06964242e-01f, 1.24083877e-01f, 1.33177144e-02f, 2.18651474e-01f, 1.77170038e-02f, -2.69528151e-01f, 1.21930249e-01f, -2.75833547e-01f, 4.95636240e-02f, -1.53205693e-01f,
  -1.30843828e-02f, -1.98274940e-01f, 5.13906896e-01f, -2.48806208e-01f, 3.39322984e-02f, 2.42225945e-01f, 6.60119891e-01f, 1.71101406e-01f, 5.55735469e-01f, -1.14137985e-01f,
  2.58704931e-01f, -1.35598019e-01f, -1.52551264e-01f, -7.68245906e-02f, 5.13134897e-01f, 2.71013021e-01f, -1.20688416e-02f, 1.88888550e-01f, -3.55146587e-01f, 3.65359575e-01f,
  2.13136926e-01f, -4.61711036e-03f, -7.86322132e-02f, 8.57525691e-02f, 3.06840893e-02f, 1.03311017e-01f, -2.62147903e-01f, -7.97830373e-02f, -1.16742440e-01f, -1.89642891e-01f,
  1.37468100e-01f, -2.24544764e-01f, -3.97895187e-01f, 4.10066962e-01f, -2.26570755e-01f, 2.46108130e-01f, 1.59107462e-01f, 2.15032533e-01f, -1.08120643e-01f, 3.06303173e-01f,
  4.77764904e-02f, 3.59224081e-01f, 4.22922462e-01f, 2.60519207e-01f, -1.90637961e-01f, -1.45749152e-01f, 5.03139980e-02f, 1.30650565e-01f, 2.57996291e-01f, -2.21892133e-01f,
  2.00804640e-02f, 4.97335419e-02f, 1.21290572e-01f, 8.70959535e-02f, 1.59132570e-01f, 2.47920126e-01f, 7.31420144e-02f, 1.06286854e-02f, 5.68775348e-02f, -2.83877492e-01f,
  1.26478806e-01f, 3.29126656e-01f, -4.33370948e-01f, -3.60247195e-01f, -1.91444516e-01f, 4.68811601e-01f, 3.26518863e-01f, 3.47984552e-01f, 1.23544261e-01f, 2.47259438e-01f,
  -3.32891226e-01f, 2.68545121e-01f, -2.29279399e-01f, 4.49006259e-01f, 6.49440587e-02f, -1.57188475e-02f, 4.12810966e-02f, 2.84870833e-01f, -1.56820968e-01f, 9.64145362e-02f,
  9.31299478e-02f, 1.40508264e-01f, 5.37341833e-01f, 1.45412153e-02f, 1.22779436e-01f, -5.40965758e-02f, 2.43605301e-01f, 9.70727429e-02f, -3.38431895e-02f, -1.01557091e-01f,
  1.67914525e-01f, -1.28873006e-01f, 2.16342211e-01f, 1.49314135e-01f, -9.40855518e-02f, -2.72841454e-01f, -2.17948422e-01f, 1.15443461e-01f, 4.45619345e-01f, 8.29618499e-02f,
  -2.02676833e-01f, 4.43909496e-01f, 7.68344477e-02f, 4.22368944e-01f, 3.23228508e-01f, 3.79329771e-01f, -2.10605532e-01f, 3.80579494e-02f, -9.44109634e-02f, -1.14089020e-01f,
  -2.07547843e-01f, 4.06748861e-01f, -1.40896857e-01f, 3.20945382e-01f, 2.13386655e-01f, -2.28166759e-01f, 2.55615622e-01f, -4.90309298e-02f, 4.65816632e-02f, 4.28846106e-02f,
  -7.89236054e-02f, 4.01578471e-03f, 1.18959606e-01f, -2.01764882e-01f, 9.85499248e-02f, 4.46497463e-02f, -2.24368423e-01f, -6.52120560e-02f, -2.29764357e-01f, 2.70512074e-01f,
  1.87541425e-01f, 1.47515178e-01f, -8.91151503e-02f, 9.51948389e-02f, -2.21599936e-01f, 2.75304377e-01f, -1.52164027e-01f, 3.81356001e-01f, -2.15148315e-01f, 1.00864312e-02f,
  -1.16064891e-01f, -4.09054495e-02f, -2.86478043e-01f, 2.22436175e-01f, -1.72756836e-01f, 1.49937287e-01f, 4.01270807e-01f, -2.73279876e-01f, 1.36376083e-01f, -1.45817001e-03f,
  2.24186815e-02f, -2.93271989e-01f, -1.10640712e-01f, 7.31932446e-02f, -1.70361286e-03f, -5.02579659e-02f, -9.30341631e-02f, -3.47333014e-01f, 4.56738472e-01f, 5.58420181e-01f,
  3.08206171e-01f, -3.24059352e-02f, -3.34016383e-02f, 6.70336485e-02f, 4.28625271e-02f, -2.41969302e-01f, 1.54725015e-01f, 1.18377671e-01f, -4.82574068e-02f, -8.63130391e-02f,
  3.39478850e-01f, -3.06672186e-01f, -2.27783889e-01f, -9.62574333e-02f, 3.88486326e-01f, -3.92013758e-01f, 1.81838781e-01f, -2.41343886e-01f, -1.08387090e-01f, 3.11450269e-02f,
  1.02026187e-01f, 5.27031766e-03f, -2.97299474e-01f, -7.58620501e-02f, 9.84036326e-02f, -2.71881551e-01f, -1.98185250e-01f, 2.89802283e-01f, -3.01256269e-01f, 2.35535413e-01f,
  5.11102416e-02f, -8.51975456e-02f, 3.31138313e-01f, 1.19916052e-01f, -4.08668667e-01f, 2.39809304e-02f, 2.10143268e-01f, -2.89308935e-01f, -3.24629515e-01f, -1.13597132e-01f,
  -2.61421591e-01f, -4.60608304e-02f, 9.72268954e-02f, -1.04560643e-01f, 3.01540077e-01f, 1.59165442e-01f, 2.58484274e-01f, -2.08818391e-02f, 4.46302623e-01f, -2.24573776e-01f,
  4.83942479e-02f, 2.66710162e-01f, 2.08501607e-01f, -1.96622927e-02f, -2.15793066e-02f, 1.42852589e-01f, -2.91891792e-03f, 1.12448215e-01f, 8.52784589e-02f, -6.07237779e-03f,
  -1.27162650e-01f, -1.66451618e-01f, -2.38022655e-01f, -1.54194579e-01f, -9.37015265e-02f, 1.01489872e-01f, -5.05815260e-02f, -2.99167633e-01f, 2.79752553e-01f, 9.31532979e-02f,
  -2.16758654e-01f, -2.96508253e-01f, -9.41596273e-03f, -3.45026046e-01f, -3.95168737e-03f, -3.53107512e-01f, 3.24148089e-01f, 1.65255621e-01f, 2.27807418e-01f, -3.33722495e-02f,
  -8.09340104e-02f, 3.09787929e-01f, -1.77761555e-01f, 3.20919544e-01f, 1.72336131e-01f, 8.35201144e-02f, -4.43983041e-02f, -6.64086789e-02f, -3.47066931e-02f, 9.00560245e-02f,
  -2.27436289e-01f, -4.71271239e-02f, -1.54549658e-01f, -1.47615954e-01f, 1.21199779e-01f, -4.69101686e-03f, -1.21281318e-01f, 2.29347259e-01f, 6.82394281e-02f, -2.53716670e-02f,
  2.70217061e-01f, -5.61038218e-02f, 1.28957674e-01f, 6.96700662e-02f, 3.04240018e-01f, -6.95188791e-02f, 5.74714184e-01f, 1.88668221e-01f, -2.13659573e-02f, -8.55729803e-02f,
  4.21909600e-01f, -1.25901356e-01f, 9.52092484e-02f, -4.03227776e-01f, -2.74318233e-02f, -5.48548326e-02f, -1.79705366e-01f, -9.46899801e-02f, -1.98991910e-01f, 6.38068318e-02f,
  -1.61059424e-01f, 6.30957633e-02f, -3.65760982e-01f, 1.42638594e-01f, -1.42598391e-01f, -4.05567437e-01f, 4.25880283e-01f, -2.61504576e-02f, 3.13830465e-01f, -4.67378348e-02f,
  -2.90743768e-01f, 4.08924878e-01f, 4.35211584e-02f, -2.40669206e-01f, -1.13914922e-01f, 4.19506818e-01f, -2.97566433e-03f, 3.08404475e-01f, 2.10366338e-01f, 4.54887629e-01f,
  -1.27518684e-01f, -3.92984487e-02f, 7.57074356e-02f, -1.46947205e-01f, 3.42111051e-01f, -5.95423639e-01f, 1.56725466e-01f, 8.58173743e-02f, -2.85814721e-02f, 2.00715885e-01f,
  1.39366210e-01f, -4.52438183e-03f, 2.45944858e-01f, 1.35555506e-01f, 8.14444125e-02f, 2.61720810e-02f, 6.02790639e-02f, -5.45162484e-02f, -1.18010983e-01f, -1.94347546e-01f,
  -5.02567552e-02f, 2.77028948e-01f, 4.04129177e-02f, 2.26066619e-01f, 4.22053397e-01f, -8.66873860e-02f, -3.55834693e-01f, -4.92120124e-02f, -4.10572827e-01f, 7.08511621e-02f,
  -4.36077081e-02f, -2.59826809e-01f, 1.73865035e-01f, 3.34475279e-01f, 3.06839913e-01f, -2.80896336e-01f, 1.13027014e-01f, 9.41941515e-02f, 2.03505382e-01f, 2.33185306e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  -4.66465838e-02f, 8.25402066e-02f, 4.95101884e-02f, 8.81878659e-03f, 8.79561156e-02f, -1.64944530e-02f, 1.35959074e-01f, -1.09401261e-02f, 1.29968196e-01f, 2.18138054e-01f,
  -2.18161778e-03f, 2.86106765e-01f, 1.46209031e-01f, 2.06443723e-02f, 1.04050292e-02f, -3.64559107e-02f, 2.14684740e-01f, 1.84541926e-01f, -3.10538430e-02f, 1.88214198e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  9.29829329e-02f, -1.12928115e-01f, -2.44687304e-01f, 1.13419540e-01f, -1.61301538e-01f, -2.11995140e-01f, -1.30208418e-01f, 3.91549803e-02f, -3.62549606e-03f, 8.05343688e-02f,
  -2.12567210e-01f, -5.14147766e-02f, -4.69286144e-01f, -7.32270479e-02f, -1.79398388e-01f, -3.88839424e-01f, 1.98493198e-01f, -1.24361664e-02f, 2.56175339e-01f, 2.47813448e-01f,
  -3.84839296e-01f, -2.00798273e-01f, 1.67419747e-01f, -4.93191332e-01f, -3.09798002e-01f, -1.89930461e-02f, 3.50977659e-01f, 2.23009810e-01f, 1.59639776e-01f, 9.44551304e-02f,
  1.40855774e-01f, 2.52409261e-02f, 1.53243691e-01f, -1.45990595e-01f, 5.02771847e-02f, -1.13059700e-01f, -3.10680214e-02f, 3.01636308e-01f, -2.36416787e-01f, 2.94273376e-01f,
  3.04155916e-01f, -4.06721950e-01f, -3.70550215e-01f, -3.14859003e-01f, -3.35881054e-01f, 5.96478134e-02f, 9.14349183e-02f, -3.54523391e-01f, -2.15147078e-01f, -5.53532481e-01f,
  8.71942565e-02f, 5.33648193e-01f, -2.73387790e-01f, 3.69467378e-01f, -9.84108895e-02f, -4.32670265e-01f, -2.39854038e-01f, -5.61306141e-02f, 5.13484478e-01f, -5.07116795e-01f,
  -3.09196144e-01f, 2.31886953e-01f, -3.93115759e-01f, -3.22634161e-01f, 1.60039857e-01f, -1.05654687e-01f, -5.75070679e-02f, 3.09109055e-02f, -1.33851036e-01f, 1.07557490e-01f,
  2.52562821e-01f, 2.64452964e-01f, -2.47568801e-01f, -7.53845498e-02f, 2.72444814e-01f, 2.45868623e-01f, 2.03425661e-01f, -6.16663620e-02f, 5.13076335e-02f, -3.85662228e-01f,
  -6.57790184e-01f, -1.14022575e-01f, -4.89749968e-01f, -1.55777559e-01f, -4.24517274e-01f, 4.18064952e-01f, 1.69557005e-01f, -1.39853582e-01f, 2.99660742e-01f, -3.94016951e-01f,
  -3.80090654e-01f, -1.08169407e-01f, -2.63194501e-01f, 1.09974250e-01f, -9.47984010e-02f, -1.58834489e-04f, -2.95188893e-02f, -7.50002638e-02f, -9.09990147e-02f, -1.68711543e-01f,
  -1.44385779e-02f, 1.15159288e-01f, 1.79354727e-01f, 9.50897485e-02f, 7.09739029e-02f, 1.96821392e-01f, 3.21575254e-02f, -3.16504896e-01f, 1.56316847e-01f, -4.49075431e-01f,
  3.76775324e-01f, -2.79779881e-01f, 9.87426788e-02f, 1.71029881e-01f, 6.67451248e-02f, -6.04064986e-02f, -3.23872477e-01f, -7.17015505e-01f, -1.91259325e-01f, -2.05665641e-02f,
  -5.44960260e-01f, -4.80602235e-01f, 1.60060138e-01f, 1.71359599e-01f, -5.35548270e-01f, -3.37068476e-02f, 3.22848469e-01f, 1.92261353e-01f, 3.49583864e-01f, 1.31278276e-01f,
  1.72680900e-01f, -1.94430724e-01f, 2.69619942e-01f, 1.95649505e-01f, -1.92734450e-01f, -1.36268130e-02f, 1.84932277e-01f, 2.50091016e-01f, 4.77331817e-01f, 9.68471542e-02f,
  8.68502110e-02f, 2.01361299e-01f, -9.45407003e-02f, 2.76087433e-01f, 2.53226727e-01f, 7.32985213e-02f, 3.00653219e-01f, -5.07353902e-01f, -1.90605968e-01f, -2.73891240e-01f,
  -7.56111518e-02f, 3.86400856e-02f, -2.85131037e-01f, -3.33684415e-01f, -2.84182757e-01f, 3.60461056e-01f, 5.44066541e-02f, 5.48809655e-02f, -3.17921132e-01f, 9.99704674e-02f,
  4.01967391e-03f, 9.24990773e-02f, 3.51899505e-01f, 1.58597991e-01f, 1.42011419e-01f, 3.43745261e-01f, -1.73021168e-01f, -2.54458487e-01f, 1.67444795e-01f, 1.28454408e-02f,
  -2.60756105e-01f, -6.12875074e-02f, -6.54922545e-01f, 1.39624864e-01f, -3.84619534e-01f, 9.19441059e-02f, 2.32366636e-01f, -6.01157963e-01f, 3.57925408e-02f, -2.76421279e-01f,
  2.55869091e-01f, 2.66758472e-01f, -3.52335419e-03f, -2.64978856e-02f, -2.06572980e-01f, -5.50991893e-02f, -1.24467760e-01f, -2.40409553e-01f, 4.64996248e-01f, 1.83978483e-01f,
  -6.02028966e-01f, 2.90582746e-01f, 1.38425499e-01f, 1.16664909e-01f, 1.12044692e-01f, 4.54068072e-02f, 3.73498462e-02f, -1.41630415e-02f, -3.14269453e-01f, 4.01574075e-01f,
  2.87055988e-02f, -2.05090210e-01f, 1.30070403e-01f, -4.69029360e-02f, 2.58024395e-01f, 1.68316923e-02f, -4.30557989e-02f, 3.54983002e-01f, -3.21113616e-01f, -1.95967600e-01f,
  -6.07496798e-01f, 2.20256690e-02f, -1.42830700e-01f, 1.67113151e-02f, -1.29830882e-01f, 2.65947461e-01f, 3.33897233e-01f, 3.91750664e-01f, -4.98586409e-02f, -1.12836882e-01f,
  -2.12256074e-01f, -4.91165519e-01f, -3.22735488e-01f, -6.09793305e-01f, 2.55764257e-02f, 2.30848849e-01f, 4.47535925e-02f, -1.52507260e-01f, -2.01711848e-01f, -1.74743056e-01f,
  1.89077243e-01f, -8.11335519e-02f, -1.66755676e-01f, -2.07054545e-03f, 1.03923149e-01f, -1.05827227e-01f, -2.17357665e-01f, -8.93240273e-02f, 4.24599737e-01f, 1.14328623e-01f,
  3.76273929e-05f, 3.74521732e-01f, -2.38306075e-01f, -7.02982396e-02f, 3.18446815e-01f, 1.59253331e-03f, -5.74744165e-01f, -4.35049236e-01f, -1.38830930e-01f, 7.98480958e-02f,
  8.44223201e-02f, 1.48034751e-01f, 2.40967974e-01f, -4.08533573e-01f, 6.65672645e-02f, 3.08430362e-02f, -1.99667454e-01f, -1.73096620e-02f, -2.46535912e-01f, -2.11337075e-01f,
  7.79976472e-02f, -9.03685391e-02f, 2.21352920e-01f, 1.70563117e-01f, 8.45732093e-02f, 4.66504470e-02f, -1.31373823e-01f, -2.35383525e-01f, 1.33566514e-01f, 1.65458485e-01f,
  -2.18708649e-01f, -1.31081551e-01f, 1.50775805e-01f, 4.72961068e-01f, -1.43175602e-01f, 1.06870271e-01f, -1.52684599e-01f, 1.40958890e-01f, 1.92824677e-01f, -4.70048189e-01f,
  -2.01727509e-01f, -6.11334257e-02f, -1.85819134e-01f, -3.34897131e-01f, -1.73543096e-01f, 1.01984382e-01f, 9.24244821e-02f, -4.46449667e-01f, 1.57097146e-01f, -2.93371901e-02f,
  -2.28159189e-01f, 9.06522870e-02f, 8.13143626e-02f, -7.76520446e-02f, -9.12442729e-02f, 2.77259380e-01f, -1.49926975e-01f, -6.71352074e-02f, -3.22270751e-01f, 2.20503896e-01f,
  -3.26218307e-02f, 1.74278364e-01f, -1.97188824e-01f, 2.20502671e-02f, -1.35506004e-01f, 1.08320802e-01f, -4.35356617e-01f, -2.60615349e-01f, 5.72670519e-01f, 3.13107580e-01f,
  -6.09905422e-01f, -1.08347848e-01f, 1.54967099e-01f, -4.93773490e-01f, -2.57518291e-01f, -3.28581750e-01f, 1.04157098e-01f, -5.75790882e-01f, -1.93147942e-01f, -2.43145257e-01f,
  1.17040180e-01f, -1.89815238e-01f, 2.27526277e-01f, 1.62887722e-01f, -1.53046906e-01f, 1.79312736e-01f, 2.49328107e-01f, -2.53494456e-02f, -8.40059072e-02f, -2.02046081e-01f,
  2.13554487e-01f, 1.71539247e-01f, 2.34380722e-01f, -3.65557253e-01f, -1.60623148e-01f, -4.59020704e-01f, 6.56315088e-02f, -4.23697293e-01f, -1.37616899e-02f, -1.05663225e-01f,
  -1.57842502e-01f, -2.34364495e-01f, 3.78308237e-01f, 1.52190700e-01f, -5.51265012e-03f, 2.23819137e-01f, -1.34582952e-01f, -1.70628533e-01f, -1.54821172e-01f, 1.99991073e-02f,
  4.56634134e-01f, -1.45188242e-01f, 1.36996713e-02f, 1.25621445e-02f, -1.70788169e-01f, -5.38760424e-03f, 1.00675113e-01f, -1.86338481e-02f, -2.95772582e-01f, -2.72084653e-01f,
  -3.69176596e-01f, 3.34455490e-01f, 9.14965943e-02f, -9.31015238e-03f, -6.44753203e-02f, -4.20280039e-01f, -2.93316483e-01f, 2.70527929e-01f, 2.12403402e-01f, -3.52602065e-01f,
  3.21535110e-01f, -1.36055341e-02f, -2.38872141e-01f, -2.22869381e-01f, 3.41265313e-02f, 4.13402915e-01f, 2.26268068e-01f, 2.73988187e-01f, -3.79104316e-02f, -3.29108566e-01f,
  -2.39129320e-01f, -4.69072521e-01f, -5.14873147e-01f, 2.86606073e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.22880764e-01f, 1.56160012e-01f, 1.28174499e-01f, -2.35381797e-01f, 7.51104057e-02f, 1.37423975e-02f, -3.63120772e-02f, -1.26475459e-02f, -4.01650034e-02f, 5.09424657e-02f,
  6.32517934e-02f, 1.26392379e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    