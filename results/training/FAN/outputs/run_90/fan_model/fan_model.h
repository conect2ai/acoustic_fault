/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.36910364e-01f, 9.33085904e-02f, -7.43728131e-02f, -3.92542928e-01f, -9.96418670e-02f, 4.92582917e-02f, 7.13195354e-02f, -2.85097837e-01f, -1.65987715e-01f, -1.79086495e-02f,
  -7.02744126e-02f, 1.08094350e-01f, 1.98059365e-01f, -1.63372576e-01f, 8.93485248e-02f, 2.93189108e-01f, -1.12459689e-01f, -7.25987405e-02f, -1.14153381e-02f, -1.59219980e-01f,
  -1.45839795e-01f, -2.06816465e-01f, -3.95149831e-03f, -9.88020152e-02f, -1.25440747e-01f, -1.54023841e-01f, -1.79264531e-01f, 1.28808692e-01f, -1.20754205e-01f, 9.48344618e-02f,
  -2.49410644e-02f, -7.70991435e-03f, -2.88081206e-02f, 1.86353121e-02f, -7.23349154e-02f, 4.33832668e-02f, 3.29045579e-02f, 1.38961494e-01f, -2.45812512e-03f, 2.26830672e-02f,
  4.10070829e-02f, -2.82039214e-02f, -4.86066192e-02f, -2.07125721e-03f, 3.16699296e-02f, -5.77000864e-02f, -2.22868752e-02f, 8.41449201e-03f, -3.17030102e-02f, -1.76805407e-02f,
  3.99836199e-03f, 3.72898765e-02f, -1.18195964e-03f, 2.20501851e-02f, 7.09535694e-03f, -5.59129640e-02f, -3.54202907e-03f, 6.68236986e-02f, -2.28578206e-02f, -8.16276390e-03f,
  5.02933636e-02f, -4.96922527e-03f, 1.16842082e-02f, 5.76619022e-05f, 4.42245640e-02f, -7.64851719e-02f, -1.99643197e-03f, 2.94643864e-02f, -4.16601630e-04f, 2.71537937e-02f,
  -2.10795701e-02f, 2.43132580e-02f, -2.57802717e-02f, -2.10477635e-02f, -9.56704468e-02f, -4.76772487e-02f, 4.12453823e-02f, 2.74969991e-02f, -4.24284562e-02f, -4.68050875e-02f,
  1.56964101e-02f, -3.17174383e-03f, 1.18479691e-02f, -9.33746155e-03f, 8.57276283e-03f, 3.32337879e-02f, -2.92883310e-02f, 3.23419943e-02f, 7.22276652e-03f, 4.73343506e-02f,
  1.38984725e-01f, -7.47289136e-02f, -1.61387399e-02f, 1.24470508e-02f, -1.94917826e-04f, -6.11566044e-02f, 1.39752477e-02f, -3.59320939e-02f, 9.06879976e-02f, -1.21164322e-01f,
  -9.60154235e-02f, -4.56139855e-02f, -2.68428051e-03f, 6.59075230e-02f, 2.46909522e-02f, -5.42397471e-03f, -3.62547897e-02f, -1.59325532e-03f, -3.40977423e-02f, -1.23074027e-02f,
  -3.76592018e-02f, 8.34660679e-02f, 2.82938741e-02f, -7.35120848e-02f, -2.23436225e-02f, 5.30878752e-02f, -4.24915776e-02f, 8.69700164e-02f, 2.95562558e-02f, -3.29406001e-02f,
  3.57306421e-01f, -1.17360689e-01f, -2.12621599e-01f, 1.48819670e-01f, 1.35684878e-01f, 1.66145544e-02f, 6.47205561e-02f, -4.17506807e-02f, -1.65452361e-02f, 2.74592228e-02f,
  1.16841286e-01f, 9.07513723e-02f, -1.15977600e-02f, -1.08490638e-01f, -1.66377109e-02f, -2.22743377e-01f, 7.11069331e-02f, 1.30936671e-02f, -8.82637277e-02f, 9.85258371e-02f,
  -1.07870579e-01f, 5.61185665e-02f, -8.86554047e-02f, -7.32449666e-02f, 1.15005821e-01f, 1.75423212e-02f, 1.42725572e-01f, -7.08678737e-02f, 5.17856702e-02f, 3.45631018e-02f,
  1.17586821e-01f, 1.23648137e-01f, -2.29084631e-03f, -7.84236044e-02f, 7.97483474e-02f, 7.29475170e-02f, 2.20932206e-03f, 2.39580777e-03f, -1.01528445e-03f, 4.97164093e-02f,
  1.24917179e-02f, 2.09047901e-03f, 8.11273057e-04f, -2.20303666e-02f, 9.21589788e-03f, -9.69159231e-02f, -7.38761872e-02f, 4.91615124e-02f, 6.34721434e-03f, 2.16063368e-03f,
  1.97333042e-02f, -2.38556955e-02f, 1.66559983e-02f, 5.13139516e-02f, -3.21790092e-02f, -9.41687729e-03f, -1.98511574e-02f, -9.81639978e-03f, 9.56434235e-02f, 6.06248677e-02f,
  7.42364377e-02f, -2.87977979e-02f, -7.92261958e-02f, -4.36330810e-02f, -7.65221417e-02f, -7.63320271e-03f, -1.44015988e-02f, 3.74155454e-02f, -2.04236582e-02f, 1.34500107e-02f,
  1.74939614e-02f, -8.06479435e-03f, 5.67498766e-02f, -1.24412114e-02f, 2.27284264e-02f, 4.01542485e-02f, 2.21995115e-02f, 7.87941292e-02f, 2.71597737e-03f, 2.97971200e-02f,
  8.86677112e-03f, 2.19788868e-02f, 6.37111836e-04f, 1.26864333e-02f, 4.01802063e-02f, -6.75092861e-02f, -4.55803499e-02f, 1.70287807e-02f, -2.09521763e-02f, 5.14239557e-02f,
  5.95765077e-02f, 1.46892183e-02f, -5.08962087e-02f, 8.77663046e-02f, -4.31690216e-02f, -3.92191410e-02f, -1.09880362e-02f, -2.58802399e-02f, 1.57113727e-02f, 2.47977935e-02f,
  7.04269409e-02f, -4.86827195e-02f, 9.82562974e-02f, 1.59296263e-02f, -7.93411136e-02f, -4.17282172e-02f, 1.35014560e-02f, 1.13874283e-02f, 5.65606505e-02f, -1.01069054e-02f,
  1.31966928e-02f, 1.49181858e-02f, 4.11160588e-02f, 8.50440115e-02f, 1.33769354e-02f, 3.68775502e-02f, 6.60899514e-03f, -4.52934473e-05f, 2.77585350e-02f, 3.41462577e-03f,
  1.84399281e-02f, -3.80093791e-02f, 2.11762860e-02f, 3.26261789e-01f, -1.99236840e-01f, -1.59523934e-01f, -2.80036731e-03f, -1.24985889e-01f, 2.54180729e-01f, -8.05323869e-02f,
  1.40012652e-02f, 2.43573770e-01f, 4.39740624e-03f, 1.29759878e-01f, 2.85389453e-01f, 1.59865141e-01f, 1.10305041e-01f, 7.07234219e-02f, 5.81335574e-02f, 8.49767253e-02f,
  6.23233132e-02f, 6.84579536e-02f, -7.19651803e-02f, -1.36973634e-01f, -1.15618601e-01f, -1.96990091e-02f, -1.56310387e-02f, -3.41942497e-02f, -4.70906645e-02f, -1.31685501e-02f,
  -1.02628171e-01f, 1.51414618e-01f, 2.29757335e-02f, 4.08922732e-02f, -3.53236310e-02f, -3.79481800e-02f, 6.34066612e-02f, 2.43512597e-02f, -1.26859248e-02f, 4.76041734e-02f,
  1.60622969e-02f, -6.91276416e-02f, 5.28613664e-02f, 1.23858877e-01f, -2.54751579e-03f, -2.88198553e-02f, 1.78884566e-02f, -9.45079550e-02f, -1.97708812e-02f, -1.68345496e-02f,
  -4.04572375e-02f, -2.60831974e-02f, 1.41623700e-02f, 3.26718688e-02f, 8.55852477e-03f, 2.43440215e-02f, -1.21572036e-02f, -3.86866704e-02f, 2.68471334e-02f, 7.29131475e-02f,
  2.23171189e-02f, 3.71910110e-02f, 1.79157965e-02f, -1.94584241e-03f, 6.10678680e-02f, -6.88798726e-02f, 5.61857671e-02f, -9.23416167e-02f, 3.92082892e-02f, 6.45914227e-02f,
  -2.32487097e-02f, 5.77778071e-02f, 7.07844365e-03f, 1.51726650e-03f, 5.66008314e-02f, 1.42682102e-02f, 1.14556821e-02f, 2.47995090e-02f, 4.52702381e-02f, -5.66170812e-02f,
  -1.69632211e-02f, 2.52811704e-02f, 3.94677147e-02f, -4.50803153e-02f, 3.27736773e-02f, 1.60076171e-02f, 6.03081807e-02f, -5.69717512e-02f, -3.56321819e-02f, 3.21104773e-03f,
  1.26971483e-01f, 3.29117745e-01f, -5.71782328e-02f, 4.76460680e-02f, 1.94721967e-02f, -4.03195582e-02f, -4.04208265e-02f, 1.46085313e-02f, 1.77374445e-02f, 1.85376741e-02f,
  2.61011999e-03f, -1.71209145e-02f, 7.99233653e-03f, 4.02943371e-03f, 2.92689428e-02f, 4.18141373e-02f, 1.18824653e-02f, 1.98907703e-02f, 3.65824401e-02f, 2.85362098e-02f,
  4.78695799e-03f, 5.77016585e-02f, 3.70617881e-02f, 1.86602939e-02f, -2.63483413e-02f, 2.48975959e-02f, 1.83558725e-02f, 5.15268184e-02f, -2.69584283e-02f, 1.38049508e-02f,
  8.67956504e-02f, -2.20821902e-01f, 7.56172538e-02f, 2.09953249e-01f, 1.24447055e-01f, -9.23667401e-02f, 1.13677703e-01f, 3.26435082e-02f, 1.37744859e-01f, -5.22777140e-02f,
  1.05540879e-01f, 8.02276954e-02f, 8.55809748e-02f, 1.38481364e-01f, 2.88334519e-01f, 4.83182631e-02f, 4.54953387e-02f, -6.02660179e-02f, 4.13882993e-02f, 1.33205324e-01f,
  9.55285877e-02f, 1.48328096e-01f, 8.84234086e-02f, -7.45258555e-02f, -1.28116105e-02f, -2.15911455e-02f, -6.19470049e-03f, 1.52148074e-02f, -8.86090770e-02f, 4.38347645e-02f,
  -1.22252233e-01f, 9.14144069e-02f, -6.26881644e-02f, -4.13050875e-02f, -9.95323807e-02f, -1.24199733e-01f, -2.44373865e-02f, 2.81708855e-02f, 8.03244486e-02f, 2.51352321e-02f,
  -4.75954451e-02f, -2.59562507e-02f, 8.70754793e-02f, 2.71582641e-02f, -9.06988010e-02f, -1.57953668e-02f, 5.16759418e-02f, -7.95353949e-02f, -3.07520339e-03f, 2.04178062e-03f,
  2.47640796e-02f, -4.06451263e-02f, -2.13361308e-02f, -7.77336434e-02f, -6.02237461e-03f, 7.88964480e-02f, 1.84961949e-02f, 2.50695297e-03f, -3.12758982e-02f, 1.49992052e-02f,
  6.01269007e-02f, -3.59782688e-02f, -4.37195338e-02f, -5.53638339e-02f, -9.55387112e-03f, -4.02500667e-02f, 2.05753837e-02f, 5.62173128e-02f, -5.64769767e-02f, -8.06366652e-03f,
  -6.33703321e-02f, 5.33259511e-02f, 6.46523386e-02f, -2.01750249e-02f, 1.13513591e-02f, -3.64944451e-02f, -5.82302036e-03f, -2.86678337e-02f, 3.02961543e-02f, -5.47957793e-02f,
  -4.78814030e-03f, 8.65343865e-03f, -3.76599692e-02f, -1.30789466e-02f, 5.38221560e-02f, -6.23023743e-03f, 6.87834844e-02f, 7.43505880e-02f, -8.85726977e-03f, -3.22717614e-02f,
  -2.06680030e-01f, 1.27115883e-02f, 4.42184135e-02f, -9.90007818e-02f, -1.50683075e-02f, 8.49224441e-03f, -6.43425249e-03f, 1.23598101e-02f, -1.01528816e-01f, 5.31578735e-02f,
  -3.60726193e-02f, -6.34518191e-02f, -9.17279497e-02f, -4.21101460e-03f, 3.27171944e-02f, -5.18796593e-02f, 4.42367271e-02f, -9.77275372e-02f, -2.89808796e-03f, 2.79876292e-02f,
  -2.59582624e-02f, 3.26887593e-02f, 1.54146282e-02f, -6.95700645e-02f, -6.90816063e-03f, -3.85744497e-02f, -2.11898200e-02f, -6.71328232e-02f, 3.11061498e-02f, 1.11285076e-02f,
  3.84558022e-01f, -1.79660872e-01f, 9.70414840e-03f, 1.33337695e-02f, 1.80797741e-01f, 9.17803720e-02f, 4.88016829e-02f, 7.93044344e-02f, 1.97771758e-01f, -8.61464515e-02f,
  -6.43318379e-03f, 1.44907041e-02f, -6.45489395e-02f, -1.09258614e-01f, 4.18450944e-02f, -3.77222486e-02f, 6.41411990e-02f, 5.13835177e-02f, -5.33730090e-02f, -1.06656864e-01f,
  1.48006100e-02f, -6.90665096e-02f, -9.72436517e-02f, -1.22674808e-01f, -7.00579062e-02f, -1.27429441e-01f, -7.59192929e-02f, -2.98374426e-02f, -3.96530293e-02f, 3.45633589e-02f,
  1.22701690e-01f, -6.13631643e-02f, -1.71300396e-02f, 3.40065397e-02f, -9.35972854e-02f, -5.23768701e-02f, 5.67660155e-03f, -2.35810783e-02f, 2.77786627e-02f, -2.19604075e-02f,
  -4.58619855e-02f, 6.33857995e-02f, 1.04859388e-02f, -5.71772978e-02f, 7.42892772e-02f, 3.36565226e-02f, -8.44186754e-04f, -4.37676683e-02f, -1.26115251e-02f, 9.04831383e-03f,
  -5.46097336e-03f, -1.13025811e-02f, -3.82572301e-02f, -5.21518523e-03f, -5.52721135e-02f, -4.36022840e-02f, -3.15786451e-02f, -1.05145453e-02f, 1.17140822e-02f, 9.22624860e-03f,
  -4.93910648e-02f, 1.01793883e-02f, 6.65177628e-02f, 2.12818477e-02f, 4.07791957e-02f, 3.15550528e-02f, -3.36805359e-02f, -3.72793414e-02f, 2.36091502e-02f, -3.17127854e-02f,
  3.74595001e-02f, -1.42161651e-02f, -5.09810485e-02f, 2.66698189e-02f, -3.53694498e-03f, 1.75546445e-02f, 1.19882068e-02f, 5.88473072e-03f, -2.81096175e-02f, 1.15169426e-02f,
  3.26319672e-02f, 6.02738671e-02f, -5.52777722e-02f, 5.61689548e-02f, -5.80957606e-02f, 1.40327727e-02f, -1.09115832e-01f, 1.62747391e-02f, -3.24178394e-03f, 4.18542465e-03f,
  -1.04815029e-01f, -1.51153266e-01f, -5.86622581e-02f, -3.62779871e-02f, 1.69271268e-02f, -6.90129995e-02f, 2.98378486e-02f, 3.31074260e-02f, 3.38156149e-02f, -1.62597634e-02f,
  -8.92455783e-03f, -2.56509762e-02f, -2.50058528e-02f, 3.71162146e-02f, 3.95520516e-02f, -8.20933133e-02f, -3.82034257e-02f, -1.37269096e-02f, -3.64574865e-02f, -2.93712504e-02f,
  -7.18086585e-02f, 7.46705150e-03f, 1.67724618e-04f, -2.18500961e-02f, -3.69104408e-02f, 2.10785083e-02f, 2.45100167e-02f, 6.65240437e-02f, -4.35440876e-02f, -1.36188632e-02f,
  2.45164633e-01f, -1.54657558e-01f, 2.42245998e-02f, -1.51955605e-01f, 4.49233837e-02f, 2.59433091e-01f, 1.31639272e-01f, -1.23495899e-01f, -7.79687464e-02f, 2.44774553e-03f,
  -9.04857833e-03f, -7.40876198e-02f, 1.66746482e-01f, -1.27448261e-01f, 3.17693204e-01f, 4.58574221e-02f, -2.10612789e-02f, -2.23940164e-02f, -1.29097521e-01f, -2.46131532e-02f,
  -9.11162868e-02f, -7.45782480e-02f, 3.89584191e-02f, -6.66439459e-02f, 1.85741652e-02f, -5.51921874e-02f, -2.29012445e-02f, -9.02424008e-02f, -2.66401917e-02f, 4.89830151e-02f,
  6.30611554e-02f, -6.60921559e-02f, -2.07618922e-02f, 4.70340960e-02f, 9.03547928e-02f, 3.30816694e-02f, 3.96403074e-02f, 7.44271725e-02f, -5.40338755e-02f, 8.32419284e-03f,
  -7.97427900e-04f, -4.23251726e-02f, -3.25118601e-02f, -1.14202639e-02f, -3.77528295e-02f, -4.59709167e-02f, -9.92486104e-02f, 6.62595406e-02f, -7.63064325e-02f, 1.24982698e-02f,
  -1.71900298e-02f, 1.86917949e-02f, 1.19708553e-02f, 3.04706134e-02f, 2.28779465e-02f, 1.10746156e-02f, 9.21546966e-02f, 2.91325767e-02f, 3.71405878e-03f, -3.44471261e-02f,
  9.79243368e-02f, 5.03786281e-02f, -5.12416847e-02f, -1.45436637e-02f, -1.04885809e-02f, -1.06133493e-02f, 1.45167531e-03f, 5.08204401e-02f, -4.84205820e-02f, 2.68271845e-02f,
  3.59472856e-02f, -4.17348482e-02f, -3.73496041e-02f, 3.19584310e-02f, -1.92340054e-02f, -8.49387795e-03f, -7.60113494e-03f, -8.22163001e-03f, -4.20941822e-02f, 2.00434327e-02f,
  -3.84450443e-02f, 2.41750740e-02f, -3.44436094e-02f, 1.43956449e-02f, 2.33249515e-02f, 3.52635211e-03f, -7.98692461e-03f, 6.07770495e-03f, 7.27515807e-03f, 4.90970276e-02f,
  -5.77486912e-03f, -3.05418782e-02f, 1.52092297e-02f, 1.17969401e-02f, -5.23136035e-02f, -1.14216637e-02f, -5.42442650e-02f, -4.26843055e-02f, 9.41278646e-04f, 1.44086760e-02f,
  3.31170447e-02f, 4.49124314e-02f, 2.08701733e-02f, -2.70711053e-02f, 1.97471268e-02f, -2.99613252e-02f, 1.00926064e-01f, 4.97917412e-03f, 5.60662784e-02f, 3.08744181e-02f,
  4.89936881e-02f, 2.12413035e-02f, -2.48361155e-02f, -1.56704821e-02f, 6.52732179e-02f, 3.49068195e-02f, -6.36986718e-02f, -2.31468119e-02f, 3.72240655e-02f, 8.74315761e-03f,
  -2.01784428e-02f, 2.49923076e-02f, 2.27481410e-01f, 2.07117423e-01f, -1.38851374e-01f, 3.46813500e-01f, 3.23506504e-01f, 2.01530885e-02f, 1.58016488e-01f, -1.72686316e-02f,
  3.67666781e-02f, 1.31630932e-03f, 1.17806951e-02f, 1.90313190e-01f, 2.74752766e-01f, 1.05231792e-01f, 2.01831058e-01f, 1.13923155e-01f, -2.49113720e-02f, 1.20430969e-01f,
  1.90473273e-02f, 4.80177142e-02f, 1.40634283e-01f, -4.70441282e-02f, 8.05359259e-02f, -5.05121164e-02f, -1.94754321e-02f, -6.37061372e-02f, -1.28559209e-03f, -2.22038981e-02f,
  7.97398090e-02f, -3.79356965e-02f, -5.45637086e-02f, -4.51979367e-03f, 9.13567841e-02f, 9.57045853e-02f, 5.86998463e-02f, -2.62755174e-02f, 1.48090497e-02f, 4.78709786e-04f,
  4.98982891e-02f, 5.86599335e-02f, 3.41674685e-02f, -7.79349729e-03f, 1.07412431e-02f, -2.14573685e-02f, 1.54496571e-02f, 2.52921246e-02f, -2.84913816e-02f, 2.20462680e-03f,
  -2.39707120e-02f, 3.71785462e-02f, 2.40540374e-02f, 6.60291174e-03f, 3.65944376e-04f, -1.06499642e-02f, 1.00525580e-01f, 1.40313711e-02f, 1.56093622e-02f, 3.83856446e-02f,
  -9.00874957e-02f, 7.54681276e-03f, 4.28416729e-02f, 1.89582799e-02f, 1.34678893e-02f, -2.93306690e-02f, 1.87290669e-03f, -8.44624713e-02f, -5.65831214e-02f, -1.21206057e-03f,
  4.28268835e-02f, -4.80191819e-02f, -8.99925735e-03f, -2.46795602e-02f, 4.80341613e-02f, -1.30592808e-02f, -1.75111238e-02f, -6.52790368e-02f, -7.92753603e-03f, 1.53635135e-02f,
  3.66703570e-02f, -3.00891176e-02f, -1.94183853e-03f, -3.64651792e-02f, 1.19117284e-02f, -2.15004366e-02f, -3.45903710e-02f, 9.13329981e-03f, 7.20113795e-03f, -9.43392282e-04f,
  2.65884344e-02f, 1.46506146e-01f, 3.89255658e-02f, -6.73493883e-03f, 2.31479574e-02f, 2.25784117e-03f, 3.08579225e-02f, -2.76749376e-02f, 3.97900827e-02f, 6.69278903e-03f,
  6.44016359e-03f, 2.67133433e-02f, 1.97390281e-02f, -2.41089780e-02f, -1.20700803e-02f, 5.67511059e-02f, 5.56019600e-04f, -3.58248018e-02f, 3.08803823e-02f, -1.92687567e-02f,
  -3.34102809e-02f, -1.10884653e-02f, 3.38676795e-02f, 5.00255777e-03f, -9.23468731e-03f, -1.53484810e-02f, -5.27795311e-03f, -6.70878366e-02f, -2.61036083e-02f, 4.09989804e-02f,
  -1.51141554e-01f, -1.46767780e-01f, -2.38893837e-01f, -1.68621331e-01f, -1.76950637e-02f, 1.98024943e-01f, 1.42695159e-01f, -2.03668520e-01f, -4.37489092e-01f, 2.03237385e-02f,
  7.56218582e-02f, -4.98816893e-02f, 1.12797543e-01f, 3.29463109e-02f, 1.33325055e-01f, 8.68911576e-03f, 3.56385745e-02f, 2.52164453e-02f, -1.16778418e-01f, -7.24649802e-02f,
  -8.99478644e-02f, 2.49127612e-01f, 9.65419933e-02f, 9.38985795e-02f, 9.34489220e-02f, -1.07264593e-01f, 1.30819499e-01f, 9.47415903e-02f, 1.44610599e-01f, 9.63890776e-02f,
  7.72600016e-03f, -9.24451202e-02f, -2.88729593e-02f, -1.18287345e-02f, -8.30864012e-02f, 8.46826956e-02f, 7.91376829e-02f, 1.81496039e-01f, -5.66390976e-02f, 2.04891991e-02f,
  -1.59019453e-03f, 8.44494030e-02f, -6.02580532e-02f, -2.90218857e-03f, -2.60584578e-02f, -5.06910644e-02f, -5.35994358e-02f, -4.95921671e-02f, -8.56973305e-02f, 1.34565234e-02f,
  9.70344152e-03f, -4.98229675e-02f, -3.98801826e-03f, 4.49242853e-02f, -1.39376055e-03f, -5.13713546e-02f, 3.96217257e-02f, 3.80248353e-02f, -2.16347985e-02f, -3.48467827e-02f,
  3.74584347e-02f, -4.78835925e-02f, 7.07023293e-02f, 2.95509528e-02f, 1.78496856e-02f, -3.28447409e-02f, 3.39937769e-02f, 6.29933998e-02f, 6.40050508e-04f, -3.20897475e-02f,
  3.65258157e-02f, -4.41232733e-02f, -2.33963095e-02f, -3.52005400e-02f, 2.85483841e-02f, -1.37002412e-02f, -9.99946799e-03f, -5.08426083e-03f, -4.01941575e-02f, 9.46646929e-03f,
  -9.40820575e-03f, 9.89281386e-03f, 5.27756428e-03f, 3.91438119e-02f, 2.77698766e-02f, -1.43096410e-02f, -9.88220051e-02f, -6.67856336e-02f, -2.68079601e-02f, 3.58892716e-02f,
  -6.93772659e-02f, -4.39129025e-02f, -8.69734660e-02f, -3.29715312e-02f, -2.14002393e-02f, -3.33600864e-03f, -1.03519193e-03f, -6.75580129e-02f, -3.21769714e-03f, 4.16100994e-02f,
  2.90894676e-02f, 1.18467612e-02f, 7.42798895e-02f, -4.11720648e-02f, -2.10313164e-02f, 3.95318903e-02f, 4.58750539e-02f, -6.89511560e-03f, 4.54856791e-02f, 1.95920169e-02f,
  5.74117638e-02f, 9.37489644e-02f, 8.44828039e-03f, 4.73535247e-02f, -2.83208559e-03f, 8.80879164e-03f, -1.40583497e-02f, -3.91835235e-02f, 5.26283458e-02f, 5.26805632e-02f,
  -3.35157663e-01f, 3.77820879e-02f, 4.39443626e-02f, 3.61492299e-02f, -2.55915876e-02f, 2.29399037e-02f, 1.70327500e-01f, -1.05433248e-01f, 1.99590877e-01f, 1.16478682e-01f,
  -5.69643788e-02f, 2.56085712e-02f, 8.18561465e-02f, 5.30412830e-02f, -2.28703953e-02f, 5.76488897e-02f, -1.09909445e-01f, -2.22947858e-02f, 4.31323014e-02f, -2.74400055e-01f,
  -1.17339976e-01f, -1.56831682e-01f, -1.34277478e-01f, -2.53286153e-01f, -1.52142227e-01f, -9.32144076e-02f, -7.95931816e-02f, 1.98926479e-02f, -5.76417632e-02f, 1.08919665e-01f,
  -5.43477088e-02f, -8.34658146e-02f, -1.36280119e-01f, 7.90306330e-02f, -1.65534526e-01f, -3.12106349e-02f, 3.71070132e-02f, 8.57921913e-02f, -7.57645145e-02f, -2.26952359e-02f,
  -3.74543332e-02f, -4.18415442e-02f, -1.97795409e-04f, 8.24414641e-02f, 1.52905965e-02f, -5.35473786e-02f, -5.32193109e-02f, -7.41305724e-02f, 4.77934070e-03f, -4.20161039e-02f,
  -5.71927708e-03f, -1.02517093e-02f, 1.67209413e-02f, -3.58265713e-02f, -1.09493993e-02f, 2.43644807e-02f, 1.35150654e-02f, -1.40782120e-02f, 6.44758111e-03f, -2.56686900e-02f,
  3.24694142e-02f, 4.35838252e-02f, -7.77891465e-03f, 3.97929363e-02f, -2.14246381e-03f, -5.86983152e-02f, 5.94443232e-02f, -3.71197127e-02f, 4.16555144e-02f, -9.45797488e-02f,
  2.25389954e-02f, -8.23635459e-02f, -2.34382711e-02f, -3.61432359e-02f, 3.67040560e-02f, 4.37406301e-02f, 6.26922399e-02f, 9.52671561e-03f, -4.16166941e-03f, -2.14403886e-02f,
  5.29590696e-02f, 3.24709937e-02f, -1.64606441e-02f, 6.01054206e-02f, 7.63919763e-03f, -1.84716918e-02f, 5.20248339e-03f, 1.39903026e-02f, -1.08394772e-02f, -5.74420318e-02f,
  2.64603160e-02f, 3.87635343e-02f, -4.79292832e-02f, -8.10937211e-02f, 6.52879663e-03f, -1.39607470e-02f, 4.68286015e-02f, -8.32566172e-02f, 2.00145692e-02f, 1.35326087e-02f,
  -1.47372214e-02f, -6.52457848e-02f, 4.72212173e-02f, -4.30945456e-02f, 3.43202427e-02f, -2.04709582e-02f, 1.86817851e-02f, 4.78498414e-02f, 1.10752266e-02f, -4.50085886e-02f,
  -1.17799155e-01f, -5.03331721e-02f, 7.69225433e-02f, -1.30565288e-02f, -8.54123905e-02f, -6.67182431e-02f, 6.19386137e-03f, -4.46861200e-02f, 2.90261651e-03f, 4.09215465e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.38899818e-01f, 2.77893156e-01f, 1.06900282e-01f, -4.80812341e-02f, -1.69792175e-01f, -1.28425524e-01f, -2.22851038e-01f, 1.06106028e-02f, 1.91723034e-01f, -4.32075784e-02f,
  -1.83217242e-01f, 3.06543916e-01f, -5.56286424e-02f, 5.97181133e-05f, -2.38864601e-01f, -8.17984343e-02f, -1.77214742e-01f, -4.73477505e-02f, 9.63846520e-02f, -8.97715315e-02f,
  -8.45252946e-02f, -3.18768263e-01f, -1.18550114e-01f, -5.42091168e-02f, 3.17730568e-02f, 3.89601029e-02f, -1.78266540e-01f, -3.03904992e-02f, 4.55015227e-02f, 7.04366416e-02f,
  -3.87966260e-02f, 1.85162053e-02f, -5.15806861e-02f, -5.64584276e-04f, -1.83360085e-01f, 4.06518951e-02f, -5.80614693e-02f, -7.98231065e-02f, -4.65903915e-02f, 2.45788880e-02f,
  6.42417073e-02f, 1.78474970e-02f, 9.16700140e-02f, 4.50425893e-02f, 5.39905801e-02f, 4.52007875e-02f, 5.57404160e-02f, -3.93939912e-02f, 8.95009190e-03f, 1.26796082e-01f,
  9.36060306e-03f, 3.10697090e-02f, 1.08664729e-01f, 4.59982408e-03f, -4.37534618e-04f, 9.60943475e-02f, -3.05709634e-02f, 4.99893092e-02f, 5.92624806e-02f, 1.21498838e-01f,
  2.15379577e-02f, -4.54738662e-02f, 1.50768496e-02f, 9.60774571e-02f, -4.02225517e-02f, 3.27453613e-02f, -2.62828171e-03f, -6.18241206e-02f, -7.21506849e-02f, -6.06793314e-02f,
  -3.21323611e-02f, 1.10618562e-01f, -3.17179076e-02f, -1.44226402e-02f, -4.17808257e-02f, -7.11760251e-03f, -3.57713327e-02f, 4.06350344e-02f, -2.47933343e-02f, 1.15808211e-02f,
  -3.56132053e-02f, -1.07422382e-01f, 1.00808457e-01f, 1.95658132e-02f, -3.97872441e-02f, -9.77835897e-03f, -1.57592893e-02f, 5.98461144e-02f, -3.19502838e-02f, -7.53588229e-02f,
  -2.84459323e-01f, -3.88322800e-01f, -1.67453662e-01f, 1.43650137e-02f, -2.96763182e-02f, -1.27767837e-02f, -4.47080620e-02f, 4.41610627e-02f, -5.54909259e-02f, -3.43444347e-02f,
  1.24434521e-03f, -1.40974149e-01f, -1.86616629e-02f, 3.26009318e-02f, -9.38332081e-02f, 1.38910776e-02f, -1.08361557e-01f, -4.47245613e-02f, -1.25183493e-01f, 7.18654320e-03f,
  -1.18995365e-02f, -2.27000341e-02f, -7.76033700e-02f, 5.04304320e-02f, -9.04517993e-02f, 4.65295315e-02f, 1.72773693e-02f, 1.31205898e-02f, -4.31703627e-02f, 1.62033867e-02f,
  3.71457517e-01f, -4.72898990e-01f, -8.53028446e-02f, 1.28088132e-01f, 2.98729241e-01f, 9.64569226e-02f, 1.63299322e-01f, 1.72169041e-02f, 2.56489497e-03f, -1.77771881e-01f,
  1.69296525e-02f, -9.28458124e-02f, -1.94442391e-01f, -3.87955420e-02f, 2.79850900e-01f, -2.13847682e-01f, 6.98856190e-02f, 2.68485174e-02f, -7.36460239e-02f, -6.17106482e-02f,
  1.09538510e-01f, 9.88656878e-02f, -3.79876979e-02f, 1.48470076e-02f, 8.60152692e-02f, -6.28928691e-02f, -6.26609325e-02f, 6.96450770e-02f, 4.54575848e-03f, 1.41094416e-01f,
  8.62329155e-02f, -8.23938623e-02f, -1.49983643e-02f, -3.15395184e-02f, -4.08239998e-02f, -1.92800201e-02f, -5.09836413e-02f, 3.02530680e-04f, 1.24095920e-02f, -4.41052429e-02f,
  -5.91400675e-02f, -2.87210811e-02f, 9.24530849e-02f, 4.81247157e-02f, 6.92284107e-02f, 2.59225033e-02f, 3.89638804e-02f, -4.83655073e-02f, -5.99941090e-02f, -1.21949516e-01f,
  -1.44480750e-01f, -6.33044839e-02f, 1.57547817e-02f, 2.72304490e-02f, -1.59554761e-02f, 4.14959006e-02f, -6.22085929e-02f, -9.99917164e-02f, -6.12407597e-03f, -9.91160702e-03f,
  3.01386416e-03f, 6.06436692e-02f, 2.31590532e-02f, 3.03758085e-02f, 2.40814639e-03f, -1.67992394e-02f, 7.31699094e-02f, -7.99447224e-02f, -1.74238347e-02f, -6.07125610e-02f,
  6.60812408e-02f, 3.64868320e-03f, -8.58289748e-02f, 2.29610293e-03f, 3.46739180e-02f, 2.79611768e-03f, 2.42432076e-02f, -1.32880500e-02f, -1.31775104e-02f, -3.77680883e-02f,
  4.55310494e-02f, -3.12178414e-02f, 8.76296535e-02f, -3.59610887e-03f, 1.68416277e-02f, 2.77569070e-02f, -2.47729290e-02f, -2.70480267e-03f, -3.67836282e-02f, 2.84696626e-03f,
  -8.33900496e-02f, -2.51880258e-01f, 1.68609545e-02f, 1.88480038e-02f, -5.51761165e-02f, -2.40470897e-02f, -9.21822153e-03f, -3.24191377e-02f, -7.79150277e-02f, 4.73290356e-03f,
  -3.11852470e-02f, 8.39262605e-02f, 7.33670741e-02f, 1.88540411e-03f, -2.54546627e-02f, 1.22945458e-01f, -9.79165584e-02f, 1.78812761e-02f, -6.07437231e-02f, -9.90795270e-02f,
  -3.60670208e-04f, -2.73780487e-02f, 4.99961711e-02f, 4.63348487e-03f, -5.24133928e-02f, 7.97785074e-02f, -3.59082110e-02f, 2.28390358e-02f, -2.84739118e-02f, -1.13665737e-01f,
  1.93129495e-01f, -1.54939690e-03f, 3.86673272e-01f, -6.67567551e-02f, 7.05387071e-02f, 7.76547566e-02f, 1.30873963e-01f, -3.54424082e-02f, -8.67283791e-02f, -1.84734061e-01f,
  6.56842217e-02f, 1.82017609e-01f, 1.68937013e-01f, -1.00039355e-01f, 1.75233722e-01f, -2.60110833e-02f, -1.71647266e-01f, -1.03303097e-01f, -1.20460577e-01f, -1.42994598e-01f,
  -7.35532939e-02f, -1.11307621e-01f, 1.65047884e-01f, -1.86982721e-01f, 7.54548535e-02f, -2.95329988e-02f, -2.76356880e-02f, 6.45781085e-02f, -7.54551962e-02f, 9.01090056e-02f,
  -1.50717705e-01f, -7.98272789e-02f, 4.55621406e-02f, 2.28984887e-03f, 7.35504506e-03f, 6.20372631e-02f, 2.16047261e-02f, 1.57552913e-01f, 7.92014319e-03f, 8.10317174e-02f,
  1.17128849e-01f, 4.48245145e-02f, -1.03129685e-01f, 1.09891571e-01f, -8.10466036e-02f, 1.77697986e-02f, 2.75040530e-02f, 2.31894646e-02f, 1.14426009e-01f, 1.97197106e-02f,
  1.06420957e-01f, 6.37688786e-02f, -3.89638394e-02f, 1.23602645e-02f, 3.99539713e-03f, -7.36342371e-02f, -2.63829939e-02f, 1.31617412e-01f, -4.02703509e-02f, 1.17168427e-02f,
  -3.68938148e-02f, -7.08043352e-02f, -1.66983493e-02f, -8.82358570e-03f, -1.93495434e-02f, -9.84975137e-03f, -2.05395855e-02f, -2.63524558e-02f, -3.35857123e-02f, 2.73621501e-03f,
  -6.59801960e-02f, -9.32289846e-03f, -9.47317928e-02f, -2.59537641e-02f, -3.18951830e-02f, -3.41977030e-02f, 4.71418351e-02f, 2.90750861e-02f, -8.26744661e-02f, -7.58985337e-03f,
  -1.32842492e-02f, -6.20599166e-02f, 4.07898054e-02f, 7.83133879e-02f, 4.74112481e-02f, 1.38957709e-01f, -2.78061908e-02f, 1.36312976e-01f, 2.60992516e-02f, 1.87484138e-02f,
  -3.39870423e-01f, -2.08466157e-01f, -2.31936276e-02f, 1.44640552e-02f, -2.23087035e-02f, 1.15135936e-02f, -5.03126755e-02f, -4.95196655e-02f, -1.28706500e-01f, 3.84188332e-02f,
  -1.45860351e-04f, -4.67662653e-03f, -7.87342265e-02f, 2.47551035e-02f, -2.55255923e-02f, -1.71058229e-03f, -5.56376530e-03f, -1.31900430e-01f, -1.16498917e-02f, -5.07429428e-02f,
  -5.57264797e-02f, -4.43403535e-02f, 7.46242329e-02f, 2.30351854e-02f, -4.31164540e-02f, -4.25568260e-02f, -6.23184592e-02f, -7.54534453e-02f, 3.94721627e-02f, 3.74212153e-02f,
  -1.63131714e-01f, -1.51039258e-01f, -1.94377363e-01f, -2.61460274e-01f, 1.50273904e-01f, 5.45507595e-02f, -1.46695778e-01f, 2.25747526e-02f, -1.12271950e-01f, 7.71481916e-02f,
  -5.02913781e-02f, -1.59184828e-01f, -2.99011096e-02f, -2.98583120e-01f, -3.15420419e-01f, -2.66852379e-01f, -2.13193953e-01f, -1.18429422e-01f, -1.63792983e-01f, 7.59902894e-02f,
  -1.73996106e-01f, -1.66001022e-02f, -2.42749542e-01f, 2.00785026e-01f, -1.64702535e-03f, 3.25403884e-02f, 2.37185165e-01f, 1.92161158e-01f, 2.66556591e-02f, -1.38826594e-02f,
  -8.77956375e-02f, 3.90801914e-02f, 6.47012983e-03f, -8.37980420e-04f, 8.85069668e-02f, 1.07165672e-01f, 1.27567649e-01f, -6.92584589e-02f, -5.53256907e-02f, -1.14262877e-02f,
  6.99266419e-02f, -6.37467504e-02f, 1.51332198e-02f, 9.19525512e-03f, 6.00044280e-02f, -2.96218656e-02f, -8.94160271e-02f, -7.18872845e-02f, -4.68872264e-02f, -5.88182509e-02f,
  -9.84627381e-02f, 2.47526020e-02f, 1.35588748e-02f, -9.30836704e-03f, -5.11512607e-02f, 3.17138880e-02f, -4.52710390e-02f, 5.92652848e-03f, 1.12807192e-02f, -5.38236499e-02f,
  2.23774603e-03f, 1.13535725e-01f, -2.28482634e-02f, -8.74000192e-02f, -4.29468341e-02f, 1.07093612e-04f, -2.76759919e-02f, -2.08985843e-02f, -9.25782770e-02f, 7.58435503e-02f,
  4.94270818e-03f, -4.94490452e-02f, 1.87359024e-02f, 3.85603085e-02f, 2.93240091e-03f, -5.69537468e-02f, 7.26984218e-02f, 1.71387605e-02f, -1.59836244e-02f, -6.89074770e-02f,
  8.51042941e-03f, -5.28182741e-03f, -3.38146277e-02f, 8.03720802e-02f, 1.43461479e-02f, -4.24918383e-02f, 2.37733256e-02f, -1.13289086e-02f, -2.67789438e-02f, 2.04600766e-03f,
  7.25292861e-02f, 1.39488921e-01f, -2.39711031e-02f, -5.26657840e-03f, 3.75074930e-02f, -3.12547246e-03f, -3.29828449e-02f, 2.53962949e-02f, 1.57070793e-02f, 5.22410274e-02f,
  1.01209931e-01f, 5.10923453e-02f, 9.32117105e-02f, 1.26279974e-02f, -8.27803835e-03f, -8.90360400e-03f, 8.25027898e-02f, 6.10885769e-02f, 6.49176389e-02f, 2.91106422e-02f,
  9.52207670e-02f, 6.43936992e-02f, -7.55257532e-03f, -1.85324661e-02f, 4.45613917e-03f, 2.24708300e-02f, 3.25604826e-02f, -4.35644500e-02f, -4.04284475e-03f, -7.56301209e-02f,
  -1.88731983e-01f, -6.53435364e-02f, -1.70826703e-01f, -1.70102641e-01f, 1.31018087e-01f, -2.30430618e-01f, -1.69093817e-01f, -1.05775893e-02f, 5.71444258e-03f, 1.44859001e-01f,
  1.26483902e-01f, -5.70264459e-03f, 9.45150778e-02f, -1.41177237e-01f, -3.03768396e-01f, -7.97925964e-02f, -3.16814423e-01f, -1.76576450e-01f, -1.21958312e-02f, -1.00970156e-01f,
  -2.06061602e-01f, -3.00541520e-02f, -2.27424026e-01f, 8.64117369e-02f, -8.88269618e-02f, -2.46101543e-02f, 9.80535448e-02f, 1.50378332e-01f, -1.50552437e-01f, -3.86512354e-02f,
  4.55245725e-04f, 9.87020656e-02f, 6.17291704e-02f, 6.78105950e-02f, -4.94263209e-02f, -6.41022921e-02f, -4.25738692e-02f, 1.22757636e-01f, 3.09571214e-02f, -4.41191830e-02f,
  -2.60824766e-02f, 9.46645904e-03f, -4.70827743e-02f, 5.81299653e-04f, 4.79348823e-02f, -4.37151501e-03f, -7.06443377e-03f, -5.29276533e-03f, -5.66009320e-02f, -6.05830364e-02f,
  -1.61390007e-02f, 2.41209217e-03f, -1.51870027e-01f, -1.49830314e-03f, -1.02914318e-01f, 3.42226103e-02f, -2.44176500e-02f, 6.33605346e-02f, -3.01768854e-02f, -1.17503637e-02f,
  3.82979326e-02f, -4.30272818e-02f, 2.61469819e-02f, 9.39563140e-02f, 8.92174542e-02f, 4.37329635e-02f, 3.51234362e-03f, 5.34947552e-02f, -3.93918268e-02f, -1.64784342e-02f,
  6.01819828e-02f, 8.86196736e-03f, 3.08506992e-02f, -7.44866729e-02f, -6.03251345e-02f, 8.97459313e-02f, -2.44928021e-02f, 4.29662652e-02f, -7.50364736e-02f, -8.15450624e-02f,
  9.37332585e-03f, 3.81999984e-02f, 2.08101477e-02f, -5.08992514e-03f, -4.57003107e-03f, 6.46953750e-03f, -2.75870711e-02f, -3.10231391e-02f, 2.81270929e-02f, -5.58714569e-03f,
  -2.90548801e-02f, -4.15749997e-02f, 9.90592092e-02f, 2.62097996e-02f, -5.90940118e-02f, -9.47006792e-03f, -4.78977617e-03f, -1.13121055e-01f, -1.12941124e-01f, -2.20054518e-02f,
  5.37326746e-02f, -2.11091749e-02f, -1.63524196e-01f, 7.76132243e-03f, -2.52913274e-02f, -2.26522479e-02f, -5.12986118e-03f, -3.14184390e-02f, -6.85538277e-02f, -5.45623489e-02f,
  -3.45078819e-02f, 1.85462870e-02f, -1.24143604e-02f, -5.96702769e-02f, 4.13835980e-02f, -4.87459637e-03f, -3.88156809e-02f, 4.24317680e-02f, 1.74593590e-02f, 5.86435534e-02f,
  8.57278258e-02f, -1.30038425e-01f, -2.14083627e-01f, -1.93366215e-01f, -8.15989524e-02f, -2.09621593e-01f, -2.24962741e-01f, -1.06772348e-01f, 8.85078236e-02f, 4.85684443e-03f,
  -6.69986457e-02f, 1.60091981e-01f, 1.39441594e-01f, -2.28630692e-01f, 1.15567058e-01f, 2.24185474e-02f, -2.25904271e-01f, -1.40259624e-01f, 6.28750250e-02f, -2.06322685e-01f,
  3.31815593e-02f, -1.33188918e-01f, -1.48406982e-01f, -1.66954130e-01f, -2.06511185e-01f, -6.74047098e-02f, 5.38673326e-02f, -1.32212207e-01f, -1.23741411e-01f, 7.99660459e-02f,
  -6.50778189e-02f, 1.61566988e-01f, 1.45409526e-02f, 5.72064966e-02f, -6.03222735e-02f, -2.81623993e-02f, -6.12978488e-02f, 5.16886264e-02f, 6.71684146e-02f, 5.03619947e-02f,
  7.70411640e-02f, 3.31640728e-02f, 1.27709964e-02f, 8.40688497e-02f, -1.16794795e-01f, -1.88079216e-02f, 5.80573417e-02f, -3.28296944e-02f, -2.15406772e-02f, -2.87683513e-02f,
  -3.17757279e-02f, 3.92346308e-02f, -9.87075716e-02f, 1.07842728e-01f, -1.40410317e-02f, -5.40049560e-03f, -6.54747859e-02f, -6.32519694e-03f, -5.44399135e-02f, 5.85249029e-02f,
  3.08985207e-02f, -4.05088924e-02f, -3.57283354e-02f, -2.04162579e-02f, -2.97392886e-02f, -9.41803213e-03f, 4.80726510e-02f, -2.09966097e-02f, -5.67123592e-02f, 7.95749128e-02f,
  4.04499620e-02f, -2.56735664e-02f, -4.36862325e-03f, -6.98485970e-02f, 1.27373291e-02f, 1.97676048e-02f, 6.12531267e-02f, -1.42010739e-02f, 3.47909890e-02f, 6.66230870e-03f,
  2.16109361e-02f, -9.51800197e-02f, 2.12827865e-02f, -2.98796985e-02f, -9.25323926e-03f, -1.59165298e-03f, -2.85427872e-04f, -3.00380960e-03f, 7.08824098e-02f, -9.37376544e-03f,
  -1.13237854e-02f, -6.63880557e-02f, 9.46338847e-02f, 6.21691421e-02f, 1.22313552e-01f, -2.81935595e-02f, -6.70954064e-02f, 3.02029736e-02f, -2.20727865e-02f, 6.47793561e-02f,
  -1.10277057e-01f, 1.07038617e-02f, -6.54638782e-02f, 4.93010692e-03f, -3.14454362e-02f, -4.42600287e-02f, 2.10588519e-03f, -6.75210264e-03f, -1.81284547e-02f, 8.90920684e-03f,
  -2.94355564e-02f, 4.07477356e-02f, 1.06573991e-01f, -4.34182920e-02f, -4.60872874e-02f, 3.66843864e-02f, 2.62989365e-02f, -5.57409227e-02f, 1.16046369e-02f, -7.77100921e-02f,
  1.87489972e-01f, -1.41959652e-01f, -2.52174586e-01f, -7.25787180e-03f, 1.04685649e-01f, 1.25736147e-01f, 7.34926760e-02f, 4.08737771e-02f, -1.12970173e-01f, 2.15969265e-01f,
  1.28701210e-01f, -7.00782090e-02f, -1.53015316e-01f, 3.39977980e-01f, 2.75890052e-01f, -2.65574344e-02f, 3.64130288e-01f, 1.46286607e-01f, -1.12294011e-01f, -4.96179573e-02f,
  7.15273023e-02f, 4.00366783e-01f, -1.17213130e-01f, 8.77134800e-02f, 1.54790372e-01f, -2.20974207e-01f, 4.97063808e-02f, -1.47002116e-01f, 2.51494944e-01f, 1.65162131e-01f,
  6.59159198e-02f, -2.54742187e-02f, -3.45315784e-02f, 1.05322488e-02f, -6.69659153e-02f, 2.62024277e-03f, -3.58845829e-03f, 5.79028390e-02f, -5.30972108e-02f, -6.01743488e-03f,
  1.23610524e-02f, -1.30234398e-02f, 1.27007470e-01f, -1.85824316e-02f, 8.18835422e-02f, 3.45717035e-02f, -1.83199346e-02f, -3.31547149e-02f, -4.30291593e-02f, -9.81905125e-03f,
  -1.15125608e-02f, -6.18871488e-02f, -3.74281226e-04f, 2.67140437e-02f, -9.87797007e-02f, -7.33679384e-02f, -2.29114182e-02f, -9.03830156e-02f, 3.84828486e-02f, -5.97704388e-02f,
  6.31619841e-02f, 3.63413505e-02f, -5.89323156e-02f, 5.00639901e-02f, 3.54584046e-02f, -2.24286839e-02f, 4.45642099e-02f, 4.06976864e-02f, -5.43798991e-02f, 2.54668482e-02f,
  1.44264183e-03f, 6.33045360e-02f, 4.35948139e-03f, 5.82940876e-02f, 1.02421775e-01f, -1.58055015e-02f, -1.00237623e-01f, 3.71123105e-02f, -3.06234378e-02f, 5.77782579e-02f,
  -5.99383339e-02f, -1.81106629e-03f, -2.90803313e-02f, -4.08438640e-03f, 8.38501845e-03f, -2.58934926e-02f, 7.21559525e-02f, 4.97650579e-02f, -7.64471889e-02f, 4.98154946e-02f,
  5.14109805e-02f, 2.87847482e-02f, 5.50782599e-04f, -3.99605697e-03f, 2.33954471e-02f, 6.59536421e-02f, 9.87332594e-03f, 3.03145945e-02f, 4.92712408e-02f, -1.23214936e-02f,
  1.19523872e-02f, -4.82074581e-02f, 4.55618314e-02f, -2.89965682e-02f, 7.78822005e-02f, 2.50947643e-02f, 4.88387011e-02f, -8.51365626e-02f, 8.00350010e-02f, 4.45943028e-02f,
  -1.99717898e-02f, 7.65298319e-04f, 1.71760563e-02f, -1.00572594e-01f, 4.37337868e-02f, -2.08741389e-02f, -1.83089189e-02f, -4.73394990e-02f, 1.38039216e-02f, -5.29871136e-02f,
  -6.92368746e-02f, -1.41692281e-01f, -2.44691670e-01f, -9.83338654e-02f, -2.31452942e-01f, -1.73701793e-01f, -2.68451869e-01f, 2.97096856e-02f, -3.00334059e-02f, 9.19639990e-02f,
  -1.22105898e-02f, 1.45171955e-01f, 2.44433820e-01f, -1.79154456e-01f, 1.10911652e-01f, 1.67986318e-01f, -1.94349840e-01f, 6.27647899e-03f, -7.56769180e-02f, -6.97725564e-02f,
  -2.72427425e-02f, -4.11135517e-02f, -1.33927420e-01f, 1.40039278e-02f, -2.63586521e-01f, -9.09479409e-02f, -1.23469979e-01f, -1.95707723e-01f, -3.05471182e-01f, -1.62338793e-01f,
  -1.39119163e-01f, 1.08920358e-01f, -1.01241976e-01f, 4.57275659e-02f, 3.09541933e-02f, 7.27382973e-02f, -1.36257172e-01f, -7.56265372e-02f, 1.30698960e-02f, 3.87554765e-02f,
  1.01304092e-01f, 6.76500276e-02f, -6.73018070e-03f, 1.05005756e-01f, -9.27362777e-03f, 4.58385274e-02f, -4.27891798e-02f, -4.52797934e-02f, 4.21123877e-02f, -3.28467973e-02f,
  -1.30424614e-03f, -9.07647535e-02f, -8.18147436e-02f, 1.13572087e-02f, -1.21046521e-01f, -5.51999286e-02f, -2.95133572e-02f, -7.36226365e-02f, -4.45841141e-02f, -4.89399862e-03f,
  -2.80426554e-02f, 2.25719418e-02f, 3.52571066e-03f, 1.84996538e-02f, -1.97572485e-02f, -1.95679627e-02f, -2.81939935e-02f, 2.64894944e-02f, -3.50297205e-02f, -2.79227179e-02f,
  -2.92674769e-02f, 4.13733609e-02f, -1.42512266e-02f, 3.12102260e-03f, -7.26305768e-02f, 4.47629951e-02f, 5.13111390e-02f, -6.43109949e-03f, -2.55831499e-02f, -2.83496324e-02f,
  4.29059565e-02f, -3.28156613e-02f, 1.43516427e-02f, -4.35965788e-03f, 1.32409893e-02f, 4.63533923e-02f, -6.82405755e-02f, -2.38434449e-02f, -4.03102413e-02f, 4.72330861e-02f,
  -1.08354270e-01f, -1.26411110e-01f, 4.36665937e-02f, -4.24534176e-03f, -5.38249547e-03f, 7.88020790e-02f, -1.58860423e-02f, -4.15097028e-02f, -1.24955371e-01f, 2.13616807e-02f,
  4.55041379e-02f, 2.76528765e-02f, -4.33343351e-02f, -7.52520561e-02f, 4.94949259e-02f, -9.17480048e-03f, -1.39971252e-03f, -1.67515539e-02f, -7.91381225e-02f, -2.72510126e-02f,
  7.93782324e-02f, 7.70662501e-02f, 1.20935179e-01f, 1.93930101e-02f, 3.36546302e-02f, -7.57619739e-02f, -2.29322370e-02f, -1.58970943e-03f, -2.89948173e-02f, -4.40392867e-02f,
  -5.09726763e-01f, 2.25269392e-01f, -3.51931840e-01f, 1.05316676e-01f, -2.52284735e-01f, 2.12848246e-01f, 1.67836666e-01f, 1.20733880e-01f, 2.01774031e-01f, 3.69201928e-01f,
  2.40322441e-01f, -2.74235867e-02f, 1.54835775e-01f, 3.14204127e-01f, -2.79355943e-01f, 1.77063853e-01f, 1.94738656e-01f, 1.09355047e-01f, -5.75418025e-02f, -3.48437279e-02f,
  -1.19635209e-01f, 1.91279933e-01f, -8.84012654e-02f, -1.07025437e-01f, -1.67954341e-02f, -1.98173955e-01f, 3.93600836e-02f, -1.93056092e-01f, 6.00282997e-02f, -4.34506238e-02f,
  4.28298637e-02f, -1.10334024e-01f, -7.83896744e-02f, -6.39419779e-02f, -4.98737255e-03f, -3.23198847e-02f, -1.17800057e-01f, -1.18885063e-01f, -2.84472071e-02f, 4.42599766e-02f,
  4.03361060e-02f, -8.99774879e-02f, 5.14253862e-02f, -2.05815211e-02f, -8.81866142e-02f, -3.33414897e-02f, -1.33298924e-02f, 9.89660025e-02f, 2.57823039e-02f, -6.13290817e-02f,
  -7.99874440e-02f, -8.81328732e-02f, 1.40852499e-04f, 4.57491577e-02f, -3.41560841e-02f, 4.51109447e-02f, 6.38918430e-02f, -3.17163207e-02f, 5.57335932e-03f, 1.65532473e-02f,
  -7.93826729e-02f, -6.61930535e-03f, -1.93410199e-02f, 6.97255433e-02f, -3.90766747e-02f, 1.49055151e-02f, 2.17545014e-02f, -2.58464087e-02f, -5.94181567e-02f, 6.17772304e-02f,
  -4.95215412e-03f, 2.51317900e-02f, 1.46112009e-03f, 2.16147378e-02f, 5.87399527e-02f, 3.89406718e-02f, -2.33771112e-02f, 1.18833547e-02f, -4.03570756e-03f, 1.74435135e-02f,
  6.27151653e-02f, -7.56807765e-03f, 7.22577348e-02f, 8.90600085e-02f, -2.45554429e-02f, -2.82696262e-02f, 1.56734623e-02f, -2.93161580e-03f, 3.88034433e-02f, -5.30231185e-02f,
  2.36357555e-01f, -5.33827581e-02f, 3.58193815e-02f, 9.75958724e-03f, 1.25189936e-02f, -9.02109221e-02f, 6.10425696e-02f, -3.30226459e-02f, -2.23020557e-02f, -6.70418292e-02f,
  -7.93224946e-03f, -5.47158765e-03f, -7.69431144e-02f, 4.20846716e-02f, -4.45199944e-02f, 8.43392313e-02f, 4.65606246e-03f, -3.69612616e-03f, 2.07274649e-02f, -1.35953939e-02f,
  1.13290530e-02f, -2.32860837e-02f, -5.54979406e-02f, 4.44744639e-02f, -2.96126772e-02f, 8.34305212e-02f, -3.35226804e-02f, -3.14942971e-02f, -4.65930179e-02f, 2.31536943e-02f,
  3.06899250e-01f, -1.93160415e-01f, -1.35947064e-01f, 2.00188056e-01f, 8.82217884e-02f, 2.05413904e-03f, -8.22564587e-02f, 1.91374570e-01f, 3.97355445e-02f, -1.92758292e-01f,
  3.72807495e-02f, -1.60543099e-01f, -2.03067437e-01f, 1.45906508e-01f, 9.10916477e-02f, -2.17920110e-01f, 1.98626250e-01f, -3.60212033e-03f, -6.30181329e-03f, -2.44255215e-02f,
  2.19075441e-01f, 1.67927355e-01f, 6.55767024e-02f, 8.90070796e-02f, 3.39607708e-02f, 1.11967929e-01f, 1.15278386e-01f, -1.30891383e-01f, 2.09391862e-01f, -3.27210166e-02f,
  -2.68443488e-02f, 4.69920523e-02f, 5.09859174e-02f, -1.15663456e-02f, 5.61367050e-02f, 2.94445138e-02f, -9.90682170e-02f, 7.98853114e-03f, -5.01958020e-02f, 1.04656275e-02f,
  -4.41470630e-02f, 1.08452410e-01f, 9.91445482e-02f, 8.54201764e-02f, 1.77317802e-02f, 7.21508786e-02f, 8.61322805e-02f, -4.32934128e-02f, -2.48687752e-02f, 3.27184908e-02f,
  -5.88972457e-02f, 5.22940829e-02f, -9.98992473e-02f, 2.06913389e-02f, 5.20058325e-04f, -1.45350560e-03f, -2.31492501e-02f, -1.10470429e-01f, -3.51461768e-02f, 6.41764328e-02f,
  1.07341981e-03f, -1.35753870e-01f, 1.38891314e-03f, 5.60070165e-02f, 3.17592695e-02f, 6.21330515e-02f, 3.17001203e-03f, 3.43789570e-02f, -1.09433720e-03f, 5.87547049e-02f,
  5.96385896e-02f, 1.20630257e-01f, -1.00478316e-02f, 1.27293309e-02f, -2.72602849e-02f, 2.03929693e-02f, -4.67328262e-03f, -1.90934967e-02f, -8.88904408e-02f, 1.27247267e-03f,
  -5.98087646e-02f, 2.32925508e-02f, -3.21389586e-02f, 3.44708972e-02f, -1.45789003e-02f, 1.81157794e-02f, 1.61421522e-02f, -3.49627621e-02f, 6.40872726e-03f, -3.44575793e-02f,
  -7.38921985e-02f, -1.02788240e-01f, -9.50240344e-02f, 3.18637565e-02f, -5.82879037e-02f, -3.46400924e-02f, -2.86332071e-02f, 8.49304199e-02f, 1.66854206e-02f, -1.09782564e-02f,
  4.39238250e-02f, -7.22518861e-02f, -8.45053867e-02f, 9.55837443e-02f, 7.37070963e-02f, 3.37768905e-02f, 1.89169645e-02f, -1.93006881e-02f, 2.91273091e-02f, 1.24530941e-01f,
  -9.90265384e-02f, 6.83842897e-02f, -7.32518435e-02f, -4.36108885e-03f, 4.80108075e-02f, -7.03053474e-02f, 2.80405898e-02f, 2.26693377e-02f, -5.98854162e-02f, 5.79078384e-02f,
  3.62008899e-01f, 9.50446501e-02f, 2.94842660e-01f, 1.86456114e-01f, 3.40059623e-02f, -5.03995642e-02f, -9.24140513e-02f, -1.18888346e-02f, 1.78302661e-01f, 4.99693938e-02f,
  -8.81584883e-02f, 2.03505099e-01f, -1.82717875e-01f, 6.43135756e-02f, -3.45497072e-01f, -1.82423189e-01f, -1.37980962e-02f, 2.63952240e-02f, -4.40480188e-02f, -8.10028892e-03f,
  -4.46455367e-02f, -2.03508049e-01f, 1.49744954e-02f, -1.61933348e-01f, 2.78541416e-01f, 1.73433363e-01f, -1.47650346e-01f, -1.11428700e-01f, 8.41490775e-02f, -1.84028238e-01f,
  -5.53496294e-02f, 3.85786071e-02f, 1.31116733e-01f, 1.96896736e-02f, -3.28305215e-02f, 3.21138767e-03f, 6.36129454e-02f, -2.89695207e-02f, -2.42510275e-03f, 3.82769224e-03f,
  1.15488410e-01f, -4.85923663e-02f, 3.14227454e-02f, 2.85273157e-02f, -1.29594747e-03f, 5.26277088e-02f, 6.59091547e-02f, 1.74676374e-01f, 8.20128247e-02f, -2.79696006e-02f,
  1.98545512e-02f, 1.13247052e-01f, 1.19516894e-01f, 1.96481459e-02f, 1.86004136e-02f, -3.99961174e-02f, 7.33911470e-02f, -4.37146574e-02f, -9.52298380e-03f, 4.42299321e-02f,
  -3.74070695e-03f, -2.33339947e-02f, -1.15238480e-01f, 7.28290081e-02f, -2.30606738e-02f, -4.23686504e-02f, -1.53861633e-02f, 7.10971560e-03f, 1.90221786e-03f, -3.90785560e-02f,
  6.29504174e-02f, 5.97929358e-02f, -1.30270682e-02f, 6.08389452e-02f, 2.43057869e-02f, 1.29434541e-01f, 1.28566906e-01f, -1.85771734e-02f, -1.20455371e-02f, 3.71545069e-02f,
  5.03555164e-02f, -1.49853062e-02f, -2.76824962e-02f, 4.17652428e-02f, -3.44585367e-02f, -6.59144297e-02f, 1.57855805e-02f, 6.60637021e-02f, -1.47316768e-03f, -3.97842601e-02f,
  -2.02868029e-01f, -1.02073304e-01f, -3.96218859e-02f, -2.45264843e-02f, -9.44345444e-03f, 1.02711707e-01f, 1.58272702e-02f, -1.19147962e-02f, -1.01037286e-01f, 1.69022940e-02f,
  -1.39204394e-02f, 5.32994233e-02f, 2.59380118e-04f, 2.96113417e-02f, -1.59331188e-02f, -2.30461471e-02f, -5.69659285e-02f, -1.05028914e-03f, -1.31751196e-02f, -3.41626592e-02f,
  9.73683819e-02f, -2.42536534e-02f, 4.72382158e-02f, -3.08684469e-03f, 4.31254879e-02f, 3.56362737e-03f, 3.81493382e-02f, -1.28190527e-02f, 9.57252644e-03f, -3.52731012e-02f,
  3.51196617e-01f, -3.37421566e-01f, -1.09893210e-01f, 1.35910735e-01f, 1.59885332e-01f, 1.03201516e-01f, 7.29155988e-02f, -1.47367060e-01f, -7.51206353e-02f, -2.05365703e-01f,
  1.54226825e-01f, -3.18135321e-02f, -1.38035655e-01f, 1.57100528e-01f, 2.86108643e-01f, -1.81650206e-01f, 1.00050330e-01f, -2.29265615e-02f, -5.15023991e-02f, 7.95663670e-02f,
  4.45693955e-02f, 1.66923285e-01f, -5.17125502e-02f, -6.34664297e-02f, 1.83669049e-02f, -1.40805304e-01f, 9.89507325e-03f, -9.97286439e-02f, -3.21690589e-02f, 5.30928113e-02f,
  1.00347988e-01f, -2.18102615e-02f, 8.89991447e-02f, -5.30712791e-02f, 5.58487792e-03f, 8.69942904e-02f, 1.57891698e-02f, -5.96863043e-04f, 6.89921826e-02f, -6.80210814e-02f,
  -7.08889887e-02f, -3.34821194e-02f, -5.33271916e-02f, 1.44240130e-02f, 1.57825556e-02f, 2.42447853e-02f, -2.65711118e-02f, -5.60239293e-02f, -1.05678618e-01f, 6.68154955e-02f,
  6.30394295e-02f, -1.88010745e-02f, 1.23700891e-02f, -1.32507592e-01f, 6.81424662e-02f, -1.84932873e-02f, -8.17327350e-02f, 4.12209779e-02f, -8.06983784e-02f, 4.89624701e-02f,
  1.22433146e-02f, -6.54570311e-02f, -2.79921219e-02f, -4.64433506e-02f, 1.43439453e-02f, 1.96703617e-02f, -2.39207689e-02f, -2.03150325e-02f, 2.03383602e-02f, 6.29391968e-02f,
  1.34728877e-02f, 4.73260786e-03f, 5.99575788e-02f, -4.13765237e-02f, -4.38362584e-02f, 1.10509049e-03f, -2.20198184e-02f, 2.71207374e-02f, 4.79223207e-02f, -2.03405488e-02f,
  1.05262920e-03f, 4.96174581e-03f, -1.00543385e-03f, -1.42024472e-01f, -1.55796669e-03f, 1.42925810e-02f, 5.37114739e-02f, -3.97431999e-02f, -2.45161727e-02f, -4.82092388e-02f,
  -1.05242074e-01f, -1.30440995e-01f, -6.28867745e-02f, 7.26581812e-02f, -1.79288797e-02f, 9.44094509e-02f, -7.93143827e-03f, -5.87180629e-02f, -4.62241769e-02f, 1.31796347e-02f,
  3.81394997e-02f, -1.18454462e-02f, -1.26808733e-01f, 2.75771338e-02f, 1.83238443e-02f, -4.86515574e-02f, -8.85240659e-02f, 5.68103492e-02f, 7.05804676e-02f, 2.58343294e-04f,
  -6.07419759e-02f, -1.11953579e-02f, 5.22838123e-02f, -2.93947966e-03f, -4.15535271e-02f, -3.96296605e-02f, 7.21652657e-02f, 3.17951962e-02f, 6.20979723e-03f, 8.74330103e-03f,
  -6.15877211e-02f, 3.94992381e-02f, 4.87946048e-02f, 9.86284614e-02f, -5.98503128e-02f, -3.71472627e-01f, -3.77196759e-01f, -1.88286044e-02f, -2.19758675e-01f, -1.91263273e-01f,
  -3.07257362e-02f, 3.76211107e-02f, -2.22742915e-01f, 5.10032363e-02f, 1.37802392e-01f, -1.78356156e-01f, 2.25688368e-01f, -4.49350737e-02f, 7.41360262e-02f, 5.99884465e-02f,
  1.92580372e-01f, 1.44006416e-01f, 3.12096238e-01f, 2.94641972e-01f, 3.60692032e-02f, 1.48871273e-01f, 3.61710697e-01f, 9.66716409e-02f, 3.36556822e-01f, 2.30512500e-01f,
  -4.14534323e-02f, -1.03412159e-02f, -9.32529569e-03f, 2.97668111e-02f, -8.83531570e-02f, -7.80795366e-02f, 2.08116416e-02f, -8.43096245e-03f, 5.92562221e-02f, -4.49566133e-02f,
  -1.56168612e-02f, 5.67384474e-02f, 4.58213780e-03f, -6.56831935e-02f, 3.04268282e-02f, 3.40552032e-02f, -2.12321598e-02f, 1.10947760e-02f, 5.89296743e-02f, -1.26920596e-01f,
  5.30044287e-02f, -9.85048115e-02f, 6.49781674e-02f, 8.69282857e-02f, 6.75300434e-02f, 1.92604493e-02f, 3.75372022e-02f, 1.57291088e-02f, -5.15359594e-03f, -1.86641738e-02f,
  1.87656470e-02f, 9.44134779e-03f, 5.60013205e-02f, -2.54933555e-02f, 5.88506423e-02f, -7.97753707e-02f, 7.21207410e-02f, -3.26642990e-02f, 3.68699664e-04f, -3.79284732e-02f,
  3.62944789e-02f, -1.80996601e-02f, -6.14259019e-02f, -6.31112903e-02f, -8.21303800e-02f, -1.12070693e-02f, 4.83632982e-02f, -5.42122833e-02f, -2.89709289e-02f, 2.39693336e-02f,
  -4.92963083e-02f, 2.65493896e-02f, -5.06275855e-02f, 2.50240322e-02f, 3.55865061e-02f, -6.96994513e-02f, -5.92519343e-02f, -9.53094810e-02f, -3.12033892e-02f, 2.16133166e-02f,
  4.65202518e-03f, 1.44050628e-01f, 2.63893064e-02f, 3.52095366e-02f, -2.84843799e-02f, -5.33507951e-02f, 4.79447767e-02f, -1.93832070e-02f, 1.48125127e-01f, 2.91021285e-03f,
  -1.28386319e-02f, 2.90630031e-02f, -3.29750963e-03f, 2.05722917e-02f, 1.11757278e-01f, -3.72009259e-03f, -4.85114008e-02f, 6.41156211e-02f, 1.54095188e-01f, 1.79626346e-02f,
  5.87891880e-03f, -1.60482511e-01f, 8.00812021e-02f, -6.60584047e-02f, 3.03039104e-02f, -5.36090136e-02f, -6.14003539e-02f, 9.01654363e-02f, 7.42279217e-02f, -4.35153907e-03f,
  7.40210414e-02f, -8.38198513e-02f, 3.01449507e-01f, -7.46928006e-02f, 2.82853097e-01f, 3.40955764e-01f, 2.77246624e-01f, 1.25375032e-01f, 2.08249435e-01f, -2.25640327e-01f,
  -1.65405944e-01f, -8.04847777e-02f, 2.35672779e-02f, -2.13067040e-01f, 2.43169174e-01f, 1.22947976e-01f, 1.74340215e-02f, -1.03898846e-01f, 2.22779661e-01f, 4.58600037e-02f,
  6.79646209e-02f, -7.01307505e-02f, 1.71191141e-01f, -1.52761295e-01f, -4.80651893e-02f, -1.00841865e-01f, -2.13394955e-01f, 7.61917681e-02f, -2.73830622e-01f, -1.03853801e-02f,
  6.95267171e-02f, -9.47563872e-02f, 6.24104030e-02f, 1.57076083e-02f, 4.10359874e-02f, 1.12936310e-02f, 4.79146466e-03f, -3.03274114e-02f, 4.21070233e-02f, -6.15423545e-02f,
  -7.77778849e-02f, -1.23784579e-02f, 4.46850061e-03f, -4.53269854e-02f, 6.75596893e-02f, -2.84756115e-03f, 9.86740515e-02f, 7.14075342e-02f, 1.36332046e-02f, 9.93013456e-02f,
  7.95527175e-02f, 1.05226254e-02f, 2.42840610e-02f, -4.18457463e-02f, 6.35964051e-02f, -5.54325804e-02f, 6.97272792e-02f, 5.28472522e-03f, 5.92363738e-02f, -5.51423021e-02f,
  -8.78499169e-03f, 1.45905301e-01f, -1.65896136e-02f, -3.59163433e-02f, -5.54296710e-02f, -7.65651613e-02f, -1.65971648e-02f, 1.67637505e-02f, 4.23828512e-02f, -1.08020578e-03f,
  -6.51669223e-03f, 4.73269112e-02f, 7.92014822e-02f, 2.55295280e-02f, -1.93727016e-02f, -6.43534064e-02f, -6.31288365e-02f, -5.13351634e-02f, 2.79599484e-02f, -2.03785785e-02f,
  -3.21372226e-02f, 4.69253100e-02f, -3.85345146e-02f, -7.07249343e-02f, -6.52373359e-02f, 1.32128838e-02f, -3.66084538e-02f, -5.66014387e-02f, -1.77590903e-02f, 6.19998574e-02f,
  -4.10983004e-02f, -1.53951094e-01f, -5.10295900e-03f, 4.99475980e-03f, -5.30309752e-02f, -9.80752110e-02f, 8.07294324e-02f, -5.13324924e-02f, 2.04596408e-02f, 2.91144606e-02f,
  4.73269522e-02f, -7.77687319e-03f, 2.27371678e-02f, -2.94905268e-02f, 1.38886245e-02f, -1.31215318e-04f, -1.96904317e-02f, -1.28200429e-03f, -2.49468274e-02f, -2.67102681e-02f,
  -4.65788543e-02f, -4.80303615e-02f, -5.46018407e-02f, -1.11305207e-01f, -9.37510878e-02f, 5.04018320e-03f, -8.25073756e-03f, -3.57689299e-02f, -1.07680587e-02f, 2.14990247e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.29222298e-01f, 1.18229210e-01f, 2.20675260e-01f, 2.01009631e-01f, 1.15829937e-01f, -1.65468812e-01f, 1.85087621e-01f, -2.14314926e-02f, 2.38085911e-01f, 1.31715283e-01f,
  7.84414113e-02f, 1.26527175e-01f, 4.37444374e-02f, 3.69702667e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  5.67098521e-02f, -1.73438221e-01f, 1.18884541e-01f, -4.82160784e-02f, 2.11922884e-01f, -8.28661546e-02f, -7.46900886e-02f, 6.90820664e-02f, 4.95526493e-02f, 1.12137847e-01f,
  -9.67886895e-02f, -3.99304748e-01f, -3.56576592e-01f, -1.17098495e-01f, -1.54150546e-01f, -4.02086526e-01f, 1.38129637e-01f, -4.00525890e-02f, 2.48144493e-01f, -2.51064956e-01f,
  6.38176501e-02f, 1.45607144e-01f, 2.89862216e-01f, 1.05143271e-01f, -1.93932459e-01f, 1.18252963e-01f, -2.84442395e-01f, -2.03129098e-01f, 2.54658461e-01f, -2.69306839e-01f,
  -1.90219939e-01f, 1.26705272e-03f, 7.78080821e-02f, 4.60546650e-02f, 8.27625319e-02f, 9.23801512e-02f, 1.50306612e-01f, -1.80791728e-02f, -1.51938945e-02f, 1.28953069e-01f,
  5.32144904e-02f, 1.49948552e-01f, -1.49599642e-01f, 1.07541859e-01f, 9.15728435e-02f, 1.73210159e-01f, -9.23886374e-02f, 1.06070712e-01f, -4.10145909e-01f, 1.06888570e-01f,
  4.12496477e-01f, -6.53753355e-02f, 3.20426375e-01f, -3.07491571e-01f, 1.64497495e-01f, 2.13996187e-01f, -2.31264099e-01f, 4.19650925e-03f, -2.35686183e-01f, -2.55206496e-01f,
  1.80299997e-01f, -2.97752675e-02f, -1.91322625e-01f, 5.12454212e-01f, -7.38888979e-02f, -2.87724826e-02f, 3.36170867e-02f, 8.16016123e-02f, 3.92798363e-04f, -2.30271190e-01f,
  -9.69863981e-02f, 1.76895201e-01f, -1.17408320e-01f, 2.70597905e-01f, -6.55353814e-03f, 2.85703748e-01f, 5.19558340e-02f, 3.21682319e-02f, 6.42616674e-02f, 1.04274444e-01f,
  3.03122431e-01f, 2.65960664e-01f, -1.53366908e-01f, -1.31436914e-01f, 9.17467177e-02f, -8.89760181e-02f, 1.96393773e-01f, 2.13277444e-01f, 2.55645722e-01f, 3.14906269e-01f,
  2.02518702e-01f, -2.83088714e-01f, -3.08572948e-01f, -9.45716277e-02f, -2.35552236e-01f, -1.80565771e-02f, -1.44647378e-02f, -9.16662887e-02f, 2.08750293e-01f, 1.01674557e-01f,
  -3.64398882e-02f, -1.15846328e-01f, 5.84968962e-02f, 9.30810627e-03f, -1.14716813e-01f, 2.94040769e-01f, -6.18514344e-02f, 8.76691341e-02f, 4.85201878e-03f, 5.03005683e-02f,
  5.56290597e-02f, 8.41337815e-02f, 2.27102846e-01f, 6.23909608e-02f, -1.35024890e-01f, 7.78374746e-02f, 1.30681649e-01f, -2.47239590e-01f, -1.88505769e-01f, 2.86596566e-02f,
  1.11025199e-01f, -3.18617187e-02f, 4.11420673e-01f, -5.78101426e-02f, -8.90544504e-02f, 5.03643863e-02f, -2.41343558e-01f, 1.14239581e-01f, 2.29811333e-02f, -1.12734340e-01f,
  -2.13626638e-01f, 2.35217229e-01f, 9.37646553e-02f, 9.61305052e-02f, 3.28492299e-02f, 2.08619367e-02f, -1.32199869e-01f, 2.84439903e-02f, -3.44415337e-01f, 9.05562565e-02f,
  -1.78027265e-02f, -2.29593188e-01f, -2.54947990e-01f, 1.64440826e-01f, -3.39515775e-01f, 1.65317148e-01f, 9.48624238e-02f, -4.00831759e-01f, -2.23981798e-01f, 4.81697433e-02f,
  3.17766070e-02f, -6.30980581e-02f, -1.03070699e-01f, 2.08559424e-01f, 1.82015166e-01f, -1.22614883e-01f, -7.88305476e-02f, -3.25128406e-01f, 3.09125453e-01f, -7.45949475e-03f,
  3.56513523e-02f, 9.94365197e-03f, 6.84847012e-02f, -1.21551566e-01f, -8.87952670e-02f, 9.73499864e-02f, 9.03702900e-02f, 7.40543753e-02f, 8.44796300e-02f, -3.73254716e-02f,
  2.40316972e-01f, 1.55251147e-02f, -5.63842542e-02f, 1.68667823e-01f, 7.98606649e-02f, -1.51291460e-01f, -7.93673992e-02f, -1.83578953e-01f, 1.23714805e-01f, 1.87043324e-01f,
  2.42184415e-01f, -5.93277253e-02f, -1.87687784e-01f, -2.46638432e-01f, 3.27266268e-02f, -3.06537181e-01f, -1.81996394e-02f, 8.03700238e-02f, 3.40942770e-01f, 1.91138059e-01f,
  -4.87858690e-02f, 9.65368375e-02f, -5.95723353e-02f, 1.94552556e-01f, -9.35380161e-02f, -3.47437151e-02f, -2.68620014e-01f, 2.94199232e-02f, -1.14218436e-01f, -1.07225373e-01f,
  5.73124029e-02f, -4.14881669e-02f, 2.28920698e-01f, 2.65414387e-01f, 1.83404431e-01f, 2.99874783e-01f, 1.87898025e-01f, 2.73058385e-01f, -1.46491706e-01f, 1.58665981e-02f,
  -1.16512395e-01f, 3.31016630e-01f, -6.54446036e-02f, -2.22692922e-01f, 1.79141492e-03f, 2.74280198e-02f, 1.12700284e-01f, 1.24368414e-01f, -2.38412488e-02f, 1.23056844e-01f,
  -9.23815146e-02f, 2.18542203e-01f, 3.43828388e-02f, 3.97171974e-02f, -2.28938267e-01f, 2.89640874e-01f, 4.94458489e-02f, 8.64540786e-02f, -6.40595108e-02f, 2.51802821e-02f,
  -4.63679433e-02f, 1.99306160e-02f, 1.89971086e-02f, -1.78194135e-01f, 2.13486671e-01f, 3.81713629e-01f, -3.08013577e-02f, 3.09115261e-01f, -2.25902200e-02f, 2.09835529e-01f,
  -2.90563554e-01f, 1.42216980e-02f, 1.06597990e-01f, -3.33214961e-02f, -1.87843516e-01f, -2.34119669e-01f, -2.13678762e-01f, 1.29370093e-01f, -1.21915355e-01f, 2.45249853e-01f,
  -2.58956969e-01f, 1.37161329e-01f, 1.20609373e-01f, -7.68944025e-02f, 2.83700466e-01f, 1.33505702e-01f, 9.70989913e-02f, -1.65035591e-01f, 9.02193189e-02f, -5.14044538e-02f,
  1.13542683e-01f, -8.49050730e-02f, 6.51951432e-02f, 5.36069348e-02f, 1.38516843e-01f, 5.92302904e-02f, -1.61704451e-01f, -3.35993230e-01f, -2.13178426e-01f, -1.92823678e-01f,
  -1.95572987e-01f, -2.35307589e-01f, 1.59465805e-01f, -6.05102070e-02f, 1.58350006e-01f, -1.89763039e-01f, 9.84666720e-02f, 1.86267763e-01f, 1.70024335e-01f, -2.42736325e-01f,
  7.72990510e-02f, -2.87180841e-01f, 4.22135778e-02f, -1.70621872e-01f, 2.61802137e-01f, -7.34270662e-02f, -2.89912611e-01f, -9.88639444e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.61421913e-01f, 2.48730518e-02f, 2.12893769e-01f, 3.31576407e-01f, 3.30151320e-01f, 2.85047859e-01f, 3.35301727e-01f, 2.06856266e-01f, 1.80292040e-01f, 2.64974356e-01f,
  -1.69933178e-02f, -1.64294362e-01f, -6.19090954e-03f, -1.09280255e-02f, 1.88890204e-01f, 2.05797672e-01f, 2.08197519e-01f, 1.26734644e-01f, -1.38319969e-01f, 2.45534837e-01f,
  1.52547821e-01f, 2.61832058e-01f, 4.56383787e-02f, -2.82158107e-01f, 1.85372517e-01f, -8.17041099e-03f, 4.93508965e-01f, -2.30911747e-02f, 1.80102624e-02f, 2.65663058e-01f,
  -1.46108791e-01f, 4.02175426e-01f, 2.98827171e-01f, 2.04804584e-01f, 1.43604696e-01f, 1.25195146e-01f, 2.44743422e-01f, 9.65315476e-02f, 2.11936980e-01f, 2.74654448e-01f,
  6.11295849e-02f, -6.16325736e-02f, 1.12116657e-01f, 1.40187010e-01f, -7.54193775e-03f, -1.46213949e-01f, 1.83041707e-01f, 2.34518468e-01f, 3.16259742e-01f, 2.11581942e-02f,
  -3.14808190e-01f, 6.63372055e-02f, 8.14154893e-02f, 1.78639352e-01f, 5.09286672e-02f, -2.24544495e-01f, 4.35831457e-01f, 7.82538801e-02f, 4.30203468e-01f, 2.29070827e-01f,
  -1.26207843e-01f, 8.64766613e-02f, 2.46028766e-01f, -6.84015453e-02f, 1.77243669e-02f, 2.47365445e-01f, -7.32960552e-02f, 2.94942826e-01f, 1.19325154e-01f, 2.07880408e-01f,
  -6.21461235e-02f, 2.70926654e-01f, -4.80701514e-02f, 6.33002147e-02f, -3.71008456e-01f, 5.57544231e-02f, 5.26650203e-03f, -2.66159236e-01f, -1.57266587e-01f, 5.75949214e-02f,
  -2.27408499e-01f, 2.54660457e-01f, 1.97680727e-01f, -2.41408840e-01f, -6.70831203e-02f, -1.20113455e-01f, 3.24986070e-01f, 1.37935176e-01f, 1.55074373e-01f, 3.81969452e-01f,
  3.57166827e-01f, -1.27586231e-01f, -1.24214925e-01f, -2.97568977e-01f, 3.48821163e-01f, 2.19897985e-01f, 7.76277781e-02f, -3.29404622e-02f, 1.79830998e-01f, -1.08410185e-02f,
  2.14672878e-01f, 1.25400592e-02f, 4.24001783e-01f, 6.46223489e-04f, 1.16392165e-01f, 3.44735771e-01f, -9.48234871e-02f, -2.97551304e-01f, 1.26045331e-01f, 1.19372241e-01f,
  7.98943788e-02f, 4.60901074e-02f, 1.58486933e-01f, -2.01370209e-01f, 2.09506229e-01f, 1.76580429e-01f, 4.50264484e-01f, -1.95843771e-01f, -7.98102915e-02f, -2.45582443e-02f,
  -2.75192708e-01f, -1.25926524e-01f, -2.23199159e-01f, -6.43270314e-02f, 3.57717663e-01f, 7.61653930e-02f, -1.67428896e-01f, 3.07999820e-01f, 4.55460884e-02f, 2.42871687e-01f,
  -6.32765815e-02f, 8.09570029e-03f, 8.37807357e-02f, 1.79298073e-02f, -1.93423524e-01f, 1.23501562e-01f, 1.20672300e-01f, -1.59643531e-01f, -5.99161312e-02f, 8.46977904e-02f,
  -1.88740604e-02f, 5.62265590e-02f, -1.90844521e-01f, -2.05532640e-01f, -1.77953199e-01f, 7.43855014e-02f, 4.65985686e-01f, -7.93543160e-02f, 4.45878971e-03f, 2.45252401e-01f,
  3.35487932e-01f, 4.11774099e-01f, 8.66599102e-03f, 3.28345448e-01f, -7.43111297e-02f, -6.12570643e-02f, 1.51115328e-01f, -1.01108387e-01f, 6.45573670e-03f, -6.64250460e-03f,
  5.08788116e-02f, 1.73998758e-01f, 1.04740791e-01f, 7.21399561e-02f, 2.15252131e-01f, 3.94745529e-01f, 2.19060093e-01f, 2.72140205e-01f, 2.02237532e-01f, 1.25975430e-01f,
  1.43294772e-02f, -2.10806146e-01f, -2.36911476e-02f, 2.83140153e-01f, 2.27269650e-01f, -4.22682278e-02f, -8.69394746e-03f, -2.41749018e-01f, 2.97328532e-01f, 2.49419108e-01f,
  3.74134392e-01f, 7.35579208e-02f, 5.79112507e-02f, 1.16709791e-01f, 1.47976398e-01f, -1.41368568e-01f, -1.86064079e-01f, 1.25826806e-01f, 1.61666259e-01f, 2.65664965e-01f,
  -3.88611257e-02f, 5.19520938e-01f, 3.72001976e-02f, 1.88530549e-01f, 2.52214164e-01f, 1.95147350e-01f, 2.33212769e-01f, 1.23979881e-01f, 2.93002576e-01f, 1.60349667e-01f,
  2.03334138e-01f, 1.39996633e-01f, 2.17104241e-01f, -3.17426920e-02f, 3.71039324e-02f, 2.74589837e-01f, 2.70480633e-01f, 7.61157796e-02f, 8.24887753e-02f, -8.91419128e-02f,
  1.53609701e-02f, 5.05779505e-01f, 2.39623725e-01f, -1.41915912e-03f, -6.92695379e-02f, 8.54080990e-02f, 3.11489254e-01f, 8.23130906e-02f, 9.65741202e-02f, 3.21540236e-01f,
  -1.92229301e-02f, 3.30663502e-01f, 1.70207527e-02f, 1.98230490e-01f, 1.92358922e-02f, 1.82697996e-01f, 6.74214512e-02f, -6.37640730e-02f, -1.13823749e-02f, 3.68354321e-01f,
  2.48180807e-01f, -1.14331385e-02f, 1.57895863e-01f, -3.54799598e-01f, 1.96841255e-01f, -1.08182825e-01f, 8.03143829e-02f, 1.95810661e-01f, -6.00663982e-02f, -3.02907918e-02f,
  -3.48863602e-01f, -3.29672664e-01f, 2.45565519e-01f, 2.16862768e-01f, -1.29555956e-01f, 3.47081795e-02f, -1.54217556e-01f, -9.20645669e-02f, 2.31926009e-01f, -3.08508843e-01f,
  -3.01850624e-02f, 2.58868963e-01f, 3.57719392e-01f, 2.92091548e-01f, 4.16443139e-01f, -8.33560601e-02f, -8.40481818e-02f, 1.22392885e-01f, -6.36771470e-02f, -4.98409532e-02f,
  -5.76696768e-02f, -1.80145446e-03f, 3.62025276e-02f, 1.73230674e-02f, -4.90501560e-02f, -1.95678979e-01f, -4.53199111e-02f, 2.15276435e-01f, 1.16311781e-01f, -1.86437041e-01f,
  -1.54276788e-01f, 2.78753880e-02f, -1.32057905e-01f, -5.67073412e-02f, -1.01059647e-02f, -2.33069927e-01f, -2.99029816e-02f, 3.36636277e-03f, -4.90571633e-02f, 1.23223215e-02f,
  -1.33756800e-02f, 4.56975847e-02f, -6.57418519e-02f, 3.70177962e-02f, -5.29689603e-02f, 2.69013774e-02f, 3.44829738e-01f, -2.48986538e-02f, 7.78125599e-02f, 3.43132257e-01f,
  6.80203587e-02f, -1.37124851e-01f, 4.19338457e-02f, 3.17550480e-01f, 2.06439406e-01f, 1.78162325e-02f, 2.83956468e-01f, -4.18977112e-01f, 1.62651911e-01f, -1.03780977e-01f,
  5.02281226e-02f, -1.11060655e-02f, -1.96625680e-01f, -1.72276914e-01f, -2.89072841e-01f, -3.38128924e-01f, 2.16770664e-01f, -5.44081926e-02f, -1.13252334e-01f, 2.37605751e-01f,
  1.27882902e-02f, -5.14600575e-02f, 9.49959308e-02f, -1.31494507e-01f, -2.94907451e-01f, 1.49679467e-01f, 5.07229805e-01f, 7.58597627e-02f, 3.42764527e-01f, -8.58791322e-02f,
  2.64220297e-01f, -1.86056625e-02f, 8.92198235e-02f, 1.01595946e-01f, 1.53979331e-01f, 1.56677961e-02f, -1.23844400e-01f, 1.99544162e-01f, 1.39019787e-01f, -1.11820571e-01f,
  1.00413837e-01f, -2.33324587e-01f, -6.33695275e-02f, -1.30945727e-01f, -9.35855210e-02f, -1.88261151e-01f, 2.74411142e-01f, 4.03743312e-02f, 9.30170193e-02f, 5.94777539e-02f,
  -2.17305511e-01f, 3.03409368e-01f, 3.01932752e-01f, -9.33012441e-02f, 2.19264537e-01f, -7.87584335e-02f, 3.82950217e-01f, 4.80250642e-02f, -9.06566605e-02f, -6.34633601e-02f,
  -2.55079806e-01f, -2.92285711e-01f, 6.24504611e-02f, 3.41144539e-02f, -3.97837982e-02f, -6.68815747e-02f, -5.70559055e-02f, 6.14036731e-02f, 3.84698547e-02f, 1.40474096e-01f,
  7.85590559e-02f, -3.14435005e-01f, 2.17606798e-01f, 1.05383031e-01f, 5.98879233e-02f, -5.75910471e-02f, -4.63914461e-02f, 7.50478357e-02f, 6.56722486e-02f, -2.46573210e-01f,
  -1.08027160e-01f, 1.56837106e-01f, -1.88927978e-01f, 1.87622726e-01f, 5.98052666e-02f, -5.54920174e-02f, 3.17072153e-01f, -1.71902284e-01f, -3.17287967e-02f, 2.35677496e-01f,
  -1.04562994e-02f, 2.96280026e-01f, 3.19268346e-01f, -2.90892005e-01f, 1.29634336e-01f, 1.30380511e-01f, 2.78445445e-02f, 2.39786983e-01f, 2.00096071e-01f, 2.38140330e-01f,
  -4.00632108e-03f, 9.17483792e-02f, 1.02407992e-01f, 1.57953292e-01f, -3.59326392e-01f, -2.54308701e-01f, 2.52969414e-02f, -1.76306084e-01f, -6.70651123e-02f, -5.97637706e-02f,
  3.11641879e-02f, 8.55020359e-02f, 2.24530712e-01f, -1.89461887e-01f, -5.22181801e-02f, 2.85193920e-01f, 3.62347335e-01f, 2.27144614e-01f, -3.04504912e-02f, 1.53631747e-01f,
  3.30228388e-01f, -8.88401866e-02f, 5.27364947e-02f, -1.96067557e-01f, 2.35228539e-02f, 5.98720014e-02f, 3.04522097e-01f, -1.25028074e-01f, 2.24689201e-01f, 3.65181975e-02f,
  3.49992394e-01f, 1.34591922e-01f, -7.63305053e-02f, 4.45530713e-02f, 9.95350443e-03f, 1.53507767e-02f, -6.45674905e-03f, -3.70168269e-01f, -2.61742651e-01f, -1.67206913e-01f,
  2.82073170e-02f, -1.73818156e-01f, 3.25543225e-01f, -1.53788477e-01f, -6.73574880e-02f, 1.73643664e-01f, -1.80964068e-01f, 3.90742332e-01f, 2.01526776e-01f, -1.92448825e-01f,
  3.90270948e-01f, -1.11653872e-01f, 3.17618817e-01f, 2.24888444e-01f, -2.96645481e-02f, 2.26751447e-01f, -1.53072104e-01f, -4.17597681e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.96655142e-01f, 2.12789744e-01f, 2.18705267e-01f, 2.64545709e-01f, -2.65039280e-02f, 2.75153667e-01f, 3.12334657e-01f, 2.56642252e-01f, 1.29563110e-02f, 2.47419879e-01f,
  8.51873010e-02f, -6.36869995e-03f, 1.56175703e-01f, 1.64795406e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.30861074e-02f, -4.92352694e-02f, 4.55056084e-03f, 6.87107593e-02f, 1.93586498e-01f, -2.50431206e-02f, 7.94759393e-02f, -7.38468468e-02f, -1.05482094e-01f, 2.11124681e-02f,
  -1.97098521e-03f, 7.38468096e-02f, -2.29465529e-01f, 2.56506383e-01f, -1.57429934e-01f, -1.61861345e-01f, 4.22176011e-02f, 1.42837130e-02f, 2.38265991e-02f, 9.38347057e-02f,
  5.66974841e-02f, -5.34262992e-02f, 8.22479576e-02f, -5.55964597e-02f, -2.16926917e-01f, -1.43326029e-01f, 2.39291657e-02f, 2.10170876e-02f, 7.72458091e-02f, -4.74966429e-02f,
  1.16240889e-01f, -1.33960903e-01f, 9.13050100e-02f, -1.19552605e-01f, -8.11231956e-02f, 4.03971151e-02f, 5.12209302e-03f, -2.76917629e-02f, -5.44640049e-02f, 8.98549110e-02f,
  -4.44160923e-02f, 2.61313558e-01f, -1.03665523e-01f, -2.35187694e-01f, 1.36907861e-01f, -2.90597796e-01f, 1.07236437e-01f, -2.27861807e-01f, -5.81231639e-02f, 2.21063614e-01f,
  9.17175859e-02f, -1.50263876e-01f, -2.84940243e-01f, 1.21130265e-01f, -2.44761214e-01f, 1.37140512e-01f, 5.75750284e-02f, 1.72027409e-01f, -9.58370194e-02f, 1.20252028e-01f,
  -5.06939106e-02f, 1.20698012e-01f, 9.93957929e-03f, 6.24947809e-02f, 1.67285934e-01f, -9.55387484e-04f, -3.68922055e-02f, 1.01885684e-01f, -1.20793637e-02f, -3.42384800e-02f,
  -9.95843336e-02f, -2.76750866e-02f, 2.47793235e-02f, -1.64492428e-03f, 2.65323848e-01f, -1.38637973e-02f, 1.45211862e-02f, -7.30839819e-02f, 1.20420478e-01f, 1.11015342e-01f,
  1.10392921e-01f, -1.11381032e-01f, 4.15823460e-02f, -2.48962820e-01f, -6.34391978e-02f, 1.82235256e-01f, -6.02437742e-02f, 2.78870732e-01f, 4.25284356e-03f, -1.46927759e-01f,
  -3.76732908e-02f, -6.97580576e-02f, -2.57822722e-01f, -1.29086882e-01f, -1.48204684e-01f, -2.04355612e-01f, -1.00239895e-01f, 4.13068570e-02f, 3.13124061e-02f, -1.06664546e-01f,
  -6.27418756e-02f, 8.58599618e-02f, 2.94663757e-03f, -6.57330453e-02f, 4.13097516e-02f, -1.39297262e-01f, -1.15713611e-01f, 1.43843040e-01f, -1.84643924e-01f, 1.36091992e-01f,
  -1.21781960e-01f, 1.24719657e-01f, -2.73166038e-02f, -1.58777162e-01f, -1.03629537e-01f, 2.09852338e-01f, 3.04888673e-02f, -2.36648783e-01f, 2.32310727e-01f, -2.37400278e-01f,
  -1.27149215e-02f, -2.37034455e-01f, 1.01791598e-01f, 4.48129773e-02f, 2.11839050e-01f, 7.95205235e-02f, 5.85043021e-02f, 1.77661106e-01f, -9.26824361e-02f, 3.20555046e-02f,
  1.20579250e-01f, 3.82976905e-02f, 4.57079709e-03f, 1.13015734e-01f, -8.67632553e-02f, -8.61263722e-02f, 5.52326534e-03f, -6.79022372e-02f, -2.52950042e-01f, 4.18371782e-02f,
  -3.61040235e-02f, 1.88850582e-01f, -1.18222065e-01f, -1.37936518e-01f, -3.22907269e-01f, 2.71998882e-01f, 1.97143909e-02f, 1.50031582e-01f, 1.06626108e-01f, -1.41469374e-01f,
  2.84822629e-04f, -1.73729777e-01f, -4.72404845e-02f, -1.75743684e-01f, 3.55012417e-02f, -3.47207412e-02f, 2.31745183e-01f, -1.51341055e-02f, -6.93636090e-02f, 2.86367416e-01f,
  -7.31891990e-02f, 8.57567266e-02f, 1.81040782e-02f, -6.28325492e-02f, 9.39304456e-02f, -5.19815236e-02f, 1.18612759e-01f, -1.83309361e-01f, -7.05999210e-02f, -2.33501211e-01f,
  2.25183368e-01f, 6.97020739e-02f, -1.32844448e-01f, 2.65406728e-01f, -2.29306847e-01f, 7.37663284e-02f, 2.33815014e-01f, -2.25690573e-01f, 5.73094599e-02f, 5.97322285e-02f,
  2.57419109e-01f, -1.54840022e-01f, 8.04278702e-02f, -2.37742767e-01f, -1.90369129e-01f, -1.90845087e-01f, 9.74837765e-02f, 9.47427377e-02f, -3.03583965e-02f, 5.85357985e-03f,
  -5.65154478e-02f, -2.05937266e-01f, 1.33895203e-01f, 4.63590324e-02f, 1.90440362e-04f, -1.09093778e-01f, -1.24792876e-02f, -1.35712340e-01f, 2.16245100e-01f, 1.51713882e-02f,
  5.46617955e-02f, -3.52017164e-01f, -6.40520975e-02f, 2.64705092e-01f, 1.30737156e-01f, 8.88228323e-03f, 4.97548003e-03f, 2.54769146e-01f, 1.03210561e-01f, -7.50848651e-02f,
  1.07429639e-01f, 9.56007615e-02f, 6.10590614e-02f, 7.47675002e-02f, -1.67823642e-01f, -2.70903796e-01f, 8.05802196e-02f, -3.54288146e-02f, 4.63121310e-02f, -1.82363495e-01f,
  6.01166561e-02f, -9.91384685e-02f, -2.09334448e-01f, 3.55415558e-03f, 1.15889065e-01f, -2.12748591e-02f, 6.34252978e-03f, 5.38882911e-02f, -4.15729843e-02f, -1.07311206e-02f,
  -1.27665833e-01f, 1.18156292e-01f, 4.13826033e-02f, 9.01073888e-02f, 4.13717218e-02f, -2.06924528e-02f, 1.39962554e-01f, -1.14381269e-01f, 7.17923492e-02f, -1.22297481e-01f,
  -2.43625998e-01f, 2.44893551e-01f, -3.82299200e-02f, -1.02725357e-01f, -1.89843044e-01f, 3.36434454e-01f, -1.12478659e-01f, 1.14723794e-01f, 8.18947889e-03f, -3.74174155e-02f,
  -1.20223043e-02f, 3.89590748e-02f, 4.73284489e-03f, -6.53329939e-02f, -7.70485476e-02f, -1.13817148e-01f, -2.31190175e-02f, 9.72944498e-02f, -2.57696840e-03f, -1.11403361e-01f,
  1.37316287e-01f, 7.67749771e-02f, 1.98162403e-02f, -1.09401733e-01f, -9.80738848e-02f, 2.50113040e-01f, -7.01884776e-02f, -1.71901230e-02f, 1.55201973e-02f, 1.36157990e-01f,
  -1.62958696e-01f, -2.87923962e-01f, -2.71018684e-01f, 2.42374092e-01f, -1.46918207e-01f, 2.91879382e-02f, 6.97733313e-02f, 2.45239154e-01f, -7.35189542e-02f, -3.52963805e-02f,
  -1.76433265e-01f, -5.30444384e-02f, 9.17511582e-02f, 1.32990062e-01f, 2.17274711e-01f, -1.33598819e-01f, 1.64347276e-01f, 1.00879043e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  8.34968016e-02f, 4.92740907e-02f, 1.62577808e-01f, 3.30376416e-01f, 1.55899882e-01f, 2.69735251e-02f, 1.91686034e-01f, 1.71656430e-01f, 2.29957014e-01f, 5.82916327e-02f,
  3.35266888e-01f, -3.32411945e-01f, -6.41487613e-02f, 2.84644812e-01f, 3.75427771e-03f, -1.92799509e-01f, 2.77272880e-01f, -1.48488998e-01f, 1.94246918e-01f, 1.34079093e-02f,
  4.02463585e-01f, 2.36580864e-01f, 1.52739659e-01f, 2.85222977e-01f, 1.56706691e-01f, 4.65189189e-01f, 2.17070192e-01f, 2.50333607e-01f, -3.12732786e-01f, 5.22744805e-02f,
  7.92234465e-02f, -4.30270612e-01f, -1.56051666e-01f, -4.27352972e-02f, 7.80509636e-02f, -3.43930721e-02f, 1.08418532e-01f, 2.44830623e-01f, 5.77975325e-02f, 9.40567330e-02f,
  1.26349330e-01f, 1.22399077e-01f, -4.83518034e-01f, 1.40816510e-01f, 3.20781283e-02f, 7.68012479e-02f, -5.55414446e-02f, -1.44415632e-01f, -4.46623117e-01f, 1.73681796e-01f,
  1.77681133e-01f, 2.47219056e-01f, 1.30638197e-01f, -2.96931952e-01f, 1.62020400e-01f, 1.45498756e-02f, 2.16062382e-01f, 7.40219802e-02f, -1.77892238e-01f, -5.28148077e-02f,
  3.89098048e-01f, 1.97461933e-01f, 2.48971269e-01f, 6.88619971e-01f, 2.56183684e-01f, 8.86379704e-02f, 2.64015794e-01f, 9.56270173e-02f, -1.39490753e-01f, 5.85709475e-02f,
  6.44113943e-02f, 1.06014453e-01f, 1.42484426e-01f, -3.19758236e-01f, 5.15335128e-02f, 1.65340617e-01f, 3.62061709e-01f, -1.83634922e-01f, 1.65561900e-01f, 2.97872335e-01f,
  -5.55976331e-02f, -2.50343263e-01f, 4.87177879e-01f, 2.63686955e-01f, -1.63294882e-01f, 2.05357447e-01f, -3.34161282e-01f, 3.65120649e-01f, 4.88607049e-01f, 3.14072855e-02f,
  -1.72071263e-01f, -1.62714019e-01f, 6.30628318e-02f, -3.83591056e-02f, -5.03433123e-02f, 8.03563222e-02f, 3.15935165e-02f, 1.65477619e-01f, 9.24895778e-02f, 4.21215475e-01f,
  2.15031579e-01f, 4.95095178e-03f, 7.54751265e-02f, 1.33740470e-01f, 1.11474276e-01f, 2.01616541e-01f, 5.53157985e-01f, -3.45809422e-02f, 5.53336702e-02f, 2.64743894e-01f,
  -9.29058269e-02f, -9.75689664e-02f, 3.33796412e-01f, -1.92274600e-01f, -1.81522090e-02f, -2.82266080e-01f, 3.30692947e-01f, 2.65417665e-01f, 4.78941858e-01f, 4.46000308e-01f,
  1.71084940e-01f, 2.20331728e-01f, 2.73043010e-02f, 1.74771339e-01f, -1.90243453e-01f, -1.99475676e-01f, 3.31641406e-01f, -4.74542022e-01f, -1.31022185e-01f, -1.73921615e-01f,
  -2.87647843e-01f, 1.74570903e-01f, 2.56442964e-01f, -6.03270680e-02f, -1.28619045e-01f, 3.66171170e-03f, -1.39131710e-01f, 1.51977912e-01f, -3.71163666e-01f, -3.28970075e-01f,
  -2.00837955e-01f, -2.17025921e-01f, 2.29666352e-01f, 1.51166588e-01f, 2.08652109e-01f, -2.26167105e-02f, -5.83893135e-02f, 7.20351189e-02f, -2.69076645e-01f, -1.51643798e-01f,
  5.30416034e-02f, 9.01555568e-02f, 1.79249763e-01f, 4.69384193e-01f, -1.32366776e-01f, 4.18248028e-01f, 1.53003693e-01f, 3.40784371e-01f, -3.18895131e-02f, 2.59980530e-01f,
  -2.50628032e-02f, 7.67999515e-02f, 3.67705617e-03f, 2.25727081e-01f, 1.75452664e-01f, -1.04149491e-01f, 9.93290991e-02f, 5.14686182e-02f, 1.70026142e-02f, -3.04262601e-02f,
  3.42524320e-01f, 3.01192373e-01f, 7.59426970e-03f, 2.50992984e-01f, -2.50678629e-01f, 5.17792664e-02f, 1.77493125e-01f, -3.00026715e-01f, -1.53030336e-01f, -1.02776363e-01f,
  4.68799174e-01f, -2.09704489e-01f, 5.04674375e-01f, 1.18216705e-02f, 1.60721898e-01f, -5.21086603e-02f, -9.57322214e-03f, -1.23063929e-01f, 1.83850095e-01f, -1.08631946e-01f,
  3.70330185e-01f, -2.11944580e-01f, 1.58693772e-02f, 3.48554105e-02f, 2.05980599e-01f, 2.54082710e-01f, -6.54734224e-02f, 1.09912887e-01f, 9.09235105e-02f, 2.15338722e-01f,
  7.76529610e-02f, -1.35235503e-01f, 3.65531594e-02f, -3.42058763e-02f, 1.31576419e-01f, -3.15274328e-01f, 2.96386153e-01f, 2.93929160e-01f, 1.76836133e-01f, -1.15935504e-01f,
  1.10767603e-01f, 3.01059544e-01f, -1.28437698e-01f, 2.44982749e-01f, -4.28853184e-02f, 4.83165860e-01f, 4.63269681e-01f, 4.73209649e-01f, 6.96097407e-03f, 2.05897734e-01f,
  -1.04331046e-01f, 4.38283235e-01f, -1.76899716e-01f, -3.82333770e-02f, 1.91135600e-01f, 9.82780233e-02f, 2.16954514e-01f, 9.45736915e-02f, 1.49385288e-01f, 3.39522749e-01f,
  1.33414775e-01f, 2.71501005e-01f, 9.10369903e-02f, 1.09473415e-01f, -1.43988967e-01f, 1.07661605e-01f, 2.05525368e-01f, 2.92716712e-01f, -1.15564004e-01f, -4.22672749e-01f,
  -6.10101581e-01f, 4.54990238e-01f, 4.89766151e-01f, 3.07164609e-01f, 2.35690534e-01f, 3.94004807e-02f, -4.09627445e-02f, 6.75028786e-02f, 5.00621973e-03f, -2.19176546e-01f,
  -8.85574296e-02f, -1.15933552e-01f, 5.43087184e-01f, -2.72155464e-01f, 3.88225019e-01f, 3.21608007e-01f, 1.17708363e-01f, 1.14963893e-02f, 1.28348470e-01f, 8.06808844e-02f,
  1.60963461e-01f, 8.73534158e-02f, 1.03518806e-01f, 1.85498759e-01f, 7.65450820e-02f, 3.19039285e-01f, -3.46428342e-02f, -1.53112486e-01f, 1.84202358e-01f, -2.07262024e-01f,
  1.71291679e-01f, -2.43310019e-01f, -4.01126891e-01f, 4.37718958e-01f, 4.13550675e-01f, 1.15966447e-01f, -2.75712982e-02f, 4.99655068e-01f, -1.16913974e-01f, 4.38751787e-01f,
  3.62207055e-01f, 4.46195714e-02f, -2.23499924e-01f, 7.75131658e-02f, 1.60546228e-01f, 2.56890319e-02f, 9.46461409e-03f, 4.36739892e-01f, 2.74439216e-01f, 1.37511402e-01f,
  2.36615360e-01f, 7.77115375e-02f, 1.53432459e-01f, 3.47944558e-01f, 3.03672552e-01f, 3.22435409e-01f, 2.31564522e-01f, -2.96705723e-01f, 3.49550694e-01f, 2.97326922e-01f,
  1.56229123e-01f, 3.74375492e-01f, -1.47237331e-01f, 2.12028101e-02f, -8.09441358e-02f, -2.52164692e-01f, 2.29309648e-01f, 2.13837460e-01f, 4.68533456e-01f, 3.94292697e-02f,
  2.99354941e-02f, 4.05438468e-02f, 8.48833844e-02f, -2.19476983e-01f, -7.93083608e-02f, -3.31500709e-01f, -9.62916166e-02f, -1.57441139e-01f, 2.53121167e-01f, -2.78932825e-02f,
  -2.26847917e-01f, -2.64075138e-02f, -1.17775381e-01f, 1.94384158e-01f, 1.50770664e-01f, -9.20384973e-02f, -8.67473632e-02f, 1.39681017e-02f, -1.00220449e-01f, 5.50521195e-01f,
  7.04041570e-02f, -2.95986593e-01f, -3.15406203e-01f, 5.66743873e-02f, -1.22986548e-01f, -3.66525888e-01f, -1.40103653e-01f, 4.37165231e-01f, 8.71058553e-02f, -9.98828337e-02f,
  9.43847299e-02f, 1.78663060e-01f, 5.25961101e-01f, 2.27108136e-01f, -6.71187714e-02f, 3.03506464e-01f, -4.53564562e-02f, 5.51364124e-01f, 1.92096591e-01f, -8.49900544e-02f,
  4.50430483e-01f, 1.70278579e-01f, 2.40691215e-01f, 2.32426226e-01f, 7.31949210e-02f, 8.79907906e-02f, -1.13141716e-01f, -1.09002867e-03f, 2.72809952e-01f, 2.42256761e-01f,
  2.32350469e-01f, -4.76435035e-01f, 1.51914254e-01f, 3.35270345e-01f, 3.98592085e-01f, 2.64412886e-03f, 7.76119679e-02f, 2.95363873e-01f, 1.02027208e-01f, -3.93714488e-01f,
  4.33368355e-01f, 3.92050713e-01f, 2.05337316e-01f, 2.58793980e-01f, -1.92080289e-01f, 9.28354785e-02f, 3.20734084e-01f, -9.50721055e-02f, -1.35919213e-01f, -3.60541523e-01f,
  -4.38172929e-02f, -1.70588553e-01f, 6.69074506e-02f, -1.15477338e-01f, -2.88118757e-02f, 8.09953883e-02f, 6.56007826e-02f, -9.75393876e-03f, 1.27344340e-01f, 2.33180568e-01f,
  1.07374132e-01f, 6.17966503e-02f, 4.95118685e-02f, -3.00320923e-01f, -3.16856205e-01f, -1.54229373e-01f, -1.64639995e-01f, 1.13845177e-01f, 3.85228358e-02f, 2.01445431e-01f,
  2.81408221e-01f, -2.49564677e-01f, 9.22820494e-02f, 4.73749042e-01f, 9.92524847e-02f, -3.88692230e-01f, -1.58740938e-01f, -3.65597233e-02f, 8.67857561e-02f, 2.90597379e-01f,
  3.43601435e-01f, 3.95385712e-01f, 1.23871304e-02f, 3.98856878e-01f, 5.77631267e-03f, 5.06617315e-02f, -1.55573338e-01f, 5.71531393e-02f, -2.26541042e-01f, 1.63324118e-01f,
  1.14490740e-01f, -5.62152937e-02f, -4.31606285e-02f, -4.72016856e-02f, -2.65415907e-02f, 1.41221792e-01f, -2.82084346e-01f, -3.92720789e-01f, -2.58306175e-01f, -1.75098151e-01f,
  1.67097956e-01f, 4.98704016e-02f, 2.86892623e-01f, 3.34239677e-02f, 1.40266940e-02f, 6.60144165e-02f, -2.95618605e-02f, -1.16164170e-01f, 1.23294190e-01f, 6.64065927e-02f,
  1.70100510e-01f, 4.01596367e-01f, 9.15437341e-02f, 4.20587152e-01f, -3.35690640e-02f, 1.90694615e-01f, -4.68951650e-02f, 7.36775994e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.52639881e-01f, 1.09059244e-01f, 1.34421110e-01f, 1.28668100e-01f, -4.57432866e-02f, 4.98270690e-02f, 2.80460835e-01f, 2.26065010e-01f, 1.75031573e-01f, 3.14212531e-01f,
  1.89119488e-01f, 3.15346718e-02f, 2.12760836e-01f, 4.12690453e-02f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  3.32535431e-02f, -2.18973570e-02f, 1.44113079e-01f, 6.14358671e-02f, 1.18486963e-01f, 8.73539597e-02f, -2.12169401e-02f, 5.81905097e-02f, 1.36577040e-02f, 2.09370092e-01f,
  -2.21875668e-01f, 1.27806067e-01f, 1.18636176e-01f, -6.48927763e-02f, 1.73524082e-01f, 3.20544913e-02f, 1.62877236e-02f, 3.25036049e-02f, 1.70383707e-01f, 3.55337411e-02f,
  -4.55345064e-02f, 4.16502208e-02f, -2.28807136e-01f, 8.84376615e-02f, -1.94747820e-01f, -1.05195837e-02f, -9.33215544e-02f, 2.22479761e-01f, 5.83406538e-04f, 2.39531398e-01f,
  -1.05063200e-01f, -9.52673778e-02f, 3.43689136e-02f, -1.20118931e-01f, -1.57792084e-02f, 5.27674705e-02f, 6.44118488e-02f, -2.14939192e-02f, 6.49370346e-03f, -9.31950845e-03f,
  4.03330699e-02f, 1.47673935e-01f, -6.55348599e-02f, -4.97234948e-02f, 1.51063100e-01f, -7.02242702e-02f, 2.03781143e-01f, -2.98726186e-02f, -1.48938283e-01f, 7.69027323e-02f,
  -5.18971160e-02f, 1.40259191e-01f, -1.97862256e-02f, 2.08041426e-02f, 1.52547717e-01f, 1.40964717e-01f, -1.96785420e-01f, -5.19273207e-02f, -8.42132792e-02f, 2.77027767e-02f,
  5.55468649e-02f, -1.32035762e-01f, 1.79178659e-02f, 1.84411123e-01f, 8.98557156e-02f, 1.42566383e-01f, 1.76660623e-02f, 7.55863190e-02f, 5.00707217e-02f, 1.14974946e-01f,
  -9.90376323e-02f, 4.85480689e-02f, -9.91681665e-02f, 1.33108526e-01f, -1.18206345e-01f, 2.00277895e-01f, -1.08372286e-01f, 1.03400378e-02f, 2.59865552e-01f, -2.92819962e-02f,
  4.63482179e-02f, -4.27409112e-02f, 4.01550010e-02f, -2.62167096e-01f, -9.75424200e-02f, 2.66968720e-02f, -2.34502718e-01f, -9.44479704e-02f, 8.07977766e-02f, 1.65394709e-01f,
  1.69792473e-02f, 1.37268066e-01f, -4.12024781e-02f, 1.14085734e-01f, -1.64722244e-03f, -9.99747664e-02f, -9.73915011e-02f, -5.42271882e-02f, -7.17239156e-02f, 5.43017238e-02f,
  9.91460979e-02f, -8.41658097e-03f, 2.24489085e-02f, -2.77181529e-02f, -1.49574116e-01f, -1.62947223e-01f, -7.24098012e-02f, -1.73263371e-01f, -9.90140513e-02f, -6.08185381e-02f,
  5.99762276e-02f, 4.34335582e-02f, -1.22371644e-01f, -1.94554597e-01f, -8.40312764e-02f, 2.51756925e-02f, -1.12026371e-01f, 8.19728523e-02f, 1.96662918e-01f, 1.19627714e-01f,
  8.92418846e-02f, -2.85971612e-01f, -2.85506658e-02f, -7.51025304e-02f, -4.58736680e-02f, -6.93929046e-02f, 3.83670926e-02f, 6.55107722e-02f, -3.82534787e-02f, 9.09980759e-02f,
  -1.54530704e-01f, -5.95148094e-02f, -1.96012184e-01f, -3.74287483e-03f, -4.87403851e-03f, 2.55502164e-02f, 1.02790475e-01f, -4.44414318e-02f, 8.08200017e-02f, 1.50156736e-01f,
  3.65489791e-03f, 8.17861259e-02f, -9.32751223e-02f, 1.29476339e-01f, 1.96369812e-01f, 2.24100709e-01f, -2.12996021e-01f, 8.22165608e-02f, 2.62782164e-02f, -2.77767349e-02f,
  -2.36665443e-01f, -1.07911795e-01f, 7.35680237e-02f, 1.60065815e-01f, 2.19763398e-01f, -1.04348391e-01f, 1.67787865e-01f, -5.62968515e-02f, -1.89575836e-01f, -7.10878074e-02f,
  -1.09377041e-01f, 2.95460057e-02f, -5.36813140e-02f, -1.87462166e-01f, -2.56068766e-01f, 6.45545125e-02f, 5.40453121e-02f, -1.05281249e-01f, -8.42583254e-02f, -4.63117510e-02f,
  -1.13113619e-01f, -1.56465196e-03f, 2.54079670e-01f, 5.35338148e-02f, 1.36660680e-01f, 2.32233241e-01f, -1.50110811e-01f, -1.34710982e-01f, -2.86991522e-02f, 4.89416346e-02f,
  6.43799901e-02f, 7.58169815e-02f, -1.67040586e-01f, 1.29901811e-01f, 6.94372132e-02f, -1.25140831e-01f, -2.31403440e-01f, 2.93647451e-03f, 5.52736223e-03f, 2.93071032e-01f,
  1.87873654e-02f, -7.60325789e-02f, 3.72442268e-02f, 8.19203705e-02f, -8.27982053e-02f, 1.09373957e-01f, -1.12509057e-01f, -4.98796394e-03f, -1.62281189e-02f, 4.11498323e-02f,
  1.20865054e-01f, -4.90969196e-02f, 9.81133059e-02f, -1.67077377e-01f, 1.98970586e-01f, 8.53465199e-02f, -2.48814020e-02f, -2.91054118e-02f, 4.90196943e-02f, 1.19937785e-01f,
  -1.16866440e-01f, 1.81666642e-01f, -1.89389989e-01f, -1.16871990e-01f, 1.48225203e-01f, -6.07283674e-02f, 1.36462778e-01f, 1.58534989e-01f, 4.47717905e-02f, -2.46124253e-01f,
  1.35772437e-01f, -2.01414362e-01f, 3.44481505e-02f, 8.06865916e-02f, -1.45195320e-01f, 1.59161054e-02f, 8.12429115e-02f, -1.44191235e-02f, 1.47242993e-01f, -5.13566611e-03f,
  -3.39195020e-02f, -1.75879635e-02f, -5.67104891e-02f, -1.93370640e-01f, 8.25872794e-02f, 8.17832071e-03f, -2.81003773e-01f, -1.69405773e-01f, -6.14005253e-02f, -5.08052856e-02f,
  9.49110091e-02f, -2.45549485e-01f, 1.05576754e-01f, -1.13168895e-01f, 7.50021404e-03f, 6.37419075e-02f, -3.20662148e-02f, 1.39950380e-01f, 2.33843520e-01f, -6.43721521e-02f,
  1.20028965e-01f, 4.91274968e-02f, -1.04110040e-01f, 8.05492103e-02f, -1.82892352e-01f, -8.40964243e-02f, 1.63987011e-01f, 1.73165873e-01f, -9.93202776e-02f, -2.23386521e-03f,
  -3.00175957e-02f, -3.43060121e-02f, 3.64830671e-03f, 3.63029260e-03f, 1.61710501e-01f, 2.97648907e-02f, 1.25913411e-01f, -4.52347174e-02f, 1.24675333e-01f, 5.44742942e-02f,
  -1.40674368e-01f, -1.58870518e-01f, 9.36907455e-02f, 2.73158193e-01f, 7.61263818e-02f, 1.06766773e-02f, -1.01108126e-01f, -8.31514671e-02f, -9.75169092e-02f, -1.82101429e-01f,
  -4.31555044e-03f, 3.74959439e-01f, 9.93462801e-02f, -7.54096359e-02f, -5.73804937e-02f, -1.68891966e-01f, 5.75620793e-02f, -1.58870388e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.60721922e-01f, 2.65447021e-01f, -7.49695599e-02f, 1.38020322e-01f, 2.00962991e-01f, 1.38745755e-01f, 2.14756384e-01f, 5.86900674e-02f, 1.92892283e-01f, 1.18499033e-01f,
  -2.66408235e-01f, -1.17340520e-01f, 3.18579912e-01f, 3.78129780e-01f, 1.95983067e-01f, 1.42622441e-01f, -1.40692756e-01f, 3.02566611e-03f, 2.86882937e-01f, 1.30630195e-01f,
  -1.66795298e-01f, -1.49561157e-02f, -1.41029313e-01f, -5.68221882e-02f, -1.98868573e-01f, 5.22043049e-01f, -2.11148895e-02f, 3.64557326e-01f, -9.98672098e-02f, -8.40144083e-02f,
  4.92556661e-01f, -6.34340942e-02f, -2.95158029e-02f, 1.25383055e-02f, -1.66404545e-02f, -3.55942309e-01f, -3.22309822e-01f, -5.85956089e-02f, 2.63412260e-02f, 3.51824373e-01f,
  -1.02447681e-01f, -8.06840286e-02f, 4.66074169e-01f, 2.75832921e-01f, -2.16491997e-01f, 3.05671275e-01f, -5.61777234e-01f, -3.69601846e-01f, 3.63433063e-01f, 1.99257120e-01f,
  1.54041022e-01f, 1.19578280e-01f, 1.57828167e-01f, 2.69571275e-01f, 2.57341236e-01f, -3.65226120e-01f, 9.29522067e-02f, 2.76538998e-01f, 5.45519412e-01f, -1.94240302e-01f,
  4.55851763e-01f, -1.90743849e-01f, -2.45602638e-01f, 1.59282014e-01f, 3.52475159e-02f, -9.37951282e-02f, 4.44680303e-01f, -6.05895519e-02f, 3.08223635e-01f, 3.10118217e-02f,
  7.37371296e-02f, -1.33828521e-01f, 3.12331140e-01f, 1.09790927e-02f, 3.79422233e-02f, 1.38341099e-01f, -2.73833901e-01f, -1.97838455e-01f, -5.31865805e-02f, -2.10555419e-01f,
  1.32214397e-01f, 5.06498888e-02f, 2.58198470e-01f, -4.52973209e-02f, -2.02770337e-01f, 4.49595332e-01f, -2.10376516e-01f, 4.40808624e-01f, 4.97706160e-02f, -3.46495886e-03f,
  1.88904822e-01f, 3.78451526e-01f, 2.09642157e-01f, -6.78386837e-02f, -3.56992036e-01f, -1.44915625e-01f, -9.76415575e-02f, 1.65746233e-03f, 9.76862833e-02f, 2.09914774e-01f,
  1.10483572e-01f, -5.45528457e-02f, 8.21461231e-02f, 1.32521108e-01f, -2.55729780e-02f, -2.19561812e-02f, -1.01063669e-01f, -1.22541832e-02f, -1.17950208e-01f, -1.33465258e-02f,
  -5.21704890e-02f, 3.55345011e-01f, 5.51615730e-02f, -3.41756493e-01f, 5.89582250e-02f, 2.14980155e-01f, 4.59842443e-01f, -5.82338572e-02f, -1.05944559e-01f, 8.96422367e-04f,
  2.86897540e-01f, 3.50313354e-03f, 2.71047086e-01f, 3.39768320e-01f, -4.96901751e-01f, 6.54766142e-01f, 8.00445005e-02f, -1.78477913e-01f, 1.11184314e-01f, -7.96163827e-02f,
  -7.26213530e-02f, 8.91153328e-03f, -2.96477586e-01f, -1.51474312e-01f, -1.70576647e-01f, 1.90416649e-01f, -6.08059876e-02f, 9.53602698e-03f, 1.60615921e-01f, -1.67081058e-01f,
  -1.09701186e-01f, 1.06223516e-01f, -4.33544785e-01f, -9.63972136e-02f, 2.02051774e-01f, 4.36816186e-01f, -1.22629859e-01f, 4.79273319e-01f, -3.61512625e-03f, -3.11091393e-01f,
  2.88441718e-01f, -2.96902061e-01f, -1.98692642e-02f, 5.69613397e-01f, 6.26074791e-01f, -8.31396058e-02f, 5.45690477e-01f, -7.37495273e-02f, -7.30009004e-02f, 1.68923125e-01f,
  1.34475335e-01f, 5.81937656e-02f, -1.12430960e-01f, 2.24419519e-01f, 1.56681687e-01f, 1.09511288e-02f, 1.40435770e-01f, -3.66157293e-02f, 1.76251993e-01f, 7.38764852e-02f,
  -1.86952367e-01f, -4.44152504e-01f, 4.60636139e-01f, 3.13439935e-01f, 2.23175529e-02f, 7.13223815e-02f, -4.00893241e-01f, 1.89736225e-02f, -2.20470905e-01f, 7.51939178e-01f,
  -1.13143176e-01f, -2.83525586e-01f, 2.46440262e-01f, 2.86196798e-01f, 1.87466010e-01f, 3.95322263e-01f, 1.49812952e-01f, 1.81367050e-03f, 9.87862870e-02f, -2.13078484e-02f,
  3.81847054e-01f, 3.41107026e-02f, -3.39581780e-02f, 1.92034692e-01f, 6.26173094e-02f, 2.25308686e-01f, 1.73232049e-01f, -4.26242761e-02f, 2.13794038e-01f, 1.47684023e-01f,
  6.20462261e-02f, -2.26630747e-01f, 2.65465677e-01f, -2.13379532e-01f, -2.43486743e-02f, -3.76385450e-02f, -2.15389952e-01f, -4.94641513e-02f, 1.23531772e-02f, -2.19429314e-01f,
  3.52053285e-01f, 2.70476133e-01f, 4.55155581e-01f, -2.04453573e-01f, 3.90923798e-01f, -2.48777583e-01f, 6.16408587e-01f, -1.00267239e-01f, 2.13819072e-01f, -1.80060819e-01f,
  -5.78239262e-02f, 7.25429952e-02f, 5.44292688e-01f, 4.29544508e-01f, 1.46966353e-01f, 4.54699527e-03f, 2.40816958e-02f, -1.47130474e-01f, -1.09677436e-02f, 2.80269563e-01f,
  2.93060262e-02f, 1.30227640e-01f, 1.40040487e-01f, 1.37971908e-01f, -3.35792452e-01f, -1.05301566e-01f, 9.13339108e-02f, 1.03746191e-01f, 1.35889322e-01f, 7.36469328e-02f,
  -4.35207747e-02f, 1.98945016e-01f, 1.23632051e-01f, 1.35156691e-01f, -8.81699696e-02f, 3.09289306e-01f, -4.01269078e-01f, 4.09214556e-01f, -4.09029931e-01f, 3.27371746e-01f,
  -3.49812284e-02f, 3.40550691e-01f, 1.22575156e-01f, 2.54410714e-01f, -2.55314469e-01f, -2.94053555e-01f, 2.11158618e-01f, 2.02975556e-01f, -8.61572027e-02f, 1.03515439e-01f,
  2.08508193e-01f, 6.89805150e-02f, -3.58799435e-02f, -5.86365126e-02f, 5.70938475e-02f, 1.56075343e-01f, -1.29468471e-01f, -6.18233047e-02f, 1.40816402e-02f, -5.57917031e-03f,
  1.10893004e-01f, 3.75383437e-01f, 1.28334522e-01f, -8.40411186e-02f, -4.81156223e-02f, 1.96867183e-01f, 3.65317643e-01f, -1.29058227e-01f, -5.58501959e-01f, -1.46288961e-01f,
  5.07647097e-02f, 6.01683617e-01f, 3.13694149e-01f, 5.23965478e-01f, -2.70510644e-01f, 2.91755497e-01f, -2.81157121e-02f, -4.46540117e-01f, 1.91749021e-01f, 2.14020818e-01f,
  2.63248533e-02f, 1.90261509e-02f, -6.22463934e-02f, 2.46835668e-02f, 1.53867498e-01f, 8.07843134e-02f, 2.02000305e-01f, -2.19003201e-01f, -1.00637823e-02f, 2.63557583e-01f,
  -1.69241682e-01f, 8.23640525e-02f, -5.86388074e-02f, 2.61210203e-01f, 2.68187076e-01f, -2.83556134e-01f, 1.29055306e-01f, -4.66562323e-02f, 5.54817200e-01f, 1.70786813e-01f,
  -4.04856592e-01f, -1.52353540e-01f, 3.10566455e-01f, 3.53611439e-01f, 2.17327163e-01f, 5.09147704e-01f, -5.89098990e-01f, 7.26823330e-01f, -2.02103615e-01f, -4.12515283e-01f,
  2.36403048e-01f, -4.56308685e-02f, 3.47045004e-01f, 5.35826534e-02f, 1.42293081e-01f, 1.23648405e-01f, 2.50526100e-01f, 6.97821751e-02f, 2.67296046e-01f, -2.06390455e-01f,
  6.39369637e-02f, -5.21701016e-02f, -2.50120223e-01f, -4.29378062e-01f, 7.15465844e-02f, -2.19770402e-01f, 3.05815544e-02f, -1.91148922e-01f, 6.67570710e-01f, -4.68137234e-01f,
  1.06575310e-01f, 6.78309798e-01f, 3.50264162e-01f, 1.22457430e-01f, 5.38122416e-01f, -3.06869090e-01f, 5.88010997e-02f, 1.27325788e-01f, 1.55656308e-01f, 1.39382854e-01f,
  3.18421483e-01f, 5.81003785e-01f, 2.24219382e-01f, -7.49407187e-02f, 1.26979545e-01f, -5.55837601e-02f, -9.17338114e-03f, 2.80644119e-01f, -4.18667756e-02f, 1.27499580e-01f,
  1.72116101e-01f, 2.12183580e-01f, -1.96651042e-01f, 6.16748631e-03f, 1.93174824e-01f, -4.47173193e-02f, 5.04747890e-02f, -1.29092112e-01f, -5.16168438e-02f, 2.44080648e-01f,
  4.74611968e-01f, 8.05436745e-02f, -4.03976738e-01f, 4.70979750e-01f, -1.39672905e-01f, 4.86813337e-01f, -5.49626090e-02f, 2.44424179e-01f, 6.36890084e-02f, 2.69179404e-01f,
  6.33816719e-01f, -1.64795220e-01f, 3.12180333e-02f, 1.44064918e-01f, 1.83068573e-01f, 4.93204892e-02f, 2.21275717e-01f, -2.87183169e-02f, 2.55044401e-01f, 3.97589207e-02f,
  -6.20153509e-02f, 2.89440136e-02f, 9.44886059e-02f, 1.57890737e-01f, 1.71578720e-01f, -5.93815036e-02f, -2.35359631e-02f, -1.09170703e-02f, -1.46873668e-01f, -2.84028888e-01f,
  1.42183006e-01f, 2.06447765e-01f, 2.55348861e-01f, 9.15786102e-02f, -1.22036420e-01f, 4.23901677e-01f, -7.51074925e-02f, 9.20133814e-02f, -2.23443359e-01f, 1.34284243e-01f,
  1.59181431e-01f, 5.35838269e-02f, 3.60765278e-01f, -2.31224373e-01f, -3.50894570e-01f, -3.55887152e-02f, 6.36385754e-02f, -1.59650981e-01f, 4.37328145e-02f, 8.64369199e-02f,
  7.84713030e-02f, 2.24185556e-01f, -8.82728323e-02f, -3.48046534e-02f, -8.23024660e-02f, 2.52409458e-01f, -3.25585157e-01f, 2.38850564e-02f, 2.12569475e-01f, 6.50207624e-02f,
  2.91530401e-01f, 4.29951809e-02f, -2.45287478e-01f, 1.68041710e-03f, -4.96410765e-02f, 2.21429378e-01f, 2.81374548e-02f, 3.08403045e-01f, -2.86470473e-01f, 4.54873711e-01f,
  -2.62938142e-01f, 3.25881600e-01f, -1.95345923e-01f, 3.15570593e-01f, 1.68643698e-01f, 1.95126772e-01f, 4.80191521e-02f, -1.73684701e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.82203576e-01f, 1.09389968e-01f, 1.27061084e-01f, 3.02748643e-02f, 8.80385861e-02f, 1.86821088e-01f, 1.32400081e-01f, 4.92925085e-02f, -7.41722947e-03f, 1.30804062e-01f,
  2.29829788e-01f, 1.48990110e-01f, -2.56449599e-02f, 1.23158671e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -7.96067715e-02f, 1.73545137e-01f, 1.72398835e-01f, -1.93786785e-01f, -8.32881965e-03f, 7.88080916e-02f, 2.41387144e-01f, -1.17879966e-02f, -6.64730370e-02f, 3.29258621e-01f,
  -5.43517340e-03f, 9.06102732e-02f, 2.07681149e-01f, 1.55959457e-01f, 2.84088582e-01f, 5.26722297e-02f, -3.62976819e-01f, 1.04357362e-01f, 1.94510043e-01f, -2.88603067e-01f,
  -4.72247034e-01f, 1.16771922e-01f, 2.30820417e-01f, 9.53095555e-02f, -3.20658177e-01f, 3.01244974e-01f, 2.86497533e-01f, 2.40200981e-01f, -7.69402742e-01f, -1.09600350e-02f,
  -4.57763463e-01f, 1.98420554e-01f, 3.20923105e-02f, 6.83275163e-02f, -1.00910753e-01f, 1.85582668e-01f, 2.34220937e-01f, 1.33928701e-01f, -1.37839705e-01f, 1.96287513e-01f,
  1.50448099e-01f, -4.33951408e-01f, -2.37789944e-01f, -3.13763648e-01f, -3.14622551e-01f, 2.87507892e-01f, 8.37198719e-02f, 3.72929186e-01f, 3.16333324e-01f, 3.33338797e-01f,
  1.06236003e-01f, 3.63194011e-02f, -3.14552337e-01f, 2.00703129e-01f, 1.04943253e-01f, 3.50370705e-01f, 1.60477459e-01f, -5.46545446e-01f, 2.79630534e-02f, 2.49336958e-01f,
  -4.09322500e-01f, -4.22082037e-01f, -2.42940441e-01f, -3.10297430e-01f, 1.52631640e-01f, 9.52896774e-02f, -3.31639916e-01f, -2.48870119e-01f, -2.06713751e-01f, -1.30151689e-01f,
  -9.51396674e-02f, -1.63325489e-01f, 7.21205100e-02f, 8.55156779e-02f, -1.05761565e-01f, -4.07521352e-02f, 2.84629792e-01f, -1.61763698e-01f, -1.62934989e-01f, 1.36225104e-01f,
  3.88254166e-01f, -1.79060981e-01f, -6.89015567e-01f, -1.23452507e-01f, -2.85988748e-01f, 1.44039571e-01f, 2.98045099e-01f, 1.46772623e-01f, 3.30273926e-01f, 2.42033750e-02f,
  -5.17861962e-01f, -5.57515323e-01f, 1.64818168e-01f, -5.73967159e-01f, 2.58932542e-02f, -4.04396206e-02f, 4.89384122e-02f, 4.08211239e-02f, 5.19662946e-02f, -1.10236153e-01f,
  8.75767320e-04f, 1.98314428e-01f, -1.70794547e-01f, 2.00261816e-01f, -2.84328759e-02f, 2.79465854e-01f, 2.26219282e-01f, 1.49836108e-01f, -1.60459682e-01f, 3.20707202e-01f,
  3.23454998e-02f, 4.72663939e-01f, -3.25233728e-01f, 3.19788903e-01f, 2.87036628e-01f, 1.08327918e-01f, 5.56717254e-02f, -4.05975670e-01f, 4.09404077e-02f, 1.62860259e-01f,
  -5.59922993e-01f, 3.78322095e-01f, -4.56497483e-02f, -5.49252748e-01f, -5.48237741e-01f, 3.52675647e-01f, 1.02974549e-01f, 2.25262150e-01f, 6.56240582e-02f, -6.25435412e-02f,
  3.10036098e-03f, -4.02235866e-01f, 1.20062202e-01f, -6.62072375e-02f, 2.48793215e-01f, -1.70730710e-01f, -2.59994626e-01f, 3.58418941e-01f, -1.09392367e-01f, 2.31848717e-01f,
  -3.98641825e-02f, 5.05044349e-02f, -4.54495758e-01f, -4.00291294e-01f, 8.75412077e-02f, 4.28653568e-01f, 9.06323195e-02f, 2.31038660e-01f, 3.51791918e-01f, -8.83655027e-02f,
  3.15928459e-02f, -2.48951748e-01f, -8.91710669e-02f, 1.36740565e-01f, 1.02819189e-01f, 2.06224203e-01f, -8.96099657e-02f, 7.38887256e-03f, 2.83203453e-01f, -1.67125598e-01f,
  -2.52189696e-01f, 1.03876956e-01f, -1.77961081e-01f, 6.49134144e-02f, -1.74799085e-01f, 5.00522964e-02f, -1.85745731e-01f, -1.34452298e-01f, 1.48572862e-01f, 1.36790842e-01f,
  -7.88147375e-03f, 1.99876562e-01f, -3.17439258e-01f, -5.33564568e-01f, 1.56564519e-01f, -1.81951180e-01f, 1.97083846e-01f, -4.10499603e-01f, 2.97651231e-01f, -6.89418733e-01f,
  1.84210483e-02f, 2.70757467e-01f, -7.28848219e-01f, -8.47655982e-02f, -5.03793992e-02f, 3.09210047e-02f, 2.53107667e-01f, 2.59840339e-01f, 1.37212411e-01f, -2.31888983e-02f,
  -2.54149109e-01f, 2.45577455e-01f, -2.14806601e-01f, -2.82546163e-01f, 2.71645516e-01f, 3.55966270e-01f, 2.96243250e-01f, 2.51039386e-01f, 2.19452053e-01f, -2.97324926e-01f,
  8.43115076e-02f, -3.04385275e-01f, -2.78615624e-01f, -2.58124471e-01f, 1.72920048e-01f, -2.83377171e-01f, 1.55410305e-01f, -4.27196920e-01f, 1.13037482e-01f, -4.11688477e-01f,
  -3.68970752e-01f, 4.69083041e-01f, -2.18204379e-01f, -2.29540486e-02f, -1.63482159e-01f, -7.25333571e-01f, 1.60974026e-01f, -1.10674694e-01f, -5.55730045e-01f, 1.38276920e-01f,
  2.86558390e-01f, -2.08212420e-01f, -3.55313301e-01f, -1.08814046e-01f, -1.34821162e-01f, -1.99649647e-01f, -1.24172177e-02f, 1.24312453e-01f, 3.95872965e-02f, 3.78392152e-02f,
  2.46743821e-02f, 1.29912913e-01f, -3.23837996e-02f, -2.02450585e-02f, 2.26305708e-01f, -1.91466659e-01f, -1.04894958e-01f, -2.53993899e-01f, 1.54855311e-01f, -2.50143945e-01f,
  -2.34382576e-03f, -3.05789292e-01f, -1.78760737e-01f, -4.17707890e-01f, 4.14753735e-01f, -1.95843160e-01f, -5.23693681e-01f, 1.59763709e-01f, -3.18547666e-01f, 1.32730916e-01f,
  -3.94131601e-01f, -2.35766441e-01f, 2.14146569e-01f, 3.47479343e-01f, 3.00824612e-01f, 2.60135800e-01f, -1.27928946e-02f, 1.02378197e-01f, 1.62419900e-01f, 2.07819596e-01f,
  -1.56413764e-01f, 1.02745153e-01f, -3.97897419e-03f, 2.45845795e-01f, 6.89635333e-03f, -2.07048237e-01f, -3.00376937e-02f, -1.64565429e-01f, 3.54571849e-01f, -1.48852229e-01f,
  9.16220322e-02f, 2.71170080e-01f, -1.99137494e-01f, 2.44036451e-01f, 4.89831001e-01f, -4.62036788e-01f, -1.76211238e-01f, -3.83145630e-01f, -4.24967438e-01f, 1.16129518e-01f,
  2.36894205e-01f, -1.30059078e-01f, -2.93066978e-01f, -4.01005059e-01f, 4.05569702e-01f, 2.16435686e-01f, -1.72811061e-01f, -2.64596879e-01f, 3.41806173e-01f, -2.52314687e-01f,
  4.17166650e-02f, -9.41398218e-02f, -1.66434445e-03f, -3.83091122e-02f, -2.24591509e-01f, -4.02494334e-02f, 1.28049895e-01f, -8.95052031e-02f, 1.78081572e-01f, 3.71495217e-01f,
  -3.38523328e-01f, 3.98820877e-01f, 8.54776651e-02f, -2.18153283e-01f, -1.95572987e-01f, -2.88504642e-02f, -5.05561948e-01f, -8.84284675e-02f, -6.96275830e-02f, 3.23201567e-01f,
  -1.67434454e-01f, -5.88088274e-01f, 3.33828107e-02f, -3.46054137e-01f, 4.77170795e-01f, 4.26664382e-01f, -3.06568313e-02f, -6.77685976e-01f, -3.47406387e-01f, -4.24426824e-01f,
  6.37318864e-02f, 1.32951364e-01f, 7.09585771e-02f, -1.44571751e-01f, 3.84179987e-02f, -2.83400685e-01f, -3.74670839e-03f, -1.68668196e-01f, -2.23225221e-01f, -2.50038296e-01f,
  2.57301629e-01f, -5.79883978e-02f, -4.37042192e-02f, 2.35266648e-02f, -9.04280916e-02f, -1.37874618e-01f, -3.30170393e-01f, 3.82587127e-02f, 8.98549706e-02f, 3.74258310e-01f,
  -4.82828289e-01f, -4.72608447e-01f, 4.35418129e-01f, 2.57506043e-01f, 7.51849264e-02f, -3.95291626e-01f, -1.17247859e-02f, -3.42286378e-01f, -4.23093706e-01f, 1.40515734e-02f,
  1.20604910e-01f, -4.98152599e-02f, 1.22196108e-01f, 2.14520961e-01f, 1.42578721e-01f, 1.39715508e-01f, 1.27179876e-01f, -2.04331130e-01f, 5.00212833e-02f, -1.43316761e-01f,
  1.40681684e-01f, -2.57002771e-01f, -5.69258891e-02f, -4.81623411e-02f, -1.85825527e-01f, 6.83225542e-02f, -9.99838859e-02f, 2.60137647e-01f, 3.23500484e-01f, 1.64574742e-01f,
  -2.30860323e-01f, 2.50357717e-01f, 3.07839364e-01f, -3.92962515e-01f, 2.89520115e-01f, -4.53670025e-01f, -1.59663379e-01f, -1.32895127e-01f, -5.30397892e-01f, -5.67192495e-01f,
  2.99707264e-01f, 2.37862304e-01f, 2.84813076e-01f, -4.17579800e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.40090659e-01f, -1.13129929e-01f, -2.47925334e-02f, -1.12610117e-01f, -1.28453210e-01f, -9.73016471e-02f, 5.20008728e-02f, 1.25151603e-02f, 1.82216883e-01f, -1.35800257e-01f,
  5.54013066e-02f, -1.13029428e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    