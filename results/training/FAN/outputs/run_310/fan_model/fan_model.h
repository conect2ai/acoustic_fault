/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.40710187e-01f, -4.41293046e-02f, -8.37131813e-02f, -3.79502147e-01f, -1.48678660e-01f, -4.51113805e-02f, -7.19340816e-02f, -2.20262319e-01f, -1.49022400e-01f, 9.20755714e-02f,
  -6.28708676e-02f, 8.65680515e-04f, 2.32285231e-01f, -1.65776014e-01f, 8.02775174e-02f, 2.54100233e-01f, -3.10334831e-01f, -7.58659616e-02f, 6.46405146e-02f, -2.11712956e-01f,
  -1.01891801e-01f, -5.04354611e-02f, 4.32626531e-02f, -3.26073803e-02f, -1.89910933e-01f, -1.69978917e-01f, 2.52291020e-02f, 8.16073194e-02f, -1.26199871e-01f, 1.22434556e-01f,
  4.38982546e-02f, 4.20227870e-02f, -2.73393262e-02f, 1.00990087e-02f, -3.38489413e-02f, -4.44239974e-02f, -4.90267249e-03f, 1.02236420e-01f, -8.27419013e-03f, -7.51704862e-03f,
  -2.82181986e-03f, -2.58693509e-02f, -4.59240600e-02f, 4.62492220e-02f, -6.32784665e-02f, -3.94019000e-02f, 5.96900936e-03f, -7.37412646e-02f, 1.81729756e-02f, -2.49272007e-02f,
  -6.06062226e-02f, -5.89098930e-02f, -3.83352824e-02f, -1.52879870e-02f, -5.79501614e-02f, -3.87895219e-02f, -1.37576023e-02f, 3.09024416e-02f, -5.71071468e-02f, -5.40869348e-02f,
  1.43531151e-02f, -1.47129260e-02f, 2.99399327e-02f, -2.83217914e-02f, -2.02096384e-02f, 1.52161364e-02f, -1.00254975e-02f, 8.18889439e-02f, -2.38597132e-02f, 2.59061027e-02f,
  -1.37888631e-02f, -1.65272281e-02f, -1.73942316e-02f, -7.31234848e-02f, -2.20586769e-02f, -1.79588739e-02f, 2.59995721e-02f, 3.78934317e-03f, -8.30017403e-02f, -7.05643266e-04f,
  6.38540536e-02f, 3.41612622e-02f, 3.05831488e-02f, 3.39673348e-02f, -2.03954596e-02f, 5.78022711e-02f, -3.87864597e-02f, 4.94012423e-02f, 1.19353645e-02f, 2.36687809e-02f,
  -1.04786061e-01f, -8.39736089e-02f, -9.45232478e-06f, 1.17413662e-02f, 2.51664687e-02f, -4.69339862e-02f, 2.49953419e-02f, -2.60993578e-02f, -3.41603085e-02f, -8.90424289e-03f,
  -1.17204040e-01f, -3.97248343e-02f, -9.74886306e-03f, -5.77707887e-02f, 1.96341295e-02f, -1.55173903e-02f, -6.89091682e-02f, 4.93295083e-04f, -2.18988098e-02f, -1.03299115e-02f,
  -4.34997715e-02f, 5.43355895e-03f, 1.13908825e-02f, 3.19306701e-02f, -1.70652084e-02f, -1.20768119e-02f, -6.93487525e-02f, -3.06696072e-02f, -1.77392585e-03f, 2.02818308e-02f,
  -8.72460566e-03f, 3.86012495e-02f, 7.10756928e-02f, -1.50556445e-01f, 3.95001657e-02f, -2.24363238e-01f, -3.01703125e-01f, -8.09421688e-02f, -1.64692178e-01f, -4.76537198e-02f,
  -1.28448024e-01f, 1.14376739e-01f, -3.63687351e-02f, -1.83338717e-01f, -3.18189710e-01f, -1.57351911e-01f, -2.53980398e-01f, -7.45448768e-02f, -6.58240840e-02f, -5.30681387e-02f,
  -1.49423331e-01f, -2.60052025e-01f, -3.92729305e-02f, -3.66164632e-02f, 2.19591353e-02f, 1.23030372e-01f, 7.77778774e-03f, 9.95106846e-02f, 4.08972055e-03f, -4.52854410e-02f,
  -1.01842033e-02f, 2.58616544e-02f, -2.48959679e-02f, 7.46989325e-02f, -7.45204166e-02f, 6.89303130e-02f, 1.27688898e-02f, 5.57428785e-02f, 2.07621045e-03f, -5.22079356e-02f,
  7.41937980e-02f, 3.14152129e-02f, -5.68680167e-02f, -1.83289498e-02f, 4.77146991e-02f, -2.70092417e-03f, 9.46087316e-02f, -6.48811983e-04f, 4.19858545e-02f, 3.97744067e-02f,
  -3.74387018e-02f, 7.84272403e-02f, 1.02187181e-02f, 2.84766760e-02f, -4.04998437e-02f, -2.67636273e-02f, 2.13533938e-02f, -9.85613931e-03f, 5.48661649e-02f, -3.90044078e-02f,
  -2.30924319e-02f, -4.32959236e-02f, -3.73983458e-02f, -4.16065939e-02f, -3.12260687e-02f, -2.33787205e-02f, 2.12719273e-02f, 3.24691972e-03f, 5.63409589e-02f, -5.32901473e-02f,
  -5.87229664e-03f, 5.68036325e-02f, -3.97255421e-02f, 5.40173566e-03f, 2.77252886e-02f, 8.22680667e-02f, 1.83321778e-02f, 1.13356531e-01f, -6.36367053e-02f, 4.22175452e-02f,
  3.25950831e-02f, 2.52146879e-03f, 1.24519700e-02f, -4.47672494e-02f, 3.45463157e-02f, -2.16857307e-02f, -2.10349006e-03f, 7.97284767e-03f, -2.68154871e-02f, -1.98321920e-02f,
  -1.80201918e-01f, -9.19668302e-02f, 4.17266414e-02f, -4.97606695e-02f, 1.05551489e-01f, -1.35253239e-02f, -4.59571443e-02f, 1.87556241e-02f, -5.73168397e-02f, -4.82059494e-02f,
  3.59504633e-02f, 6.52451022e-03f, 3.58703546e-03f, 4.62175906e-02f, -5.36101386e-02f, -8.71241018e-02f, -7.98853189e-02f, 5.68058826e-02f, 3.98333464e-03f, 6.33483455e-02f,
  2.50796229e-02f, -5.45947142e-02f, -4.58036773e-02f, -3.53706330e-02f, 1.87852290e-02f, 2.80820541e-02f, -5.63361309e-02f, 7.19789788e-02f, 2.11661472e-03f, 2.64562983e-02f,
  3.83986905e-02f, -4.55030017e-02f, 1.02621447e-02f, 1.42158285e-01f, 1.03366025e-01f, -1.23054214e-01f, -1.81605086e-01f, 1.17464319e-01f, -1.67286038e-01f, -3.71950469e-03f,
  5.82665205e-02f, -8.36498514e-02f, -1.70754790e-01f, -1.24381952e-01f, -1.11346439e-01f, -3.46677303e-01f, -9.96058807e-02f, -9.03519394e-04f, -3.26986760e-02f, 1.65538773e-01f,
  5.53257093e-02f, 1.38089776e-01f, -4.33410257e-02f, 2.00651884e-01f, 1.09937534e-01f, 2.70441175e-01f, 1.51724890e-01f, 6.24143779e-02f, 2.54439592e-01f, -5.33522815e-02f,
  -7.94254318e-02f, 7.22932741e-02f, -3.05158999e-02f, -1.02959268e-01f, 7.94072375e-02f, 8.58086441e-03f, 2.44710930e-02f, -4.74060178e-02f, 3.50977965e-02f, 1.70720629e-02f,
  -5.76836802e-02f, 5.47761172e-02f, 1.21992882e-02f, -6.47010729e-02f, 2.26370674e-02f, 1.74264126e-02f, -2.19726488e-02f, -6.95763505e-04f, 4.76591177e-02f, 8.48245714e-03f,
  -1.09016420e-02f, 1.13625200e-02f, 8.15731287e-02f, 1.34123061e-02f, 5.73824421e-02f, -2.76814289e-02f, 6.46015909e-03f, 1.21815279e-02f, 3.26652601e-02f, -7.03643775e-03f,
  7.00563937e-02f, 1.54693006e-02f, 2.34315246e-02f, -3.76641378e-02f, 3.15858722e-02f, 3.37493680e-02f, -1.30845457e-02f, 1.06188096e-02f, 1.32182194e-02f, 1.69498508e-03f,
  6.07358068e-02f, 4.45552543e-02f, -3.53481211e-02f, 4.14766520e-02f, 2.00838204e-02f, -2.23881174e-02f, -3.97425741e-02f, 2.85219718e-02f, -4.56758449e-03f, 1.44735854e-02f,
  -8.36037621e-02f, -2.07257383e-02f, 6.82701543e-02f, 2.07247701e-03f, -7.57476911e-02f, 1.01278611e-02f, 5.54450005e-02f, -4.19878475e-02f, -4.96716145e-03f, -4.34606224e-02f,
  8.45782310e-02f, 1.86082914e-01f, -1.09173665e-02f, 6.33267611e-02f, -4.82434668e-02f, -1.21920919e-02f, -9.41150859e-02f, 3.90031636e-02f, -1.52582880e-02f, 1.94620062e-02f,
  1.03597671e-01f, -1.21440506e-02f, -3.70352007e-02f, 1.07340470e-01f, -5.09910192e-03f, 3.73014882e-02f, 2.16440130e-02f, -1.08726765e-03f, 1.47761181e-02f, 4.50966023e-02f,
  1.51445761e-01f, 2.80983169e-02f, -7.72472471e-02f, 5.15734293e-02f, 9.63570997e-02f, 3.65864672e-02f, 4.64373641e-02f, 5.37113547e-02f, -5.27541339e-02f, -6.05598316e-02f,
  -3.02415527e-02f, 3.08498621e-01f, 3.25334460e-01f, 2.53673851e-01f, -2.69886591e-02f, 4.08685207e-03f, 5.89908101e-02f, 1.49602860e-01f, 9.99999940e-02f, -8.52576047e-02f,
  -1.21141724e-01f, 1.06183439e-01f, -1.00281574e-01f, 8.65213871e-02f, 8.03927109e-02f, -2.41500363e-02f, 8.78722444e-02f, 1.51757514e-02f, 9.76343602e-02f, 4.99567948e-02f,
  5.36194034e-02f, -2.56766845e-02f, 9.57979783e-02f, 5.28618395e-02f, 4.59802076e-02f, 1.20952062e-01f, -2.09075943e-01f, 2.26227324e-02f, -8.21936689e-03f, 5.04203998e-02f,
  1.06891720e-02f, -2.57278755e-02f, 1.72115471e-02f, 6.51983544e-02f, -7.67304078e-02f, -7.58384690e-02f, -1.41039593e-02f, 6.90373257e-02f, 4.34389822e-02f, 7.48223141e-02f,
  2.65999045e-02f, 3.81017327e-02f, 1.19075872e-01f, 3.70955244e-02f, 1.60420723e-02f, 1.24520056e-01f, -2.75362171e-02f, 3.67024215e-03f, 9.38574597e-02f, 6.86348155e-02f,
  7.26033449e-02f, 5.77230714e-02f, -1.20974593e-02f, 2.35483237e-02f, 2.70694438e-02f, 6.22175410e-02f, -2.49992628e-02f, -4.87012640e-02f, 1.99868884e-02f, 5.61199225e-02f,
  9.29102525e-02f, -3.00080441e-02f, -4.42120917e-02f, 2.58933101e-03f, 5.26472218e-02f, -4.15030979e-02f, 7.49162817e-03f, -3.72714847e-02f, 2.17542909e-02f, -5.81350923e-02f,
  -2.80733686e-02f, 1.47917746e-02f, -4.81616296e-02f, -3.45266759e-02f, -5.73696308e-02f, -1.41766323e-02f, -4.30496484e-02f, -1.58426929e-02f, 1.27422670e-02f, -9.34754536e-02f,
  5.29334843e-02f, 2.57807188e-02f, -2.97056269e-02f, -9.93445218e-02f, 4.48682085e-02f, -1.73397828e-02f, 7.22930208e-02f, 5.34802116e-02f, 3.31647694e-02f, -5.72843403e-02f,
  -1.59145206e-01f, 7.96419010e-02f, 8.20680521e-03f, -3.58547717e-02f, 6.52988581e-03f, -1.23856566e-03f, -1.42150745e-02f, -1.84086878e-02f, 4.07439210e-02f, 2.44787578e-02f,
  -1.89430155e-02f, -1.70226749e-02f, -2.17188690e-02f, -2.10088608e-03f, 6.12034835e-02f, -4.00777049e-02f, -8.80467799e-03f, 6.95082545e-03f, -5.11258468e-02f, -4.19800822e-03f,
  -1.03257438e-02f, -2.35658400e-02f, -5.31451181e-02f, 3.03604314e-03f, -8.84095728e-02f, -6.86295703e-02f, -4.57842834e-02f, 9.91206393e-02f, 2.81928759e-03f, 4.80406731e-02f,
  -1.25140756e-01f, 3.80207896e-02f, 2.54379272e-01f, 4.64470014e-02f, -1.36340290e-01f, -1.12176359e-01f, -1.29403612e-02f, 1.07931672e-02f, 7.84475580e-02f, -2.34822258e-02f,
  -6.81694075e-02f, 8.73874351e-02f, 4.13786285e-02f, 1.74197871e-02f, 1.01172559e-01f, 1.95194840e-01f, -6.02189777e-03f, -9.73159168e-03f, 5.51672280e-02f, -7.06194341e-02f,
  1.40743822e-01f, -5.16843498e-02f, 2.13515162e-01f, -9.12845507e-02f, -1.71521798e-01f, 5.99429086e-02f, -3.02612409e-02f, 6.91585392e-02f, -9.42111611e-02f, -1.83276813e-02f,
  -9.32833031e-02f, -4.17899527e-02f, -4.22116630e-02f, -2.82068588e-02f, -5.93809132e-03f, -5.24007389e-03f, 4.61839661e-02f, -7.70564936e-03f, -4.73180488e-02f, 5.16456924e-02f,
  -3.94456126e-02f, -3.13391834e-02f, -1.88073888e-02f, 1.92617010e-02f, -3.68719772e-02f, 1.00931954e-02f, -5.58304302e-02f, -5.92423193e-02f, 4.02801633e-02f, -3.72284018e-02f,
  2.78446591e-03f, -3.43836728e-03f, -5.14923558e-02f, -2.26081368e-02f, 7.72673339e-02f, -3.50466520e-02f, 6.86386898e-02f, -1.43120876e-02f, -5.79820611e-02f, -5.44213802e-02f,
  6.31891638e-02f, 1.02709323e-01f, -1.57220718e-02f, -7.94267654e-02f, -2.22342797e-02f, 1.21227531e-02f, -6.40952885e-02f, 4.63772006e-02f, 1.30425598e-02f, 7.02895736e-03f,
  -9.64565724e-02f, 2.42866371e-02f, -1.99396797e-02f, 9.20723134e-04f, 4.43205573e-02f, 3.63928080e-02f, 1.93078369e-02f, -1.49093587e-02f, 8.30662027e-02f, 2.31329817e-02f,
  -2.00314783e-02f, -3.51569541e-02f, 1.72692761e-02f, 1.69463623e-02f, -1.80571212e-03f, 2.22902205e-02f, 2.63094082e-02f, -8.07858247e-04f, -1.05654523e-02f, -5.05491719e-02f,
  -1.95359930e-01f, 5.78365102e-03f, 3.62649597e-02f, -1.43748000e-01f, -2.76970975e-02f, 3.28945369e-02f, 6.41094074e-02f, -3.95887792e-02f, -6.09775074e-03f, -2.04889732e-03f,
  -6.46834001e-02f, -1.94603167e-02f, -4.06362768e-03f, -2.25595683e-02f, 6.30570129e-02f, -3.49957980e-02f, 5.85976131e-02f, 3.00825611e-02f, -1.06119223e-01f, -6.85111433e-02f,
  -4.36691344e-02f, -7.78796598e-02f, 7.50313327e-02f, -2.44860724e-02f, -5.06453402e-03f, -5.50203472e-02f, -7.20298290e-02f, 8.04413389e-03f, -4.94244834e-03f, -1.67840235e-02f,
  -1.00110412e-01f, 1.96508422e-01f, 3.45305577e-02f, -3.26098278e-02f, -2.41638526e-01f, -3.43248844e-01f, -2.03791887e-01f, 1.29327327e-01f, 4.02589608e-03f, 1.33877605e-01f,
  -1.61921054e-01f, 2.59401519e-02f, 1.71055779e-01f, -3.95739898e-02f, -2.11464897e-01f, 1.20364666e-01f, -1.54576689e-01f, -1.74569190e-01f, 1.22824073e-01f, -1.28770508e-02f,
  2.18887385e-02f, -1.08152114e-01f, 9.48973298e-02f, 1.19304150e-01f, -1.78290710e-01f, 4.65605482e-02f, 3.39907855e-02f, 7.53164366e-02f, 1.39749022e-02f, -7.37528205e-02f,
  -1.32416517e-01f, 5.73006459e-02f, 6.25852644e-02f, 1.46514460e-01f, -6.90636337e-02f, -1.06065594e-01f, -7.64514208e-02f, -3.65214422e-02f, -1.18992506e-02f, -3.01312050e-03f,
  3.97442356e-02f, 2.32285764e-02f, 8.55304860e-03f, 3.47720869e-02f, 2.27079745e-02f, -5.75646386e-03f, 4.42576930e-02f, 1.50970742e-02f, -3.01365517e-02f, -4.97150794e-03f,
  -2.86445096e-02f, -3.02351508e-02f, -4.10584025e-02f, -2.42497921e-02f, -1.87984314e-02f, -2.44363695e-02f, -7.23696947e-02f, -4.93594669e-02f, 2.95682363e-02f, -6.11842982e-02f,
  -7.83206895e-03f, 1.00622714e-01f, -2.17653885e-02f, 7.26101175e-02f, -2.58579105e-02f, 3.06395311e-02f, 5.03570884e-02f, 2.18143556e-02f, 1.81084555e-02f, -4.30453531e-02f,
  -3.03476769e-02f, 7.40754232e-03f, -3.82183231e-02f, 6.00730702e-02f, -1.31629646e-01f, 3.29127721e-02f, -4.29161936e-02f, 1.28703221e-04f, -2.12151324e-03f, -4.03742632e-03f,
  6.80049732e-02f, -3.06205060e-02f, -2.38698591e-02f, 1.77430250e-02f, -9.91460029e-03f, -5.39152045e-03f, 4.13290076e-02f, 1.08582368e-02f, 1.11609399e-02f, -8.61044377e-02f,
  -2.18672138e-02f, 1.03188150e-01f, 2.36768685e-02f, -1.53575996e-02f, 9.78252478e-03f, -4.25219052e-02f, 5.75577244e-02f, -2.72562522e-02f, 2.85048727e-02f, 4.45082895e-02f,
  -8.40948522e-02f, 1.93726104e-02f, -7.10382834e-02f, 4.06056456e-02f, -2.84604393e-02f, -2.99899001e-02f, -7.61092827e-02f, -5.56447692e-02f, 1.31130973e-02f, 2.81106010e-02f,
  1.26909986e-02f, -2.96768323e-02f, -1.46006206e-02f, -6.21383190e-02f, -4.19617668e-02f, -6.59796000e-02f, 5.68863228e-02f, -5.94934486e-02f, -4.26180027e-02f, 5.09011326e-03f,
  -3.14937055e-01f, -2.67704040e-01f, 8.03093538e-02f, -1.49836183e-01f, 1.94241747e-01f, -8.69774744e-02f, -2.12790757e-01f, 1.16027407e-01f, -2.58961041e-02f, -2.89879441e-01f,
  -1.26294449e-01f, -1.69572517e-01f, -3.32347751e-02f, -3.01878512e-01f, -7.16566620e-03f, -1.23911746e-01f, -2.73043841e-01f, -1.99596420e-01f, 4.99697104e-02f, -6.62774444e-02f,
  7.66559988e-02f, -1.06249303e-01f, 6.33681938e-02f, 2.14725643e-01f, -4.98607531e-02f, 1.58085600e-01f, 1.00195132e-01f, 2.15340331e-01f, 4.25897501e-02f, 8.33503008e-02f,
  -2.47648042e-02f, 1.53945864e-03f, 1.78695805e-02f, 4.04928923e-02f, -2.06581224e-02f, -2.83742640e-02f, -1.36138108e-02f, -3.53089795e-02f, 7.75573030e-02f, 3.83708403e-02f,
  -7.67639354e-02f, 7.23176375e-02f, 3.17497738e-02f, 3.59268561e-02f, -2.62852311e-02f, 8.19660649e-02f, 2.30994243e-02f, 2.86773201e-02f, 3.68710980e-02f, 1.33256521e-02f,
  2.24595666e-02f, 4.38024662e-02f, -2.31566876e-02f, 5.47685754e-03f, 5.38935922e-02f, 1.08088888e-02f, -1.55674061e-03f, 1.00367382e-01f, 1.51712131e-02f, 3.05168089e-02f,
  -4.43521962e-02f, 5.51238842e-02f, 8.89954809e-03f, 2.60225162e-02f, 4.39260863e-02f, 2.00030636e-02f, -1.41436455e-03f, -6.34698663e-03f, -1.28452992e-02f, -5.17449118e-02f,
  -2.85025425e-02f, 1.38214873e-02f, 3.96336522e-03f, -1.43393604e-02f, 5.45736495e-03f, -4.56368774e-02f, -7.73107912e-03f, -1.85160041e-02f, 1.96007900e-02f, 2.42500324e-02f,
  -3.25744562e-02f, -4.70603956e-03f, 2.28462312e-02f, 3.97262536e-03f, -1.84909869e-02f, 2.90364139e-02f, 1.60558540e-02f, 4.91113476e-02f, 1.58269028e-03f, 4.50261869e-02f,
  -1.02199530e-02f, -1.56211987e-01f, -1.66870859e-02f, 6.74691843e-03f, -9.45503707e-05f, -6.94996491e-02f, -3.33587378e-02f, 2.49921475e-02f, -1.12462118e-02f, -1.12978574e-02f,
  3.11484300e-02f, -1.38415536e-02f, -2.48337742e-02f, -2.26095691e-03f, 1.28848283e-02f, -2.64495146e-02f, -3.19256261e-02f, 1.92852076e-02f, 2.72309035e-02f, 2.80188825e-02f,
  2.86521874e-02f, -4.28176746e-02f, 5.48938438e-02f, 5.85977212e-02f, -1.02173649e-02f, 4.45089396e-03f, 4.23963182e-02f, -1.30576547e-02f, 4.38168570e-02f, -5.83120510e-02f,
  -2.72329062e-01f, -1.76867992e-01f, -1.62419200e-01f, -2.43715510e-01f, 1.49224907e-01f, -1.82537884e-01f, -1.17551833e-01f, -1.73112676e-01f, -2.22756505e-01f, -2.92728320e-02f,
  8.20333883e-02f, -5.84996864e-02f, 1.03452489e-01f, -8.65545869e-02f, 2.22464222e-02f, 1.96831785e-02f, -1.73118651e-01f, -1.24643601e-01f, -3.19533944e-02f, -1.77783087e-01f,
  -1.01660214e-01f, 3.20611596e-02f, -7.18630999e-02f, 1.39335036e-01f, -1.57005951e-01f, -1.13471948e-01f, 1.09636985e-01f, 1.60544783e-01f, -1.86121482e-02f, 1.04373269e-01f,
  -6.04236908e-02f, -1.40792355e-01f, -4.12550643e-02f, 1.80561934e-02f, -8.77062976e-02f, -7.86827952e-02f, -2.35510003e-02f, 1.33503363e-01f, -3.72983254e-02f, -4.39137146e-02f,
  3.68251614e-02f, 5.74351214e-02f, 2.79249228e-03f, 1.07727582e-02f, 9.49641969e-03f, 1.55194132e-02f, 3.28378826e-02f, -4.68406267e-02f, 2.63256785e-02f, -2.62478832e-02f,
  -1.74849275e-02f, 1.30991610e-02f, -3.87151018e-02f, -2.71312147e-02f, 7.95596838e-03f, -4.74301130e-02f, -4.31476757e-02f, 1.26759466e-02f, -1.02620525e-02f, -3.71946618e-02f,
  3.99845168e-02f, 1.68377720e-02f, 4.98743579e-02f, 7.55874254e-03f, 1.39768980e-02f, -1.46546331e-03f, 5.02016768e-02f, 4.31981944e-02f, 4.19314802e-02f, 1.79773234e-02f,
  -2.97389068e-02f, -3.10626201e-05f, -2.85741370e-02f, -7.23510459e-02f, 4.52470360e-03f, 5.25514071e-04f, -4.28295992e-02f, -1.07175810e-02f, -5.71599044e-02f, 1.80899967e-02f,
  -2.95409206e-02f, -4.18290086e-02f, -2.57227570e-02f, 5.93792759e-02f, 1.87134836e-02f, 2.22237948e-02f, -2.45924145e-02f, -5.61340302e-02f, 3.15746218e-02f, 5.46052679e-02f,
  -3.08114719e-02f, -9.76769924e-02f, 1.21844588e-02f, 1.39877582e-02f, 3.05005163e-02f, 3.21875163e-03f, 3.35382269e-04f, -6.22560792e-02f, 1.27824745e-03f, 4.70329542e-03f,
  -4.56962436e-02f, 1.77953276e-03f, -3.70621942e-02f, 4.14704271e-02f, 1.93933193e-02f, -8.76089965e-04f, -3.65887433e-02f, 2.20377333e-02f, -8.52307901e-02f, 5.24288192e-02f,
  -4.87613194e-02f, 3.50314528e-02f, -2.93635651e-02f, 5.64342918e-06f, -5.57811977e-03f, -4.51695221e-03f, -2.71917991e-02f, -3.49258748e-03f, 2.67182831e-02f, 4.78732996e-02f,
  -2.12905109e-01f, -1.62385419e-01f, -6.93503320e-02f, -1.75071567e-01f, 2.04934806e-01f, -9.68624875e-02f, -1.27644022e-03f, -5.34635633e-02f, -6.85964897e-02f, -1.62030458e-01f,
  -9.86830052e-03f, -9.06929225e-02f, -3.26811001e-02f, -1.30766213e-01f, -7.91478753e-02f, -6.80470467e-02f, -1.41123280e-01f, -1.51921630e-01f, 1.10266745e-01f, -1.54266164e-01f,
  2.44936366e-02f, -1.09686181e-01f, 3.26688960e-02f, -3.74378338e-02f, -8.85050073e-02f, -2.99352594e-03f, 2.74969861e-02f, 1.30239412e-01f, -1.34393558e-01f, 1.58725716e-02f,
  -5.25232218e-02f, -4.14270274e-02f, 6.36296347e-02f, -7.04256594e-02f, -4.02272232e-02f, 1.03001632e-02f, -4.30702977e-02f, 7.79020116e-02f, 1.03045747e-01f, -4.58231792e-02f,
  -6.05001487e-02f, 5.54950200e-02f, -2.27695871e-02f, 1.14395477e-01f, -7.46315578e-03f, 8.71532634e-02f, 5.85347749e-02f, -5.85967340e-02f, 5.58454171e-03f, 1.04621194e-01f,
  3.79997529e-02f, -9.26438570e-02f, 6.35615215e-02f, -6.10627457e-02f, 9.41253975e-02f, -7.43763708e-03f, 1.18218735e-02f, -1.17995832e-02f, 3.27298976e-02f, -2.96869315e-02f,
  1.02227107e-02f, 3.73044275e-02f, -6.97658956e-02f, 4.76603620e-02f, -1.05240211e-01f, -1.88345481e-02f, -2.74458732e-02f, 6.82218652e-03f, -1.32613834e-02f, -3.92962694e-02f,
  -5.14564198e-03f, -1.03377542e-02f, -6.23363815e-02f, 3.80004719e-02f, -5.93118630e-02f, -4.46522385e-02f, 3.62649858e-02f, -2.32705884e-02f, -2.05773376e-02f, 3.47280726e-02f,
  -5.79640232e-02f, 3.50817293e-02f, -2.57386770e-02f, 4.11344655e-02f, -3.19917426e-02f, 3.76574807e-02f, 1.00821061e-02f, 3.36360857e-02f, 4.46944423e-02f, -1.93393230e-02f,
  -2.54494071e-01f, -1.98817790e-01f, -2.24957727e-02f, 6.48839250e-02f, -8.53039473e-02f, 4.00941819e-02f, 6.76745083e-03f, -7.03231990e-02f, -1.28164276e-01f, -4.96101379e-02f,
  6.11207485e-02f, 4.24639136e-02f, -8.05763826e-02f, -5.76194227e-02f, 1.67872664e-02f, -1.14359245e-01f, -4.37506773e-02f, -1.23913102e-02f, -2.76656132e-02f, -5.66391461e-03f,
  -2.21098047e-02f, -1.16925351e-02f, -2.17161626e-02f, 1.95841007e-02f, 3.55112478e-02f, -5.90001349e-04f, -4.13038917e-02f, 1.26412204e-02f, 1.30733820e-02f, -1.16100330e-02f,
  2.41236761e-01f, -3.53573784e-02f, 3.36280525e-01f, 1.51320547e-01f, 3.72116044e-02f, 6.43313900e-02f, 1.53130442e-01f, -9.74658469e-04f, 3.14838976e-01f, -1.95468619e-01f,
  -1.22964121e-01f, 1.83460355e-01f, -4.09323759e-02f, 1.60282478e-02f, 1.42381251e-01f, 2.02145204e-02f, -6.37976229e-02f, -1.99085511e-02f, 4.70684394e-02f, -1.35444039e-02f,
  2.51787156e-02f, -2.23203748e-01f, -3.80042456e-02f, -8.36626589e-02f, 7.80961290e-02f, 1.18957572e-01f, -2.38062888e-01f, 5.36864735e-02f, -1.52946323e-01f, 3.90795171e-02f,
  6.22217357e-02f, -1.28191756e-02f, 8.60744044e-02f, 1.00580946e-01f, -5.84307350e-02f, -6.66141063e-02f, 1.20567502e-02f, 1.97704937e-02f, 7.22942501e-03f, 2.82122158e-02f,
  -1.16605889e-02f, -5.82559826e-03f, 4.10027727e-02f, -2.91811433e-02f, 5.75173832e-02f, 5.35567477e-02f, 1.38252238e-02f, 2.89423391e-02f, 4.14092131e-02f, 1.86942630e-02f,
  1.37525667e-02f, -5.65513484e-02f, -2.22477186e-02f, -7.55655905e-03f, 6.05563596e-02f, 2.12246273e-02f, 6.91179857e-02f, 6.23165779e-02f, 2.00059544e-03f, -1.98040530e-03f,
  -4.95122857e-02f, -3.64065170e-02f, 1.93178430e-02f, -3.39071564e-02f, 1.26003912e-02f, -4.79073822e-02f, -6.74506426e-02f, 2.27528177e-02f, 4.47385609e-02f, 3.40893827e-02f,
  -5.60639687e-02f, 2.03326456e-02f, 3.22542875e-03f, 1.01692462e-02f, -5.98629788e-02f, 3.27741401e-03f, 3.98386158e-02f, 3.60269025e-02f, -5.49473800e-02f, 3.70188840e-02f,
  -1.35699650e-02f, 6.50663376e-02f, -8.83868262e-02f, 3.83522511e-02f, -3.01206801e-02f, 6.57826290e-02f, -3.21703665e-02f, -1.70221645e-02f, 2.29067672e-02f, 1.00193219e-03f,
  -2.61711460e-02f, -6.48626909e-02f, 5.75651415e-04f, 3.43328230e-02f, 4.35384028e-02f, 1.68024302e-02f, 9.90564190e-03f, 2.87202653e-02f, -1.83652434e-02f, -3.92190320e-03f,
  -6.46824669e-03f, 2.17895582e-02f, -8.79963115e-02f, 3.55258994e-02f, 7.21938035e-04f, -2.03851908e-02f, -4.05588606e-03f, -1.58264451e-02f, -9.30178612e-02f, -5.23564930e-04f,
  1.68055426e-02f, 4.06725220e-02f, 3.12440563e-02f, -5.60554415e-02f, -7.25875497e-02f, -1.68534331e-02f, -1.31927021e-02f, 2.14308929e-02f, -4.07526195e-02f, -3.05618029e-02f,
  -3.03783268e-01f, 6.79844469e-02f, 7.31696561e-02f, -1.71395913e-01f, -1.10279441e-01f, 8.98725912e-02f, 9.48563293e-02f, -1.02355152e-01f, -3.51617724e-01f, 6.52013272e-02f,
  9.83972251e-02f, -8.82972479e-02f, 1.18503504e-01f, -7.39929499e-03f, -1.34095386e-01f, 1.35934830e-01f, -1.19534343e-01f, 6.00001179e-02f, -2.67332364e-02f, -6.26389310e-02f,
  -4.72330637e-02f, -9.79009941e-02f, 1.35922149e-01f, 1.41762719e-01f, 1.95210408e-02f, -4.00143676e-03f, -1.24693207e-01f, 6.93868324e-02f, -7.42073823e-03f, 1.13649495e-01f,
  8.72400531e-04f, 5.61167765e-03f, -2.54154904e-03f, 1.89731307e-02f, 2.86524501e-02f, 6.59370720e-02f, 5.41200005e-02f, 7.72834793e-02f, 5.35175111e-03f, -1.89638436e-02f,
  -1.49371121e-02f, -2.67950632e-02f, -6.78226724e-02f, -1.82490442e-02f, -9.50528383e-02f, -7.03475671e-03f, 5.90085685e-02f, 5.06363772e-02f, 6.10869564e-02f, 3.98059003e-03f,
  8.74398798e-02f, -2.60849502e-02f, -5.19209132e-02f, -4.77800258e-02f, 4.57333215e-02f, -1.78363305e-02f, -2.62283329e-02f, 8.18693489e-02f, 1.94273051e-02f, -8.67747515e-02f,
  -4.80839275e-02f, 7.05643976e-03f, 4.44928631e-02f, -1.06749861e-02f, -9.24453698e-03f, 1.15674734e-02f, 3.56609523e-02f, 3.69642442e-03f, 4.47098340e-04f, 5.70077524e-02f,
  1.54428342e-02f, -3.86158675e-02f, 1.52653055e-02f, -2.46980470e-02f, -9.52187032e-02f, 4.78097163e-02f, 3.02734529e-03f, 3.23186442e-02f, -3.37343775e-02f, -5.10178022e-02f,
  -9.25971754e-03f, -4.23215628e-02f, 4.12373506e-02f, 6.75462186e-02f, 3.00560798e-02f, -1.55142788e-02f, -7.60511262e-04f, -7.08751660e-03f, 3.18830088e-02f, 9.45609179e-04f,
  -4.07889485e-03f, -4.08742614e-02f, 3.55066219e-03f, 3.53063419e-02f, -3.90842045e-03f, -7.81303644e-03f, -1.36806276e-02f, -7.43741915e-02f, -9.18026045e-02f, -5.82265556e-02f,
  -2.50287540e-02f, -3.83233242e-02f, -1.63171254e-02f, 2.56822095e-04f, -4.29349206e-02f, -3.90875852e-03f, -4.00379375e-02f, -6.77567571e-02f, -7.60070905e-02f, 7.16021657e-02f,
  1.34850685e-02f, 3.13780969e-03f, -1.08839991e-02f, -2.69964635e-02f, -1.01259060e-01f, -2.44284626e-02f, -3.71760428e-02f, 1.85818467e-02f, -4.19789106e-02f, -1.36433064e-03f,
  -5.50230183e-02f, 1.09101497e-01f, -4.04216349e-02f, -5.15959188e-02f, 1.18832283e-01f, -9.58339032e-03f, -7.28908405e-02f, 7.93283209e-02f, -1.40465358e-02f, 1.10678531e-01f,
  2.02620272e-02f, 9.88073554e-03f, -1.06248654e-01f, -3.06960121e-02f, -1.88578367e-01f, -1.63839072e-01f, 1.36053488e-02f, -4.21481505e-02f, 4.43536378e-02f, -1.92015395e-02f,
  -8.91582370e-02f, 1.12863602e-02f, 3.49086174e-03f, 1.11001432e-01f, 8.44661146e-02f, 7.80866593e-02f, -9.77970883e-02f, 1.87645461e-02f, 7.14414790e-02f, 7.15640038e-02f,
  -7.75361881e-02f, 9.52942576e-03f, -9.73159913e-03f, -2.13582851e-02f, -4.49167425e-03f, 3.18318885e-03f, 7.93444924e-05f, -8.14364254e-02f, 2.07932629e-02f, -5.57875494e-04f,
  -7.64360593e-04f, 1.02246376e-02f, -3.26985903e-02f, -2.01828945e-02f, 1.07087582e-01f, -4.88546211e-03f, 4.74239215e-02f, 9.96035407e-04f, 2.50872113e-02f, 8.24962184e-02f,
  -6.83091879e-02f, -2.30611134e-02f, -7.68192559e-02f, -6.69046417e-02f, 6.68823123e-02f, 2.77519040e-02f, 4.45009694e-02f, -5.15787192e-02f, 2.00833601e-04f, 5.57108447e-02f,
  -1.06013931e-01f, -3.66915092e-02f, 7.09332749e-02f, -3.67449559e-02f, -2.13425010e-02f, 3.74319255e-02f, -4.78320383e-03f, -4.22035828e-02f, 3.11818365e-02f, 3.28650549e-02f,
  -4.09357436e-02f, 4.73805331e-02f, -1.12956185e-02f, -7.11010396e-02f, -1.31891007e-02f, 5.47609664e-02f, -5.94685003e-02f, -2.05130931e-02f, 3.09517793e-02f, -4.03868407e-02f,
  -1.09758005e-02f, -3.16036046e-02f, 4.26915772e-02f, -4.21446078e-02f, -4.24874574e-02f, 2.66216062e-02f, -5.05308993e-02f, 8.84750932e-02f, 6.05882369e-02f, 5.50850574e-03f,
  -1.36355966e-01f, -1.67412251e-01f, 5.72471172e-02f, 1.34897698e-02f, -4.13135849e-02f, 5.83859757e-02f, -1.80359744e-02f, 1.59814227e-02f, -4.65490073e-02f, -2.89043803e-02f,
  -4.22832780e-02f, -5.77581152e-02f, -2.90456265e-02f, 8.81866440e-02f, -2.53463201e-02f, -3.52633521e-02f, -5.02201729e-02f, 2.30422337e-02f, -3.06110177e-02f, -5.51155061e-02f,
  7.43508562e-02f, -5.94611354e-02f, -2.23776177e-02f, 8.64407048e-02f, 2.41965707e-02f, -3.76578011e-02f, -5.43654114e-02f, 1.74690839e-02f, 5.57338893e-02f, 1.61599740e-02f,
  1.62319779e-01f, -1.55460924e-01f, -1.15238726e-01f, -7.81753883e-02f, 1.72063515e-01f, -3.81716043e-01f, -4.46440697e-01f, 6.81355596e-02f, -4.32334952e-02f, -1.91919982e-01f,
  -1.66484088e-01f, -1.03168003e-01f, -2.35779360e-01f, -2.37764329e-01f, -2.64087647e-01f, -2.65871912e-01f, -2.32467145e-01f, -1.84998825e-01f, 6.07435070e-02f, 6.28001383e-03f,
  2.90755518e-02f, -1.04331084e-01f, -1.34588599e-01f, 1.91564500e-01f, -2.00159401e-02f, 1.81993768e-01f, 1.03992507e-01f, 3.73567119e-02f, 7.83129502e-03f, -3.05343568e-02f,
  -1.64325520e-01f, 3.78143485e-03f, 9.09969583e-03f, 2.17123851e-02f, -1.39920209e-02f, 5.30606136e-03f, 4.97998670e-02f, 2.91677862e-02f, 5.91062047e-02f, 3.57410610e-02f,
  -3.47944442e-03f, 1.49277272e-02f, 8.05813633e-03f, -3.96833830e-02f, 4.15982381e-02f, 4.84839492e-02f, 5.38184904e-02f, -2.63193138e-02f, 3.53737809e-02f, -8.70889351e-02f,
  -2.13001352e-02f, -1.56946313e-02f, -4.16036732e-02f, -6.36231825e-02f, 1.17010567e-02f, 2.27667373e-02f, -9.15939361e-02f, -3.52633446e-02f, 1.77128669e-02f, -1.19179608e-02f,
  5.27811609e-02f, -4.14976478e-03f, 3.37756192e-03f, 2.11274736e-02f, -2.40452327e-02f, 5.95203824e-02f, -5.97332120e-02f, -2.63892207e-02f, 7.22155150e-04f, -4.57228124e-02f,
  -1.27474498e-02f, -6.01127520e-02f, 2.01803260e-03f, -1.09419674e-02f, -2.85134446e-02f, 3.82882208e-02f, 3.72720212e-02f, 2.79404018e-02f, -1.83439832e-02f, 6.19524345e-03f,
  2.42541935e-02f, -3.55932638e-02f, -5.61326109e-02f, 6.97342977e-02f, -2.98404917e-02f, 1.64985787e-02f, -2.35615522e-02f, 1.20269191e-02f, 4.34926227e-02f, 2.49656867e-02f,
  -1.07179180e-01f, -4.83217835e-03f, 1.69797502e-02f, -2.53542643e-02f, 2.75819115e-02f, 5.90444431e-02f, -6.36005700e-02f, 1.83042716e-02f, -2.24181190e-02f, 2.85265930e-02f,
  3.38785052e-02f, 4.07615537e-03f, 3.49864140e-02f, 2.14174986e-02f, 9.25810635e-03f, -4.23466228e-02f, -4.47202437e-02f, 6.74804375e-02f, -4.17838991e-03f, 1.07115274e-02f,
  3.72399949e-02f, 3.69043159e-03f, 3.53098065e-02f, -1.07587231e-02f, -2.12562364e-02f, -4.71185558e-02f, 1.81929264e-02f, 1.27340981e-03f, -1.59491673e-02f, -2.37526875e-02f,
  -4.28186841e-02f, -5.75384684e-02f, -6.03747740e-02f, 1.39557555e-01f, 2.35887431e-02f, 3.91384726e-03f, -3.06518693e-02f, 8.29669684e-02f, -3.15903336e-01f, -1.05649136e-01f,
  1.73548043e-01f, -1.42911211e-01f, -7.08951242e-03f, 1.43859506e-01f, 6.20985031e-02f, -1.57871887e-01f, 6.33632168e-02f, 2.89682597e-02f, -1.50060877e-01f, 7.28677064e-02f,
  3.98972705e-02f, 2.24137247e-01f, 1.49040610e-01f, 9.84030515e-02f, 1.08097702e-01f, 6.41552582e-02f, 2.54295737e-01f, 7.75716528e-02f, 2.47143477e-01f, 5.05383387e-02f,
  -1.61885191e-02f, -1.54341117e-01f, -8.44592229e-03f, 1.92517973e-02f, 1.65844560e-02f, 5.56641445e-02f, -1.06769977e-02f, 5.68955839e-02f, -2.35751756e-02f, -3.75836641e-02f,
  -4.27533798e-02f, 2.08751112e-02f, -4.67159748e-02f, 8.82700551e-03f, -6.72988296e-02f, -1.57495737e-02f, 4.40902635e-02f, -6.16723970e-02f, -2.59905532e-02f, -9.34324041e-03f,
  -7.63054267e-02f, -5.98998740e-03f, 2.15390678e-02f, 3.62146180e-03f, 1.36140492e-02f, -3.04466840e-02f, -1.13369897e-02f, -2.01227404e-02f, -9.93763208e-02f, -5.57232499e-02f,
  -2.30799504e-02f, 1.51890321e-02f, 5.69366552e-02f, 4.83636707e-02f, -3.52715664e-02f, 1.12963235e-02f, -2.67034154e-02f, 5.81751950e-02f, -8.34890828e-02f, 2.30836291e-02f,
  3.78737003e-02f, 1.75236706e-02f, 4.81795259e-02f, -3.77535298e-02f, 3.74217667e-02f, 1.93684676e-03f, 3.36824208e-02f, 3.64901461e-02f, -9.16761439e-03f, 6.40048012e-02f,
  -6.85965875e-03f, 4.45404416e-03f, 2.41468903e-02f, 2.19249818e-02f, -1.80422720e-02f, -3.06916162e-02f, 4.15902510e-02f, -5.05038165e-02f, -4.34004003e-03f, 5.02479225e-02f,
  -1.10756345e-02f, 8.16495866e-02f, 3.32771726e-02f, -1.83503423e-02f, -1.88939385e-02f, 1.27976760e-02f, 2.57943254e-02f, -5.59887066e-02f, 2.50008190e-03f, -1.23274336e-02f,
  6.24824241e-02f, 4.32220474e-03f, -7.84124772e-04f, 6.00049943e-02f, 7.24950619e-03f, 8.93008430e-03f, 1.96532980e-02f, 5.59723042e-02f, 7.31401443e-02f, 3.59660350e-02f,
  1.28907159e-01f, 5.99176483e-03f, 1.87121127e-02f, 2.90698893e-02f, 6.60807034e-03f, 1.66225173e-02f, 3.67043950e-02f, -4.60407473e-02f, 5.65080643e-02f, -7.83773605e-03f,
  -2.07357794e-01f, 1.43173099e-01f, 4.40304130e-02f, -1.28582358e-01f, -1.87491417e-01f, -1.66911244e-01f, -2.42988691e-01f, -8.72333273e-02f, -2.68330991e-01f, -2.50692014e-02f,
  2.78013498e-02f, 6.03799820e-02f, 1.19616322e-01f, -7.23099560e-02f, -6.80801198e-02f, -4.57436079e-03f, -1.67249307e-01f, -6.41401112e-02f, -2.02604961e-02f, 1.95893180e-02f,
  -1.24881625e-01f, -7.89591074e-02f, -1.02355247e-02f, 7.91433901e-02f, -2.25253496e-02f, 5.14497682e-02f, 1.69206902e-01f, 1.27607733e-01f, 5.26469573e-02f, -3.70934606e-02f,
  -1.20133102e-01f, 6.44751713e-02f, 2.65053362e-02f, -6.97243363e-02f, -2.89402306e-02f, 5.52685857e-02f, 6.83492571e-02f, 7.30651990e-02f, 1.33677665e-02f, -7.31791044e-03f,
  6.22840077e-02f, -5.01260050e-02f, -6.69299290e-02f, 5.50874285e-02f, -1.71695172e-03f, -5.58340326e-02f, -5.39556555e-02f, -2.10930668e-02f, -7.72871310e-04f, 1.81950666e-02f,
  2.86283400e-02f, -1.57686714e-02f, -3.72135118e-02f, 8.43605101e-02f, 3.74494046e-02f, -4.93991710e-02f, -7.94239435e-03f, 5.85522875e-02f, 3.82838910e-03f, -5.41328229e-02f,
  3.17653194e-02f, 9.56698805e-02f, -1.86528694e-02f, 1.24809602e-02f, 5.72597571e-02f, -4.48015071e-02f, -1.94504391e-02f, 2.99880374e-02f, -3.43123451e-02f, 3.11396755e-02f,
  -8.26434866e-02f, -9.60521773e-03f, 1.41347712e-02f, -7.99718034e-03f, -3.03330424e-04f, -3.75856161e-02f, 5.79093620e-02f, -6.41615391e-02f, -1.32623911e-02f, -3.79306898e-02f,
  -2.54527526e-03f, 2.18225867e-02f, 6.33002296e-02f, 4.58534341e-03f, 1.89620201e-02f, 3.51031460e-02f, 4.61158641e-02f, -9.65423509e-03f, -3.94381164e-03f, -6.06802143e-02f,
  -2.31191553e-02f, 1.03118904e-01f, -1.28511842e-02f, 7.34203532e-02f, 9.67627168e-02f, 1.17053639e-03f, 9.50733200e-03f, -7.45394900e-02f, 2.23572552e-02f, 2.43809144e-03f,
  -8.15323181e-03f, 4.33058571e-03f, 2.03595012e-02f, 1.60704795e-02f, 3.26358452e-02f, 2.08000839e-02f, 4.98572811e-02f, -1.07756527e-02f, -2.05274690e-02f, -1.16388053e-02f,
  4.49320897e-02f, -5.15477173e-02f, 4.62466367e-02f, -5.59481308e-02f, -1.81464273e-02f, 3.76189724e-02f, -2.53702179e-02f, 2.66581904e-02f, 4.95790802e-02f, 5.02588153e-02f,
  3.37193996e-01f, -1.93054721e-01f, 1.43229321e-01f, 6.63192719e-02f, 1.02803729e-01f, 1.97218463e-01f, 2.22821862e-01f, -7.45537058e-02f, -2.25937814e-02f, -1.94824934e-01f,
  6.40616342e-02f, 1.51775539e-01f, 2.75402814e-02f, -1.29162118e-01f, 3.55505824e-01f, -3.99185643e-02f, 4.10192348e-02f, -1.08014531e-02f, -5.07720821e-02f, 1.46154165e-01f,
  -1.27347205e-02f, 2.75377259e-02f, 4.81927395e-03f, -9.25303549e-02f, 5.60156628e-02f, -5.99052897e-03f, 1.34148121e-01f, -1.25422506e-02f, 1.04836458e-02f, 4.68956791e-02f,
  8.90177190e-02f, -8.00009891e-02f, 1.12552837e-01f, 6.96709082e-02f, 2.01406062e-01f, 9.07393619e-02f, 8.61380994e-02f, 2.89415270e-02f, -1.19134188e-02f, 5.91870174e-02f,
  6.79029152e-02f, 9.73445643e-03f, -1.05180060e-02f, -3.24261636e-02f, 1.97936073e-02f, -4.76176329e-02f, -2.26620678e-02f, 5.44295609e-02f, 2.23542154e-02f, -5.00660390e-02f,
  -6.80832490e-02f, 2.39165798e-02f, -6.50403723e-02f, 1.46333501e-03f, 7.85549916e-03f, -6.66413009e-02f, -2.49237567e-03f, 4.57427949e-02f, 8.41842517e-02f, 4.25621532e-02f,
  -2.86982786e-02f, 5.30467294e-02f, -8.37002397e-02f, -5.00382073e-02f, -1.50659848e-02f, 1.55036878e-02f, -2.25913874e-03f, 5.15862834e-03f, -6.84663840e-03f, -6.08765297e-02f,
  3.76515575e-02f, -3.29884812e-02f, -3.45517369e-03f, 1.09199714e-02f, 5.15324343e-03f, -1.72887128e-02f, 7.62665346e-02f, -8.88511352e-03f, -1.08095473e-02f, -6.69290721e-02f,
  -1.50225312e-03f, -2.08886303e-02f, -1.30463336e-02f, 2.39649918e-02f, -2.34537087e-02f, -6.79579517e-03f, 3.38871889e-02f, 1.71150285e-04f, 6.00790419e-02f, 2.29562037e-02f,
  1.62995085e-01f, 1.02117874e-01f, -4.80920412e-02f, -1.54792955e-02f, -4.97617712e-03f, 3.97842266e-02f, -4.04839078e-03f, 2.26155370e-02f, 8.35037604e-03f, 4.88751717e-02f,
  3.08647249e-02f, -1.92696452e-02f, 8.26895162e-02f, 6.83263913e-02f, 1.40096862e-02f, -1.42145595e-02f, 3.43106757e-03f, -1.32499803e-02f, 1.02433495e-01f, 6.33008778e-02f,
  3.83731872e-02f, -1.13558713e-02f, -7.21485866e-03f, -1.86807346e-02f, -2.06353460e-02f, 2.03395579e-02f, 3.72079946e-02f, -4.75479588e-02f, -2.27802880e-02f, 4.97851595e-02f,
  -3.27447623e-01f, -1.85772330e-01f, -2.22165391e-01f, -3.53911035e-02f, 3.98648866e-02f, 1.19306087e-01f, 1.04658559e-01f, -6.22868985e-02f, 1.79664772e-02f, 1.42134070e-01f,
  1.60383463e-01f, -1.25658572e-01f, 2.65027788e-02f, 2.24984899e-01f, 4.69227433e-02f, 5.96697703e-02f, 1.13971710e-01f, -1.80801358e-02f, -2.48936191e-02f, -9.24106911e-02f,
  -7.11281970e-02f, 2.17008948e-01f, 1.03585072e-01f, 2.32566707e-02f, -4.70660590e-02f, -6.38392568e-02f, 6.72185645e-02f, -4.55993898e-02f, 7.74783939e-02f, 4.11890410e-02f,
  -1.46705464e-01f, -2.11453527e-01f, -2.76386943e-02f, -3.35402451e-02f, 1.46614630e-02f, -2.10903026e-02f, -5.47122769e-03f, 2.60729212e-02f, -2.46162713e-02f, -3.27897631e-03f,
  5.16599864e-02f, 1.08471548e-03f, 6.05121776e-02f, 4.11653966e-02f, -3.83484550e-02f, -7.45916413e-03f, -4.17765696e-03f, 3.29587348e-02f, 1.71683468e-02f, -5.84294908e-02f,
  -2.90347785e-02f, 5.03255464e-02f, -1.32144187e-02f, 1.79642886e-02f, 3.47653963e-02f, 1.00367337e-01f, 1.01229854e-01f, 4.31771344e-03f, 1.07896253e-02f, 5.96323237e-02f,
  -7.73389414e-02f, 3.89470086e-02f, -3.56833078e-02f, 6.45698654e-03f, -6.11409433e-02f, 7.26431757e-02f, -4.75374460e-02f, 2.02563498e-02f, 7.74556398e-03f, -8.11264385e-03f,
  3.92473601e-02f, 1.41406143e-02f, -9.31828544e-02f, 6.43177480e-02f, -2.40360387e-02f, 2.16822531e-02f, -4.70125377e-02f, 4.25016657e-02f, 6.91562658e-03f, 3.82062085e-02f,
  -2.74976213e-02f, 4.56123389e-02f, -2.90104691e-02f, 1.02961212e-01f, -2.72274613e-02f, 1.43919084e-02f, -1.56703182e-02f, -3.17068957e-02f, -1.40431132e-02f, -3.20300838e-04f,
  -1.46026105e-01f, -8.50487202e-02f, -2.36171205e-02f, 2.05877479e-02f, -4.37432453e-02f, -2.69806082e-03f, -3.66649330e-02f, 2.00633984e-02f, -1.40917748e-02f, -3.55919562e-02f,
  3.40428995e-03f, -1.20755853e-02f, -1.17879184e-02f, -2.49292254e-02f, -3.47839892e-02f, -2.54119970e-02f, 3.51568200e-02f, 1.05018876e-02f, 7.73184970e-02f, 2.23712549e-02f,
  9.34400633e-02f, -3.65163572e-02f, 6.77914545e-02f, 1.46708163e-02f, -4.65629809e-02f, 4.81143296e-02f, -5.76580018e-02f, -4.21182178e-02f, -4.46938239e-02f, -1.08872484e-02f,
  8.96134153e-02f, -3.46289277e-01f, -5.52614443e-02f, -2.57448554e-01f, 2.41527125e-01f, 7.57418275e-02f, 1.69123620e-01f, -8.22210908e-02f, -9.83863994e-02f, -7.37985745e-02f,
  1.14715762e-01f, -1.78431645e-01f, 8.01175740e-03f, -2.28691593e-01f, 1.81101181e-03f, -2.40532070e-01f, -9.33451205e-02f, -1.12432860e-01f, -1.37488633e-01f, -7.44410902e-02f,
  -7.42613748e-02f, -1.40263271e-02f, -5.18602990e-02f, 6.37829304e-02f, 3.71801332e-02f, -3.78864445e-02f, 2.84806788e-02f, 1.47507101e-01f, -2.70418096e-02f, 3.72400805e-02f,
  1.36977494e-01f, -6.57125488e-02f, 5.74357249e-02f, -9.66049638e-03f, 7.84949511e-02f, 1.55595466e-01f, 6.73625320e-02f, 2.39117024e-03f, -4.91661078e-04f, -3.07319816e-02f,
  4.69198227e-02f, 5.19884797e-03f, -3.09852641e-02f, -4.18149009e-02f, 3.19523849e-02f, 1.94147590e-03f, -3.34242508e-02f, 3.61111723e-02f, -1.10147670e-02f, -1.50009664e-02f,
  1.51906721e-02f, -1.82394392e-03f, 7.97559321e-03f, -2.00391971e-02f, -3.97528484e-02f, 6.22455478e-02f, 1.38378739e-02f, 1.02687649e-01f, -5.97656742e-02f, -2.03954894e-02f,
  -1.98287871e-02f, 5.47853224e-02f, -3.73643115e-02f, 2.87177004e-02f, 5.38213253e-02f, 2.81306580e-02f, -1.50649110e-02f, 2.73997616e-02f, 9.69005749e-03f, -1.13508170e-02f,
  -4.45271246e-02f, -1.70613844e-02f, -7.18394294e-02f, 1.50916474e-02f, 1.04187932e-02f, 5.29793603e-03f, 6.66921865e-03f, -1.87464207e-02f, 3.90243158e-03f, -1.77448262e-02f,
  4.46441695e-02f, -9.97336954e-03f, 3.84239340e-03f, -2.55849492e-02f, 3.31957601e-02f, -3.09882127e-03f, 9.77105089e-03f, 4.51266430e-02f, 5.26543241e-03f, -1.93363037e-02f,
  -1.54077321e-01f, -2.01921701e-01f, -2.00316799e-03f, -4.61402684e-02f, 3.54908807e-05f, 3.66640165e-02f, -2.54081693e-02f, -5.17502464e-02f, -7.87553936e-03f, 7.34368041e-02f,
  1.24340905e-02f, -3.32758501e-02f, 2.53275950e-02f, -1.53938700e-02f, -6.42634928e-02f, 4.33812886e-02f, 4.22637793e-04f, 3.35815698e-02f, -4.39964049e-02f, -1.07693095e-02f,
  2.80761011e-02f, 1.85666364e-02f, 4.81405016e-03f, -4.33763228e-02f, -8.21197871e-03f, 5.18217171e-03f, -7.60166943e-02f, -2.25933045e-02f, -2.69946866e-02f, -9.25241262e-02f,
  4.04014066e-02f, -1.29194716e-02f, -6.39704689e-02f, 3.53621040e-03f, 4.45356825e-03f, -2.33644202e-01f, -1.25602350e-01f, -3.63091752e-02f, -1.00008182e-01f, 6.27642274e-02f,
  8.52566138e-02f, 1.66397557e-01f, 6.34256080e-02f, -1.58273101e-01f, -7.66585991e-02f, -3.99862453e-02f, -1.63747951e-01f, -2.38536205e-03f, -6.28944933e-02f, 1.37875065e-01f,
  -2.10620146e-02f, 2.91671809e-02f, -3.20409313e-02f, -3.77050117e-02f, -1.59429815e-02f, 1.26215965e-01f, 1.81931883e-01f, 6.68561757e-02f, 8.53128284e-02f, -3.96710187e-02f,
  -4.16310541e-02f, 9.12694931e-02f, 5.82196265e-02f, -9.48059751e-05f, -5.74075952e-02f, 2.01331787e-02f, 7.53524005e-02f, -2.71801893e-02f, 1.95283033e-02f, -1.80163253e-02f,
  1.41696380e-02f, 3.10915546e-03f, -4.77725677e-02f, -8.35513324e-03f, -8.45834017e-02f, 5.47004454e-02f, -5.96890189e-02f, -3.52025591e-02f, -8.09612498e-02f, -6.40357882e-02f,
  -1.02066621e-02f, -1.41157431e-03f, -7.46643841e-02f, -8.93497542e-02f, -5.07383011e-02f, -3.00348457e-02f, 4.76700440e-02f, 8.47314596e-02f, 6.64595282e-03f, -5.32784984e-02f,
  6.16449676e-02f, 4.47627157e-02f, -3.59460674e-02f, -3.73642333e-02f, -1.61899906e-02f, 6.98420359e-03f, -3.79786454e-02f, 3.22348624e-02f, 1.18376059e-03f, -7.67910667e-03f,
  -4.95182052e-02f, -3.79918627e-02f, -4.31714319e-02f, 1.05998069e-02f, -3.58567573e-02f, 2.36390368e-03f, 6.92675933e-02f, 5.55129275e-02f, -3.21387835e-02f, 2.77843866e-02f,
  -2.44135130e-02f, 5.25606051e-02f, 1.21854544e-02f, 5.57517111e-02f, -3.05877365e-02f, -1.03082107e-02f, 1.35991555e-02f, 1.23917516e-02f, -3.78993712e-02f, 4.43986431e-02f,
  6.27794676e-03f, 1.07266128e-01f, -6.72317818e-02f, -6.37454540e-02f, -8.23604222e-03f, 4.46442999e-02f, -8.50566849e-02f, -1.33968359e-02f, -3.41124684e-02f, 1.54212462e-02f,
  5.89142181e-02f, -9.48734730e-02f, -1.48262875e-02f, -2.85034627e-02f, -2.00809520e-02f, -1.59385484e-02f, 6.00962527e-02f, 3.61028463e-02f, -2.70743854e-02f, 3.90569493e-02f,
  7.67221898e-02f, 4.26086560e-02f, -1.02051590e-02f, -1.36575764e-02f, 1.09124379e-02f, 6.24519102e-02f, 3.10576404e-03f, 4.16511148e-02f, 2.14247983e-02f, -3.21450783e-03f,
  -3.11251581e-01f, 5.12794614e-01f, -1.92673095e-02f, 4.30769734e-02f, 3.64655070e-02f, -1.27783179e-01f, -5.60798831e-02f, 2.09755689e-01f, 2.11217791e-01f, 3.17189723e-01f,
  1.57958105e-01f, 5.08491471e-02f, 9.30160880e-02f, 1.73967928e-01f, -3.35924774e-01f, 2.75016967e-02f, 1.02199605e-02f, 7.27556348e-02f, -5.17776124e-02f, 7.65039325e-02f,
  -2.15920135e-02f, 4.19808999e-02f, -1.19083889e-01f, 3.37633714e-02f, 8.13868120e-02f, 6.20662197e-02f, -9.67617482e-02f, -6.48363009e-02f, 1.72396488e-02f, 5.08532897e-02f,
  -1.08188689e-02f, 2.10798919e-01f, 6.25534132e-02f, -6.86643422e-02f, -8.10639709e-02f, -2.95264740e-02f, -5.98180182e-02f, -9.45857018e-02f, -1.71949938e-02f, -6.93800207e-03f,
  -2.87936125e-02f, 4.97899298e-03f, 1.15182530e-02f, -1.32577065e-02f, 3.59112285e-02f, 2.83507798e-02f, -1.48337018e-02f, 4.08446454e-02f, 4.81522568e-02f, -1.83139164e-02f,
  7.63595551e-02f, 1.16669489e-02f, 5.90351177e-03f, 3.37908417e-02f, -2.13630814e-02f, 4.13580844e-03f, -1.24562718e-02f, 2.25766487e-02f, 4.18697670e-02f, -1.56076241e-03f,
  2.57679299e-02f, -6.04666211e-02f, -1.22078732e-02f, 5.41481636e-02f, 5.11154979e-02f, 2.76032630e-02f, 1.82236396e-02f, 3.70112844e-02f, -2.04981659e-02f, -2.75664730e-03f,
  -1.26264701e-02f, 6.05599023e-02f, 2.13282295e-02f, 3.54308337e-02f, -1.60711240e-02f, -6.69391314e-03f, -2.39412375e-02f, 6.35401532e-02f, -3.23857032e-02f, -1.11803059e-02f,
  6.17923439e-02f, -1.17495358e-02f, 5.49124032e-02f, -3.97134386e-02f, -3.44302468e-02f, -5.67164607e-02f, 5.54559752e-02f, 6.20222427e-02f, 1.37166819e-02f, -9.08566490e-02f,
  1.04785942e-01f, 9.69878957e-02f, -1.34917600e-02f, 7.48879462e-02f, 8.99224356e-03f, 3.03401742e-02f, -7.60444105e-02f, 6.51170462e-02f, 1.23849520e-02f, 1.04828002e-02f,
  -5.81980459e-02f, 1.05615892e-02f, -4.20946144e-02f, -4.25742827e-02f, -1.38813676e-02f, 2.22034175e-02f, 2.31966767e-02f, 1.24230431e-02f, -2.99892016e-02f, 2.38471869e-02f,
  -3.35048214e-02f, -1.44439936e-03f, -7.38948397e-03f, -7.60385618e-02f, -6.55077100e-02f, -2.99980305e-02f, -1.14902398e-02f, -5.59234358e-02f, -3.91800404e-02f, -2.36620940e-02f,
  -3.63212109e-01f, 9.06337202e-02f, 1.40101343e-01f, -2.73410201e-01f, -1.04555063e-01f, 2.08836719e-01f, 1.09538838e-01f, -1.70520723e-01f, -1.57718152e-01f, 1.22356266e-01f,
  8.68837163e-02f, -6.83484077e-02f, 3.28722030e-01f, -8.19010437e-02f, -3.81846130e-02f, 2.51374573e-01f, -5.45505024e-02f, 2.38159187e-02f, -8.58829767e-02f, -1.03065029e-01f,
  -1.08486250e-01f, -1.17495693e-01f, -2.20709830e-04f, -6.18984699e-02f, -2.08414078e-01f, -2.85829399e-02f, -7.70491287e-02f, 1.73786789e-01f, 6.75909221e-02f, 1.93479508e-02f,
  -1.38873011e-01f, -1.36746526e-01f, -4.17139754e-02f, -4.31870483e-02f, -3.95215005e-02f, -1.48019884e-02f, 9.26048495e-03f, 1.18825056e-01f, 4.61386479e-02f, 1.17605962e-01f,
  7.73771852e-02f, -4.86195385e-02f, -4.12662514e-02f, -3.39752547e-02f, -6.60327747e-02f, 2.23677848e-02f, -9.32227969e-02f, 1.09646451e-02f, -5.30286916e-02f, -5.05136214e-02f,
  7.22934380e-02f, -5.19248694e-02f, 1.71660651e-02f, 4.55377661e-02f, 5.60452007e-02f, -5.61306113e-03f, -2.99177673e-02f, 2.88735386e-02f, -5.87373897e-02f, 1.64134223e-02f,
  -4.71179597e-02f, 9.85008013e-03f, 3.18488106e-02f, -2.01094672e-02f, 9.40807536e-03f, 1.77287422e-02f, -2.58017648e-02f, 3.44985677e-03f, -5.12968637e-02f, -2.99072172e-02f,
  -3.34328078e-02f, -3.83758359e-02f, -2.28069909e-02f, 8.54004398e-02f, 4.17659208e-02f, -5.98344281e-02f, 7.95436725e-02f, -8.15582797e-02f, 3.97550780e-03f, -2.33312044e-02f,
  3.80955003e-02f, -2.64729708e-02f, 9.27356537e-03f, -5.34646446e-04f, 2.92953867e-02f, 9.63862799e-03f, 7.25290272e-03f, -3.77176031e-02f, 4.16237041e-02f, 3.37015130e-02f,
  -7.71965683e-02f, -2.38200068e-01f, 6.96113613e-03f, -4.49219644e-02f, 4.95983921e-02f, 2.38656644e-02f, -3.58237848e-02f, 5.06464206e-02f, 6.48401305e-02f, -4.53393906e-02f,
  4.33577746e-02f, -2.56716069e-02f, -1.09382778e-01f, 9.05752182e-02f, 5.99755682e-02f, -4.02214192e-02f, 4.98585515e-02f, 3.22559662e-02f, -9.16252192e-03f, -9.34312306e-03f,
  -7.84108043e-03f, 4.57458831e-02f, 2.92916447e-02f, -6.87367097e-02f, -7.03108087e-02f, 5.55461757e-02f, -7.71166980e-02f, 7.38994451e-03f, 3.65232415e-02f, -3.11811864e-02f,
  1.17106654e-01f, 3.23115848e-02f, 2.61400551e-01f, 2.49092788e-01f, -4.62056212e-02f, -3.06102782e-01f, -1.65984496e-01f, 6.31084666e-02f, 1.78219378e-01f, -1.98789418e-01f,
  -2.10869871e-02f, 1.34954974e-01f, -4.02607210e-02f, 6.23462163e-03f, -1.33636976e-02f, -9.37660336e-02f, -9.87354890e-02f, -1.29301175e-01f, 6.37812987e-02f, 1.02053896e-01f,
  5.25339209e-02f, -8.13572928e-02f, 1.04071379e-01f, 6.21431805e-02f, 1.09697282e-01f, 1.75715610e-01f, 8.46807435e-02f, 1.21120401e-02f, 7.58360773e-02f, 4.14238796e-02f,
  -1.20930821e-01f, 6.18780740e-02f, 5.56337573e-02f, 1.46077322e-02f, 3.28876376e-02f, 9.38924588e-03f, -1.30302772e-01f, -1.25180902e-02f, 2.53378842e-02f, 3.37129757e-02f,
  -4.60150093e-02f, 3.40186097e-02f, -1.78591739e-02f, 6.93995357e-02f, -7.44276494e-02f, 9.28749293e-02f, -4.33426388e-02f, 1.30623244e-02f, -7.21909665e-03f, 6.01909216e-03f,
  -8.97963438e-03f, -5.03534302e-02f, -2.27263430e-03f, -7.33624175e-02f, 2.91622877e-02f, 2.39440557e-02f, 4.36086617e-02f, -3.99452448e-03f, -9.80806164e-03f, 9.06790197e-02f,
  -1.05089933e-01f, 8.78583174e-03f, 1.32680284e-02f, 5.63952960e-02f, -2.42818799e-02f, 1.03850208e-01f, -2.14537028e-02f, 2.36215796e-02f, -1.32203791e-02f, 6.05706871e-03f,
  2.26639379e-02f, 5.07497508e-03f, -3.05781681e-02f, 3.38343196e-02f, 4.71745990e-02f, -3.02220006e-02f, 3.61724272e-02f, 1.50041580e-02f, 2.45123338e-02f, 1.59476977e-02f,
  2.60564056e-03f, -1.37418387e-02f, 2.54868604e-02f, 4.62025730e-03f, -4.46639545e-02f, -3.36084776e-02f, -3.17964442e-02f, 2.21036673e-02f, -4.39547785e-02f, -4.99956822e-03f,
  -1.66222543e-01f, 5.51250428e-02f, -6.12682616e-03f, 1.40775600e-02f, -7.95382336e-02f, -8.28284770e-02f, 3.24636661e-02f, 5.61703891e-02f, 2.79972646e-02f, -6.51622489e-02f,
  -4.36289869e-02f, -4.69267927e-02f, 4.79510054e-02f, -7.67895281e-02f, 3.45890298e-02f, -1.05323019e-02f, -4.66095693e-02f, 2.80252919e-02f, 5.52595183e-02f, 3.86632979e-02f,
  7.06652179e-02f, -1.02941245e-02f, 4.21701744e-02f, 6.40142038e-02f, -1.28586162e-02f, 1.07952086e-02f, 4.38080505e-02f, 4.35706740e-03f, 2.68781800e-02f, -1.52577478e-02f,
  -2.52028435e-01f, 2.87305862e-02f, 9.35163815e-03f, 2.92938389e-02f, -5.06903045e-02f, -5.02039082e-02f, -2.23421324e-02f, -1.71275605e-02f, -9.78668854e-02f, 1.41393647e-01f,
  1.96559690e-02f, -9.00301486e-02f, 2.27702986e-02f, 1.20721132e-01f, -1.22188916e-02f, 6.71329424e-02f, 1.70473039e-01f, 1.15061358e-01f, 5.20135649e-03f, 9.10003260e-02f,
  -1.18327439e-02f, 9.60548669e-02f, 4.00585644e-02f, 7.48514235e-02f, 6.24409467e-02f, 8.05784836e-02f, 2.56427556e-01f, 5.32263927e-02f, 1.49772406e-01f, 4.90422361e-03f,
  -1.13831878e-01f, -1.24392144e-01f, -2.29014661e-02f, -9.91289020e-02f, 5.23715932e-03f, 2.99272295e-02f, -1.82177080e-03f, -5.96930981e-02f, 3.94296087e-03f, -4.67129834e-02f,
  -5.00280149e-02f, -4.41019163e-02f, -1.27299754e-02f, -3.47512364e-02f, -1.10745609e-01f, 1.59923011e-03f, -3.40400152e-02f, 5.31935543e-02f, 2.72469632e-02f, -6.55429363e-02f,
  4.64919722e-03f, -1.64864380e-02f, 9.57917050e-02f, 6.03900589e-02f, 2.41849534e-02f, 5.90302423e-02f, 3.59577946e-02f, 3.73164974e-02f, -3.60417105e-02f, 3.06229573e-02f,
  -9.68988240e-02f, 3.16912159e-02f, -1.09706791e-02f, -4.91170771e-02f, 1.70675945e-02f, -1.56067277e-03f, 3.79255041e-02f, -2.02056263e-02f, -2.39403732e-02f, 5.23720868e-02f,
  -5.15023172e-02f, 4.69679274e-02f, -5.17644957e-02f, -4.39556912e-02f, 6.39405176e-02f, -1.72848497e-02f, 5.94800599e-02f, 1.35490624e-02f, -4.01989557e-02f, 6.23314008e-02f,
  4.09960300e-02f, 1.02385823e-02f, 5.53425355e-03f, 1.61044523e-02f, -2.51335069e-03f, -6.64747320e-03f, -3.05273570e-02f, 2.85582226e-02f, 6.38353899e-02f, -1.62424799e-02f,
  4.99444976e-02f, 1.80801854e-01f, 6.43886533e-03f, 1.23621942e-03f, 9.80656818e-02f, -3.93882804e-02f, 3.96354795e-02f, -3.92717086e-02f, 8.56975019e-02f, 2.69679222e-02f,
  2.76700202e-02f, 4.96404059e-02f, 7.10148439e-02f, 2.64474154e-02f, 6.94896132e-02f, -3.76398563e-02f, 7.08020777e-02f, 3.60811036e-03f, 4.61908430e-02f, 9.14139450e-02f,
  3.51089239e-02f, 2.73825042e-02f, -4.96586673e-02f, 1.17776766e-02f, 7.44495243e-02f, 1.76014006e-02f, 2.08625365e-02f, -6.33614734e-02f, 5.84970415e-02f, -3.13200951e-02f,
  3.47110331e-01f, 2.37351134e-01f, 1.89085260e-01f, 2.15415046e-01f, 1.33444399e-01f, -1.70350764e-02f, 1.25876218e-01f, 4.21131626e-02f, 7.86589235e-02f, -7.00256824e-02f,
  4.80975620e-02f, 1.63761854e-01f, -5.41015677e-02f, 1.18873380e-01f, -3.61375138e-02f, -1.67204037e-01f, 1.12772048e-01f, 7.06570270e-03f, -6.02989085e-02f, 2.30493277e-01f,
  7.81261548e-02f, -6.58154041e-02f, 6.70142751e-03f, -6.80678114e-02f, 4.32047807e-02f, 8.52259621e-02f, -8.56308192e-02f, 1.54450843e-02f, 2.26177666e-02f, -9.54014510e-02f,
  1.25303209e-01f, 1.20171718e-01f, 5.35909086e-02f, -1.00916391e-02f, -1.63905807e-02f, 9.38261226e-02f, 4.74423841e-02f, -2.29473766e-02f, 6.21115193e-02f, -5.19661524e-04f,
  2.15905532e-02f, -8.07912946e-02f, 3.36932903e-03f, -1.84642430e-02f, 6.93026707e-02f, 1.34614781e-02f, 2.76758894e-02f, 5.98435439e-02f, -1.13379932e-03f, -7.56243169e-02f,
  5.11356145e-02f, -4.45791967e-02f, 2.49036103e-02f, 9.93469916e-03f, 4.10494097e-02f, 6.21247385e-03f, -3.43380421e-02f, 2.34219171e-02f, -5.38189430e-03f, -1.95022728e-02f,
  -3.34154144e-02f, 6.25183582e-02f, 3.52302641e-02f, -3.60979885e-02f, -5.36729535e-03f, -4.89627905e-02f, 2.10751016e-02f, -1.93505604e-02f, 2.09332313e-02f, 1.49395382e-02f,
  8.32711458e-02f, 4.57172953e-02f, -1.43944519e-02f, -4.40498590e-02f, 3.06789875e-02f, 1.48766078e-02f, 6.68594800e-03f, -7.88027570e-02f, 4.35228907e-02f, -2.43375544e-02f,
  -6.58755424e-03f, 2.26152688e-02f, -2.07275543e-02f, 4.12823297e-02f, 1.48551837e-02f, 1.56800216e-03f, -3.82415541e-02f, 3.34526747e-02f, 4.52471711e-02f, 3.23659070e-02f,
  1.33141726e-01f, 1.20142505e-01f, -5.98989753e-03f, -3.74747030e-02f, 2.45678928e-02f, -4.89411801e-02f, 4.55621406e-02f, -1.88868716e-02f, -3.37141640e-02f, -6.33942429e-03f,
  1.95235526e-03f, 6.71973005e-02f, 2.71827215e-03f, 8.00583791e-03f, -6.39974624e-02f, -2.68286001e-02f, -2.30148248e-02f, 3.52770137e-03f, 8.08811933e-03f, 4.93208691e-02f,
  -8.82616453e-03f, -6.33900911e-02f, 2.74649356e-02f, -1.96869802e-02f, -6.16140291e-02f, 6.33764965e-03f, -2.32360400e-02f, 4.38106470e-02f, -7.21995682e-02f, 1.94007624e-02f,
  1.68761685e-01f, -2.23935083e-01f, 1.62510321e-01f, -9.26049799e-02f, 1.73872471e-01f, -1.00792110e-01f, 6.36423677e-02f, -4.68886234e-02f, 1.32049799e-01f, -1.08444147e-01f,
  -8.18587393e-02f, 6.37466386e-02f, -2.49504466e-02f, -3.07487369e-01f, 7.12850988e-02f, -3.31988884e-03f, -2.55662084e-01f, -5.54626547e-02f, 3.66901010e-02f, -5.94748184e-02f,
  -7.66000971e-02f, -1.92014307e-01f, -3.57141793e-02f, -1.78876519e-01f, -4.72931080e-02f, 3.50981019e-02f, -1.30599871e-01f, 1.12894282e-01f, -1.20993443e-01f, -4.45252210e-02f,
  3.41335684e-02f, 1.39333621e-01f, 3.39240357e-02f, 1.48672378e-02f, -3.59805487e-02f, -3.72901373e-02f, -6.41731992e-02f, 7.00510815e-02f, 1.64451059e-02f, -2.16870978e-02f,
  5.58133982e-02f, 3.59718613e-02f, -3.28253135e-02f, 1.96934063e-02f, 8.04515556e-03f, 4.11518663e-03f, 3.22130397e-02f, 4.28553410e-02f, 5.94799547e-03f, 3.43011208e-02f,
  5.94064258e-02f, 1.02040381e-03f, -8.37191287e-03f, 1.73695665e-02f, 9.31707304e-03f, 1.99298449e-02f, 3.37022380e-03f, 4.43067923e-02f, -2.97197569e-02f, -4.48550796e-03f,
  -4.82583269e-02f, -1.53379319e-02f, -2.76781544e-02f, -6.61560744e-02f, 5.39624803e-02f, -2.94504911e-02f, -2.92325206e-02f, -3.52397487e-02f, 3.84221785e-02f, 1.79218373e-03f,
  1.35826296e-03f, -2.14105239e-03f, 2.22889073e-02f, -8.03182051e-02f, -3.40194767e-03f, -3.83710600e-02f, -2.64565684e-02f, -2.90353876e-02f, 1.90780479e-02f, -2.34249290e-02f,
  2.81743128e-02f, -5.29363677e-02f, -4.17112466e-03f, -5.01858369e-02f, 1.16490591e-02f, 5.59624061e-02f, -8.39855224e-02f, -5.33897839e-02f, 4.49815802e-02f, 1.67604275e-02f,
  -1.59745991e-01f, -2.26614296e-01f, -6.07736700e-04f, 2.05824543e-02f, 4.27614041e-02f, -4.51627970e-02f, 4.02023159e-02f, -1.01607829e-01f, -6.11827374e-02f, -8.97536427e-03f,
  -4.96657863e-02f, -3.53709310e-02f, 1.23477047e-02f, -6.33113133e-03f, 4.91054682e-03f, -5.48400469e-02f, -1.17211100e-02f, -6.61489218e-02f, -3.37475538e-02f, -2.59274337e-02f,
  -6.08246513e-02f, 4.45796363e-02f, -1.37934173e-02f, 3.58569622e-02f, -9.47092101e-02f, 5.19509381e-03f, 3.41915600e-02f, 2.39672828e-02f, -1.35061322e-02f, -1.91387497e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.63840514e-02f, -8.25125650e-02f, 3.50146368e-02f, 4.12331559e-02f, -2.79585477e-02f, -1.55223086e-01f, -1.89274326e-01f, 7.80536383e-02f, 1.41265914e-01f, -2.73842029e-02f,
  1.98828168e-02f, 6.33426681e-02f, -2.84619555e-02f, -4.69726846e-02f, -6.20036311e-02f, 1.04721300e-01f, -8.75145048e-02f, 1.44651365e-02f, 4.26223241e-02f, -8.02242607e-02f,
  4.35686596e-02f, -4.64679152e-02f, 5.89639973e-03f, 7.85454810e-02f, -7.86859766e-02f, -3.44182290e-02f, -1.47945564e-02f, -9.92383901e-03f, -4.54178005e-02f, -9.87140983e-02f,
  1.75336492e-03f, -2.46768165e-02f, -7.20929205e-02f, 1.88593175e-02f, 1.59800909e-02f, 2.70627756e-02f, -1.01753332e-01f, -3.39002125e-02f, -1.02432117e-01f, 1.40413260e-02f,
  -5.39014935e-02f, -5.19301519e-02f, 1.76637284e-02f, 7.70262405e-02f, -1.61222406e-02f, 3.99293303e-02f, -2.85713486e-02f, 6.99465573e-02f, -4.40414995e-02f, 9.67403278e-02f,
  -3.07507049e-02f, -1.55122485e-03f, 2.55694073e-02f, 7.36467093e-02f, -8.92720465e-03f, -6.32442608e-02f, -4.76067252e-02f, 4.85514440e-02f, -9.62172747e-02f, -3.41023877e-02f,
  5.82726970e-02f, 6.70329854e-02f, 6.21631183e-02f, -1.17708137e-02f, -7.45979846e-02f, 6.48443103e-02f, -1.02673820e-03f, -4.25509550e-03f, 4.59589101e-02f, 1.65954437e-02f,
  -3.06405351e-02f, 5.47820218e-02f, 7.51160532e-02f, -1.99225508e-02f, -3.12472247e-02f, 3.41908708e-02f, -3.48076671e-02f, -7.22277956e-03f, 8.39970633e-02f, 6.35892991e-03f,
  5.10195866e-02f, 4.02083099e-02f, -4.80220243e-02f, 4.66861501e-02f, -1.09705560e-01f, -4.32813764e-02f, 7.67319947e-02f, -5.08845784e-02f, 3.29091772e-02f, 2.72219032e-02f,
  -1.20064758e-01f, -2.39460785e-02f, -6.18466809e-02f, 4.59909365e-02f, -1.25376761e-01f, -6.88846856e-02f, 3.16385675e-04f, -5.56009933e-02f, 4.89390232e-02f, -6.34068903e-03f,
  6.21221252e-02f, 1.73531435e-02f, 3.40415575e-02f, -4.78060693e-02f, -3.27222124e-02f, -6.02879710e-02f, -7.19163194e-02f, -4.60529365e-02f, -5.32762483e-02f, 6.02083541e-02f,
  1.80942584e-02f, 4.35827393e-03f, -9.24609378e-02f, -4.95050214e-02f, 5.50707839e-02f, -3.40977460e-02f, 8.33442956e-02f, 2.69488227e-02f, 5.77159189e-02f, 2.42304131e-02f,
  -7.71294988e-04f, -9.22833756e-02f, 4.11873832e-02f, 2.07147151e-01f, -9.46815312e-02f, -7.06524774e-02f, -6.35424852e-02f, 3.74843739e-02f, -7.98695534e-02f, -1.62983000e-01f,
  -2.70380005e-02f, -1.65170822e-02f, -1.83870241e-01f, 1.81685716e-01f, 2.37265930e-01f, -6.33385628e-02f, 1.54159918e-01f, -3.00740935e-02f, 4.36723828e-02f, -2.59645786e-02f,
  2.26698577e-01f, 1.55685619e-01f, 2.97059357e-01f, 1.90736547e-01f, 9.21702981e-02f, 1.73906326e-01f, 4.95063365e-02f, -3.37311998e-02f, 2.07610726e-01f, 9.40239895e-03f,
  -9.50851217e-02f, -5.83692603e-02f, 4.59958939e-03f, -8.13665017e-02f, -5.73399290e-02f, -1.30474523e-01f, 4.63909917e-02f, -1.94551665e-02f, -3.08482572e-02f, -4.29158211e-02f,
  -5.18903099e-02f, -6.24462739e-02f, 4.18832004e-02f, -5.03035821e-02f, -4.78706844e-02f, 7.07092434e-02f, 4.53775516e-03f, 4.44519930e-02f, -5.18323258e-02f, -4.36756648e-02f,
  -2.53347997e-02f, -8.13234970e-03f, 6.82351142e-02f, 9.19367839e-03f, 6.54253438e-02f, -1.39085986e-02f, -5.42932612e-05f, 5.44721410e-02f, -9.33481306e-02f, 3.86133157e-02f,
  2.24319808e-02f, -3.71381678e-02f, -1.02401309e-01f, -1.58159435e-02f, 4.74125557e-02f, -5.49643487e-02f, 7.58652017e-02f, -5.43128178e-02f, 6.26655519e-02f, -2.06882227e-02f,
  3.82591435e-03f, 4.35154997e-02f, 6.70882910e-02f, -2.97009628e-02f, 6.01221696e-02f, 5.46454154e-02f, -3.57664041e-02f, -7.07062706e-02f, -6.26871213e-02f, 6.27971813e-02f,
  7.87407253e-03f, 5.39077222e-02f, -4.23768535e-02f, 2.37837397e-02f, -2.26297453e-02f, -1.48393144e-03f, -2.96746530e-02f, -3.42959948e-02f, 2.61137430e-02f, 3.85465883e-02f,
  -6.37379941e-03f, 2.91839074e-02f, -1.66187678e-02f, 4.73133549e-02f, -1.78503282e-02f, 9.89742205e-03f, 6.35398701e-02f, -3.20149623e-02f, -7.98675418e-03f, -1.00188632e-03f,
  -9.14935395e-02f, 7.20702112e-03f, -6.80749565e-02f, -3.31428312e-02f, 2.12277323e-02f, -7.74323344e-02f, -1.99057609e-02f, -3.16178016e-02f, -2.20622513e-02f, 1.49331149e-02f,
  -3.11739948e-02f, 2.81947944e-02f, -3.74070778e-02f, -1.61398239e-02f, 1.47452364e-02f, 6.66267574e-02f, -6.68024197e-02f, -1.75567751e-03f, -3.76928747e-02f, 3.32747810e-02f,
  -1.22829854e-01f, 1.03840150e-01f, 7.43077546e-02f, -1.03148915e-01f, 6.74245283e-02f, 9.80946980e-03f, 1.16396971e-01f, 1.22434013e-01f, 2.04024510e-03f, -5.66619635e-02f,
  -1.38242513e-01f, 1.18682764e-01f, 1.12248294e-01f, -3.85705978e-02f, -5.79149425e-02f, -7.83081278e-02f, 2.62462478e-02f, 3.61053869e-02f, 8.44909772e-02f, 4.73851189e-02f,
  -7.58733675e-02f, 5.53918257e-02f, -1.21361740e-01f, -4.72096018e-02f, -7.15270415e-02f, -2.83400938e-02f, -6.25179633e-02f, 1.09870523e-01f, -1.61017366e-02f, -6.63616601e-03f,
  -9.15441290e-02f, -7.71971494e-02f, -1.17625773e-01f, -8.50268826e-02f, -4.62935455e-02f, -2.60966346e-02f, -1.77485589e-02f, -1.95400100e-02f, -8.77811983e-02f, -5.50509021e-02f,
  6.09679297e-02f, 6.50413036e-02f, -6.11937344e-02f, 4.53324430e-03f, 6.36650696e-02f, 3.95691805e-02f, -6.41012331e-03f, -3.72789204e-02f, -6.68467302e-03f, 1.04303891e-02f,
  -5.32880565e-03f, 3.71581204e-02f, 3.60894087e-03f, -3.64283938e-03f, -5.88083789e-02f, -6.03234731e-02f, -1.55829284e-02f, -8.31892192e-02f, 3.41809429e-02f, 4.41838056e-02f,
  -8.68641865e-03f, -2.19222829e-02f, 5.34913726e-02f, 6.36737421e-02f, 5.48609942e-02f, 4.74522300e-02f, -5.45571409e-02f, -5.26885614e-02f, -5.85895553e-02f, -7.65041448e-03f,
  -1.73395090e-02f, 7.94508215e-03f, -7.81769902e-02f, 6.29217103e-02f, 2.73236968e-02f, 1.75301172e-02f, -1.01250783e-02f, 4.17789407e-02f, -6.95249885e-02f, 7.28076696e-02f,
  -1.56437457e-02f, -4.07414436e-02f, -8.42574760e-02f, -9.42869484e-02f, -7.87460282e-02f, 4.12768126e-02f, -5.32978065e-02f, -4.31416780e-02f, -6.39366657e-02f, 4.39661592e-02f,
  -5.47702834e-02f, -7.22551718e-02f, 7.44617432e-02f, -4.52822559e-02f, -1.38682434e-02f, 2.22332124e-02f, -4.30642068e-03f, -1.63706113e-02f, -6.25578910e-02f, 7.12306648e-02f,
  -1.04787080e-02f, -1.03793763e-01f, 1.10525907e-04f, -4.19396609e-02f, 8.53939261e-03f, -4.34089117e-02f, 8.09860900e-02f, 9.00587589e-02f, -5.96568957e-02f, -8.35821256e-02f,
  6.66982383e-02f, 7.88405091e-02f, -2.91104075e-02f, -4.52005081e-02f, -6.89736828e-02f, -8.37357715e-02f, 2.62850001e-02f, 1.08930022e-02f, -3.94906215e-02f, -2.79288348e-02f,
  1.19904883e-01f, -7.61931092e-02f, -1.03900954e-01f, 2.03373004e-02f, 6.03645109e-02f, -6.96235970e-02f, -3.34668159e-02f, -8.59384388e-02f, 3.41145843e-02f, 5.36863469e-02f,
  -8.46203566e-02f, -3.25082280e-02f, 7.42172375e-02f, -1.03149332e-01f, -1.60737485e-02f, -7.95711204e-02f, -1.37429401e-01f, -2.70109624e-03f, -8.80617127e-02f, 3.97595055e-02f,
  -2.86970716e-02f, -2.90770754e-02f, -8.28854740e-02f, -1.63038671e-02f, 2.15963367e-02f, -2.31702588e-02f, 4.67653684e-02f, -4.55644242e-02f, -1.35075703e-01f, -6.43616095e-02f,
  -8.62507969e-02f, 3.29865143e-02f, -6.23147078e-02f, 3.19728032e-02f, 2.50746794e-02f, -2.58092545e-02f, -7.76717588e-02f, 5.35232686e-02f, -6.33093044e-02f, -3.93797569e-02f,
  6.97057769e-02f, -5.05148806e-02f, 1.78888962e-02f, -3.29850451e-03f, 5.48134446e-02f, 4.54395749e-02f, 7.13208094e-02f, 1.90001875e-02f, -1.88427866e-02f, -2.41672397e-02f,
  1.24915326e-02f, 6.22542612e-02f, 9.14978385e-02f, 7.18347356e-02f, 3.02691013e-02f, 4.98555154e-02f, 5.09577692e-02f, -5.67741180e-03f, 9.01510268e-02f, 7.97069669e-02f,
  -7.39037804e-03f, 7.41940411e-03f, 3.98587137e-02f, 1.11579057e-02f, -4.22105007e-03f, -1.00110017e-01f, 5.29950894e-02f, -5.19835390e-02f, 3.29191163e-02f, -4.91190292e-02f,
  5.79840504e-02f, -3.79103944e-02f, 5.80803193e-02f, -1.77248660e-02f, 3.68497670e-02f, 1.74930003e-02f, 1.88793801e-02f, -4.42009605e-02f, 3.96079347e-02f, 2.45760288e-02f,
  -4.42025764e-03f, 6.71467856e-02f, -6.90606982e-02f, -7.10031241e-02f, 4.60822619e-02f, -7.52075464e-02f, 1.51231484e-02f, -8.35518315e-02f, -5.72661906e-02f, 6.83227479e-02f,
  6.49141297e-02f, -2.88548768e-02f, 3.33777554e-02f, -2.34691408e-02f, -7.10163787e-02f, 9.71735269e-02f, 7.81986564e-02f, 7.95324892e-03f, 7.14064166e-02f, 3.40341292e-02f,
  3.18734013e-02f, 6.21931925e-02f, -2.87982617e-02f, 8.53471309e-02f, 3.81764700e-03f, -4.84168008e-02f, 1.85591672e-02f, 6.41771704e-02f, 3.92583236e-02f, 9.48196054e-02f,
  -3.45173143e-02f, 2.61802301e-02f, 1.12876467e-01f, 3.37183103e-02f, -7.37502724e-02f, 2.81319697e-03f, -6.64416468e-03f, -4.96790484e-02f, -4.24820445e-02f, 9.09469929e-03f,
  -2.22134199e-02f, 2.41574943e-01f, 1.47652850e-01f, -6.58331290e-02f, 6.75391704e-02f, -1.16268463e-01f, -6.41118316e-03f, -2.75363866e-02f, 1.83881389e-03f, 2.60388613e-01f,
  -3.01345997e-02f, 1.02491483e-01f, -7.71681964e-03f, 4.00971770e-02f, -4.47069794e-01f, -1.46850154e-01f, -5.10165133e-02f, 4.14035134e-02f, -4.13061008e-02f, 6.17885962e-02f,
  -1.64207712e-01f, -7.04152361e-02f, -1.22419551e-01f, -6.29476160e-02f, 1.22546218e-02f, 1.37678087e-01f, 3.05282902e-02f, -3.23723927e-02f, 6.06955960e-02f, -4.73447107e-02f,
  4.49432544e-02f, 5.24778618e-04f, 1.30792499e-01f, -1.00669861e-02f, 3.62292826e-02f, 2.66722869e-02f, 9.12933573e-02f, -6.95521459e-02f, -5.30415513e-02f, 2.99924742e-02f,
  3.77888493e-02f, -2.52544824e-02f, 2.36499533e-02f, -2.66911499e-02f, 2.66425647e-02f, 8.24949890e-02f, 3.80755849e-02f, 7.11865574e-02f, 1.05277523e-01f, 4.51786593e-02f,
  -1.88249722e-02f, 7.29886144e-02f, 1.54821267e-02f, 6.86507672e-02f, 7.89374299e-03f, 6.75004572e-02f, -1.26971006e-02f, -5.64412475e-02f, -5.86181879e-04f, -4.14407030e-02f,
  5.01316860e-02f, -3.83208739e-03f, -3.85770462e-02f, 4.03821655e-02f, -5.59254102e-02f, 8.17239210e-02f, -7.77001828e-02f, -6.46070614e-02f, -2.31226608e-02f, 4.91729043e-02f,
  2.66158264e-02f, 3.08840498e-02f, 4.03639637e-02f, -7.77486339e-02f, -3.85381877e-02f, 9.77807567e-02f, -4.20264713e-02f, -2.25385465e-02f, 4.92927320e-02f, -7.22865388e-02f,
  -4.90899682e-02f, -4.12344746e-02f, 1.09425257e-03f, 5.61020188e-02f, -1.15259495e-02f, -2.26352066e-02f, -8.76566693e-02f, 4.19181883e-02f, -3.37319635e-02f, 5.54945879e-02f,
  2.51361784e-02f, -1.13694049e-01f, 1.13169141e-02f, 1.20838108e-02f, -3.79867889e-02f, 3.14759761e-02f, -4.24259789e-02f, 6.15041517e-02f, -7.86994174e-02f, -1.07908137e-01f,
  9.36154649e-02f, 4.94861417e-02f, 3.77490185e-02f, -3.56217697e-02f, -8.21481645e-02f, -1.76861323e-02f, 4.68484499e-02f, -2.83515882e-02f, 1.50205474e-02f, -2.94956472e-03f,
  5.48995398e-02f, 6.55172020e-02f, 5.27077019e-02f, 2.41201334e-02f, 2.76434682e-02f, 6.22860789e-02f, -3.07465196e-02f, -4.08733338e-02f, -1.08795594e-02f, -1.83491930e-02f,
  -1.12960331e-01f, 1.48988441e-01f, 1.24351837e-01f, 3.75888012e-02f, -8.37137699e-02f, 1.02800071e-01f, -1.07291818e-01f, 1.37113765e-01f, 2.95566693e-02f, -3.81758437e-02f,
  -9.79543626e-02f, -5.26919775e-02f, 3.14802639e-02f, -3.39380242e-02f, -3.74447592e-02f, 1.24022797e-01f, 1.23035781e-01f, 7.38595650e-02f, 7.66447037e-02f, -5.57963662e-02f,
  6.07165555e-03f, -6.65908232e-02f, 3.85525338e-02f, -1.64981335e-02f, -1.60410389e-01f, -6.18698820e-02f, -1.83418110e-01f, -2.92219967e-03f, 4.38144393e-02f, -1.17237024e-01f,
  -7.53916949e-02f, -1.03717446e-01f, 8.24914053e-02f, 1.36991858e-01f, 1.61359608e-02f, -3.18337604e-02f, -5.42910136e-02f, -5.86979203e-02f, -6.24843501e-02f, 5.22863157e-02f,
  2.00177003e-02f, 2.38331985e-02f, -4.58982363e-02f, -2.86647771e-02f, 9.89899598e-03f, 1.76989809e-02f, 2.87263300e-02f, -3.22602876e-02f, 7.96212927e-02f, 1.18798345e-01f,
  1.20560331e-02f, 6.26327395e-02f, -4.67372760e-02f, 9.20473635e-02f, 6.49259686e-02f, -5.82453702e-03f, 6.94236904e-02f, -2.37475671e-02f, 2.65913531e-02f, -3.85172740e-02f,
  1.86528228e-02f, 9.93918478e-02f, -8.65592062e-02f, -1.58380120e-04f, -7.38752112e-02f, -9.16220769e-02f, 1.67018641e-02f, -2.63385344e-02f, -8.08559880e-02f, -5.05424030e-02f,
  1.09357955e-02f, 2.29228642e-02f, -7.19348192e-02f, 6.48860112e-02f, -4.54097204e-02f, 4.45702001e-02f, 5.50583899e-02f, -5.19048199e-02f, -7.58403763e-02f, -5.39562739e-02f,
  -3.04768365e-02f, -8.24288055e-02f, 6.59835758e-03f, -1.94787364e-02f, -2.18770299e-02f, 5.28345034e-02f, 9.71217752e-02f, 4.00154293e-02f, 3.63861807e-02f, -3.14967074e-02f,
  -7.92270228e-02f, 2.76471246e-02f, -1.08207797e-03f, 7.97502603e-03f, 4.89080697e-02f, 9.12552774e-02f, 1.23876654e-01f, -3.53500135e-02f, -3.16251302e-03f, 2.03972254e-02f,
  -1.14872437e-02f, -4.74552996e-02f, -1.65538099e-02f, 2.75611412e-02f, 6.03113249e-02f, -7.58111700e-02f, 2.35328227e-02f, 1.05153024e-01f, -4.83249277e-02f, 8.11613798e-02f,
  -5.45548461e-02f, 2.33430453e-02f, -7.13406652e-02f, 1.51940975e-02f, -3.99633758e-02f, -2.04048157e-02f, -1.24757485e-02f, 3.28509770e-02f, -6.94541410e-02f, 8.55133906e-02f,
  6.31333655e-03f, -5.11950180e-02f, -5.60407750e-02f, 2.32180897e-02f, 4.52211089e-02f, -4.90644313e-02f, -9.67468172e-02f, 5.81049211e-02f, 5.74957021e-02f, -1.24505945e-02f,
  1.14117734e-01f, -6.91250861e-02f, 1.27533441e-02f, -2.12382421e-01f, -2.07361266e-01f, -6.42453954e-02f, -2.94246115e-02f, -9.40458849e-02f, -3.22888196e-02f, 3.80004197e-02f,
  -7.67781213e-03f, -9.55169648e-02f, -2.01596543e-01f, -4.37002145e-02f, -5.22193760e-02f, 6.77251862e-03f, 7.93168023e-02f, 2.97999028e-02f, -5.91293238e-02f, -1.35918155e-01f,
  -2.95391139e-02f, 2.68498715e-02f, -2.46793963e-02f, -1.15949631e-01f, 6.78245500e-02f, -4.86619249e-02f, -4.38786745e-02f, 1.32256122e-02f, -6.80854619e-02f, -2.58665252e-02f,
  -6.76848441e-02f, -4.91837645e-03f, 7.37834871e-02f, 2.54131816e-02f, 4.43360247e-02f, -2.52225921e-02f, -2.48962231e-02f, -4.47247364e-03f, -2.78171748e-02f, 2.12945212e-02f,
  4.77695204e-02f, -1.54684456e-02f, -2.34077796e-02f, 4.70062792e-02f, -2.41137370e-02f, 8.49770457e-02f, -5.96708767e-02f, 2.71648522e-02f, -7.61118680e-02f, -6.05454743e-02f,
  2.90184515e-03f, -1.83225702e-02f, -9.33248848e-02f, 1.15443561e-02f, -7.71867111e-02f, 2.08523758e-02f, -3.42746638e-02f, -6.03404641e-02f, -2.58455966e-02f, -3.91541831e-02f,
  1.20119508e-02f, -8.11237916e-02f, -4.61786278e-02f, 4.88239713e-03f, 5.43144271e-02f, -3.83636691e-02f, 6.90613464e-02f, -2.67833974e-02f, 6.33944646e-02f, 4.56476621e-02f,
  -6.57468215e-02f, -1.62614025e-02f, 5.03761619e-02f, -4.95279673e-03f, 5.78998066e-02f, 3.13748568e-02f, 6.22624308e-02f, 3.53606828e-02f, 7.76412338e-02f, -9.54379812e-02f,
  4.84170392e-02f, -7.32448101e-02f, -5.90052381e-02f, -6.78463951e-02f, -5.26679233e-02f, 1.67958904e-02f, -4.33241837e-02f, -7.48839974e-02f, -5.61634526e-02f, -2.68698484e-03f,
  9.37164053e-02f, 5.00979535e-02f, -1.58947036e-02f, 6.11046292e-02f, -2.40782369e-02f, -3.00111286e-02f, 7.14880079e-02f, -7.74297789e-02f, -7.06738979e-02f, 3.31564508e-02f,
  -2.38834135e-02f, 2.13935375e-02f, -3.29069123e-02f, -9.34639387e-03f, -2.67356392e-02f, 2.80297897e-03f, 5.74494973e-02f, -2.12270804e-02f, -2.44640615e-02f, 6.96051419e-02f,
  -1.84772849e-01f, -2.85025705e-02f, 8.80297273e-02f, 1.11540891e-02f, 6.75214902e-02f, 9.77160260e-02f, 1.07008152e-01f, 7.81592131e-02f, -9.68886763e-02f, -9.72298011e-02f,
  -9.42989215e-02f, -1.52901202e-01f, -1.11786924e-01f, -3.17520574e-02f, 6.03960976e-02f, -6.85702264e-02f, 3.20260711e-02f, 3.25178611e-03f, 6.90488890e-02f, -1.98298618e-02f,
  8.22705850e-02f, -6.37830198e-02f, 1.27705008e-01f, 8.50844458e-02f, -9.04205441e-03f, 3.19336727e-03f, 6.63297996e-03f, -6.32841885e-02f, -5.69712482e-02f, 1.24719786e-02f,
  2.36106310e-02f, -2.64497269e-02f, 2.21292544e-02f, -1.78704280e-02f, -4.29905988e-02f, 7.92651251e-02f, -6.90692216e-02f, -1.80594381e-02f, -7.83413276e-02f, 2.11679786e-02f,
  -5.66559322e-02f, -2.43483037e-02f, 3.14746350e-02f, 7.58736655e-02f, 1.29020894e-02f, 3.12318709e-02f, -5.73058538e-02f, 2.02903766e-02f, 7.36110061e-02f, 4.29277457e-02f,
  -6.18484849e-03f, 7.85560533e-02f, -4.27402817e-02f, 8.20164010e-02f, -5.06966747e-02f, 3.44255613e-03f, -4.91382331e-02f, -8.70320573e-02f, 4.15735180e-03f, -5.62326647e-02f,
  7.06602260e-02f, -4.79705557e-02f, -4.87441570e-03f, -6.89324290e-02f, -3.33427936e-02f, -6.61510676e-02f, 1.61875077e-02f, 4.12106551e-02f, 7.09550874e-03f, -1.34561853e-02f,
  1.66881904e-02f, -2.20443420e-02f, 3.87640856e-02f, -3.81415151e-02f, -7.10350499e-02f, -7.50507182e-03f, 5.95324412e-02f, -7.13784320e-05f, -3.92255075e-02f, -5.57622574e-02f,
  4.22659107e-02f, 3.89154591e-02f, -3.38868164e-02f, 5.55363484e-02f, -7.19232410e-02f, -3.60048306e-03f, -8.43286887e-02f, 2.33087838e-02f, 2.04191059e-02f, -2.97323205e-02f,
  -1.77354813e-02f, -2.34971810e-02f, -3.39260474e-02f, -4.52976190e-02f, -3.08186412e-02f, -8.98121949e-03f, -5.84728085e-02f, 2.06889808e-02f, -8.16163570e-02f, -4.25512306e-02f,
  1.90691687e-02f, 3.15254033e-02f, 4.69361246e-02f, 1.18743805e-02f, 7.21502528e-02f, -2.70690229e-02f, 4.79449220e-02f, -5.65430894e-02f, 7.47255757e-02f, -7.53818452e-02f,
  -2.91080810e-02f, -9.68308672e-02f, 2.55486425e-02f, -1.17106903e-02f, 1.17757998e-03f, -8.25133622e-02f, -6.31998926e-02f, 4.77317721e-02f, -5.54282255e-02f, 7.46413618e-02f,
  2.07733035e-01f, -2.79296130e-01f, -4.45097744e-01f, -4.43633273e-02f, 1.91806003e-01f, 1.81913525e-01f, -1.25606731e-01f, 4.71335426e-02f, -2.08331853e-01f, 5.95174618e-02f,
  1.25747755e-01f, -7.09977597e-02f, -3.05372626e-01f, 2.35274330e-01f, 1.00725755e-01f, -1.60746351e-01f, 2.31994450e-01f, 7.06671104e-02f, -1.49171159e-01f, 9.74804610e-02f,
  6.32755086e-02f, 2.23006085e-01f, -7.37642497e-02f, 2.52485275e-01f, 5.28055392e-02f, -1.69454538e-03f, 2.27592990e-01f, -7.49019980e-02f, 3.21359754e-01f, 1.79664910e-01f,
  2.16726884e-02f, -3.14583480e-02f, -2.10140850e-02f, 3.90840583e-02f, -3.26835848e-02f, 6.06491342e-02f, -4.78416532e-02f, 5.50580584e-02f, -3.36337686e-02f, -2.49538384e-02f,
  -3.44226323e-02f, 6.01095036e-02f, 9.41482857e-02f, 7.77354639e-04f, 5.10177612e-02f, -1.86670832e-02f, -5.06719798e-02f, -1.27500379e-02f, -1.29455075e-01f, -2.02601347e-02f,
  -1.14734933e-01f, -1.08376220e-01f, -5.63618653e-02f, -7.19762668e-02f, -1.08156092e-01f, -1.25299888e-02f, -5.54179028e-02f, -9.21616480e-02f, 9.93420184e-02f, 3.67856398e-02f,
  3.57533954e-02f, 1.39642495e-03f, -8.40221569e-02f, 4.37832400e-02f, -2.73080133e-02f, 5.92095740e-02f, 2.27197334e-02f, 2.23857295e-02f, 5.35199093e-03f, -3.33136786e-03f,
  -3.66259590e-02f, 6.35192245e-02f, 5.52960392e-03f, 8.13108087e-02f, 6.19705245e-02f, -1.96908154e-02f, -6.05702400e-03f, 3.22472118e-02f, -3.32737039e-03f, -8.09182525e-02f,
  -1.89948082e-02f, 1.81745458e-02f, -6.22941591e-02f, -3.84591594e-02f, 1.52138900e-02f, 2.42491737e-02f, 7.20817968e-02f, -2.21528448e-02f, -9.89313144e-03f, -5.34189958e-03f,
  6.11264780e-02f, -7.88642792e-04f, -2.58604437e-02f, -2.99516004e-02f, 1.65609811e-02f, 1.43673703e-01f, 1.05415713e-02f, 2.35217772e-02f, -3.43248434e-02f, 1.75296087e-02f,
  5.62557392e-02f, -5.18533476e-02f, 4.56536002e-02f, -1.39713120e-02f, 3.42743769e-02f, -6.54651551e-03f, -3.52180675e-02f, -3.23267840e-02f, 1.00918770e-01f, 2.86950450e-02f,
  -9.92300957e-02f, 3.42857167e-02f, -5.20758680e-04f, 2.51487270e-03f, 3.40297669e-02f, -7.71538243e-02f, -8.18433799e-03f, -6.13474585e-02f, 8.19308907e-02f, -7.34774545e-02f,
  1.25738025e-01f, -9.71853435e-02f, 3.46753448e-02f, 1.24139234e-01f, 1.42027587e-01f, 7.03622252e-02f, 9.99781936e-02f, -5.52259162e-02f, -2.09556650e-02f, -8.94095898e-02f,
  -1.95876062e-02f, -1.16314366e-01f, -9.13561806e-02f, 1.09667711e-01f, 1.92014098e-01f, -3.99246588e-02f, 7.90909305e-02f, 3.70205194e-02f, -1.81553625e-02f, -7.54341111e-02f,
  1.03050001e-01f, -1.26918619e-02f, -1.65650528e-02f, -8.02523196e-02f, 2.38696076e-02f, -6.25696182e-02f, 3.27727455e-03f, -2.46292613e-02f, -2.61012893e-02f, 8.46207365e-02f,
  -1.64351258e-02f, -1.53665552e-02f, 2.50802692e-02f, -2.58169826e-02f, 5.31878583e-02f, -5.47145121e-02f, -4.23763655e-02f, 7.89922774e-02f, 8.85881558e-02f, -8.20426717e-02f,
  7.11909607e-02f, 3.71512994e-02f, 8.76187086e-02f, 5.67368651e-03f, 3.68261337e-02f, 3.13937813e-02f, 7.51994271e-03f, 4.41824226e-03f, -1.01164274e-03f, 7.79730231e-02f,
  -3.56034040e-02f, -5.52226305e-02f, 6.04200847e-02f, -5.78101957e-03f, -1.83446202e-02f, -2.50363629e-02f, 9.38524492e-03f, 1.85964461e-02f, 7.17950910e-02f, -6.24338426e-02f,
  3.98305431e-02f, 1.17948446e-02f, 3.53083722e-02f, -2.40757875e-02f, -5.32894731e-02f, 1.82283353e-02f, 7.30035231e-02f, -6.18232116e-02f, -1.03708804e-01f, -4.97385003e-02f,
  1.49984499e-02f, 9.80964527e-02f, -5.59497885e-02f, 5.32895746e-03f, -1.51374647e-02f, 9.48596150e-02f, 7.87027255e-02f, 4.11378890e-02f, -2.57118996e-02f, 1.02565214e-01f,
  -3.33500318e-02f, 1.04423344e-01f, -6.96377382e-02f, 2.64512803e-02f, 8.91380981e-02f, -5.23018725e-02f, -2.73533799e-02f, -6.82298318e-02f, -3.51326950e-02f, -6.23229705e-02f,
  2.92354804e-02f, -4.39360477e-02f, -2.76836883e-02f, -4.52366620e-02f, -5.17743528e-02f, -3.36944535e-02f, -7.15528652e-02f, 6.93160892e-02f, 8.62187985e-03f, 8.90665650e-02f,
  -6.47719055e-02f, 7.52865821e-02f, -7.73144439e-02f, 4.99342903e-02f, 5.38092442e-02f, -3.52927409e-02f, 3.23578827e-02f, 1.80855542e-02f, 2.63193604e-02f, -1.34030562e-02f,
  -3.63979153e-02f, -8.19079429e-02f, 9.18060616e-02f, -2.70415265e-02f, -4.80493046e-02f, 5.51817343e-02f, -6.49213046e-02f, -4.88903746e-02f, 2.75728367e-02f, 1.75214484e-02f,
  2.39278510e-01f, 2.33355790e-01f, -3.77347246e-02f, -5.69897927e-02f, -1.75136998e-01f, -3.28537166e-01f, -1.82681903e-01f, -1.69696555e-01f, 5.63753992e-02f, 2.06052531e-02f,
  -1.70988634e-01f, 2.71658719e-01f, -1.13870457e-01f, -6.86922222e-02f, -1.62750751e-01f, -5.63394092e-02f, -2.07565859e-01f, 1.05897421e-02f, -4.09258865e-02f, -1.49151191e-01f,
  5.89540266e-02f, -2.34304398e-01f, -8.95650312e-02f, -7.40631297e-02f, -1.06738575e-01f, 5.46772331e-02f, -9.11607128e-03f, -1.75381303e-01f, -2.58259512e-02f, -9.55504030e-02f,
  3.60123105e-02f, 1.07695065e-01f, 1.10406645e-01f, -1.31580094e-02f, -4.33951281e-02f, -5.33981659e-02f, -5.99519396e-03f, -9.70516354e-03f, 2.41243374e-02f, -1.94515530e-02f,
  3.81120965e-02f, -7.82920222e-04f, -1.90577824e-02f, 2.23021135e-02f, -1.83372088e-02f, 1.88733321e-02f, 2.79923100e-02f, 2.62896400e-02f, 5.22304140e-02f, 1.00921161e-01f,
  1.01801366e-01f, 4.99395328e-03f, -1.59329940e-02f, -7.15987291e-03f, 1.17716305e-02f, 1.91487819e-02f, -1.18842153e-02f, 4.64715399e-02f, 9.27945599e-02f, 3.46783362e-02f,
  4.26267423e-02f, 1.45736812e-02f, -2.25535817e-02f, 6.51722327e-02f, 3.00261918e-02f, 3.69489528e-02f, 5.39995767e-02f, -4.17215899e-02f, -2.23591123e-02f, -8.39832723e-02f,
  1.46044055e-02f, 3.51641476e-02f, -2.82912962e-02f, 4.21059392e-02f, 5.86057492e-02f, 5.07202186e-02f, -3.71885039e-02f, 6.70001805e-02f, -6.06762692e-02f, 3.70743945e-02f,
  -3.59287187e-02f, -3.21275257e-02f, 2.70245615e-02f, 1.59889180e-02f, 4.70947102e-03f, 4.07039188e-02f, 3.78450789e-02f, 4.07467708e-02f, -2.55406704e-02f, 6.78706123e-03f,
  -5.26329428e-02f, -1.27265975e-01f, 2.88219191e-02f, 4.01435904e-02f, 2.24968102e-02f, 4.35983837e-02f, -7.48570040e-02f, -4.79089841e-02f, -1.09729329e-02f, 1.47739546e-02f,
  -3.84548008e-02f, -6.57485127e-02f, 5.40930405e-02f, 3.13986912e-02f, -6.49116486e-02f, -1.32511929e-02f, -4.43243561e-03f, -5.80068771e-03f, 5.84658906e-02f, -3.68206576e-02f,
  2.48274710e-02f, 5.63162426e-03f, 9.46127996e-02f, 1.83666162e-02f, -5.84002770e-02f, 1.57045331e-02f, -5.88057339e-02f, 3.00622489e-02f, -3.73817831e-02f, 4.42721657e-02f,
  1.91452410e-02f, -1.81866348e-01f, -8.15979987e-02f, 7.50160664e-02f, -2.54253447e-02f, -1.00979321e-01f, -1.54293418e-01f, 3.43914740e-02f, -1.77098513e-02f, -4.95382771e-02f,
  -4.21061330e-02f, -9.96987000e-02f, -2.64406484e-02f, -9.87808779e-02f, 8.80569443e-02f, 4.09589261e-02f, -5.96775897e-02f, 6.27659187e-02f, -3.58026708e-03f, -7.87549391e-02f,
  -1.43183842e-02f, -6.46763742e-02f, -6.38120249e-02f, 5.22247702e-02f, 7.37945810e-02f, 1.27432212e-01f, 1.78404525e-01f, 5.69045451e-03f, 1.42024760e-03f, -2.17747502e-02f,
  -2.29696045e-03f, -4.47632186e-02f, 3.25870924e-02f, -1.45677581e-01f, 1.12913828e-02f, 1.05065830e-01f, 6.61088452e-02f, 3.90591733e-02f, -4.24724109e-02f, 3.59310396e-02f,
  -2.44369525e-02f, 7.06082862e-03f, -9.15564224e-02f, -3.16288061e-02f, 9.29739997e-02f, -8.95190313e-02f, 3.69483866e-02f, 6.84389099e-02f, -6.00442290e-02f, -7.15349242e-02f,
  6.81033265e-03f, 3.49448225e-03f, -5.04485667e-02f, 2.31442358e-02f, 3.24092023e-02f, 4.13122661e-02f, -1.22204162e-02f, 2.29875296e-02f, 2.24030335e-02f, 3.86768244e-02f,
  -1.67321153e-02f, 8.21680874e-02f, -7.02713653e-02f, 4.73726019e-02f, -5.41927107e-02f, 8.47059041e-02f, 7.96237439e-02f, -1.96858961e-02f, -1.60347875e-02f, 8.18218142e-02f,
  4.20568623e-02f, 5.66307008e-02f, -6.38177469e-02f, -4.97225486e-02f, -1.90730672e-02f, -7.57891610e-02f, -8.04730039e-03f, 5.23439841e-03f, 5.45755886e-02f, -5.54700978e-02f,
  5.70071936e-02f, 3.79901864e-02f, -1.37087954e-02f, -8.09688296e-04f, -3.81240924e-03f, 6.66541085e-02f, 8.86770040e-02f, 1.51448818e-02f, -9.00577381e-03f, 5.27618863e-02f,
  3.99532402e-03f, 8.27478170e-02f, 2.45528892e-02f, -8.67542103e-02f, -2.24126540e-02f, 5.15898615e-02f, 3.96614000e-02f, -7.32165352e-02f, -4.82186712e-02f, 8.20817426e-03f,
  -4.23110276e-02f, 4.89203781e-02f, 9.48973671e-02f, -5.19175157e-02f, 7.89249502e-03f, 2.12492887e-02f, -4.13648263e-02f, 9.25314650e-02f, -1.62319038e-02f, 5.72389700e-02f,
  5.56226149e-02f, 3.59063782e-02f, 1.28823975e-02f, 3.95193584e-02f, -4.17100489e-02f, 1.22128151e-01f, -4.69241031e-02f, -4.74255346e-02f, -3.81055400e-02f, 3.37107703e-02f,
  -8.05692300e-02f, -2.39088386e-02f, -1.34374067e-01f, -2.02999301e-02f, -6.65156171e-02f, -9.93633643e-02f, -1.76349536e-01f, -1.94452032e-02f, -2.31469870e-02f, 2.00560247e-03f,
  -4.81707714e-02f, -1.12156585e-01f, -8.48580971e-02f, -3.50757875e-02f, 3.23844366e-02f, 1.54289091e-02f, 3.78536843e-02f, 6.41683266e-02f, 8.64457488e-02f, -1.22644193e-01f,
  2.15246044e-02f, -6.00688457e-02f, -5.01117185e-02f, -9.57168862e-02f, -5.24348430e-02f, 4.22120877e-02f, -8.27356987e-03f, -7.45203048e-02f, -7.83742145e-02f, 4.55936007e-02f,
  1.68200471e-02f, 3.81543450e-02f, -4.67182696e-02f, -1.54034533e-02f, 7.48131201e-02f, -4.87381928e-02f, -2.00284496e-02f, 4.93370965e-02f, 7.64012411e-02f, -7.26360921e-03f,
  8.95627737e-02f, 1.36277499e-02f, 1.43529326e-02f, -3.48362848e-02f, -6.77818432e-02f, -3.99741009e-02f, 3.99411097e-03f, -3.74025595e-03f, -1.96066964e-02f, 3.59888859e-02f,
  -4.53229137e-02f, -5.70627637e-02f, 1.67786013e-02f, -8.86433385e-03f, 9.20595899e-02f, -1.39220143e-02f, 8.63147620e-03f, -7.39311054e-02f, -1.88310724e-02f, 3.90533507e-02f,
  -4.93816771e-02f, -9.52838957e-02f, -4.41360325e-02f, -4.42612357e-02f, 5.46421064e-03f, 5.91223799e-02f, 9.71229561e-03f, 2.71058362e-02f, 3.45993675e-02f, 6.04297919e-03f,
  3.14337686e-02f, -5.36766574e-02f, 7.11257756e-02f, -5.20472862e-02f, 3.88517603e-02f, -2.24034246e-02f, -5.77737689e-02f, -7.45754316e-02f, 6.37111291e-02f, 5.19844219e-02f,
  4.20855135e-02f, 9.33587477e-02f, -1.91119537e-02f, 1.98576204e-03f, 7.88372476e-03f, -4.69240025e-02f, -4.62022685e-02f, -6.06545098e-02f, -7.69063737e-03f, 3.77286645e-03f,
  -2.15024296e-02f, -3.03367414e-02f, -6.82455152e-02f, 8.01420286e-02f, 3.56828757e-02f, 6.18244745e-02f, -5.84080927e-02f, -2.73135887e-03f, 5.90965971e-02f, -9.72985998e-02f,
  5.03587015e-02f, 7.86627643e-03f, -5.44769317e-02f, -1.74245015e-02f, 7.94110298e-02f, -8.79187509e-03f, 3.18788849e-02f, 5.15633300e-02f, 1.02031559e-01f, 1.92995910e-02f,
  -7.83834383e-02f, -9.19601768e-02f, 2.41525546e-02f, -7.60682300e-02f, 7.00859891e-06f, 1.32634947e-02f, -8.69066734e-03f, 9.49762240e-02f, 5.10701984e-02f, 5.18359942e-03f,
  4.29792285e-01f, -4.84673053e-01f, -2.91843005e-02f, 1.61730558e-01f, 1.36423215e-01f, -1.32703960e-01f, -6.00503245e-03f, -1.64474368e-01f, 8.64812732e-02f, -4.34795648e-01f,
  4.24527451e-02f, 1.75955612e-02f, -5.78688309e-02f, -5.91986664e-02f, 3.72357011e-01f, -6.19678535e-02f, -3.99882756e-02f, -1.44653274e-02f, 4.55593765e-02f, -5.38905859e-02f,
  1.50330126e-01f, -7.61864558e-02f, -9.91976447e-03f, -3.36116403e-01f, -4.63529751e-02f, -1.24618590e-01f, 7.62978792e-02f, -1.40370443e-01f, -1.65778428e-01f, 6.73645586e-02f,
  -3.77470697e-03f, -2.55126283e-02f, 3.91631536e-02f, -2.42473129e-02f, -1.32060289e-01f, 2.38754172e-02f, 4.28620428e-02f, 3.66451778e-02f, 9.77590010e-02f, 1.14296349e-02f,
  3.83354165e-02f, 6.01733290e-02f, -7.48078823e-02f, 4.52264547e-02f, -2.42997240e-02f, -6.89996108e-02f, 1.01220407e-01f, 1.26733899e-03f, -7.12625980e-02f, -4.92599867e-02f,
  4.00107689e-02f, -2.12253146e-02f, 3.45923798e-03f, -6.81801289e-02f, 4.45333421e-02f, -6.04165345e-02f, -6.69584200e-02f, -4.43418883e-02f, 2.16237307e-02f, -2.85328776e-02f,
  -2.81895474e-02f, 4.10307087e-02f, -2.75730882e-02f, 5.41777760e-02f, -1.42086996e-02f, 1.14112921e-01f, 1.15257232e-02f, 5.87757118e-02f, -1.09883156e-02f, 4.71534468e-02f,
  5.14163971e-02f, 1.21737528e-03f, 4.66786623e-02f, 2.82222237e-02f, -1.79058425e-02f, -3.52379261e-03f, 6.52340874e-02f, -5.07417843e-02f, -1.48987519e-02f, -1.41618708e-02f,
  5.17920442e-02f, 1.26986457e-02f, -9.89506394e-03f, -1.45402076e-02f, -4.27430160e-02f, 4.98397183e-03f, -9.06882063e-02f, -1.20461108e-02f, 2.21827868e-02f, 2.76318975e-02f,
  -6.26434833e-02f, -3.74412119e-01f, -1.21035829e-01f, 2.61111036e-02f, -8.71066283e-03f, -7.31457993e-02f, -3.90072055e-02f, -4.63311188e-02f, -3.85484435e-02f, -2.31506713e-02f,
  -5.75916208e-02f, 5.46817714e-03f, 1.73722953e-02f, 2.30325982e-02f, 1.68747120e-02f, 1.05735995e-02f, -6.08169734e-02f, -3.24247889e-02f, 2.75121490e-03f, -9.13571864e-02f,
  -7.19187688e-03f, 6.36598617e-02f, 1.87538993e-02f, -1.69985872e-02f, -7.46015981e-02f, -1.15831913e-02f, 3.13908122e-02f, -2.93886513e-02f, -7.69627541e-02f, 4.22237767e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.29148573e-01f, 7.70544484e-02f, 1.38717636e-01f, -1.15999058e-02f, 1.96921676e-01f, 1.21286511e-01f, 2.93736663e-02f, 1.19626060e-01f, 1.19295336e-01f, 1.55277252e-01f,
  1.32233769e-01f, 1.11498870e-01f, -4.34689857e-02f, 2.77815968e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  4.48927954e-02f, 2.22077012e-01f, -8.02924857e-03f, 2.24235542e-02f, -7.38098994e-02f, -2.63966732e-02f, 1.47943035e-01f, -5.38579077e-02f, 2.84386054e-03f, 1.00487366e-01f,
  -6.83030188e-02f, 3.88403125e-02f, 2.13739306e-01f, -1.15549229e-01f, -2.22732238e-02f, 1.47914486e-02f, 1.39814332e-01f, 1.16880931e-01f, 1.40623480e-01f, -9.64571759e-02f,
  -1.17381113e-02f, 4.00805920e-02f, -6.54511079e-02f, 9.64288339e-02f, 7.71586895e-02f, -3.58837359e-02f, -1.93378925e-01f, -8.63297880e-02f, 2.21579880e-01f, 1.40390709e-01f,
  9.37456116e-02f, 3.16298664e-01f, 6.67851791e-02f, 9.95779559e-02f, 2.43027642e-01f, -7.77567774e-02f, -1.04491785e-02f, 8.95800442e-02f, 1.13841519e-02f, -8.02481100e-02f,
  6.10445021e-03f, -4.03241739e-02f, -2.60972008e-02f, -1.64377555e-01f, -3.16157252e-01f, -1.96867630e-01f, 1.61411941e-01f, -8.96270350e-02f, 1.22556826e-02f, 2.12678730e-01f,
  -5.82220890e-02f, 1.90802440e-01f, 1.42168790e-01f, -4.48844023e-02f, -2.88781643e-01f, 9.14487895e-03f, 2.22578254e-02f, 9.50654969e-02f, -8.12613294e-02f, 3.73214372e-02f,
  -1.03022061e-01f, -4.11757119e-02f, 5.42465411e-02f, 1.43475190e-01f, -1.38184195e-02f, 5.16731851e-02f, -2.91030090e-02f, 6.37727603e-02f, 1.15903787e-01f, -4.51746322e-02f,
  8.00895616e-02f, 2.64647286e-02f, -1.07414939e-01f, -7.38466457e-02f, 3.85437049e-02f, 4.88550812e-02f, 1.14869907e-01f, 9.71134827e-02f, 1.40165225e-01f, -3.67115252e-02f,
  9.76911485e-02f, 9.39884633e-02f, -1.25405595e-01f, 4.03372906e-02f, 1.30605372e-02f, 9.12201330e-02f, 2.84791198e-02f, 6.41091447e-03f, 2.16822326e-01f, 2.01690383e-02f,
  1.83575764e-01f, -8.96505453e-03f, 1.28738597e-01f, 4.31593973e-03f, 3.46707284e-01f, 2.72458762e-01f, -2.22085584e-02f, -2.21018046e-02f, 5.75263426e-02f, -1.62827503e-02f,
  5.47516765e-03f, 1.81687653e-01f, -2.74745017e-01f, 1.09954052e-01f, -2.78440386e-01f, -9.02739093e-02f, -4.83753309e-02f, 7.49994591e-02f, 1.45327866e-01f, 4.37540300e-02f,
  4.01452929e-02f, -8.21645111e-02f, -1.20312698e-01f, 2.29202565e-02f, 1.26340553e-01f, -1.84272319e-01f, 1.73795149e-01f, 9.82813612e-02f, 1.62609532e-01f, 1.38553157e-01f,
  1.56032786e-01f, 5.53592704e-02f, -2.35775664e-01f, -1.75321177e-01f, 1.09889820e-01f, -4.87697609e-02f, -5.03330631e-03f, -3.32305670e-01f, 2.55928189e-01f, 9.04229004e-03f,
  1.04285553e-01f, -3.14267911e-02f, -1.49303555e-01f, 1.38609009e-02f, 9.04978365e-02f, 3.88721116e-02f, -6.94053695e-02f, -1.56827196e-01f, 9.84204933e-02f, -4.87621278e-02f,
  -2.55849808e-02f, 1.35010153e-01f, -6.81722909e-02f, 5.67279942e-02f, 1.38117045e-01f, 1.99075025e-02f, 3.11352480e-02f, 2.21384484e-02f, 8.02072436e-02f, -2.69978195e-02f,
  9.68720913e-02f, 1.17985561e-01f, 1.26166791e-01f, 5.58463223e-02f, 6.78991303e-02f, 1.13189138e-01f, -2.79176999e-02f, -2.30063766e-01f, -1.50684878e-01f, 1.44258276e-01f,
  5.18028997e-02f, 1.46199204e-02f, 1.10101804e-01f, -5.72653161e-03f, 5.60255013e-02f, -9.15889293e-02f, 8.80811960e-02f, 4.31535505e-02f, 2.58256763e-01f, -9.20365080e-02f,
  3.22364569e-01f, 1.47491395e-01f, 4.10721041e-02f, 8.38058814e-02f, -3.05127501e-02f, 3.77509929e-02f, 1.95231497e-01f, 1.88494086e-01f, -1.35283843e-01f, -2.07389891e-01f,
  9.04071257e-02f, 7.63805062e-02f, 1.89710949e-02f, -4.72204275e-02f, 1.38502931e-02f, 4.63981368e-02f, 2.18141489e-02f, -9.48743243e-03f, -1.74316227e-01f, -3.64903025e-02f,
  -1.28646448e-01f, 5.44168726e-02f, 9.60362926e-02f, 7.39774331e-02f, -5.24939336e-02f, 1.50453433e-01f, -1.24165609e-01f, 5.19563677e-04f, -2.22899541e-01f, 5.55560291e-02f,
  5.25647290e-02f, 1.80263817e-02f, -6.88000396e-02f, -5.71336709e-02f, -1.54338986e-01f, -1.09663010e-01f, -8.51968378e-02f, 1.39245972e-01f, -5.92883155e-02f, 5.39381206e-02f,
  -8.52645710e-02f, 3.32558043e-02f, 6.02932796e-02f, 7.11439401e-02f, -5.48301525e-02f, 3.72793674e-02f, -1.89951546e-02f, -3.82591709e-02f, -2.90400058e-01f, -2.14452237e-01f,
  8.93176496e-02f, -8.66342336e-02f, -1.18824996e-01f, -2.42151827e-01f, -1.35637626e-01f, -1.45965397e-01f, 1.98485535e-02f, -1.43931031e-01f, -2.01129034e-01f, -3.32285881e-01f,
  4.74300571e-02f, -2.12504178e-01f, 1.69845566e-01f, 2.93630958e-01f, -1.05570517e-01f, -1.43034026e-01f, -8.95316452e-02f, 6.67346045e-02f, -2.24280670e-01f, -1.92513946e-03f,
  6.48256019e-02f, -2.15350837e-01f, -9.75717455e-02f, 1.39582455e-01f, 1.86396968e-02f, -1.01940721e-01f, -2.24061999e-02f, 1.29282638e-01f, -7.52096949e-03f, 7.69985318e-02f,
  2.00332120e-01f, 1.15452833e-01f, -1.90900922e-01f, -1.10847019e-02f, -3.78623679e-02f, -6.85410947e-02f, -1.39341325e-01f, 3.44524672e-03f, -6.47076145e-02f, -3.44973914e-02f,
  5.91937974e-02f, -5.60915284e-02f, 3.20519730e-02f, -4.29175748e-03f, -2.76853214e-03f, 4.40941416e-02f, -1.35218631e-02f, -4.54922728e-02f, -1.35825425e-01f, 4.57497127e-03f,
  -5.50742038e-02f, -3.58414799e-02f, -1.22415870e-02f, 8.42571482e-02f, -2.93323621e-02f, 7.08574383e-03f, -6.20870702e-02f, 1.86584834e-02f, -1.02404930e-01f, -2.20514052e-02f,
  -4.46185358e-02f, 2.07196459e-01f, 1.61576957e-01f, -2.12422628e-02f, -3.39415491e-01f, 1.05855735e-02f, 2.10726723e-01f, 2.78416634e-01f, 9.80606601e-02f, 1.52345121e-01f,
  -2.90325254e-01f, 1.11739099e-01f, 7.59298131e-02f, 1.42459765e-01f, 1.81137651e-01f, 2.23623812e-01f, -5.94203845e-02f, 4.39311936e-02f, 1.25812978e-01f, 2.25457862e-01f,
  8.68920088e-02f, 1.93191245e-01f, -5.99798746e-02f, -1.00372545e-02f, -1.49886176e-01f, -6.85943812e-02f, 9.14777219e-02f, -6.41119778e-02f, 2.14136075e-02f, -4.48823720e-02f,
  4.46728244e-02f, 5.53964730e-03f, 1.97450742e-01f, -1.23077109e-01f, -7.84008950e-02f, -1.07003629e-01f, -3.28739062e-02f, 1.05768003e-01f, 1.17516600e-01f, -4.61113490e-02f,
  1.57099798e-01f, 1.16608940e-01f, -1.66172534e-01f, -5.20742647e-02f, 2.00561080e-02f, 1.67299569e-01f, -4.22339179e-02f, 1.80545226e-01f, 8.81417170e-02f, -6.79617003e-02f,
  -9.29488689e-02f, 9.95074119e-03f, -6.62128106e-02f, 5.02683185e-02f, 4.45671976e-02f, -8.98983330e-02f, -1.00188360e-01f, -1.49557937e-03f, -3.83767895e-02f, -1.58855468e-01f,
  -8.13807473e-02f, 2.73849871e-02f, -1.10427886e-01f, 4.09085816e-03f, 7.23195001e-02f, 1.31520659e-01f, -1.24703437e-01f, -1.79049060e-01f, -7.94901922e-02f, 1.30698040e-01f,
  -1.00298740e-01f, 1.84102394e-02f, 2.01741159e-01f, -8.30652043e-02f, -1.68147191e-01f, 1.89379901e-01f, -7.82914981e-02f, -1.77323386e-01f, 2.06919119e-01f, 9.26115140e-02f,
  3.85871641e-02f, 1.22298904e-01f, 6.20785207e-02f, -5.25083058e-02f, -3.96014899e-02f, 1.90571427e-01f, -2.15246931e-01f, 1.92920104e-01f, -1.63683668e-01f, -1.96032837e-01f,
  -1.41297340e-01f, 8.04623067e-02f, -3.28877196e-02f, -1.41988158e-01f, -2.15646774e-02f, 2.85209948e-03f, -9.08633322e-02f, 1.22149095e-01f, -8.96391422e-02f, 4.26469818e-02f,
  -2.39147991e-01f, 1.00840151e-01f, 1.08029716e-01f, -1.83062971e-01f, 1.85326971e-02f, 2.09969077e-02f, -9.54636335e-02f, -1.61330834e-01f, 2.54690479e-02f, 9.72500369e-02f,
  -1.61282778e-01f, 1.28675416e-01f, -1.23951413e-01f, 2.00015157e-02f, -1.12601973e-01f, -5.96311465e-02f, -1.74504772e-01f, 1.16081201e-01f, 1.27566487e-01f, -1.35993352e-02f,
  -1.95730358e-01f, 3.90173905e-02f, -1.51440993e-01f, 1.39699459e-01f, -1.50526926e-01f, -2.61903908e-02f, -2.20076457e-01f, -2.17410494e-02f, -4.40089181e-02f, 5.28754666e-02f,
  -8.00674260e-02f, -1.49716929e-01f, 5.68696558e-02f, 2.19676897e-01f, 9.58624482e-02f, 6.15291670e-02f, -7.26128891e-02f, -2.75384728e-02f, -1.06783630e-02f, 1.63204119e-01f,
  -1.36220068e-01f, -2.05753446e-01f, -8.17138553e-02f, 1.06618628e-01f, -1.65752709e-01f, 6.09652027e-02f, -1.90839037e-01f, -1.61805764e-01f, 1.20255183e-02f, 1.12332344e-01f,
  -2.26802990e-01f, 1.43016577e-01f, -1.50405154e-01f, -2.06089363e-01f, 9.45399851e-02f, 1.42013151e-02f, 1.01796035e-02f, 9.52411722e-03f, -5.40213510e-02f, 1.44127995e-01f,
  -7.35461116e-02f, 6.57601580e-02f, -1.20538086e-01f, -1.29818946e-01f, 8.57091770e-02f, -7.46326195e-03f, -4.17869091e-02f, -2.92305619e-01f, -1.94929261e-03f, -3.32341976e-02f,
  1.13017924e-01f, -5.27096018e-02f, 2.02020034e-02f, -1.70501713e-02f, -1.92956626e-01f, 9.63545516e-02f, -2.22074483e-02f, 1.45613104e-01f, 2.46851351e-02f, 3.64010856e-02f,
  -6.95596188e-02f, 9.77950636e-03f, -7.32322484e-02f, 1.40119225e-01f, -1.11228481e-01f, 1.36884496e-01f, 6.06564730e-02f, 4.37324904e-02f, -6.48110136e-02f, 6.81114569e-03f,
  4.30913307e-02f, 8.94527212e-02f, -5.14940321e-02f, -2.39889368e-01f, -2.39777789e-01f, 3.82001437e-02f, 2.24747583e-01f, 1.59677141e-03f, -1.19511504e-02f, -1.57147303e-01f,
  -2.75991261e-01f, -1.46379456e-01f, -1.48802012e-01f, -1.78001210e-01f, 8.72137696e-02f, -1.36190727e-01f, 1.77044362e-01f, -3.85252237e-02f, -1.55207217e-01f, 9.58160833e-02f,
  -2.71417648e-01f, -2.20814142e-02f, 2.49292970e-01f, -1.53915569e-01f, -5.75403348e-02f, 2.41048560e-02f, 7.54858973e-03f, -1.87344834e-01f, 2.09965017e-02f, 2.01713085e-01f,
  -1.17218107e-01f, -9.24369097e-02f, -4.10021506e-02f, 9.15681422e-02f, 1.05168233e-02f, -1.43751716e-02f, 2.47093976e-01f, 1.03789978e-01f, -1.95984140e-01f, -4.49381908e-03f,
  -1.22628536e-03f, -2.37992421e-01f, -6.12523556e-02f, 1.51324093e-01f, -4.44249157e-03f, 7.21733049e-02f, -4.60401028e-02f, 1.95849705e-02f, -9.49150603e-03f, 2.75803376e-02f,
  9.21314284e-02f, -1.47775844e-01f, 3.23601589e-02f, 8.03988874e-02f, 2.28667825e-01f, 8.53531435e-02f, 4.37994115e-02f, -3.21401171e-02f, 1.55694902e-01f, 4.12411541e-02f,
  -4.23132646e-04f, 1.22875080e-01f, -1.09624580e-01f, 4.53378558e-02f, -6.85679242e-02f, -2.21619066e-02f, -4.88146283e-02f, 1.44622969e-02f, -2.95499228e-02f, -7.51915649e-02f,
  6.07135892e-02f, 1.22022331e-01f, -7.62344478e-03f, 3.55369896e-01f, 5.28268851e-02f, 2.06937715e-01f, 1.28769353e-01f, -2.47103963e-02f, -3.56547609e-02f, 9.38665122e-02f,
  6.19304217e-02f, -1.05039336e-01f, -2.23212820e-02f, 1.84706156e-03f, 2.16945618e-01f, -2.10765321e-02f, -2.31427178e-01f, 1.04944231e-02f, 1.89229682e-01f, -7.62335211e-02f,
  7.84425959e-02f, 1.15011983e-01f, 1.05150737e-01f, 1.97375968e-01f, -1.21924691e-01f, 7.70593807e-02f, -1.78105444e-01f, 7.11418837e-02f, 6.90264776e-02f, 7.61324316e-02f,
  -2.23174006e-01f, 1.18138880e-01f, -1.40074044e-01f, 1.24417573e-01f, -5.33626266e-02f, 2.01863229e-01f, -9.47534665e-03f, 1.10122927e-01f, -1.67224649e-02f, 9.01937857e-02f,
  -1.06617101e-01f, 1.03928596e-01f, 3.47741581e-02f, -7.49682263e-02f, -9.67073906e-03f, -7.76765272e-02f, -1.33890897e-01f, -6.98806792e-02f, 1.09515242e-01f, -1.27721773e-02f,
  -9.67035815e-02f, 4.34823856e-02f, 7.46827424e-02f, -1.38968855e-01f, -6.98908605e-03f, 8.92249197e-02f, -2.26351600e-02f, -8.02420899e-02f, -1.12021603e-01f, -2.41791494e-02f,
  1.32852495e-01f, -7.34360069e-02f, -1.58329010e-02f, 1.65739551e-01f, 1.73171371e-01f, 7.01656863e-02f, 2.17411220e-01f, 3.00905287e-01f, -8.63759890e-02f, 1.84579454e-02f,
  -3.74766998e-02f, 1.71261244e-02f, 1.15899533e-01f, 2.18592614e-01f, 7.10170623e-03f, -3.86009254e-02f, -2.44436786e-02f, 2.27708444e-02f, -9.46536064e-02f, -5.50218076e-02f,
  1.48646921e-01f, -1.34480968e-01f, 2.10901678e-01f, -2.25475263e-02f, 1.11865349e-01f, -4.41298410e-02f, 9.29697379e-02f, 3.71586867e-02f, 9.06067342e-02f, -1.12297349e-01f,
  2.15437263e-02f, 1.50309950e-01f, -5.93630262e-02f, 7.28696734e-02f, -4.86939494e-03f, -5.38408495e-02f, -1.18816137e-01f, -1.04632065e-01f, 3.43201682e-03f, -3.18067163e-01f,
  -4.70140353e-02f, 3.22967172e-02f, 1.27332538e-01f, -2.24859212e-02f, 1.20683596e-01f, -6.28590807e-02f, 1.27949998e-01f, -3.85903679e-02f, -3.61137204e-02f, -6.86885789e-02f,
  -1.39350504e-01f, -1.39211982e-01f, 1.74805939e-01f, 6.97897375e-02f, -1.09036021e-01f, 4.81047742e-02f, -2.25273892e-02f, 1.19154669e-01f, 4.68665436e-02f, 1.21075576e-02f,
  -2.69107260e-02f, 1.20915458e-01f, -1.13626584e-01f, -1.54004589e-01f, -9.71052721e-02f, 1.37265205e-01f, 1.62500031e-02f, -2.41170764e-01f, 1.29017204e-01f, 2.11659119e-01f,
  3.65449600e-02f, 8.90971720e-02f, -9.42378268e-02f, 1.27854064e-01f, 3.34201574e-01f, -2.27215048e-02f, -1.01712041e-01f, -1.02629311e-01f, -2.63732821e-01f, -2.71908473e-02f,
  1.77978054e-01f, -1.93562284e-01f, 1.07328013e-01f, -1.12846971e-01f, -2.76648492e-01f, 4.98404838e-02f, 9.34061706e-02f, -2.87095696e-01f, -3.06284782e-02f, 2.84309775e-01f,
  1.55005425e-01f, -1.40798479e-01f, -3.86866555e-02f, -4.11008261e-02f, -1.88107342e-02f, 7.30381235e-02f, -1.90463383e-02f, -3.21168602e-02f, -2.98910797e-01f, -1.48172844e-02f,
  1.65089294e-01f, -1.37585446e-01f, 3.03730648e-03f, 2.55650073e-01f, 8.40536356e-02f, 7.60886073e-02f, 5.41024134e-02f, -1.56086404e-02f, 2.31213123e-02f, 1.64004445e-01f,
  1.63419724e-01f, -1.96301714e-02f, -1.02080666e-01f, 3.97292860e-02f, -4.46850508e-02f, 6.85584694e-02f, 2.44514480e-01f, 1.76598728e-01f, 1.12869464e-01f, 1.14482641e-01f,
  7.24428967e-02f, -9.39042568e-02f, -2.22879928e-02f, 1.02334499e-01f, 1.09983593e-01f, 3.09984889e-02f, -4.61558439e-02f, -1.26828238e-01f, -6.06354661e-02f, -1.12077773e-01f,
  1.47899121e-01f, 2.60782242e-01f, 1.58052564e-01f, -7.82970786e-02f, 1.21969916e-01f, -6.74958283e-05f, -1.81459427e-01f, -7.43498504e-02f, -5.87993376e-02f, 5.43343052e-02f,
  1.57758936e-01f, 1.73674852e-01f, 1.49664223e-01f, 1.92972466e-01f, -4.34114039e-03f, -2.53475875e-01f, 2.31271870e-02f, -5.35764126e-03f, 2.56980389e-01f, -1.68454558e-01f,
  1.60061881e-01f, 1.07615001e-01f, 2.20475584e-01f, -7.74363652e-02f, 4.36640950e-03f, 2.03616302e-02f, 8.56794566e-02f, 2.71673296e-02f, 1.81812808e-01f, -5.69542013e-02f,
  -6.51055351e-02f, 7.69973733e-03f, -2.19911914e-02f, -8.75640288e-02f, 3.73170525e-02f, -1.24197438e-01f, 3.74624156e-03f, -2.63590842e-01f, -1.05259076e-01f, 7.23055378e-02f,
  3.77645195e-02f, -1.70225829e-01f, -2.14383304e-01f, -2.29581490e-01f, 4.82065193e-02f, 4.49292287e-02f, 9.53717250e-03f, 8.70330036e-02f, -1.11486185e-02f, -9.30376053e-02f,
  -1.24382213e-01f, 4.28120010e-02f, 4.02188487e-02f, -1.62072927e-01f, 3.79279740e-02f, 8.74707922e-02f, 3.54397111e-02f, -3.15189838e-01f, -7.57980943e-02f, 7.15968385e-02f,
  1.99795347e-02f, 1.60986427e-02f, -1.50285056e-02f, 2.96926320e-01f, 1.39811859e-01f, -7.77582228e-02f, -7.88451657e-02f, -1.87884904e-02f, 5.78849614e-02f, 1.53044418e-01f,
  3.08063477e-01f, 2.08487004e-01f, 2.89654150e-03f, 1.71850309e-01f, 8.35417584e-03f, 1.35055661e-01f, -1.69673860e-02f, 1.85450926e-01f, -1.04948178e-01f, 1.48746192e-01f,
  2.02024639e-01f, 1.05366871e-01f, -4.15781327e-02f, 1.00753739e-01f, 5.70320245e-03f, -1.18800208e-01f, -1.09754644e-01f, 1.65649891e-01f, 1.09220035e-01f, -1.46010071e-01f,
  3.09504662e-02f, 7.87630603e-02f, -2.92797368e-02f, -1.45572245e-01f, -2.07868777e-03f, -7.92200863e-03f, 1.33344993e-01f, -6.86419457e-02f, -4.07903269e-03f, 7.86385834e-02f,
  8.42717215e-02f, 2.41762772e-01f, 3.89195383e-02f, 1.12936102e-01f, -2.04402998e-01f, -8.66954774e-02f, 1.07023954e-01f, 1.43888474e-01f, -1.69791766e-02f, 4.29991297e-02f,
  8.85128602e-02f, 4.44358066e-02f, -6.80525526e-02f, 9.60912779e-02f, 6.80957958e-02f, -1.86891571e-01f, -3.33257280e-02f, 1.31030291e-01f, 1.10874176e-01f, 1.10105462e-01f,
  1.20138988e-01f, 2.39403427e-01f, -1.47277070e-02f, 1.27174780e-01f, 5.77744767e-02f, -2.31095087e-02f, 1.61168858e-01f, -8.40929598e-02f, -2.00863212e-01f, 1.17729358e-01f,
  8.06134492e-02f, -5.63752837e-03f, -2.88678855e-01f, 1.91054195e-01f, -4.95389253e-02f, 1.14694260e-01f, 7.22811520e-02f, -5.34163974e-02f, -3.60900238e-02f, -3.41042988e-02f,
  -1.79773234e-02f, -8.88188928e-02f, 2.03294247e-01f, 3.70926410e-02f, 1.62320390e-01f, 2.55881380e-02f, -4.33488637e-01f, -3.70699018e-02f, 7.16064051e-02f, -5.86041696e-02f,
  5.91662787e-02f, 1.66131720e-01f, 6.71447590e-02f, -4.82237339e-02f, 2.52292422e-03f, 9.40751359e-02f, -2.23979563e-01f, -1.44871771e-02f, 1.34035215e-01f, 5.17609902e-02f,
  5.90184405e-02f, 1.55819997e-01f, -6.57708272e-02f, 1.25428483e-01f, 1.01580054e-01f, 2.58001804e-01f, 1.92038920e-02f, -5.04247956e-02f, -1.04643822e-01f, 5.29678538e-02f,
  -1.44417398e-02f, -1.72591999e-01f, -1.27197921e-01f, 7.25286081e-02f, 1.06322974e-01f, -1.14443794e-01f, 4.84764986e-02f, 7.66075477e-02f, 1.05271488e-02f, -4.07481603e-02f,
  -1.15526460e-01f, -1.85963158e-02f, -1.77035317e-01f, -2.11616121e-02f, 6.52973577e-02f, -1.33788854e-01f, -5.44326231e-02f, -9.75321233e-02f, -8.29558969e-02f, 1.33718282e-01f,
  3.07786260e-02f, -1.56479985e-01f, 1.86266601e-01f, 2.06570804e-01f, -1.21465378e-01f, -1.88116208e-01f, -5.21315224e-02f, 3.12769338e-02f, 1.23749509e-01f, -4.46580127e-02f,
  -2.85997003e-01f, 7.20311403e-02f, 1.52299955e-01f, 3.07735771e-01f, 3.55264634e-01f, 4.99858819e-02f, -2.08584398e-01f, 9.82490703e-02f, 2.41850376e-01f, 4.90118526e-02f,
  1.45345375e-01f, -2.77225766e-02f, -8.25743899e-02f, 1.95086524e-01f, -8.35840255e-02f, -2.33618155e-01f, 8.44111852e-03f, -4.60784920e-02f, 2.25519072e-02f, -2.44716741e-02f,
  7.02784583e-02f, -2.34860644e-01f, 8.94047469e-02f, 1.01389170e-01f, 1.17613755e-01f, -1.68717615e-02f, -9.55240205e-02f, 7.03778863e-02f, -2.51405984e-02f, 4.35836380e-03f,
  5.97699033e-03f, -5.32993674e-02f, -1.02314204e-01f, -3.50044034e-02f, -1.38609543e-01f, -1.67276755e-01f, -1.03612393e-01f, 1.65695138e-02f, -2.51905639e-02f, -8.03368017e-02f,
  7.56411487e-03f, -2.97363196e-02f, -2.30054200e-01f, -9.53660682e-02f, -1.93626419e-01f, -3.35180876e-03f, -4.39743064e-02f, 5.85024543e-02f, 9.96432379e-02f, -5.19505665e-02f,
  1.27121648e-02f, 1.02931201e-01f, -5.68487793e-02f, -1.02371693e-01f, -1.47623390e-01f, -1.04188845e-01f, -2.78159082e-01f, -2.77912587e-01f, -1.80432484e-01f, -4.16715331e-02f,
  -1.75133541e-01f, -3.76014888e-01f, -1.05951265e-01f, -1.07787080e-01f, 3.85494903e-02f, -2.37418264e-01f, -6.77233934e-02f, -3.78556043e-01f, 2.34283861e-02f, -2.80463427e-01f,
  2.66307175e-01f, 2.00778514e-01f, -4.54497300e-02f, -3.18870367e-03f, -2.38770992e-01f, -1.77805662e-01f, -1.18559644e-01f, -1.95239648e-01f, -6.41499609e-02f, 8.66945237e-02f,
  -1.04755245e-01f, -5.43549145e-03f, 9.86300036e-03f, 1.54691517e-01f, -2.66819090e-01f, -2.34567598e-02f, -2.96098888e-02f, 2.20328271e-02f, 2.01557856e-02f, 1.53005838e-01f,
  -7.83069953e-02f, 1.15958966e-01f, 3.34617309e-02f, 2.25196704e-01f, 3.29142772e-02f, -4.76080552e-02f, 4.32844572e-02f, 4.49591130e-02f, 1.08584417e-02f, 2.83036493e-02f,
  2.39360873e-02f, -9.34388265e-02f, -8.84736255e-02f, 2.12618448e-02f, 6.07543662e-02f, -4.60052229e-02f, -8.87518078e-02f, 4.25754115e-02f, -1.15774646e-01f, -8.67246538e-02f,
  -3.68479639e-02f, 8.43716636e-02f, 1.01772837e-01f, 1.07743531e-01f, -9.44483578e-02f, 6.77061528e-02f, 1.24542184e-01f, 1.04743779e-01f, 3.44295539e-02f, -3.04474123e-02f,
  8.84297639e-02f, -8.42400938e-02f, -9.03009772e-02f, 7.93612301e-02f, -3.47299092e-02f, 4.89219278e-02f, 9.79714319e-02f, 1.38411984e-01f, -1.09727815e-01f, -8.19212198e-02f,
  1.48502693e-01f, 5.80867827e-02f, 8.42818394e-02f, -1.10133201e-01f, -1.18256815e-01f, 2.64166713e-01f, 1.04553029e-01f, -1.30373165e-01f, -2.21868038e-01f, 4.72208392e-03f,
  -1.14257615e-02f, 4.35548574e-02f, -2.05276638e-01f, 1.00216158e-01f, 3.42475027e-02f, 8.45368430e-02f, -1.31873906e-01f, -2.63665225e-02f, 2.46881470e-02f, -1.50220580e-02f,
  1.06755249e-01f, 3.50075439e-02f, 1.82140172e-01f, 7.97660127e-02f, 1.08519837e-01f, 5.78178093e-03f, 7.15938359e-02f, 1.05132982e-01f, 1.10715933e-01f, 5.52926362e-02f,
  1.31104320e-01f, -4.62008491e-02f, 1.15055509e-01f, -1.52589437e-02f, 9.11003947e-02f, 1.19866863e-01f, 6.78151250e-02f, -7.25125521e-02f, -1.14453278e-01f, 3.00698057e-02f,
  1.55388981e-01f, -6.75352365e-02f, -6.85215753e-04f, 1.26887664e-01f, 8.36999193e-02f, -5.43313026e-02f, 5.19741587e-02f, 8.94673020e-02f, 6.83254898e-02f, 1.07250661e-01f,
  -2.35214755e-02f, -3.49233113e-02f, 1.89052686e-01f, -7.71244764e-02f, 4.07253439e-03f, -9.33167189e-02f, 2.19452173e-01f, 3.94578744e-03f, -1.62697554e-01f, 7.40733668e-02f,
  -1.57640591e-01f, -5.89407571e-02f, 9.00266692e-02f, 9.15416628e-02f, 7.54749626e-02f, -2.20411271e-01f, -7.08310828e-02f, -1.70165420e-01f, -7.79278129e-02f, 9.64136571e-02f,
  -4.22940180e-02f, -2.38816321e-01f, -2.46714368e-01f, 6.07330762e-02f, -5.49153760e-02f, -4.94582765e-02f, -5.44837229e-02f, 4.75089904e-03f, -1.15415625e-01f, 1.81067288e-01f,
  2.76301336e-02f, -3.67822424e-02f, -1.54279172e-02f, 7.04739541e-02f, -2.15807986e-02f, 1.78372428e-01f, 8.15289468e-02f, 1.00556314e-01f, -1.40638545e-01f, -8.47705156e-02f,
  -6.65901527e-02f, -6.06598854e-02f, -1.96323588e-01f, -1.37322262e-01f, 1.33099601e-01f, 6.02528118e-02f, 8.97259116e-02f, -1.81604177e-02f, 7.99826980e-02f, 3.37926038e-02f,
  -9.47975367e-02f, -1.85823962e-02f, 7.42775723e-02f, 8.28726068e-02f, 2.10293859e-01f, -1.32968098e-01f, 4.35192697e-02f, -1.26074642e-01f, 4.62037027e-02f, -4.21537496e-02f,
  -3.35062295e-02f, -8.17515254e-02f, -3.90589908e-02f, -1.09322615e-01f, -7.24158138e-02f, -4.78411801e-02f, -1.03658242e-02f, 1.34496942e-01f, 1.45843118e-01f, -1.36380360e-01f,
  2.05776721e-01f, 1.68151692e-01f, 2.12572053e-01f, -1.66995659e-01f, 2.29381258e-03f, -3.93913575e-02f, 2.27404207e-01f, 1.08655818e-01f, 4.00001816e-02f, -6.68853968e-02f,
  -1.05999731e-01f, -1.07228383e-01f, -1.29087254e-01f, -1.01029076e-01f, -9.96160358e-02f, -1.47623038e-02f, 1.10343620e-01f, 1.92434597e-03f, 1.96539164e-01f, -1.41894311e-01f,
  3.34517248e-02f, -2.66319904e-02f, 4.85610254e-02f, 1.08678371e-01f, -7.96901584e-02f, -1.07621841e-01f, -4.61358353e-02f, 6.08744323e-02f, -7.66193569e-02f, 6.85879141e-02f,
  6.71697930e-02f, 4.48790044e-02f, 2.91405827e-01f, -1.27542451e-01f, 3.25969718e-02f, 6.86408058e-02f, -3.35921049e-02f, -6.18066899e-02f, 3.01693026e-02f, -1.70456067e-01f,
  -5.28538860e-02f, 1.24067336e-01f, -1.26378477e-01f, 1.17441356e-01f, -6.01158738e-02f, 4.15871888e-02f, -5.05164219e-03f, 9.87466425e-02f, -2.54629715e-03f, 2.50051524e-02f,
  1.21538326e-01f, 1.17179975e-01f, -3.17396149e-02f, -2.62750126e-03f, -2.42507458e-02f, 5.76389730e-02f, -6.08085096e-02f, 8.38746801e-02f, -7.07105100e-02f, -2.61975732e-02f,
  4.74283248e-02f, 8.25345889e-02f, 1.14199810e-01f, -4.13987450e-02f, -1.97358102e-01f, -9.44646299e-02f, 9.90630090e-02f, 3.55261452e-02f, 8.67261961e-02f, 7.77361020e-02f,
  -2.71220654e-01f, 1.78616583e-01f, 5.06456569e-02f, 1.38477892e-01f, -1.55065745e-01f, -2.80313175e-02f, -2.94560760e-01f, 1.01370208e-01f, 9.08537861e-03f, -1.83127727e-02f,
  1.57960237e-03f, 1.33033693e-01f, -1.82243884e-01f, -3.44510190e-02f, -2.34724909e-01f, -1.07153542e-01f, 8.02808478e-02f, -5.22130094e-02f, -3.00787447e-04f, -3.54710110e-02f,
  1.75691679e-01f, 1.83982134e-01f, 1.52204335e-01f, 1.05165862e-01f, 9.87239331e-02f, -1.45861998e-01f, 1.30133867e-01f, -6.27719685e-02f, 1.02743827e-01f, -1.60364747e-01f,
  1.37904048e-01f, -3.13544944e-02f, -7.56576210e-02f, 9.89561006e-02f, -1.70063525e-01f, 8.50726366e-02f, -7.19384253e-02f, 1.31446689e-01f, -9.88439540e-04f, 4.96505573e-02f,
  2.82745827e-02f, -6.67717233e-02f, -1.40468553e-01f, -1.49381444e-01f, 1.60300374e-01f, -7.05449730e-02f, -4.47959304e-02f, 2.49075666e-02f, -1.36606425e-01f, -1.99225366e-01f,
  4.03475761e-02f, -5.22260852e-02f, -6.55655339e-02f, 1.40643433e-01f, -1.45973831e-01f, 1.08940825e-01f, -8.25905949e-02f, -1.02172792e-01f, -7.97873884e-02f, -5.78979626e-02f,
  -2.39929095e-01f, -4.31745276e-02f, 2.30407029e-01f, -1.08808748e-01f, -1.12114981e-01f, 1.96251959e-01f, -7.33596385e-02f, -4.60827574e-02f, 3.61093402e-01f, -5.82606122e-02f,
  1.26113882e-03f, 1.68684438e-01f, 9.50339511e-02f, -3.62971500e-02f, -1.80907249e-01f, 1.76024690e-01f, -1.79288983e-01f, 2.09641114e-01f, -1.47452086e-01f, -2.09075809e-01f,
  -1.29482672e-01f, 9.30828899e-02f, -1.11545108e-01f, -1.49893776e-01f, -1.65057313e-02f, 1.41198980e-03f, -2.09034771e-01f, 1.05381437e-01f, 2.65283406e-01f, 5.98654114e-02f,
  -2.96720386e-01f, -6.76682070e-02f, 6.66515902e-02f, -1.07088409e-01f, -3.96401854e-03f, -7.46698305e-02f, -1.59791008e-01f, 6.86826110e-02f, 7.57275075e-02f, 4.77847792e-02f,
  -9.66389254e-02f, 6.91487119e-02f, -1.12629764e-01f, -1.14993289e-01f, -1.07090630e-01f, -1.07050039e-01f, 1.84526891e-01f, -2.17770502e-01f, -1.76297322e-01f, 2.10053727e-01f,
  1.43957108e-01f, -1.01248100e-01f, -1.66441932e-01f, 1.76606312e-01f, -4.73140515e-02f, -1.95616886e-01f, -1.61940679e-01f, -1.27280965e-01f, 5.30736856e-02f, -3.03172529e-01f,
  -1.82296604e-01f, 1.87149927e-01f, 7.55360201e-02f, 7.76841715e-02f, 1.98905408e-01f, -1.23142287e-01f, -1.68472722e-01f, -9.97437462e-02f, 1.64002910e-01f, -2.73688823e-01f,
  -6.76483363e-02f, 1.45298094e-01f, -2.83933058e-02f, -2.74094865e-02f, 7.84259886e-02f, -2.50632256e-01f, -2.87030905e-01f, -1.05114371e-01f, 4.54604216e-02f, -3.28324467e-01f,
  2.16754884e-01f, 8.69264007e-02f, 1.98846400e-01f, -9.45799649e-02f, 1.05166687e-02f, 1.09694615e-01f, 6.56155124e-02f, 5.83340824e-02f, -1.02588594e-01f, 4.51242464e-04f,
  9.21024904e-02f, -9.57785100e-02f, -6.69059455e-02f, 5.99933825e-02f, 7.01035857e-02f, 1.26976207e-01f, 1.17070295e-01f, -5.95238209e-02f, 1.12733454e-01f, -5.77307539e-03f,
  3.62071767e-02f, 1.20780453e-01f, -1.55204967e-01f, 5.28511442e-02f, -4.55517136e-02f, 1.81580871e-01f, 3.56962159e-02f, -8.14079195e-02f, -2.22516954e-02f, -1.00820209e-03f,
  -1.04790434e-01f, 2.13984251e-01f, -1.09677486e-01f, 1.69143139e-03f, -6.86047748e-02f, 1.24274217e-01f, -1.46947708e-02f, -1.43885687e-01f, -3.89352255e-02f, 7.96611458e-02f,
  -7.21601546e-02f, -4.27956413e-03f, -5.45055196e-02f, -5.49118556e-02f, -6.72929436e-02f, -1.08886123e-01f, -1.63506150e-01f, -9.45960358e-02f, -1.55103236e-01f, 1.81474239e-02f,
  -1.43656433e-02f, 9.33337305e-03f, 2.36896463e-02f, 1.29976779e-01f, -1.16787441e-01f, -1.08468972e-01f, 1.54002383e-01f, -2.09894538e-01f, 7.75375888e-02f, 1.65101826e-01f,
  2.48057246e-01f, -1.49925485e-01f, -1.64276302e-01f, 1.20619945e-01f, -2.16501206e-01f, -1.23521999e-01f, 6.12957925e-02f, 7.72877559e-02f, -9.76531208e-02f, 7.97116011e-02f,
  -7.83613995e-02f, 4.33859900e-02f, -5.57044186e-02f, -6.73499033e-02f, -2.05960963e-02f, -6.52902424e-02f, 2.35567346e-01f, 9.14793983e-02f, -2.51312345e-01f, 9.69827771e-02f,
  -1.14449359e-01f, 8.76294151e-02f, -1.67014793e-01f, -5.77643290e-02f, 1.94956228e-01f, 7.48729780e-02f, 1.02006353e-01f, -3.41185965e-02f, 2.11090684e-01f, -8.39111581e-02f,
  1.18149750e-01f, 8.10377821e-02f, 3.19310538e-02f, -7.41286799e-02f, 2.37211093e-01f, -8.83181766e-02f, -3.51918377e-02f, 2.51262095e-02f, 9.83182862e-02f, 5.49247973e-02f,
  -9.59777534e-02f, -1.05927944e-01f, 9.92485434e-02f, 1.80007219e-01f, 1.52679816e-01f, -3.17886658e-02f, -4.04334590e-02f, 5.01568094e-02f, 2.63206303e-01f, 1.05094664e-01f,
  -1.92487270e-01f, -7.00988173e-02f, -5.25968447e-02f, 4.20897126e-01f, 1.55173108e-01f, 2.37329170e-01f, 1.31738067e-01f, -9.98186246e-02f, 2.30668306e-01f, 3.82393986e-01f,
  -5.84233664e-02f, -1.02764359e-02f, -1.02542691e-01f, 2.88528036e-02f, 2.95553237e-01f, -3.43620069e-02f, -5.82417920e-02f, -1.40330642e-01f, 9.94972065e-02f, -1.85867608e-01f,
  -1.90648183e-01f, 2.42585897e-01f, 5.94031252e-02f, -1.88960899e-02f, -4.71111108e-03f, 1.08141471e-02f, 1.19751342e-01f, 1.70723628e-02f, 2.22102534e-02f, -8.55974108e-02f,
  1.03881128e-01f, 6.73820898e-02f, 4.09027860e-02f, 2.67145783e-02f, -5.75624108e-02f, 2.45870277e-01f, 8.27034353e-04f, -3.03184316e-02f, -1.13150291e-01f, -1.33185387e-01f,
  -6.33539930e-02f, -2.10433245e-01f, -6.01012558e-02f, -8.03172514e-02f, -6.73917308e-02f, -5.15333191e-02f, 9.98443291e-02f, 1.34329237e-02f, 9.98576730e-02f, 6.23641014e-02f,
  -1.58676952e-01f, -3.73873562e-02f, -5.53903356e-02f, -2.33722404e-02f, -1.56681240e-01f, 1.07254349e-01f, 1.39685079e-01f, 2.36635115e-02f, -2.14755516e-02f, -7.85100758e-02f,
  -3.46729532e-02f, -1.69424638e-01f, 1.94388047e-01f, 3.59409988e-01f, -6.80223554e-02f, -1.36352137e-01f, 2.06583008e-01f, 1.17196053e-01f, 9.85544994e-02f, -1.19848594e-01f,
  -1.63379237e-01f, -5.48426993e-02f, 1.69449553e-01f, 3.90311301e-01f, 7.05926120e-02f, 2.14721873e-01f, -4.92224935e-03f, -5.20592630e-02f, 1.08400188e-01f, 1.57594904e-01f,
  2.38847286e-01f, -1.63872883e-01f, 7.37981498e-02f, 1.09844722e-01f, -8.99465084e-02f, -1.18716612e-01f, -8.25941712e-02f, -1.36170670e-01f, -5.74261956e-02f, 8.82856920e-02f,
  1.94246292e-01f, -8.73917192e-02f, 1.45740986e-01f, -3.00429910e-02f, 1.74829170e-01f, -1.93851486e-01f, -6.90780878e-02f, 1.00924894e-01f, -1.08433723e-01f, -1.69753194e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.90056488e-02f, 7.01749464e-03f, -8.41214061e-02f, 1.34262532e-01f, -7.81493634e-02f, -6.59420043e-02f, 6.91634193e-02f, 1.24357402e-01f, 4.56542633e-02f, -7.50105605e-02f,
  6.98444173e-02f, 5.90362251e-02f, 1.37105361e-01f, -5.70990564e-03f, -1.33950010e-01f, -6.72233701e-02f, 1.52799129e-01f, -1.20516680e-03f, -2.27173157e-02f, 9.50418189e-02f,
  1.16462391e-02f, -1.24263167e-01f, -5.81850149e-02f, -1.70329644e-04f, -7.73082823e-02f, -1.79530680e-01f, -6.04877099e-02f, -8.35259855e-02f, 2.06209812e-02f, -5.55856153e-02f,
  4.43564989e-02f, 4.31720503e-02f, -1.56105936e-01f, 3.98541540e-02f, -6.57909065e-02f, -9.20988917e-02f, -1.33898988e-01f, 5.21744266e-02f, 1.19449282e-02f, 2.84305550e-02f,
  -1.01618990e-01f, -9.33853537e-02f, -3.59510668e-02f, -1.03502929e-01f, -1.77810190e-03f, -5.86471595e-02f, 1.29593909e-01f, -1.08867109e-01f, 1.32997558e-01f, -5.05985618e-02f,
  1.04561329e-01f, 7.29741305e-02f, -4.89175208e-02f, -1.10388309e-01f, -6.63031787e-02f, -3.87079380e-02f, 2.15729736e-02f, 9.03063547e-03f, -6.40401915e-02f, 1.18154153e-01f,
  -3.34091596e-02f, 1.02165826e-01f, -2.69975606e-02f, 1.58604234e-03f, 8.16675797e-02f, 4.04279530e-02f, 3.51907387e-02f, 1.17123663e-01f, 1.22644402e-01f, -3.66797820e-02f,
  9.63837728e-02f, -3.92352231e-02f, -8.25321004e-02f, 2.25139186e-02f, 8.07346031e-02f, 1.13929190e-01f, -7.41290897e-02f, -6.88637746e-03f, -7.88505450e-02f, 1.16213039e-01f,
  -2.42550820e-02f, -4.90500331e-02f, 3.55973504e-02f, 1.71174765e-01f, 1.86787173e-01f, -3.65939140e-02f, 8.62304643e-02f, 9.87345874e-02f, -1.94844436e-02f, 1.99674796e-02f,
  -5.57405725e-02f, -3.34133133e-02f, 4.65864576e-02f, 3.04469150e-02f, -3.52937588e-03f, -1.78706497e-01f, -1.75221190e-01f, -1.67488143e-01f, 3.71600352e-02f, -1.21850066e-01f,
  4.95773405e-02f, -2.02099577e-01f, 1.18605504e-02f, -1.30265653e-01f, 1.37882248e-01f, -1.04309820e-01f, -7.51759410e-02f, -1.04457967e-01f, 6.78065494e-02f, -6.55841827e-02f,
  -3.31153795e-02f, 1.46287736e-02f, 1.65820539e-01f, -9.90447327e-02f, 6.23035096e-02f, -6.42588586e-02f, -4.30715717e-02f, -9.24096256e-03f, -9.76698250e-02f, -1.34379091e-02f,
  6.90207556e-02f, -1.38947174e-01f, -2.85359714e-02f, -4.88186628e-02f, -5.38184075e-03f, 5.91981374e-02f, -1.04330197e-01f, -9.03429016e-02f, 4.31198068e-02f, -6.72637969e-02f,
  5.15597835e-02f, 5.51300161e-02f, 3.23585346e-02f, 4.53897901e-02f, 1.53731359e-02f, 1.73332214e-01f, 9.98619422e-02f, 9.53228250e-02f, 1.57782406e-01f, -1.90654639e-02f,
  1.00771874e-01f, 1.30672649e-01f, 3.26988250e-02f, 1.77117258e-01f, 6.51901662e-02f, 1.38391808e-01f, 1.02671869e-01f, 1.79127112e-01f, 2.45910376e-01f, 1.13600545e-01f,
  -1.57894865e-02f, 1.43754244e-01f, 1.54162154e-01f, -1.40895531e-01f, 1.14580676e-01f, 2.28820711e-01f, -1.26229972e-01f, -1.84157357e-01f, -4.24588025e-02f, -2.18148127e-01f,
  -1.46187812e-01f, -2.50246525e-01f, -1.60878807e-01f, 3.02939191e-02f, 6.81916028e-02f, 8.99694487e-02f, -2.06431653e-02f, 5.36276214e-02f, -1.32822156e-01f, 5.59309199e-02f,
  -3.74909975e-02f, 1.86318055e-01f, 4.22950685e-01f, -1.27235979e-01f, -5.60143366e-02f, -1.85597166e-02f, 1.38550311e-01f, -2.57581860e-01f, 5.88435068e-05f, -1.59777269e-01f,
  1.24761254e-01f, 1.16840482e-01f, 1.87367871e-01f, 1.28478497e-01f, 1.12595700e-01f, 5.93584664e-02f, 2.36050412e-01f, 3.03471014e-02f, 1.50540441e-01f, 5.88624440e-02f,
  -4.15161885e-02f, -2.27175415e-01f, 2.30921749e-02f, -1.51299862e-02f, -5.78142963e-02f, -6.47800937e-02f, 1.76225439e-01f, 8.71647671e-02f, 9.57911238e-02f, 1.01911746e-01f,
  1.25651918e-02f, 1.61636665e-01f, 3.25974412e-02f, 1.01908281e-01f, 1.01330683e-01f, -1.33805692e-01f, 1.70419291e-01f, -4.35952023e-02f, 5.88874705e-02f, 1.21870935e-02f,
  -4.48556915e-02f, 3.93352658e-02f, 7.90141299e-02f, -2.09088493e-02f, 1.97608620e-02f, 1.01097561e-01f, -3.31604034e-02f, -2.46186897e-01f, 1.14916116e-02f, 1.35403112e-01f,
  2.54856050e-01f, -5.29181771e-02f, 1.36294827e-01f, 6.82549775e-02f, -2.70072948e-02f, -1.75700769e-01f, 9.22362134e-03f, 6.26475215e-02f, -1.43513530e-01f, -6.89074695e-02f,
  2.08037049e-01f, 1.62501857e-01f, 2.14335799e-01f, -3.37154008e-02f, -2.47322798e-01f, 7.76441023e-02f, -8.71749520e-02f, -1.29305735e-01f, 2.82005817e-01f, 1.46383435e-01f,
  1.80467188e-01f, -2.45673716e-01f, -3.11202779e-02f, 2.73034662e-01f, 4.06609885e-02f, -5.36894612e-02f, 8.57916847e-02f, -1.36733943e-04f, -1.52210206e-01f, -2.44490616e-02f,
  3.13605368e-02f, -1.18947374e-02f, 9.76106599e-02f, 1.18462540e-01f, 3.23101021e-02f, -7.62712955e-02f, 3.17001373e-01f, 1.30469739e-01f, 1.21547095e-01f, 1.88380733e-01f,
  -5.11152036e-02f, 2.25970060e-01f, 2.13833869e-01f, 6.46717250e-02f, 4.27199416e-02f, 1.06843850e-02f, 2.17835635e-01f, 1.10856682e-01f, 1.57995895e-01f, 2.58364767e-01f,
  2.53584296e-01f, -1.44373626e-01f, 1.52313396e-01f, 2.08966240e-01f, 1.25619084e-01f, -1.23683922e-01f, 9.65706035e-02f, 1.98189870e-01f, 2.11907566e-01f, 2.37896010e-01f,
  2.68215626e-01f, 4.28590536e-01f, 1.83188617e-01f, -1.79942563e-01f, -1.84502602e-02f, 1.71198994e-02f, 4.99551594e-02f, 2.88516939e-01f, 8.26822445e-02f, 2.60055512e-01f,
  2.06368021e-03f, 3.42306972e-01f, 9.83497351e-02f, -7.11803883e-02f, -9.17875841e-02f, 1.32455170e-01f, -7.81585500e-02f, 2.35234704e-02f, 1.64417803e-01f, 1.13700228e-02f,
  1.40394688e-01f, 4.77665544e-01f, -1.53948739e-02f, -3.16549130e-02f, -1.42387748e-01f, 1.99865729e-01f, -8.28598216e-02f, -4.87832688e-02f, 2.34318689e-01f, 8.74943286e-02f,
  4.72196713e-02f, 4.75173257e-02f, 1.88942142e-02f, 1.48916528e-01f, -9.60397273e-02f, -8.65473226e-03f, -1.58447370e-01f, -1.20317437e-01f, -8.27584192e-02f, -1.98721379e-01f,
  6.92062452e-02f, -5.13093732e-02f, 4.53067794e-02f, -1.04760751e-01f, 1.25170320e-01f, 7.75350705e-02f, 1.81810856e-01f, 2.59512067e-02f, 1.56572863e-01f, 6.24478273e-02f,
  4.18953560e-02f, -1.07137570e-02f, -1.31036732e-02f, 4.75011691e-02f, 1.32535651e-01f, -6.02298528e-02f, 1.02072582e-01f, 6.94762543e-02f, -9.28777754e-02f, -5.84280118e-02f,
  -2.28501204e-02f, 6.53956011e-02f, 6.89676628e-02f, 7.42968917e-02f, -8.70368704e-02f, -2.63966136e-02f, 1.29097715e-01f, 1.32033125e-01f, 5.90093853e-03f, -1.15776081e-02f,
  -2.82278331e-03f, 9.26282164e-03f, -6.84152395e-02f, 5.83463125e-02f, -2.57581566e-02f, 2.73824502e-02f, -8.16080719e-03f, 1.06784597e-01f, 5.77028021e-02f, 1.89829376e-02f,
  -1.90620981e-02f, -1.47073060e-01f, -1.02655273e-02f, 1.23252541e-01f, -1.32830227e-02f, 1.57328159e-01f, -2.84584425e-02f, -9.17864367e-02f, 7.84679428e-02f, 8.16750228e-02f,
  -9.57201645e-02f, 7.64041096e-02f, 3.58748995e-02f, -8.38640109e-02f, 1.23132639e-01f, 8.69476062e-04f, 1.36531457e-01f, -6.34060502e-02f, 3.15711275e-02f, 5.71389869e-03f,
  -3.68555523e-02f, 8.40440914e-02f, -8.36069360e-02f, -2.40945946e-02f, -1.31875798e-02f, 3.72915268e-02f, 1.49216071e-01f, -6.62140027e-02f, 2.33696073e-01f, 6.79384470e-02f,
  1.99291203e-02f, 1.18227378e-01f, 1.91775933e-01f, 4.04916070e-02f, 2.76969317e-02f, 2.61695590e-03f, 1.26426175e-01f, -7.77228624e-02f, 1.31564036e-01f, 2.11709231e-01f,
  1.32915219e-02f, 9.85299945e-02f, -1.65714622e-02f, 1.40079305e-01f, -1.17191151e-02f, 1.32114232e-01f, 2.03409314e-01f, -2.84008514e-02f, 6.46331012e-02f, -3.04843962e-01f,
  6.57937005e-02f, 9.20512229e-02f, 3.14456850e-01f, 9.07671452e-02f, -1.61524773e-01f, -1.09553663e-02f, -3.37045014e-01f, 5.95532916e-03f, 3.46394986e-01f, -2.08495021e-01f,
  1.13538571e-01f, 3.33533087e-03f, -1.59624025e-01f, -2.46891722e-01f, 1.32854357e-01f, -2.43801460e-01f, 1.10601587e-03f, -5.97354285e-02f, 2.37796362e-02f, -7.68854618e-02f,
  2.54622191e-01f, -2.31520161e-01f, 2.90598601e-01f, 1.39269352e-01f, -3.24671790e-02f, -4.05992679e-02f, -5.63616958e-03f, -1.86907612e-02f, 1.72522336e-01f, 1.24540791e-01f,
  -4.73803431e-02f, 2.83759879e-03f, -1.50078312e-01f, 6.13008514e-02f, 1.23257674e-01f, -1.19951896e-01f, -3.14061642e-02f, 4.57123183e-02f, 1.34279296e-01f, 7.67187625e-02f,
  -9.26366001e-02f, 3.26751694e-02f, 8.01116508e-03f, -8.52312148e-02f, 1.82847783e-01f, 2.04316765e-01f, 1.52581528e-01f, 1.96528763e-01f, 6.57012835e-02f, 7.35163465e-02f,
  1.42302483e-01f, 5.44536784e-02f, 8.30094144e-02f, 8.25131387e-02f, 4.39277403e-02f, 4.88042347e-02f, 1.35165676e-01f, 5.91102354e-02f, 1.44131973e-01f, 1.12214021e-01f,
  5.48028164e-02f, 2.55856484e-01f, 3.22974734e-02f, -1.44864440e-01f, -2.02674955e-01f, 2.03393534e-01f, -2.12893158e-01f, -1.88258812e-01f, -3.69516730e-01f, 2.27197155e-01f,
  1.38961270e-01f, 1.64834589e-01f, 5.04443469e-03f, -1.32294387e-01f, -8.03974941e-02f, 6.36486709e-02f, 1.36551663e-01f, -9.42184776e-02f, 2.67546117e-01f, 1.24152958e-01f,
  2.56707907e-01f, 8.55120420e-02f, -4.11345750e-01f, -2.17800379e-01f, -2.14017332e-02f, -1.14989735e-03f, -8.45914856e-02f, 6.44931942e-02f, -1.16287157e-01f, 1.29726887e-01f,
  -9.98882726e-02f, 8.56995396e-03f, -1.87020227e-01f, -8.63266364e-02f, -5.41730970e-02f, 3.06640491e-02f, 4.34698462e-01f, 1.31223276e-01f, -2.43209869e-01f, 1.23291630e-02f,
  8.68739262e-02f, 3.43640834e-01f, -1.55307380e-02f, 2.54042074e-02f, -2.36366630e-01f, -7.30742067e-02f, 6.77019879e-02f, 6.36703819e-02f, 2.28426844e-01f, -2.66469959e-02f,
  -5.67113012e-02f, 1.16642170e-01f, 2.02065989e-01f, 1.33005634e-01f, -5.13158459e-03f, -1.72500804e-01f, 8.48601162e-02f, 2.47698858e-01f, 2.15777829e-01f, -1.50624529e-01f,
  -8.41428861e-02f, 1.80597737e-01f, -2.07603630e-02f, 7.32348040e-02f, 7.41129518e-02f, 4.02566232e-02f, -1.24029934e-01f, -1.40254751e-01f, 7.38484114e-02f, 1.27999827e-01f,
  -1.64306536e-01f, 2.24143229e-02f, 2.55887117e-02f, 1.33057803e-01f, 8.98015201e-02f, 1.91069581e-02f, -2.22076789e-01f, -1.55752540e-01f, -1.61916435e-01f, 3.13187629e-01f,
  1.04738064e-01f, 1.72208190e-01f, -1.38748474e-02f, -1.99365601e-01f, -1.38866529e-01f, 2.61480510e-01f, -2.50938475e-01f, -2.59223491e-01f, 1.90746248e-01f, 2.59170890e-01f,
  -1.04352854e-01f, -1.48401260e-01f, 4.26657905e-04f, 1.07449755e-01f, -9.00037736e-02f, 1.96908310e-01f, -3.61050107e-02f, 3.91361080e-02f, -5.82996197e-03f, -2.25160550e-02f,
  2.34109178e-01f, 1.06610484e-01f, 8.31530169e-02f, 2.05664024e-01f, 1.70939952e-01f, 9.87003669e-02f, -1.62964035e-03f, -7.05848038e-02f, 6.42989576e-02f, -1.49190441e-01f,
  5.37196035e-03f, 1.23985447e-02f, -1.30378082e-01f, 7.54086301e-02f, 6.64476156e-02f, 7.63953179e-02f, 1.91274866e-01f, 7.89195672e-02f, 1.08747452e-01f, 2.54341125e-01f,
  -9.39065814e-02f, 4.20499034e-02f, 1.04791574e-01f, 2.51463279e-02f, -3.44213285e-02f, 2.26281658e-01f, 1.43648550e-01f, 1.27584919e-01f, 1.94277037e-02f, 1.34595037e-01f,
  1.25060886e-01f, -2.55667567e-01f, -5.14714234e-02f, -5.18626682e-02f, -1.28472164e-01f, -3.17443281e-01f, -1.06560238e-01f, -1.71196476e-01f, -1.76078856e-01f, -1.66239962e-01f,
  -1.11834221e-01f, 5.58952102e-03f, -1.18627973e-01f, -1.67562410e-01f, 3.98646146e-02f, -1.26015708e-01f, 2.04386532e-01f, -1.75997525e-01f, 1.17355317e-01f, -5.52250035e-02f,
  5.23723066e-02f, -2.38282666e-01f, -2.52222925e-01f, -1.58883259e-01f, 2.35449225e-01f, -6.53268844e-02f, -4.98020202e-02f, -2.66965389e-01f, 9.11636651e-02f, 8.07899758e-02f,
  1.22384526e-01f, -1.04077443e-01f, -2.00135764e-02f, -1.18968841e-02f, 2.13970378e-01f, 7.46787116e-02f, 1.06572911e-01f, 1.03430204e-01f, -2.22768951e-02f, 1.19048275e-01f,
  1.17725104e-01f, 3.35803740e-02f, 6.93035796e-02f, 5.56727275e-02f, 2.89706916e-01f, 2.18253091e-01f, 2.24681631e-01f, 6.11071624e-02f, 1.19481988e-01f, 3.34208943e-02f,
  2.20396772e-01f, 1.29661918e-01f, -3.11909220e-03f, 1.37773439e-01f, 1.67287197e-02f, 1.09823458e-01f, 1.25294834e-01f, 2.32497230e-01f, 1.41502216e-01f, 1.52585462e-01f,
  1.21438369e-01f, 1.25438020e-01f, 3.55817266e-02f, 1.33918554e-01f, 1.36575729e-01f, 5.56599116e-03f, 1.31780254e-02f, -2.49151006e-01f, -6.94910511e-02f, 1.62243843e-02f,
  -7.76881799e-02f, -1.28578663e-01f, -8.91503021e-02f, 2.05404729e-01f, 2.96959668e-01f, 3.34465280e-02f, -6.28530160e-02f, 5.82362413e-02f, -2.97693610e-01f, -3.66584137e-02f,
  -1.01255514e-01f, -1.58122495e-01f, 5.40625602e-02f, -7.02887699e-02f, -3.60695943e-02f, 1.96936235e-01f, 9.69829112e-02f, -1.17002361e-01f, -1.21164927e-03f, 3.62973690e-01f,
  3.56180742e-02f, -1.74370915e-01f, 1.86291829e-01f, 9.07685086e-02f, 2.78571486e-01f, 1.56142145e-01f, 1.83658406e-01f, 1.13878019e-01f, -3.54939938e-01f, -8.18238035e-02f,
  5.37908524e-02f, -3.47037613e-02f, -2.77091423e-03f, 1.97428718e-01f, -5.89931495e-02f, 7.96243176e-03f, -1.45876750e-01f, -1.53315775e-02f, 7.94611722e-02f, 1.07316755e-01f,
  1.87306598e-01f, 1.40203843e-02f, -1.95354111e-02f, 2.09782124e-02f, 1.42326072e-01f, 1.07829720e-01f, 1.40207797e-01f, -1.17197946e-01f, 6.31554872e-02f, 4.22531888e-02f,
  1.14671469e-01f, -5.38104288e-02f, 9.28782567e-04f, 9.40272212e-02f, -5.70160747e-02f, 5.23544811e-02f, -5.72400913e-02f, -6.78367317e-02f, 2.91323289e-02f, -1.48844838e-01f,
  1.16133094e-01f, 6.67766994e-03f, 1.28966108e-01f, -8.85650441e-02f, 1.52368158e-01f, -1.31883368e-01f, -1.58674136e-01f, 9.41875763e-03f, -2.55387723e-02f, -3.55830640e-02f,
  1.74361386e-03f, 1.46714956e-01f, 9.89865810e-02f, 1.43243857e-02f, -5.65634333e-02f, 2.13533919e-02f, -1.43382862e-01f, 9.96744633e-02f, 9.33832824e-02f, -6.58111125e-02f,
  5.68239167e-02f, 2.20498815e-01f, 1.83760121e-01f, -2.26899579e-01f, 6.96104616e-02f, 9.40164104e-02f, -9.64314044e-02f, 9.18221772e-02f, 1.97689548e-01f, 1.35245234e-01f,
  -1.04412153e-01f, -1.17507815e-01f, 8.24517906e-02f, -1.06028013e-01f, 1.14433130e-03f, 8.81069005e-02f, 9.16206166e-02f, -5.79531826e-02f, -1.16008483e-01f, -2.65655275e-02f,
  -1.58649296e-01f, 5.74889965e-02f, 1.58016369e-01f, 1.45635411e-01f, 1.09146215e-01f, 5.61380088e-02f, -1.25472629e-02f, -8.46860483e-02f, 8.19064081e-02f, 9.65045244e-02f,
  9.98634323e-02f, -4.55255099e-02f, -7.08762109e-02f, 9.87916663e-02f, 1.95411503e-01f, 1.72054563e-02f, -1.92898884e-02f, 2.11588651e-01f, -1.28453702e-01f, 2.44696047e-02f,
  -6.80687502e-02f, -9.01539177e-02f, 6.25254959e-02f, -1.65316492e-01f, -9.05821845e-02f, 1.20590948e-01f, -1.79823130e-01f, 4.54116240e-02f, 6.13072887e-02f, 1.97959676e-01f,
  -6.32092580e-02f, 2.22542316e-01f, -2.36930717e-02f, -1.85994059e-01f, -8.64466652e-03f, 3.08775663e-01f, -1.06554419e-01f, -1.76269159e-01f, -3.01862904e-03f, 8.06971081e-03f,
  -2.11713724e-02f, -1.21921197e-01f, -2.53859580e-01f, -2.66071528e-01f, 2.84367707e-02f, 6.57889619e-02f, 5.38245961e-02f, 4.38431986e-02f, 1.45501494e-01f, 3.21308337e-02f,
  -1.48346737e-01f, 1.30161107e-01f, -8.22368935e-02f, 5.07646650e-02f, 1.89021602e-01f, 1.64718166e-01f, 8.60169604e-02f, -6.48868829e-02f, 5.32368757e-02f, 8.36573914e-02f,
  1.76600307e-01f, 1.92012534e-01f, -7.95214847e-02f, 1.20159104e-01f, 7.82456994e-02f, 1.34730384e-01f, 1.12916581e-01f, -4.42909822e-02f, 7.32310116e-02f, 5.46542518e-02f,
  8.13200548e-02f, -4.11179923e-02f, 9.41565260e-02f, 2.03261197e-01f, 1.20253883e-01f, -3.66456434e-02f, 7.87466541e-02f, 2.37371027e-01f, 1.96152955e-01f, 3.25655192e-02f,
  -1.75478663e-02f, 1.38501570e-01f, 8.87161642e-02f, -2.52896473e-02f, 7.95308053e-02f, -2.62834281e-02f, 1.47874400e-01f, -4.48263556e-01f, 7.43766269e-03f, 3.07324499e-01f,
  -9.29994434e-02f, -2.35512137e-01f, -2.56804198e-01f, 6.90831766e-02f, -1.78399429e-01f, -4.13114950e-02f, 1.29204810e-01f, -2.11518690e-01f, -1.27938921e-02f, 2.03477636e-01f,
  3.19613010e-01f, -1.43438399e-01f, 1.40110582e-01f, -6.45947084e-02f, 2.03972116e-01f, 5.79984784e-02f, -9.64575708e-02f, -4.02949244e-01f, 1.15230389e-01f, 1.02166742e-01f,
  1.30989462e-01f, 3.62523505e-03f, -3.35918763e-03f, 1.08862363e-01f, -8.64239559e-02f, 9.33620781e-02f, 8.08678567e-03f, -1.33439139e-01f, 5.88438660e-02f, 1.18290216e-01f,
  2.80730635e-01f, 1.09707393e-01f, -8.07855576e-02f, 2.02649534e-01f, -3.66240361e-04f, 2.94001013e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -6.94583952e-02f, 6.02219254e-02f, 1.31630257e-01f, -6.46323711e-02f, 4.36019860e-02f, -9.79863852e-02f, 1.96103409e-01f, 1.63834363e-01f, 1.94061995e-01f, 1.35991096e-01f,
  2.29613781e-01f, 1.48092322e-02f, 6.51651621e-02f, 1.30341470e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.31532783e-02f, 2.92674035e-01f, 9.24307778e-02f, -2.24942416e-02f, 2.44532451e-01f, -2.82303035e-01f, -2.20458992e-02f, -6.43927678e-02f, 6.35899752e-02f, 5.10430150e-02f,
  -4.58226502e-02f, 1.11524701e-01f, 1.08087003e-01f, 2.93398798e-01f, 3.03564191e-01f, 2.89464712e-01f, 1.01014704e-01f, 1.76164702e-01f, 1.79549009e-02f, -7.76616409e-02f,
  6.34094998e-02f, -1.60822406e-01f, 1.65271625e-01f, -5.31199425e-02f, -1.79783136e-01f, -4.11092579e-01f, -1.90761805e-01f, -3.19412082e-01f, 4.68274653e-01f, 9.66816619e-02f,
  6.32671118e-01f, 5.34593999e-01f, 3.35628718e-01f, -2.42850140e-01f, -2.55725563e-01f, -4.65844870e-01f, -2.14252532e-01f, -1.11022480e-01f, -2.43212759e-01f, 1.55049235e-01f,
  4.70411777e-02f, 1.74802184e-01f, 1.51104689e-01f, -3.05648930e-02f, 2.48623356e-01f, 4.97475177e-01f, -4.87206131e-01f, 2.83176064e-01f, -6.15935266e-01f, -2.81455040e-01f,
  5.66056035e-02f, 1.26948049e-02f, 1.26642317e-01f, -1.86571658e-01f, 1.73497543e-01f, -4.50968258e-02f, -3.81695956e-01f, -3.34043711e-01f, -3.14562649e-01f, -1.31477326e-01f,
  1.04534604e-01f, 4.53862213e-02f, -5.02976663e-02f, -5.27763724e-01f, 1.72432229e-01f, -5.32226413e-02f, 9.53693613e-02f, -2.01088235e-01f, 7.94053897e-02f, 1.13828480e-01f,
  2.53897369e-01f, -2.48637408e-01f, 1.27874061e-01f, -1.25881076e-01f, -2.03262180e-01f, 1.02990501e-01f, -2.45760098e-01f, 3.12207580e-01f, 2.73209423e-01f, 4.72009927e-02f,
  1.97142996e-02f, 3.97329405e-02f, 9.46687683e-02f, 8.14285781e-03f, 1.88093968e-02f, 1.32169619e-01f, -1.32949511e-02f, 1.70085326e-01f, 3.50948781e-01f, -3.44426334e-01f,
  -5.50315797e-01f, 2.20052406e-01f, 1.57417312e-01f, -2.02077195e-01f, -7.62808025e-02f, -1.59664452e-01f, 2.32538775e-01f, -5.12073994e-01f, -2.18093023e-01f, -2.47251838e-01f,
  9.40330625e-02f, 6.48261094e-03f, 2.06880625e-02f, 2.03620061e-01f, 3.26088071e-01f, -6.53018756e-03f, -1.15531221e-01f, 3.64324031e-03f, -2.17575748e-02f, 1.83485106e-01f,
  -1.45780146e-01f, 3.30815077e-01f, -2.65232593e-01f, 8.95887539e-02f, 4.16983105e-02f, 1.82382882e-01f, 4.72737223e-01f, -2.74349712e-02f, -4.41865772e-01f, -7.96058103e-02f,
  -3.30524206e-01f, 2.83776402e-01f, -1.20896235e-01f, 6.74002647e-01f, -5.24750710e-01f, -1.96433440e-02f, -3.07920635e-01f, 1.73648000e-01f, -1.16397008e-01f, -1.38299093e-01f,
  6.43650666e-02f, -1.26272425e-01f, -1.50429644e-02f, -5.11845499e-02f, -2.86093682e-01f, -8.83498788e-02f, 4.36367001e-03f, -1.13125563e-01f, -2.28616431e-01f, 1.20688178e-01f,
  -1.35201188e-02f, -4.21745420e-01f, -7.87907615e-02f, 1.12291254e-01f, -3.14899981e-01f, -2.71671683e-01f, -8.07685107e-02f, 1.36553273e-02f, 2.77805291e-02f, 3.91163975e-02f,
  -1.19683057e-01f, -2.91632488e-02f, 1.42333731e-01f, 3.88052553e-01f, -3.64025593e-01f, -1.51526347e-01f, 1.26974940e-01f, -2.34285161e-01f, 6.74342830e-03f, -6.53668642e-02f,
  3.24239850e-01f, 1.22857936e-01f, 6.40139580e-02f, -1.95198834e-01f, -1.75701171e-01f, 6.26789182e-02f, 5.97437099e-02f, 2.59642422e-01f, -4.61807698e-02f, 2.17425302e-01f,
  1.96279630e-01f, -7.50039667e-02f, -7.28897527e-02f, 5.08637786e-01f, 9.03157517e-02f, 1.41996413e-01f, 3.91188532e-01f, 1.64841544e-02f, -1.06651716e-01f, -6.22880422e-02f,
  -1.25724092e-01f, 1.34793848e-01f, -3.24900180e-01f, -2.98937950e-02f, 1.22290086e-02f, 6.67882442e-01f, 2.44268611e-01f, -2.34005362e-01f, -5.84091365e-01f, -4.07360531e-02f,
  2.38859028e-01f, 4.61481005e-01f, 1.72027469e-01f, -4.89322275e-01f, 1.86385348e-01f, -2.83528000e-01f, -1.22253001e-01f, 4.83226515e-02f, -5.17391451e-02f, 1.59801707e-01f,
  1.26605421e-01f, 3.94200422e-02f, 2.44674221e-01f, 1.55900493e-01f, -1.00877963e-01f, 1.43512458e-01f, 1.79186314e-01f, -3.89981866e-01f, -8.46164525e-02f, 2.18829527e-01f,
  2.41874903e-01f, 2.77044177e-02f, -7.70629868e-02f, -2.43707880e-01f, 5.42070111e-03f, -2.82838762e-01f, 2.84278363e-01f, 1.74350534e-02f, 2.95646608e-01f, 8.92677829e-02f,
  -2.63804883e-01f, 2.91110516e-01f, -2.31098533e-01f, -2.49012828e-01f, -2.07575962e-01f, -6.13535196e-02f, 1.04729667e-01f, -1.35498002e-01f, 2.18741164e-01f, 4.93751764e-01f,
  -4.83617634e-01f, 3.36124450e-01f, -2.40293797e-02f, -6.27219230e-02f, -3.39217991e-01f, 9.64272395e-02f, 6.68086484e-02f, -3.04720819e-01f, -2.38817364e-01f, -3.11804146e-01f,
  2.57874370e-01f, 4.70922470e-01f, -5.84057625e-03f, -9.92794186e-02f, 2.09986851e-01f, -2.35204473e-01f, 5.75773895e-01f, 1.17039755e-01f, -2.13814840e-01f, -4.43691075e-01f,
  -2.84264058e-01f, -4.09825861e-01f, 1.02757946e-01f, 7.34727830e-04f, -3.19970012e-01f, -4.46228445e-01f, -5.86899221e-02f, -4.51911837e-02f, 2.22004861e-01f, 4.98761237e-01f,
  4.01132911e-01f, 1.66053087e-01f, 1.96772277e-01f, 1.08902432e-01f, -4.15539779e-02f, 2.32429072e-01f, 1.83985651e-01f, 2.64412642e-01f, 3.77840161e-01f, 2.13837996e-01f,
  4.13770834e-03f, -1.09804802e-01f, -6.54653907e-02f, -1.44396320e-01f, 3.11365053e-02f, -6.21556863e-03f, 2.21643865e-01f, -1.15595676e-01f, 2.09241539e-01f, 2.76129723e-01f,
  -4.06699218e-02f, 4.02567178e-01f, 3.71006459e-01f, 4.68593724e-02f, -4.67577018e-02f, 3.42499427e-02f, 2.85900354e-01f, 3.77391785e-01f, -1.42818406e-01f, 3.63517821e-01f,
  1.77867740e-01f, 2.55205095e-01f, 1.05106123e-01f, 1.04057208e-01f, 2.18244120e-01f, -2.86463320e-01f, -5.48991978e-01f, -1.69794206e-02f, 3.56342286e-01f, 1.57694444e-01f,
  3.17860603e-01f, 4.77822237e-02f, -2.90323675e-01f, 1.04914615e-02f, 2.80811518e-01f, -4.68799829e-01f, 2.10776851e-02f, -1.95825174e-01f, -1.69793710e-01f, -8.98836851e-02f,
  7.01973677e-01f, 3.48025188e-02f, -2.00186316e-02f, -7.19099715e-02f, -2.67415851e-01f, -2.48497993e-01f, 1.05510764e-01f, -1.48867577e-01f, -6.23789467e-02f, -4.50595319e-01f,
  2.37496108e-01f, 2.67453462e-01f, -5.59223676e-03f, -1.99574739e-01f, -2.97284573e-01f, 1.61834762e-01f, 2.55345315e-01f, -2.23215539e-02f, 2.78476059e-01f, 2.05773264e-01f,
  4.95827198e-01f, 3.98015641e-02f, -1.27818450e-01f, 7.89916236e-03f, -3.46726745e-01f, 3.05535376e-01f, 5.38498498e-02f, -7.29159638e-02f, 1.33253619e-01f, 1.13089748e-01f,
  2.94187367e-01f, 2.27584064e-01f, 2.60838926e-01f, 1.17910676e-01f, -3.34269643e-01f, 2.06383303e-01f, 1.59612104e-01f, -4.20170873e-02f, 5.51594615e-01f, -2.42442831e-01f,
  -8.39490518e-02f, 8.39036703e-02f, 2.51352400e-01f, -2.44909018e-01f, -4.83811200e-02f, 1.31580621e-01f, -7.73171037e-02f, -3.55603307e-01f, 2.29604423e-01f, -4.94646430e-01f,
  4.28957582e-01f, -2.16998786e-01f, 1.04409494e-01f, 3.77687737e-02f, -1.76883876e-01f, -3.84511709e-01f, 2.60012180e-01f, -1.43839061e-01f, -6.01778507e-01f, -3.74340951e-01f,
  -7.51427710e-02f, 3.78724366e-01f, 1.00210272e-01f, 1.07841507e-01f, -2.58886684e-02f, -1.37364432e-01f, 3.19239616e-01f, -1.87296465e-01f, -2.09913865e-01f, 1.88304082e-01f,
  2.30161861e-01f, -4.23131734e-02f, -1.24092899e-01f, -2.46967077e-01f, -3.20048571e-01f, 3.62466425e-02f, 1.01486882e-02f, 1.49946436e-01f, -1.32189319e-01f, -2.76174217e-01f,
  -1.97579592e-01f, 2.95208991e-01f, -3.16312104e-01f, -7.97006264e-02f, -5.03010824e-02f, 1.09680397e-02f, 4.75730672e-02f, -3.55186015e-01f, 8.60818475e-02f, 5.87361604e-02f,
  -3.28710750e-02f, -8.14631879e-02f, 8.99356976e-02f, -1.82108298e-01f, -1.84827164e-01f, 1.77722588e-01f, 1.91141274e-02f, -1.19911484e-01f, -7.93335885e-02f, 2.20009759e-01f,
  -1.37994066e-01f, 8.78408998e-02f, 2.81138159e-02f, -4.48812880e-02f, -3.91774476e-01f, -3.56683172e-02f, 1.26281783e-01f, 3.17469954e-01f, 1.73569173e-01f, 2.96858639e-01f,
  -2.52054259e-02f, -2.85276949e-01f, 6.43669590e-02f, -1.62130460e-01f, 1.58662930e-01f, 1.19313620e-01f, 1.65359214e-01f, -7.15167299e-02f, -2.16283947e-01f, -5.10881543e-01f,
  2.85744071e-01f, 1.97701797e-01f, 2.50127554e-01f, -1.09469108e-01f, 2.68695980e-01f, -1.26283700e-02f, -2.71511346e-01f, -2.64458090e-01f, -4.31733996e-01f, -7.81376362e-02f,
  4.61936772e-01f, 1.57746881e-01f, -2.60490179e-01f, 1.80311307e-01f, 2.21070826e-01f, -2.89169043e-01f, 4.40946221e-01f, 4.41562295e-01f, 8.69717300e-02f, 7.53704533e-02f,
  1.49826268e-02f, -1.52287498e-01f, -6.67748749e-02f, -2.14838535e-01f, -2.84677860e-03f, -2.82010198e-01f, 4.40411270e-02f, -1.42160192e-01f, -1.56634867e-01f, 3.45428810e-02f,
  -7.35090598e-02f, -3.13573927e-02f, 4.35895994e-02f, 1.94571823e-01f, -1.20693088e-01f, 1.60080194e-01f, 2.37092022e-02f, -1.16840094e-01f, -1.42836079e-01f, 1.98172733e-01f,
  6.44537508e-02f, -2.57866859e-01f, 7.31498301e-02f, 7.16978833e-02f, 2.99707800e-01f, -3.73603344e-01f, -3.90926927e-01f, 3.85163486e-01f, -3.08938265e-01f, 4.40836139e-02f,
  -3.30010146e-01f, 1.09306082e-01f, -3.82369816e-01f, 5.05669057e-01f, -4.40564424e-01f, 3.38867754e-01f, 2.49820486e-01f, -2.38822728e-01f, 6.93660975e-02f, 1.55687943e-01f,
  -3.00001115e-01f, 2.91690409e-01f, 2.54269660e-01f, -3.76234025e-01f, -1.38482764e-01f, -3.45989019e-01f, 2.41679505e-01f, -7.85428211e-02f, -9.66480821e-02f, -1.39737189e-01f,
  -1.57282040e-01f, -2.27982342e-01f, -2.50376701e-01f, -9.34648421e-03f, -1.03609644e-01f, -1.17207281e-01f, 4.20163065e-01f, -1.01025440e-01f, 2.63839245e-01f, -1.43889487e-02f,
  3.78495932e-01f, -1.53196067e-01f, -1.28495499e-01f, 6.33098036e-02f, -2.13368218e-02f, 2.72625145e-02f, 6.88088611e-02f, 7.99769387e-02f, 5.54398932e-02f, -1.93523303e-01f,
  1.18939415e-01f, 1.25317127e-02f, -1.62287295e-01f, -4.06001419e-01f, -2.55134225e-01f, 1.17584437e-01f, -2.56385445e-03f, -1.83358207e-01f, 1.03898577e-01f, 1.96590334e-01f,
  1.29951537e-01f, -1.29183888e-01f, 7.71804526e-02f, -4.11557227e-01f, -8.79750252e-02f, 2.17188269e-01f, 6.71408027e-02f, 1.14443928e-01f, -2.91149337e-02f, -2.24504754e-01f,
  -8.68327171e-02f, -5.55103496e-02f, -8.37855414e-02f, 9.98728350e-02f, 2.17367172e-01f, 8.27923939e-02f, 4.28888708e-01f, -2.54286170e-01f, 2.59694397e-01f, -2.80205131e-01f,
  1.52382748e-02f, 4.06978354e-02f, -2.64957488e-01f, -3.21763963e-01f, -1.15437098e-01f, 1.34863406e-01f, -2.90424854e-01f, -5.38952090e-02f, 5.49437821e-01f, -3.15383285e-01f,
  -4.54786628e-01f, 2.48440295e-01f, 2.20417961e-01f, 8.38800669e-02f, 8.13644677e-02f, 6.20579779e-01f, -2.45293394e-01f, 1.19027430e-02f, -7.26497769e-02f, -5.34993485e-02f,
  5.56666732e-01f, -2.25661039e-01f, -5.17729700e-01f, 4.38164234e-01f, 7.75963664e-02f, 2.30575308e-01f, -1.55637041e-01f, 1.69531032e-01f, -1.92687243e-01f, 4.29726839e-02f,
  1.41607016e-01f, 1.37185201e-01f, -1.22610874e-01f, -3.47869359e-02f, -1.04337975e-01f, -3.76149774e-01f, -6.11085296e-02f, 4.33230437e-02f, 1.10540450e-01f, -1.91825122e-01f,
  -3.31230052e-02f, 2.73584634e-01f, -1.03024878e-02f, 1.04733080e-01f, -3.87616344e-02f, 2.66788621e-02f, 2.23153189e-01f, -3.66146117e-01f, -1.57098994e-01f, 1.01063989e-01f,
  -4.35085863e-01f, 1.46905348e-01f, -5.48493207e-01f, 3.57395321e-01f, 1.01944506e-02f, -8.31913054e-02f, 1.61418736e-01f, -2.58122951e-01f, -5.42153955e-01f, 2.92143553e-01f,
  -2.16978908e-01f, 4.61232007e-01f, -3.72622669e-01f, 2.39373937e-01f, 1.95257545e-01f, -2.55050898e-01f, 2.93979913e-01f, -5.63049242e-02f, 1.52454779e-01f, 8.35391786e-03f,
  -4.76849824e-01f, 2.09772974e-01f, -4.00023431e-01f, 2.98706263e-01f, 4.75285612e-02f, -1.22246541e-01f, -1.43261582e-01f, 1.67097282e-02f, -5.29257298e-01f, -4.50122692e-02f,
  4.29506212e-01f, 1.28628209e-01f, -2.53763292e-02f, 4.89640772e-01f, -2.69264549e-01f, -9.22281574e-03f, 2.75228441e-01f, -7.77275786e-02f, -2.80048698e-01f, -5.80623038e-02f,
  1.00352116e-01f, 1.13363281e-01f, -2.86709696e-01f, 2.69018840e-02f, -2.22688429e-02f, 9.59050283e-03f, 9.15790536e-03f, 1.66121751e-01f, 1.09271836e-02f, -8.79123956e-02f,
  -2.78281718e-01f, -2.08014131e-01f, 2.37615973e-01f, -9.15303305e-02f, -2.61138558e-01f, -3.65698040e-01f, -7.77557418e-02f, 1.57314353e-02f, -3.15466195e-01f, -1.04140237e-01f,
  1.76034436e-01f, -1.83596089e-02f, -6.71811253e-02f, -6.03794679e-02f, -1.04530364e-01f, -3.20447594e-01f, 3.54365110e-01f, 2.04734400e-01f, -3.20372909e-01f, 3.59539211e-01f,
  1.66540399e-01f, -8.79091620e-02f, -1.68909505e-01f, -1.79310679e-03f, 8.27647522e-02f, -3.41379464e-01f, 1.18814617e-01f, 1.20082259e-01f, 1.73410237e-01f, 3.11588168e-01f,
  -3.00165266e-01f, -7.02665374e-02f, -1.79339185e-01f, -4.89992589e-01f, 2.79492080e-01f, 1.07948989e-01f, -6.96503371e-02f, -2.93292315e-03f, 2.48153493e-01f, 5.64964414e-01f,
  -3.39393057e-02f, -1.23236090e-01f, 3.79076630e-01f, -1.16639361e-01f, 1.75140917e-01f, 1.73672765e-01f, -2.34565452e-01f, 2.27242529e-01f, 3.61515373e-01f, 1.60981968e-01f,
  -6.33285046e-02f, 7.70340338e-02f, 1.50099441e-01f, 2.32846275e-01f, -5.24486788e-02f, -1.28155097e-01f, 3.43083590e-02f, -1.35348514e-01f, 1.53902238e-02f, -4.22209203e-01f,
  -1.84387282e-01f, 1.13935798e-01f, 4.07047123e-02f, 8.73359665e-02f, 1.57062739e-01f, -5.44851482e-01f, -6.04739077e-02f, 1.79441109e-01f, -3.95701639e-02f, -3.92482966e-01f,
  3.79809807e-03f, 3.55714038e-02f, -1.37551740e-01f, 1.16250455e-01f, -3.96484196e-01f, 1.72492146e-01f, -1.08716056e-01f, 1.46685606e-02f, 2.31542364e-01f, -1.70252979e-01f,
  2.47146189e-01f, 1.14128046e-01f, -3.76930058e-01f, -3.30059081e-01f, -3.30428898e-01f, -3.04623204e-03f, 1.71649735e-02f, -8.72972161e-02f, 8.36986750e-02f, 1.46961972e-01f,
  2.68995941e-01f, -2.86792964e-01f, -8.35451782e-02f, -1.40749425e-01f, -2.62920082e-01f, -1.97256684e-01f, 4.84119207e-02f, 3.20101440e-01f, -1.14007313e-02f, -2.09241152e-01f,
  2.58780807e-01f, -2.12251619e-01f, 7.10800439e-02f, 1.30489171e-01f, -1.05901822e-01f, 3.45425829e-02f, 3.40135157e-01f, 1.66356876e-01f, -8.30365196e-02f, 1.65826440e-01f,
  6.47516251e-01f, -5.04423678e-01f, -1.88947022e-01f, 6.55648187e-02f, 2.40464792e-01f, 2.32820138e-01f, -1.42820939e-01f, 3.54955271e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.02677846e-01f, 7.05594942e-02f, -5.67707270e-02f, 7.51708597e-02f, -3.07438057e-03f, -3.30731608e-02f, -1.15236618e-01f, 8.71705115e-02f, 3.24028805e-02f, -9.90945846e-02f,
  9.06309113e-04f, 1.66929886e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    