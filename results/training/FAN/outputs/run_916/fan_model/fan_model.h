/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.05696750e-02f, 2.24532381e-01f, 1.78948026e-02f, -1.09527364e-01f, 4.56042513e-02f, 2.63250411e-01f, 3.84890258e-01f, 8.15952420e-02f, -1.19303301e-01f, 1.41377479e-01f,
  -1.79893952e-02f, -8.89516696e-02f, 2.03240048e-02f, 9.66644287e-03f, 1.57022513e-02f, 1.93474621e-01f, 1.42090440e-01f, -7.81496894e-03f, -6.02424145e-02f, -9.51138213e-02f,
  -1.85899772e-02f, -1.54515907e-01f, -2.18394369e-01f, -2.24994682e-02f, 2.18968261e-02f, -6.78885505e-02f, 2.80357841e-02f, -5.03121465e-02f, 9.40065309e-02f, 2.64151543e-02f,
  1.15073107e-01f, -4.80049616e-03f, -2.40636151e-02f, -1.47998795e-01f, -1.16015270e-01f, 6.06445521e-02f, -3.44957933e-02f, -2.67143752e-02f, 3.27241570e-02f, -8.73666704e-02f,
  1.98451639e-03f, -1.77163873e-02f, 1.33691458e-02f, 9.21245571e-03f, -1.51781170e-02f, -2.58232467e-02f, 4.87065874e-02f, -1.04807742e-01f, 3.62376533e-02f, -8.83166119e-02f,
  6.34860015e-03f, 3.46825011e-02f, -6.60760775e-02f, 5.30386306e-02f, 5.88641316e-02f, -1.18994147e-01f, 5.50271533e-02f, -1.22949913e-01f, 4.46785986e-03f, -2.01525558e-02f,
  3.18698734e-02f, -5.71808079e-03f, -3.20277587e-02f, 2.84055583e-02f, 7.00127631e-02f, 7.06401095e-02f, -3.90959270e-02f, -6.33013155e-03f, 2.67364942e-02f, -4.44895178e-02f,
  3.21919248e-02f, 2.29292456e-03f, 5.72376093e-03f, 2.38580424e-02f, -8.89760777e-02f, 5.79947270e-02f, 4.72317869e-03f, 8.95453840e-02f, 2.95403460e-03f, -8.07001293e-02f,
  -3.68589722e-02f, 1.19592086e-03f, -7.68861622e-02f, -3.16620097e-02f, 7.56426975e-02f, -6.36106282e-02f, -2.19171494e-02f, -1.06026214e-02f, 2.85622478e-02f, -5.72985634e-02f,
  5.12058735e-02f, -6.26558363e-02f, 8.64255801e-02f, 1.80511363e-02f, -5.32205999e-02f, -6.09907508e-02f, 1.64630134e-02f, -8.73260349e-02f, -1.60747841e-02f, 5.93300117e-03f,
  -1.24645531e-02f, 3.13798450e-02f, 4.34875228e-02f, -4.41699252e-02f, -1.02804743e-01f, 6.75835684e-02f, 1.21484268e-02f, -8.70608538e-02f, 4.31423150e-02f, -5.97516261e-02f,
  1.25481576e-01f, 5.27946986e-02f, 1.27347395e-01f, 9.72193107e-02f, 6.82814270e-02f, 8.60691592e-02f, 1.84653535e-01f, 1.14957832e-01f, 1.88306302e-01f, 1.30321503e-01f,
  1.94647491e-01f, -2.70903885e-01f, -2.14021325e-01f, -8.80752578e-02f, -4.89831083e-02f, 1.53520912e-01f, 6.05283026e-03f, 1.64235979e-01f, 6.79794997e-02f, -7.00731296e-03f,
  -2.06874236e-02f, 1.13469191e-01f, 3.72069255e-02f, 1.42666698e-01f, 8.67259800e-02f, -6.67602569e-02f, -1.74426094e-01f, 8.82736072e-02f, 2.17654079e-01f, 2.68941969e-01f,
  9.38668475e-02f, 4.00704816e-02f, -1.12024993e-02f, -5.00520580e-02f, -1.23473376e-01f, -8.17437842e-02f, -2.27476388e-01f, -4.21524420e-02f, -1.76818982e-01f, -2.70443261e-01f,
  5.92361949e-02f, -1.48692191e-01f, 1.75072059e-01f, -8.08117688e-02f, -8.62548053e-02f, -1.72104128e-02f, -6.95480406e-03f, -4.34968397e-02f, -1.00285821e-01f, 2.42863744e-02f,
  -5.64798526e-02f, -6.13532588e-03f, -2.92995442e-02f, -1.19545981e-02f, -1.39629152e-02f, 1.54311076e-01f, -1.73581038e-02f, -2.06885990e-02f, -6.80665448e-02f, 8.28729197e-02f,
  -9.53874439e-02f, -2.99165417e-02f, 8.85002613e-02f, 1.21493503e-01f, 6.45561293e-02f, 4.89306897e-02f, -8.84446874e-02f, -1.64982844e-02f, 6.35292614e-03f, 5.01176640e-02f,
  -2.46028453e-02f, 3.88861299e-02f, 4.18457156e-03f, -1.00900559e-02f, 4.08422388e-02f, -2.60129198e-02f, -2.25079972e-02f, 4.17253189e-02f, 5.47780357e-02f, -2.65735369e-02f,
  2.20819339e-02f, 9.32417251e-03f, -5.27986139e-02f, 3.71506531e-03f, 3.28629799e-02f, -2.00944971e-02f, 5.17406762e-02f, -6.89403862e-02f, 1.46149304e-02f, 2.13349946e-02f,
  3.40599641e-02f, 3.03394925e-02f, -2.04987060e-02f, 2.23048329e-02f, -7.76708275e-02f, -1.59383081e-02f, 1.23216463e-02f, 1.90853551e-02f, -1.24973580e-04f, 4.85353209e-02f,
  1.65090114e-01f, -1.07662916e-01f, 8.92779455e-02f, 1.33284494e-01f, -2.81479247e-02f, 2.16030739e-02f, -6.82035163e-02f, -6.32142201e-02f, -9.28563848e-02f, 8.56891796e-02f,
  -4.03380021e-02f, 9.22606364e-02f, -1.48363160e-02f, 7.49089420e-02f, 1.09517649e-01f, 5.55893891e-02f, 1.10541638e-02f, 4.19033468e-02f, 7.11195469e-02f, -4.58027460e-02f,
  -6.16478026e-02f, 1.62396729e-01f, 2.49277234e-01f, 1.16085783e-01f, 2.11172123e-02f, 2.55474418e-01f, 7.06985518e-02f, 2.15715364e-01f, 1.88032582e-01f, 2.03600720e-01f,
  -7.18034878e-02f, 9.24352631e-02f, 1.47870705e-01f, 1.75382942e-02f, 2.09809795e-01f, 2.16620907e-01f, 3.06038827e-01f, -5.02788536e-02f, -5.42174056e-02f, 1.22802578e-01f,
  7.67729357e-02f, -1.65176407e-01f, -1.06870525e-01f, -1.32021338e-01f, 2.85584070e-02f, 9.71063450e-02f, 1.56719163e-01f, 6.78299963e-02f, -2.98541673e-02f, -6.53636456e-02f,
  8.11133608e-02f, 6.29672334e-02f, -1.32258400e-01f, -5.76041080e-02f, -1.94411166e-02f, -2.30755564e-02f, 4.79835421e-02f, 1.00315683e-01f, 1.12954728e-01f, 3.70464325e-02f,
  2.26619229e-01f, -8.06619078e-02f, -5.21964729e-02f, -7.50959739e-02f, 5.56150079e-02f, -3.69162345e-03f, 1.53890466e-02f, 3.14603038e-02f, 5.72286248e-02f, 9.01152119e-02f,
  -9.58431978e-03f, -6.15168959e-02f, 5.16995974e-02f, -3.55911590e-02f, -4.67738621e-02f, -4.91170846e-02f, 4.71366234e-02f, -1.13371044e-01f, -3.58058289e-02f, 2.75975969e-02f,
  -3.94366980e-02f, 6.42997473e-02f, 1.34197086e-01f, -3.33222523e-02f, 6.02394566e-02f, -3.02404054e-02f, 7.56700262e-02f, -5.06357439e-02f, 7.53322169e-02f, 6.12993501e-02f,
  4.63919109e-03f, 5.47573669e-03f, 5.42890802e-02f, -4.97230329e-02f, 5.23406500e-03f, 2.99862353e-03f, 2.46678703e-02f, -3.40306312e-02f, -1.53269470e-02f, 5.35756983e-02f,
  2.70286314e-02f, 5.84809743e-02f, -4.38774563e-02f, -5.17475009e-02f, 3.06069553e-02f, -4.88422513e-02f, 6.36258200e-02f, -7.69051909e-02f, -2.83610681e-03f, -3.24159600e-02f,
  2.62435302e-02f, -3.68070342e-02f, 3.57098598e-03f, -3.53266783e-02f, 5.20765781e-02f, 1.73147600e-02f, -9.46356449e-03f, -5.88626899e-02f, -6.08492903e-02f, -5.09866960e-02f,
  1.33061511e-02f, 4.38457094e-02f, 7.24606514e-02f, -1.99176036e-02f, 3.28862593e-02f, 3.19458246e-02f, 2.12277360e-02f, 3.07855420e-02f, -9.14214775e-02f, -5.94131695e-03f,
  1.14564970e-02f, 3.51503529e-02f, -1.52650103e-02f, 4.82148901e-02f, 6.75967485e-02f, 9.03440416e-02f, 6.52629584e-02f, 1.01641007e-01f, -7.09312037e-02f, 5.16962335e-02f,
  4.44874575e-04f, 5.48651479e-02f, 1.27437562e-01f, 9.98482108e-02f, 5.97829893e-02f, -6.76855771e-03f, 1.69666097e-01f, 1.48211151e-01f, 9.10744444e-02f, 2.27994710e-01f,
  1.54169410e-01f, 8.69209692e-02f, 1.35633156e-01f, -7.30355531e-02f, 9.64079648e-02f, 2.54911095e-01f, 2.84114271e-01f, 2.52707779e-01f, -2.88100131e-02f, 4.77316342e-02f,
  -1.90606400e-01f, -1.97783783e-01f, -9.20937657e-02f, -8.80385190e-02f, 8.44245031e-02f, 1.87292859e-01f, 2.62236983e-01f, 1.27083868e-01f, 1.43773526e-01f, 2.74742544e-02f,
  -1.36098221e-01f, -1.20518558e-01f, -3.86084728e-02f, -4.20928821e-02f, -6.89402819e-02f, -7.24824592e-02f, 6.46001697e-02f, 6.35931175e-03f, 2.67721899e-03f, -1.18902594e-01f,
  -1.63762972e-01f, 6.88901497e-03f, -6.39543985e-04f, -8.26379806e-02f, -1.01726495e-01f, 5.23325317e-02f, 1.10353522e-01f, -3.97547707e-02f, 8.12020991e-03f, 8.50698575e-02f,
  -1.61895782e-01f, -6.99777529e-03f, -1.11038491e-01f, 3.00833508e-02f, 3.13674696e-02f, 3.66482511e-02f, 1.65883433e-02f, 1.49396807e-01f, 4.84323613e-02f, 4.65487838e-02f,
  -2.53487602e-02f, -6.95691407e-02f, 8.77097473e-02f, 1.33073032e-01f, -2.67700646e-02f, -8.18923265e-02f, -3.68130021e-02f, 6.20005690e-02f, 1.23119354e-01f, 6.77846000e-02f,
  -2.21091919e-02f, -5.96520631e-03f, -4.13391590e-02f, -2.72695683e-02f, 7.78215099e-03f, -7.80479312e-02f, 8.05076153e-04f, -5.34308143e-03f, -2.05253027e-02f, 1.52972033e-02f,
  -7.57408701e-03f, 2.32512224e-02f, 7.81775918e-03f, 9.18642059e-03f, -8.83567706e-02f, 1.19323900e-03f, 4.10607569e-02f, 2.72801258e-02f, 3.26419808e-02f, 5.54378517e-02f,
  3.88763510e-02f, -1.15637556e-02f, -1.01350322e-01f, 2.01321561e-02f, 4.01456170e-02f, 6.48899283e-03f, 9.30173844e-02f, 1.58966277e-02f, -4.70870286e-02f, -1.82886794e-02f,
  -1.52771711e-01f, -3.85381817e-03f, -2.15530135e-02f, -2.07509417e-02f, 1.43134631e-02f, -3.28450911e-02f, -5.38128018e-02f, 2.04031798e-03f, -1.02237635e-03f, -1.52861644e-02f,
  7.14560971e-04f, -8.26340318e-02f, -5.41006140e-02f, -1.27415312e-02f, -2.85092276e-02f, 5.41426018e-02f, -5.13252281e-02f, 6.55493513e-02f, -4.67204638e-02f, -1.74427517e-02f,
  -1.48048736e-02f, 1.30673915e-01f, 1.60718486e-01f, 1.15256675e-01f, -4.84102517e-02f, 1.07248701e-01f, 9.96472612e-02f, 7.93354064e-02f, 1.68659627e-01f, 1.93131134e-01f,
  3.07845801e-01f, -6.69652075e-02f, 1.44543558e-01f, 9.31669585e-03f, 5.02761938e-02f, -1.24026015e-02f, 1.01159789e-01f, 6.95213005e-02f, -2.04060413e-03f, -1.02228031e-01f,
  -1.86070576e-01f, -1.01972990e-01f, 8.91818702e-02f, 1.39044136e-01f, 2.48994321e-01f, 1.98976636e-01f, 2.49568641e-01f, 2.17999220e-01f, 3.01503658e-01f, 8.95952359e-02f,
  2.59183832e-02f, 1.60462692e-01f, 1.90298244e-01f, 1.53505251e-01f, -5.21649718e-02f, -5.18868491e-02f, -1.15886830e-01f, -2.64602881e-02f, 3.99780162e-02f, 9.15935822e-03f,
  -9.62534919e-02f, 2.75575742e-02f, 8.09121132e-02f, -7.76104182e-02f, 1.34314746e-02f, 6.98482096e-02f, -2.38645449e-02f, 9.17705148e-02f, -4.45221178e-03f, 5.90897948e-02f,
  -8.39958340e-03f, -2.59432904e-02f, 4.41263132e-02f, -3.54089215e-02f, 6.17319569e-02f, 8.67497325e-02f, 3.15700807e-02f, 9.81181562e-02f, 1.23828202e-01f, 3.29684988e-02f,
  -1.48446113e-01f, 1.08881310e-01f, 8.23300779e-02f, -2.41253339e-02f, 6.42285030e-03f, 8.71935859e-02f, 2.85264384e-02f, 6.20201975e-03f, 1.35915317e-02f, -1.37149468e-01f,
  -5.71676269e-02f, 1.92930438e-02f, 3.15661132e-02f, -5.82426339e-02f, -3.20035662e-03f, -1.41496127e-02f, -1.20329838e-02f, 4.55167927e-02f, -5.96033297e-02f, 7.95119107e-02f,
  -1.34178801e-02f, -1.54111516e-02f, -5.56664802e-02f, 5.59837222e-02f, -7.55217718e-03f, 7.88617656e-02f, 6.77942112e-02f, 1.60607509e-02f, 8.54570791e-02f, 2.49918383e-02f,
  5.21832965e-02f, 4.68273051e-02f, 1.58470822e-03f, -1.53773800e-02f, -1.11881280e-02f, -2.31419802e-02f, 4.57464270e-02f, -9.34569091e-02f, 5.41851632e-02f, 7.37062246e-02f,
  -1.14822626e-01f, 2.81479508e-02f, 7.00598508e-02f, 1.39488339e-01f, 4.51718569e-02f, 2.64424644e-03f, -1.05258480e-01f, 3.59237529e-02f, -1.55357458e-03f, -6.91427514e-02f,
  -5.13448901e-02f, 2.03552321e-02f, -7.57650957e-02f, -8.37306380e-02f, -4.90842573e-02f, -7.53639117e-02f, 9.20830816e-02f, 4.05747779e-02f, -9.20768920e-03f, -6.58510625e-02f,
  4.87075485e-02f, 1.12263225e-01f, 1.48706943e-01f, 6.69079423e-02f, 5.65282702e-02f, 1.24498188e-01f, -4.98343892e-02f, -1.11776978e-01f, 1.63003162e-01f, -4.77619953e-02f,
  -2.71935642e-01f, -6.72528986e-03f, -4.70913053e-02f, 8.71106759e-02f, 1.40330166e-01f, 9.71056446e-02f, 2.33132448e-02f, -1.20722421e-01f, 1.85801666e-02f, 4.61324565e-02f,
  -9.82552469e-02f, -1.78794321e-02f, -1.30857214e-01f, -4.86590900e-02f, -2.20584437e-01f, -5.26297763e-02f, 9.79567245e-02f, -1.90388456e-01f, -5.27050570e-02f, -3.53968740e-02f,
  3.51192839e-02f, 6.30268306e-02f, -7.98758119e-02f, -7.06192479e-02f, 2.04751596e-01f, 8.85320455e-02f, 1.09770466e-02f, -2.17114873e-02f, 1.19796313e-01f, 1.35781974e-01f,
  -2.58001406e-02f, -8.26242641e-02f, 1.82632916e-02f, -7.09426701e-02f, -1.56444684e-02f, -7.41834939e-02f, 2.86648590e-02f, -6.19299822e-02f, 4.34354171e-02f, 5.41125499e-02f,
  3.80222052e-02f, 6.42320961e-02f, 3.35239694e-02f, 4.53657731e-02f, 5.18910848e-02f, -2.56354269e-02f, 1.37516130e-02f, -1.23079598e-01f, -1.09426431e-01f, 4.67620641e-02f,
  6.48284853e-02f, 1.25249829e-02f, -1.31721213e-01f, 4.49191853e-02f, -1.01011708e-01f, 5.20991674e-03f, -1.24264546e-02f, 1.00197196e-01f, -1.06450833e-01f, 1.02631226e-01f,
  -2.66328380e-02f, 2.32661124e-02f, 5.55804819e-02f, -3.04690655e-03f, -1.67084001e-02f, 1.71482507e-02f, 6.00355975e-02f, 2.41794065e-02f, -2.80340333e-02f, 8.81706178e-03f,
  -5.10842204e-02f, -4.32335325e-02f, -5.09789735e-02f, -2.93037249e-03f, 6.61476329e-02f, -2.53874306e-02f, 4.37873378e-02f, 9.39116254e-03f, -1.14920121e-02f, -3.76206376e-02f,
  -5.12222424e-02f, 4.09054607e-02f, 3.37501578e-02f, 4.86826226e-02f, 5.37703745e-02f, -2.12170798e-02f, 8.83773118e-02f, 9.55636129e-02f, -2.10428014e-02f, -1.16892252e-03f,
  8.71011317e-02f, -2.20742360e-01f, 1.10346340e-02f, -3.00474111e-02f, -1.02676302e-02f, 8.31433684e-02f, 1.99514814e-02f, -7.56570622e-02f, -7.84904212e-02f, 4.26110104e-02f,
  -1.00772977e-01f, -1.91243123e-02f, 2.21302100e-02f, 4.97478209e-02f, 2.07891259e-02f, -1.16508873e-02f, 1.55254886e-01f, -3.52727287e-02f, -9.19381678e-02f, 1.13052711e-01f,
  3.91005240e-02f, -6.75361380e-02f, -3.17984484e-02f, 4.56426889e-02f, -3.59548512e-03f, -1.25647679e-01f, -5.70848994e-02f, 4.39855084e-02f, -1.04087345e-01f, 7.81540945e-02f,
  2.42320336e-02f, -1.18607305e-01f, 2.30810106e-01f, 4.94094677e-02f, 3.58843096e-02f, 5.76962670e-03f, -1.39271080e-01f, -7.06942827e-02f, -1.08603217e-01f, -5.56458160e-02f,
  9.02612321e-03f, 1.45943552e-01f, 2.09402621e-01f, 6.29247203e-02f, 2.82913749e-03f, 1.67179164e-02f, 2.04354182e-01f, 2.66164780e-01f, 1.07691944e-01f, -1.04935700e-03f,
  5.21957129e-02f, -2.76360195e-02f, 8.98421854e-02f, 3.66730690e-02f, -6.92749918e-02f, 1.01874553e-01f, 1.04123116e-01f, 1.27365049e-02f, -1.56467315e-02f, 1.82299450e-01f,
  2.77392507e-01f, -2.22460270e-01f, 5.14326394e-02f, 1.23229288e-02f, -6.71476051e-02f, 1.40967034e-03f, 5.17123789e-02f, 2.35231500e-02f, 2.02934630e-02f, -2.90657650e-03f,
  -4.83444780e-02f, -3.07990201e-02f, -8.05120692e-02f, 1.72476768e-02f, -5.37283793e-02f, 2.09727027e-02f, 1.03946654e-02f, 9.43837762e-02f, -3.70740816e-02f, -1.10419907e-01f,
  -1.29159689e-01f, -7.83682168e-02f, 6.06149063e-02f, -5.32072075e-02f, -5.32905385e-02f, 5.86694330e-02f, 5.47311315e-03f, 5.05617587e-03f, 6.30040243e-02f, -5.21940850e-02f,
  -1.11333698e-01f, 3.50127108e-02f, 5.93119822e-02f, -7.49410838e-02f, 2.18644571e-02f, 5.25627509e-02f, 7.52993226e-02f, -2.20410246e-02f, 4.59227599e-02f, -5.05822636e-02f,
  -5.35008032e-03f, -6.65145144e-02f, 8.71084072e-03f, 4.02106233e-02f, 3.53837758e-02f, -2.89261192e-02f, -6.20558970e-02f, 3.42263803e-02f, 2.63656452e-02f, 5.75103126e-02f,
  -4.12479247e-04f, -3.14019993e-02f, 1.11078601e-02f, -1.20315067e-02f, 3.13324146e-02f, 1.02664065e-02f, 9.87093225e-02f, 1.61441155e-02f, 1.10521950e-02f, 1.60799399e-02f,
  1.09618098e-01f, 1.12190349e-02f, 9.15000737e-02f, 3.52824256e-02f, -4.34817672e-02f, -8.62568840e-02f, 4.98776697e-02f, -7.28861168e-02f, -1.03951462e-01f, -2.33553723e-03f,
  -1.13569140e-01f, -7.25590289e-02f, 4.72531728e-02f, -4.37919870e-02f, 1.55750243e-02f, -1.45498980e-02f, 2.50759651e-03f, 6.50434121e-02f, -2.97824629e-02f, -3.02709956e-02f,
  -5.73603287e-02f, -1.87980069e-03f, 1.12217233e-01f, -3.44019593e-03f, -7.58894682e-02f, 5.63207418e-02f, 9.53328386e-02f, 3.51135768e-02f, 1.53232619e-01f, -5.18108457e-02f,
  -1.61364898e-02f, -3.03559065e-01f, 1.15460709e-01f, -1.23293810e-01f, 1.50780668e-02f, -1.38354793e-01f, -1.43990651e-01f, -5.06410711e-02f, -7.71747753e-02f, -2.86938231e-02f,
  4.35098968e-02f, 4.84599546e-02f, 2.08044603e-01f, 7.15591758e-02f, 4.54974994e-02f, -4.49512638e-02f, -1.86653823e-01f, 9.39010531e-02f, 1.07713625e-01f, -7.40360003e-03f,
  -7.39860982e-02f, -3.80978025e-02f, 5.54076657e-02f, -4.67859507e-02f, -1.31065890e-01f, 8.88623372e-02f, -6.05342016e-02f, -5.23504950e-02f, -4.11519036e-02f, -1.42102107e-01f,
  1.11837655e-01f, -6.93497136e-02f, 7.64707625e-02f, 7.97407404e-02f, 1.06494039e-01f, -3.84242721e-02f, 6.51368946e-02f, 6.04249239e-02f, -3.02613378e-02f, -4.89680097e-02f,
  -2.85429880e-02f, -3.65253002e-03f, -2.98655592e-02f, -3.13140005e-02f, -8.78267512e-02f, 3.16330567e-02f, 5.32585895e-03f, -3.91976349e-02f, 3.93553898e-02f, -4.90490440e-03f,
  -1.00119911e-01f, 4.33511250e-02f, 5.54762594e-02f, 5.07535820e-04f, -4.42986190e-02f, 1.29436597e-01f, 8.43415707e-02f, -5.42922579e-02f, 9.37444195e-02f, -6.55124709e-02f,
  2.18051928e-03f, 6.63952306e-02f, -8.25978909e-03f, -2.75184289e-02f, -1.22177163e-02f, -5.93697838e-02f, -6.63488433e-02f, -5.87500669e-02f, 1.96937062e-02f, -9.79788378e-02f,
  6.36463761e-02f, 4.05464023e-02f, 7.06756115e-02f, 3.92729975e-02f, 9.50716529e-03f, -5.14341146e-02f, -3.75048220e-02f, -4.62307595e-02f, 4.30598482e-02f, -2.19087061e-02f,
  6.51758760e-02f, 9.02511030e-02f, -4.39892225e-02f, -2.10420359e-02f, -1.65371243e-02f, -5.65111302e-02f, 2.26169322e-02f, -3.78889032e-02f, 2.59861127e-02f, -3.46374139e-02f,
  1.62101373e-01f, 1.97238475e-01f, 5.54817915e-02f, 3.64913344e-02f, -6.84906691e-02f, -6.30427292e-03f, 2.68210359e-02f, -5.41700982e-02f, -2.40077619e-02f, -7.37672225e-02f,
  2.18906514e-02f, 2.29618661e-02f, 5.28256111e-02f, 1.64813902e-02f, -2.19742637e-02f, 4.77946810e-02f, -5.86162088e-03f, 6.70034066e-02f, 6.89712018e-02f, 4.68665957e-02f,
  -7.91739970e-02f, -9.00635310e-03f, 8.44664648e-02f, 5.26738837e-02f, 1.52377700e-02f, 8.77714753e-02f, 7.37117082e-02f, 1.46328643e-01f, 1.69181153e-01f, -2.83835176e-02f,
  1.62470579e-01f, -2.88855910e-01f, -1.73328623e-01f, -1.24036901e-01f, -8.02318454e-02f, 2.62315311e-02f, 3.29054594e-02f, 1.47223413e-01f, 4.90179174e-02f, -1.70847192e-01f,
  -1.04392515e-02f, 1.85043871e-01f, 1.36743501e-01f, 1.79319486e-01f, 2.41235197e-01f, -1.35287300e-01f, -2.38978609e-01f, 2.12950259e-02f, 1.91895768e-01f, 1.79103300e-01f,
  -3.36644538e-02f, 2.73982305e-02f, 9.21151564e-02f, -2.56344955e-02f, -2.65271902e-01f, -9.50562879e-02f, -1.94609165e-01f, -1.26078248e-01f, -1.28076956e-01f, -4.85970706e-01f,
  -1.27376482e-01f, -1.51569888e-01f, 1.68849021e-01f, 4.20737304e-02f, -9.95702222e-02f, 1.51723856e-02f, 8.92672688e-02f, -8.04663748e-02f, -1.07035311e-02f, -3.79815847e-02f,
  -1.09040692e-01f, -1.89081079e-03f, -2.50781681e-02f, -5.68913817e-02f, 4.48889472e-03f, -2.82766540e-02f, -6.90882429e-02f, -1.91983785e-02f, 8.57515037e-02f, 1.39225358e-02f,
  -1.03893749e-01f, -5.30415252e-02f, 2.43270118e-02f, -5.28859254e-03f, 8.60951915e-02f, 1.57345049e-02f, -6.48445776e-03f, -3.88210863e-02f, 1.08908772e-01f, -1.32473931e-01f,
  -7.29262480e-04f, -2.00432260e-02f, -1.52402790e-02f, -2.16764398e-02f, -3.00748404e-02f, -4.86945920e-02f, -1.42335631e-02f, -5.04929051e-02f, -2.07903404e-02f, 5.21510690e-02f,
  -3.38865891e-02f, -2.47332640e-02f, 3.73157896e-02f, -2.84218881e-02f, -3.89339924e-02f, -1.26584666e-02f, -4.27432396e-02f, 1.91903133e-02f, 4.23783660e-02f, -4.52381298e-02f,
  2.12834328e-02f, 1.73912719e-02f, 9.25923977e-03f, -1.97705850e-02f, -1.11134835e-02f, 1.55986389e-02f, -3.01173329e-02f, 4.93877195e-02f, 4.53379415e-02f, -6.91728592e-02f,
  2.38537565e-01f, 1.72618702e-01f, -2.81251478e-03f, 1.21208385e-01f, -7.82897249e-02f, 2.11583655e-02f, -6.49383888e-02f, 4.99461591e-03f, -5.01226559e-02f, 3.07513326e-02f,
  6.04209199e-04f, 9.40182507e-02f, 1.17726689e-02f, -1.15638245e-02f, 7.41527379e-02f, 2.68896613e-02f, 9.31898952e-02f, 1.27730593e-02f, 2.87771765e-02f, -2.71802321e-02f,
  1.26353409e-02f, 1.49134532e-01f, 2.35122994e-01f, 7.95419514e-02f, 6.07302561e-02f, 2.54359215e-01f, 3.51221189e-02f, 1.27843514e-01f, 2.02729806e-01f, 9.99618322e-02f,
  -4.52382386e-01f, -3.42935830e-01f, -4.58766893e-02f, -4.43210155e-02f, 9.11355317e-02f, 8.09339881e-02f, -1.25453591e-01f, -1.12298734e-01f, 5.60631268e-02f, -1.43695146e-01f,
  1.61850125e-01f, 1.52906075e-01f, 1.81949347e-01f, 2.05856413e-01f, 4.10467125e-02f, -2.02689603e-01f, -8.73361528e-02f, 2.90839188e-02f, 1.87515207e-02f, 1.01643868e-01f,
  1.96818169e-02f, -1.67979270e-01f, -1.32122695e-01f, -5.67209162e-02f, -2.31600717e-01f, -9.48084742e-02f, -4.36589904e-02f, -1.43504605e-01f, -6.50055185e-02f, -2.72111803e-01f,
  8.44196603e-02f, -2.10482121e-01f, 1.18455261e-01f, 7.38888159e-02f, 4.33406793e-02f, 5.21845929e-02f, -3.20122764e-03f, -5.60169257e-02f, 5.70734916e-03f, -7.68176094e-02f,
  1.22259125e-01f, 3.31276506e-02f, -2.61755139e-02f, -6.89987838e-02f, -5.76357506e-02f, -2.96909288e-02f, -9.54679772e-02f, 2.90149380e-03f, -5.69800921e-02f, -3.51718143e-02f,
  9.04193223e-02f, 3.41435289e-03f, -9.49519407e-03f, 4.79527637e-02f, -7.85739273e-02f, -1.08067654e-02f, -1.29183367e-01f, -1.93651617e-01f, -9.13371518e-02f, -3.35171282e-01f,
  -4.56558093e-02f, 6.93821907e-03f, 6.53314963e-03f, -2.21373048e-02f, -6.30565211e-02f, 6.93344623e-02f, -7.20122159e-02f, 3.73488031e-02f, -4.40159626e-02f, -2.55937912e-02f,
  -1.48085440e-02f, 3.05379983e-02f, 3.70473266e-02f, -3.80969755e-02f, 7.04419380e-03f, 2.03124676e-02f, 2.73465756e-02f, -2.80557051e-02f, 9.33466479e-03f, 6.98977485e-02f,
  4.98906896e-02f, 1.02835134e-01f, -3.19472849e-02f, -3.42044570e-02f, 2.56699678e-02f, 4.66099158e-02f, -1.64614785e-02f, 3.72811630e-02f, 1.86104104e-02f, -4.81896661e-02f,
  -7.30080158e-02f, 2.15509474e-01f, -1.76799847e-04f, -7.20901713e-02f, -2.41435337e-04f, -2.01220829e-02f, -1.23922504e-03f, -3.00323889e-02f, 5.65255582e-02f, 4.79684863e-03f,
  -2.74351686e-02f, -6.65922835e-02f, 2.11289916e-02f, -6.11876920e-02f, 5.34779439e-03f, -3.15831304e-02f, -4.80561964e-02f, -5.96695626e-03f, 8.07320476e-02f, -7.16458133e-04f,
  -3.41981538e-02f, -4.24138680e-02f, -3.46874706e-02f, -7.69391796e-03f, 9.65463649e-03f, 8.04498717e-02f, -7.45482892e-02f, -3.86631712e-02f, -8.90164673e-02f, -2.78449208e-01f,
  -2.23501816e-01f, 1.77575201e-01f, -1.87656030e-01f, -4.53586765e-02f, -1.07270218e-01f, -1.59291655e-01f, -9.18215215e-02f, -6.23335177e-03f, -1.55982217e-02f, 8.99635777e-02f,
  1.96775451e-01f, 2.40459263e-01f, 2.29101144e-02f, 2.81513408e-02f, -9.41424891e-02f, -8.21179226e-02f, -1.15621410e-01f, -2.14356005e-01f, -1.76485181e-01f, -1.00570507e-01f,
  1.61063701e-01f, -3.96389477e-02f, -9.71488804e-02f, 4.67319824e-02f, 2.73662299e-01f, 1.56674996e-01f, 1.75398719e-02f, -1.34816822e-02f, -2.97603495e-02f, 1.21385783e-01f,
  2.53934562e-01f, -9.66889858e-02f, -1.93120036e-02f, 1.17157184e-01f, 4.06969376e-02f, 5.93987145e-02f, -3.10529899e-02f, -2.59039514e-02f, 3.51467952e-02f, 3.51924598e-02f,
  1.22813411e-01f, 3.91074568e-02f, 8.38671550e-02f, 2.23876275e-02f, -4.68379259e-02f, -5.45928553e-02f, -4.06317897e-02f, -4.70847040e-02f, 1.38252908e-02f, 1.15955502e-01f,
  9.75762531e-02f, -3.66499424e-02f, -1.38048843e-01f, -4.36171070e-02f, -6.41395971e-02f, -4.73701917e-02f, 4.16216403e-02f, 9.54743996e-02f, -7.24314004e-02f, 1.08209893e-01f,
  -2.04604212e-02f, -7.89653510e-02f, 5.23426943e-03f, -2.52788365e-02f, 5.68266073e-03f, -5.61924912e-02f, -2.11100075e-02f, -6.65446231e-03f, 3.60684246e-02f, -6.64477004e-03f,
  4.90165204e-02f, -4.27276129e-03f, -8.61436129e-03f, 4.23242189e-02f, -3.93521897e-02f, -6.08368916e-03f, -1.33906854e-02f, -1.19048925e-02f, 6.48186505e-02f, 4.87962179e-02f,
  1.45411510e-02f, 8.28157086e-03f, 7.88058043e-02f, 6.90062046e-02f, -3.25768143e-02f, -2.17609964e-02f, 1.84368938e-02f, 9.48801711e-02f, -2.45218631e-03f, -5.30216284e-02f,
  3.09472382e-01f, -2.20378041e-01f, 8.59501511e-02f, 4.86015603e-02f, 4.21144515e-02f, -5.27162142e-02f, 4.26876694e-02f, 1.85384434e-02f, -1.65844196e-03f, -1.81208327e-02f,
  -4.23612967e-02f, -1.23578319e-02f, 1.47693511e-02f, 1.99783314e-02f, -3.58087830e-02f, -1.99938603e-02f, 9.76183191e-02f, 1.83166824e-02f, -3.84396873e-02f, 4.13533933e-02f,
  4.29216884e-02f, -6.83414284e-03f, 1.97465271e-02f, -3.36819328e-02f, 7.33677745e-02f, -1.39439642e-01f, 3.31412144e-02f, -1.58779453e-02f, -1.79828018e-01f, -1.69162117e-02f,
  1.97406679e-01f, 3.06932628e-02f, -1.81079879e-01f, -5.38880490e-02f, -3.98845896e-02f, -4.52752933e-02f, -6.09581098e-02f, -1.15424111e-01f, -9.73736029e-03f, 3.96101400e-02f,
  9.74959657e-02f, 1.64801672e-01f, 4.81928885e-02f, -3.03785037e-02f, -6.54848218e-02f, -6.16043247e-02f, -4.62035835e-02f, 3.07473522e-02f, -3.11470963e-02f, -1.25593657e-03f,
  1.01422913e-01f, 1.33974170e-02f, -7.85883963e-02f, -5.62223122e-02f, 1.06396444e-01f, 2.93442477e-02f, -1.43444434e-01f, -4.40554805e-02f, 3.72000560e-02f, 2.11513802e-01f,
  2.38049537e-01f, 1.66296184e-01f, -9.89822224e-02f, 3.10702901e-02f, 4.12285849e-02f, -3.07647511e-02f, 4.91181463e-02f, -6.13604262e-02f, -1.12794591e-02f, 4.62633744e-02f,
  -1.53741818e-02f, 9.74718481e-02f, 1.99954398e-02f, 9.64032114e-02f, 1.23740090e-02f, -1.01679368e-02f, -3.75653943e-03f, -1.11756317e-01f, -5.01303971e-02f, -4.47380496e-03f,
  -5.14170378e-02f, 1.12372607e-01f, -5.09345569e-02f, 2.43819393e-02f, 1.03599072e-01f, -5.24696596e-02f, -4.38950509e-02f, 4.58162948e-02f, -1.05356630e-02f, 1.35636464e-01f,
  2.89050080e-02f, 4.25241813e-02f, 7.15303421e-02f, -5.67915738e-02f, -4.31315266e-02f, 2.47609112e-02f, -1.64494757e-02f, -3.15661393e-02f, -3.14105973e-02f, 3.83982807e-02f,
  -3.80145572e-02f, 2.02660952e-02f, 4.17364985e-02f, 6.23683594e-02f, -5.25617450e-02f, 5.20565808e-02f, 8.60471427e-02f, 1.16320457e-02f, -8.04955512e-02f, -1.00603877e-02f,
  -2.92270463e-02f, 1.91039946e-02f, 2.08942238e-02f, 3.01069655e-02f, 7.68416421e-03f, 2.39075124e-02f, 7.37948269e-02f, 3.13567580e-04f, 3.34522016e-02f, 8.03161226e-03f,
  -1.16608500e-01f, -1.69917122e-01f, 6.94365278e-02f, -6.38109399e-03f, -5.38521223e-02f, -3.98197630e-03f, 7.21813589e-02f, 1.63580086e-02f, 5.97520545e-02f, -1.45763364e-02f,
  2.47128196e-02f, -2.40607094e-02f, -5.65455668e-02f, -1.13822676e-01f, -6.08474799e-02f, 3.21719190e-03f, -1.49763659e-01f, 6.11800291e-02f, -5.57496250e-02f, 6.36885315e-02f,
  -1.47571206e-01f, -2.14742422e-02f, -8.49126875e-02f, -1.31852046e-01f, 2.46417411e-02f, 6.04129694e-02f, 1.53908031e-02f, -3.33166532e-02f, -4.32174429e-02f, -1.89629123e-01f,
  9.98263732e-02f, -2.68338799e-01f, -3.52920592e-01f, -2.49730363e-01f, -2.52841771e-01f, -2.54056662e-01f, -2.17148840e-01f, -1.92039475e-01f, 3.00874258e-03f, -1.40454531e-01f,
  -6.46889070e-03f, 5.04821204e-02f, -1.36407223e-02f, -2.15297332e-03f, -8.74396339e-02f, -2.20215231e-01f, -1.04820237e-01f, -2.76045185e-02f, 1.12544529e-01f, 5.18751480e-02f,
  1.03976637e-01f, 1.67609267e-02f, 1.21379808e-01f, 9.73238125e-02f, -5.53251617e-02f, 3.56256217e-02f, -1.32773161e-01f, -2.38384362e-02f, 1.90572459e-02f, -2.99295075e-02f,
  -6.76949322e-02f, -1.81540653e-01f, -2.28410382e-02f, 1.66923195e-01f, -3.62998508e-02f, 1.25936583e-01f, 7.53077567e-02f, -4.47225794e-02f, 6.02365844e-02f, -6.39188290e-03f,
  -4.44778502e-02f, 2.25999765e-02f, 6.99209701e-03f, 7.50492886e-02f, 1.23753073e-02f, 7.78608723e-03f, 9.25518349e-02f, 4.87146676e-02f, -7.87988584e-03f, -1.16164247e-02f,
  -1.64863244e-02f, -7.60159343e-02f, -1.31449560e-02f, -1.03318706e-01f, -5.90450503e-02f, 1.44619094e-02f, -1.16824180e-01f, -1.62460785e-02f, -6.01404905e-02f, 4.59036045e-02f,
  -4.06891666e-03f, 7.02546630e-03f, 4.34642285e-02f, 9.97505616e-03f, 5.53547926e-02f, 1.90548729e-02f, -2.48904135e-02f, 4.05891947e-02f, 1.75116770e-02f, 1.13680353e-02f,
  -3.95530909e-02f, 1.60406120e-02f, -4.02080156e-02f, -6.60672337e-02f, 5.95260635e-02f, -5.93474843e-02f, 2.49932371e-02f, -3.81245017e-02f, 7.07029477e-02f, -3.70861031e-02f,
  -1.90457504e-03f, -1.21832844e-02f, 1.83939002e-02f, -3.38228606e-03f, -1.78432036e-02f, -1.11464970e-01f, 3.48974555e-03f, -2.72007007e-03f, 5.38254790e-02f, -3.80114540e-02f,
  2.05787390e-01f, -5.82610071e-02f, -6.60275444e-02f, -2.09164042e-02f, -1.52558163e-02f, -4.33451012e-02f, -4.48239185e-02f, -2.74220798e-02f, 4.00846079e-02f, -5.23326434e-02f,
  6.66278601e-02f, -8.61351658e-03f, 2.71720458e-02f, 1.02066738e-03f, -5.86965606e-02f, 2.36606244e-02f, -5.76201007e-02f, -7.15939999e-02f, 7.74788931e-02f, -3.69564928e-02f,
  1.12082791e-02f, 5.86931892e-02f, 1.21360302e-01f, 3.32227126e-02f, 3.78943048e-02f, 3.67424972e-02f, 6.80876151e-02f, -2.81887818e-02f, 5.58151528e-02f, -5.83906658e-02f,
  2.88043320e-01f, -7.95825347e-02f, 2.67139465e-01f, -6.19586594e-02f, -8.20547566e-02f, 3.03561203e-02f, -1.10911801e-01f, -2.86919773e-02f, -3.23607819e-03f, -1.46573512e-02f,
  -9.08270627e-02f, 9.16348696e-02f, 8.63032117e-02f, 1.30000338e-01f, 1.31848887e-01f, 1.16845798e-02f, -8.31129998e-02f, 1.94416687e-01f, 4.48433459e-02f, -5.53526590e-03f,
  -1.49913728e-01f, -7.86914229e-02f, -2.30590999e-02f, 7.63582438e-03f, -2.38640815e-01f, -1.08006075e-01f, -8.03725645e-02f, -9.58742350e-02f, -2.71040555e-02f, -1.63641527e-01f,
  1.07216477e-01f, 1.59960508e-01f, 2.76497826e-02f, 4.63505499e-02f, -4.98554632e-02f, 5.91138750e-02f, -9.85426269e-03f, -5.37273772e-02f, -3.93207856e-02f, -3.99952494e-02f,
  -5.62741719e-02f, -7.03289406e-03f, -7.34224692e-02f, -4.31085229e-02f, 1.19139953e-03f, -1.47844534e-02f, 6.92007970e-03f, 4.25578058e-02f, 1.51006445e-01f, -1.07269838e-01f,
  -1.51720807e-01f, -1.66709945e-02f, 8.73907432e-02f, -2.50823051e-03f, 1.02443494e-01f, 1.03359520e-01f, 2.23828126e-02f, 8.41783136e-02f, 1.74229786e-01f, 2.38818191e-02f,
  -4.35086191e-02f, -1.22424224e-02f, 5.82538992e-02f, -3.22438851e-02f, 2.38816086e-02f, 1.97247602e-02f, 1.29355770e-02f, -2.17344146e-02f, -6.77859560e-02f, -2.64905207e-02f,
  6.74418882e-02f, -3.28975022e-02f, 2.71646380e-02f, -2.59979926e-02f, -2.21689660e-02f, 5.21373302e-02f, -2.41842065e-02f, -6.75012022e-02f, 1.66969784e-02f, -4.90591116e-02f,
  -4.33880799e-02f, 9.10555571e-02f, -6.07177801e-02f, 6.69075772e-02f, 1.45614753e-02f, -2.94487886e-02f, 2.66545229e-02f, -5.78409955e-02f, -1.35832015e-04f, -6.78221742e-03f,
  -6.45465404e-02f, 2.80936331e-01f, -5.15508503e-02f, 2.20316835e-02f, 8.15499797e-02f, -3.88567038e-02f, 6.08418211e-02f, 7.05776364e-02f, 5.11274040e-02f, 1.62992906e-02f,
  4.62316461e-02f, 7.01932907e-02f, -6.64844662e-02f, -3.56484652e-02f, 5.69973812e-02f, 1.21526076e-02f, -2.03120373e-02f, -3.75489444e-02f, 8.16447511e-02f, -8.90517682e-02f,
  -1.69309508e-02f, -2.85234284e-02f, 7.64500499e-02f, 4.57595661e-02f, 4.44493555e-02f, 4.24981304e-02f, -7.51269981e-02f, 3.31374481e-02f, 1.33343995e-01f, -1.59367546e-01f,
  -3.40426058e-01f, -7.69801810e-02f, -2.83246368e-01f, -8.32972974e-02f, -1.42472923e-01f, -1.27252191e-01f, -1.00473605e-01f, 4.53452170e-02f, -4.28412110e-02f, -1.32821634e-01f,
  -7.17468038e-02f, 7.95865878e-02f, 1.92634478e-01f, 2.05301732e-01f, 7.65808895e-02f, -2.77701952e-02f, -4.32121344e-02f, 8.67483243e-02f, -3.58166844e-02f, -8.28030985e-03f,
  7.99055919e-02f, -9.01001766e-02f, -1.04785249e-01f, -4.49152701e-02f, -5.06692976e-02f, 2.66354047e-02f, -7.58166192e-03f, -1.60823554e-01f, -1.02540709e-01f, -8.50797966e-02f,
  -1.78982481e-01f, -1.97734013e-01f, 1.75149720e-02f, 6.37304112e-02f, 5.67366323e-03f, -2.51468867e-02f, -1.03358410e-01f, 9.04909223e-02f, -1.08386679e-02f, 1.62300039e-02f,
  -3.10412189e-03f, 5.08402772e-02f, -3.51694413e-02f, 1.12052090e-01f, -5.33121973e-02f, 3.79531085e-02f, -9.31001268e-03f, 5.83647080e-02f, 8.44520479e-02f, 3.26745920e-02f,
  -3.73998508e-02f, -8.87927264e-02f, -1.44386888e-01f, -2.82140970e-02f, 4.63546207e-03f, 9.05572996e-02f, 1.40255867e-02f, 6.06096908e-02f, 6.10399209e-02f, -4.27911021e-02f,
  -8.67319200e-03f, 6.65977830e-03f, 1.93062108e-02f, -7.52988458e-02f, 3.28195356e-02f, 5.92528731e-02f, 3.27090882e-02f, -2.53540613e-02f, 3.16577824e-03f, -6.32117018e-02f,
  1.03475221e-01f, 5.05989976e-03f, 5.07359998e-03f, -5.41469157e-02f, -3.67188677e-02f, -2.01894138e-02f, -3.99548560e-02f, 8.96714032e-02f, 1.39857158e-02f, -2.20170133e-02f,
  -1.50857382e-02f, 5.57172522e-02f, 4.48035728e-03f, 9.91800874e-02f, -2.78515164e-02f, 6.59482628e-02f, -2.94801127e-02f, 5.00210971e-02f, -5.96736893e-02f, -9.36731026e-02f,
  6.49355501e-02f, 1.68759078e-01f, 2.35495344e-03f, 6.15422726e-02f, -1.35179862e-01f, 8.80602598e-02f, 1.47502089e-03f, -4.22893427e-02f, 1.91771630e-02f, -8.16744566e-02f,
  -3.21199596e-02f, -4.60637994e-02f, 3.75839956e-02f, 4.22915258e-03f, -4.65745479e-02f, -1.32634726e-04f, 1.78880300e-02f, 1.68616790e-02f, 5.99432476e-02f, -2.42793262e-02f,
  -6.22431971e-02f, -8.54286924e-02f, 9.11091920e-03f, -5.10126911e-02f, -1.78857688e-02f, -6.65593520e-02f, 2.08723396e-02f, -2.97327843e-02f, -2.69414838e-02f, -8.84791762e-02f,
  3.86034437e-02f, -2.24730536e-01f, -1.91225916e-01f, 1.89071998e-01f, 1.42902449e-01f, 2.18814835e-01f, -1.46373524e-04f, 1.71370467e-03f, 1.06560618e-01f, -6.19074628e-02f,
  3.28711350e-03f, 7.78297186e-02f, 1.18446480e-02f, 4.18014973e-02f, -4.99118567e-02f, -5.83533803e-03f, 3.02576646e-02f, 2.49073692e-02f, 1.68332115e-01f, 1.28173172e-01f,
  1.93562612e-01f, 1.89441085e-01f, 1.20770499e-01f, 7.42902532e-02f, -1.22394077e-02f, 4.70021032e-02f, -1.18534155e-01f, 6.27026334e-02f, -1.19524978e-01f, -1.53432474e-01f,
  -3.59349489e-01f, -1.74268752e-01f, 2.38436699e-01f, 1.07473090e-01f, 1.94515497e-03f, 1.58417150e-02f, 1.68895870e-02f, -2.92551350e-02f, 5.98654412e-02f, -8.48095566e-02f,
  3.66977118e-02f, 2.35634651e-02f, 1.45792486e-02f, -7.80763105e-02f, -8.27602148e-02f, -5.66459633e-02f, -1.31538346e-01f, -7.88478181e-02f, 3.29243881e-03f, -2.09604025e-01f,
  4.62487452e-02f, 5.98893082e-03f, -7.63685703e-02f, -1.27185704e-02f, -7.71353096e-02f, 9.62201878e-02f, -6.03360236e-02f, -7.55989477e-02f, -1.26855224e-01f, -7.34390393e-02f,
  6.69947788e-02f, -3.92288109e-03f, 1.76594649e-02f, -3.63346078e-02f, -3.11089791e-02f, 1.69992447e-02f, 1.64772663e-02f, 2.28745323e-02f, -1.63519345e-02f, -1.87699217e-02f,
  -4.85335402e-02f, -3.45492326e-02f, -3.10005452e-02f, 4.08624150e-02f, -5.59246503e-02f, 1.45428628e-02f, 5.19581465e-03f, -8.09639841e-02f, 3.27473693e-02f, -5.98090738e-02f,
  -3.98570448e-02f, 1.98143744e-03f, 2.19610985e-02f, 1.80364568e-02f, -3.79045717e-02f, -7.07688853e-02f, 4.89874603e-03f, 1.58708673e-02f, -5.96389174e-03f, 8.00208896e-02f,
  1.53483942e-01f, 1.45248771e-01f, -7.27310702e-02f, -5.71759157e-02f, 2.07895488e-02f, -1.11238144e-01f, -1.38638401e-02f, 1.65181179e-02f, -2.95865326e-03f, 6.21835664e-02f,
  3.18923965e-02f, -7.81074241e-02f, 2.47757155e-02f, -4.73456755e-02f, 1.81208011e-02f, 6.13240013e-03f, -7.61584379e-03f, 6.99391365e-02f, -2.10268958e-03f, -3.79962213e-02f,
  -1.35277435e-02f, 9.05069783e-02f, 1.63287342e-01f, -3.40529755e-02f, 7.40429610e-02f, 1.59290299e-01f, 1.08523272e-01f, 4.93579283e-02f, 3.03382874e-02f, 1.19202144e-01f,
  8.01162720e-02f, 1.26154199e-01f, -5.02112359e-02f, 7.04727471e-02f, 5.67685403e-02f, -6.82274699e-02f, -1.94776937e-01f, 9.31002125e-02f, 8.71459618e-02f, -4.86638211e-02f,
  1.26841128e-01f, -9.61804204e-03f, 1.35481851e-02f, -5.68896383e-02f, -6.02694899e-02f, -1.94778144e-01f, -1.67882517e-01f, -1.99661672e-01f, -1.43148601e-01f, -1.06125019e-01f,
  -1.36668324e-01f, 3.06422766e-02f, 6.97021186e-02f, 7.17563033e-02f, 1.47042453e-01f, 1.22646410e-02f, -9.41132754e-03f, 2.56554298e-02f, -7.26550370e-02f, -6.46254048e-02f,
  -1.60215780e-01f, 2.51169622e-01f, -3.67272198e-02f, 1.75844934e-02f, -3.19299921e-02f, 2.64223721e-02f, -9.63006318e-02f, 1.42111108e-02f, 8.28970373e-02f, -3.68122160e-02f,
  -4.89920005e-02f, -1.69628505e-02f, 2.99631781e-03f, -5.38222790e-02f, 2.69160867e-02f, -9.99395177e-02f, -2.82385796e-02f, -2.57374514e-02f, 7.44063780e-03f, 5.55627681e-02f,
  2.65761483e-02f, -4.70015686e-03f, -3.48510183e-02f, 5.96412793e-02f, 1.43236235e-01f, -1.74553450e-02f, 1.39899239e-01f, 9.58546028e-02f, -3.27654630e-02f, 8.07854831e-02f,
  -7.20625371e-02f, 3.25701647e-02f, -2.37627700e-02f, -2.14486942e-03f, -5.06841876e-02f, 2.15200838e-02f, 1.98349822e-02f, -6.66651875e-02f, -3.86193730e-02f, 4.11312133e-02f,
  -2.22827978e-02f, 5.40022887e-02f, 4.41019647e-02f, -1.97558496e-02f, 7.42251147e-03f, -2.22214386e-02f, 6.42718449e-02f, -2.99701486e-02f, -4.89773415e-03f, -1.19178770e-02f,
  7.66142085e-02f, -2.12339796e-02f, 1.17049124e-02f, -3.93719710e-02f, -1.27918618e-02f, -3.57574075e-02f, 3.52474153e-02f, -2.24703830e-03f, 8.79785791e-02f, 6.67480305e-02f,
  -8.17248411e-03f, 5.10564223e-02f, -9.32709053e-02f, -9.52545255e-02f, 1.52870249e-02f, -6.83821887e-02f, 4.31895815e-02f, 5.74948080e-02f, 5.64778037e-02f, -8.73837098e-02f,
  4.38963855e-03f, 5.10916486e-02f, -1.46347433e-02f, -6.54998198e-02f, -8.55557695e-02f, -4.05954570e-02f, -1.05904363e-01f, -2.62067150e-02f, -7.98995569e-02f, -2.94367346e-04f,
  -3.21248099e-02f, -1.18055664e-01f, -1.06692657e-01f, -1.11643650e-01f, -1.46049745e-02f, -1.51434183e-01f, -1.37898549e-01f, -1.42301798e-01f, -1.61526352e-01f, -7.91449398e-02f,
  -8.50428566e-02f, 4.90319505e-02f, -1.86931059e-01f, -1.01034030e-01f, 2.48244684e-02f, 6.64519742e-02f, 3.13011743e-02f, -2.34123487e-02f, 4.73177284e-02f, -3.92509066e-03f,
  1.33089215e-01f, 7.01900646e-02f, -9.34664533e-03f, 9.09118727e-02f, 5.65604456e-02f, -1.76878050e-01f, -2.32374847e-01f, -2.62603670e-01f, -1.33178294e-01f, 3.07865050e-02f,
  -1.10346489e-01f, -1.83683619e-01f, -2.00245291e-01f, -2.18139097e-01f, -1.16207749e-01f, -1.22297205e-01f, -1.40603736e-01f, -1.94952309e-01f, -1.74437776e-01f, -3.68358850e-01f,
  1.17668964e-01f, 2.46613543e-03f, 8.75793993e-02f, 2.37395409e-02f, -4.35913503e-02f, 6.80321380e-02f, 2.58488394e-02f, -9.41012695e-04f, -1.83314690e-03f, -1.53181795e-02f,
  5.48841842e-02f, -1.57299656e-02f, -1.69698615e-02f, -6.18450530e-03f, 5.05283996e-02f, 6.23914879e-03f, 5.28240157e-03f, 1.83762668e-03f, -2.62376829e-03f, 5.84590882e-02f,
  4.51416150e-03f, -1.03804931e-01f, -5.59678897e-02f, -5.39526641e-02f, 1.12055549e-02f, -9.73449424e-02f, -6.08850308e-02f, -4.94481921e-02f, -1.22286558e-01f, -2.13404253e-01f,
  -5.08600138e-02f, -5.27394786e-02f, -3.62798921e-04f, 5.68512604e-02f, 5.95066845e-02f, 1.50645813e-02f, 2.33499352e-02f, -1.45768421e-02f, -1.34280547e-02f, 8.64600763e-03f,
  -1.84992619e-03f, 6.61744848e-02f, -5.81191964e-02f, -6.52348176e-02f, -8.78737792e-02f, -5.99896908e-03f, -2.22226456e-02f, -5.49939163e-02f, 8.21750704e-03f, -2.61764452e-02f,
  -1.34548033e-02f, -3.69232111e-02f, 2.43781134e-02f, 6.55955598e-02f, 1.34556759e-02f, 2.65187351e-03f, 8.71603489e-02f, 8.24759752e-02f, 4.14244784e-03f, -1.52977407e-02f,
  2.03697652e-01f, 7.90307000e-02f, -2.56070285e-03f, -9.01029557e-02f, 1.83413438e-02f, 1.52633833e-02f, 4.37007993e-02f, 2.58729365e-02f, 6.22205175e-02f, -1.63522027e-02f,
  1.38473526e-01f, 9.18350741e-03f, -2.81618885e-03f, 3.04937661e-02f, 4.08637971e-02f, 7.92216510e-03f, 1.83487851e-02f, -8.24076980e-02f, -6.29751831e-02f, 1.72425471e-02f,
  1.17585070e-01f, -6.81374297e-02f, -2.73810085e-02f, -4.35856124e-03f, 2.12351084e-02f, 4.07751463e-02f, 2.66687088e-02f, -3.89589183e-02f, -7.53302574e-02f, 4.02632952e-02f,
  2.72244718e-02f, -4.09777090e-02f, -1.20985821e-01f, 8.14483985e-02f, 2.79587470e-02f, 1.15433171e-01f, -4.79036756e-02f, 7.26823434e-02f, 1.44258961e-01f, 7.84518942e-02f,
  -7.90333599e-02f, 4.63823304e-02f, 1.04287796e-01f, 1.58480387e-02f, -4.87095490e-02f, -4.10083234e-02f, 8.72039199e-02f, 4.53229062e-02f, -6.34428710e-02f, 3.51069495e-02f,
  3.96857690e-03f, -1.20928148e-02f, 7.82062635e-02f, 5.92347831e-02f, -1.74719580e-02f, 5.99297546e-02f, -4.84045371e-02f, 7.68417213e-03f, -6.13782890e-02f, -1.59110141e-03f,
  -2.79683799e-01f, -8.88552517e-02f, 2.50518676e-02f, 1.06267044e-02f, 1.85960215e-02f, -1.21511303e-01f, -3.34159173e-02f, -4.88713197e-03f, -5.68412580e-02f, 2.10078415e-02f,
  -1.70172621e-02f, 4.15538363e-02f, -5.86972758e-02f, -7.66200945e-02f, 6.11951947e-02f, 5.21758161e-02f, -4.76136915e-02f, -9.13369507e-02f, 5.75115457e-02f, -7.51265809e-02f,
  -9.85583737e-02f, -4.35394049e-02f, -1.55085735e-02f, 1.10849948e-03f, 2.38732286e-02f, 2.36073658e-02f, -9.00596678e-02f, -7.07019642e-02f, -8.36880952e-02f, 1.55154578e-02f,
  3.76217179e-02f, 2.29285695e-02f, -6.92085475e-02f, -6.52013943e-02f, 3.67403403e-02f, 1.12377191e-02f, 4.51565385e-02f, 6.93594292e-02f, -5.29871471e-02f, -1.86218172e-02f,
  -5.87247647e-02f, 2.24945750e-02f, 1.23761715e-02f, 3.51798013e-02f, -3.75806168e-02f, -4.68930267e-02f, 1.05971759e-02f, 6.16747774e-02f, -8.49873573e-02f, 9.85828564e-02f,
  6.49543256e-02f, 3.96169648e-02f, 6.03806302e-02f, 3.50623131e-02f, 2.79201660e-03f, 4.78572398e-02f, 5.32036647e-02f, -1.19414332e-03f, -1.68175325e-02f, -6.82199700e-03f,
  2.02304274e-01f, 1.27087876e-01f, 7.44980127e-02f, -3.92615795e-03f, 5.10766208e-02f, 4.25650105e-02f, 7.52423424e-03f, -4.05435421e-04f, 7.54650980e-02f, -6.06904924e-02f,
  -8.56722295e-02f, 5.71812093e-02f, 4.46043983e-02f, -1.50731066e-02f, 9.01979953e-02f, -7.69176036e-02f, 1.50921270e-02f, 9.09717903e-02f, -2.64637498e-03f, -4.29086573e-02f,
  8.92750639e-03f, 8.10732786e-03f, 6.41423315e-02f, -2.31900159e-02f, -2.60409880e-02f, 4.18100730e-02f, -2.05350704e-02f, -5.95799880e-03f, 3.43227349e-02f, -4.32386212e-02f,
  3.14795822e-02f, 1.42039925e-01f, -2.37876251e-01f, -7.32742175e-02f, -6.14396157e-03f, 8.88965428e-02f, 3.10865164e-01f, 2.57924944e-01f, 1.49076462e-01f, 1.75464675e-01f,
  1.37087971e-01f, -6.04156516e-02f, 4.15016040e-02f, 4.12565544e-02f, -8.63783062e-03f, 6.22839630e-02f, -5.18298941e-03f, -1.06939025e-01f, -2.68784314e-01f, -1.05710030e-01f,
  -7.13129789e-02f, -1.07449785e-01f, -6.71165138e-02f, -1.30373850e-01f, 1.14509393e-03f, -9.00516137e-02f, -1.20320357e-02f, -1.25219956e-01f, 1.66861676e-02f, -1.00593470e-01f,
  -2.41924509e-01f, 1.20134577e-01f, -1.18526146e-01f, 1.46864159e-02f, -1.37765720e-01f, -3.96115929e-02f, 1.20769002e-01f, -9.67453569e-02f, 3.83950472e-02f, 1.68092027e-02f,
  4.87203896e-02f, -3.59558798e-02f, 8.15705135e-02f, 2.49367021e-02f, 4.69275117e-02f, 3.28426104e-04f, -1.41067840e-02f, -1.95864346e-02f, -3.96894068e-02f, 4.24771495e-02f,
  2.02646703e-02f, 8.53289962e-02f, -7.19914958e-02f, 6.16846271e-02f, -3.40966857e-03f, -6.73931092e-02f, -8.78009573e-02f, 9.08654481e-02f, -2.48423554e-02f, -3.69503051e-02f,
  -1.98361091e-02f, -9.08718258e-02f, 1.63264237e-02f, 9.03880075e-02f, -2.01714854e-03f, 2.05831341e-02f, -7.34638944e-02f, -3.46918739e-02f, 7.26385266e-02f, -3.85740446e-03f,
  -5.59764765e-02f, 3.56489420e-02f, -7.75987282e-02f, 6.40833452e-02f, -5.95403910e-02f, 1.28729185e-02f, -6.46778420e-02f, -1.40229501e-02f, -7.15565905e-02f, 6.55338466e-02f,
  2.60388590e-02f, -7.21330335e-03f, 3.41799818e-02f, -1.54250832e-02f, 1.48672005e-03f, -2.68403683e-02f, -3.01436917e-03f, 7.75777549e-02f, 7.23025575e-02f, -4.26424108e-02f,
  -1.70003980e-01f, -2.11950801e-02f, 1.83699448e-02f, 7.33284354e-02f, -4.68857810e-02f, -4.12751064e-02f, -6.45432025e-02f, 2.43654028e-02f, 1.68854941e-03f, -4.18642871e-02f,
  1.59512125e-02f, 3.93439457e-03f, 5.00501283e-02f, 3.06929071e-02f, -2.11736802e-02f, -5.79735376e-02f, 4.24844436e-02f, -9.10308808e-02f, 1.00974794e-02f, 5.08073494e-02f,
  8.54873806e-02f, 7.72752464e-02f, 2.46017035e-02f, 1.08481850e-02f, 4.28240411e-02f, -9.19504017e-02f, 2.35277344e-03f, -7.22417310e-02f, -3.67086343e-02f, -2.74620131e-02f,
  -3.93141538e-01f, -9.28788111e-02f, 3.85379307e-02f, -1.20070234e-01f, -1.93924099e-01f, -1.21239007e-01f, -2.43553907e-01f, -1.97925903e-02f, -3.18602496e-03f, -1.09464325e-01f,
  -1.04796700e-01f, -9.38817635e-02f, -3.60482782e-02f, 1.37494981e-01f, 6.12713732e-02f, -1.31706884e-02f, 1.20879054e-01f, 1.57177731e-01f, 1.42233923e-01f, -8.45669731e-02f,
  2.66619623e-02f, 1.77430268e-02f, 6.24563731e-02f, 6.06639544e-03f, -1.76645871e-02f, 8.66047591e-02f, -4.01833430e-02f, -4.55651479e-03f, 1.46053936e-02f, 1.52061448e-01f,
  3.34362239e-02f, -6.90585375e-02f, 1.42542273e-02f, -1.82347577e-02f, -1.27951559e-02f, 9.81202871e-02f, -9.27583221e-03f, 1.03987813e-01f, 7.59349093e-02f, -1.67245027e-02f,
  -3.24915498e-02f, -8.51455797e-03f, 1.98032474e-03f, 1.14460818e-01f, -1.35815879e-02f, 3.62903327e-02f, 6.86130226e-02f, 1.29690781e-01f, 2.69834753e-02f, 6.90216497e-02f,
  -3.54753584e-02f, -1.59473836e-01f, -1.43872291e-01f, 3.88567895e-02f, 1.14937268e-01f, 3.79664183e-04f, -4.16181721e-02f, 5.03509119e-02f, -2.85990369e-02f, -5.28162196e-02f,
  2.61325184e-02f, 7.26628155e-02f, 4.67164413e-04f, -8.54688417e-03f, 2.22539995e-02f, -8.86088063e-04f, -2.00906880e-02f, -2.14436022e-03f, 1.66559722e-02f, 2.94606388e-02f,
  5.83246462e-02f, 6.71355566e-03f, 2.44086478e-02f, -4.51253690e-02f, 5.31954095e-02f, -3.41086872e-02f, -5.80607280e-02f, 4.27216552e-02f, -4.17174660e-02f, 2.60274000e-02f,
  7.47224838e-02f, -3.75433937e-02f, -1.32159237e-03f, 1.99092161e-02f, 4.34402674e-02f, -1.54653564e-02f, -2.97184158e-02f, 2.54038069e-03f, 2.21645441e-02f, 1.09033566e-02f,
  -2.08658502e-01f, 5.38192205e-02f, -1.17519185e-01f, 2.30282266e-02f, -2.26508100e-02f, 8.03012624e-02f, -1.09629333e-01f, -1.74368713e-02f, -4.56258617e-02f, 2.10384112e-02f,
  -7.04632849e-02f, -5.53412922e-02f, 6.67538913e-03f, 8.52829665e-02f, -7.90766254e-02f, 1.71098653e-02f, -2.82351822e-02f, 5.01366854e-02f, -1.64006054e-02f, -7.05103800e-02f,
  5.16308919e-02f, -2.23481089e-01f, -1.68105453e-01f, -1.19918071e-01f, -1.40463814e-01f, -1.49937987e-01f, -1.10130876e-01f, -1.60022244e-01f, -1.05950110e-01f, -1.75198615e-01f,
  1.09290548e-01f, 2.04466149e-01f, -6.35797009e-02f, -2.10942551e-02f, 6.37714118e-02f, 2.61707991e-01f, 3.72906834e-01f, 2.24840298e-01f, -2.04459727e-02f, 1.04751706e-01f,
  7.59215504e-02f, -8.44437554e-02f, -1.22631744e-01f, -1.06388792e-01f, 4.22172509e-02f, 1.43098935e-01f, -4.60778698e-02f, -1.32065147e-01f, -9.65757221e-02f, 7.99868256e-02f,
  -6.40681237e-02f, -1.27040789e-01f, -1.06929712e-01f, -9.30455551e-02f, -2.18863532e-01f, -1.57617047e-01f, 2.06668992e-02f, -1.28960013e-01f, -4.57961150e-02f, -2.92278826e-01f,
  1.07380480e-01f, -7.75767164e-03f, -5.44871092e-02f, -3.35364342e-02f, -1.93910170e-02f, 2.66293474e-02f, 4.40717489e-02f, 1.00297118e-02f, 3.82387377e-02f, -7.90438950e-02f,
  -3.91605869e-02f, -5.96616194e-02f, 1.23219648e-02f, 1.92343444e-02f, 2.90979892e-02f, 3.82249220e-03f, -9.46279913e-02f, -1.02917217e-01f, 1.95944123e-02f, -7.78683797e-02f,
  -6.28759116e-02f, -5.52083924e-03f, 2.68921591e-02f, 7.49838213e-03f, -6.75617754e-02f, -8.01683888e-02f, -3.15532014e-02f, -2.83534601e-02f, 9.89754945e-02f, -6.16695061e-02f,
  -2.75259744e-02f, -2.83357874e-02f, 4.49592508e-02f, -1.87899880e-02f, 1.83728281e-02f, -1.17561538e-02f, -3.96502987e-02f, 4.61379141e-02f, -5.41671598e-03f, 2.22414378e-02f,
  -3.51905301e-02f, 5.55588454e-02f, 3.24177630e-02f, 5.67027694e-03f, -4.80927266e-02f, 4.39034104e-02f, -1.61524285e-02f, 7.39364177e-02f, 6.55193999e-02f, -2.99170259e-02f,
  4.72364500e-02f, -5.21063432e-02f, 2.59965248e-02f, -8.07920396e-02f, -1.26741212e-02f, -2.55834348e-02f, -5.72069734e-02f, -1.46615971e-02f, 1.01611264e-01f, -7.39237061e-04f,
  1.80811346e-01f, -3.44834290e-02f, 2.84896307e-02f, -1.03998020e-01f, -1.13799766e-01f, -4.32043895e-02f, -1.35161085e-02f, -4.77220975e-02f, -1.27026975e-01f, 2.06809007e-02f,
  -3.13925296e-02f, 2.04026829e-02f, -3.32490280e-02f, 2.46631578e-02f, 9.13689435e-02f, 8.62478539e-02f, -2.08893474e-02f, -2.71695461e-02f, -9.04801488e-02f, -5.28467037e-02f,
  8.47230777e-02f, 8.63947123e-02f, 1.43784896e-01f, 1.43466249e-01f, -7.06219524e-02f, 9.09764171e-02f, 5.15560769e-02f, 1.37557119e-01f, 1.79401949e-01f, 1.60579503e-01f,
  3.15530509e-01f, -3.60680223e-02f, -2.53973871e-01f, 3.33482772e-02f, 1.80672631e-01f, 3.73956747e-03f, 1.81312039e-02f, 7.48571381e-02f, 9.16833580e-02f, 1.14900135e-01f,
  1.53279200e-01f, 1.36600569e-01f, 6.27545416e-02f, -6.66166916e-02f, -1.68831602e-01f, -1.37473941e-01f, -1.24072686e-01f, -2.29218021e-01f, -1.19946204e-01f, -1.27280429e-02f,
  -3.46828327e-02f, 1.16371410e-02f, -5.37010990e-02f, -1.74200788e-01f, -2.84194684e-04f, -6.01887843e-03f, -1.96935460e-01f, -9.79482085e-02f, -5.77769689e-02f, -2.10078001e-01f,
  -1.55238509e-01f, 1.99878693e-01f, -2.57730167e-02f, 1.61995322e-01f, -1.20061534e-02f, -8.89656227e-03f, 1.17257854e-03f, -1.23026622e-02f, 1.12823069e-01f, -9.84465927e-02f,
  1.53862432e-01f, -3.18367057e-03f, 5.52095845e-03f, 7.77021796e-02f, -4.52362038e-02f, 4.10395563e-02f, -1.15711607e-01f, -1.60926282e-01f, -1.25454307e-01f, -4.86178212e-02f,
  7.00025680e-03f, 3.17335837e-02f, 3.73351797e-02f, 3.08104195e-02f, -9.61888507e-02f, -3.50868143e-02f, 3.41481194e-02f, -6.93805888e-02f, -5.04891239e-02f, -4.68640849e-02f,
  -8.18605050e-02f, 2.89794821e-02f, 7.55997151e-02f, 2.88368203e-02f, -3.00456285e-02f, 2.12613679e-02f, 2.33888496e-02f, 6.26671165e-02f, -4.10244465e-02f, -6.95018917e-02f,
  1.87143311e-02f, -3.98289375e-02f, -7.13033825e-02f, -7.10030086e-03f, 6.05690703e-02f, -6.00621812e-02f, -1.97910517e-02f, -7.46890903e-02f, -1.31827537e-02f, -1.06827996e-03f,
  2.05716584e-02f, 2.51976047e-02f, 1.17227603e-02f, -2.11925730e-02f, 2.20695883e-02f, -3.37099880e-02f, 3.09200399e-02f, -4.38992567e-02f, 5.06435148e-02f, 9.32764076e-03f,
  -3.27701718e-02f, 1.48241818e-01f, -1.01618078e-02f, 5.81451766e-02f, 3.15089524e-02f, -3.70287523e-02f, 4.64327335e-02f, 4.80610207e-02f, 1.12972409e-01f, -1.12522785e-02f,
  4.51260023e-02f, -3.14489119e-02f, 7.45975152e-02f, -3.60260345e-02f, 8.15704763e-02f, 7.57789910e-02f, -4.62699533e-02f, -1.60842855e-02f, -2.02604439e-04f, 5.25033064e-02f,
  -1.17235981e-01f, -5.72574064e-02f, -2.03377996e-02f, -1.00932248e-01f, -4.18574959e-02f, 1.17982112e-01f, -1.49809554e-01f, -2.42285393e-02f, -1.95194054e-02f, -1.61838651e-01f,
  -1.57428876e-01f, -3.90278190e-01f, -1.93151057e-01f, -3.30661774e-01f, -1.79722890e-01f, 8.03170428e-02f, 3.13589536e-02f, 7.64249563e-02f, -2.54400331e-03f, -2.58978426e-01f,
  -1.69311687e-01f, -2.30980981e-02f, -1.10350609e-01f, 5.99590950e-02f, 1.43021211e-01f, -9.70427990e-02f, -6.92515224e-02f, 4.13228683e-02f, 2.93525666e-01f, 6.68618977e-02f,
  -8.66457969e-02f, -6.73514083e-02f, 4.52590585e-02f, 4.74420488e-02f, -2.17995360e-01f, -7.34427795e-02f, -1.99615210e-01f, -1.39691187e-02f, -1.04346387e-01f, -2.15247482e-01f,
  -2.34753639e-01f, -1.31902814e-01f, 7.91938305e-02f, -2.22708657e-02f, -5.39983027e-02f, 9.32695940e-02f, -9.14646834e-02f, 8.84541869e-02f, -5.02014235e-02f, -4.41412777e-02f,
  -6.55516163e-02f, -3.46008539e-02f, -4.08207811e-03f, -2.63870955e-02f, 2.40930822e-02f, 5.28104156e-02f, -1.16929431e-02f, 3.02417949e-03f, 4.14008647e-02f, -6.53688610e-02f,
  -1.06123254e-01f, 2.80116778e-02f, 6.61333427e-02f, 1.08681455e-01f, 1.44778416e-01f, -4.93836589e-02f, -3.40062305e-02f, 1.22314915e-01f, 1.05131343e-01f, -5.72521314e-02f,
  -4.70629893e-02f, -2.59994958e-02f, 3.47711816e-02f, 5.66379204e-02f, 3.44995670e-02f, -4.47962731e-02f, -4.39004228e-02f, -3.89431752e-02f, 3.95186245e-02f, 4.05567102e-02f,
  6.59891032e-03f, -6.41751662e-02f, -1.49784982e-02f, -5.30536473e-02f, -7.09101632e-02f, 3.87766771e-02f, 2.09242254e-02f, -1.58726443e-02f, -3.47959660e-02f, -3.13679352e-02f,
  1.98195186e-02f, 5.32968305e-02f, -2.72682495e-02f, 7.37339258e-03f, -2.71288306e-02f, -4.25812900e-02f, 8.88884887e-02f, 1.04474640e-02f, 3.24030742e-02f, 8.37420225e-02f,
  -8.92834291e-02f, 2.25791723e-01f, -1.51173264e-01f, 1.75833944e-02f, -6.11795392e-03f, -1.29358908e-02f, -1.11766607e-01f, 5.13961017e-02f, 5.75060630e-03f, -6.18682280e-02f,
  4.65596355e-02f, -5.70215136e-02f, -9.51147527e-02f, 7.24498555e-02f, -7.14134984e-03f, 3.81709971e-02f, -5.07516079e-02f, -3.83674316e-02f, 1.03369720e-01f, -9.91270840e-02f,
  -3.71424891e-02f, 8.07020366e-02f, -1.25089185e-02f, 7.96328634e-02f, -5.15861809e-03f, 8.33878815e-02f, 8.51929560e-02f, 8.87150615e-02f, 7.22744092e-02f, -9.09519568e-02f,
  -5.06972708e-02f, -2.68867686e-02f, 2.42099389e-01f, 7.09877983e-02f, 6.92042783e-02f, 1.81159094e-01f, 3.09286416e-01f, 1.67099148e-01f, 6.97290152e-02f, 1.25404418e-01f,
  -1.55777074e-02f, -9.37238559e-02f, -9.99974087e-02f, 3.49149369e-02f, 2.08994836e-01f, 2.36774608e-01f, 2.45222941e-01f, 2.43894383e-01f, 8.41915980e-02f, 1.57104015e-01f,
  1.34552315e-01f, 6.75047189e-02f, 1.24722287e-01f, -3.67187825e-03f, -5.75992465e-02f, 9.60150175e-03f, 3.00396117e-03f, 1.52125722e-02f, -2.54096719e-03f, -1.36676863e-01f,
  -1.02270409e-01f, -9.72556472e-02f, -2.12433245e-02f, 1.89674534e-02f, -5.63028306e-02f, -3.98403406e-02f, 1.20016644e-02f, 1.96769312e-02f, -1.29072458e-01f, 6.32634833e-02f,
  -1.02429055e-01f, -9.20743197e-02f, -2.46161930e-02f, -8.10182616e-02f, -2.25079712e-02f, 3.87745388e-02f, 1.53279409e-01f, 5.73674254e-02f, 9.28609446e-02f, 4.17289324e-02f,
  -3.13872509e-02f, 7.94303939e-02f, 4.92919609e-02f, -4.05917391e-02f, 1.12434968e-01f, -7.32899830e-02f, -8.11906159e-02f, 2.07219515e-02f, 5.52606955e-02f, 8.21523182e-03f,
  1.16291400e-02f, 3.51564027e-02f, 4.65646833e-02f, -4.42044325e-02f, 2.58047059e-02f, -8.61149281e-02f, -2.85291579e-02f, 3.47406045e-02f, 6.31555691e-02f, -6.76806569e-02f,
  1.08848438e-01f, 1.92818400e-02f, 3.55706923e-02f, -1.72113907e-02f, -1.71462763e-02f, 6.25091493e-02f, 3.40116732e-02f, -1.88013036e-02f, -3.03750392e-02f, 4.05288674e-02f,
  1.37439265e-03f, 1.27750775e-02f, -1.80509444e-02f, 1.53886294e-02f, -1.09729450e-02f, 8.45583752e-02f, -4.01158892e-02f, -7.45688155e-02f, -7.06050768e-02f, 6.50506169e-02f,
  -1.12307087e-01f, 1.42210692e-01f, -5.50521314e-02f, -8.10942203e-02f, -2.82814130e-02f, 6.09939694e-02f, -1.46791756e-01f, 5.97543679e-02f, -8.45481381e-02f, -7.29853287e-02f,
  -8.33862368e-03f, 3.25076655e-02f, 5.66077828e-02f, -3.20994742e-02f, 2.86755245e-02f, 1.11245997e-02f, 1.48917187e-03f, -1.84532218e-02f, -2.74132844e-02f, 4.32578009e-03f,
  -1.85409766e-02f, 9.95880067e-02f, -8.67350101e-02f, -4.63023894e-02f, -5.74887395e-02f, -9.09199566e-02f, -9.20043886e-02f, -3.25537063e-02f, -7.91986957e-02f, 3.70400883e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.47053805e-02f, 4.02762368e-02f, 1.75003745e-02f, -1.73278198e-01f, -1.27590701e-01f, -4.41009849e-02f, 4.04777788e-02f, -9.48412493e-02f, -1.22435808e-01f, 3.88753563e-02f,
  -1.43624227e-02f, 5.45987161e-03f, -2.68403869e-02f, 6.30935282e-03f, 1.15859486e-01f, -1.11483866e-02f, -2.63583492e-02f, 4.74910885e-02f, -8.92808586e-02f, -1.14247650e-01f,
  -7.30944350e-02f, -7.25838915e-02f, -3.51463817e-02f, -1.02939524e-01f, -9.24245268e-02f, -4.78301384e-02f, -1.69361718e-02f, 4.81045619e-02f, -6.54293820e-02f, -2.62803826e-02f,
  1.25999898e-01f, 4.51919772e-02f, -4.06226218e-02f, -5.92929982e-02f, 8.02023709e-02f, 6.92325532e-02f, 2.93938839e-03f, -3.42693515e-02f, -6.77873790e-02f, 8.06209370e-02f,
  5.52476458e-02f, -1.08970426e-01f, 9.31407139e-03f, -6.18071072e-02f, -6.94998503e-02f, -2.72064265e-02f, -4.72630970e-02f, -7.56070018e-02f, -2.13553067e-02f, 4.59068008e-02f,
  -2.29102727e-02f, 7.13256672e-02f, 7.92285427e-02f, 8.15034062e-02f, -1.51310731e-02f, 1.00906372e-01f, 1.02506064e-01f, -6.29879758e-02f, -5.78568876e-02f, -1.04074456e-01f,
  9.36915512e-06f, 2.91566104e-02f, -3.48046944e-02f, -8.43928680e-02f, 7.84526616e-02f, 1.11511182e-02f, -3.87271494e-02f, -1.88979805e-02f, 4.18051481e-02f, 5.10038137e-02f,
  -1.06830699e-02f, 8.94497707e-02f, -6.88812882e-03f, -1.49976881e-02f, 5.10459766e-02f, -3.73844281e-02f, 2.78302771e-03f, 4.45397682e-02f, 8.84628519e-02f, -2.28044949e-02f,
  1.53261947e-03f, 6.52155653e-02f, -5.28714880e-02f, 1.60082672e-02f, -2.14980002e-02f, -1.19147347e-02f, 2.60771606e-02f, 1.65926274e-02f, 2.36855801e-02f, 2.16186550e-02f,
  -4.00111750e-02f, 1.57003626e-01f, 4.80781309e-02f, -6.58789650e-02f, -5.42407110e-02f, 3.43755968e-02f, -7.75019452e-02f, 5.88635728e-02f, -4.73968983e-02f, -7.10600838e-02f,
  -6.93573337e-03f, 4.07953709e-02f, -4.01782058e-03f, -8.94569382e-02f, -7.02933408e-03f, -1.30364690e-02f, -8.08458030e-02f, -3.34056653e-02f, 1.31394586e-03f, -7.04774633e-03f,
  8.78706649e-02f, 3.43739651e-02f, 1.09985948e-01f, 9.76464674e-02f, -5.18533140e-02f, 9.57354456e-02f, 1.36323154e-01f, -5.14671318e-02f, 7.24719092e-02f, -8.23280364e-02f,
  2.73051202e-01f, 1.77416533e-01f, 1.06323205e-01f, 1.41902834e-01f, 1.53343350e-01f, 1.26753226e-01f, 2.80112214e-02f, 3.17743868e-02f, -1.59194898e-02f, -2.74015125e-03f,
  1.86258286e-01f, 9.50121731e-02f, -2.77280863e-02f, -7.05180243e-02f, -4.69910987e-02f, -1.74842402e-02f, -4.63933907e-02f, -8.93927366e-02f, -1.19823724e-01f, 9.71914679e-02f,
  7.22602233e-02f, 6.08277768e-02f, 8.05571228e-02f, -2.94584241e-02f, 4.80066277e-02f, -2.85750423e-02f, 1.13956407e-01f, 1.81998268e-01f, 1.82408050e-01f, 1.15620129e-01f,
  1.69967666e-01f, 2.10120440e-01f, -1.52080640e-01f, 4.42160945e-03f, 4.64755605e-04f, -6.39260933e-02f, -8.64654593e-03f, -1.05622530e-01f, -4.40183617e-02f, -2.48422492e-02f,
  1.27996609e-01f, -2.66578030e-02f, -5.41106537e-02f, 4.02942784e-02f, -4.34741974e-02f, -9.15590152e-02f, -1.74376480e-02f, -8.76781251e-03f, -1.50795564e-01f, 8.33543241e-02f,
  5.93372667e-03f, 1.81210890e-01f, 1.31873503e-01f, -6.34840503e-02f, -3.50445844e-02f, 8.37724097e-03f, -2.69177128e-02f, 2.95264665e-02f, -5.81567772e-02f, -9.31993425e-02f,
  -3.67862382e-03f, 5.73457889e-02f, -5.55834211e-02f, 1.33108711e-02f, -2.99702026e-02f, 3.23615558e-02f, -4.25160043e-02f, -4.43060137e-03f, 6.30557165e-02f, -1.56773385e-02f,
  -3.92756611e-02f, 5.33110499e-02f, -9.07812268e-04f, -7.03280196e-02f, -2.15860945e-03f, 7.39713013e-02f, 2.51948703e-02f, -7.95923695e-02f, 4.75011878e-02f, -1.31937675e-02f,
  -2.23983955e-02f, 6.53672293e-02f, -3.66293639e-02f, -1.03081949e-01f, -2.81667802e-02f, 1.28043350e-02f, 5.88477142e-02f, -4.52948697e-02f, -4.12437469e-02f, -3.35826213e-03f,
  -1.16476707e-01f, -5.23640178e-02f, 2.42901817e-02f, -9.72154513e-02f, 1.36106033e-02f, -3.96651141e-02f, 7.98085555e-02f, 3.80337727e-03f, 3.43041401e-03f, -1.08461775e-01f,
  5.31433262e-02f, -2.63050273e-02f, 4.36027944e-02f, -1.78481117e-02f, 3.82115059e-02f, -1.36527075e-02f, 9.73387994e-03f, 2.75948402e-02f, -1.07989786e-02f, -1.61118396e-02f,
  -1.18782043e-01f, 1.58842765e-02f, -1.00879006e-01f, -9.00880545e-02f, -5.41492663e-02f, -4.85127466e-03f, -7.38440529e-02f, -6.74194796e-03f, -8.86504129e-02f, -1.66414037e-01f,
  -1.79441288e-01f, 9.39107090e-02f, 1.21141858e-01f, -4.48499098e-02f, 1.31082609e-01f, 1.25411555e-01f, 1.30945072e-01f, -3.99776958e-02f, -4.64714803e-02f, 7.02621862e-02f,
  2.15355325e-02f, -3.87313329e-02f, -7.78758675e-02f, -3.23686115e-02f, 1.90392006e-02f, 8.94093364e-02f, 9.35071483e-02f, -7.92613029e-02f, -4.49549854e-02f, 5.23127541e-02f,
  6.70638382e-02f, -4.08655889e-02f, -1.00905877e-02f, -6.14489056e-02f, -1.19683094e-01f, -7.32923001e-02f, -4.53963410e-03f, 4.69604954e-02f, -4.16445509e-02f, 1.97258797e-02f,
  -4.17151786e-02f, 9.81089994e-02f, -7.68808424e-02f, 3.31672914e-02f, 6.55289888e-02f, -1.79785199e-03f, -8.19451809e-02f, -5.66247404e-02f, -9.42174420e-02f, -2.14517005e-02f,
  -1.47279622e-02f, 2.90372111e-02f, -2.87884790e-02f, -1.35446084e-03f, -9.01023746e-02f, -7.07378313e-02f, -9.77764949e-02f, 1.19036455e-02f, 6.60287887e-02f, 5.76897301e-02f,
  1.15202211e-01f, 7.01162145e-02f, -2.43270807e-02f, -2.27502827e-02f, 6.18726201e-02f, -8.67170393e-02f, 6.62492812e-02f, -1.75765734e-02f, 8.06412622e-02f, -1.14614807e-01f,
  -6.89600781e-02f, 7.55121708e-02f, -5.02817668e-02f, -6.10760525e-02f, -2.48205736e-02f, -7.71687850e-02f, -6.18191883e-02f, 1.50487991e-02f, 7.16393292e-02f, 2.23551057e-02f,
  -4.20135148e-02f, 2.82705687e-02f, 4.73201238e-02f, -6.24770224e-02f, -7.04324245e-02f, 5.36831990e-02f, 8.10500979e-02f, 6.52908608e-02f, -2.60817334e-02f, 4.73923869e-02f,
  -1.38543025e-02f, 3.71128805e-02f, -1.34319654e-02f, 2.18923967e-02f, 2.94704847e-02f, 6.35740682e-02f, -3.37228887e-02f, -3.43254255e-03f, 4.14271280e-02f, 6.56845048e-02f,
  -1.90868735e-01f, 1.54281154e-01f, -5.41501604e-02f, -4.36500423e-02f, -8.93519670e-02f, -3.35173197e-02f, 7.74113983e-02f, -6.97480561e-03f, -4.85961176e-02f, 6.21930957e-02f,
  5.87005876e-02f, -8.10834914e-02f, 9.51575767e-03f, -8.09844881e-02f, -2.76634395e-02f, 1.31122610e-02f, 2.13611759e-02f, -3.92350741e-02f, -4.16909233e-02f, -3.07305548e-02f,
  5.02667800e-02f, -4.57549244e-02f, -1.19676895e-01f, 4.99044508e-02f, 2.32673213e-02f, -2.35532783e-02f, -8.96441657e-03f, -1.03243090e-01f, -2.84066447e-03f, -2.53386721e-02f,
  -7.65043944e-02f, -3.73492949e-02f, 3.48715112e-02f, -7.04116598e-02f, 6.96358606e-02f, -5.54478401e-03f, 1.72591750e-02f, 5.49736805e-02f, -8.45880210e-02f, -5.40718660e-02f,
  -2.67465934e-02f, -8.03248286e-02f, -7.25992545e-02f, 8.98826588e-03f, 8.34674574e-03f, -1.80638079e-02f, -6.33685142e-02f, -5.38752042e-02f, 7.59934634e-02f, 9.66035649e-02f,
  -2.25277171e-02f, 4.41732556e-02f, -7.08165914e-02f, -5.56388162e-02f, -3.04340664e-02f, -2.33468078e-02f, 1.07567459e-01f, -1.63187198e-02f, 3.65524143e-02f, 2.32330095e-02f,
  9.65030268e-02f, -9.42265242e-02f, 1.03145458e-01f, -5.11971302e-02f, -4.95149493e-02f, -6.80568516e-02f, -7.20916837e-02f, 2.73917578e-02f, 2.71940734e-02f, -3.91605124e-03f,
  -2.45745331e-02f, 7.36750439e-02f, 8.16570595e-02f, 5.09265587e-02f, 6.97175264e-02f, 8.44342336e-02f, 2.36422345e-02f, -1.50860567e-02f, 6.09421805e-02f, -8.47504139e-02f,
  5.92263974e-02f, -1.75926369e-02f, 7.31473640e-02f, -7.50162527e-02f, -3.16588469e-02f, 2.97559407e-02f, -5.63932508e-02f, -2.33826004e-02f, 7.38330781e-02f, 4.76738922e-02f,
  -5.70828430e-02f, 5.65702235e-03f, 4.13896255e-02f, -4.08832543e-03f, -8.27487558e-02f, -5.77738434e-02f, -5.04131764e-02f, 4.46667895e-02f, -1.53936667e-03f, -8.05058926e-02f,
  5.82626425e-02f, -5.42721227e-02f, -7.08345324e-02f, 3.10221110e-02f, 3.79507728e-02f, 2.29161009e-02f, 1.56244533e-02f, -1.53715219e-02f, 8.06094185e-02f, 1.94449890e-02f,
  5.42754047e-02f, 8.40995163e-02f, 1.10024381e-02f, -6.55009821e-02f, 6.40419349e-02f, -2.40098543e-05f, 5.07007018e-02f, 4.17495668e-02f, 2.37652920e-02f, -9.14338529e-02f,
  8.68025050e-02f, 3.76734622e-02f, 6.07833862e-02f, -9.22975317e-02f, -2.90808678e-02f, -2.69749537e-02f, 3.85733284e-02f, 4.62294333e-02f, -6.60979822e-02f, 6.75039440e-02f,
  -3.90651487e-02f, 4.37405668e-02f, 1.80534143e-02f, -1.25156192e-03f, -3.02830990e-02f, 9.75422282e-03f, -5.10169230e-02f, -7.65064731e-02f, 5.76044209e-02f, -2.13420931e-02f,
  8.15967619e-02f, 9.50832590e-02f, -1.02244858e-02f, -3.27044204e-02f, -5.35353124e-02f, 5.16767837e-02f, 9.53129083e-02f, -5.15786139e-03f, -1.38027593e-02f, -6.05678000e-02f,
  -1.41712025e-01f, 5.94413467e-02f, 2.64994912e-02f, 8.03742260e-02f, 8.66620764e-02f, -2.64088474e-02f, 9.39430743e-02f, 1.74120024e-01f, 5.93679547e-02f, 5.07673584e-02f,
  -4.47674021e-02f, 1.49908707e-01f, 7.24481791e-03f, 1.72667965e-01f, 6.58245161e-02f, 6.36347532e-02f, 1.77413493e-01f, 6.99349642e-02f, 8.22795331e-02f, -2.54888721e-02f,
  4.04321440e-02f, 8.18508044e-02f, -4.22575995e-02f, 6.01777062e-02f, 1.13008209e-01f, 1.13209710e-01f, 1.02256514e-01f, 6.70968965e-02f, 1.92683563e-02f, 9.69553813e-02f,
  -1.07466258e-01f, -1.15336269e-01f, 1.06523514e-01f, 4.17691767e-02f, 1.64112449e-02f, -2.63013244e-02f, 2.68016122e-02f, 1.50543256e-02f, 7.45660290e-02f, 1.26085128e-03f,
  6.55765757e-02f, -4.97809984e-03f, -9.69753042e-03f, -1.98027212e-02f, 3.08348369e-02f, 1.30594485e-02f, -1.46067291e-02f, -3.03244777e-02f, 9.84981582e-02f, 6.51038960e-02f,
  -2.13631839e-02f, -4.19690050e-02f, -9.96189192e-02f, 1.04633331e-01f, 8.66041258e-02f, -7.12284893e-02f, 5.99716455e-02f, -6.41003400e-02f, -3.62060070e-02f, 4.89490703e-02f,
  -3.53008322e-02f, 9.57315117e-02f, 6.21185862e-02f, -1.56519581e-02f, 6.87167123e-02f, -1.45494333e-02f, -3.68951261e-02f, 3.78992409e-02f, 6.48603663e-02f, 5.45427157e-03f,
  -6.88186139e-02f, 5.09096682e-02f, -4.53497805e-02f, -7.88010433e-02f, 5.50694317e-02f, 4.26353049e-03f, -4.31350842e-02f, 1.45543879e-03f, -9.61068943e-02f, 2.67385375e-02f,
  6.24337010e-02f, -5.74821420e-02f, -6.56142889e-04f, 2.19881758e-02f, 3.51820067e-02f, -3.31734642e-02f, -7.79609084e-02f, -4.43517640e-02f, 2.86563803e-02f, -5.08009642e-02f,
  2.46842522e-02f, -8.07055235e-02f, 1.24761246e-01f, 1.07625566e-01f, 4.74162698e-02f, -8.10003951e-02f, 4.53292169e-02f, -1.91680272e-03f, 1.68837118e-03f, -6.30525779e-03f,
  -7.14235753e-02f, -9.48093925e-03f, 4.48644049e-02f, 6.71541467e-02f, -9.49325785e-03f, 1.92244090e-02f, -8.90104473e-03f, 4.09726501e-02f, 2.26244493e-03f, -1.24728689e-02f,
  -1.08196363e-02f, 4.06638160e-02f, -1.12748832e-01f, 7.25079253e-02f, 7.31196553e-02f, 6.71008416e-03f, 2.05038302e-03f, 6.82168305e-02f, -8.57789889e-02f, 2.43950859e-02f,
  -1.79164708e-01f, 6.56821355e-02f, 1.08409904e-01f, 6.69786111e-02f, 5.67790382e-02f, -1.04091421e-01f, -2.05428854e-01f, 4.05710414e-02f, 4.84456345e-02f, 3.62507887e-02f,
  -2.60147434e-02f, -1.72219202e-02f, 3.31717394e-02f, 1.11463042e-02f, 7.86584057e-03f, 7.29923621e-02f, 1.40557200e-01f, 5.83508648e-02f, -1.64048582e-01f, -9.81485173e-02f,
  -2.74731461e-02f, -1.07134981e-02f, 3.46136838e-02f, -5.48798852e-02f, 9.71318632e-02f, 2.43708845e-02f, 6.02636151e-02f, -6.08714186e-02f, -4.06997427e-02f, 2.70000175e-02f,
  5.18399738e-02f, -1.80157721e-02f, -6.00188188e-02f, -6.75046369e-02f, 1.71466582e-02f, -6.17980538e-03f, -1.65424291e-02f, 3.63298431e-02f, -5.74835837e-02f, -4.18599695e-02f,
  -9.24698487e-02f, -5.14355823e-02f, 1.92382049e-05f, -8.56815428e-02f, -4.07912135e-02f, -8.71500652e-03f, -8.24373960e-02f, -1.59381535e-02f, 8.90093856e-03f, 5.64742163e-02f,
  3.20796631e-02f, -4.51174192e-02f, -2.35511772e-02f, -6.08855747e-02f, 9.66481864e-02f, -4.61094752e-02f, -4.67443690e-02f, 2.06047222e-02f, 5.51830046e-02f, 1.05070497e-03f,
  -2.02010032e-02f, 7.10611567e-02f, -5.27099846e-03f, 4.42495123e-02f, -2.06152834e-02f, 4.71871793e-02f, -5.59483692e-02f, -2.20879223e-02f, -6.58113062e-02f, 7.47913495e-02f,
  -6.24193214e-02f, -4.25188690e-02f, 9.48410109e-02f, 6.27484545e-02f, 6.90975711e-02f, 4.94227447e-02f, -1.74545273e-02f, -8.92569870e-02f, 3.18526961e-02f, -4.54177745e-02f,
  7.21566379e-02f, 4.05787490e-02f, 5.13816103e-02f, -1.38476631e-02f, 1.30865653e-03f, -9.08798501e-02f, -3.23636830e-02f, -4.69295867e-03f, -8.54862407e-02f, -1.42281326e-02f,
  7.76809379e-02f, -1.15141608e-01f, -5.54031357e-02f, -8.89761653e-03f, 4.85634021e-02f, -5.85613176e-02f, -2.28420645e-02f, 2.15780921e-02f, 2.44057551e-03f, -1.02423973e-01f,
  -1.40555665e-01f, -2.38513667e-02f, 5.09224422e-02f, 4.72325608e-02f, -1.24016710e-01f, -8.80085304e-02f, -5.34528308e-02f, -1.97569337e-02f, -1.01154312e-01f, -5.14255948e-02f,
  -8.01205859e-02f, -3.27839069e-02f, 1.89732900e-03f, -4.64438200e-02f, -7.18428986e-03f, -6.28499016e-02f, -1.69886332e-02f, -1.04783140e-01f, -6.95736781e-02f, -3.60858031e-02f,
  -3.38094532e-02f, 6.67948946e-02f, -5.80037795e-02f, -2.76586507e-02f, 3.33579741e-02f, -3.44022363e-02f, -5.27988151e-02f, 8.25958699e-02f, 2.07663458e-02f, -7.11823022e-03f,
  2.50717364e-02f, 1.99767966e-02f, -6.77809715e-02f, -4.47847173e-02f, -8.99506360e-03f, -4.30264929e-03f, -1.03436954e-01f, -7.85570219e-02f, -1.09830543e-01f, -1.46478802e-01f,
  -1.30989432e-01f, -2.00079810e-02f, 5.75258769e-03f, 6.92865774e-02f, 7.23312944e-02f, -7.60224760e-02f, 9.25547723e-03f, -4.82647941e-02f, -7.57809505e-02f, 5.93194515e-02f,
  6.47231787e-02f, 9.86218359e-03f, -7.12076202e-02f, -2.67452653e-02f, -6.18019849e-02f, 4.69064303e-02f, -4.66628373e-02f, 1.69632453e-02f, -8.47110301e-02f, -4.22089398e-02f,
  -6.15089238e-02f, 5.48846982e-02f, -5.24626710e-02f, 4.42069136e-02f, 1.40464294e-03f, -9.55960229e-02f, -9.28408746e-03f, -9.85004902e-02f, 4.51752916e-02f, 1.86315067e-02f,
  -1.26158655e-01f, -2.28270120e-03f, -4.80349399e-02f, -2.44703926e-02f, 7.64840022e-02f, -5.46136089e-02f, -3.78818661e-02f, -3.56384479e-02f, -1.00332119e-01f, 6.28640354e-02f,
  9.18647498e-02f, -8.37744866e-03f, -8.72201938e-03f, 2.07576938e-02f, 2.97163501e-02f, 6.23780750e-02f, -6.37713447e-02f, 7.77116269e-02f, -5.84073402e-02f, -3.21175456e-02f,
  7.44605660e-02f, 7.72563294e-02f, 5.77752180e-02f, 5.17264679e-02f, 5.56056330e-04f, -6.14458397e-02f, -6.28478155e-02f, 1.01556210e-02f, 1.81117095e-02f, -3.55646424e-02f,
  5.26485331e-02f, 5.50538301e-02f, -4.66449559e-02f, -4.64891316e-03f, -2.96325572e-02f, -5.98049648e-02f, 3.11093628e-02f, 1.92607362e-02f, -7.21315965e-02f, -3.22191343e-02f,
  1.90650284e-01f, -1.01079039e-01f, -3.09750549e-02f, 5.73318377e-02f, 6.99380636e-02f, 7.99440022e-04f, 5.43310419e-02f, 4.44793552e-02f, -7.01723769e-02f, -7.77010545e-02f,
  -8.41617957e-02f, -7.62233436e-02f, 3.34335603e-02f, -6.77362457e-02f, 5.33347856e-03f, 6.45403117e-02f, -1.80649059e-03f, -5.74750118e-02f, -9.60435793e-02f, -3.66260745e-02f,
  4.16854918e-02f, 1.41598275e-02f, 9.18812901e-02f, 1.20368758e-02f, 9.75212082e-02f, -3.61612416e-03f, 5.44858240e-02f, 9.48943049e-02f, -1.01285636e-01f, 6.19164892e-02f,
  1.47508875e-01f, -3.83928865e-02f, -3.65438372e-01f, -1.00164883e-01f, -1.17224790e-01f, -1.30692720e-01f, -8.17397162e-02f, -8.57945345e-03f, -3.09899468e-02f, -9.04833451e-02f,
  -1.34295598e-01f, -7.95307830e-02f, -5.26595414e-02f, -1.52826250e-01f, -1.31532967e-01f, -2.16307014e-01f, -7.65919164e-02f, -1.04861647e-01f, -1.21354528e-01f, 5.34597002e-02f,
  -1.30892128e-01f, -2.41699107e-02f, -1.40007377e-01f, -1.24604128e-01f, -5.80187999e-02f, -3.85942794e-02f, -1.86429977e-01f, -1.05584644e-01f, -5.73678985e-02f, -2.03170851e-01f,
  -2.39598781e-01f, -1.83283053e-02f, -1.05211228e-01f, 1.51569210e-02f, -1.76774524e-02f, 7.96379820e-02f, -5.81496954e-02f, 1.21518141e-02f, 1.02701455e-01f, 1.82642043e-02f,
  2.93244310e-02f, -4.54741381e-02f, 4.09737676e-02f, -9.77854133e-02f, -6.22836053e-02f, 6.98702633e-02f, 4.87558022e-02f, -1.00282915e-01f, -8.59533697e-02f, -3.09905224e-03f,
  6.96602687e-02f, -2.45719845e-03f, -1.08162791e-03f, -2.50318064e-03f, -2.98852380e-02f, -4.56164330e-02f, -1.09739853e-02f, -7.49238878e-02f, -5.63731082e-02f, -5.48599474e-02f,
  -2.86373906e-02f, 7.24347830e-02f, -7.90445581e-02f, -4.33547311e-02f, 5.38251214e-02f, 3.56721170e-02f, -6.70444220e-02f, -2.16349750e-03f, 2.57289093e-02f, -3.24280672e-02f,
  -4.38142270e-02f, 2.57411227e-02f, -9.09089576e-03f, 4.76350263e-02f, -5.30739613e-02f, -1.02961472e-04f, 1.44410683e-02f, 2.51906011e-02f, 6.47102818e-02f, -6.90828338e-02f,
  5.32321036e-02f, -6.33853823e-02f, 4.24753688e-02f, 6.80958331e-02f, -7.86485523e-02f, -5.01997657e-02f, 2.64712293e-02f, -5.27089238e-02f, 3.47422548e-02f, 4.48279716e-02f,
  -5.38539402e-02f, 2.65791528e-02f, 1.65814720e-02f, 9.86676216e-02f, -9.42325145e-02f, 3.94428261e-02f, -8.54999274e-02f, -3.16964164e-02f, -5.13763614e-02f, 4.21415046e-02f,
  -4.66470160e-02f, 8.74352530e-02f, 1.36001715e-02f, 7.72025576e-03f, -8.06914121e-02f, 7.29028061e-02f, 4.35405262e-02f, -7.56161660e-02f, 8.24944898e-02f, 5.08733913e-02f,
  1.26003893e-02f, 6.36375323e-02f, 5.27700372e-02f, 7.68403336e-02f, 1.82849653e-02f, -5.51539101e-03f, -4.95199971e-02f, -4.26995754e-02f, 1.16067538e-02f, 3.84659041e-03f,
  -5.34684479e-01f, -3.92888822e-02f, 1.31373733e-01f, -1.97999150e-01f, -2.33867504e-02f, 1.52330846e-01f, 2.17849120e-01f, 7.33745322e-02f, -2.06450552e-01f, 1.03903823e-02f,
  2.59837378e-02f, 3.02127786e-02f, -8.41421112e-02f, 3.88337485e-02f, 8.41723606e-02f, 1.44912899e-01f, -4.98459265e-02f, -1.28179919e-02f, 2.20978130e-02f, 2.78969686e-02f,
  1.05377994e-01f, -1.64052069e-01f, -1.35657981e-01f, -1.57110095e-01f, 2.34582070e-02f, 2.33586319e-02f, -7.45764235e-03f, -5.29904850e-02f, -2.42903829e-02f, -5.57975285e-02f,
  3.14875543e-01f, -1.27794087e-01f, 4.09033410e-02f, -4.23495919e-02f, 4.23425026e-02f, -6.35224506e-02f, 6.46844357e-02f, -3.09966635e-02f, -7.29326308e-02f, -2.00344324e-02f,
  -9.95271727e-02f, -7.20822997e-03f, -9.79731232e-02f, -4.28830236e-02f, 2.82147573e-03f, -9.24558789e-02f, -4.40256670e-03f, -1.40721038e-01f, 2.73565091e-02f, 1.08232282e-01f,
  4.40768786e-02f, 5.90871274e-02f, 1.74727477e-02f, -2.04506628e-02f, -3.17188874e-02f, -8.60315189e-02f, -2.37180050e-02f, -7.22179413e-02f, 4.13913988e-02f, -3.33050303e-02f,
  -3.00977677e-02f, 4.67937067e-02f, -9.06417742e-02f, -6.19514249e-02f, -1.00533050e-02f, 4.66188006e-02f, 8.29810649e-03f, -2.68417168e-02f, -2.26701237e-02f, 2.31142398e-02f,
  6.12963401e-02f, 5.25530614e-03f, -5.72276711e-02f, 5.08793108e-02f, -6.82613924e-02f, -1.14162490e-02f, 3.34883779e-02f, 1.59614068e-03f, 5.08842394e-02f, -2.75941286e-02f,
  3.36689353e-02f, -7.18494281e-02f, 2.09102929e-02f, -2.24540848e-03f, -8.80280550e-06f, -4.72179279e-02f, -1.05519533e-01f, 4.24136966e-02f, -2.65998989e-02f, 2.57780142e-02f,
  -3.20694260e-02f, -9.40802395e-02f, -5.12898192e-02f, -6.32755505e-03f, -6.92964792e-02f, -5.19574173e-02f, -3.13240997e-02f, -2.59486511e-02f, -1.41091077e-02f, 3.87001261e-02f,
  4.45315205e-02f, -1.58192962e-02f, 1.56562198e-02f, -3.28657813e-02f, 8.41064379e-02f, -3.49361300e-02f, -9.45397243e-02f, 2.04929709e-02f, 5.66865839e-02f, 3.39596272e-02f,
  3.62450187e-03f, -1.06246537e-02f, 1.08902037e-01f, -7.84538407e-03f, -3.06975339e-02f, 6.35200366e-02f, 1.78946242e-01f, 1.11074306e-01f, 7.18827099e-02f, 9.03910547e-02f,
  2.12017164e-01f, 9.29991305e-02f, -1.91371784e-01f, -3.27436849e-02f, -1.99112356e-01f, -7.89147392e-02f, -6.98352158e-02f, 2.80504171e-02f, 4.00566086e-02f, -5.01838997e-02f,
  1.91921759e-02f, 6.61961138e-02f, -5.27562723e-02f, -1.14418138e-02f, -2.70666741e-02f, 6.20871373e-02f, -8.42539370e-02f, 1.08387358e-02f, -8.37164521e-02f, -1.12495437e-01f,
  3.26613635e-02f, -2.18364578e-02f, 2.19925493e-02f, 8.24405551e-02f, -8.49127173e-02f, -5.13451435e-02f, -9.29782614e-02f, -4.03368808e-02f, -1.60138503e-01f, -1.37518913e-01f,
  -2.84064680e-01f, -1.27264917e-01f, 3.60219670e-03f, 1.34499148e-01f, -1.09903917e-01f, 9.31398496e-02f, -2.83879153e-02f, 1.38630390e-01f, 2.16088090e-02f, 5.36929592e-02f,
  -5.92997409e-02f, 1.24866683e-02f, -1.23334341e-01f, -3.34393680e-02f, -1.24794595e-01f, 3.54235955e-02f, 5.93536980e-02f, -4.97334749e-02f, 1.09375883e-02f, 1.05135413e-02f,
  -8.83034021e-02f, -3.76646034e-02f, 5.20256422e-02f, 3.01525276e-02f, -7.50770643e-02f, 1.88290738e-02f, 5.39050065e-02f, -1.30997777e-01f, -1.02066174e-01f, 1.10914230e-01f,
  3.51856276e-02f, 6.28284225e-03f, -9.38576013e-02f, -4.67580184e-02f, 4.73675393e-02f, 1.69285629e-02f, 1.91067867e-02f, 7.56119788e-02f, -6.18931502e-02f, 5.76485209e-02f,
  -2.62218937e-02f, 6.35127947e-02f, -4.80776876e-02f, 1.20746598e-01f, -7.61123076e-02f, -9.35871899e-02f, 2.85110213e-02f, 1.81374997e-02f, -5.03562093e-02f, -3.89610678e-02f,
  -2.43310584e-03f, -8.59167501e-02f, -9.70586166e-02f, -2.91695748e-03f, -1.36153456e-02f, 4.25502323e-02f, 9.57525242e-03f, -4.25960682e-02f, -4.28989530e-03f, 3.36150117e-02f,
  5.71056902e-02f, 4.87262383e-02f, -3.35554257e-02f, 7.57445469e-02f, 6.65172935e-03f, 3.00268177e-02f, 6.95738615e-03f, 1.49682462e-02f, 4.91128042e-02f, -6.58973828e-02f,
  -8.28412846e-02f, -1.95988063e-02f, -3.31611149e-02f, -2.44367626e-02f, 2.04332955e-02f, 3.76254059e-02f, 1.90547839e-01f, 4.98630144e-02f, 6.08965494e-02f, -8.82297829e-02f,
  7.79991299e-02f, 1.73683479e-01f, 1.60550430e-01f, 3.61907221e-02f, -1.88595727e-02f, 4.58043180e-02f, 2.71473825e-03f, -6.66280687e-02f, 1.34724274e-01f, 3.05873454e-01f,
  -1.80535659e-01f, -1.48294061e-01f, 2.85648182e-02f, -1.47812562e-02f, -1.48472497e-02f, 9.19011980e-02f, 4.24726568e-02f, -4.87671457e-02f, 2.22580209e-02f, -3.88514949e-03f,
  -9.59104821e-02f, 8.20385665e-02f, -7.30640441e-02f, -8.49623308e-02f, 1.16015729e-02f, 8.03381950e-02f, 5.74074499e-02f, 4.24262099e-02f, 9.80442688e-02f, 6.18148521e-02f,
  4.48896103e-02f, 3.85167040e-02f, -2.24411506e-02f, 7.68167451e-02f, 2.92330738e-02f, 4.10723239e-02f, 5.99782281e-02f, 7.85652697e-02f, 6.28944710e-02f, 9.82324779e-02f,
  1.31314352e-01f, -1.38748720e-01f, 1.26883060e-01f, -1.04506388e-01f, -2.61424519e-02f, 7.61295296e-03f, -5.64274788e-02f, 1.15987659e-02f, 2.78862771e-02f, 1.03790246e-01f,
  2.73816679e-02f, -3.28730419e-02f, 6.61287606e-02f, -4.37568221e-03f, 3.34924832e-02f, -5.34713008e-02f, -1.98319945e-02f, -2.55289301e-02f, -1.56873628e-03f, -2.99075656e-02f,
  -8.81618112e-02f, -9.36124846e-03f, 1.74662340e-02f, 5.48954830e-02f, 3.21559235e-02f, -1.52686369e-02f, -8.84957537e-02f, 4.02134359e-02f, -1.09910681e-04f, -8.65549315e-03f,
  6.64076284e-02f, -7.04145581e-02f, 4.74177003e-02f, -6.67633638e-02f, 5.19024879e-02f, -2.45193355e-02f, 1.00825302e-01f, 4.85063791e-02f, -5.88155314e-02f, 5.26701175e-02f,
  -5.86125031e-02f, -3.45487148e-02f, -2.53182724e-02f, -2.44811252e-02f, -5.41400053e-02f, 6.01150692e-02f, 1.50177523e-03f, 3.08350883e-02f, -2.05951044e-03f, -7.91110247e-02f,
  4.79835570e-02f, -4.45779599e-02f, -4.33058888e-02f, -5.04761636e-02f, -2.71708425e-02f, -6.82842266e-03f, 5.19007333e-02f, -8.02878477e-03f, -2.14534346e-03f, -1.00749666e-02f,
  4.19898704e-02f, -2.25497521e-02f, 2.44084466e-02f, 7.72897303e-02f, 5.71009703e-02f, -6.20817617e-02f, -1.42679829e-02f, 6.68162629e-02f, -8.96155685e-02f, -7.15273805e-03f,
  8.77270568e-03f, -4.83231172e-02f, -6.40344843e-02f, 5.55888265e-02f, -1.45717533e-02f, 6.09737821e-02f, 6.10852838e-02f, 4.97607421e-03f, -7.23804384e-02f, 1.93912107e-02f,
  -2.59820018e-02f, 4.29199561e-02f, 1.31418422e-01f, 2.59830225e-02f, -4.42027450e-02f, 9.20738839e-03f, 5.06029874e-02f, 3.84966619e-02f, -3.61710303e-02f, 1.60702407e-01f,
  -3.65890205e-01f, 1.94736630e-01f, -4.37284708e-02f, -2.45460480e-01f, -4.74181250e-02f, 1.75601423e-01f, 2.20163152e-01f, 5.00587262e-02f, -7.26053044e-02f, -2.08293628e-02f,
  5.76033108e-02f, -1.66756138e-01f, -3.02249677e-02f, 1.78283621e-02f, -6.06203498e-03f, 6.04090355e-02f, 3.50266770e-02f, -1.43493921e-01f, -1.09645188e-01f, -2.37422486e-04f,
  -8.39938521e-02f, -2.55382508e-01f, -2.37881422e-01f, -5.23231216e-02f, -1.93414818e-02f, -1.82224616e-01f, -1.26044393e-01f, -1.31040558e-01f, -3.09994463e-02f, -1.18764549e-01f,
  -1.03025071e-01f, -1.49670064e-01f, -7.44500458e-02f, -7.82724768e-02f, 2.11565364e-02f, 2.04671361e-02f, -4.95228954e-02f, -1.27248585e-01f, -1.13594435e-01f, 5.20987548e-02f,
  -1.00243315e-02f, 4.36015427e-02f, -1.40350327e-01f, 5.91072887e-02f, -4.65597846e-02f, -8.72776657e-02f, -6.56456277e-02f, -7.74921775e-02f, 7.42168501e-02f, 5.35151660e-02f,
  1.46003798e-01f, -2.06974391e-02f, 2.84918938e-02f, 1.33875180e-02f, 3.95335443e-02f, -4.85046580e-02f, 1.68095194e-02f, 3.83823328e-02f, 6.16309932e-03f, 7.65825901e-03f,
  8.10597613e-02f, 6.13393225e-02f, 6.32146969e-02f, -9.16129202e-02f, 1.34026436e-02f, 1.28565039e-02f, 9.43875592e-03f, -7.49830343e-03f, -8.71505290e-02f, -6.50035813e-02f,
  -9.13465470e-02f, 2.25711800e-02f, 1.67376976e-02f, -5.02815396e-02f, 5.45240715e-02f, 8.61253962e-03f, -4.84233014e-02f, 7.01842085e-02f, 8.83983970e-02f, 2.56218594e-02f,
  2.66288780e-02f, -5.64947650e-02f, -4.42807488e-02f, -6.57175854e-02f, 3.37257981e-02f, 8.98953229e-02f, 8.36228505e-02f, 4.78149205e-03f, -9.30259079e-02f, 1.12547157e-02f,
  -1.84351534e-01f, -2.39997706e-03f, -3.57204825e-02f, -5.51238991e-02f, 1.73419658e-02f, 7.31260106e-02f, -2.68124100e-02f, -1.05278371e-02f, 1.85890980e-02f, -8.92342627e-03f,
  -6.46038726e-02f, 5.89546636e-02f, -5.77487722e-02f, 3.86382546e-03f, -1.01358913e-01f, 6.07671961e-02f, 1.36255324e-01f, -3.68102007e-02f, -1.91558544e-02f, 1.33616567e-01f,
  6.75404519e-02f, 1.00884385e-01f, -5.06391600e-02f, 3.35681662e-02f, 8.99094492e-02f, -6.00364394e-02f, -3.43453847e-02f, -2.16797516e-02f, -5.40067628e-02f, 9.71179157e-02f,
  -2.05846101e-01f, -3.31950258e-03f, 9.38847214e-02f, -1.58794761e-01f, -7.32489079e-02f, 6.46735430e-02f, 5.29005602e-02f, -2.29788739e-02f, -1.36147529e-01f, 6.91300705e-02f,
  7.09793903e-03f, -4.73961160e-02f, 2.83945464e-02f, -9.46728885e-02f, -8.41297284e-02f, 1.33827940e-01f, 1.44164726e-01f, 3.16828601e-02f, -4.67954800e-02f, 3.79639678e-02f,
  -2.24889424e-02f, -6.84731677e-02f, -1.30326420e-01f, -9.67686772e-02f, 6.15025833e-02f, 4.81431410e-02f, 1.79339852e-02f, 1.92756820e-02f, 8.12234264e-03f, 5.17368317e-02f,
  1.75521523e-01f, -8.95219594e-02f, -7.05769137e-02f, -1.29764363e-01f, -5.13292104e-02f, -5.85705489e-02f, -5.92506230e-02f, 2.19975132e-02f, -6.35448098e-02f, 6.49461746e-02f,
  -7.36550391e-02f, -7.08500296e-02f, -9.45451781e-02f, -6.70305118e-02f, 4.21270495e-03f, 6.46239668e-02f, -8.23352393e-03f, -2.66221724e-02f, 3.66014838e-02f, -6.71974421e-02f,
  -4.55996254e-03f, -1.58383697e-02f, 4.10946272e-02f, -1.59817021e-02f, -3.45899723e-03f, 2.82891467e-02f, 5.17390855e-02f, -9.93369520e-02f, -1.89135354e-02f, -9.98581350e-02f,
  7.57716596e-02f, 2.62187645e-02f, 6.38139099e-02f, -3.29237506e-02f, -5.66928312e-02f, -3.70207876e-02f, -1.47525370e-02f, -7.47056454e-02f, -2.69305855e-02f, -7.54930973e-02f,
  4.53152927e-03f, -3.38152312e-02f, -1.08018778e-01f, -5.35025485e-02f, 3.05875260e-02f, 4.97845598e-02f, -3.10018323e-02f, -5.59706651e-02f, 2.01337226e-02f, -7.81456754e-02f,
  4.22280878e-02f, -5.11065386e-02f, -3.60890664e-02f, -4.26376313e-02f, -7.52258599e-02f, 1.94941647e-02f, 3.75900455e-02f, -2.99662165e-02f, -2.77011953e-02f, -8.51071849e-02f,
  -7.30196610e-02f, -8.06569904e-02f, 6.45562336e-02f, -5.18222712e-02f, -6.27310062e-03f, 9.79861245e-02f, -2.93476619e-02f, -5.73382378e-02f, -8.37058723e-02f, 3.34650688e-02f,
  -6.08929284e-02f, -4.28358354e-02f, 6.26879930e-02f, 7.76080191e-02f, 6.34161979e-02f, 4.51799445e-02f, -9.92082059e-02f, -7.58590028e-02f, -7.99489859e-03f, -7.87609145e-02f,
  -6.89035803e-02f, -2.77935993e-03f, -9.78197232e-02f, 6.47502169e-02f, -5.14028706e-02f, -7.22065791e-02f, 6.59121275e-02f, 1.08122155e-01f, -4.15822566e-02f, 1.91809349e-02f,
  -5.61094061e-02f, 1.68509722e-01f, -3.54244597e-02f, 2.42827851e-02f, 2.58512124e-02f, -9.02796090e-02f, 1.91935655e-02f, 6.66168183e-02f, -1.12065907e-04f, -2.48248056e-02f,
  -2.55679004e-02f, -3.07310633e-02f, -1.00707389e-01f, -1.35689750e-01f, -1.27434880e-01f, -6.99056908e-02f, 3.25882807e-02f, -1.42931476e-01f, -9.61314887e-02f, -1.56672761e-01f,
  9.67624225e-03f, -6.54414594e-02f, -6.96946755e-02f, 6.23462424e-02f, 1.25874177e-01f, -7.03291744e-02f, 1.27681702e-01f, -1.98486764e-02f, -9.88785923e-02f, -6.07688017e-02f,
  -1.45367505e-02f, -5.94454212e-03f, -7.92006776e-02f, 3.42745520e-02f, 1.00252926e-01f, 2.89161745e-02f, -1.27602331e-02f, 8.40198472e-02f, 2.63240431e-02f, -5.57951070e-02f,
  2.98922546e-02f, -7.89321512e-02f, 7.46475998e-03f, 4.00046669e-02f, -5.47852963e-02f, -1.38869160e-03f, -6.22291490e-02f, 5.61528429e-02f, 1.28778694e-02f, -5.86237200e-02f,
  2.17364989e-02f, -1.99924745e-02f, 2.38959994e-02f, 3.77447233e-02f, -1.88163277e-02f, 3.38644832e-02f, 3.44119058e-03f, 3.88379842e-02f, 2.16214452e-03f, -4.58015781e-03f,
  -2.63384897e-02f, 3.48272212e-02f, -3.99166681e-02f, -1.44512067e-03f, -6.78683072e-02f, 9.90479439e-02f, -7.11413398e-02f, 1.38358157e-02f, 3.14601324e-02f, 9.29182172e-02f,
  8.86371285e-02f, 1.93817224e-02f, 7.95567185e-02f, -2.48413812e-02f, -5.38457669e-02f, 1.10802598e-01f, 2.04049144e-02f, -6.22973703e-02f, 6.66419789e-02f, -4.36288901e-02f,
  -7.23559111e-02f, -7.79132769e-02f, -2.97886599e-02f, -1.72225572e-02f, -4.26734500e-02f, -5.59926592e-02f, 3.59352939e-02f, -1.42009789e-02f, 4.48650680e-02f, 3.31589058e-02f,
  -3.75812426e-02f, 5.28105497e-02f, 3.15196402e-02f, -7.58548975e-02f, -5.90179674e-03f, -3.40519496e-03f, -7.13485107e-02f, 6.28581792e-02f, -5.94278537e-02f, -8.12141690e-03f,
  -3.23824286e-02f, 5.60711846e-02f, -5.35977855e-02f, -1.10419677e-03f, -9.93110761e-02f, -9.46512520e-02f, -8.25106502e-02f, -6.42816275e-02f, -6.42381236e-02f, 1.93867497e-02f,
  -1.82174277e-02f, -1.02125905e-01f, -5.04229777e-02f, -3.57105657e-02f, 6.98990375e-03f, -1.01009347e-01f, -3.87883596e-02f, 1.48233690e-03f, -3.37463245e-02f, -1.22252345e-01f,
  -1.16971523e-01f, 1.35261551e-01f, -5.92534095e-02f, 5.82208810e-03f, 1.85542986e-01f, 1.90845519e-01f, 2.30257422e-01f, -6.68485649e-03f, 4.68405038e-02f, 1.26133516e-01f,
  1.40898004e-01f, 4.70526293e-02f, -3.29093486e-02f, 5.84961697e-02f, 6.83371499e-02f, 1.27438143e-01f, 1.56314056e-02f, -8.88740867e-02f, -1.42489359e-01f, -6.54086247e-02f,
  1.44541815e-01f, 7.81310350e-02f, -1.73887283e-01f, 2.75908597e-02f, -6.17084317e-02f, 5.72070219e-02f, -3.19575891e-02f, 6.72207996e-02f, -6.72428752e-04f, -5.99157810e-03f,
  1.89749000e-03f, -7.50099719e-02f, -4.25542705e-02f, -2.33137067e-02f, 1.81142185e-02f, -5.42618223e-02f, 1.83534101e-02f, -3.26972455e-02f, 2.85821632e-02f, -5.79724833e-02f,
  -5.14088012e-02f, 1.27619645e-02f, -5.83120212e-02f, -1.77498329e-02f, 3.41437347e-02f, -9.57311913e-02f, -1.97997037e-02f, -1.30357817e-01f, -1.69031441e-01f, -7.70507529e-02f,
  -1.41875707e-02f, 5.71485460e-02f, -8.39674622e-02f, 3.32880579e-02f, -1.05090357e-01f, -1.31946623e-01f, -7.77277425e-02f, -2.37688925e-02f, -3.06000630e-03f, -1.06748946e-01f,
  5.10499515e-02f, 2.78950892e-02f, -5.68671040e-02f, -3.44452187e-02f, 1.26843592e-02f, -1.12327922e-03f, 5.14116511e-02f, 2.64780410e-02f, -5.50694391e-02f, 2.33348124e-02f,
  2.25265175e-02f, -5.80753898e-03f, -1.73885133e-02f, 1.37046995e-02f, -2.74994709e-02f, 2.46750712e-02f, 8.56623985e-03f, -7.83162031e-05f, -5.26100546e-02f, -3.96888331e-02f,
  -1.43912453e-02f, 2.22500041e-03f, 1.38016464e-02f, -8.57219398e-02f, -6.03232719e-02f, 7.41931871e-02f, -1.22956280e-02f, 6.32752553e-02f, 2.52357051e-02f, -3.19774263e-02f,
  -5.03708888e-03f, 8.86703506e-02f, -6.22392108e-04f, -9.72516090e-02f, 8.46864209e-02f, -8.25388730e-02f, -3.23992632e-02f, -1.18973777e-01f, -2.27822233e-02f, -8.01385567e-02f,
  6.93501383e-02f, 2.63479985e-02f, -6.03654869e-02f, 3.54739912e-02f, -1.17906183e-01f, -3.89066562e-02f, 1.13189630e-01f, -7.53337219e-02f, -1.80988219e-02f, -1.16440952e-01f,
  -6.68727681e-02f, -9.93577167e-02f, -3.43552558e-03f, -1.06211938e-02f, -7.83276707e-02f, 1.91436056e-03f, -9.65237245e-02f, -2.20789667e-02f, -1.37000352e-01f, -8.39152634e-02f,
  -1.69455484e-01f, -1.96321383e-01f, -4.34281789e-02f, -5.93360551e-02f, -2.58741230e-02f, -1.92518085e-01f, -2.54559129e-01f, -1.10260725e-01f, -6.25898093e-02f, -7.58404881e-02f,
  -1.04832761e-01f, -8.46827701e-02f, -1.87968444e-02f, -1.17685478e-02f, -5.65099195e-02f, -1.20318010e-01f, -2.64431536e-01f, -1.28196701e-01f, -1.95694447e-01f, -1.56332418e-01f,
  -2.29454711e-01f, -2.18052909e-01f, -1.85430154e-01f, -1.12917602e-01f, -3.79784852e-02f, -3.47826742e-02f, -1.39975362e-02f, -1.45242468e-01f, -5.77301346e-02f, -1.33183047e-01f,
  -7.94778690e-02f, 1.04496218e-01f, 7.99850449e-02f, 3.05212867e-02f, -8.61229077e-02f, -1.84351075e-02f, 5.31610176e-02f, 3.75279076e-02f, 6.66094497e-02f, 5.53258434e-02f,
  8.82724747e-02f, 9.56717040e-03f, 4.31006141e-02f, -1.68989301e-02f, -5.83322197e-02f, -8.42502192e-02f, 3.24236304e-02f, 3.25679779e-02f, 6.70332685e-02f, -4.69472669e-02f,
  -3.14751044e-02f, 2.72622071e-02f, 3.88491899e-02f, 1.14485711e-01f, 1.54278144e-01f, 7.66900480e-02f, 5.93968667e-02f, 1.81448951e-01f, 1.04709946e-01f, 2.48171818e-02f,
  -7.83544779e-02f, 4.20010202e-02f, 3.07959337e-02f, 5.08996844e-02f, -1.34384679e-02f, 9.17810015e-03f, 8.26899856e-02f, -7.22338483e-02f, -1.62400596e-03f, -9.30530857e-03f,
  5.27357459e-02f, -7.75488615e-02f, -4.73487638e-02f, -7.35328570e-02f, -5.33680134e-02f, -7.65932575e-02f, -1.28535684e-02f, -1.14758484e-01f, 1.10992296e-02f, -2.31926050e-02f,
  4.30192053e-02f, 8.28127787e-02f, -4.05991711e-02f, 5.38341962e-02f, 2.59520728e-02f, 5.07788360e-02f, -7.21263960e-02f, -2.53718048e-02f, 9.90963802e-02f, -1.25461323e-02f,
  4.15505022e-02f, -4.82151918e-02f, 1.59874950e-02f, 5.64941764e-02f, 9.12533104e-02f, 6.38192520e-02f, -1.15289288e-02f, 3.39646754e-03f, -2.62821782e-02f, 1.26339206e-02f,
  4.84877639e-02f, 1.86796691e-02f, -3.60365100e-02f, -6.79371208e-02f, -9.04331803e-02f, 7.37555400e-02f, -1.17563441e-01f, -1.03948139e-01f, 5.00882454e-02f, 1.57073308e-02f,
  -1.16482154e-01f, -1.53570637e-01f, -1.22778036e-01f, -4.97073941e-02f, 4.87041995e-02f, 8.89559556e-03f, -1.28312483e-02f, -9.71168559e-03f, 5.39008304e-02f, -5.20807654e-02f,
  -3.32210094e-01f, 5.60890809e-02f, 1.13539025e-01f, -2.53833026e-01f, 5.34793828e-03f, 6.55565411e-02f, 1.63502723e-01f, 5.21454029e-02f, -1.50805175e-01f, 5.95236532e-02f,
  4.77440702e-03f, -4.66358401e-02f, -1.25158727e-01f, -2.50286236e-02f, -3.02536786e-02f, 6.19211420e-02f, -3.52058038e-02f, -1.47512794e-01f, -9.68221277e-02f, -5.47049753e-02f,
  7.71222636e-03f, -2.28358448e-01f, -1.33714959e-01f, -6.24049790e-02f, -1.23051658e-01f, -1.32748306e-01f, -8.56910720e-02f, -3.33269127e-02f, 3.07392925e-02f, -3.97071205e-02f,
  8.17794353e-02f, 3.60348187e-02f, -4.69755307e-02f, -7.01518962e-03f, -9.04648192e-03f, -1.38276527e-02f, 3.73468474e-02f, -6.30512312e-02f, -2.65245531e-02f, -1.76593952e-03f,
  -3.33171785e-02f, 4.87350225e-02f, -5.38264140e-02f, -4.82496768e-02f, 3.67731564e-02f, -4.28300872e-02f, 1.19287195e-02f, 1.59085973e-03f, -2.28509028e-02f, 1.06114738e-01f,
  5.69944158e-02f, -8.13018531e-03f, -6.38444871e-02f, -4.67610881e-02f, 4.99115139e-03f, -2.85439529e-02f, 9.56283286e-02f, 3.18223014e-02f, 7.96172842e-02f, -1.20415881e-01f,
  5.92863886e-04f, 3.28907408e-02f, -2.22247168e-02f, -4.35807966e-02f, -2.82186940e-02f, -5.63945761e-03f, 2.81749163e-02f, -4.10609059e-02f, -2.58542951e-02f, 5.67170093e-03f,
  2.95152534e-02f, 8.42837691e-02f, 1.56652927e-02f, 3.19960527e-02f, -1.54716000e-02f, -7.59650171e-02f, 2.54123267e-02f, -1.90213528e-02f, -7.32957050e-02f, 4.33243215e-02f,
  -1.62509419e-02f, -6.82726353e-02f, -2.95063052e-02f, 2.79565062e-02f, 6.06608130e-02f, -4.69283313e-02f, 1.14015173e-02f, 1.13424860e-01f, -5.26154973e-02f, 9.20019373e-02f,
  -1.30052656e-01f, 1.59552693e-01f, -4.87259850e-02f, -1.15573235e-01f, -1.29609201e-02f, -7.25881308e-02f, -5.06539270e-02f, 6.44806325e-02f, 6.09805621e-02f, 4.63235416e-02f,
  1.02770947e-01f, -7.90984649e-03f, 4.67941910e-02f, -7.33345896e-02f, 5.26255183e-02f, 8.13716836e-03f, -5.12980036e-02f, -9.61495787e-02f, -1.74899325e-02f, 4.46166731e-02f,
  -1.62943397e-02f, -1.00781508e-01f, -1.55687526e-01f, -1.09325908e-01f, 6.15231618e-02f, -1.21536151e-01f, -2.61603817e-02f, 1.49777010e-02f, -8.71842802e-02f, -1.19592175e-01f,
  1.23690061e-01f, 3.01131368e-01f, 1.14566006e-01f, 7.16827139e-02f, 5.31811379e-02f, 1.27684688e-02f, 1.71146691e-01f, 7.06138313e-02f, -6.78116875e-03f, 2.83936467e-02f,
  1.29873410e-01f, -1.54409707e-01f, 2.04928070e-02f, -3.95126007e-02f, 6.25464395e-02f, 4.60421443e-02f, -6.70590177e-02f, 1.83750037e-02f, -1.28263101e-01f, -9.65386555e-02f,
  -1.21460728e-01f, 9.63863079e-03f, 5.15242144e-02f, 9.78537276e-03f, -7.11259916e-02f, -8.79133195e-02f, -7.73260836e-04f, 4.53415327e-02f, 6.47536516e-02f, -9.98133048e-02f,
  -6.10539317e-02f, 2.57757217e-01f, -1.65120900e-01f, -8.18414837e-02f, 7.44074062e-02f, -4.82707564e-03f, -6.19256012e-02f, -2.69480255e-02f, 1.08052343e-01f, -3.45978588e-02f,
  7.11994022e-02f, 8.11506435e-02f, 4.07747887e-02f, 7.98202381e-02f, 7.52976015e-02f, -5.05298860e-02f, 1.30914733e-01f, -3.95759121e-02f, 2.61328593e-02f, -6.70993626e-02f,
  -1.97823532e-02f, 8.04603472e-03f, 1.25496820e-01f, 6.76369891e-02f, -4.40324172e-02f, -1.04798399e-01f, 1.31016135e-01f, 1.22203855e-02f, -1.24050106e-03f, 4.03261408e-02f,
  -1.40883356e-01f, -4.33804616e-02f, 1.21251000e-02f, -5.46081737e-02f, -5.44929393e-02f, -1.01483576e-02f, 2.25175023e-02f, 2.96545355e-03f, 3.18463594e-02f, 8.30648392e-02f,
  -7.04758167e-02f, 3.58198881e-02f, -7.26261735e-02f, 2.08271276e-02f, 1.28186205e-02f, 8.00106227e-02f, -1.73314512e-02f, -6.90906867e-02f, 5.10353893e-02f, -5.03826402e-02f,
  2.89458688e-02f, 3.21032107e-02f, 6.35774881e-02f, 2.56060120e-02f, -7.26960897e-02f, 5.66635206e-02f, -5.24140075e-02f, 4.67075333e-02f, -4.93874811e-02f, 2.14616079e-02f,
  1.00014217e-01f, -8.60534906e-02f, -1.65613890e-01f, -4.24018167e-02f, 1.24176117e-02f, 2.28634607e-02f, 3.14610451e-02f, -9.27605182e-02f, 2.64800042e-02f, -2.43355185e-02f,
  8.17927122e-02f, 2.70289648e-02f, -5.88342594e-03f, -3.07665057e-02f, 3.75840738e-02f, -1.33670121e-02f, 5.20122312e-02f, 1.95605718e-02f, 3.48831527e-02f, -4.69434001e-02f,
  -3.40498388e-02f, -2.22003665e-02f, 3.51757035e-02f, -5.95116243e-02f, -6.82448074e-02f, -1.87816888e-01f, 6.95414189e-03f, -4.95538786e-02f, 3.38794454e-03f, 1.05822133e-02f,
  1.02721702e-03f, -8.83359089e-02f, -7.11583123e-02f, -1.21877030e-01f, -5.50500043e-02f, 1.91531982e-02f, 5.01222908e-03f, -1.39712670e-03f, 7.55530223e-02f, -2.55603865e-02f,
  1.28912792e-01f, 1.23735003e-01f, -2.76833735e-02f, 1.30884707e-01f, 8.05468485e-02f, 9.45513174e-02f, -7.90677890e-02f, -6.53793886e-02f, 1.00774631e-01f, 1.23889111e-01f,
  -4.10473272e-02f, -5.99517338e-02f, -2.45899223e-02f, -1.56837283e-03f, 2.80561037e-02f, 8.16084892e-02f, -2.31611356e-02f, -1.13792822e-01f, 6.39453903e-03f, -1.03346363e-01f,
  6.25722334e-02f, -2.84293350e-02f, 5.14011532e-02f, -4.22678851e-02f, -1.13313816e-01f, -7.99706653e-02f, -3.83238457e-02f, -1.30627295e-02f, 2.46403236e-02f, -1.07573858e-02f,
  -9.99871567e-02f, -3.26759592e-02f, 3.32270898e-02f, -4.90178242e-02f, -3.33663635e-02f, 6.15719035e-02f, -1.83978248e-02f, -4.81588058e-02f, 7.60878697e-02f, 2.30166074e-02f,
  5.03314696e-02f, 7.78932720e-02f, -2.88888477e-02f, 5.98255433e-02f, -2.26033423e-02f, -2.08566021e-02f, -1.94167495e-02f, -3.10340971e-02f, 3.11693759e-03f, 1.71833131e-02f,
  5.45108020e-02f, 2.37570498e-02f, 6.66922703e-02f, 3.56049202e-02f, 9.65535119e-02f, 1.46901084e-03f, 4.20324653e-02f, -5.38775101e-02f, -1.80338640e-02f, -1.47933131e-02f,
  4.16544117e-02f, 4.23861742e-02f, -2.61924081e-02f, 2.41386686e-02f, 1.04012832e-01f, -4.63886885e-03f, 6.75736293e-02f, 7.00253323e-02f, 3.16350870e-02f, 9.44875833e-03f,
  -6.77876025e-02f, -1.80576909e-02f, 6.05509058e-02f, -3.54994573e-02f, 4.02783714e-02f, 2.10038815e-02f, -5.37416227e-02f, 9.56950784e-02f, -3.89439054e-02f, -2.43414678e-02f,
  -1.14669971e-01f, 1.10885546e-01f, -3.38486349e-03f, -1.09376516e-02f, -7.03188553e-02f, 5.69232926e-02f, -5.90246953e-02f, -4.74831052e-02f, 1.49247833e-02f, 3.62843834e-02f,
  -6.33492097e-02f, -5.12361638e-02f, -5.05210347e-02f, -6.64792210e-02f, -4.28923070e-02f, 5.38184159e-02f, -4.52597477e-02f, 2.78010331e-02f, 8.42290297e-02f, 8.56643096e-02f,
  5.64750237e-03f, -1.23765301e-02f, 5.10203205e-02f, 1.07477248e-01f, 5.16960805e-04f, 8.49495176e-03f, -6.97184131e-02f, 1.36691136e-02f, 8.14465135e-02f, -7.72591457e-02f,
  8.27101097e-02f, -1.66001052e-01f, -2.41251558e-01f, -8.85716453e-03f, 5.13566621e-02f, -1.44980296e-01f, -9.86510888e-02f, -5.39543852e-02f, 7.42720664e-02f, -2.94755884e-02f,
  3.08420099e-02f, 7.48658031e-02f, -1.04529850e-01f, -1.45524815e-02f, -1.25709340e-01f, -2.25248501e-01f, -2.12487429e-01f, -1.41581103e-01f, -4.31028940e-02f, 1.14436455e-01f,
  7.76692703e-02f, 6.34247884e-02f, 6.96072951e-02f, -2.32928321e-02f, -4.40612137e-02f, 1.08349413e-01f, 7.72305485e-03f, -7.44399577e-02f, -9.42208022e-02f, -1.39918178e-01f,
  -1.42248482e-01f, -5.45936003e-02f, -3.37777734e-02f, -5.79157770e-02f, -7.78169110e-02f, -2.44362205e-02f, 2.19243653e-02f, -6.94699958e-03f, 1.71027761e-02f, -5.22404946e-02f,
  1.35841407e-02f, -5.08533455e-02f, 6.10736087e-02f, -6.43247440e-02f, 3.81393246e-02f, 8.71706903e-02f, 9.77437645e-02f, -7.88996220e-02f, -2.32512075e-02f, 1.10771842e-02f,
  -5.49896434e-02f, -1.12701833e-01f, -9.18050110e-02f, 4.54974659e-02f, -4.62079793e-02f, -4.85112667e-02f, 2.13228017e-02f, 9.34761390e-02f, 2.65697148e-02f, -2.81635337e-02f,
  -4.79194596e-02f, 5.19549623e-02f, 7.27993576e-03f, -5.12457229e-02f, 5.91393225e-02f, 4.38003102e-03f, -9.17623490e-02f, -3.88583764e-02f, 8.14330727e-02f, -2.12752316e-02f,
  -4.96004298e-02f, 4.86636199e-02f, -4.99179848e-02f, 4.05937135e-02f, 4.06986214e-02f, 1.26872556e-02f, -8.07409659e-02f, -8.04709867e-02f, -7.59805664e-02f, 3.14938501e-02f,
  -3.26717235e-02f, 6.89324141e-02f, -6.77443966e-02f, 4.98635732e-02f, 4.79147723e-03f, -5.68863004e-03f, -7.79235885e-02f, -6.74064681e-02f, 7.10544586e-02f, 4.05780450e-02f,
  4.50682268e-02f, -7.64877573e-02f, 4.01940284e-04f, -8.08898434e-02f, -4.72593680e-02f, 6.60081059e-02f, -5.09300083e-02f, 2.55517270e-02f, -1.66097097e-02f, 7.95897469e-02f,
  -2.53978483e-02f, -2.82266317e-03f, -3.61540467e-02f, 6.42937124e-02f, 4.47800383e-02f, 6.73417225e-02f, -7.26624653e-02f, 3.36049730e-03f, 4.79479088e-03f, -3.81597504e-02f,
  7.72133246e-02f, -8.03325102e-02f, -1.96154770e-02f, -5.78717440e-02f, -3.03846747e-02f, -1.12473205e-01f, -1.18394397e-01f, 6.37771748e-03f, -8.81704837e-02f, -5.13729043e-02f,
  -1.10843286e-01f, 9.30344686e-02f, -3.28725390e-02f, 1.15480483e-01f, 1.09679550e-01f, 3.26651037e-02f, 4.54053655e-03f, -1.12386696e-01f, 8.17840323e-02f, -8.55734944e-03f,
  5.22398315e-02f, -5.57877384e-02f, 6.61910698e-02f, -9.51961130e-02f, -1.49564907e-01f, -1.11962914e-01f, 8.11132137e-03f, -5.33521548e-02f, -1.18904114e-01f, -1.77991703e-01f,
  -7.20620677e-02f, -1.57941075e-03f, -1.30924806e-01f, 3.45674250e-03f, 9.89534408e-02f, 1.15402460e-01f, 1.21417262e-01f, -3.97603307e-03f, -5.08452244e-02f, 1.25540376e-01f,
  2.02496722e-02f, -4.12954763e-02f, -3.09489965e-02f, 4.53886464e-02f, 1.06750205e-01f, -4.16760705e-02f, -5.79273747e-03f, 6.19685724e-02f, 5.44627346e-02f, 5.99572435e-02f,
  3.25604342e-02f, -6.17006458e-02f, 2.18712725e-02f, -9.96243674e-03f, -3.75815369e-02f, 1.24918157e-02f, -9.01550278e-02f, -8.63046795e-02f, -4.76593859e-02f, 3.04445699e-02f,
  -7.73748523e-03f, -3.32338028e-02f, -2.13082060e-02f, -1.07622296e-01f, 7.08813220e-02f, -4.71808687e-02f, 3.68264131e-02f, 3.09168547e-02f, -1.00495882e-01f, -1.42701594e-02f,
  6.19443459e-03f, 4.19600643e-02f, 3.97608429e-02f, 4.92837373e-03f, 1.72344372e-02f, -1.35976477e-02f, 7.26529490e-03f, -7.56426901e-02f, 1.31832212e-02f, 3.40305381e-02f,
  3.68190259e-02f, 5.42686507e-02f, 6.09424599e-02f, 7.76957273e-02f, -2.18325946e-02f, 5.12303300e-02f, 5.11636920e-02f, -5.13293929e-02f, -3.85303050e-03f, 5.81333265e-02f,
  2.87832264e-02f, 5.58701828e-02f, 4.31561992e-02f, 6.96619228e-02f, -9.66450498e-02f, 3.62921059e-02f, -3.22013646e-02f, -9.94368196e-02f, -2.80310567e-02f, -8.99006519e-03f,
  7.82237649e-02f, -9.28751528e-02f, -5.05114384e-02f, 2.91354060e-02f, 6.19849283e-03f, 4.11206745e-02f, 2.85705496e-02f, -4.97267954e-02f, -2.42176037e-02f, 3.91827547e-04f,
  -2.72435285e-02f, -4.94044237e-02f, 3.58047970e-02f, -3.27857621e-02f, -9.15152356e-02f, 9.66669340e-03f, 6.94362894e-02f, 6.20576330e-02f, -5.34716323e-02f, 6.47960044e-03f,
  6.96526188e-03f, -6.21228851e-02f, -5.27931303e-02f, 5.84385209e-02f, -7.62375742e-02f, -5.66047877e-02f, -1.21087298e-01f, -3.25097702e-02f, -7.07558915e-02f, -9.75008309e-02f,
  2.09406495e-01f, 2.00199291e-01f, 1.33858159e-01f, 6.77846968e-02f, -8.47430676e-02f, 5.36909774e-02f, 1.92435101e-01f, 1.02525599e-01f, 2.24592686e-02f, -6.55125380e-02f,
  -1.15931205e-01f, -2.26401031e-01f, -4.02707718e-02f, 1.59764327e-02f, 7.16106221e-02f, 8.78074542e-02f, -5.33187715e-03f, 1.07677326e-01f, 4.53359000e-02f, -3.88500950e-04f,
  8.49897265e-02f, -2.92148348e-02f, -1.18154809e-02f, 8.59498978e-02f, -9.14019905e-03f, -2.57480126e-02f, 7.25618601e-02f, 7.39031807e-02f, 4.21100482e-02f, 1.08993806e-01f,
  -1.53134838e-01f, 7.72336945e-02f, -1.01553187e-01f, -9.64083150e-02f, -6.73115253e-02f, -4.00062986e-02f, 5.94428182e-02f, 6.79747527e-03f, 6.46972358e-02f, 4.39565405e-02f,
  1.64512638e-02f, 3.51911783e-02f, -7.54291639e-02f, -9.63995606e-02f, -2.89177690e-02f, 7.87631646e-02f, 7.84372911e-02f, 5.73835894e-03f, -5.43102957e-02f, -2.74042191e-04f,
  -1.07316628e-01f, 5.10755405e-02f, -2.01646853e-02f, 8.48478228e-02f, -1.05742319e-03f, -1.76576853e-01f, -4.41731513e-02f, -3.58493701e-02f, 4.25302144e-03f, -1.02352202e-02f,
  -4.80141006e-02f, 1.07500084e-01f, -7.50733912e-02f, -3.50941671e-03f, 8.18309113e-02f, 4.27786373e-02f, 7.60018378e-02f, 2.38177087e-02f, -3.86318862e-02f, 7.69787282e-02f,
  9.55902599e-03f, -9.32361782e-02f, -4.18225862e-02f, 3.59387062e-02f, -8.32641870e-02f, -4.56509553e-02f, -3.42143029e-02f, -3.16578187e-02f, -3.26296203e-02f, -4.56378385e-02f,
  -8.79402086e-02f, -4.69736122e-02f, -5.41068353e-02f, 2.28948854e-02f, -5.55869341e-02f, -1.92615169e-03f, -2.39093136e-02f, -4.31102235e-03f, -2.69248951e-02f, -4.59325425e-02f,
  -9.44030061e-02f, -2.07823724e-01f, 5.41636683e-02f, 8.87857899e-02f, 6.91541645e-04f, -5.09491190e-02f, -4.08941582e-02f, 2.86689643e-02f, -2.02417169e-02f, 2.61036237e-03f,
  7.35724345e-02f, 4.20039259e-02f, -5.31172007e-02f, -4.60054614e-02f, -8.25163424e-02f, -6.82728067e-02f, 1.09361075e-02f, 4.93838489e-02f, 1.00869173e-02f, 6.51388094e-02f,
  2.10935399e-02f, 2.65205391e-02f, 6.63821921e-02f, -7.33124688e-02f, 4.01550345e-02f, -5.96151426e-02f, 8.27283598e-03f, 3.30188274e-02f, 4.96818610e-02f, 3.89881507e-02f,
  2.77715802e-01f, 7.05163702e-02f, -1.05950408e-01f, 5.70210814e-02f, 1.26496106e-01f, 9.82009321e-02f, 3.59107964e-02f, 7.36044496e-02f, 7.71282986e-02f, -1.91540141e-02f,
  1.76480845e-01f, 1.91840187e-01f, 1.32978216e-01f, 1.25916377e-01f, 1.39065519e-01f, 3.53356823e-02f, -1.07432626e-01f, -9.16196108e-02f, -4.29750085e-02f, 5.60349785e-03f,
  4.56013251e-03f, 3.46756428e-02f, -1.32038631e-02f, 2.07669791e-02f, 1.27214761e-02f, -1.65281687e-02f, -2.94130594e-02f, 7.13568032e-02f, -9.30479690e-02f, -1.74770609e-01f,
  -5.49492948e-02f, 1.52810320e-01f, 7.54066929e-02f, 6.90181088e-03f, 5.17189652e-02f, 4.30263467e-02f, -7.58466646e-02f, -1.51222169e-01f, -8.57789069e-02f, -3.80621739e-02f,
  9.18041542e-03f, -6.59621730e-02f, -4.44639027e-02f, -3.90944555e-02f, 3.65164168e-02f, 3.46640460e-02f, -7.23223463e-02f, 3.46748903e-02f, -1.69114606e-03f, 2.95376219e-02f,
  2.36525340e-03f, -2.51572188e-02f, 5.37057258e-02f, 8.88722166e-02f, 6.97092563e-02f, -2.50834078e-02f, 2.91936193e-03f, -2.99840011e-02f, -5.48870452e-02f, 3.51553001e-02f,
  3.74093950e-02f, 5.31570986e-02f, -3.29412594e-02f, 6.15186170e-02f, 3.34070623e-02f, 4.91143428e-02f, -1.51887455e-03f, 2.42136698e-03f, -3.43541838e-02f, -7.55463913e-03f,
  -4.51932922e-02f, 1.15132920e-01f, -3.00614797e-02f, 6.05093269e-03f, -2.28214972e-02f, -8.47835839e-02f, -3.60325212e-03f, -5.75614423e-02f, 8.62178281e-02f, 1.06959224e-01f,
  2.33179741e-02f, 1.27494652e-02f, 9.76798125e-03f, -7.79619887e-02f, -5.54676317e-02f, -6.87776208e-02f, -2.59193033e-02f, 4.18841131e-02f, 1.69117399e-03f, -5.41983545e-02f,
  -5.43306880e-02f, 1.74394086e-01f, -1.76013168e-02f, 3.78234708e-03f, 2.21710280e-02f, -7.93288797e-02f, -1.13919079e-02f, -2.25352254e-02f, -1.91763658e-02f, -1.82257369e-02f,
  -7.51294345e-02f, 1.93424970e-02f, 1.46397054e-02f, -1.01932630e-01f, -6.84755892e-02f, -2.98005305e-02f, -2.07255129e-02f, 5.96977398e-02f, -6.56087622e-02f, -5.04240952e-03f,
  -9.43090394e-02f, 2.78905444e-02f, 8.10105503e-02f, -6.47378042e-02f, 2.22793128e-02f, 1.41532034e-01f, 8.60688165e-02f, -9.19968169e-03f, 3.34203430e-02f, 3.39335091e-02f,
  -1.35817006e-01f, -3.11378017e-02f, -4.29850034e-02f, -3.82837839e-02f, 2.35499181e-02f, 2.08806798e-01f, 2.00899422e-01f, 1.03429675e-01f, -2.48859301e-02f, -1.22533944e-02f,
  -6.39933348e-03f, 1.68624660e-03f, -5.79532534e-02f, -2.15434618e-02f, 7.26525411e-02f, 1.18379958e-01f, -6.84577152e-02f, 2.38460843e-02f, -9.51124448e-03f, -5.15595153e-02f,
  3.99903432e-02f, -1.15255855e-01f, -1.51732862e-01f, 5.84223568e-02f, -2.23702542e-03f, -7.08761290e-02f, -8.86913165e-02f, 2.24559326e-02f, -3.56224552e-02f, 1.17105031e-02f,
  -2.52427850e-02f, 2.68142000e-02f, 4.25251946e-02f, 4.78753932e-02f, 4.43954431e-02f, -3.85706499e-02f, -3.35001983e-02f, -1.81567166e-02f, 2.73758490e-02f, 1.39071560e-02f,
  2.31365245e-02f, -2.95270123e-02f, 1.85346175e-02f, -9.24664140e-02f, -9.22913849e-02f, 3.96859609e-02f, -8.00102502e-02f, 5.57857146e-03f, -4.59294356e-02f, 7.74386153e-03f,
  -3.78530771e-02f, -5.38422950e-02f, 5.49446419e-02f, 6.00133091e-02f, -2.85655912e-02f, 1.52066192e-02f, 3.69658731e-02f, -4.37710546e-02f, -2.79849917e-02f, -1.09560259e-01f,
  6.30948991e-02f, -4.45259456e-03f, 1.06713675e-01f, -3.48133482e-02f, 5.12264110e-03f, 3.54407094e-02f, 6.78691119e-02f, -4.91886912e-03f, -4.60697450e-02f, -5.68518415e-02f,
  -2.08812375e-02f, -6.94118366e-02f, 9.53983814e-02f, -3.13950516e-02f, -2.77959052e-02f, -1.84425302e-02f, -3.15339193e-02f, -4.71206121e-02f, 2.35514566e-02f, 7.54495487e-02f,
  5.56914806e-02f, -3.37271839e-02f, -3.98895293e-02f, -2.82530859e-02f, 1.12517573e-01f, -2.72371229e-02f, -5.00196889e-02f, -8.49772915e-02f, -6.85083331e-04f, -3.60362716e-02f,
  -1.54910401e-01f, 1.49863094e-01f, 2.02233363e-02f, 3.83253321e-02f, -2.72309948e-02f, -3.79488850e-03f, -8.34016651e-02f, -3.97512205e-02f, -8.68023410e-02f, 1.53440703e-02f,
  -2.22370476e-02f, -7.29998620e-03f, -7.88016021e-02f, -6.20566830e-02f, -1.92353074e-02f, 1.77724510e-02f, -3.35280574e-03f, 2.00159829e-02f, -9.43849534e-02f, -5.04666753e-02f,
  -6.70154244e-02f, -6.45300299e-02f, -1.20944053e-01f, -3.79632451e-02f, -1.17591701e-01f, -2.80815437e-02f, -3.53761241e-02f, -9.06254351e-02f, -2.94539351e-02f, -9.84084979e-02f,
  2.88136363e-01f, 1.08596019e-01f, 1.37636915e-01f, -3.54043916e-02f, -6.42740577e-02f, 1.09919822e-02f, 7.75121525e-02f, 1.82086658e-02f, 1.21228397e-02f, 5.81187159e-02f,
  -9.60349739e-02f, -2.03251168e-02f, 1.19902268e-02f, 4.25005369e-02f, -6.16955897e-03f, 3.36432084e-02f, 2.19045696e-03f, -6.19807467e-02f, -7.01097250e-02f, 5.65548614e-03f,
  5.43765686e-02f, 5.39670661e-02f, 7.54655823e-02f, -2.20887028e-02f, -6.60009086e-02f, -4.33396287e-02f, -5.44715077e-02f, 1.20582834e-01f, 3.18440907e-02f, -1.82403140e-02f,
  3.36452201e-02f, 2.45490834e-01f, -2.67085638e-02f, -3.46468911e-02f, -4.99243923e-02f, 5.28958179e-02f, -9.05364472e-03f, 9.29669589e-02f, 4.45039645e-02f, -2.70646680e-02f,
  -4.38217111e-02f, 5.91320507e-02f, -5.34535851e-03f, 4.93740104e-03f, -3.11554596e-02f, -5.40347695e-02f, -3.66752855e-02f, 8.76331925e-02f, -5.41865127e-03f, 8.22491348e-02f,
  -2.48660874e-02f, 6.21344782e-02f, 4.40082848e-02f, 1.08180670e-02f, 7.20863715e-02f, -2.83101760e-02f, 1.40740629e-02f, 3.07681039e-02f, -3.01942346e-03f, 7.75865316e-02f,
  -1.06422402e-01f, 9.24173966e-02f, 1.16668157e-02f, 7.11865351e-02f, -4.90096956e-02f, -5.89099564e-02f, 2.80997455e-02f, -6.90067634e-02f, -7.08278045e-02f, 5.97542822e-02f,
  -7.01652989e-02f, -3.06989346e-02f, 2.25267448e-02f, -4.70510162e-02f, -1.36889651e-01f, 3.69170867e-02f, -1.45601220e-02f, 8.80615972e-03f, 3.07112243e-02f, 2.40671728e-02f,
  -3.99410985e-02f, 3.31998318e-02f, 3.77729759e-02f, 3.93175147e-02f, 7.56129548e-02f, 2.65003610e-02f, -3.18895094e-02f, -8.32110569e-02f, -1.18742222e-02f, -7.50683248e-02f,
  -1.47421226e-01f, 2.82370928e-03f, -1.29235193e-01f, -4.54431549e-02f, -3.89950015e-02f, -2.31232140e-02f, -1.42056756e-02f, 2.29100138e-02f, -5.38255200e-02f, 7.63897374e-02f,
  6.18149787e-02f, 6.95269778e-02f, 1.00383773e-01f, -2.00509317e-02f, -1.11453325e-01f, 5.50748967e-02f, 6.30846322e-02f, 5.52570596e-02f, -1.12080745e-01f, 5.28667646e-04f,
  2.85510789e-03f, -1.16332117e-02f, -8.03379938e-02f, -4.24292795e-02f, -2.97450926e-02f, -8.61611888e-02f, 2.60472260e-02f, -1.97660574e-03f, -2.36405041e-02f, -6.26750216e-02f,
  1.86804477e-02f, -7.78284594e-02f, -2.76462361e-03f, 1.51656391e-02f, 3.44266109e-02f, -1.64613098e-01f, -1.79312751e-01f, -3.35705280e-02f, 2.66902708e-02f, -9.02902111e-02f,
  -8.98148194e-02f, 3.45073380e-02f, 4.85863760e-02f, -1.02990065e-02f, -4.10540076e-03f, 5.31630404e-03f, -3.10110953e-02f, -6.88956380e-02f, -1.62666454e-03f, -1.71206877e-01f,
  -3.07103563e-02f, -1.43575817e-02f, 4.30434644e-02f, -4.47545666e-03f, 6.21668175e-02f, 2.70636100e-02f, -2.22917716e-03f, 5.26154563e-02f, -1.13525353e-01f, -4.96178828e-02f,
  1.01847447e-01f, -1.26340231e-02f, -8.44456926e-02f, -1.09264553e-01f, 2.97495201e-02f, -7.16993585e-02f, -6.04363158e-02f, 5.51201440e-02f, 8.71910378e-02f, -4.06587357e-03f,
  2.40557943e-03f, 8.64371359e-02f, 5.69900200e-02f, 6.90436363e-02f, -6.64002448e-02f, 3.70026901e-02f, 1.61965825e-02f, 6.24285787e-02f, 8.97835642e-02f, 2.21307520e-02f,
  -4.59235683e-02f, 6.46744892e-02f, 2.48967074e-02f, -4.31082956e-02f, 7.04992786e-02f, -8.18877369e-02f, -7.55069777e-02f, -9.62974355e-02f, -8.05085618e-03f, 4.03740853e-02f,
  -1.85157899e-02f, 5.55885844e-02f, -3.45260687e-02f, -4.79527973e-02f, -1.45012420e-02f, 8.55267197e-02f, 3.96011770e-03f, -3.84707935e-02f, -8.09378773e-02f, -3.34893763e-02f,
  -4.63778712e-02f, 1.64982211e-02f, -7.17217326e-02f, 8.53352845e-02f, -6.34165779e-02f, 2.70097870e-02f, 4.79047075e-02f, 6.52700290e-02f, -3.43319960e-02f, 7.31919929e-02f,
  4.99715954e-02f, -6.67935610e-02f, -5.20512089e-03f, 1.20376768e-02f, -1.64824463e-02f, 1.59653760e-02f, 5.65402508e-02f, 2.02525575e-02f, 3.46954055e-02f, 3.82277407e-02f,
  9.28107947e-02f, -1.04215562e-01f, 9.97887030e-02f, -8.38969368e-03f, -1.85136870e-02f, -7.74750113e-02f, 3.16690430e-02f, -6.97114468e-02f, 4.25982624e-02f, -3.37566286e-02f,
  -8.75072107e-02f, -5.50805917e-03f, 7.19534755e-02f, 6.51572272e-02f, -3.83682698e-02f, -9.05285701e-02f, 1.44830821e-02f, -7.00579286e-02f, 3.81746776e-02f, 4.43035029e-02f,
  -1.69575382e-02f, -4.08291183e-02f, 4.37145047e-02f, -9.52097476e-02f, 3.81846651e-02f, -5.96725568e-02f, -8.43470693e-02f, 4.38211039e-02f, -8.10010433e-02f, -1.32271618e-01f,
  2.13916928e-01f, 1.66456386e-01f, 2.73642857e-02f, 5.52667230e-02f, 1.85894482e-02f, -6.20431639e-02f, 3.10571920e-02f, 1.16992787e-01f, 1.53395325e-01f, 1.48158118e-01f,
  -6.93339249e-03f, 4.50043678e-02f, 7.80869871e-02f, 3.05464113e-04f, 9.97193158e-02f, 1.95775688e-01f, 4.21737321e-02f, 1.53758794e-01f, 3.66160236e-02f, 3.13320942e-02f,
  -3.81817669e-02f, 4.48220111e-02f, 7.51988888e-02f, 8.51691216e-02f, 8.77762735e-02f, 4.33323793e-02f, 5.78257851e-02f, -3.07538286e-02f, -3.94318961e-02f, 1.92376941e-01f,
  3.80278528e-02f, 6.64222240e-02f, -3.14645804e-02f, -1.09455690e-01f, -6.52982891e-02f, 8.61845240e-02f, -6.43618628e-02f, 1.11919381e-02f, -4.34385054e-02f, 8.32378566e-02f,
  -2.54056770e-02f, 2.93377396e-02f, -2.74712499e-02f, 5.35510294e-02f, -2.00979616e-02f, -1.00272551e-01f, 6.80105090e-02f, 1.25114411e-01f, -6.26692474e-02f, 7.20145181e-02f,
  -6.93535879e-02f, -1.49821728e-01f, 1.08765624e-02f, -7.13283271e-02f, -9.27903783e-03f, -1.09900102e-01f, 5.61962649e-02f, 1.58497877e-02f, -1.59126464e-02f, -1.40254349e-02f,
  4.34817886e-03f, 4.89564762e-02f, -3.90375815e-02f, 8.69379565e-02f, 1.96226910e-02f, 6.54241145e-02f, 4.50976752e-02f, -9.96967964e-03f, -3.39644589e-02f, -2.46459264e-02f,
  5.11657707e-02f, 8.02179128e-02f, -5.42311668e-02f, 7.21963048e-02f, 2.99482420e-02f, -4.15120982e-02f, 4.69265841e-02f, 7.72726256e-03f, -1.62264369e-02f, 7.66404625e-03f,
  7.85144344e-02f, -1.92209929e-02f, -2.01630183e-02f, 5.29767945e-02f, 7.22740125e-03f, -1.21108424e-02f, 7.32905269e-02f, -8.65814462e-02f, -7.11879879e-03f, -2.10754070e-02f,
  -1.12588018e-01f, -1.26568183e-01f, 9.94756445e-02f, -7.63402786e-03f, -6.12535402e-02f, -2.57989131e-02f, -4.39475738e-02f, -2.25349665e-02f, -1.10497706e-01f, 4.72938828e-02f,
  -1.75469797e-02f, 1.53607531e-02f, 6.07097475e-03f, -3.74896498e-03f, 2.21521314e-02f, -7.16289803e-02f, -9.15422514e-02f, 3.33491787e-02f, -1.02509499e-01f, -8.74576941e-02f,
  1.66348182e-02f, -8.51757154e-02f, -4.38426733e-02f, -6.38800561e-02f, -4.91296053e-02f, -1.42829558e-02f, -6.08940870e-02f, -1.12599567e-01f, -5.80417998e-02f, 4.88160588e-02f,
  7.16844201e-02f, 1.01989694e-01f, 6.36792975e-03f, 1.42509460e-01f, 2.00999483e-01f, 5.97310811e-02f, 6.14977516e-02f, -1.15710534e-01f, 7.01574460e-02f, -1.18420376e-02f,
  6.74669519e-02f, 1.75521690e-02f, 5.44940159e-02f, -1.17208496e-01f, -1.53101251e-01f, -1.85809173e-02f, -4.57327813e-02f, -1.32850006e-01f, -1.32318124e-01f, 3.78119905e-04f,
  1.46682337e-01f, -1.92445028e-03f, 1.25512434e-02f, -6.14128858e-02f, 7.58215319e-03f, 7.80368224e-02f, 1.22013882e-01f, 1.58396624e-02f, -1.15301246e-02f, 1.14424653e-01f,
  -4.30839919e-02f, -4.90299091e-02f, -1.56215951e-01f, 8.29269513e-02f, -8.94603506e-03f, -9.45969746e-02f, -2.33113971e-02f, 4.46361043e-02f, -5.16125374e-02f, -8.57202634e-02f,
  8.56511295e-03f, -1.19091626e-02f, 2.47580372e-02f, -6.83654621e-02f, -1.03969917e-01f, -4.81316298e-02f, -7.62990937e-02f, -1.57670736e-01f, -1.23060830e-01f, -3.52654979e-02f,
  2.45515648e-02f, 2.16181993e-01f, -4.47654678e-03f, -7.82103240e-02f, -9.04106572e-02f, 7.86262453e-02f, 2.08511911e-02f, 3.49471229e-03f, -8.67907479e-02f, -1.41914710e-01f,
  -5.95166907e-02f, -2.66055930e-02f, 3.82736549e-02f, 2.43728403e-02f, 2.25876216e-02f, 7.63461068e-02f, -2.19738763e-02f, 7.64993876e-02f, -7.51354769e-02f, 1.74526684e-02f,
  -8.57705176e-02f, 5.50639406e-02f, -6.49273843e-02f, 3.62069393e-03f, -5.38562648e-02f, -6.71758177e-03f, -5.59347309e-02f, 4.65313382e-02f, -6.32609278e-02f, 1.67439952e-02f,
  5.58573268e-02f, -2.16597207e-02f, 2.03087255e-02f, -7.32813850e-02f, -5.74204065e-02f, 5.20906746e-02f, -6.71200454e-02f, -4.35637906e-02f, -3.29851592e-03f, 4.58540246e-02f,
  -1.22081272e-01f, -6.64196387e-02f, 2.02961471e-02f, -9.64561701e-02f, 9.06371549e-02f, -1.00051686e-01f, -4.96998169e-02f, 1.87226087e-02f, 7.69880638e-02f, 4.02302518e-02f,
  8.90050977e-02f, 5.05274758e-02f, -4.22971994e-02f, -3.77598070e-02f, 4.84193452e-02f, -1.15224589e-02f, -8.97370558e-03f, -7.34517127e-02f, -1.48702031e-02f, -8.82608891e-02f,
  -3.69751565e-02f, 5.08507974e-02f, -8.87062401e-02f, -8.96318853e-02f, -2.48458032e-02f, -8.32207501e-02f, -4.51702327e-02f, -8.00297186e-02f, -1.49681196e-01f, -8.87986496e-02f,
  3.30189168e-02f, 1.14347875e-01f, 4.36322242e-02f, 5.50648011e-02f, -2.79571638e-02f, -1.83632094e-02f, -9.32009369e-02f, -3.39944917e-03f, -2.66431249e-03f, -6.15992099e-02f,
  3.03005166e-02f, -4.27564755e-02f, -4.74718586e-03f, 5.30752204e-02f, -7.18856081e-02f, -4.00062911e-02f, 2.67359745e-02f, 8.78212526e-02f, 4.50922735e-02f, -5.38469963e-02f,
  -8.81723091e-02f, -3.38969454e-02f, 1.25811219e-01f, 2.67069768e-02f, 5.06787747e-02f, -1.86248857e-03f, 9.15927440e-02f, -3.18019837e-02f, -1.00156209e-02f, 1.07612245e-01f,
  -7.76711665e-03f, 1.01292320e-02f, 7.47945607e-02f, -6.37043267e-02f, 3.42630520e-02f, 4.79975604e-02f, 1.76504850e-02f, 8.92591998e-02f, -6.70217350e-02f, 1.04215937e-02f,
  -1.17902821e-02f, 7.54320994e-02f, -1.44718094e-02f, 1.10011091e-02f, -6.27927259e-02f, 6.40072227e-02f, -3.82024199e-02f, 1.22322366e-01f, 5.44861741e-02f, -2.63698283e-04f,
  -4.55737226e-02f, 6.65321499e-02f, 6.32365197e-02f, -9.07674357e-02f, -8.87537003e-02f, -9.88653228e-02f, 3.78256217e-02f, -6.72235787e-02f, -1.24756321e-02f, -1.85874738e-02f,
  -8.70813802e-02f, -1.09812692e-02f, -5.22819813e-03f, -8.26191083e-02f, -7.19633996e-02f, 3.38513590e-02f, -4.27815951e-02f, -7.80942887e-02f, -1.01003302e-02f, -9.69472900e-02f,
  -6.58593550e-02f, -8.42483640e-02f, -1.06469907e-01f, 4.92076017e-02f, -7.13647678e-02f, 1.47792781e-02f, -9.31528136e-02f, -3.63091603e-02f, 1.40889920e-02f, -1.46722775e-02f,
  -8.13854188e-02f, 3.36213484e-02f, -1.64948497e-02f, -1.93877853e-02f, -7.69285113e-02f, 4.29097675e-02f, -1.69507880e-02f, -7.43570849e-02f, 8.39812830e-02f, -1.01326942e-01f,
  3.80812585e-02f, 5.44738173e-02f, 5.48034944e-02f, 3.66610289e-02f, 4.47584726e-02f, 6.42753169e-02f, -9.31666940e-02f, -4.89765778e-02f, -1.86212268e-02f, -8.26687440e-02f,
  8.92970264e-02f, 4.99394611e-02f, -6.86866939e-02f, 7.30912313e-02f, -4.31754701e-02f, -1.47874613e-04f, -6.50983155e-02f, -1.71371941e-02f, -5.21315634e-02f, 8.93900543e-02f,
  2.87459940e-02f, -8.21040869e-02f, -4.50306982e-02f, -2.67565865e-02f, -2.68775560e-02f, 3.93746756e-02f, 2.38707177e-02f, -3.63156721e-02f, -6.16693608e-02f, -1.28631424e-02f,
  1.31934479e-01f, -1.51788205e-01f, -2.94257384e-02f, -3.70037258e-02f, 7.70538524e-02f, -7.61809722e-02f, -6.24634214e-02f, -2.91535049e-03f, -1.43313399e-02f, -3.49737592e-02f,
  -8.88101682e-02f, -1.06195202e-02f, -2.43969560e-02f, -1.16806634e-01f, -6.55512288e-02f, 2.52820440e-02f, 9.32996068e-03f, 1.22981980e-01f, 1.45125166e-01f, 7.28913769e-02f,
  7.01175258e-02f, 6.56371489e-02f, 6.79789186e-02f, 5.28376400e-02f, -6.68826103e-02f, 5.49255088e-02f, 6.25740439e-02f, -2.45430283e-02f, -6.22861944e-02f, -4.46622334e-02f,
  -2.25256793e-02f, -3.00453678e-02f, -2.71200445e-02f, -6.33640513e-02f, -7.18070418e-02f, -3.91774289e-02f, -5.11385463e-02f, 7.11489916e-02f, -9.63609945e-03f, 1.25711700e-02f,
  -4.16356921e-02f, 2.93020196e-02f, -7.46757910e-02f, 3.31592672e-02f, -6.77972212e-02f, 6.12392463e-03f, -4.75280322e-02f, 6.82772249e-02f, -5.05383275e-02f, -7.18056485e-02f,
  2.57429425e-02f, 6.51592910e-02f, 2.54983436e-02f, 6.60435036e-02f, -5.24041876e-02f, -3.61012332e-02f, 4.29288372e-02f, -3.60459834e-02f, -7.25554749e-02f, 5.39838672e-02f,
  -1.28344623e-02f, -2.62391008e-02f, -7.33362809e-02f, -2.13594623e-02f, 6.40469342e-02f, 4.36944328e-02f, -8.44422206e-02f, 7.12119341e-02f, -5.33590578e-02f, 6.96162283e-02f,
  -1.09766880e-02f, 3.52168456e-02f, 6.04349338e-02f, -6.14117980e-02f, 1.66059136e-02f, 1.18044177e-02f, 8.59292503e-03f, -5.20196408e-02f, 6.25612065e-02f, 5.88730611e-02f,
  7.92261437e-02f, 3.23599055e-02f, -1.70887131e-02f, -4.30170186e-02f, -3.45980562e-02f, 9.75519046e-02f, -5.68789616e-02f, -9.96811036e-03f, 8.13988447e-02f, -6.81821853e-02f,
  -1.07301682e-01f, -1.05535798e-01f, -7.05835521e-02f, 2.02014260e-02f, 5.37364259e-02f, -9.18619260e-02f, -1.22112870e-01f, -9.19166803e-02f, -8.73867497e-02f, 7.08342716e-02f,
  -5.41131608e-02f, -5.44665419e-02f, -7.40789324e-02f, 4.15546671e-02f, -6.11232035e-03f, -6.62148222e-02f, 1.31597593e-02f, 8.40247050e-02f, -6.04313351e-02f, -8.26869905e-02f,
  -3.50921378e-02f, -6.38774484e-02f, 7.10280240e-02f, -9.59712416e-02f, 3.50330062e-02f, 2.28671487e-02f, 6.44510835e-02f, -1.53478580e-02f, 1.37924673e-02f, -7.74815083e-02f,
  2.22055800e-02f, -2.36067269e-03f, -2.33501598e-01f, -2.14553084e-02f, 2.81313024e-02f, -1.25719607e-01f, 2.81389877e-02f, 3.12828869e-02f, 1.35453284e-01f, -1.61373466e-02f,
  -2.98777483e-02f, -1.97241753e-02f, -8.20755735e-02f, -3.42219807e-02f, -9.12884250e-02f, -9.13149416e-02f, -1.38077706e-01f, -1.26443416e-01f, -1.04151033e-01f, -2.97978278e-02f,
  4.79253419e-02f, 3.72002646e-02f, 2.07102131e-02f, 9.44880396e-02f, -1.41440853e-02f, -1.12044558e-01f, 2.21059620e-02f, -3.84990200e-02f, -1.67628005e-01f, -6.12741336e-02f,
  -1.58804849e-01f, -3.83566283e-02f, 3.62087414e-02f, 6.48782477e-02f, -6.72828332e-02f, -8.17881152e-03f, 1.00147314e-01f, 4.02317122e-02f, 9.18909684e-02f, 1.05663158e-01f,
  1.54598579e-02f, 6.77731559e-02f, -2.04508975e-02f, -4.46019992e-02f, 2.86248364e-02f, 3.32439542e-02f, 1.59864612e-02f, 7.03361854e-02f, 5.37498146e-02f, -6.04310557e-02f,
  -6.98763728e-02f, -4.31921035e-02f, 1.46558788e-02f, -2.24524345e-02f, -3.95358540e-02f, -3.36020812e-02f, -7.75761604e-02f, 4.34079058e-02f, -7.12502226e-02f, 5.36656901e-02f,
  1.08203709e-01f, 4.45970818e-02f, 6.79151416e-02f, -8.90056230e-03f, -2.82517504e-02f, -4.50133570e-02f, -4.03989553e-02f, -6.60484508e-02f, -7.79969851e-03f, 1.03689723e-01f,
  5.71992397e-02f, 4.32313345e-02f, -5.04356110e-04f, -1.89067163e-02f, 2.20005363e-02f, 7.12938979e-02f, -6.04055971e-02f, -1.94266643e-02f, -3.91480587e-02f, -1.39500471e-02f,
  -4.56589013e-02f, 4.01157290e-02f, -5.86880818e-02f, -6.42700568e-02f, -5.23317456e-02f, 6.53797761e-02f, -7.62549564e-02f, -3.68564352e-02f, -9.47061628e-02f, -1.38159459e-02f,
  4.26917747e-02f, -1.11954145e-01f, -1.82925984e-02f, 8.89656786e-03f, 4.89394180e-02f, -3.41620967e-02f, -3.50787491e-02f, 1.33531839e-02f, 5.93881235e-02f, 3.96562964e-02f,
  3.22388224e-02f, -6.99472874e-02f, -8.79548043e-02f, 6.30194545e-02f, 2.54665017e-02f, 1.85325835e-03f, -9.67415981e-03f, -9.61927846e-02f, -8.59627686e-03f, 1.11482397e-01f,
  1.60324480e-02f, 9.03746299e-03f, 1.29220977e-01f, 2.59871334e-02f, 4.03828882e-02f, -3.32753211e-02f, 7.51330480e-02f, 8.59198049e-02f, 4.77706864e-02f, 1.79795593e-01f,
  2.08165348e-02f, -2.41840407e-01f, 3.93588016e-05f, 1.40062273e-01f, 1.06604345e-01f, 8.00077245e-02f, 1.03401914e-01f, 4.98689376e-02f, 1.88274719e-02f, -9.08036530e-02f,
  -1.26529738e-01f, -1.15453832e-01f, -9.40683484e-02f, -8.75001401e-02f, -1.04208991e-01f, 5.71504124e-02f, 1.40618011e-02f, 6.88371435e-02f, 1.12620182e-01f, 6.38374165e-02f,
  7.31082037e-02f, 4.09224853e-02f, 7.20039979e-02f, -7.44693428e-02f, -1.03014842e-01f, -3.21610458e-02f, 6.51489338e-03f, -8.25593993e-02f, 2.38587931e-02f, -8.15901607e-02f,
  -6.71631247e-02f, -8.05870593e-02f, 2.36802790e-02f, -1.31123126e-01f, -9.31688845e-02f, -3.17555703e-02f, 6.62751347e-02f, 1.93396360e-02f, 1.61416084e-02f, -4.66733016e-02f,
  -1.17872931e-01f, -1.12569274e-03f, -1.25807688e-01f, 5.05282320e-02f, -2.90865339e-02f, 3.57099883e-02f, -1.17160834e-01f, -4.04191427e-02f, -2.31364239e-02f, -6.53173253e-02f,
  -1.29565904e-02f, 3.92627753e-02f, -6.83994815e-02f, -7.95646980e-02f, -9.45046991e-02f, -2.62413137e-02f, -8.96313563e-02f, -5.07915393e-02f, 6.29546270e-02f, 8.05176720e-02f,
  -5.23357987e-02f, -3.61819044e-02f, 2.90844049e-02f, -7.05738813e-02f, 9.64344218e-02f, -4.35564704e-02f, 7.48444721e-02f, -9.48121399e-02f, 7.78676718e-02f, 4.94481623e-02f,
  -1.17729595e-02f, 5.91244772e-02f, -4.27475423e-02f, -2.39982698e-02f, -5.49798273e-02f, -1.44584514e-02f, -6.08996563e-02f, 3.19347344e-02f, -3.35109755e-02f, 5.01430072e-02f,
  2.76792813e-02f, -6.14679977e-02f, 3.95807344e-03f, 4.80324998e-02f, -3.92661020e-02f, 7.05157686e-03f, 2.58225221e-02f, -1.18298933e-01f, 5.43318577e-02f, 3.69752944e-02f,
  5.32307774e-02f, 2.91446154e-03f, 8.28237757e-02f, 5.59142046e-02f, 5.37676364e-02f, 2.87668891e-02f, -9.69158486e-02f, -8.78178701e-02f, 3.95326763e-02f, 9.32609371e-04f,
  4.35744151e-02f, 6.38832301e-02f, -2.22527683e-02f, -2.05931496e-02f, 5.90689071e-02f, 1.19200587e-01f, -3.12108118e-02f, -6.30000979e-02f, 5.97561663e-03f, 5.23100160e-02f,
  -1.00661255e-01f, 1.06161624e-01f, 2.01752916e-01f, 1.12729430e-01f, -4.49348390e-02f, 6.29339516e-02f, 1.36908591e-01f, 4.55745570e-02f, 1.41717568e-01f, 2.02166811e-01f,
  6.23564981e-02f, -1.54864937e-01f, -1.48257166e-01f, -1.20735586e-01f, -1.57680959e-01f, -2.11566687e-01f, -8.12904462e-02f, -1.16926722e-01f, -1.05112180e-01f, -6.30797520e-02f,
  5.09288255e-03f, 1.40666112e-01f, 1.50075957e-01f, -1.90684033e-04f, 2.12169043e-03f, -1.39550641e-01f, -2.07939312e-01f, 6.14290722e-02f, 1.40033469e-01f, -6.43658265e-03f,
  2.76692882e-02f, 5.05785597e-03f, 8.74810293e-02f, -5.44828475e-02f, -2.87531968e-02f, 9.94798690e-02f, -1.80174857e-01f, -7.74477199e-02f, -1.25321418e-01f, -9.23303887e-02f,
  1.19956017e-01f, -1.80820040e-02f, 2.03019176e-02f, 8.24804045e-03f, -7.43441433e-02f, 2.64894799e-03f, -2.10802779e-02f, 5.61620183e-02f, -7.37956762e-02f, -5.30987978e-03f,
  1.04354016e-01f, 9.54780728e-02f, 1.57793257e-02f, 6.66295364e-02f, 5.27301580e-02f, 4.87411283e-02f, -1.21939033e-02f, -6.47895262e-02f, 3.28417565e-03f, 2.93719191e-02f,
  -9.47427377e-02f, 3.18355151e-02f, -4.26899008e-02f, 4.71647717e-02f, -5.58921099e-02f, 1.23508982e-01f, -1.40362261e-02f, 1.37099205e-02f, -5.59151918e-02f, -1.02651063e-02f,
  -2.38781758e-02f, -3.68230268e-02f, 1.65057164e-02f, 4.96910699e-02f, -2.28644609e-02f, -2.07130727e-03f, -9.03684124e-02f, -3.15086916e-02f, -2.22817622e-02f, 8.90646502e-03f,
  -7.16698472e-04f, -5.64119220e-02f, 3.33091952e-02f, -1.19537460e-02f, 3.41745391e-02f, -4.80947047e-02f, -8.20160750e-03f, 7.66205927e-03f, 1.99730601e-03f, -3.36153395e-02f,
  5.51279821e-02f, -9.13703814e-02f, -1.85038392e-02f, -2.94255484e-02f, -2.60827690e-02f, 1.13127232e-02f, -6.93576084e-03f, 4.60066833e-03f, -1.09438792e-01f, 7.91602675e-03f,
  1.12876184e-01f, 4.02503181e-03f, -5.05495025e-03f, 2.77582128e-02f, -1.84360035e-02f, -1.82821844e-02f, -3.54029797e-02f, 6.85451105e-02f, -1.74941942e-02f, -6.29507974e-02f,
  1.26323342e-01f, 7.45119229e-02f, -3.82047594e-02f, -6.18407913e-02f, 3.73188443e-02f, 3.25337537e-02f, -8.73462558e-02f, 1.08933568e-01f, -7.91665614e-02f, -4.21783775e-02f,
  -1.35780543e-01f, -8.79384056e-02f, 7.29507431e-02f, 9.75495279e-02f, 8.17834437e-02f, 9.17721093e-02f, 8.24125558e-02f, 9.33644101e-02f, 6.46932796e-02f, -2.81423908e-02f,
  -1.76919520e-01f, 2.80488189e-03f, -5.71528599e-02f, -1.27585649e-01f, 6.33147405e-03f, 7.12500513e-02f, -3.12264916e-02f, -5.44303358e-02f, 1.75086968e-02f, 8.96298960e-02f,
  -1.83235854e-02f, 3.45316492e-02f, 6.40318617e-02f, -8.55568051e-03f, -7.73871690e-02f, -1.18055716e-01f, -1.17917404e-01f, -8.63597691e-02f, -1.64719939e-01f, -3.69787328e-02f,
  1.01229608e-01f, -7.06378967e-02f, -3.83088179e-02f, 3.13277952e-02f, -6.56431094e-02f, -2.45276242e-02f, 2.29643285e-02f, 2.96976194e-02f, -2.88439505e-02f, -6.73594978e-03f,
  -2.93342397e-02f, -2.02962104e-02f, -5.84811680e-02f, 6.11126050e-02f, 2.45245155e-02f, -3.47417556e-02f, 1.42728873e-02f, -9.73811969e-02f, 4.95653041e-02f, -6.95094466e-02f,
  1.45259337e-03f, -6.22801967e-02f, -8.47302824e-02f, -2.06652544e-02f, -8.34824815e-02f, -9.43663344e-02f, -8.82654861e-02f, -1.59066781e-01f, -5.94086163e-02f, 4.48616408e-02f,
  6.48410916e-02f, 1.32623324e-02f, -9.52685103e-02f, -4.15435918e-02f, -1.20955937e-01f, -1.14252910e-01f, -7.90091082e-02f, -2.23589074e-02f, -1.32015362e-01f, -4.13957015e-02f,
  3.52140591e-02f, 8.60835612e-02f, 7.22710416e-02f, -2.07164548e-02f, 6.17884099e-02f, -5.37101179e-02f, 5.88221028e-02f, -4.21485007e-02f, 2.87974235e-02f, 5.56912972e-03f,
  -4.73356480e-03f, -1.15099717e-02f, 1.38094407e-02f, -7.20287934e-02f, 5.82739040e-02f, -8.16441700e-02f, 2.88443249e-02f, 1.74570400e-02f, 3.88191082e-02f, 9.24583990e-03f,
  5.85284084e-02f, 2.74069817e-03f, 6.72008395e-02f, 6.38054237e-02f, 1.63716786e-02f, -4.21982585e-03f, 7.34267524e-03f, 5.78189977e-02f, -3.73032875e-02f, 6.26032427e-02f,
  -1.13559030e-01f, -4.94528003e-02f, 2.92861904e-03f, 6.55075163e-02f, 4.09418233e-02f, -9.33746155e-03f, 8.77880827e-02f, -3.63362767e-02f, -3.42214690e-03f, -4.07203287e-02f,
  -2.54927184e-02f, -6.63946345e-02f, 1.18693672e-02f, -6.03894591e-02f, -5.01000136e-02f, -1.85920112e-02f, 1.82810444e-02f, -7.08633587e-02f, -2.94690672e-02f, -8.54997709e-02f,
  -1.14492901e-01f, 2.97045484e-02f, -1.51485756e-01f, -1.37475431e-01f, -2.99899559e-02f, 1.25586540e-02f, -5.25071360e-02f, -1.27859518e-01f, -4.76420373e-02f, -4.17242236e-02f,
  -1.26383811e-01f, -6.40002489e-02f, 9.84445810e-02f, 4.23430093e-02f, -1.18885741e-01f, -9.41871032e-02f, -1.08502962e-01f, -1.37197703e-01f, -7.46317022e-03f, -8.69433209e-02f,
  5.42038754e-02f, 7.60346800e-02f, 1.04574949e-01f, -8.68818350e-03f, 1.85861681e-02f, -3.82575728e-02f, -1.26470894e-01f, 6.57512993e-02f, -7.77656063e-02f, 1.49992313e-02f,
  -3.65608335e-02f, 7.08144084e-02f, -2.73240935e-02f, -3.40314656e-02f, 1.02304637e-01f, 5.82930408e-02f, 4.18456905e-02f, 7.58593529e-02f, -2.80694757e-02f, 6.60368335e-03f,
  2.85897076e-01f, -1.44281521e-01f, 4.49616946e-02f, -1.26387253e-01f, 4.60948609e-02f, 3.87478173e-02f, -7.97385126e-02f, 9.55170840e-02f, 1.68331116e-02f, -7.11576194e-02f,
  9.68274176e-02f, 2.40958277e-02f, -5.44205941e-02f, -5.88999465e-02f, 1.29676741e-02f, 1.91117879e-02f, -1.04372241e-01f, -6.72762021e-02f, -7.31211379e-02f, -8.78912434e-02f,
  -1.04825787e-01f, 5.35340831e-02f, -6.14920780e-02f, -5.25365733e-02f, -4.10591401e-02f, -5.59735708e-02f, 5.72634414e-02f, -2.51739547e-02f, 2.33813953e-02f, -7.75857717e-02f,
  -4.29304987e-02f, 7.26037249e-02f, -5.68873920e-02f, 5.17625064e-02f, -2.20727921e-02f, -3.74755189e-02f, 1.52691515e-04f, 3.58653367e-02f, -8.34955648e-02f, 6.53025359e-02f,
  -7.15841800e-02f, 6.58679008e-02f, 1.47227210e-03f, -5.18020988e-02f, 2.56054215e-02f, 1.53029962e-02f, 4.13560160e-02f, 3.56034897e-02f, 8.31973087e-03f, -4.09356728e-02f,
  -7.39853457e-02f, 2.04138979e-02f, 8.69524665e-03f, -4.58202362e-02f, 4.01247814e-02f, 2.75088698e-02f, -3.19699710e-03f, -6.83635846e-02f, 6.28394261e-02f, 5.50017841e-02f,
  1.61952749e-01f, -7.75545314e-02f, -2.83329524e-02f, -7.17099383e-02f, 5.55142500e-02f, -4.36714143e-02f, -6.99989870e-02f, -7.14381924e-03f, -5.23115210e-02f, 3.23483720e-02f,
  3.39455344e-02f, -7.49340421e-03f, -3.38188112e-02f, 3.70318070e-02f, -7.09164515e-02f, -6.03861064e-02f, -7.07328096e-02f, 3.40212956e-02f, -5.51450066e-02f, -5.64072840e-02f,
  5.67634292e-02f, -1.87407229e-02f, -1.14493137e-02f, 7.22218901e-02f, 4.80732089e-03f, -4.78824265e-02f, 1.23105600e-01f, 6.28120005e-02f, 2.05167737e-02f, 6.76460266e-02f,
  2.34450903e-02f, -1.72231495e-01f, 4.22922485e-02f, 1.43615276e-01f, 1.37611330e-01f, 1.10593043e-01f, 1.08438633e-01f, 1.68254543e-02f, 7.79284537e-02f, -2.41210740e-02f,
  -1.76363915e-01f, -7.47694373e-02f, -1.03866547e-01f, -5.18838316e-02f, -1.08780243e-01f, -9.26969014e-03f, 2.59632673e-02f, 1.55309170e-01f, 1.29178852e-01f, 7.10693598e-02f,
  -3.32566500e-02f, 5.55847101e-02f, 7.70583227e-02f, 1.15630932e-01f, -1.89538132e-02f, -9.64741409e-02f, -5.85157704e-03f, -6.06401302e-02f, -3.35179940e-02f, 6.61346316e-02f,
  -9.33710486e-03f, 5.81757911e-02f, -5.26472405e-02f, -7.38449246e-02f, -8.09239745e-02f, -1.89519580e-02f, 5.75400777e-02f, -4.80845682e-02f, -7.38953352e-02f, 1.19130835e-02f,
  5.04804254e-02f, -1.09280989e-01f, -1.94751006e-02f, 3.52669619e-02f, 5.43688796e-03f, 6.89508989e-02f, -6.19633589e-03f, 1.47130629e-02f, -1.00044720e-01f, -1.28189567e-02f,
  -4.90272455e-02f, -1.90528762e-02f, -1.84000786e-02f, 6.38863966e-02f, -2.20782284e-04f, 4.53235209e-03f, 5.93345426e-02f, 8.23487788e-02f, 9.19662416e-02f, -2.27732696e-02f,
  3.93442474e-02f, -2.53007021e-02f, -7.84790292e-02f, -1.85349174e-02f, -5.39495535e-02f, -6.74261674e-02f, 1.05637744e-01f, 5.36018349e-02f, -5.06143160e-02f, 3.12821269e-02f,
  8.81726220e-02f, -3.52888070e-02f, 1.07036456e-01f, 2.48388574e-03f, -4.28546965e-03f, 1.41990057e-03f, -4.00381051e-02f, 2.51376517e-02f, -2.43973751e-02f, -1.27144773e-02f,
  -6.98001087e-02f, 9.54689682e-02f, -1.88435297e-02f, 6.30371049e-02f, -7.07123429e-02f, 1.13272600e-01f, 3.04200239e-02f, -4.42074537e-02f, -4.96395715e-02f, 3.35916765e-02f,
  -5.67025691e-02f, -2.38225851e-02f, 8.63427389e-03f, -5.02470210e-02f, -3.98379043e-02f, -4.59226258e-02f, 1.76219624e-02f, -5.76578826e-02f, 1.54658863e-02f, -3.85193601e-02f,
  8.71490454e-04f, 3.65115553e-02f, -9.13250744e-02f, -2.87499670e-02f, 1.11232296e-01f, -7.31953885e-03f, -3.41901854e-02f, 9.45597962e-02f, 7.03405440e-02f, -6.75908849e-02f,
  2.89589334e-02f, 7.75178373e-02f, -3.77120101e-03f, 1.12041021e-02f, -7.60513032e-03f, 1.00909129e-01f, -3.57131399e-02f, 4.98473160e-02f, 1.27818391e-01f, 1.65535733e-02f,
  3.36580396e-01f, 2.10562795e-02f, -3.45163375e-01f, 1.46196142e-01f, -1.47948742e-01f, -2.05364019e-01f, -1.65677503e-01f, -5.45386337e-02f, 8.71531218e-02f, 8.11506342e-03f,
  -7.09240884e-03f, 1.28403157e-02f, -1.23836979e-01f, -1.34860009e-01f, -1.93552852e-01f, -5.96669316e-02f, -1.44264922e-01f, -1.75242111e-01f, -2.62938619e-01f, -1.19054606e-02f,
  1.95299368e-02f, 9.96700078e-02f, 1.56081840e-01f, 3.84743884e-02f, 4.78471518e-02f, 7.85805583e-02f, 5.49286529e-02f, 1.64745394e-02f, -8.68669599e-02f, 7.34657645e-02f,
  -1.00178674e-01f, -3.60131590e-03f, -1.21716052e-01f, 7.14299176e-03f, -1.07592314e-01f, 2.23448295e-02f, -9.10368934e-02f, -4.85011637e-02f, -1.07959643e-01f, 2.06539147e-02f,
  -1.41943917e-01f, -7.53754824e-02f, -9.18715298e-02f, 7.64116237e-04f, 5.23857661e-02f, 5.28079504e-03f, -3.94182578e-02f, -3.70715596e-02f, -9.07591432e-02f, -9.77321565e-02f,
  -6.26593083e-02f, -1.13272510e-01f, -1.04774922e-01f, 1.93741091e-03f, -1.21811286e-01f, -3.64489704e-02f, -1.04912020e-01f, -6.77519366e-02f, 3.29874037e-03f, 1.19809955e-01f,
  -3.49413715e-02f, -6.74949139e-02f, -6.80859461e-02f, 3.06597706e-02f, 2.26818379e-02f, 3.02926097e-02f, 2.00878712e-03f, 1.36925280e-02f, -9.23734233e-02f, -6.53416663e-03f,
  9.16951161e-04f, -9.37237069e-02f, -3.73997204e-02f, 1.57960597e-02f, -7.34904557e-02f, -9.40952674e-02f, 4.10823412e-02f, 6.14071898e-02f, 7.62002170e-02f, 1.46341892e-02f,
  -2.90427101e-03f, -1.82629358e-02f, -1.87235735e-02f, -6.03213459e-02f, 2.21471842e-02f, -4.68752012e-02f, 1.17822317e-02f, 2.48063337e-02f, 6.85407147e-02f, 4.53368016e-02f,
  2.49461412e-01f, -1.61800981e-01f, 1.94618646e-02f, -1.90073159e-02f, -6.59709051e-02f, -2.87839733e-02f, 2.35530455e-02f, -2.18501724e-02f, -8.11374635e-02f, -2.74999272e-02f,
  -5.39127998e-02f, -1.66733507e-02f, -4.03280258e-02f, -4.21724133e-02f, -7.65436813e-02f, 5.87330014e-03f, 1.26988441e-01f, 3.38343866e-02f, 3.40149216e-02f, 3.65749523e-02f,
  8.99128020e-02f, -3.74296941e-02f, 1.37707526e-02f, -4.79550809e-02f, -8.47332478e-02f, -4.27454710e-02f, -7.19203725e-02f, -6.79392815e-02f, -1.59126997e-01f, 2.09015295e-01f,
  2.12162644e-01f, -1.75729498e-01f, 3.32823247e-02f, 1.03428647e-01f, 2.16817483e-03f, -8.76982659e-02f, -1.62554473e-01f, -1.17537588e-01f, -2.98804268e-02f, -3.31593677e-02f,
  1.73622202e-02f, -3.65730748e-02f, -5.07009067e-02f, 3.86325009e-02f, -6.63725063e-02f, -4.86244075e-02f, 2.40334366e-02f, 1.44938335e-01f, 1.28643334e-01f, 3.42405848e-02f,
  -1.20303743e-02f, 4.81861271e-02f, 7.88340271e-02f, 1.42766491e-01f, -3.59289953e-03f, 3.35083306e-02f, 1.93999540e-02f, 9.60240737e-02f, 2.52292249e-02f, 1.43695623e-01f,
  9.86648374e-04f, -7.06863403e-02f, 4.07161526e-02f, 1.11232579e-01f, 5.23701757e-02f, -1.08554075e-02f, -3.64373885e-02f, 4.51990403e-02f, -1.50290234e-02f, -7.46369958e-02f,
  9.52779204e-02f, 3.78789641e-02f, 7.23039955e-02f, 5.90655282e-02f, -5.34058437e-02f, -8.21575001e-02f, -6.75151423e-02f, 7.34650567e-02f, 5.79735562e-02f, -1.03983991e-01f,
  -1.86708048e-02f, 5.46201393e-02f, -1.51682664e-02f, -5.86374700e-02f, -1.04009017e-01f, 1.06925599e-01f, 3.69703062e-02f, -3.20623852e-02f, -6.38053492e-02f, -6.18556142e-02f,
  8.44389498e-02f, -5.79856858e-02f, 6.07654974e-02f, -4.38821428e-02f, 1.90108605e-02f, 5.05704395e-02f, 7.29018077e-03f, -7.41545632e-02f, 3.49526368e-02f, 4.68528718e-02f,
  -2.83290166e-02f, -3.69935855e-02f, -2.14395556e-03f, -3.03405132e-02f, -7.56913871e-02f, 4.88633290e-02f, 8.38730335e-02f, -2.26662587e-02f, -5.60078956e-02f, 5.04428372e-02f,
  -2.72433693e-03f, -3.41828763e-02f, -3.08863167e-02f, -2.00189427e-02f, 6.88822418e-02f, -1.11713177e-02f, 2.13794392e-02f, -9.14816931e-03f, -6.93822578e-02f, 9.20582563e-02f,
  -1.15669698e-01f, -7.95664713e-02f, 5.64638488e-02f, 8.56692567e-02f, 6.61571994e-02f, 7.65329599e-02f, 8.49533379e-02f, 7.95173049e-02f, 2.84579173e-02f, -2.67622601e-02f,
  -3.18748094e-02f, 6.84542628e-03f, 5.40704578e-02f, -2.53127255e-02f, 5.52734658e-02f, 9.88374501e-02f, -1.46819390e-02f, -1.98174757e-03f, -4.24171537e-02f, 5.07757813e-03f,
  -7.81334564e-02f, -4.93789166e-02f, 1.97075531e-02f, -2.33895350e-02f, 2.84031387e-02f, 1.40614346e-01f, 1.69168762e-03f, 4.18216959e-02f, 4.16019261e-02f, 6.51588961e-02f,
  -1.00076512e-01f, -2.19619006e-01f, -2.70507544e-01f, -5.70876859e-02f, 5.99023886e-03f, 1.44490361e-01f, 1.35426715e-01f, 6.26533404e-02f, -6.56541437e-02f, -2.01799907e-02f,
  -1.44826531e-01f, -4.89045158e-02f, -1.47507638e-01f, -2.43908074e-02f, 7.99232945e-02f, -8.14532861e-03f, -1.71079755e-01f, -5.46874292e-02f, 7.27693737e-02f, 6.90063834e-02f,
  -2.13442221e-02f, 6.42817989e-02f, 1.63025744e-02f, -5.68775795e-02f, -7.59869162e-03f, -1.33160174e-01f, -2.19795257e-01f, -9.50787961e-02f, -4.85189222e-02f, -1.72116667e-01f,
  -1.92998543e-01f, -9.21455920e-02f, 1.25956371e-01f, 6.76210150e-02f, -8.98969993e-02f, -1.36874272e-02f, 1.94991753e-02f, -3.24774645e-02f, -2.79267959e-04f, 4.20857519e-02f,
  -9.39380378e-02f, 9.43835527e-02f, -8.05288404e-02f, 2.99846884e-02f, 6.62419479e-04f, -6.07622713e-02f, 5.42202815e-02f, -7.15969224e-03f, -1.16410352e-01f, 4.70811427e-02f,
  -3.47208418e-02f, -8.55091214e-02f, 3.53898779e-02f, -3.29293013e-02f, 6.25903010e-02f, 2.42497381e-02f, -6.40223175e-02f, 1.97341759e-02f, 2.22111437e-02f, -8.11398774e-02f,
  1.16948351e-01f, -4.96053062e-02f, -4.80380561e-03f, 3.96119244e-02f, -3.67322564e-02f, -3.11519131e-02f, 1.53118428e-02f, 4.35162820e-02f, 5.49178608e-02f, 4.28070500e-02f,
  3.91072370e-02f, -6.18294738e-02f, 6.94118142e-02f, 1.13639096e-02f, -1.02634244e-01f, 4.98795100e-02f, 3.81030552e-02f, -1.84717495e-03f, -9.48489681e-02f, 3.95880267e-02f,
  -2.01701336e-02f, 3.67938206e-02f, -1.02550633e-01f, 6.71109408e-02f, -6.68698847e-02f, -1.55501608e-02f, 4.99302335e-03f, 1.07913345e-01f, 7.30505586e-02f, 4.49634343e-02f,
  -7.06743151e-02f, -4.65698205e-02f, -4.18751612e-02f, 2.53238399e-02f, -1.18743139e-03f, 1.61930174e-02f, -6.48544356e-02f, -8.98119137e-02f, -1.19919181e-01f, -2.55429801e-02f,
  5.21019176e-02f, 2.52738371e-02f, 7.93598220e-03f, 2.12289486e-02f, 1.39544334e-03f, 4.99186739e-02f, -1.44856274e-02f, -2.49848329e-02f, 5.84242716e-02f, 2.76180860e-02f,
  -2.91747469e-02f, 3.51687670e-02f, 6.13647699e-02f, 3.42978276e-02f, 4.06036228e-02f, -4.50646803e-02f, -7.98703283e-02f, 1.25443012e-01f, 1.39770359e-01f, 4.30237502e-02f,
  -3.71738553e-01f, -7.78814480e-02f, 1.03396006e-01f, -1.67433899e-02f, 1.18188232e-01f, 2.01444309e-02f, 6.67061731e-02f, -3.38198915e-02f, 1.66370813e-02f, -6.94544390e-02f,
  -4.62866528e-03f, -8.57017562e-02f, 4.49201390e-02f, 7.53729343e-02f, -4.38740570e-03f, 2.74809264e-02f, 1.30469978e-01f, 1.43972754e-01f, 6.32321537e-02f, -1.19240955e-01f,
  3.59994397e-02f, -5.09009920e-02f, -5.57646751e-02f, -3.41083738e-03f, -6.65919632e-02f, -5.56097887e-02f, -2.05929540e-02f, -1.01306625e-02f, 4.72376607e-02f, -1.04724932e-02f,
  -2.15327367e-01f, -2.67100960e-01f, 1.09302565e-01f, 2.53771972e-02f, 7.09890053e-02f, -1.11408643e-01f, -1.06131308e-01f, -5.66345006e-02f, -6.66909516e-02f, 5.41847311e-02f,
  1.40744597e-02f, 3.44707747e-03f, 2.36254502e-02f, 5.90071306e-02f, 3.51528358e-03f, 2.48993039e-02f, -7.41099641e-02f, -1.43856956e-02f, -2.02775802e-02f, -1.29034594e-01f,
  3.77643146e-02f, -6.54536188e-02f, -1.04023807e-01f, 5.79305664e-02f, -7.55596906e-02f, -3.11369356e-02f, -1.04301229e-01f, -9.23712328e-02f, 9.80472844e-03f, -1.35394290e-01f,
  -4.35158610e-02f, 1.48475701e-02f, -3.15817483e-02f, 2.22607497e-02f, 2.40457407e-03f, 5.54765910e-02f, 1.82457026e-02f, -8.17178399e-04f, 6.45832866e-02f, -4.23677862e-02f,
  3.13344710e-02f, 4.85020969e-03f, 6.28940901e-03f, -2.03915350e-02f, 4.75832596e-02f, -8.38192180e-03f, -3.51130888e-02f, 2.50223260e-02f, 1.64456666e-02f, -6.14335313e-02f,
  3.46368505e-03f, -5.30928150e-02f, -4.24370505e-02f, 9.59456190e-02f, 2.35204212e-02f, 7.31183961e-02f, -7.28036137e-03f, -2.81368867e-02f, 3.95653360e-02f, -6.59466013e-02f,
  -1.12348132e-01f, 3.08793914e-02f, -8.02001953e-02f, -1.19557939e-01f, -8.92527029e-02f, 2.14158390e-02f, 3.46432738e-02f, 2.90295687e-02f, -4.99789082e-02f, -1.04479596e-01f,
  -3.25881392e-02f, -5.45914397e-02f, -4.73053642e-02f, 5.64831421e-02f, -9.72646102e-02f, -1.19411372e-01f, -2.94397362e-02f, 1.47817321e-02f, 5.88783920e-02f, -2.37099566e-02f,
  8.39061514e-02f, -1.48985565e-01f, -1.98023647e-01f, -7.85239935e-02f, -9.15795490e-02f, -1.34930134e-01f, -7.29410797e-02f, -1.11509018e-01f, -7.88533837e-02f, -1.92585424e-01f,
  -1.13318726e-01f, -9.01250839e-02f, -5.21603078e-02f, 4.24309447e-02f, -5.90738505e-02f, -5.44614270e-02f, -8.89190212e-02f, -2.40697693e-02f, -9.04437304e-02f, -1.15213677e-01f,
  9.07868706e-03f, 5.52257374e-02f, 4.45247851e-02f, 3.74751464e-02f, 2.39488594e-02f, -1.10820152e-01f, 3.63285318e-02f, -1.49212573e-02f, -6.11299016e-02f, -2.13150550e-02f,
  3.21228849e-03f, -3.84495445e-02f, -3.03986836e-02f, 7.95302689e-02f, 3.86819132e-02f, -6.03196537e-03f, 8.43096897e-02f, -7.20541626e-02f, -7.68132582e-02f, 2.89756674e-02f,
  3.60651594e-03f, -7.74729401e-02f, -1.76993888e-02f, 6.54749349e-02f, 7.34956935e-02f, -6.14487082e-02f, -5.50994426e-02f, -6.52132407e-02f, -6.77091926e-02f, 3.89996395e-02f,
  -1.86171271e-02f, 9.45086777e-02f, 3.01685855e-02f, 4.18680906e-02f, -6.96086213e-02f, 3.23199965e-02f, 1.92681458e-02f, -1.31315030e-02f, -3.73924598e-02f, 6.94456026e-02f,
  -7.28448182e-02f, -9.25360024e-02f, -5.67082018e-02f, -3.50538492e-02f, -5.62153850e-03f, -5.12606949e-02f, -1.27223041e-02f, -5.70486076e-02f, -1.05289005e-01f, -1.42158791e-01f,
  6.91037476e-02f, 3.23497802e-02f, -3.86773869e-02f, 5.26469667e-03f, -6.78949133e-02f, 4.35620472e-02f, 7.74419159e-02f, 3.76686156e-02f, -1.14318803e-02f, 7.38117620e-02f,
  -3.04064266e-02f, -3.29176374e-02f, 4.85863723e-03f, -3.70514281e-02f, -4.75184098e-02f, 2.32836492e-02f, 3.37716658e-03f, -4.57296930e-02f, -2.61058956e-02f, -4.64582108e-02f,
  3.72729339e-02f, -2.12806314e-02f, 2.37349458e-02f, 6.42857887e-03f, -3.46026313e-03f, -3.75925712e-02f, -6.33852854e-02f, 6.53811381e-04f, -7.21038785e-03f, -7.65108690e-02f,
  -8.93808305e-02f, -3.04750334e-02f, -1.09554999e-01f, -8.41129199e-02f, -5.08467332e-02f, -4.38933931e-02f, 6.92047477e-02f, 2.74977423e-02f, 6.51923344e-02f, -7.96205923e-02f,
  5.32625429e-02f, -3.76796201e-02f, -8.33086669e-02f, 5.61847612e-02f, -5.30816317e-02f, 3.59886289e-02f, 9.16116685e-02f, 2.92357858e-02f, -4.18873541e-02f, -8.72218087e-02f,
  3.22030783e-02f, -1.05658598e-01f, -7.63740391e-02f, -8.35068747e-02f, -9.75359157e-02f, -1.94075350e-02f, -1.28865317e-01f, -7.49098435e-02f, -6.07973188e-02f, -1.09185897e-01f,
  -8.64409134e-02f, -2.82914285e-02f, -6.70272857e-03f, 6.51605353e-02f, 1.24948174e-01f, 1.13861337e-01f, 6.78388625e-02f, 1.67141482e-02f, -8.51790607e-02f, 4.33569923e-02f,
  -5.92940375e-02f, -8.76734182e-02f, 3.68478857e-02f, -1.00880690e-01f, 4.75244485e-02f, 9.83285997e-03f, -5.86068667e-02f, -1.02441445e-01f, -4.77956086e-02f, 8.25007260e-02f,
  -3.88874002e-02f, -8.84012058e-02f, 7.55366609e-02f, -3.30681391e-02f, 5.17353676e-02f, -1.05582736e-01f, 4.25918177e-02f, -3.88539881e-02f, 1.18078301e-02f, 5.40796481e-02f,
  -7.19887763e-02f, 1.80431083e-02f, 5.34806475e-02f, 3.46470363e-02f, 2.92946734e-02f, 1.36970531e-03f, 5.94823211e-02f, -4.38666902e-02f, 4.08404283e-02f, 1.94452964e-02f,
  -5.50689772e-02f, 7.84254633e-03f, 3.72381806e-02f, 1.02932230e-01f, 1.01445056e-01f, 6.29692897e-02f, 1.82282105e-02f, -6.86692670e-02f, -3.05608492e-02f, 1.20450899e-01f,
  5.68777435e-02f, -5.01167635e-03f, -8.48782714e-03f, 6.28237650e-02f, 2.95440480e-02f, -5.76601997e-02f, 5.53883798e-02f, 4.83810045e-02f, 3.46996970e-02f, -6.05267845e-02f,
  1.47608924e-03f, -7.94742107e-02f, -4.00604717e-02f, -5.26773147e-02f, -4.49346285e-03f, -3.14537645e-03f, -9.81895253e-04f, -2.64817942e-02f, -4.46004421e-02f, -4.43786085e-02f,
  8.31129998e-02f, -8.19492489e-02f, -4.18297984e-02f, 3.09049822e-02f, -9.88115519e-02f, -6.93927631e-02f, 5.78883141e-02f, 5.86063154e-02f, 7.68056437e-02f, -3.45194824e-02f,
  -2.10484546e-02f, -4.55452800e-02f, -7.50436187e-02f, 8.99524465e-02f, 7.18273968e-02f, -5.30208163e-02f, 9.27345082e-02f, 6.21477216e-02f, 9.68262553e-02f, 8.72877017e-02f,
  2.71352790e-02f, 7.49764442e-02f, -4.06577066e-02f, -1.25318065e-01f, -5.03705852e-02f, -5.78233786e-02f, -9.69475582e-02f, -5.96303493e-02f, 1.20460121e-02f, 1.69675183e-02f,
  1.07929416e-01f, -4.89400364e-02f, 7.26030767e-02f, -7.01049343e-02f, 5.31072430e-02f, 1.17481098e-01f, 1.90613177e-02f, -1.01177044e-01f, -6.73703477e-02f, 1.25397980e-01f,
  9.88523811e-02f, -3.70813012e-02f, -4.81918314e-03f, 4.15846556e-02f, -5.03645204e-02f, -8.27266797e-02f, -1.06565943e-02f, 1.06878348e-01f, 8.31565559e-02f, 7.47541040e-02f,
  -2.25180626e-01f, -4.28921841e-02f, 8.57564155e-03f, 6.04610071e-02f, 1.87638551e-01f, 1.25973493e-01f, 1.61578506e-01f, 1.45294264e-01f, 1.41225949e-01f, 8.65006670e-02f,
  3.77453454e-02f, 1.36021227e-01f, 6.40858039e-02f, 9.24524479e-03f, 8.43167081e-02f, 1.07021824e-01f, 1.49764404e-01f, 8.47257748e-02f, 4.99312254e-03f, 9.83348638e-02f,
  1.00924097e-01f, -1.88174360e-02f, -7.01623186e-02f, -5.04484586e-02f, 4.48600985e-02f, 5.57891317e-02f, 8.62572268e-02f, 5.77712134e-02f, -2.75678802e-02f, 8.75554159e-02f,
  -5.34880050e-02f, -1.30853713e-01f, -2.09617615e-02f, 4.03695963e-02f, 1.73879357e-03f, 3.04036289e-02f, 3.85501646e-02f, -7.59519171e-04f, -5.25883287e-02f, 5.01211472e-02f,
  1.70104392e-02f, -4.98407222e-02f, 7.97830895e-02f, 5.00751287e-02f, -4.00613882e-02f, -8.80421773e-02f, 3.00167222e-02f, -4.98663448e-02f, -7.40006864e-02f, 1.96204018e-02f,
  3.56198996e-02f, 1.79352926e-03f, -5.43990247e-02f, -2.95589138e-02f, -5.64505234e-02f, -4.16598171e-02f, -3.63396257e-02f, -6.41478524e-02f, 3.52344587e-02f, -1.53504461e-02f,
  7.70726278e-02f, -2.57725455e-02f, -7.26760253e-02f, -7.40928249e-03f, 7.68230781e-02f, -3.30640748e-02f, 1.22647649e-02f, -2.54819337e-02f, 1.02011725e-01f, -7.46411607e-02f,
  3.40627022e-02f, 6.54096827e-02f, 2.09492072e-02f, -7.92252496e-02f, -1.06255906e-02f, -7.65301064e-02f, 3.05432379e-02f, -4.65574302e-02f, -1.43921450e-02f, -3.70402326e-04f,
  2.66892500e-02f, -6.30864650e-02f, 2.76345238e-02f, 3.05696223e-02f, 3.17257047e-02f, -1.41426614e-02f, 7.26986229e-02f, -5.23220599e-02f, -3.10187936e-02f, -4.78598103e-02f,
  3.79055887e-02f, 6.50794283e-02f, 1.07789569e-01f, -5.17457165e-03f, -7.40086585e-02f, -5.14147729e-02f, 4.31131310e-04f, -4.40395139e-02f, -4.30432186e-02f, 5.61238155e-02f,
  6.12264732e-03f, -3.44779193e-02f, 5.00799809e-03f, 3.82388495e-02f, -3.71782109e-02f, 1.70035437e-02f, -5.85257672e-02f, 1.07556470e-02f, -3.52991782e-02f, -4.01562415e-02f,
  4.69124652e-02f, -3.06519344e-02f, -2.11731754e-02f, 9.00975615e-02f, 6.09836094e-02f, 6.68419013e-03f, -8.67606848e-02f, -7.75081292e-02f, 9.07265674e-03f, -6.78618029e-02f,
  -1.40554667e-01f, -4.21873406e-02f, -2.31749658e-03f, -1.11939199e-01f, -7.69532546e-02f, -1.17872253e-01f, -2.66850274e-02f, -4.06993330e-02f, -7.86999688e-02f, 1.02166407e-01f,
  -1.33356225e-04f, -5.04396949e-03f, 5.80143780e-02f, 9.16357860e-02f, 3.68571058e-02f, 3.70870382e-02f, -3.95327583e-02f, 7.90769700e-03f, -4.26765047e-02f, 4.90530096e-02f,
  5.64927654e-03f, -6.02125190e-02f, -4.42136042e-02f, -4.24526334e-02f, 9.68385711e-02f, 1.71172414e-02f, -4.62492928e-02f, 8.77783597e-02f, 2.40617990e-02f, 1.21646561e-01f,
  2.65545905e-01f, -2.92645954e-03f, -4.81685158e-03f, 1.89451687e-02f, -1.39575070e-02f, 3.51884551e-02f, 7.17826933e-02f, -3.81157249e-02f, -1.11053690e-01f, -7.40562007e-02f,
  6.69324622e-02f, 4.28259112e-02f, -3.56770232e-02f, 7.45742247e-02f, -1.16433976e-02f, -3.70797515e-02f, -6.01763614e-02f, 6.11934103e-02f, -6.17014230e-05f, -8.93349051e-02f,
  -4.12150938e-03f, -2.54364442e-02f, -3.55171971e-02f, -9.95528698e-02f, 1.98218580e-02f, 7.84160495e-02f, 1.02487933e-02f, 2.30743550e-02f, -9.84429047e-02f, -1.05055116e-01f,
  4.13961634e-02f, -2.66782511e-02f, -4.74294573e-02f, -7.42035434e-02f, 3.55339088e-02f, 4.45042513e-02f, 7.50388429e-02f, -2.66284356e-03f, -5.97959347e-02f, 4.89126099e-03f,
  -2.12663691e-02f, 9.60300770e-03f, -7.59323034e-03f, 6.37959614e-02f, 6.57330528e-02f, 3.52666564e-02f, -3.91604640e-02f, -6.35716543e-02f, -7.21831396e-02f, -4.53731753e-02f,
  8.02029744e-02f, -7.04733506e-02f, -1.15277059e-02f, -2.21347343e-02f, -4.28475346e-03f, -6.65546954e-02f, 1.41366357e-02f, -8.32781643e-02f, 2.88425200e-02f, 1.54081527e-02f,
  1.89955637e-01f, -6.39033988e-02f, 1.16055608e-01f, 5.24633788e-02f, 3.36708426e-02f, -8.51257071e-02f, 5.00111058e-02f, -5.23958765e-02f, -8.86568055e-03f, 7.19071329e-02f,
  -8.33442658e-02f, 4.96689826e-02f, 9.28394347e-02f, -6.68202415e-02f, -1.07250428e-02f, -7.53171602e-03f, -7.24094734e-02f, 2.38211104e-03f, 4.87117618e-02f, -2.89548747e-02f,
  -1.21636586e-02f, 1.22072184e-02f, 1.39191553e-01f, 6.35243282e-02f, -1.58413069e-03f, -1.88355595e-02f, 5.03483079e-02f, 9.24103335e-02f, 2.34199129e-02f, 7.85325393e-02f,
  -1.54776946e-01f, -1.70726269e-01f, 1.18195182e-02f, -2.21890122e-01f, -9.19335485e-02f, -7.92413503e-02f, -2.62190942e-02f, -9.85757485e-02f, -1.42068535e-01f, -1.34762928e-01f,
  -6.81692809e-02f, 3.58932875e-02f, -2.37511396e-02f, -4.35614400e-03f, 6.53013662e-02f, -6.41075000e-02f, -2.99334656e-02f, 1.61385790e-01f, 1.60986841e-01f, 1.99845713e-03f,
  -8.30115229e-02f, -4.97975312e-02f, 5.44003546e-02f, 7.43043348e-02f, -4.72694375e-02f, -2.32523121e-03f, -1.12546943e-01f, -1.27863511e-01f, 7.12367073e-02f, -1.42379463e-01f,
  -1.18866026e-01f, -3.32496641e-03f, -2.24425811e-02f, -1.54359704e-02f, 7.66494349e-02f, -1.30520267e-02f, 4.63507287e-02f, -2.13858504e-02f, 5.73241673e-02f, -6.83429837e-02f,
  3.04337610e-02f, -5.58558926e-02f, 1.71002699e-03f, -9.69922543e-03f, 5.27742133e-02f, 4.23362106e-02f, 6.00741543e-02f, 1.28651336e-01f, 8.24493840e-02f, 4.85320650e-02f,
  5.91011271e-02f, 5.41323535e-02f, 2.47493316e-03f, 7.42606297e-02f, -4.82889125e-03f, 3.20885368e-02f, 9.88945216e-02f, 1.60690416e-02f, 1.06083162e-01f, -6.57372177e-02f,
  1.85706429e-02f, -3.16157714e-02f, 6.35122359e-02f, 3.30744274e-02f, -9.05647129e-02f, 7.39790825e-03f, -2.09723748e-02f, 6.70684427e-02f, -3.05899493e-02f, -6.12902269e-02f,
  -4.11402881e-02f, -6.11324422e-03f, 5.84929474e-02f, -5.64895496e-02f, -6.78271577e-02f, -4.53754850e-02f, -6.68376163e-02f, -6.16433807e-02f, -6.76020384e-02f, 6.08627908e-02f,
  1.88050885e-02f, 9.74675119e-02f, -1.76569000e-02f, 4.23790626e-02f, -2.01770104e-02f, 1.98547691e-02f, -7.14916885e-02f, 8.21761861e-02f, 3.30888629e-02f, -2.75424728e-03f,
  -3.95597108e-02f, 2.61130840e-01f, -1.97060462e-02f, 2.89742760e-02f, -1.03511550e-02f, 5.55464823e-04f, 2.20118258e-02f, 8.22089463e-02f, -4.42922674e-03f, -2.34522372e-02f,
  5.92050888e-02f, -6.34879544e-02f, -5.50524481e-02f, -1.14138396e-02f, 6.79820925e-02f, -9.73074639e-04f, 4.43620048e-02f, -5.64488433e-02f, -3.33617926e-02f, -7.66141638e-02f,
  -6.12135045e-02f, -8.86224136e-02f, -2.92310845e-02f, -4.47567664e-02f, -6.96857050e-02f, 5.60147278e-02f, 7.93681666e-02f, 7.00376481e-02f, 1.12712361e-01f, -1.75573751e-01f,
  -6.61658570e-02f, 5.25221340e-02f, 1.82471588e-01f, -1.08546704e-01f, 2.33484790e-01f, 1.70872539e-01f, 2.56727487e-01f, 1.25374317e-01f, -1.18222766e-01f, 2.50403900e-02f,
  -1.16777224e-02f, -2.15993524e-01f, -5.64418137e-02f, -1.56090498e-01f, 3.08050439e-02f, 2.16728579e-02f, 1.04483761e-01f, 6.91969916e-02f, 5.28756529e-02f, 1.25246588e-02f,
  -5.17075323e-02f, -1.24680452e-01f, -1.20492287e-01f, -5.23161590e-02f, -1.32143945e-01f, -8.86089206e-02f, -3.99688035e-02f, 7.02419952e-02f, -2.61285063e-02f, -4.56120968e-02f,
  -6.42422587e-04f, 7.21650124e-02f, 3.54993879e-03f, -1.07665688e-01f, -3.80456932e-02f, -7.36379698e-02f, 5.15703931e-02f, -1.01378419e-01f, 6.36226358e-03f, -6.69710040e-02f,
  -5.81426471e-02f, 3.94472070e-02f, -7.02789286e-03f, 5.92691042e-02f, 7.97431916e-02f, 6.65745959e-02f, -8.75774547e-02f, 2.80564241e-02f, 9.67328064e-03f, -6.39753342e-02f,
  -2.35768426e-02f, 1.05180191e-02f, 1.41477585e-01f, -9.20527801e-03f, 7.06169233e-02f, 4.79540415e-02f, 2.11616755e-02f, -4.30153757e-02f, 1.08020686e-01f, -6.27629384e-02f,
  -6.78387210e-02f, -5.60423657e-02f, -1.02105504e-02f, -1.78962592e-02f, 2.74718367e-02f, -4.12856154e-02f, -4.99827191e-02f, 3.49489562e-02f, -5.16513586e-02f, 6.03193184e-03f,
  1.10208904e-02f, 4.36380841e-02f, -1.79245751e-02f, -2.50610467e-02f, -6.46255165e-02f, 4.77189682e-02f, -4.33132350e-02f, 2.47812755e-02f, 8.76635164e-02f, -2.09682584e-02f,
  5.14539629e-02f, 2.29593348e-02f, 1.03165787e-02f, -4.48782220e-02f, 8.01631287e-02f, 2.63580848e-02f, 5.18406704e-02f, 1.33602065e-03f, 2.21981909e-02f, 2.10769046e-02f,
  -2.29979038e-01f, 1.80815279e-01f, -1.03161531e-02f, -1.37549996e-01f, 9.68856961e-02f, -5.71705662e-02f, -3.47918831e-02f, 2.28467230e-02f, 1.18964454e-02f, 1.45170866e-02f,
  -3.27250659e-02f, -2.75083119e-03f, 2.94584595e-02f, -4.61303890e-02f, -2.07106601e-02f, -1.53999934e-02f, -7.11931214e-02f, -5.06909844e-03f, 4.75624315e-02f, 8.69389027e-02f,
  -3.95572744e-02f, 8.51328745e-02f, 5.29593416e-02f, 4.01401930e-02f, -5.61788725e-03f, -1.94122028e-02f, -5.19102067e-02f, 3.91417183e-02f, 9.19664055e-02f, -7.17888251e-02f,
  -4.62290235e-02f, 2.56959628e-02f, 1.59687176e-01f, -8.37547556e-02f, -7.41133392e-02f, 5.87073155e-02f, 1.62738398e-01f, -8.50444287e-02f, -7.05799460e-02f, 4.81756330e-02f,
  7.30212852e-02f, -1.41759098e-01f, -9.47675481e-02f, -5.59301339e-02f, -4.73766252e-02f, 1.08798526e-01f, 1.30336240e-01f, 5.69657460e-02f, -9.16175023e-02f, -1.47402082e-02f,
  -5.65127470e-02f, -1.27865821e-01f, -8.09950680e-02f, -5.54626472e-02f, -6.82714060e-02f, -1.08037114e-01f, 2.02458240e-02f, -8.26660357e-03f, 1.12752140e-01f, -7.80256838e-02f,
  7.25673363e-02f, -4.21918072e-02f, -8.36146772e-02f, -7.20884651e-02f, -3.00227925e-02f, -3.80483898e-03f, 6.08704053e-02f, -4.16354015e-02f, 2.61777155e-02f, 4.53697443e-02f,
  -1.10646896e-02f, -7.77683184e-02f, -1.01243377e-01f, 4.03055400e-02f, 4.31921193e-03f, -3.05865183e-02f, 7.31703863e-02f, -5.05401567e-02f, 9.00243521e-02f, 1.14858136e-01f,
  -5.18471114e-02f, 9.21979472e-02f, -4.27025370e-03f, -3.19356867e-03f, 4.28779237e-02f, -7.01838406e-03f, 4.08414043e-02f, 6.04231283e-02f, 6.61429837e-02f, -5.09057231e-02f,
  -2.31065229e-02f, 6.59450963e-02f, -6.17863499e-02f, -5.49084023e-02f, -2.41109300e-02f, -5.38307168e-02f, -2.38298178e-02f, -3.41280401e-02f, 5.25170490e-02f, -8.85003433e-02f,
  -1.50272027e-02f, 9.83891785e-02f, -8.62193033e-02f, -8.05439577e-02f, -3.24263014e-02f, 6.93397969e-02f, 7.61386231e-02f, 9.09277126e-02f, -1.45016657e-02f, 4.52467091e-02f,
  -1.68965142e-02f, 7.99207389e-02f, -6.11685030e-02f, 5.84276905e-03f, 5.10654263e-02f, -6.60193264e-02f, -3.59557867e-02f, -2.96227224e-02f, -9.72580165e-02f, -2.88166273e-02f,
  -1.61938831e-01f, 2.54244450e-02f, -6.67619407e-02f, -1.28589600e-01f, -7.08057657e-02f, -5.46168126e-02f, 4.86866459e-02f, 1.00222556e-02f, 2.43148021e-02f, 7.29015023e-02f,
  2.28444617e-02f, 5.83320332e-04f, -2.35408079e-02f, -6.16388172e-02f, -3.08964644e-02f, 1.71205010e-02f, -2.16508973e-02f, -9.90533680e-02f, -9.31696407e-03f, 1.62053679e-03f,
  -6.15625717e-02f, -7.04618469e-02f, -1.44370031e-02f, -8.97028893e-02f, 2.11103335e-02f, -1.25318095e-01f, 4.75159362e-02f, -8.67063925e-02f, -6.60878886e-03f, 4.27094921e-02f,
  -4.47487980e-02f, 1.83680624e-01f, 2.53522359e-02f, 1.37904566e-02f, 1.96973197e-02f, 1.22904092e-01f, 7.51451403e-02f, 2.54617278e-02f, 6.21589497e-02f, 6.54252246e-02f,
  8.47022310e-02f, -2.97987554e-02f, -4.44890410e-02f, 5.94696589e-02f, 4.99997884e-02f, 1.27179027e-01f, 7.57506564e-02f, -8.05908740e-02f, -1.07503191e-01f, -6.03217483e-02f,
  4.22855727e-02f, -5.11310659e-02f, -4.74787503e-02f, 7.63099361e-03f, 1.68664195e-02f, -9.49235037e-02f, -6.33527292e-03f, -4.94098701e-02f, 1.80671122e-02f, -7.32112899e-02f,
  -8.46303701e-02f, -3.62769999e-02f, -1.46155268e-01f, -1.39611229e-01f, -5.74970879e-02f, 4.34319861e-02f, -4.63576950e-02f, 3.70933264e-02f, 2.22772639e-02f, 4.10525426e-02f,
  -7.02161640e-02f, -8.34631696e-02f, 3.07038892e-02f, 9.41331908e-02f, -6.72900602e-02f, -3.49186920e-02f, 7.26249442e-02f, -1.48919141e-02f, 9.27189216e-02f, 3.60350683e-02f,
  2.37852689e-02f, 1.70210134e-02f, 1.22820335e-02f, 5.23305833e-02f, 8.18418115e-02f, 3.80786099e-02f, 6.52674958e-02f, -8.57755467e-02f, 2.34079473e-02f, -6.43585920e-02f,
  2.77155973e-02f, -1.09649412e-01f, 1.56573392e-02f, -1.23972995e-02f, -6.33142814e-02f, 2.48862412e-02f, 4.43796143e-02f, -2.46956442e-02f, 3.55886854e-02f, -9.16761830e-02f,
  -1.10106468e-02f, -7.72956163e-02f, 3.26554216e-02f, 4.20922115e-02f, 5.78928217e-02f, -2.92182341e-02f, 6.31226823e-02f, -4.44302522e-02f, 8.39654282e-02f, 5.08760177e-02f,
  1.03247985e-02f, -6.10936657e-02f, 3.79452668e-02f, 6.12860024e-02f, -5.63508607e-02f, 1.92276202e-02f, -7.34956609e-03f, 5.84206246e-02f, -7.96877146e-02f, -8.51439545e-05f,
  -1.24412917e-01f, -7.47270286e-02f, 2.48903278e-02f, -1.02833599e-01f, 6.03235178e-02f, -5.23036979e-02f, 1.49222920e-02f, 6.24215268e-02f, -5.61750233e-02f, -2.01987159e-02f,
  -2.21040752e-02f, 1.95308682e-02f, 9.89741385e-02f, 7.49760792e-02f, -3.09630129e-02f, 3.68685499e-02f, 1.77952256e-02f, -7.00966120e-02f, 8.40079784e-02f, 7.26432502e-02f,
  6.74714521e-02f, 4.53291982e-02f, -1.40662789e-02f, -8.87466818e-02f, -2.58603506e-02f, -1.03439771e-01f, 4.00916412e-02f, -1.07988240e-02f, 2.76073851e-02f, -7.09898323e-02f,
  -1.06384702e-01f, -1.82176664e-01f, -1.67556524e-01f, -1.17965154e-01f, 3.11243590e-02f, -4.07017209e-02f, -3.94253954e-02f, -6.18418716e-02f, 2.16298811e-02f, -5.44890091e-02f,
  3.10275052e-02f, -4.74081710e-02f, -5.65818883e-02f, 9.60831642e-02f, 1.22985337e-02f, -9.02890861e-02f, -1.72004804e-01f, -5.62573113e-02f, -1.84500311e-02f, -2.01654155e-02f,
  -2.27498598e-02f, -5.27542308e-02f, -9.38467160e-02f, -6.39173314e-02f, -7.64424447e-03f, 4.06835377e-02f, -6.85341507e-02f, -2.45054848e-02f, -5.67142591e-02f, -1.54033974e-01f,
  -1.46912679e-01f, 1.36012599e-01f, 3.44614498e-02f, 4.64301668e-02f, 1.53519365e-03f, 9.07143876e-02f, -7.29862005e-02f, -4.12636138e-02f, -3.35165346e-03f, -6.05219379e-02f,
  7.60250241e-02f, 8.70558694e-02f, -4.66228127e-02f, -7.05137253e-02f, 8.15088749e-02f, 3.11421882e-02f, 4.85226214e-02f, -2.36965157e-02f, -2.71891654e-02f, -7.61246905e-02f,
  -9.44013819e-02f, -5.96996136e-02f, -7.20888004e-02f, -1.17489900e-02f, 9.32863727e-02f, 4.73664217e-02f, 9.23013836e-02f, 5.68410605e-02f, 9.46155712e-02f, -7.90363625e-02f,
  -1.03920050e-01f, -4.13638204e-02f, -8.28978717e-02f, -5.00769652e-02f, -7.39880204e-02f, -7.13825226e-02f, -7.92532787e-03f, 3.80717330e-02f, -2.20202282e-02f, 3.87397483e-02f,
  -7.69538954e-02f, 5.54924570e-02f, 3.15094180e-02f, -7.93117434e-02f, 5.14745042e-02f, -3.00174300e-02f, 3.85052823e-02f, 4.09123190e-02f, -2.44281311e-02f, -4.06694673e-02f,
  -2.95346417e-02f, 8.29562321e-02f, 4.67047431e-02f, -8.76065940e-02f, 4.71707843e-02f, 5.88698909e-02f, 1.95004381e-02f, 9.81971473e-02f, -2.73844358e-02f, -5.02587147e-02f,
  -1.06181931e-02f, -3.81740183e-02f, -9.39115584e-02f, 6.01934688e-03f, 2.90721878e-02f, 1.64982751e-02f, 3.27806100e-02f, -3.15440148e-02f, -2.65578721e-02f, 1.70484688e-02f,
  2.55809631e-04f, -2.51227506e-02f, -1.70010030e-02f, 9.84581783e-02f, 3.85335833e-02f, 4.74865474e-02f, -7.64369816e-02f, 8.22625607e-02f, -7.13350773e-02f, -9.60499793e-02f,
  -1.19695596e-01f, -6.87885005e-03f, -6.42290488e-02f, 3.49475928e-02f, 2.86706258e-03f, 2.91305874e-02f, -3.91784459e-02f, 1.03684673e-02f, -4.87516122e-03f, -1.19314015e-01f,
  7.72537515e-02f, -6.52319640e-02f, 3.60838547e-02f, -1.60482656e-02f, 5.56650497e-02f, -1.15600422e-01f, -1.23185888e-01f, -1.16348028e-01f, -7.36046582e-02f, 1.06104419e-01f,
  1.26152039e-01f, 1.71216384e-01f, 1.80043519e-01f, 3.53886150e-02f, -4.10925224e-02f, -7.45386034e-02f, -4.66299690e-02f, 1.34927838e-03f, 1.36861771e-01f, 2.34374148e-03f,
  7.91710466e-02f, 1.24790303e-01f, 9.55949426e-02f, 3.22998501e-02f, 7.63545930e-02f, 4.78414819e-02f, -5.06794732e-03f, 1.30838277e-02f, 1.44623175e-01f, 1.06114127e-01f,
  2.12213144e-01f, -9.82128978e-02f, 7.01991990e-02f, 1.07156895e-01f, 1.23461641e-01f, 5.10265641e-02f, -1.58347320e-02f, -2.69725416e-02f, -1.78595167e-03f, 2.64913365e-02f,
  -4.72621340e-03f, -2.78940685e-02f, -2.24160440e-02f, 8.83213535e-04f, -3.35333571e-02f, 4.93750349e-02f, 4.64342302e-03f, -2.90888380e-02f, -1.21888623e-01f, 1.01005480e-01f,
  7.86382928e-02f, 7.32341036e-02f, -2.59230565e-03f, -2.36798972e-02f, -5.93451038e-02f, -3.63570750e-02f, 2.56161299e-02f, -4.05774675e-02f, -2.43044384e-02f, -5.76587692e-02f,
  5.37364930e-03f, 1.92974526e-02f, 1.80312600e-02f, 6.07176386e-02f, 7.13328719e-02f, 7.21857622e-02f, -7.80941248e-02f, 9.02418643e-02f, -4.90405485e-02f, -3.02699991e-02f,
  -5.73080108e-02f, 7.07571954e-02f, 3.84575687e-02f, 1.40672801e-02f, 1.19477160e-01f, 2.39924900e-02f, 2.95857675e-02f, 8.14458821e-03f, -6.09029792e-02f, 5.42886667e-02f,
  5.90079948e-02f, -1.78266410e-02f, -2.60565802e-02f, 2.95663942e-02f, -8.26304406e-03f, -1.57644711e-02f, 8.06006119e-02f, 6.19733147e-02f, 1.01684462e-02f, -1.48847783e-02f,
  8.36242214e-02f, -5.01820184e-02f, 1.05700478e-01f, -7.52604306e-02f, 3.35519463e-02f, -2.63805911e-02f, 1.60078667e-02f, 5.49869500e-02f, 9.82400589e-03f, -5.14525250e-02f,
  6.36423007e-02f, -1.77280419e-02f, 3.82418409e-02f, -5.77076226e-02f, -1.05360411e-02f, -5.43893650e-02f, 1.10632248e-01f, -4.30343635e-02f, -7.59629756e-02f, -1.60273351e-02f,
  -7.98679665e-02f, -1.67800561e-02f, -8.20261016e-02f, -8.94600302e-02f, -3.09642516e-02f, 8.28228332e-03f, 5.00725135e-02f, -1.66671840e-03f, -6.16159402e-02f, -2.31523179e-02f,
  3.59601788e-02f, 1.50708538e-02f, 1.27010733e-01f, 4.33321223e-02f, -5.97593486e-02f, -5.05551277e-03f, -9.97358374e-03f, 5.74944029e-03f, 2.25038398e-02f, 4.54808213e-02f,
  6.89391121e-02f, 5.26799709e-02f, -1.71017237e-02f, -1.54751418e-02f, -5.37858605e-02f, 2.97714621e-02f, -2.02312190e-02f, -5.11894524e-02f, -7.47638941e-02f, 1.40431407e-03f,
  -4.10368368e-02f, 7.41173103e-02f, -5.80180585e-02f, 1.87616702e-02f, -2.75788289e-02f, -9.35226530e-02f, -6.63955603e-03f, 6.00864366e-02f, -2.11318722e-03f, -4.68190573e-02f,
  -9.36542898e-02f, 4.28414457e-02f, -8.87158364e-02f, -6.24493174e-02f, 8.11807290e-02f, 7.94218108e-02f, 7.06436858e-02f, 9.51638371e-02f, 6.49733376e-03f, 8.69501233e-02f,
  5.08103892e-02f, -4.44328077e-02f, 1.03072040e-01f, 8.82902890e-02f, 9.41919256e-03f, 3.48984413e-02f, 1.32477641e-01f, -3.44567862e-03f, 6.76335171e-02f, 1.04890108e-01f,
  1.92565098e-02f, -3.89723778e-02f, 1.21737853e-01f, 7.44803026e-02f, 8.73707533e-02f, 4.65934239e-02f, 8.07652771e-02f, 9.56376866e-02f, 2.91698091e-02f, -4.78652120e-02f,
  -8.21524784e-02f, 5.99604771e-02f, 3.81690972e-02f, -2.19284911e-02f, 1.00547709e-02f, 1.52349845e-02f, 6.18101731e-02f, -4.54775877e-02f, 4.70621027e-02f, 3.53008620e-02f,
  -5.79601899e-02f, -7.14590997e-02f, 7.78231472e-02f, 4.80132550e-02f, -2.58752927e-02f, -4.20353599e-02f, -4.75592576e-02f, -4.80707884e-02f, 6.18725754e-02f, 7.93431401e-02f,
  4.94845323e-02f, -3.65247168e-02f, 4.66213711e-02f, 3.26877758e-02f, -2.93314806e-03f, 7.82875940e-02f, -7.82091264e-03f, -5.99004291e-02f, 8.01064968e-02f, 4.79055494e-02f,
  -9.20655765e-03f, 5.18223867e-02f, -9.75103006e-02f, -4.20440510e-02f, 9.79517028e-03f, 6.57384619e-02f, -1.02100566e-01f, 8.30480922e-03f, 1.07275084e-01f, -5.99050969e-02f,
  -1.25261284e-02f, 2.57709231e-02f, 8.40253234e-02f, -4.63063829e-02f, 4.93564866e-02f, 8.90699252e-02f, -5.06743863e-02f, -6.79768994e-02f, 9.39326882e-02f, 5.57055138e-02f,
  -8.09380189e-02f, -5.40742837e-02f, 2.92012841e-02f, -2.42070314e-02f, -7.44654387e-02f, -5.17296139e-03f, -1.04501456e-01f, 3.31392251e-02f, -2.53584981e-02f, -1.28118962e-01f,
  1.45554051e-01f, 5.61407432e-02f, 7.95225427e-03f, 3.60717624e-02f, -4.63779233e-02f, -1.00246832e-01f, -9.78266299e-02f, -1.49859130e-01f, -6.28785044e-02f, 7.60232136e-02f,
  6.52479082e-02f, 1.55519499e-02f, 1.01290733e-01f, -6.79657981e-02f, 4.93494198e-02f, -8.43332559e-02f, -2.47345604e-02f, 9.98214111e-02f, -3.12076323e-02f, 1.01073578e-01f,
  4.64281393e-03f, 1.01062991e-02f, 2.84687672e-02f, -3.26806456e-02f, 1.34395398e-02f, 6.09826408e-02f, 5.55780418e-02f, 1.43588230e-01f, 3.90972532e-02f, 1.73082903e-01f,
  3.08255795e-02f, -4.75861542e-02f, 5.16987666e-02f, 7.43691549e-02f, 1.53275421e-02f, 5.25459787e-03f, 8.84868056e-02f, 7.94526041e-02f, -1.63455643e-02f, -8.53460059e-02f,
  7.47190043e-02f, -2.77078897e-02f, 2.61209020e-03f, -4.36987281e-02f, -8.49985629e-02f, -4.68915552e-02f, -2.56408174e-02f, 2.41918620e-02f, 1.25009017e-02f, -4.48106490e-02f,
  -2.50869766e-02f, 8.21685642e-02f, -5.67095242e-02f, -2.40058806e-02f, -4.37963493e-02f, -4.83778305e-02f, 4.05622385e-02f, 6.37560943e-03f, -6.92367777e-02f, 2.74304748e-02f,
  -7.54352584e-02f, 5.75510710e-02f, -1.94763876e-02f, 4.27753441e-02f, 5.87986894e-02f, 4.98928502e-02f, 3.82821858e-02f, 8.34602565e-02f, -7.66617432e-02f, 5.08252196e-02f,
  -8.04680213e-02f, -6.09834976e-02f, -2.43116673e-02f, -8.26763809e-02f, 1.95983350e-02f, 1.97908841e-02f, -9.23138112e-03f, -8.59177485e-02f, 8.30768980e-03f, 5.58698922e-02f,
  -4.98796739e-02f, -7.64048770e-02f, -1.70140080e-02f, -1.61622465e-02f, -5.69173172e-02f, 6.03941828e-02f, 2.37526149e-02f, -6.88149109e-02f, -4.05075364e-02f, 8.07875767e-02f,
  -7.20863342e-02f, -8.03638250e-02f, 1.05178216e-02f, 2.50576288e-02f, 1.10441288e-02f, 2.83787362e-02f, 1.62735209e-02f, -3.79208885e-02f, 3.33930701e-02f, -9.34149101e-02f,
  -1.25368265e-02f, 5.81311481e-03f, 4.65646051e-02f, -2.70669144e-02f, 5.04797995e-02f, 5.77943809e-02f, -3.40751983e-04f, -8.48655254e-02f, -4.63936664e-03f, -7.89501797e-03f,
  3.29994410e-02f, -3.32546309e-02f, -9.55234990e-02f, -1.20825969e-01f, -6.69161901e-02f, -9.90124606e-03f, 3.95226851e-03f, 6.51567802e-02f, -6.27412125e-02f, -1.29520416e-01f,
  -3.94742072e-01f, -1.66330952e-02f, -2.50099450e-01f, -5.51666133e-02f, 1.74398407e-01f, 1.49172619e-01f, -3.87255512e-02f, -7.10747167e-02f, -9.32280496e-02f, 8.07177089e-03f,
  1.47758961e-01f, 1.56932324e-01f, -4.98614460e-02f, 5.50335497e-02f, 6.61222339e-02f, -3.79347354e-02f, -2.68100426e-02f, -2.63505103e-03f, -2.96773184e-02f, 1.43400207e-01f,
  1.86091885e-01f, 1.21469982e-01f, 8.73946398e-03f, -6.93663582e-02f, -1.74718890e-02f, 1.12553937e-02f, -1.88448571e-03f, 3.20645496e-02f, 1.24868654e-01f, 6.05562404e-02f,
  -1.93150520e-01f, -2.69227087e-01f, 4.33170656e-03f, -5.54655585e-03f, 7.82243013e-02f, -1.67166620e-01f, -2.06170400e-04f, -1.43571973e-01f, -6.61994219e-02f, -7.29268566e-02f,
  8.59070048e-02f, 2.57666665e-03f, -2.34817453e-02f, -2.64657475e-02f, -1.57121255e-03f, -7.21949637e-02f, -1.24593355e-01f, -1.18728705e-01f, -9.33926478e-02f, -1.19731076e-01f,
  1.79265752e-01f, 1.04429573e-01f, -1.71984389e-01f, -4.51241136e-02f, -1.69613555e-01f, -1.71899684e-02f, -9.29757729e-02f, -1.84352323e-01f, -1.40340075e-01f, -2.51810133e-01f,
  2.92808171e-02f, 5.75370304e-02f, -5.20094819e-02f, 2.48339656e-03f, 2.84113958e-02f, 5.65310866e-02f, -1.66346098e-03f, 4.70423922e-02f, 2.43509579e-02f, 4.26349081e-02f,
  4.01569419e-02f, -8.29586089e-02f, -7.51277357e-02f, -3.13946567e-02f, 7.06763417e-02f, -6.88830465e-02f, 8.43852684e-02f, 3.67032066e-02f, 1.19580636e-02f, -7.19377697e-02f,
  -1.74174532e-02f, -6.88020065e-02f, -5.60958050e-02f, 5.07187434e-02f, 3.34800966e-03f, -1.19842619e-01f, 9.58828628e-03f, 8.26297142e-03f, 3.27267647e-02f, -4.84192669e-02f,
  -7.96177387e-02f, 1.29379973e-01f, -1.49825141e-01f, -4.01885947e-03f, 1.61874034e-02f, -4.14618552e-02f, 9.43906605e-03f, -2.45211106e-02f, 7.39990827e-03f, -1.05739690e-01f,
  -4.49124761e-02f, 2.79598776e-02f, -9.46362168e-02f, 3.04134525e-02f, -8.53625592e-03f, -8.94339606e-02f, -4.28110473e-02f, -2.79510729e-02f, -1.00869939e-01f, -1.14312395e-01f,
  5.44803366e-02f, -3.10936440e-02f, -1.92944407e-01f, -5.46455793e-02f, -8.41780305e-02f, -8.36222153e-03f, -1.56542569e-01f, -7.44213313e-02f, -9.56991091e-02f, -1.90469891e-01f,
  -6.13063909e-02f, -1.42284796e-01f, 8.85729026e-03f, -2.39557639e-01f, -8.37392062e-02f, -4.48824316e-02f, -1.35368600e-01f, 1.05609735e-02f, -1.58199504e-01f, -1.80882633e-01f,
  -6.11808449e-02f, 1.91802755e-02f, 5.10943979e-02f, -3.22028585e-02f, 4.64914329e-02f, 8.35252739e-03f, 1.74040236e-02f, 3.18362042e-02f, 1.90827355e-01f, 9.25342292e-02f,
  -6.74781203e-02f, -1.41283691e-01f, -2.80801542e-02f, -8.74509662e-02f, -8.26679617e-02f, 1.24907894e-02f, -2.55689472e-02f, -1.36366904e-01f, -6.48080632e-02f, -4.46535721e-02f,
  -1.34673774e-01f, 3.31799425e-02f, 1.23964615e-01f, 5.45522906e-02f, -3.56610529e-02f, -7.77840763e-02f, 1.94265340e-02f, 7.62105687e-03f, 7.34183714e-02f, -1.02869354e-01f,
  2.24379785e-02f, -4.50883210e-02f, -3.21400315e-02f, -2.15815622e-02f, -5.95500991e-02f, -1.01923039e-02f, 4.01456654e-02f, 7.54915774e-02f, -1.06454419e-03f, 5.84714115e-02f,
  -7.44814873e-02f, -5.82400709e-02f, -2.82996651e-02f, 7.40756169e-02f, 9.38072130e-02f, -3.72382402e-02f, -9.38518494e-02f, -9.13799033e-02f, -3.19676995e-02f, -1.99994832e-01f,
  5.18426262e-02f, -1.83611810e-02f, 3.05033522e-03f, -5.70242591e-02f, -6.79533258e-02f, 8.28693584e-02f, -4.18065721e-03f, 1.35901505e-02f, 4.26727757e-02f, -5.63135445e-02f,
  1.04100347e-01f, 5.96936159e-02f, 5.93263172e-02f, -1.22203743e-02f, -8.14680103e-03f, -7.19073601e-03f, -1.92574449e-02f, 1.89008303e-02f, 1.04504619e-02f, -3.83502319e-02f,
  3.55322994e-02f, 5.82788959e-02f, -7.83958212e-02f, 3.50157358e-02f, -9.18548182e-03f, -5.37088290e-02f, 7.44166076e-02f, -5.12474962e-02f, 4.71473224e-02f, 9.29770619e-03f,
  -1.66553512e-01f, 2.37859786e-01f, -1.40397146e-01f, 3.58472466e-02f, 1.63826272e-02f, 3.30857150e-02f, -1.02112688e-01f, 2.35046670e-02f, -7.90623799e-02f, 3.40244472e-02f,
  1.78363826e-02f, 5.52007109e-02f, -8.84741619e-02f, 3.68631035e-02f, 5.33315055e-02f, 5.32695018e-02f, -6.21703826e-02f, 3.54110152e-02f, 3.50612663e-02f, -2.17051823e-02f,
  1.67072825e-02f, -2.62318533e-02f, -2.31473660e-03f, 2.10077148e-02f, -6.15990795e-02f, 4.54983227e-02f, -3.07006221e-02f, -7.68635049e-02f, -3.37101109e-02f, -2.22056016e-01f,
  1.34954065e-01f, 1.81433365e-01f, -5.66084273e-02f, 1.20745905e-01f, 1.25275627e-01f, 9.21754017e-02f, 1.36769071e-01f, 9.59113315e-02f, 7.59242177e-02f, 4.79641892e-02f,
  1.35512382e-01f, 1.58602238e-01f, 1.55374944e-01f, 4.52915132e-02f, 1.56297092e-03f, 1.14495739e-01f, 4.14342899e-03f, 5.77427372e-02f, 5.40859159e-03f, 9.88559052e-02f,
  6.92159012e-02f, 3.97117697e-02f, 3.82173024e-02f, 7.32727423e-02f, -3.57526615e-02f, -2.41795108e-02f, 5.66990450e-02f, 1.04882874e-01f, -3.09096407e-02f, 4.93518077e-04f,
  -4.17293198e-02f, 1.43369317e-01f, -5.53557836e-02f, 2.45549809e-02f, 4.83714081e-02f, 5.13035990e-02f, -2.92998739e-02f, 3.92052978e-02f, 5.15983962e-02f, -6.88227639e-02f,
  -1.10748217e-01f, -6.47778511e-02f, 7.99696147e-02f, -4.00153622e-02f, 2.14841105e-02f, -3.77381258e-02f, 6.38895035e-02f, 4.02243547e-02f, 3.33313718e-02f, -3.46498452e-02f,
  -3.01337987e-02f, -3.86784319e-03f, -1.54694319e-02f, 1.60495937e-02f, 8.91568735e-02f, -9.98175442e-02f, 5.16776480e-02f, -7.74349319e-03f, 7.53357410e-02f, -3.46239842e-02f,
  -7.37945586e-02f, -5.60785681e-02f, 6.30231053e-02f, -3.26511636e-02f, 9.38470513e-02f, -1.47225838e-02f, 4.92725410e-02f, 1.23639163e-02f, -3.90810557e-02f, 1.91195086e-02f,
  1.33843860e-02f, -6.15700856e-02f, 5.91491386e-02f, -4.45575267e-02f, -6.89765960e-02f, 1.28189567e-02f, 3.11377421e-02f, 6.46992624e-02f, -7.46995807e-02f, -7.54272565e-02f,
  -6.68452168e-03f, 2.62885466e-02f, -5.31167649e-02f, 2.10255217e-02f, -6.72112331e-02f, -8.63188543e-05f, -3.11577469e-02f, 7.34973103e-02f, 7.55893588e-02f, 1.26161065e-03f,
  5.14267804e-03f, -3.38850431e-02f, -1.92204192e-02f, 4.38618436e-02f, -1.10690288e-01f, -1.00667052e-01f, 3.08336392e-02f, -5.80268949e-02f, -7.70946592e-02f, -1.11191552e-02f,
  5.75912148e-02f, 1.10981986e-02f, -1.17428992e-02f, 5.89906089e-02f, -4.15490419e-02f, 6.60393536e-02f, -1.22457631e-02f, -1.97884534e-02f, -1.71435494e-02f, -6.93658320e-03f,
  -2.87835915e-02f, -4.21311595e-02f, -9.55874324e-02f, 6.42591482e-03f, 3.95296626e-02f, 2.53509488e-02f, -4.65803333e-02f, -4.85396311e-02f, -4.08787802e-02f, 7.23113492e-02f,
  -2.02284992e-01f, 3.15354168e-02f, -4.52984497e-02f, -1.25339091e-01f, -9.45429876e-02f, -6.28483519e-02f, 8.13661069e-02f, 4.71433960e-02f, -3.68694887e-02f, -4.86545870e-03f,
  6.76115751e-02f, -2.62043625e-02f, -4.98121344e-02f, 1.25402045e-02f, 4.82067131e-02f, 8.60434994e-02f, -1.80653147e-02f, -1.19172167e-02f, -4.38838527e-02f, -7.85253122e-02f,
  -3.73196043e-02f, -2.18124362e-03f, -6.09067678e-02f, -9.68392044e-02f, -7.47861639e-02f, 3.86436470e-02f, -7.73269460e-02f, 5.06718829e-02f, 2.14839336e-02f, 5.04323617e-02f,
  -9.80421230e-02f, -1.03041185e-02f, 1.18764518e-02f, 9.20742229e-02f, 2.53661710e-04f, 5.32308668e-02f, 3.95859294e-02f, -3.97659615e-02f, -1.87675245e-02f, -2.38707568e-02f,
  -8.25116634e-02f, 6.78199455e-02f, -1.68255810e-02f, 1.33788139e-02f, -1.14332274e-01f, -5.61470538e-03f, 7.06323460e-02f, 6.87950402e-02f, -4.78048362e-02f, 8.19591731e-02f,
  8.69338512e-02f, 5.93445078e-02f, 1.00736886e-01f, 4.08437438e-02f, 6.32168427e-02f, 2.94863228e-02f, 5.22625893e-02f, -2.55508479e-02f, -6.56188652e-02f, 5.05121090e-02f,
  -1.78981777e-02f, -2.29499079e-02f, 4.37801518e-02f, -7.76760429e-02f, -8.63221064e-02f, -2.57046316e-02f, 6.57294765e-02f, -7.58369192e-02f, -7.96366930e-02f, 1.83478147e-02f,
  4.66101915e-02f, 5.74561320e-02f, 4.09397669e-02f, 1.73531342e-02f, 6.09620921e-02f, 7.52011687e-02f, -3.41701359e-02f, -6.48031086e-02f, -6.77571865e-03f, 4.32543084e-02f,
  -5.39528094e-02f, -5.70226014e-02f, -5.42740747e-02f, -7.98685178e-02f, 8.81705657e-02f, 2.27646753e-02f, -7.14769438e-02f, 2.32935995e-02f, 2.24379618e-02f, 7.06952661e-02f,
  -4.11579125e-02f, -3.84019897e-03f, 1.02540754e-01f, 4.83999178e-02f, -2.84265559e-02f, -1.86655391e-02f, -3.52861546e-02f, 2.23585591e-02f, 3.52662578e-02f, -8.27164426e-02f,
  5.38732782e-02f, -5.14519922e-02f, -3.98531072e-02f, 2.94096097e-02f, -6.83854744e-02f, 7.66701857e-03f, -2.93280259e-02f, 4.88603078e-02f, -2.89723333e-02f, 7.97380283e-02f,
  8.69529415e-03f, -2.78172661e-02f, 6.31272867e-02f, 7.24812746e-02f, 3.12109720e-02f, 7.13048130e-02f, -2.91182231e-02f, -9.52246785e-03f, 4.92748544e-02f, -2.45999880e-02f,
  2.38465026e-01f, 1.00281775e-01f, 8.28282461e-02f, 9.56958011e-02f, -1.44275188e-01f, -1.00113250e-01f, 5.99565953e-02f, 7.17625245e-02f, -7.75196701e-02f, -4.51318398e-02f,
  -7.25582428e-03f, 1.25656696e-02f, -1.05825484e-01f, -3.96807715e-02f, -5.11818100e-03f, 5.11706769e-02f, 7.29479734e-03f, -6.02677315e-02f, 5.98164136e-03f, 7.82013685e-03f,
  5.61263002e-02f, 1.75319903e-03f, 1.37811735e-01f, 5.05411737e-02f, 7.84335509e-02f, -4.70792614e-02f, 1.10064842e-01f, 9.67518240e-02f, 1.67964883e-02f, 8.80461410e-02f,
  2.52647046e-03f, 1.84183538e-01f, -1.74103916e-01f, 4.68689278e-02f, -5.77964969e-02f, 7.58550316e-03f, 2.43060924e-02f, -5.63391708e-02f, 6.09360822e-02f, -7.73017928e-02f,
  7.48755177e-03f, 7.14824647e-02f, -1.17304549e-01f, 6.44363537e-02f, 4.39337380e-02f, -5.91990352e-02f, 2.00728886e-02f, -2.29765903e-02f, -3.76828462e-02f, -4.32706214e-02f,
  2.82452498e-02f, -3.20270322e-02f, 1.87381692e-02f, 2.82713156e-02f, 4.89252666e-03f, -1.97139774e-02f, 6.56319559e-02f, 5.44430259e-05f, 7.43465573e-02f, 6.43650368e-02f,
  1.11948242e-02f, 5.84239587e-02f, -5.69700301e-02f, -3.65593447e-03f, -9.23850983e-02f, -8.41463879e-02f, 1.22716622e-02f, 2.80921883e-03f, -1.02576271e-01f, -6.67955801e-02f,
  -6.94551244e-02f, -9.41549242e-02f, 3.03339958e-03f, -8.63083228e-02f, 1.29314726e-02f, -3.16215605e-02f, -1.11990795e-01f, 4.19606678e-02f, -5.22307865e-02f, 4.73688282e-02f,
  -6.45389706e-02f, 4.81959507e-02f, 5.47759645e-02f, -1.04705046e-04f, 6.66426867e-02f, -1.04527429e-01f, -5.52377328e-02f, 3.04058678e-02f, -1.57134328e-02f, 7.53309280e-02f,
  1.40144648e-02f, -1.30673543e-01f, 3.03700455e-02f, 6.59912676e-02f, 4.70056459e-02f, -4.19863686e-02f, 1.47888549e-02f, 5.56769706e-02f, 5.46571538e-02f, -5.22359721e-02f,
  -7.80268223e-04f, 2.36765891e-02f, 5.64264022e-02f, -7.01339617e-02f, -9.18712690e-02f, -6.03500977e-02f, 6.24985527e-03f, 2.87690628e-02f, -6.22389354e-02f, 1.95063930e-02f,
  -4.01632488e-02f, 3.94316576e-02f, -4.81169336e-02f, -9.85432044e-02f, -9.35475901e-02f, -8.05258378e-02f, -6.60603344e-02f, -7.07147568e-02f, -8.99904445e-02f, 1.24370351e-01f,
  -1.81981832e-01f, -1.43390708e-03f, 1.17704861e-01f, -5.94585261e-04f, 2.85980180e-02f, 3.42054106e-02f, 1.76469609e-01f, -2.23672148e-02f, 6.82912245e-02f, -6.45340979e-02f,
  -3.16283666e-02f, -2.52306573e-02f, -1.42750889e-01f, -6.00791164e-02f, -5.33927307e-02f, 9.07000005e-02f, -5.33924811e-03f, -4.40189242e-02f, 4.55180788e-03f, -3.52164023e-02f,
  -5.51578440e-02f, 6.98193759e-02f, 2.81592589e-02f, -4.85114232e-02f, 6.61383122e-02f, 6.48653358e-02f, -7.81687126e-02f, 1.05001004e-02f, 6.19237721e-02f, -1.06186680e-02f,
  2.16232210e-01f, -9.72975325e-03f, -7.65474653e-03f, -1.62179410e-01f, 2.83306353e-02f, -1.07014209e-01f, -2.63030734e-02f, 1.49482712e-02f, -1.10078558e-01f, -3.60248312e-02f,
  -7.01267719e-02f, -8.75640754e-03f, -3.54820043e-02f, -3.71761955e-02f, 8.22707787e-02f, 7.31654540e-02f, -1.15481727e-01f, 4.34767343e-02f, -2.50594430e-02f, -5.45438752e-02f,
  -1.14127025e-01f, 7.00700283e-03f, 1.59390774e-02f, 6.20784611e-02f, 5.53017743e-02f, -9.90865976e-02f, -2.20451877e-02f, -2.51841415e-02f, 9.33119096e-03f, 5.33380918e-02f,
  -1.38058458e-02f, 5.87142929e-02f, 2.45082676e-02f, 1.53592322e-02f, 4.20217812e-02f, 3.87098007e-02f, -6.18250072e-02f, 8.06501508e-03f, -8.14259890e-03f, 1.17208213e-02f,
  2.12166365e-02f, 2.54633545e-04f, 3.89852300e-02f, -8.78300704e-03f, 1.68652553e-02f, 9.78753157e-03f, -1.39966663e-02f, -3.43555249e-02f, -7.18344450e-02f, 7.20239505e-02f,
  4.41165604e-02f, 3.80973853e-02f, 2.98567172e-02f, 9.84752327e-02f, -1.15876332e-01f, 4.48488668e-02f, 2.96064857e-02f, -7.97503889e-02f, -5.45670427e-02f, 1.67793687e-02f,
  5.14371991e-02f, 3.40408050e-02f, 8.87313485e-02f, 1.84725723e-04f, -2.12498251e-02f, -6.96900859e-02f, -8.34485590e-02f, 5.59097677e-02f, 1.86113473e-02f, 1.25982225e-01f,
  5.29651083e-02f, 1.00654201e-04f, 2.03080308e-02f, -3.36038135e-02f, 9.21863019e-02f, 9.21276659e-02f, 1.73424333e-02f, -2.98633110e-02f, -6.14758302e-03f, 1.22038815e-02f,
  -9.84559283e-02f, 9.23050269e-02f, 1.45703420e-01f, 1.01014614e-01f, 5.96915819e-02f, -2.69291326e-02f, 1.47873417e-01f, 9.89923701e-02f, -7.87930936e-03f, 1.23038530e-01f,
  -4.69645187e-02f, 1.48386791e-01f, -1.80498660e-02f, 5.95778525e-02f, 7.01612141e-03f, 1.09967329e-01f, 1.36929944e-01f, 1.79895669e-01f, 2.70965062e-02f, 8.03917367e-03f,
  -1.41378744e-02f, 7.86555111e-02f, 7.17632025e-02f, 8.18680599e-02f, 1.44218534e-01f, 1.68027341e-01f, 1.14196241e-01f, 1.11519448e-01f, 2.95752622e-02f, -2.73060780e-02f,
  6.98557049e-02f, 7.97178894e-02f, 9.81631801e-02f, 5.38413087e-03f, 5.76580353e-02f, 1.12366512e-01f, 1.17564999e-01f, 7.97945783e-02f, -1.92000326e-02f, 1.61726743e-01f,
  -1.26213193e-01f, -1.06505074e-01f, -5.17304018e-02f, -3.16246487e-02f, -3.83120850e-02f, -5.24370410e-02f, 4.21753749e-02f, -5.36478795e-02f, 3.53020169e-02f, 3.30364937e-03f,
  -8.66363421e-02f, -5.75424992e-02f, -7.41163939e-02f, 3.01746987e-02f, -8.83307084e-02f, -3.98302674e-02f, -6.75732419e-02f, 1.21990606e-01f, -1.04933903e-02f, 6.34988863e-03f,
  3.90086994e-02f, -1.56815663e-01f, -1.40701070e-01f, 7.60548860e-02f, 3.63384597e-02f, -1.02475643e-01f, -2.24171113e-02f, -2.00568438e-02f, -1.50547910e-03f, -4.19025607e-02f,
  -5.72959185e-02f, -8.17296356e-02f, 4.16988991e-02f, 7.21778050e-02f, 2.83343587e-02f, -5.17773405e-02f, 7.94934034e-02f, -5.68841361e-02f, 6.35309890e-02f, -2.01949626e-02f,
  -3.76509540e-02f, 2.37912163e-02f, -1.12091340e-02f, 3.28894816e-02f, -5.14686629e-02f, -1.68531071e-02f, 5.85839599e-02f, 7.13150576e-02f, -3.92221734e-02f, -7.17649469e-03f,
  3.45105218e-04f, -7.34811351e-02f, -4.68860939e-02f, -1.66112613e-02f, 7.75837526e-02f, -1.80947464e-02f, 4.22620401e-02f, -6.28183782e-02f, 1.38346907e-02f, 5.12349382e-02f,
  6.51024729e-02f, -1.64420938e-03f, -3.85609604e-02f, 5.75223640e-02f, -8.41724873e-02f, 5.07999957e-02f, -8.67777988e-02f, 5.45875821e-03f, -6.41353130e-02f, 3.02241221e-02f,
  -1.46975489e-02f, -5.41467629e-02f, 4.83008958e-02f, 5.29724918e-02f, -3.69426720e-02f, 1.70461778e-02f, 2.98807025e-02f, -3.99554754e-03f, 6.14243634e-02f, -3.98458354e-02f,
  -5.99763803e-02f, -9.49482992e-02f, -1.35284573e-01f, 5.95946647e-02f, -8.25665295e-02f, -6.33615777e-02f, -7.11490363e-02f, -2.75523998e-02f, -6.51312545e-02f, -2.18637120e-02f,
  -1.93204343e-01f, -2.37697154e-01f, -1.87366456e-01f, 1.53868675e-01f, 1.54680535e-01f, -6.86738193e-02f, -1.48447916e-01f, 9.51945111e-02f, 2.93318965e-02f, -1.63247272e-01f,
  2.86146980e-02f, 6.41503930e-02f, -4.77296598e-02f, 4.37965132e-02f, -1.57545835e-01f, -1.04345381e-01f, -7.47284386e-03f, -6.67552724e-02f, 4.13887575e-02f, 7.85835311e-02f,
  4.82762083e-02f, 8.83017182e-02f, -6.00476302e-02f, 8.73923972e-02f, 9.15696323e-02f, 1.25165850e-01f, -2.20358800e-02f, 9.48943496e-02f, -8.99917558e-02f, -6.55395463e-02f,
  -1.66211769e-01f, -9.83294751e-03f, 1.17308743e-01f, 2.55630855e-02f, -1.06195612e-02f, 2.29704604e-02f, 3.80936116e-02f, 8.54277015e-02f, 8.85279030e-02f, -3.05364467e-02f,
  1.20522839e-03f, -5.42141087e-02f, -3.99232954e-02f, 6.61322549e-02f, 1.11863511e-02f, -2.56911549e-03f, -3.11578847e-02f, -1.04403064e-01f, 2.25003273e-03f, -5.49685508e-02f,
  -4.35437039e-02f, -3.37234028e-02f, -4.36144918e-02f, -1.17637202e-01f, 4.73346151e-02f, 1.80146229e-02f, -6.08373396e-02f, -3.15842070e-02f, -2.49412842e-02f, -1.10648349e-01f,
  7.89633170e-02f, -2.05879975e-02f, 4.00206037e-02f, 5.62647916e-02f, -6.48976117e-02f, 3.47460955e-02f, 5.22529744e-02f, -2.04169527e-02f, 5.52686639e-02f, -1.95982102e-02f,
  5.45276552e-02f, -6.30335063e-02f, -3.55953425e-02f, -3.20287272e-02f, -4.02460583e-02f, 5.80419488e-02f, -3.40646580e-02f, 2.19952241e-02f, -4.50920723e-02f, 6.77196234e-02f,
  -5.09744370e-03f, -2.03549080e-02f, -1.36803370e-02f, 7.07258508e-02f, -1.63115095e-02f, 1.44819655e-02f, -2.18179151e-02f, 6.62180632e-02f, -7.45734945e-02f, -8.88106897e-02f,
  -2.65213288e-02f, -2.63135079e-02f, -4.98068705e-02f, -3.37387286e-02f, -1.71460805e-03f, -2.47336607e-02f, -7.04132095e-02f, -5.94029501e-02f, 1.39845610e-02f, -1.47015164e-02f,
  -4.58527096e-02f, -2.63781343e-02f, -8.37032124e-02f, -2.77534015e-02f, -9.70047489e-02f, 2.66087130e-02f, -1.09406225e-01f, -9.94604751e-02f, -2.37518046e-02f, 7.67632294e-03f,
  7.28138443e-03f, -4.80276458e-02f, -1.42939776e-01f, 1.65091101e-02f, 4.15624194e-02f, -8.88112783e-02f, -8.76721926e-03f, -1.13846838e-01f, -6.69240654e-02f, -2.13115945e-01f,
  1.18576549e-01f, 2.24085212e-01f, 1.89516917e-01f, 6.34828806e-02f, 9.67553407e-02f, 1.38026297e-01f, 1.31259456e-01f, 5.92947528e-02f, -1.59256220e-01f, -4.84453104e-02f,
  1.29098743e-01f, -8.47024668e-04f, -6.29768446e-02f, -1.63968712e-01f, -3.16535197e-02f, -1.07776619e-01f, -4.13016602e-02f, -1.28856450e-01f, -2.60072597e-03f, -7.84498081e-02f,
  -1.74135175e-02f, 9.73600596e-02f, 6.77614361e-02f, -7.59153888e-02f, 2.71123257e-02f, -2.58554192e-03f, 3.73107009e-03f, 2.89272666e-02f, 1.04249880e-01f, 1.66230481e-02f,
  6.30265921e-02f, 2.53275067e-01f, -2.21871048e-01f, -6.36248067e-02f, 1.42712653e-01f, 6.29772525e-03f, 2.74154451e-02f, 2.20619515e-02f, 1.02423197e-02f, -6.48592636e-02f,
  1.10511556e-01f, -4.20530774e-02f, -5.57915913e-03f, 6.96338117e-02f, 4.68570404e-02f, 3.90817448e-02f, 9.81466938e-03f, -3.39576006e-02f, -1.23896077e-02f, -4.71126623e-02f,
  4.72964495e-02f, 3.01520545e-02f, 2.12704793e-01f, 2.31667310e-02f, -3.40841338e-02f, -4.58813384e-02f, 1.31132558e-01f, -1.46603456e-03f, 8.08152780e-02f, -7.62588829e-02f,
  -4.49242033e-02f, 4.36740890e-02f, -1.44529007e-02f, -4.22742926e-02f, -3.72521281e-02f, -5.22274487e-02f, 6.23759441e-02f, 7.73923397e-02f, 2.55614687e-02f, -3.23814824e-02f,
  -3.35221328e-02f, 5.20811602e-03f, 8.98946077e-02f, 6.70345500e-02f, -8.20227712e-02f, 3.59429891e-04f, 4.82353047e-02f, -7.13023767e-02f, 7.71713257e-02f, 4.41947207e-02f,
  1.16391014e-02f, -2.02404242e-02f, 2.99614836e-02f, 6.04286641e-02f, -6.83292449e-02f, 2.43013073e-02f, -8.92412104e-03f, -8.94452911e-03f, 7.51645043e-02f, 3.92734483e-02f,
  -6.25100508e-02f, 1.63800120e-01f, -1.19222336e-01f, -1.16183303e-01f, 7.35574737e-02f, 1.83795521e-03f, 4.95394766e-02f, 3.73759097e-03f, -2.54875645e-02f, -8.04498605e-03f,
  1.17968470e-01f, -7.23033845e-02f, 1.23048030e-01f, 5.74943647e-02f, -9.39773172e-02f, -7.64823034e-02f, -1.73386335e-02f, -1.02360295e-02f, -8.17321539e-02f, 2.07204055e-02f,
  -8.10908154e-02f, -9.70895365e-02f, -8.45451057e-02f, -1.30274758e-01f, -4.99935485e-02f, -1.08988270e-01f, -5.90237752e-02f, -2.39681620e-02f, -2.37087496e-02f, -2.01496765e-01f,
  5.25256097e-02f, -5.10048028e-03f, 4.07341644e-02f, 2.81024463e-02f, 2.85539869e-02f, 1.94271822e-02f, -1.10195354e-02f, -5.14417216e-02f, 1.17175588e-02f, 9.21598542e-03f,
  9.23600718e-02f, -7.50483666e-03f, 2.03914102e-02f, -1.03659220e-01f, 9.88506619e-03f, -4.47763428e-02f, 3.72253880e-02f, -9.39967297e-03f, 1.98365320e-02f, -7.61103407e-02f,
  1.07217126e-03f, 3.37156132e-02f, -8.99874046e-03f, -8.20552111e-02f, 5.23780473e-02f, -6.74516261e-02f, -2.45913845e-02f, 1.57630797e-02f, 9.30083618e-02f, 8.13090876e-02f,
  5.27539589e-02f, -9.96244028e-02f, -4.73807901e-02f, 2.69929152e-02f, -3.34132574e-02f, 4.54437174e-02f, -4.26600724e-02f, 3.73493023e-02f, 5.80304768e-03f, 2.91512627e-02f,
  8.79359841e-02f, -2.66898777e-02f, -5.91793731e-02f, 3.10605951e-02f, 2.69564949e-02f, -6.06081598e-02f, -9.56970453e-02f, -8.58947188e-02f, -8.50696042e-02f, -1.26168784e-02f,
  -3.19186109e-03f, 6.75440654e-02f, -3.44653684e-03f, 2.47619506e-02f, -1.69220474e-02f, 8.76645818e-02f, 6.24584705e-02f, 7.05258995e-02f, -7.66357780e-02f, -4.84216809e-02f,
  -4.10991162e-02f, 5.75619116e-02f, -5.47646321e-02f, 9.40650888e-03f, -4.43810932e-02f, -5.07385880e-02f, 3.47641180e-03f, 4.00944278e-02f, -8.70633125e-02f, 8.70869458e-02f,
  6.45615757e-02f, 2.51764469e-02f, -4.53813225e-02f, -1.01342291e-01f, -5.65020368e-02f, 3.50659266e-02f, 8.34403560e-02f, 6.19155681e-03f, -3.76122929e-02f, 7.21720085e-02f,
  -7.19573796e-02f, 6.27314858e-03f, 7.48989582e-02f, -8.63485560e-02f, 3.76172364e-02f, -5.35852946e-02f, -4.42636386e-02f, 2.91025769e-02f, -8.42310339e-02f, 4.86043282e-03f,
  -7.35001117e-02f, 8.82584080e-02f, -2.60861870e-02f, -6.36321530e-02f, -1.78431142e-02f, 7.25548342e-02f, -3.56407240e-02f, -2.85434388e-02f, 7.69183040e-03f, -8.59721974e-02f,
  5.61366901e-02f, 5.11525869e-02f, -5.83780408e-02f, 5.11106513e-02f, -4.01464701e-02f, -7.53368139e-02f, 2.63495594e-02f, -4.21415530e-02f, -5.66050783e-02f, -5.71256056e-02f,
  4.19946462e-02f, -2.29460504e-02f, -1.54737663e-02f, -6.95294440e-02f, -2.23707105e-03f, -3.88312861e-02f, -3.08314543e-02f, -6.61685411e-03f, -7.97530338e-02f, 3.09822373e-02f,
  5.29484153e-02f, 8.81150141e-02f, 5.27271815e-02f, 1.14810027e-01f, -1.26093596e-01f, -1.82320639e-01f, -6.26644939e-02f, -3.00762486e-02f, -1.41772693e-02f, 8.83520860e-03f,
  -5.93548752e-02f, -1.68823719e-01f, 1.70092024e-02f, -9.72900987e-02f, -1.36357129e-01f, -7.08928928e-02f, 5.16739264e-02f, -1.69841081e-01f, -3.26878160e-01f, -1.01118602e-01f,
  -1.82613105e-01f, -1.43282145e-01f, -1.45000562e-01f, 2.91407239e-02f, 1.32328942e-01f, 1.31620318e-02f, 7.48338997e-02f, -6.95409253e-02f, -1.28000870e-01f, 1.18869692e-01f,
  5.79449423e-02f, -3.19988839e-02f, -1.05575494e-01f, -1.47607308e-02f, -4.61219624e-02f, 6.51888326e-02f, 1.49850724e-02f, 3.27228270e-02f, -8.61319825e-02f, -2.58963630e-02f,
  -5.33291437e-02f, -1.18406400e-01f, -3.69237252e-02f, -1.16987169e-01f, 5.53528517e-02f, 5.37910014e-02f, 8.65575373e-02f, -5.67381717e-02f, -8.01315159e-02f, -1.05805825e-02f,
  -8.65478590e-02f, -1.01332486e-01f, -4.28426825e-02f, -2.69055460e-02f, -8.06708485e-02f, -5.60912415e-02f, 3.38167208e-03f, 1.57897361e-02f, -9.57304314e-02f, 1.14306107e-01f,
  3.45531702e-02f, -4.02447544e-02f, -2.20255628e-02f, -5.18704504e-02f, 1.67683363e-02f, -2.39017401e-02f, 2.77392659e-03f, 2.90262159e-02f, 3.65189537e-02f, 5.66787235e-02f,
  6.57968968e-02f, 2.09841747e-02f, 5.52068017e-02f, 5.64830154e-02f, 4.62989025e-02f, 5.63463010e-03f, 8.79031606e-03f, 2.59543471e-02f, -9.97561738e-02f, -2.49385815e-02f,
  -8.59330129e-03f, 2.44950000e-02f, 4.85913232e-02f, 2.82037165e-02f, 6.88626096e-02f, 8.60609636e-02f, 3.84986252e-02f, -5.35469465e-02f, -3.00311185e-02f, 1.95997674e-02f,
  1.52822539e-01f, -2.00076073e-01f, 3.40230949e-02f, 1.64218992e-02f, 5.06261326e-02f, 6.37952089e-02f, -5.59943076e-03f, -5.85940704e-02f, -3.04203816e-02f, -7.92328194e-02f,
  -6.64148033e-02f, -6.06953166e-02f, 4.09820080e-02f, -5.40057346e-02f, -1.62132476e-02f, 4.07374017e-02f, -3.48810069e-02f, 4.75673936e-02f, -7.03947917e-02f, 8.68369043e-02f,
  -3.46221146e-03f, 3.22415195e-02f, -6.85683787e-02f, 6.61345273e-02f, 3.14596258e-02f, -5.99105880e-02f, 9.18559078e-03f, -1.13764629e-02f, -1.74402446e-02f, 1.72562376e-01f,
  1.34867728e-01f, -5.43911494e-02f, -1.98788658e-01f, 1.68991601e-03f, -1.47068933e-01f, -7.24386796e-02f, -4.36893143e-02f, -8.57118517e-02f, 2.81005781e-02f, -1.49273485e-01f,
  -1.31591886e-01f, 5.54931536e-02f, -3.86186130e-02f, 8.26131329e-02f, 1.04081504e-01f, -6.24565892e-02f, -1.40855178e-01f, 1.89714227e-02f, 4.87045050e-02f, 6.19284585e-02f,
  -3.70969810e-02f, 6.42802343e-02f, 1.34266064e-01f, 7.32700750e-02f, -4.68340479e-02f, -5.52843921e-02f, -1.68636486e-01f, -7.42906779e-02f, -3.15116309e-02f, -1.33181706e-01f,
  -9.31701958e-02f, -7.43015483e-02f, 3.73636968e-02f, 4.56729047e-02f, -2.03755274e-02f, -4.98636104e-02f, -1.02629915e-01f, -5.22554070e-02f, 4.59291860e-02f, -8.57946277e-03f,
  -6.15243092e-02f, -4.34021233e-03f, -2.48346832e-02f, -3.68087031e-02f, 3.17780003e-02f, 6.61879629e-02f, 9.05075483e-03f, 1.26158908e-01f, 5.18118665e-02f, 2.57638898e-02f,
  -8.58638287e-02f, -1.19586445e-01f, -8.99477303e-02f, -8.17348063e-02f, 4.09879925e-04f, 4.67092916e-02f, -9.29147080e-02f, -5.52594662e-02f, 4.04024906e-02f, -1.05870478e-01f,
  -9.26754028e-02f, -3.52892140e-03f, -1.11652073e-03f, 4.99670990e-02f, -2.11095735e-02f, 4.30637263e-02f, -7.48441517e-02f, -4.42708284e-03f, -4.32556979e-02f, -1.59161482e-02f,
  7.96221048e-02f, -3.30662131e-02f, -1.27523858e-02f, 6.94757178e-02f, 4.94653545e-03f, 3.72702256e-02f, 6.09292537e-02f, -5.88768721e-03f, 2.67497860e-02f, 6.61284775e-02f,
  6.52995519e-03f, 2.11883234e-04f, -9.81846824e-03f, 5.00092767e-02f, 6.75000176e-02f, -3.27788526e-03f, -5.18862121e-02f, 1.09013595e-01f, -4.60806824e-02f, -5.36113679e-02f,
  1.24382172e-02f, 1.05841249e-01f, 4.54258695e-02f, -3.54482941e-02f, -3.34509388e-02f, -3.84859070e-02f, 1.15064383e-02f, 7.98438266e-02f, -1.13332473e-01f, 5.45764416e-02f,
  -6.74901679e-02f, 1.02820687e-01f, -2.56439000e-02f, 5.32629043e-02f, 2.93038916e-02f, -2.64225136e-02f, 2.54366640e-02f, -4.24338914e-02f, -2.98366006e-02f, -4.66335192e-02f,
  -6.45592287e-02f, 1.27679552e-03f, 4.23069205e-03f, -2.74381004e-02f, 7.95287173e-03f, 9.04391780e-02f, -8.49620700e-02f, -2.09091441e-03f, 1.12082243e-01f, -1.01426750e-01f,
  -2.94362694e-01f, -4.62628268e-02f, 1.09642044e-01f, -6.28150105e-02f, 4.17998843e-02f, -7.40626827e-03f, 1.56018794e-01f, -7.46455183e-03f, -1.47131294e-01f, -3.21881957e-02f,
  1.29773766e-02f, 8.49788934e-02f, -2.65800040e-02f, 1.16916910e-01f, 2.45699193e-02f, 1.38776861e-02f, 6.49725571e-02f, -4.79892967e-03f, 2.61837326e-04f, 4.68249470e-02f,
  -1.42535819e-02f, -1.24194801e-01f, -2.26714257e-02f, -1.16111018e-01f, -2.28907261e-02f, 6.17934838e-02f, -2.91611347e-03f, -5.61539494e-02f, -6.05486799e-03f, -5.06651811e-02f,
  2.13735700e-01f, -6.20021299e-02f, -5.91493286e-02f, -9.03628245e-02f, -8.62439498e-02f, 3.47897480e-03f, 3.25961038e-02f, -8.79571661e-02f, 4.92945574e-02f, -2.46321433e-03f,
  -9.33952816e-03f, -3.23256035e-03f, -1.09531082e-01f, -1.93300168e-03f, -1.19903363e-01f, -1.09469064e-01f, 1.66865122e-02f, -1.10713966e-01f, 5.44769689e-02f, 5.34489714e-02f,
  7.50904158e-02f, -6.54254332e-02f, 7.34143257e-02f, -5.96861057e-02f, 6.69199079e-02f, 2.06721984e-02f, -5.73404469e-02f, -7.85286129e-02f, -2.07732581e-02f, 6.60964325e-02f,
  -1.55349039e-02f, -3.25751826e-02f, 7.40725594e-03f, -7.41746873e-02f, 1.53504880e-02f, 5.50592355e-02f, 3.84980030e-02f, 2.24375222e-02f, 6.05646372e-02f, -6.69663996e-02f,
  -1.78577527e-02f, 4.57363902e-03f, 1.04878485e-01f, -6.63738027e-02f, 7.65314773e-02f, -2.93141622e-02f, 7.55411461e-02f, -1.68240741e-02f, -4.00638841e-02f, -6.71950355e-02f,
  -4.89551127e-02f, -4.87197712e-02f, -9.18563306e-02f, -3.26836556e-02f, 5.67653216e-02f, -2.30152868e-02f, 9.71007999e-03f, -7.14993030e-02f, 7.62656406e-02f, -7.02467859e-02f,
  9.92341936e-02f, 5.66956773e-02f, -5.91129996e-02f, -5.78553975e-02f, -6.74594641e-02f, -6.19753152e-02f, 5.35933487e-02f, -6.44243555e-03f, -3.42539661e-02f, 4.33366261e-02f,
  3.16796526e-02f, -5.93549339e-03f, 6.05014265e-02f, 8.11606124e-02f, 4.53542992e-02f, -2.88314726e-02f, -1.97036825e-02f, 5.28878197e-02f, -2.15432327e-02f, 6.70099258e-02f,
  -5.18167578e-02f, -6.98351488e-02f, 1.40840113e-01f, -1.25636230e-03f, -7.90654588e-03f, -1.78282652e-02f, 6.45976216e-02f, -5.17950580e-03f, 6.20844327e-02f, 5.54051250e-02f,
  1.31631374e-01f, 1.98997650e-02f, 5.78491576e-03f, 5.72848544e-02f, -1.12550497e-01f, -5.71442880e-02f, 2.15565003e-02f, -4.79745381e-02f, -6.40922710e-02f, 6.13764189e-02f,
  9.41805989e-02f, -3.02799921e-02f, 9.34383124e-02f, 3.27324122e-02f, -3.24456170e-02f, 4.10342626e-02f, 5.48054799e-02f, 5.28769605e-02f, 1.01754412e-01f, 4.10715304e-02f,
  1.47867855e-02f, 8.47885199e-03f, 1.16055027e-01f, -5.96068939e-03f, -4.50988077e-02f, -5.79152852e-02f, 9.51185450e-02f, -4.29647043e-02f, -3.99910919e-02f, -3.49061824e-02f,
  2.81752145e-04f, 1.33107156e-01f, 4.60042357e-02f, -7.07058683e-02f, 1.25655487e-01f, 2.39790957e-02f, -4.50771973e-02f, 3.98009233e-02f, 8.43089446e-02f, 8.73106765e-04f,
  4.14110310e-02f, 7.74735585e-02f, -1.78369973e-02f, -2.69034598e-02f, 3.80334109e-02f, -5.75932898e-02f, -2.38131033e-03f, 9.47590098e-02f, 9.36752558e-02f, 6.81029707e-02f,
  5.45924529e-02f, 8.53317752e-02f, -1.56236934e-02f, 4.75200452e-02f, -3.30000967e-02f, -4.53991331e-02f, -5.09765707e-02f, 8.11258778e-02f, -3.99976075e-02f, -3.25892121e-02f,
  1.12298550e-02f, 5.98334260e-02f, 2.42656451e-02f, 3.95272449e-02f, 2.93736290e-02f, 6.17181286e-02f, 5.65938354e-02f, 3.33339274e-02f, 6.79538911e-03f, 8.46057981e-02f,
  8.32834989e-02f, 1.06918238e-01f, -4.69033644e-02f, 9.48714614e-02f, 1.11622877e-01f, -1.92862675e-02f, 4.54959124e-02f, 1.09255627e-01f, 1.17691651e-01f, 7.46600628e-02f,
  -6.01604171e-02f, -1.70597024e-02f, 8.54590312e-02f, 7.68657103e-02f, 6.96362788e-03f, 1.04758263e-01f, 2.69489866e-02f, 4.57019284e-02f, 5.73010221e-02f, -4.66607586e-02f,
  -1.56689081e-02f, 1.16735347e-01f, -7.55411759e-02f, -2.50406917e-02f, -7.31010735e-03f, 4.61445116e-02f, 5.31654768e-02f, 3.41634303e-02f, -6.26466498e-02f, -9.65172350e-02f,
  1.99344810e-02f, 8.53519514e-02f, -4.57639359e-02f, 4.45977896e-02f, -2.97619775e-02f, -6.35674149e-02f, -2.46598274e-02f, 5.67861050e-02f, -1.69120096e-02f, -3.98092791e-02f,
  -7.91541785e-02f, -9.24486481e-03f, 4.47794236e-02f, -4.87961657e-02f, -1.92704611e-02f, 5.39704300e-02f, -3.56906913e-02f, -1.21217176e-01f, -5.60760163e-02f, -6.71063364e-02f,
  -2.13241667e-01f, -1.88036069e-01f, -1.66309446e-01f, -7.05990791e-02f, 4.43280526e-02f, -7.56882876e-02f, 1.89781263e-02f, 3.05387024e-02f, -7.94698596e-02f, -9.68587324e-02f,
  -4.05595929e-05f, 2.71504391e-02f, -5.75727113e-02f, 2.63077579e-02f, -2.58603506e-02f, -1.29083812e-01f, -2.13224012e-02f, -1.03875481e-01f, 8.28781947e-02f, 3.66287027e-03f,
  9.34579596e-02f, 5.78078255e-02f, -6.46058545e-02f, 3.24477553e-02f, 1.42059484e-02f, 4.79723774e-02f, -9.58384946e-02f, 3.15899327e-02f, -1.01526447e-01f, -1.30188733e-01f,
  -5.10905348e-02f, -3.69095802e-02f, 6.99032545e-02f, -6.14561848e-02f, -5.50402775e-02f, -2.60274448e-02f, -1.69449802e-02f, 5.37982769e-02f, 5.93059622e-02f, -4.63226400e-02f,
  -1.60911363e-02f, 9.33798328e-02f, -4.09435816e-02f, 1.70327667e-02f, -1.21282348e-02f, 7.48225451e-02f, 2.73350440e-02f, 5.66275232e-03f, 3.15729417e-02f, 7.06642643e-02f,
  -5.94619662e-02f, -1.24988936e-01f, -5.28359264e-02f, -1.17146047e-02f, 4.91527319e-02f, -1.12218782e-01f, -8.79450515e-02f, -7.30410889e-02f, 2.58337837e-02f, 2.91100256e-02f,
  -8.69605020e-02f, -8.63706470e-02f, 2.83473562e-02f, 4.14801277e-02f, -4.73769009e-02f, -8.47816169e-02f, -7.44296536e-02f, 7.40512609e-02f, 4.77251261e-02f, 5.43251187e-02f,
  -2.13156566e-02f, -3.67872939e-02f, -4.35037799e-02f, 7.71767879e-03f, 6.64395317e-02f, -3.22407857e-02f, -5.30492365e-02f, 5.97576015e-02f, -1.55343525e-02f, 7.14645460e-02f,
  -8.43677074e-02f, 6.84537664e-02f, -4.24243435e-02f, -4.99184690e-02f, 3.96821164e-02f, 5.76576637e-03f, -6.45994991e-02f, 3.73826995e-02f, -7.29628056e-02f, -3.51488851e-02f,
  3.19640003e-02f, -2.89215948e-02f, -1.14022590e-01f, 6.40216917e-02f, 2.31501670e-03f, -5.70827574e-02f, 3.04003190e-02f, -1.05128914e-01f, -4.55570072e-02f, 7.83462375e-02f,
  -4.59210090e-02f, 5.58897033e-02f, -8.80380720e-02f, -3.53362672e-02f, -3.95851173e-02f, 1.80285200e-02f, 3.62484939e-02f, -6.87943846e-02f, -2.77446713e-02f, 3.36837694e-02f,
  6.24441430e-02f, 1.54801710e-02f, -1.28141284e-01f, -9.59450826e-02f, 8.45069140e-02f, -9.48930159e-02f, -7.07517192e-02f, -1.21591970e-01f, -2.06151903e-02f, -1.55411392e-01f,
  -1.19330220e-01f, -6.79174811e-02f, 3.66310328e-02f, 5.83353452e-02f, 5.53466603e-02f, 9.99358967e-02f, 5.25931530e-02f, 1.20776288e-01f, 2.08412930e-02f, -2.46289670e-02f,
  -1.12826884e-01f, 9.63238329e-02f, -1.22316582e-02f, 7.42228236e-03f, 1.36669934e-01f, 5.94348200e-02f, 6.40413687e-02f, 1.03477001e-01f, 1.07636854e-01f, 7.55195692e-02f,
  3.77764995e-03f, -5.49896881e-02f, 6.57386035e-02f, -5.70503734e-02f, -1.65595356e-02f, 2.86608115e-02f, 1.00770913e-01f, 3.41486139e-03f, -1.06524654e-01f, -2.50488576e-02f,
  -1.32075056e-01f, -2.04270989e-01f, 1.10883765e-01f, 6.17583431e-02f, -3.10876817e-02f, -2.81982648e-04f, 3.25911790e-02f, -4.78326622e-03f, 2.13564318e-02f, -2.14548018e-02f,
  -3.25883329e-02f, -7.56597221e-02f, 6.26810640e-03f, 2.82676276e-02f, -2.51450315e-02f, -5.60142733e-02f, 5.23045287e-02f, 9.01358202e-02f, 6.76690713e-02f, 6.43730583e-03f,
  -6.79935589e-02f, -2.08704229e-02f, -4.32154909e-02f, 3.34355272e-02f, -6.33875579e-02f, 1.02943383e-01f, -4.83990274e-02f, 1.39283920e-02f, -2.57642590e-04f, -3.55014466e-02f,
  -3.77228446e-02f, 4.24899310e-02f, -9.20377225e-02f, 4.05895747e-02f, 8.40627868e-03f, 4.43884507e-02f, 7.10696876e-02f, 5.13334721e-02f, 6.40065745e-02f, -5.76001080e-03f,
  -8.41272995e-02f, 7.19934702e-02f, -6.96080327e-02f, 5.30459732e-02f, 1.02053590e-01f, -6.92760795e-02f, -6.94016367e-02f, 6.50587901e-02f, -4.72043268e-02f, -5.26284352e-02f,
  -6.38637990e-02f, 6.30719364e-02f, -8.06610361e-02f, -8.08622688e-02f, 2.71930601e-02f, -6.72923774e-02f, -2.84153447e-02f, 7.40619451e-02f, -6.39890879e-02f, 4.43083756e-02f,
  5.55826947e-02f, 8.10481682e-02f, -1.73030980e-02f, -4.21361700e-02f, -4.08744030e-02f, -1.14702530e-01f, 3.37606184e-02f, 6.59467652e-03f, -9.12769735e-02f, 6.23780414e-02f,
  -6.12569712e-02f, 1.98947894e-03f, -7.09268451e-02f, 2.07403284e-02f, 4.29910608e-02f, 4.91032749e-02f, -1.37064084e-01f, -7.16991872e-02f, 2.31264513e-02f, -9.26949009e-02f,
  5.87510765e-02f, -4.75296080e-02f, 9.47769433e-02f, 1.08884871e-01f, -3.97080742e-02f, 1.01410009e-01f, 7.22809583e-02f, -3.73638980e-02f, 6.54848590e-02f, 9.64816958e-02f,
  1.76491871e-01f, 2.22153198e-02f, 6.73394799e-02f, 9.43939239e-02f, 4.83604409e-02f, 8.79163593e-02f, -7.39472434e-02f, -3.53558548e-02f, -7.58532584e-02f, 7.26187453e-02f,
  1.31934568e-01f, 9.55250412e-02f, 9.66997817e-02f, 4.88150865e-03f, -3.26616480e-03f, 1.70963556e-02f, 3.23877633e-02f, 5.42530753e-02f, -5.07084280e-03f, 1.20822519e-01f,
  4.86269817e-02f, 1.19196355e-01f, 6.08729720e-02f, 9.60693229e-03f, -5.30344713e-03f, 2.61066798e-02f, 6.25862926e-02f, 3.48561555e-02f, 4.44898792e-02f, -3.61819379e-02f,
  4.00307290e-02f, 9.51938033e-02f, -6.27775565e-02f, 1.42991627e-02f, -4.54347245e-02f, 3.98265496e-02f, -1.56207383e-02f, 2.86261141e-02f, 7.77388411e-03f, -2.11673528e-02f,
  6.06826171e-02f, 9.60266590e-02f, 5.19337617e-02f, 6.08276129e-02f, 3.16227376e-02f, 2.17262711e-02f, -8.38474184e-02f, 4.13416103e-02f, 6.44923300e-02f, 4.24702317e-02f,
  -3.05123422e-02f, 7.09789991e-02f, 3.33528519e-02f, -9.28694308e-02f, 6.17849268e-02f, -5.54447919e-02f, 1.06998503e-01f, 9.58464071e-02f, -7.10365772e-02f, -1.57814734e-02f,
  5.24426959e-02f, 8.92027691e-02f, -3.44494134e-02f, -5.00706434e-02f, 3.02002579e-02f, -9.07164812e-02f, -5.29277921e-02f, -8.38609040e-02f, 5.61361350e-02f, -5.17285950e-02f,
  -6.72090985e-03f, -2.05148384e-02f, -6.59708828e-02f, -6.09670766e-02f, -4.49978560e-02f, -6.01639897e-02f, -2.68876944e-02f, 2.63187499e-03f, -1.82637013e-02f, -3.85077968e-02f,
  7.36994445e-02f, -7.07162842e-02f, 7.80917034e-02f, 1.09843528e-02f, 8.81409943e-02f, -4.61683087e-02f, 7.15042278e-02f, -6.97695166e-02f, 8.92129913e-02f, -1.01409033e-02f,
  -3.91833223e-02f, 4.36449423e-02f, -8.52646083e-02f, 1.97310522e-02f, -3.90356034e-02f, 4.20630127e-02f, 7.60243908e-02f, 7.27967918e-02f, -2.42897030e-02f, -3.39377485e-02f,
  -3.42867747e-02f, 8.10835734e-02f, 5.19206040e-02f, -1.04915813e-01f, -1.02652416e-01f, -5.84938526e-02f, 6.51501566e-02f, -2.48035770e-02f, 4.89793569e-02f, -3.31746414e-02f,
  -2.40259375e-02f, -1.07774787e-01f, -7.00354129e-02f, -3.59858908e-02f, 1.59989819e-02f, -6.81149885e-02f, -9.35680568e-02f, -4.44892570e-02f, -1.17713641e-02f, 3.41098532e-02f,
  -2.83470839e-01f, 4.10309546e-02f, 7.93668851e-02f, -2.28433058e-01f, 2.09126249e-02f, 1.51403055e-01f, 1.44360617e-01f, 9.06146597e-03f, -1.32935926e-01f, -3.58547866e-02f,
  -3.23529579e-02f, 4.84452583e-03f, 7.21159130e-02f, -1.38124498e-03f, -5.76014705e-02f, 8.37472442e-04f, 1.07816778e-01f, 2.88133547e-02f, -8.19180235e-02f, -7.96958990e-03f,
  -1.21736690e-01f, -1.54580906e-01f, -2.14980066e-01f, -9.93220285e-02f, 2.61867233e-02f, 7.52629787e-02f, 3.09302360e-02f, 1.12196707e-04f, 4.40274552e-03f, -8.77757147e-02f,
  2.27491051e-01f, -1.99192744e-02f, -7.38763660e-02f, -6.42783567e-03f, 1.11230426e-02f, 6.25483599e-03f, -8.18148032e-02f, -1.51508329e-02f, -1.05017714e-01f, -7.89239034e-02f,
  1.10890893e-02f, -3.15663926e-02f, -5.16838692e-02f, -9.15373415e-02f, -9.92046446e-02f, -3.12740356e-02f, -5.90286665e-02f, -3.34442034e-02f, 5.98305538e-02f, 9.28095430e-02f,
  -2.31965887e-03f, -7.02344477e-02f, -2.57618818e-03f, 1.04200080e-01f, -5.21077625e-02f, 3.39014595e-03f, -5.77780828e-02f, -2.75116544e-02f, 4.37789597e-02f, 1.76117439e-02f,
  -2.56407652e-02f, 2.73089707e-02f, 3.17307487e-02f, 9.46709700e-03f, -5.57803735e-02f, -5.09559661e-02f, 8.59704912e-02f, 7.77671933e-02f, 1.79516226e-02f, -1.98848825e-02f,
  3.64472233e-02f, 4.86653000e-02f, -7.34846294e-02f, 3.68529707e-02f, 8.25742781e-02f, -7.77145177e-02f, -6.24593943e-02f, -7.16397241e-02f, 3.00890114e-02f, -7.01429695e-02f,
  3.56529118e-03f, 9.73948613e-02f, 4.44912575e-02f, -4.91747446e-02f, 1.01240896e-01f, -4.47263569e-02f, -3.91871184e-02f, -7.33391643e-02f, -3.76915857e-02f, -8.59392621e-03f,
  -3.74807827e-02f, 9.54479352e-02f, 8.10780004e-02f, 3.01785916e-02f, 1.75045710e-02f, -7.02798143e-02f, -2.09859498e-02f, -6.97899088e-02f, 6.05068803e-02f, 4.95808460e-02f,
  7.06798732e-02f, 1.31472228e-02f, -2.46667117e-03f, 2.53283083e-02f, -5.88878654e-02f, 2.88311485e-02f, -9.67044458e-02f, 3.31035182e-02f, 4.08221446e-02f, 1.84353217e-02f,
  7.55099021e-03f, 1.50488606e-02f, 1.49742998e-02f, 9.02123228e-02f, 8.27190578e-02f, 9.15617868e-02f, 1.36825904e-01f, 6.55012205e-02f, -1.76719688e-02f, 4.13700417e-02f,
  2.62716800e-01f, 2.02168971e-02f, -1.93789348e-01f, 1.36235291e-02f, -1.05455190e-01f, -1.05518363e-01f, -3.32583003e-02f, 7.41654215e-03f, 8.37586746e-02f, 3.75404209e-02f,
  -1.40959457e-01f, -3.73972277e-03f, 3.93442484e-03f, -1.35067806e-01f, 4.80282046e-02f, -1.04895815e-01f, -2.60615014e-02f, -2.29540281e-02f, -1.24933004e-01f, -4.33883220e-02f,
  -6.84697330e-02f, -1.23142116e-02f, -2.45969184e-02f, -4.86359410e-02f, -7.10054114e-02f, -3.41605246e-02f, -1.26581509e-02f, -8.75262022e-02f, -9.98081565e-02f, -7.59621486e-02f,
  -2.13329107e-01f, -9.07947645e-02f, 4.75104153e-02f, 9.01774317e-02f, -5.63748367e-02f, -7.11425543e-02f, -1.46793267e-02f, -6.13300726e-02f, 3.90667394e-02f, 2.11168025e-02f,
  2.61128563e-02f, 3.05743460e-02f, -2.18224525e-02f, 5.38205914e-03f, 4.74016815e-02f, -1.57556944e-02f, -4.14746068e-02f, -4.02527191e-02f, -1.15053289e-01f, -1.06092207e-01f,
  4.41703387e-02f, -1.02297612e-01f, -3.08605060e-02f, 1.88319050e-02f, -3.68169434e-02f, 6.16307557e-02f, -2.13392638e-02f, -8.98229927e-02f, -1.29544646e-01f, 7.43319690e-02f,
  -1.49298701e-02f, -5.45783229e-02f, 4.25718576e-02f, 7.84994513e-02f, 5.02067469e-02f, 1.31270697e-03f, -2.89936131e-03f, -4.95422222e-02f, 8.64904188e-03f, 1.04092555e-02f,
  4.60944884e-02f, 4.11464386e-02f, 4.62409295e-02f, 1.80406980e-02f, 3.34200300e-02f, 4.33959253e-02f, 4.39311750e-02f, 6.34307694e-03f, 2.82201730e-03f, 4.10268158e-02f,
  2.36674584e-02f, -6.42576143e-02f, -2.02750247e-02f, -5.17512253e-03f, 2.07348960e-03f, -5.68871647e-02f, 5.06653301e-02f, 6.30813166e-02f, -1.05219118e-01f, -9.70249623e-03f,
  -1.38235949e-02f, -6.97638886e-03f, 2.93075629e-02f, 1.60842761e-02f, 1.68338660e-02f, 2.43261326e-02f, -8.87208357e-02f, 1.96102262e-02f, 4.44776639e-02f, -3.62616591e-02f,
  -2.28866916e-02f, 9.28522460e-03f, 3.01319752e-02f, 3.05151083e-02f, -2.15122066e-02f, 4.89753075e-02f, 4.72337678e-02f, 1.18699409e-02f, 3.84220965e-02f, -5.07543422e-02f,
  3.98811959e-02f, 1.71378389e-01f, 1.95587426e-01f, 1.21253699e-01f, -1.86984520e-02f, -9.20307171e-03f, 7.03619421e-02f, 1.93771217e-02f, 1.06424145e-01f, 1.37774423e-01f,
  2.87222534e-01f, -5.28519079e-02f, -8.36436972e-02f, -2.45745946e-02f, -1.50576308e-01f, -2.49228269e-01f, -1.98556393e-01f, -7.74264857e-02f, -3.40632116e-03f, -5.90071119e-02f,
  -2.03188378e-02f, 9.15502012e-03f, 1.81928929e-02f, -3.60895954e-02f, -7.66300857e-02f, -4.96515110e-02f, -1.10490151e-01f, 1.35487422e-01f, 8.17026049e-02f, 6.41214773e-02f,
  8.52408558e-02f, 1.96625605e-01f, 1.75464824e-01f, 7.05127642e-02f, 2.43615061e-02f, 7.48598874e-02f, -1.01250701e-01f, 1.10930547e-01f, -3.62623520e-02f, 9.61438715e-02f,
  7.95178413e-02f, 1.24868378e-02f, 2.17166245e-02f, 6.10634051e-02f, -7.92007893e-02f, -3.58312204e-02f, -1.95725206e-02f, -1.37087069e-02f, -2.41308901e-02f, -1.05345100e-01f,
  -1.03937455e-01f, 6.88702837e-02f, -7.51536116e-02f, -7.22240284e-03f, 6.07455410e-02f, 2.19404120e-02f, 7.57127011e-04f, 3.74820782e-03f, 2.07153540e-02f, -1.87701583e-02f,
  3.82275619e-02f, -5.48323281e-02f, -7.77707845e-02f, -6.33319691e-02f, -3.55710424e-02f, -5.96241839e-03f, -2.37426907e-03f, -7.36882836e-02f, -4.70249951e-02f, 2.82731093e-03f,
  -2.81654298e-02f, 1.41407130e-02f, 2.41477638e-02f, -7.75434598e-02f, -7.09517002e-02f, -5.28970249e-02f, -1.36553659e-03f, 4.42908667e-02f, -3.27023119e-02f, 2.04785410e-02f,
  -8.71626511e-02f, 2.48699691e-02f, -1.40405940e-02f, 3.39538194e-02f, 7.01907352e-02f, -6.13661557e-02f, -1.60860606e-02f, 2.09969357e-02f, -1.29277166e-02f, 6.50682300e-02f,
  9.60571170e-02f, 8.34055129e-04f, 6.40367763e-03f, 7.20196068e-02f, -6.56305552e-02f, 1.34436199e-02f, -9.89545695e-03f, 3.36974673e-02f, 2.71331649e-02f, 3.47809643e-02f,
  3.89572680e-02f, -1.44878119e-01f, -6.78463951e-02f, 9.54468995e-02f, -8.94374847e-02f, -1.58268306e-02f, -1.04178667e-01f, -2.46396605e-02f, -6.42361566e-02f, -2.14803629e-02f,
  1.55177796e-02f, 4.97939400e-02f, -8.52216110e-02f, 3.69101614e-02f, 6.15645722e-02f, -9.89557803e-02f, 9.89775360e-03f, -5.19356430e-02f, -9.37629044e-02f, 4.63468693e-02f,
  9.21212789e-03f, -5.75967655e-02f, -1.64067131e-02f, -1.01708248e-01f, -9.20252204e-02f, -1.10392362e-01f, -3.96509655e-02f, -1.09394722e-01f, -2.80171894e-02f, -1.08313538e-01f,
  -9.56442282e-02f, 6.37682527e-03f, -3.08939293e-02f, -6.60360828e-02f, -1.23413242e-01f, -8.79392624e-02f, -2.22070813e-02f, -4.55003195e-02f, -9.79277417e-02f, 1.00274742e-01f,
  -2.03134473e-02f, 4.21955436e-02f, -8.77096206e-02f, 4.35839370e-02f, 2.69343015e-02f, -3.31144407e-02f, -1.12562999e-01f, -9.54747051e-02f, -9.48746130e-02f, -6.95889071e-02f,
  -3.28052007e-02f, -1.08284004e-01f, -3.93960029e-02f, -7.08597898e-02f, 8.30653869e-03f, -6.93670586e-02f, -9.22656730e-02f, -7.55324289e-02f, -1.97295249e-02f, -3.61994617e-02f,
  1.39073655e-01f, -1.54696643e-01f, -1.10276401e-01f, -4.74462733e-02f, -1.25174981e-03f, -8.61614719e-02f, 2.32721120e-02f, -7.23173767e-02f, 3.67091335e-02f, -4.01693843e-02f,
  -5.53432815e-02f, 7.67282248e-02f, 6.40575513e-02f, 5.70877604e-02f, 1.04275094e-02f, -2.41233688e-02f, -4.93959449e-02f, 2.18329336e-02f, -8.31802934e-02f, 8.57489370e-03f,
  9.23549682e-02f, -1.11226462e-01f, 3.42720076e-02f, -4.10223082e-02f, -4.07986343e-02f, -1.46500438e-01f, 7.96311051e-02f, 5.09808324e-02f, 3.93006131e-02f, 2.07266654e-03f,
  -3.23183052e-02f, -1.19894678e-02f, 7.87270218e-02f, -6.55998662e-03f, -5.95896170e-02f, 4.95347381e-02f, 4.84228060e-02f, 1.21272933e-02f, 8.76262262e-02f, -3.77879068e-02f,
  7.24956840e-02f, -4.70859632e-02f, -4.63544615e-02f, 4.27549854e-02f, 6.53930232e-02f, 3.90528515e-02f, 2.83573829e-02f, -3.62706967e-02f, 5.71493208e-02f, 5.23548992e-03f,
  -2.42192950e-02f, 1.40098780e-02f, 1.68720968e-02f, -6.77597057e-03f, 1.50598027e-02f, 5.31690456e-02f, -7.39863887e-02f, -3.38941216e-02f, 6.00724109e-02f, -1.72755867e-02f,
  1.30713090e-01f, -2.76268311e-02f, 1.00654038e-03f, 2.94640083e-02f, -5.70224482e-04f, 5.96777610e-02f, 7.79711157e-02f, 7.38572478e-02f, 7.27637857e-02f, 9.38602840e-04f,
  -3.40604410e-03f, 6.15931004e-02f, 7.98841044e-02f, -5.75614683e-02f, -1.50201153e-02f, 6.82353899e-02f, -6.25630990e-02f, -8.25832598e-03f, 1.84730459e-02f, -5.81362769e-02f,
  8.94098133e-02f, -7.61634298e-03f, 8.67660716e-02f, -1.72002260e-02f, 7.10319206e-02f, -6.62205219e-02f, 1.40102976e-03f, 1.10438742e-01f, 5.66127859e-02f, 1.83531344e-01f,
  4.26487960e-02f, 4.19544913e-02f, 1.06196320e-02f, 9.75503400e-03f, 4.27872911e-02f, -1.30966395e-01f, -1.77899927e-01f, -3.50471810e-02f, -2.42275465e-02f, -4.14233953e-02f,
  1.30743897e-02f, 3.12727727e-02f, -1.12800531e-01f, -6.78331926e-02f, -1.65162563e-01f, -6.77703395e-02f, 4.00856808e-02f, -1.43581659e-01f, -1.88745499e-01f, -2.36618251e-01f,
  -9.12738666e-02f, -7.96796829e-02f, -1.21062860e-01f, -1.25945389e-01f, 1.79092124e-01f, 1.07601002e-01f, 1.87451139e-01f, -1.97116062e-02f, 7.41855875e-02f, 1.08276613e-01f,
  2.22888440e-02f, 7.53646567e-02f, -9.46561247e-02f, -6.48351088e-02f, 8.56314749e-02f, -1.10529615e-02f, -8.09208397e-03f, 1.16722830e-01f, 6.26788521e-03f, 6.30036071e-02f,
  4.75154780e-02f, -2.04601884e-02f, -4.99695577e-02f, 1.59417838e-02f, -3.49724703e-02f, -7.71850301e-03f, -1.21615887e-01f, 9.99910105e-03f, -6.89047575e-02f, 4.73127440e-02f,
  2.53347326e-02f, -8.72749649e-03f, -1.86739247e-02f, 5.41525753e-03f, -1.48456665e-02f, 9.96081624e-03f, 4.14833911e-02f, 1.35885403e-01f, 2.92325690e-02f, 3.41814719e-02f,
  -1.27081633e-01f, 2.51685083e-02f, 4.69378941e-03f, -9.96562541e-02f, -7.88303763e-02f, -3.33866812e-02f, 9.82032344e-02f, -9.09111500e-02f, -9.94340181e-02f, -2.38815881e-02f,
  -8.30141306e-02f, 5.48992716e-02f, -6.68807477e-02f, -9.64820459e-02f, -1.38515970e-04f, 6.97413608e-02f, -3.05770636e-02f, -1.13963515e-01f, -7.14683682e-02f, -6.50111213e-02f,
  4.73233797e-02f, 2.62529403e-02f, 2.34351680e-02f, 1.13177737e-02f, -1.91114563e-02f, -4.07715626e-02f, 3.25343832e-02f, 2.39810757e-02f, -4.01803143e-02f, 7.35778585e-02f,
  2.90578939e-02f, -6.67895302e-02f, -4.23881821e-02f, -9.63136777e-02f, 1.58643857e-01f, 7.84947574e-02f, 4.63209711e-02f, -5.78036569e-02f, 1.20138593e-01f, 5.61809503e-02f,
  -9.67355669e-02f, -1.94403958e-02f, -5.57849146e-02f, -1.12938532e-03f, -6.19293228e-02f, -8.58950764e-02f, -6.14880249e-02f, -4.74132150e-02f, -4.94612046e-02f, 3.76713239e-02f,
  -1.97627991e-02f, -1.23074166e-01f, -6.01138510e-02f, -5.61024137e-02f, -2.15210076e-02f, 4.51805405e-02f, -1.00172311e-02f, -1.23901293e-02f, 2.85526384e-02f, -1.69703197e-02f,
  2.34671354e-01f, -2.06683278e-01f, 1.87982574e-01f, 5.87229580e-02f, 5.30907363e-02f, 1.62813976e-01f, 2.70130839e-02f, 8.37839115e-03f, -6.53717443e-02f, -9.89987701e-02f,
  -2.76902132e-03f, -7.20713362e-02f, -2.70990785e-02f, 4.59061787e-02f, 1.46397622e-02f, 4.35396619e-02f, 1.08750220e-02f, 1.00756839e-01f, 5.98985702e-02f, 2.90828198e-02f,
  -9.43321958e-02f, -8.40908885e-02f, 1.04980372e-01f, 8.52406248e-02f, -1.37770191e-01f, 2.90022735e-02f, 2.45721601e-02f, -5.52019402e-02f, -1.27187083e-02f, -1.46018520e-01f,
  -8.68588910e-02f, 1.03477143e-01f, 1.92413367e-02f, 7.71715306e-03f, -2.96573918e-02f, -7.44899362e-02f, 6.99406536e-03f, -1.25288079e-02f, -5.05195335e-02f, 2.12490931e-02f,
  5.10113649e-02f, -1.14032058e-02f, 4.55176905e-02f, -1.04374446e-01f, 7.19085634e-02f, -2.30533443e-02f, 4.51923870e-02f, 2.29188567e-03f, 5.33794910e-02f, -1.81541182e-02f,
  -9.15522203e-02f, 5.59337996e-02f, 1.44426122e-01f, -6.41472042e-02f, -8.48745462e-03f, 8.87194648e-02f, 1.28738377e-02f, 3.58266123e-02f, 6.95786104e-02f, -6.55463859e-02f,
  7.50372093e-03f, 1.13548311e-04f, 3.22349444e-02f, 3.62353225e-04f, 3.20466869e-02f, 7.08167851e-02f, 2.60545854e-02f, 4.02791910e-02f, -4.27327864e-02f, 5.85633293e-02f,
  -4.61065583e-02f, 1.93589889e-02f, -1.92097423e-03f, -2.62169950e-02f, -1.12539791e-02f, 2.55083013e-02f, 8.35944936e-02f, -1.24720469e-01f, 2.09739655e-02f, -5.64257242e-02f,
  2.25709230e-02f, -1.63258240e-02f, -2.89512146e-03f, -6.98820222e-03f, -5.97887002e-02f, 8.56544375e-02f, -1.26892440e-02f, 6.36383072e-02f, -7.23189265e-02f, -6.16831109e-02f,
  -7.70982876e-02f, 2.13381708e-01f, -2.70405668e-03f, -4.18149531e-02f, 8.27510133e-02f, -1.96358301e-02f, 1.52276810e-02f, -2.94831255e-03f, -2.29959041e-02f, -2.11671852e-02f,
  -1.06329605e-01f, 2.09676456e-02f, -3.94024998e-02f, -1.97341554e-02f, 7.14580044e-02f, 4.79467027e-02f, -8.92615542e-02f, 4.16465849e-03f, -9.85606909e-02f, -1.23411760e-01f,
  -4.20217490e-04f, -1.98173579e-02f, 1.43030629e-01f, 5.44284023e-02f, -1.80896465e-02f, 1.47588000e-01f, 2.12860145e-02f, 1.35488044e-02f, 6.27226569e-03f, -3.34334886e-03f,
  1.48709938e-01f, -4.11838926e-02f, 2.88256556e-02f, 1.41974434e-01f, -7.10256472e-02f, -1.44694746e-01f, -1.09190710e-01f, -6.99467063e-02f, 8.88565853e-02f, 2.46779826e-02f,
  -3.62831950e-02f, 9.64670256e-02f, 1.38006821e-01f, 1.44823998e-01f, 1.36364520e-01f, 1.30946096e-02f, -2.81165913e-02f, 9.85937715e-02f, 7.67562836e-02f, 4.67931069e-02f,
  1.01590537e-01f, 1.26550287e-01f, 1.69545755e-01f, 1.09047890e-01f, 8.32281336e-02f, 2.43213084e-02f, 5.68880886e-02f, 3.44167911e-02f, -1.55461598e-02f, 2.03227788e-01f,
  2.79238541e-02f, 5.59474453e-02f, 4.15285304e-02f, -6.49496317e-02f, 2.85027046e-02f, 2.73038652e-02f, -6.04363829e-02f, -5.61541831e-03f, 4.79906313e-02f, -4.32937704e-02f,
  4.98447530e-02f, 1.03231482e-02f, -2.38211453e-02f, -1.56038757e-02f, 5.54131977e-02f, 3.47174332e-02f, 1.28106279e-02f, 4.71997373e-02f, 2.83706784e-02f, 9.16356444e-02f,
  -4.87728566e-02f, -1.73435695e-02f, -1.08090984e-02f, -4.51088771e-02f, -3.39114480e-02f, 5.48463175e-03f, -8.64775777e-02f, 4.74633500e-02f, -1.01913042e-01f, 5.15851863e-02f,
  3.60303633e-02f, -1.10053243e-02f, -6.71405271e-02f, 8.29918236e-02f, -4.42403033e-02f, 4.02634107e-02f, -5.64699881e-02f, 3.63392010e-02f, -5.36912046e-02f, 6.93764836e-02f,
  8.80887359e-02f, -2.30208188e-02f, -3.65444608e-02f, 4.49570939e-02f, -4.23786342e-02f, -6.78957403e-02f, 2.65859440e-02f, 1.37919849e-02f, 3.24773490e-02f, 5.26964068e-02f,
  6.27648756e-02f, 1.08939715e-01f, 3.62482574e-03f, 8.30084924e-03f, 4.35404181e-02f, -4.75367904e-03f, 6.88454881e-02f, -4.82694097e-02f, -2.88494565e-02f, 1.04516763e-02f,
  -6.33784682e-02f, 8.68489128e-03f, 8.12872127e-02f, -7.29965279e-03f, -1.49530517e-02f, -9.46981311e-02f, 1.98779488e-03f, 5.03141731e-02f, -6.90187700e-03f, 5.56904413e-02f,
  -1.17672890e-01f, -1.70707703e-02f, -4.42729704e-02f, -5.78525402e-02f, -1.03045419e-01f, 5.00994874e-03f, -1.13737583e-01f, 1.72317196e-02f, -3.50897722e-02f, -1.00058861e-01f,
  3.43241207e-02f, -9.94660426e-03f, -1.21903926e-01f, -1.42199948e-01f, 1.80936535e-03f, -1.16933510e-01f, -5.89334518e-02f, -1.18896164e-01f, -2.03437731e-02f, -7.78186545e-02f,
  -6.91492707e-02f, -4.22255583e-02f, -5.91493957e-03f, 1.61929712e-01f, 8.69440436e-02f, 9.77866203e-02f, -1.27472766e-02f, 6.67509958e-02f, 1.14203848e-01f, 8.14305320e-02f,
  -3.34583111e-02f, 1.72742888e-01f, 7.45895281e-02f, 3.20677981e-02f, -1.21938167e-02f, 1.16160244e-01f, 9.13472846e-02f, -3.25404815e-02f, 8.54008719e-02f, 1.28477216e-01f,
  1.37525514e-01f, 5.79797837e-04f, 2.89574172e-02f, -5.37049510e-02f, -5.03844507e-02f, 1.12061128e-01f, 4.84312177e-02f, 4.18340275e-03f, 4.16988619e-02f, 1.20891724e-02f,
  -9.55878869e-02f, -1.42301768e-01f, 1.07129715e-01f, -7.10071251e-02f, -8.69801864e-02f, -1.02574147e-01f, -4.27731201e-02f, -5.77920489e-02f, -6.67134374e-02f, 5.82472794e-02f,
  -5.69088683e-02f, -3.51268649e-02f, 5.99332042e-02f, -1.19362950e-01f, 3.43001857e-02f, 4.01774645e-02f, -7.98596293e-02f, -1.05330423e-01f, 3.26076411e-02f, -4.55359817e-02f,
  6.49662912e-02f, -1.21529795e-01f, 1.78370569e-02f, 4.44278345e-02f, 7.15609789e-02f, 4.23423015e-02f, -5.64993471e-02f, -8.01150575e-02f, -8.05682614e-02f, -3.55880111e-02f,
  1.53293423e-02f, 8.26300774e-03f, 6.03231005e-02f, 4.47023474e-02f, -3.90389115e-02f, -1.84729882e-02f, 8.59025270e-02f, -5.76261356e-02f, -3.92574258e-02f, -1.65602323e-02f,
  -5.19864373e-02f, -5.92251122e-02f, 1.01112477e-01f, 2.49195881e-02f, 6.83747754e-02f, -2.16631275e-02f, -8.23045149e-04f, 1.86363384e-02f, -8.63706023e-02f, -4.93390039e-02f,
  -6.62082061e-02f, 6.53402507e-02f, 3.37278545e-02f, -1.18826749e-02f, 7.68750831e-02f, -4.89377677e-02f, -9.06337984e-03f, 4.27678078e-02f, 6.86448514e-02f, -4.22657505e-02f,
  -3.95966619e-02f, 8.08902383e-02f, 1.23883590e-01f, -4.54129018e-02f, -5.61158843e-02f, 2.54330747e-02f, 9.13323089e-02f, -3.09470445e-02f, 2.67010890e-02f, -1.69503912e-02f,
  -4.57972027e-02f, 5.44944406e-02f, 4.42096218e-02f, -5.68915047e-02f, 8.09610710e-02f, -3.76154389e-03f, 4.64249309e-03f, 9.99506116e-02f, -5.60998432e-02f, -8.90731141e-02f,
  -2.22413186e-02f, 1.05278857e-01f, -6.07766584e-02f, 1.23941809e-01f, 1.45784561e-02f, 9.18771625e-02f, -6.08261675e-02f, 7.63510764e-02f, 9.05681774e-02f, 7.60651454e-02f,
  -1.19015209e-01f, 1.50428727e-01f, -1.14141069e-02f, -7.87823722e-02f, -7.25018159e-02f, -5.40408157e-02f, 5.40611595e-02f, 3.24072577e-02f, 6.26609474e-02f, 5.14479429e-02f,
  -1.33750349e-01f, -2.29832176e-02f, -8.98082927e-03f, -1.39422361e-02f, 1.08891018e-01f, -7.73220454e-05f, 1.05866648e-01f, 1.01734869e-01f, 6.28527254e-02f, 7.04688579e-02f,
  -2.59585995e-02f, 1.27148640e-03f, 2.36998405e-02f, -1.96067303e-05f, -3.03787719e-02f, -1.88319329e-02f, -2.16314532e-02f, -2.81847678e-02f, 6.11912459e-02f, 6.38748705e-02f,
  -1.00567646e-01f, 2.78527476e-02f, -7.51076499e-03f, -9.93662551e-02f, -9.56187025e-02f, -7.31092393e-02f, 5.40671088e-02f, -4.29622270e-02f, -6.98375329e-02f, -6.96374383e-03f,
  1.16845006e-02f, -5.43259047e-02f, -8.26555565e-02f, -7.02200979e-02f, -6.11655787e-02f, -5.52298501e-02f, 2.18773242e-02f, 1.01652712e-01f, -6.53499411e-03f, -2.40829587e-02f,
  -7.54375160e-02f, -1.28635215e-02f, -7.46399015e-02f, -3.48548144e-02f, 1.14636406e-01f, 4.83592227e-02f, 6.37983084e-02f, -4.52871695e-02f, -2.07118448e-02f, -7.46598542e-02f,
  3.48123792e-03f, -9.54941958e-02f, 5.47092743e-02f, -7.86210448e-02f, -5.26419505e-02f, 4.88677211e-02f, 9.61840749e-02f, -6.90599158e-02f, -8.36270973e-02f, -6.45168275e-02f,
  -7.71701261e-02f, -6.72688568e-03f, 7.89090395e-02f, -3.02954819e-02f, -6.80707246e-02f, 7.11782798e-02f, 7.67085850e-02f, 1.64414681e-02f, 1.35666691e-02f, 4.35948633e-02f,
  -5.01279756e-02f, 1.62429698e-02f, -8.10251459e-02f, 1.07125985e-02f, 8.99767652e-02f, 8.49598572e-02f, -5.27708977e-02f, -5.06846569e-02f, -6.54674843e-02f, 7.56230345e-03f,
  -1.58626273e-01f, -1.11156173e-01f, 4.59922738e-02f, -7.86315203e-02f, 6.41138554e-02f, 4.19624429e-03f, -7.86992162e-02f, -7.06941709e-02f, -8.45104223e-04f, 3.36183570e-02f,
  5.80793656e-02f, 2.38060690e-02f, 2.99623348e-02f, 1.74742658e-02f, -3.29739563e-02f, -3.82762104e-02f, 2.75806524e-02f, 1.18791768e-02f, 4.91648540e-02f, -4.40460034e-02f,
  -1.03023075e-01f, -1.83326844e-02f, -1.15582928e-01f, 5.20160384e-02f, -5.65860011e-02f, -4.83101346e-02f, 2.24587079e-02f, -2.99481638e-02f, -8.62930566e-02f, 3.51684005e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  1.60525981e-02f, 2.10214913e-01f, 5.90044819e-02f, -3.42493467e-02f, 6.93655238e-02f, 4.75211069e-02f, 5.68182357e-02f, 5.71425743e-02f, 2.32685059e-01f, 1.37459219e-01f,
  1.16544284e-01f, 1.75488412e-01f, 9.73358080e-02f, 1.12061158e-01f, 5.72296865e-02f, 1.73311248e-01f, 1.71924338e-01f, 2.13614836e-01f, -3.11971251e-02f, 7.75805041e-02f,
  2.47735269e-02f, 1.60676718e-01f, 1.41378090e-01f, -7.68189691e-03f, 9.22734365e-02f, -1.92093775e-02f, 9.75227132e-02f, 9.59679931e-02f, 5.10849580e-02f, 4.77724411e-02f,
  3.15964594e-02f, 1.62556335e-01f, 1.82118878e-01f, 5.01540340e-02f, 8.28160122e-02f, 6.95790499e-02f, 1.87188059e-01f, 2.39735574e-01f, 1.41074374e-01f, 1.72578469e-01f,
  9.99292955e-02f, 6.02614768e-02f, -1.36227366e-02f, 8.61515291e-03f, 1.58889174e-01f, 2.62987018e-01f, 1.55191317e-01f, 6.86748475e-02f, -3.14520709e-02f, 4.63983864e-02f,
  1.55499011e-01f, -1.65362339e-02f, 1.93423867e-01f, 1.55326709e-01f, 1.18718646e-01f, 8.30601081e-02f, 6.93243593e-02f, -8.00983980e-03f, 1.56352893e-02f, 1.20615073e-01f,
  1.27928376e-01f, 3.39947194e-02f, 1.41193017e-01f, 1.56491563e-01f, 1.43312395e-01f, -8.55956599e-03f, 8.17641467e-02f, 1.86175749e-01f, 4.47953418e-02f, 7.47393221e-02f,
  1.66899398e-01f, 2.24153489e-01f, 1.85992531e-02f, 8.20813999e-02f, 2.55773157e-01f, 8.72419998e-02f, 1.23767167e-01f, 1.88780688e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.68388689e-01f, 1.28261521e-01f, -3.83104384e-01f, -1.32255837e-01f, -6.11646250e-02f, 1.07543590e-02f, -2.60624111e-01f, -1.40671870e-02f, -2.14705899e-01f, -2.42503807e-01f,
  -8.12182501e-02f, -1.17066570e-01f, -3.90912592e-01f, -7.22313449e-02f, -2.32308492e-01f, 9.97050032e-02f, -1.73996419e-01f, -3.47931892e-01f, -5.31672835e-02f, -3.99752036e-02f,
  -8.38687792e-02f, -1.67875409e-01f, -2.45073035e-01f, -4.80150789e-01f, -1.95807256e-02f, -3.00503969e-01f, 3.90843987e-01f, -4.90931123e-02f, -2.37899706e-01f, -2.35657007e-01f,
  6.15803376e-02f, -2.84151822e-01f, 1.07608318e-01f, 4.37373579e-01f, 1.07077181e-01f, 6.97846338e-02f, 1.21220179e-01f, 1.69267967e-01f, -5.87608628e-02f, 1.48382619e-01f,
  8.43705311e-02f, 2.16352805e-01f, -1.06149511e-02f, 4.72947210e-02f, 7.08494931e-02f, 7.18513727e-02f, -4.19746749e-02f, 1.25254512e-01f, 1.20133489e-01f, -8.83491114e-02f,
  -1.65516526e-01f, -1.23643421e-01f, -1.06962211e-01f, 4.57726642e-02f, 1.37044881e-02f, -2.40303546e-01f, -1.50522497e-02f, 3.65657091e-01f, -7.90798515e-02f, -5.01653850e-02f,
  6.23659268e-02f, -2.64199283e-02f, -2.66771019e-01f, 9.60612320e-04f, -1.51914686e-01f, 2.84154952e-01f, 4.71975431e-02f, -9.61113870e-02f, 1.74165200e-02f, 4.41928655e-01f,
  -1.20194361e-01f, -4.79505733e-02f, 3.04365177e-02f, 2.65388265e-02f, 9.78274271e-02f, -5.88842900e-03f, -5.43064587e-02f, -1.25232458e-01f, -6.11188523e-02f, 5.84463663e-02f,
  1.96756884e-01f, 6.45434186e-02f, 2.81906337e-01f, 1.38559401e-01f, -9.44445580e-02f, -9.53677297e-03f, 1.96092755e-01f, 4.32447977e-02f, 4.53989416e-01f, -8.29535723e-02f,
  1.02303207e-01f, 4.01005521e-02f, 4.00877744e-02f, -1.23899393e-01f, 1.95935592e-01f, -9.23751816e-02f, -2.37112522e-01f, -9.06279236e-02f, 3.36355805e-01f, -4.19531241e-02f,
  6.00644462e-02f, -6.63810521e-02f, 2.04636961e-01f, 2.44025469e-01f, -9.99394730e-02f, -2.80040409e-02f, -1.47714227e-01f, 1.49802864e-02f, 1.18146315e-02f, 4.20256019e-01f,
  -1.54131100e-01f, -5.75811267e-02f, -1.50365919e-01f, 3.07265580e-01f, -1.32772148e-01f, -1.10617869e-01f, 3.70790243e-01f, -3.45163420e-02f, -6.56885132e-02f, -1.89015821e-01f,
  2.17676312e-02f, 1.76356629e-01f, -8.85811460e-04f, -1.79641217e-01f, -3.36406417e-02f, -1.01582587e-01f, 4.30200621e-03f, -8.09234381e-02f, 9.77640301e-02f, 7.83703569e-03f,
  2.12918803e-01f, 2.95204848e-01f, 1.93347692e-01f, -9.99212712e-02f, -7.18315914e-02f, -5.70588596e-02f, -3.82721335e-01f, 2.49049827e-01f, 2.11962715e-01f, 1.77956372e-01f,
  -3.69785368e-01f, -1.53005496e-01f, 2.69816518e-02f, 1.03538848e-01f, 1.39154702e-01f, 1.54030174e-01f, 2.10777968e-02f, 2.48707294e-01f, 4.10976224e-02f, 1.11134320e-01f,
  7.92550445e-02f, -3.78401965e-01f, -1.75407827e-01f, -1.96801852e-02f, 5.21733642e-01f, -1.86746776e-01f, 1.58879906e-01f, 2.67743737e-01f, -5.04581928e-01f, 2.51694560e-01f,
  3.59349519e-01f, 4.08056021e-01f, 3.82630765e-01f, -2.66442657e-01f, 1.07060179e-01f, 9.85944644e-02f, 5.00822663e-01f, 2.00752139e-01f, 3.36995095e-01f, -1.17703669e-01f,
  3.09582710e-01f, 1.53120920e-01f, 6.08177297e-02f, -1.76279068e-01f, 1.09734498e-01f, 4.00994092e-01f, 9.45406258e-02f, -1.06282257e-01f, 2.02108160e-01f, 1.33639902e-01f,
  -2.96108630e-02f, -9.04927179e-02f, 6.95797950e-02f, -1.35439649e-01f, -1.43251225e-01f, 2.80675977e-01f, -2.64384955e-01f, 3.26679975e-01f, -1.29335091e-01f, -2.22455248e-01f,
  -1.14011824e-01f, -1.81632921e-01f, -5.75928241e-02f, 2.47837320e-01f, -2.55259216e-01f, -2.03063965e-01f, 2.41109431e-01f, -8.94555524e-02f, -1.94609597e-01f, -1.40970126e-01f,
  4.57033515e-01f, -2.20264196e-02f, -3.72634940e-02f, 1.36857359e-02f, 2.50425220e-01f, -1.43453494e-01f, -5.06061763e-02f, -3.82124968e-02f, -9.64732245e-02f, 4.72706333e-02f,
  3.37074250e-01f, -1.05523886e-02f, -1.14190526e-01f, 1.28524061e-02f, -1.02273092e-01f, 1.20900489e-01f, 7.06077740e-02f, -1.52757689e-01f, -1.15633875e-01f, -2.91055739e-01f,
  1.57978401e-01f, -5.70245497e-02f, 9.35355872e-02f, -8.76791775e-02f, -1.29527777e-01f, -1.23645216e-01f, 1.54203340e-01f, 6.38016611e-02f, -5.04102185e-02f, -6.08995818e-02f,
  -1.83789685e-01f, 1.92002460e-01f, 2.10225180e-01f, 7.51110613e-02f, -1.20336875e-01f, -2.38199458e-01f, 1.24308221e-01f, -1.63948685e-01f, -3.01336329e-02f, -2.51835641e-02f,
  -1.98580310e-01f, 2.86950916e-01f, 1.84188634e-02f, 1.17842525e-01f, -1.20169789e-01f, 1.45186603e-01f, 1.54835254e-01f, 1.59822889e-02f, 2.53389835e-01f, -4.17099474e-03f,
  -3.70892137e-02f, -8.71327668e-02f, 2.42460936e-01f, 2.44837165e-01f, 2.10402891e-01f, -5.48317172e-02f, -5.40794022e-02f, -9.20208078e-03f, 1.04792699e-01f, 1.12460464e-01f,
  2.11318746e-01f, 1.16876625e-02f, 1.18673883e-01f, 9.47960019e-02f, 3.74501288e-01f, 2.41006792e-01f, 9.48965177e-02f, 1.69370040e-01f, 2.19963238e-01f, 1.27422109e-01f,
  1.66294929e-02f, 7.64636248e-02f, 1.17886558e-01f, 2.40519360e-01f, 5.70460744e-02f, -1.21813789e-01f, -2.13661641e-01f, -3.71473730e-02f, 6.99307621e-02f, 2.51711458e-01f,
  1.66632503e-01f, -3.96702498e-01f, -2.61512637e-01f, -2.68902361e-01f, -2.44632095e-01f, 1.24608524e-01f, -1.46326125e-01f, 2.87909269e-01f, 2.53382802e-01f, -5.99938631e-02f,
  4.07478243e-01f, -2.50976235e-01f, -3.69337559e-01f, 2.08532318e-01f, 2.36630991e-01f, 3.64712119e-01f, 7.36856163e-02f, 9.25705954e-02f, -1.89510405e-01f, 1.01052247e-01f,
  -4.14195299e-01f, 5.06368518e-01f, -5.40978134e-01f, -3.66574168e-01f, 3.42962414e-01f, 2.34958783e-01f, 7.98940659e-03f, -3.13210964e-01f, 3.40919644e-02f, 8.23376328e-02f,
  -8.33926871e-02f, 7.42517039e-02f, -1.45081148e-01f, -2.97930002e-01f, -1.25446960e-01f, -2.56654713e-02f, -6.48218812e-03f, -2.06486821e-01f, -2.86387112e-02f, 2.03944761e-02f,
  -2.39925221e-01f, -1.14198141e-01f, -3.01366802e-02f, -3.31843570e-02f, -6.35554492e-02f, -9.85544361e-03f, -6.61743209e-02f, -2.02417791e-01f, -5.54428771e-02f, -3.09918504e-02f,
  -2.81320103e-02f, 4.86907661e-02f, -2.01315701e-01f, -1.66610688e-01f, 1.45363241e-01f, 7.05164596e-02f, -5.11593930e-02f, -1.50759101e-01f, 2.64851353e-03f, -1.31101102e-01f,
  1.19280681e-01f, 6.21847510e-02f, -1.56845212e-01f, 1.55572161e-01f, -1.78479239e-01f, 3.58949065e-01f, 1.86088771e-01f, 5.20957224e-02f, -1.29141837e-01f, -2.74614468e-02f,
  3.62506866e-01f, 9.41693038e-03f, 7.84309767e-03f, -1.10389121e-01f, -6.68727001e-03f, 2.72904579e-02f, 1.12480722e-01f, 4.75155264e-02f, 9.92142484e-02f, 3.20463926e-01f,
  -2.28739142e-01f, -4.70200889e-02f, -1.33201063e-01f, -5.89975044e-02f, -2.24877819e-02f, 1.43167779e-01f, -3.28952707e-02f, 6.50803223e-02f, -1.73511133e-01f, 1.63374215e-01f,
  -6.92403466e-02f, 1.47041857e-01f, -1.01876082e-02f, 1.18786223e-01f, -4.88286931e-03f, -1.38487101e-01f, -1.40451819e-01f, 1.14665829e-01f, -1.63092643e-01f, -1.14920519e-01f,
  1.35909200e-01f, 9.68117043e-02f, -5.54031432e-02f, -3.68303410e-03f, -1.71052553e-02f, 2.68651266e-02f, 1.01662122e-01f, 1.29075512e-01f, -1.17070481e-01f, -1.30381025e-02f,
  2.85849237e-04f, 1.78387258e-02f, 1.30709782e-01f, -3.44685078e-01f, 1.09267928e-01f, -3.98110412e-02f, 2.65424162e-01f, -4.02140170e-02f, -1.02178484e-01f, -1.11112788e-01f,
  1.33573160e-01f, -6.57266378e-02f, -5.09772189e-02f, -6.21718839e-02f, -1.55005336e-01f, -1.04086317e-01f, -2.49664467e-02f, -8.24770331e-02f, 2.11010590e-01f, 2.42421359e-01f,
  -2.50868827e-01f, 6.83444142e-02f, 1.10059038e-01f, -1.51922807e-01f, 1.06832147e-01f, -2.14668468e-01f, -4.32106592e-02f, -5.95179647e-02f, 2.15967610e-01f, -6.61734045e-02f,
  -4.67418060e-02f, 2.10750140e-02f, 6.16377778e-02f, 1.74458638e-01f, -2.34737411e-01f, -7.98802599e-02f, 7.42210969e-02f, -2.03067973e-01f, 2.40392357e-01f, 2.14039043e-01f,
  1.89011216e-01f, -9.95780248e-03f, 3.86700720e-01f, 5.28992116e-02f, 2.40574911e-01f, -4.18829285e-02f, 2.76371211e-01f, 3.71141993e-02f, -1.52062297e-01f, -1.27370745e-01f,
  -1.52238861e-01f, -1.62492506e-02f, 3.86434883e-01f, -6.18263632e-02f, -6.26482815e-02f, 7.22139537e-01f, 2.13369429e-01f, 2.37382054e-02f, 1.63159832e-01f, 4.30926122e-02f,
  5.75049043e-01f, -1.40229434e-01f, 1.71582535e-01f, -2.07874924e-01f, -7.49681443e-02f, -6.39691204e-02f, -1.00087069e-01f, 2.75934398e-01f, -1.02468207e-01f, -1.97124600e-01f,
  -8.60614255e-02f, -1.21255875e-01f, -6.30901530e-02f, -1.50923669e-01f, -1.75509602e-01f, -4.60177623e-02f, -2.84667850e-01f, 2.75305599e-01f, -2.00764358e-01f, 4.46838289e-02f,
  -3.49510074e-01f, -1.61021680e-01f, 1.69347316e-01f, 2.34793052e-01f, 9.57132205e-02f, 1.19789787e-01f, 2.36708224e-02f, -1.44585773e-01f, 2.05523849e-01f, 3.71990651e-01f,
  3.52714628e-01f, 8.01674351e-02f, 7.42211118e-02f, -7.04803243e-02f, -6.22530878e-02f, -7.74955153e-02f, 2.40401655e-01f, 2.94167280e-01f, -3.17251645e-02f, 2.36014158e-01f,
  -1.63793251e-01f, -7.68845752e-02f, -1.53322771e-01f, -1.24823354e-01f, -6.66892529e-02f, 8.64627659e-02f, -9.80983600e-02f, -6.73724264e-02f, 1.44742265e-01f, -5.81677742e-02f,
  4.63933833e-02f, -4.30496894e-02f, -1.31184638e-01f, 3.79110336e-01f, -1.65629357e-01f, -3.12621921e-01f, 4.31966931e-02f, -1.01981916e-01f, -1.28343508e-01f, -1.91018626e-01f,
  -8.05638060e-02f, 1.02657154e-01f, 4.10491824e-02f, -1.40804887e-01f, -1.35161385e-01f, -2.43013874e-01f, -3.70778501e-01f, 3.70929856e-03f, -3.91348079e-03f, 1.57872923e-02f,
  2.80418783e-01f, -1.74250454e-01f, -7.76096657e-02f, -1.03199460e-01f, 1.92019999e-01f, 2.48079859e-02f, 7.43055716e-02f, -2.15547070e-01f, -3.05459559e-01f, -2.42534533e-01f,
  5.22516370e-02f, 6.25558421e-02f, 4.58897129e-02f, 2.51160979e-01f, 1.57922711e-02f, 3.55261922e-01f, -2.74881393e-01f, -1.85277387e-01f, -3.74538451e-01f, -1.14942245e-01f,
  -1.93112865e-01f, -3.12246889e-01f, 2.41180763e-01f, -1.34581015e-01f, 6.24519289e-02f, -2.85161704e-01f, 1.85831204e-01f, 3.07450444e-01f, 8.92118886e-02f, 7.84173906e-02f,
  -9.12485272e-03f, 1.06367126e-01f, -4.14260536e-01f, 3.37894082e-01f, 3.21653575e-01f, -4.99620475e-02f, 1.71910394e-02f, 1.06477253e-01f, -6.41016811e-02f, 1.14530593e-01f,
  -6.33495748e-02f, -1.67705104e-01f, 4.93975803e-02f, -1.05896227e-01f, -1.48274615e-01f, 3.74368615e-02f, 4.40115221e-02f, 2.74744958e-01f, 1.80199385e-01f, 7.14036375e-02f,
  -1.67419702e-01f, -1.58973485e-01f, 4.06565927e-02f, 2.02093609e-02f, 2.58173477e-02f, 3.11642557e-01f, -1.21003613e-01f, 5.31313121e-01f, 1.44551963e-01f, 2.02127561e-01f,
  -8.70465934e-02f, 6.11450337e-02f, 3.33278239e-01f, -1.20286047e-01f, 1.19282834e-01f, -9.38501135e-02f, 7.88651556e-02f, 2.63725460e-01f, -4.75898385e-02f, 1.96146648e-02f,
  4.67617922e-02f, -1.57212436e-01f, -3.29511389e-02f, -1.02060072e-01f, -1.05919108e-01f, 1.53747618e-01f, 1.56839579e-01f, -2.80278195e-02f, 2.15680614e-01f, -1.14928015e-01f,
  -2.96330929e-01f, -7.74785271e-03f, 1.26986116e-01f, 4.44398783e-02f, 4.97945286e-02f, 4.64958232e-03f, -1.92387417e-01f, -6.65099770e-02f, -2.16651782e-02f, 7.45163932e-02f,
  6.83352873e-02f, -1.90373249e-02f, 1.93920150e-01f, -3.68015803e-02f, -2.70478994e-01f, -3.04877348e-02f, -2.30966900e-02f, 2.78518051e-02f, 4.91402373e-02f, -1.22367730e-02f,
  -1.28137380e-01f, 1.48113668e-01f, 6.57413993e-03f, 1.62440557e-02f, 4.53114718e-01f, -1.39246732e-01f, -1.33487046e-01f, 1.41053721e-01f, -3.80821829e-03f, -5.56607358e-02f,
  -5.98245040e-02f, 6.15989342e-02f, -1.20189153e-01f, -1.76037356e-01f, 7.96216875e-02f, 5.24563909e-01f, -9.45557952e-02f, -1.28005892e-01f, -2.58750077e-02f, -1.84867904e-02f,
  2.65051186e-01f, 3.89821112e-01f, 1.68903708e-01f, 1.13858074e-01f, 1.24005385e-01f, 4.58119549e-02f, -1.02810347e-02f, 3.13209325e-01f, 2.41016299e-01f, 1.81184664e-01f,
  1.39651120e-01f, 1.19565362e-02f, 2.98437290e-03f, 1.04717888e-01f, 1.16668925e-01f, -3.06447838e-02f, 2.30975956e-01f, 7.25893751e-02f, -1.04529873e-01f, 5.85720912e-02f,
  4.45334241e-02f, 4.88491394e-02f, 2.50940710e-01f, 3.34577501e-01f, 3.64382789e-02f, 1.14789203e-01f, 3.07522058e-01f, 4.37428728e-02f, 4.25620116e-02f, -2.49118358e-01f,
  1.29148647e-01f, -2.97052324e-01f, -7.65950233e-02f, 4.82537329e-01f, -3.42436939e-01f, 2.12501153e-01f, -1.71755999e-01f, 1.49376944e-01f, -2.94343770e-01f, 2.91614439e-02f,
  1.51522875e-01f, 2.71895994e-03f, 2.07491100e-01f, 1.96370304e-01f, 2.33947754e-01f, -3.72804731e-01f, 4.09076482e-01f, 1.48672223e-01f, -6.81205019e-02f, -5.10946773e-02f,
  -7.14660510e-02f, -1.02211244e-01f, -2.06421409e-02f, -7.98303559e-02f, 3.76075581e-02f, -8.01428482e-02f, 1.90334678e-01f, 2.67069906e-01f, -2.68054277e-01f, 5.88908613e-01f,
  -5.78428023e-02f, 2.09711865e-01f, -1.78274632e-01f, 2.00242326e-02f, 9.77125242e-02f, -2.12323472e-01f, -2.07503423e-01f, 1.04402043e-01f, -8.72076601e-02f, 1.06184572e-01f,
  -3.94680016e-02f, 1.73702136e-01f, 9.97197106e-02f, -1.59547180e-01f, -5.90657024e-03f, -4.55854796e-02f, 3.13949399e-02f, -4.42552567e-02f, 2.18469426e-02f, -1.02692232e-01f,
  3.71185184e-01f, 5.37965149e-02f, -1.52070940e-01f, 4.02529724e-03f, -4.73457277e-02f, -3.97799835e-02f, 6.24128819e-01f, -8.41690525e-02f, 9.89479646e-02f, -2.21087262e-01f,
  -3.59664783e-02f, 2.68865339e-02f, 8.42198357e-02f, -8.70464295e-02f, -3.01284790e-01f, -1.98272049e-01f, -1.25000447e-01f, -5.91787230e-03f, -1.78952903e-01f, -6.55544177e-03f,
  -6.68685064e-02f, -2.50403788e-02f, -5.58791570e-02f, -2.77705848e-01f, 1.66540444e-01f, -1.05611980e-02f, 1.19893633e-01f, -1.46631613e-01f, 1.58170119e-01f, -1.36604905e-01f,
  -1.47802547e-01f, -1.96523052e-02f, 3.84481102e-01f, 7.65667707e-02f, -1.26147926e-01f, -3.60864811e-02f, -8.27599969e-03f, 6.65331334e-02f, -1.15121091e-02f, -2.04216942e-01f,
  4.17114049e-01f, 1.03776343e-01f, 1.78771466e-01f, -1.63033202e-01f, -2.54727751e-01f, -5.52729368e-02f, 6.41656369e-02f, -1.32957533e-01f, 1.55089095e-01f, 3.07359863e-02f,
  4.70147654e-02f, 2.33649969e-01f, 6.26909286e-02f, 9.12464261e-02f, 7.46367080e-03f, -8.45666751e-02f, -2.69884557e-01f, -3.20196569e-01f, 9.43658724e-02f, -4.40647379e-02f,
  2.48183385e-01f, 1.20442137e-01f, -3.43957692e-02f, 4.83401194e-02f, -1.69133842e-02f, -2.30012044e-01f, 9.90281031e-02f, 1.29772380e-01f, -7.39460438e-02f, -6.62566423e-02f,
  -5.17948940e-02f, 6.59623668e-02f, 1.71337664e-01f, -1.24522619e-01f, -2.22188368e-01f, -1.24358319e-01f, 1.05851933e-01f, 3.32344860e-01f, -1.45650625e-01f, 1.51627421e-01f,
  -3.31370205e-01f, -3.06593239e-01f, -6.01121962e-01f, -3.25272866e-02f, 2.50493944e-01f, -1.98849306e-01f, 1.00402005e-01f, -1.36739939e-01f, -5.15567422e-01f, 3.90922874e-02f,
  -4.43392545e-01f, -1.95022359e-01f, -7.24931434e-02f, 3.46548617e-01f, -3.30211818e-01f, -3.50525260e-01f, -3.15350264e-01f, 2.11822838e-01f, -5.46800047e-02f, 6.24267794e-02f,
  -8.67272913e-02f, -9.08487476e-03f, 3.51203606e-02f, 3.77883799e-02f, -1.33402692e-02f, -1.56253755e-01f, -1.44544810e-01f, -9.79253203e-02f, -8.12067613e-02f, -1.20655909e-01f,
  6.77438676e-02f, -1.63467694e-02f, -3.16537291e-01f, -2.24105984e-01f, -2.22364575e-01f, 4.67144959e-02f, -4.61510420e-02f, -2.23291889e-01f, -1.18886285e-01f, 3.48563224e-01f,
  -1.81761071e-01f, -1.40154719e-01f, 2.77266383e-01f, 8.65567476e-02f, 4.51739639e-01f, -1.50727242e-01f, 1.94000438e-01f, 1.38022289e-01f, -1.08165108e-01f, -1.62483737e-01f,
  -1.27992630e-01f, -1.80308267e-01f, -1.07564867e-01f, 9.94076580e-03f, 1.50687143e-01f, 1.10056244e-01f, -1.55383095e-01f, -1.93822742e-01f, -1.25457346e-01f, -1.87969357e-01f,
  -1.95376724e-01f, -2.14675697e-03f, -8.51413012e-02f, -2.39573821e-01f, 1.95754711e-02f, -5.01169227e-02f, -6.29300252e-02f, -5.86548187e-02f, 1.83376251e-03f, 1.38656288e-01f,
  -5.84019601e-01f, -4.27144952e-02f, 1.96154341e-02f, -3.41821648e-02f, 3.33851933e-01f, -9.65817347e-02f, 1.80081770e-01f, -2.55431592e-01f, -2.60190647e-02f, -7.51807392e-02f,
  1.64037012e-02f, 4.69791852e-02f, -1.04340747e-01f, 6.74434826e-02f, -1.91417605e-01f, -1.10473178e-01f, 9.25207958e-02f, -7.59431049e-02f, -1.39695629e-01f, 3.29257876e-01f,
  -7.99529552e-02f, 2.51265354e-02f, -1.15404509e-01f, 3.44998837e-01f, -2.11272940e-01f, 1.98426664e-01f, -6.56262338e-02f, -1.41174212e-01f, 4.59821001e-02f, -5.80840074e-02f,
  6.19796552e-02f, -4.36883457e-02f, -1.83552261e-02f, -2.65057147e-01f, -2.73953438e-01f, -8.70269015e-02f, -2.30893381e-02f, -9.54006985e-02f, -1.95695430e-01f, -1.77453145e-01f,
  1.06849112e-01f, -1.53570399e-01f, -4.88581061e-02f, -2.78000478e-02f, 1.15358271e-03f, -5.97768463e-02f, -1.61729530e-01f, -9.72771719e-02f, -5.51710986e-02f, -6.83339536e-02f,
  -2.01106966e-01f, 2.21197218e-01f, -1.32178083e-01f, 1.30980071e-02f, 1.00418054e-01f, 9.44088772e-02f, 1.48249701e-01f, 5.18745482e-02f, -2.70179063e-01f, -2.27345839e-01f,
  5.26096262e-02f, 9.47155356e-02f, -1.03062131e-01f, -2.51353621e-01f, -3.28172147e-01f, 2.38156006e-01f, 2.47683972e-01f, 3.26336920e-02f, -2.17122942e-01f, 2.07732111e-01f,
  2.66063005e-01f, 1.62108839e-01f, -1.83734223e-01f, -1.22724630e-01f, -5.55729605e-02f, 2.01121643e-01f, -1.30648464e-01f, -1.27395734e-01f, 1.64296061e-01f, 3.09990104e-02f,
  3.35331798e-01f, 1.16410948e-01f, -8.07561819e-03f, -1.04749545e-01f, 1.88752547e-01f, -1.01073436e-01f, 9.13546905e-02f, 3.41816135e-02f, 1.36867300e-01f, 3.16545516e-02f,
  2.69255668e-01f, -1.70922592e-01f, -9.03656334e-02f, -1.20475106e-01f, -6.58143461e-02f, -1.05143629e-01f, 1.30116701e-01f, 9.82873216e-02f, -5.02607748e-02f, 1.47727564e-01f,
  -1.99108198e-01f, -8.61971080e-02f, 5.54455854e-02f, 1.63893208e-01f, -1.25266612e-01f, -7.21234977e-02f, -2.20312383e-02f, 1.51901850e-02f, -1.57536119e-01f, 1.04913875e-01f,
  -1.19263954e-01f, 2.04144511e-02f, -1.35109574e-01f, -1.68536037e-01f, 3.33153531e-02f, 4.87352312e-01f, 3.15640531e-02f, -3.62731740e-02f, 3.88664305e-01f, 8.62992778e-02f,
  -1.11460112e-01f, -6.61000935e-03f, -1.54197052e-01f, 1.56778350e-01f, 3.75869423e-02f, -2.51685292e-01f, -2.25896332e-02f, -5.55482544e-02f, 4.46729600e-01f, -5.25465310e-02f,
  2.46820711e-02f, 1.12448335e-01f, -2.24508271e-01f, 1.93881374e-02f, 3.98345321e-01f, 2.19160751e-01f, -1.52677938e-01f, -3.33795510e-02f, -1.45569995e-01f, -1.40780658e-01f,
  1.05005436e-01f, -2.15921611e-01f, 6.44073263e-02f, 1.95914045e-01f, -1.59039080e-01f, 6.45943135e-02f, -9.90299210e-02f, -2.48578504e-01f, -5.54063767e-02f, -8.40349719e-02f,
  -1.03352532e-01f, -5.87335899e-02f, 1.97555289e-01f, 1.73854530e-01f, 9.66157988e-02f, 6.10020151e-03f, -1.37974873e-01f, -3.50224614e-01f, -3.67465466e-02f, 1.05543889e-01f,
  3.76765653e-02f, 1.57949388e-01f, 1.84159338e-01f, 2.56376285e-02f, -1.81262881e-01f, -9.60650854e-03f, 1.02951795e-01f, -3.30482610e-03f, -7.98856616e-02f, -5.49038611e-02f,
  3.57506727e-03f, 8.85714442e-02f, 5.60130440e-02f, 6.76217601e-02f, -1.04285792e-01f, 6.08957820e-02f, 1.04555458e-01f, 2.05134705e-01f, 5.18058660e-03f, 1.37957156e-01f,
  3.07676733e-01f, 4.76016551e-01f, 4.38055903e-01f, 3.69147420e-01f, 1.00162201e-01f, 2.70220548e-01f, 4.07240354e-02f, 2.40559503e-01f, -2.91087955e-01f, -4.48274255e-01f,
  -9.05611813e-02f, -2.09339827e-01f, 6.18584082e-02f, -4.16414827e-01f, 4.75053012e-01f, -4.01986659e-01f, -3.57611328e-01f, 1.24695711e-01f, -2.08353058e-01f, -2.49652922e-01f,
  2.81605124e-01f, -1.28371164e-01f, 1.31093234e-01f, 2.36526638e-01f, -1.05559371e-01f, -1.46909291e-02f, -4.52563316e-02f, 1.03292964e-01f, -8.76575783e-02f, -1.37057662e-01f,
  -2.49060839e-02f, -1.32863343e-01f, 3.64901796e-02f, 2.11554673e-03f, 1.99423537e-01f, -1.36691093e-01f, 9.75383967e-02f, -1.52885541e-01f, -3.08994744e-02f, -2.14363620e-01f,
  -4.75277677e-02f, -8.13827589e-02f, -6.66668415e-02f, -7.71589726e-02f, -4.14334424e-02f, 2.02525258e-01f, -5.84143251e-02f, -1.96090760e-03f, -9.52248201e-02f, -8.71607363e-02f,
  -2.59846589e-03f, 2.87065152e-02f, -4.30228747e-02f, 1.91786870e-01f, 2.10461561e-02f, 5.01078486e-01f, -1.45785809e-01f, -1.79543823e-01f, -7.50328824e-02f, 4.49204862e-01f,
  -2.58347511e-01f, 1.96796209e-01f, 1.26200438e-01f, -4.44662459e-02f, -9.86170173e-02f, 3.22624370e-02f, 5.71152009e-02f, -1.11321159e-01f, -3.47453505e-02f, 3.17500621e-01f,
  2.55195536e-02f, -9.98165682e-02f, -7.27490410e-02f, -1.42431840e-01f, -1.02782808e-01f, -6.96407305e-03f, -1.89027786e-01f, -1.21844150e-01f, -1.56826973e-01f, -2.18567297e-01f,
  -9.82499868e-02f, 2.48318776e-01f, -1.39264673e-01f, 6.33659633e-03f, -1.83143973e-01f, 3.84078473e-02f, -1.28342900e-02f, -1.68768868e-01f, -4.33387570e-02f, -7.20144361e-02f,
  -1.35086983e-01f, 2.05389634e-01f, -1.70838192e-01f, 8.93986747e-02f, 9.09532309e-02f, -9.37362015e-02f, -1.82682648e-01f, -1.66937038e-02f, 3.16281438e-01f, -6.24298640e-02f,
  1.50116786e-01f, -2.59407628e-02f, -7.62651041e-02f, -9.83176306e-02f, 5.54436706e-02f, -2.63490528e-01f, 3.04539502e-02f, 5.22457948e-03f, 1.28416754e-02f, 7.74032399e-02f,
  -2.81165928e-01f, 3.54044557e-01f, -5.13079837e-02f, -1.34236723e-01f, 3.72360721e-02f, -6.79833144e-02f, 9.39718932e-02f, 8.96705911e-02f, 9.94041041e-02f, 1.57643527e-01f,
  8.85371193e-02f, 1.17109902e-01f, 4.85105515e-02f, -1.81939736e-01f, 3.87742594e-02f, -1.87069714e-01f, 1.21405669e-01f, -2.82275677e-01f, -2.58144438e-01f, -1.77537482e-02f,
  -5.59281766e-01f, -3.70941609e-01f, 2.37240627e-01f, 6.18457608e-02f, -1.55297801e-01f, -4.98352200e-01f, -3.98657359e-02f, 4.16637838e-01f, 3.37505430e-01f, 9.57005396e-02f,
  -2.91785687e-01f, -1.85012981e-01f, 6.90612644e-02f, 3.87778990e-02f, -1.13101237e-01f, -2.89612021e-02f, -2.38045931e-01f, 5.80542274e-02f, -4.55902427e-01f, 2.26227373e-01f,
  -3.79691929e-01f, -3.59644473e-01f, -1.48211911e-01f, 3.98316473e-01f, -2.94601414e-02f, 5.95131796e-03f, -6.55220300e-02f, -1.77377611e-02f, -9.12814066e-02f, 9.46928095e-03f,
  -4.03212383e-02f, -1.51201487e-01f, 6.50751591e-02f, -1.94295079e-01f, 1.68383531e-02f, 3.87028493e-02f, 1.08514205e-01f, -2.39217624e-01f, -1.83773905e-01f, -2.24575877e-01f,
  5.29459976e-02f, 6.20648563e-02f, 1.38205171e-01f, -2.40565926e-01f, -1.89603716e-02f, -5.66194579e-02f, -1.38740703e-01f, 3.36997584e-02f, -9.13052410e-02f, 4.09508497e-01f,
  6.15316257e-02f, 4.67206128e-02f, -6.00927770e-02f, -1.06126010e-01f, 6.03816099e-02f, 1.99908048e-01f, 9.00095776e-02f, -1.52096286e-01f, 2.35714078e-01f, 2.91435897e-01f,
  -1.53209955e-01f, -8.21964536e-03f, 1.21573515e-01f, -3.70927379e-02f, 4.85987775e-02f, 1.31846115e-01f, -1.18117534e-01f, -2.01822236e-01f, -1.27872333e-01f, -1.58445954e-01f,
  -9.90856253e-03f, 4.41002786e-01f, -5.02827987e-02f, 2.96231419e-01f, 3.20906639e-01f, -1.64109051e-01f, -1.12146556e-01f, 5.97032765e-03f, 2.81755906e-02f, -4.49585281e-02f,
  -1.51733637e-01f, 1.32131293e-01f, 1.08808964e-01f, 1.90939397e-01f, -4.99314815e-02f, -1.45596161e-01f, -9.83494669e-02f, 1.12056740e-01f, -8.88256431e-02f, -2.31811404e-01f,
  1.14144251e-01f, -7.61241689e-02f, -4.27471437e-02f, 2.60132372e-01f, -5.91396913e-02f, 2.16077462e-01f, -2.22081542e-01f, 1.74250782e-01f, -2.69967020e-02f, -1.45859703e-01f,
  1.17907785e-02f, -7.00347200e-02f, 9.53200534e-02f, 7.61387199e-02f, 1.09989107e-01f, 1.22593291e-01f, -1.08966883e-02f, -2.18217727e-02f, 1.87705681e-02f, 1.05376564e-01f,
  -9.59632620e-02f, 4.73090960e-03f, 1.26401940e-02f, 1.38123259e-01f, 1.13389082e-01f, 1.11073358e-02f, 5.65263396e-03f, -7.30927065e-02f, -5.51805049e-02f, 5.88670233e-03f,
  1.42062753e-01f, -5.51981255e-02f, -5.04677109e-02f, 1.24670222e-01f, 7.08575249e-02f, 3.40247035e-01f, 3.34410369e-01f, 3.19593757e-01f, -9.97032300e-02f, -2.54374415e-01f,
  1.11885101e-01f, 3.08089733e-01f, 3.30152810e-01f, 2.21033022e-01f, 1.12147748e-01f, 3.78504843e-01f, 3.50381285e-02f, 1.18839316e-01f, -1.21408217e-01f, 1.13433965e-01f,
  -1.20180950e-01f, -3.56681287e-01f, 3.59103441e-01f, -1.14349358e-01f, -2.55368561e-01f, -9.99472365e-02f, 2.81011075e-01f, -3.77758920e-01f, -1.04560815e-01f, -2.52957791e-01f,
  1.96092293e-01f, -1.47595301e-01f, -5.08179180e-02f, 1.32082343e-01f, -1.20774314e-01f, 1.02757243e-02f, 1.36260301e-01f, -2.74019182e-01f, 5.75506568e-01f, -2.01939806e-01f,
  1.71470046e-01f, -4.22214903e-02f, 2.30127260e-01f, -1.31275862e-01f, -3.62185016e-02f, -2.76976135e-02f, 4.21469621e-02f, -4.29903343e-02f, 6.20498657e-02f, -1.23424880e-01f,
  4.76638302e-02f, -1.48566794e-02f, -1.07397199e-01f, -1.24900535e-01f, -1.28506064e-01f, 1.81596670e-02f, -1.25631288e-01f, -7.91360512e-02f, -5.31899892e-02f, -8.59730765e-02f,
  -7.19693974e-02f, 8.41848329e-02f, 2.54907995e-01f, -1.97790209e-02f, 3.46704960e-01f, -8.62403214e-02f, -2.16391623e-01f, -1.96889371e-01f, -8.18610415e-02f, -1.65573016e-01f,
  -1.23526752e-01f, -2.95676067e-02f, -3.69202569e-02f, 3.30077261e-01f, -1.86127592e-02f, -8.95895511e-02f, -4.85886447e-02f, -5.33804744e-02f, -2.25163046e-02f, 1.43751025e-01f,
  -1.66945100e-01f, -6.14003129e-02f, -1.11886568e-01f, -1.07448928e-01f, -1.74637213e-01f, -4.03874367e-02f, -4.49488126e-03f, 2.52000630e-01f, -6.45442754e-02f, -1.12445727e-01f,
  -1.39992431e-01f, -5.69391325e-02f, 4.92498055e-02f, -9.99631882e-02f, 3.58671069e-01f, -4.01143581e-02f, -4.31453288e-02f, 1.18413247e-01f, -1.74977049e-01f, 3.20542902e-01f,
  -1.27637058e-01f, -8.02262723e-02f, 2.48628378e-01f, -4.52616997e-02f, -2.10285932e-01f, -7.21429512e-02f, -2.57125050e-02f, -1.78774893e-02f, 1.21001557e-01f, 5.39037026e-02f,
  5.67715578e-02f, -3.01079657e-02f, -5.80850430e-03f, 5.65344654e-02f, 5.11097163e-02f, 2.70170961e-02f, 9.05229375e-02f, -2.55584903e-02f, -4.01121490e-02f, 1.14494875e-01f,
  -2.39042729e-01f, -6.52261972e-02f, -1.83000252e-01f, 1.68326691e-01f, -5.83705045e-02f, 1.62495375e-01f, 9.02247652e-02f, 2.80674193e-02f, -4.66309935e-02f, 7.85740986e-02f,
  8.29295069e-02f, 6.04022928e-02f, -6.26036152e-02f, 1.81679189e-01f, -2.13089496e-01f, 2.63334930e-01f, 1.66147649e-01f, 8.95317048e-02f, -1.91685736e-01f, -2.27134928e-01f,
  -1.74044028e-01f, -2.57215053e-01f, -1.89502373e-01f, -2.48138636e-01f, -3.18037160e-02f, -2.95315236e-01f, 1.21414267e-01f, -2.94580162e-01f, -1.46287203e-01f, 1.86861604e-01f,
  2.69095972e-02f, -7.05869943e-02f, 2.31356800e-01f, -3.90567452e-01f, 2.95962512e-01f, 2.77761191e-01f, -1.70497969e-01f, 2.25168034e-01f, 8.51682797e-02f, 4.55705374e-01f,
  2.96625704e-01f, 7.22951116e-03f, -2.89455235e-01f, -1.56426638e-01f, -6.27506450e-02f, -4.15141545e-02f, 7.18152756e-03f, -1.66477785e-01f, -2.30915323e-01f, -2.59135291e-02f,
  -7.97217116e-02f, 1.04996718e-01f, 1.72149584e-01f, -1.04239039e-01f, 7.55531937e-02f, 5.00800490e-01f, -7.66418651e-02f, -8.69466960e-02f, 1.43645518e-02f, 2.13413939e-01f,
  1.76335096e-01f, 1.07983634e-01f, 2.61148632e-01f, 1.74272596e-03f, -4.91552390e-02f, 2.58849740e-01f, 5.50459558e-03f, -2.01670937e-02f, -1.80291250e-01f, -2.20310122e-01f,
  -1.57697782e-01f, -9.11841467e-02f, -9.05376375e-02f, 1.49285235e-02f, -1.63948521e-01f, -1.88904226e-01f, -9.63833034e-02f, -1.33443445e-01f, -1.12739295e-01f, 5.88327050e-02f,
  -1.47077709e-01f, -1.18062697e-01f, -7.26923300e-03f, 3.42687041e-01f, 1.51625380e-01f, 1.92965165e-01f, -1.97214857e-02f, -1.69358090e-01f, 1.82355538e-01f, -1.33233899e-02f,
  -7.48486593e-02f, -1.21597327e-01f, 1.40565187e-01f, -1.20376348e-01f, 1.27623141e-01f, 5.19753732e-02f, -5.77330962e-02f, -7.84792528e-02f, 6.46924198e-01f, 1.00787833e-01f,
  -1.40906900e-01f, -9.19941440e-02f, -2.87830606e-02f, 1.72504008e-01f, -1.56096920e-01f, -2.47193247e-01f, 1.15720354e-01f, 2.27079354e-02f, -4.53569479e-02f, -2.19161242e-01f,
  -6.27563596e-02f, 4.27538762e-03f, 1.59604132e-01f, -1.50018170e-01f, -2.63991296e-01f, -5.64573482e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.21355110e-02f, -5.18143363e-03f, 2.51592454e-02f, -6.87975436e-02f, -3.90709564e-03f, 1.07900366e-01f, 2.64430121e-02f, -6.28594831e-02f, 9.17246193e-02f, 6.83134869e-02f,
  -4.04382348e-02f, 5.76951467e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    