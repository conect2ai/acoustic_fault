/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.65877983e-01f, 1.99211180e-01f, -2.49773502e-01f, 1.97860718e-01f, 7.46631995e-02f, -3.66575941e-02f, -4.47710790e-02f, 6.32328764e-02f, 5.86373694e-02f, 7.68628269e-02f,
  1.65379584e-01f, 2.14715019e-01f, 1.43781692e-01f, 5.81928790e-02f, 7.31628761e-02f, -3.59009132e-02f, -5.52528575e-02f, -1.47965327e-01f, -8.43900517e-02f, -1.70540392e-01f,
  2.52028145e-02f, 1.61183566e-01f, 1.56963989e-01f, 4.81584994e-03f, -6.35980815e-02f, 6.00919984e-02f, 4.33110781e-02f, 1.40457958e-01f, -3.59006622e-03f, -3.86552401e-02f,
  -1.08078882e-01f, -3.95703241e-02f, -3.72451432e-02f, 1.02322027e-01f, 6.16554506e-02f, 4.08493318e-02f, 2.61030998e-02f, -4.00874689e-02f, 4.26694714e-02f, 3.21879201e-02f,
  7.55768046e-02f, 7.98501540e-03f, 4.07032892e-02f, 4.16924730e-02f, 9.03928131e-02f, -2.26830617e-02f, 5.07514328e-02f, -4.56718765e-02f, 2.11607199e-02f, 4.18129265e-02f,
  5.81711009e-02f, 4.97032627e-02f, -5.16293086e-02f, 8.24442953e-02f, 1.99054889e-02f, 4.29129042e-02f, 4.96501364e-02f, -1.49744265e-02f, -5.98730631e-02f, 3.24137956e-02f,
  4.00743373e-02f, 5.51962443e-02f, 2.81741973e-02f, -6.65212870e-02f, -1.76552366e-02f, -3.04359235e-02f, 7.07024410e-02f, 1.08505405e-01f, -2.02340749e-03f, -8.27614814e-02f,
  -1.21833317e-01f, -3.92274000e-02f, -1.12145935e-04f, -8.42170492e-02f, -2.91812681e-02f, -6.48243204e-02f, -1.44019921e-03f, -4.89815585e-02f, 2.48612911e-02f, 3.32772429e-03f,
  -2.23992560e-02f, -5.37665486e-02f, -2.51578204e-02f, -5.02462722e-02f, -1.08072519e-01f, -6.84033856e-02f, -5.99320084e-02f, -7.73840100e-02f, -9.17419977e-03f, 9.11455601e-03f,
  2.18333289e-01f, 1.19285151e-01f, 1.57801047e-01f, 1.38213664e-01f, 1.66065589e-01f, 2.11274475e-01f, 1.56745970e-01f, 1.82940423e-01f, 9.78231356e-02f, 2.23741215e-02f,
  1.29624456e-01f, 1.02691114e-01f, 1.29771560e-01f, 1.47789776e-01f, 7.79753253e-02f, 1.15876466e-01f, 1.95085093e-01f, 6.04017861e-02f, 1.71191379e-01f, 1.93062276e-01f,
  1.92904428e-01f, 1.64345101e-01f, 2.92970330e-01f, 2.04172567e-01f, 9.59129483e-02f, 1.20282106e-01f, 7.76364058e-02f, 1.89407229e-01f, 7.24973753e-02f, 2.19686031e-01f,
  -1.17950052e-01f, -1.45336019e-03f, -2.95872867e-01f, -3.47690582e-02f, 1.18877642e-01f, 2.22178534e-01f, 1.90000564e-01f, 2.30565578e-01f, 1.29453868e-01f, 2.93889008e-02f,
  5.70082814e-02f, 1.45311296e-01f, 7.62100890e-02f, 9.04624760e-02f, 1.31989196e-01f, 6.87412024e-02f, 1.03461601e-01f, -2.45614648e-02f, 1.06024388e-02f, 1.53371468e-01f,
  1.71539545e-01f, -1.14775389e-01f, -2.89651781e-01f, -3.43631804e-02f, -6.68215156e-02f, -4.48537432e-02f, -2.40822017e-01f, -1.06907360e-01f, -7.87042156e-02f, -2.56544143e-01f,
  -1.77118316e-01f, -2.63757646e-01f, 9.36690494e-02f, -2.03046128e-02f, -7.83063844e-02f, -1.35243267e-01f, -5.40780276e-02f, -1.76974624e-01f, -1.74208805e-02f, -7.87116885e-02f,
  -5.58117516e-02f, -8.78596008e-02f, 5.26008755e-02f, -6.81900755e-02f, -6.88939691e-02f, -3.09668537e-02f, 5.13354763e-02f, -1.20594114e-01f, -9.29436535e-02f, 3.58497947e-02f,
  1.16030842e-01f, -6.10596612e-02f, -6.71428069e-03f, 1.31163284e-01f, -2.49008066e-04f, 5.80397137e-02f, -1.00321174e-01f, -1.59919381e-01f, -1.18916631e-01f, -1.80131391e-01f,
  5.29917181e-02f, -2.01905072e-02f, -1.82880331e-02f, 2.84011313e-03f, 3.08068153e-02f, 4.00424525e-02f, 5.11035398e-02f, 1.08046927e-01f, 4.94163744e-02f, -2.64647789e-02f,
  6.23966344e-02f, 3.51277143e-02f, -5.13661886e-03f, 5.57559542e-03f, 1.02366116e-02f, -3.07989530e-02f, 9.35238320e-03f, 7.84136355e-03f, 3.47181149e-02f, -2.25168876e-02f,
  3.59656475e-02f, 4.50140759e-02f, -2.33049300e-02f, 1.75754316e-02f, 6.14227206e-02f, 1.06736310e-01f, -3.17550600e-02f, 2.52074264e-02f, -4.51609343e-02f, 3.58280167e-02f,
  -7.69592002e-02f, 7.39253238e-02f, -1.43523529e-01f, 2.22041700e-02f, -7.21032470e-02f, 1.60259567e-02f, -7.03084748e-03f, 3.50075699e-02f, 1.38597854e-03f, 2.30085123e-02f,
  3.12300995e-02f, 2.97457427e-02f, -4.60672677e-02f, -3.01025882e-02f, -1.99164194e-03f, 1.69532727e-02f, 2.89348848e-02f, 9.22075883e-02f, 3.06133162e-02f, -2.69166697e-02f,
  6.50592670e-02f, -2.81893974e-03f, -7.20238639e-03f, -3.79913412e-02f, -4.72353734e-02f, 3.68075706e-02f, -6.26400411e-02f, -9.21897143e-02f, -4.39969152e-02f, -4.30120192e-02f,
  5.83459854e-01f, -3.27198118e-01f, -2.75833905e-01f, 1.06996164e-01f, -2.68382192e-01f, -2.45730489e-01f, -4.22325104e-01f, -1.68011859e-01f, 3.37394439e-02f, -1.04886100e-01f,
  -1.64991498e-01f, 1.03455849e-01f, 1.36783034e-01f, 1.33187532e-01f, 6.26646280e-02f, -2.62723505e-01f, -1.58563077e-01f, 2.17935979e-01f, 2.29021266e-01f, 5.85787185e-02f,
  7.33952001e-02f, 9.81896147e-02f, 2.56132752e-01f, 1.61285058e-01f, -6.72755837e-02f, 8.88576582e-02f, -1.56043410e-01f, 7.50220101e-03f, -1.22060284e-01f, 8.67479295e-02f,
  3.01336765e-01f, -4.94894311e-02f, 1.00434378e-01f, 1.25545794e-02f, -1.33105298e-03f, 1.20503254e-01f, 1.69653185e-02f, -1.25686987e-03f, 3.34953777e-02f, 7.79769383e-03f,
  -1.31816277e-02f, 6.87733367e-02f, -4.21892889e-02f, 1.15121268e-02f, 1.07935136e-02f, -6.41152710e-02f, 4.92037907e-02f, 1.10156976e-01f, 2.15166416e-02f, 1.27958078e-02f,
  -9.44620967e-02f, -1.40241966e-01f, -8.65396187e-02f, -1.65565014e-01f, 1.41130453e-02f, 3.35807353e-02f, -4.16964740e-02f, -3.90542261e-02f, -1.16258822e-02f, 1.12053722e-01f,
  5.64683564e-02f, 1.63430981e-02f, -1.07520986e-02f, 1.31224208e-02f, 1.91863943e-02f, -3.22321914e-02f, 2.26550587e-02f, 2.00232137e-02f, -1.29544055e-02f, 1.39402377e-03f,
  -1.85643591e-03f, 2.91299680e-03f, 5.47257327e-02f, 1.31700896e-02f, -3.79562192e-02f, -3.05278078e-02f, 2.17039976e-02f, 4.04809155e-02f, -8.96149036e-03f, -4.72676903e-02f,
  4.31103399e-03f, 3.71443219e-02f, 2.61314549e-02f, -1.63113456e-02f, -3.85055281e-02f, -8.32859986e-03f, -3.13352160e-02f, -6.99456707e-02f, -2.13331282e-02f, -4.83259782e-02f,
  9.69501063e-02f, -2.35511243e-01f, 1.29640222e-01f, -1.29735202e-03f, -1.85919162e-02f, 6.26113042e-02f, 6.90226331e-02f, 7.85554573e-02f, -1.30837457e-02f, 4.96332906e-02f,
  -5.67836128e-02f, 9.51017514e-02f, -2.87129674e-02f, 2.02159919e-02f, 4.80988324e-02f, -4.24919501e-02f, -3.49525958e-02f, 8.57349485e-02f, -4.66734543e-02f, 8.14827811e-03f,
  -3.12057231e-02f, -2.12636068e-02f, 2.21949369e-02f, -5.44564165e-02f, 2.26353407e-02f, 6.52904138e-02f, 2.07356997e-02f, 3.26468721e-02f, -4.26401310e-02f, 8.60136524e-02f,
  6.57954633e-01f, 1.75301120e-01f, 1.50491238e-01f, 3.94595303e-02f, -1.73152447e-01f, 8.86321366e-02f, 4.88833413e-02f, 7.25437403e-02f, -6.82161078e-02f, 1.17593780e-01f,
  -4.18777838e-02f, -1.57826934e-02f, 4.62131314e-02f, -1.07603319e-01f, 6.82747215e-02f, 8.09139386e-02f, -1.67152226e-01f, -1.25609785e-01f, 2.90824883e-02f, -6.76823109e-02f,
  -1.75045207e-01f, -1.58301786e-01f, 3.81982587e-02f, -1.03507027e-01f, -2.46195793e-02f, -1.22800078e-02f, -8.11230391e-02f, -6.49643689e-02f, -1.34619758e-01f, -6.81870729e-02f,
  2.27927774e-01f, 1.10857710e-01f, -1.24084346e-01f, -8.15310031e-02f, -3.78289931e-02f, 6.08858690e-02f, 8.43886510e-02f, 2.56358739e-03f, -5.43978624e-02f, -2.73524933e-02f,
  -9.68568251e-02f, -3.94987203e-02f, -1.10978007e-01f, -1.36526838e-01f, 1.78876352e-02f, 7.20194578e-02f, 2.03336444e-04f, 2.39123013e-02f, -3.30607295e-02f, 1.06287219e-01f,
  -5.21447472e-02f, -3.86703722e-02f, 5.78270704e-02f, -6.26767352e-02f, -2.26944815e-02f, -1.33977354e-01f, 1.64868329e-02f, 2.53590066e-02f, -7.08948355e-03f, -4.75364253e-02f,
  -3.25412899e-02f, -2.67623290e-02f, 5.64646646e-02f, 1.51479244e-02f, 2.48999372e-02f, -4.14048918e-02f, -7.30780046e-03f, 3.01867519e-02f, -7.17076287e-02f, 8.22111294e-02f,
  7.19150901e-02f, 5.05057350e-02f, -6.54721409e-02f, 1.19327918e-01f, -4.78537865e-02f, 2.71902401e-02f, 3.01865209e-02f, 1.94434747e-02f, -2.97974236e-02f, -1.51798753e-02f,
  5.20290695e-02f, 1.78521071e-02f, -2.01062276e-03f, 2.76146140e-02f, 1.99006479e-02f, 7.02838078e-02f, 3.97828408e-02f, 2.96442467e-03f, 2.96539329e-02f, 6.09874679e-03f,
  -6.89971745e-02f, -1.20997488e-01f, 1.01122886e-01f, 8.60228986e-02f, 5.49594797e-02f, 4.08797078e-02f, -4.06537317e-02f, 4.31695804e-02f, 8.31785426e-02f, -1.85385440e-02f,
  7.60719404e-02f, 7.45144859e-02f, 7.60399774e-02f, 1.64553523e-02f, 1.29865753e-02f, 2.02394314e-02f, 6.21179268e-02f, 1.12405986e-01f, -5.05419681e-03f, 2.06853040e-02f,
  3.13698221e-03f, 3.88609171e-02f, 3.08299750e-01f, 1.08492032e-01f, 3.48744653e-02f, 8.80327448e-02f, 1.64418191e-01f, 1.52491748e-01f, 1.71209916e-01f, 2.63663918e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.14863288e-01f, -1.20955229e-01f, 3.19699347e-01f, 1.27662301e-01f, -5.11039328e-03f, 4.55566794e-02f, 2.88685262e-01f, 3.57132107e-01f, 1.88058764e-02f, 1.29942998e-01f,
  -1.85453519e-01f, -5.09799659e-01f, -1.19336620e-01f, -2.06087112e-01f, 2.58308444e-02f, -2.36351397e-02f, -1.18184522e-01f, 1.49815693e-01f, 1.79638311e-01f, -1.03757955e-01f,
  -4.44289505e-01f, 2.28287369e-01f, 5.72053134e-01f, 1.55916885e-01f, -1.49392679e-01f, -2.23776519e-01f, 2.11712986e-01f, -4.52848896e-03f, -1.84021696e-01f, -4.00721461e-01f,
  -1.71176940e-01f, 2.50777185e-01f, -2.14615852e-01f, 2.06654631e-02f, -1.32134736e-01f, -7.02235848e-03f, -1.46623015e-01f, 5.21154329e-02f, -3.50456163e-02f, 3.31302583e-02f,
  -4.35770266e-02f, -6.48670644e-02f, -5.49113974e-02f, -4.79058735e-02f, 1.37971073e-01f, -3.79851162e-02f, 1.84169948e-01f, 1.25760719e-01f, 6.56102002e-02f, -4.83464263e-02f,
  -4.01676208e-01f, -1.49802670e-01f, 2.51683623e-01f, 1.59831926e-01f, 5.70423494e-04f, 2.52129808e-02f, 4.45376709e-02f, -8.90197407e-05f, 1.83352455e-01f, 1.71273947e-01f,
  -7.64492229e-02f, 7.71255419e-02f, 4.84740585e-02f, 3.77709530e-02f, 1.09279081e-01f, 1.37397624e-03f, -1.16727829e-01f, -4.48510163e-02f, 4.52442318e-02f, 1.42309442e-01f,
  -1.08302228e-01f, 7.67440945e-02f, -1.49146626e-02f, -1.66803040e-02f, -6.51455745e-02f, 1.14592448e-01f, -1.04115047e-01f, 3.64572890e-02f, 1.46690058e-02f, 1.00500230e-02f,
  3.42423841e-02f, -2.22709700e-02f, 4.06038649e-02f, -5.81141189e-02f, -1.69101208e-02f, 3.07360310e-02f, -3.48163769e-03f, -2.00249366e-02f, 4.36186306e-02f, 6.78541884e-02f,
  -7.20322430e-02f, 1.02997564e-01f, -3.83156165e-02f, -1.15964010e-01f, 7.46729076e-02f, -8.77121165e-02f, 2.36581340e-02f, 4.49323356e-02f, -1.72549590e-01f, -1.31642595e-01f,
  -8.35153461e-02f, -7.07850009e-02f, 2.42532603e-02f, 4.20872904e-02f, -6.61963820e-02f, 5.47214895e-02f, -1.02376066e-01f, -1.08013563e-01f, -6.79270551e-02f, -1.18169062e-01f,
  -2.21830428e-01f, 8.61174986e-02f, 1.39135063e-01f, 9.52276886e-02f, -1.94634616e-01f, 2.62533221e-02f, 2.29102913e-02f, -4.08411920e-02f, 5.59950247e-02f, 1.99167714e-01f,
  -1.04846931e+00f, -4.34489399e-01f, -2.59327054e-01f, -8.06149065e-01f, -3.37276518e-01f, 1.69795565e-02f, -2.39231348e-01f, 8.72663409e-03f, -2.42661297e-01f, -6.49288952e-01f,
  -2.43074179e-01f, 1.23221144e-01f, -3.81524742e-01f, 7.06125274e-02f, 1.43123120e-01f, -4.51318055e-01f, -5.10189056e-01f, -5.88263310e-02f, 6.01817012e-01f, 5.64800024e-01f,
  7.69882277e-02f, -2.85563499e-01f, 1.05597228e-01f, 1.77245140e-01f, -4.08197552e-01f, -2.03196391e-01f, -5.73009312e-01f, -3.93930823e-01f, -1.19213685e-01f, -9.37059581e-01f,
  -1.15851529e-01f, -3.08564842e-01f, 9.24896449e-02f, -2.51471009e-02f, -1.13276497e-01f, 1.28338963e-01f, -7.84704760e-02f, -2.14541197e-01f, -2.47646347e-02f, 4.43787128e-03f,
  -1.17638938e-01f, 7.51429647e-02f, -3.45091932e-02f, 3.28411497e-02f, 5.45291007e-02f, 8.17780793e-02f, 2.70596109e-02f, -5.25156930e-02f, 5.46823516e-02f, 9.18673873e-02f,
  2.40702797e-02f, -1.46585748e-01f, 1.52085081e-01f, 2.60628849e-01f, 2.97717541e-01f, 1.41910911e-01f, 2.19624564e-02f, 1.84099898e-01f, 2.74547964e-01f, -3.16782743e-01f,
  -3.26615456e-03f, 1.91696621e-02f, -5.18301362e-03f, -2.38619801e-02f, 4.57575284e-02f, -3.50820310e-02f, -4.84713800e-02f, -1.18453689e-01f, 3.01395147e-03f, 6.29655942e-02f,
  -7.58037046e-02f, 6.12844853e-03f, 9.45791975e-02f, -1.14268750e-01f, -4.11481038e-02f, -1.11007601e-01f, -2.52261907e-02f, -1.78025141e-02f, 1.09898075e-01f, -8.58394653e-02f,
  2.97398977e-02f, 4.93278578e-02f, -3.25599313e-02f, 8.35146308e-02f, 3.41142379e-02f, -1.62103564e-01f, 4.82571125e-02f, 1.56644449e-01f, 3.50686498e-02f, -1.54632395e-02f,
  -2.16318831e-01f, 2.05550417e-01f, -2.29033187e-01f, 9.23539922e-02f, -9.92550924e-02f, 1.92698464e-02f, -5.01577035e-02f, 7.37945735e-02f, -4.75119650e-02f, 1.34719536e-01f,
  2.35678837e-01f, 3.59673006e-03f, -1.19069964e-02f, 1.05463609e-01f, 6.95110634e-02f, 5.65390252e-02f, -8.62273201e-02f, -2.07682922e-01f, 1.21959813e-01f, 1.29227847e-01f,
  1.06300078e-02f, -1.91860279e-04f, -3.26849110e-02f, -9.72443745e-02f, 1.13176689e-01f, 6.43164814e-02f, 4.20891754e-02f, -1.66143347e-02f, 5.96136004e-02f, -2.32802212e-01f,
  -3.00002843e-01f, -4.29379255e-01f, 2.01762110e-01f, 2.62213647e-01f, 2.23345697e-01f, -1.19432688e-01f, -8.00260305e-01f, -3.32224786e-01f, 2.59943187e-01f, -2.25585580e-01f,
  -4.22981977e-02f, 2.07377672e-01f, 2.19352096e-01f, -6.33076429e-02f, -3.02070826e-01f, -5.01873434e-01f, 5.82309477e-02f, 1.46342054e-01f, -5.81382122e-03f, -4.30012077e-01f,
  -4.63025868e-02f, 1.79587305e-01f, 4.41078812e-01f, 2.01714560e-01f, -1.80227101e-01f, 1.28367960e-01f, 4.77716513e-02f, 1.11718073e-01f, -1.62773535e-01f, -1.87260956e-01f,
  -5.49378581e-02f, -2.55601674e-01f, -2.30841096e-02f, 5.22198193e-02f, 1.73300549e-01f, -4.35194224e-02f, -1.93449318e-01f, -2.43916195e-02f, 7.87080079e-03f, 8.34229216e-03f,
  1.18119143e-01f, 8.51278901e-02f, 2.98137479e-02f, 1.24635726e-01f, -5.99893415e-03f, -5.43676503e-02f, -2.46667564e-02f, -4.33851406e-02f, -6.11252226e-02f, -1.38937876e-01f,
  -8.92391875e-02f, -7.91557580e-02f, 1.93317537e-03f, -8.44961479e-02f, -1.27354175e-01f, 1.51315540e-01f, -3.70468460e-02f, -1.53276905e-01f, 7.68258572e-02f, -7.68341273e-02f,
  -5.45258112e-02f, 1.97922941e-02f, 5.21399546e-03f, -1.40904635e-02f, -8.03684443e-03f, 3.11663635e-02f, -2.62096189e-02f, 4.14371565e-02f, -7.12475181e-02f, 2.79970802e-02f,
  -3.08434349e-02f, 1.62097923e-02f, 4.71632276e-03f, -5.77737205e-02f, 2.50108279e-02f, 1.36255294e-01f, 2.22558379e-02f, -9.14075319e-03f, 7.40218908e-02f, -2.39024335e-03f,
  2.56754365e-02f, 1.03415651e-02f, 1.41932383e-01f, -6.38495386e-02f, 5.12547046e-02f, -6.64394954e-03f, 5.30517437e-02f, -2.07543094e-02f, 3.74619476e-02f, 6.70656934e-02f,
  1.05297416e-01f, 1.13125473e-01f, -2.36787423e-02f, -2.30531935e-02f, -1.62052177e-02f, 9.14202724e-03f, 1.33982435e-01f, 2.75013801e-02f, 8.67103338e-02f, -1.77136846e-02f,
  -1.47255972e-01f, 2.05930267e-02f, -3.39093581e-02f, -6.97721203e-04f, -5.98314442e-02f, 8.45586732e-02f, 5.67650869e-02f, -1.06387772e-02f, -4.34464402e-02f, 3.97794209e-02f,
  -4.39180024e-02f, -1.02870464e-01f, -1.48091897e-01f, 4.36646136e-04f, -1.42721012e-01f, 9.99029819e-03f, 2.15056613e-02f, -1.71188384e-01f, -6.44493550e-02f, -2.63190567e-01f,
  -8.73085797e-01f, -4.80601788e-01f, 5.32182753e-01f, -6.02680147e-01f, 1.47412233e-02f, 2.29535416e-01f, -1.86931387e-01f, 8.68066028e-03f, 8.78090262e-02f, -1.50788352e-01f,
  7.62899444e-02f, 1.03920199e-01f, -6.81765974e-02f, 9.97640714e-02f, 2.62541711e-01f, -1.83124453e-01f, 3.75784189e-02f, 1.60143301e-01f, 2.70275801e-01f, 1.05949104e-01f,
  -2.73523897e-01f, -2.60266662e-01f, -5.74447885e-02f, 4.73829508e-02f, -5.49517810e-01f, -2.84881473e-01f, -1.11092925e-01f, -2.32472137e-01f, -2.67594069e-01f, -6.39488339e-01f,
  -1.33451909e-01f, -3.95135209e-02f, 3.73290747e-01f, -3.06249261e-01f, 2.53362134e-02f, -1.05121419e-01f, -2.12539941e-01f, -2.40178406e-02f, 1.06572405e-01f, -1.59546752e-02f,
  6.12282716e-02f, 2.39223257e-01f, -1.01650588e-01f, 9.97067988e-02f, -1.22746816e-02f, -1.38578743e-01f, 8.32518861e-02f, 1.44808635e-01f, 6.19792752e-02f, 7.64384568e-02f,
  -2.00302497e-01f, -1.86309487e-01f, -1.31196693e-01f, 4.80346918e-01f, 9.23741311e-02f, 2.01944888e-01f, 1.97862044e-01f, 1.60262316e-01f, 1.82508320e-01f, -4.53775883e-01f,
  5.96860647e-02f, 7.24456012e-02f, 8.21460858e-02f, 1.46386698e-01f, -1.06944777e-01f, 3.21756825e-02f, -6.12090230e-02f, 1.96554530e-02f, 7.14641660e-02f, -1.13876633e-01f,
  2.00582400e-01f, -8.28562230e-02f, 4.32356782e-02f, -1.54305547e-01f, -1.62941784e-01f, 1.24952354e-01f, -1.24713983e-02f, 1.65047571e-01f, -2.11215302e-01f, -5.07485075e-03f,
  7.92303905e-02f, 4.14651670e-02f, 5.68541400e-02f, -3.62462830e-03f, -5.49457222e-02f, 1.43622113e-02f, -2.53091335e-01f, 7.81385601e-02f, -7.91462436e-02f, 9.49913859e-02f,
  -2.35572726e-01f, 3.47875804e-01f, -3.22848290e-01f, 2.02519950e-02f, 2.80757993e-02f, -5.87313771e-02f, -2.12615468e-02f, 9.88622531e-02f, -2.23991588e-01f, -7.67207369e-02f,
  -1.58339992e-01f, -2.51541734e-01f, -1.59710810e-01f, 2.20905393e-01f, -4.83786985e-02f, 8.12181160e-02f, -1.95884883e-01f, -1.15795799e-01f, 1.21613294e-01f, -2.47766539e-01f,
  -7.67623708e-02f, -9.17865187e-02f, -3.59064519e-01f, -4.59713973e-02f, -4.04988497e-01f, -2.85521686e-01f, -1.05962299e-01f, 2.42565367e-02f, -3.67535233e-01f, -5.57304204e-01f,
  -1.09644377e+00f, -8.70306075e-01f, 6.52059376e-01f, -1.86321169e-01f, 3.74893457e-01f, 4.88317758e-01f, 4.69699115e-01f, 1.38010561e-01f, -1.75726205e-01f, 1.84353273e-02f,
  -2.13487536e-01f, -2.60517955e-01f, -2.76480973e-01f, -7.21725374e-02f, -4.13763486e-02f, 5.33655524e-01f, 3.32954884e-01f, 2.31145427e-01f, 3.58629882e-01f, 3.04368615e-01f,
  3.68089229e-02f, -2.01286912e-01f, -6.14072919e-01f, -2.50725031e-01f, -1.19031444e-01f, -2.56384443e-02f, -4.53768782e-02f, -2.18209639e-01f, -1.85494006e-01f, -1.70885310e-01f,
  3.47873628e-01f, -3.01820278e-01f, 1.18256666e-01f, -3.24497998e-01f, 8.81325379e-02f, -1.02473006e-01f, 1.82790123e-02f, -6.25765044e-03f, -1.26379147e-01f, -1.07349105e-01f,
  -1.67211860e-01f, -1.02842376e-01f, 3.37443314e-02f, -2.88945735e-02f, -8.19421336e-02f, -8.54637772e-02f, -8.36256295e-02f, -1.42914563e-01f, -2.18020193e-02f, 2.81622950e-02f,
  -2.98414081e-02f, -9.12362114e-02f, 1.66412126e-02f, -6.47123111e-03f, -6.05112799e-02f, -3.21544930e-02f, -1.54113635e-01f, -2.09065191e-02f, -2.39666983e-01f, -3.33602503e-02f,
  -2.73786914e-02f, -4.22054194e-02f, 1.55139059e-01f, -3.10628265e-02f, 8.91015455e-02f, 5.63899940e-03f, -2.58315708e-02f, -4.72561531e-02f, 5.66003174e-02f, 1.92514509e-02f,
  -6.88012466e-02f, 1.24026172e-01f, 4.37663831e-02f, -9.19265673e-02f, 2.12230347e-02f, -1.40928268e-01f, 4.27675657e-02f, -3.19551826e-02f, -8.78160819e-02f, -1.23318546e-01f,
  -7.13497475e-02f, 7.91374128e-03f, -6.76594302e-02f, 6.34269714e-02f, -1.17601277e-02f, 2.97975237e-03f, 2.48596165e-02f, -2.93223709e-02f, 6.25567660e-02f, 1.43798080e-03f,
  1.24777608e-01f, -1.64769232e-01f, 1.41217798e-01f, 1.19244615e-02f, -3.08510922e-02f, -1.99290678e-01f, -7.28543401e-02f, -4.15028520e-02f, -8.34957417e-03f, 1.37313113e-01f,
  -1.72326729e-01f, 4.06895131e-02f, -4.93509434e-02f, -3.87756042e-02f, 1.42544791e-01f, 5.61792031e-03f, -1.90664589e-01f, 5.76162077e-02f, 1.25815617e-02f, -2.28239913e-02f,
  -3.80779654e-02f, 8.48703682e-02f, 2.71795332e-01f, 1.64666846e-01f, -6.41183108e-02f, 1.85882896e-01f, 2.70178318e-01f, 1.61251828e-01f, 2.07750648e-01f, 2.84486532e-01f,
  -1.07952058e-01f, 2.74876148e-01f, -6.40769839e-01f, 5.07542342e-02f, -5.16080379e-01f, -4.08511996e-01f, -9.42562371e-02f, -1.31552249e-01f, -2.49163378e-02f, 1.91805035e-01f,
  1.83911994e-01f, 3.01770687e-01f, 5.35418212e-01f, -6.14411980e-02f, -1.39084011e-01f, 2.86407351e-01f, -2.12606400e-01f, -1.51781306e-01f, -6.14660800e-01f, -5.85243225e-01f,
  -3.33108783e-01f, -1.89814553e-01f, -2.44153395e-01f, -2.47828737e-01f, -7.15678409e-02f, -3.25707734e-01f, -8.23153257e-02f, -3.71178746e-01f, -5.33625662e-01f, -3.50020140e-01f,
  6.20929860e-02f, -3.84475678e-01f, 2.36529633e-02f, -1.12163335e-01f, 3.78310302e-04f, 1.52235344e-01f, -3.01447418e-03f, 8.60505328e-02f, 1.91842064e-01f, 2.04072878e-01f,
  1.25256762e-01f, -1.62694659e-02f, 4.14515212e-02f, 2.50225794e-02f, -1.04106702e-01f, -7.41826594e-02f, -3.89700523e-03f, -1.16799735e-01f, 1.09899759e-01f, 5.67619465e-02f,
  5.99471740e-02f, -3.20839852e-01f, -2.35899556e-02f, -1.30093083e-01f, -5.05279191e-02f, -1.00229256e-01f, -1.14249133e-01f, -2.74266839e-01f, -3.42332482e-01f, 1.34043547e-03f,
  -3.34192701e-02f, 1.52877137e-01f, -1.79313496e-02f, 2.24147364e-02f, 1.03699826e-01f, 1.49937987e-01f, 1.38934851e-02f, -4.41521481e-02f, 5.74617721e-02f, 1.26078010e-01f,
  7.69855380e-02f, -5.04346145e-03f, -4.46093641e-02f, -1.25437360e-02f, -2.67756707e-03f, -1.06208853e-01f, -1.75257716e-02f, 2.95103993e-03f, -4.35613003e-03f, 1.18584022e-01f,
  2.12753583e-02f, -3.38538848e-02f, 1.41650969e-02f, -1.92829147e-02f, -1.69997141e-01f, 4.58911099e-02f, -1.09088786e-01f, 2.36438718e-02f, 7.84043446e-02f, 3.96957435e-02f,
  3.80064428e-01f, -2.28313372e-01f, 2.54612744e-01f, -1.52881458e-01f, -8.00186396e-02f, 1.56333402e-01f, 7.44766369e-02f, -2.68067308e-02f, 5.76439798e-02f, -1.49398865e-02f,
  -9.43176001e-02f, -8.39523319e-03f, 2.04354092e-01f, -7.33204978e-03f, 1.44731000e-01f, -2.50822324e-02f, -6.26207516e-02f, -8.41758475e-02f, -6.49450645e-02f, 1.62242115e-01f,
  1.48926124e-01f, 1.01137668e-01f, 1.85470909e-01f, 2.36668959e-01f, 1.65638298e-01f, -3.35187912e-02f, 1.06831029e-01f, 3.04549616e-02f, -3.82222757e-02f, 3.54769140e-01f,
  6.91322565e-01f, -4.92827266e-01f, -2.79765248e-01f, 3.19704115e-01f, -9.55295712e-02f, 1.41032711e-01f, -3.97541225e-01f, 3.69629085e-01f, 3.78194183e-01f, -3.30720454e-01f,
  7.59489909e-02f, 6.17829978e-01f, 4.38190520e-01f, 2.28437334e-01f, 1.88723117e-01f, -5.32231748e-01f, -2.94699311e-01f, 2.25876972e-01f, 4.30166781e-01f, 2.06219345e-01f,
  3.59056368e-02f, -2.91107185e-02f, 2.02946708e-01f, 1.22820817e-01f, -4.26537067e-01f, 1.32880852e-01f, -2.98255533e-01f, -1.78012267e-01f, -2.17794478e-01f, -5.81402302e-01f,
  -3.02857935e-01f, 4.27343883e-02f, 2.76327401e-01f, 1.60829470e-01f, -1.94571450e-01f, 1.80423539e-02f, -7.00308084e-02f, 6.08128458e-02f, -1.12015102e-02f, -9.43099782e-02f,
  -2.86250468e-03f, -6.47602603e-02f, 1.08272433e-01f, -8.30844417e-02f, -3.55583876e-02f, 1.39648735e-03f, -5.37813567e-02f, 2.64432561e-02f, -4.71926220e-02f, -2.12949619e-01f,
  -1.97198033e-01f, 2.88518844e-03f, 9.57055539e-02f, 2.41376683e-01f, 9.46385115e-02f, 2.11877644e-01f, -6.81840777e-02f, 3.21951404e-04f, 2.76652098e-01f, -1.45342395e-01f,
  -7.65021611e-03f, -2.96011735e-02f, 8.93435478e-02f, 6.66424586e-03f, -1.86893269e-02f, 5.27890511e-02f, -8.34113359e-02f, -2.90677708e-04f, 3.99378985e-02f, -5.94749190e-02f,
  3.29734534e-02f, 1.61431562e-02f, -3.03772721e-03f, 2.37395056e-03f, 4.86594401e-02f, 2.08458900e-02f, -1.01146482e-01f, -4.28392366e-02f, -1.99523568e-03f, -2.24611964e-02f,
  5.15289083e-02f, -5.91490678e-02f, -9.81453955e-02f, -6.44348636e-02f, -8.58666822e-02f, 1.86331235e-02f, 8.00399184e-02f, 1.47674054e-01f, 3.91528122e-02f, -9.43512842e-02f,
  4.87547778e-02f, 3.88763219e-01f, -7.50435889e-02f, 6.59944536e-03f, -8.60614926e-02f, -1.61866769e-01f, -2.53072008e-02f, -4.46522646e-02f, -8.76609385e-02f, -3.71964164e-02f,
  7.98773021e-02f, -3.60165834e-02f, -4.65455875e-02f, -9.09699965e-03f, 5.84145710e-02f, -5.00683673e-03f, -9.74270105e-02f, 1.11107193e-02f, 8.36871415e-02f, -6.57358989e-02f,
  -9.93069559e-02f, 6.61786050e-02f, 1.79058358e-01f, 9.26107615e-02f, 1.85252890e-01f, 1.43897533e-01f, -2.74319649e-02f, 1.51453065e-02f, 1.48578823e-01f, -1.14005595e-01f,
  -3.60491604e-01f, -8.61060098e-02f, -6.99079573e-01f, -3.77564281e-01f, -4.22829896e-01f, -2.96900511e-01f, 1.89823419e-01f, 3.14547360e-01f, -1.28015488e-01f, 1.51855886e-01f,
  -1.56377852e-01f, -6.30937144e-02f, -3.06634069e-03f, 9.83069884e-04f, 3.70152146e-02f, 7.65981004e-02f, -4.61188555e-01f, -4.15809125e-01f, -1.97014168e-01f, -1.99284032e-01f,
  -1.32573053e-01f, -1.10272497e-01f, -3.94631207e-01f, 9.96927992e-02f, -5.73102497e-02f, 2.27470726e-01f, -8.29994902e-02f, -4.84222710e-01f, -2.99352974e-01f, -4.36836541e-01f,
  -1.60204604e-01f, -2.52808928e-01f, -1.46399364e-01f, -3.60525511e-02f, -5.88300228e-02f, -2.75325418e-01f, 2.67462581e-02f, -1.29933089e-01f, -7.62882456e-02f, -3.89710888e-02f,
  -2.17013150e-01f, -2.78678328e-01f, -2.05190286e-01f, -1.47816584e-01f, -6.34871274e-02f, -2.67601795e-02f, -2.79930257e-03f, -1.97673038e-01f, 5.39316088e-02f, -1.27073377e-01f,
  -1.41071826e-01f, -2.19904974e-01f, -9.82115194e-02f, 2.67484486e-01f, -1.09648526e-01f, -4.08737920e-03f, 6.21555224e-02f, 3.61819714e-02f, 1.88259527e-01f, 3.47533286e-01f,
  2.93730497e-02f, -1.04126018e-02f, 7.09016472e-02f, -2.34292466e-02f, 1.15942702e-01f, 9.04026721e-03f, -6.74291924e-02f, 4.89225127e-02f, 4.98249270e-02f, 9.10937786e-02f,
  1.34611642e-02f, 1.02282465e-01f, -1.13623038e-01f, -1.15187041e-01f, -5.34667671e-02f, -5.34417592e-02f, 3.50513831e-02f, 1.27842009e-01f, -3.29228211e-03f, -3.41395326e-02f,
  -6.81968331e-02f, -1.64162055e-01f, -7.95633066e-03f, 6.43422082e-02f, -1.73063189e-01f, -1.35325044e-01f, 1.12442300e-02f, 6.10193275e-02f, 1.91429168e-01f, 5.91963064e-03f,
  6.72954738e-01f, -1.56632692e-01f, 8.81440639e-02f, 1.74530327e-01f, -2.03866214e-01f, -1.05950378e-01f, -7.83849508e-02f, -8.03865939e-02f, -9.21177194e-02f, -2.25089006e-02f,
  -1.11613303e-01f, -2.82111079e-01f, -1.11017562e-01f, 4.91592363e-02f, 6.29863217e-02f, 9.74846408e-02f, 2.73362501e-03f, -5.59128355e-04f, -5.36192805e-02f, -2.26231486e-01f,
  7.55795762e-02f, 3.13596636e-01f, 2.94293612e-01f, 2.90540576e-01f, 2.74129268e-02f, 2.06343874e-01f, 2.79077977e-01f, 2.24699467e-01f, 2.51773685e-01f, 6.84227526e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.14732456e-01f, 2.69177169e-01f, 4.97604191e-01f, 3.44626039e-01f, 3.44372302e-01f, 7.36608386e-01f, 2.33523071e-01f, 1.15975022e+00f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -7.79232057e-03f, -8.21477175e-02f, -4.39099401e-01f, -8.46374221e-03f, 5.36405332e-02f, -4.02585603e-02f, -6.30046487e-01f, 1.20809093e-01f, -1.85573280e-01f, 5.69305480e-01f,
  2.31879681e-01f, 3.17673922e-01f, -2.96748459e-01f, -1.94469750e-01f, 8.95019174e-02f, -2.30514809e-01f, 1.54839352e-01f, -1.45068113e-02f, 3.64866614e-01f, 5.82991727e-02f,
  -2.17724089e-02f, -4.09161486e-02f, 2.51601130e-01f, -9.69873592e-02f, -4.65179950e-01f, -1.00202575e-01f, 3.06293488e-01f, 6.25181198e-01f, 7.30588734e-02f, 8.11265111e-02f,
  -1.14768587e-01f, -3.19469362e-01f, -1.11099906e-01f, -7.77440965e-02f, -3.56852800e-01f, -5.28847761e-02f, 4.55852784e-02f, 1.22411720e-01f, -6.15928583e-02f, 2.71347880e-01f,
  -4.09686446e-01f, 2.81052083e-01f, -2.70477265e-01f, -2.79945016e-01f, 1.33406788e-01f, -3.39546874e-02f, 5.68128526e-01f, 1.32137343e-01f, 1.94214564e-02f, 8.09956640e-02f,
  2.14808941e-01f, -3.36926468e-02f, -8.01323503e-02f, 3.57339904e-02f, 5.60879529e-01f, 2.48919636e-01f, 3.99033725e-02f, 3.28372329e-01f, 2.72226512e-01f, 1.44823849e-01f,
  -6.65232062e-01f, -1.07127808e-01f, 5.55151105e-01f, 5.17825373e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.28170806e-01f, -4.32955295e-01f, -4.13433127e-02f, -1.38582662e-01f, 3.79523486e-02f, 2.64293015e-01f, -5.51761985e-01f, -1.30030781e-01f, 3.30524147e-01f, -8.15187633e-01f,
  -3.87005597e-01f, -9.76385847e-02f, 6.67805254e-01f, -1.01820147e+00f, 2.07478955e-01f, 2.13184461e-01f, 2.73379862e-01f, 3.47498357e-01f, -3.33561689e-01f, 2.72141367e-01f,
  -6.54473975e-02f, -3.90163288e-02f, -1.03444600e+00f, 3.37820739e-01f, 9.00169253e-01f, -1.62083551e-01f, -3.68884832e-01f, 5.25021493e-01f, 3.30877692e-01f, -3.31005335e-01f,
  -6.38936460e-01f, 3.36145073e-01f, 2.36672595e-01f, 2.07358569e-01f, 3.72018009e-01f, 3.93337816e-01f, 3.21580261e-01f, 2.18625724e-01f, 7.24306762e-01f, 4.39000428e-01f,
  8.17329109e-01f, -4.30454433e-01f, -2.37338990e-01f, -1.75172716e-01f, 2.11381420e-01f, 7.33829021e-01f, 2.57531740e-02f, 7.94152021e-01f, 2.94742864e-02f, -5.03704906e-01f,
  5.41361809e-01f, 4.56413865e-01f, 1.28813172e-02f, 3.60737503e-01f, -1.14072812e+00f, -2.19756722e-01f, -2.00514421e-01f, 3.23500425e-01f, -4.33153629e-01f, 2.13020533e-01f,
  -1.14773527e-01f, 4.28712398e-01f, -9.15730715e-01f, 3.26513380e-01f, 3.78851116e-01f, 4.21372205e-01f, 6.87324941e-01f, 4.31689113e-01f, 4.29875046e-01f, 2.17712652e-02f,
  -3.82927835e-01f, -6.02836132e-01f, -2.00298071e-01f, 1.31398961e-01f, 7.97768593e-01f, 3.89039814e-01f, -4.50430095e-01f, 8.58969152e-01f, -1.97187752e-01f, 7.52092779e-01f,
  2.44282484e-01f, 6.45036548e-02f, 5.28066814e-01f, 3.48830879e-01f, -1.30413443e-01f, -1.16445705e-01f, 1.90126076e-01f, -4.73482758e-02f, -1.23207740e-01f, 4.85849559e-01f,
  -1.60261586e-01f, 1.62589177e-01f, 1.27935767e+00f, -6.26722500e-02f, -4.07487422e-01f, 5.64524114e-01f, 1.57711253e-01f, -2.74208874e-01f, -5.88507235e-01f, 5.18352492e-03f,
  -1.50581852e-01f, 7.19535112e-01f, -6.74513280e-01f, -4.11291361e-01f, -5.47645032e-01f, 3.98113877e-01f, -8.32979202e-01f, 4.49830532e-01f, 2.32400864e-01f, -3.44396889e-01f,
  -2.76053429e-01f, 2.67491788e-01f, 2.80908853e-01f, 1.19517922e-01f, 4.24833536e-01f, 5.32199666e-02f, -6.93834201e-02f, 8.55058283e-02f, 5.22516191e-01f, -2.54129991e-02f,
  4.72921908e-01f, 4.99557197e-01f, 4.57063735e-01f, 5.90066314e-01f, -5.78055859e-01f, 2.25103348e-02f, 6.89083278e-01f, 1.05748080e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.51402044e-01f, 4.48821962e-01f, 3.57106119e-01f, 6.09287262e-01f, 1.15982808e-01f, 5.06935537e-01f, 1.92622960e-01f, -2.37078592e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.37688178e-01f, -4.84539270e-01f, 2.66929507e-01f, 1.90908626e-01f, 4.20888543e-01f, -1.80671539e-03f, -1.77645296e-01f, 6.94866180e-01f, 1.99435487e-01f, 2.65927911e-01f,
  -1.67286262e-01f, 4.24860686e-01f, 3.55783492e-01f, -4.20332879e-01f, -5.15256599e-02f, -3.34996551e-01f, 2.63059270e-02f, 4.19147521e-01f, 2.86636800e-01f, 4.96301383e-01f,
  -2.90450007e-01f, -2.93719351e-01f, 4.40640986e-01f, 3.32117289e-01f, 2.17335060e-01f, 8.92885551e-02f, 7.67403767e-02f, 2.42604211e-01f, -4.73876715e-01f, 3.16582561e-01f,
  -8.07197750e-01f, -3.53752464e-01f, -6.78407252e-01f, -6.51045367e-02f, 1.64694190e-01f, 1.43153787e-01f, -1.07852757e+00f, 1.28900826e-01f, -2.14945093e-01f, 1.38910457e-01f,
  -1.99352175e-01f, -9.18016136e-02f, 1.35965273e-01f, -2.69652247e-01f, -3.41921479e-01f, 6.72071755e-01f, 4.26805049e-01f, -2.84630328e-01f, -5.58908165e-01f, -6.88226163e-01f,
  2.80630171e-01f, -1.30902126e-01f, -1.33195305e-02f, -4.86880839e-01f, 3.50529373e-01f, -3.91569287e-01f, 2.08164394e-01f, 1.91789046e-01f, 2.60747105e-01f, 2.15195969e-01f,
  -9.04249176e-02f, 1.08553387e-01f, 2.20364835e-02f, -3.44413012e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.12031609e-01f, 3.26904953e-01f, 9.07024443e-01f, 9.82273698e-01f, -9.88360941e-01f, 4.81857687e-01f, -8.42418313e-01f, 1.34630394e+00f, -1.08056867e+00f, -5.18781900e-01f,
  5.95305622e-01f, 3.20570111e-01f, 6.22461438e-01f, 1.10559212e-02f, -5.79478204e-01f, -2.81705141e-01f, -9.57311928e-01f, 9.01259854e-02f, -5.05989313e-01f, -1.50601149e-01f,
  -4.19867784e-01f, 2.17141837e-01f, 1.06718898e+00f, -5.09248435e-01f, -1.17827094e+00f, 2.50718683e-01f, -3.51830274e-01f, 2.33948052e-01f, -1.88618507e-02f, 4.59475458e-01f,
  8.48012388e-01f, 2.47477248e-01f, -6.12735935e-02f, -4.45013881e-01f, 7.98576176e-02f, -2.89137125e-01f, 1.09378684e+00f, 1.30099285e+00f, -1.03456116e+00f, 1.09582603e+00f,
  -1.30361187e+00f, 5.08551300e-01f, -8.71463299e-01f, 4.95426357e-01f, 3.70174438e-01f, 2.63059586e-01f, -1.06838010e-01f, 3.49338830e-01f, -7.37680634e-03f, 3.62488687e-01f,
  4.21398997e-01f, -5.25673091e-01f, -2.25807801e-01f, 2.85946697e-01f, 4.89000261e-01f, -1.06595039e+00f, 6.57754719e-01f, 9.28608850e-02f, -1.56895459e-01f, 5.83665311e-01f,
  -1.40161188e-02f, 6.05915606e-01f, 1.27898347e+00f, 2.03941539e-01f, -3.15909714e-01f, -8.41818452e-01f, 5.32283306e-01f, -1.12190378e+00f, -1.64023012e-01f, -2.46981338e-01f,
  1.29517853e+00f, 1.63061440e-01f, 7.10850894e-01f, 7.04974160e-02f, 7.14779735e-01f, -5.26927829e-01f, 2.56024569e-01f, 8.96091685e-02f, -7.42784917e-01f, 8.26557815e-01f,
  -5.37821412e-01f, -2.55094264e-02f, 2.01633677e-01f, 1.01339698e+00f, -1.86208323e-01f, -1.13568950e+00f, -7.74410605e-01f, 1.51798397e-01f, 2.55273264e-02f, 1.41569495e+00f,
  1.75458685e-01f, 7.93333232e-01f, 1.53120589e-02f, 7.84665644e-01f, -2.56249160e-01f, -6.73443556e-01f, -8.19537044e-01f, -1.01687543e-01f, 1.98145404e-01f, -1.48228705e-01f,
  -4.09423530e-01f, -6.02772295e-01f, 1.23418641e+00f, -1.02455986e+00f, -6.85794353e-01f, -2.16350093e-01f, 6.71955585e-01f, 3.12406182e-01f, 3.82007390e-01f, 9.75909948e-01f,
  -2.43273556e-01f, -1.00025386e-01f, 7.61854887e-01f, -3.95479262e-01f, 4.22760189e-01f, -8.65713954e-02f, 2.25637466e-01f, 8.28733444e-01f, -6.95784092e-02f, 5.34847915e-01f,
  -2.30945140e-01f, -1.82098404e-01f, -2.14505315e-01f, 9.32626665e-01f, 8.80689323e-01f, 5.18872917e-01f, 3.40638131e-01f, -3.52663174e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.03415644e-01f, -6.30288571e-02f, 1.95293680e-01f, -2.43079051e-01f, 1.46773970e-02f, 4.74485129e-01f, -3.12802017e-01f, 2.74403524e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  6.50432348e-01f, -4.87669170e-01f, -2.03830078e-01f, 1.33366911e-02f, 2.67238200e-01f, -3.62892538e-01f, 2.13780612e-01f, -3.72489899e-01f, -3.90967846e-01f, 6.46455050e-01f,
  -2.94630527e-02f, 3.07832897e-01f, 1.08871371e-01f, -9.82349396e-01f, 2.52118587e-01f, 4.79286090e-02f, -9.97611165e-01f, -6.00063652e-02f, 3.58167320e-01f, 6.53666377e-01f,
  -4.07046288e-01f, 1.19603813e+00f, -3.24349135e-01f, 4.87885803e-01f, 3.92021090e-02f, -4.70119208e-01f, -8.66589725e-01f, -1.21734902e-01f, 6.62693799e-01f, -1.16062653e+00f,
  3.10533136e-01f, -8.79398063e-02f, 6.79126978e-01f, -7.66371846e-01f, -4.83618677e-01f, -4.40669954e-01f, 9.57183242e-02f, 3.51666636e-03f, -7.20162034e-01f, -3.65524650e-01f,
  -4.14352447e-01f, -7.86016360e-02f, 1.32215703e+00f, -5.79995215e-01f, 2.55102277e-01f, -8.45313132e-01f, -1.02643371e+00f, 3.37835014e-01f, -5.89821160e-01f, -9.64201629e-01f,
  4.63147402e-01f, -9.49564576e-01f, -3.68302688e-03f, -2.08190247e-01f, 2.57683903e-01f, 4.09650713e-01f, -5.10630012e-01f, 5.45792878e-01f, 4.04167086e-01f, 1.74549446e-01f,
  -1.16929340e+00f, -1.33968620e-02f, 5.44944294e-02f, 1.03455819e-01f, -9.03731406e-01f, -4.35912639e-01f, -7.28184581e-01f, 5.20858705e-01f, 1.17779148e+00f, 2.72201717e-01f,
  4.00263190e-01f, -4.39915597e-01f, 2.29213387e-01f, -1.02592456e+00f, 3.86541218e-01f, -7.50132650e-02f, 5.60476594e-02f, 1.05727911e-01f, -2.86663681e-01f, 2.61467755e-01f,
  1.14010441e+00f, 7.98318163e-02f, 1.59033611e-01f, -6.15881085e-01f, 3.12658250e-01f, -1.62574303e+00f, -2.27917150e-01f, 3.58623296e-01f, 6.44372761e-01f, -6.94832504e-02f,
  -1.30185223e+00f, -8.57754707e-01f, 3.42509806e-01f, -2.08956346e-01f, 9.42397863e-02f, -1.03398353e-01f, 4.61852729e-01f, 8.53294075e-01f, -8.32497776e-02f, 1.12098598e+00f,
  -1.14381719e+00f, 6.70540452e-01f, 1.49806309e+00f, -1.11597717e+00f, 6.74155414e-01f, -8.24137628e-01f, -1.14802301e+00f, -7.72928655e-01f, -4.39911753e-01f, 5.71333289e-01f,
  -1.04084229e+00f, -9.65947151e-01f, -7.66324401e-01f, 3.47742498e-01f, -2.59285024e-03f, -1.55990779e-01f, 7.02631474e-01f, -2.57824093e-01f, -4.29952115e-01f, 5.33259928e-01f,
  -9.79149997e-01f, -7.45840073e-01f, -6.13605678e-01f, 9.21145201e-01f, -1.16864793e-01f, 2.59908121e-02f, -7.89895177e-01f, 1.53724536e-01f, -2.77643234e-01f, -8.22066903e-01f,
  -4.58374560e-01f, -1.78693622e-01f, -7.29316533e-01f, 3.57723892e-01f, 8.38337719e-01f, 1.21640101e-01f, -6.00562036e-01f, -5.75342178e-01f, -6.25336617e-02f, -1.07744727e-02f,
  1.89164355e-02f, 5.69993854e-01f, 1.66295767e-01f, -1.28590238e+00f, 8.60092938e-01f, 9.43820596e-01f, 1.18896067e+00f, -5.72562277e-01f, -2.15739578e-01f, -1.18060625e+00f,
  -3.97598356e-01f, -1.03534091e+00f, 8.98493171e-01f, -9.51234519e-01f, 3.68113995e-01f, -6.57401383e-01f, -1.44506955e+00f, -1.01233542e+00f, -1.53588104e+00f, 7.00839758e-01f,
  -8.94271374e-01f, 2.82431692e-01f, -7.25013971e-01f, -1.03482634e-01f, -1.11168051e+00f, 6.30604327e-01f, 7.93250501e-02f, -2.83251777e-02f, -1.13123901e-01f, 4.94547129e-01f,
  -9.85031724e-01f, -3.80192786e-01f, -7.59187996e-01f, -4.46926691e-02f, 7.88769364e-01f, -7.16122985e-02f, 7.16922820e-01f, 2.07912907e-01f, 8.34931374e-01f, 5.29367030e-01f,
  6.05903566e-01f, 6.93970084e-01f, -1.19174933e+00f, 1.02369475e+00f, -7.44423211e-01f, 3.26834977e-01f, 5.84906220e-01f, -1.15153539e+00f, -2.33449370e-01f, 9.91945684e-01f,
  -1.12667716e+00f, -5.64847529e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.13427615e-01f, 1.31749332e-01f, 1.14984393e-01f, -8.20876181e-01f, 6.44021556e-02f, 4.12056968e-02f, 7.56739438e-01f, 3.38830173e-01f, -2.47702435e-01f, 5.75228572e-01f,
  -6.05574608e-01f, 1.78865582e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    