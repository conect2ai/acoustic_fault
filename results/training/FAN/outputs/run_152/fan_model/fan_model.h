/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.64383340e-01f, -3.08869004e-01f, -2.98482608e-02f, -5.65559678e-02f, 1.49972275e-01f, 2.43776500e-01f, 7.72545785e-02f, 1.44071477e-02f, 5.81502132e-02f, -1.93833306e-01f,
  -9.70261022e-02f, -1.08973823e-01f, -1.77866817e-01f, -1.40471041e-01f, 8.27246755e-02f, -1.89938799e-01f, 8.80033299e-02f, 1.81196984e-02f, -6.67835474e-02f, -2.90520787e-02f,
  -4.26653167e-03f, -1.26072183e-01f, -1.21798173e-01f, -9.45255309e-02f, 6.37149960e-02f, 2.20569025e-04f, -2.94453613e-02f, -7.37994760e-02f, -8.84594768e-03f, 4.10899371e-02f,
  5.87268993e-02f, -2.35264320e-02f, 7.22730160e-02f, 4.04425561e-02f, 9.96468812e-02f, 1.06939845e-01f, 4.03381288e-02f, -1.17320344e-02f, 8.37839441e-04f, 3.09553440e-03f,
  -4.27055173e-02f, 2.25063674e-02f, -2.07911202e-04f, -2.34533474e-02f, 5.61232157e-02f, -1.88076571e-02f, 1.57811074e-03f, 6.11272454e-02f, -4.44649272e-02f, -1.28249945e-02f,
  -2.37244200e-02f, 4.60051522e-02f, 4.06260826e-02f, -3.47832590e-02f, 9.49284434e-03f, 9.30132251e-03f, -1.72118936e-02f, 2.48045363e-02f, 1.80428606e-02f, 5.53667732e-02f,
  2.05468703e-02f, -5.59695177e-02f, -4.20114063e-02f, -2.37264633e-02f, -3.67206410e-02f, 1.72096230e-02f, -2.38904413e-02f, 7.06838211e-04f, -1.81307811e-02f, -4.48828787e-02f,
  1.01848533e-02f, 6.53415453e-04f, -3.70216114e-03f, -6.46248320e-03f, -6.81060087e-03f, 3.38099711e-02f, -3.26648564e-03f, -5.25516607e-02f, 5.84947355e-02f, 8.00731417e-04f,
  -4.76734862e-02f, -1.34421820e-02f, -1.60411652e-02f, 1.99636128e-02f, 5.52340504e-03f, -2.82518249e-02f, -5.44670075e-02f, 1.55753642e-02f, -3.30463462e-02f, 2.69855037e-02f,
  -7.77480602e-02f, -1.24659456e-01f, -9.66212433e-03f, -3.86870950e-02f, -4.08279076e-02f, 2.70406660e-02f, -5.11801941e-03f, 6.45654872e-02f, -4.52463292e-02f, 9.84941726e-04f,
  2.96647865e-02f, 3.75962667e-02f, 5.54083996e-02f, 1.08100651e-02f, -7.51343323e-03f, -2.32381802e-02f, -7.95383528e-02f, -1.49310408e-02f, -3.53401015e-03f, -4.62076813e-02f,
  -8.35592207e-03f, 5.52235311e-03f, 2.36162543e-02f, 3.64846662e-02f, 2.59278286e-02f, 1.35546466e-02f, 3.51986736e-02f, -3.11443838e-03f, -6.01558760e-02f, -5.37714735e-03f,
  -3.15556467e-01f, 1.57466635e-01f, -1.39590412e-01f, -2.16212139e-01f, 6.28101602e-02f, 3.33369859e-02f, -1.41584754e-01f, 2.14801997e-01f, 3.25238481e-02f, 1.24238275e-01f,
  1.11096360e-01f, -2.56789148e-01f, 2.76299417e-01f, -2.24576369e-01f, -3.47255081e-01f, 6.60053045e-02f, -2.15783522e-01f, -1.26356959e-01f, 1.50648072e-01f, -5.21667376e-02f,
  -5.94825894e-02f, -1.21641651e-01f, -1.48748264e-01f, 2.08816484e-01f, -6.51478320e-02f, 5.80471009e-02f, -1.01316221e-01f, 8.56917351e-02f, -2.13971138e-01f, -1.05250470e-01f,
  4.69546113e-03f, -5.40694706e-02f, -1.26485797e-02f, -2.64584702e-02f, 3.67658176e-02f, -2.75346115e-02f, -6.30155504e-02f, -3.24360281e-02f, 4.57882434e-02f, 3.50765102e-02f,
  -3.01650055e-02f, -4.68724817e-02f, 7.06126820e-03f, 6.70269653e-02f, -7.72897378e-02f, -3.92762758e-02f, -4.90901135e-02f, -2.61984095e-02f, -2.62200162e-02f, -3.80471535e-02f,
  1.52918976e-02f, -4.39377874e-02f, -5.92862479e-02f, -1.04540750e-01f, -6.88495114e-02f, -2.58952193e-02f, -6.71020001e-02f, -6.69762194e-02f, -9.94098485e-02f, -5.79670295e-02f,
  1.05409813e-03f, 6.64187744e-02f, 4.16112840e-02f, -8.63970444e-03f, 2.58189104e-02f, -1.82660650e-02f, 4.20271372e-03f, -2.83966530e-02f, 3.08708940e-02f, -1.91459209e-02f,
  -1.96082182e-02f, -2.03997083e-02f, -9.11508594e-03f, -1.43546960e-03f, 1.04540261e-02f, -3.14474776e-02f, -4.80583683e-02f, 8.52564070e-03f, 2.56893598e-02f, -1.38096074e-02f,
  2.08737347e-02f, -9.39508434e-03f, -6.63817767e-03f, 8.86224397e-03f, 6.80070817e-02f, 6.76006451e-03f, 4.35612425e-02f, -4.17844839e-02f, 5.69392256e-02f, 1.54354814e-02f,
  -5.09103909e-02f, -8.84130001e-02f, 1.21054396e-01f, -5.95786199e-02f, 4.80106659e-02f, 3.21242847e-02f, -2.68799104e-02f, 5.81783056e-03f, -1.48527827e-02f, 4.30888794e-02f,
  7.01954775e-03f, 4.28645611e-02f, -5.06708398e-02f, -2.60536838e-02f, -5.07933088e-03f, -4.22802605e-02f, -3.78140956e-02f, 1.58222709e-02f, -7.56914392e-02f, 7.14876354e-02f,
  2.83156261e-02f, 5.73269017e-06f, 2.45927554e-02f, 5.59341833e-02f, -2.56540552e-02f, -1.38787357e-02f, -3.59150507e-02f, -1.48180984e-02f, -8.14183615e-03f, -8.76902882e-03f,
  4.18590546e-01f, 1.34553581e-01f, -1.10931881e-01f, 2.27530047e-01f, -1.70496181e-02f, -2.13217333e-01f, -5.68042248e-02f, -7.35114468e-03f, 3.48572314e-01f, 2.40206644e-02f,
  -1.12861142e-01f, 2.23748580e-01f, -9.56190750e-02f, 1.24060288e-01f, -2.01027170e-01f, 3.05812922e-03f, 1.50941620e-02f, 6.32237941e-02f, 6.62117153e-02f, -5.73646240e-02f,
  7.70621561e-03f, -1.87503509e-02f, -2.03270823e-01f, -3.59899774e-02f, 6.74654469e-02f, -9.51752590e-04f, -1.58078119e-01f, -7.45875910e-02f, -3.95402089e-02f, 4.31171060e-02f,
  -2.41680611e-02f, 1.44578740e-01f, 4.78967912e-02f, 3.62635069e-02f, -9.62067917e-02f, 1.32649234e-02f, -6.15426339e-02f, -2.91025229e-02f, 2.39706459e-03f, -1.68697897e-03f,
  5.79130910e-02f, -3.81418057e-02f, 6.87075257e-02f, 3.55994515e-02f, 1.28165707e-01f, 2.98813470e-02f, -2.26720725e-03f, -7.42829172e-03f, 4.58146147e-02f, -3.17812525e-02f,
  -5.28106950e-02f, -3.14915180e-02f, 1.65749863e-02f, 1.53923407e-02f, -6.28355378e-03f, -6.60863239e-03f, -4.74766716e-02f, -7.89719373e-02f, 7.84228668e-02f, 2.27801334e-02f,
  4.23831828e-02f, 4.30505315e-04f, -2.87093148e-02f, 7.87261575e-02f, -2.07896698e-02f, 4.65462543e-02f, 7.38663301e-02f, -2.79588401e-02f, 1.61318574e-02f, -5.92560042e-03f,
  -3.19800973e-02f, 3.23385932e-02f, 6.93460554e-02f, -2.34429240e-02f, -5.33567555e-02f, 6.06400855e-02f, -3.90582830e-02f, 9.47020203e-03f, -4.48616594e-02f, -1.20119750e-02f,
  2.51069013e-02f, 2.07892638e-02f, -6.17752559e-02f, 1.76803730e-02f, -1.93204358e-02f, -8.94636139e-02f, 3.57810147e-02f, -2.86945459e-02f, -9.60594509e-03f, -3.48397642e-02f,
  -1.21038221e-01f, -9.16432589e-02f, -3.64830233e-02f, 2.08651135e-03f, 3.79327983e-02f, -1.64383128e-02f, 1.19587690e-01f, 4.19131070e-02f, -7.31172934e-02f, 1.88743249e-02f,
  -7.37488642e-02f, 1.43280635e-02f, -3.06781475e-02f, 2.96048541e-03f, 1.43600637e-02f, -1.19210362e-01f, 8.03456525e-04f, 8.65894184e-03f, -2.52488274e-02f, -4.98800017e-02f,
  -5.60343675e-02f, -2.27257591e-02f, 8.45486894e-02f, 4.01371792e-02f, 2.64775120e-02f, -3.61030921e-02f, -1.89106092e-02f, -2.70794854e-02f, 1.04568098e-02f, 5.07444106e-02f,
  -1.64366260e-01f, -2.46236566e-02f, -2.37197429e-02f, 1.28974691e-01f, 1.53501540e-01f, 1.52823910e-01f, 7.43031455e-03f, 1.09749660e-01f, 4.81660441e-02f, -1.03731668e-02f,
  2.29547411e-01f, -1.36211321e-01f, 9.96867288e-03f, 2.39766598e-01f, 1.96324959e-01f, 1.49637163e-01f, 1.94730133e-01f, 5.47504947e-02f, -1.21656265e-02f, 3.36814374e-02f,
  9.40511525e-02f, 1.94964990e-01f, 1.56147406e-01f, 8.74420106e-02f, 2.80739665e-02f, -1.17221236e-01f, 2.78601944e-02f, -1.13629483e-01f, 7.39752650e-02f, 1.59620456e-02f,
  -6.60371780e-02f, -9.80846435e-02f, -7.10555464e-02f, -6.38317987e-02f, 3.57822962e-02f, -6.44309446e-02f, -1.16222478e-01f, -2.77215242e-02f, -4.63885330e-02f, 6.47840090e-03f,
  -4.83693816e-02f, -2.71678977e-02f, 5.53670190e-02f, -5.97382849e-03f, -2.58803740e-02f, -1.75272988e-03f, 2.23101247e-02f, 5.12053855e-02f, 1.19634597e-02f, 3.33137587e-02f,
  7.26029649e-02f, 1.47332111e-02f, 5.95942326e-02f, 2.73034889e-02f, 3.46905440e-02f, 5.04602268e-02f, -2.33642589e-02f, -4.87285405e-02f, 1.57804147e-03f, 1.77618384e-03f,
  3.46970856e-02f, -4.79408763e-02f, 9.34025645e-03f, -7.88439997e-03f, -2.10759556e-03f, 4.47423346e-02f, 1.00895502e-02f, 1.34063391e-02f, -4.34877761e-02f, 2.49386653e-02f,
  9.85247493e-02f, -3.77638452e-02f, -2.04352792e-02f, 2.77960626e-03f, -4.15387079e-02f, -6.68177521e-03f, -4.43782210e-02f, 2.98475120e-02f, 6.35534599e-02f, -3.84517224e-03f,
  -3.58597599e-02f, 5.24405427e-02f, 1.30573874e-02f, -1.51188141e-02f, -2.46510003e-02f, 1.67171913e-03f, 2.75752265e-02f, 3.62617336e-02f, 2.26121172e-02f, -8.28557927e-03f,
  -8.32463279e-02f, -1.08631283e-01f, -6.65796455e-03f, 5.38995117e-03f, -4.52770069e-02f, 3.75687815e-02f, -3.78061272e-02f, 4.22719494e-02f, -6.95673674e-02f, 3.53913084e-02f,
  1.02177716e-03f, -2.10954621e-02f, -8.36627558e-03f, 2.21921206e-02f, 6.89486135e-03f, 1.79890841e-02f, -4.62086499e-03f, -1.09209068e-01f, 1.87154103e-03f, -2.30382551e-02f,
  -3.89277153e-02f, 4.77671530e-03f, -2.52925400e-02f, 1.41121279e-02f, 1.30922887e-02f, 1.61554513e-03f, -5.80260297e-03f, 1.56905779e-04f, 4.69833501e-02f, 1.26334913e-02f,
  -1.76701710e-01f, -2.55962759e-01f, 2.75024891e-01f, 5.23099527e-02f, -9.13044438e-02f, 2.00804025e-02f, 4.25369889e-02f, -3.67554910e-02f, -4.56743725e-02f, -1.33452132e-01f,
  -7.54650980e-02f, -4.12267745e-02f, -1.15880579e-01f, 5.31967394e-02f, -1.53513953e-01f, -8.94837454e-02f, 1.44310493e-03f, 2.72069536e-02f, 3.52374353e-02f, -3.51906568e-02f,
  5.86513057e-02f, -2.12106571e-01f, 6.64799884e-02f, -2.12759227e-02f, -1.26990629e-02f, 1.38338596e-01f, -1.01771027e-01f, 9.87471119e-02f, 3.42516340e-02f, -4.13650051e-02f,
  -2.73189060e-02f, 9.04655457e-03f, 5.39364330e-02f, 6.69834092e-02f, 3.96688879e-02f, -1.13920271e-02f, 4.04809080e-02f, 2.70168260e-02f, 1.77658126e-02f, 5.52489832e-02f,
  1.82593204e-02f, -1.82164460e-02f, 4.82424721e-02f, 1.48045560e-02f, -7.58545548e-02f, 4.65291366e-02f, -9.00356472e-03f, 8.44025239e-02f, -1.73322558e-02f, 3.00897136e-02f,
  3.78000811e-02f, 3.66653986e-02f, 4.76770699e-02f, -3.18336338e-02f, 3.41318138e-02f, 2.10723653e-02f, 4.19057161e-02f, 5.05748987e-02f, -3.79732102e-02f, -3.87068023e-03f,
  5.15586287e-02f, -9.59024057e-02f, -3.70046198e-02f, 3.94152217e-02f, -1.54847963e-04f, 6.91439807e-02f, 1.99277047e-02f, 3.05606164e-02f, 5.78654259e-02f, -4.88526858e-02f,
  6.26194477e-03f, -3.03493440e-02f, -2.39377860e-02f, 4.90203314e-02f, 8.18959158e-03f, 3.63608710e-02f, 2.58837752e-02f, 2.19873115e-02f, 1.98690742e-02f, 6.87447339e-02f,
  -2.75949109e-02f, 1.13405008e-02f, -1.92240179e-02f, 2.33252048e-02f, -3.88061106e-02f, -6.22813292e-02f, 6.41746372e-02f, 7.71359950e-02f, 2.15280354e-02f, 1.96519643e-02f,
  -3.45388353e-01f, -1.96037471e-01f, -1.16339616e-01f, -2.53239144e-02f, -3.17016654e-02f, -7.84301609e-02f, 6.32233173e-02f, 1.31639587e-02f, -5.91396168e-02f, -1.38468333e-02f,
  6.19155318e-02f, 3.99680883e-02f, 1.70135067e-03f, 2.46873703e-02f, -3.76509950e-02f, -5.02238348e-02f, -1.45058874e-02f, -5.25220446e-02f, -1.33265197e-01f, -1.92183554e-02f,
  7.93766323e-03f, -3.66015732e-02f, 6.64209127e-02f, -3.05277742e-02f, 7.46797398e-03f, -1.65899266e-02f, -3.64172570e-02f, 7.49313757e-02f, 3.17453698e-04f, 3.99241857e-02f,
  -3.74549516e-02f, -9.82778594e-02f, 2.99196005e-01f, 2.53224492e-01f, -1.78033084e-01f, -2.76410043e-01f, 1.97579898e-02f, 5.08423708e-02f, 4.69467975e-02f, -1.23465016e-01f,
  7.36612901e-02f, -1.84686780e-01f, -1.47299448e-04f, 1.64404482e-01f, 3.14661562e-02f, 1.00861944e-01f, 1.18243814e-01f, 2.50089690e-02f, 1.54663101e-01f, 4.88450862e-02f,
  1.70205250e-01f, -7.72701204e-02f, 3.48182678e-01f, -6.43831640e-02f, 8.60911235e-02f, 1.13995343e-01f, -3.25006358e-02f, -2.54827477e-02f, -9.08182487e-02f, -6.78400546e-02f,
  -8.10125917e-02f, 1.60594642e-01f, 8.47586989e-02f, 1.31588418e-03f, 1.11486785e-01f, -5.91999218e-02f, 1.41794756e-02f, 5.88748464e-03f, 4.71498519e-02f, 2.59106737e-02f,
  -7.03637376e-02f, -1.67558454e-02f, 2.89449785e-02f, -3.58500853e-02f, -3.83846723e-02f, 2.11212132e-02f, -2.34886538e-02f, 2.56127995e-02f, -9.48718167e-04f, 4.92180288e-02f,
  3.82053368e-02f, 4.45254929e-02f, 6.04262948e-02f, 3.16146798e-02f, 7.01962858e-02f, 8.73294473e-03f, 6.67658448e-02f, -1.96913891e-02f, -8.45655650e-02f, -2.49231309e-02f,
  9.49309617e-02f, -3.74951027e-02f, -4.10279557e-02f, 4.07218710e-02f, -5.14510348e-02f, 2.92248446e-02f, -5.80253676e-02f, -2.93023791e-03f, 1.71358772e-02f, 1.62901431e-02f,
  -3.14155035e-02f, -4.00830843e-02f, -2.46987157e-02f, -1.22170961e-02f, -3.86808859e-03f, 9.69561189e-03f, 5.79718761e-02f, -1.23391576e-01f, -1.22111393e-02f, 3.48496847e-02f,
  -6.15998320e-02f, -3.41096986e-03f, 1.48861622e-02f, 2.78362799e-02f, -3.41999717e-02f, 8.51086713e-03f, -4.28508408e-03f, -2.06877738e-02f, 3.62510681e-02f, -6.76886961e-02f,
  -3.76983285e-01f, -3.36711377e-01f, -1.76601596e-02f, -8.26735273e-02f, -9.35334247e-03f, -5.17015010e-02f, 5.19555695e-02f, -3.30713876e-02f, -2.60558110e-02f, 2.05578450e-02f,
  -4.07559983e-02f, 3.20473239e-02f, -1.93119794e-02f, 7.05662072e-02f, -2.60464544e-03f, -5.67480475e-02f, -2.02999860e-02f, -5.34943230e-02f, -8.97350982e-02f, -4.48391475e-02f,
  -4.30245884e-02f, -6.87928125e-02f, 3.21834311e-02f, 2.40862705e-02f, -2.00080909e-02f, -2.57818848e-02f, -1.30354971e-01f, 1.98358502e-02f, -1.13371290e-01f, -5.09144515e-02f,
  -3.17975402e-01f, -1.77686274e-01f, -3.09277505e-01f, -6.23538718e-02f, 1.70742103e-03f, -9.37514082e-02f, -7.99707249e-02f, -8.52080248e-03f, -9.74585563e-02f, 1.87038541e-01f,
  1.09334320e-01f, 2.57955510e-02f, -1.16185367e-01f, 1.64752170e-01f, -2.53460072e-02f, -1.72655694e-02f, 1.10745244e-01f, 1.06850438e-01f, -5.97494394e-02f, -6.52167872e-02f,
  -4.60796729e-02f, 2.70145237e-01f, -6.10340834e-02f, 1.76107585e-01f, -1.59843415e-02f, -8.92458260e-02f, 2.01465324e-01f, -1.75072756e-02f, 1.55455649e-01f, 1.65479079e-01f,
  -1.04584945e-02f, -3.45199965e-02f, -4.31434549e-02f, 2.37306245e-02f, -2.53445320e-02f, 1.73023064e-02f, -9.90149006e-03f, 2.68075485e-02f, -4.31708917e-02f, -2.74801310e-02f,
  2.02586967e-02f, 4.02905941e-02f, 6.16847947e-02f, 5.63467480e-02f, -3.35484035e-02f, -4.77837585e-02f, -7.98996985e-02f, -3.65744419e-02f, -4.42129187e-02f, -1.07286356e-01f,
  -1.34833917e-01f, -6.33695573e-02f, -2.82997638e-02f, 4.55418453e-02f, -9.01197195e-02f, -2.60197856e-02f, -1.07288372e-03f, -6.22657426e-02f, 3.20085883e-02f, -2.72642877e-02f,
  -5.22689149e-03f, 3.97700667e-02f, -3.57293151e-02f, -8.27019662e-03f, -1.42936483e-02f, 1.76574979e-02f, 3.83084379e-02f, 5.74715659e-02f, -1.59837008e-02f, -1.93564892e-02f,
  2.92536840e-02f, -3.24186161e-02f, 6.67361915e-02f, 1.64620634e-02f, 6.20835286e-04f, 2.47428603e-02f, -3.23368683e-02f, 3.83084081e-02f, -3.53775322e-02f, -6.44790977e-02f,
  1.17113274e-02f, -6.57616591e-04f, -1.33108292e-02f, -1.01832265e-03f, 3.39135155e-02f, -1.52717149e-02f, 9.37726572e-02f, -6.40915409e-02f, -2.41838838e-03f, 2.54207626e-02f,
  4.01643775e-02f, 4.87187617e-02f, -9.21369996e-03f, 6.36681989e-02f, 4.32471484e-02f, -2.37075333e-02f, 1.98602695e-02f, -8.98699090e-03f, 9.36621428e-03f, -6.74598385e-03f,
  -1.93282995e-05f, -2.12030532e-03f, 4.65255864e-02f, -9.26342618e-05f, 7.83575699e-02f, -3.94134708e-02f, 7.43840635e-02f, 8.46172869e-02f, 7.98135996e-02f, 3.63786407e-02f,
  3.06717455e-02f, -4.41647992e-02f, 5.76648265e-02f, -4.10072990e-02f, 5.71739785e-02f, 1.21520339e-02f, -1.71519741e-02f, 3.51736844e-02f, -2.24748403e-02f, 7.00010732e-02f,
  3.61423850e-01f, 6.50037676e-02f, 3.14745694e-01f, 5.56627177e-02f, -1.07029453e-02f, -4.59132969e-01f, -2.03362927e-01f, -9.05739069e-02f, 5.96508570e-02f, -3.10508817e-01f,
  -2.19273299e-01f, 1.53598413e-01f, -1.71904806e-02f, -3.50144953e-01f, -1.37461603e-01f, -8.43943879e-02f, -2.77964622e-01f, -9.53933746e-02f, 1.10052973e-01f, 7.99181238e-02f,
  5.04102223e-02f, -3.48481864e-01f, -7.98585638e-03f, -1.34058625e-01f, -3.82195897e-02f, 1.18057922e-01f, -9.41750631e-02f, 1.07200779e-01f, -2.18742162e-01f, -5.76248839e-02f,
  -9.08327401e-02f, 8.63346979e-02f, 7.62888119e-02f, 4.79148328e-02f, -4.97006811e-02f, 4.64225076e-02f, 3.90669964e-02f, 6.28188178e-02f, 4.34612259e-02f, -3.18858027e-02f,
  1.16349841e-02f, 2.81860996e-02f, -4.82541285e-02f, -1.88123733e-02f, 4.15601656e-02f, 4.38738354e-02f, -8.07358883e-03f, -4.45928760e-02f, 3.83842476e-02f, 5.37354834e-02f,
  2.11682804e-02f, 2.84069348e-02f, -1.28498208e-02f, -7.58123072e-03f, 5.76008298e-02f, 1.39785334e-02f, 3.37302610e-02f, -1.01673864e-02f, -5.89803532e-02f, 2.05397997e-02f,
  -2.55106520e-02f, 2.97539532e-02f, -7.63534056e-03f, 1.58231030e-03f, 2.70182341e-02f, 4.57993373e-02f, -3.96902524e-02f, -2.01841369e-02f, 5.86723238e-02f, -1.38190603e-02f,
  2.68036290e-03f, 5.82297146e-02f, -4.23213188e-03f, -6.28419640e-03f, -2.22528838e-02f, 4.11397172e-03f, 2.39286683e-02f, -7.37508433e-03f, 1.58097465e-02f, -5.30676283e-02f,
  9.00552869e-02f, -2.26836484e-02f, -6.57029077e-03f, -1.23037612e-02f, -5.12454100e-02f, -3.28875659e-03f, -4.45358083e-03f, 2.56308261e-02f, -9.06316657e-03f, -1.53196808e-02f,
  -2.11794719e-01f, -7.81831816e-02f, -5.49114756e-02f, -1.92424878e-02f, 1.99980326e-02f, 2.59251762e-02f, -1.43160708e-02f, -4.31905612e-02f, -7.33726611e-03f, -4.03004838e-03f,
  -2.67275479e-02f, 1.75595824e-02f, 3.70248035e-02f, -2.21339595e-02f, -3.08670271e-02f, -4.41779010e-02f, 1.44417929e-02f, 2.02859305e-02f, -4.56997193e-02f, -4.14088601e-03f,
  -9.98590514e-03f, 1.61504950e-02f, 3.37233394e-02f, -4.56485786e-02f, -2.57165171e-02f, -2.26495191e-02f, -1.33207059e-02f, 7.45048374e-02f, -1.35403713e-02f, -2.24179961e-02f,
  1.72841936e-01f, -2.46586218e-01f, 1.57299981e-01f, -6.73741475e-02f, 2.66065389e-01f, 2.14984909e-01f, 1.05528668e-01f, 2.78212726e-02f, -1.58987090e-01f, -2.67192662e-01f,
  -3.50314490e-02f, 7.23964944e-02f, -1.16674788e-01f, -1.45941019e-01f, 2.02107787e-01f, -2.30224833e-01f, -1.32582471e-01f, -8.49383473e-02f, -1.14120148e-01f, -3.80364545e-02f,
  -3.17116119e-02f, -6.62912801e-02f, 1.25706807e-01f, -2.83427276e-02f, 1.67620495e-01f, 2.19864883e-02f, -6.59814179e-02f, 1.13239072e-01f, 1.24414966e-01f, 1.63746938e-01f,
  -2.26115230e-02f, -6.30806014e-02f, -1.36490650e-02f, 7.60299936e-02f, 7.10325837e-02f, 2.40277313e-02f, -9.85889137e-03f, 8.42866078e-02f, 5.82015999e-02f, 3.98738235e-02f,
  -2.45405063e-02f, 6.26715049e-02f, -4.68921103e-02f, -2.87674461e-02f, -1.12521099e-02f, 5.30166775e-02f, 1.13777526e-01f, 5.57841882e-02f, 8.86359215e-02f, 1.19097792e-01f,
  1.11812301e-01f, 6.58569708e-02f, 5.62711321e-02f, 6.14464842e-02f, 7.06232265e-02f, 2.02965531e-02f, 6.35924786e-02f, 9.67933387e-02f, -4.51669516e-03f, 6.34247288e-02f,
  -4.52468023e-02f, -4.28714007e-02f, 3.53369415e-02f, 9.52910923e-04f, -3.81899886e-02f, 4.12714630e-02f, -3.50287110e-02f, 2.13538203e-02f, 2.92535499e-02f, -6.11286499e-02f,
  -3.05293407e-02f, 1.63615460e-03f, -4.55111526e-02f, 4.86375727e-02f, -1.77215878e-02f, -2.10623853e-02f, 4.25190553e-02f, 6.44358397e-02f, -2.50697718e-03f, 2.42952816e-02f,
  -4.44200896e-02f, -1.04154628e-02f, -2.87161134e-02f, 6.85770288e-02f, -4.00939621e-02f, 4.40786667e-02f, -1.61251426e-02f, 5.61023727e-02f, -5.10919243e-02f, 6.44249246e-02f,
  -1.77513301e-01f, -2.08525911e-01f, -4.18535657e-02f, 3.15514728e-02f, -5.70511930e-02f, 7.52291991e-04f, -1.81539990e-02f, -3.08365021e-02f, -5.22418395e-02f, -5.32323271e-02f,
  7.11472631e-02f, 1.72478464e-02f, -6.26771748e-02f, -6.27809344e-03f, -5.10505028e-02f, -4.37008822e-03f, 9.91991162e-03f, -2.79029906e-02f, 2.29324102e-02f, 1.51607050e-02f,
  -8.86125397e-03f, 1.29661746e-02f, 4.78158612e-03f, 8.14190283e-02f, -3.23891379e-02f, 6.70656711e-02f, -1.06441937e-02f, 1.53677678e-02f, 9.68654156e-02f, -2.27167737e-02f,
  4.35131133e-01f, -2.45592088e-01f, 1.73782766e-01f, 2.98383147e-01f, 1.13386229e-01f, -1.31377339e-01f, -2.70804781e-02f, 4.97617275e-02f, 6.84481040e-02f, -3.01907092e-01f,
  2.48086918e-02f, -2.62604188e-02f, -1.17079630e-01f, 7.31665194e-02f, 2.95939416e-01f, -6.70825168e-02f, 1.40563369e-01f, -9.11349878e-02f, -1.08490773e-02f, 4.89899665e-02f,
  1.56352252e-01f, 7.60762542e-02f, 1.44001752e-01f, -7.84701183e-02f, 1.03252299e-01f, 5.10138534e-02f, 6.11624978e-02f, -4.00538035e-02f, -6.09869778e-04f, -8.88200756e-03f,
  -5.02982996e-02f, 6.77205026e-02f, 2.62490753e-02f, -4.11199182e-02f, 5.35457991e-02f, 9.18778963e-03f, 1.04747131e-03f, 7.13897229e-04f, 6.82470798e-02f, -2.95613310e-03f,
  -3.06951739e-02f, 2.54079467e-03f, -1.31211728e-02f, -1.14593934e-02f, 2.45418865e-02f, 3.33944848e-03f, -1.88516569e-03f, 2.36089975e-02f, 4.81872587e-03f, 2.45221481e-02f,
  -2.54085436e-02f, 2.63640918e-02f, 5.61089367e-02f, -2.94163562e-02f, 8.17607641e-02f, 6.17628591e-03f, -5.85220801e-03f, 1.03948088e-02f, -2.79731322e-02f, 1.89785790e-02f,
  6.90861568e-02f, -2.70060711e-02f, -3.85875180e-02f, -4.18236014e-03f, -1.55445784e-02f, 1.48290917e-02f, -4.56565395e-02f, 8.83656368e-03f, 3.43653187e-02f, -1.24694575e-02f,
  2.46469136e-02f, 2.67070793e-02f, -1.82664525e-02f, 1.01051927e-02f, 2.19287891e-02f, 1.17083723e-02f, 1.69239065e-03f, -5.62686920e-02f, 5.25247231e-02f, 3.22956368e-02f,
  -4.16969173e-02f, -7.02804234e-03f, -5.50748408e-02f, 3.15568298e-02f, -7.99980685e-02f, 3.74028608e-02f, 2.86160018e-02f, -1.53560480e-02f, -9.63915605e-03f, 7.06259385e-02f,
  -1.15586035e-01f, 2.41651982e-02f, -1.87191721e-02f, -6.89877942e-02f, -8.12636986e-02f, -3.36226486e-02f, 2.31811833e-02f, 3.03384699e-02f, -3.29794958e-02f, 5.10486716e-04f,
  -8.10274796e-04f, -1.72512159e-02f, -2.51664463e-02f, 1.18032498e-02f, 1.71909891e-02f, 4.95440653e-03f, -2.54361937e-03f, -1.54467868e-02f, 3.54667641e-02f, -2.28749774e-02f,
  -1.67302676e-02f, -3.06980126e-02f, 1.42395785e-02f, 2.04982376e-03f, 1.76209584e-02f, -2.50759795e-02f, 2.80228946e-02f, -8.79908539e-03f, 2.47165244e-02f, -5.03801787e-03f,
  1.94999576e-01f, -2.84408983e-02f, 1.22530274e-01f, -1.60965562e-01f, -1.58463448e-01f, -4.01902705e-01f, 1.52736681e-03f, -2.13591963e-01f, -1.22624561e-01f, 2.33459994e-02f,
  -2.08539516e-01f, 1.61832154e-01f, 1.41477123e-01f, -2.37005442e-01f, -2.06945956e-01f, 5.96214943e-02f, -2.93947339e-01f, -1.06086887e-01f, -3.46734398e-03f, -4.89828177e-03f,
  -6.79473802e-02f, -2.40326762e-01f, 3.56938541e-02f, -1.47363216e-01f, -6.82957470e-03f, 9.17987749e-02f, 1.87398344e-02f, 1.49712861e-01f, -1.16426483e-01f, -1.03787847e-01f,
  7.27601862e-03f, 5.58828004e-02f, -2.71257591e-02f, 1.10304421e-02f, -7.57812783e-02f, 3.12818587e-02f, 8.82141292e-02f, 3.09804752e-02f, 6.55428171e-02f, -3.87166962e-02f,
  4.49605696e-02f, 3.54990438e-02f, -9.57502052e-02f, 9.17945337e-03f, 5.68970405e-02f, 1.75998379e-02f, 3.55442539e-02f, -1.31375724e-02f, 5.27918302e-02f, 1.09056503e-01f,
  4.41764146e-02f, 7.43153542e-02f, -1.14698252e-02f, -2.17392985e-02f, -1.40447123e-02f, 8.40683095e-03f, 5.96601479e-02f, 6.28472194e-02f, 4.85033356e-02f, -4.16462123e-02f,
  -6.24088151e-03f, 3.12357787e-02f, -4.23877826e-03f, 5.67131117e-02f, -4.81195115e-02f, -8.53971858e-03f, 2.37338971e-02f, -5.55869518e-03f, 5.72833307e-02f, 3.54019552e-02f,
  -6.38715997e-02f, -1.85392853e-02f, -3.50908318e-04f, 2.11511049e-02f, -5.98602649e-03f, 3.67164128e-02f, 2.94414535e-02f, 3.95830115e-03f, -3.78681831e-02f, -2.74195219e-03f,
  3.98744605e-02f, -6.01984076e-02f, 2.75429189e-02f, 3.85127105e-02f, -1.96176581e-02f, -3.57674062e-02f, -7.61821717e-02f, 6.01325603e-03f, 1.41263418e-02f, -4.13480103e-02f,
  -2.00543523e-01f, -2.14617446e-01f, 9.60946549e-03f, -1.02173965e-02f, 2.69145370e-02f, -1.83322094e-02f, -1.76114663e-02f, -1.21788733e-01f, -1.50941527e-02f, -1.06373295e-01f,
  -3.75924334e-02f, 1.82565153e-02f, 2.75004422e-03f, 4.24139313e-02f, 4.49559698e-03f, -7.23877549e-02f, 4.90081944e-02f, -4.49228995e-02f, -5.78500256e-02f, -3.85730825e-02f,
  3.34063359e-02f, 1.01610441e-02f, 1.74696520e-02f, -8.97930339e-02f, -5.14656417e-02f, 4.28068824e-02f, -2.87799053e-02f, 2.53860243e-02f, 2.04899851e-02f, -3.92651046e-03f,
  -3.37763965e-01f, 2.09524035e-01f, 1.67922199e-01f, -3.28711390e-01f, -3.19913179e-02f, -2.31497973e-01f, -3.13730091e-01f, -2.14082599e-02f, -6.21157028e-02f, 1.09656425e-02f,
  -1.45407334e-01f, 7.38000572e-02f, 1.95903420e-01f, -3.03716868e-01f, -2.56113172e-01f, 4.08542231e-02f, -2.96277642e-01f, -1.78357348e-01f, 3.52734849e-02f, -7.85943791e-02f,
  -5.57958931e-02f, -1.16241939e-01f, -9.51470993e-03f, 1.55538380e-01f, -5.14592715e-02f, 1.09343678e-01f, 7.15629980e-02f, 1.57566428e-01f, -9.46327224e-02f, -2.65089199e-02f,
  -1.80833742e-01f, -7.76587874e-02f, -3.58709916e-02f, -9.10402369e-03f, -3.92343849e-02f, -1.41271558e-02f, -1.62504986e-02f, 4.22799625e-02f, 4.17976780e-03f, -4.87443246e-03f,
  3.35627794e-02f, 9.91530251e-03f, -9.76846274e-03f, 6.70932829e-02f, -6.23185933e-02f, 2.70337034e-02f, 4.76746907e-04f, 1.54538788e-02f, -2.94635743e-02f, -2.65241098e-02f,
  7.49577256e-03f, 5.99604426e-03f, -6.02060603e-03f, -7.70604610e-03f, 2.79716104e-02f, 2.54173689e-02f, -8.63414537e-03f, 5.61130717e-02f, -2.68527083e-02f, -4.76109199e-02f,
  1.18525051e-01f, 1.80085152e-02f, -3.70668694e-02f, -2.76881526e-03f, -2.21949667e-02f, -5.08387061e-03f, -2.31039245e-02f, -3.25283483e-02f, 3.94019019e-03f, -1.04116704e-02f,
  -5.42426035e-02f, -9.36212465e-02f, 2.82136239e-02f, -2.86561605e-02f, -6.04569726e-02f, -5.87185323e-02f, 6.30587786e-02f, 5.70411142e-03f, -1.80747155e-02f, -5.60319833e-02f,
  4.00440767e-02f, -3.51925613e-03f, -2.50410978e-02f, -9.04874504e-02f, -1.16227278e-02f, 5.98427616e-02f, 1.06195033e-01f, 1.90192380e-03f, 1.76576693e-02f, -6.43118769e-02f,
  -2.15466976e-01f, 3.99346603e-03f, -2.62953043e-02f, -1.02549374e-01f, 3.05295829e-02f, -1.33116404e-02f, 4.80576009e-02f, 3.20225619e-02f, 3.86360511e-02f, -3.82803753e-02f,
  4.42711711e-02f, -5.22979535e-02f, 4.44687791e-02f, -4.55598235e-02f, 8.90395045e-03f, -1.43698668e-02f, 1.87990535e-02f, 7.30842724e-02f, -8.73346031e-02f, -4.96089719e-02f,
  -2.42210590e-04f, 3.47958691e-02f, -1.07391423e-03f, -4.41257395e-02f, -8.83886870e-03f, 2.55972240e-02f, 3.68635766e-02f, 1.55574679e-02f, 9.72815789e-03f, 7.20014274e-02f,
  -2.77362734e-01f, 2.08625302e-01f, 3.28883603e-02f, -5.73551329e-03f, 2.50807464e-01f, 1.00343347e-01f, -1.67696998e-02f, 2.04235733e-01f, 1.43861501e-02f, 1.40993759e-01f,
  4.89131548e-02f, -1.50296584e-01f, -3.14468183e-02f, 2.09748581e-01f, -1.62265569e-01f, -9.13290754e-02f, 8.56957436e-02f, -1.10769451e-01f, -6.18152656e-02f, 4.33342084e-02f,
  6.59836177e-03f, 1.21724017e-01f, 1.45278201e-01f, 1.99643582e-01f, 1.38934195e-01f, 1.87648181e-02f, -4.30577993e-03f, -4.38957736e-02f, 6.66606501e-02f, -7.74950460e-02f,
  -4.62717824e-02f, 2.74635386e-03f, 8.18968713e-02f, -6.12571351e-02f, 2.02947296e-02f, 4.62646782e-02f, -5.63786924e-02f, -8.43494236e-02f, -8.43644962e-02f, -9.90137830e-03f,
  2.42199712e-02f, 3.46371420e-02f, -8.24868903e-02f, -2.58745765e-03f, 1.25193775e-01f, 6.72497153e-02f, 1.29263535e-01f, 6.47915527e-02f, 6.53752163e-02f, 5.78283593e-02f,
  8.99626985e-02f, 4.73080156e-03f, 3.05356942e-02f, -3.76608297e-02f, 3.26647013e-02f, 3.20213214e-02f, 2.21351185e-03f, -2.55355332e-02f, -2.56935358e-02f, 3.95916365e-02f,
  -3.08775157e-02f, -7.37542734e-02f, 3.50730331e-03f, -9.17229522e-03f, -2.03081369e-02f, 5.95962107e-02f, 4.18577492e-02f, -3.38286459e-02f, -9.82346088e-02f, 2.52577588e-02f,
  1.77390724e-02f, 8.05439427e-03f, 4.84098457e-02f, -5.00275521e-03f, 6.11253036e-03f, 4.09757980e-04f, -3.22847702e-02f, -9.02540982e-02f, 8.17636028e-03f, 1.43924253e-02f,
  -6.16051815e-03f, 1.83894988e-02f, -4.62879799e-02f, -1.01424148e-02f, 6.57506734e-02f, -2.90208105e-02f, 2.72979047e-02f, 8.59631300e-02f, 6.27240688e-02f, -2.56564841e-02f,
  -1.17936991e-01f, -1.47202551e-01f, 2.85260044e-02f, 1.30677922e-02f, 1.79925642e-04f, 1.17999204e-01f, 2.37467140e-02f, 5.86289819e-03f, -2.13813446e-02f, -4.12887409e-02f,
  5.13100550e-02f, 5.24731390e-02f, -5.27471825e-02f, -3.24497968e-02f, -5.13350256e-02f, 7.86352232e-02f, -6.17590435e-02f, -4.88227643e-02f, -1.18887499e-02f, 2.73209754e-02f,
  2.29133423e-02f, 2.76333708e-02f, 8.87639597e-02f, 1.92042496e-02f, 1.88175112e-03f, -1.69461723e-02f, -4.31446359e-02f, 1.86432432e-02f, -5.22508509e-02f, 2.69354694e-02f,
  -1.35918185e-01f, -9.28221494e-02f, 1.08524680e-01f, 4.88360077e-02f, -2.08334178e-01f, -1.20673634e-01f, -4.21401532e-03f, -1.44710332e-01f, 2.24924341e-01f, 8.45694467e-02f,
  -5.11445105e-02f, 1.29000982e-02f, 3.60012315e-02f, -1.52950725e-02f, -3.46243791e-02f, 1.62529141e-01f, 1.23752384e-02f, 1.32468734e-02f, 8.95779207e-02f, -1.07974328e-01f,
  1.79830063e-02f, -1.80461392e-01f, 3.31689510e-03f, -2.02005506e-01f, -1.77127987e-01f, -2.08414476e-02f, -1.15816221e-02f, -4.43275571e-02f, -1.43827274e-01f, -2.41757445e-02f,
  -1.38366356e-01f, 7.40220398e-02f, -4.47661467e-02f, 9.92671773e-02f, -1.99728440e-02f, -2.42607463e-02f, 4.26326320e-02f, 9.93074626e-02f, -1.57262653e-03f, -5.93942218e-02f,
  -1.14806658e-02f, -2.22193673e-02f, 1.07965423e-02f, 6.85583726e-02f, -7.74018168e-02f, 2.39663552e-02f, -5.58019727e-02f, -2.75083911e-02f, -2.42777634e-02f, 9.98526216e-02f,
  1.62026137e-02f, 3.57844234e-02f, 5.52933849e-02f, 3.51355225e-02f, 4.03930172e-02f, 2.58317478e-02f, 7.39446953e-02f, -1.28929894e-02f, -1.35144114e-01f, -1.03199529e-02f,
  -1.23960245e-02f, 9.94207636e-02f, 2.12107152e-02f, -8.32843482e-02f, -4.66830470e-02f, 7.04413205e-02f, 3.26692387e-02f, -3.30566131e-02f, 1.02005713e-02f, -7.70961791e-02f,
  -3.09318602e-02f, 5.68104954e-03f, 5.66626303e-02f, 1.24197677e-01f, 3.25341560e-02f, 1.39293835e-01f, -4.92357984e-02f, -8.26932341e-02f, 1.61608066e-02f, -3.88497040e-02f,
  1.11337520e-01f, 2.30615288e-02f, 1.62615720e-03f, -3.55594754e-02f, 3.36175710e-02f, -2.16435199e-03f, 6.78114220e-03f, 1.71365608e-02f, -3.28622572e-02f, -5.38268276e-02f,
  -2.28267223e-01f, -1.24216020e-01f, -1.72868383e-03f, -5.64977191e-02f, -3.54336165e-02f, -9.43023339e-02f, 2.21071877e-02f, -2.87399869e-02f, -4.93929535e-02f, 4.02821638e-02f,
  -4.50418219e-02f, 1.04262854e-03f, -1.85185280e-02f, -7.23555591e-03f, -7.32938349e-02f, 6.62767068e-02f, 4.71896827e-02f, -2.99527422e-02f, -1.34261474e-01f, -3.43990587e-02f,
  -8.42030812e-03f, -2.91026589e-02f, -3.74163017e-02f, -5.52211292e-02f, -2.93103307e-02f, 1.45574613e-02f, -1.60290673e-02f, 1.21643029e-01f, -6.86201546e-03f, -2.65239980e-02f,
  -2.86908690e-02f, 1.07106872e-01f, 1.47462368e-01f, -6.06685169e-02f, 1.64310738e-01f, 1.25776634e-01f, -1.90751180e-02f, 1.37964711e-01f, 2.29303434e-01f, -2.78898418e-01f,
  -1.33802965e-02f, -3.21942985e-01f, 7.98716620e-02f, -2.45330125e-01f, -2.42209673e-01f, 8.02593231e-02f, -9.05659422e-02f, -1.95820749e-01f, 1.61465243e-01f, -1.30720856e-02f,
  5.02211563e-02f, -2.34446153e-01f, -1.75037086e-01f, -8.81246179e-02f, -1.99083284e-01f, 4.34376784e-02f, -1.77587375e-01f, 1.20858379e-01f, -2.12035283e-01f, -1.68259665e-02f,
  -4.60841842e-02f, 3.33501287e-02f, 2.40036845e-02f, 7.86167383e-02f, -8.45402181e-02f, -1.61700905e-03f, -9.66616794e-02f, -1.74742460e-03f, 9.74201486e-02f, -1.01860769e-01f,
  -2.99583152e-02f, -1.00509644e-01f, -2.14184895e-01f, 3.99731994e-02f, 1.04709193e-01f, 2.63049416e-02f, -2.09954325e-02f, 1.35547385e-01f, 1.41085302e-02f, 3.47665846e-02f,
  6.50273170e-03f, -1.91198792e-02f, -1.29501065e-02f, 5.40576503e-02f, 3.62201817e-02f, 1.31645128e-01f, 2.40832027e-02f, -5.26429079e-02f, -6.81419447e-02f, 4.57407162e-02f,
  3.41793546e-03f, 1.39569193e-01f, -3.08325235e-02f, 2.31339913e-02f, -1.54544950e-01f, -2.17187125e-02f, -2.93651037e-02f, -5.55741116e-02f, 2.03424636e-02f, -1.79279428e-02f,
  3.84629592e-02f, -1.08133396e-02f, -5.58939856e-03f, 5.57403825e-02f, -3.15707438e-02f, 1.88082661e-02f, 4.46108729e-03f, -1.96528323e-02f, -3.13948579e-02f, -8.91692489e-02f,
  4.13904451e-02f, 8.09108242e-02f, -2.88018528e-02f, -2.08341833e-02f, -7.67258136e-03f, -4.04553041e-02f, 1.05504848e-01f, 2.50793919e-02f, 7.60556087e-02f, -7.00221304e-03f,
  1.30548924e-01f, 1.69899434e-01f, 4.19233702e-02f, 6.78965226e-02f, -2.22445950e-02f, -4.47109379e-02f, 1.23028057e-02f, -1.44341812e-02f, 3.27637158e-02f, -7.65848532e-03f,
  -5.95690161e-02f, 3.26174800e-03f, -2.28469633e-02f, 1.21951781e-01f, -5.51610254e-02f, -1.09220287e-02f, -1.44461114e-02f, 1.07907601e-01f, 1.49535397e-02f, 7.50770001e-03f,
  1.99417416e-02f, 1.76063105e-02f, -1.87932402e-02f, -6.44705147e-02f, -5.68411462e-02f, -3.84967178e-02f, -2.14996599e-02f, 1.95919871e-02f, -6.69798702e-02f, -6.43678308e-02f,
  2.99126327e-01f, 4.63677496e-02f, 1.60112858e-01f, 3.61714929e-01f, 5.69695309e-02f, -2.03500524e-01f, 1.01703173e-03f, 1.40578791e-01f, 2.71480560e-01f, -2.85454243e-02f,
  -4.46985438e-02f, 2.51136363e-01f, -2.21870571e-01f, 1.20358676e-01f, -1.98849693e-01f, -1.17441952e-01f, -6.37749806e-02f, -3.65160517e-02f, 4.57365587e-02f, 2.62191426e-02f,
  3.17195198e-03f, -2.37965751e-02f, -1.44538015e-01f, -6.49538171e-03f, -7.87554774e-03f, 1.38585180e-01f, -2.58549809e-01f, -1.11681350e-01f, -3.48533653e-02f, -5.58591299e-02f,
  -4.88156453e-02f, 2.46862397e-01f, -5.94676211e-02f, -4.34199534e-02f, -1.02810323e-01f, -4.61129472e-02f, -1.14803404e-01f, -7.28299841e-02f, 3.75438705e-02f, 3.40408981e-02f,
  2.05667466e-02f, 1.07364029e-01f, 1.33685255e-02f, 2.35204156e-02f, 2.96480451e-02f, 8.76386985e-02f, 4.72743548e-02f, -2.17349045e-02f, 4.10099700e-02f, 4.28071283e-02f,
  -2.56378110e-02f, -7.23654106e-02f, -4.66727093e-02f, -3.80185284e-02f, -8.71183202e-02f, 9.54224840e-02f, -3.17968777e-03f, -3.39951366e-02f, -9.38846916e-02f, 9.83646512e-02f,
  8.07077214e-02f, -8.71851444e-02f, 1.67109799e-02f, 3.34355421e-02f, 4.45915684e-02f, 1.54326251e-02f, -5.91395125e-02f, -8.90982598e-02f, -3.40102389e-02f, -6.01696335e-02f,
  9.46930796e-03f, 2.98673026e-02f, 8.40751752e-02f, 8.75441730e-03f, 6.46021664e-02f, -4.66036797e-03f, 1.05729392e-02f, 9.17738676e-02f, -3.69957797e-02f, 3.66882943e-02f,
  3.75638790e-02f, -2.89174169e-02f, -1.05544880e-01f, -8.03793147e-02f, -2.47599818e-02f, -2.77947504e-02f, -1.42829809e-02f, -8.02905019e-03f, -3.06196231e-02f, -1.52704567e-01f,
  -2.49626607e-01f, -5.28581180e-02f, -1.42774954e-01f, -4.69021462e-02f, 5.56517206e-02f, -7.29128048e-02f, 8.36063251e-02f, -2.27078274e-02f, -5.76582104e-02f, 3.39766815e-02f,
  -2.24524438e-02f, -6.57259077e-02f, -3.44615467e-02f, 6.16556872e-03f, -6.71105012e-02f, -4.26032068e-03f, -3.40303592e-02f, -4.25904244e-02f, -1.29746556e-01f, -3.90846059e-02f,
  -8.90951604e-02f, -1.63168963e-02f, -4.76536267e-02f, -8.46952200e-02f, -9.45112184e-02f, -8.71121883e-02f, 5.04300697e-03f, 6.98681325e-02f, -4.18158248e-02f, 5.23275929e-03f,
  -2.91032881e-01f, -5.80414943e-02f, 6.03470318e-02f, -6.94705695e-02f, -3.48924816e-01f, 1.41463146e-01f, 8.16024840e-02f, -1.62853017e-01f, 4.50497717e-02f, -3.20481770e-02f,
  8.04461166e-02f, -4.31826413e-02f, 2.81677544e-01f, 4.22827825e-02f, 2.47889996e-01f, 4.18014705e-01f, 6.35490268e-02f, 1.21993445e-01f, 4.78260405e-02f, -1.95362091e-01f,
  -5.46032302e-02f, -1.46188393e-01f, -1.25947166e-02f, -2.09989384e-01f, -2.76433617e-01f, -1.89103127e-01f, -2.27012813e-01f, 4.03197333e-02f, -1.41254455e-01f, 2.63233539e-02f,
  8.42694715e-02f, -3.40380296e-02f, -9.47118849e-02f, 5.36116175e-02f, -1.07178368e-01f, -3.89892533e-02f, 6.49757311e-03f, 6.73620850e-02f, 8.48676786e-02f, 2.39911005e-02f,
  -1.10984500e-03f, -7.81025691e-03f, -2.84751295e-04f, -1.42272692e-02f, -8.59669447e-02f, -1.22044869e-02f, 4.46315333e-02f, 1.93418562e-02f, -5.08341789e-02f, -4.50470075e-02f,
  -3.83169055e-02f, 1.26476102e-02f, -1.34528521e-02f, 3.68132927e-02f, -4.07856070e-02f, 3.74759436e-02f, 6.68365285e-02f, -6.53636009e-02f, 1.95194613e-02f, -8.82021189e-02f,
  -3.78741585e-02f, -1.61085697e-03f, 3.48151103e-02f, 3.13322581e-02f, 4.22589183e-02f, -7.46309236e-02f, 7.50837997e-02f, -1.69248469e-02f, -1.57482717e-02f, -2.34679710e-02f,
  1.13657238e-02f, -1.24954768e-02f, 2.65556891e-02f, -1.54329101e-02f, -5.79111613e-02f, -6.62501529e-02f, 4.46037054e-02f, 2.14811824e-02f, -5.63849881e-02f, 1.94990467e-02f,
  1.85551681e-02f, 1.91571061e-02f, 3.21647301e-02f, 4.28460278e-02f, 9.74049345e-02f, -6.50322139e-02f, -3.31089087e-02f, -3.36458795e-02f, 5.58204018e-02f, -3.84630673e-02f,
  9.75905657e-02f, -1.14239156e-01f, 3.65026784e-03f, 3.08641158e-02f, 8.69172961e-02f, -4.85012718e-02f, 6.69629425e-02f, -2.90525779e-02f, -1.78972725e-02f, 2.96559911e-02f,
  -1.16637595e-01f, -4.79506068e-02f, 4.57790354e-03f, -2.92024910e-02f, 8.04478675e-02f, -1.24501139e-02f, 3.43086105e-03f, 3.01428069e-03f, -7.02950433e-02f, -9.89350602e-02f,
  -6.45866394e-02f, -1.47500848e-02f, -7.51826586e-03f, -8.67342502e-02f, -2.07801666e-02f, -3.96106429e-02f, -3.41596603e-02f, -5.95950298e-02f, 4.83962372e-02f, 3.71042341e-02f,
  7.07575828e-02f, -3.15114290e-01f, 5.04825078e-02f, 2.25235984e-01f, 1.05209462e-01f, -5.45933470e-02f, 1.12623893e-01f, -9.59407259e-03f, 2.34753713e-01f, -2.25263953e-01f,
  -1.06379129e-01f, -9.22116935e-02f, -1.31800368e-01f, -1.17121842e-02f, 9.57110673e-02f, 8.98076221e-03f, 2.93615982e-02f, 2.99678184e-02f, 1.02260657e-01f, -8.41945708e-02f,
  2.29769736e-03f, -6.27302006e-02f, -2.36206204e-02f, -1.09268650e-01f, -1.00906767e-01f, 3.29731554e-02f, -1.06643356e-01f, 6.24944344e-02f, -1.12872981e-01f, 4.97053936e-02f,
  -6.09256253e-02f, 4.14980315e-02f, -9.56989154e-02f, -1.01204604e-01f, -6.93383664e-02f, 1.57157090e-02f, -1.47362370e-02f, 2.72039063e-02f, 7.00433552e-02f, -3.53658199e-02f,
  -5.17072827e-02f, -5.56732751e-02f, -2.25236174e-02f, 5.23280539e-02f, 5.26615158e-02f, -7.18425959e-02f, -3.59383319e-03f, 4.46259603e-03f, -8.49511325e-02f, 2.97636539e-02f,
  -4.52637635e-02f, -7.70666450e-03f, -3.46436575e-02f, -2.50951685e-02f, -5.37616154e-03f, 6.24166951e-02f, 7.96255246e-02f, -4.29500779e-03f, -6.22175261e-02f, 7.57781938e-02f,
  -1.56264640e-02f, 1.12638317e-01f, 4.60038614e-03f, 2.98889969e-02f, -6.83752149e-02f, -3.39898691e-02f, -4.00535055e-02f, -3.74543518e-02f, 3.25991698e-02f, -8.90298933e-02f,
  -1.30014466e-02f, 3.73067670e-02f, 3.07265818e-02f, -2.18556495e-03f, 5.69017604e-02f, 8.63067135e-02f, -1.43724894e-02f, 1.57853402e-02f, 3.25266495e-02f, 2.85305660e-02f,
  -5.37393428e-03f, 1.21203419e-02f, -1.96366757e-02f, 4.22560163e-02f, -4.37486358e-02f, -2.90943813e-02f, 1.15480283e-02f, -2.03965418e-02f, 6.76242709e-02f, -3.51386145e-02f,
  -1.96689934e-01f, -1.26170814e-01f, -8.61886814e-02f, -8.63635615e-02f, 1.33242002e-02f, -5.79364747e-02f, 6.30766302e-02f, -4.79590297e-02f, -7.73322135e-02f, 1.07781775e-02f,
  7.91084662e-04f, -1.92671642e-02f, -9.15168151e-02f, 1.05918974e-01f, 3.27406591e-03f, 2.99930200e-03f, 2.89294235e-02f, -3.15197706e-02f, -3.92715186e-02f, -3.65416259e-02f,
  -8.57940987e-02f, -3.68986540e-02f, 2.06953734e-02f, -1.86732151e-02f, -5.06850611e-03f, -2.88097002e-02f, -3.84144373e-02f, 7.71251023e-02f, 3.30010918e-03f, -2.41681226e-02f,
  -5.08017978e-03f, 2.54576981e-01f, 1.91464685e-02f, -6.86555728e-02f, -3.22491705e-01f, 1.92810595e-01f, 2.21928492e-01f, 3.23353298e-02f, -3.60583104e-02f, 1.65367931e-01f,
  -1.81596160e-01f, -6.20711735e-03f, 5.56641333e-02f, -1.21772759e-01f, 9.89565328e-02f, 1.16472259e-01f, 1.79820910e-01f, 2.01109961e-01f, -5.45450076e-02f, 1.63997516e-01f,
  -1.52566060e-02f, -1.17872618e-01f, 6.56857640e-02f, -1.34380206e-01f, -4.98284474e-02f, -9.63276923e-02f, -6.63321316e-02f, -9.02804136e-02f, -1.15838461e-01f, -9.41753685e-02f,
  2.50147916e-02f, 2.25553592e-03f, -2.17269417e-02f, 5.43087646e-02f, 1.27607509e-02f, -1.90002343e-03f, 1.27662509e-03f, -3.74426856e-03f, -1.30364299e-01f, -3.26173417e-02f,
  7.86829069e-02f, -1.18522845e-01f, -6.92453906e-02f, -1.63983367e-02f, 3.93926613e-02f, -8.36565495e-02f, -5.16380668e-02f, 1.96340717e-02f, -8.09434354e-02f, -7.03624683e-03f,
  -3.61370482e-02f, -1.16494205e-02f, -1.52947316e-02f, 6.66173771e-02f, 4.36369404e-02f, -6.75941110e-02f, 1.50645338e-02f, 4.43797410e-02f, 3.37161943e-02f, -3.78603153e-02f,
  -6.08481131e-02f, -2.51691937e-02f, -1.37718497e-02f, -6.69915136e-03f, -2.78501138e-02f, -8.90491307e-02f, 5.96725829e-02f, 1.63399056e-03f, -3.78201529e-02f, -1.44002056e-02f,
  1.91758238e-02f, 7.15383291e-02f, -1.57406181e-02f, 6.27114847e-02f, -1.56936888e-02f, 1.03775375e-01f, 4.18747701e-02f, -4.67513017e-02f, 8.73988941e-02f, -3.03699281e-02f,
  -4.67757583e-02f, 3.80615927e-02f, 9.21290964e-02f, 2.58309767e-02f, 6.50994480e-02f, 4.56572026e-02f, -9.57210921e-03f, 1.00172125e-01f, 2.77455784e-02f, -1.45633090e-02f,
  2.76940256e-01f, 2.23904043e-01f, -3.50004137e-02f, 2.44816393e-02f, 3.40224393e-02f, 7.06983358e-02f, 1.18616158e-02f, 1.92096457e-03f, 1.76811479e-02f, 5.25933281e-02f,
  -2.36099027e-02f, 9.12809968e-02f, 1.09276883e-02f, -2.42626891e-02f, 4.59914431e-02f, -4.59850430e-02f, 1.87166817e-02f, 1.74072236e-02f, 9.03753750e-03f, -1.63370324e-03f,
  -1.04563357e-02f, -4.87641096e-02f, -9.39757470e-03f, 3.02495975e-02f, 4.89900969e-02f, -2.49955505e-02f, 2.46411506e-02f, 2.64625102e-02f, -1.72644332e-02f, 9.23615135e-03f,
  -2.11971208e-01f, -1.09137721e-01f, -3.44378576e-02f, -1.98818594e-01f, 1.28440976e-01f, -6.90325797e-02f, -1.73963398e-01f, 8.70757997e-02f, -1.25009403e-01f, -1.11502215e-01f,
  -1.38059095e-01f, -1.89995319e-02f, -4.61623296e-02f, -2.81545550e-01f, 2.75011063e-01f, -1.18848465e-01f, -1.09909184e-01f, -2.13031679e-01f, 4.65204492e-02f, -1.69467866e-01f,
  1.16225025e-02f, -3.09462547e-02f, 2.49444623e-03f, 1.51762486e-01f, -5.77667989e-02f, 4.49339561e-02f, 1.93308786e-01f, 1.31967455e-01f, -5.85747622e-02f, 1.01035140e-01f,
  -2.79973838e-02f, -1.04619533e-01f, 6.03239611e-03f, 2.66071428e-02f, -8.16671625e-02f, 9.84951016e-03f, -1.19923828e-02f, 6.51366115e-02f, 6.69776872e-02f, -2.49842517e-02f,
  -9.58973840e-02f, 4.65640277e-02f, -3.00282929e-02f, 5.84643073e-02f, -2.69808695e-02f, 3.10292952e-02f, -3.09659839e-02f, -8.48917589e-02f, 6.06954545e-02f, -2.07881182e-02f,
  -7.85859674e-02f, -4.69494164e-02f, -6.78897351e-02f, -4.64234874e-03f, 2.94639599e-02f, -4.12731851e-03f, -2.01086327e-02f, -1.42148556e-03f, -2.97380266e-05f, 3.53283696e-02f,
  2.06314288e-02f, 5.57101294e-02f, -1.31153148e-02f, -2.24549547e-02f, -4.21392433e-02f, -3.93337430e-03f, -4.41290513e-02f, -3.99110727e-02f, -2.10215095e-02f, -3.35847847e-02f,
  3.24090309e-02f, -3.06769907e-02f, -2.80337799e-02f, -1.27779469e-02f, -4.04136591e-02f, -4.23095673e-02f, 4.38973727e-03f, -6.79297894e-02f, -3.41770425e-02f, 3.10526378e-02f,
  3.09613384e-02f, 3.25519070e-02f, -3.58334137e-03f, 5.04870154e-02f, -1.84172913e-02f, -1.43123185e-02f, -7.34497383e-02f, -4.72576134e-02f, -1.97786000e-02f, 4.79532331e-02f,
  4.17183302e-02f, 4.23180312e-02f, 2.11245529e-02f, 5.21510560e-03f, 3.43091078e-02f, 2.35467739e-02f, -3.00848819e-02f, 1.96499601e-02f, 1.19760081e-01f, 4.09224927e-02f,
  -2.76227500e-02f, -6.64889961e-02f, 3.12128593e-03f, -9.16060619e-03f, 2.74735726e-02f, 6.34717930e-04f, -6.91814199e-02f, 6.79052528e-03f, 3.78649794e-02f, 8.89409110e-02f,
  3.29577029e-02f, 1.46289042e-03f, 4.57765236e-02f, -1.23641277e-02f, -1.90962455e-03f, -1.22981463e-02f, -2.38485262e-02f, 1.80036481e-02f, 4.26876470e-02f, -1.49914541e-03f,
  1.46033511e-01f, -1.69716671e-01f, 1.07748233e-01f, 1.80868819e-01f, 9.01353732e-02f, -2.76887089e-01f, -1.70092061e-01f, 4.43500839e-03f, 5.05273119e-02f, -1.99341044e-01f,
  -3.04523874e-02f, 1.55921891e-01f, -1.81011930e-01f, 2.10378561e-02f, 2.67500971e-02f, -1.14287473e-01f, -4.10211571e-02f, -2.96618249e-02f, -2.43842583e-02f, 4.17486858e-03f,
  4.96741831e-02f, -7.13185668e-02f, 1.15220204e-01f, -5.10766357e-02f, 3.73529792e-02f, 9.60094482e-02f, 4.51236703e-02f, -2.03303080e-02f, 3.56486030e-02f, -1.43337166e-02f,
  -9.76500008e-03f, 8.13634880e-03f, 7.09271058e-02f, -5.80023155e-02f, -3.34075019e-02f, 2.07206514e-02f, 8.98732524e-03f, -1.50974104e-02f, -2.53309757e-02f, -1.58289156e-03f,
  -1.96230151e-02f, 5.15810810e-02f, -7.06895860e-03f, 2.46419497e-02f, 1.86593346e-02f, 5.26217557e-02f, 2.10032389e-02f, 8.72692838e-03f, 1.69119574e-02f, 1.12810344e-01f,
  2.94836629e-02f, 2.37126742e-02f, -4.83871587e-02f, -1.10182576e-02f, 3.27703431e-02f, -2.55775657e-02f, 8.07823911e-02f, 3.21004130e-02f, 1.58902798e-02f, 3.73452902e-02f,
  -6.96227103e-02f, -4.63269949e-02f, -2.18308670e-03f, 1.46423401e-02f, -3.23631689e-02f, 3.97193991e-02f, -1.73590649e-02f, 1.55181736e-02f, 2.33996529e-02f, -1.55727211e-02f,
  1.29297301e-02f, 7.30137303e-02f, 6.51710760e-03f, 5.96353635e-02f, 4.05044435e-03f, 5.91781512e-02f, -1.70974135e-02f, 2.69343778e-02f, -2.35002078e-02f, 9.36872810e-02f,
  -2.77754404e-02f, -6.67845905e-02f, -2.56345305e-03f, 2.06030067e-02f, -6.18788786e-02f, -7.17805559e-03f, 1.61180878e-03f, 5.19529507e-02f, 6.03313185e-03f, 3.01637151e-03f,
  -2.32760593e-01f, -1.74318179e-01f, -8.37016627e-02f, -2.37549981e-03f, -4.94458154e-02f, 4.71928902e-03f, 1.98890381e-02f, 3.17527466e-02f, -1.42162919e-01f, -2.86463089e-02f,
  -2.25406364e-02f, 8.52650777e-03f, -1.50235035e-02f, 2.57390700e-02f, -4.80131656e-02f, 3.46939750e-02f, -3.12963687e-02f, -5.46677783e-02f, -8.86528119e-02f, 3.05666635e-03f,
  5.85780703e-02f, -3.54374647e-02f, 3.62935476e-02f, -1.98015049e-02f, 4.68123294e-02f, 4.13414510e-03f, 2.39316430e-02f, 3.69946808e-02f, 3.45221683e-02f, -1.60904042e-02f,
  -7.11938962e-02f, 1.35317758e-01f, -2.48913929e-01f, 5.87781556e-02f, -5.19662462e-02f, 2.21750543e-01f, 8.01498443e-02f, 9.56088230e-02f, -6.96563423e-02f, 2.30364352e-01f,
  5.82397506e-02f, -1.38365582e-01f, -6.40308708e-02f, 2.17985019e-01f, 1.25474870e-01f, 4.08270806e-02f, 2.99195886e-01f, 1.64199576e-01f, -1.15407027e-01f, 5.91171347e-02f,
  -3.30065340e-02f, 2.21288309e-01f, -1.11710569e-02f, 7.06716701e-02f, 7.32954890e-02f, -1.18230999e-01f, 1.27702817e-01f, -1.80482417e-01f, 1.96051955e-01f, -2.61970088e-02f,
  1.42858982e-01f, 2.89956313e-02f, -1.08185880e-01f, 1.65379960e-02f, 7.82327875e-02f, -4.71177474e-02f, -2.97269747e-02f, -6.19876087e-02f, -5.35728261e-02f, 1.16500631e-02f,
  -6.11000583e-02f, 7.30331102e-03f, 6.39605476e-03f, -4.54644226e-02f, -1.54429879e-02f, -1.77102368e-02f, -1.39705949e-02f, -3.82413231e-02f, -5.15649021e-02f, -2.79157143e-02f,
  -8.53210315e-02f, -4.04707976e-02f, 1.75192207e-02f, 1.85588561e-02f, -7.43043572e-02f, -3.59585732e-02f, -2.11285353e-02f, -2.25578584e-02f, 6.09436408e-02f, 6.00922070e-02f,
  -1.53735066e-02f, 1.62625629e-02f, -3.82627919e-02f, 5.78554645e-02f, 6.83341932e-04f, -2.91756284e-03f, 3.10275406e-02f, 7.38442130e-03f, 1.00009535e-02f, 6.22581877e-02f,
  5.72308060e-03f, -4.71535511e-02f, -4.15556096e-02f, 1.24973971e-02f, 4.53962609e-02f, -1.54690361e-02f, -3.84016186e-02f, 4.00444865e-02f, -1.21316239e-02f, -4.15246226e-02f,
  -1.70851760e-02f, -7.84536172e-03f, 4.07831967e-02f, 9.42452252e-03f, 2.22912729e-02f, -3.24273966e-02f, 1.57027282e-02f, -2.20054784e-03f, -1.84469614e-02f, -8.73434637e-03f,
  3.66006136e-01f, 3.00788432e-01f, 5.69652114e-03f, 5.19700162e-02f, 5.73634133e-02f, 3.85220200e-02f, -3.27502750e-02f, 2.61275843e-03f, 4.95035648e-02f, 1.21564902e-02f,
  4.76971604e-02f, 2.02915054e-02f, 3.13323960e-02f, -2.68230354e-03f, 4.44620699e-02f, 2.65248921e-02f, -2.09826343e-02f, 5.45016536e-03f, 4.06960249e-02f, 9.99067649e-02f,
  7.83398673e-02f, 1.58215854e-02f, -4.13506776e-02f, -1.73122659e-02f, -2.42765173e-02f, 2.64770947e-02f, -1.69768054e-02f, -6.78464323e-02f, 3.03888489e-02f, 2.67365947e-02f,
  -2.31163725e-01f, 2.60815829e-01f, 1.05724826e-01f, -2.66335487e-01f, 1.36680275e-01f, -1.39012933e-01f, -2.72622585e-01f, 1.22996904e-01f, -2.28938922e-01f, 1.32033199e-01f,
  -2.00838849e-01f, 5.08248694e-02f, -1.27120584e-01f, -1.52827144e-01f, -4.09925610e-01f, -2.11794198e-01f, -2.02342853e-01f, -1.58123583e-01f, -4.33647484e-02f, 3.59471850e-02f,
  -8.38731751e-02f, -6.84050247e-02f, -7.12750480e-03f, 2.53046989e-01f, 1.29995003e-01f, 1.91732213e-01f, 8.43557417e-02f, 1.15922570e-01f, 9.96459648e-02f, 4.64303605e-02f,
  -2.28431001e-02f, -4.18972597e-02f, 5.87630458e-02f, 1.53421042e-02f, 4.46597300e-03f, 1.05060712e-02f, -2.63476912e-02f, 1.57044791e-02f, -3.82339209e-02f, 2.56491415e-02f,
  -1.71781220e-02f, -5.71219176e-02f, 5.24091651e-04f, 3.08698229e-02f, 2.27751359e-02f, -7.24094594e-03f, -7.74604687e-03f, 4.87416536e-02f, 8.39687698e-03f, -5.33074187e-03f,
  -3.91685963e-02f, 6.73854118e-03f, -6.69123158e-02f, -4.13103029e-02f, -9.41461604e-03f, -3.88940126e-02f, -1.77176818e-02f, 8.11967403e-02f, -1.88993029e-02f, -3.80559377e-02f,
  -4.97593544e-02f, -3.59651186e-02f, 2.01369617e-02f, 2.94298306e-02f, -3.69366854e-02f, 8.61834288e-02f, -4.95223403e-02f, 2.23732367e-02f, 2.00717803e-02f, 1.30356392e-02f,
  -3.25471684e-02f, -2.17671320e-02f, 6.13890449e-03f, -2.50518080e-02f, -1.09911514e-02f, 2.25332826e-02f, 1.39792971e-02f, 8.17663521e-02f, 7.97835831e-03f, 4.65583466e-02f,
  -2.67318599e-02f, -2.99899895e-02f, 3.11831869e-02f, -1.76425781e-02f, -7.22672492e-02f, -1.82027388e-02f, 2.27148123e-02f, 4.72351089e-02f, 4.55978662e-02f, -5.20479716e-02f,
  -1.27739996e-01f, -5.70195690e-02f, 2.74097063e-02f, 4.43092594e-03f, -2.82769394e-03f, 4.77061234e-02f, -2.71850955e-02f, 5.07932194e-02f, -5.92818111e-02f, 9.98318102e-03f,
  3.12679820e-02f, 2.42209975e-02f, -9.60378791e-04f, 2.79609542e-02f, -3.09731383e-02f, -3.70749310e-02f, -3.71833965e-02f, 1.79705676e-02f, 1.82802286e-02f, 5.92319574e-03f,
  -1.04608089e-02f, -3.87360789e-02f, 2.35335878e-03f, 9.33939870e-03f, 2.31739804e-02f, -4.08895835e-02f, 1.09034516e-02f, 2.30115112e-02f, 2.50919745e-03f, -1.84920747e-02f,
  1.86330810e-01f, -1.65456429e-01f, 8.88711438e-02f, 1.80510189e-02f, 3.61769237e-02f, -6.46501780e-02f, -1.56129971e-01f, -8.31884742e-02f, -1.61169797e-01f, -2.11236045e-01f,
  -1.92293301e-01f, 2.44251549e-01f, -1.66723222e-01f, 3.60897779e-02f, 2.82268941e-01f, -1.35001138e-01f, 1.43511772e-01f, 7.16332346e-02f, 1.04912762e-02f, 1.31646141e-01f,
  1.74615413e-01f, 7.41187707e-02f, 2.22862184e-01f, 6.59940392e-02f, 1.28951177e-01f, 3.35574076e-02f, 1.64481089e-01f, 2.51507219e-02f, 1.26605183e-01f, 9.30184498e-02f,
  -8.08373392e-02f, -1.26973808e-01f, 4.74067181e-02f, 8.23313370e-03f, 1.54835535e-02f, -5.04819527e-02f, 2.98389979e-02f, 4.63769883e-02f, -3.95090170e-02f, -2.34798212e-02f,
  9.16990340e-02f, 7.09717348e-02f, -3.17983935e-03f, -3.95503739e-04f, 2.37243064e-03f, -1.97378192e-02f, 3.74039710e-02f, 6.99947402e-02f, 5.09316102e-03f, 1.43677054e-03f,
  5.59913851e-02f, -2.24063993e-02f, -2.76147760e-02f, 1.32068545e-02f, 4.00593430e-02f, -5.53504825e-02f, -3.84399183e-02f, 5.57611845e-02f, 2.64421236e-02f, -4.32850271e-02f,
  4.48812060e-02f, -2.99542099e-02f, 3.61240469e-03f, -6.93715289e-02f, -2.46625002e-02f, -1.00381471e-01f, -3.37725841e-02f, 5.07557467e-02f, 4.08353768e-02f, -2.74131401e-03f,
  -4.76829708e-02f, 3.14306989e-02f, 5.37507841e-03f, 9.03289299e-03f, -1.14773717e-02f, -1.99095793e-02f, 2.89572459e-02f, 9.19838343e-03f, 1.40339676e-02f, -4.21448320e-04f,
  -5.85837774e-02f, 1.76488440e-02f, 1.18540069e-02f, 2.99416087e-03f, -5.07641807e-02f, 2.83664819e-02f, -1.97283830e-02f, -4.94703427e-02f, 2.66153552e-02f, 8.61890391e-02f,
  6.46988899e-02f, 2.29155645e-02f, -1.45503990e-02f, 3.55759822e-02f, -3.69729381e-03f, 5.51356189e-03f, 3.01905032e-02f, 5.06301224e-02f, 1.73291285e-03f, 2.79591046e-02f,
  5.61079197e-02f, 4.94548120e-02f, -2.94829030e-02f, 1.05385063e-02f, 2.33224276e-02f, -1.88322738e-02f, 9.14837793e-03f, 4.97622825e-02f, 3.71696204e-02f, 2.14589089e-02f,
  4.42264341e-02f, 7.30050961e-03f, 1.52316410e-03f, 1.00214910e-02f, -1.66187491e-02f, -2.26526670e-02f, 1.95146762e-02f, -6.30847067e-02f, 3.08977999e-02f, -4.81657349e-02f,
  -2.80959487e-01f, 2.00396553e-01f, -1.41155079e-01f, -6.56370120e-03f, -1.85210094e-01f, -2.43833259e-01f, -7.93837979e-02f, -2.15868577e-02f, -7.48362467e-02f, 3.88191730e-01f,
  1.73720971e-01f, 5.76435551e-02f, 1.77418306e-01f, 6.66822568e-02f, -3.73223782e-01f, 7.68029913e-02f, -1.00731902e-01f, 1.00982711e-02f, -7.93133825e-02f, -6.66028187e-02f,
  -1.41420096e-01f, -2.26949248e-03f, -4.12996933e-02f, -1.31275162e-01f, -1.15013622e-01f, 2.52239909e-02f, 7.92789608e-02f, 2.02728715e-02f, 7.27764070e-02f, -1.93433389e-02f,
  -4.91180010e-02f, 1.16399579e-01f, -1.60121005e-02f, -2.85342638e-03f, -9.83037893e-03f, 1.26654115e-02f, 4.38830070e-02f, -8.43917951e-04f, -3.88201475e-02f, 2.55543226e-03f,
  6.45895526e-02f, -6.27865642e-02f, -1.53246410e-02f, -1.21922335e-02f, -1.59022100e-02f, -4.99269227e-03f, -2.81832721e-02f, -2.68067550e-02f, 1.78314056e-02f, 2.72375089e-03f,
  -4.39707981e-03f, 6.33533671e-02f, -2.15480439e-02f, 1.07327245e-01f, -6.64573014e-02f, -1.91425774e-02f, 2.06140452e-03f, 2.29607299e-02f, 1.27970316e-02f, -5.07392660e-02f,
  3.66832800e-02f, -7.74393557e-03f, -3.36707160e-02f, 1.12848049e-02f, -3.63375247e-02f, 8.04316346e-03f, -9.72753763e-03f, 6.32522404e-02f, -8.96915607e-03f, 3.37502472e-02f,
  -2.14292761e-02f, -4.47109938e-02f, -3.75201106e-02f, 2.31279153e-02f, 2.28003450e-02f, -2.15628333e-02f, 1.27263262e-03f, 3.98184396e-02f, 2.37306617e-02f, -2.26610247e-02f,
  2.61619166e-02f, -8.21366832e-02f, 5.24143651e-02f, 7.29775205e-02f, 6.00564526e-03f, 2.67558787e-02f, 5.87118715e-02f, -1.04495259e-02f, -6.83467742e-03f, -2.49384865e-02f,
  3.13691124e-02f, 1.11274429e-01f, 2.24320702e-02f, 5.71968034e-02f, 9.06570107e-02f, 4.59225383e-03f, -1.63552631e-02f, -7.47688562e-02f, -5.43868281e-02f, -5.24040386e-02f,
  -3.03495396e-02f, 4.74609174e-02f, -7.76658719e-03f, 1.30078271e-02f, -4.66423621e-03f, 2.39224192e-02f, 4.29479405e-02f, 5.25056496e-02f, -2.52389256e-02f, 3.61772366e-02f,
  -5.69696119e-03f, 8.67728218e-02f, 3.02012973e-02f, -3.15340459e-02f, 1.54885296e-02f, 6.74741939e-02f, -4.63037938e-02f, -7.60871125e-03f, 2.07479335e-02f, 1.04474882e-02f,
  -2.96076566e-01f, 1.83491051e-01f, -5.74642047e-02f, -2.32357100e-01f, -3.62198465e-02f, -7.21297637e-02f, -1.61238149e-01f, -7.49095753e-02f, -1.09277315e-01f, 1.72665596e-01f,
  -1.55761629e-01f, 1.25130028e-01f, -6.56797960e-02f, -1.66103929e-01f, -3.24691117e-01f, -1.58978820e-01f, -1.91972971e-01f, 4.03699577e-02f, -1.93042234e-02f, -1.07631519e-01f,
  -1.01711810e-01f, -1.46451011e-01f, -1.88907400e-01f, 1.03501730e-01f, 1.42316371e-02f, 1.35786667e-01f, -2.77047530e-02f, 7.41087273e-02f, 4.05994616e-02f, 3.08364872e-02f,
  -2.09737197e-02f, -9.25088301e-02f, 2.87734214e-02f, 5.47426753e-02f, -9.69518498e-02f, 5.61272865e-03f, 8.24258402e-02f, -4.34190370e-02f, -7.44143575e-02f, -7.36462278e-03f,
  7.72147924e-02f, -1.06179407e-02f, 3.39890569e-02f, 4.19057868e-02f, 6.65615872e-02f, 1.98096558e-02f, -1.42660979e-02f, 7.28448406e-02f, 1.38985850e-02f, 2.97253989e-02f,
  -1.97456535e-02f, 5.23723522e-03f, -2.53762933e-03f, 7.91977048e-02f, -1.08142779e-03f, 2.71982830e-02f, -1.36403656e-02f, 8.07067975e-02f, -1.04323095e-02f, 1.68601633e-03f,
  -2.73216944e-02f, 3.08052097e-02f, -3.30573395e-02f, 3.85207497e-02f, -5.91860637e-02f, -9.26407240e-03f, 2.76955850e-02f, 1.86430151e-03f, 8.97143260e-02f, -1.84690636e-02f,
  -6.84355348e-02f, -5.93038602e-03f, 1.21964524e-02f, -3.59732360e-02f, -1.42943272e-02f, 4.80414229e-03f, -3.29432636e-02f, 1.15811182e-02f, -7.42948428e-03f, -3.19717899e-02f,
  4.67210263e-02f, -5.13008013e-02f, 7.33723938e-02f, 5.81975468e-02f, 3.10194679e-03f, -1.79357664e-03f, 2.43758485e-02f, 3.74348857e-03f, -2.68063657e-02f, -7.26738423e-02f,
  -8.45626146e-02f, -1.79782405e-01f, -1.36654601e-02f, 3.48847918e-02f, 9.92787257e-02f, 1.28705129e-02f, 3.59779112e-02f, 4.09177765e-02f, -3.82876433e-02f, -1.10245258e-01f,
  -2.15674541e-03f, 6.68091029e-02f, -1.46072721e-02f, 4.60741296e-02f, 4.02291380e-02f, -4.70758639e-02f, -2.78004482e-02f, 7.55576044e-02f, -5.49397282e-02f, 3.84390354e-02f,
  -1.16317216e-02f, -5.98873524e-03f, 1.95457824e-02f, -8.80975090e-03f, 4.34102193e-02f, 4.76229787e-02f, 5.44829090e-05f, 4.20157425e-02f, -1.33122979e-02f, 4.76072542e-02f,
  -3.94071221e-01f, 3.13850790e-02f, 1.73085276e-02f, -2.39079550e-01f, 5.58118634e-02f, -1.34492278e-01f, -3.01450849e-01f, 1.12309396e-01f, -7.88031965e-02f, 2.36806124e-02f,
  -1.67115554e-01f, -7.81884864e-02f, 3.83782908e-02f, -3.33607256e-01f, -1.14555873e-01f, -5.76159135e-02f, -2.17596412e-01f, -2.23245353e-01f, 4.17173393e-02f, -4.37667705e-02f,
  -3.69692296e-02f, -9.42820385e-02f, -1.18672878e-01f, 2.61381090e-01f, -1.41968966e-01f, 1.32166922e-01f, 9.63741466e-02f, 1.84634432e-01f, -8.96081105e-02f, 1.28378151e-02f,
  -1.33207008e-01f, -8.83595273e-02f, -2.96211988e-02f, 3.55766602e-02f, -3.15094516e-02f, -3.56726088e-02f, -2.18190569e-02f, 3.04658636e-02f, -2.00839508e-02f, 9.65310633e-03f,
  -7.13440496e-03f, 3.26221921e-02f, 3.01890541e-04f, 3.17393430e-02f, -6.63182586e-02f, -1.34485662e-02f, -5.87797239e-02f, -4.71968092e-02f, -1.60131361e-02f, -7.79183656e-02f,
  -6.91004246e-02f, -7.19548538e-02f, -3.35417055e-02f, -5.44387242e-03f, -1.35583142e-02f, -2.91942190e-02f, 5.16471686e-03f, -9.52720735e-03f, -1.24978330e-02f, -3.01118605e-02f,
  1.18864868e-02f, 1.79860108e-02f, -2.56064050e-02f, -2.84464583e-02f, -2.15920210e-02f, 9.17950086e-03f, -2.24371850e-02f, 2.12315051e-03f, 2.17135940e-02f, -2.99505685e-02f,
  1.07891969e-02f, -3.10905688e-02f, -1.33709069e-02f, -2.72091497e-02f, -3.62517908e-02f, -2.85388324e-02f, 2.99114492e-02f, 1.57351922e-02f, -8.46211053e-03f, -1.74913965e-02f,
  -3.36910947e-03f, -1.68964677e-02f, -1.82293430e-02f, -3.50315939e-03f, -3.77401486e-02f, 1.24117974e-02f, 4.59099421e-03f, -9.55594424e-03f, -5.04271546e-03f, -6.36112690e-03f,
  7.40315542e-02f, 1.82091370e-01f, 3.39805745e-02f, 9.77494754e-03f, 7.39124268e-02f, 1.00878300e-02f, -1.64569244e-02f, 4.35233898e-02f, 5.87216578e-02f, -2.25091297e-02f,
  3.02196331e-02f, -1.59043390e-02f, 4.93612476e-02f, -3.43884714e-02f, 2.07580347e-02f, -2.27613561e-03f, -1.25386063e-02f, 4.32401411e-02f, 4.98913936e-02f, 5.93244210e-02f,
  -6.17393013e-03f, 3.93939354e-02f, 3.02515626e-02f, 1.86013058e-03f, 4.39932803e-03f, -4.02480876e-03f, 7.47307297e-03f, 1.47435674e-02f, 3.19297053e-02f, 1.17286397e-02f,
  -2.84080267e-01f, 4.52475339e-01f, -1.85750082e-01f, -3.55600789e-02f, -1.07264519e-01f, 1.50582060e-01f, 6.66662306e-02f, 1.14635684e-01f, 7.02020451e-02f, 3.60096335e-01f,
  -1.73650426e-03f, 7.60766268e-02f, -5.01726463e-04f, 2.61773497e-01f, -4.12529051e-01f, 1.12345386e-02f, 8.07433799e-02f, 1.14235669e-01f, -2.28383392e-02f, 5.91224270e-05f,
  -1.16117932e-01f, 4.87830043e-02f, -1.37116492e-01f, 8.19445550e-02f, 2.29119156e-02f, 6.10344810e-04f, -1.60042927e-01f, -7.89531916e-02f, 1.05681598e-01f, 5.04333479e-03f,
  1.14624411e-01f, 3.60620469e-02f, -6.26731478e-03f, -9.41546448e-03f, -4.17649113e-02f, 1.25599615e-02f, -4.47715186e-02f, -9.11861733e-02f, -1.08519323e-01f, 3.37970420e-03f,
  -2.73150895e-02f, 1.43527682e-03f, 5.46938591e-02f, -3.45403166e-03f, 4.75319065e-02f, 7.62127712e-03f, 7.91052505e-02f, 4.25634149e-04f, 7.46578723e-02f, -1.59896351e-02f,
  1.35309370e-02f, 6.29151240e-02f, -2.66061295e-02f, 4.36563902e-02f, -8.71191919e-02f, 1.70729198e-02f, 1.46309817e-02f, 6.08847942e-03f, 7.15668201e-02f, 6.64137378e-02f,
  -4.06727567e-02f, 1.79146919e-02f, 3.91809084e-02f, -2.23655701e-02f, 4.82848287e-02f, -4.54475870e-03f, 2.89269686e-02f, -1.85268018e-02f, -6.88119233e-02f, 1.22575015e-02f,
  -5.01144566e-02f, 2.54972856e-02f, 1.91830359e-02f, 6.05560094e-03f, -8.49792641e-03f, 2.53003780e-02f, -6.58158734e-02f, 4.08980288e-02f, -1.56642646e-02f, -2.16374900e-02f,
  -2.48346454e-03f, -6.48260396e-03f, 4.27645929e-02f, -3.09580769e-02f, 6.34273291e-02f, -7.13207200e-02f, -1.49092590e-02f, 1.38409901e-02f, 2.13605631e-03f, -7.76946545e-02f,
  5.82685992e-02f, 4.92828600e-02f, 2.52200123e-02f, 6.68582842e-02f, 9.73272324e-03f, 3.49501934e-04f, -2.23670918e-02f, 5.04924916e-02f, -8.41475930e-03f, 3.32382797e-06f,
  5.13212476e-03f, -1.44451167e-02f, 1.50026241e-02f, 2.38340739e-02f, -3.90777625e-02f, 1.09404670e-02f, -4.72440347e-02f, -4.21013683e-03f, -8.65184963e-02f, 4.07578014e-02f,
  -1.67032311e-04f, -3.39873545e-02f, 2.63758260e-03f, 3.18775885e-02f, 2.00999100e-02f, -3.87354265e-03f, -3.82416649e-04f, 4.21887375e-02f, -2.66803112e-02f, -9.63552948e-03f,
  4.57423180e-02f, -3.50496434e-02f, -2.02044129e-01f, 1.23480059e-01f, -3.76245868e-03f, 1.67719707e-01f, 2.08356246e-01f, 3.83787788e-02f, -1.30612031e-01f, 2.06303358e-01f,
  1.21613592e-01f, -4.95396741e-03f, -5.43597415e-02f, 1.69722900e-01f, 1.94938242e-01f, -8.99067149e-02f, 1.37907624e-01f, 1.04333043e-01f, -9.77514684e-02f, 1.88757526e-03f,
  -8.09162632e-02f, 2.19973862e-01f, -8.25672150e-02f, 4.14673537e-02f, 1.49982661e-01f, -3.99951749e-02f, 2.02850387e-01f, -2.51597073e-02f, 1.84295833e-01f, 9.19016004e-02f,
  8.97791237e-02f, 6.19628280e-02f, -1.25203207e-01f, -1.07413111e-02f, 8.75215009e-02f, -2.35956591e-02f, 1.85543497e-03f, 9.81047400e-04f, 1.15076425e-02f, 1.17438277e-02f,
  -2.26756297e-02f, 4.22253795e-02f, 7.03176707e-02f, -5.39903156e-02f, -3.80279124e-02f, -6.46738918e-04f, 1.09774368e-02f, -6.87193498e-02f, -8.44974145e-02f, -2.32419092e-02f,
  -7.51451403e-02f, -3.54512334e-02f, -3.33121396e-03f, 1.11460499e-02f, -7.13065118e-02f, 4.53004092e-02f, -7.18557984e-02f, -8.28836933e-02f, 8.47155154e-02f, -1.91217344e-02f,
  1.93034895e-02f, -6.82045296e-02f, -3.92110199e-02f, -9.11603868e-03f, 4.41272035e-02f, 9.56243661e-04f, 1.16169555e-02f, 2.89103165e-02f, 4.39180993e-02f, 4.52542529e-02f,
  -2.61820406e-02f, -4.68571149e-02f, 9.34252108e-04f, -4.74151745e-02f, -1.22384529e-03f, -2.15262752e-02f, 1.61423106e-02f, 7.71207958e-02f, -6.93795308e-02f, -1.08801564e-02f,
  2.49183439e-02f, 1.61381776e-03f, -1.65514350e-02f, -5.33291474e-02f, 3.25293057e-02f, 1.34095047e-02f, -3.34174074e-02f, -5.76576628e-02f, 1.61479339e-02f, -1.87173579e-02f,
  2.72809267e-01f, 2.68865794e-01f, 2.60612871e-02f, 1.09170407e-01f, 9.91083458e-02f, 1.72936786e-02f, -6.28868416e-02f, -3.85116674e-02f, 1.05061993e-01f, 2.35480014e-02f,
  -9.43691097e-03f, 1.51686454e-02f, 1.58695821e-02f, -2.52680317e-03f, 1.05384160e-02f, 8.78289284e-04f, 6.53249258e-03f, 5.13035767e-02f, 9.31456909e-02f, 6.02519810e-02f,
  6.89892396e-02f, 9.02383924e-02f, -7.56134605e-03f, 4.59507555e-02f, -3.33828367e-02f, 8.50253180e-02f, 3.14827897e-02f, -8.63653123e-02f, 1.23779373e-02f, -3.38254757e-02f,
  1.56349674e-01f, -2.73352712e-01f, 4.84942347e-02f, 7.33283609e-02f, 7.46865794e-02f, 2.88598031e-01f, 7.58223310e-02f, 3.75698842e-02f, 1.35203507e-02f, -2.38864675e-01f,
  4.27865721e-02f, -5.59059270e-02f, -1.10645458e-01f, 1.16899408e-01f, 3.33732605e-01f, -3.69517170e-02f, 1.68670177e-01f, -3.00123319e-02f, 4.95672300e-02f, 3.11348494e-02f,
  8.41915607e-02f, 1.41763583e-01f, 7.41757527e-02f, 1.93299726e-02f, 3.50591019e-02f, -4.11132984e-02f, -1.23113140e-01f, -2.83911806e-02f, 6.20872602e-02f, 3.23130898e-02f,
  1.44530222e-01f, 2.23361030e-02f, -6.35926649e-02f, 3.06506474e-02f, 5.90506867e-02f, -1.47424974e-02f, -4.06613275e-02f, 4.87218052e-03f, 7.91096389e-02f, 6.42634928e-02f,
  -5.55039570e-02f, 1.03771597e-01f, 5.03895991e-02f, -3.89040597e-02f, -1.24011030e-02f, -5.47320629e-03f, -2.19745538e-03f, 1.23719182e-02f, 1.51488259e-02f, -9.26470663e-03f,
  2.13041566e-02f, 2.94138603e-02f, -2.81371232e-02f, 1.61249528e-03f, -2.50196812e-04f, 1.26284529e-02f, -2.31034774e-03f, -5.27683757e-02f, 3.60413454e-02f, -8.23373627e-03f,
  -3.38825807e-02f, -1.37729766e-02f, -2.94337403e-02f, -1.42722065e-03f, 4.40504998e-02f, 1.44438690e-03f, -1.41751673e-02f, 7.42989499e-03f, -5.56783192e-02f, -1.84230506e-02f,
  4.74750996e-02f, -2.47679129e-02f, 2.28454005e-02f, -3.67465778e-03f, -1.43084479e-02f, -7.27665320e-04f, -1.83407553e-02f, -5.34139723e-02f, 2.63275001e-02f, 7.03914696e-03f,
  1.00698955e-02f, 3.24597433e-02f, -3.18969861e-02f, 2.83033662e-02f, 3.20446491e-02f, -2.38428712e-02f, -8.23644735e-03f, -5.01196459e-02f, 6.84769778e-03f, 1.12345647e-02f,
  3.64764743e-02f, -1.01872273e-01f, 2.73811538e-02f, 3.31048183e-02f, -5.74995503e-02f, -6.87695220e-02f, -1.96655523e-02f, -1.38594210e-03f, 1.28878164e-03f, 4.85761911e-02f,
  -1.90911274e-02f, -3.63188535e-02f, 3.46434005e-02f, 7.43637327e-03f, 3.76416035e-02f, -1.99473719e-03f, -2.41928026e-02f, -3.79615389e-02f, -1.46487393e-04f, -3.44267674e-02f,
  -5.70046790e-02f, 6.58796588e-03f, 1.48342429e-02f, 2.60686316e-02f, -1.67153310e-02f, -3.19892876e-02f, -3.25480960e-02f, 1.14163412e-02f, -9.21225268e-03f, -4.36911844e-02f,
  4.16963637e-01f, -1.59539700e-01f, 1.76273994e-02f, 1.04572371e-01f, 1.62309036e-01f, -1.29140005e-01f, -9.38762352e-02f, 4.10510972e-02f, -3.58025804e-02f, -1.45962760e-01f,
  5.61155528e-02f, 4.59511718e-03f, -1.49431050e-01f, 6.55094907e-03f, -1.63122356e-01f, -2.31253684e-01f, -8.29603821e-02f, -8.51822272e-02f, 4.14106064e-03f, 4.24036011e-02f,
  3.67683023e-02f, -4.50553112e-02f, -7.84639921e-03f, -1.55661413e-02f, 1.89124778e-01f, 1.07122444e-01f, -2.22853795e-02f, -9.67224501e-03f, -1.24202874e-02f, 6.27057776e-02f,
  3.65367755e-02f, 1.05009139e-01f, 1.08624948e-03f, -1.35960029e-02f, -1.46028101e-02f, -4.40893788e-03f, -7.43173715e-03f, -3.38005759e-02f, 2.07447838e-02f, -3.83245125e-02f,
  2.27009077e-02f, -1.10190930e-02f, -7.27610604e-04f, -3.89881022e-02f, 6.29843622e-02f, -2.34715920e-02f, 4.18823995e-02f, 6.29777275e-03f, 1.78398052e-03f, 5.45935035e-02f,
  -2.37132865e-03f, 4.81301993e-02f, 8.31976533e-02f, 9.88808824e-05f, 2.16738768e-02f, 5.27570993e-02f, -3.49361114e-02f, -1.88399144e-02f, -2.21213643e-02f, -5.07581159e-02f,
  8.76040012e-03f, 6.02420280e-03f, 2.45680567e-02f, 2.30537225e-02f, -3.53611931e-02f, 9.09164846e-02f, 6.42688759e-03f, -2.30672117e-02f, 2.59924103e-02f, -4.51806001e-02f,
  2.68564913e-02f, 5.23330867e-02f, 1.13420747e-02f, -3.66240144e-02f, -1.43338582e-02f, 2.85375901e-02f, -5.31920232e-02f, -5.64863952e-03f, -4.84379847e-03f, -4.49839374e-03f,
  3.08213700e-02f, -1.29099255e-02f, -3.92038338e-02f, 4.76232218e-03f, -2.83310134e-02f, -5.16339168e-02f, -2.12618560e-02f, 1.50083452e-02f, 1.35878986e-02f, -2.76752468e-03f,
  -1.94093630e-01f, -3.23563159e-01f, -9.41465273e-02f, -1.05824496e-03f, -9.25147533e-03f, -1.63542328e-03f, -5.28190732e-02f, -1.00451941e-02f, -7.25919008e-02f, -9.10361484e-03f,
  -1.03345485e-02f, 3.49355824e-02f, -1.50775192e-02f, 3.35048139e-02f, -4.09858935e-02f, -4.39589247e-02f, 1.13116838e-02f, 2.47794706e-02f, -4.24972065e-02f, 1.15802269e-02f,
  1.55215627e-02f, -6.60894439e-02f, 2.77753826e-02f, -1.92984566e-03f, -3.47605273e-02f, 5.55501319e-02f, -6.08294234e-02f, 4.85691540e-02f, -3.04131862e-02f, -3.99163403e-02f,
  -2.24345848e-01f, -1.92691028e-01f, -1.54547706e-01f, -1.94193810e-01f, 4.49581780e-02f, -1.83889717e-01f, 7.66260624e-02f, -1.57381222e-01f, -1.71336785e-01f, -4.89487462e-02f,
  1.59540370e-01f, -4.54305597e-02f, 2.43713289e-01f, -1.96343005e-01f, -2.46062782e-02f, 1.48371756e-01f, -2.11809725e-01f, -6.97745606e-02f, -1.34904608e-02f, -1.64111540e-01f,
  -6.89287335e-02f, -2.19077393e-02f, -7.18117412e-03f, -1.27254784e-01f, -1.31325126e-01f, -1.28315806e-01f, 2.17166185e-01f, 8.18479657e-02f, -9.93005484e-02f, 9.92455930e-02f,
  -9.18514356e-02f, -1.57515094e-01f, 1.94173176e-02f, -4.52852398e-02f, -4.22327667e-02f, 5.86034283e-02f, 2.98523554e-03f, 1.48390442e-01f, 1.07912766e-02f, -5.78300916e-02f,
  4.19648848e-02f, -7.65556172e-02f, -6.55144304e-02f, 6.02495335e-02f, -8.49770755e-02f, -1.17938407e-01f, -5.15048355e-02f, 2.16834787e-02f, -3.28293890e-02f, -1.25386836e-02f,
  -1.78878661e-02f, -9.18480307e-02f, -5.34312017e-02f, -2.77742016e-04f, 1.06609361e-02f, -5.93796819e-02f, -1.07852286e-02f, 1.45433396e-02f, -7.42459670e-02f, -1.05587214e-01f,
  2.84767058e-02f, 6.46237226e-04f, 2.74403696e-03f, -2.66591180e-02f, 1.70688443e-02f, 7.86521137e-02f, -2.54534539e-02f, 4.05155942e-02f, -1.77588291e-03f, -1.68433376e-02f,
  -1.96075141e-02f, -2.38461345e-02f, 6.55785948e-03f, 1.05263023e-02f, 4.14362177e-02f, -1.68047994e-02f, 6.01946414e-02f, 2.41071507e-02f, -3.73623557e-02f, 6.40543818e-04f,
  2.35402714e-02f, -5.00551090e-02f, -1.26963062e-03f, 6.84136758e-03f, -6.68724701e-02f, 3.31603326e-02f, -8.30013901e-02f, -4.54803221e-02f, 2.78312173e-02f, 7.33503699e-02f,
  -1.92874551e-01f, -2.23499581e-01f, 5.19926436e-02f, -4.91550379e-02f, 4.33725305e-02f, 3.82723399e-02f, 1.70769207e-02f, -3.36651765e-02f, -2.62900833e-02f, 7.00199418e-03f,
  -6.48347195e-05f, -1.51361246e-02f, 1.83145609e-02f, 4.69363853e-02f, -1.62345953e-02f, 3.19593810e-02f, 5.77929132e-02f, 2.69694217e-02f, -3.61753367e-02f, -5.19847460e-02f,
  -4.25050035e-03f, -2.30909213e-02f, -3.48256697e-04f, -2.60186754e-02f, 7.64640048e-02f, 3.32303345e-02f, -2.08287854e-02f, -2.39751954e-03f, 5.45349494e-02f, -3.18963407e-03f,
  -1.33617461e-01f, 2.58892864e-01f, 1.82929158e-01f, -1.24166228e-01f, -3.14051896e-01f, -1.42098144e-02f, 2.50469614e-02f, 3.55109535e-02f, 1.55372858e-01f, 2.05502883e-01f,
  -1.51587650e-01f, 1.73938245e-01f, 7.91669339e-02f, -6.95345402e-02f, -7.96589404e-02f, 2.17877597e-01f, -9.59374532e-02f, -6.66273981e-02f, -8.52200165e-02f, -2.07126185e-01f,
  -1.74686909e-01f, -2.86750436e-01f, -1.74142793e-01f, -1.64496243e-01f, -2.20402241e-01f, -9.36125442e-02f, -2.33278334e-01f, 3.18024820e-03f, -2.19555676e-01f, -3.18629891e-02f,
  -1.17498405e-01f, -1.29307853e-02f, -4.39434983e-02f, -2.51580346e-02f, -6.80292472e-02f, 4.37912643e-02f, 2.90593244e-02f, -2.39426941e-02f, -7.21120387e-02f, -2.18642391e-02f,
  -4.29588975e-03f, -4.28769030e-02f, 7.20137963e-03f, 8.16303790e-02f, 2.87589673e-02f, -4.95690014e-03f, -1.39005138e-02f, -7.32443854e-02f, -4.58528399e-02f, 4.57180850e-03f,
  3.23752388e-02f, -3.34235020e-02f, 6.74522966e-02f, 3.80335897e-02f, -6.94549531e-02f, -2.11782008e-02f, 8.14837515e-02f, -4.12246436e-02f, 3.54789547e-04f, 3.72880027e-02f,
  -7.75899366e-03f, 7.09363865e-03f, -1.01646977e-02f, 5.97373173e-02f, 1.06141521e-02f, 2.72682495e-02f, 1.09559998e-01f, 1.41084697e-02f, -3.84352468e-02f, -7.26328120e-02f,
  -2.67802421e-02f, 7.17461109e-03f, 4.42582928e-02f, 3.87805365e-02f, -3.55850533e-02f, 3.40157077e-02f, -2.71604024e-02f, 2.45743133e-02f, -1.78204048e-02f, 5.86717576e-03f,
  9.66028422e-02f, 5.71908290e-03f, -9.69204381e-02f, -7.94839393e-03f, 1.49126109e-02f, 2.98073478e-02f, 5.76599427e-02f, 2.82083824e-02f, -8.40893686e-02f, -8.52457657e-02f,
  -6.77494034e-02f, 3.27379853e-02f, -6.34503961e-02f, -7.62265176e-02f, 4.44451272e-02f, -2.67612711e-02f, 4.16228846e-02f, 3.18066664e-02f, -1.20434724e-02f, -4.96831164e-03f,
  -2.64637824e-02f, -4.40976620e-02f, 6.00227565e-02f, 1.31877121e-02f, -4.70713107e-03f, -9.36868321e-03f, -4.50962037e-02f, -5.03058210e-02f, -1.12197483e-02f, -2.62192432e-02f,
  -6.99919462e-02f, -5.58497384e-02f, 7.04671666e-02f, -1.55949682e-01f, -9.68431681e-03f, 5.83189204e-02f, 8.35766923e-03f, 2.72489525e-02f, -6.79304972e-02f, 6.19414821e-02f,
  -2.97048241e-01f, -2.82947063e-01f, -1.03867911e-01f, -2.00008258e-01f, -2.22741552e-02f, 1.46946400e-01f, 1.27605498e-01f, -1.61875486e-01f, -2.63349921e-01f, -5.17571643e-02f,
  -6.04980513e-02f, -1.38403147e-01f, -1.86595991e-02f, -5.47995381e-02f, 1.21008992e-01f, 1.23059295e-01f, 6.45726174e-02f, 1.16282646e-02f, -2.82918364e-02f, -8.51231813e-02f,
  -5.43226721e-03f, 3.48906443e-02f, 8.63071233e-02f, 1.74739654e-03f, -6.88894168e-02f, -7.41498768e-02f, 8.19301680e-02f, 5.29868565e-02f, 4.55885828e-02f, 1.10016614e-01f,
  -1.10566854e-01f, -2.23512053e-01f, -3.07458751e-02f, -2.20770165e-02f, -5.24249068e-03f, 8.82968009e-02f, 5.54116033e-02f, 4.94449325e-02f, 1.51271867e-02f, 9.45317559e-03f,
  1.77963227e-02f, -3.30156134e-03f, -1.92647763e-02f, 2.31001657e-04f, -1.19794533e-02f, -5.43876328e-02f, 1.03226593e-02f, -9.16000456e-03f, -4.63000536e-02f, 2.57312730e-02f,
  -4.27578539e-02f, -1.03005916e-02f, 4.22220351e-03f, 7.46485293e-02f, -1.82121117e-02f, -5.15206903e-02f, 7.41464943e-02f, 2.04819776e-02f, 1.78127852e-03f, -6.26122765e-03f,
  8.42008144e-02f, -1.51760224e-02f, -2.25071069e-02f, -4.89426851e-02f, -1.38641587e-02f, -1.56829040e-02f, 1.15693165e-02f, 5.39941527e-02f, -2.84741819e-03f, 9.44060180e-03f,
  1.55579275e-03f, -5.12560038e-03f, -2.78915334e-02f, 5.94776217e-03f, -1.98587775e-02f, -8.11791420e-03f, -3.24119534e-03f, -2.30756849e-02f, -1.33447591e-02f, 1.18460264e-02f,
  2.08798796e-02f, 8.72084685e-03f, -2.55368203e-02f, 3.59811336e-02f, 7.97790010e-03f, -3.01211048e-02f, -4.24819030e-02f, -1.09068854e-02f, 4.21443908e-03f, 1.42681478e-02f,
  -1.48284465e-01f, -1.34605184e-01f, 4.81113121e-02f, 5.37086837e-03f, 4.03333306e-02f, -7.26467930e-03f, 4.16414887e-02f, -3.44764367e-02f, -5.41651547e-02f, 5.25164157e-02f,
  1.92689709e-02f, 4.51538004e-02f, -2.91158818e-02f, -9.17232502e-03f, 2.62485016e-02f, -3.77796069e-02f, 1.64375585e-02f, 2.51678750e-02f, 3.51229496e-02f, -1.37494993e-03f,
  1.07761882e-02f, -1.85533811e-03f, 8.26965123e-02f, 1.17129441e-02f, 4.45884317e-02f, -1.25302793e-02f, -4.47303690e-02f, 4.07235101e-02f, 4.24840413e-02f, 2.66173575e-02f,
  -5.39801955e-01f, 3.38804424e-01f, -4.20254143e-03f, -3.52651238e-01f, 6.29885821e-03f, 1.78519070e-01f, -1.57351136e-01f, 6.61303475e-02f, -2.28223830e-01f, 1.98235437e-01f,
  -6.18588831e-03f, 2.81080008e-02f, 1.67421177e-02f, 1.04869169e-03f, -3.08891952e-01f, -8.35176632e-02f, -1.85903415e-01f, -2.71535269e-03f, -4.01596799e-02f, -2.56862659e-02f,
  -1.71735123e-01f, 2.73977797e-02f, -6.88095763e-02f, 2.23611027e-01f, 5.33551276e-02f, -2.19047852e-02f, 9.41816997e-03f, 1.64747402e-01f, 6.71864077e-02f, 6.88965768e-02f,
  3.42001095e-02f, 1.64994951e-02f, -1.84922665e-02f, 6.62849005e-03f, -5.97372316e-02f, 3.16491127e-02f, -2.89943609e-02f, 1.36058200e-02f, -5.28423451e-02f, -3.46523896e-02f,
  1.01333624e-02f, 7.67151965e-03f, -2.18409281e-02f, -1.16066588e-02f, -1.95487607e-02f, 2.11323015e-02f, 5.90641331e-03f, -3.34005617e-02f, 3.05446386e-02f, -3.01352311e-02f,
  -3.65101732e-02f, -2.78310925e-02f, -7.77047500e-02f, -8.60659406e-03f, 1.15177948e-02f, 1.68731753e-02f, 8.97670723e-03f, 6.07429212e-03f, 3.08093103e-03f, -1.79167371e-02f,
  2.13521458e-02f, -4.65441793e-02f, 3.20462440e-03f, 2.87410449e-02f, 1.21151414e-02f, -1.14049651e-02f, 5.33997919e-03f, 5.17434739e-02f, -2.40337364e-02f, 3.87152992e-02f,
  -2.58728191e-02f, -6.44111782e-02f, 6.08936734e-02f, -4.57991883e-02f, -2.73752622e-02f, -2.78517548e-02f, 1.17801037e-02f, 8.01218525e-02f, -8.33630487e-02f, 2.67224405e-02f,
  -1.25732168e-03f, -6.03611814e-03f, 1.74246673e-02f, -1.16224848e-02f, 2.96294340e-04f, -1.84189677e-02f, 3.74745391e-02f, 5.00130607e-03f, 3.21882740e-02f, -5.70948161e-02f,
  7.17418715e-02f, 1.03743382e-01f, 2.23789997e-02f, 7.86054209e-02f, 5.80181479e-02f, 4.29813750e-02f, -8.04802496e-03f, 4.20277975e-02f, 3.84978540e-02f, 4.31774370e-02f,
  -5.82194561e-03f, -3.13238427e-02f, 3.35852569e-03f, -7.84155447e-03f, -2.00313404e-02f, -9.11830226e-04f, 1.42769236e-03f, -1.46994507e-02f, 3.97192594e-03f, 4.78882603e-02f,
  4.10980955e-02f, -4.67604632e-03f, -2.16743071e-02f, 5.49036860e-02f, -7.74883386e-03f, 1.53533630e-02f, 6.07466586e-02f, -1.78441536e-02f, 3.04995906e-02f, -2.27621347e-02f,
  -1.12611637e-01f, 3.47514957e-01f, 7.16621950e-02f, -1.22261830e-01f, -4.36769128e-02f, 1.62965134e-01f, 1.42775252e-01f, 1.55005053e-01f, 1.54208481e-01f, 2.99692135e-02f,
  -2.35234320e-01f, 1.12176597e-01f, 4.18653265e-02f, -2.55321056e-01f, -3.18651021e-01f, -1.42661735e-01f, -3.79569605e-02f, 9.39185247e-02f, 2.90297151e-01f, -5.43946885e-02f,
  -1.16346991e-02f, -2.84306079e-01f, -2.29136288e-01f, 1.02448743e-02f, -6.12104544e-03f, 2.42474139e-01f, -2.26568609e-01f, 1.85392752e-01f, -1.08413875e-01f, 6.72473237e-02f,
  -5.37420847e-02f, 4.08316702e-02f, 9.80371237e-02f, 1.07610539e-01f, -1.29772313e-02f, 1.82136595e-02f, 5.95308095e-02f, 3.06322463e-02f, 4.73586880e-02f, 5.49551584e-02f,
  3.69583652e-03f, -9.25401896e-02f, -1.07197249e-02f, -6.59841001e-02f, 7.75510967e-02f, 3.63485776e-02f, -3.35493917e-03f, 4.18386757e-02f, 6.31151116e-03f, 3.47010680e-02f,
  -5.64722419e-02f, 4.06672955e-02f, -5.56440577e-02f, 1.25961890e-02f, 7.95155205e-03f, 7.26911277e-02f, 3.86006348e-02f, 7.04962537e-02f, 5.41546149e-03f, 5.61934337e-02f,
  4.57167253e-02f, 5.69131002e-02f, -2.69969478e-02f, -4.04610392e-03f, 4.26855646e-02f, -1.53636455e-03f, -3.68429720e-02f, -9.43716168e-02f, 7.82923847e-02f, -1.69641152e-02f,
  -3.80937047e-02f, 7.72968978e-02f, 3.27423364e-02f, 2.47303788e-02f, 5.14051020e-02f, -1.45542910e-02f, -2.76256241e-02f, 2.07316391e-02f, -1.01907374e-02f, -1.11795496e-02f,
  1.38152447e-02f, -6.55743033e-02f, 3.22254933e-02f, 1.31755695e-02f, 3.34944874e-02f, 2.01022197e-02f, 1.07446369e-02f, 1.10007190e-04f, -3.55445705e-02f, -1.30692506e-02f,
  1.07630879e-01f, 1.47290871e-01f, 6.74234256e-02f, 1.30625702e-02f, 2.43834965e-02f, -3.81973721e-02f, 1.36988133e-03f, -9.05618537e-03f, 5.87336272e-02f, -1.85752269e-02f,
  8.94554053e-03f, 3.91897969e-02f, -6.32807463e-02f, -5.02129085e-02f, -4.07898352e-02f, -6.13351204e-02f, 2.16566259e-03f, 3.68312337e-02f, 1.81220975e-02f, 7.12867603e-02f,
  -3.72997560e-02f, -7.50794187e-02f, 2.09456813e-02f, -3.53493169e-02f, -1.71131529e-02f, -1.47214979e-02f, -1.40671665e-03f, 6.51531070e-02f, -7.50247687e-02f, -1.68199688e-02f,
  -2.22071737e-01f, -1.45068169e-01f, 5.22039719e-02f, -1.09257810e-01f, 4.29940112e-02f, 2.01901853e-01f, 1.58577740e-01f, -5.26957102e-02f, 9.12665278e-02f, -5.55112399e-02f,
  3.80223319e-02f, 1.78712253e-02f, 4.48349938e-02f, 5.40197827e-02f, 2.97196865e-01f, 2.28392407e-01f, 1.16901889e-01f, 1.09837659e-01f, 3.13288085e-02f, -1.05790809e-01f,
  -2.80184820e-02f, -4.26851772e-02f, 3.42503786e-02f, -1.70511037e-01f, -9.10577103e-02f, -2.14064524e-01f, -7.80009627e-02f, -7.19212182e-03f, -8.97000507e-02f, 7.58103132e-02f,
  -7.77276158e-02f, -1.93205312e-01f, -3.01201679e-02f, -3.15859020e-02f, -7.65801817e-02f, -1.37526346e-02f, 8.74794740e-03f, 6.52657002e-02f, -4.92777117e-03f, 1.40380813e-03f,
  1.31072877e-02f, -4.13155444e-02f, -8.43701214e-02f, 8.20986275e-03f, 2.50341892e-02f, -3.77456211e-02f, 4.40322869e-02f, 2.94717979e-02f, -1.71510484e-02f, 3.62783670e-02f,
  2.49055307e-02f, 3.87948635e-03f, -2.73553021e-02f, -1.98249649e-02f, -6.95012184e-03f, 2.05619186e-02f, 3.41756642e-02f, 6.25884756e-02f, 1.90140563e-03f, 9.00942367e-03f,
  -4.44707386e-02f, 8.13480690e-02f, -2.61357483e-02f, -8.84561893e-03f, -4.04986665e-02f, -7.73498714e-02f, 8.20124615e-03f, 2.54528262e-02f, 3.37986350e-02f, 4.16993462e-02f,
  8.92405864e-03f, -7.52255321e-02f, -5.22570312e-02f, 2.18044166e-02f, -4.92205918e-02f, -5.36329597e-02f, 2.19404325e-02f, -3.84374931e-02f, -2.74506230e-02f, -3.62774148e-03f,
  -1.40728047e-02f, 1.55989323e-02f, 5.50477905e-03f, -4.20732647e-02f, 1.15434658e-02f, 5.40022133e-03f, -1.29257469e-02f, 6.82346756e-03f, 2.29255427e-02f, 2.85224300e-02f,
  -3.56237404e-02f, -1.41064674e-01f, 1.68745834e-02f, -3.38193141e-02f, 2.09947750e-02f, 5.38576581e-02f, 2.76378281e-02f, -2.37583239e-02f, -2.40253378e-02f, -1.99637357e-02f,
  -2.48417147e-02f, 7.03145517e-03f, -6.74839243e-02f, -2.08014995e-02f, 7.64729828e-03f, 2.12636627e-02f, 8.95908393e-04f, 3.77546088e-03f, 8.39028624e-04f, -3.48532833e-02f,
  -1.01803996e-01f, -4.63678464e-02f, 4.99160402e-02f, -1.30911348e-02f, -4.82143089e-02f, -2.09556017e-02f, -7.87224025e-02f, 1.84609015e-02f, -1.87777057e-02f, 6.75624162e-02f,
  3.30302536e-01f, -2.95569766e-02f, -5.72013818e-02f, 2.56871819e-01f, 1.01814352e-01f, -9.17545781e-02f, 8.39189515e-02f, 1.04163632e-01f, -4.94320784e-03f, 1.80051997e-04f,
  7.63381124e-02f, 7.09516779e-02f, -1.16155490e-01f, 8.51579607e-02f, 1.27432019e-01f, -2.67379552e-01f, 1.52936295e-01f, 1.05611883e-01f, -1.17540739e-01f, 2.49285400e-01f,
  6.76946416e-02f, 9.71694365e-02f, 9.28797498e-02f, -6.04666471e-02f, 1.84422702e-01f, 2.00758409e-02f, 1.22138351e-01f, -9.16966721e-02f, 1.07080579e-01f, -3.13196741e-02f,
  1.08325295e-01f, 1.24908142e-01f, 4.01177332e-02f, -1.14382990e-02f, 5.56689985e-02f, -6.60529807e-02f, 8.89049470e-03f, -5.34454733e-02f, -3.70874293e-02f, 2.50994880e-02f,
  -3.64166982e-02f, 3.69915999e-02f, -1.88475344e-02f, -1.07273191e-01f, 8.68846383e-03f, -1.27739552e-02f, -1.11824889e-02f, -2.20756382e-02f, -2.16209237e-02f, 3.14653888e-02f,
  -9.72926244e-03f, -1.48044685e-02f, -1.13242222e-02f, 1.27066970e-02f, -3.41519602e-02f, -4.07317579e-02f, 5.58233587e-03f, 5.88304922e-02f, -9.42447037e-03f, -6.76205195e-03f,
  1.26171270e-02f, -1.26279294e-02f, 3.83466715e-04f, -1.71976686e-02f, -1.44263497e-02f, 4.22489904e-02f, -7.30553940e-02f, 1.58088189e-02f, -6.01882935e-02f, 5.76038249e-02f,
  2.08199676e-02f, 4.81506139e-02f, 3.03438883e-02f, -2.99143586e-02f, 9.18422453e-03f, 3.00450511e-02f, -2.29999814e-02f, 5.62035404e-02f, 1.02838399e-02f, 5.57695702e-03f,
  -5.30253537e-03f, -1.60539206e-02f, 4.48223427e-02f, 5.76850101e-02f, -8.07538512e-04f, 1.45103540e-02f, -3.29904631e-02f, 4.18997929e-02f, 2.64918916e-02f, -4.24203686e-02f,
  1.90654412e-01f, 1.93617970e-01f, -5.49236760e-02f, -1.90370940e-02f, -9.29178521e-02f, -9.78248473e-03f, -8.58900473e-02f, -3.60524431e-02f, -1.53176310e-02f, -2.80757416e-02f,
  2.96364054e-02f, 4.19373885e-02f, 1.84590872e-02f, 2.27817036e-02f, -2.78864931e-02f, 1.60662904e-02f, -1.54077001e-02f, -2.66927411e-03f, 4.66534160e-02f, 5.97740039e-02f,
  4.05070670e-02f, 3.17551978e-02f, -7.08162189e-02f, 4.54983972e-02f, 1.99151654e-02f, 2.87426990e-02f, 8.47090557e-02f, 3.56814591e-04f, -4.17443551e-02f, -5.10028489e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.51662979e-02f, 3.31660770e-02f, 3.34619224e-01f, -6.58440292e-02f, 3.36259097e-01f, 3.25477511e-01f, -5.09747863e-02f, 3.05542231e-01f, 2.95523703e-01f, -2.05548957e-01f,
  -4.68854010e-02f, -2.25279912e-01f, 2.35616136e-02f, -9.60083455e-02f, 1.54587701e-01f, 8.17580372e-02f, 6.08680863e-03f, -1.64955854e-01f, 1.67637795e-01f, -5.55184595e-02f,
  7.49752298e-02f, -1.91050321e-01f, 4.34948951e-02f, -6.39480203e-02f, -2.01353151e-02f, -5.61298802e-02f, -2.28908256e-01f, -6.23288639e-02f, -1.73489869e-01f, 3.77501594e-03f,
  1.49584059e-02f, 4.93477704e-03f, -7.69943073e-02f, 1.01980157e-02f, 4.24342379e-02f, -5.84579408e-02f, -9.11343694e-02f, 4.04617609e-03f, 1.27736554e-02f, 7.72786438e-02f,
  -8.52677301e-02f, 5.80334365e-02f, -5.72328307e-02f, -3.50873941e-03f, 6.52470142e-02f, 7.53245875e-02f, 1.24334119e-01f, 4.24168631e-02f, 4.14927378e-02f, 1.30821824e-01f,
  8.84273201e-02f, 9.56164077e-02f, 5.86640351e-02f, 1.92247834e-02f, 6.79304302e-02f, 4.25537340e-02f, -3.57186645e-02f, -3.49442549e-02f, 3.02992873e-02f, 8.25278461e-02f,
  -3.63950320e-02f, -4.68384847e-03f, 1.85887776e-02f, 1.57954395e-02f, -3.38598341e-02f, 9.44105536e-02f, -2.29820069e-02f, -3.33461538e-02f, 1.43495901e-02f, -4.90634404e-02f,
  -8.71429034e-03f, -8.71217996e-02f, 8.86965990e-02f, 5.32136336e-02f, -6.10813648e-02f, 2.20262539e-03f, -1.23154847e-02f, 2.15415321e-02f, 3.14099132e-03f, 5.46960626e-03f,
  -3.47754396e-02f, 2.23155040e-02f, 2.79716793e-02f, 5.46824187e-02f, 2.69562528e-02f, 2.35669967e-02f, -3.90681960e-02f, 8.39355141e-02f, 6.48520812e-02f, -1.11279048e-01f,
  -1.08351290e-01f, -1.67573720e-01f, -5.54488152e-02f, -5.52370287e-02f, -9.53543708e-02f, 1.83602180e-02f, -4.33285832e-02f, 9.04908553e-02f, -2.07056180e-02f, 3.54371555e-02f,
  2.72316649e-03f, -2.83760969e-02f, -2.19640229e-02f, 2.33107433e-02f, -6.84160814e-02f, 9.33774859e-02f, -9.91845131e-02f, -1.04839809e-01f, -7.21670166e-02f, -5.83733283e-02f,
  -7.25888461e-02f, -7.29638562e-02f, -6.61638507e-04f, 5.49539216e-02f, -1.11069167e-02f, -7.73489773e-02f, -4.60307598e-02f, -4.71428456e-03f, 1.05477059e-02f, 2.19105966e-02f,
  2.32453316e-01f, -8.06517825e-02f, -3.90516996e-01f, -2.14567512e-01f, 2.22999439e-01f, 2.20830455e-01f, 8.71145651e-02f, 1.00055203e-01f, -2.24501535e-01f, 2.12548345e-01f,
  2.03921989e-01f, -2.39818022e-01f, -4.32838351e-02f, -8.29426944e-02f, -1.00383259e-01f, -2.69690901e-01f, 9.69080999e-02f, -1.37210265e-02f, -1.14207059e-01f, 1.95136800e-01f,
  2.41416022e-02f, 2.45908260e-01f, -1.06406644e-01f, 1.79287687e-01f, 1.72117010e-01f, 5.12996092e-02f, 3.14757198e-01f, -2.24849097e-02f, 1.65611029e-01f, -7.33192712e-02f,
  -9.13763884e-03f, -1.92484297e-02f, -4.86276858e-02f, -1.33286566e-01f, 1.66001037e-01f, 1.56164274e-01f, 7.00503290e-02f, -1.00169405e-01f, -9.72953960e-02f, -5.72215021e-03f,
  3.67903858e-02f, -1.95259992e-02f, 1.01121468e-03f, 1.02063436e-02f, 7.38816187e-02f, 3.58454813e-03f, -3.05926241e-02f, -9.62826982e-02f, -7.19890445e-02f, 1.80470478e-02f,
  -1.19079724e-02f, -5.41015714e-02f, -1.18668657e-02f, -3.96530554e-02f, -2.11115703e-02f, 3.04914396e-02f, -4.66633635e-03f, 8.56856853e-02f, -2.20243204e-02f, 5.05344793e-02f,
  1.65760607e-01f, 2.95726620e-02f, 2.62957290e-02f, -1.05176263e-01f, -3.93461473e-02f, -3.95316482e-02f, -1.08415700e-01f, -3.76278199e-02f, -5.30571118e-02f, 3.26076932e-02f,
  2.23736931e-02f, -1.35480994e-02f, -5.02499007e-02f, 5.62266894e-02f, 8.69094282e-02f, -6.46844283e-02f, -3.17106582e-02f, 8.23314041e-02f, 1.00145288e-01f, -5.34364097e-02f,
  -1.86116889e-01f, 7.35477135e-02f, 1.77553762e-02f, 6.30716011e-02f, -6.38913810e-02f, 7.11741075e-02f, 1.04188219e-01f, 1.44477068e-02f, -2.20969152e-02f, -1.71382539e-02f,
  9.48210657e-02f, 2.47892514e-01f, 1.81057304e-02f, -6.47394657e-02f, -8.13890323e-02f, 5.27113266e-02f, -1.20112315e-01f, -8.70061368e-02f, 2.26302687e-02f, 5.10050133e-02f,
  1.80653155e-01f, 4.45503816e-02f, -3.25369299e-03f, 3.78376357e-02f, -1.16992295e-01f, 2.03559324e-01f, 3.01726796e-02f, -3.46708894e-02f, 4.85373512e-02f, 5.72363511e-02f,
  1.28066137e-01f, 1.86173216e-01f, -8.24127719e-02f, -6.88308105e-02f, 4.60730866e-02f, 1.13473900e-01f, 8.78762081e-02f, -8.13742692e-04f, 5.59206214e-03f, -8.24695602e-02f,
  -1.12982340e-01f, 4.96291928e-02f, 1.79386456e-02f, -1.25566140e-01f, 1.81872860e-01f, -5.49854524e-02f, 1.27394206e-03f, 3.39099407e-01f, 2.45744854e-01f, -1.74303539e-02f,
  -7.16469213e-02f, -4.13929522e-01f, 1.56011760e-01f, -2.20464647e-01f, -1.96042210e-01f, 8.56697932e-03f, -3.34264934e-01f, -2.91321456e-01f, 1.13231666e-01f, -2.28696406e-01f,
  -1.33912131e-01f, -5.55977561e-02f, -6.48115650e-02f, 1.82225347e-01f, 2.17812043e-02f, 1.39136285e-01f, -1.37493923e-01f, 2.21313760e-01f, -1.58204421e-01f, 1.35539249e-02f,
  5.32258302e-02f, 1.75469637e-01f, 1.82733566e-01f, 1.11015990e-01f, 3.92610654e-02f, -6.95279017e-02f, -1.54884994e-01f, 7.56695792e-02f, 5.79712130e-02f, 1.01914689e-01f,
  -1.00198172e-01f, 4.40675160e-03f, -4.10819650e-02f, 1.38524935e-01f, 1.15890592e-01f, -4.17143339e-03f, 1.64551027e-02f, 1.49287470e-02f, 2.05869246e-02f, -1.00882851e-01f,
  -5.47838323e-02f, 8.84847529e-03f, -8.31581652e-02f, -8.53420701e-03f, -1.04749158e-01f, 1.33841205e-02f, -6.93304911e-02f, -1.37247086e-01f, -1.90506762e-04f, -4.96020801e-02f,
  1.08547732e-02f, -2.34176442e-02f, -2.89607365e-02f, 2.04779252e-01f, 1.05433434e-01f, 6.10668100e-02f, 4.50655185e-02f, -4.92109805e-02f, 1.04703523e-01f, -2.49222498e-02f,
  4.64848764e-02f, 2.07941569e-02f, 2.51552816e-02f, -4.90039513e-02f, -1.25118345e-01f, -9.87613201e-03f, -6.66316077e-02f, -1.62467714e-02f, 2.66235624e-03f, -5.31624183e-02f,
  -3.89769934e-02f, -1.21854059e-01f, 1.11314006e-01f, 4.70000915e-02f, 7.41875693e-02f, 7.48834163e-02f, -5.26237488e-02f, -3.34743946e-03f, 2.29821689e-02f, -9.99471173e-02f,
  -4.74148393e-02f, -1.04287423e-01f, 1.44846708e-01f, 8.96394253e-02f, -7.62252230e-03f, -2.27645109e-03f, -1.18355103e-01f, 2.23936122e-02f, 4.74579073e-03f, 6.18084930e-02f,
  -6.10186458e-02f, -7.26763159e-02f, -5.26537895e-02f, 3.60476561e-02f, -6.61917543e-03f, 1.29036242e-02f, -1.09657556e-01f, -4.96620871e-03f, -7.46495798e-02f, -8.02212432e-02f,
  -5.86677268e-02f, -7.79152438e-02f, -6.73486292e-02f, 8.57340023e-02f, -5.13548888e-02f, -4.26347889e-02f, -8.97776932e-02f, -1.10618761e-02f, -1.12248166e-02f, -4.09854949e-02f,
  5.86243451e-01f, -3.90443295e-01f, -8.61216933e-02f, 2.63066649e-01f, 3.06836188e-01f, 2.28509501e-01f, 4.32049483e-01f, 3.46256718e-02f, 3.54442716e-01f, -2.76823491e-01f,
  -8.09299177e-04f, -7.23390430e-02f, -1.48756579e-01f, 8.08483362e-02f, 4.31175858e-01f, -4.07200353e-03f, 1.93035483e-01f, 1.34105936e-01f, 8.61840397e-02f, 1.02013454e-01f,
  2.31744409e-01f, 1.27125338e-01f, -9.36483592e-02f, -2.20414698e-01f, 2.87026912e-02f, -1.60112470e-01f, -1.89244002e-01f, -1.15163699e-01f, -1.33892119e-01f, 9.60562229e-02f,
  6.66002110e-02f, 2.61078924e-02f, 3.75857018e-02f, -4.69224341e-02f, 1.19806705e-02f, -3.53925861e-02f, 6.91062817e-03f, 3.28757279e-02f, 6.04174770e-02f, -4.29390790e-03f,
  -5.47355134e-03f, -7.08398083e-03f, 2.85219867e-02f, 1.91090498e-02f, 5.64203709e-02f, 6.08167262e-04f, 3.00087463e-02f, -3.81239317e-02f, -7.60261193e-02f, -3.81205045e-02f,
  1.01736439e-02f, -6.10614195e-02f, 2.01391131e-02f, -6.47607669e-02f, 2.89663579e-02f, 7.86039755e-02f, -8.63586664e-02f, -4.24902840e-03f, -2.66874339e-02f, 7.19708055e-02f,
  -2.32634470e-02f, 2.83757932e-02f, 2.40310925e-04f, -4.14671339e-02f, 5.64963296e-02f, 1.93279721e-02f, -1.06405932e-02f, -7.26518929e-02f, 3.21073048e-02f, 5.69130620e-03f,
  1.23864459e-02f, 4.75823022e-02f, 4.69073541e-02f, -6.04126463e-03f, 4.61997613e-02f, -1.75809767e-02f, -1.94572378e-02f, -4.04052511e-02f, 3.89571786e-02f, -2.96784542e-03f,
  1.60506759e-02f, 5.31382076e-02f, -1.86318941e-02f, -7.70459473e-02f, 1.84365064e-02f, -1.51956659e-02f, -4.70512919e-02f, 1.44886775e-02f, -3.54849063e-02f, 3.10673043e-02f,
  -4.02965136e-02f, -2.05654070e-01f, 2.43121162e-02f, -1.24882581e-02f, -9.47156921e-02f, 4.68119932e-03f, -1.04443599e-04f, 1.90384965e-02f, -4.33033668e-02f, 6.80794055e-03f,
  2.77302717e-03f, -1.44148748e-02f, -3.09967753e-02f, -9.05902777e-03f, -3.72305512e-02f, -1.67747885e-02f, 3.48530114e-02f, 1.53876925e-02f, 2.11261921e-02f, -2.65325755e-02f,
  -3.82055826e-02f, -4.90287179e-03f, 3.73329446e-02f, 4.26173508e-02f, -4.66386564e-02f, -1.49324946e-02f, 2.22262880e-03f, 9.47960652e-04f, -1.79378930e-02f, 4.55724113e-02f,
  2.72085741e-02f, -3.65725368e-01f, -1.45230934e-01f, 2.00258836e-01f, 2.15849802e-01f, -9.19190049e-02f, -1.09958790e-01f, 8.61876458e-02f, 5.52793145e-02f, -1.25885412e-01f,
  5.22516556e-02f, -1.47759959e-01f, -3.29830378e-01f, 1.44075468e-01f, 1.69043288e-01f, -2.67300069e-01f, 2.26537839e-01f, 1.55444741e-02f, -6.33970229e-03f, 2.38820445e-02f,
  1.03175640e-01f, 2.51438588e-01f, 2.08863728e-02f, 1.41285971e-01f, 4.08641770e-02f, 6.24530241e-02f, 1.40794381e-01f, -6.47232682e-02f, 1.59735978e-01f, 8.52297023e-02f,
  1.54425809e-02f, -2.71202587e-02f, 5.17257750e-02f, 5.38465893e-03f, 2.41722446e-02f, 3.34635340e-02f, 8.80302489e-03f, -3.21022496e-02f, 4.53320630e-02f, -3.67530398e-02f,
  -4.81996238e-02f, 9.21721011e-02f, -6.29315153e-03f, -7.14967474e-02f, 6.60116822e-02f, 4.07117903e-02f, -1.13902632e-02f, -1.26605621e-02f, 5.91467833e-03f, -1.04143254e-01f,
  -5.79916537e-02f, -2.30482947e-02f, 9.45638567e-02f, -2.82689859e-03f, -4.83495481e-02f, 6.34773970e-02f, 3.64360139e-02f, -9.26699862e-02f, -2.06824858e-02f, 5.12957899e-03f,
  -5.75272702e-02f, -2.23841593e-02f, -1.85236484e-02f, -1.52992345e-02f, 1.09233335e-02f, 6.00003861e-02f, -9.69623961e-03f, 2.11509806e-03f, -3.67987938e-02f, -5.44712171e-02f,
  8.18938464e-02f, -7.16977008e-03f, 1.88707318e-02f, 5.08665014e-03f, 3.15871201e-02f, 9.80810821e-02f, 6.34004688e-03f, -3.79237235e-02f, -1.92795750e-02f, 1.35620134e-02f,
  4.76829037e-02f, 3.57225649e-02f, -7.33988285e-02f, 7.98942801e-03f, 8.29790235e-02f, -6.18703365e-02f, -2.24927627e-02f, -2.39657843e-03f, 3.54534835e-02f, 2.88472716e-02f,
  -1.05557263e-01f, -1.71507791e-01f, -1.96468700e-02f, 5.10052741e-02f, -1.48277367e-02f, 6.12328053e-02f, 2.13093348e-02f, 8.61812104e-03f, -4.84951138e-02f, -4.47643250e-02f,
  6.37224540e-02f, 1.01007380e-01f, -1.87567361e-02f, -1.43981236e-03f, 9.62657407e-02f, -3.10739633e-02f, 3.97191709e-03f, 6.03329130e-02f, 1.42905980e-01f, -6.23115746e-04f,
  1.75393540e-02f, -7.85717294e-02f, 1.54334754e-01f, 4.06280346e-02f, 2.34059263e-02f, -4.01660204e-02f, -1.91027373e-02f, 8.05239845e-03f, -1.15029840e-02f, -1.81341004e-02f,
  3.61500770e-01f, -3.02596360e-01f, 1.76986888e-01f, 2.92225778e-01f, 1.83809564e-01f, 2.00529695e-02f, 2.40693882e-01f, -1.19292580e-01f, 2.00922847e-01f, -3.56398225e-01f,
  -9.20099616e-02f, 6.16277047e-02f, -8.92103314e-02f, -7.76354223e-02f, 2.28391394e-01f, -9.44620594e-02f, 1.80536639e-02f, 5.53258583e-02f, 4.22547348e-02f, -4.77959923e-02f,
  8.08618516e-02f, -1.55059904e-01f, 2.83052754e-02f, -2.94219762e-01f, 5.08248471e-02f, 1.95219517e-02f, -7.94704556e-02f, 7.23912641e-02f, -9.19611380e-02f, 6.22357652e-02f,
  2.04525553e-02f, 1.74074471e-02f, 4.69469130e-02f, -7.51417503e-02f, -2.47233529e-02f, 3.78302671e-02f, 2.96615367e-03f, 5.24077974e-02f, 1.25152782e-01f, -7.10811019e-02f,
  -1.88734178e-02f, -1.98565647e-02f, -2.85527334e-02f, -1.73493102e-02f, 6.82209656e-02f, 1.89291108e-02f, 3.36741768e-02f, -1.45103773e-02f, 8.26480705e-03f, 6.86343759e-02f,
  5.01917973e-02f, 1.28664793e-02f, -1.13988714e-02f, -4.38174009e-02f, 4.63109277e-02f, -2.63046328e-04f, 3.45117338e-02f, 1.70057695e-02f, 4.99806963e-02f, 6.08640946e-02f,
  -3.24935503e-02f, 2.35017296e-02f, -3.74898724e-02f, -1.56099629e-02f, -3.94461825e-02f, 2.84587741e-02f, -1.87995043e-02f, -5.11775613e-02f, 5.24757579e-02f, -2.38951277e-02f,
  2.94216797e-02f, 2.66456977e-02f, 2.21869089e-02f, 4.37221713e-02f, 5.61094377e-04f, 6.57710992e-03f, 9.24145244e-03f, -2.34015174e-02f, 1.51822269e-02f, 1.67130735e-02f,
  -6.68214634e-03f, 2.92547531e-02f, -1.80146936e-02f, 5.45173921e-02f, -7.43219033e-02f, 5.50777372e-03f, -8.81093740e-02f, -1.09942378e-02f, 3.77046838e-02f, 1.20616127e-02f,
  -1.96308315e-01f, -2.17702910e-01f, -4.30972315e-02f, -6.60127178e-02f, -7.40585923e-02f, -7.69401789e-02f, -1.88755691e-02f, -6.40572831e-02f, 3.40060913e-03f, -2.46463772e-02f,
  -4.13173176e-02f, 3.73208448e-02f, -2.05716360e-02f, 2.38257963e-02f, -4.91390266e-02f, -4.66066450e-02f, 2.93686017e-02f, -4.73822020e-02f, 2.38198396e-02f, -4.33939509e-02f,
  1.14892609e-02f, 7.19870627e-03f, -2.91333292e-02f, 1.95844006e-02f, -8.01086935e-05f, 7.83482660e-03f, -3.51082087e-02f, -2.70960163e-02f, 1.91923343e-02f, -5.37625700e-03f,
  1.32977426e-01f, -4.31787193e-01f, -2.23843858e-01f, 1.08688280e-01f, 1.86169893e-01f, -1.42152496e-02f, -6.44237995e-02f, 1.03072308e-01f, 6.06994219e-02f, -7.33485371e-02f,
  1.13800587e-02f, -4.43544149e-01f, -2.62192100e-01f, -2.01419681e-01f, -1.53873444e-01f, -3.16835403e-01f, -1.49029508e-01f, -1.41646028e-01f, -6.73935935e-02f, -1.28922358e-01f,
  -3.38903293e-02f, 1.13164477e-01f, -2.18357533e-01f, 1.83348969e-01f, 1.19037993e-01f, 1.52363166e-01f, 1.59362599e-01f, 2.64674556e-02f, 1.04469590e-01f, 8.41293670e-03f,
  -4.11656089e-02f, -5.76794297e-02f, -9.05946866e-02f, 3.77128385e-02f, 1.76168177e-02f, 7.73863643e-02f, -2.78044771e-03f, -3.22850496e-02f, -2.66085230e-02f, 1.77497964e-03f,
  -1.42094895e-01f, 3.20038944e-02f, 1.07379280e-01f, 2.11851764e-02f, 5.41758351e-02f, 6.02654666e-02f, 1.47647341e-03f, -3.24603729e-02f, -1.85619108e-02f, -2.01195017e-01f,
  -9.52138826e-02f, 4.30767722e-02f, 8.74232221e-03f, 2.13200711e-02f, -7.79448375e-02f, 2.62956694e-02f, 5.66939963e-03f, -1.75597295e-01f, 8.55342299e-03f, -9.37883481e-02f,
  3.07564717e-02f, -2.86986232e-02f, -2.91601885e-02f, 6.94585443e-02f, 6.86327145e-02f, 6.80420920e-02f, 1.68374721e-02f, -2.43252628e-02f, -2.38980558e-02f, -8.85446817e-02f,
  1.13544203e-01f, 2.67556664e-02f, -1.16523588e-02f, 1.39570525e-02f, -2.47342116e-03f, 4.51825634e-02f, 5.70482202e-02f, 1.10827975e-01f, 7.08822310e-02f, -3.08520608e-02f,
  5.07990569e-02f, -1.21165039e-02f, 6.88645430e-03f, 9.54547599e-02f, -3.52950431e-02f, -2.50471886e-02f, 1.14269275e-02f, 6.47652522e-02f, -2.66206283e-02f, 6.96336925e-02f,
  -8.37386921e-02f, -1.74982458e-01f, -9.09069553e-02f, 8.11659545e-02f, -7.79593289e-02f, 9.07486007e-02f, 2.16320585e-02f, 2.35975278e-03f, 1.61170475e-02f, 7.24968314e-02f,
  -2.75297314e-02f, 7.18650147e-02f, 2.01927796e-01f, 3.46546546e-02f, 1.09389899e-02f, 6.13886118e-02f, -3.83170322e-02f, -7.69688794e-03f, 8.63971859e-02f, 1.78225692e-02f,
  9.75006744e-02f, 9.82587263e-02f, 1.30946534e-02f, 8.14548805e-02f, 5.95117062e-02f, 1.77262276e-02f, 3.26923504e-02f, -6.38268068e-02f, 6.75662830e-02f, -4.89772968e-02f,
  -4.37388457e-02f, 3.22376013e-01f, 3.83837163e-01f, 3.72802317e-01f, -2.96120942e-01f, -2.22477078e-01f, -8.06086436e-02f, -7.34942481e-02f, 4.29780930e-02f, -1.15745723e-01f,
  -1.45059645e-01f, 3.10943484e-01f, -2.86129475e-01f, 2.90441006e-01f, 6.28655478e-02f, -1.57198116e-01f, 1.60919487e-01f, 9.35807377e-02f, -1.61413103e-03f, 7.12988153e-02f,
  6.86260164e-02f, -4.54740673e-02f, 1.08104505e-01f, 8.19620863e-02f, 2.19944298e-01f, 3.45769197e-01f, 1.38133600e-01f, 1.42903626e-01f, 4.02017057e-01f, 9.36959460e-02f,
  -4.34097312e-02f, 1.36829019e-02f, 9.49739665e-02f, 5.33861555e-02f, -1.68916974e-02f, -6.25278279e-02f, 2.43969020e-02f, 3.89518440e-02f, 1.52684283e-02f, 6.55825809e-02f,
  -2.19576769e-02f, 3.54483388e-02f, 1.67153165e-01f, 4.59000543e-02f, -3.52349356e-02f, 1.28168762e-01f, 8.78943130e-03f, -2.16112155e-02f, 4.26665321e-02f, -1.81387383e-02f,
  5.58830351e-02f, 6.55130018e-03f, 3.58364172e-02f, 9.30500999e-02f, 7.92860016e-02f, 6.94482997e-02f, 8.30022693e-02f, 7.14501515e-02f, 1.75676659e-01f, 1.37099236e-01f,
  -1.69263005e-01f, 2.79974770e-02f, 5.15609570e-02f, 7.44518861e-02f, 6.51940331e-02f, 3.80722620e-02f, -1.17346019e-04f, -5.95812798e-02f, 5.76272234e-02f, -3.30498815e-03f,
  3.02337427e-02f, 8.61178339e-02f, -5.82426898e-02f, 1.42662469e-02f, -3.60228792e-02f, 3.93490158e-02f, -1.57821663e-02f, 6.84671700e-02f, -8.78661685e-03f, 3.17096449e-02f,
  -3.10142674e-02f, 1.95967443e-02f, 6.49095103e-02f, -7.78801963e-02f, -4.07096464e-03f, -9.84860398e-03f, 6.85952976e-02f, 7.04511851e-02f, -7.68602267e-02f, -8.84768665e-02f,
  -1.21505074e-02f, 2.33446166e-01f, 1.21642845e-02f, 1.02346763e-02f, 5.37665263e-02f, 2.28799917e-02f, 2.12178603e-02f, 4.89034392e-02f, 9.50427055e-02f, -2.75244638e-02f,
  -8.55092257e-02f, 5.72704803e-03f, -3.48938368e-02f, -2.61944458e-02f, -7.86840450e-03f, 3.32380757e-02f, 1.05280532e-02f, -3.95275792e-03f, 4.81686927e-02f, 2.25306321e-02f,
  6.83238544e-03f, -1.47039369e-01f, 2.56946217e-02f, -4.47990410e-02f, -3.64065915e-02f, 3.32276821e-02f, 3.87856141e-02f, 4.74165678e-02f, 2.43522841e-02f, 5.67864291e-02f,
  -8.69125500e-02f, -3.05091411e-01f, -2.75164247e-01f, -2.20112681e-01f, 8.35001320e-02f, 3.83912235e-01f, -5.91458753e-02f, -8.42534527e-02f, -3.94659847e-01f, 1.94997877e-01f,
  1.30713820e-01f, -3.08378667e-01f, -3.07581365e-01f, 4.61663865e-02f, -1.41077906e-01f, -2.41102636e-01f, 2.13294476e-01f, 1.34669766e-01f, -2.31961906e-01f, 7.31210317e-03f,
  -7.86073729e-02f, 2.38853812e-01f, -1.90012410e-01f, 2.52113879e-01f, 1.34123206e-01f, 8.99423063e-02f, 2.41448179e-01f, -1.13208048e-01f, 3.06344599e-01f, 8.51524919e-02f,
  8.27248767e-02f, -1.63688406e-01f, -6.08695857e-02f, 2.27573384e-02f, 1.70870408e-01f, 1.10620402e-01f, 1.71429306e-01f, -6.50502183e-03f, -5.23216724e-02f, -5.20100966e-02f,
  7.98549876e-02f, -4.59216833e-02f, -1.38321184e-02f, -1.66133553e-01f, 1.52644850e-02f, -2.32643317e-02f, -9.89435539e-02f, -4.76717651e-02f, -9.42381471e-02f, -1.29812926e-01f,
  -2.41287008e-01f, -1.70971937e-02f, 5.99664710e-02f, 6.73648575e-03f, -2.02502720e-02f, 2.67806724e-02f, 5.99608384e-02f, 2.17648391e-02f, 1.05117731e-01f, 6.67931959e-02f,
  -3.96661125e-02f, 1.37304679e-01f, 8.76887608e-03f, 1.82850230e-02f, -7.39805847e-02f, 3.82510088e-02f, 4.96021584e-02f, 4.50790040e-02f, -5.02554327e-02f, 2.21269093e-02f,
  5.10884225e-02f, -8.53974596e-02f, 1.46499667e-02f, 8.68046060e-02f, 3.20633128e-02f, 3.31591442e-02f, 2.71209590e-02f, 1.89930312e-02f, -4.76997122e-02f, 3.62439901e-02f,
  -7.24659264e-02f, 2.93810852e-02f, -2.97623426e-02f, 5.08480594e-02f, 8.06873217e-02f, -6.53898939e-02f, 8.98322016e-02f, -2.85392907e-02f, 4.43024281e-03f, 8.22945163e-02f,
  1.77102238e-01f, 1.04666345e-01f, -3.84068452e-02f, 6.00937866e-02f, -1.14216525e-02f, 1.96772162e-02f, 9.49465763e-03f, 2.80286316e-02f, -1.67441647e-02f, 2.40524765e-02f,
  1.05076917e-01f, 3.23693864e-02f, 2.26045057e-01f, -3.01610325e-02f, 6.14543520e-02f, -6.51098927e-03f, 6.82006478e-02f, 1.62114557e-02f, 8.57043490e-02f, 8.90541524e-02f,
  5.21222800e-02f, 3.98410372e-02f, -2.50470415e-02f, 3.02362423e-02f, 1.20864555e-01f, 2.98634060e-02f, 6.07709922e-02f, -9.02252831e-03f, 5.31286821e-02f, 1.23286592e-02f,
  -3.77597928e-01f, 2.16559649e-01f, -2.72993743e-01f, 8.36749598e-02f, 1.28975362e-01f, -4.22924161e-01f, 4.13713716e-02f, 4.26320219e-03f, 1.85128257e-01f, 2.59699702e-01f,
  2.11197719e-01f, 9.64058191e-02f, 2.06812412e-01f, 1.87201187e-01f, -5.66521823e-01f, 6.82490133e-03f, -2.44563177e-01f, 1.46124791e-02f, 1.90438386e-02f, -6.94420263e-02f,
  -1.97079673e-01f, 2.84088492e-01f, -1.25644505e-01f, 2.11408615e-01f, -5.87420352e-03f, -4.12755497e-02f, -1.36946291e-01f, 1.33790746e-01f, -7.14672208e-02f, 9.89517383e-03f,
  -1.12169288e-01f, 2.76080638e-01f, 2.27382015e-02f, -7.76648000e-02f, -2.40956783e-01f, -1.15909979e-01f, -1.43911570e-01f, 1.17055159e-02f, 3.28071341e-02f, -2.81004771e-03f,
  -1.36370212e-02f, 2.15415135e-02f, 5.86655922e-02f, 1.58122912e-01f, 2.93691698e-02f, 7.96884857e-03f, -3.32522392e-02f, -7.34654739e-02f, 5.48769832e-02f, -6.83354959e-02f,
  5.01501523e-02f, -1.25940010e-01f, -1.56491026e-01f, 3.20592918e-03f, -5.99876940e-02f, 1.28894821e-01f, -1.35633469e-01f, -8.98967013e-02f, -1.11275010e-01f, -4.81151082e-02f,
  6.86510950e-02f, -2.51730289e-02f, -3.37982737e-03f, 5.22731915e-02f, 4.24775183e-02f, -5.59739163e-03f, 4.44985963e-02f, -3.46995145e-02f, -5.25509194e-03f, -1.14862248e-02f,
  -3.27396467e-02f, 3.61369103e-02f, 8.70177224e-02f, -7.23685473e-02f, -1.79461800e-02f, -1.00286221e-02f, 2.96683586e-03f, 7.51088113e-02f, -1.63062155e-01f, -7.76033774e-02f,
  1.42783850e-01f, -4.06243466e-02f, 3.41714285e-02f, -9.70927998e-02f, -2.32309457e-02f, 3.81331071e-02f, 2.81470064e-02f, -6.03892766e-02f, -3.79161630e-03f, -9.06182528e-02f,
  -3.00854385e-01f, -9.30201933e-02f, 3.21206972e-02f, 1.32367965e-02f, 1.46658451e-03f, -8.99836197e-02f, 9.67997313e-03f, -4.67549376e-02f, 9.57113039e-03f, 5.11847809e-02f,
  -8.75872225e-02f, -4.75967526e-02f, -1.56096995e-01f, 3.34600769e-02f, -2.98972726e-02f, -9.08389241e-02f, 5.34465984e-02f, 3.21538486e-02f, -3.23425941e-02f, -1.21027432e-01f,
  -1.66685134e-02f, 8.70173201e-02f, -8.03962946e-02f, 3.28131057e-02f, -3.79518755e-02f, 1.31618287e-02f, -1.29834935e-02f, -7.99920503e-03f, -6.09145463e-02f, 1.66052673e-02f,
  -2.80776143e-01f, 9.75048915e-02f, -8.41170624e-02f, -1.49910107e-01f, 2.49596998e-01f, -1.37753710e-02f, 1.14064075e-01f, 2.30134606e-01f, 7.91439414e-02f, 3.53644378e-02f,
  1.48216821e-02f, -2.27498949e-01f, 1.48226067e-01f, -1.77581653e-01f, -2.89030254e-01f, -5.98213710e-02f, -1.61881298e-01f, -1.57152221e-01f, 6.28311336e-02f, -7.18949421e-04f,
  3.35510261e-02f, 3.38815413e-02f, -1.06643056e-02f, 3.12271208e-01f, 2.14388780e-02f, 7.34856054e-02f, -2.65794713e-02f, 1.98023304e-01f, -1.18798673e-01f, 8.29846412e-03f,
  5.81016988e-02f, 1.28020957e-01f, 6.25092536e-02f, 6.94621801e-02f, 6.36546388e-02f, 8.46205465e-03f, -5.12157083e-02f, 4.73060310e-02f, 3.13677303e-02f, 7.90125877e-03f,
  -6.32669553e-02f, 1.57751190e-03f, -5.65034933e-02f, 3.13461497e-02f, 5.33101857e-02f, 2.02336963e-02f, -3.13780317e-03f, 1.50930071e-02f, 1.00705996e-01f, -4.09157015e-02f,
  4.30539101e-02f, -9.79499742e-02f, -5.33396304e-02f, -3.19723934e-02f, -3.32979746e-02f, 2.51444355e-02f, -3.18848155e-02f, -8.58732387e-02f, -9.09930170e-02f, -7.42495805e-02f,
  -2.36798339e-02f, 9.38022658e-02f, 7.84421936e-02f, 7.24340081e-02f, -3.76949199e-02f, 4.60954197e-03f, -4.41839173e-02f, -1.40799666e-02f, 4.63110395e-03f, -4.25732434e-02f,
  2.58167479e-02f, 5.11709563e-02f, 4.58674282e-02f, -4.03153040e-02f, -5.61193340e-02f, -3.76065751e-03f, -1.88257191e-02f, -1.20957159e-01f, -4.33317311e-02f, 2.83899549e-02f,
  8.44842121e-02f, -1.71375912e-04f, 2.50976253e-02f, 3.97586562e-02f, 1.66123807e-02f, -6.15961365e-02f, -2.41650827e-02f, -4.31319848e-02f, 4.52700332e-02f, -3.43091600e-02f,
  2.48524155e-02f, 1.03344703e-02f, 1.47987008e-01f, 1.02935307e-01f, 4.02550623e-02f, -2.23496407e-02f, 4.76336889e-02f, -5.03901280e-02f, -1.13904495e-02f, 4.10950929e-02f,
  2.38462035e-02f, 5.16280383e-02f, -5.38758636e-02f, -8.43503922e-02f, -4.21656780e-02f, 4.70637996e-03f, -5.61639182e-02f, 1.97450910e-02f, 2.02267393e-02f, -5.16246669e-02f,
  1.73383709e-02f, 1.77599140e-03f, 3.69595475e-02f, 7.33083859e-02f, -1.55612985e-02f, -7.73003250e-02f, -3.03261783e-02f, 5.57886064e-02f, -3.41756456e-02f, -6.19350933e-02f,
  1.54277265e-01f, 5.63456900e-02f, -9.10997167e-02f, 9.26429853e-02f, -2.25933671e-01f, 7.42728934e-02f, 3.80439818e-01f, -9.86742377e-02f, -1.72608688e-01f, 1.83505759e-01f,
  1.43507525e-01f, 1.95172261e-02f, 2.84432620e-01f, 2.05212742e-01f, 1.64576277e-01f, 2.24669442e-01f, 1.49498209e-01f, 1.16047785e-01f, -1.56185180e-01f, 1.37693495e-01f,
  -1.50458785e-02f, 2.02204168e-01f, 1.93410024e-01f, -1.73907235e-01f, 1.15623668e-01f, -1.73079789e-01f, 2.73218509e-02f, -8.04343298e-02f, -4.52558585e-02f, 6.54105172e-02f,
  -1.54227084e-02f, -3.30110379e-02f, 3.76895666e-02f, -3.43152098e-02f, 1.27066346e-03f, 4.22031470e-02f, 1.45595213e-02f, 1.06565401e-01f, -1.40843317e-02f, 1.19752157e-02f,
  -2.36630943e-02f, -1.08577214e-01f, -6.05493262e-02f, -2.79069766e-02f, -7.32940361e-02f, -9.62276533e-02f, -6.28256500e-02f, -1.71105564e-02f, -7.82470568e-04f, 5.13646938e-02f,
  1.75480414e-02f, 5.86200412e-03f, 4.26105522e-02f, 6.74814731e-02f, -1.52741345e-02f, -1.08254049e-02f, 3.36241573e-02f, -1.78716052e-02f, -6.77823648e-02f, -1.41807618e-02f,
  -6.68701343e-03f, -3.56890517e-03f, 6.40646322e-03f, 2.96404921e-02f, -3.27648558e-02f, -2.24238709e-02f, -5.89852966e-03f, 3.68758589e-02f, -9.69887536e-04f, 7.70045370e-02f,
  -3.50141264e-02f, -8.45806897e-02f, 1.90037824e-02f, 4.20060121e-02f, -5.76198585e-02f, 5.23148887e-02f, 2.91990899e-02f, -5.31528853e-02f, 2.44028252e-02f, -9.02267843e-02f,
  3.30645032e-02f, -5.94160296e-02f, 1.51331071e-02f, 4.37564105e-02f, 2.94198841e-02f, 2.67900191e-02f, 4.66295294e-02f, 2.16977596e-02f, 6.86523458e-03f, 3.03818639e-02f,
  1.01425275e-01f, 2.10363120e-02f, 1.42294569e-02f, 1.70338955e-02f, 1.36126643e-02f, -5.88059472e-03f, 3.23646478e-02f, -3.92457880e-02f, 9.31640901e-03f, 4.18338217e-02f,
  -8.72781649e-02f, -2.43479069e-02f, -9.38608348e-02f, 1.20182978e-02f, -6.66230693e-02f, 1.85337458e-02f, 5.79664297e-02f, -5.06826267e-02f, 7.17099831e-02f, 3.86844808e-03f,
  8.43197256e-02f, 2.81062592e-02f, -1.29710194e-02f, -3.48543422e-03f, -5.99282943e-02f, 9.64476764e-02f, -3.84391174e-02f, -7.84258395e-02f, -2.44104173e-02f, 2.20616367e-02f,
  -4.13107544e-01f, 2.60645840e-02f, 4.53111231e-01f, -3.55415255e-01f, 1.23114154e-01f, 1.96338803e-01f, 1.27859816e-01f, -6.64968975e-03f, -2.28315875e-01f, -7.78607950e-02f,
  1.66256027e-03f, 4.18162420e-02f, 2.09593520e-01f, -2.40366608e-01f, 1.04463540e-01f, 2.66677588e-02f, -2.94766724e-01f, -9.24548954e-02f, -9.17620771e-03f, -2.26331037e-02f,
  -2.87447777e-02f, -8.70421901e-02f, 1.24218009e-01f, 3.48640420e-02f, 1.99946631e-02f, -5.75708076e-02f, -1.10898927e-01f, 3.48850787e-01f, -1.09372661e-01f, 1.17719688e-01f,
  -1.08498409e-01f, -6.80980906e-02f, -1.23579077e-01f, -5.36860840e-04f, 1.09027699e-02f, 1.57420766e-02f, -1.35967927e-02f, 8.53821114e-02f, -9.17478204e-02f, -1.16381403e-02f,
  2.97998991e-02f, 4.17576544e-02f, -5.14064394e-02f, 5.94989471e-02f, -3.64098474e-02f, -1.70335323e-02f, 7.46970698e-02f, -4.86928225e-03f, 2.16360716e-03f, 5.30894659e-02f,
  1.33430302e-01f, 2.59133596e-02f, -2.83314101e-02f, -1.51396198e-02f, 1.25694141e-01f, -3.21807377e-02f, -6.55409619e-02f, 8.59629065e-02f, 9.61302128e-03f, -5.04823998e-02f,
  6.19752221e-02f, 4.09772769e-02f, 7.04465285e-02f, -9.52653680e-03f, -1.39344120e-02f, -1.03552388e-02f, -2.60521285e-02f, -2.67910939e-02f, 1.12445923e-02f, -3.46007966e-03f,
  -4.86523993e-02f, 4.70501464e-03f, -5.73719740e-02f, -8.20545405e-02f, -9.71953664e-03f, -9.22628790e-02f, 1.50839435e-02f, -3.80303571e-03f, -7.22592371e-03f, 3.26192081e-02f,
  -9.79640242e-03f, 3.64671722e-02f, 7.11463690e-02f, -1.88773405e-02f, -3.59492056e-04f, -9.84289777e-03f, -3.13143954e-02f, 2.23230030e-02f, -7.18318745e-02f, 8.96725282e-02f,
  -1.86461508e-01f, -1.27339885e-01f, -4.80953567e-02f, -3.76225598e-02f, -7.22767040e-02f, -3.00427657e-02f, -1.85510460e-02f, -5.32573275e-02f, -6.43593296e-02f, 2.41850782e-02f,
  -5.21310642e-02f, -2.07433011e-02f, -2.55820192e-02f, -4.14477736e-02f, 1.25898719e-01f, -4.11940590e-02f, -4.64644004e-03f, -5.03273606e-02f, -6.25137985e-02f, -3.05584855e-02f,
  -6.71655089e-02f, -6.46509901e-02f, 1.10064149e-01f, -1.38398977e-02f, -3.72426771e-02f, -1.48544330e-02f, -4.52352911e-02f, -2.22438164e-02f, 9.09450799e-02f, 3.66123058e-02f,
  -2.08421871e-01f, -1.26245871e-01f, -2.57698357e-01f, -2.96889037e-01f, -8.72492865e-02f, -8.02459270e-02f, -2.03416303e-01f, 1.07145132e-02f, 4.88400683e-02f, 1.31826133e-01f,
  -3.76080088e-02f, 1.80565938e-02f, 1.97752789e-01f, -3.08189720e-01f, -1.86531812e-01f, -1.47407502e-02f, -2.90584058e-01f, -7.13098049e-02f, -3.21825258e-02f, 5.22533357e-02f,
  -1.33654729e-01f, -1.53225074e-02f, -2.73468226e-01f, 1.30407840e-01f, -2.43939131e-01f, -1.07182480e-01f, -3.48040722e-02f, -1.94390249e-02f, -2.44972065e-01f, -1.70682013e-01f,
  -1.79121673e-01f, 8.88833869e-03f, -1.50456905e-01f, -2.61004176e-02f, -9.17478278e-02f, 8.80852789e-02f, -2.08266489e-02f, -5.92561327e-02f, -7.71393105e-02f, -1.64673571e-02f,
  5.90709858e-02f, 8.89570266e-02f, 2.30584927e-02f, -7.51015777e-03f, -3.16558629e-02f, -8.15234408e-02f, -5.23507185e-02f, -4.93771881e-02f, -4.21182252e-02f, -1.05096288e-01f,
  -1.15193643e-01f, -8.41635019e-02f, -3.49201635e-02f, 1.39997033e-02f, -3.33024003e-02f, -6.63960800e-02f, -8.51757973e-02f, -1.26117449e-02f, -4.53086831e-02f, -2.44003255e-02f,
  1.20262802e-02f, 8.23893696e-02f, -1.10125476e-02f, 3.43504436e-02f, -2.53634378e-02f, -6.71249107e-02f, -3.12265474e-02f, 2.80726068e-02f, -6.23526890e-03f, -9.22373962e-03f,
  3.96113098e-02f, -7.30037503e-03f, -7.19748961e-04f, -7.56783634e-02f, -2.45856456e-02f, 7.08418787e-02f, 6.92920014e-02f, -5.75411506e-03f, -2.12365240e-02f, 2.19637435e-02f,
  3.86539400e-02f, 1.59497547e-03f, -3.34387342e-03f, 4.11760174e-02f, -1.39319589e-02f, 3.24369483e-02f, 5.43659814e-02f, -9.42202434e-02f, 1.98342162e-03f, 9.96071398e-02f,
  6.40863255e-02f, 1.47662625e-01f, -3.65049094e-02f, -2.14717556e-02f, 3.43676955e-02f, 5.74208535e-02f, -3.50972265e-02f, -3.35369743e-02f, -9.06552449e-02f, 1.36569738e-01f,
  5.13555072e-02f, 1.86839122e-02f, 7.57008269e-02f, -3.83218005e-02f, -1.07038515e-02f, -5.91055974e-02f, 4.05020230e-02f, 4.61257994e-02f, 3.17235701e-02f, 2.26494800e-02f,
  5.99482679e-04f, 1.42499998e-01f, 1.00764014e-01f, 1.72027573e-02f, -3.78230102e-02f, 1.59136206e-02f, 4.13562730e-02f, -8.91107228e-03f, -1.87685713e-02f, 1.38901942e-03f,
  -6.42222583e-01f, 3.97785783e-01f, 2.89253592e-01f, -1.88680559e-01f, 3.08105275e-02f, 2.50152677e-01f, 2.26317018e-01f, 8.17134082e-02f, 1.48167834e-01f, 7.17847571e-02f,
  -1.56407595e-01f, -2.46542767e-02f, 1.36068553e-01f, 5.72124645e-02f, 1.57534946e-02f, 1.90528661e-01f, -2.95649655e-02f, 1.79908462e-02f, 1.21117875e-01f, -5.30760996e-02f,
  -2.31149364e-02f, -8.46083462e-02f, -1.04178851e-02f, 2.84275152e-02f, -7.18308985e-02f, -5.08126877e-02f, -2.22979337e-01f, 2.67738402e-01f, -7.05738217e-02f, 1.44776732e-01f,
  -1.58006564e-01f, -1.89718217e-01f, -2.02051893e-01f, -5.88600300e-02f, -9.78707969e-02f, -6.64160922e-02f, 5.61977737e-03f, 3.71486358e-02f, 1.10097071e-02f, -1.00937383e-02f,
  -2.15458646e-02f, -7.07033128e-02f, -5.34885563e-02f, 3.23754475e-02f, 7.63297230e-02f, -6.05906434e-02f, 7.19028488e-02f, -2.49994602e-02f, -4.61311953e-04f, -1.62358675e-02f,
  8.72450098e-02f, 1.93053149e-02f, -5.46720587e-02f, -5.42948162e-03f, 1.16077596e-02f, -3.30222920e-02f, 5.07238209e-02f, -1.57357124e-03f, -8.00042599e-02f, 1.30606992e-02f,
  9.54412073e-02f, 3.02387234e-02f, -2.72750994e-03f, 3.73145118e-02f, 5.48838675e-02f, -2.47119218e-02f, -2.13538446e-02f, -8.97589326e-02f, 3.41389924e-02f, -8.81231800e-02f,
  -8.46026167e-02f, -2.69046407e-02f, -1.22707650e-01f, -4.64327671e-02f, 1.69574078e-02f, -1.89251651e-03f, -3.46434638e-02f, -3.88671197e-02f, 3.46153006e-02f, -7.03630745e-02f,
  5.28083835e-03f, 3.26956250e-03f, -1.01130664e-01f, -1.61900505e-01f, 4.31696586e-02f, 5.70442006e-02f, -1.64028239e-02f, -1.39556490e-02f, -1.20815597e-01f, -4.10220865e-03f,
  -4.06872965e-02f, 2.48139221e-02f, -7.08003938e-02f, -1.97412580e-01f, -6.34980723e-02f, -4.93909158e-02f, 4.68123890e-02f, -8.27380270e-02f, 7.27462694e-02f, -3.01984902e-02f,
  -3.12047713e-02f, -8.03395361e-02f, -3.70618068e-02f, -1.32605657e-02f, 9.33086798e-02f, -6.18995028e-03f, 7.36910030e-02f, -2.39733644e-02f, -5.20949028e-02f, 1.35459658e-02f,
  -9.26847383e-02f, 4.47385721e-02f, 3.40333991e-02f, -1.67905226e-01f, -6.50882199e-02f, -9.22970027e-02f, -2.19523050e-02f, 2.88127689e-04f, -6.51662052e-03f, 4.80437018e-02f,
  -1.88872427e-01f, 2.26970147e-02f, -2.81828851e-01f, 1.02951363e-01f, -3.38202149e-01f, 1.31952867e-01f, 2.44842753e-01f, -7.37069100e-02f, 6.12688102e-02f, 3.57513726e-01f,
  1.60763621e-01f, 7.96141103e-04f, 1.38267443e-01f, 3.38389277e-01f, -3.62062454e-02f, 2.88873374e-01f, 2.52306104e-01f, 2.79643387e-01f, 5.28508890e-03f, 1.42733799e-02f,
  -6.03195056e-02f, 1.86343327e-01f, -1.84287578e-02f, -8.08290243e-02f, -1.36146426e-01f, -1.83211088e-01f, -6.80203587e-02f, -2.40122855e-01f, 6.54081106e-02f, -5.45637608e-02f,
  4.37692702e-02f, -3.95233221e-02f, -5.11950999e-02f, 9.55070462e-03f, -4.68863845e-02f, -2.94325370e-02f, -1.19632818e-02f, -4.61768992e-02f, 1.89356285e-03f, -5.49402740e-03f,
  3.52565721e-02f, -8.67581740e-03f, 7.72386193e-02f, -2.56208852e-02f, -5.00943919e-04f, -5.44418134e-02f, -1.95074454e-02f, 2.61420161e-02f, -3.64639636e-05f, -5.57897501e-02f,
  -2.47122310e-02f, -6.53482080e-02f, 1.40363304e-02f, 5.78858778e-02f, -6.33416101e-02f, -5.69591252e-03f, 6.95705637e-02f, -7.74714053e-02f, -4.86963382e-03f, -4.21616770e-02f,
  -1.12342378e-02f, -4.64027071e-05f, 1.91449616e-02f, 5.62133044e-02f, -2.13455372e-02f, -4.41875570e-02f, 8.00649673e-02f, 6.41631484e-02f, -1.15993563e-02f, 2.59254780e-02f,
  -2.31555682e-02f, -2.82350220e-02f, -3.48631642e-03f, 2.29353346e-02f, 6.55485094e-02f, 6.76633641e-02f, -1.20014483e-02f, -4.90460917e-02f, -8.45371839e-03f, 1.29184006e-02f,
  -8.45302828e-03f, 4.95660603e-02f, 3.69440056e-02f, 1.73433702e-02f, 6.56714141e-02f, -3.10420766e-02f, 1.85949579e-02f, -8.13287403e-03f, 3.54583375e-02f, -6.54353276e-02f,
  1.12836659e-01f, -5.02445176e-02f, 5.15732579e-02f, 5.47827594e-02f, 2.35679187e-03f, -3.31495441e-02f, 1.59574561e-02f, -6.63679764e-02f, 8.51306599e-04f, -1.08834784e-02f,
  1.07154706e-02f, 8.20717290e-02f, -7.08094090e-02f, -7.95132294e-03f, 2.45587863e-02f, 2.34926795e-03f, 1.06113449e-01f, 1.56946108e-02f, 2.24896297e-02f, -5.98963313e-02f,
  -1.91792864e-02f, -2.54089274e-02f, 3.55097838e-02f, -2.44676368e-03f, 8.21350217e-02f, 2.90679559e-02f, -1.41784400e-02f, -2.13257633e-02f, -7.31048808e-02f, 1.62050016e-02f,
  4.96815085e-01f, 3.29604208e-01f, 8.03782940e-02f, 1.97966725e-01f, -2.07435265e-01f, -5.14318086e-02f, -6.53886870e-02f, 7.97636807e-02f, -6.19650520e-02f, 1.13684468e-01f,
  -4.35701869e-02f, 1.91691071e-01f, -8.99454132e-02f, 2.40877852e-01f, -3.12323533e-02f, -1.31123915e-01f, 1.86747223e-01f, 9.11618620e-02f, -4.91930582e-02f, 2.78753191e-01f,
  4.54604104e-02f, 5.24059348e-02f, 6.40927702e-02f, 4.02457863e-02f, 2.18984142e-01f, 1.78236037e-01f, -3.14318128e-02f, -1.13659032e-01f, 1.35248899e-01f, -1.05321422e-01f,
  6.31712005e-03f, 7.56945312e-02f, 4.68723662e-02f, -2.62059812e-02f, 5.26722558e-02f, 6.38029724e-02f, 1.35242064e-02f, -4.19590287e-02f, -1.01514995e-01f, -2.20698910e-03f,
  5.03177270e-02f, 1.36002088e-02f, 6.22459911e-02f, -5.53092472e-02f, 9.00276676e-02f, 4.52700071e-02f, 1.46789551e-02f, -1.50317959e-02f, 5.74987046e-02f, 1.22113384e-01f,
  9.00481418e-02f, 3.62685509e-02f, 4.78720888e-02f, -5.91729209e-02f, -1.47598153e-02f, -1.75024215e-02f, 4.80518341e-02f, -2.09990493e-03f, 3.78442407e-02f, 5.05319759e-02f,
  4.93442528e-02f, -9.25980136e-03f, 2.17453223e-02f, 4.48753685e-02f, 5.15891006e-03f, -6.15324527e-02f, 1.94479488e-02f, -1.90877970e-02f, -6.43309504e-02f, 4.97554801e-03f,
  -5.90404146e-04f, 4.95623760e-02f, 1.80591494e-02f, -1.33962268e-02f, 5.88465817e-02f, 7.13045523e-02f, -3.42375599e-02f, -1.90630704e-02f, -2.85473857e-02f, 1.27252918e-02f,
  -7.03930184e-02f, -3.10279895e-02f, -8.73522833e-03f, -6.31501200e-03f, -1.36825666e-02f, -5.17006293e-02f, 4.01514471e-02f, 3.53766046e-02f, -9.25899893e-02f, 1.94129646e-02f,
  2.60798149e-02f, 1.42169759e-01f, -3.04445419e-02f, -1.61626935e-02f, -6.86467141e-02f, 8.74412432e-02f, 9.42232925e-03f, 9.57697779e-02f, 6.56616688e-02f, 4.42664931e-03f,
  6.27809465e-02f, -4.88988720e-02f, -7.45414346e-02f, 1.98777225e-02f, -2.00393125e-02f, 4.67127785e-02f, -2.86613684e-02f, -7.82522559e-02f, -8.81337677e-04f, 1.34114116e-01f,
  7.69242644e-02f, -1.86472535e-02f, 6.04768172e-02f, -1.01571493e-01f, 1.85545702e-02f, -6.73864409e-02f, 5.39816990e-02f, 2.78472598e-03f, 6.09097891e-02f, -2.15646997e-02f,
  7.80514106e-02f, 2.00556219e-01f, -5.11601344e-02f, 7.68667310e-02f, 5.07785939e-03f, -1.48581654e-01f, -1.34360552e-01f, 4.96671349e-02f, -1.67187676e-01f, 1.14277028e-01f,
  2.65210837e-01f, -1.36051029e-01f, 1.88406587e-01f, 3.04454535e-01f, 1.17782094e-01f, 2.86340654e-01f, 1.76695988e-01f, 6.80452511e-02f, -8.58432241e-03f, 2.31300235e-01f,
  4.93520536e-02f, 3.27223808e-01f, 3.15074712e-01f, 1.20548151e-01f, 2.32642516e-01f, -1.07772991e-01f, 1.51171073e-01f, -2.52700523e-02f, 1.09222606e-02f, 7.79268332e-03f,
  9.55736935e-02f, 2.77396142e-01f, 7.47537762e-02f, -6.16278462e-02f, 1.35317191e-01f, 1.90001596e-02f, -6.41181171e-02f, -3.15509811e-02f, -8.54927823e-02f, -4.08984795e-02f,
  -6.10166900e-02f, -4.43271101e-02f, -1.51030524e-02f, -2.05324367e-02f, -6.69235811e-02f, -7.48282000e-02f, -3.18361856e-02f, -7.47194663e-02f, -8.92359093e-02f, 6.23024255e-02f,
  4.39816266e-02f, -5.14141982e-03f, -1.35734733e-02f, 3.82884219e-02f, -3.71180698e-02f, -8.46589953e-02f, -1.14084624e-01f, 1.87047059e-03f, 1.32948067e-02f, -2.52425205e-02f,
  5.79562597e-02f, -3.80965881e-02f, 4.43841852e-02f, 4.23313417e-02f, 4.68907654e-02f, 5.11277765e-02f, -3.41050439e-02f, -5.44585623e-02f, -9.17626247e-02f, 7.71462545e-02f,
  -2.90326159e-02f, -1.51196343e-03f, -1.21113204e-03f, -2.94182785e-02f, -3.91261274e-05f, -1.62657481e-02f, -3.58510278e-02f, 6.60143094e-03f, -1.17075667e-02f, -6.24450706e-02f,
  -1.82633735e-02f, -3.76579314e-02f, 1.11590279e-02f, -4.81859706e-02f, -3.00531704e-02f, 2.91745178e-02f, 8.24315846e-02f, 6.39102235e-02f, 3.98083888e-02f, 6.10692473e-03f,
  1.55118182e-01f, 2.49196216e-01f, 1.80053376e-02f, -8.45784694e-02f, 7.01438310e-03f, 8.76346380e-02f, 5.79452217e-02f, -4.89673764e-03f, 4.97171469e-02f, 1.04487419e-01f,
  -4.94254716e-02f, -1.23919912e-01f, -5.09392470e-04f, -4.58376994e-03f, -6.64703846e-02f, 3.77130471e-02f, -5.82692586e-03f, -1.01180084e-01f, -2.23982520e-02f, 4.83365403e-03f,
  2.04823036e-02f, 8.39495007e-03f, -2.23022755e-02f, -2.04938557e-03f, -4.76893261e-02f, -2.85027940e-02f, -2.16474873e-03f, 4.42189455e-04f, 9.10254121e-02f, -4.26561683e-02f,
  -4.63714153e-02f, 1.95958287e-01f, 2.69908547e-01f, 2.32392117e-01f, -2.73961633e-01f, -3.19026589e-01f, -2.15863705e-01f, 9.14298370e-02f, -2.52181711e-03f, -1.17101513e-01f,
  -9.80539843e-02f, 1.09185085e-01f, 1.50120869e-01f, -7.60071427e-02f, 2.09117055e-01f, 5.61619252e-02f, 8.50516260e-02f, -1.07336834e-01f, 1.80906698e-01f, 2.15855688e-01f,
  2.15520918e-01f, -2.75789332e-02f, 3.07917714e-01f, 4.16439995e-02f, 6.76142648e-02f, 1.68882757e-01f, 3.18415016e-01f, 5.54696545e-02f, -4.95894514e-02f, -1.01041920e-01f,
  -1.46213770e-01f, 1.31901279e-01f, 7.18538091e-02f, 2.93205474e-02f, 7.25193769e-02f, -9.76379216e-02f, -7.34723881e-02f, 1.01803467e-02f, -1.60669163e-02f, 2.25700866e-02f,
  1.05235931e-02f, -2.57453527e-02f, -3.99522334e-02f, -1.98420379e-02f, -1.32392809e-01f, 6.89089624e-03f, -3.17097194e-02f, 4.69957367e-02f, 1.13192774e-01f, -5.76514425e-03f,
  8.18848088e-02f, -6.23729303e-02f, 4.20278758e-02f, 5.68460152e-02f, 1.36849001e-01f, -6.04928955e-02f, -8.87667909e-02f, 2.92940568e-02f, -3.69573906e-02f, 1.14941515e-03f,
  5.22892177e-02f, 4.62424429e-03f, -5.80451898e-02f, -7.63376430e-02f, -7.54969195e-02f, 5.26074367e-03f, -4.43361364e-02f, -8.15984383e-02f, 2.82252044e-03f, -6.86876550e-02f,
  -5.78671880e-02f, -2.68939286e-02f, -1.42808527e-01f, -8.51702541e-02f, 5.53448275e-02f, -2.42199898e-02f, 1.33071439e-02f, -7.90739432e-02f, 6.63208142e-02f, 4.48221155e-02f,
  2.08164789e-02f, -5.33826277e-02f, 8.64560436e-03f, -1.91406272e-02f, -1.28673807e-01f, -2.55208630e-02f, 3.84663269e-02f, 1.35005899e-02f, 8.16790089e-02f, 2.10448578e-01f,
  1.71261474e-01f, 3.98444980e-01f, 8.18909481e-02f, -6.97930083e-02f, 4.73611765e-02f, 6.21177368e-02f, -5.99392783e-03f, -1.28443390e-02f, 1.42538697e-01f, 8.90824646e-02f,
  -4.72100172e-03f, -1.64121017e-02f, -3.39227766e-02f, -9.90175083e-02f, 2.33255662e-02f, 1.48660049e-01f, 4.35694531e-02f, 1.19083293e-01f, 1.20042734e-01f, 1.01889223e-01f,
  1.04739778e-01f, -1.32512366e-02f, 8.07239041e-02f, 4.35911352e-03f, 4.04649554e-03f, 4.24290821e-02f, -3.96555439e-02f, -4.52255714e-04f, 4.93052825e-02f, 4.07334529e-02f,
  -5.37932456e-01f, 3.08895588e-01f, -3.40468884e-01f, -1.35191425e-03f, 3.41706835e-02f, 1.72995612e-01f, 1.40594631e-01f, 5.05186208e-02f, -1.85936064e-01f, 3.42278540e-01f,
  2.66724229e-01f, -6.89143911e-02f, 8.71461779e-02f, 3.00538212e-01f, -1.85160011e-01f, 1.53166369e-01f, 1.90564036e-01f, 1.33184016e-01f, -4.28022593e-02f, -1.81710571e-01f,
  -8.49168152e-02f, 3.01762044e-01f, -5.97221814e-02f, 5.06847799e-02f, 1.01853795e-01f, -1.24515913e-01f, 1.08619824e-01f, -1.27801314e-01f, 2.63836294e-01f, 1.93214178e-01f,
  -8.74510929e-02f, -2.79574424e-01f, -9.44613144e-02f, -1.40669733e-01f, -1.59127787e-01f, -1.05445385e-01f, -3.90586331e-02f, 3.14745791e-02f, -1.00416504e-01f, -4.18752544e-02f,
  1.59262903e-02f, -3.86230205e-03f, 3.42087895e-02f, -5.93781285e-02f, -1.02134541e-01f, 2.57357918e-02f, 1.16786361e-01f, 8.33716542e-02f, 2.86086258e-02f, 1.42200822e-02f,
  2.04985626e-02f, 7.52882734e-02f, 3.75051238e-02f, 9.96245965e-02f, -1.16431387e-02f, 5.01200669e-02f, 6.96236594e-03f, -5.13150496e-03f, 6.77713454e-02f, -5.06522320e-02f,
  -2.29503326e-02f, -2.38422807e-02f, 7.53645822e-02f, 1.09045338e-02f, -3.54824960e-02f, 9.04063731e-02f, 6.94680363e-02f, 3.00376583e-02f, -5.23087643e-02f, -3.38839702e-02f,
  4.15554047e-02f, 3.37751657e-02f, -5.57965748e-02f, -6.12497777e-02f, 7.24716783e-02f, 1.73608400e-02f, -6.42978847e-02f, -2.90241595e-02f, -1.29485847e-02f, 1.72121935e-02f,
  -2.41420120e-02f, -1.47331968e-01f, 8.83950070e-02f, 9.35430452e-02f, 5.37897237e-02f, -8.45189989e-02f, -4.35447283e-02f, -2.01894492e-02f, -4.00592908e-02f, 4.27108258e-02f,
  -2.27194712e-01f, -3.90541971e-01f, -2.36370750e-02f, 3.15854289e-02f, -1.13023907e-01f, -4.13900800e-02f, -9.66714546e-02f, 1.53156500e-02f, -6.50640205e-02f, -1.38471052e-01f,
  -9.93744433e-02f, 5.83275482e-02f, -7.95586705e-02f, -5.68509735e-02f, 2.26216037e-02f, 1.58220844e-03f, -4.13417444e-02f, -8.18137974e-02f, -1.57864187e-02f, 1.62236877e-02f,
  -3.39215361e-02f, -4.93157543e-02f, 1.76346302e-02f, 3.18111554e-02f, 1.25744874e-02f, 9.77608338e-02f, -7.40960836e-02f, 5.46150170e-02f, 4.35415655e-02f, 4.10956927e-02f,
  1.79553434e-01f, -6.18903600e-02f, -2.36860871e-01f, -1.85018674e-01f, 1.89001426e-01f, 2.28966087e-01f, -1.10025153e-01f, 8.79701972e-02f, -9.58872586e-02f, -1.04397342e-01f,
  2.79131625e-02f, -5.95071204e-02f, -2.79719532e-01f, 3.41310129e-02f, 2.87188619e-01f, -1.53409362e-01f, 2.57522583e-01f, 1.88665599e-01f, 5.29035814e-02f, 1.89839587e-01f,
  1.26527533e-01f, 3.07922214e-01f, -4.30768356e-02f, 3.13319176e-01f, 1.24546386e-01f, 1.03360474e-01f, 5.31661958e-02f, -1.36840353e-02f, 1.11068420e-01f, 2.00402990e-01f,
  -2.20524259e-02f, -1.07471444e-01f, -1.07608549e-01f, 8.56617559e-03f, -2.88247243e-02f, -3.94350290e-02f, 3.24990861e-02f, 7.93346465e-02f, -2.82840133e-02f, -8.09248462e-02f,
  -1.18634747e-02f, 3.25851180e-02f, 1.11464504e-03f, 2.04766002e-02f, 7.95538202e-02f, 7.96131715e-02f, 2.32870784e-02f, -2.13908423e-02f, -4.58905706e-03f, -1.76805537e-02f,
  2.54905131e-02f, -7.81021491e-02f, -1.99900474e-02f, 7.82144889e-02f, 4.08254527e-02f, 9.70180556e-02f, -2.52674744e-02f, 2.95901205e-02f, 1.52161333e-03f, 2.99566351e-02f,
  4.79161181e-02f, 5.37012368e-02f, 5.04850261e-02f, -8.99318010e-02f, 5.13886567e-03f, -8.51265248e-03f, 2.11700108e-02f, -5.56149334e-02f, 4.18995135e-03f, 2.37913858e-02f,
  -4.00937870e-02f, -7.43762106e-02f, -2.34848093e-02f, 1.49056362e-02f, -6.94900975e-02f, 3.13376798e-03f, 6.15831511e-03f, 2.03111358e-02f, 4.12646867e-02f, -8.16428587e-02f,
  -7.12730512e-02f, 8.38062242e-02f, -4.33530584e-02f, -3.88016403e-02f, -1.64910089e-04f, -1.28551731e-02f, -2.32858360e-02f, -5.30845746e-02f, -5.41877300e-02f, -2.43631881e-02f,
  1.03600860e-01f, 1.91666320e-01f, -7.42916614e-02f, 7.59953111e-02f, -4.74062338e-02f, 1.95903238e-02f, -4.83995751e-02f, 1.21850960e-01f, 9.22872573e-02f, 4.14280593e-02f,
  9.08459872e-02f, -4.69435304e-02f, -6.54431283e-02f, 2.14806702e-02f, 5.48793785e-02f, 6.67515676e-03f, 3.64208184e-02f, 2.02133509e-04f, 2.35912539e-02f, 2.69409362e-02f,
  5.57684191e-02f, 3.50166485e-02f, -2.74325022e-03f, 1.24257453e-01f, 4.22923006e-02f, -2.94790119e-02f, 5.44194207e-02f, 3.59332636e-02f, 2.46335883e-02f, -5.06563820e-02f,
  -3.99129651e-02f, 3.63077492e-01f, 9.81774088e-03f, -1.51738346e-01f, -1.31933838e-01f, -9.34461653e-02f, -2.31187135e-01f, 7.88973495e-02f, 8.73105079e-02f, 1.12777792e-01f,
  -1.84697747e-01f, 2.94630587e-01f, 1.01939514e-01f, -1.44660473e-01f, -5.23906611e-02f, 5.63171692e-02f, -2.11270913e-01f, -6.12421185e-02f, 6.03477843e-02f, -9.60033201e-03f,
  -1.10094799e-02f, -1.79257691e-01f, -1.74526736e-01f, 1.61601584e-02f, -1.48598015e-01f, -3.85277942e-02f, -2.48203710e-01f, -3.86234522e-02f, -1.59239411e-01f, -7.12826177e-02f,
  -9.64113995e-02f, -1.93336695e-01f, -9.12055597e-02f, -3.84464189e-02f, -5.37327714e-02f, -3.15158479e-02f, -9.08559710e-02f, -1.77729372e-02f, -6.03111796e-02f, 2.82249227e-02f,
  8.32505003e-02f, 2.17809957e-02f, 3.94435562e-02f, 4.32838500e-02f, -1.48732308e-02f, -6.84106862e-03f, -1.34758670e-02f, -8.49054307e-02f, 4.15347107e-02f, 4.59804945e-02f,
  1.20626345e-01f, -2.10970342e-02f, -1.34486631e-01f, -5.96919060e-02f, -8.90733153e-02f, -1.00726806e-01f, -4.35845032e-02f, -3.18851210e-02f, -7.05687404e-02f, -1.49347419e-02f,
  -5.88429235e-02f, -8.61921255e-03f, -2.71174442e-02f, -1.62987132e-02f, 1.49237728e-02f, -2.99998722e-03f, 2.76647862e-02f, -4.40973677e-02f, -3.80606614e-02f, -7.25857839e-02f,
  -5.30880280e-02f, 8.19811504e-03f, -9.33391042e-03f, -2.33921371e-02f, 2.05124486e-02f, 1.33431386e-02f, -8.48143548e-02f, 7.35641690e-03f, 3.24836895e-02f, 4.25472111e-02f,
  -9.57991462e-03f, -6.89817816e-02f, 2.13785172e-02f, 2.75461040e-02f, -2.24088077e-02f, -1.54666454e-02f, 2.04024632e-02f, 3.03732976e-02f, -3.33702005e-02f, -2.19343845e-02f,
  -1.50878206e-01f, -2.75477856e-01f, -5.92891574e-02f, -1.79634604e-03f, 7.42523326e-03f, 2.03555860e-02f, 1.82848237e-02f, 4.33807783e-02f, -9.85913724e-02f, 7.48836435e-03f,
  1.42236184e-02f, -1.18204542e-02f, -3.48603353e-02f, 1.11983884e-02f, 7.89148360e-02f, 1.94462407e-02f, -1.05693890e-02f, -4.15883362e-02f, -1.05222173e-01f, 6.59730434e-02f,
  5.28956465e-02f, 1.82397310e-02f, 1.08953947e-02f, -1.13003766e-02f, -3.33357193e-02f, -7.38549903e-02f, 4.05276828e-02f, 5.64000346e-02f, -1.04474410e-01f, 1.12531846e-02f,
  -3.03832050e-02f, 1.12189285e-01f, -8.56075510e-02f, 5.20793349e-03f, -2.25355122e-02f, -4.21561003e-01f, -3.12913358e-01f, 7.86411837e-02f, -6.10629022e-02f, 1.98043250e-02f,
  8.38873610e-02f, -1.10787012e-01f, 1.60389930e-01f, -1.83338329e-01f, -1.75265908e-01f, -1.19907884e-02f, -2.27382168e-01f, -2.00216606e-01f, -1.47624882e-02f, 1.34381698e-03f,
  -7.33635528e-03f, -3.20000798e-02f, 1.20312336e-03f, 1.27879098e-01f, -8.24935213e-02f, 1.49496332e-01f, 2.77557731e-01f, 1.29745170e-01f, -7.64681771e-02f, -7.86116421e-02f,
  -1.73509374e-01f, 1.14407621e-01f, 3.59975989e-03f, -1.08544849e-01f, 3.74432025e-03f, -7.57927401e-03f, -7.40157440e-03f, -1.32735781e-02f, 1.66500118e-02f, -3.78136747e-02f,
  -4.89879167e-04f, 2.82190591e-02f, -1.56432856e-02f, 6.52899686e-03f, -3.04592550e-02f, 2.63578240e-02f, -6.46321941e-03f, -4.08796705e-02f, -1.67968385e-02f, -2.95796599e-02f,
  -3.15358564e-02f, -7.95262679e-03f, 1.56435780e-02f, -1.34010715e-02f, 6.22572936e-02f, -1.34136863e-02f, -3.99648026e-02f, 4.18914529e-03f, 2.57964078e-02f, 2.11417396e-02f,
  5.08327670e-02f, -6.15341030e-03f, -3.72281410e-02f, -5.21545298e-02f, -7.91525561e-03f, 7.03452080e-02f, -1.89508945e-02f, 9.31497570e-03f, 6.40202016e-02f, 2.18699370e-02f,
  -3.77804488e-02f, -2.73137074e-03f, -8.70793127e-03f, -4.08434980e-02f, 6.88606780e-03f, -1.46579714e-02f, -9.75550152e-03f, -1.10910926e-02f, 1.06325042e-05f, -2.79605272e-03f,
  1.88909080e-02f, -6.75033107e-02f, -3.80802192e-02f, -1.92082785e-02f, -6.49468154e-02f, 4.10377346e-02f, 9.49993134e-02f, -3.48191261e-02f, 3.42249274e-02f, 1.12845469e-02f,
  -2.64643878e-02f, 2.53590316e-01f, 6.90813828e-03f, -4.92611676e-02f, 3.14708203e-02f, -5.96048087e-02f, -2.43388526e-02f, -6.33911788e-02f, 5.50769009e-02f, 1.75762214e-02f,
  2.31039003e-02f, 1.33800332e-03f, -7.43216090e-03f, -2.06951369e-02f, -1.44345034e-02f, 9.55792889e-03f, 5.70206307e-02f, 2.32312102e-02f, 1.33290924e-02f, 7.71720782e-02f,
  8.55400637e-02f, 4.62852009e-02f, 1.19429547e-02f, -1.94571037e-02f, -2.09045457e-03f, 2.03120057e-02f, 4.83732559e-02f, 7.71530531e-03f, 8.23187009e-02f, -8.57746229e-03f,
  8.53997171e-02f, -3.34238589e-01f, -2.87836678e-02f, -1.10674486e-01f, 1.45907074e-01f, 2.35459939e-01f, 8.80174190e-02f, -1.85071468e-01f, -4.37551349e-01f, -3.51370007e-01f,
  -6.40709102e-02f, -3.86057310e-02f, -1.30731702e-01f, 1.50089294e-01f, 4.37637031e-01f, -3.15809697e-02f, 7.11170956e-02f, 1.18968755e-01f, 5.82034253e-02f, 1.94895640e-02f,
  6.52568340e-02f, 1.82813883e-01f, 1.58096135e-01f, 1.79139063e-01f, 1.50050431e-01f, 1.13145122e-03f, 3.55172940e-02f, 1.34247720e-01f, 1.34280190e-01f, 1.83189303e-01f,
  1.07629873e-01f, -1.63235515e-01f, 4.52278778e-02f, 4.19775285e-02f, -9.61383339e-03f, -1.97860645e-03f, 9.45530757e-02f, 1.11813806e-01f, -2.30308101e-02f, -5.13511114e-02f,
  -3.42188217e-02f, 6.44548759e-02f, 6.52935309e-03f, 6.05321303e-02f, -4.17702794e-02f, -5.90228252e-02f, -8.44944939e-02f, -1.08387321e-01f, -4.42562699e-02f, -6.66849241e-02f,
  -9.82942060e-02f, -7.70578161e-02f, -8.30012262e-02f, 6.03981502e-02f, -4.47673760e-02f, -1.16834506e-01f, -7.72803947e-02f, -3.75266038e-02f, -2.86337808e-02f, -1.00967713e-01f,
  3.01963203e-02f, 8.89724493e-02f, -6.61106929e-02f, 5.87240718e-02f, -7.70858750e-02f, 1.61318611e-02f, 3.84683684e-02f, -6.20519519e-02f, 8.73149000e-03f, -2.42566247e-03f,
  -9.76945758e-02f, -5.28492518e-02f, -3.16597112e-02f, -3.04945894e-02f, -3.88917848e-02f, -4.94683199e-02f, 1.03808120e-01f, 4.25499603e-02f, -2.20859535e-02f, 8.27120095e-02f,
  1.39309270e-02f, 4.33842577e-02f, -2.32451502e-03f, 3.10885590e-02f, 3.82428318e-02f, -3.92899327e-02f, -1.53618343e-02f, -8.06229115e-02f, -1.39078330e-02f, 7.28311166e-02f,
  4.51559946e-03f, -2.35445693e-01f, -3.32656391e-02f, -1.14709707e-02f, 1.11368768e-01f, 3.20882872e-02f, 1.16619267e-01f, -3.50044779e-02f, -5.66613898e-02f, -1.18769193e-02f,
  2.63459072e-03f, 1.14432769e-03f, -7.12481812e-02f, 5.25370017e-02f, 9.43916962e-02f, -1.13992438e-01f, -3.79287265e-02f, -7.03931674e-02f, -3.18018161e-02f, -5.11959828e-02f,
  -4.58781272e-02f, -6.89642504e-02f, 5.09903952e-02f, -6.89210277e-03f, -2.35860702e-03f, -6.29480779e-02f, 2.87582111e-02f, -6.05967939e-02f, 2.34991387e-02f, -3.91900204e-02f,
  -3.66769165e-01f, 5.32892048e-01f, 3.21172535e-01f, -2.83742428e-01f, 8.04307759e-02f, 2.79350597e-02f, -2.53197074e-01f, 1.35738000e-01f, -3.08933724e-02f, 6.41740784e-02f,
  -2.74592638e-01f, 1.81172997e-01f, 3.21289599e-02f, -2.84416564e-02f, -3.05124521e-01f, -4.92887944e-02f, -2.77169347e-01f, -5.68287000e-02f, 4.64909375e-02f, -1.53832182e-01f,
  -9.95348915e-02f, -2.58726776e-01f, 8.69442150e-02f, 1.13402925e-01f, 8.80060717e-02f, 8.63072276e-02f, -2.52582580e-01f, 1.32081866e-01f, -4.77429889e-02f, 3.57342437e-02f,
  5.42763323e-02f, 4.91740555e-02f, 1.57587022e-01f, 1.40351608e-01f, -5.70934340e-02f, -7.01967254e-02f, 1.46388786e-03f, -8.38044751e-03f, -5.11025637e-02f, 7.08452016e-02f,
  4.19203267e-02f, 1.35471761e-01f, -1.77640636e-02f, 3.34997550e-02f, 3.93568538e-02f, 1.83692381e-01f, 1.56940535e-01f, 3.64222527e-02f, 1.27453700e-01f, 1.24456935e-01f,
  8.89142975e-02f, 1.07171610e-01f, -7.77316513e-03f, -2.88229771e-02f, 2.68248119e-03f, -4.53588320e-03f, -3.19543630e-02f, 5.81414923e-02f, 6.78818449e-02f, 4.87988070e-02f,
  1.59035868e-03f, -1.28763244e-01f, 3.12059280e-02f, 7.38092586e-02f, -9.46102664e-02f, 5.36371432e-02f, -3.95608768e-02f, 2.70167366e-02f, -2.02285349e-02f, 8.65555648e-03f,
  -4.19773161e-02f, 9.39664319e-02f, 2.17536301e-03f, -6.36835843e-02f, -7.30785057e-02f, 9.06300079e-03f, 1.32778827e-02f, 3.64147723e-02f, -4.38484326e-02f, 2.60584503e-02f,
  -3.25704627e-02f, -5.82008772e-02f, -1.63726956e-02f, 5.10540791e-02f, -1.52832828e-04f, 2.18588002e-02f, 3.95189971e-02f, 1.31275132e-01f, 3.20886681e-03f, -1.12359427e-01f,
  -2.48063251e-01f, -3.07216972e-01f, 3.03130411e-02f, 1.14396669e-01f, 4.27876674e-02f, 3.03229243e-02f, 2.60554347e-02f, 8.43492076e-02f, -1.40759116e-02f, -7.08890855e-02f,
  -2.65725721e-02f, -3.44362967e-02f, -9.33733657e-02f, -4.63005379e-02f, -4.55019847e-02f, -5.74330129e-02f, -1.76630124e-01f, -1.58942223e-01f, -6.87749907e-02f, 3.41327488e-03f,
  3.15563492e-02f, -1.12124095e-02f, -7.13820085e-02f, 1.65250227e-02f, -5.54051474e-02f, -8.92449319e-02f, -7.68615380e-02f, 6.75834119e-02f, -4.24472839e-02f, 1.48481475e-02f,
  5.21104150e-02f, 4.73871604e-02f, -2.23320752e-01f, -2.00891092e-01f, 4.84089106e-02f, 3.59812707e-01f, 7.29077384e-02f, -4.74078208e-02f, -2.89892346e-01f, 1.13851018e-01f,
  2.13619024e-01f, -1.05929069e-01f, 4.64542918e-02f, 2.91307151e-01f, 1.37871653e-01f, 2.18649745e-01f, 2.35304251e-01f, 1.57044798e-01f, 7.44115561e-02f, 1.04925688e-02f,
  -6.18121773e-03f, 3.27139735e-01f, 1.07098199e-01f, 1.01194367e-01f, 8.98515657e-02f, -1.79152668e-01f, -4.49448936e-02f, -9.98736024e-02f, 1.25791624e-01f, 9.01969746e-02f,
  1.64703444e-01f, -4.64773439e-02f, 7.46870041e-02f, 4.54468839e-02f, 2.11127438e-02f, 4.92100716e-02f, 1.01926355e-02f, -1.60606746e-02f, -3.50467041e-02f, -2.53613759e-02f,
  -5.91510981e-02f, -2.31041722e-02f, 6.40255138e-02f, -1.09226990e-03f, -2.49497034e-02f, -2.77519189e-02f, 2.05284287e-03f, 1.08544864e-02f, -6.22639284e-02f, 3.01231313e-02f,
  -5.08749746e-02f, 8.93230177e-03f, -2.58468818e-02f, -8.83543398e-03f, -6.16480634e-02f, -3.03824544e-02f, -1.93476435e-02f, -1.06214225e-01f, 7.99542293e-02f, -5.06153405e-02f,
  1.61619596e-02f, -2.59311218e-02f, 7.54106343e-02f, 6.95165545e-02f, 4.46770154e-02f, 2.09137686e-02f, -7.35778641e-03f, 5.38174994e-02f, -5.26936874e-02f, 3.61391455e-02f,
  -1.30753964e-02f, -4.50901240e-02f, 1.35443378e-02f, 8.91732983e-03f, 1.23614111e-04f, -1.79245658e-02f, 1.64299123e-02f, -1.53189851e-02f, -8.09089169e-02f, 5.02943285e-02f,
  -2.16044504e-02f, -1.82360951e-02f, 9.35477987e-02f, -3.27669014e-03f, 7.11784735e-02f, 3.80876940e-04f, 2.33087428e-02f, 1.34243872e-02f, 1.21556846e-02f, -2.10749172e-02f,
  5.00439964e-02f, -1.20173767e-01f, 1.61023904e-02f, 3.74504887e-02f, 5.07021975e-03f, 1.21630423e-01f, 6.66641518e-02f, 5.04441038e-02f, 4.77773435e-02f, 6.30553737e-02f,
  -5.87894432e-02f, -5.67183197e-02f, 2.95924582e-03f, 2.36161915e-03f, -6.20160848e-02f, 5.67008145e-02f, -5.45387939e-02f, -5.94864786e-02f, -8.72499496e-02f, -3.62473466e-02f,
  -6.07095659e-02f, 3.86828519e-02f, -8.30493122e-02f, 5.17047085e-02f, -1.23653747e-02f, -6.75895438e-02f, 3.03150993e-02f, -5.88701926e-02f, 4.10377868e-02f, -3.60371061e-02f,
  4.11522150e-01f, -2.68679142e-01f, -5.62776923e-02f, 1.10872723e-01f, 8.72392207e-02f, 5.53789847e-02f, 3.44560415e-01f, -1.61949888e-01f, 3.00080895e-01f, -2.82726169e-01f,
  -1.85169473e-01f, 1.15814902e-01f, 1.45901248e-01f, -2.70490915e-01f, 4.10740256e-01f, 2.31796712e-01f, 2.41007470e-02f, 6.76702484e-02f, 2.13786326e-02f, -3.72211859e-02f,
  -8.49912316e-03f, -1.27417520e-01f, -9.23650861e-02f, -3.23027045e-01f, -1.23733401e-01f, -1.89434186e-01f, -1.04213782e-01f, 4.60724309e-02f, -3.58754903e-01f, 4.17755954e-02f,
  -8.41121823e-02f, -3.16117294e-02f, -8.19623470e-02f, -7.49452114e-02f, 6.91401539e-03f, 2.87371278e-02f, 8.37181285e-02f, 1.36702463e-01f, 8.84744301e-02f, -2.41374802e-02f,
  8.66017267e-02f, 4.93735746e-02f, -1.91824716e-02f, 2.73220744e-02f, 4.01301794e-02f, -8.03252459e-02f, -8.44484661e-03f, -8.63867104e-02f, -9.78637934e-02f, 1.31317284e-02f,
  9.41617507e-03f, -3.11988872e-02f, -1.29917208e-02f, 4.56748120e-02f, -8.40550195e-03f, -1.84364561e-02f, 1.71465203e-02f, 9.06331837e-02f, 4.50131893e-02f, 9.72694159e-02f,
  -3.87069583e-02f, 1.05409279e-01f, 3.37193236e-02f, -9.72345006e-03f, 7.25824162e-02f, -1.03305675e-01f, 1.34262443e-02f, -2.23315973e-02f, 3.39537188e-02f, 3.36658247e-02f,
  5.74597642e-02f, -1.82590373e-02f, 4.09401990e-02f, 6.01559915e-02f, -3.24335843e-02f, -4.17043967e-03f, 4.77288328e-02f, 2.22042017e-02f, 5.91699630e-02f, -6.67378725e-03f,
  -3.21411379e-02f, 2.74618492e-02f, 1.45657519e-02f, 2.42803004e-02f, -5.05301541e-05f, 3.75615470e-02f, -1.07293993e-01f, -2.38963962e-02f, -4.55277450e-02f, 2.31718528e-03f,
  1.10997446e-01f, 3.09753660e-02f, -1.20702840e-01f, -7.24503770e-02f, 7.46296393e-03f, -5.05182855e-02f, 3.28169055e-02f, -4.03949842e-02f, 5.42793013e-02f, -7.72215147e-03f,
  -9.43814591e-02f, 3.35511118e-02f, 2.00049821e-02f, 3.07431165e-02f, -8.37590266e-03f, -5.78602217e-02f, 6.04282171e-02f, 7.27344118e-03f, 2.75432952e-02f, -5.65380231e-02f,
  -3.92777808e-02f, 8.94187912e-02f, 4.02585715e-02f, 2.17027608e-02f, -8.64065588e-02f, 4.95981090e-02f, 4.26984504e-02f, -1.71779171e-02f, 1.08448960e-01f, 3.60675231e-02f,
  -2.82941818e-01f, -2.62323916e-01f, 3.74953412e-02f, 3.51296246e-01f, -1.13670304e-01f, -3.97800356e-01f, -3.93635303e-01f, -2.03524739e-01f, -2.02836897e-02f, -2.97290057e-01f,
  -2.39137083e-01f, 7.26422518e-02f, -4.08121794e-01f, 2.15753838e-01f, 3.73510510e-01f, -9.85907973e-04f, 1.75801769e-01f, 2.92949602e-02f, 2.24768534e-01f, -2.48667672e-02f,
  3.21784377e-01f, 2.24421889e-01f, 2.66112715e-01f, 2.37330079e-01f, -5.25271893e-02f, 2.21538231e-01f, 4.18004841e-01f, 1.72348827e-01f, 3.31538379e-01f, 7.98512101e-02f,
  -1.91364139e-01f, -2.08111312e-02f, -3.08391526e-02f, -1.86925512e-02f, -4.32570614e-02f, -9.55605209e-02f, 3.69369239e-02f, -3.95532474e-02f, 8.81783143e-02f, 2.35569291e-02f,
  -7.50948042e-02f, 7.09914416e-02f, 1.05170570e-01f, 4.27654386e-02f, -5.42799830e-02f, 8.54918957e-02f, 3.53071317e-02f, -1.43109441e-01f, -9.40917581e-02f, -4.89260890e-02f,
  -6.38918951e-02f, -3.33849341e-02f, -2.89716888e-02f, 5.26422821e-02f, 7.37138838e-02f, -4.12526578e-02f, 1.29870459e-01f, -6.10586349e-03f, 5.57073625e-03f, 1.34094968e-01f,
  -5.92002720e-02f, 8.08094144e-02f, -4.82802987e-02f, 2.21607983e-02f, -6.22305647e-03f, 6.38295934e-02f, 7.04718307e-02f, 6.43941835e-02f, 5.91441393e-02f, -7.57706314e-02f,
  7.14347586e-02f, -1.14303194e-02f, 1.98547635e-02f, -2.07371749e-02f, 1.29298735e-02f, -6.00624792e-02f, -1.08112749e-02f, -1.53596466e-03f, 2.28136126e-02f, -4.90164617e-03f,
  4.17766241e-05f, -5.16950525e-02f, -2.48314030e-02f, -1.93276480e-02f, -9.13630947e-02f, 1.72987692e-02f, -9.73210949e-03f, -3.22319232e-02f, 1.74394790e-02f, -2.20071170e-02f,
  -1.22881740e-01f, 2.31253251e-01f, -2.48700827e-02f, -1.17132448e-01f, 1.41875371e-01f, -5.45998141e-02f, 1.08825237e-01f, 9.16483998e-03f, 1.30365677e-02f, -4.27042060e-02f,
  -4.49311994e-02f, -3.99374217e-03f, -2.79732887e-02f, -1.78486984e-02f, 4.52718362e-02f, -4.05337662e-02f, 1.38538005e-02f, 7.31466860e-02f, 4.24622782e-02f, 6.98942244e-02f,
  -1.93065461e-02f, -8.17187354e-02f, 8.82757828e-02f, 5.25581986e-02f, -2.86352951e-02f, -1.81042459e-02f, -9.86101571e-04f, -1.53524231e-03f, 7.95418099e-02f, 9.37428176e-02f,
  3.95063132e-01f, 1.74904644e-01f, 9.70088691e-03f, 2.87446290e-01f, 3.22345465e-01f, 3.04821640e-01f, 2.25706339e-01f, 2.98167497e-01f, 5.71774185e-01f, -7.69893080e-02f,
  1.57248359e-02f, 9.12231654e-02f, -1.93016589e-01f, 1.52133450e-01f, 1.54091001e-01f, 6.98751584e-03f, 2.89706528e-01f, 1.89724922e-01f, 2.77125388e-01f, 2.33312920e-01f,
  2.12435260e-01f, 1.56646922e-01f, -2.26147860e-01f, -9.92271230e-02f, 5.07862866e-02f, -1.42439768e-01f, -2.54213601e-01f, -1.67835414e-01f, -1.60918877e-01f, 3.62222828e-02f,
  -2.00079381e-02f, 1.39555410e-01f, -1.06499307e-01f, -1.05525352e-01f, 4.21705507e-02f, -7.47636408e-02f, -4.22916189e-02f, -5.60808145e-02f, -6.81935176e-02f, -8.62243176e-02f,
  -1.68814848e-03f, -6.63084388e-02f, 2.09346898e-02f, -3.96619737e-02f, 4.93787564e-02f, -1.15419356e-02f, 1.77721065e-02f, 1.62450913e-02f, -1.78565588e-02f, -1.13345673e-02f,
  -1.10553037e-02f, -5.45300692e-02f, 1.38526382e-02f, 3.59152816e-02f, -2.02572253e-02f, 5.71551323e-02f, 6.86071217e-02f, 2.64408235e-02f, -6.40507638e-02f, 1.07471034e-01f,
  1.28105953e-02f, 7.43198693e-02f, -6.28744140e-02f, -3.96603122e-02f, 8.24275166e-02f, 1.60808079e-02f, 4.42222245e-02f, 1.83746554e-02f, 7.83804432e-02f, 4.27110456e-02f,
  -5.46111129e-02f, 4.64107059e-02f, 1.01596236e-01f, 3.65920179e-02f, 1.43048450e-01f, 6.30718246e-02f, -7.51818717e-03f, 3.28249857e-02f, 9.70811844e-02f, 5.70714213e-02f,
  2.07477696e-02f, 6.42014593e-02f, -1.06173895e-01f, -9.85449329e-02f, -3.80565822e-02f, -2.63799578e-02f, 7.26775303e-02f, 2.76454315e-02f, -2.17046719e-02f, 4.86524701e-02f,
  2.17792675e-01f, 3.57266694e-01f, -2.82003339e-02f, -5.33488840e-02f, -1.08348038e-02f, 2.06901785e-02f, 7.25531429e-02f, 6.38934597e-02f, 1.03149116e-01f, 4.23161387e-02f,
  7.59623870e-02f, -9.32255108e-03f, -9.61778592e-03f, -4.43919040e-02f, -7.98264071e-02f, 3.49494927e-02f, -6.67746216e-02f, 5.27790412e-02f, 2.93284860e-02f, -5.53759141e-03f,
  -8.06473196e-02f, 8.43572542e-02f, -4.08307612e-02f, 4.85369079e-02f, 2.10798830e-02f, -3.40032727e-02f, 1.48479491e-01f, -3.77359092e-02f, 8.77024885e-03f, 2.44830269e-02f,
  9.63560566e-02f, 1.43560722e-01f, -3.29451054e-01f, 4.16152813e-02f, -3.96077521e-02f, 1.86196640e-01f, 1.90285891e-01f, -2.32137442e-02f, 2.02673879e-02f, 3.69423747e-01f,
  2.83010095e-01f, -7.89382681e-02f, 1.31922945e-01f, 3.62651646e-01f, -1.65078305e-02f, 1.58537745e-01f, 3.35654199e-01f, 1.53529525e-01f, -8.85533020e-02f, 2.23316744e-01f,
  1.57246944e-02f, 2.90184438e-01f, -5.82743548e-02f, -2.82722786e-02f, 4.75029871e-02f, -2.54372239e-01f, 1.01660214e-01f, -2.62339771e-01f, -2.94824736e-03f, -1.16738733e-02f,
  -1.23433331e-02f, 1.09166496e-01f, -5.67488819e-02f, -1.04777321e-01f, 8.16760659e-02f, 1.72849223e-02f, 1.04465652e-02f, -9.49168354e-02f, -1.22147880e-01f, -5.04853912e-02f,
  7.12464452e-02f, -5.78214936e-02f, 1.60227213e-02f, -9.87725705e-02f, -2.20544916e-03f, -2.78685298e-02f, -8.03171098e-02f, 1.58003885e-02f, -4.94677238e-02f, 3.17966044e-02f,
  2.85434034e-02f, 2.29787696e-02f, 1.36284083e-01f, 2.66268551e-02f, -4.71818447e-02f, -4.04299563e-03f, -2.46374141e-02f, 3.75907548e-04f, -2.15416518e-03f, -2.65780240e-02f,
  -3.49278301e-02f, 8.28034878e-02f, 1.15740985e-01f, -2.18995344e-02f, -3.34806070e-02f, 9.39827133e-03f, -5.06731961e-03f, 1.68793760e-02f, -6.01918697e-02f, 8.85817036e-02f,
  -3.20452712e-02f, -8.26194435e-02f, 7.30752721e-02f, 1.83317307e-02f, 1.02407500e-01f, 2.38463730e-02f, -4.73823920e-02f, -4.56913747e-02f, 6.71734959e-02f, 2.20949971e-03f,
  -4.19880487e-02f, 1.20891305e-02f, -5.97813353e-02f, -6.29454702e-02f, -1.57931410e-02f, -4.50789444e-02f, 7.28420615e-02f, 5.84717654e-03f, 1.35620730e-02f, -1.12765897e-02f,
  1.25515237e-01f, 1.27547413e-01f, 1.72892772e-02f, -1.33583555e-02f, -1.76695399e-02f, 1.17368758e-01f, 6.92003593e-02f, -1.12624252e-02f, -4.01328206e-02f, 2.31352691e-02f,
  8.47694054e-02f, 2.84363497e-02f, 6.04599081e-02f, -4.95890006e-02f, -3.66758481e-02f, 1.62155300e-01f, 9.89350155e-02f, -3.13319899e-02f, 4.89087254e-02f, -4.44647856e-02f,
  8.74970704e-02f, 5.60830347e-03f, 9.77726653e-02f, -2.63051279e-02f, 7.51752406e-02f, 5.05831689e-02f, -5.10496646e-02f, -6.29354641e-02f, 2.05163844e-02f, 2.32771616e-02f,
  5.78522533e-02f, -8.38486031e-02f, 2.41605178e-01f, -2.22017616e-01f, 1.76666364e-01f, 2.56440431e-01f, 2.04096735e-01f, 1.28987074e-01f, 1.27156869e-01f, -2.31024593e-01f,
  -1.57086655e-01f, -1.62777275e-01f, 1.15918532e-01f, -2.21963078e-01f, 2.90765703e-01f, 1.29767522e-01f, -4.17199209e-02f, -2.10657462e-01f, 1.35648981e-01f, -8.09172317e-02f,
  6.68877224e-03f, -2.01828361e-01f, 2.11559832e-02f, -8.55147615e-02f, -6.13392331e-02f, -1.01751111e-01f, -2.06345573e-01f, 1.16829067e-01f, -2.35945553e-01f, 6.30645156e-02f,
  7.34631494e-02f, -5.40137887e-02f, 7.88773075e-02f, 2.16715336e-02f, 5.60906641e-02f, -3.70736644e-02f, -4.60809618e-02f, 8.53032321e-02f, 1.60172824e-02f, -4.80673574e-02f,
  -1.27319530e-01f, -2.24311836e-02f, -1.27188852e-02f, 1.39993457e-02f, 2.31749611e-03f, -2.77020745e-02f, -2.93652173e-02f, 4.20994014e-02f, 1.69706773e-02f, 5.38928360e-02f,
  8.98575783e-02f, 4.56585847e-02f, -2.04952676e-02f, -1.60276875e-01f, -2.27187318e-03f, -5.41796209e-03f, 2.66518369e-02f, 1.78023651e-02f, 3.00262752e-03f, -3.33787464e-02f,
  -8.89281929e-02f, -2.55047847e-02f, 5.57084242e-03f, 2.47825999e-02f, 9.58498940e-02f, 1.84225347e-02f, -1.51942894e-02f, -1.27383312e-02f, 2.99714673e-02f, 1.52620347e-02f,
  -1.82151813e-02f, -5.92851937e-02f, 5.21610975e-02f, 5.65406540e-03f, -9.12904367e-02f, -3.92665230e-02f, -9.28980857e-03f, -2.75915898e-02f, 3.28170210e-02f, 5.71146682e-02f,
  -4.66793701e-02f, -6.85155811e-03f, -2.71086451e-02f, -1.23776890e-01f, 1.80504657e-02f, 5.11420928e-02f, -7.09699467e-02f, 1.72327999e-02f, -3.60106193e-02f, 3.80678624e-02f,
  2.55553629e-02f, -1.88753054e-01f, 7.44121969e-02f, -6.79400936e-02f, 1.76970605e-02f, -2.85510905e-02f, -4.48788255e-02f, 3.89036313e-02f, -2.84746406e-03f, -2.29123142e-02f,
  -6.36296645e-02f, -9.72731635e-02f, 3.61571577e-03f, -3.90095217e-03f, -9.15862992e-03f, 5.08600771e-02f, -8.97998363e-02f, -5.48687903e-03f, -1.52757987e-02f, 3.86755826e-04f,
  -1.13295270e-02f, -1.05143800e-01f, -5.75619489e-02f, -6.12425022e-02f, -6.13866784e-02f, -3.97422127e-02f, -2.48691672e-03f, 4.61319946e-02f, -5.29180430e-02f, -3.86713631e-02f,
  1.95974350e-01f, 6.66216016e-02f, -3.48251641e-01f, -1.91902891e-01f, -1.82951957e-01f, -2.40530178e-01f, -2.51991749e-01f, -4.13482413e-02f, 9.88679081e-02f, 1.71997815e-01f,
  -1.33439779e-01f, 3.28486919e-01f, 2.28670076e-01f, -2.17973113e-01f, -4.50917333e-02f, 1.39731139e-01f, -2.94221073e-01f, -5.81110977e-02f, 5.22443280e-03f, -1.58409588e-02f,
  -2.52150837e-02f, -1.47217624e-02f, -2.23589227e-01f, 4.97965887e-02f, -3.06023598e-01f, -9.52472612e-02f, -1.92496955e-01f, -1.19322419e-01f, -3.20988774e-01f, -4.42792326e-02f,
  -1.25538021e-01f, 1.47564560e-01f, -4.45036739e-02f, 1.05286367e-01f, -6.23735562e-02f, -9.74836573e-02f, -1.70773238e-01f, 3.12302839e-02f, 1.20660122e-02f, 3.39303166e-02f,
  1.20346963e-01f, 1.39717877e-01f, 3.51007767e-02f, 3.66274714e-02f, -2.39172019e-02f, -1.50390472e-02f, -1.57122649e-02f, -2.02206969e-01f, 5.76998442e-02f, 1.88149754e-02f,
  -3.49611156e-02f, -2.93172207e-02f, -8.72901231e-02f, 4.11586277e-02f, -2.23061442e-02f, -8.01612041e-04f, -3.91245857e-02f, -1.37200877e-01f, 2.82201339e-02f, -3.45595814e-02f,
  1.59453824e-02f, -5.10223955e-02f, -7.74271088e-03f, -1.96263772e-02f, -7.53624504e-03f, -6.70515299e-02f, 7.54115433e-02f, -4.18277197e-02f, 1.42520461e-02f, -1.90571696e-02f,
  -3.89185101e-02f, -2.59560626e-02f, -4.72808145e-02f, -3.97639759e-02f, -4.15033586e-02f, 6.96912557e-02f, 3.99629958e-02f, 4.07977775e-02f, -4.27894704e-02f, -4.64000441e-02f,
  4.71797995e-02f, -1.50469886e-02f, 9.82411280e-02f, -8.92646015e-02f, -1.19331948e-01f, 4.19702381e-02f, -2.19836012e-02f, 6.16066009e-02f, -3.23486701e-02f, -1.91491581e-02f,
  -1.00607395e-01f, 7.01736957e-02f, 4.66225035e-02f, 1.95666656e-01f, 3.22551355e-02f, 1.74332932e-02f, -2.91331019e-03f, -2.28560399e-02f, -1.67948790e-02f, 6.58208206e-02f,
  3.91771272e-02f, 6.78651705e-02f, -1.68367252e-01f, -8.59578922e-02f, 6.04334697e-02f, -7.26827458e-02f, 1.23085864e-02f, -5.04436344e-02f, -2.89855655e-02f, -2.06728075e-02f,
  1.79608222e-02f, 1.14657342e-01f, 1.84195340e-01f, -1.42390272e-02f, 9.93523896e-02f, -1.11024752e-02f, 3.56329009e-02f, -1.49309561e-02f, 3.59092802e-02f, -9.04566199e-02f,
  2.18497291e-01f, 3.03867161e-01f, 8.00924674e-02f, -5.63447848e-02f, -7.53040910e-02f, -2.76155591e-01f, -1.43640339e-01f, 2.48522125e-02f, -5.44320270e-02f, 1.55401751e-01f,
  -1.66397974e-01f, 3.62136900e-01f, -5.52868806e-02f, -4.41574156e-02f, -4.46715206e-01f, -2.48782203e-01f, -1.28414601e-01f, 4.20767851e-02f, 1.37549983e-02f, 4.93871197e-02f,
  -9.40637216e-02f, -2.18531504e-01f, -1.40597761e-01f, -4.25027311e-02f, 8.50002021e-02f, 2.22761512e-01f, -8.05964619e-02f, 5.54957576e-02f, 8.04214701e-02f, -6.12156093e-02f,
  -7.30157224e-03f, 1.12981074e-01f, 9.21513289e-02f, 7.27272872e-03f, -8.26759264e-02f, 2.27607731e-02f, 3.75744104e-02f, -4.10869308e-02f, -8.09719786e-02f, 2.61179321e-02f,
  7.47139677e-02f, -4.08472270e-02f, 4.47051339e-02f, -5.21743000e-02f, 6.42501786e-02f, 6.42746687e-02f, 4.69733179e-02f, 4.38264795e-02f, 5.01647331e-02f, 5.49045540e-02f,
  3.76319587e-02f, 6.99111372e-02f, -2.61822809e-02f, -3.30801151e-04f, 5.36907057e-04f, 1.64526235e-02f, -2.15429571e-02f, 1.99201796e-02f, 6.66186661e-02f, 1.58884749e-02f,
  9.33294222e-02f, -2.34855581e-02f, -3.92861404e-02f, 1.34132272e-02f, -4.66015339e-02f, -1.75807823e-03f, 8.32867157e-03f, 2.05006413e-02f, -7.46534672e-03f, -2.24655662e-02f,
  -2.22224314e-02f, 6.12691417e-02f, -1.94521863e-02f, -4.24583293e-02f, 2.03513633e-03f, 2.22268719e-02f, 3.86952190e-03f, 4.85928804e-02f, -1.95133798e-02f, -1.44418655e-02f,
  1.00416262e-02f, -6.41726106e-02f, 1.66795459e-02f, 3.64562012e-02f, -7.92429820e-02f, -2.70551424e-02f, 3.64398509e-02f, 1.98376179e-02f, -1.85005125e-02f, -7.36796409e-02f,
  -4.68897521e-02f, -2.86581870e-02f, -3.46545838e-02f, 9.19210445e-03f, -1.00926841e-02f, -2.86926441e-02f, -3.37416977e-02f, 4.61172499e-02f, -2.50783321e-02f, -5.61680160e-02f,
  4.07046489e-02f, 7.49405287e-03f, 3.94077087e-03f, -1.39851002e-02f, -1.93402544e-02f, -8.51578787e-02f, -1.36667285e-02f, 1.02967711e-03f, -5.58089949e-02f, 6.21312335e-02f,
  6.88450336e-02f, 6.53557330e-02f, -1.14969416e-02f, -4.79016341e-02f, 5.29275425e-02f, 2.05349997e-02f, 5.86745106e-02f, 2.11311802e-02f, 6.06165733e-03f, 1.82732809e-02f,
  -1.89903557e-01f, -1.37291625e-02f, -2.21672028e-01f, -1.37852937e-01f, 2.84594437e-03f, -2.46498629e-01f, -1.80911645e-01f, 4.75660227e-02f, 1.47176862e-01f, 5.47843203e-02f,
  7.41857886e-02f, -1.89534694e-01f, 1.92619041e-01f, -1.54646635e-01f, -1.83634236e-01f, 1.14398599e-01f, -3.35530996e-01f, -1.39070898e-01f, 1.69689864e-01f, -1.89221770e-01f,
  -9.49572921e-02f, -6.34568855e-02f, -1.64884865e-01f, 7.32073337e-02f, -1.12479888e-01f, -2.08164714e-02f, -3.27122543e-04f, 2.56451797e-02f, -2.56756485e-01f, 2.83672679e-02f,
  -2.61091422e-02f, 2.14074209e-01f, 5.23024751e-03f, 8.43674913e-02f, -7.17494041e-02f, -7.80141056e-02f, -1.48312986e-01f, 3.33771631e-02f, 1.22627178e-02f, 4.83001918e-02f,
  -3.97315100e-02f, 4.06933203e-02f, 4.31345366e-02f, 1.58655509e-01f, 3.54677550e-02f, 1.65365487e-02f, 2.11637318e-02f, -6.55881166e-02f, 2.93430146e-02f, -8.25551599e-02f,
  -6.75942153e-02f, 8.24631006e-03f, -1.26882076e-01f, 3.55209969e-02f, -3.50433961e-02f, 3.43990512e-03f, -7.16365501e-02f, -7.90985823e-02f, -2.29285341e-02f, -2.51753014e-02f,
  -6.50155395e-02f, -1.10328468e-02f, 9.54356696e-03f, 5.29955216e-02f, 9.41300169e-02f, 6.56836480e-02f, 9.18313675e-03f, -3.01368590e-02f, 2.54044477e-02f, -6.66918010e-02f,
  -1.02310758e-02f, 6.60843914e-03f, 8.13417286e-02f, -1.30928066e-02f, -6.83652535e-02f, -1.95613522e-02f, -8.81409273e-02f, 4.37557139e-02f, 7.78105715e-03f, -3.42508890e-02f,
  6.51530772e-02f, -2.49363240e-02f, 6.90515637e-02f, 5.24740145e-02f, -1.51401982e-02f, 5.78457937e-02f, -1.79737490e-02f, -3.25206146e-02f, 4.41916706e-03f, -3.68322767e-02f,
  -6.87793344e-02f, -5.96401021e-02f, 5.31849749e-02f, 1.01493336e-01f, -8.10936466e-02f, 1.78786777e-02f, -6.02358840e-02f, 1.44177850e-03f, -4.10643332e-02f, 7.02620819e-02f,
  -1.21835724e-01f, -8.43520742e-03f, -6.00182265e-02f, 6.12149686e-02f, -2.25912631e-02f, -2.00882666e-02f, -4.86616269e-02f, -1.78247020e-02f, -8.49689320e-02f, -3.05375811e-02f,
  -3.62460874e-02f, -2.29960810e-02f, -6.96097240e-02f, 4.61140797e-02f, -1.83715187e-02f, -4.82466109e-02f, -9.14693698e-02f, 2.54454408e-02f, -3.39401141e-02f, 1.23294489e-02f,
  -6.53908551e-02f, 1.33485913e-01f, 1.64197788e-01f, 1.97690547e-01f, -5.47204614e-01f, 3.52630839e-02f, 2.37910673e-01f, -2.29193434e-01f, 1.43514514e-01f, 2.82144219e-01f,
  -5.58793284e-02f, 1.64000407e-01f, 1.17120191e-01f, 1.33940145e-01f, -1.35758027e-01f, 3.16290706e-01f, 2.46518523e-01f, 2.57841349e-01f, -4.19483259e-02f, -7.14755580e-02f,
  -6.15896359e-02f, -2.22582817e-01f, 4.22944091e-02f, -2.51546443e-01f, -1.61271542e-01f, -7.00099617e-02f, -1.83738604e-01f, -2.56223500e-01f, -5.32535762e-02f, -2.28271782e-01f,
  -1.46653518e-01f, -5.35644963e-02f, 1.06872298e-01f, 1.20279146e-02f, -6.30873675e-03f, 7.57923257e-03f, 3.84696908e-02f, -4.04612720e-02f, -5.74181825e-02f, -1.07111093e-02f,
  4.02898677e-02f, -1.18551366e-01f, -1.08498916e-01f, -3.90801206e-02f, -4.64976951e-02f, -3.40549350e-02f, -4.26314361e-02f, 3.46605703e-02f, -3.60422172e-02f, -2.14421228e-02f,
  1.47446290e-01f, 6.65032789e-02f, 1.94800254e-02f, 1.12559922e-01f, -4.92952205e-02f, -2.81693712e-02f, 1.19767167e-01f, 3.51415686e-02f, 1.34601705e-02f, -1.34127080e-01f,
  7.11433366e-02f, 2.12334860e-02f, 9.69138753e-04f, -5.58503605e-02f, -3.50477453e-03f, -1.14924144e-02f, 3.69147845e-02f, -1.02353558e-01f, 1.58986468e-02f, -6.56105801e-02f,
  -6.01453371e-02f, -4.61982191e-02f, -3.94310765e-02f, 8.80125761e-02f, 4.66469042e-02f, 8.95641968e-02f, 9.71199796e-02f, -1.74401682e-02f, 7.48081058e-02f, -1.90812163e-02f,
  5.35498513e-03f, -4.15159799e-02f, -8.32257420e-02f, -3.80216017e-02f, -5.87051152e-04f, -6.57291040e-02f, -6.05673809e-03f, 1.40396461e-01f, 2.60981638e-02f, -1.67762727e-01f,
  -2.48175859e-01f, -2.06491932e-01f, 3.81130017e-02f, -3.53911077e-03f, 9.88894552e-02f, -2.39948872e-02f, 5.23264334e-02f, 3.23825963e-02f, -1.00328095e-01f, 2.99902763e-02f,
  2.65115481e-02f, 5.81081361e-02f, -3.23088318e-02f, -9.27549042e-03f, 2.24738698e-02f, -3.59001756e-02f, 3.88512202e-02f, 3.45399454e-02f, -8.14103112e-02f, -1.20581016e-01f,
  1.22076096e-02f, 4.60791178e-02f, 1.11462669e-02f, 5.85461073e-02f, 1.54818118e-01f, -4.74966653e-02f, -5.27493507e-02f, 3.78047340e-02f, -1.30899847e-01f, 5.36596030e-02f,
  3.55245452e-03f, 4.77817915e-02f, -9.50826034e-02f, 8.12707767e-02f, 1.70278296e-01f, -2.43811667e-01f, 9.18118358e-02f, 9.26924348e-02f, 6.67264834e-02f, 1.54172257e-01f,
  -1.38968393e-01f, -1.36102334e-01f, -3.24121192e-02f, -3.58924210e-01f, -5.88477492e-01f, -3.73944104e-01f, -2.34253302e-01f, -1.66169897e-01f, -8.48076940e-02f, 4.61337995e-03f,
  -3.32983695e-02f, -1.34466633e-01f, -9.65617672e-02f, 1.57472402e-01f, 1.87869847e-01f, 3.08556020e-01f, 1.49249524e-01f, 2.01105714e-01f, 5.95906712e-02f, -1.06562436e-01f,
  -2.86857784e-02f, -6.21440494e-03f, 9.81215984e-02f, -5.68413101e-02f, 7.78679401e-02f, 1.61235064e-01f, -3.04348394e-03f, -3.05669717e-02f, -3.31528438e-03f, -1.32622430e-02f,
  7.67996162e-02f, 8.47721007e-03f, -1.53430328e-01f, -4.39760722e-02f, 1.59909368e-01f, 1.77153759e-02f, -5.28951623e-02f, 7.07065910e-02f, 1.79091673e-02f, -9.07203108e-02f,
  2.49055624e-02f, -6.80985898e-02f, 2.08247975e-02f, -5.05561829e-02f, 1.13179367e-02f, -4.67666574e-02f, -4.70949337e-02f, -1.92336142e-02f, 8.21536928e-02f, 1.31826354e-02f,
  9.56679694e-03f, -2.10058619e-03f, 7.38021405e-03f, 3.96873755e-03f, -4.71518785e-02f, 2.45960243e-02f, 5.50804026e-02f, -1.02796666e-02f, 8.75937194e-02f, -1.72065701e-02f,
  1.56076550e-02f, 3.04862913e-02f, -5.82988299e-02f, 4.63595726e-02f, -2.52525341e-02f, 2.19332911e-02f, 6.55739382e-02f, -8.31626430e-02f, 4.62004021e-02f, 1.73643101e-02f,
  5.75580411e-02f, 4.20518219e-02f, 2.66762208e-02f, 3.66669707e-02f, -6.45295382e-02f, 5.99342212e-03f, 1.81516707e-02f, -1.72624420e-02f, 1.95925161e-02f, 1.96768553e-03f,
  1.72814522e-02f, -7.54683316e-02f, 3.77841406e-02f, 1.21802799e-02f, 8.17623828e-03f, -2.24332288e-02f, -1.18986972e-01f, -4.40662056e-02f, -1.59922764e-02f, -1.75271425e-02f,
  4.23955768e-02f, 1.78875208e-01f, 3.21332924e-02f, -5.49638160e-02f, -8.96190573e-03f, -6.56316429e-02f, -2.09906660e-02f, 6.91353753e-02f, 7.80276954e-02f, 1.19920950e-02f,
  1.30307421e-01f, 8.75164662e-03f, 3.12318988e-02f, 1.02259167e-01f, 7.92529881e-02f, 5.27862497e-02f, 5.80180110e-03f, 2.34593172e-02f, 3.53145733e-04f, -2.88315974e-02f,
  -6.84161663e-01f, 2.77505159e-01f, 4.82349917e-02f, -6.90877736e-02f, -9.79569703e-02f, 1.47007361e-01f, -8.36940035e-02f, 5.73290512e-02f, -9.39404368e-02f, 1.12305798e-01f,
  4.47201245e-02f, -2.52596647e-01f, 1.54677868e-01f, 2.01362759e-01f, -1.47585928e-01f, 3.31643999e-01f, 1.23093359e-01f, -8.44214186e-02f, 3.39044891e-02f, -1.67940617e-01f,
  -5.84811457e-02f, -5.36362976e-02f, 1.50450587e-01f, 9.82903540e-02f, -6.32878542e-02f, -1.22654006e-01f, -1.19215041e-01f, -2.81674191e-02f, 8.32794085e-02f, -9.53778476e-02f,
  -1.70930743e-01f, -2.03789070e-01f, -1.85335815e-01f, -1.14687242e-01f, -8.50916281e-02f, -5.26786298e-02f, -7.83065259e-02f, -9.05274674e-02f, -8.30606371e-02f, -2.99377199e-02f,
  -4.89462167e-02f, 3.05575766e-02f, -5.87171242e-02f, -2.09564976e-02f, -6.50413483e-02f, -2.71427240e-02f, 8.71340930e-02f, 1.13565557e-01f, 1.68666113e-02f, 8.27190802e-02f,
  8.08849633e-02f, 1.02166750e-01f, 3.17674205e-02f, 3.58828083e-02f, 5.69517910e-02f, 3.14791165e-02f, 7.55983666e-02f, -3.16394083e-02f, -1.11203073e-02f, -2.12133303e-02f,
  -4.83386591e-03f, -1.28629273e-02f, -6.29004911e-02f, -5.31348214e-02f, -3.42900632e-03f, 6.95399493e-02f, -2.26289891e-02f, -4.13081935e-03f, -9.91174672e-03f, 4.99146357e-02f,
  5.72164916e-02f, -2.36896127e-02f, 1.89746842e-02f, 5.29021136e-02f, 6.54725134e-02f, -1.19715771e-02f, -2.33238786e-02f, -5.26111275e-02f, 1.16313212e-01f, -1.67580489e-02f,
  -1.06632955e-01f, 1.93755273e-02f, 1.61939543e-02f, 3.80915329e-02f, -8.59701559e-02f, -1.35052213e-02f, 3.72035541e-02f, 1.04986027e-01f, -4.02799696e-02f, -1.36432322e-02f,
  -3.49129081e-01f, -2.55213052e-01f, -1.55497402e-01f, -8.32162201e-02f, -6.48176074e-02f, -3.99534553e-02f, -1.05232503e-02f, -3.13002691e-02f, -8.63011256e-02f, -1.20463960e-01f,
  -1.80232674e-02f, 5.88059705e-03f, -3.54704075e-02f, -2.11566836e-02f, -1.72941219e-02f, 1.11242151e-02f, -1.33628368e-01f, -1.01532124e-01f, -2.01143101e-01f, -5.24556302e-02f,
  -5.07818088e-02f, -3.68565805e-02f, 7.93657824e-03f, 4.02270630e-02f, -4.51360038e-03f, -6.41561672e-02f, -1.49425983e-01f, 3.48938257e-02f, 1.99730205e-03f, 9.50851664e-02f,
  1.77899227e-01f, 9.20713767e-02f, 4.12910849e-01f, 2.01513812e-01f, 1.35075331e-01f, 2.50934690e-01f, 1.58245578e-01f, 2.37487122e-01f, 4.79712874e-01f, -1.56783000e-01f,
  -1.79039598e-01f, 3.29101644e-02f, -9.36098769e-02f, -3.48600000e-02f, -2.50678174e-02f, -1.72562562e-02f, 6.44612163e-02f, -3.15626524e-02f, 1.33184463e-01f, 4.97689880e-02f,
  1.11373834e-01f, -2.52867848e-01f, -4.48515937e-02f, -2.12868899e-01f, -1.30986990e-02f, 9.03068390e-03f, -3.54076147e-01f, -2.71554310e-02f, -1.42119184e-01f, -6.57231286e-02f,
  9.50597748e-02f, 4.29174565e-02f, -4.96406592e-02f, 4.08586562e-02f, 1.12663582e-01f, 1.94997080e-02f, -3.73953208e-02f, -6.87494650e-02f, 1.39679201e-02f, -1.95134468e-02f,
  -1.54317273e-02f, 1.81415621e-02f, 4.18969430e-03f, -3.12632993e-02f, 9.96257439e-02f, 4.96452712e-02f, 1.14169143e-01f, 4.78802435e-02f, 2.68058497e-02f, 9.29023474e-02f,
  1.00823969e-01f, 7.84292892e-02f, 7.58800209e-02f, -1.52974986e-02f, 5.21045225e-03f, 1.04711633e-02f, 5.12246862e-02f, 2.79575139e-02f, 6.72231093e-02f, 3.92589867e-02f,
  -7.24062324e-02f, 4.15954478e-02f, -3.66388820e-02f, 1.93751641e-02f, -1.45557923e-02f, -7.90956547e-04f, -4.05874709e-03f, -5.21286912e-02f, 3.77451330e-02f, -3.47231748e-03f,
  6.36590552e-03f, -2.96918917e-02f, 9.14229825e-02f, 1.13667771e-01f, -6.61982372e-02f, 2.49569770e-02f, -7.91592970e-02f, 2.38809288e-02f, 1.53139755e-02f, 1.13313226e-03f,
  -6.90988973e-02f, -2.54877489e-02f, -4.39738631e-02f, 1.32908858e-02f, 1.58102605e-02f, 2.94055827e-02f, -3.29339989e-02f, 9.12371501e-02f, -2.94561405e-03f, -8.51744637e-02f,
  -7.20426142e-02f, -1.32786378e-01f, -4.64076623e-02f, -4.32932116e-02f, -3.35741714e-02f, -4.17949334e-02f, 2.08526608e-02f, 1.42833227e-02f, -2.35071462e-02f, -5.11167571e-02f,
  3.11575290e-02f, 1.31471744e-02f, -4.33250237e-03f, -2.07901951e-02f, -5.54881319e-02f, -2.94644404e-02f, -8.60323943e-03f, -2.35244650e-02f, -6.75074756e-02f, -5.41353375e-02f,
  -8.12557414e-02f, -2.48892400e-02f, 8.28911259e-04f, -5.44929989e-02f, -3.92512307e-02f, -3.84329259e-02f, -1.73343644e-02f, 1.31040094e-02f, -1.91599187e-02f, -2.20116810e-03f,
  3.65961432e-01f, 6.16612993e-02f, 2.17551097e-01f, 4.56375510e-01f, -9.96043831e-02f, -4.43043150e-02f, 3.39544296e-01f, -4.25308570e-02f, 4.47638392e-01f, -9.69689339e-02f,
  -1.54566258e-01f, 1.99049279e-01f, -1.36665344e-01f, 9.38504189e-02f, -2.18076244e-01f, -7.17912689e-02f, 1.33949116e-01f, 1.73334301e-01f, 1.39775783e-01f, 9.42730308e-02f,
  1.08024001e-01f, -2.17451707e-01f, -4.88965474e-02f, -2.90066659e-01f, 3.23505923e-02f, 1.16024762e-01f, -3.15956205e-01f, 1.66328938e-03f, -1.38387874e-01f, -1.70094237e-01f,
  1.48584127e-01f, 1.56809404e-01f, 4.82376181e-02f, 6.09954819e-03f, 5.14232740e-02f, -1.17294993e-02f, 2.39619985e-02f, -1.81521680e-02f, 9.42471027e-02f, 6.54316172e-02f,
  2.75149476e-02f, -4.26884294e-02f, 4.96333018e-02f, -9.68723595e-02f, 6.85579255e-02f, 2.77067740e-02f, 1.00438230e-01f, 2.37133037e-02f, -8.58980138e-03f, -3.20532322e-02f,
  1.71416566e-01f, 5.01607619e-02f, 9.58664268e-02f, -1.83911598e-03f, 2.32087672e-02f, 1.01655655e-01f, 1.40892686e-02f, -3.44276279e-02f, 4.91172774e-03f, 4.97413240e-02f,
  -9.30980071e-02f, 1.91984400e-02f, 1.33009572e-02f, 2.28836946e-02f, -4.80084345e-02f, 1.14543817e-03f, 3.44121121e-02f, -4.14005034e-02f, 3.76050435e-02f, -3.27416300e-03f,
  -1.01535134e-02f, -2.57373713e-02f, -1.76057424e-02f, -1.79649163e-02f, 5.35026267e-02f, 1.20817140e-01f, -1.17993698e-01f, -6.73245192e-02f, 1.48117885e-01f, -3.29666329e-03f,
  -1.80203412e-02f, 2.54155230e-02f, 5.32382913e-02f, -2.88633965e-02f, 3.82175036e-02f, 4.29340489e-02f, -2.55301166e-02f, 5.02587063e-03f, 3.62827703e-02f, -6.42126948e-02f,
  -3.80906574e-02f, -1.19655982e-01f, 4.69867699e-02f, 5.28380610e-02f, 4.23831083e-02f, -4.78492118e-02f, -2.79427059e-02f, 1.56234263e-03f, 5.88732213e-02f, -2.82563362e-02f,
  -2.82937493e-02f, 6.07353896e-02f, -1.19022187e-02f, -5.40118292e-02f, 1.68193653e-02f, -6.36181384e-02f, 1.08299933e-01f, -3.50599103e-02f, 2.82188747e-02f, -1.08891971e-01f,
  -2.38321368e-02f, 5.45056947e-02f, -8.48960504e-03f, 1.31966203e-01f, -4.10502851e-02f, -2.84153577e-02f, -5.18279485e-02f, -2.31967936e-03f, -7.30050877e-02f, 1.47018516e-02f,
  2.05907255e-01f, -3.50126214e-02f, -1.76038325e-01f, -1.89451545e-01f, -6.62779287e-02f, -2.69279599e-01f, -2.62477905e-01f, -1.05072111e-01f, 7.81970546e-02f, -2.71033980e-02f,
  -8.65223408e-02f, 6.90437853e-02f, 1.13778878e-02f, -1.45239174e-01f, 8.58687982e-02f, 1.45316929e-01f, -1.73971996e-01f, -1.21907249e-01f, 1.23569131e-01f, -1.24094144e-01f,
  3.34320366e-02f, -1.19040735e-01f, -6.60117790e-02f, -1.19744755e-01f, -1.71210989e-01f, -1.67220086e-02f, 6.23029619e-02f, -7.41608813e-02f, -1.60154119e-01f, 3.39616947e-02f,
  2.24702135e-02f, 6.00022264e-02f, -1.09563410e-01f, 3.14992145e-02f, -7.64352679e-02f, -7.18368888e-02f, -5.00600077e-02f, -3.69564779e-02f, 1.33457163e-03f, -3.46233509e-02f,
  4.16257791e-02f, 5.15525714e-02f, -4.59090173e-02f, -2.37165112e-03f, 8.17208644e-03f, -1.36012053e-02f, 3.92804444e-02f, -2.06717942e-02f, -5.08513711e-02f, 1.87100470e-02f,
  -7.68481493e-02f, 2.22309176e-02f, -6.68139337e-03f, 4.02818061e-02f, 3.34728695e-02f, 1.48792481e-02f, -1.47868870e-02f, -6.28003851e-03f, 1.82298217e-02f, 3.28635760e-02f,
  -5.09057492e-02f, 3.76301073e-02f, 7.34920939e-03f, 5.76577000e-02f, -1.66554488e-02f, 1.13612006e-03f, -8.95456690e-03f, 9.09815636e-03f, 3.55174243e-02f, -1.66874193e-02f,
  -1.48854153e-02f, -6.22593146e-03f, 5.14854230e-02f, -3.07539832e-02f, 9.37006809e-03f, 5.49663883e-03f, -2.45226324e-02f, -1.69429940e-03f, -3.52072939e-02f, 2.10566144e-03f,
  -8.99976306e-03f, 1.61023624e-02f, -6.19779713e-03f, 4.04580543e-03f, -1.59589127e-02f, 2.33665463e-02f, 3.29830386e-02f, 6.08550617e-04f, 3.36678922e-02f, -6.89977407e-02f,
  -9.63646993e-02f, -9.97301340e-02f, -7.46644139e-02f, 7.23177800e-03f, -6.39790520e-02f, -1.07704950e-02f, -5.80879115e-02f, -1.09972311e-02f, -3.64855975e-02f, -4.09285091e-02f,
  -6.60713157e-03f, -4.57830802e-02f, -2.00591572e-02f, 3.98635752e-02f, -4.57859449e-02f, -1.90294087e-02f, 1.12157094e-03f, -2.63212877e-03f, -5.70854396e-02f, 6.54230407e-03f,
  -3.60412970e-02f, 4.33407025e-03f, -2.03140676e-02f, 1.14971735e-02f, -1.08157713e-02f, 3.84482071e-02f, 1.29592912e-02f, 6.17876910e-02f, -2.63618561e-03f, 1.23204011e-02f,
  9.39788446e-02f, -8.17745738e-03f, 2.24934697e-01f, 2.33542040e-01f, -4.40740511e-02f, -2.00213268e-01f, -1.87319562e-01f, 6.30580261e-02f, 6.43730536e-02f, -1.50859639e-01f,
  -1.91560566e-01f, 1.41387433e-01f, -2.64639556e-01f, 4.54329066e-02f, -1.83315232e-01f, -3.36803943e-01f, 7.84786567e-02f, -2.64354912e-03f, -1.03303224e-01f, 1.68681368e-01f,
  1.40837833e-01f, -1.21799566e-01f, 1.75287932e-01f, 5.52432612e-02f, 1.15698338e-01f, 2.67114013e-01f, 1.23609431e-01f, -4.05133003e-03f, 3.08256716e-01f, -3.40591408e-02f,
  6.37546852e-02f, -1.09145204e-02f, 8.47584382e-02f, 6.99412376e-02f, 8.98160785e-02f, 1.22965211e-02f, 8.59428104e-03f, -1.15874654e-03f, 7.00560212e-02f, 8.12802687e-02f,
  2.41730474e-02f, 6.02121949e-02f, 5.02495747e-03f, -2.22413260e-02f, 9.14233401e-02f, 4.45898660e-02f, 6.18373565e-02f, 1.05935171e-01f, 1.14905089e-02f, -1.24596776e-02f,
  3.08715347e-02f, 5.98645248e-02f, 4.76908982e-02f, 9.82244462e-02f, 1.23581579e-02f, 2.38440558e-02f, -1.18478583e-02f, 8.74202624e-02f, 4.60290201e-02f, 8.42950791e-02f,
  1.04485350e-02f, -6.25245571e-02f, -5.30278012e-02f, -3.31200957e-02f, -4.43653353e-02f, 2.15399861e-02f, -5.62491268e-02f, -3.75231318e-02f, 8.62817746e-03f, -1.11887045e-02f,
  3.27664264e-03f, 4.80880700e-02f, -8.01362693e-02f, 4.22953628e-02f, -1.80992913e-02f, -2.39563920e-02f, 7.08603710e-02f, 2.98441388e-02f, 1.22510284e-01f, -2.23947270e-03f,
  -1.56918526e-01f, -2.33177599e-02f, 6.16521798e-02f, -4.50179167e-03f, -7.31297508e-02f, 1.61131267e-02f, -1.38190771e-02f, -2.74762716e-02f, -5.10506220e-02f, -2.32706908e-02f,
  7.65542835e-02f, 7.09961215e-03f, 8.99525061e-02f, 3.65026854e-02f, 1.30607532e-02f, -9.06308517e-02f, -9.90286171e-02f, 5.98730855e-02f, 2.67094169e-02f, -9.15982798e-02f,
  1.32511631e-01f, 2.11237054e-02f, 1.41503336e-02f, 4.55466919e-02f, 9.48361903e-02f, -3.37643214e-02f, 5.45583554e-02f, 3.73814031e-02f, 1.16443492e-01f, 6.69765174e-02f,
  -5.81695139e-03f, -4.99510914e-02f, 4.90320325e-02f, 5.02524786e-02f, 1.27879027e-02f, 5.21942601e-02f, -5.47409989e-02f, 7.98368268e-03f, -4.38781530e-02f, -2.26148230e-04f,
  -7.10545853e-02f, -3.93267930e-01f, 8.35535601e-02f, -5.95709607e-02f, 8.02184567e-02f, 1.81810379e-01f, 4.07177746e-01f, -3.50204527e-01f, -4.48943913e-01f, -1.35366574e-01f,
  8.39381143e-02f, 2.09778130e-01f, 1.36752605e-01f, -1.92740217e-01f, 3.37654352e-01f, -3.13537121e-02f, -2.23560095e-01f, 5.60999364e-02f, -1.90426916e-01f, -4.91321199e-02f,
  -9.11785290e-02f, -1.29188195e-01f, 1.49615154e-01f, -2.13085324e-01f, -1.31277868e-03f, 2.90461257e-03f, 2.75103956e-01f, 3.26897055e-01f, 1.66124225e-01f, 1.94595903e-01f,
  -1.02001764e-01f, -1.50812656e-01f, -1.13715261e-01f, -3.83438654e-02f, 7.55692273e-03f, 6.18306287e-02f, 1.37748942e-01f, 3.07276040e-01f, 1.38010830e-01f, 2.96070427e-02f,
  7.78917149e-02f, 4.44580279e-02f, -1.02911241e-01f, 1.28118962e-01f, -2.18534172e-02f, -9.15293247e-02f, -1.00840703e-01f, -1.28127620e-01f, -7.11787269e-02f, 6.86182529e-02f,
  -5.42740971e-02f, -1.28734142e-01f, -7.36516342e-02f, -1.08406357e-02f, 1.89734362e-02f, -4.78019267e-02f, -5.55802882e-02f, 2.51062959e-01f, -2.25751232e-02f, -9.58801955e-02f,
  -4.57156496e-03f, 2.41486225e-02f, 2.45265896e-03f, -7.46396855e-02f, 4.32938561e-02f, -4.40501637e-04f, -2.67191586e-04f, 3.26737054e-02f, 6.09654412e-02f, -5.96883371e-02f,
  -3.00408360e-02f, 5.57973385e-02f, -1.46573916e-01f, -3.70360948e-02f, 1.33094480e-02f, -1.35602459e-01f, 1.66108221e-01f, 3.02920956e-02f, -9.24822912e-02f, -8.03347826e-02f,
  -1.16992649e-02f, 7.71437436e-02f, 4.53537144e-02f, 3.97491306e-02f, -1.32850051e-01f, -1.63294328e-03f, -3.37597989e-02f, -3.50381471e-02f, -6.87078834e-02f, 1.44392043e-01f,
  4.87773083e-02f, -1.04508184e-01f, -3.27900536e-02f, -6.34594494e-03f, -2.55290940e-02f, -4.42082100e-02f, -3.00927386e-02f, -2.47827917e-02f, 8.23319796e-03f, -4.08431254e-02f,
  3.04879099e-02f, 4.79917265e-02f, -3.19708772e-02f, 8.68426729e-03f, 9.24745724e-02f, -4.00717072e-02f, 5.67920171e-02f, -3.47649446e-03f, -3.25747975e-03f, 2.53257193e-02f,
  -4.16983441e-02f, 4.82705273e-02f, 5.42958640e-02f, -1.21927030e-01f, -9.65795889e-02f, 2.16029901e-02f, -1.25392172e-02f, 1.31118204e-02f, 1.03151157e-01f, 7.18327090e-02f,
  -5.66572666e-01f, 3.13791156e-01f, -2.34918356e-01f, 5.56970853e-03f, 5.62717281e-02f, -3.83600056e-01f, 1.63230002e-02f, 8.69497061e-02f, -9.03918073e-02f, 3.58520687e-01f,
  2.50462681e-01f, -1.76384926e-01f, 2.77384609e-01f, 9.43856314e-02f, -4.49026108e-01f, -1.30416378e-02f, -1.22081749e-01f, -2.65174322e-02f, -1.70687065e-01f, 8.51743147e-02f,
  -1.35188431e-01f, 1.97167486e-01f, 2.67982204e-02f, 1.72527939e-01f, 3.92680019e-02f, -1.64479576e-02f, 3.18386286e-01f, 1.44751027e-01f, 2.08355524e-02f, -1.01025365e-01f,
  -2.51413528e-02f, 1.22428410e-01f, 5.50945885e-02f, -7.26854578e-02f, -6.27595633e-02f, 4.04178798e-02f, 9.94095299e-03f, -4.56084870e-02f, -6.16723858e-03f, -8.25854465e-02f,
  -6.17279708e-02f, -4.33789454e-02f, -8.57936367e-02f, -5.26062474e-02f, -1.62101779e-02f, 1.35568781e-02f, -5.10284752e-02f, -9.46710557e-02f, 3.80497575e-02f, -9.22757685e-02f,
  -1.21183107e-02f, -9.40622091e-02f, 2.02262006e-03f, 2.10615918e-02f, -6.11302145e-02f, -3.25495983e-03f, -5.53670414e-02f, -1.73989460e-02f, -5.06446958e-02f, -8.85110348e-02f,
  -8.68447572e-02f, -3.19520663e-03f, 4.93064821e-02f, 3.78036201e-02f, 3.27891670e-02f, 3.76967825e-02f, 1.89100560e-02f, -9.24910139e-03f, -3.15249078e-02f, 7.49261165e-03f,
  3.62925455e-02f, 8.40334315e-03f, 4.98823039e-02f, -2.16992963e-02f, -5.92396036e-02f, -2.08643749e-02f, -9.19821765e-03f, 1.23297470e-02f, -2.55951304e-02f, -6.18652193e-05f,
  1.01936594e-01f, -3.68304402e-02f, -1.37341786e-02f, 2.85851248e-02f, 4.76574115e-02f, -2.81645451e-02f, 5.84068745e-02f, -7.48340739e-04f, 6.56910539e-02f, -2.71019582e-02f,
  2.94429306e-02f, 1.58247128e-01f, 8.62869546e-02f, -1.15437317e-03f, 4.81570102e-02f, 4.96042147e-03f, -5.49989417e-02f, -8.24410096e-02f, -1.66685283e-02f, -2.10109074e-02f,
  5.53051196e-03f, 6.01899438e-02f, -9.99703910e-03f, -1.42274203e-03f, -3.14965434e-02f, 4.12010401e-02f, 7.51561597e-02f, 1.41674271e-02f, 6.66734353e-02f, -4.47559133e-02f,
  9.83404368e-02f, 9.38054174e-03f, -1.91157404e-02f, 2.53524240e-02f, 3.07646394e-02f, 2.15379149e-02f, -2.51138564e-02f, -4.02223207e-02f, 9.08223260e-03f, 1.84204783e-02f,
  -9.54897925e-02f, 4.26111698e-01f, 3.03296506e-01f, 6.50354549e-02f, -2.42061657e-03f, 3.49696934e-01f, 1.03530496e-01f, 9.62538049e-02f, 3.45504254e-01f, 8.20253566e-02f,
  -2.58733988e-01f, 2.20991731e-01f, -1.92355230e-01f, 6.44902810e-02f, -6.43635541e-03f, 7.31571950e-03f, 1.82255208e-01f, 7.15752617e-02f, 3.84154022e-02f, -5.79235032e-02f,
  -8.12731460e-02f, -1.94109008e-01f, -2.61296988e-01f, -1.26017168e-01f, -5.47366031e-02f, 1.42111424e-02f, -3.80826563e-01f, -6.06638826e-02f, -6.89929724e-03f, 1.12853937e-01f,
  -4.34550941e-02f, -3.54267173e-02f, 4.52010147e-02f, 1.06166616e-01f, 2.88338866e-02f, 4.58291732e-02f, 5.49327619e-02f, 3.23308520e-02f, -5.84076196e-02f, 6.12042099e-02f,
  -8.74989200e-03f, 2.56173201e-02f, 8.37981924e-02f, 2.28103027e-02f, 4.25452366e-02f, 3.41092348e-02f, -5.20540867e-03f, 1.00795142e-02f, 5.54678254e-02f, -3.32161523e-02f,
  -1.64884292e-02f, 7.91963190e-02f, 1.45104351e-02f, 1.04240678e-01f, 4.74912524e-02f, 6.25410527e-02f, 9.66141298e-02f, 6.58295527e-02f, 3.70950848e-02f, 9.08259675e-02f,
  -3.36620249e-02f, 7.39133358e-02f, 2.90161493e-04f, -5.89486398e-02f, 2.29096562e-02f, 1.99244432e-02f, 4.67101345e-03f, -6.15994558e-02f, 2.78910026e-02f, -5.51796369e-02f,
  -2.41521886e-03f, 2.45220661e-02f, 3.78566794e-02f, 2.88228206e-02f, -1.93497203e-02f, 2.00843029e-02f, -3.43185547e-03f, -2.55279001e-02f, 9.23173968e-03f, -2.12738924e-02f,
  -5.20814210e-02f, 5.35322167e-02f, -6.51767179e-02f, -7.73136690e-02f, 1.38213541e-02f, -4.51519415e-02f, -1.60183664e-02f, 6.42109383e-03f, -7.32412934e-02f, -1.39941666e-02f,
  2.05941975e-01f, 2.64608443e-01f, 7.19653741e-02f, 9.26831551e-03f, 1.42701138e-02f, -2.28550807e-02f, 5.84459975e-02f, 1.17964409e-01f, 1.32467836e-01f, -3.36452766e-04f,
  1.04372995e-02f, -5.96733438e-03f, 7.18946680e-02f, -9.41025540e-02f, 8.07935558e-03f, 3.94738093e-02f, -1.03197834e-02f, 4.31830771e-02f, 8.10700282e-02f, -3.60977389e-02f,
  -5.81956469e-02f, 5.75110056e-02f, 2.64425622e-03f, 7.88515806e-03f, 3.00780330e-02f, -2.11481247e-02f, 7.34330937e-02f, -1.72459260e-02f, -2.14294046e-02f, 8.79199505e-02f,
  4.72682029e-01f, -3.37007105e-01f, -3.42020839e-01f, 5.58505096e-02f, 4.97113317e-01f, 3.46931636e-01f, 1.26789272e-01f, 5.35419174e-02f, -1.22755885e-01f, -1.40391842e-01f,
  2.19821081e-01f, -1.17070697e-01f, -2.07169920e-01f, 2.18406215e-01f, 3.11319381e-01f, -1.42446056e-01f, 1.08486615e-01f, -1.13032116e-02f, -1.82304364e-02f, 4.63436395e-02f,
  7.40252361e-02f, 2.77023107e-01f, -1.46333873e-01f, -8.72592535e-03f, 2.02106550e-01f, -2.03257412e-01f, 1.22798234e-02f, -1.90807402e-01f, 6.23562895e-02f, 9.66110602e-02f,
  1.53347895e-01f, 3.37614790e-02f, 1.15378648e-01f, -9.58008766e-02f, -7.05902092e-03f, 6.98422492e-02f, -3.87147702e-02f, -3.40247415e-02f, 3.81609127e-02f, -1.04390038e-02f,
  -6.19658828e-02f, -5.70419319e-02f, 1.41105091e-03f, 1.74017381e-02f, 4.18188684e-02f, 1.65878665e-02f, 3.21338177e-02f, 6.72204196e-02f, -1.47950873e-01f, 8.08180403e-03f,
  -6.92606866e-02f, -7.48676946e-03f, 1.11020125e-01f, -1.60530463e-01f, 1.85619909e-02f, -3.38887498e-02f, -8.24518129e-02f, -5.56018427e-02f, 1.80117507e-02f, -2.01415340e-03f,
  -2.45899502e-02f, -1.90188549e-02f, 1.59155037e-02f, 4.03686427e-02f, 3.15207578e-02f, 4.58417386e-02f, 1.31037831e-01f, 1.83487535e-02f, -7.50995427e-02f, 4.06969935e-02f,
  -2.87146289e-02f, 4.04952765e-02f, 7.56305754e-02f, -7.97797367e-03f, 3.77830006e-02f, 3.33581716e-02f, 4.17851005e-03f, -2.84970067e-02f, -3.51230316e-02f, 7.41021335e-02f,
  3.87494862e-02f, -1.75626483e-02f, 5.96962124e-03f, -8.48781317e-02f, -1.70329027e-02f, -4.59315702e-02f, -8.57753213e-03f, 1.40682254e-02f, -4.79951762e-02f, -1.60930920e-02f,
  -9.26260874e-02f, -2.25701228e-01f, -4.84393314e-02f, -3.32067870e-02f, -9.58530977e-02f, 8.72147307e-02f, -4.43394855e-03f, 3.18414755e-02f, -6.47425801e-02f, 3.13952938e-02f,
  -8.66369158e-03f, -7.28942156e-02f, 2.02605911e-02f, -9.52394120e-03f, -5.94885163e-02f, 9.29478928e-02f, -8.90073404e-02f, -3.23491022e-02f, -2.64534232e-04f, 2.39359704e-03f,
  -7.94119686e-02f, -4.56687622e-02f, -2.54531996e-03f, 6.15954120e-03f, -2.03756392e-02f, 7.58341327e-03f, 7.15073273e-02f, -6.08039536e-02f, 1.00583611e-02f, -7.80872926e-02f,
  9.60519090e-02f, -1.02823436e-01f, -1.57851905e-01f, 1.47743136e-01f, 6.80953339e-02f, -1.73925504e-01f, -3.56328309e-01f, 6.45751655e-02f, -1.62693158e-01f, -2.34838203e-01f,
  2.23730486e-02f, -4.24078591e-02f, -2.45066851e-01f, 3.20860356e-01f, 2.79555470e-01f, -2.07185708e-02f, 3.50866556e-01f, 1.36435926e-01f, 1.75542921e-01f, 2.33148962e-01f,
  2.77009875e-01f, 3.70907575e-01f, 2.65326619e-01f, 3.45921129e-01f, 1.37495890e-01f, 7.31979236e-02f, 1.24031991e-01f, -1.11269392e-01f, 1.90307230e-01f, 3.73207517e-02f,
  7.33077973e-02f, 3.88893783e-02f, 2.45632380e-02f, -3.41014080e-02f, 3.77734229e-02f, -7.74003640e-02f, -1.29228152e-04f, -7.02884123e-02f, 1.69476364e-02f, -5.46938851e-02f,
  -2.84545068e-02f, 6.98619932e-02f, 9.50765237e-02f, -3.78869660e-02f, 1.33832758e-02f, -1.89739577e-02f, 6.84350953e-02f, -6.63243458e-02f, -5.15619181e-02f, 1.41378418e-02f,
  -4.20624651e-02f, -2.66724695e-02f, -1.58123393e-02f, -8.21436103e-03f, -6.55449852e-02f, -3.37317511e-02f, -2.37223301e-02f, -1.12454154e-01f, 1.74407638e-03f, 2.71944720e-02f,
  6.29436597e-02f, -6.38766140e-02f, -7.37090129e-03f, -3.00687347e-02f, -5.93015812e-02f, -1.13125136e-02f, 4.40873345e-03f, -3.76368314e-03f, -2.19990723e-02f, -1.49585335e-02f,
  9.76949092e-03f, 4.89526689e-02f, 1.45977028e-02f, -5.31938411e-02f, 9.34395567e-02f, 5.43693900e-02f, -1.72063503e-02f, -1.58560034e-02f, -1.42020173e-02f, 2.37888433e-02f,
  9.42582265e-03f, 3.64458524e-02f, -8.46022442e-02f, 2.04693433e-02f, 2.29919814e-02f, -1.24717936e-01f, 5.19840494e-02f, -6.35442138e-02f, -5.24824904e-03f, 5.88565730e-02f,
  2.22412832e-02f, 1.23539111e-02f, -2.75105387e-02f, 3.96922883e-03f, 4.67366613e-02f, 7.70801082e-02f, 8.29700157e-02f, 3.11334208e-02f, 2.67927144e-02f, -7.11902156e-02f,
  2.38434225e-02f, -2.48032119e-02f, -1.15779592e-02f, 1.75092444e-02f, 6.95400760e-02f, -6.30280375e-02f, -8.41848329e-02f, -4.16826867e-02f, 8.49764235e-03f, 1.47208735e-01f,
  1.26501005e-02f, 3.66733479e-03f, 4.96848263e-02f, -8.17841478e-03f, 3.47166657e-02f, -6.38421327e-02f, 1.27253085e-02f, 2.11490598e-02f, 2.58922372e-02f, 2.02702358e-02f,
  -6.86612576e-02f, -5.38382232e-02f, 7.21153012e-03f, -1.08348921e-01f, -1.59562379e-01f, -4.08050753e-02f, -2.95892179e-01f, -1.02987126e-01f, 2.51647853e-03f, 1.07277945e-01f,
  -2.23365456e-01f, 1.11243844e-01f, 2.81346813e-02f, -2.43037790e-01f, -3.05280276e-02f, -5.37007339e-02f, -5.24726994e-02f, -2.98616365e-02f, -2.60291398e-02f, -8.98313522e-02f,
  -1.49515286e-01f, -3.09880137e-01f, -1.47502020e-01f, -2.12071151e-01f, -1.29652545e-01f, 3.19460891e-02f, 4.12866995e-02f, -1.42747909e-01f, -1.34586439e-01f, -2.37757817e-01f,
  6.64006323e-02f, -9.80286673e-02f, 8.07484239e-02f, 8.67493302e-02f, 2.64709145e-02f, 2.49323547e-02f, -1.69964582e-02f, -1.68977425e-01f, -4.39115288e-03f, -2.61702836e-02f,
  1.31250411e-01f, 1.37755079e-02f, 1.52338194e-02f, -6.97744191e-02f, -1.10187709e-01f, -7.01962737e-03f, 4.19964977e-02f, 1.13264009e-01f, -2.24510618e-02f, -1.75185744e-02f,
  2.72185914e-02f, 1.32412255e-01f, 1.19479559e-02f, 1.18062846e-01f, 6.67043612e-04f, -5.04276603e-02f, 5.31123206e-02f, 1.19078038e-02f, 1.23280719e-01f, -4.31544706e-02f,
  -9.87497792e-02f, 6.25788122e-02f, -1.88968387e-02f, -1.01087168e-02f, -8.94395262e-02f, -5.89642152e-02f, -1.01664841e-01f, -3.29157934e-02f, -4.55508120e-02f, 2.73025576e-02f,
  7.03842491e-02f, 1.67822074e-02f, -5.89151420e-02f, 8.21420923e-02f, -9.56588015e-02f, 5.04784621e-02f, -4.86372858e-02f, 9.80217084e-02f, 9.53231752e-03f, 8.74499381e-02f,
  -3.45211178e-02f, -4.81235906e-02f, -6.23510778e-02f, 1.32611142e-02f, -4.91300672e-02f, 1.31732076e-02f, -6.77366136e-03f, 7.85641279e-03f, 1.00942597e-01f, 1.80753767e-02f,
  1.43480226e-01f, 5.76276071e-02f, 4.91268337e-02f, 5.63896485e-02f, 8.02368149e-02f, 5.72607182e-02f, -5.56328371e-02f, -6.25192374e-02f, 2.41437624e-03f, -1.09870791e-01f,
  3.72512490e-02f, 6.69905124e-03f, 1.86071157e-01f, -2.98001189e-02f, -2.59570833e-02f, 2.17566863e-02f, 4.33510132e-02f, 1.60647511e-01f, 1.08189113e-01f, 3.88896912e-02f,
  1.55788645e-01f, 6.13592844e-03f, 1.69240218e-02f, 1.35365590e-01f, 9.03387815e-02f, 7.34728351e-02f, 5.54879569e-02f, 2.15731561e-02f, 6.17807843e-02f, 3.01614609e-02f,
  1.52380407e-01f, -2.17293024e-01f, 1.18875042e-01f, -2.83820271e-01f, 6.10322729e-02f, 4.63839695e-02f, -4.73797955e-02f, -2.12406784e-01f, -2.86283284e-01f, -2.69108206e-01f,
  -1.93064183e-01f, 1.29244238e-01f, 1.95201978e-01f, -2.68769234e-01f, 3.45602185e-01f, 1.92177445e-01f, -2.48347268e-01f, -1.94360912e-01f, -4.96762954e-02f, -2.44241193e-01f,
  -6.63172975e-02f, -2.30900183e-01f, 1.05696872e-01f, -2.91632444e-01f, -1.37062326e-01f, -1.47737324e-01f, -1.55720972e-02f, 5.87256588e-02f, -1.90738320e-01f, 1.04515612e-01f,
  8.47162828e-02f, -1.22579746e-01f, 4.07751948e-02f, 6.83824643e-02f, -6.97516790e-03f, 3.56944203e-02f, 2.78916396e-02f, 8.84375870e-02f, -7.73937162e-03f, -2.72779670e-02f,
  4.98510152e-03f, 4.97666039e-02f, -7.42057487e-02f, 8.12015831e-02f, -9.23177153e-02f, -2.69694123e-02f, 3.19768749e-02f, 5.71694449e-02f, -2.74529774e-02f, 1.09649718e-01f,
  -2.32567601e-02f, 8.64097103e-02f, -2.68328767e-02f, -4.80536371e-02f, -5.09828329e-02f, -8.87629613e-02f, 3.38659659e-02f, 7.39783719e-02f, -7.32728839e-02f, -4.05659117e-02f,
  -5.23900203e-02f, 5.32700121e-02f, 7.64059573e-02f, -1.37518812e-02f, 1.32510392e-03f, 1.03161307e-02f, 3.28703821e-02f, 1.74177643e-02f, 5.93047664e-02f, 3.41622792e-02f,
  -2.78051980e-02f, -4.23115678e-02f, -4.95421700e-02f, -5.70269264e-02f, -1.57261956e-02f, 5.05125932e-02f, 3.88791561e-02f, -2.30384078e-02f, -1.03407808e-01f, 6.26500249e-02f,
  5.60574792e-02f, -5.27324341e-02f, -2.65152603e-02f, -6.75941333e-02f, -2.04812195e-02f, 9.11728665e-02f, -6.15070909e-02f, -3.59246023e-02f, 2.14759796e-03f, 8.27750489e-02f,
  -3.04941982e-02f, -2.41308674e-01f, -2.09402591e-02f, -7.12551698e-02f, 9.98022873e-03f, 4.66283634e-02f, 3.01969685e-02f, -1.14874899e-01f, -1.17986603e-02f, -4.54394072e-02f,
  -4.60685603e-02f, -3.22716907e-02f, -5.16900942e-02f, -3.87644069e-03f, -3.68281230e-02f, -5.33873662e-02f, -3.54027189e-02f, 4.13007215e-02f, 4.12736312e-02f, -6.14302270e-02f,
  -7.13772997e-02f, -5.52700125e-02f, 1.88580472e-02f, -9.34369341e-02f, -1.52967513e-01f, -1.60556231e-02f, 1.40246227e-02f, -6.31077308e-03f, -5.41743310e-03f, -2.55834162e-02f,
  2.67173558e-01f, -2.30691701e-01f, -1.32479995e-01f, -3.05221289e-01f, -8.67738500e-02f, -5.89900203e-02f, -8.38603601e-02f, -2.11245090e-01f, -2.22324103e-01f, -1.82183251e-01f,
  -1.87180430e-01f, 5.29281190e-03f, 6.70340136e-02f, -1.75803795e-01f, 2.29109555e-01f, 1.55668363e-01f, -7.83450603e-02f, -4.18113954e-02f, -1.61149558e-02f, -6.15806878e-02f,
  2.71531958e-02f, -1.44702559e-02f, 8.05866942e-02f, -3.34207900e-02f, -1.11858293e-01f, -6.86912313e-02f, 8.51113200e-02f, -3.74713354e-02f, -1.40737370e-01f, 2.59105843e-02f,
  -1.62582193e-02f, -6.41064197e-02f, -4.78993952e-02f, 3.51532623e-02f, -2.83436617e-03f, 3.03013232e-02f, 1.03411078e-01f, 3.89019288e-02f, -5.12481146e-02f, 4.22051847e-02f,
  7.27245435e-02f, 4.42974456e-02f, -7.04267174e-02f, 1.11187734e-01f, -6.19118363e-02f, -9.57328677e-02f, -4.22112308e-02f, -4.09885421e-02f, -1.05520049e-02f, 1.48073090e-02f,
  -5.15134595e-02f, -4.35879547e-03f, -8.53469074e-02f, -4.17785486e-03f, -1.00885533e-01f, -6.91592768e-02f, 1.16561845e-01f, 1.52296359e-02f, 2.10713558e-02f, 3.47270034e-02f,
  2.50168815e-02f, 1.09019563e-01f, 4.15719710e-02f, -4.37841378e-02f, -1.63321029e-02f, -2.95583270e-02f, -1.18089374e-02f, -3.81428786e-02f, -4.68728952e-02f, -2.18596254e-02f,
  -1.17441833e-01f, -1.66429114e-02f, -1.72245055e-02f, 1.23583339e-03f, 8.65745246e-02f, 6.10349588e-02f, 7.88957477e-02f, -1.99336838e-02f, -7.94626921e-02f, -6.27138764e-02f,
  -4.97383177e-02f, 2.74786036e-02f, -2.36549359e-02f, -2.13606860e-02f, 6.50250912e-02f, 3.14667709e-02f, -7.33611509e-02f, 1.58922728e-02f, -8.77062008e-02f, 2.34439895e-02f,
  4.35878746e-02f, -1.96639914e-02f, -4.42352593e-02f, -7.65227452e-02f, 4.88649495e-02f, 7.05296993e-02f, 8.30969494e-03f, -7.69512057e-02f, -3.03588156e-02f, 1.80920940e-02f,
  -1.22181708e-02f, -2.62306556e-02f, -6.72024786e-02f, 3.01384926e-02f, -1.16443429e-02f, -9.84946042e-02f, -7.73333386e-03f, -4.39534634e-02f, 5.88113302e-03f, -3.02808341e-02f,
  -4.92778569e-02f, -3.55447456e-02f, -6.31429767e-03f, -4.74459119e-02f, -9.02179331e-02f, -1.56303700e-02f, 3.93883586e-02f, -2.84774639e-02f, -1.84411146e-02f, -7.08496422e-02f,
  -4.46603954e-01f, 2.38519222e-01f, 4.16210830e-01f, -5.04353233e-02f, -1.61791340e-01f, 1.26682788e-01f, 3.01479161e-01f, -8.91956687e-02f, -2.34811634e-01f, 1.40347168e-01f,
  1.38954699e-01f, 1.52550519e-01f, 1.91789091e-01f, 1.21266536e-01f, -2.01556176e-01f, 4.60204072e-02f, 3.31101082e-02f, 5.22271357e-02f, -1.46352917e-01f, -1.38610825e-01f,
  -1.22784443e-01f, -1.73225850e-01f, 2.20925495e-01f, -2.44075000e-01f, 1.20516740e-01f, -7.15601966e-02f, -8.01161379e-02f, 4.64773998e-02f, 3.34243737e-02f, 6.79844767e-02f,
  -1.16583645e-01f, -1.72799096e-01f, 8.73765573e-02f, 3.82725373e-02f, -1.08213145e-02f, 1.93166677e-02f, 7.22619370e-02f, 3.55731957e-02f, -2.39599608e-02f, -1.08757371e-03f,
  2.00259425e-02f, -7.47081637e-02f, -9.38362032e-02f, -4.75507379e-02f, -6.66817874e-02f, -8.36667232e-03f, 1.17313422e-01f, 1.31636500e-01f, 6.74172193e-02f, 8.32655951e-02f,
  1.17429972e-01f, 1.21304572e-01f, 5.46276793e-02f, 5.59473634e-02f, 1.65858157e-02f, 3.20249870e-02f, 5.28940447e-02f, 7.68230716e-03f, 1.66627765e-02f, -9.78380069e-02f,
  -7.06106871e-02f, -1.03184119e-01f, 1.10360391e-01f, -1.04295658e-02f, 5.59496926e-03f, 3.40995230e-02f, -1.59941372e-02f, 1.31351976e-02f, 4.69648726e-02f, -3.96796428e-02f,
  -6.10764846e-02f, 1.54382829e-02f, -7.06863776e-02f, -1.12643801e-02f, -5.33087440e-02f, 4.87574050e-03f, 6.31476715e-02f, -1.51471281e-03f, -2.49816142e-02f, 4.42549214e-02f,
  9.12418310e-03f, -3.18716615e-02f, 1.40117351e-02f, 6.69759363e-02f, -7.25860568e-03f, 4.43225317e-02f, -1.43093173e-03f, 4.38080095e-02f, -2.83765439e-02f, -5.48668541e-02f,
  -3.90266389e-01f, -3.82185519e-01f, -8.45929608e-02f, -3.94430757e-02f, -2.67123096e-02f, 4.43719048e-03f, -5.17278649e-02f, -2.23062523e-02f, -7.35231563e-02f, -9.24716592e-02f,
  -2.71570627e-02f, 3.48331966e-02f, -1.03961118e-01f, -2.30994471e-03f, -8.92879516e-02f, -2.90843807e-02f, -1.04090059e-02f, 1.09092202e-02f, 1.28738740e-02f, -6.88902587e-02f,
  3.66634317e-02f, -7.34191164e-02f, 3.15183736e-02f, -3.20658088e-02f, -3.06418315e-02f, 2.06223857e-02f, -1.20219648e-01f, -5.68284169e-02f, -3.80102694e-02f, -2.58453912e-03f,
  -4.41466153e-01f, 3.36846679e-01f, 3.80037129e-02f, 1.22332193e-01f, -3.22275430e-01f, 2.32841283e-01f, 2.85189062e-01f, -3.62908165e-03f, 1.80920258e-01f, 1.89868614e-01f,
  -3.76758203e-02f, -2.77483203e-02f, 1.23458505e-01f, 1.53053537e-01f, 9.46335047e-02f, 3.26722413e-01f, 2.51779020e-01f, 1.27474621e-01f, 9.91661102e-02f, -2.88821869e-02f,
  -3.11492942e-02f, 3.72711346e-02f, 2.31522303e-02f, -3.14864628e-02f, -1.62956953e-01f, -1.00616127e-01f, -1.46619201e-01f, -1.66825932e-02f, -4.21190225e-02f, -4.19176072e-02f,
  8.50809067e-02f, -1.01672873e-01f, -7.22726136e-02f, 7.50201344e-02f, 1.90772489e-02f, -2.98864488e-02f, -2.06491491e-03f, -1.20392991e-02f, -2.32082140e-02f, 3.61852720e-02f,
  -8.09050351e-03f, 1.08612720e-02f, 5.94396740e-02f, -9.42206196e-03f, -6.62157610e-02f, -2.07062121e-02f, -5.07934205e-03f, -4.28226776e-02f, 4.92739454e-02f, -5.11074550e-02f,
  -2.85269041e-02f, 1.23141631e-02f, -6.22601844e-02f, 1.02417253e-01f, -4.60550748e-02f, 2.41703913e-02f, 1.08235836e-01f, -5.57011291e-02f, 2.81658936e-02f, 5.19292727e-02f,
  -8.83708373e-02f, 1.12441279e-01f, 6.85836449e-02f, 3.70106776e-03f, 7.39955902e-02f, 7.94214103e-03f, -1.79468505e-02f, -5.11408187e-02f, -9.65561904e-03f, 2.07974762e-03f,
  -1.34442665e-03f, -4.92910035e-02f, -3.28606227e-03f, 2.35968344e-02f, 1.56036019e-02f, -1.74236472e-03f, -6.04928359e-02f, 1.06100114e-02f, -5.23994863e-03f, 1.78903900e-02f,
  1.27724018e-02f, 3.75046656e-02f, 4.02955897e-02f, -1.98576711e-02f, 1.56065086e-02f, -5.28572872e-02f, -2.17048265e-02f, 4.17842623e-03f, -1.82943121e-02f, -2.73497049e-02f,
  1.77485019e-01f, 3.10160279e-01f, 9.06892344e-02f, 3.19611691e-02f, 9.32325423e-02f, -5.42103387e-02f, 3.65183800e-02f, -2.05912907e-02f, 1.14011489e-01f, 5.04450360e-03f,
  -1.88519880e-02f, 7.70656690e-02f, -7.45369820e-03f, -6.74845725e-02f, 2.98848227e-02f, 1.07541874e-01f, 9.56487954e-02f, 2.04514842e-02f, 5.83952852e-02f, -4.11954522e-02f,
  -3.54283080e-02f, 2.74047459e-04f, -2.05187895e-03f, 1.63679605e-03f, -1.85580421e-02f, -4.10923958e-02f, -5.25774695e-02f, -7.94148073e-03f, -3.46895419e-02f, 5.25016561e-02f,
  -2.67973125e-01f, -2.70027757e-01f, 9.96204168e-02f, -2.45157778e-01f, -1.03143953e-01f, 6.50914535e-02f, 8.96485969e-02f, -1.82748005e-01f, -2.97955215e-01f, -1.32390410e-01f,
  -6.38372675e-02f, -2.31198370e-02f, 3.37822527e-01f, -2.75923133e-01f, 4.43687707e-01f, 2.38324314e-01f, -1.57185763e-01f, 7.69032491e-03f, -1.38009414e-01f, -1.59422070e-01f,
  -8.44800547e-02f, -1.59310684e-01f, 1.77090958e-01f, -2.98703283e-01f, -2.51245588e-01f, -2.02449918e-01f, 1.21162184e-01f, 8.66396502e-02f, -2.07599476e-01f, 2.88939532e-02f,
  -1.00551963e-01f, -2.61666983e-01f, -1.47808390e-02f, 3.91279571e-02f, -6.62111789e-02f, 3.61932218e-02f, 4.88775447e-02f, 1.67654142e-01f, -2.15707645e-02f, 4.08006236e-02f,
  5.30351177e-02f, 6.95139123e-03f, -1.57475814e-01f, 1.13525279e-01f, -1.48894608e-01f, -7.01288432e-02f, -7.96609744e-02f, -3.48119661e-02f, -1.35555258e-02f, 6.91342503e-02f,
  2.84907669e-02f, 1.84131991e-02f, -3.34796757e-02f, -4.73583974e-02f, 9.17213969e-03f, -4.92399931e-02f, 3.08801699e-02f, 1.24278650e-01f, -4.91858795e-02f, -9.18503031e-02f,
  -5.31770401e-02f, 9.84113477e-03f, 2.49278322e-02f, -1.09293219e-02f, -5.08246757e-02f, -7.06081539e-02f, 3.78592834e-02f, 3.09252590e-02f, -2.85350438e-02f, -4.83354293e-02f,
  -6.03520013e-02f, 1.24107879e-02f, -4.24681269e-02f, 5.33509031e-02f, -9.61801857e-02f, -5.38465008e-02f, 1.38267413e-01f, -2.32046694e-02f, -3.47620361e-02f, -2.41022352e-02f,
  -2.41653714e-02f, -6.28722236e-02f, -8.43587816e-02f, 6.34394810e-02f, 9.61627066e-03f, 1.24202348e-01f, -7.86762387e-02f, 7.89373890e-02f, 6.35942072e-02f, 1.32957086e-01f,
  -3.26493122e-02f, -2.14303881e-01f, -4.88907099e-02f, -4.02747765e-02f, 9.29036140e-02f, 1.08668106e-02f, -4.70668040e-02f, -1.35383174e-01f, 2.15285993e-03f, -5.37204891e-02f,
  -1.43181300e-02f, 2.47964151e-02f, -4.80933748e-02f, 5.03009511e-03f, 1.73088890e-02f, 9.12346039e-03f, -3.86704467e-02f, 4.24206955e-03f, 9.52276066e-02f, -5.26580922e-02f,
  8.66045132e-02f, -3.64718214e-02f, 1.29014971e-02f, -9.28352475e-02f, -8.31258856e-03f, 5.20719886e-02f, -7.94812664e-02f, -6.65797293e-02f, -4.50258628e-02f, -2.68153809e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.59634912e-01f, 2.60083944e-01f, 2.33708426e-01f, 3.37432295e-01f, 1.83129743e-01f, 3.24437261e-01f, 3.02014232e-01f, 2.31346130e-01f, 3.62076700e-01f, 7.72873908e-02f,
  2.56585389e-01f, 2.17365593e-01f, 3.29072177e-01f, 3.07568550e-01f, 2.91937083e-01f, 1.41216323e-01f, 2.87840307e-01f, 1.36225387e-01f, 1.83793753e-01f, 3.51037443e-01f,
  3.25873077e-01f, 2.91474849e-01f, 3.22390914e-01f, 1.54349521e-01f, 3.99253368e-01f, 2.51931876e-01f, 3.23498726e-01f, 2.09224939e-01f, 2.62956858e-01f, 2.40348592e-01f,
  2.86865801e-01f, 1.71704575e-01f, 2.64478177e-01f, 2.24620923e-01f, 2.48617277e-01f, 3.68581891e-01f, 2.10747719e-01f, 3.51125926e-01f, 3.69779170e-01f, 1.08739868e-01f,
  2.75669634e-01f, 1.99123681e-01f, 3.23667079e-01f, 2.51827121e-01f, 3.57393712e-01f, 2.53629744e-01f, 2.40123287e-01f, 2.65271753e-01f, 1.49015531e-01f, 3.43220115e-01f,
  2.63470262e-01f, 3.35432976e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -9.80299562e-02f, 7.72983134e-02f, -2.65706833e-02f, -9.75398198e-02f, 8.75181183e-02f, -1.10014729e-01f, -8.47021937e-02f, -3.40537757e-01f, -2.99009681e-01f, -1.86781749e-01f,
  -1.82694644e-02f, 9.87846032e-03f, -1.58640906e-01f, -9.68380570e-02f, -5.33467531e-02f, -2.80665290e-02f, -3.33198011e-01f, 3.28782685e-02f, -1.64788797e-01f, -5.19833304e-02f,
  -9.00684297e-02f, -7.42130578e-02f, -7.89304152e-02f, -6.28279075e-02f, -1.96903825e-01f, 5.76624013e-02f, -1.56176230e-02f, -2.60056943e-01f, 9.73551795e-02f, -7.10330084e-02f,
  -8.30108002e-02f, -1.45693833e-03f, 1.12751953e-01f, -6.83096722e-02f, 4.53530326e-02f, 7.18185976e-02f, -1.18273072e-01f, 8.13522339e-02f, -2.13348001e-01f, 6.41334653e-02f,
  -1.47648364e-01f, 2.60924608e-01f, 1.55392557e-01f, 3.37064803e-01f, 2.02593952e-01f, -1.79547384e-01f, -2.15466097e-01f, -1.90266058e-01f, -1.05187975e-01f, -1.08018368e-01f,
  1.03616498e-01f, 2.90779471e-01f, -2.23521456e-01f, -1.48368001e-01f, 2.08388939e-01f, 5.42006865e-02f, 1.42197028e-01f, -2.84599900e-01f, -1.85949847e-01f, 2.17152774e-01f,
  -1.35887295e-01f, -3.03879529e-01f, 3.55509311e-01f, 2.35127774e-03f, -2.44847476e-01f, 1.99091107e-01f, 3.85500342e-02f, -1.32676676e-01f, -2.15796709e-01f, 2.55212158e-01f,
  2.77828753e-01f, 2.59278089e-01f, 9.32869017e-02f, -2.62025833e-01f, 2.53273875e-01f, -2.33962268e-01f, -3.18066508e-01f, -1.36970133e-01f, -2.33943015e-01f, -3.93160969e-01f,
  -1.16333820e-01f, -1.44258961e-01f, -1.20434128e-01f, -1.24545075e-01f, 1.99448496e-01f, 2.40871027e-01f, -9.28201713e-03f, 3.28010768e-01f, -3.16518009e-01f, -1.45985693e-01f,
  8.97525251e-02f, 5.37843704e-01f, -2.08628044e-01f, 2.04639524e-01f, -2.29084715e-01f, 5.09103894e-01f, -5.51892459e-01f, -2.82264411e-01f, -2.28265181e-01f, -2.33888149e-01f,
  -1.42689958e-01f, 2.96053469e-01f, -3.15668583e-01f, 2.00240454e-03f, -5.29569328e-01f, 3.07542533e-01f, -3.99053037e-01f, -3.84951562e-01f, -2.50396192e-01f, 1.52987698e-02f,
  5.24375141e-01f, -1.09219760e-01f, 4.58647341e-01f, -2.71408975e-01f, 5.34900427e-02f, -1.78687260e-01f, -1.01573639e-01f, -1.60846397e-01f, 3.69272202e-01f, -2.54701674e-01f,
  -3.35806757e-01f, -1.81896210e-01f, -3.06106601e-02f, -2.30797425e-01f, -2.12223798e-01f, 5.00524402e-01f, 4.47844774e-01f, 1.10779978e-01f, -2.25474723e-02f, 1.37320802e-01f,
  1.04186438e-01f, -1.93532199e-01f, -3.13039958e-01f, -5.35580367e-02f, -7.32703358e-02f, -3.97789568e-01f, 2.09316552e-01f, 2.42711917e-01f, -3.19835335e-01f, -2.78402239e-01f,
  -2.01579686e-02f, -2.23781645e-01f, 9.72230267e-03f, 8.31448808e-02f, 2.75513113e-01f, -3.87707911e-02f, 1.89149961e-01f, 1.05102688e-01f, 5.40208966e-02f, -3.16787362e-01f,
  2.41217967e-02f, 1.74196407e-01f, 2.10571110e-01f, -8.04829448e-02f, -8.95517841e-02f, 8.41552243e-02f, -2.96920300e-01f, 5.57699949e-02f, -4.22920510e-02f, 7.58448541e-02f,
  1.25601888e-01f, 1.49844870e-01f, 6.06033877e-02f, 4.79257777e-02f, -4.79638912e-02f, -4.45848666e-02f, 4.65764478e-02f, -3.25156331e-01f, 1.07641466e-01f, 2.26643905e-01f,
  -4.15820748e-01f, -4.48094547e-01f, 1.05096288e-01f, -3.20384949e-02f, -1.35764197e-01f, 9.04736109e-03f, 9.27403197e-02f, -2.40945414e-01f, 1.19664624e-01f, -4.17509407e-01f,
  -3.79854649e-01f, -2.46607840e-01f, -1.75869197e-01f, -3.44747245e-01f, 3.03961933e-01f, -1.96743935e-01f, -3.08652043e-01f, 2.31894985e-01f, -1.97641522e-01f, 1.23299308e-01f,
  -6.89191893e-02f, -1.45085588e-01f, -2.86638707e-01f, 4.04588908e-01f, 2.15884045e-01f, 1.74228907e-01f, 3.63045111e-02f, -1.47791743e-01f, -4.49708402e-01f, -1.63340136e-01f,
  1.06314987e-01f, -3.45152855e-01f, -1.40256044e-02f, 3.00896913e-01f, -4.03840356e-02f, 4.27482456e-01f, -3.15538228e-01f, 1.59758076e-01f, -8.75906423e-02f, -4.10278916e-01f,
  8.34287982e-03f, -3.10793221e-01f, 2.67886907e-01f, -6.02566376e-02f, -2.05382854e-01f, 2.82382220e-01f, -2.35631838e-01f, -2.07697839e-01f, -3.78473550e-01f, 1.85038105e-01f,
  3.52207750e-01f, 2.87831932e-01f, -4.36482042e-01f, 3.03053856e-01f, 3.22820038e-01f, -2.61126816e-01f, -1.23081945e-01f, 5.94511256e-02f, -1.58194363e-01f, 4.28188622e-01f,
  -8.04168433e-02f, -7.49356389e-01f, 2.97908068e-01f, 4.04138356e-01f, -1.35153502e-01f, -2.22014245e-02f, -5.21868875e-04f, -1.88943431e-01f, -5.47692120e-01f, -3.57703447e-01f,
  -3.52690518e-01f, -3.01902354e-01f, -3.98890287e-01f, 8.63475278e-02f, -4.14045990e-01f, -2.58757055e-01f, -2.41132662e-01f, 7.67252445e-02f, 4.58285451e-01f, 1.32883668e-01f,
  -4.65014726e-01f, 5.85478954e-02f, 2.19774142e-01f, -2.97522157e-01f, -4.21896540e-02f, -3.49502385e-01f, 4.41909470e-02f, -1.65362418e-01f, -8.40856414e-03f, -7.90629908e-02f,
  2.72678491e-02f, 9.71063897e-02f, -2.69444674e-01f, -3.16023380e-02f, -7.89550766e-02f, -5.06349131e-02f, -2.11626336e-01f, -1.36231408e-01f, -4.51661684e-02f, -1.70448162e-02f,
  -2.43087113e-01f, 4.08843607e-02f, -1.12776391e-01f, -4.45417650e-02f, -1.54938459e-01f, 1.06495898e-02f, -7.04476386e-02f, 8.20837244e-02f, -1.39526278e-01f, -1.66000918e-01f,
  -1.34565592e-01f, -3.28528397e-02f, -3.21648754e-02f, 4.31484543e-02f, -8.61638188e-02f, -2.79624015e-01f, -1.46352991e-01f, -7.53783481e-03f, -1.49276331e-01f, -1.00407131e-01f,
  -2.42789760e-02f, -8.85834917e-02f, 1.77256986e-02f, 9.37395077e-03f, 2.80096501e-01f, -8.70909765e-02f, 6.59942105e-02f, 1.31515473e-01f, 2.41896108e-01f, 2.05901727e-01f,
  3.10107559e-01f, -3.44451308e-01f, 2.65459627e-01f, 1.86961547e-01f, -2.80735373e-01f, -6.59557879e-02f, -1.67244263e-02f, -1.40622139e-01f, -1.20664962e-01f, 1.66016921e-01f,
  2.45432090e-02f, 2.05714941e-01f, -2.73408860e-01f, 2.53311455e-01f, 2.23670647e-01f, 1.14252426e-01f, 1.03316136e-01f, 2.08025575e-01f, -2.43675470e-01f, 8.52220729e-02f,
  1.55399852e-02f, -2.14573264e-01f, 1.33041963e-01f, 1.10713780e-01f, 1.32388994e-01f, -7.32931346e-02f, -3.67209944e-03f, 3.22581232e-01f, -7.62907416e-02f, -1.52591914e-01f,
  1.43409604e-02f, 7.59537145e-02f, -2.63117194e-01f, -7.45032132e-02f, -1.47710517e-01f, 1.48880228e-01f, 5.22608638e-01f, 2.61606202e-02f, 3.75273347e-01f, 1.41129926e-01f,
  3.79824460e-01f, 6.33515138e-03f, -1.55859381e-01f, -2.59050250e-01f, -1.88694254e-01f, -9.91458297e-02f, -1.62378341e-01f, 1.33254658e-02f, -5.92370890e-02f, -3.66265267e-01f,
  -5.11339188e-01f, 5.86042143e-02f, 3.77092302e-01f, -1.18570581e-01f, -2.52792001e-01f, 4.60859627e-01f, -8.58871415e-02f, 9.39434469e-02f, -2.31159732e-01f, 5.77095091e-01f,
  -2.20718637e-01f, -3.59462231e-01f, -2.83364356e-01f, -1.65934950e-01f, -1.48943678e-01f, -7.61778727e-02f, -1.41076654e-01f, -2.28593522e-03f, -7.72180706e-02f, -2.84406453e-01f,
  -2.52673388e-01f, -1.05674490e-01f, 2.23762736e-01f, 8.64896923e-02f, -2.54165530e-01f, -1.53798848e-01f, 2.81249583e-01f, 4.40699816e-01f, -1.17061801e-01f, -1.51274323e-01f,
  -2.83900481e-02f, -1.81117252e-01f, -1.51527524e-01f, -5.62398471e-02f, -1.20682672e-01f, -2.78378546e-01f, 1.13780975e-01f, -3.83694805e-02f, -8.06495398e-02f, 3.69521119e-02f,
  9.75645781e-02f, -8.86664353e-03f, 3.04573923e-02f, -2.43080944e-01f, 7.32341968e-03f, -2.33800620e-01f, -4.89784591e-02f, 7.35695213e-02f, 3.17646861e-02f, 6.96746707e-02f,
  2.08758876e-01f, 4.28275317e-02f, -2.12546065e-01f, 2.52814274e-02f, 3.02623771e-03f, -1.81153074e-01f, -1.16997287e-01f, -2.19697610e-01f, -2.48708293e-01f, -1.91248700e-01f,
  -1.45996049e-01f, -1.43768862e-01f, -1.84506506e-01f, -1.73357844e-01f, 4.40639630e-02f, -1.59272417e-01f, 3.38242799e-02f, -8.06054473e-02f, -2.95013189e-01f, -2.04987511e-01f,
  6.80374727e-02f, -1.95289075e-01f, -3.09330463e-01f, -4.32762019e-02f, 2.46422336e-01f, -6.54968247e-02f, 1.52697423e-02f, -1.79677084e-01f, 1.95090830e-01f, 2.71693707e-01f,
  -2.65225053e-01f, -6.11734129e-02f, 2.10412398e-01f, -5.02791405e-02f, 1.16232336e-01f, 4.46238928e-02f, 1.96227908e-01f, 3.84331018e-01f, -6.74448758e-02f, -8.89030099e-02f,
  -2.38609344e-01f, 4.72388901e-02f, 1.39221437e-02f, -2.22130030e-01f, 9.43990871e-02f, -2.83090889e-01f, 7.17661902e-02f, 6.75551444e-02f, 1.49338230e-01f, 1.58831716e-01f,
  -2.10042074e-01f, -2.10441768e-01f, 6.00515194e-02f, 2.28173107e-01f, 2.85551846e-01f, -1.36823580e-01f, 1.19716890e-01f, -9.98118594e-02f, -1.38102636e-01f, -2.39085078e-01f,
  -2.33334780e-01f, -2.34955788e-01f, 3.66545230e-01f, -9.11554769e-02f, -1.29031882e-01f, -2.49601513e-01f, -2.55204272e-02f, -1.21351458e-01f, -5.75699151e-01f, 7.88646698e-01f,
  4.08538282e-01f, -1.51745647e-01f, 2.42461547e-01f, 3.14146221e-01f, 1.11746199e-01f, -9.48770717e-02f, -1.96206257e-01f, 9.13181752e-02f, -1.92701325e-01f, 2.47737870e-01f,
  -2.80366898e-01f, 2.32882962e-01f, 2.88258463e-01f, -1.23710312e-01f, 3.69389087e-01f, -2.01778024e-01f, -2.55438268e-01f, -1.19827047e-01f, -2.03204334e-01f, -1.43637881e-01f,
  -1.07741520e-01f, 3.25510979e-01f, 2.25210473e-01f, 4.33279037e-01f, -3.59928340e-01f, 2.32018575e-01f, 6.15297891e-02f, -3.96759272e-01f, -7.59814978e-02f, -1.21227559e-02f,
  -3.21687073e-01f, -2.37901539e-01f, 5.02295911e-01f, -2.77704448e-01f, -2.17165500e-01f, -1.46842942e-01f, -2.90075868e-01f, -2.59866476e-01f, -3.40535671e-01f, -6.09120727e-03f,
  -1.40947521e-01f, -1.89147890e-01f, 8.36067423e-02f, 2.63352897e-02f, -1.40895352e-01f, 4.38509956e-02f, 3.31291370e-02f, 3.93291861e-02f, 6.35481700e-02f, 2.99448550e-01f,
  2.31181428e-01f, 4.22361642e-02f, 2.56683171e-01f, 1.18641637e-01f, 5.15697673e-02f, -4.29790579e-02f, -1.60966516e-01f, -1.09251566e-01f, 1.10378094e-01f, -4.08373661e-02f,
  2.27171019e-01f, 1.76691532e-01f, 7.46530890e-02f, 1.41010970e-01f, 3.78732294e-01f, -8.46292377e-02f, 5.91320395e-02f, 2.72727847e-01f, 2.37712979e-01f, 6.99538291e-02f,
  -2.80473735e-02f, 1.44558832e-01f, 1.12985544e-01f, 2.37435535e-01f, -1.84232876e-01f, -1.24869011e-01f, 6.81561977e-02f, 1.76813882e-02f, 2.90386714e-02f, -1.17121473e-01f,
  -5.19709885e-02f, 4.47720259e-01f, -3.60245645e-01f, 1.62660390e-01f, 2.43945137e-01f, 2.02754080e-01f, -2.81737894e-01f, -1.10089011e-01f, 2.29328692e-01f, -2.05770031e-01f,
  -5.34778796e-02f, 5.00622272e-01f, 3.20396662e-01f, -2.27571279e-02f, 1.06046237e-01f, -2.26192951e-01f, 4.25794631e-01f, -6.92068487e-02f, 6.00043312e-02f, 2.68172562e-01f,
  -1.12127915e-01f, -1.49497256e-01f, 3.34728330e-01f, 9.45224762e-02f, -2.15020627e-01f, 1.58271983e-01f, 3.60200942e-01f, 2.73076240e-02f, -3.03860635e-01f, 1.33228049e-01f,
  -2.43433714e-01f, -5.38605340e-02f, -7.08502950e-03f, 1.59737706e-01f, 4.98634279e-01f, 2.70205140e-01f, 3.27786267e-01f, -3.18017274e-01f, 4.67285782e-01f, -2.02717870e-01f,
  1.67408615e-01f, -5.82657278e-01f, -2.10080892e-01f, -2.83953339e-01f, -4.12054747e-01f, -1.70993343e-01f, -3.60472836e-02f, -4.24842238e-01f, 1.27740979e-01f, -2.58465081e-01f,
  4.61646944e-01f, -1.48136601e-01f, 4.36681420e-01f, -3.58603954e-01f, -2.17345491e-01f, 1.13271326e-01f, 9.74624306e-02f, 1.81379557e-01f, 1.61173925e-01f, 1.55354127e-01f,
  -2.77786970e-01f, 2.70394683e-01f, 4.89133894e-01f, 2.20841140e-01f, -4.47158813e-01f, 1.12697974e-01f, -4.14898783e-01f, -4.28541958e-01f, 3.61864448e-01f, -2.63123870e-01f,
  -2.59603351e-01f, -1.71030071e-02f, -2.39540398e-01f, -4.90001649e-01f, 5.00093639e-01f, 2.11692810e-01f, -4.23014551e-01f, -1.04318567e-01f, -2.04134792e-01f, -1.49320379e-01f,
  -2.95072019e-01f, 1.69299334e-01f, 5.39780548e-03f, 2.36411020e-01f, 7.08045363e-02f, 2.61750698e-01f, 8.08094665e-02f, 2.90963650e-01f, 8.54696855e-02f, 1.95284471e-01f,
  7.85222426e-02f, -3.77029441e-02f, 1.22833282e-01f, 2.17918903e-01f, 1.08725257e-01f, 2.06712961e-01f, 2.15841696e-01f, 3.31989169e-01f, -3.76282260e-02f, 1.40379652e-01f,
  -3.38253900e-02f, 1.83829248e-01f, 1.24000855e-01f, 2.65698850e-01f, 4.38646413e-02f, 1.76154509e-01f, 2.48631492e-04f, 5.63766919e-02f, -2.45019674e-01f, -5.99139929e-02f,
  -8.06084648e-02f, 2.23780960e-01f, -6.30585924e-02f, 7.98412412e-03f, 2.17571139e-01f, 2.39223376e-01f, 1.82212234e-01f, 1.97804973e-01f, 1.38847008e-01f, 2.01498270e-01f,
  -7.01112002e-02f, -4.45246473e-02f, -1.23622984e-01f, 8.47419500e-02f, 2.98928946e-01f, -8.17248598e-02f, -6.48717210e-03f, 1.97060615e-01f, -1.93904303e-02f, 4.68438379e-02f,
  2.56817967e-01f, -4.34274934e-02f, -2.08118588e-01f, -4.02365029e-01f, -4.74221073e-02f, -4.39983159e-01f, -3.20191771e-01f, -1.42641649e-01f, -3.81490499e-01f, -3.30790401e-01f,
  -2.78436154e-01f, 1.27212986e-01f, 5.09947002e-01f, 2.20397487e-01f, 2.57061541e-01f, 2.78309494e-01f, 2.90691793e-01f, 2.56676739e-03f, -3.05124849e-01f, 4.14626181e-01f,
  -3.92296046e-01f, -1.13664098e-01f, -1.29314080e-01f, -2.46503308e-01f, -6.91156834e-02f, 2.46682122e-01f, 2.05275133e-01f, 1.13644406e-01f, -4.00573909e-01f, -2.97271013e-01f,
  3.53819937e-01f, -7.64905512e-02f, -2.36738339e-01f, 5.23558021e-01f, 9.60158482e-02f, -1.04859352e-01f, -2.67832801e-02f, -3.23659003e-01f, -1.56547338e-01f, 3.42126451e-02f,
  -3.25064629e-01f, -4.12747115e-02f, -2.33688384e-01f, 3.19458961e-01f, -1.62233055e-01f, -1.00189090e-01f, 1.91528052e-02f, 4.23853397e-02f, -3.08082312e-01f, 3.20270598e-01f,
  3.35656434e-01f, 1.60171837e-01f, 5.32767996e-02f, -2.98443139e-01f, 1.64115533e-01f, -5.37353635e-01f, 8.23428705e-02f, 1.72507882e-01f, -3.35839629e-01f, -2.89720744e-01f,
  -5.06857693e-01f, -1.71160981e-01f, 2.83306688e-01f, 1.16845325e-01f, 3.62879634e-01f, -9.65942570e-04f, -4.14656177e-02f, 4.12981182e-01f, -2.20845699e-01f, -1.43059734e-02f,
  2.84954011e-01f, -3.97710562e-01f, -2.96705514e-01f, 2.03704402e-01f, 2.54767299e-01f, -1.67433247e-01f, -9.53668952e-02f, -1.57333650e-02f, -4.41794753e-01f, 5.21742404e-01f,
  -5.41837633e-01f, -3.67346644e-01f, 9.56800953e-02f, -3.58587146e-01f, -5.36014289e-02f, -4.35056001e-01f, 5.05040765e-01f, -1.13123350e-01f, -1.70343503e-01f, 5.47591485e-02f,
  7.09144725e-03f, -3.85083929e-02f, -9.35126618e-02f, -1.24738321e-01f, -4.77893464e-02f, 1.01841629e-01f, 4.22131121e-02f, -2.59550750e-01f, 1.81736216e-01f, -1.30721614e-01f,
  -1.30813159e-02f, -2.19773557e-02f, 5.62555045e-02f, -2.16217667e-01f, -3.20732817e-02f, -2.81564832e-01f, 1.27090156e-01f, -1.73219383e-01f, -7.47105703e-02f, 1.63477525e-01f,
  -5.60221002e-02f, 1.15744330e-01f, -2.50222445e-01f, -1.12236507e-01f, -1.94926336e-01f, 1.41281620e-01f, 1.40220985e-01f, -9.28632319e-02f, -8.63931030e-02f, 1.49954513e-01f,
  5.37739731e-02f, 1.41390443e-01f, -3.65179718e-01f, 1.22254543e-01f, 9.34734568e-02f, 8.62097666e-02f, 2.82403082e-01f, 2.85822041e-02f, 3.38188201e-01f, 1.22714154e-01f,
  1.92590296e-01f, 4.33351070e-01f, -3.21768761e-01f, 2.36703292e-01f, 1.38366997e-01f, 3.37209016e-01f, -1.76770255e-01f, -2.14278400e-01f, 1.72741428e-01f, 8.32911581e-02f,
  3.21379304e-01f, 4.25222069e-01f, -3.03826272e-01f, 2.23016843e-01f, -2.92306274e-01f, -1.01003982e-01f, 2.45344609e-01f, -3.28566551e-01f, -1.38229966e-01f, -1.13745265e-01f,
  -2.28298932e-01f, -3.17866117e-01f, -1.36443362e-01f, -3.98329675e-01f, -2.68666983e-01f, 1.80938691e-01f, 3.91120225e-01f, -1.90425381e-01f, -3.09345901e-01f, -1.87188819e-01f,
  -3.19427490e-01f, -8.09765831e-02f, 1.19365554e-03f, 2.15801984e-01f, 3.82316887e-01f, 7.64355659e-02f, 4.25296724e-01f, 5.57663679e-01f, 2.41229326e-01f, 4.15976971e-01f,
  4.13375616e-01f, -4.40618604e-01f, -4.10302937e-01f, -1.16347507e-01f, 2.58088768e-01f, -1.85197771e-01f, -3.53354633e-01f, -2.97329217e-01f, -4.85367596e-01f, -1.21327326e-01f,
  -1.02068633e-01f, -1.03409313e-01f, -4.84766439e-02f, -4.14872259e-01f, -2.66680028e-02f, -2.35527784e-01f, -3.74525078e-02f, -2.98849463e-01f, -1.96606904e-01f, -1.49353564e-01f,
  2.40839943e-01f, -2.44960323e-01f, 3.40457052e-01f, 1.00478679e-01f, 2.46312946e-01f, -2.35550731e-01f, -2.82929957e-01f, 1.95780426e-01f, 8.28349367e-02f, 3.57111633e-01f,
  -3.66887748e-02f, 3.95117342e-01f, 4.73338842e-01f, 6.40293434e-02f, 1.00461207e-01f, -5.62591493e-01f, -5.68411760e-02f, -1.91352710e-01f, 3.54587823e-01f, -7.09772632e-02f,
  -2.88857758e-01f, -2.28048116e-01f, -3.28075558e-01f, -2.69838810e-01f, -3.83109421e-01f, -5.87866664e-01f, 5.65532669e-02f, -5.27996831e-02f, -2.24622879e-02f, -7.49451816e-02f,
  -7.39483014e-02f, 3.18872221e-02f, -7.54407719e-02f, -2.27192163e-01f, -4.19752002e-02f, 9.09828395e-02f, -2.48983353e-01f, -1.22162409e-01f, -2.13417381e-01f, -1.28108725e-01f,
  -1.35762289e-01f, -2.64305528e-02f, -3.88098322e-02f, -7.38275051e-02f, -6.93206582e-03f, -9.45601240e-02f, -1.01449840e-01f, -7.88411424e-02f, 2.67141312e-02f, -1.77529603e-01f,
  -9.15979967e-03f, 8.11070576e-02f, -4.63944897e-02f, -3.18503231e-02f, -1.66464880e-01f, -7.57173821e-02f, -3.43263112e-02f, -2.39232972e-01f, -1.40281469e-01f, 2.04936396e-02f,
  7.49602020e-02f, 1.16679579e-01f, 1.09665424e-01f, -5.99347092e-02f, -5.17600812e-02f, -1.16389409e-01f, 1.21268921e-01f, -2.52632409e-01f, -9.62048322e-02f, -6.06621355e-02f,
  1.42250612e-01f, 7.70966932e-02f, -1.62203297e-01f, -2.67091803e-02f, 1.26820922e-01f, 1.78559572e-01f, -2.45719165e-01f, 1.79709479e-01f, -1.40905276e-01f, -1.17651381e-01f,
  3.80500033e-02f, 1.16585247e-01f, 1.26821203e-02f, 2.14680955e-01f, 1.49876058e-01f, -1.69017896e-01f, -2.14958452e-02f, 8.70006457e-02f, 1.53112903e-01f, 1.68137625e-01f,
  1.58908486e-01f, -2.69577205e-01f, -1.28477171e-01f, -2.23532885e-01f, -1.64124928e-02f, 1.43527657e-01f, 1.09547906e-01f, 4.83811274e-02f, -2.63249695e-01f, -1.37674570e-01f,
  9.63027179e-02f, -7.99195841e-02f, 6.99002445e-02f, -2.43102282e-01f, 9.72808301e-02f, -1.56854659e-01f, -5.58609813e-02f, -2.46786699e-03f, 6.38126256e-03f, -9.72002968e-02f,
  -1.67844445e-01f, -2.04522550e-01f, -2.35348061e-01f, -1.76489905e-01f, -7.77317956e-02f, 3.68037462e-01f, -1.67231232e-01f, -3.97905558e-02f, -2.34608069e-01f, -8.53061453e-02f,
  1.39922917e-01f, -2.41996244e-01f, -4.50245999e-02f, 2.85360277e-01f, 2.51436085e-01f, -2.48652309e-01f, 8.43825471e-03f, -1.92712456e-01f, 2.70983368e-01f, 3.33229452e-01f,
  -7.59247765e-02f, -7.74729922e-02f, 1.13334514e-01f, 4.55731988e-01f, 6.71275854e-02f, 3.57364327e-01f, 3.91458720e-02f, -1.33232191e-01f, -3.98847507e-03f, -1.09765537e-01f,
  -1.40165254e-01f, 4.51743245e-01f, -5.45831071e-03f, -4.71833684e-02f, -3.12433094e-01f, -1.74369887e-01f, -1.96475267e-01f, 4.36068811e-02f, 3.68543804e-01f, 3.65548432e-01f,
  2.85208672e-01f, -2.24033192e-01f, -1.54956430e-01f, 4.04555261e-01f, -1.76003128e-01f, -5.26205525e-02f, 1.17770573e-02f, 1.71322972e-01f, -2.52226833e-02f, -9.13771018e-02f,
  -6.70484686e-03f, 5.49354628e-02f, 1.46013154e-02f, -1.65637180e-01f, -6.51356182e-04f, 1.25652403e-01f, 1.00834772e-01f, 8.75968207e-03f, -5.65992575e-03f, -7.19398856e-02f,
  -1.99449122e-01f, 5.37192523e-02f, 2.07770076e-02f, 9.23801586e-02f, -2.88164290e-03f, -7.06706569e-02f, -7.46006519e-02f, -2.13987052e-01f, -2.10772343e-02f, -1.25498131e-01f,
  9.40865725e-02f, -1.13476686e-01f, -2.77651362e-02f, 3.27767953e-02f, 6.06416464e-02f, -4.12654765e-02f, -1.52270228e-01f, -8.86462852e-02f, 1.68211870e-02f, 6.00035163e-03f,
  -1.27996430e-01f, -2.08888337e-01f, -3.29771072e-01f, -9.76614282e-02f, -1.22848339e-01f, 1.08202875e-01f, -1.28489643e-01f, 2.38408551e-01f, 4.29923758e-02f, 1.85191259e-01f,
  -1.60790384e-01f, 2.66166568e-01f, -1.71268582e-01f, 1.18374676e-01f, 1.15236342e-02f, -9.51780006e-02f, -1.30184621e-01f, 2.30708402e-02f, -1.45193681e-01f, -2.04207659e-01f,
  4.10408638e-02f, 1.02234349e-01f, 1.34559274e-01f, 9.74360779e-02f, 8.02444816e-02f, 1.17621839e-01f, 3.70407440e-02f, -2.63242215e-01f, 1.38405487e-01f, -2.36084864e-01f,
  1.25385031e-01f, -6.47012815e-02f, -1.12543032e-01f, -1.02167763e-01f, -4.88720387e-02f, -2.65714586e-01f, -1.60931185e-01f, -1.21550515e-01f, -2.57952631e-01f, 1.91827998e-01f,
  -1.00383073e-01f, 6.68204017e-03f, -1.11682296e-01f, -2.86055654e-01f, 1.13476343e-01f, -1.91447765e-01f, -3.09061676e-01f, 5.13063073e-01f, -3.10594350e-01f, -3.83715741e-02f,
  -1.38465941e-01f, 1.03626117e-01f, -3.23151723e-02f, -2.02270418e-01f, -1.41675532e-01f, -2.17722714e-01f, 3.70115191e-01f, 3.54392678e-01f, 5.97376764e-01f, -2.64104724e-01f,
  4.32199650e-02f, -1.45300537e-01f, 3.56232971e-01f, -1.33093849e-01f, -1.49141073e-01f, -3.06917697e-01f, -1.97675660e-01f, 5.50784230e-01f, 6.85835481e-02f, 8.83124769e-02f,
  -1.33327276e-01f, -9.05536711e-02f, 4.07510288e-02f, -1.36912778e-01f, -1.41504094e-01f, -6.74675852e-02f, -5.86386509e-02f, -1.44542068e-01f, -1.34253785e-01f, -1.83817774e-01f,
  3.63834709e-01f, -1.90585434e-01f, 1.88861445e-01f, -2.12564662e-01f, -3.79905283e-01f, 3.48068208e-01f, -1.22491024e-01f, -2.19988912e-01f, -1.34509102e-01f, -1.55278713e-01f,
  8.39407519e-02f, -1.03239104e-01f, 7.10976198e-02f, 6.88820258e-02f, 1.37787899e-02f, 1.29725397e-01f, -3.12323757e-02f, -1.45958401e-02f, 1.04166508e-01f, 1.03067784e-02f,
  -1.89649642e-01f, 3.06159332e-02f, 1.45197004e-01f, 1.95373371e-01f, -1.62455589e-02f, 9.14813057e-02f, 1.15806721e-01f, 1.61175862e-01f, -4.24309336e-02f, 2.47651096e-02f,
  -7.52651319e-02f, 1.19324826e-01f, 1.02730304e-01f, -3.12551595e-02f, -6.88226148e-02f, 4.01662774e-02f, -5.35066016e-02f, -2.53064893e-02f, 7.69368187e-02f, -2.25199774e-01f,
  -1.96874347e-02f, 2.59219185e-02f, 1.92707181e-01f, -6.98667997e-03f, 7.32992515e-02f, -1.67711228e-02f, -2.10105106e-02f, 8.42883363e-02f, -9.57016349e-02f, 1.12779610e-01f,
  1.50520682e-01f, -3.27426732e-01f, -2.14027926e-01f, -8.87009203e-02f, 9.41644758e-02f, -3.04095261e-02f, -1.82143971e-01f, 1.33831754e-01f, 2.78299481e-01f, 2.16042563e-01f,
  3.32621634e-01f, -1.28759012e-01f, -4.10650373e-01f, 6.82266951e-02f, -2.41193444e-01f, -2.31455728e-01f, 3.02635938e-01f, 1.99255511e-01f, 2.18644068e-02f, 9.90279391e-02f,
  1.04904957e-01f, -2.48933643e-01f, -2.70651817e-01f, 2.41356820e-01f, -3.98762636e-02f, -1.59282088e-01f, -3.03856283e-01f, -3.34884942e-01f, 3.43551822e-02f, 1.10631585e-01f,
  1.10963285e-01f, 4.76818532e-01f, -3.74125391e-02f, 3.02804649e-01f, -1.70880228e-01f, -1.34921268e-01f, 2.65342683e-01f, -2.72580665e-02f, -1.65720657e-01f, -2.03888029e-01f,
  -5.44075251e-01f, 2.02034399e-01f, -2.86752343e-01f, 3.36848944e-01f, -2.92736322e-01f, -2.07161650e-01f, -2.40046844e-01f, -1.13946974e-01f, -3.60052109e-01f, 3.08733195e-01f,
  3.64112973e-01f, -1.63259044e-01f, 3.53965163e-02f, -2.17477188e-01f, -3.09540302e-01f, -1.56274274e-01f, 2.05475502e-02f, -1.67467535e-01f, -2.09362239e-01f, -2.29622856e-01f,
  -8.32216144e-02f, 3.57183963e-01f, -3.51848006e-01f, -6.07537217e-02f, 4.50041831e-01f, -3.16186428e-01f, -4.02008682e-01f, -3.14044535e-01f, 2.93794721e-01f, -1.95317894e-01f,
  -1.73491821e-01f, -3.81950617e-01f, 5.39299883e-02f, -2.21199289e-01f, -4.08196718e-01f, -7.09542409e-02f, -9.59674045e-02f, -1.36865407e-01f, -2.70449907e-01f, 7.17351019e-01f,
  -1.24915421e-01f, -3.48210812e-01f, 9.61868018e-02f, -4.96002942e-01f, -1.11974172e-01f, 4.64659780e-01f, 2.43183926e-01f, 3.16201866e-01f, -2.12966457e-01f, 5.66260755e-01f,
  2.01145440e-01f, 9.11227167e-02f, -1.01195388e-01f, -1.56873837e-02f, 1.35441557e-01f, -1.65723860e-01f, -3.16977650e-02f, 1.59780040e-01f, 1.35266418e-02f, 1.00575686e-01f,
  1.66612387e-01f, 5.51247820e-02f, 5.35807535e-02f, 5.85021749e-02f, 1.02071606e-01f, -1.00122346e-02f, -1.03838928e-01f, 3.39252353e-02f, 2.63403118e-01f, 9.63089168e-02f,
  1.25908583e-01f, 1.76917017e-01f, -6.29344210e-02f, 1.04709171e-01f, 1.12543717e-01f, 6.94676191e-02f, -1.22017972e-01f, 1.35604978e-01f, 1.94988489e-01f, 1.36596151e-02f,
  6.77234307e-02f, 1.37085229e-01f, 3.55941579e-02f, 1.60873398e-01f, -8.47332329e-02f, 2.11022615e-01f, -1.44544216e-02f, 5.75519949e-02f, 1.91416100e-01f, 3.65954340e-01f,
  -4.15002972e-01f, -3.16380858e-01f, -4.94060442e-02f, -2.94614255e-01f, 1.53069928e-01f, -3.29986811e-02f, 6.95486069e-02f, -3.39565843e-01f, 1.01343840e-02f, 2.77724177e-01f,
  -5.13871061e-03f, -2.96770275e-01f, 1.47462323e-01f, -4.32061076e-01f, -1.78386837e-01f, -2.72160381e-01f, -2.84598880e-02f, 1.34851292e-01f, -2.23876312e-01f, 1.51563019e-01f,
  1.92349747e-01f, -1.03104107e-01f, 2.93095976e-01f, 3.16680700e-01f, 3.27267557e-01f, 4.42245975e-02f, 2.32843757e-01f, -2.74663091e-01f, -1.32093526e-04f, 1.68963090e-01f,
  -2.21668139e-01f, 9.73832756e-02f, 3.25967968e-01f, 2.78816581e-01f, -1.86088726e-01f, 1.41071036e-01f, -2.03593984e-01f, 5.58694303e-01f, -7.64686018e-02f, -1.96011513e-01f,
  4.97358851e-02f, -1.26511082e-01f, 3.69779825e-01f, -3.39207441e-01f, 5.87706566e-01f, -4.51918840e-01f, 1.05497174e-01f, -2.73984075e-01f, 3.37596722e-02f, 3.29013556e-01f,
  -3.63896340e-01f, -1.97351649e-01f, -1.74199641e-01f, -3.79269451e-01f, -5.66666164e-02f, -2.67462105e-01f, 9.55067649e-02f, -3.89091045e-01f, 2.18575329e-01f, -2.90288568e-01f,
  -3.04616511e-01f, -2.45559245e-01f, -1.00597031e-01f, -2.07394958e-01f, -2.03550473e-01f, 1.11579180e-01f, -2.25608334e-01f, -3.83813322e-01f, 8.94017071e-02f, -1.22343749e-01f,
  -2.24989399e-01f, 4.37701851e-01f, -3.13949734e-01f, -2.08098471e-01f, -3.18207324e-01f, -1.56768635e-01f, 1.44869268e-01f, 2.80682147e-01f, 2.52285570e-01f, -4.30383086e-02f,
  -5.01991957e-02f, -3.41395527e-01f, 3.29394668e-01f, -2.22229779e-01f, -8.48127678e-02f, -3.04242462e-01f, -1.53873891e-01f, 4.04483229e-02f, 6.24062717e-02f, 1.02048367e-01f,
  -1.30865648e-01f, -2.30885427e-02f, -1.70746930e-02f, 1.41293541e-01f, -1.22720614e-01f, -2.15944648e-01f, 1.04831569e-02f, 1.73770666e-01f, -8.35364014e-02f, 8.78217369e-02f,
  1.23023346e-01f, 5.54202907e-02f, 1.42183468e-01f, -1.36652187e-01f, 7.25559294e-02f, 1.49451308e-02f, 2.93747969e-02f, 7.78178126e-03f, -4.33451459e-02f, 5.68612926e-02f,
  -2.21995898e-02f, 1.57847345e-01f, 2.47018114e-02f, -2.85339002e-02f, 1.36646107e-01f, 8.69385973e-02f, 6.70443475e-02f, 8.65675956e-02f, -5.82738668e-02f, -1.16461217e-01f,
  1.52573615e-01f, -1.28236055e-01f, 7.20963329e-02f, -1.53034896e-01f, 6.98626861e-02f, 4.40820903e-02f, 7.44825900e-02f, -1.32201284e-01f, 2.88143903e-01f, -3.08085918e-01f,
  2.08079129e-01f, 1.64451584e-01f, -2.30457738e-01f, 2.37046868e-01f, 1.49805278e-01f, -3.21419500e-02f, 3.35280269e-01f, 1.01900315e-02f, 2.11771503e-02f, -5.42599335e-02f,
  -1.01747081e-01f, 2.57851928e-01f, -3.26487988e-01f, -1.09176129e-01f, 9.29105356e-02f, -3.55206937e-01f, 2.57272512e-01f, -1.70307279e-01f, 3.47059458e-01f, 1.09811909e-01f,
  1.19607151e-01f, 3.38220596e-01f, -2.44224563e-01f, 3.37174743e-01f, -2.86181957e-01f, -2.42231682e-01f, 2.97490805e-01f, -2.66562253e-01f, 2.78805107e-01f, -2.49554798e-01f,
  2.95746308e-02f, 2.63957232e-01f, -3.26279819e-01f, 1.41525626e-01f, -8.89296085e-02f, -2.33802095e-01f, -2.02911332e-01f, -2.85044342e-01f, -2.28934973e-01f, 1.31030321e-01f,
  -2.41679594e-01f, 4.19280440e-01f, -1.28522977e-01f, -1.09169842e-03f, -2.91082948e-01f, -1.11332871e-01f, -7.80265331e-02f, -3.64907593e-01f, -1.79767430e-01f, -1.73094243e-01f,
  4.61369991e-01f, -2.23687068e-01f, -6.63216412e-02f, -5.47307990e-02f, -2.71800131e-01f, 2.23018080e-01f, -1.68896392e-01f, -2.11250558e-01f, 4.39213336e-01f, -1.39349848e-01f,
  -3.16704124e-01f, -3.54504585e-01f, -1.37262031e-01f, -2.95308501e-01f, -1.93842784e-01f, 1.88698135e-02f, 5.73154986e-01f, -3.00738424e-01f, 3.87269914e-01f, 2.39304379e-01f,
  -1.49254307e-01f, 2.68061846e-01f, 4.46510732e-01f, -3.44903879e-02f, 3.89421254e-01f, -8.26513246e-02f, -2.65671670e-01f, 3.01302612e-01f, -1.22827515e-01f, -1.47185951e-01f,
  2.02470213e-01f, -3.84440385e-02f, -1.93529159e-01f, 3.26614588e-01f, -2.24835441e-01f, -2.61334062e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.85989025e-02f, 2.11703014e-02f, -1.13372384e-02f, -7.64588043e-02f, 3.77912968e-02f, -2.32826266e-02f, -2.34758835e-02f, -6.57648593e-02f, 4.15384024e-02f, -4.31543104e-02f,
  1.01182148e-01f, 3.02289091e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    