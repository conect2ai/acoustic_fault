/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.29802513e-01f, -3.19424629e-01f, -4.61965740e-01f, 1.88250512e-01f, -2.40778729e-01f, -2.37128600e-01f, -4.08788174e-01f, 7.40419850e-02f, 1.63500309e-01f, -2.51515538e-01f,
  -8.75131711e-02f, 4.85098988e-01f, 3.91663194e-01f, 2.52020240e-01f, 1.85229033e-01f, -3.54061395e-01f, -2.63234079e-01f, 1.27590403e-01f, 3.05752993e-01f, 9.78775248e-02f,
  -4.89637963e-02f, 6.49739504e-02f, 1.62738025e-01f, 8.76102224e-02f, -1.05458751e-01f, 1.79168373e-01f, -1.34303927e-01f, -1.18765347e-01f, -1.83291152e-01f, -2.76869744e-01f,
  -1.90289225e-02f, 5.77383349e-03f, 1.30343869e-01f, 1.17376573e-01f, 2.07332969e-02f, 5.45111932e-02f, 1.78562216e-02f, 1.09792329e-01f, 1.90248583e-02f, 1.18313860e-02f,
  -3.45744491e-02f, 3.11470293e-02f, 2.25061737e-02f, 2.63518095e-02f, -5.15523106e-02f, -2.91712470e-02f, 2.58214697e-02f, 1.07551627e-01f, 5.57535961e-02f, -2.86665782e-02f,
  -5.83372638e-02f, -1.39054060e-01f, -1.33768544e-01f, -4.26184088e-02f, 6.83496371e-02f, 4.33942825e-02f, -7.79075995e-02f, 3.84143703e-02f, -6.57550618e-02f, 6.61407486e-02f,
  -3.26543227e-02f, 1.19787948e-02f, -1.37087088e-02f, 2.07934529e-02f, -1.82851534e-02f, -5.30462537e-04f, -5.97982807e-03f, -6.04416756e-03f, 5.50493225e-03f, -2.17161048e-02f,
  1.78694241e-02f, -7.83236176e-02f, 7.29878666e-03f, 1.27181166e-03f, 4.80157956e-02f, -6.61283731e-02f, -3.40929930e-03f, -1.77650061e-02f, 2.63682622e-02f, -1.77626796e-02f,
  4.14717346e-02f, -6.84771454e-03f, -1.93350930e-02f, 1.62331332e-02f, -1.30361607e-02f, 4.95547848e-03f, 1.63127296e-02f, 6.81211799e-03f, -2.21004393e-02f, -6.63210452e-02f,
  2.48691380e-01f, -5.10542393e-02f, 4.86044437e-02f, 7.69310296e-02f, -5.22862077e-02f, 1.85079463e-02f, 1.01825790e-02f, -3.70497815e-02f, -2.25661118e-02f, -1.80905573e-02f,
  5.54820150e-02f, 6.47903681e-02f, -4.06789444e-02f, -8.70428327e-03f, 2.62107011e-02f, 1.40811009e-02f, -5.05401343e-02f, 2.79374160e-02f, 2.13416293e-03f, -1.27415583e-02f,
  -1.78841185e-02f, -7.39584584e-03f, 1.29870564e-01f, 2.75913645e-02f, 8.29445273e-02f, 5.95752485e-02f, 1.43646561e-02f, 6.26495406e-02f, 5.37462942e-02f, 3.90316248e-02f,
  3.56206924e-01f, -1.60004258e-01f, -6.94146276e-01f, 2.73855962e-02f, -1.71590433e-03f, -1.65291540e-02f, -2.73614556e-01f, 1.54920056e-01f, 2.54606217e-01f, -3.41241926e-01f,
  3.56183574e-02f, 1.30712137e-01f, -6.87173083e-02f, -7.61262402e-02f, 3.44030894e-02f, -3.96175444e-01f, -3.96357983e-01f, -2.75881588e-01f, -1.42557099e-01f, 1.37216136e-01f,
  1.79048389e-01f, -5.51708005e-02f, 1.69236332e-01f, 1.69795990e-01f, -1.32632568e-01f, -7.92768002e-02f, -2.61312276e-01f, 7.84754083e-02f, 3.80520076e-02f, -4.51790124e-01f,
  -4.19702291e-01f, -8.51540267e-03f, 1.71158295e-02f, 1.52095824e-01f, -2.03222893e-02f, 1.15569420e-01f, 8.68228525e-02f, -3.86868715e-02f, 1.22372463e-01f, -7.96901621e-03f,
  2.29934640e-02f, 1.04429886e-01f, 3.28442501e-03f, 9.51676909e-03f, 6.99867588e-03f, 5.11888526e-02f, 6.29279457e-05f, -3.15495692e-02f, -7.81038553e-02f, -8.39722380e-02f,
  8.70881155e-02f, 7.18873441e-02f, -7.80272949e-03f, 2.63285767e-02f, -3.40660661e-02f, 4.81410734e-02f, 6.58491030e-02f, 1.32008523e-01f, -2.20809933e-02f, -5.25492579e-02f,
  3.42975892e-02f, -4.55414457e-03f, -3.16105597e-02f, 4.80470881e-02f, 5.63938543e-02f, 3.65431933e-03f, -5.13504110e-02f, -1.80765726e-02f, 1.04607372e-02f, 6.53844699e-03f,
  -1.63024347e-02f, -3.11972760e-02f, 1.76656861e-02f, -2.26032641e-02f, -7.01179057e-02f, -2.65607275e-02f, 1.97668988e-02f, -4.28848304e-02f, 1.75919924e-02f, -7.91303162e-03f,
  1.51062347e-02f, 5.31938076e-02f, -2.99279131e-02f, 3.91148739e-02f, -3.58442813e-02f, -6.43252283e-02f, -4.25161980e-03f, 4.65060398e-02f, 7.39831058e-03f, 6.75337985e-02f,
  2.02743545e-01f, 4.37189750e-02f, -1.12299420e-01f, -2.81091463e-02f, -3.32714468e-02f, -9.80505627e-03f, -8.12931284e-02f, 4.68727108e-03f, -1.72124449e-02f, -3.28104421e-02f,
  1.47933876e-02f, 1.07765356e-02f, -8.60809460e-02f, 1.73285604e-02f, -1.88420498e-04f, 1.59975253e-02f, 2.75762994e-02f, -1.11096680e-01f, 3.73719782e-02f, 4.59202789e-02f,
  1.28594227e-02f, -6.08267337e-02f, -1.18361805e-02f, -5.47552258e-02f, 4.98266332e-02f, -2.27027722e-02f, -1.47518620e-01f, -7.84713775e-02f, 1.95520353e-02f, -5.48696555e-02f,
  -1.44690931e-01f, 1.50391072e-01f, 1.39926404e-01f, -1.89859748e-01f, -1.60686702e-01f, -1.32992221e-02f, 9.73414853e-02f, 1.54825449e-01f, -1.14312425e-01f, -1.81258246e-01f,
  -2.40815401e-01f, -5.41224778e-02f, 2.47382163e-03f, 1.08784251e-01f, 3.72993976e-01f, 1.11741118e-01f, 2.10465282e-01f, 2.98092097e-01f, 1.66242138e-01f, -8.29982236e-02f,
  -7.55768418e-02f, 2.82193744e-03f, 1.09939128e-01f, 1.77503869e-01f, -1.62705630e-01f, -2.54787534e-01f, -6.84743971e-02f, 1.66867282e-02f, 8.37434232e-02f, 6.40588477e-02f,
  -2.56020159e-01f, 2.31979355e-01f, -1.70388222e-02f, -6.07009120e-02f, -6.08840138e-02f, 3.18941697e-02f, -1.01324730e-01f, -8.88992101e-03f, -1.06264874e-01f, -1.70474197e-03f,
  -5.95443621e-02f, -1.42923894e-03f, 1.24255596e-02f, 4.99682091e-02f, 4.10292149e-02f, 2.66716070e-02f, 1.10787518e-01f, 2.06125990e-01f, 1.49236456e-01f, 4.59632790e-03f,
  -1.35014325e-01f, 2.12736763e-02f, 5.38206436e-02f, 1.40413657e-01f, 2.52215534e-01f, 7.44470432e-02f, -5.38746873e-03f, 1.21823423e-01f, 8.26140270e-02f, -6.84782863e-02f,
  -4.75579686e-02f, -2.36970931e-02f, 6.20979071e-02f, 1.04850149e-02f, -1.30141191e-02f, -1.61320735e-02f, 8.32321793e-02f, -5.61172180e-02f, 7.33476132e-02f, -2.44981106e-02f,
  4.31826748e-02f, -2.36061774e-02f, 6.21662140e-02f, -4.34361119e-03f, -1.96562391e-02f, 3.43210809e-02f, 5.19060856e-03f, -2.27057114e-02f, 1.89234186e-02f, 1.19363815e-02f,
  1.27948588e-03f, 5.99169508e-02f, -3.28830145e-02f, 5.86504079e-02f, 1.08587425e-02f, 1.08565494e-01f, 1.14504118e-02f, 1.93206277e-02f, -4.92913835e-02f, -2.85957027e-02f,
  -3.33566785e-01f, 7.78516382e-02f, -1.83942869e-01f, 9.93906781e-02f, -5.34363650e-02f, 1.63722355e-02f, 8.66283290e-03f, 3.68844420e-02f, -1.92428213e-02f, -3.80835831e-02f,
  4.82334048e-02f, 1.40279792e-02f, 3.43459821e-03f, 1.37989391e-02f, -6.57401830e-02f, -4.53282222e-02f, -3.14388946e-02f, -1.39149174e-01f, 5.71839809e-02f, -2.85816714e-02f,
  -1.95296817e-02f, -1.56886116e-01f, -3.02419037e-01f, -1.10448830e-01f, -8.83306414e-02f, -2.24461690e-01f, -1.28262043e-01f, -2.65437633e-01f, -6.15675263e-02f, -4.46900189e-01f,
  2.69934744e-01f, -5.40030487e-02f, 2.16994077e-01f, 3.66943657e-01f, -4.44384776e-02f, -1.85251519e-01f, -5.17592669e-01f, -1.78659216e-01f, 2.28513107e-01f, 5.34082502e-02f,
  1.08368859e-01f, 6.04785271e-02f, -9.33846682e-02f, -1.01091102e-01f, -2.40788683e-01f, -2.35516340e-01f, -1.39084339e-01f, -5.56099527e-02f, -3.26873481e-01f, -1.98035881e-01f,
  -1.77327737e-01f, 3.71842533e-02f, 2.10272953e-01f, -7.70090701e-05f, 1.82618320e-01f, -1.75666302e-01f, 2.09460288e-01f, 2.92641670e-01f, -4.11772989e-02f, 3.08104724e-01f,
  1.82637513e-01f, 4.61498708e-01f, -1.43657729e-01f, 8.77987817e-02f, 1.23099595e-01f, 1.33519433e-02f, -3.22593749e-02f, 1.45811364e-01f, -5.62013034e-03f, 4.37795594e-02f,
  1.34790689e-01f, 8.10058638e-02f, 6.24569468e-02f, 2.03424860e-02f, 9.77013409e-02f, 3.87057588e-02f, 9.09151956e-02f, 5.28916977e-02f, 2.14228760e-02f, 1.15283497e-01f,
  -7.53181204e-02f, 1.07565880e-01f, 8.35784152e-02f, -1.12186193e-01f, -4.91453893e-02f, 6.25078008e-02f, 9.12391022e-02f, 7.98114613e-02f, -2.55639460e-02f, 8.89141262e-02f,
  -7.19599277e-02f, 1.30777685e-02f, -1.43089658e-02f, 1.80068542e-03f, -5.25364913e-02f, 2.27620490e-02f, 2.53008697e-02f, -6.22973405e-02f, -3.68405618e-02f, -8.85550212e-03f,
  -1.21155744e-02f, -2.42865998e-02f, 4.72801179e-03f, -1.49525572e-02f, -7.31284264e-03f, 1.41843474e-02f, -3.28047201e-02f, -4.54185270e-02f, 4.51664478e-02f, 7.14508491e-03f,
  -1.58008654e-02f, 1.94695927e-02f, 7.86500722e-02f, -2.50468832e-02f, -2.96047218e-02f, 5.21352701e-02f, 1.37684150e-02f, -3.22541781e-03f, 7.01887719e-03f, 7.08925352e-02f,
  -1.76719636e-01f, -8.42235312e-02f, 1.08606800e-01f, -7.71404952e-02f, 5.68129085e-02f, 7.95657709e-02f, 8.74994248e-02f, -1.68760084e-02f, 7.57539570e-02f, -2.64809076e-02f,
  3.47776562e-02f, -2.20667310e-02f, 7.91451484e-02f, -2.90862657e-02f, -4.83015068e-02f, -3.81264798e-02f, -4.90737148e-02f, -8.42400938e-02f, -2.28804769e-04f, 7.59175867e-02f,
  -3.09075247e-02f, -1.49769783e-01f, -2.55410612e-01f, -1.14138313e-01f, 6.27558380e-02f, -1.98822409e-01f, -1.27092734e-01f, -7.34528005e-02f, -2.34613031e-01f, -3.79814237e-01f,
  -9.71573070e-02f, -1.48345260e-02f, -2.22412318e-01f, 5.38785040e-01f, 9.23771784e-03f, -2.61844248e-01f, -7.61131719e-02f, -1.74379293e-02f, 2.03839004e-01f, 4.52815294e-02f,
  -2.31129915e-01f, 1.53869711e-04f, -1.03225641e-01f, -8.82737786e-02f, -1.74757242e-01f, 1.19644761e-01f, 2.56452084e-01f, 2.83921454e-02f, -1.57423988e-01f, -1.42073825e-01f,
  2.02488437e-01f, 4.19049829e-01f, 1.89159483e-01f, -1.96836218e-02f, 3.12606245e-01f, 1.83124468e-01f, 7.92156234e-02f, 1.64569691e-02f, -3.16431522e-01f, 6.84912741e-01f,
  -1.89276546e-01f, -6.79474622e-02f, -1.28384084e-02f, -1.80080514e-02f, -3.91964950e-02f, 4.70435573e-03f, 3.99702676e-02f, 4.57356796e-02f, -7.28720278e-02f, 2.04871763e-02f,
  5.01236655e-02f, 2.75884755e-02f, 7.80148432e-02f, -5.07988259e-02f, -3.28472145e-02f, -3.33276838e-02f, -5.51635474e-02f, 1.22159999e-02f, -4.62247469e-02f, -1.32564202e-01f,
  7.63689950e-02f, -3.18490155e-02f, -1.30593747e-01f, -1.15338542e-01f, -1.71536177e-01f, -1.42090797e-01f, -7.86795467e-02f, -9.05366242e-02f, -1.45413563e-01f, 2.74142802e-01f,
  -4.88376059e-03f, -3.09474627e-03f, -4.95649986e-02f, 4.76748198e-02f, 1.06578292e-02f, -2.42140815e-02f, 4.65986617e-02f, 5.15023693e-02f, 1.66214090e-02f, 2.48187035e-02f,
  1.61346775e-02f, -4.13178951e-02f, 3.02942935e-02f, 2.53155604e-02f, 6.09072596e-02f, -1.29624996e-02f, 1.76519826e-02f, 1.34668332e-02f, -3.30548957e-02f, 1.20937324e-03f,
  -8.50579608e-03f, -3.33879218e-02f, 8.97769406e-02f, 1.38880461e-02f, -1.77927017e-02f, -2.04619989e-02f, -1.51009373e-02f, -6.53779060e-02f, 9.82146710e-03f, -5.75878136e-02f,
  2.01267853e-01f, -2.52257019e-01f, 1.83445796e-01f, 5.04523795e-03f, 1.66888349e-02f, -7.23589882e-02f, 4.82473746e-02f, -5.13060056e-02f, -1.09749064e-02f, 3.42507660e-02f,
  -8.94597396e-02f, -1.33330291e-02f, -2.76608244e-02f, 4.21779379e-02f, 6.80720955e-02f, -3.25096548e-02f, -7.83113670e-03f, 4.54668216e-02f, -4.02093790e-02f, 5.45313805e-02f,
  4.00267467e-02f, 6.35340437e-02f, 1.26387943e-02f, 7.69962594e-02f, 8.57903361e-02f, 4.10619751e-02f, -7.72817060e-03f, 4.58213128e-02f, -1.14616528e-01f, 2.52738208e-01f,
  7.99302936e-01f, 1.96666613e-01f, 9.58832130e-02f, 1.86129168e-01f, -2.31511131e-01f, 1.37971088e-01f, 3.71517599e-01f, 1.77489221e-01f, -3.29654552e-02f, 1.65754184e-01f,
  -1.80047795e-01f, -2.99716324e-01f, -2.29041636e-01f, -2.23718464e-01f, 2.56713152e-01f, 2.91177034e-01f, 1.15940668e-01f, 1.92258596e-01f, -7.47253969e-02f, -1.18111350e-01f,
  -3.08028370e-01f, 1.01278044e-01f, 1.90960377e-01f, -6.37896582e-02f, 1.71435680e-02f, -2.01331064e-01f, 1.58576131e-01f, 5.30523099e-02f, -6.84613585e-02f, 1.18117064e-01f,
  5.77740669e-02f, 2.68578947e-01f, -1.63050830e-01f, -1.05098315e-01f, -1.20837301e-01f, 1.41645864e-01f, 9.19545442e-02f, 7.38467649e-02f, -8.42851773e-02f, 6.13312721e-02f,
  -9.33737531e-02f, -7.71187842e-02f, -2.91372351e-02f, -3.22927870e-02f, 1.05554335e-01f, 5.80749698e-02f, 3.89440767e-02f, 1.85444444e-01f, 9.60161090e-02f, 5.73087111e-03f,
  -1.97407737e-01f, -1.12341531e-01f, 4.38953005e-02f, 1.75533851e-03f, 1.11121401e-01f, -1.19565658e-01f, 1.10767214e-02f, 6.78711524e-03f, 1.95566695e-02f, 3.23359430e-01f,
  -2.87410319e-02f, 1.14380829e-02f, -3.71679813e-02f, 5.00463657e-02f, -5.92470076e-03f, -1.90420058e-02f, 1.42677370e-02f, -1.80766862e-02f, 1.31378341e-02f, 5.49125075e-02f,
  -8.09891382e-04f, 1.48085821e-02f, -1.39636286e-02f, 8.16869289e-02f, -8.74305218e-02f, 4.86899093e-02f, -7.68577633e-03f, 4.97478060e-02f, -8.09623227e-02f, 1.32324947e-02f,
  5.26398513e-03f, -3.77185307e-02f, 2.54710037e-02f, -4.24432568e-02f, -3.19743454e-02f, 3.08829434e-02f, 4.61725853e-02f, -1.17600616e-02f, 4.74028923e-02f, 6.94504753e-02f,
  7.92708993e-02f, -2.18281433e-01f, 1.00187913e-01f, 2.19420698e-02f, 9.32224561e-03f, -6.86722100e-02f, -4.88555208e-02f, -9.99221280e-02f, -6.77839592e-02f, 5.68940938e-02f,
  -3.48363854e-02f, 6.79780990e-02f, 5.37178628e-02f, -3.60371321e-02f, -2.01910920e-02f, -2.60931291e-02f, -3.29814106e-03f, -5.13452180e-02f, -3.98666412e-02f, 3.90305393e-03f,
  1.47770550e-02f, 6.25150651e-02f, 1.54895723e-01f, 4.85329591e-02f, -1.90187469e-02f, 7.61547387e-02f, 9.55188125e-02f, 4.70717810e-02f, 1.48135647e-01f, 3.61740977e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.79360044e-01f, 1.86909392e-01f, -4.92797866e-02f, -5.05819082e-01f, -2.37326235e-01f, -4.79274094e-02f, 9.75280851e-02f, -4.82128933e-02f, -1.69888824e-01f, -2.01826822e-02f,
  1.28080785e-01f, -1.53969675e-01f, -1.63039014e-01f, 1.09262113e-03f, -8.21394771e-02f, 1.29069155e-02f, -3.40344489e-01f, -4.51379448e-01f, -3.54993135e-01f, -1.44383073e-01f,
  -2.93251693e-01f, -4.96967554e-01f, -5.64517200e-01f, -3.05287689e-01f, -2.32302099e-02f, -9.97064412e-02f, 2.89753918e-02f, -1.35272920e-01f, 5.06254956e-02f, -8.99951532e-02f,
  4.64288682e-01f, -1.12622477e-01f, -1.01839036e-01f, -2.34572545e-01f, -2.47067325e-02f, -2.89048776e-02f, -6.64971117e-03f, -1.18342482e-01f, -3.46186385e-02f, 1.26877218e-04f,
  -1.39969587e-01f, -8.40042233e-02f, -4.32317331e-02f, -4.67660539e-02f, -7.94522166e-02f, 2.24648300e-03f, -7.73921832e-02f, -1.70920625e-01f, 6.21000044e-02f, 2.38120213e-01f,
  6.52135611e-02f, -1.39485419e-01f, -6.63008494e-03f, 2.89678186e-01f, 1.67787001e-01f, -2.16609940e-01f, 2.47482881e-01f, 1.85227558e-01f, 1.22307546e-01f, 2.77355999e-01f,
  3.19686346e-02f, 1.35893077e-01f, 1.34931775e-02f, -1.55138364e-03f, -5.55162691e-02f, 1.29232125e-04f, 1.12574443e-03f, 2.72952095e-02f, -2.04375232e-04f, 1.80498958e-02f,
  3.35850008e-02f, 1.07436858e-01f, 6.11078627e-02f, -1.00057520e-01f, 2.66095027e-02f, -2.29474325e-02f, -6.41932413e-02f, 1.10323459e-01f, 4.03688923e-02f, -8.75148848e-02f,
  1.58683080e-02f, 6.70007020e-02f, -1.54759949e-02f, 8.95489231e-02f, 1.60667747e-02f, -7.11025670e-02f, -7.04983249e-02f, 3.96251120e-02f, -4.56130356e-02f, -8.99734050e-02f,
  2.90148556e-01f, -2.01250002e-01f, -7.50134811e-02f, -9.79296789e-02f, -3.52551751e-02f, -2.97582969e-02f, 1.23286113e-01f, 3.77850458e-02f, -9.68459696e-02f, -1.42784640e-02f,
  6.86676204e-02f, -3.33807766e-02f, -4.25095856e-02f, 7.51982331e-02f, -1.93106905e-02f, -5.18149771e-02f, -7.93102607e-02f, -7.64918700e-02f, -1.79924779e-02f, 1.10037483e-01f,
  6.34155571e-02f, -1.26057044e-01f, -1.42070487e-01f, 9.40209329e-02f, 6.62253797e-02f, -1.85434356e-01f, 1.83272600e-01f, 2.19991580e-01f, 5.64575493e-02f, 1.61123842e-01f,
  4.71692652e-01f, -7.54640520e-01f, 3.69229376e-01f, -1.65732384e-01f, 1.10171877e-01f, 1.43810824e-01f, -2.09019512e-01f, -8.73862058e-02f, -7.51066860e-03f, -2.16745794e-01f,
  -3.44708532e-01f, 1.87455565e-02f, 3.68478745e-02f, -1.80433039e-02f, 6.52061850e-02f, -1.48894498e-02f, 1.42253101e-01f, 4.41688985e-01f, 6.22406602e-01f, 6.15828000e-02f,
  -1.91738725e-01f, -1.18327245e-01f, 9.57506374e-02f, 1.29023299e-03f, -3.80613655e-01f, 8.99208412e-02f, -1.56749994e-01f, -2.14030862e-01f, -1.36372954e-01f, -2.05545470e-01f,
  -7.44191557e-02f, -2.24659756e-01f, 1.90351531e-01f, 3.74364145e-02f, -2.04905257e-01f, 7.40971267e-02f, 8.47646035e-03f, -5.30098099e-03f, -4.20939643e-03f, -1.37841925e-01f,
  -1.89769380e-02f, 1.19776474e-02f, -7.69860074e-02f, -1.53611585e-01f, 2.47952901e-02f, -4.55963053e-02f, -2.54906528e-02f, 6.77938089e-02f, 5.25511019e-02f, -7.44531974e-02f,
  -1.71825364e-01f, 1.10604940e-02f, 1.69359241e-02f, 1.30649269e-01f, 1.54122859e-01f, 3.11987132e-01f, -1.40361488e-01f, 3.97441387e-02f, 2.11599603e-01f, -2.34164655e-01f,
  -6.71000108e-02f, 6.07145540e-02f, 6.59956504e-03f, -4.20531221e-02f, 2.85653938e-02f, 5.67381158e-02f, -4.89540286e-02f, -9.45238769e-03f, 1.05170975e-03f, -2.17378922e-02f,
  -5.22396378e-02f, 1.07965440e-01f, -1.94491576e-02f, 1.25092920e-02f, 3.73629993e-03f, -2.67550237e-02f, 7.25595206e-02f, -1.60659432e-01f, 5.08150235e-02f, 3.82703636e-03f,
  5.07289581e-02f, 1.04288809e-01f, -8.22126344e-02f, -8.82272199e-02f, -2.24280022e-02f, 5.95268086e-02f, 3.88896465e-02f, 1.68697927e-02f, -7.69264763e-03f, 6.60062507e-02f,
  -4.07167673e-01f, 6.50883019e-01f, -7.28451386e-02f, -1.01623103e-01f, 4.32319045e-02f, -7.09989443e-02f, -2.96175312e-02f, -4.88957018e-02f, -1.14015676e-01f, -5.92994653e-02f,
  -6.89802393e-02f, 3.75787318e-02f, -1.62070692e-01f, -4.09953222e-02f, 7.39260763e-02f, 1.79248694e-02f, -1.04751691e-01f, 1.44516602e-01f, 3.66521440e-02f, -9.22876671e-02f,
  -2.42634624e-01f, 2.37909213e-01f, 2.05684841e-01f, 1.70160726e-01f, 2.92508975e-02f, 4.17609423e-01f, 9.25875176e-03f, 1.63040636e-03f, 2.95163244e-01f, -1.22022837e-01f,
  1.01339746e+00f, 5.01950920e-01f, 9.34132636e-02f, 2.33802736e-01f, 9.93711054e-02f, 5.68787456e-02f, 3.11902985e-02f, -1.29449949e-01f, 1.48189701e-02f, 1.32927552e-01f,
  5.06210208e-01f, 3.46544594e-01f, 1.38146177e-01f, 2.22365074e-02f, -7.37059638e-02f, -2.15223715e-01f, -3.50127816e-01f, -1.20204158e-01f, -1.38634220e-01f, 9.40863118e-02f,
  -3.16641517e-02f, 3.81911173e-02f, 1.56893373e-01f, -8.10951665e-02f, 8.60862434e-02f, 4.50988896e-02f, 7.01865368e-03f, 1.02711096e-01f, 1.17342986e-01f, 1.66996956e-01f,
  3.92519802e-01f, 5.90338767e-01f, -2.87589580e-01f, 3.77223231e-02f, 2.02110857e-02f, -3.88002247e-02f, 3.12658362e-02f, -6.74152002e-02f, -7.16138631e-02f, -8.67071599e-02f,
  3.44689377e-02f, 4.49996591e-02f, 7.05816001e-02f, -1.02219380e-01f, -1.40679320e-02f, -1.69360321e-02f, -1.82258397e-01f, -3.06429379e-02f, -9.74091738e-02f, 3.24162329e-03f,
  1.10921137e-01f, 1.87117562e-01f, 1.83195248e-01f, -1.00165173e-01f, 4.02142256e-02f, 1.34519607e-01f, 6.36091158e-02f, 7.09093735e-02f, -3.21989059e-02f, 5.65313138e-02f,
  1.33063579e-02f, 1.66793346e-01f, 1.25479177e-01f, 2.89662480e-02f, 8.99648294e-02f, -6.83877021e-02f, 1.75111108e-02f, 4.07984667e-03f, -5.94337098e-02f, 1.08818570e-03f,
  -2.47417856e-02f, 1.11410301e-02f, -6.33691549e-02f, 8.80497843e-02f, -1.75160654e-02f, 5.60661368e-02f, -4.25538495e-02f, -2.12041251e-02f, 2.59494931e-02f, 3.45259085e-02f,
  7.83953443e-02f, -6.70211166e-02f, 3.86710912e-02f, -6.73562735e-02f, -1.42287067e-03f, 8.17565247e-02f, -7.87843578e-03f, 1.97618883e-02f, 5.03477007e-02f, -1.74555671e-03f,
  -3.22270811e-01f, -8.04920271e-02f, 4.25446173e-03f, -5.18169142e-02f, 5.30191958e-02f, -8.04414824e-02f, 1.45908624e-01f, 1.05766281e-02f, 6.67783916e-02f, -1.05959594e-01f,
  5.83766140e-02f, 2.17830855e-03f, 8.10252130e-02f, -7.49124810e-02f, -1.40290573e-01f, -1.92501217e-01f, 3.92653421e-03f, 6.67392239e-02f, -1.32659853e-01f, -3.96015383e-02f,
  -9.34703723e-02f, -1.57356948e-01f, -5.41922152e-02f, -2.40709111e-01f, -1.01415813e-01f, -4.14198637e-02f, -9.76891294e-02f, -1.13390677e-01f, -9.05757174e-02f, -2.37376884e-01f,
  5.56763053e-01f, 3.38863075e-01f, 1.54684752e-01f, 1.48666754e-01f, -4.54033196e-01f, -7.74288416e-01f, -7.90166736e-01f, -2.49684021e-01f, -1.29553434e-02f, 1.06610291e-01f,
  -1.54572949e-01f, -2.10575342e-01f, -1.17442332e-01f, -9.48900506e-02f, -1.81025267e-01f, -4.52955477e-02f, 1.96156815e-01f, 1.83028251e-01f, -1.71805009e-01f, -3.21038485e-01f,
  -7.04633221e-02f, 1.37012750e-01f, 3.73125613e-01f, 1.21341638e-01f, 3.88527438e-02f, 3.17487568e-02f, 2.25060731e-01f, 1.89376578e-01f, 4.24734950e-02f, 5.02150893e-01f,
  1.66523084e-01f, 1.14436010e-02f, -2.58001745e-01f, 1.06940694e-01f, -6.27895817e-02f, 6.81987256e-02f, -1.69681281e-01f, 1.03224538e-01f, -4.89114039e-02f, 2.80876793e-02f,
  -6.46929443e-02f, -3.05625685e-02f, -1.72545582e-01f, -3.45734833e-03f, -2.89338455e-02f, -8.68240744e-02f, 1.31942898e-01f, 1.82860494e-01f, 4.49356949e-03f, -1.00747146e-01f,
  -4.96865734e-02f, -2.07290083e-01f, -1.66604266e-01f, -1.57600686e-01f, -3.89205329e-02f, -1.22765072e-01f, -3.37172784e-02f, 5.84367402e-02f, -1.03905439e-01f, 2.73215234e-01f,
  8.12025294e-02f, -1.83432959e-02f, -2.35962067e-02f, 1.57067459e-02f, 6.95687011e-02f, -2.92895585e-02f, -1.60194226e-02f, -2.22168677e-02f, 1.90961566e-02f, -3.47716920e-02f,
  1.25356894e-02f, 7.57654831e-02f, -1.89346187e-02f, 3.71826887e-02f, 7.69449100e-02f, 1.74815021e-02f, -3.18904556e-02f, 7.25803822e-02f, 1.74268428e-02f, 9.74484812e-03f,
  2.46512182e-02f, -5.71536645e-02f, -2.87478580e-03f, -5.41880541e-02f, 6.18577749e-02f, 4.62435074e-02f, -3.59424390e-02f, 2.87127234e-02f, -2.97845504e-03f, 5.20915305e-03f,
  1.50203593e-02f, -3.17808568e-01f, 4.97022793e-02f, -5.47370911e-02f, -2.24891808e-02f, 4.34445329e-02f, 3.16263363e-02f, 1.00323133e-01f, -4.46535610e-02f, -4.15009037e-02f,
  -1.67971179e-01f, -2.54701637e-02f, -8.61972496e-02f, -3.81791545e-03f, -1.37466177e-01f, -8.17438215e-02f, 6.13369569e-02f, -1.55471489e-02f, -1.12854704e-01f, 9.59007367e-02f,
  1.48056641e-01f, -1.23647079e-01f, -1.11007422e-01f, -7.50355422e-02f, -1.06203042e-01f, -1.65356234e-01f, -1.21354908e-01f, -1.29430011e-01f, -1.98018208e-01f, 2.80599058e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.96452057e-01f, 7.62211323e-01f, 3.73475224e-01f, 7.38885462e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.67639947e-01f, -1.64763176e+00f, 4.05226082e-01f, 6.50068462e-01f, -3.85041028e-01f, -1.10972726e+00f, 1.12511683e+00f, -4.06221569e-01f, 1.75486535e-01f, 2.48909980e-01f,
  -7.14596093e-01f, -3.84061635e-01f, 6.36606157e-01f, 8.39861557e-02f, -3.37700248e-01f, -4.53639388e-01f, -7.95427978e-01f, -6.58655286e-01f, 4.26246464e-01f, -1.05633689e-02f,
  3.86510044e-02f, 7.29146183e-01f, 8.68219256e-01f, 7.86019742e-01f, -6.06312990e-01f, -6.86551690e-01f, -4.97216403e-01f, 2.49981523e-01f, -2.63487875e-01f, 1.11725545e+00f,
  1.02413130e+00f, -5.13478577e-01f, 1.02274589e-01f, 8.24407637e-01f, -3.07536930e-01f, 5.10053456e-01f, 5.99686801e-01f, 2.38026276e-01f, 3.92201692e-01f, 9.01170634e-03f,
  1.08187497e+00f, 5.84797442e-01f, 1.52472079e-01f, -9.64791477e-01f, -6.67838573e-01f, 5.72038293e-01f, -9.27061915e-01f, 5.84256947e-01f, -2.10895404e-01f, 7.74122119e-01f,
  3.21326017e-01f, 3.20282876e-01f, -8.79824400e-01f, -7.09614456e-01f, -1.19788182e+00f, 6.14065766e-01f, 5.08560777e-01f, -6.67566240e-01f, -3.44464839e-01f, -3.96812409e-01f,
  7.60299325e-01f, 2.25466654e-01f, -5.07228374e-01f, -7.57589757e-01f, 4.31416631e-01f, 8.24821666e-02f, 1.65220559e-01f, -3.61801684e-01f, -8.39165598e-02f, -3.94521117e-01f,
  -2.91211475e-02f, 8.27123880e-01f, -4.22524542e-01f, 1.36971796e+00f, -4.46704239e-01f, -4.47893739e-01f, 7.26291180e-01f, -5.36653817e-01f, -1.42672202e-02f, 3.77110898e-01f,
  3.37115765e-01f, -1.91073995e-02f, -5.58133088e-02f, 4.74534750e-01f, 4.29331541e-01f, 4.81274813e-01f, 6.90336525e-01f, 1.32400846e+00f, -1.22275436e+00f, -8.69865656e-01f,
  5.74856699e-01f, 1.07843244e+00f, 8.18484873e-02f, -4.45581228e-01f, -1.12982132e-01f, 4.80337024e-01f, 6.92621842e-02f, -1.58930030e-02f, -6.76871359e-01f, -3.93994510e-01f,
  -3.12637895e-01f, -3.15706909e-01f, -1.29289806e-01f, -7.18951166e-01f, 4.76069093e-01f, 6.96387470e-01f, 5.74004829e-01f, 1.33643079e+00f, -6.07126713e-01f, -5.69774806e-01f,
  9.06693935e-02f, 1.03677404e+00f, 1.29779607e-01f, -3.04961622e-01f, -2.44904950e-01f, -3.04971963e-01f, -1.10589063e+00f, 2.67404914e-01f, -1.27394772e+00f, -9.66020525e-01f,
  1.03306711e+00f, -1.35914254e+00f, 1.02459610e+00f, -7.16699302e-01f, -4.86483455e-01f, -1.63434654e-01f, 1.05882533e-01f, -4.51273590e-01f, 4.11042213e-01f, 4.74080533e-01f,
  -4.84873652e-02f, -3.06075573e-01f, 2.51635909e-01f, -3.88294935e-01f, -5.99900901e-01f, -7.37494349e-01f, -7.29467750e-01f, -7.43503869e-01f, 4.69257891e-01f, 7.85652399e-01f,
  -7.26228833e-01f, 1.16149652e+00f, -3.35604191e-01f, -6.06684387e-01f, 2.45677873e-01f, 1.12182051e-01f, 6.42463028e-01f, -6.37184262e-01f, -2.26234481e-01f, 8.91157985e-01f,
  -2.67415075e-03f, 2.81945705e-01f, -4.87045377e-01f, 9.03568864e-01f, 7.70755053e-01f, -1.16228461e+00f, -7.01219797e-01f, -5.37551403e-01f, 5.32736421e-01f, 6.84569120e-01f,
  -2.67875850e-01f, 2.20916003e-01f, -7.80477643e-01f, -4.65970367e-01f, 3.56673121e-01f, 6.14840031e-01f, 3.75054747e-01f, -1.28815639e+00f, -6.84132755e-01f, -7.20332503e-01f,
  -2.80708104e-01f, 5.55305853e-02f, 8.79315436e-01f, -5.06448150e-01f, -3.11329812e-01f, -4.58007872e-01f, -1.21558905e+00f, 5.23181736e-01f, 1.20201297e-01f, 2.17394859e-01f,
  7.02462256e-01f, -6.33394271e-02f, -1.17019570e+00f, -3.74514371e-01f, 6.36386096e-01f, 6.36310458e-01f, -7.78892756e-01f, 9.15831447e-01f, -2.34742284e-01f, 5.23123033e-02f,
  7.48804748e-01f, -3.90866935e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.74585826e-03f, -7.11096674e-02f, -1.24810353e-01f, -1.56535104e-01f, -4.15611684e-01f, 4.26582456e-01f, -6.52404502e-02f, 6.94847047e-01f, 1.16914874e-02f, -1.97563142e-01f,
  -3.22233438e-01f, -6.19145518e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    