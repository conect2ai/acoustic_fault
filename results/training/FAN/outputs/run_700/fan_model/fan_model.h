/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.98804781e-02f, 1.43503875e-01f, -1.04673468e-01f, -1.37957096e-01f, 6.02284307e-03f, -2.42576264e-02f, 3.68233062e-02f, -4.55155596e-02f, -1.76065102e-01f, -3.22720334e-02f,
  1.31229669e-01f, -1.70376629e-01f, -1.39588326e-01f, -6.87662512e-02f, -6.67306483e-02f, -2.79158559e-02f, 1.50098726e-02f, -1.85867831e-01f, -3.60571593e-01f, -2.43409768e-01f,
  -1.28942251e-01f, -1.33457452e-01f, -1.05806209e-01f, -1.52457267e-01f, -1.04381908e-02f, -1.39197409e-01f, -5.74007332e-02f, -1.11752361e-01f, 7.79279647e-03f, -3.65657918e-02f,
  -1.71271443e-01f, 1.17771678e-01f, -2.73387998e-01f, -9.71034020e-02f, -1.18667468e-01f, -9.89963040e-02f, -9.46997330e-02f, -8.72353241e-02f, -8.19813833e-02f, -9.20835882e-02f,
  -1.07526362e-01f, -3.02479230e-02f, -1.07419260e-01f, -1.21434651e-01f, -2.05106407e-01f, -2.19191790e-01f, -1.67937219e-01f, -1.78488269e-01f, -1.49201632e-01f, -1.27618328e-01f,
  -1.04149334e-01f, -1.06966138e-01f, -9.27555840e-03f, -1.31782323e-01f, -2.24147320e-01f, -2.01234430e-01f, -2.70792022e-02f, -1.36548549e-01f, -1.55469701e-01f, -2.43499756e-01f,
  -5.37736900e-03f, 6.22604899e-02f, 1.87151209e-01f, 6.52216375e-02f, 5.29520437e-02f, 1.21880472e-01f, 1.01207390e-01f, 8.16278011e-02f, 8.04968104e-02f, 4.10078913e-02f,
  7.77547956e-02f, -5.11593325e-03f, 6.05023317e-02f, 4.58648205e-02f, 6.14388026e-02f, 1.23283096e-01f, -1.04427757e-03f, 1.17872700e-01f, 9.09027755e-02f, 5.27495444e-02f,
  3.53634879e-02f, 3.15228701e-02f, 4.10929322e-02f, -1.26944678e-02f, 1.89669710e-02f, 2.61551049e-02f, 5.27260117e-02f, 3.46900448e-02f, 5.51822186e-02f, 9.11202282e-02f,
  -2.28205115e-01f, -6.64862022e-02f, -2.22997233e-01f, -2.29200542e-01f, -2.03682661e-01f, -1.87284768e-01f, -1.86049655e-01f, -1.47992626e-01f, -1.62012368e-01f, -2.18822822e-01f,
  -8.07228312e-02f, -1.49382398e-01f, -1.73803419e-01f, -1.79069430e-01f, -2.40279824e-01f, -2.12551206e-01f, -1.96030602e-01f, -2.37808868e-01f, -2.72270948e-01f, -1.86603233e-01f,
  -1.70697674e-01f, -1.86519638e-01f, -2.77401745e-01f, -2.53674448e-01f, -2.46019840e-01f, -2.90191770e-01f, -2.66835392e-01f, -3.04265708e-01f, -2.99007446e-01f, -2.23842695e-01f,
  3.58597785e-01f, -7.25919232e-02f, -3.00755799e-01f, 1.22784168e-01f, -2.41469875e-01f, -2.22409487e-01f, -2.97038436e-01f, 1.23822935e-01f, 9.93501991e-02f, 1.53770233e-02f,
  1.08519427e-01f, 2.80200928e-01f, 6.62866309e-02f, 1.39180481e-01f, -6.96223229e-02f, -2.18810722e-01f, -1.59385189e-01f, -5.31173907e-02f, 3.11086606e-02f, 1.66743412e-03f,
  -5.20153306e-02f, 5.33540621e-02f, 8.71190578e-02f, 1.11247629e-01f, 6.34176806e-02f, 1.43162221e-01f, -6.05787262e-02f, 2.79417541e-02f, -9.56095979e-02f, -7.89334550e-02f,
  1.70051724e-01f, 6.33190200e-02f, 4.07442003e-02f, 4.91525903e-02f, 1.37490496e-01f, 1.37179166e-01f, 9.87899974e-02f, 5.78197166e-02f, 8.79765376e-02f, 1.41090095e-01f,
  6.44446537e-02f, 1.33970723e-01f, 3.24980393e-02f, 9.99057144e-02f, 1.54994488e-01f, 1.39727131e-01f, 4.97462675e-02f, 2.68553756e-02f, 1.38324201e-01f, 2.06118692e-02f,
  -2.00465210e-02f, -8.96410830e-03f, -7.00224563e-02f, 6.44762367e-02f, 1.88597143e-02f, 5.81511557e-02f, -2.28125025e-02f, 1.92669611e-02f, 1.25544503e-01f, 2.42961153e-01f,
  -4.88690622e-02f, 2.25266106e-02f, -6.85253218e-02f, -3.98751497e-02f, -4.04724069e-02f, 4.76802979e-03f, -1.15781911e-01f, -2.30769962e-02f, -8.49402472e-02f, -4.18309383e-02f,
  -6.23355992e-02f, -1.09212145e-01f, 5.52973934e-02f, -5.62108941e-02f, 2.09650472e-02f, -1.47447377e-01f, -4.77736518e-02f, 2.20623612e-02f, -3.13101709e-02f, -2.68648565e-02f,
  4.03220281e-02f, 1.46057205e-02f, 2.27579065e-02f, -6.63186461e-02f, -4.39950898e-02f, -7.71209821e-02f, -1.02984523e-02f, -7.27383606e-03f, -2.35960446e-02f, 3.31934616e-02f,
  2.65622526e-01f, -1.70293957e-01f, 1.78855479e-01f, 1.55877069e-01f, 2.41921451e-02f, 4.03796472e-02f, 1.17955036e-01f, -5.95713034e-03f, 8.42775702e-02f, 6.22806698e-02f,
  8.20144340e-02f, 1.08237237e-01f, 4.57949080e-02f, 5.26026171e-03f, 1.13403007e-01f, 1.17420770e-01f, 7.47516677e-02f, 6.56270161e-02f, 8.20307210e-02f, 6.72479719e-02f,
  3.11415661e-02f, 3.37329917e-02f, 1.14507504e-01f, 6.03718795e-02f, 1.68584689e-01f, 7.70449862e-02f, 9.96916671e-04f, 1.46215320e-01f, -1.75649673e-02f, 1.99785218e-01f,
  2.88120806e-02f, 1.92965120e-01f, 2.41281260e-02f, 5.22427075e-02f, 2.13187672e-02f, -1.01959005e-01f, -1.27960108e-02f, -6.00538515e-02f, 2.15587467e-02f, -2.46068742e-03f,
  7.94415325e-02f, -1.94319934e-01f, -1.69463336e-01f, -6.29967079e-02f, -7.90502504e-02f, 2.70642955e-02f, 5.56967370e-02f, -8.13977495e-02f, -2.04591796e-01f, -1.98365282e-02f,
  5.36452755e-02f, 3.89650017e-02f, 5.20611368e-02f, -1.01415135e-01f, 5.28670512e-02f, -9.29393172e-02f, 1.41900703e-01f, 1.37380645e-01f, 4.99236919e-02f, 2.63591677e-01f,
  -8.35770369e-02f, 3.30531329e-01f, -9.28954110e-02f, 6.50646463e-02f, 9.45787504e-03f, -3.75828817e-02f, -1.09452561e-01f, 1.00623734e-01f, 5.55762276e-02f, 2.47737300e-02f,
  -2.72797458e-02f, -1.12561630e-02f, -8.49873647e-02f, -5.47615066e-02f, 6.02300186e-03f, 1.71184428e-02f, 3.33082192e-02f, 5.54021560e-02f, -6.25884309e-02f, -4.07179631e-02f,
  1.13944663e-02f, 9.58996937e-02f, 1.11944433e-02f, -1.01166554e-02f, -4.20126282e-02f, -1.43457074e-02f, 3.65666561e-02f, -1.10090226e-02f, 4.38699014e-02f, 1.03143916e-01f,
  -5.58856223e-03f, -7.48781115e-02f, -3.74049023e-02f, 1.48450220e-02f, 6.27443418e-02f, -5.28525896e-02f, -1.55077809e-02f, 6.90429285e-02f, -1.04069024e-01f, -1.46313487e-02f,
  3.90675329e-02f, 3.19867618e-02f, 6.21710271e-02f, -2.84412391e-02f, 1.54718170e-02f, 4.68337983e-02f, -4.28516492e-02f, 4.76825237e-02f, -2.20484417e-02f, 3.46278511e-02f,
  5.11262985e-03f, 1.37456864e-01f, 6.44959286e-02f, 3.56225036e-02f, 1.44696757e-01f, 9.40693542e-03f, -2.53982912e-03f, -2.00291965e-02f, 4.49843220e-02f, -1.47632407e-02f,
  -1.08011834e-01f, 8.35122988e-02f, -1.10379077e-01f, -5.07928766e-02f, 1.26457084e-02f, -6.84432015e-02f, -9.15801749e-02f, -4.65528183e-02f, 5.37012843e-03f, -4.58102338e-02f,
  9.56719220e-02f, -5.29213957e-02f, 6.46714792e-02f, -2.06807088e-02f, -5.70822787e-03f, -5.91846853e-02f, -2.90953945e-02f, -5.21234497e-02f, -1.01142205e-01f, -7.34388158e-02f,
  3.26181091e-02f, -1.21759385e-01f, -7.41438568e-02f, -2.35934779e-02f, -5.97969815e-02f, -7.58828223e-02f, -5.27279302e-02f, -6.99994713e-02f, -1.74419850e-01f, -7.35095888e-02f,
  -2.65873402e-01f, -3.48355845e-02f, -3.61537151e-02f, 2.37675048e-02f, 6.17018938e-02f, -9.23123583e-02f, -3.12294345e-02f, 3.10979020e-02f, 2.40492146e-03f, 7.61886686e-02f,
  -2.15275921e-02f, -3.76630314e-02f, -1.05385147e-01f, 1.30415829e-02f, -1.44189119e-01f, 6.17599934e-02f, 1.74012527e-01f, -7.40973651e-02f, -8.90092924e-02f, -1.62312749e-03f,
  -6.82896585e-04f, 1.22949094e-01f, -2.59869383e-03f, 1.06747048e-02f, 6.99096024e-02f, -1.65625953e-03f, -1.19364159e-02f, 3.70812230e-02f, -8.87232870e-02f, 1.26102552e-01f,
  -3.01628143e-01f, -3.20397504e-02f, -7.72458389e-02f, -1.31171383e-02f, -1.33721530e-01f, -5.54349869e-02f, -7.07760155e-02f, -6.58162013e-02f, -1.05326943e-01f, 4.61865105e-02f,
  6.01911172e-02f, 5.51546775e-02f, -2.27774773e-02f, -6.71011657e-02f, 6.03683256e-02f, -5.31221032e-02f, 5.01579344e-02f, -7.48499036e-02f, 7.32576400e-02f, -1.14359438e-01f,
  -4.42566201e-02f, 5.66024929e-02f, 1.35906208e-02f, 5.56161907e-03f, 4.13140990e-02f, -1.04672993e-02f, -9.32263508e-02f, 3.41160372e-02f, -1.53614596e-01f, -1.06079988e-02f,
  -7.10444450e-02f, 7.69256726e-02f, -1.39525691e-02f, 5.81962243e-02f, -2.59694154e-03f, 2.28127539e-02f, 4.06470187e-02f, 1.43834025e-01f, 3.14298868e-02f, 7.43479207e-02f,
  8.84075910e-02f, -2.45282166e-02f, 1.14811234e-01f, 5.85396737e-02f, -1.62493438e-02f, 8.43037814e-02f, -4.98161372e-03f, 8.74143746e-03f, 7.22232834e-02f, 1.14151118e-02f,
  3.81146930e-02f, 8.38874206e-02f, -2.60806009e-02f, 6.96564466e-02f, -4.46595214e-02f, 7.01912418e-02f, 9.78691131e-02f, 3.49401794e-02f, -2.43847556e-02f, 3.69756632e-02f,
  -1.77352682e-01f, -9.29070711e-02f, -1.10522397e-01f, -1.06575200e-02f, -2.12317090e-02f, -1.64737515e-02f, -4.25263718e-02f, -2.62578614e-02f, -1.58609822e-02f, -1.49998307e-01f,
  -1.32013798e-01f, -4.89048697e-02f, -4.22568172e-02f, -6.15495071e-02f, -3.39236520e-02f, -2.07595731e-04f, -5.96918687e-02f, -9.05493367e-03f, -8.45600218e-02f, 1.86262541e-02f,
  -1.69832055e-02f, -5.85676879e-02f, -1.20187514e-01f, -1.44108936e-01f, -3.46207898e-03f, -2.41753444e-01f, -1.90176904e-01f, -3.94802578e-02f, -2.43388221e-01f, -2.19043747e-01f,
  -2.99748689e-01f, 8.33051875e-02f, 1.55547068e-01f, 4.84747477e-02f, 1.90505221e-01f, -3.95185202e-02f, 1.44968852e-01f, -8.13352987e-02f, -1.11128725e-01f, 1.09054185e-01f,
  -8.22020620e-02f, -1.47464290e-01f, -1.36357084e-01f, -8.89001265e-02f, -9.95400026e-02f, 1.43286526e-01f, 1.88746676e-01f, -5.95384538e-02f, -1.90186039e-01f, -1.50465116e-01f,
  2.22057123e-02f, 1.13296703e-01f, -2.34991703e-02f, -1.16913198e-02f, 1.24022044e-01f, 6.37428388e-02f, 8.14058557e-02f, 1.65691182e-01f, 1.01834692e-01f, 3.30888182e-01f,
  -1.41915664e-01f, 3.10579175e-03f, 4.89704125e-02f, -2.19828635e-02f, 3.71912569e-02f, -1.21121533e-01f, -2.79219020e-02f, 1.99523345e-02f, 2.67067663e-02f, 9.75679513e-03f,
  1.33268952e-01f, 8.16188157e-02f, -6.96335882e-02f, 5.62020093e-02f, 9.19396281e-02f, -6.10501831e-03f, 5.35554364e-02f, 7.63663575e-02f, -2.93743219e-02f, -5.71752749e-02f,
  8.18506032e-02f, 2.85232086e-02f, -2.77797747e-02f, 3.90169732e-02f, 7.67533928e-02f, 5.56133278e-02f, -2.24542152e-02f, 7.78181553e-02f, 9.80035290e-02f, 1.22084804e-01f,
  -1.67798493e-02f, 9.40841883e-02f, 6.43193861e-03f, 6.51123449e-02f, 5.88692687e-02f, -2.07703430e-02f, 9.17484984e-02f, 5.24614751e-02f, -6.33560643e-02f, -2.81167906e-02f,
  -5.73258400e-02f, -2.68539321e-02f, 5.29903062e-02f, 3.24196853e-02f, 5.03965542e-02f, -9.29499418e-03f, 4.52707708e-02f, -3.46872583e-03f, -4.18026559e-02f, -2.11485941e-02f,
  -1.31414846e-01f, 4.30176966e-02f, 7.71883205e-02f, -2.31039915e-02f, 3.68926786e-02f, 1.57115199e-02f, -3.24880332e-02f, -8.96505918e-03f, -3.27615403e-02f, -2.55616140e-02f,
  -5.13928793e-02f, -7.53327683e-02f, 6.23129979e-02f, 7.03321677e-03f, 6.04390427e-02f, 6.58628717e-02f, 3.13724531e-03f, -2.67102774e-02f, 2.45408583e-02f, 4.47200872e-02f,
  -1.71624625e-03f, -5.75742535e-02f, -2.09040530e-02f, 2.62469910e-02f, 9.96685624e-02f, 5.45069538e-02f, 3.25923972e-02f, 3.86320315e-02f, -9.67480522e-03f, -8.05175956e-03f,
  1.17102183e-01f, 4.54354174e-02f, -6.18445836e-02f, -6.02616146e-02f, -2.77499370e-02f, -3.33466306e-02f, -2.92762499e-02f, 2.12201644e-02f, 1.75251924e-02f, 3.17257643e-02f,
  -7.86639303e-02f, 7.78326318e-02f, 1.76465362e-01f, -1.25020087e-01f, -7.83252120e-02f, -6.73675463e-02f, 1.00200385e-01f, -1.17841326e-01f, -1.37452513e-01f, -1.77917723e-03f,
  -1.91736683e-01f, -2.20064357e-01f, -1.87139213e-01f, 7.55891111e-03f, 1.05420262e-01f, 2.55988061e-01f, 1.67611405e-01f, 1.94404408e-01f, -5.27324937e-02f, -7.41609484e-02f,
  -1.52234375e-01f, -1.36461958e-01f, 4.52122465e-02f, -8.32206756e-02f, 9.82648414e-03f, -9.95211489e-03f, 1.07932344e-01f, 6.64490759e-02f, 7.20525235e-02f, 2.25773752e-01f,
  3.05292904e-01f, 1.28646493e-01f, 6.84313402e-02f, 9.12315398e-03f, 8.11038911e-03f, 1.40847847e-01f, 9.95208770e-02f, 7.16632903e-02f, 3.15410197e-02f, 4.85277325e-02f,
  1.00860447e-02f, 1.24862261e-01f, 1.01748534e-01f, 8.68952088e-03f, -1.21174380e-02f, 5.12176305e-02f, 1.26121834e-01f, 1.31282136e-01f, 1.76561370e-01f, 1.70928523e-01f,
  1.00090414e-01f, 3.12082022e-02f, 7.50050545e-02f, 4.30570357e-02f, 6.69214055e-02f, -2.99038645e-02f, 1.50668755e-01f, 8.59220549e-02f, 1.19679876e-01f, 2.14124754e-01f,
  -6.88669905e-02f, -1.19921193e-01f, -4.32581082e-02f, -5.79677895e-02f, -1.24374248e-01f, -1.13695018e-01f, -6.89905956e-02f, -8.23639706e-02f, -5.12320250e-02f, -1.10876307e-01f,
  -2.02841803e-01f, -4.63838987e-02f, -1.12521790e-01f, -1.02723278e-01f, -1.18403897e-01f, 5.52347954e-03f, -1.03622943e-01f, -8.63466486e-02f, -1.11724175e-05f, -9.32195317e-03f,
  -3.11681107e-02f, 6.26311498e-03f, -4.56018783e-02f, -9.00755078e-02f, 4.96536829e-02f, -6.04773834e-02f, -1.34378105e-01f, -1.85276061e-01f, -6.40133098e-02f, -1.21296950e-01f,
  -1.45189047e-01f, -5.75142093e-02f, 4.33256365e-02f, 3.95119935e-02f, 8.88556540e-02f, 5.38495854e-02f, 3.36204772e-03f, 3.75189707e-02f, 6.18211441e-02f, 1.08573817e-01f,
  1.22080110e-01f, 2.61996314e-02f, -1.97843909e-02f, 1.84229556e-02f, 1.60449408e-02f, 9.36359167e-02f, 1.38935270e-02f, 7.03587383e-02f, 1.00311756e-01f, 9.45034921e-02f,
  7.05052763e-02f, 9.38653424e-02f, 1.65343639e-02f, 1.02259442e-02f, 3.19949575e-02f, -8.66001397e-02f, -2.00229734e-02f, 1.84372254e-02f, -2.44414750e-02f, 1.29636992e-02f,
  -3.39426845e-01f, 2.44440213e-01f, 2.50944048e-01f, -1.36668488e-01f, 2.85468046e-02f, 3.05719431e-02f, 1.78956866e-01f, -5.02936579e-02f, -2.33890459e-01f, 1.21658005e-01f,
  -1.29612967e-01f, -1.36885867e-01f, -3.88708748e-02f, -1.72558188e-01f, -1.65174901e-01f, 2.27831274e-01f, 2.46422276e-01f, -9.46066249e-03f, -3.44303906e-01f, -2.53140748e-01f,
  -3.91126834e-02f, 4.35863286e-02f, -1.82674631e-01f, -5.84964491e-02f, 7.95516446e-02f, -1.16655186e-01f, 1.66001841e-01f, 1.44823138e-02f, 1.06017083e-01f, 2.79086918e-01f,
  4.45964374e-02f, 2.94658039e-02f, -1.41308263e-01f, -1.28498763e-01f, 1.17470687e-02f, -1.17052175e-01f, -7.35290945e-02f, -3.11330091e-02f, -7.15112910e-02f, -7.67762735e-02f,
  -6.44875690e-02f, -2.63337903e-02f, -1.11380108e-01f, -5.03744036e-02f, -2.35693492e-02f, -8.03508386e-02f, 2.35993955e-02f, -1.18156143e-01f, -2.32249983e-02f, -1.98333021e-02f,
  6.26543313e-02f, 9.73228738e-03f, -4.10750918e-02f, -9.39152911e-02f, -5.42700067e-02f, -9.77218971e-02f, 5.65279908e-02f, -9.02970657e-02f, -6.81871027e-02f, -5.83053846e-03f,
  -4.17417698e-02f, -2.00319607e-02f, 1.01198763e-01f, -5.96960215e-03f, -1.99563988e-02f, 6.35099038e-02f, -8.80344119e-03f, -7.96772190e-04f, -5.29506579e-02f, 5.55871427e-02f,
  1.37322871e-02f, 9.91251227e-03f, 8.11428726e-02f, 2.80750375e-02f, 1.03670713e-02f, 1.36692539e-01f, -5.15864678e-02f, 2.80365329e-02f, 7.11931735e-02f, 1.34432260e-02f,
  1.26645546e-02f, -2.57005598e-02f, 4.22108956e-02f, 1.68500817e-03f, -1.94723178e-02f, 2.67606396e-02f, -8.30841623e-03f, 4.85108122e-02f, 3.53227779e-02f, 7.25085437e-02f,
  -3.00551560e-02f, 3.63402776e-02f, -7.17306584e-02f, -4.52976748e-02f, -4.63442365e-03f, -6.69347718e-02f, -5.00771925e-02f, -1.15175106e-01f, -6.08293377e-02f, -1.28815010e-01f,
  -1.75299257e-01f, -1.34434015e-01f, 2.47211345e-02f, -1.18933566e-01f, -1.44783095e-01f, -1.39119104e-01f, -8.63654837e-02f, -1.98783521e-02f, -1.49820343e-01f, -1.04185984e-01f,
  -6.97661415e-02f, -7.48687759e-02f, -1.08574428e-01f, -9.38971564e-02f, -5.18604368e-02f, -1.37740493e-01f, -1.25584573e-01f, -1.50043428e-01f, -2.00868711e-01f, -7.65116736e-02f,
  -5.66434264e-01f, 9.86455902e-02f, 1.33168951e-01f, -2.15709671e-01f, 4.32126746e-02f, 2.84136087e-03f, 1.69357598e-01f, -8.93595889e-02f, -3.22617851e-02f, 1.82407096e-01f,
  1.17606223e-01f, 1.87231049e-01f, 7.08648115e-02f, 8.43968615e-02f, 2.10058913e-02f, 1.86759219e-01f, 2.15212375e-01f, -5.26805595e-02f, -9.94565934e-02f, 4.29387428e-02f,
  1.52187988e-01f, -1.70346931e-01f, -2.85687745e-01f, -1.62037417e-01f, 5.92015535e-02f, 1.66310430e-01f, 1.33681178e-01f, 3.36213671e-02f, 9.21586603e-02f, 2.61890709e-01f,
  2.16203839e-01f, -6.95362911e-02f, 6.27486408e-02f, 9.75212604e-02f, 1.51364028e-01f, 1.22916987e-02f, 6.21136390e-02f, 1.38432011e-02f, 4.34233882e-02f, 3.40401791e-02f,
  1.09608099e-01f, 1.26585513e-01f, 4.47178259e-02f, 2.93211732e-03f, -5.03424264e-04f, 9.34081823e-02f, -1.98488180e-02f, 9.18095093e-03f, -5.92526188e-03f, 1.28008008e-01f,
  1.40558630e-01f, 1.30773718e-02f, 1.86152607e-02f, 5.53160906e-02f, -2.26689577e-02f, -1.96469463e-02f, 3.57544012e-02f, 2.55624428e-02f, 3.25396731e-02f, -1.43817235e-02f,
  -6.57755882e-02f, -9.18650329e-02f, -7.14438502e-03f, 7.57772550e-02f, 1.02748731e-02f, 1.07053178e-03f, 8.65400359e-02f, 2.89521879e-03f, -1.77024696e-02f, -5.37391752e-02f,
  1.44266903e-01f, 6.31389022e-02f, 1.34523243e-01f, 6.50088582e-03f, 3.30226496e-02f, 2.62443963e-02f, 3.82445380e-02f, 1.80652607e-02f, 6.53053820e-02f, 4.64648716e-02f,
  8.10644478e-02f, 2.24274937e-02f, 3.95036787e-02f, 3.99929322e-02f, 6.28408194e-02f, 4.47725877e-02f, 1.07982725e-01f, -1.21160634e-02f, -3.84114981e-02f, 6.31364062e-02f,
  -5.74272349e-02f, 1.08565353e-01f, 1.33393064e-01f, 8.09741467e-02f, 2.40469980e-03f, -3.72849219e-03f, 7.10854679e-02f, 5.27433753e-02f, 1.30676910e-01f, 6.24701865e-02f,
  1.02639608e-01f, -6.02225261e-03f, 4.12907824e-02f, 5.64700514e-02f, 8.28884467e-02f, 8.06409121e-02f, 1.28370076e-02f, 8.79641343e-03f, 9.94655266e-02f, 7.97821358e-02f,
  -2.68185306e-02f, -3.62013094e-02f, -7.82978013e-02f, 9.49906111e-02f, 1.95256453e-02f, 1.24162965e-01f, 1.44376934e-01f, 1.53461352e-01f, 7.49590918e-02f, 1.02274278e-02f,
  2.21567396e-02f, -1.89742237e-01f, -1.45960763e-01f, -2.47419886e-02f, -1.73897035e-02f, 8.22675079e-02f, 8.70792866e-02f, -2.17504706e-02f, 6.72095492e-02f, -1.27922639e-01f,
  -2.29629297e-02f, -1.53355747e-02f, 5.47244633e-03f, 3.04610152e-02f, 1.17555462e-01f, -2.53863707e-02f, -7.72102699e-02f, -5.52100874e-03f, 2.85318077e-01f, 1.87787637e-01f,
  8.87140445e-03f, -6.60738572e-02f, -3.09988074e-02f, 1.21366151e-01f, -2.09300175e-01f, -1.19639910e-03f, -1.52948543e-01f, -2.47350112e-01f, -2.49054059e-02f, -3.54474515e-01f,
  -1.74440648e-02f, -9.80583727e-02f, 1.46874413e-01f, 7.90054947e-02f, -9.99299958e-02f, -5.22974133e-02f, 3.83866541e-02f, -1.24568082e-01f, 9.68855340e-03f, 3.62140276e-02f,
  -2.16728318e-02f, 6.42203242e-02f, -5.13430499e-02f, -1.06339574e-01f, -8.95229448e-03f, 3.21110934e-02f, -1.00285485e-01f, -7.10056871e-02f, -6.46627471e-02f, -5.22514135e-02f,
  -8.47028121e-02f, -9.47141424e-02f, -1.20256536e-01f, -8.22694898e-02f, -5.35597876e-02f, 1.15896389e-01f, 2.37520109e-03f, -4.55965567e-03f, 8.41229260e-02f, -1.53745785e-01f,
  3.74737270e-02f, 4.14541773e-02f, 2.40765028e-02f, -1.10323150e-02f, 3.82455625e-02f, -7.17552155e-02f, -1.61007105e-03f, 8.66323244e-03f, 4.48184423e-02f, -1.13151647e-01f,
  4.13864106e-02f, -3.28213274e-02f, 1.04291821e-02f, -6.03373311e-02f, -9.60866280e-04f, 1.30218202e-02f, 2.69855279e-03f, 1.52387870e-02f, 3.62504385e-02f, -6.15153015e-02f,
  5.79394847e-02f, 3.94659080e-02f, -6.84446990e-02f, 2.11265404e-02f, 6.32109791e-02f, -3.99461724e-02f, -7.60594904e-02f, -2.25008233e-03f, -1.44371642e-02f, -1.14801280e-01f,
  1.06221559e-02f, 8.91559348e-02f, -9.15598199e-02f, 2.14137007e-02f, -1.01307370e-02f, 1.35387713e-02f, 3.68125737e-02f, 2.28773728e-02f, 3.43624204e-02f, -8.46054219e-03f,
  8.33837092e-02f, 5.18414341e-02f, 7.33431727e-02f, -6.95556775e-02f, 1.44696767e-02f, -4.03116718e-02f, -1.74121689e-02f, -9.65978485e-03f, 8.78366902e-02f, -2.84582507e-02f,
  3.56787145e-02f, 5.26395515e-02f, 1.23682044e-01f, -2.38355231e-02f, 8.43371153e-02f, 1.29140720e-01f, -3.42251966e-03f, -1.66516250e-03f, 1.67538866e-01f, 1.09846339e-01f,
  3.12453896e-01f, -7.76567385e-02f, 7.86004886e-02f, -7.78328255e-02f, -1.34634599e-01f, 1.24543019e-01f, 1.02129273e-01f, 1.22251078e-01f, 4.70036156e-02f, 6.19493201e-02f,
  -2.98593324e-02f, -1.72651429e-02f, -9.39355642e-02f, -2.31876373e-02f, 6.49484247e-02f, -3.20448987e-02f, -1.24390841e-01f, -1.93900988e-02f, 1.80853561e-01f, 1.64021924e-01f,
  -1.20583363e-01f, -6.69438392e-02f, 1.51778623e-01f, 1.39257774e-01f, -1.64929032e-01f, -4.85441647e-02f, -1.72230601e-02f, 2.64891740e-02f, -1.05542719e-01f, -2.96046585e-01f,
  4.20078970e-02f, -5.07886428e-03f, 8.09842721e-02f, -1.35237100e-02f, -8.02812204e-02f, 7.91625157e-02f, -6.20881207e-02f, -5.22748493e-02f, -1.34599702e-02f, -5.90518676e-02f,
  -7.32912496e-03f, -4.89924289e-02f, -5.71565889e-03f, -8.40224251e-02f, -2.20638718e-02f, -1.20815740e-03f, -1.12131774e-01f, -8.38996917e-02f, -5.95885403e-02f, 5.63019328e-02f,
  -9.70000625e-02f, -4.30641510e-03f, -6.73539517e-03f, -7.92533159e-02f, -6.66074902e-02f, 3.76227349e-02f, 6.18795417e-02f, 3.92504595e-02f, -2.85636857e-02f, 1.82301421e-02f,
  -1.53823500e-03f, -5.77737987e-02f, -4.28632386e-02f, 1.04694679e-01f, -4.86348243e-03f, 1.12913242e-02f, 5.68917487e-03f, 4.68078405e-02f, -7.55715184e-03f, 8.81962255e-02f,
  2.58974172e-02f, -4.02376391e-02f, 6.02745749e-02f, -5.68552688e-02f, -4.58814800e-02f, 1.26962061e-03f, 1.24367848e-02f, -4.27079499e-02f, -4.72918525e-02f, -3.45565267e-02f,
  3.94597556e-03f, 5.82765937e-02f, 5.09510450e-02f, 2.92843543e-02f, -1.42852478e-02f, 2.97539756e-02f, -2.32163761e-02f, 2.33057961e-02f, 6.85864314e-02f, -1.02671320e-02f,
  9.22271609e-02f, 8.69381949e-02f, -6.97455406e-02f, 1.30164638e-01f, -2.30910070e-02f, -4.66361903e-02f, -8.03654566e-02f, -4.81624678e-02f, 1.71531066e-02f, 2.46159546e-03f,
  -3.11324801e-02f, 2.46129707e-02f, -6.08874783e-02f, 7.02674463e-02f, 1.09293185e-01f, 5.72376736e-02f, 5.68646602e-02f, -3.81377749e-02f, -4.11261059e-02f, -2.56957430e-02f,
  5.71548603e-02f, 9.83272791e-02f, 8.45824778e-02f, 4.59609367e-02f, -1.63354706e-02f, 6.81403950e-02f, 8.14633891e-02f, 8.87779817e-02f, 8.20298865e-02f, 7.72349685e-02f,
  3.24442327e-01f, -3.69954668e-02f, 2.55386025e-01f, 2.70471144e-02f, 7.17768148e-02f, 7.71597251e-02f, 1.53674483e-01f, -5.67574874e-02f, -5.27119711e-02f, 8.48730877e-02f,
  -8.65554512e-02f, 6.45515160e-04f, 3.08866589e-03f, 2.75163241e-02f, 8.57679397e-02f, 6.63135648e-02f, 1.29603893e-01f, 1.03619963e-01f, 1.26068965e-01f, -8.23975652e-02f,
  -1.01247542e-01f, -8.85505602e-03f, 1.90405324e-01f, 1.33343101e-01f, -1.64059117e-01f, -4.40580584e-02f, 4.82694656e-02f, 5.94664784e-03f, -1.30838469e-01f, -1.40257403e-01f,
  -6.25334308e-02f, -2.03420967e-02f, 1.48803025e-01f, -2.19987929e-02f, 1.00044444e-01f, 1.37801394e-01f, 1.37463272e-01f, 6.60751238e-02f, 8.37476924e-02f, 4.61644866e-02f,
  -1.74737331e-02f, -1.33004831e-02f, 2.62052454e-02f, 1.48555906e-02f, 4.11906559e-03f, 3.35478075e-02f, 1.32863402e-01f, 4.88398895e-02f, 9.38731954e-02f, 8.04379582e-02f,
  -1.40493646e-01f, 3.17988992e-02f, 7.45752007e-02f, -6.51493743e-02f, -4.80167083e-02f, 6.96051568e-02f, -3.46945785e-02f, -9.74780917e-02f, 9.12752226e-02f, 9.53933224e-03f,
  -5.81652857e-02f, 4.81328443e-02f, -2.95673553e-02f, -4.40301336e-02f, -5.24935387e-02f, -5.03921472e-02f, -1.03356771e-01f, -3.60637680e-02f, 9.80602764e-03f, -7.52013410e-03f,
  2.78456192e-02f, -9.55119580e-02f, -1.06316738e-01f, 3.43039632e-02f, -1.03389621e-01f, 5.45909107e-02f, -3.99003550e-02f, 1.43492501e-02f, 5.78083806e-02f, -5.09013087e-02f,
  -7.12563694e-02f, -1.56970043e-02f, -8.86985734e-02f, 2.19240561e-02f, -5.91649339e-02f, -1.71999377e-03f, 4.65972722e-02f, -3.84976082e-02f, -1.21242441e-02f, 1.19985007e-02f,
  -5.35217598e-02f, 1.26129046e-01f, 3.26809986e-03f, 1.23736538e-01f, 7.27729127e-02f, 9.79969501e-02f, 9.83014330e-02f, 1.41882643e-01f, 2.68232031e-03f, -2.88716406e-02f,
  1.47592574e-02f, 3.08444668e-02f, -1.75617579e-02f, 8.72224942e-02f, 7.83172399e-02f, 1.69300884e-02f, 1.63053498e-01f, 1.51184887e-01f, 7.89463744e-02f, 1.29603138e-02f,
  -1.07496353e-02f, 1.45810386e-02f, 5.57379909e-02f, 1.18195146e-01f, 2.10725814e-02f, 2.15895958e-02f, 8.02813843e-02f, -6.93224976e-03f, 1.40458539e-01f, 9.85275060e-02f,
  -9.14510936e-02f, 1.26073360e-01f, -1.06140450e-01f, -9.88942571e-03f, -1.23285665e-03f, -1.50500536e-01f, 3.63757717e-04f, -4.18742374e-02f, 2.76206806e-02f, 1.59301519e-01f,
  -8.47565830e-02f, 3.81671339e-02f, 1.16216257e-01f, 5.94357848e-02f, -7.56126344e-02f, 1.05508931e-01f, 1.22821212e-01f, -2.10239608e-02f, -2.65865892e-01f, -9.39809531e-02f,
  3.19469161e-02f, -1.38491085e-02f, -4.26444039e-02f, 4.98806275e-02f, 2.65619271e-02f, -4.68648300e-02f, 1.34708554e-01f, 9.89218205e-02f, 3.19468118e-02f, 3.36118072e-01f,
  -1.36552870e-01f, -8.91385451e-02f, -2.49792822e-02f, -2.75413506e-02f, -8.97551775e-02f, 3.91287766e-02f, 5.89047233e-03f, -2.80244742e-02f, 1.57080572e-02f, 5.78361973e-02f,
  8.91537592e-02f, -3.12974714e-02f, 6.77058771e-02f, 4.35592905e-02f, -1.66513249e-02f, -5.71355000e-02f, 1.09937616e-01f, -2.95152590e-02f, 9.66336802e-02f, 7.98153654e-02f,
  7.45545998e-02f, 1.21174730e-01f, -1.33479834e-01f, -2.48332527e-02f, -4.10460569e-02f, 3.30976304e-03f, 9.09601748e-02f, 7.17415959e-02f, -4.26655225e-02f, 1.71441019e-01f,
  2.24694051e-02f, 4.99729775e-02f, -8.36354569e-02f, -3.45299765e-02f, -6.41843164e-03f, -8.26320574e-02f, 3.51074152e-02f, 9.44260322e-03f, 6.54154420e-02f, -9.41351696e-04f,
  -7.51054510e-02f, -1.01620574e-02f, -8.44423622e-02f, -7.83539191e-02f, -4.66589145e-02f, -4.86878604e-02f, -7.11874962e-02f, 2.02687606e-02f, -7.77032673e-02f, -5.78113049e-02f,
  -8.64547268e-02f, -5.18875159e-02f, -2.30332986e-02f, 2.69793235e-02f, 3.85979563e-02f, -3.43205258e-02f, -9.98652056e-02f, -3.93206738e-02f, -4.49373126e-02f, -1.06815271e-01f,
  1.04606129e-01f, 3.75733152e-02f, 1.18016548e-01f, -1.56074984e-03f, -1.95474084e-02f, 1.89485513e-02f, 3.76047716e-02f, 4.50401538e-04f, 1.31867873e-02f, 8.14972445e-05f,
  -2.94403452e-02f, -3.38098891e-02f, -4.11293916e-02f, 6.64894953e-02f, -3.67150716e-02f, -2.50819288e-02f, 9.95848700e-03f, 8.62977132e-02f, 1.50581049e-02f, 8.63692909e-02f,
  3.62434946e-02f, -2.17412459e-03f, 1.60597283e-02f, 3.81769724e-02f, 9.82922539e-02f, -1.11814991e-01f, 3.35026681e-02f, 4.94440012e-02f, -1.21339343e-01f, 3.05601466e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.79060769e-01f, 8.27651545e-02f, 2.26625040e-01f, -2.21134230e-01f, 1.82855308e-01f, 3.00774634e-01f, 5.38857043e-01f, -6.33371696e-02f, -2.08012775e-01f, 1.18706807e-01f,
  6.12095036e-02f, -3.11193734e-01f, -2.53088772e-01f, 4.59750406e-02f, -8.98319948e-03f, 3.79422575e-01f, 2.49682516e-01f, 5.31878620e-02f, -5.04760146e-02f, -2.02134047e-02f,
  -7.94611052e-02f, -1.61137119e-01f, -3.42052579e-01f, -2.11121708e-01f, -1.25989795e-01f, -6.49936870e-02f, 9.27208290e-02f, -7.29348287e-02f, -2.86878156e-03f, -1.78098623e-02f,
  -2.51080710e-02f, -2.35655636e-01f, 9.25545692e-02f, -7.59743080e-02f, -3.41269597e-02f, -1.75341845e-01f, -2.61831358e-02f, -2.84409642e-01f, -1.49768889e-02f, 1.72225141e-03f,
  -2.36411281e-02f, -6.58477396e-02f, -1.40852273e-01f, 3.38998511e-02f, -8.12710151e-02f, -3.75203937e-02f, -1.17698930e-01f, -8.89356434e-02f, -2.03872383e-01f, -7.02547729e-02f,
  -5.07431105e-02f, -3.21817398e-02f, -1.14531524e-01f, 4.63280007e-02f, -7.80436471e-02f, -3.75366323e-02f, -5.36186397e-02f, -8.33734423e-02f, -1.22335784e-01f, -5.01293875e-02f,
  -8.35523196e-03f, 1.58629268e-02f, -5.67485541e-02f, -8.02362338e-03f, 5.34744449e-02f, -1.47167575e-02f, 2.30030213e-02f, -2.54298747e-02f, 5.00326715e-02f, 8.08799174e-03f,
  -8.06050524e-02f, -3.49772982e-02f, 1.18685991e-01f, -9.03449804e-02f, -8.53011161e-02f, -1.76538732e-02f, 2.97730546e-02f, 4.17394564e-02f, 1.39747141e-02f, -4.50897627e-02f,
  -3.20027247e-02f, -7.30621256e-03f, -6.81480914e-02f, 4.69332561e-02f, 1.05557166e-01f, -1.30425906e-02f, -1.48461135e-02f, -2.49188896e-02f, 6.85293227e-02f, 3.66981514e-02f,
  -2.71281362e-01f, 1.79026961e-01f, -2.29850896e-02f, -1.22431852e-02f, 8.82573873e-02f, -6.95623606e-02f, -5.57602681e-02f, -1.07892357e-01f, -3.65617163e-02f, 8.51150453e-02f,
  -4.17569131e-02f, -8.29425454e-02f, 4.07327302e-02f, 4.94471006e-02f, 5.21764308e-02f, 1.32958382e-01f, 3.71681415e-02f, 2.18480732e-02f, -2.34882087e-02f, -1.29371613e-01f,
  1.52386740e-01f, -2.88898554e-02f, -1.03107458e-02f, 1.02578156e-01f, -1.15640298e-01f, -6.12869002e-02f, 5.09238429e-02f, 8.36872756e-02f, 1.01313725e-01f, 1.29138961e-01f,
  4.40264381e-02f, -4.39961301e-03f, 2.78335094e-01f, -6.02240264e-02f, -9.30026621e-02f, -2.44617686e-01f, -3.06408077e-01f, -2.45243430e-01f, -1.09528512e-01f, -1.81046058e-03f,
  -1.58433929e-01f, -1.84471589e-02f, 1.31566599e-01f, 3.61702144e-02f, -1.96527094e-01f, -4.64859679e-02f, 8.73071030e-02f, -3.41814198e-02f, -1.06630623e-01f, -2.23794699e-01f,
  -1.09376907e-01f, -9.68090352e-03f, -1.34018213e-02f, -5.84136099e-02f, 2.32358769e-01f, -1.75055154e-02f, 1.95451766e-01f, 1.14276014e-01f, 1.29971296e-01f, 3.84385437e-01f,
  4.34121013e-01f, 8.36239979e-02f, 2.29369421e-02f, -6.09267838e-02f, 4.80224416e-02f, 8.55232775e-02f, -9.63184759e-02f, 1.84082240e-01f, -4.32719514e-02f, 1.32579654e-01f,
  3.06129339e-03f, 2.63404269e-02f, 7.61166438e-02f, 1.72707364e-02f, -1.34065792e-01f, -1.63450614e-01f, -1.50562152e-01f, -8.81815031e-02f, 8.83297995e-02f, 1.19340800e-01f,
  -7.24356994e-02f, -3.04820836e-02f, -3.02488804e-02f, -1.40167207e-01f, 2.90143192e-02f, -1.76353808e-02f, 1.06591573e-02f, 1.00015044e-01f, -3.28586809e-02f, 1.55487627e-01f,
  -2.11411882e-02f, 4.66447808e-02f, -1.85580011e-02f, -5.91929480e-02f, -1.06065638e-01f, 2.59480607e-02f, 1.44104004e-01f, -4.90409434e-02f, 4.15076688e-03f, -1.19382210e-01f,
  1.49229048e-02f, 7.76989982e-02f, -6.94903359e-02f, 5.84976077e-02f, 8.46385360e-02f, 5.13792597e-02f, -3.20367888e-02f, -1.93971992e-02f, 2.60385200e-02f, -1.93844344e-02f,
  -3.30882743e-02f, -8.56747478e-02f, -3.17721888e-02f, -1.61893256e-02f, -7.01540038e-02f, -6.28867839e-03f, -8.00808668e-02f, -3.79756279e-02f, 5.19933598e-03f, 3.73456106e-02f,
  1.37146274e-02f, -2.39764392e-01f, 7.74070770e-02f, -8.86966242e-04f, 1.13577731e-01f, -6.84640929e-03f, 1.31542444e-01f, 1.31057249e-02f, 1.85539294e-02f, -8.08017701e-02f,
  -8.08450580e-02f, 9.39577725e-03f, 8.17197263e-02f, -1.35803083e-02f, -2.95741484e-02f, -6.55535907e-02f, -1.41283944e-01f, -3.29235457e-02f, -8.27500895e-02f, -2.98528317e-02f,
  -1.24985039e-01f, -1.81947112e-01f, -1.10108003e-01f, -4.43615764e-03f, 1.73366770e-01f, -9.26073864e-02f, -2.37985910e-03f, 1.75578333e-02f, -1.32440612e-01f, -2.34257892e-01f,
  -1.80715188e-01f, -1.08493775e-01f, 1.35496810e-01f, 1.82989627e-01f, 1.74529970e-01f, 2.84445733e-01f, 1.86808035e-01f, 1.05109774e-01f, 2.23691896e-01f, 8.39523822e-02f,
  3.83488112e-03f, 1.63819551e-01f, 1.84547678e-01f, 1.67554408e-01f, 6.87851906e-02f, 2.28589505e-01f, 1.55095741e-01f, 8.96178335e-02f, -3.31826247e-02f, -1.83672104e-02f,
  1.43118054e-01f, -1.30585387e-01f, -1.54939160e-01f, -7.91743398e-02f, 1.51446834e-01f, 1.79650381e-01f, 6.90367594e-02f, 4.77312021e-02f, -4.09843922e-02f, 2.82450393e-02f,
  1.33978888e-01f, -2.78283544e-02f, 5.17524034e-02f, 9.43797815e-04f, -1.03375554e-01f, -1.03831530e-01f, -8.53413418e-02f, -9.57290083e-02f, -9.36758369e-02f, -6.71721473e-02f,
  7.70210708e-03f, -1.25377029e-01f, -6.38635010e-02f, -5.62360650e-03f, -8.64768103e-02f, -1.52240947e-01f, -4.39784452e-02f, 2.00806968e-02f, 1.38372228e-01f, -4.19594347e-03f,
  8.30291361e-02f, 1.33734569e-01f, 7.31662735e-02f, 1.23985283e-01f, 7.63064697e-02f, 7.64468238e-02f, 8.88610855e-02f, -3.87481623e-03f, -3.03471480e-02f, 5.70487157e-02f,
  2.74165720e-01f, 1.07403472e-01f, 7.83772692e-02f, 1.11854270e-01f, -5.67527153e-02f, -5.71183898e-02f, 5.11785708e-02f, 6.33614277e-03f, 1.28764272e-01f, -1.30557343e-01f,
  4.08932939e-02f, 1.75483376e-01f, 1.16531573e-01f, 5.26497401e-02f, 7.36060739e-02f, -3.58621217e-02f, -1.03962626e-02f, -6.26577958e-02f, 2.74253804e-02f, -5.32282144e-02f,
  4.92070056e-02f, -9.49258432e-02f, -5.78954145e-02f, -8.01624060e-02f, -6.78276196e-02f, 8.16728771e-02f, 7.66855180e-02f, 5.59913032e-02f, -1.21513724e-01f, -1.27352588e-02f,
  8.89462009e-02f, 2.40734056e-01f, 9.14476439e-02f, -4.97641005e-02f, -4.21220623e-02f, -1.71608627e-01f, 3.76139991e-02f, -5.19627929e-02f, -9.70500335e-02f, 2.21247952e-02f,
  -7.25505650e-02f, -9.23748240e-02f, -8.20472762e-02f, -8.71723741e-02f, -1.55447170e-01f, -1.72711611e-01f, -1.46910921e-01f, 6.42939582e-02f, -3.60046839e-03f, 2.31112279e-02f,
  -3.22795026e-02f, 8.35589692e-02f, 1.87066153e-01f, 1.30235210e-01f, 1.54116958e-01f, 9.10669565e-02f, -1.23072406e-02f, 4.79399264e-02f, -1.33462343e-02f, 3.80067620e-04f,
  2.62190759e-01f, 2.30487123e-01f, 2.88323462e-01f, 2.11579427e-02f, 1.21331401e-01f, 2.86060661e-01f, 5.41627765e-01f, 1.69957280e-01f, -1.76946223e-01f, -1.04473624e-02f,
  1.00157902e-01f, -3.98894936e-01f, -2.96111345e-01f, -2.50897288e-01f, 6.64272308e-02f, 2.28905618e-01f, -2.08556876e-02f, 3.72150578e-02f, -1.55133605e-01f, 3.38154333e-03f,
  -1.97719902e-01f, -1.79870930e-02f, 9.80012193e-02f, -1.99402142e-02f, -1.22898661e-01f, -2.59794056e-01f, 1.14423208e-01f, 7.09235966e-02f, 1.20628782e-01f, -1.54711217e-01f,
  6.71357140e-02f, 2.18258917e-01f, -2.32502356e-01f, -1.61337703e-01f, 6.84804618e-02f, -1.44125626e-03f, -5.87638617e-02f, 3.75147276e-02f, -1.98357347e-02f, 6.08257055e-02f,
  -4.52393927e-02f, 3.01792733e-02f, 9.24252048e-02f, 1.18940897e-01f, 1.15830645e-01f, 5.85221015e-02f, 9.09038335e-02f, 3.57097276e-02f, -7.46088056e-03f, -1.42178357e-01f,
  -1.74679235e-02f, 1.30851790e-01f, 1.78954884e-01f, 5.03722206e-02f, 6.02999404e-02f, -6.24195561e-02f, 3.69570591e-02f, 9.86822508e-03f, 7.09929168e-02f, -5.31226397e-03f,
  -5.62046543e-02f, 6.20902069e-02f, -1.60410520e-04f, 6.93390518e-02f, -1.04495930e-02f, -5.72996289e-02f, 5.24576679e-02f, 8.44374001e-02f, -1.00552756e-02f, 1.73373893e-01f,
  1.34171531e-01f, -7.92006496e-03f, 1.17113866e-01f, 1.56845629e-01f, 3.95824723e-02f, 1.10576101e-01f, 1.24740273e-01f, 8.50642249e-02f, -7.26453681e-03f, 1.62096601e-02f,
  1.94177683e-02f, -7.30973901e-04f, 1.32235482e-01f, 8.62561986e-02f, 3.74850780e-02f, -8.95564165e-03f, 8.50807801e-02f, -8.83330312e-03f, 9.64715320e-04f, 1.30911186e-01f,
  -1.96475089e-01f, 1.70749769e-01f, -1.95771009e-01f, -1.04196571e-01f, 1.44885212e-01f, -9.24024135e-02f, 4.79506217e-02f, -3.27377133e-02f, -1.21898893e-02f, 5.13164513e-02f,
  7.50496536e-02f, -6.46978617e-02f, 1.44043103e-01f, 6.82238713e-02f, 2.42980961e-02f, 5.54473475e-02f, -7.80902505e-02f, -7.12356865e-02f, -7.26285651e-02f, -1.15322784e-01f,
  -9.17191897e-03f, -7.52227753e-02f, -8.09866935e-02f, -4.50482778e-02f, -4.62559611e-02f, -2.54242837e-01f, 4.38145187e-04f, -3.08284964e-02f, 2.68730219e-03f, -2.75292937e-02f,
  -3.77917290e-01f, 7.07892329e-03f, -1.88456789e-01f, 7.47202709e-03f, 1.86791956e-01f, 1.64725631e-01f, 2.46132493e-01f, 1.10686958e-01f, -9.36818775e-03f, 7.80273899e-02f,
  3.87220792e-02f, 1.69965103e-01f, 7.40540698e-02f, 2.02666670e-01f, 1.65072978e-01f, 4.83758450e-02f, 2.27496475e-01f, 6.56839600e-03f, 8.95869210e-02f, -3.75328469e-03f,
  2.30352446e-01f, -5.18396348e-02f, -1.31345659e-01f, -4.35438082e-02f, -7.08295032e-02f, 1.30074590e-01f, -7.99750090e-02f, -6.14154078e-02f, 2.67336089e-02f, 1.15257585e-02f,
  -2.30580628e-01f, -2.32240885e-01f, 1.84537590e-01f, -6.26003966e-02f, -6.71072223e-04f, -1.23719998e-01f, 4.18966599e-02f, -8.72853026e-02f, -3.10915150e-02f, -9.56060663e-02f,
  -1.06817894e-01f, -9.47073475e-02f, 9.17699933e-02f, -1.02967909e-02f, -1.53485894e-01f, 3.91705846e-03f, -6.80873394e-02f, -9.85656381e-02f, -1.26122341e-01f, -9.66688991e-02f,
  1.93940997e-01f, 8.22981074e-03f, -1.70275584e-01f, -5.01311198e-02f, -8.71284157e-02f, -3.55876870e-02f, -2.38391891e-01f, -3.32737893e-01f, -2.34346598e-01f, -3.81015122e-01f,
  4.99235513e-03f, -4.57815751e-02f, 3.48651297e-02f, -9.44380686e-02f, -4.36490849e-02f, -3.72414552e-02f, 1.26701564e-01f, 2.01743007e-01f, 4.74423319e-02f, -1.14882179e-01f,
  -3.59034166e-03f, 2.38291593e-03f, -1.42332516e-03f, -2.35778950e-02f, 9.85123403e-03f, -1.13200456e-01f, 3.25555801e-02f, 1.22075133e-01f, -9.54505503e-02f, 1.20884903e-01f,
  -4.62434143e-02f, -1.33574709e-01f, -1.87688306e-01f, -2.32391115e-02f, 5.45192175e-02f, 1.04127422e-01f, -1.07469270e-02f, 3.44988331e-02f, 2.40338314e-02f, -5.58609776e-02f,
  -1.40029892e-01f, 6.60808757e-02f, -7.05775172e-02f, 4.37014140e-02f, -5.90904318e-02f, 1.00818574e-01f, 3.80038470e-02f, 1.06569245e-01f, -2.71225981e-02f, 8.94447640e-02f,
  -1.32341057e-01f, -1.72249690e-01f, -5.97798862e-02f, -5.11816442e-02f, 1.34340480e-01f, 1.47828087e-01f, 6.22275993e-02f, 7.09554106e-02f, -4.50099446e-02f, -1.44608259e-01f,
  5.96992448e-02f, 9.30423290e-02f, 4.67901379e-02f, -1.49815697e-02f, -6.72646984e-02f, 4.56811637e-02f, -1.03545748e-01f, -2.21939325e-01f, -1.96207389e-01f, -1.32697031e-01f,
  -3.86444718e-01f, -3.42631072e-01f, 3.02690983e-01f, 9.25503448e-02f, 2.78637141e-01f, 1.43349245e-01f, -1.01812899e-01f, 2.22641304e-02f, 1.08359559e-02f, -1.63006276e-01f,
  -3.04620713e-01f, -1.52803540e-01f, 7.63308303e-03f, -6.77121580e-02f, -3.35157104e-02f, 1.95638448e-01f, 2.74438739e-01f, 3.99517626e-01f, 3.24917883e-01f, 9.80255753e-02f,
  4.97473478e-02f, 3.21537182e-02f, 3.85561846e-02f, 1.71838015e-01f, 2.13221088e-02f, 8.03322196e-02f, 1.35708600e-01f, 4.35499847e-02f, -5.48899025e-02f, 1.37593284e-01f,
  -2.88349807e-01f, -3.06393981e-01f, 2.30219305e-01f, -1.50404692e-01f, -3.00303381e-03f, -9.76775512e-02f, -2.49438547e-02f, 4.90677264e-03f, -3.34028453e-02f, 3.54648521e-03f,
  -6.91641569e-02f, -1.09376073e-01f, -1.12836011e-01f, 5.40964864e-02f, -2.00439036e-01f, -7.42262080e-02f, 5.79052195e-02f, 4.40155342e-02f, 5.74452542e-02f, -1.37230515e-01f,
  -1.25621716e-02f, -4.82760593e-02f, -1.68143120e-02f, 9.73951444e-02f, -3.82388271e-02f, 2.22925350e-01f, -5.77788055e-02f, -1.23377055e-01f, -1.32237762e-01f, -9.64071229e-02f,
  -2.00395565e-02f, -7.17604207e-03f, -2.08141543e-02f, 7.37557234e-03f, 4.92462479e-02f, 1.00582846e-01f, 3.46468017e-02f, -6.64853007e-02f, -3.34075689e-02f, 1.26226068e-01f,
  5.93691058e-02f, 6.16082586e-02f, 3.55902053e-02f, -9.04130861e-02f, 8.40821955e-03f, -7.34630302e-02f, 5.21978885e-02f, -1.83857083e-02f, 1.48137538e-02f, 4.34782468e-02f,
  -3.12460139e-02f, 7.13326037e-02f, -1.24111278e-02f, 3.80695686e-02f, 3.99916694e-02f, 1.43799916e-01f, 5.44366576e-02f, -1.72474653e-01f, -8.56775120e-02f, -1.31940931e-01f,
  -3.57688367e-02f, 1.85573906e-01f, -2.08115980e-01f, -4.51259650e-02f, 3.89017574e-02f, 1.76357046e-01f, -9.09833983e-03f, -3.52915861e-02f, -6.51364122e-03f, -4.35773954e-02f,
  1.29947602e-03f, 1.77333839e-02f, -6.60971031e-02f, -1.58460774e-02f, 1.02074713e-01f, -1.38242885e-01f, -4.66278382e-02f, -7.65202660e-03f, -4.35219519e-02f, 1.27347752e-01f,
  5.74022979e-02f, -4.73133773e-02f, -1.17674567e-01f, 5.41150048e-02f, -1.99899212e-01f, 6.63992064e-03f, -1.17475931e-02f, 4.77780104e-02f, -2.84300521e-02f, 2.76192906e-03f,
  -4.72320795e-01f, 4.29108627e-02f, 1.13575887e-02f, -3.72039348e-01f, 1.00552127e-01f, 3.21066141e-01f, 1.23293020e-01f, 1.64426014e-01f, -3.81770693e-02f, -7.36590251e-02f,
  1.52996659e-01f, -7.27998987e-02f, -2.87913293e-01f, -4.56635915e-02f, -7.75488764e-02f, -8.25773925e-02f, -2.03234270e-01f, -2.62683600e-01f, -3.25482264e-02f, 2.38422081e-01f,
  7.85202906e-02f, -1.69151634e-01f, -9.68693495e-02f, -8.37369338e-02f, -4.98933606e-02f, -2.39520699e-01f, -2.48574674e-01f, -7.69921988e-02f, 1.17361017e-01f, -2.34741628e-01f,
  -2.21902430e-01f, 1.17109358e-01f, -8.94741043e-02f, -6.32144287e-02f, -1.41263269e-02f, -2.40585804e-02f, -1.96190104e-02f, -8.68519768e-02f, 1.03358105e-01f, -1.03021190e-01f,
  2.09847223e-02f, 1.23896047e-01f, -1.46191224e-01f, -6.29072562e-02f, -3.75289097e-02f, 6.57019243e-02f, 4.67053317e-02f, -8.84554759e-02f, 2.25100089e-02f, 2.12203100e-01f,
  1.58073246e-01f, 1.22647742e-02f, 6.49902746e-02f, 3.57533395e-02f, 1.77068472e-01f, -1.46579118e-02f, 1.18300818e-01f, 8.25792104e-02f, 3.20500210e-02f, -1.88501626e-01f,
  -1.09115448e-02f, -5.21338843e-02f, 5.01560792e-03f, -5.47181554e-02f, 1.41292050e-01f, 4.82985079e-02f, -1.19186081e-01f, -6.63814470e-02f, 3.21308486e-02f, -8.41925219e-02f,
  -2.42419094e-02f, 4.19957340e-02f, -1.43422289e-02f, -1.05549939e-01f, 5.10841273e-02f, 2.52629761e-02f, -5.72215766e-02f, -1.05449691e-01f, 1.28092945e-01f, -4.82594520e-02f,
  2.38647684e-02f, 6.43477514e-02f, -2.89334673e-02f, -6.26008445e-03f, -6.15550876e-02f, -7.82411322e-02f, -2.31418181e-02f, 2.10060030e-02f, -4.19291407e-02f, 4.12261970e-02f,
  -4.70037580e-01f, -1.48108704e-02f, -3.71985942e-01f, 2.26791929e-02f, -9.99865979e-02f, 1.36393011e-01f, 2.63288300e-02f, 1.90591570e-02f, -1.39174566e-01f, 7.64954016e-02f,
  1.31788164e-01f, -1.54910784e-03f, -1.98777184e-01f, -4.00631204e-02f, -5.61317578e-02f, 1.13270976e-01f, 5.05637452e-02f, -7.52158016e-02f, 4.80591655e-02f, 1.80186555e-01f,
  7.42411893e-03f, -2.81338878e-02f, -1.65621862e-01f, -5.91421835e-02f, -7.32515892e-03f, -1.46625340e-01f, -1.38953671e-01f, -3.12809609e-02f, -2.99552139e-02f, -3.74394536e-01f,
  -4.48414646e-02f, -7.84819499e-02f, 9.11562443e-02f, 1.31818160e-01f, 2.65650917e-02f, 2.62356829e-02f, -2.36602828e-01f, -2.00358815e-02f, 1.93949267e-01f, -1.72536701e-01f,
  -4.06094268e-02f, 2.41727337e-01f, 1.18071757e-01f, -1.02430908e-03f, -4.81746793e-02f, -1.78594723e-01f, -1.99933857e-01f, 3.40100229e-02f, 1.20224111e-01f, 8.16051513e-02f,
  8.43728483e-02f, 2.97347233e-02f, 8.15955848e-02f, -3.89224440e-02f, -8.31809044e-02f, -4.52938154e-02f, -1.54010221e-01f, 4.32155691e-02f, -8.43877196e-02f, -1.37590900e-01f,
  1.41014487e-01f, -1.08827665e-01f, 2.35608988e-03f, -1.75291166e-01f, -5.09939231e-02f, -1.31703131e-02f, -1.25120610e-01f, -2.09462434e-01f, -1.26639545e-01f, -4.67000380e-02f,
  -1.14664733e-01f, -5.20984940e-02f, -1.51221640e-02f, -4.12788503e-02f, -9.02143568e-02f, -9.75366216e-03f, -1.81396529e-01f, -1.42617688e-01f, -2.91511659e-02f, -1.59597360e-02f,
  -2.21586943e-01f, -1.69889703e-01f, -5.47349229e-02f, -1.48288161e-01f, 4.35919203e-02f, -5.63819371e-02f, -1.67925917e-02f, 2.69088522e-02f, -5.76405413e-02f, -2.37899676e-01f,
  -3.63965817e-02f, 7.67332464e-02f, -2.41041332e-02f, -4.60104719e-02f, -7.03925192e-02f, 2.20224168e-02f, -5.38178124e-02f, -6.82471395e-02f, 6.35028780e-02f, 6.31393716e-02f,
  1.72899961e-01f, 2.72092707e-02f, 7.09676668e-02f, -8.14868137e-02f, 1.97026785e-02f, -9.02906880e-02f, -1.37337178e-01f, -1.06265619e-01f, -1.44953817e-01f, -5.92098199e-02f,
  -6.34356588e-02f, -2.68874224e-02f, 6.39636293e-02f, -3.53288800e-02f, -9.66222659e-02f, -1.60388678e-01f, 4.07948270e-02f, -1.08440824e-01f, 5.39877191e-02f, -1.08926952e-01f,
  1.34818837e-01f, 2.20507998e-02f, -6.60124645e-02f, 1.34313218e-02f, -2.11558323e-02f, -1.14590786e-01f, -1.11326128e-01f, -3.40606794e-02f, 5.29330485e-02f, -4.61479723e-02f,
  -1.66695312e-01f, -8.00623372e-02f, -1.07088059e-01f, -1.72407664e-02f, 2.08592638e-02f, -1.57028884e-01f, -2.76912272e-01f, -6.91578090e-02f, -3.89862736e-03f, -5.97938560e-02f,
  -1.00198083e-01f, 1.21158278e-02f, -7.06135780e-02f, -6.62515834e-02f, -4.85709310e-03f, -1.12338305e-01f, -4.60288376e-02f, -3.66090201e-02f, -9.12878215e-02f, -1.78190604e-01f,
  4.65604709e-03f, -1.25917315e-01f, 6.26810268e-02f, 1.11221455e-01f, 1.57960668e-01f, 2.93753505e-01f, 2.16344550e-01f, 1.56714246e-01f, -1.26293283e-02f, 1.27474099e-01f,
  8.35390538e-02f, 1.29047945e-01f, 1.92766020e-03f, 7.61343613e-02f, 1.18384808e-01f, 2.67126821e-02f, 5.78598455e-02f, 2.07818281e-02f, 3.69621776e-02f, 9.22077596e-02f,
  5.96089885e-02f, -8.03345889e-02f, -2.00136602e-01f, -7.65663832e-02f, -4.46237400e-02f, 1.09573156e-01f, -1.91328928e-01f, -1.76294580e-01f, -1.58816315e-02f, -1.58854634e-01f,
  7.16400817e-02f, -5.36289066e-02f, 1.01307973e-01f, -1.83484592e-02f, -1.62420914e-01f, 1.44677199e-02f, -9.68372673e-02f, -2.50871152e-01f, 7.02990368e-02f, -9.83523671e-03f,
  -4.01852094e-02f, -9.64608118e-02f, -8.95276368e-02f, -7.23538920e-02f, -1.43020064e-01f, 9.29796994e-02f, -2.03988433e-01f, -5.06024398e-02f, -8.61799270e-02f, -9.30789411e-02f,
  -1.17233947e-01f, -1.52235895e-01f, -2.32842937e-01f, 2.13567410e-02f, 6.47004098e-02f, 1.95195898e-02f, -1.11662365e-01f, -1.01998419e-01f, -2.77019758e-02f, -1.24808125e-01f,
  -2.03259643e-02f, -9.01462138e-02f, -2.20208410e-02f, -1.16576210e-01f, 1.00072958e-01f, -4.29376438e-02f, 1.19763426e-01f, -1.07872505e-02f, 5.53261712e-02f, -4.97645624e-02f,
  2.09017601e-02f, 3.24485563e-02f, 8.32229555e-02f, -2.97559816e-02f, 7.61155337e-02f, -1.45359665e-01f, -2.99530048e-02f, -9.14652869e-02f, -2.53095962e-02f, 2.06452124e-02f,
  1.44555852e-01f, -3.96785438e-02f, -5.02104908e-02f, 6.26209974e-02f, 6.89261183e-02f, -4.03645188e-02f, -6.76551387e-02f, -6.84743673e-02f, -7.10515603e-02f, -7.18541369e-02f,
  -1.28405467e-01f, 1.68947540e-02f, 1.09137215e-01f, -3.79813686e-02f, -8.78014863e-02f, -4.61093001e-02f, 1.52673110e-01f, 6.09196499e-02f, 1.38010412e-01f, 9.74531025e-02f,
  -4.03914861e-02f, 2.27651987e-02f, -7.17397332e-02f, 1.32947862e-02f, 9.19882674e-03f, 1.02526039e-01f, -3.31870206e-02f, 1.15043983e-01f, 3.17450315e-02f, -2.47485861e-02f,
  -1.10638596e-01f, 1.37555962e-02f, 6.82508871e-02f, 5.68315163e-02f, 6.88753575e-02f, 1.14069149e-01f, 3.73841985e-03f, -5.68106323e-02f, 8.35995525e-02f, -4.32324223e-02f,
  4.09127057e-01f, 2.56216466e-01f, -1.02115072e-01f, 2.73221850e-01f, 1.41459048e-01f, 8.59969407e-02f, 6.32000193e-02f, -1.97486822e-02f, -5.61532713e-02f, 1.89848050e-01f,
  2.18952119e-01f, 1.85044214e-01f, 1.12116508e-01f, 5.42574674e-02f, -4.83078770e-02f, -7.70337284e-02f, 1.57179851e-02f, 3.24257798e-02f, -5.70570566e-02f, 2.47421656e-02f,
  1.88913390e-01f, 7.18287826e-02f, 7.67672062e-02f, -9.11388732e-03f, 2.04686001e-01f, 1.16386548e-01f, 4.08344306e-02f, 8.24979246e-02f, 1.07679784e-01f, 2.57401317e-01f,
  -2.59383339e-02f, 1.65925115e-01f, -1.98561892e-01f, 2.11851876e-02f, -5.16686775e-03f, -2.23426938e-01f, -7.52823949e-02f, -2.41352439e-01f, -6.30315170e-02f, -1.24957778e-01f,
  1.25634251e-02f, -1.90071086e-03f, -1.95899960e-02f, -5.21895364e-02f, -1.50694951e-01f, -1.10724993e-01f, -1.75798237e-01f, -2.69808173e-02f, -6.88797832e-02f, 8.47511110e-04f,
  2.53777541e-02f, 1.00081228e-01f, 4.81894910e-02f, -1.92277897e-02f, 8.23051259e-02f, 8.92618150e-02f, 5.01285046e-02f, 2.28836741e-02f, -2.95802075e-02f, 1.54977068e-01f,
  -4.45456393e-02f, -5.87505149e-03f, 9.51952189e-02f, 7.54315034e-02f, 1.25829145e-01f, -2.18360219e-02f, -9.50155035e-03f, 6.57359064e-02f, 9.75632947e-03f, -3.32987271e-02f,
  -7.92946368e-02f, 1.42668243e-02f, -1.29915819e-01f, -6.50478201e-03f, -6.50266837e-03f, -4.87342142e-02f, -4.64468971e-02f, -2.16541644e-02f, -6.22098446e-02f, -3.88189661e-03f,
  -3.00085600e-02f, -7.86790028e-02f, -1.71676472e-01f, -1.35124521e-02f, -9.54416841e-02f, -8.82868394e-02f, -9.88808051e-02f, -2.94807163e-04f, -1.45651326e-01f, -1.96132630e-01f,
  -1.78127021e-01f, -1.28486127e-01f, 7.07137689e-04f, -1.82713177e-02f, -4.42982512e-03f, -1.22110106e-01f, 1.28624082e-01f, -9.81810465e-02f, -2.04577856e-02f, -2.88101900e-02f,
  1.14065455e-02f, -1.38389096e-02f, 1.53668299e-02f, -9.78539139e-02f, -8.40211734e-02f, -4.60139960e-02f, 5.53690121e-02f, -9.38923564e-03f, -7.97974542e-02f, -1.50581840e-02f,
  -6.92270920e-02f, -9.65239033e-02f, -4.80153635e-02f, -1.60983637e-01f, 2.36460716e-02f, -4.59038392e-02f, -1.75211981e-01f, -1.44180730e-01f, -1.43228889e-01f, -1.84786573e-01f,
  -4.78796586e-02f, -1.67214915e-01f, 8.19829330e-02f, 1.82113633e-01f, -4.93855923e-02f, 6.39918372e-02f, -1.42800763e-01f, 1.05402514e-01f, 6.09752126e-02f, 5.57351811e-03f,
  9.38785225e-02f, 2.32219219e-01f, 1.39142811e-01f, 7.49157891e-02f, 6.83540180e-02f, 8.31410363e-02f, 1.73152983e-01f, 2.94044353e-02f, 6.76150322e-02f, 1.25066280e-01f,
  1.22708075e-01f, -4.40613069e-02f, -2.31934898e-02f, 3.60510871e-02f, 1.11012042e-01f, 1.73799247e-01f, 7.92783424e-02f, -2.82211602e-02f, 2.76268795e-02f, 1.37428448e-01f,
  1.16142265e-01f, -3.59230861e-02f, 1.22230761e-01f, 5.90158701e-02f, -1.09973729e-01f, -6.75376086e-03f, 9.55341384e-02f, 7.42107034e-02f, -1.65219922e-02f, 1.27244487e-01f,
  -2.10726094e-02f, -1.48520932e-01f, -3.34672220e-02f, -1.65219769e-01f, 7.11796153e-03f, 9.17444564e-03f, 6.15723692e-02f, 1.00962162e-01f, 1.35743976e-01f, 8.19224864e-02f,
  -5.63823543e-02f, 5.70978643e-03f, 2.18787640e-02f, -5.26919700e-02f, -2.92588491e-02f, -2.76416503e-02f, -1.25897899e-01f, 6.14879914e-02f, 8.25964212e-02f, 1.66862216e-02f,
  2.94856817e-01f, 1.62023440e-01f, 1.15190953e-01f, 7.97033459e-02f, 1.12896611e-03f, -8.46166909e-02f, 1.62223224e-02f, -2.94408333e-02f, 2.21637636e-02f, -1.40291452e-01f,
  1.09201577e-02f, 1.11653201e-01f, 7.33658969e-02f, 3.38904373e-03f, 1.02508590e-02f, -2.71716304e-02f, 4.33989875e-02f, 1.02795936e-01f, -1.20602898e-01f, -8.94343108e-02f,
  -4.61313277e-02f, -6.12682812e-02f, 3.18828225e-02f, -1.95036046e-02f, 9.93257668e-03f, 1.37848228e-01f, -3.94142279e-03f, 8.98121223e-02f, 1.60355624e-02f, -2.68040877e-02f,
  1.48992226e-01f, 1.18701337e-02f, 8.42286423e-02f, -3.16025652e-02f, -8.56427997e-02f, -2.18394428e-01f, 6.16673939e-02f, 8.06196406e-02f, -3.32341231e-02f, 6.98312446e-02f,
  -1.21015050e-01f, -1.18676156e-01f, -1.44116923e-01f, -6.70780912e-02f, -8.98534283e-02f, -5.92556335e-02f, 4.72245663e-02f, 1.76809013e-01f, 4.64178137e-02f, 5.74474372e-02f,
  1.64663866e-02f, 6.07786626e-02f, 3.24143432e-02f, -5.34180924e-02f, -4.59673665e-02f, 5.76706342e-02f, -1.16617590e-01f, 1.69384163e-02f, -6.05564602e-02f, -1.68281958e-01f,
  2.37328455e-01f, -5.17202079e-01f, 7.05490112e-02f, 3.98463570e-02f, 9.51973343e-05f, 1.80428967e-01f, -1.90874457e-01f, -1.02201007e-01f, 5.35382107e-02f, -1.87554136e-02f,
  1.41021926e-02f, 1.45823091e-01f, 1.20890938e-01f, 2.58491226e-02f, 9.15382281e-02f, -1.10601783e-01f, 1.08343877e-01f, 2.94524431e-01f, 3.46509635e-01f, -1.48724094e-02f,
  -1.14436053e-01f, -6.69446737e-02f, 1.08937487e-01f, 1.27508253e-01f, -1.36031777e-01f, 1.06462903e-01f, -1.09818481e-01f, -6.93800449e-02f, -9.39676464e-02f, -1.05648078e-01f,
  1.61512211e-01f, 5.07734204e-03f, 1.05967775e-01f, 1.07390434e-02f, -6.43977597e-02f, -3.81553103e-03f, 3.07481661e-02f, -8.48008767e-02f, -5.50185293e-02f, -4.83183824e-02f,
  3.53405345e-03f, -7.74063095e-02f, -1.04078846e-02f, -5.57010015e-03f, 9.06842761e-03f, 3.83114852e-02f, -1.19984917e-01f, -1.20235374e-02f, -3.83087527e-03f, -8.38947520e-02f,
  -4.22400422e-02f, 3.77517529e-02f, 1.26027852e-01f, 1.14403151e-01f, 1.79891437e-01f, 1.69668704e-01f, -3.78107801e-02f, -4.62703444e-02f, 1.01920940e-01f, -9.98452231e-02f,
  -2.28973702e-02f, 1.23508675e-02f, 1.17099628e-01f, 6.75127059e-02f, 3.05094291e-02f, 1.01857752e-01f, 6.67900667e-02f, 5.08537218e-02f, 1.28312949e-02f, 1.93847306e-02f,
  -1.02047496e-01f, 1.55922040e-01f, 1.02645718e-03f, 3.70337740e-02f, -2.42077839e-02f, 3.33041511e-02f, -3.96823101e-02f, -1.98633038e-02f, 6.08056225e-02f, 5.84513880e-02f,
  9.49920416e-02f, 2.80475821e-02f, -3.87297049e-02f, -4.35939692e-02f, 1.12933097e-02f, -6.54324610e-03f, 6.31792396e-02f, -5.33782467e-02f, -5.18543534e-02f, -1.01873614e-01f,
  -9.68780667e-02f, 3.52246135e-01f, -5.12814196e-03f, -1.27758294e-01f, 1.91305894e-02f, -7.27784559e-02f, 1.18104443e-02f, -4.95493785e-02f, 1.71630047e-02f, 1.00513473e-01f,
  -8.97872075e-02f, -2.66532470e-02f, -5.04914746e-02f, -8.81735757e-02f, -4.42043878e-02f, 5.00866883e-02f, -3.18620205e-02f, 3.48567404e-02f, -4.25154064e-03f, -2.87671443e-02f,
  -7.10975155e-02f, 6.20416328e-02f, 1.08761132e-01f, 2.04958737e-01f, 1.73955083e-01f, 2.23240212e-01f, 1.47218287e-01f, -1.36295450e-03f, 1.87644064e-01f, -1.43211678e-01f,
  1.28383949e-01f, -1.58110619e-01f, -3.90277863e-01f, -1.30239666e-01f, -2.19450802e-01f, -1.31842777e-01f, -3.56471390e-01f, -1.73025765e-02f, 2.25987360e-02f, -2.85890907e-01f,
  -2.16199011e-01f, 7.42735714e-02f, 4.31757122e-02f, 1.05396174e-01f, 1.41478583e-01f, -3.92243147e-01f, -2.49711543e-01f, -4.02804688e-02f, 1.58496842e-01f, 7.11227674e-03f,
  1.43069569e-02f, -1.00711614e-01f, 8.71653259e-02f, 1.09556243e-01f, -6.54052151e-03f, 1.14659630e-01f, -2.38547161e-01f, 3.07404157e-02f, 6.87126443e-02f, -2.96762347e-01f,
  -2.15792909e-01f, -4.45019528e-02f, -4.97256033e-02f, 7.72168040e-02f, -1.08717389e-01f, 3.37513797e-02f, -8.59820694e-02f, -8.21264982e-02f, -5.85557707e-02f, -8.73952061e-02f,
  1.68466195e-02f, -1.65140128e-03f, 4.54870462e-02f, -6.80382252e-02f, -5.74892312e-02f, -7.08636940e-02f, 6.72050565e-02f, -3.95265669e-02f, 7.60509372e-02f, -2.17100322e-01f,
  -6.53767735e-02f, -1.13112703e-01f, 4.16033305e-02f, 2.10730033e-03f, 1.92164183e-02f, 6.49911687e-02f, 7.80973025e-03f, 1.30576361e-02f, 1.18339928e-02f, -6.05188645e-02f,
  -1.37529448e-01f, -1.71044126e-01f, 1.55316596e-03f, 2.11962424e-02f, -6.37140274e-02f, -4.43423316e-02f, 5.54648601e-02f, 1.10519519e-02f, 2.44645588e-02f, -9.64267179e-02f,
  -8.47398192e-02f, 3.27385925e-02f, 5.19456342e-02f, -5.99133819e-02f, -9.92898569e-02f, -7.85705298e-02f, -7.43567571e-02f, -5.14137000e-02f, -3.08717377e-02f, -2.00379528e-02f,
  -1.08083881e-01f, 6.69466332e-02f, -8.56184140e-02f, 1.21785961e-01f, -3.00830323e-02f, 4.04613838e-02f, -1.13657145e-02f, -4.35188226e-02f, -1.29984822e-02f, -1.06370058e-02f,
  8.33285078e-02f, -6.13241419e-02f, -1.06556259e-01f, 1.70585718e-02f, -9.13099945e-02f, -8.63849744e-02f, -2.15905443e-01f, -4.77369614e-02f, 2.31549386e-02f, 1.13448072e-02f,
  -1.30545169e-01f, -3.51580754e-02f, -1.21528976e-01f, 7.99661037e-03f, -6.93296120e-02f, -1.15855090e-01f, 2.46078484e-02f, 7.03017116e-02f, -5.95411099e-02f, -2.26289585e-01f,
  -1.12647805e-02f, -1.32405311e-01f, 4.99614282e-03f, 4.08875272e-02f, 1.67619988e-01f, -2.18025502e-03f, -2.06700582e-02f, -1.16610251e-01f, 1.46625951e-01f, 5.10475645e-03f,
  -1.11769669e-01f, -3.03919911e-01f, -1.10134877e-01f, 8.78304169e-02f, -6.29307926e-02f, -3.29637349e-01f, -5.09864330e-01f, -2.63058394e-01f, 7.27700535e-03f, -3.22581194e-02f,
  -8.03208426e-02f, 1.24795705e-01f, 2.18562651e-02f, -6.03322452e-03f, -7.52469152e-02f, -1.51472554e-01f, 1.34415403e-01f, 1.34150073e-01f, -1.05373766e-02f, 6.50837719e-02f,
  2.05562770e-01f, 1.31439671e-01f, 1.25180513e-01f, 1.66681305e-01f, 1.73952028e-01f, 1.95334807e-01f, 2.98355892e-02f, 2.04636499e-01f, 1.96954325e-01f, 3.37404341e-01f,
  7.16184974e-02f, -6.08672388e-02f, -3.63041535e-02f, 1.00376964e-01f, 1.05836064e-01f, -2.72002146e-02f, 1.05390742e-01f, -8.23978428e-03f, 1.21996924e-02f, 8.81650485e-03f,
  1.05233170e-01f, 9.35731158e-02f, -2.37842817e-02f, 1.17613763e-01f, 1.18742120e-02f, 2.60116663e-02f, -9.44997147e-02f, -5.93707487e-02f, -1.45780951e-01f, -9.26749855e-02f,
  2.48545483e-02f, -1.46071212e-02f, -8.73513669e-02f, -1.36851564e-01f, -1.83694556e-01f, 5.68544939e-02f, -3.41125578e-02f, 4.02434319e-02f, -5.16539849e-02f, 1.73276793e-02f,
  -9.75825563e-02f, -8.39461759e-02f, -3.12891155e-02f, 1.39929786e-01f, -2.67315004e-02f, -1.33105731e-02f, 1.88446268e-02f, 4.29272130e-02f, 6.95335940e-02f, -3.39269787e-02f,
  -5.40028233e-03f, -3.93467136e-02f, 4.49030809e-02f, -4.10148874e-02f, 7.37139117e-03f, 6.48692697e-02f, 1.26206860e-01f, 4.02473509e-02f, 2.49984190e-02f, -4.22896184e-02f,
  -1.05433002e-01f, 3.63374762e-02f, -1.27141541e-02f, 4.58963625e-02f, 3.24671827e-02f, 7.65559822e-02f, 1.59895748e-01f, 3.95286977e-02f, -6.89297244e-02f, -2.53999941e-02f,
  -1.27490893e-01f, -6.23107404e-02f, 2.01024428e-01f, 4.79506254e-02f, 7.25395456e-02f, -5.11061139e-02f, 4.26047966e-02f, 3.57363224e-02f, -4.00666036e-02f, -1.10281020e-01f,
  3.00806165e-02f, 8.27331282e-03f, 1.64011829e-02f, -1.77688152e-01f, -8.67144987e-02f, -2.45930087e-02f, 1.16296791e-01f, -2.73648575e-02f, -4.98159155e-02f, -6.46874914e-03f,
  -6.07870221e-02f, -2.15631247e-01f, -3.55915755e-01f, -2.84315437e-01f, -6.31298199e-02f, -9.35007781e-02f, -7.56526068e-02f, 1.37474276e-02f, -1.48289993e-01f, -2.39749402e-01f,
  5.56346953e-01f, 2.68087536e-01f, 2.88094014e-01f, 1.84008986e-01f, 1.75638139e-01f, 1.90052584e-01f, 2.63178527e-01f, 2.11767048e-01f, 8.51029530e-02f, 8.32785219e-02f,
  6.42743707e-02f, 5.79762533e-02f, -4.36268840e-03f, -4.72812131e-02f, 1.56512380e-01f, 1.38851002e-01f, 1.50023948e-03f, 1.94324493e-01f, 2.66911872e-02f, 9.22598615e-02f,
  7.56310523e-02f, 2.82660127e-02f, 1.55359566e-01f, 1.04754075e-01f, 1.49353236e-01f, -8.24392214e-02f, -1.19986078e-02f, 8.33507106e-02f, 8.38287324e-02f, 1.04784854e-01f,
  -1.08544514e-01f, 4.02609587e-01f, 3.34642529e-02f, -1.55525804e-01f, 2.14703996e-02f, 4.19896543e-02f, 3.00577525e-02f, -4.83930670e-02f, -7.23925680e-02f, -7.38141313e-02f,
  -1.14970803e-01f, -9.08723176e-02f, 1.65113099e-02f, -4.90499102e-02f, 5.91151491e-02f, 6.09622151e-02f, 2.24975850e-02f, 7.17304349e-02f, 6.73156679e-02f, -6.09871112e-02f,
  -8.05405453e-02f, 6.67910054e-02f, 4.12592851e-03f, 4.02795449e-02f, 1.28235325e-01f, -1.22178547e-01f, 1.89103168e-02f, 8.94893259e-02f, -1.66828856e-02f, 6.80029625e-03f,
  -2.59484500e-02f, 1.54727148e-02f, -4.06915467e-04f, 3.92063484e-02f, 2.25324407e-02f, -5.21976128e-02f, -1.26349106e-01f, -3.12857479e-02f, -4.99997251e-02f, 4.06461358e-02f,
  -9.17573795e-02f, 9.14113969e-02f, -3.75134610e-02f, 2.88000721e-02f, 9.43501890e-02f, -7.93271437e-02f, -8.92668888e-02f, -6.09934218e-02f, -7.64802098e-02f, -5.41303121e-02f,
  -7.87443072e-02f, -8.19987878e-02f, -1.87706873e-02f, 5.38099557e-02f, 2.61275303e-02f, 1.68658525e-01f, -3.14576142e-02f, -1.08427241e-01f, -2.13323142e-02f, -7.85795972e-02f,
  -4.63726521e-01f, 1.51017725e-01f, 6.65107649e-03f, 4.66751158e-02f, -1.14407100e-01f, -1.26532525e-01f, 2.75156870e-02f, 7.69953430e-02f, -1.64473653e-01f, -1.76972389e-01f,
  -7.20917657e-02f, 2.24638972e-02f, -2.01132931e-02f, -1.67052783e-02f, -1.33408800e-01f, -1.78359941e-01f, -1.22085571e-01f, -6.69060200e-02f, -2.04272658e-01f, -2.77539283e-01f,
  -1.01597697e-01f, -1.47776008e-01f, -1.76304355e-01f, 1.20659396e-02f, -1.41500622e-01f, -2.37162039e-01f, -1.85466930e-01f, -8.01587403e-02f, -2.09684744e-01f, -5.90251945e-02f,
  -3.46607506e-01f, 5.49065415e-03f, 1.11415654e-01f, 2.01502472e-01f, 2.99582869e-01f, 5.43612195e-03f, -2.16045558e-01f, -2.71003127e-01f, -1.01106822e-01f, 3.40079255e-02f,
  -2.11263844e-03f, -9.91940945e-02f, -1.97041184e-01f, -7.98953474e-02f, -4.62460428e-01f, -1.70821548e-01f, -2.07448050e-01f, -2.07276717e-01f, -3.74252796e-01f, -8.12383592e-02f,
  -2.86495741e-02f, -9.59619358e-02f, -2.19737843e-01f, -6.07205480e-02f, 2.39052549e-01f, -2.03817692e-02f, -2.88671479e-02f, 4.04606573e-02f, 4.80899103e-02f, 1.85549036e-01f,
  4.45883244e-01f, 2.69379854e-01f, 5.86076230e-02f, 8.04660320e-02f, 1.38152242e-01f, 4.98842681e-03f, -2.58221030e-02f, -5.29074073e-02f, 7.85746351e-02f, -3.21393274e-02f,
  1.11732423e-01f, 7.90240392e-02f, 8.31879824e-02f, 1.10770397e-01f, -2.47679669e-02f, 1.16071142e-01f, -2.38653701e-02f, -1.15799159e-01f, -3.35899135e-03f, 1.23448581e-01f,
  1.05659001e-01f, 1.35306373e-01f, 1.37229696e-01f, -4.58634384e-02f, -7.62398960e-03f, 7.92096853e-02f, 8.40800405e-02f, 1.79066241e-01f, 6.52516484e-02f, -7.66528398e-02f,
  -1.04297191e-01f, -8.61586183e-02f, 1.01716079e-01f, 2.98010167e-02f, -3.79828848e-02f, 4.60567586e-02f, 3.35224867e-02f, -9.87294912e-02f, -1.52640924e-01f, -7.05986768e-02f,
  3.84163037e-02f, 5.08920550e-02f, -1.01476021e-01f, 5.71152903e-02f, 4.52493876e-02f, 9.59007517e-02f, 8.83229226e-02f, 2.55729891e-02f, 9.10750329e-02f, 1.76940188e-01f,
  9.89799649e-02f, -3.56334187e-02f, 2.35362891e-02f, 1.69338342e-02f, 2.12487996e-01f, 1.74630627e-01f, 1.01412110e-01f, 9.46552900e-04f, -2.06971597e-02f, 4.13824283e-02f,
  -1.75387058e-02f, 1.29982427e-01f, 6.12510890e-02f, -1.07815243e-01f, -4.29840758e-02f, 2.19566301e-02f, 1.57824442e-01f, 8.92376676e-02f, 2.03821972e-01f, 1.29621536e-01f,
  8.15250352e-02f, -4.51135403e-03f, -2.26666369e-02f, 7.94770345e-02f, -1.17884740e-01f, 7.23768845e-02f, -6.87228218e-02f, -6.24311268e-02f, 5.84290177e-02f, 5.03114760e-02f,
  -6.90141246e-02f, -1.81888178e-01f, -1.67456642e-01f, -1.22434892e-01f, -2.76741311e-02f, -7.39368498e-02f, -4.21128236e-02f, 1.15995921e-01f, 5.27243093e-02f, -2.13897303e-01f,
  -6.25442266e-01f, 1.69663820e-02f, 1.82254329e-01f, -2.44539410e-01f, -1.11890517e-01f, 5.28696142e-02f, 3.32944721e-01f, -5.28216641e-03f, -9.55948755e-02f, 7.29507655e-02f,
  -6.48619905e-02f, -2.26327330e-01f, -1.98670074e-01f, -6.46075532e-02f, 3.63748823e-03f, 1.83416858e-01f, 1.53134301e-01f, 8.71228129e-02f, 2.59544551e-02f, -5.52928001e-02f,
  -3.69497724e-02f, -1.60958037e-01f, -1.34806231e-01f, -1.26705334e-01f, -6.60308823e-02f, -9.23725776e-03f, 4.19843979e-02f, -6.30750433e-02f, 2.42108274e-02f, 7.70393014e-02f,
  1.94898754e-01f, -3.72119337e-01f, -5.36498725e-02f, -1.41736448e-01f, -7.29735941e-02f, -6.10405691e-02f, 9.76904631e-02f, 2.96412804e-03f, -6.40306994e-02f, 2.71279383e-02f,
  -1.35895744e-01f, -5.54319695e-02f, -1.11890227e-01f, 3.54000479e-02f, 7.25138700e-03f, -9.06863809e-02f, -8.67957175e-02f, -8.31534937e-02f, -6.01195879e-02f, -1.28625974e-01f,
  -1.51937366e-01f, -3.65959704e-02f, -7.43075758e-02f, 8.05534199e-02f, -6.21792749e-02f, -5.16193099e-02f, -8.55815709e-02f, -1.45697728e-01f, 4.08130921e-02f, 1.78569227e-01f,
  -8.44532177e-02f, 9.58971903e-02f, 1.11316063e-01f, 4.48744334e-02f, 1.05653852e-01f, 5.19727170e-02f, 1.68864876e-01f, 2.08345294e-01f, 9.18921679e-02f, 1.80442646e-01f,
  6.76491112e-02f, 2.15848520e-01f, 1.65801153e-01f, 1.10370986e-01f, -4.35069315e-02f, -1.85727375e-03f, 4.67454717e-02f, -6.65158257e-02f, 2.92329863e-03f, 7.74680451e-02f,
  -1.87218841e-02f, 9.15140137e-02f, 3.22721414e-02f, 2.62602698e-02f, 5.81291094e-02f, 5.32166176e-02f, 5.08681946e-02f, -5.74903078e-02f, -7.04639852e-02f, -6.40749112e-02f,
  1.00108683e-01f, -1.73518240e-01f, 3.74375992e-02f, 4.12664637e-02f, 4.49328274e-02f, 9.40722898e-02f, -4.88088354e-02f, 3.07679828e-02f, 1.56951323e-01f, 1.13599449e-01f,
  8.43730941e-03f, 1.33534953e-01f, -3.69882472e-02f, 1.12315491e-01f, 5.10050990e-02f, -3.26167187e-03f, -4.76171356e-03f, 3.42605524e-02f, 2.28828024e-02f, 9.87175852e-02f,
  1.16587132e-02f, 1.39420241e-01f, 2.28449360e-01f, 1.46889523e-01f, 8.69086385e-03f, 8.12531561e-02f, 2.46713474e-01f, 5.06108105e-02f, 1.70609206e-01f, 3.33826631e-01f,
  -4.87195849e-01f, -3.36095870e-01f, 1.70254275e-01f, -2.20098034e-01f, -1.51936589e-02f, 2.41562203e-02f, 7.25612715e-02f, 5.56004001e-03f, -1.60734221e-01f, -7.53911883e-02f,
  -5.00223972e-02f, 5.80333639e-03f, -3.81758101e-02f, 3.94724086e-02f, -3.39809060e-02f, 8.92231688e-02f, 1.13085017e-01f, 1.18943952e-01f, 3.21056485e-01f, 2.24908754e-01f,
  2.59932932e-02f, -1.55231848e-01f, -2.83666193e-01f, -1.34832084e-01f, -9.17608663e-02f, -4.84037772e-03f, 7.97982980e-03f, -1.82972640e-01f, -1.67519078e-01f, -7.77565166e-02f,
  4.71261948e-01f, -1.09516211e-01f, 3.93595286e-02f, -1.30000174e-01f, 7.04810210e-03f, -6.92859739e-02f, 2.03926209e-02f, -6.89991638e-02f, -1.09290756e-01f, -1.22749329e-01f,
  -1.12647228e-01f, -9.62919593e-02f, 1.09543957e-01f, -2.04367116e-02f, 1.12569360e-02f, -3.26263905e-02f, -8.57513547e-02f, -4.46501076e-02f, 3.88311851e-03f, 1.28426239e-01f,
  1.05531052e-01f, -6.39944971e-02f, 1.45355705e-02f, -4.19783331e-02f, -1.67394444e-01f, 5.04030287e-02f, -5.01337014e-02f, -5.41793406e-02f, 2.65812012e-03f, -5.78184873e-02f,
  -1.57215998e-01f, 1.06218189e-01f, -6.75495807e-03f, 1.36270188e-02f, 2.39271037e-02f, 2.85208263e-02f, 3.41008306e-02f, 9.56111252e-02f, -3.73810828e-02f, -2.21947557e-03f,
  -6.54158443e-02f, 1.71793513e-02f, -2.49191858e-02f, -3.65888700e-02f, 6.34195507e-02f, -7.66509399e-02f, 3.17979895e-04f, -7.63213933e-02f, -1.54033199e-01f, -6.06294572e-02f,
  -7.08869100e-02f, 1.98179148e-02f, -8.81394595e-02f, 4.42834198e-02f, -1.08865127e-01f, 6.52393177e-02f, 3.26394625e-02f, -2.37712059e-02f, 3.94134372e-02f, -1.44046277e-01f,
  3.40129912e-01f, -1.78305671e-01f, 1.62261203e-01f, 3.19135748e-02f, 3.63585576e-02f, -1.13880306e-01f, -3.21012251e-02f, -1.23736791e-01f, -1.28285274e-01f, -5.04906587e-02f,
  -1.76475861e-03f, -5.36020007e-03f, -3.83691341e-02f, -7.81772956e-02f, -1.12302266e-02f, 7.28130806e-03f, -7.61532784e-02f, 1.63608491e-01f, -6.94616958e-02f, 3.24588530e-02f,
  -6.02485165e-02f, -4.47744131e-02f, 1.93250209e-01f, 4.33194973e-02f, -4.18187119e-03f, 1.65102094e-01f, 2.32932389e-01f, 8.26848019e-03f, 1.39666229e-01f, 4.92817722e-02f,
  2.11891621e-01f, 4.17789072e-03f, 3.83913480e-02f, 2.37556860e-01f, -1.43807009e-01f, -4.14521962e-01f, -4.55974400e-01f, -1.49266675e-01f, 1.50365636e-01f, -1.62669569e-02f,
  -1.91236362e-01f, -1.08402103e-01f, 7.20424345e-04f, -6.82239085e-02f, -2.33169958e-01f, -3.26237604e-02f, 4.80247103e-02f, 8.89537707e-02f, -2.07825780e-01f, -2.43104205e-01f,
  -8.80015343e-02f, 2.06337407e-01f, 1.44778550e-01f, 5.73658105e-03f, 1.37354627e-01f, -2.52506193e-02f, 5.21674491e-02f, 6.52083308e-02f, -3.07568479e-02f, 1.92272976e-01f,
  -9.84142274e-02f, -9.26919654e-02f, -9.81238782e-02f, 5.83458273e-03f, -3.47582847e-02f, 1.94076840e-02f, -8.81314650e-02f, 7.12331608e-02f, -3.95251438e-02f, -2.11371928e-02f,
  -1.05783127e-01f, -1.54017225e-01f, 5.09444065e-03f, -3.65633108e-02f, -7.75510445e-02f, -1.09811224e-01f, 1.79636925e-01f, -2.59959698e-02f, -1.05587197e-02f, -7.92036057e-02f,
  -1.90503553e-01f, -1.13649756e-01f, -1.00137614e-01f, -7.72688016e-02f, -8.03023353e-02f, 1.47272563e-02f, -1.53553560e-01f, -9.56283882e-02f, -2.05470473e-01f, 2.77802914e-01f,
  -4.61135656e-02f, 4.17617410e-02f, -3.03553827e-02f, 1.08061060e-01f, -6.95690960e-02f, 8.25988576e-02f, -6.05883193e-04f, -2.68808976e-02f, -8.12695771e-02f, -8.53995886e-03f,
  1.51767591e-02f, 1.23029128e-01f, 6.44260123e-02f, 9.67817307e-02f, 4.19866368e-02f, -4.73824441e-02f, -6.68852776e-02f, 6.48689270e-02f, 3.36779915e-02f, -3.88869792e-02f,
  -8.75378102e-02f, -1.87709518e-02f, 7.83591568e-02f, -3.55559238e-03f, -9.24069155e-03f, 5.57133108e-02f, -6.42421395e-02f, -3.19169164e-02f, 1.30479887e-01f, -7.44687319e-02f,
  5.95076494e-02f, -2.07919970e-01f, -7.27744773e-02f, -1.01276129e-01f, -1.13379946e-02f, 2.52662203e-03f, -6.01507127e-02f, -9.90700498e-02f, 5.35916798e-02f, -5.52861467e-02f,
  -2.66927332e-01f, -3.59274186e-02f, 3.30597311e-02f, -3.07713207e-02f, -6.92210793e-02f, -2.66069155e-02f, 9.07633007e-02f, -1.69283733e-01f, -1.23283848e-01f, 1.90259982e-02f,
  1.78012162e-01f, -2.69294512e-02f, -3.35906744e-02f, 5.29841632e-02f, 1.97937470e-02f, 2.25766003e-02f, -1.01489037e-01f, -1.35665148e-01f, -2.33248398e-01f, 1.70119971e-01f,
  -5.43652326e-02f, 2.67798096e-01f, -1.36144117e-01f, 6.98162094e-02f, 1.13994174e-01f, -9.06873941e-02f, 9.87194777e-02f, -5.67027554e-02f, -1.38830066e-01f, 4.57795151e-02f,
  -1.12944774e-01f, 2.74039130e-03f, -2.31628120e-02f, -6.68859631e-02f, -1.03023581e-01f, 2.06967965e-01f, 2.60380328e-01f, 3.13493772e-03f, -1.16270795e-01f, 6.79687643e-03f,
  2.08295479e-01f, -4.59731147e-02f, -1.19839326e-01f, 3.10634654e-02f, 2.48603955e-01f, 1.20062947e-01f, 6.29603192e-02f, 8.93618315e-02f, 6.32279962e-02f, 3.79383177e-01f,
  -1.35353282e-01f, 7.29116146e-03f, -2.01461866e-01f, 1.17536530e-01f, -2.44999915e-01f, -9.61123183e-02f, 6.77325800e-02f, -3.24902534e-02f, 7.55934557e-03f, -4.20581773e-02f,
  -3.90895270e-03f, 2.76137982e-02f, 7.30458200e-02f, -4.69454331e-04f, -1.72154754e-01f, -7.31158257e-02f, 7.88659602e-02f, 4.51265648e-02f, -2.83127695e-01f, -2.29822636e-01f,
  1.70948774e-01f, 6.74785003e-02f, -2.91408654e-02f, 3.92682850e-02f, -1.45466968e-01f, -1.58873752e-01f, -1.13623522e-01f, -3.68437842e-02f, -2.71187991e-01f, -3.32247495e-04f,
  -7.06376806e-02f, -7.83748403e-02f, 7.78578315e-03f, -2.52199862e-02f, -3.70298587e-02f, -1.18598878e-01f, -3.28931697e-02f, 1.63801368e-02f, -2.61365231e-02f, -2.34467741e-02f,
  -1.51353627e-02f, -5.84314913e-02f, -1.73543975e-01f, -1.27155766e-01f, -8.71845782e-02f, 8.99371691e-03f, 4.31452356e-02f, 4.64103036e-02f, -4.15880494e-02f, -4.87221479e-02f,
  8.96285176e-02f, 6.42430186e-02f, -4.49106582e-02f, 5.01784869e-02f, -4.13782522e-03f, -1.16095856e-01f, -8.29864368e-02f, -4.49425401e-03f, -1.24700956e-01f, -6.81935698e-02f,
  -3.58840972e-01f, -2.42396399e-01f, -9.25244167e-02f, 8.49496201e-02f, -5.02970628e-02f, -9.61084589e-02f, 9.06795487e-02f, -9.77923349e-02f, -1.11392618e-03f, -5.31383231e-02f,
  -3.50936167e-02f, -7.87962154e-02f, 2.59270668e-02f, 5.65850660e-02f, -4.21086214e-02f, 7.35001918e-03f, 8.27500150e-02f, 1.69253722e-01f, -8.37535709e-02f, -1.95391655e-01f,
  3.82871367e-02f, -6.45607486e-02f, -3.96453030e-02f, 2.02613488e-01f, -8.34337063e-03f, -1.31794512e-01f, -4.58162129e-02f, -2.22876802e-01f, -1.99954793e-01f, -8.84196311e-02f,
  7.75274858e-02f, -3.99675220e-01f, -4.47408825e-01f, -2.92361844e-02f, -2.41523325e-01f, -1.31221920e-01f, -3.07038635e-01f, 5.65469600e-02f, 2.50188392e-02f, -2.99284399e-01f,
  -1.50672808e-01f, 1.19064018e-01f, -3.25358175e-02f, -1.59091368e-01f, -1.90331563e-01f, -3.39742482e-01f, -3.54575634e-01f, -1.84204563e-01f, 2.75724959e-02f, 1.32360756e-01f,
  -1.50889428e-02f, -8.04357417e-03f, 8.33667368e-02f, -5.77054992e-02f, -9.22403336e-02f, -6.59946576e-02f, -3.51497442e-01f, -9.62591022e-02f, -2.53466368e-01f, -4.77486968e-01f,
  -1.17590934e-01f, 1.33841828e-01f, 1.65655777e-01f, 1.29659176e-01f, -2.17778347e-02f, 1.20798886e-01f, -1.32985972e-02f, 6.58270046e-02f, 1.56985149e-01f, 1.01664387e-01f,
  8.22864473e-02f, 7.83745721e-02f, 4.36392911e-02f, 1.96611732e-01f, 8.35702103e-03f, 1.04249902e-01f, 8.12881440e-02f, 1.19945355e-01f, 3.99686471e-02f, 3.19438353e-02f,
  1.78239439e-02f, 7.71938339e-02f, 1.52254671e-01f, 6.21360429e-02f, 9.03824195e-02f, 1.53161481e-01f, 1.08803399e-01f, 1.53320193e-01f, 1.08459257e-01f, -1.91746391e-02f,
  -3.22514996e-02f, -1.31603945e-02f, 1.02500781e-01f, 1.64007172e-01f, 1.34930491e-01f, 7.82823488e-02f, 1.72830839e-02f, -1.08671794e-02f, 1.06407806e-01f, 8.40818211e-02f,
  -6.02029450e-02f, 1.08540198e-02f, -9.96355317e-04f, 2.52855048e-02f, -3.79017927e-02f, 4.63759564e-02f, -1.03070192e-01f, 8.46474022e-02f, 1.18200360e-02f, 9.18668658e-02f,
  3.99956815e-02f, -6.24832325e-03f, -9.88767520e-02f, 2.18827259e-02f, -1.24133177e-01f, 2.07609683e-02f, 9.30570066e-03f, 6.63707852e-02f, -8.35523605e-02f, -3.00755221e-02f,
  1.05610654e-01f, -1.93839535e-01f, 7.45587572e-02f, 4.82994281e-02f, -6.58394545e-02f, -8.86209980e-02f, -4.43486013e-02f, -5.22992574e-02f, 3.13071883e-03f, 1.43545493e-02f,
  -2.58855987e-02f, -5.21961078e-02f, -1.05233751e-02f, 9.73852947e-02f, 3.74849103e-02f, 7.56894946e-02f, 6.48652837e-02f, -7.13095963e-02f, -1.13431096e-01f, 3.24543864e-02f,
  -1.39358351e-02f, -3.81466076e-02f, 1.74212247e-01f, 3.91113274e-02f, 1.11376658e-01f, -6.65267482e-02f, -8.84302631e-02f, -4.96508437e-04f, -2.33600736e-02f, -4.68290336e-02f,
  6.25686049e-01f, 9.54494476e-02f, 2.46647269e-01f, 1.69680074e-01f, -1.73245072e-01f, -1.31991491e-01f, -6.19476661e-02f, 2.95429248e-02f, 6.15474731e-02f, 3.45925950e-02f,
  -2.15732791e-02f, 2.27420386e-02f, 8.68160278e-02f, 7.53817409e-02f, 7.06271529e-02f, 7.97484592e-02f, 8.63098577e-02f, 3.37339401e-01f, 2.91429639e-01f, 1.11689031e-01f,
  1.85713004e-02f, 1.53111756e-01f, 2.53726274e-01f, 1.75861388e-01f, 1.60055548e-01f, -5.12016565e-02f, 1.69485696e-02f, 7.19133392e-03f, 2.32683420e-02f, 1.64952099e-01f,
  2.29508504e-01f, 1.63797840e-01f, 1.03442902e-02f, 2.33893730e-02f, -1.00039039e-02f, 1.73890237e-02f, 2.24062335e-02f, -5.44483475e-02f, -7.95960799e-02f, -1.31668868e-02f,
  -1.19484708e-01f, -1.04789734e-02f, 2.18313430e-02f, -5.51052950e-02f, 5.42112999e-02f, 2.15543378e-02f, -1.43210245e-02f, 1.06819421e-01f, 4.59638648e-02f, 3.47780995e-02f,
  -3.47302258e-02f, 4.90088314e-02f, 5.57539426e-02f, 1.95446610e-02f, -9.33096558e-03f, 9.86247957e-02f, 9.21249911e-02f, 1.63860157e-01f, -2.21340563e-02f, 2.21953884e-01f,
  9.77143794e-02f, 5.69955185e-02f, 1.14746336e-02f, 2.69451197e-02f, 1.32851213e-01f, 6.93918765e-02f, 5.90878427e-02f, -2.26246826e-02f, 7.47336075e-02f, 9.86773521e-02f,
  -3.00786421e-02f, 6.11465313e-02f, 6.94757327e-02f, 1.31826550e-02f, 5.21771498e-02f, 1.03589455e-02f, 7.90616348e-02f, -1.89318147e-03f, 1.59752015e-02f, -5.03426753e-02f,
  4.77515310e-02f, 7.76732713e-02f, 2.30352823e-02f, 9.39752981e-02f, 4.79380824e-02f, 1.10484667e-01f, -6.04683813e-03f, 9.89283174e-02f, 2.29716953e-02f, 3.56786400e-02f,
  -4.22998786e-01f, -2.05481112e-01f, 6.98177889e-02f, 6.61134124e-02f, -9.22255218e-02f, -9.42856725e-03f, -4.96256910e-02f, 9.65330470e-03f, -1.46072507e-01f, -4.99882624e-02f,
  -9.74039361e-02f, 1.02844723e-01f, 8.42853449e-03f, 5.35856746e-02f, 2.35326029e-02f, -9.86949578e-02f, -1.59176402e-02f, -5.75378444e-03f, 7.85957836e-03f, -7.62584945e-03f,
  6.92754658e-03f, -3.11695021e-02f, 6.57310858e-02f, -1.33405561e-02f, -1.35808095e-01f, -9.93683487e-02f, -7.90677071e-02f, -8.47552493e-02f, -3.68752107e-02f, -5.40467128e-02f,
  -7.32153654e-01f, 9.34991986e-02f, 2.87471376e-02f, -2.38489017e-01f, 9.93128121e-03f, 5.30945435e-02f, -1.63108882e-04f, 1.16234854e-01f, -1.10039644e-01f, 4.78047971e-03f,
  2.29198374e-02f, 6.57936931e-02f, -3.41331959e-02f, -5.28226942e-02f, -2.25942343e-01f, -2.37565171e-02f, -1.70716420e-01f, -4.08499062e-01f, -3.36601853e-01f, -4.27777059e-02f,
  -1.16081826e-01f, -4.00812536e-01f, -3.72988701e-01f, -2.48615086e-01f, -4.41749245e-02f, -5.85623048e-02f, -9.32283401e-02f, -1.92564234e-01f, -3.74296941e-02f, -4.55735177e-02f,
  1.89342707e-01f, -9.75731239e-02f, -1.64434016e-02f, -9.09878165e-02f, 2.51570009e-02f, -7.57879168e-02f, -1.07253917e-01f, -1.05077721e-01f, -3.48842181e-02f, 5.00641540e-02f,
  2.52956916e-02f, -8.29133615e-02f, -1.67055294e-01f, 1.20380647e-01f, -9.38502699e-03f, -6.12158403e-02f, 1.04805253e-01f, -4.06842865e-02f, 1.36474058e-01f, 2.42571726e-01f,
  1.13679200e-01f, 2.50304248e-02f, 8.23563561e-02f, 2.16218829e-01f, 1.84068322e-01f, 3.56230214e-02f, 1.59435183e-01f, 1.78296149e-01f, 9.11417827e-02f, 1.79894000e-01f,
  -1.99358445e-02f, 1.96236879e-01f, -9.77185369e-03f, 1.91188268e-02f, 2.35773921e-02f, -2.79093310e-02f, -7.47283027e-02f, -3.21763046e-02f, -4.63320352e-02f, -1.60998348e-02f,
  8.90699476e-02f, 1.01391315e-01f, -7.47076198e-02f, -8.78220424e-02f, 2.24497970e-02f, 3.19297723e-02f, 7.91395269e-03f, 3.10335588e-02f, 2.83687431e-02f, 3.20856646e-02f,
  4.89903204e-02f, 8.57636854e-02f, -6.69721141e-02f, -1.70330331e-02f, -6.84377402e-02f, 2.34356746e-02f, 7.39927739e-02f, 6.19960316e-02f, 1.86949242e-02f, -8.17177519e-02f,
  3.50702666e-02f, -1.98068753e-01f, 4.24463004e-02f, 1.74469743e-02f, -6.84681460e-02f, -6.35449216e-03f, 4.03999491e-03f, -3.95331047e-02f, -7.15287924e-02f, 4.14703712e-02f,
  -5.86878844e-02f, -2.35977285e-02f, 3.63545604e-02f, 1.20444290e-01f, -9.86266062e-02f, 2.56504752e-02f, 6.90389127e-02f, -1.60498209e-02f, 5.56541309e-02f, 1.58986107e-01f,
  1.20277375e-01f, 2.06438582e-02f, -5.37895150e-02f, 1.47596225e-01f, 3.94378267e-02f, -1.20770425e-01f, 2.86606885e-02f, 7.85290748e-02f, -1.24986656e-01f, 8.89158994e-02f,
  -3.67209971e-01f, -3.30099314e-01f, 7.20945597e-02f, 5.52207567e-02f, 2.21762478e-01f, 2.16220498e-01f, 1.00486549e-02f, 7.77245164e-02f, 1.16788261e-01f, 2.95465738e-02f,
  -1.17381729e-01f, -1.06138393e-01f, 2.57572029e-02f, -7.29290247e-02f, -1.12996519e-01f, 8.92414004e-02f, 1.10274382e-01f, 6.09406531e-02f, 1.71056926e-01f, 1.54075608e-01f,
  1.46082312e-01f, -8.36834982e-02f, -6.21664934e-02f, 5.16882837e-02f, 1.54283017e-01f, 1.66392133e-01f, 1.01350490e-02f, -8.46066922e-02f, 1.28988042e-01f, 1.47719458e-01f,
  1.37315989e-01f, -1.94827199e-01f, 2.11026352e-02f, -1.47197485e-01f, -2.21504167e-01f, -1.56568244e-01f, 8.14062357e-02f, 2.32625119e-02f, -5.31082042e-02f, 7.67475367e-02f,
  -1.61695713e-03f, -1.13413736e-01f, -9.65895951e-02f, -7.14678969e-03f, -6.44882694e-02f, -2.08514575e-02f, -1.68620378e-01f, 7.83568621e-03f, 6.23782240e-02f, -5.01371957e-02f,
  -1.09555505e-01f, 9.52794624e-04f, 6.09984733e-02f, 3.01373452e-02f, -8.14483874e-03f, -4.05931026e-02f, -9.59157273e-02f, 3.95723879e-02f, -7.29544684e-02f, 1.21492776e-03f,
  6.26584068e-02f, -6.03796244e-02f, -9.09341127e-02f, -4.41810973e-02f, -1.00639393e-03f, -5.78426234e-02f, 2.80192662e-02f, 6.79271147e-02f, 1.29308766e-02f, -4.85142283e-02f,
  5.70594706e-02f, 2.18289003e-01f, 1.51569143e-01f, -2.31590196e-02f, -3.62876095e-02f, 1.37108667e-02f, 5.14925011e-02f, 5.56492805e-02f, -4.78384271e-02f, 6.94368705e-02f,
  1.27561335e-02f, 2.83406097e-02f, 6.85764253e-02f, 3.53910215e-02f, 9.42387655e-02f, 1.23897716e-01f, 7.85802975e-02f, -7.54309539e-03f, -2.37220265e-02f, -2.13125627e-02f,
  2.47880235e-01f, -1.72949079e-02f, 1.81864612e-02f, -4.56146747e-02f, -1.04894996e-01f, -1.61105216e-01f, -4.35568877e-02f, 2.09505670e-03f, -1.60070825e-02f, 1.49396248e-03f,
  -1.71411466e-02f, -3.86476405e-02f, -1.19259626e-01f, -3.26623395e-02f, 4.70570996e-02f, -7.09221810e-02f, -1.73393607e-01f, -6.43984824e-02f, 3.56670246e-02f, 2.58373674e-02f,
  -1.77331492e-01f, 1.53549691e-03f, 9.37146544e-02f, 1.11351781e-01f, 3.19408737e-02f, 1.07543185e-01f, 3.86323407e-02f, -5.36101051e-02f, 8.00874755e-02f, -5.16872928e-02f,
  -3.02959025e-01f, -1.94788679e-01f, -3.81693572e-01f, 1.49070159e-01f, 2.47275472e-01f, -7.45284706e-02f, -2.03390241e-01f, -1.27949119e-01f, 2.28156000e-01f, 5.61224706e-02f,
  4.74411547e-02f, 2.22344235e-01f, 1.23057447e-01f, 5.19290715e-02f, -2.01241344e-01f, -1.82247423e-02f, 8.19946527e-02f, -4.43880148e-02f, -1.30178064e-01f, 8.80779773e-02f,
  3.06935459e-01f, 2.34544784e-01f, -8.69013462e-03f, 9.13508162e-02f, 8.31715837e-02f, 1.21734925e-01f, 1.23589739e-01f, 1.27823293e-01f, 5.87589480e-02f, 8.97588655e-02f,
  -2.07992002e-01f, -2.65702963e-01f, -3.47506744e-03f, 8.74150917e-02f, -9.24726203e-02f, -1.02940887e-01f, -2.80132424e-02f, -1.66611269e-01f, -2.47369315e-02f, -3.44529301e-02f,
  1.16931155e-01f, 9.18048397e-02f, 2.24173069e-01f, -2.90071964e-02f, 1.57154109e-02f, -1.22723274e-01f, -9.18192118e-02f, -1.98230967e-01f, -3.12908292e-01f, -1.89079747e-01f,
  1.54551148e-01f, 2.34198675e-01f, -1.94612473e-01f, -1.40175611e-01f, -2.28277236e-01f, 1.00930668e-02f, -2.23034307e-01f, -1.91236228e-01f, -3.17537814e-01f, -2.89550960e-01f,
  2.44104117e-02f, -3.38563956e-02f, 3.65058295e-02f, 4.44867462e-02f, 1.54969916e-01f, 4.00782786e-02f, 9.91063192e-02f, 8.35238993e-02f, 1.34100780e-01f, -4.03023884e-02f,
  -5.73702231e-02f, -1.13122910e-02f, 3.84364165e-02f, -4.68582213e-02f, 3.27626914e-02f, 4.15407605e-02f, 1.57245845e-02f, -1.18988333e-02f, -2.05298252e-02f, -7.55287008e-03f,
  -3.33901793e-02f, 4.05406207e-02f, 2.16700017e-01f, 1.96233275e-03f, -5.12642898e-02f, -1.10159442e-01f, 1.64028592e-02f, -5.42744473e-02f, -9.10029858e-02f, 1.41544919e-02f,
  2.36803934e-01f, 2.03179345e-01f, 3.43626887e-02f, -5.18805534e-02f, 5.92427254e-02f, 6.57272432e-03f, 6.76081330e-02f, -1.11150220e-01f, -3.31871659e-02f, -9.29437503e-02f,
  -2.25437656e-02f, -4.93809208e-02f, 1.66062549e-01f, 1.84642553e-01f, -3.61215621e-02f, -1.05175130e-01f, 9.11197066e-02f, -7.21879378e-02f, -9.29048881e-02f, 3.89032550e-02f,
  1.13669515e-01f, -6.84437826e-02f, -1.50058880e-01f, -1.63173795e-01f, 5.52104078e-02f, -9.77862179e-02f, -3.59462872e-02f, -1.17578939e-01f, -2.99064517e-01f, -2.59048611e-01f,
  -2.26045102e-01f, -3.34601551e-01f, 1.15601696e-01f, 9.07987654e-02f, 2.43560359e-01f, 2.29972705e-01f, 2.66245902e-01f, 7.04294890e-02f, -8.82775113e-02f, -1.05150985e-02f,
  -3.94794166e-01f, -3.06124151e-01f, -3.02957147e-01f, -1.82555944e-01f, -6.73805028e-02f, 2.77004868e-01f, 3.43777835e-01f, 1.44566849e-01f, 1.74008772e-01f, 3.82963419e-02f,
  9.81726963e-03f, 1.22453153e-01f, -4.70939800e-02f, -2.96987966e-02f, 5.22692539e-02f, 5.52892312e-02f, 6.66685849e-02f, -2.51183100e-02f, -1.05665319e-01f, 1.47946239e-01f,
  -8.23333859e-02f, -2.27485076e-01f, -1.95352603e-02f, -1.06474288e-01f, -1.57850191e-01f, -2.27217451e-01f, -1.30306154e-01f, -1.36423126e-01f, -8.58544856e-02f, -4.44020070e-02f,
  -9.58004892e-02f, -6.73034927e-03f, 3.27355997e-03f, 6.29449338e-02f, 9.51914936e-02f, -6.29430190e-02f, -1.59169585e-02f, -2.37125810e-03f, 6.50222674e-02f, -3.01583800e-02f,
  6.41990919e-03f, 1.15402468e-01f, 1.88991249e-01f, 1.29701393e-02f, -7.61365965e-02f, 7.64070451e-02f, -3.40699330e-02f, 3.49606434e-03f, 4.33060713e-02f, 1.76357795e-02f,
  8.96940604e-02f, 2.36593336e-02f, -8.45922232e-02f, -4.64653559e-02f, 8.89340788e-02f, -4.62676212e-03f, 6.31176587e-03f, -1.07246026e-01f, 1.85096171e-02f, -1.00548744e-01f,
  -8.21062773e-02f, 1.56508852e-03f, -1.05078049e-01f, -5.19695692e-02f, -1.07450321e-01f, -7.04591870e-02f, 9.35318470e-02f, -1.07172318e-01f, -1.17455021e-01f, 2.16312078e-03f,
  3.80550884e-02f, 3.26492125e-04f, -2.23234412e-03f, 2.32552867e-02f, 4.78472076e-02f, -6.49943352e-02f, -3.19796279e-02f, -1.38526857e-01f, -6.47728667e-02f, 1.69181842e-02f,
  9.32748690e-02f, -1.71179876e-01f, -1.00426786e-01f, -2.75293235e-02f, 6.27171397e-02f, -1.83118895e-01f, -2.44436964e-01f, -9.84358415e-02f, 1.27553113e-03f, 2.34374609e-02f,
  -1.99110195e-01f, -7.21933767e-02f, -8.64774734e-02f, -1.71525553e-02f, 1.47043183e-01f, 8.52225348e-03f, -9.60463565e-03f, 8.87642950e-02f, 2.43717059e-02f, 5.20003699e-02f,
  1.76569819e-02f, 3.73165682e-02f, 1.06257528e-01f, 5.49576357e-02f, 5.82061559e-02f, 1.15262009e-01f, 4.58990969e-03f, 6.20003454e-02f, 6.14658855e-02f, 1.74447015e-01f,
  1.03163131e-01f, 1.99163303e-01f, -3.23507816e-01f, 1.79602996e-01f, 3.24855559e-02f, -2.23579362e-01f, -2.40467116e-01f, 5.98293245e-02f, 2.70065725e-01f, 1.81060389e-01f,
  1.05597422e-01f, -1.97662748e-02f, -1.03640035e-01f, -1.20561883e-01f, -3.71944755e-01f, -3.10344785e-01f, -2.92645872e-01f, -4.22683030e-01f, -4.84999955e-01f, -2.74639785e-01f,
  -8.83993357e-02f, -8.83579925e-02f, -1.98874190e-01f, -1.56827047e-01f, 1.98248208e-01f, 1.01396367e-01f, -2.49657799e-02f, -7.50391409e-02f, -1.52219370e-01f, 9.89097655e-02f,
  -2.80698359e-01f, -2.44169850e-02f, -6.75334260e-02f, 1.28167838e-01f, 6.63861036e-02f, -1.08295325e-02f, -1.22090653e-01f, 2.05198117e-02f, 1.05250247e-01f, -1.08931838e-02f,
  3.09334509e-02f, 2.41665617e-02f, -1.31524473e-01f, -6.07043914e-02f, 1.80042125e-02f, -2.83859298e-02f, 1.18813425e-01f, 2.88243257e-02f, 2.62671337e-02f, -2.04431731e-02f,
  -9.19662882e-03f, -1.38985366e-02f, 1.99923217e-02f, -5.51551804e-02f, -1.71196088e-01f, -1.54549420e-01f, 7.48695293e-03f, -9.06276479e-02f, -1.60327390e-01f, 2.38274977e-01f,
  -3.47390957e-02f, -2.71534044e-02f, -6.67066488e-04f, 6.41563833e-02f, 7.02266023e-02f, 1.56664313e-03f, 1.02650281e-02f, 1.90075263e-02f, -7.89590552e-02f, 1.18088730e-01f,
  8.91768113e-02f, -1.18360162e-01f, -1.34303212e-01f, -3.30780596e-02f, -7.53827468e-02f, 7.15717897e-02f, -1.98878534e-03f, 3.12422682e-03f, -5.25343828e-02f, 1.12046096e-02f,
  5.96484393e-02f, 7.35716755e-03f, 5.82737550e-02f, 3.33194807e-02f, 3.38123068e-02f, 4.43375595e-02f, -3.94884385e-02f, -3.59786977e-03f, -1.40556663e-01f, 1.32185058e-03f,
  2.43425846e-01f, -2.71315962e-01f, 2.24207956e-02f, 2.58603301e-02f, 2.91709434e-02f, 7.81547129e-02f, 6.92838132e-02f, 7.37650543e-02f, 9.98756140e-02f, 2.17741299e-02f,
  -6.75841793e-02f, -4.78411503e-02f, 4.12492529e-02f, 1.16448671e-01f, 3.84947397e-02f, -8.17431286e-02f, 1.04875207e-01f, 6.04895726e-02f, -2.98105646e-02f, 1.86406165e-01f,
  9.12587494e-02f, 1.24387853e-01f, 3.07705738e-02f, 6.27268851e-02f, -2.14421079e-02f, -9.02964175e-02f, 6.74799830e-02f, 9.17355716e-03f, -2.18379515e-04f, 3.12242419e-01f,
  -2.54121780e-01f, -5.82326353e-01f, 2.72436678e-01f, -6.34803483e-03f, 2.75174290e-01f, 2.07877204e-01f, -1.05284564e-01f, -7.97658041e-02f, -2.35244986e-02f, -1.28368765e-01f,
  -4.49620605e-01f, -2.93530524e-01f, -1.50826409e-01f, -1.95290327e-01f, -1.14334196e-01f, 4.81174067e-02f, 1.44538105e-01f, 2.71369040e-01f, 3.41096222e-01f, 1.80354584e-02f,
  1.83835477e-02f, 1.84705749e-01f, 9.43070874e-02f, 1.52974529e-02f, -1.35922343e-01f, 5.30947894e-02f, 8.18742737e-02f, 3.49599030e-03f, -1.92511648e-01f, -1.92293912e-01f,
  -2.75863826e-01f, -3.10744226e-01f, 2.16421828e-01f, -3.77829447e-02f, -5.09457029e-02f, -2.31302176e-02f, -5.26962504e-02f, 1.03245974e-01f, 4.65494283e-02f, -2.52069160e-02f,
  -6.11668117e-02f, -1.07526809e-01f, 2.92767007e-02f, 2.00530607e-02f, 9.76234153e-02f, 9.87132341e-02f, -8.78223404e-03f, -6.94084959e-03f, -1.30035654e-01f, -8.77003223e-02f,
  -1.84278056e-01f, -1.31901488e-01f, 2.93151867e-02f, 1.63408108e-02f, -9.14776474e-02f, 2.96356343e-02f, -1.04547068e-01f, -1.43890575e-01f, -2.98916176e-02f, -1.28050908e-01f,
  2.81282783e-01f, -1.01657972e-01f, -1.13522179e-01f, 6.08838105e-04f, 3.80758904e-02f, -4.42103818e-02f, -6.73703626e-02f, -1.34231895e-01f, -1.04851745e-01f, -1.24424067e-03f,
  -8.25385377e-03f, -2.11670864e-02f, -1.18925206e-01f, -6.36048168e-02f, -3.68270762e-02f, -6.86472356e-02f, -9.00068507e-02f, -1.13718897e-01f, -1.58393662e-02f, -5.68275638e-02f,
  -1.44527420e-01f, -2.54588271e-03f, 1.52548701e-02f, -3.63816097e-02f, -3.65894847e-02f, 6.23769052e-02f, -2.09731590e-02f, 1.97137762e-02f, 3.00324894e-02f, -9.25837010e-02f,
  -1.45536780e-01f, 1.13533817e-01f, -6.29776046e-02f, -7.43979812e-02f, 2.02460103e-02f, -8.90278667e-02f, -8.81891176e-02f, 1.26524968e-03f, -3.45104225e-02f, 3.51861701e-03f,
  1.83009561e-02f, 5.72514869e-02f, -5.42474678e-03f, -5.38110137e-02f, 1.52457356e-01f, 6.60874024e-02f, -1.92992494e-01f, -1.01443626e-01f, -7.29770437e-02f, -6.58049509e-02f,
  -2.70217080e-02f, 1.28379479e-01f, 1.00763835e-01f, -2.61894334e-02f, 1.38479949e-03f, 1.46335140e-01f, 1.23155061e-02f, 1.56386316e-01f, 8.72572362e-02f, 1.59369141e-01f,
  -2.82821655e-02f, -2.10988164e-01f, -2.86315203e-01f, -3.46351147e-01f, -3.42850089e-01f, -1.55873448e-01f, -1.39833331e-01f, -8.19216818e-02f, -2.10026875e-01f, -3.36113453e-01f,
  -8.94689485e-02f, 1.04638562e-01f, -7.25329593e-02f, 9.14636031e-02f, 2.30585963e-01f, -1.44667044e-01f, -1.08653314e-01f, 1.78457245e-01f, 2.42389694e-01f, 9.42759961e-02f,
  -8.53322148e-02f, -4.54965457e-02f, 2.24444382e-02f, 5.14210984e-02f, -3.34133416e-01f, -7.33337328e-02f, -2.20593512e-01f, -1.30728483e-01f, -1.36340149e-02f, -3.67771447e-01f,
  -2.37114295e-01f, -1.06582955e-01f, -5.93584701e-02f, 3.05115171e-02f, -1.79699451e-01f, 9.85525548e-02f, -7.67794326e-02f, -4.09492180e-02f, -5.60330087e-03f, -4.35176119e-02f,
  -5.03180660e-02f, 7.45427534e-02f, -9.59515944e-03f, -2.31002457e-02f, -6.17916137e-02f, -1.08228967e-01f, 3.46863531e-02f, 1.98987275e-01f, 5.07880412e-02f, -6.88390285e-02f,
  -2.15187073e-02f, 5.71566597e-02f, 1.62446462e-02f, -5.32323010e-02f, -4.96286675e-02f, 1.03641286e-01f, -2.46010197e-04f, 5.28205484e-02f, 7.34296963e-02f, -1.77418888e-01f,
  -4.42754067e-02f, -5.13166822e-02f, -4.33736891e-02f, 8.06843564e-02f, -1.55700499e-03f, -7.69683123e-02f, 3.71395536e-02f, -1.60842761e-02f, -1.66501879e-04f, 1.00766495e-02f,
  -7.23690242e-02f, 2.05169320e-02f, 1.14768953e-03f, -4.49365983e-03f, 1.04990760e-02f, 2.97945272e-02f, 8.98953453e-02f, -4.92731705e-02f, 7.73744239e-03f, 1.62941795e-02f,
  3.91326211e-02f, 8.57484043e-02f, -1.69262979e-02f, 7.15862960e-02f, 6.45812005e-02f, 4.07159068e-02f, 2.40928978e-02f, 8.33663717e-02f, -3.99070457e-02f, 1.38113886e-01f,
  -2.22093359e-01f, 3.19493949e-01f, -2.12394074e-01f, 7.90497065e-02f, 8.11772496e-02f, 2.46608127e-02f, -1.59726739e-01f, 3.11432183e-02f, -9.88040641e-02f, -4.44197021e-02f,
  3.09394747e-02f, -1.72660183e-02f, -1.16840594e-01f, -2.55044643e-02f, -1.28148451e-01f, 6.80874437e-02f, 2.84479931e-02f, -1.50799612e-02f, 1.37754560e-01f, -3.12896003e-03f,
  5.64870052e-02f, 9.06601995e-02f, 1.22029275e-01f, 3.58075202e-02f, 5.17644584e-02f, 5.54976948e-02f, -1.09503446e-02f, 9.98756438e-02f, 2.22795933e-01f, -8.57230648e-02f,
  -4.27564114e-01f, 2.47483075e-01f, 5.50555475e-02f, -1.16397895e-01f, -1.04162835e-01f, -1.33844137e-01f, 1.40775621e-01f, 1.53348848e-01f, 5.42305261e-02f, 3.49183172e-01f,
  1.92155153e-01f, -1.26381754e-03f, 9.54798684e-02f, 1.87767707e-02f, -5.15666604e-02f, 1.44208565e-01f, -9.42289680e-02f, -2.40154326e-01f, -4.01325583e-01f, -3.17465931e-01f,
  -1.30801260e-01f, -7.31525198e-03f, -1.75399989e-01f, -1.98323414e-01f, 1.39784336e-01f, 4.97452840e-02f, 2.27446198e-01f, 8.18787664e-02f, -1.91010237e-02f, 5.43828420e-02f,
  1.44470453e-01f, -1.56345278e-01f, -4.46785912e-02f, -2.11122751e-01f, 2.56186947e-02f, -3.67750302e-02f, -1.37345910e-01f, 3.16761993e-02f, -1.61740109e-01f, 2.67296005e-03f,
  -1.11398302e-01f, -3.05025037e-02f, -3.33126575e-01f, -1.05311796e-01f, -1.39311075e-01f, -1.02210075e-01f, -6.29620850e-02f, -1.41226307e-01f, -2.18465343e-01f, -5.78387752e-02f,
  -2.63258815e-01f, -2.37772301e-01f, -6.36507422e-02f, 9.12463292e-03f, -7.19310939e-02f, -2.17957929e-01f, 2.87751062e-03f, -6.33992851e-02f, -9.39123705e-02f, 2.61674792e-01f,
  1.37566999e-01f, 2.33136080e-02f, -7.82723874e-02f, 3.29373442e-02f, 9.07551721e-02f, -3.48040438e-03f, -6.33436590e-02f, 3.13171707e-02f, -7.38234147e-02f, -4.91234846e-02f,
  -4.87296432e-02f, 9.17877704e-02f, -7.63627468e-03f, 6.81752339e-02f, 6.41109198e-02f, -1.22240651e-02f, -1.02000877e-01f, 1.17767900e-01f, -3.92307304e-02f, 9.36751142e-02f,
  -8.26357864e-03f, -2.50082351e-02f, 1.60365216e-02f, 4.47928496e-02f, -1.79252904e-02f, -9.90120023e-02f, -3.51891713e-03f, 7.72442669e-02f, -5.01227081e-02f, -3.93063463e-02f,
  1.25347897e-01f, -1.29064798e-01f, 9.60534588e-02f, -2.06590164e-02f, -5.82232624e-02f, -1.31235331e-01f, -6.63995370e-02f, 9.31140333e-02f, 4.14002910e-02f, 8.58086646e-02f,
  -1.43361196e-01f, -4.97483201e-02f, 2.72922199e-02f, 4.11398243e-03f, -1.15498148e-01f, 5.50321899e-02f, 1.99471507e-02f, -7.64354365e-03f, -4.68695583e-03f, -9.37302131e-03f,
  2.08918657e-02f, 1.03577636e-01f, 3.11700441e-02f, 1.51268080e-01f, -2.80960202e-02f, 2.99829822e-02f, 1.67680189e-01f, 1.04714446e-01f, 1.74904726e-02f, 4.08528537e-01f,
  -4.82629657e-01f, -9.53857303e-02f, -6.72797039e-02f, -2.36318737e-01f, 5.81167117e-02f, 2.15541601e-01f, 1.30934447e-01f, 1.72249138e-01f, -6.66735768e-02f, -1.15958847e-01f,
  1.35354316e-02f, -8.47920105e-02f, -1.84361711e-01f, 7.37696663e-02f, -7.27595203e-03f, -3.45475748e-02f, -1.30251005e-01f, -1.81596741e-01f, 1.24569617e-01f, 1.71142846e-01f,
  1.09023862e-01f, -1.49359822e-01f, -1.13613069e-01f, -1.01477943e-01f, -1.97775483e-01f, -1.10687241e-01f, -1.47918209e-01f, -1.98327973e-01f, 2.64635328e-02f, -2.30963856e-01f,
  -1.25862285e-01f, 1.62362754e-01f, 1.75025627e-01f, -7.32589141e-02f, 1.03393933e-02f, 1.78996027e-02f, 2.57216021e-02f, -1.03305988e-01f, 1.38550222e-01f, 7.92933181e-02f,
  -1.29850626e-01f, 1.84073791e-01f, -1.07156448e-01f, 1.07092686e-01f, 9.39383581e-02f, -3.13489772e-02f, -3.14267576e-02f, 3.00183576e-02f, 7.20750988e-02f, 2.50200164e-02f,
  -5.15624434e-02f, -1.44299865e-01f, -1.12108968e-01f, 1.45468205e-01f, 6.27208650e-02f, -7.01756850e-02f, 8.81006867e-02f, 2.04600394e-01f, 8.20676535e-02f, -9.00857300e-02f,
  1.90358364e-03f, -2.07108841e-03f, 1.12257749e-01f, -3.98249552e-02f, -1.18165696e-02f, -7.35903159e-02f, -4.92822304e-02f, 7.76969567e-02f, 2.68984735e-02f, -6.58007264e-02f,
  5.86453974e-02f, -6.48618862e-02f, 9.53434780e-02f, -1.37818053e-01f, -1.23968415e-01f, -7.58836977e-03f, -3.27994898e-02f, -4.01695184e-02f, -1.09691590e-01f, -8.59287530e-02f,
  -7.83630833e-02f, -2.89947707e-02f, 3.77091728e-02f, 1.10847324e-01f, 1.36482026e-02f, -9.99068320e-02f, 1.01892218e-01f, 7.39693642e-02f, 6.00235015e-02f, -1.04925307e-02f,
  -2.57208169e-01f, -1.91262644e-02f, -1.98414758e-01f, 4.06845622e-02f, 4.24967520e-02f, 7.94509985e-03f, -2.58608997e-01f, 1.12608694e-01f, 4.95096482e-03f, -5.67704365e-02f,
  1.19910084e-01f, -5.00166081e-02f, -1.97089583e-01f, -4.25052270e-02f, 7.85073936e-02f, 1.46078765e-01f, -7.84436911e-02f, -8.72341320e-02f, -2.02318449e-02f, -7.19155073e-02f,
  -4.15581055e-02f, -2.08765790e-01f, -1.34526521e-01f, -6.96965232e-02f, 6.12145476e-02f, -2.12611005e-01f, -4.90788296e-02f, -1.54141724e-01f, -8.17088857e-02f, -3.01313311e-01f,
  -3.86814266e-01f, -1.16831332e-01f, 2.78886110e-01f, -7.94015452e-02f, 1.51998475e-01f, -6.67134672e-02f, -3.04668695e-01f, -1.33676380e-01f, -6.21751882e-02f, 8.81496072e-03f,
  5.18411258e-03f, 8.62695947e-02f, 3.64647172e-02f, 6.85594529e-02f, -1.36814877e-01f, -1.01394497e-01f, 5.60392514e-02f, 7.70987868e-02f, 1.60558168e-02f, -1.33037627e-01f,
  -4.67776209e-02f, 1.41714402e-02f, -5.01805730e-02f, -8.69006943e-03f, -1.40978172e-01f, -9.53540802e-02f, 5.02015576e-02f, -4.49306257e-02f, -7.55540654e-02f, -1.22795001e-01f,
  -3.21387313e-02f, -2.24049494e-01f, 2.13624403e-01f, -7.54878744e-02f, 2.20112890e-01f, -1.13930918e-01f, 1.98021922e-02f, 1.45685911e-01f, -3.41327600e-02f, 3.52884680e-02f,
  5.18106557e-02f, 7.45375082e-02f, -5.00967614e-02f, 6.33011311e-02f, -1.37952194e-01f, -1.48591384e-01f, 1.97563663e-01f, 1.34587884e-01f, 1.32042125e-01f, -7.57563412e-02f,
  -3.51914763e-02f, -2.59477645e-02f, -1.89837068e-01f, 4.14801277e-02f, -1.02012932e-01f, 1.38933500e-02f, 5.98320812e-02f, -3.87356542e-02f, 5.29711321e-02f, -1.78410530e-01f,
  5.62700033e-02f, 7.63379559e-02f, 1.38378575e-01f, 2.55703665e-02f, -4.39302437e-02f, 2.26739570e-02f, 5.72777428e-02f, -5.89590557e-02f, 2.21689995e-02f, -1.74921840e-01f,
  7.96815157e-02f, 3.52534503e-02f, -2.23794207e-02f, -1.60161376e-01f, -3.87471798e-03f, -3.34523013e-03f, -6.90409616e-02f, -4.07845974e-02f, -9.04378891e-02f, 4.01939228e-02f,
  -8.41218233e-02f, 3.93126123e-02f, 9.00961906e-02f, -9.93074030e-02f, -1.41558805e-02f, 6.97047785e-02f, 1.14936093e-02f, 3.78672965e-02f, -7.46899843e-02f, -1.95011962e-02f,
  -1.52426109e-01f, 3.33864421e-01f, -2.36156449e-01f, -6.81175441e-02f, 5.64716905e-02f, 9.75442119e-03f, -3.57176773e-02f, 2.22769454e-02f, 5.65497093e-02f, -8.09278488e-02f,
  -5.99602498e-02f, -1.34307280e-01f, 8.35493580e-02f, 1.77124321e-01f, -1.17097437e-01f, -4.84690294e-02f, 2.36185994e-02f, -4.59962860e-02f, 5.97508550e-02f, 1.55472588e-02f,
  1.98419448e-02f, -3.18893701e-01f, -2.90188402e-01f, -2.33102024e-01f, -2.08241612e-01f, -2.74527460e-01f, -6.78346530e-02f, -1.87516466e-01f, -7.89720491e-02f, -3.62842828e-01f,
  6.64426684e-01f, -1.93414822e-01f, -1.38735585e-02f, 1.98126629e-01f, 6.09062798e-02f, 1.82118546e-02f, 4.69771922e-02f, 5.30491769e-02f, 4.64909151e-02f, -1.94571093e-02f,
  4.49019894e-02f, 2.22943217e-01f, 1.07907072e-01f, 8.66092518e-02f, 5.97781613e-02f, -1.17445990e-01f, -7.56956637e-02f, -3.52899469e-02f, 1.62467778e-01f, 7.59545639e-02f,
  -8.13637152e-02f, -1.18793376e-01f, -7.89139122e-02f, -2.16953969e-03f, -1.64589703e-01f, 1.06042355e-01f, -4.58632261e-02f, -2.57307708e-01f, -2.42866203e-01f, -3.80570650e-01f,
  -2.97501147e-01f, 9.15149152e-02f, 8.82582888e-02f, -2.23239288e-02f, -1.71281584e-02f, 1.27611086e-01f, 8.97929892e-02f, -3.77885532e-03f, 2.49977857e-02f, -1.38090223e-01f,
  1.29028317e-02f, -3.44259888e-02f, 3.65922553e-03f, 2.39126486e-04f, -1.03515849e-01f, 7.83296674e-02f, -5.82281575e-02f, -5.36531545e-02f, 5.93330711e-03f, -1.26380891e-01f,
  -6.01921864e-02f, 1.00765705e-01f, 5.95363751e-02f, 1.35455653e-01f, 6.38734847e-02f, 4.14862335e-02f, 4.46588099e-02f, 2.71975398e-02f, 6.80911541e-02f, 1.25349596e-01f,
  -9.37381107e-03f, 6.06679171e-02f, -5.12937531e-02f, 1.77185744e-01f, 1.12855509e-01f, 1.77411154e-01f, 2.23548431e-02f, -5.68243302e-02f, 1.48691580e-01f, 4.20657657e-02f,
  -3.64818908e-02f, 1.94564406e-02f, 1.42718866e-01f, -1.74647812e-02f, -3.64405476e-02f, 1.23440707e-03f, 7.17676058e-02f, -1.33449987e-01f, -1.12809829e-01f, -8.05982798e-02f,
  1.98378880e-02f, 8.33086018e-03f, -7.93103874e-02f, -1.78754389e-01f, -1.02462761e-01f, 1.12294685e-03f, -5.07604778e-02f, 2.30837450e-03f, 6.16219416e-02f, -1.01153187e-01f,
  -2.50211477e-01f, 6.87306747e-02f, 1.06295466e-01f, -6.17598519e-02f, -8.65653157e-02f, -1.08449712e-01f, 8.57991651e-02f, -1.98647287e-02f, -1.83046475e-01f, -8.16909075e-02f,
  -1.09003559e-01f, -5.92632741e-02f, -1.25283390e-01f, -6.13427386e-02f, 1.07241079e-01f, 8.52365345e-02f, -1.59666799e-02f, 3.49697396e-02f, -8.95355344e-02f, -1.62484735e-01f,
  -3.76190245e-02f, 1.36724561e-01f, 4.04701382e-02f, 1.66154265e-01f, 1.59128129e-01f, 2.47842506e-01f, 4.98625599e-02f, 2.86772905e-04f, 8.75172690e-02f, 1.59936264e-01f,
  1.46735847e-01f, -3.78360033e-01f, -2.23936185e-01f, 9.72238407e-02f, -1.78790003e-01f, -2.35625952e-01f, -4.96823490e-01f, -1.90216333e-01f, 3.89615856e-02f, -4.12319362e-01f,
  -2.33416408e-01f, 2.05081239e-01f, 5.30649237e-02f, 1.57905743e-01f, 2.84602586e-02f, -4.44084913e-01f, -3.34862709e-01f, 1.24705069e-01f, 2.88251847e-01f, 1.21936500e-01f,
  1.43740401e-01f, 2.21037775e-01f, 3.11395198e-01f, 1.91906437e-01f, -9.93492752e-02f, 6.02674782e-02f, -2.01632410e-01f, -2.10314672e-02f, -1.55863434e-01f, -2.05968380e-01f,
  -1.90942302e-01f, -1.59890905e-01f, 4.70533520e-02f, 6.60698414e-02f, -4.58791554e-02f, -4.09246907e-02f, -1.29591241e-01f, 6.63040811e-03f, -3.09992209e-02f, -1.60107419e-01f,
  -1.61698051e-02f, -3.44839133e-02f, 2.63338476e-01f, 6.38558418e-02f, 4.08505052e-02f, -1.22250300e-02f, -1.95711013e-02f, 9.24572498e-02f, 1.23319365e-01f, -1.50460050e-01f,
  -1.11757874e-01f, 1.85711477e-02f, 4.00127657e-02f, -1.01158039e-04f, -4.59823050e-02f, 7.32570142e-02f, -1.02723233e-01f, -5.44911362e-02f, -6.65716380e-02f, -2.67886132e-01f,
  -2.03779098e-02f, 4.30784896e-02f, -3.70950438e-02f, 6.30028248e-02f, -6.15171492e-02f, 1.94204021e-02f, 5.12701832e-03f, -3.95728126e-02f, 2.20361445e-02f, 2.30718646e-02f,
  1.91977136e-02f, -6.52583838e-02f, 1.50524974e-01f, 6.13195226e-02f, 3.25560980e-02f, 1.85897816e-02f, -1.11301458e-02f, 6.34531258e-03f, 2.05649957e-02f, -6.56376630e-02f,
  4.40614484e-02f, 1.54734179e-01f, -1.00255452e-01f, 1.29881456e-01f, -6.26878738e-02f, -2.21294127e-02f, 5.64491050e-03f, 4.19650935e-02f, -3.47052291e-02f, 2.61001736e-02f,
  1.01792678e-01f, -1.01672125e-03f, -8.50485787e-02f, 5.70916906e-02f, -4.92425635e-02f, -9.99630839e-02f, -1.62103307e-02f, -6.39116094e-02f, -2.95089073e-02f, -9.11268070e-02f,
  -4.05904613e-02f, 1.14288637e-02f, -4.08586934e-02f, 1.55918658e-01f, -6.86086190e-04f, -5.60324192e-02f, -1.50765464e-01f, 1.05906285e-01f, 6.15288541e-02f, -5.39146587e-02f,
  -9.10291970e-02f, -1.46340117e-01f, -2.49628946e-02f, -2.44482066e-02f, 2.49603298e-02f, -3.51663493e-02f, -8.58473405e-02f, -9.09853131e-02f, -8.93146247e-02f, -1.93085462e-01f,
  4.03992981e-01f, -6.86158165e-02f, 1.04643842e-02f, -4.38436307e-02f, -2.64970034e-01f, -2.73413450e-01f, -2.93591201e-01f, -6.45539612e-02f, -9.25329849e-02f, -6.29981561e-03f,
  -2.24452540e-01f, 1.03044435e-02f, 5.17923571e-02f, 3.09144966e-02f, 1.40982464e-01f, 3.89999300e-02f, 2.05720291e-01f, 2.03282535e-01f, 1.23675883e-01f, 6.01782650e-02f,
  2.43654083e-02f, 3.64004485e-02f, 2.31770560e-01f, 6.38308376e-02f, 7.54155964e-02f, -1.72243249e-02f, -4.71030502e-03f, 3.38721871e-02f, 8.66089016e-02f, 4.25789863e-01f,
  3.37508380e-01f, 1.76271319e-01f, -1.14226677e-01f, 3.12319826e-02f, 2.57451292e-02f, 1.21365309e-01f, 1.91140417e-02f, 9.31246132e-02f, 1.67407617e-02f, 1.58938970e-02f,
  1.40156567e-01f, 8.08636993e-02f, -1.21018626e-01f, -3.04631572e-02f, 1.99892819e-02f, 1.10128000e-02f, 7.06041455e-02f, 2.63698578e-01f, 7.51086473e-02f, -3.73790669e-03f,
  -8.43612328e-02f, -1.86932474e-01f, -1.33436561e-01f, -2.18909562e-01f, -8.49715322e-02f, -1.11230925e-01f, -7.46422783e-02f, 9.19083580e-02f, 2.67969929e-02f, 2.40692362e-01f,
  1.49659812e-01f, 1.13429315e-01f, 5.70560805e-02f, 1.32714093e-01f, 5.09436987e-02f, -5.23991324e-02f, 1.31030781e-02f, 2.68232021e-02f, 8.55848938e-02f, 6.80883899e-02f,
  8.14470556e-03f, 3.31383236e-02f, 7.94605762e-02f, -4.03728373e-02f, -8.11297074e-02f, 9.51735489e-03f, 2.24555209e-02f, 1.67568754e-02f, -1.22276485e-01f, -8.34577251e-03f,
  3.12600620e-02f, -1.21168830e-02f, -4.00413610e-02f, 1.69821814e-01f, -2.60274448e-02f, 1.51522025e-01f, 1.03648558e-01f, 8.87121558e-02f, 4.22625169e-02f, 8.54045302e-02f,
  -2.73036540e-01f, -2.98187315e-01f, 2.48872023e-02f, 1.12966329e-04f, 5.94994538e-02f, -1.66881084e-02f, -7.24525079e-02f, -3.07703037e-02f, -9.62718651e-02f, 5.12234457e-02f,
  -6.97724894e-02f, 7.75334910e-02f, -8.77660736e-02f, -1.02037393e-01f, -8.90482741e-04f, -5.29367775e-02f, 9.97344181e-02f, -1.67690646e-02f, -3.53509635e-02f, 2.56855078e-02f,
  -6.59599006e-02f, -2.47412920e-01f, -2.65538543e-01f, -1.69336841e-01f, -1.90282911e-02f, -1.33305311e-01f, -6.20656013e-02f, -5.84947839e-02f, -1.67555809e-01f, -5.06215841e-02f,
  -5.16746104e-01f, -5.10532744e-02f, -2.38184541e-01f, -3.76480818e-01f, -1.76826954e-01f, -1.35154009e-01f, -1.73497833e-02f, -1.13468178e-01f, -2.49010772e-01f, -1.25959843e-01f,
  8.60163942e-02f, 2.01272920e-01f, 7.11155385e-02f, 1.48588642e-01f, -3.34828198e-02f, -9.94544253e-02f, -2.08190992e-01f, -1.64986074e-01f, -7.08546489e-02f, 8.89171511e-02f,
  4.61309450e-03f, -1.72151938e-01f, -2.41132304e-01f, -1.33183405e-01f, 4.15478684e-02f, 1.96036343e-02f, -5.45706823e-02f, -1.36801243e-01f, -1.78430062e-02f, -2.32594863e-01f,
  6.38098046e-02f, -9.89578515e-02f, 1.91703290e-02f, -6.01246059e-02f, -7.65323490e-02f, -1.06152631e-01f, -5.54564632e-02f, -1.11289278e-01f, -6.18141927e-02f, 6.15344336e-03f,
  -7.47819990e-02f, 5.33555746e-02f, -1.63019914e-02f, -1.84330530e-02f, -1.01808071e-01f, 7.43624866e-02f, 4.71790954e-02f, 4.40190881e-02f, 8.04552659e-02f, 1.24203339e-01f,
  2.13746518e-01f, -8.93732980e-02f, 8.29067677e-02f, 7.23617822e-02f, 4.60612699e-02f, 4.09769602e-02f, 1.43455043e-01f, 3.45774703e-02f, -8.03767741e-02f, 7.10339248e-02f,
  -8.59894529e-02f, -3.63624357e-02f, 5.10599427e-02f, -7.71729648e-02f, 7.02936947e-02f, 6.43867925e-02f, -1.06675569e-02f, -4.66697663e-02f, 6.64800331e-02f, 8.36419240e-02f,
  8.13386440e-02f, -6.40197694e-02f, 2.94219255e-02f, -4.77640890e-02f, 7.99899548e-03f, -1.04108475e-01f, -7.47581348e-02f, -1.47560658e-03f, -2.41224878e-02f, -8.43234584e-02f,
  -6.91108033e-02f, -4.98279035e-02f, -2.78521292e-02f, 4.77544554e-02f, 2.37782509e-03f, 1.60247795e-02f, 4.26518731e-03f, -4.66779172e-02f, 8.00475758e-03f, -5.85353374e-02f,
  1.03837572e-01f, -2.09589288e-01f, -6.54447749e-02f, 5.63759059e-02f, -4.40273322e-02f, 3.64589170e-02f, -1.08387016e-01f, -1.10005930e-01f, -6.05510585e-02f, -1.14255421e-01f,
  -3.03529925e-03f, -9.93575826e-02f, -8.31747651e-02f, 4.44319248e-02f, -8.79164562e-02f, -6.69045821e-02f, 1.39921093e-02f, -1.69838294e-02f, 6.83880374e-02f, 9.39968303e-02f,
  1.54922917e-01f, 3.73175330e-02f, 8.50332305e-02f, 5.10788336e-02f, 1.00670241e-01f, 4.67159189e-02f, 1.23935357e-01f, 1.34497844e-02f, -3.05417739e-02f, 3.86786321e-03f,
  -3.13517123e-01f, -1.36964321e-01f, -2.51843244e-01f, -2.82321274e-01f, 5.34405038e-02f, 1.95407793e-01f, -4.64421026e-02f, -1.14259563e-01f, 4.80452813e-02f, -2.18664274e-01f,
  1.38701782e-01f, 1.19087592e-01f, -1.10394843e-01f, -4.44177538e-02f, -3.12431753e-01f, -3.11495036e-01f, -2.17473194e-01f, -2.04170272e-01f, 4.41574827e-02f, 2.29184061e-01f,
  2.03663915e-01f, 2.30632704e-02f, 5.02438955e-02f, -5.47264563e-03f, 4.36731093e-02f, 5.43548949e-02f, -2.13931743e-02f, 1.19672995e-02f, 1.39240623e-01f, -3.54945585e-02f,
  -1.40258953e-01f, 2.51793861e-02f, 1.47503391e-01f, -6.19477183e-02f, 2.80954335e-02f, -4.48154435e-02f, 4.00273800e-02f, -5.95505573e-02f, 7.24113882e-02f, -7.56682083e-02f,
  -2.90235709e-02f, 6.55918270e-02f, -4.02995758e-02f, -1.57010730e-03f, 1.52199110e-02f, -9.91950557e-02f, -1.50462359e-01f, -3.18923667e-02f, -4.97648381e-02f, -6.13605380e-02f,
  1.31150752e-01f, 2.20255792e-01f, -6.87418804e-02f, -3.57893258e-02f, -7.05247512e-03f, 9.29134414e-02f, 1.00308381e-01f, 2.15828121e-01f, 8.55719522e-02f, 5.70294075e-03f,
  1.95188671e-01f, 1.16598763e-01f, -1.08529620e-01f, 6.03140565e-03f, -4.67252806e-02f, 3.00851110e-02f, 3.64048108e-02f, -2.78677922e-02f, 1.37545601e-01f, -1.93635058e-02f,
  3.05806939e-02f, 3.92007083e-02f, -1.00412033e-01f, -1.91495903e-02f, 4.15382907e-02f, 2.02305242e-02f, 5.49553260e-02f, -6.96738809e-02f, 6.47602677e-02f, -9.40445904e-03f,
  -1.06948167e-01f, 1.24286022e-02f, 1.85238924e-02f, 3.94846611e-02f, -2.59553697e-02f, -3.99461985e-02f, -4.58267629e-02f, -4.54297438e-02f, -9.36119482e-02f, 4.14366908e-02f,
  -1.64278165e-01f, 1.85404509e-01f, -8.55754539e-02f, -5.40528335e-02f, -6.96750311e-03f, -2.73568202e-02f, 7.34071210e-02f, 7.99569581e-03f, -1.45343402e-02f, -1.57109890e-02f,
  4.97721806e-02f, -1.38779134e-01f, -7.91156292e-02f, -1.77456662e-02f, -1.71841942e-02f, -6.33266866e-02f, -2.42228925e-01f, -9.76939276e-02f, 9.08371434e-02f, -1.50116242e-03f,
  -1.10857710e-01f, -1.00559235e-01f, -1.03686050e-01f, -2.56113917e-01f, -6.75326437e-02f, -1.13134600e-01f, -9.79633480e-02f, 3.51101346e-02f, -8.35410953e-02f, -2.89144039e-01f,
  -2.66414285e-01f, 2.55895734e-01f, -5.23166656e-01f, -2.41659060e-01f, -3.31419051e-01f, -1.24181107e-01f, -5.59488013e-02f, 1.15250669e-01f, -4.28782739e-02f, -8.17260668e-02f,
  5.95240407e-02f, 1.05323158e-01f, -3.17972042e-02f, 1.87755376e-02f, 8.26242566e-02f, -6.98002726e-02f, -3.65030497e-01f, -2.07076207e-01f, 2.83950064e-02f, 3.99013162e-02f,
  -9.26226610e-04f, -5.96553907e-02f, -7.09586367e-02f, 6.23548962e-02f, 8.68379101e-02f, 1.72624752e-01f, -1.11065723e-01f, -1.11515820e-01f, -3.30732833e-03f, -1.26445338e-01f,
  -1.37721533e-02f, -1.81227833e-01f, -3.45044956e-03f, 8.02151486e-02f, -2.74408888e-02f, -4.67120372e-02f, -6.46301135e-02f, -1.79375764e-02f, -8.67860019e-03f, -1.43723592e-01f,
  -8.42943117e-02f, 9.94023401e-04f, -2.95404047e-02f, 2.06964221e-02f, -1.03773484e-02f, -8.14256743e-02f, -1.18382514e-01f, -1.80427477e-01f, -1.62839949e-01f, -1.02199674e-01f,
  -7.51784891e-02f, -1.79737493e-01f, -9.99681875e-02f, -9.57262218e-02f, -2.74643898e-02f, -1.27688691e-01f, 9.45128687e-03f, -8.48183299e-06f, -6.94798678e-02f, 1.06165096e-01f,
  2.43663825e-02f, 2.25420780e-02f, 2.18134914e-02f, 1.05247371e-01f, 1.03840875e-02f, -1.73914973e-02f, -4.55388054e-02f, 1.39634371e-01f, -1.06887020e-01f, 1.08954631e-01f,
  -4.90425862e-02f, 5.79796918e-02f, -2.29524244e-02f, -3.70296882e-03f, 5.92805184e-02f, -7.39521980e-02f, 2.28463095e-02f, 6.62503615e-02f, 8.14358145e-02f, 2.03236528e-02f,
  6.30230084e-02f, -4.97724935e-02f, -4.88102529e-03f, 1.59805462e-01f, -1.13382816e-01f, -7.76315629e-02f, -1.44042209e-01f, 5.84148653e-02f, -3.77975963e-03f, -1.78582415e-01f,
  2.84854650e-01f, -1.60169080e-01f, 3.14803459e-02f, 1.63395315e-01f, -4.59659658e-02f, -3.25277112e-02f, 6.62548617e-02f, 5.95901627e-03f, -1.18233591e-01f, 6.16347715e-02f,
  4.70787883e-02f, 6.55330196e-02f, -2.45607179e-02f, 2.28413101e-02f, -4.02725674e-03f, -9.25058722e-02f, 8.97510424e-02f, -1.42582851e-02f, 7.69018903e-02f, 1.06576364e-02f,
  -5.43760769e-02f, 1.01161391e-01f, 1.97835237e-01f, 1.32488400e-01f, 6.89662397e-02f, 1.32559016e-01f, 1.81230664e-01f, 1.89679176e-01f, 6.30090609e-02f, 2.25856602e-01f,
  3.80757511e-01f, -3.28236073e-01f, -8.31667557e-02f, 1.09497430e-02f, -3.67335416e-02f, 3.22559439e-02f, 1.29680969e-02f, -1.42631069e-01f, -5.49682714e-02f, -7.37875402e-02f,
  -2.16154784e-01f, -1.31119385e-01f, -8.40469077e-02f, -5.87893203e-02f, 1.00170355e-02f, -5.83611466e-02f, -6.31894767e-02f, 1.14084460e-01f, 1.48743451e-01f, -2.30670301e-03f,
  -6.44908249e-02f, -3.02388836e-02f, 7.47127607e-02f, -9.45766717e-02f, -1.25888094e-01f, -5.76872118e-02f, -1.71258673e-01f, -5.51398136e-02f, -9.61231217e-02f, -2.08681434e-01f,
  1.38783157e-01f, -2.18280479e-01f, 3.58749963e-02f, -2.48847976e-02f, -3.89521243e-03f, 8.93521868e-03f, -4.47926074e-02f, -8.56772289e-02f, -8.15690905e-02f, 4.81564179e-02f,
  -8.26625228e-02f, 2.59952825e-02f, 4.93318513e-02f, -2.58390512e-02f, -2.65010316e-02f, -1.21561773e-02f, -1.04853176e-01f, -1.99777130e-02f, -4.64708917e-02f, -1.07479408e-01f,
  -9.77537110e-02f, -7.32080340e-02f, 7.81302676e-02f, 3.84417474e-02f, -1.62989385e-02f, 2.61536147e-02f, -8.91698971e-02f, -5.15240468e-02f, -7.09392056e-02f, -9.43212956e-02f,
  9.35036987e-02f, 2.96477997e-03f, -7.21467137e-02f, 2.37366837e-02f, 4.69300598e-02f, 5.48190773e-02f, 6.64925873e-02f, 6.38052002e-02f, 4.40533832e-02f, -3.21018946e-04f,
  -3.15198265e-02f, -1.21819474e-01f, -7.14859217e-02f, -8.38356689e-02f, -1.39004126e-01f, -6.74718618e-03f, -5.13270088e-02f, -5.51201738e-02f, -1.56279244e-02f, -2.48588510e-02f,
  2.94451229e-02f, -1.14014380e-01f, 2.75059287e-02f, 3.17578800e-02f, -8.61117914e-02f, 1.15448853e-03f, -4.07453403e-02f, 1.00183291e-02f, 7.00907260e-02f, 1.22743901e-02f,
  3.82165983e-02f, -2.95257987e-03f, 6.93578571e-02f, -5.21730073e-02f, 1.13759479e-02f, -5.03717735e-02f, -1.09400362e-01f, -2.98336428e-02f, -1.17793567e-02f, 4.78515547e-04f,
  -1.39045075e-01f, 4.26026508e-02f, 4.09620367e-02f, -8.80757347e-02f, 2.00489536e-01f, 4.93729627e-03f, -9.48954076e-02f, 9.15712193e-02f, -1.36425838e-01f, -1.29137069e-01f,
  -9.70003605e-02f, 1.02615498e-01f, 2.76633680e-01f, 3.47121023e-02f, 1.50176128e-02f, 1.82387322e-01f, 1.25015423e-01f, 5.45491315e-02f, 1.97992668e-01f, 2.29732737e-01f,
  -3.57893854e-02f, -4.63180989e-02f, 1.97292179e-01f, 1.43800989e-01f, -8.36652070e-02f, 9.83255915e-03f, 8.49584490e-03f, 3.85016948e-02f, -4.83326651e-02f, -5.30143790e-02f,
  1.36205241e-01f, 2.16109261e-01f, 1.62066817e-01f, 1.68464735e-01f, 1.65426672e-01f, 4.15185615e-02f, 2.25406177e-02f, 2.48902068e-02f, 1.33736476e-01f, 2.06611991e-01f,
  -1.34780528e-02f, -6.05094992e-03f, -7.97522962e-02f, -7.61616603e-02f, -4.82581817e-02f, 1.56350732e-01f, -8.04646686e-02f, -9.04376358e-02f, -4.24532853e-02f, -5.05278632e-02f,
  3.53379697e-01f, -1.05600748e-02f, 1.38824254e-01f, -7.41517693e-02f, 6.51277527e-02f, 3.95144969e-02f, 8.70136321e-02f, 9.12250727e-02f, 1.19391032e-01f, 7.00986683e-02f,
  7.74923190e-02f, -3.11629865e-02f, -1.91053957e-01f, -9.37850699e-02f, 4.72223535e-02f, -1.04956530e-01f, -9.86727625e-02f, 5.30219339e-02f, -6.00101463e-02f, -7.77569860e-02f,
  -1.21209938e-02f, -4.70761582e-02f, -5.35623059e-02f, -3.26112546e-02f, -2.60686763e-02f, 8.93214196e-02f, -5.96345328e-02f, -8.30582678e-02f, 7.68369287e-02f, 7.55753194e-04f,
  2.17028055e-02f, 1.66203193e-02f, -6.30396083e-02f, -1.30522221e-01f, -1.79019123e-01f, -7.26980418e-02f, -3.11523750e-02f, -3.36964913e-02f, -4.35434654e-02f, -2.27228776e-01f,
  -5.48531450e-02f, -2.77275704e-02f, -5.94314598e-02f, 7.43120257e-03f, 8.54438916e-03f, -3.79414782e-02f, 5.21219596e-02f, -5.62882517e-03f, -1.29758731e-01f, -1.72565207e-01f,
  -1.32117793e-01f, 6.71886131e-02f, -9.25637409e-02f, 2.30657589e-02f, -4.20605987e-02f, 3.58853340e-02f, -7.13078007e-02f, -4.01330851e-02f, -1.25311315e-01f, 6.11223355e-02f,
  1.52479127e-01f, -2.55085796e-01f, -9.49687883e-03f, -6.69223070e-02f, -2.56219562e-02f, 1.92053560e-02f, 5.03486991e-02f, 4.58687730e-02f, -4.46439069e-03f, 1.63423434e-01f,
  1.34440064e-01f, -2.32356787e-02f, -2.09082384e-02f, -6.98441640e-02f, -3.69911753e-02f, -2.61518601e-02f, -3.35006826e-02f, 2.06915960e-01f, 8.63651782e-02f, 1.15476362e-01f,
  -9.82181951e-02f, 9.11011621e-02f, 1.63557962e-01f, 1.64272208e-02f, -2.92311199e-02f, 1.78889900e-01f, 1.81301743e-01f, 2.64013037e-02f, 1.05481662e-01f, 6.74200011e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.86924174e-01f, 2.37890750e-01f, 8.89965221e-02f, 2.90231526e-01f, 1.09764203e-01f, 2.01555192e-01f, 1.51109233e-01f, 2.12332979e-02f, 1.24500908e-01f, 2.48195991e-01f,
  3.99876684e-02f, 1.59221366e-01f, 1.22631155e-01f, 1.61346823e-01f, 2.50897914e-01f, 9.78513882e-02f, 1.90119252e-01f, 9.62347239e-02f, 2.38323212e-01f, 1.00314967e-01f,
  -4.85389717e-02f, 4.73445952e-02f, 8.19421560e-02f, -1.46730496e-02f, 1.80289894e-01f, 2.66786247e-01f, 3.29609543e-01f, 2.42268905e-01f, 4.39364389e-02f, 2.23624602e-01f,
  -7.52931740e-03f, 1.94589451e-01f, -9.52628069e-03f, 1.74195275e-01f, -5.49304346e-03f, 1.65359989e-01f, 1.60627753e-01f, 2.42450669e-01f, 1.16455257e-01f, -6.61903918e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.48571092e-02f, -5.98157831e-02f, -2.29038205e-02f, 1.93439722e-02f, -4.64801267e-02f, 8.14982224e-03f, -8.95688906e-02f, 4.59229946e-02f, 2.56728120e-02f, 5.64129278e-02f,
  -7.52369463e-02f, 2.05077846e-02f, 9.00565758e-02f, 6.98793158e-02f, 2.13126373e-02f, -2.90933996e-02f, 1.05934367e-01f, 2.73067411e-02f, 2.14661196e-01f, 3.19085121e-02f,
  -1.64868489e-01f, 7.23769441e-02f, 9.67312828e-02f, 6.51190430e-02f, 1.88398451e-01f, 1.79125115e-01f, -9.44113210e-02f, 1.52501419e-01f, -2.41898134e-01f, -2.05196291e-01f,
  -7.63083994e-03f, -7.79450089e-02f, -7.42852166e-02f, -2.04923563e-02f, -8.56657997e-02f, -2.28788555e-01f, -7.90518448e-02f, -2.23318741e-01f, 2.70944118e-01f, -8.05604011e-02f,
  1.36331603e-01f, -1.24169048e-02f, 8.48229155e-02f, -1.86431501e-02f, 7.45138153e-02f, 1.25264272e-01f, 1.51014730e-01f, -4.06475961e-02f, -3.27622354e-01f, -2.42762379e-02f,
  1.02775358e-01f, 1.44105658e-01f, -2.09005445e-01f, 1.99590519e-01f, -9.58865955e-02f, 8.54325965e-02f, -8.53343755e-02f, -2.63006777e-01f, 3.49086225e-02f, -2.25162436e-03f,
  -7.50083998e-02f, 4.47731689e-02f, 1.09077401e-01f, -1.34043396e-01f, 8.15424919e-02f, 2.33115582e-03f, 9.35575366e-02f, -8.51990953e-02f, 1.08994152e-02f, -1.14151441e-01f,
  6.36314303e-02f, -1.12107702e-01f, -1.90715622e-02f, 7.19952807e-02f, -1.00159226e-02f, 5.74526340e-02f, 4.15710472e-02f, 2.32961610e-01f, -9.72285122e-02f, -4.68434431e-02f,
  -8.77903178e-02f, -1.60099827e-02f, -1.42796665e-01f, -6.51497245e-02f, -1.57145783e-01f, 7.14312345e-02f, -1.86781455e-02f, 1.59840453e-02f, -1.96166262e-01f, 1.04458414e-01f,
  4.17926237e-02f, -2.96369880e-01f, -6.99272305e-02f, -1.54859334e-01f, -1.59474835e-01f, -5.59782833e-02f, -1.58924520e-01f, 2.06535831e-02f, 1.48610115e-01f, -1.02674000e-01f,
  1.78153887e-01f, 2.44274527e-01f, -1.34589061e-01f, -7.73489550e-02f, -9.95383412e-02f, 1.24176487e-01f, 2.50090212e-01f, -9.24208090e-02f, 1.52507991e-01f, 2.20369343e-02f,
  -3.04783378e-02f, -2.98179090e-02f, 5.37989400e-02f, -3.55165035e-01f, 3.34221244e-01f, -1.40593424e-01f, -1.48162946e-01f, 9.23478976e-02f, -5.36631756e-02f, -1.87954128e-01f,
  -4.74659316e-02f, 1.96700454e-01f, 1.03364341e-01f, 1.74852256e-02f, -3.62758264e-02f, 1.90970764e-01f, -4.42679003e-02f, 5.85047379e-02f, -9.52259302e-02f, 9.39598382e-02f,
  -2.52254251e-02f, 7.26601332e-02f, 2.81516388e-02f, 2.14347228e-01f, -8.31240881e-03f, -6.82639482e-04f, -7.16599450e-02f, -1.43194363e-01f, 3.54332924e-02f, -2.80445237e-02f,
  3.52924503e-02f, -3.05595428e-01f, 9.92602706e-02f, -3.31958346e-02f, 1.21978804e-01f, -1.08713796e-02f, 3.16055894e-01f, 2.55135149e-01f, -8.17044303e-02f, -5.58023825e-02f,
  -6.43744394e-02f, -1.15868077e-02f, 3.10053080e-01f, 6.68229582e-03f, 8.70670602e-02f, 7.90811256e-02f, 1.36074558e-01f, 2.25026131e-01f, -1.33274689e-01f, -5.50268292e-02f,
  2.36641970e-02f, 1.09717406e-01f, -6.27468377e-02f, 6.11237288e-02f, -9.64262411e-02f, -8.06537420e-02f, -8.26194882e-02f, 7.59189725e-02f, 2.03244999e-01f, 2.15024799e-01f,
  -2.39434212e-01f, 1.57908455e-01f, -5.33555113e-02f, -2.49884099e-01f, 1.44518778e-01f, 1.14045434e-01f, 1.40153086e-02f, 2.30389670e-01f, -8.87497514e-02f, -1.53576896e-01f,
  -4.80953790e-02f, 7.92024359e-02f, 5.57605103e-02f, 6.24206550e-02f, 1.60933379e-02f, -1.99461818e-01f, -3.11353087e-01f, 3.49073745e-02f, 1.08514003e-01f, -1.00635566e-01f,
  -2.66186148e-02f, 1.45800248e-01f, 2.60419518e-01f, 1.44336047e-02f, -6.47955313e-02f, -1.37527781e-02f, -3.98291796e-02f, 3.96727845e-02f, -8.04069638e-02f, -1.26287028e-01f,
  3.14638093e-02f, 1.82682388e-02f, 3.89131606e-02f, -7.42000015e-03f, 6.42236993e-02f, 1.40184909e-01f, -4.43031676e-02f, 1.25978768e-01f, -2.83991657e-02f, -7.39161670e-02f,
  -1.82760973e-02f, 1.39388554e-02f, 9.79018118e-03f, -1.19901579e-02f, 1.00089386e-01f, -1.27981663e-01f, 9.07146856e-02f, -1.57440662e-01f, 6.01781197e-02f, 7.72880763e-02f,
  1.95461903e-02f, -1.92507580e-01f, 2.50221938e-01f, 1.12957537e-01f, 4.09662016e-02f, 2.10781083e-01f, -1.06255263e-01f, 7.66070709e-02f, 3.76846343e-02f, -5.05831465e-02f,
  -2.00499222e-01f, 7.02412948e-02f, 1.23595983e-01f, -1.22427873e-01f, -1.28702596e-01f, -2.62410901e-02f, 6.73479289e-02f, -2.13396922e-01f, 3.10511708e-01f, -4.78503741e-02f,
  2.71970034e-01f, -1.00203641e-01f, 2.38151029e-01f, -2.19446465e-01f, -1.91805989e-01f, 2.72230744e-01f, 1.39904529e-01f, 1.54362679e-01f, -5.07405698e-02f, -1.07650734e-01f,
  -1.65425107e-01f, 1.14049621e-01f, 1.63966835e-01f, 1.43603340e-01f, -9.83079672e-02f, -1.03135467e-01f, 1.95098653e-01f, 5.31277098e-02f, 4.76723015e-02f, 3.75223719e-02f,
  -3.97735760e-02f, 3.38663049e-02f, -3.43049131e-02f, 1.54919401e-01f, 6.72859922e-02f, -1.43814325e-01f, 6.58539170e-03f, 1.55335307e-01f, -2.79804152e-02f, 1.04602426e-01f,
  -4.33056280e-02f, 2.27353632e-01f, 1.25857219e-01f, -1.03185982e-01f, -1.89525336e-01f, -9.92869865e-03f, 1.03751048e-02f, 3.62377279e-02f, -6.84849918e-02f, -5.62394895e-02f,
  4.02703807e-02f, -8.45778510e-02f, -1.30932570e-01f, -9.77324247e-02f, 5.23337200e-02f, 4.17116797e-03f, 2.81008601e-01f, 1.24152638e-01f, 8.52530971e-02f, 1.24674499e-01f,
  -9.96331498e-02f, -1.71425924e-01f, 1.19930595e-01f, 1.70884669e-01f, -2.44749233e-01f, 1.51230618e-01f, -5.25404662e-02f, -1.88009068e-01f, -1.35558069e-01f, -8.25201795e-02f,
  5.44066131e-02f, -9.97195169e-02f, 1.33352399e-01f, -1.07576363e-02f, 2.07677588e-01f, -4.48835194e-02f, 1.99321061e-01f, -3.46347950e-02f, 7.30676949e-03f, 1.86430424e-01f,
  1.50134116e-01f, 1.05748862e-01f, -8.67942125e-02f, 8.75938758e-02f, -2.18276411e-01f, 9.07477736e-02f, 1.08674228e-01f, 5.39226495e-02f, -5.99328727e-02f, -9.03423652e-02f,
  -3.69978063e-02f, -6.19824454e-02f, -3.46095562e-02f, -4.28498015e-02f, -4.04414423e-02f, 7.48756751e-02f, -8.68040789e-03f, -8.63968953e-02f, 4.16169455e-03f, -5.78721315e-02f,
  6.50909394e-02f, -6.86041862e-02f, -8.00737664e-02f, -1.70422882e-01f, 1.43671446e-02f, -8.26074034e-02f, 1.19028553e-01f, 1.20460719e-01f, 5.93541376e-02f, -5.87971248e-02f,
  -9.73953828e-02f, -1.52759358e-01f, -6.45236820e-02f, 1.15384854e-01f, 1.59206361e-01f, -2.31782384e-02f, 1.05838120e-01f, 1.83523566e-01f, -1.08269185e-01f, -2.02930972e-01f,
  1.33578733e-01f, -1.57208163e-02f, -1.76234022e-01f, 2.79022101e-02f, 2.33178511e-02f, -3.79380137e-02f, -9.53171179e-02f, -8.90674368e-02f, 9.63964239e-02f, -1.85858622e-01f,
  1.16498940e-01f, -2.77583506e-02f, -1.49796149e-02f, 2.94005305e-01f, -2.29680687e-01f, 2.04426602e-01f, -1.66416448e-02f, -5.22466376e-02f, -3.23472887e-01f, 7.80089200e-02f,
  -1.16071552e-01f, -2.70965546e-01f, -2.09664464e-01f, 4.75114547e-02f, 4.19783071e-02f, 3.58095579e-02f, 4.37449291e-02f, -2.23668963e-01f, 1.38142198e-01f, -1.06404632e-01f,
  -1.54143959e-01f, 1.98401883e-02f, -1.58774972e-01f, 1.19899720e-01f, 5.31907082e-02f, -1.34939864e-01f, -1.16933417e-02f, -1.64764345e-01f, 3.20032053e-02f, -1.15556195e-01f,
  -4.06732559e-02f, -1.01284385e-01f, -2.75865030e-02f, -1.23899974e-01f, -1.05153590e-01f, -9.40704048e-02f, 5.21329651e-03f, -9.20913890e-02f, 4.32921052e-02f, 1.22537531e-01f,
  1.53207973e-01f, -1.09268345e-01f, 1.51368916e-01f, -4.72862385e-02f, 4.37387684e-03f, -1.03795275e-01f, 1.43973599e-03f, 1.94146484e-01f, 6.73884973e-02f, 1.01541393e-01f,
  2.17106134e-01f, -6.70680180e-02f, 4.70941477e-02f, -7.13126808e-02f, -1.95047110e-01f, -1.89508647e-01f, -3.71518731e-02f, -3.91981937e-02f, 1.84643462e-01f, -2.24002507e-02f,
  -8.64997432e-02f, -1.73859358e-01f, -7.13534132e-02f, -9.86777171e-02f, 1.45240366e-01f, 8.89618471e-02f, 1.73792467e-01f, 1.23773336e-01f, -2.02661157e-01f, 1.18441708e-01f,
  5.18935211e-02f, 1.72134563e-01f, -8.28396380e-02f, 8.16609412e-02f, 9.99045521e-02f, 1.35547578e-01f, -2.29697183e-01f, 1.68326586e-01f, -4.42385413e-02f, -1.54026300e-01f,
  7.67913461e-02f, -2.33093262e-01f, 5.11713151e-04f, -1.12863882e-02f, -1.03330798e-01f, -6.33865446e-02f, -1.02280118e-02f, -5.18283844e-02f, 5.69601096e-02f, 5.65248355e-02f,
  -5.41852834e-03f, 3.36476155e-02f, 6.11921661e-02f, -5.73159233e-02f, 3.03298850e-02f, 1.08454727e-01f, 9.30687785e-02f, 1.43041005e-02f, 1.23287350e-01f, 4.53113168e-02f,
  -7.70119280e-02f, -2.60740761e-02f, -1.52902067e-01f, -6.61759600e-02f, -1.53041378e-01f, 4.84735854e-02f, -1.76351979e-01f, 1.63007021e-01f, 1.70651093e-01f, 1.27379656e-01f,
  6.03523217e-02f, -1.95567355e-01f, 7.03211874e-02f, -1.78886861e-01f, -3.33442981e-03f, 1.95875630e-01f, -9.04661939e-02f, -1.52319387e-01f, 1.80055305e-01f, 1.05797209e-01f,
  1.12196751e-01f, -1.39492389e-03f, -7.90844411e-02f, -1.94551386e-02f, 1.34569883e-01f, -2.69511610e-01f, 2.30006248e-01f, -2.54409015e-02f, 3.71576548e-02f, 1.35063678e-01f,
  -3.44953716e-01f, -2.34650433e-01f, 1.40326887e-01f, 2.09802791e-01f, 1.48370534e-01f, 4.67825271e-02f, -1.73592031e-01f, -9.99094993e-02f, -8.30292553e-02f, 1.77723005e-01f,
  8.30474198e-02f, -5.88756278e-02f, 1.03747621e-01f, -1.16432741e-01f, -2.00774334e-03f, 8.57445076e-02f, -5.67457341e-02f, 2.05422595e-01f, 7.49726668e-02f, 1.38029680e-01f,
  9.46149230e-02f, -1.86653823e-01f, 7.45649338e-02f, -9.84138921e-02f, 3.08164917e-02f, -3.78378108e-02f, -7.09481835e-02f, -1.96374461e-01f, -5.78288324e-02f, -1.49247065e-01f,
  6.09485246e-02f, -9.94760767e-02f, 7.74841309e-02f, 6.58623651e-02f, 7.78479353e-02f, 7.16983574e-03f, -1.58929944e-01f, 1.92817003e-01f, -7.33230412e-02f, -8.23469907e-02f,
  -1.76280618e-01f, -3.46730798e-02f, 2.37411693e-01f, 6.02145568e-02f, 1.06111877e-01f, -3.73823084e-02f, -1.40514281e-02f, -3.43826950e-01f, 2.01636866e-01f, -1.80449739e-01f,
  2.51301467e-01f, 3.96438122e-01f, 6.75000157e-03f, 1.63968578e-01f, 7.97452182e-02f, -6.62968904e-02f, -7.73980934e-03f, 2.13470235e-02f, 2.10042272e-04f, -2.52627451e-02f,
  -7.12860748e-02f, -8.20695832e-02f, -3.20264772e-02f, 1.14762932e-01f, 2.45820694e-02f, -4.61968519e-02f, 2.88810670e-01f, -4.37801108e-02f, -6.61246032e-02f, 1.90614715e-01f,
  2.05464080e-01f, 4.14796211e-02f, -1.82456732e-01f, 8.42665881e-02f, 1.49617910e-01f, -1.80686235e-01f, 1.43317223e-01f, 7.22392127e-02f, 9.41870809e-02f, 2.01944843e-01f,
  -2.80570269e-01f, 1.59738883e-02f, 6.03796430e-02f, 9.26167220e-02f, -3.04616671e-02f, -3.67726050e-02f, 1.55974641e-01f, 7.17226639e-02f, -8.34907666e-02f, 9.22557618e-03f,
  6.21141717e-02f, -1.54036075e-01f, 3.26572731e-02f, 3.13044689e-03f, 3.08550764e-02f, 1.14944763e-01f, -1.92757836e-03f, 1.38669088e-01f, 1.47483898e-02f, 1.80444032e-01f,
  -5.83613776e-02f, -1.27039433e-01f, -2.77011275e-01f, -8.66872147e-02f, -4.07743335e-01f, -5.16588651e-02f, 3.17696124e-01f, 1.85167074e-01f, 2.05625519e-02f, -1.08668253e-01f,
  -2.77338564e-01f, -3.20720643e-01f, 1.56627357e-01f, -1.28173515e-01f, 1.91483200e-01f, -5.61055280e-02f, 6.56587407e-02f, 1.07532889e-01f, 9.97370929e-02f, -1.10761493e-01f,
  1.25842437e-01f, 4.94465008e-02f, 2.19182134e-01f, 9.62022319e-03f, 1.25596210e-01f, 8.75626355e-02f, -2.58861721e-01f, -2.59125270e-02f, -1.67782396e-01f, -1.42614618e-01f,
  1.30534932e-01f, -1.06753558e-02f, 2.35878546e-02f, 1.12703212e-01f, -5.75919040e-02f, -3.02704245e-01f, -1.69078797e-01f, -1.10656045e-01f, 2.94596374e-01f, -3.18588525e-01f,
  8.53369236e-02f, -1.05742641e-01f, 5.91274258e-03f, 1.59014061e-01f, 8.77515879e-03f, 9.10636261e-02f, 9.71725490e-03f, 1.31347477e-01f, 7.31208101e-02f, 2.48798765e-02f,
  -7.82872960e-02f, 2.17214357e-02f, 3.27801071e-02f, -3.05896122e-02f, -3.76835577e-02f, -2.53354579e-01f, -2.71868873e-02f, -1.40516102e-01f, -1.33114830e-01f, -3.36370207e-02f,
  -6.44851178e-02f, 4.59328368e-02f, -2.70303041e-02f, -1.13480054e-01f, -5.57655059e-02f, 3.59969959e-02f, -2.26567045e-01f, 5.67513891e-02f, -1.44258186e-01f, -1.39973208e-01f,
  1.20189279e-01f, 2.92655509e-02f, -3.79664153e-02f, -1.30551741e-01f, -1.31866306e-01f, -2.84417540e-01f, 1.49375036e-01f, -3.16693746e-02f, -1.10295579e-01f, 2.26919409e-02f,
  2.04722837e-01f, 1.53542981e-01f, 7.62759373e-02f, 5.97596653e-02f, -1.94440722e-01f, -3.63531895e-02f, 1.17269182e-03f, -1.49368078e-01f, -1.18037080e-02f, 1.33089842e-02f,
  2.51393206e-02f, -2.39665490e-02f, -2.62830079e-01f, -5.30737117e-02f, 5.34309074e-02f, -1.54179394e-01f, 2.93363363e-01f, 1.01000361e-01f, -1.11275487e-01f, 1.15327202e-01f,
  -1.03104077e-01f, 8.32894444e-02f, 1.70254521e-02f, -2.03845724e-01f, 2.67137408e-01f, 1.02836452e-01f, 1.68268234e-02f, 2.06726938e-02f, -2.91714787e-01f, 1.88207086e-02f,
  1.08835407e-01f, -7.74115697e-02f, -2.79271733e-02f, -7.85897374e-02f, 1.13631319e-02f, -1.65011398e-02f, 9.45701227e-02f, 5.22448905e-02f, -3.29922996e-02f, 1.75699859e-03f,
  -1.64343584e-02f, -4.50347066e-02f, -9.44872200e-02f, -6.12827577e-02f, 3.28200459e-02f, 1.17985226e-01f, -5.59507757e-02f, 2.27792002e-03f, 6.43173903e-02f, 1.39045194e-01f,
  1.30974352e-01f, -5.16418479e-02f, 2.27936115e-02f, 5.36624454e-02f, -1.30834905e-02f, 1.23806380e-01f, 1.34788349e-01f, -3.15470397e-02f, 5.73190786e-02f, -5.80205061e-02f,
  -3.94600667e-02f, 1.42945409e-01f, 1.72745530e-02f, -9.34915021e-02f, -1.16172239e-01f, -7.11425394e-02f, -4.91674617e-02f, 1.70424748e-02f, 5.70216365e-02f, -1.21680267e-01f,
  7.05471933e-02f, -6.59227371e-02f, 1.34851485e-01f, -2.60891050e-01f, 5.16985841e-02f, 4.63154502e-02f, -3.16717997e-02f, 1.14891335e-01f, -7.76892304e-02f, -8.16050544e-02f,
  -4.59167100e-02f, 4.11296124e-03f, 2.08423119e-02f, -7.92817173e-06f, 1.89666644e-01f, 1.13612138e-01f, -1.38593674e-01f, 1.21996634e-01f, -1.69247866e-01f, -1.46937013e-01f,
  1.27150072e-02f, -2.72599190e-01f, 1.77506372e-01f, -5.31814806e-02f, -1.20489493e-01f, 8.37993771e-02f, -8.72540623e-02f, 8.57388377e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -8.94825831e-02f, 1.21422365e-01f, -7.63385892e-02f, -6.99916482e-02f, -4.25796993e-02f, 9.93870124e-02f, -1.73771512e-02f, 1.75947994e-01f, -1.01834750e-02f, 1.06200792e-01f,
  1.92291051e-01f, -3.39921042e-02f, 8.47668797e-02f, 1.62455589e-02f, -8.95024091e-02f, -1.21474698e-01f, -2.70694084e-02f, 1.35759130e-01f, 8.50415528e-02f, -6.01591170e-02f,
  6.10112138e-02f, 2.23754207e-03f, 1.78926468e-01f, -3.46571021e-02f, -7.06143975e-02f, 1.53397888e-01f, -7.83604309e-02f, -1.89336594e-02f, 1.05527699e-01f, 1.02041252e-01f,
  -1.97591990e-01f, 7.22835958e-02f, 7.91910663e-02f, -3.24499793e-02f, 2.77858088e-03f, 7.36133829e-02f, 2.05126494e-01f, -2.10254401e-01f, 1.95770398e-01f, -7.78804198e-02f,
  -2.47428432e-01f, 6.77753333e-03f, 1.02584854e-01f, -1.72351733e-01f, 6.62766099e-02f, 1.93421647e-01f, -2.76863556e-02f, -1.77851781e-01f, -1.88824803e-01f, -1.80883348e-01f,
  3.97570394e-02f, 3.79293077e-02f, 2.46964008e-01f, -1.38522148e-01f, -6.81904182e-02f, 4.69548889e-02f, 2.92759240e-01f, 6.71989247e-02f, 1.34738296e-01f, -1.74000353e-01f,
  -2.99119893e-02f, -3.60301770e-02f, 1.49540395e-01f, 8.16205963e-02f, -1.07775694e-02f, 9.79697034e-02f, 1.14665022e-02f, -1.54123185e-02f, 1.50184035e-01f, 6.75422028e-02f,
  6.74457178e-02f, 6.29077405e-02f, 1.27053246e-01f, -3.27768624e-02f, 7.87410066e-02f, 9.95575264e-02f, 2.70991046e-02f, 1.16293304e-01f, -1.15925580e-01f, -1.22866437e-01f,
  3.23318243e-02f, -1.32494807e-01f, -5.07245958e-02f, 1.74414694e-01f, 1.06268726e-01f, 3.72683667e-02f, 3.40047963e-02f, -1.38061583e-01f, 1.24964327e-01f, -1.01449989e-01f,
  6.77432194e-02f, 2.03496069e-02f, 1.52501374e-01f, -8.17753822e-02f, -2.37181336e-01f, -1.91476848e-02f, 8.84783268e-02f, 9.01462138e-02f, -9.60405171e-02f, -1.18851863e-01f,
  5.74548030e-03f, -2.72037357e-01f, 4.16254587e-02f, -1.19013220e-01f, 2.36328140e-01f, 2.41228968e-01f, -3.10524981e-02f, 1.46625936e-01f, -3.19045857e-02f, -5.28036766e-02f,
  -6.85298964e-02f, 7.97569603e-02f, 9.03566778e-02f, 7.51423091e-02f, 4.20331247e-02f, 7.46986717e-02f, 1.59306169e-01f, 1.18349649e-01f, -2.50826210e-01f, -1.95465252e-01f,
  1.88758364e-03f, -9.09777656e-02f, -2.24002019e-01f, 1.76861212e-01f, -2.65189141e-01f, 3.05922806e-01f, 2.09982112e-01f, -5.36095724e-02f, 1.15475722e-01f, 3.83922979e-02f,
  4.67691459e-02f, -1.58312052e-01f, 3.88694219e-02f, 1.81664526e-01f, 9.09137130e-02f, 9.51996911e-03f, 4.88649085e-02f, -1.61587238e-01f, 1.26749100e-02f, 1.50639087e-01f,
  1.21634323e-02f, -1.72668546e-01f, -3.58278602e-02f, 8.21633860e-02f, 1.40046909e-01f, -1.84337303e-01f, 1.26488611e-01f, 6.33676127e-02f, -5.97566226e-03f, -1.24919549e-01f,
  1.05664437e-03f, 1.67883039e-01f, 2.13014960e-01f, -9.87773538e-02f, 4.38910425e-02f, -5.49486876e-02f, 2.30337903e-01f, 4.09572482e-01f, -9.71585661e-02f, -1.29926801e-01f,
  3.60367596e-02f, -9.06734914e-03f, 2.46972125e-02f, 2.22217426e-01f, -5.41452412e-03f, 2.58840948e-01f, -2.52694964e-01f, 3.09734136e-01f, 3.00895005e-01f, 1.41335219e-01f,
  3.90130058e-02f, 2.28494942e-01f, -4.87347459e-03f, -1.57873318e-01f, -8.57156366e-02f, 6.37894049e-02f, 3.38045746e-01f, 1.98834494e-01f, -2.35636652e-01f, 3.00956219e-01f,
  1.20434828e-01f, 4.06235233e-02f, -1.72742177e-02f, 1.44311398e-01f, -1.40298009e-01f, 1.26111835e-01f, -1.35562524e-01f, -2.16220915e-01f, 3.50647978e-02f, -3.35656375e-01f,
  1.72267362e-01f, -7.52997864e-03f, -2.83873244e-03f, 1.63804561e-01f, 2.17848774e-02f, 2.52413034e-01f, 8.59675407e-02f, 2.93974489e-01f, 1.82988718e-01f, 3.67263854e-02f,
  9.55958590e-02f, 8.69371220e-02f, 1.64798424e-01f, 7.76955625e-03f, -3.35249268e-02f, -1.05398372e-01f, 4.17819917e-02f, -1.50075078e-01f, 1.15887158e-01f, -1.46462638e-02f,
  2.17873286e-02f, 3.57100926e-02f, 1.60335183e-01f, -3.39088663e-02f, 9.09098685e-02f, -6.48646802e-02f, 2.01996312e-01f, 3.85996699e-02f, 6.92831650e-02f, 1.80345133e-01f,
  2.52143927e-02f, -1.97575502e-02f, -1.44288197e-01f, 3.36914463e-03f, 4.43702675e-02f, -8.08067843e-02f, -2.21197531e-02f, 2.84451637e-02f, -5.51634692e-02f, -2.51012087e-01f,
  2.69310385e-01f, -3.29243056e-02f, 2.06613600e-01f, -1.71559185e-01f, 1.59760803e-01f, -1.25920519e-01f, 2.99901403e-02f, 4.89972532e-02f, 1.12713464e-01f, 4.57533728e-03f,
  3.68234031e-02f, 8.09973553e-02f, 1.55864865e-01f, 2.86296576e-01f, 3.98827456e-02f, 3.55738789e-01f, -1.08432338e-01f, -1.71632528e-01f, 2.28146419e-01f, -2.89612830e-01f,
  -1.88235387e-01f, 5.88053279e-02f, -1.68649316e-01f, 1.05123267e-01f, 1.07999839e-01f, -1.73833355e-01f, 5.65890856e-02f, 1.75216317e-01f, 1.47697762e-01f, 3.52322683e-02f,
  9.76815894e-02f, -3.75961550e-02f, 1.53266728e-01f, -2.05656037e-01f, 1.63701057e-01f, -5.61991893e-02f, -1.83302891e-02f, 7.43361413e-02f, 3.33389044e-02f, 1.91939861e-01f,
  1.47143930e-01f, 8.47720802e-02f, 5.93029186e-02f, -5.92609867e-02f, -5.72309755e-02f, -1.61036626e-01f, -8.54191780e-02f, 2.70492602e-02f, -1.61484957e-01f, 1.51803821e-01f,
  1.00471033e-02f, 4.58280630e-02f, -1.13013476e-01f, -1.09770194e-01f, 2.42747530e-01f, -1.13332629e-01f, -2.11995006e-01f, 1.00387130e-02f, 1.06128469e-01f, 1.60355255e-01f,
  1.19781964e-01f, -3.09665114e-01f, -1.54011343e-02f, 3.74722421e-01f, 2.29231603e-02f, 2.24556457e-02f, 1.64089069e-01f, 1.72242969e-01f, 1.69036567e-01f, 2.97837436e-01f,
  4.81081754e-02f, 1.21403234e-02f, -4.89869481e-03f, 1.00286707e-01f, 2.12785885e-01f, 1.36085272e-01f, 4.08545434e-01f, 8.08664318e-03f, -2.43303940e-01f, 2.66228497e-01f,
  -1.55496478e-01f, -2.64536291e-01f, -5.70268705e-02f, -2.61971533e-01f, 1.74575716e-01f, 4.71232608e-02f, 5.78686669e-02f, 3.38103443e-01f, -1.02728736e-02f, -2.56308764e-01f,
  -2.93328427e-02f, 2.94864476e-01f, 5.47410862e-04f, 2.92461276e-01f, 1.67645603e-01f, 2.40920290e-01f, 1.46711588e-01f, 7.00441822e-02f, 1.96174026e-01f, 5.89592569e-02f,
  -1.00234583e-01f, 6.59284592e-02f, -3.25021967e-02f, 1.03134878e-01f, 1.62520140e-01f, -5.05275838e-02f, 1.19462777e-02f, 7.29992688e-02f, 8.11610967e-02f, -6.34774864e-02f,
  -1.83279350e-01f, -9.88809168e-02f, -9.11440477e-02f, -2.60683093e-02f, -2.06379928e-02f, 2.91289330e-01f, -1.47032380e-01f, 2.08304957e-01f, -6.37969226e-02f, -3.13475311e-01f,
  1.87516943e-01f, 2.09016994e-01f, -4.83547337e-02f, 2.53859222e-01f, -1.12218872e-01f, -2.25390956e-01f, -6.71188235e-02f, 2.45626047e-01f, 1.13959750e-02f, 2.56669104e-01f,
  1.85058117e-01f, -9.04732123e-02f, 1.65777013e-01f, 1.87430128e-01f, 4.80544865e-02f, 4.56630439e-02f, 1.03475496e-01f, -1.37027046e-02f, 6.66468963e-02f, 5.75156743e-03f,
  2.51588017e-01f, -1.82367519e-01f, -1.88835636e-01f, 3.22417051e-01f, 2.15123340e-01f, 3.10262330e-02f, -2.55712748e-01f, -1.09127343e-01f, 2.92792290e-01f, 1.07604943e-01f,
  2.57507801e-01f, 5.46086393e-02f, -6.13549054e-02f, -2.44604405e-02f, 7.43176788e-02f, 2.78260279e-02f, 1.56043351e-01f, 7.17984140e-02f, 4.42555360e-02f, 4.18994948e-02f,
  -3.66340689e-02f, 9.71989334e-02f, 1.52100287e-02f, 7.59727582e-02f, 9.71932113e-02f, 2.22738251e-01f, -6.66266605e-02f, 1.14276901e-01f, -1.23669483e-01f, 3.40665057e-02f,
  1.08500971e-02f, -2.80902445e-01f, 1.23267278e-01f, -3.93073484e-02f, 8.03915188e-02f, -5.50532900e-02f, -2.64247041e-02f, 1.23946205e-01f, 1.33583486e-01f, 2.17652902e-01f,
  -8.12955797e-02f, -9.38605592e-02f, 1.99292183e-01f, -5.14767580e-02f, -9.39911529e-02f, 6.49690479e-02f, -1.44094480e-02f, 6.79456815e-02f, 5.48189841e-02f, -1.56273648e-01f,
  1.52795836e-01f, -9.04039815e-02f, -1.25323936e-01f, -8.07086974e-02f, 2.15957314e-01f, -1.02124900e-01f, 1.85316175e-01f, -1.91329941e-02f, 5.81934638e-02f, -1.70785055e-01f,
  3.45967174e-01f, -8.35834816e-02f, 2.84611553e-01f, -3.80370617e-02f, 3.14601749e-01f, -1.58749580e-01f, 6.91478997e-02f, 4.19226289e-01f, 3.84140131e-03f, 4.49918695e-02f,
  -8.35844502e-03f, -2.18756959e-01f, -1.46642193e-01f, 1.08364783e-01f, -4.62474413e-02f, 1.93077981e-01f, -3.49767879e-02f, -1.28433272e-01f, 1.17217742e-01f, 1.20919697e-01f,
  1.32848648e-03f, 4.01564017e-02f, 2.06660166e-01f, 1.90698817e-01f, 1.59764007e-01f, 2.43249089e-01f, 1.71345606e-01f, 1.33331269e-01f, 1.38975726e-02f, 1.39211252e-01f,
  -3.60058136e-02f, 2.03549728e-01f, -2.83746533e-02f, -1.17832504e-01f, -8.93184841e-02f, 1.20943688e-01f, -9.75544676e-02f, -1.92650363e-01f, 6.73651174e-02f, 6.82755560e-02f,
  1.86623096e-01f, -1.12875663e-01f, 4.51000817e-02f, -4.63953912e-02f, -8.44410434e-02f, 2.17120305e-01f, -1.23531580e-01f, 2.90448934e-01f, -1.86408028e-01f, -1.11949146e-01f,
  1.29313424e-01f, 2.27959566e-02f, -8.14874321e-02f, 1.04058467e-01f, 9.39988494e-02f, -1.65557727e-01f, 2.44378541e-02f, -9.89240780e-02f, 2.34909922e-01f, 1.40959710e-01f,
  1.81709319e-01f, 1.05542816e-01f, 7.26127326e-02f, 1.99839547e-01f, -2.51449436e-01f, 1.29923835e-01f, -1.56628624e-01f, 2.74542332e-01f, -1.28694028e-01f, 2.29830891e-01f,
  8.78992304e-02f, -6.82648122e-02f, -2.36192688e-01f, -4.49273773e-02f, 5.52692823e-02f, 1.92290947e-01f, 2.09890649e-01f, -1.05584115e-01f, -3.11480314e-01f, -2.10383292e-02f,
  2.35066339e-01f, -1.52173847e-01f, -1.95733877e-03f, 2.31907442e-01f, 4.97388057e-02f, 7.26009682e-02f, 2.49420851e-01f, 1.84771225e-01f, 1.79781020e-01f, 3.96545082e-02f,
  1.20678782e-01f, 1.04508370e-01f, -7.40381051e-03f, -5.37341945e-02f, 1.18458278e-01f, 1.26666753e-02f, 1.51496395e-01f, 1.02613322e-01f, 1.53670803e-01f, 2.72942394e-01f,
  1.02133028e-01f, -6.53640404e-02f, -3.26974362e-01f, -1.63639814e-01f, 9.58964508e-03f, 3.63925882e-02f, -5.95816113e-02f, 3.91567796e-01f, -8.97862315e-02f, 1.02823265e-02f,
  -2.13019580e-01f, -4.46101837e-03f, 2.81053744e-02f, 1.87851310e-01f, -1.29750576e-02f, 5.15681989e-02f, 7.58120231e-03f, 6.38376037e-03f, 5.64382747e-02f, 2.70724028e-01f,
  -2.23670388e-03f, 2.31493369e-01f, -9.73810107e-02f, -2.22686067e-01f, 1.45354658e-01f, 6.15771040e-02f, -9.52489972e-02f, 1.58413619e-01f, 1.04822353e-01f, -1.56551689e-01f,
  1.15243070e-01f, 1.04783945e-01f, 1.41490936e-01f, -1.16095237e-01f, -1.34189337e-01f, -9.20834765e-02f, 1.24410868e-01f, 8.77183601e-02f, -2.23247409e-01f, -4.67869192e-02f,
  2.40284413e-01f, 6.87115714e-02f, 2.08934676e-02f, -9.37332287e-02f, -1.81647047e-01f, -2.23013595e-01f, 5.20772785e-02f, 1.56808272e-01f, -1.47226388e-02f, 5.80628328e-02f,
  1.40671954e-01f, 1.09603047e-01f, 1.12825930e-02f, -6.13494776e-02f, 6.79209903e-02f, 1.15347981e-01f, 1.32226363e-01f, -1.06742932e-02f, -1.65600821e-01f, 5.26788235e-02f,
  -1.67777333e-02f, -5.29574417e-03f, -3.29377726e-02f, 2.02451631e-01f, -9.21970699e-03f, 2.70115286e-01f, 7.53203756e-04f, -6.64721522e-03f, -2.74840314e-02f, -1.98497713e-01f,
  1.82214215e-01f, 3.92543077e-01f, -1.12226546e-01f, -5.44768572e-02f, -3.13750893e-01f, 1.64528951e-01f, -1.79416671e-01f, -7.51784351e-03f, -6.08455837e-02f, -1.72506362e-01f,
  1.22400366e-01f, 7.65770376e-02f, -1.57970548e-01f, 2.41359428e-01f, -8.75229761e-02f, -4.84206751e-02f, 2.77461767e-01f, 4.52453822e-01f, 5.70105873e-02f, 1.26937747e-01f,
  -3.02855372e-01f, 1.36334810e-03f, 1.89155992e-02f, 1.37601480e-01f, -3.14249009e-01f, 3.73700947e-01f, -2.68197417e-01f, 3.11434358e-01f, -2.47619733e-01f, 1.51999578e-01f,
  -2.81130850e-01f, -2.07709551e-01f, -2.47510999e-01f, -1.51850656e-01f, 2.45682761e-01f, 2.32817978e-01f, -4.31343168e-01f, 9.58339050e-02f, -4.21523163e-03f, 2.45121881e-01f,
  7.78346211e-02f, 1.02897249e-01f, 8.03303998e-03f, 6.77122697e-02f, 1.68057919e-01f, 4.95966524e-02f, 1.25998899e-01f, 1.90717522e-02f, 5.88369034e-02f, 3.56746875e-02f,
  -2.85234954e-02f, 1.60853207e-01f, -5.31084836e-02f, 5.60327992e-03f, -1.23740867e-01f, 6.74658716e-02f, 1.39517218e-01f, -1.74298927e-01f, 2.05005035e-02f, 1.46426752e-01f,
  -2.61565614e-02f, 2.89672962e-03f, -1.18594728e-01f, 4.01810855e-02f, 2.31328487e-01f, 2.59026617e-01f, 5.91879077e-02f, -1.94245353e-01f, 2.64563411e-01f, -1.18184183e-02f,
  1.83393925e-01f, 1.29105061e-01f, 6.91588745e-02f, 9.67757180e-02f, -1.84179302e-02f, -1.86555058e-01f, 1.60801541e-02f, 1.05109163e-01f, -2.11156100e-01f, 1.10822625e-01f,
  1.88141391e-01f, 4.82374318e-02f, 1.26443179e-02f, 1.11757800e-01f, -1.20088086e-01f, -1.74531788e-01f, 3.51449281e-01f, 6.91840053e-02f, 3.62124175e-01f, -3.58050759e-03f,
  1.66439965e-01f, 1.75058156e-01f, -1.78277254e-01f, 2.55540818e-01f, 7.54520595e-02f, 2.32158422e-01f, -2.42799535e-01f, -1.92786232e-01f, -1.86672017e-01f, 3.22150558e-01f,
  2.08600342e-01f, 1.85199007e-01f, -6.25740364e-02f, -6.77080899e-02f, 4.95011918e-02f, 1.00608967e-01f, 1.46993309e-01f, 8.10572729e-02f, 6.55293092e-02f, 1.36412159e-01f,
  1.34031117e-01f, 5.79310879e-02f, -1.44320270e-02f, -1.71717163e-02f, 3.93151529e-02f, 9.18140635e-02f, -2.05342904e-01f, 3.38894539e-02f, -9.19223875e-02f, 1.09150507e-01f,
  2.03096330e-01f, -8.69509764e-04f, 1.23233311e-01f, 3.11297059e-01f, -1.85871288e-01f, -2.38401696e-01f, -1.90255135e-01f, 8.47018510e-02f, 2.19296776e-02f, 4.03860182e-01f,
  -3.43819372e-02f, -2.65106916e-01f, 2.00585902e-01f, 2.09770933e-01f, -1.60996422e-01f, 1.52382746e-01f, -9.18581933e-02f, 6.40980303e-02f, 1.34889588e-01f, -1.31488562e-01f,
  -1.15978695e-01f, 3.12295437e-01f, -9.86601785e-02f, 8.70854110e-02f, 3.10173899e-01f, 3.44164699e-01f, 1.72321215e-01f, 2.04018429e-01f, -6.42404556e-02f, -2.08122823e-02f,
  2.19787970e-01f, 1.37634799e-01f, 3.45798969e-01f, 9.21576470e-02f, 9.24508721e-02f, 2.31621683e-01f, -2.44598523e-01f, 3.12979460e-01f, 4.71065938e-02f, 9.40026343e-02f,
  -8.02962109e-02f, -6.61131069e-02f, 1.12186030e-01f, 2.43661419e-01f, 1.01953492e-01f, 1.59101263e-01f, -2.89800344e-03f, -2.90763937e-02f, 5.09060211e-02f, -9.21607316e-02f,
  1.04932532e-01f, 1.68843478e-01f, 1.53454030e-02f, 8.18446875e-02f, 1.25156090e-01f, 4.01827395e-02f, 2.00291932e-01f, 4.98331003e-02f, 1.52025580e-01f, 8.27049911e-02f,
  4.79933806e-02f, -5.22790194e-01f, 1.32638529e-01f, 1.20755181e-01f, 1.62686229e-01f, 2.08258584e-01f, 3.86149615e-01f, 4.01128352e-01f, -1.14478089e-01f, -1.27677709e-01f,
  -3.67856883e-02f, 2.00812891e-01f, 4.09362763e-01f, -3.32056507e-02f, -4.92446311e-02f, 2.64745414e-01f, 1.33358091e-01f, 9.67861637e-02f, 3.23544592e-01f, -9.02440958e-03f,
  7.72967041e-02f, 3.97216380e-02f, -1.57478824e-01f, -1.08922653e-01f, -4.58735712e-02f, -1.87367648e-01f, 1.76458046e-01f, 4.30630110e-02f, 2.28166386e-01f, 1.01034388e-01f,
  -1.93311617e-01f, 2.19715372e-01f, -1.54476166e-01f, -1.78110033e-01f, 1.51056200e-01f, -1.59191474e-01f, -8.39312300e-02f, 3.13782841e-01f, -2.77352422e-01f, -1.96325749e-01f,
  1.07278742e-01f, 1.14649937e-01f, 1.84254989e-01f, 2.39367858e-02f, -1.83083192e-01f, -2.54384279e-01f, -2.24314988e-01f, 1.29726544e-01f, 9.19709057e-02f, -4.10672911e-02f,
  -1.16813947e-02f, -1.43629789e-01f, 1.25405835e-02f, -1.01152860e-01f, 1.49460942e-01f, -1.46855205e-01f, -6.20220564e-02f, 7.01499432e-02f, -1.81872860e-01f, 1.22392021e-01f,
  -8.68323073e-02f, -8.53493139e-02f, 1.07887127e-01f, -1.03634950e-02f, 1.61248341e-01f, -1.81713849e-01f, -7.21211880e-02f, 6.30355179e-02f, 7.19502941e-02f, -4.19906080e-02f,
  1.20712824e-01f, 2.71109402e-01f, 1.97759792e-01f, -1.92995369e-01f, -2.51161326e-02f, 1.34948567e-01f, 2.89693683e-01f, -3.30274254e-01f, 3.06499898e-01f, -5.59848621e-02f,
  2.27430359e-01f, -3.09170857e-02f, 1.16026379e-01f, 3.11981682e-02f, 2.30767772e-01f, 1.26525149e-01f, 1.72228858e-01f, 9.07524955e-03f, -4.78685237e-02f, 1.11439442e-02f,
  1.58050776e-01f, 1.20517202e-01f, 3.16873901e-02f, 3.03740799e-02f, -2.66636372e-01f, 1.04613736e-01f, -1.95861325e-01f, 5.23501523e-02f, 1.56329408e-01f, 1.71017990e-01f,
  5.82033396e-02f, 2.12406740e-01f, -1.29102856e-01f, -1.31946325e-01f, 1.54671192e-01f, -3.16846892e-02f, 1.91458091e-01f, -5.66742904e-02f, -1.65898111e-02f, -1.01088472e-01f,
  -1.28180116e-01f, 2.80899908e-02f, 1.39746144e-01f, 6.80288002e-02f, -2.68436313e-01f, -5.99398762e-02f, -8.63778666e-02f, 6.91835731e-02f, 1.61346748e-01f, 6.68811873e-02f,
  -4.45690565e-02f, 1.76036786e-02f, 7.61365369e-02f, 6.23850226e-02f, 1.71320215e-01f, 1.49614021e-01f, 2.70226579e-02f, 9.52837523e-03f, 5.21790534e-02f, 9.74612907e-02f,
  -7.90122300e-02f, -1.68562964e-01f, -4.42379601e-02f, -6.00237809e-02f, 5.84768914e-02f, 1.79112077e-01f, 7.37646595e-02f, -2.83476748e-02f, 2.97662280e-02f, -4.66601960e-02f,
  5.79807814e-03f, 1.91183567e-01f, 1.79803222e-01f, -9.33651403e-02f, 7.75918225e-03f, -1.27187431e-01f, -2.05942482e-01f, 8.67485479e-02f, 8.25971067e-02f, 5.35739549e-02f,
  1.06598981e-01f, -4.55357917e-02f, 9.84295160e-02f, -1.14788845e-01f, 2.27050826e-01f, -2.86709845e-01f, -1.78834740e-02f, 2.60544389e-01f, -7.01989383e-02f, 9.35138986e-02f,
  1.50836967e-02f, 6.88244700e-02f, 1.82216719e-01f, -8.72259401e-03f, -1.27390891e-01f, -2.62517445e-02f, -1.54732719e-01f, -1.22804046e-01f, -9.50524509e-02f, 7.52296224e-02f,
  -3.42102312e-02f, -1.87953755e-01f, 4.52438369e-02f, -1.06144354e-01f, 1.63708970e-01f, 2.39699870e-01f, -2.17159808e-01f, 1.69931859e-01f, -3.83741483e-02f, 1.48546815e-01f,
  -2.81328466e-02f, 3.73822488e-02f, 1.26539648e-01f, 1.02377841e-02f, 5.73289655e-02f, -1.02346234e-01f, 1.95290208e-01f, -2.75662374e-02f, 3.50907035e-02f, 1.59532763e-02f,
  8.95466208e-02f, -7.45837837e-02f, -1.09059267e-01f, 1.16732500e-01f, -5.58221005e-02f, -3.66023667e-02f, -9.79244113e-02f, -4.72902097e-02f, -8.32674503e-02f, -5.85291721e-02f,
  -2.61717197e-02f, 7.05463532e-03f, -1.38059855e-01f, 1.22210935e-01f, -2.13919714e-01f, 2.47564930e-02f, -4.34698425e-02f, -4.49524336e-02f, 1.30873039e-01f, -1.74595818e-01f,
  6.34222180e-02f, 7.60356113e-02f, 2.53976835e-03f, -7.27331126e-03f, 8.69454220e-02f, 6.29771352e-02f, 1.01829715e-01f, 1.01453476e-01f, 2.72976011e-01f, 3.49607840e-02f,
  -1.99107409e-01f, -9.72035155e-02f, 1.13090388e-01f, -1.51578426e-01f, 1.75909102e-01f, -3.70473266e-02f, 3.02816302e-01f, -3.35920155e-02f, -2.66351961e-02f, -5.46803474e-02f,
  1.93222791e-01f, -2.05863267e-01f, 8.89003351e-02f, 3.46552134e-02f, 8.80277529e-02f, -2.66526956e-02f, 1.98008686e-01f, 7.83858672e-02f, 2.87864923e-01f, 7.05474839e-02f,
  2.41760865e-01f, 2.35559225e-01f, -2.29692161e-01f, 1.02768436e-01f, -2.14281608e-03f, 1.11653246e-01f, 9.23665464e-02f, 2.04786792e-01f, 2.41122708e-01f, 2.35340923e-01f,
  1.92840338e-01f, 2.66437829e-01f, 8.89312252e-02f, 1.65135995e-01f, 1.60587952e-01f, 6.32600859e-02f, 7.71254003e-02f, -2.51162499e-01f, -1.55833855e-01f, -3.03144250e-02f,
  3.56020257e-02f, 1.00154020e-02f, -9.95704681e-02f, 2.27754992e-02f, 2.18394548e-01f, 8.14041923e-05f, 2.83175915e-01f, -1.22858144e-01f, 2.99062520e-01f, -8.85003433e-02f,
  -3.31771858e-02f, 2.75047094e-01f, 1.83414489e-01f, 4.20016199e-01f, 8.96789208e-02f, -2.38756314e-02f, 5.27922139e-02f, -1.48191422e-01f, -4.01219502e-02f, 1.26693234e-01f,
  1.30860835e-01f, -2.23573908e-01f, 5.23924306e-02f, -1.25420794e-01f, 2.46553477e-02f, -1.15527906e-01f, -1.02144979e-01f, 3.09006777e-02f, -1.01025075e-01f, -1.87849924e-01f,
  -7.06668571e-02f, 7.44066760e-02f, -1.65660098e-01f, 3.46406609e-01f, -6.34300634e-02f, 7.37184510e-02f, 3.64219636e-01f, -5.44201583e-02f, -8.34852308e-02f, 1.67827547e-01f,
  2.67476756e-02f, 2.83207949e-02f, -1.21958077e-01f, -2.41322778e-02f, 9.91239995e-02f, -4.95141372e-03f, 1.10045388e-01f, -2.03092143e-01f, 1.89731654e-03f, 1.68355495e-01f,
  1.22095220e-01f, 1.99015766e-01f, -6.88058212e-02f, -1.34815872e-01f, 8.87564048e-02f, 1.52899027e-01f, 6.80601448e-02f, 1.15293667e-01f, 8.35270360e-02f, 6.49979562e-02f,
  4.24069315e-02f, 2.18859792e-01f, 2.32293811e-02f, 1.09784372e-01f, -1.45461932e-01f, -6.00754321e-02f, -2.29877383e-01f, -1.22961104e-01f, 3.15378308e-01f, -3.42621356e-02f,
  -1.19066425e-02f, -7.22469538e-02f, -3.52799706e-02f, -8.02229047e-02f, -1.69782024e-02f, -1.51327476e-01f, 2.52091587e-01f, 1.90606296e-01f, 2.62097627e-01f, 1.83130652e-01f,
  1.31230161e-01f, -3.88602279e-02f, 1.32568464e-01f, 4.65239361e-02f, 2.54413068e-01f, 1.21129267e-01f, -1.72321513e-01f, -6.04413962e-03f, -1.14811108e-01f, -2.90172666e-01f,
  5.82491122e-02f, -6.73428029e-02f, 1.68897256e-01f, -1.41465545e-01f, 9.65951309e-02f, -1.85505822e-01f, 3.94010305e-01f, -5.71730882e-02f, 2.88064241e-01f, -4.63991351e-02f,
  2.94419229e-01f, 1.02821134e-01f, 1.71196014e-01f, 2.32467249e-01f, -2.66133901e-02f, 3.37186784e-01f, -3.42849158e-02f, 1.53090522e-01f, 3.21391791e-01f, -7.21526379e-03f,
  -8.78058895e-02f, -2.50189006e-01f, 1.46868667e-02f, 1.16651930e-01f, 2.44063828e-02f, -5.20919152e-02f, 1.55943120e-03f, 5.08539416e-02f, 8.88324007e-02f, 1.32946625e-01f,
  2.16974337e-02f, 1.02368712e-01f, 8.93537924e-02f, 1.87385548e-02f, -6.39055669e-02f, 2.33773366e-01f, -1.33762673e-01f, -1.46281555e-01f, -1.91402175e-02f, -6.49813488e-02f,
  -8.76448676e-02f, 3.11135888e-01f, 1.23557068e-01f, 6.71864972e-02f, -1.23720892e-01f, -8.27773809e-02f, -1.25046104e-01f, 3.68401222e-02f, -1.06561743e-01f, -2.95298278e-01f,
  1.70529440e-01f, 2.12154076e-01f, -1.62432101e-02f, 2.15054542e-01f, 2.07384989e-01f, -1.52624678e-02f, 9.61224176e-03f, 1.59612875e-02f, 2.88154542e-01f, 2.25006565e-01f,
  -1.33239320e-02f, 1.14147745e-01f, -2.51503632e-04f, 4.75643240e-02f, 3.75057086e-02f, -6.26661815e-03f, 2.73617268e-01f, 9.70353186e-02f, 1.50707319e-01f, -7.28196576e-02f,
  2.81499773e-01f, -1.48995519e-01f, -5.38617633e-02f, 2.17551276e-01f, 1.27785638e-01f, 3.85024548e-02f, 2.11729258e-01f, 8.72286856e-02f, 2.48422492e-02f, 2.04188958e-01f,
  -4.54741269e-02f, 1.18408918e-01f, 3.21586907e-01f, 2.26393968e-01f, -4.35604937e-02f, -2.54056398e-02f, 7.89416134e-02f, -1.73557788e-01f, 4.16307002e-02f, -1.14729062e-01f,
  -1.12599991e-01f, 1.10810712e-01f, -7.02086687e-02f, 8.06714036e-03f, 5.41005284e-02f, -1.71984524e-01f, 1.96378436e-02f, 1.80957347e-01f, 1.01862349e-01f, -1.30070806e-01f,
  -1.24357916e-01f, 4.43779901e-02f, 2.46477172e-01f, -1.27114341e-01f, 2.04811156e-01f, 8.49444345e-02f, -4.59313206e-02f, -1.74386367e-01f, -1.03895426e-01f, 3.09544504e-01f,
  3.03170234e-01f, -1.56134218e-01f, 5.73388003e-02f, -2.36978196e-03f, 2.90282249e-01f, 1.16316237e-01f, 1.56566352e-01f, -1.02237865e-01f, 9.69630107e-02f, -6.60578012e-02f,
  -6.98644742e-02f, 3.82304797e-03f, -5.11954725e-02f, -1.25469506e-01f, 3.14824097e-02f, -1.49559602e-01f, 2.25622803e-01f, 8.46775994e-02f, -9.79756936e-02f, 2.34132901e-01f,
  -1.99815050e-01f, -2.33961836e-01f, 1.85715891e-02f, 1.40524521e-01f, 1.47884920e-01f, 4.92991917e-02f, -1.86916128e-01f, 2.78042611e-02f, 7.65018687e-02f, 1.90371051e-02f,
  2.38119543e-01f, 1.84495971e-02f, -1.10229515e-01f, -2.64679402e-01f, -2.34369367e-01f, -1.75202414e-02f, 9.31665972e-02f, 8.35579485e-02f, -1.40076280e-01f, -7.78170303e-02f,
  -1.19429588e-01f, 5.08709671e-03f, 5.13897464e-03f, 5.35523966e-02f, -9.76884961e-02f, -1.63983896e-01f, -1.31298304e-01f, 1.29934132e-01f, -5.42540183e-05f, 9.74708721e-02f,
  1.34678021e-01f, -8.49968791e-02f, -1.19912364e-01f, 1.33492678e-01f, -2.01300710e-01f, -1.66964248e-01f, -3.11872661e-01f, -1.00687169e-01f, -3.64176720e-01f, -3.90210003e-02f,
  4.02178317e-01f, 6.95038140e-02f, 9.36381966e-02f, -1.19607165e-01f, 1.39365261e-02f, -2.81619430e-01f, 1.12790920e-01f, -7.35236034e-02f, 1.24515362e-01f, -1.37113035e-01f,
  1.84264928e-01f, 2.22874507e-02f, 1.55782655e-01f, 1.63656503e-01f, -1.70789491e-02f, 1.13975704e-01f, 1.45668328e-01f, -9.01202336e-02f, 5.83406463e-02f, -1.25460684e-01f,
  -7.07793459e-02f, 1.43020928e-01f, -2.79531628e-01f, -2.22602859e-01f, 7.81921372e-02f, 1.70561284e-01f, -6.64625913e-02f, -9.53896195e-02f, -8.02379847e-02f, -1.07505143e-01f,
  -9.90123823e-02f, -6.05684780e-02f, 3.39510262e-01f, -2.59345353e-01f, 2.26051616e-03f, 2.26039700e-02f, 7.12102801e-02f, 8.61765444e-02f, 1.36417344e-01f, 2.17917576e-01f,
  -4.51357514e-02f, 1.26233563e-01f, 1.31973073e-01f, -2.33844414e-01f, 2.61987224e-02f, -8.51571374e-03f, 9.76672173e-02f, -9.90026742e-02f, 1.90321311e-01f, 1.88361734e-01f,
  -8.94318596e-02f, 1.09539568e-01f, 9.13556814e-02f, 7.96101242e-02f, -4.81298529e-02f, 5.84364124e-02f, -8.36665034e-02f, -4.06114906e-02f, -6.41709790e-02f, -8.18469096e-03f,
  1.96098268e-01f, 1.37439370e-01f, 6.94128424e-02f, -1.03355125e-01f, 1.15140148e-01f, 1.02333568e-01f, -5.35196764e-03f, -1.64082885e-01f, 1.76075310e-01f, 1.29433528e-01f,
  -5.20233624e-02f, -4.04827036e-02f, -9.74850729e-02f, 5.84155202e-01f, 5.72653161e-03f, -1.18869163e-01f, -1.04165018e-01f, -1.88073993e-01f, -6.62463084e-02f, -2.56667081e-02f,
  -3.03355187e-01f, 1.79428875e-01f, -2.79457271e-01f, -9.84491184e-02f, 2.25451142e-01f, 1.38638109e-01f, 2.91681349e-01f, -7.07407519e-02f, -3.79160345e-02f, 3.41939107e-02f,
  -2.38172650e-01f, 1.80016294e-01f, -6.17625043e-02f, 2.71784216e-01f, -1.50974423e-01f, 4.52246577e-01f, -2.21798748e-01f, -8.93840790e-02f, -1.47893518e-01f, 3.82403582e-01f,
  3.95724066e-02f, 1.33556068e-01f, 3.10665574e-02f, -1.24634296e-01f, -2.28914708e-01f, -2.30869099e-01f, 2.37815440e-01f, 9.92942005e-02f, -7.95578957e-02f, -1.03201009e-01f,
  6.77587241e-02f, 5.31820245e-02f, 9.83078703e-02f, 1.99041352e-01f, 5.91241680e-02f, 2.26552077e-02f, 9.95030329e-02f, -6.38106987e-02f, -7.01023787e-02f, 1.98448766e-02f,
  1.70522034e-01f, -8.69783089e-02f, -7.49537125e-02f, 2.28675529e-02f, 5.48631735e-02f, 4.81471233e-02f, 1.11768760e-01f, 2.70972639e-01f, 1.42478168e-01f, 7.42390305e-02f,
  3.08063868e-02f, -9.34187174e-02f, 4.05678123e-01f, -2.06486076e-01f, -9.49142873e-03f, 1.91595495e-01f, 1.69210613e-01f, 1.48643702e-01f, 1.61862165e-01f, -1.07245795e-01f,
  1.59814745e-01f, 1.03421427e-01f, -2.02705219e-01f, -4.60257009e-02f, -1.39698327e-01f, -2.20895901e-01f, 1.74331158e-01f, 1.28223687e-01f, 6.86677992e-02f, 2.89969414e-01f,
  -3.61678660e-01f, 9.86702293e-02f, -2.14144647e-01f, -5.75459823e-02f, 1.20882414e-01f, -4.23526019e-02f, -1.13335863e-01f, 2.96427280e-01f, -3.10650051e-01f, 2.19769046e-01f,
  -1.27287567e-01f, 1.07754089e-01f, 8.36887285e-02f, -3.98592763e-02f, -1.09976888e-01f, -2.30625942e-01f, -1.84315771e-01f, 1.63882419e-01f, -6.35277554e-02f, 6.56278282e-02f,
  7.30292648e-02f, -4.13563028e-02f, 1.50082365e-01f, 7.10221678e-02f, 1.31259412e-01f, 4.60651852e-02f, 5.32794334e-02f, 9.33650732e-02f, 3.07834316e-02f, 7.90039971e-02f,
  1.30623400e-01f, 1.30056411e-01f, 1.30344063e-01f, 2.08269343e-01f, 4.12384309e-02f, 1.50506288e-01f, 1.26070842e-01f, 6.21671183e-03f, 1.29057616e-01f, 9.69563946e-02f,
  8.17830488e-02f, -5.24728075e-02f, -1.29997835e-01f, -1.55606776e-01f, -1.40154034e-01f, 1.32904947e-01f, 8.69776402e-03f, 3.07479084e-01f, -1.05916418e-01f, -3.99413221e-02f,
  6.49834275e-02f, -9.77562275e-03f, -9.22112018e-02f, -1.00530647e-02f, 1.74537338e-02f, 1.98963493e-01f, -1.02178447e-01f, -1.57950476e-01f, -1.13838121e-01f, 2.70733893e-01f,
  1.07581757e-01f, 9.64611024e-02f, -1.01054884e-01f, 1.18983118e-02f, 1.35078803e-01f, 1.90069959e-01f, -1.70645982e-01f, 1.67406663e-01f, -3.21062386e-01f, -8.20193738e-02f,
  4.75280806e-02f, 4.03745174e-02f, 1.20861821e-01f, -2.67150849e-01f, -1.94633380e-01f, -1.42797709e-01f, -1.10410266e-01f, -2.67996192e-01f, -2.37104669e-01f, -1.77921839e-02f,
  3.53864759e-01f, -6.73483387e-02f, -1.65238958e-02f, -3.14432293e-01f, -3.68073583e-02f, 8.24308172e-02f, -3.97763168e-03f, 1.11199997e-01f, 3.51542309e-02f, 5.80627955e-02f,
  1.57245412e-01f, 3.35632935e-02f, -1.67943221e-02f, 1.56349838e-01f, 6.04635887e-02f, -5.60705848e-02f, 7.43834451e-02f, 1.31981343e-01f, 7.14556798e-02f, -8.74741822e-02f,
  1.47133201e-01f, 1.09702259e-01f, 1.21664479e-01f, 1.85400054e-01f, 1.71128243e-01f, 1.09496294e-02f, -5.32303937e-02f, -1.29746541e-01f, 2.70349123e-02f, 2.93743219e-02f,
  -8.72753635e-02f, 7.06117824e-02f, -1.46004274e-01f, 3.27874944e-02f, 1.36505082e-01f, 5.20119891e-02f, 1.14218436e-01f, 5.85621707e-02f, -1.05989784e-01f, 2.66974289e-02f,
  4.71975394e-02f, -7.73619190e-02f, 1.32646821e-02f, 3.31747681e-01f, -1.42348379e-01f, 4.12466764e-01f, -1.90703019e-01f, -2.12362483e-01f, 9.23637375e-02f, 1.15979016e-01f,
  9.83494148e-02f, -4.32566591e-02f, 1.97512537e-01f, -6.82396293e-02f, 2.73578048e-01f, -5.59015013e-02f, 2.11304560e-01f, -2.60961540e-02f, -1.46448165e-01f, -3.45580913e-02f,
  2.40361884e-01f, 2.06613570e-01f, -1.24262832e-01f, 1.70515671e-01f, 1.13393463e-01f, -5.87193370e-02f, 2.44196549e-01f, -6.16656840e-02f, -1.65438712e-01f, 1.91644225e-02f,
  1.13127954e-01f, 7.52768442e-02f, 1.17336482e-01f, 1.28430530e-01f, 2.27460533e-01f, 3.27306151e-01f, 1.06785782e-01f, 3.12029332e-01f, 9.49595645e-02f, 9.94333923e-02f,
  1.25043198e-01f, 3.55018042e-02f, -8.65077078e-02f, -3.64179283e-01f, -1.39504701e-01f, 2.66079102e-02f, 9.25449058e-02f, -3.98323908e-02f, 2.91065156e-01f, 3.42369646e-01f,
  1.58691574e-02f, -2.10014835e-01f, 1.91028208e-01f, 1.58001214e-01f, 2.06871733e-01f, 1.90491900e-01f, 1.71567559e-01f, 5.70856035e-02f, 2.02734128e-01f, 3.51659179e-01f,
  1.30022401e-02f, 1.41314015e-01f, -4.27114926e-02f, -2.08851621e-01f, 2.25610603e-02f, 1.17418893e-01f, -4.87415120e-02f, 5.32411002e-02f, -1.14633992e-01f, 9.38481838e-02f,
  2.08952501e-01f, -1.23528279e-01f, -1.97029598e-02f, -2.19580233e-01f, -2.54367441e-01f, 4.38734852e-02f, 2.67400853e-02f, 2.54601277e-02f, -5.53402565e-02f, 2.33574897e-01f,
  -7.05414191e-02f, 2.53441691e-01f, 1.06558390e-01f, 9.40970555e-02f, 1.52743056e-01f, 3.27718914e-01f, -1.80450574e-01f, 5.59548810e-02f, 4.23677312e-03f, 8.41268376e-02f,
  2.72060931e-02f, -1.36100307e-01f, -1.06735967e-01f, -1.49440199e-01f, 1.31716698e-01f, -9.89686791e-03f, 1.04263790e-01f, 1.06170271e-02f, 4.22763973e-02f, 1.14272468e-01f,
  1.22183621e-01f, 8.19282457e-02f, 4.78535332e-02f, 7.06200451e-02f, 1.59382910e-01f, 1.24765426e-01f, 2.27925465e-01f, 1.20448679e-01f, 1.44107282e-01f, 9.57558826e-02f,
  1.11950815e-01f, -7.64997602e-02f, 5.26055619e-02f, -7.06572235e-02f, -1.77397028e-01f, -1.79400712e-01f, -1.15212694e-01f, 2.31678616e-02f, 2.18708552e-02f, 9.74946022e-02f,
  2.62393296e-01f, 1.88391767e-02f, 2.33330399e-01f, -4.92137820e-02f, -5.27949035e-02f, 5.56754284e-02f, 8.26634392e-02f, 2.23132610e-01f, 2.21946448e-01f, 6.23832345e-02f,
  -1.24342769e-01f, 1.18588746e-01f, 1.82135776e-01f, 4.45267111e-02f, -4.21214774e-02f, 7.53743649e-02f, 3.44342925e-02f, 3.16967130e-01f, -2.93396831e-01f, 1.11175075e-01f,
  -1.78838477e-01f, 1.92797318e-01f, 1.62424088e-01f, 1.51509956e-01f, 2.64121331e-02f, -1.81647643e-01f, -2.54045367e-01f, -2.47363493e-01f, -1.26549631e-01f, -2.29856580e-01f,
  -1.05394289e-01f, 1.17779393e-02f, 6.37485087e-02f, -6.99084476e-02f, 3.55730695e-03f, -1.94514170e-01f, -4.76332381e-02f, 3.31749138e-03f, 1.23628043e-02f, 7.18797697e-03f,
  7.14038610e-02f, 3.17713708e-01f, 1.89904734e-01f, 2.15651006e-01f, 7.78641254e-02f, 5.64272366e-02f, 2.09515125e-01f, 2.57601649e-01f, 1.94074720e-01f, 1.08062074e-01f,
  2.12108716e-01f, 2.71000005e-02f, 1.02218717e-01f, -1.54741749e-01f, 5.29342480e-02f, -2.03079268e-01f, 1.66953772e-01f, 1.41658010e-02f, 4.57041636e-02f, -2.75558047e-02f,
  4.68622660e-03f, -3.44422869e-02f, 8.47000852e-02f, 4.61445265e-02f, -5.39507344e-02f, 4.28460777e-01f, -6.43630419e-03f, -4.24015671e-01f, -3.26647013e-02f, -6.57529160e-02f,
  4.94854413e-02f, 3.69016886e-01f, -9.92472619e-02f, -1.99932918e-01f, -2.42266012e-03f, -2.42005065e-01f, 2.71344960e-01f, 1.65733397e-01f, 1.95428848e-01f, -1.99047565e-01f,
  4.14405055e-02f, 9.03860107e-02f, 3.45391338e-03f, -1.12951972e-01f, -2.91148899e-03f, -8.72465298e-02f, 6.26847893e-02f, 6.65556788e-02f, 1.57920495e-01f, -1.12090424e-01f,
  5.22078276e-02f, 3.47222149e-01f, -1.64854303e-01f, -4.06390168e-02f, 8.36519450e-02f, -2.05447778e-01f, -1.63095757e-01f, 7.35883787e-02f, 4.43442985e-02f, 1.14640385e-01f,
  1.07447609e-01f, -1.06203921e-01f, 2.01915633e-02f, 1.96426153e-01f, -6.22935072e-02f, -1.77042279e-02f, -1.24033853e-01f, -7.09044337e-02f, -4.63051349e-02f, 8.04732740e-02f,
  -3.62791568e-02f, -5.92411438e-04f, 1.51839152e-01f, 1.62361935e-01f, 1.13705866e-01f, 8.71888846e-02f, -1.24535777e-01f, -1.23745874e-01f, -1.18776597e-01f, 2.61831637e-02f,
  -9.95395407e-02f, -1.05732232e-01f, 1.46967709e-01f, 1.14804305e-01f, -6.88692788e-03f, -1.44603908e-01f, -1.42109111e-01f, -1.99005201e-01f, 6.35526925e-02f, 1.25310704e-01f,
  7.01142056e-03f, -1.83172733e-01f, -2.66584661e-02f, 2.96685062e-02f, 2.13172749e-01f, 1.09316729e-01f, -2.70618629e-02f, 1.00330412e-01f, 2.29871392e-01f, -4.65906598e-02f,
  3.12594295e-01f, -1.86112791e-01f, -1.49918526e-01f, 1.50403202e-01f, -1.31264657e-01f, -6.86583295e-02f, 6.07564673e-02f, 1.41923904e-01f, -1.43723458e-01f, 3.41815837e-02f,
  -2.10620284e-01f, -1.76979616e-01f, -1.42363787e-01f, -3.27932775e-01f, 2.55901515e-01f, -2.64820516e-01f, 2.45513320e-02f, -1.10303536e-01f, 1.90471053e-01f, 2.29510844e-01f,
  4.96289395e-02f, 2.73300689e-02f, 9.65338796e-02f, 1.89365163e-01f, 3.18928696e-02f, 3.02644586e-03f, 1.64641012e-02f, 1.57878935e-01f, 5.78104667e-02f, 1.48443326e-01f,
  1.11960106e-01f, 1.39187381e-01f, 1.61668897e-01f, 7.24525377e-02f, 1.48138866e-01f, -1.65259410e-02f, -6.45009130e-02f, 1.67312212e-02f, 1.03646524e-01f, -1.29618468e-02f,
  1.69896215e-01f, 2.35893384e-01f, 5.87753505e-02f, -4.75593731e-02f, 1.27179131e-01f, -1.16073221e-01f, -6.15360513e-02f, -7.87357762e-02f, -2.52803136e-02f, 1.22252695e-01f,
  1.69369206e-02f, 5.41533232e-02f, -9.19805467e-02f, -6.17629774e-02f, 1.69354871e-01f, 1.11693732e-01f, 2.74269372e-01f, 7.89820179e-02f, -2.67613716e-02f, 5.34356013e-02f,
  3.26280147e-02f, -1.03158824e-01f, 7.63670206e-02f, 2.71308601e-01f, -5.81679083e-02f, 3.54880482e-01f, -1.29367575e-01f, -2.59886354e-01f, 2.42633373e-02f, 1.86400518e-01f,
  1.81694046e-01f, 9.60447788e-02f, 1.35957718e-01f, -1.58046067e-01f, 3.37584883e-01f, 1.55719399e-01f, 2.49684408e-01f, -5.62069193e-02f, -6.34223148e-02f, 6.07141145e-02f,
  2.34273002e-01f, 2.40146264e-01f, -1.98145792e-01f, 9.88228619e-02f, 6.82153329e-02f, 5.56639396e-02f, 2.34078079e-01f, -3.76177230e-03f, -4.40658405e-02f, 1.28556965e-02f,
  6.26691952e-02f, -2.39351764e-01f, 1.20914150e-02f, -2.19492644e-01f, -1.52582526e-01f, -5.50944842e-02f, -1.46860376e-01f, 8.75660703e-02f, 2.72723380e-02f, -1.63188174e-01f,
  1.11652546e-01f, -1.10637382e-01f, 8.76090676e-02f, -1.81656554e-01f, -1.25822425e-02f, 5.37480377e-02f, 8.89258459e-02f, -1.19633181e-02f, 2.04705656e-01f, 2.09230319e-01f,
  2.72652537e-01f, 2.15038154e-02f, -9.70731303e-02f, 6.77168742e-02f, 3.98538411e-01f, -2.28675216e-01f, 1.31577909e-01f, -2.01511994e-01f, 3.12703699e-01f, 1.02598019e-01f,
  2.03073382e-01f, -1.44598886e-01f, -5.14249876e-02f, -6.38986006e-02f, -5.67054525e-02f, -6.40535429e-02f, -7.11783171e-02f, -3.36653478e-02f, -2.28512492e-02f, -6.66831285e-02f,
  3.36731732e-01f, 8.35168585e-02f, -3.35436970e-01f, 2.06066087e-01f, -1.00239053e-01f, -2.31621787e-01f, 9.99549180e-02f, 2.21151970e-02f, 1.15238704e-01f, 2.96007484e-01f,
  -1.57610744e-01f, -1.07574021e-03f, 2.10535511e-01f, 3.45518403e-02f, 1.43750146e-01f, 6.70351982e-02f, -8.48931000e-02f, -1.68942973e-01f, -7.65310898e-02f, 1.07367091e-01f,
  6.49623275e-02f, 1.33215353e-01f, -8.38259608e-02f, -1.32630602e-01f, 1.36956498e-01f, 1.04381770e-01f, 1.75873235e-01f, -4.21455018e-02f, 2.27377594e-01f, 8.29818696e-02f,
  1.01427510e-01f, 2.11668350e-02f, 1.39210969e-01f, 3.75509709e-02f, 1.13595009e-01f, 2.82258421e-01f, 7.20890835e-02f, 6.24726415e-02f, 1.13087669e-01f, 1.75980523e-01f,
  -4.47181985e-02f, 5.89589886e-02f, -4.06790525e-02f, 2.15116702e-02f, -2.44982600e-01f, -1.66382164e-01f, 1.91031471e-02f, -3.53929847e-02f, -4.19025496e-02f, 1.74068376e-01f,
  -7.15849176e-02f, 1.64139450e-01f, -6.52686805e-02f, 9.52139348e-02f, -5.46577619e-03f, -1.42956913e-01f, -8.26382637e-02f, 2.84135461e-01f, -1.29504045e-02f, -3.15129533e-02f,
  -7.85375163e-02f, 1.78657964e-01f, 1.67037711e-01f, 1.54268429e-01f, -1.60594240e-01f, 1.34126842e-01f, 6.26078248e-02f, 2.69228011e-01f, 8.59064460e-02f, 1.54499531e-01f,
  -2.60739028e-01f, -1.16082445e-01f, 2.09212616e-01f, 3.69845033e-02f, -1.94652095e-01f, -1.22372031e-01f, -8.09655339e-02f, -2.55577683e-01f, -8.46702456e-02f, -1.12195753e-01f,
  -1.65874109e-01f, 1.42527848e-01f, 2.08030224e-01f, -1.48599520e-01f, -7.09965602e-02f, -3.69232804e-01f, -3.11212912e-02f, -1.69030979e-01f, 1.48643926e-01f, 3.11752975e-01f,
  1.59069180e-01f, 1.67932034e-01f, 9.31419581e-02f, 5.91764040e-02f, 1.79031223e-01f, 4.56382222e-02f, 1.02021262e-01f, 1.01718903e-01f, 1.35611385e-01f, 9.84125882e-02f,
  -9.96108130e-02f, 2.14873597e-01f, 1.83285072e-01f, 8.79446045e-02f, 6.53978735e-02f, -7.22025484e-02f, 1.74325854e-01f, -2.87809204e-02f, -2.99536705e-01f, -4.64214198e-02f,
  -1.53264120e-01f, 2.49171957e-01f, -8.22217837e-02f, 4.59381789e-01f, -8.56302455e-02f, 8.65241289e-02f, -1.61419749e-01f, -1.12447582e-01f, -9.31640714e-02f, 1.66627482e-01f,
  -1.56761259e-01f, 2.83864215e-02f, -5.13040386e-02f, -3.13057303e-01f, -1.58867817e-02f, 2.17135325e-01f, 1.66211873e-01f, -6.96138442e-02f, -6.70779049e-02f, 2.82582715e-02f,
  3.30335885e-01f, 2.31295332e-01f, -7.78285787e-02f, 1.73124939e-01f, -3.01323812e-02f, -1.60111859e-01f, 1.28631771e-01f, 4.42738421e-02f, 2.51303226e-01f, 1.09638944e-01f,
  -2.32406467e-01f, 2.91335851e-01f, -1.81787729e-01f, 2.06774428e-01f, -1.49551541e-01f, 7.27363154e-02f, 3.74881208e-01f, -4.34491336e-02f, -6.69926479e-02f, 7.19568729e-02f,
  -2.06417292e-02f, 7.64294937e-02f, 1.25046790e-01f, 1.45403028e-01f, 1.23782732e-01f, 3.22553329e-02f, 2.44653914e-02f, 1.82635754e-01f, 7.87611604e-02f, -1.14031225e-01f,
  2.69986778e-01f, -6.97240839e-03f, 2.71098595e-02f, 7.16071650e-02f, -5.15656546e-02f, 1.26220927e-01f, -1.37789160e-01f, -2.30671763e-01f, 1.48809478e-01f, -2.50957727e-01f,
  2.55284924e-02f, 1.87174663e-01f, 1.20642297e-01f, 8.80845636e-02f, -6.57799989e-02f, 1.61771581e-01f, 1.34086445e-01f, -2.04363123e-01f, 4.80859801e-02f, -4.59354483e-02f,
  1.15645900e-01f, 2.39042938e-02f, -3.30237806e-01f, -2.24478737e-01f, 1.97288468e-01f, 5.92821427e-02f, -1.00342833e-01f, -1.75339475e-01f, -1.39037490e-01f, -9.42250416e-02f,
  1.72721639e-01f, -1.57377303e-01f, 3.28212768e-01f, 1.44674301e-01f, 2.02505007e-01f, 1.35526136e-01f, 1.59330249e-01f, -1.28484324e-01f, -3.06203067e-02f, 1.06950682e-02f,
  2.52287865e-01f, 1.79983109e-01f, 1.90583572e-01f, 9.53619331e-02f, -1.51051089e-01f, 1.88008323e-01f, -2.41222814e-01f, -3.23793530e-01f, 1.93986177e-01f, -3.40394855e-01f,
  -2.35984921e-01f, 1.12019487e-01f, -2.71518171e-01f, 2.29199648e-01f, 7.85656348e-02f, -2.74752025e-02f, 2.23260134e-01f, 3.30039300e-02f, 4.57845852e-02f, 1.19194098e-01f,
  2.00534746e-01f, 5.66260852e-02f, 1.85624495e-01f, 7.47835934e-02f, 3.29625547e-01f, 7.46530667e-02f, 1.56046465e-01f, 7.34707192e-02f, 5.76363038e-03f, -1.37676541e-02f,
  -6.64805248e-02f, 1.57811582e-01f, -1.84325501e-02f, -5.68466932e-02f, 5.50320186e-02f, -3.47296149e-01f, 1.28384139e-02f, 1.83551803e-01f, 5.36663122e-02f, 6.47105873e-02f,
  1.88518502e-03f, -1.28376484e-01f, -4.18338031e-02f, 3.35569531e-01f, -6.90519437e-02f, 4.08659995e-01f, -2.55927652e-01f, -1.23401117e-02f, -5.86240254e-02f, -6.76113889e-02f,
  1.14826567e-01f, 8.59901030e-03f, -7.06096888e-02f, -3.91381839e-03f, 6.37641922e-02f, -1.78089187e-01f, 5.45262881e-02f, -5.54363504e-02f, 4.16478992e-01f, -1.21274129e-01f,
  1.79566562e-01f, -2.76122335e-03f, -2.33379215e-01f, 5.21040708e-02f, 1.59750357e-01f, 2.39992321e-01f, 2.35819533e-01f, 3.50675672e-01f, 7.29316249e-02f, -5.38260452e-02f,
  -2.96745539e-01f, 4.48749168e-03f, 6.67921528e-02f, 1.65766671e-01f, 1.22513257e-01f, -6.34372458e-02f, -1.00230820e-01f, 2.18387339e-02f, 3.06027323e-01f, -1.18726246e-01f,
  -7.66627192e-02f, -4.43496294e-02f, -7.94363320e-02f, 7.94482678e-02f, 1.61133200e-01f, -1.80232991e-02f, 1.83033030e-02f, -5.08751832e-02f, 4.26120199e-02f, 1.97757542e-01f,
  7.43750036e-02f, 9.44154039e-02f, 8.86008888e-03f, -2.01897696e-01f, 1.13073662e-01f, 3.63060944e-02f, 3.75978053e-02f, 1.85062140e-01f, 1.13781683e-01f, -1.69888586e-01f,
  -7.76674822e-02f, 7.31296241e-02f, 1.03307679e-01f, -5.85733876e-02f, 3.16213220e-02f, -4.50865924e-02f, -2.82277390e-02f, 3.75967145e-01f, -2.56816208e-01f, -1.31595269e-01f,
  2.74797767e-01f, 3.92622426e-02f, -6.25856742e-02f, 2.01121807e-01f, -1.35981664e-01f, -2.97642536e-02f, -1.18575811e-01f, -1.61370873e-01f, 2.55628556e-01f, 1.16491392e-01f,
  -1.09886281e-01f, 5.97419292e-02f, -1.30737290e-01f, 1.04744777e-01f, -6.87961280e-02f, 8.59918520e-02f, -7.43073132e-03f, -2.10315492e-02f, -2.48169184e-01f, 1.73892394e-01f,
  -1.96805075e-01f, -1.44388825e-01f, -2.63895448e-02f, -1.40237048e-01f, 7.92013705e-02f, -1.58121482e-01f, -1.37602061e-01f, 4.19420016e-04f, 1.93380564e-02f, -1.94128171e-01f,
  -1.38887182e-01f, -7.62472153e-02f, 5.03575914e-02f, -1.32216468e-01f, 6.36569178e-03f, 1.48916811e-01f, 1.58092275e-01f, 2.16472875e-02f, 2.82224625e-01f, 1.25303239e-01f,
  1.40969232e-01f, 8.31114650e-02f, 1.81413651e-01f, 1.42069412e-02f, 6.33529723e-02f, 1.91661403e-01f, -9.02823079e-03f, -2.33172402e-01f, 4.81035151e-02f, 2.02087060e-01f,
  4.02095020e-02f, 7.96439126e-02f, 2.29700357e-01f, 1.01848401e-01f, -2.28901744e-01f, -1.72271505e-01f, -2.96425130e-02f, 7.36990646e-02f, 1.42228737e-01f, 3.76572907e-01f,
  -1.34842038e-01f, 7.68353343e-02f, -6.87739626e-03f, 4.16885279e-02f, 1.53061628e-01f, 1.80717617e-01f, -1.28368601e-01f, 1.71391621e-01f, -1.91976607e-01f, -3.48717123e-02f,
  -2.93518938e-02f, 1.54815301e-01f, 5.62288500e-02f, 2.34695256e-01f, 2.53064960e-01f, 8.86199400e-02f, -6.23783097e-02f, 3.49500962e-02f, -9.99408886e-02f, -4.04552408e-02f,
  2.08976939e-01f, -1.05016738e-01f, 5.19866571e-02f, 5.57337739e-02f, 1.88715030e-02f, -1.04368087e-02f, -2.49281172e-02f, 2.52898246e-01f, -3.05410419e-02f, 2.03957960e-01f,
  -3.05365741e-01f, 1.31739713e-02f, 3.08951754e-02f, 7.31505230e-02f, 5.72068803e-02f, -8.41963440e-02f, -5.63820563e-02f, -6.06720485e-02f, -8.80538076e-02f, 1.11965418e-01f,
  -1.19048662e-01f, 1.38181895e-01f, 2.60925759e-02f, -1.13688847e-02f, -1.13837130e-01f, 3.39579396e-02f, -3.11788777e-03f, -3.16156936e-03f, 1.02781057e-01f, 9.50542837e-02f,
  -1.92187373e-02f, -7.12875137e-03f, -2.36654058e-01f, -1.45119309e-01f, -1.23742729e-01f, 4.52228338e-02f, -1.51652858e-01f, 1.74577579e-01f, 2.48366356e-01f, 1.54847413e-01f,
  1.26576260e-01f, -2.74759710e-01f, 2.63795376e-01f, -6.39181882e-02f, 7.42024332e-02f, 5.11930548e-02f, 1.85375437e-01f, -6.01123646e-02f, 1.39607280e-01f, 4.07142304e-02f,
  5.78893758e-02f, 1.84027374e-01f, 4.73260581e-02f, 4.07490283e-02f, 1.63958997e-01f, -1.03165962e-01f, -1.92382745e-03f, -1.14358120e-01f, 2.47017801e-01f, 1.29766449e-01f,
  -3.54949862e-01f, 6.49699494e-02f, 1.11158732e-02f, 7.46820569e-02f, 4.04832856e-04f, 1.95208520e-01f, -1.55414939e-01f, 2.15366352e-02f, -9.78386849e-02f, -8.33403915e-02f,
  2.18089283e-01f, -5.74555397e-02f, 1.46899641e-01f, -5.41889854e-03f, -8.31824392e-02f, 1.76673844e-01f, -2.21571580e-01f, 6.32267147e-02f, 1.23310506e-01f, 1.66679531e-01f,
  1.79514855e-01f, -5.99016808e-02f, 1.35758743e-01f, 1.02905750e-01f, 1.72774181e-01f, 1.46410868e-01f, 5.26159704e-02f, 3.98606695e-02f, 8.65311921e-02f, 5.25081903e-02f,
  2.75013357e-01f, 1.86223820e-01f, 9.48910639e-02f, 1.94423527e-01f, 2.01884080e-02f, -3.33077833e-02f, -1.17705226e-01f, -4.51762788e-02f, -7.62441084e-02f, -2.31257472e-02f,
  -2.40923584e-01f, -1.55382797e-01f, 2.41835386e-01f, 1.21912397e-01f, 2.13649809e-01f, 3.18652280e-02f, 1.16759971e-01f, -2.77081430e-01f, -4.74256352e-02f, -6.26917183e-02f,
  2.97253937e-01f, 2.12068588e-01f, 3.60908695e-02f, 1.66216180e-01f, 2.52525836e-01f, -1.39415994e-01f, -1.76216308e-02f, 1.75071552e-01f, 2.80940473e-01f, 1.01695396e-01f,
  -1.16666593e-01f, -1.10756554e-01f, -7.56665915e-02f, -2.48644412e-01f, 2.24351525e-01f, -1.25135273e-01f, 3.61115962e-01f, -1.61386535e-01f, -2.41145771e-02f, -1.07323013e-01f,
  1.80960283e-01f, 3.79078463e-02f, 5.13277315e-02f, 2.48330116e-01f, 3.01552802e-01f, -1.17324039e-01f, 2.07711309e-01f, 1.37381300e-01f, 1.99281514e-01f, 3.51300687e-01f,
  -1.17314540e-01f, 5.62841855e-02f, 1.17919795e-01f, 4.42781225e-02f, 1.07503787e-01f, 1.19371200e-02f, 1.61146566e-01f, 9.95151773e-02f, 7.51987025e-02f, -8.36501718e-02f,
  -7.30156973e-02f, 1.27242327e-01f, 1.23786628e-01f, 5.19472063e-02f, -5.38618714e-02f, -5.67918383e-02f, 1.29245892e-01f, -2.49268971e-02f, 9.12268385e-02f, 2.03862274e-03f,
  2.48507541e-02f, -2.60431711e-02f, 1.08177423e-01f, -1.03404805e-01f, -1.12658970e-01f, -1.12247117e-01f, 1.29447482e-03f, 5.08332346e-03f, 6.15933314e-02f, 6.25864640e-02f,
  1.69499742e-03f, -2.05213115e-01f, 2.33839303e-01f, -7.91579485e-02f, 2.33635306e-01f, 3.69859487e-01f, 1.26073593e-02f, 2.15578135e-02f, 9.86776799e-02f, 1.48635536e-01f,
  1.04349636e-01f, 9.13440287e-02f, 2.02088043e-01f, 2.23154888e-01f, -3.93423904e-03f, -4.68178615e-02f, -2.19323058e-02f, -2.04219352e-02f, 1.86213002e-01f, -1.07740993e-02f,
  1.84414700e-01f, 9.05657038e-02f, -1.90144435e-01f, 7.82411471e-02f, 3.34274858e-01f, -6.73823711e-03f, -9.34991166e-02f, 1.05831929e-01f, 1.89884439e-01f, -2.24325836e-01f,
  -1.35537356e-01f, 5.77294175e-03f, 1.17244206e-01f, 3.91877443e-01f, 4.91110943e-02f, -6.81425678e-03f, -1.96693502e-02f, -2.99785174e-02f, 2.20628023e-01f, 1.94074307e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -2.64587123e-02f, 1.37841880e-01f, 1.41684875e-01f, 2.79373024e-02f, -1.22209936e-02f, 2.67803133e-01f, 1.92196295e-01f, 1.59338072e-01f, 5.59766479e-02f, 1.01350546e-01f,
  -5.84802702e-02f, 2.63130516e-02f, 2.08105221e-02f, 3.97687405e-02f, 1.27018794e-01f, 5.72881326e-02f, 1.78958550e-01f, 8.55811238e-02f, -6.16148673e-02f, -1.73281133e-02f,
  1.13576427e-01f, -1.96326524e-02f, 1.22909971e-01f, 2.27473602e-01f, 1.27513260e-01f, -1.79299451e-02f, 1.28356785e-01f, 2.46668279e-01f, 9.12699029e-02f, 8.76291618e-02f,
  -4.46471013e-02f, 4.14229631e-02f, 2.73798972e-01f, 1.78360328e-01f, 2.16994226e-01f, 6.58269450e-02f, 1.70069456e-01f, 2.88021136e-02f, 1.73041143e-03f, -2.76425760e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -7.59892585e-03f, -4.24317783e-03f, -2.30124686e-02f, -1.38345107e-01f, -1.50976017e-01f, 5.95706031e-02f, 2.71764427e-01f, 9.63234007e-02f, 6.44024760e-02f, 2.63929456e-01f,
  -1.49321016e-02f, -4.39779945e-02f, 1.20920300e-01f, 5.17917611e-03f, -2.29938254e-02f, -6.92851618e-02f, -1.27144963e-01f, 5.93900979e-02f, 2.01630984e-02f, -4.66023758e-03f,
  -1.04217507e-01f, 5.79280965e-02f, -1.07725471e-01f, 1.41652644e-01f, -1.38226420e-01f, -7.37977400e-02f, 1.07511558e-01f, 1.49039015e-01f, 2.75946021e-01f, 1.14020303e-01f,
  1.41264141e-01f, -5.00458889e-02f, 1.43764019e-01f, 1.69364750e-01f, 7.80648962e-02f, 9.64425281e-02f, 4.03745249e-02f, -2.49710605e-01f, -8.53644032e-03f, -6.20779023e-03f,
  1.11567788e-02f, -1.64023742e-01f, -9.08996388e-02f, -3.06780508e-04f, 9.74184088e-03f, -2.18269899e-02f, 1.01212390e-01f, 1.22224987e-01f, 2.57231221e-02f, -5.17492965e-02f,
  -1.88484311e-01f, 1.45621136e-01f, -2.16046825e-01f, 1.14179745e-01f, 1.61285445e-01f, -1.86999347e-02f, 1.70336902e-01f, 1.15102567e-01f, 6.38601780e-02f, -1.15736924e-01f,
  1.32604614e-01f, -1.67147458e-01f, -1.21862710e-01f, -1.88388512e-01f, -1.11060113e-01f, 7.11750984e-02f, 1.37015089e-01f, -6.75902441e-02f, -2.40084492e-02f, -1.13070309e-02f,
  2.06556451e-02f, -1.00289853e-02f, -7.46877789e-02f, -7.83680677e-02f, -8.19518790e-02f, 8.73470865e-03f, -1.92537218e-01f, 1.57909274e-01f, -2.10337475e-01f, 1.90321445e-01f,
  2.14923322e-01f, -9.92813334e-02f, -7.94702768e-02f, -6.98663294e-02f, -1.64853096e-01f, -1.12182178e-01f, -2.09123027e-02f, -1.40656009e-01f, -1.53705589e-02f, -8.68962556e-02f,
  1.28831379e-02f, 3.90662141e-02f, -2.45883148e-02f, 2.13300139e-02f, 7.06434920e-02f, -5.30282781e-02f, -2.70583350e-02f, -2.28968542e-03f, 3.81323323e-02f, -1.17701262e-01f,
  -2.56622612e-01f, -2.02978626e-01f, -1.95527807e-01f, 1.85026675e-01f, -1.48253053e-01f, 1.75015450e-01f, -1.11649528e-01f, 2.74765007e-02f, 5.16061811e-03f, -6.54057832e-04f,
  -2.94476569e-01f, 2.05998565e-03f, 1.38598800e-01f, -7.64061213e-02f, 2.95805559e-02f, -3.56278680e-02f, 1.07913807e-01f, -4.54916023e-02f, -1.95019618e-01f, -9.04479250e-03f,
  4.33371635e-03f, -1.19022980e-01f, 6.87720478e-02f, -1.74579799e-01f, 3.58474255e-02f, -1.06290064e-03f, 1.35051697e-01f, 1.47411913e-01f, -5.68768196e-03f, -3.43736038e-02f,
  -2.70978101e-02f, -6.75566196e-02f, 5.43426350e-02f, -5.50481677e-02f, -1.69969246e-01f, 1.33946761e-01f, -2.29197830e-01f, -1.58479828e-02f, 8.71942416e-02f, -5.45631237e-02f,
  -1.52050793e-01f, 5.30228056e-02f, -5.95603697e-02f, -5.73537871e-02f, -1.18283540e-01f, -2.99562998e-02f, 1.29989922e-01f, -6.25727475e-02f, 1.19717866e-02f, 5.27064912e-02f,
  -2.68011987e-02f, -4.63753417e-02f, 1.79687232e-01f, 1.68489113e-01f, -1.31564766e-01f, 7.01302439e-02f, 1.44181952e-01f, -4.10613716e-02f, 8.65571573e-02f, 2.49187008e-01f,
  -8.10187757e-02f, -3.57837640e-02f, -9.14747864e-02f, -6.69923499e-02f, -1.24766372e-01f, -2.04113200e-02f, 1.92724392e-01f, -6.93806633e-02f, -1.16767604e-02f, 5.98528311e-02f,
  -4.66962084e-02f, -3.67730223e-02f, 1.76612094e-01f, 3.72708612e-03f, -6.76758215e-02f, 9.89046022e-02f, -1.79241583e-01f, -5.46973646e-02f, 1.46636367e-01f, 4.45199609e-02f,
  2.61880964e-01f, -1.82824209e-01f, -1.32661253e-01f, 3.16328369e-02f, -1.00837581e-01f, 2.22140238e-01f, -1.74907893e-02f, -1.38286501e-01f, -7.36289099e-02f, 9.52638909e-02f,
  -4.36497331e-02f, 1.40904546e-01f, -1.48745939e-01f, -8.91530886e-02f, -1.97000340e-01f, 3.37994359e-02f, 8.70348737e-02f, -3.04825008e-01f, -4.43671178e-03f, -1.07156083e-01f,
  -1.85521126e-01f, -2.31949612e-01f, -9.76524875e-03f, -5.59052639e-02f, 7.13043660e-02f, -5.32299578e-02f, 3.01381340e-03f, -1.14748701e-02f, -1.05946518e-01f, -2.99683232e-02f,
  1.28456473e-01f, -3.15192163e-01f, -3.64047624e-02f, -1.62482500e-01f, -9.37781632e-02f, -1.27375752e-01f, 9.29283649e-02f, -5.82398893e-03f, -1.16772331e-01f, -6.62651733e-02f,
  1.04161948e-01f, -1.51678815e-01f, -1.15895733e-01f, 4.47615534e-02f, -1.14844859e-01f, -2.07669675e-01f, -9.68975946e-02f, -1.31163284e-01f, 2.14620024e-01f, 1.65600404e-01f,
  1.84919976e-03f, -2.25610565e-03f, 8.98801312e-02f, -1.07139446e-01f, -3.61624323e-02f, 6.89421445e-02f, 1.05909795e-01f, 1.93980671e-02f, 2.63071563e-02f, -6.34093061e-02f,
  -1.73210636e-01f, -1.54410020e-01f, 9.24262777e-02f, 1.57002792e-01f, 2.38629013e-01f, -5.59357367e-02f, 1.47749007e-01f, 6.01205751e-02f, -2.26476300e-03f, 4.55044731e-02f,
  7.82395974e-02f, 1.53269544e-01f, -2.79175378e-02f, 1.39051870e-01f, 1.36896037e-02f, 5.34929931e-02f, -1.05934866e-01f, -4.44866680e-02f, -1.08009927e-01f, 4.87384945e-02f,
  -8.84170830e-02f, -2.06665039e-01f, -1.78118885e-01f, -2.80493069e-02f, 1.33185133e-01f, -1.59005523e-01f, -1.04504652e-01f, -4.33495343e-02f, -8.48340616e-02f, -3.01190525e-01f,
  9.14237872e-02f, -7.07855299e-02f, 2.36630682e-02f, -5.20192869e-02f, -1.26519084e-01f, 1.23062246e-01f, 1.50395155e-01f, 3.81228030e-02f, 2.28277519e-01f, -2.76010241e-02f,
  -7.68061951e-02f, -1.19704522e-01f, -6.99443817e-02f, 7.04478472e-02f, -2.86099076e-01f, -2.06245948e-02f, 1.13500115e-02f, 2.14740127e-01f, 1.13715613e-02f, -3.52772862e-01f,
  3.43259647e-02f, -1.14672758e-01f, 1.64032623e-01f, 1.86097860e-01f, 1.81742702e-02f, -1.62287474e-01f, 2.07301497e-01f, 5.90376221e-02f, 2.51230877e-02f, 5.01758419e-02f,
  2.98964202e-01f, -1.16365261e-01f, 1.68350980e-01f, 3.38431932e-02f, -8.04377273e-02f, 6.71507940e-02f, 9.57484916e-02f, -2.27390807e-02f, 7.98648223e-02f, 3.29509489e-02f,
  1.18580416e-01f, 5.80931380e-02f, -2.16016665e-01f, -1.25908598e-01f, 2.73584258e-02f, 1.34160519e-01f, -8.67231265e-02f, 1.04441568e-01f, -8.00360069e-02f, -1.01425223e-01f,
  5.01063839e-02f, 1.32649690e-01f, 3.05677056e-01f, -1.12920180e-01f, 1.19973674e-01f, 1.52778491e-01f, -2.80162003e-02f, 1.30420685e-01f, -4.03042920e-02f, 3.27426553e-01f,
  1.69278443e-01f, 1.10602036e-01f, -1.26061337e-02f, 9.39957201e-02f, 9.98060107e-02f, 2.15477556e-01f, 1.79686591e-01f, 3.42609882e-02f, 5.56292683e-02f, -2.22173274e-01f,
  -1.33006275e-01f, 1.43473238e-01f, -3.18365581e-02f, 8.53405893e-02f, -1.12928517e-01f, -1.17508218e-01f, 4.57836427e-02f, 1.52955532e-01f, 4.50732000e-02f, 2.08107546e-01f,
  6.97041899e-02f, -3.83248851e-02f, 1.70017943e-01f, -2.78528541e-01f, 1.31340876e-01f, 8.26068670e-02f, -1.06052831e-01f, 2.40818486e-02f, -1.36018336e-01f, -6.69634119e-02f,
  -6.40957057e-02f, 1.59251705e-01f, 9.18896571e-02f, -2.03931063e-01f, -2.94273232e-05f, -2.77374446e-01f, -1.22404628e-01f, 3.23647261e-02f, -1.00704434e-03f, 1.56191930e-01f,
  -2.88694855e-02f, 1.65699705e-01f, 2.63376012e-02f, -1.03169475e-02f, -2.37524122e-01f, -6.92837536e-02f, 9.39221010e-02f, 1.13095403e-01f, -1.09471381e-01f, -4.22268435e-02f,
  -1.71806384e-02f, -1.70876104e-02f, -8.45648348e-02f, -8.83352086e-02f, -1.61076084e-01f, -1.24817779e-02f, 5.75076975e-02f, 3.80776115e-02f, 5.33674471e-02f, -1.11113787e-01f,
  -2.87180990e-02f, -5.66254444e-02f, -1.37798756e-01f, 5.83095998e-02f, -9.44897905e-02f, 5.05862571e-03f, 1.36590257e-01f, 9.72944498e-02f, -2.07679808e-01f, 1.62186861e-01f,
  -1.14561446e-01f, 1.41253084e-01f, 2.02857867e-01f, -5.19694313e-02f, -3.62377435e-01f, -4.19195779e-02f, 1.07954308e-01f, 9.68339071e-02f, -1.42791206e-02f, -5.42235039e-02f,
  -7.54572824e-02f, -8.11593533e-02f, 2.33589485e-01f, 1.39338836e-01f, -7.77700692e-02f, 3.59771249e-04f, -4.18421812e-02f, -7.74220973e-02f, -1.13195524e-01f, -1.12578742e-01f,
  -8.96086842e-02f, -1.34215653e-01f, -7.14842305e-02f, 9.91684049e-02f, -2.74874438e-02f, 2.34780814e-02f, 4.16831635e-02f, -1.18225634e-01f, 1.35540172e-01f, -2.53877878e-01f,
  -2.18617603e-01f, 1.58921555e-01f, 4.53208573e-03f, -1.28541589e-01f, 7.81732425e-02f, -5.93003631e-03f, 8.27691033e-02f, 5.95226586e-02f, -8.63442421e-02f, 1.69454470e-01f,
  -4.53699715e-02f, 1.38958432e-02f, 7.48675391e-02f, 1.59793228e-01f, 9.07294080e-02f, 6.28760383e-02f, -2.38941293e-02f, -5.28426170e-02f, 9.18354094e-02f, -5.10083549e-02f,
  -3.74410264e-02f, -4.94460389e-02f, -1.38273135e-01f, -1.23742800e-02f, 7.87087753e-02f, 5.44145666e-02f, -5.59984380e-03f, 1.55762449e-01f, -1.01551481e-01f, -5.20852655e-02f,
  2.22910270e-01f, -5.42141721e-02f, -9.52464435e-03f, 1.19235525e-02f, -5.12104817e-02f, 1.48052918e-02f, -1.34164905e-02f, 2.30106220e-01f, 1.73697472e-01f, 1.83701217e-01f,
  -1.36453986e-01f, 1.43690273e-01f, -8.90004560e-02f, 2.93418691e-02f, -2.22970173e-01f, 3.06630339e-02f, 9.12921131e-02f, -1.08541504e-01f, 1.31728977e-01f, 3.66169401e-02f,
  -2.59967446e-02f, 1.20065451e-01f, 8.88897777e-02f, 4.73173670e-02f, -3.96887446e-03f, -1.94157138e-01f, 1.69633806e-01f, -4.98370156e-02f, 7.89284483e-02f, -1.78075328e-01f,
  1.05628267e-01f, -6.22611567e-02f, -2.71932751e-01f, 2.11119935e-01f, 7.52520114e-02f, -5.37797436e-02f, -1.25800192e-01f, 9.91228446e-02f, -1.16321333e-01f, 9.18031856e-03f,
  -1.68317690e-01f, -1.00750059e-01f, -1.45849988e-01f, -4.50941026e-02f, 8.26403573e-02f, 3.16485971e-01f, 1.92648336e-01f, 7.70706460e-02f, -1.42487496e-01f, -1.88009515e-01f,
  1.68620527e-01f, -2.78346669e-02f, 6.69210479e-02f, 1.06538638e-01f, -2.73092072e-02f, -2.31715754e-01f, -3.18931788e-01f, -8.47422108e-02f, 3.20969857e-02f, -1.14068482e-02f,
  1.70442566e-01f, 2.03649789e-01f, -4.50475924e-02f, -6.96788356e-02f, 2.84200132e-01f, -1.88894942e-01f, 1.26128510e-01f, -1.85653955e-01f, -2.03803450e-01f, 4.07194972e-01f,
  7.69930854e-02f, 2.17713371e-01f, -3.14174443e-02f, 2.10835323e-01f, 1.11712538e-01f, 7.96499401e-02f, 7.19060451e-02f, -1.50389493e-01f, -3.99827175e-02f, -2.62081381e-02f,
  -1.02412038e-01f, 2.11306997e-02f, -1.56377062e-01f, -9.25112739e-02f, 8.12379718e-02f, 2.19009176e-01f, -1.12807481e-02f, 1.61988199e-01f, 1.32281944e-01f, -1.60445422e-02f,
  1.66787103e-01f, 9.84580666e-02f, -4.79032584e-02f, -1.09265648e-01f, -1.17219821e-01f, 4.85136658e-02f, 5.48869697e-03f, 1.34582385e-01f, 1.83279991e-01f, -3.28804702e-02f,
  1.84019387e-01f, 2.21179605e-01f, -1.06184766e-01f, 1.43155633e-02f, 2.35496517e-02f, -5.27884327e-02f, 3.28335851e-01f, 9.56445634e-02f, 6.92032352e-02f, -2.37074316e-01f,
  -1.36757001e-01f, 1.12195767e-01f, 6.25631958e-02f, -4.70165610e-02f, -1.56668887e-01f, -4.72445674e-02f, 4.31009606e-02f, 9.07762274e-02f, 1.33826137e-01f, 1.63440611e-02f,
  -4.23593586e-03f, 2.79627204e-01f, -3.13249156e-02f, -5.82292043e-02f, -9.69363302e-02f, 7.48657063e-02f, -1.95654873e-02f, 1.32106245e-01f, -2.90462166e-01f, 1.60895035e-01f,
  7.90542886e-02f, 1.13110997e-01f, 1.76034689e-01f, -9.64771956e-04f, 1.25300929e-01f, -3.36801969e-02f, -9.39847678e-02f, 1.01300597e-01f, 2.35404015e-01f, -1.30071640e-01f,
  -2.29692653e-01f, -1.35068651e-02f, 8.16711038e-02f, 4.44850326e-03f, 2.13172406e-01f, -1.59943644e-02f, 1.81086615e-01f, -1.20285131e-01f, 6.29504845e-02f, -2.26340666e-01f,
  1.65674835e-01f, 1.57518059e-01f, 8.04958716e-02f, 9.96934623e-02f, -9.67444330e-02f, -3.98699082e-02f, -1.54791996e-01f, 7.82454014e-02f, 2.89858785e-03f, 5.46327829e-02f,
  1.40412673e-01f, -1.93046510e-01f, 5.32584712e-02f, 3.96538414e-02f, 5.03083058e-02f, 4.61498052e-02f, -1.42124116e-01f, 4.81684878e-02f, -1.05144627e-01f, 5.58191016e-02f,
  1.67424306e-01f, -7.45788129e-05f, -5.19970469e-02f, 1.65359601e-02f, -1.52745128e-01f, -2.50269979e-01f, 2.87916698e-02f, -8.16465467e-02f, -3.11640352e-02f, -1.00463949e-01f,
  -8.61421898e-02f, 1.26323342e-01f, 3.18069458e-01f, 1.63860172e-02f, -2.36553967e-01f, 2.72252057e-02f, 1.65639833e-01f, 1.79052994e-01f, 2.95245070e-02f, 1.15730271e-01f,
  1.10347688e-01f, 1.67350695e-02f, -8.49248916e-02f, 1.81639567e-01f, -8.61028135e-02f, 7.27054616e-03f, 6.64543710e-04f, -1.06052132e-02f, -1.27562955e-01f, 2.74098396e-01f,
  3.66717875e-02f, 1.35566607e-01f, 7.39369169e-02f, -5.94969839e-03f, 1.37447327e-01f, -1.65009633e-01f, 1.80703942e-02f, 7.59679601e-02f, 1.42697498e-01f, 1.15975700e-01f,
  4.20004949e-02f, -5.28444611e-02f, 6.60237223e-02f, -3.36212143e-02f, -1.42647820e-02f, 1.83020875e-01f, 2.25777533e-02f, -1.66875720e-01f, -9.10717354e-05f, 7.25591034e-02f,
  -6.77322224e-02f, 9.07561183e-02f, 1.66982353e-01f, -3.71523686e-02f, -6.81040809e-02f, -6.32046387e-02f, -1.59237191e-01f, -2.92649074e-03f, 4.17157002e-02f, 9.54690799e-02f,
  -1.78037196e-01f, -1.43228799e-01f, -8.49445686e-02f, 7.74387792e-02f, -1.31788447e-01f, -6.75403550e-02f, 4.66126390e-02f, -1.63786724e-01f, -9.09456760e-02f, -2.71566898e-01f,
  -5.78914620e-02f, 8.94837920e-03f, -9.83583648e-03f, -2.41223797e-02f, 1.21909462e-01f, 5.99979796e-02f, -1.56896129e-01f, -2.91691329e-02f, 6.70682937e-02f, -6.88482523e-02f,
  -5.91344871e-02f, -3.04681838e-01f, -1.14174590e-01f, -1.78412467e-01f, -1.31574318e-01f, 5.15312217e-02f, 1.39123395e-01f, 7.09988847e-02f, 6.18395992e-02f, 4.59815636e-02f,
  2.47765314e-02f, 1.39827758e-01f, 1.18196607e-02f, -1.24621697e-01f, -2.09363908e-01f, 3.26951891e-02f, 6.37612492e-02f, -4.45457501e-03f, -1.59814894e-01f, -4.96871546e-02f,
  -1.73827484e-01f, -1.95575833e-01f, 3.17616947e-02f, 1.73937082e-01f, -3.47798802e-02f, -1.33910567e-01f, 7.49446079e-02f, -2.54824329e-02f, 8.77041221e-02f, 8.18960369e-02f,
  1.44054368e-01f, 1.29747763e-01f, 1.04158878e-01f, -1.02806855e-02f, -8.66195112e-02f, 2.17500687e-01f, -4.68242764e-02f, 1.04981281e-01f, 1.41020849e-01f, -1.54909581e-01f,
  6.65779272e-03f, 1.38042435e-01f, -1.05948694e-01f, -2.09999144e-01f, 1.77517697e-01f, -5.56029044e-02f, -1.20171802e-02f, 4.09670621e-02f, 2.09228575e-01f, 6.07592873e-02f,
  -6.98327348e-02f, -1.84612423e-01f, -1.98249876e-01f, -2.93271653e-02f, 1.39132991e-01f, 1.65780619e-01f, -7.91634694e-02f, -3.97058763e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.98383704e-02f, 4.37642708e-02f, -5.69095723e-02f, -7.85979778e-02f, -8.50453675e-02f, -5.23911193e-02f, 1.02628611e-01f, 3.53800431e-02f, 6.42007366e-02f, 1.54620916e-01f,
  -9.07993987e-02f, -7.08033741e-02f, 1.17458507e-01f, 1.74291097e-02f, 3.85513641e-02f, -8.40591937e-02f, -9.78686810e-02f, 5.60710020e-02f, -1.70542970e-02f, -3.40586901e-02f,
  -1.11968428e-01f, -2.54539177e-02f, -6.61735144e-03f, 8.87816623e-02f, -4.57465947e-02f, 1.16825346e-02f, 1.10624984e-01f, 9.03033689e-02f, 6.85862526e-02f, 9.41091254e-02f,
  -2.26799902e-02f, 1.80384323e-01f, 5.88183030e-02f, 8.04804191e-02f, -4.78614382e-02f, 4.22157422e-02f, -5.77374473e-02f, -1.19398654e-01f, -3.33209224e-02f, 1.23615181e-02f,
  1.24197982e-01f, 9.05113574e-03f, 3.04835476e-02f, -1.39633212e-02f, -6.93675876e-02f, 1.77927017e-01f, 4.74295206e-02f, 1.93462253e-01f, 1.21322013e-01f, 7.30105564e-02f,
  5.62203443e-03f, 3.23913619e-02f, -1.78117558e-01f, 1.59128189e-01f, -1.52558656e-02f, 1.17016450e-01f, 1.87155724e-01f, 1.27264280e-02f, 1.59300297e-01f, 2.62359437e-02f,
  -3.50462482e-03f, -1.51967676e-02f, 1.95384938e-02f, -6.08277088e-03f, -9.76723880e-02f, -1.43801104e-02f, -2.16672540e-01f, 1.05863459e-01f, 1.15239993e-01f, 1.65666133e-01f,
  1.50523251e-02f, -3.93421710e-01f, 1.79483704e-02f, 1.20542020e-01f, 4.73483047e-03f, 2.08576977e-01f, -1.29983991e-01f, -1.27205476e-01f, 4.30198699e-01f, -1.46767991e-02f,
  7.52911344e-02f, -1.67699754e-01f, 1.43095329e-01f, -3.43493938e-01f, 1.53539265e-02f, -9.06820223e-02f, 1.59875721e-01f, -8.75899643e-02f, -2.40019053e-01f, 8.89853388e-02f,
  1.82005093e-01f, -5.36316298e-02f, 8.29253793e-02f, 8.06273241e-03f, 1.59224689e-01f, -1.57615662e-01f, -4.13535088e-02f, 1.64375097e-01f, 2.84718007e-01f, 2.12827727e-01f,
  3.90515894e-01f, 3.53226721e-01f, 1.17707692e-01f, -7.11800680e-02f, -3.28790955e-02f, -1.01769261e-01f, 5.21944761e-02f, 3.01069468e-01f, 8.01933557e-03f, -9.38665196e-02f,
  2.67070591e-01f, -6.52060658e-02f, -5.59429452e-02f, 2.91285992e-01f, 2.04531372e-01f, -3.70883085e-02f, 2.79342979e-02f, 1.08472310e-01f, 3.78168851e-01f, 1.42948069e-02f,
  -1.40354127e-01f, 1.61334738e-01f, -2.65113145e-01f, -1.54650912e-01f, 1.66970655e-01f, 2.09961444e-01f, -1.50745392e-01f, 5.01338057e-02f, 1.68958172e-01f, -4.85622846e-02f,
  1.93013772e-01f, -1.35208040e-01f, 1.84244856e-01f, 3.73578332e-02f, 1.94717646e-01f, 1.98569953e-01f, 1.86739892e-01f, 2.19085336e-01f, 6.05105273e-02f, -6.17950149e-02f,
  8.15112069e-02f, -5.26849478e-02f, 1.30255535e-01f, 2.54474849e-01f, 2.14384288e-01f, -4.38534617e-01f, -1.49111990e-02f, 2.44199023e-01f, 3.82527322e-01f, 1.73980057e-01f,
  -3.09771925e-01f, 8.83905590e-02f, 1.19316980e-01f, 1.27225131e-01f, 4.33084816e-02f, 2.93492645e-01f, 1.54221980e-02f, 4.36499948e-03f, 1.62465408e-01f, 1.39111355e-01f,
  4.61450815e-02f, 4.45954092e-02f, 4.27310728e-02f, 1.24892533e-01f, -1.45342007e-01f, -1.75021902e-01f, -2.63283569e-02f, 3.92558500e-02f, 2.10615173e-01f, 5.87451681e-02f,
  7.74620548e-02f, -1.62152529e-01f, -2.30127081e-01f, 3.64933848e-01f, 1.78508405e-02f, -2.12642401e-01f, -3.45078558e-02f, 3.09618801e-01f, -1.78765818e-01f, 1.91581070e-01f,
  -8.85388032e-02f, -5.40064201e-02f, -3.17688316e-01f, -2.03892514e-01f, 3.37000452e-02f, 2.70630777e-01f, 3.08789402e-01f, -1.30392760e-01f, -6.76192194e-02f, -1.20252758e-01f,
  1.73588112e-01f, 2.14716062e-01f, -1.79405674e-01f, 1.45483181e-01f, 6.43878477e-03f, 4.06885892e-01f, 9.14636478e-02f, 1.56868726e-01f, -4.72854078e-02f, -7.03428835e-02f,
  2.13340476e-01f, -3.87246236e-02f, 1.87913161e-02f, 1.58121586e-01f, -4.33556855e-01f, -1.23142675e-01f, -7.06774741e-02f, -1.43840581e-01f, 6.71124905e-02f, -7.61462003e-02f,
  -2.42160007e-01f, -1.67524531e-01f, 3.65709737e-02f, 2.03826860e-01f, -3.56686056e-01f, -6.16158918e-02f, 7.76822269e-02f, -3.86248641e-02f, -6.81117103e-02f, 2.00516030e-01f,
  -7.35386759e-02f, 3.10088079e-02f, 1.02281630e-01f, 5.59970625e-02f, -7.62752593e-02f, -3.86270046e-01f, -1.55693799e-01f, -2.25517482e-01f, -2.67543755e-02f, -3.38392071e-02f,
  -8.34267810e-02f, 7.57956728e-02f, 2.87562490e-01f, 9.74275470e-02f, 3.30600441e-02f, -1.01806279e-02f, 2.69390881e-01f, -3.67908664e-02f, 1.15653314e-01f, 1.79489493e-01f,
  7.72786066e-02f, 1.82118833e-01f, -4.69262563e-02f, 2.18686134e-01f, 8.85680094e-02f, 1.85172230e-01f, -7.95586109e-02f, 2.83933282e-01f, -5.33799343e-02f, -7.80706406e-02f,
  2.47359693e-01f, 1.31772205e-01f, 1.12661578e-01f, 5.41470349e-02f, 3.53145123e-01f, 2.11076394e-01f, 1.49383500e-01f, 2.24896699e-01f, 1.85559615e-01f, -9.13237780e-02f,
  3.28805596e-02f, 5.83099462e-02f, -6.61408380e-02f, 1.35954529e-01f, 1.02314487e-01f, 9.49076414e-02f, 2.59235948e-01f, 2.05692321e-01f, -1.54786900e-01f, 1.47011727e-01f,
  1.82304561e-01f, 1.42659426e-01f, 2.94463068e-01f, -1.16969503e-01f, -9.34479833e-02f, 3.71650636e-01f, 4.56669599e-01f, 2.21540436e-01f, -7.92073756e-02f, -1.10478684e-01f,
  1.43730760e-01f, 3.34181376e-02f, -3.16102266e-01f, 2.06612095e-01f, -4.77880351e-02f, 1.10338859e-01f, 1.90176383e-01f, -7.39849880e-02f, -3.12804319e-02f, -2.13224694e-01f,
  2.65183717e-01f, 8.57937634e-02f, 1.08794786e-01f, 1.45101562e-01f, 1.64795488e-01f, 1.85807720e-01f, -4.14946415e-02f, 1.44995311e-02f, -2.01288406e-02f, 9.56495106e-02f,
  9.86558571e-02f, -1.99514493e-01f, -1.52627990e-01f, -1.77346885e-01f, -4.15606946e-02f, 1.62239313e-01f, -1.23595171e-01f, 3.01390916e-01f, -3.14324424e-02f, 2.25334391e-02f,
  -9.33942646e-02f, -4.15994167e-01f, 1.08497232e-01f, 1.26698747e-01f, -1.29229590e-01f, -2.19328046e-01f, 7.42405206e-02f, -6.59137871e-03f, 7.17585906e-02f, -1.01767644e-01f,
  -1.22369535e-01f, 1.09443091e-01f, 7.59943053e-02f, -2.19999626e-01f, -1.25393778e-01f, -1.23370670e-01f, -6.68539703e-02f, 1.20408699e-01f, -2.38449931e-01f, -1.76574633e-01f,
  -9.88003463e-02f, -5.34517951e-02f, -1.01984441e-01f, 2.19027996e-01f, -3.95667911e-01f, -2.25402966e-01f, -1.31093800e-01f, 3.04561973e-01f, 3.62633497e-01f, -2.01766148e-01f,
  2.71514114e-02f, -2.46592075e-01f, -3.85713391e-02f, 4.78151999e-02f, 1.15895025e-01f, -1.23343952e-01f, 2.11178407e-01f, -8.49382877e-02f, 2.85215735e-01f, -5.33725172e-02f,
  5.55551015e-02f, 6.24071201e-03f, 7.51682147e-02f, 1.54259339e-01f, -6.89986870e-02f, 1.13615960e-01f, -2.00385824e-01f, 6.58297464e-02f, 1.40815511e-01f, 1.23853758e-01f,
  -3.49352211e-02f, 7.97940940e-02f, 4.25430685e-02f, 2.20286489e-01f, -1.05731031e-02f, 2.73420662e-01f, -2.35402763e-01f, 1.05454780e-01f, 1.55124366e-01f, -2.11672455e-01f,
  2.40650952e-01f, -3.10358673e-01f, 3.64226252e-02f, 1.57836512e-01f, 7.06131160e-02f, 6.01774976e-02f, 2.28041947e-01f, -1.42064765e-01f, 1.57577589e-01f, -7.11092874e-02f,
  1.84319485e-02f, -1.21983655e-01f, 4.86887731e-02f, 1.73576966e-01f, -4.40391302e-02f, -2.28740983e-02f, 8.80899206e-02f, 2.01277792e-01f, 6.55018389e-02f, 2.58413076e-01f,
  -7.51161799e-02f, -3.15724134e-01f, 8.79839361e-02f, -4.92165871e-02f, -2.72953138e-02f, 2.22459599e-01f, -2.68186301e-01f, -7.41189718e-02f, 1.15620062e-01f, 2.19831914e-01f,
  1.20416135e-01f, -1.21864133e-01f, -1.85431331e-01f, 1.10460930e-01f, -4.81997356e-02f, -1.70191247e-02f, 8.11098441e-02f, -2.25213081e-01f, 1.16889179e-01f, 7.78008103e-02f,
  5.82671165e-02f, 1.29124552e-01f, -2.08319694e-01f, 2.51418442e-01f, 1.83891326e-01f, -1.50973946e-01f, 1.26258120e-01f, -3.10433954e-01f, 1.04602948e-01f, 4.50936658e-03f,
  2.34198540e-01f, 2.43075609e-01f, -6.02162741e-02f, 1.61519229e-01f, 1.34872898e-01f, 1.43366277e-01f, 1.40566558e-01f, 2.00212542e-02f, 3.34487289e-01f, -3.29602331e-01f,
  1.30417660e-01f, -1.10863864e-01f, 2.10715517e-01f, 1.04513295e-01f, -5.21453321e-02f, 3.29158813e-01f, 7.09192753e-02f, 1.63624182e-01f, 1.60338268e-01f, 6.77344948e-02f,
  -7.30468286e-03f, -2.24880472e-01f, -2.08129987e-01f, 1.05559498e-01f, 5.82491420e-02f, 1.09448388e-01f, 1.37173876e-01f, -1.20180503e-01f, 2.16178477e-01f, -2.17487644e-02f,
  -1.31338947e-02f, -1.05911933e-01f, 3.25835422e-02f, -1.03102125e-01f, -1.28597813e-02f, 5.18315397e-02f, -2.72319317e-02f, 2.85925101e-02f, 7.42005408e-02f, 4.89421822e-02f,
  8.92808810e-02f, 7.17997029e-02f, -2.10451856e-01f, 2.58429170e-01f, 3.99310946e-01f, 9.13733914e-02f, 7.43484274e-02f, 3.18005621e-01f, 1.93322655e-02f, 1.86441451e-01f,
  1.04584247e-01f, 3.88177931e-02f, -4.43864390e-02f, 1.93411827e-01f, -1.16771810e-01f, 1.59395307e-01f, 3.46912742e-01f, 1.32495686e-01f, 4.06564295e-01f, -1.76397845e-01f,
  -1.17732555e-01f, 3.23117711e-04f, 1.17875688e-01f, 1.71726838e-01f, -2.02342439e-02f, 3.30211490e-01f, 2.70641327e-01f, 3.17862451e-01f, -1.34799510e-01f, 2.16931105e-01f,
  1.89552367e-01f, 2.09621966e-01f, 4.36373428e-02f, -2.72153795e-01f, 1.23900659e-01f, -7.14125112e-02f, -5.75717874e-02f, -1.69066086e-01f, 7.60864317e-02f, 3.30696702e-01f,
  1.35968179e-01f, -1.63180828e-02f, 2.40228966e-01f, -1.35222152e-01f, 1.98905878e-02f, 1.90290228e-01f, -2.51449138e-01f, 6.10094145e-02f, 9.79556441e-02f, 8.88554081e-02f,
  1.72762811e-01f, -3.98333408e-02f, -3.10461551e-01f, -2.14173391e-01f, -1.28557310e-01f, -3.17100942e-01f, -2.79576898e-01f, -1.67617515e-01f, -5.63444421e-02f, -2.77833641e-01f,
  -2.29933202e-01f, -2.44242638e-01f, -9.84272659e-02f, -1.42579168e-01f, 2.38623559e-01f, -3.61868143e-02f, -4.31111157e-01f, 5.24006337e-02f, -2.53965318e-01f, 1.51523575e-01f,
  2.16845840e-01f, 4.17175982e-03f, -3.06986153e-01f, -1.91526905e-01f, 8.03640634e-02f, -9.02668610e-02f, -7.26457536e-02f, 3.49902995e-02f, -3.59102525e-02f, -5.79118654e-02f,
  7.45311379e-02f, 5.61385192e-02f, 1.91141553e-02f, -2.22165182e-01f, -7.90726840e-02f, 6.31629154e-02f, 7.91516006e-02f, 4.30474170e-02f, -2.04749182e-01f, -4.13691141e-02f,
  -7.85424933e-03f, 9.01428089e-02f, -3.90293710e-02f, 6.36859536e-02f, 8.47869962e-02f, -1.65625408e-01f, 6.35220036e-02f, -8.49302411e-02f, -1.46347359e-01f, -1.37871668e-01f,
  2.14723319e-01f, -1.08543210e-01f, -1.07555151e-01f, -1.11354195e-01f, -3.48884985e-02f, 1.10679932e-01f, -4.26279940e-02f, -2.39241999e-02f, -1.31045729e-01f, -1.07350521e-01f,
  1.00565270e-01f, -3.18235531e-02f, -6.96759031e-04f, 1.34118736e-01f, 1.15466937e-01f, 8.21063519e-02f, 7.83835649e-02f, -1.92154350e-03f, -5.28916381e-02f, -1.96570292e-01f,
  -6.42229021e-02f, -7.78759494e-02f, 1.07033662e-02f, -5.95953017e-02f, 1.76861824e-03f, 1.19186249e-02f, -1.35298595e-01f, 1.17649972e-01f, -1.66150909e-02f, 2.25753896e-03f,
  -1.01308994e-01f, -5.60323987e-03f, 4.96193282e-02f, 3.77053767e-01f, 3.31874460e-01f, -1.83330312e-01f, -5.59150763e-02f, -7.71911889e-02f, -7.64110014e-02f, 3.04055184e-01f,
  -7.28918314e-02f, -1.29623592e-01f, 2.09747285e-01f, -1.19655356e-01f, 2.21075565e-01f, -2.82589179e-02f, -1.62704185e-01f, 7.05882609e-02f, -7.55028240e-03f, 1.54498786e-01f,
  -1.96476012e-01f, 5.03054261e-02f, 2.32025888e-02f, 3.30041111e-01f, 8.52145404e-02f, 8.86961594e-02f, -6.37045354e-02f, -3.95203829e-02f, -1.43545881e-01f, 3.18309128e-01f,
  -2.13350654e-01f, 8.64158496e-02f, -1.43962307e-02f, 3.13184783e-02f, 7.19078481e-02f, -9.96708125e-02f, 2.82988876e-01f, -9.60195735e-02f, -1.40562337e-02f, -2.04060748e-02f,
  1.50105372e-01f, 1.16902227e-02f, 6.64651170e-02f, 1.22228451e-01f, 3.20508219e-02f, -1.33978680e-01f, -1.08760923e-01f, 6.42303303e-02f, -1.57070503e-01f, 1.67146102e-01f,
  -8.59225467e-02f, 2.41442874e-01f, 3.88183929e-02f, 3.77502114e-01f, 2.90082455e-01f, 8.80855620e-02f, 2.07953248e-02f, -1.58294383e-02f, 3.20613049e-02f, -1.21251129e-01f,
  1.52650014e-01f, 2.42713779e-01f, -4.89285141e-01f, 3.93184721e-01f, -6.47692680e-02f, -1.22760914e-01f, -1.01758456e-02f, 5.30665275e-03f, -7.33979493e-02f, -1.21270180e-01f,
  -1.87703490e-01f, 1.26303434e-01f, -2.26236597e-01f, 6.07229546e-02f, -8.47411752e-02f, 1.33437499e-01f, 2.92656422e-01f, -2.00531706e-01f, 2.79331863e-01f, -4.98896232e-04f,
  1.73279655e-03f, -1.24016345e-01f, -9.20351297e-02f, 1.13731407e-01f, 8.67651179e-02f, 3.08417320e-01f, -8.45061019e-02f, 2.43995879e-02f, 6.20070323e-02f, 1.47630805e-02f,
  -2.58759171e-01f, -1.65707827e-01f, 1.82042792e-01f, 1.67304903e-01f, 6.82964176e-02f, -2.63599474e-02f, -6.43099919e-02f, 2.30262667e-01f, 5.91513440e-02f, -9.18364152e-02f,
  1.27189636e-01f, -2.85401732e-01f, -3.14000919e-02f, -1.19686894e-01f, -3.11210677e-02f, 2.33624279e-01f, 1.41324684e-01f, 1.50325075e-01f, -7.70767704e-02f, -2.66647696e-01f,
  7.68711492e-02f, 8.18310678e-02f, -1.19894221e-01f, 1.19663872e-01f, 6.84194192e-02f, 2.57494319e-02f, -4.67596278e-02f, 1.62601188e-01f, 2.08071709e-01f, 6.67274296e-02f,
  2.34723598e-01f, -3.36142257e-02f, -2.30264943e-02f, 5.80686517e-02f, 9.34347287e-02f, 2.26043016e-02f, 7.56102894e-03f, -3.96439910e-01f, 4.82918061e-02f, -7.79712126e-02f,
  2.03098163e-01f, -1.65736347e-01f, -1.36488512e-01f, -7.54078701e-02f, 3.18733841e-01f, 1.64433554e-01f, -2.48695627e-01f, -1.67564377e-02f, 9.57210436e-02f, 3.09571415e-01f,
  2.98052162e-01f, 2.59831905e-01f, -3.91854346e-02f, -8.54796395e-02f, 7.38782883e-02f, 3.06904942e-01f, -1.76879704e-01f, -1.63182095e-01f, 1.06066085e-01f, -3.95468576e-03f,
  2.86768436e-01f, 2.07598992e-02f, -2.78350227e-02f, -1.51764423e-01f, 3.23835373e-01f, 9.35039222e-02f, -2.76715886e-02f, 3.10284585e-01f, 8.61046761e-02f, 8.63070935e-02f,
  3.38553339e-01f, 1.63653623e-02f, -1.75072640e-01f, 2.65807807e-01f, 5.20218275e-02f, 2.66508222e-01f, -4.52223718e-02f, -2.03427762e-01f, 2.69238710e-01f, -2.53630951e-02f,
  -9.03193280e-02f, 3.78536552e-01f, 3.18870962e-01f, 1.55987144e-01f, -8.31281319e-02f, 9.28227082e-02f, 1.84245437e-01f, -3.50614148e-03f, 4.35269736e-02f, 1.39414877e-01f,
  -4.67395298e-02f, 1.45268708e-01f, 5.15448861e-02f, -1.21313985e-02f, -1.44978702e-01f, 5.36280423e-02f, 2.18346924e-01f, 6.60113618e-02f, 1.99968129e-01f, 1.85415715e-01f,
  -4.62207705e-01f, -6.47261739e-02f, 8.10134113e-02f, -1.70579568e-01f, 1.30574942e-01f, 1.35306701e-01f, -8.64546150e-02f, 1.13757066e-01f, 2.31923401e-01f, 2.53149986e-01f,
  8.71218964e-02f, -6.47365078e-02f, 6.00262545e-02f, 1.07403405e-01f, -2.06590399e-01f, 2.96894610e-02f, -1.81710005e-01f, -4.96790893e-02f, -3.51550034e-03f, -3.63464653e-02f,
  -1.71976145e-02f, -5.03905892e-01f, -3.72345075e-02f, -1.89396441e-01f, 2.33711138e-01f, 2.99560875e-01f, -3.49662006e-02f, 8.96848664e-02f, 2.19064385e-01f, -4.22453694e-02f,
  4.88931760e-02f, 3.64211231e-01f, 1.90323547e-01f, -2.04828516e-01f, 4.86371964e-02f, 1.48683593e-01f, -2.98541561e-02f, 1.27890766e-01f, 1.89956576e-02f, 1.86574295e-01f,
  1.75955772e-01f, 6.28334656e-02f, 1.93190590e-01f, 6.67373836e-02f, -1.10731684e-02f, 1.56594366e-01f, 1.59037206e-02f, 1.56341881e-01f, -6.34853691e-02f, 1.36166111e-01f,
  -8.72992277e-02f, 4.97086570e-02f, 2.37498924e-01f, 1.66100159e-01f, 1.58389837e-01f, 8.90040621e-02f, 5.12144621e-03f, 1.15361236e-01f, 3.29328626e-01f, 1.01654500e-01f,
  1.64378002e-01f, 2.27994502e-01f, -1.23053923e-01f, 2.27289453e-01f, 2.06363827e-01f, -9.42021608e-02f, -2.65529454e-02f, -3.50782812e-01f, -3.92306685e-01f, 4.79206741e-01f,
  -1.91649646e-01f, 1.07199736e-01f, -1.93422168e-01f, 6.06267527e-02f, -4.84926328e-02f, 1.55612156e-01f, 1.15041286e-02f, -7.54308477e-02f, -1.78032041e-01f, 9.49676484e-02f,
  1.97207689e-01f, 2.65947223e-01f, -3.21232080e-01f, 2.61595309e-01f, 2.81857610e-01f, 8.95988420e-02f, -3.62521499e-01f, -3.44291888e-02f, -3.38461343e-03f, -2.02222183e-01f,
  -2.60058027e-02f, 1.62212640e-01f, -4.43556160e-02f, -3.17122430e-01f, -2.02157721e-01f, -1.81556985e-01f, 1.84719458e-01f, -9.88293812e-02f, -1.23123385e-01f, 1.69198677e-01f,
  1.48640245e-01f, -2.60056138e-01f, -3.02976910e-02f, 2.69013852e-01f, 2.14038581e-01f, -3.48860249e-02f, -1.24521919e-01f, 3.46247822e-01f, 3.63263547e-01f, 4.24146242e-02f,
  1.66535869e-01f, 4.07087475e-01f, 1.45483855e-02f, -3.98918167e-02f, 5.24268113e-02f, -1.11655235e-01f, 4.75888811e-02f, 8.78651962e-02f, -2.11676255e-01f, 2.05943540e-01f,
  2.39670813e-01f, 2.55231798e-01f, 2.18410686e-01f, -2.97294259e-01f, 1.07236877e-01f, 1.31322235e-01f, -8.53518620e-02f, 1.23620883e-01f, -1.89823180e-01f, -8.44865572e-03f,
  3.23554933e-01f, -1.66420102e-01f, -4.17234004e-01f, -8.63266829e-03f, -2.96064653e-02f, -2.41710424e-01f, -2.18314469e-01f, 2.78966688e-02f, 3.41344886e-02f, -3.98188867e-02f,
  -1.02447920e-01f, 2.71708369e-01f, 1.71006560e-01f, -3.96085642e-02f, 1.27940983e-01f, 1.23078570e-01f, -9.26859975e-02f, 2.75708467e-01f, 1.19893610e-01f, 3.22411239e-01f,
  4.34569046e-02f, 2.90123999e-01f, 2.49821037e-01f, 3.85822579e-02f, -2.30067056e-02f, -2.38631099e-01f, 5.31609077e-03f, -3.07655960e-01f, 8.94425660e-02f, 5.57353497e-02f,
  8.11210722e-02f, 2.40812376e-01f, 2.81559199e-01f, 2.45723963e-01f, -6.00454062e-02f, 1.08446352e-01f, 6.57435060e-02f, 2.25193202e-04f, -1.94880038e-01f, 5.26417047e-02f,
  1.84859261e-01f, 2.12217435e-01f, 8.52840114e-03f, 1.70506030e-01f, -1.27421785e-02f, -1.02602631e-01f, 2.17850938e-01f, 1.96537226e-01f, -2.59889424e-01f, -1.05852246e-01f,
  1.08305588e-01f, 5.92638887e-02f, 5.69623224e-02f, -1.01291969e-01f, 1.22940749e-01f, 2.63780236e-01f, 1.14033498e-01f, -1.38817117e-01f, 2.30731800e-01f, 2.25972429e-01f,
  9.92947593e-02f, -4.91148457e-02f, 4.85103875e-02f, -6.16593659e-02f, 3.18038046e-01f, 3.75509530e-01f, 1.89662695e-01f, -2.68586129e-01f, 3.52163501e-02f, 2.15575173e-01f,
  1.22784212e-01f, 1.27344504e-01f, 9.12078321e-02f, -7.66290501e-02f, -1.94825768e-01f, 2.22969383e-01f, -9.41081494e-02f, 2.75097668e-01f, 1.23304829e-01f, 2.58336604e-01f,
  1.59261778e-01f, -8.91563147e-02f, 1.89017989e-02f, 1.38116315e-01f, 2.92079002e-01f, 9.85441729e-02f, 1.19923241e-01f, 1.64034978e-01f, 1.34346873e-01f, -1.27175987e-01f,
  -2.54948139e-02f, 4.62094322e-02f, 1.86873019e-01f, 2.28185710e-02f, -6.07455745e-02f, -3.02716810e-02f, 1.97537407e-01f, -1.18970219e-02f, 2.04026282e-01f, -7.50724822e-02f,
  -5.29784374e-02f, 3.06378514e-01f, -2.35300928e-01f, 3.84248681e-02f, 9.49713290e-02f, -6.94035888e-02f, 8.04095529e-03f, 2.65720010e-01f, -2.57173777e-01f, -1.17028423e-01f,
  2.08522901e-01f, 7.27002025e-02f, -1.31560430e-01f, -1.98788226e-01f, 5.16920686e-02f, 2.81448543e-01f, 2.54364163e-01f, 8.87692124e-02f, -2.73308251e-02f, -7.46064484e-02f,
  -1.98775172e-01f, 2.45643780e-01f, 3.00185159e-02f, -1.57484606e-01f, 1.21648893e-01f, 4.73943315e-02f, -4.16168571e-01f, 2.53564179e-01f, -4.78121266e-03f, -5.37938550e-02f,
  4.07123230e-02f, 9.87298861e-02f, -5.86177334e-02f, 9.36619267e-02f, 6.99457526e-02f, 1.54676020e-01f, 1.74578745e-02f, -3.04526556e-02f, 2.18317121e-01f, -2.78395675e-02f,
  -3.48262046e-03f, -3.81492935e-02f, -3.15573737e-02f, 6.22166060e-02f, 1.27566757e-03f, -6.49380609e-02f, 8.71877149e-02f, -1.22617319e-01f, -4.47408296e-02f, -6.31363690e-02f,
  -2.46133313e-01f, -2.59357374e-02f, 1.66813359e-01f, 1.84893131e-01f, -6.00637086e-02f, 1.09630227e-01f, 2.02426270e-01f, -1.21069118e-01f, 1.30959556e-01f, 2.59948000e-02f,
  -2.85871565e-01f, 1.20919891e-01f, 6.42431453e-02f, 3.05636413e-03f, -6.21652603e-03f, -4.83959615e-02f, 1.44721955e-01f, 5.15620336e-02f, -3.01426858e-01f, 1.48031533e-01f,
  1.90112770e-01f, -2.30594501e-02f, 7.58172497e-02f, -2.93572228e-02f, -6.80175871e-02f, -7.58301392e-02f, 2.43530646e-01f, 2.04566240e-01f, -1.89810827e-01f, -3.12000755e-02f,
  -1.55142071e-02f, -8.16121846e-02f, -1.86858281e-01f, -8.16992074e-02f, -1.34955242e-01f, -1.04756899e-01f, -2.01738939e-01f, -3.75078879e-02f, -2.38143548e-01f, -2.74496704e-01f,
  2.13499129e-01f, -2.61988401e-01f, 6.59173504e-02f, 6.65675551e-02f, -2.37055555e-01f, -7.19388649e-02f, 1.00570256e-02f, -1.37292892e-01f, -2.58076042e-01f, -3.11664939e-01f,
  1.61204696e-01f, 5.99918589e-02f, -9.28062648e-02f, -1.07595056e-01f, -2.86214668e-02f, 4.36208695e-02f, 1.13208771e-01f, 1.57706931e-01f, 1.56706199e-01f, -1.58393368e-01f,
  1.23448506e-01f, 6.97465762e-02f, 2.17703849e-01f, 9.80064869e-02f, 2.63624907e-01f, 1.86856970e-01f, 5.47054447e-02f, 1.40229449e-01f, 1.27051204e-01f, 1.19027451e-01f,
  1.46625623e-01f, -4.65517566e-02f, 1.24407262e-01f, -1.94156244e-01f, 1.24496594e-01f, 9.59446728e-02f, 4.24571522e-02f, 5.88505454e-02f, -4.76059765e-02f, 1.36099746e-02f,
  1.97087675e-02f, 9.06806290e-02f, 2.47096956e-01f, 9.13499913e-04f, 4.92086518e-04f, -1.92057535e-01f, -2.64616162e-01f, -3.95706333e-02f, 1.49193943e-01f, 1.32696658e-01f,
  -8.63588939e-04f, -2.43051397e-03f, 5.08363955e-02f, -1.63413331e-01f, -1.65571004e-01f, 5.27001731e-03f, 1.41553715e-01f, 1.06498390e-01f, 1.21780328e-01f, -6.97558671e-02f,
  2.34387349e-02f, 9.31152478e-02f, 2.15456169e-02f, 6.50886968e-02f, -1.69699550e-01f, -1.89739570e-01f, 2.10262343e-01f, -1.92503288e-01f, -3.29974115e-01f, -2.07507268e-01f,
  2.07455039e-01f, 2.87539582e-03f, 1.59432620e-01f, -1.01738490e-01f, 1.39073029e-01f, -4.97629046e-02f, -9.27607194e-02f, 2.04541311e-01f, 1.77787215e-01f, 1.44273251e-01f,
  8.41424912e-02f, -3.36423159e-01f, -1.94022238e-01f, 2.28824034e-01f, -5.75379021e-02f, 1.19302750e-01f, 1.20712379e-02f, 2.04352245e-01f, 1.55181110e-01f, 5.98809011e-02f,
  -6.35578185e-02f, -3.60201508e-01f, 2.46842638e-01f, -1.98502749e-01f, 3.75092886e-02f, 1.58257574e-01f, 1.39380231e-01f, 1.93671167e-01f, 1.69615030e-01f, -1.11070246e-01f,
  -7.19675422e-02f, 1.44493058e-01f, -5.84886335e-02f, -2.51417011e-01f, 5.02339378e-03f, -6.35717660e-02f, 1.05349101e-01f, -1.29800722e-01f, -1.29715562e-01f, 5.18979467e-02f,
  1.67068973e-01f, -1.64598122e-01f, -8.59670714e-02f, 2.03285888e-01f, 7.04152361e-02f, 7.49588609e-02f, -1.41634464e-01f, 1.40756428e-01f, -3.56645696e-02f, -5.69724888e-02f,
  -5.60865439e-02f, 8.95507112e-02f, -3.40322286e-01f, -1.82059273e-01f, -1.59419551e-01f, -2.93360114e-01f, 1.68526277e-01f, -5.46034575e-02f, -3.15066665e-01f, -3.73557732e-02f,
  5.88132218e-02f, -1.16775803e-01f, -5.99993840e-02f, 4.36358564e-02f, 1.83171988e-01f, -2.61018932e-01f, -2.86047179e-02f, -2.60548759e-02f, 2.09838971e-01f, -3.12266707e-01f,
  1.80123914e-02f, -3.50465178e-02f, 1.88534409e-01f, -8.00630599e-02f, -1.86795920e-01f, 1.75049044e-02f, -8.73349514e-03f, -1.29592299e-01f, 4.98132966e-02f, -4.49583568e-02f,
  1.79437548e-01f, -6.20333329e-02f, 2.23508090e-01f, 3.10683280e-01f, 2.44483049e-03f, -4.96868528e-02f, 1.97638974e-01f, 1.86511621e-01f, 2.07159370e-01f, 1.48088753e-01f,
  1.49654761e-01f, -6.34046122e-02f, -1.31086111e-02f, 3.30044515e-02f, 2.50472516e-01f, 2.48260275e-01f, 9.17301551e-02f, -1.01068571e-01f, 2.16159046e-01f, 2.63595611e-01f,
  4.14275348e-01f, -5.70184104e-02f, -1.33289788e-02f, -2.86129564e-01f, -1.30792722e-01f, -7.68110380e-02f, 1.45796118e-02f, 2.00182959e-01f, 2.30196208e-01f, 1.30021796e-01f,
  1.54318854e-01f, 5.29228449e-02f, 8.46326873e-02f, 1.04816295e-02f, 1.44245252e-01f, 1.89377770e-01f, 1.17653795e-01f, 1.64941162e-01f, 2.32286364e-01f, 4.28086340e-01f,
  1.90540746e-01f, 1.42013645e-02f, 1.35779083e-01f, -3.77120316e-01f, 1.45433590e-01f, 2.56126188e-02f, 1.62550390e-01f, -2.33757943e-01f, -1.10120423e-01f, 1.23224199e-01f,
  2.17538774e-01f, 2.03082472e-01f, -9.84885022e-02f, 2.66310312e-02f, -8.22409093e-02f, 9.64499712e-02f, 1.47366703e-01f, 1.51404113e-01f, 9.63890553e-02f, 1.15873709e-01f,
  1.16364427e-01f, 1.09791882e-01f, 3.77784781e-02f, 7.06857368e-02f, 2.14315951e-02f, 3.02367471e-02f, 4.30260152e-01f, 1.86699554e-01f, -6.05516173e-02f, 1.34155164e-02f,
  3.00508082e-01f, -6.79595619e-02f, -1.79169953e-01f, 2.57116020e-01f, -1.08887836e-01f, 2.63632536e-01f, 2.14953855e-01f, -1.75100550e-01f, 1.46012053e-01f, 4.34629202e-01f,
  -1.49973378e-01f, 1.11635014e-01f, -1.58372313e-01f, 6.04715310e-02f, 1.28816038e-01f, -6.05467781e-02f, 3.29419635e-02f, 2.07917005e-01f, 3.58260833e-02f, 2.29721949e-01f,
  1.30314276e-01f, 8.33999589e-02f, -6.70640767e-02f, -9.24015641e-02f, 1.92570090e-01f, 1.02100680e-02f, 4.41251174e-02f, 1.98860601e-01f, 1.84456497e-01f, 4.35032174e-02f,
  5.98873124e-02f, 1.14978161e-02f, 2.03694627e-01f, 1.94826722e-01f, 2.48865098e-01f, 3.37022170e-02f, 9.74662900e-02f, -4.51739162e-01f, 8.36864784e-02f, -5.64141423e-02f,
  6.94825798e-02f, -1.53804973e-01f, -1.38225453e-03f, 2.49603152e-01f, 8.25313553e-02f, -9.63607337e-03f, -9.36769024e-02f, 1.01281300e-01f, -6.42162785e-02f, 3.11445832e-01f,
  5.81434518e-02f, 2.01991796e-01f, 1.09614074e-01f, -8.60347599e-02f, 1.04676299e-01f, 1.21986762e-01f, -2.77119547e-01f, -1.72958877e-02f, 1.45762786e-01f, -7.45684803e-02f,
  2.23410547e-01f, 2.37967744e-01f, 1.13880925e-01f, -1.98460340e-01f, 2.53458858e-01f, -5.27351312e-02f, 3.93467136e-02f, 2.59895951e-01f, 1.63798943e-01f, -1.02933615e-01f,
  3.23530436e-01f, 3.99925224e-02f, -2.18518302e-01f, 1.06062293e-01f, 7.63855316e-03f, 4.32182074e-01f, 7.44079128e-02f, -1.40647590e-01f, 1.54461488e-01f, -3.27187851e-02f,
  -6.02849834e-02f, 3.26657087e-01f, 2.85444204e-02f, 2.45518312e-01f, -6.72205538e-02f, 2.39390299e-01f, -7.05069862e-03f, -6.85035586e-02f, 7.73540288e-02f, 2.63415370e-03f,
  1.74717471e-01f, -1.48754030e-01f, -6.78777844e-02f, -5.89044243e-02f, 1.92348063e-01f, 1.32079214e-01f, 9.69137251e-02f, 2.74398535e-01f, 2.15455458e-01f, -1.01798475e-02f,
  2.26683989e-01f, -1.05156623e-01f, 8.68202522e-02f, 1.52511835e-01f, 1.12884425e-01f, -3.88680808e-02f, -5.25620021e-02f, 2.31661409e-01f, 7.46378228e-02f, 6.31112456e-02f,
  -6.33364171e-02f, 1.80465370e-01f, -8.12862143e-02f, 4.66874987e-03f, -1.29185736e-01f, 1.74709707e-01f, 7.88612440e-02f, 5.22447713e-02f, 1.22195221e-01f, -5.84150776e-02f,
  -3.51949222e-02f, 5.16142994e-02f, 1.41605228e-01f, 4.18325774e-02f, 1.53650850e-01f, -2.21619662e-02f, -1.52104869e-02f, 4.80332002e-02f, 5.90915754e-02f, 1.69766452e-02f,
  3.57876508e-03f, 8.57209414e-02f, -1.91820711e-01f, -5.43235913e-02f, 1.12821080e-01f, -1.06720187e-01f, 4.17219475e-03f, 1.18027121e-01f, -4.00359333e-02f, 1.44076943e-01f,
  -8.42756107e-02f, -4.54341508e-02f, 4.30005565e-02f, -1.09879740e-01f, 7.06550851e-02f, 2.20903337e-01f, 5.28253131e-02f, 6.69098459e-03f, 9.08346176e-02f, -1.26071140e-01f,
  -1.45758847e-02f, -5.10034189e-02f, -5.37366308e-02f, 2.09702507e-01f, 8.84617399e-03f, -1.84921086e-01f, -2.00793758e-01f, 4.94118594e-02f, -2.73278773e-01f, -8.75920653e-02f,
  -1.14781685e-01f, -2.35541373e-01f, -9.67020541e-02f, -1.55779824e-01f, -1.69344231e-01f, 9.66206938e-02f, 1.78824514e-02f, -1.54859051e-01f, -1.83307767e-01f, -5.12757599e-02f,
  1.24781966e-01f, -1.96866021e-01f, 7.46589079e-02f, -1.81378990e-01f, 2.06262216e-01f, -9.69530270e-02f, 7.37982839e-02f, -5.06122895e-02f, 8.10800567e-02f, -7.84715116e-02f,
  -3.92583199e-03f, 1.12885959e-01f, -2.01239921e-02f, -1.32958829e-01f, 1.99965775e-01f, 5.49994558e-02f, 2.10081249e-01f, 1.93604931e-01f, 1.47036627e-01f, 2.68017739e-01f,
  -7.80338868e-02f, 1.10324286e-01f, 1.23607516e-01f, 2.79020995e-01f, 1.46294340e-01f, 4.26121019e-02f, 5.30201197e-02f, -2.10263636e-02f, -9.12243873e-03f, -5.94162904e-02f,
  2.06087723e-01f, 3.19153905e-01f, -3.34153930e-03f, -2.37987012e-01f, -5.22736991e-05f, 1.36252850e-01f, 2.30665267e-01f, -2.58973446e-02f, 1.62648261e-01f, -2.23821029e-01f,
  -1.74728274e-01f, -9.51780286e-03f, 1.94193318e-01f, 1.89380094e-01f, 9.49907154e-02f, 1.21148072e-01f, -1.85624227e-01f, 2.59006470e-01f, 1.49137557e-01f, 2.02920973e-01f,
  8.78472254e-02f, 1.16253138e-01f, -1.66234583e-01f, 2.14901790e-01f, -2.48211506e-03f, -2.05375314e-01f, 4.87876944e-02f, 8.33605900e-02f, -5.20144522e-01f, -1.69852525e-01f,
  4.00155559e-02f, -1.48751006e-01f, 3.81589681e-02f, -1.91303343e-01f, -1.46319307e-02f, -2.74641234e-02f, 1.51944175e-01f, 9.98582691e-02f, 2.09955439e-01f, -2.13083073e-01f,
  1.33937120e-01f, -1.00466728e-01f, 8.52423310e-02f, 3.94828096e-02f, -3.36229801e-01f, 1.59200355e-02f, -2.27299184e-02f, 2.61886399e-02f, 3.68274562e-02f, -1.95581734e-01f,
  6.24205582e-02f, -2.69952510e-02f, -2.83418186e-02f, 1.47819534e-01f, -1.50704905e-01f, 1.71188921e-01f, 2.93489248e-01f, 2.47015446e-01f, 2.71003991e-01f, -1.63828567e-01f,
  3.73121172e-01f, -3.17140110e-02f, 1.84289843e-03f, -2.19113119e-02f, 1.11614570e-01f, 2.82974780e-01f, -4.49111350e-02f, -1.75924301e-01f, 1.79513678e-01f, 1.39076099e-01f,
  6.89067915e-02f, 1.05973534e-01f, -3.28503102e-02f, -1.13027811e-01f, 1.42001256e-01f, -1.34217180e-03f, -5.59023023e-02f, 2.45678890e-02f, 4.04012471e-01f, 1.44257173e-01f,
  -9.09561515e-02f, 6.51386976e-02f, 9.09408107e-02f, 1.77209586e-01f, 1.81720570e-01f, 1.63953885e-01f, 2.13054880e-01f, -3.43412906e-02f, 2.04899445e-01f, 8.37552696e-02f,
  -8.44652802e-02f, -1.88008808e-02f, -6.90189973e-02f, 2.74789810e-01f, 1.25706345e-01f, 1.32864431e-01f, 1.35760028e-02f, -1.84113026e-01f, -2.50182271e-01f, -8.47405419e-02f,
  -1.67765573e-01f, 3.58900018e-02f, -9.71623883e-02f, 7.45396642e-03f, -5.55964299e-02f, 4.28394713e-02f, -7.02026635e-02f, 2.85207480e-02f, 1.46369413e-01f, 2.36205265e-01f,
  6.56488314e-02f, -7.74552450e-02f, 6.81160092e-02f, 1.77646980e-01f, 2.41439939e-01f, 3.26900601e-01f, -3.64118554e-02f, -1.57226250e-01f, 1.22124530e-01f, 3.29580903e-02f,
  -1.52297124e-01f, 1.38362303e-01f, 3.09174061e-01f, -2.41882518e-01f, -1.15803499e-02f, -1.18550502e-01f, -1.91634446e-01f, 1.70323491e-01f, 6.88365325e-02f, 1.52081981e-01f,
  -2.57211357e-01f, -1.30872339e-01f, -1.74029425e-01f, 1.68356195e-01f, -9.12647024e-02f, 7.82611370e-02f, 1.87191531e-01f, -1.57520220e-01f, -5.67006022e-02f, -2.35556737e-01f,
  1.73884779e-01f, 5.43720834e-02f, 5.78458654e-03f, -9.97340828e-02f, 3.57235432e-01f, 2.19221432e-02f, 2.33222201e-01f, -2.03759268e-01f, 8.56618509e-02f, -8.87583941e-02f,
  2.69285083e-01f, 1.99393943e-01f, -1.85748432e-02f, 1.02432482e-01f, 1.53300717e-01f, 1.26884893e-01f, 3.58104594e-02f, 2.66940117e-01f, -1.88423142e-01f, -4.50894274e-02f,
  1.38301879e-01f, -1.35517223e-02f, -5.27128428e-02f, 3.96645457e-01f, 1.72475129e-01f, 1.84551597e-01f, -1.17114268e-01f, 1.16081879e-01f, 2.02897087e-01f, 2.74763405e-01f,
  -1.81478605e-01f, 2.33170718e-01f, 9.40158870e-03f, 3.72216702e-02f, 1.22716576e-01f, 3.10376316e-01f, 6.02527633e-02f, 1.36168793e-01f, -2.39724852e-02f, 5.93112037e-02f,
  -1.06337607e-01f, -1.71442717e-01f, 1.89761043e-01f, 7.35241473e-02f, -4.54058833e-02f, -9.25070792e-02f, 8.27732310e-02f, -1.31052151e-01f, 2.74093170e-02f, 1.92912683e-01f,
  5.87128028e-02f, 9.18725431e-02f, -1.66093960e-01f, -4.92120981e-02f, 1.82429209e-01f, 1.31574258e-01f, 1.78134799e-01f, -1.23868071e-01f, -3.11303228e-01f, -8.49037543e-02f,
  2.21895501e-01f, 2.03021958e-01f, 2.03631848e-01f, 2.33361155e-01f, -2.76663005e-02f, -3.26437466e-02f, 1.22873364e-02f, 2.21614968e-02f, 7.14960098e-02f, -8.28353222e-03f,
  3.05338353e-02f, 4.07780439e-01f, 7.07363430e-03f, 1.98818296e-01f, 1.81540817e-01f, -1.15216628e-01f, 1.21363617e-01f, 1.27373189e-01f, 1.79063696e-02f, 1.78348526e-01f,
  -5.32434762e-01f, -1.57863930e-01f, 2.06851304e-01f, -3.74489933e-01f, -2.45704681e-01f, 6.51379600e-02f, -3.02793588e-02f, -2.83827305e-01f, 1.22500814e-01f, 4.34460826e-02f,
  -2.12150216e-01f, -7.37408400e-02f, -9.17104036e-02f, -1.57415948e-03f, 3.15011740e-01f, 4.86080833e-02f, -8.20566490e-02f, 3.07154711e-02f, -2.33907416e-01f, 3.55557173e-01f,
  5.56247402e-03f, -7.95319825e-02f, -2.28561051e-02f, 1.09807476e-01f, 8.36470351e-02f, 1.67100549e-01f, -1.10141367e-01f, -1.34437487e-01f, 2.07310066e-01f, -1.46094663e-02f,
  8.97964370e-03f, 2.17479050e-01f, 1.40655309e-01f, 1.50774375e-01f, 9.91434157e-02f, 3.61541152e-01f, 1.09858856e-01f, 2.04839200e-01f, 1.44918621e-01f, -3.91053855e-02f,
  1.56582221e-02f, 2.45967638e-02f, 1.83912694e-01f, 2.65554458e-01f, -9.21950210e-03f, -6.76503628e-02f, 1.02740087e-01f, -1.03606604e-01f, -8.13577622e-02f, 7.62595376e-03f,
  1.41016617e-01f, 2.26888120e-01f, -1.24464698e-01f, 1.51192844e-01f, 2.30262548e-01f, -8.15458298e-02f, -9.14921239e-03f, 1.51289150e-01f, 1.61058441e-01f, 1.68640196e-01f,
  2.24050894e-01f, 2.11654469e-01f, 9.86701772e-02f, -6.04871847e-02f, -4.30313759e-02f, 4.73492257e-02f, 2.05652773e-01f, 2.27172133e-02f, 1.72602862e-01f, -3.57098222e-01f,
  -2.04889983e-01f, 1.94088474e-01f, 2.95157641e-01f, 1.75264031e-01f, -7.86277466e-03f, -1.04658552e-01f, 6.13542087e-03f, -1.91399232e-02f, 2.37212360e-01f, 4.15691547e-02f,
  -2.77695768e-02f, 1.57432824e-01f, 6.17963038e-02f, -9.20081362e-02f, 1.51819766e-01f, -1.02837399e-01f, 2.37486199e-01f, 5.35117872e-02f, -1.31978318e-01f, -1.28249019e-01f,
  -1.81609064e-01f, -3.25057693e-02f, 7.39491880e-02f, 1.38998911e-01f, 2.05174685e-01f, -1.87612370e-01f, -2.29589641e-01f, 1.15448549e-01f, -6.76636696e-02f, -1.70045987e-01f,
  1.00932546e-01f, 2.22687513e-01f, -9.46705788e-02f, -1.29332216e-02f, -2.87351042e-01f, 9.95376334e-02f, -2.56291240e-01f, -1.75562277e-02f, 1.46695361e-01f, 1.37880975e-02f,
  1.59940362e-01f, -2.66510934e-01f, 1.56235740e-01f, -1.70289427e-01f, 1.56969696e-01f, 8.15321505e-02f, -1.54232472e-01f, 4.77043800e-02f, 1.27600906e-02f, 7.43009429e-03f,
  9.83649567e-02f, 3.22244167e-02f, -7.00569972e-02f, 7.67655373e-02f, -1.05574928e-01f, -2.71359742e-01f, -8.30120444e-02f, 1.72259778e-01f, -3.27214360e-01f, -3.18511397e-01f,
  -1.74285635e-01f, -4.73208614e-02f, -7.47812539e-02f, -1.14527009e-02f, 2.82835901e-01f, 1.44437402e-01f, -5.07981330e-02f, 1.47367254e-01f, -3.85294221e-02f, -1.79149932e-03f,
  -4.97955717e-02f, 1.78933486e-01f, -5.71729615e-02f, 1.71592146e-01f, 9.70021859e-02f, -4.56368811e-02f, 1.29781693e-01f, 2.20790192e-01f, -1.00372270e-01f, -4.05580908e-01f,
  -7.79896304e-02f, -1.90195009e-01f, -1.82162464e-01f, 1.37320414e-01f, -3.91497724e-02f, -3.98808606e-02f, 2.52914935e-01f, 2.24087626e-01f, 9.59470421e-02f, 1.63009673e-01f,
  4.14680898e-01f, 3.32424529e-02f, 6.92384988e-02f, 7.70937055e-02f, 6.09466620e-02f, -2.00348154e-01f, 1.25929257e-02f, -3.12026367e-02f, 2.31476426e-01f, 1.78285986e-02f,
  2.16791853e-01f, -1.35013774e-01f, -4.72280271e-02f, 2.07466289e-01f, 3.16324651e-01f, -1.07299700e-01f, -2.51528710e-01f, 7.74886236e-02f, 2.89655983e-01f, 9.34902057e-02f,
  9.12960023e-02f, 3.26196373e-01f, 1.47264138e-01f, 8.02484527e-02f, -1.80322185e-01f, 1.09436408e-01f, 1.64156139e-01f, 2.49886110e-01f, 2.58678913e-01f, 3.51576179e-01f,
  1.25813276e-01f, 1.53870180e-01f, -9.12067816e-02f, 1.88918039e-01f, 1.29295766e-01f, 2.72990130e-02f, 9.51831043e-02f, -1.29551753e-01f, -3.11387718e-01f, 1.49800256e-01f,
  -5.55446669e-02f, 9.57458243e-02f, 1.35367364e-02f, -7.58198649e-02f, -1.47637427e-02f, -1.78184569e-01f, 9.12168920e-02f, -2.54539438e-02f, 1.66521460e-01f, 1.83064252e-01f,
  7.60390013e-02f, -9.66273993e-02f, 3.11194092e-01f, -1.43827081e-01f, 9.65984538e-02f, 1.08821541e-01f, 9.30782259e-02f, 9.11631994e-03f, -2.41912052e-01f, 2.83032767e-02f,
  7.35464320e-02f, 1.35781854e-01f, 7.99111873e-02f, -2.25541234e-01f, -1.76987067e-01f, -1.09416112e-01f, -3.50998491e-01f, 7.10524395e-02f, 1.90160975e-01f, 3.69982511e-01f,
  -8.26761872e-02f, 8.47852305e-02f, -3.36253434e-01f, 5.98595068e-02f, -2.45501131e-01f, 8.08171276e-03f, 2.34458044e-01f, -1.54747009e-01f, 1.48267731e-01f, -6.49984479e-02f,
  3.04334700e-01f, -1.63304037e-03f, -1.66910309e-02f, -1.36360899e-01f, -4.26559485e-02f, 1.55158574e-02f, 1.05746619e-01f, 2.21337378e-01f, -6.37106523e-02f, 1.41552866e-01f,
  1.56910762e-01f, -3.56600247e-02f, 2.60706633e-01f, 1.99022457e-01f, 2.27890998e-01f, 2.76941895e-01f, -2.94538856e-01f, -2.03221329e-02f, 1.48338601e-01f, -3.12059186e-02f,
  -1.79573223e-01f, 2.35657766e-01f, -4.35745269e-02f, -1.11069761e-01f, -2.32486576e-01f, -1.29942214e-02f, -1.89192161e-01f, 1.31147712e-01f, -1.16578661e-01f, -3.84602584e-02f,
  7.07233772e-02f, -1.33155972e-01f, 6.27588257e-02f, 1.68581948e-01f, -2.42663562e-01f, -1.27523065e-01f, 1.06887929e-01f, -1.75364435e-01f, 2.36290414e-02f, -1.07115693e-01f,
  2.25072578e-01f, 1.74686462e-01f, 5.14191128e-02f, -6.74141422e-02f, 4.05163839e-02f, -6.07267395e-03f, -1.55596003e-01f, 8.37111846e-02f, -7.96548277e-02f, -1.04372531e-01f,
  2.49142393e-01f, 1.07599795e-01f, 1.63809285e-01f, -2.59422034e-01f, 2.63777673e-01f, 3.39777142e-01f, -6.02886304e-02f, 2.34538112e-02f, 1.15380302e-01f, 2.04044104e-01f,
  2.46231761e-02f, -2.19734106e-02f, 1.21025443e-02f, 1.61888391e-01f, 8.91772211e-02f, -6.91160858e-02f, -2.20930561e-01f, 1.44689769e-01f, -1.66890815e-01f, 7.93604106e-02f,
  7.89060593e-02f, -5.10357618e-02f, 4.96014580e-02f, 5.31403199e-02f, 1.08557448e-01f, 2.87470341e-01f, 2.13903189e-03f, 1.03399031e-01f, 1.58070098e-03f, 1.13546103e-01f,
  -1.14352129e-01f, 2.65881747e-01f, -3.19049239e-01f, 7.24034607e-02f, 1.62113443e-01f, -2.00778082e-01f, -3.95365572e-03f, -1.57344773e-01f, 4.26334962e-02f, -4.97475080e-02f,
  -2.73086756e-01f, 4.91114631e-02f, -1.01687603e-01f, -7.31845424e-02f, 4.13870543e-01f, -9.67101678e-02f, 4.20660973e-01f, 6.23128563e-02f, 6.70187101e-02f, -7.77332857e-02f,
  1.04620092e-01f, -4.74564672e-01f, 2.12631792e-01f, 2.41944984e-01f, -1.35263100e-01f, 3.23515460e-02f, -3.13645273e-01f, -7.19954744e-02f, -2.70089582e-02f, 8.23823437e-02f,
  1.28919169e-01f, 7.01860711e-02f, -7.91884810e-02f, 8.95616263e-02f, -2.02462047e-01f, 1.06396168e-01f, 1.26619399e-01f, 1.77297160e-01f, 1.72236338e-01f, 5.03172353e-02f,
  -3.36252898e-01f, 2.98879325e-01f, 2.82253083e-02f, 1.81610748e-01f, 2.59149849e-01f, 6.40896335e-02f, 3.25056821e-01f, -3.59266579e-01f, -7.47748837e-03f, -2.70767123e-01f,
  1.73215911e-01f, 1.13177888e-01f, 1.91341802e-01f, 3.04212451e-01f, 2.36838996e-01f, 1.67339012e-01f, 5.69446832e-02f, 5.60223274e-02f, 1.59997478e-01f, 1.85535550e-01f,
  1.90057740e-01f, 3.43998939e-01f, 1.63287986e-02f, 1.32794783e-01f, -1.29817873e-01f, -6.17029704e-02f, 8.53913352e-02f, -1.72423229e-01f, -2.88768291e-01f, 1.73038140e-01f,
  -3.14744741e-01f, -7.91896528e-05f, -2.34986246e-01f, -1.74098648e-02f, -7.35826343e-02f, -1.19764082e-01f, 1.65318996e-02f, -1.48127735e-01f, 1.16775148e-01f, -2.75973994e-02f,
  -1.17251568e-01f, 3.15365970e-01f, -2.09033847e-01f, 2.34129027e-01f, 3.02200764e-01f, 9.06659886e-02f, -5.82795776e-02f, 3.52519266e-02f, 1.15026921e-01f, -3.28026861e-01f,
  -1.60360426e-01f, -1.27856076e-01f, 1.42854989e-01f, -1.92527503e-01f, -2.07745228e-02f, -1.71547785e-01f, -4.36229557e-02f, 1.95346445e-01f, 5.20506455e-03f, 2.46175498e-01f,
  1.45191565e-01f, 1.45081326e-01f, 1.10814264e-02f, 2.01525837e-01f, -1.04505636e-01f, 1.69165060e-01f, -2.29067892e-01f, 1.73685521e-01f, 3.46980363e-01f, -2.42214769e-01f,
  2.42091402e-01f, 1.37299895e-01f, 2.40795195e-01f, 7.50234053e-02f, -1.55596852e-01f, 2.11422015e-02f, 1.37932003e-01f, 3.62712853e-02f, 1.64929822e-01f, -2.75688857e-01f,
  1.66467670e-02f, -1.43143043e-01f, 4.42300327e-02f, -3.83066176e-03f, 3.49900834e-02f, 3.84725258e-02f, 1.44136712e-01f, 1.40914902e-01f, 2.74693161e-01f, 2.37337962e-01f,
  -6.91708028e-02f, 4.62452590e-01f, 3.87237400e-01f, -2.22203597e-01f, 2.55880564e-01f, 2.24458173e-01f, 5.02643697e-02f, 1.34975821e-01f, -7.16264471e-02f, -4.96411994e-02f,
  7.76703954e-02f, 2.10385069e-01f, -2.09978908e-01f, 2.30180889e-01f, 4.02790904e-01f, 1.73866689e-01f, 1.52896181e-01f, -2.45576248e-01f, 1.02040479e-02f, -1.27046779e-01f,
  2.91987062e-01f, 2.50645459e-01f, -3.43052745e-01f, 7.50460252e-02f, 2.33431607e-01f, 2.04708412e-01f, -6.39069453e-02f, 1.80607915e-01f, 1.14037052e-01f, -6.19725883e-02f,
  -8.20422694e-02f, -1.56176522e-01f, 6.12729974e-02f, -1.71368197e-01f, -5.06474599e-02f, -3.67998809e-01f, 1.74993381e-01f, 3.69325399e-01f, 1.20338149e-01f, 1.64983302e-01f,
  -1.14904933e-01f, -1.96476102e-01f, 2.87898351e-03f, 2.45671377e-01f, -6.29592035e-03f, 9.66881961e-03f, -1.17310956e-01f, -2.40703281e-02f, 1.31022289e-01f, 9.96893272e-02f,
  2.11674243e-01f, 1.34761870e-01f, 7.22854107e-04f, -5.73121384e-02f, -3.75296399e-02f, -6.26227632e-02f, 2.89542198e-01f, 1.22720391e-01f, 1.38721734e-01f, 2.63442993e-01f,
  7.90974125e-02f, 3.19719277e-02f, 2.34695747e-02f, -1.81479633e-01f, 1.47468805e-01f, -1.73333049e-01f, -2.23550603e-01f, 2.27678344e-01f, 1.97342560e-01f, 1.84593156e-01f,
  -1.23370700e-01f, 1.27912581e-01f, 7.53120147e-03f, 2.58407980e-01f, 4.23869975e-02f, 2.22208604e-01f, -9.88363400e-02f, 3.22288990e-01f, 2.33646348e-01f, 1.38598934e-01f,
  -5.82642630e-02f, 3.10833454e-01f, -1.11487629e-02f, 3.12991962e-02f, -2.42329195e-01f, -7.86744058e-02f, 4.96940576e-02f, -1.39940185e-02f, 5.52586243e-02f, -1.00447245e-01f,
  7.96661153e-02f, -1.24265373e-01f, -5.92448078e-02f, 3.43641117e-02f, 2.56449133e-01f, -7.53029361e-02f, 6.21827394e-02f, 1.82717919e-01f, -1.83138296e-01f, -2.71393746e-01f,
  1.26489103e-01f, 3.95818502e-01f, -1.07736271e-02f, -1.70439333e-02f, -1.31618381e-01f, 1.22323923e-01f, 1.90890327e-01f, 2.14733139e-01f, 2.86136150e-01f, 4.30533499e-01f,
  -1.14070205e-02f, 1.00521058e-01f, 4.59877960e-02f, -5.43886535e-02f, 3.94208804e-02f, 5.86438440e-02f, 1.76984176e-01f, 1.45259783e-01f, -8.81080106e-02f, -1.40129291e-02f,
  -8.80520642e-02f, -2.17558723e-02f, -1.99626356e-01f, -1.87389210e-01f, -8.69263411e-02f, 1.35837093e-01f, -4.05696273e-01f, -1.15550958e-01f, -1.06949352e-01f, -2.30750497e-02f,
  -3.64727415e-02f, -1.02084309e-01f, 1.45506233e-01f, 2.19436407e-01f, 1.41598001e-01f, 7.92665035e-02f, 1.52390465e-01f, -2.47729167e-01f, 1.41440094e-01f, 1.59269854e-01f,
  -6.96074776e-03f, -2.78795734e-02f, -2.44184971e-01f, -1.57133088e-01f, -5.52544780e-02f, 1.70667872e-01f, -1.36776716e-01f, -8.28176439e-02f, -4.72964942e-02f, 7.21213222e-02f,
  -2.58301884e-01f, -1.44924491e-03f, 4.33491804e-02f, 1.07039958e-01f, 2.62555983e-02f, 1.96383581e-01f, 2.64380157e-01f, -9.98506695e-02f, 3.13547403e-01f, 1.43057508e-02f,
  -1.85767729e-02f, -8.52535218e-02f, -2.85571162e-02f, -9.81371999e-02f, 5.02294069e-03f, -5.56867421e-02f, 2.22167552e-01f, -4.98027131e-02f, -9.53420624e-02f, 1.08065717e-01f,
  -1.38429597e-01f, 2.62709968e-02f, 3.04150544e-02f, 1.28592104e-01f, -2.26963013e-01f, 2.01840729e-01f, 3.00548613e-01f, 5.70442006e-02f, 1.59667268e-01f, 9.77021176e-03f,
  2.10878477e-01f, 3.33669558e-02f, -1.97352991e-02f, -1.47606116e-02f, 1.69095218e-01f, 1.89394340e-01f, 9.13185552e-02f, 2.43765965e-01f, 5.11476472e-02f, 7.57656768e-02f,
  9.77576338e-03f, -7.96020404e-02f, 2.72901189e-02f, -1.42370537e-01f, -1.77428365e-01f, 3.24862182e-01f, 5.03664836e-02f, 8.55954364e-02f, -3.20202410e-01f, 1.93696544e-01f,
  -1.29803285e-01f, 1.58916205e-01f, -1.81814581e-02f, 4.14219163e-02f, -1.59482554e-01f, -1.11683086e-01f, 1.82830766e-01f, 3.06207329e-01f, 2.10722126e-02f, -4.84457165e-02f,
  1.22373313e-01f, -9.32882279e-02f, -8.40582103e-02f, 1.38658928e-02f, 1.04916841e-01f, 1.31692141e-01f, 1.60712060e-02f, -3.86167206e-02f, -1.31338015e-01f, -3.78292464e-02f,
  -1.69937387e-01f, -5.48864901e-02f, 3.84991877e-02f, -3.78271431e-01f, -5.07440493e-02f, 3.29284966e-01f, 1.30943552e-01f, -3.45712066e-01f, 2.32132152e-01f, 4.03449059e-01f,
  9.97738317e-02f, 1.46819100e-01f, -2.06943169e-01f, 2.02368706e-01f, 2.59176195e-01f, 1.45766288e-01f, 1.64412588e-01f, 3.52133781e-01f, -1.60118882e-02f, 3.68734635e-03f,
  -1.89665899e-01f, 5.94931357e-02f, 1.32975653e-01f, 1.22548148e-01f, 2.77284205e-01f, -3.66953164e-02f, -8.64035711e-02f, -8.26502070e-02f, 2.50471681e-01f, 2.30324760e-01f,
  2.17593014e-01f, 3.31571549e-01f, 1.83195665e-01f, 7.06091672e-02f, 3.05405855e-01f, -1.50341421e-01f, 1.41684618e-03f, 5.12266182e-04f, 7.64360279e-03f, -1.31697152e-02f,
  -2.07227945e-01f, 2.00314388e-01f, -1.38960183e-01f, -1.16139343e-02f, -1.55470386e-01f, 3.60825325e-05f, -1.58403277e-01f, 1.66840367e-02f, 9.41800103e-02f, 1.38103604e-01f,
  -1.08342141e-01f, 2.13141382e-01f, 1.06662311e-01f, -3.44098471e-02f, 2.57408679e-01f, -2.77518392e-01f, 5.06391712e-02f, 8.31931382e-02f, 2.41235703e-01f, -9.47456807e-02f,
  -1.60311591e-02f, -1.09028868e-01f, 1.79098412e-01f, 6.73571900e-02f, -1.45713136e-01f, 1.08395733e-01f, -2.90093720e-01f, 4.73792702e-02f, 3.55199017e-02f, -8.64531845e-02f,
  9.95630324e-02f, 3.78578216e-01f, -1.20590053e-01f, 2.82106817e-01f, -1.98186964e-01f, 1.83789134e-01f, -7.11900219e-02f, 1.19138964e-01f, 2.74974227e-01f, -1.20634148e-02f,
  3.06229830e-01f, 2.13005498e-01f, 2.26437911e-01f, -1.72798395e-01f, -1.03120007e-01f, -5.70119992e-02f, 1.18360907e-01f, 1.48201406e-01f, 5.91054782e-02f, 2.68761814e-01f,
  8.24806765e-02f, 1.79056334e-03f, -1.64989129e-01f, 4.13687229e-02f, 1.15930066e-01f, -3.19682285e-02f, 2.31097743e-01f, 1.00241294e-02f, -1.87450662e-01f, -2.75358289e-01f,
  1.60360083e-01f, -2.33465105e-01f, 6.50491472e-03f, -1.12077609e-01f, -3.83243829e-01f, 9.73160192e-02f, 2.74220854e-01f, 5.47243170e-02f, 3.50645930e-02f, -2.93856978e-01f,
  1.11277066e-01f, -5.66597991e-02f, 2.15048522e-01f, -6.35781661e-02f, -4.47781771e-01f, 6.89637884e-02f, 4.96555082e-02f, 1.42789885e-01f, 7.20250607e-02f, -3.03645909e-01f,
  -2.08143935e-01f, -5.05677536e-02f, 3.80679756e-01f, 2.79490322e-01f, -7.54561424e-02f, -3.47224660e-02f, 2.94020116e-01f, -1.32776871e-02f, -3.93322855e-02f, 1.24689922e-01f,
  2.48812109e-01f, -1.16552634e-03f, 1.96966290e-01f, 7.98983276e-02f, -5.28206490e-02f, 4.76447612e-01f, -4.35387120e-02f, 8.06720257e-02f, 2.43393674e-01f, 7.54483566e-02f,
  1.52861491e-01f, 5.20487428e-02f, -1.90361321e-01f, -1.30194366e-01f, -9.59210694e-02f, 3.00186068e-01f, 1.25429869e-01f, 1.56295791e-01f, 3.82936699e-03f, 1.84744522e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  3.45376804e-02f, -2.84960829e-02f, 6.18772283e-02f, 2.07077742e-01f, 3.68502773e-02f, 7.22961798e-02f, 1.54285356e-01f, 4.71590608e-02f, -7.78038800e-02f, 1.02713212e-01f,
  1.00827768e-01f, 8.31928179e-02f, -3.59751023e-02f, 3.56680676e-02f, 1.38728708e-01f, -3.92948128e-02f, 2.02646270e-01f, -1.57448128e-02f, -7.04455674e-02f, 8.39503706e-02f,
  -7.47640803e-02f, -6.27552345e-03f, -3.17476206e-02f, -1.70750450e-02f, 1.87233597e-01f, 1.06254503e-01f, 2.47265309e-01f, 9.69562680e-02f, 9.06104445e-02f, -7.31753707e-02f,
  1.94852278e-01f, 9.53547508e-02f, 8.00403673e-03f, 1.18970715e-01f, 9.03187543e-02f, 1.21210456e-01f, -8.93954188e-02f, 1.95425436e-01f, -3.28017510e-02f, 1.38655882e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.15114318e-02f, -2.18909025e-01f, 1.02588460e-01f, -2.72140894e-02f, -5.38321324e-02f, -7.54497871e-02f, -8.23636949e-02f, -7.32523128e-02f, -2.23594923e-02f, -4.87558432e-02f,
  -1.44983619e-01f, -2.60242075e-01f, -2.48256981e-01f, 1.04664609e-01f, -1.18270867e-01f, -1.64034516e-01f, 2.85928279e-01f, 2.39403784e-01f, 2.69090384e-01f, -1.80975348e-01f,
  -1.83608606e-01f, 1.05998769e-01f, 1.86422154e-01f, 2.05268189e-01f, -3.14497352e-02f, -1.75855771e-01f, -1.19314633e-01f, 6.84908358e-03f, -7.66007379e-02f, 1.18992463e-01f,
  9.73283425e-02f, 7.54847601e-02f, 3.83999586e-01f, -1.69266552e-01f, -1.10119842e-01f, -1.88109845e-01f, -1.71178311e-01f, -1.14154331e-01f, -1.93771780e-01f, -4.33992147e-02f,
  2.40109675e-02f, 1.82451680e-01f, -6.73088282e-02f, 2.06260800e-01f, -4.00551409e-01f, -3.00829738e-01f, -2.43762150e-01f, 1.56396851e-01f, 2.15452656e-01f, 7.32116997e-02f,
  -3.02557111e-01f, -2.39081949e-01f, 7.74914399e-02f, 2.40879580e-01f, -5.83929606e-02f, -3.33342314e-01f, 1.12148620e-01f, -3.29317778e-01f, 8.77176896e-02f, -2.01223895e-01f,
  1.63862914e-01f, -1.55381352e-01f, -2.75880784e-01f, -2.43891552e-01f, -3.71079236e-01f, -3.87162492e-02f, -2.53711164e-01f, 1.04690328e-01f, -4.18638578e-03f, 3.53946209e-01f,
  9.86224785e-02f, 1.69197202e-01f, -5.76089062e-02f, 2.16626480e-01f, 1.75705627e-01f, 1.58246189e-01f, -3.47281337e-01f, 1.15817264e-01f, 1.43192008e-01f, 2.54515439e-01f,
  3.81616533e-01f, -2.61461109e-01f, -1.29381567e-01f, 3.64492945e-02f, 4.58357632e-02f, -3.17070156e-01f, 2.42742747e-02f, -4.02422547e-01f, -4.45840091e-01f, -2.63705850e-01f,
  2.15102057e-03f, 1.67493880e-01f, 1.46187738e-01f, 5.32201789e-02f, 1.22493841e-01f, 5.15153296e-02f, -1.32590696e-01f, -1.42324129e-02f, 2.30241977e-02f, 1.15593530e-01f,
  3.63973200e-01f, 1.94100197e-02f, -2.32479781e-01f, -1.51772305e-01f, 2.42241219e-01f, -4.26648885e-01f, -1.25677034e-01f, 4.63951975e-02f, -3.04729044e-01f, 7.49393702e-02f,
  -2.63397962e-01f, -8.18421468e-02f, 2.59904474e-01f, -1.30212247e-01f, 1.35593787e-01f, 6.67160302e-02f, -9.88045409e-02f, 1.76104948e-01f, -3.35698992e-01f, 2.10189242e-02f,
  -3.19385529e-01f, -2.49038413e-01f, 1.57913975e-02f, 8.98378622e-03f, 2.48032436e-01f, 8.82958248e-02f, -4.90612149e-01f, 1.37387037e-01f, 2.39342928e-01f, 4.27753218e-02f,
  -6.66304156e-02f, 8.23574886e-03f, 6.01691715e-02f, -6.67481124e-03f, 1.23065084e-01f, -6.37386590e-02f, 2.62422740e-01f, -4.00623195e-02f, 7.03059584e-02f, -2.42430955e-01f,
  -3.37503850e-02f, 2.02969715e-01f, -1.68722555e-01f, -8.56559426e-02f, 5.38208932e-02f, -2.08355095e-02f, -2.51692444e-01f, -7.17111602e-02f, -3.06261070e-02f, -1.06386334e-01f,
  2.28329182e-01f, -3.04627538e-01f, 9.32311937e-02f, -2.70700425e-01f, 1.65635660e-01f, 2.44048268e-01f, -1.56719312e-01f, -1.90865435e-02f, -1.34555936e-01f, -5.09580135e-01f,
  -2.73448169e-01f, -2.95001775e-01f, 6.75058514e-02f, 1.85632497e-01f, -7.56166056e-02f, -2.34823644e-01f, -9.86670926e-02f, -2.63955623e-01f, 1.89775273e-01f, -2.03173712e-01f,
  -1.05134018e-01f, 6.64711744e-02f, 1.19127192e-01f, -2.37816244e-01f, -2.69531786e-01f, 6.26350790e-02f, 2.87563771e-01f, 8.87345448e-02f, -9.26089436e-02f, 1.44354358e-01f,
  2.56890118e-01f, -1.13498189e-01f, 1.27626747e-01f, -2.21808270e-01f, 1.22418411e-01f, 1.16036579e-01f, -3.00553650e-01f, -7.05572367e-01f, -3.10221184e-02f, -5.23373365e-01f,
  9.64199603e-02f, 2.07245588e-01f, 1.16243973e-01f, 1.72732212e-02f, 3.24013730e-04f, -7.96629712e-02f, -1.91708922e-01f, 3.41556109e-02f, -1.86531007e-01f, 3.93522419e-02f,
  -5.77355996e-02f, -1.33178011e-01f, -9.25763324e-02f, -1.37184188e-02f, -8.56654868e-02f, -2.42435038e-01f, -3.32138129e-02f, -2.10957170e-01f, 3.23979706e-01f, 8.06319416e-02f,
  -9.89551693e-02f, -8.26175660e-02f, 2.79478561e-02f, -8.09397642e-03f, 1.27997831e-01f, 1.00355752e-01f, -9.16371047e-02f, 1.99583426e-01f, -1.22197680e-01f, -5.06053306e-02f,
  1.21777199e-01f, -3.76819670e-01f, 2.11648881e-01f, 9.51380879e-02f, -1.72504455e-01f, -3.91422302e-01f, -3.73906910e-01f, 1.29495397e-01f, 1.35553896e-01f, -2.56965280e-01f,
  -4.45464775e-02f, 1.34656370e-01f, -6.10065460e-01f, 1.56461984e-01f, -7.55347237e-02f, 1.41495854e-01f, 1.85915604e-01f, 7.77714998e-02f, 4.01317775e-02f, 7.46786371e-02f,
  1.33003891e-01f, 6.05359077e-02f, -4.14730102e-01f, -5.66422008e-02f, 5.03843799e-02f, -4.93423119e-02f, 6.52337149e-02f, -2.37190396e-01f, -2.54869640e-01f, -2.23472595e-01f,
  -1.19094603e-01f, -3.25863540e-01f, -7.97437429e-02f, -2.96447068e-01f, -1.28465503e-01f, 1.37339801e-01f, -1.14432499e-02f, 2.78992385e-01f, -4.70569730e-01f, -2.78517693e-01f,
  2.54571468e-01f, -1.67329997e-01f, 1.11950010e-01f, 2.18014270e-01f, 3.08328748e-01f, -3.59944761e-01f, -1.90604672e-01f, 2.34316111e-01f, 2.41615728e-01f, 2.38235518e-01f,
  -2.04238787e-01f, 4.89366621e-01f, -1.74925163e-01f, -2.83034325e-01f, -1.68090761e-01f, -1.59958750e-01f, 1.31364346e-01f, 1.99321255e-01f, -4.96880114e-01f, 4.69694406e-01f,
  -1.04531303e-01f, -5.59242181e-02f, 5.36164492e-02f, -3.29064727e-01f, 2.17759266e-01f, 7.66012147e-02f, 4.21410985e-02f, 6.98803067e-02f, -1.12505972e-01f, 6.73462972e-02f,
  -1.12224475e-01f, -3.54249269e-01f, -1.19731881e-01f, -3.12266469e-01f, -3.31518263e-01f, 1.15328364e-01f, 5.94116300e-02f, -1.90974977e-02f, -8.90548900e-02f, 4.95641269e-02f,
  8.11625570e-02f, -2.46726096e-01f, 1.12696022e-01f, 8.53621289e-02f, 2.98833381e-03f, 5.94595596e-02f, 7.62587413e-02f, -4.25701022e-01f, 1.84820279e-01f, -3.64477485e-01f,
  2.51229465e-01f, -1.90590307e-01f, 6.52714446e-02f, -5.88251697e-03f, 1.90027937e-01f, -3.19534987e-01f, -8.54410306e-02f, -2.68575978e-02f, 1.63612545e-01f, -4.66218404e-02f,
  3.55038285e-01f, 1.71312600e-01f, 2.46915698e-01f, 3.12823564e-01f, 1.15019813e-01f, -2.40844458e-01f, 1.56351104e-01f, -2.87266791e-01f, -4.90449309e-01f, 9.86173004e-03f,
  -8.13522004e-03f, 3.48372646e-02f, 1.16780415e-01f, 1.07896253e-01f, 2.94869781e-01f, -3.14034045e-01f, -2.37284094e-01f, 2.80273676e-01f, -8.21334422e-02f, 3.11919779e-01f,
  -2.71977484e-01f, 2.00079009e-01f, 6.05333224e-02f, -2.17821464e-01f, -1.47176988e-05f, -2.73769170e-01f, 2.20662847e-01f, 1.80338863e-02f, 1.91025034e-01f, -1.70523091e-03f,
  -6.38900697e-02f, 1.94846272e-01f, 8.78084917e-03f, 1.58409938e-01f, -9.94835570e-02f, 2.19802558e-01f, -1.58017371e-02f, -3.90230082e-02f, -3.98191631e-01f, 6.73853755e-02f,
  -4.79764193e-02f, -3.27647239e-01f, -3.19418490e-01f, -3.29963088e-01f, 1.70327693e-01f, 1.46016240e-01f, 1.69671357e-01f, -3.06909770e-01f, -6.98300526e-02f, -7.32433498e-02f,
  1.62656978e-01f, -2.13572428e-01f, 1.31671712e-01f, 1.12867117e-01f, 2.21885163e-02f, -1.56903908e-01f, 2.57723063e-01f, -3.37176651e-01f, 2.39940614e-01f, 8.28182474e-02f,
  -1.33704588e-01f, 4.06117849e-02f, -2.42635794e-02f, -3.69600415e-01f, -9.31436792e-02f, 2.26346835e-01f, 2.06961051e-01f, 1.70600459e-01f, -2.61488497e-01f, 1.37422502e-01f,
  -6.76489621e-02f, 2.12257460e-01f, -1.40168890e-01f, 2.11674109e-01f, 2.65182644e-01f, 9.01538953e-02f, -3.34817395e-02f, -1.75318673e-01f, 5.53698204e-02f, -3.06654125e-01f,
  -1.76273644e-01f, 2.95385718e-01f, -4.06373739e-02f, 1.34549469e-01f, 6.81588799e-02f, -2.69371122e-01f, 1.23141602e-01f, 6.18535466e-02f, 2.75206238e-01f, -4.47512656e-01f,
  -3.19989443e-01f, -1.47270709e-01f, -3.89278792e-02f, 1.80795193e-01f, -6.76875055e-01f, -1.97492942e-01f, 6.98554292e-02f, 1.10272065e-01f, 6.34245127e-02f, -3.63357127e-01f,
  -3.22961986e-01f, 3.33140522e-01f, 2.11208925e-01f, -3.10140222e-01f, 2.46885680e-02f, -1.19269649e-02f, -1.35291561e-01f, -3.36864024e-01f, -9.66810435e-02f, -3.71392846e-01f,
  -2.07327127e-01f, -7.51512572e-02f, -5.07448316e-01f, 1.19976290e-01f, 1.18794180e-01f, 4.53754775e-02f, -4.55266267e-01f, -1.10107094e-01f, 7.24066496e-02f, -2.52034459e-02f,
  -1.23706579e-01f, 2.92383522e-01f, -3.43113065e-01f, 1.44995615e-01f, -1.14011526e-01f, 1.74979091e-01f, 3.49580273e-02f, -3.00989687e-01f, -3.63549814e-02f, -1.15925118e-01f,
  -1.43588353e-02f, 6.89915568e-02f, 5.64628653e-02f, -3.74175981e-02f, 3.76013592e-02f, 6.51935115e-02f, 1.25679886e-02f, 8.06247965e-02f, -1.43523827e-01f, -5.89959882e-02f,
  -6.32157326e-02f, 2.61320695e-02f, -7.39139169e-02f, 2.58455634e-01f, -1.44673049e-01f, -2.77231693e-01f, -8.09188336e-02f, -2.27393150e-01f, 1.74050704e-01f, 1.13730207e-01f,
  -2.45311067e-01f, 1.67342559e-01f, -2.86267065e-02f, 2.74948955e-01f, -3.71798128e-01f, -1.66187659e-01f, -3.49295169e-01f, 1.88413993e-01f, -8.27678591e-02f, -9.53120086e-03f,
  -1.28273927e-02f, 2.15764448e-01f, 1.69057533e-01f, 7.35033825e-02f, 4.11734730e-02f, -3.70638847e-01f, 1.64596125e-01f, -8.36776346e-02f, -1.10574745e-01f, -7.31388927e-02f,
  1.59401461e-01f, 1.96127519e-01f, 8.26887339e-02f, -9.64060146e-03f, -6.62834793e-02f, 1.26583785e-01f, -2.33600542e-01f, -3.00724834e-01f, -2.01462030e-01f, 1.94004148e-01f,
  -2.71322578e-01f, -1.01926684e-01f, -2.35972390e-01f, 9.57062542e-02f, 2.07299083e-01f, -2.60966897e-01f, -1.38158277e-01f, -2.66705543e-01f, -1.55776858e-01f, -5.68373017e-02f,
  1.29698170e-02f, -5.72593883e-02f, 1.79864720e-01f, -2.65863508e-01f, -4.79226336e-02f, 2.41453964e-02f, 8.57954100e-02f, -1.49602830e-01f, -2.64423579e-01f, -3.79069686e-01f,
  1.80643663e-01f, -2.28262953e-02f, -6.30388707e-02f, -2.97197342e-01f, 8.44202563e-02f, -4.07261774e-02f, 9.40974429e-02f, 1.65382735e-02f, 1.63345292e-01f, -3.25851768e-01f,
  -7.80060068e-02f, 1.58001155e-01f, -1.73179746e-01f, -7.54925162e-02f, -1.73983335e-01f, -5.80552444e-02f, 2.07094580e-01f, -1.01686023e-01f, 1.75644338e-01f, -1.21443130e-01f,
  -3.82554263e-01f, -7.83680603e-02f, -4.37882930e-01f, -3.79240870e-01f, -4.75218259e-02f, -5.37402229e-04f, -2.38586366e-01f, 1.88100874e-01f, -2.93983202e-02f, -9.74295586e-02f,
  1.98131293e-01f, 2.02456415e-02f, -2.92558819e-01f, -2.31335774e-01f, 3.91991794e-01f, -1.00685604e-01f, 1.48219168e-01f, 1.75925985e-01f, -7.23735616e-02f, -1.83094695e-01f,
  3.24224792e-02f, -4.12570626e-01f, 9.95826647e-02f, 2.51866132e-01f, 5.78264259e-02f, 1.94285095e-01f, -3.39597583e-01f, -1.14206634e-01f, -1.54712483e-01f, 1.70552284e-02f,
  -9.50198472e-02f, 1.11202545e-01f, 9.60399359e-02f, -2.38598660e-01f, -1.96205363e-01f, 3.30129005e-02f, 1.55050112e-02f, -2.39367057e-02f, -7.02661648e-02f, -2.98958808e-01f,
  -2.21727371e-01f, -2.38067508e-01f, -2.04873517e-01f, -2.49521047e-01f, 2.78376728e-01f, -1.23678505e-01f, -6.51120171e-02f, 1.32360831e-01f, 1.10036343e-01f, 1.45341888e-01f,
  -3.04329060e-02f, -1.10284239e-01f, -9.29816812e-02f, -2.36373603e-01f, 4.37606066e-01f, -3.21043909e-01f, -3.77779305e-02f, 4.46019590e-01f, 1.69483155e-01f, 1.87065899e-01f,
  2.04768982e-02f, 7.08854478e-03f, -1.74790651e-01f, 1.13237202e-01f, -3.73872131e-01f, -9.89200622e-02f, 9.73178968e-02f, -1.99319333e-01f, -5.43008268e-01f, -6.14486299e-02f,
  2.30353326e-01f, -4.61591125e-01f, -1.22483797e-01f, -2.39787176e-02f, 1.69635266e-01f, 4.25989404e-02f, 6.61711907e-03f, -6.71216622e-02f, -2.00574666e-01f, -8.80859941e-02f,
  -8.69488269e-02f, -3.64275128e-01f, -1.80654272e-01f, -7.39824027e-02f, -9.45775583e-02f, 2.38069430e-01f, -3.33498180e-01f, 1.65174261e-01f, 1.05396770e-01f, -2.90185422e-01f,
  1.97387666e-01f, 1.72831267e-01f, 2.54972428e-01f, 1.69055805e-01f, 1.24038628e-03f, -3.93555641e-01f, -3.92099172e-01f, 6.19906597e-02f, -3.52876708e-02f, -2.50756383e-01f,
  -4.34435457e-02f, -2.74253368e-01f, 1.44158006e-01f, -1.23700038e-01f, -1.50063053e-01f, -1.62722135e-03f, -1.10571511e-01f, -2.56755829e-01f, 7.04575405e-02f, 5.02000637e-02f,
  1.15919784e-01f, 7.30417073e-02f, 3.04028690e-02f, -1.81480333e-01f, 3.29402015e-02f, -4.09020670e-02f, -1.27544060e-01f, -4.02424298e-02f, -1.77599743e-01f, -2.13838788e-03f,
  -1.11369953e-01f, 2.41607472e-01f, 3.67813632e-02f, 3.96612324e-02f, -7.26290718e-02f, 3.52998942e-01f, 9.92274731e-02f, -5.58549464e-01f, 1.33282498e-01f, -4.85522270e-01f,
  -3.94423828e-02f, 2.32028469e-01f, -1.50583878e-01f, -4.69912112e-01f, 3.29680026e-01f, 1.22818068e-01f, -4.60748345e-01f, -2.84004390e-01f, 3.13399225e-01f, 2.34916255e-01f,
  -4.75425094e-01f, -1.76495034e-02f, 4.26459219e-03f, -2.96730280e-01f, 4.90126386e-02f, 1.99631974e-01f, 1.02852963e-01f, -1.21868946e-01f, -2.23571718e-01f, 1.85579136e-01f,
  1.79499254e-01f, -2.85462320e-01f, 5.46939336e-02f, -3.81106973e-01f, -2.38720596e-01f, -2.52056450e-01f, -3.25113446e-01f, -2.14095682e-01f, 1.77639261e-01f, -8.97972211e-02f,
  2.24771630e-03f, -2.19422609e-01f, -1.87081039e-01f, -3.59124780e-01f, 6.44659773e-02f, -1.54059425e-01f, -1.22720879e-02f, 6.40832558e-02f, 1.87427789e-01f, 1.97950065e-01f,
  1.33014396e-01f, 1.76067829e-01f, -8.54056180e-02f, -1.14913374e-01f, 7.04374118e-03f, 1.07179478e-01f, 2.08195925e-01f, -2.35871479e-01f, -1.02146022e-01f, 3.22659761e-01f,
  4.66506220e-02f, 1.19193085e-01f, 3.34114850e-01f, -8.82921088e-03f, 1.84742093e-01f, -1.29768670e-01f, -3.36289167e-01f, -5.78942848e-03f, -7.44172279e-03f, -1.85657486e-01f,
  -1.55869082e-01f, 2.11493760e-01f, -2.62675077e-01f, -3.68136346e-01f, 1.45284206e-01f, -4.51746881e-02f, -6.98692128e-02f, -1.73882514e-01f, -2.46169642e-01f, 1.09058522e-01f,
  1.49726616e-02f, 2.18817368e-01f, -4.17633075e-03f, -4.64784317e-02f, -2.49052167e-01f, -1.18285947e-01f, -3.64838630e-01f, -1.71765864e-01f, 1.63660169e-01f, 1.39092878e-01f,
  3.63971628e-02f, -3.14664125e-01f, -2.19940960e-01f, -2.71179467e-01f, 9.63584613e-03f, -5.48375305e-04f, -3.10221929e-02f, -2.62149036e-01f, -4.43555415e-02f, 1.89492270e-01f,
  -3.04040164e-01f, 1.78291082e-01f, -1.26948908e-01f, 1.37991711e-01f, -2.38779947e-01f, 1.64962828e-01f, 2.11680159e-01f, 1.02415390e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.74934813e-02f, -1.97419245e-02f, 8.54635239e-02f, -1.63066000e-01f, 1.38819888e-01f, 3.68826576e-02f, 1.20687775e-01f, -3.08993692e-03f, -2.13613994e-02f, 4.29025739e-02f,
  4.18931469e-02f, -3.55067775e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    