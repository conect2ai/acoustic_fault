/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.32134187e-01f, -4.64433461e-01f, -2.20151469e-01f, -2.19804734e-01f, -5.80525994e-02f, -3.99721026e-01f, -2.85162002e-01f, -9.10345241e-02f, -1.36798367e-01f, -1.04886331e-01f,
  1.31782725e-01f, -3.21104228e-01f, 6.60282895e-02f, -2.41686746e-01f, 5.98446578e-02f, 3.96940066e-03f, -3.03048849e-01f, -1.52709469e-01f, -1.34817762e-02f, -2.49539524e-01f,
  -8.81040320e-02f, -1.04216158e-01f, -4.82236668e-02f, -2.95834150e-02f, -2.17796057e-01f, -1.03768378e-01f, 1.40460178e-01f, 3.02237831e-02f, -2.88836397e-02f, -8.64271075e-03f,
  1.53519049e-01f, 4.34604622e-02f, 5.65376878e-03f, -1.02051504e-01f, -9.92676020e-02f, -5.11379354e-02f, -3.39478068e-02f, 5.48825637e-02f, 8.48934129e-02f, -7.37474263e-02f,
  -3.79920304e-02f, -2.37762257e-02f, -9.33717936e-03f, -1.36057911e-02f, -7.02538490e-02f, -6.04590997e-02f, 1.48228910e-02f, -3.78584000e-03f, 1.20066414e-02f, -1.08529991e-02f,
  -1.89901073e-03f, 1.64408311e-02f, -6.26859590e-02f, 2.08396669e-02f, -2.78378502e-02f, -3.54546495e-02f, 9.25409608e-03f, -1.90982651e-02f, 2.11160388e-02f, -4.43365388e-02f,
  -5.02043962e-02f, -5.59093989e-02f, -9.21813995e-02f, 1.63547639e-02f, -7.38263279e-02f, 8.90355185e-02f, -2.24222280e-02f, 3.49632129e-02f, 8.37484468e-03f, -5.24938963e-02f,
  -1.65018477e-02f, -6.33486956e-02f, -1.45304371e-02f, 1.00424681e-02f, 3.21008936e-02f, 2.01042928e-02f, -5.38561074e-03f, 2.44428898e-04f, -2.25492120e-02f, 9.14166868e-02f,
  2.76532639e-02f, -5.49287312e-02f, -2.46650390e-02f, 7.39320274e-03f, 3.22692692e-02f, 1.80751104e-02f, -5.56792878e-02f, -4.44654673e-02f, 1.59830619e-02f, -1.91400889e-02f,
  -9.26254615e-02f, -2.16080278e-01f, -5.02652815e-03f, 8.94760247e-03f, 7.11805522e-02f, -3.03422045e-02f, -1.15939544e-03f, -1.41777443e-02f, -7.61660933e-02f, -1.27294939e-02f,
  -2.75252461e-02f, 2.04685722e-02f, -2.97351833e-02f, 3.39383483e-02f, -5.12933396e-02f, 4.91257943e-02f, -1.52300075e-02f, -3.34194750e-02f, -4.68792319e-02f, -1.03432713e-02f,
  -1.97872873e-02f, -7.36101791e-02f, 4.43840027e-02f, 1.29398787e-02f, 1.09675108e-02f, 1.62447281e-02f, -5.40253706e-02f, 2.31609717e-02f, 8.31302628e-03f, -1.52514409e-02f,
  -5.16642749e-01f, 8.13341364e-02f, 8.50867555e-02f, -1.67205065e-01f, -1.80183008e-01f, 2.08525121e-01f, 2.05906376e-01f, -1.37681857e-01f, -2.62381807e-02f, 2.45634019e-02f,
  -9.38210636e-02f, 2.66550750e-01f, 1.02295473e-01f, 1.77117825e-01f, -1.93886682e-02f, 1.35117680e-01f, -1.82723179e-01f, 9.54383388e-02f, -9.38910246e-02f, -1.71253964e-01f,
  -9.82876271e-02f, 9.31061525e-03f, 3.62103097e-02f, 2.10123956e-02f, -1.53807178e-01f, -2.12908745e-01f, -2.10284114e-01f, 1.16848201e-02f, -5.29512540e-02f, 1.68019637e-01f,
  8.70986655e-02f, -9.32814777e-02f, 1.08075030e-01f, 3.82342860e-02f, -5.00393249e-02f, -1.03056282e-02f, -6.83396123e-03f, 1.25699311e-01f, 6.81411568e-03f, 1.03875631e-02f,
  -1.33214402e-03f, -2.51680017e-02f, 4.93194982e-02f, 8.86316760e-04f, -4.10211943e-02f, 5.14210053e-02f, 1.80620234e-02f, -2.30825823e-02f, 2.32778732e-02f, -4.13156860e-02f,
  5.02271689e-02f, -6.34575561e-02f, -7.76223540e-02f, 3.47335115e-02f, -3.64183299e-02f, 3.29190819e-03f, 2.06889175e-02f, 5.57228066e-02f, -8.13183859e-02f, 4.42373827e-02f,
  -1.13375746e-01f, -5.62199280e-02f, -4.60952409e-02f, 2.82667074e-02f, 1.45816002e-02f, -9.83056054e-03f, 3.97959910e-03f, 6.15697354e-02f, -2.40538735e-02f, -2.69152019e-02f,
  -1.33006210e-02f, -4.61257733e-02f, 3.09708016e-03f, -4.10780832e-02f, -2.30378658e-02f, -4.11525965e-02f, 6.43647462e-03f, 2.35409830e-02f, -5.96648008e-02f, -1.60486326e-02f,
  4.74390015e-02f, -2.65564788e-02f, 1.26942292e-01f, -9.73717645e-02f, 3.36944647e-02f, -8.85192025e-03f, 2.32665185e-02f, -8.63727462e-03f, 2.55716629e-02f, -6.40407130e-02f,
  -4.92299907e-03f, -2.66579151e-01f, 4.93925298e-03f, 4.37472910e-02f, 9.10359472e-02f, 1.25948768e-02f, -4.82596969e-03f, -5.26170507e-02f, -3.19738057e-03f, -7.21710250e-02f,
  -9.01791602e-02f, -6.17171265e-03f, -1.20921962e-01f, -1.18198413e-02f, -4.94728237e-02f, -1.64060295e-02f, -5.25519671e-03f, -2.07396015e-03f, -2.33123936e-02f, -4.20440780e-03f,
  -4.40349132e-02f, -2.41444204e-02f, 1.76694058e-02f, -1.74843576e-02f, -5.42781204e-02f, -1.65302306e-02f, -9.93245915e-02f, -3.20000178e-03f, 1.66822895e-02f, 2.44723987e-02f,
  1.60776973e-01f, 5.39633445e-02f, 3.02591771e-01f, 1.14446685e-01f, -3.95051129e-02f, 2.48419587e-02f, 1.57154307e-01f, -3.52763645e-02f, 2.38754526e-01f, -2.90698886e-01f,
  3.04303113e-02f, -9.58515052e-03f, 1.69036984e-01f, 8.29894934e-03f, 8.80254209e-02f, 2.66333163e-01f, -1.23001141e-02f, 1.52107673e-02f, 1.82514817e-01f, -1.54871583e-01f,
  5.29765040e-02f, -1.96765497e-01f, 1.20672069e-01f, -2.27221213e-02f, 4.14375737e-02f, 1.31814936e-02f, -3.89584124e-01f, 1.83121800e-01f, -2.14870647e-01f, -4.51708911e-03f,
  -2.43368471e-04f, 1.38631836e-01f, 5.82625857e-03f, 4.01137397e-02f, -7.87900612e-02f, -2.80899014e-02f, -1.88337732e-02f, 1.61462247e-01f, 3.68914381e-02f, 3.40931341e-02f,
  -2.57209260e-02f, 2.43780054e-02f, -4.58343048e-03f, 9.83921364e-02f, -1.18520102e-02f, 6.36271834e-02f, 3.01780161e-02f, 3.83472405e-02f, 8.91372561e-02f, 1.02519229e-01f,
  8.32762420e-02f, 6.40060455e-02f, -1.53606257e-03f, 2.88856179e-02f, 1.09608099e-01f, 9.92477089e-02f, 4.24223207e-02f, -1.34103531e-02f, -6.33829320e-03f, 2.39976160e-02f,
  4.70009968e-02f, -1.43289827e-02f, 3.50556262e-02f, -1.70288030e-02f, 1.61375627e-02f, -4.04947698e-02f, -4.26211767e-02f, -7.19952136e-02f, -9.35125165e-03f, -4.39858958e-02f,
  -7.52600580e-02f, 4.27796599e-03f, -2.25466620e-02f, 2.67614946e-02f, -2.64272951e-02f, -2.58505847e-02f, -2.46839244e-02f, -4.03928198e-02f, -4.03805934e-02f, -3.26754265e-02f,
  -2.40798201e-02f, -1.05759744e-02f, 2.62529664e-02f, 1.93765275e-02f, -9.18880664e-03f, -1.18656838e-02f, 2.87057851e-02f, 7.97470659e-02f, 2.08655372e-03f, -2.67764069e-02f,
  -2.70239145e-01f, -3.34826410e-01f, -3.12197451e-02f, -1.40136313e-02f, -3.07581108e-02f, -2.02866737e-02f, 1.15954131e-01f, -2.41539180e-02f, -3.03017497e-02f, -2.32790168e-02f,
  -1.93398744e-02f, -6.57320991e-02f, -6.86921924e-02f, -4.95687053e-02f, 2.21716203e-02f, -6.64673075e-02f, -7.11359307e-02f, -4.11664546e-02f, -1.39916196e-01f, -3.26739289e-02f,
  -8.45358819e-02f, -4.72634705e-03f, 4.19336259e-02f, -5.06556965e-02f, -8.20795745e-02f, -1.11894287e-01f, -7.64532089e-02f, 7.56347254e-02f, -6.50723055e-02f, -2.50637196e-02f,
  5.46469331e-01f, -1.61254317e-01f, 1.92423895e-01f, 1.08482689e-01f, -3.19014378e-02f, 3.54973048e-01f, -3.97937410e-02f, -2.69258022e-02f, -1.38480335e-01f, -1.71295375e-01f,
  -5.75434491e-02f, 7.22210947e-03f, -1.13820009e-01f, 5.40212840e-02f, 4.69028592e-01f, -1.40514702e-01f, 2.93922961e-01f, 2.64249574e-02f, -1.08577833e-02f, 3.77829932e-02f,
  3.19170617e-02f, -5.88071533e-02f, 1.46436498e-01f, -1.05630912e-01f, 4.80216406e-02f, 5.14705740e-02f, -9.63395983e-02f, -4.93891863e-03f, 2.01961637e-01f, 9.05519798e-02f,
  7.76451528e-02f, -2.31815755e-01f, -8.34424123e-02f, 2.42316183e-02f, 9.59142148e-02f, 3.32881920e-02f, 6.96428195e-02f, 5.04928306e-02f, -3.94443907e-02f, 2.13067830e-02f,
  1.22134052e-02f, 8.21383949e-03f, 4.86590192e-02f, -3.54980864e-02f, -2.98548117e-03f, -1.99936777e-02f, -3.29428948e-02f, 1.09650642e-01f, -5.79102077e-02f, 4.30895165e-02f,
  1.79560259e-02f, 1.27154425e-01f, 2.91399658e-02f, 7.00990409e-02f, 7.14177191e-02f, -8.69783387e-03f, -2.76843887e-02f, 3.73931862e-02f, 9.73774493e-02f, 1.31247751e-02f,
  3.04620480e-03f, 1.28649389e-02f, -7.88816903e-03f, 3.74399163e-02f, -7.43460096e-03f, -2.79049147e-02f, -4.21939455e-02f, -5.81674697e-03f, -2.11381004e-03f, -4.14536297e-02f,
  -7.43994396e-03f, -9.59249213e-03f, -6.27375990e-02f, 2.48897299e-02f, 1.69941057e-02f, -4.90881428e-02f, 2.00315323e-02f, -6.30394369e-02f, 2.14962531e-02f, 7.95563608e-02f,
  -5.92532046e-02f, -1.62845086e-02f, 1.43621443e-02f, 4.01790515e-02f, 7.49402959e-03f, 3.06318980e-02f, 4.67117550e-03f, 1.44836120e-02f, -1.20894434e-02f, 1.25882462e-01f,
  -2.75205113e-02f, -1.37434306e-03f, -2.68096980e-02f, -2.99397763e-02f, -5.92942052e-02f, 1.15597271e-03f, 2.54924037e-03f, 2.75363196e-02f, 3.39618921e-02f, -3.39624695e-02f,
  6.01367420e-03f, -5.29814474e-02f, -6.79377373e-03f, -2.37515825e-03f, 3.03712636e-02f, 3.45899491e-03f, -3.22532728e-02f, -1.12140849e-02f, 6.44888803e-02f, -6.42186776e-03f,
  7.49039697e-03f, -6.91340342e-02f, 5.28147519e-02f, -4.80915047e-02f, 5.14994971e-02f, -1.85354128e-02f, 4.80101630e-02f, -2.07525082e-02f, -1.94892548e-02f, 7.07318867e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.33965635e-01f, -8.37613404e-01f, -6.99293971e-01f, 2.96336621e-01f, 7.09782660e-01f, 4.30952013e-01f, 1.09271929e-01f, 7.68925026e-02f, 5.09918705e-02f, -1.67964473e-01f,
  2.27173150e-01f, -2.10709840e-01f, -4.27645952e-01f, 4.27030474e-01f, 4.75865513e-01f, -6.07342243e-01f, 3.45034540e-01f, 1.13103271e-01f, -1.95891783e-01f, -6.71570236e-03f,
  1.57745585e-01f, 5.89416444e-01f, -1.71038479e-01f, 9.13871974e-02f, 2.94908613e-01f, -2.14740500e-01f, 1.07274584e-01f, -3.40286225e-01f, 2.82460213e-01f, 2.80014604e-01f,
  7.60193020e-02f, -5.62928896e-03f, 1.73399076e-02f, -1.54182583e-01f, 7.55499257e-03f, -3.27733997e-03f, -4.76057753e-02f, 3.32377814e-02f, 9.85050127e-02f, -8.15694034e-02f,
  -5.98349944e-02f, 6.56735227e-02f, 4.06707637e-02f, -6.07149452e-02f, 6.04458191e-02f, 6.55982271e-02f, 1.88777763e-02f, -4.74923775e-02f, 1.64175779e-02f, 3.78285558e-03f,
  -1.20044105e-01f, -4.90952507e-02f, 2.41063181e-02f, -2.52215005e-02f, -8.72171000e-02f, 5.61706051e-02f, -1.40624121e-02f, -3.89074981e-02f, -6.08226508e-02f, 9.61240977e-02f,
  3.58076282e-02f, 9.52291861e-03f, -1.45300594e-03f, 6.01311177e-02f, 4.67866845e-02f, 6.42360076e-02f, 5.93793765e-02f, 5.36937080e-02f, -8.02833587e-02f, 9.55185480e-03f,
  4.03925367e-02f, 4.44686674e-02f, 2.65020654e-02f, 1.01386279e-01f, 5.79302460e-02f, 9.36745405e-02f, 2.99365819e-02f, 1.39011323e-01f, -9.32868123e-02f, 4.41529509e-03f,
  -8.34315047e-02f, 8.53261426e-02f, 5.87131642e-03f, 1.44643839e-02f, -2.07633972e-02f, 1.25645637e-03f, 1.21563792e-01f, -5.23847193e-02f, -4.21261266e-02f, -1.46773010e-01f,
  -5.14737070e-02f, -3.27615887e-01f, -1.61407039e-01f, 1.36624172e-01f, -1.52646437e-01f, 1.35935679e-01f, -1.32229537e-01f, 5.12442030e-02f, -1.41219124e-01f, -7.72996321e-02f,
  9.03160647e-02f, -8.83046631e-03f, -2.72261780e-02f, 1.13230579e-01f, -3.01956777e-02f, -3.99730541e-02f, -7.89511725e-02f, 1.49399536e-02f, 1.12639420e-01f, 3.12749967e-02f,
  -2.37313136e-02f, 7.96495192e-03f, -5.14790304e-02f, 7.29133561e-02f, 5.05927131e-02f, -3.83840241e-02f, 5.49347363e-02f, -5.25233485e-02f, -6.48417994e-02f, -4.87063490e-02f,
  -7.82010853e-01f, 7.04842091e-01f, -2.74643898e-01f, 5.32195330e-01f, -3.14839095e-01f, 6.72415376e-01f, 7.07998455e-01f, 2.21689925e-01f, 4.44029778e-01f, 6.59419298e-01f,
  2.39607885e-01f, 7.36129358e-02f, 3.00172955e-01f, 6.09633207e-01f, 3.67704816e-02f, 3.03962082e-01f, 3.23957473e-01f, 2.50621706e-01f, -1.01287514e-01f, 2.58778632e-02f,
  -1.18601106e-01f, 3.31496984e-01f, -1.90112770e-01f, -1.76308781e-01f, -8.04208070e-02f, -3.36857140e-01f, 2.71860603e-02f, -2.82424420e-01f, 1.20281599e-01f, 1.74705926e-02f,
  1.97358150e-02f, -1.63617104e-01f, -3.08591276e-01f, -2.18819212e-02f, -7.93097094e-02f, -7.76644424e-02f, -6.57167062e-02f, -8.61276761e-02f, -1.90444529e-01f, -1.95993762e-02f,
  8.21811259e-02f, -1.02805339e-01f, 6.16120957e-02f, -4.54356596e-02f, -5.50787617e-03f, -1.11372061e-01f, -7.74602070e-02f, 8.54680687e-02f, 1.05761737e-01f, -4.94055524e-02f,
  -7.64441043e-02f, -2.06946135e-02f, 4.09010984e-02f, 7.71036670e-02f, -1.43892169e-01f, 5.62445894e-02f, 1.43737614e-01f, -6.77681267e-02f, 1.42148007e-02f, -3.93570699e-02f,
  -9.31548104e-02f, 6.90697283e-02f, -6.50428310e-02f, 2.36869343e-02f, 3.62944454e-02f, -6.60538152e-02f, 5.65140098e-02f, -4.08801027e-02f, -7.62373880e-02f, -4.64466065e-02f,
  8.14699680e-02f, -4.37840000e-02f, -2.96521708e-02f, 1.33921187e-02f, 1.28250360e-01f, 5.93580417e-02f, -4.52543683e-02f, -2.00926866e-02f, 1.37057915e-01f, 7.59713948e-02f,
  3.06051914e-02f, -1.79584175e-02f, 3.13000716e-02f, 1.20970368e-01f, 6.12719469e-02f, 4.48953100e-02f, 5.55172749e-02f, -1.48162991e-02f, 1.91578001e-03f, -6.48657009e-02f,
  5.08345485e-01f, 2.87790179e-01f, 1.10078670e-01f, -1.87817067e-02f, 5.56153897e-03f, -7.26455599e-02f, -2.45632343e-02f, 4.97684740e-02f, 9.00001228e-02f, -5.35802618e-02f,
  6.02566730e-03f, 9.16125998e-03f, -2.63676681e-02f, 2.26721056e-02f, 4.67854589e-02f, 1.96447030e-01f, 9.05669704e-02f, 2.54199244e-02f, 8.78341570e-02f, -6.57169819e-02f,
  -8.20362289e-03f, -4.14674506e-02f, -4.35840245e-03f, -1.88031998e-02f, -2.31430996e-02f, 6.27216399e-02f, -3.88023667e-02f, -9.81169194e-02f, -1.08370468e-01f, 3.73055451e-02f,
  6.30560935e-01f, 1.44196898e-01f, 5.50130069e-01f, 9.49298441e-01f, -3.14796567e-01f, -7.58750558e-01f, -3.57905030e-01f, 9.82483923e-02f, 1.78922072e-01f, -3.33159029e-01f,
  -1.09564140e-01f, 3.18507880e-01f, -3.36212754e-01f, 4.08538789e-01f, 3.51990968e-01f, -3.90168428e-01f, 4.74840611e-01f, -1.06910385e-01f, -1.34768279e-03f, 3.34764868e-01f,
  2.33900070e-01f, -4.94768061e-02f, 5.53806126e-01f, 1.97977442e-02f, 2.90763974e-01f, 4.33975428e-01f, 4.14564341e-01f, -1.14537492e-01f, 4.52140361e-01f, -8.95372778e-02f,
  -1.55649632e-01f, 4.34959531e-02f, 1.60269037e-01f, -2.07507256e-02f, 1.25098675e-01f, -1.58659548e-01f, -8.90062656e-03f, -1.21172860e-04f, -4.67615426e-02f, 3.69435772e-02f,
  -1.23569995e-01f, 4.65468802e-02f, 1.45267949e-01f, 5.03903488e-03f, 1.99282002e-02f, 1.41565517e-01f, 5.62316142e-02f, -2.33509727e-02f, 4.88077588e-02f, 4.09076503e-03f,
  1.67533606e-01f, 6.35228008e-02f, -2.03209054e-02f, -1.12199765e-02f, 1.07476627e-02f, 9.09164101e-02f, -8.13380033e-02f, 1.71367660e-01f, -4.07692567e-02f, 3.54562774e-02f,
  2.26886682e-02f, -1.69790730e-01f, -1.08320445e-01f, 5.85861765e-02f, -3.72098833e-02f, -2.80766226e-02f, 1.21502606e-02f, -8.00955072e-02f, -3.93135734e-02f, -1.67811438e-02f,
  7.92856663e-02f, 5.87033704e-02f, 2.07123570e-02f, -7.63960183e-02f, -8.53811502e-02f, -7.66695514e-02f, 6.27365010e-03f, -1.06997795e-01f, -2.55040005e-02f, 3.71949770e-03f,
  2.75203325e-02f, -2.66591404e-02f, 1.04083912e-02f, 1.10621806e-02f, 1.66546069e-02f, 2.21089460e-03f, 1.24922454e-01f, -5.28672757e-03f, -1.68331712e-02f, -5.64290956e-02f,
  6.52500466e-02f, 2.36640334e-01f, -5.38837574e-02f, -1.16505332e-01f, -4.59311120e-02f, -1.11160710e-01f, 1.11628726e-01f, 1.03050649e-01f, 1.65463924e-01f, -8.22134838e-02f,
  -4.31952178e-02f, 3.06686549e-03f, -2.00196460e-01f, 6.96687102e-02f, 5.93614206e-02f, -3.13533433e-02f, 5.01041338e-02f, 2.30178423e-02f, 1.77238375e-01f, 1.68957993e-01f,
  7.07971901e-02f, -2.15917930e-01f, 1.42479632e-02f, -5.16883433e-02f, -6.49480447e-02f, -1.83603559e-02f, -6.52962178e-02f, -1.97413191e-02f, 1.46863833e-01f, 6.55084625e-02f,
  -8.08227062e-01f, 7.72641182e-01f, 2.63392597e-01f, -5.52670836e-01f, 2.26593748e-01f, -1.36528134e-01f, -2.04735383e-01f, 2.71608710e-01f, -1.71654433e-01f, 1.92120805e-01f,
  -3.56762350e-01f, 1.27315596e-01f, 1.78209618e-02f, -3.99587780e-01f, -1.09973288e+00f, -5.39666295e-01f, -6.91372514e-01f, -3.49383771e-01f, -2.06151605e-01f, -5.66117726e-02f,
  -3.41095924e-01f, -5.33610106e-01f, -1.30007729e-01f, 2.05575392e-01f, 2.33291164e-01f, 3.40089023e-01f, -3.24377000e-01f, 5.01794517e-01f, -1.07483026e-02f, -2.05080241e-01f,
  -5.60133047e-02f, -2.78950408e-02f, 9.92765650e-02f, 2.16819271e-02f, 8.85840785e-03f, 1.50161535e-01f, -6.90199137e-02f, -9.40312520e-02f, -4.64249663e-02f, 4.55518998e-02f,
  -1.18519962e-02f, 1.46864746e-02f, -1.77549288e-01f, 1.40811414e-01f, 1.63784236e-01f, 1.91827655e-01f, 6.52273521e-02f, 4.80616912e-02f, 1.84962198e-01f, 1.52204439e-01f,
  2.18493804e-01f, 1.50571659e-01f, 7.16212252e-03f, -3.77280898e-02f, -6.32254109e-02f, 3.23928855e-02f, -1.09581411e-01f, 8.33723880e-03f, 1.18008733e-01f, -9.81577039e-02f,
  -5.32170534e-02f, -4.92791235e-02f, 1.97465736e-02f, 1.28340721e-01f, -1.13554083e-01f, 5.90107404e-02f, -4.23225984e-02f, -7.74039254e-02f, 6.17182329e-02f, 4.70528975e-02f,
  -1.28524065e-01f, 4.37457934e-02f, -4.92134839e-02f, -3.79697382e-02f, -9.03813094e-02f, -4.84516285e-02f, -2.62529794e-02f, -1.95969958e-02f, 1.47006018e-02f, 5.24884351e-02f,
  -6.06149361e-02f, -1.48650795e-01f, 5.70352003e-02f, 7.95331597e-02f, 2.29274482e-02f, 5.57110161e-02f, -6.12879498e-03f, 1.25698268e-01f, 3.25798094e-02f, -4.61246297e-02f,
  -2.72716254e-01f, -3.93999368e-01f, -4.56533618e-02f, -4.53899652e-02f, -1.36393085e-01f, -5.16854413e-02f, -1.25718206e-01f, 8.58060047e-02f, -1.19767062e-01f, -1.26769572e-01f,
  1.70524523e-01f, -4.51901890e-02f, -2.56523006e-02f, -3.12815011e-02f, -9.94123295e-02f, -1.91927612e-01f, -1.30068630e-01f, -7.46723190e-02f, -6.89853430e-02f, 9.95676033e-03f,
  1.16445772e-01f, -3.25528992e-04f, 7.46890232e-02f, 7.80232474e-02f, -9.16104950e-03f, 9.47806686e-02f, 4.75826524e-02f, 7.61661306e-02f, -7.99593851e-02f, -1.10204726e-01f,
  3.53556335e-01f, -6.94948852e-01f, -2.74231941e-01f, -4.36490715e-01f, -4.64809835e-02f, -2.54364371e-01f, -9.80822742e-03f, -6.88722193e-01f, -5.83381057e-01f, -3.54122669e-01f,
  -4.19684350e-02f, 2.29628354e-01f, 2.75291234e-01f, -6.00064874e-01f, 8.52458179e-01f, 2.21467048e-01f, -4.12320614e-01f, -4.49472293e-02f, -5.73739260e-02f, -2.62585908e-01f,
  2.38590334e-02f, -4.80576843e-01f, 1.62284151e-01f, -4.04145658e-01f, -2.16568723e-01f, -1.27151519e-01f, 4.06348974e-01f, 2.52125204e-01f, -2.67666131e-01f, 6.22014552e-02f,
  -2.62863692e-02f, -1.52972728e-01f, -1.94614261e-01f, 6.14448227e-02f, -8.63218606e-02f, 5.80995493e-02f, 1.51703686e-01f, 3.73983741e-01f, 1.67623721e-02f, 4.77979556e-02f,
  1.65151983e-01f, -1.45659456e-02f, -2.86538720e-01f, 6.31591454e-02f, 3.52134034e-02f, -1.58253685e-01f, -5.53654917e-02f, -8.87395069e-02f, -8.87192860e-02f, 1.80167496e-01f,
  -7.16547966e-02f, 2.16727192e-03f, -9.52940732e-02f, -6.63720071e-02f, 1.91111751e-02f, -6.64984062e-02f, 1.41639978e-01f, 1.88029990e-01f, 3.96041535e-02f, -1.42747864e-01f,
  6.78974837e-02f, 1.31461143e-01f, -3.45034152e-02f, -7.08801895e-02f, -4.22797948e-02f, -8.31938088e-02f, -6.65922277e-03f, 1.36204571e-01f, 2.03478690e-02f, 9.11997352e-03f,
  -1.98789060e-01f, -5.48515934e-03f, -1.16835162e-01f, 4.46909070e-02f, 2.39193551e-02f, -7.73070231e-02f, 2.49058723e-01f, 6.11966699e-02f, -9.29752216e-02f, -2.08107103e-02f,
  -7.93395191e-03f, 3.69414035e-03f, -1.96970589e-02f, 1.74322650e-02f, -9.27769095e-02f, 1.07087240e-01f, -7.84840807e-02f, -4.12893966e-02f, 1.83778745e-03f, 1.34647518e-01f,
  -1.20820187e-01f, -2.62156308e-01f, -1.81057170e-01f, -8.26503858e-02f, -9.04778168e-02f, -7.29142427e-02f, 1.55802947e-02f, -1.39805421e-01f, 6.09095208e-02f, -1.58187926e-01f,
  -6.34575933e-02f, 1.03015639e-01f, 9.35255736e-02f, -3.60228382e-02f, -1.27730118e-02f, -1.36167973e-01f, 6.35750517e-02f, 3.16754729e-02f, 1.97677556e-02f, -1.74973719e-02f,
  4.15324159e-02f, 6.02496937e-02f, 9.31443796e-02f, -7.40277097e-02f, -9.97551717e-03f, 1.22997440e-01f, -9.51504111e-02f, 3.24687064e-02f, 3.67154740e-02f, -9.12039578e-02f,
  4.07941699e-01f, 2.02668756e-01f, 8.62670615e-02f, 2.80421972e-01f, -3.02850068e-01f, -2.46997476e-01f, -4.03200686e-01f, -8.09845626e-02f, 6.86948955e-01f, 1.86101630e-01f,
  -4.83928859e-01f, 7.15171516e-01f, -2.74812609e-01f, -1.61218584e-01f, -2.53762335e-01f, 5.51681034e-02f, -1.21272057e-01f, 2.12859675e-01f, 1.87364474e-01f, -9.64836180e-02f,
  9.73355025e-02f, -5.44086397e-01f, -5.19685268e-01f, -6.03337705e-01f, -2.04436153e-01f, 1.59756616e-01f, -3.83263290e-01f, -3.79669577e-01f, -1.82827234e-01f, -2.08828092e-01f,
  -1.26362264e-01f, 2.84945399e-01f, -3.73206325e-02f, 1.18853979e-01f, -4.66654859e-02f, -1.23862140e-01f, -1.84158087e-02f, -1.32661298e-01f, 4.13557515e-02f, 9.10801217e-02f,
  1.42975807e-01f, -2.76536737e-02f, 7.76785985e-02f, -3.92140895e-02f, -3.54324169e-02f, -4.14340496e-02f, 9.17369276e-02f, 5.86752929e-02f, 5.70304915e-02f, -7.88464919e-02f,
  -1.90946385e-02f, 1.01044632e-01f, -5.06091528e-02f, 1.44725159e-01f, 2.47180331e-02f, -4.66508605e-03f, 5.64246736e-02f, -5.48460633e-02f, 5.26037514e-02f, 1.59214273e-01f,
  1.79329515e-02f, -9.20638442e-02f, -9.36113819e-02f, -9.76500213e-02f, -6.16271310e-02f, 8.92323032e-02f, 1.03304600e-02f, -3.82605866e-02f, 9.94537920e-02f, -1.06234290e-01f,
  -6.96812123e-02f, 9.74028138e-04f, -9.37396809e-02f, 6.24345653e-02f, 4.74622548e-02f, 1.24804705e-01f, 4.63555194e-03f, 1.26535565e-01f, 1.46872010e-02f, 9.26496759e-02f,
  -6.04598261e-02f, 2.21361853e-02f, -5.46449237e-02f, -2.82713911e-03f, -1.02021977e-01f, -1.59538705e-02f, 1.34959351e-02f, 8.23512375e-02f, 1.63855182e-03f, -1.66194618e-01f,
  3.31058837e-02f, 1.08163029e-01f, -5.04600676e-03f, 1.98799279e-02f, 1.17787413e-01f, 9.84231383e-02f, 6.14822051e-03f, 1.42342523e-01f, 6.05106838e-02f, -1.35404944e-01f,
  -1.25053376e-01f, 6.32093325e-02f, 2.72912569e-02f, 2.59100907e-02f, -5.42370277e-03f, -2.67637800e-02f, 4.49940674e-02f, 1.36454612e-01f, -5.61161079e-02f, 1.06779197e-02f,
  -3.78177278e-02f, -6.43523037e-02f, 3.82584706e-02f, -8.48771185e-02f, -2.00750423e-03f, -6.65914193e-02f, 1.37903243e-01f, 9.30276066e-02f, -1.46502778e-01f, -4.52209339e-02f,
  6.38639927e-01f, -4.34606880e-01f, 1.76710397e-01f, 2.38279760e-01f, 3.29865873e-01f, -3.88060287e-02f, 3.16807717e-01f, -2.05231886e-02f, 5.37042201e-01f, -4.40507859e-01f,
  -1.99251682e-01f, -4.64347824e-02f, -1.26094446e-01f, -4.88543302e-01f, 5.91425598e-01f, 8.91164169e-02f, -4.45351303e-02f, -2.68784225e-01f, 1.25681564e-01f, -2.64769852e-01f,
  9.97398645e-02f, -3.46109569e-01f, -4.62961979e-02f, -6.86253965e-01f, -2.49699995e-01f, -2.03704417e-01f, -2.31760234e-01f, -8.08410719e-02f, -4.60279405e-01f, -1.52795762e-02f,
  -5.43899499e-02f, 2.05136016e-02f, -2.88372412e-02f, -1.42160766e-02f, 8.24238583e-02f, 5.39989248e-02f, -9.02147293e-02f, -1.08818196e-01f, 1.03144281e-01f, 5.59400208e-02f,
  -5.65675721e-02f, 4.83373962e-02f, -6.21573068e-02f, -1.16127217e-02f, 1.39634520e-01f, -1.29672587e-02f, 9.61627886e-02f, -1.68588441e-02f, 2.60139033e-02f, 6.65055029e-03f,
  1.84952676e-01f, 8.36360753e-02f, 1.24819256e-01f, -7.31181800e-02f, -2.09669936e-02f, 2.29970254e-02f, 2.76733525e-02f, -1.74010918e-02f, 1.28469050e-01f, 9.73958522e-02f,
  -1.30521297e-01f, 5.16541153e-02f, -9.25850123e-03f, -5.33523373e-02f, -3.22484709e-02f, 8.10693670e-03f, 2.69620996e-02f, -1.02592088e-01f, 3.39087546e-02f, 7.30140954e-02f,
  1.48634957e-02f, 1.70414895e-02f, 1.13978863e-01f, 3.14477645e-02f, -2.55154110e-02f, -5.70264971e-03f, -5.06546758e-02f, 1.82188917e-02f, 3.36114317e-02f, 1.86861962e-01f,
  7.25699514e-02f, 1.41325332e-02f, -6.73324913e-02f, 9.03251842e-02f, -3.02077159e-02f, 1.75465699e-02f, -1.74231336e-01f, -1.87013913e-02f, 5.58124632e-02f, -3.44603881e-02f,
  1.01658046e-01f, -3.91482532e-01f, -5.54361790e-02f, -8.90626013e-02f, -9.75077376e-02f, -9.00118649e-02f, -6.24017715e-02f, -6.96539879e-03f, -3.25024091e-02f, -6.55428916e-02f,
  -1.30064517e-01f, -1.10216863e-01f, 6.55695274e-02f, -4.20575179e-02f, -1.00716121e-01f, 4.41834740e-02f, -3.68164591e-02f, -2.44462818e-01f, 3.17972936e-02f, -9.84544381e-02f,
  -5.25078550e-02f, -3.26243341e-02f, 2.48584338e-02f, 7.93130621e-02f, -9.41227376e-02f, 9.40842554e-02f, -5.32519771e-03f, -3.00414283e-02f, 2.13379897e-02f, -7.30401427e-02f,
  -4.79105040e-02f, 8.90881047e-02f, -3.50615740e-01f, 2.07324356e-01f, -4.61730510e-01f, -1.77801549e-01f, -2.55538225e-01f, -1.54205576e-01f, -5.89659333e-01f, 3.15255016e-01f,
  3.32663149e-01f, -5.82217336e-01f, 1.92125976e-01f, 5.58261991e-01f, -2.78080553e-01f, 4.78089541e-01f, 5.57462275e-01f, 2.56533712e-01f, -5.60580343e-02f, 1.46519259e-01f,
  2.42851570e-01f, 5.31072915e-01f, 2.80451655e-01f, 2.54945517e-01f, 2.54623801e-01f, 2.88980436e-02f, 1.66998044e-01f, -2.48810068e-01f, 3.39183778e-01f, -1.48786828e-01f,
  1.55485913e-01f, 1.86850443e-01f, 6.81736274e-03f, -9.03140679e-02f, 1.04806110e-01f, 1.24713592e-01f, -1.04637012e-01f, -2.06906766e-01f, -1.05752580e-01f, 6.65197382e-03f,
  -7.72503987e-02f, -1.82734188e-02f, 7.63945952e-02f, -6.26907423e-02f, -1.00981832e-01f, -1.06666967e-01f, -1.00007825e-01f, -1.42016903e-01f, -3.01875081e-02f, 1.48334861e-01f,
  -6.96815550e-02f, 1.55932099e-01f, 1.05308406e-01f, 1.05441757e-01f, -8.46878141e-02f, 6.76156059e-02f, 3.01712286e-02f, -8.38009566e-02f, -1.47080896e-02f, 1.01605114e-02f,
  7.51333311e-02f, -6.52555004e-02f, 3.89569364e-02f, -4.10198867e-02f, -2.38048639e-02f, 1.78917050e-01f, -4.52664308e-03f, 4.54605091e-03f, -1.93204787e-02f, 1.54774636e-01f,
  -8.96850526e-02f, -2.52642967e-02f, 7.20930323e-02f, -2.61989273e-02f, 1.23673141e-01f, -2.43469160e-02f, 9.22827572e-02f, 1.11197084e-01f, -5.21540605e-02f, -1.08783439e-01f,
  2.71487590e-02f, -5.77132888e-02f, -3.61465998e-02f, 1.62652940e-01f, -1.91425029e-02f, -2.50380725e-01f, 1.71888918e-01f, 2.11377181e-02f, -4.20352668e-02f, -1.55567586e-01f,
  1.42082393e-01f, 8.63950104e-02f, -2.19593626e-02f, -1.48942426e-01f, -9.93374619e-04f, -5.20620570e-02f, -6.17521740e-02f, -1.73030905e-02f, 1.11254089e-01f, -4.97280136e-02f,
  7.05961417e-03f, -2.59428751e-02f, 8.88859183e-02f, -1.31819036e-03f, -3.43719237e-02f, 1.31419912e-01f, 1.48036852e-01f, -1.05614580e-01f, -2.57758773e-03f, 1.48040354e-01f,
  1.46690533e-02f, 2.71988381e-02f, -5.26307076e-02f, -3.52878757e-02f, 7.66629577e-02f, 7.13931248e-02f, -1.14429325e-01f, -1.18942343e-01f, 1.01901032e-01f, 7.97388926e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.24579310e-01f, 1.87823564e-01f, 7.71110237e-01f, 1.24742496e+00f, 4.83590007e-01f, 8.93677771e-01f, 5.67065477e-01f, 4.15964276e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.22665662e-01f, -5.32555044e-01f, 3.82233799e-01f, -3.18216652e-01f, 6.14723921e-01f, 3.50804627e-01f, 6.76579475e-01f, 4.00047094e-01f, -3.21139425e-01f, 2.72151738e-01f,
  2.85165042e-01f, -1.58412933e-01f, -4.72771749e-03f, -2.64915526e-01f, 1.51574790e-01f, 1.17100716e-01f, -4.03667688e-01f, -2.66255178e-02f, 6.25708222e-01f, -3.48551661e-01f,
  5.80515750e-02f, 6.90792143e-01f, 3.67939889e-01f, 4.54178415e-02f, -2.74322242e-01f, 3.94493192e-01f, -1.42653763e-01f, -6.93762824e-02f, 3.49229664e-01f, -2.89396718e-02f,
  2.84870826e-02f, 2.61931539e-01f, -5.23250461e-01f, 3.23975921e-01f, 3.65078777e-01f, -8.77838373e-01f, -4.02222723e-01f, 1.85974807e-01f, -2.72971749e-01f, 3.50131750e-01f,
  3.42100233e-01f, -1.74606070e-01f, -1.47326097e-01f, 1.15930341e-01f, -3.54469478e-01f, 1.81568682e-01f, -2.83303648e-01f, -3.82057279e-02f, -4.29629445e-01f, 2.20765680e-01f,
  6.06393456e-01f, -5.02061546e-01f, -1.55288413e-01f, 6.08017027e-01f, 3.37846845e-01f, 5.44074513e-02f, -2.47889176e-01f, 1.44226953e-01f, -1.96374893e-01f, 3.72397676e-02f,
  3.26601058e-01f, 2.92023599e-01f, -7.51108453e-02f, 9.05252025e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.31823277e-01f, 6.44570813e-02f, 2.27558240e-01f, 7.78628945e-01f, -1.27112031e+00f, -8.03435266e-01f, -1.03407562e+00f, -6.30140305e-01f, 8.61103535e-02f, 1.19558072e+00f,
  9.00638461e-01f, -2.09905654e-02f, 3.93164009e-02f, 1.07298911e+00f, 3.12205404e-01f, 6.91878378e-01f, 7.58000851e-01f, 5.97976565e-01f, -6.52086198e-01f, 8.33060682e-01f,
  2.15868786e-01f, -6.71884060e-01f, -6.57439172e-01f, -2.97770739e-01f, 1.31656790e+00f, -1.78149745e-01f, -2.45270744e-01f, 8.39168322e-04f, 1.14384401e+00f, -5.75835854e-02f,
  9.70782936e-01f, -6.64668530e-02f, 6.05095446e-01f, -3.01628858e-01f, 1.25307903e-01f, -1.39120668e-01f, 1.03944831e-01f, 3.17387819e-01f, -8.28699112e-01f, 4.91722554e-01f,
  6.37259722e-01f, 5.47709346e-01f, 6.34979129e-01f, -2.04603210e-01f, 8.55634212e-01f, -1.00725353e+00f, -2.43200585e-01f, 8.80252838e-01f, 1.01211655e+00f, 3.68376434e-01f,
  6.82865202e-01f, 7.73790538e-01f, 1.07689846e+00f, 8.96647513e-01f, 1.08909392e+00f, -6.26430869e-01f, -8.90523314e-01f, 8.05155396e-01f, -5.97886503e-01f, 5.32274961e-01f,
  -2.37530351e-01f, 2.17198338e-02f, -1.56111106e-01f, 7.18630254e-01f, 6.35831356e-01f, 1.72139481e-01f, -1.30528316e-01f, 1.37619686e+00f, 1.44106403e-01f, -6.00201011e-01f,
  7.92097628e-01f, -4.97753441e-01f, 8.28184336e-02f, -7.85171926e-01f, -2.82437056e-01f, 7.93317139e-01f, 1.31567180e-01f, 4.27432805e-01f, 7.03920186e-01f, 4.82803658e-02f,
  2.67850339e-01f, 9.95616615e-01f, 6.10855877e-01f, 1.33152962e+00f, -9.74763155e-01f, 7.66506433e-01f, 1.40059662e+00f, 6.46455586e-01f, -4.18262780e-01f, -5.14986925e-02f,
  1.00094533e+00f, 5.81296086e-02f, 4.87001717e-01f, 9.77531910e-01f, 9.13881719e-01f, -4.49777126e-01f, 5.29618025e-01f, 4.31100726e-02f, -1.26824141e-01f, 9.74276140e-02f,
  -1.44728482e-01f, -8.44071805e-01f, 3.93169463e-01f, 8.49502683e-01f, 9.61503804e-01f, -8.08209002e-01f, 1.05078328e+00f, 9.36173368e-03f, -8.73546898e-01f, 2.66422153e-01f,
  7.64822721e-01f, -4.37160581e-01f, 5.44602692e-01f, 7.01376677e-01f, 3.59089494e-01f, -5.25764644e-01f, 1.39396465e+00f, -2.39702687e-02f, -4.80710179e-01f, -6.64825082e-01f,
  3.67031097e-01f, -8.79031956e-01f, 6.59102917e-01f, 1.59130263e+00f, 1.74235720e-02f, 8.84881437e-01f, -6.19257510e-01f, 3.79770920e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.25612032e-01f, 6.84496760e-01f, 3.77435714e-01f, 6.08984590e-01f, 4.13864523e-01f, 4.19379026e-01f, 2.42913440e-02f, 8.31525087e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -3.61932665e-01f, -5.89006484e-01f, -2.06408530e-01f, -1.17901154e-01f, 7.80823290e-01f, 1.29626766e-02f, -5.25951922e-01f, 4.60986257e-01f, 2.91843325e-01f, -9.25871015e-01f,
  3.67273271e-01f, 1.05775189e+00f, -9.78541136e-01f, -1.05215156e+00f, -2.03823939e-01f, -6.07809126e-01f, 3.55780780e-01f, 2.21443802e-01f, 2.69387156e-01f, 4.52490807e-01f,
  -5.67173958e-01f, 5.29661596e-01f, 2.92246789e-01f, -3.60286891e-01f, 5.05269766e-01f, 4.53203499e-01f, 9.08454537e-01f, -6.53675616e-01f, -5.40602565e-01f, -1.04536998e+00f,
  -8.84282053e-01f, -1.15231824e+00f, 3.54946107e-02f, -2.03539267e-01f, -1.44198179e-01f, -3.70583236e-01f, 4.23724353e-02f, -3.30794513e-01f, 8.09332252e-01f, -1.14094749e-01f,
  -6.36623204e-01f, 3.67069781e-01f, 4.65982050e-01f, -4.87812847e-01f, -9.61056530e-01f, -6.82039201e-01f, 7.30662346e-01f, 4.56564546e-01f, 4.00447994e-01f, 5.31827629e-01f,
  -4.67347950e-01f, -3.88326824e-01f, -4.04306114e-01f, 4.91707534e-01f, 1.27604258e+00f, 1.04183829e+00f, -6.95382595e-01f, -1.40675700e+00f, -6.63150489e-01f, 3.41809958e-01f,
  -2.18710825e-01f, -1.04622436e+00f, -4.25438315e-01f, 1.05590987e+00f, 6.45848751e-01f, 4.59180862e-01f, 9.49243605e-02f, 4.77171957e-01f, 8.18014979e-01f, 5.34312010e-01f,
  -1.22532356e+00f, 2.92260736e-01f, -1.05353975e+00f, -3.43521595e-01f, -1.82047844e-01f, 1.05837750e+00f, 5.33969283e-01f, 2.41855711e-01f, -6.69050395e-01f, -1.34632647e-01f,
  3.56684029e-01f, 1.56003773e-01f, 5.90906024e-01f, -4.88377772e-02f, -1.29835710e-01f, 6.70389116e-01f, 1.23945378e-01f, 7.33597398e-01f, 5.87743580e-01f, -5.45487881e-01f,
  -7.68680871e-01f, 2.18972310e-01f, -6.23429716e-01f, 1.02137530e+00f, -5.07575154e-01f, -1.50979543e+00f, 2.16157824e-01f, 6.32482767e-02f, 3.33548754e-01f, -1.07705399e-01f,
  1.03231356e-01f, -9.21267152e-01f, -1.20604172e-01f, -7.68756628e-01f, -1.88650131e-01f, 2.90316135e-01f, -9.90487039e-01f, -8.84621799e-01f, 5.08097708e-01f, 1.99724119e-02f,
  1.11434317e+00f, -7.76542962e-01f, -2.56799936e-01f, -6.67906523e-01f, -6.39377236e-01f, -6.99093521e-01f, -5.16947210e-01f, 9.81734022e-02f, -9.51906815e-02f, -3.69094938e-01f,
  2.13724375e-01f, 4.72175032e-01f, -6.01544559e-01f, -7.71180868e-01f, 3.96953106e-01f, 3.04539323e-01f, -1.00463903e+00f, -2.01766595e-01f, -5.59942901e-01f, 2.85704732e-01f,
  -3.99998605e-01f, -6.04069233e-01f, 6.90446377e-01f, -4.59620982e-01f, -7.07413793e-01f, -4.67299730e-01f, 4.39116418e-01f, -1.07485712e+00f, 4.51853722e-01f, -4.62690830e-01f,
  -5.68649650e-01f, -3.65858413e-02f, 3.02573681e-01f, 4.04422954e-02f, 6.08613528e-02f, 2.64779001e-01f, -3.56053799e-01f, 3.25920522e-01f, 7.92302847e-01f, 8.57856393e-01f,
  -4.89476323e-01f, 7.93013334e-01f, -1.45327735e+00f, 7.33320773e-01f, 3.55281979e-01f, -6.78936541e-01f, 2.49823797e-02f, 6.75320983e-01f, -2.21523881e-01f, -1.32300985e+00f,
  -7.10303903e-01f, -1.56357229e-01f, 6.20149672e-01f, 4.65647668e-01f, -7.60215580e-01f, -1.10964906e+00f, -4.87771869e-01f, -1.13392496e+00f, -2.06782013e-01f, 6.42863929e-01f,
  -2.62716353e-01f, -3.48556638e-02f, 4.07463610e-01f, -1.46356678e+00f, -6.02305770e-01f, 5.83399057e-01f, -5.47652721e-01f, 3.76115777e-02f, 1.59000754e-01f, -3.12527180e-01f,
  -4.88512248e-01f, -3.53029102e-01f, 8.13567400e-01f, 4.82106775e-01f, -8.38029310e-02f, -1.16043949e+00f, -7.07988083e-01f, -5.54584026e-01f, 4.01048571e-01f, 5.95003307e-01f,
  2.89978608e-02f, 3.31382304e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.39655764e-03f, -1.72719136e-02f, -3.08138371e-01f, 1.19739242e-01f, 3.80437881e-01f, 8.84359032e-02f, -1.69556484e-01f, -3.34249705e-01f, -2.59209156e-01f, 3.03945869e-01f,
  2.99913824e-01f, -3.63273829e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    