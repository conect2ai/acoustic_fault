/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.02195019e-01f, -1.93654418e-01f, 1.08931698e-01f, -3.99519205e-01f, 5.13341799e-02f, -2.18801156e-01f, -2.16184020e-01f, -7.08965287e-02f, 1.37858680e-02f, -1.95488676e-01f,
  -9.87116098e-02f, -1.76056307e-02f, 1.29591197e-01f, -3.81347299e-01f, -8.24977010e-02f, -5.58101805e-03f, -3.52563590e-01f, -1.35897875e-01f, 5.01945429e-02f, -1.11085586e-01f,
  5.69662116e-02f, -3.80378276e-01f, -6.33910447e-02f, -8.43717754e-02f, -3.58638801e-02f, 6.99413270e-02f, 5.78808933e-02f, 4.69032042e-02f, -2.32467055e-01f, 9.61561594e-03f,
  6.38965294e-02f, 6.76048175e-02f, -1.14012118e-02f, 8.76088291e-02f, -3.63892666e-03f, 7.32343718e-02f, -1.82462879e-03f, 1.44944219e-02f, 3.37399915e-02f, 5.50489537e-02f,
  2.11430062e-02f, 2.31085252e-02f, 3.53617482e-02f, 1.10749053e-02f, 2.63970811e-02f, 1.00551192e-02f, 2.70443503e-02f, 1.47474585e-02f, 1.17605189e-02f, -2.81292591e-02f,
  2.13143341e-02f, -3.53145041e-02f, -8.45030919e-02f, 2.47038323e-02f, 9.36429799e-02f, 1.87987462e-02f, 1.98066235e-02f, 1.62445717e-02f, 2.73222588e-02f, -4.05719168e-02f,
  5.50726545e-04f, 4.30449732e-02f, 8.92474130e-02f, -1.70478504e-02f, 5.56664765e-02f, 7.72533985e-03f, -9.46346112e-03f, -2.15179920e-02f, 1.39687462e-02f, -2.96845268e-02f,
  -7.20393062e-02f, 2.57548001e-02f, 5.52691892e-02f, -2.63680257e-02f, -1.84507016e-02f, 1.12363156e-02f, 5.80481850e-02f, -2.18078867e-02f, -4.86130826e-02f, -6.63725138e-02f,
  -4.71141608e-03f, 6.15312112e-03f, -2.53440104e-02f, -2.88322605e-02f, -1.90464593e-02f, -2.05805171e-02f, 1.21189756e-02f, -3.91253009e-02f, -2.79052593e-02f, 4.05542441e-02f,
  -1.17075495e-01f, -9.79099870e-02f, -2.88837273e-02f, 4.51842584e-02f, -1.20554872e-01f, 3.77273411e-02f, -1.99800096e-02f, 6.47186115e-02f, 2.02255603e-03f, 1.23956501e-02f,
  3.33426632e-02f, -4.37318757e-02f, 6.47952557e-02f, -1.67188179e-02f, -1.19480945e-01f, 1.33067043e-02f, 2.53864005e-02f, 9.61161405e-02f, -1.15045771e-01f, -1.88246258e-02f,
  -7.18434006e-02f, -7.09050894e-03f, 5.95983071e-03f, -3.23509309e-03f, -5.39691634e-02f, -3.72346006e-02f, -3.95946875e-02f, 6.91561028e-03f, -2.24784669e-02f, 2.15469934e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.39435658e-01f, 1.25272378e-01f, -6.56385347e-02f, 4.81836647e-01f, -8.70250463e-02f, -7.03646094e-02f, -4.01241124e-01f, 1.20341673e-01f, -2.52342433e-01f, -1.43424675e-01f,
  2.10820679e-02f, 3.62297557e-02f, -2.51908273e-01f, 5.96343696e-01f, 2.07475349e-01f, -2.12614879e-01f, 3.53770912e-01f, 2.22897723e-01f, -3.55808102e-02f, 2.13946909e-01f,
  2.62295961e-01f, 5.26257038e-01f, 2.67340958e-01f, 3.65038723e-01f, 1.97568089e-01f, 1.71075195e-01f, 2.79035062e-01f, 2.95061842e-02f, 4.84332532e-01f, 2.67838657e-01f,
  2.65076547e-03f, 5.20746447e-02f, 5.19526331e-03f, 1.21276423e-01f, -1.67834796e-02f, -4.78151925e-02f, 4.10751030e-02f, 2.91110650e-02f, -2.27756929e-02f, -7.87709951e-02f,
  -4.18021008e-02f, 5.15896231e-02f, 1.33678809e-01f, -1.09976411e-01f, 3.78266834e-02f, 2.31609810e-02f, -6.61590397e-02f, 3.27637270e-02f, -6.82240203e-02f, -1.31088365e-02f,
  -8.39013904e-02f, 6.41753599e-02f, 9.33886506e-03f, 6.00822754e-02f, 5.06132981e-03f, -3.23849916e-02f, -9.59145930e-03f, -1.18774146e-01f, 1.08230608e-02f, -6.27514720e-02f,
  4.97264639e-02f, -6.34586290e-02f, -1.35958204e-02f, 6.25212118e-02f, 5.77201806e-02f, -2.84820944e-02f, 8.12636316e-02f, -1.73224416e-02f, -2.83796918e-02f, -4.00955342e-02f,
  1.00866549e-01f, -1.48543227e-03f, 5.25131114e-02f, 2.81429198e-02f, -5.69869578e-02f, -1.28778452e-02f, -4.11196463e-02f, 1.00037105e-01f, 2.54597589e-02f, -3.56999561e-02f,
  -3.39166224e-02f, 1.17183747e-02f, -9.32749286e-02f, 6.60624653e-02f, 1.46020904e-01f, -1.18252881e-01f, 1.44164994e-01f, 1.92599662e-03f, -4.35435027e-02f, 4.72467430e-02f,
  1.48715273e-01f, -5.49424179e-02f, -1.44905835e-01f, 1.07659213e-01f, -1.10061225e-02f, -6.36797175e-02f, 7.46424496e-02f, 5.62877059e-02f, 7.71235302e-02f, -3.01119238e-02f,
  5.10152206e-02f, 5.07904403e-02f, -6.22610264e-02f, 7.11765140e-02f, 3.12849469e-02f, 7.99511448e-02f, -1.11015039e-02f, 2.88538523e-02f, 1.25294260e-03f, 1.09280705e-01f,
  -5.98348044e-02f, -1.53878734e-01f, 7.55746197e-03f, -1.25806704e-01f, 3.44015695e-02f, -6.37708604e-02f, -7.50946030e-02f, -2.10991446e-02f, -1.46194110e-02f, 1.38692008e-02f,
  -7.32074618e-01f, 2.90128171e-01f, -2.14308631e-02f, -3.81357193e-01f, -2.29920462e-01f, 1.34643197e-01f, -2.05628455e-01f, 1.45266233e-02f, -1.49270996e-01f, 4.73393686e-02f,
  -7.46698529e-02f, -1.89577833e-01f, 3.15612525e-01f, -5.59598766e-02f, 2.35944524e-01f, 3.93793076e-01f, -1.57003826e-03f, -9.09547508e-03f, 1.07360132e-01f, -3.04619014e-01f,
  1.10936910e-02f, -2.09108755e-01f, 2.17803061e-01f, -1.19609661e-01f, -3.53615552e-01f, -1.82411224e-01f, -1.42484322e-01f, -1.71662539e-01f, -1.06383100e-01f, -8.64516124e-02f,
  -1.32274777e-01f, -3.20777774e-01f, -5.46378605e-02f, 1.22056052e-01f, 1.91629063e-02f, -1.18099101e-01f, -4.16245647e-02f, -6.74746782e-02f, -9.70097408e-02f, -1.02440519e-02f,
  -1.58773805e-03f, 1.67393927e-02f, -6.95589781e-02f, 6.21889485e-03f, 1.27559975e-01f, 4.57076728e-02f, 1.63659468e-01f, -8.17438215e-03f, 1.21679142e-01f, 1.95743382e-01f,
  1.63415879e-01f, 1.93570942e-01f, -5.81228249e-02f, 3.94012071e-02f, 2.94831824e-02f, -4.45390940e-02f, -4.86723566e-03f, -6.24809600e-02f, 1.81698985e-02f, -1.72065552e-02f,
  -2.16134876e-01f, -5.49402125e-02f, -3.27974893e-02f, -6.28377497e-02f, -1.81706138e-02f, -1.00587480e-01f, -6.53909892e-03f, 8.71232748e-02f, -1.05712563e-01f, 1.85663067e-02f,
  1.07225023e-01f, 5.36359064e-02f, 1.95613578e-02f, -1.53252138e-02f, -2.22436059e-02f, -9.49206203e-02f, 3.92748266e-02f, 6.91969246e-02f, 1.05276056e-01f, 1.06560975e-01f,
  -2.47264635e-02f, 8.01060274e-02f, -2.12058402e-03f, 8.99821296e-02f, -2.53767632e-02f, -7.38447905e-02f, -5.26707284e-02f, 1.33505445e-02f, 1.44191105e-02f, -8.75185337e-03f,
  -1.09683193e-01f, -2.98091829e-01f, 9.93627235e-02f, -1.39875665e-01f, -1.31448423e-02f, 1.14385270e-01f, 2.82863099e-02f, -6.43109605e-02f, 7.44963577e-03f, -9.91443172e-02f,
  -2.80426499e-02f, -3.12568322e-02f, 1.72151532e-02f, -6.79548085e-02f, -8.23342358e-04f, 1.15314052e-01f, -1.13739014e-01f, 2.56306361e-02f, -4.23720330e-02f, 3.85265425e-02f,
  2.57288236e-02f, 3.56437527e-02f, -1.30167872e-01f, -6.91811293e-02f, -5.80327734e-02f, -2.54628826e-02f, -1.34612784e-01f, 3.50397043e-02f, 6.74066767e-02f, -5.72436228e-02f,
  3.64680290e-01f, -4.89160456e-02f, 3.81586445e-03f, 7.07100928e-01f, 3.38430554e-01f, 4.52314392e-02f, 2.13475451e-01f, 4.39856082e-01f, 5.79181194e-01f, -6.11954220e-02f,
  8.67516920e-02f, -2.52863854e-01f, -4.28475469e-01f, 1.48365721e-01f, -7.90591538e-02f, -1.22976758e-01f, 1.82459965e-01f, -1.04895137e-01f, 2.27614015e-01f, -2.35875743e-03f,
  2.48431370e-01f, 4.21284974e-01f, 2.00820714e-03f, 9.99468938e-02f, 1.05218075e-01f, 2.02228785e-01f, 6.25650063e-02f, -2.34833613e-01f, 9.68924984e-02f, -1.15645519e-02f,
  -8.65497813e-02f, 1.16485141e-01f, -6.17090613e-03f, 7.67599512e-03f, 2.47163754e-02f, 4.23307903e-02f, -3.87814008e-02f, -2.33521909e-01f, -1.99353159e-03f, 7.93218333e-03f,
  -1.59896091e-01f, -3.93184200e-02f, 1.22058570e-01f, -4.11958471e-02f, 1.46382764e-01f, 6.05785921e-02f, 4.48713377e-02f, 1.36859447e-01f, 4.11990024e-02f, -8.67179185e-02f,
  4.11065780e-02f, -1.36952460e-01f, 8.21697563e-02f, 6.41394928e-02f, 7.65444264e-02f, 5.73895201e-02f, -5.66002913e-02f, 3.15212645e-02f, 8.71135946e-03f, 1.38990641e-01f,
  -2.16212636e-03f, -4.74671572e-02f, 9.03914571e-02f, -4.28130627e-02f, 4.96625118e-02f, 3.10550202e-02f, 8.04413632e-02f, -5.98359527e-03f, -5.68809658e-02f, 4.86084893e-02f,
  7.61915669e-02f, 5.40748984e-02f, 3.60100605e-02f, -1.14635251e-01f, 5.31856231e-02f, 1.65407043e-02f, 3.32806148e-02f, -8.96650832e-03f, -1.26273520e-02f, 2.49283053e-02f,
  5.14826700e-02f, 3.10067646e-02f, -1.87765777e-01f, -1.10697508e-01f, 1.67737100e-02f, 3.20266597e-02f, -5.38411401e-02f, 1.53690964e-01f, -5.13708666e-02f, 1.03447624e-01f,
  5.61891533e-02f, 2.04600275e-01f, 9.78999957e-03f, -2.11261529e-02f, -1.29393518e-01f, 6.57100901e-02f, 6.65991306e-02f, -9.13289636e-02f, 4.94076358e-03f, 7.35230967e-02f,
  7.31537938e-02f, -1.40790483e-02f, -3.81071866e-02f, -7.92822242e-02f, -6.19448572e-02f, 1.34956852e-01f, -2.63013504e-02f, 7.36105740e-02f, 1.98403522e-01f, -4.10640193e-03f,
  -1.57138094e-01f, -8.32103491e-02f, -1.54229486e-03f, 1.82090715e-01f, -6.71486855e-02f, -1.41809076e-01f, 2.97561637e-03f, 1.10037081e-01f, -7.81258792e-02f, 1.41945416e-02f,
  3.11114073e-01f, 6.19291723e-01f, 4.74270165e-01f, 5.30373275e-01f, -1.65751204e-01f, -8.10264289e-01f, -2.85430461e-01f, 2.57639438e-01f, -5.70206009e-02f, 5.42565063e-02f,
  -1.35588720e-01f, 3.58114839e-01f, -5.20721544e-03f, 9.48549882e-02f, -4.36402261e-01f, -2.20463991e-01f, -1.56703293e-01f, -1.01751946e-01f, -1.08652692e-02f, 2.17161268e-01f,
  8.52449089e-02f, -2.51289934e-01f, 3.21575582e-01f, -1.58981919e-01f, 1.67723119e-01f, 3.87204319e-01f, 3.71856652e-02f, 1.41901091e-01f, 6.20481893e-02f, -1.45191073e-01f,
  -1.97534591e-01f, 2.24042490e-01f, 1.27217069e-01f, -5.13942204e-02f, -4.26394381e-02f, -6.98063299e-02f, 2.44677160e-02f, -3.57119404e-02f, -1.32108390e-01f, 8.10204297e-02f,
  5.80443069e-02f, -1.04802214e-01f, -2.48215515e-02f, -7.81669654e-03f, 7.90359005e-02f, 2.10514292e-01f, 1.02877177e-01f, -6.91635674e-03f, 8.03842619e-02f, 9.36328545e-02f,
  1.76700860e-01f, 3.56768705e-02f, 1.01963699e-01f, 7.22332448e-02f, -3.29632545e-03f, 4.35239635e-02f, -6.09057732e-02f, 8.16313848e-02f, 8.40261281e-02f, -1.86093687e-03f,
  4.98856045e-02f, -1.17911704e-01f, 3.91907431e-02f, 9.20760930e-02f, -1.43719800e-02f, 4.76998352e-02f, -5.33000417e-02f, -7.06996247e-02f, 3.75196785e-02f, -1.02716256e-02f,
  -1.07403204e-01f, 6.68364242e-02f, -3.46477069e-02f, -5.14560863e-02f, -7.93070570e-02f, 8.73824507e-02f, -5.52008161e-03f, 9.96161923e-02f, -5.79941012e-02f, 5.93457073e-02f,
  5.67369815e-03f, -2.17369059e-03f, -7.90156238e-03f, 1.30180200e-03f, -3.96473184e-02f, 7.09421560e-02f, -3.64239467e-03f, 1.50995523e-01f, 4.13510874e-02f, -1.14897430e-01f,
  -9.54092145e-02f, 1.95139825e-01f, 1.00998245e-01f, 5.16201816e-02f, -2.79876888e-02f, -4.18404751e-02f, -3.39189917e-02f, 1.43245727e-01f, 5.57690747e-02f, -9.69623402e-02f,
  4.41921800e-02f, -3.10678277e-02f, -1.87936991e-01f, 2.92305704e-02f, -4.09875670e-03f, -7.22910389e-02f, -5.77820949e-02f, -5.23367263e-02f, 1.53454155e-01f, 9.69274864e-02f,
  -5.86912930e-02f, -1.22703038e-01f, -8.99841040e-02f, -7.50580728e-02f, -7.19743297e-02f, 4.30556796e-02f, -7.51629248e-02f, -1.32703865e-02f, 4.24617669e-03f, 1.18414988e-04f,
  5.45430005e-01f, 1.48090854e-01f, 6.06193319e-02f, 2.62029201e-01f, -1.66452155e-02f, 3.39205831e-01f, 1.69297144e-01f, 9.87114850e-03f, 5.10839224e-01f, 1.34836793e-01f,
  -1.24017783e-01f, 7.11312592e-02f, -3.38195749e-02f, 9.44937319e-02f, 1.95364520e-01f, 1.82647146e-02f, 3.63756210e-01f, 8.22498575e-02f, 4.53897528e-02f, 9.45614353e-02f,
  4.48773466e-02f, 4.76939380e-02f, -2.52172619e-01f, -1.09968774e-01f, -1.07329950e-01f, -1.17613144e-01f, -3.30137372e-01f, -1.73051715e-01f, -6.81833327e-02f, -4.77669854e-03f,
  -3.80332246e-02f, -2.26528733e-03f, -3.81439403e-02f, 5.22023924e-02f, -6.59775361e-02f, -8.72219279e-02f, -3.47649865e-02f, -4.32840884e-02f, 8.60886835e-03f, 1.07821971e-01f,
  4.36096899e-02f, 8.44298378e-02f, 2.06079111e-01f, 1.03396714e-01f, 5.72590157e-02f, 7.72356763e-02f, -4.38514464e-02f, -1.89795569e-01f, -3.34128439e-02f, -1.47758633e-01f,
  3.41903046e-02f, -7.66472146e-02f, -1.63388357e-01f, -4.72442992e-03f, 6.48510701e-04f, 1.25644207e-01f, 1.04024395e-01f, -1.82739466e-01f, -1.33279994e-01f, 1.01720922e-01f,
  -3.66853885e-02f, 9.07382648e-03f, 7.06406077e-03f, -4.23625633e-02f, -9.35653783e-03f, -7.33593553e-02f, -4.65119630e-02f, -1.36818543e-01f, 9.67005789e-02f, 2.34269444e-03f,
  4.86482009e-02f, -7.14934757e-03f, -1.93002280e-02f, 1.41803846e-01f, -4.28336598e-02f, 2.95381267e-02f, 2.97705252e-02f, 3.84472050e-02f, -9.76938829e-02f, -2.52698269e-02f,
  -1.37999535e-01f, 2.20513791e-02f, -8.58289376e-02f, 4.27915379e-02f, -3.18830088e-02f, 6.03665225e-02f, 1.74272880e-02f, -2.31463052e-02f, -5.58419935e-02f, -1.93211604e-02f,
  6.52511120e-02f, 3.01731467e-01f, -2.86769103e-02f, -7.00352788e-02f, -4.74114828e-02f, -4.65134159e-02f, 2.80837342e-02f, 9.81792063e-02f, 2.28843261e-02f, 6.95416704e-03f,
  -9.09837801e-03f, 8.58975425e-02f, -5.05510904e-02f, -1.42318215e-02f, -3.43559347e-02f, 3.75732221e-02f, 1.52654564e-02f, 3.37199047e-02f, -1.28842622e-01f, 3.71069509e-05f,
  -5.31652793e-02f, 8.35290402e-02f, 1.96891595e-02f, 4.57169376e-02f, 6.10704683e-02f, -6.98718280e-02f, 1.78425282e-01f, 3.51421870e-02f, -6.23261072e-02f, 6.06567739e-03f,
  4.02427793e-01f, 9.85310450e-02f, -1.83299601e-01f, 2.13600755e-01f, 6.06591813e-03f, -1.54380709e-01f, -3.69545817e-01f, 8.61836448e-02f, -5.43779470e-02f, -6.88069090e-02f,
  1.40869692e-01f, 1.04203261e-01f, -1.03992201e-01f, 3.58224720e-01f, 2.60397911e-01f, 1.34194061e-01f, 1.98670790e-01f, 1.00328229e-01f, 2.71045621e-02f, 2.34793887e-01f,
  2.35702455e-01f, 5.86341381e-01f, 1.87086284e-01f, 2.79040843e-01f, 1.74711034e-01f, 1.96025111e-02f, 4.07840133e-01f, -1.89822793e-01f, 2.64238328e-01f, 4.23697382e-02f,
  -3.32269371e-02f, 1.66121081e-01f, -2.12624986e-02f, -4.94370684e-02f, 1.22134596e-01f, -3.58343795e-02f, -1.18571058e-01f, 4.96473238e-02f, -9.94946063e-02f, -1.40317529e-01f,
  5.71039356e-02f, 1.61932856e-01f, 2.20520124e-02f, 6.81091249e-02f, 1.63970217e-02f, -1.55097038e-01f, -2.98405681e-02f, -1.00823462e-01f, -1.36040181e-01f, -7.70063028e-02f,
  -4.65010479e-02f, 8.74455348e-02f, 3.20681743e-02f, -5.08682281e-02f, 2.43765023e-02f, 7.69438744e-02f, -4.84392047e-02f, 1.02488240e-02f, 8.55709463e-02f, 7.27502070e-03f,
  1.04031846e-01f, 2.34875213e-02f, 8.77983570e-02f, -6.17297068e-02f, -2.67648119e-02f, 7.19148517e-02f, -9.06129703e-02f, -6.39389753e-02f, -7.20270425e-02f, 6.47865161e-02f,
  -1.27667217e-02f, -6.09594658e-02f, 4.27586064e-02f, -2.63328087e-02f, 6.05251938e-02f, 5.15780821e-02f, -6.72908053e-02f, 1.85598414e-02f, -5.83223775e-02f, -1.21324331e-01f,
  -1.69169642e-02f, 3.74632962e-02f, 4.07420844e-02f, -3.47455926e-02f, -8.31486285e-02f, 2.66885702e-02f, 1.39144391e-01f, 4.42484245e-02f, -1.47239536e-01f, 8.77676383e-02f,
  1.36265546e-01f, 3.29782605e-01f, -1.90240920e-01f, 5.90968505e-02f, -9.52324644e-02f, 3.07658240e-02f, -1.17215849e-01f, 1.48566514e-01f, -2.58595566e-03f, 1.23142295e-01f,
  -1.08716488e-02f, -5.78968450e-02f, 1.08799018e-01f, -5.09010889e-02f, -4.99504320e-02f, 7.87378773e-02f, 1.16096035e-01f, 1.58335995e-02f, -8.00457317e-03f, 7.76559934e-02f,
  5.28306849e-02f, 1.15707004e-02f, -3.85679491e-02f, -4.18067724e-02f, 4.46789293e-03f, 1.21522196e-01f, -1.16588183e-01f, -1.68283284e-03f, 1.08662702e-01f, 9.86232795e-03f,
  5.22774994e-01f, -6.11422420e-01f, 4.56698626e-01f, 4.06891942e-01f, 2.53461361e-01f, -1.52046204e-01f, 4.60665822e-01f, -8.64516944e-02f, 5.05510606e-02f, -5.20261586e-01f,
  -3.67762707e-02f, -1.02027934e-02f, -8.82004574e-02f, 5.36371209e-02f, 4.70732152e-01f, -9.31307077e-02f, -3.04839853e-02f, 3.53177749e-02f, -2.84348670e-02f, 1.43036395e-01f,
  2.40740642e-01f, 1.18806414e-01f, 2.88963795e-01f, -3.75053108e-01f, 1.12155922e-01f, -1.10401347e-01f, 5.76718338e-02f, 3.98819364e-04f, -1.13817401e-01f, 8.02182406e-02f,
  -8.43705386e-02f, 3.41890678e-02f, 1.89419687e-02f, -1.20569780e-01f, -3.59052531e-02f, -9.04746652e-02f, -2.63948888e-02f, 1.40218139e-01f, 4.59728166e-02f, -2.19898168e-02f,
  1.07237317e-01f, 3.44720967e-02f, 8.75440091e-02f, 1.08107984e-01f, -7.66929388e-02f, 3.51450182e-02f, 9.45106745e-02f, -7.25591853e-02f, 3.03901825e-02f, 1.72431067e-01f,
  1.51725933e-01f, -2.40941066e-03f, 3.36535573e-02f, -4.74378318e-02f, -3.82887907e-02f, 6.14959672e-02f, 6.63938522e-02f, 1.09415554e-01f, 1.04382843e-01f, -1.29668731e-02f,
  -8.00521672e-02f, 5.32032959e-02f, -5.34940548e-02f, -6.24333974e-03f, -1.83363054e-02f, 4.37717997e-02f, 2.13597361e-02f, 1.00044280e-01f, -7.65158311e-02f, -2.92836688e-02f,
  4.06358717e-03f, -9.49576423e-02f, 6.03714120e-03f, -1.89110525e-02f, -3.40533555e-02f, 2.10545063e-02f, 2.66410373e-02f, 1.48577045e-03f, 3.84166650e-03f, 4.30031084e-02f,
  1.74305961e-02f, -6.06075022e-03f, 9.80154276e-02f, 1.02689229e-01f, -1.08608501e-02f, 1.90463793e-02f, -4.96676527e-02f, -2.31601540e-02f, 1.13768920e-01f, -1.02993497e-03f,
  -3.69958371e-01f, -4.27597910e-01f, -5.62926605e-02f, -2.98382491e-02f, -4.24808115e-02f, 9.76851024e-03f, -5.70592992e-02f, -7.25523233e-02f, -8.62709805e-02f, -4.86316271e-02f,
  -6.43973574e-02f, 3.95679921e-02f, -1.22991592e-01f, 9.32338685e-02f, -4.54383679e-02f, -7.94357508e-02f, -2.23737136e-02f, -1.13837592e-01f, -4.95695770e-02f, -5.17073600e-03f,
  -9.27605107e-02f, 1.13595556e-02f, 9.51021686e-02f, 4.08810787e-02f, -1.63592994e-01f, 5.34119010e-02f, 3.09565477e-02f, -1.14966720e-01f, -4.25030775e-02f, -5.60991243e-02f,
  1.89366043e-01f, 6.12471513e-02f, 1.26171395e-01f, 2.20270589e-01f, -8.52396116e-02f, -2.64265716e-01f, -2.27167457e-01f, -3.41309197e-02f, -3.17139387e-01f, 2.17649154e-02f,
  -7.07890168e-02f, 1.43509299e-01f, -3.88606787e-01f, 7.66343400e-02f, -8.34570602e-02f, -5.28462052e-01f, 1.02582157e-01f, 2.43588965e-02f, -1.28696918e-01f, -4.15241569e-02f,
  -7.27070421e-02f, -1.75290853e-01f, 2.31319740e-01f, 3.25542510e-01f, -3.21975574e-02f, 3.05656195e-01f, 3.45339060e-01f, 6.28534183e-02f, 5.77846944e-01f, -4.82886545e-02f,
  -7.84880742e-02f, -2.70978272e-01f, 1.05554059e-01f, 3.18782404e-02f, -3.25063318e-02f, 3.26356776e-02f, 1.42711308e-02f, -5.36822788e-02f, 7.68169016e-02f, 2.35233251e-02f,
  -1.06826246e-01f, 8.27639326e-02f, 1.94701236e-02f, -1.80760361e-02f, -4.84720431e-03f, 7.87322447e-02f, 4.17296961e-02f, 6.84311390e-02f, -1.14334270e-01f, -4.24905941e-02f,
  3.44645642e-02f, 1.42032623e-01f, -1.09476214e-02f, 1.62747145e-01f, 6.40627742e-02f, 7.53288493e-02f, -2.84193400e-02f, 1.18638672e-01f, 5.88329397e-02f, 9.62198451e-02f,
  -1.55058473e-01f, 4.46035713e-02f, -1.87972635e-02f, 8.77411515e-02f, -5.25973700e-02f, -3.52480784e-02f, -3.38875577e-02f, -4.69790697e-02f, -2.73237079e-02f, -3.82804908e-02f,
  1.13788970e-01f, 5.13379499e-02f, -1.19890295e-01f, 1.36592150e-01f, -4.85652573e-02f, -7.19016865e-02f, 2.52389107e-02f, 1.97142601e-01f, 1.10886030e-01f, 1.06920294e-01f,
  -2.30632536e-02f, -2.51436513e-02f, 1.88818753e-01f, -5.93051035e-03f, -9.32752490e-02f, 4.96988855e-02f, 8.70372504e-02f, -5.54711968e-02f, -1.04810104e-01f, -1.02927394e-01f,
  -6.56418428e-02f, -5.30559383e-02f, 4.67390008e-02f, 1.08736753e-01f, -1.12211585e-01f, -4.48777340e-02f, -2.21282512e-01f, 9.99822244e-02f, -3.41328271e-02f, -1.40740722e-01f,
  6.69889897e-02f, 1.57141238e-01f, -6.08437285e-02f, 8.77939388e-02f, 1.00343205e-01f, -1.08497649e-01f, 2.61953846e-03f, 1.48500428e-02f, 3.32268476e-02f, 2.17882358e-02f,
  4.18529548e-02f, -7.86186680e-02f, -4.68104854e-02f, 3.54481563e-02f, 3.91562236e-03f, 1.66206613e-01f, -2.75657550e-02f, 4.76443358e-02f, -6.31744564e-02f, -5.07916212e-02f,
  5.35564363e-01f, 2.39842966e-01f, 3.36773485e-01f, 3.81349236e-01f, -5.34787066e-02f, -5.91983050e-02f, 6.29600137e-02f, 9.91190225e-02f, 5.73046625e-01f, -6.65962249e-02f,
  -1.45947367e-01f, 1.31088927e-01f, -9.60327014e-02f, 3.38246003e-02f, -1.63083389e-01f, -1.43118069e-01f, 1.42755076e-01f, -3.74683104e-02f, 1.02130301e-01f, 4.73380983e-02f,
  1.27379015e-01f, -1.98301271e-01f, -3.26008648e-02f, -1.33093178e-01f, 3.17531303e-02f, 9.04544368e-02f, -3.64602506e-01f, -9.90548804e-02f, -3.25165272e-01f, -8.08194727e-02f,
  5.42895645e-02f, -2.95003597e-02f, 4.68262332e-03f, 7.00102523e-02f, -6.93190396e-02f, -1.29630312e-01f, -1.72094226e-01f, -1.31325930e-01f, 1.37786373e-01f, -2.78537963e-02f,
  -4.89601120e-03f, -4.31999713e-02f, -3.14197093e-02f, -1.28476739e-01f, 3.08568887e-02f, 6.98070228e-02f, 1.03838578e-01f, 1.10505577e-02f, 1.07672654e-01f, 1.50734857e-02f,
  3.99567746e-02f, 1.14176825e-01f, 1.19841889e-01f, 3.67451459e-02f, 2.39735600e-02f, 3.26000415e-02f, -1.50115103e-01f, -6.06849184e-03f, 2.71853376e-02f, -1.32049769e-02f,
  -2.47337781e-02f, -1.01658985e-01f, -1.16553150e-01f, -2.97343060e-02f, 4.56152949e-03f, 2.55906545e-02f, 3.47270854e-02f, -1.69291943e-01f, 7.00298175e-02f, 9.11636278e-03f,
  -3.58995162e-02f, -1.15153566e-02f, 5.75603619e-02f, 2.91178133e-02f, 4.12894003e-02f, -4.36516367e-02f, 1.11479191e-02f, -6.45554587e-02f, 1.43621668e-01f, 6.88438714e-02f,
  -1.59583569e-01f, -5.13609983e-02f, -2.42976868e-03f, 5.91658652e-02f, 5.27552217e-02f, 1.42312482e-01f, -4.47542705e-02f, 1.18045025e-02f, -1.89753938e-02f, -1.81354865e-01f,
  5.06126210e-02f, -5.78771457e-02f, 6.28913492e-02f, -5.94783872e-02f, 5.87209165e-02f, -3.78216878e-02f, -2.80534960e-02f, 1.07362472e-01f, 7.38510415e-02f, -1.46622047e-01f,
  4.84988280e-02f, -7.29795545e-02f, -5.95927015e-02f, 3.29763908e-03f, 1.19202137e-01f, -7.23925382e-02f, -3.71794812e-02f, 1.62072703e-02f, 6.91370070e-02f, 4.19669077e-02f,
  3.95020135e-02f, -8.03870112e-02f, 9.82863232e-02f, 6.13815896e-02f, 4.28464152e-02f, -8.28441381e-02f, 3.67440060e-02f, 2.86838170e-02f, -7.50640333e-02f, 6.86271638e-02f,
  -1.03381801e+00f, 1.97666302e-01f, -3.49914432e-01f, 1.92321017e-01f, -1.53131038e-01f, -2.41585523e-01f, 2.33541206e-01f, -7.26163713e-03f, 9.43771750e-02f, 3.77710342e-01f,
  1.95234463e-01f, -3.44413035e-02f, 2.02460453e-01f, 4.14818466e-01f, -6.66584969e-01f, 2.58803964e-01f, -1.01583719e-01f, 1.15138531e-01f, 2.23901384e-02f, -2.12982491e-01f,
  -2.14192733e-01f, 1.91830248e-01f, -8.00688788e-02f, 5.31937368e-02f, -8.09500813e-02f, -1.73698038e-01f, 5.37692942e-02f, -2.40132846e-02f, 1.34969177e-02f, -6.83154687e-02f,
  -1.97055787e-01f, 1.11659534e-01f, 3.49716693e-02f, -5.47082201e-02f, -1.49262324e-01f, -1.16600111e-01f, -7.68788382e-02f, 1.19151898e-01f, -5.47333471e-02f, -3.73062305e-02f,
  -1.55609492e-02f, 3.78042795e-02f, 1.00110337e-01f, 7.80498842e-03f, -9.04893577e-02f, -2.03320123e-02f, 4.18620892e-02f, 1.92375749e-03f, 3.97706255e-02f, -9.05179605e-02f,
  5.24775824e-03f, -4.42629233e-02f, -9.51200128e-02f, 9.46830399e-03f, -3.36130001e-02f, 1.30815715e-01f, -3.86338755e-02f, -6.43056333e-02f, -1.61735162e-01f, 7.56598497e-03f,
  -3.59401703e-02f, -8.86655301e-02f, 4.22419682e-02f, -4.83611645e-03f, -4.13271934e-02f, 2.21791156e-02f, 7.80779449e-03f, 5.72584644e-02f, 3.53007764e-02f, -2.21435912e-03f,
  -7.24693313e-02f, -1.73269995e-02f, 3.10535580e-02f, -5.47437370e-02f, -5.50026670e-02f, 6.70710653e-02f, 6.26599882e-03f, 2.21916493e-02f, -3.75043973e-02f, -1.93815473e-02f,
  5.74449189e-02f, -1.75392311e-02f, -7.00678211e-03f, 3.22966836e-02f, -2.94408761e-02f, 6.02005981e-02f, -1.03412252e-02f, 1.65973920e-02f, 9.34883021e-03f, -1.15129553e-01f,
  -4.06607181e-01f, -3.18997055e-01f, 1.33973673e-01f, 1.39345333e-03f, 5.63655496e-02f, -3.34482677e-02f, 2.87698465e-03f, -6.01935275e-02f, 7.32340813e-02f, 7.56372809e-02f,
  -1.40450627e-01f, 6.04292825e-02f, -2.51487587e-02f, 9.25380215e-02f, -3.58568765e-02f, 7.97135085e-02f, 3.10219619e-02f, 6.74254671e-02f, -7.36178383e-02f, -1.06420077e-01f,
  -6.14854172e-02f, -3.36660892e-02f, -3.34849693e-02f, 1.03368275e-01f, -6.07663430e-02f, 4.29608151e-02f, -1.29193738e-01f, -2.11222805e-02f, -3.39923427e-02f, -2.19209827e-02f,
  -6.29970968e-01f, 1.25142887e-01f, -2.44839415e-01f, -3.46327364e-01f, 1.97338965e-02f, -2.82576889e-01f, -1.58075616e-02f, 1.05407804e-01f, -1.50270090e-01f, 4.39075887e-01f,
  2.02732176e-01f, -2.12986544e-01f, 2.10616037e-01f, -2.82909751e-01f, -6.61686480e-01f, -3.46107662e-01f, -3.81317198e-01f, -8.92809704e-02f, -8.79463255e-02f, 2.29487903e-02f,
  -1.86284572e-01f, -3.23295370e-02f, -1.54532254e-01f, 3.91658366e-01f, 1.07611120e-01f, 2.78808326e-01f, 3.10721308e-01f, 2.23787382e-01f, 8.39950144e-02f, -1.66568115e-01f,
  -1.09577022e-01f, 1.27287626e-01f, 6.61315769e-02f, -5.84068485e-02f, 4.78103310e-02f, 5.96916899e-02f, -8.60062800e-03f, 3.25952992e-02f, -3.15116346e-02f, -1.39021948e-01f,
  2.93141510e-02f, -3.44663858e-02f, -1.33000657e-01f, 1.57922693e-03f, -2.56112628e-02f, 9.79350507e-03f, -2.35336311e-02f, 2.24036667e-02f, 3.77955623e-02f, -4.07791091e-03f,
  -1.19159572e-01f, 8.52953196e-02f, 1.74995803e-03f, 3.29026952e-02f, 1.50307054e-02f, 1.52603969e-01f, -1.26424000e-01f, 1.02640994e-01f, 9.83463749e-02f, -5.34667335e-02f,
  -8.00416693e-02f, 4.84537072e-02f, -3.08378525e-02f, 3.40290926e-02f, 6.36778474e-02f, -2.66779959e-03f, -8.64027441e-02f, 1.63132455e-02f, -6.81877732e-02f, 2.41025928e-02f,
  1.09626912e-01f, -5.56547381e-02f, 4.70000580e-02f, -7.01221675e-02f, 4.97384146e-02f, -3.44544053e-02f, 2.08248310e-02f, 1.43815847e-02f, 6.18470795e-02f, -6.92127496e-02f,
  9.63807702e-02f, -6.40665963e-02f, 1.90737806e-02f, 3.77684794e-02f, 7.15349317e-02f, -3.12905312e-02f, 8.47956613e-02f, -1.18017262e-02f, -5.98551147e-02f, -5.71065908e-03f,
  4.81808446e-02f, 2.58787006e-01f, -2.15297658e-02f, -2.44814046e-02f, 8.40772912e-02f, 2.92876847e-02f, -1.25571012e-01f, -9.17724818e-02f, -8.50908235e-02f, -8.84537771e-02f,
  1.72415599e-01f, 8.21971670e-02f, 1.50081933e-01f, -1.62610970e-02f, 1.04847923e-01f, -8.97440985e-02f, 2.11686995e-02f, 5.41041791e-03f, 1.10199742e-01f, 9.93729755e-02f,
  1.36270851e-01f, 7.39673451e-02f, 7.89379701e-02f, 1.11123383e-01f, 1.21425427e-01f, 1.45621091e-01f, 7.41038471e-02f, 9.59400311e-02f, 5.52572682e-02f, 1.63837940e-01f,
  -4.44148123e-01f, 3.80044766e-02f, -1.41665135e-02f, -5.96874893e-01f, 9.73798037e-02f, -5.31111896e-01f, -5.68697155e-01f, 1.63040143e-02f, 7.20208511e-02f, -1.16383776e-01f,
  -1.77748889e-01f, -4.21800837e-02f, 2.58740783e-01f, -6.18742466e-01f, -5.30933701e-02f, 2.85702646e-02f, -5.42215824e-01f, -2.36873880e-01f, 1.69935629e-01f, -1.83501914e-01f,
  -2.53260508e-02f, -2.17263117e-01f, -2.08210647e-01f, 2.17062294e-01f, -3.26429963e-01f, 2.07506001e-01f, 2.25167245e-01f, 2.24313587e-01f, -1.86783299e-01f, -1.00710960e-02f,
  -5.00164807e-01f, -3.07579517e-01f, -1.53523430e-01f, 4.13846485e-02f, -1.20245405e-01f, -2.52035493e-03f, -3.11178472e-02f, -1.62239000e-01f, 5.75199239e-02f, -1.87471792e-01f,
  -3.62734459e-02f, 6.34519532e-02f, -7.26063848e-02f, 8.66835639e-02f, -1.71277008e-03f, 4.94478606e-02f, -3.44338268e-02f, -1.33748919e-01f, 4.58720587e-02f, 5.00690863e-02f,
  5.81828542e-02f, -4.15570103e-02f, -1.52316824e-01f, 1.07932061e-01f, 8.91290307e-02f, -1.39398977e-01f, -8.73956531e-02f, 5.25265299e-02f, -6.49677515e-02f, -3.57496031e-02f,
  -2.20469721e-02f, 1.05121039e-01f, -9.92696509e-02f, 1.26765892e-02f, -3.90250720e-02f, 5.79252467e-02f, -4.03898442e-03f, -4.06108163e-02f, 3.35748568e-02f, -8.28086957e-02f,
  -7.04767033e-02f, -4.08529118e-02f, 4.99572195e-02f, -6.18302077e-02f, -7.93328211e-02f, -5.79557456e-02f, -7.88860768e-02f, -3.05776275e-03f, 1.10132538e-01f, 7.26391524e-02f,
  -5.79313822e-02f, -7.05763400e-02f, 1.16182610e-01f, 4.89002094e-02f, 3.60697880e-02f, 6.90227672e-02f, 4.06686589e-02f, -1.20510355e-01f, 4.30990905e-02f, -1.01265628e-02f,
  -1.54387757e-01f, -1.71589121e-01f, -3.49571444e-02f, -1.22949360e-02f, -8.96655843e-02f, -1.35886455e-02f, -5.59686571e-02f, -1.12239785e-01f, -6.04493208e-02f, -3.60180922e-02f,
  -5.29608540e-02f, -2.88273860e-02f, -8.83000940e-02f, -3.80489193e-02f, 5.39687648e-02f, -4.76107933e-03f, -9.08786952e-02f, -1.41244486e-01f, -1.16859704e-01f, 3.86350118e-02f,
  4.65793274e-02f, 3.46166752e-02f, 2.88748089e-02f, -2.41090655e-02f, -1.94837153e-02f, -1.22008093e-01f, 4.14495617e-02f, 6.52730688e-02f, -5.79514280e-02f, -5.73704951e-02f,
  4.84672636e-01f, 3.49874318e-01f, 2.00620398e-01f, 3.85560334e-01f, -5.07207140e-02f, -3.00145540e-02f, 9.32543799e-02f, -5.28188199e-02f, 4.38596755e-01f, 1.96999133e-01f,
  -2.87138373e-01f, 5.17417192e-01f, -6.00043423e-02f, 2.01036066e-01f, -2.89238930e-01f, -8.36302266e-02f, 2.00216681e-01f, 1.84188217e-01f, 1.58184111e-01f, 2.15005025e-01f,
  1.56886116e-01f, -2.24277064e-01f, -2.79902488e-01f, -2.85087794e-01f, -4.83304262e-02f, -5.90652274e-03f, -3.93294901e-01f, -1.14302799e-01f, -2.17399508e-01f, -1.70148656e-01f,
  1.10664982e-02f, 7.28076473e-02f, 6.47464171e-02f, 2.42872611e-02f, 7.06987754e-02f, -6.86968416e-02f, -1.35381281e-01f, -1.85716256e-01f, 9.26565975e-02f, 5.86741567e-02f,
  1.36306509e-01f, -7.90305063e-02f, 1.06148601e-01f, 1.74198858e-02f, 9.57315043e-03f, 8.07648897e-02f, 1.36571020e-01f, -1.97105464e-02f, 5.68566881e-02f, 1.59580514e-01f,
  -1.27521763e-02f, -1.03969499e-02f, -4.43452150e-02f, 6.23059198e-02f, -1.56469680e-02f, 7.43556470e-02f, 1.51772454e-01f, 2.53878012e-02f, -6.23873211e-02f, 6.85682967e-02f,
  1.13181673e-01f, 6.82761148e-02f, -9.55116674e-02f, -1.08661875e-01f, -1.08494423e-01f, 1.97748225e-02f, -3.47652729e-03f, -4.40023355e-02f, -5.45564741e-02f, 2.57586762e-02f,
  -5.34052774e-02f, 3.84539403e-02f, 3.97688337e-02f, 6.87098727e-02f, 1.69382483e-01f, -2.12573409e-02f, 2.73720808e-02f, -7.56953433e-02f, 8.15770030e-02f, 6.87185600e-02f,
  8.34820606e-03f, -2.01997720e-02f, -1.51937947e-01f, -3.94699611e-02f, 4.64377142e-02f, -2.90280394e-02f, 2.46031769e-03f, 1.35345208e-02f, 3.84600125e-02f, 7.06036165e-02f,
  5.24033532e-02f, 2.46152222e-01f, 9.33074504e-02f, 1.47837415e-01f, 1.88246518e-01f, -7.76950419e-02f, 9.96434689e-02f, 1.53989717e-01f, 1.78916578e-03f, -5.08980229e-02f,
  2.05645375e-02f, 3.50986011e-02f, -1.52969668e-02f, -7.54923671e-02f, -7.76160182e-03f, -5.25776818e-02f, 1.25191972e-01f, 6.52627647e-02f, 2.79892720e-02f, -6.25597462e-02f,
  1.30668597e-03f, 4.58858982e-02f, 1.55978739e-01f, -1.67925768e-02f, 8.76552686e-02f, -2.38291305e-02f, 5.73452823e-02f, 3.73375341e-02f, -3.18191685e-02f, 1.13110475e-01f,
  5.60263515e-01f, 2.74958104e-01f, 3.01039100e-01f, 6.95828676e-01f, -2.01083317e-01f, -1.79397136e-01f, -5.80631346e-02f, 2.61232406e-01f, 3.17373782e-01f, -7.86712915e-02f,
  3.61363888e-02f, 1.08705573e-01f, -7.71126151e-02f, -3.12539153e-02f, -1.08951665e-01f, -1.69493273e-01f, 7.17654154e-02f, 4.88098674e-02f, 2.16391459e-01f, 1.21894382e-01f,
  1.03929214e-01f, -1.53956130e-01f, 1.51984245e-01f, -4.23018038e-02f, 1.81943640e-01f, 2.50959992e-01f, 8.59032795e-02f, -4.39461358e-02f, -1.58871919e-01f, -3.04829478e-01f,
  -2.72875786e-01f, 9.20689628e-02f, -3.12559791e-02f, -1.67875495e-02f, -2.45185718e-02f, -1.49580389e-01f, -2.95411739e-02f, -2.42930457e-01f, -9.75591615e-02f, 5.73306009e-02f,
  3.19883041e-02f, 6.33398145e-02f, -2.21585855e-02f, -3.05352695e-02f, -7.07735717e-02f, 1.52019739e-01f, 1.13380879e-01f, 8.56823474e-02f, 3.19205858e-02f, 1.45134171e-02f,
  1.69142373e-02f, 9.05890949e-03f, 2.73457207e-02f, -2.35456064e-01f, 5.15032001e-02f, 3.18071470e-02f, -8.99271748e-04f, -1.56764373e-01f, 1.58945560e-01f, 6.28677476e-03f,
  1.58658735e-02f, -4.04529013e-02f, 1.45465642e-01f, 1.48652107e-01f, 1.25110313e-01f, 5.86885065e-02f, 1.26190752e-01f, 1.14391781e-01f, -5.24949506e-02f, -7.86489770e-02f,
  8.09248313e-02f, 1.11043282e-01f, 5.44348843e-02f, -3.81119624e-02f, -4.83398698e-02f, 1.20855488e-01f, -5.17581105e-02f, 6.61453679e-02f, 2.62345304e-03f, 1.16169184e-01f,
  -7.84623101e-02f, 1.88801885e-02f, 8.23602546e-03f, 6.35023862e-02f, -7.47935399e-02f, -5.42902015e-02f, 1.08465003e-02f, 1.09335400e-01f, -7.89747387e-03f, -2.16077417e-02f,
  -7.07667768e-02f, 2.13257492e-01f, -1.24355383e-01f, -1.92678452e-01f, -5.84497303e-02f, 2.02453439e-03f, 2.09214222e-02f, -1.40269369e-01f, 1.80619638e-02f, 7.04216659e-02f,
  -8.68165046e-02f, -1.17160622e-02f, 4.43136059e-02f, -1.63070649e-01f, -1.77978516e-01f, 5.59115298e-02f, -4.84630764e-02f, 4.45518605e-02f, -1.44690439e-01f, 1.84752401e-02f,
  1.13020912e-01f, -9.35662165e-02f, -1.32393703e-01f, -5.17833680e-02f, -8.06286037e-02f, -2.17018887e-01f, 8.95970687e-02f, 4.70751673e-02f, -7.39588141e-02f, 2.05586795e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.32611927e-02f, 3.25592875e-01f, 1.62454933e-01f, 1.47974387e-01f, 2.29818627e-01f, 1.86347887e-01f, 1.40543520e-01f, 2.04622939e-01f, 8.49549025e-02f, 1.63845673e-01f,
  2.63208210e-01f, 5.02013505e-01f, -2.43389886e-02f, 5.01013435e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  6.70545697e-01f, 2.13736117e-01f, 3.75141390e-02f, 5.41714579e-02f, -2.15094119e-01f, -1.41049519e-01f, 2.56341964e-01f, -4.84191030e-01f, 3.74596089e-01f, 3.11377525e-01f,
  1.90134630e-01f, -7.68382251e-02f, 2.05987897e-02f, -3.47561866e-01f, 2.35416636e-01f, -7.63135254e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -6.17164493e-01f, -3.72445464e-01f, 1.56182721e-01f, 3.01454365e-01f, 1.51830032e-01f, 3.45244408e-01f, 1.28827095e-01f, 4.11954224e-01f, -3.21571290e-01f, -3.13604712e-01f,
  -2.91498870e-01f, 4.83710140e-01f, 4.40716892e-02f, 5.44721484e-01f, -2.03264266e-01f, 2.40042478e-01f, 4.30324286e-01f, 3.11816424e-01f, 1.57262132e-01f, 5.74907601e-01f,
  -4.69990522e-01f, 2.04960838e-01f, -4.61495131e-01f, -1.66212693e-02f, 1.98086724e-01f, -4.23073173e-01f, -1.20262355e-01f, 5.89205384e-01f, 1.85651407e-01f, 3.08591992e-01f,
  -4.48730052e-01f, -3.80869776e-01f, 7.28169024e-01f, 3.16168725e-01f, -1.82261765e-01f, -8.78281519e-02f, -4.40281898e-01f, -1.66653663e-01f, -2.59792328e-01f, -1.93710566e-01f,
  5.22181511e-01f, 1.01079784e-01f, 5.57560623e-02f, -7.65135000e-03f, 5.73835611e-01f, 2.65013605e-01f, -3.09641451e-01f, -4.16091621e-01f, 5.85530758e-01f, 3.00085247e-01f,
  2.30350599e-01f, 1.94777563e-01f, 2.51157254e-01f, 2.70411998e-01f, 2.78594822e-01f, -2.84920812e-01f, 9.45464253e-01f, 5.91541767e-01f, 3.94009173e-01f, 1.93636473e-02f,
  3.95432524e-02f, -2.84397602e-01f, 2.95710474e-01f, 9.42576155e-02f, -5.75297892e-01f, -6.73203468e-01f, 7.85972714e-01f, 1.48171678e-01f, 1.95464969e-01f, 2.05950160e-02f,
  1.84320863e-02f, 5.76175869e-01f, -8.66213068e-02f, 3.15496415e-01f, -5.38132489e-01f, 2.36650556e-01f, -3.15899462e-01f, -5.38159907e-01f, -3.97271127e-01f, -1.14952125e-01f,
  5.42181492e-01f, 2.73126870e-01f, -7.36306682e-02f, -1.75824612e-01f, -8.95181447e-02f, 6.67849854e-02f, -8.80387947e-02f, -2.98070222e-01f, 4.42595422e-01f, -2.45059356e-01f,
  4.27514762e-02f, 4.44319189e-01f, 6.45249069e-01f, 2.39707708e-01f, -3.16268861e-01f, -4.32193220e-01f, 4.37216535e-02f, 6.07113503e-02f, 4.83683288e-01f, -1.99876979e-01f,
  3.55270356e-02f, 6.67102158e-01f, -1.94504321e-01f, 1.62089810e-01f, 3.18574198e-02f, 4.43608880e-01f, 2.84868836e-01f, -2.45710373e-01f, -2.75850445e-01f, -3.04037184e-01f,
  -1.15207933e-01f, 4.29416090e-01f, 1.61235273e-01f, 2.84343302e-01f, -5.37955463e-01f, -4.22753215e-01f, 4.62343311e-03f, -5.40756285e-02f, -3.65002722e-01f, -6.33233786e-02f,
  -5.18254042e-01f, 3.50465417e-01f, -7.10737780e-02f, 3.08552325e-01f, 8.08468044e-01f, 3.39331150e-01f, -8.62761512e-02f, 3.02150417e-02f, 1.03653483e-01f, -5.33878570e-03f,
  -1.90635905e-01f, 3.32854778e-01f, -6.45421863e-01f, 1.10537577e-02f, -3.40540439e-01f, 1.30049855e-01f, 1.77906632e-01f, 8.18710104e-02f, -3.25920552e-01f, -1.88813627e-01f,
  4.64954287e-01f, 8.42007399e-01f, -3.29081714e-01f, -2.97187090e-01f, 7.77434587e-01f, 2.52471983e-01f, -3.05460274e-01f, -1.33871809e-01f, 4.78489339e-01f, 5.14627695e-01f,
  2.62068003e-01f, 1.22640152e-02f, 7.01232493e-01f, 2.68641636e-02f, 4.07213569e-01f, -2.75385410e-01f, 1.41115263e-01f, 9.37528312e-02f, 3.00550759e-01f, 5.09602189e-01f,
  -3.07561398e-01f, -4.46104646e-01f, -5.48583567e-02f, 3.13175738e-01f, 2.91286081e-01f, 2.29997486e-01f, -2.44351432e-01f, -4.89904881e-01f, -3.69725116e-02f, -6.19195700e-01f,
  -2.30294392e-01f, 6.95482790e-01f, 2.89181858e-01f, -2.14342475e-01f, -3.42989653e-01f, -4.32226330e-01f, -6.75945505e-02f, 4.40553576e-02f, 1.78413406e-01f, -9.59242359e-02f,
  -2.66029596e-01f, 7.24624515e-01f, 1.31293133e-01f, 7.24464133e-02f, -3.08855981e-01f, 2.82049894e-01f, 5.71648069e-02f, 5.09764850e-01f, 7.90688470e-02f, -1.52823552e-01f,
  7.30688214e-01f, 3.80259812e-01f, -2.26051882e-01f, -5.44739306e-01f, 1.73367545e-01f, 4.33078825e-01f, 5.29654443e-01f, -1.59280196e-01f, 7.79004991e-01f, 6.11312091e-01f,
  -1.69746593e-01f, 6.41422346e-02f, 3.01725000e-01f, -1.85941029e-02f, -3.16991448e-01f, 2.88262039e-01f, 4.48013753e-01f, 1.91657141e-01f, 1.60269290e-01f, 1.63710415e-02f,
  4.83211249e-01f, -3.26435566e-01f, 2.45910153e-01f, 6.06740952e-01f, -2.86350071e-01f, 3.17814082e-01f, 2.34556809e-01f, 4.32580650e-01f, 4.19270217e-01f, -2.92885959e-01f,
  -1.87298432e-01f, -1.80527836e-01f, 1.04306869e-01f, 6.24716878e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.15368086e-01f, 7.56653428e-01f, 4.58222479e-01f, 4.67600852e-01f, -3.23867123e-03f, 2.34335914e-01f, -5.72859123e-02f, -5.48804812e-02f, 6.35565996e-01f, 6.44855917e-01f,
  7.88974017e-02f, 3.25717479e-02f, 8.60196948e-01f, -8.29964355e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.58521670e-01f, -1.16159156e-01f, 2.44879827e-01f, -3.78560185e-01f, -3.05847853e-01f, -5.17652333e-02f, -2.61103511e-01f, -1.94235250e-01f, 1.76605254e-01f, -1.77949835e-02f,
  1.00227669e-01f, 9.86122563e-02f, -4.72173959e-01f, 1.87717617e-01f, 1.58023119e-01f, 1.42471433e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.68650621e-01f, 4.06791359e-01f, -2.56616175e-01f, -9.91088897e-02f, -2.00485960e-01f, 3.64453614e-01f, -1.83638975e-01f, 6.24012984e-02f, 4.59978402e-01f, -1.63169950e-01f,
  -3.64883125e-01f, 6.25850618e-01f, -2.26834714e-02f, 2.86246657e-01f, 2.52023220e-01f, 4.68882650e-01f, 1.47526696e-01f, 9.49244052e-02f, -1.05180748e-01f, 3.86503607e-01f,
  5.74143648e-01f, 4.33014661e-01f, -8.46851051e-01f, -2.43070219e-02f, -2.71011651e-01f, 9.31540877e-02f, 6.67427123e-01f, 7.36527681e-01f, -3.71465623e-01f, -5.30140400e-01f,
  4.67663139e-01f, -7.45206699e-02f, -5.49809992e-01f, -5.28354011e-02f, 2.64112443e-01f, 1.42525211e-01f, 2.47851536e-01f, 1.89006627e-01f, 1.43295497e-01f, 4.23471481e-01f,
  4.54991668e-01f, 7.61240244e-01f, -7.54742622e-02f, 9.29519385e-02f, 4.55301225e-01f, 9.19867337e-01f, -4.56602544e-01f, 3.62142205e-01f, 4.02929671e-02f, 5.87128937e-01f,
  -1.72891468e-02f, -2.13793829e-01f, -2.04424813e-01f, 2.43667662e-01f, 7.29371011e-01f, -4.11866218e-01f, 2.14756593e-01f, -3.05185884e-01f, -6.28270566e-01f, 1.74327105e-01f,
  -8.81874114e-02f, 7.63260365e-01f, 5.64985275e-01f, 2.99754441e-01f, 2.24481300e-01f, -4.88678098e-01f, 7.13316262e-01f, 4.91576403e-01f, -2.78888464e-01f, -4.58758056e-01f,
  -1.95126403e-02f, -2.50600856e-02f, 7.91657309e-04f, -3.98796827e-01f, 3.64004225e-01f, 1.31896034e-01f, 4.17625487e-01f, 6.22077510e-02f, 3.49927068e-01f, 4.24161144e-02f,
  5.32086790e-01f, 1.08681373e-01f, 3.87836248e-01f, 5.15258193e-01f, 8.84880945e-02f, 1.45249501e-01f, 4.82295692e-01f, -2.35758047e-03f, 6.43905848e-02f, -4.04875547e-01f,
  -4.43290472e-02f, -2.92173684e-01f, 3.77438277e-01f, 1.26718715e-01f, 4.78462875e-01f, -1.07882850e-01f, -4.39555883e-01f, 6.09763563e-01f, 7.88970292e-03f, 8.75969678e-02f,
  -6.82228655e-02f, 4.25748140e-01f, -9.20100331e-01f, -1.08727053e-01f, -2.68925011e-01f, -4.27846283e-01f, 2.65928358e-01f, 6.25421405e-01f, -3.34316134e-01f, 1.83794260e-01f,
  3.18482757e-01f, -9.64959264e-02f, 1.93216085e-01f, -2.88387507e-01f, 2.76435435e-01f, 5.16628206e-01f, -2.02829987e-01f, -2.27097154e-01f, 2.59579588e-02f, -1.02766208e-01f,
  -3.07518721e-01f, -1.33710220e-01f, 1.15415633e-01f, 8.92748088e-02f, 5.27776957e-01f, 1.24996677e-01f, 6.04216814e-01f, -3.74995887e-01f, 3.79658639e-01f, -4.84125823e-01f,
  5.26179112e-02f, 8.14154446e-01f, 4.17493433e-01f, -6.18570298e-02f, 8.08421522e-02f, 3.17257226e-01f, -1.87334031e-01f, -9.13691670e-02f, 1.33908018e-01f, 2.79775839e-02f,
  6.38640463e-01f, -1.00931548e-01f, 1.33301854e-01f, -2.52017587e-01f, 1.35181189e-01f, 1.15744501e-01f, -2.90500224e-01f, 4.64809924e-01f, 5.97525001e-01f, 4.68660623e-01f,
  -7.76265025e-01f, 5.48982084e-01f, 1.93594228e-02f, 2.42154956e-01f, 3.57941777e-01f, 5.40762007e-01f, -3.84008795e-01f, -5.39344847e-01f, -4.18175071e-01f, 1.35886863e-01f,
  3.87905985e-01f, 1.56963542e-02f, 3.55796963e-01f, -7.81763420e-02f, -3.04476410e-01f, 3.32110792e-01f, 4.30206925e-01f, -1.57409027e-01f, 3.85202765e-01f, -3.05957705e-01f,
  -2.86588892e-02f, 3.47998023e-01f, 5.89594901e-01f, -3.39397900e-02f, 4.32207882e-01f, 5.07628024e-01f, -2.66080141e-01f, -3.50995451e-01f, 5.31880915e-01f, 3.86210866e-02f,
  2.49792382e-01f, -3.19094181e-01f, -9.24050882e-02f, 3.79153401e-01f, 6.73051849e-02f, 7.98766732e-01f, 4.54933941e-01f, 2.98953712e-01f, 3.42160016e-01f, 2.11097673e-01f,
  -5.44347651e-02f, 3.18589479e-01f, 3.18678856e-01f, -7.28384376e-01f, 7.10613012e-01f, 5.40735781e-01f, 2.23049670e-01f, -4.91414934e-01f, -1.18880719e-01f, 2.41432890e-01f,
  2.50135153e-03f, 2.34930113e-01f, 2.42038861e-01f, 9.77084860e-02f, 4.75577980e-01f, 2.75772542e-01f, 2.87477463e-01f, 2.20148638e-01f, -6.69398785e-01f, -4.66996461e-01f,
  4.78391677e-01f, -1.66440114e-01f, -7.09864646e-02f, -6.58110201e-01f, 3.31169367e-01f, -2.27985457e-01f, -1.74482554e-01f, 2.57727355e-01f, 4.78034288e-01f, -8.52245465e-02f,
  -5.21169007e-01f, -8.85785669e-02f, 4.69221801e-01f, -1.41556993e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -4.86012883e-02f, 6.45156324e-01f, -9.99234617e-02f, 4.93372947e-01f, 3.19474399e-01f, 6.09274268e-01f, 3.09483856e-01f, 1.17440045e-01f, 1.61358565e-01f, 3.59241694e-01f,
  4.41542640e-02f, 1.25964209e-01f, 1.27314612e-01f, -6.25169277e-02f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.98548526e-01f, 3.44720960e-01f, 1.45565182e-01f, 1.92913964e-01f, -1.79402292e-01f, -1.16567440e-01f, -1.76926404e-01f, -5.26088774e-02f, 1.07811406e-01f, -1.43827006e-01f,
  -3.61251943e-02f, 9.90724564e-02f, -2.32427679e-02f, 1.41890764e-01f, 1.37944877e-01f, 2.36993611e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.12424248e-01f, 6.10028327e-01f, 2.93364465e-01f, -2.40030989e-01f, 4.57912177e-01f, 6.89483166e-01f, -2.43487924e-01f, 1.60854891e-01f, 3.20422202e-01f, 1.70679897e-01f,
  -4.67671305e-01f, -3.13563585e-01f, 3.50448310e-01f, -3.69933903e-01f, -3.54034781e-01f, 5.52286655e-02f, -1.26599953e-01f, -5.70604861e-01f, 5.18886924e-01f, 6.08233631e-01f,
  5.45443147e-02f, 1.74485803e-01f, -3.80019516e-01f, 1.79084949e-02f, 8.21202040e-01f, -3.65478128e-01f, -3.38073343e-01f, 6.67977273e-01f, 1.98186278e-01f, -3.02881002e-01f,
  -2.83162624e-01f, -3.15712690e-01f, 2.56370604e-01f, 5.25098860e-01f, -4.86533821e-01f, 1.56254813e-01f, -6.15100026e-01f, 1.57844111e-01f, 6.66053534e-01f, 5.21922052e-01f,
  1.70897260e-01f, 7.05643415e-01f, 3.02037686e-01f, -3.35047841e-01f, 1.55451059e-01f, -2.01843902e-01f, 3.98943365e-01f, 6.55521572e-01f, 1.92739159e-01f, 7.47122645e-01f,
  -9.95414779e-02f, -9.22054946e-02f, -2.26908565e-01f, 4.54466403e-01f, -3.36133838e-01f, 3.47502977e-01f, 1.11227661e-01f, 1.11070357e-01f, -3.42076123e-01f, -5.98075807e-01f,
  6.86627403e-02f, -6.42688453e-01f, -8.38933051e-01f, -5.16939163e-01f, -3.61533905e-03f, 7.05934823e-01f, 1.24142013e-01f, -4.33432132e-01f, 5.13400137e-01f, 4.33821082e-01f,
  3.26681048e-01f, 1.21815167e-01f, 8.61291438e-02f, 1.69708252e-01f, -5.11322170e-02f, -4.66649830e-01f, 1.34301260e-01f, 3.87706429e-01f, 3.89810652e-01f, 5.91600716e-01f,
  -1.86522558e-01f, -1.81402508e-02f, 3.49484742e-01f, -4.56799775e-01f, 4.85887408e-01f, 2.77563155e-01f, 2.14185506e-01f, 2.18564123e-01f, -6.01389110e-01f, -2.11568743e-01f,
  6.27530273e-03f, -4.96747226e-01f, 6.00555599e-01f, -1.93553880e-01f, 1.04533657e-01f, -3.41591299e-01f, -1.04234971e-01f, 2.39517212e-01f, -6.48128986e-02f, 5.94651878e-01f,
  -1.05230056e-01f, -4.98032779e-01f, 2.12735116e-01f, -2.57286996e-01f, 4.19950671e-02f, -1.97134227e-01f, 4.61589210e-02f, 4.23830450e-01f, 8.75529051e-02f, 4.62660760e-01f,
  2.76170820e-01f, 5.78806639e-01f, -3.99684757e-01f, -1.57873094e-01f, -2.70314842e-01f, 3.19810390e-01f, 9.20609236e-01f, -5.37710413e-02f, 6.87870085e-02f, 1.44524425e-01f,
  -4.41415191e-01f, 1.43813014e-01f, 3.43421698e-01f, 4.30569828e-01f, -2.64820337e-01f, 8.14790189e-01f, 5.93114495e-01f, -1.08903982e-01f, -6.52812829e-04f, -8.22450459e-01f,
  -3.99041384e-01f, 4.47806090e-01f, 2.97054470e-01f, -2.85968572e-01f, 1.29579883e-02f, 2.63961405e-01f, -2.84327418e-01f, -6.06321990e-02f, 6.52846873e-01f, 6.15893900e-01f,
  -3.88751149e-01f, 2.58006722e-01f, 5.40376842e-01f, -7.11282551e-01f, 3.36519182e-01f, -3.38726550e-01f, -1.55735062e-02f, -2.41928414e-01f, -2.23953538e-02f, 1.55920489e-02f,
  4.10610288e-02f, 5.97914219e-01f, -4.48748618e-01f, 3.44406068e-01f, 5.31916201e-01f, -7.86457136e-02f, 5.96600831e-01f, -3.18617910e-01f, 4.11263481e-02f, -5.89645505e-01f,
  1.44670203e-01f, 1.87422201e-01f, 3.54408413e-01f, 7.09716916e-01f, -6.90269589e-01f, 2.25256518e-01f, 2.91335899e-02f, 5.19540831e-02f, 5.59677482e-01f, -1.11580752e-01f,
  6.21864535e-02f, 3.64917368e-01f, 4.97504994e-02f, -2.64354378e-01f, -1.14916172e-02f, -3.66150677e-01f, 1.71665817e-01f, 2.93549091e-01f, 3.86627644e-01f, -1.44682303e-01f,
  2.97926873e-01f, 4.22721595e-01f, -5.93612343e-03f, -1.77644819e-01f, 2.37614468e-01f, -5.80286905e-02f, -3.44927400e-01f, 1.34473383e-01f, 5.27660847e-01f, -2.59325594e-01f,
  -1.43409163e-01f, 1.26244962e-01f, -3.27410907e-01f, -2.96076655e-01f, 3.98515612e-01f, -5.20582318e-01f, 4.25989717e-01f, 5.06871268e-02f, 8.12462866e-02f, 2.20199134e-02f,
  -1.82609737e-01f, 2.32320964e-01f, 4.00476813e-01f, -2.64082223e-01f, 1.32734612e-01f, 1.30758420e-01f, 3.19118887e-01f, -4.84237432e-01f, 2.45390266e-01f, 1.86040662e-02f,
  1.26159459e-01f, 3.54815781e-01f, -6.28672063e-01f, 1.19601630e-01f, 8.49065661e-01f, 4.20709938e-01f, -1.90404415e-01f, 6.94606125e-01f, 2.58967906e-01f, -4.40043718e-01f,
  3.93714100e-01f, -2.78300792e-02f, 3.68109316e-01f, -1.91326693e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.07778125e-01f, -9.05519165e-03f, 4.32146907e-01f, 2.71582454e-01f, -1.06601782e-01f, -3.51433642e-02f, -1.65369734e-01f, 1.59709081e-01f, 1.99118942e-01f, 2.77650923e-01f,
  5.42822719e-01f, 1.17000565e-01f, -5.22248268e-01f, 3.64168435e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -2.58574843e-01f, -1.14431933e-01f, -6.19439662e-01f, -5.01596928e-02f, 8.95984918e-02f, -1.81315362e-01f, 1.95767581e-01f, 3.84833276e-01f, -2.52859473e-01f, 1.90092117e-01f,
  -1.59334997e-03f, 2.88657844e-01f, -6.77961707e-01f, -5.46717703e-01f, 5.06622195e-01f, 1.76954716e-01f, 1.38149813e-01f, -3.27881455e-01f, 9.04428884e-02f, -9.52706635e-01f,
  3.93024445e-01f, -7.90308975e-03f, 2.73530155e-01f, 1.62899211e-01f, -6.47347867e-01f, -3.34342241e-01f, -6.15839481e-01f, 1.21619225e-01f, -1.58022523e-01f, 2.01253910e-02f,
  -4.48136538e-01f, 1.72345623e-01f, -1.49983346e-01f, -4.41484302e-01f, 3.02002460e-01f, -3.29669297e-01f, -4.90007341e-01f, 8.05129945e-01f, 1.94093809e-01f, 4.09840196e-01f,
  2.72202548e-02f, -7.24106193e-01f, -7.57512227e-02f, 3.82279128e-01f, -1.65378913e-01f, 9.33847278e-02f, -1.60432577e-01f, -1.73341960e-01f, -2.18385518e-01f, 1.55471757e-01f,
  -2.01560929e-01f, -6.66154027e-01f, -1.25100553e-01f, 1.02867462e-01f, 3.59771609e-01f, -1.70913503e-01f, 3.14382203e-02f, 3.87892544e-01f, 3.74327153e-01f, -7.06305265e-01f,
  -7.73823440e-01f, -1.00990962e-02f, 3.55904579e-01f, -2.26242363e-01f, 5.43749452e-01f, -2.14631539e-02f, -3.35074991e-01f, -1.60124198e-01f, 1.79883689e-01f, -3.06727648e-01f,
  -6.40276194e-01f, -8.25744390e-01f, -9.33935121e-02f, 4.21670675e-02f, 4.70799387e-01f, 2.16613531e-01f, 1.02202170e-01f, -4.46892768e-01f, -1.51641250e-01f, 4.39912140e-01f,
  3.40310216e-01f, 1.96598127e-01f, 3.25670838e-01f, -4.43612039e-02f, 1.07355207e-01f, 6.22994006e-01f, 1.27078980e-01f, -4.39015388e-01f, -6.23501360e-01f, -3.98605734e-01f,
  -2.54856259e-01f, -1.39366895e-01f, 3.41891825e-01f, 5.53908153e-03f, -4.99561399e-01f, 2.49415442e-01f, -3.37966353e-01f, -3.72452497e-01f, 1.23845607e-01f, 3.20844591e-01f,
  -6.66756630e-01f, -7.50701964e-01f, -4.32530642e-01f, -4.69607770e-01f, 2.83107877e-01f, -6.52831435e-01f, -7.25222111e-01f, -9.23673734e-02f, 4.69888896e-01f, 2.87413746e-01f,
  -2.32491791e-01f, -2.30548084e-01f, 8.66368506e-03f, 2.44430393e-01f, -2.09371671e-01f, -3.73118192e-01f, 4.24393743e-01f, -5.99538051e-02f, 3.69298369e-01f, -1.87540710e-01f,
  5.50827444e-01f, 1.04106516e-01f, -5.20961940e-01f, -6.97705626e-01f, -3.23833644e-01f, -3.33064586e-01f, -4.31680888e-01f, 2.23776817e-01f, -2.15629518e-01f, 1.84620023e-01f,
  1.02879584e-01f, -2.14447960e-01f, -6.81106567e-01f, -5.19348502e-01f, 3.15039158e-01f, 3.54770243e-01f, -2.57015731e-02f, -8.19301903e-02f, 4.25095018e-03f, 1.79046378e-01f,
  -5.25276184e-01f, 1.46137848e-01f, 4.93414521e-01f, 5.05041741e-02f, 3.80117744e-02f, 4.95445251e-01f, -5.80327809e-01f, 6.39955997e-01f, -4.33636695e-01f, -2.20541343e-01f,
  -1.07924692e-01f, -2.71596789e-01f, 4.42929752e-02f, -7.14416280e-02f, 3.24414313e-01f, -2.59765089e-01f, 2.06959412e-01f, -2.86734194e-01f, -4.34048712e-01f, -6.59784436e-01f,
  -2.75956541e-01f, -6.69664890e-02f, -2.02274658e-02f, -1.67564586e-01f, -6.22629762e-01f, -6.11597905e-03f, -6.35771215e-01f, -1.66615080e-02f, 3.79952341e-01f, 5.23864031e-01f,
  4.07135725e-01f, -2.57979065e-01f, -2.60386497e-01f, -3.83774221e-01f, -4.38964665e-01f, -7.42500782e-01f, -9.48656872e-02f, 2.01336406e-02f, 4.08615351e-01f, 2.20027626e-01f,
  -4.16405469e-01f, -2.40411162e-01f, 2.72095650e-01f, 6.31561652e-02f, -4.78243649e-01f, -7.53074959e-02f, -5.19009642e-02f, -5.03851593e-01f, -8.50823298e-02f, 2.32889399e-01f,
  2.42266715e-01f, -8.81468892e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.72128712e-02f, 2.90517330e-01f, 8.01126380e-03f, -3.68777901e-01f, 6.92819357e-02f, 3.16407718e-02f, -1.45615786e-01f, -2.10859209e-01f, -2.16815457e-01f, 9.07954946e-02f,
  1.12813823e-01f, 1.35709913e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    