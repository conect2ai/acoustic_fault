/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.29688430e-01f, 1.25454783e-01f, -2.46060044e-01f, 2.72076845e-01f, -9.07791872e-03f, -1.16685830e-01f, 4.00832221e-02f, 9.89026278e-02f, -3.31181645e-01f, 3.87321234e-01f,
  4.56357270e-01f, -3.81953925e-01f, 2.12879747e-01f, 3.56770009e-01f, -3.83322597e-01f, -6.16042167e-02f, 1.44295678e-01f, 3.88822034e-02f, -2.61600673e-01f, 3.17410946e-01f,
  -8.81475359e-02f, 3.69960934e-01f, 7.26131052e-02f, -4.01834138e-02f, 2.60183305e-01f, -1.63850337e-01f, 4.03102547e-01f, -1.49406642e-01f, 2.48134181e-01f, -1.15284352e-02f,
  -8.61448061e-04f, -1.35464324e-02f, 1.95102468e-02f, -7.85391256e-02f, 2.74465922e-02f, 5.36237657e-02f, -6.55428395e-02f, -1.39203826e-02f, -6.53326958e-02f, 8.07069764e-02f,
  1.03178425e-02f, -4.15447839e-02f, -5.86117767e-02f, 3.30016837e-02f, 1.42119201e-02f, -9.39728171e-02f, 2.01935172e-02f, 4.62779775e-02f, -3.38141508e-02f, 4.37736921e-02f,
  -5.55296279e-02f, -1.46680837e-02f, 4.40627150e-02f, 3.01596951e-02f, -1.08450852e-01f, -7.93157816e-02f, 9.79746226e-03f, -2.83885654e-02f, -8.46078712e-03f, -7.75624067e-02f,
  1.29746981e-02f, -1.55655220e-02f, -1.22462101e-02f, 9.87296551e-02f, -4.67661731e-02f, 1.00231007e-01f, 9.70344432e-03f, 6.66194260e-02f, -1.01733081e-01f, 1.00933306e-01f,
  6.61141500e-02f, 3.81147303e-02f, -9.88888647e-03f, 7.06616789e-02f, 9.02991742e-02f, -6.10697782e-03f, -3.91490944e-02f, -1.50246872e-02f, -3.23083587e-02f, 2.34896373e-02f,
  3.47190984e-02f, -1.91235803e-02f, -1.51460888e-02f, 1.08822048e-01f, 7.53387213e-02f, 2.37090257e-03f, 8.29638913e-02f, 7.91435763e-02f, 9.60634835e-03f, -7.17675127e-03f,
  3.14223915e-02f, 2.27184191e-01f, -5.71331084e-02f, -7.06239715e-02f, 8.14062450e-03f, 5.64188920e-02f, -3.88755202e-02f, 2.27206573e-03f, -6.22581020e-02f, 2.46594939e-02f,
  -7.98231456e-03f, 1.18950211e-01f, -1.93279944e-02f, 4.40533161e-02f, -3.03711127e-02f, 5.76987676e-02f, 3.35763879e-02f, -4.30435538e-02f, 1.85678899e-02f, 4.72269841e-02f,
  9.31385010e-02f, -2.16416512e-02f, 1.14553026e-04f, 6.52291402e-02f, 7.60372356e-02f, -1.30898738e-02f, -7.76024982e-02f, -1.11930437e-01f, 2.47773025e-02f, -1.64827723e-02f,
  -3.95440400e-01f, 7.83533528e-02f, -4.71542403e-02f, -1.09554313e-01f, -4.79761779e-01f, -3.07364643e-01f, 5.94127849e-02f, -3.07449609e-01f, 1.87140748e-01f, 9.81179476e-02f,
  -6.34589493e-02f, 8.20545927e-02f, 2.04555422e-01f, 1.25485256e-01f, -2.24091634e-01f, 4.49863911e-01f, 1.54206641e-02f, 2.46992856e-02f, 1.44338131e-01f, -2.17300475e-01f,
  -9.19978395e-02f, -1.14278086e-01f, -1.61668375e-01f, -1.29289821e-01f, -3.65691870e-01f, -2.39478827e-01f, 6.92635356e-03f, 1.67268794e-02f, -2.76696891e-01f, 7.15167820e-02f,
  -2.89149489e-02f, 1.00144416e-01f, -1.43640283e-02f, 1.15831129e-01f, -3.00304800e-01f, 2.27826741e-03f, -9.18278769e-02f, 8.40263367e-02f, 2.95368303e-03f, -2.07359139e-02f,
  9.15937722e-02f, -7.15415254e-02f, 1.01305559e-01f, 4.66167592e-02f, -2.17522010e-02f, 2.91701443e-02f, -3.57578620e-02f, -3.92847396e-02f, 6.84172660e-02f, -3.56448591e-02f,
  6.03578612e-03f, -4.05660309e-02f, 4.75998148e-02f, 5.77012487e-02f, -6.28857762e-02f, 6.56956285e-02f, 2.13369299e-02f, -1.30070478e-01f, 2.79526785e-02f, -7.78497383e-02f,
  -6.12133695e-03f, 5.89203723e-02f, -1.22880116e-02f, 8.44079182e-02f, 4.74938639e-02f, 1.31967753e-01f, 1.12155057e-01f, -3.11798323e-02f, -3.09363026e-02f, -4.15265672e-02f,
  -1.18924290e-01f, 1.96472388e-02f, 1.26606360e-01f, -9.33926925e-02f, 7.47396937e-03f, 1.51422217e-01f, 7.06043467e-02f, -8.01539049e-03f, -1.50585935e-01f, 5.23302294e-02f,
  1.40009627e-01f, -1.65244061e-02f, -1.02308117e-01f, 4.40224893e-02f, 4.98373434e-02f, -5.91185316e-02f, 1.33813784e-01f, 1.29217692e-02f, 7.84844533e-02f, -1.90217435e-01f,
  -3.01208973e-01f, -3.11263949e-02f, -2.51419786e-02f, -1.54192090e-01f, 1.37810960e-01f, 1.82295665e-02f, 2.03749776e-01f, 5.98953366e-02f, -1.29868418e-01f, -3.48228402e-02f,
  -1.00224875e-01f, 3.95261906e-02f, -5.91324121e-02f, -9.53865424e-03f, -5.60706519e-02f, 5.77445934e-03f, 4.80456240e-02f, -2.63904762e-02f, -1.23419471e-01f, -7.07022697e-02f,
  -6.81002215e-02f, -9.02131125e-02f, 1.94598120e-02f, -3.85657139e-02f, -3.58076170e-02f, -7.20762163e-02f, -6.16701953e-02f, -4.09371108e-02f, -3.03804353e-02f, 1.29612768e-02f,
  -4.60819095e-01f, 4.72616613e-01f, 1.53399706e-01f, 1.46965692e-02f, -3.56376141e-01f, 8.46946314e-02f, 1.87596500e-01f, -8.64816532e-02f, 3.05587143e-01f, 3.24391991e-01f,
  -2.05378756e-01f, 2.87111074e-01f, 7.91339874e-02f, -1.43321648e-01f, -2.86362320e-01f, 3.48192364e-01f, -3.99411052e-01f, 7.70959398e-03f, -1.29238918e-01f, -2.54171282e-01f,
  -1.15673624e-01f, -3.03795457e-01f, -2.23218977e-01f, -1.74071342e-01f, -2.61347353e-01f, -1.59999058e-02f, -2.87218273e-01f, 2.24459603e-01f, -1.16919510e-01f, -9.79431048e-02f,
  -2.47081704e-02f, 7.61689246e-02f, -1.03497617e-01f, -3.93021628e-02f, -1.76305681e-01f, 7.44421259e-02f, 5.58221526e-02f, 3.91887464e-02f, -3.02253272e-02f, 8.94979089e-02f,
  4.51282933e-02f, -3.53624881e-03f, -8.78424570e-02f, 4.44360897e-02f, -4.20395993e-02f, 1.96085442e-02f, -8.12012106e-02f, -8.11096728e-02f, 5.09355739e-02f, -1.13601713e-02f,
  8.20274428e-02f, -4.97189525e-04f, 3.22638229e-02f, 5.70655763e-02f, -5.63652776e-02f, -3.09090130e-03f, 6.81669787e-02f, 1.32048249e-01f, -2.04282310e-02f, 8.11455399e-02f,
  -4.25119847e-02f, -7.66948843e-03f, 4.70933355e-02f, 9.64722410e-03f, -3.85038480e-02f, -3.66434194e-02f, -9.13863350e-03f, -9.37162563e-02f, 3.04067071e-04f, -1.08951293e-01f,
  4.48279791e-02f, -5.35694472e-02f, -6.84398264e-02f, 8.03958476e-02f, -6.54849932e-02f, 7.92715233e-03f, -6.31079823e-02f, 1.24902623e-02f, 1.55159337e-02f, -5.13419658e-02f,
  3.30597125e-02f, -3.63752879e-02f, -6.96048886e-02f, -1.43063103e-03f, -7.21300021e-02f, -2.36939117e-02f, -5.56641584e-03f, 1.55241400e-01f, -1.00891776e-01f, -1.01103015e-01f,
  1.38997864e-02f, -2.17339210e-03f, -2.20365096e-02f, -5.26212677e-02f, 5.44838347e-02f, -1.07677981e-01f, -9.97996479e-02f, -3.84663418e-02f, 1.07834637e-01f, -1.04167648e-01f,
  -2.52345223e-02f, 2.25897580e-02f, -5.78941889e-02f, -3.64114181e-03f, 4.69337925e-02f, 2.14420799e-02f, 3.64488480e-03f, 4.81258333e-02f, -4.40038145e-02f, -9.46729332e-02f,
  -1.73855945e-01f, -1.74098071e-02f, 4.47461791e-02f, -1.36619642e-01f, -9.72262472e-02f, 5.28556481e-03f, -2.46359799e-02f, 3.76449823e-02f, -7.93283656e-02f, -2.36339960e-02f,
  5.99338293e-01f, -6.17124438e-01f, -8.27717483e-02f, -1.77052587e-01f, 4.39696670e-01f, 1.85875595e-01f, -9.83375683e-02f, -6.87235966e-02f, -4.03061397e-02f, -4.46158081e-01f,
  -2.61368435e-02f, -2.10166827e-01f, -1.32597119e-01f, -1.11125998e-01f, 5.76750457e-01f, -5.22278585e-02f, 1.29529403e-03f, -1.98911622e-01f, 1.00684546e-01f, -4.82477620e-02f,
  1.19013719e-01f, 8.00451338e-02f, 1.48564979e-01f, -3.75935361e-02f, 6.80902153e-02f, -1.56441048e-01f, 6.70126677e-02f, -2.68277917e-02f, -1.11534065e-02f, 5.16314767e-02f,
  7.57171735e-02f, -9.97606292e-02f, -3.09568662e-02f, 1.73055865e-02f, 4.55858707e-02f, 9.16992780e-03f, 3.01362276e-02f, 1.08619751e-02f, 8.13824236e-02f, -8.14220756e-02f,
  -1.90717336e-02f, -1.94663648e-02f, -1.82046182e-02f, 4.30282205e-02f, 3.06787193e-02f, 6.09095814e-03f, -1.79656036e-02f, 7.55346417e-02f, -1.41430840e-01f, 3.54646593e-02f,
  -3.85083742e-02f, 2.38171173e-03f, 4.20228690e-02f, -1.45370036e-01f, 1.35139097e-02f, -4.72607417e-03f, -3.06921359e-02f, -3.88665423e-02f, -4.47913036e-02f, -4.87250388e-02f,
  -1.04657896e-02f, -1.42560024e-02f, 2.25228798e-02f, 9.46213976e-02f, 2.13196948e-02f, 9.14923381e-03f, 3.72200459e-02f, 6.81170076e-02f, 2.92125288e-02f, 4.24535759e-02f,
  -6.67963689e-03f, 5.78751788e-03f, 1.94247030e-02f, 2.71400195e-02f, -4.44620959e-02f, -1.61169302e-02f, 2.71767825e-02f, -6.30664453e-02f, -4.38301004e-02f, 7.58167356e-02f,
  -3.54630593e-03f, 3.11330482e-02f, -5.34910783e-02f, -2.69368328e-02f, 1.43203046e-02f, 7.31225312e-02f, -1.69610212e-04f, -1.56044764e-02f, 1.78846531e-02f, 8.73713419e-02f,
  -2.17322797e-01f, -3.35661530e-01f, -6.87358752e-02f, -4.15203953e-03f, -1.09688558e-01f, -4.45708707e-02f, 8.76451135e-02f, -4.84324433e-02f, -3.38205360e-02f, 6.89733103e-02f,
  -3.16081132e-04f, -6.39188141e-02f, -1.54280066e-02f, 4.46074046e-02f, -5.69187803e-03f, 1.93060022e-02f, -4.01626006e-02f, -6.44406602e-02f, 1.25617400e-01f, -3.12129129e-02f,
  -1.06057655e-02f, 3.19323279e-02f, 6.66987896e-03f, 7.57893696e-02f, 2.53777634e-02f, -3.73757035e-02f, 4.45367508e-02f, 4.36367234e-03f, 2.03464366e-02f, -2.61782799e-02f,
  -2.80037820e-01f, 2.37240538e-01f, -3.12994957e-01f, 2.71184742e-01f, -9.18267071e-02f, -1.37699217e-01f, -2.67759800e-01f, 3.71921323e-02f, -3.69274884e-01f, 6.07110225e-02f,
  3.53450179e-01f, -4.22698230e-01f, -5.88235585e-03f, 4.65195954e-01f, -5.94823807e-02f, 2.15590373e-01f, 2.37096623e-01f, 8.05482361e-03f, -2.01394528e-01f, -4.21208218e-02f,
  -2.38078088e-02f, 4.72181410e-01f, 2.73008376e-01f, 2.74945106e-02f, 8.53067040e-02f, -1.70903921e-01f, 2.49547169e-01f, -1.55156195e-01f, 2.09661126e-01f, -4.39306023e-03f,
  9.23303887e-02f, -7.46006817e-02f, 4.65438813e-02f, -4.00925018e-02f, 4.19611819e-02f, 7.78304189e-02f, -6.01393245e-02f, -1.11525521e-01f, -1.05554596e-01f, -9.37017724e-02f,
  -1.96200863e-01f, 3.23800743e-02f, 1.82606820e-02f, 6.46782592e-02f, -9.90425721e-02f, 3.71915102e-02f, -6.33319989e-02f, 4.64592353e-02f, -8.71768817e-02f, -1.98109094e-02f,
  4.86127436e-02f, 2.05121469e-02f, 2.65291017e-02f, -7.39360303e-02f, -9.52783078e-02f, -3.00151743e-02f, -2.93954536e-02f, -4.82649058e-02f, 2.44446900e-02f, -1.40714860e-02f,
  9.09961015e-02f, -3.79981659e-02f, 6.48669899e-02f, -2.27205674e-04f, 7.62938894e-03f, 9.57894549e-02f, 1.09280152e-02f, 4.10856716e-02f, -1.63002357e-01f, 7.44619891e-02f,
  3.68710631e-03f, 2.27685031e-02f, 2.50795335e-02f, -2.66854782e-02f, 5.52603416e-02f, -6.95023872e-03f, 3.83426286e-02f, 7.13249110e-03f, 6.05608560e-02f, -6.34337170e-03f,
  -1.90890152e-02f, -4.40375395e-02f, -2.94298120e-03f, 5.72163670e-04f, 4.36441153e-02f, -1.42231807e-02f, 3.65240164e-02f, -2.18184628e-02f, -1.18232012e-01f, 2.16838978e-02f,
  2.07848698e-02f, 3.38385403e-02f, -9.14821681e-03f, -4.71802093e-02f, -7.91928265e-03f, -1.05829369e-02f, -2.47276183e-02f, -3.04971356e-02f, 4.09342311e-02f, -3.83448601e-02f,
  9.19586048e-02f, -4.71682735e-02f, 2.31482368e-02f, -2.18522064e-02f, 1.00145131e-01f, 7.35391304e-03f, 3.89555581e-02f, -2.77614836e-02f, 1.27457991e-01f, 7.67946197e-03f,
  5.91153130e-02f, -1.25051439e-01f, -5.58208413e-02f, 2.45110672e-02f, 1.73881352e-02f, 7.97337517e-02f, -7.85950571e-02f, 2.26317463e-03f, 8.58774707e-02f, 1.89996976e-02f,
  4.41504853e-05f, -5.99412739e-01f, -3.87424380e-01f, -1.59711719e-01f, 5.54100335e-01f, 2.55827606e-01f, -4.16484661e-02f, 3.23397554e-02f, -3.56028438e-01f, -1.12029247e-01f,
  2.62696415e-01f, -3.35582256e-01f, -1.39090180e-01f, 4.99993972e-02f, 4.26279008e-02f, -2.68123239e-01f, -2.37183869e-02f, -6.38238387e-03f, 7.05785751e-02f, -6.68143854e-02f,
  1.10699445e-01f, 4.58856076e-01f, 5.94423749e-02f, 1.65739447e-01f, 1.23068690e-01f, -7.00437650e-02f, -2.76309880e-03f, -8.35043490e-02f, 1.46755949e-01f, 9.37719177e-03f,
  9.99332443e-02f, -3.64444032e-02f, 2.69351583e-02f, -9.27500948e-02f, 7.31384009e-02f, 3.61030325e-02f, -5.07945046e-02f, 6.01123013e-02f, -1.77771002e-02f, -7.23331096e-03f,
  -2.36593224e-02f, 1.57274798e-01f, 6.14132620e-02f, -1.45531157e-02f, 1.06097035e-01f, 5.55579066e-02f, 6.29044771e-02f, 8.54316577e-02f, -4.97480296e-02f, 8.83221924e-02f,
  -8.72826669e-03f, -2.70546824e-02f, 8.67804587e-02f, -7.42021799e-02f, 1.38209052e-02f, 5.94265461e-02f, -1.63098499e-02f, 8.18105042e-02f, 1.15601188e-02f, 1.02349833e-01f,
  6.01154044e-02f, 1.57934893e-02f, 2.87941787e-02f, -2.50284392e-02f, 5.37037849e-02f, 8.08714256e-02f, -2.83987783e-02f, 1.10994093e-01f, -8.95838886e-02f, 8.13909099e-02f,
  3.74702699e-02f, 2.88419109e-02f, 1.38369007e-02f, 6.14850558e-02f, 1.15748845e-01f, -2.86604222e-02f, -1.32544888e-02f, -1.77226644e-02f, 7.87620060e-03f, 6.63137659e-02f,
  -6.16831053e-03f, 3.70131410e-03f, -1.39813796e-02f, 4.95035388e-02f, 3.24444193e-03f, -5.66786714e-02f, 1.57489739e-02f, -2.76973899e-02f, 2.56177969e-02f, 1.79386400e-02f,
  -1.69335261e-01f, -4.72080469e-01f, -5.77479340e-02f, 2.58251242e-02f, -1.46207318e-01f, 1.26924561e-02f, -2.46493407e-02f, -6.45473972e-02f, -6.74671121e-03f, -1.50489528e-02f,
  1.23669222e-01f, -5.75774051e-02f, -1.09527782e-01f, 1.03517652e-01f, -4.65297475e-02f, -3.56571912e-03f, -1.14711009e-01f, -1.05681159e-01f, -6.46783635e-02f, 4.03610012e-03f,
  -4.08495683e-03f, 9.93045121e-02f, 1.59117859e-02f, 1.42602533e-01f, 1.57628894e-01f, -1.35672584e-01f, 5.14693409e-02f, -3.26915942e-02f, 1.16961533e-02f, -9.08018649e-02f,
  -3.06749996e-02f, 4.17328447e-01f, -4.09274310e-01f, -1.91343337e-01f, -5.40630147e-02f, 3.16850036e-01f, 9.74551439e-02f, -7.08876923e-02f, -9.92915221e-03f, 3.60966176e-01f,
  1.42881319e-01f, 1.88486829e-01f, 9.56416577e-02f, 2.08687007e-01f, -4.48466897e-01f, -8.26949161e-03f, 7.88392201e-02f, 1.13882303e-01f, -1.36089414e-01f, -6.10891767e-02f,
  -2.33468473e-01f, 1.34749040e-01f, -1.23858251e-01f, -4.95928749e-02f, -3.29683826e-04f, -1.25915438e-01f, -2.23621339e-01f, -1.15977615e-01f, 2.03429848e-01f, 1.50669906e-02f,
  2.24504113e-01f, -6.31219000e-02f, -5.17465360e-02f, 6.41119108e-02f, -1.90691147e-02f, 8.51235166e-02f, -4.29107808e-03f, 4.38988721e-03f, -9.19452235e-02f, 5.15991412e-02f,
  5.82505427e-02f, -2.41214242e-02f, -7.85178244e-02f, -4.53540310e-02f, 6.38606474e-02f, -1.68095995e-02f, 1.14196502e-01f, 3.13616660e-03f, 5.74425794e-02f, 5.25850579e-02f,
  3.12456326e-03f, 4.91076931e-02f, -1.03221491e-01f, 6.79714307e-02f, -9.00794268e-02f, 4.15697023e-02f, -8.97389874e-02f, 2.36231927e-02f, 8.37886557e-02f, 1.26919588e-02f,
  -1.23345144e-01f, 1.58487186e-02f, 3.01903430e-02f, 4.74275351e-02f, -2.44912487e-02f, -1.39720486e-02f, 6.07169932e-03f, 7.46880611e-03f, -4.79453318e-02f, 2.40919758e-02f,
  6.32499158e-02f, -3.75188887e-03f, -1.40058696e-02f, -3.64415646e-02f, 9.16069001e-02f, 6.13439362e-03f, 2.01012399e-02f, 6.00700863e-02f, -3.60729285e-02f, -5.45105338e-02f,
  -1.58248208e-02f, 3.88865434e-02f, 8.62130150e-03f, -2.07124241e-02f, -5.25433347e-02f, -9.69760418e-02f, -5.07464074e-02f, -2.26453971e-02f, -6.93581859e-03f, -6.63087219e-02f,
  2.63289809e-01f, 6.94357678e-02f, 7.58549795e-02f, 2.28695527e-01f, 5.64362742e-02f, 1.03343632e-02f, -1.10180944e-01f, -1.09736749e-03f, 1.09863104e-02f, -3.45379747e-02f,
  5.40065840e-02f, 4.84208204e-02f, -3.00097801e-02f, -7.28583708e-03f, -4.89807762e-02f, -4.83543463e-02f, 3.29243504e-02f, 8.63386493e-04f, -2.88798027e-02f, -1.43601727e-02f,
  2.38393005e-02f, 1.79611500e-02f, 1.71438064e-02f, -1.10159561e-01f, -2.83607505e-02f, 3.42823751e-02f, 4.02695388e-02f, -6.56035393e-02f, -3.51307616e-02f, 2.46840324e-02f,
  -5.71700215e-01f, 1.11858904e-01f, -3.35034609e-01f, -5.90238348e-02f, 3.54419313e-02f, 6.26618445e-01f, 3.24283928e-01f, 5.18355966e-02f, -1.63011536e-01f, 4.39722836e-01f,
  3.79937381e-01f, -1.13548219e-01f, 1.85456857e-01f, 4.44840729e-01f, 3.56652886e-01f, 3.74516547e-01f, 1.25889376e-01f, -3.56097519e-02f, -1.69613913e-01f, -2.59195417e-01f,
  -1.24484770e-01f, 3.59557837e-01f, 1.77529559e-01f, 1.53865695e-01f, 3.94886546e-02f, -5.42064160e-02f, 1.71563193e-01f, -2.98823044e-02f, 2.58792341e-01f, 2.37772107e-01f,
  -9.72798169e-02f, -2.31694028e-01f, -1.06253125e-01f, -1.06874788e-02f, 1.28803521e-01f, -2.69675907e-02f, 3.13394926e-02f, -7.76004093e-03f, -4.51055318e-02f, 9.59568005e-03f,
  -3.71242464e-02f, -6.66901693e-02f, 4.11800481e-02f, -5.70301479e-03f, -1.37746884e-02f, -7.17005879e-02f, 3.89124155e-02f, 3.72683257e-02f, -1.51415933e-02f, 3.82339917e-02f,
  -2.17348058e-02f, 5.18244579e-02f, 2.04499699e-02f, 3.55126634e-02f, -2.61594839e-02f, 1.39987208e-02f, 1.34429941e-03f, 6.01850003e-02f, 5.92086427e-02f, 3.22175771e-03f,
  2.57128160e-02f, -3.32592987e-02f, 1.98573750e-02f, 1.29027350e-03f, 4.87538092e-02f, -3.95155065e-02f, -2.95347515e-02f, 4.99509610e-02f, -2.54762080e-02f, -1.72096025e-02f,
  -1.38948560e-01f, -6.19838610e-02f, -1.82435233e-02f, 2.26345882e-02f, -3.16084437e-02f, 9.00056437e-02f, -1.77449491e-02f, 4.04335633e-02f, -1.48471549e-01f, 2.19390374e-02f,
  -5.00205681e-02f, -3.77471074e-02f, -2.92800665e-02f, 4.14232127e-02f, 5.84641024e-02f, 2.90011580e-04f, -1.77834965e-02f, -5.32900393e-02f, 9.46220681e-02f, 4.85802330e-02f,
  -4.97483695e-03f, 1.55156001e-01f, 9.57029387e-02f, 7.13951886e-02f, -6.64217398e-02f, -1.48398674e-03f, 3.01572010e-02f, 6.76696375e-02f, -3.97134982e-02f, 6.12852648e-02f,
  -2.19468325e-02f, -5.86589575e-02f, -4.40938473e-02f, -3.56073491e-02f, 2.24350393e-02f, 1.33496709e-02f, 2.88828998e-03f, -6.16510920e-02f, 2.52129063e-02f, 1.17967594e-02f,
  8.19359254e-03f, -1.77452434e-02f, -1.94782801e-02f, 4.47358377e-02f, 6.94259023e-03f, 5.02318479e-02f, -9.79712158e-02f, -6.07247166e-02f, 4.59245928e-02f, -3.53905582e-03f,
  -1.99533522e-01f, -2.10509971e-01f, 3.62987183e-02f, 1.78757817e-01f, 1.58855289e-01f, 2.88332313e-01f, 1.55616343e-01f, 2.99014539e-01f, 3.22984874e-01f, -4.95646000e-02f,
  1.53388411e-01f, -3.52004439e-01f, -1.73071548e-01f, 2.73431957e-01f, 1.02059536e-01f, -2.15547159e-02f, 4.57098156e-01f, -4.61458899e-02f, 1.02364965e-01f, -2.81654261e-02f,
  3.47772613e-02f, 2.96517730e-01f, 4.38705161e-02f, 8.94709378e-02f, 1.26631871e-01f, -1.65830273e-02f, -2.21722052e-01f, -1.22682542e-01f, -4.05934304e-02f, -9.89972055e-03f,
  1.85326919e-01f, -9.79081318e-02f, 1.92596316e-01f, -8.60358253e-02f, 6.75180852e-02f, -2.72124801e-02f, -1.91046566e-01f, -5.46228401e-02f, -3.83677781e-02f, -2.26199832e-02f,
  -1.44196153e-01f, 3.41515034e-03f, 1.50386110e-01f, 8.77785124e-03f, -1.69600677e-02f, -3.30584496e-02f, 6.07772395e-02f, 1.61695749e-01f, -1.67722125e-02f, 3.88366990e-02f,
  2.75031049e-02f, 1.65780425e-01f, 8.31918046e-02f, 2.52670702e-03f, 1.04788214e-03f, 1.04866318e-01f, 2.16448829e-02f, -1.47832939e-02f, -6.98332489e-02f, 7.92287737e-02f,
  -2.16422696e-02f, -3.19640078e-02f, -7.52872825e-02f, 7.95110594e-03f, -5.46818599e-02f, -3.51128802e-02f, 5.59755191e-02f, -4.21475470e-02f, 2.98402421e-02f, 3.42469662e-02f,
  7.23666325e-02f, -6.39100224e-02f, 1.03004321e-01f, 6.88595474e-02f, -1.29700871e-02f, 7.93579780e-03f, -7.01194927e-02f, -1.13114296e-02f, 2.68647093e-02f, 1.40052736e-01f,
  -6.30609170e-02f, 1.63893793e-02f, -5.68143353e-02f, -7.58026317e-02f, -4.05655876e-02f, -2.34788209e-02f, 1.82787273e-02f, 4.12605256e-02f, -3.10655423e-02f, -5.22784330e-02f,
  -2.73512036e-01f, -5.07488549e-01f, 6.86696246e-02f, -2.53133047e-02f, 4.58977893e-02f, 1.10377342e-01f, 1.10501140e-01f, 7.32987151e-02f, -1.86036021e-01f, -1.04151871e-02f,
  8.05166066e-02f, -2.10034344e-02f, -1.45499572e-01f, 1.80565007e-02f, -3.54754478e-02f, -4.57232259e-02f, -8.66934583e-02f, -1.31044850e-01f, 9.31702647e-03f, -5.19426763e-02f,
  -8.53485540e-02f, -2.09813118e-01f, 4.38341126e-02f, 4.53754924e-02f, -6.16713008e-03f, -7.41460845e-02f, -4.84709255e-02f, 1.04670510e-01f, -7.49762207e-02f, -3.21252607e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.02179658e-01f, 6.66484952e-01f, 3.37484479e-01f, 2.52974957e-01f, 8.99381876e-01f, 1.10289621e+00f, 5.60589254e-01f, 9.23580706e-01f, 1.15177917e+00f, -2.13700280e-01f,
  5.21560274e-02f, -6.22445405e-01f, -2.82264352e-01f, 1.33659653e-02f, 3.00715387e-01f, 2.31448159e-01f, 5.17676413e-01f, 1.96816549e-01f, 4.66709495e-01f, -6.09286223e-03f,
  3.31496567e-01f, 3.88659947e-02f, -3.80781114e-01f, -2.50315040e-01f, 9.24198925e-02f, -3.26970220e-01f, -7.84997821e-01f, -2.19164878e-01f, -5.13097167e-01f, 1.58489674e-01f,
  4.23849374e-02f, 5.34644350e-02f, -3.21799070e-01f, -6.45622984e-02f, 5.81665663e-03f, -1.41327336e-01f, -1.21373661e-01f, -1.46604657e-01f, -8.07608888e-02f, 1.05897620e-01f,
  -2.02801585e-01f, -4.37835380e-02f, -2.08974145e-02f, 7.19339326e-02f, 2.86390334e-01f, 5.35350293e-04f, 1.62971318e-01f, 1.41561300e-01f, -3.92205119e-02f, 1.07563376e-01f,
  9.15130600e-02f, 9.12845805e-02f, 2.22730525e-02f, 6.36471361e-02f, -5.26655763e-02f, -5.03087183e-03f, -3.10443416e-02f, -4.81007174e-02f, 7.21703991e-02f, 1.52028561e-01f,
  1.52781010e-02f, -3.99626940e-02f, 3.28404568e-02f, -1.03905603e-01f, 1.97691530e-01f, 5.60661815e-02f, -1.42405063e-01f, -1.11124493e-01f, 1.15205050e-02f, -1.06910013e-01f,
  8.99517760e-02f, 6.89075142e-02f, 3.30512635e-02f, -8.22601616e-02f, 1.02523260e-01f, 9.31667909e-02f, -5.34785204e-02f, -4.99630012e-02f, 1.03049025e-01f, 7.18015432e-02f,
  8.29303935e-02f, 1.51213899e-01f, -1.19785354e-01f, 1.98491123e-02f, 1.46091953e-02f, -4.12536226e-02f, 2.18574796e-02f, 1.15937486e-01f, 1.04657091e-01f, -1.41725928e-01f,
  4.38359678e-01f, 4.00822759e-01f, -6.44931942e-02f, -6.09131828e-02f, -1.18558846e-01f, 2.00857595e-03f, 2.52741817e-02f, 1.94614574e-01f, 6.78573251e-02f, 1.35977581e-01f,
  3.54323573e-02f, -6.05328754e-03f, -2.34830175e-02f, -8.62540901e-02f, -2.15664059e-02f, 2.25315213e-01f, -2.45524496e-01f, 2.87596658e-02f, -6.41356111e-02f, -1.38201639e-01f,
  -1.99309826e-01f, 4.39824350e-02f, -1.36328131e-01f, 1.38921410e-01f, -5.40674552e-02f, -3.29659909e-01f, 1.07389040e-01f, -7.26580918e-02f, -7.62398094e-02f, -1.93642806e-02f,
  -7.02222943e-01f, -3.18788528e-01f, -3.00534666e-01f, -3.56304854e-01f, -1.16898231e-01f, 7.17916250e-01f, -1.26622364e-01f, -6.87470138e-02f, -8.17491770e-01f, 3.27830702e-01f,
  2.70611823e-01f, -7.28521645e-01f, -3.55734117e-02f, -7.01577589e-02f, -1.56430259e-01f, -8.22237357e-02f, 4.93741423e-01f, 2.25849435e-01f, -2.52203882e-01f, 4.19079512e-01f,
  1.55355647e-01f, 4.95221525e-01f, 3.55994910e-01f, 5.59277117e-01f, 3.01676661e-01f, 2.81676620e-01f, 9.02195930e-01f, 1.90137282e-01f, 5.47250032e-01f, -1.00625768e-01f,
  6.30165543e-03f, -1.65414378e-01f, -1.20003387e-01f, -2.21876562e-01f, 3.81704658e-01f, 2.15873316e-01f, 2.84374118e-01f, -1.39058828e-01f, -1.56168774e-01f, -6.37028739e-02f,
  -1.28493592e-01f, -1.64107785e-01f, -7.39658177e-02f, -1.25012487e-01f, -1.82905704e-01f, -7.61639625e-02f, -9.13199484e-02f, -2.95559666e-03f, -1.77692652e-01f, -1.23566933e-01f,
  -7.08342483e-03f, -6.80308864e-02f, 2.84067187e-02f, -3.37763950e-02f, -6.89713433e-02f, -1.16421476e-01f, 7.02336952e-02f, 1.16030023e-01f, -3.52945030e-02f, -1.14621654e-01f,
  3.75866331e-02f, 3.29422615e-02f, 1.54507279e-01f, -1.48174554e-01f, -4.59555276e-02f, 5.15159853e-02f, -1.96094200e-01f, -1.43714342e-02f, -1.60682052e-01f, 9.31687206e-02f,
  -4.32739519e-02f, -1.30759403e-01f, -9.53163579e-02f, 1.54336795e-01f, 8.12067091e-02f, -5.53543717e-02f, 1.28363939e-02f, 7.66425431e-02f, 1.96654692e-01f, 1.23899028e-01f,
  -1.45147428e-01f, -5.85114816e-03f, 1.43605053e-01f, 2.56920233e-02f, -1.91535339e-01f, 2.62737218e-02f, -8.99449661e-02f, 5.70499972e-02f, 1.23688668e-01f, 1.32290319e-01f,
  2.66111374e-01f, 4.54081327e-01f, -9.29886550e-02f, -1.05218977e-01f, -4.28655334e-02f, 5.54482266e-02f, -1.42635375e-01f, 6.35826215e-02f, 1.41721308e-01f, 2.95907934e-03f,
  2.92363703e-01f, 1.71802014e-01f, 1.69130862e-01f, -3.33180092e-03f, 6.15053736e-02f, 1.97626770e-01f, 2.05553442e-01f, -1.14756107e-01f, 1.26027822e-01f, 3.05941731e-01f,
  1.05359450e-01f, 1.85460210e-01f, -1.02072403e-01f, 6.44279048e-02f, 1.08949162e-01f, 2.34181345e-01f, 6.61421120e-02f, -9.82297584e-03f, 2.80742925e-02f, -2.07900554e-02f,
  1.19501925e+00f, -8.49396408e-01f, -1.08928263e-01f, 5.78437388e-01f, 4.12957609e-01f, 4.13106263e-01f, 8.16718340e-01f, -2.05066830e-01f, -1.61042288e-01f, -5.79273760e-01f,
  2.84043312e-01f, -2.11824521e-01f, -2.30410293e-01f, 1.32292122e-01f, 7.47444272e-01f, -3.82359385e-01f, 1.96458280e-01f, 2.32480630e-01f, -2.63172835e-01f, 3.66225280e-02f,
  2.49233752e-01f, 1.45318449e-01f, 1.56998411e-02f, -5.44464409e-01f, 4.41979975e-01f, -1.49614722e-01f, -1.23290233e-02f, -2.41342187e-01f, -3.01344573e-01f, 1.67036504e-01f,
  1.55729905e-01f, -4.96946871e-02f, 7.85295367e-02f, -1.29512176e-01f, -3.69845815e-02f, 1.54906809e-01f, 8.90427679e-02f, 1.51695028e-01f, 1.27823189e-01f, -1.17245167e-01f,
  1.51825428e-01f, -4.58314177e-03f, 4.34995331e-02f, 1.25280008e-01f, 1.07608579e-01f, 4.12863232e-02f, 1.94086861e-02f, -1.30533858e-03f, -5.37001751e-02f, 5.11186421e-02f,
  3.16271037e-02f, 2.56012287e-02f, 1.07198276e-01f, -2.08692774e-01f, -3.41205485e-02f, -1.35716116e-02f, -1.27427563e-01f, 3.34335770e-03f, -3.26980315e-02f, -1.58706710e-01f,
  -1.39849016e-03f, -2.59174518e-02f, 4.10402417e-02f, 1.28007442e-01f, 7.29735121e-02f, 1.18468918e-01f, 2.84352582e-02f, -4.35735583e-02f, 2.52428744e-02f, -3.55842710e-02f,
  8.24234858e-02f, 1.33172944e-01f, -8.11331719e-02f, -1.23596182e-02f, 8.70426819e-02f, 9.13205966e-02f, 1.51341304e-01f, -1.19086735e-01f, -8.22390765e-02f, 1.19529940e-01f,
  1.19019829e-01f, -5.01593165e-02f, -8.01722184e-02f, 5.88900484e-02f, -1.05343081e-01f, -2.31788874e-01f, -2.19816014e-01f, -6.54236078e-02f, -2.27329694e-02f, 2.51319945e-01f,
  -2.30481103e-01f, -8.75191331e-01f, -1.97965428e-01f, -1.53112784e-01f, -2.00980082e-01f, 7.55188055e-03f, 8.65539815e-03f, -1.83815826e-02f, -2.67699957e-01f, 7.10558966e-02f,
  2.12413236e-03f, 2.52207190e-01f, -1.17721863e-01f, 7.49203712e-02f, 3.36041301e-02f, -1.49672478e-01f, -3.17001753e-02f, -7.17723221e-02f, 7.90559947e-02f, -1.57354623e-01f,
  3.04428115e-02f, 5.82629517e-02f, 1.89804569e-01f, 1.13262251e-01f, -1.56843647e-01f, -1.66103840e-02f, -1.36317566e-01f, -1.39202764e-02f, -1.63917262e-02f, -6.37070313e-02f,
  -1.58464754e+00f, -4.94490191e-02f, 5.56337655e-01f, -7.49755144e-01f, -3.21144313e-01f, 5.46957970e-01f, 4.74071711e-01f, -3.48883510e-01f, -5.95754921e-01f, 6.97146356e-02f,
  -7.62357237e-03f, -2.48327211e-01f, 7.30301976e-01f, -1.85442880e-01f, 6.98522389e-01f, 6.26629710e-01f, 1.84609517e-02f, 1.49239242e-01f, -1.42561764e-01f, -4.80645508e-01f,
  -1.10258833e-01f, -2.07815364e-01f, 6.25236273e-01f, -2.53816873e-01f, -5.25137305e-01f, -4.94580299e-01f, -1.61825046e-01f, 2.98581362e-01f, -1.53170973e-01f, 1.41413689e-01f,
  -7.54231989e-01f, -7.14881539e-01f, -2.02622995e-01f, 7.95482695e-02f, -8.25974494e-02f, 7.93826580e-02f, 2.09122777e-01f, 3.54789168e-01f, -1.14368901e-01f, -4.89244573e-02f,
  4.33677509e-02f, 1.05314469e-02f, -2.89514035e-01f, 1.73761830e-01f, -2.69986182e-01f, -1.70413345e-01f, -9.67243537e-02f, -5.40285110e-02f, -2.21063592e-03f, -2.76368018e-02f,
  1.01888224e-01f, -1.17618747e-01f, -1.05040185e-01f, -5.53744398e-02f, 1.16097733e-01f, -9.24802125e-02f, 9.09943357e-02f, 4.60541956e-02f, -1.03795692e-01f, -2.11483657e-01f,
  1.89814806e-01f, 6.75748661e-02f, -1.80208609e-01f, -6.07326590e-02f, 1.64055228e-01f, -4.25964743e-02f, 3.98762105e-03f, 1.03590049e-01f, 2.01431080e-03f, 5.85149676e-02f,
  -3.42667773e-02f, -4.80636545e-02f, -1.71091571e-01f, -1.26111731e-02f, -5.09316251e-02f, -1.65237606e-01f, 1.14332050e-01f, -1.39486730e-01f, -8.12169388e-02f, -4.10256116e-03f,
  -4.83702123e-02f, 1.35135174e-01f, -1.15014330e-01f, 1.17991805e-01f, 1.06849991e-01f, -1.39826611e-02f, -1.69181809e-01f, -1.39057795e-02f, 8.71797837e-03f, 1.42381206e-01f,
  -8.14375758e-01f, -7.11181402e-01f, 2.79552322e-02f, -7.28673115e-02f, 1.19802924e-02f, -1.02546088e-01f, 7.55827948e-02f, -1.53648630e-01f, -8.01913068e-02f, -6.06124438e-02f,
  -4.91489656e-02f, 1.25633366e-02f, -1.22688480e-01f, 4.01948653e-02f, 1.93162888e-01f, -4.97955345e-02f, 2.89446878e-04f, -1.19827241e-01f, -6.52030483e-02f, -1.38876453e-01f,
  -1.57178193e-01f, 8.76961425e-02f, 2.28617385e-01f, -3.13899405e-02f, 1.10425249e-01f, -1.26374438e-01f, -3.03754568e-01f, -2.35746615e-02f, 1.06218997e-02f, 1.84163600e-01f,
  4.02987510e-01f, -6.11757636e-01f, 5.34783840e-01f, 2.81148374e-01f, 8.21914494e-01f, 3.32274288e-01f, 7.47211576e-01f, -4.00912985e-02f, 2.99550951e-01f, -6.05326593e-01f,
  -1.43330917e-01f, -1.27639979e-01f, 4.66848463e-01f, -3.60661745e-01f, 4.40951407e-01f, 2.07349211e-01f, -1.25327155e-01f, -1.09809518e-01f, 1.89739630e-01f, 1.06698103e-01f,
  1.09517567e-01f, -4.02418166e-01f, 3.07698816e-01f, -3.52921158e-01f, 3.42581362e-01f, -1.26794904e-01f, -2.15290591e-01f, 4.36127722e-01f, -7.16674149e-01f, 1.66882083e-01f,
  -6.28443137e-02f, 8.00572708e-02f, -3.64562087e-02f, -1.36045311e-02f, 6.76379204e-02f, 2.87666321e-01f, -4.78734188e-02f, 2.46057332e-01f, 2.55501390e-01f, 3.46212722e-02f,
  -4.41667289e-02f, 1.11372238e-02f, -1.65743217e-01f, 1.38399512e-01f, 8.65565911e-02f, -1.01808384e-01f, 7.33278617e-02f, -4.63086404e-02f, 1.29866615e-01f, 2.78768092e-01f,
  1.63697973e-01f, -1.15524694e-01f, 3.68979573e-02f, -2.83029601e-02f, 5.65548278e-02f, -3.03197447e-02f, 8.56610611e-02f, 1.94528088e-01f, -8.19002688e-02f, -8.69381242e-03f,
  -1.28888816e-01f, 1.61501288e-01f, 6.64633960e-02f, -1.65422469e-01f, 6.61986768e-02f, -4.57910597e-02f, -9.91774797e-02f, -1.74431428e-02f, -3.56147774e-02f, -4.35223877e-02f,
  -1.43493965e-01f, -3.16269584e-02f, 2.61751227e-02f, 1.34032458e-01f, -3.41350250e-02f, -3.26175503e-02f, 3.74361090e-02f, -3.71370353e-02f, -5.23160398e-02f, 6.84814379e-02f,
  -9.16475356e-02f, 2.25690994e-02f, 3.93946990e-02f, 1.93610579e-01f, -1.77138776e-03f, 1.14750683e-01f, -1.05258167e-01f, 2.12457627e-01f, 5.88540547e-02f, 1.92539226e-02f,
  -3.19157481e-01f, -7.41000652e-01f, -1.27029330e-01f, -3.74513045e-02f, -1.16770037e-01f, -3.37037146e-02f, -6.84009716e-02f, -7.65154809e-02f, -1.91131949e-01f, 8.55774060e-02f,
  -3.92364077e-02f, 1.97575931e-02f, -2.03875247e-02f, 9.70425159e-02f, -1.61667719e-01f, -1.02176435e-01f, 1.13501072e-01f, -1.89117983e-01f, -1.13802366e-01f, -1.70870036e-01f,
  3.85123305e-02f, -9.31625739e-02f, -6.65761158e-02f, -5.40299527e-02f, -9.73630548e-02f, 4.46031094e-02f, 1.51498979e-02f, -2.48692974e-01f, 1.93592355e-01f, 4.79470789e-02f,
  1.80652499e-01f, 2.06999928e-01f, -4.36904281e-01f, 3.17279637e-01f, -8.07906985e-01f, 8.76555920e-01f, 1.19044602e+00f, -3.82381737e-01f, 3.98102582e-01f, 6.88447893e-01f,
  4.92803901e-01f, 1.41141206e-01f, 5.37754416e-01f, 9.78926659e-01f, 1.34231240e-01f, 7.33928382e-01f, 7.24358380e-01f, 6.38498724e-01f, -1.13456666e-01f, 2.33384550e-01f,
  -7.51260668e-02f, 4.91498321e-01f, -1.43540338e-01f, -4.06077981e-01f, 1.95119694e-01f, -6.26227081e-01f, -3.93668205e-01f, -3.45452696e-01f, -1.10899776e-01f, -1.51835337e-01f,
  1.58102095e-01f, 6.36326447e-02f, -9.60879773e-02f, 2.82165147e-02f, -2.18965532e-03f, 2.11745761e-02f, -1.63518544e-02f, -1.47467971e-01f, -1.28268749e-01f, -4.03456157e-03f,
  1.16841823e-01f, -9.31355432e-02f, 4.53343615e-02f, -1.31358489e-01f, -2.14511342e-02f, -1.39711767e-01f, -7.06596896e-02f, 7.51935095e-02f, -4.35337760e-02f, -5.54880053e-02f,
  1.47095516e-01f, 5.22990003e-02f, 1.15537934e-01f, 1.80954784e-01f, -1.19604051e-01f, 9.66172293e-02f, 2.48331413e-01f, -4.66294994e-04f, 7.05797970e-02f, -1.41450418e-02f,
  -7.19711781e-02f, 1.36522159e-01f, 7.27137104e-02f, -8.80630240e-02f, -1.37194968e-03f, -1.51097625e-01f, 1.20322838e-01f, -1.53400572e-02f, -5.15594594e-02f, 5.59560247e-02f,
  -1.91570912e-02f, -6.12810142e-02f, 1.36580124e-01f, 1.22069068e-01f, 6.61008731e-02f, 1.60321053e-02f, -5.74601702e-02f, -3.87075134e-02f, 1.00524254e-01f, -1.06266581e-01f,
  -4.42384742e-02f, 1.18440367e-01f, 8.63438323e-02f, -3.37157249e-02f, 1.01328410e-01f, -1.37162656e-01f, 2.45988872e-02f, -1.23041794e-02f, 1.86870098e-02f, -1.26652598e-01f,
  1.57455012e-01f, 1.29379421e-01f, 7.98451230e-02f, 2.29112171e-02f, -3.14605571e-02f, -7.71880969e-02f, 1.08161934e-01f, -9.90463868e-02f, 2.60106511e-02f, -8.74208286e-02f,
  -1.60903513e-01f, -1.08054187e-02f, 2.47736741e-02f, -8.90671536e-02f, 4.61945124e-02f, 6.59934357e-02f, 2.77012855e-01f, -3.34898680e-02f, 1.07017122e-01f, -2.62664825e-01f,
  -1.74311608e-01f, 1.15877390e-01f, -1.42306015e-02f, -2.03721635e-02f, 9.19741839e-02f, -5.08604979e-04f, 3.63261416e-03f, -1.33105800e-01f, -2.30677038e-01f, 4.31284532e-02f,
  1.58570662e-01f, -1.59631997e-01f, -4.61874157e-01f, -7.27098942e-01f, -8.92481282e-02f, -2.83002526e-01f, -5.74927747e-01f, 4.45058122e-02f, -2.97112554e-01f, -7.78658316e-03f,
  -1.43870354e-01f, -4.84318733e-01f, 4.63690281e-01f, -7.30452299e-01f, -4.65998381e-01f, 2.31388912e-01f, -9.93856370e-01f, -7.32997239e-01f, 1.68086424e-01f, -6.02060199e-01f,
  -1.80500537e-01f, -1.59193888e-01f, -2.89760679e-01f, 3.66926819e-01f, -3.83354872e-01f, 4.24051750e-03f, 2.62202621e-01f, 2.34109715e-01f, -4.39438164e-01f, -1.41195029e-01f,
  -7.19171241e-02f, 1.22371867e-01f, 7.26980492e-02f, 9.40397605e-02f, 9.51762199e-02f, 1.95157900e-01f, -1.46060705e-01f, 3.88080627e-02f, 3.31878699e-02f, -1.28222436e-01f,
  -6.49024323e-02f, -9.75988656e-02f, -4.83497977e-02f, 3.51329774e-01f, 7.99208656e-02f, 2.53050569e-02f, -4.77758162e-02f, -1.20465793e-01f, -3.73330474e-01f, 1.85402539e-02f,
  -2.29269043e-01f, -2.00774148e-02f, -3.53691876e-02f, -2.47578666e-01f, -1.00920402e-01f, -3.65067720e-02f, -2.07411826e-01f, -2.35353366e-01f, -3.02683767e-02f, 3.79192792e-02f,
  1.68498203e-01f, 4.46001366e-02f, 1.61293820e-01f, 1.90200239e-01f, -7.66404420e-02f, -6.80587888e-02f, -4.34125923e-02f, 1.12050967e-02f, 3.15957740e-02f, -7.30486736e-02f,
  -5.39264083e-02f, -7.35033602e-02f, 1.85559034e-01f, -2.24739909e-02f, -1.18008137e-01f, 3.94404791e-02f, 3.61864567e-02f, 2.34555770e-02f, -2.73878694e-01f, -7.16205984e-02f,
  -6.92652836e-02f, -3.74554880e-02f, 6.36951774e-02f, -4.81486879e-02f, -1.42551377e-01f, 1.09922634e-02f, 1.13973580e-01f, -1.63641751e-01f, 3.32900882e-02f, -1.40237898e-01f,
  -1.45045638e-01f, -3.22031556e-03f, -1.41431898e-01f, -2.00167730e-01f, -1.48255080e-01f, 1.12974063e-01f, -8.76797270e-03f, -1.11487828e-01f, -1.36302218e-01f, 4.61805752e-03f,
  -1.38879921e-02f, -1.32735074e-01f, 1.88563159e-03f, 1.21433266e-01f, -1.52142629e-01f, 1.16292229e-02f, -2.01040387e-01f, -1.75368525e-02f, -1.71641558e-01f, 1.67618886e-01f,
  -1.55613363e-01f, 4.48627993e-02f, 3.61458920e-02f, -8.78748447e-02f, -1.35292128e-01f, 4.21588123e-03f, 9.92659181e-02f, -1.10597443e-02f, -9.42552835e-02f, -2.45087937e-01f,
  6.29060507e-01f, 3.42020571e-01f, 6.65010929e-01f, 8.61943424e-01f, -2.05853283e-01f, -8.02933097e-01f, -3.05142075e-01f, 1.55005723e-01f, 7.27968037e-01f, -4.67226475e-01f,
  -4.23679292e-01f, 6.18690014e-01f, -8.54446352e-01f, 4.47830886e-01f, -1.68733388e-01f, -6.91638291e-01f, 5.19959748e-01f, -2.38265861e-02f, 2.10897893e-01f, 3.65168124e-01f,
  6.33292258e-01f, -3.36663902e-01f, 3.94711673e-01f, -2.14086190e-01f, 2.76657611e-01f, 6.38000965e-01f, -1.11253552e-01f, -3.41292411e-01f, 3.60074580e-01f, -3.69741112e-01f,
  -4.46571335e-02f, 3.15751642e-01f, 2.53378510e-01f, 3.60469334e-02f, 1.06386773e-01f, -1.92094166e-02f, -1.36077553e-01f, -2.50631124e-01f, -9.13980976e-02f, -8.19208920e-02f,
  4.50030575e-03f, -2.63409130e-03f, 1.71722531e-01f, -5.84314875e-02f, 1.95306182e-01f, 2.24359170e-01f, 1.98174432e-01f, 1.04200758e-01f, 1.68484524e-01f, 4.54713814e-02f,
  2.56196529e-01f, 1.90680131e-01f, 2.33073458e-01f, 8.46083984e-02f, 1.67614326e-01f, 1.56835377e-01f, -1.55911064e-02f, 6.19465262e-02f, 8.06504264e-02f, 2.01293245e-01f,
  -7.23725744e-03f, -1.60178304e-01f, -1.66969642e-01f, 3.91849354e-02f, -1.14364006e-01f, 9.12143886e-02f, -5.25847524e-02f, -5.00875711e-02f, -7.17090443e-02f, -2.74409726e-02f,
  -3.43900993e-02f, 1.60588786e-01f, -2.79627126e-02f, 1.54020600e-02f, 9.02255401e-02f, 2.12628096e-01f, -7.17825964e-02f, -1.87894881e-01f, 2.37284556e-01f, 2.09924635e-02f,
  -3.41924168e-02f, -9.06232893e-02f, -1.16933532e-01f, -7.46726943e-03f, -2.04109028e-01f, -1.79444298e-01f, 1.19138047e-01f, 8.41398239e-02f, 4.34285104e-02f, -1.07479848e-01f,
  -8.76390263e-02f, 1.67338386e-01f, 6.86027110e-02f, -6.37385920e-02f, -2.33449116e-02f, -5.48006818e-02f, 7.58347064e-02f, 1.90534219e-01f, 1.02571018e-01f, -5.08547574e-02f,
  -5.86367249e-02f, 3.76381236e-03f, -1.23417526e-01f, -1.51802907e-02f, -4.35761921e-03f, -1.27739683e-02f, -1.46157276e-02f, -1.23959016e-02f, 1.06893145e-01f, 9.06114951e-02f,
  -5.56028336e-02f, -2.60147661e-01f, 1.83085606e-01f, 1.77687600e-01f, 3.80338542e-02f, 1.11240812e-01f, 1.33172022e-02f, 2.88632251e-02f, -1.70658920e-02f, 9.19235423e-02f,
  -1.38059402e+00f, 1.16120374e+00f, 2.08487406e-01f, -2.35543296e-01f, 2.00732276e-02f, -6.92548454e-01f, -3.59045774e-01f, 5.23812413e-01f, -1.33178189e-01f, 1.01528496e-01f,
  3.70541960e-01f, -2.52606198e-02f, 9.14105713e-01f, 3.44292760e-01f, -1.71987385e-01f, 4.90222871e-01f, -3.28834713e-01f, -2.06783831e-01f, 2.05178618e-01f, 3.04057658e-01f,
  6.33809424e-04f, 5.02074420e-01f, 4.63055521e-01f, 7.25541949e-01f, 1.74722269e-01f, 1.27536789e-01f, 8.26955736e-02f, 4.60357934e-01f, -2.12206230e-01f, -8.06429982e-02f,
  -4.54342186e-01f, 3.65976214e-01f, 9.36461389e-02f, -2.21589953e-01f, -3.03712040e-01f, -3.00921768e-01f, -3.07849646e-01f, 2.85222731e-03f, -4.74755578e-02f, -6.16396591e-02f,
  -1.39207095e-01f, 2.41120875e-01f, -1.07416138e-01f, 1.36755124e-01f, -1.53332695e-01f, 6.56925067e-02f, 1.82868168e-01f, -1.33614257e-01f, 3.54791969e-01f, 7.11442083e-02f,
  2.25588575e-01f, 2.95702219e-02f, -1.32183090e-01f, 3.34908976e-03f, 1.23995729e-01f, 2.63286773e-02f, -1.43512368e-01f, -1.70278192e-01f, -4.20236886e-02f, -2.06607252e-01f,
  -6.67158375e-03f, -7.99740553e-02f, 8.12434331e-02f, -6.04218729e-02f, 4.98232357e-02f, 1.23357080e-01f, 8.49683881e-02f, -1.00659177e-01f, -1.95977062e-01f, 4.23390456e-02f,
  -1.28663644e-01f, -7.59334043e-02f, 1.25129864e-01f, -1.81882903e-01f, -6.97411969e-02f, 2.26251855e-02f, -7.53121153e-02f, 2.11749747e-02f, -1.21843770e-01f, -2.20669955e-02f,
  1.26050740e-01f, -1.20586015e-01f, 6.56134039e-02f, -9.16959271e-02f, 3.20291035e-02f, 2.74042208e-02f, 3.08182798e-02f, 5.79483807e-02f, -2.34267816e-01f, 1.40230767e-02f,
  -5.54053426e-01f, 2.50290483e-01f, 7.25946650e-02f, -3.33108269e-02f, -7.61890113e-02f, -1.30104914e-01f, 4.40647230e-02f, -3.68445851e-02f, -9.91290063e-02f, -1.24296457e-01f,
  -2.11633682e-01f, -1.83439285e-01f, -1.50872737e-01f, -4.24003564e-02f, 5.07818675e-03f, 1.07235108e-02f, -6.57908479e-03f, -7.18190596e-02f, -1.56988785e-01f, -1.36352345e-01f,
  7.13354945e-02f, 4.79757003e-02f, -4.43666354e-02f, 2.94064786e-02f, -1.00079544e-01f, -1.61660105e-01f, -7.18720108e-02f, 1.29168257e-01f, 3.30812088e-03f, 1.57868490e-01f,
  -8.06230903e-01f, 1.74392536e-01f, -9.25665855e-01f, -5.53270280e-01f, 3.57669502e-01f, -7.12382853e-01f, -2.74046332e-01f, -1.29979014e-01f, -9.31481570e-02f, 5.94562173e-01f,
  2.26147085e-01f, -3.97673070e-01f, 2.99845248e-01f, -6.75840676e-01f, -8.71482074e-01f, -4.65443015e-01f, -8.25933695e-01f, -4.33809012e-01f, -1.70110732e-01f, -4.47654396e-01f,
  -5.08376360e-01f, 5.80324442e-04f, -5.73758841e-01f, 4.90080982e-01f, -2.07573235e-01f, 3.82223845e-01f, 5.25644124e-01f, 3.92869234e-01f, -1.88547164e-01f, -1.43195674e-01f,
  -4.47598279e-01f, 6.34172261e-02f, 1.51472121e-01f, -1.89736217e-01f, -2.12858230e-01f, 1.25136361e-01f, -2.35354975e-02f, 1.09661352e-02f, -6.12908863e-02f, -2.10621074e-01f,
  1.11802295e-01f, 1.52193801e-02f, -9.50964540e-02f, 4.79594730e-02f, 1.04051150e-01f, -8.68330523e-03f, -1.63962826e-01f, -7.99136832e-02f, -1.34098586e-02f, -1.76896483e-01f,
  -2.83759952e-01f, -1.77311763e-01f, -9.85404402e-02f, 3.18985432e-02f, -1.34786621e-01f, -3.71641815e-02f, -1.28400713e-01f, 5.79258353e-02f, -2.25562602e-01f, -1.44868448e-01f,
  -3.38062420e-02f, 7.74266869e-02f, -1.34866089e-01f, -1.04491860e-01f, -1.65112372e-02f, 4.92692105e-02f, -1.59774497e-02f, 9.64272469e-02f, 1.42514691e-01f, 7.39655830e-03f,
  -1.66877341e-02f, 7.73982797e-03f, 6.83927238e-02f, -8.58159810e-02f, 4.69253473e-02f, 4.75022122e-02f, 3.78083922e-02f, 4.56781834e-02f, -2.72533186e-02f, -3.90571877e-02f,
  1.18115537e-01f, -9.59612951e-02f, 3.96569483e-02f, 1.14371195e-01f, -1.86587170e-01f, 2.09027622e-02f, 8.08957294e-02f, -6.81646019e-02f, 4.37878259e-02f, -6.52029291e-02f,
  -2.43412331e-01f, -1.13087319e-01f, 4.66636792e-02f, 1.63713530e-01f, 1.15745455e-01f, -3.56697291e-02f, -1.02980867e-01f, -1.87407568e-01f, -1.56839326e-01f, 2.05437243e-02f,
  5.46549112e-02f, 9.99940336e-02f, -4.22548093e-02f, -7.24152401e-02f, -6.85293376e-02f, -4.72170822e-02f, 9.16308314e-02f, 3.38402316e-02f, 1.99797060e-02f, -2.94487569e-02f,
  1.97607905e-01f, 1.63435936e-01f, 4.59207669e-02f, 9.91833881e-02f, 1.97016984e-01f, -3.66584249e-02f, 9.32093486e-02f, 2.14934163e-02f, 7.07672760e-02f, 2.88991276e-02f,
  -6.59698367e-01f, 6.17348135e-01f, 4.83259559e-01f, -6.58541620e-01f, 1.68970034e-01f, 7.00778723e-01f, -4.52562034e-01f, 3.38455200e-01f, -4.25519466e-01f, 2.91196704e-01f,
  -4.81687099e-01f, 2.36195505e-01f, -4.97625381e-01f, -3.00090313e-01f, -9.42925155e-01f, -6.27659738e-01f, -3.41949701e-01f, -3.16405654e-01f, -2.43216142e-01f, -3.06009185e-02f,
  -2.45536968e-01f, -6.02362394e-01f, -7.24219903e-02f, 2.91644156e-01f, 4.92198080e-01f, 4.05000687e-01f, -3.57496679e-01f, 2.19918832e-01f, 2.79627442e-01f, 5.08456901e-02f,
  1.25605762e-01f, -3.33017200e-01f, 2.33614624e-01f, 2.17477039e-01f, 4.03879024e-02f, 1.73639223e-01f, 1.04503304e-01f, -9.71109867e-02f, -1.67024627e-01f, 1.59066040e-02f,
  7.59597570e-02f, 1.25731260e-01f, 4.49109897e-02f, -1.14588045e-01f, 1.06206037e-01f, 1.30574226e-01f, 1.97432771e-01f, 2.13467583e-01f, 2.26997390e-01f, 1.40257418e-01f,
  1.04385838e-01f, 3.01453322e-01f, 1.47423878e-01f, -1.36675732e-02f, -3.46448049e-02f, -1.42548950e-02f, -1.06295291e-03f, 1.47145048e-01f, 1.56391427e-01f, 7.72279128e-03f,
  -6.87282234e-02f, -6.07754961e-02f, 2.29675863e-02f, -5.09237964e-03f, -1.29460156e-01f, 7.07072318e-02f, -5.62311187e-02f, -6.94618747e-02f, -2.78785489e-02f, 9.00610536e-02f,
  -9.19471830e-02f, 4.75425608e-02f, -1.39011592e-01f, 6.82782382e-02f, -9.70497280e-02f, -2.33968385e-02f, 2.58590039e-02f, -1.90348193e-01f, -2.52530389e-02f, 1.70089845e-02f,
  -2.96953768e-01f, -1.13501370e-01f, -1.98329419e-01f, 1.20678969e-01f, 3.31277624e-02f, -3.54175083e-02f, 1.02880083e-01f, 2.12844253e-01f, -7.26041384e-03f, -1.08296074e-01f,
  -7.10818097e-02f, -4.98668045e-01f, -1.32983640e-01f, 5.83691671e-02f, -1.36066347e-01f, 9.03638303e-02f, -9.41046551e-02f, 2.37089798e-01f, 2.49974225e-02f, -6.87288269e-02f,
  1.30057082e-01f, -7.72940293e-02f, 2.37940520e-01f, -7.63013735e-02f, -5.35297655e-02f, -8.43146592e-02f, -1.80659816e-01f, -1.93718728e-02f, 3.91624756e-02f, -4.24177386e-02f,
  1.69235364e-01f, -1.77989230e-01f, -1.48281008e-01f, 9.04298737e-04f, 3.59861925e-02f, -3.26026380e-02f, -3.65701295e-03f, 5.86008579e-02f, 3.63470353e-02f, 4.13263664e-02f,
  4.44848359e-01f, 2.03456376e-02f, -5.73532403e-01f, -4.86424357e-01f, -3.29204530e-01f, 1.42856300e-01f, -3.88638079e-01f, -2.13225082e-01f, -2.17249338e-02f, 2.19532415e-01f,
  -5.05012989e-01f, 1.33157149e-01f, 4.46942925e-01f, -5.43366611e-01f, 4.23827201e-01f, 4.91567522e-01f, 4.60570259e-03f, -6.89788684e-02f, -2.11009458e-01f, 2.17565909e-01f,
  -1.18655920e-01f, -2.95329038e-02f, -3.89677852e-01f, -4.65025119e-02f, -2.52558142e-01f, -3.19491148e-01f, 1.64430454e-01f, -4.62682188e-01f, -5.22813797e-01f, -4.05285090e-01f,
  -2.94798881e-01f, -6.53853118e-02f, -1.93615541e-01f, 2.37526484e-02f, 8.75887051e-02f, 1.31751612e-01f, -8.97328407e-02f, -4.20425273e-02f, -2.06633911e-01f, 6.88591599e-02f,
  4.37431991e-01f, 1.28790975e-01f, -1.24222608e-02f, 6.48819953e-02f, 8.76376126e-03f, -3.98263335e-02f, 1.80912588e-03f, -1.58119470e-01f, -4.50746827e-02f, 8.99540354e-03f,
  -7.62544721e-02f, -3.96756120e-02f, -1.13424860e-01f, 1.85032487e-01f, 7.97404535e-03f, -4.67977487e-02f, 1.19977161e-01f, 1.54683858e-01f, 1.10905819e-01f, 1.81397155e-01f,
  8.49576741e-02f, 2.09104866e-01f, -3.36116515e-02f, -1.61472037e-01f, -1.48719609e-01f, -1.79188743e-01f, -8.31868127e-03f, -6.43345565e-02f, -5.11640646e-02f, 1.38078565e-02f,
  3.28368656e-02f, -1.87510744e-01f, 2.04938632e-02f, 2.06730947e-01f, 7.58677721e-04f, 1.99247897e-01f, -1.14754014e-01f, -3.22437584e-02f, -6.20550811e-02f, -9.67449173e-02f,
  -1.22294113e-01f, 1.00741833e-01f, -1.52655423e-01f, -8.75694901e-02f, -1.41854286e-01f, -8.82634968e-02f, 1.68805808e-01f, 5.91114759e-02f, -2.13562548e-01f, 2.18156546e-01f,
  6.84907436e-02f, 5.84712565e-01f, -1.48463652e-01f, -6.77746758e-02f, 3.91681753e-02f, 1.41693264e-01f, 7.57746398e-02f, -5.33985049e-02f, 1.62306219e-01f, 2.04211131e-01f,
  1.73340201e-01f, -1.32928252e-01f, 1.92530558e-01f, -2.38962639e-02f, -3.12196016e-02f, 6.62162900e-03f, 2.55693942e-01f, 1.43651769e-01f, 2.97727704e-01f, 7.28602149e-03f,
  1.71697229e-01f, 1.98560804e-01f, 4.59024191e-01f, 5.12579717e-02f, 1.79161683e-01f, 9.61165801e-02f, 6.85767680e-02f, -7.25905746e-02f, 3.08945656e-01f, 1.25408977e-01f,
  5.64056218e-01f, -4.29157525e-01f, -6.64395154e-01f, 8.77093226e-02f, 3.06892663e-01f, 5.23512244e-01f, 1.93181917e-01f, -7.38707334e-02f, -3.95252496e-01f, -1.43831775e-01f,
  7.77487680e-02f, 2.63912916e-01f, -6.09260142e-01f, 6.84371889e-01f, 1.09975958e+00f, -4.45005715e-01f, 6.13809049e-01f, 5.27575493e-01f, -2.00327069e-01f, 4.95013930e-02f,
  1.04105398e-02f, 7.69787014e-01f, -9.71838459e-02f, 4.61731672e-01f, 4.62166756e-01f, -4.47484553e-02f, 4.85102683e-01f, 4.67706956e-02f, 9.02121484e-01f, 7.58024395e-01f,
  1.02969714e-01f, -3.97570357e-02f, -1.12014301e-01f, -3.69140729e-02f, -6.46675527e-02f, 2.36977506e-02f, 1.44277930e-01f, 4.13480997e-01f, -9.24123079e-02f, -6.96799234e-02f,
  8.70402828e-02f, 2.69878745e-01f, 1.91923484e-01f, -1.91428382e-02f, -3.68886767e-03f, 6.27296939e-02f, -1.21043965e-01f, -3.03708106e-01f, -9.52761993e-02f, 3.32320668e-02f,
  -2.45503753e-01f, -2.05244213e-01f, -1.06246948e-01f, 4.64861840e-02f, -5.08099347e-02f, 1.50074661e-02f, 5.13206646e-02f, -3.02837435e-02f, 2.19268315e-02f, 1.10488757e-01f,
  1.26329765e-01f, -3.44850831e-02f, -1.73285529e-01f, -6.04169331e-02f, -2.33446267e-02f, -6.07275218e-02f, -2.34053712e-02f, 2.61426046e-02f, -6.26580417e-02f, -7.60883093e-02f,
  -6.32772297e-02f, 1.21187903e-01f, 4.01746929e-02f, -1.59701928e-02f, -3.80933098e-02f, -1.66699260e-01f, 3.70980687e-02f, 2.39718601e-01f, -1.73009440e-01f, -3.28487977e-02f,
  -3.31199989e-02f, 1.83106393e-01f, -1.08421966e-01f, -3.80360410e-02f, 1.39350101e-01f, -2.82126628e-02f, 1.78414360e-01f, 2.78862175e-02f, -1.69123277e-01f, -1.91315003e-02f,
  -9.04052556e-02f, 1.28655970e-01f, -9.87529457e-02f, -2.39353683e-02f, 1.40561655e-01f, 2.44812652e-01f, -6.96803033e-02f, 1.55323699e-01f, 1.41936764e-01f, -3.51788886e-02f,
  1.70037523e-01f, -1.11091033e-01f, -6.67376146e-02f, 7.23552182e-02f, 6.02233373e-02f, -1.59823499e-03f, -3.23700458e-02f, 1.16692679e-02f, 1.45697579e-01f, 8.13453570e-02f,
  7.58736283e-02f, 2.59321816e-02f, 5.91174811e-02f, -1.86747789e-01f, 1.98191851e-01f, -5.76469265e-02f, 1.94827050e-01f, -2.27347776e-01f, 7.78837949e-02f, 1.02217868e-03f,
  6.21633269e-02f, 3.95096503e-02f, 6.09956145e-01f, -3.00734311e-01f, -2.44405702e-01f, -1.50656790e-01f, -1.23490781e-01f, -4.95308608e-01f, -3.46842408e-01f, -2.17197016e-01f,
  -3.24260056e-01f, 4.55068111e-01f, 2.94593126e-01f, -2.42449418e-01f, 4.08105493e-01f, 2.39005983e-01f, -3.31156284e-01f, 8.64030421e-03f, -9.27750468e-02f, -4.77477908e-01f,
  -1.98813558e-01f, -7.23328650e-01f, 3.59264940e-01f, -8.86736512e-01f, -1.40213907e-01f, -1.09562017e-01f, -1.86141819e-01f, -7.36501217e-02f, -3.28496903e-01f, 1.17631234e-01f,
  5.08549102e-02f, -3.76153678e-01f, 1.08319119e-01f, -1.38305677e-02f, 1.28934090e-03f, 2.99869664e-02f, 1.27499700e-01f, 1.34920955e-01f, -8.10836107e-02f, 4.36735414e-02f,
  5.65119907e-02f, 3.92814167e-02f, -2.49370411e-01f, 1.69760268e-02f, -7.03763515e-02f, 9.08165723e-02f, 1.67906016e-01f, 2.11930171e-01f, -4.59580831e-02f, 3.35625380e-01f,
  1.54831871e-01f, 2.92715758e-01f, 1.33087486e-01f, 1.83784187e-01f, 6.65787756e-02f, -1.09016046e-01f, 2.56475866e-01f, 3.61859292e-01f, 8.76641367e-03f, -1.31338626e-01f,
  -9.59706530e-02f, -1.09606870e-01f, -5.42808473e-02f, 1.35811232e-02f, -1.23849921e-01f, -7.39361644e-02f, -5.59318177e-02f, 1.47061134e-02f, -3.19133103e-02f, -2.51010582e-02f,
  -1.44510910e-01f, -1.72353610e-02f, -6.38942719e-02f, -6.94542006e-02f, -9.07070488e-02f, -7.03449249e-02f, 1.77915052e-01f, -9.03153885e-03f, -2.64644120e-02f, 6.68183714e-02f,
  -4.83313613e-02f, -1.21385314e-01f, 3.96304503e-02f, -3.62015441e-02f, -2.02457190e-01f, 1.39870420e-01f, -6.38697818e-02f, 8.96845534e-02f, 1.96925290e-02f, -5.31563796e-02f,
  -3.10303509e-01f, -6.08157873e-01f, -1.82055265e-01f, 3.73384170e-02f, 3.19242738e-02f, 1.36780664e-01f, -2.60714948e-01f, -1.17049746e-01f, -1.17333643e-01f, -3.19380701e-01f,
  -1.40153542e-01f, 6.00021295e-02f, -7.06527382e-02f, -7.59824440e-02f, -1.01985499e-01f, -2.81646680e-02f, -1.59941792e-01f, -5.47374450e-02f, -1.44754857e-01f, 7.41867814e-03f,
  -5.11217266e-02f, -9.12118182e-02f, 7.14509189e-02f, -7.23169819e-02f, -5.16483299e-02f, -1.26996515e-02f, -1.26729161e-01f, -2.56995056e-02f, -1.86053361e-03f, -5.02480492e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.11970723e-01f, 7.65495718e-01f, 6.36271060e-01f, 6.58331633e-01f, 6.74147248e-01f, 6.92868948e-01f, 7.70264030e-01f, 9.22055304e-01f, 7.65173078e-01f, 7.58551478e-01f,
  1.00085437e+00f, 6.40582800e-01f, 5.66201687e-01f, 7.06175923e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.37111449e-01f, -9.42252815e-01f, 3.17712545e-01f, -1.87982038e-01f, -6.52836561e-01f, 1.46768212e-01f, -4.26160991e-01f, -7.49663234e-01f, -9.56865698e-02f, 7.22650051e-01f,
  6.61815345e-01f, 5.65685570e-01f, -6.02198958e-01f, 7.39638865e-01f, -1.13921367e-01f, 4.50084776e-01f, 6.20721355e-02f, 4.35533673e-01f, -2.92252451e-01f, 4.79276180e-01f,
  -6.05662763e-01f, 6.40954316e-01f, -9.77380097e-01f, 8.11225951e-01f, -7.80857027e-01f, -7.34189272e-01f, -6.03221245e-02f, 5.22803329e-02f, -8.27862918e-01f, -3.91437560e-01f,
  -9.13070202e-01f, 1.35340557e-01f, -3.48660946e-01f, 3.31390530e-01f, -6.48208288e-03f, 6.99154198e-01f, -3.45183611e-01f, 7.17230141e-01f, -3.49619418e-01f, -9.62578058e-01f,
  -5.12977876e-02f, 8.69445562e-01f, -8.91428113e-01f, -7.07326293e-01f, 2.46858701e-01f, 6.78153515e-01f, 1.01565576e+00f, 1.07377899e+00f, 2.18652114e-01f, -6.32079467e-02f,
  4.80751991e-01f, 1.17704615e-01f, 2.01869354e-01f, -1.37275398e+00f, -1.20863807e+00f, 4.53781784e-01f, 3.29162389e-01f, -1.11825788e+00f, -2.55890548e-01f, -9.92798626e-01f,
  -4.04908478e-01f, 2.93024957e-01f, 6.41869247e-01f, -5.03241181e-01f, 6.19728088e-01f, -2.86640704e-01f, -6.52823865e-01f, -5.88205993e-01f, -3.40537652e-02f, -5.88311076e-01f,
  4.27264683e-02f, 1.05320662e-01f, -3.68009537e-01f, 1.05014496e-01f, 6.17467538e-02f, -7.43480846e-02f, 6.61567628e-01f, 4.13612396e-01f, 4.03895348e-01f, -9.50535655e-01f,
  7.41186202e-01f, 6.35003984e-01f, -8.95995617e-01f, -8.25350285e-02f, 4.61151659e-01f, -2.29946509e-01f, -7.12602139e-01f, -5.15342832e-01f, -8.20889235e-01f, 7.63453171e-02f,
  -1.03886759e+00f, -1.19757973e-01f, 9.45003182e-02f, -9.75636840e-01f, 9.78581667e-01f, -8.80305946e-01f, 1.88030377e-02f, -1.31711125e-01f, -4.87678498e-01f, -7.31836796e-01f,
  -3.97456437e-01f, 1.26280293e-01f, -6.86302409e-02f, 2.76948124e-01f, 2.80348837e-01f, 5.02515445e-03f, 1.00437880e+00f, 5.72657406e-01f, -4.40581262e-01f, -4.19497520e-01f,
  1.02834180e-01f, 3.96718681e-01f, -5.07903218e-01f, -3.12430233e-01f, -6.54841304e-01f, -1.34210575e+00f, -6.06532037e-01f, -1.25542894e-01f, -2.31144458e-01f, -9.24181938e-01f,
  4.28918213e-01f, -7.71556437e-01f, 9.18819904e-01f, 8.67182493e-01f, 6.33890927e-02f, -5.22465110e-01f, -3.19191962e-01f, -9.21174347e-01f, 4.59727317e-01f, 2.19591290e-01f,
  -3.43876779e-01f, 3.41294616e-01f, 3.54882747e-01f, -2.63421655e-01f, 3.82934771e-02f, 3.68379295e-01f, 3.67690593e-01f, -6.76397979e-01f, 3.04082960e-01f, -5.90535849e-02f,
  2.70501822e-01f, 1.76806912e-01f, 2.14672834e-01f, -6.56080425e-01f, 8.19432199e-01f, 8.08344305e-01f, 4.07553226e-01f, 4.89531994e-01f, -1.36118793e+00f, 7.07372606e-01f,
  1.68230429e-01f, -8.91391516e-01f, 2.15244204e-01f, -9.01335835e-01f, 4.09366906e-01f, -8.57139409e-01f, 5.68398714e-01f, -3.65506172e-01f, -8.93393755e-01f, 3.39451373e-01f,
  6.33498430e-01f, 3.21728498e-01f, -1.70455724e-01f, 6.65625811e-01f, 5.67018092e-01f, -1.90475091e-01f, 3.29358846e-01f, 9.93396044e-01f, 3.36618930e-01f, -1.00411046e+00f,
  4.97677684e-01f, 8.62339437e-01f, -7.98746049e-01f, -8.50649655e-01f, -1.17654741e+00f, 3.85297477e-01f, 7.60229886e-01f, -1.77851230e-01f, 7.81484425e-01f, -8.14369082e-01f,
  -6.46070898e-01f, -1.14900425e-01f, -1.63624898e-01f, 5.65257251e-01f, -5.85900366e-01f, 2.00555891e-01f, -8.37022781e-01f, -8.30567062e-01f, -1.02615952e+00f, 5.99535406e-01f,
  -1.01272121e-01f, -6.60772741e-01f, -4.75221723e-02f, -1.18918255e-01f, -9.37907491e-03f, -5.65051913e-01f, -1.99263170e-01f, 1.47158787e-01f, -3.36469471e-01f, 2.93462574e-01f,
  -8.83003533e-01f, -1.83703303e-01f, -4.52222526e-02f, -7.20715046e-01f, 9.30879891e-01f, -3.44003230e-01f, 8.50079834e-01f, -6.54521048e-01f, -1.11518502e+00f, 4.99344319e-01f,
  4.53577697e-01f, -7.54225612e-01f, 5.45363724e-01f, -1.31110585e+00f, 6.01742983e-01f, 1.23633020e-01f, 1.75618738e-01f, 5.71689546e-01f, -5.84527314e-01f, -3.22440743e-01f,
  -6.05640769e-01f, -7.74747610e-01f, -6.49613798e-01f, -5.38315058e-01f, -5.72221994e-01f, -4.69491482e-01f, 1.80280387e-01f, 1.21904969e-01f, -2.74428427e-02f, -1.51749760e-01f,
  -1.23066120e-01f, -4.28975374e-01f, -5.91554224e-01f, -3.72865021e-01f, 3.45129102e-01f, 1.37527317e-01f, 6.03343844e-01f, -2.86463052e-01f, -4.07775134e-01f, -7.07464218e-01f,
  -2.41451606e-01f, -3.43843967e-01f, -4.53714162e-01f, -1.12547338e+00f, -9.07907784e-01f, 1.58676758e-01f, -3.82395864e-01f, -3.38689983e-01f, 4.87701505e-01f, -9.28141549e-02f,
  -6.81092024e-01f, 2.80904144e-01f, -9.76644874e-01f, 6.01292372e-01f, -4.50657785e-01f, 7.16689885e-01f, -4.40042496e-01f, 1.06599249e-01f, -2.10221827e-01f, 3.56762975e-01f,
  -5.72752655e-01f, -1.11340582e-01f, -4.14069861e-01f, 4.49186951e-01f, 2.98285991e-01f, 2.29210854e-01f, -2.68793494e-01f, -3.01773131e-01f, -6.46497190e-01f, 4.95963246e-01f,
  -5.66496193e-01f, -7.18217909e-01f, -1.54318571e-01f, -6.18782341e-01f, -5.61980009e-01f, 3.91695321e-01f, -8.68759215e-01f, -3.98664445e-01f, -4.35674429e-01f, -7.97560513e-01f,
  -3.03912371e-01f, 9.18749571e-01f, 6.99546278e-01f, -7.34024525e-01f, -1.17304993e+00f, 1.49363309e-01f, 4.80461903e-02f, -6.73986793e-01f, -2.75377817e-02f, 1.74072310e-01f,
  3.71302128e-01f, -4.34129298e-01f, 3.35427225e-02f, 2.58281767e-01f, -1.14636747e-02f, -3.58622447e-02f, 5.50182104e-01f, -5.19123495e-01f, -8.55716169e-02f, -2.83318728e-01f,
  2.27555498e-01f, -6.78892612e-01f, 6.11347891e-02f, -4.10254955e-01f, 1.82538196e-01f, -3.47230673e-01f, -8.43146503e-01f, -7.17862487e-01f, 5.79467595e-01f, 6.13356233e-01f,
  7.23074019e-01f, -1.05103187e-01f, -7.15186656e-01f, -1.09589446e+00f, -7.40018725e-01f, -3.87754202e-01f, -1.00791276e+00f, -9.18459147e-02f, 4.86765429e-02f, 6.48083627e-01f,
  6.74077645e-02f, 4.40623164e-02f, 9.74997580e-01f, 4.43873167e-01f, 2.59919703e-01f, -7.83347040e-02f, 4.93561029e-01f, 1.05551340e-01f, -1.37339771e-01f, 8.02640378e-01f,
  -9.45922196e-01f, -5.34435451e-01f, -6.96628988e-01f, -8.71025696e-02f, 6.25727057e-01f, 1.66185305e-01f, -3.16022336e-01f, -6.85444653e-01f, -4.42706525e-01f, 8.78522158e-01f,
  -8.50537360e-01f, -7.93493092e-01f, -3.61437291e-01f, -7.45218754e-01f, 7.31103495e-03f, -8.69087160e-01f, -9.20294940e-01f, 6.43336713e-01f, 5.50281465e-01f, 1.93930849e-01f,
  -3.61008704e-01f, -7.05409110e-01f, 1.47221804e-01f, 3.84425223e-01f, 1.44743666e-01f, -1.75018996e-01f, -1.98149979e-02f, -1.68326721e-01f, 4.37134087e-01f, -5.49545407e-01f,
  4.43390578e-01f, -4.16980237e-01f, -1.83218345e-01f, 5.91844559e-01f, -7.19489157e-01f, -6.54027879e-01f, -4.92703259e-01f, 6.33063972e-01f, -5.61708033e-01f, -4.54341769e-01f,
  -7.37560570e-01f, -7.22627282e-01f, -1.98652118e-01f, -8.58301699e-01f, -1.82946041e-01f, -3.14705253e-01f, -7.22990870e-01f, 8.54429603e-01f, -4.01507080e-01f, -3.65154505e-01f,
  8.17767859e-01f, -4.74623412e-01f, -5.39909124e-01f, 6.35321379e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.45673797e-01f, -4.90856469e-02f, 1.58537820e-01f, -2.54933596e-01f, 1.98656186e-01f, 2.39854619e-01f, 4.55055945e-02f, -1.20181486e-01f, 2.69774437e-01f, -2.38216847e-01f,
  -2.18871832e-01f, 9.75002870e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    