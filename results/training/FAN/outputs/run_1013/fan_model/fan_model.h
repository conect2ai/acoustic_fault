/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.28237331e-02f, 1.91493645e-01f, 4.57949460e-01f, -2.45180115e-01f, 1.17069505e-01f, 3.88351083e-01f, 5.05027533e-01f, 5.62168844e-02f, -1.82424963e-01f, -1.85296568e-03f,
  1.38214603e-01f, -2.00172499e-01f, -1.50954835e-02f, 8.90480205e-02f, 2.15966076e-01f, 2.69715071e-01f, 1.96288437e-01f, 1.36304960e-01f, 1.55064449e-01f, 3.64939310e-02f,
  -2.57575870e-01f, -3.24925721e-01f, -1.22947499e-01f, -1.11729108e-01f, -4.15823996e-01f, -1.99570611e-01f, 5.35550639e-02f, -9.58841369e-02f, 2.18756244e-01f, -1.89093560e-01f,
  2.11903632e-01f, 1.04201995e-01f, 1.56054661e-01f, -6.86065555e-02f, 4.40063924e-02f, 9.52079426e-03f, 5.04710004e-02f, -8.53655487e-02f, 3.42828035e-02f, -1.69254821e-02f,
  -3.55829336e-02f, -3.29920873e-02f, -3.94529030e-02f, -3.91155481e-02f, -4.75639664e-02f, -3.82575803e-02f, -1.35921225e-01f, -4.07232419e-02f, 8.40106234e-03f, 9.09548849e-02f,
  -8.45345762e-03f, 1.14386149e-01f, 2.20798716e-01f, 4.34277169e-02f, 3.74862365e-02f, 2.86577456e-02f, 2.52331998e-02f, 9.51124132e-02f, 1.63397446e-01f, -6.87878951e-02f,
  -5.98013029e-02f, -2.22349521e-02f, -1.93227977e-02f, -1.34395942e-01f, -1.25421152e-01f, -6.36567920e-02f, -2.73363981e-02f, -6.30111098e-02f, -3.07646208e-02f, -1.55893654e-01f,
  -4.10147309e-02f, -1.37571496e-05f, -7.56143918e-03f, -6.19814545e-02f, -5.05462736e-02f, -5.01656979e-02f, 3.46831195e-02f, -1.28914252e-01f, -4.03274484e-02f, -7.37777427e-02f,
  -7.31884763e-02f, -6.74829334e-02f, -1.43228367e-01f, -8.55905786e-02f, 1.50820212e-02f, -1.70640275e-02f, -6.88967556e-02f, -1.74398512e-01f, -1.52372167e-01f, -9.48990807e-02f,
  -2.00771108e-01f, 3.00324738e-01f, 9.42424536e-02f, 7.40869343e-02f, 2.48428974e-02f, 5.77076077e-02f, -6.97641727e-03f, 8.30991790e-02f, 1.12136668e-02f, 2.65927259e-02f,
  1.16442807e-01f, 7.61021152e-02f, 1.12032659e-01f, 2.02674661e-02f, 8.70281979e-02f, 6.22369163e-02f, 2.89768800e-02f, 7.85861462e-02f, 1.26574367e-01f, 2.55497638e-02f,
  4.46463786e-02f, 1.82496607e-01f, 1.68737993e-01f, 1.03661187e-01f, 9.52361152e-02f, 1.54683948e-01f, 2.24797368e-01f, 1.59493968e-01f, 2.34947532e-01f, 1.93498507e-01f,
  1.40768528e-01f, 2.08771363e-01f, 5.72397411e-01f, -9.82712135e-02f, 7.98000693e-02f, 2.34100029e-01f, 3.29921812e-01f, -2.90087461e-02f, -1.91947564e-01f, 1.37588158e-01f,
  -1.21471426e-02f, -2.38484785e-01f, -4.22599632e-03f, -1.05541095e-01f, 1.42957449e-01f, 3.74828339e-01f, 4.54462677e-01f, 2.49012783e-01f, 8.23549926e-02f, -1.05091169e-01f,
  -1.36096671e-01f, -6.85924441e-02f, -6.73478376e-03f, -1.31339999e-02f, -6.26037270e-02f, -7.28059709e-02f, 1.83671594e-01f, 7.24031925e-02f, 1.47959337e-01f, 2.84306891e-03f,
  3.38525146e-01f, 2.87917838e-03f, -5.37186535e-03f, -1.73323885e-01f, 1.10917753e-02f, -5.26851602e-02f, 3.69812511e-02f, -7.82001317e-02f, 1.05976472e-02f, -5.84004670e-02f,
  -1.12109326e-01f, -3.02055310e-02f, 1.21294344e-02f, -6.17886186e-02f, 9.20108110e-02f, -8.27432424e-02f, 2.97253206e-02f, -7.79174492e-02f, 2.31306913e-04f, 4.65468690e-02f,
  -7.13626444e-02f, 4.56294119e-02f, 8.81129950e-02f, 8.07932299e-03f, -8.19396302e-02f, -5.01972921e-02f, 2.88872253e-02f, -1.26117975e-01f, 4.18103784e-02f, -1.08603962e-01f,
  -4.96919565e-02f, 1.32227000e-02f, -4.77119274e-02f, -3.46808583e-02f, -8.94858688e-02f, -1.85483824e-02f, 2.08883435e-02f, -7.26423934e-02f, -7.62948543e-02f, -1.76096018e-02f,
  -9.92023796e-02f, 2.48594191e-02f, -1.23988919e-01f, -3.37440744e-02f, -1.49623677e-01f, -4.02190909e-02f, -3.23830657e-02f, -1.01642646e-01f, -4.42497097e-02f, -5.28315641e-02f,
  -4.94535379e-02f, -1.18447676e-01f, -3.91326360e-02f, -8.41255859e-02f, -8.57894346e-02f, -8.61121640e-02f, -1.04764730e-01f, -1.14308380e-01f, -1.81511313e-01f, -1.04821533e-01f,
  -8.35378468e-02f, 4.83989827e-02f, 8.43769386e-02f, -5.48813539e-03f, -2.98254173e-02f, -4.91027124e-02f, -8.61030817e-03f, -5.33655360e-02f, -4.76448834e-02f, -3.32077816e-02f,
  -7.15831891e-02f, 3.33936699e-02f, 4.24941331e-02f, -7.55542815e-02f, -5.15477732e-03f, 8.81053135e-03f, 2.83078626e-02f, 8.88584256e-02f, -4.96961810e-02f, -5.45410514e-02f,
  -1.75158940e-02f, 1.73944607e-01f, 2.09055349e-01f, 4.94659580e-02f, 2.57724430e-02f, 5.61393350e-02f, 1.29023239e-01f, 6.44425303e-02f, 1.61778927e-01f, 5.62867932e-02f,
  -2.31907576e-01f, 3.55932564e-01f, 2.24603936e-01f, 6.80737123e-02f, -7.57255852e-02f, -2.70663023e-01f, -7.06752166e-02f, -2.46502534e-01f, -7.43622482e-02f, 5.76094612e-02f,
  -1.53933883e-01f, -1.56627581e-01f, 2.79740756e-03f, -2.09122211e-01f, -2.01338887e-01f, 1.60084397e-01f, 2.93325603e-01f, -1.10329762e-01f, -4.96379793e-01f, -4.17501539e-01f,
  -1.05100527e-01f, 1.50189832e-01f, -2.90116146e-02f, -6.22113794e-02f, 2.56057292e-01f, -6.82089403e-02f, 2.39143014e-01f, 9.51595008e-02f, 2.58842204e-03f, 4.73802507e-01f,
  -1.66070536e-02f, -7.94540271e-02f, -1.92435145e-01f, -1.53115258e-01f, -1.50131406e-02f, -1.63322389e-01f, -1.88401848e-01f, -4.17504124e-02f, -7.65264705e-02f, -1.76700037e-02f,
  3.29893418e-02f, -6.94150254e-02f, -4.67977114e-03f, -3.44264023e-02f, -5.89906834e-02f, -1.26238152e-01f, -6.57746792e-02f, -5.45266494e-02f, -1.37725502e-01f, -1.73984393e-01f,
  -1.35043114e-02f, -3.85459419e-03f, -4.45349067e-02f, -1.44623905e-01f, -9.44517776e-02f, -1.24607638e-01f, -3.87235694e-02f, -1.32278383e-01f, -2.19212458e-01f, 1.21102720e-01f,
  5.76498313e-03f, 4.74079251e-02f, -2.88874526e-02f, 2.60582957e-02f, 2.21500432e-06f, 7.03979433e-02f, 4.92181778e-02f, -9.83295310e-03f, -1.44711230e-02f, 1.08816102e-01f,
  7.71825537e-02f, -4.81704297e-03f, -8.67251866e-03f, 6.16143495e-02f, 8.57207626e-02f, 1.21235088e-01f, 2.97467480e-03f, 8.17753822e-02f, 3.11356764e-02f, 6.58092499e-02f,
  4.08889260e-04f, -2.27637235e-02f, 2.90046111e-02f, 1.63362585e-02f, 1.77887622e-02f, 2.56563872e-02f, 8.26941654e-02f, -4.19018604e-02f, 2.97220163e-02f, 8.05029124e-02f,
  -2.17082929e-02f, -2.22820178e-01f, -4.96461317e-02f, -1.34535909e-01f, -3.69286649e-02f, -1.10705029e-02f, -1.23055689e-02f, -7.04447925e-02f, 5.72570674e-02f, -4.31877151e-02f,
  -1.60675317e-01f, -6.75846040e-02f, 4.33618128e-02f, -5.34746498e-02f, -1.23585463e-01f, -9.84884053e-02f, 3.75940576e-02f, -8.93404782e-02f, -8.93147364e-02f, -5.57702407e-03f,
  6.69323951e-02f, -1.46411121e-01f, -1.82174295e-01f, -4.19917181e-02f, -1.05669491e-01f, -2.06967995e-01f, -6.29550070e-02f, -8.43711346e-02f, -2.21536681e-01f, -8.59029684e-03f,
  -5.12278736e-01f, -5.11060178e-01f, -1.78899720e-01f, 2.83440687e-02f, 2.13776052e-01f, 3.89655083e-02f, -2.05892801e-01f, -1.83156386e-01f, 5.03693931e-02f, -2.90171001e-02f,
  1.68857977e-01f, 3.44686657e-01f, 1.65346786e-01f, 5.02306968e-02f, -2.13584807e-02f, -2.35699549e-01f, -2.31635511e-01f, 9.24213231e-03f, 2.03069970e-01f, 2.86665350e-01f,
  1.82182230e-02f, -8.89782608e-02f, -1.11146467e-02f, -7.54126757e-02f, -9.51769128e-02f, -8.40949453e-03f, -8.85978714e-02f, -4.09222841e-02f, -5.96450791e-02f, -2.49036595e-01f,
  2.73533046e-01f, -1.25820667e-01f, 1.35229796e-01f, 1.01946779e-01f, 6.74997866e-02f, 4.55511436e-02f, 1.28775220e-02f, 6.96474314e-02f, 1.00551262e-01f, -6.99044690e-02f,
  1.75467849e-01f, 4.86198291e-02f, 3.43234167e-02f, 1.30273610e-01f, 3.60532850e-02f, 4.35944609e-02f, -2.08604783e-02f, 7.26354716e-04f, 6.89652339e-02f, 1.12321466e-01f,
  1.65370375e-01f, 1.27630785e-01f, 9.64411476e-04f, -1.96151324e-02f, 9.96444076e-02f, 1.43248156e-01f, 1.33772194e-02f, -5.52812107e-02f, -5.74873164e-02f, -1.96990773e-01f,
  -8.93482342e-02f, 6.66156120e-05f, -2.10841279e-02f, -4.98702899e-02f, 5.90961762e-02f, 6.47003576e-02f, -7.43128136e-02f, -1.19536219e-03f, 1.15010515e-02f, -8.19903314e-02f,
  4.20755893e-02f, 3.54885943e-02f, -8.45935382e-03f, -8.67840461e-03f, -5.32658845e-02f, -5.89416213e-02f, -9.80190784e-02f, -9.83887166e-03f, 2.27164440e-02f, -7.60261863e-02f,
  2.44424026e-02f, 4.31623496e-02f, -4.25912887e-02f, 9.87910014e-03f, -1.59179196e-02f, -2.13874821e-02f, 2.45862119e-02f, 6.98313713e-02f, -2.81916186e-02f, -3.41428258e-02f,
  3.23491134e-02f, 1.66005507e-01f, -1.56732388e-02f, -8.07740763e-02f, 5.03933243e-02f, 9.10486206e-02f, 3.49724777e-02f, -1.58707127e-02f, 7.98819885e-02f, -2.70736013e-02f,
  1.37429200e-02f, 6.84990734e-02f, 9.70693156e-02f, 7.15314522e-02f, 6.08474314e-02f, 8.14126059e-02f, 1.39847761e-02f, 3.80586013e-02f, -3.06995567e-02f, 6.68578595e-02f,
  3.82498540e-02f, -7.56996050e-02f, 4.85380702e-02f, -1.74091682e-02f, -1.08354967e-02f, -2.78833192e-02f, -5.05199516e-03f, -5.77468537e-02f, -3.30657437e-02f, -2.56074548e-01f,
  6.16346657e-01f, 4.08034660e-02f, -9.58609879e-02f, 2.02733591e-01f, -1.59863487e-01f, -2.46506110e-01f, -3.67329627e-01f, -1.67821541e-01f, -6.61892444e-02f, 1.84783079e-02f,
  1.32736385e-01f, 1.98933035e-01f, -1.20080607e-02f, -3.55671570e-02f, 4.86673117e-02f, -4.69674617e-01f, -4.31129366e-01f, 8.47516358e-02f, 6.05222955e-02f, -2.18093954e-02f,
  -1.09839939e-01f, 9.15487185e-02f, 2.27131009e-01f, 7.25643337e-02f, -8.01045224e-02f, -1.25179529e-01f, -9.34509188e-02f, 2.04320401e-01f, -1.37788802e-01f, 4.50975262e-02f,
  1.97883487e-01f, 3.43855679e-01f, -1.87726170e-01f, 6.07730448e-02f, 3.66133749e-02f, -1.70190297e-02f, -8.70787203e-02f, 3.77249345e-02f, 2.19417829e-02f, -4.04574014e-02f,
  7.32748955e-02f, 5.15632294e-02f, 4.53579240e-02f, 1.86393764e-02f, 4.17338312e-02f, -2.59230360e-02f, 8.74842182e-02f, -2.68047377e-02f, 3.24941762e-02f, 2.28352975e-02f,
  -4.19516116e-02f, 1.44583493e-01f, 1.92734152e-01f, -1.36909768e-01f, -2.48867343e-03f, 6.79585012e-03f, -2.06052475e-02f, 6.89103007e-02f, 1.36137074e-02f, -7.82951638e-02f,
  -7.39751803e-03f, 4.20024507e-02f, 1.18010407e-02f, 6.37439191e-02f, -2.72083357e-02f, 3.17708179e-02f, -2.19888706e-02f, 2.98115537e-02f, -1.45599488e-05f, -5.36941141e-02f,
  -5.41508244e-03f, 3.12890746e-02f, 6.05947152e-02f, -2.70691328e-02f, -4.15929109e-02f, 6.69039339e-02f, 1.05950823e-02f, 3.36774252e-02f, 2.72723939e-02f, 7.38920346e-02f,
  2.24069804e-02f, 1.64217092e-02f, 7.22142383e-02f, -2.08372641e-02f, -2.40576416e-02f, -3.37953568e-02f, 1.91751979e-02f, -3.10358256e-02f, 2.40452215e-03f, -3.06097772e-02f,
  -6.15571178e-02f, 5.30909672e-02f, 4.39244136e-02f, -2.32262909e-02f, -1.49974786e-02f, -1.80470422e-02f, 4.14893962e-03f, 5.83484722e-03f, 5.96535392e-02f, -5.49049452e-02f,
  4.12600441e-03f, 5.39778545e-02f, 1.68241654e-02f, -6.69364408e-02f, -1.34344146e-01f, -1.25275195e-01f, -4.50581452e-03f, 4.53574657e-02f, -4.16125432e-02f, -6.96821734e-02f,
  -1.33615732e-01f, -1.50246218e-01f, -1.36599034e-01f, -1.85368612e-01f, -9.65889245e-02f, -9.60495844e-02f, -1.62815407e-01f, -1.36790037e-01f, -1.99653357e-01f, -3.47910494e-01f,
  -6.84396550e-03f, 1.52731195e-01f, 5.96827209e-01f, -2.62346625e-01f, -2.52064258e-01f, -7.52725750e-02f, -2.68949300e-01f, -2.63782471e-01f, -1.71495318e-01f, 1.57465383e-01f,
  2.51832873e-01f, -4.04400453e-02f, 1.66243359e-01f, 7.61209577e-02f, -9.05609876e-03f, 2.04648420e-01f, 7.48458952e-02f, 2.43118048e-01f, -1.01249412e-01f, -2.74981946e-01f,
  -3.35404366e-01f, -2.35965729e-01f, 4.25869599e-03f, -5.12108654e-02f, -1.18690776e-02f, -5.08696176e-02f, 3.51061523e-01f, 1.24027543e-01f, 1.69384018e-01f, 1.16878457e-01f,
  4.60336477e-01f, 1.13005698e-01f, -2.16952160e-01f, -1.29051253e-01f, 8.99618268e-02f, 7.77540496e-03f, -7.38850832e-02f, 4.33969013e-02f, -3.87794562e-02f, 1.92674026e-02f,
  4.62826379e-02f, -8.99474472e-02f, 1.80461854e-02f, -1.27108796e-02f, -8.63456577e-02f, 2.79892497e-02f, 1.10484168e-01f, 5.64685985e-02f, 1.13301039e-01f, 1.06958590e-01f,
  -3.39418910e-02f, 2.54694968e-02f, 1.35238186e-01f, 2.87830159e-02f, 6.50910810e-02f, 1.33022770e-01f, 1.39127269e-01f, 1.51246235e-01f, 6.18467703e-02f, 3.85965109e-02f,
  -8.84597898e-02f, 1.04007944e-01f, 1.01855537e-02f, -9.96333510e-02f, -8.78329501e-02f, 3.70073132e-02f, 5.25605008e-02f, 1.18998643e-02f, -2.12817192e-02f, -4.46397699e-02f,
  -3.54364514e-02f, 5.52766509e-02f, -3.84317227e-02f, 6.69348463e-02f, 1.23642333e-01f, 8.30194205e-02f, 4.89061549e-02f, 4.39844094e-02f, 2.66191792e-02f, -4.00140844e-02f,
  9.49800853e-03f, 4.84141260e-02f, 7.27508217e-02f, 4.17036116e-02f, 7.17222765e-02f, 6.02953918e-02f, 7.13503314e-03f, -6.80593401e-02f, 6.17487589e-03f, -6.58613164e-03f,
  -3.50114882e-01f, 1.50180221e-01f, -2.33502071e-02f, 4.83186804e-02f, -2.62459964e-02f, 1.66945755e-02f, 9.12698135e-02f, 4.35951538e-03f, 5.21315709e-02f, 2.34394986e-02f,
  3.56040187e-02f, -3.69313285e-02f, 2.50267573e-02f, 1.78214826e-03f, -6.33565262e-02f, -4.49079573e-02f, -4.61085588e-02f, 1.49205709e-02f, 3.55261602e-02f, 1.97342504e-02f,
  -2.75150221e-02f, -7.51444399e-02f, -1.05247147e-01f, 2.37199222e-03f, -1.46615077e-02f, -8.02674219e-02f, -9.22514882e-04f, -6.47665635e-02f, 5.87760936e-03f, -2.44766146e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.07778335e+00f, -2.72468865e-01f, 2.90181786e-01f, 4.56551611e-01f, 1.65309776e-02f, -8.82943198e-02f, -1.45064905e-01f, 1.09500088e-01f, 1.23239622e-01f, 7.31771290e-02f,
  -2.07621343e-02f, 1.31183386e-01f, 7.54405856e-02f, 9.82313082e-02f, 1.90571602e-02f, -2.06763130e-02f, 2.08145659e-03f, 2.86114752e-01f, 4.06874329e-01f, 1.49348378e-01f,
  1.13053225e-01f, 2.45022446e-01f, 4.30242777e-01f, 1.38050914e-01f, -2.67691072e-02f, 9.14264657e-03f, -5.89758419e-02f, -1.13380671e-01f, -8.10239464e-02f, 1.39146119e-01f,
  -1.44569650e-01f, 3.02208096e-01f, -8.24729260e-03f, -9.35406238e-02f, -1.03523217e-01f, 5.56917526e-02f, 1.49787381e-01f, 1.04013726e-01f, -1.11860640e-01f, -1.55974433e-01f,
  -1.51067242e-01f, 4.67952490e-02f, -5.20313345e-02f, -9.54293385e-02f, 3.48978788e-02f, 3.19078863e-02f, -7.96477497e-02f, 4.45474088e-02f, -1.17687061e-01f, -7.44089335e-02f,
  -4.61861193e-02f, 1.02713123e-01f, 5.09607531e-02f, -5.95824718e-02f, 2.96093784e-02f, -5.01206890e-02f, -6.52895644e-02f, 7.80408606e-02f, 1.92509722e-02f, 2.56872773e-01f,
  3.61709118e-01f, 4.51617509e-01f, 2.74510831e-01f, 2.24856988e-01f, 3.68303210e-02f, -1.28130063e-01f, -1.97003528e-01f, -1.19970053e-01f, 1.73996776e-01f, 1.80546030e-01f,
  -1.12450987e-01f, 1.27489001e-01f, 6.64853603e-02f, 2.24858001e-02f, 2.48021558e-02f, 8.98155645e-02f, -5.57983257e-02f, -5.97018264e-02f, 9.02826637e-02f, 6.30878657e-02f,
  7.69732967e-02f, -1.97177604e-01f, 3.21673341e-02f, -1.94006279e-01f, -1.76789016e-01f, 1.52131110e-01f, 2.83597738e-01f, 7.07463222e-03f, 1.47122681e-01f, 9.55702588e-02f,
  -5.30730486e-01f, 1.26812935e-01f, 2.17712447e-01f, -1.06781818e-01f, -4.59504314e-02f, -9.01703835e-02f, 1.42428219e-01f, -3.60331200e-02f, -1.87619701e-01f, -1.53773218e-01f,
  -1.52144730e-01f, 7.23134130e-02f, -1.01366244e-01f, 3.11135175e-03f, -2.42930390e-02f, -7.66855804e-03f, -1.20862074e-01f, -1.10262953e-01f, -1.62995309e-01f, -1.28715560e-01f,
  -1.43482447e-01f, 3.35541889e-02f, 1.43933490e-01f, -2.92386278e-03f, -1.16942830e-01f, 3.63244675e-02f, -8.46936852e-02f, -3.61516885e-02f, 3.99079248e-02f, 1.09381571e-01f,
  1.00218773e+00f, -6.28433824e-01f, -9.51443851e-01f, 1.05973296e-01f, -6.35516405e-01f, -6.94352686e-01f, -6.53354824e-01f, 1.75380126e-01f, 3.18918824e-01f, -4.95629519e-01f,
  -4.11487758e-01f, 5.39982438e-01f, 3.99719954e-01f, 3.55555832e-01f, 5.37811577e-01f, -7.25723445e-01f, -5.57971895e-01f, 2.19532534e-01f, 5.22205532e-01f, -1.57868434e-02f,
  -9.08029601e-02f, 3.08690518e-01f, 7.61272311e-01f, 4.35858011e-01f, -3.81831139e-01f, -1.48330346e-01f, -5.72802186e-01f, -4.46990311e-01f, -5.61817348e-01f, -8.97211194e-01f,
  -8.36445451e-01f, -2.58673608e-01f, 1.29623517e-01f, 3.32258940e-01f, -1.54434085e-01f, 2.77914792e-01f, -9.15017575e-02f, 3.16508383e-01f, 2.34048203e-01f, -1.44556478e-01f,
  -1.03659816e-01f, 2.35118032e-01f, 9.36490595e-02f, 2.00632550e-02f, 1.27000846e-02f, -7.16082752e-02f, 2.12426558e-01f, 2.88246930e-01f, 1.79900810e-01f, -2.25058660e-01f,
  -3.80165666e-01f, -1.50340334e-01f, -6.53466210e-02f, -1.12054870e-01f, 5.98492334e-03f, 1.70383051e-01f, -4.32788610e-01f, -1.86860576e-01f, 8.51798803e-02f, -3.90036553e-01f,
  -1.43734664e-01f, -1.33215427e-01f, 2.04160530e-02f, -4.98451255e-02f, 9.42360908e-02f, 4.24068496e-02f, -6.46173954e-02f, 4.58461493e-02f, 5.17238230e-02f, -5.09624593e-02f,
  1.00796282e-01f, 3.87191921e-02f, 1.78277791e-02f, -4.09606360e-02f, -6.09914847e-02f, 1.10276770e-02f, -9.08185020e-02f, 2.06045341e-02f, 2.52287593e-02f, 6.25739172e-02f,
  5.08419238e-02f, -8.39292556e-02f, 1.60075072e-02f, 1.41148061e-01f, -2.64195167e-03f, -2.17471849e-02f, -1.43846139e-01f, -1.60008576e-03f, 1.78662866e-01f, -1.08146049e-01f,
  3.75572711e-01f, 9.78002474e-02f, -3.50921869e-01f, 1.58622578e-01f, -2.74041206e-01f, 1.70682499e-03f, -2.70309001e-01f, 1.87968940e-01f, 2.15557385e-02f, -5.38128475e-03f,
  -5.42213507e-02f, 1.59459054e-01f, -3.21250819e-02f, -6.85763285e-02f, -5.46711348e-02f, -6.60986230e-02f, 1.47799447e-01f, -9.30742845e-02f, 7.17798322e-02f, -5.27359731e-02f,
  -1.21420361e-02f, 8.37419033e-02f, 1.78578749e-01f, -1.04468368e-01f, -6.20944165e-02f, 5.80912009e-02f, -3.64455104e-01f, -2.64602244e-01f, 1.90687910e-01f, -1.75130069e-02f,
  -6.48503125e-01f, -1.99555069e-01f, -3.77753794e-01f, -5.80875397e-01f, -6.12544008e-02f, 3.63951534e-01f, 6.43442929e-01f, 2.96929121e-01f, -1.82416931e-01f, -9.74298641e-02f,
  -2.51478761e-01f, -2.30864987e-01f, -3.05531114e-01f, 1.38761001e-02f, 2.25663587e-01f, 3.91043097e-01f, 1.06147051e-01f, 1.58829659e-01f, 3.00709426e-01f, 4.03898537e-01f,
  2.44626120e-01f, -4.65435758e-02f, -2.02692941e-01f, -2.29153976e-01f, -2.55320668e-01f, -4.08276729e-02f, -2.99362779e-01f, -2.60540962e-01f, -1.92313362e-02f, -3.82027328e-01f,
  2.21189752e-01f, -5.35255253e-01f, 5.66325933e-02f, -7.72417039e-02f, -1.93022922e-01f, -9.17402282e-02f, -8.62754136e-02f, -2.44480059e-01f, -5.06508350e-02f, -5.99181689e-02f,
  -1.62161574e-01f, -1.13627225e-01f, -1.68634742e-01f, -7.06410259e-02f, -7.98204839e-02f, -5.65143712e-02f, -1.17264405e-01f, -8.98610130e-02f, -1.05941463e-02f, -2.24933058e-01f,
  -1.02100134e-01f, -9.75834429e-02f, 1.83852687e-02f, 2.31181145e-01f, 1.00489603e-02f, 5.44030815e-02f, 4.73833010e-02f, -3.38303223e-02f, 2.52327090e-03f, 4.11948040e-02f,
  2.05059782e-01f, 1.06159419e-01f, -1.29226193e-01f, -6.03405498e-02f, -6.86080009e-02f, 1.78896099e-01f, 9.41173807e-02f, 1.59655347e-01f, 3.11164111e-01f, 7.26486817e-02f,
  1.12772830e-01f, -6.50539622e-02f, 7.11923540e-02f, 6.28404096e-02f, -1.30914405e-01f, -1.40070364e-01f, 1.02182813e-01f, -1.96733654e-01f, -1.20112620e-01f, -2.40811870e-01f,
  -1.20511457e-01f, 1.03864215e-01f, -1.45632386e-01f, 2.24159453e-02f, -6.12682439e-02f, -8.77654552e-02f, -1.54706454e-02f, -9.98067111e-02f, -9.82398614e-02f, 5.50944582e-02f,
  1.30779877e-01f, -3.33363533e-01f, 9.49303135e-02f, 5.41989394e-02f, -1.43776894e-01f, -1.03924446e-01f, -2.90390670e-01f, -3.57670523e-02f, -4.02825363e-02f, 1.45598426e-01f,
  3.39683034e-02f, 1.77015606e-02f, -5.84611297e-02f, 1.90845698e-01f, 1.63840249e-01f, 2.21545801e-01f, -1.95216220e-02f, 4.67089824e-02f, 9.43191722e-02f, -6.90612495e-02f,
  2.44084615e-02f, 1.81205630e-01f, 3.01388919e-01f, 3.93916965e-01f, 3.12288523e-01f, 3.85527074e-01f, 3.29892784e-01f, 1.20118089e-01f, 1.70595124e-01f, 4.49150592e-01f,
  -1.23030722e+00f, -9.30094719e-01f, 2.63107449e-01f, -1.01258171e+00f, -4.70918328e-01f, -3.02458644e-01f, -1.01441038e+00f, -4.07263696e-01f, -2.63511956e-01f, -1.07140934e+00f,
  -2.47640818e-01f, 3.49498987e-01f, 3.53258580e-01f, 4.89697009e-01f, 1.38968781e-01f, -1.01685977e+00f, -3.84729236e-01f, 2.51064450e-01f, 6.63404822e-01f, -2.61120886e-01f,
  -6.10153317e-01f, -6.14075959e-01f, -3.58317979e-02f, -3.92653309e-02f, -1.00349867e+00f, -8.46939459e-02f, -2.64412642e-01f, -3.70341957e-01f, -1.80631459e-01f, -8.03475976e-01f,
  -3.42926890e-01f, -7.52851814e-02f, 4.45126563e-01f, 1.80194736e-01f, -2.30707288e-01f, 8.44053850e-02f, -2.68549323e-01f, 1.28260374e-01f, 8.27699453e-02f, -3.82771604e-02f,
  -1.26627262e-03f, 1.26108333e-01f, 1.92634463e-01f, -4.09916006e-02f, -2.85919666e-01f, -6.08905219e-02f, -1.72612220e-02f, 2.02621922e-01f, 2.13190138e-01f, -8.55558645e-03f,
  -2.10459381e-02f, -7.53251165e-02f, 3.46489251e-01f, 2.84781992e-01f, 2.33015597e-01f, 4.77336854e-01f, 1.64141078e-02f, 1.89655945e-01f, 4.22917783e-01f, -8.30070019e-01f,
  -8.85973051e-02f, 6.90297410e-02f, -4.31923866e-02f, -1.22544290e-02f, 8.93885419e-02f, 1.43909259e-02f, -8.86687860e-02f, -7.77788609e-02f, 1.18824914e-01f, -3.12991603e-03f,
  3.46925366e-03f, -1.85387973e-02f, 4.87003736e-02f, -1.33498549e-01f, 5.69252707e-02f, -3.74865718e-02f, 3.31895277e-02f, -2.33003125e-02f, 1.04639372e-02f, -1.10952586e-01f,
  1.15609467e-01f, 9.17566270e-02f, -8.47309828e-03f, -5.38241118e-02f, 1.35879636e-01f, -1.69493780e-02f, 6.33158386e-02f, 1.14328802e-01f, 1.82176922e-02f, 1.49855644e-01f,
  -2.02997774e-01f, 4.79663342e-01f, -5.33787251e-01f, 1.90459654e-01f, -2.45166495e-01f, 1.45191684e-01f, -2.80864798e-02f, 1.10162549e-01f, 1.20299831e-01f, -1.96996391e-01f,
  4.28743437e-02f, -9.86159965e-02f, -7.90742189e-02f, 7.68836662e-02f, -1.90145180e-01f, 2.03903377e-01f, -1.19837902e-01f, -1.94577754e-01f, 1.34794876e-01f, -3.83649766e-02f,
  2.26902571e-02f, -1.73031799e-02f, -1.69433743e-01f, -5.15689775e-02f, -6.43777847e-02f, 3.30497503e-01f, -2.48043276e-02f, 2.54170559e-02f, 2.25114182e-01f, -9.05699909e-01f,
  3.18159372e-01f, 8.65785182e-01f, -7.35891223e-01f, 5.86120248e-01f, -1.10118143e-01f, -4.81554151e-01f, 2.15259656e-01f, 3.72423053e-01f, 6.36368573e-01f, 8.20642173e-01f,
  2.91952729e-01f, -7.43627310e-01f, -4.29855376e-01f, -7.01073945e-01f, -9.35304999e-01f, 1.13586612e-01f, -4.13800031e-02f, -9.34900641e-01f, -1.47396636e+00f, -8.10340643e-01f,
  -1.65091947e-01f, -1.62072495e-01f, -4.42921132e-01f, -4.05734271e-01f, 3.27148825e-01f, -3.74119580e-01f, 2.22413853e-01f, -1.32288367e-01f, -4.54367906e-01f, 1.11430109e-01f,
  -6.91937745e-01f, -4.08733897e-02f, -5.40263891e-01f, -1.65398613e-01f, 1.05458841e-01f, -1.32253962e-02f, -2.55792201e-01f, -2.89432973e-01f, 4.46246937e-02f, 7.44859800e-02f,
  -3.20723176e-01f, -1.49188653e-01f, -2.18049839e-01f, -3.50361526e-01f, -3.66370529e-01f, -3.96017879e-01f, 1.17183469e-01f, -3.26358050e-01f, -3.35001498e-01f, 1.22693688e-01f,
  2.55092233e-01f, -5.22722781e-01f, -7.15718567e-01f, 1.14289381e-01f, -2.33780652e-01f, -4.32336241e-01f, -8.02806914e-02f, -3.20869327e-01f, -5.26544929e-01f, 7.12859035e-01f,
  2.82368243e-01f, 1.04355253e-02f, 4.71809134e-02f, 7.41245300e-02f, 2.63389915e-01f, 2.81505696e-02f, -1.39359966e-01f, -8.10299218e-02f, -2.01485157e-01f, 1.18592374e-01f,
  4.98760156e-02f, 1.05944835e-01f, 5.41787222e-03f, 1.74810469e-01f, -6.11428730e-02f, -1.29565448e-01f, -4.36418205e-02f, 2.33861610e-01f, -5.92206642e-02f, 8.57691616e-02f,
  -2.14589342e-01f, -2.97789901e-01f, -1.04696147e-01f, 2.12836172e-02f, 4.41266112e-02f, 2.47528702e-02f, 5.22466339e-02f, -1.88003257e-02f, 1.26512527e-01f, 1.33916348e-01f,
  2.40851060e-01f, -3.68679136e-01f, 1.24680502e-02f, -5.57677224e-02f, -6.64458945e-02f, 7.34402090e-02f, 2.11885542e-01f, 2.10746467e-01f, -3.36168818e-02f, -4.36202884e-02f,
  -2.45726839e-01f, -5.53483851e-02f, 1.97663829e-01f, -1.38496701e-03f, -3.88043106e-01f, -1.13919079e-01f, 3.86313438e-01f, -1.94942921e-01f, -1.86732933e-01f, 2.38742441e-01f,
  6.23030603e-01f, 6.12623282e-02f, -2.17803374e-01f, 3.29443425e-01f, 9.78569910e-02f, -2.57157296e-01f, -2.19108939e-01f, -1.00700431e-01f, -4.83708084e-01f, 7.69532979e-01f,
  -5.47604978e-01f, 9.70977724e-01f, 5.64960241e-01f, -5.47956884e-01f, 2.52094120e-01f, 5.02958596e-01f, 8.75021517e-01f, 1.14091590e-01f, -4.61766630e-01f, 3.92714053e-01f,
  4.90946591e-01f, -3.82454932e-01f, -9.87976640e-02f, -1.34021282e-01f, 1.51127756e-01f, 3.39389712e-01f, 1.72911257e-01f, -3.26605469e-01f, -5.13480365e-01f, -3.63680243e-01f,
  -3.19771945e-01f, -2.79833317e-01f, -4.96763885e-01f, -3.43044311e-01f, 9.43724439e-03f, -3.67819309e-01f, 3.83951843e-01f, 1.37870416e-01f, 4.31321681e-01f, -1.45759508e-01f,
  2.02877730e-01f, 5.70133328e-01f, -5.27711630e-01f, -2.16592446e-01f, 1.00044221e-01f, -2.72617191e-01f, -2.16400642e-02f, -1.14969037e-01f, -1.65624265e-02f, -1.78479299e-01f,
  6.37852997e-02f, 6.41492531e-02f, 1.23138882e-01f, 1.68931544e-01f, 9.49424431e-02f, 9.20739248e-02f, 6.52437806e-02f, -6.94887862e-02f, -4.66758460e-02f, 2.10803285e-01f,
  3.37112870e-04f, 9.66831371e-02f, 4.00108695e-01f, 3.91965359e-01f, 1.43954307e-01f, -3.55744034e-01f, 3.46969098e-01f, -3.70114893e-02f, 1.59966424e-01f, -2.79923975e-01f,
  -3.48218769e-01f, -7.79912919e-02f, 2.80529678e-01f, -1.70099586e-01f, -1.06521301e-01f, 4.41769324e-02f, -3.10664363e-02f, 5.19642532e-02f, -3.26726306e-03f, -5.02953492e-02f,
  -3.80663909e-02f, 8.85101482e-02f, -4.36255708e-02f, 3.80317755e-02f, -1.29454374e-01f, 1.16573438e-01f, 5.87076247e-02f, 1.52860627e-01f, 1.90188095e-01f, 1.75149500e-01f,
  -1.21453270e-01f, 2.24385317e-02f, 5.69671988e-02f, 7.07896948e-02f, 1.25238195e-01f, -1.03772901e-01f, -1.96969315e-01f, -6.15527481e-02f, -1.40848666e-01f, -6.01934008e-02f,
  -6.38979554e-01f, 4.89878953e-01f, -2.95592189e-01f, -9.32058617e-02f, 1.54649988e-01f, 1.80992335e-01f, 3.91828157e-02f, 9.12971348e-02f, 4.97994386e-02f, -8.38646963e-02f,
  2.22394779e-01f, -3.22063088e-01f, 3.96060437e-01f, 6.31598756e-02f, -2.59408265e-01f, -1.68859392e-01f, 4.61327210e-02f, -7.63485432e-02f, -1.51712403e-01f, -9.03616659e-03f,
  -1.19765345e-02f, -3.48225653e-01f, -6.09987855e-01f, -2.54512876e-01f, -5.16907871e-01f, -8.42350841e-01f, -1.08028464e-01f, -4.79997367e-01f, -1.04310676e-01f, -4.20211405e-01f,
  4.64097470e-01f, 8.38430002e-02f, -1.51245022e+00f, -3.44529748e-01f, -9.77089942e-01f, -8.22300553e-01f, -1.27555147e-01f, -1.76542625e-01f, -3.24767858e-01f, -3.17710698e-01f,
  -1.75073788e-01f, 1.83065042e-01f, 1.65276434e-02f, -1.29492190e-02f, 3.72431189e-01f, -2.93618351e-01f, -8.04827034e-01f, -3.25114340e-01f, -6.56251684e-02f, 2.70788729e-01f,
  4.59416717e-01f, 3.65514785e-01f, 3.40743363e-01f, -6.00596927e-02f, -6.33955598e-02f, -6.86027035e-02f, -7.20404625e-01f, -4.03934956e-01f, -4.08744425e-01f, -4.89468783e-01f,
  1.04119293e-01f, -5.72785139e-01f, -4.04028028e-01f, -2.42624190e-02f, -2.53508061e-01f, 6.39087483e-02f, 1.61534667e-01f, -2.63289839e-01f, -1.26165852e-01f, -2.10590258e-01f,
  -1.63799539e-01f, -3.85606624e-02f, -1.89848116e-03f, 5.15781492e-02f, 2.24293321e-02f, 1.07278295e-01f, -6.23427816e-02f, -2.36593619e-01f, -2.28101358e-01f, -1.57578334e-01f,
  -4.96440493e-02f, -1.97202593e-01f, -2.28180885e-01f, -2.65152693e-01f, -3.83548588e-01f, -3.82849604e-01f, -3.34948719e-01f, -3.26770961e-01f, -4.93706465e-01f, -8.22037384e-02f,
  -1.01100691e-01f, -9.06286389e-02f, -5.92250340e-02f, 6.07674047e-02f, 2.44048029e-01f, -1.93732604e-03f, -3.99260037e-03f, 6.26102388e-02f, 1.37198672e-01f, 1.93656191e-01f,
  -1.08631045e-01f, -2.14684710e-01f, -5.30751012e-02f, 1.15051962e-01f, -2.56467760e-02f, -9.09556597e-02f, 1.67832032e-01f, 3.09840262e-01f, -1.56036885e-02f, 5.08848354e-02f,
  2.55179200e-02f, 1.21115163e-01f, -9.68524367e-02f, 2.12288663e-01f, -3.52261573e-01f, -1.47117704e-01f, 1.10104837e-01f, -7.21887592e-03f, 9.29885879e-02f, -1.47588775e-01f,
  9.18512046e-01f, -3.06482732e-01f, 3.51506263e-01f, 7.84162581e-02f, -1.64948195e-01f, -1.53486356e-01f, 1.47491759e-02f, -9.65298116e-02f, -7.35843629e-02f, 1.88520163e-01f,
  4.22720946e-02f, 1.36637971e-01f, 5.09773903e-02f, -8.54953378e-03f, 6.56035403e-03f, 1.33848879e-02f, 1.80436715e-01f, 1.50692677e-02f, -1.84493542e-01f, -2.20729262e-02f,
  -8.55313167e-02f, 2.43318558e-01f, 6.65089250e-01f, 1.99177742e-01f, 1.72980800e-01f, 6.79327697e-02f, 2.90571630e-01f, 1.58182845e-01f, 1.28861591e-01f, 7.68088520e-01f,
  1.00016701e+00f, -7.07570851e-01f, 7.75645971e-01f, 2.38903314e-01f, 4.60167497e-01f, 4.83243436e-01f, 2.31655777e-01f, 1.95479006e-01f, 9.56942812e-02f, -1.20483108e-01f,
  -5.57583809e-01f, -6.68582618e-01f, -5.83007336e-01f, -4.14627939e-01f, -2.55670607e-01f, -1.25058508e-02f, 3.56683433e-01f, 4.67640370e-01f, 4.24170882e-01f, 8.14499930e-02f,
  -5.34400582e-01f, 7.41024762e-02f, 2.10248411e-01f, 4.60957699e-02f, -1.95941210e-01f, -1.16046749e-01f, 5.46981506e-02f, 1.19901329e-01f, -2.25566059e-01f, -3.56933326e-02f,
  8.28375295e-02f, 1.34900808e-01f, -1.45964772e-01f, -2.58323252e-01f, -1.22566923e-01f, -2.52347380e-01f, -9.51308981e-02f, -3.12476121e-02f, -9.93157253e-02f, 2.31834762e-02f,
  -5.21969423e-02f, -1.01976112e-01f, 4.41222154e-02f, -9.03269276e-02f, 9.02654678e-02f, -4.91021201e-02f, -1.09972902e-01f, -7.59008760e-03f, -1.06673203e-01f, -2.90157378e-01f,
  -5.81624925e-01f, -7.09847361e-02f, 2.26866961e-01f, -3.67787294e-02f, -1.76578015e-02f, 3.43712717e-02f, 3.09684630e-02f, 1.19007146e-03f, 1.80099949e-01f, 3.09873894e-02f,
  -1.93942294e-01f, -4.35286090e-02f, -1.52065217e-01f, -8.08699280e-02f, -9.25275758e-02f, -1.31312937e-01f, 2.12561749e-02f, -1.34760723e-01f, -4.48734835e-02f, 1.66731905e-02f,
  -1.50168657e-01f, -4.93566412e-03f, 2.55340301e-02f, -9.41154882e-02f, -3.38638335e-01f, 5.92643954e-02f, -3.07609700e-02f, -1.12232953e-01f, 7.98811577e-03f, -5.14698178e-02f,
  9.76918358e-03f, 8.02352577e-02f, -4.98816408e-02f, -2.87236925e-02f, -1.51433393e-01f, -2.13638730e-02f, -1.03162877e-01f, -9.49220210e-02f, -4.69366573e-02f, -2.18363740e-02f,
  -4.96350318e-01f, -8.59374404e-02f, -2.74456460e-02f, 5.45289740e-02f, 1.76927537e-01f, -1.83306724e-01f, -1.41747802e-01f, -5.83611019e-02f, -2.66561490e-02f, 7.31360316e-02f,
  1.51950018e-02f, 8.38734806e-02f, -1.14870816e-01f, -8.17327574e-02f, 1.96144328e-01f, -2.97301984e-03f, -3.02675903e-01f, -5.75935356e-02f, -1.19486503e-01f, -2.14456335e-01f,
  -1.99604467e-01f, 1.36631280e-01f, 2.06153631e-01f, 4.06419821e-02f, -7.06823543e-02f, 1.87468186e-01f, 9.34430808e-02f, 8.92469138e-02f, 1.94277421e-01f, 4.10747267e-02f,
  -1.15321445e+00f, -4.05870855e-01f, -4.70622540e-01f, -6.48897111e-01f, 4.08315033e-01f, 3.05097073e-01f, 4.05186176e-01f, -1.07316688e-01f, -4.36868876e-01f, -1.66473553e-01f,
  3.57635885e-01f, 2.49214903e-01f, -2.49897048e-01f, 2.48727456e-01f, 9.94941741e-02f, 6.48035035e-02f, 1.15122631e-01f, 5.21353222e-02f, 2.86014050e-01f, 5.78374088e-01f,
  3.83777767e-01f, -1.85141638e-01f, -3.70071650e-01f, -3.25804204e-03f, -1.98365420e-01f, -8.72460380e-02f, -3.31120640e-01f, -1.56130165e-01f, 2.87073016e-01f, 1.25057608e-01f,
  -9.88465697e-02f, -5.09196758e-01f, 2.67425328e-01f, 3.25439245e-01f, 3.15101355e-01f, -4.46387827e-01f, -2.83301063e-02f, -3.69310677e-01f, 4.83528851e-03f, -1.96768329e-01f,
  1.54506475e-01f, 3.42406854e-02f, 8.75226706e-02f, -1.66863836e-02f, -2.18776539e-01f, -1.37818083e-01f, -3.46583098e-01f, -2.75722265e-01f, -4.47851628e-01f, -1.51676238e-02f,
  9.04354155e-01f, 4.55858827e-01f, -3.92848849e-01f, 3.12085859e-02f, -2.77518719e-01f, -8.43842849e-02f, -4.56605433e-03f, 1.50973022e-01f, -2.55807310e-01f, -3.30397576e-01f,
  4.06843163e-02f, -2.94136237e-02f, -4.20493074e-02f, -1.92863867e-01f, 1.34040609e-01f, -6.54725879e-02f, -1.13740772e-01f, 3.54428776e-02f, 7.92409331e-02f, -1.83644861e-01f,
  4.41172533e-02f, 9.99903083e-02f, 5.50483959e-03f, -1.88393191e-01f, 8.89304206e-02f, -1.84268415e-01f, 1.92818671e-01f, 2.56779771e-02f, 1.14599518e-01f, -8.66992250e-02f,
  9.78839248e-02f, 1.06064290e-01f, -2.55290717e-01f, 7.42450878e-02f, 1.13765284e-01f, -6.65577352e-02f, -2.33249649e-01f, 2.16843992e-01f, -2.53207356e-01f, -2.01838404e-01f,
  -6.50110960e-01f, 3.30774546e-01f, -3.41518641e-01f, -1.14562139e-02f, -8.47419649e-02f, 7.03147054e-02f, 3.40138189e-02f, 1.00785919e-01f, -3.43261003e-01f, -2.12887958e-01f,
  2.24299982e-01f, -7.53425434e-02f, -3.60498220e-01f, 2.17303839e-02f, 1.16934821e-01f, -1.48973793e-01f, 5.17575536e-03f, 6.59960732e-02f, 8.86705741e-02f, 6.07553273e-02f,
  -4.63679954e-02f, 9.74727198e-02f, -3.98201555e-01f, -3.46841127e-01f, -1.47021085e-01f, -1.98802665e-01f, -2.24898547e-01f, -1.88458059e-02f, -3.89061719e-01f, -6.58297539e-01f,
  1.38571835e+00f, 1.47552341e-01f, -7.86691979e-02f, 2.28494048e-01f, -2.49560535e-01f, -3.70604128e-01f, -4.15128559e-01f, -7.16541708e-02f, 1.92155570e-01f, 8.99395943e-02f,
  2.66961783e-01f, 2.56890088e-01f, 3.26949805e-01f, 1.25464678e-01f, -4.54981662e-02f, -2.83383906e-01f, -3.70331049e-01f, 7.59145394e-02f, -1.86838228e-02f, -9.45768431e-02f,
  -2.61800736e-01f, -1.05759934e-01f, 3.21090013e-01f, 3.60054262e-02f, -7.92267025e-02f, 5.98533861e-02f, -1.43312559e-01f, -2.25105122e-01f, -1.91253409e-01f, -3.25462043e-01f,
  -2.33276173e-01f, 2.73030102e-01f, -1.37631446e-02f, 2.20438078e-01f, 2.30074823e-01f, 1.15936354e-01f, 1.59429565e-01f, -3.29835191e-02f, -2.49560885e-02f, -2.15928167e-01f,
  -2.47384142e-02f, 9.59594920e-02f, 5.65637834e-02f, -1.36353135e-01f, -1.73458114e-01f, -1.93590466e-02f, 1.47889063e-01f, -1.90497395e-02f, -1.07490838e-01f, -8.22739527e-02f,
  5.42617403e-02f, 2.65178755e-02f, -4.48391028e-02f, -7.25778192e-02f, 1.70170575e-01f, -8.34722444e-03f, 6.34514838e-02f, 7.92426243e-02f, -2.24686544e-02f, 8.86281133e-02f,
  1.07961493e-02f, 1.91342324e-01f, 1.91472948e-01f, 2.26419419e-02f, 3.51516381e-02f, 6.19277395e-02f, -1.87179297e-01f, -1.68156639e-01f, 1.92230400e-02f, 1.32926539e-01f,
  -2.43184730e-01f, -7.61647001e-02f, 4.50546108e-02f, -5.71615770e-02f, 1.13231324e-01f, -1.12484679e-01f, -4.00126241e-02f, -7.79717565e-02f, 4.42695692e-02f, 1.32654607e-01f,
  9.11253616e-02f, -1.94051757e-01f, -1.12716317e-01f, -6.18941151e-02f, -1.71645954e-01f, -1.45081186e-03f, -7.86626637e-02f, -9.28026214e-02f, -6.36929497e-02f, -1.76727489e-01f,
  -2.46670797e-01f, 2.49867335e-01f, 9.37658921e-02f, 1.24291524e-01f, 7.28770569e-02f, 1.62212312e-01f, 1.05242491e-01f, -1.60092726e-01f, -2.47463077e-01f, -1.33842453e-01f,
  -8.03385451e-02f, 6.69154078e-02f, 7.40808696e-02f, -7.22353673e-03f, 9.81286168e-02f, -2.66727190e-02f, 1.89789176e-01f, 1.32051677e-01f, -5.68904914e-02f, 4.90058847e-02f,
  1.40094921e-01f, -9.99477357e-02f, -6.40221313e-02f, 7.39201754e-02f, 1.34686798e-01f, 1.27412841e-01f, -8.80933702e-02f, -1.16391657e-02f, -1.98706407e-02f, -2.59354599e-02f,
  -9.35740829e-01f, -7.21090555e-01f, -4.73754376e-01f, 2.95544043e-02f, 5.04156232e-01f, -2.97251463e-01f, -9.18680131e-01f, -6.91956878e-01f, -2.15510994e-01f, -5.82288265e-01f,
  6.05088063e-02f, 6.35286808e-01f, -3.69808488e-02f, 7.90000483e-02f, -3.31970096e-01f, -6.36804044e-01f, -3.08149606e-01f, 1.64672509e-01f, 5.71199000e-01f, 6.89606369e-01f,
  6.81051552e-01f, 5.42880476e-01f, 4.65284705e-01f, 2.04208359e-01f, 2.49089390e-01f, 4.59910035e-01f, -8.54609627e-03f, 3.59654009e-01f, 3.78357582e-02f, 3.78258228e-02f,
  -3.69136214e-01f, -8.22853446e-01f, 1.87983826e-01f, 4.03888077e-01f, 2.76973546e-01f, -5.59584022e-01f, -2.68397361e-01f, -6.78951889e-02f, -9.33946446e-02f, -1.40592411e-01f,
  3.19689780e-01f, -3.52095440e-02f, 2.54356116e-01f, 1.64524391e-01f, 1.46424681e-01f, -2.35590607e-01f, -1.23905867e-01f, -3.39525759e-01f, -3.57141465e-01f, -1.49813503e-01f,
  4.74891692e-01f, 2.28794187e-01f, -3.92583758e-01f, -3.01215976e-01f, -5.26841044e-01f, 4.41099823e-01f, -3.61393005e-01f, -1.22099623e-01f, -4.44386601e-01f, -6.72956526e-01f,
  -1.12987891e-01f, 1.07877158e-01f, -6.71034353e-03f, -1.38933375e-01f, 1.22388735e-01f, -1.13802757e-02f, 7.24212304e-02f, 8.27893913e-02f, 5.13487868e-02f, -1.73339784e-01f,
  -5.60670979e-02f, -2.86248811e-02f, -7.09672421e-02f, -1.29097059e-01f, 1.57861382e-01f, 9.06599090e-02f, 1.61369100e-01f, 1.05455341e-02f, 1.64476231e-01f, -1.15807496e-01f,
  -1.23449169e-01f, -6.70989528e-02f, 2.99747199e-01f, 4.98979166e-02f, -1.66291595e-01f, -2.21404672e-01f, -7.39602894e-02f, 2.77452525e-02f, 2.93641593e-02f, -9.78682563e-02f,
  2.35637933e-01f, 4.98205662e-01f, -4.03101861e-01f, -1.44494608e-01f, 3.31136100e-02f, 2.72678375e-01f, 6.51514456e-02f, -4.81390720e-03f, 1.25723079e-01f, -1.39022246e-01f,
  -9.75702778e-02f, -3.38430442e-02f, -3.10042016e-02f, 2.25273103e-01f, -2.99456511e-02f, -1.36021391e-01f, -1.43743590e-01f, 1.01394616e-02f, -1.49695247e-01f, 6.13710135e-02f,
  -2.73966551e-01f, -3.51084083e-01f, -5.04004061e-01f, -5.07674992e-01f, -6.12141900e-02f, -8.82532299e-02f, -1.25682622e-01f, -1.23041347e-01f, -6.63985193e-01f, -9.50139761e-01f,
  3.18898290e-01f, 1.81564137e-01f, -1.03476793e-01f, -3.46952468e-01f, 5.98615766e-01f, 3.85117680e-01f, -1.99559972e-01f, -6.50658235e-02f, 2.50677258e-01f, -2.10868835e-01f,
  5.50991714e-01f, 9.92722362e-02f, -5.73401153e-01f, -6.73734784e-01f, -1.31038022e+00f, -1.00320458e+00f, -9.58254516e-01f, -8.42235506e-01f, -6.28687799e-01f, 1.73920065e-01f,
  8.62170979e-02f, -1.18654341e-01f, -4.08412635e-01f, -5.59814751e-01f, 7.65952840e-02f, -3.90187740e-01f, -3.97506833e-01f, 1.54555459e-02f, -3.75775665e-01f, -3.80146354e-01f,
  -3.59139182e-02f, 6.75633907e-01f, 9.58392397e-02f, -7.11536687e-03f, 5.42821512e-02f, -5.69397621e-02f, 1.13055892e-01f, -1.17364280e-01f, 2.24543124e-01f, -2.32227951e-01f,
  1.98434994e-01f, 1.96645647e-01f, 2.19740808e-01f, 1.52700499e-01f, 5.33993989e-02f, -1.29146114e-01f, -4.79992405e-02f, -3.80646020e-01f, -4.40812677e-01f, 2.81892747e-01f,
  4.83897865e-01f, 1.83149204e-01f, -2.24373743e-01f, -1.45868227e-01f, -2.33866408e-01f, -2.80650705e-01f, 2.24206865e-01f, 1.28604963e-01f, -4.25690234e-01f, -4.94730443e-01f,
  -1.87966213e-01f, -1.72953252e-02f, 3.12554806e-01f, 1.96478084e-01f, -3.53097022e-02f, 2.11300060e-01f, -8.80585983e-03f, -2.05986291e-01f, -1.52202812e-03f, -9.34220552e-02f,
  -6.02722093e-02f, 5.71613088e-02f, 5.10809794e-02f, -7.24556968e-02f, -4.65497047e-01f, -6.89036623e-02f, 5.48115000e-02f, -4.51610684e-01f, -3.07398677e-01f, -2.07211182e-01f,
  -8.91367570e-02f, 2.22936664e-02f, 1.16119973e-01f, -1.95932686e-01f, -4.29601073e-02f, -2.58656263e-01f, 1.26521870e-01f, 1.29825920e-01f, 1.44534037e-01f, 1.36272922e-01f,
  -3.00273329e-01f, -3.60071927e-01f, -2.59642690e-01f, -1.17739402e-01f, -3.24593186e-02f, -1.20789744e-01f, 2.12298155e-01f, -1.09933568e-02f, 3.66408020e-01f, -6.65144920e-02f,
  5.64676337e-02f, -9.11802426e-02f, -8.40306804e-02f, 1.85368717e-01f, -6.52666464e-02f, 1.50464281e-01f, -4.16189641e-01f, -1.34470731e-01f, -1.62970603e-01f, 3.92496020e-01f,
  -3.88623416e-01f, -8.75324547e-01f, -6.10272884e-01f, -4.84325677e-01f, 8.00746828e-02f, -5.95121920e-01f, -4.49357927e-01f, -4.02783483e-01f, -8.63854527e-01f, -1.23688412e+00f,
  -3.23646277e-01f, 1.16423205e-01f, 8.00957441e-01f, 2.34761704e-02f, -1.86995894e-01f, -6.53019190e-01f, -1.08835661e+00f, -6.93081379e-01f, -6.32764474e-02f, -9.27750915e-02f,
  -7.32001439e-02f, 2.45838329e-01f, 5.87006748e-01f, 2.12611005e-01f, -4.21237975e-01f, 1.29474685e-01f, 2.81588435e-01f, 1.93306297e-01f, -4.08715397e-01f, -6.42971456e-01f,
  -2.95194715e-01f, -1.25067353e-01f, -2.84941554e-01f, -2.22767755e-01f, 6.45719588e-01f, 2.40674525e-01f, 5.09484887e-01f, 3.30879152e-01f, 1.30728051e-01f, 1.21165121e+00f,
  1.07258236e+00f, -1.18243180e-01f, -1.03008695e-01f, 1.03619650e-01f, 3.64212602e-01f, -1.85369141e-02f, -8.98984522e-02f, 4.70798492e-01f, 2.42115371e-02f, 9.34283063e-02f,
  1.46972001e-01f, 3.08962185e-02f, 1.57300666e-01f, -3.40947732e-02f, -3.34827244e-01f, -5.38966358e-01f, -1.05716422e-01f, -1.97644979e-01f, 6.57671168e-02f, 1.81900814e-01f,
  -1.34471282e-01f, -2.51438886e-01f, -6.62063574e-03f, -2.77447969e-01f, 1.89317062e-01f, 6.09651133e-02f, -1.40072256e-01f, -2.03137547e-02f, -3.56115222e-01f, 4.82313365e-01f,
  -8.14854167e-03f, 1.02149881e-01f, -1.16978131e-01f, -1.16659723e-01f, -5.46782091e-02f, 2.43564650e-01f, 1.58574075e-01f, 1.95881948e-02f, 1.56644434e-02f, 1.22910559e-01f,
  -1.32607579e-01f, -1.75131876e-02f, 5.27336560e-02f, -5.41273803e-02f, 1.10658579e-01f, -1.07891306e-01f, 7.86188543e-02f, -2.29778975e-01f, -7.05032423e-02f, -2.02195086e-02f,
  -1.78923100e-01f, -7.50448275e-03f, 2.11345732e-01f, 3.99584472e-02f, 2.45295539e-02f, -1.49252815e-02f, -4.73149829e-02f, -1.18163705e-01f, -1.09913044e-01f, -8.62934291e-02f,
  2.36400887e-01f, -8.24031770e-01f, 2.55463719e-01f, 1.30598228e-02f, 7.70140067e-02f, -1.87731292e-02f, 1.55540600e-01f, -1.47335887e-01f, 5.85112907e-02f, -1.06974617e-01f,
  -1.70200408e-01f, 1.89112872e-02f, 2.13585496e-01f, -6.77679703e-02f, -2.83953786e-01f, -2.11419240e-01f, -2.48862609e-01f, -1.50397822e-01f, -1.71142027e-01f, -1.77212387e-01f,
  -1.41902030e-01f, -7.37481773e-01f, -3.17336559e-01f, -2.55179908e-02f, 1.61726493e-03f, -2.57420838e-01f, -2.04559192e-02f, -4.33545280e-03f, -4.85635698e-01f, -5.13141215e-01f,
  5.95763385e-01f, -1.85764536e-01f, -2.86176562e-01f, 6.96643531e-01f, 1.60942748e-01f, -3.50099206e-02f, -2.57787853e-01f, -1.90263186e-02f, 4.39340770e-01f, 2.92957664e-01f,
  2.74517685e-02f, 3.48000288e-01f, 3.18666786e-01f, 7.31408149e-02f, -8.02978352e-02f, 1.34561568e-01f, 3.81487280e-01f, 1.98853359e-01f, 2.70429611e-01f, 3.94474000e-01f,
  6.31010950e-01f, 4.42190796e-01f, 3.75670433e-01f, 3.05819243e-01f, 3.87368739e-01f, 4.70620900e-01f, 1.46345660e-01f, 2.03566968e-01f, 1.71951756e-01f, 5.81030369e-01f,
  1.47741914e-01f, -2.75750458e-01f, 2.30657160e-02f, 7.87258521e-02f, -2.19516352e-01f, 1.04097417e-02f, 2.48038452e-02f, -6.04905710e-02f, -2.38204319e-02f, 7.11007938e-02f,
  -6.20629452e-02f, -6.16932660e-02f, -2.01154649e-02f, -5.03932610e-02f, -1.01819538e-01f, -1.09000340e-01f, -5.12157232e-02f, -7.03312382e-02f, -2.64710069e-01f, -6.71047568e-02f,
  2.28548050e-01f, -2.23225188e-02f, -4.11406696e-01f, -2.59814054e-01f, -2.11208835e-01f, -6.63481057e-02f, -2.44366601e-01f, -9.78907049e-02f, -4.06400532e-01f, -3.25552225e-02f,
  1.55858509e-03f, -2.27714986e-01f, 4.04874012e-02f, 7.76608959e-02f, 3.05100441e-01f, 2.00726435e-01f, 9.56098177e-03f, -5.32101393e-02f, 5.92946522e-02f, -5.34236059e-02f,
  -4.03393507e-02f, 8.79484043e-02f, -1.40249595e-01f, 1.89200684e-01f, 2.53663421e-01f, -7.72674382e-02f, -5.81212416e-02f, -1.62873060e-01f, -1.90813571e-01f, -1.33848056e-01f,
  1.20246865e-01f, -8.34042057e-02f, 5.18085137e-02f, -5.25343530e-02f, 1.10884190e-01f, -1.09769396e-01f, 3.23512346e-01f, 6.30699843e-02f, 7.47278109e-02f, 1.32445753e-01f,
  7.65717728e-03f, -3.30829769e-01f, 3.35449457e-01f, -1.92936033e-01f, -2.04522207e-01f, -2.39684820e-01f, 6.23562932e-03f, -1.47139445e-01f, -1.33180782e-01f, 2.21632235e-02f,
  4.61949930e-02f, -7.85558447e-02f, -6.87955022e-02f, -7.32098892e-03f, 8.39107707e-02f, 3.99931297e-02f, -1.02517363e-02f, -1.32139668e-01f, -1.62606806e-01f, -2.46843427e-01f,
  -7.75097832e-02f, 9.79276001e-03f, 5.73445857e-03f, -2.40768716e-01f, 3.23780216e-02f, 8.34147856e-02f, -1.14664070e-01f, 4.03965153e-02f, -2.34898329e-01f, 1.87727734e-02f,
  3.42203081e-02f, -2.20429122e-01f, 1.94481224e-01f, 5.40584207e-01f, 7.20372975e-01f, 6.03535056e-01f, 4.71367568e-01f, 3.43559921e-01f, 3.22377801e-01f, 3.55224431e-01f,
  4.12069827e-01f, 3.72424990e-01f, 3.00630271e-01f, 1.85440272e-01f, 7.15406165e-02f, 1.52059123e-01f, 2.40567610e-01f, -3.08929905e-02f, 1.33130357e-01f, 2.34197631e-01f,
  1.10536441e-01f, 5.15320785e-02f, -2.56938249e-01f, -1.24019742e-01f, 1.49565786e-01f, 1.51160747e-01f, 1.80681720e-01f, 1.59942508e-01f, 2.31501926e-02f, -1.22010559e-01f,
  -2.98761483e-02f, -1.10147148e-02f, 2.01821774e-01f, -5.56432419e-02f, -1.96187407e-01f, -3.69431019e-01f, -5.67496847e-03f, -2.28283256e-01f, -1.52081206e-01f, -2.34970406e-01f,
  1.54925091e-02f, -1.04601130e-01f, 7.85429776e-02f, -3.67719196e-02f, -3.13970111e-02f, -1.28877154e-02f, -9.33908895e-02f, -4.50800918e-03f, 2.79765856e-02f, 5.66307157e-02f,
  5.05999513e-02f, 2.49060646e-01f, 2.88973391e-01f, 1.12565547e-01f, 6.05693413e-03f, 5.45604527e-02f, -7.27880821e-02f, -1.62367314e-01f, -7.68620148e-02f, -1.37052268e-01f,
  4.07325864e-01f, 2.12424397e-01f, 2.82701641e-01f, 2.51488507e-01f, 1.41071811e-01f, 1.15194991e-01f, 1.85828775e-01f, 1.69903710e-01f, 2.24001467e-01f, 4.35085669e-02f,
  -3.01961452e-02f, 1.15298353e-01f, 1.33584872e-01f, 3.95253450e-02f, 1.16120316e-01f, 1.42871991e-01f, -8.59919414e-02f, 9.31390654e-03f, 7.12188110e-02f, 2.81841271e-02f,
  9.16115865e-02f, 5.03502637e-02f, -1.35920197e-01f, -1.18634388e-01f, -2.83264113e-03f, 1.94383100e-01f, 4.04872894e-02f, -4.41719964e-03f, -1.11633658e-01f, -1.49314418e-01f,
  1.08546220e-01f, 4.67234284e-01f, 9.62898657e-02f, 1.50141967e-02f, -2.45781243e-02f, -1.49642244e-01f, 1.55870765e-01f, -1.08812802e-01f, -2.20994487e-01f, -9.45197791e-02f,
  2.77340878e-02f, -2.13608861e-01f, -2.13263165e-02f, -6.52147979e-02f, -6.31907210e-02f, -6.09369501e-02f, -1.13653094e-02f, 2.74456143e-01f, -3.61581817e-02f, -1.03280120e-01f,
  -1.70647636e-01f, 1.57381028e-01f, 2.39928693e-01f, 9.91039574e-02f, 1.18319824e-01f, 1.52121112e-01f, -1.51719779e-01f, -7.97129348e-02f, 2.42454614e-02f, -2.24975541e-01f,
  -1.08974302e+00f, 2.75753587e-01f, -2.80884683e-01f, -1.49792671e-01f, -1.95022419e-01f, -3.93447131e-01f, -2.86758780e-01f, -1.41622826e-01f, 7.40451515e-02f, 2.79603630e-01f,
  2.79859155e-01f, 2.19720319e-01f, 2.47534320e-01f, -3.06173563e-01f, -6.37335479e-01f, -3.51590663e-01f, -4.34014231e-01f, -9.11930323e-01f, -7.76875257e-01f, -3.78059596e-01f,
  -3.01913410e-01f, -6.15992725e-01f, -6.99900985e-01f, -3.95553201e-01f, 5.66975474e-01f, 1.29247487e-01f, 5.54770343e-02f, -2.36238256e-01f, -1.29488796e-01f, 3.70270684e-02f,
  4.54196870e-01f, -1.63697693e-02f, -9.97139141e-02f, -2.26262048e-01f, 8.59009251e-02f, -9.91417468e-02f, -4.59927581e-02f, 1.54665619e-01f, 1.13560751e-01f, 1.83217019e-01f,
  -5.84064573e-02f, -2.41363049e-02f, 4.50312532e-02f, 6.94198459e-02f, -2.14987099e-02f, -5.63141666e-02f, 1.25027835e-01f, -2.49336078e-03f, -6.19452563e-04f, 2.61080980e-01f,
  2.46602688e-02f, -2.22041398e-01f, 5.22748977e-02f, 2.26823524e-01f, 4.20420058e-02f, -1.73354626e-01f, 2.34087169e-01f, 1.00378513e-01f, 4.71161632e-03f, 3.13425869e-01f,
  -1.80986375e-01f, 2.53397048e-01f, 1.71789020e-01f, 4.04191315e-02f, 7.28696957e-02f, 1.07655115e-01f, 1.73171908e-01f, 1.15392707e-01f, -1.25414342e-01f, 9.29596499e-02f,
  1.53360575e-01f, 7.67339079e-04f, 1.08677000e-02f, -8.23548436e-02f, 3.29120597e-03f, 9.48351156e-03f, -1.30264759e-01f, 1.32462859e-01f, 4.62043770e-02f, 8.49666670e-02f,
  -3.66969742e-02f, -3.32591385e-02f, 7.17039853e-02f, 9.64484885e-02f, -3.66211012e-02f, 1.71620604e-02f, -7.05470890e-02f, -1.95325390e-01f, -9.44275633e-02f, -7.11559877e-02f,
  4.25828338e-01f, -4.54630136e-01f, 2.73223400e-01f, -8.44137818e-02f, 1.52853038e-03f, 9.60148349e-02f, 2.05059633e-01f, -4.25051674e-02f, 5.37898540e-02f, 5.86393625e-02f,
  -7.00939633e-03f, -5.82898632e-02f, 3.77675034e-02f, 2.61858046e-01f, -4.30612750e-02f, -7.96078295e-02f, 7.41140768e-02f, 8.80079493e-02f, -4.88035157e-02f, 3.14882517e-01f,
  1.18018068e-01f, -9.28916410e-02f, -5.82929961e-02f, 1.16933323e-01f, -3.83233652e-02f, -2.06043914e-01f, 2.52907932e-01f, 1.85813487e-01f, -7.39102066e-02f, 9.60327461e-02f,
  -8.33904803e-01f, 4.55393851e-01f, 3.16363811e-01f, -6.28901601e-01f, -1.46832347e-01f, 2.49199137e-01f, 5.78580558e-01f, 3.50176632e-01f, -1.99603647e-01f, -1.24325141e-01f,
  -3.56146753e-01f, -4.87851232e-01f, -3.43872309e-01f, 1.61460549e-01f, 4.94991243e-01f, 3.91275853e-01f, 4.81035262e-01f, 3.16993564e-01f, 8.94630104e-02f, 2.35670581e-01f,
  1.16274036e-01f, -2.01389596e-01f, -1.61648378e-01f, 1.32213399e-01f, -1.76539898e-01f, -1.56904235e-01f, -1.17886908e-01f, -2.68707365e-01f, 2.24274933e-01f, -5.84108457e-02f,
  -6.57707453e-01f, -1.90526515e-01f, 1.65005207e-01f, -3.80112052e-01f, -2.77696311e-01f, 2.62118489e-01f, 2.08787426e-01f, 1.79208159e-01f, -8.91553238e-02f, 1.98156327e-01f,
  -4.31505412e-01f, 7.88493678e-02f, -3.26974034e-01f, 5.85129112e-02f, -2.33890221e-01f, -5.27701490e-02f, 3.11293811e-01f, 3.18059444e-01f, 1.36375740e-01f, 2.53293037e-01f,
  1.82498217e-01f, -4.46164727e-01f, -3.66261125e-01f, 4.48309630e-01f, 3.25743049e-01f, -2.38958776e-01f, 2.81568430e-02f, -3.22176926e-02f, 3.11344206e-01f, -3.23034078e-01f,
  3.98155116e-02f, 1.12516209e-01f, 2.45697722e-01f, 3.08337301e-01f, -2.97540631e-02f, -1.39351442e-01f, -2.28453577e-02f, -8.67858157e-02f, -5.66145070e-02f, 7.01738149e-02f,
  1.09307662e-01f, -3.00601199e-02f, 9.33711603e-02f, -2.51666069e-01f, -2.15433180e-01f, -3.66084352e-02f, -1.27685517e-01f, -3.99103425e-02f, -6.99458867e-02f, 2.06520379e-01f,
  -1.58007309e-01f, -1.25675857e-01f, 1.00109745e-02f, 4.84389216e-02f, 2.25098059e-01f, 1.45987853e-01f, 3.01636267e-03f, -6.81820661e-02f, 1.42827019e-01f, 7.13941734e-03f,
  -3.47765535e-01f, 4.69971508e-01f, -4.04485255e-01f, 7.79367611e-02f, -1.59761488e-01f, -6.49179891e-02f, -2.55547408e-02f, 9.81291085e-02f, -1.47758543e-01f, 7.33216200e-03f,
  1.42644286e-01f, 8.64225030e-02f, -1.98998764e-01f, 2.08345667e-01f, -1.18380845e-01f, 9.94820613e-03f, 3.14921066e-02f, -1.86393470e-01f, 4.36855443e-02f, 1.92895323e-01f,
  1.19396910e-01f, -3.34497988e-01f, -6.71725571e-01f, -1.43224895e-01f, -5.10417186e-02f, -5.94163001e-01f, -3.69385332e-01f, -2.94774234e-01f, -2.55524904e-01f, -4.00112897e-01f,
  4.17086214e-01f, 6.97738767e-01f, 3.33747603e-02f, 5.50545752e-02f, -1.37375250e-01f, -2.76746284e-02f, 3.94140005e-01f, 2.09561840e-01f, -1.10738903e-01f, 1.56638652e-01f,
  -3.83695178e-02f, -1.39240816e-01f, 3.45267393e-02f, 1.65266886e-01f, 2.68995285e-01f, 3.70216966e-01f, 2.80939192e-01f, 2.37329602e-01f, 1.05251983e-01f, 7.76048675e-02f,
  5.22952378e-02f, 6.24938570e-02f, 5.35606630e-02f, 2.78650284e-01f, 3.76985401e-01f, -6.52408227e-02f, 9.44651067e-02f, 1.70896530e-01f, 2.17404693e-01f, 5.70531309e-01f,
  2.96502441e-01f, 4.54047501e-01f, -5.18428624e-01f, -2.16511622e-01f, -1.13940060e-01f, -4.09708917e-02f, -4.60780114e-02f, -1.07792933e-02f, 8.07814766e-03f, -2.47395760e-03f,
  -3.80994007e-02f, -2.64421981e-02f, -8.02865475e-02f, 1.33187035e-02f, -8.27104822e-02f, -2.23008953e-02f, 1.51547521e-01f, 2.71035194e-01f, 4.19051684e-02f, 6.34939224e-02f,
  1.12472497e-01f, 1.22710550e-03f, 7.90578276e-02f, -3.66650820e-02f, 1.10288575e-01f, -2.73752749e-01f, 1.00540388e-02f, 8.90173614e-02f, -1.16093747e-01f, 8.01300704e-02f,
  -7.99279101e-03f, 1.14753433e-01f, 9.97689441e-02f, 3.24281991e-01f, 1.60037443e-01f, 2.74195001e-02f, 1.37944296e-01f, 1.44637331e-01f, 2.30867267e-02f, -3.42663229e-02f,
  1.52993217e-01f, 1.35726556e-01f, 1.22776039e-01f, 1.88211538e-02f, -1.48488224e-01f, 7.97047317e-02f, 1.34930432e-01f, 2.61508338e-02f, -3.27663310e-02f, -9.90670249e-02f,
  -6.66698813e-02f, 9.08875391e-02f, -2.12060288e-01f, 2.65410990e-01f, -6.82474524e-02f, -1.92238852e-01f, -2.45730072e-01f, -1.37355626e-01f, -1.70833260e-01f, -8.15283209e-02f,
  -6.12328291e-01f, -6.67989552e-01f, 2.30332986e-02f, 2.17380807e-01f, -1.26124352e-01f, -1.66658163e-01f, -4.35639732e-02f, -1.15404509e-01f, -7.52920136e-02f, 9.81094316e-02f,
  -5.47775589e-02f, 7.82674700e-02f, -1.22701049e-01f, -1.05914950e-01f, -8.32461417e-02f, -2.10179165e-01f, -7.95576870e-02f, -2.12423839e-02f, -3.25688086e-02f, 9.94114801e-02f,
  -6.40304154e-03f, -2.79019535e-01f, -2.96815664e-01f, -1.31009415e-01f, -1.97965533e-01f, -4.17810410e-01f, -2.16257051e-01f, -3.09141368e-01f, -4.36563343e-01f, -2.92559773e-01f,
  7.92905409e-03f, 9.31534693e-02f, -1.46291047e-01f, -5.26136994e-01f, -5.98534763e-01f, -1.42049640e-01f, 8.96793418e-03f, -1.85088187e-01f, -2.88361162e-01f, 1.40358915e-03f,
  4.84198749e-01f, 8.63906682e-01f, 8.26286912e-01f, 8.58402848e-01f, 8.48178864e-01f, 4.47413586e-02f, -5.27440012e-01f, 5.82375340e-02f, 4.12543833e-01f, 2.53817827e-01f,
  1.22465948e-02f, -5.58785915e-01f, -3.41519952e-01f, -1.26213878e-01f, -5.76840103e-01f, 1.46520391e-01f, -5.64661562e-01f, -7.21382797e-01f, -8.78563151e-02f, -8.69263709e-01f,
  6.76547229e-01f, -4.94435072e-01f, 2.18133956e-01f, -1.63805448e-02f, 5.74806631e-02f, 1.37505665e-01f, 1.72510326e-01f, -3.35408449e-01f, 8.81505664e-04f, -2.37833962e-01f,
  -1.72878861e-01f, -1.30836396e-02f, -2.48537585e-01f, -1.51222765e-01f, -4.26667273e-01f, -1.43949181e-01f, -1.45980552e-01f, -3.01121492e-02f, -6.15223087e-02f, 1.29650563e-01f,
  1.42093124e-02f, -4.76818711e-01f, -3.14535797e-01f, 1.41960755e-01f, 3.80095514e-03f, 5.11038024e-03f, -2.66056418e-01f, -3.56067568e-01f, -8.35812986e-02f, -8.31421852e-01f,
  8.14216733e-02f, 4.05254476e-02f, -1.64918806e-02f, -1.02693401e-02f, 1.76776499e-01f, 1.04971252e-01f, 1.72172636e-02f, -5.46840988e-02f, -1.12031773e-01f, -1.03990734e-01f,
  -1.34892529e-02f, 1.08897373e-01f, -2.21322104e-02f, -4.74147685e-02f, 1.30700514e-01f, -2.91140169e-01f, -3.22026871e-02f, 1.53259426e-01f, 3.79344821e-02f, -6.59245849e-02f,
  1.01847515e-01f, -1.76844612e-01f, -6.85093552e-02f, 1.74600989e-01f, 4.40826342e-02f, 1.31965265e-01f, -3.69628482e-02f, 1.75528210e-02f, 6.76894113e-02f, -2.16651171e-01f,
  2.67335773e-01f, 3.54467571e-01f, 2.58561611e-01f, 1.40489221e-01f, -2.78236061e-01f, -3.72168683e-02f, 1.12193257e-01f, 4.55719512e-03f, 9.07318294e-03f, 1.64031714e-01f,
  1.40519887e-01f, 1.58091813e-01f, -6.41187057e-02f, -1.67594001e-01f, 4.73440252e-03f, -2.23091710e-02f, 1.58309147e-01f, 1.93090960e-01f, -1.22589707e-01f, -2.34286010e-01f,
  -1.96971521e-01f, -3.49524975e-01f, 2.17142835e-01f, 2.71487385e-01f, -1.96721166e-01f, 1.21156953e-01f, 1.53143927e-01f, 2.60651290e-01f, 3.43905926e-01f, -9.12633911e-03f,
  -5.17990887e-01f, 4.52212095e-01f, -8.67213607e-02f, 1.39168635e-01f, 4.15746897e-01f, 4.89405751e-01f, 5.40600419e-01f, 3.67469579e-01f, 1.42476752e-01f, 3.40467721e-01f,
  5.13510048e-01f, 3.64385694e-01f, 2.40364090e-01f, 1.19194940e-01f, 1.10078573e-01f, 3.11229825e-01f, 1.35973886e-01f, -2.99431652e-01f, -3.01666021e-01f, 1.92957252e-01f,
  4.44153160e-01f, 1.46482661e-01f, -1.92768067e-01f, -8.99702013e-02f, 1.66371912e-01f, 1.21615015e-01f, 1.77627385e-01f, 3.53859395e-01f, 4.50247049e-01f, -1.37911543e-01f,
  -4.50786427e-02f, 1.56931326e-01f, -1.71335608e-01f, 6.40642941e-02f, 7.43450224e-02f, -2.45297700e-01f, -3.59506495e-02f, -2.68400937e-01f, -3.62877883e-02f, 1.91567186e-02f,
  -6.62823766e-02f, -9.98324528e-02f, -4.94856238e-02f, -1.11117087e-01f, -6.56961799e-02f, -6.51830956e-02f, -2.26579756e-01f, -5.58254756e-02f, 2.85062082e-02f, -3.68416458e-02f,
  4.04921956e-02f, 2.12046221e-01f, 1.81597710e-01f, 6.96435869e-02f, 1.89157039e-01f, 9.60168988e-02f, -3.97945847e-03f, -8.95184129e-02f, -3.97220850e-02f, -1.86644807e-01f,
  -1.28866760e-02f, -1.71771094e-01f, -1.68563146e-02f, -8.12138021e-02f, 3.60751338e-02f, -1.46066742e-02f, -8.86172056e-02f, 1.40258819e-01f, 1.91309322e-02f, -5.08193560e-02f,
  5.69020584e-02f, 1.76318884e-02f, -1.36312023e-01f, 1.09005030e-02f, -1.42108291e-01f, -7.51408413e-02f, -6.99485987e-02f, -1.59606382e-01f, -5.65937087e-02f, -1.39140442e-01f,
  -5.25589660e-02f, -4.54696417e-02f, -7.71428794e-02f, -3.08517218e-02f, -6.32955432e-02f, 1.14895040e-02f, -5.56803271e-02f, 9.06844288e-02f, 9.92823094e-02f, -1.81316156e-02f,
  2.79628396e-01f, 1.34673059e-01f, -1.69229805e-01f, -2.05331609e-01f, -8.25612247e-02f, -1.19872876e-01f, -6.71318397e-02f, -5.00124879e-02f, -1.37518384e-02f, 1.11004367e-01f,
  3.29869203e-02f, -2.46537328e-01f, -5.39590977e-02f, -1.31206751e-01f, -1.53031215e-01f, -3.57595049e-02f, -8.71152505e-02f, -1.70463860e-01f, 8.05742741e-02f, -6.91944594e-03f,
  -1.13615535e-01f, -2.55658738e-02f, -1.61542326e-01f, -1.08948901e-01f, 6.91231266e-02f, 2.77677588e-02f, -5.51421475e-03f, -3.36935259e-02f, 2.16153413e-02f, -1.62472129e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.06563771e+00f, 7.63877749e-01f, 1.03093088e+00f, 5.17060339e-01f, 8.71413171e-01f, 7.80223846e-01f, 6.81141675e-01f, 1.49360716e+00f, 5.80380499e-01f, 8.51148427e-01f,
  3.62162799e-01f, 4.43587333e-01f, 1.29596519e+00f, 6.47464931e-01f, 4.89111394e-01f, 7.25016952e-01f, 1.05419457e+00f, 1.43846303e-01f, 8.39627862e-01f, 2.76860148e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.23851955e-01f, -7.32662082e-01f, -5.04339933e-01f, -3.32739592e-01f, -6.11767992e-02f, -4.57827389e-01f, -2.90303022e-01f, -1.60377085e-01f, -5.87124944e-01f, 1.02232341e-02f,
  1.58163160e-01f, -7.06951320e-01f, -5.05210459e-01f, 3.68543774e-01f, -5.13948262e-01f, 2.72697419e-01f, -1.76294148e-01f, -1.28260672e+00f, 1.99309319e-01f, -2.74018615e-01f,
  4.43584502e-01f, 2.30886877e-01f, 5.37964821e-01f, 4.61608857e-01f, -1.40206265e+00f, -2.06910118e-01f, -8.65633130e-01f, 6.80123791e-02f, 2.09029183e-01f, -3.06980349e-02f,
  8.26164559e-02f, -5.20172715e-01f, 1.18175358e-01f, 8.19097236e-02f, -1.49130031e-01f, 4.17049825e-02f, 9.54059735e-02f, 6.99694604e-02f, 1.77853405e-01f, -3.14772815e-01f,
  -2.18602374e-01f, 1.65922478e-01f, 1.61998838e-01f, 7.31610209e-02f, 4.81791764e-01f, 8.12043548e-01f, -5.65067492e-02f, 9.04003501e-01f, -1.07941997e+00f, -3.78609061e-01f,
  3.96694362e-01f, -4.63518649e-02f, -4.48792875e-01f, 2.96608895e-01f, -1.24843955e+00f, -6.49283409e-01f, -6.20127320e-01f, 3.56481075e-01f, 7.63388798e-02f, -5.62150657e-01f,
  -1.59838998e+00f, 4.68371585e-02f, 9.05543864e-01f, -8.35307613e-02f, 2.22465932e-01f, 5.20008542e-02f, 1.55688927e-01f, 1.77104175e-01f, 1.74718872e-01f, 1.06469609e-01f,
  -4.45014060e-01f, -1.21633038e-01f, 8.69168788e-02f, 9.79749262e-02f, 2.97537506e-01f, 6.22896515e-02f, -3.72124523e-01f, 6.52045071e-01f, -1.24130785e-01f, 8.80864263e-01f,
  -8.06046486e-01f, -4.34824765e-01f, -1.29162180e+00f, -1.33034751e-01f, 2.02721119e-01f, 3.02040517e-01f, 9.06021714e-01f, -9.35165942e-01f, 1.07327402e-01f, -4.18082356e-01f,
  -1.22796983e-01f, -1.10035765e+00f, 7.34120727e-01f, -7.10958242e-01f, -3.01491562e-02f, -1.25256956e+00f, -1.42837331e-01f, 2.15314910e-01f, 3.25158462e-02f, -2.54015289e-02f,
  -2.77290016e-01f, 3.25590044e-01f, 9.88128781e-01f, 1.66625470e-01f, -2.73377955e-01f, 1.78194851e-01f, -7.23450720e-01f, 6.98487937e-01f, -2.18717217e-01f, -1.05342340e+00f,
  7.06032872e-01f, 5.26522279e-01f, 8.24805796e-02f, 8.79632354e-01f, -6.43663645e-01f, -8.98033082e-01f, 8.62344921e-01f, -1.62205696e+00f, -5.77362597e-01f, 5.24440557e-02f,
  -7.74715066e-01f, -7.70576179e-01f, -9.06982243e-01f, 1.26286283e-01f, 7.48202085e-01f, -6.03533566e-01f, 2.49258667e-01f, -2.18441337e-01f, 4.86494564e-02f, 5.77104352e-02f,
  2.54204601e-01f, -2.16155663e-01f, 7.81811476e-02f, 2.57866774e-02f, -4.93725419e-01f, -4.83176976e-01f, 3.90176505e-01f, 1.94915026e-01f, -5.64028136e-02f, 3.59625638e-01f,
  -5.30330956e-01f, -4.49780881e-01f, -1.00007117e+00f, 3.08204800e-01f, 5.55923343e-01f, -5.85159212e-02f, -4.17243212e-01f, -3.37291032e-01f, -7.22911656e-01f, -5.15473299e-02f,
  -1.61335334e-01f, 3.63922805e-01f, 9.05356467e-01f, -1.23497081e+00f, 3.78463089e-01f, 5.79556644e-01f, -2.76611567e-01f, -3.24823171e-01f, -3.64449978e-01f, 2.55262613e-01f,
  9.75786299e-02f, 2.74636060e-01f, 6.91140771e-01f, 5.26428409e-02f, 3.62194747e-01f, -2.00430512e-01f, -3.90732169e-01f, -3.79136950e-01f, 3.64240259e-02f, -2.37912968e-01f,
  -1.31675795e-01f, -6.01039648e-01f, -5.87342083e-02f, 7.42143154e-01f, 2.50882208e-01f, -1.28217399e+00f, 9.94839072e-01f, -1.21887183e+00f, 7.77345359e-01f, -4.46705520e-01f,
  -1.30757236e+00f, 7.07648974e-03f, 1.26814023e-01f, -2.78519392e-01f, -7.68108964e-01f, 5.84532797e-01f, -6.07610464e-01f, 1.42839134e-01f, -1.59437507e-01f, -6.35085821e-01f,
  -2.09930226e-01f, 3.29933643e-01f, 1.40230224e-01f, 2.25626066e-01f, -2.44767144e-01f, -2.01410353e-01f, -2.15343207e-01f, -4.18594256e-02f, -4.62223917e-01f, 2.18331367e-02f,
  4.86952245e-01f, -2.72083551e-01f, 5.88838041e-01f, 5.64304948e-01f, 4.40217465e-01f, -3.25366169e-01f, -1.02634823e+00f, -8.07810247e-01f, -9.69198823e-01f, -4.33952272e-01f,
  -7.07018554e-01f, 3.75504255e-01f, -9.29600120e-01f, 3.27687591e-01f, -1.02180588e+00f, -7.58207679e-01f, 7.21135616e-01f, 2.86784112e-01f, -1.13466537e+00f, -1.53400528e+00f,
  3.29618543e-01f, 8.51474404e-01f, -8.12778294e-01f, -5.62417388e-01f, -9.65259820e-02f, -9.32688490e-02f, -5.68629026e-01f, -2.61162966e-01f, -8.00254717e-02f, -7.80630261e-02f,
  -1.01830900e-01f, -1.55663028e-01f, 1.60869703e-01f, 4.73815314e-02f, -4.94840622e-01f, -4.78490919e-01f, -1.18295872e+00f, -4.81347561e-01f, 7.36842453e-02f, -7.05046058e-01f,
  1.10468134e-01f, 1.13776937e-01f, -2.82736361e-01f, -5.22254825e-01f, 8.43208790e-01f, -5.78192353e-01f, -1.07326932e-01f, -6.68214798e-01f, -9.00522918e-02f, -1.34083956e-01f,
  3.57936174e-01f, -6.43794596e-01f, 6.78105056e-01f, 1.22691236e-01f, -9.30397689e-01f, 5.32665372e-01f, -9.29231718e-02f, 7.58771673e-02f, 6.43754154e-02f, 3.02777201e-01f,
  -9.14873406e-02f, 3.46173793e-01f, 3.39420319e-01f, 3.04455072e-01f, -4.46500987e-01f, -2.07616106e-01f, -6.46387339e-01f, -6.47858083e-01f, 2.32321590e-01f, -8.79794806e-02f,
  4.42847073e-01f, -4.17515904e-01f, -8.38501811e-01f, -7.66393304e-01f, -2.56914794e-01f, 1.48801064e+00f, -2.84868300e-01f, -8.57573807e-01f, -7.86534071e-01f, -6.53670907e-01f,
  -5.02921343e-01f, 2.63460100e-01f, 2.29982466e-01f, -9.79112148e-01f, -1.32200241e-01f, -6.11581087e-01f, -8.46410155e-01f, -6.33230507e-01f, -5.91925800e-01f, 4.10233364e-02f,
  -7.28504360e-02f, 4.62288558e-01f, -2.78780371e-01f, 3.88197660e-01f, -3.63675237e-01f, -1.99921653e-01f, 7.22242892e-01f, 3.56942803e-01f, 5.94587088e-01f, 4.60107714e-01f,
  2.85790145e-01f, -9.37884450e-01f, -1.13952303e+00f, -1.69117165e+00f, -1.06310420e-01f, -7.79198349e-01f, -6.66540042e-02f, -7.08662271e-01f, 6.01169944e-01f, 2.61932202e-02f,
  9.73847210e-01f, 8.22347224e-01f, 7.01370001e-01f, 1.86779469e-01f, -1.88089520e-01f, 2.15682372e-01f, -1.32156324e+00f, -4.08157945e-01f, -1.13417232e+00f, -3.41390759e-01f,
  1.17999427e-01f, 3.27591032e-01f, 3.37511420e-01f, 1.36169955e-01f, -2.57576346e-01f, 1.93388864e-01f, 4.50207800e-01f, 5.60983956e-01f, -1.50080889e-01f, 3.75037462e-01f,
  -4.40868050e-01f, 1.08666003e-01f, -9.15510774e-01f, -1.19070244e+00f, 4.40694898e-01f, -1.64973363e-01f, -1.08224463e+00f, -4.18912441e-01f, 9.15252626e-01f, -6.12466931e-01f,
  -5.82417190e-01f, -1.02340102e+00f, -6.96214616e-01f, -9.93955016e-01f, 6.52347624e-01f, -5.30990183e-01f, -5.37059426e-01f, 4.94521081e-01f, -4.96439219e-01f, 3.44976485e-01f,
  1.25277102e+00f, 3.06829154e-01f, 2.50883907e-01f, -3.08905095e-01f, 4.62617397e-01f, -1.22638173e-01f, 2.27155507e-01f, -2.95725409e-02f, 7.34118879e-01f, 6.20604575e-01f,
  5.42500973e-01f, -4.40608323e-01f, 6.31677985e-01f, 4.86559421e-01f, 2.78392434e-01f, -9.11810517e-01f, -1.23761415e+00f, -7.07880437e-01f, -2.26149648e-01f, 1.29284930e+00f,
  -3.09607834e-01f, 5.25073767e-01f, -5.40952265e-01f, -6.17952347e-01f, -7.98010290e-01f, 4.25305396e-01f, -1.21852589e+00f, -8.30436587e-01f, 2.18796119e-01f, -2.05560267e-01f,
  -2.41392832e-02f, 3.45131636e-01f, -6.45622194e-01f, 1.83470234e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.09060895e-01f, -4.23132271e-01f, 3.65600765e-01f, -1.51056901e-01f, -1.89914301e-01f, 2.30001241e-01f, 1.26648694e-01f, 3.63610946e-02f, 2.40593210e-01f, 3.72392088e-01f,
  6.47726506e-02f, 5.11185229e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    