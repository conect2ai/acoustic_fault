/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.86462533e-01f, -4.65061009e-01f, 1.98479831e-01f, -2.82952100e-01f, 1.61557794e-01f, -2.16615111e-01f, 6.70653358e-02f, -9.78143960e-02f, 1.15416698e-01f, -5.66097908e-02f,
  6.56291470e-02f, -7.12942006e-03f, 8.88560936e-02f, -1.77644327e-01f, -2.96036541e-01f, -1.33890271e-01f, -2.00148076e-01f, -1.34845786e-02f, -3.57975699e-02f, -5.06686829e-02f,
  -1.13292851e-01f, -2.57743359e-01f, -4.58403565e-02f, -1.42319694e-01f, 1.98010802e-01f, 8.74764845e-02f, -3.69618572e-02f, 3.40260416e-02f, -1.92711912e-02f, 2.76425537e-02f,
  8.57288018e-02f, 1.58597842e-01f, 1.41110629e-01f, 7.47516099e-03f, 3.42868548e-03f, 8.15228820e-02f, 1.81147130e-03f, 7.74514824e-02f, 7.01902285e-02f, -7.84795731e-02f,
  -4.57692109e-02f, -2.45841872e-02f, -1.04718961e-01f, -6.58617765e-02f, -1.56671140e-05f, 9.88284312e-03f, 4.08912897e-02f, 4.72486168e-02f, -1.83905603e-03f, -1.07443482e-02f,
  -2.19595209e-02f, 4.50062053e-03f, 9.14745405e-02f, 4.53932881e-02f, 1.04371058e-02f, -7.38804042e-02f, -1.53760118e-02f, 1.06010459e-01f, 2.09113006e-02f, 9.54840519e-03f,
  7.84011707e-02f, 1.03149749e-02f, 6.56934604e-02f, 1.81575399e-02f, -5.79401851e-02f, 3.70358862e-02f, -5.50199579e-03f, 3.10891122e-02f, -2.88368333e-02f, -2.15905309e-02f,
  5.66930398e-02f, 6.04034681e-03f, 5.92343807e-02f, 6.18639849e-02f, -3.37505690e-03f, 3.27783488e-02f, 5.73640130e-02f, 4.76534814e-02f, 3.25916298e-02f, 2.82863770e-02f,
  -3.31212743e-03f, -5.33603923e-03f, -1.31978532e-02f, -3.08382837e-03f, -4.22638617e-02f, 6.86108917e-02f, 5.65165207e-02f, 2.92254072e-02f, 7.18098432e-02f, -9.10152495e-03f,
  -1.28507257e-01f, -2.10094616e-01f, -2.61522662e-02f, 1.79242454e-02f, -2.23789830e-02f, -8.95143896e-02f, -3.38937379e-02f, -3.82724777e-02f, -8.84049758e-02f, 9.09169670e-03f,
  1.97827518e-02f, 2.41221022e-02f, 1.02498248e-01f, 1.38347140e-02f, -3.55073512e-02f, -1.88660622e-02f, -6.12690710e-02f, -3.73531058e-02f, -1.64975077e-02f, -3.15618329e-03f,
  -2.68506985e-02f, 4.66720350e-02f, 4.48390953e-02f, -1.91034768e-02f, 2.04010773e-02f, 4.79279533e-02f, 2.90612429e-02f, -5.80903664e-02f, 1.98006146e-02f, -2.10426450e-02f,
  -2.38861471e-01f, -4.42134917e-01f, -4.14598035e-03f, -7.01667136e-03f, 2.08193630e-01f, -5.98074906e-02f, 1.79126948e-01f, -2.71861166e-01f, -2.88108736e-01f, -3.28899652e-01f,
  1.05500810e-01f, -1.63884118e-01f, -1.37891239e-02f, -1.21020325e-01f, 2.50685424e-01f, -5.37334643e-02f, -2.53917817e-02f, -8.76571145e-03f, -9.78031531e-02f, -2.92632189e-02f,
  5.26223481e-02f, 1.45343974e-01f, 2.12328538e-01f, -1.20065108e-01f, 9.69534442e-02f, -4.28184047e-02f, 2.11756989e-01f, 1.30066320e-01f, 6.62273765e-02f, 1.66114599e-01f,
  1.12619206e-01f, -1.42213956e-01f, -4.44611832e-02f, -4.38509807e-02f, -3.25014405e-02f, 6.94660619e-02f, 4.92138602e-02f, 1.45435914e-01f, 4.60581332e-02f, -7.80042484e-02f,
  -4.12691273e-02f, 3.66736646e-03f, 1.83451511e-02f, 1.32213719e-02f, -4.68361266e-02f, -4.91569750e-02f, -2.71783695e-02f, 5.50509081e-04f, 2.18499228e-02f, -2.43349764e-02f,
  -2.07743905e-02f, -3.03700995e-02f, -1.97148952e-03f, 5.49931377e-02f, 3.03686038e-02f, -7.27782547e-02f, 3.85484584e-02f, 9.50070545e-02f, -6.41865656e-02f, -4.81845401e-02f,
  -7.92871565e-02f, -4.16858681e-03f, 2.83605736e-02f, -1.75907742e-02f, 1.00832554e-02f, 1.29102264e-02f, -1.94359794e-02f, -2.72467895e-03f, 9.09270253e-03f, -5.51500432e-02f,
  3.73383574e-02f, 2.64364854e-02f, -2.35629268e-03f, -2.00676043e-02f, 5.70066944e-02f, -3.47073041e-02f, 4.56887335e-02f, 3.50945927e-02f, -7.08683301e-03f, -5.86828729e-03f,
  1.47776143e-03f, 2.90718377e-02f, -1.12007679e-02f, 3.23652588e-02f, 8.55423324e-03f, -9.79494490e-03f, -4.79001515e-02f, -1.32033657e-02f, 3.15642655e-02f, 3.49729992e-02f,
  -1.10168673e-01f, -2.38155529e-01f, -5.30214570e-02f, 3.81799671e-03f, 3.97394784e-03f, -1.45435892e-02f, -6.64001107e-02f, -1.07436389e-01f, -1.23591733e-03f, 2.35777069e-02f,
  -6.02878677e-03f, 1.95407532e-02f, -1.06792212e-01f, 4.16530743e-02f, 3.78041565e-02f, -6.48804083e-02f, 7.18582273e-02f, 1.40418597e-02f, 2.53841318e-02f, -9.56399366e-03f,
  -8.99431389e-03f, 3.23696784e-03f, 7.86542078e-04f, -2.58231536e-03f, -1.43081909e-02f, 2.88870092e-02f, 2.70863553e-03f, -9.45862830e-02f, 3.79916504e-02f, 1.59546658e-02f,
  1.96004380e-02f, 1.85038581e-01f, -2.29076073e-01f, 9.76944491e-02f, 7.72617310e-02f, -9.08133537e-02f, 2.47960668e-02f, 1.91356316e-01f, 9.22716036e-02f, 2.05692440e-01f,
  2.08404750e-01f, -1.81870624e-01f, 6.87100962e-02f, 1.66912377e-01f, -4.64294404e-01f, 1.93940829e-02f, -2.30313484e-02f, -1.27419103e-02f, 6.12430535e-02f, 6.30199239e-02f,
  -1.78048722e-02f, 1.51604787e-01f, -1.26406327e-01f, 4.93379496e-02f, 1.03749782e-01f, 1.02593694e-02f, -7.62800127e-02f, -3.32541466e-02f, -6.59941062e-02f, -6.25849590e-02f,
  1.17095083e-01f, 1.69566110e-01f, 4.25404385e-02f, 3.25684920e-02f, 8.60410929e-02f, -4.21380848e-02f, -5.08407317e-02f, -3.50435041e-02f, -5.16881049e-02f, 2.47752499e-02f,
  9.94755980e-03f, -5.97829057e-04f, -9.74160805e-03f, -5.05930604e-03f, 2.97006331e-02f, 4.55607213e-02f, 3.54643390e-02f, 4.55059670e-02f, 8.96064099e-03f, -3.20783965e-02f,
  4.79714386e-03f, -2.05216762e-02f, 4.31248434e-02f, 8.57076887e-03f, -5.09226806e-02f, 3.28266211e-02f, -3.58379260e-02f, -1.04713634e-01f, 9.02110990e-03f, 6.76758885e-02f,
  -2.19830535e-02f, -2.22939420e-02f, -1.52414502e-03f, 6.55139014e-02f, 3.18938643e-02f, 8.81156325e-02f, 3.94936800e-02f, -7.34561728e-03f, 2.20912360e-02f, 2.38845721e-02f,
  1.90774519e-02f, 3.73703539e-02f, 2.14890372e-02f, 1.11074485e-02f, 1.66039728e-02f, 3.89231369e-02f, -2.37304047e-02f, 3.05998251e-02f, 1.46466084e-02f, 3.04981507e-02f,
  1.48296840e-02f, 2.20339950e-02f, 2.40748748e-02f, -2.23936159e-02f, 3.54017951e-02f, -2.73221210e-02f, 5.20915836e-02f, 1.74014643e-02f, 4.03796788e-04f, -7.55984262e-02f,
  2.60340124e-01f, -2.14757863e-02f, 7.49300718e-02f, 9.83798727e-02f, -5.81505802e-03f, -4.41611297e-02f, -5.81643991e-02f, -3.47134657e-02f, 3.00379060e-02f, 2.44970061e-02f,
  2.61424873e-02f, 1.23394635e-02f, -1.16550492e-03f, 1.45183951e-02f, 4.00377857e-03f, -1.52769778e-02f, -3.62617001e-02f, 9.40321200e-03f, 2.08101459e-02f, 8.48320033e-03f,
  1.93414763e-02f, 1.87982488e-02f, -4.49708626e-02f, 4.87765819e-02f, 7.38240359e-03f, 3.08045354e-02f, -2.12287102e-02f, -4.98050312e-03f, -4.61255200e-02f, -5.84169105e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.87036830e-01f, 1.07482344e-01f, -2.01905593e-01f, 2.75639564e-01f, 1.73061430e-01f, -3.19028348e-02f, -4.08701718e-01f, 1.76853389e-01f, -2.75152683e-01f, -3.03271823e-02f,
  1.86218858e-01f, 2.31926274e-02f, -2.88864881e-01f, 3.87967259e-01f, 3.98262382e-01f, -1.06328867e-01f, 4.03963894e-01f, 1.87226176e-01f, -4.40591425e-02f, 2.26750404e-01f,
  2.09076867e-01f, 6.01235867e-01f, 1.45737201e-01f, 4.01220024e-01f, 3.02997410e-01f, 8.69819373e-02f, 3.53455901e-01f, -1.53420657e-01f, 3.76326263e-01f, 2.06710652e-01f,
  2.45795120e-02f, 3.55253033e-02f, -8.89637880e-03f, -2.05209535e-02f, -3.67996991e-02f, -1.47614721e-02f, -1.10768192e-01f, -7.31928414e-03f, -4.31794487e-02f, -8.34505036e-02f,
  -8.72591287e-02f, 6.13268502e-02f, 8.00422020e-03f, 6.93499073e-02f, -3.74158584e-02f, -9.09603834e-02f, -9.22901258e-02f, -5.34812137e-02f, -1.03598237e-01f, -1.71017330e-02f,
  -9.92290229e-02f, 6.03201240e-02f, 5.31336945e-03f, 5.96149452e-03f, -6.64519817e-02f, 3.42822410e-02f, -9.92161781e-02f, -5.89535572e-02f, -1.88095830e-02f, 6.06851419e-04f,
  9.96697769e-02f, -3.66790555e-02f, -5.05558178e-02f, -2.25062985e-02f, 8.67631510e-02f, 8.19720142e-03f, -3.47207263e-02f, 2.41842084e-02f, -1.22049823e-01f, 6.66964501e-02f,
  -7.81038310e-03f, -5.74108399e-03f, 1.37434080e-02f, -5.80292568e-03f, 2.41305847e-02f, -1.61231197e-02f, -4.03216593e-02f, 6.97330013e-02f, -3.36046144e-02f, 4.27903980e-02f,
  -1.60563178e-02f, 4.13172171e-02f, -2.75288634e-02f, 1.89563129e-02f, 6.74319547e-03f, 1.40406946e-02f, 8.64613950e-02f, 4.96626571e-02f, -9.13533345e-02f, 1.53486365e-02f,
  1.18539445e-01f, 2.50216752e-01f, -7.25472048e-02f, 2.83755064e-02f, -4.95804548e-02f, 9.28840488e-02f, -6.51639178e-02f, 1.41924322e-01f, 1.43305296e-02f, 1.70704275e-02f,
  2.17320304e-02f, -6.42240122e-02f, 2.04878524e-02f, -1.58423483e-02f, 1.69548690e-02f, -1.47558087e-02f, 2.29464890e-03f, -1.17011564e-02f, 2.21626200e-02f, 7.81068802e-02f,
  -2.51848418e-02f, -6.98687211e-02f, -5.98383248e-02f, 5.25064813e-03f, 5.90055250e-02f, -7.83972666e-02f, 9.03166085e-03f, -5.39404601e-02f, 6.20496720e-02f, -4.42114621e-02f,
  -5.50449848e-01f, 2.89218217e-01f, -4.84417915e-01f, -3.22987467e-01f, 1.00875348e-01f, -2.30476752e-01f, -1.33818641e-01f, 6.42734095e-02f, -1.74629062e-01f, 5.70943296e-01f,
  2.86226094e-01f, -3.21252108e-01f, 2.22576678e-01f, -1.44811258e-01f, -5.92945397e-01f, -1.20175980e-01f, -2.01495990e-01f, -3.06942258e-02f, -1.63728893e-01f, 5.55157028e-02f,
  -2.09610730e-01f, 1.74925864e-01f, -2.01208174e-01f, 4.31311548e-01f, 3.95939872e-02f, 4.36615981e-02f, 4.88023967e-01f, 1.83243617e-01f, 5.14645129e-02f, -7.07364380e-02f,
  -8.17456692e-02f, -1.26823438e-02f, -5.71744181e-02f, -1.56487077e-01f, 4.43978310e-02f, 1.26087785e-01f, -1.09369373e-02f, -1.02390140e-01f, -2.59154998e-02f, -9.58068967e-02f,
  -1.09241465e-02f, -5.54761253e-02f, -1.01688705e-01f, -1.79745574e-02f, -3.16101722e-02f, -6.76001683e-02f, -1.68759719e-01f, -7.70080313e-02f, -3.21785808e-02f, -8.44760314e-02f,
  -1.42979294e-01f, -3.03067993e-02f, 8.47386289e-03f, -3.68512757e-02f, -8.03436115e-02f, -4.42172959e-02f, -1.95171237e-02f, 2.34483667e-02f, 4.19963598e-02f, -9.53228623e-02f,
  6.26536384e-02f, 9.70523581e-02f, -3.41014117e-02f, -3.26439962e-02f, 3.15415524e-02f, 8.24089870e-02f, -5.52371815e-02f, -1.25810737e-03f, -2.39881836e-02f, 7.23378286e-02f,
  -3.51340510e-02f, -8.45649093e-02f, -2.70513576e-02f, -3.02900393e-02f, -3.82768475e-02f, -2.51146164e-02f, -1.60845648e-02f, 4.09976803e-02f, -1.85249615e-02f, -2.63835322e-02f,
  6.08115084e-02f, 4.77877744e-02f, 4.45986055e-02f, 5.81317805e-02f, -1.55595383e-02f, -2.51423232e-02f, 1.03522107e-01f, -2.52317730e-02f, -2.10078135e-02f, 1.49633521e-02f,
  1.41124278e-01f, 3.29367250e-01f, 1.48743745e-02f, 3.43227237e-02f, -4.07613181e-02f, -7.27716461e-02f, -8.07970762e-02f, -6.64283782e-02f, 1.56102180e-02f, 4.37027998e-02f,
  1.31588191e-01f, 2.35334989e-02f, 1.36216387e-01f, -3.44210886e-03f, -5.75073212e-02f, 7.07148239e-02f, 1.55517042e-01f, 2.47441046e-02f, 9.91894901e-02f, -9.34720878e-03f,
  1.29823834e-01f, 2.00780779e-02f, -7.08187595e-02f, 5.95471747e-02f, -1.70301273e-02f, 8.54930803e-02f, 4.14193124e-02f, 3.60532152e-03f, 3.79742007e-03f, 5.63358068e-02f,
  -6.09426320e-01f, 2.09639400e-01f, -1.52381077e-01f, 8.08040872e-02f, -3.17746788e-01f, 2.81059057e-01f, 2.30752960e-01f, -2.24775635e-02f, -1.50737509e-01f, 3.96941334e-01f,
  1.90152466e-01f, -2.93914855e-01f, 2.26269856e-01f, 4.85400885e-01f, -2.43629962e-01f, 4.15237218e-01f, 2.87934989e-01f, 2.67763853e-01f, -2.03691088e-02f, 6.86580688e-02f,
  -4.67585847e-02f, 2.74643481e-01f, 1.59600988e-01f, 2.46163398e-01f, 5.47777452e-02f, -1.11283951e-01f, -8.73256922e-02f, -1.01056457e-01f, 1.44500762e-01f, -4.98800687e-02f,
  1.99658707e-01f, 1.04301959e-01f, -1.27512738e-01f, -3.85715738e-02f, -4.40651774e-02f, -1.01833297e-02f, -6.37190416e-02f, -7.67664760e-02f, -3.64215113e-02f, -1.88836046e-02f,
  -1.12225160e-01f, -1.09722860e-01f, 1.77023895e-02f, -7.02858046e-02f, -6.01059794e-02f, -9.25459117e-02f, 2.09673736e-02f, 6.50286078e-02f, -5.33122458e-02f, -3.90805677e-02f,
  -2.81011015e-02f, 2.91478075e-02f, 5.00898808e-02f, 2.82336213e-02f, -6.00911044e-02f, -3.77083793e-02f, 8.40190202e-02f, -4.42996360e-02f, -2.94254795e-02f, -7.78153613e-02f,
  -1.03266992e-01f, -1.76744014e-02f, 6.80879205e-02f, -1.98882408e-02f, 1.03053451e-02f, 1.36196967e-02f, -7.18080392e-03f, 3.85686592e-03f, -9.81264189e-02f, 5.91613203e-02f,
  -8.58130492e-03f, -6.40114620e-02f, -2.28985716e-02f, -4.18564901e-02f, -6.30082982e-03f, 2.57514175e-02f, -2.48053763e-03f, -1.49073629e-02f, 4.19636853e-02f, 1.77622065e-02f,
  4.40547988e-02f, -4.45976742e-02f, 1.53227383e-02f, 7.20105544e-02f, -1.81566477e-02f, -3.72900739e-02f, 2.63107121e-02f, -7.47175217e-02f, 1.44576533e-02f, -3.17972936e-02f,
  1.73708066e-01f, 4.46702987e-02f, 1.18270762e-01f, -5.52876387e-03f, 3.66375782e-02f, 2.55130627e-03f, 4.78899814e-02f, -2.47750320e-02f, 1.59657805e-03f, -2.96243187e-02f,
  -3.61117721e-02f, 6.99438974e-02f, -5.84119149e-02f, -1.62933320e-02f, -1.18165128e-01f, 7.65311942e-02f, 3.46434638e-02f, -5.24033830e-02f, -3.92374583e-02f, -3.35993655e-02f,
  -7.31137097e-02f, -7.43601620e-02f, -1.92627113e-03f, 6.34583365e-03f, 6.85977191e-03f, -2.97909398e-02f, -8.51388350e-02f, 3.84506136e-02f, -7.12447837e-02f, 2.42785662e-02f,
  -9.49070156e-02f, -2.75735885e-01f, -2.30696335e-01f, -2.82509595e-01f, -1.57872200e-01f, -5.43325722e-01f, -5.15141666e-01f, -1.84555098e-01f, 1.38419703e-01f, -4.75530839e-03f,
  -6.83498085e-02f, 3.53064165e-02f, 2.44986311e-01f, -2.85914093e-01f, 5.04656434e-02f, 2.32004449e-01f, -4.43568915e-01f, -7.55179003e-02f, 1.57395378e-01f, -1.95106894e-01f,
  -8.02371427e-02f, -1.75161123e-01f, -1.12562910e-01f, 1.28404740e-02f, -2.21175551e-01f, -2.41936487e-03f, 1.50484219e-01f, 2.88774911e-02f, -2.35571340e-01f, 1.32481679e-02f,
  -1.24918088e-01f, 2.71340430e-01f, -8.29659682e-03f, 1.06015265e-01f, -4.73727882e-02f, -7.07501620e-02f, -8.71853530e-02f, 2.69143246e-02f, 4.28424813e-02f, 8.00308073e-04f,
  1.23733738e-02f, 6.23738505e-02f, -2.75456440e-02f, 9.62859094e-02f, -8.29738751e-02f, 4.24637794e-02f, 3.82562578e-02f, 2.16504317e-02f, 4.07110192e-02f, 2.18461566e-02f,
  -2.49367133e-02f, -3.77390012e-02f, -6.57289252e-02f, -5.15112206e-02f, -7.55350590e-02f, 2.96098776e-02f, -5.69042303e-02f, 6.79197386e-02f, -4.17688452e-02f, -8.03795159e-02f,
  -4.08881754e-02f, 4.03911062e-02f, -1.09232292e-01f, 4.40321080e-02f, -4.42050323e-02f, 2.35453118e-02f, 2.65434803e-03f, 1.64681394e-02f, 1.54889589e-02f, 2.18862668e-03f,
  -6.36732280e-02f, -2.24742237e-02f, 4.62521315e-02f, -5.23987077e-02f, -4.09980826e-02f, 2.67448127e-02f, -3.70498523e-02f, 1.92596521e-02f, -1.54895231e-01f, -6.89385757e-02f,
  4.80303317e-02f, -2.78797280e-02f, -1.44693246e-02f, 1.65657271e-02f, 3.05209849e-02f, 9.12813172e-02f, 7.47704506e-02f, 4.59411368e-02f, 2.98664533e-02f, -3.87431793e-02f,
  -7.12726563e-02f, -4.28347476e-02f, -2.39756685e-02f, -4.30512987e-02f, 7.15499371e-02f, -3.08829751e-02f, -2.58107092e-02f, -7.41080893e-03f, -5.26803657e-02f, -7.87047297e-03f,
  -4.25619893e-02f, -4.12460230e-02f, -3.99062894e-02f, 4.14727926e-02f, -2.14568637e-02f, -1.03321075e-01f, 1.71692949e-02f, 1.17525477e-02f, -5.00126295e-02f, -1.63577329e-02f,
  -1.99374035e-02f, -5.73273795e-03f, 3.24211270e-02f, 3.50887142e-02f, -3.14923772e-03f, -5.73833771e-02f, -1.26074925e-02f, 3.44879590e-02f, -6.54611588e-02f, -2.81946752e-02f,
  7.11009800e-01f, -5.28889120e-01f, -2.12957963e-01f, 6.38849318e-01f, 4.75798607e-01f, 1.61387116e-01f, 3.15010637e-01f, 3.35176736e-01f, 7.67917514e-01f, -2.74226248e-01f,
  -9.72849652e-02f, -2.42949307e-01f, -4.30790752e-01f, 1.43258929e-01f, 4.23151284e-01f, -1.98636174e-01f, 4.31413770e-01f, 5.99690601e-02f, 1.53966695e-01f, 7.41274878e-02f,
  2.65760094e-01f, 2.26201057e-01f, -1.78503707e-01f, -7.84987118e-03f, 8.16855729e-02f, 5.42073883e-02f, -8.45838860e-02f, -2.53041506e-01f, -1.88424915e-01f, 2.56546419e-02f,
  9.29825306e-02f, 1.10338822e-01f, -7.87297338e-02f, -7.04037622e-02f, -3.20258029e-02f, -8.09420347e-02f, -1.96822420e-01f, -7.53243566e-02f, 9.37215686e-02f, -2.70272642e-02f,
  -1.19050860e-01f, -1.85123291e-02f, 8.87203068e-02f, 3.52328643e-02f, 1.89712331e-01f, 7.44093582e-02f, 2.61869864e-03f, -5.27916523e-03f, -1.17831320e-01f, -7.26031214e-02f,
  -5.06116860e-02f, -5.55710196e-02f, 2.51305383e-02f, -1.49696276e-01f, 2.80181039e-02f, 9.97211933e-02f, -1.31708300e-02f, -1.03025883e-01f, -4.98171560e-02f, 9.05577913e-02f,
  -9.76956412e-02f, 8.37956592e-02f, -1.90728996e-02f, 3.89709771e-02f, 3.67837325e-02f, 8.23781341e-02f, -9.69013479e-03f, -8.05131346e-02f, 5.68451062e-02f, -8.22006017e-02f,
  6.89800009e-02f, 2.69684698e-02f, 5.49598709e-02f, -2.98051257e-02f, 6.06612638e-02f, 1.67123396e-02f, -1.09966081e-02f, -3.85623053e-02f, 3.25167142e-02f, 6.10761531e-02f,
  -5.38935997e-02f, 3.56136598e-02f, -7.93125406e-02f, 3.32935806e-03f, -6.75614551e-03f, -3.42613063e-03f, -6.69450639e-03f, -3.40793356e-02f, -7.15164142e-03f, -3.88943288e-03f,
  -7.68966973e-02f, -5.82006387e-02f, -7.02845806e-04f, -4.86583784e-02f, 1.25133479e-02f, -1.09247036e-01f, 1.64482575e-02f, 1.03865750e-02f, -5.75073771e-02f, 1.99069924e-04f,
  4.74667363e-02f, 3.69928777e-02f, -6.96878657e-02f, -4.18989174e-02f, -7.38304853e-02f, -3.98674607e-03f, 1.63121279e-02f, 7.06010759e-02f, 3.57762203e-02f, -5.90121746e-02f,
  -3.79775614e-02f, -2.38690944e-03f, -2.56984569e-02f, 1.23546392e-01f, -3.29794288e-02f, -4.86079901e-02f, 3.64803188e-02f, 3.90871279e-02f, -9.88030806e-02f, -2.47459207e-03f,
  -3.14754277e-01f, 2.93709993e-01f, -2.29546010e-01f, -1.30536422e-01f, -2.74565846e-01f, 1.93215281e-01f, 6.79962933e-02f, -1.63571492e-01f, 1.34890214e-01f, 3.98677468e-01f,
  1.29888669e-01f, -5.16405255e-02f, 2.41687492e-01f, -8.07427894e-03f, 1.81209445e-01f, 3.68635327e-01f, 2.51293838e-01f, 5.66357039e-02f, -8.86543617e-02f, -1.66400209e-01f,
  -3.07704136e-03f, -1.52232394e-01f, -1.22997694e-01f, -1.93785310e-01f, -3.25235873e-01f, -1.28834724e-01f, 2.59893574e-02f, -2.97647357e-01f, -1.12778127e-01f, 1.12361461e-02f,
  -2.05837324e-01f, -1.63371056e-01f, -1.20384231e-01f, -1.33844271e-01f, -1.08526293e-02f, -1.04251370e-01f, -1.40656397e-01f, 6.36445917e-03f, -8.89474601e-02f, 2.42433436e-02f,
  3.64540815e-02f, -1.15670033e-01f, 4.93872501e-02f, -8.13908726e-02f, 7.10616261e-02f, 5.00371121e-02f, 2.68025305e-02f, -3.51914912e-02f, -2.14708764e-02f, 6.28961772e-02f,
  2.00891644e-02f, 9.80047137e-03f, -1.38028963e-02f, 1.04438201e-01f, 2.85909977e-02f, 1.48049342e-02f, -3.24689932e-02f, 9.41333175e-03f, 9.05651376e-02f, 1.28155157e-01f,
  6.74257353e-02f, -7.67231744e-04f, -3.19442595e-03f, -1.41248349e-02f, 4.21317741e-02f, 1.16028320e-02f, -2.32299464e-03f, -5.96687272e-02f, 9.91683081e-03f, 2.95933951e-02f,
  9.24447700e-02f, -3.45731415e-02f, -5.58058023e-02f, 4.71135564e-02f, 3.98955829e-02f, -1.94107722e-02f, 3.05489847e-03f, 1.64975598e-02f, 4.87400703e-02f, 8.28901082e-02f,
  4.17929329e-02f, 2.55331304e-02f, -1.36836793e-03f, 7.58563774e-03f, -1.49609884e-02f, 1.80480182e-02f, -4.52912264e-02f, -1.71088555e-03f, 3.66999507e-02f, 1.55628892e-02f,
  -6.26134723e-02f, 1.08350411e-01f, -2.72282213e-02f, -6.09535091e-02f, 3.21534835e-02f, 4.28755619e-02f, 2.93135713e-03f, -4.89271805e-02f, 1.14888497e-01f, -2.14475170e-02f,
  3.68427336e-02f, -2.90502794e-02f, -1.65610332e-02f, 3.21565121e-02f, 4.98768948e-02f, 7.57805184e-02f, -6.16283603e-02f, -5.14531173e-02f, 3.64655778e-02f, -3.36848795e-02f,
  -1.65953338e-02f, -3.97005957e-03f, 4.86967266e-02f, -4.10305103e-03f, -8.17336068e-02f, 1.24606472e-02f, 4.71621156e-02f, -7.87953585e-02f, 2.71751992e-02f, 8.81437969e-04f,
  -1.98167831e-01f, 1.05653375e-01f, -8.19545016e-02f, 2.54650295e-01f, 4.92318608e-02f, 2.72905350e-01f, 1.72578856e-01f, 1.59144551e-01f, 3.84626538e-01f, 2.52164721e-01f,
  -9.30473302e-03f, 1.12954862e-01f, 1.43891834e-02f, 1.47494048e-01f, 3.22091818e-01f, 4.46312362e-03f, 3.06731850e-01f, 7.53954127e-02f, 8.39728937e-02f, 1.27915800e-01f,
  -5.06394282e-02f, 6.44687116e-02f, -2.61530697e-01f, -1.57590583e-01f, -1.27923727e-01f, -8.76993611e-02f, -1.16326317e-01f, -1.34840518e-01f, 6.14672154e-02f, 1.69914201e-01f,
  4.86474368e-04f, 5.40468730e-02f, -3.57948467e-02f, -8.48739296e-02f, 1.86978206e-02f, -1.95014253e-02f, -1.79041158e-02f, -8.29382613e-02f, 3.59068215e-02f, -4.04903712e-03f,
  7.83202797e-02f, -9.75028332e-03f, 1.09723061e-02f, -1.06800020e-01f, -9.21501145e-02f, -8.58805329e-03f, -2.30956543e-02f, -4.72512245e-02f, -5.91611415e-02f, -1.36222214e-01f,
  -3.43322009e-02f, 1.08730895e-02f, 8.15384760e-02f, -1.80010945e-02f, 2.17608102e-02f, -5.00560142e-02f, 1.01152346e-01f, 1.11776283e-02f, -2.23131403e-02f, 1.03536934e-01f,
  -2.55116876e-02f, 1.32018894e-01f, 5.49627207e-02f, -6.61549792e-02f, -1.76577736e-02f, -8.63269493e-02f, 2.27462146e-02f, -3.87101136e-02f, -9.42129362e-03f, -5.60578294e-02f,
  1.98248886e-02f, 6.77822605e-02f, 2.76074652e-02f, 4.24420126e-02f, 5.68883009e-02f, -1.87007524e-02f, -1.00142837e-01f, 2.89539248e-02f, 1.65708512e-02f, -5.12707643e-02f,
  -3.55034731e-02f, 1.13188356e-01f, -9.98599455e-02f, -4.97358441e-02f, -3.47242765e-02f, 5.29395044e-02f, 7.35700056e-02f, 3.15112658e-02f, -1.18621411e-02f, 9.81989652e-02f,
  2.14732319e-01f, 4.58778948e-01f, -2.18577031e-03f, 6.53283894e-02f, -7.94779137e-03f, -6.52513653e-02f, 8.58734250e-02f, -1.27659366e-02f, 8.60764831e-02f, 2.35645082e-02f,
  -6.71888068e-02f, -3.96813154e-02f, 3.70417722e-02f, -1.89782735e-02f, 3.68959904e-02f, 1.65916197e-02f, 4.21759598e-02f, 7.76161700e-02f, 1.51809126e-01f, -2.45539211e-02f,
  -7.26886988e-02f, 3.25177088e-02f, -9.01801698e-03f, -4.83427830e-02f, 6.70096800e-02f, 4.97390591e-02f, 3.33673246e-02f, -6.24294877e-02f, 6.42397106e-02f, 4.86219451e-02f,
  -4.91763294e-01f, 2.33916193e-01f, -1.83254406e-01f, -3.63775939e-01f, -2.31970497e-03f, -3.69133055e-01f, -4.27847326e-01f, 9.18976292e-02f, 5.19942157e-02f, -6.13230094e-02f,
  -1.77916244e-01f, 1.71509350e-03f, 2.54513025e-01f, -2.46306494e-01f, -2.65934974e-01f, 1.60641029e-01f, -5.03434181e-01f, -3.03985983e-01f, 1.44927323e-01f, -2.62920171e-01f,
  -1.26801863e-01f, -1.70242846e-01f, -1.09547682e-01f, 1.95011497e-01f, -2.60805458e-01f, -7.08582103e-02f, -1.20181732e-01f, 2.07749635e-01f, -1.99067473e-01f, 1.00037105e-01f,
  -1.39421791e-01f, -6.87758774e-02f, -9.27359834e-02f, -8.00236911e-02f, -2.94550955e-01f, -1.73593327e-01f, -1.18625432e-01f, 1.83706507e-02f, -1.03310659e-03f, -2.63214093e-02f,
  -3.68427373e-02f, 2.35209148e-02f, -6.84620738e-02f, 8.38424638e-02f, 3.94134186e-02f, 4.99982126e-02f, 1.11809678e-01f, -5.89032881e-02f, -2.85706837e-02f, 9.51709524e-02f,
  8.83614738e-03f, -3.06462515e-02f, -1.29184932e-01f, -8.84453580e-03f, 6.23989254e-02f, 1.93109121e-02f, -1.02719836e-01f, -4.53095697e-02f, -7.05071539e-02f, -1.69480760e-02f,
  3.53522003e-02f, -5.98258041e-02f, 4.04838212e-02f, -2.50219330e-02f, 5.70898876e-02f, 1.02454219e-02f, 5.14771864e-02f, 2.82675084e-02f, -1.15763750e-02f, -2.29026377e-02f,
  -3.72765213e-02f, -2.06143851e-03f, -3.44046880e-03f, -1.08406648e-01f, -2.93703955e-02f, -1.00296333e-01f, -4.54609543e-02f, -3.24099883e-02f, 4.28610742e-02f, 2.69086869e-03f,
  3.91369909e-02f, -1.15804153e-03f, 1.21274672e-01f, -9.30213034e-02f, 3.25141184e-04f, 2.28990931e-02f, 1.28005436e-02f, 6.06125742e-02f, -2.90782750e-02f, -4.85356897e-02f,
  -4.19232309e-01f, -3.41641963e-01f, -8.80476609e-02f, 4.82814200e-03f, 2.73754392e-02f, -4.66122404e-02f, -4.62890230e-02f, -9.13644433e-02f, -8.59547555e-02f, -3.04782316e-02f,
  -1.58875808e-01f, -1.24326892e-01f, -1.34920955e-01f, -1.41704930e-02f, 2.52660885e-02f, -5.75191192e-02f, -1.12905473e-01f, -3.23918685e-02f, -2.04869360e-01f, -5.97637743e-02f,
  -2.77057867e-02f, -9.16312542e-03f, -2.70475727e-02f, -2.35569105e-02f, -9.10672694e-02f, -9.13877636e-02f, -8.89600366e-02f, -1.73333865e-02f, -5.29745594e-02f, -3.09316930e-03f,
  2.80562162e-01f, -1.69304609e-01f, -5.62146187e-01f, 1.11865383e-02f, 2.85307050e-01f, 7.74235204e-02f, -2.06023473e-02f, 1.95916414e-01f, -2.55322367e-01f, 1.75851107e-01f,
  2.80259579e-01f, -1.77883387e-01f, -1.47023484e-01f, 1.02006935e-01f, 1.29667431e-01f, -3.40025723e-01f, 1.82567611e-01f, 5.72792143e-02f, -1.73547596e-01f, 1.85730815e-01f,
  4.53035310e-02f, 4.77722466e-01f, -1.15389116e-01f, 2.59135902e-01f, 1.49314269e-01f, 2.01677736e-02f, 4.12351102e-01f, -8.93134177e-02f, 3.02005172e-01f, 5.20145819e-02f,
  -1.19473569e-01f, -2.44390871e-02f, 2.02323645e-02f, -1.43940493e-01f, 1.51912615e-01f, 1.60862058e-01f, 1.69882970e-03f, -4.68339585e-02f, -1.71161547e-01f, -1.54971769e-02f,
  -5.30642010e-02f, 6.86461385e-03f, 2.89410762e-02f, -1.07527729e-02f, 7.11600184e-02f, 6.22534640e-02f, -7.23684207e-02f, -5.24615832e-02f, -8.11127350e-02f, -1.41871385e-02f,
  -1.25421464e-01f, -7.86996186e-02f, 6.79306034e-03f, -4.67478111e-02f, -2.04671789e-02f, 3.34038474e-02f, 1.16721522e-02f, 1.42700132e-02f, -1.65560618e-02f, 8.03045258e-02f,
  1.19944319e-01f, -2.24767327e-02f, 5.34636825e-02f, -1.92409083e-02f, 4.24553789e-02f, 2.01609861e-02f, 6.18464537e-02f, -1.96682755e-03f, 3.07715894e-03f, 1.83472075e-02f,
  1.06603354e-01f, 7.60413939e-03f, 6.60383180e-02f, -3.50222923e-03f, 2.01822786e-06f, -6.70721605e-02f, -1.10342680e-02f, 7.10195079e-02f, -2.61799283e-02f, -1.90649610e-02f,
  -5.06963618e-02f, -2.44837850e-02f, 5.79976588e-02f, -2.11614948e-02f, -3.33734080e-02f, -4.51847650e-02f, 9.50329751e-02f, -3.60042192e-02f, -1.74182039e-02f, 1.32176485e-02f,
  6.67912513e-02f, 9.22445878e-02f, -1.01558030e-01f, 5.56558697e-03f, -1.25305345e-02f, 1.58067405e-01f, 3.14391069e-02f, -7.40327500e-03f, 5.28098531e-02f, -1.50496354e-02f,
  1.12361096e-01f, -8.47984198e-03f, 3.58827934e-02f, 1.60127636e-02f, -3.66573371e-02f, 1.52933836e-01f, 2.77666915e-02f, 6.10696934e-02f, 1.28115028e-01f, 9.58118662e-02f,
  1.53843490e-02f, 5.22320531e-02f, -6.07118476e-03f, 7.26900101e-02f, -1.07559273e-02f, 9.27668288e-02f, 7.95640610e-03f, 3.86111438e-02f, 4.99182902e-02f, -7.25328699e-02f,
  1.99356422e-01f, 6.30866349e-01f, 5.49557447e-01f, 5.01122952e-01f, -2.42047280e-01f, -5.42328060e-01f, -3.63524854e-01f, 3.39465529e-01f, -1.45591339e-02f, 5.18270731e-02f,
  -8.17687064e-02f, 2.61333525e-01f, -1.96765158e-02f, 2.11054772e-01f, -8.69126245e-02f, -1.45593271e-01f, -5.13436124e-02f, -1.35708060e-02f, 5.96445389e-02f, 1.70897007e-01f,
  1.15605064e-01f, -1.89404801e-01f, 4.51405168e-01f, -8.42765626e-03f, 1.26913071e-01f, 5.06314814e-01f, 2.00716585e-01f, 4.38532569e-02f, 2.78837532e-01f, -5.16241863e-02f,
  -1.02198087e-01f, 5.04236929e-02f, 1.63533509e-01f, -2.48161945e-02f, 5.69317713e-02f, -5.54447696e-02f, -1.71914995e-02f, -7.21156225e-02f, 8.24520588e-02f, 1.93411913e-02f,
  2.28200965e-02f, -1.56193404e-02f, 2.88580526e-02f, -7.85490572e-02f, -1.24589056e-02f, 1.28432959e-01f, 1.01619206e-01f, 7.16231912e-02f, 7.06228837e-02f, 9.55052599e-02f,
  5.00197336e-02f, 9.62259024e-02f, 1.57703161e-02f, 1.11664543e-02f, 8.07305053e-02f, 1.48329092e-02f, 2.51113493e-02f, 1.23189099e-01f, -1.37540555e-04f, 1.88675225e-02f,
  -4.03682701e-02f, -5.83497509e-02f, -4.42411005e-02f, -5.49716167e-02f, -4.18752991e-03f, -4.80646156e-02f, 6.78832131e-03f, -1.78548358e-02f, 2.56794486e-02f, -1.17528617e-01f,
  4.24270555e-02f, 9.98989567e-02f, -1.51175056e-02f, -9.93955433e-02f, 3.77370082e-02f, -5.84514029e-02f, 1.35612004e-02f, 1.92695037e-02f, -6.11540638e-02f, 1.20603435e-01f,
  -4.19378839e-02f, -1.64944865e-02f, -3.46368663e-02f, 2.32400298e-02f, -1.16241485e-01f, 3.06852348e-02f, 7.33837187e-02f, -2.26153955e-02f, 1.07279085e-01f, -2.32796762e-02f,
  -1.04291327e-01f, 3.10145199e-01f, 3.23460251e-02f, 2.65469830e-02f, -3.51449475e-02f, -6.53994828e-02f, -4.74786498e-02f, 1.52233634e-02f, 1.47289494e-02f, -8.28604996e-02f,
  -3.12512405e-02f, -1.74949691e-03f, -1.09695867e-01f, 4.59542833e-02f, -3.73412669e-02f, -1.31976865e-02f, 2.81653441e-02f, 6.15898240e-03f, 9.58973467e-02f, 9.23733935e-02f,
  4.64809611e-02f, -5.26648685e-02f, 2.27119029e-02f, -1.83419418e-02f, -2.23966651e-02f, -4.15948331e-02f, -3.70813124e-02f, -2.61954386e-02f, 5.35123907e-02f, -1.48279872e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.47141942e-01f, 3.31890166e-01f, 1.26017153e-01f, -4.06520721e-03f, 5.56209445e-01f, 1.57812029e-01f, 8.94019902e-02f, 2.76220441e-01f, 4.08967853e-01f, 2.16351762e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.23766676e-01f, -1.54249653e-01f, 2.45843753e-01f, 2.64859885e-01f, 8.50699916e-02f, -5.68613075e-02f, 1.91529632e-01f, 9.15699899e-02f, -3.70143563e-01f, -5.15784204e-01f,
  3.06597501e-01f, -1.62563205e-01f, -1.15210041e-01f, -7.11891726e-02f, 2.89556324e-01f, 1.85254529e-01f, -1.12482034e-01f, 3.98369074e-01f, -3.77108194e-02f, -8.65520597e-01f,
  -4.11865681e-01f, 5.74390292e-01f, 2.35027537e-01f, -1.00153387e-01f, 4.02462870e-01f, -2.42305398e-01f, -2.48252273e-01f, -2.60550603e-02f, 1.90527752e-01f, -7.04120798e-03f,
  7.94472769e-02f, 2.30154201e-01f, -1.07850321e-02f, -1.69577405e-01f, -3.36201251e-01f, -6.00151420e-01f, 4.08215225e-02f, -4.10664082e-01f, 2.21585169e-01f, -4.43414688e-01f,
  3.34416449e-01f, 3.92385006e-01f, -1.12439059e-01f, 4.98266757e-01f, 4.43883806e-01f, -1.07146595e-02f, 2.57279545e-01f, -2.24436969e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.96135402e-01f, 3.88300836e-01f, 2.64371987e-02f, 1.58819512e-01f, -2.74690613e-02f, 6.29174411e-01f, -1.06900170e-01f, 1.21705353e+00f, -2.02359781e-01f, 1.38708845e-01f,
  -3.39102417e-01f, -2.48971388e-01f, -1.84062690e-01f, 4.05220807e-01f, 5.32723486e-01f, -2.02475294e-01f, 2.66507685e-01f, -1.31318077e-01f, -1.85179949e-01f, 2.58010745e-01f,
  7.59626878e-03f, -1.40452102e-01f, -2.66918451e-01f, 7.76012195e-03f, -4.59409170e-02f, -2.09575057e-01f, 8.03335726e-01f, -3.68232699e-03f, 3.75173122e-01f, -3.12624067e-01f,
  -1.91263393e-01f, -1.46082669e-01f, 2.68883884e-01f, -3.52312922e-01f, 8.90380666e-02f, 7.82478511e-01f, 4.22873765e-01f, -6.49593949e-01f, 3.35737050e-01f, -2.86545515e-01f,
  -4.76327002e-01f, -2.62371868e-01f, 9.86766219e-01f, -3.68122458e-01f, -1.20664604e-01f, -1.43905789e-01f, 2.77696043e-01f, 7.52516270e-01f, 7.02947453e-02f, 7.89182067e-01f,
  1.47746131e-01f, 3.87247413e-01f, 1.63350955e-01f, 3.55013132e-01f, -4.66726661e-01f, 7.09505379e-01f, 7.01238275e-01f, -2.88419515e-01f, 4.00978237e-01f, 1.69812635e-01f,
  -1.66768804e-01f, -4.46461976e-01f, 1.24286562e-01f, -8.89154151e-02f, -1.55769110e-01f, 5.64338088e-01f, 2.43326887e-01f, -5.62659442e-01f, -5.74516594e-01f, 5.56754827e-01f,
  1.24552965e-01f, -1.21700503e-01f, 5.50793171e-01f, -1.20859236e-01f, 1.03393292e+00f, 6.45900071e-01f, 5.29212892e-01f, -2.67075777e-01f, 1.08034350e-01f, -5.60588479e-01f,
  -3.62428188e-01f, 4.84640807e-01f, -5.80668114e-02f, -1.73761457e-01f, 2.13221267e-01f, 4.73682284e-01f, 6.31242573e-01f, 1.07454598e-01f, 2.79541880e-01f, -2.09801376e-01f,
  2.94841647e-01f, 1.83874313e-02f, -1.53809860e-01f, -4.37608324e-02f, 7.14917541e-01f, -4.89411801e-01f, -2.21592590e-01f, 1.62905067e-01f, 4.44825023e-01f, -4.75152731e-01f,
  -8.64484161e-02f, 4.19786781e-01f, 1.02829385e+00f, 1.39155939e-01f, -2.03558356e-01f, 1.26558125e-01f, 2.64428109e-01f, -1.91414922e-01f, 5.45438409e-01f, -2.70596981e-01f,
  7.69032955e-01f, 7.58434951e-01f, -6.54283240e-02f, 3.75818908e-01f, 8.28163922e-02f, 2.99738228e-01f, -3.70233655e-01f, 1.12466998e-01f, 1.45142630e-01f, -1.36315867e-01f,
  -2.85516437e-02f, 4.65228856e-01f, -3.27293538e-02f, 1.21697932e-01f, 1.03010945e-01f, 9.93997976e-02f, 3.36966574e-01f, -2.16931939e-01f, 3.67486328e-02f, 3.61748338e-01f,
  3.28588933e-01f, -4.33317393e-01f, -2.42410526e-01f, -9.40588415e-02f, 4.21385944e-01f, -4.16780729e-03f, 5.99219322e-01f, 8.75829101e-01f, -4.68840778e-01f, 2.58697510e-01f,
  -1.76222280e-01f, 1.31971049e+00f, -6.27788305e-02f, 7.11037517e-01f, 2.02918332e-02f, 7.03579262e-02f, -8.14676955e-02f, 3.06720197e-01f, -7.74871884e-03f, 6.01776540e-01f,
  -8.84995833e-02f, 5.43649375e-01f, -7.12539777e-02f, 1.64164364e-01f, 4.27221745e-01f, -4.34048086e-01f, 7.61569440e-02f, 2.67110884e-01f, 4.34056014e-01f, -2.34523758e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.38076749e-02f, 1.83495417e-01f, 6.20710254e-01f, 3.42252851e-01f, 4.74098593e-01f, 2.44544134e-01f, -1.58599004e-01f, -5.88331707e-02f, 3.31741929e-01f, 4.72216643e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -7.11412370e-01f, -1.00372434e+00f, -1.40721440e-01f, -8.35961521e-01f, 3.34498763e-01f, 2.08237499e-01f, 1.88984722e-01f, -1.55357778e-01f, -3.81477058e-01f, 8.42532635e-01f,
  4.82667565e-01f, 2.97609985e-01f, -2.49392897e-01f, 1.16988778e-01f, 2.77011693e-01f, -2.30054095e-01f, 2.98751980e-01f, -6.55957043e-01f, -1.08431570e-01f, 2.78512567e-01f,
  3.55759978e-01f, -1.01441205e-01f, -4.56078053e-02f, -1.75641458e-02f, -7.08441257e-01f, -2.76127309e-01f, 5.65670133e-01f, 7.25808561e-01f, 6.99830830e-01f, 4.26065087e-01f,
  -2.10693493e-01f, 2.56421208e-01f, -8.15816581e-01f, 4.24302787e-01f, -2.67994910e-01f, 4.13248062e-01f, -7.65114352e-02f, 5.43290019e-01f, -2.07261249e-01f, -7.00168461e-02f,
  7.26821423e-01f, -5.93894780e-01f, -9.47659686e-02f, 5.62463760e-01f, 5.05704522e-01f, -2.77189076e-01f, -5.96673727e-01f, 3.88645232e-02f, -8.25348943e-02f, 2.33229518e-01f,
  -5.05629145e-02f, -6.55772626e-01f, -5.97892925e-02f, -5.96138418e-01f, 1.06215835e+00f, -1.88214444e-02f, -4.96557415e-01f, -4.18070406e-01f, -3.54918957e-01f, -2.14630604e-01f,
  -5.02266526e-01f, -4.93594147e-02f, 4.33126301e-01f, 6.66774750e-01f, 9.90915656e-01f, 8.03171217e-01f, 1.06540167e+00f, -6.44461393e-01f, 6.03624880e-01f, 5.60726762e-01f,
  -2.03010231e-01f, -4.44014281e-01f, -4.85478699e-01f, -8.14094692e-02f, 9.97937657e-03f, 8.92708525e-02f, -5.58719456e-01f, -6.91046491e-02f, 9.38678443e-01f, -5.41188538e-01f,
  6.54542327e-01f, 1.77536637e-01f, -2.84649014e-01f, -4.13101375e-01f, 7.58633971e-01f, 8.31383944e-01f, -3.96665692e-01f, 4.37765360e-01f, -2.21958816e-01f, -2.50674397e-01f,
  1.15394032e+00f, -5.79813719e-01f, 9.76213887e-02f, -6.37459336e-03f, -3.41204464e-01f, -1.08282074e-01f, -4.46650326e-01f, -8.10238905e-03f, -3.28829914e-01f, 5.17508924e-01f,
  -6.49796784e-01f, -5.06778479e-01f, -9.91238281e-02f, 5.35536766e-01f, 5.90749204e-01f, 5.81289470e-01f, 5.46165884e-01f, 3.36195938e-02f, -4.08832282e-01f, 6.08104728e-02f,
  -4.37576711e-01f, 3.56364757e-01f, -6.47811472e-01f, -3.59033912e-01f, -6.05168268e-02f, -6.63262129e-01f, -5.52820086e-01f, 4.20509368e-01f, 3.02351359e-02f, -2.62437105e-01f,
  -9.58839804e-02f, -5.36850035e-01f, -6.02438569e-01f, -4.09522802e-01f, -1.35828137e-01f, 4.66635704e-01f, 1.02869475e+00f, -2.32826069e-01f, -8.27389419e-01f, -6.20741904e-01f,
  -1.23893380e-01f, 2.62224585e-01f, 3.43553722e-01f, -2.77316540e-01f, -2.00888500e-01f, -3.35259795e-01f, 1.32073015e-01f, -3.40608269e-01f, -5.06014764e-01f, -2.25489691e-01f,
  1.15214729e+00f, -3.62430960e-01f, 4.68583971e-01f, -4.71813604e-02f, 7.09199309e-01f, -2.90339291e-01f, 9.13142979e-01f, 7.67162263e-01f, -1.37907040e+00f, 8.67254939e-03f,
  -3.54383469e-01f, 4.48889196e-01f, 9.81812298e-01f, -4.17957567e-02f, -5.83612144e-01f, -4.18274462e-01f, -6.35774374e-01f, -2.04571292e-01f, -7.09560096e-01f, -1.61895290e-01f,
  -1.19530605e-02f, -3.00167706e-02f, -4.28581566e-01f, 4.53379273e-01f, -3.62365574e-01f, -6.48343801e-01f, 1.08008349e+00f, 6.54113144e-02f, -4.19784576e-01f, 5.94908774e-01f,
  -1.52092054e-01f, 2.17947707e-01f, 2.23591402e-01f, 2.08155081e-01f, -6.79785788e-01f, 4.59015608e-01f, 7.43057728e-01f, 1.04244018e+00f, -3.03451568e-01f, 9.92236674e-01f,
  2.54156649e-01f, -1.54446661e+00f, -2.19296306e-01f, -1.98276743e-01f, 7.01844037e-01f, -1.70641884e-01f, -6.56452239e-01f, -2.97617704e-01f, 2.18568042e-01f, 1.46940634e-01f,
  3.57540518e-01f, -2.17457861e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.24802910e-01f, -2.31564522e-01f, -1.24463819e-01f, -3.70370090e-01f, 6.85202658e-01f, 3.79506737e-01f, -5.81482410e-01f, -4.45014983e-01f, -5.08992553e-01f, 7.73475409e-01f,
  -6.51646033e-02f, 5.71276724e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    