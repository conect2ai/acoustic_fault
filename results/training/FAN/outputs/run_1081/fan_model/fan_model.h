/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.69458109e-01f, 1.54919535e-01f, 2.18265831e-01f, -3.15406732e-03f, 9.30522382e-02f, 2.28963152e-01f, 2.72749454e-01f, 2.66140521e-01f, -4.17928956e-02f, 1.38939753e-01f,
  -1.83544904e-01f, -1.56853735e-01f, -8.42290893e-02f, 5.09785861e-02f, 2.12504491e-01f, 2.95678616e-01f, 2.40736306e-01f, 9.80512798e-02f, 6.11368157e-02f, 1.77369371e-01f,
  2.09253550e-01f, 1.78930506e-01f, 1.41133919e-01f, 1.46807451e-02f, 5.69675453e-02f, -1.89495478e-02f, 5.64308912e-02f, 8.96053389e-02f, 7.96955526e-02f, 8.31248537e-02f,
  -1.41438544e-01f, -2.81803906e-02f, 1.12412691e-01f, 6.53425604e-02f, 3.22340280e-02f, 1.10911861e-01f, 7.84368590e-02f, 6.14601746e-02f, 4.15148251e-02f, 1.03641897e-01f,
  -6.91257715e-02f, 1.35965362e-01f, -1.67938899e-02f, 1.28772110e-01f, 1.11231759e-01f, 2.39383839e-02f, 1.14014082e-01f, 1.05987400e-01f, 1.06410228e-01f, 7.28946030e-02f,
  1.06153272e-01f, -7.60962665e-02f, 1.93954434e-03f, 9.95807201e-02f, 2.87129283e-02f, 8.08071792e-02f, 2.40292102e-02f, 9.39889774e-02f, 5.05241305e-02f, 8.58079940e-02f,
  -5.14684170e-02f, -3.85603756e-02f, 2.35492215e-02f, 1.51264006e-02f, -2.19182987e-02f, -6.00535274e-02f, 2.87400819e-02f, -4.46114652e-02f, -1.70414671e-02f, 6.04138151e-02f,
  -2.50201859e-02f, 3.00736586e-03f, 1.21486727e-02f, -2.46352665e-02f, -3.14654782e-02f, 4.88663204e-02f, -8.08977056e-03f, 1.91800166e-02f, -1.49650387e-02f, 7.06742108e-02f,
  -7.97411369e-04f, 1.13252839e-02f, -4.58146706e-02f, 6.92979246e-02f, 8.74208882e-02f, 8.99318978e-03f, -7.42308870e-02f, -3.22183408e-02f, -7.30115026e-02f, -9.00929645e-02f,
  -3.54699902e-02f, 2.39827204e-02f, 9.57531631e-02f, 1.13698654e-01f, 8.14000219e-02f, 1.32619098e-01f, 6.90048411e-02f, 1.96703315e-01f, 1.42261073e-01f, 9.96029004e-02f,
  4.02047038e-02f, 9.05662179e-02f, 1.57603085e-01f, 5.86027168e-02f, 1.20452240e-01f, 7.66362026e-02f, 8.11068639e-02f, 1.28644437e-01f, 6.42478168e-02f, -4.72371932e-03f,
  1.15053773e-01f, 1.99290782e-01f, 1.54196098e-02f, 1.37058005e-01f, -9.43318754e-03f, -6.95027830e-03f, 1.72822461e-01f, 1.58701226e-01f, 1.33416295e-01f, 1.34327412e-01f,
  3.02727252e-01f, 1.75980441e-02f, 3.19283843e-01f, 1.62663192e-01f, 5.55868857e-02f, 1.18555643e-01f, 2.49104828e-01f, 1.40230015e-01f, -2.28257421e-02f, 1.99274737e-02f,
  -1.22500241e-01f, -3.26790810e-01f, -1.44779474e-01f, -5.56839257e-02f, 9.60324481e-02f, 1.78789690e-01f, 2.19555750e-01f, 2.12992683e-01f, 1.32470569e-02f, -6.93417117e-02f,
  -1.86631918e-01f, -3.91782634e-02f, 1.06348708e-01f, 1.03424855e-01f, 1.76254492e-02f, -1.41732648e-01f, 1.31673470e-01f, 7.97738880e-02f, -6.31881505e-02f, -1.00031272e-01f,
  -1.35295466e-01f, 8.73448700e-02f, -2.95487586e-02f, -1.51881859e-01f, -7.08762109e-02f, -8.44203234e-02f, 1.61316264e-02f, 4.80849519e-02f, -1.27776610e-02f, 2.33813636e-02f,
  -6.51716441e-02f, -5.55485673e-02f, 1.76056521e-03f, -7.24919662e-02f, 8.89830440e-02f, 1.06954202e-02f, 7.29355216e-02f, 1.09655902e-01f, 3.08840815e-02f, -9.64727402e-02f,
  -1.44492015e-01f, 6.89696381e-03f, 3.73286493e-02f, -2.65136492e-02f, 3.12430635e-02f, -2.12138472e-03f, 3.44694927e-02f, 2.61650179e-02f, 3.48112523e-03f, 2.87885368e-02f,
  7.93218985e-02f, -7.08454242e-03f, 1.80945126e-03f, 3.49099971e-02f, -1.45305172e-02f, 4.53670435e-02f, 2.38355286e-02f, -1.02250338e-01f, 1.96968904e-03f, 4.75994162e-02f,
  6.13429360e-02f, 4.99889255e-02f, 1.49985608e-02f, 1.03198238e-01f, 1.69688109e-02f, -1.78693775e-02f, 8.75073671e-02f, 4.50280607e-02f, -4.43779752e-02f, -2.06730850e-02f,
  3.27547826e-02f, -4.06339355e-02f, 9.47678089e-03f, 3.67893986e-02f, 8.98644049e-03f, 2.52165552e-02f, -4.45493162e-02f, -4.50726375e-02f, 7.93877710e-03f, 5.89728467e-02f,
  -2.12957375e-02f, 8.72542243e-03f, -6.71045184e-02f, -6.98861945e-03f, -7.90915042e-02f, -4.42219451e-02f, -1.02667920e-01f, -6.66866302e-02f, -1.54525474e-01f, 1.17923552e-02f,
  -6.08371384e-02f, 3.35270335e-04f, -4.71393391e-03f, -6.31835163e-02f, -1.35857901e-02f, -1.47905812e-01f, -7.15989992e-02f, 3.33508700e-02f, -2.94535086e-02f, -1.08034663e-01f,
  -6.14179038e-02f, 4.58814483e-03f, -8.27785488e-03f, -1.27031311e-01f, -3.50728817e-02f, -4.61088754e-02f, -1.29458025e-01f, -1.00372978e-01f, -7.16538280e-02f, -1.49540501e-02f,
  1.35565981e-01f, -1.68350846e-01f, -1.10270441e-01f, -2.86504533e-02f, -1.43114313e-01f, 7.60139078e-02f, 7.76601508e-02f, 1.01665609e-01f, -3.43969464e-02f, -7.49367326e-02f,
  2.45417412e-02f, -5.11426926e-02f, 2.01679990e-02f, 1.17552787e-01f, 1.42509878e-01f, -1.63969189e-01f, -1.32165626e-01f, 2.76515186e-02f, 1.90408424e-01f, 1.27767593e-01f,
  9.73860249e-02f, 5.60814142e-02f, -3.86133082e-02f, 6.63435534e-02f, -1.81989059e-01f, 3.49417217e-02f, -1.05272293e-01f, -1.34154096e-01f, -9.58363190e-02f, -2.67514735e-01f,
  -6.40100911e-02f, -2.04401895e-01f, 1.02725320e-01f, -6.09005652e-02f, -1.73010319e-01f, -6.95973188e-02f, 1.55220535e-02f, -1.21382937e-01f, -7.51353130e-02f, -2.68222857e-03f,
  -9.35257077e-02f, -1.28983632e-01f, -1.63770065e-01f, -5.13443165e-02f, -1.40774205e-01f, 9.53806471e-03f, -1.08197987e-01f, -1.05356753e-01f, -5.38149960e-02f, -1.06457353e-01f,
  -1.19675174e-01f, -2.02470869e-01f, -2.77880225e-02f, -1.22056849e-01f, -1.35858074e-01f, -4.31100577e-02f, -4.76094931e-02f, -1.40384436e-01f, -1.30285725e-01f, -9.05088633e-02f,
  -5.77193573e-02f, 6.30951971e-02f, 1.14163002e-02f, 5.85488230e-02f, 4.53787930e-02f, 7.00074583e-02f, -4.42047371e-03f, -6.90302672e-03f, 7.49842823e-02f, 2.46145055e-02f,
  1.02952227e-01f, 4.52817492e-02f, 7.70135373e-02f, 2.76692379e-02f, 6.32653907e-02f, -6.06182311e-03f, 1.22118006e-02f, 7.02597126e-02f, 3.12048960e-02f, 8.65340009e-02f,
  8.76027644e-02f, -2.16519609e-02f, 6.56578988e-02f, -1.51336752e-02f, 3.26518640e-02f, 7.93426707e-02f, -8.49819090e-03f, 5.50100766e-02f, 8.44274089e-02f, 2.40236465e-02f,
  1.26282096e-01f, -2.38637403e-02f, -3.72613408e-02f, -8.51300359e-02f, -8.88449773e-02f, -5.55774234e-02f, -8.86223763e-02f, -8.62496644e-02f, -7.83896074e-03f, -1.17410459e-01f,
  -3.83634865e-02f, 1.36077031e-02f, -9.67197344e-02f, -2.19534915e-02f, -1.39853992e-02f, -2.32698955e-02f, -8.92076716e-02f, -2.95646023e-02f, -1.95739116e-03f, -2.81729680e-02f,
  -1.49349868e-01f, -6.84098387e-03f, 1.95591096e-02f, 4.30803187e-02f, -1.18970819e-01f, -5.50468154e-02f, 1.14556774e-01f, 4.77668159e-02f, 5.06938137e-02f, 8.98794010e-02f,
  -2.66685873e-01f, 2.56162614e-01f, 5.01836427e-02f, -1.99581683e-01f, -8.68478566e-02f, 1.01702116e-01f, 2.57092237e-01f, 1.52707487e-01f, -8.23571458e-02f, 1.24809138e-01f,
  -3.27266902e-02f, -1.67540267e-01f, -1.16941959e-01f, -3.85255404e-02f, 2.66810693e-02f, 1.98547140e-01f, 9.32068389e-04f, -1.79809436e-01f, -6.35146946e-02f, 8.03509951e-02f,
  1.33235930e-02f, 1.73659287e-02f, -3.45705934e-02f, 2.64528152e-02f, 6.66276366e-02f, -1.25544533e-01f, 1.16143093e-01f, -2.04565264e-02f, 7.05593154e-02f, -1.44311599e-02f,
  -6.96411952e-02f, 5.07456474e-02f, -6.89803138e-02f, -8.54904801e-02f, -1.44213494e-02f, 4.09056060e-03f, -6.52308762e-02f, -3.54774036e-02f, 1.75937954e-02f, 6.27191365e-02f,
  -5.42298891e-02f, 1.52412904e-02f, -3.21016721e-02f, 2.78455988e-02f, 7.64831081e-02f, 7.95286298e-02f, 2.62921341e-02f, 5.86081333e-02f, -8.54454264e-02f, 5.33467308e-02f,
  2.53005400e-02f, -2.83813719e-02f, -6.60810992e-02f, 3.59099843e-02f, 3.43759879e-02f, -8.33803639e-02f, 2.68191136e-02f, -2.69625038e-02f, 6.64306059e-02f, 1.06880013e-02f,
  6.55432343e-02f, -3.74311791e-03f, 5.35920747e-02f, 4.81577553e-02f, -4.74401601e-02f, 3.86438593e-02f, -4.85977493e-02f, -5.61101027e-02f, 5.56599572e-02f, 1.72913130e-02f,
  -4.08935510e-02f, 4.52734716e-02f, 6.32016063e-02f, -1.46690086e-02f, 6.10923918e-04f, 1.02842897e-01f, 3.37481499e-02f, -1.32447574e-02f, 2.79196426e-02f, 4.68522869e-02f,
  3.34953424e-03f, 5.73171079e-02f, 4.08205763e-02f, 7.94423521e-02f, 4.75327894e-02f, 3.94545356e-03f, 5.34713455e-02f, -1.89725831e-02f, 4.93415864e-03f, 4.19314317e-02f,
  -9.22643989e-02f, -1.13835812e-01f, -1.59311984e-02f, 8.13808516e-02f, -4.67458740e-02f, -5.22606373e-02f, -9.52599943e-02f, -4.29605395e-02f, -5.40781692e-02f, -1.05427824e-01f,
  -5.80984689e-02f, 8.78133718e-03f, 1.24599347e-02f, -2.79190075e-02f, -2.29458325e-02f, 6.71462528e-03f, -6.12165704e-02f, -3.86270247e-02f, 4.86537348e-03f, -1.37266237e-02f,
  -3.66794993e-03f, -1.11796577e-02f, -3.78209837e-02f, -4.25841250e-02f, -8.28634277e-02f, -1.41736701e-01f, -1.01122633e-01f, 9.46697127e-03f, -7.72996992e-02f, 5.52200526e-02f,
  -7.09321573e-02f, -1.31906867e-02f, -1.16023958e-01f, 2.53091782e-01f, 1.53103471e-01f, 5.53481281e-02f, -3.50804664e-02f, 9.59498361e-02f, 2.75158621e-02f, 2.24740729e-02f,
  1.27346575e-01f, 2.87874460e-01f, 1.11877248e-01f, 1.96642920e-01f, 1.06657080e-01f, 9.08431932e-02f, 5.28977513e-02f, 5.49746864e-02f, 1.90366320e-02f, 7.51413926e-02f,
  4.97958027e-02f, 5.36414497e-02f, -1.30616561e-01f, -2.56741624e-02f, 1.14924528e-01f, 2.74024278e-01f, 8.24327245e-02f, -1.16757207e-01f, -1.26127884e-01f, 7.92002454e-02f,
  1.93529740e-01f, -1.16782427e-01f, 1.05210587e-01f, 1.30836189e-01f, -3.56926434e-02f, 9.50340182e-02f, 8.55775625e-02f, 1.18319079e-01f, 9.45475176e-02f, 1.17391944e-02f,
  4.74493988e-02f, 1.13949127e-01f, 1.60076782e-01f, 1.74958091e-02f, 1.00789241e-01f, 7.72276595e-02f, -3.15261586e-03f, -7.92259350e-02f, -5.63148633e-02f, -1.38215125e-02f,
  1.05094858e-01f, 5.97925819e-02f, -7.87324384e-02f, 7.65631199e-02f, 4.01266627e-02f, 1.76798888e-02f, -2.53403019e-02f, -5.28263580e-03f, -1.99980028e-02f, -7.59911388e-02f,
  -5.01123182e-02f, 1.07578322e-01f, 2.65377034e-02f, 7.20022842e-02f, 2.45557772e-03f, 1.57594755e-02f, 3.60915475e-02f, 8.40891823e-02f, -5.47783859e-02f, -1.51156560e-02f,
  4.03739847e-02f, -7.03159943e-02f, 4.35435679e-03f, -1.23264147e-02f, 9.29632485e-02f, 6.83103502e-02f, 3.03413942e-02f, 1.17651606e-02f, -3.75525914e-02f, -1.10200398e-01f,
  -9.37658995e-02f, -5.50740920e-02f, -1.53398262e-02f, -4.19390015e-03f, -1.02975601e-02f, 5.06989192e-03f, 8.17613751e-02f, 3.48609388e-02f, 1.09356701e-01f, -6.11458309e-02f,
  3.50497603e-01f, -4.38028686e-02f, 1.40203223e-01f, -2.18228884e-02f, 6.06145151e-02f, 4.19597514e-02f, -2.21516546e-02f, 5.74879237e-02f, 1.14707328e-01f, 7.68453032e-02f,
  -8.09689015e-02f, 2.75936089e-02f, 9.36169177e-02f, -1.52584892e-02f, 6.84966967e-02f, 1.12688065e-01f, 5.82686849e-02f, 1.22909352e-01f, 3.69812287e-02f, 2.54796315e-02f,
  -1.69815496e-02f, 1.11534864e-01f, 2.22355127e-01f, 1.19066983e-01f, 6.32779067e-03f, 1.66122615e-01f, 5.85879274e-02f, 1.42775699e-01f, 1.34948090e-01f, 1.98106617e-01f,
  1.63182124e-01f, 9.79808420e-02f, 1.21358976e-01f, 1.94933847e-01f, 1.92006826e-02f, -2.55771875e-02f, -3.30485515e-02f, 1.89133477e-03f, 2.63265409e-02f, -7.59320557e-02f,
  9.60785821e-02f, 2.41214689e-02f, 9.74502880e-03f, 1.54693112e-01f, 1.69707820e-01f, -6.07416667e-02f, -1.68224871e-02f, 1.75873265e-01f, -4.77706380e-02f, -1.27275065e-01f,
  -1.15520492e-01f, -4.91383672e-02f, -3.26879285e-02f, -3.47201480e-03f, -4.59892899e-02f, -8.18812381e-03f, -9.98115912e-02f, -9.63071361e-02f, -3.79354917e-02f, 1.21735312e-01f,
  1.16806991e-01f, 1.06420822e-01f, 1.54131711e-01f, 6.51737973e-02f, 1.19257294e-01f, 1.11058086e-01f, 8.75875130e-02f, 1.53312296e-01f, 2.07601804e-02f, 1.02889501e-01f,
  1.83301374e-01f, 1.57741934e-01f, 9.20919236e-03f, -4.11496758e-02f, 8.70562494e-02f, 2.82188933e-02f, 4.80478629e-02f, 7.74126053e-02f, 1.73156604e-01f, 1.41113801e-02f,
  1.24583133e-01f, 7.06365556e-02f, 6.99462369e-02f, 1.18945753e-02f, 1.08831033e-01f, 1.51568845e-01f, 1.27937868e-01f, 1.44454628e-01f, 1.27656147e-01f, 1.03336841e-01f,
  -3.25421877e-02f, -1.82334110e-01f, -1.39219135e-01f, -8.82076249e-02f, -1.53204128e-01f, -3.42141390e-02f, -3.23119536e-02f, -1.94231212e-01f, -8.87701660e-02f, -1.27358049e-01f,
  2.36165319e-02f, 5.98763488e-02f, -6.08318299e-03f, -5.41871786e-02f, -8.00261572e-02f, 3.88259664e-02f, -2.00233534e-02f, -1.25105008e-01f, -7.27433860e-02f, -4.89969254e-02f,
  -3.60534266e-02f, -1.57091841e-02f, -6.64146021e-02f, -1.07510071e-02f, 5.08363247e-02f, -3.22350785e-02f, -1.35237928e-02f, -7.16162175e-02f, -1.23055354e-01f, 5.00362813e-02f,
  -2.17213139e-01f, 2.65513986e-01f, 8.22160095e-02f, 2.25339904e-02f, 9.41710025e-02f, 8.55696127e-02f, 5.08924760e-02f, 8.83209482e-02f, 7.03551397e-02f, 5.57507426e-02f,
  4.44163978e-02f, 1.12499222e-01f, -1.62291769e-02f, 8.99341926e-02f, -1.39392074e-02f, 7.20956922e-02f, -4.81876507e-02f, 1.17375843e-01f, -2.18968298e-02f, -1.75214000e-02f,
  -4.22268808e-02f, 5.25713935e-02f, 5.39560430e-02f, 3.45977135e-02f, 1.09577933e-02f, 1.41958982e-01f, 1.75080094e-02f, -2.57955715e-02f, 1.49168745e-01f, 2.15351228e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.81763941e-01f, 2.14886740e-01f, -1.62388906e-01f, 1.11165628e-01f, 2.78463125e-01f, 1.27341151e-01f, 8.15364644e-02f, -1.25605896e-01f, -5.12866909e-03f, 1.06204003e-01f,
  6.85261339e-02f, 2.39698626e-02f, -2.20808275e-02f, 3.50258611e-02f, -6.12552240e-02f, 1.26515463e-01f, 2.66202152e-01f, 2.48998851e-02f, -2.14180544e-01f, -1.05514601e-01f,
  2.36861497e-01f, 2.06579007e-02f, -9.19990391e-02f, 2.98396088e-02f, 1.92206472e-01f, 1.56476527e-01f, 5.14789596e-02f, 1.04835689e-01f, 1.42003983e-01f, 1.61972135e-01f,
  -2.31320933e-01f, -2.91945159e-01f, -6.12877607e-02f, -6.86232448e-02f, -1.02548404e-02f, -2.65293241e-01f, -1.89606801e-01f, -1.39585912e-01f, -9.93074775e-02f, -1.27413973e-01f,
  9.17101130e-02f, -9.65854153e-02f, 1.08843103e-01f, 1.92496777e-02f, -1.63189754e-01f, -1.35482192e-01f, 8.77161417e-03f, -2.92537630e-01f, -1.96576938e-01f, -2.82166392e-01f,
  3.58213991e-01f, 1.22884534e-01f, -1.96019784e-01f, -1.86124429e-01f, -2.13975027e-01f, -1.74932629e-01f, -1.31391242e-01f, -1.56095639e-01f, -3.11356038e-01f, -1.11875810e-01f,
  -1.01093784e-01f, -1.10092163e-01f, -7.52346069e-02f, 6.83315983e-03f, 4.51457575e-02f, 4.13548350e-02f, 7.00635910e-02f, 6.41352125e-03f, -2.50517931e-02f, -2.31340863e-02f,
  1.08555686e-02f, -8.62014741e-02f, -5.30053824e-02f, -9.04343575e-02f, 5.45482077e-02f, 6.82304502e-02f, -3.33796404e-02f, -1.57150447e-01f, 2.33941041e-02f, 2.48604454e-02f,
  7.02083409e-02f, -6.41661137e-02f, -4.15684581e-02f, -1.30146056e-01f, -5.43594696e-02f, -4.96620573e-02f, -1.65902257e-01f, -1.12437300e-01f, -1.23254452e-02f, -1.84072163e-02f,
  9.04944073e-03f, -9.97469425e-02f, -7.63298273e-02f, -1.88186154e-01f, 1.35224098e-02f, 1.52978413e-02f, 1.57197025e-02f, -4.48725373e-02f, -5.00432663e-02f, -2.48812288e-01f,
  -6.80535734e-02f, -9.79744494e-02f, 7.91778713e-02f, -1.45763919e-01f, -1.34936526e-01f, -1.51316047e-01f, 1.20243557e-01f, 1.93178758e-01f, 6.06808588e-02f, -1.91115513e-01f,
  4.63537648e-02f, 4.00877707e-02f, -1.69928595e-01f, -1.53602883e-01f, -3.83484662e-02f, -4.25847955e-02f, -1.62856132e-01f, -1.55229215e-02f, -7.50767589e-02f, -1.32523805e-01f,
  -5.27255714e-01f, -1.23032004e-01f, -2.25686148e-01f, -5.40370524e-01f, -2.61344790e-01f, 2.30890904e-02f, 2.91834474e-01f, 1.50384922e-02f, -3.83933127e-01f, -7.50279203e-02f,
  2.17746377e-01f, 1.31334856e-01f, -2.45873649e-02f, 1.36110827e-01f, 2.48616442e-01f, 1.38881430e-02f, -3.83855969e-01f, -3.41989025e-02f, 2.10369959e-01f, 3.37544590e-01f,
  1.36833340e-01f, -5.58774471e-02f, -1.32340625e-01f, -4.89542820e-02f, -1.16591312e-01f, -9.37677398e-02f, -1.64491564e-01f, -2.23417148e-01f, 1.89493131e-02f, -2.70760298e-01f,
  1.44751698e-01f, -3.33761513e-01f, 4.38874476e-02f, -5.81373535e-02f, -5.02576753e-02f, 8.51245597e-03f, 3.17830369e-02f, -1.66943297e-01f, -4.59918659e-03f, -9.96586457e-02f,
  -2.17987955e-01f, 9.52166393e-02f, -4.07093875e-02f, 8.88490379e-02f, 6.34079054e-02f, 6.69917986e-02f, -1.85103975e-02f, -8.87007192e-02f, -1.95060447e-01f, 1.52177572e-01f,
  8.61930940e-03f, -1.27242673e-02f, -1.61645100e-01f, -6.98095411e-02f, 4.15471792e-02f, -7.91415572e-02f, 2.22860366e-01f, -1.10978466e-02f, -4.54616994e-02f, 5.80254905e-02f,
  1.07273147e-01f, 3.28521384e-03f, 2.25697272e-02f, -1.83717012e-02f, 2.08261814e-02f, -4.79659326e-02f, -2.31626276e-02f, 1.56250432e-01f, 7.73632526e-02f, 6.73630461e-02f,
  -1.02946945e-01f, -2.47887727e-02f, -4.19874825e-02f, -1.02979183e-01f, -1.52357593e-02f, -6.75437599e-02f, -1.35974046e-02f, 2.06699952e-01f, -7.05119874e-03f, -1.05309866e-01f,
  -4.28717919e-02f, -1.58487439e-01f, -1.73477884e-02f, 1.42557725e-01f, -1.84035107e-01f, -4.43518497e-02f, 3.27599957e-03f, 1.54087737e-01f, 5.10838442e-02f, -3.07856966e-02f,
  8.03438053e-02f, -1.52249876e-02f, -2.75799707e-02f, -9.02741477e-02f, 3.48153412e-02f, -5.67135029e-03f, -1.41395226e-01f, 1.00251362e-01f, -1.50942832e-01f, 1.36290893e-01f,
  2.46697050e-02f, -5.79494750e-04f, 3.77675518e-02f, 1.86229274e-02f, 6.79701865e-02f, 9.14913937e-02f, 1.17857577e-02f, -1.06293753e-01f, -1.88330114e-01f, -2.70731077e-02f,
  -1.67922396e-02f, 4.10903431e-02f, 6.76261559e-02f, 1.04411151e-02f, 9.86339897e-03f, -1.51938293e-02f, 2.55234838e-01f, 4.30217162e-02f, 9.44219157e-02f, 1.36934087e-01f,
  -1.11842163e-01f, 1.26670882e-01f, -1.77594781e-01f, 2.72955418e-01f, 3.43114108e-01f, 2.22541437e-01f, 2.89137345e-02f, 3.46595049e-02f, 1.05277576e-01f, 2.23109741e-02f,
  2.59509951e-01f, 1.81585357e-01f, 1.77508354e-01f, 1.58905029e-01f, -1.33930981e-01f, -2.41604522e-02f, 1.65135637e-01f, -1.15323346e-02f, -1.01708405e-01f, 9.53696892e-02f,
  1.77155674e-01f, 7.31229549e-03f, -1.85821235e-01f, -1.06950067e-01f, 1.96221858e-01f, 1.33303061e-01f, -2.03196108e-02f, 1.44379005e-01f, 8.71245265e-02f, 8.80642086e-02f,
  -1.18885890e-01f, -1.36894956e-01f, -1.19818468e-02f, 7.44586959e-02f, 2.12502126e-02f, -2.55703330e-01f, -1.09223433e-01f, -2.10902542e-01f, -4.23965156e-02f, -1.31566823e-01f,
  1.09373935e-01f, -8.31078514e-02f, -6.20199833e-03f, -7.95168951e-02f, -2.00936094e-01f, -1.00083373e-01f, -2.57819772e-01f, -3.68206441e-01f, -2.28317261e-01f, -1.75139964e-01f,
  2.25855276e-01f, 1.92336127e-01f, -1.58913001e-01f, -1.36180103e-01f, -2.42465168e-01f, 4.47056703e-02f, -2.47271135e-01f, -1.91177666e-01f, -3.04345042e-01f, -2.97786206e-01f,
  5.88264922e-03f, -2.69596297e-02f, 3.71098518e-02f, -7.99467564e-02f, -7.06414431e-02f, 8.71977583e-02f, -2.71144435e-02f, 5.94054833e-02f, -5.92834549e-03f, -2.40539275e-02f,
  8.24498013e-02f, 8.16540197e-02f, -7.40543306e-02f, -4.44186516e-02f, 3.60463373e-02f, 4.26355340e-02f, -1.76024307e-02f, -1.13282641e-02f, 9.01810154e-02f, -7.21795904e-03f,
  5.53938262e-02f, -1.50259286e-02f, -1.80648584e-02f, -4.89445031e-02f, 5.91966026e-02f, 1.89376369e-01f, -7.28246421e-02f, -3.23499963e-02f, 1.12384118e-01f, -1.30814403e-01f,
  -4.20481563e-02f, 2.10976750e-02f, -4.76800231e-03f, 7.91958049e-02f, 9.22428817e-02f, 7.14240074e-02f, 2.30260149e-01f, -7.56653398e-02f, -8.40975046e-02f, -3.26881222e-02f,
  -5.05378693e-02f, 3.36416662e-02f, 8.46180785e-03f, -1.93335772e-01f, -1.66908223e-02f, -6.00851141e-02f, 8.74992833e-03f, 7.12479725e-02f, -4.86523584e-02f, 9.33341961e-03f,
  -3.67094278e-02f, -1.33539215e-01f, -1.20968990e-01f, 1.19536202e-02f, 2.61994991e-02f, 5.28441258e-02f, -4.57448289e-02f, -1.13596097e-01f, -1.51578650e-01f, -2.96345949e-01f,
  -4.27361012e-01f, -6.96636662e-02f, 2.40913346e-01f, -1.17720999e-01f, -2.65392382e-02f, 5.97323440e-02f, -2.03994766e-01f, -8.20231959e-02f, -1.34846568e-02f, -1.18291816e-02f,
  -3.00483909e-02f, -4.43961620e-02f, 7.46594146e-02f, 1.71791576e-02f, -1.31481245e-01f, 7.73433223e-02f, 5.67191876e-02f, 4.64697741e-03f, -9.88983512e-02f, -1.86788008e-01f,
  -1.46047443e-01f, -2.10354198e-02f, 8.75753351e-03f, -7.65371323e-02f, -8.63367841e-02f, -1.13667481e-01f, 8.45127553e-02f, -5.32094017e-02f, -6.84875697e-02f, -1.48411259e-01f,
  2.76626423e-02f, -2.77056605e-01f, 1.11056618e-01f, -1.96520045e-01f, 1.33342177e-01f, 5.83078153e-02f, -1.37105323e-02f, 1.11025542e-01f, -7.91678950e-03f, 7.52884373e-02f,
  1.19563840e-01f, 1.58534124e-01f, -1.21363305e-01f, 1.07814364e-01f, -9.04082656e-02f, -9.12965015e-02f, 1.51382145e-02f, 1.15523867e-01f, 7.10492060e-02f, 5.30424453e-02f,
  -2.67391168e-02f, -7.49830529e-02f, -1.78750515e-01f, 3.46398680e-03f, 1.47905916e-01f, 1.12311915e-01f, 7.61347562e-02f, 1.37792164e-02f, 7.06391335e-02f, -2.21788883e-01f,
  2.57978775e-02f, -1.70627348e-02f, 1.99257433e-01f, 3.34827155e-02f, 1.76673252e-02f, 6.24822937e-02f, 1.09391965e-01f, -5.78066148e-03f, -1.25561774e-01f, 1.07242418e-02f,
  1.08058445e-01f, 3.31705809e-02f, 3.12908925e-02f, -1.25753909e-01f, 4.79984730e-02f, 3.22543755e-02f, -2.54188776e-01f, -1.29039034e-01f, 7.28551345e-03f, -1.41529525e-02f,
  -1.67464502e-02f, 1.37713384e-02f, 1.31956741e-01f, -3.30931507e-02f, -1.26390144e-01f, 1.09328240e-01f, 7.54991174e-02f, -3.30056921e-02f, -4.92974706e-02f, -8.30254853e-02f,
  -1.00503460e-01f, 9.19585302e-02f, -9.01704207e-02f, -6.29660189e-02f, -5.34530077e-03f, 2.08663628e-01f, -5.14172055e-02f, 7.25637525e-02f, -4.09500338e-02f, -1.49681538e-01f,
  -1.01125017e-01f, -4.07581404e-02f, 5.54868579e-02f, 1.87506378e-01f, -8.40964392e-02f, -1.28935754e-01f, -9.08281803e-02f, 5.12594469e-02f, 9.97315161e-04f, 9.97945480e-03f,
  -5.77731803e-02f, -2.14581445e-01f, -3.17144513e-01f, -3.20162214e-02f, -8.71796384e-02f, -1.92704007e-01f, -1.57625392e-01f, -2.67818242e-01f, -2.33549550e-01f, -4.33567762e-01f,
  4.27036256e-01f, -4.25278664e-01f, -3.24132115e-01f, 1.31682947e-01f, -6.45240322e-02f, 8.75376258e-03f, -2.11637989e-01f, -1.07992357e-02f, 2.02711210e-01f, -6.29605353e-02f,
  8.35374594e-02f, 2.93185055e-01f, 1.70374468e-01f, 1.32469893e-01f, 1.14421509e-01f, -3.08427781e-01f, -1.76747501e-01f, 7.66910389e-02f, 1.58913881e-01f, 1.88883528e-01f,
  -4.04614881e-02f, 3.99395227e-02f, 1.69665158e-01f, 9.92709920e-02f, -2.36640915e-01f, 2.01994441e-02f, -3.65047216e-01f, -6.91958750e-03f, -9.84165370e-02f, -2.38778412e-01f,
  1.41505226e-01f, 1.93893462e-02f, 9.95837674e-02f, 5.40965013e-02f, -4.21215855e-02f, 1.06040826e-02f, -1.14652559e-01f, -1.14036396e-01f, -3.80456410e-02f, 1.24193214e-01f,
  6.97617233e-02f, -3.35160643e-02f, -2.68368740e-02f, -1.14665538e-01f, -4.25341502e-02f, 4.22688462e-02f, -1.26105566e-02f, -1.10690668e-02f, -9.53869428e-03f, 3.20505979e-03f,
  -1.63276747e-01f, 2.66042165e-02f, 5.46410419e-02f, -4.07344438e-02f, -2.26032641e-02f, -2.20335145e-02f, -1.96191862e-01f, -5.94668873e-02f, -1.10384241e-01f, -2.88581818e-01f,
  1.96934938e-02f, -1.22149074e-02f, -1.45960990e-02f, -7.02942461e-02f, -7.62974843e-02f, 9.19115767e-02f, -4.64711301e-02f, 3.29073258e-02f, 2.19545942e-02f, 1.62732508e-02f,
  9.06575173e-02f, 7.19455630e-02f, 7.26800188e-02f, -7.91737884e-02f, 6.47380948e-02f, -3.88154201e-02f, 6.82095736e-02f, -3.95645313e-02f, 1.21552691e-01f, 1.48485694e-02f,
  -5.27436007e-03f, 6.98480010e-02f, -1.06959986e-02f, 3.64661664e-02f, -1.71437524e-02f, -4.97688912e-02f, -6.27494417e-03f, 8.15730244e-02f, 1.24002293e-01f, 6.57135025e-02f,
  1.24595888e-01f, -4.25034650e-02f, 5.21488525e-02f, -3.74477953e-02f, -2.12673508e-02f, 5.28598726e-02f, 4.60603982e-02f, 1.90478712e-02f, -4.43260930e-03f, -9.87048298e-02f,
  -5.01461385e-04f, 3.10438816e-02f, -2.02209707e-02f, -1.77389771e-01f, 6.29223650e-03f, 1.37307122e-01f, 3.29636643e-03f, 7.73018301e-02f, 7.00952346e-03f, 4.97108847e-02f,
  -3.13495621e-02f, 8.56680721e-02f, 8.60558897e-02f, 3.31661627e-02f, 4.12284359e-02f, 9.32968874e-03f, -1.72912836e-01f, -1.42496556e-01f, 8.84567052e-02f, -1.30341753e-01f,
  -4.09626514e-01f, 6.85538501e-02f, 3.42380881e-01f, -1.96244702e-01f, 3.38192284e-03f, 1.21241517e-01f, 9.39066187e-02f, -1.66250467e-01f, -2.47770235e-01f, 1.24377264e-02f,
  -7.15788975e-02f, -2.09911749e-01f, -8.99478346e-02f, 4.97471057e-02f, -5.03621921e-02f, 1.19795822e-01f, 2.93373950e-02f, -4.20638733e-03f, -1.07140072e-01f, -2.48475790e-01f,
  -1.48530856e-01f, -1.78163886e-01f, -1.89990550e-01f, 4.42883074e-02f, -5.22887893e-02f, -1.38986871e-01f, 1.74851537e-01f, 2.04396956e-02f, 2.28284411e-02f, -3.29220034e-02f,
  5.64289168e-02f, 7.76050612e-03f, 1.35912508e-01f, -1.16703548e-01f, 2.11838961e-01f, 1.92979258e-02f, -5.25194407e-02f, 2.09187955e-01f, 1.65049266e-02f, -1.21035255e-01f,
  7.48664215e-02f, -5.36991796e-03f, -1.47079691e-01f, -1.04014039e-01f, -3.91833968e-02f, -6.37096986e-02f, -1.06621802e-01f, -4.57348078e-02f, -1.06060347e-02f, -1.70952994e-02f,
  -1.22276787e-02f, -1.48955151e-01f, -3.34125757e-02f, 1.46991417e-01f, 1.74114741e-02f, -7.65394792e-02f, 1.83449537e-01f, -7.61809647e-02f, 3.55797168e-03f, -9.96531248e-02f,
  -1.12281874e-01f, 4.09178250e-02f, 6.61751851e-02f, 6.04264177e-02f, -7.47832805e-02f, 9.49055031e-02f, 4.58601452e-02f, -3.00226994e-02f, -5.99441007e-02f, -1.97151199e-01f,
  -6.08796626e-03f, 6.90872818e-02f, 9.41434577e-02f, 3.65186296e-02f, 1.29583418e-01f, 3.72472666e-02f, 3.45638990e-02f, 4.97973599e-02f, -1.36724031e-02f, -3.60750295e-02f,
  -1.08049132e-01f, 6.18830882e-02f, -7.51491031e-03f, -1.70232560e-02f, 5.70516810e-02f, 2.85613593e-02f, 9.67589840e-02f, 5.82070090e-02f, -6.04864135e-02f, 2.98959967e-02f,
  -1.98015660e-01f, 2.51001209e-01f, -6.11189492e-02f, -8.20331648e-02f, 6.68107346e-02f, 1.62165090e-01f, 4.04754765e-02f, 1.30007535e-01f, -7.32597560e-02f, -5.00569604e-02f,
  4.11896110e-02f, 1.61805987e-01f, 8.22190717e-02f, 2.38753157e-03f, 9.14203972e-02f, -5.85142598e-02f, -3.23225446e-02f, 5.75774461e-02f, -1.27745494e-01f, -1.91155300e-01f,
  -6.32622764e-02f, -2.14387655e-01f, -2.47797877e-01f, -9.31101069e-02f, -1.10233001e-01f, -1.09629206e-01f, -2.64466405e-02f, -1.56291172e-01f, -5.53979725e-02f, 5.74384853e-02f,
  -2.13761255e-01f, 5.44074103e-02f, 1.93208501e-01f, 3.71912532e-02f, 4.09091152e-02f, -1.77997887e-01f, -2.82652587e-01f, -1.81566611e-01f, -3.05499788e-02f, 5.18881045e-02f,
  -1.12982146e-01f, 1.73743032e-02f, 5.41794524e-02f, 3.86414714e-02f, -9.46769118e-02f, 1.46755829e-01f, 2.85889447e-01f, 8.01891237e-02f, -3.00923675e-01f, -3.27721417e-01f,
  9.27158594e-02f, -5.46291657e-02f, -1.26258820e-01f, 1.71882260e-04f, 2.27089465e-01f, 1.78311523e-02f, 2.40160644e-01f, 1.47886872e-01f, 1.72103390e-01f, 3.80002052e-01f,
  7.47208670e-03f, -7.70578161e-02f, -5.17827719e-02f, -9.71796513e-02f, 9.32071209e-02f, 1.13841459e-01f, 4.24015149e-02f, 1.64524794e-01f, 9.66395885e-02f, -2.95481030e-02f,
  -5.99337555e-03f, 1.00844696e-01f, 2.36735363e-02f, -1.05233498e-01f, -5.74671179e-02f, -1.49145350e-01f, -1.33584335e-01f, -2.52630394e-02f, -8.12872946e-02f, -7.67633095e-02f,
  2.44399920e-01f, -5.39412759e-02f, -5.83937317e-02f, 5.04593924e-03f, 9.25589502e-02f, -5.32226302e-02f, -1.69018686e-01f, -7.36622959e-02f, -2.04005510e-01f, 7.33848885e-02f,
  -1.43678496e-02f, 5.41529171e-02f, 1.32977039e-01f, 7.28660151e-02f, 4.82907034e-02f, 7.57982880e-02f, 2.00973004e-01f, 4.44668122e-02f, 3.90486009e-02f, -2.60855108e-02f,
  1.07246742e-01f, -3.68955880e-02f, 7.48140067e-02f, 2.78542470e-02f, 1.03096068e-01f, 6.61067888e-02f, 4.28997092e-02f, -1.86572596e-02f, -3.17782573e-02f, 2.01711550e-01f,
  -3.07667442e-02f, 7.12487474e-02f, 1.25685886e-01f, -4.03939448e-02f, 1.44868204e-02f, 1.16397403e-01f, -1.28486566e-02f, -1.19810179e-02f, 1.95063576e-02f, 8.10555965e-02f,
  -4.94180508e-02f, -3.40621620e-02f, 1.21717475e-01f, 3.02445106e-02f, 4.95734550e-02f, -6.94258697e-03f, 7.38462284e-02f, 1.24557465e-02f, -5.36569990e-02f, -2.90920865e-02f,
  -1.34884983e-01f, 1.11269914e-01f, 2.01459527e-02f, -7.80092701e-02f, -5.95086925e-02f, -1.09102346e-01f, -1.29914761e-01f, -2.99943835e-02f, -1.91214457e-01f, -8.60387385e-02f,
  -8.94754473e-03f, -2.23795772e-01f, -2.02435955e-01f, -1.42076582e-01f, -7.20102414e-02f, -5.94781153e-02f, -1.41206101e-01f, -2.38529816e-02f, -2.08811149e-01f, -1.08620800e-01f,
  5.05798280e-01f, -4.44870181e-02f, 1.78014979e-01f, 1.62593201e-01f, 7.64658600e-02f, 1.37924299e-01f, 7.08150268e-02f, -5.92352487e-02f, -2.72768643e-02f, 1.04907807e-02f,
  -1.85279418e-02f, 1.65461794e-01f, 1.88085586e-01f, 1.47667557e-01f, 1.77253917e-01f, -4.97527644e-02f, 5.82553297e-02f, 2.52330482e-01f, 1.19543627e-01f, 3.60031091e-02f,
  -1.33366615e-01f, -1.86082032e-02f, 1.48661226e-01f, -9.13795084e-03f, 3.71033810e-02f, -1.33390613e-02f, 2.09627040e-02f, 5.19588888e-02f, -3.69587950e-02f, -3.40182930e-02f,
  -4.66189422e-02f, 9.34111923e-02f, 7.92730674e-02f, 7.08660334e-02f, 2.82317903e-02f, -6.95505440e-02f, -1.53058589e-01f, -2.22094692e-02f, -8.65369961e-02f, -1.01269700e-01f,
  -7.63534531e-02f, -8.33882540e-02f, 7.28866607e-02f, 3.09013445e-02f, -6.76430482e-03f, 3.42398207e-03f, -7.88247287e-02f, 9.45482701e-02f, 1.01178981e-01f, -7.22477660e-02f,
  -7.61234462e-02f, -1.24200182e-02f, -3.74680534e-02f, 2.17520054e-02f, 1.25436038e-01f, 1.19483337e-01f, -6.07424043e-02f, 9.50489864e-02f, 2.33368613e-02f, -3.71481292e-02f,
  9.08592865e-02f, 2.29312256e-01f, 2.20957205e-01f, 1.06512092e-01f, 5.57979532e-02f, 7.27308765e-02f, 2.11822558e-02f, -7.27059692e-02f, 3.41556817e-02f, -1.18819894e-02f,
  -3.23315635e-02f, 7.09116459e-02f, 8.49831402e-02f, 4.75968681e-02f, 4.19786386e-02f, -3.84920500e-02f, -1.03783295e-01f, -8.03423226e-02f, 1.20845236e-01f, -1.22981407e-01f,
  -2.76388507e-02f, -2.94946712e-02f, -7.17683956e-02f, 5.99862672e-02f, 3.46436650e-02f, 3.22043933e-02f, 5.95573820e-02f, 4.77624945e-02f, -4.44503725e-02f, 3.31691536e-03f,
  -3.96077186e-01f, 9.68515128e-02f, -9.06284302e-02f, 1.19122090e-02f, -1.03062563e-01f, -1.27041996e-01f, -4.00788076e-02f, -1.39625361e-02f, -1.26385629e-01f, -1.32469997e-01f,
  -1.83415398e-01f, -1.24524310e-02f, 5.63736595e-02f, -9.61170048e-02f, -9.71359834e-02f, -9.86256599e-02f, 4.01289165e-02f, -6.18554428e-02f, -7.04874992e-02f, -2.19150156e-01f,
  -1.35755792e-01f, 2.66016684e-02f, -2.21509114e-02f, 5.94561882e-02f, 9.59053729e-03f, 7.49552101e-02f, -1.57640700e-03f, -1.52858393e-02f, 1.30983189e-01f, -5.93675785e-02f,
  -4.32361633e-01f, 8.48487392e-02f, -7.95156136e-03f, -4.13340151e-01f, 1.44527867e-01f, 2.82138526e-01f, 3.28995556e-01f, 1.61683381e-01f, -1.18772790e-01f, -4.20505963e-02f,
  9.43234563e-02f, -1.06845446e-01f, -1.02629021e-01f, -4.00669686e-02f, 9.93040763e-03f, 4.05320637e-02f, -1.15576342e-01f, -9.82488394e-02f, 5.56470044e-02f, 1.81242436e-01f,
  7.64967874e-02f, -2.02295840e-01f, -2.73885041e-01f, -6.91150427e-02f, -2.85596460e-01f, -3.48179460e-01f, -1.44164473e-01f, -7.72485659e-02f, 6.16336539e-02f, -2.39023611e-01f,
  -9.55389813e-02f, 1.65245514e-02f, 1.29859313e-01f, -1.17130592e-01f, -5.26913181e-02f, -5.37517294e-03f, 1.19591899e-01f, -6.39320305e-03f, 2.16970744e-04f, -2.96821166e-03f,
  -1.07125878e-01f, 1.60774440e-01f, -2.33684570e-01f, -7.50162005e-02f, 1.39204189e-01f, 2.07427889e-02f, -1.28886536e-01f, 1.93084814e-02f, 3.30112539e-02f, 1.50225684e-01f,
  9.89420936e-02f, 2.18858689e-01f, -8.63843560e-02f, 9.78284404e-02f, 1.80843949e-01f, -1.47138074e-01f, 9.00642201e-02f, -5.69343455e-02f, 2.50001196e-02f, -3.36604536e-01f,
  -1.68712568e-02f, 2.48020999e-02f, 1.81753207e-02f, 4.99125496e-02f, -1.36112273e-01f, 1.78845264e-02f, -7.46287629e-02f, 9.01214108e-02f, 6.66040108e-02f, -1.77763447e-01f,
  2.89159250e-02f, -2.89299842e-02f, -4.38608564e-02f, -6.78908229e-02f, 1.23715447e-02f, -9.82408598e-02f, 1.39118284e-02f, -5.24206040e-03f, -1.56554610e-01f, 5.02377981e-03f,
  9.01036039e-02f, -9.91365612e-02f, -6.78814799e-02f, 7.26345927e-02f, 1.00804143e-01f, 5.63722886e-02f, -2.08992884e-02f, 4.82453257e-02f, -3.09986584e-02f, 4.23254222e-02f,
  -5.14484286e-01f, 1.48301661e-01f, -1.61517337e-01f, 3.36795896e-02f, -5.21628633e-02f, 9.34776850e-03f, -2.18023844e-02f, -2.32037157e-02f, 1.14329398e-01f, -1.75600522e-03f,
  1.73024639e-01f, -1.41590275e-02f, -1.75925851e-01f, 2.26681903e-02f, 8.39440972e-02f, -4.30318825e-02f, -1.46693319e-01f, -7.93165341e-02f, 1.24998435e-01f, -1.54015854e-01f,
  -1.34544253e-01f, 6.20417530e-03f, -2.47284591e-01f, -9.46646109e-02f, -1.78853810e-01f, -1.86998144e-01f, -2.39385203e-01f, -5.88562563e-02f, 1.91226713e-02f, -5.22715747e-01f,
  -6.67018741e-02f, 4.83617961e-01f, 1.89038321e-01f, -1.61867067e-01f, 2.20755160e-01f, 2.83451170e-01f, 4.28960592e-01f, 1.54187977e-01f, -1.66924521e-01f, 1.62319720e-01f,
  1.96721315e-01f, -1.57907248e-01f, -1.67964354e-01f, -7.98079371e-02f, -4.64351065e-02f, 2.04313487e-01f, -3.59020829e-02f, -1.52427569e-01f, -2.96178758e-01f, -2.22224399e-01f,
  -1.02033667e-01f, -1.17127992e-01f, -2.66770244e-01f, -2.57798135e-01f, -1.43600628e-01f, -2.89748400e-01f, 5.69312535e-02f, -1.62864160e-02f, 5.59791662e-02f, -3.27550143e-01f,
  -2.61715632e-02f, 4.09093976e-01f, -2.69959003e-01f, -5.61092533e-02f, 1.33043304e-01f, -8.94559473e-02f, -9.00417492e-02f, -5.28498776e-02f, 4.86933328e-02f, -9.02745780e-03f,
  1.14516029e-02f, 2.68159378e-02f, 1.97257787e-01f, 8.94280896e-02f, 1.07762694e-01f, 7.23240674e-02f, 7.83586204e-02f, -7.29956944e-03f, -7.89715871e-02f, -2.32002847e-02f,
  3.77641208e-02f, 1.18526980e-01f, 1.83829457e-01f, 7.56186992e-02f, 1.49404481e-01f, -1.61496133e-01f, 1.10064097e-01f, -1.15331888e-01f, 5.36954924e-02f, -9.75056142e-02f,
  4.69607636e-02f, -1.17542725e-02f, 2.08347663e-02f, 1.94202513e-02f, -1.07562598e-02f, -1.47114983e-02f, -4.38354686e-02f, 3.94007266e-02f, -2.64283009e-02f, 6.83356151e-02f,
  5.39554395e-02f, 5.00628687e-02f, 2.68586054e-02f, 3.56659554e-02f, -1.47752121e-01f, 9.42391157e-02f, 6.19359352e-02f, 1.15797713e-01f, 3.96763720e-02f, 3.37975584e-02f,
  -2.46253591e-02f, -1.29253501e-02f, 6.34605810e-02f, -1.92690082e-02f, 7.16809034e-02f, 2.33927723e-02f, -8.35455060e-02f, 6.77261129e-02f, 2.17476822e-02f, 1.51472732e-01f,
  -1.58418804e-01f, 2.37770110e-01f, -2.66175807e-01f, -5.80975451e-02f, 2.12010667e-01f, -1.44198444e-02f, -6.24925494e-02f, -9.45464075e-02f, -5.60326651e-02f, 2.79165376e-02f,
  -7.88301229e-03f, 5.11048827e-03f, 1.87944487e-01f, -4.09640931e-02f, -2.10038707e-01f, -2.88302712e-02f, 5.38328849e-02f, -6.04979210e-02f, -7.07058683e-02f, -1.03205062e-01f,
  -6.14977144e-02f, -5.92336915e-02f, -9.91363004e-02f, -1.12838261e-01f, -7.45021999e-02f, -2.07537562e-01f, -1.07141487e-01f, -9.36761796e-02f, -9.19817612e-02f, -2.60426909e-01f,
  2.07378238e-01f, -1.28725588e-01f, 2.06782728e-01f, 7.38013610e-02f, 1.51395127e-02f, -5.31361513e-02f, -6.75042942e-02f, 1.77341159e-02f, 7.44411498e-02f, 7.38113299e-02f,
  6.99454099e-02f, 1.62130833e-01f, 1.54600337e-01f, 1.72132373e-01f, 1.88856751e-01f, 1.51000530e-01f, 9.91693139e-02f, 2.37302512e-01f, 3.07580292e-01f, 6.57556653e-02f,
  -2.08072718e-02f, 1.18399382e-01f, 1.13169424e-01f, 2.04747334e-01f, -1.48645481e-02f, 1.49798989e-01f, 1.49434730e-01f, 3.50963548e-02f, 4.88573201e-02f, -1.25940540e-03f,
  -3.93122695e-02f, 6.12193570e-02f, 8.69033858e-02f, 5.65688275e-02f, 8.79065171e-02f, -4.04192023e-02f, -6.76885098e-02f, -1.04453512e-01f, -8.59110728e-02f, -1.09945498e-01f,
  -1.50214210e-01f, -9.90357995e-02f, 1.35388514e-02f, -8.54844823e-02f, -6.98565543e-02f, -1.09433413e-01f, 1.00140736e-01f, 2.12864224e-02f, 9.69767421e-02f, -2.73647299e-03f,
  -2.74833851e-03f, -1.07860096e-01f, -5.97418398e-02f, 4.48901914e-02f, -4.33510579e-02f, 5.19149043e-02f, 9.84040927e-03f, -4.58709002e-02f, -1.43174632e-02f, 5.69906309e-02f,
  3.77885662e-02f, -4.12960770e-03f, 5.17528094e-02f, 9.83702540e-02f, 8.77881143e-03f, 7.64035806e-02f, 4.78225537e-02f, 1.09295249e-01f, 9.35725123e-03f, 2.90997070e-03f,
  1.17713749e-01f, 1.39639050e-01f, 6.31799623e-02f, 9.65177640e-02f, 1.09644391e-01f, -2.26914100e-02f, -2.13363439e-01f, 2.57904269e-02f, 3.90823558e-02f, 1.04863057e-02f,
  4.81833667e-02f, -2.91951299e-02f, 5.63073605e-02f, 1.45243332e-02f, -3.05339750e-02f, 1.19634539e-01f, 1.74100939e-02f, -4.02192548e-02f, -8.93001854e-02f, -1.21188238e-02f,
  -3.33445996e-01f, 5.51789030e-02f, 4.92049977e-02f, -9.90039483e-02f, -5.65472990e-02f, -5.27193695e-02f, 7.52501842e-03f, -6.07687309e-02f, -2.08980337e-01f, -9.40530971e-02f,
  -1.37971014e-01f, 7.12375203e-03f, -4.41585816e-02f, 1.99211296e-02f, -1.13431819e-01f, -1.21305473e-01f, -4.14912067e-02f, -1.33073451e-02f, -1.01471432e-02f, -3.50210108e-02f,
  -2.55538058e-02f, -1.24629162e-01f, -2.95126677e-01f, 9.51030292e-03f, -9.13135260e-02f, -3.91163826e-02f, -3.05917505e-02f, -4.33033593e-02f, -7.63651282e-02f, -1.78309262e-01f,
  4.57274824e-01f, -1.59368604e-01f, -1.21395491e-01f, -2.10317504e-02f, -2.49568984e-01f, -1.88580409e-01f, -1.15824714e-01f, 5.57034323e-03f, -1.45177305e-01f, -1.17787927e-01f,
  9.27973464e-02f, -3.87895358e-04f, 4.81984541e-02f, -4.55685565e-03f, -3.78181972e-02f, -2.60230452e-01f, -3.29336792e-01f, -5.69060482e-02f, 6.61001503e-02f, -5.21519296e-02f,
  -7.88182840e-02f, -1.70087382e-01f, -1.07986741e-01f, -2.50545796e-02f, -1.84531361e-01f, -2.70535499e-02f, -2.69005686e-01f, -1.24785602e-01f, -1.25116631e-01f, -2.15956956e-01f,
  -1.89208925e-01f, 2.60232687e-01f, 9.10361782e-02f, 1.21151738e-01f, 1.68526366e-01f, 1.12406433e-01f, 4.45398763e-02f, 9.94399115e-02f, 7.82493874e-02f, -6.60244226e-02f,
  2.55018566e-03f, 4.35913466e-02f, -1.48180285e-02f, 1.51740476e-01f, 8.63641798e-02f, 1.00780621e-01f, 2.38942951e-01f, -3.57522490e-03f, -1.38752922e-01f, -3.59559096e-02f,
  1.38758123e-01f, 2.18636170e-02f, -3.99541855e-02f, 5.34943379e-02f, 6.48598140e-03f, 9.86492112e-02f, 1.76927075e-01f, 1.08426690e-01f, 1.18145324e-01f, 1.24007769e-01f,
  -2.02916533e-01f, -1.09809510e-01f, 1.22924358e-01f, 2.13631198e-01f, 7.12431446e-02f, 9.36054811e-02f, 3.62633616e-02f, -4.44436483e-02f, 8.20271820e-02f, 4.14652340e-02f,
  -1.33364173e-02f, -7.16349334e-02f, 2.13381514e-01f, -1.72042087e-01f, -6.57304600e-02f, 2.88835037e-02f, 5.62068745e-02f, -8.16747993e-02f, 2.22252253e-02f, -5.61302453e-02f,
  9.70105380e-02f, 4.91021480e-03f, -1.05209745e-01f, -1.39249312e-02f, 7.40066916e-02f, -7.92267844e-02f, -7.20658228e-02f, -1.07500076e-01f, -7.24275261e-02f, -1.77673280e-01f,
  -4.94548008e-02f, 9.28634219e-03f, -5.99995740e-02f, 4.42023911e-02f, 6.87089749e-03f, 1.23338096e-01f, 6.21873885e-03f, -1.01231160e-02f, 5.89185860e-03f, -8.08001235e-02f,
  -4.81869765e-02f, 3.21090072e-02f, -6.68298304e-02f, 7.48088062e-02f, 1.49697214e-01f, 8.63282755e-02f, 2.36493751e-01f, 1.14357412e-01f, -6.35161474e-02f, -2.79680062e-02f,
  1.04362257e-01f, 2.76292227e-02f, 5.10487556e-02f, 1.24545330e-02f, -1.70018468e-02f, 5.21665663e-02f, 3.94335277e-02f, -4.00555041e-03f, -4.85187620e-02f, 8.83449838e-02f,
  -4.21113312e-01f, 8.19333419e-02f, -3.15386429e-02f, 3.86288017e-01f, 2.77808964e-01f, 2.51111299e-01f, 3.09100509e-01f, 1.62568659e-01f, 1.20354891e-01f, 2.17366993e-01f,
  2.62675256e-01f, 3.19631159e-01f, 2.37923965e-01f, 2.50861913e-01f, 1.00015722e-01f, 1.96942672e-01f, 2.72517532e-01f, 1.83503143e-02f, 6.66800067e-02f, 1.23624966e-01f,
  1.37803063e-01f, 1.01487927e-01f, -6.73195422e-02f, 9.00883451e-02f, 5.20758890e-02f, 1.83003619e-01f, 1.55172601e-01f, 1.65415928e-01f, 1.05762653e-01f, 7.30389804e-02f,
  -2.69584209e-02f, -1.96716145e-01f, 4.71341684e-02f, -5.76497279e-02f, -7.80518353e-02f, -2.49231651e-01f, 1.93270724e-02f, -6.98631033e-02f, -5.93469515e-02f, 4.60239723e-02f,
  -8.53973106e-02f, -4.36916053e-02f, -7.36593828e-03f, 3.94029282e-02f, -7.27347285e-02f, -1.33628920e-01f, -1.41268328e-01f, 2.90678232e-03f, 1.71643347e-01f, 1.31648883e-01f,
  8.38065818e-02f, 1.09476350e-01f, 8.32483266e-03f, 9.34274495e-02f, -3.61906067e-02f, 2.42456477e-02f, 4.12332788e-02f, -4.90243174e-02f, -6.86931387e-02f, -1.65127471e-01f,
  2.49809697e-01f, 4.18035164e-02f, -3.45694013e-02f, 2.05951408e-02f, -1.08292706e-01f, -1.75607264e-01f, -7.77041540e-02f, 1.29806578e-01f, 6.64193258e-02f, -1.20876156e-01f,
  2.58273575e-02f, 1.40038103e-01f, 3.40017602e-02f, -9.74963009e-02f, 4.69077490e-02f, -4.88405451e-02f, 2.06604656e-02f, 2.18882412e-02f, -1.16351858e-01f, -1.20059349e-01f,
  -1.24141586e-03f, -1.30326916e-02f, -1.34015873e-01f, -1.21590443e-01f, 5.46456240e-02f, -9.12357401e-03f, 4.67493273e-02f, 9.11882967e-02f, 9.91895143e-03f, 1.47438543e-02f,
  2.56698340e-01f, 1.42592445e-01f, 2.58832965e-02f, 3.72526199e-02f, -1.24140210e-01f, -1.18571937e-01f, -3.06218024e-02f, -5.47356978e-02f, -7.11651817e-02f, 7.45944232e-02f,
  -8.58749449e-02f, -8.24863315e-02f, -9.10632685e-02f, -3.10637653e-02f, -1.01717837e-01f, -3.22467387e-02f, 2.07382794e-02f, 1.01429448e-01f, 1.00133650e-01f, -4.99937311e-02f,
  -1.48125477e-02f, 1.00882754e-01f, 1.07993176e-02f, 9.50942412e-02f, 1.95518099e-02f, 9.41596329e-02f, -1.42458081e-01f, -2.46613584e-02f, -7.38988770e-03f, -5.46511002e-02f,
  3.47703882e-02f, -2.00146064e-01f, -1.79732172e-03f, 8.02203864e-02f, -2.43550315e-01f, -1.59536958e-01f, -2.58643299e-01f, -1.20303370e-02f, 1.88393164e-02f, -2.83060104e-01f,
  -2.17506394e-01f, 1.06827453e-01f, 5.71323372e-02f, 9.96409357e-02f, 2.63439380e-02f, -2.51486719e-01f, -4.74293642e-02f, 2.94278890e-01f, 2.03110665e-01f, -9.01087746e-02f,
  -1.81220785e-01f, 5.64529933e-02f, 3.07252944e-01f, 1.97793581e-02f, -2.89065480e-01f, -7.90598243e-02f, -1.84752420e-01f, -9.18282848e-03f, -1.51155040e-01f, -2.04865679e-01f,
  -2.11324200e-01f, -2.10214078e-01f, 7.21697807e-02f, 4.68836352e-02f, 4.52875309e-02f, 3.82989608e-02f, 2.24175844e-02f, 5.07046841e-02f, 7.86684677e-02f, 1.43964086e-02f,
  -3.21719348e-02f, -1.18843801e-01f, 1.63724506e-03f, 1.16673820e-02f, -1.09068587e-01f, -5.37040643e-02f, -3.40042710e-02f, 1.84503213e-01f, 1.41674923e-02f, -1.60673290e-01f,
  -3.42016108e-02f, -1.68944970e-01f, -6.83862716e-02f, 1.23330116e-01f, 6.31939545e-02f, 2.20888302e-01f, -1.26435205e-01f, -1.75155550e-01f, -1.80711783e-02f, -2.69563943e-01f,
  1.22618839e-01f, -6.91578537e-03f, -2.91695017e-02f, 5.15744761e-02f, -2.33137757e-02f, 2.78742835e-02f, 7.02315122e-02f, 6.48454428e-02f, -2.38138903e-02f, 1.05984852e-01f,
  1.89653590e-01f, 9.82302893e-03f, -3.92200276e-02f, -1.78133234e-01f, -7.57643059e-02f, -3.40849310e-02f, 5.72085194e-02f, -9.11805481e-02f, -1.64015532e-01f, 6.59112707e-02f,
  -4.06718701e-02f, 3.35000828e-02f, -1.10226437e-01f, 3.45163681e-02f, 4.62894514e-02f, -7.03563243e-02f, -1.60742447e-01f, 7.08646979e-03f, -2.81630047e-02f, -7.34231621e-02f,
  -4.18764865e-03f, 2.07023159e-01f, -2.99835473e-01f, 2.87752096e-02f, 1.32896584e-02f, 6.76596314e-02f, -6.63980469e-02f, 8.63600969e-02f, 1.34024546e-01f, -2.27200329e-01f,
  -2.50419863e-02f, -5.62330857e-02f, 4.39208038e-02f, 1.51485205e-01f, 8.20140168e-02f, -5.79615310e-03f, 6.34460850e-03f, 3.85500677e-03f, -3.31063122e-02f, 4.91078533e-02f,
  2.47181971e-02f, -3.52989733e-02f, -2.69295666e-02f, 4.47975844e-02f, -1.08521372e-01f, -5.87805361e-02f, -5.16879037e-02f, -1.39389589e-01f, 2.45616660e-02f, -1.56576142e-01f,
  4.03434694e-01f, -5.43554276e-02f, -1.90727875e-01f, 8.83243158e-02f, 1.89083703e-02f, 4.54245694e-02f, -1.95364896e-02f, 7.05381185e-02f, 1.33616060e-01f, 8.69667083e-02f,
  -2.22059973e-02f, 5.17056920e-02f, 1.00577413e-03f, -6.84049949e-02f, -4.04789113e-03f, -2.15392351e-01f, -1.78924814e-01f, -1.03977630e-02f, 3.04734092e-02f, 1.25062615e-01f,
  1.00850465e-03f, -4.12376523e-02f, 1.75519679e-02f, 1.74501222e-02f, -1.40178134e-03f, 1.05178498e-01f, -9.10466835e-02f, -1.67847723e-01f, -6.01336882e-02f, -9.21932012e-02f,
  -2.44657379e-02f, -2.22565811e-02f, 8.04936737e-02f, 2.13795323e-02f, -4.95573767e-02f, -7.52006397e-02f, -1.44056072e-02f, -1.23411879e-01f, -2.54394040e-02f, -4.61609811e-02f,
  -8.09579063e-03f, -1.81070030e-01f, -8.43380690e-02f, -1.36510776e-02f, 2.55798530e-02f, 7.89023787e-02f, -1.53458923e-01f, -1.06375992e-01f, -6.43458739e-02f, -1.33628055e-01f,
  -1.42134085e-01f, -6.60030097e-02f, 2.19776155e-03f, -6.48100972e-02f, -1.15730770e-01f, 2.66615879e-02f, -1.57614231e-01f, -5.18012904e-02f, 2.21901834e-02f, -1.13427132e-01f,
  -5.07058501e-02f, 7.83998594e-02f, 1.42971396e-01f, -7.45427087e-02f, -7.53591210e-02f, -1.32729739e-01f, -1.80119917e-01f, 2.33139750e-02f, 3.27724963e-02f, 3.27607766e-02f,
  -4.14177254e-02f, -1.80053953e-02f, -7.98213258e-02f, 9.40879658e-02f, 8.44576433e-02f, -5.30562587e-02f, 3.06950454e-02f, 3.03785838e-02f, -1.42540960e-02f, 1.77143529e-01f,
  3.54243778e-02f, 2.75838785e-02f, 1.52357325e-01f, 6.95365965e-02f, -1.82245746e-02f, -4.77358550e-02f, 1.65228128e-01f, 7.55343139e-02f, -7.71089345e-02f, 5.09073138e-02f,
  1.53472826e-01f, 1.78791016e-01f, -3.00238188e-02f, -2.73344386e-03f, -4.21432219e-02f, -1.14659667e-01f, 7.43660238e-03f, -5.59978783e-02f, -9.41370502e-02f, 4.73361202e-02f,
  -2.95277629e-02f, -2.74266284e-02f, 3.59045640e-02f, 9.36959535e-02f, 1.42518193e-01f, -7.08788708e-02f, -1.62111089e-01f, 2.83832047e-02f, -6.77098110e-02f, 3.98751423e-02f,
  1.02692544e-02f, 4.85056862e-02f, -2.67781038e-02f, 9.29508433e-02f, -2.28865147e-02f, 3.35313231e-02f, 2.59715170e-02f, 2.72925068e-02f, 6.46892516e-03f, 1.14757314e-01f,
  -3.04370314e-01f, -2.97843307e-01f, -1.05084933e-01f, -3.41417044e-01f, -1.77853659e-01f, -9.19779465e-02f, -1.14470094e-01f, 7.12876990e-02f, -7.65152723e-02f, -2.40598515e-01f,
  -1.22014083e-01f, 5.07122166e-02f, -1.40273541e-01f, 3.39699686e-02f, 2.30437680e-03f, -2.11795166e-01f, -2.15438813e-01f, 1.18116267e-01f, 2.49606848e-01f, 4.34257269e-01f,
  1.33318156e-01f, 2.09785894e-01f, 1.60741121e-01f, 2.98068345e-01f, -1.03208788e-01f, 5.08858263e-02f, 8.45435411e-02f, 2.98632798e-03f, 2.32551303e-02f, -2.78424084e-01f,
  -5.91015965e-02f, -2.77361602e-01f, 8.69704783e-02f, 2.39249989e-01f, 1.56992655e-02f, -1.77831873e-01f, -4.14297767e-02f, -8.77563432e-02f, -1.32657271e-02f, -2.01320186e-01f,
  -9.14634243e-02f, 8.82833004e-02f, -1.22258425e-01f, 1.26267657e-01f, -1.35514969e-02f, 8.36190507e-02f, 4.13463265e-03f, 7.20656365e-02f, -8.15693140e-02f, -1.92268685e-01f,
  -7.47917965e-02f, 4.63695228e-02f, -8.17181841e-02f, -5.05091511e-02f, 1.10595435e-01f, -5.41922115e-02f, 2.05367804e-01f, 1.24161996e-01f, 1.21041663e-01f, -2.75116805e-02f,
  1.22949451e-01f, -6.77364096e-02f, -1.70986086e-01f, -6.34201318e-02f, -7.63301104e-02f, -5.66842034e-02f, 3.17538157e-02f, 1.72250524e-01f, 1.06105611e-01f, -4.27737162e-02f,
  5.55734092e-04f, 3.62227447e-02f, 1.41059205e-01f, 3.33821997e-02f, 1.47100031e-01f, -1.31655142e-01f, -1.47143945e-01f, 2.17452809e-01f, 2.43442575e-03f, 7.93109983e-02f,
  5.13653941e-02f, 9.77308974e-02f, 4.56245057e-02f, 7.80692399e-02f, -1.67844921e-01f, 2.20455844e-02f, -1.06840551e-01f, -2.31584776e-02f, -4.23167050e-02f, -1.02216266e-01f,
  6.06500506e-02f, 1.24342971e-01f, -2.02609167e-01f, 1.50564969e-01f, 1.24279819e-02f, -6.22252701e-03f, -1.10504583e-01f, -4.12313826e-02f, -2.65001915e-02f, -1.66344717e-01f,
  1.40729532e-01f, -1.99055318e-02f, -2.37795785e-02f, -3.36080119e-02f, -6.25457019e-02f, -2.00593192e-02f, -1.91154584e-01f, -5.40960580e-02f, -1.40639216e-01f, -8.82970809e-04f,
  -2.06317097e-01f, -7.89283365e-02f, -3.33149374e-01f, -1.49996042e-01f, -7.92021081e-02f, -9.89829004e-02f, -8.17693993e-02f, 8.77526104e-02f, 3.39183724e-03f, -2.42136002e-01f,
  3.35587442e-01f, -1.06008783e-01f, -1.92983672e-01f, 1.66173577e-01f, -4.42696549e-03f, -1.46753684e-01f, -1.61306560e-01f, 5.25770299e-02f, 1.21973403e-01f, -1.32469580e-01f,
  -1.34308338e-01f, 1.14203326e-01f, 3.55928615e-02f, 5.23590371e-02f, 1.62158594e-01f, -1.48188323e-01f, 3.13104838e-02f, 2.14515120e-01f, 1.32097334e-01f, 6.97185099e-02f,
  -3.84227335e-02f, 7.97457844e-02f, 1.99719891e-01f, 2.28254329e-02f, -3.17279071e-01f, -2.43714936e-02f, -1.16212711e-01f, -2.17227682e-01f, -1.38707191e-01f, -2.37680003e-01f,
  -4.79431897e-01f, -2.30432793e-01f, 1.04006983e-01f, -8.41068476e-03f, 3.87555510e-02f, 1.91406205e-01f, 4.97198757e-03f, 1.37083530e-01f, 6.72070906e-02f, -4.30290475e-02f,
  -2.88121868e-02f, 6.53953031e-02f, -4.80080470e-02f, -1.28098786e-01f, -7.95620829e-02f, 1.15557583e-02f, 6.60030395e-02f, 1.32983238e-01f, 7.06850812e-02f, -1.05331644e-01f,
  -1.07782893e-01f, -4.74641435e-02f, -4.76138927e-02f, -1.15567967e-01f, -8.40719938e-02f, -1.20623410e-03f, -1.65382504e-01f, -1.10796593e-01f, -1.29154533e-01f, -4.04847488e-02f,
  5.96764684e-02f, 1.07766569e-01f, -1.30125150e-01f, 6.33892193e-02f, 5.69790564e-02f, -8.79283901e-03f, -1.12206958e-01f, -4.19075303e-02f, -1.30956426e-01f, 3.46365944e-02f,
  -3.92387770e-02f, 5.53581379e-02f, -1.25749350e-01f, 7.34668598e-02f, -1.66214064e-01f, -1.08296042e-02f, -5.45551814e-02f, 3.65007930e-02f, -2.59384569e-02f, -1.86493546e-02f,
  1.72654223e-02f, 4.18101251e-02f, -5.20543978e-02f, -7.78460056e-02f, 1.00651070e-01f, 8.12693499e-03f, -7.88420662e-02f, -4.97176871e-02f, 8.52912962e-02f, 3.47665772e-02f,
  3.19497683e-03f, 1.71829849e-01f, -1.46689624e-01f, -1.10647716e-02f, -1.65481865e-01f, -1.34535888e-02f, -1.50715664e-01f, 2.90297791e-02f, -1.32149428e-01f, -6.94355592e-02f,
  -1.47518486e-01f, -1.48542255e-01f, -1.16175525e-01f, -1.46662816e-01f, 7.14184716e-02f, 1.68797858e-02f, -6.87615499e-02f, -7.25252670e-04f, -4.49979343e-02f, 3.20700146e-02f,
  -2.76207794e-02f, 7.51090646e-02f, 1.19284146e-01f, 6.36899099e-02f, -9.13508981e-02f, 1.41789436e-01f, 4.38660383e-02f, 1.63194053e-02f, 8.93600471e-03f, 2.36854792e-01f,
  2.63281643e-01f, 3.71930413e-02f, -4.59097400e-02f, 2.06472471e-01f, 4.33639735e-02f, -2.11451814e-01f, -4.29440498e-01f, -1.87291443e-01f, 1.22249842e-01f, 4.87089455e-02f,
  1.99556857e-01f, 1.09113947e-01f, -8.10848922e-02f, -4.26576398e-02f, -3.53793710e-01f, -2.78575748e-01f, -2.02456608e-01f, -1.93321571e-01f, -2.46149108e-01f, 4.43850942e-02f,
  -7.31183402e-03f, -8.05726624e-04f, -3.62274674e-04f, -3.81524675e-02f, 2.15345696e-01f, 5.95460124e-02f, 4.74112220e-02f, 1.39368594e-01f, 1.17710099e-01f, 3.15943003e-01f,
  2.79626220e-01f, 3.35145473e-01f, -1.25995591e-01f, 1.88202225e-02f, 1.59423277e-01f, -1.83321368e-02f, -1.63890556e-01f, 1.12806343e-01f, 8.52183253e-03f, -7.15524983e-03f,
  9.12602991e-02f, 5.08611836e-02f, 6.05796389e-02f, -8.32696166e-03f, -3.88321765e-02f, 2.03533601e-02f, -7.75153413e-02f, -1.24271110e-01f, -1.51511028e-01f, 8.69585946e-02f,
  -1.47219356e-02f, 6.58965409e-02f, -2.62418222e-02f, -5.85924201e-02f, 4.88768145e-03f, -1.59113407e-01f, 6.89500719e-02f, 1.65213361e-01f, -1.18010826e-01f, 7.29575008e-02f,
  -2.79261023e-02f, -7.40034366e-03f, -6.01270683e-02f, 6.25507906e-02f, -4.30017971e-02f, 6.72271103e-02f, 5.71728684e-03f, -7.52117485e-02f, -3.21689271e-03f, -7.02195764e-02f,
  -2.47874670e-03f, 1.68511756e-02f, -4.37111147e-02f, 5.79853207e-02f, -5.59566021e-02f, 3.52706835e-02f, -9.64028537e-02f, -8.16795900e-02f, 3.80797405e-03f, 1.00728758e-01f,
  -7.45427907e-02f, -4.60023209e-02f, 1.48998588e-01f, 7.34396353e-02f, -1.10404007e-01f, -1.92787144e-02f, -2.80630384e-02f, 5.56948073e-02f, -1.32387310e-01f, -2.71442030e-02f,
  -5.21418266e-02f, -2.78372079e-01f, 2.07237765e-01f, -8.40764642e-02f, -3.77977872e-03f, -8.08496848e-02f, -1.92288272e-02f, -1.27646029e-01f, 6.84905658e-03f, 6.45195395e-02f,
  -3.33731286e-02f, -6.30927682e-02f, 1.68381562e-03f, -9.21498016e-02f, -1.23186829e-02f, 8.22073072e-02f, -1.52179271e-01f, -6.87818900e-02f, -1.60410658e-01f, 8.50651860e-02f,
  -2.13881165e-01f, -1.85866177e-01f, -9.75102633e-02f, -1.83432102e-01f, -6.63250759e-02f, -1.35022402e-01f, -6.44889176e-02f, -3.32182571e-02f, -2.21740529e-01f, -2.52159178e-01f,
  -2.78458029e-01f, 3.89812350e-01f, -1.88169256e-01f, -6.63391724e-02f, -5.63750379e-02f, -1.21723346e-01f, 2.02511311e-01f, 1.58546925e-01f, 1.47309482e-01f, 3.25899094e-01f,
  2.76683509e-01f, 9.80364159e-03f, -7.31573105e-02f, -1.54794753e-01f, -8.58787820e-02f, 1.80624023e-01f, -1.40195861e-01f, -4.42640334e-01f, -4.46356326e-01f, -9.98831838e-02f,
  8.83755386e-02f, -5.73754357e-03f, -2.79382378e-01f, -7.11114481e-02f, -2.99799722e-02f, -2.26741031e-01f, -1.12944199e-02f, -2.55917192e-01f, -9.75785311e-03f, -6.93874806e-02f,
  -3.32996249e-01f, -3.08447659e-01f, -9.58204046e-02f, 2.41969340e-02f, -8.40567946e-02f, 6.29534945e-02f, 4.41321544e-02f, -1.37768388e-01f, 1.76267281e-01f, 1.79799542e-01f,
  3.79314423e-02f, 2.38650460e-02f, -5.97305782e-02f, -5.00344299e-02f, -5.12092821e-02f, 8.63834936e-03f, 1.07126705e-01f, -5.80807924e-02f, -3.89276221e-02f, 7.99436718e-02f,
  4.66081016e-02f, -1.52315900e-01f, -1.18242845e-01f, 1.89552139e-02f, -1.24136448e-01f, -1.06754489e-01f, -3.28143947e-02f, -1.11133933e-01f, -2.03291729e-01f, 2.35932082e-01f,
  -2.90059391e-02f, -1.80286393e-02f, -7.12022604e-03f, 1.09789267e-01f, 1.49166331e-01f, -3.68926339e-02f, -6.82065124e-03f, -1.36781007e-01f, -7.61995539e-02f, 8.87788385e-02f,
  5.08136749e-02f, 1.54930539e-02f, 5.91575578e-02f, -8.34380090e-03f, -6.85953163e-03f, -8.11968446e-02f, -3.92098092e-02f, 5.16230799e-02f, -3.28237526e-02f, -1.14760986e-02f,
  -5.84857166e-02f, -5.15624359e-02f, -8.34104568e-02f, -5.68738729e-02f, -6.97653070e-02f, -4.32477221e-02f, 5.96466698e-02f, 6.84773177e-02f, 5.93384393e-02f, 4.18914072e-02f,
  1.04188316e-01f, -2.15458393e-01f, 7.65950009e-02f, 3.69290472e-03f, -8.10278878e-02f, 5.47145978e-02f, -4.18495899e-03f, -9.45801213e-02f, 3.17509621e-02f, 5.18362597e-03f,
  3.32620591e-02f, 5.86322695e-03f, 1.24830179e-01f, 1.38051614e-01f, 1.00164577e-01f, -3.43809724e-02f, 2.18229517e-01f, -4.39276583e-02f, 7.29876757e-02f, 1.22247331e-01f,
  2.82006145e-01f, 1.86493844e-01f, 6.46219701e-02f, 3.54435928e-02f, 2.67034769e-03f, -1.26776636e-01f, 1.09547265e-01f, 2.41552480e-03f, -1.35561958e-01f, 4.40137178e-01f,
  -1.12754583e-01f, -3.36982429e-01f, -2.20035404e-01f, -1.14202149e-01f, -2.44601846e-01f, -1.18668891e-01f, -2.02382937e-01f, -1.09903365e-01f, 8.32183100e-03f, -2.96480149e-01f,
  -4.73097265e-02f, 1.46082729e-01f, -7.05662593e-02f, -7.55495578e-02f, -1.88055426e-01f, -4.44786310e-01f, -2.83851206e-01f, -1.09019324e-01f, 4.97571602e-02f, -3.52866575e-02f,
  -1.39799461e-01f, -1.30805224e-01f, 8.85012001e-02f, -5.49440570e-02f, -5.99961318e-02f, 4.37003225e-02f, -2.07199022e-01f, -2.35412717e-02f, 2.89205518e-02f, -1.24412663e-01f,
  -1.07399449e-01f, 5.85394166e-03f, 6.13511056e-02f, 7.05812424e-02f, -5.47681898e-02f, 4.01912741e-02f, -1.00003898e-01f, -1.71809271e-01f, 4.15104404e-02f, -2.69972663e-02f,
  -3.32165547e-02f, -1.02546617e-01f, -2.44596656e-02f, 5.06705679e-02f, -1.06177732e-01f, -8.27104226e-02f, -7.07400292e-02f, -1.34891514e-02f, 1.76363904e-02f, -9.14953277e-02f,
  -8.24888945e-02f, 1.55989472e-02f, -7.63931125e-02f, 5.19605502e-02f, 1.57311782e-01f, -4.77288896e-03f, 5.13323285e-02f, 1.19420201e-01f, 1.64883465e-01f, -5.88341579e-02f,
  -1.21620305e-01f, -1.58292986e-02f, -1.01413399e-01f, 9.31190886e-03f, -9.40049216e-02f, 1.87416766e-02f, -1.68420188e-02f, -4.68516089e-02f, 1.05868913e-02f, -1.06952880e-02f,
  1.30305905e-02f, -3.93885933e-02f, -1.36287376e-01f, -1.58506289e-01f, -7.70489126e-02f, -1.59271657e-01f, -1.04533888e-01f, -4.17475142e-02f, -3.14227231e-02f, -6.39284588e-03f,
  3.76594551e-02f, -4.67613228e-02f, 2.73711625e-02f, -1.65200606e-03f, -8.34960043e-02f, -1.11761875e-01f, 3.01546399e-02f, -1.79767143e-02f, -1.29627690e-01f, 4.72828466e-03f,
  -3.08642626e-01f, 3.36196534e-02f, -1.79078624e-01f, -1.17894627e-01f, 9.39301774e-03f, -4.70391065e-02f, 1.64865796e-02f, 1.64445844e-02f, -1.31380912e-02f, -1.83710515e-01f,
  -4.51947842e-03f, -1.33896992e-01f, -1.09528318e-01f, -2.35277340e-02f, -9.82447714e-03f, 1.98981222e-02f, -2.63370872e-01f, -9.01497826e-02f, -1.54878628e-02f, -5.59023395e-03f,
  -1.24154417e-02f, -1.32061869e-01f, -1.29383042e-01f, -3.99301201e-02f, -1.88215859e-02f, -7.80906621e-03f, -7.88254216e-02f, 2.85225492e-02f, 9.50862654e-03f, -2.27669075e-01f,
  4.17532444e-01f, -3.08847278e-01f, -3.92095931e-02f, 1.45114973e-01f, -3.54243000e-03f, 9.72647667e-02f, -2.08163396e-01f, -1.22226246e-01f, 1.04183428e-01f, -7.32253417e-02f,
  1.02720588e-01f, 1.98604316e-01f, 3.11553687e-01f, 1.51472926e-01f, 2.12644711e-01f, -1.96576118e-01f, -2.00832207e-02f, 1.86043382e-01f, 2.58654922e-01f, -3.29374266e-03f,
  -1.47751905e-02f, -1.79287717e-01f, -1.41047584e-02f, -7.32029602e-02f, -1.54799014e-01f, 1.65526979e-02f, -4.78379987e-02f, -9.63211060e-02f, -8.95225778e-02f, -1.67998388e-01f,
  6.68921471e-02f, 1.77897394e-01f, 3.24464329e-02f, 2.71101594e-02f, -2.91735698e-02f, -2.24386528e-02f, 2.78647263e-02f, -1.45455569e-01f, -1.83705077e-01f, -1.74621284e-01f,
  -8.73774141e-02f, 2.72109415e-02f, 9.11104456e-02f, -4.59007248e-02f, -1.86564028e-01f, -3.21989432e-02f, -1.35989115e-01f, 1.10495612e-01f, 8.15943405e-02f, -3.89461443e-02f,
  -1.03122361e-01f, 1.61186252e-02f, -3.05636656e-02f, -2.09200736e-02f, 1.17174484e-01f, 6.12604432e-02f, 5.98581061e-02f, 5.90615459e-02f, 1.41289681e-01f, 9.48169082e-02f,
  4.38002963e-03f, 9.57412869e-02f, 1.47176310e-01f, 1.44638032e-01f, 9.95433852e-02f, 6.06185757e-03f, 7.26666152e-02f, -1.84147246e-02f, 4.46211882e-02f, -5.66335469e-02f,
  -6.88230246e-02f, 1.03219561e-01f, 1.34328559e-01f, 3.53617407e-02f, 1.03726298e-01f, 6.09408729e-02f, 3.39494757e-02f, 5.67487776e-02f, 9.42462087e-02f, 6.83166683e-02f,
  5.75651340e-02f, -2.85309833e-02f, -4.07247059e-02f, -1.37298331e-01f, -6.42720610e-03f, -4.43212986e-02f, -4.41189334e-02f, -3.63296792e-02f, -4.69542146e-02f, -1.08287215e-01f,
  -1.05712980e-01f, 3.82418305e-01f, 1.38645306e-01f, 8.59742314e-02f, -4.36898060e-02f, -9.15681496e-02f, 1.79506138e-01f, 6.31822320e-03f, -6.07885048e-02f, -1.44379824e-01f,
  -4.43836041e-02f, 9.62467045e-02f, 2.90982984e-02f, -3.10241170e-02f, -7.12069273e-02f, 1.88354068e-02f, 8.29940364e-02f, 1.36353299e-01f, 2.36881077e-02f, -1.19859822e-01f,
  -1.38682380e-01f, 6.81512132e-02f, 1.54955253e-01f, 1.76313147e-01f, 8.83883983e-02f, 2.01660305e-01f, 3.11379340e-02f, -9.71541330e-02f, 1.29155457e-01f, -1.22564390e-01f,
  4.90448564e-01f, -8.84326771e-02f, -3.06176007e-01f, 7.67333284e-02f, -1.93254411e-01f, -2.01483257e-02f, -1.03410058e-01f, 1.13568613e-02f, 2.12720986e-02f, -1.64308786e-01f,
  -1.78491604e-02f, 2.99968719e-01f, 2.56414205e-01f, 1.06915146e-01f, 2.47343794e-01f, -9.40209031e-02f, -1.32618263e-01f, 6.85833991e-02f, 2.51482666e-01f, -4.70223511e-03f,
  -6.85669184e-02f, -7.89223388e-02f, 7.50554428e-02f, 2.42647296e-03f, -2.04130381e-01f, -6.78399811e-03f, -3.31770509e-01f, -5.34571931e-02f, -4.29770499e-02f, -3.48895401e-01f,
  -6.02248162e-02f, -3.93780917e-02f, -9.57290679e-02f, 1.86475785e-03f, -2.01085463e-01f, 1.28692269e-01f, -1.63669717e-02f, -5.04028425e-02f, 5.07519655e-02f, 4.59127873e-02f,
  -1.54383168e-01f, -1.09756343e-01f, -2.18197107e-04f, -1.22409225e-01f, -1.48881316e-01f, 3.30073573e-02f, -7.30263814e-02f, -2.29904074e-02f, -2.65776981e-02f, -6.11715615e-02f,
  -1.03632949e-01f, 1.03662815e-02f, -1.47669479e-01f, -5.67805693e-02f, 4.88480702e-02f, 4.68722060e-02f, -8.62681270e-02f, -1.32373929e-01f, -8.74818936e-02f, -1.48038819e-01f,
  8.84173140e-02f, -1.11896493e-01f, 2.84967739e-02f, -6.21670783e-02f, 5.66181820e-03f, -2.37856992e-02f, 6.17483146e-02f, -4.77597825e-02f, 3.52017023e-02f, -5.75303510e-02f,
  -3.35011072e-02f, -5.07918112e-02f, 5.38307801e-02f, -7.77149349e-02f, -5.79488352e-02f, -2.96647977e-02f, -9.42916423e-03f, 3.93549353e-02f, -1.13249168e-01f, 3.82670313e-02f,
  6.34243786e-02f, 1.31142139e-02f, -2.68991515e-02f, 8.01260695e-02f, -3.88078056e-02f, 1.63797978e-02f, -2.40138005e-02f, -3.83014381e-02f, -7.54495058e-03f, -3.46572734e-02f,
  1.42815813e-01f, 1.38784468e-01f, 3.06859612e-02f, 4.59183753e-02f, -1.06467143e-01f, 3.69931310e-02f, 1.39630109e-01f, 1.56673440e-03f, 2.98199449e-02f, -8.67124368e-03f,
  -3.39072049e-02f, 1.59566868e-02f, 6.21455796e-02f, -4.97757271e-02f, -3.86859849e-02f, 3.67014408e-02f, 2.35185660e-02f, -3.84740196e-02f, -6.76624477e-02f, 6.97053820e-02f,
  3.47750522e-02f, -4.66214567e-02f, 1.10967793e-01f, 4.97494154e-02f, -3.16776522e-03f, 1.90895274e-01f, 9.30491183e-03f, 4.96935844e-02f, 1.45158052e-01f, 1.11359119e-01f,
  2.70901293e-01f, 1.20640196e-01f, -3.04144174e-01f, 1.84715867e-01f, -3.27372342e-01f, -3.56100261e-01f, -3.36962581e-01f, -1.67580992e-01f, 1.26854420e-01f, -1.24847598e-01f,
  -7.52293468e-02f, -1.32443253e-02f, 9.51416567e-02f, -5.65000214e-02f, -1.10353075e-01f, -3.20290178e-01f, -3.19629103e-01f, -1.17780887e-01f, -1.56156048e-01f, -1.28118768e-01f,
  4.48714644e-02f, 1.24327652e-01f, 1.08291447e-01f, 1.15027525e-01f, -2.12846845e-02f, 1.04010046e-01f, 4.99819231e-04f, 1.12481844e-02f, -1.37754455e-01f, -1.50419354e-01f,
  6.67414963e-02f, -7.77229890e-02f, -2.71922588e-01f, -1.08146437e-01f, -2.66183149e-02f, -2.03931015e-02f, -3.54627036e-02f, -2.18741689e-02f, 1.27415270e-01f, -9.74408463e-02f,
  1.89290196e-02f, -5.94568960e-02f, 1.04609355e-01f, -1.37854561e-01f, -1.41154453e-01f, -7.23349005e-02f, -1.21415164e-02f, -1.01581976e-01f, -8.49910975e-02f, -2.63885260e-02f,
  1.91264618e-02f, -1.71666324e-01f, -1.14587171e-03f, -9.41148028e-02f, 3.09459306e-03f, 7.22405463e-02f, -9.81355160e-02f, -6.68603778e-02f, -9.57783163e-02f, 1.00522883e-01f,
  -3.75676081e-02f, 1.21381814e-02f, -7.62675405e-02f, 2.33826637e-02f, -1.78069118e-02f, 8.45126249e-03f, 1.06911078e-01f, -2.31837179e-03f, -2.20293039e-03f, 5.96898496e-02f,
  -1.27260149e-01f, 2.61198846e-03f, -2.09569503e-02f, 1.31194256e-02f, -1.42728062e-02f, -6.68412745e-02f, 7.33685121e-02f, -5.57990093e-03f, -1.03764914e-01f, 1.59449261e-02f,
  -9.61679965e-02f, 4.31065522e-02f, 8.56520666e-04f, 1.24213070e-01f, -1.19779207e-01f, -8.42555836e-02f, -1.49941565e-02f, -4.90170941e-02f, 1.51394326e-02f, -5.53035364e-02f,
  4.56804752e-01f, -1.70965120e-01f, 9.94537324e-02f, -2.35593077e-02f, 1.13460563e-01f, -6.83284774e-02f, 1.18417405e-02f, -3.71573754e-02f, -1.19569227e-02f, 9.96927097e-02f,
  -5.72129712e-02f, 1.89630195e-01f, 8.65507647e-02f, -4.02173102e-02f, -7.83203989e-02f, -7.34853446e-02f, -1.04393348e-01f, -8.86852294e-02f, -1.32796034e-01f, 1.17262155e-02f,
  -1.83512401e-02f, 2.33527250e-03f, 1.75414026e-01f, 1.44241035e-01f, 7.35084862e-02f, 1.23517059e-01f, 1.98893085e-01f, 1.26797765e-01f, 6.28621951e-02f, 2.72438020e-01f,
  -4.23618823e-01f, 1.68661371e-01f, 1.26629546e-01f, -1.43630058e-01f, 8.66562948e-02f, 7.47676343e-02f, 1.64389238e-01f, -1.44925669e-01f, -1.58311009e-01f, 7.99123719e-02f,
  -1.19958937e-01f, -1.19793192e-01f, 7.16943434e-03f, 9.70670432e-02f, -4.05712985e-02f, 3.28216851e-01f, 3.86889368e-01f, 9.83750746e-02f, -3.16449672e-01f, -3.32618564e-01f,
  -3.96814793e-02f, -5.37775569e-02f, -6.18079156e-02f, -1.45403817e-01f, 3.76812834e-03f, -7.48910150e-03f, 1.36420265e-01f, 6.35867789e-02f, 1.44991294e-01f, 2.75580943e-01f,
  -1.31570995e-01f, -2.40671694e-01f, -3.34948637e-02f, 9.78293456e-03f, -1.04466230e-01f, 6.64575817e-03f, -7.31300414e-02f, 6.46299333e-04f, -9.08735022e-02f, -6.52746707e-02f,
  1.32416800e-01f, 4.23326306e-02f, -1.29815519e-01f, -1.01240247e-01f, -1.40025899e-01f, -1.19881980e-01f, -8.04081336e-02f, -1.60238724e-02f, -4.46094498e-02f, -2.07336381e-01f,
  2.39511162e-01f, -9.98262465e-02f, -1.84285611e-01f, 1.68056898e-02f, -3.16409953e-02f, -9.28260311e-02f, -1.39034644e-01f, -2.01633587e-01f, -8.40969197e-03f, -1.80695310e-01f,
  1.80897620e-02f, 7.52316788e-02f, 8.40669647e-02f, 3.75932567e-02f, -5.69324307e-02f, 2.82534845e-02f, 7.23728389e-02f, -3.94992679e-02f, -3.84303462e-03f, -3.38116731e-03f,
  5.51427342e-02f, -9.94881094e-02f, -9.35279652e-02f, 1.43192440e-01f, -8.23735520e-02f, -9.09200609e-02f, -1.15277678e-01f, -1.53344393e-01f, 5.90730123e-02f, 1.25239626e-01f,
  3.11630475e-03f, 1.34444237e-01f, -4.01190227e-05f, 3.99354962e-04f, -2.66955607e-02f, 1.48381591e-01f, -8.27487856e-02f, -1.42030016e-01f, 9.55525339e-02f, -1.12698548e-01f,
  -2.14601040e-01f, 2.25854293e-01f, -1.13937542e-01f, -1.32151216e-01f, 3.25258151e-02f, -4.07403670e-02f, 1.73245948e-02f, -9.66923498e-03f, 7.94902146e-02f, -8.25861320e-02f,
  -1.53092042e-01f, 1.23176267e-02f, -5.90856969e-02f, 6.59181997e-02f, -1.41510934e-01f, 2.77609024e-02f, 1.21674165e-01f, 1.44898981e-01f, -6.94367141e-02f, -1.44481406e-01f,
  -4.75172652e-03f, -1.10797800e-01f, -2.02486053e-01f, 6.04315996e-02f, 6.38471097e-02f, -4.32419553e-02f, -1.07843250e-01f, -2.10637242e-01f, -3.52092609e-02f, -1.24867857e-01f,
  1.48308128e-01f, 2.06300750e-01f, -6.54858425e-02f, 1.85165137e-01f, 1.73956648e-01f, -1.21568345e-01f, -2.68155038e-01f, -3.35593641e-01f, 1.30469069e-01f, 1.06223211e-01f,
  2.62212735e-02f, -4.81425636e-02f, 9.45146680e-02f, -5.68656139e-02f, -3.82486224e-01f, -2.83134058e-02f, 1.76332638e-01f, -1.40392736e-01f, -3.18306893e-01f, -2.62274057e-01f,
  8.41834545e-02f, -1.56791192e-02f, -1.96265429e-01f, -1.13871925e-01f, 2.43401662e-01f, 3.33517343e-02f, 1.63486108e-01f, 1.37059987e-01f, 7.46814534e-02f, 2.29915395e-01f,
  2.12385088e-01f, -2.69450322e-02f, -2.68108964e-01f, -1.41207799e-01f, 1.18133366e-01f, -2.08857842e-02f, -1.37761474e-01f, 1.21534400e-01f, 8.18770658e-03f, 5.95961213e-02f,
  1.24528952e-01f, -8.29260424e-02f, 8.60374123e-02f, -2.71942150e-02f, -1.32977366e-01f, -9.92301702e-02f, -9.52394754e-02f, -2.95097113e-01f, -2.10722014e-01f, 2.27250978e-02f,
  1.68438092e-01f, 7.38536194e-02f, -8.61522481e-02f, -1.05463207e-01f, -1.72079504e-01f, 2.00346708e-02f, -6.77163675e-02f, -3.89853567e-02f, -3.28949600e-01f, 1.30643427e-01f,
  -4.13092971e-02f, 6.97622728e-03f, -3.13321501e-02f, 9.34092235e-03f, -3.45335044e-02f, 9.96665210e-02f, 1.40846506e-01f, -8.16781148e-02f, -7.93147609e-02f, 2.07530782e-02f,
  1.13225870e-01f, 4.20378484e-02f, -1.37903802e-02f, 9.71051008e-02f, 5.50371483e-02f, 2.98538394e-02f, -6.38071960e-03f, -6.31397367e-02f, -9.11417976e-02f, -4.28878218e-02f,
  6.40946701e-02f, -6.15401007e-02f, 1.68358684e-01f, -9.06257704e-02f, -4.66068648e-02f, 8.52128565e-02f, -1.01796295e-02f, -4.95342501e-02f, 9.03511345e-02f, -9.28089023e-03f,
  -3.51828486e-02f, -2.16094673e-01f, 1.50626093e-01f, -9.05126408e-02f, 5.63901216e-02f, -7.45584890e-02f, 2.96828207e-02f, 1.61942225e-02f, 6.69101253e-02f, -4.37971577e-02f,
  -2.23248869e-01f, -3.60027291e-02f, 1.72771066e-01f, -4.52090427e-02f, -1.27182364e-01f, -8.58188327e-03f, 1.60793543e-01f, -1.62366889e-02f, -1.06234990e-01f, 5.55437850e-03f,
  -3.12502086e-02f, -2.34073579e-01f, -7.83538148e-02f, -8.95199031e-02f, 6.22171313e-02f, -2.68022227e-03f, -2.20832285e-02f, -4.30045463e-02f, -2.26778418e-01f, -5.96922860e-02f,
  3.83620530e-01f, -1.58324093e-01f, 2.01582357e-01f, 9.10779908e-02f, 1.21050261e-01f, 2.59096503e-01f, 2.53454149e-01f, 7.77297989e-02f, -4.85244766e-03f, 6.56594187e-02f,
  3.37682441e-02f, -5.97320125e-02f, -1.27406046e-01f, -1.66905433e-01f, -1.36914924e-01f, -4.59566563e-02f, 9.41099413e-03f, 2.23535988e-02f, 5.87826781e-02f, 6.07878864e-02f,
  1.91571563e-02f, 1.05784677e-01f, 1.08045988e-01f, 4.10028175e-02f, -8.69257301e-02f, -2.76103467e-02f, 2.27137357e-02f, -1.09869756e-01f, -9.69553143e-02f, -1.38118684e-01f,
  -2.11670861e-01f, 1.64450645e-01f, 5.37312403e-02f, -7.37539679e-02f, 1.88310556e-02f, 5.90522997e-02f, 2.31349878e-02f, -1.10363655e-01f, -4.98886071e-02f, -4.95465361e-02f,
  1.20436272e-03f, -1.19570166e-01f, -1.46107584e-01f, -1.44514013e-02f, 3.58726531e-02f, -1.43648818e-01f, -2.60751583e-02f, -9.99609195e-03f, -9.67993438e-02f, -1.22494534e-01f,
  -1.80001497e-01f, -1.30989067e-02f, -1.17873251e-02f, 1.57367885e-02f, -1.16772138e-01f, -7.47415647e-02f, -1.15838505e-01f, 4.65837568e-02f, -3.51807103e-02f, 4.46087420e-02f,
  1.10260602e-02f, -4.68354905e-03f, 9.51555818e-02f, 1.78382099e-02f, 1.59572158e-02f, -1.55905597e-02f, -4.94856909e-02f, 9.12404582e-02f, 5.11203595e-02f, -3.28564569e-02f,
  -9.55236331e-02f, 1.09633766e-01f, 3.24752294e-02f, 6.25480339e-02f, 4.55527864e-02f, -5.19247958e-03f, -8.27596039e-02f, -9.66258049e-02f, 4.35121991e-02f, 1.16785102e-01f,
  4.28731889e-02f, -9.74179730e-02f, -5.21413749e-03f, -4.54869568e-02f, 1.74778495e-02f, 6.21845163e-02f, 6.76554888e-02f, -2.49373987e-02f, -2.15454381e-02f, 2.78558526e-02f,
  -7.39536062e-02f, 1.57219827e-01f, -2.77701654e-02f, -2.05754116e-01f, 2.90506259e-02f, -9.04738754e-02f, -9.89074856e-02f, -7.41293132e-02f, -1.34649007e-02f, -1.51990339e-01f,
  -1.31340638e-01f, -1.21586524e-01f, -7.08747357e-02f, -1.42991364e-01f, 1.65455067e-03f, -9.21145454e-02f, -1.41758814e-01f, -1.42064273e-01f, 4.15206477e-02f, -8.07716250e-02f,
  -1.11811496e-01f, 1.33766726e-01f, 6.11650236e-02f, 1.02536887e-01f, -7.10584596e-02f, 1.17772393e-01f, 3.09463087e-02f, -2.94202827e-02f, 6.71175271e-02f, 1.37010589e-01f,
  6.94522560e-02f, -2.28024259e-01f, -1.50312603e-01f, 1.38987124e-01f, 1.39939591e-01f, -1.19689159e-01f, -2.24053666e-01f, -8.39238316e-02f, -2.26214845e-02f, -7.14474246e-02f,
  1.64606571e-01f, 3.20500791e-01f, -1.21331252e-01f, -1.64138883e-01f, -3.20565969e-01f, -4.57637995e-01f, -4.08079684e-01f, -2.61087239e-01f, 6.88722655e-02f, 3.12829375e-01f,
  2.49765649e-01f, 5.77662289e-02f, -7.35329390e-02f, -2.57693212e-02f, 9.41386893e-02f, 8.61537755e-02f, -7.31740845e-03f, 1.24830730e-01f, -6.78241551e-02f, 5.61302714e-02f,
  2.04035770e-02f, 5.20609925e-03f, 9.57605466e-02f, 1.84742987e-01f, 1.25401676e-01f, -5.94396666e-02f, -1.31130546e-01f, -1.09410681e-01f, 6.12206012e-02f, -1.52802728e-02f,
  1.48277104e-01f, 4.40463461e-02f, -7.47056976e-02f, 1.99587822e-01f, -5.22703975e-02f, 5.81009984e-02f, -3.91676314e-02f, -1.34442866e-01f, -1.26313657e-01f, 2.27290373e-02f,
  8.73761773e-02f, 2.62833923e-01f, -2.51248609e-02f, -1.10456809e-01f, -1.91739738e-01f, -1.65000930e-01f, 2.15001963e-03f, 1.39202699e-01f, -2.20078975e-01f, -1.88419044e-01f,
  1.33233532e-01f, 2.15943810e-02f, 9.58966382e-04f, -5.00128604e-03f, 4.36250716e-02f, 3.00179888e-02f, 2.18556840e-02f, 4.82879020e-02f, 5.60014322e-02f, 3.65571901e-02f,
  -1.35345208e-02f, -7.48586282e-02f, -1.26024373e-02f, -2.16122530e-02f, -6.45458028e-02f, 7.07204780e-03f, -8.15136582e-02f, 1.05300592e-02f, -5.12770154e-02f, 3.28297764e-02f,
  8.51318836e-02f, -6.06343187e-02f, 5.33703603e-02f, 1.74368322e-01f, -3.52165960e-02f, -1.68632314e-01f, -5.67015745e-02f, 2.90692803e-02f, -1.09813474e-01f, -5.61181791e-02f,
  5.90392016e-02f, -1.36036292e-01f, -3.60007435e-02f, 3.98039110e-02f, 1.47345737e-01f, 3.09155099e-02f, 4.63154763e-02f, -9.74880904e-02f, -6.32812530e-02f, -1.14849113e-01f,
  2.75696293e-02f, -5.89387864e-03f, -7.93812722e-02f, 2.14809068e-02f, 3.07476893e-02f, 4.89253663e-02f, -2.76049376e-01f, -1.85211413e-02f, -6.54660687e-02f, 1.59390755e-02f,
  -1.81242600e-01f, -7.22901449e-02f, -1.57630637e-01f, -2.61096746e-01f, -1.81203187e-01f, -1.81073487e-01f, -1.54078126e-01f, 7.65916985e-03f, -2.09319428e-01f, -4.10085440e-01f,
  6.78071558e-01f, 2.92428672e-01f, 3.13010395e-01f, 1.21887244e-01f, 7.17496946e-02f, 5.90106882e-02f, 2.53436983e-01f, 1.87795863e-01f, -1.11365512e-01f, 1.09182596e-01f,
  1.13276273e-01f, -1.53241262e-01f, -1.34797484e-01f, 4.64882404e-02f, 1.54885262e-01f, 1.51203483e-01f, -1.07325405e-01f, 5.90685010e-02f, 1.82917252e-01f, 8.31294358e-02f,
  -4.58188057e-02f, 9.35015306e-02f, 2.12288365e-01f, -1.76421627e-02f, -6.74788058e-02f, -1.19129635e-01f, 1.35047724e-02f, 2.09358074e-02f, 1.00972854e-01f, -1.62946522e-01f,
  -2.15058178e-01f, 2.16729313e-01f, -1.81036070e-01f, -1.45139232e-01f, 1.25934765e-01f, -1.18130557e-02f, -3.71019766e-02f, 2.25313958e-02f, -1.44018997e-02f, -1.00263096e-01f,
  -8.21491331e-02f, 1.05117168e-02f, 9.09632593e-02f, 3.46490033e-02f, 3.86517979e-02f, 3.71542014e-02f, 1.31390989e-01f, 9.10979323e-03f, 8.92746672e-02f, 3.33278142e-02f,
  -3.82152088e-02f, 9.34190154e-02f, 3.97948623e-02f, 5.57547845e-02f, 1.49498492e-01f, 4.65559773e-02f, 6.81189671e-02f, 4.64720242e-02f, 1.87009439e-01f, 1.55212820e-01f,
  -1.50866538e-01f, 2.25965470e-01f, 1.90105498e-01f, 8.91900361e-02f, 6.36068210e-02f, 7.91118219e-02f, 3.99800902e-03f, -2.69730818e-02f, 7.14217871e-02f, 1.17553219e-01f,
  -7.66562670e-02f, 1.47786485e-02f, 3.95260006e-02f, -5.42357787e-02f, -1.14825768e-02f, 1.39293242e-02f, 4.55049984e-02f, -7.87413269e-02f, 4.40867245e-02f, -1.53443694e-01f,
  1.11553118e-01f, 3.35327201e-02f, -1.15076713e-01f, 8.75444785e-02f, -1.19283706e-01f, -1.07029742e-02f, -9.16671008e-03f, -5.71129918e-02f, 3.13578956e-02f, -5.85878342e-02f,
  -5.66327751e-01f, -1.19164646e-01f, -5.76236397e-02f, 2.84630116e-02f, -3.36506851e-02f, 6.31805696e-03f, 7.54078338e-03f, -1.37879178e-01f, -1.34902254e-01f, -2.62962401e-01f,
  5.50832273e-03f, 3.95881478e-03f, 9.01757851e-02f, 7.30142444e-02f, -7.05978423e-02f, -1.50728926e-01f, -1.05370268e-01f, -1.18806094e-01f, -1.61120415e-01f, -8.71615484e-02f,
  -5.92479482e-02f, -3.64340693e-02f, -5.19812964e-02f, -4.91462573e-02f, -7.79716820e-02f, -2.62898356e-01f, -8.38934258e-02f, -8.24141502e-02f, 3.65451761e-02f, -3.42329368e-02f,
  5.25504291e-01f, 1.51422411e-01f, 1.18097231e-01f, 3.06064814e-01f, -4.81837615e-02f, -2.99270332e-01f, -4.22664255e-01f, -1.13164783e-01f, 7.49576315e-02f, 7.56369308e-02f,
  5.34989946e-02f, 1.13462709e-01f, -4.00391966e-02f, -2.02930942e-02f, -2.87361085e-01f, -8.24747533e-02f, -2.24973299e-02f, -7.68287703e-02f, -2.90525436e-01f, -1.41067833e-01f,
  -8.37266594e-02f, 4.31354754e-02f, -2.10813005e-02f, -2.73503717e-02f, 1.09697610e-01f, 1.40484571e-02f, 7.03615770e-02f, 7.44544342e-02f, -8.35009962e-02f, 4.17712748e-01f,
  4.77350533e-01f, 3.02812636e-01f, -3.11276644e-01f, 2.35890616e-02f, 9.28025693e-02f, 1.15425356e-01f, 7.75386691e-02f, 1.17671520e-01f, 1.34656787e-01f, 1.61546171e-01f,
  4.51349989e-02f, -5.31053208e-02f, 1.09073251e-01f, -6.07112306e-04f, 4.13310379e-02f, 2.42760237e-02f, -6.64108917e-02f, 5.05564883e-02f, 3.04400604e-02f, 2.21541315e-01f,
  3.97158004e-02f, -2.44360082e-02f, 9.07963887e-02f, -1.44653276e-01f, -1.04875267e-01f, -4.78658713e-02f, -1.87863037e-01f, -7.12582050e-03f, -2.56659240e-01f, 1.79961234e-01f,
  -8.55016410e-02f, 5.79319634e-02f, 4.82925726e-03f, -5.21094650e-02f, 5.25641851e-02f, 6.24802895e-02f, 1.01980053e-01f, -5.03981523e-02f, 1.52525604e-02f, 5.68528064e-02f,
  7.22800265e-04f, 9.18346047e-02f, 9.16688293e-02f, 4.29822542e-02f, -1.33956313e-01f, 6.40193757e-04f, -1.41732516e-02f, 1.01776393e-02f, 2.58343518e-02f, -1.82405692e-02f,
  -2.33686417e-02f, 5.05912974e-02f, 8.65968317e-02f, 4.84455377e-03f, -8.51677358e-03f, -4.61579068e-03f, 1.16358541e-01f, -1.82469022e-02f, -2.09499542e-02f, 8.01675022e-03f,
  2.41760220e-02f, -4.14967477e-01f, 2.07263976e-01f, -7.22010210e-02f, 7.99228773e-02f, -1.03974931e-01f, 6.46512955e-02f, -1.00917816e-01f, 3.35278772e-02f, -9.09311473e-02f,
  -5.18070087e-02f, 3.37400287e-02f, 1.05732210e-01f, 5.22669330e-02f, -1.35793552e-01f, -1.04812272e-01f, -1.10168479e-01f, 1.48313716e-02f, -4.75864261e-02f, 6.54600114e-02f,
  -1.39834404e-01f, -3.17310899e-01f, -6.11905009e-03f, -1.96325317e-01f, -4.28444855e-02f, -2.06287593e-01f, -1.48722589e-01f, -1.27054259e-01f, -3.65241438e-01f, -1.32089615e-01f,
  3.65379989e-01f, -1.11885652e-01f, -3.50131750e-01f, 1.15988195e-01f, -1.96312606e-01f, -1.95429295e-01f, -8.91182795e-02f, -2.25598123e-02f, 2.12094977e-01f, -1.37656257e-01f,
  -1.39119342e-01f, -4.40856107e-02f, -3.90109867e-02f, 1.22688652e-04f, 5.95611371e-02f, -8.93098339e-02f, -8.39660168e-02f, 1.23580612e-01f, 1.33459434e-01f, -2.43289061e-02f,
  8.39205384e-02f, 2.26152375e-01f, 2.83750713e-01f, 1.05197385e-01f, -1.50158212e-01f, -1.90323852e-02f, -8.69360715e-02f, -1.30092993e-01f, -1.85255662e-01f, -3.68728817e-01f,
  -4.63014573e-01f, -2.53717810e-01f, -1.69474557e-01f, 1.79933563e-01f, 2.30424125e-02f, 1.09971046e-01f, 7.32593685e-02f, -7.37826377e-02f, 1.50834713e-02f, -1.24279119e-01f,
  -7.51383156e-02f, -2.54743714e-02f, -7.67281726e-02f, -1.03433102e-01f, -9.34593379e-02f, -2.46707238e-02f, 1.78361803e-01f, 8.76302794e-02f, 7.44393170e-02f, -1.10510856e-01f,
  1.73698887e-02f, -1.70721292e-01f, -1.46417171e-01f, -1.39840394e-02f, -2.02369258e-01f, -1.58245885e-03f, -2.16591686e-01f, -2.90237159e-01f, -8.51445347e-02f, -5.29506281e-02f,
  2.57391650e-02f, 1.00928005e-02f, -8.12976137e-02f, 1.24132626e-01f, 1.35694534e-01f, 5.40432194e-03f, -1.40890673e-01f, -9.27715451e-02f, -5.85526004e-02f, 9.88332331e-02f,
  3.74209904e-03f, -7.30208457e-02f, -8.76040682e-02f, -3.82060222e-02f, -4.10204716e-02f, -7.65755549e-02f, -3.94328199e-02f, 2.57702470e-02f, 8.24815780e-02f, 7.39924088e-02f,
  6.77092597e-02f, -1.47887185e-01f, 3.90465744e-02f, 3.62250134e-02f, 5.37829138e-02f, -1.15941107e-01f, 4.77086082e-02f, -3.29114683e-02f, -1.28757972e-02f, -1.24248832e-01f,
  2.54431486e-01f, 1.02947138e-01f, -1.82222262e-01f, -6.36024848e-02f, 1.18383929e-01f, 1.14500068e-01f, 2.16152333e-02f, 1.05993792e-01f, -7.80836716e-02f, -1.02611750e-01f,
  -7.28761479e-02f, -1.72388479e-01f, -4.97867167e-02f, -2.00490892e-01f, -1.18334733e-01f, -3.08562610e-02f, 1.62903666e-01f, 4.97540366e-03f, 6.54239729e-02f, 7.39052743e-02f,
  2.30808854e-01f, 1.76616862e-01f, 6.98179603e-02f, -4.04009223e-02f, -5.87115474e-02f, 4.99012657e-02f, -1.38831243e-01f, -4.82735671e-02f, -1.06137425e-01f, 2.30936885e-01f,
  -6.91230834e-01f, 7.98434243e-02f, 2.19266459e-01f, -3.88732523e-01f, 8.32394138e-03f, 8.86705220e-02f, 3.78318518e-01f, -5.86874923e-03f, -1.31491944e-01f, 1.51804000e-01f,
  1.25183553e-01f, -9.02136862e-02f, -9.14631113e-02f, 5.04178070e-02f, 1.62108466e-01f, 2.43646428e-01f, 2.47778967e-01f, -8.36981684e-02f, -2.66790427e-02f, 3.35227735e-02f,
  -5.31178936e-02f, -1.70051754e-01f, -1.95045739e-01f, -1.42866477e-01f, -7.03589842e-02f, -1.14720045e-02f, 5.32371178e-03f, -2.95771770e-02f, 1.04292147e-01f, 1.03646897e-01f,
  3.59843582e-01f, -1.90041468e-01f, 1.39641583e-01f, -1.13751076e-01f, -2.44117025e-02f, -7.91547000e-02f, -4.18941826e-02f, -8.29798058e-02f, -1.59412727e-01f, -1.27874613e-01f,
  -2.19797984e-01f, -7.10827336e-02f, -9.62968469e-02f, -1.43207181e-02f, -1.20793708e-01f, -2.84677632e-02f, -7.35046864e-02f, -5.70273399e-02f, 7.88552389e-02f, 1.13284588e-01f,
  7.23507330e-02f, -1.37473196e-02f, 3.06009669e-02f, 1.27820894e-01f, -8.45726486e-03f, -4.38777395e-02f, -1.96461659e-02f, -6.11791015e-02f, -5.90762161e-02f, -6.60230145e-02f,
  -7.71322325e-02f, -3.20212953e-02f, -4.64763232e-02f, -3.19839292e-03f, 1.07405685e-01f, 5.84925711e-02f, 5.10671139e-02f, 8.66347633e-04f, 5.42464405e-02f, 2.29275394e-02f,
  -6.23222925e-02f, 8.86858776e-02f, 6.05778247e-02f, -1.34654030e-01f, -1.27462270e-02f, -3.09748761e-02f, 1.65418293e-02f, -1.31209670e-02f, 2.49057938e-03f, -8.71059150e-02f,
  -5.84652126e-02f, 7.70817921e-02f, -6.82270974e-02f, 9.48723704e-02f, 1.34256363e-01f, -7.33829737e-02f, 7.26590231e-02f, 5.28109856e-02f, 4.64856848e-02f, -4.99940179e-02f,
  6.23873174e-02f, 2.14457307e-02f, 1.10728949e-01f, 2.16364525e-02f, -1.46275917e-02f, -1.10539675e-01f, -5.58303494e-04f, -1.03144243e-01f, 6.07884079e-02f, -2.09754985e-02f,
  -6.58331439e-02f, -1.35463014e-01f, -6.71254247e-02f, -1.46626309e-03f, 2.98203877e-03f, -8.76718313e-02f, -8.90163556e-02f, 9.66490339e-03f, 3.33860293e-02f, 7.95478839e-03f,
  -4.57789488e-02f, -1.59812532e-02f, -1.26890436e-01f, 9.59542692e-02f, 5.48330136e-02f, -2.15412211e-02f, 9.68118757e-02f, -6.15633689e-02f, -4.50552888e-02f, 3.71133201e-02f,
  6.04639053e-01f, 6.49822429e-02f, 2.69842297e-01f, 5.72518958e-03f, -3.13076794e-01f, -3.63867342e-01f, -1.77926421e-01f, -6.60239235e-02f, -4.41231877e-02f, -1.07401619e-02f,
  -2.90925145e-01f, -1.62134796e-01f, -5.18674441e-02f, 7.60931745e-02f, 1.87949881e-01f, 9.61773247e-02f, 1.39988124e-01f, 3.94908249e-01f, 2.87777990e-01f, 3.51603962e-02f,
  4.08787802e-02f, 1.92788616e-01f, 3.29439968e-01f, 2.54550099e-01f, 3.65709700e-02f, 6.20445907e-02f, 3.70250735e-03f, 1.17350623e-01f, 2.34682336e-02f, 2.48150140e-01f,
  -4.70695645e-02f, 1.33119419e-01f, -3.12176421e-02f, 5.03646582e-02f, 4.31116708e-02f, 1.36109456e-01f, -8.89727399e-02f, -4.15634103e-02f, -3.53671834e-02f, -1.05868511e-01f,
  5.72446920e-02f, -8.63671154e-02f, -8.26489627e-02f, -1.13703236e-01f, -1.40202582e-01f, -2.58125160e-02f, 1.17632352e-01f, 1.58009931e-01f, 7.50767142e-02f, 2.50881873e-02f,
  -1.66529968e-01f, -1.37239859e-01f, -1.34324446e-01f, -2.76759654e-01f, -1.13111511e-02f, -1.35170832e-01f, -1.00597605e-01f, 3.54675688e-02f, -1.53126776e-01f, -6.91762893e-03f,
  -2.68484771e-01f, -6.02205619e-02f, -5.89842089e-02f, -1.45080537e-01f, -2.00096041e-01f, -7.09048435e-02f, -6.58913776e-02f, -3.01609542e-02f, -1.13491029e-01f, -6.78099284e-04f,
  -2.21365958e-01f, -2.05436256e-02f, -1.27583817e-01f, -1.19641073e-01f, -2.42821220e-02f, 6.60547838e-02f, -9.41172764e-02f, -5.31277247e-02f, -4.91570607e-02f, -2.54151989e-02f,
  1.63219813e-02f, -8.40541162e-03f, -2.31397711e-02f, -1.02371521e-01f, -5.03870770e-02f, -1.05073929e-01f, -5.65355197e-02f, -1.27827555e-01f, -1.98624097e-02f, 6.92227930e-02f,
  -2.03650579e-01f, 6.31141141e-02f, 9.90287364e-02f, 2.75326997e-01f, 1.43314406e-01f, 7.68579096e-02f, 1.07145473e-01f, 8.97888616e-02f, -7.38134887e-03f, -1.58030484e-02f,
  8.15823898e-02f, 1.66801572e-01f, 5.30669577e-02f, 1.03540728e-02f, -2.42606997e-02f, -5.10427207e-02f, -4.27555759e-03f, 5.01893684e-02f, -4.37349407e-03f, -3.48753631e-02f,
  6.24060407e-02f, -1.14005491e-01f, -1.65892720e-01f, -2.25028366e-01f, -1.24208018e-01f, -2.55166709e-01f, -1.82664126e-01f, -1.90183185e-02f, -1.38575733e-01f, -2.53599674e-01f,
  6.35280609e-02f, -2.50037998e-01f, 3.13323468e-01f, 6.33403659e-02f, -1.14430211e-01f, -4.03659642e-01f, -5.24548054e-01f, -2.50693709e-01f, 3.90197826e-03f, -5.18549094e-03f,
  -5.80986915e-03f, 1.47934079e-01f, 1.41538635e-01f, 1.02798060e-01f, 6.85169846e-02f, -4.06758068e-03f, 1.56159133e-01f, 4.44044232e-01f, 1.53439656e-01f, -3.16870958e-02f,
  -7.26383692e-03f, 1.93518445e-01f, 3.72314602e-01f, 2.21912205e-01f, 1.02657191e-01f, 3.54563370e-02f, 8.49555358e-02f, 9.95236784e-02f, -5.52696474e-02f, 3.27448338e-01f,
  3.17027092e-01f, -1.26883283e-01f, -1.05038285e-02f, 3.72381806e-02f, 3.31548601e-02f, -7.34320050e-03f, -3.45073268e-02f, 1.39192611e-01f, -4.48571332e-03f, 7.09107742e-02f,
  7.59207970e-03f, 6.48889244e-02f, -2.59470120e-02f, -1.91614646e-02f, 2.94338148e-02f, -5.74249402e-02f, 1.50459096e-01f, 8.75900388e-02f, 1.85836051e-02f, 5.02514280e-02f,
  1.24237165e-02f, -7.45191127e-02f, -6.90215975e-02f, -2.34935924e-01f, -1.76075190e-01f, 8.59741718e-02f, -1.44982964e-01f, -1.12219919e-02f, -1.67780653e-01f, 6.58830330e-02f,
  1.02063909e-01f, 4.35995422e-02f, 1.35860398e-01f, 1.30001947e-01f, -3.26302387e-02f, 1.61394700e-02f, 7.61953443e-02f, -1.16443969e-02f, 1.42707199e-01f, 1.59298152e-01f,
  9.26624686e-02f, 3.99742983e-02f, 8.14953744e-02f, 2.07742210e-02f, -1.57314120e-03f, 4.67000939e-02f, 4.34490032e-02f, 4.38941680e-02f, 2.39846818e-02f, 1.82526093e-02f,
  4.52217795e-02f, 2.89335456e-02f, 1.87628623e-02f, 8.06217864e-02f, 3.79846469e-02f, 1.38861760e-01f, 1.60355628e-01f, -4.38244194e-02f, 4.45018113e-02f, 8.70898017e-04f,
  5.49201816e-02f, -1.40780751e-02f, 1.75326705e-01f, 3.36379558e-02f, 4.13146615e-02f, -2.32922062e-02f, -3.97065543e-02f, 3.21646295e-02f, -2.44170502e-02f, 9.53479111e-02f,
  3.67853884e-03f, 1.91109236e-02f, -1.48770675e-01f, 4.07748409e-02f, -2.15064525e-03f, -7.66284540e-02f, 9.33810547e-02f, -6.78610429e-02f, 5.09668961e-02f, 9.62628983e-03f,
  3.67141999e-02f, -2.00771749e-01f, -2.48607621e-01f, -2.80164450e-01f, -2.21571892e-01f, -7.63922632e-02f, -1.58181623e-01f, -2.54994452e-01f, -1.44127578e-01f, -2.95616001e-01f,
  4.24095482e-01f, -2.84099251e-01f, -4.11715984e-01f, -9.86194164e-02f, -2.97030866e-01f, -3.66646498e-02f, -1.69696927e-01f, 3.49458633e-03f, 6.88410178e-02f, -3.36660713e-01f,
  -4.33509424e-02f, 3.34731579e-01f, 1.71896204e-01f, 1.77586973e-01f, 2.42402539e-01f, -3.51541638e-01f, -2.35589996e-01f, 2.71035247e-02f, 2.48689994e-01f, 1.16586238e-01f,
  -5.38358837e-02f, -8.16604868e-02f, 1.23043872e-01f, -4.46620248e-02f, -1.58916548e-01f, -7.97397122e-02f, -2.40898088e-01f, -8.00835192e-02f, -1.12588286e-01f, -3.79920840e-01f,
  -1.97452545e-01f, -8.31963941e-02f, 8.17452520e-02f, 1.57321334e-01f, -1.80458158e-01f, -1.13189733e-02f, -1.29024312e-01f, -1.16487682e-01f, 2.52798985e-04f, -6.84505627e-02f,
  -1.72962472e-01f, 7.70712942e-02f, -1.09284155e-01f, -1.02475341e-02f, -8.13816115e-02f, -1.05449110e-01f, 1.71280168e-02f, 9.60481539e-02f, -8.96901637e-02f, -3.97267751e-02f,
  -1.82787001e-01f, -6.80561513e-02f, 9.34967492e-03f, 1.27426367e-02f, -7.36491457e-02f, -7.06491992e-02f, -1.70871347e-01f, -4.71669845e-02f, -5.68132699e-02f, -1.59749478e-01f,
  3.40144522e-02f, 3.11496649e-02f, -2.68036742e-02f, 8.99511427e-02f, -8.95516500e-02f, 5.83089925e-02f, -6.78218529e-02f, -7.20143542e-02f, -3.22249755e-02f, 7.89289027e-02f,
  1.67299099e-02f, -7.04218522e-02f, 4.46333438e-02f, -3.25192953e-03f, -6.14775755e-02f, -7.01726414e-03f, -4.13794070e-02f, 4.47920151e-02f, 1.07251648e-02f, 9.00495201e-02f,
  1.32996351e-01f, 1.31947890e-01f, -7.18402043e-02f, 3.79055813e-02f, 4.61421758e-02f, -6.27825260e-02f, -7.05788732e-02f, 7.24639744e-02f, 1.18636608e-01f, 8.36624578e-02f,
  3.92688811e-02f, 1.21030338e-01f, -6.55482784e-02f, -5.70078054e-03f, 8.12564394e-04f, -1.50350615e-01f, 1.49281565e-02f, -2.68036611e-02f, -1.72309414e-01f, -2.66284086e-02f,
  1.02623746e-01f, 2.36952566e-02f, -6.71335459e-02f, 5.41862510e-02f, 7.07493126e-02f, -1.22689128e-01f, -4.11945991e-02f, 4.02674340e-02f, 7.55789429e-02f, -1.32101206e-02f,
  1.26109989e-02f, -6.42801002e-02f, 1.04021616e-01f, 4.26884145e-02f, -3.57461907e-02f, 3.05835996e-02f, 1.25623997e-02f, -1.03337420e-02f, 1.74787566e-01f, -3.26558799e-02f,
  1.34114757e-01f, 4.78886366e-01f, 1.85393214e-01f, -2.08072186e-01f, 6.36880323e-02f, 6.71118647e-02f, 3.35573912e-01f, 1.17037892e-01f, -2.23105460e-01f, 8.29149187e-02f,
  5.70586175e-02f, -2.89853483e-01f, -1.75904393e-01f, -6.91375043e-03f, 3.14403363e-02f, 1.57973349e-01f, -2.82572787e-02f, -1.20912055e-02f, -1.76397681e-01f, -1.31769642e-01f,
  -6.96770847e-02f, -1.68761045e-01f, -1.89981267e-01f, -8.24792683e-02f, 4.57222946e-02f, -2.47712210e-01f, 1.00032963e-01f, 7.23306537e-02f, 2.24283755e-01f, 2.44476035e-01f,
  2.25806952e-01f, 4.54900801e-01f, -2.36736208e-01f, -1.44246742e-01f, -1.23474449e-01f, 2.24945080e-02f, -1.26732856e-01f, -6.89405799e-02f, -5.68497851e-02f, 1.05342761e-01f,
  -9.30217505e-02f, 2.11325616e-01f, 1.54792266e-02f, -6.97433949e-02f, -8.03182647e-02f, -1.70391425e-01f, -4.23244610e-02f, 9.89066362e-02f, -6.86812028e-02f, 8.22880566e-02f,
  3.76522876e-02f, 6.02229163e-02f, 2.60285825e-01f, 8.28235820e-02f, 6.29756600e-02f, -2.58183628e-01f, 1.53990686e-01f, 1.09554693e-01f, 7.77019337e-02f, 8.52525681e-02f,
  -2.21120734e-02f, -7.98467360e-03f, -1.06056444e-01f, -5.55450143e-03f, 4.15252075e-02f, -1.52524561e-02f, -1.02504464e-02f, -9.88116954e-03f, -5.75055294e-02f, 6.36759028e-02f,
  -5.76803125e-02f, -1.91780459e-02f, 4.70907055e-02f, 4.27341871e-02f, -1.50070667e-01f, -1.68289021e-02f, -8.82366020e-03f, 2.18042210e-02f, 1.16842970e-01f, 3.05594550e-03f,
  -6.76544234e-02f, 5.06029576e-02f, -1.53496221e-01f, -1.49803445e-01f, 1.49287097e-02f, 1.38222575e-02f, -1.83269411e-01f, -7.86497518e-02f, -2.82908380e-02f, 5.47133386e-02f,
  -3.76419097e-01f, 8.01471248e-02f, -2.08689481e-01f, -6.07400574e-02f, -1.93016361e-02f, 3.68243009e-02f, -3.21368054e-02f, -7.83495530e-02f, 1.31134197e-01f, 3.95710543e-02f,
  -4.71634697e-03f, 9.16096121e-02f, -1.05095588e-01f, 3.85079645e-02f, -2.01644719e-01f, -6.78126421e-03f, -4.04327661e-02f, -1.29540443e-01f, -3.14691931e-01f, -1.63509861e-01f,
  -2.35476926e-01f, -1.03034347e-01f, -1.37689576e-01f, -1.39524629e-02f, -1.98598847e-01f, -3.55710655e-01f, -1.99991554e-01f, -1.56925231e-01f, -5.47031388e-02f, -2.16524482e-01f,
  7.10708722e-02f, 2.09396765e-01f, -2.00201005e-01f, -1.21272765e-02f, 1.43976420e-01f, -7.96585158e-03f, -8.04119036e-02f, -5.30740842e-02f, 1.65939201e-02f, 6.49741217e-02f,
  7.72668570e-02f, 1.31338343e-01f, -1.87335070e-02f, 2.38496251e-02f, 4.68211025e-02f, 1.29024386e-02f, 5.87655231e-02f, -3.17256227e-02f, -4.37896065e-02f, -3.41248177e-02f,
  3.86907309e-02f, 3.95758562e-02f, -2.17355546e-02f, -9.25069302e-02f, 2.36774877e-01f, 1.71410441e-01f, -3.66338738e-03f, 1.34436890e-01f, 1.59586146e-01f, 2.15239346e-01f,
  -1.27458379e-01f, 9.35014337e-03f, -2.12435171e-01f, 7.70776197e-02f, 9.36111510e-02f, -1.13071546e-01f, -1.19142354e-01f, -1.98000908e-01f, 4.06704552e-04f, -5.63010685e-02f,
  3.38535495e-02f, 3.34100947e-02f, 3.80257033e-02f, 6.63718134e-02f, -5.17478995e-02f, -4.64029461e-02f, 1.30884890e-02f, 9.52281244e-03f, -2.27441452e-02f, 6.00550033e-04f,
  9.19051021e-02f, 6.43251650e-03f, -8.98565874e-02f, -1.04019269e-01f, -3.04060932e-02f, -5.83197502e-03f, -2.56064311e-02f, 3.22318897e-02f, -4.16661389e-02f, -5.52989915e-02f,
  2.07168490e-01f, 8.29289407e-02f, 7.23392740e-02f, 7.15618655e-02f, 1.92795470e-01f, 1.10381588e-01f, 1.19398080e-01f, -1.68715306e-02f, 3.43632023e-03f, 3.17041539e-02f,
  -2.06205416e-02f, -8.25862736e-02f, -6.23498484e-02f, -2.93227714e-02f, -2.39156354e-02f, 7.53202736e-02f, 1.01895906e-01f, -2.68866178e-02f, 2.26956811e-02f, -8.15584734e-02f,
  2.19697859e-02f, -1.50437325e-01f, -1.40970334e-01f, 3.49235460e-02f, -4.27833125e-02f, 6.60490543e-02f, 8.58960897e-02f, 4.90769325e-03f, -5.13326377e-02f, -1.80833600e-02f,
  -4.69689667e-01f, -1.68754384e-01f, 3.46609652e-02f, -1.22029865e-02f, 1.22925691e-01f, 1.48393046e-02f, -1.67839546e-02f, -7.32334033e-02f, -1.39253020e-01f, -1.67411208e-01f,
  -3.15293521e-02f, 8.56455192e-02f, 2.47238809e-03f, -1.65253114e-02f, -1.90621484e-02f, -2.03711130e-02f, 1.12563632e-01f, -4.95242998e-02f, -1.47736147e-01f, -1.04582369e-01f,
  -5.43539785e-02f, -2.30501711e-01f, -2.12211773e-01f, -2.06062958e-01f, -4.17180778e-03f, -7.53506199e-02f, -6.49103522e-02f, -2.07254905e-02f, -1.37186274e-01f, -8.11977535e-02f,
  -2.12248877e-01f, -4.27345395e-01f, -2.07117110e-01f, -1.87918708e-01f, -2.13709697e-01f, 2.26096734e-02f, -1.20090485e-01f, -2.33383812e-02f, -1.90839216e-01f, -3.50112766e-01f,
  -1.67493075e-01f, 1.08371124e-01f, 3.31101269e-02f, 8.26565474e-02f, 1.44069597e-01f, -3.05042028e-01f, -1.56660035e-01f, 1.49844913e-02f, 3.05911571e-01f, 1.62211925e-01f,
  6.39626458e-02f, -4.04132344e-02f, 1.33075908e-01f, -3.28302905e-02f, -3.49527478e-01f, -3.37680839e-02f, -2.57642150e-01f, -1.88225612e-01f, -1.22895762e-01f, -3.94144386e-01f,
  -2.40455270e-01f, -1.68633610e-01f, 1.58930555e-01f, 8.62671286e-02f, -9.85640138e-02f, 6.31689653e-02f, -4.99324724e-02f, -7.61915296e-02f, -8.64891559e-02f, -4.85992804e-02f,
  -7.14657977e-02f, 3.91428880e-02f, -1.73505079e-02f, 3.86807285e-02f, -2.71076337e-02f, 2.80377269e-02f, -1.48636743e-01f, 4.89050411e-02f, 1.41643122e-01f, -6.47974908e-02f,
  -3.26236933e-02f, 2.77188104e-02f, 7.65684769e-02f, 1.13586701e-01f, 8.02626312e-02f, 1.15748778e-01f, -1.30069941e-01f, 1.12867303e-01f, -1.89188346e-02f, -4.59525317e-01f,
  -4.54607159e-02f, -1.10614829e-01f, -2.56883781e-02f, 4.05609570e-02f, 1.08577356e-01f, -7.10176602e-02f, -5.79630062e-02f, 3.75162880e-03f, 3.20689427e-03f, 6.97077811e-02f,
  2.98950821e-02f, 2.75440253e-02f, -2.22170874e-02f, -1.22795537e-01f, -8.11088458e-03f, -5.01458123e-02f, 8.02816600e-02f, -6.73099980e-02f, -4.01934162e-02f, 2.11403295e-02f,
  -3.38166840e-02f, 8.14790428e-02f, -4.93083969e-02f, 1.03009969e-01f, -5.62518425e-02f, -1.03036076e-01f, 3.13570984e-02f, 1.03417961e-02f, 9.41730142e-02f, -3.17976139e-02f,
  -2.02590913e-01f, 9.89199206e-02f, -1.91160902e-01f, 9.98906046e-02f, -7.74354637e-02f, 9.24931932e-03f, -7.28063434e-02f, 7.12761730e-02f, 8.62283856e-02f, -9.66889560e-02f,
  1.55183390e-01f, -3.32040079e-02f, -1.41458243e-01f, 5.64340875e-03f, 7.20565692e-02f, 6.25505075e-02f, -7.67922178e-02f, 1.27792563e-02f, 4.11462560e-02f, 5.02023548e-02f,
  -3.70150506e-02f, 4.08696160e-02f, -1.62787773e-02f, -3.32834125e-02f, 1.02631696e-01f, 5.97084761e-02f, -3.23725455e-02f, -3.05103138e-02f, 4.88999374e-02f, -4.34639543e-01f,
  1.10733509e-01f, -4.31025743e-01f, 1.03901654e-01f, 8.91582817e-02f, 3.04325908e-01f, 3.85794103e-01f, 2.46276677e-01f, 1.11149475e-01f, -5.93808480e-02f, -9.42784920e-02f,
  -2.13359997e-01f, -3.86942416e-01f, -3.44930679e-01f, -3.21149945e-01f, -2.37782255e-01f, 2.02201217e-01f, 2.40921766e-01f, 8.49683732e-02f, 1.60520211e-01f, 1.38052210e-01f,
  -9.34289172e-02f, 9.90185440e-02f, -3.66121083e-02f, -3.27820890e-02f, -2.01390356e-01f, -1.44767612e-01f, -8.62527788e-02f, 8.65443274e-02f, -1.78765804e-01f, -1.12378158e-01f,
  -1.62664905e-01f, -7.55890533e-02f, -5.16201109e-02f, -1.34878129e-01f, -1.54622952e-02f, -7.40347356e-02f, -4.35757898e-02f, -1.16352886e-01f, -1.04752205e-01f, 1.34553060e-01f,
  6.31898344e-02f, -8.88738483e-02f, 7.16711655e-02f, -6.28523380e-02f, 1.10496484e-01f, -3.91937420e-02f, -9.08229277e-02f, -1.61879718e-01f, -2.19061211e-01f, -9.84956697e-02f,
  -1.59526467e-01f, -1.36181815e-02f, 1.35208756e-01f, 1.38853909e-02f, -1.27738938e-01f, 9.48103517e-02f, -4.69888560e-02f, -1.64226890e-01f, 2.64864918e-02f, 4.66901995e-02f,
  7.12311342e-02f, -3.83242443e-02f, -7.88684860e-02f, -1.04566198e-02f, -1.07073031e-01f, 1.11387841e-01f, 4.85937931e-02f, -1.57877710e-03f, 4.69602048e-02f, -1.04571963e-02f,
  -1.86617021e-03f, -1.94937646e-01f, -4.15779352e-02f, -4.10891324e-02f, -8.56250301e-02f, -1.42142296e-01f, -1.09272311e-02f, -5.49677648e-02f, -1.14153968e-02f, -7.78968632e-02f,
  -7.02105686e-02f, 2.86975652e-02f, 4.44768295e-02f, -1.28295809e-01f, -1.54095307e-01f, -1.10363729e-01f, -4.69964892e-02f, -5.18916287e-02f, -5.23001663e-02f, -1.12241589e-01f,
  -3.14940691e-01f, -5.67210540e-02f, 7.65528083e-02f, -2.20567943e-03f, 6.03646077e-02f, -2.19155625e-01f, -1.53244421e-01f, -7.30672553e-02f, -2.05806531e-02f, 5.32946438e-02f,
  1.43822193e-01f, -3.20764482e-02f, -5.04009612e-02f, 4.22881730e-02f, 1.85465395e-01f, 8.58730599e-02f, -9.53717455e-02f, -2.26164684e-02f, -1.14848733e-01f, -5.68089746e-02f,
  -9.30542946e-02f, 1.71662867e-01f, 2.18152910e-01f, 1.46726429e-01f, 1.12784915e-01f, 2.64344573e-01f, 1.06005467e-01f, 1.18246369e-01f, 7.52222389e-02f, 2.34422937e-01f,
  5.47872603e-01f, -1.52040198e-01f, 2.46955276e-01f, 2.15247139e-01f, 1.63960904e-01f, 2.97224909e-01f, 1.82444692e-01f, 1.62897214e-01f, 8.33285227e-02f, 7.86945075e-02f,
  1.01793632e-01f, 1.10111706e-01f, -2.81561129e-02f, -1.00171976e-01f, 8.18211213e-02f, -3.99788357e-02f, -1.24546036e-01f, 1.63329944e-01f, 1.82924390e-01f, 1.39490440e-01f,
  -2.27724731e-01f, -8.79876614e-02f, 9.19008031e-02f, -6.92306831e-02f, -2.86026329e-01f, -5.38790412e-02f, -8.54644179e-02f, -7.61862919e-02f, -1.03431739e-01f, -1.95030540e-01f,
  -4.64988127e-02f, 1.39967978e-01f, -1.19927011e-01f, -2.81393528e-01f, 7.37691764e-03f, -9.32842270e-02f, 6.76466450e-02f, -1.00252055e-01f, -1.92505792e-01f, -1.45051450e-01f,
  -1.58529893e-01f, -1.47195861e-01f, -5.70834614e-02f, -1.47296384e-01f, -1.11988327e-02f, -7.19720647e-02f, -4.25912738e-02f, 1.33618163e-02f, -1.72242802e-02f, -2.53341272e-02f,
  -2.07595870e-01f, 1.51097570e-02f, 7.39086568e-02f, 5.42073473e-02f, 6.47756085e-02f, 4.12995815e-02f, 6.84557930e-02f, -1.81523971e-02f, 1.18135381e-02f, -1.57197818e-01f,
  -4.64385487e-02f, 8.31705481e-02f, 3.87185104e-02f, 1.20945476e-01f, 1.92695111e-01f, 1.84274279e-02f, -1.50187761e-01f, -6.08930103e-02f, 3.12343724e-02f, 2.01074723e-02f,
  -1.16589509e-01f, 5.22364676e-02f, 1.48608118e-01f, 9.84321628e-03f, -3.42504829e-02f, -5.09725735e-02f, 1.64405443e-02f, -1.17401272e-01f, 1.31862033e-02f, 1.21261410e-01f,
  1.11815646e-01f, -1.07536703e-01f, -3.96119052e-04f, -4.41130064e-03f, -1.03257209e-01f, -1.35118105e-02f, 7.99533948e-02f, -5.99134015e-03f, -4.09493446e-02f, -6.02743998e-02f,
  -1.42755687e-01f, 2.73974210e-01f, -9.11077634e-02f, -1.23777986e-01f, -1.05291337e-01f, -7.88608268e-02f, 7.85565451e-02f, -2.71307901e-02f, 1.59551669e-02f, -2.03191135e-02f,
  9.51615497e-02f, -4.03278284e-02f, 2.94770133e-02f, 5.85771091e-02f, 8.43598247e-02f, 1.67794470e-02f, -5.55030257e-02f, 2.61995830e-02f, 5.58964610e-02f, 5.39066978e-02f,
  -1.12319626e-01f, 7.34417513e-02f, 9.71501023e-02f, 5.91254793e-02f, 1.14352465e-01f, 1.16884723e-01f, 1.48644149e-01f, 7.01277032e-02f, 1.93833187e-01f, -8.77315626e-02f,
  2.81229109e-01f, -1.09430440e-01f, 3.73279154e-01f, -1.14961103e-01f, 1.36714010e-02f, 1.68832794e-01f, 2.33812287e-01f, 1.68760344e-01f, -1.23138219e-01f, -9.24358219e-02f,
  -3.01544547e-01f, -3.00909162e-01f, -2.72040248e-01f, -3.13325405e-01f, -1.59803838e-01f, 2.46544227e-01f, 2.69461691e-01f, 1.60062507e-01f, 3.24162751e-01f, 2.47048780e-01f,
  8.96324124e-03f, 2.17547953e-01f, 2.16347471e-01f, 1.17922656e-01f, 5.36002219e-02f, -6.10365532e-02f, 1.29102349e-01f, -1.38280364e-02f, -3.10632158e-02f, 3.38401124e-02f,
  3.57681289e-02f, -1.00452580e-01f, 5.64881489e-02f, -1.55211031e-01f, -1.15702294e-01f, -2.11213939e-02f, 7.26708844e-02f, 9.66504123e-03f, -1.58444405e-01f, -5.37294894e-03f,
  -2.25696713e-01f, -1.53495058e-01f, -1.46306261e-01f, 1.63088776e-02f, 2.72505414e-02f, 3.14710066e-02f, 3.75220329e-02f, 1.16079316e-01f, -8.63169432e-02f, -1.01025969e-01f,
  -2.61160702e-01f, 1.59393977e-02f, 6.29275963e-02f, 6.91840723e-02f, -1.62033126e-01f, -1.14611313e-01f, 1.25703394e-01f, -1.01026837e-02f, 6.11819364e-02f, 2.19062835e-01f,
  8.90633389e-02f, -7.79494643e-02f, -1.00348480e-01f, 1.33996636e-01f, -2.51765810e-02f, -1.19902596e-01f, -3.08943801e-02f, -6.82435855e-02f, 1.74898785e-02f, -4.13399562e-02f,
  -1.45982966e-01f, -5.72815444e-03f, -3.23505886e-02f, -4.81807329e-02f, -1.05399378e-01f, 9.87712890e-02f, 3.42544205e-02f, 5.22331707e-02f, 4.46977317e-02f, 4.57411595e-02f,
  -6.13842383e-02f, 1.29017472e-01f, 8.63797516e-02f, 4.49246354e-02f, -2.52858065e-02f, -8.39279667e-02f, -7.93528706e-02f, 6.50866656e-03f, -9.37531586e-04f, 1.47528276e-01f,
  9.45105106e-02f, -2.85174459e-01f, -8.80284328e-03f, 1.40970409e-01f, 6.15927093e-02f, 2.16835421e-02f, -2.29185179e-01f, -1.51275516e-01f, -1.50586873e-01f, -1.40460506e-01f,
  -1.71502843e-01f, -1.90301105e-01f, -5.45797683e-03f, 5.61412191e-03f, -7.22895637e-02f, -5.71562275e-02f, -2.21948728e-01f, 6.15440914e-03f, -9.51074362e-02f, -7.88568482e-02f,
  7.87898526e-03f, 1.13732986e-01f, 1.34275466e-01f, -6.76440373e-02f, -5.64126633e-02f, 6.11284934e-02f, 6.13356791e-02f, 8.77540857e-02f, 1.11081287e-01f, 2.96276957e-01f,
  1.51271313e-01f, -2.25591823e-01f, -2.15294957e-01f, 5.49207740e-02f, -8.68080482e-02f, -1.45430908e-01f, -2.90107518e-01f, 6.20522797e-02f, 1.31062552e-01f, -2.64491200e-01f,
  -8.55115652e-02f, 2.44907334e-01f, 9.80352163e-02f, -5.14550805e-02f, -3.32740843e-02f, -3.60792369e-01f, -2.92498648e-01f, -8.08798894e-02f, 1.95516616e-01f, 8.02402943e-02f,
  -1.25423111e-02f, -3.87652554e-02f, 3.77554372e-02f, 2.64915265e-02f, -9.80701745e-02f, -2.07784977e-02f, -1.29113778e-01f, -8.63301605e-02f, -1.97567031e-01f, -3.19211572e-01f,
  -2.47074857e-01f, 6.20149029e-03f, 4.22694348e-02f, 8.66102800e-02f, -4.51904982e-02f, 1.55157983e-01f, 4.31497407e-04f, -5.29252514e-02f, 8.76096785e-02f, -8.36228603e-04f,
  3.34102064e-02f, -4.20504883e-02f, -3.25628072e-02f, 1.30399447e-02f, 3.30918632e-03f, -1.96596719e-02f, -3.63029763e-02f, 7.26439953e-02f, -6.03592433e-02f, -2.30739452e-02f,
  -5.46764173e-02f, -9.49253216e-02f, 2.34828461e-02f, -4.04026844e-02f, 4.32002731e-02f, 3.47389504e-02f, -8.18394125e-02f, -4.95844102e-03f, -6.16837479e-02f, -1.75381362e-01f,
  3.40337679e-02f, -3.65416147e-02f, 5.54732420e-02f, 1.63681693e-02f, 1.05649307e-01f, -1.44806160e-02f, -8.01056698e-02f, -6.88544288e-02f, -5.78194037e-02f, -2.24174671e-02f,
  7.28562251e-02f, -1.27578020e-01f, 8.10976848e-02f, -4.38563116e-02f, -6.29589483e-02f, -1.44823238e-01f, 1.94662176e-02f, -1.14591956e-01f, -1.07861593e-01f, 6.78310767e-02f,
  -3.84964198e-02f, 3.45824398e-02f, -1.07387356e-01f, 2.59927660e-02f, 3.52755934e-02f, -1.53634995e-01f, 2.45627202e-02f, -6.81293607e-02f, -9.24463198e-02f, -8.65830630e-02f,
  2.26647332e-02f, -8.69660378e-02f, -2.08858177e-01f, 4.04741652e-02f, 1.98794864e-02f, -2.33660862e-02f, -1.81369726e-02f, -3.12307347e-02f, -2.92621329e-02f, -1.41280964e-01f,
  -3.05979163e-03f, -5.04711233e-02f, -1.17000066e-01f, 1.58087630e-02f, 1.90313458e-01f, 6.34501129e-02f, -1.31476685e-01f, -7.57635161e-02f, 1.09703001e-02f, 5.19139208e-02f,
  -6.43723980e-02f, -1.47890925e-01f, 7.48016760e-02f, -3.69088985e-02f, -1.33861962e-03f, -4.37827855e-02f, -1.52576100e-02f, -2.84902658e-02f, -6.47487417e-02f, -1.90551102e-01f,
  -6.17044330e-01f, -7.01794587e-03f, 1.74601272e-01f, -2.48807281e-01f, -1.36621252e-01f, -1.17811831e-02f, 4.88207154e-02f, -1.11213446e-01f, -3.42173517e-01f, 4.56377082e-02f,
  6.16794564e-02f, 7.30668530e-02f, 1.31326422e-01f, 4.34580594e-02f, -6.23142608e-02f, 2.56460279e-01f, 5.26184924e-02f, -1.65932775e-02f, -4.91918661e-02f, -4.85164206e-03f,
  -4.00975300e-03f, -3.27967592e-02f, -2.96503216e-01f, -8.88023898e-02f, -2.10543517e-02f, -4.22168076e-02f, 1.31690830e-01f, -3.30527909e-02f, 2.66197007e-02f, -5.97069226e-02f,
  4.80711758e-01f, -1.42830595e-01f, -4.44620959e-02f, -1.28916398e-01f, 2.24892944e-02f, -1.48880646e-01f, 1.59887932e-02f, 3.93367559e-02f, -1.63406178e-01f, -6.29180372e-02f,
  -9.36429799e-02f, -7.43471533e-02f, -6.23693839e-02f, 1.06399871e-01f, 6.38293996e-02f, -3.59925255e-02f, -7.80642331e-02f, 8.25668406e-03f, -4.66036871e-02f, -4.41685738e-03f,
  9.21021253e-02f, 8.20774992e-04f, 8.19536671e-02f, -4.57218364e-02f, 4.34087589e-02f, -1.13158576e-01f, 1.21205568e-01f, -5.91544844e-02f, -4.73338999e-02f, 1.10239066e-01f,
  -3.56434546e-02f, -1.79145057e-02f, -1.29831001e-01f, -3.53274139e-04f, -9.66408178e-02f, -1.51448483e-02f, 3.13392878e-02f, 1.53713627e-02f, 2.15996406e-03f, -1.06710069e-01f,
  9.61956084e-02f, 2.81372257e-02f, -2.99371574e-02f, 3.71301509e-02f, 1.00814275e-01f, -1.10086799e-01f, -4.44844627e-04f, 2.34615523e-02f, -1.06072061e-01f, -3.22664715e-02f,
  -9.43412632e-02f, -5.65403812e-02f, 4.89143953e-02f, -2.35178098e-02f, 1.31558543e-02f, -9.67640355e-02f, 3.62053029e-02f, -9.00280029e-02f, 6.48483783e-02f, -1.39734402e-01f,
  2.90077358e-01f, -1.26108214e-01f, 1.53120086e-01f, -3.20937298e-02f, -1.08986348e-02f, -5.93946241e-02f, 1.22863725e-02f, -2.21593380e-02f, -3.32632586e-02f, -1.04035176e-02f,
  -2.23273262e-01f, 6.26923293e-02f, 9.01263133e-02f, 1.11445241e-01f, 2.00077761e-02f, -1.05651751e-01f, 8.01293328e-02f, -9.18363482e-02f, 5.80324605e-02f, 5.66340424e-02f,
  -1.12898066e-03f, -7.27440715e-02f, 6.82603419e-02f, 5.80507219e-02f, 3.62259522e-02f, 2.07957439e-02f, 6.85376003e-02f, -8.17201361e-02f, -2.50090770e-02f, 2.23318338e-01f,
  1.39304414e-01f, -4.61340547e-02f, -1.37286410e-01f, 1.39233887e-01f, 1.09462366e-01f, 7.82853141e-02f, -2.09989965e-01f, 3.60636823e-02f, 1.61672592e-01f, -2.06071600e-01f,
  7.31684715e-02f, -6.66058660e-02f, -1.26550809e-01f, -1.67396843e-01f, -5.43274045e-01f, -4.54447776e-01f, -3.27500254e-01f, -3.57229590e-01f, -2.38200456e-01f, -1.38392188e-02f,
  1.55025110e-01f, 1.25335800e-02f, -1.02918617e-01f, 7.76135251e-02f, 2.67184258e-01f, 8.49649385e-02f, 9.69427526e-02f, 1.59763336e-01f, 6.36963993e-02f, 1.65753394e-01f,
  -1.42011449e-01f, 2.69897550e-01f, 2.14580193e-01f, 4.24127132e-02f, 2.68452372e-02f, -5.95947867e-03f, -4.69741859e-02f, -7.28238001e-02f, 2.58020639e-01f, -3.23333330e-02f,
  3.07968091e-02f, -7.12427124e-02f, 7.66774863e-02f, 8.26352686e-02f, 1.29989991e-02f, 1.03912847e-02f, -6.27041385e-02f, -6.83561862e-02f, -9.12433416e-02f, -3.52923013e-02f,
  -5.32744490e-02f, -6.27306625e-02f, -1.01550043e-01f, 4.31154855e-02f, -9.47687104e-02f, -1.45042270e-01f, 3.14933173e-02f, 3.73758227e-02f, 1.27557382e-01f, 9.90870446e-02f,
  -1.03463829e-01f, 4.30427566e-02f, 6.33141920e-02f, 5.61801977e-02f, -8.46577361e-02f, 2.31456645e-02f, 1.42082542e-01f, -6.31394014e-02f, -7.31139928e-02f, -3.92584465e-02f,
  -2.76296064e-02f, -6.27442524e-02f, -1.39564842e-01f, 1.23525023e-01f, 8.35865214e-02f, 5.57311624e-02f, 7.50218108e-02f, 4.23379242e-02f, 5.29809929e-02f, 5.77567890e-02f,
  -1.39392130e-02f, -1.44528029e-02f, 7.79190809e-02f, -3.48470174e-03f, -5.68654947e-02f, -3.47780660e-02f, 1.77598670e-02f, 4.20393609e-02f, -3.53236496e-02f, -7.89724067e-02f,
  1.21455640e-01f, -1.45272955e-01f, 2.08582263e-02f, -8.42375532e-02f, 1.12958081e-01f, -2.28996715e-03f, 4.42512222e-02f, -2.69168187e-02f, 1.02162406e-01f, 4.40245606e-02f,
  -6.67722225e-02f, -1.66606754e-02f, -1.22782076e-02f, -1.23393908e-01f, -1.21661760e-02f, 8.79970044e-02f, -8.44278634e-02f, 8.68039653e-02f, -7.61603117e-02f, 7.49188010e-03f,
  -9.15665925e-02f, -1.79922417e-01f, -2.02416196e-01f, -1.01490803e-01f, 1.38112545e-01f, -1.08857073e-01f, 2.17718016e-02f, 1.04227453e-01f, 1.89302098e-02f, -7.40425140e-02f,
  -1.39673829e-01f, 5.19231021e-01f, -1.05654918e-01f, 1.89675651e-02f, -1.66769862e-01f, -2.77430385e-01f, -1.14913620e-01f, 4.48830053e-02f, 8.54299366e-02f, 3.03370446e-01f,
  6.87903091e-02f, -2.62730032e-01f, -9.09142047e-02f, -1.14930548e-01f, -3.02818120e-01f, 8.68728682e-02f, -4.49174596e-03f, -2.93698430e-01f, -5.81895232e-01f, -4.24483806e-01f,
  -1.10487387e-01f, -3.84444557e-02f, -1.46109462e-01f, -1.00694366e-01f, 1.78356245e-01f, -9.29826498e-03f, 2.53545254e-01f, -3.82196903e-02f, 4.69933992e-04f, 7.80325904e-02f,
  -2.53502250e-01f, -1.56187415e-01f, -1.77745685e-01f, -1.17728033e-03f, 4.09248695e-02f, -1.04019992e-01f, -1.22900873e-01f, -2.54890081e-02f, 1.10019767e-03f, -7.25650461e-03f,
  -7.30140731e-02f, -7.07285181e-02f, -2.40156934e-01f, -8.78996775e-02f, -1.83071524e-01f, -2.38430843e-01f, -1.18500412e-01f, -2.48150080e-01f, 5.34039699e-02f, 2.01057214e-02f,
  -1.76218510e-01f, -2.65897870e-01f, -1.76758438e-01f, -1.21312439e-02f, -1.12634515e-02f, -2.80939221e-01f, 3.03782020e-02f, -8.12120214e-02f, 3.01002711e-03f, 3.18271756e-01f,
  1.15548283e-01f, -3.21432650e-02f, -1.97464060e-02f, -9.41392109e-02f, -1.05646089e-01f, -7.88459461e-03f, 6.07870631e-02f, -1.06148057e-01f, 1.18889593e-01f, 5.02401628e-02f,
  -6.65937066e-02f, 5.02195470e-02f, 4.21454720e-02f, 1.25962105e-02f, 3.01678292e-02f, 2.33493801e-02f, -2.25115251e-02f, 1.51645765e-02f, -1.15380712e-01f, 5.68811335e-02f,
  5.30658774e-02f, 2.58129425e-02f, 7.02110007e-02f, 4.38208617e-02f, 4.49182056e-02f, 1.46621361e-01f, -9.78399068e-02f, -1.70125253e-02f, -1.82210535e-01f, -9.50961411e-02f,
  2.87014633e-01f, 7.16020586e-03f, 9.59586725e-02f, 2.98444442e-02f, -2.02357844e-02f, -3.29003111e-02f, 1.13973342e-01f, 2.91021466e-02f, -8.42981506e-03f, 5.25982790e-02f,
  -6.99750558e-02f, 8.05152506e-02f, -7.42786154e-02f, 2.64179669e-02f, -2.00264052e-01f, -1.53003916e-01f, 9.24310759e-02f, -3.79625824e-03f, 5.03528938e-02f, 2.85431389e-02f,
  5.81513755e-02f, 9.90504697e-02f, 1.40869528e-01f, 1.80557847e-01f, -5.58327558e-03f, -8.58738869e-02f, 7.68219829e-02f, 5.35241589e-02f, -7.46363774e-02f, 4.14631456e-01f,
  4.26783681e-01f, -2.19275415e-01f, -3.05415958e-01f, 1.82290867e-01f, 6.43420266e-03f, 2.10140496e-02f, 2.45270748e-02f, 1.25424460e-01f, 7.45119378e-02f, -1.05198868e-01f,
  -2.11573392e-01f, -2.08549023e-01f, -2.25870147e-01f, -1.71741560e-01f, 3.80803533e-02f, -6.08273484e-02f, -4.88496199e-02f, -2.49598362e-02f, 2.00075656e-01f, 1.59842655e-01f,
  1.52763939e-02f, 5.78427389e-02f, 1.39621049e-01f, -3.39496993e-02f, -1.52508870e-01f, -6.68709679e-03f, -1.73685908e-01f, -1.47812963e-01f, -2.28390634e-01f, -2.57725537e-01f,
  -2.38103062e-01f, -2.43822634e-01f, 4.30916715e-03f, -1.37402471e-02f, -4.35673073e-03f, -1.02909930e-01f, -6.93763606e-03f, 2.59192418e-02f, -7.69786537e-02f, -8.45828727e-02f,
  -1.78366691e-01f, -5.27475886e-02f, -9.86016989e-02f, -3.70232314e-02f, 9.50791240e-02f, 6.00485243e-02f, -2.25417479e-03f, -1.33950815e-01f, -3.77631374e-02f, -1.63444266e-01f,
  -1.28007576e-01f, -3.23124550e-04f, 3.14740576e-02f, -1.05046138e-01f, -1.98950931e-01f, -2.98850350e-02f, -1.80802435e-01f, -1.43778799e-02f, -8.28364268e-02f, 4.81573492e-02f,
  3.90172862e-02f, 1.10848132e-03f, -3.84606495e-02f, -4.48184982e-02f, 2.97294594e-02f, 1.11182548e-01f, 8.93505216e-02f, 8.48071128e-02f, -2.78127473e-02f, 8.50654840e-02f,
  2.42466871e-02f, -2.31934432e-02f, -7.52827227e-02f, -4.94982302e-02f, -8.79823267e-02f, -7.24183992e-02f, 1.03124939e-01f, -6.03257231e-02f, -2.77659651e-02f, 8.73824582e-03f,
  -6.47420660e-02f, -9.32505205e-02f, 2.72644609e-02f, -5.25079146e-02f, -1.18122995e-01f, -2.17627063e-02f, -8.94404650e-02f, -8.02139342e-02f, 5.14330044e-02f, 2.75540799e-02f,
  1.38637379e-01f, -2.07691044e-01f, 1.11980483e-01f, 7.21620470e-02f, 9.25024739e-04f, -2.58435085e-02f, -1.88413292e-01f, -8.02366585e-02f, -1.77610554e-02f, 8.23019594e-02f,
  -7.50101581e-02f, -1.14025762e-02f, -1.27848879e-01f, -1.13619454e-01f, 2.77935639e-02f, 1.90748479e-02f, -1.21776864e-01f, 8.25900733e-02f, -9.82751846e-02f, -1.11198230e-02f,
  1.97353922e-02f, 7.36473277e-02f, 2.84800947e-01f, 1.51403651e-01f, 3.70149352e-02f, 1.74605995e-01f, 1.13938116e-01f, 1.02286838e-01f, -2.21796799e-02f, 2.77818948e-01f,
  -7.32668757e-01f, 7.99527317e-02f, 4.27646935e-02f, -2.84745872e-01f, 4.59916964e-02f, -2.77132429e-02f, -5.22360541e-02f, -1.36930510e-01f, -1.67308226e-01f, 1.19732961e-01f,
  1.75391540e-01f, -2.49316003e-02f, -5.14506968e-03f, -1.57342851e-01f, -4.03394341e-01f, -1.05217397e-01f, -1.12205550e-01f, -3.86378825e-01f, -3.62202138e-01f, -1.71341658e-01f,
  -1.81770682e-01f, -4.28664893e-01f, -5.19178867e-01f, -2.05266804e-01f, 2.98842471e-02f, -1.41259238e-01f, -9.36079919e-02f, -2.16018379e-01f, 5.09993620e-02f, 4.00968408e-03f,
  2.86168933e-01f, -1.07285909e-01f, 6.46739751e-02f, -1.22026719e-01f, 4.64803167e-02f, -9.14324075e-02f, -4.79755253e-02f, -1.34305041e-02f, -5.37347756e-02f, -3.51382513e-03f,
  4.25232612e-02f, 3.02102678e-02f, -1.79945052e-01f, 7.89694339e-02f, 6.19881600e-03f, -6.53108656e-02f, 1.12699434e-01f, -7.25006536e-02f, 1.04443580e-01f, 1.82710126e-01f,
  1.79959685e-01f, 9.79561061e-02f, 1.07965104e-01f, -1.65590495e-02f, 6.06647916e-02f, 3.00207455e-02f, 1.30870398e-02f, 1.49977759e-01f, 9.42309648e-02f, 5.64339906e-02f,
  -4.77911867e-02f, 9.22741517e-02f, 1.96502712e-02f, -2.78138276e-02f, 1.38906896e-01f, 3.43368016e-02f, -7.12902844e-02f, 6.02785684e-02f, -1.47365198e-01f, -1.14702351e-01f,
  1.52590886e-01f, 8.81909803e-02f, -1.28552234e-02f, -1.10882536e-01f, 5.23976870e-02f, 3.11140884e-02f, 6.57119974e-03f, -4.02016677e-02f, -1.78243183e-02f, -4.70282994e-02f,
  1.33356806e-02f, 2.23296136e-03f, 1.67240971e-03f, 4.83806543e-02f, 5.19597344e-02f, -3.00925947e-03f, 1.21858627e-01f, 5.99221811e-02f, -1.17630742e-01f, 8.08038116e-02f,
  -8.07870254e-02f, -2.02508911e-01f, -2.55654864e-02f, 5.95323853e-02f, 1.08283095e-01f, 5.42509481e-02f, 2.95911711e-02f, 1.26896584e-02f, -9.42062810e-02f, 6.12243749e-02f,
  -6.89733922e-02f, -2.62035429e-02f, 4.26338706e-03f, -4.69597755e-03f, -4.78192158e-02f, -4.66336384e-02f, 6.67982996e-02f, -1.02640189e-01f, 4.67324257e-02f, 1.50217652e-01f,
  3.53406966e-02f, 2.72771884e-02f, -1.64511934e-01f, -5.69911264e-02f, -8.90597403e-02f, -4.39415537e-02f, 4.20883894e-02f, 6.02257252e-02f, 6.02368601e-02f, -1.09169297e-01f,
  9.02177170e-02f, 1.62281911e-03f, 1.75490260e-01f, 2.41844460e-01f, 9.46220383e-02f, 8.81084204e-02f, -1.31005451e-01f, -8.88811573e-02f, 7.90233985e-02f, -1.72899947e-01f,
  1.71145380e-01f, 1.18060015e-01f, -7.48003498e-02f, 3.93477008e-02f, -1.10541999e-01f, -3.76302212e-01f, -3.92354369e-01f, -1.99958906e-01f, 5.86351119e-02f, -2.86790002e-02f,
  7.39767551e-02f, -1.79182049e-02f, 1.09025128e-02f, -6.77120462e-02f, -1.54370174e-01f, -6.10102899e-02f, -1.83324218e-01f, -2.79938187e-02f, -7.82994181e-02f, -1.14378788e-01f,
  7.32664093e-02f, 1.47878185e-01f, 7.80178830e-02f, -1.61150470e-01f, -3.64887565e-02f, -6.10552728e-03f, 2.74558757e-02f, -2.44475901e-01f, 4.70149890e-02f, -1.29031077e-01f,
  3.49251879e-03f, -3.95315746e-03f, -3.72922532e-02f, -3.39536481e-02f, -1.24613240e-01f, -1.38545364e-01f, -1.99187979e-01f, -1.62258402e-01f, -1.00705788e-01f, -5.50310537e-02f,
  -2.46302173e-01f, -2.68341415e-02f, -1.34048432e-01f, -3.96284610e-02f, -1.39330521e-01f, -1.83959380e-01f, -1.65566280e-01f, -1.43246606e-01f, -1.37767196e-01f, -3.40069860e-01f,
  -2.54678220e-01f, 3.97347584e-02f, 9.96640399e-02f, -4.57473099e-02f, -1.16430476e-01f, -1.30787522e-01f, -1.65771842e-02f, -2.41756067e-02f, -1.24058843e-01f, -2.59460714e-02f,
  3.43726948e-02f, 1.11094874e-03f, -2.06536613e-02f, -1.69584081e-01f, -1.15120076e-01f, -1.08557671e-01f, -3.08537241e-02f, -2.48036981e-02f, -1.14770345e-01f, -5.33390194e-02f,
  -4.34118472e-02f, 1.62338484e-02f, 1.08849900e-02f, -4.50869352e-02f, -4.01112661e-02f, -6.75538974e-03f, -8.68417770e-02f, -2.04597265e-02f, -1.98398322e-01f, -1.44972682e-01f,
  6.97781891e-02f, 1.05399162e-01f, -7.40890950e-02f, 3.29575613e-02f, -5.68026714e-02f, -4.34488468e-02f, 2.53539532e-02f, -1.52821355e-02f, 9.09001306e-02f, -4.76973914e-02f,
  4.90006618e-03f, 3.67771485e-03f, -6.09299242e-02f, -6.88994005e-02f, 1.09060571e-01f, -5.23701571e-02f, -3.23048443e-01f, 5.53970970e-02f, 2.31317766e-02f, -9.19262171e-02f,
  -1.18303657e-01f, -8.74008387e-02f, -7.57206827e-02f, -9.40312371e-02f, -1.10397957e-01f, -7.69039914e-02f, -1.47228315e-01f, 5.09931706e-02f, -1.21555604e-01f, -3.23419631e-01f,
  6.84931176e-03f, -3.23475212e-01f, 1.88010931e-01f, -2.84512131e-03f, 1.03970267e-01f, 1.29618958e-01f, 3.18609998e-02f, 5.97213209e-02f, -1.54514592e-02f, 4.52552475e-02f,
  -3.86026837e-02f, -1.33901894e-01f, -2.50467211e-02f, -1.55145660e-01f, -2.10682768e-02f, -5.59727401e-02f, 1.96498958e-03f, 7.47247413e-02f, -4.56688702e-02f, -2.35378444e-02f,
  -1.12326510e-01f, -1.51713520e-01f, -5.93946464e-02f, 1.16197728e-02f, 7.28320554e-02f, 9.18873996e-02f, 8.62123743e-02f, 1.64949410e-02f, -1.28812313e-01f, 6.59836922e-03f,
  2.19173461e-01f, 6.32605478e-02f, -4.28818603e-04f, -1.48644196e-02f, 1.04514584e-01f, -5.87575287e-02f, 4.17980775e-02f, 8.65062028e-02f, 1.59206726e-02f, 5.07433079e-02f,
  9.08533335e-02f, 7.38524571e-02f, 1.47582432e-02f, -3.89993265e-02f, -7.64709339e-03f, 8.08081403e-02f, -3.62161137e-02f, -1.13872541e-02f, -2.57052947e-02f, -1.36854842e-01f,
  -1.38891175e-01f, 1.74523350e-02f, 4.22671102e-02f, -5.27514778e-02f, 3.07245217e-02f, 1.97347384e-02f, -3.85817066e-02f, -1.80898141e-02f, 2.79782470e-02f, -8.26852024e-03f,
  -6.53479546e-02f, 8.02597683e-03f, 7.35578835e-02f, 6.26228154e-02f, 1.40776202e-01f, 1.29417419e-01f, 1.98304787e-01f, 9.43587273e-02f, 1.62307873e-01f, 2.91659921e-01f,
  2.04475254e-01f, 2.88232833e-01f, 1.98364630e-01f, 1.48218051e-01f, 1.97127432e-01f, 6.10807575e-02f, 1.54313445e-01f, 3.82478461e-02f, 1.15603462e-01f, 2.46842727e-01f,
  8.39173570e-02f, 9.73053649e-02f, 1.70449927e-01f, 1.35041565e-01f, 1.09186940e-01f, 1.07613899e-01f, 1.94143966e-01f, 1.39454812e-01f, 1.33648336e-01f, 2.40620807e-01f,
  4.21848185e-02f, 8.26433003e-02f, 7.46690184e-02f, -8.22067037e-02f, 1.11016206e-01f, 5.13982251e-02f, 8.37850869e-02f, 3.05106249e-02f, 8.49264264e-02f, 1.01331927e-01f,
  6.71386719e-02f, 3.00877336e-02f, 1.04313634e-01f, 1.15552776e-01f, 1.77099392e-01f, -3.51386480e-02f, -6.57218369e-03f, 1.19861830e-02f, -8.47492889e-02f, 5.31828729e-03f,
  -2.59526968e-02f, 2.68641450e-02f, 1.25894360e-02f, 6.31705076e-02f, 1.73640493e-02f, 7.89973661e-02f, 1.16399206e-01f, 6.73510954e-02f, -2.01956537e-02f, 7.38390014e-02f,
  -2.30472788e-01f, -7.29857609e-02f, 1.51354805e-01f, -1.50730601e-02f, -1.72104821e-01f, -2.90570050e-01f, -3.44457299e-01f, -1.76346570e-01f, -1.58577949e-01f, -5.11190039e-04f,
  -1.58688352e-01f, -4.88938950e-02f, 3.99116725e-02f, 2.24752259e-02f, 6.10197037e-02f, 1.13682993e-01f, 2.58723289e-01f, 2.12230861e-01f, 4.19500843e-02f, -1.76308855e-01f,
  1.47757664e-01f, 1.17244311e-01f, 9.61485133e-02f, 2.24706843e-01f, 5.54290153e-02f, 7.80774206e-02f, 2.97691196e-01f, 1.52864933e-01f, 2.46578589e-01f, 4.05159444e-01f,
  9.58806053e-02f, 1.29175439e-01f, -1.21784419e-01f, -4.11996478e-03f, -1.16507702e-01f, -8.37109908e-02f, -1.05234139e-01f, 4.19710539e-02f, -6.97006956e-02f, 2.92920917e-02f,
  -3.35633308e-02f, -1.00685835e-01f, -1.62542358e-01f, 1.15348220e-01f, -1.59143224e-01f, -4.58448976e-02f, 1.73914935e-02f, 9.04919952e-02f, 1.00011647e-01f, -1.22597821e-01f,
  -1.29617164e-02f, -9.95291993e-02f, 3.85876335e-02f, -1.89871565e-02f, 2.62104869e-02f, 1.70758486e-01f, -3.10052168e-02f, -1.40858935e-02f, 5.32025173e-02f, -6.41128123e-02f,
  1.47928089e-01f, 9.92474928e-02f, -1.38848692e-01f, 1.05037652e-02f, -1.03329252e-02f, -1.22163948e-02f, 6.70496970e-02f, -5.03599793e-02f, 1.08615858e-02f, 7.62642249e-02f,
  -6.40013963e-02f, -2.18945369e-02f, 2.97019277e-02f, -1.12586608e-02f, -4.14048769e-02f, -3.88997309e-02f, -1.24371648e-02f, 1.31038055e-01f, 8.40287283e-02f, 4.82123457e-02f,
  -1.79496058e-03f, -1.57309234e-01f, -3.38713499e-03f, 9.20873322e-03f, -1.11743309e-01f, 8.45149979e-02f, -6.33631423e-02f, -2.01598898e-01f, -5.69474436e-02f, 5.63353114e-02f,
  -1.27832144e-01f, 1.03429526e-01f, -1.68025404e-01f, -1.09413549e-01f, -1.66535713e-02f, 8.45243484e-02f, -1.02679078e-02f, 2.75696404e-02f, -1.91792957e-02f, -6.79486915e-02f,
  -1.02808535e-01f, -1.33454695e-01f, -1.89206582e-02f, 6.02032989e-02f, -1.31108999e-01f, -2.49641016e-02f, -1.15275420e-01f, 2.15937495e-02f, 1.76216550e-02f, -1.31966650e-01f,
  -1.82875291e-01f, -1.10655755e-01f, -8.97792131e-02f, -2.57230073e-01f, -7.86651447e-02f, -1.18389584e-01f, -7.35944510e-02f, -7.13727027e-02f, -1.45161070e-03f, -2.01527387e-01f,
  -1.17994122e-01f, -5.12089841e-02f, -3.65435809e-01f, -2.19572008e-01f, -1.65519267e-01f, 8.52072705e-03f, 2.53216863e-01f, 7.79232979e-02f, -7.31124207e-02f, 5.34741692e-02f,
  -3.84009890e-02f, -8.00798163e-02f, -9.14489403e-02f, -8.67442340e-02f, 1.22236043e-01f, -1.59851849e-01f, -1.49196833e-01f, -1.40897436e-02f, 1.25396371e-01f, 3.39039445e-01f,
  1.39929026e-01f, 1.34437636e-01f, 1.31186619e-01f, 6.52067363e-02f, -9.42570195e-02f, -1.56688094e-02f, -1.31895930e-01f, -1.82623953e-01f, -1.04592256e-01f, -2.98212796e-01f,
  -1.69605672e-01f, -2.47843161e-01f, 1.05038509e-02f, -1.12288125e-01f, 5.09489439e-02f, 9.73925963e-02f, 7.29223266e-02f, 4.22384143e-02f, 9.93957743e-02f, 2.02750713e-02f,
  -2.23074883e-01f, 1.49585426e-01f, -2.49744002e-02f, 6.90005869e-02f, -3.07203028e-02f, 4.65556607e-03f, -5.49766328e-03f, -2.47069038e-02f, -5.02692885e-04f, -8.09996426e-02f,
  -1.19517203e-02f, -5.39520048e-02f, -1.49166346e-01f, -6.95391148e-02f, -6.10352755e-02f, -1.03853745e-02f, -5.81095330e-02f, -9.12329629e-02f, -1.40297845e-01f, -8.11935514e-02f,
  1.19265700e-02f, 1.27084538e-01f, 2.32620850e-01f, 1.48366228e-01f, 1.55726343e-01f, 1.65421724e-01f, 6.32334873e-02f, 1.76231846e-01f, 2.43401691e-01f, 4.08240221e-02f,
  7.92482346e-02f, -1.28774885e-02f, -2.29856884e-03f, -5.23435920e-02f, -1.13962993e-01f, -3.60006690e-02f, -2.83442065e-02f, 5.19611575e-02f, 7.36166444e-03f, 1.32956356e-02f,
  -5.39260618e-02f, -8.71409774e-02f, -1.04986042e-01f, 7.65344724e-02f, -7.62780458e-02f, 4.10070177e-03f, -1.59974307e-01f, 1.90235209e-02f, -4.95316461e-02f, -1.10297069e-01f,
  2.03182667e-01f, -2.13441893e-01f, -9.76149440e-02f, -5.85579649e-02f, -1.63675368e-01f, -4.99396510e-02f, 3.05513386e-02f, 3.78000550e-02f, 3.68950404e-02f, 7.37797841e-02f,
  -1.07192034e-02f, 6.64074719e-02f, -3.12327631e-02f, 3.12447157e-02f, 3.22231837e-02f, 4.50300574e-02f, 3.70190367e-02f, -1.22377770e-02f, -2.58300770e-02f, 5.54270577e-03f,
  1.24000367e-02f, 1.58964515e-01f, 9.72405449e-02f, -1.25996932e-01f, -3.28268521e-02f, 7.77655318e-02f, 1.44689396e-01f, -8.01309943e-02f, -7.51746725e-03f, 1.98922694e-01f,
  -4.52783890e-02f, -3.39624166e-01f, 3.20661396e-01f, 1.99843884e-01f, 2.73805380e-01f, 2.13799328e-01f, 2.78798938e-01f, 1.87016740e-01f, 1.71605289e-01f, 6.69515878e-02f,
  -1.22285388e-01f, -1.40929250e-02f, -1.92943253e-02f, 1.95984007e-03f, -1.40219359e-02f, 1.50800690e-01f, 2.05757469e-01f, 1.06878407e-01f, 2.69518733e-01f, 1.86193809e-01f,
  6.94191307e-02f, 1.21470485e-02f, -1.10150933e-01f, 4.57662120e-02f, 1.15709238e-01f, 5.82112335e-02f, -7.09480345e-02f, -8.25669058e-03f, -2.78437976e-02f, 6.94967434e-02f,
  -3.21265534e-02f, -2.46588945e-01f, 1.29883572e-01f, -1.47024482e-01f, -9.64578316e-02f, -3.94438244e-02f, 2.13741641e-02f, -4.50940877e-02f, -9.38111469e-02f, -6.56088516e-02f,
  -9.57959816e-02f, -1.71228334e-01f, -2.59706639e-02f, -1.20590657e-01f, -4.45228443e-02f, -3.99723612e-02f, -6.39733151e-02f, -4.43403646e-02f, -8.94028470e-02f, 1.31772738e-03f,
  -9.92522389e-02f, -5.94977438e-02f, 4.39327443e-03f, -1.99406426e-02f, -7.58854151e-02f, -3.98379145e-03f, 2.58391863e-03f, -1.90247912e-02f, -6.05839305e-04f, -8.73717740e-02f,
  -2.08109822e-02f, 1.69932507e-02f, 9.35713947e-02f, -1.61460240e-03f, 1.22735023e-01f, 1.42891914e-01f, 1.50011942e-01f, 5.38921282e-02f, 1.49499804e-01f, 1.23263851e-01f,
  -3.11142001e-02f, 1.55133218e-01f, 7.67006353e-02f, 8.38480294e-02f, 6.91435039e-02f, -2.10935017e-03f, 2.45099701e-02f, -1.44965053e-01f, -1.40381707e-02f, 5.32000279e-03f,
  -4.52268030e-03f, 5.25179096e-02f, -7.43842721e-02f, 1.00957565e-01f, -8.11981931e-02f, -6.05341382e-02f, 5.17558903e-02f, -1.82025641e-01f, -8.17473382e-02f, 1.41130676e-02f,
  -9.43753049e-02f, -8.68264399e-03f, 1.69536784e-01f, -9.01900977e-02f, -1.69687197e-02f, -1.00497715e-01f, -3.64398248e-02f, -1.32500112e-01f, -5.37351295e-02f, -1.27747610e-01f,
  -5.78742139e-02f, -2.68478561e-02f, -9.08506066e-02f, 2.10521929e-02f, 1.98868647e-01f, -8.03451091e-02f, -1.05530202e-01f, 9.85716060e-02f, 4.17702971e-03f, 6.28102869e-02f,
  -8.00385475e-02f, -7.02683628e-03f, 1.71851829e-01f, 1.53346509e-01f, -1.07541857e-02f, 1.45197570e-01f, 8.38135257e-02f, 5.76439537e-02f, 2.76072021e-03f, 3.76148224e-02f,
  -2.16401383e-01f, -3.48520726e-01f, -2.67620623e-01f, -1.90536782e-01f, 7.34275626e-03f, -2.25697514e-02f, -2.86063313e-01f, 2.95921620e-02f, 6.23938404e-02f, -3.35928142e-01f,
  -1.80176601e-01f, 9.11527872e-02f, 3.22119147e-02f, -8.18127021e-03f, -8.60910565e-02f, -3.30073655e-01f, -2.28481069e-01f, 8.57510418e-02f, 2.20242724e-01f, 3.09571654e-01f,
  1.32257670e-01f, -6.47464097e-02f, 1.09690890e-01f, 6.96699098e-02f, 2.87527796e-02f, -3.56743559e-02f, -1.66443050e-01f, 3.26835848e-02f, 1.17863208e-01f, -8.34974274e-02f,
  -2.02143475e-01f, -1.33191198e-01f, 1.27485976e-01f, 8.86804145e-03f, -3.64212729e-02f, -6.01917356e-02f, -2.04281643e-01f, 1.41569432e-02f, -7.37687200e-02f, -9.91064310e-02f,
  -9.35563594e-02f, -4.62965146e-02f, -3.73366736e-02f, -2.16901600e-02f, -9.04253796e-02f, -3.44713517e-02f, -3.48096937e-02f, 1.05061546e-01f, 2.18749493e-02f, 3.07849534e-02f,
  1.86347682e-02f, 1.70460716e-01f, 1.70362014e-02f, 4.37938161e-02f, 1.30910337e-01f, 1.18136659e-01f, 1.35506675e-01f, 2.99089849e-01f, 1.92314789e-01f, -7.15466961e-02f,
  2.37447601e-02f, 3.06918975e-02f, 1.43040121e-01f, -4.60606739e-02f, -5.97925484e-02f, -3.67525667e-02f, -1.02178052e-01f, -1.02202855e-01f, -6.78649396e-02f, -4.13360186e-02f,
  -1.89465154e-02f, -7.53839836e-02f, -3.93950641e-02f, -1.83906630e-02f, 1.35126784e-01f, -2.02900991e-02f, 1.22732483e-02f, -6.09555393e-02f, 1.20696001e-01f, 8.13748538e-02f,
  1.19396634e-01f, 1.40910998e-01f, -1.34648726e-04f, 5.31194285e-02f, 1.69177383e-01f, 2.07440611e-02f, 1.18691027e-01f, 1.46868929e-01f, 1.54079646e-01f, 8.95385295e-02f,
  -3.26099396e-01f, -1.22554936e-02f, -1.49890453e-01f, 1.92802437e-02f, -1.01377435e-01f, 1.20036289e-01f, -2.31120989e-01f, -3.25025362e-03f, -1.25284001e-01f, -7.59437829e-02f,
  1.09716415e-01f, -1.49164692e-01f, -4.33978103e-02f, 2.41730027e-02f, -9.54827443e-02f, 2.68937722e-02f, -1.94095057e-02f, -1.05805419e-01f, 1.06847920e-02f, 1.11082666e-01f,
  3.07998843e-02f, 5.22897653e-02f, -6.83475658e-02f, -6.38005212e-02f, -9.18453734e-04f, 4.31582630e-02f, 1.05220027e-01f, 2.32843742e-01f, -5.47900818e-05f, -2.18298569e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  -5.74314296e-02f, 1.15665853e-01f, -6.66445494e-02f, 8.20884332e-02f, 4.68591191e-02f, 1.02786392e-01f, 1.92363039e-01f, 2.31117189e-01f, -4.53330344e-03f, 3.25373083e-01f,
  1.76631778e-01f, -3.07743579e-01f, -4.34757322e-02f, 2.01695412e-01f, 4.89794314e-02f, 5.04345037e-02f, 3.12374294e-01f, 1.92415956e-02f, 3.60639930e-01f, 6.55050725e-02f,
  8.32198784e-02f, -1.11491494e-01f, 1.19128086e-01f, 2.27677435e-01f, 9.11346450e-03f, 2.53159672e-01f, -9.04412419e-02f, 7.31051713e-02f, 1.64951891e-01f, 3.55606109e-01f,
  1.78407654e-01f, 2.89565742e-01f, 2.13966206e-01f, 1.51873499e-01f, 1.25334337e-01f, 4.78045978e-02f, 5.70608228e-02f, 1.59275174e-01f, 2.16569424e-01f, 2.70897508e-01f,
  1.63354389e-02f, 1.07719503e-01f, 5.37348203e-02f, 3.07261735e-01f, 1.83231175e-01f, 1.30217507e-01f, -1.17551833e-01f, -1.49154579e-02f, 2.00294316e-01f, 1.35505080e-01f,
  3.67203169e-02f, 1.03083096e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -7.03542978e-02f, 7.05242828e-02f, 2.31272932e-02f, -7.97652751e-02f, 6.44684136e-02f, -1.51196197e-01f, 2.68121716e-02f, 8.09923783e-02f, -2.25083977e-01f, -1.31906480e-01f,
  1.42301507e-02f, 2.80774683e-02f, 7.22803175e-02f, -8.49983692e-02f, 7.22576082e-02f, -2.14609772e-01f, -3.69839445e-02f, -7.78676420e-02f, 1.48112312e-01f, 7.92870596e-02f,
  -2.64465958e-01f, -1.80207685e-01f, -3.80777456e-02f, 1.33599788e-01f, 1.60278361e-02f, -8.41738731e-02f, -3.65469195e-02f, -1.27477959e-01f, -1.55019701e-01f, 6.35201633e-02f,
  -1.39625892e-01f, 7.90016800e-02f, 8.16902518e-02f, 2.85909418e-02f, 4.38606292e-02f, 2.34655533e-02f, 1.16178870e-01f, -2.12948304e-02f, -6.38232380e-02f, -6.72301054e-02f,
  3.92310381e-01f, -1.00722365e-01f, -1.13386502e-02f, -7.68057629e-02f, -3.79678719e-02f, -8.96580070e-02f, 2.59621143e-02f, 1.37014627e-01f, -1.98274314e-01f, 8.65695849e-02f,
  -2.99603306e-02f, 6.67901412e-02f, -8.20613801e-02f, -1.28677815e-01f, 4.79148217e-02f, 9.34413671e-02f, 1.38381392e-01f, -1.42222513e-02f, -1.89542100e-01f, 1.58424392e-01f,
  -1.01321883e-01f, -1.74070984e-01f, 2.13117689e-01f, 8.09071586e-02f, -6.92673922e-02f, -1.85050734e-03f, -6.83415383e-02f, 2.77131367e-02f, 7.60280639e-02f, -7.04336166e-02f,
  -6.76814839e-02f, 3.24137397e-02f, -6.69756234e-02f, -7.23822862e-02f, 1.21743076e-01f, 4.14068848e-02f, 1.18682645e-01f, -4.85986620e-02f, 2.02497527e-01f, -1.14938520e-01f,
  1.94385543e-01f, -1.57923579e-01f, -7.20815584e-02f, -2.37084012e-02f, 1.83786172e-02f, -5.04752547e-02f, 4.77143824e-02f, 1.62258878e-01f, 3.32823545e-01f, -4.41750884e-02f,
  1.76975980e-01f, -1.91371664e-01f, 1.26325965e-01f, 2.07963228e-01f, 4.77783196e-02f, 9.50141698e-02f, 1.34482116e-01f, 1.73364788e-01f, 2.49745846e-01f, -9.07181129e-02f,
  5.98113425e-02f, -3.03258281e-02f, 1.59357026e-01f, -1.02723517e-01f, 9.05538574e-02f, -1.53664779e-02f, -4.05417651e-01f, -2.00235501e-01f, -1.22451268e-01f, 2.76285075e-02f,
  -1.06858574e-01f, 5.96717522e-02f, -4.12019603e-02f, -3.66548806e-01f, -1.43781919e-02f, -3.71285856e-01f, 6.05118535e-02f, -1.12696834e-01f, 1.99207410e-01f, 1.97097465e-01f,
  2.34680567e-02f, -1.40262559e-01f, 2.40239147e-02f, -7.00788526e-03f, -1.68541595e-01f, 2.07727682e-02f, -1.70991793e-01f, -1.28819078e-01f, -1.20344564e-01f, -1.85653716e-02f,
  -6.12556785e-02f, -6.53165579e-02f, -1.26357347e-01f, 6.84801936e-02f, -4.97402735e-02f, -3.87122110e-02f, 7.90783092e-02f, -2.02356324e-01f, 3.56597751e-02f, 4.54230048e-02f,
  1.03336066e-01f, 1.52834639e-01f, 1.80437431e-01f, -1.46973908e-01f, -3.03531382e-02f, 4.07262519e-02f, -1.05430916e-01f, 4.90737222e-02f, 1.05652288e-01f, -8.83320346e-02f,
  -3.04632424e-03f, -1.37832180e-01f, 8.98265317e-02f, 1.06139399e-01f, -9.56961811e-02f, -9.48392004e-02f, 2.09090393e-03f, -3.99277359e-01f, -6.79161325e-02f, 2.07313802e-02f,
  1.84870407e-01f, 9.38811451e-02f, -1.37608096e-01f, 2.74179041e-01f, -1.72396526e-01f, -3.00992280e-02f, -1.61975548e-01f, 1.30310938e-01f, -3.63061279e-01f, -5.54214083e-02f,
  3.48327309e-01f, -9.80631784e-02f, -2.06829369e-01f, 2.22164422e-01f, -3.22163664e-03f, -1.20373040e-01f, 2.66306996e-01f, 1.14983536e-01f, 1.37234032e-01f, -2.07801238e-01f,
  -2.67192423e-02f, 1.86631024e-01f, -2.70532370e-01f, -1.40011981e-01f, -2.99133398e-02f, 3.27103063e-02f, -1.51629686e-01f, 6.39100820e-02f, -1.51243910e-01f, 7.63503537e-02f,
  1.33011535e-01f, -6.74226731e-02f, -2.23791823e-02f, -1.39793143e-01f, 4.89602275e-02f, -5.84266447e-02f, -1.63009521e-02f, 7.09364191e-02f, -8.07106793e-02f, 1.19015291e-01f,
  1.51142264e-02f, -5.27004199e-03f, 1.12225406e-01f, 2.72853635e-02f, 4.63030040e-02f, 2.97143400e-01f, 4.36394177e-02f, -7.18468651e-02f, 1.25722364e-01f, -2.26544254e-02f,
  -1.01548761e-01f, 1.66014761e-01f, 1.32577404e-01f, 2.50193387e-01f, 5.88089302e-02f, -1.15564741e-01f, 2.89153129e-01f, 8.52070898e-02f, -1.28309419e-02f, -6.03839085e-02f,
  1.02940395e-01f, -2.72392929e-01f, -3.31850909e-02f, 9.30142850e-02f, 1.01489514e-01f, 1.44765124e-01f, -9.24471319e-02f, 6.42944053e-02f, -1.16217412e-01f, -4.70948145e-02f,
  -1.39890328e-01f, 2.07743451e-01f, -2.65170962e-01f, 6.18873909e-02f, 1.74676273e-02f, -2.47648060e-01f, -2.51601726e-01f, 2.07557932e-01f, -1.52064702e-02f, 5.16945124e-03f,
  2.97549903e-01f, 9.09483060e-02f, 3.80346328e-01f, -1.42708838e-01f, -5.70225902e-03f, 1.17861684e-02f, -2.00357810e-01f, -1.46821603e-01f, 6.95500942e-03f, -1.12493828e-01f,
  6.26305025e-03f, -5.03348596e-02f, -2.41465494e-01f, 1.21741466e-01f, 2.68032216e-02f, -9.47462916e-02f, -1.75439082e-02f, 1.07521914e-01f, 1.02741808e-01f, -4.84331883e-02f,
  -1.42512202e-01f, 6.14330247e-02f, -1.17325433e-01f, -2.69417465e-02f, 1.24193609e-01f, -1.51105732e-01f, 6.87549338e-02f, -9.24289227e-02f, -8.30281824e-02f, -8.90565887e-02f,
  -3.62405926e-02f, -1.30875319e-01f, 1.10162022e-02f, -6.07036278e-02f, 8.27031117e-03f, 1.71968952e-01f, -2.43983701e-01f, -1.47228733e-01f, 7.82942921e-02f, -9.15764347e-02f,
  -1.49165448e-02f, 7.55211115e-02f, 1.30149007e-01f, -5.56591153e-02f, 9.68673676e-02f, -5.82038090e-02f, -1.92717984e-02f, -7.00194240e-02f, 3.15339454e-02f, 1.57949373e-01f,
  2.66255140e-01f, -3.42610735e-03f, 1.59404546e-01f, 8.95682815e-03f, -2.44840905e-01f, 9.17468071e-02f, 1.49757743e-01f, -7.14447498e-02f, 8.55043828e-02f, 2.98707426e-01f,
  2.47931615e-01f, -2.41715163e-02f, -1.64909169e-01f, 1.80799589e-02f, -1.33930117e-01f, 7.70810321e-02f, 4.31795716e-02f, 1.39327258e-01f, 1.53833749e-02f, 1.86379090e-01f,
  -1.66097194e-01f, 7.94777833e-03f, 1.25097781e-01f, -9.29551497e-02f, -1.29530743e-01f, 3.69823948e-02f, 7.61146769e-02f, -5.86123019e-02f, 1.95985749e-01f, -1.99672669e-01f,
  7.24517331e-02f, -5.31560667e-02f, 1.21231087e-01f, 5.37398644e-03f, 6.22200705e-02f, -2.86962390e-02f, 2.85661612e-02f, -3.85462828e-02f, 6.54571950e-02f, -1.38381556e-01f,
  3.02326560e-01f, 1.27630368e-01f, 3.40448059e-02f, 2.00128451e-01f, 1.90606952e-01f, -1.65165141e-01f, 1.96734697e-01f, -3.68237086e-02f, -8.20754021e-02f, -3.11925281e-02f,
  -3.15065607e-02f, -2.66792685e-01f, -5.74844219e-02f, -1.43499047e-01f, 3.91602851e-02f, -5.48919030e-02f, 1.91530719e-01f, -1.00383691e-01f, 1.92255020e-01f, -8.26322939e-03f,
  -3.87123525e-02f, -1.22181065e-01f, -9.33627710e-02f, 1.60730481e-01f, 1.89340755e-01f, -1.74972147e-01f, -4.91173863e-02f, 1.41837507e-01f, 2.90567186e-02f, -1.18006043e-01f,
  -9.52719077e-02f, -4.09353562e-02f, -1.50623530e-01f, 3.84939276e-02f, -4.11101468e-02f, 1.14209235e-01f, -1.57341406e-01f, -1.69974878e-01f, 3.99487466e-02f, 5.76220313e-03f,
  2.20597818e-01f, -1.22472145e-01f, 5.62080480e-02f, 3.01486030e-02f, 2.41081859e-03f, -2.45276913e-02f, 2.20473289e-01f, -7.97779188e-02f, 1.30868271e-01f, 1.02300517e-01f,
  -1.34157360e-01f, 1.18148729e-01f, 5.26152812e-02f, 4.57285047e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.63234016e-02f, -1.03209034e-01f, -1.31364301e-01f, -2.63416827e-01f, 1.29579931e-01f, -1.06308479e-02f, 4.11183573e-03f, 5.34900874e-02f, -4.26044762e-02f, 1.76620454e-01f,
  2.55875569e-02f, 1.37271032e-01f, -8.40151384e-02f, 1.33279189e-01f, -1.91726297e-01f, -1.21135935e-01f, -8.31642970e-02f, 9.45895314e-02f, 2.46034935e-02f, -1.39038041e-01f,
  9.23147276e-02f, -1.08623482e-01f, -8.71513113e-02f, 2.24178806e-01f, 1.67435855e-02f, -1.46939799e-01f, 8.30431804e-02f, -2.18181297e-01f, 1.40751213e-01f, -3.82184722e-02f,
  -9.40034539e-02f, -2.14231133e-01f, 4.75072302e-02f, -7.00987119e-04f, -3.20601434e-01f, -2.95751058e-02f, -9.77801979e-02f, -2.80542076e-02f, -2.35321410e-02f, -4.55860160e-02f,
  -1.54653057e-01f, -8.97998884e-02f, 2.03380529e-02f, -1.05872966e-01f, -1.36681423e-01f, -1.65172338e-01f, 7.72119239e-02f, -2.58679003e-01f, -3.05922806e-01f, 1.51832402e-01f,
  1.96321588e-02f, -4.51344997e-02f, -1.04791462e-01f, -7.49405399e-02f, 8.16737637e-02f, -5.71257398e-02f, 4.45668623e-02f, -2.46204183e-01f, -1.12538338e-01f, 1.08423032e-01f,
  -1.37862712e-01f, -6.63069170e-03f, 4.04397696e-02f, -1.56288087e-01f, -7.14095458e-02f, 1.70885831e-01f, 2.17927501e-01f, 1.71168640e-01f, 5.34426570e-02f, 3.11383815e-03f,
  -2.13865861e-02f, 1.34934634e-01f, -4.37505729e-02f, 1.75548598e-01f, 1.05252706e-01f, 1.38010651e-01f, 1.83051512e-01f, 1.74732566e-01f, 2.01456361e-02f, 6.95611909e-02f,
  -2.82130778e-01f, 4.25610282e-02f, 2.31984958e-01f, -9.94139165e-02f, 1.20312452e-01f, 9.94151756e-02f, 1.04243591e-01f, -7.51100332e-02f, -8.05535167e-02f, 1.16718657e-01f,
  -9.66638774e-02f, 8.05586725e-02f, 5.66095347e-03f, -1.07839480e-01f, -1.06973872e-02f, -1.43379122e-01f, -4.19526659e-02f, -4.16804515e-02f, -2.34176919e-01f, 2.71109104e-01f,
  -6.81707337e-02f, -1.25886634e-01f, -1.56842396e-01f, 6.82907403e-02f, -1.32307127e-01f, -1.93102434e-01f, 3.54573935e-01f, 1.16793532e-02f, 1.75065950e-01f, -3.89038958e-02f,
  1.97613925e-01f, 1.61016554e-01f, 8.98673236e-02f, 4.60932665e-02f, -1.78349808e-01f, 1.59953654e-01f, -1.98420867e-01f, 2.41186813e-01f, -2.33208656e-01f, 2.06675213e-02f,
  -1.74402058e-01f, -1.67474635e-02f, -1.30778119e-01f, -7.46907219e-02f, 2.48093396e-01f, -1.33873224e-01f, 2.20250078e-02f, 1.53400466e-01f, 1.52664527e-01f, -3.72095816e-02f,
  1.49222568e-01f, 9.18337107e-02f, 1.21253476e-01f, 1.73352718e-01f, 3.88156995e-02f, -8.94559771e-02f, -3.40660289e-02f, 3.28590125e-02f, 3.31522614e-01f, -1.81268200e-01f,
  -1.36905923e-01f, 1.52557597e-01f, 3.84165719e-02f, 7.36254826e-03f, 2.82433420e-01f, -9.62878615e-02f, -1.59573793e-01f, 1.64497897e-01f, -2.17153475e-01f, -2.91863322e-01f,
  2.88945138e-02f, 9.82108414e-02f, -5.97750247e-02f, -9.05077606e-02f, 1.71832535e-02f, 1.72724470e-01f, 1.19869880e-01f, 1.17841572e-01f, -4.50619012e-02f, 8.10163096e-02f,
  5.42217307e-02f, 1.07819485e-02f, 1.99692488e-01f, -3.10851157e-01f, -1.06120646e-01f, 1.73257932e-01f, 1.45277664e-01f, 2.69112010e-02f, -4.93686944e-02f, 2.39912327e-02f,
  -2.41976930e-03f, -2.35837027e-01f, -1.87615994e-02f, 2.25379989e-01f, -2.60213315e-01f, -4.33114655e-02f, 1.40118927e-01f, 1.37278408e-01f, 9.10597369e-02f, 1.65720358e-01f,
  7.01504126e-02f, 7.10145757e-02f, 5.28931841e-02f, 1.11875609e-01f, 2.22353041e-01f, 3.64985391e-02f, 3.11194267e-02f, 1.20299667e-01f, -1.36946458e-02f, 1.50771394e-01f,
  9.82997939e-02f, 2.59585101e-02f, 1.33329928e-02f, -2.59892885e-02f, 1.60008684e-01f, 5.18790595e-02f, -5.73628098e-02f, -3.00177280e-02f, 1.09294847e-01f, 9.71543789e-02f,
  7.93684088e-03f, 7.93972169e-04f, 5.96738607e-02f, 1.10219069e-01f, 1.47886083e-01f, -1.70176357e-01f, 3.33445311e-01f, -1.11811664e-02f, 2.07860872e-01f, 2.18456574e-02f,
  4.00388129e-02f, 7.87282363e-02f, 2.38426954e-01f, 3.54007781e-01f, 6.16441155e-03f, -1.43197015e-01f, 4.10277843e-01f, -2.51063287e-01f, -9.68947336e-02f, -3.33448470e-01f,
  -2.54149765e-01f, 1.29310071e-01f, 2.46647105e-01f, -1.18462376e-01f, 1.10683687e-01f, -4.91488501e-02f, -1.92354247e-02f, 2.33146742e-01f, 1.67951211e-01f, 5.54802306e-02f,
  1.00670546e-01f, 2.34277800e-01f, 1.53377429e-01f, -2.15334833e-01f, 1.99021712e-01f, -9.49101821e-02f, -1.62358731e-01f, -1.20031007e-01f, 1.61677897e-01f, 1.64677978e-01f,
  -2.32159048e-01f, -1.31938398e-01f, 6.65013120e-02f, -2.70144731e-01f, -1.99668501e-02f, 5.61403222e-02f, 2.84062982e-01f, 1.88125387e-01f, -1.57005891e-01f, 3.08399081e-01f,
  1.71342030e-01f, -2.37569120e-02f, 4.40402478e-02f, -6.60226739e-04f, 9.55719873e-02f, -7.81882778e-02f, 9.46532637e-02f, 8.27800855e-02f, -4.31903340e-02f, 8.63131881e-02f,
  1.74299031e-01f, 4.89840508e-02f, -2.02796221e-01f, -1.22187724e-02f, -9.28776899e-06f, -1.16736241e-01f, -3.19592506e-02f, -1.91295326e-01f, -1.27996847e-01f, -1.40383750e-01f,
  -1.38901457e-01f, -9.66855288e-02f, -3.36055197e-02f, -9.69706923e-02f, -4.22757380e-02f, 2.07720608e-01f, -2.34991238e-01f, 7.29066283e-02f, 3.66970785e-02f, -3.72017585e-02f,
  -1.24543026e-01f, 2.94573093e-03f, 2.77039371e-02f, -1.41865075e-01f, 8.59550983e-02f, 2.38461360e-01f, -6.81847660e-03f, 2.48237904e-02f, 1.71345800e-01f, 1.42486855e-01f,
  2.40268454e-01f, -4.03248817e-01f, 2.39367306e-01f, 8.94752145e-02f, 2.09342726e-02f, 1.43681407e-01f, 2.85273582e-01f, 2.85336584e-01f, -2.45756805e-01f, 2.69840151e-01f,
  6.91624656e-02f, 5.22287190e-02f, 1.88643277e-01f, 4.49517407e-02f, 1.21156551e-01f, 2.14544922e-01f, 2.14023650e-01f, 5.70989177e-02f, -4.75672856e-02f, -2.80768555e-02f,
  -5.73848337e-02f, -4.24764901e-02f, 1.44052878e-01f, -1.75915167e-01f, -2.53188517e-02f, 1.52969360e-01f, -1.29326776e-01f, 7.01174736e-02f, 1.07691819e-02f, -3.28798196e-04f,
  2.38059223e-01f, 1.12039492e-01f, -4.32063341e-02f, -9.84941944e-05f, -2.43983306e-02f, -6.63011372e-02f, -4.79614288e-02f, -2.07328908e-02f, 1.20869257e-01f, 4.03425321e-02f,
  1.31587952e-01f, 1.39481819e-03f, -7.90714938e-03f, 1.56466275e-01f, -1.32560693e-02f, 5.74575625e-02f, 1.70627847e-01f, 9.58708897e-02f, -3.04350942e-01f, 6.22817017e-02f,
  -8.44116732e-02f, -1.30808577e-01f, 1.74686000e-01f, -2.25968108e-01f, -1.79357026e-02f, 2.09887519e-01f, 1.18047364e-01f, 1.65447026e-01f, 7.83782899e-02f, -1.36440620e-01f,
  -5.16954139e-02f, 1.96776405e-01f, 1.15269661e-01f, 2.57737219e-01f, 1.37623236e-01f, -2.59086192e-01f, -1.19838893e-01f, 1.47343442e-01f, -1.56196952e-01f, 9.30571184e-02f,
  1.71426348e-02f, 1.51323974e-01f, -1.26367480e-01f, 1.28005266e-01f, 5.45960031e-02f, 3.07658464e-01f, -3.91195863e-01f, -3.32324281e-02f, 1.98206574e-01f, -1.38013750e-01f,
  2.10011870e-01f, -1.01310365e-01f, 1.13345154e-01f, -6.67762011e-02f, 4.50947993e-02f, 1.80726409e-01f, 6.45633740e-03f, -2.17458993e-01f, -1.73987411e-02f, -8.86814147e-02f,
  -1.10813556e-02f, 7.05001354e-02f, 3.89816472e-03f, 1.03130424e-03f, 1.00458942e-01f, -2.63709482e-03f, 1.09945148e-01f, 7.52208456e-02f, 1.97378814e-01f, 6.07983023e-02f,
  -5.20100966e-02f, -5.32701686e-02f, -1.16065539e-01f, 5.16262557e-03f, -6.59506917e-02f, -9.12231579e-02f, 1.28810614e-01f, -4.04290333e-02f, 8.77510011e-02f, -5.39272092e-03f,
  3.16551566e-01f, -5.01600131e-02f, -2.48806730e-01f, 9.88189653e-02f, 1.65172994e-01f, 9.29484591e-02f, 1.34248137e-01f, 1.19652756e-01f, 7.32921362e-02f, 1.63407564e-01f,
  8.89125243e-02f, 4.34205169e-03f, 8.07862654e-02f, -4.60539646e-02f, 1.38256818e-01f, 1.11631632e-01f, -3.75394821e-02f, 2.62218595e-01f, 1.36691377e-01f, -2.56091744e-01f,
  -2.06188455e-01f, 1.01817951e-01f, 8.34779292e-02f, 2.09215850e-01f, -8.96759108e-02f, 2.42149785e-01f, -1.01377480e-01f, -1.01064444e-01f, -4.68863845e-02f, 2.26720273e-01f,
  -6.51492849e-02f, -1.02615371e-01f, 2.37098575e-01f, -8.94179419e-02f, 8.17619562e-02f, -4.37769108e-02f, 5.44259325e-02f, -2.81962991e-01f, 7.74632767e-02f, 1.91577896e-01f,
  -2.02256754e-01f, 2.22333238e-01f, 2.63504833e-01f, -2.22761780e-01f, -6.09564483e-02f, -3.35997827e-02f, -3.80032160e-03f, 1.81016043e-01f, 1.61572285e-02f, 1.54397547e-01f,
  -3.14382426e-02f, 6.34344891e-02f, 1.11103840e-01f, 1.83611602e-01f, 1.53405786e-01f, -1.72097191e-01f, 5.39166778e-02f, 8.43984112e-02f, -4.51496728e-02f, -3.10393460e-02f,
  2.58673728e-01f, 2.80140698e-01f, 6.76726401e-02f, -7.53063010e-03f, -1.93637371e-01f, -4.25572619e-02f, -9.52349082e-02f, -1.26568070e-02f, 1.37816653e-01f, -1.53062150e-01f,
  -8.84496421e-02f, -1.58991793e-03f, 1.43096760e-01f, -2.38184690e-01f, 1.98713735e-01f, 9.04993340e-02f, 1.36871830e-01f, -1.68365344e-01f, 2.53023565e-01f, -8.75571370e-02f,
  -3.03889573e-01f, 2.62228195e-02f, 7.11932182e-02f, -3.73329176e-03f, -1.12132914e-01f, 8.47425610e-02f, 9.32504609e-02f, -1.87861830e-01f, -2.42616713e-01f, 9.48093385e-02f,
  1.78076103e-01f, -1.22131661e-01f, -2.61716396e-01f, -6.60094321e-02f, -1.45108312e-01f, -5.36838956e-02f, -5.97194284e-02f, 1.30353242e-01f, -5.82535528e-02f, 2.79229194e-01f,
  -1.37056828e-01f, 1.48837671e-01f, 1.26166806e-01f, 4.25614603e-02f, 1.20189652e-01f, 1.00507215e-01f, -7.76855722e-02f, 3.38273570e-02f, 1.31355688e-01f, 3.75654876e-01f,
  2.37069681e-01f, 4.84059425e-03f, -2.00288758e-01f, 1.44059330e-01f, -7.45547488e-02f, 4.55166809e-02f, 1.75848514e-01f, 2.63726022e-02f, 1.48346856e-01f, -1.39702678e-01f,
  -1.18991628e-01f, -1.21915616e-01f, 3.59189287e-02f, 1.58071034e-02f, 2.44584769e-01f, -2.63002068e-01f, 1.25752330e-01f, -5.76317199e-02f, 2.25759819e-02f, -1.19158685e-01f,
  2.34636873e-01f, -2.47258053e-04f, -1.78758040e-01f, -2.91142046e-01f, 1.04723908e-01f, -6.31072298e-02f, 1.42645776e-01f, -2.22692713e-02f, -2.37921581e-01f, -7.69434273e-02f,
  -1.71667784e-01f, 2.85122126e-01f, 5.18499613e-02f, 3.64638977e-02f, 1.10873722e-01f, -8.32280740e-02f, 1.04602769e-01f, 1.24708720e-01f, 3.07808489e-01f, -2.32867226e-01f,
  1.93510145e-01f, -3.08476806e-01f, 2.78358519e-01f, -4.62210849e-02f, 1.39364347e-01f, 2.72835135e-01f, 2.11211279e-01f, -3.48494291e-01f, 2.97756176e-02f, 1.94878712e-01f,
  -2.34949753e-01f, -2.98269838e-01f, -3.31181079e-01f, -2.00694263e-01f, -9.80357528e-02f, 2.32817963e-01f, 1.30359251e-02f, -3.27352099e-02f, -2.86593229e-01f, 1.67866036e-01f,
  -1.03685267e-01f, -4.65118028e-02f, 1.43268809e-01f, -1.68815196e-01f, 1.85415328e-01f, -2.26145953e-01f, 1.71130329e-01f, 4.92426082e-02f, -2.15773527e-02f, -5.49044348e-02f,
  -1.38053512e-02f, -4.54146005e-02f, -1.88196227e-01f, -3.33807319e-02f, 4.33847643e-02f, -5.77205904e-02f, -6.76465183e-02f, 4.88994196e-02f, -2.90784333e-02f, 8.58039111e-02f,
  2.24555641e-01f, -5.95192760e-02f, 3.03747714e-01f, -5.21182418e-02f, -5.79111613e-02f, 2.27449745e-01f, -2.28226334e-02f, -4.18991260e-02f, 1.24982223e-01f, 1.29281640e-01f,
  -1.64817661e-01f, 2.04973087e-01f, 6.85158148e-02f, 8.71399790e-02f, 1.73098639e-01f, -3.84336244e-03f, -3.71359549e-02f, 1.84959427e-01f, 1.89250559e-01f, 1.46723494e-01f,
  3.18317860e-02f, -1.83889732e-01f, -4.54943515e-02f, 1.30543746e-02f, 2.36432925e-01f, -2.58368813e-02f, -5.02294004e-02f, 2.13681564e-01f, -2.04049215e-01f, 3.71427834e-02f,
  1.63576335e-01f, 2.60336459e-01f, -5.93522452e-02f, 7.49782398e-02f, 2.36751661e-01f, -2.77551204e-01f, 9.87863168e-02f, -2.94836670e-01f, 1.93211585e-01f, -6.97652400e-02f,
  1.50081322e-01f, 9.22171697e-02f, -5.86362705e-02f, -9.04678479e-02f, 3.02651882e-01f, -1.48575492e-02f, 1.60931155e-01f, -5.97659610e-02f, -4.43137623e-02f, 1.96404144e-01f,
  4.88452353e-02f, 9.22600552e-02f, 6.36436194e-02f, -3.93936299e-02f, 4.44149412e-02f, 2.69572753e-02f, -2.33160242e-01f, -2.24176988e-01f, -6.47971034e-02f, -1.15870669e-01f,
  1.17955156e-01f, -5.10346815e-02f, 1.13138363e-01f, 8.07986874e-03f, 1.02112807e-01f, -6.94735050e-02f, 2.38590464e-01f, -1.42615005e-01f, -6.90653026e-02f, 1.07320100e-01f,
  1.63555089e-02f, -2.48003408e-01f, -5.97166903e-02f, 2.06399098e-01f, 6.09053746e-02f, 2.74341814e-02f, 4.30184752e-02f, -1.71163194e-02f, 8.23507011e-02f, 1.25069529e-01f,
  -2.06378728e-01f, 1.27018765e-01f, 1.62764564e-01f, 1.31386563e-01f, 1.82686865e-01f, -2.64689237e-01f, 1.17584288e-01f, -9.77002010e-02f, 1.36800185e-01f, 9.45205092e-02f,
  2.83009619e-01f, -5.82881905e-02f, -3.04789037e-01f, 1.73987389e-01f, 1.40643090e-01f, 2.66080320e-01f, -1.81962341e-01f, 1.27153754e-01f, 2.08587214e-01f, -9.78612676e-02f,
  6.54221922e-02f, -1.74441621e-01f, 2.40968332e-01f, -3.00808828e-02f, 1.11857645e-01f, -1.15645312e-01f, 1.56424239e-01f, -8.51513669e-02f, 1.21337570e-01f, -1.34392813e-01f,
  1.16379783e-01f, -1.34013951e-01f, 2.46736407e-02f, 2.89596021e-01f, -5.30249020e-03f, 1.18929699e-01f, 2.15183735e-01f, 1.63074937e-02f, -1.07869230e-01f, 8.65653604e-02f,
  -1.05815634e-01f, -2.26688758e-01f, -6.20598458e-02f, -1.68989561e-02f, 8.87121707e-02f, 1.16446637e-01f, 2.89242893e-01f, -4.59117852e-02f, 2.71420807e-01f, 1.77410662e-01f,
  -7.27566630e-02f, 1.31756738e-01f, 2.40895376e-01f, -2.63480414e-02f, -1.34103261e-02f, -8.16718638e-02f, 7.18171671e-02f, -9.39441100e-02f, 3.15818369e-01f, -9.98569801e-02f,
  9.59745944e-02f, -3.60007398e-03f, 4.51693032e-03f, -8.31605401e-03f, 2.82512698e-03f, -2.26398036e-02f, 6.00646585e-02f, -1.86464578e-01f, -1.15344889e-01f, 4.22929168e-01f,
  8.96998718e-02f, 7.28947204e-03f, -1.48287462e-03f, -2.43743077e-01f, -1.94374710e-01f, -8.63613859e-02f, 2.43607119e-01f, -1.07043386e-01f, -2.33018282e-03f, -1.08668938e-01f,
  -2.12953016e-01f, 5.05469404e-02f, -7.66484961e-02f, -2.01437384e-01f, -7.79596493e-02f, -1.49843991e-01f, -1.25661775e-01f, 2.02087417e-01f, -9.20739546e-02f, 8.58706385e-02f,
  -1.23454213e-01f, 3.98822241e-02f, -3.75615433e-02f, 7.14298617e-03f, 1.90301135e-01f, -1.95604607e-01f, -4.28491943e-02f, -5.27682854e-03f, 1.34433120e-01f, -1.58164665e-01f,
  -9.84099507e-02f, -1.68936960e-02f, -9.94119123e-02f, -1.09852560e-01f, 5.77280894e-02f, -1.38441503e-01f, 1.32673100e-01f, -1.57589749e-01f, 1.28447443e-01f, 4.96272258e-02f,
  -1.57476276e-01f, 2.70868272e-01f, 1.32384315e-01f, -9.47800353e-02f, 1.31639972e-01f, -5.43150958e-03f, -2.59288192e-01f, 1.25791594e-01f, -4.58030552e-02f, -4.99964878e-02f,
  1.97622538e-01f, -9.28526968e-02f, -2.44983602e-02f, -4.82517518e-02f, 2.38294862e-02f, 8.33689347e-02f, 6.48348182e-02f, -7.20679462e-02f, -1.53060883e-01f, 1.39754176e-01f,
  6.95912493e-03f, 9.10504386e-02f, -5.23359515e-02f, -3.05639386e-01f, -3.34188640e-01f, -2.02199202e-02f, 1.11254402e-01f, 2.26552874e-01f, -1.75424680e-01f, 1.26964748e-01f,
  -8.00329968e-02f, 8.85284543e-02f, -2.54215277e-03f, 2.78131783e-01f, -1.45587146e-01f, 5.08983694e-02f, 3.42079133e-01f, -1.13382973e-01f, 2.78186291e-01f, -1.72976717e-01f,
  1.66912943e-01f, 6.89157769e-02f, -7.21698776e-02f, -2.37067342e-01f, 5.86194173e-02f, -2.42439401e-03f, 1.14899442e-01f, 1.44555583e-04f, -1.14787027e-01f, 1.00911230e-01f,
  3.52272168e-02f, 2.80261099e-01f, -2.44528800e-02f, 9.49983001e-02f, 1.27091783e-03f, 6.02474175e-02f, 4.94620856e-03f, 3.96143552e-03f, -1.07197337e-01f, 1.66879505e-01f,
  -5.04798479e-02f, -1.61529686e-02f, 1.23555847e-02f, -1.09740600e-01f, -1.22954451e-01f, 1.82092056e-01f, -2.60262847e-01f, 2.60828376e-01f, -1.49866864e-02f, 1.80560470e-01f,
  1.16413601e-01f, 2.87335943e-02f, -4.26342487e-02f, 2.06708219e-02f, -5.13643995e-02f, 9.92241800e-02f, -1.23569340e-01f, 1.27049744e-01f, -2.09471975e-02f, 2.74605960e-01f,
  -9.40737650e-02f, 6.00072322e-03f, 2.63163596e-01f, -1.05238361e-02f, -8.53454843e-02f, -1.37183592e-01f, 1.69044033e-01f, 4.57585789e-02f, -2.23983735e-01f, -4.21724021e-02f,
  6.09067045e-02f, 3.19652334e-02f, -1.19872771e-01f, -6.30385280e-02f, 1.30438015e-01f, -3.45095783e-01f, 8.81207362e-02f, -1.03692934e-01f, -7.68488273e-02f, -1.64265320e-01f,
  -1.61024392e-01f, -1.74265698e-01f, -1.15928806e-01f, -2.30390579e-02f, 3.51698212e-02f, 8.05135667e-02f, 1.55813172e-01f, 2.71424890e-01f, 2.73156930e-02f, 3.71897519e-01f,
  7.21628740e-02f, 1.22903474e-01f, 1.94056422e-01f, 4.24003638e-02f, -1.38581708e-01f, -1.51969522e-01f, 1.12852026e-02f, 1.16111562e-01f, 2.37410460e-02f, 4.16061282e-02f,
  1.75536126e-01f, -4.23293486e-02f, -1.29030064e-01f, -2.21669897e-01f, -1.19109616e-01f, -7.11543933e-02f, 2.18729332e-01f, 1.25513613e-01f, 9.47719291e-02f, 1.08563088e-01f,
  2.39278540e-01f, 5.72796026e-03f, 4.46089506e-02f, 4.59261984e-02f, 8.04375410e-02f, -5.85754775e-02f, 8.90245661e-02f, -4.82551716e-02f, -8.84209946e-02f, 1.03176601e-01f,
  4.71601449e-02f, 1.51567888e-02f, 3.75560112e-02f, 2.71560609e-01f, -1.96424142e-01f, 8.44603498e-03f, -2.55329281e-01f, 9.48954523e-02f, -4.04746644e-02f, -1.37675598e-01f,
  9.61321369e-02f, 6.10803179e-02f, 1.52822539e-01f, 5.08061573e-02f, 2.71542311e-01f, -9.33704078e-02f, 8.31989869e-02f, -2.91153882e-02f, 2.22530570e-02f, -1.12899527e-01f,
  3.82223278e-02f, -7.57037476e-02f, -2.43533000e-01f, -7.72205973e-03f, 1.81678794e-02f, -3.10501158e-01f, 2.54352521e-02f, -8.78810361e-02f, -7.34658316e-02f, 2.03507096e-01f,
  2.64546722e-01f, 3.06605585e-02f, -1.40032843e-01f, 2.89518923e-01f, 1.81380942e-01f, 2.48090159e-02f, -9.21760406e-03f, 7.40220211e-03f, -4.04760707e-03f, 2.19641432e-01f,
  1.35085315e-01f, -1.44152902e-02f, 6.36552721e-02f, -7.61247203e-02f, 7.23030791e-02f, -4.07842249e-02f, -4.81898971e-02f, -2.99387239e-02f, -6.76545724e-02f, -3.31338234e-02f,
  1.08587272e-01f, -1.54435607e-02f, 1.16041303e-01f, -2.67995626e-01f, 1.99953303e-01f, 1.11529961e-01f, 1.88848957e-01f, -2.57818098e-03f, -1.00857608e-01f, 1.76771566e-01f,
  9.06448364e-02f, 4.99062426e-02f, -4.01271433e-02f, -1.08039655e-01f, 2.96540886e-01f, -3.31796184e-02f, -1.39577284e-01f, -8.01943839e-02f, -2.15030372e-01f, 7.46557862e-02f,
  -1.62765104e-02f, -1.45592093e-01f, 1.06407054e-01f, -4.40434590e-02f, 3.26921209e-03f, -1.63268894e-02f, 1.83409125e-01f, 1.33440316e-01f, -1.61058959e-02f, 2.61585355e-01f,
  4.65275533e-03f, -9.94700845e-03f, -1.87506944e-01f, -2.02059071e-03f, -2.22658515e-01f, -1.96813613e-01f, 3.64253484e-02f, 3.73530984e-02f, -8.19655731e-02f, 7.66141862e-02f,
  1.24999695e-01f, -2.85093099e-01f, 5.42488229e-03f, -7.95840397e-02f, 9.93860736e-02f, 7.54000172e-02f, -1.43198222e-01f, -8.35920572e-02f, 2.04326302e-01f, -8.44904929e-02f,
  -2.18090758e-01f, -2.47419342e-01f, -1.00094497e-01f, -1.97596654e-01f, 2.22205892e-01f, 1.39045253e-01f, 1.46883309e-01f, 7.44688511e-02f, 6.52271658e-02f, 9.89238694e-02f,
  3.12694237e-02f, 1.24008127e-01f, 6.44233525e-02f, 9.90268439e-02f, -3.38167772e-02f, -1.20800354e-01f, -5.36301658e-02f, -8.81271362e-02f, 7.81345889e-02f, 1.34554729e-01f,
  1.19049169e-01f, 4.18417528e-02f, -2.95631379e-01f, -3.18739451e-02f, 1.74195487e-02f, 1.19319081e-01f, 3.43144848e-03f, 1.43809259e-01f, 7.58916810e-02f, -2.90547125e-02f,
  9.48766172e-02f, 1.98635235e-01f, 1.35686874e-01f, 1.53211847e-01f, 1.41288042e-01f, 7.29925260e-02f, -2.53531843e-01f, 7.98842236e-02f, 1.82082236e-01f, -3.07464063e-01f,
  -8.39096159e-02f, 1.86220616e-01f, 7.06806034e-02f, 6.20937860e-03f, 1.07865278e-02f, 1.36065837e-02f, -2.56877810e-01f, -1.33303002e-01f, -1.25051066e-01f, 1.71183407e-01f,
  -7.01281130e-02f, -8.87385383e-02f, 1.06185786e-01f, -1.01991789e-02f, 1.75712362e-01f, 6.66776001e-02f, 9.52194333e-02f, -9.65697840e-02f, 1.16199709e-01f, 1.89940169e-01f,
  1.15915081e-02f, 2.69436300e-01f, 1.02393448e-01f, -2.05071390e-01f, -1.32908583e-01f, 1.36771321e-01f, -3.50126252e-02f, 8.30024928e-02f, -3.80680561e-02f, -1.39398202e-01f,
  -3.58535051e-02f, 5.06821647e-02f, -4.90236282e-02f, -6.06136397e-02f, -1.56765282e-01f, -2.29415506e-01f, -1.11806825e-01f, 7.29560927e-02f, 4.93287593e-02f, -1.62472457e-01f,
  -4.19257343e-01f, 1.16776347e-01f, -3.61179739e-01f, 1.31474271e-01f, -1.90302819e-01f, 1.54747769e-01f, -2.99374829e-03f, -1.17069915e-01f, 2.29268000e-01f, 9.19777080e-02f,
  -1.75381795e-01f, -7.27789626e-02f, 1.51443765e-01f, -2.15984341e-02f, -1.10444993e-01f, 3.61484498e-01f, -1.89291477e-01f, 2.62082338e-01f, -3.32260430e-02f, -7.80487247e-03f,
  -1.53722139e-02f, -2.64776230e-01f, 7.04014301e-02f, -1.02739990e-01f, -1.35128781e-01f, -8.44401494e-02f, 1.84982479e-01f, 9.27697718e-02f, -5.55940531e-02f, -5.13511784e-02f,
  1.68293417e-01f, -2.02464741e-02f, -2.29949415e-01f, -1.02037460e-01f, 1.34951860e-01f, -2.79877365e-01f, 5.33082150e-02f, -1.36420846e-01f, -1.56545863e-01f, 6.39898852e-02f,
  8.02327469e-02f, 2.98636973e-01f, 1.29750296e-01f, 9.92921181e-03f, -1.61581822e-02f, 3.59314948e-01f, 1.47376835e-01f, 8.88067782e-02f, -3.00756358e-02f, 9.46659073e-02f,
  1.08256593e-01f, -6.64429665e-02f, -8.19922015e-02f, 2.06040163e-02f, 1.96224093e-01f, 2.20163211e-01f, 8.03576633e-02f, 1.69292226e-01f, 1.36772007e-01f, 1.21786222e-01f,
  3.56118307e-02f, 1.76696986e-01f, 1.18107826e-01f, -1.57993719e-01f, 2.24755242e-01f, 2.46229082e-01f, 1.03573583e-01f, -1.40337139e-01f, -2.30370790e-01f, -3.11607290e-02f,
  2.73017377e-01f, -6.33687153e-02f, -1.06399164e-01f, -7.74547011e-02f, -4.80453409e-02f, -3.12993646e-01f, 7.35326260e-02f, -1.17473500e-02f, 1.07408784e-01f, -1.16561458e-01f,
  1.63593158e-01f, -1.60029114e-04f, 2.80203581e-01f, -9.31081921e-02f, -4.51392710e-01f, -3.22619155e-02f, 2.16634005e-01f, 3.48361284e-01f, 2.44194910e-01f, 5.94559908e-02f,
  -9.93663371e-02f, -6.53097183e-02f, 2.32775584e-01f, 5.31419106e-02f, 2.15219274e-01f, -2.18937348e-04f, 2.21657543e-03f, -2.76822243e-02f, -5.83190396e-02f, -7.13630160e-03f,
  -1.79304615e-01f, -1.04796022e-01f, -2.10466251e-01f, 2.56583422e-01f, -1.59727618e-01f, 3.49935830e-01f, -5.05004823e-02f, 2.14271128e-01f, 9.98903140e-02f, 1.93545043e-01f,
  -1.52450904e-01f, -5.20368703e-02f, 2.01964639e-02f, 7.73112252e-02f, 1.72007024e-01f, -2.49896228e-01f, -1.31554091e-02f, 5.87525517e-02f, -6.68687746e-03f, -8.96551982e-02f,
  6.17868043e-02f, -2.98723974e-03f, -7.40848109e-02f, -1.82586268e-01f, -1.41406596e-01f, -4.96822037e-02f, -7.20096901e-02f, 5.71098104e-02f, 1.10068135e-01f, -2.92178154e-01f,
  1.12235308e-01f, 5.37871048e-02f, -6.63053170e-02f, 6.56531379e-02f, 7.03232214e-02f, -1.36278734e-01f, 2.53038248e-03f, 1.85792536e-01f, -2.31212944e-01f, -1.10513970e-01f,
  -1.74933061e-01f, -7.21918568e-02f, 1.21526934e-01f, -1.10561714e-01f, -3.29284430e-01f, 3.81867439e-01f, 1.26516437e-02f, 1.81201275e-03f, -8.41742977e-02f, -1.39271721e-01f,
  1.57966003e-01f, 4.85060290e-02f, 4.03955698e-01f, 1.50606215e-01f, 1.28492787e-01f, -2.40996331e-01f, 2.90071964e-01f, -4.50243540e-02f, -2.71599621e-01f, -1.10233083e-01f,
  1.41309381e-01f, -2.46973604e-01f, 2.14599445e-02f, 1.71336561e-01f, -1.58883139e-01f, 2.06077639e-02f, -2.24101111e-01f, 2.36321017e-02f, 1.30660966e-01f, -1.75297767e-01f,
  2.63285369e-01f, -1.33612640e-02f, -9.21202675e-02f, 3.05364490e-01f, 2.17792377e-01f, 2.13638976e-01f, -8.08635727e-02f, -3.31758827e-01f, -1.01987690e-01f, -1.70642380e-02f,
  9.39410627e-02f, 2.04503536e-02f, 2.18024299e-01f, 7.88373500e-02f, 1.28083140e-01f, 2.21122667e-01f, -1.00981332e-01f, 1.51430070e-01f, -9.68469679e-02f, 2.95491636e-01f,
  -2.73351818e-01f, -7.24185109e-02f, -3.05748843e-02f, -2.05861777e-02f, -7.38522485e-02f, 2.49701589e-01f, -1.90706179e-01f, 2.52262443e-01f, 2.13228703e-01f, 5.34400679e-02f,
  1.15774609e-01f, 3.75930130e-01f, 6.64498890e-03f, -1.06201097e-01f, -1.17344506e-01f, 2.01619849e-01f, -3.48108411e-02f, 8.35980400e-02f, -4.13665771e-02f, -8.03372823e-03f,
  2.43110299e-01f, 1.52544826e-02f, -3.25486720e-01f, -1.93137810e-01f, -1.66966587e-01f, 2.63126463e-01f, -5.66207692e-02f, -8.14330280e-02f, 1.79616939e-02f, 1.98039174e-01f,
  1.67868808e-01f, 1.07966766e-01f, 1.82236552e-01f, 2.98088491e-01f, 2.14524329e-01f, -1.27945110e-01f, 4.74017352e-01f, 8.30295235e-02f, 2.68529560e-02f, -2.88352966e-02f,
  1.06247798e-01f, 1.05378270e-01f, -2.33905818e-02f, -7.96053559e-02f, 3.62919807e-03f, 1.67301610e-01f, -7.28329122e-02f, 8.17999542e-02f, 2.12357026e-02f, 3.32558192e-02f,
  2.73709595e-01f, -6.94881901e-02f, -2.02797607e-01f, 1.27233076e-03f, 1.80028722e-01f, -1.01686463e-01f, 1.34528413e-01f, 1.85173884e-01f, -1.15099631e-01f, 2.47735441e-01f,
  1.56116143e-01f, 5.84369749e-02f, -1.76468641e-02f, -7.32311159e-02f, -1.89128578e-01f, 5.12094889e-03f, -6.31778762e-02f, 8.43175426e-02f, -1.54037371e-01f, 1.56294137e-01f,
  -2.54855454e-01f, 1.04738280e-01f, 2.62643844e-01f, -2.96038464e-02f, 9.54235718e-02f, -1.00385398e-01f, -7.24711567e-02f, 3.63011770e-02f, 1.01342008e-01f, 4.05273493e-03f,
  -5.43830730e-02f, 1.75482526e-01f, -4.28849123e-02f, -1.90390449e-03f, -6.41000196e-02f, 2.19479539e-02f, 1.84960440e-02f, -1.74579173e-01f, -1.12041272e-01f, 2.30063275e-01f,
  1.42046334e-02f, -9.36874375e-02f, 5.04915491e-02f, -1.77742392e-01f, -1.24311984e-01f, -1.82668343e-01f, 3.64019632e-01f, 1.33767366e-01f, 6.07681386e-02f, -5.27343573e-03f,
  8.42932463e-02f, -1.38984904e-01f, 6.17881753e-02f, -3.22685331e-01f, -2.16886759e-01f, 6.78647682e-02f, -1.78490076e-02f, 2.44646803e-01f, -3.52442190e-02f, 2.53335312e-02f,
  -1.82873860e-01f, 1.01441778e-01f, 8.59824754e-03f, 1.27115801e-01f, 2.65612453e-01f, 1.77630018e-02f, -6.06061593e-02f, 1.30869806e-01f, 2.12263003e-01f, 5.02665490e-02f,
  2.06000492e-01f, 2.07845375e-01f, 1.89703375e-01f, -5.09978607e-02f, 1.65338814e-01f, 1.36771038e-01f, 1.25895500e-01f, 1.48282629e-02f, -1.65188145e-02f, -5.48851900e-02f,
  -1.61350995e-01f, -4.58157770e-02f, -9.48162004e-02f, -1.16373435e-01f, 2.22002238e-01f, -3.18871513e-02f, -3.01123500e-01f, 8.87744874e-02f, -2.65246779e-02f, -3.91433612e-02f,
  1.17466658e-01f, 1.73346415e-01f, -1.26211971e-01f, 1.93168819e-01f, 1.32140487e-01f, 3.89370285e-02f, 7.59150311e-02f, -5.51410243e-02f, 9.99640524e-02f, 3.13306972e-02f,
  1.48763508e-01f, 2.72994429e-01f, 9.27806366e-03f, -3.61674696e-01f, -9.35712364e-03f, 1.72442898e-01f, 8.78681615e-02f, 2.47892082e-01f, 2.00109500e-02f, 1.97455674e-01f,
  -3.39062423e-01f, 4.42810319e-02f, 1.13816932e-02f, 1.82020083e-01f, -2.12672666e-01f, 9.21914205e-02f, -3.93885411e-02f, 2.16163784e-01f, 2.10649341e-01f, 1.92295462e-01f,
  1.75883040e-01f, -1.61162466e-01f, 4.26450595e-02f, -1.23006791e-01f, 2.92881906e-01f, -1.97090849e-01f, -4.19303775e-02f, -1.13097608e-01f, -1.89297888e-02f, 1.66618422e-01f,
  -7.01507851e-02f, 2.65490487e-02f, -1.86269283e-02f, 2.01894566e-01f, 1.80904433e-01f, 1.60390094e-01f, -5.72699420e-02f, 1.26280591e-01f, -4.10950221e-02f, 2.48357579e-01f,
  -7.56480694e-02f, 2.81464290e-02f, -8.44587535e-02f, 7.60231614e-02f, -2.01450363e-01f, -1.78696528e-01f, -7.64323547e-02f, -3.73564094e-01f, -2.06420198e-02f, -7.88541958e-02f,
  -1.50465816e-01f, 1.16528332e-01f, -2.13693455e-02f, 3.24957579e-01f, 9.53208134e-02f, -1.29645675e-01f, -8.21751505e-02f, -1.66285560e-01f, 1.31903559e-01f, -3.47297668e-01f,
  -1.18948504e-01f, 1.87697083e-01f, -4.71070021e-01f, -2.56609201e-01f, 3.31975929e-02f, -1.04355156e-01f, -2.32001722e-01f, -1.28390208e-01f, 1.15382574e-01f, 2.02569246e-01f,
  -2.02714264e-01f, 3.35666358e-01f, 2.63620377e-01f, -2.12986946e-01f, 3.18261266e-01f, 1.76194191e-01f, -8.03419724e-02f, -1.71230122e-01f, 4.94544119e-01f, 1.52865574e-01f,
  -1.16461083e-01f, 1.61889017e-01f, 1.88282654e-01f, 2.25999057e-01f, -2.48622537e-01f, 7.49177719e-03f, -2.10352257e-01f, -3.71593088e-01f, 2.56546080e-01f, -8.55558440e-02f,
  -8.46995786e-02f, 2.02476561e-01f, -2.98076458e-02f, 1.08238742e-01f, 2.42001265e-01f, 1.42321307e-02f, 2.79728681e-01f, -1.11340150e-01f, 2.10042313e-01f, -2.51561869e-02f,
  7.83131123e-02f, 1.75363272e-01f, 1.50990635e-01f, 5.34263775e-02f, 7.63567239e-02f, 1.19900003e-01f, -1.51007667e-01f, 1.20876655e-01f, -1.32453576e-01f, -9.94791090e-02f,
  -7.98716918e-02f, 1.59556046e-01f, -1.04051195e-01f, 1.93701386e-01f, 7.38173574e-02f, 8.13713744e-02f, 2.44702578e-01f, 1.48497254e-01f, 3.50091085e-02f, 5.86407147e-02f,
  -2.17004538e-01f, 2.00436428e-01f, -6.95765193e-04f, 1.10289022e-01f, 1.17642224e-01f, -1.19173519e-01f, -6.52776435e-02f, -1.71467751e-01f, -1.14625826e-01f, 7.48056732e-03f,
  -2.27277070e-01f, 1.95381731e-01f, -3.10572177e-01f, 1.65457562e-01f, -2.40493968e-01f, 1.89622790e-01f, -9.04068202e-02f, -4.91871238e-02f, 1.82635993e-01f, 3.46616171e-02f,
  1.55516982e-01f, -8.60797241e-02f, 1.70076177e-01f, -1.03664003e-01f, 1.33680224e-01f, 2.37430856e-01f, 1.55377164e-01f, 2.84313112e-01f, -2.36913353e-01f, 8.74217227e-03f,
  -2.80964404e-01f, -2.33626217e-01f, -3.64241228e-02f, -1.12085089e-01f, 1.73267331e-02f, 3.30310203e-02f, 1.84576839e-01f, 2.17743088e-02f, -1.72747150e-02f, 3.24898928e-01f,
  1.38145372e-01f, 8.82019177e-02f, 2.12820143e-01f, -4.70152125e-02f, 1.30506381e-02f, 1.02039844e-01f, -1.14118919e-01f, 2.39210919e-01f, -7.31299743e-02f, -2.26169959e-01f,
  -2.68701967e-02f, -4.67807800e-02f, 8.26833546e-02f, -2.52305508e-01f, 1.52684003e-01f, -9.90772434e-03f, 1.87634274e-01f, 4.93563935e-02f, 1.38853505e-01f, 1.80584297e-01f,
  -1.87759772e-01f, -1.31151481e-02f, 7.93902799e-02f, -1.74856797e-01f, 3.58434319e-02f, 1.57563329e-01f, 7.59819895e-02f, -1.04061611e-01f, -6.63339393e-03f, 1.10186771e-01f,
  -1.45046130e-01f, 9.39260721e-02f, 2.25986451e-01f, -4.03925627e-02f, 3.22831511e-01f, 1.29835844e-01f, 2.96868086e-01f, -6.07210174e-02f, -1.13471150e-01f, 1.95124820e-01f,
  4.40608025e-01f, 1.58454657e-01f, -1.09353833e-01f, -5.42952400e-03f, 2.92691663e-02f, 1.97494566e-01f, -5.29593825e-02f, 1.67206615e-01f, -2.90695876e-02f, 1.58210382e-01f,
  3.32480893e-02f, -3.09732612e-02f, 7.12661371e-02f, -1.50484651e-01f, 1.43953860e-01f, 1.99384823e-01f, 1.61180764e-01f, -1.12968482e-01f, 4.90577035e-02f, 6.40835837e-02f,
  -1.07677490e-01f, -1.17449798e-01f, 1.50897294e-01f, -4.31898087e-02f, 1.37564719e-01f, 2.88746357e-01f, 2.61410512e-02f, 1.42194510e-01f, -2.92449277e-02f, 1.59945879e-02f,
  1.39116973e-01f, -2.58993846e-03f, 1.64054297e-02f, 2.22839452e-02f, 1.43200636e-01f, -1.70087069e-01f, 1.24385051e-01f, -1.56000450e-01f, 1.22617036e-01f, -1.34694502e-01f,
  8.28290805e-02f, 7.39192441e-02f, -5.73113328e-03f, -2.85395126e-05f, -2.41397977e-01f, -3.36434901e-01f, -2.39080563e-03f, -7.96559379e-02f, -8.13753083e-02f, 9.64522362e-02f,
  1.70275718e-01f, -1.93985239e-01f, 2.40649670e-01f, -1.49986178e-01f, 4.79511358e-02f, -2.55737938e-02f, -6.10777512e-02f, -8.73494428e-03f, 1.09184675e-01f, 1.48920387e-01f,
  -6.68780922e-05f, 2.19463676e-01f, -3.04524899e-01f, -2.38201231e-01f, -3.98858115e-02f, 3.11789989e-01f, -1.32865235e-01f, -1.43091395e-01f, -3.46440375e-02f, 2.07975388e-01f,
  -4.27337617e-01f, -1.84915423e-01f, 9.17254984e-02f, 4.00553733e-01f, 1.20466173e-01f, 2.31537804e-01f, -1.02270655e-01f, 1.44039452e-01f, -1.20957129e-01f, 1.44291952e-01f,
  2.63903081e-01f, -1.33102104e-01f, -1.87985286e-01f, -7.21566081e-02f, 6.41347468e-02f, 1.54041439e-01f, 3.17164540e-01f, -8.63863304e-02f, 1.96616367e-01f, -7.64055876e-03f,
  -6.98400959e-02f, 2.02553552e-02f, 1.33768991e-01f, -3.00753769e-03f, -1.13747388e-01f, 1.51570439e-01f, -3.87117639e-02f, -3.92651148e-02f, -1.96979150e-01f, 8.70770961e-02f,
  -2.95451917e-02f, -2.60851651e-01f, -1.66759133e-01f, -1.72249466e-01f, 8.31455886e-02f, -1.67324588e-01f, -9.67908427e-02f, 1.71444178e-01f, -4.64082621e-02f, 2.95598865e-01f,
  -9.39210225e-03f, -6.71444312e-02f, -2.41211742e-01f, -9.80789289e-02f, 1.56564359e-02f, -1.36251360e-01f, -1.38494208e-01f, 2.26394549e-01f, -3.98902774e-01f, -2.07367480e-01f,
  2.85183731e-02f, 3.51086557e-02f, -2.66630836e-02f, -3.01143914e-01f, 1.17578566e-01f, 4.19298001e-03f, 6.93750679e-02f, 2.45987013e-01f, 4.26197022e-01f, -2.59580165e-01f,
  1.35058220e-02f, 3.14172000e-01f, 2.17598617e-01f, -1.46907911e-01f, 4.19546813e-01f, 8.04034844e-02f, -1.14546075e-01f, 1.34150565e-01f, 1.94130763e-01f, 1.46032721e-01f,
  -1.11714669e-01f, -1.12609372e-01f, 9.72874928e-03f, -1.90322995e-01f, 3.99710387e-02f, -2.06473619e-02f, -1.62535399e-01f, 1.80602193e-01f, -9.86679271e-02f, -1.12496994e-01f,
  -5.84236644e-02f, -3.15572359e-02f, 1.53740019e-01f, -6.14699908e-03f, 1.20510951e-01f, 4.42240201e-02f, 6.60086423e-02f, -2.04285327e-02f, 9.12844762e-03f, 1.42101243e-01f,
  2.92098355e-02f, 7.74696469e-03f, 4.42880765e-02f, 1.17832586e-01f, -1.45547643e-01f, 1.24819659e-01f, 1.22340485e-01f, -2.41143443e-03f, 1.27338186e-01f, 2.09402591e-01f,
  -3.62093210e-01f, -4.01717126e-02f, 2.40884393e-01f, 1.91184476e-01f, -6.53576031e-02f, 3.63930613e-02f, 1.32316709e-01f, -3.97303179e-02f, 8.43620449e-02f, -1.91237345e-01f,
  -2.15630814e-01f, 8.88800770e-02f, -1.59419134e-01f, -6.15687855e-02f, -1.94418300e-02f, 2.13568777e-01f, -1.84556201e-01f, 6.95130676e-02f, 7.58772343e-02f, 1.06228307e-01f,
  1.69245955e-02f, 2.26316258e-01f, 6.87557235e-02f, -3.41514230e-01f, 9.33564976e-02f, -5.52644320e-02f, -2.81168461e-01f, 7.54633099e-02f, 1.93458393e-01f, -3.24082300e-02f,
  -4.51396825e-03f, 3.55958380e-02f, 2.62660474e-01f, -1.50757402e-01f, -9.34567451e-02f, -1.86721031e-02f, -1.48789257e-01f, -7.87273720e-02f, -1.04409799e-01f, -5.55895828e-02f,
  1.07412100e-01f, 1.14302291e-02f, -3.41788054e-01f, -1.32301733e-01f, 1.17276991e-02f, 6.38879687e-02f, 1.49392441e-01f, 2.16662154e-01f, 2.69004144e-02f, 2.08761081e-01f,
  9.83741209e-02f, 9.33115110e-02f, 1.15575247e-01f, -1.11070588e-01f, 5.09558208e-02f, -4.36922684e-02f, 8.48111212e-02f, -1.89184714e-02f, 1.51752844e-01f, -2.19087929e-01f,
  1.73316345e-01f, 1.71506166e-01f, -3.35300565e-02f, -9.43266973e-02f, -7.43820444e-02f, 4.33467627e-02f, -1.33689195e-01f, -1.10948332e-01f, 1.11035435e-02f, -8.22165236e-02f,
  5.99542595e-02f, 1.25156209e-01f, -4.98794764e-03f, -1.46534089e-02f, 3.64689261e-01f, -5.15991868e-03f, 3.51192713e-01f, 6.42191023e-02f, -2.34885901e-01f, 1.78104132e-01f,
  2.60429502e-01f, 2.56565642e-02f, 1.64340306e-02f, 1.37671798e-01f, 1.71181738e-01f, -1.68566748e-01f, -1.79327488e-01f, 3.87979060e-01f, -3.00935566e-01f, -5.94732463e-02f,
  2.82491967e-02f, 8.21140260e-02f, -4.25964534e-01f, 1.72412791e-03f, 1.84887797e-02f, -1.69356763e-01f, -2.01479405e-01f, -3.24081592e-02f, 1.79414526e-01f, -7.62710571e-02f,
  6.60505742e-02f, 4.23581213e-01f, 1.81657478e-01f, -2.22149611e-01f, 1.39212176e-01f, 3.79608423e-02f, 1.69397295e-01f, 1.82060093e-01f, -1.28340423e-01f, -2.62085665e-02f,
  1.07305720e-01f, -2.69428752e-02f, 1.43471748e-01f, 9.00117457e-02f, 1.08887270e-01f, -3.77345420e-02f, 7.47628929e-03f, -3.21321301e-02f, -1.32472649e-01f, -5.27586155e-02f,
  2.40101218e-01f, 1.17992153e-02f, -4.60679568e-02f, 1.74131189e-02f, -4.00168747e-02f, 1.11372001e-01f, 2.08039314e-01f, -5.76066971e-02f, -9.67028216e-02f, 8.48338678e-02f,
  -1.20477408e-01f, -1.47161722e-01f, 1.87582999e-01f, 1.52282938e-01f, -4.34381925e-02f, 1.32139817e-01f, 1.03684716e-01f, 9.35043991e-02f, 1.86462030e-01f, 9.04676467e-02f,
  8.02023336e-02f, -5.87454773e-02f, 1.35565142e-03f, 9.04232077e-03f, 2.69781679e-01f, -2.35004172e-01f, -1.52689755e-01f, 7.89993182e-02f, 9.25932229e-02f, 1.05277345e-01f,
  1.40098867e-03f, 2.75486439e-01f, -2.02322334e-01f, -1.82182178e-01f, 3.04497704e-02f, 1.45660684e-01f, -3.31300676e-01f, -3.39859501e-02f, 1.90249428e-01f, 1.89843103e-01f,
  -1.97048299e-02f, -7.56697282e-02f, 1.58946797e-01f, 5.32166474e-02f, 3.36881727e-03f, 4.26756125e-03f, 4.43396112e-03f, 7.12283403e-02f, 1.28522873e-01f, 5.71441837e-02f,
  1.49668351e-01f, 1.37066171e-01f, 6.24795184e-02f, 6.28441945e-02f, -6.08265921e-02f, 3.06081362e-02f, 3.17169875e-02f, 9.59771350e-02f, 2.33489200e-01f, 1.50257228e-02f,
  -1.07212611e-01f, -2.38415569e-01f, -1.11122325e-01f, -2.03324836e-02f, 1.32942691e-01f, -1.57865122e-01f, -1.05977304e-01f, 2.65935779e-01f, -7.42168054e-02f, -1.60697639e-01f,
  -2.38852501e-01f, 6.38477355e-02f, 1.17972672e-01f, -6.53354824e-02f, -1.08172305e-01f, -6.77522793e-02f, -6.46771565e-02f, -7.97671601e-02f, -6.85136318e-02f, -1.68794349e-01f,
  1.00056585e-02f, 8.64553601e-02f, -1.10171204e-02f, 1.81417271e-01f, 1.96302887e-02f, -1.76676258e-01f, 7.67927198e-03f, -2.22109526e-01f, 1.60483479e-01f, -6.48706481e-02f,
  5.78378364e-02f, 1.35641187e-01f, 1.07041024e-01f, -1.86621845e-01f, 2.47594774e-01f, -1.95643187e-01f, 1.82531014e-01f, -4.83824611e-02f, -1.00250160e-02f, -1.92493156e-01f,
  -5.87825365e-02f, -6.74443170e-02f, -1.67145714e-01f, 1.51064351e-01f, -4.06104289e-02f, 1.51025489e-01f, -1.44555345e-01f, 3.59532565e-01f, 1.62962392e-01f, 9.15621966e-02f,
  2.29991227e-02f, 2.02986091e-01f, -4.23706546e-02f, 1.92707166e-01f, -1.27960416e-02f, 1.62704632e-01f, 1.59267023e-01f, -9.58057120e-02f, 3.24233733e-02f, -1.77395970e-01f,
  -9.26184878e-02f, -4.88528572e-02f, 8.72064009e-02f, -4.05000113e-02f, 1.53450146e-01f, -1.63794801e-01f, 1.31908685e-01f, 1.34756193e-01f, -7.71792606e-02f, 4.49735895e-02f,
  -3.74924205e-02f, 2.11695522e-01f, 1.09487064e-01f, 7.25632757e-02f, 4.12101150e-02f, -4.33626352e-03f, -1.97616518e-01f, -6.54905066e-02f, 4.50384796e-01f, 2.37982854e-01f,
  -5.24699641e-03f, 9.20608044e-02f, -1.40733957e-01f, 2.53465343e-02f, -1.48835406e-01f, 2.79435128e-01f, -1.70466900e-01f, 1.59890894e-02f, 2.22019449e-01f, 8.14412534e-02f,
  6.86450824e-02f, -9.78763178e-02f, -1.26289353e-01f, 6.73545524e-02f, -3.54269683e-01f, 8.32585916e-02f, 1.50850400e-01f, 3.34825739e-02f, -3.76199007e-01f, 1.20325811e-01f,
  5.65225258e-02f, -3.90174985e-01f, -2.37617120e-01f, 1.10848226e-01f, 2.35615373e-01f, -4.79959734e-02f, 3.18639189e-01f, -2.61838853e-01f, 2.02714354e-02f, -1.82009354e-01f,
  1.11929454e-01f, -3.25754136e-01f, 1.99336987e-02f, -3.57793719e-02f, -1.56003073e-01f, 1.40845805e-01f, 6.50203899e-02f, -2.44858608e-01f, -7.56022781e-02f, 1.96453482e-01f,
  9.20491200e-03f, 2.94506043e-01f, 5.11626946e-03f, 1.18012205e-01f, 1.77813664e-01f, 1.41967416e-01f, 3.61234769e-02f, 1.43714190e-01f, -1.26108915e-01f, 9.72495601e-02f,
  -2.26761267e-01f, -5.34338003e-04f, -2.65610553e-02f, -1.05322776e-02f, 1.23587646e-01f, -1.38264179e-01f, 4.21325210e-04f, 1.72902286e-01f, 7.83072636e-02f, 1.23157062e-01f,
  1.11555561e-01f, 2.46241540e-02f, -1.02130756e-01f, 2.74479926e-01f, 5.15744602e-03f, -2.84188315e-02f, 1.32375276e-02f, 2.28902400e-01f, -1.20207243e-01f, -1.46984532e-01f,
  4.04251143e-02f, -1.34792060e-01f, -1.26927271e-01f, 1.46791711e-01f, 1.63599342e-01f, -1.18525000e-02f, 2.71307733e-02f, 1.70550153e-01f, 7.49360323e-02f, 1.95390452e-02f,
  -5.37329689e-02f, -2.47605324e-01f, -1.20663539e-01f, 1.12784810e-01f, 2.47437954e-02f, 6.98394477e-02f, 1.46184400e-01f, 2.17276998e-02f, 2.30064556e-01f, -7.59035870e-02f,
  1.74132690e-01f, 2.71565497e-01f, 1.47874311e-01f, 9.47106481e-02f, -1.77849072e-03f, -1.95507824e-01f, -1.21068485e-01f, -1.00899555e-01f, -6.92063794e-02f, -1.52929470e-01f,
  1.84188019e-02f, 9.73277837e-02f, 1.70296684e-01f, -2.07450345e-01f, 1.08368158e-01f, 1.15735702e-01f, 8.73423666e-02f, 1.64488539e-01f, 1.36919603e-01f, 1.93484262e-01f,
  2.12101609e-01f, 5.36692739e-02f, -1.96964666e-02f, 4.33088094e-02f, 1.78145602e-01f, 2.82647997e-01f, -3.59109230e-02f, -1.38339832e-01f, 2.81165153e-01f, 6.58553094e-02f,
  7.98248425e-02f, 3.46075706e-02f, -2.63003767e-01f, 1.77027613e-01f, 1.52906343e-01f, -1.15380600e-01f, 3.48537527e-02f, 4.14099246e-01f, -1.53674603e-01f, -2.68840343e-01f,
  1.34662166e-01f, -9.36024189e-02f, 2.82416609e-03f, -1.29452646e-01f, 1.63503096e-01f, -4.46956977e-02f, 7.99130872e-02f, 7.52464309e-02f, -2.15218768e-01f, -5.12462407e-02f,
  -8.87997672e-02f, 3.52050215e-01f, -4.82152551e-02f, -6.53630961e-03f, -4.50720862e-02f, 2.78639514e-02f, -1.89364374e-01f, 1.29674554e-01f, 3.34631264e-01f, -3.81286838e-03f,
  -2.58175552e-01f, -1.65077835e-01f, 1.94269285e-01f, 8.50307569e-02f, -1.95751429e-01f, 2.48959005e-01f, 1.16343386e-01f, 2.61122942e-01f, 2.88469680e-02f, 2.84285218e-01f,
  -1.86925065e-02f, 2.52275735e-01f, -2.48947926e-02f, 1.98759556e-01f, -1.49773136e-01f, 2.07669046e-02f, -1.33907214e-01f, 8.17666799e-02f, 1.10360282e-03f, -1.67280823e-01f,
  1.62163123e-01f, 4.95348871e-02f, 1.79210976e-01f, 1.11041449e-01f, 2.35088974e-01f, 1.85028061e-01f, 2.78320193e-01f, 3.23174059e-01f, 8.88770297e-02f, -1.27186440e-02f,
  -8.82644393e-03f, 6.45618662e-02f, -1.75104126e-01f, -1.56976238e-01f, -2.96507418e-01f, 2.96981186e-01f, -2.14687169e-01f, 3.94152105e-03f, 9.35944840e-02f, 1.99127078e-01f,
  -7.11088777e-02f, -3.88372421e-01f, 2.18767166e-01f, -8.64461884e-02f, -3.53495985e-01f, 1.15292594e-01f, -2.86227874e-02f, 2.17315093e-01f, 1.32922158e-01f, -1.32684499e-01f,
  1.54587746e-01f, -1.54014364e-01f, -9.51409340e-02f, -1.20662950e-01f, 3.60669643e-02f, 8.98824483e-02f, -1.31358877e-01f, 2.64464356e-02f, -3.12809438e-01f, 3.93614992e-02f,
  1.64911762e-01f, 2.66659528e-01f, 8.43848884e-02f, 1.96617395e-01f, 4.05724883e-01f, -2.14656994e-01f, -1.28962919e-01f, -1.67828664e-01f, -7.99666867e-02f, 1.82840198e-01f,
  -2.16187257e-02f, 2.46912047e-01f, -1.16719425e-01f, -1.89313889e-02f, -1.21071152e-01f, 1.70942590e-01f, 2.19585240e-01f, -3.48175257e-01f, -2.00623617e-01f, -4.54973914e-02f,
  3.71343166e-01f, 1.67473882e-01f, 1.43626511e-01f, -1.99600235e-02f, 1.33090794e-01f, 8.52767155e-02f, 1.23387128e-02f, 1.42495885e-01f, 1.89652175e-01f, 1.18467860e-01f,
  -9.72893387e-02f, -1.93106130e-01f, 1.35958716e-01f, 3.22916359e-02f, 2.46740773e-01f, -5.62495552e-02f, 9.15439725e-02f, 1.55700415e-01f, 1.53146625e-01f, 9.72843394e-02f,
  1.81240454e-01f, 1.29342124e-01f, -4.82955128e-02f, -2.06186682e-01f, 5.52751049e-02f, -1.08737454e-01f, -4.41144146e-02f, 1.90990552e-01f, -9.12519246e-02f, 1.46070704e-01f,
  5.28995134e-02f, 2.27552786e-01f, 2.53029615e-01f, 7.26687312e-02f, 1.89695060e-01f, 2.99923699e-02f, -9.37583148e-02f, 1.54915184e-01f, 1.93575576e-01f, 5.71837611e-02f,
  -1.15493238e-01f, 2.26855278e-02f, 1.62053749e-01f, -2.44292468e-01f, -1.19960241e-01f, 9.51757059e-02f, 7.70843178e-02f, -1.59172431e-01f, 1.64759338e-01f, 2.84370542e-01f,
  -7.10102171e-02f, -8.14059377e-03f, 1.31760046e-01f, -2.28197247e-01f, -4.79500480e-02f, -6.17923476e-02f, 4.77096140e-02f, 6.59641176e-02f, -5.13624912e-03f, 2.29291245e-02f,
  8.09914619e-02f, -3.39937932e-03f, 2.08006814e-01f, -1.50695175e-01f, 1.97087198e-01f, 1.84957981e-01f, -2.80615836e-01f, 2.34558463e-01f, 1.17321447e-01f, 2.13209257e-01f,
  8.50293860e-02f, 3.46188480e-03f, 1.32565245e-01f, -6.45760149e-02f, -7.24529251e-02f, -3.55053134e-02f, -1.26892656e-01f, -1.70512185e-01f, -8.23588297e-02f, 1.86002791e-01f,
  -1.09910510e-01f, -1.50723040e-01f, -8.41648653e-02f, 1.62725914e-02f, 2.57271141e-01f, -1.29485637e-01f, -8.90848693e-04f, 5.63442037e-02f, -7.19125047e-02f, -2.92259842e-01f,
  1.23291440e-01f, -1.40950322e-01f, -1.33938417e-01f, 1.64508656e-01f, 7.43670389e-02f, -5.70165813e-02f, 1.02843679e-01f, 2.59488255e-01f, -3.33806008e-01f, 9.05861929e-02f,
  1.69018090e-01f, -4.55980301e-02f, 6.41404688e-02f, -3.41874659e-01f, 1.98202312e-01f, -1.62845969e-01f, 1.76772639e-01f, -2.67071202e-02f, 4.09446329e-01f, -9.68668908e-02f,
  -1.39587253e-01f, 1.42194659e-01f, 3.35918248e-01f, 1.71880633e-01f, -1.00435570e-01f, -5.76769337e-02f, 1.39028713e-01f, 9.64286476e-02f, 1.93048850e-01f, -9.86358896e-02f,
  2.23754078e-01f, -1.63169801e-01f, 1.37041271e-01f, -2.05159411e-01f, 5.03593415e-04f, -8.41418561e-03f, 1.55826926e-01f, 3.59405614e-02f, 4.05749530e-02f, -1.03977047e-01f,
  1.51654705e-01f, 2.42908776e-01f, -1.07334368e-01f, 2.05218151e-01f, 2.42883191e-01f, 3.45788114e-02f, 2.02909544e-01f, 1.56276166e-01f, 2.96515506e-02f, -1.32935094e-02f,
  -1.26115486e-01f, -1.33000001e-01f, -3.64182174e-01f, -3.77802411e-03f, 1.65945053e-01f, -9.14184675e-02f, -9.79081728e-03f, 3.05885952e-02f, -1.16072044e-01f, 2.25270301e-01f,
  2.28020385e-01f, -2.76725367e-02f, 1.06119551e-01f, 3.19973053e-03f, 5.22081107e-02f, -1.29256561e-01f, -2.82915026e-01f, 6.49222406e-03f, -1.07103124e-01f, 2.16693245e-03f,
  -3.82219478e-02f, 8.09838250e-02f, 1.21574655e-01f, 1.61772460e-01f, -1.33111671e-01f, -1.76963702e-01f, -1.75266549e-01f, 2.05932632e-01f, 1.29278943e-01f, -1.62102446e-01f,
  4.08253819e-02f, 3.27363051e-02f, 2.39756510e-01f, -1.41523136e-02f, 8.87367800e-02f, 2.67487377e-01f, 3.21817130e-01f, -1.51140362e-01f, 1.94960028e-01f, 7.93071613e-02f,
  -9.56665426e-02f, -7.00607672e-02f, -3.44332486e-01f, 4.87378351e-02f, 2.26216074e-02f, -3.73300165e-02f, 1.87062964e-01f, 1.45581320e-01f, -2.48093456e-01f, 5.80849461e-02f,
  9.11040306e-02f, 8.73102993e-02f, 3.32320720e-01f, -2.34736845e-01f, 6.37573078e-02f, 1.72266752e-01f, 3.53666432e-02f, 3.77870202e-02f, 3.56816351e-02f, -2.51980964e-04f,
  2.05076113e-02f, 1.04509942e-01f, -2.95000840e-02f, -2.25133896e-01f, 2.93860883e-02f, 1.28197461e-01f, 9.64953452e-02f, 3.06657422e-02f, 1.63360104e-01f, 1.76998958e-01f,
  9.48915258e-02f, 1.58280820e-01f, -1.77301317e-01f, 2.32625574e-01f, 1.82729796e-01f, -1.38211120e-02f, 2.75015712e-01f, 2.93515682e-01f, 5.01116812e-02f, -5.87671176e-02f,
  -9.94721428e-02f, 4.43814788e-03f, 2.28882656e-02f, -2.05794917e-04f, -2.69458264e-01f, 3.40500884e-02f, 2.51881480e-01f, 1.15654171e-01f, -2.33793944e-01f, -9.63352770e-02f,
  -1.85770810e-01f, 3.04094613e-01f, 1.44602835e-01f, -1.11277156e-01f, -6.50389269e-02f, 4.85300049e-02f, -1.91497698e-01f, -1.16188481e-01f, 4.12915438e-01f, -1.73514366e-01f,
  -2.68595278e-01f, -2.15516210e-01f, 2.60546088e-01f, 2.22375374e-02f, 6.94940239e-02f, 1.43425301e-01f, 9.75870416e-02f, -6.29370939e-03f, -1.45608351e-01f, 2.96155602e-01f,
  1.00070767e-01f, 1.88196421e-01f, -1.80827677e-01f, 4.50476438e-01f, 1.02297448e-01f, 9.69679430e-02f, -4.70047742e-02f, 7.00790063e-02f, 3.62142771e-02f, -8.07246044e-02f,
  2.07096189e-01f, -2.80606113e-02f, -3.79328243e-02f, 1.49041712e-01f, -8.62511992e-02f, 8.74879733e-02f, 8.55853781e-02f, 7.92879239e-03f, -9.81988534e-02f, 1.82293225e-02f,
  -6.08830974e-02f, 2.96595506e-03f, -1.79808974e-01f, -3.32970023e-02f, -1.93670467e-01f, 3.84287126e-02f, 2.73315352e-03f, -5.66653870e-02f, 8.82017985e-02f, -3.32771912e-02f,
  2.39982292e-01f, 3.50085236e-02f, -1.61594152e-02f, 1.32328153e-01f, -3.14434320e-02f, 1.28346249e-01f, -7.31142163e-02f, 1.09332263e-01f, 6.87574819e-02f, 2.52480119e-01f,
  1.72704652e-01f, 1.91907868e-01f, 4.34785634e-02f, -1.52485445e-01f, -2.45176882e-01f, -1.01823574e-02f, -8.61227289e-02f, 1.28778294e-01f, 2.56449938e-01f, 1.63498744e-01f,
  3.28420639e-01f, 5.05105592e-02f, -1.59197429e-03f, 2.85103947e-01f, 2.46846080e-01f, 7.95048699e-02f, 3.36424857e-01f, 7.47910738e-02f, 1.82644188e-01f, -3.74815971e-01f,
  2.74704266e-02f, 1.20847374e-01f, 1.34980083e-01f, -1.65329501e-01f, 1.77905753e-01f, -1.49407059e-01f, -1.84652835e-01f, 9.57263261e-02f, 1.56170264e-01f, -1.76733032e-01f,
  1.49060801e-01f, 8.55677798e-02f, -1.09272093e-01f, 2.59652704e-01f, -1.11269563e-01f, 1.08744882e-01f, 1.16679184e-01f, 1.71545148e-01f, 9.29905400e-02f, -3.70320827e-02f,
  4.19664122e-02f, 1.47839516e-01f, 7.39950538e-02f, 1.72629356e-01f, -1.76596865e-01f, -2.77761417e-03f, 1.35972157e-01f, -1.48043707e-01f, -7.22306371e-02f, 4.97697629e-02f,
  -1.25281587e-01f, -6.34447783e-02f, 2.49697119e-01f, -6.46920800e-02f, -1.37503333e-02f, 2.29824692e-01f, 1.27089545e-01f, 1.75488032e-02f, 1.69762194e-01f, -5.50543480e-02f,
  -1.13332376e-01f, -8.91634822e-02f, 1.03293724e-01f, 1.23388015e-01f, 1.54181391e-01f, -8.24889019e-02f, 1.71424747e-02f, -1.81074366e-01f, -9.35233608e-02f, 2.03047857e-01f,
  1.04727849e-01f, -5.57925701e-02f, -1.25092968e-01f, -3.98769341e-02f, 2.43440151e-01f, -1.15912937e-01f, -8.79548863e-02f, 2.72629797e-01f, 1.35062635e-02f, -5.67376502e-02f,
  2.84171611e-01f, 2.17375964e-01f, -1.62358791e-01f, -1.11205708e-02f, -6.28907233e-02f, -6.62269816e-02f, 2.59610880e-02f, -2.19830066e-01f, -8.25115014e-03f, -7.25333095e-02f,
  4.36275080e-02f, -1.04723692e-01f, -1.13255121e-01f, -1.85257301e-01f, -2.28360649e-02f, 1.29721850e-01f, 1.24163687e-01f, -7.17244446e-02f, 1.82326823e-01f, 6.45411387e-02f,
  6.31123260e-02f, -1.23058967e-02f, -5.12870960e-02f, 1.13065496e-01f, 4.71109264e-02f, -8.28187093e-02f, -1.80571631e-01f, 2.16639549e-01f, -2.09213287e-01f, -6.91799819e-02f,
  1.52678058e-01f, -1.47809014e-02f, 2.14426026e-01f, 2.89234638e-01f, -1.15224808e-01f, 2.34748021e-01f, -1.54834446e-02f, 9.73747000e-02f, 3.00691158e-01f, 4.07775462e-01f,
  -1.18949853e-01f, -1.08491234e-01f, 1.81311611e-02f, 1.25481904e-01f, 5.28300516e-02f, 7.35842213e-02f, -8.88307020e-02f, 6.11885004e-02f, 3.07841539e-01f, 8.15386251e-02f,
  -2.75857419e-01f, -2.43539035e-01f, -9.59422737e-02f, 2.72453874e-01f, 1.25487521e-01f, 9.01093557e-02f, 1.87232092e-01f, 1.05798826e-01f, -1.91475436e-01f, -3.73115689e-02f,
  2.21959919e-01f, 1.16100729e-01f, -2.50027310e-02f, -8.80080760e-02f, 2.73358971e-01f, 1.06854998e-01f, 4.62397859e-02f, 5.41909523e-02f, -2.37740520e-02f, 6.43994883e-02f,
  1.08313292e-01f, -9.27966312e-02f, 1.13638677e-01f, 1.44639194e-01f, -2.54823178e-01f, 2.98312038e-01f, 1.31867066e-01f, -2.90281996e-02f, 1.62499622e-01f, -4.33783606e-02f,
  -1.55742392e-01f, 1.99924514e-01f, 1.51727751e-01f, 1.02450907e-01f, 1.38932467e-01f, 3.13643843e-01f, 9.16347653e-02f, 2.16432974e-01f, 2.36000687e-01f, 1.90357983e-01f,
  1.97942868e-01f, 7.54762581e-03f, -2.52360906e-02f, -2.20978424e-01f, -4.04416062e-02f, 3.05533502e-02f, -2.13242173e-01f, -1.29857520e-03f, -2.58789778e-01f, 1.21299587e-01f,
  3.65742743e-02f, 3.83437425e-02f, -1.52496487e-01f, -2.50095099e-01f, 2.05614224e-01f, -2.62352377e-01f, 3.24582378e-03f, 7.78608173e-02f, 1.08742990e-01f, -3.26229259e-02f,
  2.84739017e-01f, -2.14910761e-01f, 1.96884215e-01f, -2.16830105e-01f, -1.42784670e-01f, 6.51700329e-03f, 1.61469951e-01f, 3.11274976e-01f, -1.60327986e-01f, 1.19858749e-01f,
  -1.31691217e-01f, -7.19682276e-02f, -1.12996958e-01f, 1.98977381e-01f, 2.83832997e-01f, 1.52048066e-01f, 3.62633951e-02f, -8.46149996e-02f, -1.99229687e-01f, -7.61238560e-02f,
  -1.09503441e-01f, 1.40703380e-01f, -4.12890241e-02f, 3.94729197e-01f, -9.91286114e-02f, 2.30570823e-01f, -2.36865476e-01f, 2.35460296e-01f, 5.13105541e-02f, -1.50917947e-01f,
  -1.09652244e-01f, 2.14094996e-01f, 4.66082655e-02f, 2.23227143e-01f, 9.14703235e-02f, -1.46653622e-01f, 1.40604049e-01f, 1.50032416e-01f, 1.09870188e-01f, 9.72502232e-02f,
  -8.13333839e-02f, 2.83288546e-02f, -1.11770637e-01f, 3.19912508e-02f, 2.13904791e-02f, -8.80440027e-02f, -4.60071526e-02f, 8.74278545e-02f, -1.67771399e-01f, 1.82829592e-02f,
  7.20603988e-02f, 9.81068239e-02f, 3.19366097e-01f, 3.62736546e-02f, -1.17657557e-01f, 1.78089291e-01f, 1.84624374e-01f, -4.75607626e-02f, 7.64387622e-02f, -1.58404395e-01f,
  -6.02384694e-02f, 2.20612898e-01f, -4.31941934e-02f, 1.68286026e-01f, 1.15545534e-01f, 1.19594857e-01f, -5.80588803e-02f, 1.68170586e-01f, 1.04619280e-01f, 1.11000344e-01f,
  1.98391050e-01f, -2.46352598e-01f, -2.26520941e-01f, 4.76212613e-02f, 2.45708600e-01f, 1.65221244e-01f, -5.17589040e-02f, 1.86338529e-01f, -1.96072817e-01f, 1.78757776e-02f,
  1.38773263e-01f, 1.34159088e-01f, -1.06671944e-01f, -6.43956438e-02f, 2.68776029e-01f, 4.41516228e-02f, 2.11636245e-01f, -1.60975203e-01f, 1.67820409e-01f, -2.95516282e-01f,
  5.07753193e-02f, -4.55921628e-02f, 1.22315176e-01f, -1.22854840e-02f, 1.27937958e-01f, 3.05749066e-02f, -8.83494690e-03f, 7.93651342e-02f, 7.99256712e-02f, 3.66697520e-01f,
  1.10075012e-01f, 2.17025712e-01f, 1.80301368e-01f, -2.32776105e-02f, 2.45542631e-01f, 1.95837170e-01f, 5.19116633e-02f, -1.35056511e-01f, -1.92856476e-01f, -1.38663962e-01f,
  -6.64032474e-02f, -7.06458613e-02f, 1.64102763e-01f, -2.07057238e-01f, 1.84309110e-01f, 2.36893028e-01f, -1.07708029e-01f, 1.92951560e-01f, 2.57601261e-01f, 4.49202582e-02f,
  -1.13129139e-01f, -4.41952348e-02f, 1.80857778e-01f, -1.40384555e-01f, 2.61026949e-01f, 1.68861941e-01f, -1.76623389e-01f, 1.54250160e-01f, 2.74144113e-01f, -4.74636666e-02f,
  2.24050805e-01f, -4.15733866e-02f, -1.91282511e-01f, -1.94621965e-01f, 1.26725823e-01f, 3.27896893e-01f, 3.15745145e-01f, 1.19241364e-01f, 1.85524523e-01f, -3.32546502e-01f,
  2.86316033e-02f, 2.11494267e-01f, -1.98949143e-01f, -9.48378909e-03f, 2.45708957e-01f, -1.78421345e-02f, -1.29187584e-01f, 6.04275167e-02f, -1.56180099e-01f, -1.17361091e-01f,
  -2.21921042e-01f, -7.23045319e-03f, 2.51935869e-02f, -7.15888068e-02f, 1.60935000e-01f, 2.84407347e-01f, -1.18410408e-01f, 5.38137294e-02f, 1.00316055e-01f, 4.97114100e-02f,
  3.00328046e-01f, -1.33834913e-01f, -1.94851175e-01f, -9.15943831e-02f, 1.25282258e-01f, 9.72493514e-02f, -3.96072790e-02f, 5.42458892e-03f, 4.98375110e-02f, -5.49821220e-02f,
  -6.53353631e-02f, -4.82119322e-02f, -1.03839651e-01f, 3.61538976e-02f, -5.24401069e-02f, 3.23129036e-02f, -1.04427025e-01f, 1.57132655e-01f, -8.67125019e-02f, 5.60909808e-02f,
  1.09837009e-02f, 1.01989396e-01f, -2.87736282e-02f, 6.97570667e-03f, 3.08504581e-01f, -2.24139214e-01f, 1.89273477e-01f, -1.60912722e-01f, -1.58870667e-01f, 1.65604040e-01f,
  -2.61743777e-02f, 3.04487050e-01f, -2.25715861e-01f, 2.85531223e-01f, 2.29366153e-01f, 2.06023380e-01f, -2.33320728e-01f, -3.82040180e-02f, -4.33003381e-02f, -2.86658823e-01f,
  -2.52863348e-01f, -1.58092082e-01f, 2.98501819e-01f, 9.42635909e-03f, 1.39681816e-01f, 4.07703482e-02f, 2.19783839e-02f, 2.69365072e-01f, 1.48597494e-01f, -1.42300734e-02f,
  1.60682932e-01f, 1.19101241e-01f, -1.23851839e-02f, -2.96909451e-01f, 3.62716503e-02f, 1.95586115e-01f, 2.56774634e-01f, -3.90938297e-02f, 1.94619477e-01f, 1.56117380e-01f,
  2.47644410e-02f, 1.84667885e-01f, 5.43059036e-02f, 5.83937624e-03f, 1.57485574e-01f, -1.05213793e-02f, -1.62970454e-01f, 3.39413226e-01f, -2.13873863e-01f, 7.48463497e-02f,
  1.98185556e-02f, -7.40825608e-02f, 4.51424159e-02f, 1.31203672e-02f, -1.28262937e-01f, 1.51375141e-02f, -1.72845304e-01f, -1.96009278e-02f, -1.67421550e-01f, -5.01408093e-02f,
  -2.03774393e-01f, -2.25251764e-01f, -3.76388729e-01f, 2.05827072e-01f, 1.04158640e-01f, 1.38946787e-01f, 1.80581808e-01f, 8.64416081e-03f, 5.73709644e-02f, 1.50982797e-01f,
  -3.48682195e-01f, 1.37006149e-01f, -2.37759978e-01f, -3.70713919e-02f, -1.55805096e-01f, 2.24685576e-02f, -3.09338719e-01f, 1.12722896e-01f, 1.19195133e-01f, 5.54930419e-02f,
  -1.47034287e-01f, -2.75452971e-01f, 9.07209963e-02f, -1.44308776e-01f, 8.75559598e-02f, -1.06648877e-01f, 1.35352267e-02f, 5.30697927e-02f, 1.26652658e-01f, -5.42776808e-02f,
  -2.32948720e-01f, -4.01040196e-01f, -2.10388247e-02f, -1.84899941e-01f, 1.63947433e-01f, -2.82403797e-01f, 1.05868049e-01f, -1.75001457e-01f, -7.35724345e-02f, 1.02441326e-01f,
  7.61212260e-02f, -6.01477921e-02f, 2.74802864e-01f, 3.05316597e-01f, -1.53162792e-01f, 2.85695344e-01f, 2.50167459e-01f, 4.90344763e-02f, 7.95227960e-02f, -1.16085701e-01f,
  5.35707176e-02f, 6.01799376e-02f, 7.63662905e-02f, 1.06138758e-01f, 1.21073835e-02f, 1.03275500e-01f, -2.25933883e-02f, 1.01271801e-01f, 4.92379703e-02f, 1.62216142e-01f,
  3.71933803e-02f, -5.85621744e-02f, -7.71143585e-02f, 1.29088968e-01f, -1.67816043e-01f, -1.39475971e-01f, -2.32907921e-01f, -2.48638436e-01f, -1.65800840e-01f, 4.33695167e-02f,
  -1.83741227e-01f, -6.21226989e-03f, -6.78051040e-02f, 3.07999641e-01f, -1.45836458e-01f, -9.96977836e-02f, 2.11066734e-02f, -7.80241042e-02f, -3.66230793e-02f, -2.01018676e-01f,
  9.51317474e-02f, 1.47286998e-02f, 9.48053878e-03f, -3.69739741e-01f, -1.75370455e-01f, -1.22532293e-01f, -1.12531170e-01f, -1.16770871e-01f, -1.21223547e-01f, 2.50250638e-01f,
  -1.85834736e-01f, 2.22495824e-01f, 2.04243630e-01f, 1.46069407e-01f, -1.21940590e-01f, 1.69499040e-01f, 3.75469178e-02f, 3.13853868e-03f, 3.94685358e-01f, -1.11839529e-02f,
  -1.78939745e-01f, 3.75928283e-01f, 1.26723155e-01f, 3.82537425e-01f, -2.27157846e-01f, -2.04883382e-01f, -1.90478295e-01f, -1.22898677e-02f, 3.09990436e-01f, -1.35426894e-01f,
  -1.71400368e-01f, 1.60312489e-01f, -1.34437203e-01f, 1.88012496e-01f, 1.55792549e-01f, -1.38975069e-01f, 2.12250143e-01f, 4.86983545e-02f, 7.63964280e-02f, 2.42865339e-01f,
  2.06975967e-01f, 2.42126703e-01f, 2.10986614e-01f, -4.34748456e-02f, 9.04816538e-02f, 3.58034819e-02f, 2.00782772e-02f, -3.48816186e-01f, -8.86990596e-03f, 2.32507408e-01f,
  -6.55623451e-02f, -4.60654311e-02f, -1.31939888e-01f, -4.75665741e-02f, -1.48830637e-02f, -5.83560020e-02f, 7.90536404e-02f, 1.31685331e-01f, 8.27315263e-03f, -1.51346385e-01f,
  -8.10391456e-02f, -2.31118903e-01f, 1.01117333e-02f, 1.41290262e-01f, 6.35510832e-02f, -1.29694998e-01f, 2.39967734e-01f, -2.34465986e-01f, -3.73700231e-01f, -1.34850172e-02f,
  1.05866030e-01f, -1.47603471e-02f, -5.77940233e-03f, 1.70242742e-01f, -1.63328782e-01f, 1.41645223e-01f, -8.12884793e-02f, 1.32508755e-01f, 3.20550621e-01f, 1.46198925e-02f,
  -1.18525848e-01f, 6.23510219e-03f, -6.82945549e-02f, 1.76339643e-03f, -2.79871166e-01f, 1.23405091e-01f, 7.16765299e-02f, 3.08865488e-01f, -5.43294847e-02f, 1.72502995e-01f,
  1.24804363e-01f, 3.22492033e-01f, 1.06743947e-01f, -1.77084599e-02f, -1.66088119e-02f, -3.79789546e-02f, -9.60727483e-02f, 3.08149099e-01f, -7.61327520e-02f, -3.02320689e-01f,
  2.90518180e-02f, -1.37675516e-02f, 3.98809351e-02f, 1.85503632e-01f, 1.36389852e-01f, 2.26560384e-01f, -3.35277780e-03f, -6.42685518e-02f, -7.80354962e-02f, -4.12198864e-02f,
  -2.30667904e-01f, -3.05165313e-02f, -1.56474188e-01f, -1.09418621e-03f, -7.10947067e-02f, -7.69579224e-03f, -1.26600891e-01f, -5.05651161e-02f, 4.83249724e-02f, 4.88888565e-03f,
  4.25750650e-02f, 2.97813326e-01f, -8.17002058e-02f, -1.20031610e-01f, -2.26453051e-01f, 9.52997208e-02f, -3.97674516e-02f, -5.76150157e-02f, -1.81188926e-01f, 3.80720124e-02f,
  9.38230231e-02f, 1.21549129e-01f, -2.61338264e-01f, -6.73117563e-02f, 1.29905969e-01f, -3.21918353e-02f, 3.77042554e-02f, 5.02477065e-02f, -6.02226183e-02f, 2.96878248e-01f,
  1.65581450e-01f, -7.23181292e-02f, 2.22071260e-01f, 2.82648832e-01f, 2.50934303e-01f, -6.14951737e-02f, 3.77358735e-01f, 2.51205206e-01f, -8.57081413e-02f, -3.42947096e-02f,
  -1.71526931e-02f, 2.74476975e-01f, -8.36948976e-02f, 1.56479657e-01f, -6.59612566e-02f, 2.39522353e-01f, -8.62997323e-02f, 1.46874145e-01f, 2.15234961e-02f, 1.30069524e-01f,
  9.62277949e-02f, -3.66019793e-02f, -1.25774309e-01f, -2.27980665e-03f, 6.69500604e-02f, 2.35502660e-01f, 1.84345409e-01f, 8.53136331e-02f, 1.59910560e-01f, 1.27343042e-02f,
  7.01346174e-02f, -5.97205982e-02f, 1.55935496e-01f, -8.85472745e-02f, 1.02950670e-01f, -8.77204761e-02f, 3.43007267e-01f, -1.36342600e-01f, 3.18333864e-01f, -1.18792035e-01f,
  4.50178161e-02f, -6.93758801e-02f, 2.71731257e-01f, -6.62117153e-02f, -4.16107178e-01f, -1.09285973e-01f, 3.77007872e-02f, 2.52449885e-02f, 1.68359399e-01f, 6.62203953e-02f,
  1.62445158e-02f, -1.06910132e-01f, 1.72111049e-01f, -1.03506379e-01f, 9.54586565e-02f, -5.15720956e-02f, -1.48292825e-01f, 3.37663814e-02f, 3.47839653e-01f, 4.44305241e-02f,
  3.19455087e-01f, -6.41457140e-02f, -7.80992731e-02f, -2.89854616e-01f, 1.82362407e-01f, 2.16660634e-01f, -4.15296070e-02f, -2.29524136e-01f, 9.45965499e-02f, 1.96791768e-01f,
  -2.89198786e-01f, -1.00174889e-01f, -1.02393076e-01f, 2.72288203e-01f, -1.48198865e-02f, -4.64292206e-02f, -8.93764645e-02f, 1.48975149e-01f, -2.61410438e-02f, 1.55747890e-01f,
  2.29691431e-01f, 2.12175902e-02f, 5.32116480e-02f, 4.23892811e-02f, 9.02272165e-02f, 2.01030523e-01f, 5.16048307e-03f, -4.14074719e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  9.45278481e-02f, 1.54237941e-01f, -1.63857564e-02f, 2.43246183e-01f, 7.57998228e-02f, -7.07717165e-02f, -9.69404355e-03f, 2.18553647e-01f, 2.14524403e-01f, 1.58516131e-02f,
  -9.98139903e-02f, -6.12338781e-02f, 2.85692979e-03f, 4.68699932e-02f, -9.75558385e-02f, -1.48830458e-03f, 1.19199678e-01f, 8.47103521e-02f, 1.45941749e-01f, 7.34306499e-02f,
  6.89240769e-02f, 1.99773476e-01f, 1.12972751e-01f, 2.54182041e-01f, 4.07214314e-02f, 2.63390303e-01f, 2.33921364e-01f, 1.48458943e-01f, -7.24539310e-02f, 2.60636769e-02f,
  4.89621684e-02f, 1.50356134e-02f, -2.14025646e-01f, 8.58203396e-02f, 1.21337503e-01f, 3.94839095e-03f, -3.10744960e-02f, 1.44629076e-01f, 6.21761791e-02f, 1.00671299e-01f,
  -1.13184229e-01f, 1.52119279e-01f, 1.69780210e-01f, 1.60730928e-01f, 6.50455384e-03f, 1.57514066e-01f, 9.85782668e-02f, 1.49320960e-01f, 1.91416979e-01f, 7.28742555e-02f,
  8.96180347e-02f, 2.27348730e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.96440925e-02f, 2.45111361e-01f, 9.01288465e-02f, 6.02357239e-02f, -7.63496011e-02f, 1.34288117e-01f, 1.21040955e-01f, -2.37202153e-01f, 2.49389857e-01f, 2.06988052e-01f,
  3.04236542e-03f, 9.52650234e-02f, -2.98073471e-01f, -1.49774760e-01f, -7.27569498e-03f, 2.41736650e-01f, -6.77536950e-02f, 1.34457037e-01f, 2.03739911e-01f, 1.08415164e-01f,
  -8.23255181e-02f, 9.01775286e-02f, -5.49157932e-02f, 1.04781494e-01f, 3.50369364e-01f, 1.12385064e-01f, -1.90053359e-02f, 1.86489984e-01f, 1.53855190e-01f, 3.34134027e-02f,
  -2.28989854e-01f, 1.53454300e-02f, 1.37013057e-02f, 4.21075821e-02f, -7.31228068e-02f, 2.64058918e-01f, -1.83263570e-01f, 1.25789925e-01f, 6.74277991e-02f, 1.82402339e-02f,
  7.38462657e-02f, 6.54987991e-02f, -5.79504780e-02f, -1.05672345e-01f, 1.54717341e-01f, -4.50243391e-02f, -8.84790272e-02f, -3.20062339e-01f, -3.83329503e-02f, 1.07144095e-01f,
  -1.65049173e-02f, 1.62011340e-01f, 1.74468353e-01f, -9.20900181e-02f, 1.04282379e-01f, -9.43462700e-02f, 2.56410062e-01f, -6.60607740e-02f, 1.32987902e-01f, 1.76372513e-01f,
  9.04140249e-02f, -2.12867379e-01f, 5.14788274e-03f, -7.97884837e-02f, 3.98776121e-02f, 2.14947745e-01f, 2.75631607e-01f, 8.95448104e-02f, 1.04238845e-01f, 1.81276549e-03f,
  2.23650470e-01f, 4.33052294e-02f, -3.29834878e-01f, -4.72353287e-02f, -1.56076133e-01f, -3.18914205e-01f, -2.11148849e-03f, -5.05478531e-02f, -2.58820318e-02f, -1.90602526e-01f,
  1.58490315e-02f, 5.60717024e-02f, -3.31340507e-02f, -2.39458650e-01f, -9.35001895e-02f, 1.39413089e-01f, -4.87553850e-02f, -1.70218930e-01f, 1.10576689e-01f, 1.08614892e-01f,
  7.32633621e-02f, -1.88744381e-01f, -8.66486356e-02f, 2.65652835e-02f, -1.24342456e-01f, -6.39958009e-02f, 6.65134788e-02f, 8.77921134e-02f, -7.12345913e-02f, 3.62491794e-02f,
  -1.94165587e-01f, -6.82304474e-03f, -2.73616582e-01f, 9.86499041e-02f, -6.95708916e-02f, -1.21520482e-01f, 6.98654773e-03f, -1.55998752e-01f, 1.30242363e-01f, -2.04364434e-01f,
  -1.11008219e-01f, 1.17658600e-01f, 5.13113551e-02f, 3.69246453e-02f, 9.41731110e-02f, -9.52498987e-02f, 4.56933165e-03f, -1.97309271e-01f, 8.61556903e-02f, -1.39091283e-01f,
  4.87269126e-02f, -1.90802291e-02f, 5.80926389e-02f, 1.82776302e-01f, 1.03623066e-02f, -3.50373425e-02f, 1.93441212e-01f, -2.84015357e-01f, -5.56690060e-02f, -1.74338240e-02f,
  -4.53166813e-02f, -5.23545966e-02f, -1.71345606e-01f, -9.90967527e-02f, -1.67656764e-01f, 2.92628668e-02f, -8.34443718e-02f, -1.31370634e-01f, -7.06540793e-02f, 2.83072531e-01f,
  5.04840948e-02f, 4.53287438e-02f, 7.26660565e-02f, 1.21683158e-01f, -1.00835375e-01f, -5.86415827e-02f, 1.59606989e-02f, -4.63102460e-02f, 2.34213118e-02f, 1.96725160e-01f,
  1.72371089e-01f, 9.59818885e-02f, 2.58027241e-02f, 1.00435637e-01f, 1.14920102e-01f, 1.81595579e-01f, 1.32892966e-01f, 7.05578700e-02f, -2.13064536e-01f, -8.72087479e-02f,
  -1.01044483e-01f, -6.05611131e-02f, 1.35636777e-01f, -3.04875197e-03f, 2.14056950e-02f, -1.68281384e-02f, -1.55591384e-01f, 1.76820885e-02f, 9.17102396e-02f, 6.66285213e-03f,
  -4.19187471e-02f, -9.52006280e-02f, -3.69312167e-02f, 7.36434683e-02f, -1.29911751e-01f, -8.71473700e-02f, 7.70850927e-02f, 1.13821656e-01f, -1.82833329e-01f, -1.85494766e-01f,
  9.11304951e-02f, -2.42664851e-02f, 1.14586987e-01f, -2.45896950e-02f, 1.37927830e-01f, 6.40346929e-02f, -9.09537748e-02f, -1.05437927e-01f, -1.52470293e-02f, -5.68365566e-02f,
  -2.40564734e-01f, -9.40769687e-02f, -4.89699915e-02f, -1.53566137e-01f, -4.39454429e-02f, -9.44906250e-02f, -2.18634773e-02f, -7.78918266e-02f, 2.75280494e-02f, -2.30486970e-02f,
  -2.79553458e-02f, 7.36931488e-02f, 2.05847062e-02f, 3.08304164e-03f, 1.68396443e-01f, -9.67298076e-02f, 2.09387541e-02f, 1.88232079e-01f, 8.86812210e-02f, -4.19740789e-02f,
  1.28416583e-01f, -1.80558767e-02f, 1.24025121e-01f, 1.54822543e-01f, 3.39508206e-01f, 2.22420871e-01f, 1.23711497e-01f, -1.09769359e-01f, -2.22326387e-02f, 3.77020389e-02f,
  7.65416026e-02f, 1.42400891e-01f, -2.17691332e-01f, 1.46492630e-01f, -9.81646180e-02f, 2.51841191e-02f, -2.32932605e-02f, -1.09153144e-01f, -1.66958943e-01f, -4.51346152e-02f,
  -4.70117927e-02f, 4.33434360e-02f, 2.69513607e-01f, 3.89616042e-02f, -1.22916363e-01f, -9.17877629e-02f, -7.50495195e-02f, 8.86523128e-02f, -2.14014381e-01f, 7.52230221e-03f,
  6.80723810e-04f, 8.91043544e-02f, -9.81697366e-02f, -2.25311607e-01f, -7.56417662e-02f, 1.20479010e-01f, -6.15223646e-02f, -9.53520089e-02f, 1.38875479e-02f, -1.81603879e-02f,
  -2.98430119e-02f, -2.67917663e-02f, -1.91992268e-01f, 3.33653577e-02f, -2.74748385e-01f, 6.10470660e-02f, -1.11962952e-01f, -1.32782117e-01f, 3.50296386e-02f, 8.23324546e-02f,
  -1.36956170e-01f, -2.86378711e-01f, 1.83241107e-02f, 6.35245293e-02f, -7.44072795e-02f, -4.09973301e-02f, -2.97152642e-02f, 1.49506897e-01f, 2.07789332e-01f, 2.48049758e-02f,
  -2.17316840e-02f, 7.19086677e-02f, -1.51748121e-01f, -2.39645261e-02f, 1.52445138e-01f, 1.24550730e-01f, -1.31267026e-01f, 2.26073693e-02f, 1.39586702e-01f, 7.95035213e-02f,
  -7.91668817e-02f, 1.28137931e-01f, -8.37659314e-02f, -8.08071122e-02f, 1.48336828e-01f, 3.05505004e-02f, 1.03933334e-01f, -3.22400540e-01f, -1.01986080e-01f, -3.68828736e-02f,
  1.57654971e-01f, -8.20108503e-02f, 1.67066276e-01f, -2.11668313e-01f, -8.89359936e-02f, -8.68082047e-02f, -6.95339665e-02f, 1.08768962e-01f, 1.28737748e-01f, 1.43845621e-02f,
  1.51053980e-01f, -1.19169891e-01f, 2.06747409e-02f, 1.24509878e-01f, 8.22893158e-02f, -1.46510720e-01f, -5.53049743e-02f, 3.59705128e-02f, 1.70570761e-01f, 8.99475664e-02f,
  -7.83481002e-02f, 4.49200757e-02f, 9.78353694e-02f, -5.17642237e-02f, 8.01111832e-02f, 5.59156574e-02f, -4.73814942e-02f, 8.28972384e-02f, 4.26882617e-02f, -1.89910177e-02f,
  2.25765202e-02f, -9.22516659e-02f, -1.67335182e-01f, -2.98316270e-01f, -2.19763428e-01f, -2.55062252e-01f, -7.67277405e-02f, 1.90703586e-01f, 3.86487126e-01f, 3.10680151e-01f,
  -5.22250459e-02f, 1.87527195e-01f, 6.84261620e-02f, -1.82557017e-01f, 1.63151845e-01f, 1.68726265e-01f, -6.76423637e-03f, 1.19432911e-01f, 1.64252333e-02f, -6.43910095e-02f,
  -9.25213620e-02f, 2.72061098e-02f, 5.89244738e-02f, 1.49938300e-01f, 1.22349098e-01f, 2.01944392e-02f, 6.17060512e-02f, 2.60322064e-01f, -7.74553278e-03f, -9.66261253e-02f,
  -2.82569766e-01f, 1.11787412e-02f, -1.83820605e-01f, -1.09238038e-02f, -9.02272761e-03f, -5.89562021e-02f, 8.60799700e-02f, -1.01239430e-02f, -6.93331584e-02f, 3.38309258e-02f,
  1.82560250e-01f, -5.12429290e-02f, 1.26805425e-01f, 2.46510431e-02f, -4.18680673e-03f, 4.62593889e-04f, -2.63530165e-01f, 2.88446322e-02f, 4.33300845e-02f, 1.11462131e-01f,
  -2.13451684e-01f, -9.46994647e-02f, -1.04103461e-02f, -8.96671787e-02f, -2.44111970e-01f, -2.12294281e-01f, -2.31890604e-02f, -1.76145703e-01f, -1.20096117e-01f, -2.60330141e-01f,
  -1.21308044e-01f, -8.79288018e-02f, -3.04156393e-01f, 1.74535930e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.98152655e-01f, 7.23561272e-02f, -3.87321487e-02f, 8.60081315e-02f, 1.72717080e-01f, 1.89267784e-01f, 1.65071875e-01f, -5.51635437e-02f, 3.40046346e-01f, 2.28962243e-01f,
  1.13015078e-01f, 4.79547083e-02f, 2.42878171e-03f, 1.92764044e-01f, 1.30983397e-01f, 2.35429421e-01f, -2.10636086e-03f, -4.96515185e-02f, -1.76466644e-01f, -2.82819252e-02f,
  8.68207887e-02f, -3.32590759e-01f, -7.91432485e-02f, 4.49794754e-02f, -1.13767900e-01f, -1.63955122e-01f, -9.08295885e-02f, -9.73401684e-03f, -1.00037880e-01f, -1.07513785e-01f,
  -3.08487006e-02f, -2.43764743e-01f, 5.13466708e-02f, 1.17426299e-01f, -1.32305011e-01f, 2.51945615e-01f, 2.04076186e-01f, 2.94130053e-02f, 1.48200288e-01f, -8.34336132e-03f,
  8.88874568e-03f, -2.39085495e-01f, -1.12015873e-01f, 7.38937855e-02f, 9.10544619e-02f, 1.87461942e-01f, 7.43501037e-02f, 1.24233492e-01f, -3.22390676e-01f, 5.67860827e-02f,
  -1.25782892e-01f, 1.09169625e-01f, -2.71753490e-01f, -2.02009026e-02f, -2.75838282e-03f, 6.28942922e-02f, 7.79210180e-02f, -1.98076338e-01f, -3.97914797e-01f, -2.77926903e-02f,
  2.51559108e-01f, 3.11287735e-02f, -1.23011068e-01f, 3.55067179e-02f, -6.35112450e-02f, -2.40992010e-01f, 1.64657891e-01f, 1.09660558e-01f, -2.10424978e-03f, -5.45308553e-02f,
  2.46765733e-01f, 9.63205770e-02f, -3.33029449e-01f, -1.03791423e-01f, -1.90977249e-02f, -1.16179153e-01f, 2.51262605e-01f, 1.48485571e-01f, 9.41896290e-02f, -2.26632044e-01f,
  2.33078226e-01f, 2.66839843e-02f, -7.96674378e-03f, -6.46070093e-02f, 7.47915804e-02f, 1.91933841e-01f, 3.57054263e-01f, -2.32323751e-01f, 1.24132253e-01f, -1.02647826e-01f,
  2.49024387e-02f, -2.52274543e-01f, -1.41490698e-01f, -1.79131866e-01f, -1.33163184e-02f, 4.03172374e-02f, 9.67128724e-02f, 1.10946976e-01f, 2.97823787e-01f, 1.81153357e-01f,
  -9.34229344e-02f, 1.52180672e-01f, 2.55510360e-01f, 1.41151056e-01f, -1.26723731e-02f, 1.27539650e-01f, 9.20703709e-02f, -3.45955305e-02f, -2.05764733e-02f, 2.54746731e-02f,
  -4.04055119e-01f, 3.64340067e-01f, 1.37381509e-01f, 2.59225339e-01f, 2.44376305e-02f, -2.56153762e-01f, 1.83264077e-01f, 2.05306977e-01f, -3.91672328e-02f, 1.68954089e-01f,
  2.18039006e-01f, 5.98085895e-02f, -3.92781571e-02f, -1.12885617e-01f, 3.70369814e-02f, -1.86953530e-01f, 1.00803494e-01f, 1.41283199e-01f, 1.50421441e-01f, -5.78612089e-02f,
  -2.66311735e-01f, 1.71024457e-01f, 2.10360363e-01f, 1.47628531e-01f, -1.84092931e-02f, 3.79434526e-02f, 1.10998124e-01f, -4.53299396e-02f, 1.33803159e-01f, 2.92265445e-01f,
  -4.16932851e-02f, 4.39873859e-02f, 5.44942059e-02f, 8.79747197e-02f, 5.39912693e-02f, -1.95362926e-01f, 4.61936444e-02f, 4.78776954e-02f, 1.27125248e-01f, -4.10774946e-02f,
  -1.85198486e-02f, 2.24280789e-01f, -1.67706400e-01f, 8.17029849e-02f, 2.55118936e-01f, 1.29118040e-01f, -7.60632232e-02f, -8.78776424e-03f, 2.59834021e-01f, 4.36877906e-01f,
  3.58976349e-02f, 1.28384873e-01f, -1.81185931e-01f, -4.79293317e-02f, -3.49604130e-01f, 1.84815496e-01f, 7.27882534e-02f, -2.24797856e-02f, -6.93769157e-02f, -2.68318374e-02f,
  -1.09239601e-01f, 2.73202360e-01f, -2.87885040e-01f, 7.42682219e-02f, 1.96420059e-01f, -3.25004190e-01f, 7.32553080e-02f, 3.25782746e-02f, 1.97461262e-01f, 2.61601627e-01f,
  -7.52355456e-02f, -1.26136065e-01f, -1.63808577e-02f, 5.33566661e-02f, -1.13096148e-01f, 2.02246130e-01f, -6.39361590e-02f, 2.04953216e-02f, -2.84753472e-01f, 1.39891982e-01f,
  -6.54864684e-02f, 1.94436833e-01f, 2.49510467e-01f, -2.00279534e-01f, -6.47469610e-02f, 2.78203815e-01f, 1.61096111e-01f, -7.64805898e-02f, -1.10238895e-01f, 1.16769731e-01f,
  7.23132417e-02f, 1.81434676e-01f, 1.13301329e-01f, 3.75696510e-01f, -1.10370539e-01f, -1.90135986e-02f, 1.87575817e-01f, 1.27123386e-01f, 2.06559580e-02f, 2.60788202e-01f,
  1.29888669e-01f, 3.09228301e-01f, 1.03076249e-01f, -9.14074630e-02f, -1.55462638e-01f, 1.04177587e-01f, 1.72101304e-01f, 1.59201413e-01f, 1.43683003e-02f, 2.00308766e-02f,
  1.25433803e-01f, -2.48875264e-02f, 5.31271696e-01f, -2.38211870e-01f, -3.09237212e-01f, -2.10694507e-01f, -5.05032837e-02f, 1.13542773e-01f, -1.75462186e-01f, 5.27864546e-02f,
  2.87225842e-01f, -1.54654086e-01f, 2.05749385e-02f, 1.40889600e-01f, 1.58993229e-01f, 1.69160277e-01f, -1.65999562e-01f, -1.52508199e-01f, 1.10920414e-01f, -5.60961813e-02f,
  1.04152091e-01f, 3.92571650e-02f, -3.55317742e-01f, -1.09350085e-01f, -2.96414077e-01f, -9.33626518e-02f, -2.46524870e-01f, 2.47914702e-01f, 5.03018759e-02f, -7.85296038e-02f,
  -1.00994974e-01f, 5.12257069e-02f, 1.55493483e-01f, 3.70572776e-01f, -2.09227622e-01f, 1.75062284e-01f, 1.23519011e-01f, 2.80669063e-01f, 1.52188882e-01f, 1.30099654e-01f,
  4.21673805e-01f, 1.12262771e-01f, -6.12392053e-02f, 4.32173163e-01f, -1.94160208e-01f, 1.61741272e-01f, -7.99295530e-02f, -7.93798361e-03f, 2.55000759e-02f, -2.19153419e-01f,
  -8.22022036e-02f, 3.40009987e-01f, 1.91005334e-01f, -4.20630872e-02f, 1.41269177e-01f, -7.74613768e-02f, -2.71736309e-02f, -8.85112062e-02f, -4.45738472e-02f, -1.68509409e-03f,
  -3.07969689e-01f, -7.78925419e-02f, -1.63586885e-01f, 4.35344100e-01f, 1.64777681e-01f, 2.45922636e-02f, 1.92265511e-02f, 1.88367650e-01f, -9.14193243e-02f, -1.08838849e-01f,
  9.06769484e-02f, 1.39132619e-01f, -6.68276623e-02f, 2.63088167e-01f, 2.09990814e-01f, 1.33732080e-01f, 7.34515712e-02f, 1.69288188e-01f, -1.73698664e-02f, 4.41771410e-02f,
  -7.62423724e-02f, 1.54868111e-01f, 2.54807264e-01f, -3.70262086e-01f, -1.22220568e-01f, -1.17971683e-02f, 2.31715124e-02f, -2.88073942e-02f, -1.31106943e-01f, 2.90610999e-01f,
  -1.29913967e-02f, -3.82717848e-02f, 3.91063504e-02f, -7.71334171e-02f, -3.67444679e-02f, 2.24031240e-01f, 1.82643101e-01f, 1.38441011e-01f, -1.80342458e-02f, 3.31494927e-01f,
  3.43795747e-01f, -2.78770439e-02f, 1.60810709e-01f, 8.23522136e-02f, 9.94576365e-02f, 1.82964146e-01f, -3.08156367e-02f, 1.13131024e-01f, -3.35019082e-01f, -2.57557333e-01f,
  1.64210021e-01f, -2.48590946e-01f, -4.42684675e-03f, 2.52184153e-01f, -1.42141104e-01f, -7.21567050e-02f, 1.62297532e-01f, -2.03528572e-02f, -1.53362960e-01f, -2.76440889e-01f,
  1.36308193e-01f, 2.12179899e-01f, 1.83888510e-01f, -9.32017621e-03f, -1.49086878e-01f, -8.06696266e-02f, 6.14955872e-02f, 1.15650622e-02f, -2.09465861e-01f, -1.84194013e-01f,
  4.91138883e-02f, 2.43373334e-01f, 2.24679679e-01f, 2.67063946e-01f, 5.78008918e-03f, 4.49655987e-02f, -1.05489455e-01f, 9.14992467e-02f, -1.69031039e-01f, 1.35993630e-01f,
  -1.24493040e-01f, -1.20545276e-01f, -8.11859667e-02f, -1.13477148e-01f, -1.01352416e-01f, 3.36422697e-02f, -1.76238120e-01f, 5.65387048e-02f, -3.23182754e-02f, 1.90379277e-01f,
  2.98882693e-01f, -1.63157463e-01f, 2.68643111e-01f, 7.45598525e-02f, 7.43321478e-02f, -1.19071119e-01f, 4.49294224e-03f, 3.01684022e-01f, 8.23791325e-02f, -2.65412360e-01f,
  -6.33696616e-02f, -1.00660756e-01f, 3.47000986e-01f, -1.14437891e-02f, -1.37362704e-02f, 4.23851199e-02f, -3.55158560e-02f, -2.51668245e-01f, 3.27917308e-01f, -1.42924599e-02f,
  -2.62742281e-01f, 3.68792415e-01f, -1.80305824e-01f, -2.10503370e-01f, -8.61084536e-02f, -2.29295284e-01f, -6.49295822e-02f, -1.30798500e-02f, 1.37005478e-01f, -2.79832911e-02f,
  9.89982486e-02f, 8.35198835e-02f, -7.19901547e-02f, -2.54465371e-01f, 2.43350387e-01f, 2.50220317e-02f, 2.76589125e-01f, 2.84225401e-02f, 1.85133427e-01f, 1.36038631e-01f,
  3.28868441e-02f, -1.08072395e-02f, 8.80344138e-02f, 4.60438952e-02f, -2.03776136e-01f, 4.37708586e-01f, 2.39961222e-02f, 1.21808916e-01f, 1.15438841e-01f, 1.45965498e-02f,
  -5.65645918e-02f, 1.73083425e-01f, 8.38184580e-02f, 9.97596532e-02f, 3.56390737e-02f, -5.97930066e-02f, 1.74281210e-01f, -8.90457332e-02f, -1.53193250e-01f, 1.68147638e-01f,
  -1.86817467e-01f, 3.19586061e-02f, 5.57742314e-03f, 1.52750343e-01f, 6.57526255e-02f, -1.81038052e-01f, 1.17540866e-01f, 4.83939163e-02f, -1.32689387e-01f, -1.58266857e-01f,
  2.21527606e-01f, 7.86019340e-02f, -9.63044092e-02f, 1.26364082e-01f, -3.65045637e-01f, -1.19145125e-01f, 2.03640060e-03f, 1.15350001e-02f, 2.10806981e-01f, -8.45505521e-02f,
  -2.37186942e-02f, -7.12243561e-03f, 2.22820848e-01f, -1.26348853e-01f, -1.67217180e-01f, 5.33516966e-02f, 4.48659539e-01f, 1.73992693e-01f, 2.35023960e-01f, 3.80737305e-01f,
  -3.15165251e-01f, -1.07773624e-01f, 2.23448187e-01f, -1.13700312e-02f, -5.47715798e-02f, 3.07925999e-01f, 1.47842124e-01f, 1.84622370e-02f, -3.55253890e-02f, -5.16671874e-02f,
  7.37627298e-02f, 1.21389935e-02f, 3.33610117e-01f, 1.44823128e-02f, 6.84004128e-02f, 9.56573337e-02f, 7.70913213e-02f, 2.75736619e-02f, 3.31624478e-01f, -1.14555053e-01f,
  -1.78664163e-01f, -7.61848018e-02f, 9.52741280e-02f, 1.24962606e-01f, -2.51513451e-01f, 1.69808775e-01f, 1.54475942e-01f, 1.20606227e-02f, -1.01030923e-01f, 1.16937965e-01f,
  2.20061522e-02f, 1.37636617e-01f, -2.04228014e-02f, -2.41192672e-02f, -3.45743932e-02f, 3.13547663e-02f, 2.15188906e-01f, 1.93092391e-01f, -2.36449450e-01f, -4.12051603e-02f,
  -1.81199878e-01f, -4.30025011e-02f, -1.33425817e-01f, 2.13690773e-01f, 2.69519985e-02f, 1.72927845e-02f, 1.03981443e-01f, -1.18030407e-01f, -1.02430955e-01f, 1.82302207e-01f,
  -1.65361613e-02f, -2.14448515e-02f, -1.30504156e-02f, 1.33690566e-01f, -3.79142128e-02f, -2.07011148e-01f, -4.38644644e-03f, -3.05205703e-01f, -7.40320003e-03f, 1.63778707e-01f,
  2.32543394e-01f, 2.91553795e-01f, 1.46535814e-01f, 7.02322200e-02f, 3.03297676e-02f, 3.80264670e-02f, 1.83007732e-01f, 5.71722835e-02f, 7.40737692e-02f, 3.36209908e-02f,
  1.78682357e-01f, -2.35918522e-01f, 1.27827302e-01f, 2.67079532e-01f, 3.04859996e-01f, -9.81573164e-02f, 4.38905209e-01f, -1.26513794e-01f, 1.09020233e-01f, -1.33171171e-01f,
  2.55474895e-02f, -1.75155684e-01f, -1.13825694e-01f, 1.22686394e-01f, -1.48147538e-01f, -1.12478934e-01f, 3.46400626e-02f, -7.80478716e-02f, 1.36045098e-01f, 4.00919374e-03f,
  -4.60598022e-02f, 1.93860039e-01f, -1.55635685e-01f, 7.03755617e-02f, 4.60637361e-02f, -1.81258097e-02f, 2.09220350e-01f, 1.58624753e-01f, -3.90553534e-01f, -2.49239281e-01f,
  1.73665956e-01f, 1.70051754e-01f, 5.77627271e-02f, -2.34884754e-01f, -2.18392294e-02f, 2.88080331e-03f, -1.34290799e-01f, -1.88071817e-01f, 2.35844806e-01f, -2.11327318e-02f,
  3.36105339e-02f, -1.98845088e-01f, -3.97080600e-01f, -3.18302453e-01f, -2.74946421e-01f, 1.38036415e-01f, -2.76391447e-01f, -5.13878763e-02f, -4.08531994e-01f, 1.97524764e-03f,
  -3.35136324e-01f, -1.08315267e-01f, -3.13986212e-01f, -1.54174596e-01f, 3.92696187e-02f, -2.04831883e-01f, -4.35269289e-02f, 4.98983234e-01f, 9.48990136e-02f, -1.42253488e-01f,
  7.29389191e-02f, -2.96878554e-02f, -4.84946333e-02f, 5.37818559e-02f, -4.38362313e-03f, -1.07451670e-01f, -1.37805328e-01f, 7.05922619e-02f, 1.34770483e-01f, -1.62459999e-01f,
  3.73542532e-02f, 2.34450139e-02f, -2.94692237e-02f, -1.30906701e-01f, -3.63564156e-02f, 4.56192382e-02f, -1.00564353e-01f, 7.90088922e-02f, 3.25358585e-02f, 3.99680994e-02f,
  4.50231321e-02f, -1.60334576e-02f, 7.47273341e-02f, 1.58741288e-02f, -5.85834458e-02f, -9.71755683e-02f, -1.54130965e-01f, 8.07107091e-02f, -5.48450500e-02f, -1.04010008e-01f,
  5.95103800e-02f, -4.12982218e-02f, 1.10009536e-01f, -6.28929287e-02f, 6.16062544e-02f, -2.03861133e-03f, -4.23192233e-02f, 5.15154116e-02f, 1.36228874e-01f, 8.18123370e-02f,
  -9.39703658e-02f, -1.00487813e-01f, -3.11840083e-02f, 4.30303328e-02f, 1.26120165e-01f, 2.33495682e-01f, 2.66744830e-02f, 3.76379415e-02f, -9.88287851e-02f, 5.01886718e-02f,
  1.44408643e-01f, 1.95024461e-01f, 1.74221277e-01f, -4.82691154e-02f, -5.72319925e-02f, 1.12976059e-01f, 2.17148170e-01f, 1.35417897e-02f, -2.56779402e-01f, -2.73105145e-01f,
  1.36204481e-01f, 1.94725007e-01f, -9.74894017e-02f, -1.91290095e-01f, 1.38063863e-01f, -1.70501452e-02f, 1.81441993e-01f, -3.28368507e-02f, -3.50333750e-02f, 8.51224437e-02f,
  -5.49728842e-03f, 2.65487824e-02f, 1.26644865e-01f, -2.07009256e-01f, 1.43061668e-01f, -7.42483810e-02f, 7.92073607e-02f, -9.44991112e-02f, 9.25050899e-02f, 9.78726596e-02f,
  -2.34684080e-01f, 4.02216911e-01f, -7.25160465e-02f, -7.57101625e-02f, 1.36565939e-01f, 2.58851200e-01f, 1.43128559e-02f, 1.97912529e-01f, 2.38905791e-02f, 1.73780337e-01f,
  -6.73567429e-02f, -1.23785459e-01f, -5.00427708e-02f, 1.37492567e-02f, 2.04761103e-01f, 3.08734216e-02f, -2.28567064e-01f, 6.12407625e-02f, 7.33673126e-02f, 2.37266257e-01f,
  1.06249623e-01f, -1.34628087e-01f, 2.19563738e-01f, 1.57366082e-01f, 4.43166159e-02f, -1.07761860e-01f, 1.62628010e-01f, -5.28799593e-02f, 2.60081422e-02f, 6.19238503e-02f,
  1.53187305e-01f, -1.75098300e-01f, 1.57775015e-01f, -1.81970865e-01f, -7.74891973e-02f, 5.11485226e-02f, 1.70709670e-01f, 8.26898143e-02f, -4.16965261e-02f, -6.69194683e-02f,
  -9.20187011e-02f, -8.79895985e-02f, -2.18588486e-01f, -2.55299240e-01f, 3.00974935e-01f, -8.17513689e-02f, 2.68302947e-01f, -1.40634310e-02f, 1.80331036e-01f, -1.30106032e-01f,
  2.05228344e-01f, 2.01378241e-01f, 6.51270449e-02f, 1.35281205e-01f, 2.62641013e-02f, 3.31937857e-02f, 2.99654812e-01f, -2.83456761e-02f, 2.83904195e-01f, -4.52626217e-03f,
  1.10642843e-01f, -1.16325542e-03f, -1.14740662e-01f, -2.97331857e-03f, 1.61330834e-01f, -1.36438131e-01f, -5.29415607e-02f, 4.75583076e-02f, 2.35314101e-01f, 2.21503705e-01f,
  -1.10580988e-01f, 1.06985547e-01f, -6.14629164e-02f, 1.34015918e-01f, -2.86234301e-02f, -4.77101170e-02f, 4.46345024e-02f, 2.48906106e-01f, -1.14081830e-01f, 3.72533388e-02f,
  -1.53288618e-01f, 1.98757604e-01f, 3.39148045e-02f, 2.13131294e-01f, 4.14715037e-02f, -1.80693164e-01f, 9.98988822e-02f, 8.88454821e-03f, -1.64297730e-01f, 1.04217336e-01f,
  1.33660242e-01f, -1.15378551e-01f, 1.40233651e-01f, -3.65122524e-03f, 1.27186909e-01f, 1.97096318e-01f, 7.31064752e-02f, 1.24139495e-01f, 1.70554981e-01f, 3.00301015e-01f,
  1.03999518e-01f, 8.75812694e-02f, 1.71916232e-01f, 1.22243188e-01f, -6.62852451e-02f, -3.07234704e-01f, -1.84819922e-01f, -1.96438849e-01f, 1.58683121e-01f, 1.21722044e-02f,
  1.87042654e-02f, 5.12650125e-02f, -1.09642319e-01f, -1.55472964e-01f, 1.96285129e-01f, 3.78971621e-02f, 7.24718999e-03f, 1.52183905e-01f, -1.67931959e-01f, -1.99935287e-01f,
  -3.19529861e-01f, -2.80270427e-01f, -3.27337474e-01f, -1.80387750e-01f, -1.33857489e-01f, -2.87253201e-01f, 4.72420268e-02f, -1.99139059e-01f, 7.58727193e-02f, -1.70193285e-01f,
  2.48799041e-01f, -8.53094682e-02f, 1.78158477e-01f, 1.74417511e-01f, 3.04740936e-01f, 1.00848667e-01f, 1.59492821e-01f, 1.49893790e-01f, -2.90309995e-01f, 9.70915183e-02f,
  8.62441305e-03f, -1.43229052e-01f, 6.29329458e-02f, 9.58441496e-02f, 2.22043440e-01f, 4.13270116e-01f, -9.85004678e-02f, 2.14157663e-02f, 1.53443232e-01f, -1.93180919e-01f,
  3.04467417e-02f, -1.34485096e-01f, 8.53451490e-02f, 1.45986527e-01f, 6.27978370e-02f, 1.22059554e-01f, 1.48184136e-01f, 8.82793665e-02f, 3.58283222e-01f, 2.12013274e-01f,
  2.40505159e-01f, -1.10845275e-01f, -7.23569244e-02f, 2.52596382e-02f, 3.10812891e-02f, 2.10703425e-02f, -3.14062685e-01f, -2.98334479e-01f, 3.88497347e-03f, -5.88940680e-02f,
  2.18670025e-01f, 1.74584851e-01f, 2.22127825e-01f, 2.88623348e-02f, 1.38234094e-01f, -5.16178645e-03f, 1.53937533e-01f, 7.83660486e-02f, 9.17084962e-02f, 1.92577660e-01f,
  6.55420348e-02f, 1.04874685e-01f, 4.42072377e-02f, 2.04957530e-01f, 3.02126199e-01f, -1.71981916e-01f, 3.26265097e-01f, -1.08082086e-01f, 1.45376567e-03f, -5.23786731e-02f,
  6.60895929e-02f, -3.81783885e-03f, -2.07629025e-01f, 1.58047993e-02f, -8.49060640e-02f, -1.30072847e-01f, 3.05133045e-01f, 2.38438070e-01f, -2.84938663e-02f, 1.85107037e-01f,
  4.06486131e-02f, 2.54877299e-01f, 1.45469382e-01f, 2.94631720e-02f, 1.79340541e-01f, -5.89719493e-05f, 2.41213277e-01f, 2.19619670e-03f, -1.65669829e-01f, -1.26582131e-01f,
  2.29814053e-02f, 2.44134486e-01f, -1.79607481e-01f, -1.08354561e-01f, 1.80602700e-01f, 4.88027856e-02f, -1.43209442e-01f, -1.40822798e-01f, 2.07152471e-01f, -1.64981991e-01f,
  1.00306153e-01f, -9.63585004e-02f, 2.10211352e-01f, -1.77472740e-01f, -6.02201037e-02f, -1.16323762e-01f, 2.55131517e-02f, 2.93569118e-01f, 1.41441897e-01f, -1.20072342e-01f,
  1.44454673e-01f, 3.92049812e-02f, -8.10899585e-02f, -8.79193470e-02f, 4.09900337e-01f, 1.20104343e-01f, -6.30883500e-02f, -9.89825279e-02f, 8.45284760e-02f, 2.52461493e-01f,
  -9.92128253e-03f, 1.75211459e-01f, -1.62067115e-01f, -1.54563963e-01f, -2.87705363e-04f, -2.94675883e-02f, 6.51363283e-02f, -1.09246783e-01f, -1.33958533e-02f, 1.72955513e-01f,
  3.99903283e-02f, 1.33212686e-01f, -1.41879022e-02f, 5.64267375e-02f, -6.08888746e-04f, 2.35193625e-01f, -2.00447012e-02f, 8.25374275e-02f, 1.14254579e-01f, 2.05785692e-01f,
  -1.91777289e-01f, 1.09157443e-01f, 1.40459448e-01f, -1.65598601e-01f, -2.18162104e-01f, 1.20169826e-01f, 1.06541306e-01f, -1.75200909e-01f, -8.44112113e-02f, -8.83950517e-02f,
  5.51663991e-03f, -1.15397856e-01f, 2.51587808e-01f, -4.79934335e-01f, -4.33602631e-02f, -1.67119235e-01f, -3.48188244e-02f, 1.75462723e-01f, -1.49418041e-02f, -7.85032436e-02f,
  1.80427775e-01f, -1.48463883e-02f, -1.78021401e-01f, -5.36738411e-02f, -5.72669916e-02f, 2.67611206e-01f, 1.47086293e-01f, 2.10374638e-01f, 2.71186322e-01f, -7.65279382e-02f,
  2.01430514e-01f, 9.99532193e-02f, 1.19936362e-01f, -7.98810124e-02f, 8.81108344e-02f, -5.80045544e-02f, -2.31519490e-01f, 3.28645676e-01f, -1.98925927e-01f, -2.14797691e-01f,
  -4.75393906e-02f, 3.37938935e-01f, -1.42460108e-01f, -2.77426928e-01f, 2.45890707e-01f, -3.00220679e-02f, -8.01309198e-03f, 1.03452988e-01f, 1.17177211e-01f, 1.96850955e-01f,
  -1.00692213e-02f, 4.61022370e-02f, -4.11607698e-02f, -4.95008156e-02f, 8.47935453e-02f, 1.87893793e-01f, 1.94321200e-02f, -7.81093985e-02f, 2.06163630e-01f, 2.34940708e-01f,
  3.25020641e-01f, 1.10477410e-01f, -4.67112958e-02f, -1.29001260e-01f, 5.79812825e-02f, -1.65058479e-01f, -4.04128313e-01f, 4.16110903e-02f, 2.10107919e-02f, -1.04098149e-01f,
  -3.33391845e-01f, 3.00128222e-01f, 1.70194209e-01f, 1.65264532e-01f, -8.77459571e-02f, -2.50414789e-01f, -3.63790132e-02f, -2.70934641e-01f, 1.16956599e-01f, -7.76679963e-02f,
  -2.10371777e-01f, -2.99917497e-02f, -2.74164621e-02f, -2.54838377e-01f, -1.42640732e-02f, 6.58840463e-02f, 1.40465975e-01f, -4.97603677e-02f, 1.85079917e-01f, 2.49427706e-01f,
  -1.95726499e-01f, 1.25964627e-01f, 9.30651501e-02f, 1.84898823e-01f, 1.33316694e-02f, 1.60774514e-01f, -1.70277059e-01f, -3.86101961e-01f, -6.68665320e-02f, -1.68218046e-01f,
  4.48065139e-02f, 2.49828786e-01f, 1.92516763e-02f, 8.08003023e-02f, -6.89872503e-02f, 2.20344231e-01f, -8.43014717e-02f, -1.58771500e-01f, 8.81169662e-02f, 2.45638788e-01f,
  6.35862574e-02f, 1.76907256e-02f, 9.90816355e-02f, -9.30116698e-02f, 1.84983835e-01f, 1.66723832e-01f, 1.33768559e-01f, -1.29727051e-01f, 3.87621582e-01f, 7.15519488e-02f,
  7.47869313e-02f, 2.40984842e-01f, -3.46901342e-02f, 1.03463508e-01f, -3.10340255e-01f, 3.70336682e-01f, 7.08957091e-02f, -1.67423174e-01f, 1.56558439e-01f, 1.20683141e-01f,
  -2.41666272e-01f, 1.80533543e-01f, -7.41284043e-02f, 2.47976892e-02f, -1.60866324e-02f, -8.03003609e-02f, 1.48812281e-02f, -1.70788858e-02f, 1.13277517e-01f, 6.98535368e-02f,
  -2.30176076e-01f, -3.26966196e-01f, 1.77891534e-02f, 1.02179624e-01f, -1.05177447e-01f, -3.54105905e-02f, 3.18245068e-02f, 1.11808680e-01f, -5.21171540e-02f, -8.05989653e-02f,
  1.21380799e-01f, -7.20151812e-02f, -5.86958556e-03f, 1.34243473e-01f, -2.55055010e-01f, -1.32794142e-01f, 2.22744733e-01f, -1.65496200e-01f, 2.33400032e-01f, -2.26854876e-01f,
  1.56262219e-01f, 4.11669254e-01f, 1.36859506e-01f, -1.30059253e-02f, 4.27157134e-02f, -6.74066171e-02f, -2.81876713e-01f, 5.37956506e-02f, 8.45677108e-02f, -2.04359517e-01f,
  1.71372354e-01f, 1.13904022e-01f, 1.29442841e-01f, -1.22024320e-01f, 1.04555786e-01f, -1.06262406e-02f, -1.09208263e-01f, 1.42347157e-01f, 1.54173806e-01f, -1.75228029e-01f,
  -1.73850298e-01f, 1.36139289e-01f, -1.98656186e-01f, 1.45078212e-01f, -9.79715884e-02f, -1.67172626e-01f, 5.79711460e-02f, 1.02199316e-01f, 2.47938782e-01f, -2.68767923e-01f,
  1.58029288e-01f, 1.79002553e-01f, 1.39057755e-01f, -7.98081607e-02f, 1.74643606e-01f, 1.39799654e-01f, 2.28693232e-01f, 1.31088108e-01f, 1.27666947e-02f, 7.19481558e-02f,
  1.47077050e-02f, 1.53619647e-01f, -2.91956306e-01f, 1.66779771e-01f, 6.95343688e-02f, 3.48716229e-01f, -4.17317413e-02f, -9.85066518e-02f, -3.05473544e-02f, 2.66947672e-02f,
  -1.78690940e-01f, 1.87971473e-01f, -6.03482239e-02f, 3.98576111e-01f, -8.70059580e-02f, 1.63190439e-01f, -8.74443799e-02f, -3.09682898e-02f, 1.29838854e-01f, 1.87365353e-01f,
  5.48518300e-02f, 1.61758006e-01f, -8.22712556e-02f, 2.80840725e-01f, 9.63056311e-02f, -9.79927778e-02f, 3.25905383e-02f, 1.10429160e-01f, -1.47028282e-01f, 1.20461024e-01f,
  -7.55826756e-02f, -4.01187032e-01f, 5.50608011e-03f, 2.57150233e-01f, -1.20085500e-01f, -1.60383329e-01f, 1.54504314e-01f, 2.44895630e-02f, 2.88499873e-02f, -7.28991479e-02f,
  -4.97089103e-02f, 2.17442364e-01f, 1.08931549e-01f, 7.23441020e-02f, 6.66077062e-02f, 1.76654607e-01f, 4.60259393e-02f, 1.14758961e-01f, 3.05627018e-01f, 2.15306301e-02f,
  6.99219853e-02f, 3.44553441e-01f, -1.11821359e-02f, 3.04310471e-01f, 7.31843486e-02f, 2.01485306e-01f, -1.93106234e-01f, -1.35629818e-01f, -3.05799067e-01f, 3.82261211e-03f,
  2.35928781e-02f, -1.92649990e-01f, -2.50051826e-01f, 1.25426278e-01f, 1.42232701e-01f, 2.93787539e-01f, 5.91164967e-03f, -1.70822442e-01f, 6.57210350e-02f, -2.88586527e-01f,
  1.97703928e-01f, 1.15712546e-01f, 5.29053882e-02f, 2.66298920e-01f, -1.71139836e-02f, -2.06374913e-01f, 2.64653563e-01f, -1.24381334e-01f, -4.87054661e-02f, 1.92166224e-01f,
  1.23497099e-01f, 1.16054334e-01f, -2.48364612e-01f, 6.05251342e-02f, 9.63462815e-02f, 1.37744620e-02f, 1.81417868e-01f, -7.45713115e-02f, -2.50571966e-01f, 1.02185041e-01f,
  2.68189739e-02f, 1.19107656e-01f, 2.88763255e-01f, -7.83514380e-01f, 5.81538260e-01f, 1.95932463e-01f, 2.56689459e-01f, -9.84912831e-03f, 1.33379638e-01f, 1.89360157e-01f,
  -4.28661406e-02f, 1.08849339e-01f, 7.30152056e-02f, -2.09135681e-01f, -7.74750859e-02f, 1.28230751e-01f, -8.02559033e-02f, -2.30438605e-01f, -3.10489297e-01f, 1.68006822e-01f,
  1.96626619e-01f, -6.21064007e-02f, 1.11885481e-02f, -1.07995659e-01f, -1.27303183e-01f, 3.14163744e-01f, 2.17259139e-01f, -1.26640320e-01f, -5.68689965e-02f, 2.32751623e-01f,
  -7.33538717e-02f, 3.98443669e-01f, 1.64941281e-01f, -3.02432310e-02f, 2.52144367e-01f, 1.38856575e-01f, 5.30628450e-02f, -1.66234270e-01f, -3.90849821e-02f, 2.73364037e-01f,
  9.70413163e-02f, 6.80862600e-03f, 2.64066875e-01f, 2.77931720e-01f, -1.72282025e-01f, 7.42619261e-02f, 2.57437885e-01f, 2.42235556e-01f, -6.96954429e-02f, 1.40024042e-02f,
  8.12932104e-02f, 1.65808231e-01f, -1.06651686e-01f, -3.11538935e-01f, -8.64705890e-02f, -1.08339898e-01f, 1.48599356e-01f, 1.19436122e-01f, 7.26422444e-02f, -8.62787962e-02f,
  6.04422018e-02f, 1.89891234e-02f, -9.37934592e-02f, -1.40099879e-02f, 2.13856608e-01f, -1.54438660e-01f, -3.00339282e-01f, 3.61288190e-01f, -9.02989134e-03f, 2.11265624e-01f,
  -5.65336347e-02f, 1.16804488e-01f, -7.56477192e-02f, -2.52609581e-01f, 7.67723098e-02f, 1.73708573e-01f, 1.19461633e-01f, 9.04847234e-02f, 1.00910865e-01f, -8.13262388e-02f,
  -2.61897922e-01f, 7.58776292e-02f, 6.01882599e-02f, -2.66248196e-01f, 1.34469017e-01f, -2.92850491e-02f, 5.80780469e-02f, 1.72962502e-01f, 2.84735803e-02f, 3.66457105e-02f,
  2.74142646e-03f, 5.84708899e-02f, 7.93749392e-02f, -2.26695284e-01f, 7.97404721e-02f, 6.96126595e-02f, -1.61938963e-03f, 1.06688790e-01f, -8.99334252e-02f, 1.65506586e-01f,
  6.17690384e-02f, 9.18629542e-02f, 4.43545170e-03f, -1.23585425e-02f, -3.69272605e-02f, -8.85550454e-02f, 1.54484615e-01f, -4.34079081e-01f, 1.66959628e-01f, 2.27937661e-02f,
  -2.07289129e-01f, 1.74378194e-02f, 6.41479492e-02f, -3.62673365e-02f, -7.69770220e-02f, -5.49596027e-02f, 1.10227196e-02f, -1.18688591e-01f, -8.47524479e-02f, -5.01671014e-03f,
  1.57651976e-01f, 2.15380579e-01f, 8.88998881e-02f, -7.32766837e-02f, 1.03000820e-01f, 7.37710968e-02f, 3.11736744e-02f, -7.29597881e-02f, -1.03698306e-01f, 1.42657235e-01f,
  2.23637640e-01f, 3.28004956e-02f, 2.23850220e-01f, 1.54312765e-02f, -2.01376468e-01f, -5.64018302e-02f, -2.20520914e-01f, 2.66005188e-01f, -1.61415890e-01f, 2.71078169e-01f,
  -9.09412876e-02f, -1.80991869e-02f, 2.93447543e-02f, 1.45360768e-01f, 2.19803944e-01f, -1.03303246e-01f, -2.86812857e-02f, 1.12513728e-01f, -9.49440971e-02f, -7.32077658e-02f,
  6.82054162e-02f, -4.13099006e-02f, -7.81578943e-02f, 1.05845690e-01f, 1.00615673e-01f, 2.31425151e-01f, 1.56457171e-01f, -1.22851075e-03f, -3.87185901e-01f, 7.85998851e-02f,
  6.56358078e-02f, -1.19734406e-01f, -2.20911354e-01f, 8.72945860e-02f, -9.95696858e-02f, 8.51572454e-02f, -2.61290316e-02f, -6.01503849e-02f, 3.27077746e-01f, 1.12516455e-01f,
  7.92216510e-02f, -2.48987108e-01f, 9.85847190e-02f, 6.59758002e-02f, 2.36760750e-01f, 1.80594578e-01f, 1.56033754e-01f, 5.25050610e-02f, 3.03875417e-01f, -2.67393082e-01f,
  1.10532559e-01f, 3.55378687e-02f, 8.54885653e-02f, 5.19735403e-02f, -8.56522247e-02f, -1.28490120e-01f, 1.04224578e-01f, -1.89672440e-01f, 2.47832611e-01f, 1.98594749e-01f,
  -1.32505372e-01f, -1.16895191e-01f, 3.83904696e-01f, 1.73002899e-01f, -1.65264592e-01f, 1.42117247e-01f, 5.98676577e-02f, -8.51718336e-02f, -3.77346314e-02f, -3.68405394e-02f,
  -1.15023144e-01f, 8.68759155e-02f, -2.07091942e-02f, 6.53098449e-02f, -1.22146286e-01f, -9.50654224e-02f, 1.06597766e-02f, -7.70596713e-02f, 2.50472546e-01f, -1.08105779e-01f,
  -7.22940490e-02f, 5.54127544e-02f, -5.76145016e-02f, 3.62750515e-02f, 9.51299518e-02f, 2.48891756e-01f, -9.52014253e-02f, 1.99338481e-01f, 1.50879294e-01f, 4.29355174e-01f,
  -5.39709553e-02f, 6.38506338e-02f, -1.60465375e-01f, 8.64263251e-02f, -3.14461529e-01f, 1.37574375e-01f, -9.76939276e-02f, 1.47448629e-01f, 1.14653766e-01f, -1.39597580e-01f,
  4.94101197e-02f, 2.23616526e-01f, -2.11285084e-01f, -9.29807350e-02f, -3.50887701e-02f, -2.55198538e-01f, 2.95642726e-02f, 8.75053648e-03f, -4.27486077e-02f, 1.51849002e-01f,
  -2.04489961e-01f, 1.10246696e-01f, -5.25512807e-02f, -2.23453976e-02f, -1.78121746e-01f, 4.03689919e-03f, -3.47113013e-02f, 1.70351818e-01f, -2.26889998e-02f, 1.10945873e-01f,
  6.12294152e-02f, 1.50727406e-01f, 1.32871598e-01f, -1.52983636e-01f, 2.47131497e-01f, 3.51690918e-01f, 2.38562942e-01f, -4.74807061e-02f, -2.29625612e-01f, 1.18686385e-01f,
  7.85342902e-02f, 3.61647129e-01f, 3.15979153e-01f, 2.81024426e-01f, -1.98255479e-01f, 6.98192492e-02f, 1.24200389e-01f, 1.00694358e-01f, 1.59598708e-01f, 9.55406129e-02f,
  1.80302318e-02f, 2.15560421e-01f, -1.57698080e-01f, -1.02183260e-01f, -2.98003465e-01f, 1.64178554e-02f, 8.74212235e-02f, -6.87650293e-02f, -6.16027182e-03f, 2.04241216e-01f,
  1.31546721e-01f, -2.21578870e-02f, 3.37308645e-01f, -2.21122786e-01f, 2.98754638e-03f, -2.52800763e-01f, 1.26998154e-02f, 1.73122957e-01f, -9.29976031e-02f, 2.29713559e-01f,
  1.54815152e-01f, -3.01696155e-02f, 9.69642848e-02f, 1.19402505e-01f, -9.09582525e-02f, -7.23764375e-02f, -1.28658637e-01f, -6.84517715e-03f, 3.67955744e-01f, -1.87059283e-01f,
  -2.60254834e-02f, -2.04581812e-01f, -3.19937199e-01f, -5.91944112e-03f, -2.93095112e-01f, -4.61181765e-03f, 4.20398898e-02f, 1.67216957e-01f, 6.59009293e-02f, -5.84509037e-02f,
  -2.11529523e-01f, -2.32400239e-01f, 1.50991917e-01f, 3.55100751e-01f, -4.46972484e-03f, 2.12079212e-01f, -7.00148419e-02f, -5.16829826e-02f, 3.28819960e-01f, 2.38743529e-01f,
  -8.45358334e-03f, 2.97974080e-01f, -9.97443423e-02f, -4.49351147e-02f, -3.29392195e-01f, -2.77172774e-01f, -1.59494475e-01f, -1.98339194e-01f, -2.38175690e-02f, 1.36879003e-02f,
  -1.97516754e-01f, -1.03079759e-01f, 4.92843948e-02f, -1.38216037e-02f, 2.12750614e-01f, 5.44952080e-02f, -3.56384516e-02f, 1.07925244e-01f, -1.45462617e-01f, 3.27352472e-02f,
  -2.25346714e-01f, 1.76666588e-01f, 1.50590152e-01f, 1.32813632e-01f, 4.41385433e-02f, 5.52046634e-02f, -9.48479921e-02f, 1.46302909e-01f, 4.12143648e-01f, 1.81997582e-01f,
  -7.19599202e-02f, -5.09025529e-02f, 1.55099705e-01f, -1.89367950e-01f, -3.24077129e-01f, -8.88399705e-02f, 1.31290436e-01f, 7.00274929e-02f, -1.42287746e-01f, -1.29072294e-01f,
  1.88303694e-01f, 1.18101746e-01f, 2.12835014e-01f, -1.47816427e-02f, 1.08332314e-01f, 9.29703265e-02f, 2.56522268e-01f, 2.70364940e-01f, 3.19417238e-01f, 6.67551011e-02f,
  3.02247256e-01f, -1.11034222e-01f, 1.45829886e-01f, 3.53684872e-02f, 2.64438540e-01f, 4.17233497e-01f, 2.37046868e-01f, 8.19088295e-02f, 3.31689626e-01f, -2.80714393e-01f,
  1.22598968e-01f, -1.19783327e-01f, 2.45931908e-01f, -4.67513017e-02f, 3.39356154e-01f, 7.49599040e-02f, 1.14375018e-01f, 4.38050985e-01f, 6.08358420e-02f, 8.42657462e-02f,
  2.28412692e-02f, -1.27587542e-01f, -1.27052348e-02f, 1.06980905e-01f, -2.07319170e-01f, -1.36831990e-02f, -9.18673351e-03f, 1.13308288e-01f, 1.30625501e-01f, -1.10395916e-01f,
  2.11077467e-01f, 1.18920058e-01f, 1.67319551e-01f, 2.08991468e-01f, -1.66423731e-02f, -1.84524715e-01f, -6.42227679e-02f, 1.42311841e-01f, 6.40903190e-02f, -3.02872479e-01f,
  2.43920192e-01f, 1.63771346e-01f, -2.00898852e-02f, 8.39251503e-02f, 1.34962210e-02f, -5.17720357e-02f, -8.43085349e-02f, 7.95480907e-02f, 1.01126894e-01f, -7.85821304e-03f,
  -1.12516701e-01f, -1.76791847e-02f, -1.54526994e-01f, -1.10576965e-01f, -2.09426776e-01f, 5.96024934e-03f, 4.41562198e-02f, 5.73589616e-02f, 1.19443692e-01f, -4.18441892e-02f,
  1.28490791e-01f, -1.79469988e-01f, 4.93271500e-02f, 1.60229683e-01f, -6.48874417e-02f, -3.12830880e-02f, -1.47311658e-01f, 1.28809780e-01f, -1.28537580e-01f, -1.44126013e-01f,
  -3.38404715e-01f, 3.20558771e-02f, -9.19929072e-02f, 1.58612520e-01f, -2.93652207e-01f, -3.31506968e-01f, -8.78025740e-02f, -3.48213851e-01f, -3.71431977e-01f, -3.79982263e-01f,
  -1.82158463e-02f, -2.22883806e-01f, 1.87087376e-02f, 7.90598541e-02f, 8.33883788e-03f, 8.17945451e-02f, 1.22674353e-01f, -4.04698141e-02f, -3.02904062e-02f, 1.78426534e-01f,
  1.11599453e-01f, 1.11973599e-01f, -2.46550469e-03f, -1.39028728e-01f, -2.36837622e-02f, 7.00659826e-02f, 1.11185350e-01f, -1.02613814e-01f, 1.73201598e-02f, 9.98393353e-03f,
  -2.01845884e-01f, 2.01655075e-01f, -6.95288256e-02f, -1.08836442e-01f, 9.42800790e-02f, -3.59911144e-01f, 1.86913833e-01f, 1.66811362e-01f, -5.89240119e-02f, 1.08673297e-01f,
  1.92424506e-02f, -1.69876199e-02f, -1.53542802e-01f, 1.18101671e-01f, 3.53179500e-02f, -3.97110105e-01f, -1.03901261e-02f, 1.18823545e-02f, 4.22952548e-02f, 1.07972018e-01f,
  -1.45120814e-01f, 1.74292661e-02f, -4.46677953e-02f, 7.48159960e-02f, -6.07860507e-03f, -2.89735436e-01f, 2.11937472e-01f, 1.00039653e-01f, -2.03333616e-01f, -2.07200479e-02f,
  2.20614374e-02f, -2.37758160e-01f, -7.99178705e-03f, 7.88962841e-02f, 2.86381841e-02f, 3.00510917e-02f, 2.12201905e-02f, -3.72742899e-02f, 9.08999220e-02f, -4.49589677e-02f,
  -1.12488449e-01f, -9.37669501e-02f, -3.73006836e-02f, -4.60000783e-02f, -1.06447287e-01f, 7.53309950e-02f, -1.18862294e-01f, 4.61612493e-02f, 2.68731769e-02f, 9.48579311e-02f,
  -1.92947760e-02f, -9.15356949e-02f, -1.34942845e-01f, 3.03878970e-02f, -1.92482118e-02f, -1.04592107e-01f, -2.51368750e-02f, 1.47298304e-02f, -5.21572074e-03f, -8.80014375e-02f,
  2.44849212e-02f, -2.41338685e-02f, 1.27911434e-01f, -8.86907130e-02f, 1.28497789e-02f, -2.29278971e-02f, 6.78494992e-03f, -4.20645401e-02f, -1.17009692e-01f, -2.62836516e-02f,
  -7.13927746e-02f, -1.16670728e-01f, -7.33162835e-02f, -1.27203017e-01f, -1.24943614e-01f, -4.78551723e-02f, -1.10573888e-01f, -9.15305167e-02f, -3.96583453e-02f, 1.65725369e-02f,
  -1.41912689e-02f, 5.09151369e-02f, 3.32600586e-02f, -2.01358204e-03f, -1.05525265e-02f, 5.82294054e-02f, 4.63443585e-02f, 8.91061574e-02f, 3.87786180e-02f, 6.97248280e-02f,
  -3.41108851e-02f, -3.27749774e-02f, -6.63248450e-02f, -5.17069586e-02f, -5.51027618e-02f, -3.19582447e-02f, -5.22096641e-02f, 4.67313789e-02f, -1.21073008e-01f, -5.54334521e-02f,
  -7.94422477e-02f, -1.68287400e-02f, 1.11703817e-02f, 1.99087977e-01f, -3.96799333e-02f, -2.58545160e-01f, 1.01922914e-01f, 5.85692562e-02f, 4.12879810e-02f, 2.63735771e-01f,
  -5.92975430e-02f, 1.21983476e-01f, 2.50657480e-02f, 1.17682107e-01f, 5.30488640e-02f, -2.78237581e-01f, 1.31371439e-01f, 1.17311507e-01f, 1.41697869e-01f, 3.84582877e-02f,
  3.72690745e-02f, -2.07785424e-02f, 1.16379879e-01f, 7.55806314e-03f, 9.06918794e-02f, 3.94146629e-02f, 4.34114039e-02f, 3.18767130e-02f, 9.38444063e-02f, 2.17606470e-01f,
  -4.06936966e-02f, -1.66116003e-02f, -2.46008188e-01f, 4.31129038e-01f, -1.75046965e-01f, -1.80644795e-01f, 1.37171090e-01f, 1.50461942e-01f, -1.92603111e-01f, 2.48573020e-01f,
  1.95033550e-01f, 1.39619395e-01f, 4.26827446e-02f, 1.35030568e-01f, 1.24405056e-01f, 1.85681656e-02f, -7.07231760e-02f, 1.38950691e-01f, -6.89262822e-02f, -1.87374607e-01f,
  -1.05724707e-01f, 2.17529655e-01f, -7.60110691e-02f, 2.37274766e-02f, -6.21933714e-02f, -1.27770931e-01f, -1.08135499e-01f, -1.95291966e-01f, 1.87349096e-01f, -6.28050268e-02f,
  4.39335853e-02f, 1.63242832e-01f, -8.03018138e-02f, -1.91529661e-01f, -1.77283332e-01f, 1.03098236e-01f, -6.07733913e-02f, -1.63534373e-01f, 2.12105110e-01f, 3.80049288e-01f,
  2.65106801e-02f, -1.10369280e-01f, -4.21442166e-02f, -2.38888860e-01f, -2.99220622e-01f, -1.86336577e-01f, -2.12074793e-03f, -1.71599075e-01f, -7.08970893e-03f, -5.71141876e-02f,
  -6.08391613e-02f, -6.77689910e-02f, -6.24868087e-03f, -1.11501165e-01f, 7.42822811e-02f, -4.28143702e-02f, -2.59742498e-01f, 2.72729862e-02f, -4.40189578e-02f, -1.05782010e-01f,
  5.87828457e-03f, 1.28195181e-01f, -1.18752524e-01f, -1.08788326e-01f, -2.89356690e-02f, 6.46261200e-02f, -1.90113112e-01f, -2.73011833e-01f, 2.75135875e-01f, -5.64689236e-03f,
  2.82157600e-01f, 1.11040190e-01f, 3.28006297e-01f, -9.32613984e-02f, 4.26389873e-02f, 1.60481960e-01f, 9.59336907e-02f, 1.08207643e-01f, 1.52023405e-01f, -9.11927372e-02f,
  7.52317607e-02f, 1.89900532e-01f, -6.23479933e-02f, 2.22983807e-01f, -6.72136806e-03f, 6.73178881e-02f, 8.34094435e-02f, -7.30088428e-02f, -1.48678385e-02f, 1.03246287e-01f,
  2.24258304e-01f, 1.16297603e-01f, 1.17779955e-01f, 1.61610767e-01f, 1.26734376e-01f, -3.11998650e-03f, 3.73034209e-01f, 1.32963628e-01f, 2.17907965e-01f, -1.23397365e-01f,
  1.71848938e-01f, 2.25834250e-01f, -3.37577052e-02f, 2.09705085e-01f, 3.11672628e-01f, 3.13708723e-01f, -2.27022357e-02f, 2.02056140e-01f, 4.43848819e-02f, 1.19833708e-01f,
  -4.87640128e-02f, -4.18814756e-02f, 6.17351793e-02f, 1.83991164e-01f, -1.04793891e-01f, 3.03390175e-01f, -9.49567333e-02f, -1.79797322e-01f, 7.76558295e-02f, 1.10842496e-01f,
  3.31609339e-01f, -2.02863514e-01f, -6.62578363e-03f, 3.42644274e-01f, -1.95194080e-01f, -3.06239575e-02f, 3.91875990e-02f, 2.05117300e-01f, -1.12291705e-02f, 1.09244585e-01f,
  1.56743750e-01f, 3.26863825e-01f, 5.52654862e-02f, 9.40243900e-03f, -1.03213243e-01f, 7.50164241e-02f, -7.48617724e-02f, 1.75503612e-01f, -1.92297116e-01f, -5.07379286e-02f,
  -9.50891431e-03f, -1.56301007e-01f, -1.44331781e-02f, 1.26787305e-01f, 4.04384919e-02f, 6.86167777e-02f, 3.14790189e-01f, -3.81565899e-01f, -9.67557207e-02f, 1.10995166e-01f,
  7.90344626e-02f, 3.31009150e-01f, 1.83353797e-02f, 1.97690755e-01f, 1.09588780e-01f, -5.73964305e-02f, -1.99591070e-01f, 8.36521164e-02f, -9.96399596e-02f, 1.32355019e-01f,
  -1.19415805e-01f, 6.85017630e-02f, 1.02831587e-01f, 6.92004412e-02f, 3.46181214e-01f, -1.45225346e-01f, -1.37858137e-01f, 3.24015439e-01f, 1.97114676e-01f, 9.00283232e-02f,
  2.55105108e-01f, 9.21694711e-02f, -9.09826458e-02f, 1.25446498e-01f, 3.63141209e-01f, -6.95016310e-02f, -8.44170153e-02f, 1.45431459e-01f, -3.82090151e-01f, 1.43164098e-01f,
  2.01652125e-01f, -2.28566661e-01f, -2.88148433e-01f, -3.69026288e-02f, 3.90953332e-01f, -7.51729608e-02f, 1.98480293e-01f, -7.04294890e-02f, 1.00763164e-01f, -3.22987378e-01f,
  -2.60718763e-01f, 2.51873559e-03f, -1.74045771e-01f, -3.48930880e-02f, 2.57444590e-01f, 2.22768888e-01f, 1.27746746e-01f, 1.45344406e-01f, -1.26462674e-03f, 1.21493392e-01f,
  -1.02826439e-01f, 1.74463317e-01f, -1.49679333e-02f, 1.29246086e-01f, -1.05226323e-01f, -1.88577041e-01f, -3.41922641e-01f, -9.39961299e-02f, -7.07695931e-02f, 3.00653446e-02f,
  1.74863767e-02f, 3.45994234e-02f, -2.21278459e-01f, 1.82261527e-01f, 1.18529558e-01f, -1.11459740e-01f, 2.18052775e-01f, 2.56562918e-01f, -7.63759688e-02f, -1.31276891e-01f,
  -2.85338044e-01f, 1.46044701e-01f, 6.74395114e-02f, -3.83525431e-01f, -7.08602369e-02f, -2.36514248e-02f, 5.53840138e-02f, 4.24714610e-02f, 2.21780613e-01f, 3.01572025e-01f,
  4.97965030e-02f, -3.33335549e-02f, 1.09094843e-01f, 2.69679666e-01f, -2.22935945e-01f, -1.33528799e-01f, -3.82633097e-02f, -3.01224232e-01f, 1.37178779e-01f, -1.16893008e-01f,
  -3.26553762e-01f, 5.12968795e-03f, -1.23541594e-01f, 1.02255814e-01f, 9.75830257e-02f, 6.92878366e-02f, 1.54646710e-02f, -2.21803650e-01f, -1.74087156e-02f, 6.15794323e-02f,
  3.02827526e-02f, -1.55094594e-01f, 1.37456492e-01f, 1.24434017e-01f, -4.58836742e-02f, 3.53462845e-02f, 9.81578976e-02f, 1.08872965e-01f, 1.29159298e-02f, 3.29959512e-01f,
  2.42456570e-01f, 1.28651172e-01f, 6.54453039e-02f, 2.03506038e-01f, -1.08655915e-02f, -7.64365345e-02f, -3.23562741e-01f, 2.70729482e-01f, 1.01667076e-01f, -2.07709849e-01f,
  -1.06222168e-01f, 2.17872202e-01f, -1.89592272e-01f, -2.38682851e-02f, 6.67519122e-02f, -7.79646039e-02f, 4.14428413e-02f, 6.00658655e-02f, 1.54082328e-01f, 1.93035603e-01f,
  9.49605778e-02f, -1.05403423e-01f, 1.33588463e-01f, -1.19054936e-01f, -1.32704321e-02f, -1.06268004e-01f, 2.58642877e-03f, -2.77508777e-02f, 6.73374534e-02f, 1.34464115e-01f,
  5.54175079e-01f, -2.75446415e-01f, 9.81774554e-03f, -1.17024571e-01f, 1.81768313e-01f, 1.12005740e-01f, 2.56476969e-01f, -1.25255743e-02f, -3.40548068e-01f, -1.56042278e-01f,
  2.82237351e-01f, 4.75337684e-01f, 1.35586843e-01f, 1.00443102e-01f, -4.27092239e-02f, 3.49958474e-03f, -8.12331811e-02f, 1.94902405e-01f, -1.33063942e-02f, 1.40508711e-01f,
  1.50461107e-01f, -2.04158485e-01f, -1.31533340e-01f, 5.55691868e-02f, -7.55683407e-02f, 1.18757427e-01f, 4.67232615e-02f, 6.25089481e-02f, -9.84270424e-02f, -1.34177078e-02f,
  -1.66908100e-01f, -1.12855241e-01f, 1.23988464e-02f, -3.48955333e-01f, -1.01553909e-01f, -2.10940927e-01f, 1.38989598e-01f, -2.17044842e-03f, 1.95174664e-01f, 2.95540214e-01f,
  2.62426466e-01f, -1.04672357e-01f, 1.45942286e-01f, 4.16653976e-02f, -9.13097411e-02f, -2.76137382e-01f, -1.18077211e-01f, 2.46966466e-01f, 2.07680687e-01f, -4.22174521e-02f,
  6.88064843e-02f, 5.77622429e-02f, -1.04803033e-01f, -1.27450615e-01f, -2.13106960e-01f, 1.06491238e-01f, -4.92182709e-02f, 2.52437860e-01f, 1.06405228e-01f, 1.42529428e-01f,
  -1.93382084e-01f, -3.37687314e-01f, -7.29644224e-02f, -1.01556256e-01f, -1.18673168e-01f, 1.76950157e-01f, 4.74491082e-02f, 6.15129434e-02f, -2.85926729e-01f, 1.60349444e-01f,
  8.95472616e-02f, -9.52577125e-03f, -1.50174528e-01f, 4.40724529e-02f, 3.21414769e-01f, -5.95776886e-02f, 1.03658900e-01f, 2.22211760e-02f, 1.42071322e-01f, 2.38501593e-01f,
  1.57622427e-01f, -2.36502253e-02f, -1.09238997e-01f, 7.97476247e-02f, -2.97320217e-01f, 1.97529301e-01f, -4.84868586e-02f, -1.10312872e-01f, -1.27852648e-01f, 1.65494472e-01f,
  1.11301504e-01f, -2.26685610e-02f, 1.53666884e-01f, 1.41898841e-01f, -1.96590260e-01f, 2.00287238e-01f, 1.89442277e-01f, -1.43357009e-01f, -2.43995488e-02f, -2.12352760e-02f,
  -8.63547772e-02f, -5.47325723e-02f, -1.20958909e-01f, -1.26920298e-01f, 6.89308271e-02f, -4.55749407e-02f, 1.39126912e-01f, -4.24719080e-02f, -3.61346751e-02f, 1.25998318e-01f,
  -2.48506442e-01f, -1.36722177e-01f, 4.64358665e-02f, 6.89618476e-03f, 5.96032711e-04f, -1.05520435e-01f, -7.50314519e-02f, 1.33578435e-01f, -1.44930765e-01f, 5.59515655e-02f,
  -1.59340680e-01f, 1.88214928e-01f, -2.80176491e-01f, -4.76647466e-02f, -1.28752977e-01f, -4.37663078e-01f, -2.68050171e-02f, 7.04669803e-02f, 1.07189633e-01f, 6.00184910e-02f,
  2.15417340e-01f, 9.12342817e-02f, 1.26596645e-01f, 1.74556479e-01f, -1.20946549e-01f, -3.63645554e-02f, -3.27795669e-02f, -3.93296868e-01f, -9.52880234e-02f, -1.50472030e-01f,
  3.62981558e-01f, 1.42528176e-01f, -1.50265962e-01f, 6.19162470e-02f, 2.17791840e-01f, -2.66936481e-01f, 1.98885560e-01f, -1.06570072e-01f, -6.45944402e-02f, 1.49393663e-01f,
  -4.51407544e-02f, -2.73933619e-01f, -2.58377612e-01f, -2.79587954e-01f, -1.21350788e-01f, 9.55199171e-03f, -1.63573742e-01f, -2.58005500e-01f, 1.43665448e-02f, 2.55078077e-01f,
  2.54302621e-01f, -3.34104896e-01f, 1.47294730e-01f, 1.79598898e-01f, -2.11016126e-02f, 1.39490470e-01f, 6.62702620e-02f, 7.17340484e-02f, 2.91403592e-01f, 8.71683881e-02f,
  -1.24969527e-01f, -6.65947795e-02f, 7.36282095e-02f, 2.21333399e-01f, -1.43861189e-01f, -4.82797846e-02f, -2.66614873e-02f, 4.66567636e-01f, -2.55655169e-01f, -1.40942051e-04f,
  1.21691696e-01f, -1.51424989e-01f, -4.60462086e-03f, -6.39348254e-02f, -1.99647754e-01f, 3.52928162e-01f, -4.58813272e-02f, -2.54504499e-03f, 2.01840445e-01f, -2.02681161e-02f,
  2.28611797e-01f, 3.59705418e-01f, 1.30925506e-01f, 6.32932456e-03f, -2.13510603e-01f, -2.15789750e-01f, 1.24910027e-02f, -1.76636666e-01f, -1.70750126e-01f, -1.33319169e-01f,
  -5.16814105e-02f, 1.02575809e-01f, -1.67979449e-01f, 4.09047715e-02f, -4.03241426e-01f, 1.76180959e-01f, 2.01625302e-01f, -3.11681807e-01f, 9.75721031e-02f, 9.33150426e-02f,
  -1.87022611e-01f, 1.44456670e-01f, 3.21639121e-01f, 8.43617395e-02f, -1.56796351e-01f, 1.03992157e-01f, 5.09381853e-02f, 4.88902442e-02f, 6.38463795e-02f, 2.59383738e-01f,
  1.69125968e-03f, 2.98103601e-01f, 3.23790044e-01f, 1.62045613e-01f, -3.90244350e-02f, -3.64482731e-01f, 1.14997989e-02f, 9.89359543e-02f, 1.56118214e-01f, -1.69078469e-01f,
  -2.54470464e-02f, 7.79915303e-02f, -5.46381660e-02f, -2.09820896e-01f, 1.26287878e-01f, 1.89712256e-01f, 1.26448020e-01f, -9.09748953e-03f, 3.31317127e-01f, -8.72298703e-02f,
  -6.88044950e-02f, -8.87958705e-02f, 1.73319191e-01f, -1.81007162e-01f, -1.88173160e-01f, 2.98244599e-02f, 1.42452329e-01f, 1.01506345e-01f, 1.75791323e-01f, -1.62670180e-01f,
  1.93957701e-01f, 1.70570999e-01f, 8.73528942e-02f, 4.76113558e-01f, 5.34277968e-02f, 1.49500057e-01f, -1.84183806e-01f, 1.42003313e-01f, -7.35156834e-02f, -2.85987444e-02f,
  1.75929800e-01f, 1.05860636e-01f, 2.33978748e-01f, -9.92081091e-02f, 8.75634402e-02f, -7.98691735e-02f, 2.65833229e-01f, 2.95788318e-01f, 3.30958399e-04f, 1.38711846e-02f,
  2.98532397e-02f, -1.61665201e-01f, 1.54267341e-01f, -1.40352458e-01f, 1.46402270e-01f, 8.27361271e-02f, 1.41804919e-01f, 9.16369036e-02f, -2.43729889e-01f, 1.22402631e-01f,
  1.15238488e-01f, -1.37923151e-01f, 1.48139998e-01f, -6.66743740e-02f, -8.59248191e-02f, 1.11426279e-01f, 9.90390331e-02f, 5.39832264e-02f, -2.31480062e-01f, -1.57158859e-02f,
  3.82215790e-02f, -1.31376773e-01f, 2.55129516e-01f, 1.68811306e-01f, 3.10037494e-01f, 3.92619148e-02f, 9.65302736e-02f, 2.52770633e-01f, 3.08792461e-02f, -3.40871699e-02f,
  1.77470759e-01f, -1.65229529e-01f, 1.65161967e-01f, 7.16952533e-02f, -7.54443258e-02f, -1.90847620e-01f, 4.77380380e-02f, 1.86442479e-01f, -2.30213329e-01f, -1.86613426e-01f,
  -2.80770250e-02f, -1.05315382e-02f, -9.44785774e-02f, 2.56347805e-02f, 1.06730752e-01f, -2.80546844e-02f, 2.44433675e-02f, -3.57421562e-02f, 1.49053708e-01f, -1.20476753e-01f,
  -1.13197729e-01f, 2.01687917e-01f, 5.26060015e-02f, 1.12793697e-02f, 3.18624638e-02f, -4.46303338e-02f, 4.17143941e-01f, -1.79974586e-02f, -1.11299746e-01f, 5.46381772e-01f,
  -3.23621154e-01f, -5.69056235e-02f, -1.52188554e-01f, 7.88698569e-02f, 1.01406418e-01f, -2.59924363e-02f, 2.82223616e-02f, 1.47640198e-01f, 7.81895742e-02f, 7.97980577e-02f,
  1.51973516e-01f, -2.30422802e-02f, -4.54605408e-02f, 1.25255406e-01f, 1.67591572e-01f, 1.69107258e-01f, -1.85711488e-01f, -6.36756085e-05f, 8.05518553e-02f, 1.18442647e-01f,
  1.46232396e-02f, -1.06578946e-01f, -7.69921695e-04f, 1.56570926e-01f, -2.73528248e-02f, -1.68999508e-01f, 2.06846982e-01f, -1.96040705e-01f, -3.98881100e-02f, 3.04820180e-01f,
  2.68901080e-01f, -1.59604982e-01f, -9.93875638e-02f, 2.73510158e-01f, 2.25503728e-01f, -1.28293112e-01f, -1.16899662e-01f, 1.01150356e-01f, -1.62323043e-02f, 1.26810312e-01f,
  8.46632048e-02f, 1.05514109e-01f, -2.56174337e-02f, -1.59200072e-01f, -1.37100399e-01f, 1.57094114e-02f, 2.48787105e-02f, 1.04310192e-01f, 2.20306829e-01f, 3.00550014e-01f,
  -9.73123163e-02f, 3.88843454e-02f, -9.33673978e-02f, -1.09429456e-01f, -6.80549294e-02f, 3.11527550e-01f, -2.81503379e-01f, 3.20008665e-01f, 9.41848382e-02f, -1.33149028e-01f,
  5.91044426e-02f, -1.06469365e-02f, -1.12176612e-01f, 7.49214664e-02f, -2.35814035e-01f, -3.41834515e-01f, -3.74655515e-01f, -9.18774456e-02f, 2.15844736e-01f, -4.93276976e-02f,
  2.25271553e-01f, -2.02914000e-01f, -2.37900559e-02f, 1.35852918e-01f, 2.91079611e-01f, -8.71716738e-02f, -1.03711836e-01f, 2.98179686e-01f, 1.96914390e-01f, 6.92607090e-02f,
  1.76439092e-01f, 1.98980361e-01f, 2.17503533e-01f, 2.38952674e-02f, 2.37386137e-01f, -5.04240906e-03f, -3.78269851e-01f, -1.21519744e-01f, 1.66026339e-01f, 1.28561288e-01f,
  1.62331626e-01f, -1.55067936e-01f, 3.10074449e-01f, 3.61289494e-02f, -1.59026325e-01f, -2.05770787e-02f, 1.61039576e-01f, 1.51533276e-01f, 2.80019671e-01f, -2.13163532e-02f,
  2.08264992e-01f, 1.30471230e-01f, -2.05826223e-01f, 1.62085906e-01f, 2.71740496e-01f, 8.33233967e-02f, 1.21994115e-01f, -1.06265932e-01f, 1.77423611e-01f, -1.83661226e-02f,
  1.41225874e-01f, -1.53066665e-01f, 2.72598267e-01f, 2.58128136e-01f, 1.91947594e-01f, 2.68483460e-01f, -2.80462116e-01f, -1.76304236e-01f, -1.45374194e-01f, 5.33118993e-02f,
  5.93124218e-02f, -4.60398436e-01f, -9.84431282e-02f, 4.56965901e-02f, 4.08671387e-02f, 8.71132761e-02f, 1.15442842e-01f, -2.00400390e-02f, -3.02489519e-01f, 2.63011128e-01f,
  -1.39061250e-02f, -3.73757072e-02f, -1.65434869e-03f, -2.60944255e-02f, -1.19430996e-01f, 1.91512465e-01f, -9.81293246e-02f, -2.67874561e-02f, 1.92958146e-01f, 3.12080443e-01f,
  5.22030704e-02f, -2.60737568e-01f, 1.33634537e-01f, 2.44311348e-01f, -1.17387645e-01f, -1.40893795e-02f, -1.25651211e-01f, 7.30664358e-02f, 1.42847523e-01f, -1.09880336e-01f,
  -2.05400102e-02f, -7.82871693e-02f, -2.33541075e-02f, -3.12374830e-02f, 3.50097232e-02f, -9.08353478e-02f, -1.83242097e-01f, -1.70112059e-01f, -1.41244963e-01f, -5.40778153e-02f,
  1.60562266e-02f, 1.39360800e-01f, -5.84094338e-02f, -7.86919296e-02f, 4.30985633e-03f, -4.66888025e-02f, 6.83931857e-02f, -3.35508347e-01f, -1.04258105e-01f, -1.81789711e-01f,
  -8.41778666e-02f, 1.77934323e-03f, -8.15529600e-02f, 2.33781502e-01f, 5.44050559e-02f, -4.38277163e-02f, -1.97859928e-01f, 5.88961551e-03f, -1.92857146e-01f, 1.74076468e-01f,
  6.61015287e-02f, -3.51729281e-02f, -4.67971824e-02f, 1.25353247e-01f, 1.05324283e-01f, 1.40170217e-01f, 1.72546729e-01f, 1.48070097e-01f, -5.58012836e-02f, -5.44464327e-02f,
  2.60915577e-01f, -9.63464975e-02f, -1.34406447e-01f, -1.32903963e-01f, 1.22539870e-01f, 3.18365484e-01f, 1.71903670e-01f, -9.24363285e-02f, 1.69291735e-01f, -8.08734819e-03f,
  3.52274030e-02f, -9.59170833e-02f, 2.90236287e-02f, 2.29230970e-01f, -8.00366551e-02f, -3.16940658e-02f, 1.00214824e-01f, -1.46123068e-02f, 6.52190819e-02f, 1.15168512e-01f,
  1.56865731e-01f, -1.53157279e-01f, 3.05465721e-02f, 5.53492643e-02f, 7.63397813e-02f, -3.03700436e-02f, -4.27530073e-02f, -4.12998209e-03f, 1.75984517e-01f, -2.00893776e-03f,
  6.81266189e-02f, -1.85024232e-01f, 6.60056621e-02f, -6.91161007e-02f, 6.18559644e-02f, 2.05072135e-01f, 1.64613143e-01f, 1.55806988e-01f, 1.63371101e-01f, -1.00912899e-01f,
  -9.11239162e-02f, 2.40932971e-01f, 2.00245708e-01f, 7.32223988e-02f, -2.08001629e-01f, 4.69434299e-02f, -3.47678661e-02f, -1.37879699e-01f, -6.73316643e-02f, 1.63274437e-01f,
  2.97097433e-02f, 2.65480820e-02f, 5.92725836e-02f, -7.90452138e-02f, 1.88809708e-01f, 2.13644847e-01f, -1.05136208e-01f, 2.04864353e-01f, -7.84606300e-03f, 2.64034182e-01f,
  -6.64965585e-02f, -3.43227506e-01f, 2.15848505e-01f, 2.34657273e-01f, -1.98224634e-01f, 3.16082865e-01f, -3.65880221e-01f, -4.13764805e-01f, -3.78740638e-01f, -1.21633157e-01f,
  -2.46307310e-02f, -4.42667790e-02f, -6.80032447e-02f, 1.44343287e-01f, -3.93703543e-02f, -2.36831680e-02f, 2.27743573e-02f, -1.02897756e-01f, 2.61646807e-01f, 4.28553969e-02f,
  -8.34597126e-02f, 3.74247842e-02f, -3.34355325e-01f, -4.25330177e-02f, 1.59007877e-01f, 8.87696892e-02f, -3.61824967e-02f, 4.57883701e-02f, 5.57974614e-02f, 4.48357195e-01f,
  2.48237416e-01f, 2.40967721e-02f, -3.44504654e-01f, -2.22417355e-01f, -2.98661411e-01f, 5.70208542e-02f, -3.14823121e-01f, -1.05267232e-02f, -6.96324259e-02f, -3.92069705e-02f,
  -3.19367237e-02f, 2.71540675e-02f, -4.66172956e-02f, 8.40005949e-02f, 5.07737435e-02f, -6.67608604e-02f, 8.04458372e-03f, 1.48999497e-01f, 1.43034339e-01f, 1.32734820e-01f,
  1.66189641e-01f, -3.30180377e-02f, 2.55129874e-01f, -1.10196985e-01f, 1.67626411e-01f, 2.57310778e-01f, 1.02446362e-01f, 2.08049715e-01f, -5.43311715e-01f, -7.82492161e-02f,
  1.75530240e-01f, 3.95325348e-02f, 2.94232428e-01f, -1.23359933e-01f, 1.75179288e-01f, -9.02365446e-02f, -1.39922976e-01f, 1.55854270e-01f, 1.17475741e-01f, -5.42898253e-02f,
  5.41626289e-02f, 1.56476796e-01f, 2.90189236e-01f, -1.16682285e-02f, -9.46906731e-02f, 4.06297818e-02f, -1.88563079e-01f, 2.11429387e-01f, 2.13728160e-01f, 1.89967528e-01f,
  5.16774058e-02f, -2.72951692e-01f, 1.18477426e-01f, -4.44701947e-02f, 3.57348174e-02f, -2.08216667e-01f, 1.39631242e-01f, -2.45979786e-01f, -4.48968232e-01f, 8.49572569e-02f,
  -1.05251014e-01f, -2.70602614e-01f, -1.88454419e-01f, -2.20026672e-01f, 1.38299331e-01f, -2.14452092e-02f, -5.07924752e-03f, 1.42156899e-01f, -5.75164594e-02f, 1.25418216e-01f,
  -1.70687273e-01f, 2.57086098e-01f, 5.57656866e-03f, -2.98254877e-01f, -1.47664994e-01f, -8.72535855e-02f, 1.36907808e-02f, -1.23268440e-01f, -9.03134942e-02f, 1.01865105e-01f,
  -4.27920014e-01f, 1.18313797e-01f, -7.84918815e-02f, -4.86238524e-02f, 1.94142744e-01f, 1.83155432e-01f, -1.02987863e-01f, 9.43306535e-02f, -2.16095094e-02f, -8.08105990e-02f,
  1.72042593e-01f, -3.83481443e-01f, 1.38956189e-01f, 7.92671815e-02f, 2.81289876e-01f, -1.53627828e-01f, -1.96623970e-02f, 2.34835193e-01f, 1.79761630e-02f, -2.47462064e-01f,
  3.82317871e-01f, 1.08318865e-01f, -1.71953008e-01f, 5.70861399e-01f, -1.32018462e-01f, -1.44421250e-01f, -2.35799506e-01f, -1.62254736e-01f, -2.22103596e-02f, -1.20991049e-02f,
  8.93758796e-03f, 2.71028191e-01f, 1.69358402e-01f, 6.92613870e-02f, 3.15794200e-02f, -1.21196091e-01f, 4.13574636e-01f, 1.21551141e-01f, 1.92915931e-01f, 6.93669021e-02f,
  -9.85595286e-02f, 8.63855705e-02f, -4.47938330e-02f, 2.13527411e-01f, 2.67879441e-02f, -1.16437204e-01f, 2.90904772e-02f, 4.13870841e-01f, 1.55294105e-01f, 4.43865433e-02f,
  7.55206421e-02f, -8.20526928e-02f, 7.91834593e-02f, 3.02602142e-01f, 1.17800780e-01f, -8.87184311e-03f, -2.86896620e-02f, 7.95440599e-02f, 1.12668619e-01f, -5.51381744e-02f,
  -2.35701695e-01f, 1.99615080e-02f, -1.48479640e-01f, 8.48580822e-02f, -1.46844070e-02f, 1.57894805e-01f, 8.34673271e-02f, -1.64745077e-01f, -8.80401880e-02f, 2.44380355e-01f,
  -7.07777068e-02f, -2.13835612e-02f, 6.52765110e-03f, 1.14322647e-01f, 8.80757049e-02f, 1.01292267e-01f, -3.46584737e-01f, -9.52004567e-02f, 2.95317285e-02f, 1.57686606e-01f,
  2.49209017e-01f, 8.46620798e-02f, 1.26522586e-01f, 4.30984527e-01f, 4.70836014e-01f, 1.94340125e-01f, 1.58102930e-01f, 1.96929500e-01f, -4.10105109e-01f, -3.23971480e-01f,
  1.42557979e-01f, -2.18060315e-02f, 1.15320854e-01f, 6.26736581e-02f, 8.48839581e-02f, 6.04795441e-02f, 8.18697661e-02f, -9.47674289e-02f, -9.13731828e-02f, 2.14442685e-01f,
  2.76781201e-01f, -3.63393649e-02f, -8.10863823e-02f, -2.83041853e-03f, -3.16632032e-01f, 8.91530588e-02f, 1.17506415e-01f, -1.45026445e-01f, 1.56878401e-02f, 2.46566869e-02f,
  4.45759833e-01f, 3.66029084e-01f, 2.02210799e-01f, 2.08251670e-01f, -1.24168515e-01f, -2.05743819e-01f, -2.02117376e-02f, 1.27503037e-01f, 9.39249992e-02f, 2.84743104e-02f,
  -2.82480232e-02f, 1.83078170e-01f, -8.05170387e-02f, 3.09382051e-01f, -2.77407646e-01f, -6.81636184e-02f, 2.15080470e-01f, 1.59787789e-01f, 7.65513768e-03f, -7.93869793e-02f,
  2.53358394e-01f, 2.47575685e-01f, -5.36494330e-02f, 7.24110380e-02f, -3.05968951e-02f, 1.51577964e-01f, -2.07547933e-01f, 3.30786526e-01f, -1.07745953e-01f, 8.54789000e-03f,
  -6.15308546e-02f, 2.26511523e-01f, 2.16496706e-01f, 2.95173675e-01f, -2.34260857e-02f, -1.44516388e-02f, -1.50449455e-01f, -1.25210464e-01f, 6.21361136e-02f, 2.25937784e-01f,
  7.70025998e-02f, 3.82606417e-01f, -3.03947330e-02f, -3.27625632e-01f, -5.69247939e-02f, -1.17452025e-01f, -8.77120867e-02f, 1.27874464e-01f, -2.39274472e-01f, 3.15854512e-02f,
  -5.96788749e-02f, -2.08295330e-01f, 4.56161192e-03f, -3.66679579e-02f, 4.07883346e-01f, -1.17005140e-01f, -1.83588378e-02f, 1.60865307e-01f, -2.75947481e-01f, 5.10623120e-02f,
  -3.89067605e-02f, -1.53506592e-01f, -1.84250548e-01f, -3.50204706e-02f, 9.14309621e-02f, 1.53943822e-01f, 1.14253536e-01f, 1.41486406e-01f, -1.95541054e-01f, -6.19043298e-02f,
  -1.82512239e-01f, 1.47583395e-01f, -1.36289179e-01f, 6.55216724e-02f, -7.44745973e-03f, 1.32472590e-02f, -1.80463687e-01f, 2.39231866e-02f, 8.21074843e-03f, 1.36173353e-01f,
  5.13717942e-02f, 3.20571601e-01f, -4.19173315e-02f, 1.55952573e-01f, 2.94892550e-01f, 1.43611476e-01f, -4.15993221e-02f, 1.79156944e-01f, 8.16115513e-02f, -7.94509947e-02f,
  -1.74395889e-01f, 1.10792883e-01f, 9.65513289e-02f, 2.12357447e-01f, -7.95917436e-02f, -1.30555063e-01f, 1.73570588e-01f, 5.26678574e-04f, 1.55515894e-01f, 1.70053422e-01f,
  2.69268095e-01f, 8.12801495e-02f, 1.73404887e-01f, 7.54886195e-02f, -2.20954224e-01f, 3.10905844e-01f, -1.20282374e-01f, -2.82429487e-01f, 6.59222156e-02f, 8.33002478e-02f,
  8.02265182e-02f, 1.32355481e-01f, -1.01572052e-01f, -2.05493625e-02f, -9.27316695e-02f, 4.95322756e-02f, 1.62816286e-01f, 2.00355679e-01f, 1.60632968e-01f, 1.55438706e-01f,
  -1.17563672e-01f, 1.19552657e-01f, -6.98732212e-02f, 8.08964595e-02f, 6.20781817e-02f, -1.97070897e-01f, -9.92674567e-03f, -8.46072659e-02f, 3.79082710e-01f, 4.05079909e-02f,
  1.78888530e-01f, 1.50912061e-01f, -1.29129469e-01f, -2.74107665e-01f, -3.99004072e-02f, -4.60975394e-02f, -2.99890116e-02f, -2.13969633e-01f, -1.61895573e-01f, 2.26108104e-01f,
  1.55500039e-01f, -1.88584030e-02f, 5.22280149e-02f, -9.22817811e-02f, 7.55596086e-02f, 2.12982446e-01f, 2.20764831e-01f, -6.30660877e-02f, 6.89447895e-02f, -1.03826765e-02f,
  8.12573638e-03f, -1.11283988e-01f, 1.82574928e-01f, 2.85748094e-01f, -4.41170484e-02f, 3.14859271e-01f, 1.54982790e-01f, -1.57950893e-01f, -3.07436466e-01f, 2.88700670e-01f,
  1.39632225e-01f, 1.48169234e-01f, -3.93912941e-02f, 2.09129192e-02f, 1.07851796e-01f, 2.20966026e-01f, -1.62249982e-01f, -3.82996015e-02f, -9.08501148e-02f, -2.07147717e-01f,
  -2.71079928e-01f, -1.58080176e-01f, -1.64693639e-01f, 1.92105025e-01f, -5.56085892e-02f, -3.18614505e-02f, 1.47122249e-01f, 6.51010051e-02f, -2.31472999e-01f, 1.96719900e-01f,
  1.98872358e-01f, 2.74796903e-01f, -1.87329918e-01f, 3.48485820e-02f, -1.40626416e-01f, -6.19230559e-03f, -8.09966028e-02f, 3.46680433e-01f, 2.16962487e-01f, -2.68242322e-02f,
  3.26241553e-01f, 4.30546582e-01f, 2.09323213e-01f, -3.68604422e-01f, 2.49470115e-01f, 1.67173922e-01f, -9.84349400e-02f, -1.91274211e-01f, 7.36987069e-02f, -3.08093995e-01f,
  -5.01185395e-02f, -4.20798868e-01f, 1.28679927e-02f, 1.51002973e-01f, 1.12947829e-01f, 9.00750831e-02f, 3.17495167e-01f, -5.94543517e-02f, 3.70402306e-01f, 1.64618403e-01f,
  2.19949886e-01f, -2.18932167e-01f, -3.81265506e-02f, 3.94845337e-01f, 4.62145619e-02f, -1.44681469e-01f, 3.52403790e-01f, 3.60915922e-02f, -2.04760134e-02f, 2.36537606e-01f,
  2.05379888e-01f, 5.89136600e-01f, -1.29376546e-01f, 4.01531011e-01f, -4.19011107e-03f, -7.13043064e-02f, 1.73332527e-01f, 9.33117867e-02f, 3.04184407e-01f, 1.81455255e-01f,
  9.42259878e-02f, 2.04510450e-01f, -1.92998767e-01f, -8.98415074e-02f, 1.20844096e-01f, 3.45488340e-01f, 1.31552964e-01f, -1.78357676e-01f, -3.08065534e-01f, -7.52839446e-03f,
  -1.88329071e-01f, 9.39671621e-02f, 1.27188265e-02f, -2.69665793e-02f, 6.35813922e-02f, -1.15539379e-01f, -2.81993210e-01f, -1.08955234e-01f, -3.50215919e-02f, 1.64354779e-02f,
  2.00654089e-01f, 7.34683201e-02f, -5.69652824e-04f, 9.51833501e-02f, 6.46024793e-02f, 2.40218882e-02f, -1.52820930e-01f, -7.05490028e-03f, 2.21335411e-01f, -6.70972392e-02f,
  -8.06287304e-03f, 2.33408958e-01f, 1.90341055e-01f, -1.02250189e-01f, -2.50593632e-01f, 2.03497171e-01f, 1.69160441e-01f, -1.60322770e-01f, -2.50105083e-01f, -1.90996572e-01f,
  2.16839299e-01f, 9.49136615e-02f, 3.73597264e-01f, -6.70483828e-01f, -9.43701938e-02f, -2.00215861e-01f, -1.40833780e-01f, 2.83378184e-01f, -9.44619346e-03f, -4.86520752e-02f,
  3.17659140e-01f, -1.75487876e-01f, -7.82783329e-03f, -2.70995229e-01f, -1.00312233e-01f, 5.83585091e-02f, 1.12108663e-01f, 1.13199227e-01f, 1.88542858e-01f, -2.57760048e-01f,
  -8.04135352e-02f, -8.31266865e-02f, 1.61729708e-01f, 2.03134328e-01f, 1.60241816e-02f, 4.52286415e-02f, -2.34340042e-01f, -4.90045011e-01f, 2.70090818e-01f, 1.02319699e-02f,
  3.30198705e-01f, 1.60105512e-01f, -1.72510341e-01f, 3.28577667e-01f, 3.12032440e-04f, -1.14199959e-01f, -9.41061676e-02f, 2.65837222e-01f, -9.80410492e-04f, 1.71322614e-01f,
  -1.12143770e-01f, -5.75763658e-02f, -1.49935246e-01f, 1.38678730e-01f, 3.22338372e-01f, 1.68239847e-01f, 1.20114096e-01f, -1.24633968e-01f, 4.17454541e-02f, -1.38724566e-01f,
  -4.30090204e-02f, -4.45390522e-01f, 2.81202197e-02f, 1.67496309e-01f, -1.11784667e-01f, -1.18428580e-01f, 3.47954452e-01f, -4.79062684e-02f, 3.32912296e-01f, -2.65832961e-01f,
  -3.88323963e-02f, 1.73773155e-01f, 2.59893294e-02f, -1.18104750e-02f, -1.26412258e-01f, 1.24947198e-01f, 1.67598739e-01f, 4.57833260e-01f, 1.72940552e-01f, 1.26140118e-01f,
  1.39885787e-02f, 9.72710103e-02f, -7.19727501e-02f, -1.74025998e-01f, -1.31318629e-01f, 4.37243372e-01f, 9.12852213e-02f, 1.48610786e-01f, -1.14565127e-01f, -8.55011120e-02f,
  -1.02901414e-01f, -5.54940924e-02f, -1.27461753e-04f, 1.17666200e-02f, 1.00593954e-01f, -8.30220655e-02f, 2.45387778e-01f, 8.58599693e-02f, -2.05948576e-01f, 8.76774266e-02f,
  1.79132462e-01f, -5.18739343e-01f, 5.53761125e-01f, 2.97458977e-01f, 2.66350269e-01f, -2.51419187e-01f, 3.67020629e-02f, 2.07262814e-01f, -1.28891379e-01f, 1.19673893e-01f,
  -9.26713720e-02f, -9.29228887e-02f, 1.67363554e-01f, 1.43160000e-01f, -2.52573222e-01f, -5.39270882e-03f, -1.88559309e-01f, 8.85500945e-03f, 3.64272475e-01f, -8.19288045e-02f,
  1.80686712e-02f, 1.15432605e-01f, -8.50876048e-02f, 3.24254297e-02f, -1.64120808e-01f, -2.66375005e-01f, 2.09094316e-01f, 2.03945071e-01f, -4.50434070e-03f, 2.88551211e-01f,
  4.26162988e-01f, -4.22465466e-02f, 2.11207904e-02f, 1.56187937e-01f, 1.98337048e-01f, -1.80996895e-01f, -5.35466224e-02f, -1.44357327e-02f, 2.11160481e-01f, 9.79029089e-02f,
  8.67950544e-02f, 7.53886551e-02f, 6.95926398e-02f, -1.04270637e-01f, 9.50683504e-02f, 9.58391950e-02f, -5.92524782e-02f, -3.23224813e-02f, 1.36079013e-01f, 1.51678264e-01f,
  1.45722941e-01f, -1.04307570e-01f, 8.78977925e-02f, -1.85470611e-01f, 1.69222146e-01f, -1.51730767e-02f, 1.35524869e-01f, -3.86929452e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -4.96973023e-02f, 1.37206256e-01f, 1.04982540e-01f, 1.07000634e-01f, 2.01557085e-01f, 1.87261343e-01f, 1.75054133e-01f, -3.23204100e-02f, 5.42293973e-02f, -5.17725013e-02f,
  4.34421748e-02f, -5.91765903e-02f, -4.69914898e-02f, -6.81409091e-02f, 7.85997435e-02f, 9.37266797e-02f, -6.72709942e-02f, 1.32709712e-01f, -6.00780845e-02f, 8.56288001e-02f,
  2.41729189e-02f, 1.01447761e-01f, 3.29748318e-02f, 1.03006743e-01f, 1.48733571e-01f, 1.49269924e-01f, -1.34329557e-01f, 6.10945933e-02f, -3.21365632e-02f, 2.64278613e-02f,
  1.36106908e-02f, 1.77101910e-01f, 2.38855761e-02f, 4.97017279e-02f, -1.12421475e-01f, 3.76244844e-03f, -1.18991375e-01f, 4.04444486e-02f, 2.20060125e-01f, -8.23873430e-02f,
  -2.17969492e-02f, 4.46414948e-03f, 6.28103018e-02f, 1.72259714e-02f, 1.33360565e-01f, 8.70269164e-02f, 1.16433471e-01f, -2.13598739e-02f, 6.12714030e-02f, 1.28684923e-01f,
  -3.04252040e-02f, 1.46479025e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -3.07789057e-01f, -1.39205635e-01f, -1.01169869e-01f, -1.80747509e-01f, 1.19125113e-01f, -1.54624388e-01f, -1.49128750e-01f, 1.06543243e-01f, -3.05403978e-01f, -4.88279574e-02f,
  -2.77720660e-01f, 1.50725856e-01f, -2.36831203e-01f, -6.75715804e-02f, -2.89651841e-01f, 5.15616452e-03f, -4.12273586e-01f, -2.16337427e-01f, -6.77508414e-02f, -1.29313413e-02f,
  1.39689490e-01f, 1.73133463e-01f, 1.41119570e-01f, 3.84257995e-02f, -1.59135520e-01f, 2.57692695e-01f, -6.64616153e-02f, 1.62727624e-01f, 1.77759647e-01f, -4.52632427e-01f,
  3.33218947e-02f, -7.30047286e-01f, 6.71401471e-02f, -2.18498241e-02f, -3.21609885e-01f, -1.81277350e-01f, 1.35407448e-02f, -4.95997697e-01f, 8.00404176e-02f, -1.47568852e-01f,
  3.88991535e-02f, 8.06051195e-02f, -4.38427567e-01f, -5.08741975e-01f, -9.58345309e-02f, -3.10225606e-01f, -5.73685467e-01f, -1.85488477e-01f, 1.96194097e-01f, 8.52085091e-03f,
  -1.06196161e-02f, 1.67849436e-01f, -1.53212026e-01f, 1.77008927e-01f, -6.95809573e-02f, -1.65756494e-01f, -1.59868568e-01f, -4.73415434e-01f, -4.07109201e-01f, -1.69285648e-02f,
  1.94281876e-01f, -6.97726980e-02f, -7.12984204e-02f, -5.00653684e-02f, -2.81570673e-01f, 1.41391560e-01f, -2.70714074e-01f, -1.39303813e-02f, -3.65297273e-02f, -1.82379305e-01f,
  1.36551961e-01f, -1.40215993e-01f, 2.44701698e-01f, 2.56335646e-01f, -2.00498268e-01f, 5.42361796e-01f, 6.73295418e-03f, 6.64094016e-02f, -2.09663570e-01f, 1.29226774e-01f,
  1.23110682e-01f, -1.48522615e-01f, 1.11001030e-01f, 1.88998625e-01f, 3.68919611e-01f, -1.12867527e-01f, -3.24500538e-02f, 5.15909195e-02f, -2.72043258e-01f, 2.38143176e-01f,
  -1.38802724e-02f, 1.03022851e-01f, 2.23367423e-01f, -1.70314044e-01f, -1.56824231e-01f, -1.86594620e-01f, 1.56303555e-01f, -2.87341714e-01f, 8.11361149e-03f, 8.62973854e-02f,
  -4.11061674e-01f, 3.36914435e-02f, 1.81123819e-02f, -9.03153047e-02f, 1.78323418e-01f, -1.15143739e-01f, 2.45907134e-03f, -4.63399068e-02f, -9.52709373e-03f, 2.07481980e-01f,
  -7.56630525e-02f, -4.37016517e-01f, 7.09623622e-04f, 1.22131988e-01f, 1.99201137e-01f, 5.79486862e-02f, -9.67800543e-02f, -3.64638423e-03f, -3.47561181e-01f, 1.96972013e-01f,
  1.96174696e-01f, -4.77928430e-01f, -1.16560787e-01f, -1.13985501e-01f, -2.82937527e-01f, -8.57503153e-03f, 8.48052278e-03f, 4.66782860e-02f, -3.25873792e-02f, 1.03383385e-01f,
  -6.98520290e-03f, 7.24033937e-02f, -1.36540875e-01f, 3.74211594e-02f, -2.64585376e-01f, 1.45675898e-01f, 2.80540287e-01f, 3.21725577e-01f, 1.75160348e-01f, -5.20072319e-03f,
  -3.50524992e-01f, 1.41843721e-01f, -2.80246347e-01f, -2.91798770e-01f, -2.68359512e-01f, 6.90613762e-02f, 1.16354853e-01f, -2.13784114e-01f, 6.26240075e-02f, -2.13776246e-01f,
  -2.90129799e-02f, 8.72381553e-02f, 2.04931766e-01f, -3.35500017e-02f, -4.18042451e-01f, -6.05897367e-01f, -2.87762463e-01f, 1.92683622e-01f, -6.05187081e-02f, -5.00722110e-01f,
  -1.55239686e-01f, -1.49981022e-01f, -4.07433778e-01f, -2.92425066e-01f, 7.86224976e-02f, -3.95975187e-02f, -1.38707668e-01f, 7.03391507e-02f, -1.43677399e-01f, 2.56458253e-01f,
  -5.37355661e-01f, -3.15038711e-01f, -2.17318293e-02f, 1.15090996e-01f, -2.33962655e-01f, 6.13409502e-04f, -8.38103592e-02f, 1.02034263e-01f, 1.96017593e-01f, 2.83815622e-01f,
  -9.11406204e-02f, 5.87313324e-02f, -1.60776507e-02f, -5.86686790e-01f, 1.01733260e-01f, 4.24046516e-02f, 3.47174481e-02f, 1.96783990e-01f, -7.18868896e-02f, -3.46375614e-01f,
  3.70018870e-01f, 7.00471625e-02f, -2.11843718e-02f, 7.06990361e-02f, -6.44840375e-02f, -5.58080524e-02f, 2.62462124e-02f, -1.05115563e-01f, 2.17673361e-01f, -2.10036300e-02f,
  1.76506475e-01f, -1.56772267e-02f, -6.06926195e-02f, 2.10213169e-01f, -1.09264940e-01f, -4.12242562e-01f, -6.45404533e-02f, -1.67401895e-01f, -2.69800901e-01f, -3.29675347e-01f,
  -4.59730417e-01f, -2.52963543e-01f, -2.08215311e-01f, -4.93142605e-01f, -1.91266343e-01f, -3.17963600e-01f, -9.64686647e-02f, -9.28190723e-02f, 1.28339872e-01f, -1.53027281e-01f,
  -3.01690578e-01f, -2.54399657e-01f, 8.11370164e-02f, 9.47207287e-02f, -2.47954249e-01f, 1.89350143e-01f, -2.24107400e-01f, -1.02888539e-01f, 1.81451067e-01f, -1.29558533e-01f,
  -3.77365142e-01f, -5.66675290e-02f, -2.87775159e-01f, -5.02368761e-03f, 4.85426076e-02f, -2.99107671e-01f, 9.78377536e-02f, -2.43975207e-01f, -3.78763139e-01f, -2.06040308e-01f,
  -1.12480596e-02f, -2.46109009e-01f, -3.99402082e-01f, -1.07027357e-02f, -2.86486208e-01f, 8.19765553e-02f, 2.81197820e-02f, -2.99436897e-01f, -4.45641607e-01f, -1.50424883e-01f,
  4.75650420e-03f, 9.93771255e-02f, 1.92216828e-01f, 1.63636565e-01f, 2.48842593e-02f, 3.99004757e-01f, 8.57231990e-02f, -1.89477429e-01f, -2.04293087e-01f, 1.24644130e-01f,
  -1.97234452e-02f, -4.35714275e-02f, 2.76140243e-01f, 3.09703737e-01f, 6.43188283e-02f, -7.99840838e-02f, 3.16692770e-01f, -2.63528764e-01f, 5.85024431e-02f, -2.27477446e-01f,
  -1.90035142e-02f, -1.38628528e-01f, 1.66809201e-01f, -1.18299231e-01f, 2.73240786e-02f, -2.39585429e-01f, -2.71128774e-01f, -6.87828511e-02f, 1.11489166e-02f, -1.17716752e-01f,
  -1.25303883e-02f, -1.80550084e-01f, 5.81163354e-02f, 1.36630863e-01f, 7.51160011e-02f, -1.91985190e-01f, 8.24735984e-02f, -6.79207623e-01f, -4.75923205e-03f, 3.28642540e-02f,
  9.86276940e-02f, -2.12597162e-01f, 1.40511557e-01f, -6.70919940e-02f, 6.84136758e-03f, 3.49985063e-02f, 6.66149110e-02f, -5.24026789e-02f, 1.10676877e-01f, -1.59742519e-01f,
  1.04536980e-01f, -1.09603651e-01f, -1.59969807e-01f, -1.89671785e-01f, 1.08248457e-01f, -3.05902451e-01f, 4.20640409e-02f, 1.42127857e-01f, -9.34824056e-04f, -9.04394388e-02f,
  2.50173301e-01f, -1.40941933e-01f, 1.44024238e-01f, -4.04301435e-02f, 1.21316999e-01f, -1.72797740e-02f, 1.15946986e-01f, -1.72008023e-01f, -1.85470894e-01f, -3.74168694e-01f,
  2.84748822e-01f, 3.36620100e-02f, 2.16715723e-01f, 2.03584239e-01f, -9.35364515e-02f, 2.02568293e-01f, 6.66663796e-02f, -1.60497263e-01f, 6.89824596e-02f, -2.46168628e-01f,
  2.36511439e-01f, -3.17504466e-01f, -3.13302040e-01f, 1.29049681e-02f, -4.74752635e-02f, 1.81424096e-01f, 2.14827746e-01f, -1.87912226e-01f, -1.03665620e-01f, 8.11839625e-02f,
  -2.38494962e-01f, -2.74822533e-01f, -1.10562444e-01f, -1.38732186e-02f, 8.62203687e-02f, -4.74154241e-02f, -3.56583983e-01f, 1.54906765e-01f, -1.80570915e-01f, 9.88308266e-02f,
  -3.36573124e-02f, -6.34145379e-01f, 1.17234953e-01f, -2.69082040e-01f, -1.80183530e-01f, 2.18971953e-01f, -1.09997625e-02f, 7.57670850e-02f, -1.55158207e-01f, -1.11389145e-01f,
  -6.64299959e-03f, 5.28073981e-02f, -8.45918432e-02f, -7.35631492e-03f, -3.57656449e-01f, 1.26456618e-01f, -3.08910847e-01f, -2.16165464e-02f, 8.86614025e-02f, 3.25165153e-03f,
  2.26623520e-01f, -3.54218185e-02f, 2.27906734e-01f, 2.04381198e-01f, -2.03238741e-01f, -2.68920004e-01f, 3.30470875e-02f, 2.50339150e-01f, -2.71806359e-01f, 1.67398259e-01f,
  9.42350104e-02f, -1.87499925e-01f, -3.52359773e-03f, -4.81736153e-01f, 1.79979801e-01f, -1.86680600e-01f, -2.41708085e-01f, 5.97488210e-02f, 9.55311283e-02f, -5.76246940e-02f,
  -2.29904369e-01f, -2.46594727e-01f, -4.51887771e-02f, -1.47929028e-01f, -1.35059655e-01f, -3.43910269e-02f, -1.03686273e-01f, 1.68710187e-01f, -3.80345464e-01f, -1.10681914e-01f,
  -1.26738787e-01f, 2.35925153e-01f, 1.56645272e-02f, -2.20097408e-01f, -2.06585065e-01f, -1.90243810e-01f, 9.82754380e-02f, 1.69944376e-01f, 1.97508797e-01f, 1.24154046e-01f,
  -3.81528378e-01f, -1.70460030e-01f, 7.33502880e-02f, 1.06875263e-01f, -4.58355784e-01f, 2.06858143e-02f, -2.76981622e-01f, 4.22955453e-02f, -3.54357809e-01f, -3.60407650e-01f,
  5.26412763e-03f, 2.40853224e-02f, 2.09235221e-01f, -1.18835546e-01f, -1.74126998e-01f, 7.62889609e-02f, -4.14340049e-02f, 2.63344705e-01f, 1.26663253e-01f, -1.45116448e-01f,
  -5.21539450e-01f, 3.10520500e-01f, -1.22407809e-01f, -1.44506022e-01f, -2.93163300e-01f, -2.13231325e-01f, 1.65033802e-01f, -2.07455784e-01f, -1.20917223e-01f, 3.16427886e-01f,
  3.61187570e-02f, -6.81842715e-02f, 1.92681164e-01f, -2.69623935e-01f, -4.75325674e-01f, -5.83178163e-01f, -3.77174646e-01f, 2.40165684e-02f, 2.42406949e-02f, 4.55109626e-02f,
  1.73239708e-01f, 1.18547985e-02f, 1.18762344e-01f, 5.46865612e-02f, -1.86044216e-01f, -2.07266003e-01f, -1.60956740e-01f, 1.25232726e-01f, -1.15715951e-01f, 8.70064422e-02f,
  2.24010125e-01f, -2.33948022e-01f, 2.10287854e-01f, 7.66234770e-02f, 1.13570899e-01f, -3.76098156e-02f, -3.66865508e-02f, -1.27704218e-01f, -5.32802641e-02f, -4.43608686e-02f,
  -3.96484345e-01f, -4.25520003e-01f, -2.21520305e-01f, -3.27500373e-01f, 1.15346059e-01f, -3.12942147e-01f, -6.97033554e-02f, 1.03191026e-01f, -1.36570260e-01f, 1.10228740e-01f,
  -1.13067180e-01f, 1.61916271e-01f, 1.27996758e-01f, 4.66122031e-02f, -2.59032667e-01f, 9.34194475e-02f, -8.36298391e-02f, -1.02966197e-01f, -6.20615780e-02f, -3.27441484e-01f,
  2.59120971e-01f, 1.49497524e-01f, -4.29895341e-01f, 1.80321828e-01f, -9.54898745e-02f, -2.71809310e-01f, -4.01384272e-02f, -1.66066647e-01f, 5.58137521e-02f, -2.91307241e-01f,
  3.80535722e-02f, -3.21771860e-01f, -5.77835320e-03f, -1.93588823e-01f, 7.04158396e-02f, 1.75251946e-01f, 1.77855447e-01f, -5.87732121e-02f, -7.45716318e-02f, -1.06969029e-01f,
  -9.12204832e-02f, -1.86013430e-02f, -8.08535442e-02f, 2.20089585e-01f, -2.01646276e-02f, -1.48255572e-01f, 1.18654862e-01f, -9.98602808e-02f, 8.02035853e-02f, -9.02816132e-02f,
  -2.49053404e-01f, -1.17903583e-01f, -2.52977490e-01f, -1.82118014e-01f, 3.10859233e-01f, 5.82574010e-02f, 5.32341823e-02f, 1.65660128e-01f, 1.72337204e-01f, -2.99411476e-01f,
  -1.14912920e-01f, 7.90833756e-02f, -1.72006965e-01f, -1.34055093e-01f, 1.30989507e-01f, 6.14501126e-02f, 2.96665758e-01f, 7.99329877e-02f, -2.00008437e-01f, -4.83499497e-01f,
  -1.96897000e-01f, 1.59796640e-01f, -2.75311440e-01f, 3.38091701e-01f, -7.69909844e-02f, -2.77708232e-01f, -1.51719272e-01f, 1.17946878e-01f, -3.22185367e-01f, -4.20470923e-01f,
  -1.18081033e-01f, -9.95625481e-02f, 1.33655712e-01f, 4.69406284e-02f, -9.24277753e-02f, -1.62736982e-01f, -3.23521048e-01f, 1.38803855e-01f, -3.33530933e-01f, 3.33189934e-01f,
  -3.05665970e-01f, 1.21165641e-01f, -3.24434340e-02f, -2.53039271e-01f, -2.74652928e-01f, 1.34950787e-01f, -1.98869601e-01f, -3.03977668e-01f, -1.31696880e-01f, -2.55601779e-02f,
  -1.69211552e-02f, -5.09494603e-01f, -2.91585088e-01f, -3.62611771e-01f, 1.02936834e-01f, -2.30010711e-02f, 1.45202326e-02f, 6.70283809e-02f, 1.85483322e-01f, 1.88069865e-01f,
  7.84561187e-02f, 1.73818484e-01f, -3.49941373e-01f, 2.86137998e-01f, 9.13117602e-02f, 3.81994635e-01f, -7.35905170e-02f, -3.25386494e-01f, -2.32846677e-01f, 7.38005713e-02f,
  1.57474577e-01f, -2.49269918e-01f, 4.99548726e-02f, 1.61960557e-01f, 1.15801081e-01f, -1.00695714e-01f, 2.50881970e-01f, -4.33672279e-01f, 1.24285452e-01f, 2.52728034e-02f,
  9.01842432e-04f, 2.14993185e-03f, -2.98732638e-01f, -2.08366841e-01f, 1.08395211e-01f, -1.33636057e-01f, 1.52509719e-01f, -3.20237130e-01f, -1.35609552e-01f, 3.35722901e-02f,
  2.37504523e-02f, -3.48952532e-01f, -5.13578095e-02f, 2.41267204e-01f, -6.20320678e-01f, -8.07181075e-02f, 1.06966980e-01f, -8.80344138e-02f, 4.04968932e-02f, 1.31960914e-01f,
  7.40863532e-02f, -1.54824555e-01f, -6.62238598e-01f, -2.59161592e-01f, -6.03430867e-01f, -2.65801586e-02f, 1.23436585e-01f, -4.24049906e-02f, -5.03779471e-01f, 4.94149141e-02f,
  1.21076338e-01f, -2.02380374e-01f, 1.68204740e-01f, 2.05325931e-01f, 1.56002268e-01f, 7.04376921e-02f, -5.34084857e-01f, -1.67214960e-01f, -4.18327272e-01f, -2.63888955e-01f,
  1.36379421e-01f, 5.71916513e-02f, -2.61961520e-02f, -6.39662594e-02f, 1.58838257e-01f, 2.36402415e-02f, -7.19522983e-02f, -1.79614186e-01f, -2.36241177e-01f, -2.92919636e-01f,
  2.16482580e-01f, -9.79452506e-02f, -1.38478786e-01f, -3.98404777e-01f, 1.79448858e-01f, 2.28336170e-01f, -1.90873638e-01f, -2.47592956e-01f, -3.60771507e-01f, 2.47033477e-01f,
  -1.95126355e-01f, 1.68556884e-01f, -4.49518800e-01f, 1.28293037e-01f, -3.50717038e-01f, -2.61328965e-01f, 7.57090822e-02f, 2.14464873e-01f, -3.53824854e-01f, 1.31390885e-01f,
  1.53988570e-01f, 9.84099731e-02f, -3.21383364e-02f, -3.06220710e-01f, 2.71732062e-01f, 1.32391691e-01f, -2.79450476e-01f, -2.25131392e-01f, -7.56624103e-01f, -4.00340147e-02f,
  -1.91375762e-01f, -4.44158673e-01f, 4.57347557e-03f, -4.18022692e-01f, 1.43142059e-01f, -2.59861588e-01f, 1.97125211e-01f, 1.68184862e-01f, -2.13402852e-01f, -3.11794579e-01f,
  -2.71136373e-01f, -2.24364534e-01f, -6.20707154e-01f, 1.58541054e-01f, -2.50436336e-01f, -1.39127329e-01f, -4.47774142e-01f, 1.70297146e-01f, -2.50572145e-01f, 1.12798877e-01f,
  1.31844923e-01f, -2.72969753e-01f, 1.05377637e-01f, -2.14166403e-01f, -4.58497219e-02f, 1.48154080e-01f, 2.42833853e-01f, 1.45441040e-01f, -5.57206497e-02f, 1.93365442e-03f,
  1.93960413e-01f, 2.06800729e-01f, 1.63515523e-01f, -3.76207769e-01f, -1.94263309e-01f, -1.83878779e-01f, 4.85211052e-02f, -1.47562280e-01f, -1.26496449e-01f, -2.81079561e-01f,
  2.42456391e-01f, 2.05470547e-02f, -1.22923799e-01f, -2.52427459e-01f, -3.43136489e-02f, -3.63597691e-01f, 6.51970506e-02f, -1.15038931e-01f, 1.46563500e-01f, 4.20748293e-02f,
  2.03952998e-01f, -4.90804389e-02f, 3.44501734e-02f, 3.95829417e-02f, -2.04743996e-01f, -6.39923289e-02f, 2.39084110e-01f, -1.71473548e-02f, -3.85196134e-02f, 1.56711146e-01f,
  1.27366722e-01f, -1.31489828e-01f, -2.51308918e-01f, -7.31439069e-02f, -7.24340230e-02f, 1.80278122e-01f, 7.65305310e-02f, 3.69342864e-02f, 2.93754011e-01f, 8.90693888e-02f,
  -8.72330666e-01f, -3.14536914e-02f, -5.76307774e-01f, 1.70403197e-01f, -2.72235513e-01f, -2.13831574e-01f, -1.70275509e-01f, -2.26376846e-01f, -1.62578508e-01f, 1.01444803e-01f,
  -1.55638576e-01f, -3.44781540e-02f, -1.68676645e-01f, -4.53672022e-01f, -2.07026184e-01f, 5.73240042e-01f, -5.80159605e-01f, 2.18104318e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.48185176e-02f, -9.73831713e-02f, 1.71898738e-01f, 6.83262274e-02f, -5.34309298e-02f, 5.47605604e-02f, 1.27073785e-03f, -8.03454369e-02f, 4.56140116e-02f, 3.89490798e-02f,
  5.09511419e-02f, -1.22450404e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    