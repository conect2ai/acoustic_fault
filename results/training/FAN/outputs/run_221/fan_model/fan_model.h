/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.07938427e-02f, -8.50191265e-02f, -1.01967342e-01f, 3.86957563e-02f, 4.04130807e-03f, -1.60117626e-01f, -1.98010474e-01f, 6.05473518e-02f, -2.59390533e-01f, 6.69356510e-02f,
  1.49326980e-01f, -4.61888351e-02f, -2.55040172e-03f, -4.62524928e-02f, 4.90847006e-02f, -1.23107038e-01f, -1.38486832e-01f, -1.70855876e-02f, -1.29916698e-01f, 1.77704915e-01f,
  7.14683831e-02f, 1.78215340e-01f, 1.47394286e-02f, 1.10533796e-02f, -6.74916357e-02f, 6.07711188e-02f, 3.19215119e-01f, -3.58348116e-02f, 1.97392240e-01f, -8.79945979e-02f,
  -7.34064961e-03f, -1.54984906e-01f, -6.99166283e-02f, -2.33236365e-02f, 6.36433288e-02f, 7.41337566e-03f, 5.38243689e-02f, -1.38891831e-01f, -4.06445861e-02f, -5.02527617e-02f,
  -1.83088742e-02f, 1.12742856e-02f, -3.78336310e-02f, -4.91805784e-02f, 1.28062777e-02f, -5.16149476e-02f, 4.38684858e-02f, -1.61952619e-02f, -2.68165413e-02f, -5.36420457e-02f,
  3.56275849e-02f, -8.29013512e-02f, 2.35202815e-02f, -1.73669737e-02f, -2.89931335e-02f, -4.91778851e-02f, -6.25369698e-02f, -3.76216732e-02f, 7.73668569e-03f, -4.93722111e-02f,
  -5.88849112e-02f, -5.11017591e-02f, 2.87462771e-02f, 2.78885812e-02f, 7.36598745e-02f, 5.97908944e-02f, 1.76329445e-02f, 7.41760433e-02f, -1.14462832e-02f, 8.26472118e-02f,
  6.43050075e-02f, 6.26671640e-03f, 1.62699558e-02f, -2.47109383e-02f, 6.20201007e-02f, 4.02748063e-02f, 3.18747759e-02f, -5.11910431e-02f, 4.28663269e-02f, -2.34380900e-03f,
  -5.42803444e-02f, -2.65451763e-02f, -3.10715218e-03f, 4.09980565e-02f, -9.25054774e-03f, 6.93114027e-02f, 2.91432906e-02f, 5.52189024e-03f, 7.17178825e-03f, 7.97161646e-03f,
  2.71163762e-01f, 3.57048959e-01f, -3.40235489e-03f, 9.30686947e-03f, 2.60507595e-02f, 2.03909185e-02f, -3.85994054e-02f, 3.06323525e-02f, 4.29811217e-02f, 5.58637902e-02f,
  -3.98463719e-02f, -5.66459959e-03f, 4.58189026e-02f, -2.25576479e-02f, -5.65641150e-02f, 1.05563663e-02f, 1.07851245e-01f, 5.27560934e-02f, 5.22758476e-02f, 4.60555702e-02f,
  8.08915570e-02f, 7.26076588e-02f, -6.65848404e-02f, 5.13470881e-02f, -5.66576794e-03f, 6.09534141e-03f, 3.94312330e-02f, -4.91858497e-02f, 5.50726056e-02f, -2.47156825e-02f,
  -4.27808732e-01f, 2.85177655e-03f, -1.91748083e-01f, 1.97563440e-01f, -1.60176322e-01f, 1.55124128e-01f, 3.38443875e-01f, -2.43031941e-02f, 2.81045467e-01f, 3.45499903e-01f,
  1.04300134e-01f, 5.37211932e-02f, 4.20902707e-02f, 8.94415677e-02f, 8.44199490e-03f, 1.08665377e-01f, 3.61311212e-02f, 9.32141989e-02f, -8.22539181e-02f, -1.21306792e-01f,
  -8.98778588e-02f, 3.15539481e-04f, -1.82403192e-01f, -1.56837568e-01f, -1.29867345e-01f, -5.05857989e-02f, -1.33166566e-01f, -2.31893640e-02f, -4.55243774e-02f, 5.03670238e-02f,
  -5.43621182e-02f, 4.91446294e-02f, -1.74551025e-01f, -5.72732696e-03f, -3.53487879e-02f, -5.38005866e-02f, -3.95061746e-02f, -5.34549095e-02f, 1.83483530e-02f, 1.28827859e-02f,
  -5.72948083e-02f, -1.90664269e-02f, 1.31228985e-03f, 2.75873113e-02f, 4.86062607e-03f, -3.67124379e-02f, -6.86021075e-02f, -9.43476241e-03f, -3.20523195e-02f, -8.82016942e-02f,
  -1.20916897e-02f, -2.35173553e-02f, 4.25358005e-02f, 1.10889651e-01f, -6.51730224e-02f, 6.75043985e-02f, 8.89357179e-02f, 1.44503952e-03f, 5.30825555e-02f, 7.81648792e-03f,
  -2.91164522e-03f, 4.19807769e-02f, -1.02597522e-02f, 2.77165305e-02f, -8.03955272e-03f, 2.18288880e-02f, 7.68838227e-02f, 2.30737086e-02f, -3.89935710e-02f, 3.36006433e-02f,
  4.33612205e-02f, -2.63471566e-02f, 2.19576526e-02f, 2.76552010e-02f, 7.96768144e-02f, 2.23499490e-03f, 2.12802030e-02f, 1.41973852e-03f, 2.70771571e-02f, 3.67010683e-02f,
  3.20232386e-04f, 2.08511334e-02f, -2.35020015e-02f, -5.77037921e-04f, 1.07290618e-01f, 1.58793107e-02f, 3.58684994e-02f, 2.19985694e-02f, -4.43970673e-02f, -3.66470637e-03f,
  3.35960120e-01f, 2.57684559e-01f, 8.64913389e-02f, -4.41563800e-02f, -9.61260218e-03f, -4.56659980e-02f, 4.60009603e-03f, -5.17927669e-02f, 6.79443255e-02f, -8.16383399e-03f,
  -7.75863044e-03f, -5.13284877e-02f, 5.10842875e-02f, 1.25151444e-02f, 3.71478759e-02f, 8.03444758e-02f, 6.47463426e-02f, 2.78954040e-02f, 1.92477815e-02f, -4.09356803e-02f,
  3.40625964e-04f, 2.57799905e-02f, 2.83582266e-02f, 2.51601823e-02f, -8.33982453e-02f, 2.32365504e-02f, -2.53613237e-02f, -2.51186267e-02f, -2.45822687e-02f, 1.14093060e-02f,
  3.08149904e-01f, 4.32182029e-02f, 1.12793975e-01f, 7.30168298e-02f, 2.11456984e-01f, -5.43714613e-02f, -1.60957307e-01f, 2.25945339e-01f, 1.91978320e-01f, -9.83796343e-02f,
  -9.65914279e-02f, -4.75734174e-02f, -1.63297191e-01f, 4.61962540e-03f, -2.20129471e-02f, -7.78286308e-02f, 1.66086063e-01f, -2.43963357e-02f, 9.60736424e-02f, -2.79671866e-02f,
  1.48261115e-01f, 1.91039704e-02f, -2.01646909e-02f, 1.13027021e-01f, 4.68088202e-02f, 9.71452370e-02f, 1.05034009e-01f, -1.01730771e-01f, -7.46013671e-02f, 4.12560105e-02f,
  -3.98163572e-02f, 5.38551286e-02f, -3.01731620e-02f, -1.16224103e-01f, 3.94245647e-02f, -4.92830798e-02f, -9.48179364e-02f, -8.69175196e-02f, -2.93768849e-02f, -4.23643664e-02f,
  -9.79279727e-02f, 5.44720963e-02f, -7.71841442e-04f, 2.58397288e-03f, -4.75232396e-03f, -6.92856777e-03f, -2.57913815e-03f, -6.19491329e-03f, 1.79203581e-02f, -6.96811453e-02f,
  -1.47019699e-01f, 1.79465313e-03f, -1.58035941e-02f, 4.56857309e-02f, 2.90814582e-02f, -2.38271076e-02f, -4.84010838e-02f, -1.07488967e-02f, -5.84604684e-03f, 5.66091239e-02f,
  7.80407712e-02f, 3.67456786e-02f, 2.67121010e-02f, -4.91097085e-02f, -6.82008490e-02f, -2.50946060e-02f, -2.46165283e-02f, 7.60203879e-03f, -4.27604578e-02f, -5.17502315e-02f,
  1.99280977e-02f, -8.22904799e-03f, 4.82560880e-03f, -7.57736042e-02f, -3.69351916e-02f, -5.23814596e-02f, -5.59500754e-02f, 2.09700856e-02f, -3.34903486e-02f, -5.04280217e-02f,
  9.07577388e-03f, 1.43101411e-02f, -1.12122940e-02f, 1.69056896e-02f, 1.62224285e-02f, -2.88082883e-02f, 5.59329726e-02f, -1.52555080e-02f, -3.12137753e-02f, 3.98990000e-03f,
  -1.64910600e-01f, 1.01256400e-01f, 1.97183229e-02f, -5.54269254e-02f, -7.25417510e-02f, -7.68807065e-03f, 6.60386756e-02f, 5.05733900e-02f, 6.56813057e-03f, -5.71752004e-02f,
  2.03560460e-02f, -8.74251127e-02f, 3.71653549e-02f, 1.26127675e-02f, 3.36491899e-03f, 3.95310782e-02f, 1.66281573e-02f, 3.38558294e-02f, 3.77444811e-02f, 2.61322241e-02f,
  -2.46544573e-02f, -4.14382145e-02f, 1.10579198e-02f, 2.08365582e-02f, -1.80374067e-02f, 7.16209039e-02f, 4.32770327e-02f, -6.50221808e-03f, 5.36630005e-02f, 8.28554947e-03f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.23753899e-01f, -9.56315920e-02f, 2.78088599e-01f, 1.92526653e-01f, -8.33703876e-02f, 6.73414171e-02f, 4.19806808e-01f, -3.83818150e-02f, 1.15956828e-01f, 1.32475197e-01f,
  5.27873337e-02f, 5.38276955e-02f, 1.07523665e-01f, 2.36143898e-02f, 3.76650169e-02f, 6.23886473e-02f, 1.56170681e-01f, 1.78527623e-01f, 6.59776619e-04f, 5.39121777e-02f,
  9.79391709e-02f, 1.18632376e-01f, 2.28897315e-02f, -1.40333191e-01f, -5.39707839e-02f, -5.53659648e-02f, -7.33846752e-03f, -8.69707018e-02f, -1.64645955e-01f, -1.02029823e-01f,
  -3.16079967e-02f, 6.55026436e-02f, -7.58173093e-02f, -5.08894213e-02f, -9.41843614e-02f, -7.93520212e-02f, 5.59883527e-02f, -3.66894379e-02f, -8.03536400e-02f, -5.77750430e-02f,
  1.61871258e-02f, -8.87822211e-02f, -3.28732934e-03f, -6.60075173e-02f, -2.90871914e-02f, 7.92430341e-03f, -6.28052726e-02f, -6.55787066e-02f, -9.68919322e-02f, -1.54296517e-01f,
  6.73252437e-03f, -1.16492398e-01f, -1.59980711e-02f, -7.68861547e-02f, -3.92430201e-02f, -3.52196433e-02f, 2.24225386e-03f, 2.48910226e-02f, -2.60102060e-02f, -7.00913370e-02f,
  4.49092053e-02f, 6.43326491e-02f, 2.81015672e-02f, 9.75095108e-03f, 7.75674284e-02f, -1.83905456e-02f, -2.46943813e-02f, -1.36899613e-02f, -2.33985335e-02f, 7.90469572e-02f,
  3.64829227e-02f, -9.58029763e-04f, 2.48748367e-03f, 1.18601718e-03f, 8.97746384e-02f, 4.47377861e-02f, 7.93567970e-02f, -8.26687217e-02f, 3.96714285e-02f, -1.14675410e-01f,
  1.32291868e-01f, -3.08298711e-02f, -3.03949118e-02f, 1.72631964e-02f, 5.35365343e-02f, -2.90265307e-02f, -3.10792811e-02f, 2.44352091e-02f, 1.37815457e-02f, -4.80629429e-02f,
  -2.98338354e-01f, -8.48454759e-02f, -1.35727776e-02f, 2.76588183e-02f, -1.10718295e-01f, -9.93651524e-02f, -8.81670043e-02f, -4.40197624e-02f, -1.29897654e-01f, 4.78843786e-02f,
  -2.47684889e-03f, 2.16375124e-02f, -9.03697610e-02f, -9.83959213e-02f, 3.95773398e-03f, -7.78891891e-02f, 6.94777519e-02f, -5.14965095e-02f, -2.95049255e-03f, -4.01715189e-03f,
  -7.90710002e-02f, -4.80738236e-03f, -3.69776711e-02f, -1.18472636e-01f, 1.76048949e-02f, -2.24800687e-02f, -2.06097551e-02f, -5.51214963e-02f, -1.16053395e-01f, -6.06503598e-02f,
  2.62776818e-02f, -4.85288091e-02f, -1.16955236e-01f, 1.50993494e-02f, -3.26861180e-02f, -8.91270190e-02f, -1.87481895e-01f, 4.30094451e-02f, -7.03806952e-02f, 9.70345438e-02f,
  -7.55833164e-02f, -5.38882390e-02f, 1.15293637e-02f, -1.36663049e-01f, 5.48178004e-03f, 8.40584561e-03f, 2.48314925e-02f, -2.81487089e-02f, 7.98237845e-02f, 3.01914066e-02f,
  8.96420479e-02f, -9.06844363e-02f, -1.65101548e-03f, -3.11330613e-03f, -6.08132593e-02f, 1.18701637e-01f, 1.14760548e-01f, -1.16140924e-01f, 6.15589367e-03f, -5.41644730e-02f,
  7.07277581e-02f, 7.58458227e-02f, 6.45211115e-02f, -8.21675286e-02f, 5.19000106e-02f, -7.01968512e-03f, 6.87160119e-02f, 9.90886427e-03f, 6.18617646e-02f, 2.31783390e-02f,
  -5.19582555e-02f, -6.43394515e-02f, -6.52857823e-03f, -1.80991297e-03f, -9.59797502e-02f, 3.20387408e-02f, -1.57690735e-03f, 8.81682150e-03f, -1.45197019e-01f, 5.44956047e-03f,
  -6.46614879e-02f, -1.05140544e-01f, -5.95349148e-02f, -9.96307135e-02f, 6.28522858e-02f, -4.24275026e-02f, 5.89393079e-02f, -7.35585913e-02f, -4.27007489e-02f, -1.12965396e-02f,
  6.38518855e-02f, 5.42695858e-02f, -2.99351662e-02f, -3.10930945e-02f, 1.81933697e-02f, -1.28471181e-01f, -1.53919328e-02f, -6.41305968e-02f, 3.41029502e-02f, -7.11388811e-02f,
  -8.57293955e-04f, 7.42507949e-02f, 2.79458780e-02f, -4.46865112e-02f, 4.95268293e-02f, -1.33101549e-02f, -8.45130980e-02f, -1.54611235e-02f, -5.82976406e-03f, -3.28080617e-02f,
  -1.23692555e-02f, -4.21389975e-02f, -2.70334035e-02f, 3.86727508e-03f, -7.76494592e-02f, -3.25276516e-02f, 2.12096740e-02f, -1.03075244e-01f, -4.07977076e-03f, -6.00386458e-03f,
  5.87549768e-02f, 1.43336982e-01f, 7.59567395e-02f, -6.21176995e-02f, 1.85915045e-02f, 8.74071643e-02f, 3.04735266e-02f, 6.01715371e-02f, 7.11379424e-02f, 2.31555458e-02f,
  7.38783479e-02f, 4.23056446e-03f, -3.85738052e-02f, 2.40581669e-02f, 3.23395953e-02f, 5.08614630e-03f, 9.20000114e-03f, 2.15064939e-02f, -1.86791725e-03f, -1.86406728e-02f,
  3.03831138e-02f, -3.32320407e-02f, 1.11477077e-02f, -3.36301029e-02f, -5.08350655e-02f, 4.62963209e-02f, -1.08112134e-02f, -9.12884367e-04f, -6.54517561e-02f, -4.91991527e-02f,
  -3.21406960e-01f, 4.39788699e-02f, -2.35664368e-01f, -6.30837977e-02f, -1.35053083e-01f, -3.26854378e-01f, -1.52284488e-01f, -1.86725438e-01f, -2.02306628e-01f, 1.88444123e-01f,
  2.28982083e-02f, -1.23218693e-01f, 1.45275742e-01f, 1.70702606e-01f, -1.64949238e-01f, 2.13265494e-01f, 7.70124719e-02f, 1.54163331e-01f, -1.24772340e-02f, -4.37342599e-02f,
  7.09496588e-02f, 6.39655888e-02f, 1.49670288e-01f, -7.11050257e-02f, -1.00025997e-01f, -9.46376696e-02f, 3.75446454e-02f, -7.63947517e-02f, -7.58113936e-02f, -1.23917550e-01f,
  -2.51634359e-01f, -2.89252639e-01f, -1.39658302e-01f, -6.76277131e-02f, -7.81502649e-02f, -1.46721065e-01f, -5.22978604e-02f, 3.11746951e-02f, 3.25093940e-02f, -3.13866511e-02f,
  -5.29262237e-02f, 4.33316920e-03f, -8.55439007e-02f, 6.56191856e-02f, -6.43472299e-02f, -8.96279961e-02f, -3.48054692e-02f, 5.60111292e-02f, 4.95640934e-02f, -3.32783982e-02f,
  -7.83334151e-02f, -3.91098298e-02f, -3.13446149e-02f, 5.04433103e-02f, 8.18316359e-03f, -7.04665948e-03f, -5.00254370e-02f, -4.12784033e-02f, -1.58001229e-01f, -5.13101034e-02f,
  -1.43039366e-02f, 4.57989750e-03f, 4.57655638e-02f, -4.51336950e-02f, -3.01357806e-02f, -2.05670502e-02f, 1.26538482e-02f, 5.14744222e-02f, -6.66000508e-03f, 3.07885110e-02f,
  -2.13796012e-02f, 7.40933940e-02f, -7.99854398e-02f, -2.18761284e-02f, 2.10800674e-02f, 5.73687721e-03f, 3.29574607e-02f, -1.36107691e-02f, -3.09927873e-02f, -5.36560453e-03f,
  -2.10389867e-02f, -2.27765311e-02f, 1.42619815e-02f, 6.42286986e-02f, -9.95701328e-02f, 7.32857808e-02f, 2.02490017e-02f, -7.15659559e-02f, 3.25193144e-02f, 4.03551348e-02f,
  -2.88930327e-01f, -4.77663219e-01f, 1.48895206e-02f, -9.25554335e-02f, -2.92749573e-02f, -5.64772002e-02f, 3.57953385e-02f, -3.86036299e-02f, -1.25152379e-01f, -1.17814042e-01f,
  -9.40117240e-02f, 3.94981727e-02f, -8.66408497e-02f, 5.46680577e-02f, 5.04043177e-02f, 3.66710871e-02f, -1.16885966e-02f, 1.00041963e-02f, -3.84106822e-02f, -1.28508899e-02f,
  1.51263643e-02f, -2.36334223e-02f, 3.68457325e-02f, -1.39731187e-02f, 2.64212172e-02f, 2.58453246e-02f, -8.56779702e-03f, -3.13821132e-03f, -2.79418305e-02f, -5.80783514e-03f,
  1.98106766e-01f, -7.72841275e-01f, -2.08707288e-01f, 8.80884975e-02f, 2.34821558e-01f, 3.04147154e-01f, 1.58190444e-01f, -8.51775482e-02f, -3.51479322e-01f, -3.33060235e-01f,
  1.23047553e-01f, -6.66276738e-02f, -2.76442736e-01f, 1.14350125e-01f, 4.09008354e-01f, -2.24284813e-01f, 2.08414450e-01f, 9.28828046e-02f, -2.07692355e-01f, -1.08689800e-01f,
  -1.35707054e-02f, 3.09021860e-01f, -1.64994448e-02f, 5.55627374e-03f, 9.34507102e-02f, -1.22287944e-01f, -4.43592742e-02f, -4.66162153e-02f, 2.28336021e-01f, 2.28279158e-01f,
  7.19637275e-02f, -1.43078238e-01f, 3.56535390e-02f, 5.19752912e-02f, -6.55417368e-02f, -3.86540182e-02f, 4.89869080e-02f, 1.52187720e-01f, 8.03901851e-02f, -1.99094452e-02f,
  -3.04924175e-02f, 5.66088706e-02f, 4.07488607e-02f, 4.07033376e-02f, -1.94834583e-02f, -1.76714472e-02f, -1.18205912e-01f, -5.05413972e-02f, -6.10433333e-02f, -1.82323856e-03f,
  -1.04176819e-01f, 1.79211106e-02f, -4.64877896e-02f, 3.80901620e-02f, -3.69245298e-02f, 9.05614067e-03f, -7.12618604e-02f, 5.80264144e-02f, -6.16378710e-02f, 3.21851633e-02f,
  -2.04077717e-02f, -2.96442118e-02f, 2.70434236e-03f, 6.46032169e-02f, -1.06057003e-02f, 4.15964238e-02f, 3.26815583e-02f, 4.33747359e-02f, 1.64715818e-03f, -3.52392681e-02f,
  -2.94550117e-02f, 6.02196306e-02f, 1.29799396e-02f, 4.15521301e-02f, 5.50591275e-02f, -5.57800615e-03f, 1.71893034e-02f, 5.82083464e-02f, -8.65930989e-02f, 1.41082639e-02f,
  1.37622897e-02f, 2.90459692e-02f, -2.76459418e-02f, 1.01273740e-02f, 8.11720788e-02f, -3.30317125e-04f, 1.40818991e-02f, -9.26672295e-02f, -3.69675900e-03f, 2.43301317e-02f,
  -1.26632214e-01f, -3.72764170e-01f, -3.98269892e-02f, 5.52452020e-02f, -5.95394671e-02f, 1.99715327e-02f, -3.69820744e-02f, 1.91749446e-03f, -3.01881507e-02f, -6.22164235e-02f,
  9.87739023e-03f, 3.79760712e-02f, -3.13285962e-02f, 9.83824208e-02f, 4.78585102e-02f, -7.30787665e-02f, -2.84531303e-02f, 6.92434460e-02f, 4.12108637e-02f, -6.28004223e-02f,
  -2.47184504e-02f, -6.99469298e-02f, 9.75383520e-02f, 3.65801193e-02f, -2.73575075e-02f, -4.84348051e-02f, 1.27794296e-02f, -1.75399035e-02f, 1.31469835e-02f, -3.93835530e-02f,
  -8.14842999e-01f, 1.42018452e-01f, 1.39089808e-01f, -3.83724660e-01f, 2.31814235e-02f, -1.62443623e-01f, -3.35335761e-01f, 3.03772390e-02f, -1.36387229e-01f, -1.14450283e-01f,
  -1.80869684e-01f, 5.02910540e-02f, -1.34582678e-02f, -1.34055540e-01f, -5.33096135e-01f, -7.87366778e-02f, -4.12135929e-01f, -2.09840417e-01f, 1.06871195e-01f, -6.88517094e-02f,
  -1.43585190e-01f, -1.89322948e-01f, -1.58569291e-01f, 1.63828716e-01f, -5.11492789e-02f, 2.78346539e-02f, -1.57012641e-01f, 1.94089428e-01f, -8.88201296e-02f, 1.00818025e-02f,
  -1.41193017e-01f, -3.83500569e-02f, 1.05265148e-01f, 4.34950478e-02f, -9.44070071e-02f, 2.02925541e-02f, -3.40153947e-02f, 3.23388390e-02f, 5.29950066e-03f, 4.39158781e-03f,
  6.99599739e-03f, -3.00191110e-03f, 1.80866066e-02f, 7.13149607e-02f, -3.45215201e-02f, 9.43816379e-02f, 1.32010669e-01f, 1.11603709e-02f, 1.79726053e-02f, 7.99156055e-02f,
  5.13327047e-02f, 1.61522850e-02f, -3.17397192e-02f, -1.05062902e-01f, -4.90933657e-02f, 2.18701698e-02f, -1.02910660e-01f, -1.07986713e-02f, 3.69496159e-02f, -5.29127195e-02f,
  -4.31850851e-02f, -1.70817249e-03f, -3.89452390e-02f, 9.71860811e-02f, -7.78417364e-02f, 1.97703075e-02f, -5.17717935e-02f, -1.96002871e-02f, -3.16663422e-02f, -5.36996238e-02f,
  -1.02686342e-02f, -6.35733828e-02f, 2.72028428e-02f, -1.47682745e-02f, -5.53281903e-02f, -6.81949407e-03f, -2.46843770e-02f, -4.08795802e-03f, 1.03892460e-02f, -5.64450659e-02f,
  -2.01143678e-02f, -2.94296127e-02f, 1.56157487e-03f, 1.51789933e-02f, -1.65483765e-02f, 2.00618915e-02f, 1.23423822e-02f, 2.20882259e-02f, -4.16578166e-02f, -8.36150348e-02f,
  -1.30143777e-01f, -3.35686564e-01f, -3.32948864e-02f, 1.43723646e-02f, -1.55981826e-02f, -4.47689518e-02f, -4.73056212e-02f, -7.21238973e-03f, -7.96178579e-02f, 3.31357829e-02f,
  -5.85324988e-02f, -6.05293252e-02f, -4.74443138e-02f, -2.14792788e-02f, 7.92383496e-03f, -1.18835904e-01f, -5.54584190e-02f, -5.86006418e-02f, -6.09805137e-02f, 2.73956661e-03f,
  3.97461690e-02f, 2.04605353e-03f, -4.49993983e-02f, 6.30397946e-02f, -8.90070759e-03f, -1.41163096e-01f, -4.72735390e-02f, -8.92007630e-03f, -6.15378581e-02f, -4.25699241e-02f,
  -6.11519456e-01f, 1.58558369e-01f, -3.59971747e-02f, -2.27756262e-01f, 7.16835484e-02f, -9.10003558e-02f, -4.84887995e-02f, 2.30738241e-02f, -9.76630524e-02f, 2.78774232e-01f,
  -6.29986729e-03f, -1.91423267e-01f, 7.34262243e-02f, -2.59535700e-01f, -6.88899934e-01f, -3.85469079e-01f, -2.77929217e-01f, -5.10767624e-02f, -2.38121465e-01f, 4.24887985e-02f,
  -1.92592531e-01f, -2.06720978e-01f, -2.12985724e-01f, 1.16809674e-01f, 1.38218194e-01f, 2.51021266e-01f, 1.00141801e-01f, 1.49892628e-01f, 1.63592592e-01f, -1.09307002e-02f,
  -5.22609130e-02f, 7.32976347e-02f, 1.27467439e-01f, 8.59398693e-02f, -1.47159118e-02f, 4.79421020e-02f, 3.62403654e-02f, -5.96353933e-02f, -5.11216186e-02f, -6.87806532e-02f,
  7.18495473e-02f, 1.67440362e-02f, -7.82589912e-02f, -8.13622251e-02f, 1.24592230e-01f, 3.50349061e-02f, -6.77991733e-02f, 7.41745457e-02f, 8.40453431e-03f, -8.89575556e-02f,
  -5.05862050e-02f, 6.33978099e-02f, 5.12256809e-02f, 5.88047542e-02f, -1.14690242e-02f, 5.97304031e-02f, 5.58490977e-02f, 9.45560560e-02f, 5.02833389e-02f, 4.62473631e-02f,
  -6.39862046e-02f, 7.32972324e-02f, -2.15884615e-02f, -6.32160008e-02f, 2.46921070e-02f, 9.29370224e-02f, -1.64092854e-02f, -3.31161581e-02f, -4.25785454e-03f, 1.80167742e-02f,
  5.83826602e-02f, -1.21872714e-02f, -3.78762409e-02f, 6.34361804e-02f, -1.66125316e-03f, 8.98296572e-03f, 1.89775005e-02f, 5.77518903e-03f, -5.27738817e-02f, 1.15800099e-02f,
  6.21104613e-02f, -1.38697252e-02f, 3.99362296e-02f, -1.71499476e-02f, 5.60836270e-02f, -6.13217568e-03f, 6.15911791e-03f, 7.42712766e-02f, 5.74434875e-03f, -9.38683189e-03f,
  5.87473027e-02f, 1.02354087e-01f, -2.41423901e-02f, -1.89857781e-02f, 7.08266348e-02f, -1.23971030e-02f, -4.83623557e-02f, -9.74281039e-03f, 1.72930658e-02f, 2.11289749e-02f,
  7.49947429e-02f, 7.47100413e-02f, 4.47953306e-02f, -7.19263963e-03f, -3.44995351e-04f, 5.08674793e-02f, -1.06119566e-01f, 1.97814349e-02f, 4.86509390e-02f, -3.59458709e-03f,
  3.96662951e-02f, -2.18416494e-03f, -5.98014444e-02f, -3.52677368e-02f, 3.36959474e-02f, 8.23355690e-02f, 3.09208850e-03f, -3.02956477e-02f, -4.24597487e-02f, 1.29851718e-02f,
  -1.03154168e-01f, -1.80445284e-01f, -1.19510502e-01f, -2.02529222e-01f, 3.37696224e-02f, -3.43390495e-01f, -4.06692863e-01f, -8.18336308e-02f, 2.13471666e-01f, -1.10881366e-01f,
  -2.91921854e-01f, 1.42957985e-01f, -6.96926117e-02f, -3.26359451e-01f, 9.04730186e-02f, 1.88617930e-01f, -4.81113732e-01f, -1.62435591e-01f, 1.30188316e-01f, -2.40414113e-01f,
  -6.90151230e-02f, -2.97609121e-01f, -1.26426443e-01f, -1.25503197e-01f, -2.28200749e-01f, -1.30574976e-03f, 1.03453040e-01f, -1.41417563e-01f, -1.50658593e-01f, -6.42611906e-02f,
  -2.96342392e-02f, 1.71021238e-01f, 1.85338582e-03f, 5.37993275e-02f, -1.44152969e-01f, -4.57835831e-02f, -1.01235099e-01f, -6.83102608e-02f, 2.43823994e-02f, -2.03560386e-02f,
  4.43853065e-02f, 9.33584496e-02f, 3.43854912e-02f, -3.84108052e-02f, -8.75672232e-03f, 3.05409562e-02f, 5.76923154e-02f, -8.07997361e-02f, -6.27458841e-02f, -2.48596761e-02f,
  -7.09095225e-02f, -4.06010486e-02f, -8.67171586e-02f, 1.50324255e-01f, -6.07851967e-02f, -1.38997972e-01f, 2.98209134e-02f, -1.94638204e-02f, -1.52700190e-02f, 7.80006573e-02f,
  -1.55452061e-02f, -7.38554373e-02f, 1.32683534e-02f, -9.43524018e-02f, -5.69328712e-03f, -1.75682772e-02f, -1.38405874e-01f, 5.09260930e-02f, 4.39329669e-02f, -9.93123651e-02f,
  3.91200505e-04f, 2.79402956e-02f, 4.79662567e-02f, 1.69755332e-02f, -3.61939669e-02f, -2.60566041e-04f, -7.14567527e-02f, -1.60649661e-02f, -6.36094138e-02f, -4.17172685e-02f,
  -1.28057310e-02f, 1.47789204e-02f, 2.83719623e-03f, 4.53937389e-02f, 4.00574319e-03f, -4.23158072e-02f, 1.74949858e-02f, 6.84188232e-02f, -4.78661712e-03f, -1.24427915e-01f,
  -6.71314672e-02f, 1.22918986e-01f, 3.68282720e-02f, 4.31626849e-02f, 1.98184159e-02f, -6.41688285e-03f, -2.36689672e-02f, 1.69961080e-02f, -3.27184871e-02f, -4.43773456e-02f,
  -1.87711529e-02f, 4.53915410e-02f, -4.04702388e-02f, -1.07301846e-01f, -5.16671091e-02f, -3.72658633e-02f, -1.46315126e-02f, -1.54074319e-02f, -1.82187408e-02f, -1.10467739e-01f,
  -7.95523524e-02f, 5.18296883e-02f, -1.85828153e-02f, -7.12320730e-02f, -1.72915924e-02f, 6.57503726e-03f, 3.34072486e-02f, 6.72140121e-02f, 1.87935662e-02f, 5.69480658e-02f,
  5.73952496e-02f, -9.38810259e-02f, 1.80500254e-01f, -1.40845692e-02f, 2.91669458e-01f, 3.02746236e-01f, 3.16134781e-01f, 1.22423217e-01f, 1.29823297e-01f, -2.80760974e-01f,
  -1.55892730e-01f, -7.18306527e-02f, -1.76783337e-03f, -2.00737223e-01f, 1.34650916e-01f, -7.73565918e-02f, -4.24739420e-02f, -7.44265392e-02f, 1.66305378e-01f, 2.77324133e-02f,
  2.13258695e-02f, -3.28572206e-02f, 9.68684852e-02f, -1.30054623e-01f, 1.85955374e-03f, -1.79631058e-02f, -2.69466549e-01f, 5.07557951e-02f, -1.75406173e-01f, -2.42191199e-02f,
  6.80250078e-02f, 3.93837579e-02f, 6.95105791e-02f, 9.04676467e-02f, 7.87695199e-02f, -6.04070798e-02f, -3.64141837e-02f, 4.09440175e-02f, 1.16549030e-01f, 5.60528673e-02f,
  6.73650429e-02f, -3.10108950e-03f, 2.52357777e-02f, -3.81083824e-02f, 5.83782606e-02f, -3.26335803e-02f, 1.96372326e-02f, 7.29854926e-02f, 4.39442024e-02f, 1.00333346e-02f,
  7.15768486e-02f, 8.02609026e-02f, -3.03340498e-02f, -3.26850861e-02f, -4.92217243e-02f, 2.87922081e-02f, -1.04242526e-02f, -8.37211832e-02f, -1.73234772e-02f, 4.74189296e-02f,
  -7.26158693e-02f, 5.70240356e-02f, -5.09579293e-02f, 3.80854346e-02f, -2.32739877e-02f, -5.49051492e-03f, 2.28082482e-03f, 4.56429310e-02f, 1.50302378e-02f, 9.38698999e-04f,
  1.62944645e-02f, -5.40436283e-02f, -1.32739022e-02f, 4.59574386e-02f, -7.51453126e-03f, -7.13455528e-02f, -9.35872609e-04f, -8.15577134e-02f, 1.74301956e-02f, 2.47900039e-02f,
  -4.04541306e-02f, -4.71501313e-02f, -5.22545874e-02f, 6.60695359e-02f, 4.63898070e-02f, 3.21979895e-02f, 4.18000966e-02f, -1.02462113e-01f, 3.23824994e-02f, 6.75613061e-03f,
  2.30030231e-02f, -1.10922672e-01f, 3.47304568e-02f, 5.61136901e-02f, 1.27640478e-02f, -8.06680173e-02f, 2.01941896e-02f, -4.94435318e-02f, -2.62217745e-02f, -4.81634885e-02f,
  -7.55087584e-02f, 5.58112822e-02f, 5.55784581e-03f, 9.89741459e-03f, 4.32229787e-02f, 5.47256283e-02f, -8.20524320e-02f, -4.29015979e-03f, -2.74104904e-02f, -3.89722362e-02f,
  -1.07023858e-01f, 5.00782467e-02f, -1.86528172e-02f, 5.20457141e-03f, -1.01633504e-01f, -8.57821703e-02f, -6.91554546e-02f, -9.59377289e-02f, 3.55451507e-03f, 4.75105681e-02f,
  1.65718123e-01f, 2.67257337e-02f, -3.80865514e-01f, -1.15101993e-01f, 1.75281540e-01f, 1.89997196e-01f, 1.41244486e-01f, -3.52859236e-02f, -1.81032121e-01f, 1.91459104e-01f,
  1.64187104e-01f, -1.90370865e-02f, -1.82574630e-01f, 2.50083685e-01f, 2.46316753e-02f, -1.09585248e-01f, 2.71497279e-01f, 1.36057019e-01f, -8.67073759e-02f, 2.07044389e-02f,
  -5.12277149e-02f, 4.11713302e-01f, -2.00088426e-01f, 1.00875370e-01f, 2.83914059e-01f, -1.44094750e-01f, 8.92502367e-02f, -1.54555872e-01f, 1.66465566e-01f, 1.95987806e-01f,
  1.73688427e-01f, 8.32708366e-03f, -1.12808734e-01f, 1.25872879e-03f, 1.86290033e-02f, 4.10927907e-02f, -7.19489064e-03f, 4.70152609e-02f, -8.20639655e-02f, -1.62788748e-03f,
  1.03151925e-01f, 5.25328703e-02f, 3.03262868e-03f, -1.76399294e-02f, 1.52672073e-02f, -2.21795756e-02f, -5.23381382e-02f, -3.79432552e-02f, -2.62802336e-02f, 9.97297764e-02f,
  -7.37785548e-02f, 7.36667588e-02f, -3.26244812e-03f, -1.83272548e-02f, -9.79270637e-02f, -1.80014297e-02f, -2.67854836e-02f, -2.46096756e-02f, 6.84453100e-02f, 4.54717129e-02f,
  6.87190071e-02f, 1.22177498e-02f, 4.02501225e-03f, 2.39045569e-03f, -9.09719691e-02f, -1.09569856e-03f, -2.91750021e-02f, -1.34367412e-02f, -6.77223429e-02f, 9.44080874e-02f,
  -9.93920341e-02f, -1.08552109e-02f, 5.65673783e-02f, 1.03850372e-03f, 1.01501249e-01f, -4.29124385e-02f, 2.03441698e-02f, 5.32521307e-02f, -1.42814636e-01f, -6.09039292e-02f,
  7.02746511e-02f, 5.61223412e-03f, 1.66648626e-02f, 2.93182749e-02f, 4.94387485e-02f, -2.92340834e-02f, 1.05962992e-01f, 5.53038996e-03f, -5.83719052e-02f, 1.55422287e-02f,
  2.23509759e-01f, -5.14586500e-05f, -2.49369107e-02f, 3.11177466e-02f, -9.28212255e-02f, 4.67797406e-02f, 2.30991654e-03f, 5.29549038e-03f, -3.27583775e-02f, 1.26837371e-02f,
  8.58117417e-02f, -7.33597800e-02f, 1.00961581e-01f, -8.97385255e-02f, -4.16452512e-02f, 1.00743152e-01f, 3.03205959e-02f, -1.05843619e-01f, -7.37400949e-02f, -3.13090235e-02f,
  -4.11855243e-02f, 4.36079875e-02f, -3.78431492e-02f, -9.16950703e-02f, 6.64543957e-02f, 6.86759204e-02f, 2.84530735e-03f, -5.17489128e-02f, 1.04493424e-01f, -6.03064969e-02f,
  6.62682414e-01f, 2.29498018e-02f, 2.79919684e-01f, 4.10113335e-01f, 2.07230896e-01f, -1.98652536e-01f, 4.88857785e-03f, 1.16880096e-01f, 4.32073057e-01f, -6.34617656e-02f,
  -7.25361407e-02f, 2.27940917e-01f, -3.41384858e-01f, 1.18075520e-01f, -3.45675826e-01f, -3.28573674e-01f, -8.00034329e-02f, -6.85035363e-02f, -3.03730089e-03f, 6.79940730e-02f,
  1.02024898e-01f, -3.09630066e-01f, -1.07733391e-01f, -3.11434984e-01f, 1.94414750e-01f, 1.63396493e-01f, -2.81585634e-01f, -1.82579264e-01f, 1.65988598e-02f, -1.06492899e-01f,
  1.54640526e-01f, 1.50775164e-01f, 9.62807331e-03f, -8.17304943e-03f, -8.48527253e-02f, -1.79189479e-03f, -5.59141412e-02f, -1.28752500e-01f, 1.17833577e-01f, 9.84388888e-02f,
  3.46583202e-02f, 2.86623687e-02f, 5.39596081e-02f, -8.03201124e-02f, 1.38536125e-01f, 7.53549635e-02f, 1.10022470e-01f, 1.62533522e-01f, 7.52655193e-02f, 9.48368981e-02f,
  9.82971787e-02f, 8.99678022e-02f, 4.34001833e-02f, -3.20246853e-02f, -4.83590662e-02f, 4.82288040e-02f, 8.80846307e-02f, -1.53269423e-02f, 9.11760330e-02f, 6.96800277e-02f,
  -1.89547464e-01f, -1.83240771e-01f, -5.13012968e-02f, -1.49926906e-02f, -9.25523788e-03f, 3.89876887e-02f, -4.77917828e-02f, -2.08183676e-02f, 4.65344377e-02f, -9.34932381e-03f,
  5.48708439e-02f, 5.88773265e-02f, -2.76350770e-02f, 1.03770278e-01f, 2.21955869e-02f, 5.62827699e-02f, -2.16725040e-02f, 1.99531559e-02f, 2.46124677e-02f, 6.92564026e-02f,
  -5.37625253e-02f, -3.48600745e-02f, -4.29582894e-02f, 3.32841673e-03f, -4.33843816e-03f, 5.01622222e-02f, 1.22412452e-02f, 8.90941471e-02f, -2.45312019e-03f, -8.38740990e-02f,
  -6.68667778e-02f, -4.18299913e-01f, -5.95039129e-02f, 8.24648067e-02f, -7.69824861e-03f, 2.41894275e-03f, -1.97256692e-02f, 7.72656277e-02f, -2.98197493e-02f, -6.39922917e-02f,
  -2.25333869e-02f, 5.21798059e-02f, 3.63684930e-02f, 3.21168154e-02f, -7.82612860e-02f, 3.99877317e-02f, -6.48253933e-02f, -8.15036893e-02f, -1.29059523e-01f, -1.18242398e-01f,
  8.22133943e-02f, -3.02574448e-02f, -2.10987143e-02f, 5.36114834e-02f, 5.67298383e-02f, -3.59733589e-02f, -1.26382364e-02f, -3.33891325e-02f, -4.67303693e-02f, -7.52298385e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.85529524e-01f, 8.77105817e-02f, 9.34122354e-02f, 1.42778620e-01f, 6.88984871e-01f, 4.64828938e-01f, 5.46390526e-02f, 5.48764952e-02f, -2.55796313e-02f, 1.47294760e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.61651546e-01f, 4.93642455e-03f, 2.56367415e-01f, 7.16760576e-01f, 8.92381445e-02f, 2.56725401e-01f, -2.38572359e-01f, 9.56008211e-02f, -2.54861325e-01f, 4.93009120e-01f,
  1.75632656e-01f, 2.62464792e-01f, -1.63678601e-01f, -1.76929489e-01f, 2.85531521e-01f, -5.23490429e-01f, -4.59133722e-02f, 5.58734834e-01f, 3.19822460e-01f, 5.37814647e-02f,
  -5.51041842e-01f, 5.06567776e-01f, -5.27031384e-02f, -1.29358798e-01f, -1.93334743e-01f, 2.18638957e-01f, 3.73633146e-01f, 2.23124847e-01f, -4.43132401e-01f, 1.55633062e-01f,
  -2.14219987e-01f, 5.66099957e-02f, 2.79406667e-01f, -3.56455475e-01f, 2.82727867e-01f, -1.37784302e-01f, 5.01850247e-01f, -4.28939164e-01f, -1.00995399e-01f, -2.80845612e-01f,
  3.49040985e-01f, -2.50152051e-01f, 1.10829867e-01f, -2.05689698e-01f, 3.43109578e-01f, 3.42296094e-01f, 2.66281247e-01f, -5.14490783e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.05653355e-01f, -2.42566578e-02f, 1.27957001e-01f, 2.38880590e-01f, 2.40527526e-01f, -1.55236078e-02f, -1.94784790e-01f, 1.74552903e-01f, -1.00499168e-01f, -1.14932224e-01f,
  1.72962219e-01f, 1.09590754e-01f, 3.63160998e-01f, -2.42789060e-01f, 1.05037726e-02f, -1.89812899e-01f, 5.04298091e-01f, 2.54700899e-01f, 2.79617608e-01f, -7.09339261e-01f,
  -1.28408134e-01f, 5.59066050e-02f, 5.90654790e-01f, 6.66578263e-02f, -4.14882272e-01f, 1.51524663e-01f, -1.81787729e-01f, -2.91505486e-01f, -5.76729439e-02f, 3.60652149e-01f,
  -1.42793775e-01f, 5.43490767e-01f, 1.18848113e-02f, 4.67124194e-01f, 5.28273880e-01f, -4.43797857e-02f, -4.76760864e-01f, -2.14625582e-01f, -2.99600065e-01f, 1.32908106e-01f,
  1.98413923e-01f, -3.21405590e-01f, 1.14974558e+00f, 7.04473376e-01f, 6.38280153e-01f, -1.75441548e-01f, -2.68112630e-01f, 2.06407890e-01f, 2.94749081e-01f, 1.75953671e-01f,
  -9.25104246e-02f, 3.73266011e-01f, 1.86935544e-01f, -4.43885952e-01f, 6.52050450e-02f, 9.98061523e-02f, 3.66226226e-01f, 2.78806686e-01f, 1.43174594e-02f, 4.82840789e-03f,
  -1.08841307e-01f, -1.92267522e-01f, 6.36409044e-01f, -3.14088821e-01f, 3.05226982e-01f, 3.07972848e-01f, -5.57297543e-02f, 2.87019193e-01f, -3.68724078e-01f, -4.47188973e-01f,
  1.90565456e-02f, -1.20734237e-01f, -2.23266035e-02f, 1.00942230e+00f, -2.21458942e-01f, -3.48296285e-01f, -2.41632819e-01f, 1.77679732e-02f, 3.11131269e-01f, -3.12544763e-01f,
  2.89303660e-01f, -1.22771591e-01f, -2.36369491e-01f, -9.46533307e-02f, -3.66215914e-01f, -1.78051237e-02f, -1.23041250e-01f, -1.82226300e-01f, 1.64738148e-01f, -4.97552902e-02f,
  2.67589301e-01f, 1.30668789e-01f, -1.09555133e-01f, 1.86219081e-01f, -9.53717250e-03f, 6.50060177e-01f, -8.03063959e-02f, -7.09859058e-02f, -3.03299800e-02f, 1.66801259e-01f,
  1.93366796e-01f, -6.94859326e-02f, -1.64935976e-01f, 2.41016880e-01f, 2.51446187e-01f, 1.63730994e-01f, 4.48198199e-01f, 3.32311600e-01f, 5.21392286e-01f, -3.27728726e-02f,
  1.88954361e-02f, -1.64913267e-01f, -7.45992437e-02f, 1.09594569e-01f, 5.22434831e-01f, 4.65910852e-01f, -2.61824518e-01f, 1.54368430e-02f, 2.99006224e-01f, 1.08405381e-01f,
  4.57458645e-02f, -1.54784694e-01f, 2.34888420e-01f, 8.63122523e-01f, -1.82209387e-01f, -4.74423438e-01f, 2.58751154e-01f, 1.78956196e-01f, -8.14068690e-02f, 2.42161751e-03f,
  4.90420423e-02f, 5.25129199e-01f, -1.07570402e-01f, 1.61293328e-01f, -1.09230854e-01f, -6.40013516e-02f, -2.50623912e-01f, 3.62510651e-01f, -6.56349882e-02f, -1.14647597e-01f,
  -1.59443319e-01f, -3.44690114e-01f, 4.70918268e-01f, -2.32550472e-01f, 6.64354086e-01f, -4.38467450e-02f, 3.72233272e-01f, -4.72485960e-01f, -1.74150616e-02f, -4.18610245e-01f,
  3.86105835e-01f, -1.65770322e-01f, 6.22885585e-01f, 4.54687536e-01f, 6.33560717e-01f, 4.38202024e-01f, -2.06044242e-01f, 9.38661844e-02f, -2.72933189e-02f, 3.19345564e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  4.39849943e-02f, 4.22940105e-01f, 1.99649453e-01f, 3.19063902e-01f, 2.73805767e-01f, 5.24986945e-02f, -1.00753464e-01f, 1.91102371e-01f, 1.90413982e-01f, 6.00143194e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.21027398e-01f, -3.08774449e-02f, 2.23517746e-01f, -1.56830326e-01f, 6.73016787e-01f, -8.52798223e-01f, -3.64731669e-01f, 4.11464393e-01f, -5.64884096e-02f, -7.68860877e-02f,
  1.83955520e-01f, -1.05635054e-01f, -1.03283204e-01f, -1.66815668e-01f, -1.80190817e-01f, -1.79334328e-01f, -3.48087966e-01f, 5.62785985e-03f, -1.56552687e-01f, 5.30769229e-01f,
  -8.20661306e-01f, 9.81575847e-01f, 2.92058259e-01f, -2.71071792e-01f, 8.81620590e-03f, 5.46965003e-02f, 1.34699449e-01f, -1.42700717e-01f, 1.55054525e-01f, 1.98909104e-01f,
  2.01179475e-01f, 1.10610966e-02f, 6.15925388e-03f, -3.35964590e-01f, -1.53419033e-01f, -1.63935676e-01f, -5.48736453e-01f, 1.05229688e+00f, 7.09478697e-03f, -2.88042665e-01f,
  1.25405611e-02f, 4.50013638e-01f, 6.68701828e-02f, -7.95445815e-02f, 4.74318862e-01f, -8.08751304e-03f, -3.45566779e-01f, 1.10445723e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.16351414e-01f, 3.25002015e-01f, -2.89994121e-01f, -7.48044789e-01f, -2.53973067e-01f, 4.06911224e-01f, 3.13035727e-01f, 9.74208489e-02f, 9.50970769e-01f, -3.84040177e-01f,
  -6.44094869e-02f, -6.47767959e-03f, 2.19217390e-01f, -3.29427451e-01f, -3.26117203e-02f, 4.30382490e-01f, 7.35277653e-01f, 4.38235790e-01f, 9.65539813e-01f, -4.94153172e-01f,
  1.32709801e-01f, 9.23448980e-01f, -1.47474036e-01f, 4.31250423e-01f, -6.50640875e-02f, -2.06412911e-01f, -1.98417097e-01f, 1.69809908e-02f, -1.76746830e-01f, -3.28312308e-01f,
  -5.44380844e-01f, 7.81089425e-01f, -5.95114715e-02f, -1.15657143e-01f, 4.65463370e-01f, -7.57940933e-02f, 2.14986414e-01f, -3.29734683e-01f, -1.85425729e-01f, 3.54474932e-01f,
  -1.61588579e-01f, 3.38887155e-01f, 3.32570449e-02f, -2.26596802e-01f, 7.63603002e-02f, 2.73690253e-01f, 8.94818604e-02f, 1.48323238e-01f, 6.69687808e-01f, 2.49238178e-01f,
  4.79249051e-03f, -3.59747738e-01f, -5.73780298e-01f, 7.46169686e-01f, 8.30171928e-02f, -3.89437497e-01f, 4.25582230e-01f, 5.43716431e-01f, -2.05599159e-01f, 9.22797993e-02f,
  4.54090387e-01f, 4.89516817e-02f, -1.61541160e-02f, 2.05314621e-01f, 2.94962943e-01f, -4.01332118e-02f, -1.17468454e-01f, -2.10226551e-01f, 2.88946271e-01f, 1.03372641e-01f,
  -7.94122815e-02f, 4.33533967e-01f, 1.52775615e-01f, -2.46291026e-01f, -4.19869661e-01f, 4.01046932e-01f, 1.86241984e-01f, -5.63144274e-02f, -1.03632405e-01f, -3.40863131e-02f,
  -9.76644307e-02f, 4.64533381e-02f, 2.70268530e-01f, -2.22393394e-01f, 3.93175274e-01f, 9.36946124e-02f, 7.12828487e-02f, 1.03968754e-01f, 1.55573264e-01f, -7.58469552e-02f,
  8.17783251e-02f, 8.47266242e-02f, 3.71854054e-03f, -3.18381399e-01f, -2.52071738e-01f, -7.47184306e-02f, -6.07132912e-02f, 3.66708457e-01f, 5.28863907e-01f, 6.70498550e-01f,
  2.65444607e-01f, 3.68541360e-01f, 1.85103029e-01f, 3.90751380e-03f, 2.15162598e-02f, 6.46788776e-01f, 1.01732373e+00f, -1.31990924e-01f, -6.04669899e-02f, 2.93140978e-01f,
  4.26175237e-01f, 3.84041041e-01f, -6.08171709e-02f, -1.69966724e-02f, 6.57647610e-01f, 8.54158640e-01f, 1.14217496e+00f, -4.93344277e-01f, 2.47070417e-01f, -4.53228742e-01f,
  1.17159915e+00f, -1.67030454e-01f, -3.02807719e-01f, -9.54297632e-02f, 2.36093074e-01f, 9.83518243e-01f, -3.66021283e-02f, 2.34633297e-01f, -1.07358284e-01f, -4.73170698e-01f,
  -4.81698900e-01f, -4.52104181e-01f, 6.86956823e-01f, -7.84237683e-01f, -4.42618281e-01f, 1.78003967e-01f, 2.49659687e-01f, -3.90905999e-02f, 5.87969065e-01f, 6.72281444e-01f,
  -1.67691574e-01f, 1.83408394e-01f, 1.10283129e-01f, 9.43358779e-01f, 8.81826460e-01f, 6.23834550e-01f, 1.93563238e-01f, -8.67965937e-01f, -4.02447283e-01f, -2.16721490e-01f,
  -4.32821587e-02f, 7.84128189e-01f, -4.90158230e-01f, -1.54915661e-01f, -2.59900630e-01f, -1.35491654e-01f, -2.94758171e-01f, 1.33605316e-01f, -4.32443470e-01f, 7.04830587e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  6.21963628e-02f, 6.43100321e-01f, 1.22759223e-01f, 4.89554197e-01f, 7.76882768e-02f, 3.09963375e-01f, 4.02593911e-01f, 3.27017158e-01f, 2.39490867e-01f, 9.34277356e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.87071040e-01f, 9.63662863e-02f, -7.60463238e-01f, -7.85950363e-01f, 1.03651023e+00f, 3.53800297e-01f, 4.09017131e-02f, 3.10933501e-01f, -4.81403805e-02f, 7.57292271e-01f,
  -3.47782046e-01f, -3.39058816e-01f, -8.67771581e-02f, -5.47318578e-01f, -5.83788864e-02f, 6.66642308e-01f, 3.19916308e-01f, -1.13512166e-01f, 3.05769920e-01f, -7.40153313e-01f,
  7.68451095e-01f, 7.26759374e-01f, -3.57200027e-01f, -2.66854763e-01f, 7.14362487e-02f, 2.58840293e-01f, -3.03849280e-01f, -1.71624288e-01f, 1.10712194e+00f, -2.80482292e-01f,
  -4.08941090e-01f, -3.07535857e-01f, 1.51241809e-01f, 5.61282218e-01f, 3.31157774e-01f, 1.70762479e-01f, -1.21349372e-01f, -5.58669686e-01f, -2.47808665e-01f, -6.19760454e-01f,
  2.26349011e-03f, -4.81041163e-01f, 5.61311357e-02f, -1.18854374e-01f, 5.00317574e-01f, -2.31035188e-01f, 1.01640975e+00f, -6.26467884e-01f, -8.37924659e-01f, -4.15721327e-01f,
  -6.44291759e-01f, -1.46975935e-01f, 2.31693536e-01f, 2.53534675e-01f, 2.58622188e-02f, 4.88345399e-02f, -2.30138004e-01f, 5.97204603e-02f, 6.51837215e-02f, -1.43120855e-01f,
  5.04331775e-02f, 7.34804571e-01f, 6.33555502e-02f, -8.07595253e-01f, 5.28479517e-01f, 5.73489606e-01f, 3.17247719e-01f, -3.15655380e-01f, -6.91768050e-01f, 5.05592048e-01f,
  1.89196423e-01f, 8.27439368e-01f, -3.08440775e-01f, 3.15877229e-01f, 2.90226787e-01f, 2.86749989e-01f, -1.71450660e-01f, 2.38271967e-01f, 1.11661525e-02f, -2.07989722e-01f,
  5.88774741e-01f, 4.36407864e-01f, 6.15099370e-01f, -9.25901681e-02f, -1.60689384e-01f, 3.77749741e-01f, 1.48069337e-01f, 9.63305235e-01f, -1.28723294e-01f, 5.05075417e-02f,
  2.52443910e-01f, -1.12872668e-01f, -4.47198749e-01f, -6.86321199e-01f, -1.02817714e+00f, 1.15775132e+00f, -7.84958601e-01f, -7.69816160e-01f, -2.20305383e-01f, 6.35561466e-01f,
  -3.93935740e-01f, -5.08745492e-01f, -1.26582623e-01f, 3.41364602e-03f, 2.53101379e-01f, -2.89722025e-01f, 3.91801655e-01f, 1.26313612e-01f, -7.85766304e-01f, -8.35285723e-01f,
  5.92811882e-01f, 8.89189482e-01f, -6.65280640e-01f, -1.97681874e-01f, -6.70335889e-01f, -2.62824744e-01f, 6.79336309e-01f, 1.22187562e-01f, 1.06339908e+00f, -4.15078998e-01f,
  -4.02794212e-01f, 7.17089117e-01f, 2.46233031e-01f, -7.92016536e-02f, -3.94623816e-01f, -2.09166333e-01f, -3.63768667e-01f, -2.94559807e-01f, 5.51297903e-01f, 5.39918900e-01f,
  -3.31664920e-01f, 7.79337227e-01f, -8.14349592e-01f, -1.26956260e+00f, -7.50692725e-01f, -6.41209245e-01f, 1.73911244e-01f, -2.79395372e-01f, -1.86344832e-01f, -3.62617001e-02f,
  2.63607055e-01f, 1.01692057e+00f, -3.60100240e-01f, -8.38932395e-02f, -4.95756656e-01f, -2.26278573e-01f, 2.25270554e-01f, 8.78543615e-01f, -9.38044965e-01f, -2.74167687e-01f,
  1.34308934e-01f, 7.36920297e-01f, 3.77258211e-01f, -5.27311504e-01f, -3.09959859e-01f, 8.86901394e-02f, 4.40861613e-01f, -6.25595093e-01f, -2.39809137e-02f, 3.97641361e-01f,
  -4.14083004e-02f, 6.71375915e-02f, 4.04785305e-01f, -1.08443546e+00f, 1.18175626e-01f, 2.96900541e-01f, -5.36585450e-01f, -7.42347062e-01f, 2.13339433e-01f, -4.70901936e-01f,
  -2.16459706e-01f, -6.83254674e-02f, -3.31634632e-03f, 1.25142598e+00f, -8.07601362e-02f, -6.31203175e-01f, 3.01042795e-01f, -6.54873908e-01f, 2.11022153e-01f, 4.96843308e-01f,
  -6.62412345e-01f, -4.05071527e-01f, 2.97919154e-01f, -3.85947675e-01f, -1.71754450e-01f, -2.87526399e-01f, 2.96207160e-01f, -1.86076924e-01f, -4.10219848e-01f, 2.54694968e-01f,
  8.56977165e-01f, 1.86797112e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  7.39660189e-02f, 3.44448537e-01f, -1.39506370e-01f, -3.33977759e-01f, -1.93220958e-01f, -2.06080358e-02f, -2.56541390e-02f, 1.71955019e-01f, 5.04599631e-01f, -1.32866025e-01f,
  -4.13901061e-02f, -1.74963281e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    