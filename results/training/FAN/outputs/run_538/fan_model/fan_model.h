/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.82563829e-01f, 6.23142421e-02f, 5.04721552e-02f, -2.61619061e-01f, -3.29969972e-01f, -7.24117681e-02f, 1.21403866e-01f, -3.37210357e-01f, -2.60944039e-01f, 6.51450232e-02f,
  -1.90846011e-01f, 1.51810557e-01f, 2.18661070e-01f, -1.15928493e-01f, 1.13969289e-01f, 2.27204680e-01f, -1.33542165e-01f, -3.89888063e-02f, -1.10295802e-01f, -2.68275112e-01f,
  -8.61313269e-02f, -3.03569198e-01f, 8.02111626e-02f, -2.06674308e-01f, -1.99455768e-01f, -1.79197744e-01f, 1.04283199e-01f, 1.56390280e-01f, 3.46335620e-02f, 1.01790614e-01f,
  -1.33401796e-01f, -2.07518920e-01f, -1.63333848e-01f, 5.07055409e-02f, -8.10325667e-02f, 6.29128218e-02f, 2.14476138e-03f, 1.18416846e-01f, -3.23297530e-02f, -2.83737853e-02f,
  1.02949671e-01f, -1.03245080e-01f, -2.24330202e-02f, 8.92061070e-02f, -7.18938410e-02f, -9.16871279e-02f, -4.92308289e-02f, -6.47898540e-02f, -5.59118912e-02f, 2.34267078e-02f,
  2.91099921e-02f, -4.18402962e-02f, -3.16178310e-03f, -2.08378769e-03f, 1.39939534e-02f, -2.68446393e-02f, 1.10847548e-01f, 3.10357269e-02f, -8.41129795e-02f, -6.08255006e-02f,
  -8.91019925e-02f, 5.58266453e-02f, -5.25044464e-02f, -2.74536461e-02f, -1.61847547e-02f, 1.76072177e-02f, 1.00640923e-01f, 1.37390820e-02f, 1.45478901e-02f, -3.37799476e-03f,
  -6.10031188e-02f, -2.18311884e-02f, -7.33006597e-02f, -3.97087298e-02f, 7.29153529e-02f, -2.86663342e-02f, -8.08081683e-03f, -4.77431575e-03f, -1.69025734e-02f, 8.52013938e-03f,
  -4.16621845e-03f, 3.28895077e-02f, 5.23891672e-02f, -1.23732276e-02f, -3.86377040e-04f, 4.55144942e-02f, 3.50172110e-02f, -3.48698683e-02f, 4.53837626e-02f, 8.70150253e-02f,
  -1.40201241e-01f, -4.19095866e-02f, -8.67541134e-02f, -1.78453941e-02f, 7.32942969e-02f, 8.47846270e-03f, -1.82002392e-02f, -9.43617746e-02f, 4.22585458e-02f, -6.68768510e-02f,
  -3.39549370e-02f, 8.99942666e-02f, -2.22863872e-02f, -3.52273360e-02f, 2.55411901e-02f, -8.01247135e-02f, 3.52785885e-02f, 4.98047024e-02f, -2.69659348e-02f, -2.86978576e-02f,
  -8.38499367e-02f, -3.14038545e-02f, 6.28457814e-02f, -9.71783847e-02f, -1.01363279e-01f, 8.44004452e-02f, -8.73650685e-02f, 7.14856759e-02f, 6.95862621e-02f, 4.82393466e-02f,
  1.94160670e-01f, 2.86176234e-01f, -2.46699210e-02f, -3.03037375e-01f, 1.86408713e-01f, 3.98201644e-01f, 7.57174715e-02f, 3.82617146e-01f, 3.31956148e-01f, -5.29203974e-02f,
  -2.69170105e-01f, -1.08477809e-01f, -7.71526620e-02f, -1.92005306e-01f, -3.06122363e-01f, -6.02085851e-02f, -2.10261326e-02f, 1.42501788e-02f, 1.92725599e-01f, 1.22329019e-01f,
  4.79534753e-02f, -3.85387093e-01f, -2.80799180e-01f, 3.92673723e-02f, 1.20659411e-01f, 1.56998202e-01f, -2.08650157e-01f, 1.69528387e-02f, -6.04658499e-02f, 1.60456076e-02f,
  -4.47268412e-02f, 8.73134509e-02f, 5.34616709e-02f, -2.57802345e-02f, 2.15137228e-02f, 4.84281639e-03f, 1.72875524e-02f, -5.82001032e-03f, -7.81060830e-02f, 2.39588562e-02f,
  9.54207219e-03f, -1.70707196e-01f, -1.65979173e-02f, -1.29470453e-01f, 1.38839513e-01f, -9.95457987e-04f, 4.92401682e-02f, 4.03230600e-02f, 1.23832878e-02f, 5.13832271e-02f,
  -8.92797764e-03f, 1.69861957e-01f, 1.24198638e-01f, 5.06963395e-03f, 5.33306785e-02f, -3.28117199e-02f, -3.94742563e-02f, 3.81171778e-02f, 7.59075508e-02f, 9.77880955e-02f,
  4.26696390e-02f, 8.55555572e-03f, -5.32546006e-02f, -1.52059495e-01f, 6.38494790e-02f, 8.34890753e-02f, -1.69254281e-02f, 1.53673077e-02f, 5.79936840e-02f, -4.05754335e-02f,
  2.01769341e-02f, 3.56568926e-04f, 3.92957628e-02f, -5.88276656e-03f, -3.17593478e-02f, -3.43872723e-03f, 1.16613125e-02f, 6.98521174e-03f, 1.07829995e-01f, -5.47760073e-03f,
  -4.25103456e-02f, -5.19485660e-02f, -6.43221382e-03f, -1.94456819e-02f, -3.42559442e-02f, -4.57829572e-02f, 9.48905870e-02f, 4.91148159e-02f, 3.70462798e-02f, -6.04232922e-02f,
  1.13882780e-01f, 2.95836538e-01f, -1.22045679e-02f, 4.43940796e-02f, -7.83000216e-02f, 1.66671351e-02f, -9.16625708e-02f, 7.58347958e-02f, -5.84118441e-02f, 3.23508494e-02f,
  -2.53465772e-02f, 2.94538178e-02f, 2.43432261e-02f, -3.36772539e-02f, -4.15714234e-02f, 7.41780363e-03f, -1.18998736e-01f, 5.93926162e-02f, -6.58405125e-02f, 1.14146434e-01f,
  -5.60567863e-02f, 6.54233992e-03f, -3.58616784e-02f, 1.03521101e-01f, 4.58261520e-02f, 3.64661440e-02f, 1.44483879e-01f, 6.43907636e-02f, -1.04961820e-01f, 1.80419553e-02f,
  3.80066216e-01f, -3.01340431e-01f, -3.68088424e-01f, 1.99782327e-01f, -5.91663830e-02f, 2.12420166e-01f, 2.51276195e-01f, 2.08566129e-01f, 3.22342724e-01f, 1.07861102e-01f,
  1.02172136e-01f, 1.22139789e-03f, -4.58993316e-02f, 3.46295178e-01f, 3.93743902e-01f, 1.14014313e-01f, 2.36506209e-01f, 8.85305628e-02f, 4.41396981e-02f, -4.83514182e-02f,
  7.45929554e-02f, 2.62161046e-01f, 8.48492905e-02f, -8.12617242e-02f, -1.02265984e-01f, -1.21337399e-01f, 4.97760065e-02f, -1.51093483e-01f, 1.22089989e-01f, 5.11184186e-02f,
  -2.42839474e-02f, 1.26008287e-01f, 1.57408267e-02f, -9.43640992e-02f, 4.19443585e-02f, -8.92670900e-02f, -9.91745517e-02f, -1.51230143e-02f, -4.44154292e-02f, -1.11398902e-02f,
  -8.73596296e-02f, -1.98103096e-02f, -1.93487760e-02f, -6.67940676e-02f, -7.41706491e-02f, -3.49976346e-02f, -5.96727096e-02f, -4.07285569e-03f, -1.10226601e-01f, -6.15755878e-02f,
  2.22864542e-02f, -1.08740024e-01f, -5.87749332e-02f, -3.34595926e-02f, 2.47278716e-04f, 2.16329638e-02f, 4.59152181e-03f, -1.47932723e-01f, -2.61408221e-02f, 5.01880199e-02f,
  9.29567590e-02f, -6.47739023e-02f, -1.81850091e-01f, 1.85752250e-02f, 7.02009723e-03f, -1.47790655e-01f, -2.03225054e-02f, -1.95276011e-02f, 1.24777276e-02f, -4.21402752e-02f,
  8.22446495e-02f, 2.97074337e-02f, -2.56593898e-02f, 7.80234262e-02f, 8.72897804e-02f, 7.50522837e-02f, 7.59640262e-02f, 3.41327116e-02f, -1.64476794e-03f, 7.96140209e-02f,
  -9.60636288e-02f, 3.04912124e-02f, -1.21739663e-01f, -3.74079198e-02f, 3.12829316e-02f, 8.66220742e-02f, -5.14154360e-02f, 6.46469416e-04f, 2.63072830e-02f, 4.91775051e-02f,
  1.17097862e-01f, 2.94830561e-01f, 7.26740882e-02f, 2.22745147e-02f, -6.73429891e-02f, 2.26685144e-02f, -6.61942959e-02f, -4.13354784e-02f, 1.32516593e-01f, 1.09486185e-01f,
  -6.52870629e-03f, -7.14748353e-02f, -3.12518291e-02f, -2.86205299e-02f, -6.13191910e-02f, 4.36034575e-02f, 6.42526075e-02f, -8.50554854e-02f, 1.02445722e-01f, -6.92684716e-03f,
  6.47794735e-03f, 2.02289335e-02f, 3.73501852e-02f, -2.52421331e-02f, -3.93497245e-03f, 4.17672582e-02f, 7.01032653e-02f, -6.58103218e-03f, 4.21636254e-02f, -3.40177082e-02f,
  5.45451403e-01f, -3.41734856e-01f, -1.52670173e-02f, 3.24489892e-01f, 8.56566802e-02f, 1.27385303e-01f, 1.79932460e-01f, -8.34574103e-02f, 4.50735586e-03f, -8.32142383e-02f,
  1.96573660e-01f, 7.69224465e-02f, -3.31166804e-01f, 3.58795375e-01f, -6.81200996e-03f, -2.56050944e-01f, 1.36224389e-01f, 2.95022905e-01f, -2.18269393e-01f, 9.58652645e-02f,
  -1.42784677e-02f, 1.36258394e-01f, 1.09657750e-01f, -1.60062373e-01f, 1.93497702e-01f, 6.36926014e-03f, -1.42395392e-01f, -1.41308218e-01f, 1.89629644e-01f, -2.54768077e-02f,
  1.91259637e-01f, -7.64327794e-02f, 5.10409586e-02f, -8.14976245e-02f, 5.19718509e-03f, 5.23682237e-02f, 4.88409102e-02f, 7.13802800e-02f, 4.51558754e-02f, -3.27908210e-02f,
  -4.46088687e-02f, 2.15855166e-02f, -1.39305629e-02f, -8.68432149e-02f, 8.72326791e-02f, 1.37710832e-02f, 2.21747290e-02f, 8.00868198e-02f, 5.38368858e-02f, 5.17376103e-02f,
  4.70112860e-02f, 1.11866985e-02f, 6.17066547e-02f, -8.07767883e-02f, -1.97810996e-02f, -4.90512103e-02f, 5.99376149e-02f, 1.32377716e-02f, 7.40914270e-02f, 1.40669961e-02f,
  2.80024558e-02f, -1.30627275e-01f, 3.07436269e-02f, 3.75667959e-02f, -3.43227796e-02f, 2.49670632e-02f, 4.47237864e-02f, 5.18331006e-02f, -2.76867189e-02f, 5.68767898e-02f,
  7.46421367e-02f, 1.09042898e-01f, 4.83707301e-02f, 7.43635297e-02f, 4.94812010e-03f, 1.14963152e-01f, -1.12105217e-02f, -6.91883964e-03f, 1.76776573e-03f, 6.81901723e-02f,
  -1.13600111e-02f, 1.89457294e-02f, -2.30495036e-02f, 2.30637789e-02f, 6.46586716e-03f, -2.74262950e-02f, -7.89252594e-02f, 1.05618741e-02f, 2.95160916e-02f, 3.50693762e-02f,
  -2.08885849e-01f, -4.13466364e-01f, -5.96426018e-02f, 7.43385404e-02f, -4.92586978e-02f, 5.46530169e-03f, -2.55264831e-03f, 3.00125475e-03f, -1.15792066e-01f, -2.98822895e-02f,
  1.89248717e-03f, 2.93863416e-02f, -3.14535270e-03f, 1.09465525e-01f, 1.74927246e-02f, -2.01467462e-02f, 2.78772432e-02f, -5.18302582e-02f, 1.15835732e-02f, -1.63718462e-02f,
  4.93234657e-02f, 2.36271564e-02f, 3.91547568e-02f, -2.75948364e-02f, 2.18689218e-02f, -1.01359952e-02f, -2.00083759e-02f, 3.00635956e-02f, 9.25537388e-05f, -1.21450424e-02f,
  -3.62129480e-01f, 1.73670992e-01f, 1.57017544e-01f, -1.76693499e-01f, -4.19122279e-02f, -1.06633911e-02f, -1.91649899e-01f, 5.18582389e-02f, -1.81907505e-01f, 1.83896404e-02f,
  -2.62581021e-01f, 1.93436414e-01f, -1.88451901e-01f, -2.79495925e-01f, -2.99243450e-01f, -2.79373497e-01f, -1.36125818e-01f, -4.18869182e-02f, 1.08824961e-03f, -6.03093579e-02f,
  -9.93709825e-03f, -3.20083320e-01f, -1.27933785e-01f, 2.27685824e-01f, 4.44308855e-03f, 1.81230083e-01f, -7.58779198e-02f, 2.48328000e-01f, 1.68040603e-01f, -1.53031554e-02f,
  -6.74504638e-02f, -1.56712249e-01f, 5.74842058e-02f, 9.13567990e-02f, 2.53848974e-02f, 5.33924885e-02f, 1.10895909e-01f, 1.17456717e-02f, -7.45572001e-02f, 5.89306764e-02f,
  1.36664659e-02f, 1.47080980e-02f, -1.40969921e-02f, -6.64613470e-02f, 7.15961913e-03f, 1.43808136e-02f, -6.28863871e-02f, 5.26743568e-02f, 7.68300816e-02f, -5.64368181e-02f,
  -5.68933273e-03f, 3.96130010e-02f, 3.38760987e-02f, 1.21546336e-01f, 8.39057490e-02f, -3.10921799e-02f, 3.69712785e-02f, 1.40982285e-01f, 6.08456880e-02f, -4.80118357e-02f,
  -2.79864371e-02f, 2.58870181e-02f, -4.55287993e-02f, -6.20144829e-02f, -6.65315893e-03f, -7.95450155e-03f, -9.63852275e-03f, -1.86165073e-03f, 8.62779245e-02f, -5.43102361e-02f,
  2.32936745e-03f, 1.28749143e-02f, 1.80371664e-02f, -5.10631911e-02f, 2.54360307e-03f, 4.61789519e-02f, 7.16448575e-02f, 2.37727072e-02f, 6.03586920e-02f, 2.70866677e-02f,
  -7.73262093e-03f, 4.45315018e-02f, 4.30220515e-02f, 6.68863207e-02f, 4.12002355e-02f, -2.30118502e-02f, 2.27125976e-02f, -2.89155431e-02f, -9.55045745e-02f, -2.12736465e-02f,
  4.93035652e-02f, 1.31418824e-01f, -1.04092788e-02f, 4.61689569e-02f, 7.34652504e-02f, -3.51752192e-02f, -8.05457458e-02f, -3.03478949e-02f, -4.14328324e-03f, -4.81945202e-02f,
  3.89201269e-02f, 1.01885237e-01f, 5.43323494e-02f, 2.31075264e-03f, 8.05268213e-02f, -1.10516371e-02f, -1.29795512e-02f, 7.81193317e-04f, 3.21301594e-02f, 2.36370659e-04f,
  2.72641797e-02f, 2.91407071e-02f, 9.87280831e-02f, 2.16106791e-03f, 1.08919434e-01f, -2.85728667e-02f, 1.29611148e-02f, -4.06376570e-02f, 1.45457443e-02f, 4.69460487e-02f,
  -1.63327128e-01f, 1.36721686e-01f, 4.37214106e-01f, -1.50540575e-01f, -3.22419643e-01f, -1.43459871e-01f, 1.28151998e-01f, -1.03462730e-02f, 2.35054847e-02f, 3.81344855e-02f,
  -3.12499642e-01f, 3.27134341e-01f, 2.98169851e-01f, -2.39042893e-01f, 1.33867294e-01f, 5.10681281e-03f, -1.68400884e-01f, -1.08459806e-02f, 5.78720719e-02f, 3.62649225e-02f,
  -1.46413431e-01f, -3.77207547e-01f, 8.70039165e-02f, -1.89560771e-01f, -2.12095439e-01f, 1.05540119e-01f, 9.72854644e-02f, 2.93839246e-01f, -2.22210228e-01f, 6.27259538e-02f,
  -1.96169928e-01f, -1.18111402e-01f, -1.11412890e-01f, -3.70155908e-02f, -4.91467454e-02f, 7.16753975e-02f, 1.45222872e-01f, 7.19981417e-02f, 5.09024365e-03f, 6.28968328e-02f,
  -5.82973845e-02f, -1.37977019e-01f, -7.22027719e-02f, 6.04362115e-02f, -5.04774600e-02f, -3.57478671e-02f, -4.52305377e-03f, -9.10550877e-02f, -1.09770484e-02f, -8.60529989e-02f,
  -4.30618487e-02f, 7.79106468e-02f, -7.99385533e-02f, -6.71030730e-02f, 1.05003804e-01f, -1.16837712e-03f, 1.12585358e-01f, -1.78327244e-02f, -6.96369112e-02f, -9.86250788e-02f,
  6.96014017e-02f, 9.52789411e-02f, 2.11553872e-02f, -5.21289520e-02f, -2.36515654e-03f, -1.50549859e-01f, 1.29076838e-01f, -4.13118601e-02f, 4.46352661e-02f, -2.13639513e-02f,
  -1.25120863e-01f, -1.21548012e-01f, 1.67497192e-02f, -5.50048612e-02f, -3.73317376e-02f, -1.04846265e-02f, 3.25784348e-02f, -1.20586649e-01f, 2.35100295e-02f, -2.67638657e-02f,
  2.81548444e-02f, 1.22081405e-02f, -2.87518129e-02f, -8.20773020e-02f, 6.55670911e-02f, 8.92712697e-02f, 1.30923791e-02f, 1.80179626e-03f, 8.57068151e-02f, 5.86263128e-02f,
  -4.50182185e-02f, 2.18291447e-01f, 1.94027033e-02f, -8.66970122e-02f, 2.24467479e-02f, -2.57678106e-02f, 5.91175854e-02f, 5.35327010e-02f, 1.44445777e-01f, 9.46398266e-03f,
  4.41622883e-02f, -3.25366184e-02f, 4.20911126e-02f, -1.06533095e-01f, 5.58356307e-02f, 1.23527134e-02f, 1.14287458e-01f, 5.03429137e-02f, -7.29840025e-02f, 6.56800941e-02f,
  7.68900290e-02f, 5.90173043e-02f, 7.81321526e-02f, -5.00930287e-02f, -9.08224359e-02f, -1.74785685e-02f, 3.48564647e-02f, -1.00410385e-02f, 2.80400598e-03f, 9.24009923e-03f,
  -5.93330085e-01f, 4.04578149e-01f, 2.08720714e-01f, -2.96883374e-01f, -4.52219769e-02f, 4.21090811e-01f, 1.67390183e-01f, 2.84462757e-02f, -1.76848724e-01f, 1.77142546e-01f,
  5.50788455e-02f, -3.51546070e-04f, 2.46016234e-01f, 1.73970491e-01f, 1.11830391e-01f, 3.12082559e-01f, 8.57316628e-02f, 3.08440328e-02f, -4.36318703e-02f, -9.38680116e-03f,
  -7.68679157e-02f, 1.74492598e-01f, 1.65864229e-01f, 1.42448261e-01f, 9.85754770e-04f, -1.44715205e-01f, -6.57432973e-02f, 4.59497645e-02f, 3.75630185e-02f, 5.59146181e-02f,
  -6.48630485e-02f, -1.18914761e-01f, -6.00239560e-02f, -1.71815825e-03f, 2.12674942e-02f, -4.77546044e-02f, -2.96616163e-02f, -1.06573859e-02f, -1.83134172e-02f, 5.11638634e-02f,
  1.30086919e-04f, 4.89700325e-02f, -3.83735932e-02f, 1.80764310e-02f, -3.65306810e-02f, 5.53080738e-02f, 7.50272721e-02f, -8.05455260e-03f, 1.00158758e-01f, -3.70473275e-03f,
  3.68062221e-02f, 1.72099527e-02f, 5.30754356e-03f, 2.32961196e-02f, 3.60634439e-02f, 1.87541079e-02f, 5.74555844e-02f, -4.03289385e-02f, 1.01297619e-02f, -5.28448820e-02f,
  -4.59599495e-03f, -6.96195476e-03f, 5.23112752e-02f, -1.38976332e-02f, 1.96381379e-02f, -7.96281844e-02f, 1.47484839e-02f, 3.88186201e-02f, -1.54962810e-02f, 5.21990471e-02f,
  -5.75221926e-02f, 3.56286988e-02f, 1.31566003e-02f, 1.92150213e-02f, -4.51236926e-02f, -1.15734242e-01f, -2.86071710e-02f, 3.27733485e-03f, -6.50888011e-02f, -2.32895352e-02f,
  -7.22396141e-03f, -3.55857704e-03f, 6.12039678e-02f, 1.37916403e-02f, 5.14381938e-02f, 6.91831186e-02f, 6.78516701e-02f, -4.29784879e-03f, -8.05318058e-02f, 2.06682701e-02f,
  1.37040421e-01f, 2.95320034e-01f, 4.70753200e-03f, 3.09289619e-02f, 3.10034566e-02f, 4.40471321e-02f, -3.15082297e-02f, 1.95961795e-03f, 9.19285193e-02f, 3.32900062e-02f,
  2.80247126e-02f, -4.82063703e-02f, -1.15569467e-02f, -4.50686552e-02f, -1.46747287e-02f, 6.44071698e-02f, -5.20815179e-02f, -5.78206033e-02f, 6.09554071e-03f, -8.30045622e-03f,
  2.28315648e-02f, -1.75469425e-02f, 1.13067543e-02f, 9.63846873e-03f, -3.92514244e-02f, 7.04949396e-03f, -3.68272401e-02f, -3.11799254e-02f, 1.17325941e-02f, 2.42101140e-02f,
  -4.58197087e-01f, 3.00354302e-01f, -3.48804414e-01f, 1.12397537e-01f, -6.78587556e-02f, 7.57072791e-02f, -8.69616866e-02f, 1.65141568e-01f, -1.84659541e-01f, 3.90894622e-01f,
  2.11287320e-01f, 9.45025310e-02f, -1.36161253e-01f, 3.78153205e-01f, -1.94515258e-01f, -1.52647987e-01f, 2.42392451e-01f, 1.69783100e-01f, -1.59202516e-01f, 5.39356321e-02f,
  -1.52826712e-01f, 3.18443030e-01f, -3.74127738e-02f, 1.37321770e-01f, 1.30929232e-01f, -9.28142481e-03f, 1.35922968e-01f, -1.13702029e-01f, 3.60977590e-01f, 1.12251915e-01f,
  1.10960737e-01f, -5.96238635e-02f, -1.63029525e-02f, 2.82037258e-03f, -1.54565489e-02f, 1.77769456e-02f, 1.08991284e-02f, 3.54553796e-02f, -7.36465529e-02f, -2.44648065e-02f,
  -6.05116561e-02f, 1.85834039e-02f, 4.15904298e-02f, -4.65720259e-02f, -1.77755896e-02f, -9.95491515e-04f, -5.44688366e-02f, 2.33940911e-02f, 4.61144559e-02f, 8.35663290e-04f,
  -6.50446489e-02f, 2.95189042e-02f, -2.32007075e-02f, 1.03558823e-02f, -1.13541298e-01f, -5.70620503e-03f, 3.51814814e-02f, -5.73488884e-02f, 5.29388934e-02f, 6.93647796e-03f,
  1.83608066e-02f, -6.16140850e-02f, -4.94472496e-02f, 3.06982137e-02f, -2.65213046e-02f, 4.39946540e-02f, 1.76839028e-02f, 1.05210893e-01f, -5.79437576e-02f, 4.14110757e-02f,
  3.59380022e-02f, -1.77913345e-02f, 3.46704357e-04f, 1.85716432e-02f, -4.25938703e-03f, 4.11582272e-03f, -3.60576212e-02f, 1.04794584e-01f, -7.88624287e-02f, 4.81414609e-02f,
  2.87382640e-02f, 1.60344280e-02f, 2.58315634e-03f, -2.26407852e-02f, 6.32980540e-02f, -2.07723062e-02f, 8.67243856e-02f, -2.24311892e-02f, 1.81641672e-02f, 5.51431114e-03f,
  1.43248633e-01f, 1.31559923e-01f, -1.48992473e-02f, -1.02914097e-02f, 5.79438880e-02f, -8.91037136e-02f, -4.60238084e-02f, 1.97447538e-02f, 1.57359522e-02f, 9.86683276e-03f,
  2.00984608e-02f, -4.49591279e-02f, -3.44546847e-02f, 6.63346797e-02f, 6.14634678e-02f, -6.21073581e-02f, -3.06674093e-02f, -5.61432447e-03f, 1.09971669e-02f, 7.07285479e-02f,
  8.27255771e-02f, -5.12048602e-02f, 1.83390155e-02f, -4.57585566e-02f, 8.71025398e-02f, -4.71315645e-02f, 3.25793810e-02f, 3.23331319e-02f, 2.11485960e-02f, 1.67609081e-02f,
  -3.97619337e-01f, 3.21937174e-01f, 1.68109626e-01f, -2.99595714e-01f, -1.97873712e-01f, -4.79856953e-02f, 1.41345002e-02f, -1.83215812e-01f, -1.27637222e-01f, 2.30837837e-01f,
  -1.19074076e-01f, 2.56877333e-01f, 2.70403683e-01f, -4.69311327e-02f, -1.94746897e-01f, 2.61426210e-01f, -1.71000838e-01f, 1.22536451e-01f, 9.62074474e-02f, -1.96090236e-01f,
  -1.99518800e-01f, -2.30174467e-01f, 5.10723963e-02f, -1.14559188e-01f, -1.01685539e-01f, -7.07311407e-02f, -1.80828139e-01f, 8.12259689e-02f, -1.60867214e-01f, 7.97969326e-02f,
  -9.46073830e-02f, -1.08993083e-01f, 4.55780737e-02f, 8.20825025e-02f, -9.34240296e-02f, 3.93869244e-02f, -5.44502214e-02f, 1.23278365e-01f, 2.20800359e-02f, 8.26973766e-02f,
  1.10337712e-01f, 2.66346019e-02f, 6.15533069e-03f, 1.30524859e-01f, -3.90750580e-02f, 7.33086094e-02f, -3.83065850e-03f, 4.13128361e-02f, 2.58956514e-02f, 1.68222655e-02f,
  6.24116808e-02f, 2.10610870e-02f, -7.68130273e-02f, 6.44200742e-02f, -2.63922811e-02f, 4.19877470e-02f, -2.60803569e-02f, 2.29079556e-02f, 1.00304661e-02f, -6.40541911e-02f,
  5.79243526e-02f, -1.37620121e-02f, 7.73003176e-02f, -8.06697458e-03f, -4.51538041e-02f, -5.54998033e-02f, 8.29189196e-02f, -1.94197427e-02f, 4.90254909e-02f, -8.62326249e-02f,
  -1.28146797e-01f, -2.12428756e-02f, -1.05811305e-01f, 3.12873647e-02f, -7.73097277e-02f, -2.94932164e-02f, 4.17096987e-02f, 3.01110726e-02f, -8.88004825e-02f, -2.94011813e-02f,
  -4.35402356e-02f, -7.11311959e-03f, 8.65582936e-03f, -6.12159446e-02f, -3.70714068e-02f, -1.39531726e-02f, 1.24003356e-02f, 6.61469772e-02f, -2.10271571e-02f, -6.62107840e-02f,
  -5.18759526e-02f, -1.96156830e-01f, 1.40876565e-02f, 2.67761126e-02f, 5.66620454e-02f, -1.20953126e-02f, 2.78950837e-02f, -5.39278202e-02f, 8.30107629e-02f, -3.71349007e-02f,
  7.58843264e-03f, -1.26997083e-02f, -7.18994364e-02f, -3.49219218e-02f, 1.72014609e-02f, -1.16046749e-01f, -3.24987597e-03f, -4.47143428e-03f, 5.67844836e-04f, -1.69837624e-02f,
  -3.41606215e-02f, -2.27112379e-02f, 8.34468938e-03f, -1.74767315e-01f, -2.64319824e-03f, -9.31903794e-02f, 1.23956532e-03f, -4.55400348e-03f, 2.99676824e-02f, 4.36070189e-02f,
  -2.92383224e-01f, 2.18154237e-01f, 7.62545913e-02f, -8.71890187e-02f, -1.06863976e-01f, -5.11886895e-01f, -3.68405432e-01f, -6.46445751e-02f, 1.94361340e-02f, 2.02537298e-01f,
  1.69868930e-03f, 1.28303885e-01f, 2.04479054e-01f, -3.20394039e-01f, -4.03429389e-01f, 1.01588648e-02f, -3.67204964e-01f, -1.08669788e-01f, 1.56841688e-02f, 1.76540595e-02f,
  -1.17035164e-02f, -1.65721372e-01f, 7.48311430e-02f, 4.70518507e-03f, -1.22191519e-01f, 6.55716807e-02f, 1.22828126e-01f, 1.24682806e-01f, -6.80500492e-02f, -1.17177241e-01f,
  -1.10419221e-01f, 6.70846850e-02f, 3.15700583e-02f, -2.10084543e-02f, 1.11489827e-02f, -1.74137410e-02f, 6.15616096e-03f, -5.87241426e-02f, 2.95392908e-02f, 1.52323376e-02f,
  8.20636228e-02f, -4.56442721e-02f, -8.58822372e-03f, -4.27797362e-02f, -3.82845961e-02f, 3.28475311e-02f, 2.09299847e-02f, 1.92641020e-02f, 8.83171186e-02f, -5.66845713e-03f,
  -2.17335522e-02f, -2.36758515e-02f, 2.71238610e-02f, 5.09888418e-02f, 2.03284025e-02f, -2.28676153e-03f, -3.10847070e-03f, 6.98117763e-02f, 7.42004439e-03f, -6.41577318e-02f,
  -4.53298837e-02f, -3.36808302e-02f, -3.55089791e-02f, -2.99308747e-02f, -2.31107958e-02f, 1.87675916e-02f, -4.34360579e-02f, -1.59376133e-02f, 5.39162122e-02f, -2.09670234e-02f,
  -2.17166636e-02f, -2.67256387e-02f, -5.55821657e-02f, 1.05201453e-02f, 2.55575334e-03f, 1.48432218e-02f, -2.27147248e-02f, 5.07867970e-02f, -4.57953475e-02f, -5.75792640e-02f,
  1.50403082e-02f, -4.56441045e-02f, 2.81238575e-02f, 4.76308924e-04f, -4.89948094e-02f, -3.29981260e-02f, 4.58251834e-02f, -2.15851050e-02f, 7.72775784e-02f, -2.32451074e-02f,
  1.94062889e-02f, 1.33233324e-01f, 6.12215437e-02f, 2.20618322e-02f, -1.41201157e-03f, -2.33520847e-03f, -5.44958040e-02f, -7.63824955e-02f, -4.16376628e-02f, -4.85177264e-02f,
  -6.98857084e-02f, -4.63377722e-02f, -1.34355556e-02f, 1.15170563e-02f, 9.50920489e-03f, 4.39584116e-03f, 8.35618973e-02f, 1.35316802e-02f, -1.27246110e-02f, 1.29564032e-01f,
  2.86240969e-02f, -8.58434476e-03f, -2.41949111e-02f, -2.64154244e-02f, 1.50392782e-02f, 1.77096501e-02f, -6.18579462e-02f, -2.25967038e-02f, 9.00912508e-02f, 2.98147630e-02f,
  -5.42426594e-02f, 5.57210706e-02f, -5.78890443e-02f, 1.80713043e-01f, 1.80245146e-01f, -3.31035882e-01f, -2.75879446e-02f, 8.98559839e-02f, 2.76209377e-02f, 7.68933594e-02f,
  -1.54487059e-01f, 1.83687478e-01f, -1.77259579e-01f, -1.68445423e-01f, -2.18489796e-01f, -3.86086345e-01f, -1.77783817e-01f, -1.51010156e-01f, -6.06167652e-02f, 1.85187593e-01f,
  -1.31160095e-02f, 2.01710001e-01f, -1.47388682e-01f, 3.58450770e-01f, 4.12607417e-02f, 1.97278351e-01f, 1.89786181e-01f, 2.39126042e-01f, 1.41433313e-01f, 7.12432191e-02f,
  -1.74115881e-01f, 7.76528241e-03f, 2.63354778e-02f, 3.61590497e-02f, -1.08756013e-01f, 5.55197261e-02f, -7.54455943e-03f, 8.48349854e-02f, 4.73507568e-02f, -6.56566955e-03f,
  -2.41533592e-02f, 3.85734551e-02f, 8.97164568e-02f, 1.29179269e-01f, 1.51339814e-01f, 7.23499944e-03f, -1.00661866e-01f, -1.33176595e-01f, 5.99600486e-02f, -1.48415476e-01f,
  -2.90292762e-02f, -1.36024758e-01f, -1.09971762e-01f, 2.02428065e-02f, -4.44036648e-02f, 1.56402923e-02f, -1.81381553e-02f, -3.98178250e-02f, -6.43318817e-02f, 8.55709165e-02f,
  3.02480138e-03f, 3.08544654e-02f, -4.23174788e-04f, 8.35660174e-02f, 8.32275376e-02f, 3.72523628e-02f, 3.19964699e-02f, -1.53582273e-02f, 4.06884477e-02f, -8.96902382e-02f,
  8.27687979e-02f, 1.45899672e-02f, 3.95540781e-02f, 2.39859745e-02f, -2.34170780e-02f, 5.33368662e-02f, 9.72210392e-02f, 2.11044475e-02f, -2.87974998e-02f, -6.22196682e-02f,
  1.58592481e-02f, -5.11786751e-02f, 5.23456782e-02f, -3.85571904e-02f, 2.77315290e-03f, -2.62403321e-02f, -3.03309038e-03f, -1.17393769e-01f, -5.79176731e-02f, -1.37335085e-03f,
  -7.78722316e-02f, 1.33768365e-01f, -4.79078330e-02f, 1.24802522e-01f, 5.16010821e-02f, -5.36385030e-02f, 1.39253335e-02f, -1.27197867e-02f, -2.42228224e-03f, 8.46185237e-02f,
  5.16899601e-02f, 3.07884309e-02f, -2.30642464e-02f, 3.57806608e-02f, 2.81279273e-02f, 6.68469700e-04f, 5.31181581e-02f, 1.97641738e-02f, 1.51464283e-01f, 4.78475168e-03f,
  -1.37836277e-03f, 1.34136789e-02f, 7.07177669e-02f, 1.04058580e-02f, -2.91631315e-02f, -5.78847006e-02f, 5.62400706e-02f, -5.55782728e-02f, 5.42449318e-02f, -8.47332552e-02f,
  2.05186918e-01f, -3.88179362e-01f, -2.45265514e-01f, -2.73585487e-02f, 4.39319819e-01f, 1.61262602e-01f, 2.95549836e-02f, 1.17875166e-01f, -3.13105017e-01f, -1.47361115e-01f,
  2.65876114e-01f, -1.93935290e-01f, -7.19329715e-02f, 3.67754363e-02f, 2.87862688e-01f, -1.09588586e-01f, -9.20081511e-02f, -5.28653972e-02f, 3.58829163e-02f, -3.26806828e-02f,
  1.50045231e-01f, 3.52365613e-01f, 2.11673453e-01f, 2.01308236e-01f, 1.74391985e-01f, -1.21447891e-01f, 1.46274582e-01f, -1.12674581e-02f, 9.25051272e-02f, 9.98338610e-02f,
  1.11715235e-01f, -2.08523255e-02f, -4.07796800e-02f, -8.44710842e-02f, 1.07924722e-01f, 6.11329973e-02f, -7.16510182e-03f, 1.02928624e-01f, 1.24660451e-02f, 6.90037832e-02f,
  -6.76480457e-02f, 8.04940835e-02f, -3.96923758e-02f, 4.98571713e-03f, -1.07745379e-02f, 4.72669192e-02f, 9.75755788e-03f, 4.62827794e-02f, -5.14491908e-02f, 1.22279368e-01f,
  4.01950665e-02f, -2.83650905e-02f, 1.07859215e-03f, -5.53843752e-03f, 6.22793660e-02f, 2.66037639e-02f, -3.79389599e-02f, 1.04028821e-01f, -3.97570841e-02f, 9.26963985e-02f,
  1.08597726e-01f, -6.25714101e-03f, 1.22410497e-02f, 3.15487050e-02f, -1.72549766e-02f, 5.78029267e-02f, -4.63240668e-02f, 7.79052228e-02f, -2.34522372e-02f, 5.39070591e-02f,
  1.55687332e-02f, 1.85722895e-02f, 2.01609787e-02f, 4.42183726e-02f, 7.46217519e-02f, -2.51069628e-02f, -6.84989542e-02f, -2.21690489e-03f, -5.10264002e-02f, 2.58824043e-02f,
  -4.01793197e-02f, -9.20206010e-02f, -9.15194582e-03f, -2.92790210e-04f, -8.60113353e-02f, -3.03785149e-02f, -1.29135046e-02f, -8.40615481e-02f, 5.70615865e-02f, 1.99845433e-02f,
  -2.26204902e-01f, -2.03537017e-01f, -2.23407173e-03f, 8.79763998e-03f, -9.92913693e-02f, 3.27238850e-02f, -4.87581193e-02f, -2.58663166e-02f, -7.84230977e-02f, -9.10484865e-02f,
  1.38376758e-01f, 4.77633402e-02f, -1.39449403e-01f, 1.81426667e-02f, -8.88862647e-03f, 4.19925451e-02f, -4.72130142e-02f, -1.41565427e-01f, -8.81314799e-02f, 3.10654454e-02f,
  3.06890663e-02f, 1.30667984e-01f, 4.25208956e-02f, 1.64557740e-01f, 6.65289536e-02f, 2.17274539e-02f, 1.47511763e-02f, -9.51133668e-02f, 5.40749468e-02f, -2.88401153e-02f,
  -3.44985306e-01f, 2.55101011e-03f, -2.17389524e-01f, -2.94974327e-01f, -1.79258734e-01f, 1.43150419e-01f, -1.74502552e-01f, 2.66238391e-01f, -1.08905673e-01f, 3.38276565e-01f,
  4.91415374e-02f, -1.26872072e-02f, 3.00485790e-01f, -3.29520583e-01f, -3.57356131e-01f, 3.78334910e-01f, -2.00678080e-01f, -1.06640467e-02f, 1.91897564e-02f, 7.42599815e-02f,
  -1.89139709e-01f, -3.16445604e-02f, -9.75494385e-02f, 1.72163010e-01f, -2.00421706e-01f, -1.51281670e-01f, -2.06395164e-01f, -3.81285837e-03f, -3.08159322e-01f, -2.38488272e-01f,
  -6.50583673e-03f, 4.44469489e-02f, -1.12317920e-01f, -2.38813087e-02f, 5.62954359e-02f, 3.94307151e-02f, -1.03367068e-01f, -2.55991216e-03f, -6.47773892e-02f, 8.18394590e-03f,
  7.89914876e-02f, 4.61458042e-03f, -2.76936125e-02f, 7.40416497e-02f, -1.11418709e-01f, -4.09575477e-02f, -5.01961000e-02f, 1.95031706e-02f, -5.93290143e-02f, -2.64390581e-03f,
  -1.53221656e-02f, -4.04299386e-02f, -7.93039948e-02f, -2.27688290e-02f, -1.61724344e-01f, -1.46460459e-01f, -5.74750826e-02f, -2.46533360e-02f, -3.94746885e-02f, -4.88571636e-02f,
  1.68983452e-02f, 5.89101762e-03f, 4.95010279e-02f, 6.54298067e-02f, 5.76520227e-02f, -1.91690810e-02f, 2.32427493e-02f, 2.97042634e-02f, -1.08704731e-01f, 2.55049914e-02f,
  -1.35153625e-02f, -5.89600429e-02f, 3.62926684e-02f, 4.66222167e-02f, -1.61840599e-02f, 6.38651028e-02f, 5.86070605e-02f, 7.17756450e-02f, 5.35817221e-02f, 3.53485234e-02f,
  5.35721555e-02f, -6.90048411e-02f, 3.31891663e-02f, -2.62182932e-02f, 4.01927792e-02f, 8.03368818e-03f, 1.64079051e-02f, -5.14671858e-03f, 7.27905482e-02f, -4.88996468e-02f,
  -2.98664737e-02f, -1.23972580e-01f, 3.25544737e-02f, -5.10518067e-02f, 1.76918879e-02f, 4.95879315e-02f, -7.07223266e-03f, -3.98507677e-02f, -6.03763200e-02f, 3.45395058e-02f,
  3.40073258e-02f, -5.47212735e-02f, 7.17896521e-02f, -7.11116195e-02f, 3.55939716e-02f, -1.69960856e-02f, -3.63516770e-02f, -3.35875116e-02f, -3.63963880e-02f, 5.47040962e-02f,
  1.71524417e-02f, 1.55671299e-01f, 9.15500298e-02f, -1.58364128e-03f, -5.70934154e-02f, 5.50262257e-02f, 7.19586313e-02f, -7.00252969e-03f, -5.14659509e-02f, 1.23306811e-02f,
  4.15989637e-01f, 2.13418633e-01f, 1.93460777e-01f, -8.33220556e-02f, 7.82931522e-02f, 2.20296815e-01f, 7.53238201e-02f, 1.64988160e-01f, -8.87680799e-02f, 1.77643865e-01f,
  2.54996508e-01f, 8.06209147e-02f, 2.30847701e-01f, -4.73792218e-02f, 8.17945376e-02f, -5.20700328e-02f, 1.26628250e-01f, 1.28382608e-01f, -1.23649932e-01f, 2.20466897e-01f,
  -3.20929959e-02f, -7.36345947e-02f, 1.16643690e-01f, -9.37216505e-02f, 3.72473001e-01f, -5.39847463e-02f, -1.61304008e-02f, -9.39902291e-02f, 1.65601168e-03f, -1.47823840e-02f,
  9.30926949e-02f, -3.67869101e-02f, 3.62741463e-02f, 1.70642268e-02f, 1.44451573e-01f, -6.90036118e-02f, 9.20455456e-02f, -3.95769477e-02f, -1.21824279e-01f, 2.33159699e-02f,
  4.36294079e-02f, 9.34022963e-02f, -1.44927227e-03f, -1.39188170e-01f, 9.10542384e-02f, 2.66052801e-02f, 1.88662764e-02f, 8.97269398e-02f, 1.26069367e-01f, 7.20285550e-02f,
  1.76559191e-03f, 4.57728095e-02f, 8.09864104e-02f, 8.04693103e-02f, 6.46755248e-02f, -1.01226337e-01f, -1.15831859e-01f, 5.44176921e-02f, 1.35004416e-01f, -8.82570166e-03f,
  2.08151322e-02f, -1.30869985e-01f, -1.85115151e-02f, -2.05428898e-02f, 3.62802148e-02f, 4.30983454e-02f, -2.14436706e-02f, -3.21168802e-03f, -1.95237398e-02f, 1.68955520e-01f,
  -5.58617525e-02f, -2.51737759e-02f, -5.18490709e-02f, -1.19226174e-02f, -7.43937641e-02f, 4.53999685e-03f, 4.97586019e-02f, -1.18762413e-02f, 2.83957105e-02f, -6.04826398e-02f,
  -7.79649094e-02f, 4.03090287e-03f, 8.20239261e-02f, 6.18832521e-02f, -1.49840377e-02f, -2.69046659e-03f, 1.30711924e-02f, 8.16801414e-02f, -1.69222746e-02f, 1.17001221e-01f,
  2.65631378e-01f, 1.86588436e-01f, -1.85850635e-02f, 1.38314098e-01f, -4.25869972e-02f, 1.01056062e-01f, -1.97606623e-01f, -1.74214114e-02f, 9.16631147e-03f, 3.94670740e-02f,
  -2.02254057e-02f, 1.33541571e-02f, 3.06535028e-02f, -9.38083045e-03f, -7.10391998e-02f, -8.45880434e-03f, -1.76365487e-02f, 3.72476205e-02f, 7.70939738e-02f, 4.54220474e-02f,
  1.12983160e-01f, -1.26266573e-02f, -1.21964114e-02f, 5.27077820e-03f, 9.53837764e-03f, 9.69765559e-02f, 6.04102127e-02f, -1.16330326e-01f, -6.53321147e-02f, 2.53922562e-03f,
  2.24449128e-01f, -2.10078746e-01f, 4.03303802e-01f, -7.51412287e-02f, 5.76748028e-02f, -3.00009370e-01f, 4.98329327e-02f, -1.09089881e-01f, -1.33651748e-01f, -3.79837483e-01f,
  -1.89878456e-02f, -1.91877931e-01f, 1.98083356e-01f, -2.72586823e-01f, -1.81525528e-01f, -1.74852498e-02f, -3.00436646e-01f, -2.89063931e-01f, 2.71823183e-02f, 2.25977856e-03f,
  -2.43023578e-02f, -3.43116552e-01f, 1.32646978e-01f, -2.30687678e-01f, 4.00610305e-02f, 1.23152435e-01f, -1.41535923e-01f, 1.33585468e-01f, -1.75883234e-01f, -1.78065583e-01f,
  7.70473015e-03f, 1.01467624e-01f, 1.23391621e-01f, -5.11323102e-02f, 1.23989489e-02f, 5.29862568e-02f, 2.50844974e-02f, 3.18057276e-02f, 7.25883171e-02f, -1.50536681e-02f,
  1.79694849e-03f, -7.10920542e-02f, -1.25705540e-01f, -9.63730142e-02f, 3.21228132e-02f, 6.15287311e-02f, 5.85492700e-02f, 9.30905864e-02f, 5.33341477e-03f, 1.39121056e-01f,
  1.20901868e-01f, 9.85988528e-02f, 1.06487177e-01f, -2.53319349e-02f, 8.16633478e-02f, -1.92022196e-03f, -3.95832360e-02f, 9.99853611e-02f, -5.75720705e-02f, -6.43756166e-02f,
  -1.43796736e-02f, -1.77979302e-02f, 5.23721464e-02f, 1.86739620e-02f, 3.75809241e-03f, 3.27467173e-02f, -8.72066543e-02f, 3.60012576e-02f, -1.69973392e-02f, -3.05611920e-03f,
  -1.25471335e-02f, 4.74037454e-02f, -6.00004289e-03f, -2.40391120e-02f, 6.04027212e-02f, 1.64103210e-02f, 4.91606742e-02f, -7.05282539e-02f, 3.53581719e-02f, 6.20799400e-02f,
  -9.19071585e-03f, 1.09801451e-02f, 1.95449628e-02f, 6.06404580e-02f, -4.39496338e-02f, 1.12116113e-02f, -8.96299705e-02f, 1.41847143e-02f, 3.40461060e-02f, -4.70336564e-02f,
  -1.33023366e-01f, -3.15144777e-01f, -1.21666212e-03f, -6.20355383e-02f, -8.83546323e-02f, 3.44947390e-02f, -4.02376950e-02f, -1.09754376e-01f, -3.53688002e-02f, -5.02534509e-02f,
  1.93597935e-02f, 4.23617773e-02f, 6.14531524e-03f, 1.82705298e-02f, -1.23133481e-01f, 1.70781091e-02f, -6.66430667e-02f, -1.48675069e-01f, -1.00411147e-01f, -6.99166879e-02f,
  -4.98552397e-02f, 2.16910895e-02f, -4.99917828e-02f, -3.74808572e-02f, -5.72581291e-02f, 2.52993722e-02f, 3.64235565e-02f, -5.80731258e-02f, 5.01023494e-02f, -6.01142906e-02f,
  1.28718257e-01f, 3.62718031e-02f, -1.80437535e-01f, -3.72649692e-02f, -2.42312744e-01f, -4.36857730e-01f, -3.23034316e-01f, -1.91271260e-01f, -3.13913226e-01f, 2.22100019e-01f,
  6.40791059e-02f, 2.95939893e-01f, 1.56176671e-01f, 2.05682814e-02f, -3.45444262e-01f, -2.34317034e-01f, -2.13847235e-01f, -9.36125517e-02f, -1.38641149e-01f, 1.69334918e-01f,
  -5.19292057e-02f, 4.94629890e-02f, 7.94090703e-02f, 8.45374539e-02f, 4.17000018e-02f, 2.42342338e-01f, 3.19509804e-01f, -5.22395186e-02f, 1.60640821e-01f, -1.10212967e-01f,
  -8.42150375e-02f, 6.15104474e-02f, 9.06458721e-02f, 9.74718574e-03f, -7.17067486e-03f, -4.63249441e-03f, -2.69462224e-02f, -5.71270585e-02f, 5.89174591e-03f, 4.08658981e-02f,
  1.19291402e-01f, 2.55617127e-02f, 4.53907363e-02f, -1.65988617e-02f, -2.59497631e-02f, 1.06680237e-01f, 1.44050308e-02f, 3.09475977e-02f, 7.45624378e-02f, -4.39028721e-03f,
  4.48579863e-02f, 1.35550816e-02f, 2.77785044e-02f, 3.08102388e-02f, 2.43485235e-02f, 4.96586449e-02f, -2.01336555e-02f, -7.33594969e-02f, 3.32269110e-02f, -1.00591369e-01f,
  1.77984126e-02f, -1.34650797e-01f, 5.99101596e-02f, -2.14134473e-02f, 1.26705114e-02f, 2.06744298e-02f, 1.78833902e-02f, -1.02607133e-02f, -1.17563196e-02f, 2.08022092e-02f,
  3.85643356e-02f, 5.22538014e-02f, 1.80328346e-03f, 2.61343122e-02f, 4.17435914e-02f, 2.29269117e-02f, -2.79245935e-02f, 3.12298387e-02f, -4.65681069e-02f, -4.14280742e-02f,
  3.44954580e-02f, 3.20229232e-02f, 7.64269084e-02f, 6.72724172e-02f, 1.43924020e-02f, -4.30739075e-02f, 2.60193888e-02f, -3.30407545e-02f, -8.51908326e-03f, -8.58125165e-02f,
  -1.84849799e-01f, -1.24792501e-01f, -7.75828632e-03f, 6.02941588e-02f, -3.83919664e-02f, -2.48569474e-02f, -1.37029216e-01f, -7.12267756e-02f, -9.18199047e-02f, 5.34064434e-02f,
  -5.20247093e-04f, 1.96145177e-02f, 9.66750085e-02f, 4.02066074e-02f, -2.40659155e-02f, -6.37562051e-02f, 1.14384092e-01f, -3.11646815e-02f, 2.73598712e-02f, 3.61819118e-02f,
  1.03315823e-01f, 6.77499995e-02f, -2.13186331e-02f, -6.96543530e-02f, 5.33306003e-02f, 1.49485156e-01f, 3.84815820e-02f, -4.07171734e-02f, -3.79139185e-02f, -1.63319695e-04f,
  4.23023075e-01f, -1.49939105e-01f, -2.28871703e-01f, -4.71803471e-02f, 2.90337622e-01f, -3.34336668e-01f, -1.56237796e-01f, -4.47005555e-02f, -1.09627232e-01f, -1.48414314e-01f,
  -3.53854001e-02f, -1.32415608e-01f, -1.92811057e-01f, -3.45438063e-01f, -3.40999573e-01f, -3.00892800e-01f, -4.08601761e-01f, -1.39772907e-01f, -5.27273342e-02f, 4.20250557e-02f,
  -6.09122105e-02f, -7.52474889e-02f, -1.90859675e-01f, 1.40537545e-01f, 1.54540658e-01f, 2.48823211e-01f, 8.35961252e-02f, 1.10156894e-01f, -2.73601934e-02f, 4.53253090e-02f,
  5.61645441e-02f, 1.33968428e-01f, 5.73173910e-03f, 1.37800081e-02f, 9.01783642e-04f, 5.07845730e-02f, 7.10195526e-02f, -5.23187555e-02f, -6.64740056e-02f, -5.54253086e-02f,
  -3.50732729e-02f, 2.28085220e-02f, -2.75570359e-02f, -1.39986174e-02f, 3.11591104e-02f, -1.30284671e-03f, -9.10942405e-02f, -1.15107922e-02f, 5.64964581e-03f, -2.27830335e-02f,
  -6.31643385e-02f, -1.48036433e-02f, -1.30872220e-01f, -9.15791243e-02f, -4.11733761e-02f, -2.26500854e-02f, -4.67493460e-02f, 3.24475802e-02f, -3.04990020e-02f, 4.98399995e-02f,
  3.96655947e-02f, 3.90521735e-02f, -7.63897784e-03f, 5.98624572e-02f, -1.15280924e-02f, 1.38488010e-01f, -9.80716348e-02f, 4.59832624e-02f, 4.50758003e-02f, 4.20404449e-02f,
  2.53384262e-02f, -6.39252504e-03f, 1.88989490e-02f, -2.55656950e-02f, -2.97909416e-03f, 2.26801485e-02f, -3.51387006e-03f, 2.63139587e-02f, -2.49131061e-02f, 1.27037903e-02f,
  4.14400883e-02f, -6.48715571e-02f, -3.36834565e-02f, 1.27882627e-03f, -1.10640623e-01f, 1.35305105e-02f, -1.27878113e-04f, -1.69899072e-02f, 2.53534913e-02f, 8.84291157e-03f,
  -3.22471000e-02f, -1.61448896e-01f, -4.91066538e-02f, 3.00053526e-02f, 9.76342801e-03f, 5.51321683e-03f, -7.01764524e-02f, 4.65595759e-02f, -1.17641073e-02f, -8.54867278e-04f,
  8.12591985e-02f, 1.85945258e-02f, 5.97139336e-02f, 5.64656183e-02f, 1.12116281e-02f, -8.61248970e-02f, -8.74255318e-03f, 5.51927574e-02f, -4.99574915e-02f, 3.22050676e-02f,
  4.03815359e-02f, 6.85635656e-02f, 4.26207148e-02f, 1.13779366e-01f, 6.89358562e-02f, 5.53502962e-02f, 1.59116145e-02f, 1.02349721e-01f, -5.07890843e-02f, -8.71670470e-02f,
  1.41682774e-02f, 3.39819193e-01f, -3.62283409e-01f, -1.89623004e-03f, -4.60289605e-02f, -8.78985748e-02f, -1.96936116e-01f, 9.61733684e-02f, 1.07132360e-01f, 3.02465975e-01f,
  9.12661403e-02f, 2.98965815e-02f, 3.30021977e-02f, -6.74664928e-03f, -2.05984175e-01f, -1.83766246e-01f, 8.40050578e-02f, -3.75703606e-03f, -2.67050900e-02f, 9.00281221e-02f,
  -5.78898489e-02f, 2.50236928e-01f, -3.09346706e-01f, 6.95184544e-02f, 7.09416717e-03f, -3.87674868e-02f, 7.19937459e-02f, -1.50247648e-01f, -2.62624212e-02f, -1.71773415e-02f,
  4.61722352e-03f, 9.81919393e-02f, 2.65526995e-02f, -6.08842596e-02f, -5.03388718e-02f, -5.54514444e-03f, -1.84323620e-02f, -1.28179118e-01f, -3.80663686e-02f, 7.37927109e-03f,
  -7.46427476e-02f, -2.52416581e-02f, 1.52568975e-02f, -3.52154672e-02f, 4.29397076e-02f, 2.00498160e-02f, -5.14083803e-02f, -3.06697842e-02f, -4.64108773e-02f, -8.67336169e-02f,
  -1.27166370e-02f, -5.30600883e-02f, 9.23839340e-04f, 1.92400664e-02f, -6.19372400e-03f, 7.20329955e-02f, -4.39583138e-02f, -5.00929058e-02f, 7.80296400e-02f, 4.32488322e-03f,
  -5.32145388e-02f, 4.97451425e-02f, -1.26995752e-02f, -5.57716005e-02f, 2.03410499e-02f, -5.06084301e-02f, 5.91781884e-02f, -7.34128132e-02f, 1.05199941e-01f, 2.01279181e-03f,
  -9.09047276e-02f, 1.08561711e-02f, -1.27752721e-02f, -5.14658727e-03f, 3.27536464e-02f, 1.81691088e-02f, -4.01167385e-02f, 2.21613776e-02f, 1.96043793e-02f, -9.72371250e-02f,
  6.94535226e-02f, 1.76202469e-02f, -1.21920258e-02f, -3.93970869e-02f, 9.21889301e-03f, 4.83477451e-02f, 8.07551071e-02f, -2.82763895e-02f, 1.35983778e-02f, -7.24038854e-02f,
  3.14585745e-01f, 3.37005913e-01f, 7.53794760e-02f, 9.94142592e-02f, 5.82330488e-02f, -5.02035581e-03f, -5.41770458e-02f, 5.37413582e-02f, 1.57626435e-01f, -1.08943321e-02f,
  1.29700974e-01f, -1.58469821e-03f, -3.59886661e-02f, -7.43438601e-02f, 2.41699796e-02f, -1.19106779e-02f, 3.84817012e-02f, 1.31340235e-01f, 1.93225697e-01f, 6.76037967e-02f,
  -6.83329441e-03f, 9.89862159e-03f, -7.33468384e-02f, 3.40065137e-02f, 2.65595783e-02f, -2.99588079e-03f, 2.49530133e-02f, -5.86179458e-02f, -1.40227415e-02f, 2.06654184e-02f,
  -6.57281727e-02f, -2.07021475e-01f, 2.73478061e-01f, -1.52651668e-01f, 1.04269728e-01f, 2.11355696e-03f, -2.18508080e-01f, 4.45780158e-02f, 2.03093916e-01f, -3.05619866e-01f,
  -2.68085748e-01f, 9.47775543e-02f, -1.04233928e-01f, -2.77794868e-01f, 1.20963044e-01f, 2.29146555e-02f, -3.14777255e-01f, -2.09926099e-01f, 1.89580649e-01f, -9.39410552e-02f,
  7.65889212e-02f, -2.12504134e-01f, 1.57089420e-02f, 2.39845365e-02f, -2.15339914e-01f, 8.49417225e-02f, -2.79631972e-01f, 1.74159274e-01f, -2.51742452e-01f, 9.62760895e-02f,
  -1.78219691e-01f, 8.02095905e-02f, 2.55375411e-02f, 3.89469266e-02f, -1.84488922e-01f, -1.21877484e-01f, -4.09148447e-03f, 6.39165863e-02f, 1.03232823e-01f, 2.83435080e-02f,
  -5.74371628e-02f, 7.58076534e-02f, 2.01849192e-02f, 1.29541844e-01f, 3.44745554e-02f, 1.01290591e-01f, 5.05211651e-02f, -5.20610483e-03f, 5.00551201e-02f, 1.49923474e-01f,
  5.20817079e-02f, -4.55083102e-02f, -5.11433110e-02f, -3.28621976e-02f, 1.12484179e-01f, 3.29944231e-02f, 5.65302558e-02f, 8.15837923e-03f, 6.26126584e-03f, 8.01660772e-03f,
  7.21109360e-02f, 3.91656160e-02f, 8.54041055e-03f, 7.78321028e-02f, 2.58766674e-02f, -3.29173543e-03f, -8.45162570e-03f, -5.65760881e-02f, 1.60543863e-02f, -5.40138260e-02f,
  -4.88453619e-02f, 1.25341853e-02f, 2.11481340e-02f, -1.48269152e-02f, -1.01309214e-02f, 4.99456413e-02f, 4.58632316e-03f, -3.18248905e-02f, -9.01036039e-02f, -7.08428025e-03f,
  7.70908780e-03f, 6.12161122e-02f, -4.18383479e-02f, -4.84525561e-02f, 4.39528115e-02f, 2.93705091e-02f, -8.37229118e-02f, 5.26073575e-02f, -3.40514304e-03f, 6.55371547e-02f,
  -3.44633669e-01f, -1.83921501e-01f, 4.60707359e-02f, 5.99487796e-02f, -3.29100788e-02f, 5.57901412e-02f, 1.64953060e-02f, 7.47127682e-02f, -9.77396592e-02f, 6.72047511e-02f,
  -6.50127903e-02f, -8.87843892e-02f, -1.14095137e-01f, 4.44822423e-02f, -8.49940814e-03f, -1.86778437e-02f, -6.23009168e-02f, 2.72892173e-02f, -1.33666724e-01f, -6.87547401e-02f,
  1.86006911e-02f, -1.93026327e-02f, 5.37001602e-02f, -4.01390158e-02f, -8.46181512e-02f, -1.00045606e-01f, 4.61099297e-02f, 1.04164533e-01f, -2.48120707e-02f, -1.87305585e-02f,
  2.29412466e-01f, 1.81238681e-01f, -1.26693487e-01f, -1.46418676e-01f, -1.44554198e-01f, -4.41900820e-01f, -3.09413642e-01f, -2.25141183e-01f, -1.38797641e-01f, 1.04242750e-01f,
  -7.75041431e-02f, 1.43352836e-01f, 1.54777512e-01f, -2.77010113e-01f, -3.30299765e-01f, -1.00039124e-01f, -3.32986534e-01f, -8.65606442e-02f, 2.74011977e-02f, 8.15565214e-02f,
  -3.13470960e-02f, -1.53754637e-01f, -1.93373725e-01f, 1.36994556e-01f, 6.04271814e-02f, 1.92058131e-01f, 1.07691959e-01f, 9.15881842e-02f, -7.55942389e-02f, -1.35622784e-01f,
  -1.22403761e-03f, 9.92414728e-02f, -3.52372602e-02f, 4.32401709e-02f, -1.13717727e-02f, 8.05576816e-02f, 4.05411460e-02f, -4.44989614e-02f, 2.55992729e-02f, 1.34406704e-02f,
  3.22860368e-02f, 3.20945345e-02f, -5.30027896e-02f, 3.17386016e-02f, 5.76082468e-02f, -1.25686219e-02f, -6.70266822e-02f, -7.97897354e-02f, 5.76143637e-02f, 2.20604893e-02f,
  -6.66073337e-02f, -7.30331102e-03f, -3.60836461e-02f, -1.56839248e-02f, -3.18379328e-02f, 1.44873932e-02f, -1.04792498e-01f, -6.88250214e-02f, 2.65234485e-02f, -4.29478697e-02f,
  1.24862846e-02f, 6.21465743e-02f, 2.61659431e-03f, 2.76679471e-02f, 3.69962230e-02f, 3.66449133e-02f, 7.15204980e-03f, -1.89482346e-02f, 7.27881193e-02f, 2.41398476e-02f,
  -8.79786257e-03f, 6.33804779e-03f, -1.10668875e-02f, -1.02681555e-02f, -3.70542631e-02f, 4.77486663e-02f, 3.74791026e-03f, 4.06952091e-02f, -6.45120665e-02f, -8.31204131e-02f,
  9.21793059e-02f, 6.14841618e-02f, 6.51081419e-03f, 9.60957780e-02f, 4.30781767e-02f, -9.38806981e-02f, -1.04783680e-02f, -4.66141999e-02f, -5.11339754e-02f, -8.52160305e-02f,
  1.00066215e-01f, 1.98353201e-01f, -1.37723371e-01f, -1.11268209e-02f, -6.60222163e-03f, -3.69393751e-02f, -6.68156147e-02f, -6.48219064e-02f, 9.82125625e-02f, 1.53863551e-02f,
  -8.20435397e-03f, -8.92144348e-03f, 2.64408253e-02f, 8.60831663e-02f, -1.41545674e-02f, -7.89636299e-02f, 1.03360869e-01f, 4.78922836e-02f, -6.53074831e-02f, 4.26361598e-02f,
  3.60775962e-02f, 9.34471115e-02f, -7.40901902e-02f, 1.76450592e-02f, 1.89947970e-02f, 3.24132442e-02f, 6.08577281e-02f, -3.82599421e-02f, 7.13221580e-02f, 2.15362143e-02f,
  -4.54668775e-02f, 4.23570871e-01f, -2.41769671e-01f, 5.98315187e-02f, -3.17346938e-02f, 3.39357942e-01f, 1.96526110e-01f, 1.02204092e-01f, 1.42278969e-01f, 4.34012562e-01f,
  2.75889505e-02f, 2.91814860e-02f, 5.14475964e-02f, 3.70032758e-01f, -4.17999983e-01f, -2.77314126e-03f, 3.13355178e-01f, 1.45622954e-01f, -5.43450974e-02f, 9.10700038e-02f,
  -1.16536401e-01f, 1.54689878e-01f, -2.22111598e-01f, 1.41512901e-01f, 7.84693211e-02f, 6.74241930e-02f, -1.60624579e-01f, -1.85846016e-01f, 1.70457140e-01f, -9.96710733e-02f,
  1.10689120e-03f, 2.50059720e-02f, -2.56722141e-02f, -2.52078827e-02f, 4.55852151e-02f, 3.39602083e-02f, -9.03207529e-03f, -1.06582716e-01f, -1.92135707e-01f, -3.83388996e-02f,
  -2.83233984e-03f, -1.29904021e-02f, 3.79647575e-02f, 1.62200851e-03f, 1.38216257e-01f, -2.31141951e-02f, -3.59256454e-02f, -3.81758884e-02f, 3.61361727e-02f, -4.49304022e-02f,
  -3.61165032e-02f, 3.43974084e-02f, 9.04921535e-03f, 8.64936933e-02f, -8.73377994e-02f, 2.61711329e-02f, 9.57870670e-03f, -4.87697236e-02f, 1.01282336e-01f, 1.08654395e-01f,
  8.96246359e-02f, -2.04215036e-03f, -6.84937509e-03f, -3.76597531e-02f, -3.13039646e-02f, -2.67345756e-02f, 4.31454331e-02f, -2.60505155e-02f, -9.89357010e-02f, 1.07166864e-01f,
  -1.06204554e-01f, 1.86123177e-02f, 1.99292134e-03f, 4.83264886e-02f, 5.22055803e-03f, 5.06147295e-02f, -1.60222515e-01f, -3.59105617e-02f, -5.94851859e-02f, -8.51131380e-02f,
  -1.56641789e-02f, 1.18786120e-03f, 8.63251183e-03f, -2.43482320e-03f, 4.63406444e-02f, -9.53243524e-02f, -1.17547819e-02f, 1.64128486e-02f, -8.29349980e-02f, -5.75069040e-02f,
  2.11470455e-01f, 3.17627877e-01f, -4.51577734e-03f, -3.12956795e-02f, -3.09802741e-02f, 3.40573303e-02f, -8.43595900e-03f, 8.45357180e-02f, 4.66245674e-02f, 5.22587858e-02f,
  3.62105332e-02f, -4.83837025e-03f, 1.42592881e-02f, -3.65383830e-03f, -4.70039919e-02f, 6.02319203e-02f, -3.62965837e-02f, -3.84155661e-02f, -8.99511650e-02f, 1.54122040e-01f,
  5.12491390e-02f, -2.49347445e-02f, 3.58887739e-03f, 4.99730110e-02f, 8.37682337e-02f, 4.52367812e-02f, 6.24409541e-02f, 5.02298586e-02f, -2.30480768e-02f, 1.11244284e-01f,
  -2.63487846e-01f, 2.33994067e-01f, 7.22486898e-03f, -2.07201391e-02f, -1.01523027e-01f, -2.73480237e-01f, -1.67696819e-01f, 1.42038122e-01f, 2.86529869e-01f, 1.73580691e-01f,
  -1.07669204e-01f, -1.10463038e-01f, 1.20785251e-01f, -2.04784900e-01f, -3.39786947e-01f, 1.82588398e-01f, -2.01105550e-01f, -7.72007704e-02f, 1.75129101e-01f, -6.84462115e-02f,
  -1.61193088e-02f, -1.75213978e-01f, -2.42822513e-01f, 1.36901379e-01f, -1.90709367e-01f, 2.67444760e-01f, -5.56160696e-02f, 1.05579227e-01f, -2.23242223e-01f, -1.10978574e-01f,
  -1.23932086e-01f, 1.39788762e-01f, 4.15458046e-02f, -1.77686997e-02f, -2.71441229e-02f, -1.05741031e-01f, -5.99639565e-02f, -2.50088908e-02f, -2.43372563e-03f, 7.01326237e-04f,
  -1.28835812e-02f, -2.96775550e-02f, 1.69502497e-02f, 1.78734306e-02f, 2.69391779e-02f, -1.27726747e-03f, 6.93047941e-02f, -5.33764660e-02f, 3.13388668e-02f, -9.22040418e-02f,
  -3.52014154e-02f, -7.30687752e-02f, -7.29246959e-02f, 4.62164916e-02f, 1.65653862e-02f, 2.50228141e-02f, 5.20803928e-02f, -4.20931131e-02f, 8.91191233e-03f, 8.19894373e-02f,
  1.15991235e-02f, 5.45627512e-02f, -1.86115857e-02f, -6.33073226e-02f, 9.04014111e-02f, -2.87983380e-02f, 2.16303747e-02f, -5.92840835e-02f, 4.01356742e-02f, -8.68281350e-02f,
  4.91739661e-02f, -4.12070937e-02f, 7.48445839e-02f, 5.66144381e-03f, -6.52617961e-02f, -1.29800839e-02f, -7.27862418e-02f, 1.97356455e-02f, 2.24369373e-02f, -3.59520316e-02f,
  1.64730512e-02f, -4.31425720e-02f, 1.16713000e-02f, -3.47709958e-03f, -2.75224615e-02f, 2.08577141e-02f, -4.14229836e-03f, -3.48961726e-02f, 3.27501558e-02f, -7.39368126e-02f,
  7.55324885e-02f, 1.35613233e-01f, 8.55592787e-02f, 3.60669084e-02f, 4.41866741e-02f, 4.79068719e-02f, -4.10845093e-02f, 2.72018537e-02f, 1.17988558e-02f, 2.18417458e-02f,
  -6.22901283e-02f, -2.33837385e-02f, 1.74172204e-02f, -6.39702678e-02f, -3.00495513e-02f, -1.06324563e-02f, -7.64679238e-02f, 7.18851909e-02f, -8.47344622e-02f, -3.52899544e-02f,
  -7.52697175e-04f, -3.13565433e-02f, 3.88758741e-02f, 5.83719276e-02f, -4.30855267e-02f, -3.33157405e-02f, -5.83691746e-02f, 9.41553786e-02f, -5.28944992e-02f, 3.24589643e-03f,
  -1.48310572e-01f, -6.94290251e-02f, 1.12931216e-02f, -2.79929787e-01f, -9.99263003e-02f, 5.61877340e-02f, -1.63881630e-01f, -2.06975445e-01f, -2.05471516e-01f, -9.24359336e-02f,
  1.67055354e-01f, 1.60416305e-01f, 2.02980638e-01f, 2.64996916e-01f, 3.65453303e-01f, 2.85337090e-01f, 1.40831649e-01f, 1.77600250e-01f, 3.42724510e-02f, -2.26465151e-01f,
  -6.22574911e-02f, -1.00480184e-01f, 5.41390404e-02f, -2.73552865e-01f, -2.43937552e-01f, -3.26344669e-01f, -4.68638949e-02f, -2.02950075e-01f, -2.34302152e-02f, 1.70490742e-01f,
  9.88855138e-02f, -1.37100980e-01f, -4.21868190e-02f, 1.05884701e-01f, -5.62715381e-02f, 2.88096350e-02f, -6.05914444e-02f, 4.72660884e-02f, -6.71408791e-03f, 8.70300755e-02f,
  -2.45351736e-02f, 8.38885531e-02f, 7.31890351e-02f, 1.09649228e-03f, -7.01784864e-02f, 1.08891442e-01f, 1.23744279e-01f, 4.56932141e-03f, 2.70753745e-02f, 4.01469804e-02f,
  -2.81228926e-02f, 5.50516769e-02f, 7.98009485e-02f, 1.67708881e-02f, 5.41860349e-02f, -1.49139902e-02f, 4.50199358e-02f, 5.53437285e-02f, -2.12098099e-02f, -6.27333717e-03f,
  3.16185295e-03f, -1.66501477e-01f, -1.03244465e-02f, 8.96400586e-03f, 2.28830911e-02f, -3.81896161e-02f, -6.12614676e-02f, 1.26219541e-02f, -1.28697813e-01f, -7.53722116e-02f,
  -2.00605281e-02f, -5.58933392e-02f, -6.32239059e-02f, -6.26264736e-02f, -5.62554970e-03f, -6.04135506e-02f, 3.17102745e-02f, 2.03467980e-02f, 9.09496937e-03f, -1.03454649e-01f,
  -4.80512120e-02f, 4.02521007e-02f, 1.06891990e-01f, 6.05010912e-02f, -1.35418950e-02f, -6.73260763e-02f, -1.79026816e-02f, 9.86688398e-03f, -2.14146916e-02f, 4.47615385e-02f,
  -1.92568287e-01f, -3.24422598e-01f, -1.46522149e-01f, 4.37733047e-02f, 3.33608426e-02f, 1.13196827e-01f, -2.31079161e-02f, 1.03118420e-01f, -2.55500879e-02f, -1.45016517e-02f,
  3.49044837e-02f, -6.67777658e-02f, -8.20966959e-02f, -1.79443359e-02f, -1.65375229e-02f, 7.11326823e-02f, -1.13417543e-01f, -2.94885729e-02f, -7.38844872e-02f, -8.10460895e-02f,
  -5.79749011e-02f, -3.96617465e-02f, 1.86031908e-02f, -6.00799061e-02f, 1.57190918e-03f, -3.01250033e-02f, -9.34150293e-02f, -6.26434237e-02f, 5.08426316e-02f, 4.00965773e-02f,
  2.94817060e-01f, -4.66744155e-01f, -1.62980825e-01f, 1.88035473e-01f, 2.11521164e-02f, 1.65541694e-01f, 2.84688443e-01f, -2.18565449e-01f, 2.06104308e-01f, -7.21823499e-02f,
  7.21345395e-02f, -7.51003101e-02f, 3.20755243e-02f, 1.57881007e-02f, 3.03435653e-01f, 1.59255654e-01f, 7.45712221e-02f, 4.70582694e-02f, 1.62020460e-01f, -1.69423297e-01f,
  2.94591468e-02f, 1.87162399e-01f, -1.88595399e-01f, -1.88401684e-01f, 2.04545353e-02f, -1.68241769e-01f, -4.62176092e-02f, 4.11588997e-02f, -2.01358780e-01f, 4.04383987e-02f,
  6.49406239e-02f, -5.65533377e-02f, 4.52899486e-02f, 2.47628335e-03f, -6.75634816e-02f, 1.34997126e-02f, 5.02977408e-02f, 1.28390923e-01f, 9.36372578e-02f, -3.93126123e-02f,
  1.23710912e-02f, 3.73647694e-04f, 7.36960396e-02f, 1.75147895e-02f, -7.05188587e-02f, -4.54479046e-02f, -9.83184874e-02f, -5.78697771e-02f, -7.62118325e-02f, -1.11858845e-01f,
  5.77283613e-02f, -9.02495533e-02f, -3.29996236e-02f, 5.79330847e-02f, -5.62055819e-02f, 2.27040425e-02f, 7.48938471e-02f, -2.30694134e-02f, -4.84123528e-02f, 3.67088802e-02f,
  -2.77713761e-02f, 4.06383052e-02f, 4.91719693e-02f, -1.07938558e-01f, 4.47180495e-02f, -8.09033141e-02f, 4.05821092e-02f, 6.38883375e-03f, 5.79822659e-02f, -6.06033355e-02f,
  -2.01661065e-02f, -3.92860584e-02f, -2.99659148e-02f, 2.90071946e-02f, 1.13260923e-02f, 5.68618812e-02f, -1.19353617e-02f, 1.55926030e-02f, -3.04198880e-02f, -4.44110893e-02f,
  1.94411129e-02f, 4.04701941e-02f, 4.68086861e-02f, 3.70774120e-02f, 5.49672395e-02f, 4.65578772e-02f, -7.41352737e-02f, -5.50802387e-02f, -4.43616956e-02f, 4.20303345e-02f,
  -1.69283509e-01f, -2.43575573e-01f, -2.27723997e-02f, 2.40202080e-02f, 4.79326583e-02f, -8.03435892e-02f, 2.62602828e-02f, -9.35217515e-02f, 5.86965168e-03f, 7.59366304e-02f,
  -1.05027758e-01f, 8.88197646e-02f, -3.24342586e-02f, 6.88552484e-02f, 1.08982600e-01f, -4.84316703e-03f, 3.09050214e-02f, 9.85854715e-02f, 3.36013883e-02f, -3.71479951e-02f,
  -1.20995231e-01f, 9.96337235e-02f, 8.97064731e-02f, 1.69095024e-02f, 1.78184342e-02f, 7.75546730e-02f, -1.01004720e-01f, -3.32894921e-02f, 3.73595767e-03f, 2.74908226e-02f,
  4.01407063e-01f, 1.27659708e-01f, 1.53165564e-01f, 3.51342797e-01f, 2.62864083e-01f, -4.59619731e-01f, -2.55362630e-01f, 1.64732933e-01f, 1.31137535e-01f, -1.55172884e-01f,
  -1.68001726e-01f, 2.44109228e-01f, -4.06073987e-01f, 1.97660595e-01f, -2.74283051e-01f, -3.84836346e-01f, 1.41373202e-01f, 1.32291362e-01f, 2.88792457e-02f, 2.62338161e-01f,
  2.35782877e-01f, -1.18474990e-01f, 1.09197289e-01f, 9.62902308e-02f, 1.43941283e-01f, 2.70531744e-01f, -1.68330912e-02f, -9.39773321e-02f, -1.62309725e-02f, -7.30818063e-02f,
  -6.20012470e-02f, 1.84907794e-01f, 1.05612092e-01f, -3.17227691e-02f, -4.69838828e-02f, 3.22655328e-02f, -6.73209801e-02f, -9.61686671e-02f, -3.80030982e-02f, -8.21516737e-02f,
  -2.52602939e-02f, 2.67095957e-02f, 7.42778331e-02f, -6.77004755e-02f, 9.00374576e-02f, 6.20080680e-02f, 2.97783483e-02f, -2.41029318e-02f, 1.05239786e-01f, -1.66657306e-02f,
  1.89858712e-02f, -7.12812319e-02f, 7.30247870e-02f, -4.64483686e-02f, 1.72199905e-02f, 7.85244852e-02f, 3.66129093e-02f, -3.74923386e-02f, -3.01852338e-02f, 1.14629842e-01f,
  -2.14313939e-02f, -4.73479815e-02f, -5.38436472e-02f, -1.35748019e-03f, -9.09900591e-02f, 4.75806110e-02f, -5.06361537e-02f, -3.09227891e-02f, 1.18972384e-04f, -1.77798849e-02f,
  3.13554448e-03f, 8.81617442e-02f, 4.62013260e-02f, 2.59849597e-02f, 5.17703667e-02f, 5.75912036e-02f, -5.51313125e-02f, -9.18177068e-02f, 1.08964093e-01f, -1.75673999e-02f,
  4.98136040e-03f, 3.35249528e-02f, -9.00706053e-02f, 6.93540042e-03f, -4.28866930e-02f, -4.72574197e-02f, 2.36471333e-02f, 2.70354934e-02f, 1.34622129e-02f, -2.30732914e-02f,
  -1.95446044e-01f, -8.55343565e-02f, -3.87548208e-02f, -2.33825855e-02f, -7.63862487e-03f, -4.75361906e-02f, 6.38596714e-02f, 9.26480740e-02f, -2.39746906e-02f, -4.20997031e-02f,
  9.69834030e-02f, 4.90050111e-03f, -5.11887576e-03f, -3.90328132e-02f, -8.61705374e-03f, -1.27700102e-02f, -4.85363230e-02f, 4.84044291e-02f, 3.38930190e-02f, 6.51196167e-02f,
  2.08677165e-02f, -2.35340465e-02f, 5.62483035e-02f, 8.14270601e-02f, 3.95274647e-02f, 1.90766677e-02f, 2.20931619e-02f, 1.00653537e-01f, -4.13442701e-02f, -1.76687725e-02f,
  1.51366815e-01f, 2.09791586e-02f, 3.96943450e-01f, 9.45303366e-02f, -1.42979220e-01f, 3.36630613e-01f, 2.79488295e-01f, -2.61134189e-02f, 1.92548096e-01f, -3.26746672e-01f,
  -1.12426400e-01f, -2.10558008e-02f, 2.57372409e-02f, -1.82030752e-01f, 2.73616552e-01f, 2.64220893e-01f, 7.76368380e-02f, -6.71955049e-02f, 1.60606772e-01f, -1.06624424e-01f,
  1.10090494e-01f, -3.61916304e-01f, 1.95317760e-01f, -1.37649268e-01f, -2.12845020e-02f, 9.53590348e-02f, -3.83823305e-01f, 4.98328544e-02f, -2.63578117e-01f, -1.20729610e-01f,
  1.30883589e-01f, -4.33214828e-02f, -1.28126834e-02f, 2.72128228e-02f, 5.61069772e-02f, -1.16498675e-02f, 2.22752034e-03f, -1.40124392e-02f, 6.94391280e-02f, 2.56656222e-02f,
  -9.44334790e-02f, -9.43515748e-02f, -3.58403362e-02f, -8.37944075e-02f, 3.55416723e-02f, 2.69727539e-02f, -7.81906862e-03f, 7.48762190e-02f, -2.31716335e-02f, 6.70979545e-02f,
  1.32344559e-01f, 6.22955933e-02f, 4.36243676e-02f, -6.06783219e-02f, 6.73758611e-02f, -5.62140997e-03f, 9.54497159e-02f, 1.45467771e-02f, 6.53571934e-02f, 3.07735186e-02f,
  -4.71268147e-02f, 7.02060163e-02f, 2.40146331e-02f, -1.60610955e-02f, 4.36436236e-02f, -3.01630981e-02f, -5.15017137e-02f, -9.61619616e-02f, 1.13251964e-02f, 4.73224645e-04f,
  -5.75677566e-02f, -3.54146492e-03f, -9.36521143e-02f, 4.45585549e-02f, -7.45258108e-02f, -2.38407869e-02f, 5.62532805e-02f, -4.27704342e-02f, 9.80031714e-02f, 2.18605772e-02f,
  -2.32409313e-02f, 5.31712957e-02f, 3.67648862e-02f, -1.34167681e-02f, 6.24289885e-02f, -3.08696385e-02f, -8.62892792e-02f, 6.42366260e-02f, 5.94782121e-02f, -2.59348974e-02f,
  -7.72143379e-02f, -1.16576701e-01f, 1.66158043e-02f, -2.31800005e-02f, 7.39797205e-03f, -8.37465748e-02f, 3.30051705e-02f, -3.39266062e-02f, 5.51448055e-02f, -5.00895642e-02f,
  -3.39055471e-02f, 4.11849469e-02f, -1.17475903e-02f, 1.83508825e-03f, 9.06781715e-05f, 3.78207937e-02f, 3.67777869e-02f, -6.40093833e-02f, -5.42029329e-02f, -8.58702287e-02f,
  -9.79437381e-02f, -2.58414559e-02f, -4.53043804e-02f, -3.89911309e-02f, -7.36971274e-02f, -2.13919356e-02f, -3.22494507e-02f, 6.22704253e-02f, -5.42928688e-02f, -1.80962030e-02f,
  -5.62089421e-02f, 2.34150663e-01f, 9.13449526e-02f, 1.57381713e-01f, 9.64467376e-02f, -3.36597741e-01f, -7.13442639e-02f, 2.18479156e-01f, 5.18126845e-01f, 7.24974498e-02f,
  2.23359019e-02f, -1.41129121e-01f, 8.60111564e-02f, 8.07987154e-02f, -4.36944395e-01f, 3.05279866e-02f, -6.86137751e-02f, -7.49361888e-02f, 2.82507926e-01f, -1.82681277e-01f,
  1.98126342e-02f, -1.55724764e-01f, -2.12702602e-01f, 3.05050681e-03f, 3.36526036e-02f, 1.29191741e-01f, -2.43910968e-01f, -1.36224311e-02f, -3.21178854e-01f, -1.18991517e-01f,
  -2.22392916e-03f, 2.31053278e-01f, -3.65826720e-03f, -3.06409467e-02f, 5.15559688e-02f, 3.27987783e-02f, -1.22060202e-01f, -1.49241090e-01f, -1.05067324e-02f, 2.62625441e-02f,
  -4.92962934e-02f, -1.38080984e-01f, 8.04264620e-02f, -2.17595380e-02f, 1.08314611e-01f, 7.05595389e-02f, 1.49025898e-02f, 1.15673326e-01f, 9.43503343e-03f, -7.09386617e-02f,
  2.71187294e-02f, 9.32108983e-02f, 2.32949425e-02f, 5.04906662e-02f, -1.19940333e-01f, 9.35648307e-02f, -9.85732302e-03f, -1.36806831e-01f, 9.24686901e-03f, 1.78882685e-02f,
  -3.71766202e-02f, 6.97009712e-02f, 4.82743606e-03f, 1.78979382e-01f, -2.62910016e-02f, 8.11398476e-02f, -2.73712445e-02f, -3.80305909e-02f, 4.28636605e-03f, -1.50672030e-02f,
  6.69103190e-02f, 6.16979674e-02f, 1.39517292e-01f, -7.38951797e-03f, 1.49739077e-02f, 1.10819735e-01f, -1.38215691e-01f, 3.70340757e-02f, 7.52605349e-02f, 4.98599224e-02f,
  8.64831507e-02f, -1.63694844e-02f, -2.53153611e-02f, 9.22766179e-02f, 4.66848835e-02f, -1.00293783e-02f, 6.41571507e-02f, 5.91779388e-02f, 8.36109370e-02f, -1.27323061e-01f,
  -3.13872434e-02f, -6.08988069e-02f, -2.15559788e-02f, -1.86760444e-02f, 2.13677976e-02f, -7.63793290e-02f, 7.56212473e-02f, -5.88365411e-03f, 7.67683331e-03f, 9.90361441e-04f,
  -1.06473535e-01f, 1.70058310e-02f, -1.06574260e-01f, -5.28015457e-02f, -3.18528786e-02f, -8.61320570e-02f, 1.36133907e-02f, 6.52457252e-02f, -4.23163325e-02f, -5.26179262e-02f,
  -1.08240701e-01f, -4.48417813e-02f, 7.29674473e-03f, 6.25452995e-02f, 1.06476739e-01f, -1.08659364e-01f, 3.58163230e-02f, 1.09577971e-02f, -3.00173033e-02f, 4.75921966e-02f,
  -4.12465125e-01f, 3.91719550e-01f, -2.93225914e-01f, -1.93169057e-01f, -7.20381960e-02f, -1.69455349e-01f, -2.92155385e-01f, -7.24265911e-03f, -1.71097562e-01f, 1.98882073e-01f,
  -2.30323356e-02f, 3.35582830e-02f, 5.30396886e-02f, 1.81120098e-01f, -3.07889342e-01f, 1.44337788e-01f, -1.00378335e-01f, 8.62872601e-03f, 1.48590803e-01f, -9.15815085e-02f,
  -1.12390928e-01f, 1.77395687e-01f, -1.11012027e-01f, 1.47749722e-01f, -7.04346672e-02f, -3.06207538e-02f, -9.07246992e-02f, 1.25798853e-02f, 7.09103346e-02f, 7.38812461e-02f,
  -1.36465028e-01f, -1.91173241e-01f, -1.07235223e-01f, -6.53115883e-02f, -1.64373174e-01f, -9.28308368e-02f, -5.90612926e-02f, 2.03713086e-02f, 4.52328660e-03f, 2.63164062e-02f,
  1.08567243e-02f, 1.01735415e-02f, 1.14448965e-01f, 5.60457595e-02f, -7.63220191e-02f, -8.00511520e-03f, 4.04195897e-02f, 3.07277665e-02f, 8.23981464e-02f, 1.33707067e-02f,
  4.71049398e-02f, -1.42649701e-02f, -4.02022339e-02f, 5.61252795e-02f, -7.56483600e-02f, 1.08013876e-01f, -3.37192044e-02f, -3.08734681e-02f, -3.06660142e-02f, -6.99782968e-02f,
  -2.73916870e-02f, 4.83060814e-02f, 1.91865731e-02f, 3.97788808e-02f, -4.77507673e-02f, -1.00515801e-02f, -1.60585567e-02f, 2.44016014e-02f, -1.70853306e-02f, -2.02767421e-02f,
  -1.59825459e-02f, -3.59057337e-02f, 1.81033630e-02f, -5.55960536e-02f, 1.10726431e-02f, -3.84263285e-02f, -2.60630213e-02f, 1.91011844e-04f, 1.40323136e-02f, -3.49427797e-02f,
  5.79493754e-02f, 1.95345767e-02f, -2.70934831e-02f, 3.60181332e-02f, 4.83135432e-02f, -2.33246647e-02f, -1.60285160e-02f, -2.50394009e-02f, -5.90125890e-03f, -3.53900902e-02f,
  -9.57132876e-02f, -3.05790514e-01f, -1.41825266e-02f, -9.22560766e-02f, 5.82643300e-02f, 6.47099838e-02f, 2.08408083e-03f, 3.33740003e-02f, -3.06100640e-02f, -1.00480258e-01f,
  -5.95700592e-02f, -2.52263900e-02f, -8.57499540e-02f, 1.27481371e-02f, 8.08648579e-03f, 4.96703712e-03f, 4.45370674e-02f, -7.68238455e-02f, -1.59668192e-01f, 6.73886240e-02f,
  -7.36077502e-02f, -9.43474546e-02f, -5.75993285e-02f, -7.90630728e-02f, 2.25544721e-02f, -4.43046652e-02f, -4.01105955e-02f, 9.83863920e-02f, -2.34258361e-03f, 4.23426777e-02f,
  2.55329847e-01f, -2.51241803e-01f, -9.20131207e-02f, -2.68566936e-01f, -1.82921335e-01f, -1.11906370e-02f, -1.65907577e-01f, -3.24096531e-01f, -4.22311246e-01f, 1.76704247e-02f,
  -2.31877029e-01f, 1.06701642e-01f, -2.86354482e-01f, -3.19008142e-01f, -5.82106002e-02f, -1.39485478e-01f, -2.12904941e-02f, 7.75091276e-02f, -1.98762476e-01f, -6.00248426e-02f,
  -1.09708771e-01f, -2.33048499e-01f, -2.33944282e-01f, -8.66067410e-02f, -1.48283467e-01f, 1.04354970e-01f, 7.65604675e-02f, -1.81464374e-01f, 1.94780141e-01f, 5.93240187e-02f,
  -6.51011467e-02f, -2.37952277e-01f, 2.65369844e-02f, -2.70013809e-02f, -2.70376019e-02f, 7.92924091e-02f, 1.59392521e-01f, -1.68986637e-02f, -7.62219653e-02f, -2.91662384e-02f,
  1.04695275e-01f, 6.04519900e-03f, -7.65382722e-02f, 4.53463122e-02f, 6.52480647e-02f, 3.71065326e-02f, -2.75435727e-02f, 6.25010729e-02f, -5.93809821e-02f, 3.83786075e-02f,
  -2.09613354e-03f, 4.64767590e-03f, -4.13701013e-02f, 6.45970181e-02f, 4.06829603e-02f, 3.56173376e-03f, 8.21183100e-02f, 9.49323550e-02f, 1.55138582e-01f, 5.36700487e-02f,
  9.56631675e-02f, 2.96453610e-02f, 3.62977125e-02f, -6.30995780e-02f, -3.09386738e-02f, -7.65866339e-02f, 1.05696864e-01f, -6.85581043e-02f, -5.85036464e-02f, -2.78279223e-02f,
  -4.33783084e-02f, 5.40150404e-02f, -4.80996594e-02f, 6.33093789e-02f, -3.80829759e-02f, 1.52461091e-03f, 1.06252143e-02f, -4.29305322e-02f, 5.24219386e-02f, -1.38411568e-02f,
  -3.55907381e-02f, 4.82812561e-02f, -4.69945446e-02f, 4.93185073e-02f, 3.72722521e-02f, 6.93464428e-02f, 1.82637889e-02f, 6.88240072e-03f, -2.30948199e-02f, 1.43736526e-01f,
  -3.97296287e-02f, 3.90700400e-02f, -1.60748199e-01f, 3.57420221e-02f, 1.76960614e-03f, 8.70845094e-02f, -9.48438644e-02f, -4.84825261e-02f, -1.03642354e-02f, -6.24726973e-02f,
  7.45404139e-02f, -3.03434916e-02f, 7.37455562e-02f, -4.08572182e-02f, 1.08788989e-01f, -2.26805862e-02f, 1.29021734e-01f, 1.21042140e-01f, 3.34662236e-02f, 5.44223338e-02f,
  1.55068556e-04f, 9.45658684e-02f, 1.51504595e-02f, 1.42621538e-02f, 8.97074789e-02f, -3.72979827e-02f, 4.77494337e-02f, 6.99858414e-03f, 1.62648588e-01f, 6.64964467e-02f,
  2.72082090e-01f, -1.10819660e-01f, 2.43790939e-01f, 2.27936998e-01f, -2.91852742e-01f, -2.11857826e-01f, -1.37294799e-01f, -2.51904041e-01f, 2.28327811e-02f, -3.69172662e-01f,
  -9.47956666e-02f, 4.83569890e-01f, -4.62512560e-02f, 8.99135247e-02f, 4.02875006e-01f, 1.63753718e-01f, 3.23744178e-01f, 1.31406784e-01f, 7.58066103e-02f, 4.33520563e-02f,
  9.34982449e-02f, -2.29203165e-01f, 4.25742827e-02f, -3.17465872e-01f, -3.16921294e-01f, -7.17753246e-02f, -5.80751412e-02f, -1.52663320e-01f, -6.68264506e-03f, 8.56842548e-02f,
  -1.31851569e-01f, -1.24726156e-02f, -3.57116833e-02f, -1.77797116e-02f, -1.47486972e-02f, -1.55457789e-02f, 3.30757844e-04f, -4.47887518e-02f, 8.07531103e-02f, 7.00167194e-02f,
  4.48959917e-02f, 5.62369674e-02f, 8.55917037e-02f, -1.50605924e-02f, -9.76734385e-02f, 8.25846642e-02f, 2.50247251e-02f, -1.05974134e-02f, -3.30228098e-02f, 1.10984549e-01f,
  3.31012048e-02f, 6.57468662e-02f, 1.43872082e-01f, 1.24507487e-01f, 1.44045964e-01f, 8.89753848e-02f, 1.18962124e-01f, 1.29568219e-01f, 3.04102078e-02f, 5.49693704e-02f,
  -4.64304574e-02f, -1.22604454e-02f, 1.10421674e-02f, -3.60547118e-02f, -6.49624243e-02f, 1.47067457e-02f, 5.79376239e-03f, 2.92895250e-02f, 9.67081562e-02f, 2.37870216e-02f,
  2.14354526e-02f, -5.90799702e-03f, -5.49555421e-02f, -7.07266480e-02f, 8.96406732e-03f, -5.49212284e-02f, 4.13147695e-02f, 3.26907262e-02f, 3.18887755e-02f, -4.60658446e-02f,
  -7.69962594e-02f, -1.70751251e-02f, 1.67838030e-03f, -1.04605526e-01f, -1.01985686e-01f, -3.18082348e-02f, -8.16309080e-02f, -5.47466092e-02f, -7.23709017e-02f, 2.05366369e-02f,
  4.04538065e-02f, 2.45197803e-01f, -4.50297073e-02f, -8.16661492e-02f, 8.63303989e-03f, -1.87449865e-02f, 8.39392021e-02f, 1.13318190e-01f, 2.39438540e-03f, -9.82348025e-02f,
  6.48816954e-03f, -5.94913922e-02f, 1.46246590e-02f, 8.58151093e-02f, 5.81204370e-02f, -2.84495912e-02f, 3.66102047e-02f, 3.07234377e-02f, 4.66599762e-02f, -1.42733799e-02f,
  -1.07242800e-01f, 1.01364208e-02f, 2.84314025e-02f, -8.71345103e-02f, -4.93821735e-03f, -9.32085700e-03f, 3.20875421e-02f, -1.65445246e-02f, 3.65001038e-02f, 6.28796369e-02f,
  5.48607826e-01f, 1.71465948e-01f, -8.18622857e-02f, 3.22898209e-01f, -5.08130714e-03f, -3.07063133e-01f, -1.15890197e-01f, 1.84434261e-02f, 4.80363607e-01f, -6.80477917e-02f,
  -1.24624752e-01f, 2.38671616e-01f, -3.45955789e-02f, -8.96873325e-02f, -1.42514497e-01f, 5.70212528e-02f, -2.18770113e-02f, 2.81558894e-02f, 1.56007022e-01f, 6.71920925e-02f,
  5.62739447e-02f, 2.84958351e-02f, -2.13445157e-01f, 2.70093232e-02f, -2.61635743e-02f, 1.22567408e-01f, -1.27225712e-01f, -1.05395243e-01f, -1.80164874e-01f, -1.47528037e-01f,
  -1.89948708e-01f, 1.87940463e-01f, -1.13465395e-02f, 6.13398626e-02f, -5.30094653e-02f, -1.19327158e-01f, -8.45365822e-02f, -7.86552355e-02f, 1.16868373e-02f, 5.83799034e-02f,
  4.12442386e-02f, 8.18719566e-02f, 9.43999141e-02f, 9.66130123e-02f, 1.45113096e-01f, 1.09200580e-02f, -4.18158546e-02f, -2.34971140e-02f, -4.35052477e-02f, -2.55264957e-02f,
  1.85233802e-02f, -6.12643845e-02f, -4.34232093e-02f, 8.42841715e-02f, -4.92865779e-02f, 7.61248469e-02f, -6.02559224e-02f, -3.77186462e-02f, 7.65730254e-03f, 7.96424970e-02f,
  8.68287981e-02f, 9.65854451e-02f, 7.21676946e-02f, 2.05654353e-02f, 5.04491106e-02f, -3.49636711e-02f, -2.38018489e-04f, -6.18875287e-02f, -2.68858857e-02f, -4.83856071e-03f,
  -1.82086229e-02f, 3.79859880e-02f, -5.61553016e-02f, 5.60367964e-02f, 2.15124097e-02f, 4.59413193e-02f, -6.17049746e-02f, 5.05675301e-02f, 4.71615642e-02f, -2.28900947e-02f,
  1.56242372e-02f, 5.51709421e-02f, -5.72384298e-02f, -1.00935116e-01f, -4.53029126e-02f, 7.25355968e-02f, 3.48113365e-02f, -2.84362882e-02f, 1.55629348e-02f, -6.30570352e-02f,
  -1.71496477e-02f, 2.21483618e-01f, -3.86856459e-02f, -6.48103803e-02f, -4.66569662e-02f, 2.02012565e-02f, 5.52383251e-02f, 3.16122137e-02f, 7.89580122e-02f, -3.54768932e-02f,
  -4.35100216e-03f, -2.71622930e-02f, 1.41608305e-02f, -3.68415639e-02f, -3.10350489e-02f, -2.07477324e-02f, 3.40923741e-02f, 2.74898373e-02f, 1.96383316e-02f, 9.61497799e-03f,
  3.76753584e-02f, 5.19691333e-02f, -1.58106182e-02f, -4.94845994e-02f, 2.64234692e-02f, -2.88706105e-02f, 8.84355530e-02f, 7.14041963e-02f, -1.49550093e-02f, 6.96262792e-02f,
  1.81412324e-01f, 1.05080068e-01f, 8.88046920e-02f, 4.23052192e-01f, -1.02658778e-01f, -3.43229547e-02f, 2.41587728e-01f, 4.46320996e-02f, 2.57489502e-01f, 1.69982061e-01f,
  -1.27079925e-02f, -5.35501353e-02f, -2.48401135e-01f, 2.67498523e-01f, -4.11185890e-01f, -2.02214018e-01f, 3.86117637e-01f, 9.65925083e-02f, -1.36687225e-02f, 1.68984711e-01f,
  1.08497813e-01f, 6.86002374e-02f, -1.10609062e-01f, -1.06335245e-01f, 2.03520760e-01f, 1.43687114e-01f, 2.63656601e-02f, -1.27336636e-01f, 1.60897374e-01f, -2.08272174e-01f,
  7.37461448e-03f, 3.63337621e-02f, -4.88229422e-03f, -3.28257680e-02f, 9.09724757e-02f, 5.52889630e-02f, 7.09873140e-02f, -1.33993551e-01f, 4.14005592e-02f, 7.27130398e-02f,
  7.22756684e-02f, -5.73574714e-02f, 6.98821917e-02f, -7.23355711e-02f, 1.40610814e-01f, 6.55553117e-02f, -6.62558377e-02f, 1.87413413e-02f, 2.09895894e-02f, -1.28636226e-01f,
  -5.12120165e-02f, -2.67204531e-02f, 5.50329760e-02f, 5.01154289e-02f, 1.48036117e-02f, -4.01745215e-02f, 4.14554588e-02f, -4.01558578e-02f, 6.89919665e-02f, -1.22098969e-02f,
  2.09274087e-02f, -4.93397098e-03f, 2.33607907e-02f, -5.07244878e-02f, -5.73060624e-02f, 3.84577513e-02f, 4.57293913e-02f, -1.21209092e-01f, 4.87725772e-02f, -1.47326998e-02f,
  1.10293344e-01f, 1.43813659e-02f, 2.35162135e-02f, -2.36148015e-04f, 9.13071632e-02f, 8.17077085e-02f, -3.84105183e-02f, -2.21743695e-02f, 5.33568524e-02f, 3.50955129e-02f,
  -5.71614094e-02f, -4.87645417e-02f, 2.34925169e-02f, 9.45105776e-02f, -1.24659725e-02f, -1.04077630e-01f, 4.40125540e-02f, -2.89015453e-02f, 9.47953686e-02f, 9.90794878e-03f,
  6.67203069e-02f, 1.20940683e-02f, -1.76209360e-02f, -1.63041484e-02f, -7.39860758e-02f, -8.72451160e-03f, 4.27997038e-02f, 7.60925263e-02f, 1.11642210e-02f, 7.27312192e-02f,
  9.87812728e-02f, 1.27263233e-01f, 1.05098337e-01f, -5.80562204e-02f, -8.76809135e-02f, -2.95064524e-02f, 1.18881669e-02f, 2.27130689e-02f, 5.24045452e-02f, 2.44963989e-02f,
  6.31628260e-02f, 7.82774985e-02f, -6.95613623e-02f, 4.48137298e-02f, 9.14711058e-02f, 6.43438324e-02f, -1.84235368e-02f, -4.91668954e-02f, -7.68354163e-02f, 5.46592064e-02f,
  -2.74508027e-03f, -4.80952486e-02f, -3.14798355e-01f, 1.09323170e-02f, 3.87195349e-01f, -1.19887240e-01f, 2.68903915e-02f, 3.38847518e-01f, -2.12071747e-01f, 3.67516354e-02f,
  1.23288251e-01f, -4.21641439e-01f, -2.09578071e-02f, 4.63972166e-02f, -2.94583917e-01f, -3.89613450e-01f, -2.17581853e-01f, -2.24120170e-01f, -9.87345129e-02f, 5.12243062e-02f,
  -1.08256312e-02f, 3.84325445e-01f, -1.51978396e-02f, 3.00044328e-01f, 3.33271801e-01f, 1.09410182e-01f, 3.50954264e-01f, 9.96330380e-02f, 1.57859549e-01f, -7.50557240e-03f,
  -1.10490441e-01f, -1.83024537e-02f, 4.91864607e-02f, -5.32754026e-02f, 6.71619698e-02f, 1.42461970e-01f, -7.88068846e-02f, -1.92459170e-02f, -1.38950452e-01f, -8.26188251e-02f,
  -7.45468065e-02f, -8.60246830e-03f, -2.75511667e-02f, 6.44626245e-02f, 6.86802566e-02f, -6.14868663e-02f, -5.47997802e-02f, -6.83449358e-02f, -5.42235970e-02f, -4.83595580e-02f,
  -8.66113603e-02f, -8.80611464e-02f, -1.93044599e-02f, -8.70477557e-02f, -5.98804094e-02f, -4.35999371e-02f, -1.33334091e-02f, -2.24144533e-02f, -4.32302207e-02f, 6.89252168e-02f,
  5.57763875e-02f, -8.32770672e-03f, 1.00424299e-02f, -1.50254862e-02f, -1.87274185e-03f, 3.10754012e-02f, -6.23334609e-02f, 3.85906431e-03f, -8.15570951e-02f, 6.42921403e-02f,
  -1.04678907e-02f, 4.54874672e-02f, 4.15438265e-02f, 2.32111402e-02f, 2.08158940e-02f, 2.83719506e-02f, -4.84545529e-02f, -9.49875638e-03f, 3.45299840e-02f, -1.11251790e-02f,
  2.64846422e-02f, -5.55796511e-02f, 2.28984393e-02f, 1.77616607e-02f, -4.94723544e-02f, -8.35057907e-03f, 6.88821375e-02f, -1.87579300e-02f, -2.06215167e-03f, 5.22298329e-02f,
  -7.19231963e-02f, 1.19475856e-01f, 3.61788785e-03f, -1.98429078e-02f, -8.38950351e-02f, -1.73548982e-02f, -5.25084846e-02f, -1.31662400e-03f, -3.30766626e-02f, 3.06236893e-02f,
  6.02663234e-02f, 2.39783581e-02f, -2.18928233e-02f, -2.96164174e-02f, 3.04076751e-03f, 1.27148613e-01f, 1.63071156e-02f, -2.15476248e-02f, 1.47359192e-01f, 3.36078592e-02f,
  1.30260214e-01f, 1.07994163e-02f, -1.24113252e-02f, 7.25875720e-02f, 7.63642043e-02f, 2.24407483e-02f, 5.91555573e-02f, -4.03259583e-02f, 1.66859776e-02f, -1.09714307e-01f,
  -5.07058315e-02f, -1.45142516e-02f, -1.72095791e-01f, -1.85636520e-01f, -4.01718169e-02f, -1.76913943e-02f, -9.36396196e-02f, -9.72023010e-02f, -4.13978070e-01f, 3.70344408e-02f,
  1.03374720e-01f, 1.49168164e-01f, 1.08220406e-01f, 2.37661645e-01f, 2.42996320e-01f, 1.70430064e-01f, 2.20548823e-01f, 2.30081066e-01f, 4.82707769e-02f, 2.18377158e-01f,
  2.16561511e-01f, 2.78195947e-01f, 1.23417497e-01f, 2.87476033e-01f, 3.26077282e-01f, 9.34251919e-02f, 2.38612667e-01f, 1.84308425e-01f, 1.80408373e-01f, 9.96265486e-02f,
  -1.64257754e-02f, -1.17343113e-01f, 2.47184411e-02f, -9.44881886e-02f, -2.07085796e-02f, -8.12129453e-02f, 1.20710619e-01f, 4.05329540e-02f, -2.01706961e-01f, -2.55363509e-02f,
  1.01627991e-01f, -1.37300603e-03f, -3.95799875e-02f, -3.07512619e-02f, -1.26476854e-01f, -1.03823692e-01f, -6.33007735e-02f, -7.91284442e-02f, -3.80893536e-02f, -5.18824309e-02f,
  -3.11112832e-02f, -5.58017455e-02f, -2.10672524e-02f, -7.48188049e-02f, -4.77701128e-02f, -6.75354227e-02f, -1.66983366e-01f, 9.63595808e-02f, 4.29108797e-04f, -1.18135020e-01f,
  7.79690593e-02f, 3.47206295e-02f, 5.12562431e-02f, -4.88751531e-02f, 1.14484474e-01f, -1.95323881e-02f, -7.98737910e-03f, 8.94146711e-02f, 1.89990420e-02f, 3.44367549e-02f,
  -1.96911953e-02f, -1.14239240e-02f, -6.12070188e-02f, -1.46473154e-01f, 4.32509072e-02f, -6.08114712e-02f, 1.39986873e-01f, 5.39877713e-02f, -5.11880815e-02f, 5.71308024e-02f,
  -5.22810500e-03f, 2.96601411e-02f, -1.34406080e-02f, 2.89306138e-02f, -7.74635049e-03f, -6.42371550e-02f, -5.76496460e-02f, -1.45973459e-01f, -1.37027623e-02f, 1.01707056e-01f,
  1.42694563e-01f, 2.68600911e-01f, -6.27402142e-02f, -3.18698175e-02f, 5.62146343e-02f, 5.38310260e-02f, 5.22688068e-02f, 7.85473660e-02f, 3.02059874e-02f, 7.82271847e-02f,
  -2.26005595e-02f, -5.24991527e-02f, 1.20372444e-01f, -9.63781923e-02f, 8.30550417e-02f, -1.13430984e-01f, 1.20708704e-01f, -7.50486553e-02f, 6.51526377e-02f, 3.25555764e-02f,
  6.47478970e-03f, 2.94346008e-02f, 9.70870536e-03f, 4.71330173e-02f, -3.79521959e-02f, 6.67523742e-02f, 1.81530826e-02f, -9.81233865e-02f, 1.49547145e-01f, 3.43149863e-02f,
  -1.51638925e-01f, -1.10437378e-01f, 1.95220456e-01f, 9.93967652e-02f, 2.07545206e-01f, -5.35449497e-02f, -9.01053101e-03f, -7.66094076e-03f, -1.47174358e-01f, -1.30174726e-01f,
  -1.14357844e-01f, -1.27420560e-01f, -1.29973158e-01f, -3.24011028e-01f, -2.11532712e-01f, -3.28835219e-01f, -1.36028156e-01f, -6.86841980e-02f, -1.26057953e-01f, 2.12786645e-01f,
  5.00018746e-02f, 9.52916518e-02f, 1.94771037e-01f, 2.37979531e-01f, 2.01091677e-01f, 2.29807213e-01f, 1.88245848e-01f, 1.52537808e-01f, 8.52186605e-02f, -1.74060971e-01f,
  1.70096382e-02f, -7.35673681e-02f, 6.38517216e-02f, -3.47983576e-02f, 2.38104552e-01f, -5.08328862e-02f, 1.06867157e-01f, 4.78767455e-02f, -5.89249004e-03f, 8.59294310e-02f,
  4.93764095e-02f, 4.75221546e-03f, -4.93071862e-02f, -2.66521629e-02f, 3.37909767e-03f, 4.05218452e-02f, 2.91978102e-02f, 5.85601740e-02f, -5.96453156e-03f, -6.33927807e-02f,
  -2.74061114e-02f, -6.59670830e-02f, -4.13940996e-02f, -1.32484827e-02f, 4.01265780e-03f, -3.35335210e-02f, 1.11706238e-02f, 1.19901918e-01f, -1.90247342e-01f, -8.17483524e-04f,
  -5.07598855e-02f, 2.37908252e-02f, -2.33539324e-02f, -4.44282964e-02f, 2.82534063e-02f, 7.89969694e-03f, -2.40409989e-02f, 3.65617238e-02f, 5.60461283e-02f, -1.63988897e-03f,
  4.98444736e-02f, -3.09954248e-02f, -1.74140155e-01f, -4.16432135e-02f, 9.41930935e-02f, -6.30152300e-02f, 6.08976297e-02f, -5.71972355e-02f, -3.42171337e-03f, -4.77708019e-02f,
  -7.17839897e-02f, -1.02856413e-01f, 6.92165345e-02f, 4.49653948e-03f, -8.70363191e-02f, 1.40840143e-01f, -4.08235891e-03f, -1.24002405e-01f, 1.55820688e-02f, 3.65132838e-02f,
  1.72176331e-01f, 1.86038300e-01f, 6.38660416e-02f, -9.22613367e-02f, -2.27026418e-02f, -3.88533585e-02f, -1.07799135e-01f, -1.23937890e-01f, 2.13421080e-02f, 1.10484324e-02f,
  1.75624952e-01f, 1.35319352e-01f, -4.01583537e-02f, -7.17633292e-02f, 1.30390618e-02f, -5.22291437e-02f, 1.87972095e-02f, 9.49198380e-02f, 4.87411069e-03f, 1.03910282e-01f,
  1.67936563e-01f, 1.10835128e-01f, 1.89038068e-02f, 5.31646684e-02f, 9.57565084e-02f, 7.97599647e-03f, 7.20119849e-02f, 1.69068351e-02f, -7.62541741e-02f, 1.21979425e-02f,
  -4.42116439e-01f, -2.89120972e-01f, 3.87224853e-02f, -4.83720511e-01f, 1.99617118e-01f, 1.59966975e-01f, 1.85872510e-01f, -1.71149597e-01f, -3.66700917e-01f, -3.06198113e-02f,
  1.75389990e-01f, -5.44456057e-02f, 1.57948405e-01f, -7.37455934e-02f, 7.12617263e-02f, 1.15817927e-01f, -1.88555717e-01f, -1.47923335e-01f, -8.89082253e-02f, -2.27329433e-02f,
  -7.27022886e-02f, 1.78385437e-01f, 6.04943782e-02f, 1.09673262e-01f, 3.90806282e-03f, -1.90209731e-01f, 7.71290958e-02f, 2.11196855e-01f, -6.94703609e-02f, 1.76853254e-01f,
  1.13646463e-01f, -2.39180222e-01f, -3.21229137e-02f, -2.10896172e-02f, -1.22416457e-02f, 7.24387020e-02f, 5.33816814e-02f, 1.47012398e-01f, 7.77942389e-02f, -3.34543586e-02f,
  3.23392339e-02f, 4.66740429e-02f, -2.67498083e-02f, 9.03569907e-03f, -8.64895657e-02f, -1.16350017e-01f, -1.70365736e-01f, -2.57333498e-02f, -5.71706370e-02f, -6.45420607e-03f,
  -7.21515417e-02f, -2.95627676e-02f, -7.29866177e-02f, -1.12528857e-02f, 3.37870084e-02f, -1.07999314e-02f, -3.12024374e-02f, 3.16325277e-02f, -8.34767595e-02f, -1.38147578e-01f,
  -6.05649576e-02f, 5.03408313e-02f, -2.47962158e-02f, -5.03865555e-02f, 1.50808375e-02f, 6.69263080e-02f, -1.76299233e-02f, 8.73682573e-02f, -1.07681870e-01f, 3.95757519e-02f,
  -2.67541539e-02f, -7.87755325e-02f, -1.46764824e-02f, -2.05015615e-02f, -8.46819580e-02f, -6.47991225e-02f, 2.10535079e-02f, 8.91707465e-02f, -9.70986560e-02f, -3.78185920e-02f,
  5.02969995e-02f, 3.08311451e-02f, 1.07945073e-02f, 7.03597441e-02f, -1.34301968e-02f, 6.68862015e-02f, -6.47109700e-03f, 3.14900652e-04f, 6.74999356e-02f, 1.05337009e-01f,
  8.82150158e-02f, -2.38492593e-01f, 7.71856382e-02f, -2.97542717e-02f, 1.67645365e-02f, -6.26285672e-02f, -5.28157456e-03f, -5.98371029e-02f, -7.10549206e-02f, -1.03967143e-02f,
  -3.17431428e-02f, -1.14436872e-01f, 1.02189975e-02f, 2.86895260e-02f, -8.71898700e-03f, 2.70487890e-02f, 1.17988683e-01f, 3.18763293e-02f, 5.18254340e-02f, -8.20693225e-02f,
  3.23659033e-02f, -1.59247220e-02f, 6.69464618e-02f, -4.44679260e-02f, 4.09287922e-02f, -1.91629361e-02f, -2.62110401e-02f, -2.14719083e-02f, 3.24527323e-02f, -1.41570484e-02f,
  7.97443762e-02f, -2.33853340e-01f, 2.58265704e-01f, 1.54378843e-02f, -3.73590104e-02f, -3.83820206e-01f, -2.55240090e-02f, -1.42065853e-01f, 1.96031660e-01f, -1.99705094e-01f,
  -1.53494835e-01f, 2.41626382e-01f, -1.10870237e-02f, -2.17321068e-01f, -1.02026053e-01f, 3.64167839e-02f, -3.40627074e-01f, -1.09105706e-01f, 1.33097246e-01f, -1.65341169e-01f,
  1.14783123e-02f, -3.24868888e-01f, -6.90203756e-02f, -2.16743112e-01f, -4.47894167e-03f, 9.28281248e-02f, -1.99610770e-01f, 1.07458510e-01f, -1.81575850e-01f, 8.37596878e-02f,
  -1.67681724e-01f, 8.87176991e-02f, 1.98891442e-02f, 3.28315571e-02f, -1.69488430e-01f, -3.92840151e-03f, 1.95756566e-05f, 1.51305631e-01f, 1.14926003e-01f, 1.06630437e-01f,
  9.95616466e-02f, 3.31249982e-02f, 1.75058320e-02f, 1.03052706e-01f, 6.30763620e-02f, 4.06407863e-02f, 3.30456719e-02f, -4.83458824e-02f, 9.84443799e-02f, 6.13680631e-02f,
  5.85624240e-02f, 4.37973365e-02f, -3.84401381e-02f, 1.82241257e-02f, 5.91747165e-02f, -2.62226956e-03f, 5.30712008e-02f, 4.76128571e-02f, -2.91873887e-02f, -6.91669527e-04f,
  3.50425206e-02f, -4.91572209e-02f, -4.23438661e-02f, 4.98165656e-03f, 8.17835629e-02f, -2.52240361e-03f, -1.46101331e-02f, 1.31068407e-02f, 7.91575611e-02f, -4.72122505e-02f,
  -1.22208059e-01f, 9.12251100e-02f, 4.47775088e-02f, 9.17610060e-03f, -5.19159362e-02f, 1.21315196e-02f, -2.69920938e-03f, 5.64392982e-03f, -7.77186155e-02f, 2.88743749e-02f,
  6.94296882e-02f, -1.02644861e-01f, -1.09384367e-02f, -6.89646974e-03f, 2.98106875e-02f, 5.80733716e-02f, -3.66616361e-02f, -1.00919530e-02f, 1.34292655e-02f, -4.22070436e-02f,
  -4.00932819e-01f, -3.42842191e-01f, -2.09794920e-02f, 7.80595839e-02f, -4.03212383e-02f, -6.92668632e-02f, -2.56038923e-03f, 3.12103778e-02f, -1.19757354e-01f, -5.45010576e-03f,
  -9.71453935e-02f, -2.67308410e-02f, -7.72440434e-02f, -1.50780408e-02f, -8.57966542e-02f, -3.08577940e-02f, -2.55350824e-02f, -1.30773317e-02f, -1.52707830e-01f, -9.71843079e-02f,
  -1.03682585e-01f, 1.87305050e-05f, 7.89867656e-04f, -2.82125436e-02f, 4.60782945e-02f, -1.36561524e-02f, -1.92575380e-02f, 8.62222984e-02f, -5.24124093e-02f, -1.04326673e-01f,
  3.02282065e-01f, 3.02842885e-01f, 8.65246728e-02f, -8.23120177e-02f, 1.12167045e-01f, 1.08288750e-01f, -1.93162709e-01f, 1.29647180e-01f, -2.39262041e-02f, 9.48288962e-02f,
  -1.36034578e-01f, 2.46864319e-01f, -2.18879178e-01f, -7.64473975e-02f, -2.33916387e-01f, -3.20314378e-01f, -7.77464807e-02f, 9.95683223e-02f, -7.11497813e-02f, 2.07824931e-01f,
  -8.87432992e-02f, 1.30446732e-01f, -2.29234114e-01f, 1.45462617e-01f, 2.40481004e-01f, 1.61283478e-01f, -2.20812604e-01f, 6.23893924e-02f, 2.03203604e-01f, 2.90051047e-02f,
  9.92346853e-02f, 3.92298810e-02f, -7.18328804e-02f, -7.01750368e-02f, -5.83036654e-02f, -2.33119912e-02f, -8.63842107e-03f, -2.45180521e-02f, -5.31811528e-02f, -1.30751291e-02f,
  1.59194469e-02f, 3.12651247e-02f, 3.39299813e-02f, -2.68359333e-02f, 5.37479557e-02f, -1.15508372e-02f, 2.59843445e-03f, -1.59171782e-02f, -2.80238651e-02f, 2.98018381e-02f,
  3.87815088e-02f, -5.16648889e-02f, 4.62131053e-02f, 1.99177936e-02f, -1.40999528e-02f, 2.50579300e-03f, -1.70220174e-02f, 1.06723554e-01f, 2.94079818e-02f, 4.52658013e-02f,
  -4.71765660e-02f, -2.34884117e-02f, -7.12098628e-02f, 5.70038147e-02f, -1.09609747e-02f, -4.27203439e-03f, -1.77633930e-02f, -9.93281826e-02f, -5.90063771e-03f, 1.00408383e-01f,
  -1.44133931e-02f, 5.25709800e-02f, -4.43696678e-02f, -6.16709106e-02f, -1.62773989e-02f, -3.79265309e-03f, -4.94916476e-02f, 1.38536796e-01f, -1.51774501e-02f, -5.18640317e-02f,
  6.03283048e-02f, 2.00471170e-02f, 1.47763252e-01f, -7.87397176e-02f, -3.18790004e-02f, 2.07866486e-02f, 4.74788323e-02f, 4.90564592e-02f, -8.26472789e-02f, -4.31445166e-02f,
  2.92895764e-01f, 2.91524410e-01f, 6.25454709e-02f, 1.33846765e-02f, 9.06337798e-03f, -4.39030044e-02f, -2.85177957e-02f, -3.37405317e-02f, 1.19751699e-01f, -2.01794244e-02f,
  -6.33680746e-02f, 3.08397952e-02f, 4.43617851e-02f, 5.27357403e-03f, -2.93595120e-02f, 2.68363338e-02f, -2.29811780e-02f, 3.05761565e-02f, -1.77897175e-03f, 7.72315934e-02f,
  4.35605180e-03f, 1.87626667e-02f, -6.18617721e-02f, 2.88210195e-02f, 4.20707986e-02f, -3.07896584e-02f, 1.54426172e-01f, -3.68826389e-02f, 1.46948397e-02f, -2.84029134e-02f,
  6.57990396e-01f, -4.84559327e-01f, 1.49450555e-01f, 1.70189440e-01f, -3.70861664e-02f, 2.27506161e-01f, 7.26553425e-02f, -1.02559693e-01f, 3.40172112e-01f, -4.30779874e-01f,
  -3.18373561e-01f, 2.08259583e-01f, -3.80712867e-01f, -1.53607547e-01f, 3.35502267e-01f, -1.79128617e-01f, 2.02513769e-01f, 5.14949672e-02f, 4.70539667e-02f, -6.66409805e-02f,
  6.33320436e-02f, -2.87664413e-01f, -1.17677145e-01f, -1.69887692e-01f, -5.19778170e-02f, 1.94820046e-01f, -2.41783321e-01f, -2.69666612e-02f, -1.41327813e-01f, -6.82309270e-02f,
  6.39398620e-02f, -1.26983255e-01f, -6.97046667e-02f, 4.44574878e-02f, -2.13427078e-02f, -9.78657454e-02f, 2.72998884e-02f, 4.83973362e-02f, 9.25516784e-02f, -2.78540943e-02f,
  5.97325042e-02f, 4.73183990e-02f, 6.15947656e-02f, 3.90986316e-02f, -2.73212232e-02f, -4.08477988e-03f, 3.84730287e-02f, 8.63770582e-03f, -1.88662857e-02f, 2.26221588e-02f,
  -4.18132544e-02f, 6.78797904e-03f, 1.17252367e-02f, -1.86448998e-03f, 6.22255392e-02f, 6.81867376e-02f, 2.13797502e-02f, 1.71861779e-02f, 4.66406532e-02f, 5.32654412e-02f,
  -9.79113057e-02f, 7.28449505e-03f, -5.20363562e-02f, -8.94852802e-02f, 2.33912040e-02f, -5.89615814e-02f, -1.89502463e-02f, -5.03550544e-02f, 1.18408583e-01f, -4.49638851e-02f,
  3.17959897e-02f, 9.17699654e-03f, -1.23699661e-02f, -1.05467029e-02f, -2.16434319e-02f, -9.11828037e-03f, 7.14746639e-02f, 8.62451736e-03f, 2.76574362e-02f, -1.67322792e-02f,
  -3.07175480e-02f, 4.83177230e-02f, -2.30180267e-02f, 3.58568914e-02f, -1.65121648e-02f, 1.78430639e-02f, -4.93413024e-02f, 2.82354876e-02f, -8.57059471e-03f, 2.08553690e-02f,
  -1.93699509e-01f, -1.57797694e-01f, 2.35006474e-02f, -8.25552829e-03f, 3.12799290e-02f, -2.75475923e-02f, 1.64697301e-02f, 2.74464060e-02f, -6.46886081e-02f, -1.89765655e-02f,
  8.26975331e-03f, -5.77202626e-02f, -8.78119655e-03f, 9.32191834e-02f, -2.26181699e-04f, -1.11646272e-01f, 6.92937663e-03f, -1.31429890e-02f, -3.03504094e-02f, -5.16479127e-02f,
  -3.07895970e-02f, 6.66669309e-02f, 2.07685083e-02f, -2.87043455e-04f, 4.49576005e-02f, -8.94788653e-02f, 3.11725456e-02f, 3.24129798e-02f, -4.55189608e-02f, 3.06802918e-03f,
  6.63171113e-02f, 1.09101273e-01f, 1.99098304e-01f, -5.53835370e-02f, -2.42722541e-01f, -3.17301750e-01f, -2.30854139e-01f, -2.15176210e-01f, -3.12104881e-01f, -1.61258593e-01f,
  -3.13612550e-01f, 2.16531277e-01f, 4.24871854e-02f, -3.20868760e-01f, 1.56333774e-01f, -4.85495552e-02f, -1.35824129e-01f, -3.01009435e-02f, -5.26999831e-02f, 6.44259304e-02f,
  -7.73499832e-02f, -2.95002997e-01f, 1.69101462e-01f, -1.13334827e-01f, -6.64436817e-02f, 4.03750986e-02f, 1.31060988e-01f, 9.69703197e-02f, -1.71164349e-02f, -9.97823998e-02f,
  -1.50664449e-01f, -1.10823743e-01f, -8.52608029e-03f, 9.39837173e-02f, 6.18692897e-02f, 1.09447926e-01f, 1.32888334e-03f, 7.36665502e-02f, 2.97171958e-02f, -7.15806410e-02f,
  4.54220772e-02f, 2.08160970e-02f, -5.37783019e-02f, -7.46975541e-02f, -8.49618167e-02f, -6.27590865e-02f, 2.81750634e-02f, -4.31789756e-02f, -3.65321487e-02f, 1.03973314e-01f,
  1.54400198e-02f, 3.05565204e-02f, -9.64382887e-02f, -6.61979839e-02f, 6.56795735e-03f, -1.67760357e-01f, -8.03789347e-02f, 3.28947678e-02f, -3.57609242e-02f, -4.34770882e-02f,
  -3.08888201e-02f, 7.07378164e-02f, -1.28189214e-02f, -1.45944888e-02f, 9.44178365e-03f, -1.25313029e-01f, -2.61670612e-02f, 2.44250591e-03f, -1.31251849e-02f, -5.42181730e-02f,
  -1.47023171e-01f, -1.30202633e-03f, -6.11437075e-02f, 2.26351637e-02f, -5.65041881e-03f, -1.04574718e-01f, 9.13232267e-02f, -7.74178561e-03f, 2.07976215e-02f, -1.42709408e-02f,
  -2.02402892e-03f, 1.10044619e-02f, 6.68609329e-03f, 3.03096399e-02f, -1.02961555e-01f, 6.88617378e-02f, 9.64424163e-02f, -1.74415726e-02f, -4.35695238e-02f, 8.44052508e-02f,
  -6.20816574e-02f, 2.47496843e-01f, -1.04933463e-01f, -5.57066798e-02f, 5.91203086e-02f, 3.08627449e-02f, 2.71897707e-02f, -5.59407333e-03f, -5.21532213e-03f, -3.52996700e-02f,
  5.40999845e-02f, -2.68180761e-02f, 4.80083823e-02f, 1.56768337e-02f, -8.60483479e-03f, -4.10099886e-02f, 7.32282922e-02f, -5.93043771e-03f, 1.95597485e-02f, 6.50148094e-03f,
  9.19483230e-02f, -4.01163287e-02f, 1.21379942e-01f, -7.83193037e-02f, -3.57577987e-02f, 1.24762300e-02f, -5.83286211e-02f, 7.32789654e-03f, 7.43748024e-02f, 3.43782678e-02f,
  2.49767557e-01f, -3.54913473e-02f, 1.75549269e-01f, 1.08693607e-01f, 6.20989278e-02f, -3.50366533e-01f, -1.00698462e-02f, -9.17347893e-02f, 3.18842113e-01f, -3.46333653e-01f,
  -2.30805948e-01f, 4.45788980e-01f, -7.68115511e-03f, -2.97870338e-01f, 3.49953443e-01f, -8.27007666e-02f, -2.54799426e-01f, -4.40185964e-02f, 1.99028358e-01f, -6.36830786e-03f,
  5.62093444e-02f, -1.75111875e-01f, -8.95498171e-02f, -8.62711743e-02f, -2.36862570e-01f, 6.85539469e-02f, -2.69455940e-01f, 1.28934830e-01f, -2.57125020e-01f, 5.40980436e-02f,
  -8.43547359e-02f, 9.15051028e-02f, -4.47678529e-02f, 4.11770120e-02f, -8.37819502e-02f, -9.13893431e-02f, 2.19398681e-02f, 9.80558768e-02f, 5.31977974e-02f, 5.23189865e-02f,
  5.35028577e-02f, 4.66667041e-02f, 7.26253241e-02f, -1.96757750e-03f, -2.06400715e-02f, -1.36539238e-02f, 6.01486303e-02f, -9.56561565e-02f, 2.04852074e-01f, -4.89444919e-02f,
  -4.10041064e-02f, -8.56820941e-02f, -1.05472498e-01f, -5.01434356e-02f, 1.23377293e-01f, -3.94595833e-03f, 4.78446260e-02f, 1.97777543e-02f, -1.55904191e-02f, 3.05160955e-02f,
  6.17576428e-02f, 2.72028539e-02f, -5.48717454e-02f, -8.06890875e-02f, 4.08330075e-02f, -1.24273188e-01f, 4.51214723e-02f, -6.15885332e-02f, 4.61634956e-02f, -4.59401347e-02f,
  -7.47084171e-02f, 5.82263991e-02f, 8.57552420e-03f, -1.18135363e-01f, -2.40851808e-02f, 2.90791988e-02f, -1.74182397e-03f, -9.44995657e-02f, -3.73438187e-02f, -3.72852087e-02f,
  9.40204188e-02f, -3.32163610e-02f, 5.00815781e-03f, -2.87997928e-02f, -6.63641244e-02f, 1.07377894e-01f, -3.86870988e-02f, -7.56110922e-02f, -1.42881796e-02f, 4.42368127e-02f,
  -7.47906715e-02f, 9.67149660e-02f, 5.29119670e-02f, 3.01784072e-02f, 2.10461225e-02f, -4.84722406e-02f, -4.69159940e-03f, -2.11543143e-02f, 5.14993258e-02f, 7.85708544e-04f,
  -8.32272172e-02f, -4.53531779e-02f, -3.01319603e-02f, 3.37337404e-02f, 5.36650755e-02f, -4.01232503e-02f, -2.40849494e-03f, 3.91090102e-02f, -7.44642466e-02f, 1.04759866e-02f,
  -6.39861971e-02f, 1.34811932e-02f, 3.74984480e-02f, 3.66646200e-02f, -8.18713978e-02f, -1.69251114e-02f, 5.57820983e-02f, 1.07946927e-02f, -2.49522366e-02f, -2.88664959e-02f,
  -3.99050713e-01f, 1.73357353e-01f, -1.16704047e-01f, -1.21224545e-01f, -2.38680199e-01f, 7.02870190e-02f, 5.65558612e-01f, -3.09217423e-01f, -4.46206927e-02f, 2.41104275e-01f,
  -3.82212945e-03f, 1.25597790e-01f, 3.31689000e-01f, -2.23821789e-01f, -3.06697428e-01f, 2.40944266e-01f, -2.12680563e-01f, 1.26769722e-01f, -1.27450511e-01f, -1.28969118e-01f,
  -1.37837142e-01f, -1.32485911e-01f, -1.67394102e-01f, -1.21015251e-01f, -1.99023411e-01f, -2.56711785e-02f, -4.25579473e-02f, 1.58027813e-01f, -1.72737464e-01f, -8.08207393e-02f,
  -2.73706522e-02f, -1.03994563e-01f, 6.73556924e-02f, 3.05953380e-02f, -4.74635586e-02f, 4.54530083e-02f, 5.32941259e-02f, 4.37473021e-02f, -3.75512429e-02f, 2.18624976e-02f,
  1.02738440e-01f, -6.27717972e-02f, -6.99510947e-02f, 7.77483881e-02f, -9.94561836e-02f, -7.08608702e-02f, -9.36841071e-02f, -6.77962676e-02f, 2.85498681e-03f, 4.85523511e-03f,
  -3.60651240e-02f, -3.15382592e-02f, -7.38260970e-02f, 5.42889126e-02f, -2.74985563e-02f, 1.79957245e-02f, 8.13307092e-02f, 8.30793977e-02f, 2.18418296e-02f, -8.66443813e-02f,
  -2.11081281e-02f, 9.57372487e-02f, 1.44124851e-02f, 3.16784158e-02f, 1.47392247e-02f, 6.13930747e-02f, -7.91010540e-03f, -4.05932292e-02f, 2.06170697e-02f, 1.86331272e-02f,
  -5.27662691e-03f, -7.50308251e-03f, -1.01891741e-01f, -5.49819507e-02f, 5.69984764e-02f, 4.46299985e-02f, 1.19808882e-01f, 1.87559314e-02f, -3.14487927e-02f, -3.98228653e-02f,
  4.87805679e-02f, -6.24007136e-02f, 8.07989016e-02f, -1.38427056e-02f, -1.46974437e-02f, -7.49151558e-02f, -9.54459012e-02f, 3.06178387e-02f, 1.59471128e-02f, 7.10336789e-02f,
  3.59863564e-02f, 1.48189873e-01f, 8.04979131e-02f, 3.65466462e-03f, 3.10677178e-02f, -8.33195522e-02f, -3.28507647e-02f, -1.11994654e-01f, 9.93021727e-02f, -9.06574726e-02f,
  -2.90253162e-02f, 2.53683534e-02f, 4.89888899e-02f, -6.04436435e-02f, -1.57114174e-02f, 3.46436091e-02f, 1.37473837e-01f, -1.51242921e-03f, 3.33521254e-02f, -1.23133093e-01f,
  -4.61707227e-02f, 6.80657253e-02f, 3.86640355e-02f, -6.48433194e-02f, 3.13500129e-02f, 4.05318365e-02f, -3.33474241e-02f, 6.30222121e-03f, -1.78532973e-02f, 5.12719937e-02f,
  -4.52449024e-01f, 1.32121220e-01f, -4.91074771e-02f, -3.48755062e-01f, 1.57112002e-01f, -2.65978187e-01f, -3.48737210e-01f, 2.88859457e-01f, -2.44668409e-01f, -2.96498928e-02f,
  7.61702880e-02f, -2.43002921e-01f, 1.74342513e-01f, -1.96822897e-01f, -1.06104791e-01f, 1.09789290e-01f, -3.78031015e-01f, -2.70906240e-01f, 8.89164582e-02f, -3.48427817e-02f,
  -6.49520457e-02f, -3.02393697e-02f, 3.80070359e-02f, 2.98535287e-01f, -4.98360284e-02f, 3.53596844e-02f, 2.81790853e-01f, 1.61078617e-01f, -5.88396564e-02f, 9.59759876e-02f,
  -6.89819977e-02f, 1.59622133e-02f, -2.94496748e-03f, -3.39412540e-02f, 2.05528028e-02f, -5.44704944e-02f, -9.33310017e-02f, 8.19112137e-02f, -7.20003322e-02f, 2.90724654e-02f,
  -5.59006855e-02f, 6.46611443e-03f, -2.22149827e-02f, 7.16704652e-02f, -1.00108549e-01f, 4.54364717e-02f, -4.07692119e-02f, -3.81007278e-03f, 1.40398182e-02f, 5.64662041e-03f,
  -2.51076110e-02f, 4.54018125e-03f, -1.47993878e-01f, -6.28447607e-02f, 3.53996120e-02f, -8.80480632e-02f, -8.44796225e-02f, 1.78258796e-03f, -1.05171308e-01f, -1.76355112e-02f,
  -6.68772757e-02f, 2.67009921e-02f, 8.65754113e-02f, 5.79745620e-02f, -2.40274072e-02f, 6.56892359e-02f, -2.59628519e-02f, 3.36859748e-02f, -3.69747020e-02f, -1.76115837e-02f,
  4.02726308e-02f, 3.99014093e-02f, -3.02770454e-03f, -4.91667800e-02f, -1.49789033e-02f, -9.64389276e-03f, -6.16546497e-02f, 1.02788750e-02f, -3.16912159e-02f, 1.82958655e-02f,
  3.75920050e-02f, -3.76321636e-02f, 3.34781520e-02f, 5.26240692e-02f, 3.70189771e-02f, 8.06069151e-02f, 3.32320593e-02f, -2.68026232e-03f, 1.51250390e-02f, -2.46589934e-03f,
  -1.09580494e-01f, 1.14331990e-01f, 8.74895975e-02f, -4.45493199e-02f, -9.91531461e-03f, 1.94215886e-02f, -4.10448089e-02f, -7.97309633e-03f, -1.59438066e-02f, -5.30329626e-03f,
  -1.32329151e-01f, -8.07434246e-02f, 1.78868379e-02f, -2.34406833e-02f, -7.16403052e-02f, 6.99139759e-02f, -1.11897536e-01f, -9.16794613e-02f, -9.23931748e-02f, 7.70387873e-02f,
  2.63822339e-02f, -9.97733697e-02f, -5.29717468e-02f, -5.22278510e-02f, -1.10762060e-01f, -5.52025437e-02f, -1.13995252e-02f, 1.81819908e-02f, 2.28705425e-02f, -1.31071629e-02f,
  -1.51774347e-01f, -5.28795160e-02f, -1.38035998e-01f, -6.53132275e-02f, -3.25876117e-01f, 1.33279905e-01f, 1.04000948e-01f, -3.26584965e-01f, -1.18335173e-01f, 1.68866411e-01f,
  -1.37071148e-01f, 3.06497902e-01f, -1.65525973e-01f, 2.18959212e-01f, 7.78532401e-02f, 1.63673371e-01f, 2.57601231e-01f, 2.30764791e-01f, -1.31708816e-01f, -1.81904823e-01f,
  -1.29220784e-01f, -1.10160083e-01f, -5.92966899e-02f, -7.85131827e-02f, -1.39017701e-01f, -5.27665485e-03f, -6.92835376e-02f, -1.59200966e-01f, 2.88773447e-01f, 1.73199371e-01f,
  -6.56595230e-02f, -1.49185389e-01f, 4.75710705e-02f, 1.71112306e-02f, -5.48046567e-02f, 3.66360545e-02f, 9.59604010e-02f, -1.62598714e-02f, 1.37333879e-02f, 5.37619628e-02f,
  5.10384664e-02f, -8.82515311e-02f, 1.38111085e-01f, -2.42016395e-03f, -2.32133400e-02f, -4.34282422e-02f, -7.64183998e-02f, -7.56546631e-02f, -7.57770613e-02f, -7.47249573e-02f,
  -4.13384363e-02f, 2.09020674e-02f, 1.81413516e-02f, 5.40515548e-03f, -8.82439166e-02f, -1.89066883e-02f, 8.29102024e-02f, 3.89551334e-02f, -9.23636090e-03f, 7.70988390e-02f,
  5.16238473e-02f, 6.39339685e-02f, -8.83780885e-03f, 4.57511237e-03f, 1.63693517e-03f, -8.67060497e-02f, 4.45474572e-02f, 5.69090359e-02f, 3.01445611e-02f, -1.16328739e-01f,
  -8.68882015e-02f, 9.03578177e-02f, 1.20848417e-02f, 2.39554755e-02f, 3.08525041e-02f, 3.24523821e-02f, 5.91505207e-02f, -4.80610318e-02f, -4.07770388e-02f, -4.69621494e-02f,
  -2.80998927e-02f, -8.12565014e-02f, -3.61878797e-02f, -2.47943867e-02f, -4.80534844e-02f, -4.30639088e-02f, -5.96313700e-02f, -2.82746572e-02f, -8.19262862e-03f, 2.60689325e-04f,
  -1.41290531e-01f, -4.24121693e-02f, 3.67240086e-02f, -2.25725546e-02f, 1.28122225e-01f, 6.63999841e-02f, 5.29166274e-02f, 3.01867817e-03f, -6.96746632e-02f, -3.35785896e-02f,
  -2.54835114e-02f, 5.35704084e-02f, 9.83523391e-03f, -6.55774027e-02f, 4.16958816e-02f, -5.18671796e-02f, -8.93076789e-03f, 3.21970284e-02f, 3.35175209e-02f, -4.60682437e-02f,
  -3.38531472e-02f, -2.71020401e-02f, 7.49910017e-03f, -4.40181084e-02f, 3.87794636e-02f, 6.94736019e-02f, 1.77309420e-02f, 6.67545870e-02f, -2.96020359e-02f, -2.01214403e-02f,
  -4.10476625e-02f, 3.61593813e-01f, 2.08090171e-01f, 2.13326558e-01f, -1.44438282e-01f, -1.71512932e-01f, 1.20329894e-01f, -6.96558971e-03f, 3.39265823e-01f, 5.54975495e-02f,
  -2.29119480e-01f, 3.13218087e-01f, -1.13877095e-01f, -3.63691971e-02f, -4.42746729e-01f, -1.16350710e-01f, -1.90263554e-01f, 1.42020658e-01f, 4.46018651e-02f, 2.25472465e-01f,
  -2.18119957e-02f, -2.13721380e-01f, -1.66055143e-01f, -8.50347430e-03f, -4.86579128e-02f, 2.54830062e-01f, -2.04063132e-01f, 1.06369473e-01f, -1.42873138e-01f, -1.72271371e-01f,
  -8.52121115e-02f, 1.28425673e-01f, 1.09940879e-01f, 7.75341243e-02f, -1.10634454e-01f, 4.51514013e-02f, -4.68703397e-02f, -7.72980079e-02f, -1.20767429e-02f, 3.65354083e-02f,
  6.66184053e-02f, -5.31391576e-02f, 5.92006147e-02f, -4.54774778e-03f, 1.12393029e-01f, -9.77551658e-03f, 8.96494761e-02f, -2.82491874e-02f, 6.58541173e-02f, -1.37496278e-01f,
  1.71403531e-02f, -3.45427380e-03f, -1.92857254e-02f, 3.97964939e-02f, 3.42937978e-03f, -1.27044320e-02f, -1.49143934e-02f, 1.51579259e-02f, 3.53635363e-02f, 9.27880930e-04f,
  2.20128614e-02f, 5.47719374e-02f, 3.47057320e-02f, -2.24264674e-02f, -1.89720578e-02f, -4.15684357e-02f, -3.60143371e-02f, -1.43718094e-01f, 5.97844310e-02f, -6.42308742e-02f,
  -3.89098860e-02f, 1.17319278e-01f, 4.54101190e-02f, -4.29492537e-03f, 4.28219251e-02f, 1.79315209e-02f, -1.95040256e-02f, 7.05847070e-02f, 8.20679516e-02f, -7.16468990e-02f,
  -2.01237611e-02f, -8.00282508e-02f, 5.58260456e-02f, -3.80875841e-02f, -1.62503812e-02f, -1.94923747e-02f, 2.38521677e-02f, -1.14439622e-01f, 2.15566680e-02f, 9.39858053e-03f,
  4.59858216e-02f, 2.03731358e-01f, 2.92445626e-02f, -2.60716323e-02f, 1.13309413e-01f, -7.91994631e-02f, -2.47572530e-02f, 9.19906795e-02f, 1.59111712e-02f, -6.11026622e-02f,
  -5.80366934e-03f, 6.85985461e-02f, 1.88133605e-02f, 2.15722509e-02f, -3.56298797e-02f, -1.25575215e-01f, 7.59467296e-03f, 5.41112795e-02f, -3.72932553e-02f, 4.01878282e-02f,
  -9.18217283e-03f, -3.90994027e-02f, 7.22276326e-03f, -1.64625011e-02f, -1.28142824e-02f, -3.14382836e-02f, 1.84270535e-02f, 8.74299631e-02f, -1.09532095e-01f, 4.98247482e-02f,
  1.37589991e-01f, 3.76319706e-01f, -1.56710669e-01f, 2.09730238e-01f, -1.78429112e-01f, -3.70768666e-01f, 1.55197322e-01f, 5.09876162e-02f, 1.01968892e-01f, 3.79821151e-01f,
  1.77523464e-01f, 6.46274388e-02f, 1.78561449e-01f, 1.67023137e-01f, -4.21523720e-01f, -1.34484515e-01f, 1.16105459e-03f, 1.90691680e-01f, -7.56515772e-04f, 2.89911091e-01f,
  -1.67990655e-01f, 1.06187224e-01f, -1.69597462e-01f, 3.36891040e-02f, 7.11908340e-02f, 1.63717344e-02f, -7.35579804e-02f, -7.37457201e-02f, 6.08080104e-02f, -6.36352673e-02f,
  -5.54200597e-02f, 2.91003764e-01f, 3.67118558e-03f, -3.34885158e-02f, 6.50786459e-02f, 6.88381046e-02f, -7.23800659e-02f, -1.08096572e-02f, -7.23379804e-03f, 9.08637717e-02f,
  -5.67799956e-02f, -5.18452637e-02f, -9.85956006e-03f, 5.75695038e-02f, -5.14466725e-02f, -5.40374964e-02f, -2.02228446e-02f, 3.01435846e-03f, 6.86098039e-02f, -2.42250189e-02f,
  3.48528102e-02f, -6.00440502e-02f, -2.92037427e-02f, 3.95590737e-02f, -1.35706112e-01f, -3.36379856e-02f, -9.95461047e-02f, -9.13917571e-02f, -4.42818797e-04f, -2.60999557e-02f,
  1.63420383e-02f, -1.13948835e-02f, 7.34061077e-02f, 6.30843788e-02f, 4.50631306e-02f, 1.21717909e-02f, -9.31509677e-03f, -1.76712070e-02f, -3.21203582e-02f, 1.90533437e-02f,
  -1.13824740e-01f, 2.14782506e-02f, -4.46649007e-02f, 1.92295332e-02f, -1.27699403e-02f, 7.61564029e-03f, -6.68997169e-02f, 2.17289962e-02f, -6.39964119e-02f, 1.81297399e-02f,
  1.85446665e-02f, -4.49823821e-03f, 1.99674699e-03f, -9.40379798e-02f, 3.46112214e-02f, 2.17574462e-02f, -2.18432769e-02f, -4.96514840e-03f, 6.22230247e-02f, -2.48539988e-02f,
  6.48918152e-02f, 2.23086268e-01f, -8.12414568e-03f, 6.51279930e-03f, 3.33506428e-02f, -1.75897107e-02f, -4.21590842e-02f, 1.08535392e-02f, -1.01021898e-03f, 3.83181237e-02f,
  3.60412933e-02f, -2.87963338e-02f, 1.34017924e-02f, -9.20973998e-03f, -8.63644406e-02f, 6.70705736e-02f, 1.26596168e-02f, -5.36784530e-02f, -4.60427999e-02f, 1.19879143e-02f,
  -1.50006535e-02f, 4.55822088e-02f, -5.17044589e-02f, 1.30197238e-02f, -2.34868210e-02f, 6.71095997e-02f, 5.44634797e-02f, -2.35670786e-02f, -7.50558870e-03f, -2.24007014e-02f,
  3.58502060e-01f, 3.03825680e-02f, 3.04318815e-01f, 2.77697444e-01f, 7.95053095e-02f, -1.87608555e-01f, 4.47982165e-04f, -1.07207321e-01f, 7.73139149e-02f, -3.39743495e-01f,
  -2.40105197e-01f, 4.56327528e-01f, -3.72366726e-01f, 4.55847150e-03f, 2.67853051e-01f, -2.90035844e-01f, 1.72418747e-02f, 2.32765861e-02f, 1.15046471e-01f, -2.62586232e-02f,
  1.65126115e-01f, -2.06669971e-01f, 1.22223496e-01f, -1.94772929e-01f, 1.67208523e-01f, 2.81941295e-01f, 1.68816298e-02f, 1.81891575e-01f, 2.62509078e-01f, 1.15279503e-01f,
  -8.85629430e-02f, -1.93301588e-02f, 1.54404193e-01f, 1.30662238e-02f, -2.64012832e-02f, -1.83978640e-02f, 2.61949655e-02f, 8.62456560e-02f, 4.38227803e-02f, 9.08856094e-03f,
  4.93464060e-02f, 3.30351223e-03f, 3.26633616e-03f, 4.45080474e-02f, 7.14709982e-02f, 4.29312661e-02f, 4.43069935e-02f, -2.74219885e-02f, -5.14479214e-03f, 6.13027401e-02f,
  1.06430233e-01f, 2.05458589e-02f, -6.91135600e-03f, 2.37211050e-03f, 1.47104412e-01f, 7.65321925e-02f, 2.60593705e-02f, 9.74825919e-02f, 5.36239818e-02f, 1.29762441e-01f,
  -1.29962176e-01f, -2.07597297e-02f, 7.25000724e-02f, 5.12612006e-03f, 3.05889770e-02f, 5.06277904e-02f, -3.87886427e-02f, -1.01641320e-01f, 7.08584487e-02f, -4.35086675e-02f,
  1.23879667e-02f, 6.65956587e-02f, -8.41795653e-02f, 5.07961102e-02f, -6.85846955e-02f, 4.77105491e-02f, 4.51428862e-03f, 5.49070947e-02f, 4.60369624e-02f, -2.06743064e-03f,
  -2.95120459e-02f, 4.04652879e-02f, 2.25247685e-02f, -5.13757356e-02f, -4.30422537e-02f, 3.68159898e-02f, -6.40514940e-02f, 1.03303082e-01f, -7.57379532e-02f, -1.37912370e-02f,
  -1.20601341e-01f, 1.23876957e-02f, -7.31901973e-02f, 3.26593556e-02f, 2.46960446e-02f, -4.25283164e-02f, -1.61161665e-02f, -6.60744635e-03f, 6.98557347e-02f, -5.73917627e-02f,
  -4.14373651e-02f, -1.81783903e-02f, -3.16760354e-02f, -2.43820809e-02f, 5.69453114e-04f, -4.01876681e-03f, -6.15183339e-02f, -1.15611097e-02f, -5.77179119e-02f, 6.88207860e-04f,
  -5.71905971e-02f, -8.56614485e-02f, -2.40811482e-02f, 3.53986323e-02f, -9.62982103e-02f, -6.17083237e-02f, 8.08883309e-02f, 4.31022495e-02f, 3.10670231e-02f, -5.41293696e-02f,
  9.97920856e-02f, 6.57724142e-02f, -5.75222000e-02f, 9.75381732e-02f, 1.29992068e-01f, -1.74903199e-01f, -2.26194765e-02f, 1.48093551e-01f, -2.51662195e-01f, 2.29628012e-01f,
  1.15996897e-01f, -1.31450102e-01f, -1.65376440e-01f, 1.87009409e-01f, -5.60863793e-01f, -3.62896889e-01f, -2.86897104e-02f, 5.72926663e-02f, -2.10868940e-01f, 1.30105868e-01f,
  -1.96280822e-01f, 2.25507647e-01f, -8.81651789e-02f, 2.35731527e-01f, 1.80298731e-01f, 2.01441199e-01f, 1.82530403e-01f, 5.50721996e-02f, 2.00776488e-01f, 2.66136043e-02f,
  -7.76358992e-02f, -9.83653124e-03f, 2.68311538e-02f, -9.49400663e-03f, 1.38879949e-02f, 5.43403924e-02f, 1.10293031e-01f, 3.43102515e-02f, 4.01070267e-02f, -2.33048145e-02f,
  6.14856519e-02f, 1.63991272e-03f, -8.23116452e-02f, 1.10303378e-02f, 9.43269283e-02f, -3.42053063e-02f, -3.95264998e-02f, 1.05591081e-01f, 5.22535620e-03f, -3.08606531e-02f,
  -8.09030831e-02f, 2.05469634e-02f, 8.63921642e-02f, -5.78742698e-02f, -1.54566050e-01f, -3.23754884e-02f, -4.39452268e-02f, -4.55704145e-02f, -5.96676320e-02f, -1.41517743e-01f,
  2.55573336e-02f, 2.86453720e-02f, 2.35863309e-02f, 4.09135297e-02f, -8.64697248e-02f, 6.59079030e-02f, 1.96940005e-02f, -3.08387987e-02f, 2.69763861e-02f, -6.58118948e-02f,
  4.15944904e-02f, -5.26297130e-02f, 4.69769314e-02f, 5.65916933e-02f, 4.01009631e-04f, 4.07206789e-02f, 1.51989507e-02f, -7.96665624e-02f, -4.63887267e-02f, -2.39145663e-02f,
  9.17839855e-02f, -1.03307173e-01f, -4.24529426e-02f, 1.34964004e-01f, -6.17925562e-02f, -3.67028490e-02f, 1.06106833e-01f, 4.96875786e-04f, 3.27412151e-02f, 5.42281717e-02f,
  2.22388543e-02f, -2.76616011e-02f, -4.68036570e-02f, 9.96812154e-03f, -1.01071507e-01f, 2.01030895e-02f, -1.08244352e-01f, -5.07515036e-02f, -3.23826820e-02f, -1.01274170e-01f,
  5.67175336e-02f, 1.18489608e-01f, 8.43938515e-02f, 2.05901805e-02f, 4.15443592e-02f, -4.23476845e-03f, -7.04378495e-03f, 1.57228652e-02f, 2.04883795e-02f, 2.59878226e-02f,
  1.40088543e-01f, 1.45828845e-02f, -3.13500613e-02f, -2.52296869e-02f, 1.39933050e-01f, 4.01634313e-02f, 4.59347703e-02f, 4.12296206e-02f, -3.74899653e-04f, 2.57950220e-02f,
  2.86856174e-01f, -1.52606830e-01f, -1.49695808e-02f, 2.98880398e-01f, -3.19079846e-01f, -4.76640195e-01f, 1.92722782e-01f, -8.55273530e-02f, 1.83577135e-01f, -1.96027115e-01f,
  -1.13286026e-01f, 3.68010476e-02f, 2.81964272e-01f, -1.94100320e-01f, 1.20634183e-01f, 1.01075225e-01f, -9.53781977e-02f, -1.66324362e-01f, 2.89772779e-01f, 2.09979951e-01f,
  2.42237240e-01f, -1.37044042e-01f, 1.30257485e-02f, -1.72071323e-01f, 3.71529488e-03f, 1.36943266e-01f, 1.70449987e-01f, 2.27757573e-01f, -1.36470109e-01f, -1.44737393e-01f,
  4.50317777e-04f, 8.16301927e-02f, 3.84828970e-02f, -1.52143538e-02f, -7.59722441e-02f, 4.16568965e-02f, 1.34411780e-02f, 1.35816142e-01f, 1.97508484e-02f, -2.22252519e-03f,
  1.03783775e-02f, 3.39035094e-02f, -5.67319505e-02f, 3.03425957e-02f, -3.55280265e-02f, -4.13073376e-02f, -2.94589205e-03f, -9.46205333e-02f, -5.06350622e-02f, 4.19193991e-02f,
  2.82727240e-04f, -7.15047717e-02f, -2.92904396e-02f, -6.01100549e-02f, -1.09437056e-01f, -3.02004851e-02f, -2.01612338e-02f, 2.07334328e-02f, -1.20796770e-01f, -1.08681552e-01f,
  1.85828179e-03f, 3.89951803e-02f, 2.59168763e-02f, -6.30052537e-02f, 1.12865651e-02f, 2.34195351e-04f, -2.17371602e-02f, -6.08219914e-02f, 1.11316942e-01f, -5.91410287e-02f,
  -5.13516217e-02f, -5.52919554e-03f, 1.06198601e-01f, 8.05863459e-03f, 9.82524711e-04f, -5.97713627e-02f, 1.75107513e-02f, 1.44418821e-01f, 2.82882969e-03f, 2.71571968e-02f,
  8.72238949e-02f, -1.64551122e-04f, 2.50647794e-02f, 2.75537353e-02f, -1.93511564e-02f, 3.58023793e-02f, 6.19100370e-02f, -8.88906792e-02f, -1.43527500e-02f, 2.41863020e-02f,
  -1.12703107e-01f, 6.51584798e-03f, 9.41421390e-02f, -1.36452019e-01f, 1.44038433e-02f, -1.97513886e-02f, 3.46408077e-02f, -1.08824223e-01f, -7.52992854e-02f, -2.54693143e-02f,
  -2.57142261e-02f, -1.34406490e-02f, -2.28990354e-02f, 2.82346159e-02f, -3.02685760e-02f, -4.18117596e-03f, -3.59918252e-02f, 1.05735939e-03f, -5.52592017e-02f, -5.58774471e-02f,
  -9.01284739e-02f, -2.76871361e-02f, -7.58970305e-02f, -1.40962169e-01f, -1.76130049e-02f, -5.18007539e-02f, 9.07492451e-03f, 9.53690261e-02f, 7.89830275e-03f, -1.84314903e-02f,
  -3.27621758e-01f, 3.18042666e-01f, 2.73347557e-01f, -2.63208508e-01f, 2.50849649e-02f, -2.78015763e-01f, -5.74767470e-01f, 8.10606703e-02f, -2.55436078e-02f, -2.14118227e-01f,
  -1.75732911e-01f, 9.92353857e-02f, -6.26979694e-02f, -1.55358091e-01f, -3.91260058e-01f, -1.28266647e-01f, -2.63226539e-01f, -1.11158729e-01f, 9.39979255e-02f, 1.34963691e-02f,
  -2.85357442e-02f, -3.32721651e-01f, -1.10739032e-02f, 2.73137450e-01f, -6.55632019e-02f, 1.91112727e-01f, -1.13987528e-01f, 1.85980305e-01f, 1.22200800e-02f, -1.45375192e-01f,
  -1.65858455e-02f, -1.17280416e-01f, 1.20345436e-01f, 7.82025307e-02f, 2.44284864e-03f, -5.91333993e-02f, -5.28773554e-02f, -3.79271619e-02f, -2.74403561e-02f, -3.27764377e-02f,
  -4.49189954e-02f, -3.81430201e-02f, -1.22297361e-01f, -1.58073790e-02f, -5.03039137e-02f, 5.61973192e-02f, 5.72904944e-02f, 1.40960306e-01f, 5.29190190e-02f, 5.50237764e-03f,
  1.01422764e-01f, 3.02421153e-02f, -3.22262617e-03f, -1.13452807e-01f, 1.01167625e-02f, -3.21167223e-02f, 3.46736126e-02f, 1.34907914e-02f, -1.29508190e-02f, -2.78657023e-02f,
  -1.16310135e-01f, -1.71901230e-02f, -6.68524997e-03f, 4.60260659e-02f, -1.14213570e-03f, 7.97363073e-02f, -8.68144333e-02f, -8.59729275e-02f, 5.51719852e-02f, -8.09019282e-02f,
  -2.94291880e-02f, 1.64381471e-02f, -4.51525263e-02f, -3.13751362e-02f, -5.25087714e-02f, -1.47868684e-02f, 2.23842915e-02f, 1.94113608e-02f, 4.29651514e-02f, 4.13247012e-02f,
  -8.19505379e-03f, 6.54085772e-03f, -2.58374814e-04f, -2.82672886e-02f, -7.55639896e-02f, 6.73810858e-03f, 3.27369347e-02f, -2.20884420e-02f, -2.05512289e-02f, -4.14296351e-02f,
  -7.52708390e-02f, -1.14745021e-01f, -6.90603778e-02f, -3.91653851e-02f, 8.48615095e-02f, -4.06321213e-02f, 4.55638431e-02f, 7.90057331e-02f, -6.63384646e-02f, -1.04374839e-02f,
  2.53199544e-02f, -3.28811221e-02f, 7.19115734e-02f, -1.38529460e-03f, 3.75630260e-02f, 3.08380686e-02f, -3.91278267e-02f, -1.29002007e-02f, -3.82835753e-02f, -6.38181046e-02f,
  -1.95589047e-02f, -2.96888724e-02f, -6.34254888e-02f, -4.54473235e-02f, -8.81593451e-02f, -1.04247332e-01f, 1.70626733e-02f, 5.63239604e-02f, -5.76368757e-02f, 5.65832593e-02f,
  -9.55198482e-02f, -1.68057531e-01f, 3.65334600e-01f, 1.42836750e-01f, 4.52745892e-02f, -1.57425627e-01f, -2.26730511e-01f, 1.59937769e-01f, 1.72742754e-02f, -2.01028109e-01f,
  -2.65828162e-01f, -6.27046973e-02f, -1.94361299e-01f, -8.14521909e-02f, -4.36660610e-02f, -2.26821318e-01f, 5.61522283e-02f, -1.74044177e-01f, 9.37612355e-02f, 2.26196293e-02f,
  2.30610788e-01f, -2.74545312e-01f, 2.26614684e-01f, 1.34084880e-01f, 1.74332932e-01f, 2.44846359e-01f, -7.04857931e-02f, 7.15094805e-02f, 7.80498087e-02f, -8.72763991e-02f,
  -1.29675627e-01f, 5.19394688e-02f, 9.06801820e-02f, 6.04092889e-02f, 3.35250124e-02f, -9.06043649e-02f, -3.11834365e-02f, -1.33321598e-01f, 6.45050853e-02f, 7.84234032e-02f,
  -3.22079770e-02f, 4.93664332e-02f, 5.10546789e-02f, -2.17291228e-02f, 1.25667937e-02f, 1.06531821e-01f, 3.32877748e-02f, 6.83821291e-02f, -1.66288447e-02f, 9.20111984e-02f,
  1.09998636e-01f, 7.22635537e-02f, 3.57643478e-02f, -4.71687764e-02f, 6.27324730e-02f, 3.49123101e-03f, 5.94237261e-02f, 7.55967945e-02f, -2.16164570e-02f, 2.88317353e-02f,
  -6.54908195e-02f, 4.86188866e-02f, 8.89341757e-02f, 3.52962017e-02f, -4.18560691e-02f, -3.82315852e-02f, -3.53513807e-02f, 1.32111004e-02f, 8.05029199e-02f, -2.02574898e-02f,
  -4.83018234e-02f, 5.24228252e-02f, -1.38085810e-02f, 3.25901695e-02f, 7.45300800e-02f, 7.42513360e-03f, -3.10607702e-02f, 1.54816061e-02f, 8.01897347e-02f, 3.84968817e-02f,
  -6.65773526e-02f, -6.84758136e-03f, -5.02847508e-02f, 2.11968794e-02f, -1.13923199e-01f, 5.74194919e-03f, 1.49128884e-01f, 5.66369928e-02f, 8.16874057e-02f, 1.21012423e-02f,
  -1.63843751e-01f, -1.84498414e-01f, 6.67113960e-02f, -5.83230555e-02f, -7.10274577e-02f, 2.13725176e-02f, -1.89431924e-02f, 6.76570237e-02f, -8.42650235e-02f, -3.79516892e-02f,
  1.15307935e-01f, 2.23927125e-02f, 8.13713949e-03f, -5.41137569e-02f, 1.41095398e-02f, -7.52917230e-02f, -4.52614715e-03f, -8.58842582e-02f, 2.91743726e-02f, -5.67711964e-02f,
  -5.03470935e-02f, -5.64052910e-02f, 1.36981234e-01f, 5.84135987e-02f, 3.78596783e-02f, -8.73890519e-02f, -1.64714735e-02f, 1.73960309e-02f, 4.75048414e-03f, 1.19328527e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.07569540e+00f, 2.42513821e-01f, 4.84956764e-02f, -2.85160810e-01f, 1.28611177e-01f, 4.35370207e-01f, -3.51956069e-01f, -9.37447026e-02f, -3.22999567e-01f, -1.77652866e-01f,
  -3.19024891e-01f, -2.35463247e-01f, -2.83061206e-01f, 2.70894706e-01f, 1.54002070e-01f, 1.94078684e-01f, 1.67670131e-01f, -8.35138336e-02f, 1.83520794e-01f, -1.95139676e-01f,
  1.10898122e-01f, 9.58708003e-02f, 1.38258725e-01f, 3.29341114e-01f, -4.83138300e-02f, -3.41867656e-02f, -1.42271683e-01f, -2.94535512e-05f, 3.26136023e-01f, 2.36663207e-01f,
  -1.38671353e-01f, -5.46348929e-01f, -1.67485788e-01f, -6.62833974e-02f, -1.62201568e-01f, -1.51953980e-01f, -6.29292428e-02f, -3.75213511e-02f, -3.76747362e-02f, 1.50148161e-02f,
  -1.47275422e-02f, 4.91439998e-02f, 7.57160336e-02f, 3.89935970e-02f, -5.43536730e-02f, 2.57372428e-02f, 1.16138503e-01f, -4.47425526e-03f, -3.49730588e-02f, 5.20501435e-02f,
  -5.72382882e-02f, 1.01329193e-01f, -5.19186258e-02f, 5.36860637e-02f, 2.95392387e-02f, 3.10980827e-02f, 1.96376160e-01f, 6.43211752e-02f, 3.77700403e-02f, 7.66480491e-02f,
  1.20650955e-01f, 2.01158989e-02f, -8.08573440e-02f, -1.20597169e-01f, 4.89373095e-02f, -5.18886298e-02f, -1.72937810e-02f, -4.56185006e-02f, 3.38374712e-02f, -5.99634945e-02f,
  5.19537181e-02f, -1.27649516e-01f, 3.94364400e-03f, -4.12216075e-02f, -9.02606919e-02f, -7.83713236e-02f, -7.38688419e-03f, -4.12821909e-03f, -5.74822873e-02f, 9.02765393e-02f,
  -9.18684155e-02f, 3.54938954e-02f, -7.90410340e-02f, -3.18871848e-02f, -8.52353231e-04f, 4.36338559e-02f, 7.28651229e-03f, -6.66668639e-02f, -3.38225476e-02f, -4.75446954e-02f,
  -5.79778492e-01f, -5.56257129e-01f, -3.15583423e-02f, -1.43928856e-01f, -1.24691278e-02f, 7.75960013e-02f, 6.92656711e-02f, 5.14230020e-02f, -6.69542775e-02f, -2.21712049e-02f,
  -1.08805478e-01f, -3.36602293e-02f, -4.28189561e-02f, 3.77512611e-02f, 7.50534236e-02f, -2.39219740e-02f, -3.55818495e-02f, -1.01777151e-01f, -1.44515127e-01f, -4.84600700e-02f,
  -1.05342202e-01f, -1.32034615e-01f, 9.78915244e-02f, 8.86331722e-02f, -3.51755461e-03f, -7.79416561e-02f, -1.38649270e-01f, 3.06333788e-02f, -5.90580935e-03f, 1.68453567e-02f,
  -4.09778774e-01f, 5.46463966e-01f, 3.37129593e-01f, -4.22225922e-01f, 7.33379647e-02f, 7.50810727e-02f, -3.76668632e-01f, 1.49103269e-01f, -1.78156361e-01f, 1.40528619e-01f,
  -1.97190985e-01f, 1.39235869e-01f, -7.46805370e-02f, -2.29782075e-01f, -5.64926863e-01f, -4.21765059e-01f, -5.01925349e-01f, -2.46493444e-01f, -1.58802003e-01f, -2.75458068e-01f,
  -2.96151936e-01f, -4.58142728e-01f, -1.69429943e-01f, 2.19938874e-01f, 1.96324196e-02f, 1.97770983e-01f, -3.66520017e-01f, 3.08698773e-01f, 6.53966665e-02f, 4.62374203e-02f,
  1.01010218e-01f, 1.34672355e-02f, 1.43909439e-01f, 1.19667821e-01f, -1.11969568e-01f, 8.67442563e-02f, 2.31643487e-02f, 3.77822667e-02f, -1.50450602e-01f, 1.47982404e-01f,
  6.77729398e-02f, 1.04786113e-01f, 4.53536101e-02f, 4.79943193e-02f, 4.41639796e-02f, 1.43001333e-01f, 1.17552899e-01f, 1.12991162e-01f, 1.48016766e-01f, 1.15140133e-01f,
  6.12344332e-02f, 1.34015977e-01f, -4.02271822e-02f, -8.14778656e-02f, -3.22986133e-02f, 1.16166107e-01f, -1.32093430e-01f, 8.95304307e-02f, 4.38496061e-02f, 4.90943193e-02f,
  7.21315444e-02f, -1.97974175e-01f, 3.79192010e-02f, -1.15165524e-02f, -6.93482310e-02f, 5.27028516e-02f, -1.08177654e-01f, -4.33591157e-02f, -2.72112694e-02f, 4.37240340e-02f,
  -3.16007994e-02f, 1.02205992e-01f, 2.14318205e-02f, -1.26088649e-01f, -3.25944386e-02f, -1.05750095e-02f, -4.94166277e-02f, -2.62584649e-02f, -1.17937006e-01f, -5.21315895e-02f,
  -8.11635628e-02f, -6.69489875e-02f, 4.97286655e-02f, 3.07368324e-03f, 1.18617173e-02f, 9.96939391e-02f, -1.09654412e-01f, 1.63463205e-01f, -4.66320999e-02f, -1.64482653e-01f,
  -2.67995268e-01f, -2.94965923e-01f, 3.30435624e-03f, 8.88385624e-02f, 4.12156843e-02f, 4.71613593e-02f, 7.02088326e-02f, -1.03474855e-02f, 3.49405482e-02f, -6.25909343e-02f,
  7.23768547e-02f, -5.98445982e-02f, -3.08804680e-02f, -2.11814716e-02f, -5.45596471e-03f, -8.08952302e-02f, -1.67653561e-01f, -7.20211025e-03f, -5.87204695e-02f, 1.95120238e-02f,
  5.76741435e-02f, -4.92082126e-02f, -1.25864133e-01f, -1.31400183e-01f, -7.80992582e-02f, 1.62224639e-02f, -1.11958034e-01f, 8.16987678e-02f, -4.50976528e-02f, -4.12065499e-02f,
  -4.13502812e-01f, -2.91369408e-02f, 5.39207101e-01f, 4.81605589e-01f, -5.70173562e-01f, -3.55109245e-01f, 3.51178735e-01f, -2.87269145e-01f, -2.46558592e-01f, 6.27590194e-02f,
  1.13819063e-01f, 7.61843920e-02f, 1.35497063e-01f, 2.46634871e-01f, 2.28883192e-01f, 3.02512527e-01f, 1.54310197e-01f, 2.66699433e-01f, -1.14513718e-01f, -3.88011709e-02f,
  4.96258661e-02f, 1.39392167e-01f, 3.33874732e-01f, -2.31565922e-01f, -6.25765696e-02f, 1.12775244e-01f, 2.19926581e-01f, 1.40582368e-01f, 1.77029110e-02f, -2.35083681e-02f,
  -3.69228482e-01f, 1.01204999e-01f, -1.00497365e-01f, -1.45180732e-01f, -9.73668173e-02f, -6.56903610e-02f, 1.93381160e-01f, 2.43762374e-01f, 1.18428737e-01f, -4.32988517e-02f,
  -1.31164744e-01f, 1.65205449e-02f, -4.68183272e-02f, -7.72117972e-02f, -1.47648737e-01f, -8.07934701e-02f, -2.25487858e-01f, -6.89076260e-02f, 7.08668306e-02f, -7.03240931e-02f,
  1.68234773e-03f, -7.69705251e-02f, 5.56632727e-02f, 1.24257758e-01f, 2.84515042e-02f, 9.52936523e-03f, 1.45456925e-01f, -8.58916491e-02f, -1.13838829e-01f, 5.97268231e-02f,
  -1.97559036e-02f, 7.98211843e-02f, -2.40298901e-02f, 1.75103862e-02f, -3.76247689e-02f, 1.51256904e-01f, -8.18562582e-02f, 7.11856559e-02f, 6.19752370e-02f, -1.18342685e-02f,
  -2.16842024e-03f, 1.61985531e-02f, -7.03423098e-02f, -1.03021421e-01f, -3.71784493e-02f, 2.44609993e-02f, 1.28032088e-01f, -4.93004583e-02f, 2.45799609e-02f, 4.27185837e-03f,
  2.20677406e-01f, 7.88665339e-02f, -9.35190469e-02f, 4.62289527e-02f, -2.18207780e-02f, 5.18052429e-02f, 1.69136785e-02f, 9.06322449e-02f, 3.23195346e-02f, -5.38383797e-02f,
  -1.62280560e-01f, 3.16740215e-01f, 6.93760738e-02f, -2.09206447e-01f, 5.02485633e-02f, -1.68084636e-01f, 7.14451447e-02f, -1.12903982e-01f, -5.30119501e-02f, 1.15830544e-02f,
  -2.44914696e-01f, -4.57989462e-02f, -1.37206912e-01f, -2.94933580e-02f, 1.31503224e-01f, 7.16230571e-02f, 1.54707864e-01f, -1.91505104e-02f, -3.82812880e-02f, -2.16062777e-02f,
  2.48114262e-02f, 1.27689019e-01f, 1.92554053e-02f, -2.48404872e-02f, 7.42258923e-03f, -2.03909967e-02f, -6.53116480e-02f, 3.66583690e-02f, -1.16201796e-01f, 7.63993934e-02f,
  5.28736174e-01f, 4.74176444e-02f, -3.57601345e-01f, -3.83459836e-01f, -2.75487214e-01f, 7.68661052e-02f, -2.41385281e-01f, -1.56513989e-01f, -2.36282557e-01f, -7.41323158e-02f,
  -3.63695204e-01f, 5.49605191e-02f, 6.12094924e-02f, -1.80305451e-01f, 3.48049313e-01f, 3.52144271e-01f, -1.98774278e-01f, -2.58748084e-01f, -1.73596162e-02f, -1.35329753e-01f,
  -8.12739879e-02f, -1.61320686e-01f, -9.03766677e-02f, -9.57196802e-02f, -1.97261229e-01f, -1.97876528e-01f, -2.13416040e-01f, -2.97784656e-01f, -2.40466297e-01f, -2.49243245e-01f,
  1.06641194e-02f, -8.61874148e-02f, -1.56704843e-01f, 2.62983683e-02f, -4.73285057e-02f, 6.04765303e-02f, -1.04489222e-01f, -9.13468301e-02f, -8.06054622e-02f, 9.40526202e-02f,
  1.25524282e-01f, 2.21091628e-01f, 1.78491008e-02f, 3.04698590e-02f, 6.04723506e-02f, -1.60999194e-01f, 7.25449622e-02f, -1.13406248e-01f, -1.61046535e-01f, 1.56843230e-01f,
  -7.25056008e-02f, 1.52561769e-01f, -8.64113718e-02f, -2.03173719e-02f, -2.21110687e-01f, -9.92407948e-02f, 2.00815931e-01f, -1.54166237e-01f, -5.05791828e-02f, 1.43228173e-01f,
  7.11343586e-02f, 1.59353301e-01f, 1.05832636e-01f, 6.80306628e-02f, 9.60284770e-02f, -3.20033357e-02f, -5.24311922e-02f, 2.72369795e-02f, -2.69646198e-02f, -3.89480367e-02f,
  -1.72442228e-01f, -3.08329036e-04f, -1.36968091e-01f, 3.89664099e-02f, 1.02022709e-02f, 1.97026923e-01f, -2.41551455e-02f, -1.14235595e-01f, -1.61718428e-01f, 9.25850198e-02f,
  -1.18028991e-01f, -5.28879138e-03f, -1.04021870e-01f, -1.46623388e-01f, -1.52824828e-02f, -4.48645800e-02f, -4.60852385e-02f, 5.21110035e-02f, 5.84766641e-02f, -8.44301879e-02f,
  -6.68790191e-02f, 8.88934657e-02f, -5.20585701e-02f, -3.07524875e-02f, -1.26562238e-01f, 8.11581984e-02f, -1.43509414e-02f, -5.20706177e-02f, -6.40193000e-02f, -5.54018430e-02f,
  9.27250460e-03f, 4.61254418e-02f, -5.33268265e-02f, 1.02946356e-01f, -8.58674049e-02f, -3.54991108e-02f, -1.54855818e-01f, -1.15667827e-01f, -9.46586058e-02f, 1.13108143e-01f,
  -1.35369539e-01f, 1.80831671e-01f, 8.95475447e-02f, -9.04971957e-02f, -1.77293897e-01f, -4.86582927e-02f, 2.16578543e-01f, -2.66540367e-02f, -1.22447506e-01f, -2.00978115e-01f,
  -5.57351649e-01f, -4.53533620e-01f, -1.76705554e-01f, 3.17277340e-03f, -3.87631580e-02f, -2.51056731e-01f, -4.08817381e-01f, -1.04280151e-01f, -3.91713291e-01f, -2.64438123e-01f,
  8.26748833e-02f, -2.25464225e-01f, -3.41069698e-01f, -7.92136863e-02f, 5.03285974e-02f, -4.61108357e-01f, 1.16572209e-01f, 1.13065861e-01f, -3.65143269e-02f, 2.85131007e-01f,
  1.13596506e-01f, 2.59120643e-01f, 3.49153548e-01f, 4.71734941e-01f, 1.30960271e-01f, 4.17471290e-01f, 5.69165528e-01f, 3.25740099e-01f, 4.93467867e-01f, 1.61157370e-01f,
  -3.13624531e-01f, -2.19035789e-01f, -3.00520342e-02f, 4.49793339e-02f, 1.07669927e-01f, 1.74591959e-01f, 7.25292787e-02f, -7.28185698e-02f, -6.55027777e-02f, 1.53201893e-01f,
  1.91038735e-02f, 1.22722894e-01f, 8.37199241e-02f, -7.81012028e-02f, -9.41922888e-02f, 8.66148435e-03f, 2.99533061e-03f, -2.20764931e-02f, -3.82726118e-02f, -1.42798066e-01f,
  -1.23531677e-01f, -3.80933397e-02f, 1.23927020e-01f, -3.88389230e-02f, -4.53376956e-02f, -1.62392464e-02f, 8.07000473e-02f, 1.15040846e-01f, 2.21030992e-02f, 1.16941139e-01f,
  -7.87812248e-02f, 1.15621872e-01f, 6.33736625e-02f, -3.40156741e-02f, 3.92137617e-02f, -9.22543481e-02f, -4.74952087e-02f, -5.26472740e-02f, 5.94974756e-02f, -5.61936118e-04f,
  2.72202771e-02f, -1.14093319e-01f, -1.40079707e-01f, 2.92844847e-02f, 6.45950884e-02f, -7.98352361e-02f, 2.02570222e-02f, 9.16360021e-02f, 3.11876405e-02f, 4.44741594e-03f,
  -2.34496489e-01f, 1.16466871e-02f, -8.22482184e-02f, -1.45571483e-02f, -1.38966501e-01f, 1.14273867e-02f, -1.11435613e-04f, 6.92683831e-03f, 4.84187305e-02f, 1.47103518e-01f,
  9.47729573e-02f, 2.69191474e-01f, 4.27255891e-02f, -4.17975895e-02f, -5.28484955e-02f, 7.03898072e-03f, -4.40399423e-02f, -4.29761745e-02f, 3.14568169e-02f, 8.18198398e-02f,
  1.31920442e-01f, 7.32444897e-02f, 4.51501235e-02f, -2.79454868e-02f, 1.15257815e-01f, 2.37592254e-02f, 7.75468573e-02f, 9.05579329e-02f, 1.31513447e-01f, 1.55807465e-01f,
  2.95195123e-03f, 3.85747179e-02f, 1.67994462e-02f, 3.39096109e-03f, -4.26730979e-03f, -2.40681693e-02f, -4.66093570e-02f, 5.65789528e-02f, 1.84141099e-02f, -7.13182688e-02f,
  2.99371928e-01f, 5.19140184e-01f, -5.90587184e-02f, 3.17167789e-01f, 9.55705866e-02f, 5.47644734e-01f, 4.26513821e-01f, 3.74477655e-01f, 3.70665967e-01f, 2.85573393e-01f,
  -3.64649147e-02f, 2.75385231e-01f, -1.36548668e-01f, 2.80494064e-01f, -3.07696968e-01f, -5.25817759e-02f, 4.70625579e-01f, 3.11668158e-01f, 9.06466022e-02f, 1.71377465e-01f,
  9.23051909e-02f, -7.71800876e-02f, -3.28035027e-01f, -2.00829551e-01f, 5.64109795e-02f, -6.85684532e-02f, -5.41521847e-01f, -3.52462202e-01f, 4.76019159e-02f, 7.08650276e-02f,
  1.54388875e-01f, 7.95485526e-02f, -7.58742765e-02f, -6.23022355e-02f, -1.01256989e-01f, -8.63958374e-02f, -1.29474759e-01f, -1.26205474e-01f, -1.08246893e-01f, 9.51348767e-02f,
  1.72546253e-01f, -3.91405076e-02f, 7.40200579e-02f, -1.50641918e-01f, 8.33220258e-02f, 6.45749569e-02f, 1.93687323e-02f, 1.19693421e-01f, 1.32399693e-01f, -7.28776818e-03f,
  -1.14766844e-01f, 2.88564386e-03f, 1.08124100e-01f, 9.52487737e-02f, -1.15204919e-02f, 1.02150209e-01f, 6.52786419e-02f, 3.13120671e-02f, 1.19398031e-02f, 1.83982864e-01f,
  -1.47256106e-01f, 1.16479523e-01f, 1.54167239e-04f, -9.37475190e-02f, -4.65899706e-02f, -8.19123983e-02f, -2.40853522e-02f, 6.46202192e-02f, 6.61976039e-02f, -7.10923644e-03f,
  3.88162360e-02f, -9.54311108e-04f, 7.50663504e-02f, -1.05033047e-01f, 1.94827944e-01f, 7.67639130e-02f, 2.34124251e-02f, -4.01822217e-02f, 2.27706268e-01f, -8.18042755e-02f,
  -1.43105820e-01f, 6.90203607e-02f, -6.02123141e-02f, -4.73990887e-02f, -5.75324371e-02f, 4.30437289e-02f, -1.00456730e-01f, 7.50631094e-02f, -4.29511592e-02f, -1.07322924e-01f,
  2.16217101e-01f, 1.26713336e-01f, -9.39756748e-04f, -4.24015289e-03f, -1.54265627e-01f, -4.92945760e-02f, 6.75558746e-02f, 3.15425582e-02f, -4.59930338e-02f, -6.55420497e-02f,
  1.02409549e-01f, 9.58741009e-02f, -1.00465640e-01f, -2.09441446e-02f, -9.13896933e-02f, 1.58494115e-01f, 4.44278456e-02f, 2.84865648e-02f, -6.69521764e-02f, -1.17887512e-01f,
  -1.86344236e-01f, 8.61263946e-02f, -2.87312455e-02f, 7.98617229e-02f, 5.42121045e-02f, 1.69075578e-02f, 1.45849988e-01f, -6.72437251e-02f, -1.97935417e-01f, 6.49587885e-02f,
  2.19944641e-01f, -7.42937505e-01f, -5.43110430e-01f, -2.17939809e-01f, 4.56993490e-01f, 6.39504015e-01f, 2.08061665e-01f, -2.21776515e-01f, -7.54021525e-01f, 1.84281264e-02f,
  1.57509223e-01f, -1.58905715e-01f, -2.12881640e-01f, -1.65752873e-01f, 1.75045699e-01f, -3.80751282e-01f, 1.39097869e-02f, 1.25194043e-01f, -3.60082865e-01f, 1.12782218e-01f,
  -1.22203454e-01f, 1.24621905e-01f, -2.76159108e-01f, 6.19532727e-02f, 2.55726933e-01f, 2.94410437e-02f, 5.64562857e-01f, 1.43144757e-01f, 2.21209690e-01f, 1.44563064e-01f,
  -5.97778410e-02f, -2.19383061e-01f, -1.13935448e-01f, -1.28379375e-01f, 1.57208845e-01f, 2.12509751e-01f, 3.24356347e-01f, 6.37065247e-02f, -5.62842079e-02f, -6.60250857e-02f,
  1.34994134e-01f, -9.51005667e-02f, -7.14257061e-02f, 5.20800985e-02f, -6.18261360e-02f, -8.01735148e-02f, -2.21955881e-01f, -9.26745087e-02f, -2.12511778e-01f, -1.07513659e-03f,
  -1.31711230e-01f, 8.50071386e-02f, 4.80498597e-02f, -1.05584953e-02f, 1.37468276e-03f, -1.03586584e-01f, 5.65945804e-02f, 2.85467505e-01f, -1.77267715e-02f, 4.73561585e-02f,
  1.37241155e-01f, 1.73329011e-01f, 1.60092682e-01f, -1.66429207e-01f, -1.92728471e-02f, -8.00385997e-02f, -5.35921380e-03f, -6.09747954e-02f, -7.58598298e-02f, -4.40109447e-02f,
  3.96217592e-02f, -2.90281791e-02f, -5.44555709e-02f, -5.41585162e-02f, 1.15139417e-01f, -1.14079557e-01f, 1.11081406e-01f, 6.88217506e-02f, 6.75870329e-02f, -6.67730793e-02f,
  -8.57753381e-02f, 6.23435900e-02f, 6.61243349e-02f, 8.45575482e-02f, -8.11147839e-02f, 9.90024731e-02f, -3.19731310e-02f, -1.03615098e-01f, -1.26477391e-01f, 8.65231231e-02f,
  1.60849378e-01f, 4.86072190e-02f, -1.79464817e-01f, 2.36475356e-02f, -1.36704743e-01f, 1.04945496e-01f, -2.19366252e-01f, -6.29639924e-02f, 3.14084217e-02f, -1.79606900e-02f,
  2.54878253e-01f, -1.32865068e-02f, 1.68557987e-01f, 3.54255773e-02f, -1.69438068e-02f, 1.16810903e-01f, 7.11305887e-02f, 1.27399474e-01f, 8.66410509e-02f, 7.95388874e-03f,
  1.60003111e-01f, 1.27359569e-01f, -5.43902488e-03f, -1.13786273e-02f, 4.26474698e-02f, 2.20540643e-01f, 1.32704049e-01f, 1.04257233e-01f, 2.00026296e-02f, -1.09456077e-01f,
  6.82679951e-01f, -2.30125740e-01f, -2.63600469e-01f, 4.74075794e-01f, 3.90885890e-01f, 2.18426406e-01f, 9.71795246e-02f, 2.79971123e-01f, 3.36229920e-01f, -2.39596710e-01f,
  3.27091694e-01f, -4.03894186e-01f, -4.89079922e-01f, 4.63681251e-01f, 1.93877771e-01f, -3.45341027e-01f, 4.10414279e-01f, -8.54151417e-03f, 1.48596480e-01f, 2.97321886e-01f,
  2.78357506e-01f, 5.81369102e-01f, -2.54077941e-01f, 1.64884567e-01f, 3.03877652e-01f, -3.46914306e-02f, -6.22576438e-02f, -4.21025515e-01f, -2.98113152e-02f, -3.95186767e-02f,
  1.01257265e-01f, 2.89283067e-01f, -1.49123631e-02f, -1.09166197e-01f, -6.59728376e-03f, 3.84428799e-02f, -1.40012786e-01f, -2.49865353e-01f, -3.52846645e-02f, 1.96521310e-03f,
  -1.94720775e-01f, 3.04392427e-02f, 1.82979673e-01f, -7.04975054e-02f, 2.45881125e-01f, 6.55907020e-02f, 1.90464519e-02f, -2.64320336e-02f, -8.62959772e-02f, -3.07922326e-02f,
  -6.46971688e-02f, 5.60395084e-02f, 8.51812363e-02f, -1.43700063e-01f, 2.31840108e-02f, 1.20635465e-01f, -8.90815258e-02f, -2.04294160e-01f, -3.16411234e-03f, 1.47301173e-02f,
  4.96799611e-02f, -8.94623771e-02f, 7.04447404e-02f, -4.61514145e-02f, 5.43519817e-02f, 1.22188099e-01f, 3.68435606e-02f, -4.29045260e-02f, 5.60172508e-03f, -1.32296449e-02f,
  3.07371672e-02f, 8.30918401e-02f, 1.67251781e-01f, 4.18391377e-02f, -2.87599266e-02f, 5.48370406e-02f, -1.08763583e-01f, 3.94496247e-02f, 1.79922339e-02f, 7.35281548e-03f,
  3.90623137e-03f, 1.03375986e-01f, -1.02315702e-01f, -3.88732553e-02f, -6.94754571e-02f, 9.42173693e-03f, 1.49284810e-01f, -8.38170294e-03f, 5.26056588e-02f, -5.98820858e-02f,
  -8.14740211e-02f, -1.17893420e-01f, -1.46855205e-01f, -3.23279686e-02f, -1.25771612e-01f, 5.28543666e-02f, -7.38663599e-02f, 1.62138581e-01f, -7.12475628e-02f, 8.72760043e-02f,
  2.58483328e-02f, -1.03868403e-01f, 8.92207399e-02f, 1.38734933e-02f, -1.58452708e-02f, 1.15215458e-01f, -7.29166567e-02f, -5.26796356e-02f, -1.10868521e-01f, -3.91467549e-02f,
  -7.33745396e-02f, 3.43599878e-02f, -3.63337472e-02f, -3.08371079e-03f, 5.46759106e-02f, -1.32091388e-01f, -5.09573556e-02f, 2.47854143e-02f, -7.11104497e-02f, -1.26990199e-01f,
  -1.67049900e-01f, -1.72497347e-01f, -3.64286751e-01f, -3.57259274e-01f, 6.32418394e-02f, -4.83913720e-01f, -4.19787019e-01f, -1.29051685e-01f, 6.17988966e-02f, 1.51531979e-01f,
  -4.23773117e-02f, -1.30080864e-01f, 2.13410750e-01f, -4.49447900e-01f, -4.72332358e-01f, -2.89131310e-02f, -5.31753600e-01f, -3.78452569e-01f, -1.34129636e-03f, -2.69927502e-01f,
  -9.52110738e-02f, -1.43079370e-01f, -4.35428172e-01f, 2.30733871e-01f, -2.50024468e-01f, 4.32677642e-02f, 3.38217378e-01f, 1.35608464e-01f, -3.37259412e-01f, 4.55527976e-02f,
  -2.19584957e-01f, -1.40718566e-02f, -1.14491642e-01f, -9.75338146e-02f, -9.78011042e-02f, 5.23302555e-02f, -9.19367969e-02f, -3.79276387e-02f, -8.29648525e-02f, -6.83301967e-03f,
  8.34439099e-02f, 8.63944218e-02f, -4.18474674e-02f, 1.16999075e-01f, 1.44138783e-01f, -1.27253914e-02f, -8.21090341e-02f, -1.34197816e-01f, -1.00827821e-01f, -1.48763672e-01f,
  -3.37542117e-01f, -9.21675786e-02f, -1.76906828e-02f, -1.03061482e-01f, -1.33800395e-02f, 8.36552978e-02f, -1.33240938e-01f, -1.38313904e-01f, -1.32317364e-04f, -3.87336388e-02f,
  5.34380078e-02f, 5.14476076e-02f, 3.45861092e-02f, 1.00951888e-01f, -3.04179695e-02f, 3.90270613e-02f, 1.84804350e-02f, -1.55896116e-02f, 5.76311313e-02f, -2.46715490e-02f,
  1.83962539e-01f, -1.94073431e-02f, 1.16845459e-01f, -9.88790765e-02f, -1.20430179e-01f, 7.52672851e-02f, 4.93146814e-02f, -1.92299625e-03f, -1.74137369e-01f, -6.75951391e-02f,
  1.23330176e-01f, -9.18936431e-02f, 6.82637170e-02f, 7.40850046e-02f, -5.29172011e-02f, 8.05977508e-02f, 3.46933641e-02f, -4.49470356e-02f, 7.13477880e-02f, 1.12325919e-03f,
  -3.36718224e-02f, 3.74980643e-02f, 5.57264648e-02f, 1.35606796e-01f, 3.11894231e-02f, 6.50653243e-02f, -2.82772761e-02f, -1.59496918e-01f, -1.84993781e-02f, -3.53209265e-02f,
  -1.90328714e-02f, 3.79329023e-04f, 3.20204273e-02f, -1.80029031e-02f, 1.94897838e-02f, -1.62767041e-02f, 1.33996576e-01f, 1.02678262e-01f, 1.54328980e-02f, 5.50529920e-02f,
  4.40042326e-03f, 1.54673129e-01f, 7.13695437e-02f, 2.64344402e-02f, -8.75409693e-02f, 1.15611292e-01f, 2.10803617e-02f, 7.12387562e-02f, 6.53714165e-02f, -2.19571479e-02f,
  -2.61371732e-01f, -5.44373333e-01f, -3.38625669e-01f, 3.19454670e-02f, 5.66503704e-02f, -2.68710047e-01f, -4.19983298e-01f, -1.49503052e-01f, -2.87781239e-01f, -8.73457268e-02f,
  -1.26803160e-01f, -1.19687304e-01f, -4.95474100e-01f, -1.22818217e-01f, 1.64154973e-02f, -4.16718364e-01f, 8.93413723e-02f, -8.30866024e-02f, -7.46179298e-02f, -1.34772211e-01f,
  3.86619046e-02f, -8.41792077e-02f, -1.70584977e-01f, 1.38407499e-01f, -1.22156024e-01f, 2.49512583e-01f, 5.33907950e-01f, 1.05759883e-02f, 3.93592119e-01f, 2.26569306e-02f,
  -8.56281072e-02f, -1.32816955e-01f, -1.00407764e-01f, -5.08785918e-02f, 1.13386460e-01f, 9.20294300e-02f, 8.15955549e-02f, -1.15265697e-01f, 1.19537003e-01f, -5.35437427e-02f,
  9.16201770e-02f, 4.13789153e-02f, 7.01467246e-02f, 4.17879634e-02f, -8.14479738e-02f, 6.45435750e-02f, -7.13820606e-02f, -2.13274378e-02f, 5.23429550e-03f, -2.96426147e-01f,
  -2.25421995e-01f, -4.86563928e-02f, 8.95059258e-02f, 2.08077431e-01f, 8.22010338e-02f, -3.45364958e-02f, 4.36291136e-02f, -3.58991437e-02f, 1.43188447e-01f, -1.00999931e-03f,
  3.46988859e-03f, -2.41512023e-02f, -1.97442308e-01f, 1.08983275e-03f, -9.69198570e-02f, 1.10675283e-01f, 5.01783006e-02f, 3.22042443e-02f, 2.17161085e-02f, -1.48712676e-02f,
  4.18653898e-02f, 5.79035208e-02f, 1.39356218e-02f, -2.22408567e-02f, -8.55591223e-02f, 7.86872581e-02f, 6.25242069e-02f, 6.07478507e-02f, 6.46662042e-02f, -1.30258929e-02f,
  3.41607630e-02f, 1.12065615e-03f, -3.43685113e-02f, 1.17660969e-01f, -9.87064466e-02f, -6.86245933e-02f, 4.75160331e-02f, -6.19425289e-02f, -2.63017919e-02f, -1.17139108e-02f,
  7.08403289e-02f, 1.67705193e-02f, -3.45270522e-02f, 3.31519581e-02f, 1.37691656e-02f, -8.81222170e-03f, -2.30124481e-02f, -6.78669196e-04f, 5.25334589e-02f, -1.32726282e-01f,
  1.23972140e-01f, 1.29714966e-01f, 1.66352481e-01f, 6.01131879e-02f, 9.16334987e-02f, -6.38829097e-02f, -7.55577674e-03f, 1.83128417e-01f, 1.90689564e-01f, 1.88104346e-01f,
  6.93545714e-02f, 4.18131240e-02f, 6.42381907e-02f, 7.63190463e-02f, 8.30481127e-02f, 9.87389311e-02f, 1.26457006e-01f, -3.69692519e-02f, 1.23729736e-01f, 4.82270755e-02f,
  3.14353585e-01f, -1.78406134e-01f, -1.04493350e-02f, 2.29549870e-01f, 1.83723625e-02f, -4.57440704e-01f, -6.53978288e-01f, 1.25687076e-02f, -7.16136098e-02f, -4.84265566e-01f,
  -1.36359468e-01f, -2.63869595e-02f, -2.50836074e-01f, 2.56015241e-01f, 4.43229049e-01f, 8.25411528e-02f, 1.23495072e-01f, -9.03225094e-02f, 1.27673000e-01f, 2.08491281e-01f,
  3.38863105e-01f, 4.06888902e-01f, 3.60439122e-01f, 3.23674172e-01f, 4.57909293e-02f, 2.88181424e-01f, 4.37360525e-01f, -1.63053691e-01f, 1.15600295e-01f, 6.41578063e-02f,
  -3.34887393e-02f, 1.05398476e-01f, 4.69135083e-02f, -3.34253758e-02f, 9.66263637e-02f, -1.74450532e-01f, -1.06167570e-01f, -2.44793110e-02f, 7.42131472e-02f, -9.03908983e-02f,
  2.36157533e-02f, 1.31039336e-01f, 5.87436631e-02f, 3.20817754e-02f, -9.69863534e-02f, 1.16854995e-01f, 6.41336888e-02f, 1.08346306e-02f, -6.02429807e-02f, -1.08088022e-02f,
  -5.08625945e-03f, -5.18639944e-02f, 2.10916027e-02f, 6.76524416e-02f, 5.64224012e-02f, -7.70659419e-03f, 3.48800328e-03f, -7.79689774e-02f, -8.25227574e-02f, 4.54882756e-02f,
  7.19621181e-02f, -1.17778882e-01f, -4.79103327e-02f, -1.22527398e-01f, -1.06555499e-01f, 6.28601015e-02f, -7.50964284e-02f, -3.06458138e-02f, -5.91398031e-02f, -3.45917605e-02f,
  -2.98733581e-02f, 8.34011734e-02f, 1.61745679e-02f, -2.16151834e-01f, 1.74023539e-01f, 9.38023850e-02f, 2.35510506e-02f, -1.00324281e-01f, -6.01550005e-02f, -1.45101938e-02f,
  9.48376507e-02f, 4.23796698e-02f, -9.38810036e-02f, -4.34055440e-02f, -8.83031860e-02f, -1.06988503e-02f, 4.29414771e-02f, -1.14687167e-01f, 3.83542408e-03f, 4.90060896e-02f,
  3.10466047e-02f, 1.42755255e-01f, -1.07251465e-01f, -8.89561474e-02f, 7.70738721e-02f, 4.29629236e-02f, 8.38612318e-02f, -1.77823231e-02f, -8.84595886e-03f, -2.54803356e-02f,
  1.15311958e-01f, -4.01181467e-02f, -6.25880584e-02f, 4.83573861e-02f, -3.16727571e-02f, -4.93658967e-02f, -3.77302431e-02f, 9.53902379e-02f, 8.92727226e-02f, 1.80395037e-01f,
  6.49833009e-02f, -1.25687063e-01f, 9.05810669e-02f, -2.93768588e-02f, -4.85637933e-02f, 2.06134450e-02f, -7.38801807e-02f, 2.53192037e-02f, 6.80449456e-02f, 5.52150831e-02f,
  3.40134203e-01f, -4.05453682e-01f, -1.79248556e-01f, -8.28462094e-02f, -7.52905756e-02f, -2.56123573e-01f, -1.07599348e-01f, -5.17814100e-01f, -1.75126702e-01f, -3.40369076e-01f,
  -1.69946194e-01f, 3.25253487e-01f, 4.15133417e-01f, -4.39105451e-01f, 4.65435863e-01f, 4.13169026e-01f, -4.11046594e-01f, -2.98709590e-02f, -1.27782345e-01f, -1.61121473e-01f,
  -6.47111088e-02f, -2.16884315e-01f, 2.03876458e-02f, -4.13738579e-01f, -2.59749174e-01f, -2.79275805e-01f, 1.68823913e-01f, 2.35142224e-02f, -3.56247127e-01f, 1.22221187e-01f,
  -2.14757442e-01f, -6.88564703e-02f, -5.33707626e-02f, -8.63165930e-02f, -8.02068338e-02f, 8.23918059e-02f, 2.22211912e-01f, 2.21695647e-01f, 8.70485976e-02f, -5.54917976e-02f,
  1.11689650e-01f, 5.24100810e-02f, -2.10765272e-01f, 9.96614099e-02f, -1.09881252e-01f, -2.68801898e-01f, -1.40429795e-01f, -7.13362023e-02f, -5.40830120e-02f, -9.18025225e-02f,
  -4.68582362e-02f, -3.34663838e-02f, -2.87045278e-02f, -2.92300410e-03f, 1.37389705e-01f, -1.03860684e-01f, 3.25144418e-02f, 2.03535900e-01f, 4.18072417e-02f, -4.20279689e-02f,
  -4.15996537e-02f, 1.54626250e-01f, 6.81859851e-02f, -5.08723520e-02f, -9.94728580e-02f, -1.14309020e-01f, -2.49402644e-03f, 3.29338983e-02f, 8.20209607e-02f, -8.48865602e-03f,
  -5.30483685e-02f, 3.27647328e-02f, -1.12528786e-01f, 4.79681790e-02f, -6.00122139e-02f, 5.14532924e-02f, 6.53601484e-03f, -1.03054464e-01f, -8.34542513e-02f, -2.06199382e-02f,
  3.06725129e-02f, -1.33922487e-01f, -3.36316079e-02f, 5.40773496e-02f, -8.55624303e-02f, 1.55738652e-01f, -1.05689988e-01f, -3.64074856e-02f, -5.41338101e-02f, 1.28301039e-01f,
  -1.26386747e-01f, -1.50683865e-01f, -6.08355813e-02f, -8.43436867e-02f, -4.30797264e-02f, -1.69013068e-01f, 8.22247490e-02f, -6.97188228e-02f, -8.28465819e-02f, -2.77963299e-02f,
  -2.22893521e-01f, 9.38628018e-02f, -1.03710376e-01f, 6.16190955e-02f, 5.90005070e-02f, -2.09426001e-01f, 1.50616392e-01f, 1.72081348e-02f, 3.39339413e-02f, -1.23546794e-01f,
  2.04116851e-02f, 7.19147502e-03f, 1.27327293e-01f, -4.34229672e-02f, -4.60673682e-03f, 9.41254199e-02f, -3.31000052e-02f, -1.44268228e-02f, 7.79686347e-02f, -2.16056406e-02f,
  -1.56941473e-01f, 4.66363698e-01f, 4.31315571e-01f, 2.11537540e-01f, -3.32419157e-01f, -2.09215388e-01f, 4.09513384e-01f, -1.67773917e-01f, -8.42113718e-02f, 3.72510761e-01f,
  1.55662239e-01f, 3.83634508e-01f, 1.83292925e-01f, 3.68730485e-01f, -5.90161920e-01f, -4.62705679e-02f, -7.87426233e-02f, 3.20168555e-01f, -1.47518456e-01f, -5.84787503e-02f,
  -2.36774683e-01f, -3.75627279e-01f, 1.48077488e-01f, -4.17811930e-01f, 2.91813016e-01f, 9.57110822e-02f, -1.80638447e-01f, -3.55025232e-02f, 8.54904056e-02f, 6.95276111e-02f,
  -2.13528693e-01f, -1.06101640e-01f, 1.76729828e-01f, 6.36712909e-02f, -6.28423244e-02f, 1.20575607e-01f, 1.45577028e-01f, 9.55279917e-02f, -1.84477475e-02f, -4.74440232e-02f,
  1.04115687e-01f, -9.83972624e-02f, -2.22802237e-02f, -9.00662318e-02f, -1.02000237e-02f, 5.50060049e-02f, 1.30537316e-01f, 1.65522397e-01f, 1.06707387e-01f, 1.60498753e-01f,
  2.15540111e-01f, 1.47164837e-01f, 1.01122119e-01f, 1.00138344e-01f, 2.81714387e-02f, 4.06814031e-02f, 8.23014379e-02f, 7.55111054e-02f, 7.26203248e-02f, -1.31955087e-01f,
  -1.03770941e-01f, -1.32180229e-01f, 9.13904011e-02f, 9.74719077e-02f, 1.75909288e-02f, 8.92008692e-02f, 8.02511647e-02f, -4.29438464e-02f, 1.19834263e-02f, 3.62368114e-02f,
  -1.22630790e-01f, 4.18491997e-02f, -2.10066959e-01f, -1.37459589e-02f, 2.28806362e-02f, -1.51243398e-03f, 5.78037426e-02f, -2.51553189e-02f, -8.86026025e-02f, 1.12230452e-02f,
  -1.06410729e-03f, -6.81260005e-02f, 1.15617059e-01f, 5.29744290e-02f, -3.01611666e-02f, 5.02306931e-02f, -1.45051209e-02f, 6.40253127e-02f, -8.36858749e-02f, -1.62778020e-01f,
  -6.59044921e-01f, -5.51017821e-01f, 2.91621238e-02f, -2.77344827e-02f, -1.08504370e-02f, -8.36009830e-02f, 1.69059057e-02f, -6.48478931e-03f, -2.51083702e-01f, -1.96572125e-01f,
  -3.29566486e-02f, 7.44547695e-02f, -1.36509240e-01f, -1.12805022e-02f, -7.35794157e-02f, -9.54587534e-02f, -3.99321355e-02f, -9.72975120e-02f, -1.37106225e-01f, -1.40449386e-02f,
  -4.98842709e-02f, -3.76141071e-02f, 3.80233862e-02f, -2.16015615e-02f, -1.26562282e-01f, 1.13445474e-02f, -9.38735828e-02f, 1.07322015e-01f, -1.60888210e-01f, 2.16145124e-02f,
  -6.67240560e-01f, 5.30739784e-01f, 1.32637739e-01f, 3.61606628e-01f, -2.73997188e-01f, -4.22058284e-01f, -1.06981583e-01f, 8.90926421e-02f, 2.13931993e-01f, 3.93922806e-01f,
  4.11559880e-01f, -7.41111487e-02f, 3.77199531e-01f, 4.44576502e-01f, 2.27213986e-02f, 3.85506541e-01f, 1.30540654e-01f, -4.51944768e-02f, 1.41546711e-01f, 1.73001662e-01f,
  -8.67949857e-04f, 4.93545026e-01f, 2.08405763e-01f, 2.06330031e-01f, 2.46465392e-02f, 4.76823300e-02f, 1.53688371e-01f, 2.70923644e-01f, -5.83993234e-02f, 4.38782126e-02f,
  3.51776974e-03f, 3.78423393e-01f, -7.94166476e-02f, -2.80081015e-02f, -5.95608130e-02f, -3.06606889e-01f, -5.34521975e-02f, -7.68464953e-02f, 6.07930012e-02f, 4.63522114e-02f,
  -2.31945589e-02f, -9.10864584e-03f, -7.17941597e-02f, 2.29465328e-02f, -7.66830966e-02f, 2.36819480e-02f, -5.38780354e-02f, -1.01906948e-01f, 3.53007913e-02f, -4.59481664e-02f,
  8.21776837e-02f, 9.58346277e-02f, -8.52487236e-02f, 4.21478152e-02f, 6.73012255e-05f, -4.73510697e-02f, -8.22477490e-02f, -8.90074819e-02f, 9.26950127e-02f, -2.83913165e-02f,
  -6.16800645e-03f, -5.52213602e-02f, 5.14775142e-03f, 3.16026919e-02f, 9.07390639e-02f, 1.96672603e-02f, 6.03387989e-02f, 5.38245169e-03f, -2.84427833e-02f, -5.55864796e-02f,
  -1.07648827e-01f, 2.25618714e-03f, -5.10295369e-02f, -1.39717460e-02f, 2.58513261e-02f, 1.14269271e-01f, -6.34682178e-03f, 5.70785068e-03f, -1.88303422e-02f, 4.66834661e-03f,
  1.62621617e-01f, -1.76942497e-02f, 1.31932095e-01f, -7.23590925e-02f, -1.14395171e-02f, 1.62652731e-01f, 8.77100378e-02f, 7.34437406e-02f, 6.59943074e-02f, -1.26144901e-01f,
  1.14946559e-01f, 2.81719416e-01f, 2.11820398e-02f, -5.09282425e-02f, 1.35987476e-01f, -9.19880643e-02f, -1.91725641e-02f, -1.02297515e-01f, 6.24047359e-03f, -9.94317420e-03f,
  -3.49052101e-02f, -8.35981369e-02f, -1.97481483e-01f, 1.86648369e-02f, -1.63801201e-02f, 1.66703537e-02f, 6.80082813e-02f, 6.20940998e-02f, 4.23952229e-02f, -4.70160693e-02f,
  3.91507223e-02f, 4.69419025e-02f, -6.42559454e-02f, 3.53344828e-02f, -1.33110747e-01f, -1.10306693e-02f, -2.05238521e-01f, -8.89666472e-03f, 3.19384336e-02f, 3.79123837e-02f,
  7.80583620e-01f, -6.74113929e-01f, 6.61499947e-02f, 2.27670312e-01f, 5.68552554e-01f, 2.22551644e-01f, 4.19478536e-01f, -7.87013322e-02f, 1.00413166e-01f, -4.49776858e-01f,
  1.33570433e-01f, -2.45303020e-01f, 1.04440026e-01f, -6.97914734e-02f, 4.75237042e-01f, 6.04722090e-02f, 1.44960076e-01f, -1.29889427e-02f, 1.41546071e-01f, 1.57941058e-01f,
  2.99321711e-01f, 8.84127021e-02f, 2.66052932e-01f, -2.01173693e-01f, 3.79067570e-01f, -2.16789141e-01f, -1.46166846e-01f, 1.53253719e-01f, -3.34725112e-01f, 1.69383422e-01f,
  1.37241974e-01f, 7.89963603e-02f, 1.37577042e-01f, -1.81304708e-01f, 1.58169195e-01f, 1.59773618e-01f, -7.76773915e-02f, 1.21254407e-01f, 8.74553695e-02f, -4.99651907e-03f,
  3.73019278e-02f, -4.94147055e-02f, -7.71786571e-02f, -1.73409004e-02f, -2.62652431e-02f, -1.22614995e-01f, 2.56933160e-02f, 7.98993409e-02f, 1.75704621e-03f, 8.46538469e-02f,
  1.61285281e-01f, -1.27137452e-01f, -4.00973894e-02f, -1.14709273e-01f, 3.52811553e-02f, -2.04305109e-02f, 3.24479230e-02f, -2.92787999e-02f, -1.82592109e-01f, 5.74803874e-02f,
  -6.12826273e-02f, -8.11829511e-03f, -2.28474643e-02f, -3.87262851e-02f, 1.13895588e-01f, -9.44238901e-02f, -6.53585270e-02f, -1.23346098e-01f, 5.44714816e-02f, -7.92478211e-03f,
  5.33942766e-02f, 5.49183451e-02f, -1.02873088e-03f, -3.55838239e-02f, 1.48789138e-01f, -9.88777913e-03f, 8.84142742e-02f, -2.82871258e-02f, 1.14941135e-01f, 3.07079894e-03f,
  -1.48002505e-01f, -6.80176243e-02f, 5.81219047e-02f, -2.43515298e-02f, -5.63487001e-02f, -3.64501849e-02f, -1.59738883e-01f, 2.98861191e-02f, -3.57015664e-03f, 7.52203390e-02f,
  -2.11964473e-01f, -6.96990430e-01f, -3.29730995e-02f, -1.33281514e-01f, -3.37343477e-02f, 1.06644683e-01f, -4.10454832e-02f, -2.71566883e-02f, -4.72257696e-02f, 7.36848339e-02f,
  -4.83006611e-02f, 3.68563123e-02f, -5.02085835e-02f, 7.38408417e-02f, -7.53919631e-02f, -1.75807513e-02f, -3.63164651e-03f, -1.56539008e-01f, 7.77582675e-02f, -2.28559941e-01f,
  -2.68195346e-02f, -5.19647896e-02f, 8.21823925e-02f, 3.09485048e-02f, -9.44515988e-02f, -8.45233575e-02f, -2.79503707e-02f, -5.94236553e-02f, -5.15185483e-02f, -7.15304986e-02f,
  -3.64403576e-01f, 3.80676895e-01f, 1.04484469e-01f, -3.76689762e-01f, -1.43493349e-02f, -2.93741286e-01f, -2.97467411e-01f, 2.60612275e-02f, -6.91760983e-03f, 1.04364522e-01f,
  -2.37548165e-02f, 2.33969927e-01f, 1.58863783e-01f, -7.80366808e-02f, -4.14439768e-01f, 5.47216423e-02f, -3.46362025e-01f, -3.21133465e-01f, -4.25473452e-02f, -2.27536276e-01f,
  -2.37708300e-01f, -2.56128401e-01f, -1.09005742e-01f, 2.37157539e-01f, -3.25273573e-02f, 5.85451797e-02f, -2.02377126e-01f, 1.85908750e-01f, -3.33558880e-02f, 2.05032095e-01f,
  -3.42559427e-01f, -1.68092415e-01f, -2.46952754e-02f, -1.47245571e-01f, -2.69517988e-01f, -1.45878330e-01f, -1.70856833e-01f, -1.40685700e-02f, -9.19235349e-02f, -1.30322695e-01f,
  -5.04681580e-02f, 3.37984674e-02f, 8.36739317e-02f, -2.50656460e-03f, -4.52446267e-02f, 1.52491793e-01f, 1.46817163e-01f, 7.90092051e-02f, 1.66567415e-01f, 1.61709581e-02f,
  1.08823672e-01f, 3.06393225e-02f, -2.04052385e-02f, 6.07270040e-02f, 2.39950977e-02f, -4.96480986e-02f, -1.14833660e-01f, 1.04411773e-01f, -2.02187747e-02f, 1.49246966e-02f,
  4.36209477e-02f, -1.00553252e-01f, -6.68695616e-03f, 1.17330879e-01f, -4.32584323e-02f, 2.34638646e-01f, 2.95760185e-02f, 3.46863084e-02f, 6.58410192e-02f, -7.53503144e-02f,
  1.14389230e-02f, 5.77628613e-02f, -1.13699567e-02f, -7.71400332e-02f, -3.68631594e-02f, -9.36168060e-02f, -4.26641330e-02f, 9.42391604e-02f, 1.22495025e-01f, -1.12999320e-01f,
  -1.37475133e-01f, -9.74032059e-02f, 1.05089135e-01f, 5.08652925e-02f, -1.66360185e-01f, -5.35178334e-02f, 1.09344600e-02f, 1.13825604e-01f, -1.08079985e-01f, -7.17548877e-02f,
  -4.44606960e-01f, -4.63050008e-01f, -2.72218406e-01f, -6.21777289e-02f, -1.50314823e-01f, -1.34221122e-01f, -2.24144310e-01f, -6.03288785e-02f, -2.17495635e-01f, -5.51225021e-02f,
  -5.75709268e-02f, -1.16249472e-01f, -1.10413253e-01f, -7.54498020e-02f, -5.06346598e-02f, -9.82548296e-02f, -2.48904422e-01f, -8.60566795e-02f, -1.52190536e-01f, 3.12312674e-02f,
  1.02868959e-01f, 3.91207961e-03f, 9.02819112e-02f, 1.37521531e-02f, -1.35905400e-01f, 9.36375652e-03f, -6.78472295e-02f, -3.11203022e-02f, -1.05318300e-01f, 1.22172184e-01f,
  1.78600162e-01f, 3.10280114e-01f, -3.23072463e-01f, 6.84075803e-02f, -2.38480389e-01f, 3.12352568e-01f, 1.27470434e-01f, 1.92522332e-02f, -7.57164285e-02f, 5.05031765e-01f,
  1.05041087e-01f, 2.48550214e-02f, 1.12625763e-01f, 3.09494376e-01f, 2.77878255e-01f, 3.47639471e-01f, 5.03569424e-01f, 2.46238679e-01f, -1.02025323e-01f, 3.44632894e-01f,
  1.59074709e-01f, 4.83575523e-01f, -1.98006615e-01f, 1.41496882e-01f, -2.99667791e-02f, -2.17378870e-01f, 3.20481025e-02f, -3.72142434e-01f, 8.79876018e-02f, -2.16357559e-02f,
  -2.56065354e-02f, 1.18831441e-01f, -2.87092328e-02f, -2.84761433e-02f, 1.72587596e-02f, -2.61687413e-02f, -5.89020737e-02f, -1.08291693e-01f, -1.56469271e-01f, -4.39142510e-02f,
  6.35032728e-02f, -1.09149806e-01f, 2.13149533e-01f, -6.19031079e-02f, -1.01511501e-01f, -8.23518410e-02f, -5.37121901e-03f, -1.70521200e-01f, -2.19343533e-03f, 5.47386147e-02f,
  -2.39384510e-02f, 3.72863598e-02f, -2.27601584e-02f, 2.04785988e-02f, -1.14430524e-02f, 1.05781421e-01f, 7.58204237e-02f, -1.09023467e-01f, 5.69334887e-02f, 1.14715740e-01f,
  5.44439405e-02f, 4.62285392e-02f, 1.05215795e-01f, -8.90039206e-02f, 1.91094894e-02f, -6.97517246e-02f, -1.66199300e-02f, -9.12633911e-02f, -5.18719181e-02f, 1.10791713e-01f,
  -1.78939272e-02f, -1.10475607e-01f, 3.06995511e-02f, 1.44639850e-01f, 1.58589229e-01f, -1.09564349e-01f, -1.33955374e-01f, 7.01622516e-02f, -1.15243311e-03f, -8.04225504e-02f,
  2.87688673e-02f, 6.40896261e-02f, -5.98495118e-02f, -8.00923780e-02f, 2.83386651e-02f, -4.32265177e-02f, 1.16193943e-01f, -2.64367554e-02f, -8.88339952e-02f, -3.94250415e-02f,
  1.56676650e-01f, 3.41948152e-01f, -6.15948923e-02f, -5.60185090e-02f, 9.11418721e-02f, 1.31564558e-01f, 3.34301852e-02f, -1.05394376e-02f, 8.21242183e-02f, 9.18058902e-02f,
  2.07114518e-01f, 3.34710139e-03f, 1.51836723e-01f, 1.63595565e-02f, -1.18260477e-02f, 1.77684188e-01f, 1.34303778e-01f, 6.03824817e-02f, 2.42081378e-02f, 4.64258790e-02f,
  3.20951827e-02f, 1.06579468e-01f, 6.39979020e-02f, -4.54347162e-03f, 4.18071672e-02f, 7.92945176e-02f, 9.44674164e-02f, -3.86416502e-02f, 3.90606411e-02f, 3.65886241e-02f,
  -1.17172971e-01f, 2.03703657e-01f, -4.34013642e-02f, 4.73954618e-01f, -2.48755157e-01f, -3.54135185e-01f, -2.18672991e-01f, 5.45234866e-02f, -1.39439940e-01f, 1.75771594e-01f,
  2.52519339e-01f, -1.26720101e-01f, 3.16973776e-02f, 6.04810596e-01f, -2.01076820e-01f, 3.15377295e-01f, 2.93824822e-01f, 4.16298509e-02f, -2.31234193e-01f, 2.00228319e-01f,
  6.53869733e-02f, 4.12350595e-01f, 3.72193098e-01f, 9.56325457e-02f, 9.12268013e-02f, 5.08774295e-02f, 4.05529775e-02f, 3.25547042e-03f, 1.72901377e-01f, -1.15851618e-01f,
  2.07758635e-01f, 1.19581051e-01f, 8.28677043e-02f, 3.92340124e-03f, -4.23838608e-02f, 9.92094129e-02f, 7.45693892e-02f, -1.00578159e-01f, -1.13233022e-01f, -4.37113829e-03f,
  -1.21433534e-01f, -8.96984264e-02f, 2.40032747e-02f, -1.70179233e-02f, 1.65718328e-02f, -2.21384615e-02f, -3.62014621e-02f, -1.20364122e-01f, 3.32143568e-02f, 1.98746342e-02f,
  5.74135631e-02f, 1.23606078e-01f, -1.57356486e-01f, 1.54330218e-02f, -9.81785282e-02f, -1.26948059e-01f, -2.58840322e-02f, 1.71292461e-02f, -4.84675579e-02f, -3.80226411e-02f,
  -6.88776523e-02f, -5.61887678e-03f, 3.57443094e-02f, 7.03269541e-02f, -3.55096944e-02f, 3.64014693e-02f, 2.76393723e-02f, -4.60162666e-03f, -9.59849432e-02f, 5.13757467e-02f,
  1.40673712e-01f, -1.36271352e-02f, -2.11382695e-02f, -1.42358840e-01f, -4.99064587e-02f, -8.28946233e-02f, -1.16053484e-01f, 1.64837629e-01f, 1.03923064e-02f, 1.20441452e-01f,
  -6.30107746e-02f, -1.33052886e-01f, 3.29402164e-02f, 1.83447730e-02f, 1.35263577e-01f, -7.64868557e-02f, 2.16385752e-01f, 7.91748762e-02f, 3.08700036e-02f, -6.25701249e-02f,
  1.00451842e-01f, 1.08095378e-01f, 6.41816407e-02f, -6.04947880e-02f, 2.78080646e-02f, 6.04947209e-02f, 9.36636999e-02f, 9.84478518e-02f, -1.05220765e-01f, -1.65557206e-01f,
  -6.55340478e-02f, -1.86422244e-01f, -1.04514375e-01f, 1.13624372e-02f, 6.84021264e-02f, -5.03560677e-02f, -6.67551905e-02f, -1.12821557e-01f, -4.28694347e-03f, 7.64892772e-02f,
  3.63115333e-02f, -7.45194480e-02f, 6.84956312e-02f, -1.18906394e-01f, 1.27048954e-01f, 1.70038883e-02f, 3.25176455e-02f, -8.60289019e-03f, 1.73300266e-01f, 2.26050932e-02f,
  2.33215362e-01f, -3.41983169e-01f, 4.68222052e-01f, 8.94495398e-02f, 3.81570876e-01f, 5.83770096e-01f, 3.97913843e-01f, 1.42830566e-01f, 5.14951944e-01f, -4.17986482e-01f,
  -3.97088021e-01f, -1.58795759e-01f, 1.32317260e-01f, -2.51542091e-01f, 6.18354559e-01f, 3.10827941e-01f, 4.46641520e-02f, -5.94833307e-02f, -1.52944736e-02f, -6.29489124e-02f,
  7.51443207e-02f, -3.61717969e-01f, -1.00784346e-01f, -4.59127814e-01f, -4.25945431e-01f, -2.98711866e-01f, -6.00423634e-01f, 2.63353020e-01f, -4.17036146e-01f, 1.65293559e-01f,
  4.78902049e-02f, -9.65153873e-02f, -4.76556532e-02f, 3.01774032e-02f, 8.17010626e-02f, 1.79675277e-02f, 9.61299464e-02f, 1.85818687e-01f, 5.42300567e-03f, 1.37473177e-02f,
  -8.51715729e-02f, -2.83153374e-02f, -1.92235962e-01f, 7.29017854e-02f, 1.25642762e-01f, -1.04689643e-01f, 3.02280840e-02f, -5.98779060e-02f, 1.00722209e-01f, 1.23099647e-01f,
  4.93706949e-02f, 7.42956921e-02f, 1.19360082e-01f, -1.97154760e-01f, -1.35168359e-02f, -1.22349001e-02f, -4.36869860e-02f, 2.23028157e-02f, 1.02980860e-01f, 8.03855732e-02f,
  -8.41731858e-03f, 8.49659741e-02f, 5.08448407e-02f, 5.20018265e-02f, -2.02388354e-02f, 4.80946302e-02f, -2.26349700e-02f, -1.37358293e-01f, 4.74341922e-02f, 3.30873430e-02f,
  -5.23280771e-03f, -4.75236364e-02f, 1.02734447e-01f, 1.42855957e-01f, -1.51156768e-01f, -1.03605613e-01f, -1.29978552e-01f, -1.54327884e-01f, 2.53113415e-02f, 1.27464965e-01f,
  -3.07310931e-02f, 1.49627790e-01f, -1.96180850e-01f, -4.83114012e-02f, 2.72000208e-02f, 2.30541267e-02f, -8.42394829e-02f, -2.69983262e-02f, -6.63665906e-02f, -2.41120066e-02f,
  -2.13123066e-03f, -2.61136055e-01f, -1.73372194e-01f, -2.23390326e-01f, -1.68459415e-01f, -2.38801152e-01f, 7.92304426e-02f, -7.76456594e-02f, 8.04560333e-02f, -1.56007092e-02f,
  3.14360633e-02f, -2.02145964e-01f, 2.44923476e-02f, -1.54696275e-02f, 1.36366129e-01f, -1.69474781e-01f, -1.36073202e-01f, -1.42713189e-01f, 1.56734407e-01f, -1.60773229e-02f,
  -4.05251607e-02f, -1.28354877e-01f, 2.22806893e-02f, -1.57251701e-01f, -2.90899932e-01f, 9.60991532e-02f, -1.42913401e-01f, -4.17829230e-02f, 3.18329558e-02f, 1.01347648e-01f,
  -6.45418644e-01f, -3.65316719e-02f, -3.14161181e-01f, -1.33819163e-01f, -4.47184481e-02f, 3.42383444e-01f, -2.66831845e-01f, -6.29304424e-02f, -4.53386962e-01f, -2.84375120e-02f,
  7.78193120e-03f, -2.09554479e-01f, -2.10014850e-01f, 4.93487567e-01f, 2.51534253e-01f, 3.89892220e-01f, 4.48137224e-01f, 1.86011449e-01f, 3.97771418e-01f, -5.49612865e-02f,
  2.87502825e-01f, 6.03872716e-01f, 3.29188824e-01f, 4.82542336e-01f, 2.25791857e-01f, 9.13626477e-02f, 1.57438695e-01f, -6.66759312e-02f, 2.27143228e-01f, 5.66006787e-02f,
  7.93752149e-02f, -2.71081388e-01f, -7.98695385e-02f, -4.16528657e-02f, -1.23512596e-01f, -1.26384422e-01f, 4.65817808e-04f, -1.52735843e-03f, -1.03599139e-01f, 1.11537529e-02f,
  -1.56880409e-01f, 1.23121522e-01f, 1.59199163e-01f, -3.14261019e-02f, -7.77608948e-04f, -5.96431419e-02f, 1.52630895e-01f, 3.35859843e-02f, 1.17510287e-02f, 1.69728979e-01f,
  -1.91647951e-02f, 1.44153580e-01f, 1.35048563e-02f, 6.59226105e-02f, 6.53276313e-03f, -2.89396383e-02f, -3.14953774e-02f, -1.45154700e-01f, 5.51345386e-02f, -9.23071355e-02f,
  -4.78719212e-02f, -3.19665410e-02f, 9.44089741e-02f, 5.31818084e-02f, -6.73999414e-02f, -3.58800255e-02f, 6.10908866e-02f, 5.86260520e-02f, -6.57871179e-03f, 2.48870775e-02f,
  -1.38953449e-02f, -4.98279966e-02f, -9.65923294e-02f, 4.06102883e-03f, 1.33623334e-03f, 4.56615491e-03f, -8.54976382e-03f, -4.65781502e-02f, 4.96065095e-02f, 1.46956980e-01f,
  -4.11594398e-02f, -5.96985333e-02f, -1.10095635e-01f, 1.12716839e-01f, 3.91846336e-02f, -1.25027016e-01f, 5.64108416e-03f, 4.53725420e-02f, -1.95251976e-03f, 2.99936663e-02f,
  -1.18770577e-01f, -4.87745523e-01f, -5.14410660e-02f, -7.14635402e-02f, -2.17064284e-02f, 1.57969594e-02f, 2.18939912e-02f, 1.18217178e-01f, 7.67954737e-02f, -1.68806598e-01f,
  -8.33209530e-02f, -1.14472909e-03f, -3.89247201e-02f, -2.35196222e-02f, 3.19260247e-02f, -1.67168215e-01f, -1.07336640e-01f, -9.58775654e-02f, -5.70315309e-02f, 3.46694738e-02f,
  -1.90001622e-01f, -1.28522843e-01f, 8.04704428e-02f, 1.72790334e-01f, 3.21737975e-02f, -9.91516709e-02f, -8.34365115e-02f, -4.65919375e-02f, 1.71686888e-01f, 4.78426889e-02f,
  2.12164253e-01f, 3.28431636e-01f, 4.48517241e-02f, -8.44788626e-02f, -2.58807242e-01f, 4.16109294e-01f, 1.00370876e-01f, -2.44603045e-02f, 2.42739484e-01f, 3.94401073e-01f,
  -1.30764157e-01f, 3.24991167e-01f, -1.87724054e-01f, 1.68328226e-01f, -2.38867458e-02f, 2.49821663e-01f, 3.34392846e-01f, 1.82061434e-01f, -2.64943819e-02f, 2.74543501e-02f,
  -8.10267478e-02f, -7.50205740e-02f, -3.78225029e-01f, -1.56235769e-01f, 2.67302841e-02f, -1.61345407e-01f, -4.06046242e-01f, -1.59581184e-01f, 3.69988084e-02f, -5.90543821e-03f,
  1.13098904e-01f, -5.64130209e-02f, 1.44139584e-02f, 1.91933110e-01f, 1.78282797e-01f, 1.29508853e-01f, 5.81534393e-02f, 9.17861760e-02f, -7.57677183e-02f, 3.64436433e-02f,
  1.37903064e-01f, -9.20499638e-02f, 2.00586215e-01f, -7.42530301e-02f, 2.82382704e-02f, 6.14640638e-02f, -1.09198071e-01f, 6.92540035e-02f, 4.97362167e-02f, -6.60681650e-02f,
  1.49598867e-01f, -2.93667614e-02f, -1.85847692e-02f, 1.41375810e-01f, -8.24608356e-02f, -1.02934405e-01f, 1.22450152e-02f, 1.19375691e-01f, 9.04377848e-02f, 1.18579514e-01f,
  4.25987020e-02f, 1.65303066e-01f, 6.09638207e-02f, -1.87211912e-02f, 7.19464794e-02f, -1.27404660e-01f, -6.31340519e-02f, -1.12568505e-01f, -1.35178536e-01f, -6.23795688e-02f,
  -1.02204585e-03f, -1.94037735e-01f, 2.94302404e-02f, 4.08398919e-02f, 8.63657743e-02f, 1.35198042e-01f, 3.52706611e-02f, 4.12548631e-02f, -3.91188525e-02f, -2.67097317e-02f,
  -1.46523342e-01f, -7.63389021e-02f, 3.05795651e-02f, -7.15286210e-02f, 3.22014354e-02f, -1.70030653e-01f, 3.77376899e-02f, -3.07345390e-02f, -2.88477819e-02f, -1.29530966e-01f,
  1.02668129e-01f, 3.64934057e-01f, 6.17514066e-02f, 8.38472098e-02f, 1.46546200e-01f, 1.65585145e-01f, 1.54745474e-01f, 1.86241060e-01f, 3.60747054e-02f, 6.28056377e-02f,
  -4.62556705e-02f, -3.80652994e-02f, 1.22054070e-01f, -1.63635299e-01f, -1.20478518e-01f, 9.30772275e-02f, 4.78235669e-02f, -4.33733240e-02f, 1.45785725e-02f, -1.25707358e-01f,
  2.72195833e-03f, 1.61962137e-01f, -8.11911095e-03f, 3.07296570e-02f, -1.44438185e-02f, -5.65802678e-02f, 1.10919282e-01f, 7.40708923e-03f, -2.34162901e-02f, 1.25160933e-01f,
  3.79219681e-01f, 1.18603639e-01f, -3.10186204e-02f, 3.32622826e-01f, 1.95957571e-01f, -1.37815988e-02f, -1.70004889e-01f, 3.34770262e-01f, 2.08402827e-01f, -2.17780456e-01f,
  -7.30426684e-02f, 4.59793247e-02f, -4.17764813e-01f, 2.33836755e-01f, 4.09669638e-01f, -1.47290081e-01f, 5.77027321e-01f, 2.89196461e-01f, 2.84316957e-01f, 3.16503197e-01f,
  2.27868110e-01f, 4.24706697e-01f, 1.93281230e-02f, 2.42316842e-01f, 2.79105037e-01f, 7.92947114e-02f, 2.44555414e-01f, -1.31254047e-01f, 2.03773007e-01f, 2.37871990e-01f,
  -7.60889705e-03f, 5.77487648e-02f, -1.97742209e-02f, -6.10096864e-02f, -6.53418005e-02f, -1.67423353e-01f, -1.74514905e-01f, -9.49684530e-02f, 5.60049936e-02f, -6.22101612e-02f,
  -1.20665073e-01f, -1.03044435e-01f, 1.72845237e-02f, 1.36633059e-02f, 7.79769719e-02f, 1.04818856e-02f, 4.07192521e-02f, 6.75105862e-03f, 7.03420639e-02f, 6.89079165e-02f,
  -5.78384176e-02f, 3.80321220e-02f, 6.21917658e-02f, 1.01185098e-01f, 1.12735577e-01f, 1.38021797e-01f, -8.63950029e-02f, -9.69057344e-03f, 4.82131951e-02f, 1.41110688e-01f,
  9.72540304e-02f, -3.59576494e-02f, -9.12834629e-02f, -5.44989333e-02f, 2.23124036e-04f, 8.25144425e-02f, 5.27024642e-02f, -5.75158261e-02f, -8.73858035e-02f, 2.58293971e-02f,
  -2.80882977e-02f, 6.80374280e-02f, -1.88816395e-02f, -2.16126647e-02f, 1.64986216e-02f, 6.81030825e-02f, -5.50250299e-02f, 5.27234469e-03f, 3.20092365e-02f, 1.79621205e-02f,
  2.17206050e-02f, 1.49238408e-01f, -3.39303724e-02f, -6.11631125e-02f, 1.09079592e-02f, -1.20560229e-02f, -6.55700937e-02f, 1.99423125e-03f, -1.33403733e-01f, 5.92204854e-02f,
  1.78950727e-01f, 3.27207863e-01f, -3.74808423e-02f, -6.61936253e-02f, -3.37393396e-02f, 5.70475012e-02f, -5.75232171e-02f, 1.17129073e-01f, 2.19261497e-01f, -6.00616150e-02f,
  1.62036177e-02f, -1.32398099e-01f, -3.51623259e-02f, 3.61523405e-02f, 5.18914200e-02f, 6.25906810e-02f, -5.42126223e-02f, 1.23915426e-01f, 1.55706331e-01f, 4.29734476e-02f,
  -3.96907628e-02f, -1.16290197e-01f, 1.57158095e-02f, 1.25860795e-01f, 2.72536464e-02f, -2.58059353e-02f, 1.45257846e-01f, 4.47247624e-02f, -5.64288236e-02f, 5.41966036e-02f,
  5.04935980e-01f, 3.23009729e-01f, 4.74749386e-01f, 5.53825438e-01f, -7.50374496e-02f, -3.94211352e-01f, -2.27397919e-01f, 2.27851525e-01f, 4.69322741e-01f, -9.14542228e-02f,
  -3.51727247e-01f, 4.99496073e-01f, -3.19569260e-01f, 1.93040490e-01f, -3.08704525e-01f, -4.22797203e-01f, 4.90989871e-02f, -1.28780946e-01f, 1.88244715e-01f, 2.19119161e-01f,
  4.26156670e-01f, -3.24770600e-01f, 2.90957779e-01f, -1.87030360e-01f, 2.73367107e-01f, 2.38964066e-01f, -2.12608278e-01f, -2.06736714e-01f, 1.80415750e-01f, -3.51213515e-01f,
  7.10195899e-02f, 1.89683646e-01f, 1.80158138e-01f, 2.63521541e-02f, 1.37818366e-01f, 6.10887706e-02f, 7.70544112e-02f, -1.66539624e-01f, 9.30155441e-02f, 3.44279185e-02f,
  1.44545346e-01f, 9.22089163e-03f, 2.46137138e-02f, -9.00558755e-02f, 1.43306360e-01f, 1.95713654e-01f, 2.47141197e-01f, 2.91393042e-01f, 1.42473355e-01f, 1.84426218e-01f,
  2.68840283e-01f, 2.25856006e-01f, 1.63175315e-01f, -7.25007281e-02f, 2.02043533e-01f, 7.20993951e-02f, -4.55569774e-02f, 2.87231114e-02f, 5.79988174e-02f, 9.10347402e-02f,
  -2.93392781e-02f, 4.17587683e-02f, -8.31546113e-02f, -4.00938988e-02f, -2.70996690e-02f, -1.59258340e-02f, -1.40547017e-02f, -3.96176279e-02f, -4.59340326e-02f, -1.35368794e-01f,
  4.97574545e-02f, 2.61594653e-02f, -9.12268907e-02f, 6.77765682e-02f, -2.16222531e-03f, 1.65970415e-01f, -1.19449571e-01f, -7.89714903e-02f, 1.68096907e-02f, 2.45620497e-02f,
  -1.06393777e-01f, -1.55145898e-01f, -4.12845239e-02f, 3.35268155e-02f, -1.31405562e-01f, 3.65454778e-02f, 8.66158158e-02f, 1.85783774e-01f, 8.16047490e-02f, -1.08572654e-01f,
  -2.11438701e-01f, -1.16879813e-01f, 1.41267747e-01f, -8.28685090e-02f, 6.64403737e-02f, -1.87001936e-02f, -4.29748036e-02f, 1.67204998e-02f, 1.78986769e-02f, -6.98092505e-02f,
  1.75848752e-01f, 1.15198493e-01f, -8.80274549e-02f, -5.55795357e-02f, -1.72612816e-01f, 6.36779442e-02f, 2.89631970e-02f, -4.89881150e-02f, -3.07911430e-02f, -2.97776908e-02f,
  1.79093882e-01f, -7.00518563e-02f, 1.67384699e-01f, 1.92943558e-01f, 5.44408783e-02f, 8.93835351e-02f, 6.28247708e-02f, 1.28675237e-01f, -5.51102832e-02f, 1.05854152e-02f,
  -2.17270866e-01f, -2.45223612e-01f, -1.83713779e-01f, 3.10771585e-01f, -5.12973845e-01f, -2.02228084e-01f, 2.46651545e-01f, -3.44493002e-01f, 2.21690059e-01f, 1.91245809e-01f,
  2.87726969e-01f, -4.53651309e-01f, 2.12353691e-01f, 3.30246091e-01f, -2.62010276e-01f, 5.10650396e-01f, 2.72923142e-01f, 2.77224064e-01f, -5.64367063e-02f, -2.08563417e-01f,
  -2.00392023e-01f, -3.15452248e-01f, 1.18343458e-01f, -5.32450557e-01f, -2.37916008e-01f, -2.56613106e-01f, 2.06317455e-01f, -4.08762366e-01f, -6.72006980e-02f, -2.18304113e-01f,
  -2.50671327e-01f, -1.67622194e-01f, 4.94062761e-03f, -7.35734776e-02f, -7.43141049e-04f, -1.23600876e-02f, -2.02724487e-02f, -1.49287477e-01f, -1.13769159e-01f, -8.90022665e-02f,
  1.14904821e-01f, -2.00135753e-01f, -5.50761297e-02f, 2.52440460e-02f, -1.11381762e-01f, -1.78317383e-01f, 2.88511422e-02f, 1.88693151e-01f, -1.14343129e-01f, -1.41293943e-01f,
  5.23958616e-02f, 5.15266173e-02f, 2.12996155e-01f, 1.06205709e-01f, 6.47622161e-03f, 1.99169479e-02f, 8.81033093e-02f, -8.25802051e-03f, -4.81278338e-02f, -7.78957456e-02f,
  3.12071834e-02f, -1.57909766e-02f, 9.42423567e-03f, 7.16479076e-03f, 3.59605327e-02f, 1.32929757e-01f, -4.83870357e-02f, 5.45901656e-02f, -8.65774415e-03f, 5.20284139e-02f,
  4.45628576e-02f, -9.87915248e-02f, -2.50867158e-02f, 1.46873355e-01f, 7.12220892e-02f, 1.40406981e-01f, 1.55673185e-02f, -5.40874116e-02f, 1.13169067e-01f, -1.37412678e-02f,
  2.02294309e-02f, 2.37493291e-02f, 1.13939606e-01f, 6.07230365e-02f, 2.03278828e-02f, 2.13333573e-02f, 1.33861616e-01f, 6.23542294e-02f, 9.89876315e-02f, -1.40095666e-01f,
  -4.91561472e-01f, -4.79425073e-01f, -6.05919100e-02f, -1.39982969e-01f, -6.08747564e-02f, -6.69129863e-02f, -2.90923771e-02f, -1.37657300e-01f, -1.78314045e-01f, -6.76609576e-02f,
  -1.85317378e-02f, 1.92704096e-01f, -1.18866101e-01f, -3.21341902e-02f, -2.37920936e-02f, 4.08905931e-03f, 3.38161550e-02f, 1.15343947e-02f, -5.15198000e-02f, -9.95817482e-02f,
  1.01557337e-01f, -1.09513365e-01f, -4.93630841e-02f, 3.92087288e-02f, 3.70888263e-02f, -5.11534996e-02f, -2.21509740e-01f, -1.76756699e-02f, -6.44533485e-02f, 2.28337571e-02f,
  -9.44831312e-01f, 3.51504803e-01f, -4.83114064e-01f, -3.65895271e-01f, -2.37799212e-01f, -1.39760494e-01f, 2.08210498e-02f, 9.86538902e-02f, 2.42101625e-01f, 4.95569140e-01f,
  1.87269315e-01f, -4.42101173e-02f, 4.93611455e-01f, -1.60114169e-01f, -4.88891512e-01f, 2.78875649e-01f, -4.25234854e-01f, -2.40614899e-02f, -5.67979226e-03f, -4.14620899e-02f,
  -2.64513731e-01f, -1.59546901e-02f, -3.11074585e-01f, 2.74660230e-01f, -6.04807496e-01f, -3.46586645e-01f, -3.24587375e-01f, 8.34718272e-02f, -5.50583363e-01f, -1.18787229e-01f,
  -4.78409380e-01f, 2.70071346e-02f, -2.45061710e-01f, -1.63805872e-01f, -3.72648448e-01f, -1.88285857e-01f, -2.23993972e-01f, -4.24954742e-02f, -3.02579012e-02f, -1.27287805e-02f,
  -4.60238056e-03f, 4.05067988e-02f, -1.13919370e-01f, 1.67265669e-01f, 8.43905061e-02f, -7.72712305e-02f, -8.43295902e-02f, -1.81073233e-01f, -4.13481966e-02f, -1.24714307e-01f,
  -2.96015888e-02f, -5.03969267e-02f, -2.45625991e-02f, -1.30790830e-01f, -2.56575733e-01f, -2.90809628e-02f, -1.24098167e-01f, -2.30507240e-01f, -1.90714210e-01f, -8.45873877e-02f,
  8.68243277e-02f, 2.24593934e-03f, 6.45833556e-03f, 7.51646087e-02f, -5.36525995e-02f, -2.72401683e-02f, 1.27173096e-01f, 5.62611874e-03f, 1.12329639e-01f, 4.21493575e-02f,
  -1.36257438e-02f, 7.53299743e-02f, 5.85740097e-02f, -2.19010472e-01f, 8.22896659e-02f, 1.36063963e-01f, 4.06876318e-02f, -1.19744755e-01f, -1.95878465e-02f, -7.54237697e-02f,
  6.41524494e-02f, -5.43640926e-02f, -5.57970591e-02f, -1.21849580e-02f, 2.94871256e-02f, -1.97009146e-02f, -1.35417774e-01f, -9.24074650e-03f, 2.53706705e-02f, -1.06518321e-01f,
  -4.14383560e-01f, -4.22745831e-02f, 9.80160609e-02f, 1.33959338e-01f, 1.90912895e-02f, -1.00506097e-01f, 1.40162930e-03f, -1.47157580e-01f, 3.41367684e-02f, 5.74754179e-02f,
  -4.43591252e-02f, 1.21962070e-01f, -8.91840532e-02f, 6.35874346e-02f, 7.09519163e-02f, -2.10930333e-02f, 2.07281262e-02f, -1.01947859e-01f, -7.39066675e-02f, -2.35689119e-01f,
  -6.97514936e-02f, 1.32841602e-01f, 2.02873379e-01f, 1.20289223e-02f, 4.68238443e-02f, -1.07282825e-01f, -1.41836181e-02f, -1.10154890e-01f, -2.52553910e-01f, 5.53417131e-02f,
  -4.66926068e-01f, -6.07852340e-02f, -1.60735086e-01f, -5.13013840e-01f, 2.27422118e-01f, 3.63831013e-01f, -1.86729401e-01f, 3.06846470e-01f, -2.10769221e-01f, 3.40333313e-01f,
  3.04860502e-01f, -4.56128508e-01f, 1.63331002e-01f, -3.76433611e-01f, -4.07404900e-01f, -3.53801042e-01f, -4.07279164e-01f, -2.96875030e-01f, -1.38993487e-01f, -6.58959672e-02f,
  -3.09572786e-01f, -1.48691937e-01f, -4.44914281e-01f, 3.81603420e-01f, -9.43857878e-02f, -1.21728622e-03f, 2.20398977e-01f, 3.14772904e-01f, -1.23978272e-01f, -5.89314699e-02f,
  -1.24290258e-01f, 6.01120107e-02f, 3.18566561e-02f, 2.83444319e-02f, 5.47210872e-02f, 1.91366538e-01f, 6.47254987e-04f, 8.90546758e-03f, 3.97824198e-02f, -4.71375473e-02f,
  -1.29158407e-01f, 8.41263011e-02f, -1.58814594e-01f, 8.45874399e-02f, 1.22375093e-01f, 3.76460031e-02f, -1.84206292e-02f, 3.48834768e-02f, 8.80897045e-02f, -1.90448046e-01f,
  -7.39190951e-02f, -1.35905519e-01f, 4.15884191e-03f, -1.17443711e-01f, -4.10330333e-02f, 9.05754641e-02f, -7.81257376e-02f, -1.37914428e-02f, 3.45155112e-02f, -1.63199469e-01f,
  -4.20293845e-02f, 7.79586360e-02f, -5.65403327e-03f, -2.00292449e-02f, -6.33003041e-02f, 3.31670530e-02f, -9.12651718e-02f, -1.44881643e-02f, -3.92784961e-02f, 3.44298333e-02f,
  1.52633380e-04f, -7.90288150e-02f, -6.74583996e-03f, 7.56007433e-02f, 1.78515390e-02f, -1.48451939e-01f, 8.04740004e-03f, 1.63961519e-02f, -1.48970485e-01f, 4.11232933e-02f,
  7.88378567e-02f, 2.87437104e-02f, 1.70079377e-02f, -3.75164077e-02f, 4.58216220e-02f, -3.19137867e-03f, 1.29117489e-01f, -8.11696500e-02f, 2.49371435e-02f, 3.69853564e-02f,
  1.42349780e-01f, 3.84449065e-01f, 7.86441099e-03f, 3.15908641e-02f, 7.61609524e-02f, 2.32707802e-02f, 4.72789891e-02f, -2.26627048e-02f, 8.54235217e-02f, 7.01726824e-02f,
  4.32672771e-03f, -3.37371565e-02f, 9.12303105e-02f, -3.89165357e-02f, -2.72760689e-02f, 7.71670938e-02f, 3.74493562e-02f, -1.03762066e-02f, 4.22242992e-02f, 9.20871720e-02f,
  6.45765662e-02f, 1.35084540e-01f, -5.28610237e-02f, -4.82006036e-02f, 8.37138444e-02f, 2.35418379e-02f, 5.40497229e-02f, -8.85292217e-02f, -9.26799886e-03f, 5.42555489e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.36612403e-01f, 5.22512376e-01f, 3.07524711e-01f, 3.46314371e-01f, 2.82416582e-01f, 4.52661783e-01f, 5.13819575e-01f, 2.61153489e-01f, 3.50434691e-01f, 3.03987354e-01f,
  2.66410351e-01f, 1.89487725e-01f, 4.30846781e-01f, 4.17042255e-01f, 3.62447172e-01f, 3.75963360e-01f, 3.31161022e-01f, 2.82453388e-01f, 5.60383439e-01f, 1.52102068e-01f,
  4.13854122e-01f, 4.27440733e-01f, 4.46055859e-01f, 1.01590440e-01f, 4.87040490e-01f, 4.07830447e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.30367607e-01f, 7.18263090e-02f, 8.38379934e-02f, 1.27827451e-01f, 2.76712272e-02f, -4.99205217e-02f, -1.46442175e-01f, -1.83804914e-01f, -1.83616832e-01f, 1.25852481e-01f,
  -2.37664595e-01f, 3.38536091e-02f, 8.42813328e-02f, 8.38541090e-02f, 5.68313859e-02f, 1.23012520e-01f, -3.67888212e-01f, 1.14922538e-01f, -2.62123883e-01f, -1.60066709e-01f,
  -1.00819007e-01f, 1.03202388e-01f, -1.89623743e-01f, -1.24414943e-01f, -1.68082997e-01f, 9.73289087e-02f, 1.15078442e-01f, -1.65202171e-01f, -6.53319955e-02f, -7.19394982e-02f,
  -3.67278270e-02f, -5.63675985e-02f, 8.63852426e-02f, 7.22166747e-02f, -4.85204831e-02f, 5.77268042e-02f, -4.70141061e-02f, -3.53696436e-01f, -3.59261662e-01f, -1.00949064e-01f,
  -4.62127984e-01f, -1.78149566e-01f, 8.95162299e-02f, -1.97715878e-01f, 3.71058695e-02f, -1.86034992e-01f, -3.71035933e-01f, -2.88574602e-02f, -3.85248698e-02f, -1.13146089e-01f,
  -1.65402219e-01f, 3.56067896e-01f, -3.67739707e-01f, 1.37038797e-01f, 1.98875600e-03f, -1.91432551e-01f, -7.77764618e-02f, 4.24966626e-02f, 3.55121344e-01f, 2.53126532e-01f,
  2.24741884e-02f, -1.81068480e-01f, -2.45190963e-01f, 3.09348643e-01f, -2.54515499e-01f, -1.56872556e-01f, -3.04431766e-02f, -1.54130220e-01f, -4.34227064e-02f, -3.98484677e-01f,
  -1.72049120e-01f, 1.70627326e-01f, 7.45228771e-03f, 1.38638049e-01f, 1.74592494e-03f, -2.97850788e-01f, -1.13719344e-01f, 1.52374551e-01f, 3.17604125e-01f, -9.56196859e-02f,
  -2.34221131e-01f, -3.79761904e-01f, 2.30044603e-01f, -1.88313723e-01f, 5.98076209e-02f, -1.66482374e-01f, 1.69112071e-01f, -2.49997541e-01f, -3.36487204e-01f, -2.97160000e-01f,
  -2.50306398e-01f, -2.65467644e-01f, 3.38414341e-01f, -1.48824647e-01f, 3.47881377e-01f, -1.15223140e-01f, 1.98777840e-01f, -2.58624345e-01f, 9.26815048e-02f, -8.21930692e-02f,
  -3.30121279e-01f, -2.21481279e-01f, 1.61928385e-01f, -4.83800501e-01f, 4.41812277e-01f, -4.52140898e-01f, -2.92931288e-01f, 9.12553370e-02f, -2.57156074e-01f, -3.33274871e-01f,
  -4.21186686e-01f, -1.29724309e-01f, -4.07502264e-01f, -1.67062148e-01f, 4.90767747e-01f, 3.98518950e-01f, -5.57456374e-01f, -3.52806672e-02f, 1.56442702e-01f, 3.69642466e-01f,
  -6.41003311e-01f, 2.39808187e-01f, 3.68104428e-02f, -6.20539188e-01f, -3.93752724e-01f, 6.91944063e-01f, 2.53527433e-01f, -2.14268774e-01f, -1.10339709e-01f, 8.40340927e-02f,
  -3.09400797e-01f, 7.76865259e-02f, -1.89786077e-01f, -3.16072285e-01f, -6.76084161e-02f, -2.68514574e-01f, 4.22468372e-02f, -2.28040427e-01f, 1.35163993e-01f, 1.94571406e-01f,
  4.15802091e-01f, -2.51375556e-01f, -1.61046684e-01f, -1.33580193e-01f, -1.49923125e-02f, -4.71044518e-03f, -3.90917271e-01f, -2.23475501e-01f, -2.16230586e-01f, -6.91767409e-02f,
  2.30854809e-01f, 6.74437061e-02f, 1.30687535e-01f, 9.34436098e-02f, -3.17759924e-02f, -1.38540557e-02f, 1.94905531e-02f, 3.42989773e-01f, 6.78929985e-02f, 8.77055153e-02f,
  2.17521712e-01f, -2.33638898e-01f, 1.25123426e-01f, 1.81643978e-01f, -3.67599666e-01f, 1.56373873e-01f, 1.96300626e-01f, -2.59940803e-01f, -1.02199418e-02f, 1.53159231e-01f,
  1.19109400e-01f, 2.14658871e-01f, -6.96568638e-02f, 1.00050561e-01f, 2.54991382e-01f, 2.51151808e-02f, -3.31764549e-01f, -3.63654971e-01f, -3.36453497e-01f, -3.39670330e-01f,
  8.64862668e-05f, 1.38630763e-01f, 3.13036025e-01f, -2.23609313e-01f, -4.89869475e-01f, 1.49749771e-01f, 3.16589028e-01f, -3.10813457e-01f, -2.24463895e-01f, -1.83519959e-01f,
  5.03863215e-01f, -3.52857977e-01f, 5.19843221e-01f, -1.25774577e-01f, 3.98010900e-03f, -9.26997364e-02f, 4.05868709e-01f, -1.86072648e-01f, 7.59863332e-02f, 2.92251676e-01f,
  -4.66199964e-01f, 2.07015380e-01f, -5.54346554e-02f, -2.73351163e-01f, -4.03277099e-01f, -4.08656508e-01f, 9.00509357e-02f, -6.70059547e-02f, -7.21835494e-02f, 1.15667945e-02f,
  -8.91099684e-03f, 4.05688524e-01f, 1.46877944e-01f, -2.18479559e-01f, 1.01890296e-01f, -3.23849410e-01f, 3.36136669e-01f, -3.96535218e-01f, -2.24826425e-01f, -4.66015995e-01f,
  -3.05409819e-01f, -2.40938589e-01f, 2.74910405e-02f, -3.87496769e-01f, 3.55461895e-01f, -3.85544032e-01f, 1.49837360e-01f, -2.60094076e-01f, -2.25952700e-01f, -4.26780373e-01f,
  -2.61013985e-01f, -1.40642002e-01f, -6.01768672e-01f, 2.71419227e-01f, -2.35885859e-01f, 2.55365819e-01f, 3.70766699e-01f, 3.76745999e-01f, 2.74440181e-02f, -4.79597300e-01f,
  -2.57292315e-02f, 9.43583436e-03f, -2.78899163e-01f, 5.09527102e-02f, 1.10882506e-01f, -4.34233516e-01f, 3.91265452e-01f, 1.11542903e-01f, -3.51611882e-01f, 1.18820369e-01f,
  1.67196006e-01f, 1.80165946e-01f, -6.13459945e-01f, -3.85639191e-01f, -4.48208362e-01f, -2.22319111e-01f, 4.28106487e-02f, -1.60650849e-01f, -2.04979572e-02f, -3.77099514e-01f,
  4.11145464e-02f, -2.57117212e-01f, 2.20052302e-02f, -1.05291456e-01f, -2.22316518e-01f, -3.06991875e-01f, -1.30605418e-02f, -2.82886744e-01f, -4.11925942e-01f, -3.96618769e-02f,
  -9.71371755e-02f, 1.72468975e-01f, -4.45062295e-02f, 7.49358325e-04f, 8.47527608e-02f, -1.75167039e-01f, 9.91589203e-02f, -3.07571381e-01f, 6.90332707e-03f, 4.03153300e-02f,
  -7.40936473e-02f, 7.63851777e-02f, -1.27966806e-01f, 1.21674106e-01f, 1.33156478e-01f, -1.93692297e-01f, -2.95058750e-02f, 3.45449429e-03f, -1.78805262e-01f, 4.95642759e-02f,
  -2.09936183e-02f, -1.05657488e-01f, 7.95562342e-02f, -5.29351570e-02f, -1.08120821e-01f, 4.84488346e-02f, 2.87980083e-02f, -3.83514702e-01f, -8.39332789e-02f, -1.14869356e-01f,
  -1.81699052e-01f, -1.63092196e-01f, -7.25751445e-02f, -1.02901570e-01f, 7.38551095e-02f, -4.95480374e-02f, -9.53220800e-02f, -4.34076265e-02f, -2.17010677e-01f, 8.50576088e-02f,
  1.60048366e-01f, 5.95913418e-02f, -2.42377967e-01f, -3.86346012e-01f, 3.48136932e-01f, -2.19696030e-01f, -2.30135933e-01f, 1.54932380e-01f, 1.36857957e-01f, -1.18078798e-01f,
  -4.89086002e-01f, -4.02570069e-01f, -7.78150335e-02f, 2.00207189e-01f, -2.18658686e-01f, 1.21727824e-01f, -2.77486831e-01f, -2.67878681e-01f, -2.48725936e-01f, 1.54544979e-01f,
  1.10000469e-01f, 1.86478570e-01f, -3.44480455e-01f, -2.81136036e-01f, -5.59875295e-02f, 1.58498347e-01f, 6.29166141e-02f, -2.00023979e-01f, 6.15570806e-02f, -6.99522868e-02f,
  3.14232051e-01f, 1.77557822e-02f, 1.04316674e-01f, -1.12767242e-01f, -2.45608799e-02f, 4.28991348e-01f, -2.84119427e-01f, -1.28452638e-02f, -2.14763612e-01f, -8.72654542e-02f,
  3.59795183e-01f, -1.20126203e-01f, -3.54765236e-01f, 2.19789237e-01f, 1.03751190e-01f, -1.88418791e-01f, -1.67790577e-01f, 2.22360462e-01f, 3.71001244e-01f, -2.73306575e-02f,
  -8.15376639e-02f, -3.83106589e-01f, 3.60645503e-01f, -5.23328483e-01f, 1.88170061e-01f, 2.61088848e-01f, -1.43682718e-01f, 5.77152431e-01f, 2.26265147e-01f, -3.94492328e-01f,
  -3.63308340e-01f, -6.20794952e-01f, -6.94274604e-02f, -7.05739036e-02f, -2.07200974e-01f, -1.46358199e-02f, -1.86249882e-01f, 3.42488557e-01f, -2.78861374e-01f, 1.98942363e-01f,
  -3.16105872e-01f, -3.00355554e-01f, -2.76682943e-01f, -9.45538655e-02f, 7.67313689e-02f, -9.45214182e-02f, -2.47751296e-01f, -1.99628055e-01f, 1.12563903e-02f, -1.35213867e-01f,
  8.84660631e-02f, 3.31143364e-02f, -1.17222495e-01f, -2.86164343e-01f, -1.58344269e-01f, 1.78617705e-02f, -2.12910995e-01f, -8.99056941e-02f, 2.50743516e-02f, -1.28484974e-02f,
  3.38742733e-02f, -2.53295973e-02f, 1.08018287e-01f, -5.31415679e-02f, 4.73215058e-02f, -3.90115172e-01f, 5.57301752e-02f, -8.94898027e-02f, 1.85910836e-01f, -1.02002479e-01f,
  -2.57353365e-01f, -5.24964094e-01f, 1.40607998e-01f, -2.89904147e-01f, 2.18603965e-02f, 1.14467449e-01f, 2.39884090e-02f, 1.66514754e-01f, 2.47802287e-01f, -1.67865112e-01f,
  6.49129301e-02f, 1.24784105e-01f, -3.19965094e-01f, 6.78794235e-02f, 7.33836219e-02f, -1.41426235e-01f, -2.58005202e-01f, -2.60942243e-02f, -1.37307465e-01f, -2.45090902e-01f,
  1.02827214e-02f, 1.02352448e-01f, 2.20403180e-01f, -2.52739817e-01f, 2.05738991e-02f, 1.03462957e-01f, -3.05386126e-01f, -1.04780439e-02f, -1.60833150e-01f, 5.40298820e-02f,
  -4.39878032e-02f, 1.39351189e-01f, 4.36602579e-03f, 1.61715373e-01f, 2.10798800e-01f, 4.24038827e-01f, -1.14062659e-01f, 2.49889866e-01f, -2.89610803e-01f, 6.05489537e-02f,
  3.33893567e-01f, 3.56966347e-01f, 1.14464082e-01f, 3.02475363e-01f, 3.71605754e-01f, 3.33544449e-03f, 2.07147360e-01f, -1.90650031e-01f, -4.29523773e-02f, -6.68778569e-02f,
  -4.33935553e-01f, 3.13418597e-01f, 2.39042118e-01f, -3.07622552e-01f, -4.33692187e-02f, 1.67528227e-01f, -2.96311647e-01f, 5.32432914e-01f, -2.73947984e-01f, 9.41522121e-02f,
  2.03964218e-01f, 3.60914737e-01f, 9.52211916e-02f, -2.47521371e-01f, -2.31809225e-02f, 3.03241134e-01f, 2.33550221e-01f, 2.75470704e-01f, -1.80390492e-01f, 3.60270798e-01f,
  1.96342275e-01f, -2.02064678e-01f, 2.15415418e-01f, 6.29421696e-03f, -3.19939964e-02f, -1.28181145e-01f, 1.21863961e-01f, 3.47899705e-01f, -4.26005609e-02f, -4.65081722e-01f,
  -5.06082118e-01f, -6.17499650e-02f, -7.57609546e-01f, -2.91684657e-01f, 4.11357611e-01f, -3.53653550e-01f, -1.89028576e-01f, -1.75650358e-01f, 4.44512889e-02f, 3.44023734e-01f,
  -1.97953165e-01f, 4.00725424e-01f, -3.75368029e-01f, 1.50835633e-01f, -7.96884954e-01f, -3.43171477e-01f, -3.93594176e-01f, -2.70812690e-01f, -2.98828602e-01f, -3.07252347e-01f,
  4.72642452e-01f, 3.05963218e-01f, -8.70303661e-02f, 1.09138593e-04f, 1.16291352e-01f, 8.34849700e-02f, 2.00680390e-01f, -9.17993635e-02f, -2.15850383e-01f, 1.44262567e-01f,
  7.94868683e-04f, 3.10085207e-01f, 7.04826191e-02f, -9.24910605e-02f, 1.63227662e-01f, -1.45442531e-01f, 4.60858196e-02f, 7.04461932e-02f, 2.35797212e-01f, -2.00594794e-02f,
  -5.84179386e-02f, 2.65994042e-01f, 1.34940207e-01f, 7.87422210e-02f, 8.44840053e-03f, 8.92322809e-02f, 2.29901541e-02f, 9.71490592e-02f, 8.62981677e-02f, 3.18096913e-02f,
  1.10924788e-01f, 8.76060650e-02f, -5.14404699e-02f, -5.27355522e-02f, 2.78408051e-01f, -3.24614197e-01f, -2.21902458e-03f, 6.77351430e-02f, 1.34183213e-01f, 1.15102768e-01f,
  2.28425011e-01f, -2.47341357e-02f, 1.97778985e-01f, 1.62679479e-01f, 1.25715554e-01f, 1.15361542e-01f, 1.23940364e-01f, -7.65158013e-02f, 2.76169330e-01f, 1.90087557e-01f,
  -2.06845656e-01f, -1.30373475e-04f, 4.56329212e-02f, 9.05871391e-02f, 3.02040070e-01f, -4.14143831e-01f, -4.67146128e-01f, 2.33256057e-01f, 1.05306320e-01f, 4.67644215e-01f,
  -1.77816868e-01f, 2.91412443e-01f, 6.77322745e-02f, -3.81165773e-01f, 6.92260936e-02f, 4.21080440e-01f, -7.16435835e-02f, 2.71194667e-01f, -4.20525640e-01f, -5.04645884e-01f,
  -4.15185928e-01f, 3.84579659e-01f, -4.69226658e-01f, -1.42100707e-01f, 1.72753364e-01f, 2.88794637e-01f, -3.28570485e-01f, -2.47258723e-01f, 4.78617579e-01f, -3.64314578e-02f,
  4.63429123e-01f, -2.16017962e-01f, -2.97366589e-01f, -4.79930788e-01f, -4.65375900e-01f, -3.17719996e-01f, 9.83629003e-02f, -6.76834956e-02f, 3.78727108e-01f, 5.56905046e-02f,
  -1.62023172e-01f, -2.14658752e-01f, 2.80303042e-02f, -1.92878097e-01f, -5.62691651e-02f, 5.84202111e-01f, -1.86755195e-01f, -1.73764125e-01f, -4.05294180e-01f, -2.67846316e-01f,
  -3.99931431e-01f, -2.49445543e-01f, 5.65920353e-01f, 3.49097908e-01f, 6.02315664e-01f, 3.11022192e-01f, -3.03383350e-01f, 5.80131710e-02f, 1.58236444e-01f, -1.05364598e-01f,
  -2.98331529e-01f, -4.31077540e-01f, -2.59734482e-01f, -4.12705541e-01f, -1.84905268e-02f, -4.65243280e-01f, -3.27591388e-03f, 2.16533709e-02f, -7.61880204e-02f, 2.85627335e-01f,
  -4.02230740e-01f, -1.17325522e-01f, 1.97283730e-01f, 4.26177710e-01f, 2.74492577e-02f, -2.18428522e-01f, -8.96153077e-02f, -2.87536561e-01f, 2.64348313e-02f, 1.68112233e-01f,
  2.67037392e-01f, -6.39051795e-02f, 5.40585518e-02f, 2.01208696e-01f, 1.48058653e-01f, 2.32483253e-01f, 1.78934991e-01f, 4.61278379e-01f, 1.25688970e-01f, 7.12313205e-02f,
  9.24790725e-02f, -1.27646253e-01f, -3.06892782e-01f, 5.48493722e-03f, 8.50411505e-02f, -3.69312555e-01f, -1.04468048e-01f, 6.02147207e-02f, 3.61278057e-01f, 9.11690965e-02f,
  8.94491673e-02f, 1.88118607e-01f, 2.15909451e-01f, 1.80784196e-01f, 2.23567054e-01f, 4.33320701e-02f, -1.21537179e-01f, 1.16900429e-01f, -4.73311655e-02f, -4.94002141e-02f,
  1.07280679e-01f, 1.37569467e-02f, -2.25671664e-01f, 2.10995197e-01f, 6.76778480e-02f, 5.90499975e-02f, 3.05279344e-01f, 9.68315899e-02f, 2.91627079e-01f, 4.96642403e-02f,
  1.97198495e-01f, 7.51272291e-02f, -1.12612389e-01f, 1.45189017e-01f, 3.78361829e-02f, 1.72727585e-01f, -3.46713699e-02f, -4.93720621e-02f, 2.45276943e-01f, 1.19080655e-01f,
  8.53712708e-02f, -4.59232628e-02f, 3.53036284e-01f, 4.24601912e-01f, -3.54690313e-01f, -3.36531214e-02f, 3.26553732e-01f, 3.13288689e-01f, -9.11137182e-03f, 1.17813841e-01f,
  -2.14436144e-01f, 1.69942472e-02f, -5.26256025e-01f, 1.47985205e-01f, -9.15958360e-03f, -6.12051129e-01f, -2.14127332e-01f, -3.61334294e-01f, 2.00648412e-01f, -3.86321098e-02f,
  -1.41896442e-01f, 4.50656682e-01f, 3.28060448e-01f, -1.42703012e-01f, 2.61320412e-01f, -1.10932127e-01f, 4.08369392e-01f, 2.49649152e-01f, -2.02293500e-01f, 1.13268411e-02f,
  4.09186095e-01f, 5.13059020e-01f, 2.24379942e-01f, -4.00437564e-01f, -2.11352855e-01f, -3.04962754e-01f, -3.31109583e-01f, -3.19438338e-01f, 1.52538419e-01f, 5.80502868e-01f,
  -3.39262858e-02f, 2.97848880e-01f, 3.72775137e-01f, -3.35416377e-01f, 1.99839011e-01f, 5.14400184e-01f, 9.03863013e-02f, 8.45499337e-02f, -4.24718201e-01f, -7.69063234e-02f,
  -3.79435748e-01f, -3.29659820e-01f, -2.07039312e-01f, -8.38854551e-01f, 1.64454311e-01f, 2.01861158e-01f, -3.49021167e-01f, 3.59843165e-01f, -3.84471059e-01f, -1.80893049e-01f,
  -3.17823201e-01f, -2.31505528e-01f, -2.66421765e-01f, -1.67634919e-01f, -3.46561849e-01f, 4.39029746e-02f, -4.15574551e-01f, -4.74616706e-01f, 2.30466068e-01f, -2.44930863e-01f,
  2.78483033e-01f, -6.00672364e-01f, 4.23821449e-01f, 1.70260400e-01f, -8.63825828e-02f, -1.51899368e-01f, 2.43227109e-01f, -1.58678919e-01f, -1.25543416e-01f, 1.41040236e-01f,
  1.40516862e-01f, -1.59278020e-01f, -1.29689604e-01f, -8.28569904e-02f, -7.25240111e-02f, -1.56016052e-01f, -2.58948565e-01f, 4.13667783e-03f, -1.20748952e-01f, -1.83405299e-02f,
  2.31731758e-02f, 4.09991629e-02f, 1.27019063e-01f, -9.89745744e-03f, 1.28859848e-01f, -1.66362207e-02f, -1.25099970e-02f, -7.51134753e-02f, 2.42093459e-01f, 1.04351498e-01f,
  -1.54304340e-01f, -6.85919002e-02f, -6.94645047e-02f, -6.83559552e-02f, 1.99044734e-01f, -1.78146705e-01f, 3.19564827e-02f, -1.28854439e-01f, 1.11757107e-01f, 7.27592930e-02f,
  -1.19548678e-01f, 1.20558841e-02f, -5.24113961e-02f, 1.69551566e-01f, -1.36120915e-02f, 1.31104305e-01f, -2.90965229e-01f, -8.46182629e-02f, 5.48982574e-03f, -7.89983943e-02f,
  -4.62838411e-02f, -1.58687830e-01f, 2.02596381e-01f, 2.25533154e-02f, 1.21875599e-01f, 6.44531846e-02f, 1.19233364e-02f, 1.51594117e-01f, -7.59683549e-02f, -4.59208161e-01f,
  3.52520704e-01f, 2.73045689e-01f, 1.66378409e-01f, -2.72355616e-01f, -4.40800130e-01f, -5.04303992e-01f, -4.72019553e-01f, -4.19173747e-01f, -2.57940859e-01f, -5.83005548e-02f,
  3.61019760e-01f, -2.16243029e-01f, -8.53021629e-03f, 4.06574517e-01f, -2.51908749e-01f, 3.41265708e-01f, -3.28764409e-01f, 2.84543097e-01f, -2.35073090e-01f, -2.43030936e-01f,
  7.45805204e-02f, -2.95006305e-01f, 2.36311138e-01f, 5.23864686e-01f, 2.99429089e-01f, 5.72720110e-01f, -2.84365505e-01f, -4.15385991e-01f, -3.16862822e-01f, 4.22631890e-01f,
  3.81444424e-01f, 3.13754886e-01f, -4.75573897e-01f, 7.29097333e-03f, -4.29654092e-01f, 2.20808491e-01f, -1.96166441e-01f, 2.08674446e-02f, -4.29770082e-01f, 9.66107473e-02f,
  -4.65045810e-01f, -9.96748954e-02f, -3.99943709e-01f, 1.14638016e-01f, -1.56943187e-01f, 2.09313929e-01f, 1.95271894e-02f, 2.21352950e-01f, -2.04299733e-01f, 2.22565770e-01f,
  -4.62545574e-01f, -4.07412767e-01f, -2.96111226e-01f, -1.30278990e-01f, -4.22641784e-01f, 1.52792215e-01f, -3.77252698e-01f, 5.73801696e-01f, -1.03523344e-01f, -1.42618090e-01f,
  1.85310394e-02f, -3.11129510e-01f, -1.97082832e-01f, -3.80993128e-01f, 4.85598534e-01f, -1.56836584e-01f, -2.56828129e-01f, -1.65427655e-01f, 2.69303024e-01f, -3.08372438e-01f,
  -2.53868252e-01f, 7.00727105e-02f, 3.35697979e-01f, 2.62651473e-01f, -4.25031185e-01f, -2.09528685e-01f, -5.67025468e-02f, -2.93428656e-02f, 7.26209804e-02f, -1.49590865e-01f,
  1.55389816e-01f, -4.04191576e-02f, -1.64967597e-01f, -2.31130078e-01f, 2.98938267e-02f, -2.74641991e-01f, -5.15551381e-02f, 7.88884610e-02f, -1.94676295e-01f, -1.61411747e-01f,
  -1.71170384e-01f, -1.56298399e-01f, -4.45606699e-03f, 9.71968770e-02f, -1.41791314e-01f, -2.22440481e-01f, -1.64309382e-01f, -1.20722547e-01f, -1.52196169e-01f, 1.12148076e-01f,
  -1.81441024e-01f, 2.20321547e-02f, 7.20307305e-02f, 5.18945642e-02f, -2.94716358e-01f, -6.10813266e-03f, -1.22006975e-01f, -2.44553730e-01f, -1.17367126e-01f, 1.47894339e-03f,
  -2.02709451e-01f, 8.31643343e-02f, -3.23125094e-01f, -1.62017465e-01f, 1.25886485e-01f, -2.96483606e-01f, -2.48153970e-01f, -8.19386691e-02f, -3.18005607e-02f, -5.03837280e-02f,
  -1.19578997e-02f, -7.71335438e-02f, -9.91408899e-03f, -2.08186910e-01f, -9.32748914e-02f, 2.14160420e-02f, -4.41257805e-02f, 2.32122570e-01f, 1.59014910e-02f, -4.01719920e-02f,
  -2.15779796e-01f, -1.25934705e-01f, 2.45923862e-01f, -3.33149046e-01f, -8.01020209e-03f, 2.49324366e-01f, 2.45016217e-01f, -2.47389942e-01f, -1.10210933e-01f, 7.47072399e-02f,
  -2.14549303e-01f, -5.08158393e-02f, 2.05699950e-01f, 3.04146320e-01f, -8.64158720e-02f, 1.79021597e-01f, 3.02455008e-01f, -2.42073193e-01f, 2.12690622e-01f, 2.63587832e-01f,
  4.93823364e-02f, -1.63503718e-02f, -2.42612064e-01f, 8.11730996e-02f, 1.09375261e-01f, 3.15773487e-01f, 2.87930429e-01f, 2.35404983e-01f, -1.49797380e-01f, -2.55608648e-01f,
  5.13938069e-02f, -1.78190202e-01f, -1.59941241e-01f, 2.12319180e-01f, -1.52557135e-01f, 1.48947001e-01f, 2.62125522e-01f, 2.71021813e-01f, -8.01100582e-02f, 8.16993564e-02f,
  1.11807778e-01f, -1.91317543e-01f, -2.95043826e-01f, 6.77120835e-02f, -3.29178005e-01f, 3.26219082e-01f, 2.03297719e-01f, -6.32144660e-02f, -1.46211728e-01f, -6.04350045e-02f,
  -3.46795678e-01f, 3.82936597e-01f, 2.22168788e-02f, -2.37174124e-01f, -1.90287203e-01f, -3.07482421e-01f, 4.07959670e-01f, 2.36507431e-01f, 2.53484249e-01f, 3.94896835e-01f,
  -3.91973972e-01f, -2.11091518e-01f, -3.57181430e-01f, 2.20761433e-01f, -5.09287901e-02f, -2.81574637e-01f, -6.06269091e-02f, 5.92665887e-03f, -6.88345055e-04f, -1.11247607e-01f,
  -5.88712767e-02f, 2.10300118e-01f, 1.08241551e-01f, -1.05040811e-01f, 1.05540708e-01f, -1.25655159e-01f, -2.17412971e-02f, 4.54315878e-02f, 8.23919997e-02f, 1.00723781e-01f,
  7.36321062e-02f, 5.31695262e-02f, -6.06273711e-02f, 7.86238238e-02f, -1.19318716e-01f, 7.83291385e-02f, -1.43297091e-01f, 1.59296412e-02f, 1.86152030e-02f, -9.85725895e-02f,
  9.93175507e-02f, -2.84039471e-02f, -1.00696579e-01f, 1.80156425e-01f, -8.34089071e-02f, -3.10373642e-02f, 1.23106893e-02f, -2.28975549e-01f, -1.38872609e-01f, -1.17434762e-01f,
  1.12469001e-02f, 5.47764078e-02f, -9.44815129e-02f, -1.84707463e-01f, -4.55623493e-02f, -4.99501871e-03f, -1.61947832e-01f, -2.50128865e-01f, -1.64494738e-01f, -1.51930511e-01f,
  -1.36041582e-01f, 8.04269239e-02f, -1.03465423e-01f, -1.38177499e-01f, 1.09110206e-01f, -1.29567549e-01f, -1.39974087e-01f, -2.96562091e-02f, 1.23148277e-01f, -7.84272254e-02f,
  4.44449931e-02f, -1.79553535e-02f, -2.42341340e-01f, 2.65980419e-02f, -2.78449729e-02f, -1.90880299e-01f, -2.24815160e-01f, 1.30011961e-01f, -2.69719005e-01f, 3.50012444e-03f,
  2.80617833e-01f, 4.22902256e-02f, 1.05176814e-01f, -9.53144208e-02f, 3.95823836e-01f, 2.44871616e-01f, -7.50102252e-02f, -2.47845769e-01f, 2.77275234e-01f, -4.97611761e-02f,
  2.06598148e-01f, -2.58911818e-01f, 1.91483304e-01f, -2.20218226e-01f, 1.72411948e-01f, -2.45467141e-01f, 4.62624766e-02f, -1.88278422e-01f, -3.50765944e-01f, 2.09882572e-01f,
  -1.27225012e-01f, -7.47422874e-02f, -2.23025754e-01f, -3.40807408e-01f, 3.29421878e-01f, 2.32327789e-01f, 9.92098898e-02f, 2.21195400e-01f, 1.18737921e-01f, 2.38181695e-01f,
  -2.22505897e-01f, -1.44131288e-01f, 1.98093951e-01f, -3.00091147e-01f, 3.53332579e-01f, 2.13364765e-01f, -2.60647655e-01f, 3.30646306e-01f, -3.32071781e-01f, 1.04232028e-01f,
  2.49650076e-01f, 2.75717080e-01f, 7.23305717e-02f, 3.27388048e-01f, 7.18141571e-02f, 3.16349208e-01f, -4.54613686e-01f, -2.71474779e-01f, 4.74570870e-01f, -3.40250015e-01f,
  3.64449531e-01f, -3.67936343e-01f, -2.44523630e-01f, -7.01441914e-02f, -4.45151746e-01f, 5.04528396e-02f, 4.70369697e-01f, -2.45859578e-01f, -3.04504633e-01f, 3.92906308e-01f,
  -2.71372020e-01f, -1.94168165e-01f, 1.64266855e-01f, 3.36962134e-01f, -3.77519399e-01f, -1.09881736e-01f, -2.89027065e-01f, 3.15438479e-01f, 2.21556157e-01f, -2.81980127e-01f,
  -1.91964149e-01f, -2.55960345e-01f, 8.30263346e-02f, 8.21039081e-02f, 5.69948219e-02f, 1.12605080e-01f, 4.90705259e-02f, 1.38853267e-01f, 2.18685910e-01f, -8.52244124e-02f,
  2.56020010e-01f, 1.46442587e-02f, 9.06858817e-02f, 2.00601704e-02f, 1.42512575e-01f, 2.95142308e-02f, 9.24324542e-02f, 8.30847472e-02f, 1.94794640e-01f, -2.99960822e-01f,
  3.93628292e-02f, 2.83892490e-02f, -1.41876206e-01f, -1.94930792e-01f, 7.50819147e-02f, -1.48040339e-01f, 1.46761805e-01f, 2.06884984e-02f, -4.28790934e-02f, -4.09373939e-02f,
  -5.38892113e-02f, 5.71139604e-02f, 1.10260153e-03f, -2.73721702e-02f, -4.46288427e-03f, 2.03390732e-01f, 2.21364662e-01f, -5.97239509e-02f, -3.30467410e-02f, -3.95523235e-02f,
  -3.20609706e-03f, 8.18390325e-02f, -8.21787044e-02f, 2.10869238e-01f, 1.47873476e-01f, 6.05552793e-02f, -6.07055379e-04f, -1.20063938e-01f, 5.80454916e-02f, -9.83197689e-02f,
  5.52912727e-02f, -3.95975336e-02f, 7.47809038e-02f, 4.50770438e-01f, -3.97666633e-01f, -5.28262295e-02f, 3.95276427e-01f, -2.48047590e-01f, 2.65015811e-01f, -5.74437752e-02f,
  -2.67017066e-01f, 5.83376437e-02f, -1.04514129e-01f, -2.73373961e-01f, 2.53362775e-01f, -1.55202925e-01f, 1.09698288e-01f, 3.87823403e-01f, -1.60009459e-01f, -1.13095157e-02f,
  -2.53288776e-01f, 1.21631466e-01f, -1.35195389e-01f, -3.36349249e-01f, -3.95015597e-01f, 3.73280942e-01f, 3.66287380e-01f, -4.33905303e-01f, 1.38427660e-01f, -5.19613862e-01f,
  -3.40283036e-01f, 1.81870177e-01f, 3.61418098e-01f, -3.64588618e-01f, -2.92078108e-01f, -2.94283926e-01f, 1.69199795e-01f, -2.27110200e-02f, 5.60069025e-01f, 3.45401376e-01f,
  -2.55063772e-01f, 2.55934060e-01f, 2.27789760e-01f, 3.63587052e-01f, 2.83637404e-01f, -3.26635569e-01f, 1.11238226e-01f, -2.17564434e-01f, -3.01758379e-01f, 3.08816046e-01f,
  -1.18855059e-01f, 3.92063230e-01f, -2.91537702e-01f, -9.99298915e-02f, -2.90514410e-01f, -3.81711990e-01f, 3.44500899e-01f, -6.95650429e-02f, -2.46812433e-01f, -5.67374825e-01f,
  4.76512432e-01f, -5.40360212e-01f, -3.67721438e-01f, -1.49327353e-01f, -2.81858563e-01f, 4.29125875e-01f, 2.23762348e-01f, -1.26465395e-01f, 4.40542519e-01f, -1.40792176e-01f,
  -4.43518996e-01f, -4.01394099e-01f, 3.77545238e-01f, -2.89022863e-01f, -4.36774760e-01f, -4.64236826e-01f, -3.98019522e-01f, 1.76809989e-02f, -3.26951474e-01f, -3.51752430e-01f,
  1.63030118e-01f, -4.25130278e-02f, 5.08062206e-02f, 1.35497749e-01f, -1.19658135e-01f, 2.19168290e-01f, 2.76294649e-02f, 1.33633018e-01f, 2.62447298e-01f, 5.98178729e-02f,
  6.14634566e-02f, -1.23394048e-02f, 1.35032043e-01f, 1.75746053e-01f, 2.30646711e-02f, -3.25360745e-02f, -1.68794632e-01f, -2.19368525e-02f, 1.49582513e-03f, 1.51050426e-02f,
  5.70609756e-02f, 1.50284961e-01f, -1.37717664e-01f, -4.92476858e-02f, 2.02869266e-01f, -1.12325593e-03f, 8.63628089e-02f, 3.17202061e-01f, -2.30825283e-02f, -1.41008690e-01f,
  -2.05141902e-02f, 1.86966360e-02f, -1.74087867e-01f, 2.48096168e-01f, -3.31259012e-01f, 1.15443386e-01f, 1.20710656e-01f, 9.35007073e-03f, 5.76871336e-02f, 1.14304885e-01f,
  2.90943179e-02f, 8.88635814e-02f, 1.53489038e-01f, -8.86575691e-03f, 3.87042351e-02f, 2.40901962e-01f, -3.33455438e-03f, -1.19919308e-01f, -1.00232825e-01f, 1.90578386e-01f,
  1.83343813e-02f, -5.01079373e-02f, 3.60969424e-01f, -2.80300260e-01f, -2.18313485e-01f, 3.48115772e-01f, -9.95721109e-03f, -8.71981159e-02f, 1.43857956e-01f, -3.84945303e-01f,
  3.19514126e-01f, 2.24374667e-01f, 1.38589948e-01f, 2.78273225e-01f, 2.38566712e-01f, 5.88868372e-02f, 2.32735068e-01f, 2.89565116e-01f, 3.40057492e-01f, -3.34209323e-01f,
  2.87679166e-01f, 1.27072245e-01f, 2.55883306e-01f, -2.98142314e-01f, -2.39888623e-01f, -8.66062418e-02f, -3.35830927e-01f, -1.80904403e-01f, -1.26567796e-01f, 4.40619469e-01f,
  -3.42476457e-01f, -2.63286471e-01f, 1.63271442e-01f, 2.41544053e-01f, 1.77866206e-01f, 2.88564563e-01f, 3.11968237e-01f, -5.12552559e-01f, 1.50128812e-01f, -3.21026027e-01f,
  1.90124527e-01f, -3.72743428e-01f, 2.05808759e-01f, 1.07193239e-01f, -1.07925132e-01f, 7.06338584e-02f, 2.13502079e-01f, -1.70792818e-01f, 2.84896791e-01f, -1.41990110e-01f,
  2.49529839e-01f, 6.76631182e-02f, -4.26580906e-01f, 5.91800921e-02f, -4.06840652e-01f, -2.07376182e-01f, 4.46123570e-01f, -2.96648532e-01f, 5.96938431e-01f, -3.88557106e-01f,
  2.25034118e-01f, 4.75039333e-01f, -6.07704580e-01f, -1.91257596e-01f, -6.17929161e-01f, -6.17667258e-01f, -2.84436852e-01f, -1.52365163e-01f, 3.98586728e-02f, -3.62362772e-01f,
  -2.23948494e-01f, -3.66510063e-01f, -5.90165593e-02f, -3.15477818e-01f, -1.29584536e-01f, -1.98757008e-01f, -9.23950225e-02f, 4.20082390e-01f, 1.53033853e-01f, -7.35128298e-02f,
  -8.24580714e-02f, -2.73809433e-02f, -1.26116514e-01f, 8.82974267e-02f, 1.87816285e-03f, 1.20357469e-01f, 6.99956194e-02f, -1.86062157e-02f, 9.26458463e-02f, -2.70366222e-02f,
  2.12520480e-01f, 6.43387437e-03f, 3.14998254e-02f, 8.62473175e-02f, 1.91428930e-01f, 1.19695917e-01f, 6.20632507e-02f, 1.26484498e-01f, 9.55293849e-02f, 9.80966091e-02f,
  5.22703901e-02f, -1.01629578e-01f, -2.70525903e-01f, 7.13405311e-02f, 8.02636147e-02f, 2.33145788e-01f, 6.16891608e-02f, 1.31804109e-01f, 7.90614560e-02f, -8.59887451e-02f,
  8.04697257e-03f, 1.03846200e-01f, 2.31625363e-01f, -1.62989393e-01f, -3.57888937e-02f, -2.11665869e-01f, 3.71821038e-02f, 9.57631469e-02f, 1.06186755e-01f, 4.37826626e-02f,
  2.50198483e-03f, -6.08830340e-03f, -3.26112509e-01f, -7.61297047e-02f, -1.95940688e-01f, 1.23491906e-01f, 1.88569427e-01f, -1.07881457e-01f, 1.52956939e-03f, -8.43124762e-02f,
  2.08180070e-01f, -3.42165679e-01f, 3.78980517e-01f, 2.42640316e-01f, 9.78049040e-02f, -3.03367823e-01f, 1.09180920e-01f, 2.59891391e-01f, 2.36878797e-01f, 1.46827459e-01f,
  -3.61611217e-01f, -1.25579670e-01f, 3.25909376e-01f, 3.03946227e-01f, 4.53076601e-01f, 2.09049523e-01f, -5.06301560e-02f, 1.13073271e-02f, 3.06232661e-01f, 2.35541791e-01f,
  4.67349589e-02f, -2.00823590e-01f, -3.94680113e-01f, 3.42976540e-01f, 8.75805765e-02f, 2.08797887e-01f, 2.93538515e-02f, 2.11570755e-01f, 1.56076834e-01f, 1.89729258e-01f,
  2.69789547e-01f, -3.58655840e-01f, -2.07312211e-01f, 1.62157148e-01f, -3.63483936e-01f, 2.73032218e-01f, 3.46430302e-01f, 2.50778615e-01f, 3.65380734e-01f, 2.57856011e-01f,
  7.15518557e-03f, -2.84922451e-01f, 1.94382951e-01f, 2.88098276e-01f, 3.16360056e-01f, 4.28848326e-01f, 2.79064953e-01f, -8.73424020e-03f, 3.42421234e-01f, 3.40123355e-01f,
  -1.64137632e-01f, 3.52559060e-01f, -1.42223403e-01f, -9.30286199e-02f, -2.62937456e-01f, 2.64471650e-01f, -2.36838266e-01f, -2.04542220e-01f, -4.05265123e-01f, -9.77980047e-02f,
  -3.20729494e-01f, -2.42618263e-01f, 5.46136558e-01f, -1.46640062e-01f, -3.48384678e-01f, 2.32952893e-01f, -3.84887069e-01f, 8.41724873e-02f, -1.51760057e-01f, -2.16515020e-01f,
  2.23294094e-01f, -2.47853398e-01f, 5.42911708e-01f, -1.24623731e-01f, -3.21755826e-01f, -5.06493032e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -6.25061542e-02f, -2.07505152e-02f, -4.95348882e-04f, -2.32422333e-02f, 3.75432707e-02f, 9.45952535e-02f, -7.71450717e-03f, -5.39765470e-02f, -3.59536298e-02f, -1.52904475e-02f,
  9.24624223e-03f, -3.39445472e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    