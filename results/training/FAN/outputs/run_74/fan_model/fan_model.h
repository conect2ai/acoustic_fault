/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.04282597e-01f, -2.72493392e-01f, 3.87515910e-02f, -4.46826108e-02f, 6.43018857e-02f, -2.23782569e-01f, -7.38669410e-02f, -8.44073519e-02f, 2.08383072e-02f, -2.41492745e-02f,
  6.11277390e-03f, -5.67848645e-02f, 5.21832146e-02f, -1.23843208e-01f, 1.43668830e-01f, -1.34502556e-02f, -1.68988451e-01f, -1.01005256e-01f, 1.11788161e-01f, -8.29969645e-02f,
  8.35702196e-02f, -3.03486567e-02f, 6.23817220e-02f, 3.01695019e-02f, 8.56663883e-02f, 9.12612081e-02f, 2.28696555e-01f, 1.16385750e-01f, -1.32100329e-01f, 2.85194851e-02f,
  -7.03000799e-02f, 5.52403647e-03f, 5.86254783e-02f, -2.33214963e-02f, -6.27913326e-02f, -3.06908023e-02f, 4.71000113e-02f, 7.34231099e-02f, 4.53910753e-02f, 3.41095515e-02f,
  -7.21851178e-03f, 5.04975282e-02f, -8.79759341e-03f, 1.27582783e-02f, -1.20644141e-02f, 4.95997164e-03f, -2.83173621e-02f, -4.81262878e-02f, -5.38105555e-02f, 5.71935624e-02f,
  6.10381477e-02f, 4.41532955e-03f, -3.01007610e-02f, -4.78249565e-02f, 1.22822402e-02f, -4.53389734e-02f, 1.69430703e-01f, 6.42437662e-04f, -1.21336179e-02f, -2.30638906e-02f,
  -3.93921956e-02f, 1.88693792e-01f, -2.42765043e-02f, 9.77030676e-03f, -1.91056374e-02f, -6.71052234e-03f, 7.16579705e-02f, 3.28707416e-03f, 1.18566245e-01f, -3.46475169e-02f,
  -5.41477278e-02f, -9.54547003e-02f, -8.34384710e-02f, 2.76635736e-02f, 8.69066119e-02f, 7.84757826e-03f, 7.35238567e-02f, -3.91244842e-03f, -8.44239444e-02f, 9.45059117e-03f,
  -1.58737022e-02f, -3.64239737e-02f, -1.58475786e-02f, 8.41192678e-02f, 3.47554907e-02f, 1.52922541e-01f, 1.29188020e-02f, -5.13267629e-02f, -9.45764314e-03f, 1.37306387e-02f,
  -1.56870887e-01f, 9.30213602e-04f, 2.13501062e-02f, -3.42769921e-02f, -3.66998538e-02f, 8.04482251e-02f, 1.92009564e-02f, -1.63702350e-02f, -7.85273686e-02f, 4.59146239e-02f,
  -4.89468016e-02f, 1.58542953e-02f, -3.50889862e-02f, -1.32700626e-03f, -4.73789982e-02f, 4.82875742e-02f, -1.45164598e-02f, -1.36219576e-01f, -1.04848377e-01f, -4.90242019e-02f,
  -5.56697100e-02f, -2.68875044e-02f, 1.35201663e-01f, 6.19515739e-02f, -4.69603017e-02f, 7.39128888e-02f, 5.94638847e-02f, -3.75431553e-02f, 4.09592353e-02f, 1.20192841e-02f,
  4.10690337e-01f, -1.63101733e-01f, 1.53253913e-01f, 1.04815707e-01f, -4.90469076e-02f, -4.38107401e-02f, -1.29275918e-01f, 1.49431244e-01f, 1.31383270e-01f, 9.68271941e-02f,
  4.05731350e-02f, 3.05485558e-02f, 1.72466449e-02f, 6.73315823e-02f, 3.97810601e-02f, -5.80985770e-02f, 1.87936410e-01f, -6.35097995e-02f, -7.74919018e-02f, 1.66303366e-01f,
  1.02216126e-02f, -4.37373556e-02f, 6.31653666e-02f, -1.11750886e-03f, -1.74538651e-03f, 1.31777734e-01f, -3.36508416e-02f, -3.37554328e-02f, -5.62414452e-02f, -1.02622531e-01f,
  -4.11358587e-02f, 1.82059780e-01f, 8.29161108e-02f, 7.55076623e-03f, 1.62764937e-01f, 7.06654638e-02f, -3.79839875e-02f, -3.20627391e-02f, 2.26627644e-02f, -2.08348799e-02f,
  -2.96801608e-02f, -7.28935152e-02f, 7.56646618e-02f, -1.57977939e-02f, -1.81629900e-02f, -1.47312641e-01f, -1.38602480e-01f, 4.44036461e-02f, -3.85421216e-02f, -1.32031152e-02f,
  -2.57716309e-02f, -1.20053049e-02f, -2.78849690e-03f, -2.82884873e-02f, 6.08575530e-02f, -2.26045344e-02f, -2.30276380e-02f, 4.38118689e-02f, -5.76675832e-02f, 1.53118204e-02f,
  1.11570425e-01f, -3.47480997e-02f, -2.71794982e-02f, -4.53774594e-02f, -2.06227656e-02f, -6.85949773e-02f, -5.30913249e-02f, -8.33609849e-02f, -3.31532285e-02f, 6.13919385e-02f,
  -5.47218276e-03f, 7.54035562e-02f, 3.25333737e-02f, 6.06600791e-02f, 3.80765498e-02f, 5.19871041e-02f, 1.75480656e-02f, -1.97254922e-02f, 9.20589790e-02f, -6.04066327e-02f,
  -6.15193062e-02f, -2.14171261e-02f, -2.98896693e-02f, 2.99555361e-02f, -6.77329823e-02f, 2.63845567e-02f, -1.28374752e-02f, -4.33858819e-02f, -9.09604039e-03f, 2.57745273e-02f,
  2.24360712e-02f, 2.17369467e-01f, -2.00722236e-02f, -7.38932565e-02f, -1.22872986e-01f, -4.98674996e-02f, 9.94494930e-03f, -7.02198176e-03f, -6.03679903e-02f, -5.73732844e-03f,
  4.72444817e-02f, -3.74614857e-02f, 9.76408273e-02f, 5.66421039e-02f, 2.57764924e-02f, 5.48535064e-02f, -2.38640860e-04f, 1.25377728e-02f, -1.07402708e-02f, -8.85797758e-03f,
  -5.49416207e-02f, 1.28254881e-02f, -3.06865200e-02f, -1.72730293e-02f, 5.61393090e-02f, 3.51399034e-02f, -3.42036486e-02f, 6.64832890e-02f, -6.64606458e-03f, -4.04511802e-02f,
  1.15700670e-01f, 3.09188247e-01f, -1.67482004e-01f, 1.44851848e-01f, -1.86031330e-02f, -4.27096188e-02f, -1.33796260e-01f, 1.23066962e-01f, 4.85742688e-02f, 6.07893169e-02f,
  -1.63164526e-01f, 5.09942044e-03f, -1.39358804e-01f, 1.97800949e-01f, -4.06090111e-01f, -2.63087451e-02f, -1.48028493e-01f, 3.39615569e-02f, -1.69579033e-02f, 1.31960332e-01f,
  -3.68531533e-02f, 1.44672811e-01f, -1.17514849e-01f, 1.37155384e-01f, 6.73573911e-02f, 1.43279150e-01f, 1.33524369e-03f, 8.34371969e-02f, 6.64601550e-02f, -1.56092271e-01f,
  8.70227739e-02f, 5.29409796e-02f, 7.58534819e-02f, -7.75378197e-02f, -5.85613586e-02f, 2.88117342e-02f, -1.01636611e-01f, -7.33287558e-02f, -2.65175588e-02f, -1.04195394e-01f,
  -9.43132490e-02f, -8.66302624e-02f, 8.98589380e-03f, 6.24702089e-02f, 3.97232175e-02f, -1.67989451e-02f, 1.00732502e-02f, -6.92066178e-02f, 5.76317906e-02f, -4.70086969e-02f,
  -4.34810296e-03f, -3.48940827e-02f, -2.36418005e-03f, -1.03061453e-01f, -1.44976735e-01f, 1.52764320e-02f, -1.27420738e-01f, -2.05209814e-02f, -4.38570417e-02f, -2.47407556e-02f,
  -5.06425872e-02f, -1.00768618e-01f, 6.34692796e-03f, 5.83231524e-02f, -3.54461446e-02f, -4.42234613e-02f, -5.65265715e-02f, -5.77108301e-02f, -3.58081050e-02f, -6.42739683e-02f,
  5.40326424e-02f, 2.92476937e-02f, 1.01914383e-01f, -4.73546004e-03f, -2.08299491e-03f, 1.11571550e-02f, 4.79908325e-02f, 1.09395180e-02f, -5.36170788e-02f, -1.34951295e-02f,
  2.01338646e-03f, 2.98645515e-02f, 4.59120236e-02f, -2.77850889e-02f, 3.58109921e-02f, 3.40689272e-02f, 3.87386605e-02f, 1.04781277e-01f, 3.81377116e-02f, -1.04991578e-01f,
  2.17702985e-01f, 3.38329040e-02f, -3.82062024e-03f, 3.97483371e-02f, 4.31376882e-02f, 1.17586449e-01f, 1.91883522e-03f, -6.62753880e-02f, -4.19342890e-02f, 9.48772579e-02f,
  -2.11401526e-02f, -2.82719620e-02f, -6.21892773e-02f, -2.86324602e-02f, -1.29539505e-01f, -3.15385126e-02f, -6.48270249e-02f, -3.39879505e-02f, -5.25219552e-02f, 4.95378561e-02f,
  1.22076996e-01f, -1.83108244e-02f, -1.96977556e-01f, -3.16642113e-02f, -1.24826811e-01f, -9.78130400e-02f, 3.63668017e-02f, 2.83645596e-02f, -7.50981942e-02f, -9.29947942e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.10816622e-01f, 1.23065233e-01f, 3.37840676e-01f, 1.36117190e-01f, -1.63746178e-01f, -4.26128432e-02f, 8.57393593e-02f, -6.59766942e-02f, 8.70280266e-02f, 6.82689175e-02f,
  -1.16923362e-01f, 4.23143506e-01f, -1.04090139e-01f, 2.37923823e-02f, -1.85469985e-01f, -2.24301413e-01f, -1.60432130e-01f, 8.96388814e-02f, 2.41879676e-03f, 8.11709836e-02f,
  -1.81871615e-02f, -3.46217602e-01f, 4.22531087e-03f, -1.38941899e-01f, 3.21050614e-01f, 1.90083385e-01f, -2.83470541e-01f, -3.79050360e-03f, 1.33284971e-01f, -6.01663068e-02f,
  -8.85422900e-03f, -1.97069924e-02f, 8.48748833e-02f, -3.59116471e-04f, -8.22877958e-02f, 7.69895092e-02f, -3.44093367e-02f, -7.28911683e-02f, 2.45441366e-02f, 2.17962652e-01f,
  4.00432572e-02f, 2.32287142e-02f, -5.59078753e-02f, 7.15192929e-02f, 3.97566743e-02f, 1.84354186e-01f, 6.74987659e-02f, 1.13956951e-01f, -4.41103205e-02f, 5.04874960e-02f,
  2.22725555e-01f, 3.89751531e-02f, 7.24035352e-02f, -6.52954429e-02f, 2.50716899e-02f, -1.11381322e-01f, 9.40266997e-02f, 4.85691912e-02f, 4.74620387e-02f, -3.03949160e-03f,
  -2.44151592e-01f, -1.61112130e-01f, -9.05138850e-02f, 2.97192056e-02f, 4.27273624e-02f, 8.29238370e-02f, 6.31699339e-02f, 1.09711386e-01f, 5.67113888e-03f, -1.10100150e-01f,
  -5.50988410e-03f, -5.65884113e-02f, -1.09608345e-01f, 1.90132856e-02f, 2.13377550e-02f, 5.35582043e-02f, -1.08693577e-01f, 1.39511138e-01f, -6.05418831e-02f, 4.51981723e-02f,
  -5.76664321e-02f, 1.74915530e-02f, -5.45437485e-02f, -5.82396239e-02f, -7.51321465e-02f, 2.65846457e-02f, 4.18317840e-02f, 1.31548509e-01f, -2.30147783e-02f, 3.28146257e-02f,
  -1.08035952e-01f, -2.51996160e-01f, -8.28300044e-02f, 6.83467984e-02f, -7.48244971e-02f, 3.97209637e-02f, -8.45402107e-02f, -8.57749209e-03f, -2.21608561e-02f, 4.18650471e-02f,
  -1.55274747e-02f, 9.30451676e-02f, -1.71669305e-03f, 8.90350528e-03f, -6.54418468e-02f, 2.86392942e-02f, -9.11234096e-02f, -1.63811073e-01f, -2.29066014e-01f, -5.81966080e-02f,
  -6.59831287e-03f, -1.67672876e-02f, 1.89107791e-01f, -4.20882888e-02f, -4.53898311e-02f, -9.30562988e-02f, 5.45634367e-02f, -4.30697342e-03f, 4.33888957e-02f, 3.72271389e-02f,
  -2.76439399e-01f, 3.13814014e-01f, -4.18926835e-01f, 1.15691856e-01f, -6.76299771e-03f, 5.56240857e-01f, 4.85795379e-01f, 3.60138230e-02f, 2.39705637e-01f, 4.87713993e-01f,
  2.90718049e-01f, 2.46820599e-01f, 1.33044586e-01f, 5.34206212e-01f, -2.14605536e-02f, 3.60249251e-01f, 3.91963512e-01f, 4.03780490e-01f, 5.47228381e-03f, 1.00184835e-01f,
  -1.51833847e-01f, 2.86593020e-01f, -1.52447581e-01f, -6.72659874e-02f, -6.25248477e-02f, -2.35830113e-01f, -1.21716306e-01f, -1.42853439e-01f, 1.38788521e-01f, 7.79648200e-02f,
  1.10583127e-01f, -2.94005536e-02f, -3.53578255e-02f, -1.20063044e-01f, -1.44654110e-01f, -2.64609698e-02f, -1.07432972e-03f, -1.26865104e-01f, -1.09811544e-01f, 7.65681118e-02f,
  -6.08311854e-02f, 5.10876114e-03f, -8.14491361e-02f, -5.38355252e-03f, -2.08127443e-02f, -4.62247767e-02f, -1.54453572e-02f, -7.72056431e-02f, 3.00111976e-02f, -5.14476337e-02f,
  -8.74029100e-03f, -3.47061977e-02f, 1.49144717e-02f, -5.35958223e-02f, -8.01835284e-02f, 9.17875469e-02f, 1.05688408e-01f, 4.74884883e-02f, 1.67857990e-01f, 7.15531632e-02f,
  -3.07654850e-02f, -3.59573285e-03f, -2.81985700e-02f, -5.33414958e-03f, -2.25368049e-02f, -1.07314087e-01f, 4.18012664e-02f, 5.04937954e-03f, -5.44564836e-02f, 1.89532582e-02f,
  -4.68209898e-03f, -3.78828533e-02f, 2.73094214e-02f, 1.73805263e-02f, 1.13784268e-01f, 2.63624769e-02f, -5.30063622e-02f, -4.03824709e-02f, 6.21910766e-02f, 1.06294774e-01f,
  -1.45522440e-02f, 6.25869855e-02f, 1.07200310e-01f, -5.04465355e-03f, 8.45094994e-02f, -1.37371853e-01f, 2.32862569e-02f, -5.52972667e-02f, -3.56243066e-02f, -6.77335113e-02f,
  1.48242816e-01f, 1.63968384e-01f, -7.14388536e-03f, -1.08807273e-01f, 5.45668090e-03f, -4.22726646e-02f, 3.57963592e-02f, 1.76009592e-02f, -1.54080684e-03f, -1.19756740e-02f,
  -1.03738151e-01f, 2.74687074e-02f, -6.76586181e-02f, 4.71013337e-02f, -2.25509182e-02f, 1.38296410e-01f, 4.65464443e-02f, -7.27426726e-03f, -5.92425559e-03f, -2.31673978e-02f,
  1.33057851e-02f, 1.29083516e-02f, -7.25941500e-03f, -8.60430151e-02f, 3.93776298e-02f, 2.72835270e-02f, 1.06447630e-01f, 2.01211330e-02f, -5.19577488e-02f, 3.80032919e-02f,
  -4.48219866e-01f, 5.51033199e-01f, 4.53048319e-01f, -2.79120147e-01f, 2.94528812e-01f, 3.54422152e-01f, -1.15661681e-01f, 3.14959407e-01f, 1.39126673e-01f, -1.56086311e-01f,
  -1.90446049e-01f, 2.56537758e-02f, 8.73880163e-02f, -2.38763746e-02f, -9.09280777e-02f, 7.95626640e-02f, -9.88493767e-03f, -1.68865412e-01f, 2.81438589e-01f, 7.43660927e-02f,
  1.24293856e-01f, -1.47952601e-01f, 2.26596981e-01f, 3.28004271e-01f, 1.27023458e-01f, 4.12743911e-02f, -3.94172996e-01f, 1.99557021e-01f, -1.75529048e-01f, 7.69869909e-02f,
  4.79376726e-02f, -1.54828221e-01f, 8.98986161e-02f, 1.31132334e-01f, 6.46645622e-03f, 3.25275101e-02f, -1.46978900e-01f, -6.98988363e-02f, -1.21689521e-01f, 8.76278523e-03f,
  -6.94636405e-02f, 1.91967674e-02f, -7.91342333e-02f, 8.99647623e-02f, 1.17662989e-01f, 1.05960093e-01f, 1.41874939e-01f, 1.80839196e-01f, 1.25422731e-01f, 8.63295570e-02f,
  1.35303125e-01f, 1.44971624e-01f, 3.06791440e-02f, -8.90832618e-02f, -8.29306955e-04f, 2.54922546e-02f, 4.50878479e-02f, -4.88456897e-02f, 3.23566571e-02f, -2.38830671e-02f,
  5.82703203e-02f, 7.22215623e-02f, 1.54713243e-02f, 3.60661671e-02f, -8.44615325e-02f, -5.33229113e-02f, 2.69684568e-03f, -2.50983387e-01f, -6.64249361e-02f, -3.40708927e-03f,
  -1.44218966e-01f, -5.33160307e-02f, 1.46471828e-01f, 2.45993603e-02f, -2.49937251e-02f, 6.47486746e-02f, -1.42962292e-01f, -5.27258068e-02f, -1.06646598e-03f, -2.01829337e-02f,
  1.08956844e-02f, -1.06094606e-01f, -6.65135011e-02f, -2.84581855e-02f, -4.99439752e-03f, -1.86256692e-02f, 5.14473952e-02f, 3.50612663e-02f, 7.50541175e-03f, -4.40122001e-02f,
  -2.80650333e-02f, -1.75008386e-01f, 1.89560931e-03f, 1.20047238e-02f, 1.70019027e-02f, 1.34167401e-03f, 3.54141518e-02f, -2.02805307e-02f, -3.00833751e-02f, 2.18494944e-02f,
  6.05427213e-02f, -3.87333743e-02f, -2.68038400e-02f, -8.91398937e-02f, -5.43443412e-02f, -6.96163625e-02f, -1.28804788e-01f, -5.81582226e-02f, -5.34238331e-02f, 7.02964216e-02f,
  3.70402797e-03f, -8.63916278e-02f, -1.23689912e-01f, 3.62770632e-02f, -9.71460640e-02f, -4.90242988e-02f, -9.26137269e-02f, 1.31915361e-01f, -3.58231775e-02f, -1.99507345e-02f,
  -1.44702241e-01f, 4.77036834e-02f, -4.32295352e-02f, 2.62395203e-01f, 1.57236923e-02f, -1.65176138e-01f, -1.18386097e-01f, -3.01601328e-02f, -1.90495566e-01f, 7.96795636e-02f,
  1.08114220e-01f, -5.93907125e-02f, -1.65337287e-02f, 2.48356447e-01f, 2.91966163e-02f, -1.21436819e-01f, 2.94281036e-01f, 4.08364758e-02f, -7.54006803e-02f, 2.40479454e-01f,
  -1.45869255e-02f, 5.36192544e-02f, 9.96227041e-02f, 9.42337513e-02f, 3.64116654e-02f, 1.70464575e-01f, 3.10132682e-01f, -8.07188898e-02f, 2.23597556e-01f, 4.34192121e-02f,
  -5.34321815e-02f, 4.25352342e-02f, 6.21926365e-03f, -9.12065804e-02f, 5.81427552e-02f, 1.41501933e-01f, 1.50769204e-01f, -7.81787634e-02f, -1.41054094e-01f, -2.92293485e-02f,
  2.51804236e-02f, -2.68133599e-02f, 1.05589114e-01f, 5.03343390e-03f, -9.21764523e-02f, 2.05182098e-02f, -5.16961180e-02f, -3.75046842e-02f, -6.30501360e-02f, 8.77766162e-02f,
  2.02795062e-02f, 1.11287080e-01f, 4.45542186e-02f, 1.24138176e-01f, 4.56254035e-02f, -6.13811833e-04f, -3.61438617e-02f, 9.51254070e-02f, 2.67702416e-02f, -4.03897092e-02f,
  6.09627962e-02f, -7.38370344e-02f, -3.37141678e-02f, -1.21556491e-01f, -2.17831805e-02f, 3.63561995e-02f, -1.19507052e-01f, -1.93130430e-02f, -7.70081356e-02f, 7.41481110e-02f,
  -3.65859941e-02f, 2.76567135e-02f, 3.09011694e-02f, 3.10104415e-02f, -4.27320600e-02f, -1.62951127e-01f, -8.24665129e-02f, 1.74568295e-02f, 5.62083945e-02f, -3.38096768e-02f,
  3.58222313e-02f, -4.75564189e-02f, -4.32801321e-02f, 3.69801186e-02f, -7.21690804e-02f, 4.97180820e-02f, 5.89798018e-02f, 6.37541153e-03f, -7.77926147e-02f, -6.06941804e-02f,
  1.06971562e-01f, 2.44634241e-01f, -8.89814831e-03f, -1.91310301e-01f, 5.82031012e-02f, 4.88615520e-02f, -4.77130190e-02f, 2.08572112e-03f, 5.53889945e-02f, 7.02418154e-03f,
  2.19263956e-01f, -1.27247889e-02f, 1.41429424e-01f, -9.62095149e-03f, 1.87450144e-02f, 9.93511677e-02f, 9.85864699e-02f, 2.65776552e-02f, 1.93122178e-01f, 1.14802808e-01f,
  1.00061812e-01f, 3.46147344e-02f, -6.54679984e-02f, -1.44958779e-01f, 1.25163436e-01f, 1.38129622e-01f, -3.67030613e-02f, -4.06969190e-02f, 6.30573109e-02f, 7.93433338e-02f,
  -6.99953079e-01f, 2.12119579e-01f, -1.96809247e-01f, -7.79101104e-02f, -1.10051051e-01f, -1.93424717e-01f, 8.45575929e-02f, -1.48606017e-01f, 4.97358106e-02f, 2.43984729e-01f,
  1.43521667e-01f, -1.31924495e-01f, 1.79267511e-01f, 8.59297737e-02f, -2.80976772e-01f, 3.26792240e-01f, -1.05185904e-01f, 1.38443653e-02f, 1.02013730e-01f, -1.97937876e-01f,
  -1.87854730e-02f, 1.09969020e-01f, -3.61407474e-02f, 1.38452530e-01f, -6.95997179e-02f, -1.44406885e-01f, 1.02842063e-01f, -4.10872325e-02f, 2.05911677e-02f, 1.08378790e-02f,
  -3.79163772e-01f, -2.80140579e-01f, -1.32526249e-01f, -6.44206330e-02f, -1.86652288e-01f, -6.03082702e-02f, -1.59476046e-02f, 2.99691194e-04f, 1.04191480e-03f, -3.25087607e-02f,
  -1.13541476e-01f, -4.07473184e-02f, -7.20589459e-02f, 1.57834534e-02f, 5.21652587e-03f, -4.65638191e-03f, -2.90916990e-02f, -4.08425890e-02f, 3.90649624e-02f, -6.21292135e-03f,
  5.84124066e-02f, -3.60125937e-02f, 8.38597398e-03f, 1.61019444e-01f, 2.68131886e-02f, 6.01793192e-02f, 7.95518532e-02f, -7.71442875e-02f, -1.39449328e-01f, -9.24547613e-02f,
  5.33651039e-02f, 1.50009841e-01f, 2.02026893e-03f, 2.35125404e-02f, 7.53604323e-02f, 2.35422160e-02f, -4.16429043e-02f, 3.15622278e-02f, 3.73401009e-02f, -1.33445607e-02f,
  -6.75232783e-02f, -6.11551777e-02f, -3.40365134e-02f, -7.13805854e-02f, -2.17804060e-04f, -7.97392987e-03f, 9.15196352e-03f, -4.56243791e-02f, -3.16083170e-02f, -4.18723784e-02f,
  -2.76946165e-02f, -1.00046597e-01f, 1.37123331e-01f, -3.44753824e-02f, -1.51393590e-02f, 6.03725091e-02f, -2.55239718e-02f, -1.86814752e-03f, -6.81488141e-02f, -8.94103795e-02f,
  -5.91091394e-01f, -3.69441330e-01f, 1.15941488e-03f, -1.72469378e-01f, -1.19087465e-01f, -3.71143706e-02f, -2.76975781e-02f, -1.10905103e-01f, -1.50326520e-01f, -1.23039812e-01f,
  -2.54175887e-02f, -1.00809000e-02f, -6.22486845e-02f, 5.67252748e-02f, 2.96497960e-02f, -4.35249172e-02f, -1.77373867e-02f, -4.73114103e-02f, -8.82683694e-02f, -6.80352822e-02f,
  -5.91489822e-02f, 4.16881107e-02f, 5.55114001e-02f, 1.24846488e-01f, 1.42350849e-02f, -5.05370870e-02f, -3.06271240e-02f, 9.34811868e-03f, -8.57879519e-02f, -8.35666712e-03f,
  2.83956140e-01f, -1.82700202e-01f, -2.26799622e-01f, -1.88539363e-02f, 5.30468784e-02f, 1.15754865e-01f, -8.67906660e-02f, -1.15846686e-01f, -3.71549547e-01f, -1.10472078e-02f,
  1.99306875e-01f, 5.45656197e-02f, -1.79851592e-01f, 4.18001562e-01f, 2.67480284e-01f, -4.31893691e-02f, 2.40221798e-01f, 2.37447277e-01f, -1.30365327e-01f, 8.01503658e-02f,
  6.42796308e-02f, 4.30562675e-01f, -9.05390531e-02f, 2.64426079e-02f, 1.85022891e-01f, -1.84008121e-01f, 9.62431058e-02f, -9.87889394e-02f, 1.49739757e-01f, 1.73376441e-01f,
  -3.24041769e-03f, -1.73511053e-03f, -9.53271389e-02f, -6.00731559e-03f, 1.51789654e-02f, 5.76841738e-03f, 1.92553923e-03f, 1.16228506e-01f, -3.56301889e-02f, 8.49767064e-04f,
  5.80168189e-03f, 1.11798076e-02f, -2.02158783e-02f, -2.62099262e-02f, 4.62343395e-02f, -2.85000633e-02f, -9.84090120e-02f, -7.26938993e-02f, -1.17432714e-01f, 5.69511838e-02f,
  -8.87863934e-02f, 5.35248145e-02f, -1.74494274e-02f, 2.20056400e-02f, -2.07873076e-01f, -2.90986504e-02f, -1.09548718e-01f, -8.68065879e-02f, 8.77391025e-02f, -5.29680355e-03f,
  5.19760922e-02f, 1.13600373e-01f, 1.45073384e-02f, 5.18636927e-02f, -2.12876629e-02f, -2.23552808e-03f, 3.72091718e-02f, -8.99906829e-02f, -1.65830441e-02f, -4.02408913e-02f,
  -1.10024940e-02f, -3.80213037e-02f, 9.91233587e-02f, 5.04514785e-04f, 2.27309708e-02f, 8.39252248e-02f, 1.16155474e-02f, -6.51232377e-02f, -1.03375196e-01f, -1.55793920e-01f,
  -3.00529636e-02f, -2.73444280e-02f, -7.34869856e-04f, -2.06187125e-02f, 1.58261672e-01f, 3.38900015e-02f, 1.45754620e-01f, -5.67644984e-02f, -4.42214161e-02f, 4.98113409e-02f,
  -1.61303896e-02f, -4.65180278e-02f, -1.25939995e-01f, 4.56821583e-02f, -8.89784992e-02f, 8.86087194e-02f, 2.50110915e-03f, -8.50907862e-02f, -7.57363951e-03f, -4.57728989e-02f,
  -1.38377016e-02f, -1.00698635e-01f, 4.27075364e-02f, -4.00155596e-02f, -9.16568562e-02f, 1.12449033e-02f, 3.07749156e-02f, -1.96158290e-02f, -7.70810694e-02f, 2.37369984e-02f,
  1.86724234e-02f, -1.33388238e-02f, 3.41746472e-02f, -1.48278132e-01f, -5.64829819e-03f, 1.13034196e-01f, -5.55616096e-02f, -8.06834549e-02f, 1.53129503e-01f, -1.33476436e-01f,
  1.09529458e-02f, -2.31863260e-01f, -1.22887857e-01f, 2.28720352e-01f, 7.38826953e-03f, -1.79664418e-01f, -1.08163618e-01f, 9.39256400e-02f, -1.98158380e-02f, -2.14660205e-02f,
  2.03588799e-01f, 1.58323973e-01f, -1.31233424e-01f, 4.46238726e-01f, 2.98837751e-01f, -1.12243958e-01f, 1.89820573e-01f, 9.22371298e-02f, 8.98634791e-02f, 1.07647225e-01f,
  1.79957867e-01f, 2.21907482e-01f, 3.50184590e-01f, 2.50291467e-01f, 1.62135273e-01f, 2.59829074e-01f, 3.77482772e-01f, -4.28253189e-02f, 4.79312122e-01f, 9.13410410e-02f,
  -3.60883074e-03f, 1.01131247e-03f, 2.33323257e-02f, -7.08098039e-02f, 2.16230340e-02f, -1.09305151e-01f, 6.52255490e-02f, 4.29057442e-02f, -1.98463965e-02f, 3.25953364e-02f,
  -1.28818646e-01f, 1.75530333e-02f, 1.91225056e-02f, 6.42007589e-02f, -3.16796489e-02f, -2.01303209e-03f, 8.85131955e-02f, 1.72812231e-02f, -6.60227984e-03f, 3.90111133e-02f,
  -5.07271849e-02f, -6.51996434e-02f, 2.16937009e-02f, -3.66251022e-02f, -1.55210374e-02f, -6.33223951e-02f, -1.42124435e-02f, -6.58066124e-02f, -4.24644537e-02f, 1.18755631e-01f,
  -4.86748032e-02f, 4.25573532e-03f, -6.34035468e-02f, -1.23376548e-02f, 8.22053873e-04f, 4.65497095e-03f, 7.74785802e-02f, 1.10269159e-01f, -2.34894408e-03f, 2.63767410e-02f,
  2.41907891e-02f, 6.09619878e-02f, 4.49594893e-02f, -6.01689890e-02f, -6.69468148e-03f, 1.32034309e-02f, 2.65644640e-02f, 1.03190735e-01f, -1.03265263e-01f, 1.01641290e-01f,
  1.47435265e-02f, -2.66235061e-02f, -3.47923972e-02f, -3.19888517e-02f, 2.53718235e-02f, -3.91414948e-02f, -1.98395867e-02f, 6.49782494e-02f, -9.32171848e-03f, -6.95165172e-02f,
  -1.83362551e-02f, 6.33919910e-02f, -9.82479565e-03f, 3.56251895e-02f, 3.46324705e-02f, -5.24307527e-02f, -4.75000702e-02f, 3.46762426e-02f, -4.02024500e-02f, -1.07511386e-01f,
  4.60207611e-02f, 2.60563549e-02f, -7.49297217e-02f, 2.15675924e-02f, 6.78925142e-02f, -9.18033421e-02f, -5.85982725e-02f, 7.60296434e-02f, 1.50956109e-01f, 1.07535630e-01f,
  2.22118217e-02f, -4.01186049e-02f, -7.00289309e-02f, -1.35611922e-01f, 8.81260484e-02f, -4.90260730e-03f, 5.16182818e-02f, -1.44641817e-01f, 2.01705564e-02f, 6.80707097e-02f,
  -1.11343488e-01f, -1.12628967e-01f, 1.79446936e-01f, -2.79226303e-01f, 8.79375413e-02f, -1.61208715e-02f, 6.38876110e-02f, -1.06568031e-01f, -1.32915750e-01f, -1.83258832e-01f,
  -1.30900323e-01f, 1.38952777e-01f, 1.87643677e-01f, -2.08993956e-01f, 1.94834992e-01f, 1.39953449e-01f, -2.24146172e-01f, -5.38258106e-02f, -1.45131141e-01f, -4.47566174e-02f,
  -3.73371094e-02f, -2.17210516e-01f, -6.08603703e-03f, -1.31841898e-01f, -2.72346791e-02f, -2.82380842e-02f, 3.17687318e-02f, 4.58416007e-02f, -6.96281418e-02f, 1.56901181e-01f,
  -1.89845249e-01f, -8.37302059e-02f, -3.54754068e-02f, 2.61937473e-02f, -1.25692070e-01f, 8.46593454e-02f, 4.55371253e-02f, 3.32665294e-02f, -2.67462227e-02f, 4.16399911e-02f,
  -2.18996946e-02f, -2.07767878e-02f, -1.53804287e-01f, 2.91115381e-02f, -3.76082659e-02f, -3.11210733e-02f, -1.21836774e-02f, -8.12512413e-02f, -5.15776165e-02f, 3.14911790e-02f,
  -2.95714494e-02f, -5.68971261e-02f, -3.08162551e-02f, -5.18656299e-02f, 5.31122647e-02f, -1.94323793e-01f, 1.08045638e-01f, 1.64051890e-01f, 4.65564290e-03f, -1.30515948e-01f,
  1.55728795e-02f, 7.21722320e-02f, -3.62971388e-02f, -3.80616933e-02f, -2.27881804e-01f, -3.15908082e-02f, 5.29191010e-02f, -4.81826812e-02f, -6.28862083e-02f, -5.24169430e-02f,
  4.94943326e-03f, 1.23807900e-01f, 1.44704446e-01f, -1.38798170e-02f, -2.08245501e-01f, 1.05112769e-01f, 4.89053391e-02f, -6.23727962e-02f, -3.88814160e-03f, -1.17922425e-01f,
  -1.41579315e-01f, 6.71529174e-02f, 1.06030777e-01f, 2.91056745e-03f, 8.65762979e-02f, 8.53671879e-03f, -6.13562949e-02f, 1.32673740e-01f, 7.72247091e-02f, 6.11748211e-02f,
  -2.69955277e-01f, -2.17648134e-01f, -1.30763829e-01f, -4.09681015e-02f, -1.22861840e-01f, 1.01579428e-01f, -6.79946318e-02f, -6.32233173e-02f, -5.05509563e-02f, 8.02170560e-02f,
  -1.08152106e-01f, -3.83804254e-02f, -4.09594774e-02f, -1.88890584e-02f, -1.05454884e-01f, -1.39947295e-01f, -1.44776031e-01f, -5.83847649e-02f, -1.57925099e-01f, -4.60604578e-02f,
  -1.42733365e-01f, -6.49850294e-02f, -9.47728194e-03f, -9.50856954e-02f, 3.77675667e-02f, -4.55263630e-02f, 1.05658121e-01f, -6.93788677e-02f, 1.20598033e-01f, 1.06434431e-02f,
  9.83922929e-02f, -1.86625332e-01f, -2.72663772e-01f, 2.13386607e-03f, 2.54413873e-01f, 6.26620874e-02f, -3.60189900e-02f, 7.83522725e-02f, -1.45424351e-01f, 1.91531759e-02f,
  1.28621548e-01f, -1.21808298e-01f, -3.27401400e-01f, 3.09730526e-02f, 8.78644660e-02f, -3.65102500e-01f, 1.19106315e-01f, -6.72825798e-02f, -1.13065355e-01f, 3.62761132e-02f,
  -5.18054441e-02f, 2.95646071e-01f, 9.86907631e-02f, 2.94734150e-01f, 1.20577760e-01f, 5.55217080e-02f, 3.02615792e-01f, 5.68274632e-02f, 3.98111522e-01f, 2.59026978e-02f,
  -1.01558818e-02f, -1.28454044e-01f, -4.46701385e-02f, 5.37026562e-02f, 6.40966967e-02f, 4.37838174e-02f, 2.88048461e-02f, -7.67586976e-02f, -5.26024736e-02f, -1.30946517e-01f,
  -9.42459106e-02f, 5.35897398e-03f, 3.70693132e-02f, 1.80047929e-01f, 6.63723275e-02f, 6.40707165e-02f, 5.94327189e-02f, 8.13388750e-02f, 3.88897560e-03f, -1.50865793e-01f,
  -1.75371945e-01f, 2.53228266e-02f, -7.51375034e-02f, 8.37112814e-02f, 5.28113730e-02f, -2.12234408e-02f, 3.41415335e-03f, 5.57211600e-02f, -5.54074198e-02f, -2.37226244e-02f,
  4.62966971e-02f, -2.88247019e-02f, -1.67638943e-01f, -1.40837938e-01f, -1.96337816e-03f, 3.40644903e-02f, 2.51062121e-02f, -4.99303937e-02f, -1.06699802e-01f, 8.93030241e-02f,
  2.74547134e-02f, 2.26558335e-02f, -1.19047962e-01f, 2.73348279e-02f, 3.25879939e-02f, -9.89162177e-02f, 3.19184326e-02f, 1.70204520e-01f, 5.63030206e-02f, 1.21152243e-02f,
  -6.20073229e-02f, 9.65335369e-02f, 1.13757946e-01f, -6.28483435e-03f, -4.39455397e-02f, 1.53677464e-01f, 7.94581603e-03f, 1.03618518e-01f, 9.13015474e-03f, -1.40763894e-02f,
  3.67792509e-03f, -2.36671809e-02f, -4.97559682e-02f, 2.83121038e-02f, -8.89690965e-02f, -5.19380393e-03f, -1.07237928e-01f, 4.14534546e-02f, -7.27928430e-02f, -7.23101944e-02f,
  1.17309764e-01f, 1.23984359e-01f, -4.24150974e-02f, 1.10276900e-01f, 3.41795087e-02f, 1.32543325e-01f, -5.33719584e-02f, 8.92629325e-02f, 2.47609958e-01f, 3.29596959e-02f,
  5.90920113e-02f, 1.56862438e-01f, -9.74797085e-02f, 9.69401598e-02f, 6.73669651e-02f, 4.90538403e-02f, 1.17575124e-01f, -7.39815608e-02f, -1.03491805e-01f, -1.01367742e-01f,
  -4.52113837e-01f, 2.13224694e-01f, 2.24173553e-02f, 4.63269055e-01f, -1.99869826e-01f, -2.26918911e-03f, 1.26614153e-01f, 9.40630957e-02f, -2.35975496e-02f, 3.27320933e-01f,
  3.61654729e-01f, -2.11370960e-01f, 2.28857949e-01f, 5.72511554e-01f, -7.66062737e-02f, 3.15267205e-01f, 2.73170739e-01f, 1.79830402e-01f, -1.75284818e-01f, 1.32638410e-01f,
  7.87774399e-02f, 2.36374378e-01f, 2.97604710e-01f, -6.60256222e-02f, -4.32088189e-02f, -3.38370427e-02f, 1.32791728e-01f, -1.14973299e-01f, 2.72512585e-01f, -1.56091690e-01f,
  -1.56994816e-02f, 7.49073178e-02f, -1.44381179e-02f, -1.69796079e-01f, -5.70920575e-03f, 6.12722710e-02f, -3.21657993e-02f, -1.50196686e-01f, -3.24538536e-02f, -7.73032159e-02f,
  -1.14716016e-01f, -1.24896877e-01f, -1.02280140e-01f, -6.82084337e-02f, -4.10529077e-02f, -4.63490188e-02f, -1.27171157e-02f, -5.07071055e-02f, 2.83312891e-03f, -4.98633012e-02f,
  -1.89641956e-02f, -3.56215723e-02f, 1.01845264e-01f, 3.79099473e-02f, -1.82489934e-03f, 7.51277506e-02f, 2.60314830e-02f, -4.07255925e-02f, -5.26333507e-03f, -1.37727842e-01f,
  -6.41759858e-02f, 1.02368323e-02f, 6.11761324e-02f, 6.27643690e-02f, 3.49892713e-02f, 5.82668111e-02f, 8.97725224e-02f, 2.59691197e-03f, -1.94508955e-02f, 1.01496726e-01f,
  -1.62056498e-02f, 5.08067757e-02f, 8.05498660e-02f, -3.10487356e-02f, -1.06334211e-02f, 5.09585813e-03f, 3.77371870e-02f, 6.97545940e-03f, 8.78351778e-02f, 2.12652348e-02f,
  -3.06400713e-02f, -1.00585036e-01f, 1.12821221e-01f, 8.89797062e-02f, 4.73036692e-02f, -9.17490274e-02f, 2.35076528e-02f, 3.14796492e-02f, 1.03130512e-01f, 3.55202407e-02f,
  1.78442568e-01f, 9.65043604e-02f, 7.34925419e-02f, -2.88689174e-02f, 1.00177117e-01f, -6.07579425e-02f, 9.66050476e-03f, -3.69910188e-02f, 6.74726292e-02f, -4.83470075e-02f,
  -2.62636561e-02f, -5.91699146e-02f, 5.14020445e-04f, 2.10743621e-02f, -2.09903084e-02f, 8.57592747e-02f, 1.13003038e-01f, -1.40184686e-02f, 6.21942617e-02f, 1.23769008e-01f,
  7.60700479e-02f, -1.22704364e-01f, -9.67333987e-02f, 7.53084803e-03f, -7.69864628e-03f, -8.33320171e-02f, -8.18086714e-02f, -1.13581412e-01f, -2.20789108e-02f, 6.43631443e-03f,
  -3.31503421e-01f, -7.36957118e-02f, 3.36801648e-01f, -2.08558246e-01f, -7.88976103e-02f, 3.75953376e-01f, 3.06700796e-01f, -6.56772107e-02f, -1.21971652e-01f, -5.39851896e-02f,
  9.68973860e-02f, -1.85188264e-01f, 2.67102152e-01f, -1.22750238e-01f, 3.39567631e-01f, 1.30654201e-01f, -9.09106061e-02f, 7.38155991e-02f, -8.67213532e-02f, -2.09930986e-01f,
  -1.63175195e-01f, -3.11636418e-01f, 4.77331579e-02f, -1.21417545e-01f, -2.07304701e-01f, -2.42183939e-01f, -9.28432643e-02f, 1.31910026e-01f, -1.06645569e-01f, 8.52046981e-02f,
  -3.38109210e-02f, -2.79903889e-01f, -1.17426023e-01f, 6.42130524e-02f, -3.91923562e-02f, 4.78672124e-02f, 9.55947936e-02f, 1.12943292e-01f, -6.22326434e-02f, -3.88179794e-02f,
  -1.33590460e-01f, -3.37119028e-02f, -7.07202852e-02f, 3.47662456e-02f, -8.94721523e-02f, 9.38327797e-03f, 3.63165066e-02f, 5.48073016e-02f, -5.08586504e-02f, 1.00858040e-01f,
  8.75335336e-02f, 1.59195124e-03f, -7.25474507e-02f, -1.00050107e-01f, -9.08589661e-02f, -1.74586158e-02f, -3.05191241e-02f, 9.86090954e-03f, -1.15532845e-01f, -1.01731651e-01f,
  1.61595404e-01f, -2.07061358e-02f, 3.10645290e-02f, -4.75310721e-02f, -3.26875262e-02f, -9.60616171e-02f, -1.01930343e-01f, 1.43544991e-02f, -1.15493506e-01f, -5.82536757e-02f,
  -1.30150497e-01f, -1.34926975e-01f, -1.20253496e-01f, 3.50717567e-02f, -4.06277962e-02f, -7.56430849e-02f, 7.76502956e-03f, -7.05069900e-02f, -2.45809872e-02f, 5.01933843e-02f,
  4.77690771e-02f, 8.97653177e-02f, -7.23730326e-02f, 9.03248638e-02f, 1.35347232e-01f, -8.57655518e-03f, -2.40298122e-01f, -1.38656301e-02f, 1.16267568e-03f, -2.50932779e-02f,
  -2.01500580e-01f, -2.36736462e-01f, 3.48506868e-02f, 4.07239981e-02f, -6.59555383e-03f, 4.00116108e-03f, -5.47678536e-03f, -7.89188072e-02f, -8.70689899e-02f, -6.95626736e-02f,
  6.07488155e-02f, -5.92961684e-02f, -4.90312465e-02f, 8.31085965e-02f, 1.25925213e-01f, 8.66007209e-02f, 9.16556176e-03f, -5.27864061e-02f, -4.21464406e-02f, -7.87707791e-02f,
  5.56330569e-02f, -2.89940834e-02f, 8.58132690e-02f, -1.01491086e-01f, -7.56613463e-02f, 2.48085195e-03f, -6.30111024e-02f, 8.99139643e-02f, 6.92487694e-03f, 5.91053292e-02f,
  3.81510317e-01f, -9.05900747e-02f, 4.09556143e-02f, 4.73315626e-01f, 2.71182775e-01f, 1.26214027e-01f, 9.66209099e-02f, 3.39889109e-01f, 6.82833910e-01f, -1.08557232e-01f,
  -4.87195030e-02f, -1.48299886e-02f, -3.15784633e-01f, 1.95132539e-01f, 5.28041311e-02f, -6.10848144e-02f, 2.34931305e-01f, 4.83822562e-02f, 2.83983618e-01f, 1.19969279e-01f,
  2.31866077e-01f, 1.43608987e-01f, -3.12452078e-01f, -1.78333387e-01f, 2.05432568e-02f, -8.68364125e-02f, -2.18512207e-01f, -2.33953208e-01f, -1.68224439e-01f, -1.02649197e-01f,
  1.15625188e-02f, -5.46585731e-02f, -3.56537174e-03f, 2.05519851e-02f, -3.31796631e-02f, -1.63754210e-01f, -1.39316753e-01f, -2.97596574e-01f, 1.66356079e-02f, -6.06524907e-02f,
  -1.08006872e-01f, -6.93702623e-02f, 5.09863198e-02f, 1.17123492e-01f, 1.20196149e-01f, 1.01826563e-01f, 7.09038079e-02f, 9.75997001e-03f, 4.59700299e-04f, 2.59113945e-02f,
  6.47013187e-02f, 6.77665025e-02f, 4.58065644e-02f, -5.80889955e-02f, -1.45038189e-02f, 8.94774646e-02f, 8.04213509e-02f, -3.59957516e-02f, 4.36732993e-02f, 4.91484478e-02f,
  -8.31927210e-02f, 1.50835663e-02f, -2.90023033e-02f, 3.67986830e-03f, 7.10367709e-02f, 1.78319681e-02f, 1.48151487e-01f, 3.76411863e-02f, 1.43478006e-01f, 5.01620285e-02f,
  7.74668157e-02f, 4.84440699e-02f, 1.59815997e-01f, 2.19050441e-02f, 4.94427374e-03f, 2.03805283e-01f, 1.35216797e-02f, 1.27358185e-02f, -3.27228270e-02f, 6.71977550e-02f,
  9.81233940e-02f, 4.89572324e-02f, -1.05775423e-01f, -7.56369829e-02f, 4.01733033e-02f, 1.52872093e-02f, 3.88339646e-02f, 3.36662009e-02f, 5.06013772e-03f, -4.35205139e-02f,
  5.69848269e-02f, 6.41260073e-02f, -1.03259236e-01f, -1.67157669e-02f, -6.03563562e-02f, 1.41937630e-02f, 5.44791445e-02f, 6.50371760e-02f, -5.37308939e-02f, 9.99610573e-02f,
  -6.69032112e-02f, -2.03664955e-02f, -6.11755997e-02f, -1.41862631e-02f, -7.61955529e-02f, 4.86293882e-02f, -8.87238681e-02f, 2.43712645e-02f, -5.89965209e-02f, -9.58140474e-03f,
  4.65749353e-02f, 5.80702312e-02f, 4.51175012e-02f, 9.82158110e-02f, 9.75907519e-02f, -2.02389047e-01f, 1.20682970e-01f, -2.47803554e-02f, -6.38399273e-02f, -2.67174784e-02f,
  -4.65061255e-02f, 2.42546916e-01f, 5.09398393e-02f, -1.41612589e-01f, 1.37987465e-01f, -3.19546163e-01f, -1.58837706e-01f, -2.50281710e-02f, -1.21977225e-01f, 3.17099899e-01f,
  -2.69903690e-02f, 3.12976062e-01f, -3.33101898e-02f, -2.60674298e-01f, -6.51465237e-01f, -4.47561026e-01f, -2.90375710e-01f, -1.06380153e-02f, -1.35413557e-01f, 1.66698739e-01f,
  -1.22488603e-01f, -3.69981974e-01f, -1.63751006e-01f, 1.66331828e-01f, 8.54439735e-02f, 2.97329545e-01f, 6.09570630e-02f, 1.86108887e-01f, 1.41373679e-01f, -1.86136141e-01f,
  -1.42842531e-01f, 2.37215981e-02f, 9.64605063e-02f, -1.12176165e-02f, 2.27267053e-02f, 1.17921971e-01f, 7.27134496e-02f, -5.30592278e-02f, -3.23134549e-02f, 6.21132404e-02f,
  1.47907376e-01f, -7.20947906e-02f, -6.10748269e-02f, 8.59414972e-03f, 1.39373362e-01f, -2.46884674e-02f, -5.15149571e-02f, 5.36037050e-02f, 4.56862599e-02f, -6.57809898e-02f,
  5.01862764e-02f, 7.66401663e-02f, 1.02131121e-01f, 1.27516510e-02f, -5.29724173e-02f, 1.13440238e-01f, -6.09476827e-02f, 2.43090875e-02f, 8.90738741e-02f, 2.82064229e-02f,
  3.74327078e-02f, 1.59113258e-02f, -9.24332291e-02f, 5.27859032e-02f, 1.22825941e-02f, -3.49058658e-02f, -1.10026598e-01f, 3.08179384e-04f, 6.28965497e-02f, -2.99966708e-02f,
  -4.01241817e-02f, 6.96247071e-02f, -1.30336257e-02f, 1.70127824e-01f, 1.87161993e-02f, 3.18507738e-02f, 7.98344463e-02f, -3.03799286e-02f, -1.58219486e-02f, 1.40654389e-02f,
  -4.35749963e-02f, -2.11640671e-02f, -4.24986100e-03f, 3.24813463e-02f, -1.35899261e-01f, -3.64816673e-02f, 2.64971349e-02f, -1.74991656e-02f, 1.23132374e-02f, 5.03820516e-02f,
  -9.40370262e-02f, 4.84999046e-02f, 3.69627066e-02f, -6.08773045e-02f, -1.48450853e-02f, 2.04386245e-02f, -1.36365861e-01f, -5.89985214e-02f, -3.61294337e-02f, -6.94734603e-02f,
  1.71862036e-01f, 1.08767219e-01f, 1.15764216e-01f, 9.13035795e-02f, -2.72960048e-02f, -7.43804425e-02f, 1.79314271e-01f, 7.17584118e-02f, 4.15080562e-02f, 4.71678749e-02f,
  1.28128856e-01f, 1.46379232e-01f, -2.66064182e-02f, 4.58462425e-02f, 8.22087079e-02f, 1.11738957e-01f, 2.32907124e-02f, 1.04847670e-01f, -5.32967597e-03f, -1.66355725e-02f,
  5.56004196e-02f, -1.04796417e-01f, 1.95337281e-01f, -9.46353748e-02f, 6.16935454e-02f, -8.71484727e-03f, 9.71531421e-02f, -2.32166409e-01f, -2.09866136e-01f, -1.21569350e-01f,
  -3.39451954e-02f, 2.33381063e-01f, 9.79158431e-02f, -8.92371386e-02f, 1.79590330e-01f, 6.17477037e-02f, -1.26519874e-01f, 3.16213071e-02f, -1.26173019e-01f, -1.62901193e-01f,
  -1.71911031e-01f, -3.70963693e-01f, 1.01810358e-01f, -1.51885062e-01f, 1.07094206e-01f, -4.61717844e-02f, -3.13891321e-02f, 2.57150233e-02f, -5.61489575e-02f, 2.28989527e-01f,
  -1.02738567e-01f, -1.94372162e-01f, -1.41684383e-01f, -8.29526186e-02f, -7.25819170e-02f, 9.06370506e-02f, 1.43611562e-02f, 1.71540007e-01f, -1.46821691e-02f, 4.29674005e-03f,
  9.63782221e-02f, 7.65570179e-02f, -3.37227173e-02f, 7.26139694e-02f, 5.52573008e-03f, 4.51908186e-02f, -1.02882078e-02f, 2.92773619e-02f, -5.23572974e-03f, 9.78955254e-02f,
  -3.72024775e-02f, -1.49677740e-02f, -7.55468532e-02f, 4.98619378e-02f, 2.85290815e-02f, -3.25203091e-02f, -5.24670929e-02f, 1.41774699e-01f, 6.58446550e-02f, -1.39957488e-01f,
  7.15690851e-02f, -1.47505939e-01f, -1.11293614e-01f, 2.57760752e-02f, -4.87534665e-02f, -9.49297994e-02f, -1.81537598e-01f, -7.65410736e-02f, -4.62366641e-02f, -1.67770479e-02f,
  -1.48863427e-03f, 4.08208631e-02f, 5.09781465e-02f, -1.02373391e-01f, -3.07124052e-02f, 1.44309122e-02f, 2.98788976e-02f, -4.47849296e-02f, -7.99836442e-02f, 8.91493410e-02f,
  -4.95494567e-02f, -2.17633527e-02f, 1.30504787e-01f, 2.93774679e-02f, -6.45322576e-02f, 1.99655979e-03f, -2.41536666e-02f, 1.18593328e-01f, 7.10998923e-02f, 2.54008602e-02f,
  -2.63051867e-01f, -2.70361304e-01f, -8.08591917e-02f, 1.68741122e-02f, 1.05494801e-02f, 2.45562680e-02f, -1.15674675e-01f, -4.68961038e-02f, -1.24329440e-02f, -8.14373121e-02f,
  -7.72709027e-02f, 5.00126556e-02f, -1.07183028e-02f, -1.16217192e-02f, 3.98851372e-02f, -5.78933395e-02f, 3.89370248e-02f, 1.43972784e-02f, -1.33947402e-01f, 8.14017802e-02f,
  2.93975268e-02f, -1.54251270e-02f, 2.25055255e-02f, -5.28326593e-02f, -1.27078116e-01f, 3.96467857e-02f, 9.20916498e-02f, 1.57298461e-01f, 1.37713356e-02f, 4.68247533e-02f,
  -4.39749449e-01f, 6.97279302e-03f, -3.03354830e-01f, -2.28383422e-01f, 9.61827114e-02f, -4.79635477e-01f, -1.84115350e-01f, 1.77686632e-01f, 1.33426204e-01f, 1.48358822e-01f,
  8.23475793e-02f, 1.31101981e-02f, 1.52620524e-01f, -2.09017307e-01f, -2.86934197e-01f, -4.29459736e-02f, -3.47272843e-01f, -3.08410317e-01f, 6.49945438e-03f, -1.22617766e-01f,
  -1.67779982e-01f, -3.60293239e-02f, -3.28672022e-01f, 1.05909392e-01f, -1.70999631e-01f, 2.65340228e-02f, 1.60508245e-01f, 1.32356018e-01f, -2.19841242e-01f, 6.43312111e-02f,
  -2.01159175e-02f, 2.56378412e-01f, -3.58292311e-02f, 5.13126329e-02f, -7.76904076e-02f, -9.86955687e-02f, -1.08699031e-01f, 1.05006760e-02f, -3.38076353e-02f, -1.11696906e-02f,
  3.90981399e-02f, 7.80504271e-02f, -3.54003608e-02f, 2.51020119e-02f, -3.18449060e-03f, -3.46247479e-02f, 8.00440609e-02f, -1.27278924e-01f, -4.08398770e-02f, -1.00559043e-02f,
  1.72474440e-02f, -4.34784312e-03f, -1.45270869e-01f, -6.86280988e-03f, 8.57403353e-02f, 1.43948495e-01f, -4.98643480e-02f, 6.40116781e-02f, 1.63013185e-03f, 8.58120024e-02f,
  7.10638613e-02f, -2.01303929e-01f, -1.52296633e-01f, 1.02739932e-03f, 8.21809769e-02f, 5.50405234e-02f, -6.14768118e-02f, 1.18788026e-01f, 3.01558301e-02f, 7.28216395e-02f,
  -5.89840002e-02f, -2.63526030e-02f, -4.53072134e-03f, -9.72001627e-02f, -2.03196272e-01f, -4.87432107e-02f, -1.23255394e-01f, 1.37435310e-02f, -5.34109250e-02f, -2.10942831e-02f,
  1.23968862e-01f, 1.42357443e-02f, 3.11761685e-02f, 2.96028843e-03f, -1.15281753e-02f, -2.30508968e-02f, 6.49722219e-02f, -3.09342053e-02f, -1.46928325e-01f, -8.42423216e-02f,
  1.48422113e-02f, 1.41570315e-01f, 4.77321744e-02f, 1.44993111e-01f, 8.46680440e-03f, -1.13988250e-01f, 3.53548266e-02f, -2.67368136e-03f, -6.19626567e-02f, -5.89113720e-02f,
  -2.47901957e-02f, -8.70753005e-02f, -2.12658849e-02f, 1.29030779e-01f, 3.68183069e-02f, -5.59307169e-03f, 9.87564679e-03f, -9.83826891e-02f, -2.52046492e-02f, 6.91042170e-02f,
  -3.51580232e-02f, -2.16432102e-02f, -1.86369494e-02f, -2.62077507e-02f, 4.41441275e-02f, 4.38349247e-02f, -7.41730109e-02f, -4.07400914e-02f, 1.21491747e-02f, -7.54509028e-03f,
  1.29419602e-02f, -1.44930676e-01f, -1.13033287e-01f, -4.55515742e-01f, 8.33481774e-02f, 1.60401717e-01f, -8.31466541e-03f, 6.37985989e-02f, -2.40615711e-01f, 3.22644830e-01f,
  2.22410783e-01f, -1.75003856e-01f, -9.08697397e-03f, -1.93609491e-01f, -4.26200032e-01f, -1.60692349e-01f, -2.78156132e-01f, -1.99760310e-03f, -1.67623594e-01f, 4.33500297e-02f,
  -2.04518408e-01f, -6.34831935e-02f, -1.68228447e-01f, 2.39660442e-02f, -1.33732008e-02f, 2.84356177e-02f, 7.96812624e-02f, 2.06832767e-01f, 1.38075845e-02f, 5.65150455e-02f,
  4.33333255e-02f, 1.32727742e-01f, 1.00781210e-01f, -1.96598354e-03f, 1.50416315e-01f, 1.47529319e-01f, 2.21511591e-02f, -6.30706474e-02f, 3.66704948e-02f, -6.21380098e-02f,
  -2.19949521e-02f, -6.26567379e-02f, -2.01077741e-02f, -2.00723968e-02f, -5.81245385e-02f, -4.72474322e-02f, -9.03763101e-02f, 3.14273089e-02f, -8.73117894e-02f, -8.24847631e-03f,
  -8.14900622e-02f, -5.31409085e-02f, 3.24620381e-02f, -6.54635206e-02f, 8.93809088e-03f, -1.69787388e-02f, 5.30890524e-02f, 1.23137981e-01f, -2.30212193e-02f, -1.24454191e-02f,
  9.81391147e-02f, -5.18816002e-02f, -5.06584113e-03f, -1.42936781e-01f, 5.01648113e-02f, 3.17093059e-02f, -1.50570869e-01f, -4.65813000e-03f, 2.65187249e-02f, 1.61338132e-03f,
  -1.39295325e-01f, -3.11611220e-02f, 4.95524071e-02f, -4.57401909e-02f, -2.77002305e-02f, 9.54479072e-03f, 1.12175522e-02f, -2.12438013e-02f, -1.84204429e-02f, 2.74556670e-02f,
  -9.47493035e-03f, -1.00646093e-02f, -1.70244463e-02f, -9.84852947e-03f, -1.16015762e-01f, 1.72034483e-02f, -4.73547764e-02f, -5.35701104e-02f, -5.83669730e-02f, 9.53740031e-02f,
  1.71686694e-01f, 1.95602998e-01f, 1.73393205e-01f, 3.66161615e-02f, 6.27905130e-02f, 9.33482721e-02f, 2.48082913e-02f, -3.12915556e-02f, -2.68733948e-02f, -2.20684870e-03f,
  1.67927463e-02f, -3.29780160e-03f, 5.27431630e-02f, 4.44822311e-02f, -9.58933234e-02f, 1.83715031e-01f, -2.33141216e-03f, 4.23338972e-02f, 8.18144828e-02f, 6.12146817e-02f,
  -6.84489906e-02f, 1.32822171e-01f, -9.39756408e-02f, 3.41333114e-02f, 2.18883785e-03f, 8.06270242e-02f, 8.16249847e-02f, 7.30442256e-02f, 6.95626289e-02f, 1.22114934e-03f,
  -2.72717774e-01f, 4.78104860e-01f, 3.59899163e-01f, 2.36744270e-01f, -4.42075163e-01f, -1.61903679e-01f, 1.34751469e-01f, -5.47819631e-03f, 3.04607809e-01f, 3.24451625e-01f,
  -1.15358047e-01f, 2.92404681e-01f, 7.71765225e-03f, 1.07665233e-01f, -2.04491749e-01f, 9.31319743e-02f, 3.50846648e-02f, 1.77939922e-01f, 4.55075093e-02f, 7.04135075e-02f,
  1.65728759e-02f, -7.40966573e-02f, 7.31737614e-02f, -3.09959333e-02f, 9.50671509e-02f, 1.94210932e-01f, -4.89590550e-03f, 2.61871088e-02f, 9.49306339e-02f, -2.52267141e-02f,
  3.02239023e-02f, 1.22415692e-01f, 3.23596746e-02f, 1.08928479e-01f, -3.67716774e-02f, -9.64405686e-02f, 2.01873295e-02f, 2.19116062e-02f, 2.77832430e-03f, 2.88566574e-03f,
  -5.46710826e-02f, 6.27309829e-02f, 4.39966060e-02f, -9.81879011e-02f, -8.75196755e-02f, 1.26617059e-01f, -9.00767148e-02f, -1.03365861e-01f, 1.00195162e-01f, -1.22673213e-02f,
  -1.36929080e-01f, 1.29578665e-01f, 5.41438125e-02f, 1.24629609e-01f, 5.73479906e-02f, 1.19487390e-01f, 9.82320085e-02f, 7.34240040e-02f, 2.97373645e-02f, -7.57521391e-02f,
  -6.85150474e-02f, 1.18643232e-01f, -5.30431559e-03f, 7.21582621e-02f, -8.21884908e-03f, 1.16234280e-01f, -1.40592664e-01f, -1.11513726e-01f, 1.91186916e-03f, -1.06799249e-02f,
  1.03013448e-01f, 5.66241890e-02f, 1.65907741e-02f, -3.48513275e-02f, -3.16652320e-02f, 1.35701925e-01f, 6.43138587e-02f, 6.86871186e-02f, -5.62883690e-02f, 8.05158094e-02f,
  1.45268768e-01f, 2.31640320e-02f, 7.56855980e-02f, -7.07102343e-02f, 1.36460826e-01f, -9.90189612e-04f, 2.21496485e-02f, 7.47742727e-02f, 1.67650968e-01f, -8.98188874e-02f,
  -1.44465221e-02f, 2.57473528e-01f, 6.37298152e-02f, 8.53080526e-02f, 8.96512419e-02f, -5.60080782e-02f, 2.93310899e-02f, -2.11528894e-02f, 2.25306228e-02f, -5.08397492e-03f,
  -1.45797014e-01f, 9.22107324e-02f, -7.77121410e-02f, -2.89137606e-02f, -3.80507954e-05f, 5.81448227e-02f, 6.50924221e-02f, 2.40965039e-02f, -6.50165454e-02f, -3.93626168e-02f,
  -1.32964969e-01f, 2.97814552e-02f, 8.45667198e-02f, 5.34016751e-02f, -2.00191326e-02f, 9.59959719e-03f, -1.23849958e-01f, 8.87646079e-02f, -1.00188904e-01f, -3.76408473e-02f,
  5.44844680e-02f, -5.30798063e-02f, 5.19874059e-02f, 1.55810550e-01f, -2.24867657e-01f, -3.24831843e-01f, -8.12217295e-02f, -1.93048924e-01f, 8.63108709e-02f, -1.80193096e-01f,
  -8.19608420e-02f, 2.57243156e-01f, 2.77574658e-01f, -2.13169232e-01f, 3.75593275e-01f, 2.11646363e-01f, -4.87662107e-02f, -7.34634027e-02f, 1.33685559e-01f, 4.33761775e-02f,
  5.92197068e-02f, -2.28312716e-01f, 2.17051461e-01f, -2.65338421e-01f, -3.10829282e-01f, -1.07899262e-02f, 8.57613906e-02f, -6.74794242e-02f, -1.55052707e-01f, 9.14690550e-03f,
  1.95954554e-02f, -2.78949793e-02f, 3.84274721e-02f, 5.17474189e-02f, -1.46931019e-02f, -2.58707888e-02f, 6.71475008e-02f, 1.80663690e-02f, 3.71157341e-02f, 1.59017425e-02f,
  4.47183587e-02f, -7.84850586e-03f, -6.98071904e-04f, 1.10925235e-01f, -5.56748398e-02f, 5.97712537e-03f, -3.28660533e-02f, 6.05181344e-02f, -2.38061920e-02f, 4.39234963e-03f,
  -2.29737326e-03f, 2.27085631e-02f, 7.42913634e-02f, 1.75366759e-01f, 1.04096122e-01f, -8.79596323e-02f, 8.26648995e-02f, 7.39005953e-02f, 5.95004372e-02f, 3.80857475e-02f,
  -4.91155498e-03f, 2.75787972e-02f, -8.51506069e-02f, -6.36489391e-02f, 3.07775065e-02f, 2.67221350e-02f, 4.50512255e-03f, 3.42425541e-03f, -4.49937060e-02f, 4.17811945e-02f,
  -2.91660093e-02f, -1.23468801e-01f, -1.35881647e-01f, -3.85267511e-02f, -1.15921989e-01f, 6.03157282e-03f, 8.98997039e-02f, 6.17776811e-02f, 1.72818646e-01f, 7.61247519e-03f,
  7.34823123e-02f, 1.05450816e-01f, -1.80659547e-01f, -5.27046770e-02f, -1.22057445e-01f, 3.64416987e-02f, 8.84494334e-02f, -5.22988848e-02f, -2.82884575e-02f, 5.80112748e-02f,
  8.53959844e-02f, 2.00121522e-01f, -4.91890591e-03f, 1.22721858e-01f, 1.79515872e-02f, -1.05013223e-02f, 1.40593313e-02f, -1.12458013e-01f, 1.17265999e-01f, 4.20941822e-02f,
  -2.32255030e-02f, 2.64872536e-02f, 1.03303663e-01f, 1.90348327e-02f, 1.14707544e-01f, -4.89929039e-03f, 1.20214857e-01f, 1.13924272e-01f, 8.79011378e-02f, 1.34901091e-01f,
  5.55670336e-02f, 3.91327813e-02f, 1.33922309e-01f, -9.98745635e-02f, 6.20249286e-03f, -4.69905790e-03f, -7.31058419e-02f, -1.39792552e-02f, 9.40491930e-02f, 1.39335036e-01f,
  3.50661218e-01f, -4.67601031e-01f, 9.18074250e-02f, 3.34481448e-01f, 3.88485193e-01f, 8.46936405e-02f, 2.44584441e-01f, -3.15623060e-02f, 9.82955694e-02f, -3.68973464e-01f,
  -6.86988458e-02f, -2.86738761e-02f, -2.50440747e-01f, -1.26346927e-02f, 3.45650643e-01f, -2.01950148e-01f, 2.06290990e-01f, 6.32749917e-03f, -9.51041058e-02f, -9.05666351e-02f,
  1.92845181e-01f, 1.75862178e-01f, 1.55714735e-01f, -1.15322895e-01f, 1.45526826e-01f, -1.12559348e-01f, 1.69403050e-02f, 9.47370194e-03f, 5.42341881e-02f, 2.42965654e-01f,
  6.56287819e-02f, 2.15655379e-03f, 1.04911879e-01f, 8.60731874e-04f, -1.50342539e-01f, -5.09722196e-02f, 2.42214166e-02f, 1.03252843e-01f, 1.46964133e-01f, -7.02874810e-02f,
  3.82476579e-03f, 8.08242112e-02f, -2.83323564e-02f, 6.11708798e-02f, 1.20787896e-01f, 6.68885931e-02f, 1.25262914e-02f, -2.31595542e-02f, 7.19506070e-02f, -1.26575992e-01f,
  -1.00033395e-01f, -3.79904099e-02f, 8.12334195e-02f, -2.22730497e-03f, 8.67376197e-03f, 5.24854176e-02f, 1.12586096e-02f, -7.32183736e-03f, -1.73155200e-02f, 2.26836167e-02f,
  -9.66296718e-02f, -8.31569359e-03f, -1.06922634e-01f, 1.21308886e-01f, 4.05397639e-02f, 1.33450270e-01f, 5.10110408e-02f, -6.68810308e-02f, -5.33746406e-02f, 2.80315697e-04f,
  -3.80413122e-02f, 2.49884222e-02f, 5.74695878e-04f, 3.62201929e-02f, -5.29904105e-02f, 1.19686425e-01f, 2.28257421e-02f, -2.82353908e-02f, -5.91404922e-02f, 1.40358493e-01f,
  -2.03027334e-02f, 5.71896471e-02f, -3.70257767e-04f, 6.86442386e-03f, 7.18977451e-02f, -7.32439803e-03f, -3.13544907e-02f, -5.65447137e-02f, -4.18521129e-02f, -8.31414759e-02f,
  -1.71460763e-01f, -4.70022500e-01f, -3.49043980e-02f, 9.46360379e-02f, -9.53077227e-02f, -1.14479758e-01f, 5.58636002e-02f, -9.36580747e-02f, -8.81903097e-02f, -1.12542249e-01f,
  -1.14036448e-01f, -2.61803009e-02f, -9.63963121e-02f, 9.39101651e-02f, 6.71622455e-02f, -1.16882212e-01f, -1.09300561e-01f, -9.61992294e-02f, 6.10264838e-02f, -9.18183625e-02f,
  -8.76981467e-02f, -1.77028552e-01f, 3.98428477e-02f, 1.89212590e-01f, -4.36029769e-02f, -2.66606472e-02f, -8.74924064e-02f, 2.34915819e-02f, -1.79650679e-01f, -8.50664452e-02f,
  -6.44515380e-02f, 3.84544700e-01f, -5.29205252e-04f, -1.52842835e-01f, 2.07928270e-02f, -5.20906985e-01f, -3.71090204e-01f, -9.14028510e-02f, 1.05216004e-01f, 2.69828700e-02f,
  -2.26491839e-01f, 2.63281673e-01f, 6.27514049e-02f, -2.57511854e-01f, -2.86516517e-01f, -1.49839288e-02f, -4.28763926e-01f, -9.72780436e-02f, 9.36361551e-02f, -1.80400148e-01f,
  -7.72653297e-02f, -1.18561856e-01f, -1.82998151e-01f, -2.77116299e-02f, -8.88275206e-02f, 8.89453366e-02f, -7.67034814e-02f, -1.00425668e-01f, -4.20553908e-02f, 9.11755264e-02f,
  -9.72848609e-02f, -3.89129929e-02f, 7.67810866e-02f, 3.01137450e-03f, -2.58628339e-01f, -1.21972755e-01f, -3.50771807e-02f, 2.72954274e-02f, 1.84990037e-02f, 7.77999638e-03f,
  1.51753174e-02f, 1.29170790e-01f, -5.13400994e-02f, 3.68426293e-02f, 1.07281215e-01f, 1.56983376e-01f, 5.17905690e-02f, -1.16876438e-02f, 1.00915179e-01f, 1.03467703e-01f,
  5.33795319e-02f, 1.15756497e-01f, -7.23955557e-02f, -6.72916323e-02f, -2.35042125e-02f, -5.97350970e-02f, 4.78934459e-02f, -9.29923379e-04f, -5.39610386e-02f, 1.43655315e-02f,
  -1.22566715e-01f, -5.45503721e-02f, 2.73758955e-02f, -2.27619279e-02f, -2.92235408e-02f, 1.08892664e-01f, 6.92115575e-02f, 1.39103174e-01f, -9.15980060e-03f, -1.87299669e-01f,
  -6.78231046e-02f, 1.26826437e-02f, -1.07553802e-01f, -1.03511751e-01f, -6.21208511e-02f, 4.47556190e-02f, -3.96976434e-02f, 6.13963045e-02f, -6.42828271e-02f, -1.02724910e-01f,
  5.62661290e-02f, -4.08507772e-02f, -1.07512893e-02f, -7.16987401e-02f, 4.55301628e-02f, 1.06673442e-01f, 7.47713447e-02f, 7.80307874e-02f, -1.23326471e-02f, -8.04045349e-02f,
  -2.24411726e-01f, -2.76664317e-01f, -1.12570442e-01f, -3.48245278e-02f, -1.20696068e-01f, -9.52701718e-02f, -2.19748467e-02f, 1.12954229e-02f, -4.43907268e-02f, -8.59096125e-02f,
  -7.02804774e-02f, -1.04321614e-01f, -7.90615827e-02f, -6.43223599e-02f, -1.65640321e-02f, -1.10777088e-01f, -1.73820496e-01f, 5.03747426e-02f, 2.12257146e-03f, 6.41818941e-02f,
  8.29985514e-02f, -3.14563885e-02f, -9.63144228e-02f, -2.40055248e-02f, -3.66871357e-02f, -7.71688297e-02f, 9.39934477e-02f, 2.14315616e-02f, -5.09097725e-02f, -5.63695515e-03f,
  2.25351319e-01f, -6.67173192e-02f, -3.83965611e-01f, -9.75098461e-03f, 9.59837958e-02f, 2.98719198e-01f, -1.80495102e-02f, -3.47923231e-03f, -2.91619241e-01f, 8.78337249e-02f,
  1.22236863e-01f, -1.63967058e-01f, -2.05870196e-01f, 3.57987076e-01f, 2.33788624e-01f, -6.92217723e-02f, 2.57200509e-01f, 1.54089004e-01f, -1.07737578e-01f, 6.92173317e-02f,
  5.08275405e-02f, 4.76970851e-01f, -1.76186800e-01f, 2.30359703e-01f, 1.77035868e-01f, -1.77920654e-01f, 2.55571324e-02f, -1.84597328e-01f, 1.88269243e-01f, 7.96087906e-02f,
  1.12039141e-01f, -9.40856710e-02f, -7.38284439e-02f, -5.24250492e-02f, -8.91811699e-02f, 8.23252350e-02f, -7.40853027e-02f, 3.60878371e-02f, -4.63400371e-02f, -3.53237614e-02f,
  -2.07940936e-02f, 6.41937330e-02f, 1.20526955e-01f, -8.43282789e-02f, 1.43527305e-02f, 6.21133558e-02f, -3.09932884e-02f, -1.05220415e-01f, -1.30158812e-02f, 5.33062331e-02f,
  -8.90999287e-02f, 3.58011224e-03f, -4.80048209e-02f, -6.57812953e-02f, -1.15346365e-01f, 7.25577073e-03f, -4.40849066e-02f, -6.78316057e-02f, 4.48267832e-02f, -9.16625410e-02f,
  1.06514432e-01f, -1.63462181e-02f, 7.40439966e-02f, 6.58753663e-02f, 2.85604578e-02f, 1.79076213e-02f, 6.44141585e-02f, -9.07423645e-02f, -9.55938175e-02f, -3.73747349e-02f,
  2.11665966e-02f, 2.30022408e-02f, 5.26849031e-02f, 7.01041296e-02f, 3.21914512e-03f, 1.18342293e-02f, 5.36476821e-02f, -5.19118533e-02f, -1.58158049e-01f, -2.22950485e-02f,
  -3.40049807e-03f, -9.78582320e-05f, -2.55381549e-03f, 3.59612852e-02f, 1.31250426e-01f, -5.96062951e-02f, 1.38671522e-03f, -9.04766656e-03f, -1.11761197e-01f, -4.86614997e-04f,
  7.06089064e-02f, -1.37026738e-02f, -7.13334084e-02f, 9.08821449e-02f, -1.06033385e-01f, 1.49930254e-01f, -5.69496788e-02f, 6.39758557e-02f, 1.45022059e-02f, 4.84981574e-02f,
  -5.74767939e-04f, -1.36794262e-02f, -4.35819058e-03f, -6.85626417e-02f, -8.63964781e-02f, -3.78651582e-02f, -7.37607032e-02f, -1.38034821e-01f, -5.53890318e-03f, 1.25120440e-02f,
  1.87063124e-02f, 5.57434447e-02f, 8.23198701e-04f, 8.32244083e-02f, 7.37318322e-02f, -7.04707429e-02f, 6.70644967e-03f, -1.46385729e-01f, 6.00478500e-02f, -1.39953434e-01f,
  2.44826935e-02f, 5.26739478e-01f, 1.13564089e-01f, 2.23956376e-01f, -5.67975342e-02f, 4.16336447e-01f, 3.21529120e-01f, -1.13424482e-02f, 3.79137307e-01f, 2.84362137e-01f,
  -1.34557948e-01f, 3.70867848e-01f, 1.17653729e-02f, 2.31779426e-01f, 8.72496888e-02f, 2.61185199e-01f, 3.77624333e-01f, 1.90189421e-01f, 8.34364146e-02f, 1.69976465e-02f,
  6.89278394e-02f, 4.27681115e-03f, -2.39560217e-01f, -1.97387084e-01f, -2.26180315e-01f, -1.14284575e-01f, -3.22408199e-01f, -1.53435931e-01f, -1.10381365e-01f, -1.95808448e-02f,
  -8.58768448e-02f, 2.98389196e-02f, -1.54070154e-01f, -2.87921634e-02f, 1.49876652e-02f, -1.06845815e-02f, 3.82306753e-03f, -2.62291860e-02f, -6.31442443e-02f, 5.00082597e-02f,
  1.45062640e-01f, 7.07256123e-02f, 7.93929249e-02f, 2.57663452e-03f, -4.32211440e-03f, 1.96063500e-02f, -7.49465358e-03f, -5.63786104e-02f, 5.61968051e-02f, -4.17979248e-02f,
  -7.46037811e-02f, 2.40219496e-02f, -5.36672287e-02f, 3.50675769e-02f, -4.94018085e-02f, 3.76073793e-02f, 3.03050637e-01f, -3.22152190e-02f, 7.35998452e-02f, 1.44931957e-01f,
  -3.37527283e-02f, 1.45225406e-01f, -2.86552887e-02f, -8.83992761e-02f, 3.16820890e-02f, -5.31012863e-02f, 8.08100775e-03f, -4.97340709e-02f, 1.31518036e-01f, 1.42632881e-02f,
  -5.24946302e-02f, -8.34202468e-02f, -1.27485655e-02f, 6.87463954e-02f, 5.75978160e-02f, -2.95253173e-02f, -5.35353608e-02f, -4.16073427e-02f, 8.43268540e-03f, -1.14534311e-01f,
  -8.84636492e-02f, 1.39759228e-01f, -8.04912895e-02f, -9.37000886e-02f, 8.20956901e-02f, -7.51467273e-02f, -3.18275653e-02f, -5.78729436e-02f, -9.15345177e-02f, -6.58826763e-03f,
  1.60279363e-01f, 3.38726640e-01f, 3.41355044e-04f, 9.97265950e-02f, -1.84858274e-02f, 4.86246776e-03f, 3.15415822e-02f, 3.43802609e-02f, -1.32678926e-03f, 2.02608574e-02f,
  6.12693168e-02f, 1.31194234e-01f, 5.00418320e-02f, -7.06163198e-02f, 3.45160104e-02f, 4.85261157e-02f, 1.66888744e-01f, 7.25737810e-02f, 2.86218561e-02f, -1.64030492e-01f,
  -6.35976419e-02f, 1.98615473e-02f, 7.50156417e-02f, 1.18147687e-03f, 5.68191297e-02f, -3.77503559e-02f, -9.15267225e-03f, -8.96372348e-02f, -4.74196002e-02f, 1.01385236e-01f,
  3.19698229e-02f, -5.39483093e-02f, -2.08999030e-02f, 2.31988296e-01f, -4.76479195e-02f, -3.13587666e-01f, -2.57988781e-01f, 1.80048510e-01f, -1.41961202e-01f, -3.05594690e-02f,
  3.48423310e-02f, -1.53005987e-01f, -1.71299949e-01f, -9.01442990e-02f, 2.19593234e-02f, -3.01272422e-01f, 1.30656481e-01f, -2.41809368e-01f, -9.14883986e-02f, 2.32904881e-01f,
  1.75012514e-01f, 1.98666111e-01f, 2.73384213e-01f, 3.24525476e-01f, 2.64783390e-02f, 2.42500022e-01f, 3.72557342e-01f, 1.97907984e-02f, 3.22734803e-01f, -1.36198821e-02f,
  -8.44176188e-02f, 3.29913124e-02f, 3.50028500e-02f, -1.61798164e-01f, 8.67048874e-02f, -7.86277838e-03f, 9.40676429e-04f, -7.21040294e-02f, -5.92224412e-02f, -5.07626645e-02f,
  -6.21186458e-02f, 3.76885533e-02f, 6.91165403e-02f, -3.64187136e-02f, -1.57265235e-02f, 2.10880791e-03f, -1.05320089e-01f, -1.56926382e-02f, -8.25724304e-02f, 1.91735923e-01f,
  1.19087674e-01f, -1.38089629e-02f, 1.05754256e-01f, 6.54887483e-02f, 1.10175215e-01f, -1.70665476e-02f, -1.32328682e-02f, 5.30229472e-02f, -5.06711788e-02f, 1.02692582e-01f,
  1.55852035e-01f, -1.31991178e-01f, -4.89151254e-02f, -8.74333531e-02f, -2.91162846e-03f, 1.52695086e-02f, -1.47960335e-01f, 2.62477566e-02f, -6.56827241e-02f, 5.33538237e-02f,
  -5.12131564e-02f, 1.12466834e-01f, -7.13261738e-02f, -2.68147700e-02f, 7.22892731e-02f, -1.02625631e-01f, -9.40343216e-02f, 7.17225224e-02f, 1.21741794e-01f, -1.52081847e-02f,
  -1.48708552e-01f, -1.17774829e-02f, -3.39921415e-02f, -5.06033637e-02f, -6.18666187e-02f, -2.79399399e-02f, 3.96495871e-02f, -4.98796590e-02f, -1.23707987e-01f, 5.58224041e-03f,
  1.29359454e-01f, 2.36612305e-01f, -2.64531653e-02f, -8.02633539e-02f, -9.58962739e-03f, -1.21154785e-01f, 2.33063810e-02f, 5.80109470e-02f, 3.53057981e-02f, -4.94481251e-02f,
  1.47114038e-01f, 5.23809269e-02f, 2.49722190e-02f, -9.51289162e-02f, 8.29567388e-02f, 1.41955212e-01f, -2.70171240e-02f, -3.87537964e-02f, 1.20617993e-01f, 2.39824697e-01f,
  1.39288008e-01f, 6.31347224e-02f, -1.44355872e-03f, 1.01712504e-02f, 1.25709707e-02f, -9.18497965e-02f, 2.92143915e-02f, 1.56982511e-01f, 5.90343326e-02f, 4.69812937e-02f,
  -1.35063082e-01f, -1.27771392e-01f, -3.64804506e-01f, -1.36770457e-01f, 4.46383029e-01f, 1.12949066e-01f, -1.56061307e-01f, 2.34428942e-02f, -2.33255327e-01f, 1.61914602e-01f,
  9.44008902e-02f, -3.06058675e-01f, -1.59117758e-01f, -2.84700990e-01f, -3.20430964e-01f, -2.85193950e-01f, 9.63880681e-03f, -1.17530502e-01f, -1.99326247e-01f, -5.89421717e-03f,
  -7.95634314e-02f, 1.40641838e-01f, -1.22844584e-01f, 3.49995583e-01f, 1.12137303e-01f, 1.78728223e-01f, 3.36629748e-01f, 1.41637534e-01f, 2.15428114e-01f, -4.11762632e-02f,
  -1.31238714e-01f, -1.85816333e-01f, -2.51370594e-02f, -6.97183535e-02f, -6.94688922e-03f, 9.03568491e-02f, 8.57946500e-02f, -4.68808673e-02f, 2.53682886e-03f, -1.89287052e-01f,
  4.09206981e-03f, 2.65426617e-02f, -4.89728153e-02f, -1.04423910e-01f, -1.67762823e-02f, -2.38847882e-02f, -9.66344327e-02f, -3.89217995e-02f, -8.28283653e-02f, -1.42372355e-01f,
  -1.28512278e-01f, 2.49514095e-02f, 1.41314566e-01f, -2.59910617e-02f, -8.38873982e-02f, -5.45377359e-02f, 1.29427582e-01f, 1.21631380e-02f, 1.46046788e-01f, 1.24453314e-01f,
  3.21612414e-03f, 2.32443720e-01f, 1.09139131e-02f, 2.72678095e-03f, 2.83409934e-02f, -9.56025161e-03f, 1.00229792e-01f, 3.01157013e-02f, 3.69263962e-02f, -6.58472627e-02f,
  5.88430502e-02f, -3.62267084e-02f, -7.90404752e-02f, 4.61796895e-02f, 1.29144071e-02f, -3.71984462e-03f, 1.15134262e-01f, -2.78481264e-02f, -1.20996404e-02f, -6.27518371e-02f,
  -8.28502048e-03f, -5.12807332e-02f, -6.91143125e-02f, -2.30698939e-02f, -1.88159402e-02f, -4.99468446e-02f, -1.91827472e-02f, -5.37208328e-03f, 6.62360489e-02f, 1.46147609e-01f,
  -3.50863896e-02f, 9.09414329e-03f, -4.31294776e-02f, -3.47302034e-02f, -3.18209007e-02f, 5.21030724e-02f, -1.55405715e-01f, -3.09691448e-02f, -2.35003810e-02f, 1.55359041e-03f,
  1.07744858e-01f, 1.25847831e-01f, 1.89729467e-01f, -1.31531596e-01f, 2.59898640e-02f, 1.21442206e-01f, 9.32065621e-02f, 1.28022164e-01f, 1.85705945e-01f, 1.53748998e-02f,
  1.12588346e-01f, 2.27370095e-02f, 1.65138528e-01f, 2.21015498e-01f, 7.13074431e-02f, 1.08727537e-01f, 9.32300314e-02f, 7.23451748e-03f, -1.84693909e-03f, 9.58995745e-02f,
  3.26120853e-01f, -3.30719113e-01f, 3.57095867e-01f, 2.00894982e-01f, 2.25211993e-01f, 1.45915195e-01f, 3.45772624e-01f, -1.06025405e-01f, 8.43499675e-02f, -3.16055000e-01f,
  -5.36561012e-02f, 8.41738507e-02f, 7.64645040e-02f, -1.70004621e-01f, 2.84583747e-01f, -4.47081178e-02f, -4.65706289e-02f, 1.20606996e-01f, 4.39124629e-02f, -1.04084453e-02f,
  -2.60714162e-02f, -2.44959921e-01f, -5.93030406e-03f, -2.82316267e-01f, -4.30251248e-02f, -2.14746445e-01f, -1.51052803e-01f, 8.68678093e-02f, -3.05551350e-01f, 2.83604227e-02f,
  -7.32167736e-02f, 3.00037488e-02f, -1.08660258e-01f, -2.12845430e-01f, 5.02055399e-02f, -1.90429594e-02f, 2.04028115e-02f, 1.75547600e-01f, 1.87838841e-02f, -6.22343533e-02f,
  -9.58495960e-02f, 2.34597679e-02f, -6.39438331e-02f, -2.97414772e-02f, -7.05376938e-02f, -1.05714664e-01f, 9.76488634e-04f, -7.58709759e-02f, -3.73453200e-02f, 1.31164595e-01f,
  -1.36604905e-02f, 1.73653364e-02f, 2.55715419e-02f, -5.91855124e-02f, -1.74552873e-02f, -2.73298658e-03f, 1.04147345e-01f, 2.39374861e-01f, -1.64415967e-02f, -1.42782986e-01f,
  3.68975140e-02f, -4.47790995e-02f, -6.01641797e-02f, 1.44364648e-02f, -2.07725931e-02f, -1.17433444e-01f, -1.74121857e-01f, -8.31100941e-02f, -6.00449517e-02f, -5.80670126e-02f,
  4.74132858e-02f, -1.03622235e-01f, 8.76061618e-02f, 3.07961162e-02f, -6.43376261e-02f, 2.96448041e-02f, 1.11502558e-01f, 6.87252730e-02f, -8.21424201e-02f, -1.01613715e-01f,
  3.24832946e-02f, -4.76241745e-02f, 1.02866506e-02f, 5.07075004e-02f, 5.58285527e-02f, -6.06132788e-04f, -1.51713297e-01f, 6.35061190e-02f, 5.89467324e-02f, -2.71679065e-03f,
  -1.82553783e-01f, -2.15878218e-01f, -1.49850905e-01f, -1.29383147e-01f, -1.17005454e-03f, -3.53596434e-02f, 1.25782564e-02f, -1.06367059e-02f, -4.11941782e-02f, -7.85857067e-02f,
  -9.28971246e-02f, 5.35463681e-03f, -1.05482042e-02f, -1.51374331e-02f, -1.72870412e-01f, -3.53564881e-02f, 8.45506117e-02f, -2.90999711e-01f, -3.08208819e-02f, -5.09517938e-02f,
  -2.32057441e-02f, 4.95490581e-02f, -5.60852140e-03f, -8.52581412e-02f, -8.80239997e-04f, 1.74396560e-01f, 2.56067850e-02f, -1.07364997e-03f, -8.75015706e-02f, 1.75665673e-02f,
  4.53861989e-02f, -2.76949614e-01f, -2.90667355e-01f, -2.15424463e-01f, -8.74692425e-02f, -2.82341868e-01f, -3.21525693e-01f, -2.10152745e-01f, -7.30721876e-02f, -7.65676200e-02f,
  -1.39367774e-01f, -1.09389082e-01f, 1.73884034e-01f, -1.58274516e-01f, 1.97852030e-01f, 2.49231175e-01f, -2.57941693e-01f, 8.01556781e-02f, -6.49464317e-03f, -1.10388845e-01f,
  2.58721970e-02f, -1.82754278e-01f, -6.07289262e-02f, -2.26052716e-01f, -2.51082003e-01f, -8.98347199e-02f, 9.92481634e-02f, -1.34744465e-01f, -2.48504862e-01f, -1.36058047e-01f,
  3.08330990e-02f, -9.72192958e-02f, -2.67607272e-02f, -2.31362488e-02f, -6.74752295e-02f, 3.67309526e-02f, -3.85009754e-03f, -1.35724572e-02f, 1.53289633e-02f, 7.12340102e-02f,
  -5.80819696e-03f, 8.43448043e-02f, -4.58813645e-02f, 1.14884876e-01f, 9.66000110e-02f, -1.66921362e-01f, -2.95599960e-02f, 9.80181172e-02f, 3.30377631e-02f, 6.25245273e-02f,
  -1.00684343e-02f, 8.01195204e-02f, -3.31623927e-02f, 1.41323477e-01f, -1.18497729e-01f, -2.79159155e-02f, 2.55126506e-02f, 2.34873537e-02f, -1.04808517e-01f, -5.97497262e-02f,
  -9.14954096e-02f, 3.72925214e-02f, 2.38576811e-02f, 2.23895647e-02f, -1.30495444e-01f, -3.86053920e-02f, -5.62768690e-02f, 3.73249967e-03f, -7.70442262e-02f, 5.97604811e-02f,
  -2.19170209e-02f, -1.80378303e-01f, 8.15842524e-02f, 1.04672037e-01f, -3.47974338e-02f, 7.24491104e-02f, 1.03601106e-01f, -1.38021991e-01f, -1.05274282e-01f, -1.13292016e-01f,
  2.14518860e-01f, -8.00354406e-02f, 2.03672349e-02f, 5.62589206e-02f, -5.49675599e-02f, 1.63581014e-01f, -1.18059125e-02f, -5.35470434e-02f, 7.76988044e-02f, -1.69446003e-02f,
  -8.88822749e-02f, -2.29136974e-01f, -5.46040721e-02f, -1.50407508e-01f, 7.63971880e-02f, -7.57676437e-02f, -1.66580919e-02f, -1.32479236e-01f, 1.26181887e-02f, -2.08564475e-02f,
  1.75768603e-02f, 8.23806524e-02f, 1.25512242e-01f, -6.94881193e-03f, -2.27952108e-01f, -1.22159645e-01f, 1.04951821e-01f, 1.01338357e-01f, -1.25505134e-01f, -7.32715353e-02f,
  2.28082389e-02f, -2.62402184e-02f, 2.64776647e-02f, -5.26522882e-02f, -4.39599566e-02f, 3.34811211e-02f, 2.38280520e-02f, -2.50571035e-02f, -3.30372714e-02f, -1.42994691e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.90684336e-01f, 1.37051836e-01f, 4.11086261e-01f, 1.68638706e-01f, 3.18988383e-01f, 1.69742182e-01f, 1.94638669e-01f, 3.01344037e-01f, 5.15659526e-02f, -3.73950303e-02f,
  2.16224372e-01f, 2.36923635e-01f, 2.06211269e-01f, 2.21216321e-01f, 1.45349324e-01f, 2.14102566e-01f, 2.47452706e-01f, 2.83227742e-01f, 1.90503329e-01f, 2.85742879e-01f,
  1.19180515e-01f, 2.93812811e-01f, 1.83547065e-01f, 2.67167002e-01f, 3.43456358e-01f, -1.60782531e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.79005459e-02f, 3.60490046e-02f, -8.92634764e-02f, 1.90655753e-01f, 2.92363279e-02f, -2.24731043e-01f, -1.16950497e-01f, -3.98451984e-01f, -8.53984207e-02f, 1.68213114e-01f,
  -8.28818753e-02f, -1.42256528e-01f, 3.66087139e-01f, 9.25387293e-02f, -1.77893247e-02f, -1.55681865e-02f, 1.42931476e-01f, 1.25980794e-01f, -3.66148651e-01f, 1.04703024e-01f,
  -1.79302767e-01f, -3.44126791e-01f, 1.24630913e-01f, 2.83695668e-01f, 2.03836605e-01f, 5.41564375e-02f, -2.83092439e-01f, -9.76617709e-02f, 9.11599547e-02f, -7.14086592e-02f,
  1.32621571e-01f, 1.83470458e-01f, 7.88718238e-02f, 2.39687547e-01f, 7.57451132e-02f, -1.34156227e-01f, 1.96587071e-01f, -4.24053408e-02f, 2.10383728e-01f, -9.30610597e-02f,
  -1.49141587e-02f, -1.01704359e-01f, -1.43320277e-01f, -4.55033630e-02f, -4.24596071e-02f, 5.31718619e-02f, 7.00308233e-02f, -2.97256768e-01f, -7.60846362e-02f, 6.12162836e-02f,
  1.50731668e-01f, 8.95990059e-02f, -2.27617875e-01f, 1.29055399e-02f, 1.53609455e-01f, -9.57719460e-02f, 1.80727571e-01f, 1.45825176e-02f, -1.50769994e-01f, -6.48366287e-02f,
  -2.95838993e-02f, 7.20863789e-02f, 1.68363377e-01f, -2.33289555e-01f, 2.24256694e-01f, 1.14978701e-01f, -1.16610322e-02f, -7.56266788e-02f, 7.69355968e-02f, 1.70503810e-01f,
  -1.88533112e-01f, 9.39580798e-02f, -2.18676835e-01f, 2.68623322e-01f, -6.63282797e-02f, 8.59830156e-02f, 1.81316718e-01f, -1.43422946e-01f, 2.56529868e-01f, 2.01119557e-01f,
  6.87760487e-02f, 7.55051337e-03f, 1.29897995e-02f, -1.35179341e-01f, -2.38593310e-01f, 9.52108018e-03f, -2.44333133e-01f, -2.65879273e-01f, 1.78251877e-01f, -3.21971267e-01f,
  1.45318374e-01f, 1.71148390e-01f, 7.72399530e-02f, 2.44873226e-01f, -1.13877878e-01f, -1.02569759e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.79811558e-02f, 1.48019969e-01f, 2.06309453e-01f, -2.30752409e-01f, -6.49451986e-02f, 1.12222269e-01f, -1.72810152e-01f, 5.72966993e-01f, -1.13420166e-01f, -6.05434291e-02f,
  1.13122109e-02f, 2.98157334e-01f, 2.88764566e-01f, -3.32495928e-01f, 2.57528454e-01f, 7.62667805e-02f, 5.17641306e-02f, 1.62763044e-01f, -1.96901917e-01f, -8.29598829e-02f,
  -9.54541638e-02f, -7.46235698e-02f, -9.94512439e-02f, 1.13208115e-01f, 2.22215310e-01f, -1.82890385e-01f, 4.07337397e-01f, 3.65937114e-01f, 1.42056912e-01f, 1.76260561e-01f,
  -1.49142265e-01f, 1.00173563e-01f, 2.59174466e-01f, 4.25484963e-02f, 1.22397870e-01f, -2.21075788e-01f, -1.43950790e-01f, 4.33241963e-01f, 4.75652926e-02f, 3.55436862e-01f,
  -1.05495714e-01f, 1.39624283e-01f, 2.76737273e-01f, 3.33570868e-01f, -6.33343682e-02f, 3.84798571e-02f, 6.19743951e-02f, 3.90707314e-01f, -1.80961192e-01f, -7.31042102e-02f,
  3.92657340e-01f, -8.46369416e-02f, 3.80932420e-01f, 2.20247060e-01f, 8.74190331e-02f, -1.20495491e-01f, -2.21991837e-01f, 2.56789893e-01f, 1.33709535e-01f, 9.97097194e-02f,
  -2.61219256e-02f, 3.66624922e-01f, -2.09358007e-01f, 1.45171896e-01f, 1.79871798e-01f, 3.83138061e-01f, 1.76047668e-01f, -1.70691952e-01f, 3.99982750e-01f, 1.59082621e-01f,
  1.81955040e-01f, 1.02301925e-01f, 7.67715275e-02f, -1.49021983e-01f, -2.59305388e-01f, 1.08060680e-01f, -1.45205826e-01f, 6.40694723e-02f, 3.13307494e-02f, -3.60602885e-01f,
  -1.75685868e-01f, 3.32705230e-01f, 3.89712393e-01f, 1.72811255e-01f, -4.01657879e-01f, 6.50043413e-02f, 7.82948509e-02f, 1.66857526e-01f, 3.35512966e-01f, 2.22022478e-02f,
  -8.92237574e-02f, 3.92751098e-01f, -1.10734940e-01f, 1.95240140e-01f, 2.82144517e-01f, -1.23654000e-01f, 6.12323266e-03f, 1.00778162e-01f, -1.88981324e-01f, 3.22806567e-01f,
  5.62327616e-02f, -2.60278255e-01f, 1.21478714e-01f, -2.27693856e-01f, -3.61059755e-01f, 3.67062986e-01f, 1.35845885e-01f, 2.62882356e-02f, 3.32258850e-01f, 1.42809525e-01f,
  2.02597544e-01f, 3.27872574e-01f, 2.02153772e-01f, -1.23757921e-01f, -1.77124981e-02f, 6.64889812e-02f, 3.75945002e-01f, -1.90153271e-01f, 1.05168983e-01f, 3.97514641e-01f,
  1.96292192e-01f, 1.49151459e-01f, -7.85950422e-02f, -1.04035132e-01f, 3.46817136e-01f, -1.47785574e-01f, 3.03442061e-01f, 2.28978187e-01f, 2.98189819e-01f, 1.53570250e-01f,
  7.97349587e-02f, 7.00008422e-02f, -8.94016549e-02f, 2.07533777e-01f, 2.28117853e-01f, 6.41888455e-02f, 3.82246464e-01f, 1.94001734e-01f, 4.62975651e-01f, 6.00497164e-02f,
  5.91205135e-02f, 1.79777339e-01f, -2.13416778e-02f, 2.10549086e-01f, 4.47616503e-02f, -1.83854058e-01f, 2.77313918e-01f, 1.04437973e-02f, 3.21772158e-01f, 3.44706327e-01f,
  3.83918613e-01f, -8.84140581e-02f, -3.38549823e-01f, 2.85444051e-01f, 1.90584324e-02f, 1.75348744e-02f, 7.37637356e-02f, 1.33214325e-01f, -1.33971959e-01f, -2.29587182e-02f,
  3.58122796e-01f, 1.44832283e-01f, 1.17706224e-01f, -4.55039367e-02f, 1.18054546e-01f, 6.85003176e-02f, -5.82939871e-02f, 6.47451133e-02f, -3.12365051e-02f, 2.27611691e-01f,
  -3.13662112e-01f, 2.06087232e-01f, 3.12774867e-01f, -9.17910263e-02f, 3.76225799e-01f, 1.58024430e-01f, -1.41693354e-01f, 3.25920671e-01f, 2.25468054e-01f, -3.71276997e-02f,
  -1.25372186e-01f, 1.11898154e-01f, -2.62054592e-01f, -6.15476891e-02f, 2.08587438e-01f, -5.45601770e-02f, 5.25277406e-02f, 5.19279093e-02f, 4.01876420e-01f, 3.79521310e-01f,
  7.20930845e-02f, -1.78495005e-01f, 1.29497811e-01f, 1.02148920e-01f, 2.57805884e-01f, -2.86624998e-01f, 6.64949417e-02f, 2.22544998e-01f, -2.16653958e-01f, 4.41775501e-01f,
  -1.26438603e-01f, 1.20965019e-01f, 7.85409436e-02f, 3.82373214e-01f, 2.72495389e-01f, -3.18531513e-01f, 1.86551392e-01f, 2.87495822e-01f, 1.38584059e-02f, 1.29596412e-01f,
  -3.04891795e-01f, -1.54533237e-01f, -6.39599413e-02f, -6.27794564e-02f, 3.02026165e-03f, 2.30997652e-01f, -1.75853702e-03f, -1.80294484e-01f, 3.73151213e-01f, 3.98044467e-01f,
  2.46187747e-01f, -1.28892194e-02f, -1.74917296e-01f, 2.84538772e-02f, 1.27424315e-01f, 3.23878407e-01f, -2.70706534e-01f, 1.68607622e-01f, -1.86408654e-01f, -3.90450656e-01f,
  1.63824156e-01f, -1.59578606e-01f, -2.61894792e-01f, 1.17485180e-01f, -1.69173107e-01f, 1.91328913e-01f, 7.42552355e-02f, 3.29201430e-01f, -2.74828915e-02f, -2.27889776e-01f,
  3.68739486e-01f, -2.81029761e-01f, -1.55047253e-01f, 2.39232913e-01f, -3.65852714e-02f, 1.03748508e-01f, -1.63992539e-01f, 2.94905663e-01f, 2.09928885e-01f, 1.61630884e-01f,
  -2.94676945e-02f, -1.70543745e-01f, -1.86144814e-01f, -2.23050475e-01f, 3.94909918e-01f, 2.05810979e-01f, -6.82430416e-02f, 2.01325595e-01f, 6.51447102e-02f, 6.74553439e-02f,
  -2.19196662e-01f, -2.02437907e-01f, -3.21317278e-02f, 1.68363988e-01f, -1.34556994e-01f, 5.14004827e-02f, 3.69573951e-01f, 1.04756393e-01f, 9.32730082e-03f, 2.14825734e-01f,
  -1.05945021e-01f, 3.60029191e-01f, 3.57134998e-01f, -4.27721262e-01f, -1.15873016e-01f, 2.26351649e-01f, 2.45431080e-01f, -8.03872757e-03f, -8.52307491e-03f, 1.30973548e-01f,
  8.78270268e-02f, 1.56621486e-01f, 3.14296931e-02f, 5.54135963e-02f, -4.17622775e-01f, -9.18702930e-02f, 9.38216299e-02f, 3.98340821e-01f, 1.41624227e-01f, 1.46384314e-01f,
  2.76718214e-02f, -3.21742631e-02f, -2.56529689e-01f, -2.35104710e-01f, 3.00538987e-01f, -1.92958251e-01f, 2.92480201e-01f, -1.25614896e-01f, 2.19864517e-01f, -4.22906727e-02f,
  7.43497089e-02f, 2.12498769e-01f, -1.00670323e-01f, -1.37041628e-01f, 1.37384832e-01f, -1.96378157e-01f, 7.35344291e-02f, 2.14344963e-01f, 2.24012747e-01f, -1.04321219e-01f,
  1.26665369e-01f, 6.27513826e-02f, -9.52433143e-03f, 3.95191073e-01f, -9.39513072e-02f, -2.05435246e-01f, -2.53709614e-01f, -2.04655156e-01f, 2.35215813e-01f, 1.67406663e-01f,
  1.54905111e-01f, 2.64278561e-01f, 2.59765740e-02f, -1.90453529e-01f, 2.01555967e-01f, 2.05178842e-01f, 2.85163701e-01f, 1.05950296e-01f, -1.42513663e-01f, 1.52114648e-02f,
  -2.55696416e-01f, 2.26517081e-01f, 6.13523722e-02f, -4.26182970e-02f, 2.27435872e-01f, -1.49636686e-01f, -2.04282954e-01f, 3.58512729e-01f, 3.40395927e-01f, 1.39789000e-01f,
  -1.85454726e-01f, 1.95504306e-03f, -2.35552743e-01f, -4.55460176e-02f, 4.78951454e-01f, -1.42865162e-02f, 2.62436420e-01f, -6.03641532e-02f, 7.39023015e-02f, 3.40777785e-01f,
  3.09910268e-01f, 7.37354346e-03f, 2.71695971e-01f, 2.14630306e-01f, 2.57386625e-01f, 4.63215172e-01f, -1.17101997e-01f, -2.95148581e-01f, 4.33341600e-02f, -2.52963871e-01f,
  4.89175588e-01f, -4.73135822e-02f, 2.31947288e-01f, -1.50548965e-01f, 8.30261316e-03f, 2.12297678e-01f, 2.53988534e-01f, -1.68609917e-01f, 1.71544433e-01f, 3.29700530e-01f,
  -8.75940546e-02f, 1.92067940e-02f, 1.77380905e-01f, 3.33027691e-01f, -1.33361131e-01f, -2.12232828e-01f, 1.86613649e-01f, -8.02754685e-02f, 1.06150173e-01f, -3.28433424e-01f,
  2.08289072e-01f, 4.38726753e-01f, 2.89258122e-01f, -3.21742713e-01f, 5.69998808e-02f, 9.71977860e-02f, 1.30773842e-01f, -5.49337070e-04f, -8.80077034e-02f, -2.76347816e-01f,
  -4.56770808e-02f, 1.03966877e-01f, 2.76639551e-01f, -1.25372142e-01f, -1.24105498e-01f, 2.92389154e-01f, 1.35108441e-01f, -5.81597686e-02f, 1.41493782e-01f, -2.28883013e-01f,
  1.58935055e-01f, 3.54990453e-01f, -2.49868199e-01f, 4.88554426e-02f, -8.21427852e-02f, -9.80617851e-02f, -2.45096058e-01f, -4.05618362e-02f, 4.94533658e-01f, -8.44258964e-02f,
  2.99481988e-01f, -8.54736641e-02f, -3.35085988e-02f, 1.37768999e-01f, 2.02356383e-01f, 1.07118651e-01f, 1.55048326e-01f, 3.63113105e-01f, 1.42033294e-01f, -4.05620709e-02f,
  -1.29075065e-01f, -3.65269303e-01f, 1.44207776e-01f, 2.32093260e-02f, 3.24477822e-01f, -1.31137157e-02f, 5.08412644e-02f, -4.11910042e-02f, -1.05355650e-01f, 3.17697644e-01f,
  -1.82584167e-01f, -2.15422556e-01f, 3.55018020e-01f, 1.28326356e-01f, -3.79354030e-01f, 3.19995224e-01f, -2.25175709e-01f, 2.98716009e-01f, 8.41170400e-02f, 2.33798787e-01f,
  8.04771036e-02f, -3.93148586e-02f, 8.92630219e-02f, 2.13528603e-01f, -9.12376791e-02f, -3.18841189e-01f, 2.28644267e-01f, 5.27033489e-03f, 1.78124189e-01f, 3.39416951e-01f,
  2.65772134e-01f, -8.17135051e-02f, 6.49845749e-02f, 1.05285175e-01f, -1.34964556e-01f, 3.14505279e-01f, -1.76352352e-01f, 1.35462791e-01f, -3.41210783e-01f, 7.32627735e-02f,
  1.10697381e-01f, -1.68911278e-01f, 1.66508257e-01f, -2.20642582e-01f, -1.92645222e-01f, 5.10028064e-01f, 1.44246578e-01f, -2.19838470e-01f, 4.33730856e-02f, 8.06656703e-02f,
  -4.80731338e-01f, -3.45744565e-02f, 3.09478641e-01f, -2.91800976e-01f, 2.34539270e-01f, 3.50437254e-01f, 1.19548641e-01f, 5.22686481e-01f, 9.26727727e-02f, -3.67842615e-02f,
  1.87656209e-01f, 2.66793847e-01f, 2.00033233e-01f, -1.78149655e-01f, -1.14046998e-01f, -1.37312517e-01f, 2.44032383e-01f, 3.39861810e-01f, 3.23434979e-01f, 2.50407606e-01f,
  2.86545485e-01f, -1.03410579e-01f, 1.65336475e-01f, 1.13663204e-01f, -2.14272916e-01f, 1.89506933e-01f, 4.83886808e-01f, -2.00661004e-01f, -2.27488115e-01f, 2.11111784e-01f,
  -2.45334953e-01f, 3.18557620e-02f, 4.65888321e-01f, 2.96182036e-01f, -1.83310553e-01f, 1.37251075e-02f, -5.65293878e-02f, 4.80609775e-01f, -6.50874153e-02f, -2.58831054e-01f,
  8.36487412e-02f, 3.72555852e-02f, 2.17606530e-01f, 1.01639353e-01f, 5.47168637e-03f, 5.23904786e-02f, -2.17645854e-01f, 7.86966085e-02f, 1.81758419e-01f, -9.79886502e-02f,
  4.37057167e-01f, 1.27763063e-01f, 3.68414700e-01f, -9.67739671e-02f, -1.74127240e-02f, 3.05541217e-01f, -6.24193577e-04f, 3.43330540e-02f, -5.60911698e-03f, -1.73966825e-01f,
  4.30550575e-01f, 1.33117601e-01f, 3.76636922e-01f, 1.11933433e-01f, 1.87114030e-01f, -1.25445202e-01f, -2.91781545e-01f, 4.03772980e-01f, -5.31943664e-02f, -2.11933210e-01f,
  1.06436133e-01f, 2.12702319e-01f, -7.89746642e-02f, 2.64766552e-02f, 2.60440707e-01f, 3.29766899e-01f, 5.02677560e-01f, -3.74844342e-01f, 2.67863691e-01f, 3.02430511e-01f,
  2.62950063e-01f, 2.66983896e-01f, 2.08391458e-01f, 9.43884179e-02f, -1.23567291e-01f, -1.67134374e-01f, -1.40039325e-01f, 1.06055923e-01f, -1.77149683e-01f, 7.45215714e-02f,
  -7.71034858e-04f, 4.01817262e-01f, 1.27073498e-02f, -4.52553300e-04f, -2.20770597e-01f, -1.51421472e-01f, 4.01989639e-01f, 3.68480355e-01f, 8.38327184e-02f, -1.50655620e-02f,
  -1.27642512e-01f, 4.79794621e-01f, 6.04789443e-02f, -2.76403099e-01f, 2.51789868e-01f, 6.04006869e-04f, 5.55716455e-02f, -4.62571857e-03f, -1.49847850e-01f, 1.00736516e-02f,
  -1.48913026e-01f, 4.45165746e-02f, -4.31663021e-02f, -4.78958264e-02f, 4.99589145e-02f, -1.33754507e-01f, 2.34381959e-01f, 9.25058648e-02f, 5.05845547e-02f, 1.68107226e-01f,
  -2.31367692e-01f, 2.79631019e-02f, 1.31993264e-01f, -1.57482713e-01f, -9.38343536e-03f, 9.21841040e-02f, 3.19731474e-01f, 1.34503484e-01f, -2.27669645e-02f, 2.48219311e-01f,
  6.11127652e-02f, 3.82777125e-01f, -1.23978361e-01f, -1.60418645e-01f, -2.07977146e-01f, -1.09773993e-01f, 1.32323252e-02f, 3.97159845e-01f, 1.81046352e-01f, 2.43142858e-01f,
  1.67245597e-01f, -2.06025783e-02f, -2.57746041e-01f, -9.52406088e-04f, 3.28351289e-01f, -2.54494906e-03f, 5.52365899e-01f, -7.41034746e-02f, 2.67901391e-01f, -6.21579885e-02f,
  -7.31682330e-02f, 1.25457853e-01f, -1.93819702e-01f, -1.16364352e-01f, 1.30242914e-01f, 1.28391847e-01f, 1.06970720e-01f, 1.84483275e-01f, 2.55308241e-01f, -2.42225245e-01f,
  2.10078284e-01f, -1.06644236e-01f, 1.92255266e-02f, 2.17432231e-01f, -1.44597888e-01f, 1.78911179e-01f, -6.48893341e-02f, -2.70124197e-01f, 1.53559923e-01f, -3.89517806e-02f,
  3.22042525e-01f, 1.52338892e-01f, 3.27036440e-01f, -4.64136750e-02f, 8.96382853e-02f, 1.30983442e-01f, 4.00030613e-01f, -8.61858279e-02f, 3.90805244e-01f, -1.41597092e-01f,
  1.32086501e-01f, -2.43443474e-01f, -2.85407096e-01f, 2.08213180e-01f, -7.31186047e-02f, -2.38318831e-01f, -9.58623812e-02f, 3.01073909e-01f, 2.74135858e-01f, 1.23223260e-01f,
  2.95131411e-02f, 2.85955817e-01f, 2.61229694e-01f, -6.95134476e-02f, 4.69624475e-02f, 3.41187626e-01f, -1.75254375e-01f, 2.67592877e-01f, -8.19964036e-02f, 8.50739777e-02f,
  2.27181539e-01f, -2.89693922e-01f, -2.46773195e-03f, 5.22552803e-02f, -7.52763376e-02f, -5.18475771e-02f, -6.56395219e-03f, 2.16193452e-01f, -1.89398035e-01f, 1.70390502e-01f,
  -1.98515981e-01f, 2.46411741e-01f, -2.28486843e-02f, 3.99978787e-01f, 5.01190543e-01f, -2.71629021e-02f, 2.40570441e-01f, 3.20094913e-01f, 9.13920905e-03f, -8.05566460e-02f,
  -1.51834726e-01f, 6.76016435e-02f, 1.46615252e-01f, 6.41003922e-02f, -2.25106165e-01f, 1.05908714e-01f, 5.95336519e-02f, 1.63309559e-01f, 3.47611070e-01f, -1.26602296e-02f,
  3.94291997e-01f, 1.04249261e-01f, -9.06883478e-02f, 3.10798883e-01f, 4.08724487e-01f, 2.57115573e-01f, 2.22622111e-01f, 1.25320971e-01f, 5.09007812e-01f, 1.55631721e-01f,
  3.68617177e-01f, -3.59072745e-01f, -9.11757722e-02f, 2.66786933e-01f, -2.52301127e-01f, -1.81518286e-01f, 3.42924714e-01f, 4.70515825e-02f, 1.25469953e-01f, 6.79211542e-02f,
  -1.78658105e-02f, 4.90179151e-01f, 1.39398083e-01f, 1.71704188e-01f, -3.08895737e-01f, -3.61766726e-01f, 3.30878645e-01f, 3.24395001e-01f, 4.30523753e-01f, 1.38488963e-01f,
  -2.27604479e-01f, 1.04982316e-01f, 4.10952598e-01f, 9.52818990e-03f, 4.96076167e-01f, -2.86057383e-01f, 1.66389033e-01f, 3.70879859e-01f, -5.73009625e-02f, 2.35329956e-01f,
  -2.75845788e-02f, -3.26064140e-01f, 2.24438414e-01f, -2.89992064e-01f, -2.57595450e-01f, 8.66390914e-02f, -1.27348334e-01f, 9.79075283e-02f, 2.37278819e-01f, 3.00760806e-01f,
  2.43804216e-01f, -2.34218374e-01f, 1.93684444e-01f, 7.72967264e-02f, 7.09832311e-02f, 2.72078693e-01f, -2.41593341e-03f, 1.38765857e-01f, -2.32891485e-01f, 2.49298632e-01f,
  4.19011742e-01f, 9.92782190e-02f, 3.02091409e-02f, -2.42277339e-01f, -3.67945409e-04f, 2.06439123e-01f, 3.41494709e-01f, 2.37569004e-01f, 2.63995349e-01f, 2.40206644e-01f,
  3.55221242e-01f, 3.66281331e-01f, -4.89419252e-02f, -2.13098660e-01f, -1.88409045e-01f, 7.28594810e-02f, 4.10463810e-01f, 2.07166359e-01f, 4.54883933e-01f, -1.41442820e-01f,
  2.35318802e-02f, 1.19414881e-01f, -2.80372500e-02f, 3.90355617e-01f, 3.41407835e-01f, 4.66110036e-02f, -1.02695070e-01f, -1.61639433e-02f, 3.45291495e-01f, 1.63111359e-01f,
  2.14398399e-01f, 1.65385768e-01f, -6.30686730e-02f, 5.81220128e-02f, -1.77819610e-01f, 6.04926907e-02f, 3.69843036e-01f, 7.48929754e-02f, 7.61585012e-02f, -9.00241360e-02f,
  1.77339405e-01f, 6.25038296e-02f, 1.67115062e-01f, -1.17849164e-01f, -8.67014155e-02f, 1.81502059e-01f, 1.11342207e-01f, 3.84229958e-01f, 1.11220248e-01f, 7.18436539e-02f,
  4.03153300e-01f, 1.68310791e-01f, -6.87167421e-02f, 2.66947709e-02f, -1.05293207e-01f, 2.62081683e-01f, 2.20028404e-02f, -4.78825048e-02f, 3.51430118e-01f, 8.71441290e-02f,
  3.16589564e-01f, 8.23505521e-02f, 2.03657836e-01f, -8.12132210e-02f, -1.78075314e-01f, 3.71071309e-01f, 1.19309038e-01f, 7.28276223e-02f, -2.77673513e-01f, 2.24679813e-01f,
  -2.23879412e-01f, 1.62456155e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.06426977e-01f, 2.03551561e-01f, 2.86179125e-01f, -5.23680001e-02f, 2.59158224e-01f, 7.38825835e-03f, 2.07062572e-01f, 1.11517847e-01f, 8.93502533e-02f, 2.17588246e-02f,
  2.10464790e-01f, 2.28270039e-01f, 2.80633241e-01f, 4.21806216e-01f, 1.95940793e-01f, 3.37353498e-01f, 2.22769871e-01f, 2.65339553e-01f, 4.92001623e-02f, 2.53114909e-01f,
  2.62725651e-01f, 1.06497556e-01f, 1.42275557e-01f, 2.32226685e-01f, 3.71742129e-01f, 1.27869219e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  4.68716882e-02f, 4.01473418e-02f, 3.12862806e-02f, -2.29954347e-01f, -4.13037799e-02f, 6.41864464e-02f, 5.51314987e-02f, -2.11766418e-02f, -7.67902359e-02f, 4.03968384e-03f,
  -1.01960294e-01f, 2.27734208e-01f, 4.15524328e-03f, -9.62812677e-02f, -5.78525066e-02f, 3.06993034e-02f, 1.36277840e-01f, 2.32498810e-01f, 8.16290304e-02f, 4.14054617e-02f,
  2.25798979e-01f, -1.99227065e-01f, 4.04812619e-02f, -1.47666827e-01f, -4.33314666e-02f, -7.91189671e-02f, 7.97807723e-02f, 1.33586124e-01f, -9.33088437e-02f, -8.85016173e-02f,
  1.45968040e-02f, 3.84861641e-02f, 1.69194322e-02f, 1.14118099e-01f, 5.27096633e-03f, -1.85934287e-02f, -9.46827382e-02f, 9.01539251e-02f, 1.20952860e-01f, -1.28980815e-01f,
  3.72840092e-02f, 1.11154236e-01f, -1.89202577e-01f, -3.50650884e-02f, 1.19774215e-01f, -3.02224304e-03f, 1.24182567e-01f, -6.45420328e-02f, -5.06297722e-02f, -1.07447155e-01f,
  -6.02181330e-02f, -5.38435504e-02f, 1.22550234e-01f, 2.27817044e-01f, -7.98659250e-02f, 6.10848740e-02f, -4.82529812e-02f, -1.48764223e-01f, -6.55332804e-02f, 1.31936923e-01f,
  2.60372087e-03f, 7.30116218e-02f, -3.13042812e-02f, -1.36942104e-01f, 1.27911001e-01f, -1.79065198e-01f, 1.01746351e-01f, 3.75355855e-02f, -6.90551894e-03f, 1.62090734e-01f,
  8.40089172e-02f, -7.61855841e-02f, 1.68667123e-01f, -6.51616156e-02f, -5.85870370e-02f, 4.83050011e-02f, 6.03614077e-02f, -9.48836580e-02f, 4.29848135e-02f, -1.23586349e-01f,
  5.59764318e-02f, -2.36362547e-01f, -1.62475765e-01f, -3.79791632e-02f, -7.96605349e-02f, 2.08834216e-01f, -1.37855232e-01f, 2.11138338e-01f, -3.61016952e-02f, -1.35135651e-01f,
  4.10646237e-02f, -3.69191132e-02f, 1.23345949e-01f, -5.29051572e-02f, 2.50428971e-02f, -1.47888483e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.22970767e-01f, 1.04615286e-01f, 2.61878252e-01f, 1.49061263e-01f, 2.70535171e-01f, -1.48575336e-01f, -2.55480587e-01f, -2.74295509e-01f, 3.59074384e-01f, -3.05901051e-01f,
  -8.99001881e-02f, -8.03809911e-02f, -2.07204536e-01f, 2.29296207e-01f, 1.60544142e-02f, 2.33021215e-01f, 1.12696223e-01f, 2.09739476e-01f, 3.02774739e-02f, 5.13715208e-01f,
  -3.89141962e-02f, 3.84169489e-01f, 4.63310964e-02f, 3.43215972e-01f, 3.36750485e-02f, 3.15500438e-01f, 3.39451373e-01f, -4.56164390e-01f, 3.42475682e-01f, 1.59361899e-01f,
  1.38971120e-01f, -1.09460190e-01f, -2.20331565e-01f, -2.59909153e-01f, -7.31199011e-02f, 9.75811332e-02f, 1.88994870e-01f, -5.41625954e-02f, -4.40648884e-01f, 9.36537795e-03f,
  3.02736640e-01f, 3.32607180e-01f, 9.57624614e-02f, -1.14051796e-01f, -4.20147359e-01f, 3.65459055e-01f, 5.70276976e-02f, 2.64898449e-01f, 1.80327728e-01f, -1.50378302e-01f,
  -1.52375236e-01f, 5.80343716e-02f, -2.39384666e-01f, -6.06704280e-02f, 2.32264370e-01f, 1.66418731e-01f, 1.87373295e-01f, 2.56587744e-01f, 3.09711158e-01f, 1.60042979e-02f,
  3.92290354e-01f, 3.38384479e-01f, -1.36979833e-01f, 2.63425838e-02f, 1.90376922e-01f, 4.92918305e-02f, 1.75102010e-01f, -4.92860854e-01f, 5.26219606e-02f, 5.11597916e-02f,
  -1.17382233e-03f, 4.81320411e-01f, 1.28407210e-01f, -4.20744270e-01f, 3.93461972e-01f, 1.38921708e-01f, 1.57032669e-01f, -2.56697327e-01f, 6.30023330e-02f, 1.37163281e-01f,
  1.86702728e-01f, -5.17201237e-02f, 8.63446202e-03f, -5.95763847e-02f, 5.03527001e-03f, 2.35582367e-01f, 3.44766140e-01f, 9.51569676e-02f, 3.75392772e-02f, 1.73784167e-01f,
  3.30511004e-01f, -1.70457885e-02f, -3.62557471e-01f, -1.70562088e-01f, -7.87770450e-02f, 3.82668018e-01f, 1.82891831e-01f, 3.16241533e-02f, 1.64627180e-01f, 1.53108433e-01f,
  -1.48278654e-01f, 1.59789518e-01f, 3.39777499e-01f, 7.14930966e-02f, 7.91633874e-02f, 1.10421494e-01f, -8.56173113e-02f, -1.86028834e-02f, 4.34229910e-01f, -2.67283648e-01f,
  4.25832793e-02f, -3.17973584e-01f, -8.33053142e-02f, -2.39630803e-01f, -3.96353267e-02f, 6.01991713e-02f, 3.01321208e-01f, 3.47367793e-01f, -3.45867276e-01f, 4.76765603e-01f,
  -1.12933710e-01f, 1.39083695e-02f, 8.85207355e-02f, -2.00653560e-02f, 2.85659462e-01f, -2.26250604e-01f, 2.69806266e-01f, -8.98523778e-02f, 4.96614389e-02f, 1.74299795e-02f,
  1.64668038e-02f, -3.07183534e-01f, 2.85753924e-02f, 2.31366336e-01f, 2.94560254e-01f, 1.83775321e-01f, 1.33819118e-01f, -7.35428557e-02f, 1.19149394e-01f, 3.35612714e-01f,
  3.97888094e-01f, -1.47965252e-01f, -1.58244342e-01f, -1.45398900e-01f, 1.05912544e-01f, -3.03664267e-01f, -2.37922356e-01f, -1.41086921e-01f, 2.64145166e-01f, 2.44640782e-01f,
  -1.17987692e-01f, 3.28355253e-01f, -1.04843661e-01f, -9.96480659e-02f, -4.60779816e-02f, 1.82414472e-01f, 1.42725753e-02f, -9.08116028e-02f, -2.07166150e-02f, 1.19758099e-01f,
  -1.19351149e-01f, 9.96863768e-02f, 6.60638511e-02f, 1.34686276e-03f, 1.18928570e-02f, -8.39390755e-02f, -1.78101927e-01f, 2.91309655e-01f, 8.10281113e-02f, 5.82788400e-02f,
  1.93272069e-01f, -1.77356988e-01f, -1.53497934e-01f, 2.17072055e-01f, 3.54331791e-01f, 3.00504863e-01f, -2.34539047e-01f, 5.12318395e-04f, -2.88359404e-01f, 8.81803110e-02f,
  -2.17856705e-01f, 3.13174546e-01f, 2.31491745e-01f, 1.20987199e-01f, 1.46749020e-01f, 2.39645869e-01f, 2.33460218e-01f, -2.47486159e-01f, -1.10187471e-01f, 1.24782965e-01f,
  1.94517165e-01f, 4.19171542e-01f, 3.80244665e-02f, -1.28176287e-01f, -8.59772488e-02f, 2.84719527e-01f, 2.40421250e-01f, 1.82558045e-01f, 2.22713724e-01f, -2.13450983e-01f,
  1.00208655e-01f, 3.39946896e-01f, -3.65874320e-01f, 2.26555318e-01f, 1.61864758e-01f, 2.14495286e-01f, -2.83121224e-02f, -1.13481060e-01f, 3.67183208e-01f, 1.77280307e-01f,
  4.15287644e-01f, 2.92469896e-02f, 1.40542388e-01f, -1.32248908e-01f, -3.06194216e-01f, 4.67866845e-02f, -1.81707829e-01f, -8.92652720e-02f, -2.66969055e-01f, 2.40931571e-01f,
  3.92406881e-01f, 3.52773815e-01f, 1.15908921e-01f, -2.99775600e-01f, -2.27906983e-02f, 1.47799462e-01f, -1.59277990e-01f, -5.28820492e-02f, 6.97008744e-02f, 1.81116864e-01f,
  2.11977080e-01f, 2.24654421e-01f, -2.80339513e-02f, 1.71403855e-01f, 7.13109924e-03f, 4.71070141e-01f, 3.47695686e-02f, -1.63142249e-01f, -3.19605321e-01f, -2.44514272e-01f,
  2.07349524e-01f, 4.70301032e-01f, 7.82577842e-02f, -3.34604770e-01f, 4.47072685e-01f, -3.52931231e-01f, 1.40630782e-01f, -2.38914520e-01f, -1.96181417e-01f, -3.05401623e-01f,
  -9.00743753e-02f, 2.60013044e-01f, 1.95986688e-01f, 2.73750782e-01f, 2.97990948e-01f, -1.12898633e-01f, -3.78954746e-02f, -4.01631631e-02f, 9.08320770e-04f, 2.84803748e-01f,
  -1.48296282e-01f, -2.48522431e-01f, -1.97962716e-01f, 1.47940189e-01f, -1.21064946e-01f, 2.36912936e-01f, 4.30360585e-01f, 2.04322301e-02f, -5.73800392e-02f, -3.00401121e-01f,
  -1.97475746e-01f, 2.69027561e-01f, -1.17900960e-01f, 2.40316674e-01f, -2.28882745e-01f, -2.12155700e-01f, -2.65577555e-01f, -1.72836408e-02f, 3.95780921e-01f, 1.47253379e-01f,
  1.09492339e-01f, 3.50231171e-01f, 3.50174695e-01f, 2.10737452e-01f, 3.78398448e-01f, -1.36590660e-01f, 3.71602029e-01f, 2.31508911e-01f, 7.69384131e-02f, 3.23052742e-02f,
  -1.56755462e-01f, -2.36786425e-01f, -6.20478243e-02f, 6.78237081e-02f, 2.10180670e-01f, 2.15504318e-02f, 1.27924219e-01f, 2.74091959e-02f, -3.29150409e-01f, 2.12781042e-01f,
  7.07143992e-02f, 2.76767433e-01f, 1.48708969e-01f, 1.57749176e-01f, 3.29839110e-01f, -9.37539786e-02f, 4.62175846e-01f, 1.01381257e-01f, 3.22039127e-01f, -7.81067312e-02f,
  -1.50366887e-01f, -9.50101390e-02f, 1.94364533e-01f, -3.15480344e-02f, -1.61694542e-01f, 1.67776167e-01f, -3.03721745e-02f, 3.20635051e-01f, -2.20942810e-01f, -6.67875707e-02f,
  -6.14413479e-03f, 1.66590497e-01f, -1.10136740e-01f, 8.72179214e-03f, -1.74047127e-01f, -2.16108471e-01f, 1.32525131e-01f, 1.73387796e-01f, -4.72891510e-01f, 8.78422707e-02f,
  2.24164382e-01f, -8.30684379e-02f, 2.00969487e-01f, -1.70313835e-01f, 2.04696164e-01f, 1.51085958e-01f, -3.44810605e-01f, 1.18272915e-01f, 2.00180151e-02f, 1.39792070e-01f,
  -2.64626056e-01f, 1.69957027e-01f, 1.41785875e-01f, -2.09622994e-01f, 2.28774190e-01f, 2.66953498e-01f, -3.64172161e-02f, 1.93982407e-01f, -4.74440366e-01f, 9.63620655e-03f,
  4.24783677e-01f, 2.97372818e-01f, 1.32020727e-01f, -1.17710575e-01f, -5.91495708e-02f, -3.18073511e-01f, 2.15036213e-01f, 2.65098959e-02f, -8.76570642e-02f, 1.59656659e-01f,
  3.12710971e-01f, -2.18808725e-01f, 2.35795692e-01f, 1.73916206e-01f, -1.06792852e-01f, -2.96010524e-01f, -3.38186055e-01f, -9.82328579e-02f, 2.96941191e-01f, -3.92467603e-02f,
  -2.92834966e-03f, -2.22021848e-01f, 2.76777029e-01f, -2.71238327e-01f, 1.66061863e-01f, 3.29473168e-01f, -8.91700760e-02f, 2.14935958e-01f, 3.66636962e-01f, -2.20166951e-01f,
  2.31857926e-01f, 1.93814673e-02f, -3.26167606e-02f, 1.81073278e-01f, -2.05450892e-01f, -2.96309087e-02f, -1.07849851e-01f, -4.33011234e-01f, -1.50263369e-01f, 1.74732670e-01f,
  3.12409729e-01f, 4.35708046e-01f, -1.65466778e-02f, -1.19824279e-02f, 2.17859879e-01f, -1.13310643e-01f, 1.94712058e-01f, 1.25803888e-01f, 4.02980059e-01f, 2.04139594e-02f,
  -3.42614092e-02f, -3.12251180e-01f, -5.67080416e-02f, -1.08145766e-01f, 1.14543714e-01f, -6.94574267e-02f, 6.56712502e-02f, -9.15616825e-02f, 3.85897011e-01f, -1.41028583e-01f,
  -1.02480128e-02f, 2.79888242e-01f, -6.86558902e-01f, -2.73682848e-02f, 3.75697874e-02f, 3.77467662e-01f, -1.08477205e-01f, 2.11085215e-01f, 9.15488750e-02f, 2.25883648e-01f,
  6.40312433e-02f, -2.78734118e-01f, -3.55857193e-01f, 3.60762933e-03f, -2.17634663e-01f, 1.84260130e-01f, 1.12484187e-01f, -1.47752240e-01f, -1.97274640e-01f, 2.93043077e-01f,
  7.78651237e-02f, 2.72298127e-01f, -2.12946415e-01f, 4.16448176e-01f, 1.53210551e-01f, 3.46055448e-01f, -2.62931019e-01f, -8.95375535e-02f, 1.69714436e-01f, -3.40982407e-01f,
  2.36584216e-01f, 2.53283471e-01f, -1.12227470e-01f, 8.50678682e-02f, -9.08074379e-02f, 1.67990535e-01f, 3.03690195e-01f, -8.48358199e-02f, 8.09667557e-02f, 2.22169816e-01f,
  -7.20547661e-02f, -4.34366196e-01f, -3.76257231e-03f, -1.24714319e-02f, 2.86691725e-01f, 1.41612560e-01f, 2.21361712e-01f, -7.87291750e-02f, -5.87566309e-02f, 1.27473488e-01f,
  2.47511327e-01f, 5.82913719e-02f, -7.90405944e-02f, -4.45918068e-02f, 2.93121368e-01f, -1.09928429e-01f, 2.21857831e-01f, -1.55304879e-01f, 3.74867231e-01f, -1.98220164e-01f,
  -4.43850718e-02f, -6.04725108e-02f, -9.72536858e-03f, -6.59083202e-02f, -9.09250602e-02f, 2.15011895e-01f, -2.32560396e-01f, 1.42791808e-01f, -1.40409082e-01f, -7.16323107e-02f,
  2.49042720e-01f, 3.55047345e-01f, 4.75924462e-01f, 4.55657206e-02f, 1.24872573e-01f, -8.17088112e-02f, 2.94852108e-01f, -3.77692431e-01f, 2.83959597e-01f, -3.07429433e-01f,
  -4.98098284e-02f, 7.85876811e-02f, 4.88829613e-02f, 2.05797315e-01f, 1.61764640e-02f, -7.15300590e-02f, 6.45917002e-03f, 3.49108815e-01f, 4.83329326e-01f, 5.94055176e-01f,
  1.81447014e-01f, 2.15054244e-01f, -1.84995100e-01f, 2.78551161e-01f, -3.89563516e-02f, 2.55225211e-01f, 1.87623814e-01f, 3.92515771e-02f, -1.08244359e-01f, 1.87274113e-01f,
  1.84502453e-01f, -1.18835583e-01f, -3.17656286e-02f, 4.15432677e-02f, -1.22804381e-01f, 3.27775776e-01f, -2.20030576e-01f, -1.18048694e-02f, 9.45660844e-02f, -4.70815487e-02f,
  -3.92549127e-01f, 3.97961617e-01f, 3.65809761e-02f, 1.24616168e-01f, 6.98219985e-02f, 3.93067330e-01f, 3.87873292e-01f, 1.60752326e-01f, -2.14940622e-01f, -1.60446629e-01f,
  6.17586600e-04f, 2.04248935e-01f, -1.73010558e-01f, 3.97792995e-01f, -7.14877099e-02f, 9.51352492e-02f, 1.37132406e-01f, 7.29141906e-02f, -2.53690571e-01f, 3.60267311e-01f,
  2.17186406e-01f, 3.43429774e-01f, 2.14967519e-01f, 8.38839728e-03f, -2.61947930e-01f, -6.15868084e-02f, -2.66220152e-01f, -3.39384288e-01f, 2.20741108e-02f, 1.00698024e-01f,
  -8.02889094e-03f, 5.17180622e-01f, 1.34075522e-01f, 2.89360166e-01f, 1.89499825e-01f, 4.84899096e-02f, 8.45104754e-02f, 2.65641510e-01f, 2.41886914e-01f, 1.31179988e-01f,
  1.93576798e-01f, -2.46814057e-01f, -2.46936664e-01f, -1.44507036e-01f, -9.26151350e-02f, 1.78368744e-02f, 2.79739559e-01f, 2.07217354e-02f, 2.31984615e-01f, 2.37989817e-02f,
  -8.64121318e-02f, 2.96450913e-01f, -1.79318842e-02f, 2.33680934e-01f, 3.71509679e-02f, 4.13821131e-01f, 1.11264683e-01f, 2.52567798e-01f, 1.62687644e-01f, 8.38634893e-02f,
  -7.47998804e-02f, 2.04538871e-02f, 4.45721485e-02f, 1.37362242e-01f, -1.54863268e-01f, -1.63585722e-01f, 3.14297199e-01f, -1.75221846e-01f, -9.65038985e-02f, -3.04979503e-01f,
  2.11825043e-01f, -4.15319726e-02f, -2.66714424e-01f, 4.06026542e-01f, -4.95505594e-02f, -5.95402829e-02f, 3.66477296e-02f, 2.50603527e-01f, 3.52801025e-01f, -4.41006236e-02f,
  -1.01927191e-01f, 1.77499115e-01f, 9.77021232e-02f, -3.28484833e-01f, -3.97917867e-01f, -1.64839223e-01f, 4.20999080e-01f, 3.90341341e-01f, 1.98905133e-02f, -6.49626506e-03f,
  -2.72758193e-02f, -2.63098419e-01f, 8.00089315e-02f, 2.18865767e-01f, 2.00877160e-01f, 1.69558246e-02f, 1.50486127e-01f, -7.22773075e-02f, 4.92369458e-02f, 3.96695793e-01f,
  2.58581638e-01f, -2.12882459e-01f, -3.13133121e-01f, -1.74500316e-01f, 2.53884047e-01f, 1.64487362e-01f, 8.47719610e-02f, -2.45731518e-01f, 3.94393682e-01f, -1.58462375e-01f,
  2.63783429e-02f, 9.29692909e-02f, -2.10960701e-01f, -6.22704811e-02f, -6.65709376e-02f, 2.19920799e-01f, 2.22268224e-01f, 1.04070172e-01f, 5.33797918e-03f, -3.45223956e-02f,
  -7.43397921e-02f, -4.53252867e-02f, -2.73553245e-02f, 1.28986388e-01f, 3.05085957e-01f, 2.76713908e-01f, -2.60562152e-01f, -8.65997896e-02f, 3.36300045e-01f, 2.26611778e-01f,
  9.94704291e-02f, 2.85319060e-01f, -2.53239244e-01f, 9.76629928e-02f, -1.72272712e-01f, -1.61015794e-01f, 3.82441610e-01f, 3.51597458e-01f, 1.07598446e-01f, -1.27072036e-01f,
  2.60534346e-01f, -2.65179247e-01f, 6.30397052e-02f, 4.70637493e-02f, -2.85874814e-01f, -1.70171589e-01f, 1.49087310e-01f, -1.34078667e-01f, 5.37198067e-01f, 3.89349878e-01f,
  1.42747328e-01f, -1.76410809e-01f, 1.95949465e-01f, 1.87224478e-01f, 3.15502286e-01f, -1.49788827e-01f, -2.36310154e-01f, 1.97428256e-01f, 2.27324456e-01f, 1.03374347e-01f,
  5.44335209e-02f, -4.53331545e-02f, -5.54325618e-02f, 1.67276561e-01f, 4.11522210e-01f, -1.84108853e-01f, 1.87064707e-01f, -2.18050092e-01f, -1.09903358e-01f, -2.38294989e-01f,
  -1.30441606e-01f, 2.80118048e-01f, 2.35851750e-01f, 3.23554665e-01f, -2.73932606e-01f, 4.34835374e-01f, -7.53591061e-02f, 7.07064494e-02f, -5.06904647e-02f, 8.66287723e-02f,
  -8.97775441e-02f, -2.76236951e-01f, 3.25999856e-01f, 6.45000488e-02f, 4.83584069e-02f, -2.11623088e-01f, -1.77446082e-01f, 2.33076960e-01f, 4.31089103e-02f, 1.45797562e-02f,
  2.26945221e-01f, -1.66872680e-01f, -1.51865967e-02f, 3.51640224e-01f, -3.14896077e-01f, 1.93823889e-01f, -3.30627337e-02f, 3.40169251e-01f, 2.98110545e-01f, 1.02614298e-01f,
  2.35060334e-01f, 7.63260126e-02f, 2.96045274e-01f, 7.07110809e-03f, 1.50305748e-01f, 1.71836242e-02f, -1.68285802e-01f, -1.16551317e-01f, 1.31104156e-01f, -6.90700933e-02f,
  -1.78193241e-01f, 4.23903167e-02f, 1.56482607e-01f, 4.08805311e-01f, 2.67662369e-02f, -6.10750206e-02f, -1.20464377e-01f, -4.17340249e-02f, 1.52934287e-02f, 3.01015645e-01f,
  -2.07795098e-01f, 7.56016597e-02f, 5.25166392e-02f, 9.87241939e-02f, -2.79441565e-01f, 3.74070764e-01f, 2.89481640e-01f, 9.99173298e-02f, 2.96902776e-01f, 3.65206599e-02f,
  2.10140705e-01f, -1.31030902e-02f, -2.52826631e-01f, -7.24607408e-02f, -1.78620204e-01f, 3.90588045e-02f, -1.92618087e-01f, 3.16093504e-01f, -4.61811684e-02f, 1.78259075e-01f,
  7.77813792e-02f, -4.58716638e-02f, -2.78159410e-01f, 2.62586832e-01f, 2.13974118e-01f, -6.17805161e-02f, 3.19878101e-01f, 1.78685598e-02f, -2.38570757e-02f, 4.10214700e-02f,
  1.21589407e-01f, -3.93083727e-04f, 1.38283923e-01f, 1.71982393e-01f, -1.68897599e-01f, 1.23158067e-01f, 2.04531431e-01f, -1.86867982e-01f, 8.24259892e-02f, 2.00776279e-01f,
  -9.81714875e-02f, -2.48443916e-01f, -3.50928843e-01f, -1.51121289e-01f, -1.69439744e-02f, 3.82924855e-01f, -1.84287533e-01f, -6.20978139e-02f, 3.27492028e-01f, -1.68846503e-01f,
  2.22305477e-01f, 3.32308531e-01f, -1.05362795e-01f, 1.72078758e-01f, 4.46719229e-01f, -2.65638053e-01f, 3.15796345e-01f, 7.42125064e-02f, 3.43097866e-01f, -2.67326813e-02f,
  2.37753287e-01f, 1.25362903e-01f, 4.16735649e-01f, 1.87906418e-02f, 1.94422916e-01f, -1.13760307e-01f, -9.29335728e-02f, -2.73633122e-01f, 4.60495353e-01f, -1.71997577e-01f,
  1.88606651e-03f, -1.46832600e-01f, -8.33873898e-02f, 1.64956495e-01f, -5.45433201e-02f, 7.85532873e-03f, -7.26910355e-03f, -7.99017847e-02f, 9.40170325e-03f, 4.40504014e-01f,
  -5.12528904e-02f, 4.57422942e-01f, -1.72009230e-01f, 5.51417351e-01f, -1.23962216e-01f, 2.77213544e-01f, 2.96863496e-01f, -3.08893144e-01f, 4.15032774e-01f, 1.55496376e-03f,
  6.42905608e-02f, -1.07760817e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.26363197e-01f, -1.07981399e-01f, 2.17178017e-01f, 1.29551351e-01f, 1.30228654e-01f, -4.72388649e-03f, 8.82433951e-02f, 5.15813902e-02f, -1.63153987e-02f, 6.28755391e-02f,
  8.77254978e-02f, 7.18659535e-02f, -5.23839034e-02f, 8.86439979e-02f, 6.30620420e-02f, 3.26595753e-01f, -5.01230173e-02f, 6.06867932e-02f, 1.04526266e-01f, 1.02007091e-01f,
  -1.00313850e-01f, 9.05949622e-02f, -9.93298069e-02f, -6.35148212e-02f, 1.12725692e-02f, 2.11230993e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.62875743e-02f, 1.18030943e-01f, -8.52807909e-02f, -2.55129308e-01f, 3.26188385e-01f, 2.86773443e-01f, -2.63593107e-01f, -4.29535061e-01f, 1.38225481e-01f, 2.41302863e-01f,
  1.33952806e-02f, 4.79207560e-02f, -3.47737402e-01f, -4.61709708e-01f, -1.45814270e-01f, -3.13076675e-01f, 2.86030024e-01f, -3.63368630e-01f, 3.21205318e-01f, -4.74311471e-01f,
  -3.55803370e-01f, -2.97903001e-01f, 2.26285979e-01f, 1.96058229e-01f, 2.81996310e-01f, -8.37222412e-02f, -7.23554790e-02f, 1.60170913e-01f, -1.64298844e-02f, 3.46002400e-01f,
  -5.46607256e-01f, -2.49685138e-01f, -2.48838395e-01f, -5.71371205e-02f, 1.79536194e-01f, 4.42140013e-01f, 2.22070575e-01f, -1.44482717e-01f, -3.83883268e-01f, -1.96991488e-01f,
  2.07556620e-01f, 5.29910214e-02f, 2.98392743e-01f, -5.88042676e-01f, -6.43534288e-02f, 9.12887752e-02f, -5.31294644e-01f, 3.51296276e-01f, -2.82240426e-03f, 5.61386161e-02f,
  4.83249098e-01f, -9.22644362e-02f, 3.72525364e-01f, -3.02572101e-02f, -1.78123489e-01f, 2.34810069e-01f, -4.36494142e-01f, 2.63242424e-01f, -3.72007012e-01f, 1.16886646e-01f,
  -1.50603816e-01f, -9.80212912e-02f, -2.89312094e-01f, -3.29381078e-01f, -1.69234965e-02f, -2.58414507e-01f, 7.32533336e-02f, -2.27758307e-02f, 2.36867834e-02f, 1.81624182e-02f,
  -4.64583039e-01f, -3.80222410e-01f, -5.46733916e-01f, -2.06192154e-02f, -1.98241342e-02f, -8.74435231e-02f, 4.07583386e-01f, 2.69414395e-01f, -3.03506523e-01f, 3.40805531e-01f,
  -3.65762323e-01f, 1.39954500e-03f, -3.32416147e-01f, -2.10993141e-01f, 2.76378155e-01f, 2.01130211e-01f, 4.03563045e-02f, -2.89466709e-01f, -2.01743886e-01f, 2.02694565e-01f,
  9.26449299e-02f, -2.44192079e-01f, 4.10558075e-01f, -2.02512398e-01f, -3.69098067e-01f, -4.18267518e-01f, 8.77176598e-02f, -2.11620986e-01f, -1.69819713e-01f, -1.24036953e-01f,
  1.41456485e-01f, 2.20158324e-02f, -2.35172093e-01f, -1.39018632e-02f, 2.42584988e-01f, -3.04940343e-01f, -3.73153657e-01f, 1.81763247e-01f, 9.60297957e-02f, -1.95821017e-01f,
  3.62972349e-01f, -1.09931687e-02f, 3.19076747e-01f, 1.17305644e-01f, 2.39215508e-01f, 1.88590303e-01f, -1.91744953e-01f, -6.68295979e-01f, -4.11780119e-01f, 1.82278410e-01f,
  3.02704275e-01f, -3.95235956e-01f, -3.98970276e-01f, -5.22554934e-01f, -1.94080189e-01f, -1.94626033e-01f, -2.46555102e-03f, -4.95066017e-01f, 1.47479177e-01f, 3.43474329e-01f,
  1.52589709e-01f, -9.81982797e-02f, -5.29865801e-01f, -6.14244878e-01f, 3.84791434e-01f, -1.34457737e-01f, 1.00528479e-01f, -2.67021120e-01f, -3.60014737e-01f, 1.20141841e-01f,
  -4.10653800e-01f, -1.14308901e-01f, 1.67659685e-01f, -4.71695244e-01f, 2.89948821e-01f, -1.60502329e-01f, -3.33569974e-01f, 3.22539926e-01f, -1.84028894e-01f, 4.05443281e-01f,
  1.84011087e-03f, -3.70454341e-01f, 2.40062922e-01f, -1.84475169e-01f, -3.37132156e-01f, -1.35425955e-01f, -3.70607644e-01f, -2.31864713e-02f, -7.88334943e-03f, 8.53005946e-02f,
  1.38319388e-01f, 3.36357392e-02f, -7.50318542e-02f, -3.03199232e-01f, 1.48588791e-01f, 1.48352936e-01f, 1.97706565e-01f, -4.08392817e-01f, -4.65302318e-02f, 4.49363023e-01f,
  2.98514843e-01f, -2.31822710e-02f, -2.70864099e-01f, -3.09923172e-01f, -3.04573476e-01f, -2.71497935e-01f, -2.76863307e-01f, 1.20251089e-01f, -2.08510056e-01f, -3.16217661e-01f,
  -3.55986468e-02f, 3.58064532e-01f, -1.48010939e-01f, -2.88119644e-01f, -5.49520180e-02f, -2.57945340e-02f, -3.42800021e-01f, 3.47302169e-01f, -3.56524020e-01f, -6.51464835e-02f,
  8.69093239e-02f, 4.06749099e-01f, -3.91328633e-02f, 1.90461099e-01f, 1.05229586e-01f, 3.92091095e-01f, 1.37490286e-02f, 2.84749150e-01f, 3.58254015e-01f, 1.07530151e-02f,
  -4.45810676e-01f, 1.71756715e-01f, -3.34460467e-01f, -5.69853127e-01f, 3.02012861e-01f, 3.03765349e-02f, -2.25296885e-01f, 9.10215899e-02f, -1.09555528e-01f, 2.75862426e-01f,
  -1.67491853e-01f, -1.81144446e-01f, -1.38223901e-01f, 1.90996364e-01f, -4.21894729e-01f, -6.47189438e-01f, -4.20944452e-01f, 1.29849240e-01f, 3.75019759e-01f, -1.22514382e-01f,
  5.40860631e-02f, -3.79349470e-01f, 4.22433347e-01f, 1.24522462e-01f, -2.27570698e-01f, 1.04928866e-01f, -2.93776626e-04f, -6.78743795e-02f, -2.26034038e-03f, -6.05824888e-02f,
  6.80120513e-02f, 3.89673591e-01f, -3.31413984e-01f, -3.10174197e-01f, -2.26177990e-01f, 2.47561261e-01f, -3.82874310e-01f, -3.35853398e-01f, -3.46591547e-02f, 8.86909813e-02f,
  2.48318955e-01f, -2.91069299e-01f, 3.10362965e-01f, 2.13779002e-01f, -2.35632777e-01f, -2.98060179e-01f, 4.52324152e-01f, 3.88720185e-01f, -3.32262874e-01f, -2.24147379e-01f,
  -3.74112993e-01f, -2.98970938e-01f, 1.99346617e-01f, 2.46329814e-01f, -3.17607552e-01f, -3.33672434e-01f, -1.44042790e-01f, -9.44103822e-02f, -1.17218621e-01f, -6.93282038e-02f,
  8.98186713e-02f, 1.63683549e-01f, -3.99293929e-01f, -3.16500105e-02f, -3.73964310e-01f, 1.89636230e-01f, 1.97694540e-01f, -2.74826467e-01f, 1.54974893e-01f, 2.67552078e-01f,
  4.00668651e-01f, -2.40608871e-01f, 1.11488169e-02f, -9.00557563e-02f, -3.33646864e-01f, 9.00585800e-02f, -2.10272759e-01f, -3.77083004e-01f, 3.32022220e-01f, 1.38841778e-01f,
  -2.83170968e-01f, 1.67904004e-01f, 1.71639353e-01f, 7.11441115e-02f, -8.00289214e-02f, 4.35157150e-01f, 6.93187565e-02f, -2.06076086e-01f, 6.91645518e-02f, 9.76362452e-02f,
  2.27064505e-01f, -2.34446868e-01f, 4.38698679e-02f, 2.86213513e-02f, 2.43819296e-01f, 2.85116911e-01f, -4.01465744e-01f, -3.58431160e-01f, -3.05769801e-01f, 3.58236320e-02f,
  3.25296253e-01f, -3.21557850e-01f, -4.44841057e-01f, 1.35529101e-01f, -4.67245430e-01f, -4.75434422e-01f, -3.01389009e-01f, 3.27609897e-01f, -9.10088792e-02f, 9.87629965e-02f,
  2.52072752e-01f, 9.43813697e-02f, -4.74617034e-01f, -3.94469351e-01f, 1.98218703e-01f, -3.62699658e-01f, 2.66734213e-01f, -1.68453425e-01f, -4.33949202e-01f, 2.15284005e-01f,
  -1.52350828e-01f, 1.30284339e-01f, 1.73607886e-01f, 2.38767564e-01f, -2.55050272e-01f, -2.69627184e-01f, -1.83082864e-01f, -1.50197625e-01f, 1.27220750e-01f, -4.89118338e-01f,
  8.55950266e-02f, -4.47258959e-03f, -2.39017710e-01f, 5.18480301e-01f, -1.41982049e-01f, -1.79577634e-01f, -2.76961505e-01f, 2.79503673e-01f, 5.37712185e-04f, -2.53267437e-01f,
  5.65477721e-02f, -3.15306097e-01f, -4.12195206e-01f, 1.96613878e-01f, 2.15248764e-01f, 2.13920444e-01f, 4.45947528e-01f, -3.75795692e-01f, -3.17481190e-01f, -2.76068270e-01f,
  3.92673612e-01f, -5.25133073e-01f, -4.21653092e-02f, -1.07000776e-01f, 3.96719994e-03f, -2.25546226e-01f, -1.50652230e-01f, 4.70944524e-01f, 3.47919762e-01f, 4.17232752e-01f,
  3.11780453e-01f, -1.53618068e-01f, 1.34674594e-01f, 1.65244758e-01f, -4.12103653e-01f, -5.50100386e-01f, 1.84186384e-01f, -2.03335151e-01f, -5.03839731e-01f, 4.07102466e-01f,
  -3.47403198e-01f, -5.34734964e-01f, -3.09588194e-01f, -2.58754373e-01f, -4.00822043e-01f, 1.28108144e-01f, -2.55938351e-01f, -3.85220163e-02f, 1.04614511e-01f, -3.57116967e-01f,
  -1.63991764e-01f, -2.86835670e-01f, 1.03373580e-01f, 3.30014825e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  9.60688069e-02f, 1.05694056e-01f, -1.67775154e-01f, -1.11945234e-01f, 2.17046663e-01f, 1.01477489e-01f, 4.18349095e-02f, 2.28451900e-02f, -8.27777758e-03f, 7.22173899e-02f,
  -1.43043041e-01f, -8.07604790e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    