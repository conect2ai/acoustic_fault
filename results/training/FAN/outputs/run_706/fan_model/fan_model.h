/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.80118028e-02f, -1.57887951e-01f, -6.04024669e-03f, -5.68346120e-02f, -1.58472016e-01f, -1.27646431e-01f, -1.88241944e-01f, -7.15361908e-02f, -5.76890521e-02f, -1.50966823e-01f,
  -2.64932718e-02f, 1.92184314e-01f, 1.80629209e-01f, 4.22850028e-02f, 1.55198753e-01f, -9.89574641e-02f, -1.45002857e-01f, 3.98589745e-02f, 1.59826562e-01f, -1.47556281e-02f,
  -1.78496316e-02f, -9.39668119e-02f, 5.19390516e-02f, 9.76226628e-02f, -1.73636720e-01f, 1.04105556e-02f, -1.79411143e-01f, -1.11029692e-01f, -2.93841027e-02f, -3.98982704e-01f,
  4.34324965e-02f, -2.93913074e-02f, -8.33253637e-02f, 1.81743558e-02f, 1.71547441e-03f, -2.55822595e-02f, 7.67703876e-02f, -7.13659674e-02f, 2.87965462e-02f, -5.58579937e-02f,
  3.01945815e-03f, -3.29054967e-02f, -3.72803919e-02f, -5.15544564e-02f, 4.76249829e-02f, -2.98487302e-02f, -9.57355648e-02f, -5.22741787e-02f, -2.69741230e-02f, -9.45744812e-02f,
  -1.64656967e-01f, -5.93796000e-02f, 4.87289540e-02f, 2.95697190e-02f, -1.02859490e-01f, 4.25953381e-02f, -6.24472797e-02f, -6.00624010e-02f, 2.03605881e-03f, -1.46003023e-01f,
  -3.98881696e-02f, 5.65458648e-02f, 3.30369808e-02f, -1.29856452e-01f, -8.49313065e-02f, -5.36293387e-02f, 1.06238583e-02f, -9.29200277e-02f, 1.67345349e-02f, -3.09492424e-02f,
  6.51916414e-02f, -1.44869862e-02f, -2.71277875e-02f, -9.11188424e-02f, -6.37446940e-02f, -1.90516915e-02f, 4.61062863e-02f, 1.91574804e-02f, 1.11130290e-02f, -8.11448246e-02f,
  1.39094507e-02f, -4.65428345e-02f, 3.41642350e-02f, -4.88912128e-03f, -8.90006199e-02f, -1.37747414e-02f, 5.25737368e-02f, 1.79915614e-02f, 8.52910727e-02f, 1.43721169e-02f,
  1.74828246e-01f, 1.76302910e-01f, -1.53773781e-02f, -4.50150222e-02f, 6.62211925e-02f, -3.15357484e-02f, -8.83354526e-03f, 1.28024761e-02f, 6.98438063e-02f, -3.29860002e-02f,
  1.81385372e-02f, 4.90439348e-02f, 6.16510026e-03f, -3.48848617e-03f, 4.24560085e-02f, -5.34353554e-02f, 3.03195231e-02f, -4.97727841e-02f, -7.07591996e-02f, -3.77224460e-02f,
  2.38514785e-03f, -6.29111007e-02f, 3.81103829e-02f, 5.13716117e-02f, 6.24671653e-02f, 9.16272923e-02f, 6.09448627e-02f, 8.24356638e-03f, 3.77562456e-02f, -1.18059162e-02f,
  -2.81590372e-01f, 2.41651267e-01f, 2.12475836e-01f, -5.39816245e-02f, 6.90598935e-02f, 4.16133776e-02f, 8.41613635e-02f, -1.55391976e-01f, -1.52468041e-01f, 2.58102119e-02f,
  1.56347528e-01f, -5.77874817e-02f, -6.42642677e-02f, 9.20824241e-03f, -1.83615401e-01f, 1.39642851e-02f, -2.24350430e-02f, -1.86559245e-01f, -2.77167261e-01f, -1.10151656e-01f,
  -4.60669473e-02f, -3.40860747e-02f, -1.94117263e-01f, -1.77739024e-01f, 5.96028604e-02f, -3.01924348e-02f, 1.34006828e-01f, 2.37119496e-01f, 1.65858760e-01f, 3.72615248e-01f,
  2.94674724e-01f, 2.92615682e-01f, -1.98309049e-02f, -4.35576551e-02f, 1.00178935e-01f, -6.07387051e-02f, 3.81070189e-03f, -2.38421988e-02f, -5.94927222e-02f, 5.41660413e-02f,
  1.79167062e-01f, 5.09643070e-02f, -7.05900341e-02f, -1.70129109e-02f, 7.13723600e-02f, 2.52790172e-02f, -1.05445758e-02f, 3.99085283e-02f, 3.95517424e-02f, 3.80566940e-02f,
  1.22617021e-01f, 2.09116146e-01f, 1.95033327e-01f, -5.65648451e-02f, 1.13459621e-02f, -5.43767661e-02f, 3.32390144e-02f, -1.16673457e-02f, -6.18652739e-02f, -5.49095087e-02f,
  -9.34708193e-02f, 5.61683886e-02f, 3.26778404e-02f, -7.00660124e-02f, -6.77753314e-02f, 8.80381316e-02f, 6.40257969e-02f, -4.24020998e-02f, -1.35071725e-01f, -5.66480076e-03f,
  4.12028618e-02f, -6.06315164e-03f, 5.03512705e-03f, -7.10452199e-02f, 3.43642421e-02f, 3.19326408e-02f, 4.41211201e-02f, 3.36739719e-02f, -6.01494424e-02f, 2.33854502e-02f,
  7.37675652e-03f, -7.60161551e-03f, 6.65544346e-02f, -3.34034823e-02f, -5.36517566e-03f, -4.35424894e-02f, 9.60395187e-02f, -3.64334285e-02f, 9.76340771e-02f, 8.61947238e-03f,
  -1.89084709e-01f, 1.54380962e-01f, -3.68535221e-02f, -8.53625387e-02f, 9.00630057e-02f, -3.22923735e-02f, 6.77643418e-02f, -3.89220193e-03f, -3.32890935e-02f, 3.32849063e-02f,
  9.10135508e-02f, -1.14907091e-02f, 4.40701544e-02f, 7.17725009e-02f, -6.12392835e-02f, -7.34404624e-02f, 1.62171386e-03f, -1.03098147e-01f, -3.80193554e-02f, 8.98134522e-03f,
  -7.50028044e-02f, -2.00774267e-01f, -1.66229159e-01f, -8.87944624e-02f, -5.92076369e-02f, -1.58093989e-01f, -8.58174264e-02f, -5.42878993e-02f, -1.91849649e-01f, -1.88391820e-01f,
  2.74360687e-01f, -4.94159788e-01f, -1.12006061e-01f, 7.30658025e-02f, -6.16110936e-02f, -2.13214923e-02f, 8.57621059e-03f, -1.33374408e-02f, -5.26620522e-02f, -1.51772454e-01f,
  -4.04264173e-03f, 1.10051231e-02f, 2.51198877e-02f, -8.78634825e-02f, -9.68243927e-02f, -1.34320125e-01f, -4.26227190e-02f, -2.52437349e-02f, 1.40120208e-01f, 6.36571720e-02f,
  -6.04792535e-02f, 1.22284546e-01f, 1.43975243e-01f, -7.98483342e-02f, -1.19640157e-01f, -1.65155437e-02f, -2.25160588e-02f, 4.87137176e-02f, -2.33383864e-01f, -2.14977816e-01f,
  -4.66778055e-02f, -2.40057573e-01f, -9.92380604e-02f, -1.76687479e-01f, -4.94905822e-02f, -6.16851822e-02f, -3.78756374e-02f, -5.35063222e-02f, -1.37636945e-01f, -1.15552872e-01f,
  -1.54496163e-01f, -1.82715639e-01f, -7.86434114e-02f, -9.94818583e-02f, -3.88283320e-02f, -4.79124524e-02f, -1.62213705e-02f, -2.00934365e-01f, -6.62759021e-02f, -1.28913850e-01f,
  -1.60378158e-01f, -1.34497732e-01f, 2.18179096e-02f, -1.74673229e-01f, -3.46687734e-02f, 3.56909446e-02f, -8.22061375e-02f, -3.22625525e-02f, 1.50884930e-02f, 5.33330813e-02f,
  4.56855446e-02f, 5.40757785e-03f, -2.60197707e-02f, 1.01704234e-02f, 1.33423090e-01f, 6.75400048e-02f, 5.02095409e-02f, -1.00838551e-02f, -1.72784496e-02f, 1.21059582e-01f,
  -7.00125620e-02f, 6.87362626e-02f, 3.20462547e-02f, -1.96826179e-02f, -2.78588235e-02f, 3.37503776e-02f, -1.91650819e-02f, -3.72677520e-02f, 6.66042417e-02f, 1.13967014e-02f,
  5.69099896e-02f, 1.28948716e-02f, 5.43636717e-02f, -1.34082336e-03f, -7.90289976e-03f, 4.84453188e-03f, 8.17408711e-02f, 5.29201701e-02f, 9.88497585e-02f, 9.58439186e-02f,
  1.00343995e-01f, -1.39906481e-01f, -4.29948643e-02f, -1.12197444e-01f, -1.72072910e-02f, -6.52131736e-02f, -8.71900320e-02f, -1.39216319e-01f, -1.35734648e-01f, -9.50026065e-02f,
  -1.67586938e-01f, 1.70315225e-02f, -1.38477847e-01f, -2.88139489e-02f, 1.12946026e-01f, -9.39860716e-02f, -8.27804953e-02f, 1.90418474e-02f, -1.28742620e-01f, -5.96735673e-03f,
  -4.60116453e-02f, 3.20964828e-02f, 1.61268383e-01f, -8.41697305e-02f, 2.80615706e-02f, 1.61278099e-01f, 6.80580661e-02f, 9.03136730e-02f, 4.79722694e-02f, 1.44197941e-01f,
  -5.20862162e-01f, -1.58032447e-01f, -1.65701136e-01f, -1.61677778e-01f, 1.95108857e-02f, 1.47544453e-02f, -2.96179265e-01f, -1.12282649e-01f, 1.05946302e-01f, -7.50123858e-02f,
  1.30140632e-01f, 2.65231669e-01f, 2.32416570e-01f, 1.03781700e-01f, -1.25392780e-01f, -1.40897349e-01f, -1.53853506e-01f, -9.06718224e-02f, 6.30419180e-02f, 5.88223301e-02f,
  1.33375287e-01f, -1.52296484e-01f, -1.38170615e-01f, -7.24560171e-02f, 4.54197824e-02f, 1.83973670e-01f, 1.87873859e-02f, -5.39349839e-02f, 8.29026103e-02f, -9.88094285e-02f,
  1.05548047e-01f, -1.37124822e-01f, 1.25355631e-01f, 8.60005692e-02f, 1.01970367e-01f, -2.94264164e-02f, 7.71593973e-02f, -2.54311170e-02f, -4.88511734e-02f, -4.55743894e-02f,
  -5.19608632e-02f, -5.79576939e-02f, 3.25699411e-02f, -1.06313694e-02f, 1.28480829e-02f, -1.17442653e-01f, -2.65383255e-03f, -1.56023018e-02f, -6.80139959e-02f, -5.41710965e-02f,
  4.66525368e-02f, -9.74388644e-02f, -8.16803277e-02f, -7.90455192e-02f, -6.79711923e-02f, 5.18151969e-02f, -8.35202485e-02f, -2.71477401e-02f, 3.28073911e-02f, -1.94885418e-01f,
  8.04924741e-02f, 2.42236964e-02f, 3.27390283e-02f, -9.73428320e-03f, -4.47981693e-02f, 5.76943867e-02f, 6.63196295e-02f, -4.30694297e-02f, -8.56165309e-03f, 8.34918022e-03f,
  2.61886336e-04f, 1.86665412e-02f, -4.11142707e-02f, -1.01858497e-01f, 3.09326919e-03f, -8.13429728e-02f, -9.45116282e-02f, -6.80025443e-02f, -7.33855693e-03f, -3.44164968e-02f,
  6.21862710e-02f, -1.08797837e-03f, -3.16725187e-02f, -1.81848686e-02f, 3.81003842e-02f, -5.30979969e-02f, -5.75388670e-02f, 5.54247480e-03f, -1.51965469e-02f, 5.89898136e-03f,
  7.25039914e-02f, 9.88677070e-02f, 3.74150835e-02f, -1.06998226e-02f, -1.18161626e-01f, -2.58168578e-02f, 1.41576873e-02f, -2.19312385e-02f, 2.54795924e-02f, -6.81813657e-02f,
  -2.56678108e-02f, -2.64802929e-02f, 9.14009660e-03f, -2.44482029e-02f, 1.08938748e-02f, 2.01729834e-02f, -9.81142446e-02f, -4.57214043e-02f, -3.42085622e-02f, -1.48538113e-01f,
  -8.87044892e-02f, -1.56815812e-01f, -1.09622605e-01f, 4.12624748e-03f, -6.30554603e-03f, 2.92038713e-02f, -1.81966126e-02f, 7.90735334e-03f, -3.63395140e-02f, -1.88279927e-01f,
  -7.16603687e-03f, 7.14516267e-02f, 8.23762748e-05f, 5.02981097e-02f, -8.05343613e-02f, 4.55111973e-02f, 2.11662427e-02f, -2.15593547e-01f, -2.32975744e-02f, 5.68081923e-02f,
  9.22842771e-02f, 1.52052164e-01f, 1.28978193e-01f, 8.86957943e-02f, 1.35838076e-01f, 2.76547551e-01f, 2.01242521e-01f, 2.01271713e-01f, 1.19891033e-01f, 1.75019026e-01f,
  1.51600614e-01f, 2.27973178e-01f, 8.39178190e-02f, -9.03130993e-02f, -1.15044221e-01f, 3.72095127e-03f, -8.60056430e-02f, 7.09155425e-02f, -6.47024764e-03f, 7.26953968e-02f,
  2.74440855e-01f, -1.55484810e-01f, 6.84378222e-02f, 1.04396291e-01f, 4.21739928e-02f, -2.35401355e-02f, 1.61189120e-02f, -5.67476936e-02f, -1.70776132e-03f, 8.87374282e-02f,
  7.98210353e-02f, 7.13895112e-02f, -2.59400140e-02f, 1.11443527e-01f, 2.53946558e-02f, 1.14345051e-01f, 5.82968704e-02f, 9.81167629e-02f, 1.54317796e-01f, 1.17398784e-01f,
  4.81033847e-02f, 1.10919081e-01f, 1.92129984e-01f, -4.14138772e-02f, 1.34982644e-02f, 1.46449953e-01f, 1.39993113e-02f, 1.46673787e-02f, 2.09892467e-02f, -6.81058620e-04f,
  -6.90275505e-02f, 6.54125120e-03f, 6.28748089e-02f, -8.17794800e-02f, -1.99837014e-02f, -8.00980162e-03f, -1.41633034e-01f, -1.46465257e-01f, -1.53758777e-02f, 2.08930727e-02f,
  3.24324407e-02f, -8.87339264e-02f, -7.63363242e-02f, -3.49862836e-02f, -3.26729119e-02f, -7.96592981e-02f, -7.41676316e-02f, 2.37988606e-02f, -1.16130434e-01f, -1.16732143e-01f,
  -5.70118502e-02f, -3.85284238e-02f, -8.49731341e-02f, -1.33566663e-01f, -5.90448193e-02f, -3.19183804e-02f, -6.18304359e-03f, -8.70573055e-03f, -5.97458296e-02f, -7.20931515e-02f,
  3.66350085e-01f, -2.42234722e-01f, 1.08875483e-01f, -6.54272363e-03f, 2.64944173e-02f, -1.73286907e-02f, -2.97271982e-02f, -1.21290602e-01f, -4.05321680e-02f, 3.50364558e-02f,
  2.44802274e-02f, 5.71252033e-03f, -2.02296097e-02f, -4.08049710e-02f, 3.13449875e-02f, 2.10211091e-02f, 7.44837299e-02f, 1.01381563e-01f, 6.01860927e-03f, -1.86451674e-02f,
  3.17285918e-02f, 1.11345053e-01f, 2.25558236e-01f, -6.00574203e-02f, 3.65252495e-02f, 1.34084702e-01f, 9.56582874e-02f, -1.76801626e-02f, 1.59567334e-02f, 7.93777257e-02f,
  3.82527530e-01f, -2.43802279e-01f, -9.71905887e-02f, 1.71019435e-01f, -2.00443104e-01f, -3.18061978e-01f, -6.13570929e-01f, -1.17454618e-01f, 2.34111235e-01f, -7.63650835e-02f,
  -5.56369759e-02f, 2.71229327e-01f, 1.96191221e-01f, 1.62294284e-01f, 3.73446494e-02f, -3.85929525e-01f, -2.89005965e-01f, 1.36536643e-01f, 1.16200469e-01f, -3.81927378e-02f,
  -9.44958329e-02f, 3.08957361e-02f, 2.56319314e-01f, 1.38785049e-01f, -7.50847235e-02f, 9.46559310e-02f, -2.79604048e-02f, 4.67840135e-02f, -2.05445150e-03f, 1.16145601e-02f,
  2.38406174e-02f, 1.57325752e-02f, 2.04350613e-02f, 1.00609444e-01f, 1.48629751e-02f, 1.66110508e-02f, -3.24025489e-02f, 1.09030288e-02f, 8.24019164e-02f, 4.51714434e-02f,
  -4.00329940e-04f, 3.90366502e-02f, 7.52780437e-02f, 4.67196517e-02f, -2.80048209e-03f, -2.43996643e-02f, 2.40167584e-02f, 6.38594553e-02f, 2.09208000e-02f, 9.55975614e-03f,
  -3.09648849e-02f, -6.13395199e-02f, -1.13798872e-01f, -2.20480915e-02f, -7.41570145e-02f, 9.71438959e-02f, -2.69534178e-02f, 1.60430029e-01f, 1.09827975e-02f, -2.97003333e-03f,
  -6.40885085e-02f, -6.10785894e-02f, -9.71178710e-03f, -3.59778106e-02f, -3.53136100e-02f, 1.82141513e-02f, -1.92915145e-02f, -4.74989191e-02f, 5.71496375e-02f, -3.95145863e-02f,
  -2.90091038e-02f, 1.74008012e-02f, 1.80589575e-02f, -4.44607958e-02f, 7.52278790e-02f, 5.07340720e-03f, 4.13825223e-03f, -1.64834801e-02f, 1.65312476e-02f, 1.53553672e-02f,
  4.53850068e-02f, 3.32755526e-03f, -1.31557118e-02f, 6.03830628e-02f, 1.15779517e-02f, 7.23951533e-02f, 4.92519140e-02f, 6.63377270e-02f, -2.14420296e-02f, 2.22232901e-02f,
  8.23948011e-02f, 3.71626355e-02f, -7.08492994e-02f, 6.26572073e-02f, -8.00627246e-02f, 2.60594916e-02f, 7.13654011e-02f, 1.15564764e-02f, 8.64367411e-02f, -3.79813835e-02f,
  5.92588745e-02f, 3.93879339e-02f, -6.22684211e-02f, 1.05586592e-02f, -3.93886380e-02f, -2.86547430e-02f, -4.27455418e-02f, -7.83782378e-02f, -4.26396914e-02f, 2.78856000e-03f,
  -9.71176103e-03f, -1.44773230e-01f, -3.83118317e-02f, -1.02561191e-01f, 7.54732117e-02f, -4.32166345e-02f, -1.32382944e-01f, 2.05074195e-02f, -4.69897725e-02f, -1.74456820e-01f,
  1.35445312e-01f, 1.15972456e-04f, 5.07257171e-02f, -1.11873329e-01f, -1.85216472e-01f, -3.35530192e-01f, -2.91035086e-01f, -2.45775893e-01f, -1.62726626e-01f, -7.53664672e-02f,
  -2.59241145e-02f, -7.72581920e-02f, 9.77964625e-02f, -1.10608954e-02f, 5.41890413e-03f, -5.50370291e-02f, -4.00016978e-02f, 5.36930561e-02f, -2.67163932e-01f, -4.08591479e-01f,
  -1.75947726e-01f, 9.17191897e-03f, -1.28859699e-01f, -7.24079087e-02f, -5.09823766e-03f, 7.60954246e-02f, 1.06315449e-01f, 6.07579201e-02f, -1.22114055e-01f, 1.54995963e-01f,
  6.81751966e-02f, -1.03774093e-01f, -2.66587138e-01f, -2.11080924e-01f, -1.67292416e-01f, -2.10824341e-01f, -1.89986169e-01f, -9.76175442e-02f, -2.20835552e-01f, -1.25203595e-01f,
  -1.99983537e-01f, -2.20646143e-01f, -1.03612177e-01f, -2.12779328e-01f, -2.45417356e-01f, -1.87014997e-01f, -2.11364776e-01f, -1.19444497e-01f, -1.92918614e-01f, -2.20779821e-01f,
  -2.04351053e-01f, -2.15457946e-01f, -1.42499000e-01f, -1.70029879e-01f, -2.42189363e-01f, -2.23705977e-01f, -1.29128516e-01f, -8.82463902e-02f, -2.27702968e-02f, 3.85113433e-02f,
  8.70575104e-03f, 5.57197034e-02f, 6.15964010e-02f, -6.26232922e-02f, 2.01359287e-01f, 1.18330084e-01f, 1.13894999e-01f, 1.41711056e-01f, 3.60640474e-02f, 1.49826020e-01f,
  2.76435688e-02f, 1.10281020e-01f, 8.47926289e-02f, 1.59121335e-01f, 1.26653552e-01f, 1.85097888e-01f, 7.91487843e-02f, 1.23009138e-01f, 1.14988990e-01f, 1.24270119e-01f,
  1.29532471e-01f, 8.20519328e-02f, 1.49196833e-01f, 9.69303474e-02f, 9.24480483e-02f, 1.46946907e-01f, 5.43431826e-02f, 2.56167073e-02f, 3.18271145e-02f, 3.60422283e-02f,
  -1.10001527e-01f, -1.50537878e-01f, -2.25707181e-02f, -3.86292562e-02f, -1.76751509e-01f, -1.85934559e-01f, -1.63073599e-01f, -1.76229343e-01f, -1.82278141e-01f, -1.51899055e-01f,
  -2.06289470e-01f, -1.86641663e-01f, -6.58163875e-02f, -1.62984759e-01f, -1.69827014e-01f, -1.87270880e-01f, -2.26778626e-01f, -1.79637507e-01f, -1.85058340e-01f, -2.79800653e-01f,
  -2.96065062e-01f, -1.77214473e-01f, -1.97585851e-01f, -6.44829348e-02f, -2.20729709e-01f, -1.04065135e-01f, -1.12086646e-01f, -1.47114515e-01f, -5.51806539e-02f, -1.32908002e-01f,
  2.79567569e-01f, -2.39206888e-02f, 2.00556338e-01f, 1.46650374e-01f, 2.52328604e-01f, 3.20196152e-01f, 9.25296471e-02f, -1.97089806e-01f, -3.63682061e-02f, -8.55795220e-02f,
  6.00671880e-02f, 1.28800347e-02f, 4.60774302e-02f, 2.19181422e-02f, -5.39280325e-02f, -4.34563980e-02f, 1.72112271e-01f, 1.84638247e-01f, 3.54877353e-01f, 2.25852966e-01f,
  1.29873544e-01f, 2.12537065e-01f, 2.19372571e-01f, 8.06141123e-02f, 3.06343809e-02f, 1.43700866e-02f, 1.08113186e-02f, 2.09290341e-01f, 6.87335581e-02f, 1.56605616e-01f,
  1.86532378e-01f, 7.44156241e-02f, 3.02115344e-02f, 9.64140892e-02f, 7.69372508e-02f, 2.66642775e-02f, 8.49189237e-02f, 3.13237980e-02f, -2.55712122e-02f, -4.40558940e-02f,
  1.06534906e-01f, 7.34347999e-02f, 5.11167664e-03f, 8.62454250e-02f, 1.00860283e-01f, 6.32034754e-03f, -9.48012769e-02f, -1.21787330e-02f, -1.60066523e-02f, -1.08392477e-01f,
  1.80152860e-02f, 1.79398686e-01f, 5.83718941e-02f, -1.00780196e-01f, -9.43687111e-02f, 5.48579358e-02f, -1.13465518e-01f, -8.08930695e-02f, -1.07620237e-02f, -8.92620012e-02f,
  -1.11953458e-02f, -1.84745621e-02f, -2.60699354e-02f, -3.13939303e-02f, -1.18836991e-01f, -6.05218895e-02f, 6.21057628e-03f, 3.50886770e-02f, 4.07522619e-02f, -1.17064677e-02f,
  -2.56240945e-02f, -5.91828376e-02f, -2.75589135e-02f, 5.30380057e-03f, 1.32101204e-03f, 1.08612195e-01f, 1.90806575e-02f, -4.69156094e-02f, -6.97347224e-02f, -8.28626156e-02f,
  8.47046450e-02f, -4.12225202e-02f, 4.57182676e-02f, 1.36299646e-02f, -1.71162393e-02f, 1.05540063e-02f, 7.74103403e-03f, 2.74714679e-02f, -5.07173389e-02f, 1.93383712e-02f,
  -6.55541494e-02f, 4.82597128e-02f, -1.08252667e-01f, -3.43382433e-02f, 1.79128543e-01f, -9.58688259e-02f, 1.20418429e-01f, 4.86113988e-02f, 9.15332139e-02f, 7.00015351e-02f,
  -1.19110802e-02f, -1.12537248e-03f, 8.32937509e-02f, 7.35610072e-03f, 7.81168267e-02f, -1.43987611e-02f, -1.00977290e-02f, 9.30187032e-02f, 1.72159281e-02f, 3.98301892e-03f,
  -8.84541273e-02f, -3.36468429e-03f, 1.44795664e-02f, -2.39192415e-03f, -3.89533117e-02f, 1.91622004e-01f, 6.58585206e-02f, 1.70196164e-02f, 1.01693429e-01f, -1.62832767e-01f,
  -5.06166518e-01f, 2.66906261e-01f, 2.39769667e-01f, -2.54453778e-01f, 9.01573673e-02f, 1.36027575e-01f, 2.80929506e-01f, -3.82383764e-02f, -1.75148860e-01f, 1.64120942e-01f,
  -3.13988663e-02f, -1.26187265e-01f, -4.23431993e-02f, -2.56870780e-02f, -2.06872933e-02f, 3.54434669e-01f, 1.42634705e-01f, -7.54615664e-02f, -1.52548507e-01f, -5.40955700e-02f,
  -1.72919650e-02f, -1.07569017e-01f, -2.41143882e-01f, -1.33723587e-01f, 3.53951380e-02f, -2.08125655e-02f, 2.01409146e-01f, -7.00453147e-02f, 7.58801624e-02f, 1.98476136e-01f,
  3.47348511e-01f, -6.06682748e-02f, -2.47472227e-02f, -4.79723029e-02f, -1.36699779e-02f, -8.19144621e-02f, -4.20982130e-02f, -9.00066122e-02f, -7.02722147e-02f, -2.23593763e-03f,
  -1.06425375e-01f, -5.65766245e-02f, -1.77334845e-01f, 2.20075846e-02f, 2.09524836e-02f, -1.63804907e-02f, -5.88732176e-02f, -1.02061331e-01f, -3.66660506e-02f, 5.80130927e-02f,
  -3.27430926e-02f, -8.50921571e-02f, 2.65722256e-02f, 6.79645836e-02f, -9.08528343e-02f, -4.40021753e-02f, 9.23846141e-02f, -1.18137933e-01f, -4.62358296e-02f, 8.02932382e-02f,
  -8.10346100e-03f, 1.30749680e-02f, 8.99998844e-02f, -6.83847070e-03f, 2.20858529e-02f, -5.36391102e-02f, 2.63286196e-02f, 1.98263265e-02f, 1.06432075e-02f, 7.75361136e-02f,
  -5.04653864e-02f, -4.39632647e-02f, 3.53061594e-02f, -6.13953620e-02f, 9.00139138e-02f, -3.26172709e-02f, 5.65948039e-02f, 9.54078883e-02f, -5.12667932e-03f, 1.48322051e-02f,
  -9.34963152e-02f, -6.79238886e-02f, 5.50951362e-02f, 3.79353911e-02f, 2.57547535e-02f, 8.53289887e-02f, -1.57063249e-02f, 2.35861614e-02f, -1.90546960e-02f, -1.86700728e-02f,
  7.51365945e-02f, -7.36554638e-02f, 7.26446733e-02f, -6.28340710e-03f, 3.34671699e-03f, -2.70904554e-03f, 1.41885146e-01f, -5.48679270e-02f, -3.93903926e-02f, -1.29395559e-01f,
  7.76071474e-02f, 6.23972109e-03f, -1.68572515e-02f, 1.62680671e-02f, -1.10322973e-02f, 2.40346156e-02f, 4.84141856e-02f, -5.42902425e-02f, -7.23151192e-02f, 2.89198186e-04f,
  6.54421523e-02f, -8.28350186e-02f, -1.16939537e-01f, -2.55064107e-02f, 4.73242514e-02f, -1.05898246e-01f, 3.85860018e-02f, 5.58260828e-02f, 6.31801859e-02f, 1.70053810e-01f,
  -4.20927018e-01f, 7.98263550e-02f, 3.23136330e-01f, -2.69890666e-01f, 1.75235018e-01f, 1.68156371e-01f, 2.77718425e-01f, -1.16162501e-01f, -3.20481449e-01f, 1.01784937e-01f,
  3.77151705e-02f, -1.98028818e-01f, -6.46368600e-03f, 4.70299646e-02f, 3.73177007e-02f, 3.35169554e-01f, 3.42371941e-01f, 1.34715661e-01f, -1.08508527e-01f, -1.02921732e-01f,
  -6.19918630e-02f, -6.41308054e-02f, -3.74245495e-01f, -1.57349750e-01f, -1.33281965e-02f, -8.69263411e-02f, 1.38264194e-01f, -6.18527643e-02f, 8.06483850e-02f, 1.67023540e-01f,
  2.45576665e-01f, -8.84844959e-02f, -1.11445040e-02f, -9.47878435e-02f, 5.01660742e-02f, -5.37393428e-02f, 3.65690924e-02f, -8.17137212e-02f, -4.88740765e-02f, -5.89069165e-02f,
  -1.21410020e-01f, -2.29264759e-02f, -6.83156922e-02f, -3.72904651e-02f, -7.26923198e-02f, -9.62345302e-02f, 1.44805107e-02f, -7.43098781e-02f, 7.07174540e-02f, 8.23466852e-02f,
  1.41169488e-01f, 6.83417171e-02f, 7.44502842e-02f, -3.40614803e-02f, -6.26055337e-03f, -6.09142147e-02f, -6.26012236e-02f, -1.03516221e-01f, -5.51227853e-02f, -1.15755834e-01f,
  -6.51152134e-02f, 6.25470951e-02f, -2.72209123e-02f, 1.60512305e-03f, -4.41928990e-02f, 2.74476539e-02f, -3.51433530e-02f, -3.18515394e-03f, 8.41101110e-02f, -2.84870546e-02f,
  1.79505236e-02f, 7.20506459e-02f, 7.12089688e-02f, 5.38203167e-03f, 3.02199423e-02f, -4.08884622e-02f, -2.84891389e-02f, -4.93976176e-02f, 3.23695652e-02f, -4.27049622e-02f,
  -6.19606636e-02f, 1.12772863e-02f, 2.60331500e-02f, -4.38919850e-02f, -2.83223465e-02f, -8.10261816e-02f, 3.20560834e-03f, -2.47525182e-02f, -4.80683409e-02f, 2.95615080e-03f,
  -1.15223534e-01f, 7.07039908e-02f, 2.93904804e-02f, -1.06348641e-01f, 1.94472857e-02f, 4.17760052e-02f, -4.04526182e-02f, -1.81405842e-02f, -1.03450501e-02f, 3.76521959e-03f,
  -7.07440302e-02f, 2.90350374e-02f, 2.77401190e-02f, 2.26158313e-02f, 2.72302534e-02f, -4.17147763e-02f, 1.87016521e-02f, -3.71678248e-02f, -3.05174664e-02f, -7.73296654e-02f,
  2.55684070e-02f, 2.44833622e-02f, 6.67579919e-02f, 5.76901250e-02f, 2.54109018e-02f, 8.66872221e-02f, 1.57007337e-01f, -2.41871160e-02f, 1.14557169e-01f, 1.47020027e-01f,
  4.61614989e-02f, 1.25067592e-01f, -4.67016213e-02f, -1.88568875e-01f, -1.61581576e-01f, -3.89154665e-02f, 7.75944144e-02f, -3.11064720e-02f, -6.35973960e-02f, 3.92590240e-02f,
  -2.66522378e-01f, -3.72164398e-01f, -3.14293772e-01f, -1.39137939e-01f, 2.37784777e-02f, 9.38582122e-02f, -8.87324195e-03f, -2.64790952e-02f, -1.47787645e-01f, -1.10098757e-01f,
  -6.04037605e-02f, -8.06520134e-02f, 9.14075673e-02f, -9.63469874e-03f, -4.19055112e-02f, -1.53850868e-01f, 1.55066187e-02f, 5.52901160e-03f, -7.00898468e-02f, -1.50252640e-01f,
  -1.44734368e-01f, 1.01034148e-02f, -1.11153290e-01f, -1.59583956e-01f, -1.28167599e-01f, -4.24851254e-02f, -1.08631663e-01f, -6.71925396e-02f, -9.19292420e-02f, -5.16383760e-02f,
  -2.02469617e-01f, -1.77314341e-01f, -2.76570648e-01f, -8.57921690e-02f, 3.77199426e-03f, 3.56309935e-02f, 3.58020067e-02f, 5.23601361e-02f, 7.52600506e-02f, 1.93783008e-02f,
  -8.26903582e-02f, -2.02458262e-01f, -6.89570978e-02f, 1.76906511e-02f, -3.28395963e-02f, -1.91301674e-01f, -1.85097251e-02f, -1.12307914e-01f, -2.61976626e-02f, -2.91560180e-02f,
  3.86215150e-02f, 4.05663857e-03f, 4.34247218e-02f, 1.84557125e-01f, 3.50755900e-02f, 3.32868807e-02f, -7.40853045e-03f, 9.53633860e-02f, 4.32057306e-02f, 1.86963510e-02f,
  5.47313802e-02f, 2.61528268e-02f, -2.18089223e-02f, 3.87398638e-02f, 5.61251678e-03f, -8.59724954e-02f, -3.75679396e-02f, 9.04760882e-02f, 3.01476102e-02f, 7.99676552e-02f,
  9.05248430e-03f, -6.83839107e-03f, 8.93525109e-02f, -1.10498201e-02f, 4.77788262e-02f, 6.84549287e-02f, 6.26885518e-02f, -7.40163494e-03f, -3.08219437e-03f, 1.63954925e-02f,
  6.88974708e-02f, -1.73296034e-01f, -8.58980715e-02f, -1.12192594e-01f, -4.68042493e-02f, -2.82340199e-02f, -3.54395285e-02f, -8.05855542e-03f, -9.77385193e-02f, 7.61700869e-02f,
  -4.45516817e-02f, -9.07886028e-02f, -1.50101870e-01f, -5.12950160e-02f, -8.97837952e-02f, 3.15859169e-02f, 9.47914571e-02f, -6.73445016e-02f, 1.21938149e-02f, -1.32610612e-02f,
  9.66479555e-02f, -3.56304683e-02f, -9.56460740e-03f, 8.06720108e-02f, -6.28478602e-02f, -1.04412280e-01f, -8.83289278e-02f, -5.25280088e-03f, 5.35232164e-02f, 1.02068394e-01f,
  -2.87744135e-01f, -1.45665348e-01f, 1.19511746e-01f, -9.84950885e-02f, -3.44181731e-02f, 2.29309909e-02f, -9.96638238e-02f, -3.78058665e-02f, -3.33703756e-02f, -1.98822215e-01f,
  -1.25869840e-01f, -4.22570631e-02f, -8.68065655e-02f, 1.55446723e-01f, 1.18581355e-01f, -6.09675534e-02f, 8.10682923e-02f, 1.24006093e-01f, 1.63180634e-01f, 2.07929894e-01f,
  1.14117190e-01f, 2.29225215e-02f, 6.73451498e-02f, 1.58133224e-01f, 3.01303193e-02f, 2.26668641e-02f, -1.22806624e-01f, 5.25312088e-02f, 3.09613217e-02f, 7.15271235e-02f,
  -1.70771271e-01f, -2.16831397e-02f, 1.32028535e-01f, 4.21637930e-02f, -1.18379913e-01f, -7.00701540e-03f, 4.38243262e-02f, 3.93384509e-02f, -6.17102273e-02f, 5.35057224e-02f,
  -5.02149351e-02f, 2.75167134e-02f, -2.51715332e-02f, 9.50012803e-02f, 2.17575338e-02f, 3.80489379e-02f, 6.52638301e-02f, 7.13847578e-02f, 1.07737659e-02f, 3.38258930e-02f,
  7.84540847e-02f, -6.19893074e-02f, -1.62748069e-01f, -6.20217249e-03f, 1.46349177e-01f, -6.39111400e-02f, -9.98415425e-03f, 1.88844338e-01f, -2.79709604e-02f, -6.22721799e-02f,
  -7.88509566e-03f, -8.45353976e-02f, -1.79760158e-02f, 7.99979270e-03f, -2.68886033e-02f, -6.85479939e-02f, -1.13516226e-02f, -6.84075952e-02f, 1.13455974e-01f, 1.73498653e-02f,
  5.35642877e-02f, -7.59251490e-02f, 5.07866889e-02f, -9.79659483e-02f, -3.64555581e-03f, -1.01954874e-03f, 3.95614132e-02f, -3.12090274e-02f, -3.19820307e-02f, 4.70771566e-02f,
  1.09845623e-02f, -1.39281212e-03f, -5.83077036e-02f, -1.01688434e-04f, 7.96747655e-02f, 5.01236990e-02f, 2.36590896e-02f, 1.18252710e-01f, 2.50521880e-02f, -3.04239877e-02f,
  -2.97907472e-01f, -4.45719697e-02f, -1.22957356e-01f, 6.79753572e-02f, -1.85277835e-02f, -2.19118856e-02f, -4.99678291e-02f, 5.01461662e-02f, -1.60084423e-02f, -4.38704565e-02f,
  -7.10759535e-02f, -1.29949264e-02f, -8.62380788e-02f, 6.87394366e-02f, 1.72623899e-02f, 5.08325938e-05f, -2.17951704e-02f, -3.55741270e-02f, 1.08722836e-01f, 3.50513011e-02f,
  -3.89963724e-02f, -4.03343849e-02f, -6.92467988e-02f, -1.16852149e-01f, -1.14224106e-02f, -2.67470405e-02f, -7.09766522e-02f, 1.31616658e-02f, -4.70641553e-02f, -2.87411779e-01f,
  2.20678255e-01f, 7.76876807e-02f, 2.23263457e-01f, 6.64259046e-02f, -8.27234313e-02f, -1.33672923e-01f, -2.58592814e-01f, 2.74586678e-02f, 6.72883168e-02f, -2.02107310e-01f,
  3.95932719e-02f, 3.04330774e-02f, 4.11383659e-02f, -6.74206242e-02f, -1.72792196e-01f, -3.20042908e-01f, -1.56004086e-01f, 2.89094672e-02f, -3.13806813e-03f, 6.44766092e-02f,
  -1.62933988e-03f, -7.60449970e-04f, 2.54065096e-01f, -1.46158636e-02f, 4.27568033e-02f, 1.25448229e-02f, 8.84749144e-02f, 1.64719954e-01f, 5.03654331e-02f, -7.92822707e-03f,
  9.03213471e-02f, 2.88726568e-01f, 7.20465481e-02f, 1.39216864e-02f, 9.84115005e-02f, 1.49788395e-01f, 5.85510619e-02f, 9.12929401e-02f, 5.89238554e-02f, 9.02010053e-02f,
  1.25999838e-01f, 1.44296005e-01f, 1.11602120e-01f, 3.10606956e-02f, 9.33753625e-02f, 4.04894128e-02f, 1.52186945e-01f, 1.70799956e-01f, 4.92747985e-02f, 1.30345449e-01f,
  9.05208215e-02f, 2.08570942e-01f, 2.81704962e-01f, 2.14747898e-02f, 1.60729438e-01f, 2.81356624e-03f, 2.13690206e-01f, 2.29315519e-01f, 6.38001710e-02f, 6.55756891e-02f,
  -7.43565559e-02f, 2.57789213e-02f, 1.26296431e-02f, -6.88833743e-02f, -1.14627674e-01f, -7.19660446e-02f, -2.03430932e-02f, -9.59570780e-02f, -6.06995039e-02f, -1.07642069e-01f,
  2.11363174e-02f, -2.59866118e-02f, -2.18212511e-02f, -2.19341516e-02f, -6.65949583e-02f, -4.21672734e-03f, -1.32426262e-01f, -1.03133351e-01f, 1.02335559e-02f, -1.57898199e-02f,
  -7.20901564e-02f, 4.94981892e-02f, -8.96792412e-02f, 3.89473164e-04f, -8.30377638e-02f, -5.45303486e-02f, -4.50127684e-02f, -6.97563812e-02f, -5.48777655e-02f, -8.07381123e-02f,
  -1.48680314e-01f, 4.98142801e-02f, -1.23474985e-01f, 3.73924896e-02f, 7.78221264e-02f, 5.56602329e-02f, 1.83440577e-02f, 4.74199429e-02f, -1.77957863e-03f, -6.63173199e-02f,
  1.01728313e-01f, 1.13556981e-02f, 6.46597520e-02f, 5.32753300e-03f, 1.01091452e-01f, 5.43810017e-02f, 2.91450955e-02f, -7.00796545e-02f, 3.36492173e-02f, 1.21416897e-01f,
  -1.11540064e-01f, -9.09466445e-02f, -7.21127838e-02f, -1.24185696e-01f, 5.07795699e-02f, -1.55237406e-01f, -1.48661032e-01f, -1.41586382e-02f, -1.07280910e-01f, -4.12915707e-01f,
  -2.34964028e-01f, 1.81504235e-01f, -2.50627995e-01f, 1.53387114e-01f, 1.76694110e-01f, -1.17071897e-01f, -2.82346997e-02f, 5.54158464e-02f, 1.23647369e-01f, 1.28881186e-01f,
  6.65702447e-02f, -1.73496157e-01f, -1.75644144e-01f, -2.50869960e-01f, -2.30953023e-01f, 1.75940439e-01f, 2.69476380e-02f, -4.00230378e-01f, -5.13211012e-01f, -1.57572508e-01f,
  1.82277113e-01f, 9.44258124e-02f, 2.32603606e-02f, -5.82469963e-02f, 3.07636827e-01f, -6.82505369e-02f, 1.79819673e-01f, 1.19920857e-01f, -1.38383564e-02f, 2.34844401e-01f,
  -2.93443799e-01f, -3.44817191e-02f, -5.33923842e-02f, 5.93160698e-03f, 3.22838761e-02f, -8.75868052e-02f, -1.16144322e-01f, 1.39131602e-02f, 4.16519046e-02f, -1.34500572e-02f,
  9.26290751e-02f, -1.49162794e-02f, 5.14420960e-03f, 4.28990163e-02f, -7.87160099e-02f, -1.32995863e-02f, 9.18769464e-02f, -8.84011462e-02f, -1.03940316e-01f, -8.34346861e-02f,
  -3.02591976e-02f, 8.72095153e-02f, -8.89805779e-02f, 1.62250269e-02f, -1.39974892e-01f, -4.26628925e-02f, 2.67988015e-02f, -1.75128113e-02f, -1.91974655e-01f, 1.70220695e-02f,
  -1.14024505e-01f, -3.34864948e-03f, 3.15871798e-02f, -3.23967487e-02f, -1.85142066e-02f, -3.30058043e-03f, -4.30276766e-02f, -2.71092877e-02f, 1.90367922e-02f, 7.62630478e-02f,
  -3.13821509e-02f, -5.58697283e-02f, -2.38060504e-02f, 6.41545504e-02f, 3.72906178e-02f, 5.55063225e-03f, -6.22241618e-03f, 7.77916517e-03f, -1.09503493e-02f, 1.00189276e-01f,
  -5.79817295e-02f, -6.85524195e-02f, 1.33996502e-01f, -7.73553476e-02f, 4.18666638e-02f, -4.37327623e-02f, 7.68901408e-03f, 1.12185779e-03f, -1.41284084e-02f, 2.73778997e-02f,
  6.16569594e-02f, -1.41975924e-01f, -7.77980611e-02f, -9.67319906e-02f, -5.75698428e-02f, -6.25317916e-02f, -1.84173360e-02f, -7.17010498e-02f, 2.27125303e-04f, -6.78932369e-02f,
  -4.95751202e-02f, -1.23682909e-01f, -5.61430827e-02f, -4.79184687e-02f, 2.77423183e-03f, -3.85714360e-02f, 3.71710733e-02f, -3.14183533e-02f, -9.55276042e-02f, 3.83765399e-02f,
  4.59453985e-02f, 1.62980109e-02f, -8.30723196e-02f, -1.69866696e-01f, -1.26167417e-01f, -1.61539137e-01f, -1.76176429e-01f, -2.56311577e-02f, -1.36928827e-01f, -2.95291375e-02f,
  -1.46697268e-01f, 2.60966569e-01f, 8.32865480e-03f, 3.59267890e-02f, 1.30327478e-01f, 8.48748013e-02f, 1.43157184e-01f, -2.08937544e-02f, -2.04216428e-02f, 2.23198444e-01f,
  1.54616177e-01f, -2.05572873e-01f, -1.71692833e-01f, -1.28072143e-01f, -2.23386019e-01f, 7.50949234e-02f, 1.61088914e-01f, -1.82388082e-01f, -4.59429443e-01f, -1.93899676e-01f,
  5.52796759e-02f, 6.52611926e-02f, -4.91836295e-02f, -9.51770917e-02f, 1.27368540e-01f, -2.24232852e-01f, 1.08666509e-01f, 9.02863815e-02f, 1.40968844e-01f, 3.29959929e-01f,
  -2.67281905e-02f, 2.22301558e-01f, -1.36330754e-01f, 8.83771777e-02f, 2.83851791e-02f, -4.04239632e-02f, -2.36585838e-05f, 2.35378975e-03f, -8.34814087e-03f, 6.89895228e-02f,
  7.16127455e-02f, 3.14962640e-02f, -8.25558975e-02f, 6.49557309e-03f, 6.72859475e-02f, -3.25040221e-02f, 1.40211925e-01f, -2.11688969e-02f, 5.62379090e-03f, 2.11867644e-03f,
  5.75462021e-02f, 2.26792380e-01f, 8.45774785e-02f, 1.26860067e-01f, 1.27580790e-02f, -1.56906694e-02f, 7.79633075e-02f, 4.37199138e-02f, 2.90115699e-02f, 4.46264558e-02f,
  1.57628059e-01f, 8.75288807e-03f, -9.04003829e-02f, 3.65708508e-02f, -3.00910529e-02f, 6.33361936e-02f, 9.45200119e-03f, 8.32926854e-03f, -9.89494771e-02f, -7.87475612e-03f,
  2.76750587e-02f, -9.54754185e-03f, -9.01491791e-02f, 4.45987992e-02f, 1.12294637e-01f, -3.72376037e-03f, -6.32386431e-02f, -9.25073847e-02f, -6.38735592e-02f, -6.74135685e-02f,
  2.44721062e-02f, -5.99432252e-02f, -6.52603209e-02f, -1.67042211e-01f, 8.23816359e-02f, 9.69960727e-03f, 3.36344019e-02f, -5.27447090e-02f, -2.26510856e-02f, 1.13800377e-01f,
  -2.71833956e-01f, -5.34588397e-02f, -3.11876070e-02f, -7.46361464e-02f, 4.39335406e-03f, -8.16373341e-03f, 9.15251556e-04f, 1.04625106e-01f, 1.34676591e-01f, 7.66847730e-02f,
  -4.58034016e-02f, 4.02285010e-02f, 1.71420798e-02f, 7.11580664e-02f, -1.05609916e-01f, 3.74117075e-03f, 8.55400637e-02f, -9.84238386e-02f, -6.23199232e-02f, 6.54891282e-02f,
  4.31067646e-02f, -1.02717847e-01f, -1.24166571e-01f, -1.87389553e-02f, 5.42145558e-02f, -1.10465288e-01f, -1.17758058e-01f, -6.78972304e-02f, -9.29595008e-02f, -1.40003949e-01f,
  -6.66541874e-01f, -7.95682147e-02f, -6.90916926e-02f, -2.01621935e-01f, 1.64391682e-01f, 1.04215287e-01f, -5.41176386e-02f, -3.93515304e-02f, 1.52514890e-01f, -2.14063353e-03f,
  1.87946275e-01f, 1.26509860e-01f, 7.08954558e-02f, 1.43831626e-01f, -8.67045894e-02f, -7.96538517e-02f, -1.50827393e-01f, -1.89375132e-01f, 5.64606860e-02f, 2.59947807e-01f,
  1.23690762e-01f, -8.70501548e-02f, -1.25723988e-01f, 2.49044562e-04f, 1.73289359e-01f, 2.30901375e-01f, 1.20266534e-01f, 7.34541714e-02f, 2.42667094e-01f, 3.85173932e-02f,
  4.62145545e-03f, -1.94219574e-01f, 7.85200521e-02f, -5.62982867e-03f, -3.20475847e-02f, -8.15610066e-02f, -9.14981961e-02f, -5.93588948e-02f, -7.70518780e-02f, 2.38950402e-02f,
  1.99439265e-02f, 4.65515368e-02f, -6.16302565e-02f, -3.83873768e-02f, -3.12582888e-02f, -2.00863499e-02f, -1.12027049e-01f, -1.02014989e-01f, -1.09652661e-01f, 7.28151947e-03f,
  3.19118388e-02f, -1.10516578e-01f, -8.02489221e-02f, 6.27915636e-02f, 5.31023666e-02f, -1.54854162e-02f, 6.69567287e-02f, 2.79224440e-02f, 2.71827281e-02f, -1.17368966e-01f,
  -2.76488867e-02f, 4.08124775e-02f, 1.24833072e-02f, -3.50670516e-02f, 6.64449111e-02f, 8.58416483e-02f, 3.84428799e-02f, 1.20352708e-01f, 3.51833403e-02f, 2.57136766e-02f,
  3.35009322e-02f, 8.77839401e-02f, 1.15587804e-02f, -2.06015352e-03f, 7.32020065e-02f, -8.07255805e-02f, 7.82458335e-02f, 6.72719106e-02f, -9.70684458e-03f, 4.68688384e-02f,
  1.19519897e-01f, 4.67289388e-02f, 4.12983559e-02f, 2.16636620e-02f, 3.00452374e-02f, -1.38536775e-02f, 4.70505171e-02f, 5.76809570e-02f, -1.38637656e-02f, 6.99465275e-02f,
  1.61167681e-01f, 6.50879666e-02f, -6.75225407e-02f, 2.34946385e-02f, -1.20803505e-01f, 9.33565944e-03f, -5.14590479e-02f, -9.29317623e-03f, 1.38006825e-02f, 5.80705982e-03f,
  1.13870436e-02f, -8.12311620e-02f, 7.56669231e-03f, 4.91744019e-02f, -8.35019106e-04f, -2.04367582e-02f, 7.30541125e-02f, -8.33539590e-02f, 9.86603945e-02f, 6.85101300e-02f,
  -1.12324432e-01f, -5.57227358e-02f, -2.16227304e-02f, -1.97046120e-02f, 1.32180043e-02f, -2.69586779e-02f, -1.06960535e-02f, 7.46092945e-02f, -1.82746705e-02f, -1.21840775e-01f,
  -4.01576817e-01f, -1.56691030e-01f, 1.65053874e-01f, -2.34184992e-02f, -8.43774900e-03f, -2.70826727e-01f, -4.59511429e-01f, -2.43449494e-01f, 3.55960019e-02f, -2.12639406e-01f,
  5.21573424e-02f, 1.82250261e-01f, 3.60097550e-02f, 1.30934358e-01f, -1.61632419e-01f, -3.23449343e-01f, -2.43557334e-01f, -8.19414258e-02f, 5.53227495e-04f, -1.01948544e-01f,
  2.55615674e-02f, -4.54436196e-03f, 5.35243154e-02f, 8.20184778e-03f, 2.30629519e-02f, 1.25721917e-01f, 7.05368221e-02f, 2.32207514e-02f, 7.47202113e-02f, 8.81271660e-02f,
  -1.12521565e-02f, -7.58606866e-02f, -1.21151865e-01f, -2.45890245e-02f, 1.11428320e-01f, -1.09934807e-01f, -1.05086222e-01f, 8.53856727e-02f, -3.56709361e-02f, -5.05125709e-02f,
  2.30026641e-03f, -6.12187870e-02f, -1.03863396e-01f, 5.74348792e-02f, -1.09590411e-01f, -1.26288444e-01f, -7.54350750e-03f, -5.46175167e-02f, -5.78555837e-02f, 6.61659334e-03f,
  -1.32711595e-02f, 5.30156903e-02f, -3.54774669e-02f, 6.74468791e-03f, -3.05940900e-02f, 7.48133138e-02f, -2.43159477e-03f, -3.49149927e-02f, -4.55429330e-02f, 1.78770218e-02f,
  -6.17763624e-02f, 6.18508533e-02f, 2.84737186e-03f, 1.66258067e-02f, -8.51965249e-02f, 1.11116394e-02f, 2.57141553e-02f, -2.09015142e-02f, -8.29180330e-03f, -6.10843711e-02f,
  4.63601016e-02f, -4.06501256e-02f, -2.63947491e-02f, 7.36794695e-02f, 5.64634614e-02f, 3.61976363e-02f, -3.03160381e-02f, 2.94158403e-02f, -1.55586256e-02f, -2.57903729e-02f,
  -5.65514117e-02f, -1.34527693e-02f, 6.48088157e-02f, 4.22874689e-02f, 4.03697155e-02f, 2.55488344e-02f, 1.04953572e-02f, 1.12601802e-01f, 8.98488052e-03f, 3.89414951e-02f,
  2.20661759e-02f, -9.28736702e-02f, -7.16915652e-02f, -1.23041525e-01f, -2.67528724e-02f, 7.57452399e-02f, 3.99787873e-02f, 2.30151452e-02f, 3.19177173e-02f, -5.56531250e-02f,
  -8.39582365e-03f, -7.76591897e-02f, 3.21403728e-03f, -9.70633142e-03f, -1.05304569e-01f, -1.00290701e-01f, -8.62813648e-03f, 9.57660377e-03f, -1.08121313e-01f, -5.61295301e-02f,
  -7.50246197e-02f, -1.79327145e-01f, -9.67527553e-02f, -9.38863903e-02f, -1.14222050e-01f, -1.84410363e-01f, -3.31624784e-02f, -1.36845589e-01f, -2.41165414e-01f, -2.38393873e-01f,
  5.08163035e-01f, -2.92517662e-01f, -2.09986400e-02f, 2.18300641e-01f, -9.12768692e-02f, 5.88176474e-02f, 3.91096696e-02f, 9.92470160e-02f, 8.77378210e-02f, 5.30661643e-02f,
  -6.70052618e-02f, 3.22525352e-02f, 1.40862921e-02f, -8.69787931e-02f, 1.16233923e-01f, 6.84901550e-02f, -8.20914060e-02f, 9.61110443e-02f, 1.79264918e-01f, -3.25920060e-02f,
  -1.27250239e-01f, 7.76428282e-02f, 8.53321031e-02f, 4.85254154e-02f, -1.89854011e-01f, -1.10858507e-01f, -7.27497637e-02f, -5.07079475e-02f, -1.76929489e-01f, -3.25165451e-01f,
  -2.48646066e-01f, -9.40636322e-02f, 3.63306142e-02f, -6.14174642e-02f, -1.13858491e-01f, 4.49353084e-02f, -8.80987272e-02f, -1.95611757e-03f, -2.68364847e-02f, 1.62250083e-02f,
  -4.88999858e-02f, -9.53344554e-02f, -7.69445300e-02f, -8.28382149e-02f, -1.63170114e-01f, -9.69134346e-02f, -1.42755851e-01f, 1.27983419e-02f, 3.61970142e-02f, -5.13223521e-02f,
  -1.16919883e-01f, -5.97311743e-02f, 6.33638799e-02f, -7.93709308e-02f, -1.03958309e-01f, -6.56488314e-02f, -1.70061544e-01f, -6.67726770e-02f, -1.50137082e-01f, -1.81575745e-01f,
  -1.12205660e-02f, -6.29377877e-03f, -7.18447194e-02f, 8.76038522e-02f, 1.11628711e-01f, 8.44818950e-02f, 9.09080803e-02f, -3.25083248e-02f, 5.99726886e-02f, 2.86961459e-02f,
  8.10652375e-02f, -1.91442259e-02f, -1.04956068e-02f, 7.08613917e-02f, 1.98679511e-02f, -3.41715030e-02f, 2.44778786e-02f, -6.66371211e-02f, -5.92005961e-02f, -3.63610163e-02f,
  1.22425295e-02f, 3.81168164e-02f, 5.73813682e-04f, -1.35276183e-01f, 3.67269740e-02f, -1.29555003e-03f, -5.02497219e-02f, 7.06948480e-03f, 8.61699805e-02f, 1.17025107e-01f,
  -3.67678404e-02f, 7.99558312e-03f, -7.45681929e-04f, -1.27836391e-01f, -9.88423675e-02f, 1.99534222e-02f, -1.68187469e-01f, -2.67119277e-02f, -1.07600778e-01f, -1.21316509e-02f,
  -9.32895485e-03f, 5.57420328e-02f, 3.51512209e-02f, -9.55110416e-02f, -2.85112462e-03f, -1.84965543e-02f, -7.80052245e-02f, 2.10917294e-02f, -4.48003337e-02f, -1.29320696e-01f,
  -8.67334008e-03f, 1.20490365e-01f, 6.90320432e-02f, -8.00395384e-02f, -2.82390658e-02f, 4.79607582e-02f, -4.68153879e-02f, -4.38904427e-02f, 1.33443207e-01f, 1.33783951e-01f,
  -5.14323175e-01f, -1.94179386e-01f, 2.39387423e-01f, -3.51597257e-02f, -5.72906584e-02f, 3.74087170e-02f, -3.29522789e-02f, 5.94795030e-03f, 8.85336921e-02f, -7.19262511e-02f,
  8.82627591e-02f, 1.04552612e-01f, 1.63400561e-01f, 1.09337822e-01f, 9.66029689e-02f, 2.31390316e-02f, -1.17727056e-01f, 1.29141256e-01f, 3.05967033e-01f, 6.77804053e-02f,
  -8.30170587e-02f, -1.41459659e-01f, -1.24100707e-01f, 1.57328263e-01f, -1.63199037e-01f, 7.01480135e-02f, -5.78632653e-02f, -1.79910585e-01f, -4.55571190e-02f, -2.94915706e-01f,
  1.32081062e-01f, -1.33102471e-02f, 2.46200562e-01f, 6.67268783e-02f, 5.02233580e-02f, 4.45406400e-02f, 5.73727526e-02f, 1.82370737e-01f, 1.29061013e-01f, 9.35387313e-02f,
  -3.99195477e-02f, 1.22271068e-01f, -8.14491138e-03f, 5.35400063e-02f, 2.96123512e-03f, 5.71322776e-02f, 7.07234209e-03f, 1.04746997e-01f, 1.31942809e-01f, 4.49784063e-02f,
  5.09847440e-02f, -1.25343427e-01f, -4.73086052e-02f, 1.26789615e-01f, 8.00689086e-02f, 6.74633682e-02f, 2.21578855e-04f, 1.19324047e-02f, 1.89355984e-01f, -1.10303760e-01f,
  6.33343160e-02f, 1.35710584e-02f, 6.91009536e-02f, -1.30038947e-01f, -1.36101916e-01f, 3.74536030e-02f, -8.20776820e-02f, -4.25165668e-02f, 6.44030422e-02f, -6.00981861e-02f,
  6.34495020e-02f, 3.26162390e-02f, -7.55568966e-03f, 3.33694927e-02f, 2.44042594e-02f, -5.58617972e-02f, -2.08616629e-02f, -7.60891512e-02f, -2.57711653e-02f, -7.99411088e-02f,
  -4.07680236e-02f, 8.91749188e-02f, -6.43133894e-02f, 1.63567718e-02f, -3.69336680e-02f, -2.60939244e-02f, 1.37978146e-04f, 6.77536502e-02f, -7.19125345e-02f, -3.78732644e-02f,
  1.29660264e-01f, 1.95204467e-01f, 5.84528930e-02f, 5.32811582e-02f, 9.65866223e-02f, 1.76330552e-01f, 1.11324349e-02f, 6.20622858e-02f, 5.23159467e-02f, -2.11163573e-02f,
  4.86804023e-02f, 7.47682080e-02f, -2.71651894e-02f, 7.80310705e-02f, 5.05400822e-02f, 9.68125165e-02f, 8.16601887e-02f, 2.16260329e-02f, 5.74985221e-02f, 4.78163138e-02f,
  -5.15093580e-02f, 1.39976233e-01f, 9.42865983e-02f, 1.23189263e-01f, 1.04201563e-01f, 6.65863454e-02f, 9.51988325e-02f, 1.66550860e-01f, 1.78621888e-01f, 7.62169063e-02f,
  -4.51278716e-01f, -2.43216738e-01f, 4.23525959e-01f, -9.47875604e-02f, 9.65350047e-02f, 1.03632994e-01f, 2.13437825e-02f, -1.12762004e-01f, -2.19698429e-01f, -2.43070051e-02f,
  -8.84922817e-02f, -1.68851689e-02f, -3.76105979e-02f, 1.55264765e-01f, 9.61538330e-02f, 6.73687980e-02f, 2.40454704e-01f, 3.06097776e-01f, 3.36426318e-01f, 1.69334665e-01f,
  3.48314345e-02f, -1.07838556e-01f, -2.03938469e-01f, -1.48589816e-03f, -3.03314719e-02f, 1.03309102e-01f, -4.77384180e-02f, -1.49351403e-01f, 6.52176747e-03f, 4.44784854e-03f,
  1.39393240e-01f, -2.71408528e-01f, 2.64329642e-01f, 3.12790871e-02f, 2.00299874e-01f, -3.51346731e-02f, 1.72379479e-01f, 8.15018117e-02f, 5.28509170e-02f, -5.06565645e-02f,
  4.11799736e-02f, 7.81486630e-02f, 1.31121129e-01f, 6.90963566e-02f, -1.68796536e-02f, 1.15305997e-01f, -3.24926004e-02f, 2.41630282e-02f, 1.32587358e-01f, -2.79572364e-02f,
  7.63499960e-02f, -7.38979690e-03f, 1.36810422e-01f, 1.42562285e-01f, 7.24272132e-02f, 9.32611227e-02f, 4.97592874e-02f, 6.92668334e-02f, -1.53725687e-02f, -7.04446211e-02f,
  -5.04259951e-02f, -2.83735283e-02f, 2.70113088e-02f, -5.41212820e-02f, -3.10304910e-02f, -5.31930197e-03f, -3.69938253e-03f, -6.68862164e-02f, 3.36275026e-02f, -4.03048322e-02f,
  -1.07531575e-02f, 3.01118288e-03f, -2.63685975e-02f, 1.68067229e-04f, -4.45914082e-02f, 1.80701111e-02f, -1.28101772e-02f, -5.52098490e-02f, -3.45730670e-02f, -2.39567012e-02f,
  1.98466033e-02f, 1.02700191e-02f, -1.86143331e-02f, -2.66662147e-02f, -5.66708967e-02f, 8.57611839e-03f, -6.75011948e-02f, -2.79454831e-02f, -5.58896884e-02f, 2.81990226e-02f,
  -1.70740694e-01f, 6.38230294e-02f, -2.48568710e-02f, 5.72190061e-02f, 6.28532395e-02f, 8.69686306e-02f, -3.05473525e-02f, 1.81641113e-02f, 2.95799561e-02f, 3.91432829e-02f,
  6.68634847e-02f, 5.16344458e-02f, -6.46466613e-02f, 4.84317802e-02f, -1.36347776e-02f, 7.19738677e-02f, 1.76321808e-03f, 9.69398543e-02f, 2.39176098e-02f, 2.76501980e-02f,
  7.47222155e-02f, 9.58882719e-02f, 9.27273557e-02f, 1.56273693e-01f, 1.19573222e-02f, 1.58185139e-01f, 5.05296774e-02f, 9.57992673e-02f, 3.36756483e-02f, -8.62899944e-02f,
  -2.85186321e-01f, -2.36142278e-01f, -4.67930362e-02f, 1.03521608e-01f, 7.79547766e-02f, 3.94848622e-02f, -3.45441788e-01f, -8.12738612e-02f, 3.17023806e-02f, -1.48241997e-01f,
  1.51479870e-01f, 2.90302038e-01f, 1.16902746e-01f, 1.31265596e-01f, -1.24380738e-02f, -2.04139605e-01f, -2.71256894e-01f, 6.10783324e-02f, 1.58286080e-01f, 1.76250026e-01f,
  2.91855894e-02f, -4.95146960e-02f, 1.24375872e-01f, 7.35414550e-02f, -1.03099011e-01f, 7.15144724e-02f, -9.45190787e-02f, 1.85394809e-02f, -1.02429688e-01f, -2.09914058e-01f,
  -9.63259265e-02f, -4.58140261e-02f, 2.49411702e-01f, 8.23579729e-02f, 1.69555530e-01f, -6.15822338e-03f, 1.18128680e-01f, 4.50531468e-02f, 1.56352192e-01f, 5.81232645e-02f,
  1.24065757e-01f, 2.83444766e-02f, 1.53050140e-01f, 1.38233334e-01f, 2.50416920e-02f, 9.08488259e-02f, 4.53487635e-02f, 5.14134811e-03f, 8.10865536e-02f, 2.85300170e-03f,
  4.60548960e-02f, 6.52014241e-02f, 6.83879629e-02f, 6.47896677e-02f, 5.18731633e-03f, 9.83277783e-02f, 1.02132760e-01f, 4.25366759e-02f, -2.48677544e-02f, -1.06769636e-01f,
  6.73346221e-02f, 3.27277258e-02f, -2.05993354e-02f, 5.88700324e-02f, 1.84171367e-02f, 9.26130936e-02f, 6.59531206e-02f, 2.55886987e-02f, -4.31490131e-02f, 1.85120646e-02f,
  3.57005075e-02f, 2.02142857e-02f, 9.94464755e-02f, -3.04837618e-02f, 3.44090462e-02f, -1.12666547e-01f, -6.80395290e-02f, -3.02641187e-02f, 1.25838429e-01f, 3.82121615e-02f,
  -2.16864771e-03f, 2.23522931e-02f, -4.84856078e-03f, 3.90820429e-02f, -6.46037683e-02f, 2.06662081e-02f, -1.04017273e-01f, -4.58890237e-02f, -1.86198726e-02f, -1.22345313e-01f,
  4.75050658e-02f, 2.71569043e-01f, -5.87347373e-02f, 5.77544048e-02f, -2.21584737e-02f, 4.33342271e-02f, 7.77687803e-02f, 5.37608489e-02f, 1.64125472e-01f, 3.86412139e-03f,
  -8.69883411e-03f, -9.86492168e-03f, 1.28021999e-03f, 9.10618752e-02f, 1.02977855e-02f, 8.53672549e-02f, 2.46269722e-02f, -4.18047607e-02f, 3.47558111e-02f, 7.23874420e-02f,
  4.30245511e-02f, -4.27767448e-02f, 9.89337713e-02f, 1.72340795e-02f, 6.85284957e-02f, 6.12242967e-02f, -1.16580546e-01f, -1.60268899e-02f, -1.87779386e-02f, -3.34495544e-01f,
  -2.40781859e-01f, 3.22307765e-01f, -9.69205424e-02f, -7.39461109e-02f, 2.43691385e-01f, 1.70085758e-01f, 2.51268446e-01f, 2.52934843e-01f, 1.54639944e-01f, 2.00202256e-01f,
  2.80634701e-01f, 1.88217431e-01f, 1.12132393e-01f, 2.12895013e-02f, -1.02716960e-01f, -7.01545551e-03f, -5.87180331e-02f, -2.37309799e-01f, -1.85714334e-01f, 8.49905536e-02f,
  2.32722551e-01f, 2.68800389e-02f, -1.34717256e-01f, 3.31024937e-02f, 1.58963725e-01f, 1.18250832e-01f, 2.96362452e-02f, 1.91810384e-01f, 2.10327595e-01f, 1.24400124e-01f,
  -7.43502527e-02f, 1.59902662e-01f, 6.56073615e-02f, 7.62557909e-02f, 9.75564197e-02f, 8.11365917e-02f, 1.15381442e-01f, 1.79643989e-01f, 9.91027951e-02f, 8.79422650e-02f,
  1.26451924e-01f, 1.77665904e-01f, 3.97615023e-02f, 1.19210854e-01f, 1.12683550e-01f, 1.15984967e-02f, -1.98953990e-02f, 6.30719634e-03f, 3.33909169e-02f, 1.77530378e-01f,
  2.28897661e-01f, 1.38264060e-01f, 6.93298131e-02f, 1.26525953e-01f, 2.79843695e-02f, 1.28842771e-01f, 1.10982768e-01f, 1.21791877e-01f, 5.69467619e-02f, 1.02897480e-01f,
  3.75049934e-02f, -6.67516813e-02f, -2.32957043e-02f, -1.02872401e-02f, -8.46787095e-02f, -4.07801941e-03f, -2.18627583e-02f, -4.20106836e-02f, 7.71407387e-04f, -6.77164495e-02f,
  8.96188710e-03f, 3.66179943e-02f, -5.11585250e-02f, 4.73546097e-03f, -1.46355443e-02f, 2.29526442e-02f, 2.13936698e-02f, -6.58200160e-02f, -7.57636176e-03f, 5.78125045e-02f,
  -4.95454744e-02f, 3.35366651e-02f, -1.11150397e-02f, 2.29332857e-02f, -4.63126563e-02f, -4.69495319e-02f, -1.44452173e-02f, 5.87796308e-02f, -6.89731911e-02f, -4.65907305e-02f,
  -2.26732835e-01f, -1.58853959e-02f, -1.07389698e-02f, 2.58018565e-03f, 3.06803398e-02f, 7.89844766e-02f, 4.54473570e-02f, 8.64568278e-02f, 1.83967888e-01f, 1.07886389e-01f,
  1.96863174e-01f, 4.98723947e-02f, 7.76697993e-02f, 3.37776616e-02f, 4.87418883e-02f, 8.85382816e-02f, 7.88277313e-02f, -3.97457220e-02f, 4.45397943e-02f, 5.07422127e-02f,
  5.04384600e-02f, -3.27740684e-02f, 7.41671845e-02f, 5.81511557e-02f, 1.47440210e-01f, 6.90314621e-02f, 2.43578833e-02f, 1.08649105e-01f, -5.76636605e-02f, 4.84826751e-02f,
  2.28520796e-01f, -4.55308370e-02f, -4.80863363e-01f, 5.99089637e-02f, -1.82462364e-01f, -1.27283052e-01f, -1.36758178e-01f, 7.95001611e-02f, 1.44932285e-01f, -4.51858006e-02f,
  9.72919632e-03f, 2.86633074e-01f, 1.98197395e-01f, 6.65833950e-02f, 7.45792985e-02f, -2.12631285e-01f, -3.05753976e-01f, -1.60407528e-01f, -1.44900437e-02f, -6.55125156e-02f,
  6.52207620e-03f, -3.83933336e-02f, 6.29853681e-02f, 1.53161302e-01f, -8.47542882e-02f, 5.14617898e-02f, -1.08484872e-01f, -6.98352903e-02f, -7.87246823e-02f, -2.48716325e-01f,
  -8.62588808e-02f, -1.53647065e-01f, -6.65969774e-02f, -3.11480556e-02f, -1.61055818e-01f, -9.34003107e-03f, -4.48247567e-02f, -1.25920162e-01f, 1.05452221e-02f, -8.53238180e-02f,
  -1.34478897e-01f, -2.14908384e-02f, -1.78063940e-02f, -1.12480178e-01f, -9.75437090e-02f, -8.81009549e-02f, -1.24288745e-01f, -8.73225480e-02f, -4.39915173e-02f, -1.59731433e-01f,
  -1.05746619e-01f, -1.60743862e-01f, -1.17379673e-01f, -1.29756525e-01f, -4.96583544e-02f, -1.62781313e-01f, -9.39204544e-02f, -2.02985853e-01f, -1.72513630e-02f, -8.87262169e-03f,
  3.80981304e-02f, -2.06675548e-02f, -2.02523302e-02f, 6.78112581e-02f, 3.71062011e-02f, 5.77289909e-02f, 5.23685403e-02f, 2.83328891e-02f, 3.86701315e-03f, 7.64613375e-02f,
  7.61406645e-02f, 2.09698407e-03f, -2.16864818e-03f, 3.56316427e-03f, 6.61035329e-02f, 3.59334843e-03f, -5.65048680e-02f, 5.66135272e-02f, -5.92023507e-02f, 2.65959781e-02f,
  2.12035086e-02f, 2.48499792e-02f, -6.07522018e-02f, -1.11367402e-03f, -1.06798492e-01f, -8.68693069e-02f, -4.30926196e-02f, 3.31673548e-02f, -3.61485556e-02f, -2.00119074e-02f,
  3.52807999e-01f, -1.84604913e-01f, -7.10344687e-02f, 4.11474481e-02f, -7.25226030e-02f, -3.37480828e-02f, -3.18207368e-02f, -1.40371531e-01f, -1.03638783e-01f, 1.90267544e-02f,
  -1.13646366e-01f, -1.02992371e-01f, -1.30537674e-01f, -7.85411447e-02f, -9.21973437e-02f, -1.34789929e-01f, 1.30044261e-03f, -4.97492328e-02f, -8.68047215e-03f, -1.12177998e-01f,
  -4.08756770e-02f, -6.06838018e-02f, 1.54776387e-02f, 3.99953797e-02f, -5.37054427e-02f, -2.19040513e-02f, -5.83449975e-02f, -7.42679685e-02f, -6.68397546e-02f, -2.23984979e-02f,
  -9.37699452e-02f, -2.80735642e-01f, 3.11795413e-01f, -1.32551685e-01f, 7.75197595e-02f, 2.51028299e-01f, 1.62889227e-01f, 9.81691405e-02f, -1.59494787e-01f, -7.47856349e-02f,
  -2.27200035e-02f, 1.39336949e-02f, -2.32300553e-02f, -3.32151763e-02f, 9.45956036e-02f, -2.84498818e-02f, 1.79002993e-03f, 3.50633234e-01f, 5.32960057e-01f, 9.18074548e-02f,
  -5.55107668e-02f, -1.09035276e-01f, 7.59713799e-02f, -1.02903843e-02f, -8.90147164e-02f, 1.32815197e-01f, -4.94523160e-02f, 1.08690383e-02f, 3.40064056e-02f, -1.51315242e-01f,
  1.83284745e-01f, 3.80257554e-02f, 7.15326145e-02f, -7.47184968e-03f, 4.38677631e-02f, 5.13256353e-04f, 2.94770543e-02f, -8.72079954e-02f, -2.05888022e-02f, -2.06646770e-02f,
  -3.61283682e-02f, -4.57683839e-02f, 7.95360282e-02f, -1.70639548e-02f, 8.47943872e-02f, 7.48964697e-02f, 1.52552314e-02f, -3.00340410e-02f, -1.75925959e-02f, 1.74558256e-02f,
  -6.03776537e-02f, 9.78712142e-02f, 7.31124431e-02f, 4.75258790e-02f, 1.23032019e-01f, 1.04848757e-01f, 8.13158229e-02f, -1.01436175e-01f, 1.06025353e-01f, -1.98600888e-01f,
  -1.72133781e-02f, -2.97227614e-02f, 5.30388318e-02f, -3.16854119e-02f, -3.63288224e-02f, -3.00034396e-02f, -1.18778944e-02f, 4.70838882e-03f, -7.59120984e-03f, -4.15445864e-02f,
  -5.36399782e-02f, -3.22394855e-02f, 1.74894817e-02f, -4.26606052e-02f, -9.80008580e-03f, 1.16105758e-01f, 4.05177586e-02f, -6.52452856e-02f, -5.76010905e-02f, 4.98111360e-02f,
  -2.63200011e-02f, 2.24732421e-03f, 1.25561226e-02f, 3.08003183e-02f, -1.58082880e-02f, 2.62796637e-02f, 5.09911962e-02f, -2.23635067e-03f, -8.81695896e-02f, 2.21349038e-02f,
  -1.90240115e-01f, 2.85625845e-01f, -9.00771245e-02f, -7.91510344e-02f, 1.49160653e-01f, -8.45927149e-02f, -5.07156737e-02f, -1.31795630e-02f, -8.70086104e-02f, -8.61671939e-02f,
  8.41393620e-02f, 3.14726979e-02f, -2.22874526e-03f, -2.52726413e-02f, -4.43476671e-03f, -6.23725280e-02f, -1.03063017e-01f, 6.20199479e-02f, -6.05913289e-02f, 4.19431217e-02f,
  -2.19635982e-02f, 8.59223679e-02f, 1.39825255e-01f, 6.16896600e-02f, 4.73883413e-02f, 1.59301355e-01f, 1.09913170e-01f, 1.54984459e-01f, 2.50947803e-01f, 7.29700923e-02f,
  4.64991719e-01f, -2.94487059e-01f, 3.19432557e-01f, 3.57850641e-01f, 4.00034897e-02f, -1.05227418e-01f, -1.70709774e-01f, 9.25551448e-03f, 5.36398366e-02f, 1.46863520e-01f,
  -1.19232424e-01f, -2.61446349e-02f, -1.51256062e-02f, 1.04017109e-02f, 1.61705658e-01f, 8.33458379e-02f, 1.82675272e-01f, 3.60468477e-01f, 6.52047843e-02f, -7.30167404e-02f,
  -1.13986947e-01f, 1.24736942e-01f, 1.33437052e-01f, -2.73482054e-02f, 4.22294177e-02f, -4.29129787e-02f, -3.65624651e-02f, 9.50473323e-02f, -1.66535288e-01f, 2.31737748e-01f,
  1.75786197e-01f, 2.16961920e-01f, 7.33895823e-02f, 5.00882305e-02f, 5.60095794e-02f, 5.83999939e-02f, 5.42987883e-02f, 8.37072432e-02f, 4.86527570e-02f, 2.74577439e-02f,
  6.56083971e-02f, 7.90024251e-02f, 1.49807632e-01f, 9.66163632e-03f, 1.15063734e-01f, 1.04951702e-01f, 5.79360761e-02f, 1.86641484e-01f, 1.54761195e-01f, -4.15040180e-02f,
  -2.54455097e-02f, 3.03303432e-02f, 5.03732972e-02f, 6.96551427e-03f, 3.93497460e-02f, 1.28028885e-01f, -4.08910140e-02f, 8.10198858e-02f, 4.83693182e-02f, -2.77527496e-02f,
  -1.22599043e-01f, -7.09898174e-02f, -5.01411706e-02f, -1.03906110e-01f, -3.20515297e-02f, 2.76652891e-02f, 5.30155301e-02f, -1.05082154e-01f, -2.48006843e-02f, 1.76212583e-02f,
  -3.56586203e-02f, 4.31734584e-02f, -1.28824739e-02f, 5.93779162e-02f, 2.90511902e-02f, -2.32301988e-02f, -4.98864800e-02f, 8.53593741e-03f, 3.33061256e-02f, 4.80882563e-02f,
  1.10066226e-02f, 4.84824628e-02f, 4.01756028e-03f, -5.98298833e-02f, -5.76067194e-02f, -4.44552563e-02f, -6.52800500e-02f, -6.63632825e-02f, 5.50997406e-02f, -5.77095933e-02f,
  8.30167755e-02f, 5.64834811e-02f, 1.36760026e-01f, 1.12685680e-01f, 6.62529841e-02f, 3.93936075e-02f, 5.92315346e-02f, -3.31752785e-02f, 3.98885459e-02f, 6.41341209e-02f,
  7.71583393e-02f, 1.70123801e-02f, 4.49747704e-02f, 2.18692999e-02f, 7.31937438e-02f, 1.07301302e-01f, 2.81822286e-03f, 5.28562348e-03f, -1.37940468e-02f, -2.91382838e-02f,
  1.68943498e-02f, -5.78462903e-04f, 7.49502555e-02f, 8.18249956e-02f, 6.11400492e-02f, 1.41889215e-01f, -2.22352222e-02f, 5.34082437e-03f, -1.25278849e-02f, 7.72488043e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.80366591e-01f, -4.98820096e-02f, -2.81614840e-01f, 1.98308583e-02f, 1.00789312e-02f, -1.38277665e-01f, -6.47046715e-02f, 8.57846886e-02f, 9.73613411e-02f, 1.22902855e-01f,
  2.16221195e-02f, 1.17936693e-01f, 1.65907383e-01f, 1.59256399e-01f, 6.77261949e-02f, 1.09018341e-01f, 8.45195651e-02f, 1.56430125e-01f, 5.01031540e-02f, 9.72048193e-02f,
  2.22337037e-01f, 1.32820383e-01f, -5.71615733e-02f, 1.41377181e-01f, 1.63414493e-01f, 2.79842317e-01f, 3.76716889e-02f, 1.17499210e-01f, 1.00053005e-01f, 2.86615789e-01f,
  -1.61058232e-02f, 1.76321045e-01f, 1.87815502e-01f, 1.16677091e-01f, -1.53099701e-01f, 3.16536725e-02f, -2.80790608e-02f, -1.63574353e-01f, -1.26777589e-01f, -6.36874959e-02f,
  -9.11819339e-02f, 2.45848224e-02f, 7.93992803e-02f, -3.07494518e-03f, -3.17653790e-02f, -7.33190253e-02f, 9.15934518e-02f, 8.63750055e-02f, 9.58522335e-02f, -9.54265296e-02f,
  2.16059759e-01f, -1.02589056e-01f, -1.66849032e-01f, -1.64897926e-02f, 9.43152010e-02f, 1.27520472e-01f, -1.30750760e-01f, 1.11995399e-01f, -6.81147650e-02f, 1.61755413e-01f,
  1.68861419e-01f, -2.72225421e-02f, -2.91935243e-02f, 1.28434703e-01f, 2.97938406e-01f, 1.40755549e-01f, 3.15428562e-02f, 1.34618312e-01f, 1.53478831e-01f, 1.24311224e-01f,
  -4.72345762e-03f, -2.65770517e-02f, -1.18406832e-01f, -2.76059415e-02f, 1.00019043e-02f, -3.42049077e-02f, -1.20525546e-01f, -9.42896158e-02f, -1.00227267e-01f, -1.18440740e-01f,
  2.31487304e-02f, -7.08305016e-02f, -7.27465674e-02f, -3.19454335e-02f, -2.27853190e-02f, 4.08356525e-02f, -5.39114233e-03f, -6.59065694e-02f, -1.14600966e-02f, 3.14077511e-02f,
  -4.62805629e-01f, -6.74101263e-02f, 3.05181950e-01f, 1.28294364e-01f, 5.61181642e-03f, -1.24836743e-01f, 6.13125525e-02f, -8.57920945e-02f, -1.46166131e-01f, -9.98433605e-02f,
  -2.06719697e-01f, 2.97054760e-02f, -2.49278098e-02f, -2.01608799e-02f, -8.16576183e-03f, -2.50783395e-02f, -3.79673317e-02f, 5.95024526e-02f, -4.70813476e-02f, -2.07517117e-01f,
  -1.17422722e-01f, -2.24849820e-01f, -1.01054952e-01f, -1.33801550e-01f, 9.99310687e-02f, -2.29236744e-02f, -1.83805287e-01f, -1.42077088e-01f, -1.25084281e-01f, -1.05710246e-01f,
  -9.11088437e-02f, 1.68565586e-01f, 3.61603126e-02f, 1.42947480e-01f, 3.72308880e-01f, 8.20048898e-02f, -1.46664038e-01f, -3.07132900e-01f, 6.99635074e-02f, -2.07712334e-02f,
  2.80065000e-01f, 1.60966620e-01f, -1.04111647e-02f, -1.20053105e-01f, -4.87297475e-01f, -2.83658296e-01f, -2.77117729e-01f, -4.60366696e-01f, -4.88566041e-01f, -1.82505444e-01f,
  8.74534771e-02f, -1.01491764e-01f, -2.96711355e-01f, -1.30659699e-01f, 2.35397115e-01f, -2.83046276e-03f, -4.06545065e-02f, 1.01878762e-01f, 1.26013160e-01f, 2.85159528e-01f,
  2.27200061e-01f, 2.06606820e-01f, -3.19321230e-02f, 8.80916566e-02f, 9.72917974e-02f, -1.29155040e-01f, 5.76860085e-03f, -2.08916962e-02f, 8.72970596e-02f, 6.04927633e-03f,
  3.51419777e-01f, 9.68144313e-02f, 1.25812128e-01f, -1.21707153e-02f, -1.76964507e-01f, -2.51062155e-01f, -2.42836192e-01f, -2.11751148e-01f, -2.20297500e-01f, -3.56504172e-02f,
  -1.32079311e-02f, 2.54479140e-01f, -1.07143164e-01f, -1.19750902e-01f, -2.38096416e-01f, 4.92644869e-02f, 3.66150849e-02f, 2.62641404e-02f, -2.16382086e-01f, -1.57727227e-01f,
  -8.12864751e-02f, -2.33224053e-02f, 1.44588247e-01f, 8.39693397e-02f, 4.31275815e-02f, 1.31817749e-02f, -2.06997469e-02f, -5.74249253e-02f, -5.62570766e-02f, -6.33097813e-02f,
  -6.07799925e-02f, 2.45056339e-02f, -8.32717679e-03f, -5.28850295e-02f, -8.71504247e-02f, 5.50325215e-02f, -3.74906175e-02f, -1.58795267e-01f, -1.03587218e-01f, -4.28372286e-02f,
  -1.65783778e-01f, 6.54895753e-02f, 1.57193080e-01f, -3.65471728e-02f, 7.18968287e-02f, -3.07102241e-02f, 3.00477482e-02f, -1.29854549e-02f, -4.11903672e-02f, -8.00514445e-02f,
  -2.89938189e-02f, -5.19248359e-02f, -1.00727640e-02f, 6.40047994e-03f, 7.14901648e-03f, 4.08324338e-02f, 1.12246618e-01f, 3.67388315e-02f, 1.06147952e-01f, -2.35491902e-01f,
  -8.03035032e-03f, -9.31841284e-02f, -1.98224522e-02f, -4.29882370e-02f, -1.18264154e-01f, -1.54024567e-02f, -1.63326442e-01f, -3.54559869e-02f, -1.53549314e-01f, 1.43365845e-01f,
  -3.04994136e-02f, -1.44668877e-01f, -6.84588328e-02f, -1.52127789e-02f, 7.19833076e-02f, -6.04597442e-02f, -1.78067669e-01f, -2.00049534e-01f, -2.88082540e-01f, -2.86421657e-01f,
  5.20538449e-01f, 8.74133855e-02f, 2.06296697e-01f, 1.28207088e-01f, -1.99914292e-01f, -1.94946244e-01f, -3.61720592e-01f, -8.59951451e-02f, 7.09631369e-02f, -2.98610646e-02f,
  -9.71880630e-02f, 1.04189798e-01f, 7.32106864e-02f, 1.40857235e-01f, 9.29481313e-02f, 7.46927485e-02f, -9.58099321e-04f, 2.98199594e-01f, 3.82522084e-02f, -6.67146295e-02f,
  -6.64387718e-02f, -3.08596808e-02f, -4.41653170e-02f, 1.19288437e-01f, 7.30072334e-02f, 1.03872284e-01f, 1.21612353e-02f, -7.27607682e-02f, -8.25735256e-02f, 2.90144265e-01f,
  2.15535119e-01f, 1.56455010e-01f, 2.09160492e-01f, 2.11156473e-01f, 4.40128110e-02f, 2.28998765e-01f, 5.91413826e-02f, 4.71696369e-02f, 4.35709842e-02f, -7.06888512e-02f,
  -2.37178829e-04f, -5.02828397e-02f, -5.44047579e-02f, -1.24032810e-01f, -1.30708158e-01f, 2.51202956e-02f, -1.13047197e-01f, 7.87700899e-03f, 1.04537584e-01f, 6.28146529e-02f,
  -6.83398172e-02f, -1.88909069e-01f, -2.14940667e-01f, -1.06726676e-01f, -4.38429303e-02f, 3.37971449e-02f, -5.08494638e-02f, -4.63783704e-02f, -2.60819383e-02f, -8.73919725e-02f,
  4.09485139e-02f, -3.21071036e-02f, 5.83520345e-02f, -5.59268594e-02f, -1.08207881e-01f, -1.60467356e-01f, -9.82686430e-02f, -8.92506987e-02f, -8.14824924e-03f, -1.74984321e-01f,
  -1.26787022e-01f, -4.39650528e-02f, 8.76805857e-02f, -2.42192503e-02f, 1.33486912e-01f, -2.76556276e-02f, -7.81329870e-02f, 1.32235989e-01f, -8.55872259e-02f, -6.02347702e-02f,
  -6.26872554e-02f, 1.94137264e-03f, -7.07702562e-02f, -1.81129687e-02f, 5.95682710e-02f, -1.82782002e-02f, -5.59741817e-02f, 6.99387714e-02f, -3.29650231e-02f, -4.63828668e-02f,
  -1.01177417e-01f, 7.88806677e-02f, 2.45165825e-01f, 2.35597476e-01f, 1.38226468e-02f, 5.85598052e-02f, 1.46905527e-01f, 5.83455758e-03f, 1.38249531e-01f, 1.54734384e-02f,
  1.19832046e-01f, 1.47149861e-01f, 5.97379692e-02f, 3.35944295e-02f, -1.08851425e-01f, -1.79961659e-02f, 1.37928888e-01f, 1.72840357e-01f, 2.04811335e-01f, 8.01478624e-02f,
  -5.59865460e-02f, 4.30861302e-02f, -3.20368707e-02f, 8.04008096e-02f, 4.58332375e-02f, 1.39633954e-01f, 1.01387007e-02f, 3.34149646e-03f, -8.39071050e-02f, -1.54828012e-01f,
  -8.86695325e-01f, -1.56668529e-01f, -3.15353870e-01f, -2.05858812e-01f, 2.02507764e-01f, 2.23050475e-01f, 3.97457033e-01f, 1.04760498e-01f, -2.24069431e-02f, 7.89795257e-03f,
  2.47586910e-02f, -7.07028583e-02f, -8.81395489e-02f, 7.48185366e-02f, 1.76517025e-01f, 1.90488741e-01f, 2.38500640e-01f, 6.35575922e-03f, 1.68120429e-01f, 3.00464004e-01f,
  2.34029159e-01f, -1.06812254e-01f, -2.28394985e-01f, -2.30565351e-02f, -5.71604855e-02f, 6.20735530e-03f, -9.01811942e-02f, -1.86167806e-01f, 1.17450252e-01f, 1.58279583e-01f,
  -4.03885722e-01f, -2.28896543e-01f, 1.92190841e-01f, -9.79014263e-02f, -6.25383481e-02f, -1.88290961e-02f, 6.72969222e-02f, -1.87731400e-01f, 3.05549204e-02f, -4.72192578e-02f,
  -8.43659639e-02f, -3.09026316e-02f, -4.89219762e-02f, 4.58119810e-02f, -7.23185064e-03f, -1.04610564e-03f, -7.34133571e-02f, -1.85666934e-01f, -1.58726692e-01f, -1.22225963e-01f,
  1.79755583e-01f, 2.55892873e-02f, -2.96340495e-01f, 9.86921787e-02f, -9.49290395e-02f, -8.10253620e-02f, 1.63867790e-03f, -5.32349423e-02f, -1.70152724e-01f, -1.93967670e-01f,
  7.01823756e-02f, 1.47127500e-02f, 5.47387898e-02f, -3.46705271e-03f, -8.58352855e-02f, 9.32255015e-02f, -1.11411875e-02f, 7.63223991e-02f, 5.50320521e-02f, -6.53932467e-02f,
  1.82016771e-02f, 3.82738039e-02f, 1.03513010e-01f, -4.30128612e-02f, -7.90172722e-03f, -1.08504355e-01f, 5.35665639e-02f, 9.06448811e-02f, 3.14229317e-02f, 8.90776049e-03f,
  -1.14176884e-01f, -2.99985539e-02f, -7.75308311e-02f, 4.30088341e-02f, 8.46250951e-02f, -6.04023375e-02f, 3.82531583e-02f, 3.78760397e-02f, -1.23391606e-01f, -7.56825805e-02f,
  -2.83842534e-01f, 1.74436957e-01f, -1.44388855e-01f, -5.64322360e-02f, -8.63130845e-04f, -4.42164876e-02f, -3.61222923e-02f, 4.91513610e-02f, -3.52987088e-02f, 2.69529596e-02f,
  4.14639749e-02f, 1.14263214e-01f, -1.68441206e-01f, -9.18214582e-03f, 6.84178323e-02f, -3.36470976e-02f, 3.80693339e-02f, -1.57825164e-02f, 4.94933054e-02f, 7.16909096e-02f,
  -1.07857235e-01f, 2.73166895e-01f, -8.33177790e-02f, -3.83596346e-02f, -5.87713420e-02f, -9.50695053e-02f, -2.93071028e-02f, -1.12828784e-01f, -7.00294673e-02f, -1.91446751e-01f,
  -9.88824964e-02f, -1.54778153e-01f, -4.92607236e-01f, -3.53271306e-01f, -4.90343750e-01f, -1.83108002e-01f, -1.66631803e-01f, 7.28732266e-04f, -1.08557627e-01f, -2.63145745e-01f,
  2.47391947e-02f, 1.61379382e-01f, -3.94634791e-02f, -5.69456723e-03f, 2.06141829e-01f, -3.40931594e-01f, -3.57968777e-01f, -1.61242291e-01f, 2.45110780e-01f, 2.03483403e-01f,
  -8.31867605e-02f, -9.83399451e-02f, 7.39706755e-02f, -2.73019169e-02f, -2.05360427e-01f, 7.60921910e-02f, -2.71991432e-01f, -1.58854142e-01f, -1.76897913e-01f, -4.02314782e-01f,
  -7.03571439e-02f, -1.71262786e-01f, -8.97499993e-02f, 7.35304579e-02f, -1.88803837e-01f, -9.31883901e-02f, -1.13574348e-01f, -1.52830914e-01f, -6.31193221e-02f, -1.26592815e-01f,
  -1.21458136e-01f, 7.46294260e-02f, 7.41064772e-02f, 1.02925105e-02f, -3.75145748e-02f, 5.58301471e-02f, -6.30099922e-02f, 3.48376967e-02f, 4.57713678e-02f, -3.11674494e-02f,
  3.09068542e-02f, 6.78381771e-02f, 1.47851497e-01f, 5.19571751e-02f, -1.30833033e-02f, 7.13763833e-02f, 7.20647126e-02f, -8.71138349e-02f, 1.38928801e-01f, -9.56826881e-02f,
  -1.97880417e-02f, 3.45283821e-02f, -3.86239067e-02f, 1.05997078e-01f, 1.33080050e-01f, 5.20209083e-03f, 5.33122942e-02f, 8.50282013e-02f, 1.36897206e-01f, 6.09345287e-02f,
  -7.91134313e-02f, -1.13140933e-01f, -5.21561727e-02f, 2.76128743e-02f, -2.17805058e-02f, 1.63293295e-02f, -1.20646395e-02f, 4.67900420e-03f, -5.96170127e-03f, -9.52873230e-02f,
  -8.03559124e-02f, -1.12245968e-02f, -1.71441846e-02f, 6.22247159e-02f, -6.01388291e-02f, -9.13143829e-02f, -4.57075462e-02f, 1.15715198e-01f, -1.44354463e-01f, -6.77510276e-02f,
  2.15517372e-01f, -8.89842957e-02f, -7.78737292e-02f, 1.42648980e-01f, -6.58844188e-02f, -2.26057187e-01f, -1.50231510e-01f, -4.24377546e-02f, -8.54766928e-03f, 2.63342168e-02f,
  -5.88920303e-02f, 2.04599332e-02f, -1.26191992e-02f, -6.80114701e-02f, 7.22176209e-02f, -3.05850767e-02f, -1.21005736e-01f, 1.59691632e-01f, 9.82863829e-02f, -1.48088649e-01f,
  -2.33723130e-02f, 1.08517662e-01f, 2.04939291e-01f, 6.77335188e-02f, -2.49557272e-02f, 1.12316474e-01f, -1.35207567e-02f, 7.76840225e-02f, 9.32562798e-02f, -1.04376025e-01f,
  7.25307345e-01f, 2.78208196e-01f, 3.92445475e-02f, 1.18645340e-01f, -1.15477003e-01f, 3.25361677e-02f, -9.08295512e-02f, 1.05260704e-02f, 1.64254606e-01f, 1.54262647e-01f,
  3.72947097e-01f, 4.45105463e-01f, 3.61285806e-01f, 2.24029839e-01f, 2.22750753e-01f, -1.10847041e-01f, -1.12077177e-01f, 2.43462510e-02f, 2.12746754e-01f, 5.90276271e-02f,
  9.78202671e-02f, -5.49079143e-02f, 5.20467833e-02f, 7.96831772e-03f, -7.51581937e-02f, 1.20405525e-01f, -1.42621771e-01f, -2.84944266e-01f, -1.94409059e-03f, -5.26171587e-02f,
  -4.70511941e-03f, 1.68802738e-01f, 9.63504910e-02f, -9.64195132e-02f, -1.42491832e-01f, 2.06902251e-02f, 7.57370070e-02f, -1.68664008e-02f, -1.90565120e-02f, -1.48063570e-01f,
  -4.27770205e-02f, 4.22246661e-03f, -1.04156494e-01f, 2.51786839e-02f, -5.60927764e-02f, 3.80864777e-02f, 7.16421055e-03f, -1.46599468e-02f, 2.24030577e-02f, -9.91252623e-03f,
  -9.53075849e-03f, 9.31569859e-02f, 7.32327066e-03f, 4.31972966e-02f, 6.06609769e-02f, 1.04438305e-01f, -3.93280163e-02f, 2.97080278e-02f, 1.00941628e-01f, 1.48701459e-01f,
  4.22480442e-02f, 1.72264159e-01f, 1.57720193e-01f, 1.77993178e-01f, 4.64993566e-02f, 5.91618530e-02f, -7.09641129e-02f, 7.09816907e-03f, 7.51544237e-02f, -1.37701496e-01f,
  4.25209589e-02f, 1.80016235e-01f, 6.68708757e-02f, 7.66918287e-02f, 1.74894944e-01f, 1.90455049e-01f, -1.27277644e-02f, 3.43800858e-02f, 2.22257674e-02f, -8.06901604e-02f,
  -3.43683660e-02f, -1.68912932e-02f, -1.48306862e-02f, 6.47584870e-02f, -1.46745006e-02f, 2.03553498e-01f, 7.03166947e-02f, 9.68272313e-02f, 1.16836637e-01f, 3.24391983e-02f,
  -2.35409230e-01f, 2.34362811e-01f, 4.99625057e-02f, -3.33462916e-02f, -9.90954041e-02f, -1.48050129e-01f, 6.62732497e-02f, -7.56568611e-02f, -1.40379697e-01f, -1.42557975e-02f,
  -4.90895770e-02f, 9.93700232e-03f, -3.67976539e-02f, -1.34000704e-02f, -5.61320297e-02f, -5.33049516e-02f, -1.82807017e-02f, 1.21368960e-01f, 3.07696275e-02f, 1.31297493e-02f,
  9.19390991e-02f, 1.17511138e-01f, 5.88934012e-02f, 6.12112843e-02f, -8.93841460e-02f, 1.12787718e-02f, -4.35865931e-02f, -6.25807196e-02f, 2.25358699e-02f, 4.60817032e-02f,
  -1.35834724e-01f, 1.27985016e-01f, 2.27048829e-01f, -1.75449207e-01f, 3.47037688e-02f, -9.57785398e-02f, 5.77011928e-02f, -1.40447423e-01f, -4.84022833e-02f, 3.58256027e-02f,
  3.82201746e-02f, 4.31979448e-02f, 4.05244827e-02f, 1.37149513e-01f, 8.47916752e-02f, 2.42930397e-01f, 3.77534330e-01f, 9.04851034e-02f, -2.04914019e-01f, -1.72921970e-01f,
  1.89158674e-02f, 3.42588872e-02f, -1.09426528e-01f, -1.21931814e-01f, 1.91923276e-01f, -8.14141110e-02f, 7.39011988e-02f, -6.06294796e-02f, 4.00122330e-02f, 4.40977663e-01f,
  1.12092057e-02f, -1.09322108e-01f, -3.70684601e-02f, -8.25832188e-02f, 5.18285334e-02f, -2.96873879e-02f, -3.87524441e-03f, 2.09294736e-01f, 1.09589538e-02f, 4.62580100e-02f,
  1.07948288e-01f, 3.53088230e-03f, 1.34859949e-01f, -4.68872674e-02f, -2.95163631e-01f, -7.84559026e-02f, -6.07760847e-02f, 4.27538082e-02f, 4.23043370e-02f, -1.39109433e-01f,
  3.38618636e-01f, -1.10781848e-01f, -8.97689685e-02f, 1.53726377e-02f, -4.12528999e-02f, -1.41377389e-01f, -2.25579709e-01f, -1.16441615e-01f, -1.33823439e-01f, 2.47117635e-02f,
  -8.51161927e-02f, -1.28545955e-01f, 4.23070341e-02f, 8.74833390e-02f, 8.95420685e-02f, 1.17168859e-01f, 1.24719404e-01f, 1.05179269e-02f, -3.57487947e-02f, -5.06772399e-02f,
  1.06877936e-02f, -9.31930318e-02f, -2.18385551e-02f, -1.13417581e-01f, -5.83469123e-02f, 2.52852459e-02f, -1.88886914e-02f, 1.37532830e-01f, -1.82161510e-01f, -4.71499152e-02f,
  -3.41114402e-02f, -6.89224992e-03f, 7.35433027e-02f, 6.94430023e-02f, 1.55677512e-01f, 9.58758369e-02f, 1.11304976e-01f, -1.13570001e-02f, -4.47333865e-02f, 1.19287215e-01f,
  -5.94129339e-02f, 9.32904631e-02f, -8.06409717e-02f, 2.96925977e-02f, -1.08126327e-01f, -4.90102060e-02f, -3.54965474e-03f, -8.24043006e-02f, -2.88561862e-02f, -4.50965129e-02f,
  2.01647609e-01f, -1.17528234e-02f, 1.49460152e-01f, -1.46400998e-03f, -7.92949200e-02f, -4.24210057e-02f, -1.38337269e-01f, 7.90943205e-02f, -6.73190728e-02f, -1.01107210e-01f,
  1.57252401e-01f, -2.60331959e-01f, -1.76213324e-01f, -1.07522227e-01f, -2.49948084e-01f, -2.81957060e-01f, -6.02783971e-02f, -2.76947469e-01f, -2.30355039e-01f, -2.27412760e-01f,
  8.09212923e-01f, 2.97187895e-01f, 1.82216629e-01f, 1.97159663e-01f, -1.67538226e-02f, 5.93952648e-02f, 2.20997140e-01f, 2.39094749e-01f, 6.37905002e-02f, 2.23937660e-01f,
  1.69012100e-01f, 4.58567962e-02f, 1.48120418e-01f, 6.68239668e-02f, 1.22608840e-02f, 1.76120903e-02f, -2.26848707e-01f, 7.74937123e-02f, 1.11141600e-01f, 4.98050712e-02f,
  -1.26151949e-01f, 4.04791981e-02f, 1.87933221e-01f, 9.50570479e-02f, -9.26086083e-02f, 3.28065269e-02f, -4.00963388e-02f, -8.66813362e-02f, -1.35215864e-01f, -1.75208777e-01f,
  -1.54254079e-01f, 2.91012347e-01f, 4.91773933e-02f, 2.91368109e-03f, 1.64941490e-01f, 2.76531100e-01f, 1.81524783e-01f, 1.59442037e-01f, 3.66502069e-02f, -1.20448746e-01f,
  -8.34702924e-02f, 1.54761747e-01f, 1.52850524e-01f, 1.16456628e-01f, -5.14423214e-02f, 2.89414451e-02f, -1.47261098e-02f, 2.89967307e-03f, -8.78806561e-02f, -3.63619849e-02f,
  -3.03616119e-03f, -4.12957668e-02f, -2.23154724e-02f, -4.17973511e-02f, 1.51372212e-03f, -7.35760108e-02f, -2.27161199e-02f, -5.84397353e-02f, 1.27571297e-03f, 2.20969133e-02f,
  -4.76584025e-03f, -4.35273349e-03f, 1.08313538e-01f, 7.70537183e-02f, 3.89693268e-02f, 3.41225192e-02f, -4.22485881e-02f, -1.17892914e-01f, 9.83200073e-02f, 1.92804635e-01f,
  -1.22594442e-02f, -9.85983759e-03f, 4.46008630e-02f, -1.67693049e-02f, 1.35958958e-02f, -1.45572163e-02f, -1.33816913e-01f, -9.35602468e-03f, -1.19134337e-02f, 2.04073079e-02f,
  1.43929245e-02f, -1.19693443e-01f, 1.70254663e-01f, 4.00696658e-02f, -4.07388546e-02f, -6.04114719e-02f, -6.78910539e-02f, 4.40819934e-02f, 1.44879535e-01f, -3.40089798e-02f,
  -1.38488710e-01f, 3.12270224e-01f, 1.53831705e-01f, -4.02504541e-02f, -7.64835849e-02f, 9.75046679e-02f, 2.08418164e-02f, -7.99507946e-02f, -2.23593503e-01f, -1.58082351e-01f,
  -1.69384688e-01f, 8.12742636e-02f, 1.49460137e-01f, 4.35378589e-02f, 6.21184632e-02f, -1.48965463e-01f, 1.65403970e-02f, -9.53743458e-02f, -1.02363877e-01f, -1.95150092e-01f,
  -6.38215691e-02f, -1.04382671e-01f, 3.31483558e-02f, -1.06842428e-01f, -2.65890300e-01f, -9.59488563e-03f, -2.97736432e-02f, -2.23464161e-01f, -1.84308738e-01f, 4.94252406e-02f,
  -2.08220720e-01f, -1.79522023e-01f, -4.08789366e-01f, -3.89662266e-01f, -1.59580186e-01f, 1.57336742e-01f, 2.04400793e-02f, 1.87511876e-01f, -1.03799039e-02f, -2.40249544e-01f,
  -1.89787075e-02f, 1.31381333e-01f, -1.09355234e-01f, 8.33370611e-02f, 7.59543106e-02f, -2.60679930e-01f, -2.70485491e-01f, -2.08577603e-01f, 2.32990354e-01f, 2.22453013e-01f,
  -2.39333995e-02f, -2.83980638e-01f, -2.00491864e-02f, -1.07852139e-01f, -3.50991726e-01f, -3.04543316e-01f, -4.96363223e-01f, -3.29119772e-01f, -2.58374631e-01f, -7.21322060e-01f,
  -4.67291206e-01f, 8.70741755e-02f, 1.86407477e-01f, 9.54706445e-02f, -1.65322304e-01f, 1.15570597e-01f, -4.62583127e-03f, -4.35118638e-02f, 3.77022196e-03f, -9.61735472e-02f,
  4.32506688e-02f, 9.01896060e-02f, -8.95374417e-02f, 5.17100133e-02f, -5.88189736e-02f, 7.60480762e-02f, 1.49755731e-01f, 7.38341659e-02f, 8.77421126e-02f, 5.39317317e-02f,
  3.93214300e-02f, -6.42286334e-03f, 6.11552261e-02f, 1.46827310e-01f, 2.52040744e-01f, 1.16778150e-01f, 2.52627488e-02f, 2.04729870e-01f, 1.76741719e-01f, -1.22152597e-01f,
  -2.56626680e-02f, -9.08360705e-02f, -4.00976576e-02f, 3.86884920e-02f, 5.56194447e-02f, 1.19757829e-02f, -8.16523656e-02f, -9.54767168e-02f, 7.99890310e-02f, -1.37755245e-01f,
  5.98453209e-02f, -5.10881171e-02f, 6.88523799e-02f, -1.09116703e-01f, -1.10757791e-01f, -1.46154100e-02f, 1.86724402e-02f, 1.72529742e-02f, 1.63897071e-02f, 7.59955347e-02f,
  6.90268874e-02f, 3.46062928e-02f, -1.78276971e-01f, 4.13052784e-03f, 1.46498997e-02f, 2.77139265e-02f, -4.08296809e-02f, 9.96322185e-02f, -7.73678273e-02f, 6.00703284e-02f,
  -2.73430645e-01f, 1.92679375e-01f, -1.70684502e-01f, 9.76209119e-02f, -1.37028530e-01f, 2.37300452e-02f, -5.72123118e-02f, -2.31382307e-02f, -1.36141209e-02f, 7.07587451e-02f,
  1.35389388e-01f, -8.37850794e-02f, -1.88969716e-01f, 4.49131653e-02f, 1.09702252e-01f, 6.27655759e-02f, 1.31406505e-02f, 1.28171816e-02f, 7.48428777e-02f, 3.73168066e-02f,
  -2.22598743e-02f, 1.59555659e-01f, 3.12683843e-02f, -2.11457256e-02f, 1.43962681e-01f, 7.75851235e-02f, -4.56120819e-02f, -3.64782624e-02f, 1.91098731e-02f, -1.45837486e-01f,
  5.32039464e-01f, -7.12764710e-02f, 2.33061343e-01f, 2.56224900e-01f, 4.43500668e-01f, 4.01887715e-01f, 3.15617859e-01f, 1.13837548e-01f, 9.14474726e-02f, 1.61483269e-02f,
  -9.58320349e-02f, -2.99563974e-01f, -2.90285200e-01f, -3.51503223e-01f, -1.53527677e-01f, -3.22639081e-03f, -1.28718615e-02f, 4.30086404e-02f, 1.37567565e-01f, 6.86051548e-02f,
  -1.31111562e-01f, 3.90382968e-02f, 1.44564077e-01f, -3.99299785e-02f, -1.82822108e-01f, -1.16414726e-01f, 5.53155958e-04f, 4.12934385e-02f, -5.82869053e-02f, -3.50082844e-01f,
  -2.85899034e-03f, 3.39626074e-01f, 8.15528333e-02f, -3.79079059e-02f, 8.33066553e-02f, -7.40162805e-02f, 1.49682045e-01f, 1.07815221e-01f, 1.32658675e-01f, 1.08561732e-01f,
  -2.55268645e-02f, 6.87582418e-02f, 8.39103237e-02f, 1.08908862e-01f, 1.97995588e-01f, 1.53967068e-02f, -4.24562488e-03f, 7.01558739e-02f, -4.86376286e-02f, -7.88607895e-02f,
  -1.70424491e-01f, 2.49856114e-01f, 1.69712424e-01f, 2.41644215e-02f, -9.59957689e-02f, 4.69038598e-02f, 1.08869381e-01f, 8.27120990e-02f, 4.69576716e-02f, 1.32044824e-02f,
  -1.29682600e-01f, -1.10807739e-01f, -3.25322300e-02f, 7.09556118e-02f, 1.00659683e-01f, 1.84967905e-01f, 7.86090866e-02f, -7.93409869e-02f, -7.26154745e-02f, -7.77885020e-02f,
  2.02083606e-02f, -6.57910155e-03f, 8.96317363e-02f, 4.23976295e-02f, -3.40109039e-03f, 8.79057571e-02f, -1.82295945e-02f, -7.44692832e-02f, -8.90988186e-02f, -6.79808632e-02f,
  -9.33664516e-02f, 4.30781133e-02f, 9.55567360e-02f, -1.51146743e-02f, 7.62485862e-02f, 4.37710695e-02f, -1.11734681e-01f, -6.84200078e-02f, 8.09673965e-03f, -1.32482827e-01f,
  -1.30278453e-01f, 1.69289798e-01f, -5.06013483e-02f, -1.75966442e-01f, -3.94657142e-02f, -1.84958324e-01f, -7.05682337e-02f, -3.36175337e-02f, 1.56462848e-01f, 2.64217630e-02f,
  -1.53111815e-02f, -9.83169954e-03f, -8.91007334e-02f, -4.89427224e-02f, 1.12905197e-01f, 8.88179317e-02f, -7.44423270e-02f, -2.01755539e-02f, -1.32280394e-01f, -1.40399575e-01f,
  -7.45897889e-02f, 6.38057515e-02f, 1.56524792e-01f, 6.59674853e-02f, -2.34367356e-01f, 3.43947858e-02f, 9.28049088e-02f, 3.18703204e-02f, -1.59033444e-02f, -8.20634235e-03f,
  -1.55637980e-01f, -1.30482659e-01f, 2.03944966e-01f, 3.86324376e-01f, 2.24419624e-01f, 2.80459762e-01f, 2.94983417e-01f, 1.37683138e-01f, 2.14566261e-01f, 5.27677760e-02f,
  -6.98977411e-02f, 3.73415984e-02f, 1.32192999e-01f, 1.58848569e-01f, 1.05192043e-01f, 2.35878736e-01f, 3.91254157e-01f, 1.82413533e-01f, 1.27189338e-01f, 5.65429740e-02f,
  1.48909658e-01f, -3.46301012e-02f, -1.38963103e-01f, 1.14851139e-01f, 1.29248619e-01f, 9.67942551e-02f, -2.06493703e-03f, -2.58972272e-02f, 5.05397934e-03f, 2.74576873e-01f,
  1.22923605e-01f, -3.55415083e-02f, 9.33510512e-02f, -1.92068458e-01f, -1.90247506e-01f, -2.56928891e-01f, 1.95723176e-02f, -4.38183956e-02f, -1.11842960e-01f, 1.98019966e-02f,
  -1.11870036e-01f, -1.81125417e-01f, -7.70466402e-02f, -1.39119774e-01f, 5.78466617e-03f, -9.25454870e-02f, -3.69107164e-02f, 2.07704008e-01f, 1.54700503e-01f, 2.29370985e-02f,
  2.13727094e-02f, -1.03680663e-01f, 1.44353837e-01f, 1.71062335e-01f, 1.27027959e-01f, 1.98916644e-02f, 4.55092192e-02f, -5.51037677e-02f, 6.55168891e-02f, 9.54040363e-02f,
  1.05367884e-01f, 2.24179332e-03f, 1.17068946e-01f, 1.47107407e-01f, -7.28502423e-02f, -4.61493842e-02f, 1.67389795e-01f, 1.34981751e-01f, 1.24282412e-01f, -1.70461833e-01f,
  1.14027122e-02f, 2.55843580e-01f, 8.14540237e-02f, 8.09495226e-02f, -1.80624425e-02f, 3.46421357e-03f, -4.20018509e-02f, -5.92333972e-02f, -9.03291702e-02f, -1.50062442e-01f,
  2.67079547e-02f, -2.03193575e-02f, -9.87709388e-02f, -5.06872423e-02f, -2.40249224e-02f, 1.99086852e-02f, 7.47066140e-02f, -9.56919044e-02f, -1.35472029e-01f, -5.81967160e-02f,
  1.74044386e-01f, 8.53306949e-02f, 4.17700782e-03f, 3.77203375e-02f, -1.12481773e-01f, -2.89050967e-01f, 5.54755479e-02f, 1.23764373e-01f, 9.93989184e-02f, 7.28244558e-02f,
  -3.33855860e-02f, -3.98750231e-03f, -7.48553500e-02f, -7.58105367e-02f, -7.13312328e-02f, -3.05752456e-02f, -5.18631749e-02f, 7.17342049e-02f, 2.43767738e-01f, 2.00892705e-02f,
  -8.79829004e-02f, 1.42927185e-01f, 1.05668485e-01f, 4.76532355e-02f, 7.70957395e-02f, -2.30908319e-02f, -8.04042891e-02f, -2.95894071e-02f, 8.95427540e-02f, -5.07981256e-02f,
  2.07989588e-01f, -2.56922096e-01f, 2.73198903e-01f, 2.43925229e-02f, -3.48574668e-01f, -3.94312292e-01f, -5.39162755e-01f, -2.42496759e-01f, -1.31070107e-01f, -2.47351781e-01f,
  -2.34474406e-01f, 1.25839338e-01f, 1.38088644e-01f, 1.60381466e-01f, 1.99348599e-01f, 4.29974534e-02f, 3.73412192e-01f, 5.28266847e-01f, 2.09120974e-01f, -1.14077292e-01f,
  4.99563105e-02f, 1.81982309e-01f, 3.40463847e-01f, 7.22942352e-02f, 8.07821304e-02f, -7.29885772e-02f, -7.04797031e-03f, -2.33511962e-02f, 1.04240943e-02f, 5.10837793e-01f,
  5.70170544e-02f, -1.38557881e-01f, 3.17697413e-02f, -1.57747064e-02f, 6.89369142e-02f, 1.00235932e-01f, -1.01569869e-01f, 1.18926451e-01f, 4.98662665e-02f, 9.61549580e-02f,
  3.68789062e-02f, 3.85742299e-02f, 6.90495223e-02f, 1.10327251e-01f, -8.70533660e-03f, 2.52569839e-03f, 9.71972421e-02f, 1.82566211e-01f, 8.74181613e-02f, -1.56600699e-01f,
  -1.05823362e-02f, -1.10283561e-01f, -7.12993070e-02f, -2.19018057e-01f, -7.24831074e-02f, 1.45798638e-01f, -1.48659497e-01f, 7.04775900e-02f, -4.01578397e-02f, 1.05917253e-01f,
  8.26342702e-02f, 1.58803523e-01f, -5.36116809e-02f, 7.43038803e-02f, 3.97981666e-02f, 2.53273305e-02f, 1.50244161e-01f, -5.92459962e-02f, 1.04168028e-01f, 7.55996630e-02f,
  5.36241494e-02f, -3.24644297e-02f, 3.96604165e-02f, -4.49920930e-02f, 6.92514330e-02f, -5.43141626e-02f, 6.00337647e-02f, 2.15707086e-02f, -2.37689335e-02f, -8.26136395e-02f,
  -2.24931631e-02f, 5.78744672e-02f, -9.07912850e-03f, 9.74161550e-02f, -9.60510001e-02f, 7.62506062e-03f, 5.47175072e-02f, -1.61142468e-01f, -1.68588925e-02f, 4.81825508e-02f,
  -1.44892797e-01f, -6.88057914e-02f, -6.05667196e-02f, 5.98627515e-02f, -9.44958851e-02f, -6.81111813e-02f, -5.17022423e-02f, 2.29525492e-02f, -6.78990632e-02f, -1.69090956e-01f,
  -3.00020099e-01f, -5.50204590e-02f, -8.47286135e-02f, 8.92759580e-03f, 2.29243152e-02f, -9.37822759e-02f, -8.54933336e-02f, -3.30280513e-02f, -5.03640287e-02f, -6.15582839e-02f,
  1.20172374e-01f, -2.73403883e-01f, -1.57875538e-01f, -2.86939472e-01f, -2.21940622e-01f, -6.16138466e-02f, -8.71784911e-02f, -1.53355375e-01f, -2.56536275e-01f, -3.46021712e-01f,
  -1.79997645e-02f, -4.17195082e-01f, -1.74672931e-01f, 3.32712024e-01f, 3.44077855e-01f, 1.56656757e-01f, 3.56390662e-02f, -6.02068938e-03f, 1.49831459e-01f, -1.96524896e-02f,
  -1.27654644e-02f, 2.36214489e-01f, 1.79613575e-01f, 1.60652235e-01f, -4.18011332e-03f, 7.20117763e-02f, 8.83890763e-02f, 1.59449250e-01f, 8.30858499e-02f, 9.90786701e-02f,
  5.19589707e-02f, -5.99576496e-02f, -1.06888242e-01f, 3.44551615e-02f, 5.07561937e-02f, 1.72727495e-01f, 4.48879525e-02f, -9.20412466e-02f, -5.96099906e-02f, 1.46072522e-01f,
  -2.90194422e-01f, -2.81076103e-01f, 2.02115640e-01f, 8.72596949e-02f, -1.70139983e-01f, -2.38539964e-01f, -1.29281357e-01f, -1.79979891e-01f, -9.14010629e-02f, -2.31399149e-01f,
  -2.14904360e-02f, -1.79597095e-01f, 3.29984762e-02f, -1.41818561e-02f, -2.18001357e-03f, -3.39767560e-02f, -7.07285777e-02f, -2.29724377e-01f, -1.22457869e-01f, -1.34503588e-01f,
  1.14386261e-01f, 4.63019349e-02f, -1.26499727e-01f, -1.63194805e-01f, -9.90376100e-02f, 1.10526174e-01f, -1.29781678e-01f, -1.11695513e-01f, -1.80023015e-01f, -2.80547947e-01f,
  4.25996669e-02f, -3.01928464e-02f, 7.70644620e-02f, 9.93378088e-02f, 1.24358915e-01f, 1.40451342e-01f, 9.54152122e-02f, 1.14624184e-02f, 4.11084034e-02f, -4.02716659e-02f,
  1.57412961e-02f, -3.59283239e-02f, -8.90123770e-02f, 1.32704154e-01f, -3.10756303e-02f, 1.30220473e-01f, 9.86801013e-02f, 1.26576414e-02f, 6.19224161e-02f, 1.37550998e-02f,
  -7.87010714e-02f, 5.99287190e-02f, 1.37143537e-01f, 4.62241955e-02f, 9.69237909e-02f, 1.38769403e-01f, 1.09173022e-01f, 2.31360514e-02f, 1.20623417e-01f, -3.05392742e-02f,
  -1.92248791e-01f, -1.17174163e-01f, -2.29482371e-02f, -6.24376275e-02f, -3.57450172e-02f, 9.88015160e-03f, 2.73011904e-02f, -1.01297632e-01f, -1.41956523e-01f, -1.33630559e-01f,
  -1.44928306e-01f, -3.69202308e-02f, 1.58524420e-02f, -4.28394228e-02f, 7.90952221e-02f, -2.15147287e-02f, 4.18133289e-02f, 1.99641231e-02f, 1.49592273e-02f, -1.33473411e-01f,
  -6.92518875e-02f, 8.08888450e-02f, 1.71905652e-01f, -5.08588664e-02f, -7.24392980e-02f, 9.30352062e-02f, 3.68561074e-02f, 6.19694665e-02f, 7.04426467e-02f, -2.03899518e-02f,
  3.25609267e-01f, 3.46629381e-01f, 2.67940879e-01f, 1.89809389e-02f, -6.30016625e-03f, 2.31154069e-01f, 4.89894748e-01f, 1.87551349e-01f, 1.56483371e-02f, 6.63176104e-02f,
  -1.17277175e-01f, -3.21923614e-01f, -2.83215970e-01f, -1.86571002e-01f, 1.23925991e-01f, 2.02856690e-01f, 1.03618748e-01f, 6.86543509e-02f, 3.48880962e-02f, 3.26857343e-02f,
  -1.19738758e-01f, 1.88638315e-01f, 2.40413994e-01f, 6.21045530e-02f, 4.02395539e-02f, -1.86227471e-01f, 8.71485919e-02f, 1.66263878e-01f, 1.56829894e-01f, -2.42907070e-02f,
  1.09169327e-01f, 2.70820379e-01f, -2.74642080e-01f, -2.38479182e-01f, -1.36480570e-01f, 3.78070138e-02f, 3.25794034e-02f, 3.52161042e-02f, 1.30951067e-03f, -2.96323523e-02f,
  -8.27063769e-02f, -9.14397743e-03f, 1.10680349e-01f, 1.13065638e-01f, 1.10565595e-01f, 1.45226732e-01f, 1.23524569e-01f, 2.39156693e-01f, 2.89880708e-02f, 6.73491582e-02f,
  -1.22009382e-01f, 1.09978467e-01f, 4.73990440e-02f, -2.28444058e-02f, 8.20869282e-02f, -1.44068316e-01f, -6.56474382e-02f, 4.21615653e-02f, 3.82200032e-02f, 2.87488941e-02f,
  -9.27781388e-02f, -5.41695245e-02f, -7.34679103e-02f, 9.14958417e-02f, -9.88039225e-02f, -1.55836537e-01f, -4.50362600e-02f, 7.21612573e-02f, 4.05659638e-02f, 1.38668329e-01f,
  9.67792235e-03f, -4.61236052e-02f, 1.19396195e-01f, 1.52395032e-02f, -2.63524819e-02f, 1.23801224e-01f, 1.49739496e-02f, -2.69152205e-02f, 1.33709759e-01f, -2.69513614e-02f,
  2.18042344e-01f, 7.70589039e-02f, 1.12868614e-01f, 1.54326588e-01f, -5.76830655e-03f, 6.13256656e-02f, 3.47251631e-02f, 4.44666520e-02f, 5.78570589e-02f, -1.29644843e-02f,
  5.35739178e-04f, -6.24835491e-02f, -2.11269617e-01f, 1.79327969e-02f, 1.02262445e-01f, 1.13581330e-01f, -2.20531207e-02f, -8.89129415e-02f, -7.53449574e-02f, 3.04417089e-02f,
  1.18548319e-01f, 2.93230657e-02f, 1.81781605e-01f, 1.00156881e-01f, 9.16617457e-03f, -4.78860810e-02f, -1.35729268e-01f, -7.09290057e-02f, -4.71564978e-02f, -3.74589674e-02f,
  -9.72424597e-02f, -1.51165083e-01f, 8.31806567e-03f, -9.35499221e-02f, -1.51346609e-01f, -2.30797499e-01f, -1.09851599e-01f, -6.61432669e-02f, -2.57830154e-02f, -1.24164604e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.22365391e-02f, 1.22923553e-01f, 1.21944241e-01f, 1.38924137e-01f, 2.20138833e-01f, 1.19203098e-01f, 2.14616254e-01f, 3.84782940e-01f, 1.25206470e-01f, 1.17756717e-01f,
  -3.70885618e-02f, 1.15416057e-01f, 6.80283159e-02f, 3.21968389e-03f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.65145600e-01f, 2.59990990e-01f, -8.69742185e-02f, 1.69363078e-02f, -4.13117707e-02f, 7.55752474e-02f, -5.11953756e-02f, 1.70789406e-01f, -2.44185716e-01f, -1.89156622e-01f,
  -3.23736072e-02f, -1.21201752e-02f, 3.53539810e-02f, -4.62817661e-02f, -1.25368580e-01f, -1.10003930e-02f, -8.54786020e-03f, -8.40692744e-02f, 9.55930725e-02f, 2.69527771e-02f,
  -6.30602241e-02f, 1.87690482e-02f, -8.56231302e-02f, 1.86832532e-01f, 1.00747034e-01f, 5.60722053e-02f, -6.39080331e-02f, 6.24845847e-02f, 2.51343161e-01f, -7.52069335e-03f,
  3.91417176e-01f, 1.29148453e-01f, -7.95497671e-02f, -1.39702335e-01f, -2.16170356e-01f, -7.52310753e-02f, 1.71407178e-01f, 4.97797132e-02f, -1.81586131e-01f, -2.09506184e-01f,
  -5.65969087e-02f, 3.12016495e-02f, -7.16780545e-03f, 1.15621462e-01f, 2.95783412e-02f, 2.65699685e-01f, -3.83607559e-02f, 2.29674578e-02f, 1.66086584e-01f, 8.97242799e-02f,
  -6.78102151e-02f, -3.52206901e-02f, -1.33283556e-01f, -3.13588008e-02f, 9.05131921e-02f, -7.35887066e-02f, -4.00458649e-02f, 6.23430125e-03f, 1.09784923e-01f, -2.26982370e-01f,
  -2.29314089e-01f, 1.70725420e-01f, -1.09760918e-01f, -1.01145655e-02f, -4.49249297e-02f, -3.34424269e-03f, 4.51913849e-02f, -6.58273026e-02f, -1.46329347e-02f, 4.09032032e-02f,
  3.87582816e-02f, 1.43438190e-01f, -6.05169386e-02f, 1.32818192e-01f, 1.80879831e-02f, -5.51472045e-02f, 4.12491299e-02f, -2.66877599e-02f, 1.09649651e-01f, 5.71881095e-03f,
  -2.80198753e-02f, 1.03884973e-01f, -1.45297557e-01f, 1.18416905e-01f, -1.67829252e-03f, 7.88913667e-02f, 1.08187636e-02f, 6.89815581e-02f, -2.74221022e-02f, 1.71490923e-01f,
  1.03166349e-01f, 1.19580794e-02f, -3.14148888e-02f, 7.00869560e-02f, 5.64551167e-02f, -1.01802126e-02f, -5.61810285e-02f, 4.10092957e-02f, 2.82245711e-03f, 8.81544277e-02f,
  3.98287289e-02f, -3.74553469e-03f, -6.46257401e-02f, 5.95517531e-02f, -1.22846343e-01f, -3.58114354e-02f, 3.50751877e-02f, -2.42402498e-02f, -8.09157938e-02f, 5.25812879e-02f,
  -6.43966123e-02f, 2.40931716e-02f, 2.51252539e-02f, 9.55773965e-02f, 6.09145276e-02f, -6.48951679e-02f, 1.40451595e-01f, -4.60915923e-01f, -2.07812741e-01f, -4.56992090e-02f,
  -3.93550880e-02f, 2.33418494e-01f, -1.81075931e-01f, -8.39800760e-02f, -2.31932372e-01f, 3.31784457e-01f, -2.24867985e-01f, 1.59337252e-01f, -1.90777704e-01f, 6.86494336e-02f,
  8.09685811e-02f, -1.63224816e-01f, -2.44941995e-01f, 4.10202192e-03f, -8.23250860e-02f, 1.03275022e-02f, -6.84103295e-02f, -9.82562602e-02f, -1.43082395e-01f, 4.30905856e-02f,
  -1.15914397e-01f, -3.16324644e-02f, -3.21526490e-02f, -1.43995687e-01f, -2.49521118e-02f, 5.19496091e-02f, -1.21345088e-01f, -1.63184300e-01f, -1.34622306e-01f, -5.46700731e-02f,
  -1.19530231e-01f, -7.25805089e-02f, 1.00475565e-01f, -2.30457008e-01f, 2.77668148e-01f, 2.28025075e-02f, 4.04685689e-03f, -5.01058921e-02f, -1.70561727e-02f, 9.32193175e-02f,
  -1.60863400e-01f, 1.07640371e-01f, -2.19285950e-01f, -5.37529513e-02f, -2.67045587e-01f, 6.95301741e-02f, 2.23968565e-01f, 3.08589160e-01f, 7.50239864e-02f, 3.95416319e-02f,
  -2.19505206e-01f, -1.07618369e-01f, -1.58393919e-01f, -6.31439760e-02f, 8.31450373e-02f, 1.72419935e-01f, -2.59274244e-01f, -1.08104557e-01f, 6.66521639e-02f, 4.33852047e-01f,
  -1.00800261e-01f, -2.63649911e-01f, -1.34544417e-01f, -2.39268132e-02f, -8.03801045e-02f, 9.12729353e-02f, 7.03110769e-02f, -7.61338621e-02f, -2.51326919e-01f, -2.90903300e-01f,
  -2.19637558e-01f, 1.28806844e-01f, 2.21438124e-03f, -1.75045431e-02f, 1.09824389e-01f, 1.07082248e-01f, 3.65184769e-02f, -6.27593026e-02f, 2.88080368e-02f, -9.69756469e-02f,
  1.28218517e-01f, 1.18166000e-01f, -3.94241093e-03f, 7.88138062e-02f, -4.07033116e-02f, -5.94969392e-02f, -1.15892328e-01f, -8.70580003e-02f, 5.11859246e-02f, 2.60101873e-02f,
  -7.82728568e-02f, -6.86717033e-02f, 1.11975051e-01f, 7.37443240e-03f, -4.10718769e-02f, 1.10912308e-01f, 1.40305581e-02f, -6.99363127e-02f, 1.66658178e-01f, -1.42890383e-02f,
  2.27448419e-01f, 1.21006943e-01f, -2.87508458e-01f, -4.93593700e-03f, -5.42858765e-02f, 2.89340258e-01f, 2.47656360e-01f, -4.33745533e-02f, -3.23546737e-01f, -1.88157424e-01f,
  1.57048747e-01f, 2.98602488e-02f, 8.79010335e-02f, -7.08525116e-03f, -1.71472564e-01f, 8.94260406e-02f, -8.41361098e-03f, -3.80186550e-02f, -2.85187121e-02f, 1.37745187e-01f,
  -1.54075697e-01f, -1.82101220e-01f, 2.83006728e-02f, 1.32814094e-01f, -1.14460163e-01f, 1.17311105e-01f, -1.01324446e-01f, 4.76352796e-02f, 5.92828952e-02f, 8.21542367e-03f,
  -3.49681079e-02f, -5.06252702e-03f, 1.88794300e-01f, -4.14445281e-01f, 3.08740456e-02f, 1.96086913e-02f, -1.02361897e-02f, 6.08894601e-03f, -1.00456052e-01f, 1.26399398e-01f,
  9.27720219e-02f, 1.69598877e-01f, 2.68144608e-02f, 2.75354888e-02f, 2.18559559e-02f, 1.44103423e-01f, 9.08699632e-02f, -1.16179004e-01f, -1.35525495e-01f, 2.37938017e-03f,
  1.10424064e-01f, 5.47130816e-02f, 2.62412913e-02f, 1.22807741e-01f, 8.02062526e-02f, -8.67842417e-03f, 1.59412753e-02f, 2.84260530e-02f, -4.08856794e-02f, 9.12070423e-02f,
  3.45315523e-02f, 1.01995967e-01f, -2.84191161e-01f, 3.99395525e-02f, -2.19774932e-01f, -1.49591891e-02f, 3.00543364e-02f, -6.59026802e-02f, 1.61065105e-02f, -9.60386172e-02f,
  -2.35235289e-01f, 4.49062586e-02f, -3.85283940e-02f, -1.88990176e-01f, -1.27060086e-01f, -4.83147129e-02f, -2.87233859e-01f, -1.51445448e-01f, 2.53259927e-01f, -1.02560043e-01f,
  -6.45824745e-02f, -1.78387478e-01f, -6.73714280e-02f, 1.55493736e-01f, -4.81519029e-02f, 1.52629673e-01f, -2.43718624e-02f, -3.26500624e-01f, 1.42703697e-01f, -3.77487272e-01f,
  7.49880373e-02f, -1.92936778e-01f, -9.55974311e-02f, 2.65352815e-01f, -2.39593387e-01f, 1.84654281e-01f, 4.54272293e-02f, -6.32649139e-02f, -1.20328508e-01f, 3.96029688e-02f,
  -6.09271321e-03f, -2.07653679e-02f, -1.01103328e-01f, 1.11164339e-01f, 4.71718311e-02f, -1.47361532e-01f, -2.35862248e-02f, 4.14561853e-03f, -1.29819840e-01f, 1.74978107e-01f,
  1.88954473e-02f, -1.96435824e-01f, 1.29416613e-02f, -5.95292449e-02f, -1.82645172e-02f, -9.15005133e-02f, 1.65695295e-01f, -1.35932956e-02f, -9.81741399e-02f, 1.37837499e-01f,
  -2.93526947e-02f, 1.33034140e-01f, -4.84359413e-02f, 4.51638475e-02f, -4.46804352e-02f, 5.98521307e-02f, -4.93899509e-02f, -8.07808638e-02f, -7.18588568e-03f, 4.53611865e-04f,
  1.38024211e-01f, 1.08988166e-01f, -1.46281749e-01f, -1.92166194e-01f, -1.34971529e-01f, -4.45881635e-02f, -8.86856243e-02f, 4.02102694e-02f, -7.66544938e-02f, 5.60050048e-02f,
  -4.29548807e-02f, -4.74500023e-02f, -5.64046018e-02f, -1.12667836e-01f, -1.51893899e-01f, -1.65123343e-01f, 7.20275939e-03f, -5.47038540e-02f, -9.70170870e-02f, -3.26931886e-02f,
  -1.82005718e-01f, -2.46787503e-01f, 7.62227923e-02f, -4.14070189e-01f, 4.25016023e-02f, 8.13804418e-02f, 7.05786571e-02f, 6.42762333e-02f, 3.07838116e-02f, 1.36405587e-01f,
  1.30428839e-02f, -6.42184019e-02f, -1.86748937e-01f, 2.05552578e-02f, 5.99692650e-02f, -7.36762881e-02f, 4.55297902e-02f, 6.70916587e-02f, 1.22227766e-01f, -8.00238401e-02f,
  -9.67258401e-03f, 1.02059171e-01f, -3.80243398e-02f, 2.17654064e-01f, 2.97051598e-03f, 1.88707151e-02f, 2.50753108e-02f, -3.70825641e-02f, -8.33893865e-02f, 5.33220321e-02f,
  -3.73011306e-02f, 1.46521494e-01f, 1.29506215e-01f, -7.12554678e-02f, 6.10374622e-02f, -4.33311835e-02f, 7.68690854e-02f, -2.00912859e-02f, 1.09576099e-01f, 3.05649103e-03f,
  -5.31703047e-02f, 1.39576748e-01f, -1.65263325e-01f, -4.14886922e-02f, 8.00095350e-02f, -7.36928731e-02f, 2.60002166e-01f, -2.76103884e-01f, -2.59447889e-03f, 1.51355955e-04f,
  -6.82792217e-02f, 9.40247998e-02f, -1.08782396e-01f, -1.10067390e-01f, -1.02866471e-01f, -7.99916089e-02f, 1.93698213e-01f, -5.75317144e-02f, 1.35682493e-01f, 1.20231241e-01f,
  -1.95712388e-01f, 7.13107362e-02f, 9.72934663e-02f, 1.53863505e-01f, -2.80594677e-02f, -1.48458794e-01f, -6.49302676e-02f, -3.95114541e-01f, -3.70775014e-02f, 1.56651407e-01f,
  1.17040768e-01f, 9.50489566e-02f, -1.83025211e-01f, 1.12727776e-01f, 1.64758727e-01f, 2.01162766e-03f, -8.95862561e-03f, 2.53955200e-02f, 7.02243894e-02f, 8.56955126e-02f,
  1.12810053e-01f, 2.19015881e-01f, 9.44475234e-02f, 8.02455097e-02f, 9.49893519e-03f, 8.46067369e-02f, 1.57799274e-01f, 1.06501214e-01f, 3.56761441e-02f, -8.43188837e-02f,
  -9.80975665e-03f, -1.22798188e-02f, 3.20580825e-02f, 1.21716462e-01f, 3.51751819e-02f, 2.09715247e-01f, -3.78488936e-02f, -5.72941615e-04f, 1.02718331e-01f, -7.94387050e-03f,
  -8.80693942e-02f, 1.41821504e-02f, 1.18558623e-01f, 1.38851076e-01f, -1.24253727e-01f, -1.02600388e-01f, -7.72430450e-02f, -1.32886380e-01f, 1.93363398e-01f, 4.61466797e-02f,
  -6.18176460e-02f, -1.31736085e-01f, -2.72135735e-01f, 1.47654340e-01f, -1.12777837e-01f, 1.76885620e-01f, -1.84718892e-01f, -2.86546975e-01f, -1.64782763e-01f, 2.21935231e-02f,
  1.49429977e-01f, 2.24239111e-01f, -1.01043224e-01f, -2.00210363e-01f, -5.48176952e-02f, 6.49470463e-02f, -4.39568534e-02f, 5.53947948e-02f, -7.68873245e-02f, -3.96525174e-01f,
  1.10650152e-01f, -4.75715071e-01f, 1.36171713e-01f, 1.58602744e-01f, 4.68386635e-02f, -1.36194853e-02f, -2.47197643e-01f, -6.54177591e-02f, 1.12654373e-01f, 1.41484231e-01f,
  -2.20262125e-01f, -6.91174045e-02f, 1.61994994e-01f, 8.72353092e-02f, 5.62751852e-03f, 7.99266398e-02f, -1.36012137e-01f, 1.08187579e-01f, 1.35161489e-01f, -1.15749136e-01f,
  2.04655379e-01f, 2.14777201e-01f, 9.43289101e-02f, -1.20879479e-01f, 8.10059533e-02f, 4.59007770e-02f, 3.24177980e-01f, 8.56150761e-02f, -1.64593786e-01f, 3.40493172e-02f,
  1.43958941e-01f, -1.19132269e-02f, -8.65150616e-02f, -8.89108423e-03f, 1.81805730e-01f, 6.32110983e-02f, -8.75561908e-02f, 7.53660798e-02f, 1.23953700e-01f, -1.23556994e-01f,
  2.10771896e-03f, -6.62948340e-02f, 2.88141251e-01f, -7.60594681e-02f, -1.88782379e-01f, -4.04668786e-03f, -1.78475842e-01f, 1.74661353e-01f, -6.99819773e-02f, 8.10845047e-02f,
  1.66472152e-01f, 2.49676835e-02f, 1.59860969e-01f, 1.18040219e-01f, 5.60648851e-02f, -8.14989284e-02f, -1.81268841e-01f, -6.49652034e-02f, -6.44734427e-02f, 8.16348791e-02f,
  -1.91802725e-01f, 6.05581328e-02f, 4.36048247e-02f, -3.31486613e-02f, -9.39693227e-02f, -1.77780509e-01f, 2.52087153e-02f, 1.70607921e-02f, 7.82588050e-02f, -1.52524665e-01f,
  -1.87575594e-01f, -1.55340984e-01f, 6.62547350e-02f, 2.96387583e-01f, -8.30070153e-02f, 1.01345219e-02f, 6.21277615e-02f, -4.92945649e-02f, -6.98695183e-02f, 1.44876465e-02f,
  4.37533297e-02f, 8.12114701e-02f, 2.89145522e-02f, 8.78168736e-03f, -2.60529257e-02f, 3.67920212e-02f, 7.57791400e-02f, 9.93300602e-02f, -5.96985444e-02f, -1.26491785e-01f,
  -9.30482745e-02f, 7.36980662e-02f, -1.77581504e-01f, -8.73668641e-02f, -2.31685899e-02f, -9.09768492e-02f, 4.57085595e-02f, 1.04534730e-01f, 1.66785195e-01f, 4.11505764e-03f,
  6.48070499e-02f, 1.02926977e-01f, 1.00269541e-01f, 5.45655079e-02f, -1.06520250e-01f, 4.38674949e-02f, -1.66021511e-01f, 7.95125440e-02f, -1.93947658e-01f, 1.66304246e-01f,
  1.56472236e-01f, 6.48987293e-02f, -1.37937129e-01f, -2.00522497e-01f, 1.88883662e-01f, 5.92649914e-02f, 9.06234980e-02f, -4.66083921e-02f, 1.63421318e-01f, 6.66754618e-02f,
  1.91893987e-02f, -4.45404053e-02f, -3.92635912e-02f, 1.23925813e-01f, 1.51544929e-01f, -1.78783357e-01f, -4.67150211e-02f, 1.63177237e-01f, -2.26917312e-01f, -1.99504793e-01f,
  1.26754180e-01f, 8.75360444e-02f, 1.63525436e-02f, 2.00650588e-01f, -2.89420217e-01f, 1.08708002e-01f, -2.17830334e-02f, -3.88027877e-01f, -3.54148597e-01f, 2.82882065e-01f,
  -3.00099459e-02f, -2.83088479e-02f, -9.21114534e-02f, -9.79274660e-02f, 1.94362879e-01f, -7.04795681e-03f, -3.28548513e-02f, 2.15575069e-01f, -1.57758474e-01f, 1.71011969e-01f,
  1.94512289e-02f, -4.13094647e-02f, -9.02875885e-02f, 1.32411271e-01f, -1.29642114e-01f, 6.95330724e-02f, 4.91712391e-02f, 6.13805512e-03f, -8.45353976e-02f, 1.72513008e-01f,
  1.01080678e-01f, 3.22024524e-02f, 2.19038859e-01f, -1.47421166e-01f, 4.07771282e-02f, -4.58331853e-02f, 1.56983003e-01f, 5.83381066e-03f, -1.21167637e-01f, -7.31134564e-02f,
  -1.12008594e-01f, 1.59318089e-01f, 2.39851400e-01f, 1.41050860e-01f, 3.19090754e-01f, 9.85662639e-03f, -7.81057775e-02f, -3.36262360e-02f, -1.11398727e-01f, 9.57511887e-02f,
  -1.68397173e-01f, 1.09068729e-01f, -6.95143566e-02f, -5.85866682e-02f, -1.53083559e-02f, 4.22608703e-02f, -2.35581726e-01f, -2.23199889e-01f, 6.39262721e-02f, 2.01754883e-01f,
  5.89034520e-02f, -2.71671921e-01f, -6.76794946e-02f, 1.19951829e-01f, -7.97193870e-02f, -3.58083844e-02f, 3.39387745e-01f, -1.61620155e-01f, 3.68445776e-02f, 2.68800892e-02f,
  6.65020347e-02f, 4.85012770e-01f, -1.00891158e-01f, 1.46272928e-01f, -3.24169211e-02f, 1.36990123e-03f, 1.77761894e-02f, -2.09901497e-01f, -1.40478974e-02f, 7.94171616e-02f,
  -5.77894039e-02f, 6.02938198e-02f, -2.07080945e-01f, 1.15236275e-01f, -8.91361758e-02f, 6.79267617e-03f, 1.23564852e-02f, -5.64088523e-02f, -1.56174824e-01f, 6.79463968e-02f,
  -1.77441556e-02f, 9.96442810e-02f, -1.81426629e-01f, 4.42529768e-02f, -3.20817046e-02f, 6.41549230e-02f, 1.14197209e-01f, -3.63229029e-02f, -6.96970383e-03f, -1.14822663e-01f,
  2.96278685e-01f, 1.70129817e-02f, -3.04314494e-02f, 1.59724250e-01f, -7.10639134e-02f, -3.71217728e-02f, 2.41532505e-01f, 2.27855131e-01f, 1.25766158e-01f, 6.21728003e-02f,
  -9.56681073e-02f, -2.25000083e-02f, 1.34187892e-01f, 4.15111512e-01f, 4.62570190e-02f, 6.92784134e-03f, -1.69025466e-01f, -2.46499509e-01f, -1.59244493e-01f, -8.10325444e-02f,
  8.83621424e-02f, 6.90736994e-02f, -2.00500980e-01f, -4.21803594e-02f, 2.03164935e-01f, 2.03767210e-01f, 6.65950775e-02f, -2.26964340e-01f, -3.58656853e-01f, 8.87513980e-02f,
  2.12879673e-01f, 9.33917239e-02f, -3.93359214e-01f, -9.62136388e-02f, 5.33232093e-02f, 1.80768952e-01f, -6.65975511e-02f, 1.58216909e-01f, 1.04130194e-01f, -4.78221402e-02f,
  -8.63403752e-02f, -1.24183483e-01f, -3.26604815e-03f, 7.33220205e-02f, -3.68326227e-03f, 5.21065444e-02f, 1.38679296e-01f, 6.96644261e-02f, 4.37816605e-02f, -8.84827152e-02f,
  2.78147380e-03f, 2.82971263e-01f, 1.56928375e-01f, -9.20375362e-02f, 2.25028515e-01f, 1.13911778e-01f, -7.07394704e-02f, -3.81858759e-02f, -6.61442354e-02f, 2.76702433e-03f,
  -1.12535760e-01f, -8.61849710e-02f, -1.17249914e-01f, -6.82420731e-02f, -1.08971842e-01f, -6.02281652e-02f, -2.71131426e-01f, 9.12082382e-03f, -2.02815935e-01f, 3.16677392e-02f,
  1.07398974e-02f, -9.40046161e-02f, 8.64408724e-03f, 3.14989358e-01f, 1.01086803e-01f, 2.08181068e-02f, 8.40497948e-03f, 1.58142388e-01f, -6.62775114e-02f, -2.32082292e-01f,
  1.16119310e-01f, 3.94632993e-03f, -6.38847277e-02f, -1.90438569e-01f, -2.38218196e-02f, -9.97243449e-02f, 1.26781650e-02f, 8.12974796e-02f, 5.59431389e-02f, -1.07447177e-01f,
  -1.26493633e-01f, 1.26942381e-01f, 4.92876172e-02f, -5.50316125e-02f, 6.82959557e-02f, 1.01449981e-01f, 1.06657505e-01f, 1.24575116e-01f, -1.73775807e-01f, -6.39223084e-02f,
  -3.05038273e-01f, 2.54312724e-01f, -1.53812300e-02f, 1.29250824e-01f, 9.04057920e-02f, -1.42171815e-01f, 7.74008632e-02f, 3.31984833e-02f, 1.41575962e-01f, -1.50327953e-02f,
  1.60343722e-01f, -9.58488323e-03f, 2.11702377e-01f, 8.85436237e-02f, 8.54094103e-02f, -2.57112272e-02f, 1.60397708e-01f, -6.60567209e-02f, 7.21742138e-02f, -4.30537201e-02f,
  -6.18977509e-02f, -1.86906978e-02f, -6.51936000e-03f, -4.31089522e-03f, -2.39749122e-02f, 8.17869902e-02f, 7.54286125e-02f, 4.15858328e-02f, 5.70036471e-02f, 1.08377792e-01f,
  -3.60764079e-02f, 4.37053889e-02f, 1.30123734e-01f, 9.36267748e-02f, -4.11028638e-02f, 3.50009440e-03f, -9.01627243e-02f, 1.06057018e-01f, -8.15225393e-02f, 2.46162608e-01f,
  -2.68413901e-01f, -1.94619536e-01f, 4.83269766e-02f, -8.93567279e-02f, 1.71599552e-01f, -1.89646857e-03f, 8.13398659e-02f, -8.79812986e-02f, 8.55383230e-04f, 2.87977076e-04f,
  1.36698976e-01f, 3.47548053e-02f, 8.94161686e-02f, -6.46970645e-02f, -1.82964548e-01f, -1.49579555e-01f, 1.21156387e-01f, 1.11721158e-01f, -2.30360463e-01f, 2.29832694e-01f,
  3.69953960e-01f, 6.52390495e-02f, -1.09626420e-01f, -8.84701610e-02f, -1.77912533e-01f, 2.36382425e-01f, 1.54677227e-01f, -1.32868513e-01f, -3.63200456e-02f, 1.21173888e-01f,
  3.22413631e-02f, -5.44821611e-04f, 2.88146157e-02f, 2.88491324e-02f, 7.46587366e-02f, -2.76037809e-02f, 4.07999456e-02f, 9.08441900e-04f, 7.08854124e-02f, 6.64066821e-02f,
  9.87101197e-02f, 4.25942354e-02f, 1.17211491e-01f, 9.75160748e-02f, 1.51934296e-01f, 7.85206482e-02f, 2.01635018e-01f, -7.43600205e-02f, 4.37259348e-03f, 1.52785897e-01f,
  -3.21714953e-02f, 7.37100793e-03f, -1.82774886e-01f, -1.18397795e-01f, 1.70130193e-01f, -1.13330618e-01f, -2.14414507e-01f, 4.62903269e-03f, -1.58389390e-01f, 1.12891681e-01f,
  8.16925988e-02f, 7.95769505e-04f, 4.19750847e-02f, -1.27761200e-01f, -8.25742781e-02f, -5.08978218e-02f, 1.17853321e-01f, -1.12348683e-01f, 6.22601099e-02f, 1.71721265e-01f,
  2.69827079e-02f, 2.73290649e-02f, 1.07356943e-01f, -7.58878738e-02f, 7.08218962e-02f, -5.80654703e-02f, -6.56379163e-02f, -1.78645790e-01f, -1.58754170e-01f, 2.96711445e-01f,
  1.91693947e-01f, -6.19380921e-03f, -1.14546224e-01f, 3.71070839e-02f, 2.71465033e-01f, 1.97712690e-01f, -7.94318169e-02f, -2.29996011e-01f, 7.65496418e-02f, -1.32122010e-01f,
  -8.01928267e-02f, -1.77853137e-01f, 1.04685631e-02f, -1.95127174e-01f, -2.48127244e-02f, -2.63470295e-03f, 2.85123643e-02f, 5.66726029e-02f, -3.82263474e-02f, -1.53849237e-02f,
  2.92756036e-02f, -9.29520279e-03f, 1.81509197e-01f, -2.20136300e-01f, -1.41581878e-01f, -2.85657290e-02f, -1.60278454e-01f, -3.48686278e-02f, 7.54039222e-03f, 6.08096533e-02f,
  -3.71940881e-02f, 7.94275030e-02f, -1.00644641e-02f, -2.14592546e-01f, 2.37589538e-01f, 9.58000645e-02f, 2.07837224e-01f, 1.56222507e-01f, -2.63394535e-01f, 1.50754049e-01f,
  -1.31429791e-01f, 7.10669830e-02f, 1.39845341e-01f, 5.98367117e-02f, 1.24102831e-01f, -7.31474981e-02f, -8.31840783e-02f, 1.83838844e-01f, 1.73809648e-01f, 1.31644472e-01f,
  -6.01278469e-02f, -3.98038402e-02f, -5.92851266e-02f, -7.28235319e-02f, 1.11883961e-01f, 7.00472668e-02f, -8.55279639e-02f, 1.00616403e-01f, 2.35677406e-01f, 6.52013943e-02f,
  -1.06153414e-01f, 4.70390019e-04f, -4.00495622e-03f, -2.07394168e-01f, -2.05084383e-01f, -2.26609856e-01f, 1.70308560e-01f, -1.66691318e-01f, -1.78683043e-01f, 2.16748267e-01f,
  -3.89122777e-02f, 2.62272537e-01f, 7.04001412e-02f, 2.04176024e-01f, -1.56357419e-02f, 2.71348029e-01f, -4.29104157e-02f, 9.98805910e-02f, -1.84407290e-02f, 3.86098512e-02f,
  -4.40819487e-02f, -2.80207731e-02f, -3.25459465e-02f, -7.76652172e-02f, -1.09901369e-01f, 3.97806019e-02f, 1.13171868e-01f, 1.39210805e-01f, 1.12322599e-01f, 6.39099330e-02f,
  2.17391327e-01f, 4.50288353e-04f, 5.50413802e-02f, -7.24009722e-02f, -6.08113706e-02f, 9.49243736e-03f, -4.60426435e-02f, 1.82264879e-01f, -5.54199144e-02f, 1.07248314e-01f,
  -2.37597957e-01f, 5.06600738e-02f, 8.52268040e-02f, -1.58438936e-01f, 2.61208296e-01f, 2.18294114e-02f, -4.27149713e-01f, -2.03827724e-01f, -3.23809206e-01f, 1.22280829e-01f,
  7.53199458e-02f, -4.59966958e-02f, -3.60969082e-02f, -7.62323514e-02f, 7.47581795e-02f, 1.41528070e-01f, -5.51296026e-02f, 6.50384948e-02f, -1.14466235e-01f, 1.05090998e-01f,
  -5.68615831e-02f, 5.12135327e-02f, -2.57351816e-01f, -4.42009680e-02f, 1.21721029e-01f, 2.80855293e-03f, 1.89343244e-01f, -2.39865910e-02f, 1.80904463e-01f, 1.56267434e-01f,
  -1.80934623e-01f, 7.22467750e-02f, 2.80949980e-01f, -1.73055723e-01f, -2.04781175e-01f, 3.46417069e-01f, 1.18912652e-01f, -2.41813898e-01f, 4.58121970e-02f, 4.13806252e-02f,
  7.23570213e-03f, -1.27559677e-01f, -6.83402121e-02f, -9.99628007e-02f, -3.64240333e-02f, 2.15131462e-01f, -2.02271432e-01f, -5.96763007e-02f, -8.52406025e-02f, 4.88357171e-02f,
  -4.95913438e-02f, -6.07267432e-02f, -1.12541609e-01f, -1.05052844e-01f, 2.80583054e-02f, -1.05178162e-01f, -7.19266804e-03f, -1.36525580e-03f, 6.75212070e-02f, 2.27947813e-02f,
  -8.38932674e-03f, 8.99638832e-02f, -5.39287254e-02f, 1.20516330e-01f, 9.50833187e-02f, -1.78473800e-01f, 2.01069400e-01f, -1.53454751e-01f, -1.59961611e-01f, 2.11028066e-02f,
  9.87120047e-02f, 1.02559902e-01f, 1.22003786e-01f, 3.27811949e-02f, -2.33179405e-02f, -9.12808329e-02f, -7.33767226e-02f, 1.02981858e-01f, 1.83301732e-01f, 1.72004938e-01f,
  -1.75190881e-01f, 1.11349374e-01f, -1.00651734e-01f, 7.26142600e-02f, 1.05032302e-01f, 2.65680756e-02f, 1.36635527e-01f, -1.95282504e-01f, 2.31969841e-02f, 9.94253382e-02f,
  -2.18944371e-01f, 3.22491348e-01f, 3.61110300e-01f, -4.28037811e-03f, 3.67825627e-02f, -3.76458205e-02f, 1.89446449e-01f, -3.16587746e-01f, -1.59078896e-01f, -8.07737466e-03f,
  -3.25187773e-01f, -2.66658813e-02f, -1.61259249e-01f, 1.61131442e-01f, -6.15704581e-02f, -2.39653531e-02f, -6.66036010e-02f, 2.72964448e-04f, -2.54152548e-02f, 9.02106017e-02f,
  -6.67110160e-02f, -1.22608833e-01f, -2.65989937e-02f, 9.09100100e-02f, -1.84370149e-02f, -3.03992331e-02f, -1.01148151e-01f, 1.29512241e-02f, -4.71676700e-02f, -5.09757809e-02f,
  -8.62537697e-02f, 3.89922708e-02f, 9.01156813e-02f, 5.55657446e-02f, 1.05269797e-01f, 8.33029151e-02f, -1.07172526e-01f, -1.06551228e-02f, 7.37302676e-02f, -6.62078289e-03f,
  -8.58515576e-02f, -1.69283628e-01f, 4.10701372e-02f, 3.13086472e-02f, -2.19083056e-01f, -8.04029331e-02f, -7.27300067e-03f, 3.47418189e-02f, -7.49518052e-02f, 1.08019775e-02f,
  1.83609503e-04f, -4.22062986e-02f, 4.49543744e-02f, 1.61010951e-01f, -6.80004731e-02f, 7.03340322e-02f, 3.79810259e-02f, 1.27480775e-01f, 5.22948913e-02f, -1.67398073e-03f,
  1.06314950e-01f, -1.58695221e-01f, -1.59154326e-01f, -9.45710912e-02f, -6.20133169e-02f, 3.81436795e-01f, 2.77157098e-01f, -8.65258351e-02f, 1.29320115e-01f, -2.82346696e-01f,
  2.79147178e-01f, -2.83918351e-01f, -1.21725239e-01f, 1.00171968e-01f, -4.04676422e-02f, -7.59574473e-02f, -1.03666291e-01f, 1.83047161e-01f, 6.04022061e-03f, 9.03718695e-02f,
  3.09821591e-02f, 4.10144515e-02f, -5.98596781e-02f, -1.14285685e-02f, -3.03007104e-02f, -1.60115007e-02f, -1.73379816e-02f, -9.79663134e-02f, -4.28374857e-03f, -1.00808993e-01f,
  -1.05276942e-01f, 3.79188620e-02f, -7.39726722e-02f, -9.63571761e-03f, 2.13823348e-01f, -1.10087194e-01f, -7.55172689e-03f, -3.95947546e-02f, -3.15135181e-01f, 1.51109457e-01f,
  1.07780039e-01f, 7.51646161e-02f, -3.14580739e-01f, 1.63223013e-01f, -1.15536656e-02f, -8.59188214e-02f, 3.17105472e-01f, -4.52015214e-02f, 2.09464431e-02f, -3.43184948e-01f,
  -3.55210513e-01f, -1.51025197e-02f, -2.26983689e-02f, -4.33711000e-02f, -1.30829886e-01f, -3.07401478e-01f, -3.14551964e-02f, 1.63672358e-01f, 1.98681027e-01f, 1.06409915e-01f,
  4.08328213e-02f, 1.28651336e-01f, -1.98803004e-02f, -3.03220134e-02f, 1.34687558e-01f, 2.12236941e-02f, -3.42937522e-02f, -1.96138874e-01f, -1.82238609e-01f, -1.43461719e-01f,
  1.53423473e-01f, -7.51543865e-02f, -1.65267155e-01f, 3.53230387e-02f, 5.78542650e-02f, -9.47962478e-02f, -5.51901832e-02f, -3.61903310e-02f, 1.49603143e-01f, -1.14965580e-01f,
  -8.35795850e-02f, 6.39729798e-02f, -1.52490228e-01f, 7.85553157e-02f, 1.75484449e-01f, 3.34224291e-02f, 2.66233981e-02f, 1.54322550e-01f, -1.75524488e-01f, 8.47114176e-02f,
  -2.67354697e-02f, -6.65267035e-02f, -2.02559114e-01f, -1.32153304e-02f, -1.28799275e-01f, -5.20202927e-02f, 2.04323843e-01f, 7.81389996e-02f, -8.01752955e-02f, -6.25279639e-03f,
  -6.19847402e-02f, 7.52328858e-02f, 3.44826235e-03f, 1.14882372e-01f, 4.29635346e-02f, -3.43322940e-02f, -1.65496796e-01f, 1.35924384e-01f, -8.42840448e-02f, 4.69177179e-02f,
  -2.50315011e-01f, 1.07675195e-02f, 1.29886284e-01f, 1.72137991e-02f, 1.43427685e-01f, 6.42674565e-02f, -3.57386135e-02f, 2.22025421e-02f, 3.11079137e-02f, -1.49212405e-01f,
  -8.84318165e-03f, -7.95766786e-02f, 1.02708019e-01f, 5.63510172e-02f, -1.28539559e-02f, -7.11168870e-02f, -7.24668652e-02f, 1.30336150e-04f, 4.38780189e-02f, -4.40691337e-02f,
  -1.55248612e-01f, -3.49081606e-01f, 7.46292993e-02f, -1.98037669e-01f, 2.23180130e-01f, -1.97158992e-01f, -2.11335893e-04f, -1.56667635e-01f, -2.22159684e-01f, 1.81843638e-01f,
  1.63573921e-01f, -8.28511789e-02f, 6.19659834e-02f, 1.10096969e-01f, 5.45734540e-02f, 6.50155321e-02f, 8.36734939e-03f, -2.87288483e-02f, 4.01556157e-02f, 5.76567501e-02f,
  7.87125528e-02f, -2.97029857e-02f, 2.41412535e-01f, 2.39553571e-01f, -3.51807475e-02f, -1.49812430e-01f, -1.53811872e-01f, 2.25900888e-01f, 5.32513112e-02f, 9.47717503e-02f,
  1.10326461e-01f, 9.20197666e-02f, -1.37326136e-01f, -1.02215121e-02f, -4.27676179e-02f, 4.05978732e-04f, -1.21385437e-02f, 5.52142076e-02f, -7.06748068e-02f, -1.83782190e-01f,
  7.47659132e-02f, -7.16811866e-02f, -3.26226592e-01f, -9.71881226e-02f, 2.10084081e-01f, 3.29592451e-02f, -3.71747650e-02f, -1.80333257e-02f, -1.68242916e-01f, 1.23724550e-01f,
  2.57165339e-02f, 2.59632081e-01f, 1.59138098e-01f, 3.60972315e-01f, -1.72815844e-01f, 1.04053676e-01f, -1.49190649e-01f, -5.24105765e-02f, -7.26608485e-02f, -1.87687635e-01f,
  -1.05215490e-01f, -6.34073764e-02f, -9.92165282e-02f, 1.40964225e-01f, -6.27966076e-02f, 2.35451292e-02f, -1.08216554e-02f, -3.82976979e-01f, -2.65695959e-01f, -9.36190411e-02f,
  1.51246130e-01f, 4.64853831e-02f, -2.68813014e-01f, -5.06054685e-02f, -1.30468920e-01f, 3.06473136e-01f, -2.38522738e-01f, 2.20956907e-01f, 1.12423934e-02f, -1.77477956e-01f,
  -7.60638192e-02f, 4.97782081e-02f, -2.52460223e-02f, -8.98863897e-02f, -1.48422822e-01f, -6.42808303e-02f, -1.91760600e-01f, -2.62175828e-01f, -3.56130861e-02f, -7.13114515e-02f,
  -3.77868637e-02f, 5.23155835e-03f, -8.01277757e-02f, -6.21535853e-02f, -1.70896873e-01f, 1.11432392e-02f, -1.42500952e-01f, 4.83648665e-02f, -1.12616636e-01f, -3.68987471e-02f,
  -4.47957590e-02f, -1.25368908e-01f, -1.06834792e-01f, -1.18769102e-01f, 1.66764721e-01f, 2.02153604e-02f, 5.98503612e-02f, -1.07694961e-01f, -2.60759927e-02f, -9.84050985e-03f,
  -2.34233066e-01f, 1.11417688e-01f, 1.03863716e-01f, -7.89691061e-02f, 1.85046032e-01f, -5.49851209e-02f, 1.54851899e-01f, 3.12503904e-01f, 1.49747282e-01f, -3.18050990e-03f,
  -2.57930070e-01f, 1.17023727e-02f, -1.82771112e-03f, 3.21146026e-02f, 1.06937690e-02f, 9.24000517e-02f, -3.32352906e-01f, -1.36903316e-01f, 1.95455849e-01f, 9.51971486e-02f,
  1.70952529e-02f, 1.35735631e-01f, -2.10468918e-01f, 2.06366852e-01f, 8.47083256e-02f, -6.75996840e-02f, -4.85739820e-02f, -1.25642270e-01f, 2.30741769e-01f, -4.67951670e-02f,
  -1.67607144e-01f, -7.15863407e-02f, -2.89056860e-02f, -2.55491827e-02f, -1.61676988e-01f, -1.05824150e-01f, 8.14430490e-02f, -1.43202230e-01f, 5.40627688e-02f, -4.46364135e-02f,
  1.80015340e-01f, 1.19143739e-01f, -3.56170274e-02f, -1.16237558e-01f, 7.92052522e-02f, 1.31475434e-01f, 2.22703636e-01f, 9.35992133e-03f, -4.30377424e-02f, 1.58411399e-01f,
  8.47855657e-02f, -9.61449295e-02f, 1.10273408e-02f, 5.62382415e-02f, -1.37377456e-01f, -2.29230106e-01f, 2.22962961e-01f, -2.34189987e-01f, -3.40978242e-02f, 8.27608351e-03f,
  -3.71192634e-01f, -5.32563962e-02f, -1.89860329e-01f, -2.68249661e-02f, 7.15277269e-02f, -1.24145724e-01f, -1.59109131e-01f, 2.17882656e-02f, -9.84691605e-02f, -2.26036727e-01f,
  3.15199494e-01f, 3.21073323e-01f, -2.83388674e-01f, -2.01158658e-01f, 5.62505089e-02f, -1.49176657e-01f, -2.09372658e-02f, -1.13728017e-01f, 1.28417267e-02f, 4.65233773e-02f,
  6.95616566e-03f, 1.57506928e-01f, 3.87247317e-02f, 1.50359109e-01f, 2.85899956e-02f, 1.11672148e-01f, -1.97088078e-01f, -3.80132981e-02f, 1.58444077e-01f, 1.69394892e-02f,
  -1.72371641e-01f, 3.89611125e-02f, 1.84929013e-01f, -1.89008072e-01f, 1.79677844e-01f, 1.58918485e-01f, -1.02911308e-01f, 9.14111882e-02f, -3.31744663e-02f, 3.45107317e-02f,
  -8.32437947e-02f, -8.71355738e-03f, 5.62651306e-02f, -6.60620455e-04f, -1.39094200e-02f, -1.64836273e-01f, -5.78468591e-02f, -9.61794034e-02f, -9.46643427e-02f, 8.54113847e-02f,
  -1.47224113e-01f, -3.95363308e-02f, -7.95820262e-03f, -7.84509107e-02f, -4.01508026e-02f, 3.98964398e-02f, -1.71534717e-02f, 1.51503682e-02f, -8.11476409e-02f, 2.84370016e-02f,
  2.04640534e-02f, 3.38827632e-02f, -5.59270941e-02f, 1.16007134e-01f, 9.35157537e-02f, 5.72158173e-02f, 1.62881166e-01f, 8.16580504e-02f, -5.47740795e-02f, -2.98477504e-02f,
  -1.72847196e-01f, -4.98239435e-02f, 3.68185826e-02f, 8.46112370e-02f, 6.42845035e-02f, -1.89587906e-01f, 1.63547635e-01f, 1.06452964e-01f, -4.42074984e-02f, -8.48396122e-02f,
  -3.58812027e-02f, 1.36571363e-01f, 1.49678560e-02f, 7.73299038e-02f, -1.79149985e-01f, -3.55532318e-02f, 3.05703908e-01f, 1.89517364e-01f, 9.28392634e-03f, -4.70423400e-02f,
  1.16891831e-01f, -2.55928957e-03f, -1.84691057e-01f, 1.03147766e-02f, 1.68186709e-01f, -2.86325604e-01f, -1.31249800e-02f, 6.74140360e-03f, -1.09867856e-01f, 1.93991680e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.96404785e-01f, 3.52599807e-02f, -1.68616269e-02f, 3.18141542e-02f, -1.06967408e-02f, 3.44700776e-02f, -5.62959686e-02f, -2.87422892e-02f, -1.11817703e-01f, -8.96774530e-02f,
  7.55019039e-02f, 4.82297055e-02f, 9.15990248e-02f, -1.08300529e-01f, 7.56722987e-02f, -7.69201219e-02f, -6.22319505e-02f, -2.37969533e-01f, -1.79901011e-02f, 1.59569651e-01f,
  -1.52642742e-01f, 4.94902255e-03f, -8.87360647e-02f, 3.85229886e-02f, -1.41655564e-01f, -3.77030782e-02f, -8.11344385e-02f, 8.21791887e-02f, 7.52495974e-02f, 5.17680310e-03f,
  3.71866286e-01f, -2.59511620e-02f, -3.42622437e-02f, -4.01150256e-01f, -1.78519309e-01f, -1.87842533e-01f, 9.51740965e-02f, 2.57961422e-01f, -2.71100998e-01f, -3.65209997e-01f,
  -1.30867716e-02f, 5.71362078e-02f, 1.72939673e-01f, 2.37515077e-01f, -6.97515532e-02f, 2.17559531e-01f, 6.07575662e-02f, -6.07031621e-02f, 3.15691978e-01f, -1.85407456e-02f,
  1.43163636e-01f, -3.78538482e-03f, 5.52293099e-02f, 2.07000319e-02f, 2.53578834e-02f, 2.85095423e-01f, -4.64808166e-01f, 9.90265831e-02f, 3.29717636e-01f, -3.40054114e-03f,
  2.42045954e-01f, -7.68969208e-02f, 1.67660370e-01f, -2.73020752e-02f, -2.20174283e-01f, 1.24350794e-01f, -1.42039836e-03f, 1.95341721e-01f, 2.32435968e-02f, -9.25289765e-02f,
  3.33190933e-02f, 2.73088962e-01f, -3.38034704e-02f, 1.84430331e-02f, 1.89581037e-01f, 3.68002150e-03f, -1.11181280e-02f, -1.09145716e-01f, 1.11359894e-01f, 1.17720842e-01f,
  1.21017568e-01f, 1.55867383e-01f, 4.40560952e-02f, 1.08568586e-01f, -2.60606185e-02f, 5.29969297e-02f, 1.40608430e-01f, 1.11239828e-01f, 5.28574102e-02f, 6.10418990e-02f,
  1.11373380e-01f, 5.40469661e-02f, 7.39429817e-02f, -2.96950843e-02f, 2.56382793e-01f, 1.72242716e-01f, -2.13547666e-02f, -6.62629381e-02f, 5.71836531e-02f, -4.58678342e-02f,
  1.89372674e-01f, -4.21899855e-02f, -1.76637232e-01f, -1.45772651e-01f, -1.19887151e-01f, 1.63078502e-01f, -2.06386633e-02f, 1.54682487e-01f, 4.74401787e-02f, -1.15468971e-01f,
  -1.37059152e-01f, 1.08806733e-02f, 5.61190322e-02f, -3.79476734e-02f, 2.26038188e-01f, -3.18621308e-01f, 2.29097113e-01f, 4.76865377e-03f, 2.52990164e-02f, 1.29929036e-02f,
  3.53050619e-01f, -5.08897379e-03f, -1.08973503e-01f, -1.20628215e-01f, 1.77213117e-01f, 4.47692007e-01f, 7.03616291e-02f, -1.80886000e-01f, 1.26737878e-01f, -6.74478011e-04f,
  -2.82599758e-02f, 2.16329303e-02f, 1.36680409e-01f, -1.76179916e-01f, 1.48886010e-01f, 7.44718835e-02f, -1.90542415e-02f, 1.31703198e-01f, 1.85367435e-01f, 1.29026577e-01f,
  8.17891732e-02f, -1.97308585e-01f, 2.00220466e-01f, 2.26682901e-01f, -1.83032244e-01f, 7.62606785e-02f, 3.26260686e-01f, 9.72215980e-02f, -5.37804589e-02f, -5.78542352e-02f,
  1.34109646e-01f, -8.63142088e-02f, 2.00690106e-01f, 6.49153367e-02f, -3.00064027e-01f, 6.99831918e-02f, -1.83194831e-01f, 1.17630541e-01f, -4.53647003e-02f, -1.35429879e-03f,
  4.38969016e-01f, -1.51302278e-01f, 1.25122234e-01f, 8.07713345e-02f, 2.28491873e-01f, 1.10971645e-01f, -1.17678434e-01f, -2.64454365e-01f, -2.55356371e-01f, 1.30236596e-01f,
  3.37022692e-01f, 3.53822738e-01f, 3.68917912e-01f, 1.18548900e-01f, -3.00409198e-01f, -1.83333173e-01f, 3.93252552e-01f, 2.72410184e-01f, -1.87027857e-01f, -6.37530625e-01f,
  -9.23678279e-02f, 1.30692482e-01f, -7.62803853e-02f, -2.66584039e-01f, 1.02632180e-01f, -3.28424275e-02f, -2.13267475e-01f, -3.16251926e-02f, -3.77981886e-02f, 4.43508983e-01f,
  2.80229539e-01f, 1.07080145e-02f, 9.29714926e-03f, 1.01306997e-01f, 9.50952247e-02f, 4.48132083e-02f, -1.70966834e-02f, 1.03584804e-01f, 1.66406438e-01f, -6.81347772e-02f,
  8.93152654e-02f, 1.16214849e-01f, 1.24211572e-01f, -9.03447196e-02f, -1.13400660e-01f, 3.03536147e-01f, 9.50344503e-02f, -1.31462976e-01f, 1.26667753e-01f, 1.36661097e-01f,
  1.81747660e-01f, -4.71879691e-02f, 9.59048942e-02f, 8.02451074e-02f, -2.41794623e-02f, 1.01681508e-01f, -8.90761241e-02f, 2.06392676e-01f, -2.90538400e-01f, -2.65134647e-02f,
  -6.52399659e-02f, -5.75936697e-02f, 2.17896074e-01f, -7.64503330e-02f, -3.12739700e-01f, -1.49897277e-01f, -3.01707536e-01f, -5.67566231e-02f, -1.06966063e-01f, -1.70417771e-01f,
  2.24540144e-01f, -1.91742256e-02f, -3.45583186e-02f, -1.26488686e-01f, 1.09684393e-01f, -1.52928516e-01f, -2.12197259e-01f, -2.14165986e-01f, -3.72350104e-02f, 7.16863051e-02f,
  -1.77699238e-01f, -3.56391631e-02f, 1.10363718e-02f, 2.86609549e-02f, 1.80647038e-02f, -2.22866848e-01f, 1.22449966e-02f, 7.35697448e-02f, -9.48166996e-02f, 4.93462056e-01f,
  1.13750800e-01f, 1.78816646e-01f, -8.86165723e-02f, -1.31042853e-01f, -1.10560417e-01f, 1.48280919e-01f, 1.36725279e-02f, 7.42388591e-02f, 2.66983807e-01f, 8.71355683e-02f,
  -1.71679527e-01f, 5.61729707e-02f, 6.84607103e-02f, -3.79767537e-01f, 1.26136869e-01f, 1.58346500e-02f, 5.96725848e-03f, 1.45568565e-01f, 5.89622967e-02f, -2.34730661e-01f,
  -9.87739339e-02f, -2.79815681e-02f, -2.34387308e-01f, -5.25114238e-02f, 7.49188289e-02f, -1.54138595e-01f, -8.23870376e-02f, -9.87357944e-02f, -1.27165914e-01f, -3.02152455e-01f,
  1.90541759e-01f, 6.89565912e-02f, 2.26414680e-01f, -1.73158920e-03f, 2.30523691e-01f, 1.64463576e-02f, 2.92708367e-01f, -2.77092643e-02f, -5.78781329e-02f, -1.27211437e-01f,
  -2.76959538e-01f, -2.37076823e-02f, -9.72464383e-02f, 1.88171521e-01f, 1.73083529e-01f, 4.43865620e-02f, 1.52439013e-01f, 1.51427194e-01f, 1.59374776e-03f, 2.87428424e-02f,
  -1.41662553e-01f, 6.32191598e-02f, 1.91175163e-01f, 6.89136833e-02f, -2.80395061e-01f, -1.08699583e-01f, -5.41600585e-02f, 3.34227711e-01f, 2.40955770e-01f, -1.95032328e-01f,
  3.34916785e-02f, -4.02023606e-02f, -1.44712210e-01f, -3.81845720e-02f, 1.63279742e-01f, 1.43030003e-01f, -1.19726986e-01f, 7.28793740e-02f, 2.48064741e-01f, -2.33634070e-01f,
  8.52335915e-02f, -5.32437228e-02f, -1.82430493e-03f, 1.02786951e-01f, 4.39092517e-02f, -3.32017569e-03f, 1.14624105e-01f, 1.66504905e-01f, 2.61974156e-01f, 8.72539729e-02f,
  2.54345071e-02f, 2.44505197e-01f, 8.63084421e-02f, 7.98930451e-02f, -4.91341278e-02f, 2.78051585e-01f, 6.78883344e-02f, -2.53573451e-02f, -1.35985434e-01f, 2.37111047e-01f,
  1.19782813e-01f, -2.70381253e-02f, 2.23724589e-01f, 1.99349105e-01f, 7.00874105e-02f, -1.61048830e-01f, 4.62667406e-01f, -2.28854686e-01f, 7.47271702e-02f, -1.27554119e-01f,
  -2.04115540e-01f, 1.15937218e-01f, -9.15976837e-02f, 2.50125885e-01f, 3.06632161e-01f, -2.66617924e-01f, 6.79982528e-02f, 3.87340449e-02f, 1.80422276e-01f, 4.82821435e-01f,
  1.25202447e-01f, 4.80750091e-02f, -1.93908691e-01f, -1.54674917e-01f, -2.74600685e-01f, 1.44256622e-01f, 1.08402688e-02f, -1.96784347e-01f, 8.09466764e-02f, 2.00477801e-02f,
  2.30769470e-01f, 3.30038756e-01f, -1.66459993e-01f, 3.21138576e-02f, -2.89215326e-01f, 1.55294076e-01f, 2.88331091e-01f, 7.05292225e-02f, 5.54978959e-02f, -1.11453347e-01f,
  -1.79974928e-01f, 2.87577182e-01f, 3.70510891e-02f, 2.00041488e-01f, -1.37088716e-01f, 1.09467879e-01f, 2.59418748e-02f, 7.95757920e-02f, 1.23199724e-01f, 6.51692897e-02f,
  7.38270953e-02f, 2.23269299e-01f, -2.16490120e-01f, 8.41849372e-02f, 1.16923504e-01f, 4.30067629e-02f, 5.53869829e-02f, -3.01194906e-01f, -1.13112405e-01f, -1.57914504e-01f,
  1.87929526e-01f, -1.69989094e-02f, -2.36522049e-01f, 3.17281410e-02f, 1.14468083e-01f, 5.64627759e-02f, 1.39429033e-01f, 1.33466303e-01f, -6.48822403e-03f, 1.01458974e-01f,
  -1.68285921e-01f, 1.40207499e-01f, 3.44078064e-01f, 1.38007626e-01f, 3.89195303e-03f, 6.84615448e-02f, 1.70198381e-01f, 2.01976538e-01f, 3.00231695e-01f, -6.42704889e-02f,
  -2.39301533e-01f, -1.11794665e-01f, -2.99709320e-01f, -4.63579446e-01f, -3.90393510e-02f, -3.67814712e-02f, 1.10627256e-01f, 1.58450514e-01f, 1.25265762e-01f, 1.28920466e-01f,
  5.87009750e-02f, 2.79822022e-01f, 2.78854281e-01f, -1.77434832e-01f, 4.01199788e-01f, -2.63606876e-01f, -1.87452249e-02f, -2.65401423e-01f, 3.64621818e-01f, 1.41425252e-01f,
  -3.82802904e-01f, 2.39321500e-01f, -2.51663804e-01f, -1.13554299e-01f, -7.24098384e-02f, -3.37049335e-01f, -1.31956497e-02f, -4.88424934e-02f, 1.29756004e-01f, -1.40983146e-02f,
  1.22572608e-01f, 2.06280574e-01f, 2.31556352e-02f, 1.26353636e-01f, 6.68241456e-02f, -3.10084224e-01f, 2.92954266e-01f, 2.64770061e-01f, 5.61152734e-02f, 2.52842735e-02f,
  4.73632701e-02f, 2.59401172e-01f, 6.39848709e-02f, -2.12009884e-02f, 1.52576283e-01f, 1.98787615e-01f, 1.81595117e-01f, -9.44541674e-03f, 1.21594638e-01f, 2.64827460e-01f,
  1.80622172e-02f, 4.66849245e-02f, 1.90259606e-01f, 5.09127341e-02f, -3.94461691e-01f, 1.27373800e-01f, -1.23615794e-01f, -4.78594080e-02f, -2.61647880e-01f, -2.10954815e-01f,
  -1.74064249e-01f, 1.34844631e-01f, -2.13396754e-02f, 2.43485510e-01f, -1.93226293e-01f, -3.54318857e-01f, 3.36978108e-01f, -1.78276896e-01f, -7.79725909e-02f, -2.59433299e-01f,
  1.65339410e-01f, -1.31825060e-01f, -1.10232361e-01f, -3.65855724e-01f, 2.71059535e-02f, 5.86408377e-02f, -2.93096274e-01f, 2.64537428e-02f, -5.01473956e-02f, -2.32551191e-02f,
  -1.89758748e-01f, 6.84532225e-02f, 1.14494748e-01f, -7.22167045e-02f, -1.12722859e-01f, 1.25311911e-01f, -5.51567972e-02f, 1.97487280e-01f, -2.06469014e-01f, -4.60117698e-01f,
  1.45057365e-01f, -1.15969501e-01f, 2.19870314e-01f, 8.76093358e-02f, 1.47443861e-01f, -4.46123853e-02f, -1.05915718e-01f, 4.40377705e-02f, -7.68107027e-02f, -2.38358542e-01f,
  1.73888102e-01f, 1.35881215e-01f, 2.47876987e-01f, 2.36998320e-01f, 3.66699845e-02f, 3.10555130e-01f, 1.19028710e-01f, -1.19562529e-01f, 8.76782462e-02f, 2.12258920e-01f,
  3.20336558e-02f, 6.73222542e-02f, -5.73979989e-02f, 1.20732337e-02f, 1.68221936e-01f, 1.07133828e-01f, 9.71095338e-02f, 1.67603895e-01f, 2.62658656e-01f, -1.82999849e-01f,
  1.77233189e-01f, -2.10986108e-01f, -9.08696428e-02f, -9.84375253e-02f, -1.03184834e-01f, -5.64016066e-02f, 1.11183198e-02f, -6.70742393e-02f, 1.25651941e-01f, 6.73554838e-02f,
  3.22169453e-01f, 2.03872800e-01f, 4.31720763e-01f, 8.97820443e-02f, -2.57201612e-01f, 3.99983190e-02f, 7.58143440e-02f, 1.62642598e-01f, 2.74282426e-01f, -1.76931754e-01f,
  -2.16258109e-01f, -2.30183885e-01f, -3.93135324e-02f, 3.51957798e-01f, -3.59815866e-01f, 6.19769990e-01f, 2.25362498e-02f, -1.33060843e-01f, 2.14309916e-01f, -1.08021453e-01f,
  2.76958168e-01f, -1.02132723e-01f, -1.47118000e-02f, 1.08927839e-01f, 1.73974991e-01f, -2.04261150e-02f, 1.04532972e-01f, 4.41435091e-02f, -4.95439731e-02f, -1.24212064e-01f,
  1.98550716e-01f, -1.28703460e-01f, 9.81657878e-02f, 1.69546567e-02f, 8.50419477e-02f, 2.09800020e-01f, 1.51859760e-01f, 1.44022182e-01f, 2.96479035e-02f, 3.37226570e-01f,
  1.18109606e-01f, 2.46915389e-02f, 2.19384924e-01f, 1.82789683e-01f, -2.37688944e-02f, 7.99301714e-02f, -4.13492173e-02f, 1.97944432e-01f, 4.42274548e-02f, -3.71167175e-02f,
  3.68655883e-02f, -2.57647084e-03f, 1.27594411e-01f, -9.38465223e-02f, -2.43456885e-01f, -2.11091321e-02f, 5.43284288e-04f, 2.34706953e-01f, 1.53563526e-02f, -1.95741788e-01f,
  1.16970986e-02f, -2.66648959e-02f, 2.11192481e-02f, 8.13318640e-02f, 1.28337309e-01f, 2.15265095e-01f, -1.15096182e-01f, -1.38999537e-01f, -8.55553597e-02f, -2.04029053e-01f,
  -1.76375255e-01f, -1.34647667e-01f, -4.12233658e-02f, 4.89414446e-02f, -8.97297710e-02f, 1.19360603e-01f, -3.74085754e-02f, 3.71976085e-02f, -9.37204137e-02f, -2.02851649e-02f,
  -2.65440512e-02f, 1.76758707e-01f, 3.93496267e-02f, 1.53240934e-01f, 1.09140508e-01f, 2.67786741e-01f, 6.92090690e-02f, -4.50204574e-02f, -1.40127704e-01f, 4.79012817e-01f,
  2.15875193e-01f, 1.19928584e-01f, 3.81527185e-01f, 7.90227428e-02f, -9.59972758e-03f, -1.86116528e-02f, 9.25679356e-02f, -2.10111052e-01f, 1.91092998e-01f, 1.47074729e-01f,
  1.05674967e-01f, 1.37040377e-01f, 3.41142148e-01f, 2.02756852e-01f, 4.43715453e-02f, 1.10665686e-01f, 1.02168463e-01f, 2.70846449e-02f, 1.14416361e-01f, 1.32714838e-01f,
  5.63702881e-02f, 1.64507449e-01f, 1.42336354e-01f, 3.49755324e-02f, -5.12586273e-02f, 9.57138017e-02f, 2.94573963e-01f, 8.10315683e-02f, 2.36951545e-01f, -1.14787430e-01f,
  1.56598344e-01f, -9.58889201e-02f, 6.46457821e-02f, -9.84733030e-02f, -2.04636380e-01f, -1.41416743e-01f, 1.36199668e-01f, 2.29573280e-01f, 1.76072136e-01f, -4.14272659e-02f,
  3.65515143e-01f, 1.91709965e-01f, -2.07917124e-01f, 6.80601895e-02f, 1.74254514e-02f, 3.84692639e-01f, 1.22672454e-01f, -6.19210154e-02f, -8.27943757e-02f, -1.27829596e-01f,
  -3.63778770e-02f, 4.40563738e-01f, -2.34836727e-01f, 2.46670052e-01f, -1.25483572e-01f, -2.45690510e-01f, 7.77899921e-02f, -2.12466687e-01f, 1.30480945e-01f, -3.07601571e-01f,
  -1.69070229e-01f, 1.21004112e-01f, 1.04234643e-01f, -4.11442250e-01f, 5.41320108e-02f, 1.37905225e-01f, 1.25049710e-01f, 1.48007572e-01f, 1.29754141e-01f, 2.55859017e-01f,
  5.15440591e-02f, 2.31116661e-03f, 3.67382132e-02f, 8.53589103e-02f, -4.24120575e-02f, 3.88095491e-02f, 1.53970137e-01f, -3.14486288e-02f, -1.04534097e-01f, 1.31981373e-01f,
  1.78034723e-01f, 3.28939855e-01f, 1.06792308e-01f, -1.82249591e-01f, 2.25555394e-02f, 4.38821176e-03f, -1.19141132e-01f, 4.37310264e-02f, 3.04975539e-01f, 9.09053162e-02f,
  -7.20417276e-02f, -8.78367722e-02f, 1.48783237e-01f, 7.57484883e-03f, 4.39713955e-01f, 5.29969446e-02f, -1.75009385e-01f, -4.64492202e-01f, -5.20793736e-01f, -1.36309862e-01f,
  -2.70723969e-01f, 5.73064573e-02f, -8.05777818e-05f, -1.87881872e-01f, -8.76675174e-02f, 1.01263642e-01f, 2.59060293e-01f, -1.87350199e-01f, -1.53092921e-01f, 9.59700495e-02f,
  1.07166708e-01f, 1.71584964e-01f, -1.83360875e-01f, 1.13276817e-01f, 4.70175475e-01f, 1.20556623e-01f, -1.10137321e-01f, -2.99516946e-01f, 3.08802277e-01f, 9.72063541e-02f,
  -1.59078404e-01f, 2.78416783e-01f, -2.74219960e-02f, 5.24560176e-02f, -1.25014797e-01f, 1.91460934e-03f, 2.99119771e-01f, 2.35312097e-02f, -1.81216955e-01f, 1.71479031e-01f,
  -3.54574732e-02f, 4.55632545e-02f, 1.78425640e-01f, -3.17510180e-02f, 7.03906268e-02f, 2.78115034e-01f, 1.04969725e-01f, 1.69424340e-01f, 1.18053205e-01f, -2.65399013e-02f,
  -6.90349517e-03f, 3.70270875e-03f, 2.02151209e-01f, 1.84641257e-02f, 1.74415439e-01f, 1.41496524e-01f, 1.27351470e-02f, 6.79708974e-05f, 1.12691455e-01f, 5.43244146e-02f,
  -1.12261668e-01f, 1.42337039e-01f, -5.62929995e-02f, 4.32335809e-02f, 4.11252901e-02f, -1.57230750e-01f, -9.31696445e-02f, 1.02158584e-01f, 7.33713210e-02f, -1.20577171e-01f,
  2.49741539e-01f, -1.33977428e-01f, -8.29438418e-02f, 3.45764011e-02f, 8.21532160e-02f, -3.80927436e-02f, -6.27157167e-02f, 1.13355324e-01f, -2.19915166e-01f, -8.24065655e-02f,
  -2.20724314e-01f, -1.62970811e-01f, -4.48571891e-03f, -2.33551726e-01f, 5.54531207e-03f, -2.03228611e-02f, -1.80854216e-01f, -4.57193628e-02f, 1.66889355e-01f, -7.45339319e-02f,
  2.37836525e-01f, 3.89906049e-01f, -3.93345147e-01f, -1.71940431e-01f, 5.32131076e-01f, -1.62753552e-01f, -4.44273174e-01f, -3.32650661e-01f, 2.04137281e-01f, 3.07075083e-01f,
  1.42945752e-01f, 2.38342676e-02f, -7.21758753e-02f, -4.41869870e-02f, -7.65467668e-03f, 5.94350398e-02f, 2.51661744e-02f, 1.50013372e-01f, -5.29409274e-02f, 3.74769024e-03f,
  8.63210410e-02f, 3.04019630e-01f, -3.30020078e-02f, 1.87630937e-01f, 9.84376743e-02f, 6.27323836e-02f, -1.39934272e-01f, 6.20404817e-02f, 3.44530493e-02f, 1.27521411e-01f,
  1.41789034e-01f, 6.72394857e-02f, 1.02305681e-01f, -1.39997033e-02f, 1.95662022e-01f, 1.31513774e-01f, 3.18416059e-02f, -1.50037557e-02f, 1.92077681e-01f, -3.95436771e-02f,
  7.92223066e-02f, -2.12787297e-02f, 2.39731729e-01f, 1.93025172e-01f, 3.37806810e-03f, -2.79028207e-01f, -1.04722064e-02f, -1.52799770e-01f, -9.86944586e-02f, 2.77810004e-02f,
  -1.84271466e-02f, -4.64758128e-02f, -1.73441142e-01f, 5.30414395e-02f, -9.08423960e-02f, -1.02147065e-01f, 6.72465190e-03f, 1.69098354e-03f, -9.87933651e-02f, -6.06440306e-02f,
  -2.41492733e-01f, 6.27102926e-02f, 4.11266275e-02f, 6.35712743e-02f, 1.85500413e-01f, -3.57919186e-01f, -3.54465023e-02f, 1.22233339e-01f, -2.70897504e-02f, 3.07848960e-01f,
  -4.89447005e-02f, 2.87385602e-02f, -2.12641999e-01f, 5.21349609e-01f, 1.29296467e-01f, 3.01608760e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.01098061e-01f, 1.13833986e-01f, 5.33789583e-02f, -1.25055566e-01f, 5.19518591e-02f, 1.21147789e-01f, 1.30091310e-01f, 3.94095592e-02f, 4.45345370e-03f, 1.63838461e-01f,
  -8.49170983e-03f, 1.26061395e-01f, 9.02417675e-03f, 9.58008170e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.02929273e-02f, -1.10247601e-02f, -1.65421948e-01f, 6.12623151e-03f, -5.31610176e-02f, 1.50728181e-01f, -8.93165320e-02f, 3.10578868e-02f, 8.47337433e-05f, -2.27558732e-01f,
  -6.66897148e-02f, 2.19731688e-01f, 2.95603257e-02f, 1.27907973e-02f, 3.29310745e-02f, 5.24475649e-02f, -1.07259065e-01f, 1.06856830e-01f, 7.78084770e-02f, 2.68576503e-01f,
  -5.82072698e-02f, 1.12533554e-01f, 9.19462591e-02f, -8.03064108e-02f, 1.14215799e-01f, 3.17264833e-02f, -2.05577791e-01f, 5.54309078e-02f, 2.82488316e-02f, -1.67817116e-01f,
  -2.18988396e-02f, 3.16328406e-02f, -1.92314461e-01f, 3.13231759e-02f, 1.79182544e-01f, 2.56142646e-01f, -1.47450313e-01f, 1.43099576e-01f, 1.92656428e-01f, 1.62115216e-01f,
  -1.82514951e-01f, -1.54486045e-01f, 2.36683324e-01f, 7.32911453e-02f, 4.29529548e-02f, 2.35074889e-02f, 1.93614766e-01f, -6.99234605e-02f, -6.01328053e-02f, -3.74277048e-02f,
  -1.18092120e-01f, 3.13656069e-02f, 2.87664890e-01f, -2.33598277e-01f, -8.11278448e-02f, 1.53253555e-01f, 4.10527922e-02f, -1.76287573e-02f, 1.81846380e-01f, -2.20020816e-01f,
  2.41551533e-01f, -2.48133436e-01f, -7.02320933e-02f, -2.10921913e-01f, 7.99877122e-02f, 6.05576895e-02f, 9.03009623e-02f, 9.93087292e-02f, -1.52412755e-03f, 3.92378829e-02f,
  -2.39961725e-02f, -1.56066671e-01f, 2.12021083e-01f, -1.58695295e-01f, -7.70785585e-02f, -8.01375732e-02f, -8.52549151e-02f, -7.44017065e-02f, -1.34017855e-01f, -7.31918886e-02f,
  9.70450346e-04f, -7.06902742e-02f, 8.96312483e-03f, -2.74189399e-03f, -1.27121225e-01f, -3.94608043e-02f, -1.73328698e-01f, 5.49953803e-02f, -1.26760960e-01f, 5.19221649e-02f,
  1.36128396e-01f, 2.82359987e-01f, -1.43053755e-01f, -2.89973021e-01f, -3.05845179e-02f, 8.10709074e-02f, -3.36473323e-02f, 1.24194838e-01f, -1.46812618e-01f, 4.11477722e-02f,
  3.94574344e-01f, -2.06688419e-02f, 2.70454660e-02f, -1.96173042e-01f, -1.81098774e-01f, 3.22724819e-01f, 8.46746936e-02f, 1.66240975e-01f, 7.37502845e-03f, -3.26169014e-01f,
  4.74638119e-02f, 2.04092383e-01f, -7.24539682e-02f, -1.97826605e-02f, 3.37005258e-01f, 1.09344296e-01f, -1.45260796e-01f, -1.05860136e-01f, 2.27125540e-01f, -5.61824776e-02f,
  -5.40919006e-02f, -1.85278475e-01f, -2.93494612e-02f, -2.32098550e-02f, 1.18184790e-01f, -2.47930605e-02f, 9.71626267e-02f, 1.62743405e-01f, 9.70804021e-02f, -3.96287516e-02f,
  1.63731277e-01f, 1.52165338e-01f, 1.71547562e-01f, 9.91190039e-03f, 6.99022934e-02f, 3.02932441e-01f, -3.38874847e-01f, -7.08130673e-02f, -9.11001787e-02f, -7.22562671e-02f,
  3.47064026e-02f, 4.63808738e-02f, -9.98600051e-02f, 1.22329623e-01f, -2.89181918e-01f, 2.45089978e-01f, 4.71368320e-02f, 3.35562140e-01f, -1.86591223e-02f, 8.14454071e-03f,
  1.59383208e-01f, 1.67353079e-01f, -7.89825097e-02f, -4.73247245e-02f, 3.61550122e-01f, 9.27134827e-02f, -1.82446033e-01f, -2.09600270e-01f, -1.19394064e-01f, -1.86005328e-02f,
  -6.29452318e-02f, 2.89163083e-01f, 1.38867304e-01f, 1.70962840e-01f, 9.12237763e-02f, 7.50655681e-02f, 7.15443492e-02f, -1.24711059e-01f, 1.32753104e-01f, -8.42347816e-02f,
  -2.01204270e-01f, -1.81733415e-01f, -9.10616890e-02f, -1.59153998e-01f, 2.91560203e-01f, -6.49295328e-03f, 9.28537920e-02f, 1.11795254e-01f, -1.19410403e-01f, 8.41040611e-02f,
  1.15803167e-01f, 9.57131982e-02f, 2.76473373e-01f, 5.69138713e-02f, -2.56380439e-01f, -1.77327171e-02f, -7.20448792e-02f, 1.80260301e-01f, 1.97116002e-01f, -1.37385175e-01f,
  1.45158008e-01f, 1.15910120e-01f, -1.02321934e-02f, -2.11648121e-01f, -1.95876852e-01f, -2.38620266e-01f, -1.26721915e-02f, -1.66744739e-02f, 6.89800009e-02f, 4.65218015e-02f,
  -5.55137284e-02f, 2.30498180e-01f, -8.92833900e-03f, -1.22203164e-01f, 1.57225251e-01f, 1.33882150e-01f, 1.41550511e-01f, 1.86221097e-02f, 1.43134808e-02f, -2.80717790e-01f,
  2.94359773e-02f, -7.24545866e-02f, 1.82952464e-01f, -1.28422409e-01f, 7.38262236e-02f, 2.19386190e-01f, 5.79341017e-02f, -1.76092915e-04f, 1.02229834e-01f, -3.04857731e-01f,
  -1.63092375e-01f, 4.14952964e-01f, -1.27326176e-01f, -3.18276644e-01f, 1.72138944e-01f, 2.70021886e-01f, -8.30421299e-02f, -3.11349034e-01f, -2.41597205e-01f, 1.51645541e-01f,
  2.45618641e-01f, 2.24134177e-01f, -1.08121321e-01f, -3.63610908e-02f, 1.74199734e-02f, -1.24021389e-01f, 1.70382395e-01f, 2.79438645e-02f, -1.67875931e-01f, -3.18862975e-01f,
  -1.18773259e-01f, -3.10185365e-03f, -7.03815073e-02f, -1.33530647e-01f, 1.57746524e-01f, 1.21796414e-01f, -4.35103439e-02f, -8.38897377e-02f, 1.39088899e-01f, 1.91431776e-01f,
  -1.59616962e-01f, -7.10514635e-02f, -1.37021720e-01f, 1.35661364e-01f, -7.54796155e-03f, 5.82765117e-02f, -3.92790347e-01f, -3.27131450e-01f, -9.79760438e-02f, 1.42383128e-01f,
  1.02889530e-01f, 4.99890782e-02f, -1.79346219e-01f, -2.22314954e-01f, 3.38341412e-03f, 1.28435671e-01f, -3.41778845e-01f, -9.24749821e-02f, -1.98910147e-01f, -5.73877506e-02f,
  3.65888104e-02f, -1.56166375e-01f, 1.15676031e-01f, -1.24671392e-01f, -1.86565116e-01f, -7.26175010e-02f, 6.50697798e-02f, -2.05704853e-01f, -1.88024357e-01f, -1.43569857e-01f,
  -3.01744670e-01f, 1.31961226e-01f, -2.13769466e-01f, 4.58483920e-02f, -1.71152398e-01f, 9.01806355e-03f, -3.19316685e-01f, 3.21578503e-01f, 1.24715634e-01f, 5.49729168e-02f,
  -1.44962603e-02f, 1.74117222e-01f, -8.16149823e-03f, 2.34738111e-01f, -6.60655722e-02f, 8.69468134e-03f, 1.68983757e-01f, -2.63141870e-01f, -6.88595604e-03f, -2.11334631e-01f,
  1.84303418e-01f, -1.07509173e-01f, -1.33322135e-01f, 9.00906101e-02f, 2.45161280e-02f, -3.06224059e-02f, 3.74261886e-02f, 2.28681147e-01f, 2.62636155e-01f, 1.32839367e-01f,
  1.41176004e-02f, -3.76533084e-02f, -2.11973354e-01f, -1.90567777e-01f, 1.30203560e-01f, 1.12474523e-01f, -2.63209697e-02f, -8.68531242e-02f, 2.57180393e-01f, -3.40786912e-02f,
  -6.22826479e-02f, -4.11976695e-01f, -2.77106259e-02f, 2.20922887e-01f, -7.50555843e-02f, 2.17850357e-02f, -3.07553500e-01f, -1.21806033e-01f, 2.25828782e-01f, 8.25050250e-02f,
  1.36985585e-01f, -5.16893975e-02f, 2.79821153e-03f, -1.66194066e-01f, -1.64712295e-01f, -6.37847260e-02f, 5.33109792e-02f, -1.66407883e-01f, -7.48816580e-02f, 2.53462434e-01f,
  9.22092143e-03f, 1.67977065e-03f, -4.67039160e-02f, -2.16208205e-01f, -1.27667725e-01f, -3.98441739e-02f, -3.15676749e-01f, 4.70369272e-02f, 1.83154985e-01f, 7.69127831e-02f,
  1.04374103e-01f, -8.37915465e-02f, -1.70617625e-01f, -1.65145859e-01f, 7.06126913e-02f, 4.64220494e-02f, -1.01047948e-01f, 2.68619537e-01f, 2.27400251e-02f, 2.61913866e-01f,
  -9.59991571e-03f, -3.62336099e-01f, -2.12868117e-02f, 9.92275625e-02f, -7.31688514e-02f, 3.39664221e-02f, -1.54377773e-01f, 4.82935905e-02f, -6.86691999e-02f, 2.59418637e-02f,
  2.30745077e-02f, -6.06353059e-02f, 4.69738841e-02f, -2.56543700e-02f, -1.90548182e-01f, -8.76339823e-02f, 8.75495523e-02f, 2.35485077e-01f, 1.68989643e-01f, 3.77956852e-02f,
  -4.89531942e-02f, 3.12677138e-02f, 1.17540859e-01f, -2.76667267e-01f, 1.35753013e-03f, 1.02358438e-01f, -1.98544279e-01f, 7.36057907e-02f, 1.23274863e-01f, -2.31803447e-01f,
  2.98296493e-02f, 1.03956550e-01f, -2.39530951e-01f, -1.25518814e-01f, -2.31032625e-01f, 2.13085040e-02f, 4.62416410e-02f, 3.96754332e-02f, -8.39134492e-03f, -1.56373084e-02f,
  -7.40607083e-02f, 1.82823598e-01f, 1.77530721e-01f, 2.16942221e-01f, -1.21792272e-01f, 4.53144014e-02f, -5.21676755e-03f, 6.05964139e-02f, -1.53559387e-01f, -3.25804129e-02f,
  2.56414730e-02f, 2.53736734e-01f, -1.50992975e-01f, -1.71983987e-01f, -3.88053536e-01f, -5.46110310e-02f, -3.30213070e-01f, 1.69634461e-01f, 1.95258558e-01f, 5.61156869e-02f,
  -2.52971411e-01f, 1.21228835e-02f, 6.87902346e-02f, 4.61501554e-02f, -2.66092047e-02f, 1.05435461e-01f, -1.99684128e-02f, -2.78128255e-02f, 1.08449817e-01f, -2.79056251e-01f,
  4.11294878e-01f, -1.22874349e-01f, -1.79129675e-01f, -1.96005441e-02f, 7.10885087e-03f, 1.17319211e-01f, 2.70787567e-01f, 8.69684070e-02f, 2.56724089e-01f, -1.52989343e-01f,
  -2.50720561e-01f, -7.66491964e-02f, -8.29775035e-02f, -3.00029740e-02f, 6.23476841e-02f, -2.32954860e-01f, -1.32548690e-01f, 7.95124620e-02f, 3.27554107e-01f, -2.59732679e-02f,
  -1.78275362e-01f, -1.51014868e-02f, 7.61024430e-02f, 5.25705814e-02f, -1.03837922e-01f, -6.79686069e-02f, -2.36414187e-02f, 2.52036124e-01f, -7.21943676e-02f, 2.46677414e-01f,
  1.18136488e-01f, 1.99589178e-01f, -9.88435932e-03f, -2.27274336e-02f, 3.27462070e-02f, -1.73050556e-02f, 5.52582443e-02f, 3.87042761e-01f, -7.34968169e-04f, -1.57540843e-01f,
  6.48032594e-03f, 3.16654108e-02f, 2.88998727e-02f, 1.63310796e-01f, -1.22155190e-01f, 3.07733174e-02f, 2.23827839e-01f, -5.59055954e-02f, -3.70880030e-02f, -3.41359735e-01f,
  -1.34299556e-02f, 1.29598260e-01f, 1.79507926e-01f, 9.28489566e-02f, -8.61746892e-02f, 1.07831240e-01f, 2.91258991e-01f, 2.68178552e-01f, -2.91939497e-01f, 3.56854767e-01f,
  2.03225657e-01f, 3.76494795e-01f, -2.64832318e-01f, -4.90596704e-02f, -2.09134772e-01f, -1.24542722e-02f, -2.85330471e-02f, 1.71413511e-01f, 1.66494593e-01f, 4.31424975e-02f,
  5.39251231e-02f, 1.24868400e-01f, 9.58106890e-02f, -3.83438319e-02f, 3.19184840e-01f, -3.70318145e-02f, -1.52232200e-01f, -8.15174356e-02f, -9.39720273e-02f, -2.25844204e-01f,
  -1.22232564e-01f, 9.48765129e-02f, 2.16715783e-01f, 1.24464765e-01f, -1.04397207e-01f, 1.15505479e-01f, 6.34140149e-02f, -1.45709038e-01f, 2.44245395e-01f, 7.74725452e-02f,
  -5.17548136e-02f, -2.06389382e-01f, -1.24115378e-01f, 1.94515958e-01f, -4.21699509e-02f, -1.05002008e-01f, 1.33189470e-01f, 2.98322029e-02f, -4.00191406e-03f, 2.38242615e-02f,
  3.68779808e-01f, 2.01055393e-01f, 4.08641770e-02f, 4.28662688e-01f, 2.11609617e-01f, 1.18137807e-01f, 1.13455709e-02f, -2.20446754e-02f, 1.67326614e-01f, 2.39860803e-01f,
  -5.19178025e-02f, -2.05850109e-01f, -2.37654045e-01f, -1.11725843e-02f, -2.06030965e-01f, 1.87999159e-01f, 1.42324701e-01f, -2.34457061e-01f, -1.60447985e-01f, -6.46351576e-02f,
  2.83388853e-01f, 6.51274174e-02f, -5.35939038e-02f, 2.48656765e-01f, 5.83433919e-02f, 1.68170348e-01f, 2.05586061e-01f, -6.13622740e-03f, 1.20972261e-01f, 1.05283014e-01f,
  4.93357703e-02f, -3.98704596e-03f, -4.09443900e-02f, -1.77256223e-02f, 4.38574180e-02f, 9.37525369e-03f, 3.37337375e-01f, -1.90793738e-01f, -3.44929099e-02f, 1.26765907e-01f,
  1.07690513e-01f, -1.35811985e-01f, 2.19198704e-01f, -7.80614391e-02f, -1.16974264e-01f, -3.86920273e-02f, -4.28443819e-01f, 4.34299409e-02f, -2.24625528e-01f, -3.16886716e-02f,
  6.29360825e-02f, -1.30577087e-01f, -5.99709637e-02f, -6.32456467e-02f, 3.04675758e-01f, -6.55535161e-02f, 1.47405848e-01f, 3.47911119e-02f, 1.95073336e-01f, 1.13708429e-01f,
  1.21526167e-01f, 2.71073170e-02f, 1.29158482e-01f, 1.52378246e-01f, -1.84156805e-01f, -1.60543054e-01f, 2.18420297e-01f, -1.18707283e-03f, -1.30003974e-01f, -1.26598505e-02f,
  -1.15640931e-01f, 2.77940214e-01f, -2.33751804e-01f, -1.27280131e-01f, -4.83204005e-03f, 2.40118906e-01f, 8.70841593e-02f, 1.22297384e-01f, 7.92127401e-02f, -2.99445242e-01f,
  -5.18516302e-02f, -1.75419763e-01f, -1.69965431e-01f, -1.28253296e-01f, 2.12150067e-01f, 2.74662763e-01f, 1.34783402e-01f, -2.91475326e-01f, 4.05335650e-02f, -8.15526769e-02f,
  1.70911327e-02f, 1.03776462e-01f, -1.20495953e-01f, -2.56639779e-01f, -6.88387454e-02f, -1.89315140e-01f, 1.17195122e-01f, -4.86757345e-02f, 1.75517753e-01f, -1.03753798e-01f,
  8.40368643e-02f, -1.35296807e-01f, 2.53906935e-01f, 6.96613938e-02f, -1.55242994e-01f, 2.56421641e-02f, -1.67369232e-01f, 9.62554812e-02f, 8.78389031e-02f, -1.53067112e-01f,
  -1.35729834e-01f, -2.90793031e-01f, -5.26724756e-03f, -1.25627816e-01f, -1.37856632e-01f, -5.08680679e-02f, -7.10784346e-02f, -2.82854259e-01f, 1.39277980e-01f, 2.85522848e-01f,
  6.72843680e-02f, -2.52158910e-01f, 8.23899657e-02f, 1.14334181e-01f, -3.04909945e-01f, -2.28887916e-01f, -6.47478476e-02f, -2.80659139e-01f, -1.34096712e-01f, -4.80888002e-02f,
  1.18381776e-01f, -1.80265293e-01f, -3.18432689e-01f, -2.17821255e-01f, -7.05722719e-02f, -5.85116446e-02f, -2.10386842e-01f, -2.22888902e-01f, 1.49047941e-01f, 1.58295453e-01f,
  -4.65579368e-02f, 6.67729825e-02f, 1.10214598e-01f, -3.70405577e-02f, -1.14016309e-01f, 4.32144627e-02f, 3.84215638e-02f, 1.47275804e-02f, -2.18864486e-01f, 6.88981786e-02f,
  8.78000781e-02f, -2.82006085e-01f, 4.25151512e-02f, -3.20404142e-01f, -2.04329595e-01f, -8.36616307e-02f, -1.44459143e-01f, -2.30245069e-02f, -4.36251014e-02f, -9.14967880e-02f,
  4.57993969e-02f, 7.91770741e-02f, 1.13257483e-01f, -8.50024745e-02f, -5.65641001e-02f, -1.55080348e-01f, 1.97148994e-01f, 2.57996228e-02f, -1.08274519e-01f, 6.27288595e-02f,
  -2.03897744e-01f, 4.24852222e-02f, 1.57357514e-01f, -9.72926393e-02f, 1.79136202e-01f, 9.00209174e-02f, -7.26363212e-02f, -1.41512454e-01f, -1.52736485e-01f, 2.85247136e-02f,
  3.01022362e-02f, -3.39079723e-02f, -1.96216658e-01f, -7.54241198e-02f, -3.06088440e-02f, 7.78901353e-02f, 1.28098696e-01f, -7.17952922e-02f, 5.84262870e-02f, -1.54924300e-02f,
  -1.67193219e-01f, 3.78731519e-01f, 1.94207385e-01f, 5.70763275e-02f, 5.79393208e-02f, 1.61783338e-01f, 4.51719314e-02f, 8.39579031e-02f, 2.73804992e-01f, 3.03319484e-01f,
  2.10875303e-01f, -1.74586833e-01f, -1.84077919e-01f, 2.22296298e-01f, -2.31915750e-02f, -1.33000031e-01f, -1.07627297e-02f, 2.66841352e-01f, 1.77465633e-01f, -3.91473919e-02f,
  -3.69939283e-02f, 5.51501065e-02f, 1.45480812e-01f, 2.94968605e-01f, -1.21562034e-01f, 3.37706476e-01f, 1.33916557e-01f, 1.45944878e-01f, 1.14958331e-01f, -1.75825581e-01f,
  7.70880654e-02f, -1.29855916e-01f, -6.12457469e-03f, 1.73123583e-01f, -6.20714538e-02f, -2.02863291e-01f, 1.86438009e-01f, 1.00341486e-03f, -3.07420995e-02f, -7.69566894e-02f,
  -3.20794880e-02f, 1.44624725e-01f, -1.16174571e-01f, -2.59579569e-01f, -1.20381363e-01f, 1.06333435e-01f, -1.52622871e-02f, 1.82847470e-01f, 2.61097010e-02f, 2.90799111e-01f,
  -3.45098883e-01f, 4.54820469e-02f, -1.34777548e-02f, -1.73792809e-01f, -9.06938501e-03f, 4.04577553e-02f, 4.10309248e-03f, 4.70894873e-02f, -6.08367957e-02f, 1.85911939e-01f,
  1.69803545e-01f, 3.37299526e-01f, 1.54861450e-01f, 1.07244104e-01f, -9.14605334e-03f, 3.00557077e-01f, 1.53995156e-01f, -8.98250490e-02f, 2.33045369e-02f, -1.73261035e-02f,
  -5.58273569e-02f, -1.75619852e-02f, 2.35869922e-02f, 4.05161589e-01f, -2.06034645e-01f, -2.30696108e-02f, -3.49537246e-02f, -6.44080192e-02f, -2.63731152e-01f, 1.56753749e-01f,
  1.88583523e-01f, 6.10731095e-02f, 1.20431565e-01f, -1.38719574e-01f, -9.05279517e-02f, -2.64432877e-01f, 2.43071645e-01f, 8.24750960e-02f, -4.16019447e-02f, -9.59414840e-02f,
  4.27681506e-02f, 1.77573532e-01f, 1.52983427e-01f, 1.99044317e-01f, -9.25280899e-02f, -9.31209046e-03f, -1.08895414e-01f, -1.20007969e-01f, 1.64869368e-01f, 4.33006808e-02f,
  2.36184344e-01f, -4.44569485e-03f, 1.95583135e-01f, -1.28666833e-01f, 8.27602595e-02f, -2.88110133e-02f, -2.27118835e-01f, -4.07134295e-02f, 6.04910078e-03f, 1.79510131e-01f,
  -9.74745899e-02f, 1.64546281e-01f, 1.53045086e-02f, -3.93621065e-02f, 1.88097525e-02f, 1.35324821e-01f, -1.29750237e-01f, -5.62404506e-02f, -1.37875706e-01f, 9.32597592e-02f,
  -2.01741919e-01f, 2.51758397e-01f, -4.01365161e-02f, 1.38948441e-01f, -1.28995609e-02f, 1.54167265e-01f, 3.28631461e-01f, -4.13055196e-02f, 4.33674678e-02f, 2.05429807e-01f,
  7.43087977e-02f, 1.76616356e-01f, -1.32069439e-01f, 3.20351958e-01f, -1.94150925e-01f, -4.93173786e-02f, -1.34622812e-01f, 1.70537040e-01f, -8.15757439e-02f, 1.39531031e-01f,
  3.79990071e-01f, -8.63447040e-02f, -1.80609658e-01f, 5.78004159e-02f, -1.23431146e-01f, 2.28460044e-01f, 6.22152835e-02f, -2.82261848e-01f, -1.29311368e-01f, -2.55262274e-02f,
  1.71216011e-01f, -2.24570632e-02f, -1.58446759e-01f, -1.06251441e-01f, 3.74763399e-01f, -9.11283121e-02f, 2.57598191e-01f, -1.04672626e-01f, 1.67733133e-01f, -7.83561990e-02f,
  2.39730775e-01f, -7.56465655e-04f, -3.11773837e-01f, -3.45178425e-01f, -5.05187586e-02f, 4.00228091e-02f, -3.98351364e-02f, -1.44102901e-01f, 2.98625324e-02f, 5.81213422e-02f,
  1.56826228e-02f, -1.61407545e-01f, 1.54898971e-01f, 3.00719887e-01f, -2.13044971e-01f, -1.41038775e-01f, 1.85084447e-01f, 5.05561344e-02f, 2.03989998e-01f, -3.04903388e-02f,
  -2.44353022e-02f, 7.46801198e-02f, -7.08575249e-02f, 1.01429850e-01f, 1.24189138e-01f, 4.29213606e-02f, 1.71953529e-01f, 1.32140920e-01f, 1.25518322e-01f, 1.46631569e-01f,
  5.92796840e-02f, 1.20885417e-01f, 6.55342937e-02f, -2.04785377e-01f, -1.45066604e-01f, 2.92712916e-02f, 4.79475148e-02f, 6.94868341e-02f, 2.65196890e-01f, 1.24940671e-01f,
  2.56063282e-01f, -1.19290277e-01f, 9.66120213e-02f, -6.83460161e-02f, 2.02454597e-01f, 3.13919336e-01f, 1.77834615e-01f, -2.53670007e-01f, -1.08227268e-01f, -1.20881170e-01f,
  1.32108435e-01f, 3.30711603e-02f, -1.80646200e-02f, 9.63149667e-02f, 2.11107776e-01f, 2.25381419e-01f, -1.54564515e-01f, 4.43548374e-02f, 9.03240871e-03f, 1.23943545e-01f,
  -1.72689721e-01f, 8.19988251e-02f, -1.48322970e-01f, -2.30877146e-01f, -1.00706942e-01f, -6.65652519e-03f, 1.04178833e-02f, -1.79015383e-01f, -1.82293747e-02f, 6.92503452e-02f,
  -1.51033163e-01f, 9.49120224e-02f, 2.25286067e-01f, 1.65598139e-01f, 4.88899089e-02f, 1.13563195e-01f, -6.51596040e-02f, -7.24680796e-02f, -3.44676882e-01f, -5.37856407e-02f,
  -1.81582868e-01f, 1.21836007e-01f, 8.04239826e-05f, -6.61507100e-02f, 1.14955537e-01f, 7.78148845e-02f, 3.25554311e-02f, 5.78900799e-02f, -2.30523869e-01f, -2.75514871e-02f,
  -1.77126184e-01f, 2.74624318e-01f, 5.43130413e-02f, 3.68158907e-01f, 8.16054046e-02f, 1.29485548e-01f, -4.94453171e-03f, 3.48540954e-02f, 1.84456930e-01f, 1.69811230e-02f,
  7.05374405e-02f, -3.60995159e-02f, 1.22413374e-01f, 5.39518520e-02f, -2.49647036e-01f, 1.27224671e-02f, -4.34487872e-02f, -1.82073176e-01f, -2.69080073e-01f, 1.54551864e-01f,
  8.29241574e-02f, 6.35157004e-02f, 1.66046694e-01f, -5.28984740e-02f, -6.08079648e-03f, -1.44382760e-01f, -2.51063228e-01f, 1.56048909e-01f, 1.77372217e-01f, 5.87840788e-02f,
  2.15482544e-02f, -4.26907130e-02f, 1.32303521e-01f, -9.20166075e-02f, 4.94018085e-02f, 1.99860305e-01f, -3.67115527e-01f, -6.03193715e-02f, 6.40592203e-02f, 8.76374394e-02f,
  -1.22467719e-01f, 1.51818171e-01f, 3.01472783e-01f, -9.18521285e-02f, 1.42813832e-01f, -1.72446683e-01f, 1.56677529e-01f, 2.00802147e-01f, -7.47338235e-02f, -1.39983237e-01f,
  -1.72125816e-01f, 8.45757034e-03f, 3.12418789e-02f, 1.65572315e-01f, -7.14444667e-02f, -1.28425524e-01f, 4.06114101e-01f, -9.86707956e-02f, 2.37844214e-01f, 2.54781514e-01f,
  1.84487104e-01f, 1.09004706e-01f, 4.38047908e-02f, -1.54835612e-01f, -4.30625118e-02f, 1.39360949e-01f, 8.86648297e-02f, 1.23278163e-02f, 9.18145478e-02f, 8.20437148e-02f,
  -7.05131069e-02f, -1.52097559e-02f, 1.52247593e-01f, -1.94037929e-01f, 7.86463693e-02f, 9.35849696e-02f, 1.81202352e-01f, 1.19858049e-01f, 3.09823096e-01f, 2.90967822e-02f,
  4.06740427e-01f, -2.18994617e-01f, -1.17497198e-01f, 3.20736527e-01f, 7.92003423e-02f, 1.69214164e-03f, 1.37947232e-01f, -1.49912059e-01f, 1.95359848e-02f, 1.71083391e-01f,
  -1.37164250e-01f, 2.10053295e-01f, 1.12230591e-01f, 5.37412539e-02f, 1.07493445e-01f, -1.28476217e-01f, -1.54356509e-01f, -1.32662341e-01f, 2.84878928e-02f, 3.16739351e-01f,
  1.03370853e-01f, -2.88475364e-01f, -8.24441463e-02f, -2.55045235e-01f, -1.13054648e-01f, -1.07567534e-01f, 1.75187692e-01f, -5.68068996e-02f, -1.59062594e-01f, 1.50466874e-01f,
  3.05328798e-02f, 1.28789753e-01f, 1.12339631e-01f, 1.99876428e-01f, -9.23735425e-02f, -8.56518820e-02f, -4.24396899e-03f, -8.98888037e-02f, -2.82978751e-02f, 1.88236177e-01f,
  -1.68257207e-01f, 3.30581933e-01f, -8.16063732e-02f, 3.54866013e-02f, 1.74353555e-01f, 1.56314835e-01f, -4.41273414e-02f, 1.71874166e-01f, -1.89457789e-01f, 1.61294654e-01f,
  2.39631850e-02f, 1.29540816e-01f, 3.78973819e-02f, 6.07397147e-02f, -8.45119916e-03f, 1.44242376e-01f, -6.61993697e-02f, 2.85104722e-01f, -3.13095488e-02f, 1.98594794e-01f,
  2.63147075e-02f, 2.48659596e-01f, -2.65537888e-01f, -9.08686221e-02f, -1.73322737e-01f, 1.42811865e-01f, 1.79255038e-01f, -1.70336533e-02f, -1.19477734e-01f, 1.70870706e-01f,
  6.05992489e-02f, -1.85290948e-01f, 6.27996996e-02f, -1.72216102e-01f, -2.90870219e-02f, -7.34530913e-04f, 1.77225694e-02f, 1.22182220e-01f, 5.69941066e-02f, -5.53434379e-02f,
  -1.59268051e-01f, 8.57866555e-03f, 1.15403779e-01f, -1.19224243e-01f, 4.56208177e-02f, 2.62734131e-03f, 3.22766930e-01f, 2.30339579e-02f, -9.69921350e-02f, -2.58459508e-01f,
  3.92841958e-02f, 2.43991256e-01f, 1.46441802e-01f, -2.45153129e-01f, -1.53012112e-01f, 2.62044370e-01f, 1.78754508e-01f, 1.28487557e-01f, 1.15541443e-01f, 1.42153874e-01f,
  -2.08013445e-01f, -9.61800218e-02f, 1.16336145e-01f, -1.56126842e-01f, -8.61969441e-02f, 1.37879159e-02f, -1.42908603e-01f, 1.68683045e-02f, -6.57564728e-03f, -1.67862326e-01f,
  3.30010980e-01f, -1.17232256e-01f, 4.59421575e-02f, -2.06035718e-01f, 5.82422353e-02f, -2.31803298e-01f, -2.22868264e-01f, -9.60982516e-02f, 1.09006993e-01f, -3.78767811e-02f,
  -1.93140030e-01f, -2.27121755e-01f, 2.28301119e-02f, -9.28259268e-02f, -5.58510050e-02f, -1.45148262e-01f, 1.08305793e-02f, 4.24243212e-02f, -8.41665268e-03f, 1.05039403e-01f,
  -6.52133822e-02f, -2.41479471e-01f, -6.17465237e-03f, 1.20146126e-01f, 1.10629007e-01f, -5.99631704e-02f, -2.66794622e-01f, -1.02963792e-02f, 2.91804194e-01f, -5.30380532e-02f,
  -2.18958527e-01f, -3.30852270e-01f, -9.17504877e-02f, 1.21853966e-02f, 7.71475374e-04f, -2.31185779e-01f, 1.84820201e-02f, -2.90849209e-01f, 9.64868367e-02f, 2.30452195e-01f,
  6.35198206e-02f, 3.40965725e-02f, 5.99881001e-02f, 1.53468754e-02f, -2.13729858e-01f, -1.92241669e-01f, 1.11795157e-01f, 2.39530932e-02f, -2.54732035e-02f, -1.85543716e-01f,
  -5.30310422e-02f, -1.94167674e-01f, 9.97634903e-02f, 1.44588888e-01f, 9.43111032e-02f, 7.89772198e-02f, 7.23928493e-03f, 7.08372816e-02f, 1.63459569e-01f, -7.30899274e-02f,
  1.08139776e-01f, 1.64805397e-01f, -1.02466844e-01f, 2.07203448e-01f, -2.00762019e-01f, -9.69783664e-02f, 2.58496236e-02f, -3.20499507e-03f, 7.77302235e-02f, -1.66268438e-01f,
  8.91744196e-02f, -2.28239573e-03f, -6.81089759e-02f, -1.90869451e-01f, -2.60066897e-01f, -6.06841482e-02f, -1.52404122e-02f, -1.69448435e-01f, 4.08555955e-01f, 1.87844306e-01f,
  -1.90536618e-01f, 7.69060687e-04f, 2.93135077e-01f, 1.44450307e-01f, -1.30064264e-01f, 2.16071755e-02f, 8.36647376e-02f, -3.59815359e-01f, -1.01472385e-01f, 6.83326349e-02f,
  2.17554979e-02f, -1.84082575e-02f, 1.67014092e-01f, 5.34900986e-02f, 1.00518696e-01f, -5.18326759e-02f, 1.54734984e-01f, 3.46223637e-02f, 7.25921243e-02f, -4.23078798e-02f,
  -3.68914790e-02f, -2.18267530e-01f, 2.09110633e-01f, 7.38894716e-02f, -8.46415684e-02f, 2.14596078e-01f, -4.83813174e-02f, -8.50392431e-02f, -2.77851194e-01f, 6.28076866e-02f,
  2.09971368e-01f, 3.40719745e-02f, -2.09713653e-01f, -8.55153352e-02f, 6.58494905e-02f, 2.61698142e-02f, 1.81037962e-01f, 1.73437446e-02f, -6.95710778e-02f, 2.08890215e-01f,
  1.12871259e-01f, 2.08601996e-01f, 1.67445809e-01f, 1.56302806e-02f, -1.07831182e-02f, -7.23982230e-02f, 1.21294722e-01f, 2.42928252e-01f, -6.66637048e-02f, -1.92210704e-01f,
  2.24386424e-01f, 1.30741715e-01f, 7.34271929e-02f, 2.31433392e-01f, 1.97161555e-01f, 1.66418940e-01f, -6.97892904e-02f, 7.80918300e-02f, 3.14733274e-02f, 3.72135825e-02f,
  5.13687581e-02f, 1.78011358e-01f, 6.83874860e-02f, 7.35375658e-02f, 2.07821101e-01f, -2.04738006e-01f, 6.21860400e-02f, -7.94920325e-02f, 1.43384621e-01f, 2.60469615e-01f,
  1.56448677e-01f, -4.08285158e-03f, -1.37322411e-01f, -9.42249820e-02f, 1.35032147e-01f, -8.88072327e-02f, -1.71383262e-01f, 1.48177803e-01f, 1.63361326e-01f, -3.14401425e-02f,
  -5.68499044e-02f, -4.30697203e-02f, 3.07089672e-03f, 8.43298733e-02f, -1.64830506e-01f, 2.23853379e-01f, -1.36990445e-02f, -2.31526032e-01f, -2.54222807e-02f, -4.92313951e-02f,
  -3.01720232e-01f, -2.66962051e-01f, -5.06650656e-02f, 7.35767409e-02f, 8.53776112e-02f, 6.66246861e-02f, -1.94957517e-02f, 2.59236962e-01f, -2.73434888e-03f, -8.27195197e-02f,
  -1.11918144e-01f, -3.69774364e-02f, -2.70371944e-01f, -1.12901523e-03f, 1.47905484e-01f, -4.82120663e-01f, 2.03134492e-01f, -2.72869408e-01f, -9.46267098e-02f, -1.29041091e-01f,
  -9.08666775e-02f, -2.38220751e-01f, -7.46987090e-02f, -4.21551522e-03f, -1.15197577e-01f, -1.77518710e-01f, -1.04006819e-01f, -2.86933988e-01f, -2.94576615e-01f, -7.44327977e-02f,
  1.37329642e-02f, -3.27498645e-01f, 2.50322193e-01f, 3.36448327e-02f, 2.57770628e-01f, 2.28876770e-02f, 2.36534551e-01f, 1.36111304e-01f, 4.21256386e-02f, -3.12496096e-01f,
  1.13755472e-01f, -5.87074868e-02f, 6.35314093e-04f, 1.95078820e-01f, 1.17180489e-01f, -7.34434724e-02f, 3.02568153e-02f, 1.77801643e-02f, -2.54663378e-01f, -2.26240931e-03f,
  -1.86049715e-01f, 3.00355643e-01f, -1.79793760e-02f, 1.76869556e-01f, -1.84009179e-01f, 1.31821483e-01f, -1.83867440e-01f, -1.53029338e-01f, 9.24585313e-02f, -8.75459909e-02f,
  -1.32473990e-01f, 4.08041328e-02f, 1.77117541e-01f, -1.40045539e-01f, -1.86540827e-01f, 5.44656292e-02f, -1.50005743e-01f, 7.82251582e-02f, -1.09040439e-01f, -5.22907116e-02f,
  -1.78761527e-01f, 5.03480583e-02f, -8.10144320e-02f, -9.22274664e-02f, -7.95167834e-02f, -9.11836177e-02f, 2.60778338e-01f, -1.56219944e-01f, -2.03318983e-01f, 8.11510310e-02f,
  -2.80524969e-01f, 4.62438315e-02f, 5.29208034e-02f, 7.46100470e-02f, 1.05408281e-01f, 3.90105128e-01f, 3.40325125e-02f, 5.72857186e-02f, -9.11079794e-02f, 9.64842662e-02f,
  1.18524745e-01f, 1.61646187e-01f, 1.74244478e-01f, 1.16942093e-01f, -1.26837134e-01f, 1.89050496e-01f, -1.26770943e-01f, 2.23961487e-01f, -2.00518012e-01f, 8.58886074e-03f,
  2.12322205e-01f, 8.78184065e-02f, -9.37672853e-02f, 3.16714138e-01f, 1.76972419e-01f, 2.06205472e-01f, -2.49303982e-01f, -2.47081041e-01f, -2.19577357e-01f, -2.09005103e-01f,
  -1.54013261e-01f, 1.05184540e-01f, 2.42350698e-01f, 1.47002503e-01f, -1.13452658e-01f, 5.56671247e-02f, 2.08826020e-01f, 1.10073827e-01f, 2.22310364e-01f, -2.00818822e-01f,
  1.45290256e-01f, 1.18533215e-02f, -3.98604758e-03f, 7.74246529e-02f, 2.42805675e-01f, -1.07957318e-01f, -3.24085504e-02f, 1.18783563e-02f, 1.41861305e-01f, -2.19726801e-01f,
  2.99271703e-01f, -8.47286284e-02f, 1.53198615e-01f, 3.85720506e-02f, -1.26960367e-01f, -2.05180317e-01f, 1.12808004e-01f, 5.07959723e-03f, 5.32081053e-02f, -1.53062036e-02f,
  -3.45897347e-01f, 1.78041279e-01f, -3.38625073e-01f, -1.48133487e-01f, -3.04589123e-01f, -1.83125958e-02f, -1.48829356e-01f, -2.20141023e-01f, -2.09358074e-02f, -2.11663261e-01f,
  5.03610820e-02f, 9.66801271e-02f, -1.15876526e-01f, -2.02006176e-01f, -1.17965437e-01f, -2.01887563e-02f, -8.81817043e-02f, -1.81801245e-01f, -2.93780211e-02f, -1.39515534e-01f,
  -1.74807146e-01f, -1.06569223e-01f, -3.73220779e-02f, 4.78355996e-02f, -1.37331694e-01f, -9.16954055e-02f, -7.99983069e-02f, 9.25509408e-02f, -3.75276208e-01f, -3.00089214e-02f,
  4.32549939e-02f, 3.21495235e-01f, -2.10671097e-01f, -9.54038277e-02f, 1.29667297e-02f, 7.04907719e-03f, -3.06949645e-01f, -2.11484954e-01f, -1.91605031e-01f, 7.21211284e-02f,
  -9.27205011e-02f, 2.11430341e-01f, -1.13595784e-01f, -5.80238961e-02f, 2.99566060e-01f, -2.98169374e-01f, 2.65777618e-01f, -2.54891235e-02f, -1.85880244e-01f, -2.62000233e-01f,
  3.33970077e-02f, -1.64949164e-01f, 7.53918961e-02f, 1.91558599e-01f, 2.04753906e-01f, -4.02738191e-02f, 5.56381792e-02f, -3.02782804e-01f, -5.80295697e-02f, 1.78526342e-02f,
  -6.71257218e-03f, 5.17910533e-02f, -2.67128855e-01f, -7.22140307e-03f, 1.95759445e-01f, -1.60144363e-02f, -8.08769092e-02f, -2.00875446e-01f, 5.29731289e-02f, -4.91283759e-02f,
  -1.94458187e-01f, 5.78287616e-02f, -1.50238141e-01f, -2.30229825e-01f, -4.03214507e-02f, 2.85903275e-01f, -1.59038216e-01f, -2.70685166e-01f, 3.60123701e-02f, -1.51050076e-01f,
  -1.30751327e-01f, -1.52634755e-01f, -6.64955452e-02f, -1.17468469e-01f, -2.43291687e-02f, -2.22808957e-01f, 1.81551158e-01f, -2.31541827e-01f, -3.16623040e-02f, 5.84270246e-02f,
  -1.93672795e-02f, -4.65594083e-02f, 2.18499094e-01f, -9.56003219e-02f, 4.94251540e-03f, 1.24325611e-01f, -1.98453516e-02f, 1.65897593e-01f, 1.81353405e-01f, 3.21317226e-01f,
  -2.46199071e-01f, -6.95046410e-02f, 1.84877932e-01f, -1.15145426e-02f, 3.20986956e-02f, 7.90765360e-02f, -1.13165349e-01f, 4.08318602e-02f, -1.68564349e-01f, -4.57638642e-03f,
  2.81630844e-01f, -1.30015463e-01f, 1.19579561e-01f, -1.34201929e-01f, -8.84545073e-02f, 2.84108333e-02f, 2.75294989e-01f, 1.23727567e-01f, -1.41951367e-01f, 2.15095177e-01f,
  -2.15630442e-01f, -7.53530487e-02f, -4.08076011e-02f, -7.42092682e-03f, 2.04287302e-02f, 5.59169129e-02f, 1.43975625e-02f, 2.92096082e-02f, 6.13640733e-02f, 1.59394786e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.77720338e-01f, 4.10046279e-01f, -1.66335553e-01f, 3.69669825e-01f, 2.59284955e-02f, -7.81127140e-02f, 8.05532634e-02f, -8.12903121e-02f, -1.95880055e-01f, 3.81633580e-01f,
  1.23510815e-01f, 1.39363527e-01f, 1.91470478e-02f, 1.47863686e-01f, -6.36491226e-03f, -5.33133671e-02f, -5.14682829e-02f, 2.63716280e-01f, 1.01276934e-01f, 2.20163882e-01f,
  1.57472789e-01f, 4.23523374e-02f, -1.35457501e-01f, 1.62306875e-01f, 3.90596152e-03f, 1.93921164e-01f, -2.77215481e-01f, 6.41473159e-02f, 2.52654552e-01f, -2.66956031e-01f,
  -8.13352168e-02f, -1.69594586e-01f, -5.66811450e-02f, 1.65500984e-01f, 1.38962969e-01f, -7.78390244e-02f, 2.05553055e-01f, -1.63308933e-01f, 2.10289687e-01f, -1.60765305e-01f,
  -3.62204522e-01f, 2.78965563e-01f, 2.04447523e-01f, 3.31877530e-01f, -2.62995269e-02f, -2.79616088e-01f, 1.11473873e-01f, 6.14660941e-02f, -9.34497118e-02f, 2.55552083e-01f,
  2.14105099e-01f, 8.24140236e-02f, -4.13049012e-02f, 1.67113930e-01f, 9.89891067e-02f, 1.04139023e-01f, 1.66582182e-01f, -5.58458045e-02f, 3.22376303e-02f, -1.64897833e-02f,
  8.50550532e-02f, 2.71519214e-01f, -1.70740813e-01f, 1.51626170e-01f, 8.28654915e-02f, -1.40056014e-01f, 1.28284588e-01f, 2.96434581e-01f, 1.20653778e-01f, 3.03709269e-01f,
  -1.40750453e-01f, 5.07679209e-02f, 2.09594831e-01f, 3.30601454e-01f, 3.93854007e-02f, 4.74096872e-02f, -6.24814406e-02f, 1.60940379e-01f, 1.49523482e-01f, 1.27670050e-01f,
  7.71157257e-03f, -8.99421517e-03f, 1.08223772e-02f, 1.01710178e-01f, -2.12753867e-03f, 2.24141017e-01f, 9.79047120e-02f, 1.83080643e-01f, 1.57491207e-01f, -2.79637635e-01f,
  2.77986050e-01f, 6.25950918e-02f, 1.25839397e-01f, -9.86513495e-02f, -5.35357893e-02f, 1.62978455e-01f, -1.42393753e-01f, -4.54642363e-02f, -2.54196604e-03f, 3.98116022e-01f,
  1.62639856e-01f, -1.65114123e-02f, -1.52796373e-01f, -2.51094371e-01f, -8.25407207e-02f, 2.39164948e-01f, 9.09742564e-02f, -1.88392505e-01f, -6.05885208e-01f, -9.92741436e-02f,
  2.15070710e-01f, 2.15334684e-01f, 2.86533326e-01f, 3.61180007e-02f, 7.09153041e-02f, 3.36974412e-02f, 1.51054591e-01f, -5.49673997e-02f, -7.53834993e-02f, 5.65166235e-01f,
  -1.35850623e-01f, -2.44635597e-01f, 2.62323529e-01f, 2.77195722e-01f, 1.33359805e-01f, -1.51554435e-01f, 9.91563275e-02f, 2.08723366e-01f, -1.42008021e-01f, 2.05449417e-01f,
  -4.22450483e-01f, 1.83685511e-01f, -2.44471449e-02f, 2.28944644e-02f, 1.17776819e-01f, 1.86804727e-01f, -2.25944266e-01f, 3.00006390e-01f, -4.20772582e-02f, 1.14115410e-01f,
  2.61455804e-01f, 1.45393088e-01f, 1.11130245e-01f, -9.41282585e-02f, -1.03764251e-01f, 4.92738932e-03f, 8.51013362e-02f, -6.97822496e-03f, -2.84814894e-01f, 2.45230243e-01f,
  1.74455732e-01f, 1.17587976e-01f, -1.57164007e-01f, 2.87575126e-01f, 6.83044270e-02f, 4.50770557e-02f, -5.89388423e-02f, -4.50945318e-01f, -4.54474062e-01f, -1.06481174e-02f,
  -1.41253680e-01f, 1.29577503e-01f, -3.29461873e-01f, 1.87436432e-01f, -1.05725296e-01f, -3.38816166e-01f, -1.93828225e-01f, -1.65068075e-01f, -3.33553515e-02f, 8.21627602e-02f,
  -3.85869555e-02f, 2.15186000e-01f, 2.98194230e-01f, -1.28707975e-01f, 1.12534173e-01f, 1.04788169e-02f, -1.36501640e-01f, 1.64773867e-01f, 6.68781772e-02f, 6.88506737e-02f,
  3.05860847e-01f, -2.66647860e-02f, 1.99062303e-01f, 1.55575812e-01f, -2.71867335e-01f, -2.26724565e-01f, 5.00482261e-01f, 8.75096768e-02f, 7.14293718e-01f, -7.05084577e-02f,
  -2.05516174e-01f, 4.72330749e-02f, -1.72126099e-01f, 2.09199652e-01f, 1.80148229e-01f, 2.24691227e-01f, 1.10061057e-02f, -6.45035692e-03f, 6.20760284e-02f, -1.05753884e-01f,
  1.34545356e-01f, -1.25118554e-01f, 5.77674918e-02f, -1.19798116e-01f, 1.13793410e-01f, -5.41451983e-02f, 2.13064030e-01f, 2.07428992e-01f, -2.43087873e-01f, 1.21750765e-01f,
  9.68831331e-02f, -1.71927549e-02f, 3.77640724e-01f, -8.11518449e-03f, -6.99677616e-02f, 2.39135832e-01f, 3.01695615e-01f, -1.59994334e-01f, 2.40188316e-01f, -3.66644524e-02f,
  -2.11449161e-01f, 4.04023647e-01f, 4.69173372e-01f, 5.02207100e-01f, 8.43762383e-02f, 4.34013382e-02f, 6.12617172e-02f, -1.90372244e-01f, 2.55809456e-01f, 2.50654519e-01f,
  2.84937948e-01f, -6.11753799e-02f, -6.74180761e-02f, -2.44404629e-01f, -2.64811307e-01f, -3.23202729e-01f, -1.13176890e-01f, -5.57348579e-02f, 2.90110987e-02f, 3.91450040e-02f,
  2.92775989e-01f, -1.23451665e-01f, 1.77720547e-01f, 4.68047857e-02f, 2.36704759e-02f, 3.92764986e-01f, 8.00568312e-02f, 2.87102133e-01f, 1.76111594e-01f, 1.13968149e-01f,
  4.56901677e-02f, 3.24137956e-01f, -1.53587133e-01f, 5.91003716e-01f, 3.66458803e-01f, 3.05539519e-01f, 1.47554964e-01f, 1.43325403e-01f, 5.40295988e-03f, 5.53769246e-02f,
  1.60437912e-01f, 1.39321491e-01f, 1.28928632e-01f, -2.06824645e-01f, -5.79219572e-02f, 2.33345702e-01f, -1.83529928e-01f, 1.52707249e-01f, 1.26994222e-01f, 6.80454522e-02f,
  2.07099795e-01f, -4.38555181e-02f, 4.62636799e-02f, 4.01087403e-02f, 9.50005725e-02f, 1.68543048e-02f, 1.35370880e-01f, -3.62179652e-02f, -5.52672707e-02f, 1.18805483e-01f,
  -9.15701762e-02f, 4.59612191e-01f, 7.58416369e-04f, -2.91932851e-01f, -2.64388651e-01f, -2.50927247e-02f, -2.25669459e-01f, -3.37307714e-02f, 3.81330132e-01f, 2.70420194e-01f,
  -3.38150077e-02f, -2.53420025e-01f, -4.82449271e-02f, -8.32983851e-02f, 4.09957677e-01f, -4.50153108e-04f, -3.21717232e-01f, 1.85084805e-01f, 6.82129785e-02f, 2.40816608e-01f,
  6.05039299e-01f, 5.03719188e-02f, -1.80831645e-02f, -3.14454705e-01f, -3.48646134e-01f, 3.05035233e-01f, 5.13884500e-02f, 1.87050134e-01f, 9.31147113e-02f, 2.42043123e-01f,
  3.77330601e-01f, -2.33748615e-01f, 1.87589496e-01f, 1.43778563e-01f, 1.36949107e-01f, -5.57217076e-02f, 1.32414639e-01f, 4.89548087e-01f, 1.24766394e-01f, 2.39313811e-01f,
  2.03705579e-01f, 1.02406666e-01f, -1.66598663e-01f, -1.64335072e-01f, 3.51273626e-01f, 1.07691258e-01f, 1.89198807e-01f, 1.18863486e-01f, 4.78764147e-01f, 6.95236102e-02f,
  1.15225010e-01f, 3.23263615e-01f, 1.41824335e-01f, 3.53750795e-01f, 1.25241086e-01f, 3.55098397e-01f, 5.31215310e-01f, -1.09264217e-01f, 2.30153233e-01f, 2.28061378e-01f,
  -1.60845846e-01f, 1.99223813e-02f, 2.03996152e-01f, -2.46848449e-01f, 4.23573762e-01f, 1.31273037e-02f, -4.96374279e-01f, -9.49315950e-02f, 6.70187056e-01f, -1.30993783e-01f,
  -2.44303003e-01f, -2.22354472e-01f, -8.01261887e-02f, -2.56086618e-01f, 9.28987265e-02f, 5.93684614e-01f, -1.99776158e-01f, -2.60848731e-01f, -1.62504643e-01f, 8.42680559e-02f,
  -1.40951335e-01f, 1.46154329e-01f, 5.37844181e-01f, 1.52399153e-01f, -2.56206721e-01f, 3.07475537e-01f, -4.91435766e-01f, -8.91691074e-02f, -3.67729306e-01f, -5.77541701e-02f,
  -3.21123362e-01f, 2.84061641e-01f, 2.77270585e-01f, -4.56570208e-01f, -3.52611959e-01f, 3.14664304e-01f, 3.43130559e-01f, 6.76582456e-02f, 4.29388434e-01f, -2.05063671e-01f,
  2.85501033e-01f, -2.04302624e-01f, 3.37450385e-01f, -3.47306192e-01f, 1.41331963e-02f, -8.17533880e-02f, 4.23872843e-02f, 5.62590268e-03f, -2.28126898e-01f, 4.28471901e-02f,
  -9.45560634e-02f, 1.54665500e-01f, 3.71962994e-01f, 1.48371056e-01f, 1.26851872e-01f, -9.12162215e-02f, 1.79336399e-01f, -7.43793994e-02f, -6.23670816e-02f, -2.29484305e-01f,
  6.26527816e-02f, -2.69465595e-01f, -2.07722783e-01f, 2.41361558e-03f, -1.25570983e-01f, -1.37543142e-01f, 4.74576801e-02f, -8.75845030e-02f, -3.69413570e-02f, -3.73757966e-02f,
  -6.52284801e-01f, 5.08908406e-02f, -3.16997804e-02f, -2.17494415e-03f, -2.97960401e-01f, -2.69463778e-01f, -3.49913925e-01f, -1.60970688e-01f, -2.51859665e-01f, -1.01301350e-01f,
  -3.83604378e-01f, 1.99832514e-01f, 5.92570053e-04f, 3.82481456e-01f, 6.62421063e-02f, -9.31774601e-02f, -1.50165081e-01f, 1.10584646e-01f, 9.35796872e-02f, -2.65227944e-01f,
  -2.44573161e-01f, -1.21199645e-01f, -1.49805903e-01f, -1.27924547e-01f, 3.18824261e-01f, -3.49425673e-02f, 2.00791150e-01f, 2.30878904e-01f, 1.72653809e-01f, 1.26700073e-01f,
  -3.11525673e-01f, 4.94796544e-01f, 4.89510894e-01f, 2.21063688e-01f, 2.72004783e-01f, -1.23545811e-01f, 1.98629841e-01f, -3.63895744e-01f, 1.36600256e-01f, 2.45177418e-01f,
  4.56960469e-01f, 3.78410459e-01f, -5.51852435e-02f, 2.68151194e-01f, -1.34205474e-02f, 3.94584417e-01f, 2.22116664e-01f, 5.17559759e-02f, 2.84035355e-01f, -1.48747370e-01f,
  4.48193885e-02f, 6.32671267e-02f, -1.14199609e-01f, -4.77623530e-02f, -1.77472338e-01f, -1.03786439e-01f, -1.45688295e-01f, 3.31301332e-01f, -3.31730843e-02f, 1.01208225e-01f,
  -3.32522951e-02f, 1.54477865e-01f, -1.94929451e-01f, -3.19515467e-01f, -5.51421702e-01f, 4.41792399e-01f, 3.47150981e-01f, -3.43224734e-01f, -4.65503633e-01f, -2.56527156e-01f,
  -4.22884315e-01f, -3.00165988e-03f, 6.69912919e-02f, -1.43491551e-01f, 8.73220898e-03f, -3.92294191e-02f, 9.51681212e-02f, -4.30685617e-02f, -1.22506507e-02f, 4.57428508e-02f,
  -9.73768532e-02f, 8.58420506e-02f, -7.96396565e-03f, -3.03105056e-01f, 1.33225620e-01f, -6.97700903e-02f, -4.50478606e-02f, 2.05908671e-01f, 1.21127047e-01f, -1.78944632e-01f,
  -4.35102582e-01f, 4.65343669e-02f, 1.97622746e-01f, 1.91273063e-01f, -2.41619423e-01f, 2.77793080e-01f, 5.24212182e-01f, 2.04255849e-01f, 4.29939777e-01f, 3.03994089e-01f,
  -9.51341838e-02f, -1.22464441e-01f, 4.11999613e-01f, 4.34555173e-01f, 1.43924162e-01f, -9.69320722e-03f, 2.51765132e-01f, 1.65819749e-01f, 5.53734973e-02f, -1.31726936e-01f,
  1.21828347e-01f, 9.35553387e-03f, 1.79445058e-01f, 1.26051784e-01f, 1.01088606e-01f, 1.58405334e-01f, 1.43395707e-01f, 1.17871419e-01f, 3.07899624e-01f, 7.14379773e-02f,
  1.10902332e-01f, 1.15422584e-01f, 3.90446424e-01f, -4.90495414e-02f, -6.89840093e-02f, 8.35935585e-03f, 3.40676904e-01f, -4.08728123e-02f, -5.31733409e-02f, -1.52101606e-01f,
  4.36513066e-01f, 1.31739095e-01f, 2.77517855e-01f, -2.81812489e-01f, -2.08214950e-02f, 1.40841790e-02f, 3.68536890e-01f, -3.28231603e-01f, 2.78555974e-02f, -3.85314022e-04f,
  3.03570509e-01f, 8.60993788e-02f, -3.34111989e-01f, 1.84229419e-01f, 3.06265682e-01f, 3.90006900e-01f, -9.83587727e-02f, 2.49797925e-01f, -1.23336121e-01f, -2.50843525e-01f,
  -1.95076704e-01f, 1.72304675e-01f, 5.90361748e-03f, 7.54140988e-02f, -4.03668910e-01f, 1.04047857e-01f, -3.34296655e-03f, 4.33638180e-03f, 5.73831499e-01f, 1.55495241e-01f,
  -2.79553443e-01f, -3.45553458e-02f, -1.79819405e-01f, 3.94296914e-01f, -1.17629737e-01f, 1.15250185e-01f, 5.48847139e-01f, -6.29161373e-02f, 8.08187366e-01f, 4.13554497e-02f,
  -2.63222456e-02f, 1.60196796e-01f, 2.29262933e-01f, 2.19569709e-02f, 1.83948174e-01f, 5.63840196e-02f, 3.28677207e-01f, -2.62299061e-01f, -5.68749569e-02f, 1.20869555e-01f,
  -6.28166616e-01f, 2.73889881e-02f, -4.12182398e-02f, -2.35204652e-01f, 1.29299417e-01f, 1.21238738e-01f, 2.32305393e-01f, 1.93565831e-01f, 1.66145399e-01f, 2.36060351e-01f,
  4.12559718e-01f, -5.58265686e-01f, 1.37751117e-01f, -1.64017603e-01f, 2.51006186e-01f, -1.89339314e-02f, -5.13218269e-02f, -5.37877269e-02f, -1.39988795e-01f, 2.56169647e-01f,
  1.73979610e-01f, 1.27387092e-01f, -1.23698376e-02f, 2.62759864e-01f, 5.95046952e-02f, 6.27892166e-02f, -2.10828796e-01f, 5.31905890e-01f, -1.65781111e-01f, 8.77570175e-03f,
  -2.40942314e-01f, -1.22732900e-01f, -1.69229105e-01f, 2.95526892e-01f, 1.23676986e-01f, 8.72304440e-02f, -5.11306763e-01f, -1.37996888e-02f, -4.17980552e-01f, 5.24501093e-02f,
  -2.55448464e-02f, 3.55813473e-01f, -9.19501781e-02f, 3.22748721e-01f, 1.19705208e-01f, 1.27298877e-01f, 1.04533553e-01f, 1.28564119e-01f, 1.58188224e-01f, 4.94701695e-03f,
  -1.40746862e-01f, -4.29713100e-01f, -2.39553049e-01f, -1.56612396e-01f, 5.33044292e-03f, -2.94423029e-02f, -1.13383345e-01f, -3.07271779e-01f, 9.13951322e-02f, 1.95948705e-01f,
  -8.15317035e-02f, -2.82915950e-01f, 2.54292578e-01f, -2.15452462e-02f, -1.41661584e-01f, 1.56635717e-01f, -1.87683493e-01f, 2.20178008e-01f, 1.96571797e-02f, -1.86613992e-01f,
  8.83495882e-02f, -9.95275304e-02f, -1.67977393e-01f, -2.80369539e-02f, 2.34657645e-01f, 5.24120741e-02f, 2.15595931e-01f, -2.91654915e-01f, -2.85395205e-01f, 2.88446844e-01f,
  1.76327020e-01f, 6.11599647e-02f, 2.39942014e-01f, 1.41208738e-01f, -4.19922620e-01f, 3.68783921e-02f, 2.19940335e-01f, -3.50454807e-01f, -2.17223212e-01f, -2.35336885e-01f,
  -2.73943543e-01f, 2.78124988e-01f, -7.43228644e-02f, -2.92713255e-01f, -1.76546842e-01f, 1.69454832e-02f, -4.33314331e-02f, 2.87613541e-01f, 9.23763588e-02f, 3.17780077e-02f,
  2.54267544e-01f, 4.21485305e-01f, 3.57596546e-01f, 5.86311109e-02f, 6.13962151e-02f, 1.98434547e-01f, 2.06920400e-01f, -4.10666555e-01f, -3.65708619e-02f, -7.61793330e-02f,
  -2.76478410e-01f, 2.30859801e-01f, 5.23901582e-01f, 2.68890679e-01f, 2.95072407e-01f, 3.02087665e-01f, -1.30592331e-01f, -2.48162635e-02f, 4.09462720e-01f, 4.97822575e-02f,
  2.63463944e-01f, 2.59829909e-01f, 9.67299044e-02f, 9.87369940e-03f, 8.50048363e-02f, 2.75031269e-01f, 1.77043602e-01f, 3.33765268e-01f, 4.34469819e-01f, 3.80184740e-01f,
  1.86389923e-01f, 4.82092291e-01f, 4.88660723e-01f, 2.97216684e-01f, -1.47780627e-01f, 2.94808626e-01f, 2.05749184e-01f, -1.34888768e-01f, 3.71284217e-01f, 7.43082985e-02f,
  -2.51863594e-03f, -5.85585907e-02f, 3.37247968e-01f, -3.03711176e-01f, -1.51697367e-01f, -1.26163915e-01f, -1.36993587e-01f, 1.21619053e-01f, 1.79604627e-02f, 1.51401177e-01f,
  -3.66266727e-01f, -5.28771222e-01f, -1.59720883e-01f, -1.64075464e-01f, -1.46981046e-01f, 2.51908213e-01f, 3.85881603e-01f, 4.47573736e-02f, -1.69710502e-01f, 1.90689400e-01f,
  -7.06834942e-02f, 1.82825089e-01f, -1.85323656e-01f, 2.27951393e-01f, -2.46273980e-01f, 2.19689563e-01f, 2.70892978e-01f, -3.52707148e-01f, 1.24111354e-01f, 3.28289360e-01f,
  1.43175453e-01f, -1.65277049e-01f, 5.96646667e-02f, -2.99093157e-01f, 1.26013756e-01f, 3.24170925e-02f, 2.26810634e-01f, -6.57784268e-02f, -4.33395850e-03f, 1.02612443e-01f,
  5.63623071e-01f, 1.98824808e-01f, 1.36934623e-01f, 2.26976722e-01f, 2.34703586e-01f, 4.07091916e-01f, -8.28575566e-02f, -1.40730023e-01f, 2.89493538e-02f, -3.47824469e-02f,
  -6.67966530e-02f, 1.48487389e-02f, 1.20679609e-01f, 1.08819515e-01f, -9.93729755e-02f, 2.06601515e-01f, 5.61813079e-02f, 1.18857369e-01f, 1.27741233e-01f, 3.37345988e-01f,
  9.44501385e-02f, 2.04279259e-01f, 3.89103889e-02f, -2.41133794e-01f, 4.32971597e-01f, -6.02423586e-02f, -3.26624155e-01f, 1.96832225e-01f, 3.07573602e-02f, 7.06632078e-01f,
  2.27632046e-01f, 6.57403320e-02f, 7.59396479e-02f, 1.71623498e-01f, 1.64914519e-01f, 2.65565030e-02f, 1.99263990e-01f, -1.43917784e-01f, 2.78426886e-01f, -1.26115799e-01f,
  -1.86384916e-01f, -5.45755982e-01f, 2.39932500e-02f, 2.57587731e-02f, 2.25741044e-01f, -2.88936589e-02f, 2.99904287e-01f, -2.04843059e-01f, -1.86023474e-01f, -9.52636674e-02f,
  2.14489818e-01f, 2.49375731e-01f, -1.11337215e-01f, 1.68212041e-01f, -6.05103187e-02f, 4.02979761e-01f, 3.36005464e-02f, 2.25943133e-01f, 1.65285230e-01f, 3.63184631e-01f,
  1.05490156e-01f, 3.58688235e-01f, 4.43160206e-01f, 6.08436167e-02f, 2.15521097e-01f, 1.62895501e-01f, 1.16282068e-01f, 1.78019762e-01f, 1.69508889e-01f, -1.58024564e-01f,
  -3.38590652e-01f, 1.26507282e-01f, -3.06120459e-02f, 9.88464281e-02f, 1.54564261e-01f, 1.73681349e-01f, -1.37749672e-01f, 5.84922209e-02f, 1.67988762e-01f, -9.58067402e-02f,
  5.01863420e-01f, 3.72718751e-01f, 2.76767701e-01f, 3.62412453e-01f, 8.87449682e-02f, 2.45261326e-01f, 7.71444291e-02f, -3.06827396e-01f, 2.80817330e-01f, 6.88236132e-02f,
  -1.31749824e-01f, -2.84525678e-02f, 8.58621299e-03f, -9.09528583e-02f, 1.34644404e-01f, 2.63426006e-01f, 9.17527229e-02f, 1.19203165e-01f, -4.15224582e-02f, 1.16246246e-01f,
  2.70989746e-01f, -5.30511886e-02f, -4.24605221e-01f, 4.21102047e-01f, -6.23261482e-02f, 1.72265142e-01f, -1.91033974e-01f, -3.45177650e-01f, 6.38246611e-02f, 9.93002206e-02f,
  2.54193041e-02f, 3.03564966e-01f, -3.00622016e-01f, 6.61251992e-02f, -2.13774201e-02f, 8.83337334e-02f, 2.42683455e-01f, 5.84431849e-02f, -8.78534466e-02f, 2.90304776e-02f,
  -8.98833945e-02f, -1.78134236e-02f, -5.82031487e-03f, -2.59952806e-02f, 1.29785582e-01f, 2.21170306e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.14948153e-01f, 3.83323245e-02f, 1.54227018e-02f, 8.57846141e-02f, 1.75697803e-01f, 1.94583401e-01f, 2.08079576e-01f, 1.12090133e-01f, 8.08583573e-02f, 4.29123528e-02f,
  1.39796495e-01f, 6.24069571e-02f, 6.64815158e-02f, 1.84381083e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.84376895e-01f, -3.25718105e-01f, 1.02410011e-01f, 2.11004794e-01f, 2.49420375e-01f, -4.85978238e-02f, -2.04616077e-02f, 1.77691355e-01f, -2.83892483e-01f, 2.34783635e-01f,
  -5.92636392e-02f, 1.07816607e-01f, 1.67454571e-01f, 2.93477792e-02f, 1.39360473e-01f, 1.78738028e-01f, 4.12089005e-02f, -1.45711020e-01f, 7.60509865e-03f, -3.31105262e-01f,
  -9.28817876e-03f, -2.71774858e-01f, -3.63302618e-01f, 2.66778648e-01f, -2.14657634e-01f, 2.01156735e-01f, 1.19611718e-01f, -5.25371283e-02f, 1.17089257e-01f, 3.17221016e-01f,
  2.66491860e-01f, -1.11869946e-02f, -7.95693249e-02f, 2.46338949e-01f, 4.02085409e-02f, -2.73654222e-01f, -2.25030541e-01f, -8.86615813e-02f, 4.57460284e-01f, -1.22289285e-01f,
  -2.19213650e-01f, -1.49018914e-01f, 2.37441495e-01f, 2.79183060e-01f, 4.23886366e-02f, -6.90218568e-01f, -1.95293739e-01f, 3.51666182e-01f, 1.44212723e-01f, 3.43803108e-01f,
  -2.95966752e-02f, -5.00938833e-01f, 2.03426912e-01f, -2.37771466e-01f, 2.96772450e-01f, -6.21682465e-01f, 3.18594962e-01f, 1.92601845e-01f, -3.43856961e-01f, -4.39364165e-01f,
  -2.52373040e-01f, -4.28185612e-01f, -1.93932191e-01f, -1.51998997e-01f, -3.40880454e-01f, 1.56784490e-01f, -5.37128672e-02f, -2.78803110e-01f, 3.58838201e-01f, 2.05579042e-01f,
  -2.29574785e-01f, -1.30042195e-01f, 3.87774706e-02f, -3.94030482e-01f, 6.29138499e-02f, -1.86027899e-01f, -4.02985871e-01f, 3.46617848e-02f, 2.11014062e-01f, 1.19201474e-01f,
  1.49932593e-01f, 3.05052996e-01f, 2.89145023e-01f, 7.31488988e-02f, 7.62630999e-02f, -2.39614084e-01f, 5.29195666e-02f, 1.81230634e-01f, -3.31882536e-01f, -2.69583523e-01f,
  4.03849065e-01f, -4.80641603e-01f, 9.59836543e-02f, 9.06525925e-03f, -1.29698634e-01f, -3.86178613e-01f, 3.13399166e-01f, -2.02277765e-01f, 1.55713797e-01f, 3.75229985e-01f,
  2.52064206e-02f, 3.54100689e-02f, -3.22976679e-01f, 2.61866122e-01f, 2.18311250e-01f, -1.83907047e-01f, 4.79639508e-02f, 9.40739587e-02f, -3.84460151e-01f, -3.19915116e-01f,
  -2.23082379e-01f, -3.19575846e-01f, 3.79591137e-01f, 3.22614312e-01f, 1.88279465e-01f, -8.68590781e-04f, -3.21488678e-01f, 1.85827866e-01f, 1.71447262e-01f, -3.09341401e-01f,
  -1.60067439e-01f, -2.65214413e-01f, 1.79561183e-01f, -8.29450071e-01f, 1.50993317e-01f, -3.24665159e-01f, -1.52270645e-01f, -1.34615630e-01f, 1.56392634e-01f, 6.17038980e-02f,
  -2.11053386e-01f, 1.59781411e-01f, 2.38802612e-01f, -2.93448299e-01f, -2.07749024e-01f, 2.16636375e-01f, 6.36130273e-02f, 3.86701226e-02f, -1.60547853e-01f, -6.37715980e-02f,
  -2.61440724e-01f, -6.42203316e-02f, 9.58506316e-02f, -2.96850324e-01f, -2.14849468e-02f, -1.53635561e-01f, 2.22066358e-01f, 1.20313868e-01f, 2.35720491e-03f, -1.65167898e-01f,
  -1.23983435e-01f, 9.93141010e-02f, -2.27825999e-01f, 4.80344743e-01f, 3.09150040e-01f, 2.90752668e-03f, 9.23669860e-02f, 4.57513183e-01f, 1.77211650e-02f, 6.07634604e-01f,
  1.57186896e-01f, 3.33269894e-01f, -1.99795291e-01f, -1.48658261e-01f, 1.14338823e-01f, -9.99443009e-02f, -4.53195006e-01f, -4.22446281e-01f, 2.32364163e-01f, 7.32327858e-03f,
  -2.85741761e-02f, -3.55893642e-01f, 1.56976655e-01f, -4.63933825e-01f, -1.32194147e-01f, 3.72819394e-01f, -1.34412333e-01f, 2.78491855e-01f, 5.88001646e-02f, 4.25744690e-02f,
  3.29315782e-01f, -6.76185191e-02f, 2.32762590e-01f, 4.90030423e-02f, -4.81946558e-01f, -6.39766037e-01f, -3.70150298e-01f, -7.81521738e-01f, -9.01320484e-04f, 2.20817387e-01f,
  1.00046486e-01f, 5.85182086e-02f, -3.02649230e-01f, 1.36328176e-01f, 2.16334671e-01f, 1.15142509e-01f, 2.76474625e-01f, -9.48731750e-02f, 1.44278347e-01f, -8.66049677e-02f,
  2.39826128e-01f, -2.03128099e-01f, 2.00562462e-01f, 4.54540327e-02f, -5.57109639e-02f, 4.20542002e-01f, -3.34340930e-01f, -2.74631977e-01f, 2.67126560e-01f, 3.64961505e-01f,
  7.89537877e-02f, 8.96520391e-02f, 1.37864292e-01f, 4.82137531e-01f, 2.87306488e-01f, 2.96148676e-02f, 7.86218643e-02f, 2.51672268e-01f, 1.96964353e-01f, -1.99327320e-01f,
  -2.27078825e-01f, -1.71054915e-01f, 3.80151749e-01f, -3.00487339e-01f, 3.06473434e-01f, 2.86145329e-01f, -3.00112784e-01f, -2.54189223e-01f, -1.96079895e-01f, -6.03554249e-01f,
  -5.36993966e-02f, 1.83573276e-01f, -4.18705314e-01f, -8.28269497e-02f, 1.57541707e-01f, -3.97330858e-02f, 1.43523976e-01f, -1.72298461e-01f, 2.52431095e-01f, -1.37880400e-01f,
  -1.84796453e-02f, -1.03139421e-02f, -3.22147310e-02f, 1.21130377e-01f, 2.92841829e-02f, -7.31530190e-01f, -3.68564367e-01f, 2.12136313e-01f, 2.43771270e-01f, 3.82668003e-02f,
  -3.64161164e-01f, 4.67554331e-01f, -5.88460147e-01f, -3.04287404e-01f, -6.87606156e-01f, 1.24403797e-02f, 2.32509166e-01f, -2.87951045e-02f, -1.67612731e-01f, 2.52125919e-01f,
  -4.40399230e-01f, 3.02210987e-01f, -5.41618206e-02f, -1.84390306e-01f, -1.30112529e-01f, -1.09014727e-01f, -4.63163584e-01f, -5.92704583e-03f, 2.32989356e-01f, -3.31534833e-01f,
  2.21540287e-01f, 2.30269000e-01f, -2.16208875e-01f, -1.44966945e-01f, 1.12052064e-03f, -1.52449459e-01f, -2.76523102e-02f, -2.05068052e-01f, -2.23032564e-01f, -2.77208209e-01f,
  -4.76002917e-02f, 3.80612791e-01f, 1.25362754e-01f, 4.17640448e-01f, -1.43237054e-01f, -2.38753363e-01f, -3.11816931e-01f, 4.74697292e-01f, 2.61385083e-01f, -4.86511976e-01f,
  -1.41055644e-01f, 4.25514787e-01f, 4.50406432e-01f, 3.03772867e-01f, 2.91245997e-01f, 2.53038466e-01f, -2.04952329e-01f, -3.11131269e-01f, -7.82675669e-02f, -1.52639762e-01f,
  2.01063484e-01f, 4.39858735e-01f, -8.33142474e-02f, 2.05833495e-01f, -2.01933712e-01f, -5.99635541e-01f, 2.28664860e-01f, 6.87692091e-02f, 8.25205445e-02f, -1.79368675e-01f,
  -9.13153868e-03f, -2.52144009e-01f, -4.71035801e-02f, 1.01225026e-01f, 4.59990986e-02f, -1.25729769e-01f, -2.02711359e-01f, 1.52272627e-01f, -3.35923105e-01f, 2.41140723e-01f,
  -7.24561363e-02f, -2.98568234e-02f, 9.07351226e-02f, -4.39891815e-01f, -1.63373128e-01f, 2.24130481e-01f, 1.00417770e-02f, 3.57889712e-01f, 2.17864998e-02f, 4.45836902e-01f,
  1.96356833e-01f, -3.68034154e-01f, 8.99001360e-02f, -2.58040298e-02f, -2.45564669e-01f, 1.67196929e-01f, -5.97988889e-02f, -3.68681073e-01f, -2.17798859e-01f, 7.32954592e-02f,
  -2.45739996e-01f, 3.84710014e-01f, -1.62573397e-01f, 2.46710122e-01f, 2.51814257e-03f, -3.67130220e-01f, -3.49555850e-01f, 1.08702943e-01f, 1.00983113e-01f, -4.26269412e-01f,
  -1.63658723e-01f, -6.42007887e-02f, 1.30509898e-01f, 3.80401015e-01f, 2.44516820e-01f, -3.04135025e-01f, 1.92700520e-01f, 2.82781333e-01f, 4.97445822e-01f, 2.19081149e-01f,
  3.67082357e-01f, 1.82296261e-01f, -9.15931910e-02f, -3.87095101e-02f, 6.94881007e-02f, 4.33774769e-01f, 2.50375479e-01f, -3.95315200e-01f, 6.89564869e-02f, 4.24875736e-01f,
  -1.00777701e-01f, -2.66364753e-01f, -2.21380413e-01f, 6.95513859e-02f, 1.23403914e-01f, -5.85779548e-01f, -2.17385143e-02f, -4.16604318e-02f, -4.96070227e-03f, 3.33494991e-01f,
  -2.55047470e-01f, -4.17332411e-01f, 1.27994373e-01f, 1.86516866e-01f, -2.83307076e-01f, 2.95195401e-01f, -3.56437862e-01f, 3.70769501e-01f, -2.92589694e-01f, -2.12907091e-01f,
  -7.94820487e-02f, -1.05021492e-01f, -4.68447894e-01f, 7.54904449e-02f, 3.54185551e-01f, 2.21739545e-01f, 8.78309682e-02f, -1.96440797e-02f, 2.33930036e-01f, -1.44754320e-01f,
  -2.95249581e-01f, -2.07457528e-01f, 2.30753291e-02f, -1.39125481e-01f, -5.29526621e-02f, 1.18083164e-01f, -1.21508762e-02f, 1.15916781e-01f, -2.29472026e-01f, -2.00129390e-01f,
  8.49660337e-02f, -2.00158864e-01f, 2.05052391e-01f, -2.28232779e-02f, -3.63246709e-01f, -1.45891488e-01f, -1.17370188e-01f, -1.39433041e-01f, -4.61816102e-01f, 2.14597266e-02f,
  -2.46365264e-01f, -3.14467907e-01f, 3.89270931e-01f, -2.16562018e-01f, 2.75115222e-01f, 1.84850499e-01f, -4.47797179e-01f, 2.24055707e-01f, 3.04805934e-01f, -2.87089407e-01f,
  9.49048221e-01f, -4.22941267e-01f, -2.96512574e-01f, 2.47090068e-02f, -3.74312311e-01f, 1.56407177e-01f, -4.08852488e-01f, 1.01006128e-01f, -6.59488440e-02f, -6.19667590e-01f,
  -3.95115584e-01f, -8.30543637e-01f, -3.34473163e-01f, 2.49753863e-01f, 2.62805581e-01f, -1.10926896e-01f, 8.17814842e-02f, 2.31161267e-01f, -8.28105584e-02f, -1.00934999e-02f,
  3.25761139e-01f, -5.70487650e-03f, -2.67266780e-01f, 4.16018844e-01f, 4.10195775e-02f, -1.33597940e-01f, 9.97085944e-02f, 1.74175784e-01f, -1.23251930e-01f, -2.90015936e-01f,
  8.73435587e-02f, -2.07920432e-01f, -2.41298992e-02f, 1.82570010e-01f, 1.53957203e-01f, -2.75666326e-01f, 1.82999715e-01f, 8.38150680e-02f, -4.78983521e-02f, 2.10126132e-01f,
  -2.32710332e-01f, -7.37036690e-02f, 7.88769796e-02f, -1.01236761e-01f, -5.36435843e-02f, 6.51229769e-02f, -4.26132202e-01f, 3.34882408e-01f, 1.62740946e-01f, 3.78245562e-02f,
  -1.50830775e-01f, -2.55129844e-01f, 2.96946198e-01f, 4.23452407e-01f, -3.83172231e-03f, -7.70140514e-02f, -1.19420163e-01f, -4.73509312e-01f, -4.95917708e-01f, 5.79663217e-02f,
  -1.96503773e-01f, 4.30192351e-01f, -3.83180320e-01f, -2.96882987e-01f, 1.30139112e-01f, -3.68987501e-01f, 2.24175408e-01f, -1.88957497e-01f, -2.77767003e-01f, -3.74054234e-03f,
  -1.42535448e-01f, 2.91502215e-02f, -2.62425452e-01f, 4.22783613e-01f, 1.42124176e-01f, -2.13753268e-01f, -7.16055036e-01f, -2.01192573e-01f, 2.20745087e-01f, 1.93160191e-01f,
  -3.67386520e-01f, -5.63268304e-01f, 3.35675180e-01f, -4.32374567e-01f, 4.05991882e-01f, 9.32507664e-02f, -7.18296459e-03f, -2.46531785e-01f, 3.49938571e-01f, 4.07106727e-01f,
  2.70539880e-01f, -4.72867191e-01f, 8.21402296e-02f, 1.83495611e-01f, -1.38941348e-01f, 1.58058375e-01f, 2.25404784e-01f, -6.02158666e-01f, -9.40662622e-02f, -3.09550077e-01f,
  -1.95573747e-01f, -1.29464552e-01f, 2.78821617e-01f, -5.76215703e-03f, 1.69116259e-01f, 2.64739871e-01f, 2.50922084e-01f, 1.32321492e-01f, -2.91342646e-01f, 9.58928391e-02f,
  4.82217044e-01f, 2.45516866e-01f, 4.70619529e-01f, -1.69397891e-01f, 1.38255790e-01f, -1.49936602e-01f, 9.41368863e-02f, 2.84116477e-01f, -4.49707925e-01f, 4.92337644e-01f,
  -2.79232860e-01f, 4.32106405e-01f, 4.20430511e-01f, 4.83739525e-01f, 2.79641598e-01f, -2.56988138e-01f, -3.12700123e-01f, 3.34546387e-01f, -4.91495967e-01f, 8.00100803e-01f,
  5.89082539e-01f, -7.33303070e-01f, -4.13470149e-01f, 1.21900149e-01f, -5.50745055e-02f, 9.91786867e-02f, -3.28957886e-01f, 1.67693142e-02f, 1.59142226e-01f, -1.50345415e-01f,
  -4.51120973e-01f, -6.29197776e-01f, -1.67559803e-01f, 8.20490904e-03f, 1.92142740e-01f, -3.19738448e-01f, 6.60030693e-02f, -3.49237829e-01f, 1.82325542e-01f, -2.86276519e-01f,
  1.60890147e-01f, -3.29358667e-01f, 3.76297474e-01f, -2.11565375e-01f, 5.12299061e-01f, -1.98364943e-01f, -6.48161024e-02f, 2.65815228e-01f, 1.72169954e-01f, -2.74713561e-02f,
  -5.14974669e-02f, 1.39064208e-01f, 3.58640194e-01f, 2.81924754e-01f, -2.27282748e-01f, -9.03347060e-02f, 1.93528771e-01f, 5.70680164e-02f, 3.06588739e-01f, -2.55126476e-01f,
  2.16209158e-01f, -4.30487782e-01f, 2.40492582e-01f, -1.48702949e-01f, -4.43394065e-01f, -3.20061266e-01f, 1.32668227e-01f, 1.37326166e-01f, -3.14669609e-01f, 1.42209947e-01f,
  1.77255958e-01f, -3.84128362e-01f, -3.76525462e-01f, 6.29912317e-02f, -1.75381541e-01f, -4.00706619e-01f, -3.16690505e-01f, -8.50605220e-02f, -1.07698023e-01f, 5.13492882e-01f,
  1.54361665e-01f, -2.71963865e-01f, -3.73085022e-01f, 9.15414914e-02f, 2.63922900e-01f, 1.10640526e-01f, 6.97092479e-03f, 1.89890668e-01f, 1.31544217e-01f, -4.78607528e-02f,
  -2.85540611e-01f, -4.12519276e-01f, -1.14642680e+00f, 8.88249949e-02f, -4.46438402e-01f, 2.54898041e-01f, 1.12561677e-02f, 1.98930562e-01f, 1.93487465e-01f, 8.04983675e-02f,
  1.57545760e-01f, 7.46977851e-02f, -1.27147734e-01f, -9.31539163e-02f, -3.38020593e-01f, 1.76626965e-01f, -6.03224710e-02f, -3.50844085e-01f, 8.96141380e-02f, 8.65957886e-02f,
  1.26832008e-01f, 1.99851871e-01f, -2.06400007e-01f, 3.13629061e-01f, -2.81544894e-01f, -2.30331585e-01f, -8.43717456e-02f, 2.79826820e-01f, -1.61229432e-01f, -1.32765491e-02f,
  -1.66546851e-02f, -1.88069820e-01f, 1.51702106e-01f, 5.33804931e-02f, 7.16685224e-03f, 3.78037632e-01f, -3.28774959e-01f, -2.86174506e-01f, 2.15136454e-01f, -1.73415706e-01f,
  3.07971351e-02f, -3.31314176e-01f, -2.82707009e-02f, 1.75536677e-01f, 2.06067979e-01f, -7.54501745e-02f, 9.45851281e-02f, 1.06134050e-01f, 2.19981857e-02f, -4.79733758e-02f,
  2.64005542e-01f, 5.08715175e-02f, -2.46318892e-01f, -1.58509851e-01f, -1.72358498e-01f, 1.21568501e-01f, -1.73839301e-01f, -2.27440268e-01f, -1.61363438e-01f, -3.85187835e-01f,
  -8.81552026e-02f, -2.38265321e-01f, -3.35760057e-01f, -5.58769286e-01f, 1.57278895e-01f, 6.10237956e-01f, -4.93060201e-01f, -3.03570122e-01f, 3.71498436e-01f, -2.58674435e-02f,
  -5.66282451e-01f, 4.20471877e-01f, -3.43951732e-01f, -2.34747287e-02f, -1.48275927e-01f, 2.23936841e-01f, -2.21344084e-02f, 1.54572517e-01f, 2.25421548e-01f, 3.42812151e-01f,
  -3.24934304e-01f, -2.66759813e-01f, -1.57577187e-01f, 3.38844806e-01f, 1.90736577e-01f, -2.14869916e-01f, 2.46039450e-01f, -9.18754712e-02f, -2.65943319e-01f, 8.32141340e-02f,
  -2.24636033e-01f, 3.61552723e-02f, -1.90448344e-01f, 2.86607802e-01f, 1.32762223e-01f, -9.39841568e-02f, 1.06777303e-01f, -2.34085381e-01f, 2.64329940e-01f, -1.30769879e-01f,
  -3.79978627e-01f, 2.31062531e-01f, -3.26136023e-01f, 1.64451733e-01f, -9.91426222e-03f, -2.28986219e-01f, -3.34388673e-01f, -4.91533697e-01f, 1.84673071e-02f, -2.31074095e-01f,
  -3.29011768e-01f, -3.02117050e-01f, -3.54230791e-01f, 3.15259904e-01f, -6.73637211e-01f, -2.70363271e-01f, 3.80535334e-01f, -2.68103540e-01f, 3.75631005e-01f, 4.18012232e-01f,
  -2.48347148e-01f, 1.20395824e-01f, -5.58754802e-01f, 1.30668759e-01f, -3.14651817e-01f, 2.20431238e-01f, -4.95136529e-01f, 2.95749217e-01f, -6.03516161e-01f, -5.24163961e-01f,
  -3.27412397e-01f, 2.06907243e-02f, -1.24234222e-01f, -2.43912991e-02f, -3.52243811e-01f, -4.38486964e-01f, 3.48678976e-01f, -4.46189195e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.99237522e-02f, 2.85942629e-02f, 2.58618407e-02f, 5.55978008e-02f, -3.18645947e-02f, -1.14857599e-01f, 1.72545072e-02f, 5.65873347e-02f, 2.43163452e-01f, 6.25153556e-02f,
  3.22727561e-02f, 4.78313230e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    